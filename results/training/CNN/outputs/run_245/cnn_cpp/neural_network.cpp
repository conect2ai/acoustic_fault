#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.70661390f, 0.91223192f, 0.11101487f, 0.08125123f, -0.04831050f, 0.46445712f, 0.00733702f, -0.45407781f, 
    -0.20408158f, -0.33507240f, 0.35459259f, 0.06656013f, -0.12034079f, 0.08175528f, -0.27505410f, 0.02089637f, 
    -0.29020572f, 0.20182179f, -0.11795057f, -0.18097499f, -0.09456784f, 0.14493726f, -0.09935175f, -0.00120441f, 
    0.14545757f, -0.43889719f, -0.43868932f, -0.47717428f, -0.50598472f, -0.33677864f, -0.37234434f, 0.67484176f, 
    0.38720647f, 0.11897770f, 0.46502239f, -0.20199218f, -0.26579759f, 0.06369083f, -0.23852089f, -0.18609139f, 
    0.01179146f, -0.01099859f, 0.03454221f, -0.15450010f, -0.14808173f, 0.00043840f, 0.00879584f, -0.09738485f, 
    -0.06288670f, -0.06561691f, -0.48942170f, 0.96445489f, 0.19918439f, -0.25089917f, 0.49592310f, -0.16955453f, 
    0.53275472f, 0.61023694f, -0.05965843f, 0.40699247f, -0.13485397f, 0.24029812f, 0.23192334f, -0.18592489f, 
    -0.01346809f, 0.34080690f, -0.13086358f, -0.02951830f, 0.03025021f, 0.02596219f, -0.02672250f, -0.04173327f, 
    -0.08108982f, -0.04160517f, 0.06848763f, -0.76288837f, 0.67133880f, 0.62485307f, -0.45905364f, -0.27208874f, 
    -0.55516046f, 0.18700987f, -0.11001804f, -0.25045693f, -0.27554190f, -0.41571772f, 0.32440379f, -0.09332267f, 
    0.33163103f, -0.18728247f, -0.40267581f, -0.22833538f, -0.03051582f, -0.27419209f, -0.24730241f, 0.12221979f, 
    0.07842669f, -0.09829067f, 0.09726829f, -0.09523027f, 0.11270020f, 0.14216623f, 0.17709802f, 0.17586353f, 
    0.00744611f, 0.65766776f, 0.31532568f, -0.40232724f, 0.40241817f, 0.46683311f, 0.18594018f, 0.03480035f, 
    0.33522144f, 0.19656761f, -0.24451762f, -0.12298598f, -0.24622434f, -0.07787347f, -0.28608584f, 0.23534383f, 
    -0.13479359f, -0.35545075f, 0.09799233f, -0.12877648f, -0.14340080f, 1.06842947f, 0.39958233f, 0.12594122f, 
    0.71497524f, 0.98437929f, 0.12223657f, -0.16106036f, 0.06244045f, 0.49493924f, 0.20770712f, -0.03006034f, 
    0.24394730f, 0.21042669f, -0.01171394f, -0.05255695f, -0.12580948f, 0.00860215f, 0.16399038f, 0.02655104f, 
    -0.24783087f, 0.18526293f, 0.12980053f, 0.13176957f, 0.07313302f, 0.06181468f, -0.48162201f, -1.10889339f, 
    -0.07376050f, 0.44588858f, 0.07914991f, -0.15661114f, 0.24025610f, 0.60485166f, -0.15880318f, -0.33718762f, 
    0.18375671f, -0.22485293f, -0.10027484f, 0.13484451f, -0.06242371f, -0.02958300f, 0.21975468f, -0.24076243f, 
    -0.16837263f, -0.04080936f, -0.01735220f, 0.19814806f, 0.08783855f, -0.02090987f, -0.12070498f, -0.44672802f, 
    -0.69336528f, -0.41331285f, 0.20303233f, 0.24683739f, 0.04979021f, 0.91879225f, 0.35889858f, -0.05341082f, 
    0.19189522f, 0.10828978f, -0.05727337f, -0.07927579f, -0.29552817f, 0.18353207f, -0.04825273f, 0.21281560f, 
    -0.04020672f, 0.17631388f, -0.09650774f, -0.11472180f, -0.03401323f, 0.06269247f, 0.25604317f, 0.06880667f, 
    -0.44924501f, -0.28100216f, 0.13806842f, -0.08346258f, -0.36589259f, 0.21894777f, -0.38218954f, -0.52468270f, 
    -0.47824749f, 0.09204325f, -0.11920457f, -0.00559683f, 0.04673850f, -0.00595874f, -0.25310525f, -0.30642584f, 
    -0.03384417f, 0.11790816f, -0.11262563f, 0.31321594f, -0.07213823f, 0.25735024f, 0.32416499f, 0.30274114f, 
    0.17851676f, -1.20070863f, 0.26818317f, 0.27824959f, -0.20463626f, -0.34828937f, 0.52416110f, 0.49372357f, 
    -0.28205380f, 0.39416417f, 0.43152425f, -0.08297936f, -0.15376471f, 0.40297124f, -0.09165264f, 0.08148479f, 
    -0.07139070f, -0.06150155f, 0.08534039f, -0.00894086f, 0.05996446f, 0.03909224f, -0.05043601f, 0.10781143f, 
    -0.04496504f, 0.15193760f, -0.60559118f, -0.73531121f, -0.39066389f, 0.00520404f, 0.05991063f, 0.33001512f, 
    0.18229207f, -0.17115957f, 0.04483231f, -0.11462004f, -0.20535499f, 0.02311397f, 0.10451590f, 0.18279921f, 
    0.35808185f, -0.22025840f, 0.23081139f, 0.54945683f, 0.07037887f, 0.00172347f, 0.00461656f, 0.04410861f, 
    -0.46845329f, 0.20167652f, -0.29843464f, -0.52501124f, -0.67162597f, -0.46022350f, -0.43386427f, -0.42372370f, 
    -0.15668948f, -0.40097836f, -0.22408766f, 0.08095787f, 0.14674143f, 0.22716381f, 0.27154061f, -0.08294265f, 
    0.05138791f, -0.15491119f, 0.18588862f, 0.05816108f, 0.04025643f, 0.08748814f, 0.02249295f, -0.15045691f, 
    -0.11688756f, -0.04100330f, -0.14698249f, 0.37089750f, 0.51258564f, 0.07070576f, 0.58236986f, 0.77754915f, 
    0.47845930f, 0.53013736f, 0.23439489f, -0.39881170f, 0.11274592f, -0.19485818f, -0.16820484f, 0.01701050f, 
    -0.17113820f, 0.06538488f, -0.16706310f, 0.20049061f, 0.33695287f, -0.03647801f, -0.01049042f, 0.33152792f, 
    0.15602848f, 0.30691376f, 0.15245877f, -0.12521484f, 0.18770297f, -0.00572435f, 0.59570462f, 0.68442345f, 
    0.67439854f, -0.29971200f, -0.03984595f, -0.10730997f, -0.20360997f, -0.17852959f, 0.27705821f, 0.16534549f, 
    -0.14114645f, -0.42853317f, -0.12182401f, -0.03283032f, -0.12560849f, 0.07061951f, -0.11129305f, -0.28156587f, 
    -0.21528536f, -0.17353027f, -0.05207276f, -0.27736649f, -0.07495997f, -0.36881405f, -0.32151291f, -0.23981728f, 
    0.60306346f, 0.33334440f, 0.26673734f, -0.98771083f, 0.10584666f, -0.44741833f, -0.33212942f, -0.04807783f, 
    0.54130727f, 0.07577046f, 0.12271822f, 0.17593606f, -0.22403058f, 0.06912272f, 0.04691270f, 0.05671594f, 
    0.23422091f, 0.08624563f, -0.21655627f, 0.00788096f, 0.01141997f, 0.07508535f, 0.08579884f, 0.71169275f, 
    0.94265515f, -0.06603532f, -0.45308957f, -0.47506905f, -0.29155275f, -0.73613793f, -0.07777561f, -0.29589710f, 
    0.21070668f, 0.24693373f, 0.25166789f, -0.14413442f, 0.19789422f, -0.02800414f, 0.05776722f, 0.13038693f, 
    0.02739785f, -0.00046367f, 0.18130447f, -0.20197903f, 0.17608258f, 0.10495946f, -0.23351370f, -0.09527259f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23890063f, -0.11306944f, 0.05106239f, 0.06028691f, -0.16697641f, 0.09673596f, 0.07107172f, 0.00828524f, 
    0.10705815f, -0.07722396f, 0.05990310f, 0.03936725f, 0.20759250f, -0.04077424f, 0.08751986f, 0.25207791f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06537109f, 0.05929669f, -0.06435781f, -0.07432763f, 0.01630077f, 0.03564505f, 0.04636746f, 0.01068620f, 
    -0.03174889f, 0.03560671f, 0.04438767f, 0.05160976f, -0.03582385f, -0.04192088f, -0.02006750f, -0.05429385f, 
    -0.01969109f, -0.05984339f, -0.05208158f, -0.07530735f, 0.02816885f, -0.06431148f, -0.02363384f, 0.06433424f, 
    0.05186396f, -0.00786275f, -0.03016117f, -0.01539822f, -0.00216628f, 0.02211234f, -0.02511926f, -0.02582642f, 
    0.00461959f, -0.06044047f, -0.05058560f, -0.01037572f, -0.07137971f, -0.01314855f, -0.06183081f, 0.02067793f, 
    0.02199443f, -0.00110785f, -0.01203087f, -0.05660515f, -0.05331490f, -0.06177940f, 0.07025741f, -0.01428267f, 
    -0.02393875f, -0.06039478f, 0.06102682f, -0.02266479f, -0.02751373f, -0.06952492f, -0.02921528f, 0.00638700f, 
    0.06623412f, -0.03902188f, 0.04609535f, 0.05247427f, 0.06633300f, -0.00121944f, 0.01053703f, 0.01414277f, 
    0.00528648f, -0.04748343f, -0.00082784f, 0.00865889f, 0.01263373f, -0.05117471f, -0.03741756f, 0.05747637f, 
    -0.00736559f, -0.03558664f, 0.02712304f, -0.02566093f, -0.04338664f, 0.02713280f, -0.03920234f, 0.01350629f, 
    0.03993915f, -0.01912954f, -0.04290172f, -0.00471270f, 0.02889214f, -0.07142375f, -0.05619197f, -0.05932100f, 
    -0.07058007f, 0.06001573f, 0.00115814f, 0.02954173f, 0.01679505f, 0.01884513f, 0.06412329f, 0.02079001f, 
    -0.05617357f, 0.03907236f, -0.04332434f, 0.00364662f, 0.02162442f, 0.02026954f, 0.04234042f, 0.02786076f, 
    0.04933840f, -0.05357520f, 0.04190126f, -0.05253130f, 0.06264817f, 0.01790527f, 0.04724157f, -0.01418609f, 
    0.02364929f, -0.01742325f, 0.03977333f, -0.02851393f, 0.04768787f, -0.06917980f, 0.01499900f, 0.07205459f, 
    -0.02754641f, -0.06360349f, -0.01079924f, 0.02692435f, -0.06976013f, 0.03171955f, 0.04016202f, -0.05674111f, 
    -0.03584363f, -0.02886292f, -0.00849394f, 0.01847228f, -0.06506836f, -0.01782900f, -0.05634671f, -0.00573388f, 
    -0.07117737f, -0.05878501f, -0.00263641f, 0.00753663f, 0.03608403f, -0.05125735f, 0.01675193f, 0.02573427f, 
    -0.04449406f, -0.02276287f, -0.04435605f, -0.06122012f, -0.00871887f, -0.04172111f, 0.00805052f, -0.03121516f, 
    -0.02639715f, 0.01381819f, -0.06747776f, -0.00584667f, -0.01535222f, -0.04309534f, -0.03711718f, -0.00021093f, 
    0.06137456f, -0.01062266f, -0.04864394f, 0.00185941f, 0.01310550f, 0.05099745f, 0.03789984f, -0.06631727f, 
    -0.01275047f, -0.06044984f, -0.03128017f, 0.01852759f, 0.05366038f, 0.02260945f, -0.06838845f, -0.03210099f, 
    -0.04818975f, -0.04504813f, 0.05673216f, -0.01998083f, -0.04777759f, 0.05837300f, -0.05827317f, -0.07758701f, 
    -0.05852459f, -0.06567802f, 0.03145900f, -0.04306826f, 0.03372471f, -0.04273157f, 0.03152113f, -0.04618463f, 
    0.25377303f, -0.20571207f, 0.11979232f, -0.02674636f, -0.00652226f, -0.02602484f, 0.01327550f, -0.13979146f, 
    0.17205244f, 0.01447492f, 0.07691288f, -0.02621097f, -0.05361478f, -0.06623874f, -0.08573999f, 0.03590580f, 
    -0.06323918f, -0.16586068f, -0.04695435f, 0.02962408f, 0.13949063f, -0.11508995f, -0.02171988f, -0.08193576f, 
    -0.16077313f, 0.49265027f, -0.15308657f, -0.10724866f, -0.02415162f, 0.15398484f, -0.00733069f, 0.07093254f, 
    0.03006965f, 0.08771466f, 0.05126845f, -0.06914059f, -0.28895086f, 0.28720015f, -0.20618907f, -0.07902836f, 
    -0.15716845f, 0.11619949f, -0.01836013f, 0.06180006f, 0.20367093f, -0.01488168f, 0.06752070f, -0.05855655f, 
    0.16133553f, -0.15691628f, 0.02520872f, 0.08971604f, 0.17286229f, 0.13802344f, -0.07229014f, -0.05990881f, 
    -0.19661574f, -0.09873533f, 0.11313816f, 0.08780423f, 0.26850528f, -0.30149600f, 0.03712045f, 0.30368403f, 
    -0.10241370f, -0.02124606f, 0.06997374f, 0.16071354f, 0.25840670f, -0.04238422f, -0.12116553f, 0.09056564f, 
    -0.37776136f, 0.18197052f, -0.16450000f, -0.11147825f, -0.02691408f, 0.03158297f, 0.10555834f, 0.14535624f, 
    0.03990492f, -0.00319165f, -0.07625810f, 0.01288329f, -0.13852616f, 0.02985505f, -0.06016483f, 0.08749958f, 
    -0.06545609f, 0.02237394f, 0.03751106f, 0.09115061f, 0.10024518f, -0.02855800f, -0.08749827f, -0.00572428f, 
    -0.00938941f, -0.15323214f, -0.04281481f, -0.18541203f, -0.06050708f, 0.12883084f, -0.02129412f, 0.03945224f, 
    0.02379808f, -0.06345741f, 0.07154974f, 0.07389257f, -0.07214869f, -0.03390756f, -0.07426484f, 0.02197380f, 
    -0.00608204f, 0.10497808f, -0.02529762f, 0.10712630f, -0.08074874f, 0.00424654f, 0.08896200f, -0.04067709f, 
    0.14295328f, -0.00466317f, 0.06826796f, 0.08162027f, 0.06519695f, -0.07483010f, -0.05789059f, 0.06920172f, 
    -0.04857426f, 0.02318315f, 0.09344805f, 0.01561005f, -0.04340477f, 0.06282786f, -0.05086846f, -0.06884933f, 
    -0.01212784f, 0.02375562f, -0.02470137f, 0.08542949f, 0.04133606f, 0.13771525f, 0.24106397f, 0.10403100f, 
    0.42036062f, -0.03792774f, 0.28076118f, 0.04415679f, -0.12208215f, 0.06739973f, -0.00269919f, 0.08199761f, 
    0.10544217f, 0.03354953f, 0.07388200f, -0.03857742f, 0.07557832f, 0.01965368f, -0.07010566f, 0.05405333f, 
    0.00047070f, -0.03151710f, 0.09082844f, 0.01893581f, 0.08534682f, 0.03965839f, -0.07824183f, 0.13799965f, 
    -0.01635066f, 0.02557058f, -0.04415114f, -0.07726232f, 0.14582972f, -0.01514860f, 0.08294470f, 0.12641972f, 
    0.02641910f, 0.03348661f, 0.06544057f, 0.06074923f, 0.20499125f, 0.01867497f, -0.12848967f, -0.03825238f, 
    -0.01900234f, -0.02746864f, 0.11352980f, -0.18578643f, 0.02549174f, 0.13639408f, 0.15269729f, 0.16960359f, 
    -0.01185946f, 0.09928066f, 0.12257099f, -0.15932545f, -0.06269274f, -0.03289771f, 0.03027782f, 0.11535688f, 
    -0.03437943f, -0.04056333f, -0.07556962f, -0.09471787f, 0.37641129f, 0.05076465f, 0.05682165f, 0.09413422f, 
    -0.01749140f, -0.08083203f, 0.13357420f, 0.16281979f, 0.06703940f, 0.16611636f, -0.01031286f, 0.02468479f, 
    0.32371843f, -0.11176718f, -0.06122889f, -0.17656414f, -0.06503220f, 0.14286315f, -0.09646603f, -0.05216840f, 
    -0.07243506f, 0.07520570f, 0.00500885f, 0.02549364f, -0.14321445f, 0.24198076f, -0.16189137f, 0.03169614f, 
    0.09504957f, 0.15165502f, 0.20078498f, -0.06611016f, -0.10948776f, -0.08704932f, -0.03503526f, 0.01820847f, 
    0.04666715f, 0.22688042f, 0.10876134f, -0.07333576f, 0.03806830f, 0.08295982f, -0.09419356f, -0.01156015f, 
    -0.04658526f, 0.13172930f, 0.10173859f, -0.04670738f, 0.08789898f, 0.16059157f, -0.01193055f, 0.22874726f, 
    0.09309011f, -0.04436179f, -0.05529664f, -0.02593149f, -0.20720723f, -0.07852670f, -0.11284608f, -0.00900105f, 
    0.42422771f, 0.10186827f, -0.11459416f, 0.26485956f, -0.12041251f, 0.08835911f, -0.10351381f, 0.05239850f, 
    -0.00413537f, -0.02414250f, 0.02129771f, 0.01662109f, 0.27316535f, 0.06165328f, 0.06132916f, 0.00008114f, 
    0.09594749f, 0.00505579f, -0.07197779f, -0.11274821f, 0.02576898f, 0.02236076f, -0.03472721f, 0.07933414f, 
    -0.26003644f, 0.06616926f, 0.15535471f, -0.02107771f, 0.08641092f, -0.19065484f, -0.01435897f, 0.09041377f, 
    -0.06903390f, 0.09081244f, -0.06946233f, -0.03820087f, -0.01537238f, 0.24096118f, 0.05104833f, -0.24109645f, 
    0.18173645f, -0.00530454f, 0.09934349f, 0.01386582f, 0.05051131f, -0.03953094f, 0.17554827f, 0.09985303f, 
    0.06704247f, 0.05822691f, 0.06700387f, 0.22264349f, 0.07492008f, -0.05620234f, -0.06681212f, -0.03024215f, 
    0.09778756f, -0.08867839f, -0.06617258f, 0.16491562f, -0.04401312f, -0.12560986f, 0.35213161f, 0.09093895f, 
    0.02741615f, -0.03850349f, -0.01837760f, 0.18169351f, -0.03387662f, 0.02587714f, -0.01327139f, 0.14840913f, 
    -0.00595784f, -0.16811703f, -0.10841677f, 0.20266922f, 0.04769883f, -0.07536595f, 0.00181243f, -0.06696828f, 
    -0.09790545f, 0.01699096f, -0.13172875f, -0.01606339f, -0.28010920f, -0.15474355f, -0.10602462f, 0.32635269f, 
    -0.05695627f, 0.18349825f, 0.14443125f, -0.08431970f, -0.03771378f, -0.14552671f, 0.04610246f, -0.04732230f, 
    -0.21839248f, -0.25116035f, -0.23561189f, 0.29743719f, -0.00746111f, -0.08831573f, -0.01223742f, -0.05972261f, 
    0.00293111f, 0.00730009f, -0.04194498f, -0.07957416f, -0.15830044f, -0.19227299f, 0.12089007f, -0.22837231f, 
    -0.05771811f, 0.03594167f, 0.15135525f, -0.02941160f, -0.04980603f, -0.08305796f, 0.15033987f, -0.01203573f, 
    -0.19041497f, -0.12705514f, 0.07207846f, -0.08558361f, 0.18600670f, -0.00837442f, -0.02691344f, -0.05422550f, 
    0.08023244f, 0.10168201f, 0.07817164f, -0.00577193f, 0.38949287f, -0.04016815f, -0.16681702f, 0.11097599f, 
    -0.14050983f, -0.17110215f, -0.02035834f, 0.14318596f, 0.00167011f, 0.00172146f, -0.12135155f, -0.10205060f, 
    0.39000240f, 0.03963204f, -0.11294251f, -0.03837463f, -0.02187606f, 0.04926598f, -0.04066372f, 0.00082063f, 
    0.07347999f, 0.10022395f, 0.10130744f, 0.14142351f, 0.01377189f, -0.10032446f, -0.25251976f, -0.11785175f, 
    0.07531704f, 0.03115904f, 0.06838363f, 0.07726520f, 0.10549729f, 0.04601829f, 0.03234382f, 0.03621141f, 
    0.04966210f, 0.14799707f, 0.29379660f, -0.09418453f, 0.01597106f, -0.05151780f, -0.05608939f, 0.11161204f, 
    0.08274627f, 0.00395938f, -0.01789503f, -0.06816556f, -0.31829900f, 0.18263175f, -0.15287943f, -0.20299947f, 
    0.14584963f, 0.05526174f, 0.06411199f, -0.04086499f, -0.02586574f, -0.04936135f, 0.04392375f, 0.05605540f, 
    0.34110737f, 0.06409791f, -0.05441080f, 0.15912214f, 0.03065612f, -0.02796424f, 0.00746301f, -0.03684323f, 
    0.03388974f, 0.10893623f, -0.01491813f, 0.12045075f, 0.30627635f, -0.14802554f, -0.08113644f, 0.18768983f, 
    -0.10110803f, 0.01945502f, -0.04499903f, 0.06695254f, -0.02601692f, -0.11234181f, 0.01116329f, -0.02122504f, 
    0.07566740f, 0.11652349f, -0.03550773f, -0.01331746f, 0.05342223f, -0.05129698f, 0.06379377f, -0.06190365f, 
    0.10971975f, 0.02504214f, 0.16223520f, 0.04825562f, -0.33563420f, 0.06262967f, -0.02711713f, -0.00216657f, 
    -0.02261168f, 0.08905841f, 0.00260264f, -0.02108435f, -0.01296996f, 0.08209864f, 0.01072837f, -0.13076109f, 
    0.37655598f, -0.00862045f, -0.16980673f, 0.16586210f, 0.00695435f, 0.04469928f, -0.12259300f, -0.05685301f, 
    0.00935289f, -0.00909606f, 0.14034685f, 0.04982284f, 0.09339248f, 0.03800771f, -0.07458718f, -0.00465603f, 
    0.00723213f, -0.00550176f, 0.04264105f, 0.03711876f, -0.11522285f, 0.09610512f, -0.03043582f, 0.09895599f, 
    -0.18691871f, -0.10051180f, -0.08193073f, -0.14033873f, 0.17663696f, 0.13283534f, -0.03354504f, 0.01932538f, 
    -0.08252861f, -0.03172032f, 0.12084875f, 0.02519225f, -0.16715690f, 0.07312938f, 0.07309919f, -0.06069643f, 
    0.12457601f, -0.09546765f, -0.08536336f, -0.09715976f, 0.06630648f, -0.11698690f, 0.01754483f, 0.05159301f, 
    0.24399808f, 0.16932045f, -0.07585590f, -0.15035067f, -0.01487538f, 0.06962604f, 0.08207080f, -0.05575388f, 
    -0.06981320f, -0.07024825f, 0.12234820f, 0.04959972f, -0.10675869f, -0.03663303f, 0.05411400f, -0.01184185f, 
    0.26186267f, -0.06227348f, 0.16416170f, -0.03670618f, -0.01440156f, -0.00198651f, 0.10383619f, -0.00541537f, 
    0.03940174f, -0.07856572f, -0.05596343f, -0.04247986f, -0.06154306f, -0.02176987f, -0.00125303f, 0.04873672f, 
    -0.00941723f, -0.03083902f, -0.05365749f, -0.05628074f, 0.02094924f, -0.00423603f, -0.02351475f, -0.00773018f, 
    0.06111224f, -0.04676089f, 0.00989095f, -0.00072348f, -0.05610545f, 0.01022202f, -0.05545774f, 0.01259722f, 
    -0.02199760f, -0.04429848f, -0.06905906f, -0.06660737f, -0.04538780f, -0.07581317f, -0.02135705f, 0.03832135f, 
    -0.02518145f, -0.02669499f, -0.05935780f, -0.06971274f, 0.02484376f, 0.03137943f, -0.04982698f, -0.05178848f, 
    0.03197020f, -0.05842115f, 0.06844137f, -0.04326171f, -0.06738192f, 0.03640185f, -0.05077245f, 0.05631177f, 
    -0.01977887f, -0.00283408f, 0.02414057f, -0.01143667f, -0.06452002f, -0.01279756f, -0.00695360f, 0.03137116f, 
    0.01787237f, 0.00024500f, 0.04859828f, 0.05540320f, -0.04107040f, 0.02736434f, -0.04060577f, 0.05042599f, 
    0.06166561f, -0.03980431f, -0.00220386f, 0.04063176f, -0.01083561f, -0.01995561f, 0.00053994f, 0.05568919f, 
    0.01310705f, -0.05740749f, 0.05604605f, 0.00324918f, -0.00442501f, 0.01875693f, 0.05611260f, -0.05876956f, 
    0.04016999f, -0.05106457f, 0.01032131f, -0.07147178f, -0.03593516f, -0.01499328f, -0.04112118f, -0.07337815f, 
    0.05699002f, 0.01025957f, -0.00075947f, -0.03045866f, -0.04215254f, 0.00360272f, 0.03003068f, -0.03996033f, 
    -0.03470071f, -0.06732558f, 0.05260712f, -0.01929162f, -0.06688137f, -0.00783230f, -0.02249766f, -0.00497662f, 
    0.04569275f, -0.03621804f, 0.00336518f, -0.01769021f, -0.05839926f, -0.07337900f, -0.00682007f, 0.04791709f, 
    -0.00271465f, 0.00152519f, 0.02264084f, -0.06321735f, 0.04194335f, 0.04687509f, -0.01117031f, 0.01512818f, 
    0.03900856f, 0.03639315f, -0.07020666f, -0.04062110f, -0.01794032f, -0.00339039f, 0.05891276f, 0.04491310f, 
    0.01676459f, -0.05500259f, -0.02831724f, 0.00143121f, -0.03354253f, 0.03169844f, -0.04102915f, -0.01761959f, 
    0.01629162f, -0.06595235f, -0.00234471f, 0.05478099f, 0.02011915f, 0.05762593f, 0.02745024f, 0.03989525f, 
    -0.02291675f, -0.05777797f, -0.02573289f, -0.05494956f, -0.01500760f, 0.05950971f, -0.01927088f, -0.07818286f, 
    -0.01454601f, -0.06520328f, -0.01677863f, 0.02867563f, 0.02476448f, -0.04024170f, -0.06603091f, 0.00350936f, 
    -0.02415293f, -0.01578953f, -0.06086791f, -0.00388371f, -0.00644878f, 0.00400113f, -0.00076634f, -0.01829453f, 
    -0.02312134f, -0.03278216f, -0.07393756f, 0.02079638f, 0.02171403f, -0.02330454f, 0.03733502f, -0.02708378f, 
    -0.04004439f, 0.01994754f, 0.00801445f, -0.05373853f, -0.06763484f, 0.04055047f, 0.02770999f, -0.01251894f, 
    0.01598304f, 0.05350990f, 0.01600927f, -0.06136796f, -0.06614752f, 0.06366640f, 0.04733556f, -0.00071435f, 
    -0.01497613f, -0.02472901f, 0.03695757f, 0.00941539f, 0.00225064f, -0.07161752f, -0.00870644f, 0.01934147f, 
    -0.03481858f, -0.03108364f, 0.02851297f, -0.07066081f, -0.03336398f, 0.05197433f, -0.05287999f, 0.02578511f, 
    -0.03057050f, 0.05962546f, 0.05687880f, 0.05941314f, 0.01932935f, -0.00253668f, 0.01020759f, 0.01844485f, 
    -0.00719250f, -0.05903089f, 0.00122107f, 0.04442649f, -0.00158920f, 0.01145114f, 0.03100984f, -0.02378268f, 
    -0.02401753f, -0.02366101f, -0.03414007f, -0.06371673f, -0.05947142f, 0.00555763f, -0.06735981f, -0.03316227f, 
    0.01409525f, -0.00433236f, -0.00678687f, 0.05593000f, 0.04521946f, 0.03287956f, 0.03733155f, 0.02153764f, 
    -0.04990503f, -0.06594206f, 0.04769111f, -0.06959330f, -0.04828027f, -0.01720121f, 0.02286306f, 0.02384337f, 
    0.01242921f, 0.05491893f, -0.06931174f, 0.04103386f, -0.05169613f, 0.04854442f, 0.02875756f, 0.02121685f, 
    0.05623309f, 0.02015186f, -0.01210516f, 0.00357926f, -0.01035487f, -0.06280901f, -0.03104804f, -0.05435780f, 
    -0.03513458f, -0.05943008f, 0.03900610f, 0.03143544f, 0.03142941f, 0.05465270f, -0.00592387f, -0.00827442f, 
    0.02178457f, -0.05951329f, -0.05370089f, 0.02606742f, 0.02859538f, -0.03534489f, -0.03981334f, -0.04584891f, 
    0.00640890f, -0.02149577f, -0.03911129f, -0.03883552f, 0.01701269f, -0.00109077f, 0.02560201f, -0.03530492f, 
    -0.06716897f, 0.02234939f, 0.02484780f, -0.03921012f, 0.04443883f, -0.05590878f, 0.00127578f, -0.01445914f, 
    -0.01723100f, -0.00387138f, -0.06838445f, 0.05248658f, -0.05782912f, -0.00014466f, -0.02535637f, 0.05994239f, 
    0.03844621f, 0.02660936f, -0.02604694f, -0.07242493f, -0.05054621f, -0.03581838f, -0.03038098f, -0.00800874f, 
    -0.06555568f, -0.06882539f, 0.04601405f, -0.01339331f, -0.05654775f, 0.04794230f, 0.03820755f, -0.07416590f, 
    -0.02475907f, -0.02051226f, -0.07104006f, 0.05438960f, -0.08263927f, 0.00906653f, -0.00287147f, -0.07466872f, 
    0.03204300f, -0.05789614f, -0.04345207f, -0.01287823f, 0.03943693f, -0.00626172f, 0.06305926f, -0.01792913f, 
    -0.03028018f, -0.00248986f, -0.02382053f, -0.03168950f, 0.03010760f, -0.07680156f, -0.01286625f, -0.05179309f, 
    -0.06743242f, 0.00088936f, 0.05232808f, 0.01075823f, 0.04111635f, -0.00281940f, -0.00500357f, -0.07316101f, 
    -0.00015682f, -0.01595931f, -0.06108879f, -0.06237762f, -0.05314976f, -0.01353200f, 0.04060583f, -0.06118619f, 
    0.02247483f, -0.03973462f, -0.00949637f, 0.04326358f, 0.04419293f, -0.06785959f, -0.00880549f, 0.04080307f, 
    0.05154048f, -0.04983586f, 0.04451376f, 0.03578765f, -0.00699151f, -0.01244338f, -0.07605784f, 0.04875631f, 
    -0.06702156f, 0.00905038f, 0.03894911f, -0.01366895f, 0.02531885f, -0.02156736f, -0.02921743f, 0.02187009f, 
    -0.00990217f, -0.07585880f, 0.03109957f, -0.04259547f, -0.01771557f, -0.00988854f, 0.06459768f, -0.07311412f, 
    -0.00529708f, 0.06607746f, -0.04653442f, 0.04231865f, 0.03265827f, 0.01891077f, 0.05655072f, -0.02295833f, 
    0.01243741f, 0.03375230f, -0.00144422f, 0.03272631f, -0.01357898f, -0.03233210f, -0.07121447f, 0.05794034f, 
    0.05618341f, 0.02629695f, 0.05953546f, -0.02772087f, 0.04260251f, 0.01345469f, -0.05149937f, -0.00861279f, 
    -0.05203308f, 0.06505918f, 0.01989882f, 0.04211022f, 0.04854960f, -0.06271163f, 0.00158068f, 0.00457832f, 
    -0.00431265f, -0.04485361f, -0.03804796f, 0.02043340f, -0.07300626f, -0.07359915f, 0.05114662f, 0.04839312f, 
    -0.07377989f, -0.06100299f, -0.05626046f, -0.02543572f, -0.06524374f, -0.00883716f, -0.06687193f, -0.05968577f, 
    0.06917103f, 0.01178257f, -0.00243312f, 0.03492926f, 0.03442293f, 0.00782029f, 0.06345816f, 0.01184469f, 
    0.02680833f, 0.05602898f, 0.05441215f, -0.07116606f, 0.05848741f, 0.02286847f, -0.02270815f, 0.04423893f, 
    -0.00522296f, -0.05196471f, -0.01066085f, -0.06915735f, -0.04401612f, -0.00269903f, -0.05309966f, -0.06969803f, 
    -0.02821652f, -0.03015572f, 0.01087742f, -0.00835358f, -0.01478659f, 0.03864131f, 0.04887529f, -0.06704216f, 
    0.02602342f, -0.06546650f, -0.06801552f, -0.04475684f, 0.04196228f, 0.00046089f, -0.02331669f, -0.07377137f, 
    -0.05388522f, -0.02399499f, 0.01021730f, -0.01207217f, -0.06215512f, 0.05335703f, -0.04100342f, 0.01893394f, 
    0.03211327f, -0.00544723f, -0.04755906f, -0.03174989f, 0.06063516f, -0.06394947f, -0.02681251f, -0.01447645f, 
    -0.06225231f, -0.00761640f, -0.06005140f, -0.00461712f, -0.05043321f, -0.01276184f, -0.02419906f, -0.06802446f, 
    -0.07227999f, -0.06061796f, 0.04277878f, 0.00315401f, -0.05754196f, 0.01163406f, 0.02947977f, -0.02742654f, 
    -0.03189698f, 0.02515929f, 0.04293881f, -0.06483226f, -0.04334811f, -0.01565655f, -0.06976938f, -0.05587143f, 
    0.04928401f, -0.04561939f, -0.01489924f, 0.01638778f, -0.00295670f, -0.00062730f, -0.03530629f, -0.00839615f, 
    0.05625480f, -0.07711577f, -0.03821946f, 0.01445590f, -0.04243519f, -0.01341437f, -0.00269765f, 0.05802825f, 
    -0.03213638f, -0.00829405f, -0.05326732f, 0.02507817f, 0.06611452f, 0.04782895f, -0.02732405f, -0.07823915f, 
    0.02277241f, -0.03694275f, 0.00994999f, 0.01712009f, -0.04106659f, 0.05024819f, -0.02669186f, -0.04338109f, 
    0.02128632f, 0.04185385f, 0.01193041f, 0.06593749f, -0.06433987f, -0.07490002f, -0.02218981f, -0.03042709f, 
    0.02387148f, 0.02945022f, -0.00704697f, -0.02845601f, 0.02827302f, -0.04962464f, -0.07027217f, 0.02117029f, 
    -0.06815203f, 0.01025032f, -0.03319882f, -0.02884126f, 0.05406975f, -0.03338661f, 0.02644040f, 0.05435758f, 
    0.13528113f, -0.00155593f, -0.01562419f, 0.08395459f, -0.14181921f, -0.04309861f, 0.08452047f, -0.04235938f, 
    -0.07721598f, -0.06117434f, -0.00509062f, -0.01692699f, -0.32483825f, 0.18920869f, 0.08680753f, 0.20662935f, 
    0.09731932f, 0.12147071f, 0.02585956f, -0.12887730f, 0.01117989f, -0.08775521f, 0.07924562f, 0.04318780f, 
    -0.22308002f, 0.18164805f, 0.05408842f, -0.08665773f, -0.04189281f, 0.06701617f, 0.02857997f, -0.01049088f, 
    0.03273202f, 0.02286140f, -0.11998052f, 0.01860401f, 0.16250880f, 0.17863815f, 0.32654315f, 0.31766072f, 
    0.04175286f, -0.03227853f, -0.10956921f, 0.03160562f, -0.05811395f, 0.01146932f, -0.00896740f, -0.03704276f, 
    0.07193231f, -0.00361919f, -0.07094712f, -0.10295380f, 0.11751621f, 0.02971734f, 0.15394375f, -0.06597985f, 
    -0.14375035f, -0.12991582f, -0.10894138f, -0.04217988f, 0.25133705f, -0.22448879f, 0.05954781f, 0.01686601f, 
    0.03100494f, -0.02130237f, 0.06546476f, 0.00476928f, 0.04613587f, -0.03402064f, 0.00168030f, 0.02640614f, 
    -0.43165177f, -0.03597756f, -0.13308929f, -0.27182025f, 0.11751569f, 0.12493954f, 0.03944565f, 0.05955835f, 
    0.05068811f, -0.01189976f, -0.02172456f, -0.01186983f, -0.38580790f, 0.29931453f, 0.00280246f, -0.20779109f, 
    0.01547353f, -0.05108716f, 0.10679536f, 0.17199056f, 0.04451953f, 0.00007072f, 0.00457653f, -0.12101964f, 
    -0.05112688f, -0.05485798f, 0.04138319f, 0.33754376f, 0.04096829f, -0.02347123f, 0.03157280f, -0.00895517f, 
    -0.11285723f, -0.02522612f, 0.05633884f, 0.00384687f, -0.02680960f, 0.20472836f, 0.04630158f, 0.06258114f, 
    0.04631717f, -0.01977613f, -0.00548040f, -0.10700104f, -0.08398906f, -0.00333696f, 0.06692622f, -0.12961112f, 
    -0.36815313f, 0.25446516f, 0.21144737f, -0.12734354f, -0.10025920f, 0.03645879f, -0.07802944f, 0.03684490f, 
    0.04539530f, 0.04411838f, 0.14946193f, -0.05623291f, 0.18541807f, 0.10669816f, -0.06958719f, 0.21608853f, 
    0.02405457f, 0.04987413f, 0.08495126f, 0.12617840f, 0.07892911f, 0.02080118f, 0.09605843f, -0.00630514f, 
    0.08824375f, 0.04264685f, 0.16768703f, 0.10378511f, -0.06615217f, -0.02870751f, -0.00386353f, 0.04750489f, 
    0.04750892f, 0.03962509f, -0.02145083f, 0.02196546f, 0.00678015f, -0.02242188f, 0.09454758f, -0.00425487f, 
    -0.01962050f, 0.02493756f, -0.05731614f, 0.04667995f, 0.03998183f, 0.17717782f, -0.06326565f, 0.07483827f, 
    -0.10287251f, -0.05118639f, 0.08721098f, 0.07601437f, -0.00070324f, 0.03536490f, -0.06322034f, -0.01662194f, 
    -0.04028706f, -0.03396125f, 0.05506096f, 0.13492997f, -0.01739017f, 0.01099061f, -0.04596663f, 0.22215161f, 
    -0.05396648f, -0.11302977f, 0.04851779f, -0.03050191f, -0.02298118f, -0.01929063f, 0.02337256f, 0.11102053f, 
    0.18919078f, -0.25146943f, -0.06331266f, -0.05667566f, 0.04618812f, -0.15875812f, -0.01053876f, -0.08971136f, 
    0.15434636f, 0.06490278f, 0.06646226f, -0.06466218f, 0.22308439f, 0.34494960f, -0.07529883f, -0.05960078f, 
    0.00818745f, 0.08919316f, 0.07962574f, -0.05509096f, -0.11172639f, -0.04427400f, 0.13841788f, -0.12957056f, 
    -0.41990221f, -0.09700058f, 0.04093517f, -0.21339726f, 0.03927192f, 0.11629455f, -0.01753566f, 0.08039849f, 
    0.06030051f, -0.03486321f, -0.02034580f, -0.06720629f, -0.04177525f, 0.14887439f, -0.01624503f, 0.30329597f, 
    -0.09560925f, 0.12924215f, 0.01567147f, -0.03014501f, 0.08342595f, -0.02267560f, -0.05240073f, -0.12540631f, 
    0.12472326f, -0.05856650f, 0.01321072f, -0.00889793f, 0.02350452f, 0.05046805f, -0.00450364f, 0.00284289f, 
    -0.00534107f, -0.03551667f, -0.04412327f, 0.06654291f, -0.17664398f, 0.01748422f, -0.26864019f, -0.17834450f, 
    0.14509863f, -0.00028810f, -0.02921657f, -0.04896029f, -0.00292200f, 0.10248867f, 0.08006695f, -0.04137503f, 
    -0.00900742f, 0.09732941f, 0.08682989f, -0.01749675f, -0.01362364f, 0.07041758f, -0.07443758f, -0.17855965f, 
    0.11886333f, 0.10496446f, -0.00974109f, -0.09300168f, 0.12086436f, 0.09647372f, 0.08056933f, -0.05600851f, 
    0.03141411f, 0.05709470f, -0.06663155f, 0.19331433f, -0.09357155f, 0.06083304f, 0.03087061f, -0.05028439f, 
    0.11674579f, 0.06197939f, -0.03489245f, 0.17843285f, -0.04906717f, -0.01945533f, -0.05093184f, -0.17383376f, 
    0.01931792f, -0.06145245f, 0.16451801f, 0.01150932f, 0.44406646f, 0.07265833f, -0.02723082f, 0.17915998f, 
    -0.04068280f, 0.12588175f, -0.09591859f, 0.10725325f, -0.13522600f, 0.03340952f, 0.08845185f, 0.06282104f, 
    0.30639184f, -0.02927753f, 0.06551997f, 0.13823606f, 0.08391593f, 0.02603841f, -0.07338855f, 0.04762200f, 
    -0.06405700f, -0.02756859f, -0.02752030f, 0.04933991f, 0.02358419f, 0.14797020f, -0.16089691f, -0.20215771f, 
    -0.04818942f, -0.15272523f, 0.10074572f, -0.03074093f, 0.13305365f, -0.04861008f, -0.08544542f, -0.18636872f, 
    -0.07190756f, -0.29708013f, 0.02116688f, -0.04110870f, -0.04022797f, -0.04807528f, 0.05389979f, -0.13801698f, 
    0.00008379f, 0.02898549f, 0.01947113f, 0.06381642f, 0.10957260f, 0.08810255f, -0.12188180f, -0.08469036f, 
    -0.03316576f, 0.03727610f, -0.13158178f, -0.24281096f, -0.10250333f, 0.01852742f, 0.07459441f, -0.08669384f, 
    0.49346474f, 0.17185703f, -0.22939228f, 0.15093641f, 0.10963051f, -0.02468440f, -0.08385038f, 0.15754291f, 
    -0.07038722f, 0.11354753f, 0.08166900f, 0.01888740f, 0.03166419f, 0.05810434f, 0.09911818f, 0.10402713f, 
    0.14345682f, 0.00575057f, 0.06890230f, 0.11384390f, 0.10924442f, 0.10266449f, 0.03722042f, 0.08010151f, 
    -0.06786109f, 0.08877305f, 0.06607620f, 0.11566435f, 0.21375024f, 0.10652011f, -0.02135111f, 0.06408776f, 
    -0.01935211f, 0.06562273f, -0.01658106f, -0.09694710f, 0.04376715f, -0.30705667f, -0.15450740f, 0.00383493f, 
    -0.03197106f, -0.06665589f, -0.05114679f, 0.12930274f, -0.03700675f, 0.04565297f, 0.08396395f, 0.08605895f, 
    0.50355667f, -0.18911834f, -0.05546205f, -0.02211692f, 0.12017588f, 0.02892062f, -0.05053368f, -0.07517796f, 
    -0.02573190f, 0.01916365f, 0.05232612f, 0.05355447f, 0.10246848f, -0.39328697f, -0.22783634f, -0.11631349f, 
    0.24050073f, -0.03451229f, -0.01955773f, -0.03141885f, -0.02458184f, 0.16319990f, 0.20350304f, 0.00531597f, 
    0.27977440f, 0.34521002f, 0.16490969f, -0.18813632f, -0.01326759f, -0.02301271f, -0.04644988f, 0.08100910f, 
    0.04298762f, 0.05873854f, -0.00277525f, -0.21052657f, 0.07624276f, 0.33425876f, -0.13781923f, -0.39885494f, 
    0.05627174f, 0.00408533f, 0.08639535f, -0.11883457f, 0.13315618f, -0.19795251f, 0.04363412f, -0.01013018f, 
    0.23374906f, -0.27384290f, -0.09590687f, 0.07620219f, 0.14396517f, -0.01644555f, -0.11424782f, 0.10358139f, 
    0.14078388f, 0.13466635f, 0.16221666f, -0.00876033f, 0.17370914f, -0.14117709f, -0.10705738f, 0.08836564f, 
    -0.05594179f, -0.03490920f, -0.15020615f, -0.07819838f, -0.07436086f, -0.10120463f, 0.09989215f, -0.01965844f, 
    -0.22767398f, -0.05569929f, 0.11578806f, 0.00512135f, -0.02215406f, 0.04823592f, 0.24839471f, 0.03330204f, 
    0.06749702f, 0.08533425f, 0.06917716f, -0.00746699f, -0.10343028f, -0.21072309f, -0.00443837f, -0.05293377f, 
    -0.12237482f, -0.13080850f, 0.08319645f, 0.00939711f, -0.01541351f, 0.02946280f, -0.03186704f, 0.05009331f, 
    -0.22447006f, -0.29517850f, -0.15058400f, 0.00030224f, -0.19600075f, -0.02722428f, -0.17548306f, -0.03500123f, 
    0.07317803f, 0.09557476f, 0.14867201f, 0.07307870f, -0.50063187f, -0.41849267f, 0.18343681f, 0.03009679f, 
    -0.15325172f, -0.05145803f, -0.18726218f, -0.11274612f, -0.03071555f, 0.17633756f, -0.06186740f, 0.15966547f, 
    0.08437102f, 0.23879753f, 0.02587577f, 0.00666446f, 0.18360780f, 0.10454330f, -0.00403571f, -0.11163755f, 
    0.13692926f, 0.09978051f, -0.23438910f, 0.07985264f, 0.11571665f, 0.05427140f, 0.02860999f, -0.11988635f, 
    0.09935750f, 0.09737185f, -0.16121592f, -0.06893068f, 0.16467352f, 0.11720569f, 0.00266850f, -0.02751286f, 
    0.06127313f, -0.12525067f, -0.14114070f, -0.10275951f, 0.06108012f, 0.00765027f, -0.04775753f, -0.14745183f, 
    -0.05750822f, -0.06634089f, 0.30452263f, 0.12556453f, -0.11328190f, 0.03487487f, 0.19199152f, -0.09337083f, 
    0.11036100f, 0.07920916f, 0.07147662f, 0.11349891f, 0.04407120f, -0.04226791f, -0.03875982f, -0.02865415f, 
    -0.05859821f, 0.01336325f, 0.04676487f, 0.00745320f, -0.03712337f, -0.05182845f, 0.04715019f, 0.00569037f, 
    0.06192382f, -0.06946663f, 0.02231521f, -0.03676605f, 0.01762787f, -0.05043696f, -0.04093240f, 0.03389719f, 
    -0.06509864f, -0.03721014f, -0.05957547f, -0.06890376f, -0.05313070f, -0.07293883f, 0.04316405f, 0.00032538f, 
    -0.01755529f, 0.05018596f, -0.05587425f, -0.04822603f, -0.01918037f, 0.06564800f, 0.06502099f, 0.04186383f, 
    0.04379670f, -0.06604239f, -0.07039935f, -0.04776507f, 0.02945503f, 0.00381168f, 0.00174445f, -0.04957712f, 
    0.01666314f, 0.03462071f, -0.05028191f, 0.02426674f, -0.06239345f, -0.08514612f, 0.03398434f, 0.02228137f, 
    -0.03423525f, -0.03618087f, 0.05819749f, 0.03126092f, -0.00661755f, 0.01293810f, -0.02651224f, 0.02101358f, 
    -0.01027614f, -0.01515011f, -0.01839466f, -0.05370250f, 0.03434811f, -0.01180985f, -0.01567132f, 0.00998676f, 
    0.03951262f, -0.06532286f, -0.01989936f, -0.00306445f, 0.04412398f, 0.02255930f, 0.02754395f, 0.05529394f, 
    -0.02817755f, -0.06099368f, 0.06893973f, 0.03108484f, 0.03927742f, -0.02886696f, -0.03859807f, 0.00176082f, 
    -0.03846881f, 0.01170986f, -0.01770915f, 0.02250371f, 0.04226080f, -0.04490501f, -0.05368652f, 0.02979477f, 
    0.03907891f, -0.01521565f, 0.02361704f, 0.03271710f, 0.01040544f, -0.04125354f, -0.04946934f, 0.03628850f, 
    0.00637595f, 0.01996906f, -0.01322847f, 0.04721779f, -0.04622227f, -0.07516851f, 0.05735720f, -0.07326251f, 
    -0.07099859f, 0.03965930f, -0.07244211f, 0.02650633f, -0.05624572f, -0.02861682f, 0.04192546f, -0.02654434f, 
    0.01585466f, -0.06892039f, 0.01235226f, -0.01645059f, -0.06434534f, 0.05189246f, 0.01943483f, -0.08601833f, 
    0.00381375f, -0.03789656f, 0.00094100f, -0.07462104f, 0.02665088f, 0.06237406f, -0.04879865f, 0.00207233f, 
    0.02307664f, 0.01750826f, 0.02999963f, 0.00560558f, 0.06334609f, 0.00824954f, -0.02724352f, 0.01974835f, 
    0.00247463f, -0.05450094f, -0.08144344f, -0.02854842f, 0.00663807f, 0.01840593f, 0.05182065f, 0.05695261f, 
    0.03914396f, 0.00824259f, -0.06442959f, 0.06152652f, 0.03948876f, 0.03109253f, -0.05870355f, -0.00186380f, 
    -0.06006807f, -0.02853096f, -0.06871905f, -0.01282586f, -0.06768606f, 0.03934072f, 0.02761775f, 0.04719026f, 
    -0.04518620f, -0.01230512f, -0.01861513f, -0.06295887f, -0.07384256f, -0.03661262f, -0.07855278f, -0.04266991f, 
    0.03216400f, -0.01497928f, -0.00122732f, -0.03819157f, -0.03576470f, -0.02369956f, -0.01014790f, 0.05402749f, 
    0.06533460f, 0.04243727f, -0.00145981f, -0.05289293f, -0.02594471f, -0.06454495f, 0.03196118f, 0.01097170f, 
    -0.03355722f, -0.06122038f, 0.01332511f, -0.00276684f, 0.00901542f, 0.03985148f, -0.00095728f, -0.05142260f, 
    -0.04854628f, -0.01469613f, 0.06173865f, -0.01839123f, -0.02302809f, 0.00883300f, 0.04554885f, -0.02471734f, 
    0.00975508f, -0.00061150f, 0.03237924f, 0.00858634f, -0.02371718f, -0.02750409f, -0.04060072f, -0.09103031f, 
    0.03551742f, -0.02361152f, 0.01285149f, -0.03732910f, 0.04351847f, -0.07157160f, -0.03350522f, -0.02564376f, 
    -0.02945052f, 0.03779238f, -0.03847453f, -0.06252439f, -0.00239188f, -0.05209997f, -0.04859339f, -0.04533192f, 
    -0.00981376f, 0.04551274f, -0.07965063f, 0.01954157f, 0.02403576f, -0.00144855f, -0.02605315f, 0.03480838f, 
    0.02392291f, 0.04533133f, -0.06137699f, 0.02570473f, 0.03303907f, 0.01310914f, -0.00775281f, -0.05245256f, 
    0.00722426f, 0.00936275f, 0.01479981f, 0.05028457f, -0.06787033f, 0.04884408f, -0.02813832f, -0.01170836f, 
    -0.04591468f, -0.05965883f, -0.07058131f, 0.01617954f, -0.05261602f, 0.00468307f, -0.06897811f, -0.05664825f, 
    0.02672704f, -0.01544629f, -0.02868689f, -0.00993155f, 0.04413782f, 0.03897477f, 0.02476715f, -0.00786686f, 
    0.05432766f, -0.02254248f, -0.08314463f, 0.00978648f, -0.06285033f, -0.03671066f, 0.05757710f, 0.05622769f, 
    0.03505096f, 0.02690906f, 0.02462965f, 0.02985863f, -0.02699429f, -0.04549308f, 0.03107896f, -0.03033135f, 
    -0.03274432f, -0.06592289f, -0.06749340f, 0.01833379f, 0.01146938f, -0.07822243f, -0.01668938f, 0.05399271f, 
    -0.04349959f, -0.04108140f, 0.05147854f, 0.05988678f, -0.07583304f, -0.00826309f, -0.05521220f, 0.03398729f, 
    0.01729568f, -0.04033079f, -0.02010983f, 0.02082322f, -0.03152706f, -0.00373989f, 0.02035479f, 0.02475773f, 
    -0.01269262f, 0.05105839f, -0.04977199f, -0.05750791f, 0.05728033f, -0.00751584f, -0.05018985f, -0.00415203f, 
    -0.03472099f, 0.00278439f, -0.05521059f, 0.02408099f, -0.05188879f, -0.07219743f, -0.01736995f, -0.03522956f, 
    -0.07562099f, -0.05438484f, -0.02646761f, -0.02852713f, 0.05130063f, -0.01851343f, -0.00534479f, -0.05384750f, 
    -0.04646390f, 0.04389535f, -0.07438321f, 0.00963936f, 0.01592415f, -0.04224159f, 0.03368038f, 0.04357688f, 
    -0.06691083f, -0.01748232f, 0.02954684f, -0.05649564f, 0.06102004f, -0.07768039f, -0.03809274f, 0.02953207f, 
    0.03870082f, 0.02845998f, 0.05962359f, -0.02598492f, 0.01245738f, -0.01953511f, 0.00385434f, 0.04598271f, 
    -0.04392654f, 0.04169801f, -0.06693202f, -0.03487337f, -0.04328272f, 0.05986614f, 0.01655768f, 0.00787228f, 
    0.01247200f, 0.02377493f, -0.09268516f, 0.03959424f, 0.05941280f, 0.00635477f, -0.05558408f, 0.01966142f, 
    0.00075080f, -0.00618071f, -0.04424901f, -0.05504902f, 0.01269274f, 0.06056197f, 0.03215717f, -0.04814531f, 
    -0.00558197f, -0.00988673f, -0.03103756f, 0.00675779f, 0.03934870f, -0.03322610f, -0.06321264f, -0.00064368f, 
    -0.02153014f, 0.04646552f, -0.04953639f, -0.08991227f, -0.07312756f, 0.01871550f, 0.02491578f, -0.05098449f, 
    0.01873933f, -0.03338443f, 0.05966438f, 0.05109075f, -0.04914976f, 0.01131974f, -0.08204713f, 0.07075613f, 
    0.00343424f, 0.06088298f, 0.07021763f, -0.04391375f, 0.03651966f, -0.01690276f, -0.02172231f, 0.03149224f, 
    0.01384447f, -0.05816196f, 0.04660974f, 0.02164149f, -0.01237776f, 0.01440903f, -0.04246829f, -0.05303492f, 
    -0.01521744f, 0.00720591f, 0.00819878f, -0.03310151f, 0.04479853f, 0.01089366f, -0.06099186f, -0.00047110f, 
    -0.00666081f, -0.01335003f, 0.08446006f, -0.00821991f, -0.00988583f, -0.00747128f, 0.04672032f, 0.02372830f, 
    0.03361887f, -0.07285786f, 0.04752931f, 0.05305721f, -0.05289665f, 0.04904506f, -0.05863211f, -0.03350137f, 
    0.03782049f, 0.04110003f, -0.06608751f, -0.04978414f, 0.01461723f, -0.00054910f, 0.04415642f, 0.00787145f, 
    0.03530883f, 0.03226084f, -0.04987630f, -0.01625630f, 0.03719004f, -0.03583385f, 0.01104615f, 0.03328811f, 
    -0.04790250f, 0.04143399f, -0.05362789f, -0.00500525f, -0.03433396f, 0.06847138f, -0.03154864f, 0.00247332f, 
    -0.03899343f, -0.05691534f, -0.02364955f, -0.06184798f, 0.02451856f, -0.03320178f, 0.02033613f, 0.06382640f, 
    0.06297003f, 0.03942807f, -0.01398574f, -0.02181165f, 0.04882986f, -0.06206024f, -0.08814514f, -0.02719494f, 
    -0.00598950f, -0.03506588f, -0.01283849f, -0.05970587f, -0.04535061f, 0.04610327f, -0.03695465f, 0.03026102f, 
    -0.03637946f, -0.09023441f, -0.03880163f, -0.07709944f, 0.00614689f, -0.07619333f, -0.07836431f, -0.05743803f, 
    -0.01582507f, -0.04991735f, -0.07061328f, 0.01499945f, -0.03200313f, 0.02484236f, -0.05917438f, -0.09097280f, 
    -0.04926657f, -0.07706845f, -0.00238530f, 0.01839620f, -0.03888783f, 0.03079881f, 0.05023801f, -0.03292548f, 
    -0.08073844f, -0.05395998f, -0.02056869f, -0.05720664f, 0.02007428f, -0.05832487f, 0.02341602f, -0.02843478f, 
    0.05639505f, 0.06916482f, -0.01371440f, -0.04059452f, -0.01532965f, -0.02004415f, 0.02587167f, -0.08644100f, 
    -0.02466659f, -0.03345405f, -0.03568754f, -0.06299258f, 0.05862741f, -0.09373213f, -0.02374084f, -0.02318294f, 
    0.00139311f, -0.05442160f, -0.07292818f, 0.03251868f, 0.00053296f, 0.06193633f, -0.07204367f, 0.03513072f, 
    0.03116094f, 0.00150948f, -0.00674050f, 0.02528898f, 0.01757354f, -0.02033062f, 0.00000253f, -0.04863555f, 
    0.06619493f, 0.01374239f, 0.02542672f, 0.03527390f, 0.05910412f, -0.00177505f, 0.06754424f, -0.04379802f, 
    -0.00353157f, -0.06858821f, 0.02438621f, 0.06644981f, 0.01520160f, -0.03042734f, 0.03355705f, -0.05073189f, 
    0.02273521f, 0.00869106f, -0.07738648f, -0.02785170f, -0.05318742f, 0.04108735f, -0.03509398f, -0.05927645f, 
    -0.10085644f, 0.08449079f, -0.10512123f, -0.02882696f, 0.05177430f, -0.11816125f, -0.03178515f, -0.01891611f, 
    0.02285288f, 0.07023987f, 0.01772210f, 0.05629307f, -0.17825140f, 0.02669307f, 0.22389898f, 0.15961933f, 
    -0.11650989f, -0.05251899f, 0.08554979f, 0.02408345f, 0.01140211f, 0.04008766f, 0.05248208f, -0.00682047f, 
    0.10375866f, 0.00045105f, -0.17058589f, 0.14399798f, -0.00834684f, -0.01639953f, 0.04461422f, 0.13053036f, 
    -0.10066123f, 0.01223360f, -0.04233330f, -0.04771066f, 0.17763937f, -0.08101057f, 0.17270736f, -0.18614674f, 
    -0.01561871f, -0.08699506f, 0.04147583f, -0.03009564f, 0.02949411f, -0.01916091f, 0.00395098f, 0.05420048f, 
    -0.06743192f, -0.06626195f, -0.16329327f, -0.07210843f, 0.11106980f, 0.12120210f, -0.16033080f, 0.03914052f, 
    -0.06191114f, 0.05961428f, 0.06920549f, -0.00315314f, -0.10032198f, -0.03428918f, -0.17712051f, 0.05180297f, 
    0.06523111f, 0.00088548f, -0.12734374f, -0.06786843f, -0.16450346f, -0.00131845f, -0.14044192f, -0.02705488f, 
    0.10803760f, -0.03678813f, 0.24090251f, -0.18740511f, -0.19334108f, 0.05141048f, -0.03600909f, 0.03655737f, 
    0.07081293f, 0.02986076f, 0.08312463f, -0.02134258f, -0.10508369f, -0.14944421f, -0.04190228f, 0.13975768f, 
    -0.03901924f, -0.17570680f, 0.00429814f, -0.12195294f, -0.05845214f, -0.03884601f, -0.01391291f, -0.07103026f, 
    0.26287693f, 0.05050627f, 0.04711063f, -0.21570273f, 0.00186891f, 0.03647084f, -0.08035001f, 0.04806826f, 
    0.03811739f, 0.05653477f, -0.09234561f, 0.01467268f, 0.17794532f, 0.11560142f, -0.04549395f, -0.01310986f, 
    -0.03798380f, -0.01243941f, -0.08694116f, 0.17120531f, 0.11004227f, 0.06308834f, 0.02444243f, -0.07918459f, 
    -0.05166027f, -0.08273090f, 0.11119181f, -0.05614981f, -0.17175449f, -0.13489193f, 0.17079158f, 0.02943749f, 
    -0.05764832f, 0.05360282f, -0.12553355f, 0.03315655f, 0.19983368f, -0.02132346f, 0.19160528f, 0.11076231f, 
    -0.12306096f, -0.02468076f, -0.02644404f, -0.09254035f, 0.10379534f, -0.04338107f, -0.04231224f, -0.02974934f, 
    -0.21097228f, 0.05369467f, -0.16185826f, -0.12486253f, 0.11411211f, -0.05593639f, 0.03573393f, -0.09538390f, 
    -0.09218185f, -0.19618340f, -0.10607990f, -0.08322136f, -0.27584341f, -0.16113226f, 0.03669245f, -0.01518441f, 
    -0.11394627f, 0.01827572f, -0.05790934f, 0.01405451f, 0.00937008f, -0.02365609f, 0.00559961f, -0.04939278f, 
    -0.28660786f, 0.08901047f, -0.00547494f, -0.03952587f, -0.03168858f, 0.02569550f, -0.01380326f, -0.07174443f, 
    0.03089378f, -0.04318180f, -0.16874883f, -0.03351260f, -0.16227888f, -0.13304828f, -0.04079161f, -0.06847173f, 
    -0.10227764f, -0.00232310f, -0.08145941f, -0.03682150f, 0.01908799f, 0.04614969f, 0.00441052f, -0.02429522f, 
    -0.50025493f, 0.09654696f, 0.07937331f, -0.16830015f, -0.01501023f, 0.06498141f, -0.05958436f, -0.12012039f, 
    0.09554468f, 0.02566475f, 0.02765765f, 0.09869180f, 0.17713073f, 0.07370190f, 0.12510593f, 0.20468105f, 
    0.01817583f, 0.15532869f, -0.01403330f, -0.03231184f, 0.04079445f, 0.02852731f, -0.18744107f, -0.14714183f, 
    0.48464045f, -0.04491757f, -0.08138282f, 0.26876926f, 0.00479671f, -0.06230144f, -0.17912661f, -0.15467739f, 
    -0.02319167f, 0.13235882f, 0.09885917f, 0.17052640f, 0.09519341f, -0.43083712f, -0.07970209f, -0.15487842f, 
    0.13197899f, -0.09957775f, 0.02102384f, 0.03269633f, 0.09686421f, -0.08910991f, 0.04891650f, -0.12886301f, 
    -0.15938528f, 0.12847735f, 0.05093793f, -0.10275911f, -0.02499362f, 0.03279852f, -0.02323047f, 0.12438295f, 
    0.16624682f, 0.04486089f, 0.00191652f, -0.09582806f, -0.38836518f, -0.17024013f, -0.14989185f, -0.05703699f, 
    0.12950386f, -0.01027671f, 0.05279804f, 0.01812319f, -0.04990286f, 0.00200186f, 0.13866624f, 0.12509912f, 
    -0.01254251f, -0.04406407f, 0.02149579f, 0.06457464f, 0.08087538f, -0.03324075f, 0.07757437f, 0.14901604f, 
    -0.02366214f, 0.14505836f, 0.01221327f, 0.08747906f, 0.22540334f, -0.01577899f, 0.02371340f, 0.07218928f, 
    -0.12056993f, 0.05159873f, 0.14259546f, -0.08744358f, -0.01275706f, 0.03336941f, -0.11760872f, -0.05150937f, 
    0.10674238f, 0.16571790f, 0.08529513f, 0.05641194f, -0.07623636f, -0.02853527f, 0.13898790f, 0.04540760f, 
    -0.01886634f, 0.15837741f, -0.04075794f, -0.08751817f, -0.39021826f, 0.02079473f, -0.03777779f, 0.12522230f, 
    0.17303327f, 0.07804371f, 0.06802623f, 0.04702026f, 0.05861111f, 0.01952989f, -0.04863158f, -0.11013174f, 
    -0.09976162f, 0.11658814f, -0.00516858f, 0.09618363f, 0.00009803f, 0.03452356f, -0.03171580f, -0.01192167f, 
    0.00374975f, 0.04715532f, 0.04567840f, -0.09828208f, 0.13797483f, 0.00073622f, 0.15231045f, 0.07432079f, 
    0.16470271f, 0.11262482f, -0.06495365f, 0.08823152f, -0.02920478f, 0.10150100f, -0.02938273f, 0.03111006f, 
    -0.31134936f, 0.11177982f, -0.11752071f, -0.04531142f, 0.11384901f, -0.00519009f, 0.07441745f, -0.01122198f, 
    0.12528531f, 0.08707157f, 0.05569820f, 0.16788678f, -0.37233838f, -0.11058863f, 0.09516618f, 0.26599091f, 
    0.19546300f, -0.12460990f, -0.17289571f, -0.12408365f, -0.08278649f, -0.12221767f, 0.01030866f, 0.04384544f, 
    0.04290915f, -0.07782077f, 0.09030639f, -0.33669043f, 0.01894531f, 0.15848546f, -0.06614856f, -0.01709470f, 
    0.04627108f, 0.16988297f, 0.19196156f, 0.12084692f, -0.22609951f, 0.11340031f, 0.03370898f, -0.08793435f, 
    0.17607540f, -0.14151697f, -0.01375796f, -0.14836425f, -0.03658110f, -0.02815536f, 0.08092075f, 0.11896469f, 
    0.02972939f, 0.03942272f, -0.00620862f, 0.00939448f, -0.01252774f, -0.05874909f, 0.04685725f, -0.05615948f, 
    -0.06099825f, 0.03850688f, -0.06315958f, 0.01406234f, 0.05264240f, -0.00802346f, -0.07059326f, -0.01243581f, 
    -0.00942609f, 0.02699118f, -0.02800387f, -0.06473666f, 0.02439227f, -0.02767987f, -0.01328261f, -0.03570468f, 
    0.05527051f, 0.03747603f, 0.05251772f, -0.06774012f, 0.01388220f, -0.06727060f, -0.07836679f, -0.01986729f, 
    -0.07379753f, -0.04243313f, 0.04678672f, 0.03186705f, -0.06579966f, -0.02775204f, -0.05345030f, -0.02275498f, 
    0.01776697f, 0.06008961f, -0.02963357f, -0.07693626f, 0.02271330f, -0.04399209f, -0.06403783f, -0.04789335f, 
    -0.02291175f, -0.06571207f, -0.04067113f, -0.03361348f, 0.00566001f, 0.00893728f, 0.04118680f, -0.03405600f, 
    0.00746671f, -0.04634837f, -0.07833658f, 0.04000437f, 0.05940351f, -0.01404712f, 0.02986383f, 0.00870072f, 
    0.00925795f, -0.01598022f, -0.05934769f, -0.05591950f, -0.06040321f, 0.00013754f, 0.04933832f, 0.05453473f, 
    0.01031987f, -0.06708713f, 0.00764654f, -0.05644199f, 0.03645500f, 0.02456679f, 0.05502991f, -0.02780401f, 
    -0.03300226f, -0.04255392f, -0.03254941f, 0.04331429f, -0.03849626f, -0.02413261f, -0.02358244f, 0.01807627f, 
    -0.06649742f, -0.01173289f, -0.00473271f, -0.02137172f, -0.07953165f, 0.02726674f, -0.00144991f, -0.08038572f, 
    -0.06442048f, -0.02699707f, -0.03058878f, -0.07580274f, -0.04401123f, 0.00624284f, 0.02549583f, -0.02982325f, 
    -0.02639658f, -0.05238990f, 0.02984798f, 0.04172679f, -0.06201910f, -0.01952901f, -0.07778110f, 0.03012923f, 
    -0.05179910f, -0.00914940f, 0.01087180f, 0.00390644f, -0.05527550f, 0.01572960f, -0.05004835f, 0.01904275f, 
    -0.03833489f, -0.06854957f, 0.05049078f, 0.02148432f, 0.04027559f, -0.03528571f, -0.08364760f, -0.05332145f, 
    0.00652170f, -0.03988796f, -0.02318532f, -0.07480998f, 0.01812574f, -0.05142165f, -0.07963560f, -0.05437014f, 
    -0.07809022f, 0.03993728f, -0.01190488f, -0.05675895f, -0.02968493f, 0.02484469f, 0.01677096f, -0.00265605f, 
    0.01254872f, -0.00524410f, -0.00674014f, -0.06970774f, 0.02236370f, 0.02873778f, -0.00804690f, -0.01678871f, 
    0.04212821f, 0.04321035f, 0.04333117f, 0.04499730f, 0.03599112f, -0.00604606f, -0.00535690f, -0.04245530f, 
    -0.00997249f, 0.04832054f, -0.07653242f, -0.02648949f, -0.02789992f, -0.04370211f, -0.05091290f, 0.00260616f, 
    -0.02411005f, -0.01971562f, -0.08203671f, 0.01555594f, -0.02488952f, -0.07520545f, 0.01357643f, -0.07114891f, 
    0.01751343f, 0.04727513f, -0.02158348f, 0.05421158f, -0.01851610f, -0.07125941f, -0.05283376f, -0.03825230f, 
    0.03163351f, -0.02974417f, 0.06094548f, 0.05086741f, -0.05723329f, 0.04126232f, 0.04409282f, 0.03564869f, 
    -0.10092394f, 0.07692582f, 0.06150987f, 0.00578922f, 0.06380465f, -0.08644734f, 0.09477256f, -0.05120900f, 
    0.07590187f, -0.01205711f, 0.01276189f, 0.08462919f, -0.28701323f, -0.00084803f, 0.10376850f, 0.19178498f, 
    -0.02360920f, 0.17775027f, 0.03686015f, 0.01203104f, -0.07001765f, 0.02038287f, 0.15067780f, -0.02197875f, 
    0.10454408f, -0.25748026f, 0.01449905f, 0.16319062f, 0.04997213f, -0.00916255f, 0.07996782f, -0.01257010f, 
    -0.03597702f, 0.00706943f, 0.00935859f, -0.03859165f, 0.18931703f, -0.30128554f, 0.23104577f, 0.19154705f, 
    0.00827827f, -0.13054809f, -0.03926632f, 0.10304462f, 0.05029203f, 0.01582973f, 0.06085631f, 0.00905765f, 
    -0.14191778f, 0.10883073f, -0.01222791f, -0.07297397f, 0.05613419f, 0.11085016f, 0.01869591f, 0.08275603f, 
    0.06937078f, -0.03742773f, -0.01077491f, 0.07421270f, -0.05935618f, 0.15451582f, -0.16463977f, -0.27626806f, 
    0.04191170f, 0.05476362f, 0.06556763f, -0.06269769f, 0.01409970f, 0.11877537f, 0.09302779f, -0.10140426f, 
    -0.18898413f, -0.03119761f, 0.00692944f, -0.22915462f, 0.13226293f, 0.06919647f, 0.01356564f, 0.05833774f, 
    0.00430330f, 0.03878397f, 0.06208792f, -0.04661172f, -0.24181652f, 0.01387280f, -0.04553051f, 0.00279574f, 
    0.18175077f, -0.01585805f, -0.02259466f, 0.01173411f, -0.06600834f, 0.02218934f, -0.06684669f, -0.12830968f, 
    0.15902545f, 0.00051461f, -0.01572915f, 0.21532309f, -0.02338815f, 0.09327503f, -0.00106718f, -0.07827277f, 
    0.01265035f, -0.05577154f, -0.04115203f, -0.02859312f, 0.00760674f, -0.15574890f, -0.03398900f, 0.13284627f, 
    0.01139174f, 0.09460202f, -0.07679266f, -0.05131893f, 0.02445703f, -0.01739323f, -0.07989424f, -0.04903449f, 
    -0.14773776f, -0.02824904f, 0.11577657f, -0.01957798f, 0.02855032f, 0.05938711f, -0.11311705f, -0.03394582f, 
    0.02430916f, 0.07423557f, -0.03940064f, 0.02076759f, 0.13809055f, -0.05436977f, -0.00213211f, 0.16185302f, 
    0.03143506f, 0.08856930f, 0.04066995f, -0.05216739f, 0.12683900f, -0.05728406f, -0.00048222f, -0.01030456f, 
    -0.18283214f, 0.33299622f, -0.01353869f, -0.25830072f, 0.15311742f, 0.05618918f, 0.07490092f, -0.00886915f, 
    0.09595641f, 0.04722703f, -0.08754601f, 0.08557479f, 0.13596357f, 0.11384247f, 0.09889411f, -0.32415992f, 
    0.09312584f, 0.00362253f, -0.06081411f, 0.06513539f, 0.05558307f, 0.09331682f, 0.00591763f, 0.02479298f, 
    0.26290065f, 0.02319103f, -0.01116782f, -0.17306547f, -0.01487482f, 0.04073467f, -0.04714706f, 0.14629006f, 
    0.10712742f, 0.07308383f, 0.06353975f, 0.11538446f, 0.11363242f, 0.04553574f, 0.16317815f, 0.12794158f, 
    -0.06247972f, -0.06176662f, -0.02442843f, -0.06311461f, -0.01587237f, -0.02369994f, -0.05248412f, 0.00406495f, 
    0.00924549f, -0.03081085f, -0.07710796f, -0.05455300f, -0.04427131f, 0.01146919f, -0.04288058f, 0.06080897f, 
    -0.01859395f, 0.02357861f, -0.02950237f, -0.01271021f, 0.02154453f, 0.04131688f, 0.05814509f, -0.05917231f, 
    -0.07221362f, -0.04478313f, 0.04368697f, -0.04231687f, 0.05832112f, 0.04906577f, -0.06135811f, -0.04488865f, 
    -0.06483467f, -0.06618530f, -0.04833260f, -0.05160416f, 0.04776078f, -0.06075434f, -0.02464553f, 0.02440033f, 
    0.05065149f, 0.04489478f, 0.04338799f, -0.00224176f, -0.06549313f, 0.00479120f, -0.00509550f, 0.00599234f, 
    -0.04536843f, -0.04355774f, -0.07283208f, 0.01755033f, -0.05402902f, 0.06668715f, 0.01146152f, -0.01949959f, 
    -0.05595689f, 0.04051967f, -0.05324864f, -0.04424333f, -0.00942960f, -0.03133016f, 0.05297204f, 0.06241858f, 
    0.04327979f, -0.07717875f, 0.01526124f, -0.04825751f, -0.05186731f, -0.07044442f, 0.03800635f, -0.03376618f, 
    -0.04193156f, -0.04151789f, -0.05963597f, -0.07053351f, -0.05624402f, 0.05385934f, 0.03526231f, 0.06455063f, 
    -0.06746165f, 0.02780386f, -0.07618821f, 0.03837681f, 0.04767073f, -0.04584301f, -0.00843686f, -0.00711732f, 
    0.04561919f, 0.00772589f, 0.01105714f, -0.03494413f, 0.02384669f, 0.00736221f, -0.00252943f, -0.00325308f, 
    0.05585578f, -0.00933855f, 0.03688892f, 0.01631414f, 0.02867294f, -0.06991284f, 0.01724852f, 0.03537320f, 
    -0.01011375f, 0.05430199f, -0.06058824f, 0.04874685f, -0.00292143f, -0.05257909f, -0.07769039f, -0.04233180f, 
    -0.05237053f, -0.07579964f, 0.01399038f, 0.00290749f, 0.06602176f, -0.02917791f, -0.06503523f, -0.03499161f, 
    -0.01281957f, -0.04345817f, -0.04962356f, -0.06544839f, 0.00939152f, -0.04552628f, 0.05343321f, -0.03207961f, 
    0.04780806f, 0.01577755f, 0.01624140f, 0.00618075f, 0.03471811f, 0.03355358f, 0.01026571f, -0.03108110f, 
    0.05494845f, 0.00156726f, -0.08325499f, 0.01244013f, 0.04356491f, -0.05284832f, 0.03942854f, 0.01540756f, 
    -0.03871144f, -0.07011275f, -0.02298012f, 0.05622795f, 0.05609151f, -0.03959540f, 0.00720367f, -0.05152779f, 
    0.03020275f, -0.03982877f, 0.03414062f, -0.03161487f, -0.04911896f, -0.01342079f, 0.05525699f, -0.00204010f, 
    -0.07343110f, -0.00167456f, -0.03054711f, 0.00968124f, -0.05176320f, -0.03493150f, -0.06731390f, -0.03614897f, 
    0.05944888f, 0.00040894f, -0.04737368f, 0.00807991f, -0.06152078f, -0.06194863f, 0.04378213f, 0.04352713f, 
    -0.01668826f, -0.02848091f, 0.02581089f, -0.06594489f, 0.00088407f, 0.04262368f, -0.04366406f, -0.03134515f, 
    0.01180468f, 0.03350586f, -0.04472639f, 0.03373871f, -0.06632913f, 0.05262944f, 0.03596614f, -0.04307908f, 
    0.03203613f, -0.03046992f, -0.04079216f, 0.00419253f, -0.05311145f, 0.03301861f, -0.04578039f, -0.02407521f, 
    -0.05900560f, -0.05159217f, 0.05179895f, 0.03719816f, 0.00699357f, 0.00618403f, -0.01115723f, 0.03297999f, 
    -0.04843372f, -0.05833994f, -0.07684863f, -0.03466202f, -0.06989238f, -0.06143449f, -0.04222433f, -0.06371132f, 
    0.02260631f, -0.00939639f, -0.07890799f, -0.06209139f, -0.00040207f, -0.00517763f, 0.00707745f, -0.05670490f, 
    -0.02881243f, -0.02910147f, 0.05716689f, -0.06176952f, -0.00568401f, -0.00219949f, -0.06193623f, 0.01234987f, 
    0.02173699f, -0.07233985f, -0.00279329f, -0.06379209f, 0.00236801f, -0.03298972f, 0.04100978f, 0.05824731f, 
    -0.02831117f, 0.01026824f, 0.00411277f, -0.07153829f, 0.04948187f, -0.06054699f, 0.05507561f, -0.02321031f, 
    0.00498525f, -0.06767030f, 0.00354439f, -0.03432671f, 0.04739624f, 0.05664666f, -0.02757424f, -0.07539732f, 
    -0.02210680f, -0.03951405f, 0.06647650f, 0.03066577f, -0.04058360f, -0.00042732f, 0.05046326f, -0.04744428f, 
    0.02116158f, -0.00836460f, -0.05290026f, -0.07089266f, 0.02422902f, 0.06080272f, -0.05036496f, -0.02410164f, 
    -0.06611919f, -0.02559653f, 0.00417114f, -0.05098668f, 0.02880234f, 0.04785219f, -0.04286407f, -0.01981070f, 
    -0.01875925f, 0.05682858f, -0.06528364f, 0.01318010f, 0.05382376f, 0.00881626f, 0.02997330f, 0.01578917f, 
    0.02940344f, 0.00378942f, 0.02063984f, -0.05509798f, -0.05747270f, 0.04662496f, 0.05471715f, -0.03056542f, 
    -0.03316890f, -0.07306447f, 0.02521661f, 0.05096083f, -0.03000551f, 0.00815884f, 0.00153633f, 0.02793159f, 
    0.02681162f, 0.02091347f, -0.04549864f, 0.05175952f, -0.07696265f, -0.03898231f, -0.06849927f, -0.00361463f, 
    0.03080752f, 0.04111747f, -0.00009664f, -0.06232430f, 0.04186996f, 0.04356190f, -0.00818723f, -0.02677275f, 
    -0.03543341f, -0.04797631f, -0.03712887f, -0.05978645f, -0.03150140f, 0.05575976f, -0.07116249f, -0.07042375f, 
    0.06131758f, -0.04747805f, -0.05576254f, 0.04846102f, 0.02588412f, -0.04377694f, -0.02071661f, -0.03409539f, 
    -0.03961928f, -0.03080721f, -0.01307202f, 0.02789641f, 0.05842200f, 0.05069622f, -0.04097212f, -0.03566081f, 
    -0.04053920f, -0.00703286f, -0.04512382f, -0.01091012f, -0.00197619f, -0.00154800f, -0.03426229f, -0.01853537f, 
    0.00593461f, 0.01787623f, 0.05392684f, 0.06286842f, 0.01812947f, -0.06914806f, -0.04422531f, 0.05717400f, 
    -0.07478070f, -0.06325833f, -0.06470954f, 0.04915409f, -0.06003552f, 0.05437378f, -0.02379163f, -0.07193836f, 
    -0.06788248f, -0.04686385f, 0.04662079f, -0.05007620f, 0.00284854f, -0.00321468f, -0.02009983f, -0.00060970f, 
    -0.03537665f, -0.04307967f, -0.01187033f, 0.04795995f, -0.07662340f, -0.01259576f, 0.01073043f, 0.01069763f, 
    -0.04570620f, 0.04343158f, 0.05326416f, 0.04187042f, -0.02448305f, -0.02534857f, -0.02881586f, -0.01506016f, 
    -0.35887218f, -0.10162916f, 0.04503192f, 0.06019647f, 0.03728136f, 0.04006354f, -0.05276916f, 0.07082557f, 
    -0.01784429f, 0.04578096f, 0.03512403f, 0.17167568f, 0.22415431f, -0.05341443f, 0.06346490f, -0.15758266f, 
    -0.06160519f, 0.00498958f, 0.08917490f, -0.19441646f, -0.00045188f, -0.11211997f, 0.05447679f, 0.11032911f, 
    -0.19607237f, 0.22511388f, 0.02938887f, 0.01931096f, 0.23959942f, 0.00520388f, -0.10799479f, -0.16025831f, 
    -0.00068698f, 0.07937565f, -0.00033589f, 0.07137883f, -0.04383792f, -0.03455741f, -0.14422177f, -0.05988288f, 
    0.12231807f, 0.18322517f, 0.00911579f, 0.06636623f, -0.05181050f, 0.06104347f, 0.00598323f, -0.08887430f, 
    0.02238555f, -0.14924942f, 0.10671219f, 0.05571334f, -0.19947876f, -0.10811818f, 0.02542354f, -0.08129483f, 
    0.03547572f, -0.01221600f, -0.03063568f, 0.00876578f, -0.19363958f, 0.00968230f, 0.16146047f, -0.24237391f, 
    -0.10399961f, 0.12042894f, 0.00321864f, -0.03127916f, -0.08457884f, 0.12510997f, -0.01683948f, 0.04878564f, 
    0.25619978f, -0.29033315f, 0.11917877f, -0.00534172f, 0.09735560f, -0.14945661f, 0.10851667f, -0.06950630f, 
    0.13165136f, 0.06898660f, -0.04350290f, 0.00215548f, 0.34420183f, -0.16383247f, 0.11914472f, 0.02152440f, 
    -0.17742641f, 0.11526781f, 0.06313346f, 0.03759259f, 0.04451719f, 0.04404120f, 0.04908795f, 0.02632265f, 
    0.14444406f, 0.21029286f, -0.07062143f, 0.05296471f, 0.09658837f, -0.02072681f, 0.11433691f, -0.12134708f, 
    0.06846195f, 0.07598564f, 0.07307690f, -0.02911204f, 0.08363897f, -0.01643746f, -0.08454987f, 0.15847820f, 
    -0.04394925f, -0.06752104f, -0.00390638f, -0.06290609f, -0.02074862f, 0.08929493f, -0.01359555f, -0.12549391f, 
    0.14198366f, 0.06604765f, -0.13086911f, -0.05653814f, 0.00169986f, -0.06306593f, -0.02084629f, 0.11419339f, 
    -0.02094670f, 0.09117208f, 0.04586484f, 0.04949633f, -0.02093472f, 0.35523325f, -0.09726557f, -0.02571171f, 
    0.04586488f, 0.00804101f, 0.01260477f, -0.08600603f, -0.05466539f, -0.00483281f, 0.06050206f, 0.00682265f, 
    -0.07645352f, 0.02038863f, 0.01859620f, -0.07454035f, -0.03360218f, -0.02453342f, 0.04059152f, 0.05875107f, 
    0.02834753f, -0.05723689f, 0.18326369f, -0.00288088f, 0.03374095f, 0.10693865f, 0.01062959f, 0.11220425f, 
    0.22583309f, -0.13909529f, 0.02427602f, -0.00357202f, -0.14391617f, -0.12229556f, -0.08358329f, -0.02594978f, 
    0.23525791f, -0.00255130f, 0.16305286f, -0.17324778f, 0.08596289f, 0.11766327f, 0.05545752f, 0.04201638f, 
    -0.10745502f, 0.09023765f, 0.12275097f, 0.11497913f, -0.29399171f, 0.05401636f, -0.18372688f, 0.13179925f, 
    0.20742169f, -0.05065717f, -0.03900233f, 0.09393068f, -0.09239488f, 0.06543311f, 0.04730079f, 0.08642840f, 
    -0.24284208f, -0.02757649f, -0.06106273f, 0.00172847f, -0.01090354f, -0.09411190f, 0.04403140f, -0.13574934f, 
    0.03652479f, 0.02702645f, 0.06654058f, -0.05406469f, 0.22775267f, 0.17146288f, 0.12901837f, 0.22336507f, 
    0.09139921f, 0.21095297f, 0.09150104f, 0.05206033f, -0.03413473f, 0.11415105f, -0.10087741f, -0.08044347f, 
    -0.05704178f, -0.27688539f, 0.00881828f, -0.00682414f, -0.17212835f, -0.02246020f, -0.07992278f, -0.02161061f, 
    0.07860017f, 0.01455811f, 0.07017164f, 0.17751430f, 0.20598103f, 0.09967855f, 0.19295026f, 0.20513837f, 
    -0.04422478f, -0.03701677f, 0.07084048f, -0.04936245f, -0.19454814f, -0.05672902f, -0.07415776f, -0.05839246f, 
    -0.39812014f, 0.11485533f, -0.10173577f, -0.26375017f, 0.02320051f, -0.10148487f, -0.11108125f, 0.05007312f, 
    0.01207818f, -0.01690526f, -0.08654495f, -0.02919727f, -0.38320431f, -0.15054698f, -0.28512251f, 0.05401120f, 
    0.03586525f, -0.10134261f, -0.10282005f, -0.03343507f, 0.13099049f, -0.06176896f, -0.07296967f, 0.04898618f, 
    0.21301940f, 0.09020263f, -0.08427079f, 0.04895143f, 0.05782732f, 0.19835535f, 0.02446928f, 0.05127499f, 
    -0.04996772f, 0.09372673f, 0.03380835f, -0.01472584f, 0.00838784f, 0.06310757f, -0.03459835f, -0.05545136f, 
    0.04717735f, -0.04554937f, 0.11693797f, -0.09355606f, -0.09631147f, 0.03779308f, -0.00446820f, 0.04063866f, 
    0.27185497f, 0.32210422f, 0.05118658f, 0.13014066f, 0.13100877f, -0.03077383f, -0.06729576f, 0.11685561f, 
    -0.06664311f, -0.07298458f, -0.13241847f, -0.12298213f, -0.45543092f, 0.26744211f, -0.00065705f, -0.08052772f, 
    0.24972646f, 0.10104875f, 0.11362965f, 0.01500193f, 0.04455298f, -0.01268280f, -0.06330611f, 0.10352601f, 
    0.18677221f, 0.10155784f, 0.02636176f, 0.18484044f, 0.06461639f, 0.16529863f, 0.09805283f, -0.07542615f, 
    -0.04485597f, 0.01515059f, 0.02059626f, 0.00990560f, 0.41652611f, 0.02641889f, 0.18437590f, 0.24442561f, 
    0.23800167f, 0.17251398f, 0.05580095f, 0.13418998f, 0.05869026f, 0.00950440f, -0.00365246f, -0.04913729f, 
    -0.32825744f, -0.02110588f, -0.09865469f, -0.14331487f, 0.06830513f, -0.01326925f, -0.04884398f, 0.08856834f, 
    0.03897983f, 0.01618647f, 0.01400008f, -0.07465197f, -0.28427312f, 0.01179601f, -0.04041775f, 0.20732714f, 
    -0.06024051f, -0.15181144f, -0.04038864f, -0.00407538f, -0.04974421f, -0.00156182f, -0.04613689f, -0.02376305f, 
    -0.05633471f, 0.24400273f, 0.18550637f, -0.10914223f, -0.07568093f, 0.02026453f, -0.04467312f, 0.00176507f, 
    -0.08269116f, 0.05137185f, 0.16040011f, -0.06959611f, 0.03210178f, 0.02523221f, 0.05770571f, 0.13232310f, 
    0.04059258f, -0.10087521f, -0.04413018f, -0.00856648f, 0.01131841f, -0.02256614f, 0.00987155f, 0.05050233f, 
    0.19607870f, 0.01249163f, -0.15618053f, 0.04533547f, 0.01595178f, -0.08132607f, -0.14342354f, -0.09734391f, 
    0.00545139f, -0.00073288f, 0.17295754f, 0.07459565f, 0.00852982f, 0.15148164f, 0.17463493f, 0.20872079f, 
    0.04260493f, -0.02525447f, 0.01349528f, 0.15562116f, -0.02260322f, 0.21799193f, 0.03459315f, -0.10197769f, 
    0.17113709f, -0.08948047f, -0.06304435f, -0.05946089f, -0.00544588f, -0.07859910f, 0.00587220f, 0.21071313f, 
    -0.10526286f, 0.05305231f, 0.09548990f, 0.04116875f, 0.17088334f, -0.28462681f, 0.24387766f, -0.03944227f, 
    0.01973569f, -0.10032839f, 0.02547444f, 0.01511585f, 0.04214243f, -0.03498951f, 0.02410579f, 0.13988711f, 
    -0.27671680f, -0.03310912f, 0.04543052f, -0.04674025f, 0.26732948f, 0.10223029f, -0.20693527f, -0.05213673f, 
    0.23502204f, 0.08031073f, 0.04884030f, 0.05338788f, -0.15617929f, 0.13602468f, -0.29470149f, -0.06887269f, 
    0.10451931f, 0.04558715f, -0.07482395f, 0.01933591f, 0.06364395f, 0.00201551f, -0.12106577f, 0.00534249f, 
    0.30410764f, -0.02282069f, 0.23279843f, 0.08748412f, -0.06869955f, -0.03408333f, -0.02724880f, 0.05698756f, 
    0.01050666f, 0.11441837f, 0.01812694f, 0.13974577f, -0.06327168f, -0.14579143f, -0.06901801f, 0.18248308f, 
    -0.08146304f, 0.07293817f, -0.02369917f, 0.03465642f, -0.05543997f, -0.03173149f, 0.04171328f, -0.04543494f, 
    0.10334919f, -0.10570574f, 0.02524792f, 0.07963120f, -0.02688993f, -0.02998070f, -0.06991667f, -0.00121154f, 
    -0.02030245f, -0.09336979f, -0.27249047f, -0.00522119f, -0.29987583f, 0.10012504f, 0.10967876f, -0.06554880f, 
    0.15400563f, 0.10512880f, 0.16156484f, 0.14845434f, 0.01926329f, -0.02149248f, -0.09472548f, 0.03324240f, 
    0.17602745f, -0.01080918f, 0.13950609f, 0.22577637f, 0.09874438f, -0.01192267f, 0.13983230f, -0.04492692f, 
    -0.06118371f, -0.09716353f, -0.04355583f, -0.04321709f, 0.42026132f, 0.13267104f, 0.20839489f, 0.13938278f, 
    0.07831428f, 0.07258297f, 0.13647577f, 0.08347627f, -0.09532844f, -0.07514060f, 0.00650368f, -0.04469639f, 
    0.01677075f, -0.01420706f, -0.20669544f, -0.12432365f, 0.08296435f, 0.06397296f, -0.01116654f, -0.02642219f, 
    -0.10991693f, -0.12836042f, -0.02586967f, 0.04967070f, 0.04909756f, -0.10079698f, 0.00885464f, -0.14779982f, 
    -0.08656927f, -0.04322914f, -0.16007163f, -0.03513264f, 0.18666127f, -0.06105391f, 0.12551121f, 0.23952590f, 
    -0.26573199f, -0.10616834f, 0.02378600f, -0.13298154f, -0.01323758f, -0.14014679f, 0.02729310f, 0.03568834f, 
    -0.01289133f, -0.02120130f, -0.06071283f, -0.07676127f, 0.24447989f, -0.03387820f, -0.11618583f, -0.04382012f, 
    0.06419943f, 0.14067183f, -0.16050296f, -0.06773049f, 0.07340174f, 0.06021976f, -0.08608735f, 0.00130742f, 
    0.23735240f, 0.16169684f, -0.00247290f, 0.26399413f, 0.08374842f, 0.02131658f, -0.02430491f, -0.14527129f, 
    -0.03428200f, -0.08364904f, 0.11770386f, 0.05001408f, -0.28832901f, -0.06237188f, 0.00163102f, 0.20805888f, 
    0.00377639f, 0.01861553f, -0.09733003f, 0.06724585f, -0.10030343f, 0.07993945f, 0.10846239f, -0.05593283f, 
    0.46615577f, -0.14503983f, 0.06332798f, 0.30473959f, -0.06243462f, -0.00499800f, -0.11470531f, -0.10061190f, 
    -0.04025859f, 0.07571955f, 0.12194084f, -0.01326791f, 0.25371549f, -0.50066853f, 0.08757581f, -0.14266780f, 
    -0.10616747f, -0.02560463f, -0.09593112f, 0.08648171f, 0.09665176f, 0.01500719f, 0.21146898f, 0.04555143f, 
    0.05630717f, 0.13173243f, 0.09009309f, 0.00829179f, 0.22049777f, 0.15501200f, -0.04468867f, -0.02093624f, 
    0.08407266f, -0.06642272f, -0.01659312f, -0.04458800f, -0.08259688f, 0.19031127f, -0.05502494f, -0.12863274f, 
    0.15865971f, -0.03264240f, 0.00748651f, -0.06665478f, 0.10246836f, -0.01310838f, 0.05892005f, 0.08557961f, 
    -0.26867446f, -0.05640484f, 0.05010683f, -0.27463984f, 0.08154631f, -0.07543170f, 0.02565663f, 0.09240432f, 
    -0.05370035f, 0.17820941f, 0.08950832f, 0.13995352f, -0.19886748f, -0.12141188f, -0.09556764f, 0.11616831f, 
    0.02802363f, -0.08418306f, 0.06696156f, -0.07298076f, -0.05453337f, -0.02471050f, 0.00099193f, -0.01725579f, 
    -0.15988347f, -0.13317181f, -0.06403210f, -0.13193090f, -0.01561027f, -0.03021627f, 0.09217086f, 0.11400672f, 
    -0.02210339f, 0.01242232f, 0.04770638f, 0.07522541f, -0.34262890f, -0.24317904f, 0.08584426f, 0.06396852f, 
    0.06487466f, 0.16713858f, 0.07159895f, -0.09702466f, -0.00649057f, -0.03037004f, -0.03395841f, 0.02040630f, 
    -0.21171641f, -0.15971816f, 0.08526783f, -0.01336064f, -0.05770789f, -0.07653200f, -0.13528813f, -0.22626783f, 
    0.03553379f, 0.11652749f, 0.04676874f, 0.00593130f, -0.08432764f, -0.19821170f, -0.03971379f, -0.01136886f, 
    0.00549965f, 0.01080519f, -0.05071595f, -0.05104483f, 0.06528094f, -0.09457194f, 0.10936288f, 0.13474981f, 
    0.05459133f, 0.28606063f, 0.11052332f, -0.07500629f, 0.21915659f, 0.09440455f, 0.02660821f, -0.06368401f, 
    -0.02898186f, 0.12021707f, -0.04109795f, 0.04091815f, 0.20746759f, -0.08397426f, 0.26367301f, -0.07944650f, 
    0.03310376f, -0.00199579f, -0.19657700f, -0.00298666f, 0.11858685f, 0.08098909f, 0.01261570f, 0.04166647f, 
    -0.22207277f, 0.02613090f, -0.08881578f, -0.30986339f, 0.14456366f, 0.08165145f, -0.08837371f, -0.01716186f, 
    0.10701901f, 0.10565848f, 0.09514177f, 0.11450601f, 0.33196455f, 0.08315399f, 0.02813954f, -0.11125539f, 
    -0.03395505f, 0.12880452f, 0.02467795f, -0.09750815f, 0.04594025f, 0.01022375f, 0.01815977f, 0.02447203f, 
    -0.16368821f, 0.03295333f, 0.01522262f, -0.01138206f, 0.10596538f, -0.04173155f, -0.07123896f, -0.00601024f, 
    0.01827331f, 0.08047531f, 0.08229136f, -0.02267666f, -0.27413243f, -0.18824100f, -0.10711150f, -0.05984092f, 
    -0.16071729f, -0.14422344f, 0.01973089f, 0.13502871f, -0.07721694f, 0.08451068f, 0.17046301f, 0.05980917f, 
    -0.30797899f, 0.00978734f, -0.08375398f, -0.10424991f, 0.01234659f, 0.07376255f, 0.13303828f, 0.21242836f, 
    -0.01603504f, 0.07280856f, -0.07231171f, 0.12989680f, 0.03363140f, 0.19772217f, 0.09991063f, 0.05005217f, 
    -0.00720346f, 0.01473017f, 0.08469190f, -0.01643360f, 0.04425927f, -0.05856663f, 0.14288327f, 0.22004755f, 
    -0.23059782f, -0.04888278f, -0.05520396f, -0.12763527f, 0.08906134f, 0.00258892f, 0.03137317f, 0.09443679f, 
    0.11968427f, 0.04308420f, 0.07208385f, 0.10637348f, -0.28591567f, -0.09476246f, -0.21053104f, -0.09463053f, 
    0.01404072f, 0.06313811f, -0.03240473f, -0.02493315f, 0.10381248f, 0.03982028f, 0.02494700f, 0.13476962f, 
    0.29251871f, -0.02435626f, -0.01602213f, -0.00939349f, -0.05258169f, 0.03700798f, 0.01720587f, -0.02587790f, 
    0.05394537f, -0.10190543f, 0.07130630f, 0.05524453f, -0.12109385f, -0.14637686f, -0.18195596f, 0.14021997f, 
    -0.01973255f, -0.14921235f, -0.00865591f, 0.03260760f, -0.06489833f, 0.12621503f, 0.05888043f, 0.04352301f, 
    0.28972101f, 0.06225815f, -0.01323378f, -0.12281959f, 0.02915052f, 0.12052658f, -0.11116388f, 0.11636610f, 
    0.16261737f, -0.04604549f, 0.02835200f, 0.03694835f, 0.21315959f, 0.23133366f, -0.06006997f, -0.08217225f, 
    -0.12929045f, 0.03951538f, -0.01827229f, 0.12918241f, 0.04590800f, -0.01101389f, 0.07843129f, -0.01040616f, 
    0.14033245f, -0.08310189f, -0.11059574f, 0.04972946f, -0.16939424f, -0.10790738f, 0.09199157f, 0.04756496f, 
    -0.03291726f, 0.04870820f, -0.07109480f, 0.03229821f, 0.13654219f, -0.04354905f, -0.07204050f, -0.13834812f, 
    -0.01569880f, -0.00723039f, 0.14898017f, -0.13139175f, 0.10384979f, 0.02565106f, 0.05350285f, -0.06916326f, 
    -0.36038187f, 0.06159723f, -0.26332477f, -0.17985332f, 0.20300433f, 0.04877014f, 0.03107257f, 0.05753046f, 
    -0.01448761f, -0.06740310f, 0.00540933f, 0.05053127f, -0.26937088f, 0.12747961f, 0.10271008f, 0.08083585f, 
    0.01440454f, 0.08749945f, 0.02154118f, 0.03303909f, -0.02733550f, 0.05156252f, 0.14583057f, 0.03336849f, 
    -0.16334659f, 0.56630641f, 0.16535898f, 0.09696045f, 0.01961515f, 0.07493289f, 0.09081456f, 0.07203238f, 
    0.00001338f, -0.05469006f, 0.01551140f, -0.01772889f, -0.05495757f, -0.15201826f, 0.10610116f, 0.18336108f, 
    0.04678660f, 0.04296173f, 0.06029925f, 0.06338695f, -0.02772688f, 0.10059734f, 0.06955442f, 0.03014647f, 
    -0.38714260f, -0.05768787f, -0.19162489f, -0.04935097f, -0.03817202f, 0.04114478f, -0.07116365f, 0.02044889f, 
    0.01856029f, 0.09695353f, 0.03477976f, -0.08331796f, 0.06684028f, -0.02621013f, 0.10928408f, 0.30331650f, 
    0.21425505f, 0.13594800f, 0.11276539f, 0.07529626f, 0.06832384f, 0.08553118f, -0.11379120f, 0.03231715f, 
    0.17074832f, -0.13776566f, -0.14671665f, -0.09325469f, -0.16094187f, -0.05433745f, 0.04591901f, -0.09515654f, 
    0.04594167f, 0.04561793f, -0.11006673f, 0.17534934f, 0.21413177f, 0.02662786f, 0.15285598f, 0.02892732f, 
    0.07047984f, 0.01951319f, 0.20501406f, -0.14698829f, -0.20830943f, -0.03746456f, -0.06839235f, -0.00338329f, 
    -0.41111547f, 0.21575491f, -0.21225798f, -0.18244831f, -0.08242038f, -0.07879089f, -0.09012439f, 0.07051666f, 
    0.15008482f, -0.01548345f, 0.10753366f, -0.03286576f, -0.16759680f, -0.29651520f, -0.26264036f, -0.07682170f, 
    -0.05045709f, -0.08934767f, -0.24638359f, -0.09442175f, -0.12779295f, -0.02829328f, -0.09461079f, 0.01542334f, 
    0.23953560f, -0.12175970f, 0.11726950f, 0.10402775f, 0.01197077f, 0.11253020f, 0.00491030f, 0.25219199f, 
    -0.06761321f, 0.05892719f, -0.14247820f, 0.00479283f, -0.08504146f, -0.07438985f, 0.01170760f, -0.11386684f, 
    -0.01926791f, 0.04219171f, -0.04935398f, -0.01539877f, 0.09521699f, 0.00408631f, -0.10232034f, -0.04836320f, 
    0.23517120f, 0.28157124f, 0.17904273f, 0.19281171f, 0.13265003f, -0.13671492f, -0.07442711f, 0.06579345f, 
    -0.12649655f, 0.13324185f, -0.13535161f, -0.13706023f, -0.20867909f, 0.36335689f, 0.07589133f, -0.13976255f, 
    0.22268566f, 0.01463441f, 0.08751219f, 0.18231586f, -0.00737939f, 0.14573832f, 0.01496961f, -0.01116744f, 
    0.03803461f, 0.17910890f, 0.13536064f, 0.26386288f, 0.02382758f, 0.09959380f, -0.03413500f, 0.09950915f, 
    -0.04979055f, -0.13322224f, -0.05561345f, 0.16580047f, 0.52337122f, 0.14103420f, 0.37208036f, 0.42074102f, 
    0.30859464f, 0.06586881f, 0.21476227f, 0.23869446f, 0.02847447f, 0.08380632f, 0.21729200f, 0.13721882f, 
    -0.35134137f, -0.07432892f, -0.13072363f, -0.10958156f, 0.03107249f, 0.00545742f, 0.02046939f, 0.02114514f, 
    0.03191794f, -0.01314547f, 0.06981935f, -0.09821017f, -0.47451442f, -0.16934058f, 0.02899088f, 0.15134285f, 
    -0.18643582f, 0.12873442f, 0.00449224f, 0.02620086f, 0.03160571f, 0.10245516f, 0.17362942f, 0.02937476f, 
    -0.11610902f, 0.13415119f, 0.16320208f, 0.00962300f, -0.03664586f, 0.07573166f, 0.01522828f, 0.00291143f, 
    -0.12432161f, -0.02798637f, -0.05048253f, -0.02729694f, -0.12206310f, -0.17834330f, 0.09821644f, 0.11180028f, 
    -0.06937321f, -0.02358751f, 0.10133251f, -0.13104805f, -0.06974442f, -0.03826749f, -0.01923539f, 0.00418271f, 
    0.06021001f, 0.21294923f, -0.07086752f, -0.00537031f, 0.08406474f, -0.10962043f, 0.01918641f, -0.12303356f, 
    0.09624690f, -0.00791718f, 0.13142540f, 0.04100814f, -0.33119339f, 0.10108469f, 0.17061694f, 0.25226149f, 
    0.01024869f, 0.17219973f, 0.09887819f, -0.02139481f, -0.05476391f, -0.04080813f, 0.16333389f, 0.05617625f, 
    0.06561119f, -0.14953579f, 0.03576772f, 0.16340029f, 0.02923281f, 0.00048055f, 0.10503440f, 0.07473744f, 
    -0.13386635f, -0.10096650f, -0.11798774f, -0.04549778f, 0.39415216f, -0.30156833f, 0.16643824f, 0.20565408f, 
    0.00369140f, -0.03861153f, 0.00601189f, -0.01723988f, 0.16743496f, 0.08537339f, 0.12363654f, -0.01491808f, 
    0.02989439f, -0.02897903f, -0.01823882f, -0.11051968f, 0.14226644f, 0.03679061f, 0.07007102f, -0.00259959f, 
    -0.03472009f, 0.01533316f, -0.07384825f, -0.05825194f, 0.00208891f, 0.12869871f, -0.17303680f, -0.24940395f, 
    0.03649731f, 0.06544355f, -0.00436139f, -0.12435920f, -0.01203688f, 0.13822626f, 0.11633663f, -0.06054350f, 
    -0.11981698f, 0.01274908f, 0.05047122f, -0.27909642f, 0.11344311f, 0.11527280f, 0.02601459f, 0.00468839f, 
    0.09225129f, 0.06969358f, 0.09073897f, -0.02900688f, -0.32207444f, -0.04859161f, 0.09395068f, -0.00477059f, 
    0.14421195f, -0.13522922f, -0.03571347f, 0.12249146f, -0.04370861f, 0.09818429f, 0.01311428f, -0.04843416f, 
    0.05489874f, -0.11632976f, -0.04845459f, 0.05013528f, -0.08685110f, 0.04796017f, -0.00323049f, -0.04259630f, 
    -0.02418354f, -0.05375089f, -0.06192880f, 0.03695190f, 0.20225054f, -0.11585271f, 0.09489954f, 0.13309051f, 
    -0.05382234f, 0.09387097f, -0.14618681f, -0.00952508f, -0.09215698f, -0.00297207f, -0.09208139f, 0.02022244f, 
    -0.16381148f, -0.02932508f, 0.21743523f, 0.00268528f, -0.03143644f, 0.09606108f, -0.04459796f, -0.10122923f, 
    -0.01321206f, 0.04201282f, 0.00692178f, -0.08360158f, 0.10302015f, 0.02486322f, -0.03260377f, 0.11765347f, 
    0.01053221f, 0.06488898f, 0.05580313f, -0.17209502f, 0.16997787f, -0.10695672f, -0.00218997f, -0.08520088f, 
    0.01680772f, 0.26159823f, 0.11587785f, -0.22034730f, 0.15788123f, 0.01712040f, -0.06763572f, -0.05107479f, 
    0.02204938f, -0.06720836f, -0.20076440f, 0.01453757f, 0.28684980f, 0.05460391f, 0.21722700f, -0.32996520f, 
    0.01880601f, 0.13110128f, -0.03716140f, -0.02586680f, 0.04314817f, 0.17747782f, 0.03734985f, -0.00750871f, 
    0.33674413f, -0.05637572f, -0.12373979f, -0.19505236f, -0.00078707f, 0.03609468f, -0.00709105f, 0.01847361f, 
    0.00918560f, 0.08822053f, 0.03318650f, 0.08667035f, 0.03875795f, 0.03199207f, 0.05689704f, 0.01755581f, 
    -0.04442310f, 0.03784785f, 0.03105894f, -0.10332945f, 0.09560862f, -0.04452202f, 0.00441932f, 0.03693286f, 
    0.29439938f, -0.08314814f, 0.05527917f, -0.06192456f, -0.21600051f, 0.01208088f, -0.03747042f, -0.05666257f, 
    -0.04087892f, -0.05754070f, -0.11233681f, -0.00860425f, 0.15742891f, 0.34928018f, 0.02583669f, -0.00258065f, 
    0.14150725f, 0.18330561f, 0.09988295f, 0.14611331f, 0.09276593f, -0.03355475f, 0.03122638f, 0.01651170f, 
    0.02441124f, -0.03024354f, 0.06803679f, -0.22317481f, -0.08217398f, -0.01816881f, -0.15855215f, 0.03225531f, 
    0.11356748f, 0.04110083f, 0.02250913f, 0.01922061f, -0.25049660f, 0.25972468f, 0.09827853f, 0.27269915f, 
    0.08391346f, -0.03332926f, -0.10197183f, -0.01536190f, 0.02374120f, 0.00262944f, -0.03867030f, 0.01670616f, 
    0.13565217f, 0.04428336f, -0.13488513f, -0.13171399f, 0.04500212f, 0.06135347f, 0.00052372f, 0.04165169f, 
    0.00647979f, 0.02297647f, -0.03205775f, -0.07490930f, 0.27515712f, -0.25725716f, -0.04703490f, 0.35098833f, 
    0.09101918f, -0.01430202f, 0.01794663f, -0.04112070f, 0.01890912f, -0.11943442f, -0.07643820f, -0.00617448f, 
    -0.50197262f, 0.19351950f, -0.23996998f, 0.01447073f, 0.12677322f, 0.11367417f, -0.05416011f, 0.05198748f, 
    -0.02565149f, -0.02182855f, 0.02895978f, -0.00206002f, -0.14930047f, 0.37091380f, 0.01477878f, -0.13383894f, 
    0.04189195f, 0.10678447f, 0.09029084f, -0.01386346f, -0.05047540f, 0.06586120f, -0.12414640f, 0.00456491f, 
    -0.26768294f, -0.10590549f, 0.14676222f, 0.14253867f, -0.02245270f, 0.01848928f, 0.02247108f, 0.00885436f, 
    -0.07354374f, -0.07339475f, 0.05972104f, 0.01552744f, 0.14973055f, 0.16041104f, 0.07737775f, -0.03108178f, 
    0.12367485f, -0.04562397f, 0.02883975f, -0.10894117f, 0.00339309f, -0.11064549f, 0.03241495f, 0.05679237f, 
    -0.33049518f, -0.03990072f, 0.12425368f, 0.00608289f, 0.15077816f, 0.01965006f, 0.06551149f, 0.04092697f, 
    0.13987057f, 0.04158014f, 0.07155194f, 0.02495008f, -0.16674374f, -0.25451261f, -0.00017211f, 0.08102492f, 
    0.03044452f, -0.01034439f, -0.03846037f, 0.10965033f, 0.09052424f, 0.04299625f, 0.02764815f, 0.11356813f, 
    0.10000550f, -0.12429985f, 0.09638563f, 0.36022037f, -0.19478583f, -0.13077176f, -0.01338572f, -0.09013554f, 
    0.10668012f, 0.16434459f, -0.02377100f, 0.16823225f, -0.05045515f, -0.03743299f, -0.04623947f, 0.24881211f, 
    -0.07512160f, -0.00791773f, 0.04494200f, -0.05976391f, -0.02971029f, -0.00806186f, -0.04874502f, -0.10075660f, 
    0.04821688f, -0.18976361f, -0.15478261f, 0.15203866f, 0.07561941f, -0.08236556f, -0.01680791f, 0.06992166f, 
    -0.01219544f, -0.04612518f, 0.02309174f, 0.13863726f, 0.06590852f, 0.17516789f, 0.06068414f, -0.16067721f, 
    -0.00513188f, -0.13505255f, 0.00892647f, -0.00093299f, 0.03715089f, -0.08082055f, -0.03554936f, 0.15484828f, 
    0.26508570f, 0.17919505f, 0.02676038f, -0.03035136f, -0.02240739f, -0.05135790f, -0.02933343f, 0.04740324f, 
    -0.07906682f, 0.05598730f, -0.00586644f, -0.02918811f, 0.08526284f, -0.06999557f, 0.05557842f, -0.02442782f, 
    0.04294429f, -0.06824031f, 0.02008347f, 0.12720451f, -0.03120066f, 0.10672130f, 0.00044697f, 0.03376152f, 
    0.15144722f, -0.26892382f, -0.10040831f, -0.10460609f, 0.02333463f, -0.03224930f, 0.02275840f, -0.02912324f, 
    -0.01058246f, -0.04283210f, 0.08902431f, -0.14446530f, -0.08872028f, 0.05485559f, -0.11646803f, -0.18224317f, 
    -0.13460858f, 0.03467911f, -0.01384092f, 0.02049934f, -0.03568669f, -0.02685658f, -0.00016447f, 0.16300581f, 
    0.01522704f, 0.01877497f, -0.06353762f, 0.03018204f, -0.05942388f, 0.02045029f, 0.00787498f, -0.00245059f, 
    -0.09644287f, 0.14024262f, 0.08929615f, -0.03914480f, 0.13034050f, 0.12395500f, 0.02242782f, 0.07378051f, 
    -0.06487423f, 0.05183060f, 0.01528582f, -0.03003297f, 0.14143428f, 0.06938496f, 0.04260078f, -0.00213316f, 
    0.10076667f, 0.16240577f, 0.00658394f, 0.27728364f, -0.03657307f, 0.08359981f, 0.03283577f, -0.14637181f, 
    -0.00168088f, -0.12193964f, 0.03348960f, 0.01666872f, -0.12159047f, -0.12488270f, -0.00027375f, 0.10142387f, 
    0.10217963f, 0.00081637f, -0.03632252f, -0.05275840f, 0.09697763f, 0.01699925f, 0.03960030f, 0.07189480f, 
    -0.22258331f, -0.04009323f, 0.00575054f, -0.28755242f, 0.09781864f, 0.06739267f, -0.11742548f, 0.09558433f, 
    0.09134810f, 0.00669171f, 0.03571953f, 0.07697450f, 0.24509571f, -0.19171409f, 0.12934662f, -0.09401232f, 
    -0.09527992f, -0.02642200f, 0.04759531f, 0.04685238f, -0.01044696f, -0.06947605f, 0.01957662f, 0.09551793f, 
    0.05674059f, -0.19512419f, 0.06030640f, 0.08899920f, 0.15039921f, 0.02674179f, 0.12251237f, 0.02739131f, 
    0.11000785f, -0.03339269f, -0.22231492f, 0.00614463f, -0.22441947f, -0.16962878f, 0.12615716f, -0.09806508f, 
    -0.06998957f, -0.05360719f, -0.00765939f, 0.10781039f, -0.01649329f, -0.04571461f, 0.05957385f, -0.03667946f, 
    0.10866601f, -0.07136988f, 0.04470917f, 0.16656685f, -0.06612653f, 0.02320962f, 0.00385304f, -0.00592701f, 
    -0.00518233f, 0.03368353f, -0.03526924f, -0.07396882f, 0.15513685f, 0.04346487f, -0.11440185f, -0.05678799f, 
    -0.18485308f, 0.01193385f, 0.06437071f, 0.07380547f, 0.05956139f, 0.00212197f, 0.10367692f, 0.09367152f, 
    -0.16233969f, 0.03707916f, -0.02814033f, 0.16407058f, -0.03075021f, -0.12559673f, 0.01615827f, -0.03409314f, 
    0.02124484f, -0.09000961f, -0.14236933f, -0.03888794f, 0.24033415f, 0.02383787f, 0.11708437f, -0.18014301f, 
    -0.04377544f, 0.01913886f, 0.09563231f, 0.06989907f, -0.02339093f, 0.02641631f, -0.03503000f, -0.03687208f, 
    -0.30738196f, 0.31443405f, 0.01835975f, 0.09201680f, 0.03466985f, -0.04003277f, -0.00553473f, -0.02014039f, 
    -0.06728241f, -0.00177325f, -0.01289771f, 0.07244594f, -0.17113109f, -0.18327922f, 0.07546847f, 0.08252247f, 
    0.09415860f, 0.18863964f, 0.05075166f, 0.04333455f, -0.14589027f, -0.00331096f, 0.10402854f, 0.11022901f, 
    0.12760924f, -0.07792050f, 0.18657072f, 0.25337803f, -0.02801982f, -0.04097368f, 0.05073462f, -0.13274291f, 
    -0.05933182f, 0.01380025f, -0.03534802f, 0.03632208f, 0.22996192f, -0.31439441f, 0.22511631f, -0.00633379f, 
    0.13346295f, -0.16094041f, -0.01330249f, 0.06520405f, -0.11367478f, 0.08514325f, -0.12058872f, -0.09917643f, 
    -0.14676149f, 0.07958791f, 0.04711732f, -0.02830019f, -0.08647919f, -0.09304144f, 0.11781512f, -0.04889989f, 
    0.14635122f, -0.10602099f, -0.11464529f, -0.06512775f, 0.03271360f, 0.13820961f, 0.18539226f, -0.30103689f, 
    -0.19010220f, -0.04585226f, 0.04612800f, -0.08521940f, -0.03341693f, 0.01646407f, 0.20024502f, 0.02139998f, 
    -0.02702133f, -0.11290408f, -0.08204231f, -0.16383447f, 0.15483533f, 0.02932934f, 0.20188387f, 0.03493148f, 
    -0.07491013f, -0.02769330f, -0.05401604f, 0.10824987f, -0.07876526f, -0.07935477f, -0.08431953f, -0.06625188f, 
    -0.04884173f, -0.00996197f, 0.14013572f, -0.01121143f, -0.12422782f, -0.04386432f, 0.03185936f, -0.07064714f, 
    0.04208456f, 0.12394267f, -0.00212841f, 0.14434363f, 0.07805458f, 0.12819390f, 0.13780323f, -0.09551656f, 
    0.00193893f, -0.00289656f, -0.04137082f, -0.02007348f, -0.00054787f, -0.05750014f, 0.03760727f, 0.11618913f, 
    -0.03002571f, -0.06261088f, -0.05074692f, -0.00614260f, -0.00177961f, 0.12268147f, 0.06071014f, -0.01647357f, 
    -0.33868027f, 0.12651981f, -0.05933645f, -0.17085241f, -0.08310395f, 0.00242795f, 0.09481345f, 0.03139820f, 
    0.04094173f, 0.07364824f, 0.09255396f, -0.13458024f, 0.01062379f, 0.01522417f, 0.05336539f, 0.30461225f, 
    0.13186987f, 0.08405159f, 0.13099039f, -0.00259958f, 0.03448160f, 0.02427591f, 0.10679016f, -0.06940512f, 
    -0.12552433f, 0.42883551f, 0.11767029f, -0.15333146f, 0.03511933f, -0.05689530f, -0.03163323f, -0.00409912f, 
    0.14440209f, -0.04766574f, -0.07822350f, -0.00277320f, 0.05099939f, 0.06194679f, 0.18393254f, -0.14503555f, 
    0.07491107f, -0.00885105f, -0.05820014f, 0.10377194f, 0.06822445f, 0.05963034f, -0.02623293f, 0.05952705f, 
    0.09046132f, -0.19409910f, 0.17004831f, -0.21766239f, -0.11900298f, -0.01358255f, 0.05780034f, -0.03551490f, 
    -0.01761910f, 0.04692052f, 0.07350139f, 0.06834092f, -0.13291493f, 0.03224215f, 0.01482029f, 0.11359062f, 
    -0.07860328f, -0.07770935f, 0.03259667f, 0.02648669f, -0.04356322f, -0.07263033f, -0.12429080f, -0.08353689f, 
    -0.06837469f, 0.00845766f, -0.05441851f, -0.03199343f, -0.07309734f, -0.07319410f, -0.02861843f, -0.05485644f, 
    0.04542716f, -0.04634948f, 0.06201949f, -0.04101900f, -0.01221864f, 0.05262500f, 0.04253355f, 0.03090457f, 
    0.05920921f, -0.04803244f, -0.02852726f, -0.02709522f, -0.06754004f, 0.05027910f, -0.04554320f, -0.06938782f, 
    -0.01627017f, 0.03172940f, -0.05230735f, -0.01250595f, -0.03248641f, -0.03301036f, -0.00740451f, 0.01966644f, 
    -0.03577059f, -0.00683198f, -0.07179072f, 0.06054637f, -0.03542752f, -0.00501826f, 0.04742201f, -0.05339747f, 
    -0.04884760f, -0.06327365f, -0.00587696f, -0.01266276f, 0.04103232f, -0.05912615f, 0.03456858f, -0.05001606f, 
    0.03714740f, 0.02067192f, -0.01347966f, -0.05326061f, -0.02224554f, -0.07307982f, -0.04293206f, -0.05398885f, 
    -0.01084812f, -0.03538610f, 0.00311486f, -0.01240593f, 0.01557497f, -0.06682039f, 0.00493080f, -0.04887776f, 
    0.01850179f, 0.03806379f, -0.05581941f, 0.00880563f, 0.02393174f, -0.05588986f, 0.05267458f, 0.04950235f, 
    -0.03705541f, -0.02586587f, 0.02897045f, 0.06120196f, -0.01033704f, -0.02955908f, 0.05294319f, -0.07423142f, 
    -0.06120539f, -0.03992437f, 0.02674924f, 0.05945785f, 0.02142104f, -0.00314623f, -0.04701366f, -0.05917815f, 
    -0.05527797f, -0.01256339f, -0.01066850f, 0.00887565f, 0.05305573f, 0.04411497f, -0.02235399f, -0.01899882f, 
    0.07960452f, -0.03587233f, -0.02765744f, 0.04922837f, -0.05530795f, -0.03761880f, -0.06062847f, -0.02877156f, 
    0.00406673f, 0.06148035f, 0.06106019f, 0.05387202f, -0.07717563f, 0.01763294f, -0.06604894f, 0.01535298f, 
    -0.05228793f, 0.06192434f, 0.04935776f, -0.05911100f, 0.05657299f, 0.05967839f, -0.01661873f, 0.03501154f, 
    -0.07558056f, 0.03560759f, -0.01783969f, 0.03929571f, -0.06322496f, 0.05566449f, 0.04711793f, -0.07054552f, 
    -0.05050840f, -0.00632759f, 0.00886592f, 0.04933957f, -0.01545888f, 0.01172661f, -0.06661974f, 0.05113095f, 
    -0.04556351f, 0.03759906f, -0.02734351f, 0.03949454f, 0.01334013f, 0.01044595f, 0.04774847f, -0.03175453f, 
    -0.04811408f, 0.04655627f, 0.05519377f, -0.04472229f, 0.05399223f, -0.04348982f, 0.03512985f, -0.02860360f, 
    0.01521820f, -0.07291040f, 0.03130077f, 0.06101488f, -0.07467666f, -0.01233010f, -0.02799084f, -0.07327870f, 
    -0.02408352f, -0.04955280f, -0.03476639f, -0.00962914f, -0.05101124f, -0.05403174f, 0.01998416f, 0.01243339f, 
    -0.07273631f, 0.04358594f, 0.04844856f, 0.01640495f, 0.03871473f, 0.05154210f, -0.02344835f, -0.03827144f, 
    -0.01189090f, -0.01365714f, -0.02566116f, 0.00068627f, 0.05837317f, -0.00807979f, -0.05352604f, -0.00723063f, 
    0.04240411f, 0.04762724f, -0.07533402f, -0.02466379f, -0.06814195f, 0.02824366f, -0.07737485f, -0.03950977f, 
    -0.08038786f, -0.24055207f, -0.19376981f, 0.00930175f, 0.19501479f, -0.07117378f, 0.06700181f, -0.08907464f, 
    0.01907615f, 0.08000899f, 0.07439642f, -0.05533243f, -0.02524875f, 0.03073801f, -0.16453533f, 0.21996216f, 
    -0.08806958f, 0.09690837f, 0.01030282f, -0.01563225f, -0.16899429f, 0.04426323f, -0.01670147f, -0.07679364f, 
    -0.09150521f, -0.19573146f, -0.04277219f, -0.00296348f, 0.07203229f, 0.07147737f, 0.01379340f, 0.10775955f, 
    0.00829686f, 0.06831557f, 0.07806053f, 0.13576469f, 0.33607909f, -0.00984210f, 0.01032380f, 0.25531536f, 
    0.05744880f, 0.03136597f, -0.07269848f, -0.04601811f, 0.06253061f, 0.14978646f, -0.01203220f, 0.04223776f, 
    0.08097947f, 0.07320994f, 0.09584421f, -0.19305238f, 0.09233182f, -0.06798045f, 0.09916864f, 0.10305828f, 
    0.08572336f, 0.06939912f, -0.05138789f, -0.08094045f, -0.34231469f, 0.20912381f, -0.19080101f, -0.28711283f, 
    0.24870557f, 0.09970785f, 0.11924981f, -0.16682272f, 0.05483264f, -0.01669005f, 0.13550451f, 0.15284282f, 
    0.15627083f, -0.09830005f, 0.06380636f, -0.20176308f, 0.01041572f, 0.08587479f, -0.05370493f, 0.00470816f, 
    0.04250924f, 0.06361488f, 0.07473327f, 0.01057020f, 0.02381108f, -0.12782601f, -0.03444297f, 0.02356637f, 
    -0.10584716f, -0.04942046f, -0.03251998f, 0.14013830f, -0.04104263f, -0.01359064f, -0.02429933f, -0.00357291f, 
    0.15548752f, 0.19364545f, 0.04011388f, 0.19382395f, -0.00844493f, -0.06425671f, -0.05461522f, -0.02302232f, 
    0.08696838f, -0.06937406f, 0.07277170f, -0.01519215f, 0.01507831f, 0.01357459f, 0.07952323f, 0.05514765f, 
    -0.02447837f, 0.08925533f, -0.05606220f, 0.05508590f, -0.00418592f, -0.01830604f, -0.07170326f, 0.00976022f, 
    0.02635044f, -0.18529692f, 0.07000639f, 0.03446323f, -0.17217906f, -0.03278900f, -0.21874830f, -0.16630466f, 
    -0.00719592f, 0.05461344f, -0.03361768f, -0.02451364f, 0.09164536f, -0.06107042f, 0.01002379f, 0.07691105f, 
    -0.10224016f, -0.06112212f, -0.03554209f, -0.17328736f, 0.14601386f, -0.07425956f, -0.12260922f, -0.06105137f, 
    -0.29957873f, -0.14754297f, -0.03962417f, -0.17074314f, 0.25173426f, 0.00538370f, 0.00069850f, -0.06616032f, 
    0.02809586f, 0.01065002f, -0.03930404f, 0.09155344f, 0.11068361f, 0.02582198f, -0.00312340f, -0.09184396f, 
    0.15837269f, 0.09029838f, -0.10132416f, -0.01833644f, 0.03712344f, 0.08599336f, 0.15042061f, -0.02270911f, 
    0.30213913f, 0.44502488f, 0.00780108f, 0.17658195f, 0.07174996f, 0.10922084f, 0.05726904f, -0.02041177f, 
    0.00330131f, -0.00833624f, 0.13251983f, 0.03789367f, 0.02732019f, 0.11360482f, 0.07172184f, 0.18353960f, 
    0.20643519f, -0.08288018f, 0.05316563f, 0.04899234f, 0.10210444f, -0.13237078f, -0.02340616f, -0.04119107f, 
    -0.05893551f, 0.02747480f, -0.07190599f, 0.02509173f, -0.05899761f, 0.05058701f, -0.01256770f, 0.00465086f, 
    0.03094858f, -0.00539731f, -0.06961014f, -0.02288606f, -0.01360842f, 0.02371540f, 0.03437284f, 0.04115788f, 
    -0.07249059f, -0.04351678f, 0.04801801f, 0.01243585f, -0.06828268f, -0.04547713f, 0.02915655f, -0.03012752f, 
    0.05096851f, -0.03650917f, 0.02231462f, -0.05148373f, -0.00714757f, 0.01576432f, -0.01580128f, 0.03655026f, 
    -0.02660747f, -0.03383544f, 0.00670953f, -0.00493847f, -0.03242664f, -0.02199343f, 0.05092788f, 0.02790919f, 
    -0.05547275f, 0.03086796f, 0.01400789f, 0.05484898f, -0.08156344f, -0.03933975f, -0.04603364f, -0.04895435f, 
    -0.05533273f, -0.02660627f, 0.04300925f, -0.02768914f, -0.00193407f, -0.05911544f, -0.06174036f, -0.07281838f, 
    0.05110566f, 0.03285731f, -0.04962618f, -0.06765164f, -0.02467173f, -0.02985161f, -0.03074914f, 0.01820069f, 
    0.00757197f, -0.04340833f, -0.03724482f, -0.04962939f, 0.02383474f, -0.06301473f, -0.07201612f, -0.06002583f, 
    -0.03491755f, -0.05042220f, 0.00861159f, 0.00577983f, 0.06206974f, -0.05804502f, -0.05072112f, -0.02229148f, 
    -0.01643429f, -0.04951292f, -0.02218748f, -0.03435253f, -0.05541793f, 0.03478146f, -0.01280897f, -0.05702993f, 
    0.04778648f, -0.00404589f, 0.07073283f, -0.07611068f, -0.04403405f, 0.01329469f, 0.01864701f, -0.07259755f, 
    -0.05647365f, -0.01619671f, -0.00935437f, 0.00254148f, 0.03496091f, 0.00376156f, 0.04049161f, -0.05322514f, 
    0.04737018f, 0.04808783f, 0.03850433f, -0.00206787f, -0.05258509f, 0.03850621f, -0.05913971f, -0.07804877f, 
    0.00857299f, -0.04060320f, -0.07017903f, -0.07361293f, -0.00886420f, -0.06099600f, -0.05523698f, 0.00304867f, 
    -0.03383219f, 0.00259584f, -0.04371315f, 0.05071300f, -0.04820613f, -0.03808992f, -0.01131543f, 0.01307529f, 
    0.01307151f, -0.03534321f, 0.00887716f, 0.01345883f, -0.00931930f, 0.00377381f, 0.04916113f, 0.02754699f, 
    0.05583474f, -0.01104182f, 0.00866173f, -0.02223903f, 0.05970663f, -0.07544802f, -0.06631566f, 0.01792181f, 
    -0.03592424f, -0.05476306f, 0.00493843f, 0.01525895f, -0.07490101f, -0.04281743f, -0.04631783f, 0.03211735f, 
    -0.01503829f, -0.05435797f, -0.05934448f, 0.00113542f, 0.05412475f, -0.01238757f, 0.04971231f, 0.04810316f, 
    0.04751850f, 0.01820446f, 0.04881969f, 0.00352094f, 0.01275305f, -0.01351096f, -0.05713255f, -0.05373134f, 
    0.01259833f, 0.02105606f, 0.00367680f, 0.03123704f, -0.06253173f, 0.02834245f, 0.05954699f, 0.03156971f, 
    -0.02550992f, -0.07440982f, -0.08459409f, 0.05637019f, -0.07335031f, 0.05622024f, 0.03072849f, 0.00289472f, 
    0.04968878f, 0.05343798f, 0.06868346f, 0.02480437f, -0.04598071f, 0.02494921f, -0.03894479f, -0.01440215f, 
    0.37423399f, 0.09885195f, -0.11833316f, 0.26562262f, 0.13097952f, -0.01579919f, 0.11188296f, -0.03127053f, 
    0.01841707f, 0.00945956f, 0.03480541f, 0.04943986f, -0.48949283f, -0.09375247f, -0.02908560f, -0.07231868f, 
    0.04588822f, 0.02002354f, 0.02143654f, -0.14086303f, 0.03284208f, -0.08751611f, 0.16803370f, 0.04371920f, 
    -0.26578104f, 0.09287475f, 0.09163775f, 0.04205354f, -0.02336235f, -0.07433750f, -0.06883879f, 0.11077009f, 
    0.03359220f, 0.00505114f, 0.01172768f, -0.06120848f, 0.08376194f, 0.02725369f, 0.13203290f, -0.01080509f, 
    -0.17009258f, -0.03434779f, -0.03110908f, 0.03737928f, 0.14738490f, 0.06095901f, 0.12523696f, 0.04892690f, 
    0.16618638f, -0.14905381f, -0.09277547f, 0.03750386f, 0.06672619f, 0.01652223f, 0.20740156f, 0.01669783f, 
    -0.01986120f, -0.00761586f, 0.06393513f, 0.07846551f, 0.12991452f, -0.09001609f, 0.03059581f, -0.05546483f, 
    0.02247279f, 0.00611432f, 0.02653246f, -0.01329505f, 0.14710537f, -0.00171279f, 0.03979636f, -0.03206826f, 
    -0.54646391f, -0.04615029f, 0.15618370f, -0.22228266f, 0.19559130f, 0.00950619f, 0.07657669f, 0.13181147f, 
    0.06281142f, -0.02031719f, 0.07827509f, 0.03099419f, -0.28425452f, 0.04915176f, -0.03554867f, 0.07707564f, 
    0.03917370f, -0.06484646f, 0.11165761f, 0.08415031f, -0.01304290f, -0.01747707f, -0.08389296f, 0.01394230f, 
    -0.01359685f, -0.19635551f, 0.00136969f, -0.07329453f, -0.08249330f, 0.11562145f, 0.08751534f, 0.07019972f, 
    0.00133286f, -0.10611724f, 0.00917453f, 0.04053904f, -0.06999194f, -0.26944813f, 0.14201690f, 0.01502276f, 
    -0.16561571f, 0.07425781f, -0.06088995f, 0.01169601f, 0.03155200f, -0.04921217f, -0.01279919f, -0.02143315f, 
    -0.21221535f, -0.11770241f, 0.12601894f, -0.12341952f, 0.06609088f, 0.03066656f, 0.00744899f, 0.01450725f, 
    0.08339605f, 0.16154847f, -0.04689375f, -0.08461666f, -0.15272377f, -0.09192851f, -0.06225767f, -0.12217476f, 
    -0.13992801f, 0.04204218f, -0.04103610f, -0.05582440f, 0.09597749f, -0.09639636f, 0.04288237f, 0.04942620f, 
    0.26382160f, -0.05713739f, 0.21432841f, 0.07277065f, 0.02658275f, -0.03933670f, -0.04339157f, 0.02510687f, 
    0.13689668f, 0.03138019f, -0.08657319f, 0.00207017f, 0.35094613f, 0.07054323f, 0.10785680f, -0.21314731f, 
    0.10112030f, -0.08488492f, 0.02444079f, 0.01219010f, 0.15215373f, 0.25997326f, 0.09631928f, 0.09703393f, 
    -0.03283858f, 0.12891327f, -0.01241692f, 0.03626065f, 0.07656953f, 0.04930723f, -0.05256869f, -0.04986417f, 
    0.03734694f, 0.01686675f, 0.06402156f, 0.22888778f, 0.41806406f, 0.21024735f, -0.15586238f, 0.12513416f, 
    -0.01359190f, 0.04841333f, -0.06847431f, 0.09619362f, 0.08808699f, -0.03289952f, -0.09106278f, 0.15378144f, 
    0.16204272f, 0.00400585f, 0.20427246f, -0.15174332f, -0.14015219f, 0.05371090f, -0.00131869f, -0.04591020f, 
    0.05875764f, 0.04539413f, -0.04835862f, -0.09445448f, 0.34555650f, 0.14698450f, -0.08699315f, -0.12760340f, 
    0.05679844f, -0.00637998f, -0.04353481f, 0.14865121f, -0.00707610f, 0.15801142f, -0.02330985f, 0.01703880f, 
    0.05435627f, -0.10123202f, -0.08330035f, -0.17227574f, -0.04464717f, 0.11461711f, 0.03318257f, -0.02753539f, 
    -0.00937404f, 0.01503454f, 0.10919926f, 0.00310867f, -0.35908893f, -0.04108191f, -0.16880707f, 0.06813985f, 
    -0.14265862f, 0.09028646f, 0.05500556f, 0.06412797f, -0.03557593f, -0.07081265f, -0.06068679f, 0.01484656f, 
    -0.13014251f, 0.06379890f, 0.01268507f, -0.03476748f, -0.01304844f, -0.14165811f, -0.15945883f, -0.02204978f, 
    -0.03725673f, -0.00907758f, -0.06164311f, -0.04007408f, 0.14026190f, -0.00585962f, -0.06711471f, 0.23716626f, 
    -0.07275783f, -0.05604732f, -0.08364400f, 0.03644183f, 0.10181641f, -0.07360362f, -0.08533139f, 0.02873784f, 
    -0.05391506f, 0.33072484f, -0.15193321f, 0.38344792f, -0.03146954f, 0.08757836f, -0.01673208f, -0.08715823f, 
    -0.08798023f, -0.04464595f, 0.01892071f, -0.07599739f, 0.14176354f, 0.09719654f, -0.05930524f, 0.08686628f, 
    0.15657508f, 0.13010561f, -0.12763938f, 0.06005890f, -0.02855269f, 0.00663382f, -0.02339240f, 0.00135677f, 
    -0.10383798f, 0.01534816f, -0.11882269f, -0.04856821f, -0.00589291f, 0.03096839f, -0.12106177f, 0.05983779f, 
    0.04222767f, 0.04646217f, 0.11960170f, -0.03434263f, -0.15953830f, -0.11254118f, -0.10452972f, 0.05077307f, 
    -0.03990490f, 0.07370917f, 0.08036727f, 0.07796454f, -0.02298537f, -0.03165815f, -0.02046358f, -0.00121737f, 
    0.31177157f, 0.08426270f, -0.21746963f, 0.28173965f, 0.22258072f, 0.07724698f, 0.00016669f, 0.04460110f, 
    0.11420219f, -0.12486596f, 0.01200840f, 0.10551424f, -0.03085495f, -0.11486174f, -0.07961578f, -0.12649959f, 
    0.08613396f, 0.04044692f, 0.19264084f, 0.28523070f, 0.03813985f, 0.17155552f, 0.00931459f, -0.03972111f, 
    0.20361592f, -0.04327420f, 0.01608785f, -0.06491106f, -0.04612714f, 0.07576643f, 0.04993308f, -0.00963232f, 
    -0.08231518f, -0.06343268f, 0.08021817f, 0.01013116f, 0.02356027f, 0.09988184f, -0.02027835f, -0.05652052f, 
    -0.17268357f, 0.00841384f, 0.02572710f, 0.02717726f, 0.04647005f, -0.10003263f, -0.01660485f, 0.01087784f, 
    0.07947189f, -0.10616530f, -0.10297808f, -0.04260369f, -0.07990037f, -0.09792019f, -0.04433744f, 0.11197227f, 
    0.08805695f, 0.04222442f, 0.09366921f, -0.02774952f, 0.10189937f, -0.04874416f, 0.27779210f, -0.19811581f, 
    -0.00523467f, 0.07258157f, 0.14652070f, -0.05046215f, -0.09073290f, 0.05172949f, 0.04504371f, 0.00281653f, 
    0.19921832f, 0.02352637f, 0.01830926f, -0.06822154f, -0.04167763f, 0.06055382f, -0.08047157f, 0.09435730f, 
    -0.05416382f, -0.07693527f, -0.14029948f, -0.10104070f, 0.11125902f, -0.03609989f, -0.16912986f, -0.10425799f, 
    0.12193141f, 0.11798771f, -0.05931417f, -0.00786855f, -0.04804344f, 0.04201204f, -0.01494630f, 0.04738236f, 
    0.07937352f, -0.29366621f, 0.18163191f, -0.12203157f, -0.03651929f, -0.11008658f, -0.10161369f, -0.05026769f, 
    0.05761942f, -0.05720047f, 0.07472060f, -0.03454072f, -0.18032536f, 0.02789935f, -0.12843290f, -0.02810147f, 
    0.04167998f, 0.02326986f, -0.09997848f, 0.05514134f, 0.01341415f, 0.03962234f, -0.01050781f, 0.06004563f, 
    0.23013410f, -0.04567881f, -0.04900133f, -0.05573666f, -0.09903534f, -0.06638671f, 0.06530996f, 0.00335489f, 
    0.06206490f, 0.06748315f, 0.09063805f, -0.10012013f, -0.01380244f, -0.06187631f, 0.11965417f, -0.07581944f, 
    -0.06593856f, -0.02042870f, 0.05633257f, 0.05638666f, 0.03253331f, -0.00109392f, 0.12601919f, -0.03645938f, 
    -0.31082559f, 0.15449691f, -0.08060506f, 0.05584931f, 0.16085380f, 0.01263788f, -0.00685627f, 0.02051059f, 
    -0.05010929f, -0.02121147f, 0.01772376f, -0.11522663f, -0.08445027f, 0.22725089f, 0.00074382f, 0.04416313f, 
    0.07880676f, 0.06517011f, 0.04495891f, -0.09471413f, 0.07852438f, -0.01216226f, 0.01301092f, 0.06627276f, 
    -0.23600978f, -0.03656360f, 0.04488071f, -0.13731225f, -0.03528846f, -0.05999645f, 0.12556575f, 0.04697213f, 
    0.01665954f, -0.00635225f, 0.15863974f, 0.06265485f, 0.09961462f, -0.26385418f, 0.11344418f, -0.10753707f, 
    -0.05078320f, -0.03150008f, 0.01095545f, -0.15710562f, 0.06059949f, -0.15182066f, 0.09101227f, 0.06143603f, 
    -0.18372060f, -0.07104322f, -0.07336045f, 0.07558725f, 0.18018137f, 0.00071691f, 0.05162689f, 0.00621441f, 
    0.07690850f, 0.05402062f, -0.00311173f, 0.03637050f, -0.22781438f, -0.20036820f, -0.01072048f, -0.10378658f, 
    0.09363095f, -0.07377512f, -0.04117506f, 0.05701896f, -0.01795007f, 0.05313182f, 0.04932286f, 0.12499671f, 
    0.03193853f, -0.13005100f, 0.13785727f, 0.32656407f, -0.06223767f, -0.06903241f, -0.02161112f, 0.01242450f, 
    0.03446138f, 0.12697348f, -0.04311808f, 0.02853591f, 0.12781326f, 0.17222248f, -0.00696451f, 0.01680054f, 
    -0.03102732f, -0.01393225f, -0.01392884f, -0.00534153f, -0.00715238f, 0.06544518f, -0.06939980f, 0.00430349f, 
    0.03070105f, -0.07666848f, -0.13011922f, 0.01450905f, -0.01832283f, -0.06642356f, 0.01733762f, -0.10770477f, 
    0.04280289f, -0.05990007f, 0.06979275f, 0.05093582f, 0.19109729f, 0.21960084f, 0.09793450f, -0.13265175f, 
    -0.06283882f, 0.03416361f, -0.02481639f, 0.09969091f, 0.05777822f, -0.16175325f, -0.08492330f, 0.04477298f, 
    -0.19788668f, 0.27593014f, 0.11385836f, 0.11312318f, -0.02468898f, 0.04642156f, -0.06305893f, 0.13660157f, 
    -0.06463008f, 0.01801379f, 0.01573168f, -0.07814957f, -0.28002927f, -0.37285772f, -0.03140172f, 0.05458236f, 
    0.00003715f, 0.02866876f, -0.09420087f, 0.02922739f, 0.02915345f, -0.03958752f, 0.06727360f, 0.21884379f, 
    0.07008105f, -0.01434940f, -0.05503339f, 0.09858783f, -0.03610641f, 0.04765686f, 0.20509581f, 0.11090021f, 
    -0.00175852f, 0.01442149f, -0.10901080f, 0.04512624f, 0.27527544f, -0.08973963f, 0.17082143f, -0.08871511f, 
    0.07743918f, -0.14374083f, 0.12354112f, -0.03455184f, -0.12921958f, -0.01274438f, 0.00165981f, 0.22792116f, 
    -0.34678528f, 0.23816942f, 0.04822963f, -0.05302025f, 0.00163771f, -0.03937829f, 0.06411950f, -0.00703794f, 
    0.12084734f, 0.14765143f, 0.01716636f, 0.01423481f, 0.12340283f, 0.14931224f, 0.11042521f, -0.03144117f, 
    -0.16915931f, 0.04306049f, 0.04409122f, -0.02888301f, 0.07186479f, -0.10865941f, -0.02967274f, 0.09095661f, 
    0.39944762f, -0.11559275f, -0.15414287f, 0.16054258f, -0.02064145f, 0.00231564f, 0.07346039f, 0.02545547f, 
    -0.08883344f, 0.00291865f, 0.03861284f, 0.04401431f, -0.06475702f, -0.23860961f, -0.17070644f, 0.02214940f, 
    0.04916601f, -0.06748805f, 0.06809724f, -0.02820819f, -0.06613436f, -0.02424208f, 0.19467258f, 0.03712101f, 
    0.14482498f, 0.05829118f, -0.05803771f, -0.08470923f, 0.09931783f, 0.03531112f, -0.11873461f, 0.20780078f, 
    -0.08048898f, 0.00684237f, -0.09355913f, 0.04560232f, -0.22943440f, 0.10628919f, 0.06563271f, -0.14724250f, 
    0.04367919f, 0.05798369f, 0.06646582f, 0.01814246f, 0.07165726f, 0.07109009f, -0.03423372f, -0.00758485f, 
    -0.02306995f, 0.07101847f, -0.19552492f, -0.11162261f, -0.03437404f, 0.04338070f, 0.10580821f, 0.01799119f, 
    0.12843530f, -0.07303481f, -0.10162822f, 0.03176843f, 0.12157881f, -0.06481221f, 0.07148054f, 0.22993375f, 
    0.06672408f, 0.08320190f, 0.09062900f, 0.14359897f, -0.06144901f, 0.11937483f, 0.00116889f, -0.02629384f, 
    0.04247532f, 0.40204307f, -0.09296386f, -0.15971960f, 0.03992813f, 0.04480463f, 0.07656198f, 0.13203274f, 
    -0.04419203f, -0.09642481f, 0.04358390f, -0.06727619f, -0.08023003f, 0.07378156f, 0.11450648f, 0.01935097f, 
    -0.07655970f, 0.11103797f, 0.13383768f, 0.18609285f, 0.04559604f, 0.02482099f, 0.13037203f, 0.11110952f, 
    -0.39067891f, -0.01157101f, 0.36485481f, 0.04750256f, -0.09968337f, -0.02208315f, 0.09257558f, -0.00217908f, 
    -0.00486173f, -0.11420464f, -0.02280396f, -0.25066283f, -0.02688539f, -0.31645957f, 0.04864120f, 0.10808660f, 
    -0.16112716f, 0.17110774f, -0.03199121f, 0.06117167f, -0.06467791f, 0.01964453f, -0.11278697f, -0.16478522f, 
    0.02908016f, 0.01145459f, 0.06287590f, -0.02546638f, -0.04353051f, -0.03833514f, -0.06123652f, 0.05700053f, 
    -0.02555021f, -0.04063307f, -0.00869095f, 0.04808699f, 0.05924336f, -0.07209111f, 0.00974100f, 0.00622484f, 
    -0.02009320f, -0.00231947f, -0.03593605f, 0.04424302f, -0.01217024f, 0.02548813f, 0.06862543f, -0.07485309f, 
    -0.04128243f, -0.05845989f, -0.01703574f, -0.05237323f, -0.07506686f, -0.07469514f, 0.02649025f, -0.01008267f, 
    0.04135963f, -0.00464836f, -0.00862769f, -0.04658940f, 0.03226028f, 0.05944185f, 0.01805280f, -0.02800698f, 
    -0.01609651f, -0.07065905f, -0.05127908f, 0.04925254f, 0.04628922f, -0.07506946f, -0.05112439f, -0.01004160f, 
    -0.06142940f, 0.00126915f, -0.05859207f, -0.05223948f, 0.02418215f, 0.04135856f, -0.01017931f, -0.07666326f, 
    -0.02897139f, -0.02972343f, -0.03421652f, -0.06268177f, 0.00284335f, 0.05533267f, -0.06838986f, -0.00154028f, 
    0.04769243f, -0.03521838f, -0.06367427f, -0.05655356f, -0.02329950f, -0.02065893f, 0.04164174f, -0.03223274f, 
    -0.06014870f, 0.05581995f, 0.04413166f, 0.02998701f, 0.03749435f, -0.00418979f, -0.02885007f, -0.00185068f, 
    0.05671466f, 0.00936350f, -0.05361992f, 0.00661937f, 0.03140786f, -0.03194334f, -0.03673914f, 0.01239435f, 
    -0.02705057f, -0.03328471f, 0.06527604f, -0.06416774f, 0.05796804f, -0.04719037f, 0.01679054f, -0.00925545f, 
    0.04447521f, 0.04408507f, -0.01666348f, -0.01600650f, -0.00765097f, -0.06465741f, -0.00071089f, -0.03240827f, 
    -0.06501448f, 0.05654616f, 0.00625069f, -0.01201870f, -0.04064623f, -0.03986672f, -0.06038362f, -0.05708836f, 
    0.01473974f, -0.06346397f, -0.03284925f, -0.05744613f, -0.05312652f, 0.04427165f, -0.04615332f, -0.01675019f, 
    0.02876831f, 0.03718701f, 0.00314799f, -0.02851300f, 0.05733376f, -0.03545196f, -0.00386947f, -0.07550726f, 
    0.03978864f, -0.04566918f, -0.00587704f, -0.03376974f, -0.04836054f, 0.02978006f, 0.00782409f, 0.04764364f, 
    -0.03447257f, -0.06239137f, -0.02654535f, 0.01710140f, 0.05307094f, -0.05104226f, -0.07038064f, -0.01514564f, 
    0.06208478f, -0.02821802f, -0.01960606f, -0.02467972f, -0.02435764f, -0.03117837f, 0.02512343f, -0.06174232f, 
    -0.04556161f, -0.06631298f, 0.06480268f, -0.02838031f, -0.07699486f, -0.02489580f, -0.04122294f, -0.07549188f, 
    0.04987891f, 0.01378511f, 0.02898959f, 0.06012127f, -0.05597726f, -0.06698589f, -0.02440933f, 0.05988175f, 
    0.06331988f, 0.04370074f, -0.00700775f, 0.06440352f, -0.02417237f, -0.01902276f, 0.06657131f, -0.04126446f, 
    -0.07610749f, -0.07635069f, -0.05055055f, -0.00798071f, 0.04037799f, 0.03499126f, 0.03988755f, -0.02863564f, 
    0.02712641f, -0.06537967f, -0.07226473f, 0.05668136f, 0.04895356f, -0.00723268f, -0.01816060f, -0.04067868f, 
    -0.19523394f, 0.16799605f, 0.06812344f, -0.09847862f, -0.04190866f, 0.00517748f, 0.02042344f, 0.00393591f, 
    0.01541250f, 0.08159619f, -0.00780451f, -0.00865786f, 0.00266108f, 0.19855538f, 0.17161149f, -0.31712350f, 
    0.08151441f, 0.18872403f, 0.07326607f, -0.13798821f, -0.04173717f, 0.08868242f, 0.17792338f, 0.04620557f, 
    -0.40154752f, -0.14652385f, 0.18376046f, -0.03372178f, 0.06747298f, -0.09865475f, 0.11993107f, -0.06551218f, 
    0.07243027f, -0.12631097f, -0.01964944f, -0.18861201f, -0.03108325f, -0.08099470f, 0.23925759f, 0.31779251f, 
    0.02312398f, 0.06537542f, 0.05826164f, 0.00600420f, -0.02301157f, 0.07553219f, -0.09089072f, -0.04628466f, 
    -0.17362711f, 0.00546747f, -0.16035955f, 0.04081451f, -0.21196535f, -0.04420955f, 0.04522198f, 0.02058478f, 
    0.12739572f, 0.03106945f, -0.06820896f, 0.06830262f, -0.12496417f, 0.03768116f, -0.05081424f, -0.18661374f, 
    -0.14412701f, 0.06186034f, 0.01758437f, 0.00579863f, -0.12077031f, 0.17946562f, 0.14898093f, -0.12568824f, 
    -0.00668916f, -0.06252293f, 0.12680039f, 0.04020365f, -0.02967028f, 0.11840180f, 0.02898626f, -0.02171208f, 
    -0.04048787f, -0.09291840f, 0.00885346f, -0.12999526f, 0.02272509f, 0.06343047f, 0.19729388f, -0.24353786f, 
    0.09606534f, 0.09540831f, 0.08104830f, 0.02127466f, -0.02655053f, 0.08175318f, -0.03680119f, 0.09920021f, 
    0.09033283f, 0.12164678f, 0.05188133f, 0.16513424f, 0.04441884f, 0.07107970f, 0.05890425f, 0.03038556f, 
    -0.05360901f, 0.06988983f, -0.01400538f, 0.06903385f, 0.51819551f, 0.07267915f, -0.06679282f, 0.17173894f, 
    -0.03527101f, -0.03340954f, -0.07838881f, -0.03263525f, -0.01669035f, 0.09825853f, -0.00154577f, 0.01346342f, 
    -0.02035774f, 0.08718552f, -0.01759517f, -0.13381134f, 0.11963326f, 0.06411152f, 0.14823940f, 0.07910620f, 
    0.06753523f, -0.02905671f, -0.01423076f, 0.00428420f, 0.09749264f, 0.16585937f, -0.03085783f, -0.00707343f, 
    0.01958167f, -0.01013795f, 0.09773875f, -0.01857583f, 0.08688006f, -0.10134288f, -0.09966616f, -0.05285101f, 
    -0.21294075f, 0.11060710f, -0.04663870f, -0.03940878f, -0.01443066f, -0.03456207f, 0.05420095f, -0.01807548f, 
    0.05420944f, -0.01283511f, -0.09424648f, -0.04781228f, 0.01445156f, 0.13830499f, -0.06472977f, -0.05849112f, 
    -0.02403989f, 0.02112914f, 0.04983577f, -0.04558339f, -0.05348021f, 0.07051204f, -0.05695162f, -0.03300278f, 
    0.19017437f, -0.11323867f, 0.08146065f, 0.07433489f, -0.06871796f, -0.05729936f, -0.00232396f, 0.07628702f, 
    0.04479964f, 0.10095207f, -0.11719359f, -0.03439361f, -0.18495378f, 0.15234086f, 0.07613956f, 0.20920478f, 
    -0.04721186f, -0.08807447f, 0.00453151f, 0.18251774f, -0.00748766f, 0.00606563f, 0.03501613f, 0.00573478f, 
    -0.05359378f, -0.08990475f, 0.04669689f, -0.02941379f, -0.03281506f, -0.06032822f, 0.06019395f, -0.06823455f, 
    -0.04670318f, 0.02072414f, 0.01094268f, -0.05668186f, -0.06091728f, -0.00140932f, -0.07739589f, -0.02240810f, 
    0.01743634f, -0.01992797f, -0.02805921f, -0.00424888f, 0.03158855f, -0.06128891f, 0.05175617f, 0.02561977f, 
    -0.01695755f, -0.03026054f, 0.00468225f, -0.01191129f, 0.06153499f, 0.00872085f, 0.01059058f, -0.09371805f, 
    0.03470254f, -0.10181582f, -0.03508398f, 0.04815401f, 0.02655349f, -0.03129549f, 0.05480600f, -0.04530274f, 
    -0.08480660f, -0.03972012f, 0.02323526f, -0.01574832f, -0.01309052f, 0.00249151f, -0.02633125f, 0.05332293f, 
    0.03293802f, 0.02261743f, -0.06495995f, 0.04908739f, 0.03763600f, 0.00184765f, -0.03128926f, -0.04810106f, 
    -0.09186138f, -0.07241417f, -0.04579399f, -0.07947759f, -0.04835669f, 0.00571064f, -0.08967667f, -0.00863803f, 
    -0.05774837f, -0.02879710f, -0.05847235f, -0.01893417f, 0.03930221f, 0.00031149f, -0.08479010f, -0.02946498f, 
    -0.05164748f, 0.05324859f, 0.05374622f, -0.07740639f, 0.04704099f, -0.05092448f, 0.01674381f, 0.02208258f, 
    0.01024205f, 0.00382530f, 0.00006825f, -0.01096740f, -0.09151126f, -0.06589721f, -0.00150472f, -0.01396715f, 
    -0.08666705f, -0.05709076f, 0.02903543f, -0.04242676f, -0.04758871f, 0.01170911f, -0.05977528f, -0.07575195f, 
    -0.05355132f, -0.06583299f, -0.07429136f, -0.07256161f, -0.04502013f, -0.09816103f, -0.01026313f, -0.04998506f, 
    -0.04378133f, 0.05271437f, -0.03629432f, -0.00491507f, -0.07825465f, -0.00862378f, -0.03036894f, 0.01830365f, 
    0.01565995f, -0.07656193f, -0.04468506f, 0.02899676f, -0.09692857f, -0.04218742f, 0.03525994f, 0.01542644f, 
    0.03215840f, 0.00208075f, 0.00285606f, 0.03306058f, 0.05315826f, -0.05791200f, -0.02060403f, -0.01853501f, 
    0.01806051f, -0.02550464f, 0.01967030f, -0.02355183f, -0.04340264f, -0.00732838f, -0.05779940f, -0.05919119f, 
    -0.04116233f, 0.00065409f, 0.07153667f, -0.04330932f, -0.03060907f, 0.03692603f, 0.00445569f, -0.02774685f, 
    0.05228890f, 0.04028973f, -0.06035569f, 0.03801920f, -0.02248750f, -0.04548468f, 0.01283134f, -0.04810605f, 
    -0.06158383f, 0.00977129f, 0.00902925f, -0.09357475f, 0.03898291f, -0.04316613f, 0.03606613f, -0.00636520f, 
    -0.07320989f, -0.01746974f, -0.04320541f, 0.03491620f, 0.03417822f, 0.01156999f, -0.08655792f, -0.09159388f, 
    0.01666754f, 0.05647488f, 0.03312571f, 0.01182789f, 0.00413517f, 0.02059947f, -0.06069164f, 0.03375798f, 
    -0.01515535f, 0.03770734f, -0.06022630f, 0.05281460f, 0.00171783f, 0.03437572f, -0.02252143f, 0.02890211f, 
    -0.09207216f, -0.04682487f, 0.05867515f, -0.05077063f, -0.00107168f, -0.06914367f, -0.00885942f, -0.07866853f, 
    -0.06311231f, 0.21313302f, 0.03334842f, 0.11665145f, -0.05759626f, -0.00208290f, 0.04737734f, 0.05572380f, 
    -0.03343618f, -0.09921276f, 0.01960833f, 0.02261855f, -0.10921299f, -0.05573554f, 0.13497211f, 0.03666333f, 
    0.02318202f, 0.05696633f, 0.05444569f, 0.04077960f, 0.10333528f, -0.10103295f, -0.01808346f, 0.12920709f, 
    0.08960628f, 0.16105261f, 0.05931910f, 0.12452124f, -0.03560451f, -0.07358320f, 0.05884628f, -0.03867099f, 
    -0.09835397f, 0.05792961f, -0.08436873f, 0.00101186f, 0.05780446f, 0.18150280f, 0.01126383f, -0.20257361f, 
    0.15813911f, 0.04444768f, -0.03582466f, 0.04424504f, -0.01884711f, 0.11097540f, -0.12428020f, 0.00560529f, 
    0.12863721f, 0.00009328f, -0.25619915f, 0.01817094f, -0.04107811f, -0.03087522f, 0.06892502f, 0.02835217f, 
    -0.05971723f, 0.08128261f, 0.10052034f, -0.09489927f, 0.20943803f, -0.28362730f, 0.17386487f, 0.15050772f, 
    -0.04498117f, -0.11147759f, 0.01169949f, 0.05911657f, -0.00026522f, 0.03460813f, 0.05686532f, 0.03959016f, 
    -0.22249196f, -0.09259263f, 0.02967289f, -0.06965837f, 0.00363607f, -0.01357879f, 0.09962381f, 0.16101462f, 
    -0.06456039f, -0.12293343f, 0.00265597f, -0.05050165f, -0.14590664f, 0.19893433f, 0.10198478f, -0.05437830f, 
    0.05231684f, -0.00851426f, 0.06229681f, -0.10078736f, 0.08563203f, 0.04049174f, 0.05544749f, -0.08990733f, 
    -0.03824107f, -0.05706704f, 0.19549848f, -0.17563601f, 0.10471513f, 0.03747594f, 0.11368436f, 0.08244576f, 
    -0.08239269f, -0.09231024f, -0.06622218f, 0.10692796f, 0.35336214f, 0.10797603f, 0.14432846f, -0.02344844f, 
    -0.00237976f, -0.07957865f, -0.00880545f, 0.03830206f, 0.01751427f, 0.01909667f, 0.11519008f, 0.00024006f, 
    -0.40603933f, 0.07226039f, 0.04970774f, -0.19833973f, -0.06859429f, -0.05777136f, 0.03788963f, 0.01591527f, 
    0.06163664f, 0.03403929f, -0.07648221f, 0.00737370f, -0.17302611f, -0.05000857f, 0.20818654f, 0.12490090f, 
    -0.01305903f, -0.00709913f, -0.13830851f, 0.01295607f, 0.07984509f, 0.08951496f, 0.04992837f, 0.16944189f, 
    0.06731822f, 0.01024728f, 0.09769872f, 0.32143801f, -0.02775813f, -0.08854276f, -0.07196106f, 0.06525093f, 
    0.12547772f, 0.11446968f, 0.02528059f, -0.00427579f, -0.25864729f, -0.11848985f, -0.04130736f, 0.12897789f, 
    -0.03225465f, 0.11847417f, 0.07075325f, 0.11328245f, 0.04027234f, 0.10662200f, -0.09511262f, 0.02716521f, 
    -0.09083656f, -0.11442123f, 0.02965058f, 0.13716398f, -0.09059801f, -0.04351525f, -0.00942248f, 0.00933173f, 
    -0.01125165f, 0.00909271f, -0.00600059f, 0.11811241f, -0.07716170f, 0.03831608f, -0.13275214f, -0.06851875f, 
    -0.10344703f, -0.01362616f, 0.02812675f, -0.01462959f, 0.02471127f, -0.02674804f, 0.04583324f, 0.05769348f, 
    0.14124238f, 0.25618452f, -0.01258213f, 0.22286013f, 0.01089831f, 0.04608408f, -0.05926486f, 0.03943764f, 
    -0.07048667f, -0.08962876f, 0.04127900f, -0.06411379f, -0.27827021f, -0.20915531f, 0.01244444f, 0.14580551f, 
    0.01069875f, 0.05542967f, -0.00756306f, -0.00532319f, -0.03779221f, 0.08142913f, 0.08309004f, 0.04210718f, 
    0.04969190f, 0.02697877f, 0.05151374f, 0.07550921f, 0.00744596f, -0.01990851f, 0.07209026f, 0.05345002f, 
    -0.02825089f, -0.00836443f, -0.05165337f, 0.07888383f, 0.40132165f, -0.14224745f, 0.25894591f, 0.06704766f, 
    0.01637859f, -0.21769595f, 0.07461083f, -0.03846167f, -0.13282543f, -0.01542233f, 0.00770697f, 0.12038269f, 
    -0.14753005f, 0.19526769f, 0.08071101f, -0.11893404f, 0.11269364f, 0.09198654f, 0.03320771f, -0.10959642f, 
    0.01325066f, -0.01330766f, -0.14133073f, 0.00020768f, 0.09278473f, 0.13081123f, 0.03082152f, -0.00671357f, 
    0.00133766f, 0.03432842f, 0.01709754f, -0.05623944f, 0.05875705f, -0.16324747f, -0.04544009f, 0.10332660f, 
    0.01153191f, 0.09213357f, 0.00431299f, -0.06925352f, 0.11435058f, -0.05404633f, -0.06879743f, 0.08164788f, 
    -0.09125326f, 0.10783055f, 0.03333863f, 0.14362594f, -0.17908986f, -0.06704741f, -0.16670962f, 0.00049857f, 
    -0.03735365f, -0.14506945f, 0.04227638f, -0.03392926f, 0.03085919f, -0.00952000f, 0.03114513f, -0.06105297f, 
    -0.03841877f, 0.04859109f, 0.05952111f, 0.12728114f, -0.03233325f, -0.10338663f, -0.00033450f, 0.17477819f, 
    -0.11813231f, 0.00975836f, -0.11224587f, -0.07278793f, -0.48248664f, -0.02997350f, 0.08791191f, -0.19517317f, 
    0.10022906f, 0.01260341f, 0.09155333f, 0.03814834f, 0.06367444f, -0.07395838f, -0.09268256f, 0.01183908f, 
    -0.03708784f, 0.05415881f, 0.03667867f, -0.03885676f, -0.00849784f, 0.01064738f, -0.06316216f, -0.07084885f, 
    0.04972455f, 0.13566388f, 0.02218289f, 0.04412892f, 0.20465331f, -0.01432844f, 0.08374277f, 0.29841220f, 
    0.00575952f, 0.04103014f, -0.00990508f, 0.13099723f, -0.00850240f, 0.15159436f, 0.04303689f, 0.02221845f, 
    0.05844455f, 0.18362591f, -0.02581797f, -0.02570036f, 0.12014449f, 0.00366392f, -0.07253563f, 0.08315756f, 
    -0.09496821f, 0.00723628f, -0.00193689f, -0.05684471f, 0.06415492f, -0.10993914f, 0.22863036f, -0.03359410f, 
    0.03405070f, 0.11844376f, -0.00383630f, 0.06149187f, 0.06550023f, 0.13707167f, 0.07564061f, 0.18138592f, 
    -0.42124268f, -0.01369306f, 0.17761113f, -0.09161098f, -0.03159400f, 0.00323308f, -0.01959325f, -0.10978014f, 
    -0.01343104f, 0.02332217f, 0.03428067f, -0.09493593f, 0.37714192f, -0.13969681f, -0.02456312f, 0.03599554f, 
    -0.10367356f, 0.09048299f, -0.09238805f, 0.01847368f, -0.05781924f, -0.01584224f, -0.10119395f, 0.03991402f, 
    0.17137623f, -0.11371477f, 0.18952467f, -0.28874180f, 0.08870571f, 0.07497750f, 0.03125370f, 0.03766977f, 
    -0.01998112f, 0.02601504f, 0.06621844f, 0.02903504f, 0.24704726f, 0.15116069f, 0.01425922f, -0.05271840f, 
    -0.19742593f, -0.10850543f, -0.04329181f, 0.26048779f, 0.05353451f, 0.00916330f, -0.09981035f, -0.13489267f, 
    0.40221915f, 0.09715399f, -0.11118340f, -0.05405654f, -0.11346348f, 0.22164243f, 0.00450280f, -0.02571818f, 
    0.00029587f, 0.12392585f, -0.02798963f, -0.00401136f, -0.35682291f, 0.06132188f, -0.26607221f, -0.21461579f, 
    -0.13489902f, 0.08035387f, 0.12776062f, 0.00759343f, 0.07495192f, 0.00881242f, -0.04044213f, -0.09259550f, 
    0.12603845f, 0.11288973f, 0.10180913f, 0.00672310f, 0.12285520f, 0.01701357f, -0.25619218f, -0.01923942f, 
    -0.09995071f, 0.06917310f, 0.12155303f, -0.04139537f, 0.07780902f, -0.07277354f, -0.07199737f, 0.38626766f, 
    0.25064561f, 0.06350570f, 0.04845273f, 0.06567900f, 0.04287310f, -0.08278754f, 0.01016710f, 0.05602869f, 
    -0.08480150f, 0.21723232f, -0.15475993f, 0.15755680f, -0.12440943f, -0.06184143f, -0.08510653f, 0.03116415f, 
    -0.00237975f, 0.10044008f, 0.06381834f, 0.07170623f, 0.27913582f, 0.16862874f, 0.09988309f, 0.13124004f, 
    0.00167487f, -0.03606768f, -0.23079100f, 0.06603487f, 0.08072942f, 0.03812456f, -0.08730119f, 0.02365528f, 
    -0.23742430f, -0.09751308f, 0.03319347f, -0.16833772f, -0.11150744f, 0.04325036f, -0.05597154f, -0.00078609f, 
    0.05799390f, 0.15854897f, 0.06181711f, -0.14094289f, 0.09788918f, -0.10517020f, -0.00987933f, 0.00055996f, 
    -0.03508203f, 0.13044554f, 0.02316333f, -0.05084627f, -0.02344018f, -0.03750033f, 0.04773348f, -0.00375351f, 
    0.18219759f, 0.08808244f, -0.02111268f, 0.17162962f, 0.05480970f, -0.10297386f, -0.06229615f, 0.05233904f, 
    0.00352081f, 0.03639641f, 0.09996077f, 0.00365851f, -0.06183107f, -0.21304008f, 0.08905339f, -0.21117969f, 
    -0.01499255f, 0.03387848f, 0.05757787f, 0.15374795f, -0.01079470f, 0.09161583f, 0.14710155f, 0.00589247f, 
    0.17229535f, -0.07361057f, 0.01578116f, 0.17481899f, 0.15081508f, 0.09424150f, 0.03275332f, -0.01068956f, 
    -0.08557979f, 0.00848158f, 0.06621400f, 0.06111882f, -0.06518135f, -0.07045233f, -0.18890782f, 0.08091508f, 
    -0.06462999f, -0.02713503f, -0.04248815f, -0.09706663f, 0.09301483f, -0.14645085f, -0.08575405f, 0.02785276f, 
    -0.04079956f, -0.27828377f, -0.37127119f, -0.05287010f, 0.11334262f, 0.03872849f, -0.05548403f, -0.00304382f, 
    -0.00574562f, 0.04304267f, -0.06042723f, 0.01323522f, 0.01417498f, -0.16648740f, 0.19571345f, -0.34958005f, 
    0.06672484f, -0.02743380f, 0.10895281f, -0.09760290f, -0.01140548f, 0.00548315f, 0.09314406f, 0.09031539f, 
    0.00515823f, 0.01613879f, -0.05552402f, 0.05523559f, 0.00083594f, -0.00057438f, -0.05194564f, -0.05352550f, 
    0.03136089f, -0.01018363f, -0.07320774f, 0.03164892f, -0.05782638f, 0.05677359f, -0.01274265f, -0.02475419f, 
    0.04771445f, 0.02924379f, 0.04832317f, 0.02071960f, -0.00493636f, -0.04657885f, 0.05896056f, -0.07046583f, 
    0.00747925f, 0.01645966f, -0.00006075f, -0.04953304f, -0.05207485f, 0.00195233f, 0.04003999f, -0.07068887f, 
    0.01357869f, -0.02538800f, -0.00939242f, 0.05736497f, -0.07096216f, -0.04982718f, 0.02545736f, 0.06146128f, 
    0.00088147f, -0.02949929f, 0.01841160f, 0.05335442f, 0.01305698f, -0.03180978f, -0.01217234f, -0.04860746f, 
    -0.06732916f, 0.05028343f, -0.06101856f, 0.03139231f, 0.02020338f, 0.00607269f, 0.03684303f, -0.06022302f, 
    -0.02327893f, -0.01748810f, -0.03642753f, 0.05408328f, -0.03280694f, 0.01633887f, 0.00790688f, 0.05547412f, 
    0.05945887f, -0.08372643f, -0.01853609f, -0.02048701f, 0.03735870f, -0.04027761f, -0.04097860f, -0.07016139f, 
    -0.06223272f, 0.03654214f, -0.02450059f, -0.03727866f, -0.04402165f, 0.01352554f, 0.04883909f, -0.02435068f, 
    0.01021782f, 0.00573874f, 0.00573884f, -0.01436982f, -0.06710952f, -0.02775018f, -0.03607446f, -0.01667563f, 
    -0.00569778f, -0.00560894f, -0.00821439f, -0.02693810f, 0.04954483f, -0.01797546f, -0.07233407f, -0.04575041f, 
    -0.07824931f, 0.04513001f, 0.04897333f, 0.06539789f, 0.00326644f, 0.02970860f, -0.02702188f, -0.03752312f, 
    0.02264631f, -0.01479938f, -0.06611051f, 0.03793697f, -0.03298083f, -0.01006988f, 0.01418797f, -0.04609937f, 
    -0.07041048f, -0.04664753f, 0.00872106f, -0.03722173f, 0.05736225f, 0.04841356f, -0.05793236f, -0.03382524f, 
    0.00593470f, -0.07834977f, 0.04033732f, 0.00200274f, -0.02577622f, -0.06695016f, -0.04889621f, 0.02150026f, 
    0.01437820f, -0.05493887f, 0.03210918f, -0.06590622f, -0.00136848f, -0.02249286f, -0.00783242f, -0.05562622f, 
    0.04100287f, 0.06187356f, -0.01196800f, -0.07058556f, 0.03973860f, -0.06871157f, -0.07449003f, -0.03411969f, 
    -0.03087014f, 0.04352460f, -0.06687528f, -0.05526070f, 0.01917115f, 0.03681759f, 0.05726499f, 0.03049357f, 
    -0.02774913f, -0.04138463f, -0.07967829f, -0.02092929f, -0.05500747f, 0.05943479f, 0.03875341f, -0.02666945f, 
    -0.06101535f, -0.03003682f, -0.07168236f, 0.03301271f, -0.04860075f, 0.05852510f, -0.05720711f, 0.02435743f, 
    -0.06763005f, -0.00443574f, -0.03110270f, -0.06895945f, -0.04623670f, 0.04726356f, 0.00971404f, 0.00613805f, 
    -0.00652951f, -0.05839315f, -0.03346387f, -0.02042328f, -0.02744709f, -0.03306991f, 0.03214822f, -0.05604161f, 
    -0.03681748f, -0.02499119f, 0.04928558f, -0.01548683f, 0.05834536f, 0.00357907f, 0.03391369f, -0.04867301f, 
    0.00676517f, 0.01104788f, 0.03361390f, -0.03000236f, 0.03578000f, 0.00333373f, 0.05014529f, -0.01501826f, 
    -0.03004537f, 0.03123094f, -0.03215996f, 0.01121568f, -0.07548978f, -0.04680714f, -0.01617508f, -0.05314109f, 
    -0.02151614f, -0.03685080f, 0.04697960f, -0.05198730f, 0.05685606f, -0.02568856f, 0.00358146f, -0.00650965f, 
    -0.01868336f, -0.05859234f, -0.03496380f, -0.05186381f, -0.04932714f, -0.02190777f, 0.00295713f, -0.08698003f, 
    0.02634122f, 0.05206373f, -0.00858412f, -0.02848130f, -0.01479390f, -0.00042467f, 0.02948907f, 0.03084724f, 
    0.05239837f, -0.04384106f, 0.04799011f, -0.04392480f, -0.01392855f, 0.00628841f, 0.03175378f, 0.01209424f, 
    -0.02730333f, -0.06279939f, 0.05824669f, -0.04386686f, -0.00003907f, -0.03216602f, -0.00402405f, -0.00030713f, 
    0.02220939f, -0.07916761f, 0.06509121f, -0.00687008f, -0.00087477f, -0.03544600f, -0.01509600f, 0.07365431f, 
    -0.06745587f, -0.02604815f, 0.05731057f, 0.01847622f, 0.05318315f, -0.03588125f, -0.00981599f, 0.01838435f, 
    -0.07619523f, -0.00423080f, -0.01099887f, -0.01008484f, 0.00952601f, -0.00330969f, 0.00402324f, -0.06517471f, 
    0.05786141f, -0.05659052f, -0.03131102f, -0.07671250f, 0.04196098f, 0.01307673f, 0.05733607f, 0.05189846f, 
    0.02283054f, -0.03484841f, -0.05245926f, -0.07672150f, -0.06231143f, 0.06533641f, 0.05635496f, -0.00225605f, 
    0.03005434f, -0.00483874f, -0.04869316f, -0.02861818f, 0.02226379f, -0.05834153f, 0.03995668f, 0.00586960f, 
    -0.07449747f, -0.04328144f, 0.02543861f, 0.02590889f, 0.00110166f, 0.05766261f, 0.01671547f, -0.06661247f, 
    -0.04280108f, -0.04888682f, 0.05039482f, 0.05738865f, -0.01627186f, -0.02785608f, 0.00272929f, -0.01670863f, 
    0.01441721f, -0.05300004f, -0.00413866f, -0.00724877f, -0.02465797f, -0.06707208f, -0.05683065f, 0.04359840f, 
    -0.02226322f, 0.05131783f, -0.02660143f, 0.02975160f, 0.04194617f, 0.00980700f, -0.05945136f, -0.06275415f, 
    -0.05987808f, -0.07340640f, 0.04844521f, -0.00604129f, 0.05745578f, -0.08001195f, 0.05806077f, -0.07610574f, 
    0.00429329f, -0.07886236f, 0.05407270f, -0.06422991f, -0.06069832f, -0.01532814f, 0.01552018f, -0.00627859f, 
    -0.02600846f, -0.02687636f, 0.00722713f, 0.01664207f, -0.04688752f, -0.06653204f, -0.04273223f, 0.04376926f, 
    -0.00074447f, -0.07716554f, -0.06661023f, 0.04606451f, -0.00095235f, 0.00127755f, -0.03588568f, -0.03189531f, 
    -0.04836101f, 0.03403436f, -0.00245376f, -0.06709783f, 0.06427221f, 0.01067314f, 0.05031916f, 0.02607867f, 
    -0.03046238f, -0.01100631f, -0.01875907f, -0.01754775f, -0.00141213f, -0.07954197f, 0.05288842f, -0.05356643f, 
    0.04118099f, 0.03543042f, 0.06036609f, -0.00004752f, -0.07322989f, -0.05462333f, -0.00624773f, -0.07911761f, 
    0.02721804f, 0.07102501f, 0.10656640f, -0.05397862f, -0.20270231f, -0.01929230f, 0.04656054f, 0.02978175f, 
    0.09322613f, -0.10452154f, 0.04235293f, 0.07578448f, -0.15957549f, 0.04186031f, 0.03774389f, -0.02972659f, 
    0.01135555f, -0.09276620f, 0.07025596f, -0.00915096f, 0.14686514f, -0.04524387f, -0.05325644f, -0.05145211f, 
    -0.16019680f, 0.30497518f, -0.01709302f, -0.01698246f, -0.03723261f, 0.02444191f, -0.05158212f, -0.02548477f, 
    -0.04175169f, 0.11813393f, 0.04947695f, -0.06608957f, -0.34287590f, 0.31435519f, -0.03394140f, -0.09883498f, 
    0.03832590f, -0.00105796f, -0.04760923f, 0.12248067f, 0.05804598f, -0.01011524f, -0.01474508f, -0.17393418f, 
    0.10848203f, -0.17405090f, -0.20852707f, 0.12888114f, 0.10760242f, 0.12524265f, -0.07977018f, -0.07035141f, 
    -0.11570659f, -0.09646435f, 0.06052426f, 0.02303267f, 0.41093713f, -0.51665151f, 0.16304964f, 0.39644831f, 
    -0.06511048f, -0.15094130f, -0.03204866f, 0.17856313f, 0.03997535f, 0.04130138f, -0.04478742f, 0.09066340f, 
    -0.60737932f, 0.10804948f, -0.20487577f, -0.12178389f, 0.04965207f, 0.11004872f, 0.09480806f, 0.12214794f, 
    -0.08978304f, -0.12915796f, -0.01865592f, -0.04574055f, -0.17708768f, 0.27416900f, 0.02191316f, 0.05031792f, 
    0.04095455f, 0.10691847f, 0.04364727f, 0.05026290f, 0.09640002f, -0.06856288f, -0.00767072f, -0.01422599f, 
    -0.10145513f, -0.06908128f, 0.02841355f, -0.09778894f, 0.05610458f, 0.10089584f, 0.15627211f, 0.03761235f, 
    -0.03034791f, 0.03398669f, 0.08225809f, 0.06723290f, -0.02764966f, 0.10772586f, -0.09466945f, 0.14613868f, 
    0.01018045f, -0.10060650f, -0.00879783f, -0.03146146f, 0.05993406f, 0.06569050f, 0.18169473f, -0.10705378f, 
    -0.21502721f, 0.16211237f, 0.03416013f, -0.05639369f, 0.02505576f, -0.03840990f, 0.12832293f, 0.13143677f, 
    -0.01001968f, 0.10663435f, 0.09295883f, -0.08485171f, 0.10309725f, 0.10445439f, 0.17773938f, 0.10398103f, 
    0.00875066f, 0.14205800f, 0.00626165f, 0.14587609f, -0.02907772f, 0.14185718f, 0.23277873f, 0.15857387f, 
    0.23063466f, -0.02333796f, 0.20981394f, 0.25321949f, -0.15860952f, -0.11624527f, 0.04430643f, 0.06002399f, 
    0.16653019f, 0.11963207f, 0.02248165f, 0.08644753f, -0.27337334f, 0.04092183f, -0.00402917f, 0.20528062f, 
    0.09033854f, -0.09074830f, -0.01066068f, 0.09497924f, -0.07039095f, -0.02727826f, -0.18951409f, 0.06672321f, 
    -0.09621034f, -0.22391213f, -0.00272608f, 0.06129878f, 0.01009825f, -0.07272272f, -0.00152696f, 0.07123224f, 
    0.06701729f, 0.08612385f, 0.04802509f, 0.09611002f, -0.04782142f, -0.03072774f, -0.08623366f, -0.08569469f, 
    -0.10688180f, 0.02640501f, 0.10647955f, -0.24087179f, -0.06090678f, 0.03912337f, 0.02290178f, 0.22619106f, 
    0.59708905f, 0.05478852f, 0.11396958f, -0.08271875f, -0.05356520f, -0.16349885f, -0.00042235f, -0.10400315f, 
    0.16680014f, 0.16078581f, 0.16976833f, 0.08791217f, 0.22931899f, 0.16946840f, -0.03634876f, -0.05396955f, 
    0.00187603f, -0.00364134f, -0.06263362f, 0.01183230f, 0.11728937f, 0.03042912f, 0.01708551f, -0.00326175f, 
    -0.27907330f, -0.11452249f, -0.19791219f, -0.29786247f, 0.06358919f, 0.03273963f, -0.11910265f, 0.06445403f, 
    0.21813026f, -0.11653658f, 0.01886421f, -0.14515826f, -0.20155902f, -0.00231228f, 0.19629605f, 0.23213509f, 
    -0.30031002f, 0.17640470f, 0.04683183f, -0.12248916f, 0.01628889f, -0.03227336f, 0.12716047f, -0.02744049f, 
    0.18618406f, -0.31794372f, -0.05592987f, -0.09299622f, -0.04253817f, 0.11161384f, 0.00099574f, 0.09685167f, 
    0.04389931f, -0.04447965f, -0.08815917f, 0.09639604f, 0.15751369f, 0.10470763f, -0.17158751f, 0.10390126f, 
    -0.01079369f, -0.02110135f, -0.10132440f, -0.01474672f, 0.15083730f, 0.01828977f, -0.05374392f, -0.00455374f, 
    0.01286122f, 0.24365939f, -0.01427486f, 0.23800179f, -0.12293535f, -0.03477589f, -0.10684237f, -0.13456452f, 
    0.00590981f, 0.05720788f, -0.05841503f, -0.13890794f, 0.26968068f, 0.16532803f, -0.11857527f, -0.00969004f, 
    0.03204615f, -0.03561276f, -0.08080842f, 0.14087497f, -0.03897599f, 0.07454030f, -0.09869540f, 0.06913184f, 
    -0.19330916f, -0.08745470f, 0.02768962f, -0.04467053f, -0.20941730f, -0.12572965f, -0.15217531f, -0.07675834f, 
    -0.00117306f, 0.00095902f, -0.06054217f, 0.05586030f, 0.02508160f, -0.07322744f, -0.05178878f, -0.05736678f, 
    -0.08634660f, 0.00812964f, 0.01193230f, 0.13934383f, -0.03633559f, -0.16646026f, -0.08283246f, 0.04300204f, 
    0.19843806f, -0.05579245f, -0.04959553f, 0.37463108f, 0.26904199f, -0.11199902f, 0.09323964f, 0.00248810f, 
    -0.07265915f, -0.24440542f, -0.05352272f, 0.08187068f, 0.14068513f, 0.05552944f, 0.03190020f, -0.03574829f, 
    -0.12925035f, -0.03044602f, 0.21034373f, 0.13144486f, -0.06404242f, -0.09070568f, -0.05864877f, 0.00376003f, 
    0.34338582f, -0.12677267f, -0.03774751f, -0.01595697f, -0.17800114f, -0.15048969f, -0.02612240f, -0.08167345f, 
    -0.10559704f, 0.12776348f, 0.16753373f, -0.02998199f, 0.37837020f, -0.05276392f, -0.16057296f, -0.19235289f, 
    -0.01149160f, -0.09808055f, -0.00731491f, -0.17280599f, 0.06462857f, 0.07077178f, 0.12937184f, 0.07574499f, 
    -0.01026456f, -0.24852253f, -0.10304670f, 0.07810052f, 0.11345093f, -0.08056045f, -0.07225350f, 0.04696590f, 
    -0.05354133f, 0.14377354f, -0.07355170f, 0.02636526f, 0.45350119f, 0.11753663f, -0.08126344f, -0.11213625f, 
    0.13963489f, -0.04567910f, -0.10978510f, 0.02035924f, -0.12135987f, 0.21344735f, 0.16820417f, -0.05166956f, 
    -0.05591816f, -0.23335986f, -0.01580112f, -0.01899615f, 0.12475906f, 0.04457529f, 0.09424295f, -0.11292868f, 
    0.05664237f, 0.00491135f, -0.01147802f, 0.09706075f, 0.48132089f, 0.06912813f, 0.06767321f, 0.12632048f, 
    0.03153180f, 0.00376118f, -0.02840370f, -0.07884301f, -0.05103665f, -0.01536238f, -0.13016044f, -0.07199795f, 
    0.26522285f, 0.11863176f, -0.03944251f, -0.03373526f, 0.12968107f, 0.08497252f, -0.19414389f, -0.09989170f, 
    0.06516064f, 0.04956645f, 0.07336836f, 0.16111282f, 0.08167104f, -0.13028096f, -0.25052091f, -0.03253525f, 
    0.08160411f, 0.08832225f, -0.02358198f, 0.10605624f, -0.03982271f, 0.02645414f, -0.06423930f, -0.13768606f, 
    0.22175099f, 0.03882138f, 0.18693365f, 0.02426711f, -0.12154578f, -0.02193648f, -0.09011281f, -0.11692455f, 
    0.05183694f, -0.02825801f, -0.06882644f, -0.06909730f, -0.12743071f, 0.12163241f, 0.08495761f, -0.04930771f, 
    0.16841188f, -0.04091934f, 0.06719338f, 0.00826114f, -0.03635213f, -0.00973252f, 0.02866988f, 0.01856235f, 
    0.21951155f, 0.02721900f, -0.00733414f, 0.08778486f, 0.07036661f, -0.12562002f, -0.06211446f, 0.10899791f, 
    0.11484779f, 0.14056550f, -0.09407876f, 0.04332061f, 0.34905487f, -0.06584398f, 0.06558003f, 0.05688187f, 
    -0.16291353f, 0.12106608f, 0.01000173f, 0.09071994f, 0.14982234f, -0.12197094f, -0.06600993f, 0.01333631f, 
    -0.10970932f, -0.00893816f, 0.00833625f, 0.17956126f, 0.02057249f, -0.15533738f, 0.11036560f, -0.04162380f, 
    -0.05312654f, 0.17202452f, 0.10252219f, -0.01480948f, -0.28308401f, 0.01444605f, 0.02676601f, 0.14236271f, 
    0.17207277f, -0.00482898f, -0.04188034f, 0.01400048f, -0.02248397f, -0.01816722f, -0.09569506f, -0.00139611f, 
    0.08698197f, 0.03409394f, 0.02699540f, 0.04283486f, 0.04772720f, 0.01476135f, -0.12360728f, -0.00197912f, 
    -0.01408591f, 0.04156395f, 0.13303339f, 0.02112513f, 0.00433225f, 0.22544642f, 0.15640269f, 0.02026332f, 
    0.07344761f, 0.02757549f, -0.13656425f, 0.02504211f, -0.16320740f, 0.04398703f, -0.07793129f, -0.00183096f, 
    0.00863022f, -0.19540527f, 0.01402739f, 0.07704202f, 0.06776065f, 0.02141120f, -0.00531802f, -0.15813772f, 
    0.10643531f, 0.04416208f, 0.11623567f, 0.01484704f, 0.11018862f, 0.02305812f, 0.04655943f, 0.13333704f, 
    0.10421854f, -0.15559618f, -0.11817145f, -0.18968169f, -0.08320857f, -0.12759764f, 0.02753546f, 0.05153861f, 
    0.30334646f, -0.26161119f, -0.05673429f, -0.10750633f, 0.02666379f, 0.10364304f, -0.10226912f, -0.14894129f, 
    -0.07502545f, -0.03929113f, 0.07397190f, 0.02425604f, -0.20313324f, 0.07773346f, -0.00703906f, -0.15379487f, 
    0.12324284f, -0.13814574f, 0.08008189f, 0.07165756f, -0.00531291f, -0.01333095f, 0.03759173f, 0.05705892f, 
    -0.38980040f, 0.32821167f, 0.06784768f, 0.09531372f, 0.15463647f, 0.08744260f, -0.05522741f, 0.09168368f, 
    0.12454270f, 0.09390150f, -0.00719758f, 0.06389559f, -0.38984093f, -0.09928659f, 0.17604725f, 0.11298870f, 
    -0.01991652f, 0.02716330f, 0.11429659f, -0.04738390f, 0.07666525f, -0.01534343f, 0.18827024f, 0.13311087f, 
    0.23668765f, -0.02478297f, 0.04318114f, 0.41899949f, -0.05714801f, -0.17155164f, 0.06103195f, -0.10801464f, 
    -0.05714589f, -0.05223282f, -0.12452272f, -0.08033604f, 0.27389699f, -0.39264378f, 0.09835919f, -0.15933512f, 
    0.06900623f, -0.06174365f, -0.00746861f, 0.01493563f, 0.00920990f, -0.02544183f, 0.04044729f, -0.02374648f, 
    -0.29768121f, 0.16185009f, -0.03610478f, 0.09043656f, -0.00434572f, 0.05200390f, -0.07140487f, 0.11469061f, 
    0.06911074f, 0.03596848f, -0.00091247f, -0.03914586f, 0.16001679f, 0.05565036f, 0.18798684f, 0.01269582f, 
    -0.07687958f, -0.07174099f, 0.01485727f, -0.00347308f, -0.09699082f, -0.01219901f, -0.06012663f, 0.07032754f, 
    -0.01183732f, -0.06943770f, 0.02689323f, -0.17922781f, -0.06993280f, -0.04286683f, 0.04634478f, 0.07995510f, 
    -0.07809964f, 0.02960257f, 0.01452335f, 0.01543869f, -0.19168656f, -0.14250886f, -0.08596035f, 0.06279960f, 
    -0.02822872f, -0.18380614f, 0.04651587f, 0.03292971f, -0.08782744f, -0.00091398f, 0.16803543f, -0.04781957f, 
    0.15922874f, -0.04567078f, 0.01121931f, -0.09966724f, 0.05106220f, 0.00805370f, 0.10774191f, -0.03532730f, 
    -0.04447667f, 0.06351081f, -0.06135615f, 0.13686390f, 0.04087787f, 0.10108135f, 0.01065803f, 0.13530833f, 
    -0.04631961f, 0.02119935f, 0.06559239f, 0.04019595f, 0.11181924f, 0.14753582f, 0.04201681f, -0.15051909f, 
    -0.26142433f, 0.11778028f, 0.03724515f, -0.11058021f, -0.07808705f, 0.03350878f, 0.10570094f, 0.03069334f, 
    0.07401413f, 0.04856299f, -0.04500993f, 0.06240800f, 0.17731684f, 0.11007193f, 0.10814402f, 0.19796111f, 
    0.03068045f, 0.12434978f, -0.02353472f, 0.04378723f, 0.05699150f, 0.08602026f, 0.13379513f, 0.04375873f, 
    0.01228773f, 0.48124376f, 0.05810505f, -0.17478529f, 0.11612466f, 0.00784807f, -0.04532919f, -0.02957979f, 
    -0.04551561f, -0.11225905f, -0.08109024f, -0.12848072f, -0.03508355f, -0.09005639f, 0.21764335f, -0.03305735f, 
    0.06238583f, 0.10801619f, 0.01005607f, 0.14708152f, 0.07641602f, 0.11315995f, -0.06234598f, 0.08911209f, 
    -0.18231170f, -0.14854303f, 0.25069413f, -0.24631335f, -0.07715366f, 0.03546743f, 0.06688923f, 0.02064628f, 
    0.09874891f, 0.07648900f, -0.09293092f, -0.05224109f, -0.10550392f, -0.19279738f, 0.00817740f, 0.06029705f, 
    -0.10905045f, 0.09798586f, -0.02217704f, -0.07175572f, -0.08080535f, -0.05096259f, -0.02605665f, -0.04077376f, 
    -0.02630547f, 0.13104285f, 0.27783895f, -0.02382629f, -0.16173433f, -0.07452780f, 0.05920149f, -0.02912169f, 
    -0.05680940f, 0.12369401f, -0.09434416f, 0.06705083f, 0.20679773f, -0.14449090f, -0.27734956f, -0.07586464f, 
    0.19400965f, 0.05949947f, 0.13006461f, 0.20377867f, -0.00927166f, 0.08480989f, -0.07499480f, 0.02736730f, 
    0.43861994f, -0.22518790f, -0.04860940f, 0.00539285f, 0.18977620f, 0.03866677f, -0.04687104f, -0.08606625f, 
    -0.00417219f, -0.00476300f, 0.09319381f, -0.02501950f, -0.25675446f, -0.08083713f, -0.34713808f, 0.24830781f, 
    -0.05639444f, 0.05544702f, -0.11676889f, 0.03970691f, -0.04934121f, -0.05069927f, -0.08789549f, -0.05844738f, 
    0.00596367f, -0.08259832f, 0.10591850f, -0.08942442f, -0.16808540f, -0.00145434f, 0.11611409f, -0.03361348f, 
    -0.03463714f, 0.22399633f, 0.01690111f, -0.04388209f, 0.16362391f, 0.26328236f, 0.27742621f, 0.13502932f, 
    -0.09411713f, -0.02292415f, 0.01032523f, -0.06322624f, 0.06835422f, 0.03511476f, 0.32008985f, 0.13389289f, 
    -0.12008923f, 0.02268469f, -0.16163750f, 0.17358731f, 0.09986205f, 0.13308382f, -0.03168569f, 0.04827415f, 
    -0.07066229f, 0.00873211f, -0.05853589f, -0.18914272f, 0.20320858f, -0.03614868f, -0.11318029f, -0.06510370f, 
    0.11158051f, 0.20350304f, -0.13024744f, 0.11165985f, 0.01955894f, 0.18089837f, 0.19808993f, 0.01019343f, 
    -0.31606314f, 0.00826152f, -0.11078276f, 0.11519044f, 0.06207826f, -0.02030291f, -0.13565728f, -0.17716987f, 
    0.06219072f, -0.06379601f, 0.12832418f, -0.17458941f, -0.08949718f, -0.31814653f, -0.01107636f, -0.12464510f, 
    0.04717284f, 0.16181168f, 0.14543080f, 0.07421649f, -0.12084692f, 0.12551901f, 0.08001189f, -0.04267743f, 
    -0.21461266f, 0.02259188f, -0.16765884f, 0.08769140f, 0.22578309f, 0.18174593f, -0.02246491f, 0.13005112f, 
    0.12116404f, -0.14100720f, -0.08124954f, -0.09329742f, -0.48447934f, -0.21386355f, -0.20057194f, -0.15839604f, 
    0.23193502f, 0.07706505f, 0.04892073f, 0.01666668f, 0.06923922f, 0.11774248f, -0.33410305f, -0.13404895f, 
    0.21955423f, 0.25078258f, 0.32075456f, 0.15066178f, 0.01782648f, -0.04213018f, -0.01347267f, -0.12322489f, 
    0.16819058f, 0.13626543f, 0.19928183f, 0.13059430f, 0.30627748f, 0.25003609f, 0.15406279f, 0.08481701f, 
    -0.16076139f, -0.03455610f, -0.00468389f, -0.07556219f, 0.06182967f, 0.02034411f, 0.13021782f, 0.03781807f, 
    0.37320128f, -0.12923825f, 0.15454775f, 0.12454756f, -0.14657550f, -0.15838349f, -0.14070834f, -0.11333048f, 
    0.02106741f, 0.09857980f, 0.10028552f, -0.08309051f, -0.18514840f, 0.15851481f, 0.17959972f, 0.02206055f, 
    -0.18285021f, -0.16185032f, 0.05297472f, 0.11069152f, -0.11499816f, -0.06792402f, 0.04954428f, -0.12552115f, 
    -0.01346515f, -0.05142938f, -0.06485087f, -0.07247782f, 0.05424304f, -0.05767195f, 0.02264453f, 0.01250502f, 
    -0.00322552f, 0.05455882f, -0.07681830f, 0.00905956f, -0.00507721f, -0.04000654f, -0.03824664f, 0.02177564f, 
    0.03373764f, 0.01542311f, 0.03526613f, 0.03274711f, -0.04831505f, -0.04482808f, -0.01062683f, -0.04388105f, 
    -0.04566900f, -0.05144744f, -0.06943925f, -0.00010076f, 0.06518180f, 0.00310816f, -0.02022951f, -0.05442518f, 
    -0.04218069f, 0.00025851f, -0.02376323f, -0.06702302f, 0.04359324f, -0.05057387f, 0.05414515f, 0.05558860f, 
    -0.01459322f, -0.03716011f, -0.05941897f, 0.01515581f, 0.04541411f, -0.05396190f, 0.02500414f, -0.02036570f, 
    -0.00804612f, -0.03574736f, 0.04035897f, 0.05517572f, -0.06831397f, 0.03580116f, 0.02446713f, 0.05992532f, 
    -0.00925188f, 0.00842662f, -0.01339240f, 0.05468674f, -0.04422212f, 0.02443703f, 0.03594899f, 0.04347157f, 
    -0.00672561f, -0.02881888f, -0.06400585f, -0.07050332f, -0.07072063f, -0.05260962f, -0.00292536f, 0.06087400f, 
    0.01593786f, -0.05440467f, -0.04391308f, -0.06138525f, -0.03448588f, -0.02410234f, 0.00535648f, 0.01098560f, 
    0.00808137f, 0.00545695f, -0.07086397f, -0.06994732f, -0.04579020f, 0.03116054f, -0.03745110f, 0.05621907f, 
    0.04105204f, -0.00891071f, -0.07726801f, -0.07012288f, 0.05438768f, -0.01182520f, -0.00465576f, 0.04992672f, 
    -0.02236021f, 0.00381923f, 0.02522996f, 0.01027861f, 0.05670457f, 0.03469162f, 0.03243589f, -0.02680985f, 
    -0.04794848f, 0.00314468f, -0.07344983f, 0.06315225f, -0.03803817f, 0.00811750f, 0.03262476f, -0.02522451f, 
    0.00284924f, -0.05811981f, -0.07275831f, 0.03575347f, 0.06001026f, 0.02080106f, -0.05525843f, -0.05268179f, 
    -0.04777396f, 0.04121375f, -0.01594714f, 0.05389641f, -0.01300367f, -0.07715078f, -0.02083591f, 0.00240610f, 
    0.03530372f, -0.03502599f, -0.06910086f, 0.01343851f, 0.04372804f, 0.01529631f, -0.03230477f, 0.03996071f, 
    -0.01712044f, 0.01746751f, -0.07852831f, -0.02313451f, 0.05104059f, 0.05636888f, 0.01079430f, 0.00635934f, 
    0.01255471f, -0.07772735f, -0.06401461f, -0.06522746f, -0.01259219f, -0.02849921f, -0.02385982f, -0.05615103f, 
    0.05708241f, -0.04546532f, -0.01584338f, 0.01622027f, 0.02708970f, -0.05899032f, 0.01954180f, 0.04805632f, 
    -0.01881267f, 0.05529941f, 0.01985317f, -0.01021036f, 0.00969672f, -0.05111070f, 0.00054977f, -0.00766413f, 
    -0.03522530f, -0.05001841f, 0.03568587f, -0.06695182f, 0.01624661f, -0.08191758f, 0.05151053f, 0.05617026f, 
    -0.05779638f, -0.01691506f, -0.02679904f, 0.05178344f, 0.01760953f, -0.06296307f, -0.05796004f, 0.05897570f, 
    0.05990956f, -0.02163823f, -0.07128832f, -0.00214593f, 0.05741710f, -0.06341338f, -0.05515063f, -0.02145291f, 
    -0.01419580f, 0.00507369f, -0.05814552f, -0.10171884f, 0.01384293f, -0.11026930f, -0.01910572f, 0.11095668f, 
    -0.14323318f, 0.09125261f, -0.02313970f, -0.02691508f, 0.13192186f, 0.19739892f, 0.09960935f, -0.10628912f, 
    0.10953116f, 0.06735099f, 0.10941781f, 0.02752277f, -0.05267520f, 0.09029298f, 0.05176963f, 0.10950869f, 
    -0.05449545f, -0.05367855f, 0.05417693f, -0.11597712f, 0.03141050f, -0.03088607f, 0.11972500f, -0.01264479f, 
    -0.08728659f, -0.10525824f, -0.04642372f, 0.02834299f, 0.16592132f, 0.19463527f, -0.05298221f, 0.08857211f, 
    0.05981845f, 0.24040645f, 0.00373298f, -0.00132722f, -0.08530028f, 0.11704551f, 0.00064396f, 0.11305635f, 
    0.04538191f, 0.09839756f, 0.01921908f, -0.04387902f, -0.19971809f, 0.00646443f, 0.02015524f, -0.06233273f, 
    0.07073677f, 0.22569260f, 0.09322970f, 0.01649587f, -0.16958500f, 0.19813906f, 0.02887365f, 0.01702528f, 
    0.09557974f, 0.12672555f, -0.05394634f, -0.12709405f, -0.13066727f, 0.07827181f, -0.04617748f, -0.15512888f, 
    0.60015482f, -0.08549882f, 0.22861649f, 0.17311350f, -0.19380912f, 0.09319259f, -0.05376540f, -0.06632444f, 
    0.09521642f, -0.01848995f, 0.07707459f, 0.00027270f, 0.26477471f, -0.08030442f, 0.21540594f, -0.06410441f, 
    0.00391756f, 0.09388600f, -0.10276554f, 0.04352823f, 0.03690317f, 0.04078598f, 0.16438098f, 0.03337296f, 
    -0.00677353f, 0.03278168f, 0.02616114f, 0.02367009f, 0.09681908f, 0.02523907f, -0.12924504f, 0.08466560f, 
    -0.02429659f, 0.09635419f, -0.05270486f, 0.03599927f, 0.46494007f, 0.19298874f, 0.07870686f, -0.13903911f, 
    0.04530486f, -0.03603608f, -0.03310387f, 0.15971377f, 0.02533119f, 0.02932456f, 0.03218171f, 0.12624173f, 
    0.05374574f, 0.01873711f, 0.13557470f, -0.04292713f, -0.01403122f, -0.03010713f, 0.01109555f, 0.06753504f, 
    -0.04257181f, -0.10281323f, -0.09953705f, 0.10125944f, 0.07517233f, 0.08255785f, 0.09356324f, 0.04573871f, 
    -0.12829423f, -0.11162109f, -0.00852006f, -0.14335376f, -0.07407482f, -0.04272463f, -0.09786034f, -0.10775512f, 
    -0.19241063f, -0.22335006f, -0.05189343f, 0.06087417f, -0.09252924f, -0.08551290f, -0.01283982f, -0.12181387f, 
    -0.11078189f, -0.05398621f, -0.03204866f, -0.14760217f, 0.07024083f, -0.08485335f, -0.10481068f, 0.13790427f, 
    -0.01083455f, 0.10781324f, 0.15023318f, -0.01142611f, -0.07042968f, -0.00020341f, 0.09045922f, -0.02763576f, 
    0.15585534f, -0.01641735f, 0.06256332f, 0.30199569f, -0.04863325f, -0.01757332f, 0.00320892f, -0.06190207f, 
    -0.00822550f, 0.04401454f, -0.17498358f, -0.22852600f, -0.14908487f, -0.08173897f, 0.02551161f, 0.03519451f, 
    -0.06647812f, 0.10017273f, 0.07455938f, 0.08405709f, -0.05009130f, -0.03356431f, 0.01008619f, -0.06328648f, 
    0.21345118f, 0.02788521f, -0.05716502f, 0.12529680f, 0.03796847f, 0.06233445f, 0.05873708f, 0.04886241f, 
    -0.10775036f, 0.05742620f, -0.04707769f, -0.06986766f, 0.09224097f, -0.15850210f, -0.19283758f, -0.04532289f, 
    0.14489982f, 0.04769971f, -0.11293272f, -0.08112803f, -0.07991467f, -0.00400466f, -0.00216858f, -0.06328516f, 
    -0.07922778f, -0.06936003f, 0.14377479f, -0.03536936f, 0.10921904f, 0.06547978f, -0.02756083f, 0.08596431f, 
    0.08402676f, -0.14961070f, 0.08420791f, 0.06171065f, 0.19581629f, -0.25618020f, 0.10794998f, 0.18820037f, 
    -0.11571423f, 0.04847206f, 0.04418468f, 0.01836597f, -0.08768011f, -0.12766859f, -0.03672127f, 0.02951241f, 
    -0.05941922f, -0.00213239f, 0.28175661f, -0.05078029f, -0.02732678f, -0.12457523f, 0.11678807f, -0.12018616f, 
    0.07458540f, -0.02814423f, -0.15574530f, 0.11586197f, -0.01769425f, 0.35244092f, -0.00825440f, -0.22990640f, 
    -0.02110081f, 0.02226087f, -0.00110003f, -0.04186897f, 0.12418429f, -0.07131448f, 0.06011043f, 0.13693294f, 
    0.16511586f, 0.02811453f, -0.09023270f, 0.13284691f, 0.07888474f, -0.08509733f, 0.02756064f, -0.03356822f, 
    -0.00920863f, 0.15682368f, -0.05858549f, 0.05903439f, 0.05224753f, -0.09801663f, -0.09550442f, -0.13378789f, 
    0.06055509f, 0.07928143f, 0.04947514f, 0.07609265f, -0.03152639f, 0.04914709f, 0.09448217f, 0.09883175f, 
    -0.03727622f, -0.04283023f, -0.10244076f, 0.19743875f, -0.04289125f, -0.11600813f, -0.03420202f, 0.00852955f, 
    -0.00975386f, -0.00249873f, 0.08257195f, -0.04073748f, -0.54092193f, -0.21837497f, 0.13691978f, -0.03841816f, 
    -0.01806711f, 0.02127810f, 0.02472080f, -0.08938646f, 0.04119648f, -0.08999880f, -0.08349670f, 0.08528343f, 
    0.24393010f, 0.07109848f, -0.06191258f, 0.09864195f, 0.10552515f, 0.08120486f, -0.15112045f, -0.08888929f, 
    0.02183351f, -0.09010071f, -0.02904252f, -0.03801119f, -0.08860444f, 0.08341391f, -0.19623810f, 0.05788134f, 
    0.11782026f, 0.04118234f, 0.01386974f, 0.10283864f, -0.03255994f, 0.08668797f, -0.00438971f, -0.03452678f, 
    0.21696398f, 0.05880021f, 0.03447212f, -0.14713146f, -0.02539648f, 0.08681397f, 0.05727253f, 0.02723849f, 
    -0.10963564f, -0.06840216f, 0.01424290f, -0.04207270f, 0.43181974f, 0.06682257f, 0.14222062f, -0.10342137f, 
    0.06367742f, -0.04393955f, 0.03210847f, -0.04965821f, 0.08287007f, 0.02203912f, 0.23496258f, 0.11802878f, 
    -0.02344322f, -0.13207366f, 0.02865560f, -0.14797997f, 0.08914696f, -0.03093335f, -0.05655844f, 0.04522946f, 
    0.02046248f, -0.00079029f, 0.10343421f, -0.06139464f, 0.39562312f, 0.07815188f, 0.06312703f, 0.10221941f, 
    0.00459038f, 0.00061532f, 0.00824113f, 0.09106584f, 0.04933665f, 0.01031286f, -0.07587829f, 0.00882057f, 
    0.00799144f, -0.02204421f, -0.06114350f, 0.01622528f, 0.01363536f, -0.08990361f, 0.02217561f, -0.05810652f, 
    0.09181021f, -0.02711065f, 0.00499758f, 0.02393416f, -0.07364238f, 0.27365652f, 0.16950594f, 0.31954417f, 
    0.01489420f, 0.03950206f, 0.07188851f, 0.04963434f, 0.03776504f, -0.04150458f, 0.00130780f, -0.13230579f, 
    -0.09367633f, 0.22191004f, -0.05149068f, -0.06583599f, -0.10106684f, 0.05666196f, -0.00799637f, 0.06991916f, 
    0.01217153f, 0.06768925f, -0.08068547f, -0.03497590f, 0.11415965f, 0.10867041f, 0.11560036f, 0.17959350f, 
    0.05726189f, -0.08305202f, -0.09152118f, -0.03253794f, 0.09282088f, -0.01171118f, -0.05870047f, 0.03180030f, 
    0.10359399f, 0.07051127f, -0.10695367f, -0.15558641f, 0.12554459f, 0.18137985f, 0.01028572f, 0.08014085f, 
    -0.08434688f, -0.05760899f, 0.00373337f, 0.01427833f, 0.11041880f, -0.24952574f, -0.10336890f, 0.02550033f, 
    0.14111602f, -0.01803400f, 0.03569341f, -0.05499388f, -0.13261436f, 0.07236253f, 0.00385638f, -0.03095020f, 
    -0.28146586f, 0.00531252f, 0.03647362f, -0.21854790f, -0.11771961f, 0.16006111f, -0.15381065f, 0.13820444f, 
    0.03782371f, -0.01755357f, -0.06046215f, -0.03587060f, -0.21511118f, 0.17258516f, 0.02980447f, -0.00910725f, 
    -0.03273286f, -0.11689568f, -0.01778108f, 0.12102997f, 0.02923647f, 0.09576637f, -0.11298297f, -0.06606911f, 
    0.13673174f, -0.06223627f, 0.10362632f, 0.20293862f, 0.00693038f, 0.00590699f, -0.03693863f, 0.04953187f, 
    -0.00421722f, -0.06182057f, -0.14036064f, -0.06988012f, 0.27803981f, 0.20720543f, 0.00727696f, -0.02951396f, 
    0.08065071f, 0.11248489f, -0.08286722f, 0.07456841f, 0.09251340f, 0.01274375f, 0.13470827f, -0.06721499f, 
    -0.27337411f, 0.06582025f, 0.20950004f, -0.00659843f, -0.08047857f, 0.01548516f, 0.02932869f, 0.00043990f, 
    0.06534018f, 0.10611460f, 0.09309158f, 0.00884262f, 0.27222261f, 0.04698048f, 0.09565694f, 0.18565890f, 
    0.03798607f, 0.12032840f, -0.04627888f, -0.02698867f, 0.17025831f, -0.06495636f, -0.08863640f, -0.08424155f, 
    -0.12915739f, -0.10804976f, -0.08270585f, 0.03886240f, -0.00383828f, -0.07301110f, 0.01790500f, 0.03261512f, 
    0.13303059f, -0.00787621f, -0.06964218f, 0.20449083f, -0.19442454f, -0.21414807f, -0.10821011f, 0.06684788f, 
    0.00802640f, 0.06463746f, -0.09379308f, 0.00654921f, -0.01796219f, 0.03611048f, -0.13532430f, -0.00553450f, 
    0.08156072f, -0.07328732f, -0.04059657f, 0.15743773f, 0.04103215f, 0.06345644f, -0.07038003f, 0.05753817f, 
    0.02537109f, 0.11467055f, -0.03598683f, 0.05052220f, -0.14146438f, 0.02101328f, -0.02463620f, 0.11937104f, 
    -0.02361948f, -0.11054289f, 0.03087115f, -0.13705225f, 0.11140525f, 0.03340546f, 0.06359515f, 0.07425376f, 
    0.12369585f, -0.24547070f, 0.02357368f, 0.01222281f, 0.09201445f, -0.11622831f, 0.07079896f, -0.03670702f, 
    0.12755400f, 0.00422625f, 0.08993717f, -0.00480050f, 0.00982686f, 0.07371940f, -0.19727765f, -0.08971643f, 
    -0.02536106f, -0.04089958f, -0.07261290f, -0.08290630f, 0.04247790f, -0.05924343f, 0.04738116f, -0.02463468f, 
    -0.25096244f, 0.17988674f, -0.03889951f, -0.06529307f, 0.02732961f, 0.14895371f, 0.09893337f, 0.03039748f, 
    -0.03565649f, -0.05657377f, 0.06599897f, -0.08919561f, -0.21122262f, 0.11998577f, -0.27843684f, -0.12449670f, 
    -0.12234197f, 0.21741834f, -0.02739098f, 0.08904666f, 0.07608771f, 0.01933860f, -0.06387650f, -0.03049812f, 
    0.13404199f, -0.18329890f, 0.11421236f, 0.11431110f, -0.08265690f, 0.01078268f, 0.04628782f, -0.02812378f, 
    -0.02704854f, -0.10188050f, -0.07861171f, 0.09508058f, -0.08855775f, 0.02447048f, 0.15204167f, -0.09583424f, 
    -0.09699620f, 0.01881303f, 0.10034796f, 0.15490973f, 0.07926876f, 0.12255362f, 0.10344040f, 0.02033891f, 
    -0.14878096f, 0.08654092f, -0.13383177f, -0.12935434f, 0.01637306f, -0.09538405f, 0.10935130f, -0.08620521f, 
    0.09515810f, 0.05952555f, -0.01296354f, 0.06236215f, 0.08779439f, -0.08908052f, 0.02218157f, 0.05787525f, 
    -0.01183062f, 0.09768003f, -0.03685149f, 0.22090386f, 0.11881177f, -0.00512508f, 0.09638242f, 0.10041055f, 
    0.11879022f, -0.03408624f, -0.08367483f, -0.10628320f, -0.03476027f, 0.03303617f, -0.01648449f, -0.12851250f, 
    0.04772213f, 0.01582899f, 0.13011689f, 0.03192027f, 0.13367502f, -0.21632214f, -0.07461302f, 0.10399061f, 
    -0.16191755f, -0.02251480f, 0.01497307f, 0.08550077f, -0.11330449f, 0.14176986f, -0.08460282f, -0.13992219f, 
    0.33029240f, 0.11388843f, -0.16237877f, 0.09423322f, 0.07609539f, 0.04271519f, -0.04140149f, 0.08360216f, 
    -0.07763745f, -0.07189563f, 0.05939487f, 0.00669682f, -0.20398219f, 0.13650975f, -0.20065211f, -0.20156334f, 
    -0.07229073f, -0.01976891f, 0.00995327f, -0.08563818f, 0.03287522f, 0.07274418f, 0.05462348f, 0.00956912f, 
    0.30074701f, -0.13915625f, 0.18538345f, -0.18965927f, -0.00617489f, 0.09669585f, 0.05038043f, 0.06971830f, 
    0.07702873f, -0.00710728f, 0.08649568f, 0.02869955f, 0.35330907f, 0.22074626f, -0.02082508f, -0.16422412f, 
    0.02426669f, -0.00402992f, 0.02776787f, -0.01663426f, -0.01805699f, -0.02162366f, -0.02691875f, 0.04429061f, 
    0.39276037f, 0.00135045f, -0.06852622f, -0.11375132f, -0.00421013f, 0.08983035f, -0.02699598f, -0.00231463f, 
    -0.03177570f, 0.07868943f, 0.08276030f, 0.05768076f, 0.05612848f, 0.04122119f, -0.04643280f, 0.15547371f, 
    0.16511543f, -0.02472460f, 0.08183589f, -0.00611949f, 0.03920303f, 0.13618903f, 0.13546078f, 0.01966987f, 
    0.01947182f, -0.01193563f, 0.04107118f, 0.05301880f, -0.05556042f, -0.00070634f, -0.05343143f, -0.02281835f, 
    -0.02030062f, -0.01179165f, -0.06958506f, -0.01297296f, 0.01349244f, -0.06102756f, -0.03857488f, 0.05840620f, 
    0.00413808f, -0.00441036f, -0.00980754f, 0.06613964f, -0.04504531f, 0.00200884f, -0.02936202f, -0.05597968f, 
    -0.07397407f, 0.03340336f, -0.05557593f, -0.04398628f, 0.03854682f, 0.01605362f, 0.03993957f, 0.04671169f, 
    -0.02070790f, -0.04747432f, -0.04753466f, -0.01704550f, 0.03997513f, -0.06650977f, -0.04319182f, -0.01187970f, 
    -0.01629601f, 0.06255943f, 0.01577944f, -0.05783683f, -0.06983338f, -0.03324459f, -0.01257475f, -0.05763609f, 
    -0.05235228f, -0.01223909f, 0.06498069f, 0.06802575f, -0.04524442f, -0.05416911f, -0.04445291f, 0.06146878f, 
    -0.02096326f, -0.04709974f, -0.00284368f, -0.02164562f, -0.06620713f, 0.01830833f, 0.00850626f, -0.02919000f, 
    0.04424595f, 0.04781533f, -0.07271954f, -0.06821664f, -0.05510161f, 0.00062970f, -0.01275284f, -0.06781641f, 
    -0.01325132f, -0.03166587f, -0.06523273f, -0.06121482f, -0.01522999f, 0.01141769f, -0.01182294f, 0.01178159f, 
    0.05423961f, -0.04842891f, 0.02385541f, -0.00281161f, 0.05382349f, -0.04435295f, -0.06574729f, 0.05891699f, 
    -0.03974847f, -0.01760076f, -0.05398087f, 0.01588534f, 0.00300881f, 0.02106726f, 0.01225102f, -0.06718946f, 
    -0.01358232f, -0.00649306f, -0.06693082f, 0.04859059f, 0.01782769f, 0.01260102f, -0.00633222f, -0.04889194f, 
    0.04264763f, -0.06315637f, -0.02457094f, 0.02867370f, 0.03231042f, -0.02319574f, -0.05912402f, -0.05086802f, 
    -0.00888398f, 0.03178949f, 0.00596394f, 0.06563896f, -0.05688357f, -0.01076864f, 0.04217719f, 0.05034081f, 
    0.00555846f, -0.04426884f, -0.03232005f, -0.05072140f, 0.04040222f, -0.00070819f, -0.06816087f, -0.02227192f, 
    0.06467608f, 0.06606023f, -0.07232562f, 0.03683334f, -0.07496137f, -0.07010283f, -0.05157042f, -0.03937484f, 
    -0.01306752f, 0.01410727f, 0.04472797f, 0.03445192f, 0.01392892f, -0.06592003f, 0.05943785f, -0.02730130f, 
    -0.05886282f, 0.04389076f, 0.03376009f, -0.00627996f, 0.00165759f, 0.01280565f, -0.05739453f, -0.03243724f, 
    0.05943856f, 0.06293360f, -0.03856011f, 0.00119304f, -0.01401013f, -0.06697074f, -0.04887695f, -0.06280432f, 
    0.03893717f, -0.06286049f, -0.04949563f, 0.05811672f, -0.04815836f, -0.00259780f, 0.00524236f, -0.05239944f, 
    -0.06327394f, -0.02869685f, 0.04605536f, 0.01659943f, -0.04395790f, -0.02476533f, 0.03799685f, -0.04170934f, 
    -0.04086277f, 0.01315707f, -0.02091040f, 0.01551389f, 0.03636787f, 0.02306773f, 0.02028326f, -0.00868821f, 
    -0.03381371f, 0.02997383f, -0.04379345f, -0.05117193f, -0.02404725f, 0.00078879f, 0.01536287f, 0.05247276f, 
    -0.01980418f, 0.18795778f, 0.04116487f, -0.08610606f, 0.00902806f, -0.03440343f, -0.10773544f, -0.01135441f, 
    0.08846518f, 0.03940305f, 0.02670222f, -0.07714954f, -0.15138021f, 0.13103485f, -0.20132127f, -0.03844559f, 
    -0.00446532f, 0.19038589f, 0.12710086f, 0.13900471f, -0.18083151f, 0.04741871f, 0.33217454f, 0.13156134f, 
    -0.26841685f, -0.29345450f, 0.19186699f, -0.04269708f, -0.04251499f, -0.01164363f, 0.02957417f, 0.09349449f, 
    0.13116792f, -0.06099783f, -0.02575775f, -0.08653556f, 0.02390281f, 0.14263953f, 0.45185682f, 0.29825452f, 
    -0.01265616f, -0.02271529f, 0.13731277f, 0.07003885f, 0.00624443f, 0.12953505f, 0.11220339f, 0.24275716f, 
    0.01724678f, 0.13353147f, -0.28040338f, -0.33883500f, -0.02040579f, -0.15278015f, 0.05021239f, 0.07812440f, 
    0.25157925f, 0.05076558f, 0.06402318f, -0.06367236f, -0.00102673f, -0.11640327f, -0.08147804f, -0.14657788f, 
    0.06966245f, -0.00612470f, -0.00399092f, -0.30595583f, -0.07530662f, 0.06697132f, -0.02915668f, -0.10655817f, 
    -0.11513375f, 0.14297676f, -0.07795111f, 0.03209107f, 0.03756883f, 0.01376047f, -0.00506552f, -0.01730300f, 
    -0.13231565f, -0.00757996f, 0.26753679f, 0.15507226f, -0.28201997f, 0.13138808f, -0.05955645f, -0.09682098f, 
    0.22948278f, -0.06468573f, -0.02968775f, 0.07034393f, -0.24823280f, -0.06601153f, 0.09379050f, -0.05756520f, 
    0.01604374f, -0.05750404f, 0.12219185f, 0.02297346f, 0.11152719f, 0.18028156f, -0.05947554f, 0.00933160f, 
    -0.16944706f, -0.00257647f, 0.02840352f, -0.00450602f, 0.64271754f, 0.00922812f, -0.08043435f, -0.11482488f, 
    0.04165304f, -0.06251143f, -0.13889313f, -0.10819261f, 0.00159976f, -0.09018929f, 0.03557298f, 0.11171710f, 
    0.11967763f, 0.00560233f, 0.04679726f, -0.00731390f, -0.08276766f, 0.00983672f, 0.13899626f, -0.02158559f, 
    0.07545011f, -0.03853357f, -0.08249719f, 0.04092536f, 0.17662142f, -0.17305237f, -0.18012397f, 0.07329838f, 
    0.06569214f, -0.03901875f, 0.05688301f, -0.01686677f, 0.03907844f, -0.01203318f, 0.11786329f, -0.11747383f, 
    -0.16366285f, -0.04023475f, -0.08719585f, 0.02987025f, 0.04279764f, -0.26045534f, 0.03102453f, -0.07179745f, 
    -0.12145792f, -0.01211152f, -0.16587383f, 0.04609180f, 0.00941017f, 0.08561403f, 0.02547002f, 0.02474126f, 
    -0.02128452f, 0.00569084f, 0.00284532f, 0.08898418f, -0.02031114f, 0.16665623f, 0.17660543f, 0.02389699f, 
    0.10036545f, 0.34132147f, -0.01205538f, 0.16679960f, 0.02718777f, 0.07818872f, -0.08655407f, 0.12446668f, 
    -0.01189048f, 0.03725376f, 0.12419016f, -0.12860647f, 0.07675444f, 0.07255781f, 0.32315034f, 0.14062221f, 
    -0.09768163f, 0.14165741f, 0.02900452f, -0.07598859f, 0.03976408f, -0.07700387f, -0.05963518f, 0.03553897f, 
    0.07316212f, -0.14358197f, -0.01270447f, 0.11934888f, 0.08906398f, 0.09501598f, 0.04531807f, -0.07381572f, 
    0.22402021f, 0.02765625f, 0.10436060f, -0.09189008f, -0.05162315f, -0.08795149f, 0.02344227f, 0.00299561f, 
    -0.16894954f, -0.24044169f, 0.02001791f, -0.04854433f, 0.11683339f, -0.07189789f, 0.11611799f, -0.06460330f, 
    -0.19093676f, 0.46898213f, -0.17024590f, -0.10714174f, 0.04059528f, 0.12557913f, -0.01284276f, 0.08110218f, 
    -0.03462797f, 0.05691259f, -0.00830247f, -0.02105740f, -0.21266329f, 0.27396464f, 0.01953777f, -0.16639748f, 
    -0.15924883f, 0.04697317f, 0.12964298f, -0.02401762f, 0.03769480f, -0.14385937f, 0.06335533f, -0.09254341f, 
    -0.13624471f, -0.17041861f, -0.01517898f, 0.06932228f, 0.17011906f, 0.05701342f, -0.08855229f, -0.11267678f, 
    -0.03926390f, -0.15302123f, -0.00179811f, 0.04527991f, 0.15172932f, -0.34965599f, -0.00195258f, 0.37944633f, 
    -0.06223077f, -0.00426220f, -0.12978235f, 0.11635410f, 0.12980142f, -0.02978822f, -0.25733501f, 0.09692800f, 
    -0.19725639f, 0.04061170f, -0.04304457f, -0.01820351f, -0.10938716f, -0.06558039f, 0.03437699f, 0.02725211f, 
    -0.02209303f, -0.02807336f, -0.10469054f, 0.10257161f, 0.08995786f, -0.04253637f, -0.23302360f, 0.12981264f, 
    -0.13507867f, -0.01008339f, 0.07861200f, 0.16018000f, 0.15672326f, -0.09234117f, 0.01295805f, 0.05022756f, 
    0.12356534f, -0.01884629f, 0.02524728f, -0.14450701f, 0.00979369f, -0.00149732f, 0.01609699f, 0.11465245f, 
    0.11245631f, -0.01836578f, 0.06625954f, 0.04664761f, -0.42655197f, 0.09124252f, -0.08997869f, -0.00462983f, 
    0.07078682f, 0.06370131f, -0.02661410f, 0.17107441f, -0.00333582f, 0.12696296f, 0.00970499f, -0.05376605f, 
    0.35661000f, 0.14618075f, -0.05982714f, 0.02283310f, -0.10378926f, -0.06774101f, 0.03333912f, 0.14855030f, 
    -0.12627186f, 0.11524226f, 0.08524878f, -0.01810799f, 0.23144564f, 0.35034573f, -0.03625285f, -0.04233872f, 
    0.01394792f, 0.07247160f, 0.10579119f, 0.09729071f, -0.16336916f, 0.22636390f, 0.17650630f, 0.10089984f, 
    0.15866259f, -0.06252014f, 0.04430704f, 0.00225406f, -0.06301443f, 0.04221534f, -0.02553919f, 0.13128249f, 
    0.05127881f, -0.02546216f, 0.00198010f, -0.02013131f, -0.20835032f, -0.06398975f, 0.06535954f, 0.24376807f, 
    0.03857898f, -0.06787331f, 0.08472141f, -0.02520982f, -0.05012299f, -0.01595911f, -0.09218770f, 0.04128474f, 
    -0.28283808f, 0.10962733f, 0.19254659f, 0.08954348f, 0.13004965f, 0.02339519f, -0.03451060f, 0.01260910f, 
    -0.10448889f, 0.03043391f, 0.01134171f, -0.07636866f, 0.05661390f, -0.26459509f, -0.24557091f, 0.09216260f, 
    0.07452933f, 0.00219853f, 0.06148266f, -0.08581208f, 0.04590562f, 0.29053131f, 0.07161938f, 0.08034778f, 
    0.02694679f, 0.01322379f, -0.06237878f, 0.01239235f, -0.04650174f, 0.00044740f, -0.03967192f, -0.04512630f, 
    0.05352153f, -0.07496425f, 0.04558969f, 0.03777313f, -0.04697502f, -0.05306866f, 0.00995226f, -0.04875853f, 
    -0.06784575f, -0.03338845f, 0.02805683f, -0.01269329f, -0.04604248f, -0.02821183f, -0.05519925f, 0.03218493f, 
    -0.05146964f, -0.04436150f, -0.05506968f, -0.06116643f, -0.07282578f, 0.04573836f, -0.05186655f, 0.00139787f, 
    0.01523016f, -0.06832756f, -0.02241069f, 0.00362284f, 0.03669288f, -0.07037677f, 0.00530377f, 0.03606175f, 
    0.02050648f, -0.00197476f, 0.04241745f, -0.00421131f, -0.03291479f, -0.03569614f, 0.04294154f, 0.00074321f, 
    0.04502801f, -0.06044530f, -0.00793031f, -0.00789838f, 0.05964484f, -0.02887161f, 0.05804770f, 0.04044046f, 
    0.01320114f, -0.02397548f, -0.01697799f, 0.06047923f, -0.08183649f, -0.05525172f, -0.06474335f, -0.00912047f, 
    -0.07118557f, -0.01981713f, 0.05555877f, -0.06799528f, -0.00543919f, -0.02689821f, -0.02453382f, 0.01348954f, 
    0.04169810f, 0.05261647f, -0.03372747f, 0.03648813f, 0.00640191f, -0.05562928f, 0.00678264f, -0.07026803f, 
    -0.01550803f, -0.02582114f, 0.04040626f, -0.06124929f, -0.05450425f, -0.00069305f, 0.05054998f, -0.07672192f, 
    -0.02250048f, -0.05233276f, -0.06227519f, 0.00956645f, -0.05235103f, -0.01193989f, -0.05215046f, 0.00255788f, 
    0.03191120f, -0.06495877f, 0.01571770f, 0.03429480f, -0.02130918f, 0.04841202f, -0.06111766f, 0.04160884f, 
    0.02722155f, 0.04493380f, -0.03932918f, -0.07667786f, -0.04875845f, 0.00081821f, -0.01648222f, -0.07525703f, 
    -0.08271542f, -0.06654146f, -0.00046466f, 0.03963022f, 0.03897720f, 0.02970167f, 0.02940783f, 0.00206159f, 
    0.00141948f, 0.00230409f, 0.05812649f, 0.06438065f, -0.00795307f, -0.01075661f, -0.02667564f, 0.01195409f, 
    -0.03391336f, -0.01563383f, 0.04692852f, -0.02476054f, -0.07013714f, -0.02473290f, -0.04591905f, -0.03592986f, 
    0.02063672f, -0.03123857f, 0.05115156f, -0.02066907f, -0.04634443f, -0.06672371f, -0.06081787f, -0.04759112f, 
    -0.00218180f, -0.01145385f, -0.02691814f, 0.06885862f, 0.01762600f, 0.03639969f, -0.01119150f, -0.06140267f, 
    0.03302392f, 0.01802540f, -0.02994104f, -0.02915165f, 0.02349591f, 0.00213714f, -0.01094217f, -0.00933036f, 
    0.02974409f, -0.05512431f, -0.04019948f, 0.05877731f, -0.00785203f, 0.06401496f, -0.04059377f, -0.02258031f, 
    -0.05557975f, -0.04884936f, -0.03371952f, 0.02649657f, 0.04813509f, -0.07492248f, -0.04495575f, 0.02711882f, 
    0.02060208f, -0.02745836f, 0.04948451f, -0.07478435f, 0.02606639f, 0.03055029f, 0.05816501f, -0.04552278f, 
    0.02801540f, 0.00500909f, -0.02475249f, 0.00387047f, 0.00260269f, 0.04540101f, 0.02696733f, 0.04546292f, 
    0.03293790f, 0.05674696f, 0.05853561f, -0.06340352f, -0.05236154f, 0.04828547f, 0.02831776f, 0.04597652f, 
    0.01329452f, -0.02824140f, -0.03527622f, -0.04169291f, 0.00837907f, -0.04706920f, 0.01767779f, 0.02885828f, 
    -0.00051367f, -0.03112944f, 0.04402300f, -0.03071715f, -0.03596109f, 0.06671125f, 0.02648848f, -0.06521524f, 
    -0.04015494f, -0.01793495f, 0.04515818f, 0.04165582f, 0.00715291f, -0.05120397f, -0.00003151f, -0.04610537f, 
    -0.07195629f, 0.00902994f, -0.02081515f, -0.05891575f, -0.05863484f, 0.03303108f, -0.03747967f, -0.03499428f, 
    -0.04317653f, -0.00840743f, 0.00314019f, 0.02137700f, -0.06327317f, -0.02883966f, 0.00755132f, -0.04444811f, 
    -0.06060358f, 0.01839434f, -0.06663337f, -0.04097835f, 0.02550260f, -0.04734238f, -0.03232067f, 0.05028531f, 
    0.01223380f, 0.01961258f, -0.01489477f, -0.06794933f, 0.03044340f, 0.04993497f, -0.05969551f, 0.01304579f, 
    -0.05890386f, 0.03557471f, -0.02656284f, 0.05631292f, -0.02496105f, -0.04124315f, 0.00331329f, 0.05572553f, 
    -0.03104228f, 0.02972645f, 0.06595823f, -0.03169164f, -0.07169722f, 0.06449302f, -0.02175484f, -0.03012395f, 
    0.02520361f, -0.04650073f, 0.01985816f, -0.05427770f, -0.06087856f, -0.03214480f, -0.01474646f, -0.04384332f, 
    -0.04480260f, -0.04362519f, -0.01063767f, 0.02424024f, -0.07162989f, -0.01682792f, 0.00538951f, -0.01756905f, 
    -0.00661544f, -0.00622665f, 0.00511865f, 0.03262477f, 0.05248057f, -0.05563721f, -0.05379579f, -0.03464693f, 
    -0.03069262f, 0.00123183f, -0.06968098f, -0.02817979f, -0.05554868f, 0.05342375f, -0.03028927f, -0.04572996f, 
    -0.07504849f, -0.06674369f, 0.05666540f, -0.01495635f, 0.00736334f, -0.01541151f, 0.02330501f, -0.05086113f, 
    0.06113115f, -0.01573891f, -0.05821746f, 0.06596591f, -0.02510144f, 0.01081628f, 0.02873840f, -0.01041518f, 
    0.01960262f, -0.04743936f, 0.05635025f, -0.05550478f, -0.02870903f, -0.00860341f, 0.04344794f, 0.03145522f, 
    0.05971697f, 0.05938932f, -0.06345528f, -0.03543406f, -0.05211075f, -0.00230155f, -0.01283497f, -0.00454288f, 
    0.05691916f, -0.06019891f, 0.02653166f, 0.00367937f, -0.00207166f, -0.03195627f, 0.01919363f, -0.06454013f, 
    -0.06416612f, 0.06423507f, 0.04201786f, 0.02739075f, -0.04628292f, -0.02213905f, -0.06631435f, 0.02920122f, 
    -0.04469073f, -0.02370285f, 0.01909779f, -0.04942094f, -0.01965442f, 0.03485026f, -0.04979855f, -0.06378119f, 
    -0.07181920f, 0.03194848f, -0.06651177f, -0.01446372f, 0.01609608f, -0.01215516f, -0.01977868f, -0.03873299f, 
    -0.03706683f, -0.07505340f, 0.01919200f, 0.00222593f, -0.07646248f, -0.07239108f, 0.00996904f, 0.06658887f, 
    -0.05266603f, -0.03609646f, 0.04182862f, 0.06342968f, -0.01907476f, -0.06992030f, -0.02808642f, -0.00913741f, 
    0.12499311f, 0.06628463f, -0.07520050f, 0.20907912f, -0.13746980f, -0.04780242f, 0.01395438f, 0.02482381f, 
    -0.13676931f, -0.04078640f, -0.01013994f, -0.02369523f, -0.22823451f, -0.15187940f, -0.23380464f, 0.18095973f, 
    0.08750758f, 0.01483262f, -0.07641976f, -0.03500675f, -0.07917070f, -0.04828215f, 0.05267041f, 0.06508455f, 
    -0.11196671f, 0.14757937f, 0.02287157f, -0.04158628f, -0.15173140f, 0.02068167f, 0.16797063f, 0.10488271f, 
    -0.00858278f, 0.01848933f, -0.00469039f, 0.19165324f, 0.32617199f, 0.33308589f, 0.24091296f, 0.17533526f, 
    0.04128648f, -0.01360382f, -0.00799753f, 0.08441444f, -0.07248931f, 0.09554646f, -0.10047536f, 0.02101017f, 
    -0.01240623f, 0.12338624f, 0.02325294f, -0.15737793f, 0.03009809f, -0.03372836f, 0.22032215f, -0.00229510f, 
    -0.06976906f, -0.01557763f, -0.07634757f, -0.08951752f, 0.16719204f, -0.10694451f, 0.04855992f, -0.01080699f, 
    -0.06866148f, -0.00509075f, 0.06190545f, -0.05631829f, 0.09894946f, -0.16105331f, -0.05956009f, 0.11838078f, 
    -0.07168520f, -0.04476178f, -0.17590012f, -0.09175586f, 0.08187259f, 0.14128983f, -0.03126633f, 0.04003613f, 
    0.01505209f, -0.02216652f, -0.07491270f, -0.02628577f, -0.27083337f, 0.18871754f, -0.02116370f, -0.14033513f, 
    0.01007362f, -0.00445818f, 0.01110865f, 0.06126926f, 0.00057544f, -0.04267734f, 0.09014671f, -0.06952803f, 
    0.00898012f, -0.05500514f, 0.14054793f, 0.19745080f, 0.04471364f, 0.02015079f, -0.12949459f, 0.16795711f, 
    -0.09958944f, -0.05008027f, 0.07049931f, -0.06913160f, -0.29903463f, 0.25787288f, 0.21666458f, -0.13750789f, 
    0.02315316f, -0.03301799f, -0.00927312f, -0.08949360f, 0.00040382f, -0.11135907f, 0.01351250f, -0.11081729f, 
    -0.16895604f, 0.11509221f, -0.02333562f, -0.07717685f, -0.08374698f, 0.12820861f, -0.18899347f, 0.00516991f, 
    0.08196282f, 0.01700751f, 0.07047118f, 0.00151999f, 0.07289506f, 0.04366320f, -0.03920209f, 0.32242244f, 
    0.03775260f, 0.06804110f, -0.11798730f, -0.00217237f, 0.03400394f, 0.03062366f, 0.03206001f, 0.07314660f, 
    0.00945800f, 0.04240024f, 0.10167556f, 0.08920927f, 0.00278409f, -0.01464078f, -0.05514498f, 0.04352535f, 
    0.06377805f, -0.00893720f, -0.09433340f, 0.00051757f, -0.06067789f, -0.10523871f, 0.11069203f, 0.05371405f, 
    -0.13084745f, 0.27170277f, 0.06573883f, 0.16832963f, 0.00967539f, 0.19516611f, 0.01312828f, 0.05783460f, 
    -0.09109033f, 0.14144440f, 0.20437619f, 0.31862727f, 0.00138865f, 0.08879912f, 0.02281502f, -0.06966487f, 
    -0.08744370f, -0.14956060f, -0.07052442f, -0.08930640f, -0.01531800f, -0.10457294f, 0.08983409f, 0.10829826f, 
    -0.09367801f, -0.06269424f, 0.02547361f, 0.02506362f, 0.01573173f, -0.03470930f, -0.01800455f, 0.01153362f, 
    -0.06652030f, 0.20256582f, 0.10008026f, -0.22713774f, 0.03625052f, -0.00063971f, 0.01869501f, 0.04029761f, 
    0.03165169f, 0.07961480f, 0.01452827f, 0.01129518f, -0.10062891f, -0.01890511f, 0.16061901f, 0.05304335f, 
    -0.08331154f, 0.18187448f, 0.18496393f, 0.29385397f, -0.12529099f, 0.07835359f, 0.11591272f, 0.06375809f, 
    0.16605291f, -0.06934002f, -0.09190650f, 0.11224087f, -0.02891158f, 0.03923808f, 0.05110649f, 0.01448181f, 
    0.04302901f, 0.02126269f, -0.05714965f, -0.02458352f, 0.24361692f, -0.05267297f, 0.24600106f, 0.08998768f, 
    -0.17232208f, -0.03022734f, 0.01915995f, -0.11333562f, -0.01123400f, 0.07804371f, 0.08182171f, 0.17095301f, 
    -0.22305743f, 0.08683351f, -0.09302578f, -0.28904030f, 0.01794815f, 0.17730932f, -0.07832602f, 0.11148135f, 
    0.23157895f, -0.00567200f, 0.00419057f, 0.05633615f, 0.13835984f, 0.11387538f, -0.16656075f, 0.10580133f, 
    -0.01366695f, -0.12217679f, -0.20535736f, -0.17446442f, -0.06405313f, -0.01890519f, -0.10344148f, -0.05371598f, 
    0.30501798f, 0.19464615f, 0.01448227f, 0.05268113f, -0.13074113f, 0.02635078f, -0.00887599f, 0.05369895f, 
    -0.03759585f, 0.01989052f, 0.03603471f, 0.06599846f, -0.16735958f, -0.07082592f, -0.09533697f, -0.10983934f, 
    0.17736709f, -0.08222406f, -0.02563895f, 0.01961727f, -0.07028642f, -0.04073017f, 0.06263191f, 0.04855619f, 
    0.02396123f, -0.00052828f, -0.01259641f, -0.15843840f, 0.03218634f, -0.05399022f, -0.30014777f, 0.02351384f, 
    -0.05276315f, 0.10388096f, -0.16752131f, 0.15072396f, 0.45193234f, 0.33797938f, -0.04198545f, -0.26047537f, 
    0.11166111f, 0.14135231f, 0.04238131f, 0.07605292f, 0.08947335f, -0.05751707f, 0.07202432f, 0.14285976f, 
    0.06548342f, -0.06075325f, 0.13656119f, -0.01994049f, 0.00528752f, -0.00176187f, 0.26080588f, 0.00680184f, 
    0.17054206f, -0.13126017f, -0.24670909f, 0.02558755f, 0.34230158f, -0.16881059f, 0.01139551f, 0.13879076f, 
    0.06664450f, -0.07454450f, 0.11361803f, 0.09155035f, 0.07021318f, -0.14110908f, -0.05927457f, -0.10881374f, 
    -0.10548571f, 0.16780309f, -0.21178289f, -0.14654191f, 0.02882841f, -0.09918977f, -0.02654073f, -0.05315179f, 
    -0.14713764f, -0.14514664f, -0.05544985f, 0.04240704f, -0.19726071f, -0.13881700f, 0.00297805f, 0.13383618f, 
    -0.01876867f, -0.00695089f, 0.01708281f, -0.06824238f, 0.09248753f, 0.07808996f, 0.19532321f, 0.15903895f, 
    -0.16389175f, -0.00237048f, 0.05791822f, 0.05605558f, 0.01368588f, -0.02152031f, -0.12025513f, 0.07609650f, 
    -0.02319468f, 0.09541944f, -0.09067953f, -0.14064433f, -0.06052861f, -0.21554187f, 0.11770541f, -0.00170762f, 
    -0.06665965f, 0.06888622f, 0.01542219f, -0.09630138f, 0.07246470f, 0.11924801f, 0.10422308f, -0.04391455f, 
    0.30351424f, 0.05054178f, -0.14118190f, 0.19469039f, -0.00638953f, -0.00304592f, -0.01136526f, 0.07112639f, 
    -0.01718088f, 0.07368401f, 0.05199358f, -0.03972558f, -0.02029944f, -0.24515466f, 0.01510867f, -0.10478000f, 
    0.07587634f, -0.06365042f, 0.00456172f, -0.20004359f, 0.05137743f, -0.00463824f, 0.03612110f, 0.02321353f, 
    -0.18770708f, 0.10218037f, 0.11234282f, 0.07119218f, 0.05759000f, -0.00968870f, 0.00004953f, -0.02698599f, 
    -0.01836356f, -0.10416836f, -0.05376382f, -0.01783101f, 0.14815232f, -0.01344763f, -0.04160829f, -0.14424051f, 
    0.02543903f, 0.07772235f, -0.03212188f, -0.00134622f, 0.00795206f, 0.04950443f, 0.05810468f, 0.00982441f, 
    0.08068173f, -0.13351321f, 0.15116563f, 0.13087277f, -0.11499371f, -0.03224087f, 0.02983732f, -0.14905088f, 
    -0.01015123f, -0.02666448f, -0.01613954f, 0.08246093f, 0.12424693f, 0.11881427f, 0.24795686f, 0.04906486f, 
    -0.08271895f, 0.11714955f, -0.09175709f, 0.01273123f, -0.06614697f, -0.02399272f, -0.03713173f, 0.03288294f, 
    0.27420288f, -0.13141653f, 0.25794983f, 0.01067838f, -0.09764058f, -0.06339067f, 0.17875376f, 0.01318362f, 
    0.03198260f, 0.00228997f, -0.00205300f, 0.03481689f, 0.22902451f, -0.31636989f, 0.04734470f, 0.02451668f, 
    -0.13369532f, 0.01439292f, -0.01311939f, -0.03673440f, 0.16557366f, 0.02949010f, 0.15654795f, 0.06976576f, 
    -0.04645308f, -0.16503261f, -0.03299545f, -0.05377869f, 0.09945826f, -0.07602512f, 0.02767855f, -0.01409988f, 
    -0.05854245f, 0.03316754f, -0.00843260f, -0.01325572f, -0.21287557f, -0.16210304f, 0.04720147f, -0.04034198f, 
    0.00112848f, -0.03502852f, 0.04207455f, 0.14107262f, -0.04324733f, 0.10139211f, -0.06448717f, 0.00382388f, 
    0.01562697f, 0.02784045f, 0.11994437f, -0.16730389f, 0.00225375f, 0.07417888f, 0.05051409f, 0.04101761f, 
    -0.06880387f, 0.05964497f, -0.04307778f, 0.04595152f, -0.17440674f, 0.26477778f, 0.07001984f, -0.12403069f, 
    -0.11138096f, -0.04865408f, -0.07302421f, -0.06172651f, -0.02693885f, -0.02834209f, -0.04119997f, -0.00460087f, 
    0.27706552f, -0.00336232f, 0.05888688f, -0.02797246f, -0.11790211f, 0.03802705f, -0.01209053f, 0.04371939f, 
    -0.04399235f, -0.00725503f, 0.09732742f, -0.15536195f, 0.40492302f, 0.05225469f, 0.14926410f, -0.06355937f, 
    0.01875144f, 0.02005607f, 0.13766181f, 0.10920477f, 0.02101072f, 0.06961950f, 0.16567859f, 0.02137619f, 
    -0.09550732f, -0.08468926f, 0.10439965f, -0.00394906f, 0.04104144f, -0.01374790f, -0.00039342f, -0.14998479f, 
    0.02961071f, 0.08406559f, -0.04096588f, -0.02351245f, 0.14512849f, 0.03745133f, -0.24921037f, -0.03029720f, 
    0.08619489f, 0.13928883f, -0.13922656f, 0.11487950f, 0.07729825f, 0.02078705f, 0.00443659f, 0.03225418f, 
    -0.05835658f, 0.01486056f, -0.02049938f, 0.03709362f, 0.00605124f, -0.03974287f, 0.05428127f, -0.01376873f, 
    -0.04018921f, 0.04722480f, -0.02482351f, 0.06313136f, -0.03744925f, -0.03509280f, 0.02486163f, -0.03071088f, 
    -0.00639635f, 0.05858587f, -0.04388818f, -0.02061279f, 0.06154890f, -0.00244219f, 0.02063923f, -0.03907560f, 
    -0.01847878f, -0.07411028f, -0.03001111f, -0.06123782f, 0.04133696f, -0.01181290f, -0.04937555f, -0.06050736f, 
    -0.06841038f, 0.02318322f, -0.01299370f, -0.05542069f, -0.05882673f, 0.00886196f, 0.00540685f, -0.04993352f, 
    0.05798788f, 0.04198340f, -0.05850757f, -0.04056915f, -0.06162782f, -0.02080920f, -0.03310349f, 0.02403501f, 
    -0.04251257f, -0.04998870f, 0.01096053f, -0.06764586f, -0.01321802f, 0.02672988f, 0.05979686f, -0.03705206f, 
    -0.01859234f, 0.02779021f, -0.01059213f, 0.04934388f, 0.03964328f, -0.01504161f, -0.05782043f, 0.05882693f, 
    -0.05531718f, 0.01635516f, -0.06095275f, -0.07362583f, -0.01100394f, 0.01071236f, -0.01791557f, 0.05704747f, 
    -0.04867401f, -0.03981783f, -0.04546377f, -0.01115669f, -0.01700276f, 0.03898610f, -0.04867522f, -0.01808034f, 
    -0.03960297f, -0.02318130f, -0.06111519f, 0.01163328f, 0.02412466f, 0.05342187f, -0.00621474f, -0.06019351f, 
    -0.01002113f, -0.05959035f, -0.03850920f, -0.04892413f, -0.05607155f, 0.04888805f, -0.00690441f, -0.02639469f, 
    0.02079769f, 0.02740656f, -0.01453860f, -0.07152513f, -0.02615984f, -0.01373611f, 0.04112402f, 0.04501778f, 
    -0.01347568f, -0.00559284f, -0.02822312f, 0.05117317f, -0.00847264f, 0.03460562f, 0.01944604f, 0.03693159f, 
    0.05066919f, -0.04096070f, 0.02611951f, -0.07621849f, -0.02239659f, -0.06556310f, 0.02032978f, 0.01842968f, 
    0.02630618f, 0.05658241f, -0.01040220f, -0.04429775f, 0.05209369f, 0.01046531f, -0.07727154f, 0.06201057f, 
    0.04745170f, 0.00501879f, -0.07293572f, -0.00259228f, 0.02178235f, 0.00325916f, 0.00629691f, 0.06327976f, 
    -0.07662787f, -0.06137647f, -0.05985624f, -0.01426795f, -0.06456826f, -0.03186856f, -0.03884418f, -0.07524292f, 
    -0.05893936f, -0.05263364f, -0.00949339f, -0.04415356f, -0.03191415f, 0.00779153f, -0.06556924f, -0.02989000f, 
    0.06184906f, -0.06216903f, -0.05501924f, -0.01253570f, 0.05759301f, 0.05245366f, 0.04753749f, -0.06499217f, 
    -0.00665103f, 0.02569626f, 0.02177573f, -0.02541681f, 0.04899997f, -0.05286255f, -0.01419100f, -0.00996181f, 
    0.02618853f, -0.06396382f, 0.01682069f, 0.01281368f, -0.04621396f, -0.01339268f, -0.03744805f, -0.05582789f, 
    0.06047862f, -0.00711489f, -0.03837211f, -0.04695839f, -0.01935955f, -0.01469409f, -0.02700340f, 0.00762070f, 
    -0.03788069f, 0.02316382f, 0.02903867f, 0.02912122f, -0.02291775f, 0.05104207f, -0.06127573f, -0.02069321f, 
    0.00266050f, -0.06534915f, -0.06251175f, -0.03389406f, 0.00991290f, 0.01812165f, -0.01605232f, -0.04887033f, 
    -0.00198147f, 0.05349653f, 0.06100311f, 0.00788916f, -0.05690226f, 0.02080424f, 0.02999098f, -0.07374886f, 
    -0.06645802f, -0.03768511f, -0.05880193f, -0.05886877f, -0.04342708f, 0.03889984f, 0.06537139f, 0.01407109f, 
    -0.00525353f, -0.06449012f, 0.05645273f, -0.00321008f, -0.05507087f, -0.03030294f, 0.02594200f, -0.02396435f, 
    0.05690945f, -0.05775788f, -0.07236082f, -0.01004213f, 0.01603024f, 0.00960438f, -0.07255421f, -0.00686311f, 
    0.01883155f, -0.03461554f, 0.03423702f, 0.01051702f, -0.01186549f, 0.02808645f, -0.00327237f, -0.05264181f, 
    0.02402415f, -0.04481616f, 0.00809118f, 0.01321315f, -0.02926809f, 0.01157075f, -0.06600681f, 0.04569001f, 
    -0.01517901f, -0.01483131f, -0.05647438f, -0.07397457f, 0.01399029f, 0.04913704f, -0.05923654f, 0.02638131f, 
    -0.05284973f, -0.06942011f, 0.03181060f, -0.00930714f, -0.04642602f, 0.05781572f, -0.03085898f, -0.06983915f, 
    -0.03401345f, 0.01333247f, -0.02257279f, -0.04399411f, 0.05026037f, -0.04336785f, -0.06113315f, 0.01296172f, 
    -0.01880031f, 0.02862958f, 0.02816424f, 0.02582917f, 0.03495815f, 0.01620687f, -0.05595990f, -0.01685045f, 
    -0.02839906f, 0.02623793f, -0.07610053f, -0.04359050f, -0.02054525f, 0.02677429f, -0.04683128f, 0.03464727f, 
    0.05110142f, 0.00247397f, 0.02292792f, -0.02726397f, -0.01547193f, 0.02450377f, 0.05896826f, 0.02885108f, 
    -0.04238075f, -0.04891204f, 0.00207059f, 0.06273150f, -0.02005556f, 0.05196319f, -0.07274201f, 0.01365206f, 
    -0.05300208f, -0.03097771f, 0.04303692f, 0.03733217f, 0.03478067f, -0.03319366f, -0.04344967f, 0.01476518f, 
    -0.04018339f, -0.01580901f, -0.01171510f, -0.07775778f, 0.02710266f, -0.03587314f, -0.00045383f, -0.06571016f, 
    -0.05411708f, 0.00912584f, -0.06254074f, -0.05249823f, 0.03915656f, 0.00681466f, -0.01820377f, -0.07095335f, 
    -0.04619056f, 0.03020386f, -0.03726794f, -0.02143724f, -0.06202291f, -0.01417916f, 0.04513004f, 0.04851788f, 
    0.00693103f, -0.01830291f, -0.06029127f, 0.00426736f, -0.02933315f, -0.02474036f, -0.07656556f, -0.06386917f, 
    0.00460038f, -0.00754907f, -0.01051105f, -0.02855574f, 0.03251737f, 0.01245528f, -0.05770785f, 0.05515465f, 
    -0.01662429f, 0.04524007f, -0.02571503f, -0.00817975f, 0.02609229f, 0.05465914f, 0.05836180f, -0.02442320f, 
    -0.05174742f, 0.04087431f, 0.02819687f, 0.01842901f, 0.02537076f, -0.07894668f, -0.02443406f, 0.02829876f, 
    0.04457429f, 0.03200125f, 0.05532617f, 0.04692271f, 0.00459349f, 0.01663223f, -0.04287247f, -0.01469999f, 
    -0.06585444f, 0.02342620f, 0.02825844f, -0.06892589f, -0.02081861f, 0.01562439f, -0.05470407f, -0.00045152f, 
    -0.32953137f, 0.02915278f, 0.03321809f, -0.09775578f, -0.01645952f, 0.10783392f, -0.05870654f, 0.11650226f, 
    -0.02404012f, 0.03913131f, -0.07749447f, -0.08397388f, 0.10643014f, -0.15751739f, -0.04286888f, -0.24621467f, 
    -0.11965121f, -0.19991966f, 0.01350466f, 0.04033311f, 0.10555816f, -0.03781300f, -0.03159197f, 0.05200668f, 
    -0.20443828f, 0.18704121f, -0.14885646f, 0.04332226f, 0.10758030f, -0.09176745f, 0.00199992f, -0.03467747f, 
    -0.01821260f, -0.09948605f, -0.03492263f, 0.03558337f, -0.09675384f, 0.10817460f, -0.01252096f, -0.15371171f, 
    0.02851757f, -0.01772123f, 0.06707200f, -0.13758156f, -0.16949467f, -0.06220004f, -0.00624002f, 0.08832566f, 
    -0.13368639f, -0.04483131f, 0.10840905f, 0.10788219f, -0.26163200f, -0.04506862f, -0.06271724f, -0.02844917f, 
    -0.01596127f, -0.03521055f, 0.07390714f, -0.01014543f, -0.18453597f, -0.18700860f, 0.04507096f, 0.13736226f, 
    -0.12463205f, 0.06010881f, -0.09080511f, 0.09831238f, -0.09227345f, -0.04013478f, -0.10157811f, 0.00152293f, 
    0.42704019f, -0.15198369f, -0.01132823f, 0.03356106f, -0.15283911f, -0.24613145f, 0.03319469f, 0.08773352f, 
    -0.02945241f, -0.06666344f, -0.06149372f, 0.00675853f, 0.21752904f, -0.24213719f, -0.11291629f, -0.07909769f, 
    -0.14692397f, -0.03758303f, -0.06206492f, 0.08674467f, -0.06445955f, -0.04384898f, -0.00819091f, 0.12077633f, 
    0.16126433f, 0.07430522f, 0.01528194f, -0.19246203f, 0.09208191f, -0.04620902f, -0.07916927f, 0.07733572f, 
    0.05763107f, 0.08317432f, 0.08063645f, 0.08979832f, 0.00717182f, 0.13748358f, -0.06821103f, 0.02680864f, 
    -0.15549979f, -0.20359407f, -0.11575533f, 0.17729323f, 0.07198675f, 0.03313597f, 0.07223064f, -0.04117543f, 
    0.31019980f, 0.00254171f, -0.27989507f, -0.05947875f, -0.32177499f, -0.08308540f, -0.00076899f, 0.15357223f, 
    -0.04584726f, 0.01927744f, 0.02900590f, 0.06968905f, 0.08390995f, 0.14153334f, -0.14949456f, -0.23162790f, 
    -0.08106074f, -0.10250685f, 0.10437360f, -0.00126634f, -0.01800890f, 0.05973469f, 0.06770045f, -0.00505244f, 
    -0.15661289f, -0.06721137f, -0.11311595f, -0.11037397f, 0.08173660f, 0.05323821f, -0.05389199f, 0.11382012f, 
    -0.09018353f, -0.07519469f, 0.10109709f, -0.17825769f, -0.22583887f, -0.03919350f, 0.02577404f, 0.10761154f, 
    0.01180482f, 0.02240815f, 0.08565234f, 0.01946586f, -0.05279482f, -0.11087932f, -0.07018921f, -0.04407101f, 
    -0.07116886f, 0.14418133f, 0.22028948f, 0.12184910f, 0.01035573f, -0.03433052f, 0.04855139f, 0.08006383f, 
    -0.01405675f, -0.00235925f, -0.07423084f, -0.21346682f, -0.30645540f, -0.29798275f, -0.10650244f, 0.17680483f, 
    -0.01031310f, 0.19340482f, 0.01272565f, -0.00175412f, -0.05329255f, 0.01810164f, 0.02432130f, -0.02885982f, 
    -0.22329772f, 0.34437481f, 0.10399083f, -0.03124197f, -0.07279126f, 0.11719102f, -0.01572474f, 0.03096128f, 
    0.07978816f, 0.05843951f, -0.09663700f, 0.03803059f, -0.14918140f, 0.00514618f, 0.08275014f, -0.22466600f, 
    -0.07305676f, 0.02333242f, 0.03025354f, -0.03510639f, 0.01231450f, 0.06993609f, 0.25214797f, 0.21845771f, 
    0.06686947f, -0.19699927f, 0.02576055f, 0.21170482f, -0.03540408f, 0.01900427f, 0.04796901f, -0.13018906f, 
    0.02683362f, -0.04442025f, -0.05267218f, -0.18225092f, -0.14232852f, -0.26135981f, 0.16930017f, -0.04765157f, 
    -0.01556768f, -0.07211222f, 0.03655899f, 0.05356898f, 0.01471474f, -0.14768377f, 0.06026154f, 0.05621082f, 
    -0.17594583f, 0.08812922f, -0.15899098f, 0.16628592f, -0.01465581f, 0.05013621f, -0.07209855f, 0.11749958f, 
    0.09900129f, 0.07754297f, 0.06211209f, 0.02747355f, 0.15508655f, -0.02166705f, 0.08504660f, 0.08458848f, 
    -0.19544233f, -0.05760819f, -0.04514459f, 0.11837429f, -0.05105007f, 0.09121682f, 0.01994411f, -0.07353631f, 
    -0.25749490f, 0.13289645f, 0.04013773f, 0.02295490f, 0.02399390f, -0.01060324f, 0.03470817f, -0.01659657f, 
    -0.08447789f, -0.10407840f, -0.01515601f, -0.05902882f, -0.17647272f, 0.10205439f, -0.10359328f, -0.01390626f, 
    0.21925277f, 0.06742618f, 0.02968243f, -0.03524482f, -0.09963157f, -0.09411576f, 0.04947391f, 0.12752241f, 
    -0.00164407f, -0.05928842f, -0.03750670f, -0.16875978f, -0.09031416f, 0.06861521f, -0.01949707f, -0.04947421f, 
    -0.01021378f, 0.07762869f, -0.01201647f, 0.05852977f, 0.53755134f, -0.11820390f, -0.01860089f, 0.13906929f, 
    -0.01195399f, -0.05392419f, 0.02055470f, 0.10573269f, 0.02482243f, 0.15609075f, 0.06140872f, 0.00405439f, 
    -0.14824620f, 0.10535824f, -0.06244871f, -0.05241767f, 0.07271389f, 0.01938004f, 0.13971530f, 0.02189119f, 
    0.06857345f, -0.04302172f, -0.03795319f, -0.10107684f, -0.06014661f, 0.01286179f, -0.00690339f, -0.15892790f, 
    0.08911923f, -0.04049919f, 0.05599033f, -0.03592373f, -0.00368904f, -0.03908575f, -0.01759962f, 0.00434558f, 
    -0.01069306f, 0.42710495f, 0.02367986f, -0.04349599f, 0.07378994f, 0.03370233f, 0.00116594f, 0.00185542f, 
    0.00994048f, 0.01867620f, -0.03336883f, 0.00131440f, -0.10786604f, 0.10271555f, 0.12511532f, 0.01939033f, 
    -0.04784235f, -0.04216877f, 0.05546466f, 0.05685692f, 0.03593425f, 0.03565238f, 0.01384773f, 0.08230731f, 
    -0.03504602f, -0.16882092f, 0.14975359f, -0.08130712f, -0.02400667f, -0.06111166f, -0.01360528f, 0.12041388f, 
    0.20532505f, 0.14643352f, 0.05082274f, 0.10090702f, -0.07885902f, 0.12032405f, 0.03431616f, 0.05460645f, 
    -0.16099733f, 0.18010400f, -0.07435504f, -0.01990037f, -0.08464383f, 0.00747852f, -0.02952758f, 0.00395657f, 
    -0.15024026f, 0.17909478f, 0.18471262f, 0.08383442f, -0.04733641f, 0.22012860f, 0.10705907f, -0.04884796f, 
    -0.00677189f, 0.06464556f, -0.21812332f, 0.01880910f, -0.09329969f, -0.32315281f, -0.33661962f, -0.31323338f, 
    0.26660118f, -0.02111626f, -0.04371767f, 0.10207733f, 0.14697798f, 0.08133791f, -0.04782816f, 0.09995061f, 
    0.02042767f, -0.09363586f, 0.13393538f, -0.10605132f, 0.05130937f, 0.01352785f, -0.09278812f, -0.04809127f, 
    0.07753810f, 0.04178458f, 0.08366667f, 0.02259466f, -0.05389526f, 0.06976545f, 0.04141705f, 0.03763775f, 
    0.15627046f, -0.04842274f, 0.04552123f, -0.02673895f, -0.05664673f, -0.01061494f, -0.09092714f, -0.06712661f, 
    0.00943366f, 0.13253912f, 0.06694473f, -0.04914270f, -0.02631227f, 0.07704027f, -0.07225656f, -0.09553406f, 
    0.05351115f, -0.03143529f, 0.02301934f, -0.17132466f, 0.26660928f, -0.19857945f, 0.22932558f, 0.28032160f, 
    -0.12189732f, -0.08085357f, 0.00580431f, 0.07292315f, 0.09321401f, -0.28922027f, -0.04103953f, 0.01911592f, 
    -0.33428752f, 0.02171824f, -0.23461545f, 0.10859300f, 0.27335268f, 0.05630114f, -0.05425809f, 0.04276050f, 
    -0.04400267f, -0.00302633f, -0.11117972f, -0.02688892f, -0.11631491f, 0.18959138f, -0.23817793f, -0.45071837f, 
    0.12214235f, 0.12824272f, 0.08443219f, 0.00188981f, 0.14075410f, 0.09039526f, -0.05234088f, 0.06484315f, 
    -0.18943104f, 0.05952035f, 0.05262633f, 0.09423330f, 0.06275413f, -0.03438343f, 0.25054890f, 0.08476277f, 
    0.00424300f, -0.01497898f, 0.04688302f, 0.01983943f, -0.53040183f, -0.06344382f, -0.11386440f, -0.22262129f, 
    0.20146659f, -0.07828254f, -0.06087064f, 0.00716053f, -0.06339698f, 0.02993989f, 0.03510251f, 0.04037954f, 
    -0.41974553f, -0.09587944f, -0.31524923f, -0.20322931f, 0.16970821f, 0.10790870f, 0.09487662f, 0.09624328f, 
    0.16172703f, 0.04088370f, -0.02002030f, 0.00695389f, -0.22310236f, -0.21292855f, -0.11101697f, -0.02258564f, 
    0.11907449f, 0.15818499f, -0.08385357f, 0.17215514f, 0.17933755f, 0.23415694f, 0.04986481f, 0.33246142f, 
    0.02092960f, 0.26122797f, 0.13504480f, 0.31175849f, -0.00289117f, -0.00439695f, -0.15529862f, -0.06087084f, 
    0.16809253f, 0.02906886f, 0.12167525f, 0.10015069f, -0.08469260f, -0.02364527f, 0.21156655f, 0.33461297f, 
    0.04426954f, 0.10873714f, -0.02875178f, -0.08218709f, 0.08267230f, 0.10789178f, 0.06649060f, 0.10157648f, 
    -0.20174819f, 0.11606649f, 0.26082289f, 0.14320292f, -0.13148086f, -0.15594129f, 0.00826674f, -0.04031101f, 
    0.12655175f, 0.07700318f, 0.10271177f, -0.01822327f, -0.01053302f, -0.01786955f, 0.17818463f, -0.04914875f, 
    -0.11089478f, -0.08056857f, -0.12736802f, -0.01471275f, 0.00024635f, -0.04347464f, -0.06341766f, 0.17273320f, 
    -0.02318425f, 0.05983892f, 0.05413952f, -0.01517231f, 0.05428540f, -0.05447191f, 0.05736174f, -0.03073815f, 
    -0.07267348f, -0.07513300f, -0.01425355f, 0.05905515f, -0.01807909f, 0.05216404f, 0.03953391f, 0.04772872f, 
    -0.02629295f, 0.04168072f, 0.05030209f, 0.00717267f, -0.04861526f, -0.04763930f, -0.06377438f, -0.06036438f, 
    0.03681697f, 0.03297551f, 0.05517601f, -0.02614812f, 0.02202406f, 0.05085377f, -0.05966484f, -0.06191284f, 
    -0.05443991f, -0.05628361f, 0.04159492f, -0.00312800f, -0.01458266f, -0.07140386f, 0.00251513f, -0.06358568f, 
    0.05602706f, -0.02519710f, 0.02864894f, -0.01300060f, 0.00447098f, 0.03779855f, -0.02384568f, 0.01578380f, 
    -0.03882753f, -0.00011908f, -0.01417278f, 0.01165930f, 0.00057429f, -0.06921873f, -0.00823908f, -0.03696368f, 
    0.02401109f, -0.03827978f, -0.00872164f, -0.01889716f, 0.00854235f, 0.02490465f, 0.02454515f, -0.05227747f, 
    -0.07426891f, -0.05028992f, -0.04401259f, -0.00018377f, -0.00454024f, -0.04414888f, -0.02834279f, 0.00463173f, 
    -0.03894620f, -0.05890360f, -0.07263461f, -0.03476935f, 0.04256640f, 0.01460966f, 0.06363514f, 0.04957680f, 
    -0.05255762f, -0.07066517f, -0.01631567f, 0.03306779f, -0.02335475f, 0.04968024f, 0.00669107f, -0.00872387f, 
    -0.05881325f, -0.02384839f, -0.03059327f, 0.04586500f, -0.02582409f, -0.01686178f, 0.01521682f, 0.03520995f, 
    -0.07482648f, -0.07088412f, -0.06183447f, -0.01861255f, -0.07255699f, -0.05562235f, -0.00155388f, -0.07440124f, 
    0.01319765f, -0.06883975f, 0.01900321f, -0.00815370f, 0.03202244f, -0.02775048f, -0.07625639f, 0.00141061f, 
    0.03229172f, 0.00300924f, 0.01207882f, -0.02066920f, -0.03891108f, -0.00463054f, 0.00563881f, -0.07247453f, 
    0.01043508f, -0.04003640f, 0.00634971f, -0.01631833f, -0.02947653f, -0.07955080f, -0.04942077f, -0.00571531f, 
    0.01413762f, -0.04111397f, 0.04221692f, -0.05464841f, -0.01295785f, -0.00342867f, 0.05684046f, 0.02461275f, 
    -0.04814262f, -0.04236662f, -0.06381228f, -0.06439313f, -0.05765791f, -0.00425915f, 0.01146244f, 0.05654109f, 
    -0.01696539f, -0.03500769f, 0.01548900f, -0.05265384f, 0.04622187f, -0.03864449f, 0.03068567f, 0.02438310f, 
    0.04794748f, -0.06077271f, -0.03527689f, -0.00401481f, -0.03159032f, 0.03552188f, 0.06214007f, 0.00556176f, 
    0.01912971f, -0.03613769f, 0.06479627f, -0.00295024f, -0.00535939f, 0.00176149f, -0.00143439f, 0.00480433f, 
    -0.04416185f, -0.05680572f, -0.05361369f, 0.03727140f, -0.03719084f, 0.06363027f, 0.00556741f, 0.03586125f, 
    0.02559160f, 0.01555655f, 0.02266149f, -0.00462078f, 0.06162931f, 0.02040238f, -0.03003353f, 0.02876911f, 
    -0.02697203f, -0.02652507f, 0.04651739f, 0.01881642f, 0.00621745f, -0.03921198f, 0.04180332f, 0.04435857f, 
    -0.28456137f, -0.00771628f, -0.00324316f, -0.07416881f, 0.06439883f, 0.09178919f, -0.08222812f, 0.02350238f, 
    -0.06292689f, 0.03234671f, -0.00196017f, 0.00160435f, 0.01172764f, -0.10242544f, -0.13051254f, -0.13676645f, 
    -0.02887219f, 0.12032454f, -0.02522359f, -0.03184498f, -0.11748727f, 0.09123981f, -0.01156337f, 0.21511661f, 
    0.07360539f, -0.40105879f, 0.11262300f, 0.02482649f, 0.10090549f, -0.07261813f, 0.07901299f, -0.10658803f, 
    -0.00164393f, 0.08846289f, 0.07542417f, 0.03659458f, -0.03584912f, -0.01560899f, -0.00784954f, 0.02279270f, 
    0.13875622f, -0.00480417f, 0.02836209f, 0.18677947f, -0.06032755f, 0.18701306f, 0.05078425f, 0.12906598f, 
    0.10407639f, 0.03169674f, -0.12609099f, 0.02635499f, -0.14225715f, -0.15776014f, 0.15174688f, 0.15928693f, 
    0.27939138f, 0.01663526f, 0.06398820f, -0.01399717f, -0.24019526f, 0.05332666f, -0.06203625f, -0.38097262f, 
    0.03140653f, 0.04273060f, 0.03738302f, -0.06065795f, 0.03793710f, 0.08218950f, 0.16927034f, 0.00681785f, 
    0.17607975f, -0.07096938f, 0.10241454f, 0.01009509f, 0.06223696f, -0.00538371f, 0.12472542f, -0.01708845f, 
    0.01342708f, 0.05298772f, 0.05147970f, 0.01090565f, 0.01707030f, 0.02647646f, -0.05037105f, 0.08190659f, 
    0.11633603f, -0.01677635f, 0.11338664f, -0.05968682f, -0.12890522f, 0.04248166f, -0.03344337f, 0.01116994f, 
    0.05158505f, 0.16043769f, 0.03649825f, -0.01994169f, 0.05710048f, 0.09421524f, 0.09374247f, 0.04303705f, 
    0.17589536f, 0.00303434f, 0.19935963f, 0.10957498f, 0.41604307f, -0.16044143f, 0.06350768f, 0.02271667f, 
    -0.13046354f, -0.07746165f, -0.02354465f, -0.15764250f, -0.00314519f, 0.00843590f, 0.08303184f, 0.08039635f, 
    -0.08520474f, -0.24271062f, -0.21135156f, 0.01550694f, -0.05269935f, 0.04064053f, -0.00184915f, -0.04975906f, 
    -0.00942650f, -0.02648849f, 0.02202357f, 0.08846618f, -0.33039320f, -0.17495428f, -0.19532710f, -0.19128467f, 
    0.02683693f, -0.11649524f, -0.08040323f, -0.11680790f, 0.07960968f, 0.00671202f, -0.08196844f, 0.01143641f, 
    -0.23441476f, -0.04628192f, -0.12954161f, 0.04594092f, 0.14151073f, -0.07264286f, 0.01426547f, 0.02096146f, 
    0.01911090f, 0.03687476f, 0.00666986f, 0.06141947f, -0.05733737f, 0.22891216f, 0.05750013f, 0.01604823f, 
    0.06064571f, 0.03130058f, -0.07211400f, 0.01913399f, 0.00780316f, 0.07708970f, 0.08545294f, -0.05651731f, 
    0.26467389f, 0.27519503f, 0.02144491f, -0.01339875f, -0.05272310f, 0.07259340f, 0.06823259f, 0.09030554f, 
    0.05722494f, -0.06424240f, 0.15997554f, 0.13647881f, -0.03858203f, 0.25428048f, 0.18543516f, 0.14135745f, 
    0.10187740f, 0.07148998f, 0.10806590f, 0.13699177f, 0.04302280f, -0.08912503f, -0.07423607f, -0.03796360f, 
    0.01502840f, -0.06825871f, 0.04936434f, 0.16697963f, -0.05579658f, -0.01168886f, -0.01640730f, 0.00208645f, 
    0.15605865f, 0.00158421f, 0.19017839f, 0.08935016f, -0.22412592f, -0.25402007f, -0.19413547f, -0.11298870f, 
    0.04657933f, -0.13849410f, -0.08784001f, -0.14603896f, 0.04193538f, -0.18586075f, -0.00968083f, -0.01043881f, 
    -0.34431726f, 0.36332896f, -0.02535788f, -0.08077235f, -0.00315335f, 0.04387502f, -0.02490585f, 0.10107335f, 
    0.05145893f, 0.08623723f, 0.00655457f, 0.12970829f, -0.17350599f, 0.31172726f, -0.06188164f, 0.02314359f, 
    -0.01528940f, 0.08264499f, -0.03649870f, 0.02962696f, 0.04296020f, 0.02535122f, 0.02632604f, -0.08804736f, 
    -0.03062779f, -0.14177582f, 0.06200882f, 0.07132156f, -0.01822740f, -0.07419372f, 0.01460732f, -0.10802068f, 
    0.10634853f, -0.14240260f, 0.02411114f, 0.03153658f, 0.05245150f, -0.18540426f, 0.13121931f, -0.00550425f, 
    -0.25153401f, -0.14723854f, 0.00576685f, 0.08694173f, 0.21861216f, -0.07432714f, 0.07394318f, 0.12464780f, 
    -0.18077864f, -0.15067710f, -0.10452336f, -0.20147756f, 0.21798994f, -0.02733009f, 0.06661164f, 0.06367818f, 
    0.04705511f, 0.04887956f, -0.11264106f, -0.04870515f, -0.08155593f, -0.06744307f, -0.11666290f, -0.01768353f, 
    -0.05981656f, 0.01244520f, 0.05030804f, 0.18350804f, 0.07578859f, -0.00012160f, 0.06331329f, 0.03723383f, 
    0.11698150f, 0.05836955f, 0.01990163f, 0.19406675f, 0.04237310f, 0.08419882f, 0.14721498f, -0.03212092f, 
    -0.04775897f, -0.01667975f, 0.15214951f, -0.09704085f, -0.39762905f, 0.07826461f, -0.15124281f, 0.10257056f, 
    -0.11594962f, -0.06965102f, -0.06330245f, 0.02232927f, 0.05407263f, 0.09870785f, -0.03049933f, -0.11139994f, 
    0.01291107f, 0.05680264f, -0.13271204f, -0.07003039f, -0.02239524f, 0.00176523f, -0.01141176f, -0.00355907f, 
    -0.01943354f, 0.23711327f, 0.04852374f, -0.08081276f, -0.09121546f, 0.04329869f, -0.11035355f, 0.01165576f, 
    0.00624223f, 0.06065553f, 0.05272193f, -0.10531423f, -0.11677781f, 0.00451748f, 0.06160039f, 0.08042169f, 
    0.15581015f, 0.06058391f, 0.06322473f, -0.11187882f, -0.10404256f, -0.04231229f, -0.05177558f, 0.06885348f, 
    0.06050060f, 0.06283379f, 0.19003786f, 0.01363408f, -0.08786751f, 0.11996170f, 0.11518794f, 0.04154529f, 
    -0.05254905f, -0.19352221f, -0.12953313f, 0.02802173f, 0.02094422f, 0.01163078f, -0.05665134f, 0.05079445f, 
    0.09481025f, 0.19028054f, 0.14399968f, 0.01439963f, 0.04678665f, 0.11680716f, 0.07110716f, 0.01930773f, 
    0.00116625f, 0.06872156f, 0.14541563f, 0.07659421f, -0.03105423f, -0.08628395f, -0.05116611f, 0.20849319f, 
    0.06550337f, -0.03407129f, 0.04945782f, -0.07204658f, -0.04987432f, 0.05278092f, 0.06872918f, 0.07897314f, 
    -0.22281922f, -0.09175756f, 0.21984451f, 0.08248543f, -0.13418311f, 0.14053452f, -0.01591888f, -0.05860751f, 
    0.07837956f, -0.06848630f, 0.09527039f, 0.08221636f, -0.05972500f, 0.00409376f, -0.06677908f, -0.21444301f, 
    0.15844940f, -0.16124979f, -0.02488407f, 0.00993103f, 0.05998621f, 0.00065566f, -0.09204992f, 0.00011522f, 
    -0.26920986f, 0.30957538f, 0.12191890f, -0.26406664f, 0.05153308f, -0.12141841f, -0.12275400f, -0.11574147f, 
    0.05215014f, 0.13939935f, 0.05873927f, 0.16028251f, -0.31061351f, 0.15197313f, 0.05107579f, 0.04096411f, 
    0.05432272f, -0.00145681f, 0.03563557f, 0.05847351f, 0.02300167f, -0.08172294f, -0.10771388f, -0.12585615f, 
    0.00435450f, 0.05675469f, -0.09510026f, -0.08281591f, 0.00548505f, -0.07844044f, -0.17428152f, -0.14106363f, 
    -0.01169218f, 0.03367548f, 0.06591090f, -0.07910451f, 0.15066445f, -0.37488019f, 0.03619507f, 0.10781720f, 
    -0.03450678f, -0.07140261f, -0.04618593f, -0.10203002f, 0.02598830f, -0.04924092f, 0.07237177f, 0.04385905f, 
    -0.37015602f, -0.05920839f, -0.17940953f, 0.09145401f, 0.28829318f, 0.10395503f, 0.05097977f, 0.08110323f, 
    0.10233228f, 0.07850707f, -0.01170474f, 0.02831544f, 0.05863253f, 0.11530779f, -0.05405478f, -0.16566759f, 
    0.08712409f, 0.06959515f, 0.08095665f, -0.04304938f, 0.00852574f, 0.05156768f, -0.06825788f, -0.01262181f, 
    -0.00932818f, 0.00738998f, 0.11607564f, 0.25984690f, -0.00686624f, 0.04125335f, 0.19262713f, -0.02541600f, 
    -0.01279685f, 0.04621332f, 0.18056452f, -0.04973808f, -0.37353301f, 0.23571983f, -0.27220237f, 0.04275585f, 
    0.06672294f, -0.05246520f, 0.00154831f, -0.21745840f, 0.09050751f, 0.05450996f, 0.08588133f, -0.09215496f, 
    -0.26580948f, 0.05593587f, -0.26221502f, -0.02203106f, 0.07377262f, -0.02054524f, 0.02971531f, 0.08270510f, 
    -0.03748962f, 0.24008526f, 0.10995207f, 0.06612074f, -0.06243358f, 0.00215096f, -0.08285918f, -0.08396858f, 
    0.11552381f, 0.01234576f, 0.03475266f, 0.14165573f, 0.06751365f, 0.06005250f, 0.15951993f, 0.31746987f, 
    0.03646613f, 0.01434390f, 0.17961033f, 0.15090330f, 0.03019598f, -0.02120738f, -0.00239039f, -0.12289706f, 
    0.17451917f, 0.14289008f, 0.04978257f, 0.15709469f, -0.29581282f, 0.01558050f, 0.08639536f, 0.40865231f, 
    0.12884831f, -0.23107323f, -0.16668138f, -0.19584538f, -0.15296367f, -0.16518059f, -0.06622683f, 0.11117117f, 
    -0.09188896f, 0.01122960f, 0.08075377f, -0.08713175f, 0.01254932f, -0.01413294f, -0.01110455f, -0.14362642f, 
    0.05236827f, 0.11419447f, 0.20033242f, 0.19024022f, -0.12099399f, -0.02639185f, 0.01863105f, 0.05017218f, 
    -0.05733562f, -0.02205557f, -0.00350729f, -0.01290559f, 0.07106118f, 0.01540060f, 0.06958105f, 0.17711337f, 
    0.11526153f, -0.00090745f, -0.00048338f, 0.13029978f, 0.19295982f, 0.07083893f, 0.07836831f, 0.00386102f, 
    0.10097982f, 0.05026042f, 0.00037522f, 0.13778731f, 0.05891801f, -0.05208903f, 0.06481025f, -0.07706028f, 
    -0.04903525f, -0.03665314f, 0.02248623f, -0.04594495f, 0.04170976f, -0.00375731f, -0.09800786f, 0.03103383f, 
    0.16917029f, 0.09391098f, -0.05280640f, 0.22551139f, 0.19172022f, 0.06499803f, -0.02638162f, -0.08989311f, 
    -0.10899377f, 0.09559757f, -0.02717182f, 0.00379540f, 0.16201033f, -0.17192835f, -0.34214494f, -0.30011782f, 
    -0.00996034f, 0.18606618f, -0.12638515f, 0.08958768f, 0.08091936f, 0.11810579f, 0.07294591f, -0.00694679f, 
    0.21215351f, -0.08009290f, 0.18095244f, 0.22034115f, -0.12445796f, -0.04771497f, 0.09759856f, -0.02093550f, 
    -0.07111658f, 0.03843252f, 0.08520082f, 0.02992113f, 0.09735223f, 0.16747646f, 0.19095814f, -0.09906606f, 
    -0.08196125f, 0.11300409f, 0.02045388f, 0.03985463f, -0.02812415f, 0.00021335f, 0.01794239f, 0.00895886f, 
    0.21338767f, -0.18415533f, 0.16227068f, -0.17165864f, 0.02517302f, -0.06310095f, 0.16691287f, 0.03014471f, 
    0.12552659f, 0.06906908f, 0.02931064f, -0.01753851f, 0.24922660f, -0.19366808f, 0.12150329f, 0.11000430f, 
    -0.13452996f, -0.01418154f, -0.14977083f, 0.05165975f, 0.09478277f, -0.15350944f, 0.06786583f, 0.05383748f, 
    -0.15738344f, -0.12910129f, -0.10593072f, -0.27195820f, -0.05115207f, -0.06108629f, 0.05687073f, -0.15635246f, 
    -0.01441141f, -0.03024034f, 0.00238494f, 0.03727439f, 0.01414794f, -0.28412133f, -0.05659981f, 0.02175899f, 
    -0.13447919f, 0.05018639f, -0.03296184f, 0.07537189f, 0.00358827f, 0.15926127f, -0.01176254f, -0.05842355f, 
    -0.00073648f, 0.01456664f, 0.10732410f, -0.20809461f, -0.06357908f, 0.04711463f, -0.12435554f, 0.17370224f, 
    -0.00602593f, -0.02956377f, -0.00858868f, 0.02048500f, -0.28185600f, 0.07626048f, -0.04334961f, -0.18326686f, 
    -0.10218591f, -0.06590093f, -0.01613516f, -0.15831502f, -0.01167358f, -0.05197290f, 0.09159360f, 0.03297237f, 
    0.26894563f, 0.12131825f, 0.24645938f, -0.07377187f, 0.00467313f, 0.11476922f, -0.02114254f, -0.01602746f, 
    0.02208913f, -0.03672678f, 0.00085140f, -0.10494766f, 0.37987745f, 0.01732213f, 0.16634412f, 0.00455627f, 
    0.05954851f, 0.08229289f, 0.03895029f, 0.09202992f, -0.02411543f, -0.04113264f, 0.00763937f, -0.06226976f, 
    0.13830961f, -0.08604059f, 0.08297385f, -0.10853029f, 0.10571239f, 0.07812096f, -0.02457338f, -0.18449542f, 
    -0.04772475f, 0.03593226f, 0.04865251f, 0.00255689f, 0.06893698f, 0.10190959f, -0.16338874f, -0.03795883f, 
    0.02333989f, -0.00113611f, 0.00653119f, -0.03932069f, 0.04754271f, 0.02465514f, 0.04324558f, -0.05805747f, 
    0.25498328f, -0.06989905f, -0.38974723f, -0.02112194f, 0.12618454f, 0.04390680f, -0.04355951f, -0.07759973f, 
    0.06563142f, -0.03799718f, 0.08559262f, -0.01769452f, 0.22687870f, 0.26730725f, 0.18057144f, -0.00128586f, 
    0.03078650f, 0.16037875f, 0.05497742f, -0.01527144f, -0.06376389f, 0.07129396f, -0.02427976f, -0.06760684f, 
    -0.18287414f, -0.02925573f, 0.15120569f, -0.11602958f, 0.06180090f, 0.02591673f, -0.13694371f, 0.14362678f, 
    -0.01423756f, -0.13390175f, 0.03138234f, -0.04152660f, 0.07309627f, -0.25521109f, 0.20462607f, -0.06995983f, 
    -0.18319574f, -0.07490386f, -0.11656202f, 0.19639650f, -0.06277527f, 0.01431039f, 0.00037023f, 0.16661282f, 
    -0.02904798f, -0.18696325f, -0.02689504f, 0.11186427f, 0.10500244f, -0.04396424f, 0.05315535f, 0.03293219f, 
    0.15551564f, -0.06224811f, -0.08281485f, -0.11750539f, -0.10599700f, -0.17358178f, -0.12181682f, -0.04018394f, 
    0.18582126f, 0.03358170f, 0.02024815f, -0.06701758f, 0.13780962f, -0.11309216f, -0.08347919f, -0.08689254f, 
    0.08569551f, 0.12064462f, 0.14826430f, 0.09310932f, -0.00104664f, -0.22369412f, 0.11414874f, 0.12023824f, 
    -0.06555027f, 0.09673472f, -0.01780346f, 0.09738019f, 0.10227458f, 0.12377577f, 0.09956355f, 0.19864380f, 
    -0.11616945f, -0.02561844f, 0.19293502f, 0.07796999f, -0.05062091f, 0.02113183f, 0.06135797f, -0.10787246f, 
    -0.14793701f, 0.04396422f, 0.20390712f, 0.27739283f, -0.01246856f, -0.19999470f, 0.03349989f, 0.00378749f, 
    0.01619281f, -0.03374396f, 0.04180342f, -0.03359251f, -0.28757223f, 0.05045595f, 0.28881538f, -0.00298292f, 
    -0.01058679f, 0.08506057f, 0.11633155f, 0.01566552f, -0.06388090f, -0.08901267f, -0.09916558f, 0.05454413f, 
    0.25269303f, 0.19515684f, 0.20849165f, 0.23738885f, 0.02780948f, -0.04520815f, -0.00968572f, -0.05058720f, 
    -0.13833125f, -0.03860699f, 0.01206273f, -0.01122950f, 0.19831888f, 0.33068246f, 0.11321493f, 0.03115894f, 
    -0.00794198f, -0.04437136f, 0.05401825f, -0.00013124f, -0.11795783f, 0.01754299f, 0.08098738f, -0.01141592f, 
    0.08483008f, -0.29879150f, -0.13732310f, 0.02172343f, -0.10950274f, -0.03204347f, 0.03475498f, -0.05704063f, 
    -0.05644742f, 0.05755194f, 0.13600166f, -0.01350605f, 0.17573060f, -0.23607638f, -0.13454826f, -0.05704625f, 
    0.12001510f, -0.21271996f, 0.00338527f, 0.01198379f, -0.06798428f, -0.04131975f, 0.05904235f, -0.08439732f, 
    -0.29993394f, -0.02290242f, 0.05779767f, -0.06084904f, 0.20465435f, -0.04012096f, -0.10652088f, 0.06391632f, 
    -0.15783085f, -0.12119374f, -0.03485861f, 0.08037397f, 0.29323930f, 0.12441488f, -0.17291263f, -0.01034834f, 
    0.17355792f, 0.10058336f, -0.15061215f, 0.10412294f, 0.11672802f, 0.14157303f, -0.09439723f, 0.05103198f, 
    0.04001405f, -0.06594535f, -0.06587510f, -0.03675022f, -0.04492958f, 0.00149179f, -0.02110039f, -0.00020792f, 
    -0.03960053f, -0.02733677f, 0.04918796f, 0.06225526f, 0.00969216f, 0.06293216f, 0.04980094f, -0.03793512f, 
    -0.00763423f, 0.00412363f, -0.06641805f, 0.03305174f, -0.03830802f, -0.06712853f, -0.05764005f, -0.07269821f, 
    -0.06428307f, 0.01127447f, -0.03930417f, -0.06808257f, -0.01850622f, 0.03101229f, -0.02049777f, -0.06854614f, 
    -0.05612051f, 0.03467728f, -0.03007990f, 0.05192798f, -0.01002695f, -0.03507244f, 0.01283036f, 0.06149554f, 
    0.05323478f, 0.02675836f, 0.03752505f, 0.06212418f, -0.03560368f, -0.03507407f, 0.03439858f, 0.01678669f, 
    0.02269720f, 0.04949711f, 0.05037908f, 0.06339771f, -0.00682805f, -0.06950290f, -0.02281100f, 0.04207524f, 
    -0.02637718f, -0.04214278f, -0.03966842f, -0.07446068f, 0.05345745f, -0.01454061f, -0.01429500f, -0.03372065f, 
    -0.01146129f, -0.04804598f, 0.03436685f, 0.04352151f, -0.02668037f, 0.05187968f, 0.00588098f, -0.06257198f, 
    -0.03714109f, 0.01358346f, 0.01403743f, -0.05251836f, 0.03054931f, -0.02669086f, 0.00416158f, -0.00880371f, 
    0.03246124f, -0.01486788f, -0.06236983f, 0.05677390f, -0.02988794f, -0.04104157f, 0.01345396f, -0.02336794f, 
    -0.00883899f, 0.06614156f, 0.03744138f, 0.00719076f, 0.02208419f, 0.00547563f, -0.05214548f, -0.05184859f, 
    0.04601558f, 0.02864107f, -0.05619136f, -0.00851050f, -0.06694262f, -0.07393365f, -0.03673970f, 0.07024729f, 
    -0.05247230f, -0.04603265f, -0.06085624f, -0.01134618f, 0.03485364f, -0.03255025f, -0.01052389f, -0.04676004f, 
    0.04310217f, 0.05801933f, -0.07349403f, 0.05690748f, -0.07258358f, 0.01296769f, -0.04490133f, -0.03496658f, 
    -0.07129539f, 0.00822374f, -0.03732474f, -0.01666327f, -0.02015878f, 0.00777665f, 0.04108164f, -0.01071479f, 
    0.03045520f, -0.01649600f, -0.02551474f, 0.05237176f, 0.05974522f, 0.05018174f, -0.06728449f, -0.02243641f, 
    0.07041387f, 0.06202203f, -0.04131015f, 0.00914764f, -0.05600004f, -0.01006955f, -0.06907840f, -0.00737208f, 
    0.02438593f, 0.06438122f, -0.07148056f, -0.03540898f, -0.05544778f, 0.04814317f, 0.05288137f, 0.00723815f, 
    -0.07746329f, -0.02378911f, -0.06090746f, 0.03663837f, 0.04532703f, -0.05239001f, 0.03798661f, -0.04639006f, 
    0.04137010f, -0.07036655f, -0.04250545f, -0.06154487f, -0.07237303f, -0.03097485f, 0.02831939f, 0.03878498f, 
    -0.05879249f, -0.06004733f, -0.07109729f, -0.00339321f, 0.03208383f, 0.05051695f, -0.03206338f, -0.01559354f, 
    0.03070675f, -0.07489941f, -0.03882575f, -0.06170217f, -0.07318346f, -0.05831873f, -0.01316074f, -0.07770582f, 
    0.06165205f, -0.00384960f, -0.05413839f, 0.05014771f, 0.02977680f, 0.05683191f, 0.06773583f, 0.00013211f, 
    -0.00159124f, 0.00007131f, -0.02457012f, 0.01650064f, 0.04441451f, -0.01591081f, 0.04049853f, -0.06121341f, 
    -0.04122190f, -0.02209698f, -0.07367124f, 0.01025058f, -0.07244594f, 0.05344727f, -0.06257792f, 0.04272741f, 
    -0.01479466f, 0.03155505f, -0.01490162f, 0.05295528f, -0.06680067f, -0.01634397f, -0.07306191f, 0.01410511f, 
    0.00205091f, 0.00619555f, 0.06272061f, -0.06162623f, 0.00414404f, -0.01372438f, -0.07790107f, 0.00081252f, 
    -0.02149730f, 0.01920404f, -0.03692025f, 0.05809324f, 0.04956552f, -0.00710984f, 0.06368941f, -0.01398178f, 
    -0.06134079f, -0.02999993f, 0.03674476f, -0.03191197f, -0.02214646f, -0.02173753f, -0.07412297f, 0.01288286f, 
    -0.02377705f, -0.02235422f, 0.00798088f, -0.04913131f, 0.01753354f, 0.02801538f, 0.06530089f, 0.04952431f, 
    0.00231513f, -0.07113578f, 0.06134500f, 0.04698354f, 0.01157701f, -0.04258068f, -0.00525444f, -0.03448678f, 
    -0.00223700f, -0.02436464f, 0.00827539f, -0.05643249f, -0.01013362f, -0.01406295f, -0.01038215f, -0.06929322f, 
    -0.00665169f, -0.01206559f, -0.05937671f, -0.05736821f, -0.07170100f, -0.01270120f, 0.01981453f, 0.00909663f, 
    -0.02565969f, 0.00122620f, 0.00807245f, -0.00256008f, -0.06694435f, 0.02309521f, -0.07016914f, 0.06552140f, 
    -0.07803898f, -0.05827330f, -0.03407554f, 0.02198347f, -0.08076604f, -0.00344389f, -0.02782954f, 0.00383101f, 
    0.03932985f, 0.04032539f, 0.04398082f, -0.06192798f, -0.03478406f, 0.00515586f, 0.01635202f, 0.05506733f, 
    0.06519928f, -0.07187293f, -0.02903895f, 0.01976481f, 0.02451146f, -0.02120067f, -0.05867573f, -0.02091632f, 
    0.04634844f, 0.06523971f, -0.05467370f, -0.04537829f, 0.00569738f, -0.05263359f, -0.06146844f, -0.01716490f, 
    0.05779818f, 0.04709032f, 0.01696070f, -0.02410974f, 0.02328619f, -0.06534249f, 0.03246241f, -0.02814184f, 
    0.04261885f, -0.04223695f, 0.01672700f, -0.06736036f, -0.03979807f, 0.06120784f, 0.04633129f, -0.03994644f, 
    0.02973387f, -0.00477797f, 0.06392679f, -0.03387517f, 0.02624069f, 0.06290438f, 0.04185953f, -0.05282974f, 
    0.00857619f, 0.01338724f, -0.05282464f, -0.00293540f, -0.02442764f, 0.02170442f, -0.01033357f, 0.04356745f, 
    -0.02539813f, -0.05628656f, 0.06879499f, 0.03647821f, -0.04977601f, 0.06108963f, 0.05072624f, -0.03036523f, 
    0.01848354f, -0.06218326f, 0.02625138f, -0.05002020f, 0.04073624f, -0.06183970f, -0.02901188f, -0.01461330f, 
    -0.03761428f, 0.00465983f, -0.07457338f, 0.06000221f, 0.01470840f, 0.00326854f, -0.00478348f, -0.02189923f, 
    -0.02150018f, -0.01975457f, -0.03205979f, -0.05085956f, 0.03210048f, -0.01447180f, -0.00626942f, 0.00974331f, 
    -0.04626235f, -0.00144448f, 0.00156933f, 0.01065987f, -0.07101824f, -0.06437667f, -0.08199526f, -0.05034142f, 
    -0.05360774f, 0.01978495f, -0.03883193f, 0.06855613f, -0.02008536f, 0.03510059f, 0.03144309f, 0.01566499f, 
    0.06576367f, -0.11824913f, -0.01549824f, -0.05454993f, -0.15478443f, 0.06651545f, -0.05635361f, -0.12868728f, 
    -0.08847585f, 0.04400467f, -0.07927524f, -0.04945376f, -0.08279666f, 0.08242016f, 0.05475947f, -0.03973196f, 
    -0.06056145f, 0.02905891f, -0.07115879f, 0.01840885f, -0.00930007f, -0.01253218f, -0.03208227f, 0.07014141f, 
    -0.11118332f, 0.06801045f, -0.01506786f, 0.05810095f, -0.00611337f, 0.00918212f, -0.01330052f, 0.00958559f, 
    -0.05635910f, 0.20526190f, 0.03909650f, 0.06259745f, -0.08867420f, 0.02926295f, -0.00324021f, 0.09206846f, 
    -0.05698416f, -0.08974094f, -0.11221015f, -0.02736047f, 0.08674767f, -0.00532768f, -0.05422308f, -0.06195888f, 
    0.07477868f, 0.00426709f, 0.08687209f, 0.01819894f, 0.00069939f, -0.03112686f, -0.08282311f, -0.06534080f, 
    0.08625306f, 0.00695533f, 0.01347798f, -0.09375114f, 0.08083457f, -0.10663518f, 0.11242768f, 0.10483883f, 
    0.06453000f, 0.04760370f, 0.04806739f, -0.14204201f, 0.11716370f, 0.02222895f, 0.02972399f, 0.00107187f, 
    -0.03519378f, -0.00793752f, 0.02587533f, 0.08045143f, -0.06064256f, 0.05588093f, 0.06513823f, -0.11718285f, 
    0.05565805f, 0.00125155f, -0.05503862f, -0.12884700f, -0.13865893f, -0.01255888f, 0.17024238f, -0.05676590f, 
    0.01516841f, 0.01287014f, 0.07531801f, -0.03641342f, 0.10186920f, 0.05279912f, -0.07853784f, -0.00521580f, 
    -0.08310236f, 0.02740627f, -0.06899989f, 0.00302118f, 0.00628378f, -0.06261782f, 0.03951292f, -0.08605334f, 
    -0.07660969f, 0.14004856f, -0.08101021f, -0.03448325f, -0.01404795f, -0.03991378f, 0.08304799f, -0.08016092f, 
    -0.00287764f, 0.12371615f, -0.14083995f, -0.05312429f, -0.04784686f, 0.01307346f, 0.01391900f, 0.02222553f, 
    -0.03167555f, 0.04296556f, 0.00831846f, -0.03380665f, 0.05174768f, 0.07066684f, 0.04985361f, -0.01462995f, 
    -0.03226124f, -0.08444466f, 0.01489914f, -0.07055160f, 0.06858467f, 0.00721158f, -0.03359959f, -0.07099319f, 
    0.03384133f, -0.01444423f, -0.11468111f, -0.04058892f, 0.11491662f, -0.15059231f, 0.08711099f, 0.04352520f, 
    -0.03670678f, -0.08830203f, 0.02768840f, -0.00417058f, 0.08407658f, -0.00904724f, 0.02841659f, -0.09604552f, 
    0.06458761f, 0.08218657f, -0.05731231f, -0.01560948f, 0.08794549f, -0.03659319f, 0.00712202f, 0.18306491f, 
    -0.14708890f, -0.01727961f, 0.11010996f, -0.05434543f, -0.00600454f, -0.03563147f, -0.01248191f, -0.01225747f, 
    -0.02662564f, 0.13478501f, -0.00708162f, -0.05282430f, 0.08431291f, -0.09594440f, -0.09119893f, 0.03067138f, 
    -0.01489122f, -0.00378328f, 0.11228762f, 0.07172031f, 0.16869164f, -0.09715147f, -0.02301239f, -0.06416083f, 
    -0.06629040f, -0.07224205f, 0.01853306f, -0.00533493f, -0.04329355f, 0.00274641f, -0.02406418f, 0.03771121f, 
    0.01499098f, -0.01737460f, 0.06404553f, 0.04134259f, -0.06002784f, 0.00716433f, -0.07803114f, -0.04998354f, 
    0.05932983f, 0.03057261f, -0.00248456f, -0.03412405f, -0.02997846f, -0.02467337f, -0.04875556f, 0.00292550f, 
    0.04473466f, -0.03013053f, 0.04510655f, -0.04254386f, -0.02302174f, 0.03685605f, 0.02651953f, 0.05156578f, 
    -0.03956492f, 0.02657113f, -0.05641723f, 0.01662709f, -0.02599653f, -0.00297398f, -0.01639000f, 0.03499871f, 
    -0.06185089f, -0.05136804f, 0.05581826f, -0.05796603f, 0.04418101f, -0.05782535f, -0.05323765f, 0.01039541f, 
    0.03814619f, -0.05519425f, 0.01753638f, -0.02968101f, -0.00828500f, -0.00374449f, 0.04830895f, -0.05218004f, 
    -0.02581971f, -0.00697593f, -0.00795585f, -0.04445121f, 0.01154234f, 0.02985460f, 0.02213667f, -0.03241679f, 
    0.04874007f, -0.05668762f, -0.05527838f, -0.06616787f, -0.04933880f, -0.05008545f, 0.03127234f, -0.07712667f, 
    -0.03330513f, 0.01225013f, -0.06322333f, 0.03626306f, -0.01153237f, -0.07769633f, 0.02007484f, 0.05532241f, 
    0.01747984f, -0.01307381f, 0.05768712f, 0.02132034f, -0.03709161f, 0.03541418f, 0.04098003f, 0.05243423f, 
    0.01380147f, 0.03065444f, 0.04610759f, 0.03250255f, 0.05521401f, -0.03078368f, 0.01402279f, -0.01395400f, 
    -0.00239723f, -0.01390634f, 0.06013697f, 0.05973353f, -0.04237275f, 0.01988923f, -0.04221821f, -0.05952403f, 
    0.01357421f, 0.05513989f, -0.04900941f, -0.03533624f, -0.06124118f, 0.05543376f, -0.04311537f, -0.03261842f, 
    -0.01213206f, -0.03688318f, -0.01094251f, -0.02314197f, -0.04264219f, 0.05018358f, 0.02775717f, 0.00079778f, 
    -0.02460708f, -0.00903677f, 0.06118769f, -0.03011579f, -0.01485327f, -0.02089249f, -0.00592188f, -0.03832844f, 
    -0.00581416f, 0.05512823f, -0.01095076f, 0.02621703f, -0.02737797f, 0.05845224f, 0.01246601f, -0.00871257f, 
    -0.00392439f, 0.00057856f, -0.04678776f, -0.08029226f, 0.06177548f, 0.01219951f, 0.01452067f, -0.07199326f, 
    0.01039716f, 0.01771799f, 0.03898208f, -0.06781168f, -0.01349906f, 0.00539241f, -0.01325716f, -0.02377812f, 
    0.00653612f, 0.01885438f, 0.05508874f, -0.07539448f, -0.04492389f, -0.07016568f, -0.00526793f, 0.00168720f, 
    -0.07251130f, 0.03988606f, -0.04461581f, 0.04714873f, -0.02080237f, -0.01608261f, 0.04163823f, -0.06283724f, 
    -0.06682110f, -0.04306081f, 0.02742803f, 0.00914859f, -0.00115875f, -0.01651909f, 0.06590620f, 0.04369545f, 
    0.02953121f, -0.04030444f, -0.01944035f, 0.00910282f, -0.06534076f, -0.06190639f, 0.02354941f, 0.00253540f, 
    -0.01091352f, 0.01708676f, -0.00902022f, -0.06659906f, 0.06759713f, -0.07926270f, -0.01135579f, -0.05403849f, 
    -0.09704966f, -0.05166876f, -0.04480890f, 0.04476305f, 0.23515619f, 0.03571862f, -0.04153780f, -0.01716464f, 
    0.16216497f, 0.00970108f, 0.09049936f, 0.09247156f, 0.26526028f, 0.06704649f, 0.17755029f, -0.04808328f, 
    0.12494526f, 0.13468991f, 0.20622967f, -0.06904115f, -0.02384004f, -0.02011119f, -0.05131399f, -0.02199324f, 
    0.00666123f, 0.15899786f, 0.00414989f, 0.07257667f, 0.20378962f, -0.09130409f, -0.20707834f, -0.01593828f, 
    -0.01276039f, 0.11028252f, -0.00628231f, 0.00063793f, 0.05498184f, -0.19897467f, -0.20734678f, -0.21594486f, 
    0.12455770f, 0.15570986f, -0.08937450f, 0.01658009f, 0.06839289f, 0.09668288f, -0.00666753f, -0.03341518f, 
    0.20906410f, -0.21996064f, 0.04305315f, 0.13929942f, -0.02362121f, 0.03407944f, -0.11090164f, -0.09063374f, 
    0.06133305f, 0.04960964f, 0.08706606f, 0.04094062f, -0.24055035f, -0.00779737f, 0.05452285f, -0.07391150f, 
    0.09694849f, 0.05608398f, -0.05295185f, -0.00405472f, -0.03984869f, 0.06141651f, 0.01955057f, -0.06518520f, 
    0.26309517f, -0.23711847f, 0.32182196f, 0.01002735f, 0.01322192f, -0.18780844f, 0.11091846f, 0.08319314f, 
    0.11543110f, 0.16023193f, -0.06263676f, 0.02768454f, 0.49287325f, -0.17578427f, 0.15127805f, 0.11024546f, 
    -0.16746929f, -0.00213553f, -0.01764649f, -0.04581756f, 0.03337221f, -0.04262637f, -0.03186953f, -0.01828594f, 
    -0.00214767f, 0.00824352f, 0.14950554f, 0.02919621f, 0.09351358f, 0.02667809f, 0.15132324f, -0.02370034f, 
    0.04873661f, 0.08033772f, -0.02553896f, 0.07792878f, 0.18634887f, -0.12582342f, -0.06555899f, 0.02204447f, 
    0.08336499f, -0.00593325f, 0.04343794f, 0.00646568f, 0.00866389f, 0.07584167f, 0.08757523f, 0.05169307f, 
    -0.02412342f, -0.00648284f, 0.11019128f, -0.09265675f, 0.00078542f, -0.09450859f, 0.05794672f, 0.14938897f, 
    -0.14135627f, 0.01130723f, -0.03024337f, 0.01488389f, -0.05889856f, 0.33642393f, 0.11803479f, -0.02871875f, 
    0.01593792f, -0.05335062f, -0.07571881f, -0.10507600f, -0.09351953f, -0.03396390f, -0.08406267f, 0.00083417f, 
    -0.03340817f, -0.16602710f, -0.01767895f, 0.02871678f, -0.04991527f, 0.00839006f, -0.09935928f, -0.13334605f, 
    0.05674175f, 0.04403061f, 0.04096982f, -0.03193034f, 0.02908361f, -0.05574377f, 0.02198355f, 0.05165690f, 
    0.18421154f, -0.17391114f, 0.01987652f, -0.13195059f, -0.03183160f, -0.05877385f, 0.08761215f, -0.02611217f, 
    0.14181797f, -0.11891925f, 0.01837331f, -0.15462744f, 0.09826006f, 0.02668223f, -0.05372104f, -0.15422885f, 
    -0.08744003f, 0.06177654f, 0.03034591f, 0.11877932f, -0.15304412f, 0.21392894f, -0.26406255f, -0.04357062f, 
    0.22198004f, 0.04305587f, -0.16445284f, 0.07647076f, 0.13372181f, 0.07020753f, 0.01176638f, 0.09724467f, 
    -0.07399783f, -0.01513682f, 0.14806737f, 0.11970321f, -0.06278041f, 0.00446257f, 0.00367034f, -0.12285406f, 
    0.06655753f, -0.00065400f, 0.12543654f, 0.07025377f, -0.07112104f, -0.16936633f, -0.15726034f, 0.07837844f, 
    0.01610548f, -0.17736214f, -0.02801285f, -0.01614810f, 0.03244779f, -0.00003429f, -0.08539838f, -0.19001424f, 
    -0.14049973f, 0.19639872f, -0.14299770f, -0.05222710f, -0.05320514f, 0.14547859f, -0.05311012f, 0.17020157f, 
    -0.00030289f, 0.21428595f, 0.00317986f, 0.17489868f, -0.14453867f, 0.16908319f, 0.04576094f, 0.10382568f, 
    -0.14601009f, 0.01569328f, -0.03814300f, 0.09198633f, -0.00604182f, -0.03573583f, 0.05904232f, 0.00632010f, 
    -0.11215575f, 0.07857261f, 0.12974024f, -0.08492313f, 0.22823000f, 0.10911374f, -0.04767131f, -0.03123517f, 
    -0.04679496f, -0.21639305f, -0.08945255f, 0.00853674f, 0.06332557f, -0.17158327f, -0.09583627f, 0.03254962f, 
    0.05065814f, -0.12972787f, -0.01040418f, 0.01597036f, 0.08628589f, -0.03589615f, -0.12590252f, 0.12883869f, 
    -0.30268729f, 0.12566055f, -0.20405440f, -0.05703279f, 0.10632316f, -0.00169689f, 0.04023915f, 0.04626331f, 
    0.00719874f, 0.02872155f, -0.06829195f, 0.08582486f, -0.09209268f, 0.07984584f, -0.26976281f, 0.04008328f, 
    -0.00944962f, -0.02396081f, 0.17074077f, 0.13600774f, 0.03234049f, -0.01008534f, -0.06171870f, -0.03793341f, 
    0.18123725f, 0.08639699f, 0.02051159f, 0.27964461f, -0.03016778f, 0.00315610f, -0.02495809f, 0.11110669f, 
    0.05286964f, -0.00475028f, 0.07373175f, 0.03590904f, -0.51499093f, 0.02551911f, -0.18959714f, 0.08972931f, 
    0.01961941f, 0.00729177f, -0.00465614f, -0.00941901f, -0.01740951f, -0.02689407f, -0.01554273f, -0.06784258f, 
    0.22578293f, 0.08515552f, -0.16576006f, 0.18386158f, -0.05667872f, 0.04808787f, -0.11430841f, -0.08296130f, 
    -0.00003405f, 0.08730567f, 0.17601223f, -0.03394026f, 0.25383845f, 0.07377104f, -0.14492001f, -0.01361582f, 
    0.08141105f, 0.09253676f, -0.02338846f, 0.05069753f, -0.03406933f, 0.10779534f, 0.01859416f, 0.16259326f, 
    0.01702502f, 0.11916236f, -0.00666405f, -0.16513549f, 0.08012699f, -0.02639890f, 0.03849400f, 0.09161562f, 
    0.08436673f, 0.07445130f, 0.17659394f, 0.14808294f, -0.17267030f, 0.04680284f, 0.13745451f, 0.02764508f, 
    -0.05002675f, -0.10321578f, -0.09087530f, -0.04950486f, -0.07418443f, 0.00168089f, -0.03587367f, 0.05269010f, 
    -0.19098651f, 0.21329699f, 0.08357543f, -0.12280457f, -0.04759170f, -0.00477961f, 0.03445274f, 0.15142234f, 
    0.06877625f, 0.04944170f, 0.07874172f, 0.12993908f, 0.05368853f, -0.04016162f, -0.06719568f, 0.16375856f, 
    0.06899047f, -0.00231960f, 0.10213332f, -0.12565012f, 0.04911499f, 0.07647686f, 0.10281076f, 0.10821185f, 
    0.05070451f, 0.05971193f, 0.08501872f, -0.20487539f, -0.20155476f, -0.06852786f, 0.05892156f, 0.01250387f, 
    -0.00093653f, 0.10416877f, 0.02074257f, -0.02189562f, 0.39406392f, 0.10230339f, 0.06645326f, -0.18294154f, 
    0.10114623f, 0.01777821f, 0.01463592f, 0.05883826f, 0.04038684f, 0.11512934f, -0.02943072f, -0.03501376f, 
    -0.00768084f, 0.08159170f, -0.13507625f, -0.05403185f, 0.03601581f, 0.02149846f, 0.06777690f, 0.01222094f, 
    0.01271547f, -0.16525495f, -0.02671821f, -0.14291072f, -0.17486738f, 0.09973259f, -0.18589887f, 0.03084619f, 
    0.06949214f, 0.09917545f, 0.02214772f, -0.05501024f, -0.15551111f, -0.05138071f, -0.07613102f, 0.01224746f, 
    -0.07217746f, 0.03996529f, 0.09314263f, 0.08719616f, -0.25068909f, -0.08435168f, -0.08045724f, -0.03588859f, 
    -0.03391232f, 0.02569900f, 0.07480391f, 0.03333373f, 0.15246266f, 0.17841633f, 0.13203770f, 0.36325404f, 
    -0.10782513f, -0.02458656f, -0.06178448f, -0.02363000f, -0.21691890f, -0.02859672f, -0.07529893f, -0.15732569f, 
    0.37158808f, 0.06968389f, -0.02086140f, 0.16766298f, -0.16754010f, -0.02764644f, -0.09837977f, -0.07327842f, 
    0.01398080f, 0.08907768f, -0.02063573f, -0.01403439f, 0.31334218f, -0.10983397f, 0.10120244f, -0.18408440f, 
    0.03401388f, 0.03124672f, -0.09565424f, -0.01476220f, 0.03444429f, 0.06860668f, 0.05016963f, 0.12760057f, 
    -0.01702182f, 0.01181404f, -0.19299500f, -0.05086582f, 0.09271494f, 0.00004514f, -0.06406044f, -0.09156045f, 
    -0.01131376f, 0.19973667f, 0.06498859f, 0.03791109f, 0.26362953f, 0.20188645f, -0.03866703f, -0.05655351f, 
    0.01337350f, -0.00398049f, 0.01714339f, 0.19509140f, -0.10243527f, 0.18054859f, -0.03806193f, 0.03295968f, 
    0.31223843f, 0.07436291f, -0.04385445f, 0.04667405f, 0.11159703f, -0.01966019f, 0.08823747f, 0.20145150f, 
    0.05174498f, -0.09641050f, -0.11942634f, 0.04326597f, 0.09256443f, 0.04854116f, -0.09008589f, -0.16966848f, 
    -0.01369849f, -0.04067459f, 0.03299622f, 0.18354723f, 0.02880932f, 0.14722811f, 0.00639117f, -0.06046555f, 
    0.08704265f, -0.10046884f, -0.00199103f, 0.01645468f, -0.15194489f, 0.04297070f, -0.04984331f, -0.00906475f, 
    0.00055980f, -0.08607274f, 0.08250548f, -0.04067468f, 0.11333001f, 0.10767203f, -0.17774841f, 0.19842800f, 
    -0.10714433f, -0.05484145f, 0.09974569f, -0.02759212f, -0.09347568f, -0.11609255f, 0.04207078f, -0.13093799f, 
    0.06353925f, -0.25370985f, -0.00571590f, 0.13576297f, -0.06541417f, -0.03452701f, -0.09435382f, 0.08965950f, 
    0.01910696f, 0.13263701f, 0.00007579f, -0.07909328f, -0.14966325f, -0.20292629f, 0.05583897f, -0.09824260f, 
    0.04116473f, 0.05328165f, 0.05231099f, 0.01787335f, -0.03048427f, 0.07723147f, 0.17291804f, -0.07760278f, 
    0.01517375f, 0.09700599f, 0.00943321f, 0.06008463f, 0.05868933f, 0.01215423f, -0.05910946f, 0.05600596f, 
    0.03378791f, -0.00528819f, 0.07753018f, -0.03937919f, 0.14403902f, 0.12831517f, 0.20968863f, -0.03156405f, 
    0.00173290f, 0.07226684f, 0.07981279f, 0.21731333f, 0.04588055f, 0.05554320f, -0.02921072f, -0.05949737f, 
    0.19134773f, 0.09231532f, 0.04877663f, -0.03109677f, 0.01564966f, -0.11106779f, -0.06161170f, -0.06870236f, 
    -0.05944766f, 0.04370850f, 0.00721427f, 0.02444575f, 0.03963824f, 0.14030731f, -0.13954198f, -0.15424438f, 
    0.06433716f, 0.03259973f, 0.10169239f, -0.12186479f, -0.02703636f, 0.12840325f, -0.04805588f, 0.10303882f, 
    0.13195553f, -0.03066589f, -0.04105997f, 0.03156535f, 0.04381351f, 0.13677089f, -0.06555445f, 0.08139622f, 
    -0.01565851f, 0.16191635f, 0.28668067f, -0.10495888f, -0.00767397f, -0.14470012f, -0.01812671f, 0.19770285f, 
    0.15199953f, -0.06087486f, -0.02396622f, -0.02082599f, -0.17180972f, 0.04736830f, 0.04714243f, -0.11574616f, 
    0.17645922f, -0.01977849f, 0.21439485f, 0.14655061f, -0.07688534f, 0.08244567f, -0.05526239f, 0.02796525f, 
    0.04670917f, 0.04864869f, 0.09807546f, 0.10304685f, 0.13383903f, 0.04320854f, 0.14913458f, 0.03395045f, 
    0.04279049f, -0.07331297f, -0.06026182f, -0.18361329f, 0.07179859f, 0.05255929f, -0.15015124f, -0.06856015f, 
    -0.12373673f, -0.02863524f, 0.05806564f, -0.20386857f, -0.01177036f, -0.01807910f, 0.10902354f, 0.01977227f, 
    0.03378842f, 0.02390745f, -0.03224377f, 0.12625526f, 0.30508876f, 0.03029626f, 0.02703458f, -0.13128556f, 
    0.03548483f, 0.04044046f, 0.05766485f, -0.02191565f, 0.00499149f, -0.02177044f, 0.13873196f, 0.10623819f, 
    -0.11429267f, -0.10020059f, 0.23263238f, -0.06721184f, 0.00997756f, -0.17704949f, 0.18623567f, 0.08396210f, 
    0.07493070f, 0.09893890f, -0.12528655f, -0.08092509f, -0.02928770f, -0.15665247f, 0.32648361f, -0.12431911f, 
    -0.07458316f, 0.07555813f, -0.04440901f, 0.02964710f, 0.05133792f, 0.00703838f, 0.08295569f, 0.09707575f, 
    -0.00065019f, -0.13971534f, -0.08387434f, 0.27837607f, -0.01382073f, -0.04091511f, -0.01027206f, -0.08843762f, 
    -0.03688891f, 0.07389534f, -0.13295029f, 0.09156923f, -0.14128831f, -0.06083202f, -0.15756629f, 0.36701268f, 
    0.00869904f, -0.04522030f, 0.10456796f, -0.06741239f, 0.05496588f, -0.06521747f, -0.09306888f, -0.03162634f, 
    -0.14231713f, -0.01666786f, -0.18235192f, 0.19650067f, 0.00713998f, -0.02353271f, 0.05516000f, -0.02269992f, 
    0.05902784f, 0.03836027f, -0.01924469f, 0.08733075f, -0.06272346f, 0.05549732f, -0.07420923f, -0.10950451f, 
    0.04924263f, 0.03765940f, 0.02496762f, 0.06049976f, 0.01413202f, -0.03257781f, 0.02844087f, -0.02414531f, 
    0.36656135f, 0.04820589f, -0.01135591f, 0.08135914f, 0.05438212f, 0.07356382f, -0.06156691f, -0.01686881f, 
    -0.05941422f, -0.09486394f, 0.02534687f, 0.00259519f, -0.07550651f, -0.11782064f, 0.00911707f, 0.11063386f, 
    0.00010902f, -0.12733163f, -0.20150635f, 0.17819463f, -0.02940637f, 0.03596663f, -0.07749608f, -0.07915042f, 
    0.29336169f, -0.02491093f, -0.05775533f, 0.03432940f, -0.08142433f, 0.05969936f, -0.03844282f, 0.11612982f, 
    0.00787907f, 0.04895275f, -0.00299531f, -0.03396951f, -0.08110765f, -0.18669951f, 0.05131309f, -0.12093712f, 
    -0.06981586f, -0.10929900f, -0.03387401f, 0.08712407f, -0.04357624f, -0.00470497f, 0.03972147f, 0.08832641f, 
    0.09899118f, 0.11027975f, 0.02543676f, 0.06194673f, 0.28926796f, 0.16393298f, -0.05945803f, -0.10066154f, 
    -0.03427230f, -0.05252223f, 0.01014479f, -0.16183537f, 0.24444483f, -0.01523238f, -0.08067290f, 0.19389319f, 
    0.16340165f, -0.05344499f, 0.05093014f, 0.02357927f, 0.05475239f, -0.07948239f, -0.00125500f, 0.06418525f, 
    -0.20736605f, 0.30282402f, -0.06464680f, 0.09840719f, -0.01728743f, -0.09288276f, -0.07717158f, 0.00852760f, 
    -0.03334320f, 0.22203402f, -0.06705133f, 0.16498646f, -0.14227700f, 0.05709841f, -0.15956338f, 0.19294387f, 
    -0.10177781f, 0.01071028f, -0.04891032f, -0.05206999f, 0.00097481f, -0.07581221f, 0.01252855f, -0.02875245f, 
    -0.16251488f, -0.18581389f, -0.07222942f, 0.02745662f, -0.11588546f, -0.13991462f, 0.01841362f, -0.01258759f, 
    0.03164218f, 0.06401264f, -0.01410068f, -0.04912974f, -0.45501292f, -0.18021113f, 0.15079707f, -0.11585224f, 
    0.06319769f, 0.09796696f, 0.02672700f, -0.02291957f, -0.04451667f, -0.04405010f, -0.06363750f, 0.01324937f, 
    -0.04126882f, 0.09578898f, 0.15975520f, 0.08327831f, 0.13472784f, -0.01693434f, -0.08823880f, -0.03498810f, 
    0.09826708f, 0.12373201f, 0.05388545f, -0.01835172f, 0.14347836f, -0.11067673f, 0.06766971f, 0.10004579f, 
    0.01262201f, 0.03329078f, -0.01832980f, 0.15286076f, 0.09423950f, 0.10430881f, 0.07399164f, 0.12288559f, 
    0.18325101f, 0.00880092f, -0.00441323f, 0.08639718f, 0.03847178f, 0.03536047f, 0.02028618f, -0.00504310f, 
    0.00644924f, 0.06693609f, 0.05607441f, 0.02339721f, 0.04776698f, -0.13937956f, -0.01366859f, 0.12799425f, 
    0.05426697f, -0.15771472f, -0.01089053f, 0.00414898f, 0.09193080f, -0.01769779f, 0.06178714f, 0.00677608f, 
    -0.35089591f, -0.10124197f, -0.12511732f, -0.08447108f, 0.08437216f, -0.14260933f, 0.03470504f, -0.03988624f, 
    0.12082043f, 0.02304619f, 0.02131263f, 0.02858034f, 0.53514123f, -0.00885011f, 0.03229008f, -0.24184556f, 
    -0.04723281f, 0.08053426f, -0.10584606f, -0.10184388f, 0.09067518f, 0.07004904f, 0.03811549f, 0.11887690f, 
    0.12363030f, 0.03719560f, 0.07165927f, -0.06501062f, 0.01406409f, -0.06119424f, -0.00149751f, 0.14349420f, 
    -0.08516445f, 0.10331969f, -0.08481388f, -0.14504331f, 0.04590111f, -0.07396168f, -0.18214333f, -0.30526644f, 
    -0.07407030f, 0.00326467f, 0.05179832f, 0.07564377f, -0.08559643f, 0.17971568f, 0.18682544f, 0.20717287f, 
    -0.34928554f, -0.31354687f, 0.01943458f, -0.17206359f, -0.02148579f, -0.02174720f, 0.19696370f, 0.08078448f, 
    -0.03404253f, -0.14250766f, 0.08011984f, -0.04408449f, -0.18206830f, 0.16809331f, 0.12341763f, 0.01389530f, 
    -0.11527495f, 0.04524317f, 0.05853503f, 0.02306957f, -0.07226098f, 0.08767542f, 0.11602133f, 0.16005409f, 
    -0.14345807f, 0.01866423f, -0.00017584f, -0.01182798f, -0.10397413f, -0.14772435f, 0.11067092f, 0.07412515f, 
    0.21201482f, 0.13402109f, 0.09709261f, 0.15442115f, -0.19738160f, 0.12731084f, 0.01490383f, -0.22792788f, 
    -0.20645392f, 0.10700585f, -0.04057818f, -0.00390413f, 0.08791524f, 0.12506792f, 0.06346335f, 0.07877452f, 
    0.24317798f, 0.16465347f, 0.16217344f, 0.26911941f, -0.02715769f, 0.03799711f, 0.12074673f, -0.10735456f, 
    -0.08623748f, -0.11110432f, 0.11335262f, -0.05239644f, -0.04612782f, -0.07714931f, -0.10875395f, 0.07221119f, 
    0.10984742f, 0.04059941f, -0.00917560f, -0.04043228f, -0.02520121f, 0.14006820f, 0.12730069f, 0.01999885f, 
    0.14659196f, 0.11789299f, -0.04653992f, -0.17635711f, 0.06592017f, 0.11938547f, -0.05963826f, 0.14853562f, 
    0.10357156f, -0.01892795f, 0.06833715f, -0.04096361f, 0.29219434f, -0.10869830f, 0.00259253f, 0.05049948f, 
    -0.25531664f, 0.08869080f, -0.00116364f, 0.07676835f, -0.03233123f, -0.02287017f, 0.01613612f, 0.09121644f, 
    0.33972463f, -0.16843513f, -0.15499605f, -0.02210647f, -0.00116037f, -0.01599618f, 0.15835650f, 0.01510860f, 
    0.12522274f, -0.08640219f, -0.02165338f, 0.03728053f, -0.15067375f, -0.14027564f, -0.10047444f, -0.24258666f, 
    -0.01006233f, -0.04831222f, 0.18530947f, -0.04665234f, 0.02447639f, -0.00463261f, -0.02602726f, -0.08558538f, 
    -0.05624360f, 0.00109470f, -0.09667795f, -0.16155431f, -0.01209238f, 0.08343361f, 0.07718801f, 0.06137037f, 
    -0.10043536f, -0.16454771f, 0.05750570f, -0.15324053f, 0.20809285f, 0.27461126f, -0.00323790f, -0.04935791f, 
    -0.04866593f, 0.00446972f, 0.07793978f, 0.08958870f, -0.00427712f, -0.00251081f, 0.22798054f, 0.10068659f, 
    -0.13578263f, 0.38117698f, 0.15367100f, 0.13132755f, -0.03119207f, -0.08390987f, 0.05992501f, 0.18549246f, 
    0.06525975f, -0.00406070f, -0.07029114f, -0.15122090f, 0.21322700f, 0.01444610f, 0.19139843f, 0.16655318f, 
    0.09835142f, 0.20436098f, 0.02250219f, 0.26304075f, 0.01046700f, -0.01720776f, -0.04568335f, -0.12687999f, 
    0.19112262f, -0.30918425f, 0.14112054f, 0.16418645f, -0.01818048f, -0.05470232f, -0.02409024f, -0.04298243f, 
    -0.00771311f, -0.10083137f, 0.05680656f, 0.18447982f, 0.11673693f, 0.05222604f, -0.18855932f, -0.11345164f, 
    0.04340397f, 0.03364941f, -0.05138678f, -0.13167839f, 0.06310462f, -0.04270110f, -0.09869446f, -0.09277965f, 
    -0.05341887f, 0.29557502f, 0.02368093f, -0.13925649f, -0.03359334f, 0.00950491f, -0.04610400f, 0.09045342f, 
    0.07103769f, -0.00491775f, 0.07657111f, 0.10255165f, 0.01940198f, 0.20327631f, -0.33315644f, -0.00322940f, 
    -0.02498373f, 0.14051393f, -0.03698409f, -0.09161506f, 0.09277332f, 0.01763882f, 0.00978392f, -0.20276211f, 
    0.11233816f, -0.15292703f, 0.25390431f, 0.00582968f, -0.17022766f, -0.14461142f, -0.01585883f, -0.08773279f, 
    -0.12198198f, -0.05556103f, -0.00070761f, 0.13749443f, -0.00125282f, 0.20115989f, 0.19216800f, -0.04350821f, 
    -0.03562510f, -0.05902264f, -0.01352770f, 0.01323126f, 0.00426532f, -0.06766845f, -0.00296573f, 0.13859494f, 
    0.07385773f, -0.11226728f, -0.09392639f, -0.08811190f, 0.05800030f, -0.07155351f, 0.02597102f, -0.04864068f, 
    0.10529137f, 0.00855270f, 0.03972028f, -0.04704945f, 0.15427230f, -0.14394742f, 0.08131427f, -0.07253311f, 
    -0.10266379f, 0.18788783f, 0.01995684f, 0.16677558f, 0.05298324f, 0.06421626f, 0.16215946f, -0.00093140f, 
    -0.08336503f, -0.02165531f, -0.18353650f, 0.22372928f, 0.08673001f, -0.03725121f, 0.07991119f, -0.23233172f, 
    0.00250290f, 0.01443057f, 0.14281063f, 0.00964206f, -0.49986732f, -0.14454600f, -0.04002233f, 0.02226435f, 
    -0.04232602f, 0.03222680f, 0.08381919f, 0.09784712f, -0.04919013f, 0.01140623f, -0.08876976f, -0.01329590f, 
    0.14117685f, -0.00182504f, -0.09452167f, 0.01918622f, 0.14846785f, 0.07307343f, -0.20613316f, -0.12493063f, 
    -0.07371474f, 0.15829541f, 0.10170435f, -0.12042367f, -0.31892702f, 0.15811683f, -0.10453521f, -0.16602789f, 
    0.08055362f, 0.07968559f, -0.09938803f, -0.09487460f, -0.07172090f, 0.08221614f, -0.02550051f, 0.02293325f, 
    0.28077215f, -0.12386158f, 0.24383774f, 0.03758575f, -0.18239181f, 0.07307955f, -0.01479039f, -0.04056005f, 
    0.02169661f, -0.03965747f, 0.24325036f, 0.07832538f, 0.53094852f, 0.17459174f, 0.14402089f, -0.04259791f, 
    0.03652586f, 0.03460121f, -0.11983719f, -0.20393519f, -0.03773220f, -0.12572493f, -0.10844176f, -0.04698096f, 
    0.41257516f, 0.00188395f, -0.15821187f, 0.00145784f, 0.09795064f, 0.19309536f, 0.03902391f, -0.11766921f, 
    -0.01638895f, -0.01307376f, 0.18878525f, 0.04408884f, -0.00225612f, 0.14156760f, -0.13728593f, 0.07622177f, 
    0.06521720f, -0.10731971f, -0.00469699f, 0.04335265f, -0.02184631f, 0.06031025f, 0.10760645f, 0.02621421f, 
    0.07525236f, 0.09119261f, -0.09119143f, 0.28562835f, -0.00557295f, -0.04907277f, 0.08344876f, 0.05363739f, 
    0.00685181f, -0.01717059f, -0.01972649f, -0.03587834f, -0.42075467f, -0.00977008f, -0.03502814f, 0.08602227f, 
    -0.01913011f, 0.18820600f, 0.01098067f, -0.18670745f, 0.03358653f, -0.01136939f, 0.07392661f, 0.17512171f, 
    -0.45868877f, 0.13109332f, 0.13404247f, -0.04918930f, 0.00731899f, 0.00473916f, 0.10151023f, -0.00002103f, 
    0.07584883f, -0.02755922f, -0.15278400f, 0.03118971f, 0.25617626f, 0.17288758f, 0.32056710f, 0.24191836f, 
    0.06327876f, -0.14203800f, -0.10225663f, 0.04777380f, -0.01989111f, 0.09211984f, 0.00697687f, 0.07003996f, 
    0.00642053f, -0.00284631f, -0.13758533f, -0.01897017f, -0.03545206f, 0.05101823f, 0.15016697f, 0.01459961f, 
    0.03815310f, -0.03559017f, -0.09943444f, 0.14479905f, 0.08942912f, -0.07034335f, -0.00659298f, -0.24252714f, 
    -0.07648807f, 0.03621093f, 0.05150278f, -0.11714637f, 0.03898550f, 0.07087605f, -0.03869138f, 0.02079678f, 
    -0.11692888f, -0.13098301f, 0.08193650f, -0.24105373f, 0.15795437f, 0.02641389f, -0.00022666f, -0.08177124f, 
    0.06695343f, -0.06603229f, 0.01131439f, -0.01563776f, -0.29102519f, 0.09908794f, 0.02552698f, -0.26600972f, 
    0.02207881f, 0.03197823f, 0.17726156f, 0.09203788f, -0.06500328f, 0.11964572f, -0.01269842f, 0.05093884f, 
    0.20891665f, 0.00160651f, 0.15844835f, 0.35688666f, 0.06542619f, 0.08782544f, 0.04758240f, 0.10813291f, 
    -0.06468745f, -0.09011225f, 0.00542867f, -0.04996732f, 0.09100224f, 0.14815326f, -0.00925716f, 0.00929508f, 
    -0.04597619f, 0.07677815f, -0.13264039f, -0.03732482f, -0.02719334f, 0.06539725f, 0.01182147f, -0.04257469f, 
    -0.24298942f, 0.08765922f, 0.14579746f, -0.12225528f, -0.02588521f, 0.10458982f, -0.07976843f, 0.01686925f, 
    -0.02643549f, 0.04469232f, 0.05679571f, -0.07487361f, 0.01583730f, 0.13094491f, -0.07391449f, 0.15724909f, 
    0.00561630f, 0.04421684f, -0.11851189f, -0.12406135f, 0.07588423f, -0.01910602f, 0.00715885f, -0.12297553f, 
    -0.05569541f, -0.01600652f, 0.01974996f, -0.08880703f, -0.12335002f, -0.10231201f, 0.04062442f, -0.03006279f, 
    0.10085783f, -0.03689587f, -0.11524919f, -0.00377661f, 0.09796977f, -0.07749784f, 0.09819466f, -0.02207218f, 
    0.06127378f, 0.17838970f, -0.01100740f, 0.13162336f, 0.03185225f, 0.16170964f, 0.00438386f, 0.02917427f, 
    0.11022152f, 0.12504475f, 0.23994917f, 0.16563009f, 0.00874322f, 0.01932576f, 0.04640843f, 0.04603913f, 
    -0.00415906f, -0.05555874f, 0.06052077f, 0.01975684f, -0.04287700f, 0.14043060f, -0.16246885f, 0.27692088f, 
    -0.01786121f, -0.09918198f, -0.05434792f, 0.08651360f, 0.07960986f, 0.07535633f, -0.10438704f, -0.02521313f, 
    0.05735586f, -0.05244963f, -0.03998854f, -0.00113219f, -0.04057607f, -0.07154719f, -0.04654656f, -0.02184186f, 
    0.01341898f, -0.05226034f, -0.03471851f, 0.00227794f, -0.06660295f, -0.02570885f, 0.05755895f, -0.01865962f, 
    0.04050857f, -0.06362239f, -0.05879649f, 0.00494268f, 0.03552325f, 0.01126509f, 0.01766295f, -0.08047423f, 
    0.01847707f, 0.02187130f, -0.03298132f, 0.04240339f, 0.02569848f, 0.06390556f, -0.02282450f, -0.02061365f, 
    -0.06440059f, 0.01521843f, -0.07635012f, 0.02432065f, -0.07620575f, -0.01772117f, -0.07950471f, -0.02894694f, 
    0.01036599f, 0.00111819f, -0.03364034f, -0.05726269f, 0.06207963f, 0.01084263f, 0.04403671f, 0.00228856f, 
    -0.04665358f, -0.06557951f, -0.06273372f, -0.05661197f, 0.02677747f, -0.04449066f, -0.04821649f, -0.02573528f, 
    -0.04646429f, 0.02645933f, -0.04578904f, 0.04149904f, -0.01159482f, -0.05119790f, -0.04810353f, -0.03749883f, 
    -0.05199491f, -0.01344724f, 0.00583927f, 0.02244931f, -0.03355076f, 0.02613925f, -0.05622309f, 0.00918640f, 
    0.03490581f, -0.02558744f, 0.01406619f, 0.01262781f, 0.06431191f, -0.00797425f, -0.01257485f, -0.06161852f, 
    -0.02221576f, -0.04697802f, 0.04414995f, -0.00512931f, 0.01620642f, 0.00051334f, -0.06340941f, 0.02541645f, 
    -0.03641759f, -0.00791933f, 0.02803445f, -0.01049226f, 0.03221685f, 0.03809733f, 0.01980871f, 0.02707889f, 
    -0.02280036f, -0.05454631f, 0.00657463f, -0.02883666f, -0.00448979f, 0.03661496f, -0.05386908f, 0.05997872f, 
    -0.00277100f, -0.07794202f, 0.04096261f, 0.00693401f, 0.00640656f, 0.03148880f, -0.05133064f, 0.03716704f, 
    -0.06730881f, -0.02396681f, -0.01552074f, -0.05124598f, 0.01821569f, -0.04820034f, -0.05361573f, 0.04121000f, 
    0.04901966f, -0.00513910f, -0.04135721f, -0.02836048f, 0.05517501f, 0.01242833f, 0.02413884f, -0.07361756f, 
    0.04080854f, -0.00977261f, 0.02594830f, 0.00203692f, -0.01864946f, 0.04731125f, -0.07357039f, 0.02380407f, 
    0.02038780f, -0.06087314f, -0.07007611f, 0.02850718f, -0.02218382f, 0.05774655f, 0.05622848f, 0.00512080f, 
    -0.05224633f, -0.05201278f, 0.06603459f, 0.01144642f, -0.00221390f, -0.05945197f, -0.01752641f, -0.00441132f, 
    -0.06971036f, 0.03367728f, 0.02536744f, -0.06552695f, -0.02832525f, 0.04042882f, 0.04141663f, -0.07319881f, 
    0.06323579f, -0.07029860f, -0.04593789f, 0.00367124f, -0.00393718f, 0.03381494f, -0.04662140f, -0.04189304f, 
    -0.02432846f, 0.01967625f, -0.04816088f, 0.03734704f, 0.03229508f, -0.03123966f, -0.02321014f, 0.04677926f, 
    -0.06340076f, -0.01988422f, 0.01143572f, 0.04249228f, -0.04747484f, 0.05217245f, -0.00506737f, 0.00660960f, 
    0.03986200f, 0.06111424f, -0.06163255f, 0.04129477f, -0.03127022f, -0.00974442f, 0.05227813f, 0.00111912f, 
    -0.04685554f, -0.00368116f, -0.03526803f, 0.04508266f, 0.05975731f, 0.03409521f, -0.02034594f, -0.05948127f, 
    -0.07715061f, 0.01642562f, -0.05839275f, -0.07385215f, 0.04682688f, 0.02338754f, 0.05484281f, -0.02745543f, 
    -0.01887777f, 0.06543668f, -0.04199515f, 0.00833604f, 0.04351528f, 0.06102758f, 0.00609001f, -0.01794908f, 
    -0.04690524f, 0.00694703f, 0.05208080f, -0.06608424f, 0.03501232f, 0.02434319f, 0.04247570f, -0.02406801f, 
    -0.06400511f, 0.03784910f, -0.05453652f, -0.02050066f, -0.03932974f, -0.03520316f, 0.06064519f, -0.06173490f, 
    -0.06692208f, -0.03805462f, 0.04003615f, -0.01761639f, -0.03132485f, 0.00139224f, 0.04562696f, -0.02388354f, 
    -0.00609994f, 0.00164974f, -0.04198459f, 0.05957574f, -0.07543726f, -0.01576910f, 0.00118165f, 0.01524326f, 
    -0.05496743f, -0.01549352f, -0.04853056f, 0.03840383f, 0.03979077f, -0.01876424f, 0.00978828f, -0.01677120f, 
    -0.04104139f, 0.04207176f, -0.04141285f, -0.00128640f, 0.03343910f, -0.00702174f, -0.06923647f, 0.04413751f, 
    -0.00632722f, -0.02901214f, 0.01646350f, -0.02681236f, 0.02738122f, -0.06404674f, -0.07623293f, -0.01079094f, 
    0.01735051f, 0.01892781f, 0.05047230f, 0.01690128f, -0.07563833f, -0.04286057f, -0.02047752f, -0.03495968f, 
    -0.04181907f, -0.01417505f, -0.01226382f, 0.02249532f, 0.01070244f, -0.03936767f, 0.04366405f, -0.01873410f, 
    -0.02899393f, -0.03548802f, 0.05635281f, -0.01114653f, -0.06984917f, -0.02873044f, -0.00736997f, -0.02023722f, 
    -0.06060049f, 0.01094037f, 0.02239986f, -0.01417254f, -0.05611585f, -0.00644874f, 0.00914600f, 0.03048566f, 
    0.02384177f, -0.02325977f, -0.05801172f, -0.02472363f, 0.01851976f, -0.05775819f, -0.03590963f, 0.06050244f, 
    -0.04244411f, 0.01709975f, 0.05597367f, -0.05170229f, -0.06782448f, -0.03356848f, -0.06208569f, -0.03474199f, 
    -0.02595657f, -0.03508247f, 0.05122125f, -0.02666043f, -0.05447731f, 0.05064210f, -0.07157951f, -0.06784755f, 
    0.02732515f, -0.02523911f, -0.02592254f, 0.01279846f, -0.01109460f, 0.03655642f, -0.01170078f, 0.04404842f, 
    -0.07281704f, -0.02255799f, 0.02126067f, -0.07673986f, -0.00188217f, -0.07297546f, 0.04149933f, 0.02590768f, 
    -0.07092547f, 0.04473687f, -0.00687926f, -0.00368891f, 0.04140759f, -0.02989718f, -0.05915712f, -0.07384016f, 
    0.00309173f, 0.05082912f, 0.04312690f, -0.02832429f, 0.00292458f, 0.03819624f, 0.04970977f, 0.00280165f, 
    0.03154653f, -0.03879772f, 0.05445238f, 0.05225045f, -0.02046490f, -0.01652208f, 0.02433172f, -0.00480037f, 
    -0.00217715f, 0.00492167f, -0.03117394f, -0.00017119f, -0.07005932f, 0.04649891f, -0.00720981f, 0.00392141f, 
    -0.04303807f, -0.02605517f, -0.07459913f, -0.02842236f, -0.05206059f, 0.06086962f, 0.00847764f, -0.03499599f, 
    -0.25770929f, -0.07327651f, 0.16725931f, -0.15794183f, -0.06544621f, 0.08387865f, 0.09311424f, -0.00641614f, 
    0.06689756f, -0.08022236f, 0.04029416f, 0.08774374f, 0.26167107f, 0.18220997f, 0.02087079f, 0.22063653f, 
    0.07846750f, 0.01324219f, 0.00116208f, 0.06798071f, 0.08879040f, -0.05756913f, -0.07025775f, -0.08179504f, 
    0.18122961f, 0.10262988f, -0.03228581f, -0.14282846f, -0.08086292f, 0.11270300f, -0.04789016f, -0.02856671f, 
    0.08206626f, 0.14243853f, 0.02155114f, 0.11719317f, -0.09351324f, 0.08082256f, -0.14168850f, 0.08407701f, 
    0.15846600f, -0.03927416f, -0.02993836f, 0.07860269f, 0.05339951f, -0.04543326f, -0.06837773f, -0.10717936f, 
    0.04694061f, 0.13543405f, -0.11821410f, -0.19878815f, -0.05602622f, -0.12265783f, -0.12077211f, 0.00476977f, 
    -0.00967254f, -0.06682265f, 0.07090005f, -0.17620224f, 0.14530423f, -0.17457023f, 0.00879181f, 0.15034047f, 
    0.02446702f, -0.11401510f, 0.00143746f, -0.00493428f, -0.04955148f, -0.08789448f, 0.02157501f, 0.06422544f, 
    -0.30427662f, -0.00510597f, -0.35706419f, 0.00960488f, -0.01659231f, 0.12205616f, -0.08421895f, 0.12215495f, 
    0.03897696f, 0.06198234f, -0.10837459f, -0.01978712f, 0.08458856f, 0.32572412f, 0.02052003f, 0.03701780f, 
    -0.01821815f, 0.13335969f, 0.09385283f, -0.01606779f, 0.07680611f, -0.05624218f, 0.01813535f, 0.02372795f, 
    -0.11043318f, 0.02460854f, 0.09262598f, 0.19498658f, 0.00318256f, -0.01034175f, 0.06754237f, 0.04640432f, 
    -0.00355088f, -0.03264800f, 0.14653191f, -0.02485932f, -0.31047830f, 0.24352279f, -0.03770560f, -0.06676557f, 
    0.19791864f, -0.03837987f, 0.05267322f, -0.16762182f, 0.08348890f, -0.06921718f, 0.00715290f, -0.05169825f, 
    -0.15969850f, 0.17184879f, -0.04590649f, 0.09900457f, -0.02759619f, 0.09643188f, -0.02587359f, 0.06289709f, 
    0.06952368f, 0.04907326f, 0.16677438f, -0.05087318f, 0.02875542f, -0.08278613f, 0.04516459f, 0.14812852f, 
    0.11463360f, 0.13980263f, -0.08745734f, 0.20399559f, -0.09480166f, 0.05855440f, 0.11227630f, 0.16285115f, 
    0.01535574f, -0.10584492f, 0.12712896f, 0.18934062f, -0.05879446f, 0.02683172f, -0.07939763f, 0.03711114f, 
    0.11754583f, 0.13628514f, 0.09831229f, 0.08477674f, -0.32561737f, -0.01380761f, -0.11005463f, 0.20101313f, 
    -0.01841854f, -0.03306167f, -0.01742893f, 0.00664815f, -0.06611786f, -0.10516086f, -0.10962107f, 0.00915714f, 
    0.08938985f, -0.18815225f, 0.03109852f, -0.02515026f, 0.00988110f, 0.07330880f, 0.04390503f, 0.05844335f, 
    0.00432208f, 0.07088660f, 0.14148365f, 0.16026975f, -0.29522339f, -0.10197110f, 0.04274814f, -0.16491057f, 
    -0.03559275f, -0.18918678f, 0.09332334f, -0.06923047f, -0.10415173f, -0.04130261f, 0.10927124f, 0.13283660f, 
    0.02950166f, -0.16665880f, 0.01771053f, -0.02398650f, 0.09319709f, 0.00245759f, -0.04096413f, 0.10188979f, 
    -0.00797924f, 0.19307357f, -0.03890112f, -0.04111074f, 0.23656473f, 0.13791609f, -0.02432928f, -0.22363019f, 
    -0.03364024f, -0.03879870f, 0.08130562f, -0.12577836f, 0.01897694f, -0.04745799f, 0.06143195f, 0.03871147f, 
    -0.38175079f, 0.08846047f, -0.00133026f, -0.10718387f, 0.26595277f, 0.01387071f, -0.03070789f, 0.07998347f, 
    0.07037762f, -0.04161616f, -0.00199382f, -0.02827660f, 0.03824884f, 0.16805437f, 0.06021117f, 0.18568166f, 
    0.02185534f, 0.12194686f, 0.01586522f, 0.02236832f, -0.00396875f, -0.03343839f, -0.01643648f, -0.05905769f, 
    -0.12224095f, -0.10542911f, 0.03813089f, 0.03423960f, -0.09961452f, -0.00547511f, -0.05534057f, -0.03505306f, 
    0.17149104f, 0.07038970f, -0.03801202f, 0.09473027f, -0.18214975f, 0.05359333f, -0.09491850f, -0.06410851f, 
    0.02391205f, 0.10832807f, 0.00165299f, -0.00307488f, -0.09483644f, 0.04063622f, 0.00200518f, 0.08657815f, 
    0.44954786f, -0.04103367f, 0.27267599f, 0.09365891f, -0.08974757f, 0.00003766f, -0.04581312f, -0.18104842f, 
    0.01763872f, -0.05361422f, -0.04819194f, 0.08326619f, 0.35267526f, -0.21473253f, -0.00262914f, -0.05556563f, 
    -0.06202841f, 0.08363795f, 0.08417462f, 0.08357509f, -0.01004104f, 0.11378892f, 0.07525564f, 0.04765429f, 
    0.24166311f, 0.13326629f, 0.02586474f, 0.21255435f, -0.05834426f, 0.03365750f, -0.08091279f, -0.06073227f, 
    0.00842544f, 0.14919797f, -0.05117712f, 0.03541799f, 0.15868966f, 0.09867390f, -0.14580669f, 0.05600960f, 
    -0.09154794f, 0.01261839f, 0.04906852f, 0.09382291f, 0.00180240f, 0.11050644f, -0.04630905f, 0.00043335f, 
    0.33246076f, 0.05958584f, -0.14977345f, 0.10599564f, 0.02200351f, -0.08066859f, 0.11637688f, 0.05994937f, 
    -0.07120813f, -0.07394748f, -0.01755865f, 0.01821077f, 0.12445893f, 0.31988478f, -0.06792223f, -0.09325697f, 
    -0.12065931f, -0.11632743f, 0.14998485f, -0.12950043f, 0.01895284f, -0.05137897f, -0.04454928f, -0.12807740f, 
    -0.09811533f, -0.20348506f, -0.07307018f, -0.19484682f, -0.07919908f, -0.01166484f, -0.03949362f, 0.03394453f, 
    -0.10737793f, -0.11283661f, 0.12405493f, 0.02053309f, 0.04240593f, 0.06666463f, 0.03685349f, -0.08410861f, 
    0.06360672f, -0.05970095f, -0.03029986f, -0.02072872f, -0.16430604f, -0.07744520f, 0.17085521f, 0.03616595f, 
    0.05099037f, 0.16765936f, 0.13086769f, 0.12599619f, -0.02341929f, -0.04432636f, -0.06917627f, 0.14317451f, 
    -0.00184186f, 0.09400862f, -0.04310343f, -0.08387895f, -0.02414230f, 0.02313412f, -0.07489067f, 0.25900185f, 
    0.10601380f, 0.10492818f, 0.02660836f, 0.07512344f, 0.00952796f, 0.08732698f, 0.06652530f, -0.04305431f, 
    0.05704233f, 0.10075185f, 0.13230476f, -0.23120685f, 0.12902050f, -0.16992930f, 0.02452609f, -0.04261207f, 
    0.13420230f, 0.03574048f, 0.10084598f, -0.12770166f, -0.06751861f, 0.18867216f, 0.02621510f, 0.35659152f, 
    -0.10640020f, 0.04575257f, 0.12008060f, 0.12863345f, -0.04170999f, 0.03964079f, 0.13234758f, -0.05979737f, 
    0.17154965f, -0.03937351f, -0.23102117f, 0.15020822f, -0.00821125f, 0.06220675f, 0.12065776f, 0.13973802f, 
    -0.09906891f, -0.00706415f, -0.05750807f, -0.17553757f, 0.07704753f, 0.16386181f, -0.16606712f, 0.05232094f, 
    -0.17932136f, 0.07131943f, 0.02158590f, -0.07279734f, 0.13327426f, 0.00271607f, 0.06040724f, 0.17946255f, 
    0.13927774f, 0.03648535f, -0.17459165f, -0.20190519f, 0.14239956f, 0.14810091f, 0.10795254f, 0.21637262f, 
    -0.04948149f, 0.05285827f, 0.00055326f, 0.03814791f, 0.11003238f, -0.01081268f, -0.06249990f, 0.11626972f, 
    0.18272342f, -0.08196916f, -0.02294508f, -0.11786608f, 0.04528942f, 0.20874816f, 0.03826007f, -0.01076896f, 
    0.06959775f, 0.14299135f, -0.11962035f, -0.03592556f, -0.14566238f, 0.18979642f, -0.00984655f, -0.03923720f, 
    -0.00788766f, -0.09895040f, 0.16726299f, -0.03513334f, -0.15450194f, -0.04926633f, 0.07633238f, 0.09804676f, 
    0.13475603f, -0.14235538f, -0.16635060f, 0.08088401f, 0.00787170f, -0.02570581f, 0.06944974f, 0.01463819f, 
    0.07427590f, -0.18799704f, -0.07909250f, -0.23361745f, -0.03894205f, 0.04593499f, -0.29884434f, -0.03555052f, 
    0.06589710f, 0.06441315f, -0.06782848f, 0.12276854f, 0.78105605f, 0.12805106f, -0.08261973f, -0.08102958f, 
    -0.00293283f, 0.12321715f, -0.05017311f, 0.20142978f, -0.15087497f, 0.03262673f, 0.01749339f, -0.05095217f, 
    0.25990784f, 0.01804974f, 0.13660093f, 0.05667386f, -0.05299844f, 0.00106758f, 0.07898346f, 0.05401808f, 
    0.04053425f, -0.17569344f, -0.22203445f, -0.08170693f, 0.17112587f, -0.09470951f, -0.05430036f, -0.03771248f, 
    0.09098890f, -0.17993461f, 0.06802728f, 0.03062774f, 0.09676259f, -0.02731262f, -0.04396453f, -0.30890572f, 
    0.05370476f, 0.10099740f, 0.06398962f, -0.10384401f, 0.14199790f, -0.13187109f, 0.07769331f, -0.13847099f, 
    0.03030728f, -0.10261424f, -0.15101235f, 0.07501754f, 0.03946593f, 0.15111829f, 0.04510763f, -0.09046153f, 
    -0.07803009f, 0.08166477f, 0.02655723f, 0.04837693f, -0.02562307f, -0.04716302f, 0.02299644f, 0.06263454f, 
    0.38896558f, 0.17435385f, -0.12769768f, 0.13676347f, 0.00861662f, -0.02097959f, -0.06164873f, -0.03011755f, 
    -0.05052295f, 0.04372483f, -0.14319900f, -0.13987707f, -0.12255304f, -0.13251626f, 0.21686707f, 0.12799250f, 
    -0.05973232f, 0.08392987f, 0.08093461f, -0.26744375f, -0.08927906f, -0.01837243f, 0.12755135f, -0.09130082f, 
    -0.02840369f, -0.05646292f, 0.13860041f, 0.04448719f, -0.06617465f, 0.12303636f, 0.05066362f, 0.06103052f, 
    -0.03839508f, 0.06442564f, 0.00902678f, -0.01074134f, -0.03055523f, -0.20755832f, -0.20588613f, -0.21282822f, 
    0.02910924f, -0.14482188f, -0.08209828f, 0.04310014f, -0.04404004f, -0.03423950f, -0.08702939f, -0.04464757f, 
    -0.12628643f, 0.06271521f, -0.05531519f, -0.20139919f, 0.04670304f, 0.06404357f, -0.05777182f, 0.16721828f, 
    0.12017815f, 0.08942748f, 0.09995201f, 0.16300945f, -0.23495872f, 0.19431433f, 0.13496253f, 0.27009389f, 
    0.03102432f, -0.10344119f, 0.03110457f, 0.08209933f, -0.09283417f, -0.02333771f, -0.01738999f, 0.03456220f, 
    -0.14914675f, 0.14308326f, 0.11074474f, -0.11818788f, 0.18396987f, 0.00561182f, 0.02535779f, -0.00102081f, 
    0.05677554f, -0.13339306f, -0.06469408f, -0.01844264f, -0.09342508f, -0.05651779f, -0.10921261f, -0.02611278f, 
    0.01107473f, -0.01573116f, 0.05736645f, -0.05491675f, 0.14480048f, -0.14915757f, -0.09253899f, 0.14630876f, 
    0.02193699f, 0.08162414f, -0.29082865f, 0.18648712f, 0.06004364f, -0.01498051f, -0.00647961f, 0.04512232f, 
    -0.08762651f, -0.06422712f, 0.03075656f, 0.01763689f, -0.00596235f, 0.05390495f, -0.24040301f, -0.04695341f, 
    0.04386332f, 0.03304610f, 0.21237908f, 0.17377310f, -0.04120304f, 0.08022183f, 0.07643183f, 0.00487319f, 
    0.24490340f, 0.25554079f, 0.05407017f, 0.24216567f, 0.07347243f, 0.00892628f, -0.01126832f, 0.07840890f, 
    0.09594617f, 0.00340528f, 0.05880551f, -0.06904146f, -0.53584087f, 0.07444263f, 0.01892287f, -0.04076889f, 
    0.06460148f, -0.01994886f, 0.12133977f, -0.01483900f, 0.18376075f, -0.13209122f, -0.08351273f, -0.01097542f, 
    0.21645151f, -0.05846250f, -0.34292978f, 0.12176500f, 0.08385241f, -0.01439445f, -0.06378461f, -0.06578162f, 
    0.06858999f, 0.03481475f, 0.06040218f, -0.04144311f, 0.08230270f, 0.03883503f, -0.09548677f, 0.03138805f, 
    -0.02943788f, -0.00205956f, 0.01312019f, 0.16053854f, 0.06951904f, 0.07530451f, 0.04805465f, 0.11469015f, 
    -0.12270080f, 0.03131073f, -0.05431711f, -0.18424377f, 0.06658436f, 0.01772061f, 0.10476293f, 0.06966910f, 
    0.06714192f, 0.05430046f, 0.15669252f, 0.10272939f, -0.21229160f, 0.07622357f, 0.01645919f, 0.07513921f, 
    0.05085042f, 0.00197527f, -0.08218741f, -0.03587378f, -0.03638111f, -0.05648171f, 0.11205805f, 0.07412186f, 
    -0.28559068f, 0.25780851f, 0.30296022f, 0.04500484f, 0.03879854f, -0.04668328f, 0.05101777f, 0.17931981f, 
    0.07953617f, -0.02524558f, 0.14382103f, 0.00258726f, 0.16660170f, -0.08791378f, 0.08205832f, 0.15700947f, 
    0.06949493f, -0.02300879f, 0.10309374f, 0.10414407f, -0.01263809f, 0.04886503f, -0.06993385f, 0.01914733f, 
    0.28093386f, 0.00886164f, 0.01264097f, 0.26477402f, -0.14795068f, -0.03402952f, 0.01243745f, 0.09932604f, 
    -0.03886089f, -0.01196224f, 0.09908897f, -0.06122610f, -0.43098477f, -0.06203721f, -0.12602942f, -0.10413383f, 
    0.04409834f, -0.01782851f, 0.00004295f, -0.16655403f, 0.01450916f, -0.09888172f, 0.08780994f, 0.05344614f, 
    -0.44533986f, 0.36202699f, 0.13831991f, -0.07786308f, 0.01528086f, -0.00376401f, 0.02345012f, 0.18560019f, 
    0.12091551f, -0.07489769f, -0.04080735f, -0.04136867f, 0.05047833f, 0.27181181f, 0.41765407f, 0.19544999f, 
    -0.05629719f, -0.10477509f, -0.00888786f, 0.05086268f, -0.04320548f, 0.08870186f, -0.05233424f, 0.00336719f, 
    -0.00590271f, -0.00474951f, -0.01623279f, -0.03030526f, 0.03031461f, -0.03340797f, 0.13204332f, -0.16087927f, 
    0.01325588f, -0.12353646f, -0.17919949f, 0.15707976f, 0.21383263f, -0.19340205f, 0.17589130f, 0.08459109f, 
    -0.08004729f, -0.00042737f, -0.02955848f, -0.03996349f, 0.08938522f, -0.02654719f, -0.17119227f, 0.02693040f, 
    -0.21282965f, -0.00449670f, -0.07396177f, -0.20504603f, 0.11767862f, -0.05441536f, 0.00506535f, 0.09666494f, 
    0.07058792f, -0.03150092f, -0.04469075f, -0.05408292f, -0.21343970f, 0.21671996f, -0.03602857f, -0.18282779f, 
    0.01885309f, -0.01798548f, 0.18126646f, 0.14464492f, -0.01277629f, 0.07652694f, 0.03320497f, -0.05837405f, 
    0.16157494f, -0.03862752f, 0.07050306f, 0.28357109f, -0.02995327f, -0.02136618f, 0.01231795f, 0.02715951f, 
    -0.06067256f, -0.06389338f, -0.02924858f, -0.05710177f, -0.26056656f, 0.12996501f, -0.03388186f, -0.02525255f, 
    -0.00305791f, 0.05694732f, -0.06092804f, -0.02578840f, -0.06164809f, -0.08191939f, -0.08582542f, 0.01170539f, 
    -0.16408150f, 0.09398253f, 0.02638805f, -0.13468426f, -0.03895169f, 0.08722632f, 0.02716389f, -0.04476691f, 
    0.06185255f, 0.12059383f, 0.04239130f, -0.05383461f, 0.12510082f, 0.15673968f, -0.15156670f, 0.17005013f, 
    -0.01730224f, 0.06422409f, 0.06413036f, 0.05599755f, -0.03538644f, 0.05745982f, -0.00780486f, 0.07339544f, 
    0.19308980f, 0.03688397f, 0.13846980f, 0.02788064f, -0.08877076f, -0.02142049f, -0.02303073f, 0.06709811f, 
    -0.01045104f, -0.06762075f, 0.04807645f, 0.03247939f, 0.17137894f, -0.04859634f, 0.11949290f, -0.02529806f, 
    -0.05258083f, -0.00000049f, 0.12972517f, 0.11205115f, -0.04977622f, 0.10580833f, 0.06621624f, 0.08515435f, 
    -0.20596097f, 0.09480154f, 0.21340337f, 0.13476697f, -0.02356372f, -0.00666874f, 0.02186069f, -0.00362240f, 
    -0.02244810f, -0.01152583f, -0.00293058f, -0.06613628f, 0.09860142f, 0.02459808f, -0.06275233f, 0.29780558f, 
    0.00032919f, 0.00318620f, -0.02477441f, 0.13562690f, 0.06006896f, 0.07647657f, 0.02810143f, 0.01860818f, 
    0.27188802f, -0.13857329f, 0.00151945f, 0.06395020f, -0.10049252f, 0.06778162f, -0.05452299f, 0.05900778f, 
    -0.02217437f, -0.00899825f, -0.06147446f, 0.00179536f, 0.25577348f, 0.00951149f, 0.01208676f, -0.35093796f, 
    0.15320256f, -0.00083977f, 0.07859206f, -0.16772553f, 0.05266043f, -0.09017856f, 0.07216518f, 0.03578530f, 
    -0.30409026f, 0.14216672f, 0.09347555f, -0.19670154f, 0.12216876f, -0.02479679f, -0.11136787f, -0.05561390f, 
    0.12946321f, -0.01971380f, -0.00475278f, -0.02471739f, -0.37638429f, 0.13141221f, -0.12824956f, 0.01540523f, 
    0.06515358f, 0.19488907f, 0.03164171f, 0.00586621f, -0.05547746f, -0.01225733f, 0.07244686f, -0.11429040f, 
    0.12828541f, -0.28519189f, 0.05071378f, 0.08024975f, -0.12903517f, -0.04740563f, 0.03770087f, -0.10519195f, 
    -0.03457437f, 0.03038976f, -0.06389994f, 0.12395006f, 0.16365275f, -0.03125696f, 0.15186720f, 0.14297394f, 
    -0.11264092f, 0.00747990f, -0.07631379f, 0.04893919f, -0.03725899f, 0.00848862f, 0.05515634f, 0.01067927f, 
    -0.17963736f, 0.04431322f, 0.10961742f, 0.07839195f, 0.01363545f, -0.05389093f, 0.06364341f, -0.03357016f, 
    -0.02361052f, 0.02861349f, -0.03149913f, -0.05748066f, 0.24904960f, 0.07201800f, -0.03704655f, -0.14641280f, 
    -0.03348150f, 0.20313309f, 0.00150519f, -0.02548554f, 0.10074770f, -0.03105477f, 0.04121006f, 0.04959726f, 
    -0.15467550f, 0.00799011f, 0.01749470f, 0.09007107f, -0.01856755f, -0.05365264f, 0.17833498f, -0.05213843f, 
    -0.00705286f, 0.01859812f, 0.13326667f, 0.03682722f, 0.04108704f, -0.11277784f, -0.05321893f, -0.03799569f, 
    -0.01690834f, -0.04211604f, 0.00326124f, -0.03195897f, -0.01018321f, 0.02314669f, 0.04318528f, -0.00209424f, 
    0.00614231f, 0.01841410f, 0.00643990f, -0.10660543f, 0.17953482f, -0.03349099f, 0.09485546f, 0.02310602f, 
    -0.00655794f, 0.09174146f, 0.01197268f, 0.05208012f, -0.20746942f, 0.25468090f, -0.05934456f, -0.23542006f, 
    0.06811211f, 0.05287711f, -0.05399790f, 0.12787609f, -0.00827328f, -0.05413622f, -0.02111386f, 0.10658519f, 
    0.17097105f, -0.22738470f, 0.10577741f, 0.20870037f, -0.23461878f, 0.01209631f, -0.04215046f, -0.02327309f, 
    0.07664409f, 0.09296626f, 0.18271819f, -0.00783233f, 0.11653067f, 0.11148030f, -0.09217399f, 0.09137347f, 
    0.01586654f, -0.13061933f, 0.04756735f, 0.00272162f, -0.10035528f, -0.06801026f, -0.04961354f, -0.06424472f, 
    0.00954929f, -0.14022247f, -0.08299448f, 0.06034360f, 0.03262307f, -0.04229673f, -0.05134019f, -0.05797284f, 
    -0.05603305f, 0.07354384f, 0.09064188f, 0.00665967f, 0.07044187f, 0.21153367f, -0.18434137f, -0.01104511f, 
    0.05138374f, 0.02099884f, -0.06551015f, 0.20567730f, -0.01745991f, 0.07079772f, 0.01904531f, 0.13803804f, 
    -0.37569299f, 0.08950404f, 0.14325285f, -0.14755890f, -0.08472386f, -0.07677455f, -0.12961863f, -0.14222790f, 
    0.21574521f, -0.00566938f, 0.00170971f, 0.03429290f, -0.28638482f, -0.09951587f, 0.26645821f, 0.07720759f, 
    0.11165646f, 0.03027802f, 0.06777889f, 0.21877876f, -0.05569002f, -0.06384957f, 0.00238246f, 0.15735573f, 
    0.18743783f, -0.05104849f, -0.16953687f, 0.04771470f, -0.00651775f, 0.06742802f, 0.15780541f, 0.05071212f, 
    0.02706352f, -0.03391981f, -0.00382338f, 0.23161410f, 0.20536046f, -0.29015908f, 0.07227743f, 0.06723425f, 
    0.10359959f, 0.00438751f, -0.04615184f, 0.05784213f, -0.07486364f, -0.03334189f, -0.06294373f, 0.14138742f, 
    -0.48508340f, 0.01899560f, -0.07902952f, -0.28308594f, 0.11248041f, 0.08195127f, 0.06000782f, 0.11540573f, 
    0.05421798f, 0.15820783f, -0.15636484f, 0.07984079f, -0.01462945f, -0.11113391f, -0.13553798f, -0.10259958f, 
    -0.06449625f, -0.14550315f, -0.09841102f, -0.00133461f, -0.20807692f, 0.04837894f, 0.05465749f, 0.05034317f, 
    0.04143075f, 0.05967365f, -0.01802866f, 0.00566249f, 0.18887654f, 0.13621786f, 0.06072330f, 0.22146752f, 
    0.15533403f, -0.16670673f, 0.03805790f, 0.05510489f, -0.20693947f, -0.27465674f, -0.06840874f, -0.08535506f, 
    0.18089187f, 0.16417328f, -0.03209522f, 0.17063260f, -0.02255912f, -0.16094150f, -0.02212963f, 0.12852859f, 
    0.15417378f, 0.05394454f, 0.00060787f, 0.26898238f, 0.07817747f, 0.01647812f, -0.16160305f, 0.02270508f, 
    0.12489298f, 0.03926422f, -0.18664952f, -0.01249946f, 0.25934747f, 0.19951725f, -0.07433825f, -0.05934855f, 
    0.24227618f, 0.13668382f, 0.10138311f, 0.21546014f, 0.03668436f, 0.25423768f, -0.08839323f, 0.00993064f, 
    -0.03584398f, 0.16024993f, 0.07785830f, -0.01354998f, 0.09882848f, -0.07525681f, 0.21913807f, 0.05860037f, 
    0.16934904f, -0.19340928f, -0.15702160f, -0.07961331f, 0.37142405f, 0.05486643f, 0.23911731f, 0.32428893f, 
    0.19459347f, -0.12976781f, 0.00554355f, -0.04023774f, -0.00760572f, -0.08222473f, 0.03631562f, -0.25387251f, 
    -0.21165088f, 0.32474336f, -0.22914313f, -0.40751481f, 0.06938303f, -0.04283896f, -0.00013534f, 0.03249859f, 
    0.03316252f, -0.09413427f, -0.02619525f, 0.02418322f, -0.31356859f, 0.07486021f, 0.03735353f, -0.16737442f, 
    -0.06340194f, -0.00830564f, -0.06963826f, -0.08260980f, 0.02175141f, -0.01715426f, 0.14121917f, 0.18000007f, 
    0.03559662f, -0.11632467f, 0.20698203f, -0.08795839f, -0.07423377f, -0.10751604f, -0.06781537f, -0.06507403f, 
    0.03558865f, 0.07581733f, 0.00145108f, -0.03122550f, -0.21846955f, -0.21054421f, 0.15560494f, 0.16358133f, 
    -0.20397985f, 0.02996122f, -0.09765550f, -0.05025498f, -0.00565253f, 0.11533904f, 0.03816485f, -0.16697103f, 
    0.07761814f, -0.11154959f, 0.09911722f, -0.07451676f, 0.13657601f, 0.02988122f, 0.02133969f, -0.04242010f, 
    0.03793904f, -0.09222765f, 0.02084821f, -0.02285740f, 0.33129147f, -0.07954679f, -0.02549952f, 0.07300412f, 
    -0.02259882f, -0.08489829f, 0.02714138f, 0.09627006f, 0.02786467f, 0.09797913f, -0.23121434f, -0.10576653f, 
    0.41476065f, -0.09383923f, -0.13674700f, -0.04245484f, -0.05447804f, 0.06539804f, -0.09540515f, -0.02472977f, 
    0.00135444f, 0.16733328f, 0.12859245f, 0.00695384f, -0.19400063f, -0.06076784f, -0.28256851f, -0.18223327f, 
    -0.02641541f, 0.11213092f, 0.07450292f, 0.10410176f, -0.03137705f, -0.04063731f, 0.03107736f, 0.00706473f, 
    0.05064415f, 0.07393613f, 0.14154978f, 0.01233001f, 0.07439305f, 0.03761257f, -0.14459860f, -0.04646698f, 
    -0.05036610f, -0.05128870f, 0.00741999f, -0.07612024f, -0.01718207f, 0.08274923f, 0.08432607f, 0.08468559f, 
    0.03737282f, -0.01666507f, 0.00984852f, 0.01142149f, 0.09105627f, -0.03795876f, -0.01861021f, 0.00168035f, 
    0.17653097f, 0.08967652f, -0.06538624f, 0.24672294f, -0.02661846f, -0.06874889f, -0.01398469f, 0.10278895f, 
    -0.05191642f, 0.02069090f, -0.00156550f, 0.11312226f, 0.16976573f, -0.04767077f, -0.08284768f, 0.24656238f, 
    -0.06543083f, 0.10057115f, -0.07451617f, -0.10717030f, 0.09601453f, -0.03344742f, -0.07313467f, 0.02606703f, 
    -0.23026344f, -0.06476054f, 0.04728773f, -0.11927818f, 0.05169224f, -0.02222926f, 0.10984064f, 0.04010520f, 
    0.11612704f, 0.02857033f, 0.10950238f, 0.00562344f, -0.41967946f, -0.15255640f, 0.09117691f, -0.11760820f, 
    0.12862618f, -0.04956331f, 0.12120765f, -0.10640316f, -0.02564590f, 0.03046664f, 0.03935437f, 0.10970524f, 
    0.24675964f, -0.09408490f, -0.00350373f, 0.13358517f, 0.13272732f, -0.04929494f, -0.03454998f, 0.00230944f, 
    0.03854221f, -0.07878714f, -0.03869436f, 0.00053454f, -0.13311507f, -0.14764197f, 0.08773731f, -0.11982433f, 
    0.07735106f, 0.08981843f, -0.09054455f, 0.10034705f, -0.12620243f, 0.02476822f, 0.11870354f, 0.12070446f, 
    0.10790340f, -0.06136592f, 0.06067259f, 0.06347306f, 0.10330509f, 0.01643885f, 0.06174403f, 0.02800838f, 
    -0.08180045f, 0.12393197f, 0.10942496f, 0.02989417f, -0.05835271f, -0.07647725f, -0.06624874f, 0.21186481f, 
    -0.04981993f, -0.02061384f, -0.03443798f, 0.00236883f, 0.06628793f, -0.16011541f, -0.01781011f, -0.02628162f, 
    -0.09162176f, -0.13141777f, -0.19496800f, -0.03863943f, 0.07464886f, 0.01968681f, -0.02227807f, -0.10567150f, 
    0.01934429f, -0.07040187f, 0.14707220f, 0.06116890f, 0.10984673f, 0.10733180f, 0.07362791f, -0.29778871f, 
    0.13990718f, 0.10084528f, 0.08338564f, 0.02562236f, -0.05278763f, -0.00100994f, 0.07632248f, 0.02422438f, 
    -0.00617148f, 0.03061092f, -0.02589641f, -0.02609177f, -0.00194171f, 0.03599067f, -0.08226962f, 0.04948029f, 
    -0.00307810f, -0.04993518f, 0.03452281f, -0.07790922f, -0.03039688f, -0.05556300f, -0.05905911f, 0.05344306f, 
    -0.04317974f, -0.02171679f, -0.03782364f, 0.00991735f, -0.06485381f, -0.08057831f, -0.05407654f, 0.01546297f, 
    0.01846291f, 0.04015170f, -0.03248582f, -0.06594024f, 0.00962611f, -0.04418385f, 0.02712615f, 0.06536858f, 
    -0.06718824f, -0.06368742f, -0.01842345f, 0.04676476f, -0.01664216f, -0.05780850f, 0.03709993f, 0.02525350f, 
    -0.04610984f, -0.07124846f, -0.07121996f, -0.04873566f, 0.05257137f, 0.03664828f, -0.06666486f, -0.05350428f, 
    -0.03654876f, 0.03877344f, 0.00900239f, -0.04046001f, 0.02294108f, -0.02457771f, 0.01219672f, 0.02976369f, 
    -0.03013329f, -0.04223387f, -0.07909794f, -0.06658307f, -0.00752669f, 0.00248318f, 0.01961503f, -0.07369453f, 
    0.05835962f, 0.01039566f, 0.02775184f, -0.01178825f, -0.03073763f, 0.02198909f, 0.06259853f, -0.01301875f, 
    -0.07616666f, -0.03113800f, 0.00428013f, 0.04159176f, -0.06858049f, 0.05123977f, -0.06396099f, -0.03703124f, 
    -0.07744636f, -0.04976067f, 0.05291346f, -0.00760557f, 0.00813428f, 0.00543468f, -0.04080194f, 0.01656784f, 
    0.05150512f, 0.05168247f, -0.01072828f, -0.03404769f, 0.02955811f, -0.04301479f, 0.01238543f, 0.01453809f, 
    -0.06276564f, -0.05658121f, -0.00872197f, -0.02885489f, -0.00547853f, -0.01350755f, -0.03921317f, -0.06429125f, 
    0.03697027f, -0.01529875f, 0.01007940f, 0.05119341f, 0.01917914f, -0.06400879f, -0.08485886f, -0.01956960f, 
    0.00113959f, -0.02778377f, -0.05838640f, -0.00617109f, -0.07072074f, 0.05953355f, -0.01916404f, 0.05248667f, 
    -0.02105542f, -0.05875971f, -0.03493407f, -0.06435295f, 0.02425229f, 0.05094000f, 0.04558563f, -0.06151287f, 
    0.01842697f, -0.01621968f, -0.02601109f, 0.01449729f, -0.04066981f, 0.01517131f, -0.02528876f, 0.04093291f, 
    0.06971357f, -0.04358111f, -0.04518299f, -0.00935292f, 0.01482483f, -0.04329204f, -0.02564669f, 0.03702531f, 
    0.03587984f, 0.04227613f, 0.03662612f, -0.01027059f, 0.05387610f, 0.04509667f, 0.01250404f, 0.01954689f, 
    -0.02427709f, 0.03206912f, -0.05662317f, -0.05662382f, -0.05848316f, 0.00594771f, -0.05818091f, -0.06341484f, 
    -0.01813100f, -0.05097780f, -0.00222342f, 0.05309512f, -0.06351352f, -0.04493789f, -0.02290801f, 0.00887033f, 
    -0.01161176f, 0.06540293f, 0.04298713f, -0.00374789f, -0.06789533f, -0.05930451f, 0.00477599f, 0.01063418f, 
    -0.05162562f, 0.02654204f, -0.04148625f, -0.02924305f, 0.03669395f, -0.05337719f, -0.04008305f, 0.03852824f, 
    -0.02493734f, 0.03657900f, -0.04367940f, 0.04689649f, -0.04223389f, -0.07541239f, -0.01787629f, -0.00855782f, 
    0.02673879f, 0.04448158f, -0.01530016f, 0.04125672f, 0.10051841f, 0.07886899f, 0.01825836f, 0.02555829f, 
    0.05159338f, -0.01399523f, 0.00738741f, 0.04068390f, -0.07177310f, -0.09765323f, -0.16008924f, -0.17832471f, 
    -0.00030250f, 0.10885617f, 0.05028409f, -0.07105055f, -0.12925376f, -0.00820393f, 0.04176242f, 0.01596794f, 
    0.09178032f, -0.28942516f, 0.18288882f, 0.07749776f, 0.15917282f, -0.08716427f, 0.04937747f, -0.09934518f, 
    -0.00029017f, 0.07255697f, 0.09868322f, 0.05658011f, -0.01295631f, -0.16587371f, -0.12053012f, 0.04095509f, 
    -0.00033024f, 0.01188973f, -0.03568731f, 0.06980831f, 0.10537900f, 0.12840162f, 0.01769266f, -0.00488628f, 
    0.20503765f, -0.13006847f, -0.03087774f, 0.11820458f, -0.03566209f, -0.12208578f, 0.09917346f, -0.04657552f, 
    0.13169402f, 0.00200158f, -0.06677292f, 0.05047610f, -0.06761922f, 0.17187202f, 0.04990168f, -0.32333958f, 
    0.11419210f, 0.06039127f, 0.03093133f, 0.03439101f, 0.09187032f, 0.12693006f, 0.18711548f, 0.09546214f, 
    -0.17809361f, -0.03441070f, 0.01924339f, -0.05775755f, 0.14376836f, -0.10953562f, 0.07312787f, 0.00868243f, 
    0.07389352f, 0.05682620f, 0.05789239f, -0.00122838f, -0.00434296f, -0.02630248f, 0.06506301f, 0.03914107f, 
    -0.00634928f, -0.01835913f, 0.05308140f, 0.07156511f, 0.02844826f, 0.03637808f, -0.05174459f, -0.01860220f, 
    -0.10623146f, -0.01476136f, 0.07662496f, -0.04898993f, 0.04011820f, -0.01064671f, 0.16997705f, -0.02378512f, 
    0.16609688f, 0.03564245f, 0.16393580f, 0.02107543f, 0.06906608f, -0.43901628f, 0.03707875f, 0.01712957f, 
    -0.18731809f, 0.01345670f, -0.05081894f, -0.11054400f, -0.01631881f, -0.05716248f, -0.07354455f, 0.01159535f, 
    -0.15443824f, -0.11537284f, -0.04880295f, -0.09677175f, 0.00037593f, 0.03163651f, -0.09977005f, -0.00456526f, 
    0.04903431f, -0.01185907f, -0.01569104f, -0.04899485f, -0.37998638f, -0.17712457f, -0.08977778f, -0.13203236f, 
    0.04981687f, -0.03931371f, -0.07678282f, -0.20684081f, -0.01235467f, -0.07871182f, -0.07218286f, 0.01216899f, 
    -0.00853655f, 0.01002585f, 0.13883334f, -0.01679975f, 0.13975906f, 0.01040322f, 0.01537887f, 0.02114030f, 
    0.07730665f, 0.05854939f, -0.02534650f, 0.08396690f, 0.25420237f, 0.21065778f, 0.13204630f, -0.12810604f, 
    0.17066486f, -0.12805527f, -0.07658051f, 0.07882705f, 0.02379218f, 0.13178906f, 0.01506862f, -0.01404262f, 
    0.28098419f, 0.07313105f, -0.04098460f, -0.09531204f, 0.02882153f, 0.06267575f, 0.01471100f, -0.08890681f, 
    0.10670843f, 0.02485322f, 0.12384614f, 0.11785627f, 0.14074355f, 0.29999518f, 0.06253514f, 0.12883118f, 
    0.06036556f, 0.03527198f, 0.00537646f, 0.13834287f, 0.00530614f, -0.01372810f, -0.03698008f, 0.06775290f, 
    0.13876198f, 0.11582759f, -0.03093873f, 0.08148611f, 0.04629518f, -0.18845309f, 0.03178373f, -0.02823399f, 
    -0.02823965f, 0.05958023f, 0.09578024f, -0.01146574f, -0.19415410f, -0.04405424f, 0.13261344f, 0.31488547f, 
    -0.02703766f, -0.17792098f, -0.07387978f, 0.15861040f, 0.04454437f, 0.03389968f, -0.02032450f, -0.01398066f, 
    0.04786194f, 0.17328267f, -0.24678157f, 0.04351680f, -0.12185301f, 0.04510994f, 0.11573175f, 0.14403266f, 
    -0.05088657f, -0.00174107f, 0.00188893f, -0.11759957f, 0.11418924f, 0.13450244f, -0.03103604f, -0.20888524f, 
    -0.16551474f, 0.09979060f, 0.10729979f, -0.10462322f, 0.05331838f, -0.04233411f, 0.07983518f, 0.06854624f, 
    -0.01838774f, -0.01538010f, 0.02986832f, 0.04184113f, 0.04404933f, 0.11283422f, -0.14412935f, -0.05502468f, 
    -0.15441014f, 0.11256776f, 0.09755270f, -0.00657385f, 0.13459407f, -0.06392564f, -0.14449440f, 0.14097500f, 
    -0.03735278f, -0.03712999f, -0.13495556f, -0.00149994f, -0.05196156f, 0.02717450f, -0.15959108f, -0.02573881f, 
    0.26132903f, -0.05890270f, 0.10990691f, -0.07922528f, -0.25746268f, 0.00177797f, -0.02710177f, 0.02785962f, 
    0.09019059f, -0.14310752f, -0.04578353f, 0.01278007f, -0.10521369f, -0.14682674f, -0.05437709f, 0.14012675f, 
    -0.04583334f, -0.10124218f, -0.15486395f, -0.14563222f, 0.01627824f, 0.02205035f, -0.04155849f, -0.05238596f, 
    0.08018208f, -0.23029129f, -0.00982418f, -0.33007449f, -0.05215411f, 0.01858016f, -0.19382276f, -0.03615715f, 
    -0.02982621f, 0.02453055f, -0.13940404f, 0.05918812f, 0.03307488f, 0.15226792f, -0.00993256f, -0.17589541f, 
    0.01267772f, 0.05872903f, 0.02636972f, 0.22246121f, 0.03330287f, 0.09802108f, -0.10117117f, -0.07736038f, 
    0.06199130f, -0.02337746f, 0.03225381f, -0.01350274f, -0.08998347f, -0.16820328f, 0.05089064f, 0.08056123f, 
    -0.07011976f, -0.08631378f, -0.03649032f, -0.03631851f, 0.20831667f, -0.17788707f, 0.17543525f, 0.02533388f, 
    -0.11005858f, 0.03217620f, 0.03965204f, -0.05855066f, -0.02050503f, -0.03585119f, 0.06497002f, -0.04970430f, 
    0.08448038f, 0.03904893f, -0.04482065f, -0.03594625f, -0.05423191f, 0.08709382f, 0.03331912f, -0.06721789f, 
    -0.05326749f, -0.20091388f, -0.02058297f, -0.07939512f, -0.09063284f, -0.08629311f, 0.03722524f, -0.05168051f, 
    -0.13077243f, 0.10490771f, 0.06489363f, 0.00104816f, 0.01392321f, -0.00999314f, 0.03518660f, 0.03624588f, 
    -0.24985196f, 0.00255783f, -0.02418560f, 0.06750734f, 0.00600664f, 0.04480429f, 0.03498267f, -0.11470471f, 
    -0.05978353f, -0.06322096f, -0.20329748f, -0.08290521f, -0.02343193f, -0.26148283f, -0.09172680f, -0.10307618f, 
    -0.08013612f, -0.00612654f, -0.04375110f, -0.14270413f, -0.05742706f, 0.01752564f, 0.00386805f, -0.07857468f, 
    -0.34693316f, 0.01221424f, 0.14970450f, -0.19134825f, 0.08743675f, 0.08785541f, 0.03682373f, -0.06355310f, 
    0.09706854f, 0.05154176f, 0.00711649f, 0.08316381f, 0.27390462f, 0.10539889f, -0.06163976f, 0.20579334f, 
    -0.03660167f, 0.08696711f, 0.09020049f, 0.07961382f, -0.03067425f, 0.02695928f, 0.02777389f, -0.01067990f, 
    0.47494161f, -0.27899212f, -0.05272945f, 0.12546852f, 0.01482629f, 0.08944189f, -0.01617797f, -0.18765400f, 
    -0.02373252f, 0.03255263f, 0.09941775f, 0.03122912f, 0.13031115f, -0.31104481f, -0.13550887f, -0.01517553f, 
    0.11297834f, 0.04623172f, 0.04164285f, 0.08615420f, 0.06357506f, 0.03940303f, 0.00033398f, -0.09748391f, 
    -0.05079244f, 0.20648122f, 0.16191849f, -0.06861713f, -0.05662711f, -0.13705266f, -0.13122889f, 0.11429411f, 
    0.08556168f, -0.00223541f, -0.05756319f, -0.10431577f, -0.33176330f, 0.33595559f, -0.08826441f, -0.23647568f, 
    0.00535694f, 0.01820070f, -0.05108548f, -0.06355063f, 0.02751696f, -0.00932506f, 0.13886063f, 0.02018568f, 
    0.18356392f, 0.01918209f, -0.20798051f, 0.00483953f, -0.00006823f, 0.03065295f, 0.10312285f, -0.04426000f, 
    0.01491269f, 0.03643180f, 0.08926810f, 0.10117677f, 0.17953271f, -0.13575953f, -0.03493830f, 0.04814298f, 
    0.00078750f, 0.09247200f, -0.02582350f, 0.04847708f, -0.08206499f, -0.09930202f, 0.00317346f, -0.00941619f, 
    0.09211078f, 0.14468905f, -0.07947521f, 0.14266498f, -0.06704530f, 0.02341270f, 0.02886702f, -0.02804383f, 
    0.10642581f, 0.05787549f, 0.06749707f, 0.03612173f, -0.08271798f, 0.00056705f, -0.03013464f, 0.22032581f, 
    -0.00051874f, -0.02384171f, 0.04755122f, -0.01797335f, -0.05867708f, 0.00484162f, 0.00282696f, -0.09334242f, 
    0.11501711f, 0.13524868f, -0.08861973f, 0.09031793f, 0.02747145f, 0.17540663f, -0.10505014f, -0.04146148f, 
    -0.02456662f, -0.06675468f, 0.13830566f, 0.03905226f, 0.06154528f, -0.06777726f, -0.04080540f, 0.16820171f, 
    0.20299354f, 0.08178341f, 0.10405455f, 0.00511573f, 0.01764333f, 0.08676051f, -0.07987756f, -0.00948798f, 
    -0.21622375f, 0.19970062f, -0.10689065f, -0.29058805f, 0.20174867f, 0.15358506f, 0.03735981f, 0.00339458f, 
    -0.01415264f, -0.01639606f, -0.00892451f, 0.08607242f, -0.06682438f, 0.16178934f, 0.06929994f, -0.12382802f, 
    0.11496961f, -0.04206172f, -0.08888333f, -0.06021923f, -0.04639233f, -0.09702846f, -0.04419063f, -0.05325238f, 
    0.35830951f, -0.06469383f, -0.04323480f, -0.27719998f, -0.10599807f, 0.10340623f, 0.03710920f, 0.07179567f, 
    -0.04677839f, -0.08341627f, 0.09354605f, 0.07661530f, -0.20015377f, -0.04355317f, 0.25020921f, -0.04533502f, 
    0.16594683f, -0.01680880f, 0.03285656f, 0.01218582f, -0.12408897f, -0.11731347f, 0.01416840f, -0.05728265f, 
    -0.16863231f, 0.31113645f, 0.12101053f, -0.03583912f, -0.16269615f, -0.07364268f, 0.09863626f, 0.01043389f, 
    -0.03627854f, 0.02324103f, -0.05547794f, 0.01992025f, -0.01418958f, 0.07626510f, -0.14010587f, 0.09052626f, 
    0.06488074f, 0.18231922f, 0.07314546f, 0.07378916f, -0.07068264f, 0.03521255f, 0.18647838f, 0.18710028f, 
    0.16072738f, -0.27948162f, 0.01692647f, 0.07205846f, -0.03772176f, 0.01749330f, 0.21604066f, -0.09643444f, 
    -0.05663079f, -0.17708114f, -0.10115340f, -0.12733857f, 0.21697579f, -0.18029189f, 0.00767309f, 0.22545794f, 
    0.11533848f, -0.08289009f, 0.08815441f, -0.00292153f, -0.11301438f, -0.03745173f, -0.13636649f, 0.04153756f, 
    -0.12694959f, 0.29350945f, 0.03652572f, -0.05110390f, -0.03969564f, -0.16918974f, 0.07074089f, 0.04679487f, 
    -0.06079178f, 0.11844989f, -0.08977508f, 0.03300375f, 0.19821009f, 0.30894864f, 0.13562995f, -0.11998688f, 
    -0.09159245f, 0.03606536f, -0.00496021f, 0.04691681f, -0.00881768f, 0.03615126f, -0.00540143f, -0.01469364f, 
    0.07841616f, 0.03842287f, -0.12395895f, 0.07806105f, -0.04774050f, 0.19681390f, -0.04311571f, -0.03685995f, 
    -0.10436146f, 0.02766179f, 0.14685245f, -0.03743638f, -0.10669144f, 0.07301835f, 0.05954034f, -0.12107693f, 
    0.18062669f, 0.05522164f, -0.16614309f, 0.09823347f, 0.00815328f, -0.03965421f, 0.22585404f, 0.08572730f, 
    -0.12424152f, -0.03914592f, -0.05965394f, 0.01649231f, 0.04873586f, 0.03947986f, -0.11337659f, 0.06952943f, 
    -0.07727471f, -0.02963832f, -0.04598223f, -0.02225884f, 0.20607230f, 0.00700211f, 0.02938260f, 0.06066867f, 
    -0.02705996f, -0.02112510f, 0.12918225f, 0.06153119f, -0.06825011f, 0.02014702f, 0.08785785f, 0.02282082f, 
    -0.13214232f, 0.15663989f, 0.02747610f, -0.03918740f, 0.08242152f, 0.24066849f, -0.03370236f, 0.09455948f, 
    0.07844108f, -0.06962733f, -0.07815919f, 0.02825752f, -0.07393648f, -0.11166152f, 0.04793917f, 0.31692195f, 
    0.11541829f, 0.00960140f, 0.16544594f, 0.12872629f, 0.00821481f, 0.09498562f, 0.01125621f, -0.10066364f, 
    0.00486213f, 0.33586070f, 0.06198058f, -0.13915150f, 0.03475657f, 0.10965879f, 0.04444604f, 0.10727107f, 
    -0.01023811f, -0.08555458f, -0.08140641f, -0.12020262f, 0.23514809f, 0.17384356f, 0.07140533f, -0.08326941f, 
    -0.13506722f, 0.22520772f, 0.02174251f, 0.07457412f, 0.11170180f, 0.08251950f, 0.05406657f, 0.01702737f, 
    0.21296100f, -0.29482335f, 0.12597854f, -0.04040683f, -0.16012105f, -0.11104088f, 0.01945542f, 0.08515306f, 
    0.09610652f, -0.16398439f, -0.16370480f, -0.22256713f, -0.07574883f, -0.09810337f, 0.31704021f, 0.06174539f, 
    -0.16600759f, -0.00441662f, 0.15842479f, -0.05779533f, -0.13038705f, -0.04453159f, 0.00894174f, -0.12464859f, 
    -0.44065505f, 0.03177001f, 0.12871520f, -0.11929072f, 0.05620245f, 0.16773041f, 0.00639373f, -0.02202371f, 
    0.10199098f, -0.01819238f, -0.02788676f, 0.05170858f, 0.22233319f, 0.02655021f, -0.06419151f, 0.13184647f, 
    -0.02397053f, 0.00911461f, 0.07101832f, -0.02794066f, -0.05971218f, -0.04875485f, -0.18246400f, 0.05695169f, 
    0.26733336f, -0.07706705f, -0.04077605f, 0.13867526f, -0.05256515f, -0.07441837f, -0.08627991f, -0.17166653f, 
    -0.04992654f, 0.16339287f, 0.06150099f, 0.04602266f, -0.26134670f, -0.07505513f, -0.27654386f, -0.09204222f, 
    0.08518468f, -0.02202321f, -0.06348307f, 0.21624839f, 0.07784311f, 0.01645742f, 0.01477157f, -0.12457985f, 
    0.10494008f, 0.03808699f, -0.17178203f, -0.01623661f, -0.06270598f, -0.07060137f, -0.01509303f, 0.07625462f, 
    0.05846868f, -0.11381084f, 0.03570872f, -0.09757937f, -0.20698790f, -0.27698261f, 0.04835889f, -0.10816927f, 
    -0.07239008f, -0.10641595f, 0.03674818f, 0.09615671f, -0.01804288f, 0.11738533f, 0.22844562f, 0.04892860f, 
    -0.22653261f, -0.07272996f, -0.18719161f, -0.02111360f, 0.12517737f, 0.02825891f, 0.01960295f, 0.13324535f, 
    -0.02384794f, 0.04748605f, 0.00879232f, 0.04755618f, 0.10389196f, 0.18852727f, 0.09451956f, 0.10264243f, 
    -0.08068272f, 0.03646095f, -0.00386005f, -0.01159423f, 0.04904624f, -0.05038202f, -0.15567763f, 0.00732883f, 
    -0.06021953f, 0.07049447f, -0.00369642f, 0.04938357f, 0.07195029f, 0.06319920f, 0.11269493f, -0.03498514f, 
    0.05484791f, -0.02460536f, 0.18932928f, 0.05154710f, 0.20548680f, -0.10846285f, -0.10243647f, 0.20201215f, 
    -0.06239844f, -0.03992281f, -0.05129202f, -0.21419400f, -0.03544578f, 0.04527103f, 0.10678022f, -0.07250058f, 
    -0.15916479f, 0.07979505f, -0.07197759f, 0.06961156f, 0.08464679f, 0.01035272f, -0.07192533f, 0.01578346f, 
    0.06172247f, 0.13648565f, 0.16782336f, -0.05211843f, -0.15272577f, 0.00034559f, 0.04894224f, -0.03893507f, 
    0.14045684f, 0.12042993f, 0.01502389f, 0.11313348f, 0.00379936f, 0.04020297f, 0.00721871f, 0.05383790f, 
    -0.11684602f, 0.09791606f, 0.04031788f, 0.01588120f, 0.10517293f, -0.11168686f, 0.07442647f, 0.07198423f, 
    0.15126814f, 0.17023714f, 0.04660235f, 0.11374734f, -0.26732674f, 0.08392797f, 0.06634698f, 0.06011724f, 
    0.13172235f, -0.18631543f, -0.11392020f, -0.07044354f, -0.02554390f, 0.05623213f, -0.17526862f, -0.11564018f, 
    0.37040412f, -0.03363184f, 0.02240512f, -0.16415977f, -0.03616060f, 0.06475031f, 0.05780987f, 0.13576257f, 
    0.10347095f, 0.00710223f, 0.15516728f, 0.13019894f, -0.22159521f, 0.16518892f, 0.10781599f, -0.09228837f, 
    0.14506079f, -0.08060292f, 0.06353422f, -0.06207787f, -0.01031504f, -0.06162887f, 0.02200624f, 0.11704431f, 
    0.38464847f, -0.13182847f, 0.11204726f, -0.06219440f, -0.16768762f, -0.03021262f, 0.13830194f, 0.05939036f, 
    0.04367651f, 0.05646819f, -0.07730312f, -0.12694296f, -0.05011890f, 0.04327375f, -0.21474807f, -0.10823052f, 
    -0.00787086f, -0.00091492f, 0.02071795f, 0.05445444f, 0.08728672f, 0.05958132f, 0.08110013f, 0.01833402f, 
    -0.47148123f, -0.00546147f, 0.03110634f, -0.28937271f, -0.07640719f, 0.16584289f, 0.10344958f, 0.15456037f, 
    0.06270116f, -0.04523272f, 0.01972894f, -0.02307403f, -0.22856268f, 0.46703985f, 0.00559370f, 0.22391155f, 
    -0.05142921f, 0.12968944f, -0.03311646f, 0.06182852f, -0.01310629f, 0.00237535f, 0.03473083f, 0.12110984f, 
    -0.05084109f, -0.01927795f, -0.07958477f, -0.05980841f, -0.00621762f, -0.03006043f, 0.15832850f, -0.00655213f, 
    -0.16040696f, -0.10015010f, -0.06700764f, 0.16129929f, 0.19069616f, -0.21673070f, 0.04300044f, 0.12848388f, 
    -0.07913154f, -0.05646418f, 0.11294245f, 0.02821529f, 0.11574662f, 0.04715483f, -0.06998734f, 0.14756301f, 
    -0.41346031f, 0.24506855f, -0.16861778f, 0.13231052f, 0.01649453f, 0.12595037f, -0.03525949f, -0.01026976f, 
    0.00609649f, -0.15237562f, 0.08326228f, -0.06310337f, -0.24245647f, 0.13882501f, 0.04470052f, -0.06725971f, 
    0.11573444f, 0.04614938f, -0.01709866f, 0.10862098f, 0.07326234f, 0.03561315f, 0.04264168f, 0.08845358f, 
    -0.11805078f, 0.01927635f, -0.06272298f, 0.03988019f, 0.01343907f, 0.11103100f, -0.13889575f, 0.11895528f, 
    -0.00430043f, -0.08251049f, 0.07854215f, -0.06072950f, 0.11215072f, 0.09593334f, 0.00608439f, -0.05650632f, 
    -0.10311531f, 0.07297400f, -0.07007943f, 0.06278235f, -0.03902549f, -0.11354436f, 0.00602127f, 0.02888047f, 
    0.16986246f, 0.01678342f, -0.10647018f, 0.14690475f, 0.11412970f, 0.01573750f, 0.00480732f, 0.04716533f, 
    0.12888077f, -0.03056922f, 0.00173299f, 0.07886263f, 0.05880856f, -0.07837090f, -0.10305249f, -0.07251041f, 
    0.01074062f, -0.10041877f, 0.00992982f, 0.14444594f, 0.13623476f, 0.11762032f, 0.07638336f, -0.03527159f, 
    0.14145079f, -0.22038941f, 0.08557995f, 0.13974288f, -0.10127813f, 0.02075789f, 0.01572629f, 0.13377056f, 
    -0.02395890f, 0.08428250f, -0.02599612f, 0.05816456f, 0.11308342f, 0.14606993f, -0.10382584f, -0.02602680f, 
    -0.17845611f, 0.11990728f, 0.11986187f, 0.02510140f, -0.01407384f, 0.09906793f, 0.02901401f, 0.05560192f, 
    0.03617578f, 0.20599456f, -0.06847320f, 0.24470408f, 0.03356225f, 0.03536819f, 0.06793571f, 0.07949308f, 
    0.06194378f, -0.05600914f, -0.04803261f, -0.05432458f, 0.07662067f, 0.02672053f, 0.13525245f, 0.08944651f, 
    -0.12063150f, 0.03064320f, 0.14485484f, 0.05116306f, 0.01968081f, 0.01023975f, -0.04118576f, 0.01400468f, 
    0.01785529f, -0.02570953f, 0.03282050f, 0.04488667f, 0.00402549f, -0.00061354f, 0.04037412f, -0.04921482f, 
    -0.07396710f, -0.07938656f, -0.01278953f, -0.01551404f, 0.05519377f, -0.03047474f, -0.05602050f, -0.00362779f, 
    -0.04558865f, -0.07604253f, -0.06296415f, -0.06947830f, 0.02522651f, -0.02464995f, 0.00386857f, -0.07125116f, 
    -0.02848379f, 0.01874316f, -0.01466768f, 0.04748718f, -0.03826458f, -0.06498250f, -0.07543094f, 0.05366752f, 
    -0.04457846f, 0.01313724f, -0.00004990f, -0.01822475f, -0.02529096f, -0.02616530f, -0.05770978f, 0.01303941f, 
    0.02195789f, -0.07354981f, 0.02171164f, -0.06591763f, 0.04845094f, 0.03997033f, -0.02447772f, -0.03155807f, 
    0.01870499f, -0.05384280f, -0.04001754f, -0.00636320f, -0.02616583f, 0.00615143f, 0.02026862f, -0.02020444f, 
    -0.07094907f, 0.01713443f, 0.04352251f, 0.00270241f, -0.06900370f, 0.04403586f, -0.00614455f, -0.07895204f, 
    -0.01921114f, 0.02100018f, 0.02227379f, -0.06749087f, -0.02245876f, 0.02541130f, 0.03344932f, 0.00047228f, 
    0.06258634f, -0.07855843f, 0.02685830f, -0.00952948f, 0.01894600f, 0.03211221f, -0.06385425f, 0.03314738f, 
    0.03026706f, -0.03367045f, -0.05178200f, -0.03779168f, -0.01240142f, -0.07256303f, -0.06237922f, 0.03959878f, 
    -0.05715007f, -0.06365613f, -0.02914955f, -0.04912805f, 0.05526448f, 0.01183272f, -0.05553837f, 0.02055245f, 
    -0.03849680f, 0.05014666f, 0.03780790f, -0.01956995f, -0.06547868f, 0.02786583f, -0.06418151f, -0.04933891f, 
    0.02398907f, -0.02371305f, -0.04639028f, -0.02114536f, 0.03527910f, -0.03068502f, -0.00629807f, 0.02555055f, 
    0.01155951f, -0.01449920f, 0.06083071f, -0.08060955f, -0.07043096f, 0.00245855f, 0.01985552f, -0.06831908f, 
    -0.01407923f, 0.03582100f, -0.05102742f, 0.02198474f, 0.04385018f, 0.01245105f, 0.00817025f, 0.05665207f, 
    -0.00270705f, -0.04567612f, 0.05371144f, -0.01697276f, 0.00708767f, -0.02550253f, 0.04430425f, -0.07094552f, 
    -0.00836186f, -0.01096750f, 0.04500390f, 0.03763121f, -0.07013240f, 0.01128603f, -0.04881825f, -0.00037783f, 
    -0.02437864f, 0.06264352f, 0.06339135f, -0.04065653f, -0.01466327f, -0.01690120f, 0.01392362f, 0.04224805f, 
    0.00760861f, 0.04625395f, -0.07798868f, -0.02553246f, 0.01497013f, -0.00885406f, -0.02910922f, -0.02132397f, 
    -0.02118874f, 0.00076337f, -0.08468152f, 0.02761590f, 0.03045761f, -0.03775806f, 0.00347855f, -0.00024206f, 
    0.04532858f, 0.03242562f, 0.00759241f, -0.06797889f, -0.03994076f, 0.02017197f, 0.01582841f, 0.05634550f, 
    -0.04591697f, 0.02700116f, 0.03470493f, -0.00133604f, 0.03948564f, -0.06388684f, -0.02641809f, -0.05834310f, 
    -0.08251737f, 0.02323526f, 0.03212892f, 0.05919611f, -0.02795949f, 0.05880940f, -0.07669295f, -0.07145303f, 
    -0.32652330f, 0.02843757f, 0.08440688f, 0.05931561f, 0.00132519f, 0.20241603f, -0.00480714f, 0.16307080f, 
    -0.06691773f, -0.00770656f, -0.01596779f, 0.02327430f, 0.00251457f, -0.19205034f, -0.31227195f, -0.23796597f, 
    0.09723554f, 0.03510066f, -0.03067834f, 0.02982453f, -0.10153385f, 0.07468817f, -0.03039177f, 0.12935004f, 
    0.00745393f, -0.26261073f, 0.16960156f, -0.00201062f, 0.08080349f, -0.03809201f, 0.05918369f, -0.01939274f, 
    0.16430570f, -0.02445474f, 0.04186746f, 0.20430730f, 0.00654539f, -0.08360082f, 0.23101577f, 0.14990114f, 
    0.19339725f, -0.12125131f, 0.08677810f, 0.04290617f, -0.12252779f, -0.01369331f, -0.05599321f, 0.09916034f, 
    -0.14955540f, 0.24297720f, 0.02463404f, -0.18946323f, -0.13173905f, -0.19525692f, 0.04899972f, 0.06407362f, 
    0.21027172f, -0.02763837f, -0.12101877f, -0.04522197f, -0.16882145f, 0.15790574f, -0.11016387f, -0.23810749f, 
    -0.04389139f, 0.02528018f, 0.08546585f, -0.10909028f, 0.02993799f, -0.02511328f, 0.15105122f, 0.15925874f, 
    0.35020706f, -0.11360697f, -0.10804599f, 0.12669824f, 0.10757414f, -0.00343409f, 0.09806278f, 0.03077100f, 
    -0.06281929f, 0.04971412f, 0.09443730f, -0.04823431f, 0.10037525f, 0.02391227f, -0.05888429f, -0.08659603f, 
    -0.00485659f, -0.03019018f, 0.16657005f, 0.05906688f, -0.12911402f, 0.01647272f, 0.06252667f, 0.01980063f, 
    0.09526251f, 0.26368162f, 0.08290377f, 0.18678814f, 0.06922514f, -0.07168991f, -0.01490149f, 0.11105853f, 
    0.06464090f, 0.03936804f, 0.10560337f, -0.00067866f, -0.26556203f, 0.08559471f, 0.02289068f, -0.00926687f, 
    -0.07414092f, -0.05208951f, 0.02193849f, -0.17256069f, 0.13653117f, -0.01152280f, 0.01371233f, 0.04438278f, 
    0.02277969f, -0.08101954f, -0.31252810f, 0.06799641f, -0.04520514f, 0.01457702f, -0.05410497f, -0.09212298f, 
    0.04473170f, 0.05535237f, -0.04958668f, 0.03996789f, -0.02654207f, -0.08008400f, -0.19239065f, 0.09142222f, 
    0.14935170f, 0.00289893f, 0.06573494f, -0.04767366f, 0.03426769f, 0.01929607f, -0.05196679f, -0.01826261f, 
    -0.32904252f, 0.02330302f, -0.14236628f, 0.02927942f, 0.10862065f, 0.05218064f, 0.06075017f, 0.04180243f, 
    0.05162362f, 0.08401570f, 0.08456504f, 0.10242636f, -0.22518130f, 0.06149315f, 0.08732048f, 0.16562968f, 
    0.03692960f, 0.02264374f, 0.00157361f, 0.07491899f, 0.00662687f, -0.01564489f, 0.08825877f, -0.04868963f, 
    -0.16597106f, 0.16141576f, 0.28677863f, -0.01908814f, -0.07433718f, 0.01057059f, 0.12454928f, 0.06476500f, 
    0.07864866f, 0.00261249f, 0.17235312f, -0.04804361f, -0.00302610f, -0.00783666f, 0.14895640f, 0.16724147f, 
    0.05964770f, 0.02212288f, 0.00691661f, 0.11747514f, -0.01625590f, -0.14739050f, -0.07985704f, -0.01635380f, 
    -0.08613278f, -0.00425162f, -0.07806526f, -0.06935989f, -0.04980185f, -0.07935690f, 0.05636964f, 0.04614124f, 
    -0.07108253f, 0.04042253f, 0.05233171f, -0.02814831f, -0.02635404f, 0.00543495f, -0.04015338f, -0.07063452f, 
    -0.05872229f, -0.06454686f, -0.05136291f, -0.06040141f, 0.02498214f, -0.08206639f, -0.05681277f, -0.07914080f, 
    -0.04305733f, -0.06083629f, -0.00712091f, -0.08209484f, -0.07404832f, -0.04153908f, 0.00596641f, -0.04177133f, 
    0.01196539f, 0.01395611f, -0.04100093f, 0.06365462f, -0.00368148f, 0.01410842f, -0.09508064f, 0.00754262f, 
    0.00726218f, -0.02724832f, 0.01353708f, 0.01954670f, -0.09915260f, 0.00050878f, -0.09331165f, -0.05488263f, 
    -0.06579085f, -0.04836667f, 0.06241540f, -0.01765115f, -0.06278442f, 0.03775860f, 0.05162288f, 0.00266971f, 
    -0.02982393f, 0.01241081f, -0.06544509f, 0.05298813f, -0.02605988f, -0.04364271f, -0.08637695f, -0.07167397f, 
    0.03881162f, 0.04663480f, -0.08436288f, 0.00382271f, -0.00448324f, -0.04016803f, -0.01072697f, -0.06406897f, 
    -0.00603884f, -0.08522105f, 0.02580274f, -0.08220347f, 0.03325462f, 0.03385892f, -0.06546064f, -0.00355903f, 
    0.03150511f, 0.03966311f, -0.07133016f, -0.02715064f, 0.03871671f, -0.09328717f, 0.04674103f, -0.06895122f, 
    -0.04610339f, -0.02350315f, -0.05062398f, 0.02752951f, 0.01004166f, -0.04599676f, 0.00381459f, -0.03409680f, 
    0.03556802f, -0.06131244f, -0.05516130f, 0.03662675f, -0.04885088f, -0.03452447f, -0.05487665f, -0.02344834f, 
    -0.01857533f, 0.05312674f, 0.06851174f, -0.02194794f, -0.09156620f, 0.02457773f, -0.01017343f, 0.04658587f, 
    -0.07476193f, -0.02638331f, 0.03382449f, -0.04564440f, 0.03917953f, -0.01781388f, 0.00990146f, -0.04173500f, 
    -0.05623153f, -0.03419130f, 0.03339917f, -0.03374507f, 0.01187242f, -0.03462373f, -0.06644569f, 0.01848940f, 
    -0.03282905f, -0.02002125f, -0.07009948f, 0.01206081f, -0.04400716f, 0.02706031f, 0.05529637f, 0.04533833f, 
    -0.01008116f, -0.05702563f, -0.01652329f, -0.07323910f, -0.05008517f, 0.05068366f, 0.04303344f, 0.02733636f, 
    -0.00708162f, 0.01832982f, -0.04012954f, 0.01687398f, 0.03636509f, -0.05818219f, 0.05831109f, -0.07501396f, 
    0.05509889f, 0.07400726f, 0.04903432f, -0.04766680f, 0.02658930f, -0.02113481f, -0.08140897f, -0.03528687f, 
    -0.05929429f, -0.03693457f, 0.05060109f, 0.03471284f, 0.01502947f, -0.04470920f, 0.00258831f, -0.03356583f, 
    -0.09806531f, -0.10850582f, 0.05364600f, 0.03986947f, 0.02337923f, 0.04382829f, 0.04530763f, -0.06159451f, 
    0.00635028f, -0.01852664f, -0.08674261f, 0.04590830f, 0.03677062f, 0.01544781f, -0.04364951f, 0.00595596f, 
    0.02665862f, -0.00828038f, 0.00878896f, -0.06203042f, 0.04340086f, 0.03839707f, -0.02804620f, 0.02365326f, 
    -0.04317134f, 0.00523986f, -0.03172788f, 0.00706107f, 0.05011020f, -0.05476673f, -0.01871250f, 0.01790698f, 
    -0.06790708f, 0.05170825f, 0.02866138f, -0.00288476f, -0.01649579f, -0.04828865f, 0.04893804f, -0.06688821f, 
    -0.02293405f, 0.06006067f, 0.02457836f, -0.07919269f, 0.05863782f, 0.06273247f, -0.07183160f, -0.04377240f, 
    0.03236390f, 0.06104938f, -0.05984795f, 0.00157741f, 0.06629097f, -0.08001958f, -0.05408588f, -0.06069167f, 
    -0.01683271f, 0.02569432f, 0.04344752f, -0.01936469f, 0.01386940f, -0.04235443f, 0.01541708f, -0.02924208f, 
    0.00353404f, 0.05952304f, 0.03530251f, 0.02015310f, -0.04008905f, 0.01335337f, -0.03876823f, 0.04922210f, 
    -0.00454547f, -0.06471203f, 0.01263648f, -0.04594848f, 0.05747323f, -0.04020289f, -0.05190886f, 0.02867065f, 
    -0.01164694f, -0.05701885f, 0.05091357f, 0.00971787f, -0.04976772f, 0.06079865f, 0.04360247f, -0.07321928f, 
    0.02337626f, -0.02900434f, 0.05058980f, -0.07151389f, -0.05954492f, -0.06050186f, 0.04597070f, -0.07448086f, 
    0.00341874f, 0.02411914f, -0.03152002f, 0.01500854f, -0.02754447f, -0.01925424f, -0.06633110f, 0.01926988f, 
    0.02481817f, 0.02550803f, -0.06481500f, -0.04298288f, -0.01950031f, 0.04253618f, 0.04540775f, -0.07371986f, 
    0.05730345f, -0.05247094f, 0.06367068f, -0.03325231f, 0.00748180f, -0.04751248f, 0.05519236f, 0.01534913f, 
    0.01071862f, 0.00073114f, -0.01698051f, -0.06539864f, 0.01501995f, -0.01095604f, 0.05783581f, -0.05815650f, 
    0.04015364f, 0.03404018f, 0.00109825f, 0.01166809f, -0.04350255f, -0.02210284f, -0.00571263f, -0.00914224f, 
    0.04011751f, -0.07480736f, -0.01852900f, 0.03977835f, 0.03240250f, 0.00140706f, -0.04372971f, 0.04413545f, 
    0.00038545f, 0.00713406f, -0.05230604f, -0.00513219f, 0.03043414f, -0.05354557f, 0.01694125f, -0.02578505f, 
    -0.03609466f, -0.03978420f, -0.01288055f, -0.00623432f, -0.06292875f, 0.03078626f, 0.05785122f, -0.06491796f, 
    0.01069616f, -0.04866439f, -0.07013480f, 0.05234482f, 0.02748518f, 0.05122410f, -0.01397551f, -0.01333756f, 
    -0.04436576f, 0.03004077f, -0.03213990f, -0.01353065f, -0.04962370f, 0.03320419f, -0.07814570f, -0.02757042f, 
    -0.01946649f, -0.00814504f, 0.01019792f, -0.03458599f, -0.04386185f, -0.00247968f, -0.06707494f, -0.02372247f, 
    -0.01362722f, 0.00841339f, -0.06207431f, 0.05805266f, 0.04692475f, -0.03959880f, -0.07134210f, 0.00637957f, 
    -0.01494063f, -0.06732050f, -0.02195769f, 0.04416175f, -0.00949240f, -0.07415560f, -0.03647535f, 0.00703701f, 
    -0.06884060f, 0.01868922f, 0.03343861f, 0.03309476f, -0.00367584f, 0.06052609f, 0.00831427f, -0.02374176f, 
    0.03269989f, -0.02556657f, -0.06718106f, 0.03345342f, -0.05717137f, -0.06817542f, -0.06769975f, -0.06462229f, 
    0.11611674f, 0.11117842f, 0.00267583f, 0.15975538f, -0.03055260f, -0.04679288f, -0.01687596f, -0.05136832f, 
    0.02081729f, 0.02870071f, 0.07383510f, 0.12776929f, -0.30781740f, 0.14809965f, 0.08845141f, 0.03446180f, 
    0.01696992f, 0.14645836f, -0.02561224f, -0.14318796f, 0.09100202f, 0.03074940f, 0.12210830f, -0.06985463f, 
    -0.15688254f, 0.16519240f, 0.08631886f, 0.08343563f, 0.00008154f, 0.08234552f, -0.07775278f, 0.10179553f, 
    0.00492410f, 0.02713485f, -0.09838623f, -0.00831557f, 0.19325189f, -0.21208006f, 0.46360782f, 0.21645856f, 
    -0.10579491f, -0.17862135f, -0.09173127f, 0.00215996f, 0.11862851f, -0.07863897f, 0.15315098f, -0.15226583f, 
    -0.04235142f, -0.06338036f, -0.03303958f, -0.00274870f, 0.16009231f, 0.11026687f, 0.00619981f, -0.03550888f, 
    0.06847425f, -0.13489167f, -0.12369220f, 0.04142522f, 0.13257997f, -0.14059553f, -0.16788039f, -0.07519068f, 
    0.09262757f, -0.01237189f, 0.02868975f, -0.02309848f, 0.03880026f, -0.07272068f, -0.01033703f, -0.12153234f, 
    -0.37764886f, 0.03310812f, 0.11719634f, -0.23419558f, 0.11719777f, -0.10128665f, 0.05528338f, 0.13196208f, 
    -0.07588152f, -0.00512882f, -0.05475274f, 0.02789642f, -0.13596745f, 0.13518620f, -0.03630658f, -0.06581775f, 
    -0.00101727f, -0.07334755f, 0.16415556f, 0.14575695f, -0.01776008f, 0.00131116f, -0.07828932f, -0.10748260f, 
    0.11573167f, -0.07986559f, -0.00802666f, 0.33409515f, -0.08607093f, 0.00507019f, 0.17392218f, -0.03645135f, 
    -0.04890603f, -0.00539505f, -0.08273874f, -0.04633987f, -0.17316934f, -0.04235216f, 0.07611892f, 0.13174367f, 
    0.06574593f, -0.01243414f, -0.00741833f, -0.07125729f, -0.03583728f, -0.03665037f, -0.04894690f, -0.04624958f, 
    -0.04564069f, 0.13261156f, 0.23908199f, -0.02634008f, -0.00332032f, 0.00588066f, -0.06287922f, -0.12812296f, 
    -0.03432564f, 0.19114414f, 0.11145419f, -0.14243986f, 0.17836346f, 0.21433933f, -0.05995486f, 0.15338987f, 
    -0.02264997f, -0.01330253f, 0.10385977f, -0.06079540f, 0.12697673f, -0.07551644f, -0.01399169f, 0.01416655f, 
    0.07104528f, 0.06655806f, 0.00741554f, -0.13876468f, 0.01347987f, 0.06687658f, -0.00808787f, 0.02411934f, 
    -0.02571489f, 0.02018511f, 0.04747279f, -0.02489800f, 0.16018485f, -0.09478091f, 0.11051153f, -0.16661666f, 
    0.09902886f, -0.11451393f, -0.02241427f, 0.01937591f, -0.05448008f, 0.01588760f, -0.04678820f, 0.00257325f, 
    -0.14449202f, -0.03662673f, 0.01291117f, -0.16200869f, 0.07526377f, -0.00318795f, -0.10964160f, 0.05597120f, 
    0.09776208f, 0.16425322f, 0.22603914f, 0.16234915f, 0.28277507f, 0.15958764f, -0.10928083f, 0.13627663f, 
    0.09225774f, 0.03867249f, -0.17561580f, -0.05365251f, 0.06859206f, -0.01377614f, -0.08161130f, 0.20047492f, 
    0.15796947f, -0.02282528f, 0.01654781f, -0.05175730f, 0.01496384f, -0.01930807f, 0.04170431f, -0.06349781f, 
    0.07732560f, -0.00408296f, 0.14290172f, -0.13990372f, 0.00959121f, 0.00763222f, 0.05609711f, 0.18764235f, 
    -0.09053960f, -0.10903031f, 0.00553604f, 0.15276100f, -0.01223708f, 0.03530212f, -0.00336487f, -0.17059061f, 
    0.07791625f, 0.21447796f, -0.26627073f, -0.03284587f, -0.11524829f, -0.00492054f, 0.11834912f, 0.23904470f, 
    -0.02757306f, 0.12966344f, 0.03082394f, -0.00653388f, -0.01970107f, 0.32305017f, -0.09704540f, -0.16920187f, 
    -0.09117121f, 0.05821601f, 0.03518806f, -0.05775918f, 0.07924264f, 0.03688278f, 0.05255642f, 0.12950087f, 
    0.07846288f, 0.09803123f, -0.06406650f, -0.00737259f, 0.23785004f, 0.13714322f, -0.06617017f, 0.04867478f, 
    -0.10652692f, 0.07869011f, 0.11116296f, 0.02204164f, 0.06536863f, -0.21258433f, -0.16548480f, 0.34703660f, 
    0.09511399f, -0.05307140f, 0.01790218f, -0.03804766f, 0.10281798f, -0.03206861f, -0.08685394f, 0.10747896f, 
    0.07508831f, 0.15377007f, -0.02218312f, 0.09843304f, -0.13709463f, 0.02464324f, -0.05832178f, 0.08859754f, 
    -0.00305550f, -0.08230563f, -0.01794442f, 0.09109784f, 0.01928926f, -0.03680952f, -0.13170104f, 0.30680996f, 
    -0.05989490f, -0.08024547f, 0.00205369f, -0.00142235f, 0.01952908f, -0.02706605f, 0.00984927f, -0.03086980f, 
    0.06988449f, -0.08048886f, -0.01932194f, -0.23934846f, -0.02162458f, 0.01937651f, -0.18584947f, 0.15180953f, 
    0.02481662f, -0.08056637f, -0.12701920f, 0.07669805f, 0.10315270f, 0.25369215f, -0.10975870f, -0.23311412f, 
    0.08805010f, 0.05103356f, 0.02721361f, 0.17946744f, 0.05473155f, -0.09046535f, 0.03741249f, 0.04816060f, 
    0.25414991f, -0.16897681f, -0.03501675f, 0.04558568f, -0.15555626f, -0.08681182f, 0.10438876f, 0.05933079f, 
    0.00124134f, -0.00835675f, -0.01329443f, 0.04505294f, 0.17700529f, -0.11808187f, 0.09631068f, -0.14096309f, 
    -0.09854169f, -0.08153095f, 0.06781853f, 0.11304004f, 0.02769929f, 0.02295789f, 0.12867399f, -0.03263711f, 
    -0.04047364f, -0.04981719f, -0.06719473f, 0.14943273f, 0.13330300f, 0.03168214f, -0.07307452f, -0.01045852f, 
    -0.04426335f, -0.05819912f, -0.09144201f, 0.01733802f, -0.27736607f, -0.16252778f, -0.07581329f, 0.19839136f, 
    -0.08368715f, 0.14294164f, -0.00645585f, 0.01079388f, 0.09317073f, 0.04397452f, 0.02241909f, 0.02505483f, 
    -0.24480748f, 0.32235801f, -0.11727630f, 0.18761624f, 0.04846597f, 0.08001935f, 0.06734897f, 0.07716748f, 
    -0.08685762f, -0.00914734f, -0.12777609f, -0.09111212f, 0.07746293f, -0.13489474f, 0.05312815f, -0.03955914f, 
    -0.08211240f, 0.06197979f, 0.09830468f, -0.08936657f, -0.01514710f, 0.07969718f, 0.14827959f, 0.02139300f, 
    0.26101512f, 0.00765340f, 0.09487946f, -0.12475239f, 0.04887971f, -0.00303541f, 0.01293399f, -0.05349843f, 
    -0.03920316f, 0.00743628f, 0.10600188f, -0.00482257f, -0.08684773f, 0.02863794f, 0.11914618f, 0.25208381f, 
    -0.06715091f, -0.08246595f, -0.00190459f, 0.26821065f, 0.09481138f, 0.06461163f, 0.01031356f, -0.04992893f, 
    0.16911474f, -0.02748233f, -0.17697041f, 0.03229852f, -0.15224209f, 0.01529208f, 0.09453391f, 0.24436633f, 
    -0.03272018f, -0.00523633f, 0.06798469f, -0.01709425f, -0.01983557f, 0.09837128f, 0.01990309f, -0.21159834f, 
    -0.13791840f, 0.01497769f, 0.12551253f, -0.17177647f, 0.04626638f, -0.05952025f, 0.08586694f, 0.20402914f, 
    -0.02299588f, 0.05905537f, 0.01609875f, -0.03607897f, 0.25521141f, 0.12678961f, 0.01466056f, 0.14783561f, 
    -0.09256309f, 0.06595061f, 0.12553106f, -0.05007848f, 0.03605773f, -0.04781533f, -0.12120423f, 0.27480227f, 
    0.06535326f, -0.01718142f, 0.00514308f, -0.03847846f, -0.00956815f, 0.02416995f, -0.16677558f, 0.04234087f, 
    0.17234398f, 0.22093013f, 0.04016718f, 0.03387456f, -0.14572251f, 0.04918056f, -0.01422580f, 0.02203037f, 
    0.01585755f, -0.03394622f, 0.06024576f, 0.11468641f, -0.06905749f, -0.17233303f, -0.15568504f, 0.28488848f, 
    0.00683411f, -0.14528219f, -0.09324342f, -0.01116102f, -0.02436597f, -0.00749087f, 0.00758660f, 0.01068273f, 
    0.12274145f, 0.00141958f, -0.00193547f, -0.35594186f, 0.05902719f, -0.01110702f, -0.19604945f, 0.06020140f, 
    0.08757302f, -0.08443502f, -0.10431949f, 0.05774160f, 0.07190643f, 0.19185291f, -0.07675336f, -0.15372089f, 
    0.14827661f, 0.08782953f, 0.07927489f, 0.13235998f, 0.05305924f, -0.03982263f, 0.04393123f, 0.06573373f, 
    0.26120263f, -0.16177392f, -0.03087526f, 0.16318065f, -0.07461303f, -0.09388890f, 0.01192354f, -0.05375133f, 
    0.04249807f, -0.07833679f, -0.10639559f, 0.08979762f, 0.22385859f, -0.18584904f, 0.08029229f, -0.04396357f, 
    0.01589257f, -0.04966854f, 0.04949120f, 0.09831817f, 0.04432007f, 0.07901096f, 0.01881374f, 0.01385879f, 
    0.03296794f, -0.01008049f, 0.00869384f, -0.09904509f, 0.07775409f, 0.09221777f, -0.00676521f, 0.09165494f, 
    -0.08538511f, -0.07473949f, -0.07913920f, -0.05371285f, -0.13967435f, -0.07436471f, 0.01686100f, 0.05758798f, 
    -0.14099130f, 0.07700922f, 0.01844895f, -0.02114554f, 0.15559873f, 0.00140344f, 0.10477471f, 0.04526478f, 
    -0.16186829f, 0.17861181f, -0.04207570f, 0.09212211f, 0.04191065f, -0.02648033f, 0.05021021f, 0.11258714f, 
    0.01545991f, -0.01966443f, -0.06577685f, -0.17087400f, 0.15096943f, -0.23743331f, 0.08217686f, -0.02540983f, 
    -0.00583088f, 0.13103448f, 0.07003224f, -0.09076457f, -0.02622929f, 0.09946046f, 0.06082011f, -0.02271836f, 
    -0.18794826f, 0.26391235f, 0.00753211f, 0.07988457f, -0.03268052f, 0.02168060f, -0.00340417f, -0.04747424f, 
    0.00622890f, -0.07860120f, 0.09768990f, 0.03126632f, -0.21796016f, 0.00985929f, 0.22068910f, 0.20822170f, 
    0.05285457f, 0.06843808f, 0.02041017f, 0.09978999f, -0.05943948f, 0.10130462f, 0.07827580f, -0.01413280f, 
    0.19907826f, -0.05598190f, 0.07913633f, 0.22068718f, -0.07686920f, -0.12534204f, -0.00803610f, -0.02680329f, 
    -0.02513811f, 0.00905597f, -0.08205181f, 0.01399569f, 0.24971375f, -0.19166707f, 0.33653465f, 0.08284350f, 
    0.06170177f, -0.09429815f, -0.04158933f, -0.00659096f, -0.02126234f, -0.05567049f, 0.00029895f, 0.07814988f, 
    -0.01793729f, 0.13380118f, -0.10720736f, -0.14443594f, 0.12449064f, 0.09737972f, -0.07840010f, 0.07951492f, 
    0.07275119f, 0.12128383f, 0.00075199f, -0.04969678f, 0.11931270f, -0.07538270f, -0.05778074f, 0.08910120f, 
    0.07207994f, -0.05036006f, -0.03841218f, -0.09878090f, -0.06640372f, -0.06384762f, 0.03906243f, -0.03796942f, 
    -0.08502901f, -0.00327028f, 0.15850976f, -0.03085369f, -0.02291507f, 0.11686389f, -0.02537762f, 0.15054330f, 
    -0.04791514f, 0.08839833f, -0.01122761f, 0.04622298f, -0.20217864f, 0.14289601f, 0.05407621f, 0.00546394f, 
    0.03717059f, -0.13050710f, 0.04655194f, -0.11668462f, -0.02157230f, 0.11338505f, -0.05806223f, -0.01429345f, 
    0.04650421f, 0.06169702f, 0.14565268f, 0.01527851f, 0.00136341f, 0.06341043f, 0.03081165f, -0.00070445f, 
    0.02235162f, -0.03998312f, -0.14658715f, 0.00062207f, 0.14329426f, 0.18091919f, 0.10268811f, -0.02098011f, 
    0.06354106f, 0.03777499f, -0.02366981f, -0.05811831f, 0.14218436f, -0.08426867f, 0.04330488f, 0.07042218f, 
    -0.41478994f, -0.00340627f, 0.24233705f, -0.03140876f, -0.06163847f, -0.00370198f, 0.11922815f, -0.01390873f, 
    0.09535686f, 0.14232799f, -0.06008838f, -0.00777699f, 0.26605380f, -0.14139892f, 0.18715976f, 0.23835517f, 
    0.01558061f, 0.12378749f, 0.02294285f, 0.08384803f, 0.14250214f, 0.04867477f, -0.05933282f, 0.01538392f, 
    -0.17532951f, 0.22344458f, -0.14653938f, 0.13914219f, 0.01068890f, -0.09438962f, -0.02471749f, -0.03254055f, 
    0.09553036f, 0.04459758f, -0.15572208f, 0.14483057f, -0.20222695f, -0.13368288f, 0.05182284f, 0.12284645f, 
    -0.01878515f, 0.00005936f, 0.02932884f, -0.00729633f, 0.02031915f, 0.02651799f, -0.05627605f, -0.02950174f, 
    -0.24497360f, -0.13910900f, 0.02759834f, -0.03078449f, -0.00969783f, -0.06567619f, -0.04495823f, 0.04215957f, 
    0.03629496f, 0.05889575f, -0.04806694f, -0.01232810f, 0.02472174f, -0.01429238f, 0.01300190f, -0.04502423f, 
    -0.09872349f, -0.06273653f, -0.11463488f, -0.10365871f, 0.06292849f, 0.00076690f, -0.06208485f, 0.10576836f, 
    0.20990363f, -0.09778193f, 0.02136126f, -0.02787638f, 0.17467812f, 0.03898534f, 0.03583004f, 0.00795850f, 
    0.00303826f, 0.04446730f, -0.05836855f, -0.04442563f, 0.27263239f, -0.24854386f, -0.09083871f, -0.18920092f, 
    0.03691918f, -0.12388306f, -0.06852186f, 0.10843679f, -0.08348656f, 0.11566167f, -0.05463465f, 0.00696490f, 
    0.05706370f, -0.05358957f, -0.04756184f, -0.04215106f, 0.12486335f, 0.03836928f, 0.06181201f, 0.04541578f, 
    0.05840670f, 0.01647344f, 0.04650818f, -0.04523083f, -0.08654434f, 0.07794009f, -0.24683413f, -0.23185059f, 
    -0.11222189f, 0.16660154f, 0.06964518f, 0.04174295f, 0.07646070f, -0.05704466f, 0.05911138f, 0.06469501f, 
    0.00411978f, -0.02385107f, 0.25409073f, 0.15092736f, -0.05507132f, -0.05937931f, -0.05239246f, -0.06421281f, 
    0.07803779f, 0.08640097f, 0.03491775f, 0.08782522f, -0.15167016f, 0.26456231f, 0.04561023f, -0.05472782f, 
    0.07247868f, 0.06482022f, -0.07835080f, -0.00772249f, 0.08445638f, 0.04387554f, -0.01849158f, 0.10675475f, 
    0.46190616f, 0.02266449f, 0.09235564f, 0.19509391f, 0.00299030f, -0.11974655f, 0.08225253f, -0.12161142f, 
    0.05946275f, -0.03764856f, 0.07203422f, -0.01589399f, 0.32372198f, -0.26226857f, -0.04677322f, 0.13770281f, 
    -0.05935569f, 0.04177526f, -0.05327151f, 0.03526002f, 0.02706247f, -0.09486564f, 0.04281193f, 0.11880994f, 
    0.03461145f, 0.06049599f, -0.12240468f, -0.14537686f, -0.00943867f, -0.03835030f, 0.00089554f, 0.09024242f, 
    0.15338601f, -0.00241421f, 0.12400817f, 0.06852390f, -0.17625812f, -0.21967380f, 0.04350910f, -0.07922644f, 
    -0.12997627f, 0.07682639f, 0.03277641f, 0.04073890f, -0.05575102f, -0.04952187f, -0.01253396f, -0.00006871f, 
    0.48960808f, -0.14809552f, -0.12408018f, 0.10083728f, 0.09579175f, -0.10826249f, 0.01076804f, 0.08291582f, 
    0.02640076f, -0.12142880f, -0.10220478f, 0.04444700f, -0.14418367f, -0.02492387f, -0.04662348f, -0.13268718f, 
    -0.02319932f, -0.03078351f, 0.02982677f, -0.03108456f, -0.03589258f, 0.09155592f, -0.04683663f, -0.00793666f, 
    0.11282724f, -0.16834374f, -0.06627755f, -0.05244206f, 0.11813278f, 0.07643014f, 0.00279379f, -0.01393621f, 
    -0.07550845f, -0.12079578f, 0.07800517f, -0.11891746f, 0.24874398f, 0.12985736f, 0.04792395f, -0.05940888f, 
    0.02594971f, 0.06671751f, 0.01563621f, 0.04100101f, 0.00430203f, -0.07653640f, 0.16143408f, 0.06959555f, 
    -0.05655259f, 0.27998286f, -0.06385636f, -0.00498078f, 0.00998394f, 0.01631232f, -0.03764261f, -0.03493116f, 
    -0.00497085f, -0.02992853f, -0.05686243f, -0.06165622f, 0.27998212f, 0.07684432f, -0.02752681f, -0.00109754f, 
    0.07635667f, 0.15199305f, 0.05401891f, 0.02375418f, 0.08257367f, 0.09672670f, -0.04128191f, -0.06573920f, 
    0.04599949f, -0.05309994f, -0.03110001f, -0.02064702f, -0.07367937f, -0.05274245f, -0.02837041f, -0.04717718f, 
    -0.01406495f, -0.05324232f, -0.05757893f, -0.05044505f, 0.00236448f, -0.00110762f, -0.03247217f, -0.06670758f, 
    -0.03811294f, 0.00729775f, 0.03272643f, -0.06346574f, -0.00041885f, -0.00439980f, 0.02154554f, -0.03263318f, 
    0.04942456f, 0.01725218f, 0.05162372f, 0.04454788f, -0.07879610f, -0.00926142f, -0.03453091f, 0.04929482f, 
    0.00401005f, -0.00134502f, -0.06373587f, 0.01311298f, -0.06190760f, -0.03020312f, 0.00875415f, 0.02901278f, 
    0.04896521f, -0.06968442f, -0.06922915f, -0.01501045f, 0.03117556f, 0.01308095f, 0.00992832f, 0.06110962f, 
    -0.04019433f, 0.00483018f, 0.06522784f, -0.00157291f, -0.02146623f, -0.03136908f, -0.05310778f, -0.07857659f, 
    -0.00463719f, 0.02526270f, -0.05064005f, -0.01692767f, -0.02485186f, -0.05309450f, 0.02460431f, -0.03465254f, 
    0.04567383f, 0.03309602f, -0.02613970f, 0.03851089f, 0.00195536f, 0.06392889f, -0.01418785f, -0.01803257f, 
    -0.00227307f, -0.05917972f, -0.02851948f, -0.06652838f, 0.01768753f, 0.03768792f, 0.00049110f, -0.05422357f, 
    -0.03364382f, -0.02453815f, -0.00472780f, -0.03342470f, -0.01408137f, -0.00088892f, -0.00490506f, -0.04715230f, 
    0.05058195f, 0.02353796f, 0.04839358f, -0.07961541f, -0.03468909f, -0.04474557f, 0.03836408f, 0.02839057f, 
    -0.07970554f, -0.00132643f, 0.03021911f, 0.00488013f, 0.00197317f, 0.02456753f, -0.05244389f, 0.00708176f, 
    -0.05386277f, -0.00561593f, 0.01418256f, -0.06913418f, -0.04823066f, -0.07105231f, 0.04337748f, -0.02214326f, 
    0.01962557f, -0.00678462f, -0.00369325f, -0.08182938f, -0.04415922f, -0.02842680f, 0.01977039f, 0.06148713f, 
    0.04505466f, 0.03826420f, -0.02948163f, 0.02985449f, 0.04507677f, 0.03681790f, 0.02066732f, 0.04504810f, 
    0.04199614f, -0.06174902f, -0.03063156f, -0.06815834f, 0.03479391f, 0.06094389f, -0.02440161f, 0.00531075f, 
    -0.00109362f, -0.02075867f, 0.02667676f, 0.00178835f, -0.01842051f, -0.04451824f, 0.06237543f, -0.02583065f, 
    -0.03692304f, 0.02675667f, -0.01895587f, -0.01192061f, -0.04213872f, 0.04905457f, -0.05790967f, -0.00884995f, 
    -0.03916036f, 0.02571620f, -0.00304732f, 0.00257858f, 0.00580169f, -0.06851052f, -0.05969709f, 0.05841536f, 
    -0.05808897f, 0.02269927f, -0.00778533f, -0.03260269f, -0.03107413f, -0.01420224f, 0.00000695f, 0.02825522f, 
    -0.04383754f, 0.01844265f, 0.04699080f, -0.00521570f, -0.02632678f, -0.06779201f, -0.05350876f, 0.05535261f, 
    -0.00544092f, 0.02422610f, 0.03951646f, -0.03322809f, 0.00927771f, -0.03092692f, -0.04164963f, 0.00195844f, 
    -0.01237653f, -0.01251082f, 0.00354069f, 0.03644831f, -0.05084458f, 0.02844983f, -0.03860061f, 0.03566859f, 
    0.20451772f, 0.02790224f, 0.18141429f, -0.18463708f, -0.02231955f, 0.05573694f, -0.02922113f, -0.01606386f, 
    -0.08055951f, 0.09164091f, -0.05618764f, -0.02118546f, 0.09814297f, 0.03993039f, -0.07725294f, -0.01945170f, 
    -0.02288633f, -0.01493702f, -0.07555284f, 0.16605973f, 0.07267891f, 0.04679525f, 0.04150506f, 0.00701221f, 
    0.11123181f, -0.15154316f, 0.01997693f, -0.05657393f, -0.00309861f, 0.05489032f, 0.07659870f, -0.00494407f, 
    0.05363328f, -0.08878195f, -0.02197501f, -0.11739649f, -0.20919333f, -0.14443755f, -0.08491594f, 0.13847129f, 
    -0.19145265f, 0.00591322f, 0.09510612f, 0.07923956f, -0.06037544f, -0.05634060f, 0.03987309f, 0.01301286f, 
    -0.14195517f, 0.18275650f, 0.15722917f, -0.00657033f, 0.01936758f, -0.02354571f, -0.14252895f, -0.08598524f, 
    -0.03373858f, -0.12173799f, -0.08376710f, 0.09347276f, 0.11023825f, 0.22679746f, 0.01482730f, 0.10904510f, 
    -0.09685285f, -0.05596917f, -0.03964280f, 0.11752620f, 0.09083646f, -0.11689728f, -0.04578966f, 0.02999021f, 
    -0.05762769f, 0.28753543f, -0.12278827f, 0.22703445f, -0.05637583f, 0.05093949f, -0.02100605f, -0.02572027f, 
    -0.08628476f, -0.04271965f, 0.05177711f, 0.07662591f, -0.02947275f, -0.06102836f, -0.09478471f, -0.04248232f, 
    0.15796880f, 0.13798952f, -0.05645420f, -0.07034471f, 0.04513688f, -0.08795694f, 0.01189744f, 0.02720634f, 
    -0.13774700f, -0.02847863f, -0.17454237f, 0.03794413f, -0.09179941f, -0.03225460f, -0.01891669f, 0.02604315f, 
    -0.05221147f, 0.01035148f, -0.03991254f, -0.01691003f, -0.19501676f, -0.15162864f, 0.00535905f, 0.00705944f, 
    -0.04253533f, 0.11373571f, 0.18877944f, 0.09700987f, -0.11950202f, 0.04557506f, -0.05734221f, 0.04621280f, 
    0.25871187f, 0.05538492f, -0.08378088f, 0.24527013f, 0.32711223f, 0.05280510f, 0.00975829f, -0.01405220f, 
    0.06413966f, -0.01093548f, -0.02000857f, 0.03282191f, -0.04149567f, -0.06949934f, -0.13472787f, -0.02801489f, 
    0.07783001f, -0.02545435f, 0.21416494f, 0.21350195f, -0.07517280f, 0.01248064f, 0.08428965f, -0.00185271f, 
    0.18209305f, 0.16236834f, -0.04120703f, -0.06513245f, 0.03132358f, 0.16117370f, 0.10864395f, 0.07628407f, 
    -0.10139408f, -0.13106464f, 0.00794470f, -0.09455482f, 0.28920415f, 0.12735413f, -0.06062750f, -0.16685271f, 
    -0.15109001f, -0.03620979f, 0.11780847f, -0.06131473f, 0.13928221f, 0.00576591f, 0.09242458f, 0.12794636f, 
    -0.09639381f, -0.25397807f, -0.14416884f, 0.02131050f, -0.09235084f, -0.01069020f, 0.05515734f, 0.06229568f, 
    0.07091644f, 0.02860685f, -0.03650445f, -0.14669736f, 0.22741288f, -0.00067651f, 0.24887055f, -0.10687450f, 
    0.03304157f, -0.03358734f, 0.07712322f, 0.01466320f, -0.00923068f, 0.09417251f, 0.00494714f, -0.05610715f, 
    -0.05002526f, 0.16989872f, 0.03817808f, 0.01008424f, -0.06342875f, 0.06060314f, 0.06314044f, 0.07474665f, 
    -0.06992149f, 0.01854851f, -0.10385899f, 0.01822910f, -0.03436461f, -0.13156888f, 0.23003122f, 0.11035156f, 
    0.07810666f, -0.05722149f, 0.05567896f, 0.02383103f, 0.08594354f, 0.01222891f, 0.01036912f, 0.01714594f, 
    0.34695771f, 0.19419926f, -0.07607958f, 0.17479943f, -0.00064361f, -0.03817351f, 0.05271572f, -0.08510049f, 
    -0.07287740f, 0.03421856f, -0.00564955f, -0.02243723f, 0.09468975f, 0.03513813f, -0.25920367f, -0.32157815f, 
    0.07187467f, 0.09328897f, 0.09050272f, 0.02398010f, -0.07987391f, -0.09978860f, -0.12484457f, -0.00965694f, 
    0.01687133f, 0.02550879f, -0.03479701f, 0.17046322f, -0.00655163f, -0.06911110f, 0.01747661f, -0.09893078f, 
    -0.16341150f, -0.00011889f, 0.04837018f, -0.05604134f, 0.39796916f, 0.05736707f, 0.24933147f, 0.29338816f, 
    -0.18184684f, -0.02806080f, 0.05028765f, 0.10780861f, 0.00121973f, 0.00505624f, -0.11520414f, -0.03907282f, 
    0.12667835f, -0.09800827f, 0.09012776f, 0.14542009f, -0.15494472f, -0.01698165f, 0.09895244f, 0.06820401f, 
    0.03356116f, -0.03994285f, 0.02880725f, 0.02848070f, 0.16157252f, -0.18269034f, 0.07667493f, 0.05164648f, 
    -0.07042113f, 0.04722533f, -0.03156893f, -0.12343552f, 0.16495174f, -0.11816038f, 0.11312815f, 0.00824329f, 
    -0.15823515f, -0.09059234f, 0.05581385f, -0.27861226f, 0.09916532f, -0.06968457f, -0.02097186f, -0.03552014f, 
    -0.01297873f, 0.02712052f, -0.11231750f, 0.05444850f, -0.02369411f, 0.12073447f, 0.10672295f, 0.02150545f, 
    0.10723699f, -0.06261333f, 0.07313741f, 0.08637153f, 0.02346799f, 0.08601019f, -0.03735072f, -0.11414940f, 
    -0.08522070f, 0.23608325f, 0.09479928f, -0.07392380f, -0.06011542f, -0.00877184f, 0.15782264f, 0.11595623f, 
    -0.02288973f, -0.03934974f, 0.00014620f, -0.00928830f, -0.10741090f, -0.00522466f, 0.31389472f, 0.26623604f, 
    0.03339170f, 0.13205753f, 0.00029222f, 0.08400831f, -0.11576754f, 0.08016901f, 0.03848334f, 0.09446321f, 
    0.28602514f, 0.13586503f, 0.12188097f, 0.09358522f, -0.14061522f, 0.00403230f, 0.06602982f, 0.02286161f, 
    0.03580732f, -0.04467556f, 0.09231540f, -0.05774390f, 0.07453952f, -0.04265413f, 0.01779459f, 0.04405933f, 
    -0.04605361f, 0.14192288f, 0.12362535f, 0.08459580f, 0.05702778f, 0.03476845f, -0.02607131f, -0.00609278f, 
    -0.10404377f, -0.27463335f, 0.01023849f, -0.01202888f, -0.06063871f, -0.03561286f, -0.02818051f, -0.05213172f, 
    0.00721399f, 0.02953091f, -0.11961194f, -0.15119317f, -0.17611432f, -0.16635032f, -0.13602528f, -0.28425214f, 
    -0.06386625f, 0.00691882f, 0.07128011f, -0.02507283f, -0.09605269f, 0.02483578f, 0.01975301f, -0.14321338f, 
    0.13095482f, 0.20208722f, -0.08739106f, -0.09427736f, -0.02023896f, -0.02754698f, -0.02299796f, 0.07042690f, 
    0.04569248f, 0.07708477f, -0.14675452f, 0.01549532f, -0.06406521f, 0.12416963f, 0.15283678f, -0.07296268f, 
    0.08911473f, 0.11538562f, 0.04392416f, 0.08337128f, -0.00499469f, 0.04647468f, 0.14599197f, 0.09887271f, 
    0.02699186f, -0.27743778f, 0.09442887f, -0.02793547f, 0.02431436f, -0.01969373f, 0.11811128f, -0.01800798f, 
    -0.10406617f, -0.13109851f, -0.08343293f, -0.21579848f, 0.00257207f, -0.01542819f, 0.04054789f, 0.03423989f, 
    0.01303023f, 0.06228585f, 0.06337214f, 0.00473676f, 0.01899422f, 0.00338131f, 0.01610019f, 0.11190267f, 
    0.10297544f, -0.01819031f, -0.09874667f, 0.04492264f, -0.11649546f, -0.07277849f, 0.12506422f, -0.02599379f, 
    0.07937886f, 0.19234306f, 0.07568227f, 0.13416506f, -0.02787175f, 0.25552228f, 0.10429647f, -0.04197034f, 
    -0.05329610f, 0.05125811f, -0.01614291f, 0.02283158f, -0.06790239f, 0.19749461f, 0.06908475f, -0.18345003f, 
    0.11933271f, 0.08087146f, 0.17889391f, 0.17335035f, 0.01620710f, 0.12154332f, 0.00060215f, -0.04288524f, 
    0.01164949f, -0.03458929f, 0.08867384f, -0.13344505f, -0.03477000f, 0.03229382f, 0.17078868f, 0.02240243f, 
    0.16822302f, 0.02263781f, -0.07449292f, -0.02279940f, 0.02267803f, 0.15170643f, 0.05794662f, 0.04500957f, 
    -0.12142117f, -0.09846084f, 0.00742516f, -0.12879372f, 0.04516818f, 0.02196948f, -0.04908962f, -0.05192179f, 
    -0.01415607f, 0.02034483f, -0.01517323f, -0.01115249f, 0.72570908f, -0.09024870f, 0.03340403f, -0.03183936f, 
    -0.09996181f, 0.01550344f, -0.01822257f, 0.11192939f, -0.00035436f, 0.04666756f, 0.09212179f, 0.08087417f, 
    -0.04742302f, -0.09545520f, 0.14325312f, -0.05779458f, 0.05981289f, 0.03190917f, 0.15534271f, 0.03735681f, 
    0.11702011f, -0.12567276f, -0.17794736f, 0.04441072f, -0.24388297f, -0.21350239f, 0.11799250f, -0.07949767f, 
    0.00165821f, -0.01327125f, -0.00568596f, -0.01352708f, 0.04158516f, -0.04924344f, -0.08429387f, -0.14265257f, 
    0.03135785f, 0.03436986f, 0.01962673f, 0.12581946f, 0.06561241f, -0.02812710f, 0.00202644f, 0.00347937f, 
    -0.02872911f, -0.05189032f, -0.11505254f, -0.05095110f, 0.25167960f, 0.17778830f, -0.10032734f, -0.19616555f, 
    -0.10704182f, 0.13993055f, 0.07401601f, -0.02237651f, 0.04153249f, 0.09957138f, 0.05424968f, -0.07364255f, 
    0.20786911f, -0.04099843f, -0.13194089f, 0.08679842f, -0.01970416f, -0.12601364f, -0.07312831f, 0.05823983f, 
    0.07914011f, -0.04611446f, -0.09901685f, -0.10153320f, 0.16408321f, 0.20192125f, 0.15289669f, -0.04980776f, 
    -0.12701312f, 0.09542086f, 0.01234610f, 0.18563031f, -0.02250704f, -0.09698021f, -0.09911337f, -0.06862007f, 
    0.18492264f, 0.27370471f, 0.14747919f, -0.04822903f, -0.06150241f, -0.01160506f, -0.04616167f, -0.04620828f, 
    -0.04128373f, -0.06789713f, 0.10707058f, 0.06657618f, 0.13516387f, 0.15988159f, 0.23618819f, 0.16389759f, 
    -0.02626003f, -0.08072413f, -0.01704033f, 0.17813529f, 0.12493525f, 0.08646979f, 0.00006180f, -0.02162692f, 
    0.35660556f, 0.27494428f, -0.08170681f, 0.10591945f, 0.00500113f, 0.04594234f, 0.05700418f, -0.11065084f, 
    -0.15731606f, 0.03771892f, 0.02310232f, -0.13963625f, -0.25626194f, -0.02363720f, -0.27704647f, -0.21732832f, 
    0.07671921f, 0.03397352f, 0.01034918f, -0.08785296f, 0.05706012f, -0.01924970f, -0.04374533f, -0.04922742f, 
    0.10551219f, -0.02442675f, -0.00475501f, 0.01051347f, 0.06894541f, 0.01898243f, -0.05197727f, 0.10174777f, 
    -0.07157956f, -0.03918574f, 0.16414888f, -0.04292660f, 0.42523807f, -0.06036884f, 0.21690433f, 0.50538236f, 
    -0.01245087f, -0.14474951f, -0.09979010f, 0.09779110f, -0.02948031f, 0.00714307f, -0.03955554f, 0.02646747f, 
    -0.10237481f, 0.08388016f, -0.07547658f, 0.13170129f, -0.16516463f, 0.03382804f, 0.03483720f, 0.08947396f, 
    -0.09710242f, -0.04683574f, 0.01733173f, -0.06857345f, 0.11241142f, 0.13561243f, 0.13603704f, 0.03282321f, 
    0.11021651f, -0.01710770f, -0.23575705f, -0.15297030f, 0.03894059f, 0.02102141f, 0.07538538f, 0.03513613f, 
    -0.35768199f, -0.22421490f, -0.04601362f, -0.26162013f, -0.00173698f, -0.03885826f, -0.02040079f, -0.04876513f, 
    -0.07156458f, 0.00430437f, 0.01317272f, 0.06136468f, 0.28990480f, 0.14261004f, 0.04887126f, -0.05723742f, 
    0.04785391f, -0.07012942f, 0.07223137f, 0.13349386f, 0.13178837f, 0.04406319f, 0.14678779f, 0.04173987f, 
    -0.10471828f, 0.14101987f, 0.07330306f, -0.00551533f, -0.00422012f, -0.01075658f, 0.14204012f, 0.14008690f, 
    0.07842307f, -0.03016571f, 0.01610493f, -0.06632375f, -0.18409249f, -0.15526870f, 0.16154076f, -0.02577547f, 
    -0.05052745f, -0.00666351f, -0.08093456f, 0.27997103f, -0.00389248f, 0.02179395f, -0.03267227f, 0.15454595f, 
    0.31013873f, 0.09408092f, 0.26667976f, 0.33577985f, -0.03093534f, -0.05359536f, -0.03103627f, -0.11021436f, 
    -0.02460523f, 0.02143275f, 0.05443536f, -0.02612727f, -0.16964625f, -0.22019266f, -0.20654535f, 0.31258312f, 
    -0.03529322f, 0.06536078f, 0.10716792f, -0.04769832f, 0.04109020f, 0.02760366f, -0.10223049f, -0.02259534f, 
    -0.29351404f, -0.43227008f, -0.18794383f, 0.09815415f, 0.07492655f, -0.12084127f, 0.01554372f, -0.01320637f, 
    0.11030222f, -0.05588960f, -0.06908804f, -0.07176683f, -0.15803516f, -0.14025851f, 0.02878426f, -0.37244037f, 
    -0.18094721f, 0.00767810f, 0.00647279f, -0.16759363f, -0.11184628f, -0.02648326f, 0.09451225f, 0.05513286f, 
    0.00322716f, -0.05120391f, 0.01232631f, 0.00394842f, -0.06212768f, -0.05316133f, 0.05765082f, -0.00861940f, 
    -0.06772870f, -0.06281073f, -0.00811995f, -0.04609733f, 0.04528083f, 0.03522354f, -0.03249356f, 0.01484218f, 
    -0.02808411f, -0.03263927f, -0.04728445f, -0.07432159f, 0.02348789f, 0.03882553f, -0.04044062f, 0.03052166f, 
    -0.03742597f, 0.04838605f, 0.02705316f, 0.01442336f, 0.05251590f, -0.01370073f, 0.01593430f, -0.01479343f, 
    -0.06757244f, -0.03852941f, -0.01191307f, -0.03852059f, -0.08330072f, -0.05382175f, -0.06997000f, -0.05097737f, 
    -0.03322515f, 0.00755317f, -0.02587042f, 0.01132793f, -0.01671450f, -0.03428052f, 0.04979410f, -0.07994698f, 
    -0.02293921f, 0.06168979f, -0.03285666f, 0.04726794f, -0.04015500f, -0.00407412f, 0.06018910f, -0.01052115f, 
    0.04549924f, -0.01103038f, -0.03416520f, -0.01202735f, -0.05390413f, -0.02563670f, -0.01593339f, 0.04788450f, 
    0.02155521f, -0.05548428f, -0.03894354f, 0.04818561f, 0.02712433f, -0.05840588f, 0.02752681f, -0.02575170f, 
    0.01072603f, -0.07228879f, 0.06656219f, 0.02712961f, -0.04878154f, -0.04051997f, -0.03042935f, -0.06524786f, 
    -0.04022980f, -0.02316265f, 0.01706431f, -0.02111730f, 0.03183730f, -0.02284822f, -0.06884895f, 0.00034066f, 
    -0.03462273f, -0.00094498f, 0.01202440f, 0.03757097f, 0.00244467f, 0.05039544f, -0.06559726f, 0.00108440f, 
    -0.02143497f, 0.04953710f, 0.01302866f, 0.04886000f, -0.00606475f, 0.02483921f, -0.06954844f, 0.05463138f, 
    0.00419767f, 0.07232962f, 0.01160443f, -0.05043992f, 0.03830478f, -0.07964069f, 0.03193351f, -0.05842344f, 
    -0.08201173f, 0.04758443f, 0.01615875f, -0.08401912f, -0.02424651f, -0.01702006f, -0.03785786f, 0.00221642f, 
    0.06189287f, -0.00497206f, 0.01150213f, 0.03789792f, -0.07579441f, 0.05167123f, -0.03766267f, 0.01971214f, 
    0.03151121f, -0.04926747f, -0.03211853f, -0.02548789f, 0.03189098f, -0.04018128f, 0.02918133f, -0.03040662f, 
    -0.06015175f, 0.02246106f, -0.07477905f, 0.01816500f, 0.03371530f, -0.04523429f, -0.06763181f, 0.07086021f, 
    -0.07094011f, -0.07165435f, 0.04485958f, 0.05436340f, -0.01785810f, 0.02191824f, 0.06286163f, -0.06867125f, 
    -0.06661326f, -0.02661405f, 0.00448576f, -0.01397296f, -0.06625787f, 0.03096112f, -0.08367177f, 0.04418648f, 
    0.03719051f, -0.03231721f, -0.02389580f, -0.02029275f, -0.01251036f, 0.01593021f, 0.02818562f, 0.03185071f, 
    0.04988467f, -0.01463489f, -0.02643000f, -0.07293884f, -0.02150685f, 0.06773046f, -0.03064102f, -0.08341798f, 
    -0.01795542f, -0.02455062f, 0.03581580f, 0.04775987f, -0.06440700f, 0.04813439f, -0.03928069f, 0.03671852f, 
    0.00828450f, -0.07510231f, -0.05980242f, -0.05276170f, 0.05018508f, -0.01531401f, -0.03543754f, -0.02381955f, 
    0.02909173f, -0.00735920f, -0.04216462f, 0.03566528f, -0.01155859f, 0.00606033f, -0.07621258f, -0.00130460f, 
    -0.06706808f, -0.03347605f, 0.02042352f, -0.05225962f, -0.04679608f, -0.05468363f, 0.05729926f, 0.05789888f, 
    0.00065473f, -0.03349084f, 0.03556303f, -0.05215459f, -0.07654740f, -0.02049820f, -0.04831336f, 0.02471829f, 
    -0.05823696f, -0.00093240f, 0.03367712f, -0.02564368f, 0.00156948f, 0.01306945f, 0.01508435f, -0.05111007f, 
    0.00823561f, 0.04163752f, -0.05602806f, 0.01186449f, -0.06731965f, 0.05454785f, 0.00547632f, 0.05929042f, 
    -0.01233496f, 0.05932138f, -0.07867211f, -0.07052157f, -0.06542233f, -0.03201278f, 0.04597004f, -0.06711587f, 
    0.01555829f, 0.04605165f, -0.06912866f, 0.02991770f, -0.07725007f, -0.06996804f, 0.05285012f, 0.00511848f, 
    0.05640718f, -0.01371741f, -0.07418051f, 0.00694233f, 0.02930140f, -0.04352283f, -0.06476680f, 0.04272120f, 
    -0.06744586f, 0.02506335f, -0.07285226f, -0.01240515f, 0.04468339f, -0.07848463f, 0.01186210f, -0.00586933f, 
    -0.03549383f, -0.06211873f, 0.01262963f, -0.05616079f, -0.02613894f, -0.01599210f, -0.05198248f, -0.02039764f, 
    -0.01123958f, 0.03094071f, -0.02957856f, -0.03023225f, -0.02629311f, 0.01790941f, -0.00222974f, -0.04819132f, 
    0.00842983f, 0.00733205f, -0.00459922f, -0.02726016f, -0.00984565f, 0.00497987f, 0.01266363f, -0.07707544f, 
    0.04685802f, -0.04921797f, -0.03628928f, 0.00375491f, -0.01274598f, -0.05955809f, -0.06847762f, -0.04510212f, 
    0.01548909f, 0.01623627f, -0.04762350f, 0.04715934f, -0.00163556f, 0.05270465f, -0.02832737f, -0.03418832f, 
    -0.06367411f, 0.03414941f, 0.04985153f, 0.05028850f, -0.04324092f, 0.01532176f, -0.02565448f, 0.02823857f, 
    0.03491910f, -0.04887552f, -0.04214348f, 0.01331384f, -0.07546628f, -0.03559630f, 0.02078983f, -0.05454583f, 
    -0.06132565f, 0.02577778f, -0.05118716f, -0.02364109f, -0.03470639f, 0.01435348f, -0.05950869f, 0.01642373f, 
    -0.03710015f, 0.05997322f, 0.05531129f, 0.05684565f, -0.02623673f, -0.06850639f, 0.02661416f, -0.03900871f, 
    0.03423124f, 0.01089771f, -0.00956576f, -0.00626375f, -0.00782805f, 0.06216156f, 0.01595606f, -0.05979371f, 
    -0.02907252f, -0.07523409f, 0.05308227f, -0.05195150f, -0.07177360f, -0.07198815f, 0.00902781f, -0.06852328f, 
    0.06203835f, -0.02940451f, -0.00121506f, 0.04019955f, -0.00176093f, -0.04029483f, -0.00541541f, -0.00214512f, 
    -0.07373616f, -0.01507007f, -0.06698736f, 0.01207130f, -0.02412329f, 0.04455248f, 0.01348018f, -0.00977487f, 
    0.01400664f, -0.06093488f, -0.05825240f, 0.04491660f, -0.06740586f, 0.05989051f, 0.03335644f, 0.00089963f, 
    0.04035848f, -0.00391864f, -0.04883532f, -0.05590762f, -0.00854009f, -0.02870142f, -0.05789762f, 0.05630204f, 
    -0.04610167f, 0.04695498f, 0.06047212f, 0.04868139f, -0.06062717f, -0.05774986f, -0.00041766f, -0.07752658f, 
    -0.06188592f, -0.04610244f, 0.01452933f, 0.05467287f, 0.06487347f, -0.01464584f, 0.03712939f, -0.00913672f, 
    0.02246178f, -0.02132759f, 0.05739624f, -0.06733032f, 0.04880523f, 0.03165184f, -0.06247068f, -0.05357608f, 
    -0.04875813f, -0.00740962f, 0.06274570f, -0.06793033f, 0.06351344f, 0.05109730f, -0.07061549f, 0.03848542f, 
    -0.03406875f, 0.04563851f, 0.00242197f, 0.04221612f, -0.07244484f, 0.04005293f, -0.07067909f, 0.03516709f, 
    -0.05467150f, -0.02773949f, 0.06559274f, -0.04141241f, -0.05331597f, 0.02612900f, -0.04483844f, -0.00594774f, 
    -0.00504893f, 0.00389306f, -0.00354986f, 0.02614357f, -0.04928837f, 0.03512752f, -0.01234945f, 0.02790178f, 
    -0.04491543f, -0.06541129f, -0.05197471f, 0.05787348f, -0.06372283f, -0.05475274f, -0.05510599f, -0.07482541f, 
    0.01362754f, -0.00869585f, 0.06010366f, -0.01184022f, -0.04617374f, -0.00702305f, 0.01699476f, 0.03545086f, 
    -0.07364236f, -0.07189668f, -0.03056793f, -0.01448300f, -0.04051989f, -0.07454458f, 0.04871953f, -0.03549308f, 
    -0.06594541f, 0.05260335f, -0.00483679f, 0.02105793f, -0.01990379f, -0.07100680f, 0.01834139f, 0.01414375f, 
    0.03204023f, 0.00176339f, -0.01136996f, -0.07790191f, -0.02708407f, -0.05780524f, -0.00691664f, 0.03419292f, 
    0.04868281f, 0.01515261f, 0.06119770f, -0.00696178f, 0.02768358f, -0.06568730f, -0.03122726f, -0.01351607f, 
    -0.06370813f, 0.05629294f, -0.06974296f, -0.07243957f, -0.07404168f, 0.00969404f, -0.04601790f, -0.02483981f, 
    -0.03068596f, -0.02706979f, -0.03684247f, 0.04193410f, -0.07086955f, 0.01415131f, -0.05256062f, 0.04740088f, 
    -0.07020354f, 0.04631030f, -0.05561573f, -0.01813340f, 0.01261676f, -0.00505583f, 0.02243887f, -0.01051375f, 
    -0.00066236f, -0.05345838f, 0.03017260f, -0.00686084f, 0.02022620f, -0.00853911f, 0.05230966f, -0.03725873f, 
    -0.01438649f, -0.05954414f, 0.03270010f, -0.07754696f, -0.04894829f, 0.05276969f, 0.00936815f, -0.01537082f, 
    -0.00461160f, -0.00487217f, -0.05632142f, 0.02230413f, -0.07261635f, 0.02125044f, 0.02453574f, -0.05399854f, 
    -0.02901650f, -0.01401481f, -0.07291204f, -0.01294848f, 0.06505889f, -0.05957195f, -0.01432656f, -0.06189672f, 
    -0.03060791f, -0.01961439f, -0.07260770f, 0.01842149f, 0.02867321f, -0.01899753f, 0.00033585f, 0.04396104f, 
    0.03964236f, -0.03522597f, 0.01945394f, -0.03116477f, 0.01517650f, -0.03617295f, 0.02362854f, 0.05865806f, 
    -0.07593080f, 0.02343674f, 0.01265395f, 0.02828162f, 0.06547901f, -0.04248815f, -0.00498289f, -0.05899877f, 
    -0.03038404f, -0.06512202f, -0.01129850f, -0.06978091f, -0.01720998f, -0.03091134f, 0.04878298f, 0.05524373f, 
    -0.05060590f, 0.05513090f, 0.01264839f, 0.05382598f, -0.06134702f, -0.01161220f, -0.01920445f, -0.07519089f, 
    -0.00160606f, -0.06057914f, 0.01531099f, 0.00948817f, 0.05411115f, -0.03901767f, -0.07309671f, -0.03493771f, 
    -0.05345020f, -0.04551128f, -0.02279941f, -0.00549242f, 0.03697226f, 0.06044130f, -0.05753752f, -0.08129270f, 
    -0.04314389f, 0.03353095f, -0.00979025f, 0.02428534f, -0.00453255f, -0.00705446f, -0.03908281f, -0.03735485f, 
    0.06403793f, 0.04709087f, -0.07049605f, 0.00764004f, 0.00161833f, 0.05564788f, 0.05194595f, -0.03341415f, 
    0.04093089f, 0.03313652f, 0.02590970f, -0.02267608f, 0.00030999f, 0.05541343f, -0.00749285f, -0.05831538f, 
    -0.02588033f, -0.02987896f, 0.06057997f, -0.01035898f, -0.04641759f, -0.03469129f, 0.04760764f, 0.07001062f, 
    0.05406350f, 0.01725704f, -0.06237829f, -0.03356940f, -0.02909205f, -0.05550922f, 0.01701122f, 0.03840691f, 
    0.02971848f, -0.06121045f, -0.06514896f, 0.04019237f, 0.01096146f, -0.03119102f, -0.06205784f, -0.07629243f, 
    0.03234150f, -0.04079276f, -0.03668595f, -0.02810028f, 0.00340057f, 0.05216121f, 0.00823168f, -0.07374803f, 
    -0.03320047f, -0.03483320f, -0.04968567f, -0.04788347f, -0.04211746f, 0.00796346f, 0.04836486f, 0.02824654f, 
    0.02562793f, 0.05110581f, -0.06609363f, 0.04708419f, -0.01297471f, 0.02392208f, 0.04925306f, 0.04539408f, 
    -0.00089852f, -0.05253033f, -0.06135196f, 0.06487485f, -0.03828421f, 0.04545594f, -0.00056698f, 0.00989337f, 
    -0.06599718f, -0.02428870f, 0.05093440f, -0.03499277f, -0.01627059f, -0.01616685f, -0.04875071f, 0.05194381f, 
    0.05205098f, -0.06206024f, -0.03127152f, -0.03613950f, -0.02056496f, -0.05465543f, -0.04127613f, -0.02057195f, 
    0.05868793f, 0.01007869f, -0.03935052f, 0.06744222f, -0.04247185f, -0.00353688f, -0.05729873f, -0.04886907f, 
    -0.07753351f, 0.03814450f, -0.05437795f, 0.01291836f, 0.05225253f, -0.02641775f, 0.06593022f, 0.05920569f, 
    -0.05641793f, 0.01745077f, -0.01134073f, -0.00711189f, -0.00194770f, -0.06032805f, 0.02378392f, -0.01801193f, 
    -0.00358306f, 0.02889778f, -0.03331150f, -0.06795330f, 0.01740076f, -0.05087854f, -0.07584558f, 0.04489511f, 
    -0.02487047f, 0.03771943f, 0.06038300f, 0.01884286f, -0.05823561f, -0.02134320f, 0.00500215f, 0.04806244f, 
    0.03930419f, 0.06051231f, -0.07364750f, -0.03261635f, -0.01404224f, 0.04365563f, 0.04245194f, 0.00576043f, 
    -0.06581799f, -0.07825729f, -0.01458918f, 0.05925767f, -0.07624133f, -0.03868071f, 0.01988829f, 0.01517887f, 
    -0.06373802f, -0.06603014f, 0.01316463f, 0.02867979f, -0.00131887f, 0.01037074f, 0.05620191f, -0.00269568f, 
    -0.02718654f, -0.06183178f, -0.04430422f, -0.01002501f, 0.03442410f, -0.02256703f, -0.01016989f, 0.01897889f, 
    -0.03098347f, 0.00097958f, 0.00430529f, -0.02346254f, -0.05982586f, 0.03437575f, -0.00591748f, 0.04221547f, 
    0.01759814f, 0.00653753f, -0.07354990f, -0.06139193f, -0.05820721f, -0.05141125f, -0.06232047f, 0.01668951f, 
    -0.03382745f, -0.02207148f, -0.00971301f, -0.01754346f, 0.04558848f, 0.06125509f, 0.06001421f, -0.02061750f, 
    -0.01016636f, 0.04216002f, 0.01711804f, 0.02796090f, 0.04444003f, 0.02259496f, 0.02233181f, -0.05256017f, 
    -0.03193480f, -0.00575626f, -0.02634315f, 0.02625674f, 0.01251841f, -0.06571117f, 0.05002219f, -0.01356164f, 
    0.03515225f, 0.05765701f, 0.01210384f, 0.00637928f, -0.01030736f, -0.04392003f, -0.04220539f, -0.06196389f, 
    -0.02604391f, -0.00931879f, -0.02662633f, 0.02541550f, -0.04662260f, -0.02260048f, 0.02477921f, 0.05013992f, 
    0.01062085f, 0.01291726f, -0.04605023f, -0.04560281f, -0.05214335f, -0.01119040f, -0.01427270f, -0.04870721f, 
    -0.01644100f, -0.02901484f, 0.00942524f, 0.03575084f, -0.02704729f, -0.00011522f, -0.05861108f, 0.00313434f, 
    0.03664630f, -0.07198929f, 0.01065703f, -0.02409999f, 0.03639652f, 0.05148058f, -0.01210445f, 0.05057790f, 
    0.06520373f, -0.05461807f, -0.05268203f, 0.00898154f, 0.04976486f, -0.02551957f, -0.00843444f, 0.01622249f, 
    0.01599605f, -0.06508917f, 0.02207142f, -0.04053267f, -0.01899735f, 0.00616018f, -0.03045694f, -0.00442839f, 
    -0.01946560f, -0.07431433f, -0.05025169f, 0.02399248f, -0.02287784f, 0.05829575f, -0.03178108f, -0.07332107f, 
    0.01195060f, 0.00916536f, 0.03221418f, -0.01260769f, 0.01097092f, -0.06103210f, -0.00967360f, 0.05945500f, 
    0.02696616f, 0.01020127f, -0.04932921f, 0.05158575f, 0.00986076f, -0.04507900f, -0.00056267f, 0.00361128f, 
    0.01435347f, 0.05757926f, -0.01749497f, -0.04394763f, -0.06938785f, -0.05903026f, 0.06196721f, -0.02278048f, 
    0.06330620f, 0.00518365f, 0.01432508f, 0.05817091f, 0.01361241f, -0.02414423f, 0.02645656f, -0.05966906f, 
    -0.04006648f, 0.04891995f, 0.03282444f, -0.07280856f, -0.04324633f, -0.03088390f, -0.06067077f, -0.05956404f, 
    -0.02115097f, 0.03217001f, -0.04960976f, 0.04713003f, -0.03118955f, -0.05793522f, -0.07208461f, 0.05945198f, 
    0.00096768f, -0.01776392f, 0.00343258f, 0.04045760f, -0.04764221f, -0.01981516f, 0.06786404f, -0.05329300f, 
    0.04172696f, -0.00636791f, -0.04273393f, -0.02155394f, 0.03577141f, -0.02955989f, 0.05875423f, -0.07751513f, 
    -0.04979336f, 0.04420971f, -0.00116304f, -0.05728287f, 0.00660936f, 0.04087861f, -0.04818341f, -0.04885577f, 
    0.02398913f, 0.02957155f, -0.05185336f, -0.00561344f, -0.05465548f, 0.00059564f, -0.05483469f, -0.07724316f, 
    0.02076691f, -0.06834433f, -0.07146071f, 0.01230066f, -0.05466882f, -0.05849433f, -0.00163655f, 0.01777212f, 
    -0.04957123f, 0.12233289f, 0.11456451f, -0.10713213f, -0.19194394f, 0.10995267f, -0.02787966f, 0.14026973f, 
    -0.07757840f, -0.05848355f, -0.14218645f, -0.03707362f, 0.22866356f, 0.12652087f, -0.04432303f, -0.08672313f, 
    0.12593587f, 0.15658917f, -0.00563335f, 0.13514520f, -0.03757340f, 0.03646585f, 0.03564828f, 0.08399229f, 
    0.11948757f, -0.32720575f, 0.16692518f, -0.03881161f, -0.06639571f, 0.03726153f, -0.04959743f, -0.07217727f, 
    0.10860007f, -0.04663477f, 0.10191520f, -0.06856818f, -0.21525225f, -0.11332549f, 0.05403749f, 0.28847790f, 
    0.10374575f, -0.07003200f, -0.03298774f, 0.12506297f, -0.14957891f, -0.12768744f, -0.05871670f, -0.00459384f, 
    -0.12115015f, 0.28640535f, 0.00396495f, -0.07242474f, -0.10784078f, 0.02815519f, -0.02948485f, 0.01154314f, 
    0.01988813f, 0.02677437f, -0.13259822f, -0.08843315f, 0.17203990f, 0.07683010f, 0.03184640f, 0.18649726f, 
    -0.05860509f, -0.08382075f, -0.01079319f, 0.08095364f, -0.03088373f, -0.06150288f, -0.01572298f, -0.06019367f, 
    -0.32009849f, 0.25024393f, -0.31363076f, 0.23347509f, 0.10207327f, 0.15256478f, 0.01851589f, 0.06933437f, 
    -0.17010795f, 0.01452037f, -0.03902335f, -0.18097551f, -0.16875088f, 0.37942925f, 0.04772941f, -0.20968638f, 
    0.18443191f, 0.22997878f, 0.08250803f, 0.00159234f, -0.06465288f, 0.03099736f, -0.02519738f, -0.08455157f, 
    -0.34475946f, 0.01609969f, 0.13088305f, 0.06312296f, -0.07277253f, 0.03248909f, 0.02323438f, 0.04863803f, 
    -0.04912955f, -0.01442667f, 0.06444857f, -0.13625540f, -0.02242939f, -0.01452700f, 0.16057022f, -0.01144245f, 
    0.10226716f, 0.03726256f, 0.11393370f, -0.15144941f, -0.01125723f, -0.02852605f, 0.13755079f, 0.09562337f, 
    -0.08327992f, 0.12683780f, -0.01059202f, 0.11942130f, 0.16371620f, 0.05265498f, 0.10618583f, -0.02868739f, 
    0.08242977f, -0.08660084f, -0.04892897f, 0.01920589f, -0.01898996f, -0.22333808f, -0.06616645f, 0.13389015f, 
    0.07464956f, -0.00645360f, 0.06738435f, 0.28842744f, 0.00049965f, 0.09577155f, 0.02094526f, 0.01159487f, 
    0.04766012f, 0.14165723f, 0.10677809f, 0.27306101f, 0.02620239f, 0.02106587f, 0.04358612f, 0.00127767f, 
    -0.05361102f, 0.06375542f, -0.05912831f, 0.05959144f, -0.05855809f, 0.02667959f, -0.06493851f, 0.12782185f, 
    -0.09368130f, 0.08237470f, 0.10660933f, 0.01004660f, 0.06527935f, 0.00614610f, 0.00467535f, -0.09883806f, 
    -0.07476799f, -0.29901510f, -0.08322106f, 0.10780241f, -0.14050442f, -0.20198897f, 0.00032858f, 0.10602757f, 
    0.19389631f, -0.04650023f, 0.03613649f, -0.01631553f, 0.07958824f, 0.12484244f, 0.17211050f, -0.19541790f, 
    -0.22860336f, -0.09728357f, 0.00140529f, 0.11575337f, -0.07994866f, -0.15141453f, -0.01198555f, -0.00445442f, 
    0.33337563f, -0.04243013f, -0.15696695f, 0.18758221f, -0.05071819f, 0.02875851f, 0.07048377f, -0.03115414f, 
    0.06631035f, -0.16827999f, 0.05232392f, -0.03475838f, -0.05688754f, 0.11547259f, -0.02094381f, 0.07271349f, 
    0.04634235f, 0.08026533f, -0.08366383f, -0.03258110f, 0.01760883f, -0.05187374f, -0.00538594f, -0.20393792f, 
    -0.19666862f, 0.32214358f, 0.05555137f, -0.12068413f, -0.03950235f, 0.01243688f, -0.23160642f, 0.16643660f, 
    0.08942629f, 0.05027298f, 0.03694181f, -0.02389952f, -0.02732721f, 0.23740548f, 0.07043457f, 0.16419801f, 
    -0.11656140f, 0.06230741f, -0.13934113f, -0.04698499f, 0.10338541f, 0.01824586f, -0.02434600f, 0.03489587f, 
    0.26178923f, -0.11030575f, -0.10798725f, 0.00383153f, 0.15849489f, 0.15696421f, -0.00332360f, -0.03608644f, 
    -0.02079503f, -0.09917389f, 0.04491337f, -0.01483302f, 0.15325159f, -0.24489339f, 0.01328576f, 0.17134513f, 
    0.07977135f, 0.02770974f, 0.00778757f, -0.05218362f, 0.00526536f, -0.11879677f, -0.02769635f, -0.05580267f, 
    -0.37649402f, 0.10396238f, 0.08473928f, -0.17159668f, 0.11647950f, 0.01442186f, 0.06460986f, 0.06913906f, 
    -0.01241504f, -0.00959551f, 0.01212272f, 0.00504160f, -0.15676019f, 0.31340140f, 0.01756888f, 0.06833196f, 
    0.02236375f, -0.01203401f, 0.12339411f, 0.08603382f, 0.01421619f, 0.01134911f, -0.07455144f, -0.03128849f, 
    -0.00584552f, -0.04972461f, 0.14132681f, 0.16972324f, 0.00953552f, -0.09585798f, 0.01729181f, 0.07566755f, 
    0.00185495f, -0.05002909f, 0.00210726f, 0.00021423f, -0.17834496f, -0.08042579f, 0.05302519f, -0.07612590f, 
    -0.01545350f, 0.04964470f, -0.10628208f, -0.07352389f, 0.09493216f, -0.15444876f, 0.06597568f, 0.01831920f, 
    -0.23434979f, -0.09512285f, 0.20871897f, -0.07096346f, 0.01132452f, 0.00216595f, -0.01750299f, -0.12593719f, 
    0.02223663f, 0.16471399f, 0.04976583f, 0.03179531f, -0.02262752f, 0.08157643f, 0.08446503f, 0.01778504f, 
    -0.11706744f, -0.05686178f, -0.16061585f, -0.04847426f, 0.02805475f, -0.04299518f, -0.01142373f, 0.09510039f, 
    0.22169913f, -0.22772476f, 0.10767552f, 0.29698396f, -0.15417145f, -0.10230876f, -0.06503735f, -0.05844617f, 
    0.05011487f, 0.12468237f, -0.03658541f, 0.07511402f, 0.04363155f, -0.14114684f, -0.03245801f, 0.18761681f, 
    0.04772790f, -0.06868455f, 0.04810380f, -0.02162359f, 0.05381467f, 0.10271075f, -0.05169169f, -0.03593544f, 
    -0.19177607f, 0.05655610f, -0.09343763f, 0.24741207f, 0.05822366f, -0.02868355f, 0.03481363f, 0.05174292f, 
    -0.04373474f, 0.04503852f, 0.10272591f, 0.17160563f, 0.25400618f, 0.12951031f, -0.18612088f, -0.03519224f, 
    -0.05852555f, 0.03032596f, -0.14234047f, 0.08109486f, 0.18367922f, 0.13856335f, 0.01285576f, 0.19381569f, 
    0.05986214f, -0.07357211f, 0.05470245f, -0.04066498f, 0.01110354f, -0.07449445f, -0.01858574f, -0.07231878f, 
    0.03197842f, 0.02340396f, 0.04836319f, -0.07146502f, -0.04646382f, -0.00035837f, -0.01105643f, -0.04408894f, 
    0.01008366f, 0.04464932f, 0.03046859f, -0.03197653f, 0.04518941f, -0.00234718f, 0.01001840f, 0.00980004f, 
    -0.04173207f, -0.03368652f, 0.01330539f, -0.04186120f, -0.00192958f, -0.03975382f, 0.06077280f, -0.03111092f, 
    -0.03877917f, -0.05408989f, 0.04987141f, -0.02684653f, -0.06442253f, -0.06092627f, -0.05748161f, -0.07875644f, 
    -0.00056927f, 0.04057830f, -0.00792813f, 0.04710572f, -0.06526379f, -0.01874649f, -0.05767640f, -0.06638743f, 
    0.06187440f, -0.04882313f, -0.00667825f, -0.02794814f, 0.00688056f, -0.02472787f, -0.00260225f, -0.05619784f, 
    0.01251616f, 0.06528499f, 0.04707250f, -0.04444267f, -0.00228228f, 0.01820721f, -0.00225377f, -0.03146758f, 
    0.01963606f, -0.02468024f, 0.06304774f, 0.02418551f, 0.05513906f, -0.03015476f, -0.00859898f, -0.00981721f, 
    -0.02576018f, -0.06143697f, -0.04635703f, 0.05849240f, 0.03092379f, -0.02559478f, -0.03297189f, -0.04589230f, 
    -0.03784337f, 0.06346758f, 0.06187613f, -0.07319077f, -0.02252453f, -0.04192607f, -0.03509066f, 0.03649650f, 
    0.01364957f, -0.07703546f, 0.00027655f, -0.03593196f, 0.00192965f, -0.01212083f, -0.00150078f, -0.01205520f, 
    -0.06456944f, -0.01763181f, -0.06417942f, 0.02919719f, -0.04134602f, 0.02031561f, -0.05300315f, -0.04890650f, 
    0.00782790f, 0.04381853f, 0.00471108f, -0.00929826f, -0.06521725f, -0.06777941f, -0.01816765f, -0.05686452f, 
    0.05663854f, 0.04000286f, 0.04340465f, -0.02949063f, -0.05719350f, -0.03004598f, -0.07517846f, 0.03556648f, 
    0.00242206f, -0.02086498f, 0.06450626f, 0.00973032f, 0.04616187f, -0.04855770f, 0.02083101f, 0.03470064f, 
    -0.03551563f, 0.03563663f, 0.03935806f, -0.01782467f, 0.02679926f, -0.01674120f, -0.02208127f, 0.01953930f, 
    -0.07469734f, 0.03314427f, -0.07063441f, 0.03074880f, -0.05160032f, 0.00899203f, -0.02228724f, -0.02532209f, 
    0.04736937f, -0.01533099f, -0.07240690f, -0.00119434f, 0.05100853f, 0.03433494f, 0.06465174f, -0.05278946f, 
    -0.01819889f, 0.01058192f, -0.04167501f, 0.05865854f, -0.04320281f, -0.02781045f, 0.05799220f, 0.04779338f, 
    0.04493267f, 0.04391701f, -0.01867090f, -0.06467914f, 0.01315317f, -0.03473111f, -0.02885988f, -0.05495097f, 
    0.02286517f, 0.03593640f, -0.05840353f, 0.06057419f, -0.01317835f, 0.02860544f, 0.04347795f, -0.03197066f, 
    0.04050687f, -0.01231447f, 0.01628786f, -0.05652227f, -0.03096863f, -0.02213075f, 0.02238168f, -0.03630761f, 
    -0.04832734f, 0.03964538f, -0.04670671f, -0.03134962f, -0.07652238f, -0.00109276f, -0.03399971f, -0.07061295f, 
    -0.05561818f, 0.33080027f, 0.00398849f, 0.11807676f, 0.11296121f, 0.06123635f, -0.04729757f, 0.01845921f, 
    -0.12327529f, 0.05042719f, 0.13118093f, -0.00332347f, -0.48581752f, -0.23103078f, 0.04813142f, 0.16321169f, 
    0.02210085f, 0.02361022f, 0.01103888f, 0.09994129f, 0.05806118f, 0.07786809f, 0.09693686f, 0.00388575f, 
    0.08115647f, -0.02545753f, 0.03660883f, 0.22297645f, -0.09847493f, -0.00557670f, 0.07652569f, 0.06752417f, 
    -0.11248350f, 0.06637198f, -0.01596301f, 0.02775149f, 0.32672989f, -0.28893661f, 0.32316422f, -0.03179125f, 
    -0.00076595f, -0.05510966f, -0.04198274f, 0.03673099f, 0.04094553f, -0.02672611f, 0.18264654f, 0.03310703f, 
    -0.20580624f, 0.18415466f, 0.11047244f, 0.02993914f, 0.13813430f, 0.12648597f, -0.00823243f, -0.00649393f, 
    0.08119822f, -0.06535004f, 0.03849182f, 0.05456233f, 0.11655603f, 0.06697272f, -0.07802121f, -0.16268946f, 
    -0.13036115f, 0.01410085f, -0.11155596f, 0.01040280f, 0.05355000f, 0.00023320f, -0.03068590f, 0.12589826f, 
    -0.04633025f, -0.12831153f, -0.02648847f, -0.21569997f, 0.01542330f, -0.10733040f, -0.03148088f, 0.10604009f, 
    -0.05731983f, 0.13628092f, 0.06332926f, 0.10091227f, -0.24598302f, -0.25483686f, -0.19838008f, 0.12774709f, 
    -0.07833544f, -0.16901664f, 0.11783797f, -0.04502465f, 0.02709546f, -0.00632769f, 0.03827734f, 0.00839596f, 
    0.11701448f, -0.09827247f, 0.02397554f, -0.04240418f, -0.06132618f, 0.01157213f, 0.03287189f, 0.09338174f, 
    -0.06061992f, 0.03089813f, -0.11119458f, 0.00269829f, -0.25963086f, -0.11331048f, -0.00209176f, -0.07981350f, 
    0.01765192f, 0.10836536f, 0.04206067f, 0.00602398f, 0.03574362f, -0.04550100f, -0.16719726f, -0.01798228f, 
    -0.04622330f, -0.06437117f, -0.00522119f, -0.12499523f, -0.11686867f, -0.02456842f, 0.10140882f, -0.02305281f, 
    0.04242761f, 0.09312043f, 0.03723903f, 0.00249525f, 0.08365991f, 0.02996331f, -0.03001753f, 0.13464290f, 
    0.05539547f, 0.01303957f, 0.05952502f, 0.04422796f, -0.02574004f, 0.00637748f, 0.03685563f, 0.09494901f, 
    0.06276888f, 0.38043949f, 0.06741580f, -0.30334041f, 0.07169005f, 0.11903685f, -0.09010644f, 0.06372431f, 
    -0.05134115f, -0.01427781f, 0.04287499f, -0.09895740f, 0.15047990f, 0.01095149f, 0.24492021f, -0.21414475f, 
    0.05543271f, 0.10182340f, 0.00484760f, 0.08854539f, 0.10427653f, 0.15923133f, 0.20027266f, 0.10431483f, 
    -0.32402840f, -0.01426628f, 0.26337329f, -0.17263673f, -0.01527470f, -0.01154820f, 0.04413059f, 0.05629145f, 
    0.13819692f, 0.11810985f, 0.00794126f, -0.10076685f, 0.12835996f, -0.12710078f, -0.10099008f, 0.01124674f, 
    0.01507638f, 0.04382782f, 0.05848230f, -0.07634681f, 0.01426023f, 0.04568998f, 0.02266098f, -0.10565444f, 
    -0.15495950f, 0.01183150f, 0.01535912f, 0.14176345f, 0.09263698f, -0.17601912f, 0.03213242f, 0.06666855f, 
    0.07217531f, 0.12245267f, 0.05295195f, 0.01419231f, -0.28471804f, -0.12291202f, 0.10711263f, 0.09496695f, 
    -0.16863477f, -0.07824215f, 0.10702545f, 0.00224940f, -0.02537563f, -0.02605503f, 0.06506824f, 0.07668903f, 
    -0.28344259f, 0.20312345f, -0.07140230f, 0.01094498f, 0.01171398f, -0.05774909f, 0.13935015f, 0.10521050f, 
    -0.07575472f, 0.10595456f, -0.06571678f, 0.03888647f, 0.15679672f, 0.27476770f, 0.17630501f, -0.13765807f, 
    0.02821035f, 0.08251400f, 0.04149870f, -0.01479302f, -0.00449532f, 0.09488922f, 0.14463553f, 0.18106003f, 
    -0.08592167f, -0.13399506f, -0.08660495f, 0.12263209f, 0.06618256f, -0.00860838f, 0.16315211f, 0.01597323f, 
    0.06211184f, 0.05049058f, 0.10455678f, 0.14991920f, -0.12701535f, 0.00988259f, 0.08862685f, -0.23090175f, 
    -0.14592001f, -0.03531558f, 0.01739463f, -0.11492661f, -0.04541352f, 0.07702971f, -0.01785565f, 0.05393546f, 
    0.30604208f, -0.26494992f, 0.20431998f, -0.18142113f, -0.04799163f, -0.08466848f, 0.07227969f, -0.05143901f, 
    0.12357146f, -0.10420128f, 0.13527264f, 0.07206055f, -0.01440465f, -0.25864008f, -0.09803430f, 0.04626444f, 
    -0.04763392f, -0.05835915f, -0.03425954f, 0.11490964f, -0.03831636f, 0.03937793f, 0.05731030f, 0.04721350f, 
    0.30802226f, 0.12838353f, 0.09476325f, -0.26462913f, 0.01085974f, 0.13367626f, -0.08390538f, 0.02767299f, 
    0.07909913f, -0.00394257f, -0.06358048f, 0.14054354f, 0.30128911f, 0.08471913f, -0.11325262f, 0.01239201f, 
    -0.16607985f, -0.04325383f, -0.10502654f, 0.18187551f, 0.06270650f, 0.08985348f, -0.07762878f, 0.04766044f, 
    0.09883138f, -0.10859828f, -0.01934015f, -0.22424713f, -0.15855156f, -0.06735992f, 0.00599650f, 0.04709216f, 
    0.01319932f, 0.10864789f, -0.03599752f, 0.00596200f, 0.10105737f, 0.15178919f, -0.05397849f, -0.01764836f, 
    -0.04839009f, -0.11827119f, 0.02358273f, -0.21871509f, 0.01720036f, -0.01325473f, 0.04445054f, -0.03940405f, 
    -0.08753761f, 0.01547820f, -0.11229512f, -0.21440090f, -0.01916017f, -0.03941292f, -0.02009318f, -0.02352729f, 
    -0.01481273f, -0.22126502f, 0.09407276f, -0.08002587f, 0.03653261f, 0.11022098f, 0.09784351f, -0.01835295f, 
    0.10579493f, 0.12712927f, -0.00224214f, 0.13301885f, 0.01893890f, 0.06786280f, 0.12808703f, 0.03237212f, 
    -0.02440139f, 0.35691059f, 0.22587739f, 0.17184031f, 0.04975008f, 0.06994673f, 0.11047761f, 0.06935430f, 
    -0.14840199f, 0.04400049f, -0.09581649f, -0.12441595f, -0.16839038f, -0.10491596f, -0.18277532f, 0.23690537f, 
    0.09335554f, 0.08092471f, 0.05180303f, 0.03682770f, 0.10440405f, 0.06606327f, -0.00110879f, -0.00693377f, 
    0.06691547f, 0.03821788f, -0.16839270f, 0.03715240f, 0.11765978f, 0.09120760f, -0.14134079f, 0.02658604f, 
    -0.09722561f, 0.14559387f, 0.03486761f, 0.02415991f, 0.29751819f, -0.05892609f, 0.02114195f, -0.26650593f, 
    -0.01232125f, 0.16270559f, 0.14037710f, -0.00076005f, -0.15160021f, 0.06957427f, -0.07594164f, 0.11221705f, 
    0.10380365f, 0.00207301f, 0.05477630f, 0.01164815f, 0.10465935f, -0.07788336f, -0.18008631f, 0.09051108f, 
    -0.03534812f, 0.02190075f, -0.04610084f, 0.08292591f, 0.00022028f, 0.15685859f, 0.01505256f, -0.19659652f, 
    0.17774925f, 0.07224620f, -0.00223680f, 0.10202942f, -0.14178674f, 0.12708479f, -0.05502866f, 0.14427423f, 
    0.22388893f, -0.26825207f, -0.09487225f, 0.00914406f, -0.05127247f, 0.00242302f, 0.04901965f, 0.04928146f, 
    0.15637790f, 0.23108163f, 0.20657541f, 0.03945277f, -0.14416738f, -0.07051215f, 0.10929777f, 0.00471318f, 
    -0.05250983f, -0.06066279f, 0.00047220f, -0.15851820f, -0.04228554f, -0.04898746f, 0.04961568f, 0.07248664f, 
    0.35922962f, -0.18459655f, 0.29410887f, 0.18427619f, 0.06302655f, -0.09180408f, 0.08608098f, -0.03073254f, 
    0.00495611f, -0.03374295f, -0.03631973f, 0.04331036f, 0.35622448f, 0.01908759f, -0.05369511f, 0.06778269f, 
    -0.08882301f, 0.09826946f, 0.03583536f, -0.06656009f, 0.03722138f, 0.03905971f, 0.08677761f, 0.11864589f, 
    -0.10909215f, 0.11306762f, 0.11324160f, -0.08976480f, 0.18386403f, 0.01905155f, 0.00080805f, 0.06626005f, 
    -0.12170147f, 0.02030880f, 0.04721635f, 0.08786819f, 0.35268053f, -0.13422497f, 0.09320498f, -0.24195263f, 
    0.04118188f, -0.05436139f, 0.04664730f, 0.10313962f, -0.00380871f, -0.13379477f, 0.04304652f, 0.08415155f, 
    -0.17266935f, -0.11994032f, 0.08426715f, -0.19746506f, -0.03224855f, -0.12459007f, 0.16946076f, 0.16517916f, 
    -0.02118887f, -0.13491656f, 0.01779063f, 0.01668987f, -0.20067179f, 0.03871616f, 0.05070427f, -0.24781001f, 
    -0.14479321f, -0.01682897f, -0.04681193f, -0.18692416f, -0.15928984f, -0.07124919f, -0.03718382f, 0.03069536f, 
    -0.11268590f, -0.16782025f, -0.12670004f, 0.16251239f, -0.02310090f, -0.05348825f, -0.05615781f, -0.12082520f, 
    0.01653963f, 0.08173373f, 0.10339909f, 0.01962785f, -0.15642194f, -0.06677953f, -0.13998443f, 0.21000461f, 
    0.17511067f, -0.00002506f, 0.03517733f, 0.05051072f, -0.07234152f, -0.00856467f, 0.09059881f, -0.02826792f, 
    -0.17890123f, 0.21467037f, 0.13238248f, 0.20373408f, -0.00042608f, 0.02893534f, 0.06172024f, 0.04310447f, 
    -0.08846457f, -0.06437869f, -0.00528133f, 0.04131011f, -0.06085065f, 0.22609341f, -0.15621880f, -0.01605500f, 
    0.16366076f, 0.05770886f, -0.11220943f, 0.19968383f, -0.04646260f, -0.01976729f, -0.07086561f, -0.04842269f, 
    -0.07172751f, 0.02443957f, -0.06273822f, 0.04328991f, -0.06982291f, -0.04442367f, -0.00272664f, -0.07156955f, 
    -0.05186820f, 0.03434624f, 0.04722421f, 0.06149692f, -0.04767794f, 0.01615520f, -0.02627893f, -0.01625863f, 
    0.03275307f, -0.04119621f, -0.02986079f, -0.01877138f, -0.01565096f, 0.07083236f, 0.01763058f, 0.05227689f, 
    -0.01802654f, 0.04849846f, -0.07023337f, -0.04523514f, 0.01619896f, -0.00681066f, 0.00644113f, -0.05035674f, 
    0.02609321f, 0.02614808f, -0.05959339f, -0.05532296f, -0.05794176f, -0.05135199f, 0.01274441f, -0.02756765f, 
    -0.02476145f, -0.01946896f, -0.01731738f, -0.02413399f, -0.01061470f, -0.02161822f, 0.03319709f, 0.00073185f, 
    0.01214086f, 0.00369217f, -0.02592377f, -0.05742823f, -0.00035175f, 0.03910337f, -0.02543330f, -0.03309725f, 
    0.00051997f, -0.03359942f, -0.06813274f, -0.04233253f, 0.04293957f, -0.03863876f, -0.02151224f, -0.04087213f, 
    -0.06372441f, -0.04036465f, -0.01527543f, 0.04606074f, 0.05968080f, -0.01430237f, -0.06042835f, -0.00796454f, 
    0.04999149f, -0.04833625f, -0.01836249f, -0.03641222f, -0.03542562f, -0.01796842f, -0.02480274f, -0.07055400f, 
    -0.02135596f, -0.02202303f, -0.03774787f, 0.07004742f, -0.02863640f, 0.06865472f, -0.01936926f, -0.04166969f, 
    -0.06814772f, -0.06687508f, -0.07041752f, -0.00134310f, -0.03780934f, -0.03233785f, -0.06223750f, 0.04141061f, 
    0.03287625f, 0.03579225f, 0.00126120f, -0.01795948f, -0.04193948f, 0.00537729f, 0.07210521f, 0.06853954f, 
    -0.04722118f, 0.00049806f, 0.05986126f, 0.04235583f, -0.00526609f, 0.02821012f, 0.01608757f, 0.02250553f, 
    0.03026989f, -0.03686833f, -0.05336064f, -0.06273799f, -0.01162008f, -0.05041173f, -0.03630603f, -0.07070552f, 
    0.06118530f, -0.04010332f, 0.02647638f, 0.00383395f, -0.03736566f, 0.05731961f, 0.02487465f, -0.02632049f, 
    -0.03999337f, -0.02598894f, -0.05243096f, -0.05615901f, -0.05219549f, -0.06632350f, -0.02177267f, -0.05895250f, 
    0.02521221f, -0.05107941f, -0.06387894f, -0.01073340f, -0.05097214f, -0.02823281f, -0.02067440f, -0.04205383f, 
    -0.02815514f, 0.06959594f, -0.06447762f, 0.05306868f, -0.02716449f, -0.06629383f, 0.04217870f, 0.03180147f, 
    -0.05112052f, 0.06204274f, 0.03113523f, 0.03514207f, 0.01849792f, -0.04861667f, 0.04859148f, 0.03895300f, 
    -0.01298365f, -0.00361494f, 0.06684576f, 0.05957068f, 0.00903519f, 0.00318788f, 0.01518989f, 0.04784191f, 
    -0.02048128f, 0.05168883f, 0.05709320f, 0.02991580f, -0.00414028f, 0.06437320f, -0.06778925f, 0.02102632f, 
    -0.00407184f, 0.03726266f, -0.01878007f, -0.03965970f, 0.06039409f, 0.03678219f, -0.02556276f, 0.02459310f, 
    -0.05726447f, 0.04386958f, 0.06549910f, -0.06988379f, -0.02060512f, -0.02814058f, -0.01048527f, -0.03738368f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02735971f, 0.11859995f, 0.01216354f, 0.12999550f, -0.02972654f, -0.02103358f, -0.06993699f, 0.03590951f, 
    -0.01173052f, 0.09747923f, -0.04178872f, -0.01470921f, 0.00193542f, -0.03916529f, 0.05804003f, -0.05174413f, 
    -0.03756508f, -0.01364226f, 0.00357712f, -0.01766705f, -0.00474763f, -0.00274439f, 0.01941966f, 0.08609647f, 
    -0.00030886f, -0.03028477f, -0.03802751f, -0.04611789f, 0.07073715f, -0.02012188f, 0.09713252f, 0.02039465f, 
    0.00139244f, 0.07219324f, -0.01214387f, 0.11795416f, -0.06365669f, -0.06490266f, 0.03870697f, -0.06550888f, 
    0.10286156f, -0.03096002f, -0.02462375f, -0.06842086f, 0.06659018f, 0.02668181f, 0.04256666f, 0.03552037f, 
    -0.07677227f, -0.04268524f, -0.01599918f, 0.00993367f, 0.01232591f, 0.00766747f, -0.00425087f, 0.01660879f, 
    0.13940591f, 0.03917496f, 0.06111680f, 0.04251916f, 0.05031962f, -0.01555565f, -0.03181527f, -0.05777576f, 
    0.05012266f, -0.05685635f, -0.05219279f, 0.00184943f, 0.06890476f, 0.14778860f, 0.08715019f, -0.03914671f, 
    0.01863261f, -0.05145685f, -0.01181047f, -0.06121076f, -0.07190038f, 0.01472438f, 0.20791633f, -0.07034174f, 
    -0.13226092f, 0.02913000f, -0.01611862f, 0.08905525f, 0.00510065f, -0.01471170f, 0.01168028f, 0.06798368f, 
    0.08760280f, 0.01582907f, 0.10720978f, 0.08348128f, 0.00401720f, 0.02066530f, 0.06568788f, -0.06270266f, 
    0.04206381f, -0.01020673f, 0.05364725f, -0.09834551f, 0.10056892f, 0.09117600f, -0.03255156f, -0.00564233f, 
    -0.01542340f, 0.04814105f, 0.01727097f, 0.05523341f, 0.03189375f, -0.01975318f, -0.02014326f, 0.02067917f, 
    0.02709323f, 0.01042845f, -0.09641201f, 0.01614157f, 0.02318343f, 0.04594745f, -0.00033364f, -0.01087348f, 
    0.06090352f, -0.11591710f, 0.04520050f, -0.06340423f, 0.10260094f, 0.11752009f, 0.01189815f, 0.03477810f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05191694f, 0.02620203f, 0.13651852f, -0.40393713f, 0.00837000f, 0.07895654f, -0.03040143f, 0.07827882f, 
    0.10418776f, -0.34847584f, 0.01821725f, 0.03965678f, 0.02654634f, -0.11758304f, -0.34639835f, 0.06581870f, 
    -0.04923524f, -0.00923797f, -0.08575142f, -0.15592547f, -0.18789649f, -0.39864239f, -0.40021214f, -0.06238666f, 
    -0.38404638f, -0.13468905f, 0.34518862f, 0.11613656f, -0.17896958f, -0.08536561f, -0.33968607f, 0.02876038f, 
    -0.04521674f, 0.16021048f, 0.16189307f, -0.17320102f, -0.03119267f, 0.22706199f, -0.05806042f, 0.15002258f, 
    -0.22281870f, 0.08233546f, -0.03273089f, 0.06542968f, 0.18926339f, 0.36790529f, -0.22262660f, -0.13399968f, 
    0.15295894f, -0.09662699f, 0.09128499f, -0.22329207f, 0.01327316f, -0.02654867f, -0.07872168f, 0.29630294f, 
    -0.16584939f, -0.09177062f, -0.00197249f, -0.09568460f, 0.15127949f, -0.12215747f, 0.07058625f, 0.05320219f, 
    -0.09564838f, 0.26325420f, 0.09871277f, 0.02971261f, 0.02032904f, -0.21480559f, 0.02653207f, -0.18714006f, 
    -0.34994733f, -0.09110294f, -0.06365278f, 0.10036464f, -0.06039668f, -0.16830762f, -0.22885230f, 0.23061465f, 
    0.09796847f, -0.12129241f, 0.09863241f, -0.26579437f, -0.00589570f, 0.00768648f, 0.06101603f, 0.06460372f, 
    -0.01013562f, 0.14207223f, -0.13093711f, -0.00382648f, 0.16560848f, 0.03724619f, -0.10262883f, 0.05244078f, 
    -0.07383721f, -0.07679316f, -0.18952227f, 0.07910257f, 0.01831066f, 0.18940659f, 0.05831678f, -0.14173818f, 
    -0.06631988f, -0.07365404f, -0.07118654f, -0.04582904f, -0.10922211f, 0.05184786f, -0.19456507f, -0.05545661f, 
    0.10095708f, -0.00043527f, 0.28556329f, 0.14036478f, -0.06125099f, -0.03880639f, 0.04641436f, -0.03613792f, 
    -0.00621585f, 0.30026624f, 0.03258915f, 0.08293108f, -0.38693175f, -0.23625930f, 0.05446727f, 0.01264230f, 
    -0.04916973f, 0.12722732f, 0.15558633f, 0.01721540f, 0.06600668f, -0.04719270f, 0.04975088f, -0.02771022f, 
    -0.14275685f, -0.08143988f, 0.01627676f, 0.02098828f, -0.03327961f, -0.20006496f, -0.09058774f, 0.03841044f, 
    -0.28944597f, -0.03960077f, 0.07090791f, -0.01093659f, -0.02527103f, 0.18097496f, -0.13898438f, -0.15412055f, 
    0.22033188f, -0.37551636f, 0.03440054f, 0.05762693f, -0.19069976f, -0.08070862f, -0.33894846f, -0.03297185f, 
    -0.08141638f, 0.20852560f, 0.03067515f, 0.01537211f, 0.08221692f, -0.21301189f, 0.03054299f, -0.03835510f, 
    0.06527085f, 0.14150466f, -0.01728419f, -0.00261532f, 0.11852829f, 0.26781964f, 0.11749826f, -0.12541088f, 
    0.26344946f, 0.00228462f, -0.05736914f, 0.13533808f, -0.22079442f, 0.08333481f, 0.05150766f, -0.65124053f, 
    0.20848207f, 0.06258221f, -0.05343135f, -0.02436895f, -0.40353453f, 0.11747114f, -0.08098363f, -0.07035426f, 
    0.13683914f, -0.06419583f, 0.35033381f, -0.01533481f, -0.24873835f, 0.14493527f, 0.18471664f, 0.02000474f, 
    0.26710087f, 0.01855874f, 0.05564361f, 0.06031647f, -0.06789567f, -0.05429644f, 0.12952363f, 0.23265842f, 
    -0.02830313f, 0.16355397f, -0.06860176f, 0.24832430f, -0.20372173f, 0.01976811f, -0.03312211f, 0.13020860f, 
    -0.00010670f, -0.31961960f, 0.12084406f, 0.03898683f, 0.21189456f, -0.49743024f, 0.16922478f, 0.05439783f, 
    -0.08579566f, -0.01335073f, -0.08554637f, -0.02751117f, -0.08115969f, 0.04151114f, -0.00888809f, -0.09356868f, 
    0.02045827f, -0.01193352f, -0.08673182f, -0.03576197f, -0.04098952f, -0.21593252f, 0.12949769f, -0.04670462f, 
    0.16601837f, 0.15354644f, -0.15126936f, 0.08832533f, 0.00785580f, 0.04273526f, -0.04993266f, 0.00314235f, 
    -0.03144021f, 0.08312856f, -0.00070626f, -0.05810770f, -0.06675551f, -0.26565281f, -0.07210948f, -0.01546296f, 
    -0.05907737f, 0.01546443f, 0.27787989f, 0.22775418f, 0.05656397f, 0.01663423f, 0.00911127f, -0.21812350f, 
    0.07935759f, 0.22061858f, 0.04782771f, -0.04919841f, 0.08358659f, 0.07598731f, -0.01739864f, -0.09585117f, 
    -0.07315037f, -0.07780984f, 0.06429158f, -0.06313565f, -0.33449236f, -0.13781136f, -0.13526560f, 0.01363355f, 
    -0.01894147f, 0.05115389f, -0.01714154f, 0.13968791f, -0.23771350f, -0.01609747f, 0.19615743f, -0.07077038f, 
    -0.24144898f, 0.04584770f, 0.04033938f, -0.16005999f, -0.01404487f, -0.16928564f, 0.05060615f, 0.10578008f, 
    -0.31813192f, 0.19691218f, -0.04625102f, 0.03192651f, -0.16349402f, -0.25183824f, 0.20902219f, -0.18569070f, 
    0.16719776f, -0.08555324f, 0.27528459f, -0.31932309f, 0.04968385f, 0.11033915f, 0.00110103f, 0.00540398f, 
    -0.21767662f, 0.01369670f, -0.00755320f, -0.00397459f, 0.09496956f, -0.10600227f, -0.01539631f, 0.05758998f, 
    -0.10625209f, -0.27105314f, -0.65313923f, 0.02793880f, 0.08677920f, -0.20866495f, -0.42097199f, 0.13415766f, 
    -0.47611624f, 0.06376328f, 0.00148703f, -0.38818404f, 0.04844776f, 0.09396413f, -0.37700397f, 0.07386942f, 
    0.16949421f, -0.19553287f, -0.15708293f, 0.03030634f, -0.20982961f, -0.03785538f, 0.03750081f, 0.12973343f, 
    -0.13719337f, 0.35872433f, -0.39653331f, -0.57073861f, -0.21948631f, -0.14632224f, 0.14483526f, -0.01720846f, 
    0.01999141f, 0.23483413f, 0.18919913f, 0.08036107f, 0.11795916f, -0.07275405f, -0.00821949f, -0.25002837f, 
    0.04990745f, 0.05406818f, -0.59564263f, 0.18013723f, 0.19632986f, -0.17187749f, 0.11067346f, 0.05458259f, 
    -0.13122483f, 0.15922639f, 0.15087639f, 0.11303817f, 0.00630279f, 0.04938220f, -0.00603509f, -0.07274611f, 
    0.07323325f, -0.11826204f, -0.22018717f, 0.06361825f, -0.32380202f, 0.05460670f, 0.13813773f, 0.03563747f, 
    0.05683273f, -0.10095698f, 0.15496542f, -0.05983256f, 0.04516003f, -0.06815397f, 0.05020959f, 0.06721870f, 
    -0.08876866f, -0.21411160f, -0.08686459f, -0.01053583f, -0.05793887f, 0.12443347f, -0.20695850f, 0.04893122f, 
    -0.24895802f, 0.00624600f, -0.00563500f, -0.08339421f, 0.11564986f, 0.07920551f, -0.35540542f, 0.27828947f, 
    0.10132731f, -0.33237064f, -0.04759538f, 0.03505991f, -0.18039657f, 0.03740310f, 0.14490561f, 0.02490289f, 
    -0.02962156f, -0.27616951f, -0.05945237f, 0.19124068f, 0.05422038f, -0.10006901f, -0.07744311f, 0.07537955f, 
    0.19520383f, -0.36819956f, 0.04563826f, 0.00232077f, -0.16033785f, -0.04482751f, -0.20509033f, -0.26939029f, 
    -0.78880113f, -0.03210460f, 0.19772841f, -0.07077932f, 0.04472307f, -0.21177699f, 0.06584299f, 0.14660335f, 
    0.11910508f, 0.08413982f, -0.02986213f, 0.26548669f, 0.20026639f, 0.02846054f, 0.03871639f, 0.02169261f, 
    0.20456880f, -0.45001099f, 0.21071835f, 0.03968472f, 0.04758864f, 0.07754135f, 0.00381516f, -0.40607184f, 
    0.11447129f, 0.00493178f, -0.00966107f, 0.15506336f, 0.03577387f, -0.07228030f, 0.08933122f, -0.02320824f, 
    0.10340330f, -0.06353255f, 0.15049841f, -0.26148728f, 0.15339206f, 0.03811639f, 0.04754099f, -0.12140148f, 
    0.14663242f, -0.24646616f, 0.22370292f, 0.22926268f, -0.05861085f, -0.25137144f, -0.11239482f, 0.04070786f, 
    -0.21387547f, 0.14904387f, -0.47134724f, -0.33258939f, -0.38589165f, 0.08793601f, -0.07457327f, 0.19699077f, 
    0.06628343f, 0.06488590f, -0.05987719f, 0.24812496f, 0.14552841f, 0.11350282f, 0.07942535f, -0.02817403f, 
    -0.37928620f, -0.16035636f, -0.18803395f, -0.40362790f, -0.05035635f, -0.00385637f, 0.07409523f, 0.06541286f, 
    -0.01676656f, -0.26888028f, 0.19794078f, 0.03664490f, -0.01633423f, 0.22546114f, 0.37066785f, -0.07399312f, 
    -0.08704572f, 0.10097022f, -0.03429601f, -0.13849045f, 0.07765730f, 0.05801751f, -0.08721236f, 0.22833623f, 
    -0.32416975f, -0.26396182f, -0.03569928f, 0.07993244f, -0.03241852f, 0.15187123f, -0.01811468f, 0.04605782f, 
    0.12830998f, -0.06235751f, 0.00837588f, -0.25087371f, 0.06079206f, 0.00641341f, 0.11446153f, 0.09320005f, 
    0.16206801f, 0.12601981f, -0.04929568f, -0.02079360f, 0.12359094f, -0.08561998f, -0.15937465f, 0.03030754f, 
    -0.00856017f, -0.03370646f, -0.14304662f, 0.23763546f, -0.04102174f, -0.08780540f, 0.06403359f, 0.12452746f, 
    0.20898035f, -0.01330983f, 0.05380332f, 0.00165266f, 0.20811294f, -0.34790185f, -0.37111777f, 0.28064686f, 
    -0.09952773f, -0.07429128f, -0.21194652f, -0.15064171f, 0.12262807f, -0.08602665f, 0.02602033f, 0.02125224f, 
    0.14996906f, 0.03446637f, 0.05018810f, 0.15512045f, 0.21828765f, -0.12381222f, -0.04757911f, 0.05624051f, 
    0.08692416f, 0.16104010f, 0.11566627f, -0.01511335f, -0.22513816f, 0.05690574f, 0.08796757f, -0.12102804f, 
    -0.36491486f, -0.01827329f, -0.02867155f, 0.02102709f, -0.08127699f, -0.33351311f, 0.18969229f, -0.09687373f, 
    -0.04761444f, 0.11337916f, -0.13239101f, -0.45808581f, 0.06412489f, -0.06229112f, 0.01867604f, 0.07065147f, 
    -0.18868844f, 0.17496149f, 0.03812931f, 0.13331735f, -0.34015822f, 0.36929360f, -0.15397310f, 0.04951001f, 
    -0.20099518f, 0.22830713f, -0.03710702f, 0.09795648f, -0.05493662f, 0.00494367f, 0.07519807f, -0.09467363f, 
    -0.05424887f, 0.03088332f, 0.06877944f, 0.15146661f, 0.17639177f, 0.22755462f, -0.25281727f, -0.07508491f, 
    -0.00398453f, 0.13015960f, -0.14843771f, 0.18025281f, 0.00596407f, 0.05904933f, -0.07998616f, -0.08107466f, 
    -0.02750785f, -0.04150089f, -0.07746655f, 0.08851961f, 0.24674563f, 0.03622205f, -0.50669962f, -0.04782152f, 
    -0.05485360f, 0.01173976f, -0.20976973f, -0.00121810f, 0.03176981f, -0.05952930f, 0.01328738f, 0.26299399f, 
    -0.08468736f, 0.36500400f, -0.07583117f, 0.05780430f, 0.04663691f, -0.28444347f, 0.08209990f, -0.06791570f, 
    0.16594565f, 0.02912128f, -0.00975712f, -0.05714448f, 0.14039013f, -0.41581962f, 0.17780647f, -0.14816311f, 
    -0.25496420f, 0.06114191f, 0.19498898f, -0.03723196f, 0.16796209f, 0.00658049f, 0.12391864f, 0.02715247f, 
    0.13491911f, -0.07981358f, 0.18790804f, -0.05744990f, -0.04442016f, -0.05324617f, -0.01986538f, 0.07831649f, 
    0.12883358f, -0.13397324f, -0.08588542f, -0.05973270f, 0.07827590f, -0.45171788f, 0.04012942f, -0.07119661f, 
    0.11450519f, -0.06673912f, -0.36306420f, 0.13243197f, -0.00735531f, 0.03650705f, -0.02160181f, 0.05980263f, 
    -0.29295507f, -0.07205849f, -0.08466476f, 0.21410625f, -0.49707580f, -0.09028980f, -0.06765242f, 0.01055785f, 
    -0.50372571f, -0.02443605f, 0.28939566f, 0.03408508f, 0.16732612f, 0.14884928f, 0.30473217f, -0.06263503f, 
    0.14384438f, -0.08852685f, -0.04718554f, -0.20654230f, 0.02907901f, -0.17052856f, 0.12838250f, -0.52073401f, 
    -0.19229946f, 0.08892493f, -0.11890905f, 0.03634001f, 0.15225093f, 0.05381494f, -0.07846636f, 0.23291528f, 
    -0.24020422f, -0.28355691f, 0.11408354f, 0.14922917f, -0.00601761f, -0.63895977f, -0.00892690f, 0.06173140f, 
    0.20149797f, -0.34127083f, 0.09495680f, 0.05201434f, 0.20936458f, 0.06459596f, 0.03771138f, 0.16070642f, 
    -0.01847662f, 0.07894473f, 0.08267348f, -0.28533292f, -0.35461414f, -0.01364498f, -0.15248409f, -0.06191499f, 
    -0.04736448f, -0.17293642f, -0.10716444f, -0.22503595f, -0.08730450f, -0.05174522f, -0.04796024f, 0.04011123f, 
    0.03863134f, 0.20597403f, 0.10480713f, -0.00284572f, 0.02060215f, -0.26617491f, -0.12107969f, 0.02401417f, 
    -0.01021223f, -0.04546409f, -0.65527183f, -0.07054612f, -0.06408525f, 0.04910899f, -0.04973155f, -0.07852866f, 
    -0.02156484f, -0.00890735f, -0.07919344f, -0.06172283f, -0.00157727f, -0.05622335f, -0.33276984f, 0.03058992f, 
    0.10428341f, 0.02103537f, -0.05373044f, 0.24670205f, -0.52454042f, -0.18101451f, -0.04021574f, 0.13218166f, 
    -0.85099596f, 0.11388084f, -0.61478823f, 0.05543517f, 0.22816309f, -0.03171689f, 0.03087718f, 0.04269880f, 
    0.09525944f, -0.16866392f, -0.00138153f, 0.18507099f, 0.07603529f, 0.17686160f, -0.05153942f, -0.04781460f, 
    0.02803111f, -0.59379768f, 0.06438004f, -0.05678895f, -0.23515685f, -0.14449339f, -0.18453473f, 0.17029902f, 
    0.12108881f, 0.01024404f, 0.11012343f, 0.12654896f, -0.31347141f, 0.17818335f, -0.07951672f, -0.00107990f, 
    -0.01232606f, 0.02809520f, -0.01362159f, -0.05864936f, -0.12343457f, 0.25561666f, 0.04066886f, -0.01221358f, 
    0.23239194f, 0.17189394f, -0.15617128f, -0.02743823f, 0.18202440f, 0.11457504f, -0.25924629f, 0.16951400f, 
    -0.13021877f, 0.01888332f, -0.08403831f, 0.19119753f, -0.07283629f, 0.08999871f, -0.12031537f, 0.02476116f, 
    -0.25125527f, -0.35383976f, 0.24712119f, 0.07865328f, 0.14713207f, 0.04689306f, 0.02276300f, -0.52211726f, 
    0.19101098f, -0.00250093f, -0.04410709f, 0.09729190f, 0.05245342f, -0.00994238f, -0.22136566f, -0.03276740f, 
    0.18142813f, -0.03903477f, 0.02080091f, 0.10593546f, -0.07103182f, -0.04942293f, 0.06334847f, 0.06553736f, 
    -0.08601213f, -0.01037426f, -0.02134138f, -0.24214751f, -0.18963762f, -0.22820625f, 0.16676332f, 0.04131682f, 
    -0.02403232f, 0.03690528f, 0.17220865f, -0.36070690f, 0.01336590f, 0.01040709f, -0.08121348f, -0.04933574f, 
    -0.03974871f, -0.24451602f, -0.26232982f, -0.07153803f, 0.15594111f, 0.31863183f, 0.14183137f, 0.03224467f, 
    0.03272337f, -0.37903425f, 0.15010013f, -0.00975434f, -0.07729194f, -0.03693620f, 0.06628287f, 0.16129005f, 
    0.03511928f, -0.13649462f, 0.03495625f, -0.02248436f, -0.02625205f, 0.09996471f, 0.20674318f, 0.04959040f, 
    0.10213525f, -0.08341835f, 0.01270838f, 0.12887333f, 0.15939191f, 0.14958517f, -0.09647317f, -0.12525859f, 
    0.22067729f, 0.14860024f, -0.11559988f, -0.27441993f, 0.21627448f, -0.01093073f, 0.07427721f, -0.01570085f, 
    -0.40890977f, -0.35920599f, -0.32318783f, -0.01403984f, 0.04883326f, 0.20448610f, -0.06340854f, -0.08724594f, 
    0.07787902f, -0.12863515f, 0.06605205f, 0.03473171f, -0.30044454f, -0.16695617f, 0.22648595f, 0.15683131f, 
    -0.09659500f, -0.07589920f, 0.21392655f, 0.01818254f, 0.17694260f, -0.21409650f, 0.04717510f, -0.05474558f, 
    -0.27742442f, -0.07281648f, -0.00162130f, 0.00537275f, 0.23398146f, 0.00618872f, 0.04708703f, -0.00026620f, 
    -0.02206903f, -0.10810588f, 0.02755800f, 0.02607843f, -0.22497246f, -0.25461510f, 0.00886398f, 0.01810423f, 
    0.10197801f, -0.04600342f, -0.07677921f, -0.11050712f, 0.01666356f, 0.17355555f, -0.12128214f, 0.20524119f, 
    0.00867648f, -0.20867582f, -0.38038698f, -0.10480756f, 0.11761408f, -0.03569451f, 0.00190557f, 0.10172927f, 
    0.15519297f, -0.16838565f, -0.11468578f, 0.01830528f, -0.12040406f, 0.33563513f, -0.24663004f, -0.03645845f, 
    -0.28374133f, -0.05308646f, 0.17498586f, 0.07954622f, -0.12218881f, -0.43801326f, -0.04741420f, 0.03319258f, 
    0.03623700f, 0.06579475f, 0.11662296f, -0.28156340f, -0.28022942f, 0.22185421f, -0.30747125f, 0.05672637f, 
    -0.22458243f, 0.06458728f, -0.09018004f, 0.03963023f, 0.03364590f, -0.03234091f, 0.04858081f, -0.00141883f, 
    0.01130470f, 0.02985345f, -0.07975046f, -0.01450663f, -0.05030102f, -0.13002063f, -0.07324945f, -0.05944210f, 
    -0.05297858f, 0.12125999f, -0.00889254f, -0.11326000f, -0.02938272f, 0.04192412f, -0.02767034f, -0.02618872f, 
    -0.32922062f, 0.09922467f, 0.05306299f, -0.02314239f, -0.02456054f, 0.13935360f, 0.20011839f, -0.06514227f, 
    -0.06188591f, -0.00266069f, 0.02782930f, 0.02974714f, -0.29877353f, 0.09376369f, 0.24454434f, -0.26581407f, 
    -0.21800278f, -0.00692837f, 0.12695919f, 0.04144990f, 0.04251724f, -0.04118885f, -0.23264745f, -0.01177442f, 
    0.20629744f, -0.35324055f, 0.15165830f, -0.32309595f, -0.03148767f, -0.17862056f, 0.05154345f, 0.24263181f, 
    0.01049251f, 0.09088645f, -0.03680805f, 0.04190816f, 0.21594080f, -0.37770846f, 0.12394337f, 0.06263179f, 
    -0.12894413f, -0.02071303f, -0.20671125f, -0.28141862f, 0.00913000f, -0.04396009f, 0.05687418f, -0.33731318f, 
    0.06707901f, -0.00312956f, 0.03982496f, -0.30675533f, -0.28772485f, 0.16581748f, 0.03290595f, 0.04624949f, 
    -0.23667899f, 0.09176791f, -0.07148519f, -0.00529133f, -0.10587744f, -0.04497003f, 0.04891406f, 0.16875088f, 
    0.21400611f, -0.07260747f, 0.05815895f, -0.14829858f, 0.02701517f, 0.36003527f, -0.19172913f, -0.21833773f, 
    0.25106004f, 0.25222531f, -0.37219471f, -0.02414419f, -0.13010147f, -0.02372408f, -0.05149305f, 0.01262547f, 
    -0.27751932f, -0.31166461f, -0.36685371f, -0.12879893f, 0.16638334f, -0.28820044f, 0.16570514f, -0.05928103f, 
    0.09422633f, 0.04848468f, -0.22310047f, -0.44896382f, 0.13999440f, -0.40084878f, -0.05638176f, -0.35436499f, 
    -0.04662101f, -0.00430048f, 0.13439514f, 0.02132251f, -0.04241085f, 0.19989274f, -0.03823584f, -0.02856036f, 
    -0.23244452f, 0.16067994f, -0.04967272f, 0.14877652f, 0.07969169f, -0.02731868f, -0.06637990f, -0.05468633f, 
    -0.00990702f, -0.28670886f, 0.26484764f, 0.07530978f, 0.02244634f, -0.10073554f, 0.36132801f, -0.02369207f, 
    -0.03429785f, -0.19899675f, 0.07399604f, 0.19383357f, 0.01444540f, -0.04420095f, 0.01591940f, -0.42086351f, 
    -0.16536152f, 0.26857859f, -0.05766195f, 0.09104519f, 0.06729592f, 0.04969868f, 0.19802175f, 0.07147842f, 
    0.16030192f, -0.00922233f, -0.08714795f, -0.17244376f, 0.27295166f, 0.22146137f, 0.26387426f, 0.06249236f, 
    -0.05721387f, 0.06645428f, -0.40145713f, 0.12892212f, 0.08884390f, 0.04849309f, 0.06739021f, -0.03696561f, 
    -0.12814444f, 0.13726516f, 0.01272542f, 0.17756927f, 0.01036284f, -0.07855015f, -0.06422411f, -0.28404996f, 
    0.17438841f, 0.10528260f, -0.02993048f, 0.01843735f, -0.55599612f, -0.01963004f, -0.05959101f, 0.11071675f, 
    0.11373512f, -0.00275623f, -0.05821219f, 0.17855133f, -0.30448171f, -0.13747527f, -0.04250833f, 0.03554782f, 
    -0.50826669f, 0.01114988f, 0.05042634f, -0.21087477f, 0.19456956f, -0.07907159f, 0.04926981f, -0.02786294f, 
    -0.08039365f, 0.14280201f, 0.00744202f, 0.01302363f, 0.15747730f, -0.31962022f, -0.34538344f, -0.04184215f, 
    -0.00631485f, 0.03968458f, 0.03178342f, -0.00329144f, 0.00740750f, -0.11972795f, -0.06908202f, -0.03318293f, 
    0.02888619f, 0.21934944f, 0.18336256f, -0.33918381f, -0.27507758f, -0.03504364f, -0.02871253f, -0.21223058f, 
    -0.05741821f, -0.02836841f, 0.05200333f, -0.31448218f, -0.34927398f, 0.16144319f, 0.16000478f, -0.04209003f, 
    0.08213258f, 0.01032033f, 0.25369290f, 0.10187908f, -0.01894570f, -0.19799694f, -0.04177248f, 0.18199384f, 
    -0.03667858f, 0.00937481f, -0.11198443f, -0.03845641f, 0.11236484f, 0.06853186f, 0.18956020f, 0.06905017f, 
    0.17922111f, -0.07242988f, 0.09511895f, -0.12930992f, 0.06113280f, -0.03624068f, -0.06606841f, -0.08307463f, 
    0.03003541f, 0.06352765f, -0.40158302f, 0.05288334f, 0.18323411f, -0.16091323f, -0.06863429f, 0.00836342f, 
    0.00427393f, 0.07279884f, -0.13346162f, 0.35281041f, 0.08196949f, 0.05004396f, 0.05754691f, -0.08334481f, 
    0.15499394f, -0.14028585f, -0.07097093f, -0.06405640f, 0.05827554f, 0.03105364f, 0.32391968f, 0.03236407f, 
    -0.01996363f, -0.06958903f, -0.02535222f, 0.33832908f, 0.18141779f, -0.12925743f, -0.34068021f, 0.24196750f, 
    0.04070372f, -0.22688693f, -0.17966303f, -0.29985416f, -0.01395605f, -0.00469488f, 0.14002810f, 0.03137052f, 
    -0.32655811f, 0.02390091f, -0.17248574f, -0.24185865f, -0.06729367f, 0.06935507f, -0.07244746f, -0.21264498f, 
    -0.35991517f, 0.10283994f, -0.06553376f, -0.06205957f, 0.09274013f, -0.24627194f, 0.14045902f, -0.08781086f, 
    -0.49194905f, -0.04159480f, -0.10297568f, -0.31470492f, 0.03648158f, 0.15976454f, -0.02411925f, -0.01781214f, 
    0.21711755f, -0.08118467f, -0.00096415f, -0.26828396f, -0.13111037f, -0.37375328f, -0.06671076f, 0.04328207f, 
    0.30898589f, -0.05807509f, -0.47077224f, -0.02218867f, 0.20081209f, 0.21607739f, 0.41390812f, -0.01106346f, 
    -0.03319602f, 0.04849827f, 0.07928193f, -0.08854964f, 0.01451473f, 0.14925744f, 0.30528554f, 0.02694066f, 
    -0.04367307f, -0.31704265f, 0.00145169f, -0.05960783f, -0.08041996f, -0.07084563f, -0.08573543f, 0.23719685f, 
    0.20960195f, -0.03298966f, 0.17380454f, -0.16743281f, -0.02319543f, 0.17134924f, -0.00397597f, -0.06957483f, 
    -0.06433512f, -0.10734683f, 0.29252180f, -0.34521878f, 0.37878487f, -0.05376893f, -0.04769811f, 0.12910345f, 
    0.04700651f, -0.05101691f, -0.01889438f, 0.06554905f, -0.06273911f, -0.15705094f, -0.00222026f, -0.01443869f, 
    -0.25833273f, -0.32150304f, -0.43825215f, -0.34681875f, 0.00585618f, -0.06498989f, -0.01411288f, -0.01743324f, 
    0.03726305f, -0.55409652f, -0.17663720f, -0.00135052f, -0.21815607f, 0.12427568f, 0.00277959f, -0.03746567f, 
    -0.05296991f, 0.17304304f, -0.32791609f, -0.03845196f, -0.00903301f, -0.04476034f, 0.08263677f, 0.17412843f, 
    0.28712410f, -0.46552768f, 0.01232490f, 0.06160871f, 0.05639634f, -0.01800910f, -0.29798585f, 0.07017497f, 
    0.15185277f, -0.01234773f, -0.08795987f, -0.19451550f, -0.07151071f, 0.15074663f, 0.09711173f, 0.04592086f, 
    -0.61412197f, 0.27482033f, 0.01656271f, -0.00965530f, -0.34279665f, -0.03150344f, 0.21263324f, -0.08399148f, 
    0.25556538f, 0.00325855f, -0.06710632f, -0.31781238f, -0.08193489f, -0.03429155f, 0.02284639f, -0.31544864f, 
    0.02573662f, 0.03183784f, 0.02975928f, -0.06154067f, -0.16097181f, 0.50009185f, -0.07763454f, -0.38698852f, 
    -0.25994208f, 0.00835806f, -0.08035444f, 0.20204972f, 0.08437991f, 0.20341644f, 0.05652008f, 0.10099787f, 
    0.06569538f, -0.05585703f, 0.03535136f, -0.03075566f, -0.05404036f, 0.06070188f, 0.05230436f, 0.02072196f, 
    -0.39640093f, -0.20437296f, -0.64099646f, 0.03374019f, -0.13809560f, 0.03743613f, -0.33594453f, -0.01899026f, 
    0.17272955f, -0.06160469f, -0.02042068f, 0.00870155f, -0.03355043f, -0.06015501f, 0.13214986f, -0.09262365f, 
    -0.14476342f, 0.11453511f, 0.06775370f, 0.21119426f, 0.11479438f, 0.01228661f, 0.01822774f, -0.30713710f, 
    0.09615801f, 0.11875047f, 0.00178820f, 0.16799814f, 0.00521743f, -0.37322202f, -0.10392501f, -0.07401197f, 
    0.04543651f, 0.11265872f, -0.13849629f, -0.13685104f, -0.26416087f, 0.16631107f, -0.03775360f, -0.27145189f, 
    -0.03298276f, -0.03555288f, 0.19651587f, 0.07045104f, 0.09348781f, -0.15337506f, 0.09445212f, 0.07585112f, 
    0.09641597f, -0.38530004f, -0.00058678f, -0.49020901f, -0.02752958f, -0.03157752f, 0.01521317f, -0.07687681f, 
    0.03007432f, -0.31227151f, 0.19119708f, 0.06454588f, 0.02353896f, 0.02336856f, -0.30959791f, -0.06659135f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11667411f, 0.05543171f, -0.00699287f, 0.06647142f, 0.00604298f, -0.05974412f, 0.07430670f, -0.05342150f, 
    0.05548633f, -0.07936263f, 0.04733640f, 0.08840251f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
