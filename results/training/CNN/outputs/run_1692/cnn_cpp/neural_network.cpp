#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.67897004f, 0.43968898f, -0.72627842f, 0.45474508f, -0.13403952f, -0.36491424f, -0.22501813f, -0.18514113f, 
    0.25545219f, -0.34501526f, -0.19573882f, -0.18526730f, 0.39312264f, -0.12985694f, 0.33640918f, 0.21900862f, 
    -0.32161060f, 0.35867175f, -0.78145772f, -0.05845271f, -0.47982752f, -0.69359738f, -0.54293591f, -0.44835728f, 
    0.51171410f, -0.24207786f, 0.34617421f, 0.60823178f, 0.68649042f, -0.52558488f, -0.55875438f, -0.15338606f, 
    0.22768408f, -0.01540654f, 0.17684725f, 0.01371828f, 0.05830821f, 0.45890984f, -0.31294447f, 0.41320845f, 
    -0.50648528f, 0.34430388f, -0.28155732f, 0.35639772f, -0.12285788f, -0.82184964f, -0.51260614f, 0.57741344f, 
    -0.01966426f, 0.61420006f, 0.01759369f, -0.31936380f, 0.12731999f, -0.02175906f, 0.43235794f, 0.31985602f, 
    -0.57678115f, 0.04688697f, 0.00417355f, -0.25980595f, -0.23634054f, 0.05305309f, 0.39948511f, 0.07021062f, 
    -0.04577835f, -0.92804599f, 0.27866530f, 0.60364056f, -0.12860252f, -0.46184233f, -0.50562882f, 0.34338135f, 
    -0.38141954f, -0.95708722f, -0.87609148f, 0.58810461f, 0.63960373f, 0.33850777f, 0.15665185f, -0.03799069f, 
    0.23143274f, -0.34096864f, -0.50075203f, -0.02651604f, -0.37183174f, -0.56232363f, -0.19237390f, 0.21995766f, 
    0.47926134f, -0.21483940f, -0.02439437f, -0.19780286f, -0.19978583f, -0.35993427f, 0.20897017f, -0.03492529f, 
    0.48922792f, 0.24556082f, 0.00903646f, 0.74688506f, 0.60536140f, 0.01558636f, -0.11549117f, -0.37649268f, 
    -0.15546830f, -0.18058309f, -0.22713855f, 0.21453738f, -0.06027829f, -0.26108760f, 0.31477803f, 0.37041304f, 
    -0.46792302f, 0.11997975f, -0.05106105f, 0.29881737f, 0.15711419f, -0.88661128f, -0.20212618f, -0.19854991f, 
    -0.06275943f, 0.75708121f, 0.42693660f, -0.47684625f, -0.30032715f, -0.64231116f, 0.38573515f, 0.26227930f, 
    -0.55568570f, -0.05267050f, 0.08751518f, -0.11196090f, 0.10719330f, 0.38776353f, -0.06313559f, 0.02184348f, 
    0.46704793f, 0.20734763f, -0.71326280f, 0.26419088f, 0.06055277f, 0.38788608f, -0.10747602f, -0.28891537f, 
    0.01628293f, 0.11645210f, 0.44256675f, 0.32909456f, -0.31471264f, -0.55267853f, 0.08125871f, 0.18848498f, 
    0.20857090f, -0.79100066f, 0.76648057f, -0.20847729f, -0.64500302f, 0.06800412f, 0.11777540f, -0.50160503f, 
    0.19927844f, -0.39162189f, -1.02268517f, 0.33899298f, 0.59814149f, 0.02430648f, 0.51605755f, -0.35982588f, 
    0.15641680f, -0.19231185f, -0.11913244f, -0.26624715f, -0.50295401f, 0.30582085f, -0.06135746f, -0.58049971f, 
    0.70961303f, -0.40386415f, -0.14183803f, 0.56295145f, 0.39822471f, -0.17409126f, -0.13803244f, 0.47241983f, 
    -0.31736359f, -0.56239563f, 0.34516293f, 0.29414394f, 0.35407326f, 0.21436992f, -0.51929712f, -0.35232267f, 
    -0.52435309f, -0.16727276f, -0.00901677f, 0.35140520f, -0.28884214f, 0.33666229f, 0.11565194f, 0.31406292f, 
    -0.07417291f, -0.42600611f, 0.19802210f, 0.15926637f, -0.36224434f, 0.62265378f, -0.07005790f, -1.10489762f, 
    0.63454896f, 0.71406710f, -0.56548923f, -0.45418054f, 0.67156976f, 0.01261750f, 0.20716305f, -0.15144145f, 
    -0.10812252f, 0.62595385f, -0.19366118f, -0.56077504f, -0.50705743f, -0.75437295f, -0.30531263f, 0.57345212f, 
    -0.07613049f, 0.04367768f, -0.16645460f, -0.56156796f, 0.03582023f, -0.53606617f, 0.25498340f, -0.44874084f, 
    0.24874890f, -0.25549987f, 0.47457358f, 0.43666691f, 0.61033815f, -0.48663557f, -0.70818436f, -0.25211903f, 
    0.01989854f, -0.01975166f, -0.11821690f, -0.89802331f, -0.96512449f, -0.04830370f, 0.51875973f, 0.10875884f, 
    -0.64582056f, -0.14956439f, -0.19625475f, 0.06453708f, -0.79360378f, -0.64919186f, -0.72378820f, 0.29500234f, 
    -0.07043721f, -0.31791368f, -0.38223529f, -0.38046798f, -0.45663866f, -0.64370352f, -0.03678007f, -0.35889372f, 
    -0.52882141f, -0.35805687f, -0.55835462f, -0.44341317f, -0.49763462f, -0.75208539f, 1.23498762f, -1.19900608f, 
    -0.87293267f, 0.24282314f, 0.34888431f, 0.24538234f, 0.03795482f, 0.18424611f, -0.26159433f, 0.69926161f, 
    0.08390766f, 0.33990905f, -0.32447684f, 0.37366396f, -0.34904283f, -0.19182102f, 0.41047424f, -0.36836612f, 
    -0.15435223f, -0.55836338f, 0.43208024f, -0.53635681f, -0.74772906f, 0.60226631f, 0.25938460f, 0.29202846f, 
    0.02681564f, 0.48568609f, -0.71915489f, 0.16805768f, -0.72089493f, -0.13100095f, 0.55973983f, 0.27077636f, 
    -0.49441454f, -0.49664366f, 0.45090738f, 0.21141532f, -0.06107927f, 0.35738125f, 0.05620439f, -0.03304996f, 
    0.04612918f, 0.38232464f, -0.27432489f, 1.06481981f, -0.69341046f, -0.60298944f, 0.80923921f, -0.55153596f, 
    0.54068732f, -0.36384562f, -0.08600892f, 0.05958150f, 0.12658003f, 0.34092170f, -0.17025805f, -0.16948077f, 
    -0.18084054f, 0.52758962f, 0.34761518f, -0.05810970f, -0.28220990f, -1.04797399f, 0.11192203f, 0.70178384f, 
    0.04863752f, -0.71974373f, 0.02726391f, 0.14940183f, 0.06904619f, 0.37743938f, -1.07338762f, -0.58826417f, 
    0.72974777f, -0.06500708f, -0.04026092f, 0.33860004f, 0.12298018f, 0.21181850f, -0.37848535f, 0.48906040f, 
    0.26582146f, 0.50881881f, -0.64454979f, -0.15145738f, -0.17844479f, 0.17163563f, -0.03471571f, -0.04272693f, 
    -0.63278824f, -0.25451440f, -0.34257790f, 0.52697062f, 0.06256974f, -0.54688108f, -0.40416285f, 0.09719407f, 
    -0.64897162f, -0.32200405f, -0.21697707f, -0.14852777f, 0.26107565f, -0.13725671f, 0.02720350f, 0.30571145f, 
    0.12345400f, 0.08171486f, -0.87468690f, -0.64240205f, -0.66251034f, -0.08061957f, 0.40818140f, 0.77288914f, 
    0.22471453f, -0.10642369f, -0.17351313f, -0.22546098f, -0.82249445f, 0.04567661f, 0.16454095f, 0.67579114f, 
    0.15361926f, -0.02558898f, -0.20878311f, 0.10414902f, -1.10151327f, -0.31072468f, 0.71075803f, 0.80504465f, 
    -0.59401649f, -0.79521251f, -0.33035308f, -0.19315051f, -0.46484491f, -0.11844247f, 0.74523145f, -0.67602056f, 
    0.56693244f, 0.08143626f, -0.02550750f, 0.01183565f, -0.34430605f, -0.00373914f, -0.99839771f, 0.92759115f, 
    -0.06856995f, -0.16523971f, 0.37373626f, 0.33269253f, -0.23056261f, 0.02751320f, -0.22190899f, 0.53133613f, 
    0.42367190f, -0.82105857f, -0.44119948f, -0.32462075f, -0.52407402f, 0.30047405f, -0.76119912f, 0.26617488f, 
    0.64161372f, 0.22672617f, -0.52264601f, -0.74778479f, -0.75898528f, -0.36444849f, -0.70499003f, -0.64886075f, 
    -0.52499992f, 0.24737905f, 0.05413038f, -0.08081133f, 0.48611036f, -0.24212338f, 0.05846361f, 0.15789339f, 
    0.49449664f, -0.50921631f, -0.26920089f, 0.50675327f, 0.20105313f, -0.49246696f, -0.49443746f, 0.20767093f, 
    0.21794865f, 0.23670106f, 0.34691587f, -0.69201720f, -0.51431191f, -0.11174638f, -0.59836876f, -0.64373207f, 
    -0.23704901f, -0.11867506f, -0.41081211f, 0.54782659f, -0.49581113f, 0.06677545f, -0.07151977f, 0.26695052f, 
    0.18989180f, -0.35225838f, 0.25909987f, 0.10198919f, 0.26090959f, -0.18452671f, -0.20983274f, -0.14120591f, 
    0.75100791f, -0.46496978f, 0.15543552f, 0.30011371f, -0.05048569f, -0.35423660f, -0.43017766f, -0.63247102f, 
    -0.57122827f, 0.77382523f, -0.53408921f, -0.23116852f, 0.19132647f, 0.19414917f, 0.17336878f, -0.69264382f, 
    0.45668048f, -0.57082289f, -0.09515459f, 0.26908112f, 0.21235789f, 0.18236724f, 0.39876249f, -0.14712086f, 
    -0.23707387f, 1.07514870f, 0.09228382f, -0.89486384f, -0.21752077f, -0.37036815f, 0.07787566f, 0.17461835f, 
    -0.03763772f, -0.40995511f, 0.01509545f, -0.59884542f, 0.39387527f, -0.04093449f, -0.04978544f, 0.24128751f, 
    0.25943562f, 0.24889365f, 0.25123176f, -0.01635030f, -0.35897163f, 0.18430761f, 0.63935661f, 0.10506941f, 
    0.07976433f, 0.13632926f, -0.33349398f, 0.58590806f, 0.25407547f, -0.52866656f, -0.56896186f, -0.07496478f, 
    -0.25881094f, 0.05145332f, 0.09171624f, 0.51641548f, -0.94021130f, -0.25498006f, 0.79033345f, -0.65622991f, 
    -0.39997998f, 0.44437876f, -0.21745872f, 0.16288903f, 0.06661993f, 0.36656937f, 0.25907063f, -0.08981767f, 
    -0.00346182f, 0.59019995f, -0.30001134f, -0.03118900f, -0.29238322f, 0.01776288f, -0.35612923f, 0.14098348f, 
    0.26032025f, -0.43859830f, 0.18430875f, -0.11505814f, 0.54400390f, -0.36167416f, -0.21673439f, -0.64651465f, 
    -0.55350238f, -0.15985294f, -0.68623275f, -0.91415387f, -0.83288264f, 0.21550532f, 0.21212536f, 0.27323124f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23898454f, -0.16202851f, -0.10088244f, 0.11736149f, 0.12208288f, 0.12140514f, 0.26028106f, 0.04679373f, 
    0.05937242f, 0.09690022f, 0.12988390f, 0.09419180f, 0.11927532f, -0.24766394f, -0.10411061f, 0.26283833f, 
    0.13873824f, 0.22579734f, 0.13026226f, 0.19662577f, -0.10290445f, 0.35683954f, 0.14187771f, 0.15660347f, 
    0.02419633f, 0.24157621f, 0.08780300f, -0.17009984f, -0.22397354f, -0.24423940f, 0.16462630f, 0.04296004f, 
    0.44035611f, 0.09249235f, 0.11307988f, 0.09169880f, 0.28226542f, 0.02729633f, 0.03504913f, 0.28510869f, 
    0.08283351f, 0.00410121f, -0.09994996f, 0.12909448f, -0.05858396f, 0.24385835f, 0.18442415f, -0.05679328f, 
    -0.18417521f, -0.01989288f, 0.03966720f, -0.31434214f, 0.12870616f, 0.19691354f, 0.35244483f, 0.14946513f, 
    0.16141561f, 0.00663841f, 0.22781216f, 0.08367982f, 0.20351410f, 0.35550514f, 0.01008986f, -0.09076687f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.41223487f, -0.18280008f, -0.36716712f, 0.28198895f, -0.19991247f, -0.00381235f, -0.01437674f, -0.04903713f, 
    -0.01682876f, 0.00080335f, -0.02122087f, 0.00468729f, -0.00349472f, 0.06450380f, 0.03244237f, -0.03747110f, 
    0.03672065f, -0.15800497f, -0.03263608f, -0.14625812f, 0.10824528f, 0.01587109f, 0.01796087f, -0.03479722f, 
    0.10413618f, 0.07234605f, 0.06532390f, 0.06375555f, 0.04577391f, -0.01905248f, -0.06701997f, 0.06713267f, 
    -0.06958970f, -0.09752016f, -0.01389713f, -0.00997549f, 0.05446429f, 0.01963223f, 0.01848614f, -0.01096832f, 
    0.25034857f, 0.25492394f, 0.10436152f, -0.29244205f, -0.07771713f, 0.09096938f, 0.11979343f, 0.05335793f, 
    0.10762782f, 0.05058869f, -0.00292512f, -0.02590073f, 0.00949871f, 0.02775246f, -0.00258271f, 0.00772316f, 
    -0.03918077f, 0.02401070f, -0.09469914f, 0.10001542f, -0.13635086f, -0.04695580f, -0.13574582f, 0.00239238f, 
    -0.06867336f, -0.03412501f, 0.02434506f, -0.06473352f, -0.02966043f, 0.06344263f, 0.01787529f, 0.02541819f, 
    -0.02934342f, 0.04504156f, 0.05344256f, -0.02588092f, -0.05553132f, -0.03471591f, -0.01071663f, -0.04507356f, 
    -0.20233005f, -0.17662691f, -0.14560127f, 0.02219308f, 0.02481380f, -0.01559428f, 0.02196888f, 0.00575462f, 
    0.01938933f, 0.04351377f, -0.14194016f, 0.04369852f, -0.01929984f, -0.13663003f, -0.05547197f, -0.02184112f, 
    -0.06791861f, -0.15110962f, 0.01568198f, -0.07639041f, 0.17680469f, -0.08499579f, -0.11016311f, -0.11809497f, 
    -0.03289811f, -0.02605475f, -0.07114515f, 0.08537272f, 0.02615222f, 0.00131266f, -0.08327021f, -0.04439903f, 
    -0.01896897f, -0.08171135f, -0.13960136f, -0.00853621f, 0.04414592f, 0.04502656f, 0.03623737f, -0.01289577f, 
    -0.11054995f, -0.10644110f, -0.20523310f, 0.09858713f, -0.13815516f, 0.01899539f, -0.09532238f, -0.11559560f, 
    -0.02830849f, 0.00339479f, -0.02636787f, 0.00208986f, -0.06775586f, -0.00262887f, 0.03793729f, -0.05836679f, 
    -0.05622856f, -0.13258784f, -0.01053407f, -0.10341366f, 0.11473677f, -0.06218136f, -0.00570816f, 0.05004838f, 
    -0.07661711f, -0.03075825f, 0.09146917f, -0.10898538f, -0.10017222f, -0.04190511f, 0.01169519f, -0.01833719f, 
    0.01453143f, 0.01615498f, 0.05121510f, -0.03948987f, 0.02015300f, -0.01698034f, -0.04575979f, -0.05526150f, 
    0.28636602f, 0.05319362f, -0.30318409f, 0.04045710f, 0.09826396f, 0.11822953f, 0.13941708f, 0.13256595f, 
    -0.13217583f, -0.10729795f, 0.00770558f, 0.04839312f, -0.08323637f, 0.03226600f, 0.05535277f, 0.02621792f, 
    0.04866940f, 0.01286906f, -0.00223386f, 0.02960288f, 0.21904540f, 0.21424204f, 0.06100477f, -0.29505497f, 
    -0.08541857f, 0.07927588f, 0.04097288f, -0.06141069f, 0.06490141f, -0.03411600f, 0.01850845f, -0.00153310f, 
    -0.00681532f, 0.03912058f, 0.02777186f, -0.00734384f, -0.03847117f, -0.03312897f, -0.08592936f, 0.02857547f, 
    0.09959356f, 0.11621989f, 0.00539914f, -0.07709309f, -0.03787424f, 0.02415059f, 0.03111859f, -0.01637984f, 
    -0.05169493f, -0.06797259f, -0.08164972f, 0.03494001f, -0.00802203f, 0.01531944f, 0.00501707f, -0.01627503f, 
    -0.05049434f, -0.01072865f, -0.00539987f, 0.01095614f, -0.47652158f, -0.07871853f, -0.04310409f, -0.00573184f, 
    -0.21218741f, 0.05756418f, 0.01178187f, -0.04285045f, -0.01389622f, 0.06899086f, 0.01290617f, 0.03517847f, 
    0.00101299f, 0.05569402f, 0.07227223f, 0.06768890f, 0.03707511f, -0.01381750f, -0.00604056f, -0.09221767f, 
    0.03742487f, 0.02936959f, 0.07196674f, -0.03490438f, 0.04219732f, -0.02071286f, 0.01802214f, 0.02812132f, 
    -0.02558053f, 0.00919136f, 0.02066511f, -0.05375032f, 0.06009015f, -0.03574277f, -0.03052245f, -0.03510758f, 
    -0.05155612f, -0.04196083f, -0.04834531f, -0.00492275f, 0.26768297f, 0.05125310f, 0.02107064f, -0.01202229f, 
    -0.04972716f, -0.01064523f, 0.02838797f, 0.10601201f, 0.06885114f, -0.03950219f, 0.00195127f, 0.06841738f, 
    0.03692943f, 0.09778487f, -0.06401756f, 0.03389040f, 0.03339000f, -0.03989080f, 0.01379729f, -0.00074529f, 
    0.03649820f, 0.05745727f, -0.00362355f, 0.02620913f, 0.02020485f, 0.02459342f, 0.01276199f, -0.00931855f, 
    0.06471211f, 0.04176744f, -0.17904733f, 0.00540176f, -0.21102367f, -0.04711225f, -0.00965611f, -0.04635810f, 
    -0.00486276f, -0.05345242f, -0.02454356f, 0.01984160f, -0.32336774f, -0.15898371f, 0.27972108f, -0.04303836f, 
    -0.05960103f, -0.06380781f, 0.04877273f, -0.07224976f, 0.00910339f, -0.00161148f, -0.02977059f, 0.00630242f, 
    -0.00128151f, 0.03750143f, 0.04450272f, -0.03391804f, 0.04339033f, -0.14456546f, -0.08429116f, -0.06664360f, 
    0.05409408f, -0.03240334f, -0.06628554f, 0.04773885f, -0.02020954f, -0.07064617f, -0.03350562f, -0.00281287f, 
    0.00247645f, -0.00728783f, 0.01112793f, -0.01547778f, 0.01554781f, -0.02456470f, -0.07996875f, -0.06027905f, 
    -0.00653445f, -0.09141169f, -0.04844242f, -0.01135124f, -0.17115387f, 0.04098778f, 0.07142035f, -0.03163174f, 
    -0.18533069f, -0.15042013f, 0.05491474f, -0.04469160f, -0.02651942f, -0.06497353f, -0.00429021f, -0.02603329f, 
    -0.05473819f, -0.04700326f, -0.05031650f, -0.16657804f, 0.04647748f, -0.16972426f, -0.12695412f, 0.02420020f, 
    -0.10056695f, -0.12430643f, 0.04512858f, -0.12970181f, 0.01743349f, -0.14008144f, -0.03314421f, 0.06444025f, 
    0.09071841f, -0.06144054f, -0.04685964f, -0.16573627f, -0.19649968f, -0.03580081f, -0.08084889f, -0.02842226f, 
    -0.03964258f, 0.01441448f, -0.06530017f, 0.00207911f, -0.11708873f, -0.00890515f, 0.20274469f, -0.15068389f, 
    0.08911680f, -0.06902196f, 0.02442005f, 0.02305861f, -0.15733185f, -0.13661647f, -0.09065649f, -0.15576299f, 
    0.02187330f, 0.00763298f, -0.10332684f, 0.03860288f, -0.07222134f, -0.03057696f, -0.04270536f, -0.14937873f, 
    0.09449358f, 0.03808295f, -0.00951571f, 0.08552755f, 0.02687257f, 0.00607773f, 0.04533760f, 0.01501569f, 
    0.05723590f, 0.01377622f, 0.01863315f, 0.02774092f, -0.06126294f, 0.02782864f, -0.02184328f, -0.05387108f, 
    -0.01676680f, -0.11748144f, -0.02926379f, -0.03625104f, 0.16183916f, 0.21302761f, 0.01823678f, -0.27864581f, 
    -0.09243679f, -0.04445177f, -0.06327125f, -0.03209543f, -0.09965825f, -0.10572581f, -0.08800166f, 0.03703772f, 
    -0.02138521f, 0.01646310f, -0.01088604f, -0.00611489f, -0.05978806f, -0.02469810f, -0.01245727f, -0.00552005f, 
    -0.14256929f, -0.20730489f, 0.00233268f, 0.02687481f, -0.06725723f, -0.03887481f, 0.01304103f, -0.02785190f, 
    0.01325250f, 0.01713075f, -0.00753040f, 0.02488074f, -0.08051625f, -0.04768216f, 0.01172477f, -0.07292329f, 
    -0.09284960f, -0.00665280f, -0.08347660f, 0.01343585f, -0.84528756f, 0.18566002f, 0.49067426f, -0.08925205f, 
    0.08952836f, -0.30207327f, -0.09875022f, 0.11334516f, 0.09486342f, -0.24212824f, 0.02949505f, 0.03906738f, 
    -0.11476727f, 0.06526582f, 0.00569894f, -0.08858094f, 0.04854704f, 0.00312490f, -0.20259333f, 0.01107664f, 
    0.03568186f, 0.07907125f, -0.22623442f, -0.17012501f, -0.31251630f, 0.08714401f, 0.03427418f, -0.11201756f, 
    0.06987587f, 0.10414921f, 0.03298991f, 0.00301525f, 0.00467707f, 0.00930117f, 0.01454336f, -0.03580464f, 
    -0.00157576f, -0.03974166f, -0.13773268f, 0.02680427f, 0.04432954f, 0.08703820f, 0.00646730f, -0.09370434f, 
    -0.05800192f, 0.02292496f, 0.06904499f, 0.02238922f, -0.08485413f, -0.03248445f, -0.07075550f, -0.01043725f, 
    -0.00363828f, 0.01603842f, -0.03251046f, -0.01790985f, -0.13596301f, -0.06903470f, 0.01059216f, -0.04416887f, 
    -0.18570040f, 0.45432597f, 0.06331158f, -0.21909980f, -0.01136173f, -0.04532710f, -0.05773652f, -0.32276595f, 
    -0.08286846f, -0.03875936f, 0.03401791f, -0.00798653f, 0.03711922f, 0.05067011f, 0.01880340f, 0.03293334f, 
    0.11391309f, 0.05333468f, 0.01741715f, -0.01943901f, 0.48307863f, 0.24688606f, -0.07819092f, -0.25855154f, 
    -0.07027047f, 0.10563014f, 0.06949393f, 0.14346544f, -0.10314041f, 0.06632259f, -0.02024498f, -0.02960178f, 
    -0.02283631f, 0.01953296f, 0.05396615f, 0.02101137f, 0.01404863f, 0.07222036f, -0.03318859f, -0.02463811f, 
    0.27681530f, 0.12347136f, 0.07440320f, -0.17123671f, -0.06206056f, 0.12544449f, 0.12879959f, 0.23023376f, 
    -0.02608932f, 0.07925807f, 0.00543744f, 0.00300048f, -0.05093258f, -0.03996748f, 0.00025020f, 0.00131938f, 
    -0.13260418f, -0.06018059f, -0.07802289f, 0.00677403f, 0.17790073f, 0.23993091f, 0.14544949f, -0.23627670f, 
    -0.07674178f, 0.06123175f, 0.18057725f, 0.13301980f, 0.04709307f, 0.10322091f, -0.01370866f, -0.04324038f, 
    -0.01937860f, -0.11594264f, -0.13152976f, -0.14160268f, -0.14064226f, -0.00596784f, -0.00688491f, 0.16102071f, 
    0.12700805f, -0.11646394f, -0.64498121f, 0.10606102f, 0.01462190f, 0.10918051f, -0.05299668f, 0.00948430f, 
    -0.12356788f, 0.11118195f, -0.09360486f, -0.01993822f, -0.27718857f, -0.03173045f, -0.13712320f, 0.00833806f, 
    0.08702755f, 0.02843949f, 0.00137267f, 0.06733435f, -0.27940714f, -0.13537009f, -0.14423555f, 0.01450436f, 
    0.15012830f, 0.02479275f, -0.01162515f, -0.00745770f, -0.00935085f, 0.07554886f, -0.03186165f, 0.03677477f, 
    0.01788589f, 0.01525125f, 0.00658080f, -0.04996374f, -0.00646596f, -0.12124537f, -0.14711264f, 0.06478877f, 
    0.11479232f, 0.14917243f, 0.18699650f, -0.19190502f, 0.00493443f, -0.13411824f, -0.02098091f, 0.02138149f, 
    -0.09244099f, -0.15643826f, -0.00905718f, 0.02423571f, -0.01993443f, -0.00207512f, -0.02085915f, -0.00307719f, 
    -0.07868298f, 0.00392132f, -0.04371292f, -0.15304552f, 0.07754906f, -0.05354608f, 0.09411789f, -0.15966688f, 
    -0.02086054f, -0.03312306f, -0.08998420f, -0.03946434f, -0.07228700f, 0.02912918f, -0.03551121f, -0.03466145f, 
    -0.04675118f, 0.00333970f, 0.05907609f, 0.06746592f, -0.12570231f, -0.04937523f, -0.03227484f, -0.00367847f, 
    -0.05088793f, -0.04604283f, -0.08125068f, 0.06014267f, 0.01616747f, 0.00303990f, 0.01766833f, 0.01698358f, 
    0.02652364f, 0.05095570f, -0.02784160f, 0.00921852f, 0.00761928f, -0.03802488f, -0.00593637f, -0.14416672f, 
    -0.08168106f, -0.02070666f, 0.01207097f, -0.02288858f, -0.05361443f, -0.20141113f, -0.31427848f, 0.02435054f, 
    0.02275006f, -0.10959934f, 0.01871395f, -0.04704838f, -0.10118388f, -0.00793638f, -0.01817222f, -0.00273161f, 
    -0.01087600f, -0.01771144f, -0.11561600f, 0.00920063f, 0.02377612f, -0.08337592f, 0.00181930f, -0.02735224f, 
    -0.15476683f, -0.05947663f, -0.06799797f, 0.04382248f, -0.04211448f, -0.00534462f, -0.00876233f, -0.05168305f, 
    0.03393538f, 0.03375746f, -0.03891176f, -0.02979492f, -0.06340159f, -0.03964088f, 0.06063840f, -0.01892591f, 
    -0.09531963f, -0.04217154f, -0.04499992f, -0.04436695f, 0.13220751f, 0.17950621f, 0.23198813f, -0.16595535f, 
    0.03236770f, -0.16303834f, -0.10529009f, 0.04219413f, 0.03068842f, -0.15038225f, 0.16737944f, -0.16516449f, 
    -0.05055767f, -0.07243773f, -0.02914641f, -0.03305844f, -0.00927620f, 0.02200330f, -0.11748974f, 0.04880061f, 
    0.15323956f, 0.00000669f, 0.23584422f, -0.28558150f, 0.09719352f, -0.03641139f, 0.03309481f, 0.11543341f, 
    -0.02332034f, 0.00599845f, 0.00475958f, -0.01910372f, -0.13340093f, 0.01609643f, -0.06533188f, 0.00994023f, 
    -0.02438365f, 0.04837229f, 0.02012009f, 0.03166828f, -0.21713312f, -0.00291509f, 0.04379006f, -0.10001962f, 
    -0.00409389f, -0.03423428f, 0.00448509f, -0.13280796f, -0.06292699f, -0.05820937f, -0.00381033f, 0.03559582f, 
    0.03347131f, 0.04649469f, 0.02283200f, 0.04604648f, -0.02620926f, -0.11888479f, -0.06415448f, -0.03840668f, 
    0.21395999f, 0.14050622f, -0.04762247f, -0.13548735f, -0.04668489f, 0.00971526f, 0.07748425f, 0.08606762f, 
    -0.04466059f, 0.05963567f, -0.01813407f, -0.02716425f, -0.00652002f, -0.05526184f, -0.00952846f, -0.02685634f, 
    -0.05544155f, -0.01194512f, -0.13004120f, 0.02979636f, 0.09532507f, 0.11691197f, 0.06796399f, -0.06441178f, 
    0.05314168f, 0.01695208f, 0.03369997f, 0.03718436f, -0.00383325f, -0.08995382f, 0.03538172f, -0.14133236f, 
    -0.07522856f, -0.01036692f, 0.02577017f, -0.02024308f, 0.04075424f, 0.04661554f, -0.00738731f, -0.01071224f, 
    0.26519734f, 0.02593748f, -0.03257179f, -0.03659160f, 0.02100138f, 0.16518614f, 0.09251235f, 0.21979168f, 
    0.00574714f, -0.04203128f, -0.06249125f, -0.02240064f, -0.02123562f, 0.10036255f, 0.09026499f, 0.09296976f, 
    0.06048559f, 0.02215715f, -0.01399694f, -0.01845668f, 0.09082027f, -0.11757734f, -0.16067500f, -0.00051553f, 
    0.02675113f, 0.07817850f, -0.01022307f, 0.11184707f, -0.04991786f, 0.03663120f, 0.02811432f, 0.00410848f, 
    -0.09168106f, 0.00613106f, -0.03026611f, 0.01609511f, 0.08359189f, 0.02442024f, 0.00957540f, 0.01823207f, 
    0.32989833f, 0.29339549f, -0.13606405f, -0.39177909f, 0.01849975f, -0.04437942f, 0.07647118f, 0.00792716f, 
    0.10450563f, 0.03634758f, -0.00266033f, -0.03789096f, 0.00725840f, -0.12868978f, -0.04233518f, 0.02954742f, 
    -0.03721610f, 0.09856012f, -0.00881522f, 0.19081005f, -0.40207359f, -0.20735313f, -0.30036241f, 0.08129585f, 
    -0.04834428f, -0.06710470f, 0.03265323f, -0.01604968f, 0.02174092f, 0.04709677f, -0.11223020f, -0.02102249f, 
    0.01665824f, 0.09661926f, 0.06963234f, -0.07492141f, 0.01103125f, 0.01868786f, -0.03321176f, -0.13630138f, 
    -0.44064993f, -0.08881772f, 0.22324054f, -0.01075968f, -0.00294661f, -0.05264384f, 0.00751075f, -0.01605199f, 
    0.08325742f, -0.04266008f, -0.07280306f, 0.02078147f, 0.05040535f, -0.08608560f, -0.03195124f, 0.00033055f, 
    0.03077866f, -0.01503589f, -0.16965023f, -0.02371647f, 0.11289454f, 0.19295295f, 0.09478332f, -0.18332182f, 
    -0.15818177f, 0.06521631f, 0.11721516f, 0.10785444f, 0.06831879f, 0.15239923f, -0.07556892f, 0.02797126f, 
    0.03451990f, -0.01796219f, -0.01722991f, 0.00435302f, -0.06938627f, 0.06345301f, 0.00932250f, -0.04889620f, 
    0.03854203f, 0.24947731f, 0.27156299f, -0.21691853f, -0.21059820f, -0.02049587f, -0.05883865f, -0.06541511f, 
    -0.06891158f, 0.01507823f, -0.03542622f, -0.09057137f, -0.04229710f, 0.04291938f, -0.00886978f, 0.03476330f, 
    0.01096988f, 0.17692913f, 0.19198792f, 0.11901677f, -0.01289138f, -0.02218776f, -0.00470584f, 0.03771818f, 
    0.08596975f, 0.00614289f, -0.00386347f, -0.00507557f, 0.06036648f, 0.07164149f, -0.20881540f, 0.07858286f, 
    -0.10480510f, -0.16359647f, -0.03765251f, -0.01864079f, -0.09674883f, -0.00372103f, -0.05018167f, -0.00310788f, 
    0.01855510f, 0.02785220f, 0.13454780f, 0.01359265f, -0.01305687f, -0.08937619f, -0.03942776f, 0.07670493f, 
    0.02888149f, 0.04358840f, 0.01515541f, 0.09394779f, -0.04765851f, -0.00127642f, -0.05277740f, -0.02324563f, 
    -0.02989731f, 0.03279953f, -0.07801517f, -0.02855130f, 0.26779932f, 0.27222952f, 0.14291777f, -0.32423893f, 
    0.02899815f, 0.15065941f, 0.19372478f, 0.10306513f, -0.01397824f, 0.01212589f, -0.02953873f, -0.03372718f, 
    -0.00349321f, 0.01646372f, -0.04238442f, -0.02442863f, -0.10437561f, -0.00782178f, -0.01460742f, -0.15948264f, 
    0.06767529f, 0.08676819f, -0.02364173f, -0.02077972f, 0.02177635f, -0.00847519f, 0.02543144f, 0.02424877f, 
    -0.01056149f, -0.05665007f, 0.00237179f, -0.13643384f, -0.08924507f, -0.01500043f, -0.01513648f, -0.06079201f, 
    0.01910624f, 0.01206976f, 0.00128905f, -0.00094811f, 0.04474498f, -0.11825971f, 0.01545117f, -0.11624479f, 
    0.05101271f, -0.04044986f, 0.00524263f, -0.03056587f, -0.02995961f, -0.04163028f, -0.03473652f, 0.04527490f, 
    0.04803871f, -0.08845143f, -0.02333295f, -0.00590551f, 0.02527366f, -0.02112847f, -0.07030898f, -0.00411855f, 
    0.27495167f, 0.15361159f, -0.07498082f, -0.19765061f, -0.00613397f, -0.01960248f, 0.06564882f, 0.07613885f, 
    -0.13691162f, -0.10636372f, -0.03037591f, -0.04023964f, 0.05398132f, -0.04466662f, 0.01579956f, -0.02005962f, 
    0.01390384f, -0.01139107f, 0.00352729f, 0.03077320f, 0.04934167f, 0.04150905f, -0.02046189f, 0.05745610f, 
    0.02786018f, 0.03315629f, 0.02790475f, 0.01093407f, 0.00419076f, -0.10841241f, 0.00655397f, -0.08707512f, 
    -0.05055308f, 0.03050284f, 0.03371605f, -0.00314768f, 0.04837731f, -0.05897770f, -0.04916037f, -0.02313057f, 
    -0.08099058f, 0.07027347f, -0.11905984f, -0.04482025f, -0.18230218f, -0.05260900f, -0.05624628f, -0.12370703f, 
    0.01660187f, 0.03758896f, 0.01548010f, -0.01760669f, 0.01524462f, -0.00561863f, -0.00381599f, -0.03995737f, 
    -0.01147140f, -0.00851205f, -0.08573829f, -0.03741055f, 0.11036791f, 0.06090040f, -0.04917929f, 0.02665785f, 
    0.08976624f, 0.05509698f, 0.04275738f, 0.04900715f, -0.03491702f, -0.04269084f, -0.09198131f, -0.09406840f, 
    -0.00921605f, 0.00099942f, 0.03075220f, -0.02800357f, 0.02384821f, 0.01450075f, -0.01323668f, -0.00992781f, 
    -0.11151812f, -0.13773835f, -0.19576979f, 0.07584777f, 0.00454505f, 0.00527926f, -0.03147787f, -0.04319120f, 
    0.02383991f, 0.03334568f, 0.02825166f, -0.06455702f, -0.22677672f, -0.06385560f, -0.05485614f, 0.00206168f, 
    0.06033438f, 0.01612255f, -0.03634648f, 0.02129841f, 0.11204280f, 0.12092051f, -0.01096364f, 0.02439120f, 
    -0.13290438f, -0.02032566f, -0.18436886f, -0.03978094f, -0.14719245f, -0.03037805f, 0.04048866f, 0.01421142f, 
    -0.00190179f, 0.04167087f, -0.01554806f, -0.04933031f, -0.01312412f, -0.03220828f, -0.13796236f, -0.15913107f, 
    0.04613239f, 0.09891649f, 0.40016684f, -0.24842705f, 0.03719851f, -0.12778968f, 0.05417150f, 0.02052349f, 
    0.02926906f, -0.18039846f, 0.00835325f, -0.11588003f, -0.06685329f, -0.03427500f, -0.01000719f, -0.01575388f, 
    0.02253093f, -0.01379494f, 0.02432637f, -0.14804746f, -0.20203361f, -0.25348687f, -0.05275680f, 0.05942319f, 
    -0.10519487f, 0.00592873f, -0.01857615f, 0.01480858f, 0.04626965f, 0.01297124f, -0.00678039f, -0.01579782f, 
    -0.03792847f, 0.04195603f, -0.01891395f, -0.13066109f, -0.01083786f, -0.03689243f, -0.07965320f, 0.04240914f, 
    -0.09598214f, -0.02722338f, 0.24482119f, -0.15551382f, 0.06283445f, -0.03110595f, 0.07523474f, -0.17922240f, 
    0.01250352f, -0.05179639f, -0.13565421f, -0.00219510f, -0.01068869f, -0.01396026f, 0.02244586f, -0.09450388f, 
    0.00137975f, -0.17662281f, -0.08794354f, -0.05106160f, 0.28219518f, 0.27563310f, 0.08598722f, -0.32392174f, 
    -0.06750059f, 0.09595749f, 0.09792972f, 0.04940418f, 0.02706127f, 0.07391024f, 0.00169649f, -0.02039383f, 
    -0.01022047f, 0.02493423f, 0.00700881f, 0.01969278f, -0.03201890f, 0.01805331f, 0.04235842f, 0.01175027f, 
    0.26499945f, 0.09278112f, 0.01438443f, 0.09158374f, 0.00490486f, 0.02269018f, -0.04459742f, -0.07373050f, 
    -0.00982694f, -0.11086357f, -0.08692130f, 0.04057265f, 0.08659972f, 0.04155640f, -0.01351852f, 0.12827532f, 
    0.07009615f, 0.01164082f, 0.10093484f, 0.11015185f, -0.14028963f, -0.12640303f, -0.07421748f, -0.05987223f, 
    -0.02034244f, -0.07872517f, -0.02208697f, 0.00681436f, 0.02494231f, -0.13210042f, -0.03081076f, 0.00327931f, 
    0.01688947f, -0.02564854f, -0.01073676f, -0.03133911f, -0.01337106f, -0.02272496f, -0.06791285f, -0.05338611f, 
    -0.32602689f, 0.02756643f, -0.05855382f, 0.15468933f, 0.13027920f, 0.06054567f, 0.00435096f, -0.05072936f, 
    -0.30542514f, -0.00011813f, -0.01600461f, 0.02158300f, -0.02701462f, 0.00915425f, 0.03974862f, 0.02749621f, 
    0.01990281f, -0.01253018f, -0.19482148f, -0.00113215f, -0.12613209f, -0.04129544f, 0.25876495f, 0.00448228f, 
    -0.05020272f, 0.02112605f, 0.03646581f, -0.02453714f, 0.00533165f, 0.01583584f, 0.00173843f, -0.03374328f, 
    -0.02520493f, 0.09406237f, -0.05875181f, -0.07824390f, 0.10734762f, -0.04896604f, 0.05031851f, -0.01738170f, 
    0.02025978f, 0.10647826f, 0.07927803f, -0.01677802f, 0.08380429f, 0.00530189f, -0.02272157f, 0.05018222f, 
    0.01410669f, -0.07174187f, -0.14604576f, -0.02808385f, 0.03336836f, 0.02407947f, -0.13698959f, -0.15528686f, 
    0.07354917f, 0.03953661f, 0.02305110f, -0.03590197f, 0.01407949f, -0.34736663f, 0.18321355f, 0.01906447f, 
    0.08973219f, -0.07035802f, 0.12995693f, 0.03206439f, 0.00746289f, 0.00791354f, 0.10528776f, 0.02780234f, 
    0.02989514f, -0.01866684f, 0.01073591f, 0.02524402f, -0.01990460f, -0.07181176f, 0.00252529f, -0.08805692f, 
    0.04358520f, -0.05280073f, -0.02353605f, 0.05327471f, -0.07272475f, 0.03801810f, -0.01284018f, -0.00022955f, 
    -0.03541305f, -0.00711000f, -0.04586370f, 0.05153473f, 0.06637936f, 0.05404101f, -0.03106662f, -0.02388549f, 
    0.11927532f, 0.00948791f, 0.06393877f, 0.01651055f, 0.09958909f, -0.38829792f, 0.29108280f, -0.06021858f, 
    -0.12298276f, 0.16185635f, 0.01779886f, 0.10267036f, 0.07028002f, -0.25302425f, 0.02646352f, -0.06905688f, 
    -0.04749467f, -0.21028602f, -0.12548180f, 0.18540467f, 0.09949110f, -0.26403889f, 0.02478344f, -0.03632320f, 
    0.20903988f, -0.32158628f, -0.06573088f, 0.02939946f, -0.09179983f, -0.00437275f, -0.00364591f, 0.04890100f, 
    -0.05905524f, -0.11744606f, 0.06804529f, -0.10586080f, 0.02868562f, -0.04886136f, -0.01237149f, -0.01280881f, 
    -0.03928638f, -0.03110560f, -0.00506092f, -0.02399440f, -0.26124254f, 0.05738370f, -0.16354282f, 0.09099676f, 
    0.20804819f, -0.01431398f, 0.07775684f, -0.10747388f, 0.14625601f, -0.02312434f, -0.04665606f, 0.02952727f, 
    -0.02310743f, 0.02380146f, 0.03803238f, 0.01305621f, -0.01477912f, -0.00446287f, -0.01282795f, 0.01886916f, 
    -0.10813621f, -0.10885150f, -0.13527477f, -0.07951605f, -0.04309726f, -0.04252182f, 0.06488948f, 0.07102289f, 
    0.10631695f, 0.08313126f, 0.06647001f, -0.07901950f, 0.02758779f, 0.07420489f, 0.03980976f, -0.03643740f, 
    0.00957492f, -0.01926010f, 0.02246335f, 0.07084628f, 0.26142058f, 0.14645374f, 0.05350610f, 0.02034255f, 
    0.05166262f, -0.03668946f, -0.05369442f, -0.01491916f, -0.04063623f, -0.06024164f, -0.01133252f, 0.00776321f, 
    0.01586029f, -0.00302147f, -0.03688066f, 0.10192288f, 0.04752242f, -0.15685497f, 0.04951294f, 0.11364325f, 
    0.02046916f, 0.06172556f, 0.00607609f, -0.02509772f, 0.00416438f, 0.01476372f, -0.01881742f, 0.03346832f, 
    0.00802994f, -0.02165154f, -0.05883057f, 0.08817986f, -0.04024377f, -0.00093533f, -0.02661195f, -0.06330231f, 
    0.04509733f, 0.03546029f, -0.00169426f, 0.02821091f, -0.09401453f, -0.08332857f, 0.28652260f, -0.02334201f, 
    -0.17851900f, 0.02190171f, -0.01615977f, -0.02554365f, -0.09963618f, -0.00250513f, 0.05525560f, 0.02641894f, 
    -0.05368641f, -0.16770080f, -0.01795647f, 0.20390081f, -0.05051214f, -0.13147284f, 0.05418774f, -0.03659458f, 
    -0.04828375f, -0.00869549f, -0.03959829f, -0.01301603f, -0.06366333f, 0.00926728f, -0.03354002f, -0.07407561f, 
    0.00212626f, -0.04557357f, 0.15273689f, 0.14211576f, -0.10982508f, 0.00425639f, 0.10865517f, -0.10357574f, 
    -0.03740866f, -0.01709772f, 0.03121965f, -0.02315176f, 0.27631924f, 0.02167648f, 0.22907281f, -0.04446122f, 
    0.12978026f, 0.02406131f, -0.02967196f, -0.01469718f, -0.05341573f, 0.05194941f, -0.00598337f, -0.01024638f, 
    -0.00810100f, -0.00595317f, 0.04798200f, 0.16961986f, -0.00852124f, 0.03351408f, 0.09218760f, -0.06516314f, 
    0.03113937f, 0.05411872f, 0.00359714f, 0.00388648f, 0.01335319f, 0.09679712f, -0.10002255f, -0.01843114f, 
    0.01934488f, -0.06240698f, -0.04318669f, 0.00227671f, 0.00732250f, 0.03769856f, 0.04033305f, -0.05851755f, 
    0.03353563f, 0.08779450f, 0.05449115f, -0.04518148f, -0.30864313f, -0.20862250f, -0.03906298f, -0.27675232f, 
    -0.08540223f, 0.01850970f, 0.20089568f, -0.14155601f, -0.09162040f, -0.04106893f, 0.04486072f, 0.04326739f, 
    -0.03933957f, -0.00298282f, 0.06325725f, -0.04408724f, 0.02996802f, 0.00732082f, -0.01759978f, -0.04506925f, 
    0.06050475f, -0.13465102f, -0.04081839f, -0.01561810f, 0.22449657f, 0.05635642f, 0.10737265f, -0.03837223f, 
    0.03996160f, -0.04144211f, -0.01496729f, 0.07714011f, 0.10374010f, 0.06214394f, 0.08847207f, 0.10365307f, 
    -0.07661235f, 0.06890863f, 0.09711481f, -0.21675545f, -0.84463799f, 0.09674443f, -0.10748319f, 0.04591690f, 
    -0.07791933f, -0.06341486f, 0.08605536f, 0.15469067f, -0.09901178f, 0.01961773f, 0.00204979f, -0.00663202f, 
    -0.00864592f, 0.01192360f, -0.00444815f, 0.04611828f, 0.15456817f, 0.03708913f, -0.07482828f, 0.08955134f, 
    -0.00547045f, 0.02211154f, -0.04046202f, -0.06497528f, -0.03108528f, 0.04058866f, -0.04369612f, 0.00825903f, 
    0.01920937f, -0.10721892f, 0.00348869f, 0.14540806f, -0.02946679f, 0.02077820f, -0.03107790f, -0.05092239f, 
    -0.01909346f, 0.03929429f, 0.05598834f, -0.05526555f, -0.32527506f, 0.09796757f, -0.16797020f, 0.04124638f, 
    -0.03561036f, -0.01055826f, 0.05231168f, 0.15363272f, -0.02406849f, 0.02941130f, 0.07387824f, -0.06566922f, 
    0.03820569f, 0.01370697f, -0.00219154f, -0.00679434f, 0.00691800f, 0.02935266f, -0.05960697f, -0.03566598f, 
    0.05817016f, -0.01168171f, 0.10339551f, -0.11785440f, 0.06748224f, 0.03078839f, 0.01495019f, -0.12873752f, 
    -0.03956845f, -0.01582903f, 0.07592538f, 0.00794114f, -0.01963694f, 0.06251746f, -0.02691307f, -0.20832299f, 
    0.16728331f, -0.12196392f, 0.07977467f, 0.08545332f, -0.57284307f, -0.56152266f, 0.09792966f, -0.22149666f, 
    0.08050177f, 0.18830261f, -0.03674754f, 0.11156161f, 0.16271020f, -0.06067186f, 0.05196725f, -0.04879135f, 
    0.01598492f, -0.04803828f, -0.00560518f, -0.10378601f, 0.10066237f, 0.08321844f, 0.17967778f, 0.03062052f, 
    -0.09492171f, -0.07641765f, -0.31716841f, -0.02770597f, -0.25277418f, -0.07228680f, -0.10399686f, -0.32441097f, 
    0.05657904f, 0.04601851f, -0.04921288f, -0.04226106f, -0.00511537f, 0.05111342f, 0.01924553f, -0.05767708f, 
    0.08503348f, -0.12402156f, -0.00004723f, -0.00444215f, 0.05531213f, 0.18731758f, -0.21535701f, -0.02612008f, 
    -0.08941732f, -0.07719909f, 0.04529364f, -0.05620284f, 0.04898492f, 0.12169797f, -0.02035304f, 0.02711561f, 
    0.02145145f, -0.01102461f, 0.05632710f, -0.08988096f, 0.03584695f, 0.01727709f, -0.03245461f, 0.08920994f, 
    0.23796625f, -0.08788594f, 0.02989201f, -0.03380063f, -0.04354998f, 0.06513631f, -0.12425692f, -0.26185021f, 
    0.05508206f, -0.11816654f, -0.00360786f, -0.05828181f, 0.00435606f, 0.01861129f, 0.02266400f, 0.02653538f, 
    -0.00998777f, -0.11932062f, 0.03158740f, -0.04670394f, 0.26296982f, 0.16561939f, 0.19955753f, 0.15640508f, 
    0.22371465f, 0.13608475f, -0.05697952f, 0.02201105f, 0.16579883f, -0.26852602f, 0.07406512f, -0.07298912f, 
    0.04855243f, -0.06364647f, -0.08659659f, 0.06560741f, 0.03183642f, 0.01868727f, -0.02520081f, -0.03112457f, 
    0.29404581f, 0.23422356f, 0.31303689f, 0.14435877f, -0.02016779f, 0.10580813f, -0.11034857f, -0.04347333f, 
    0.12259342f, 0.04258998f, 0.01479459f, -0.03970915f, 0.02095257f, -0.09525087f, 0.02091530f, 0.01837995f, 
    0.00133268f, -0.03569051f, -0.00474283f, 0.04636470f, 0.10047662f, 0.13683450f, 0.06873251f, 0.01032992f, 
    0.00230507f, 0.23147547f, -0.09807534f, -0.16480632f, 0.00877446f, 0.08923335f, 0.01171205f, 0.05507041f, 
    0.04542870f, 0.04351625f, 0.06000498f, -0.15912998f, -0.06445191f, -0.01662976f, -0.15661229f, -0.06965109f, 
    0.96201265f, 0.03938789f, -0.20518033f, -0.00912105f, -0.18756777f, -0.12264945f, 0.06038702f, -0.02073181f, 
    -0.13889585f, 0.08585908f, 0.06883368f, -0.04929690f, 0.02788492f, -0.02682282f, 0.00957385f, -0.03948480f, 
    0.00517023f, -0.08140543f, -0.02648808f, 0.08446390f, 0.35534075f, 0.17080437f, 0.04610117f, 0.01570155f, 
    0.10322365f, 0.00620294f, -0.01722222f, -0.07742158f, -0.03571019f, -0.08359055f, -0.01284988f, 0.01841084f, 
    -0.02929126f, -0.00969843f, -0.00948886f, -0.06633707f, 0.04308310f, -0.07876713f, 0.10483614f, 0.01130622f, 
    -0.47080421f, -0.01295854f, -0.03539606f, -0.11653523f, 0.16126369f, 0.07413379f, 0.09511676f, 0.14690863f, 
    0.20300837f, 0.16058998f, 0.04232937f, 0.01071872f, -0.01785636f, 0.00669822f, -0.04661307f, -0.01130152f, 
    0.00093956f, 0.01306880f, 0.00089626f, 0.14086047f, -0.25166985f, 0.42522326f, -0.08872649f, 0.11322062f, 
    0.10147097f, 0.04674498f, 0.06324147f, 0.03118869f, -0.08673801f, 0.01247325f, -0.02159487f, -0.00065641f, 
    -0.07250380f, 0.01576696f, -0.01818922f, 0.08587656f, -0.11030827f, 0.04409787f, -0.13632573f, -0.14130287f, 
    0.12482094f, 0.07830878f, 0.07072975f, 0.09237732f, 0.01495508f, 0.02033705f, -0.01515803f, 0.01431343f, 
    -0.01249542f, -0.06125303f, -0.02605355f, 0.03581540f, -0.05820542f, -0.02193490f, 0.05002512f, -0.07270569f, 
    -0.01342019f, -0.02713789f, 0.03987023f, -0.01736761f, 1.24729729f, 0.33508629f, -0.27730089f, 0.00470750f, 
    -0.13075536f, -0.10029078f, 0.04563216f, -0.08490194f, 0.01780451f, -0.01509128f, 0.03750763f, -0.02094624f, 
    0.02486672f, -0.17173611f, -0.18568759f, 0.09658897f, 0.03394508f, -0.02782925f, -0.08521833f, 0.07413840f, 
    -0.06121391f, 0.04752585f, 0.14828129f, 0.03107090f, 0.02746579f, 0.06260118f, 0.03091493f, 0.09675852f, 
    -0.03401346f, -0.04474117f, 0.06656245f, -0.02549553f, -0.00848876f, 0.09111106f, -0.07679251f, -0.04362984f, 
    -0.03093163f, 0.02260409f, -0.02166645f, -0.04879244f, -0.55182046f, 0.04826340f, -0.14495124f, -0.00290727f, 
    0.09477708f, 0.09882265f, -0.09105575f, 0.18831946f, 0.15617925f, 0.07193764f, -0.21231827f, 0.10453769f, 
    0.06215209f, 0.02955176f, 0.01149418f, -0.14385608f, 0.03414851f, 0.06221528f, 0.01682015f, 0.08360256f, 
    -0.21252757f, -0.17936209f, -0.22469147f, -0.12857683f, 0.06882493f, 0.02276921f, 0.00435241f, 0.05341709f, 
    0.12592953f, 0.07757962f, 0.01229107f, 0.04637360f, 0.00236732f, 0.00609288f, -0.10182067f, 0.02466762f, 
    -0.00944538f, -0.06318029f, 0.00952227f, -0.02831394f, 0.28141120f, 0.08239698f, 0.09061051f, -0.05746267f, 
    0.02938385f, -0.02428759f, -0.03125748f, -0.09883293f, 0.04355453f, -0.05441197f, -0.00810941f, -0.04138048f, 
    0.01370964f, 0.01367434f, 0.00333616f, 0.07676183f, 0.04317730f, -0.00592558f, 0.04831694f, -0.01695349f, 
    0.06665213f, 0.05518425f, -0.02714545f, -0.00382027f, -0.04558270f, 0.07529548f, 0.02236261f, -0.07618874f, 
    0.27113056f, 0.05767558f, 0.10650199f, -0.03113928f, -0.00189850f, 0.01633930f, 0.03654353f, -0.05069480f, 
    -0.04453949f, -0.21049975f, 0.01393841f, 0.02337948f, -0.05968802f, -0.01881653f, -0.10532464f, -0.05991986f, 
    -0.06861192f, -0.02999378f, 0.04592588f, 0.05564424f, 0.09690618f, -0.01859357f, -0.15212059f, 0.07030024f, 
    0.05009253f, 0.05182500f, -0.03354083f, -0.01674087f, -0.04136511f, 0.04613621f, -0.00128468f, 0.02986030f, 
    -0.17437211f, 0.04959790f, 0.03076426f, 0.16767278f, -0.05294006f, 0.13780402f, -0.04178238f, 0.17052904f, 
    -0.29184058f, -0.02364828f, -0.03640578f, -0.03665454f, -0.06350847f, -0.05136050f, -0.05214160f, 0.03779675f, 
    -0.01367937f, 0.01117009f, -0.00042849f, 0.01955429f, 0.11001164f, -0.33868355f, 0.06282139f, 0.05044147f, 
    -0.02198131f, -0.05992729f, 0.03116408f, 0.07231121f, 0.01925519f, -0.02068114f, 0.08736646f, -0.14813404f, 
    0.12402787f, -0.02881350f, -0.12110610f, 0.02063429f, -0.02302057f, -0.00145548f, -0.02454212f, -0.05679140f, 
    -0.15366855f, 0.07469390f, -0.20145471f, 0.10566720f, 0.15577036f, 0.22510576f, -0.19646469f, -0.07822509f, 
    0.07755823f, -0.05917887f, 0.08301909f, 0.00152247f, 0.05697025f, -0.02060805f, 0.09514150f, -0.32034048f, 
    -0.02722124f, -0.18552193f, -0.24239334f, -0.24084508f, -0.28745806f, 0.30800927f, 0.15811509f, 0.11087373f, 
    0.13213520f, 0.02460822f, -0.01915920f, -0.01706893f, -0.00723143f, -0.07785039f, 0.01433062f, 0.15333295f, 
    0.16738026f, -0.02226756f, 0.05307949f, 0.11666945f, -0.12191400f, -0.10554485f, 0.01492126f, 0.00738384f, 
    -0.52081674f, -0.37007868f, 0.22981052f, 0.03953716f, 0.09509196f, 0.01601863f, 0.00905662f, -0.00543818f, 
    -0.12478794f, -0.00054930f, 0.11868523f, 0.02016309f, -0.07300386f, -0.00339200f, 0.14428706f, 0.10949668f, 
    0.03654105f, -0.13943093f, 0.09780398f, 0.03558222f, -0.44382894f, -0.02058989f, -0.21815273f, -0.34294692f, 
    -0.53632277f, 0.01497842f, -0.40545070f, 0.00218668f, -0.13170703f, 0.13896750f, -0.03069878f, 0.00687365f, 
    -0.01814769f, 0.04145288f, 0.00801843f, 0.06159214f, -0.02589624f, -0.02785473f, -0.04465527f, -0.19526614f, 
    0.04582107f, 0.09834860f, -0.32598516f, -0.27702227f, -0.51167685f, -0.07114577f, 0.03701395f, -0.07268189f, 
    -0.12714417f, 0.01160687f, -0.02728373f, 0.01205578f, 0.03078409f, 0.01068955f, -0.02240365f, -0.19874784f, 
    -0.17319471f, -0.14096622f, -0.17797314f, -0.28689304f, 0.15404154f, 0.00075103f, -0.04769195f, 0.08017467f, 
    -0.01693024f, -0.00687503f, -0.06986320f, -0.01354107f, 0.08070274f, -0.09172612f, -0.07138409f, 0.02515156f, 
    -0.01041710f, -0.02508544f, -0.05794654f, -0.09539188f, -0.04815002f, 0.05763033f, -0.00576219f, -0.09139686f, 
    -0.04280477f, -0.08672623f, 0.04692661f, -0.05257941f, 0.00115000f, 0.06026667f, 0.08713567f, -0.00923905f, 
    0.02502319f, 0.04479833f, -0.02625040f, -0.02691567f, 0.03193840f, 0.14327586f, 0.05086680f, -0.10120299f, 
    -0.03029913f, -0.03466969f, 0.03884796f, 0.04145199f, -0.25105390f, 0.14964770f, -0.00926506f, 0.29856902f, 
    0.01854623f, -0.10307902f, -0.11104863f, 0.09844596f, -0.21685164f, -0.05466809f, 0.00472710f, 0.04622341f, 
    0.00219799f, -0.06108859f, -0.00251363f, 0.03057573f, 0.07767630f, 0.05824655f, -0.21959405f, 0.15213679f, 
    0.00766590f, -0.00960514f, -0.04899406f, 0.01833187f, 0.00821119f, -0.00782705f, 0.01406656f, 0.03909216f, 
    0.02364009f, -0.00429305f, -0.13979006f, -0.02505220f, 0.04695185f, 0.03530567f, -0.02989656f, -0.00389526f, 
    0.00044781f, 0.00508639f, 0.01767416f, -0.01585813f, 0.08995442f, 0.21778195f, -0.32140455f, -0.13624379f, 
    -0.10757959f, -0.03197017f, -0.03040767f, -0.01348667f, 0.20420294f, 0.09017425f, 0.03957761f, 0.05777926f, 
    0.01533040f, -0.02223698f, -0.07047091f, -0.01646176f, -0.04751273f, -0.02838779f, 0.00529736f, -0.00333123f, 
    0.00837261f, 0.11453939f, -0.15546484f, -0.09592435f, -0.07612419f, 0.08404666f, 0.16226552f, 0.11262815f, 
    0.10445402f, -0.02635021f, -0.01009303f, -0.04422618f, 0.04996667f, -0.02180337f, 0.00227042f, 0.01782239f, 
    0.03899678f, 0.02951992f, -0.03519284f, 0.06817009f, -0.22033858f, -0.33053103f, -0.04820481f, -0.07384660f, 
    -0.08591749f, -0.00929047f, 0.10498590f, -0.03468204f, 0.08799305f, -0.02630772f, -0.07703399f, 0.10534243f, 
    -0.05843252f, 0.04535943f, -0.01023432f, -0.02666219f, 0.00879659f, -0.03916428f, 0.04647891f, 0.06085827f, 
    0.04455034f, -0.24907230f, -0.00435480f, -0.16481943f, -0.14576730f, 0.00001599f, 0.08673374f, -0.26425523f, 
    0.07713676f, 0.10724498f, -0.01140442f, -0.03806725f, 0.02533021f, 0.02814000f, 0.00399821f, -0.04607276f, 
    0.02756927f, -0.10286572f, 0.06114739f, 0.05042050f, -0.07605591f, -0.07099251f, -0.09086177f, -0.01504972f, 
    -0.05928861f, -0.00105984f, 0.02248482f, 0.00351291f, 0.06921917f, -0.06202050f, -0.08330338f, 0.11060012f, 
    -0.02421822f, 0.05215821f, -0.07017075f, -0.05102259f, -0.02295710f, 0.02286672f, 0.02400458f, 0.04495969f, 
    0.30586278f, -0.02798068f, 0.09772170f, 0.10125981f, -0.06913974f, -0.01163931f, -0.00523418f, -0.01453544f, 
    0.00412980f, 0.02315717f, 0.14284876f, -0.05622829f, 0.03451983f, -0.06877480f, -0.06324025f, -0.03825288f, 
    -0.04532503f, -0.15106736f, 0.02264128f, 0.05941898f, -0.08632418f, -0.17956892f, -0.09450401f, -0.05404614f, 
    -0.16564409f, 0.00755809f, 0.01446365f, -0.00860319f, -0.06811497f, 0.06500988f, -0.03511511f, -0.01344340f, 
    0.07292265f, 0.13401099f, 0.09286701f, 0.01451264f, -0.04816616f, -0.07592902f, 0.22686563f, 0.03086743f, 
    -0.75119126f, 0.10547305f, -0.11856085f, -0.10611797f, 0.02176574f, -0.03868182f, -0.02587836f, -0.02634844f, 
    0.06824651f, 0.10710633f, 0.03913490f, 0.06339758f, 0.02559693f, -0.01480996f, -0.06192583f, -0.04378138f, 
    0.05394963f, 0.02737341f, 0.04553896f, -0.00020195f, 0.22074082f, 0.04519209f, 0.08955590f, 0.06540228f, 
    0.11743768f, -0.06813022f, 0.01881468f, 0.01095359f, 0.02628907f, -0.02269511f, -0.01734840f, 0.01222906f, 
    0.02215966f, -0.01986790f, 0.04000413f, 0.07481546f, 0.01134628f, 0.04975832f, 0.05098345f, -0.01992953f, 
    -0.20719698f, -0.10918406f, -0.15604146f, -0.36539984f, 0.24361683f, 0.02613491f, 0.03338849f, -0.02779692f, 
    -0.05138658f, 0.07770267f, 0.00098966f, -0.00459675f, -0.03971157f, -0.05725367f, 0.04984157f, 0.23257260f, 
    -0.07061382f, 0.07990597f, 0.01923619f, -0.15200107f, -0.20811963f, 0.14090185f, -0.08718074f, 0.22712460f, 
    0.09821220f, -0.01285906f, 0.02867086f, -0.07379828f, 0.07348890f, 0.01216864f, -0.04341394f, 0.03160129f, 
    0.00600025f, 0.01266210f, 0.02280024f, 0.01294095f, 0.02461552f, 0.00953448f, -0.18060227f, 0.06305812f, 
    -0.12503545f, 0.05691582f, 0.12248462f, -0.25632349f, -0.03913178f, 0.06014368f, -0.05790604f, -0.04409515f, 
    -0.00477621f, 0.00957535f, 0.03247613f, 0.04025245f, 0.02920014f, -0.05720453f, -0.00505259f, 0.07986962f, 
    -0.11279868f, -0.03817515f, 0.08392674f, 0.05231258f, -0.12499525f, -0.07546686f, 0.04952275f, 0.09496445f, 
    0.06219171f, 0.00588757f, -0.00287189f, 0.05875843f, 0.06356883f, -0.15104178f, -0.04355096f, -0.08093996f, 
    0.01752695f, 0.01467557f, 0.08915447f, -0.02172659f, -0.00583392f, 0.02882588f, 0.00180210f, -0.01939713f, 
    -0.33572739f, -0.33789763f, -0.49526298f, -0.07770635f, -0.39581484f, 0.06865864f, 0.02251404f, -0.08595000f, 
    -0.04596520f, -0.10151646f, -0.01761115f, 0.03568400f, 0.00535249f, 0.01742096f, -0.01989895f, 0.02066622f, 
    -0.01277402f, -0.02079743f, 0.00129943f, -0.02247015f, -0.24021451f, -0.04694171f, 0.08432314f, -0.01593196f, 
    -0.03638560f, -0.00376316f, 0.01119287f, -0.03308215f, -0.04864448f, 0.03497351f, -0.00457376f, -0.02393396f, 
    -0.00583280f, 0.03720363f, -0.01395229f, -0.02804860f, -0.05229071f, 0.01918568f, 0.03188297f, -0.03960870f, 
    -0.00144103f, -0.09882475f, -0.02375285f, -0.03492128f, -0.01815429f, 0.02306433f, -0.05555319f, -0.00024676f, 
    -0.01862316f, 0.01543260f, 0.00916316f, 0.06066603f, -0.12240351f, 0.11767267f, 0.22126614f, 0.08626144f, 
    0.02843899f, -0.04005323f, 0.07773030f, -0.00329370f, 0.22526135f, -0.00655887f, 0.15608415f, 0.06687763f, 
    0.16732341f, -0.05857940f, 0.05734375f, 0.02170593f, 0.05134150f, -0.13240336f, -0.04131866f, 0.02421130f, 
    0.07323590f, -0.02255420f, 0.07678451f, 0.05677748f, -0.02734426f, 0.00689277f, 0.02620044f, 0.00276105f, 
    -0.04268873f, 0.04569248f, 0.07632989f, -0.07564688f, 0.06626511f, 0.04002516f, -0.10639344f, -0.11040826f, 
    -0.08588075f, 0.01156870f, -0.00786500f, 0.03776881f, -0.00690800f, -0.03573033f, 0.02609618f, 0.05334030f, 
    -0.03945747f, -0.09431021f, 0.02889001f, 0.02966361f, 0.03679798f, -0.21381818f, 0.23686528f, 0.08833423f, 
    -0.03524422f, 0.02588407f, -0.15331696f, 0.03614429f, -0.13579862f, -0.03758565f, 0.04242666f, -0.06379854f, 
    0.00089663f, -0.16085735f, 0.04244214f, -0.01547678f, 0.08640581f, -0.04841450f, 0.10119995f, -0.18959016f, 
    -0.06779464f, 0.02759290f, 0.42262542f, 0.13783528f, 0.13556698f, -0.02242541f, -0.03568039f, 0.04809962f, 
    0.11661829f, -0.21244134f, 0.07025662f, -0.02950714f, 0.08336019f, -0.02360440f, 0.11099812f, -0.02646561f, 
    -0.01254220f, 0.04554978f, -0.00729304f, -0.02150713f, -0.15453552f, -0.06997433f, -0.28148445f, 0.04698735f, 
    -0.20652515f, 0.00702542f, 0.08199920f, 0.04688844f, 0.07671558f, -0.10952464f, 0.01217585f, 0.02550136f, 
    -0.05390095f, 0.02792805f, -0.02483310f, 0.03274676f, 0.01664162f, -0.00713177f, -0.03790128f, -0.01064653f, 
    -0.02335110f, 0.03349359f, 0.03008097f, 0.05044443f, 0.13304202f, -0.00001246f, 0.01302852f, -0.13090570f, 
    0.02532277f, -0.16160233f, -0.01454807f, 0.00803416f, 0.03780611f, 0.05630710f, 0.03413287f, 0.01308439f, 
    -0.00735828f, -0.04626349f, 0.02475171f, -0.02941186f, -0.49522370f, -0.17889608f, 0.21501468f, -0.32934573f, 
    -0.00730751f, 0.00479950f, 0.00912045f, -0.06523451f, 0.00239705f, 0.05163775f, -0.00612849f, -0.00951895f, 
    0.02055685f, -0.02057494f, -0.01687881f, -0.00665943f, -0.12068302f, 0.01978461f, -0.03911705f, -0.01100408f, 
    0.08011810f, 0.00787200f, -0.08392678f, 0.01554524f, 0.03109071f, 0.05880227f, -0.03207214f, 0.00956679f, 
    0.04760630f, 0.01855447f, -0.08184145f, -0.13000779f, -0.07426281f, 0.01988410f, -0.01511804f, 0.00233471f, 
    -0.09182584f, -0.03617583f, 0.04193074f, -0.04711194f, -0.22487369f, -0.25602806f, 0.40445778f, 0.10916901f, 
    0.25334221f, -0.12454925f, -0.03389589f, -0.08319465f, -0.02248374f, 0.06757380f, -0.01453905f, 0.00556137f, 
    0.05138047f, -0.05536789f, 0.09828573f, 0.06658040f, 0.04350066f, -0.01524511f, -0.04453446f, 0.05032434f, 
    -0.08162818f, 0.00145198f, -0.01851750f, 0.01937401f, 0.00222539f, 0.01011488f, -0.01308553f, -0.12698358f, 
    0.01210142f, 0.00648907f, 0.02223921f, -0.05855465f, -0.08096743f, 0.01513259f, -0.00174807f, 0.05663836f, 
    -0.00909617f, -0.03785273f, 0.00933479f, -0.01005189f, 0.01011526f, -0.22753923f, -0.00091424f, -0.08034833f, 
    -0.12348774f, 0.06213171f, 0.03368865f, 0.00723274f, -0.01784347f, 0.07585910f, 0.04007389f, 0.02584522f, 
    -0.02739827f, 0.08721364f, -0.04881366f, 0.00849507f, 0.04490897f, 0.07075302f, 0.08958276f, -0.02157596f, 
    0.00842712f, 0.01183851f, 0.05377495f, -0.10397696f, 0.04308821f, 0.07440333f, -0.24314915f, -0.08658622f, 
    0.01771480f, 0.07964265f, 0.03612664f, -0.00903173f, 0.07948787f, -0.05695136f, -0.06712456f, -0.01002142f, 
    0.00266999f, -0.08221145f, 0.01007838f, 0.00144079f, 0.23504150f, 0.08145943f, 0.01927721f, 0.11912350f, 
    0.01994159f, 0.05013834f, -0.00966537f, 0.04471874f, -0.06224261f, 0.07228811f, -0.04075688f, -0.00019289f, 
    -0.02095611f, 0.06112160f, 0.00256685f, 0.03479033f, 0.01393340f, 0.04323591f, 0.13033035f, 0.06304005f, 
    0.33946955f, -0.03848425f, -0.11368209f, 0.06496486f, 0.25735644f, 0.08705235f, 0.02288872f, -0.07020608f, 
    0.00220087f, 0.06024756f, -0.18085580f, 0.08781148f, 0.10005216f, 0.04549100f, -0.10439618f, 0.03547522f, 
    0.02693618f, -0.00848954f, 0.02868306f, 0.00869650f, 0.23699386f, 0.18749169f, -0.26860744f, 0.17965694f, 
    0.07229484f, -0.13261898f, 0.04301056f, 0.12379189f, -0.19859533f, 0.02370228f, 0.04605049f, 0.04257254f, 
    0.02931005f, 0.00568294f, 0.00386641f, -0.02186083f, -0.06932446f, 0.01469621f, -0.10218644f, -0.01970547f, 
    -0.10086252f, 0.02232200f, -0.00493405f, 0.00310249f, 0.01025415f, 0.00790504f, -0.10643347f, -0.09211591f, 
    -0.00498629f, -0.00254427f, -0.05301679f, -0.04280953f, 0.00017946f, -0.01349792f, -0.04908347f, 0.01358212f, 
    -0.06706269f, -0.05429238f, 0.01453987f, -0.01898462f, -0.16892566f, -0.00329267f, -0.11466574f, 0.06959154f, 
    0.01843204f, 0.06558132f, 0.08240753f, 0.07399008f, -0.04960347f, 0.01272601f, 0.05800388f, 0.05070452f, 
    0.07781498f, 0.03397191f, 0.00887043f, 0.03089284f, 0.00542181f, -0.03938726f, 0.03499393f, -0.02338640f, 
    0.00534234f, -0.10477806f, -0.07699076f, -0.14795838f, 0.04534664f, -0.07870346f, -0.02375351f, 0.06572708f, 
    0.02607798f, 0.04046649f, 0.01522889f, -0.00900590f, -0.10975059f, 0.12910393f, 0.04047562f, 0.13050725f, 
    -0.14171062f, 0.00556398f, 0.04362404f, -0.03810232f, 0.46716839f, 0.12341394f, -0.23097742f, -0.15406723f, 
    0.03719968f, 0.00653718f, 0.08850933f, -0.21679693f, -0.05243073f, 0.03555679f, 0.01328755f, -0.08768968f, 
    -0.01055984f, 0.02184977f, -0.10254283f, 0.07473819f, -0.04814764f, 0.05321729f, 0.03160108f, -0.06643985f, 
    -0.11436226f, -0.55047017f, 0.07486566f, -0.28701374f, -0.08915954f, 0.11529224f, 0.02200782f, -0.18331841f, 
    -0.00821135f, -0.11552797f, 0.04697939f, 0.01501064f, -0.01225034f, 0.02948557f, -0.01417711f, 0.05182010f, 
    -0.05867616f, 0.02037506f, 0.04691404f, 0.05518354f, 0.01543499f, 0.12363062f, 0.06419139f, 0.16597642f, 
    -0.10840059f, 0.01395098f, 0.06489921f, 0.08311199f, 0.05300413f, 0.05277009f, 0.02163861f, 0.02468681f, 
    0.00431209f, 0.02971200f, 0.08018817f, 0.02628340f, 0.00683553f, -0.03154328f, 0.07901576f, 0.01938171f, 
    -0.76333249f, -0.33833587f, 0.30213425f, -0.17887698f, -0.06991094f, -0.18457615f, 0.11522783f, -0.05836431f, 
    0.00159053f, 0.03037246f, 0.00586382f, -0.02409397f, -0.00405124f, 0.01547970f, -0.03151753f, -0.05042377f, 
    -0.12640530f, 0.08096401f, -0.10719590f, 0.01497427f, -0.01595466f, -0.37951633f, 0.50318033f, 0.56246299f, 
    0.04409964f, 0.00407406f, 0.05153032f, -0.20299618f, 0.18029928f, -0.02771434f, -0.00059754f, 0.01510181f, 
    0.03206709f, 0.00211289f, -0.05560167f, -0.05444532f, -0.02381943f, -0.04286281f, -0.00463431f, -0.06837878f, 
    -0.32597253f, -0.23171172f, 0.42626670f, 0.35730961f, -0.02949175f, -0.03474855f, -0.02619166f, -0.00538877f, 
    0.06154246f, -0.07993065f, -0.00993887f, -0.00013001f, -0.02568710f, 0.03510620f, -0.07561577f, -0.02216390f, 
    0.00916594f, -0.03886446f, -0.00461463f, -0.02075780f, -0.33633476f, -0.52278721f, -0.25831938f, 0.08139201f, 
    -0.34035486f, -0.04307083f, -0.02932283f, 0.00885720f, -0.06376745f, -0.15746219f, -0.02384684f, -0.04498042f, 
    0.01036589f, -0.00033043f, -0.03399312f, -0.06998942f, -0.03281622f, 0.04818415f, -0.02699127f, 0.16699421f, 
    -0.14698675f, 0.40649465f, 0.42870370f, -0.04451882f, 0.14680223f, -0.09811720f, 0.03580517f, -0.06080437f, 
    -0.05548588f, 0.00487499f, 0.02369030f, 0.05027109f, -0.09654934f, 0.01310567f, 0.07766826f, 0.04267645f, 
    -0.02961622f, -0.04233363f, 0.08982045f, -0.08893800f, -0.33492306f, -0.14927982f, -0.02195974f, -0.24092802f, 
    -0.26979673f, -0.00377190f, -0.02122854f, -0.04761056f, 0.00834617f, 0.06985608f, 0.04056027f, -0.01423634f, 
    0.00550529f, 0.05824516f, -0.01849043f, 0.14606224f, -0.07233652f, -0.04788166f, 0.05197408f, 0.02237223f, 
    0.04471855f, 0.18016045f, -0.21257921f, 0.09788698f, 0.04785110f, 0.01289057f, 0.03895729f, -0.06401093f, 
    -0.05068993f, 0.01838203f, -0.02843866f, 0.09187616f, -0.05854026f, 0.00748499f, -0.00455088f, -0.02618490f, 
    -0.02066443f, 0.04827051f, -0.12748702f, 0.07656783f, -0.05815953f, 0.01871857f, -0.16017760f, 0.12263842f, 
    -0.05076502f, 0.04613272f, 0.04529873f, -0.00445251f, -0.09093440f, 0.11720328f, 0.01164465f, 0.02109541f, 
    0.01389333f, 0.06783190f, -0.06039519f, 0.10644429f, 0.14706188f, 0.10344446f, -0.00269324f, 0.02395071f, 
    -0.03735431f, -0.06579573f, 0.01708321f, -0.12694484f, 0.03138688f, 0.00576670f, -0.05840696f, -0.02471515f, 
    0.01915349f, 0.05170543f, -0.03259877f, -0.06538958f, -0.07899432f, 0.07723562f, 0.01505530f, 0.10040314f, 
    -0.10059381f, -0.01643749f, 0.02556960f, -0.00422543f, -0.52566803f, 0.53448224f, -0.11893762f, 0.00736975f, 
    -0.20160137f, 0.01467323f, -0.05782422f, -0.01288898f, -0.08945797f, 0.10076861f, 0.01003315f, 0.04709548f, 
    0.05850459f, -0.08943705f, -0.00971462f, -0.07170407f, 0.01179996f, 0.12047990f, 0.05117407f, -0.05584158f, 
    0.02995933f, -0.04449950f, -0.02065472f, 0.00189867f, 0.08987388f, 0.02654064f, -0.00636804f, 0.02164933f, 
    -0.02802536f, 0.00862572f, 0.03561609f, 0.01994362f, -0.07872491f, 0.09474785f, -0.03509467f, 0.01168588f, 
    0.03644780f, 0.11251210f, 0.05055016f, -0.08221790f, 0.27828652f, -0.00811394f, -0.22349516f, 0.14880620f, 
    0.09940644f, 0.10055564f, -0.00072134f, -0.21782690f, -0.08033838f, 0.07183772f, -0.12227270f, 0.03357606f, 
    0.01867700f, 0.02547599f, -0.06875979f, 0.00178051f, -0.01043121f, 0.01417658f, 0.06984528f, -0.04714169f, 
    0.28583980f, 0.07374531f, -0.01061384f, 0.14342867f, 0.20496839f, -0.06478372f, 0.09680077f, -0.10971917f, 
    0.06993223f, 0.06441850f, -0.06299233f, -0.00077074f, -0.01391096f, 0.02168246f, -0.04721162f, 0.01668657f, 
    0.02682181f, -0.00639285f, -0.15111732f, 0.05891372f, -0.27541474f, -0.09335268f, 0.23913491f, -0.09318551f, 
    -0.08061665f, 0.02916732f, 0.04564593f, 0.00697337f, -0.02363938f, 0.07015388f, 0.03002026f, -0.02365546f, 
    -0.01532671f, 0.05289708f, -0.03906019f, 0.03399067f, -0.04599378f, 0.03819945f, -0.07133829f, -0.02788486f, 
    -0.04445298f, -0.08383027f, 0.22779962f, 0.21542902f, 0.02941656f, 0.01843375f, 0.03818873f, -0.00871080f, 
    0.07175694f, -0.05884735f, 0.01156759f, 0.03696175f, 0.02185440f, 0.06578290f, -0.06009174f, 0.01507491f, 
    0.01832085f, 0.01007875f, 0.05313358f, -0.01312811f, 0.01017081f, -0.01681749f, 0.05033024f, 0.04857631f, 
    0.05466895f, 0.02610121f, -0.02392194f, -0.01290120f, 0.05955713f, -0.09639311f, 0.00213123f, 0.03276047f, 
    -0.06933962f, 0.02290752f, 0.02042644f, 0.01709334f, -0.03914401f, -0.01094144f, 0.01233620f, -0.01643971f, 
    -0.29466817f, 0.31557536f, 0.36195976f, 0.11480885f, 0.36161625f, -0.17691626f, 0.00158645f, 0.07416047f, 
    0.12513034f, 0.11432128f, 0.02479963f, 0.05002197f, 0.02111976f, -0.04886457f, 0.09025174f, -0.00522472f, 
    0.02467021f, 0.00461225f, -0.02752841f, 0.02254269f, 0.09818558f, -0.05401388f, 0.26950130f, 0.01835093f, 
    0.15194695f, -0.00826431f, 0.02245944f, 0.06529809f, 0.03531254f, -0.03226078f, -0.00565421f, 0.02527200f, 
    0.07184967f, -0.10168245f, 0.15303969f, 0.02026398f, -0.00803968f, -0.01902504f, 0.04384190f, -0.03534187f, 
    0.22255713f, 0.09364390f, -0.03096291f, 0.35865068f, 0.04662890f, 0.09014227f, -0.02903233f, -0.16053270f, 
    0.12721686f, -0.08046314f, -0.03770739f, 0.02360559f, -0.07516120f, -0.04786629f, 0.01853340f, -0.03557468f, 
    0.16993719f, 0.08292050f, -0.02762764f, 0.08697788f, 0.27813730f, -0.22145464f, 0.04006792f, -0.21363781f, 
    -0.07316310f, 0.06365440f, -0.04227316f, -0.02192716f, -0.04773587f, -0.04423535f, -0.00465664f, -0.04452589f, 
    -0.00615079f, -0.08041146f, 0.01717617f, 0.06241317f, 0.04743974f, -0.10296227f, 0.04746481f, 0.02860847f, 
    0.15263905f, -0.14223029f, -0.02815799f, -0.06549944f, 0.03866789f, 0.02712886f, 0.00540859f, -0.01758960f, 
    -0.02070574f, -0.00144186f, 0.01681767f, 0.00218266f, 0.04682232f, 0.03406554f, 0.00114803f, 0.08039881f, 
    0.10053548f, -0.02643066f, 0.15676703f, 0.10861170f, -0.50074607f, -0.21195671f, 0.03824636f, -0.28973320f, 
    -0.45102245f, 0.04037857f, 0.08463675f, -0.08209439f, -0.08039743f, -0.16528012f, -0.00515101f, 0.00853883f, 
    0.01360338f, 0.03706019f, -0.08012970f, 0.01694118f, -0.03646054f, -0.15678179f, 0.07924042f, 0.13912441f, 
    -0.26226771f, -0.19621195f, 0.22919822f, 0.10206145f, -0.36597064f, -0.03876374f, -0.01449283f, -0.05938042f, 
    -0.05916054f, 0.10615982f, -0.02879971f, -0.01085015f, 0.00036445f, -0.02594243f, -0.03165248f, -0.00314245f, 
    0.09774453f, 0.14051472f, 0.11584269f, 0.16099839f, -0.03647510f, -0.05527525f, -0.04373510f, -0.08174475f, 
    -0.00919425f, 0.01280586f, -0.04821291f, -0.00728162f, 0.04844036f, 0.06119467f, -0.07408572f, -0.08141878f, 
    -0.17507203f, 0.15268183f, 0.04426542f, 0.12094050f, -0.04104781f, -0.03184765f, 0.06364345f, -0.00891925f, 
    -0.07126836f, 0.02350447f, -0.03209982f, 0.01673393f, 0.05707507f, -0.01296746f, -0.11564160f, -0.12276968f, 
    -0.02360796f, -0.02795043f, 0.06218953f, -0.06102249f, -0.05747364f, 0.00920074f, -0.04540904f, -0.00286377f, 
    -0.07837594f, -0.02448825f, -0.05035236f, -0.05008611f, -0.34660023f, -0.50862151f, -0.51639450f, 0.16782248f, 
    -0.27009088f, -0.11096424f, -0.03937731f, 0.07573289f, -0.10996163f, 0.08051464f, -0.04676674f, -0.00802120f, 
    0.01566539f, -0.03593045f, -0.02426047f, -0.02652507f, 0.00014512f, 0.02122925f, -0.27167878f, 0.02714470f, 
    0.09770560f, -0.05147499f, 0.04543138f, 0.04855696f, 0.06616718f, 0.01407774f, -0.07513729f, -0.02414147f, 
    0.06788032f, -0.01024184f, -0.09087253f, -0.01565992f, 0.05822191f, 0.02765186f, -0.01235534f, -0.01569329f, 
    -0.08721669f, -0.03888337f, 0.01486097f, -0.03227614f, -0.12349714f, 0.05014113f, -0.04971921f, -0.01979120f, 
    0.07362228f, 0.06258515f, -0.02783909f, 0.02806394f, 0.11234073f, -0.07928058f, 0.01650793f, 0.09924806f, 
    -0.08747678f, 0.02127910f, -0.03166777f, 0.00171488f, 0.00440226f, 0.05504549f, -0.03209837f, 0.00390004f, 
    -0.08634610f, -0.07105836f, 0.20373835f, 0.21849771f, -0.19771825f, 0.03697357f, -0.19151565f, -0.03571578f, 
    0.11386693f, -0.19194335f, -0.00595233f, 0.06907385f, -0.04493034f, 0.02385633f, -0.01236787f, -0.03640184f, 
    -0.03073383f, 0.02205635f, 0.05337998f, -0.01550143f, 0.13945307f, 0.07594770f, 0.16941695f, 0.03757393f, 
    0.12512800f, -0.03645818f, 0.01746100f, -0.01256357f, -0.00584139f, -0.09348250f, 0.00774217f, -0.05746595f, 
    -0.04499165f, 0.05518446f, 0.07167827f, 0.00965371f, -0.06937066f, -0.04190828f, 0.00841042f, -0.01046551f, 
    -0.01716811f, -0.40479645f, 0.26519713f, -0.17847608f, 0.00553368f, 0.07844131f, 0.01577293f, -0.28052625f, 
    -0.07405706f, -0.04663657f, 0.00876542f, -0.00012412f, 0.00651350f, -0.00010373f, -0.03574912f, 0.01944889f, 
    -0.04538355f, -0.08172815f, 0.04505908f, 0.09194461f, 0.05350548f, -0.03547279f, 0.10896813f, 0.06871832f, 
    0.05078736f, 0.01045468f, -0.07229303f, 0.01173519f, 0.09957451f, -0.16007213f, -0.06468205f, -0.09434941f, 
    -0.02162135f, 0.01887137f, 0.00945119f, 0.02501294f, -0.07949142f, -0.01343070f, 0.02655146f, -0.04789242f, 
    0.02155664f, 0.00217466f, 0.15815079f, -0.06533493f, 0.08251760f, -0.00085805f, -0.00726382f, -0.01660442f, 
    -0.01572040f, 0.06705333f, -0.08094389f, -0.02180601f, -0.07863414f, 0.01145926f, 0.07401928f, 0.03532509f, 
    -0.03870493f, -0.04361941f, 0.06348293f, -0.02618247f, -0.21249104f, -0.04394051f, 0.03227677f, -0.03630415f, 
    0.02022151f, 0.00128938f, 0.03814426f, -0.17727789f, -0.20964161f, -0.13087200f, 0.03682512f, 0.02382198f, 
    -0.02106663f, 0.00170851f, -0.01818171f, 0.01498733f, -0.01158121f, -0.02958820f, -0.10740944f, -0.06160741f, 
    0.56117707f, 0.16783831f, -0.52004963f, 0.13490224f, 0.06741901f, -0.01858015f, 0.12944692f, -0.00679530f, 
    -0.05573771f, 0.15491694f, -0.02991569f, -0.01939074f, -0.03197699f, -0.01817641f, -0.07389321f, 0.03955255f, 
    0.03739981f, 0.07641781f, -0.21355762f, 0.11621368f, -0.00056702f, -0.07113755f, 0.03580517f, -0.21983972f, 
    0.10563970f, 0.01744667f, -0.00959416f, -0.00228284f, 0.02137881f, 0.06674562f, 0.01782332f, -0.00645545f, 
    -0.00204762f, 0.00516671f, 0.03806144f, 0.11700092f, -0.06900690f, -0.16278678f, 0.12896129f, -0.00680212f, 
    -0.06610390f, 0.02069999f, -0.27034760f, -0.12895797f, -0.03949554f, 0.09689602f, 0.01276356f, 0.05473386f, 
    0.00224648f, -0.02034833f, 0.02546654f, 0.03867594f, 0.05262830f, 0.06292580f, -0.09878129f, 0.03630928f, 
    0.01808741f, -0.09402584f, -0.08926262f, -0.00652837f, -0.40861264f, -0.56485474f, -0.52318215f, -0.04203478f, 
    -0.48099187f, 0.02107391f, 0.04772474f, -0.02129928f, -0.09846549f, -0.23315337f, -0.01273463f, 0.00576831f, 
    -0.01757610f, 0.01406958f, -0.03553648f, -0.02167198f, -0.00844506f, 0.01429244f, -0.20291910f, -0.05454570f, 
    -0.18054457f, -0.01032583f, 0.03447580f, 0.12276892f, 0.16546147f, -0.03862789f, 0.02272359f, -0.04612215f, 
    -0.04161180f, 0.03864215f, 0.00270544f, -0.01384866f, -0.06310172f, -0.05208224f, 0.03996852f, -0.04309772f, 
    -0.02100355f, 0.06702536f, -0.04246446f, 0.00942474f, -0.05514402f, 0.28339520f, -0.09627754f, -0.20491973f, 
    0.23865323f, 0.25709891f, 0.23746853f, -0.01122556f, -0.03365425f, -0.26612589f, -0.04991574f, 0.08675630f, 
    0.06845739f, -0.00078690f, 0.08708927f, -0.07392291f, 0.19197363f, 0.08770292f, 0.13773638f, -0.27059880f, 
    0.11372574f, -0.16560890f, -0.20595881f, -0.08629785f, 0.11868142f, 0.06837860f, 0.09163565f, 0.04883342f, 
    0.04417340f, 0.04904336f, 0.01017977f, -0.02798831f, 0.02766998f, -0.07910592f, -0.05200689f, -0.09551135f, 
    -0.04971774f, 0.04425305f, 0.03689459f, -0.05695122f, -0.36393270f, -0.06750590f, 0.55961937f, 0.33040550f, 
    0.36801171f, -0.05224643f, -0.07910921f, -0.12669094f, 0.05011691f, -0.13258414f, -0.03366128f, 0.00544406f, 
    -0.02090378f, -0.03002816f, 0.08379899f, -0.02708821f, 0.06764859f, 0.01309545f, 0.02363109f, -0.06786340f, 
    -0.00501021f, -0.09889406f, 0.07875998f, -0.09651950f, -0.38972604f, 0.09423301f, 0.09474329f, -0.03304594f, 
    0.09673804f, -0.20944490f, 0.07597293f, -0.02697268f, -0.02857168f, 0.04956689f, -0.12514357f, 0.01376595f, 
    -0.05723914f, 0.27726784f, -0.04586330f, -0.15151210f, -0.12454545f, 0.43746766f, 0.03302119f, -0.12855642f, 
    0.00563900f, 0.15896854f, -0.01775148f, -0.04279888f, -0.08501945f, -0.00564074f, -0.12107056f, -0.08871362f, 
    -0.03492437f, -0.01875976f, 0.05748002f, -0.06118366f, 0.11028660f, 0.00068703f, 0.05502347f, -0.02364433f, 
    -0.13248457f, 0.06623247f, 0.01444852f, 0.06448549f, 0.13287671f, 0.02586921f, -0.04721895f, 0.03431345f, 
    -0.10140611f, 0.02813162f, -0.02196555f, -0.02609398f, -0.07951411f, -0.05581655f, -0.06622659f, -0.11166328f, 
    0.02128567f, 0.07790764f, -0.00696905f, -0.07364280f, 0.23148878f, 0.17178857f, -0.26844698f, 0.18202463f, 
    -0.02191783f, 0.13931496f, 0.10139471f, -0.09953251f, 0.06711186f, 0.10547699f, 0.00801928f, -0.01429233f, 
    -0.04688080f, -0.11195015f, -0.06453695f, -0.01291460f, -0.10717140f, 0.09266578f, 0.09564120f, -0.06804825f, 
    -0.22124147f, 0.48647088f, -0.00008832f, -0.02193243f, 0.20317362f, 0.27675280f, 0.08653599f, -0.02421262f, 
    -0.07810705f, -0.04956310f, -0.11723629f, 0.03127338f, 0.05894385f, -0.01050488f, 0.04679858f, -0.02024025f, 
    -0.05097333f, -0.00362818f, 0.02903941f, 0.04794530f, 0.04028460f, -0.08590756f, -0.19758874f, -0.05604728f, 
    0.12689476f, 0.08016284f, 0.05203719f, 0.03913567f, 0.05800540f, 0.05002343f, 0.11827241f, -0.02216304f, 
    0.00607850f, 0.00246024f, -0.03343875f, 0.00337158f, -0.07536487f, 0.14767797f, -0.12728147f, 0.05341406f, 
    -0.08191600f, -0.05048575f, -0.11407929f, -0.06046876f, 0.08425824f, 0.01320172f, 0.07106284f, 0.02534473f, 
    0.06727670f, 0.08356838f, -0.02531737f, 0.06962410f, -0.00605637f, -0.07138315f, 0.00873276f, 0.02668739f, 
    0.02802534f, -0.03331133f, 0.12329795f, 0.12139701f, -0.49639270f, -0.24267764f, 0.31972823f, -0.05977648f, 
    0.26767105f, -0.06711898f, -0.01523118f, -0.21818079f, 0.08103582f, -0.02654732f, 0.10527291f, 0.08426388f, 
    0.04132377f, 0.00904215f, 0.11304685f, -0.02440685f, 0.06899371f, 0.04968459f, -0.03686183f, -0.00854492f, 
    -0.36327758f, 0.10523536f, -0.18307017f, -0.25088996f, -0.14519705f, -0.05399978f, -0.01021847f, -0.01450335f, 
    0.02909817f, -0.15181243f, -0.02777083f, 0.02008778f, -0.23095615f, -0.07079502f, -0.08621973f, 0.01833227f, 
    -0.01280495f, 0.05922871f, -0.11467286f, -0.25772277f, 0.33196855f, 0.17211114f, -0.07768299f, -0.07377818f, 
    0.10348447f, 0.17582606f, 0.03603053f, 0.06240131f, 0.12533590f, 0.03651975f, -0.15472932f, -0.02763212f, 
    0.01705415f, 0.09170160f, 0.08854723f, -0.10558610f, 0.09105396f, -0.02104703f, 0.07430657f, 0.06954224f, 
    -0.13294344f, 0.28195861f, -0.12845381f, 0.36604795f, 0.12818110f, -0.01489467f, -0.01724167f, -0.08796860f, 
    0.05764838f, 0.01870443f, 0.03468778f, 0.04305097f, 0.06367592f, -0.05266761f, -0.01684373f, 0.18178838f, 
    0.05438789f, 0.12571213f, 0.01309232f, 0.00260854f, 0.07112125f, -0.24764678f, -0.05331369f, -0.07186737f, 
    -0.13998589f, -0.09892198f, -0.01620416f, -0.05219493f, 0.01549885f, -0.09510069f, -0.04422608f, -0.07738096f, 
    0.01079052f, -0.04557719f, -0.04029224f, -0.14883046f, -0.04812004f, -0.16711351f, 0.03161652f, 0.01837352f, 
    -0.13265002f, 0.11941132f, 0.19628519f, 0.06126860f, 0.14060847f, -0.04706591f, 0.07899386f, 0.01376541f, 
    -0.00626977f, -0.06652162f, 0.05773767f, -0.01399132f, -0.08920493f, -0.03047380f, 0.07807521f, 0.02602892f, 
    -0.13548401f, 0.05719348f, -0.14681125f, -0.10019287f, 0.31977031f, 0.00720050f, -0.02109592f, -0.26869845f, 
    0.13095583f, -0.00574584f, -0.07659755f, 0.01711583f, -0.03440764f, -0.09326617f, -0.05940682f, -0.09683553f, 
    -0.00542697f, 0.11507553f, -0.04071480f, -0.01457031f, 0.02136830f, 0.07037659f, -0.03206068f, 0.01312504f, 
    0.57957804f, 0.64071268f, 0.17151299f, -0.63427347f, 0.11950282f, 0.05812282f, 0.04254266f, -0.04212071f, 
    -0.21577802f, -0.06546471f, -0.03347974f, -0.05570032f, 0.20212300f, -0.19437894f, 0.03810161f, -0.09101956f, 
    -0.00873471f, -0.13384716f, 0.08935115f, 0.02893813f, -0.11859024f, 0.10662956f, -0.22967286f, -0.25093934f, 
    0.04951562f, 0.01266291f, -0.05154281f, -0.04344455f, 0.00041665f, -0.22862826f, 0.00662822f, -0.01943064f, 
    -0.04897857f, -0.09221744f, 0.01272850f, 0.08085316f, 0.01339411f, 0.00518755f, -0.17659646f, -0.30331647f, 
    -0.14461401f, -0.12321464f, -0.09844106f, 0.04814078f, -0.05545860f, 0.09434876f, 0.15895748f, 0.05213382f, 
    -0.02305403f, 0.08287208f, -0.01752797f, -0.03716491f, -0.10341210f, 0.06982188f, -0.10670983f, 0.07094851f, 
    -0.02253406f, 0.11815598f, 0.07037913f, -0.11134038f, -0.06101152f, -0.03805589f, -0.08984309f, 0.02013413f, 
    0.05250925f, -0.00266675f, 0.01121214f, -0.00417934f, 0.06299888f, 0.00594464f, -0.01296722f, 0.02312710f, 
    -0.00031981f, -0.06371333f, -0.07318430f, 0.07863721f, -0.04637279f, 0.02157342f, -0.01046632f, -0.08741840f, 
    0.11578035f, 0.17891730f, 0.23858242f, -0.26050499f, -0.20781431f, -0.06591608f, -0.21810088f, -0.08168805f, 
    -0.16083857f, -0.12447122f, -0.05507680f, -0.07250274f, 0.06801217f, 0.04802033f, 0.04203425f, 0.00379365f, 
    0.02632485f, 0.05390645f, -0.05558256f, -0.00646308f, 0.64609885f, 0.63440758f, -0.22051165f, -0.82763940f, 
    -0.02715223f, -0.03897360f, -0.15861242f, 0.05314012f, -0.12012859f, -0.20016538f, 0.00771726f, -0.03137022f, 
    0.00384551f, -0.12083735f, 0.00607004f, 0.05678874f, -0.05328603f, -0.00303453f, 0.05535202f, 0.01913807f, 
    0.03575285f, -0.02323431f, 0.13872018f, -0.10115188f, 0.24267709f, -0.07063388f, 0.07411429f, -0.02052184f, 
    -0.00094888f, 0.05309838f, 0.04046171f, -0.08011089f, -0.03222343f, 0.07792229f, 0.02443608f, -0.03282465f, 
    -0.10355178f, 0.01700524f, -0.07200126f, 0.09968109f, 0.03521619f, -0.14117821f, -0.04477910f, -0.00692754f, 
    0.15168926f, -0.01011525f, -0.10547033f, -0.01628301f, 0.02261905f, -0.12845479f, 0.08949643f, 0.03244092f, 
    -0.01653165f, -0.01389199f, -0.04408575f, -0.03808074f, 0.06062231f, 0.10420856f, 0.01023666f, 0.07476630f, 
    -0.09286608f, -0.43231717f, 0.42362821f, -0.08904345f, 0.21412775f, -0.23934013f, 0.02182650f, 0.10301935f, 
    -0.01479834f, 0.03034963f, 0.18547848f, 0.05671139f, -0.00927418f, 0.01668459f, 0.16652241f, -0.05768630f, 
    -0.04725217f, 0.11506630f, -0.14561746f, -0.06731147f, -0.50080699f, 0.16242351f, -0.21935287f, -0.02774014f, 
    0.29983836f, 0.12103646f, 0.02125960f, -0.02920432f, 0.01222632f, -0.05309809f, -0.13437134f, 0.11785565f, 
    -0.08827002f, 0.13131841f, 0.09693781f, -0.05780092f, -0.03756851f, 0.09922822f, -0.02391082f, -0.05167245f, 
    -0.08731008f, -0.02035969f, -0.22725269f, 0.04297803f, 0.22982664f, 0.04201119f, 0.00101772f, 0.01245715f, 
    -0.02036502f, 0.00900857f, -0.01135221f, 0.07856436f, 0.04710421f, 0.05951356f, 0.08243026f, -0.02953873f, 
    0.00345026f, 0.13100763f, -0.03742313f, 0.09495436f, 0.08843613f, -0.08742747f, -0.16420306f, -0.04520394f, 
    0.19051903f, -0.02500704f, 0.13286749f, 0.05873774f, 0.03124390f, 0.06232391f, -0.06168462f, -0.02779750f, 
    0.00511739f, -0.08417746f, -0.00217103f, 0.06138578f, 0.04382479f, -0.01356115f, 0.00274006f, -0.06013440f, 
    -0.65150523f, 0.59640485f, 0.13185355f, 0.15118848f, 0.41136143f, -0.02081230f, 0.03506390f, 0.09349950f, 
    -0.14396663f, -0.02195107f, -0.13563636f, 0.05672354f, 0.08649742f, 0.08508445f, 0.03949910f, 0.10066393f, 
    0.00025013f, 0.11017171f, -0.05754113f, -0.06677697f, -0.48814684f, 0.11514144f, 0.08470469f, -0.15353703f, 
    -0.34773687f, -0.24461173f, -0.10461567f, 0.11686610f, 0.04971892f, -0.12042221f, 0.03880994f, -0.01225745f, 
    -0.02778726f, 0.09059321f, -0.05375187f, -0.01569035f, 0.02969538f, -0.01933977f, 0.08434075f, -0.18657994f, 
    0.10336313f, -0.07316907f, -0.12773462f, -0.17872937f, -0.01693600f, 0.01110014f, 0.03850830f, -0.06652509f, 
    -0.02122256f, -0.00831696f, 0.04397142f, 0.01021053f, -0.15672834f, -0.05498672f, -0.02455912f, 0.04981409f, 
    -0.03726069f, 0.11452692f, -0.15848348f, -0.07028016f, -0.41237324f, 0.10573314f, 0.05458847f, -0.10961279f, 
    -0.08224536f, -0.02693127f, 0.04628541f, -0.10760444f, -0.03136711f, -0.11774667f, -0.05203619f, 0.08722689f, 
    -0.13100210f, -0.04294055f, -0.12333758f, -0.09209660f, 0.02801205f, 0.09361010f, -0.07115822f, -0.09561303f, 
    -0.42177904f, -0.17609948f, -0.20411709f, 0.01212793f, -0.26674321f, -0.01550706f, -0.12015561f, -0.19931194f, 
    -0.08044364f, -0.07699742f, 0.02878049f, -0.04473351f, 0.00474905f, 0.04207431f, -0.10786051f, 0.03455292f, 
    -0.01236987f, -0.05991015f, -0.09157235f, -0.07512547f, -0.26089942f, 0.19089904f, 0.09959149f, -0.19177425f, 
    0.34015092f, 0.03187957f, 0.18485610f, -0.02731739f, -0.06791267f, -0.04792277f, 0.00932915f, -0.02042211f, 
    -0.00292650f, 0.06075089f, 0.03450079f, -0.00319968f, 0.02959727f, 0.05414793f, 0.01306124f, -0.07737728f, 
    -0.09976716f, -0.15445508f, -0.01152586f, -0.13530792f, -0.35141277f, -0.04026908f, -0.03492714f, -0.03396901f, 
    -0.01555992f, -0.19234450f, -0.03775721f, 0.00257053f, -0.04866273f, -0.09438075f, -0.00612195f, -0.12416390f, 
    -0.06040597f, 0.11300739f, -0.23631907f, -0.12238871f, 0.19055030f, 0.28023264f, 0.04077727f, -0.36086202f, 
    0.37909600f, 0.01754207f, -0.04628623f, -0.01415081f, 0.03729891f, -0.16427609f, 0.06049451f, 0.00823475f, 
    -0.18208690f, 0.02237380f, -0.12185610f, 0.04257528f, 0.00475746f, 0.00413624f, 0.05373691f, -0.08366014f, 
    -0.03526033f, 0.35653770f, -0.06878714f, -0.23699954f, 0.04429568f, 0.12497158f, 0.03023640f, -0.11621625f, 
    -0.01041330f, -0.23337474f, -0.07813041f, -0.03788356f, -0.04773452f, -0.00378928f, 0.12041021f, 0.07362515f, 
    0.04694425f, -0.00290977f, -0.03981427f, 0.02228502f, -0.13382390f, -0.29357961f, 0.23430826f, 0.01315238f, 
    -0.00110634f, -0.09099428f, -0.05123340f, 0.03528804f, 0.03560135f, -0.06649143f, 0.07464805f, 0.05362085f, 
    0.02786925f, 0.01682312f, 0.01534808f, -0.05351850f, -0.04284048f, -0.00078827f, 0.05203503f, -0.07681790f, 
    -0.02328217f, 0.08194721f, -0.19102718f, 0.05563542f, 0.12703829f, 0.04204797f, -0.02488833f, -0.00587794f, 
    -0.03447747f, 0.02013926f, -0.12731850f, 0.08280268f, -0.02488192f, 0.04411054f, 0.07048302f, -0.03596447f, 
    -0.02047272f, 0.03049109f, 0.06438444f, 0.01588570f, -0.23673563f, -0.19849975f, -0.07683361f, -0.10251978f, 
    0.26653928f, 0.13385127f, 0.08582561f, -0.00980194f, 0.07804801f, -0.08621675f, -0.11660964f, 0.10480877f, 
    0.03457435f, 0.04170793f, -0.00712582f, 0.06672262f, 0.07781787f, 0.01926144f, 0.13621712f, 0.04267807f, 
    0.08384647f, 0.08375717f, -0.07509965f, -0.06101220f, 0.22075048f, 0.17292911f, 0.01290039f, -0.01231207f, 
    -0.02480031f, -0.16428170f, -0.12823211f, 0.06999286f, 0.11648601f, 0.05018631f, 0.10191223f, -0.03829016f, 
    -0.02744160f, 0.06194915f, 0.00741206f, 0.08877916f, -0.62717098f, 0.69579858f, 0.06146691f, -0.18042320f, 
    0.08348352f, 0.24217243f, -0.01081393f, -0.00652996f, -0.00249561f, 0.03845776f, -0.11185799f, -0.04904774f, 
    0.00026147f, -0.13557591f, -0.01731846f, -0.03478777f, 0.02629022f, -0.10538483f, 0.06247359f, 0.04526642f, 
    -0.03033783f, 0.38078254f, 0.04900383f, -0.04073557f, 0.28337786f, 0.02030448f, -0.00495034f, -0.04719649f, 
    0.02953198f, -0.04525624f, -0.22187881f, 0.03851163f, -0.07603905f, -0.05825289f, 0.08140495f, -0.11725640f, 
    -0.11394934f, 0.15524045f, 0.01256196f, -0.05996218f, 0.16260161f, -0.40391654f, 0.07516173f, 0.12939130f, 
    -0.19463976f, 0.11480672f, 0.18923301f, -0.02622358f, -0.00073092f, 0.13440931f, 0.02094696f, -0.11713056f, 
    0.10123999f, -0.20897439f, -0.10063925f, -0.02541171f, -0.17080039f, 0.00048658f, 0.00868083f, -0.12488033f, 
    0.61654508f, 0.09573106f, -0.08913119f, -0.04256840f, -0.22310247f, 0.08287913f, -0.00152784f, 0.02549138f, 
    -0.04152579f, -0.03037743f, -0.23779610f, -0.18308252f, 0.06391166f, 0.03184681f, -0.05740248f, 0.02944862f, 
    -0.01346539f, -0.04929870f, 0.06119851f, 0.06406651f, -0.11408962f, -0.03502723f, -0.21521986f, 0.07133337f, 
    0.31817424f, -0.18916130f, 0.09604488f, -0.04654452f, 0.01430551f, 0.07272172f, 0.01251255f, -0.02662977f, 
    0.02771855f, -0.14312121f, -0.10345639f, -0.03523171f, 0.08388315f, 0.03013613f, 0.11343858f, -0.03866021f, 
    -0.06322061f, -0.21607387f, -0.04406723f, 0.12860961f, 0.29089323f, -0.12952961f, -0.00959688f, 0.04379193f, 
    0.10206656f, 0.04879828f, -0.00507722f, 0.01435442f, -0.03604968f, -0.12432106f, 0.01689983f, -0.10714246f, 
    0.02810879f, -0.02453241f, 0.07735715f, -0.04786269f, -0.12668188f, -0.11420688f, -0.16703549f, -0.01591279f, 
    -0.16774958f, -0.05311237f, 0.00748941f, -0.09632250f, 0.04125765f, -0.14784294f, 0.02242889f, -0.01754706f, 
    0.10927845f, 0.02439484f, -0.27024040f, -0.00211797f, -0.06364790f, 0.08024359f, -0.14757295f, 0.00184205f, 
    0.16945200f, 0.14975958f, 0.04131316f, -0.38057184f, 0.06212132f, 0.02176949f, 0.02052803f, -0.03608613f, 
    0.03192826f, -0.02175798f, 0.10178591f, -0.00461115f, -0.00726417f, -0.05884100f, 0.15169246f, 0.05795540f, 
    -0.03059302f, -0.04063894f, -0.07595433f, -0.10494974f, -0.01771595f, -0.06111964f, -0.22103605f, -0.08927541f, 
    0.10487186f, 0.09377979f, -0.04483021f, -0.05943559f, 0.08428128f, -0.00201429f, -0.09502891f, 0.04569373f, 
    -0.04642617f, -0.00333920f, -0.07857204f, -0.01695007f, -0.02977309f, 0.06791186f, -0.12834609f, -0.08656421f, 
    -0.11821334f, -0.09013642f, -0.14591105f, -0.11180201f, 0.08978643f, 0.13543294f, 0.05682144f, 0.01905578f, 
    -0.02455145f, 0.01746255f, -0.12327214f, 0.01025240f, 0.00670569f, -0.01507809f, -0.05747068f, -0.04661660f, 
    -0.00293122f, -0.10195457f, 0.09522334f, -0.08201335f, -0.21870953f, 0.01404411f, 0.16592827f, -0.17427707f, 
    0.03744663f, 0.12812462f, -0.01218553f, 0.02865753f, 0.02965367f, -0.09933011f, -0.11419100f, -0.01327947f, 
    0.01673416f, -0.01371056f, 0.00953456f, -0.09050614f, 0.02196448f, 0.12192649f, -0.05170619f, -0.02449661f, 
    -0.20863280f, -0.09410267f, -0.11132513f, -0.05555693f, 0.32257685f, 0.05109650f, -0.06248586f, -0.00087313f, 
    0.04707064f, -0.07911099f, -0.08885055f, 0.05506646f, -0.01246610f, 0.06230622f, -0.01093366f, -0.03482940f, 
    -0.07107467f, 0.24259293f, 0.05568456f, 0.03035005f, 0.25232947f, -0.18542416f, -0.21531023f, 0.06296051f, 
    0.20028506f, 0.11265063f, -0.04338917f, 0.06355581f, -0.15101022f, -0.08496853f, -0.11042795f, -0.07243028f, 
    0.04087427f, 0.01170281f, -0.04618882f, 0.07314618f, 0.05744997f, 0.01735657f, 0.02176011f, -0.02527134f, 
    0.02647972f, -0.03999263f, 0.25929192f, -0.15773095f, 0.22312912f, -0.16646135f, 0.05108471f, -0.05942013f, 
    0.05793759f, -0.03703365f, 0.02196380f, -0.05884322f, 0.01985273f, -0.03931447f, 0.09288622f, -0.07916401f, 
    -0.11001922f, -0.14728925f, 0.00232988f, 0.01805598f, -0.25876388f, -0.19427185f, -0.23936738f, 0.05023252f, 
    0.26301724f, 0.16050623f, 0.05809764f, 0.05202313f, -0.01964013f, 0.01353519f, 0.05930295f, 0.08314379f, 
    0.05556382f, 0.05437547f, -0.01712461f, 0.06201369f, 0.04596068f, 0.08878151f, 0.08526602f, 0.01280078f, 
    0.16367552f, 0.41479632f, -0.37353420f, 0.09270647f, -0.16299382f, 0.10170104f, -0.07511719f, 0.05275130f, 
    -0.01881005f, 0.03580542f, -0.07132345f, -0.05160768f, 0.05788597f, -0.07435451f, -0.04724450f, -0.04794507f, 
    -0.09168758f, -0.20082097f, 0.05229405f, 0.03309804f, -0.08232193f, 0.12315942f, 0.00820987f, 0.23027591f, 
    0.24578135f, -0.00711159f, -0.01029333f, 0.10107148f, 0.07600228f, 0.09507865f, 0.03971642f, 0.07281574f, 
    0.03314796f, -0.13212292f, -0.03060222f, -0.11144317f, 0.07916084f, -0.06431238f, 0.15469082f, -0.15272272f, 
    0.15599518f, 0.24895339f, -0.15598579f, -0.39861012f, 0.09454539f, -0.05742238f, -0.04966364f, -0.12913832f, 
    -0.06414325f, -0.15255883f, -0.05144025f, 0.05574306f, -0.07218111f, 0.01938999f, 0.05400580f, 0.09163529f, 
    -0.00171750f, -0.02740788f, -0.07934505f, 0.06903477f, -0.22211468f, 0.07700968f, -0.17525147f, 0.08187988f, 
    -0.28808123f, 0.00435084f, -0.03353475f, 0.06915259f, 0.07764485f, 0.04464418f, 0.05027278f, -0.11333102f, 
    0.06110267f, -0.16378039f, -0.00487169f, -0.06980238f, -0.01245593f, -0.03964849f, 0.05133542f, -0.05514697f, 
    0.26969981f, -0.12574922f, -0.06846943f, -0.19920550f, -0.05609164f, 0.03205706f, 0.09909341f, 0.03018935f, 
    0.08265138f, -0.02156635f, 0.15168257f, -0.03458674f, 0.11579341f, -0.17999731f, -0.07317040f, -0.16611481f, 
    0.01797048f, -0.04366083f, 0.13096061f, 0.09105289f, 0.04658001f, -0.10499862f, -0.22851519f, 0.05637084f, 
    0.19698198f, 0.12642242f, -0.01427226f, 0.04638931f, 0.09972119f, 0.13590872f, -0.02891640f, -0.02816619f, 
    -0.04068850f, -0.02961311f, -0.04597438f, -0.04758889f, -0.06874089f, 0.08534769f, -0.12289773f, 0.02112397f, 
    -0.18491597f, -0.06969370f, 0.18494421f, -0.21174587f, -0.07134771f, -0.00699928f, 0.04400097f, -0.04529194f, 
    0.00985602f, 0.05692399f, -0.00161467f, 0.00450274f, 0.09444635f, 0.02268390f, -0.06975295f, -0.13238096f, 
    -0.08022187f, 0.02834992f, -0.03336122f, -0.06488650f, 0.18095562f, 0.10867295f, 0.08529637f, 0.05333975f, 
    -0.00027455f, -0.02299600f, 0.01337083f, 0.04434270f, 0.01592871f, 0.13602750f, 0.08781491f, -0.06050505f, 
    -0.02747197f, -0.06103289f, -0.00225621f, 0.07003162f, 0.01554889f, -0.06763277f, -0.00554400f, 0.00296531f, 
    0.08780615f, 0.19886437f, 0.21305610f, 0.25353414f, 0.10593665f, -0.10179621f, -0.07215253f, -0.12018625f, 
    -0.02035724f, 0.05147250f, 0.06887270f, 0.03280151f, -0.02174846f, 0.05698249f, 0.02175333f, 0.00086716f, 
    0.03165095f, -0.06277605f, 0.01227255f, -0.09496586f, -0.06923084f, -0.01307038f, -0.12993596f, -0.04074932f, 
    0.08567946f, 0.03290704f, -0.04778301f, 0.05941664f, -0.09745349f, -0.03212992f, 0.02385236f, 0.02056281f, 
    0.05487463f, -0.04876731f, 0.01541830f, -0.03078021f, -0.05870726f, 0.10665165f, -0.10633658f, -0.00146516f, 
    0.01315626f, 0.02246445f, -0.06809174f, -0.01570357f, -0.11282060f, -0.00744862f, -0.01721846f, 0.05246981f, 
    0.03228832f, -0.01134053f, -0.01158989f, -0.05023792f, -0.09102593f, -0.15758060f, 0.06084686f, -0.02947648f, 
    0.01582252f, 0.04342584f, -0.07677835f, 0.07254401f, -0.04687860f, -0.31258795f, 0.04572753f, -0.01242888f, 
    -0.00697309f, -0.09306152f, -0.16809002f, 0.02027313f, -0.08726386f, 0.06337506f, -0.00202874f, -0.04426934f, 
    -0.00608944f, -0.08433974f, -0.06545632f, -0.03732310f, -0.06857739f, -0.00277716f, -0.08992928f, -0.00030618f, 
    -0.02297544f, -0.08402822f, 0.08677606f, -0.13669758f, -0.00732989f, 0.04469208f, 0.03660275f, -0.06392036f, 
    -0.02344195f, -0.01583878f, 0.00918104f, 0.05811386f, 0.07251520f, -0.05405068f, -0.04399360f, -0.00088906f, 
    -0.11618929f, -0.00243436f, -0.07475921f, -0.06811678f, -0.35955384f, -0.05104413f, 0.11214201f, -0.13393854f, 
    -0.07346416f, -0.06476980f, 0.00946766f, -0.12040623f, -0.04683718f, 0.05999331f, -0.12299091f, -0.03649138f, 
    0.11611533f, 0.13495120f, 0.14494358f, -0.17181484f, 0.01813409f, 0.00357809f, -0.03446982f, -0.00124804f, 
    0.11934365f, -0.13379507f, 0.20250037f, 0.05229741f, 0.06980696f, -0.14268064f, -0.03262149f, -0.10010169f, 
    0.01159814f, 0.03035144f, 0.08931645f, -0.02357002f, -0.04843561f, 0.06171181f, -0.00096363f, 0.05767988f, 
    0.02926554f, 0.07101375f, -0.01337882f, -0.05929204f, 0.03743354f, 0.12690383f, 0.20916872f, 0.14787427f, 
    0.11655550f, -0.03222311f, -0.07246202f, 0.00492179f, -0.04606976f, 0.11202892f, -0.01061610f, 0.01971215f, 
    0.05701983f, 0.00518527f, 0.01869626f, 0.00725064f, -0.01721242f, -0.05019983f, -0.07098816f, -0.10768751f, 
    0.14275281f, -0.00885501f, 0.09416948f, 0.04994211f, 0.02984115f, 0.03986602f, -0.02839613f, 0.02995139f, 
    -0.03270626f, -0.06827132f, 0.11800949f, -0.00469996f, -0.00261385f, -0.02151531f, -0.01245095f, -0.00468887f, 
    -0.06674716f, 0.00444519f, -0.09125742f, -0.07993855f, 0.15153287f, 0.11131215f, -0.20651311f, 0.18284929f, 
    0.24763121f, 0.00150882f, 0.09224530f, 0.06129016f, 0.02748876f, 0.08439334f, 0.03273270f, 0.01381998f, 
    0.04863772f, -0.00683331f, 0.01105635f, -0.03305976f, 0.05183060f, 0.02476225f, -0.07495162f, -0.03768379f, 
    0.02357444f, -0.00440943f, -0.02774452f, 0.04469879f, -0.05669668f, 0.08342186f, 0.00684876f, 0.04811735f, 
    0.02140775f, 0.01679324f, 0.05491142f, 0.10947718f, -0.04827002f, 0.07850990f, -0.00548799f, 0.05289866f, 
    -0.09032836f, 0.00563954f, -0.05562611f, -0.05090655f, -0.35798848f, -0.21807651f, 0.03857857f, -0.05655193f, 
    0.10502330f, -0.00565086f, 0.01826205f, -0.01208530f, -0.04167621f, 0.08709665f, 0.05232217f, 0.03099549f, 
    -0.08018328f, -0.13713495f, -0.00653749f, -0.06281034f, -0.01350413f, 0.08909979f, -0.05783801f, 0.08518835f, 
    0.02098579f, 0.02315487f, 0.06178005f, 0.00350159f, 0.00814981f, 0.08803863f, 0.06229473f, 0.19608617f, 
    -0.07507846f, 0.09491372f, -0.04951679f, -0.02136608f, 0.23824884f, -0.12752035f, -0.06512324f, 0.12142725f, 
    0.00672873f, -0.10995407f, -0.04352283f, -0.00761284f, -0.03961688f, 0.13842192f, -0.20909177f, -0.01217665f, 
    -0.11591597f, 0.07689780f, -0.04351031f, 0.00627207f, 0.07243901f, -0.04592862f, 0.09770685f, -0.03271497f, 
    0.04026246f, 0.02424856f, 0.00839127f, -0.03332307f, -0.00027233f, 0.03945874f, -0.17208663f, 0.04222746f, 
    -0.04141826f, -0.00785355f, -0.06652761f, -0.02264942f, 0.02095884f, 0.07384510f, 0.03725979f, 0.01635505f, 
    0.02666740f, 0.08998228f, -0.02034966f, 0.01661393f, -0.01418394f, 0.00916508f, -0.05055242f, 0.02498593f, 
    -0.10599404f, -0.07414263f, -0.03902379f, -0.04422391f, 0.13794725f, -0.11184277f, -0.03846237f, 0.15680744f, 
    0.07486410f, -0.03966019f, -0.04368225f, -0.02429100f, -0.00491265f, -0.02672808f, -0.01670289f, -0.06018135f, 
    -0.00892160f, -0.05651737f, 0.05319666f, 0.02363819f, -0.03753461f, 0.09458327f, -0.02978530f, 0.01115982f, 
    -0.05271661f, -0.60841727f, -0.11959142f, 0.20819643f, -0.36520475f, 0.12304025f, -0.08487564f, 0.05949065f, 
    -0.13404885f, 0.00054780f, -0.00776583f, -0.08045296f, -0.15633339f, 0.05131218f, -0.12537737f, -0.01949958f, 
    -0.00759405f, -0.01738939f, -0.21488313f, 0.09426200f, 0.00140003f, -0.08650386f, 0.04406053f, -0.07796832f, 
    -0.09469881f, -0.18948467f, -0.16161849f, 0.01039063f, 0.11553965f, -0.05063771f, -0.02941446f, -0.04333277f, 
    -0.05712928f, -0.03264555f, 0.07423732f, -0.24843715f, -0.11811350f, -0.01733040f, 0.05905144f, -0.02518610f, 
    0.12014627f, 0.09301037f, 0.01449765f, -0.11118806f, 0.05559307f, 0.10816449f, 0.03239481f, 0.10319970f, 
    0.04815724f, 0.12065133f, 0.03230071f, -0.00895302f, 0.10856488f, 0.01566824f, 0.06315568f, 0.02039390f, 
    -0.02629417f, -0.16275600f, -0.11751095f, -0.10205007f, 0.08294191f, -0.01429052f, 0.18736565f, 0.12447324f, 
    0.04932109f, -0.06792203f, -0.00247677f, -0.04269942f, 0.00278251f, 0.00169379f, 0.01680832f, -0.07494821f, 
    -0.04215354f, -0.02202953f, 0.02477018f, -0.03666888f, 0.00738180f, -0.04791665f, 0.00217267f, -0.16765185f, 
    -0.06423056f, -0.05285308f, -0.12534407f, 0.04680928f, 0.02610288f, 0.10174635f, -0.07162062f, 0.06314025f, 
    -0.06414024f, -0.00633530f, 0.04344081f, 0.01399182f, 0.04693899f, -0.18593520f, 0.05944737f, -0.02428449f, 
    -0.26761952f, -0.05713888f, -0.11945117f, -0.04875651f, 0.06252817f, -0.69653553f, -0.24574688f, 0.20367204f, 
    -0.11500317f, -0.06061824f, -0.07627063f, -0.17910419f, -0.13046409f, -0.09049657f, 0.04920847f, -0.22273405f, 
    0.01844411f, 0.17224146f, 0.00374536f, 0.08831585f, -0.04692283f, -0.04051493f, -0.24142019f, 0.02607888f, 
    0.05172686f, 0.17069222f, 0.06891263f, 0.25426400f, 0.16371700f, 0.04287000f, 0.04768239f, 0.09244299f, 
    -0.03787409f, 0.26226586f, 0.00430062f, 0.00384820f, 0.01920935f, -0.11077325f, -0.06065642f, 0.02499740f, 
    -0.02292338f, -0.07636575f, 0.11085121f, -0.12892303f, -0.12286557f, -0.01155885f, 0.13913786f, 0.05118659f, 
    -0.02286415f, -0.07723144f, -0.03791475f, -0.13201608f, -0.05024828f, 0.02999516f, -0.04061010f, -0.02767265f, 
    0.00074018f, -0.04006305f, 0.05829652f, -0.02572252f, 0.06400585f, -0.00896821f, -0.13700892f, -0.00774260f, 
    0.13322267f, 0.05428065f, -0.18146126f, 0.22204909f, 0.33294362f, -0.01673046f, -0.00992521f, 0.09556751f, 
    0.07708430f, 0.22160950f, 0.01225414f, 0.02313619f, 0.01967547f, 0.01275361f, 0.02152818f, -0.02125432f, 
    -0.04496984f, -0.01477114f, 0.07669815f, 0.04145238f, 0.10512307f, -0.14012398f, 0.13357097f, 0.19321962f, 
    0.10453881f, -0.22021286f, -0.03413934f, -0.03739074f, -0.19655415f, -0.07018015f, -0.02338102f, 0.03373784f, 
    0.05856850f, 0.05707476f, 0.03123226f, -0.05873493f, -0.06857235f, -0.01423186f, -0.04548670f, -0.03492647f, 
    -0.05501237f, -0.10816906f, 0.07533425f, 0.15763336f, 0.11463085f, -0.10124145f, 0.06078144f, -0.10984001f, 
    -0.08395336f, -0.08783370f, 0.00550204f, 0.01951564f, 0.03507647f, 0.04985387f, -0.04059844f, 0.00592027f, 
    0.12139919f, -0.00826143f, 0.10361397f, 0.10097723f, -0.05302423f, -0.05735232f, 0.04243771f, 0.19115311f, 
    0.11727190f, -0.05207223f, 0.07110054f, -0.00803655f, -0.01722629f, 0.09237203f, 0.02012649f, 0.01180911f, 
    0.00853301f, 0.08504728f, 0.00646089f, 0.15171507f, 0.14422111f, 0.03840034f, 0.10907371f, 0.32265425f, 
    -0.05524284f, -0.43596208f, 0.08962603f, -0.13761760f, -0.00541039f, -0.09095141f, -0.02094687f, 0.00540546f, 
    -0.01117045f, -0.27523988f, 0.02104374f, -0.14240454f, -0.15005668f, 0.06308179f, -0.05796037f, 0.05031184f, 
    0.03738615f, -0.08431667f, -0.01430745f, -0.14370824f, 0.13624005f, 0.00740987f, -0.07299734f, 0.10471617f, 
    0.17443290f, 0.08168787f, 0.00589281f, 0.07649641f, 0.04488884f, 0.05108701f, 0.10083238f, 0.06176062f, 
    0.04245681f, -0.03821453f, 0.11819503f, 0.10773133f, -0.01547983f, -0.01620669f, -0.08733830f, 0.02133151f, 
    -0.06693509f, -0.01175740f, 0.06224111f, 0.03951846f, -0.02585488f, -0.01903684f, -0.09890543f, -0.06481418f, 
    -0.03267444f, -0.03437069f, 0.02000443f, -0.11063626f, 0.11524398f, -0.03012620f, 0.01749122f, -0.04038813f, 
    -0.06924281f, -0.05621038f, -0.00548153f, -0.08181950f, -0.10706612f, -0.09428879f, -0.03462795f, -0.31434724f, 
    -0.10957741f, -0.10431437f, -0.06712668f, -0.01095840f, 0.19224274f, -0.11175364f, 0.04826986f, -0.03099944f, 
    0.00726766f, -0.05575214f, 0.04700322f, -0.01930394f, 0.10689652f, 0.00921617f, 0.09400165f, 0.14362033f, 
    0.03095789f, -0.02423789f, 0.00083422f, -0.07211398f, -0.04941067f, 0.07175740f, 0.05341434f, 0.09728143f, 
    0.00906385f, 0.04491993f, 0.03705090f, 0.05356476f, 0.04039044f, -0.05290075f, 0.00619804f, 0.09110795f, 
    0.03527440f, -0.04275050f, -0.04484318f, 0.01533583f, -0.16546972f, -0.16591738f, 0.05126076f, 0.03797771f, 
    -0.24176529f, 0.01919453f, 0.05466692f, -0.00035635f, -0.05486971f, -0.01628028f, 0.01960002f, -0.12946647f, 
    -0.12109295f, 0.12765348f, 0.03359019f, -0.20270009f, 0.01345076f, 0.01434245f, -0.15129352f, -0.02934171f, 
    -0.03113021f, -0.03792213f, -0.05196299f, -0.16948473f, -0.05073541f, -0.00327480f, -0.04145077f, 0.01189905f, 
    0.08067145f, -0.01344669f, 0.03506243f, -0.03396905f, 0.08117087f, -0.03280719f, -0.01508017f, 0.03616722f, 
    0.01524866f, -0.10044620f, -0.09140764f, 0.10809943f, -0.16022114f, 0.10738540f, -0.16145146f, 0.11774184f, 
    -0.16962583f, 0.03002416f, -0.02332116f, -0.08060993f, -0.13814628f, -0.05002840f, -0.09913532f, -0.04315025f, 
    0.00548507f, 0.05536046f, 0.07785157f, -0.00349905f, -0.12346792f, -0.06801866f, -0.06992894f, -0.14630277f, 
    -0.08650259f, -0.22084977f, -0.02628926f, 0.10729848f, 0.07117663f, -0.11234755f, -0.10912493f, 0.01102358f, 
    -0.19234478f, -0.02221921f, -0.12482719f, 0.00479013f, 0.00265014f, -0.05377600f, -0.09570886f, -0.06536945f, 
    -0.06086354f, -0.00508191f, 0.01113609f, 0.07267671f, 0.01078400f, 0.03267513f, -0.08338878f, 0.10457122f, 
    0.16699411f, -0.09457489f, 0.04617310f, 0.00295748f, -0.01654835f, 0.01048946f, 0.03953561f, -0.00614240f, 
    -0.01248230f, -0.03372057f, 0.06263286f, -0.03643580f, 0.01590377f, -0.00777444f, -0.05862720f, -0.00055606f, 
    -0.02802493f, -0.17591330f, 0.12674734f, 0.11552064f, 0.07156590f, -0.07350282f, -0.06009298f, -0.09615156f, 
    -0.10503487f, -0.07583822f, 0.01828447f, -0.00815959f, 0.01760886f, -0.04071617f, -0.09834949f, -0.03936876f, 
    0.05394843f, 0.10286837f, 0.01062525f, 0.03027166f, 0.13695769f, 0.08509144f, -0.01009478f, 0.12960510f, 
    0.01978584f, -0.00598603f, -0.05462782f, -0.02776723f, -0.05190458f, 0.00725847f, 0.06821851f, 0.01726133f, 
    -0.09550755f, 0.03788155f, -0.02576331f, 0.10245522f, 0.04380434f, -0.05170431f, -0.05562364f, -0.00726301f, 
    -0.00407657f, -0.06504523f, 0.20317838f, 0.02048680f, 0.08026228f, -0.21756728f, -0.03637313f, -0.15452377f, 
    -0.00254621f, 0.09545174f, 0.04256086f, 0.03871901f, -0.10727792f, -0.00439673f, 0.00046611f, 0.03054160f, 
    0.02771734f, -0.00287331f, 0.06207289f, -0.00109937f, 0.02230310f, -0.19786288f, 0.09218010f, -0.01954428f, 
    0.02766330f, -0.14480691f, -0.06613474f, 0.02699696f, 0.04162797f, -0.00163279f, 0.04434305f, -0.00968658f, 
    -0.09548775f, -0.03203749f, -0.01036938f, 0.00497515f, 0.00758766f, 0.02312225f, -0.04092568f, -0.07493592f, 
    -0.03028072f, -0.40141499f, 0.07979189f, 0.09654615f, -0.07567023f, 0.01698440f, -0.02622372f, 0.11012007f, 
    -0.26836455f, -0.08951072f, -0.02618169f, -0.03771678f, -0.01628943f, 0.02579895f, -0.18890247f, -0.00144967f, 
    0.10589305f, 0.02021715f, -0.00360366f, 0.07929576f, 0.11472844f, -0.10627688f, 0.04042372f, -0.21469615f, 
    -0.33843991f, 0.06564604f, 0.00262584f, -0.00944478f, 0.05674616f, 0.08078649f, -0.00016140f, -0.09176444f, 
    0.06238546f, 0.02507851f, -0.16661867f, -0.08368523f, 0.02878511f, -0.00165268f, -0.10148388f, 0.11812745f, 
    0.30710486f, -0.41625541f, -0.25095493f, -0.20007819f, -0.13996378f, 0.10766991f, -0.04767477f, 0.01929160f, 
    0.09625959f, 0.03510222f, 0.04004579f, -0.04321269f, -0.01839174f, -0.07562376f, 0.03882591f, -0.00025895f, 
    -0.13738924f, 0.06501985f, -0.11260644f, 0.12694667f, -0.03025758f, 0.05206855f, 0.38104004f, 0.14267373f, 
    0.00324510f, 0.06428957f, 0.11559025f, -0.20574415f, 0.08039055f, 0.09321676f, 0.01859313f, -0.08728069f, 
    -0.05199786f, -0.10256585f, -0.07770531f, -0.11157846f, 0.02743321f, -0.24619485f, -0.03453954f, 0.00853927f, 
    0.04016693f, 0.13811186f, 0.07076026f, 0.00499688f, 0.11653898f, 0.10950241f, 0.20277283f, 0.06045494f, 
    0.14548986f, 0.04907199f, 0.00364566f, -0.04216455f, -0.00716733f, 0.04478019f, 0.00741658f, 0.09473456f, 
    0.10301157f, -0.00436272f, 0.05229719f, 0.35602909f, 0.08556887f, 0.02213151f, 0.00586980f, 0.00362350f, 
    -0.02634004f, 0.04149386f, 0.02664333f, 0.11545195f, 0.01675177f, 0.04002510f, 0.01381755f, -0.06981920f, 
    -0.09711788f, -0.16535436f, 0.05609372f, 0.15911527f, 0.04439224f, -0.09651425f, -0.01138621f, -0.01003717f, 
    -0.02491974f, 0.09882765f, -0.03878926f, 0.10259315f, 0.05764085f, 0.05838543f, 0.10575391f, -0.08482090f, 
    -0.01035240f, 0.07022019f, 0.04710908f, -0.08398760f, 0.05927436f, -0.01223412f, 0.00619526f, 0.02296494f, 
    -0.06552435f, -0.04223320f, -0.05730124f, -0.09521709f, 0.03285699f, 0.08099169f, 0.15358907f, 0.19934142f, 
    0.13648491f, -0.22742423f, 0.06513550f, 0.03258932f, 0.06235104f, 0.00739780f, 0.02021965f, 0.01464720f, 
    -0.01109968f, 0.02174531f, 0.06822318f, -0.02780499f, -0.01107002f, -0.03834213f, 0.07812378f, -0.10068025f, 
    0.02240878f, 0.12831363f, -0.00538372f, 0.05363448f, 0.00730877f, 0.05414845f, -0.02986793f, -0.03922559f, 
    -0.04340124f, 0.03444258f, 0.06899373f, 0.03077248f, -0.01142914f, 0.06533503f, 0.05377891f, 0.07659195f, 
    0.00616962f, 0.01977135f, -0.10699451f, -0.01762399f, 0.18160360f, -0.01411027f, -0.00112134f, 0.11074300f, 
    -0.10586616f, -0.01076117f, -0.08576981f, -0.03230206f, -0.09168395f, 0.00250327f, -0.03463490f, 0.01221037f, 
    -0.30594462f, -0.11995674f, -0.10397541f, 0.01755468f, 0.02566369f, -0.06939116f, -0.04215447f, -0.02132718f, 
    0.20739010f, 0.06434095f, 0.15013018f, 0.20412463f, 0.01581135f, -0.08873986f, -0.10196918f, -0.13885066f, 
    -0.06542420f, -0.01882804f, 0.00747094f, -0.03555866f, -0.00893794f, 0.06802426f, 0.02684495f, 0.03359080f, 
    -0.01927069f, -0.07498431f, -0.03605200f, -0.12950650f, 0.02773216f, 0.03990560f, 0.02829345f, -0.00167442f, 
    0.02513220f, -0.01273167f, -0.02979651f, 0.04777973f, -0.03522241f, -0.00267813f, 0.06931722f, -0.03401941f, 
    0.08342744f, -0.05764490f, 0.06602454f, 0.03376507f, -0.04219726f, -0.00248044f, -0.06667931f, 0.00901259f, 
    0.12781185f, 0.14510669f, -0.10943112f, 0.22981644f, 0.09801027f, 0.08263648f, 0.13493773f, 0.05253501f, 
    -0.02922769f, 0.06671379f, 0.06156282f, -0.04349883f, -0.00967120f, -0.03402322f, 0.01295122f, -0.06740918f, 
    0.04554549f, -0.07620237f, -0.02333946f, -0.10874286f, 0.11725612f, 0.09996080f, 0.05599456f, 0.09449500f, 
    0.00773324f, -0.00783515f, -0.03344305f, -0.06731415f, -0.00264235f, 0.08830366f, 0.16255507f, -0.05541250f, 
    0.02612038f, 0.06264059f, 0.03524201f, 0.13089871f, -0.00004863f, -0.02899605f, -0.04119450f, -0.01632390f, 
    -0.16160648f, 0.00173682f, 0.04967001f, -0.09364848f, 0.00106460f, 0.01749886f, 0.02519931f, 0.04918652f, 
    0.05797359f, 0.04653852f, -0.02976248f, -0.05944066f, 0.01073346f, -0.01877967f, -0.02951976f, -0.00499680f, 
    0.04590012f, 0.08085833f, -0.09182189f, -0.01430047f, -0.03352052f, -0.08226996f, 0.12928131f, -0.09511936f, 
    0.11537512f, -0.03791866f, -0.02297325f, 0.02082906f, -0.11120184f, 0.06527989f, 0.00095715f, 0.00646350f, 
    0.03254394f, -0.10818615f, 0.00788720f, 0.02001081f, -0.09102863f, -0.04170986f, -0.14623557f, -0.25127974f, 
    -0.07989235f, -0.10094095f, -0.00459265f, 0.16248783f, -0.00256979f, -0.11718998f, -0.10242364f, 0.03793085f, 
    -0.21045446f, -0.08321100f, -0.06236439f, -0.15421955f, 0.07521217f, -0.01148609f, -0.05836343f, -0.05603656f, 
    -0.09154014f, -0.01596715f, -0.10199822f, -0.11104377f, 0.00946734f, 0.07984025f, -0.07947866f, -0.04072191f, 
    -0.23032758f, 0.05705885f, 0.03626897f, 0.01912280f, 0.01433546f, 0.05799267f, 0.03361898f, 0.02668496f, 
    -0.01197137f, 0.04247172f, 0.04095336f, -0.06468302f, 0.02404794f, 0.03737793f, -0.08797938f, 0.02670895f, 
    -0.15333198f, 0.10681688f, 0.01788535f, 0.11216900f, -0.28848666f, -0.05775821f, -0.15661740f, -0.10899589f, 
    -0.06563468f, -0.04125715f, 0.01816793f, -0.06826463f, -0.03496391f, 0.03864028f, -0.07230715f, -0.01759342f, 
    0.10231898f, -0.09145284f, -0.21793672f, 0.01024043f, 0.08042891f, 0.19801141f, 0.24114817f, 0.21926986f, 
    0.21455975f, -0.11511482f, 0.02102590f, 0.01574275f, 0.01923298f, 0.18623061f, 0.01787648f, 0.02327413f, 
    -0.00320661f, 0.03994469f, 0.01851780f, 0.01358334f, -0.00597566f, -0.07332192f, -0.02275233f, -0.17417146f, 
    0.30135950f, 0.07371242f, -0.26131177f, -0.20292844f, 0.11556166f, -0.07546207f, 0.12458552f, 0.06188203f, 
    -0.05656515f, 0.07800870f, 0.10692537f, -0.03606624f, -0.10569988f, -0.08110631f, 0.04316642f, -0.08168603f, 
    -0.03026148f, -0.13462038f, -0.01531409f, 0.05289770f, -0.05866088f, 0.01247036f, -0.13372293f, -0.08352564f, 
    -0.10684612f, 0.02430653f, -0.05138051f, -0.11093602f, -0.04231456f, 0.11558019f, 0.12436070f, 0.01929773f, 
    -0.03856676f, 0.12282445f, -0.04168946f, -0.04772376f, -0.02106950f, 0.06824573f, 0.02118547f, 0.11044338f, 
    0.04377075f, 0.02016241f, 0.14238249f, 0.02002376f, -0.12454240f, 0.04749323f, 0.13046934f, 0.14808704f, 
    0.15570025f, -0.09117977f, -0.00749481f, -0.10176097f, 0.02456721f, 0.02911863f, 0.02800027f, 0.00990688f, 
    0.04777386f, 0.00421664f, 0.11515471f, 0.09776004f, 0.51106316f, -0.08928315f, -0.34060398f, 0.02739941f, 
    0.00015641f, 0.05965699f, 0.02130778f, -0.02154817f, -0.10902458f, 0.08473813f, 0.01602769f, -0.01296864f, 
    0.02008740f, -0.10418257f, -0.04455366f, 0.16246335f, 0.01915574f, -0.03877006f, -0.11834669f, -0.02606373f, 
    0.06499939f, -0.03150663f, -0.12149174f, -0.04530520f, 0.08734139f, -0.06763482f, 0.04531960f, -0.15072010f, 
    -0.11965775f, 0.02264991f, 0.14749533f, -0.01962277f, 0.15257008f, -0.00197201f, 0.12610641f, 0.12944360f, 
    -0.08231929f, -0.07818277f, 0.07844730f, 0.04170048f, -0.22841446f, -0.02805165f, -0.18020065f, 0.03648304f, 
    -0.18407780f, 0.10441175f, -0.18074444f, -0.09310452f, 0.10104307f, -0.11715671f, -0.01023659f, 0.02355621f, 
    -0.10048450f, 0.12759943f, 0.13843544f, 0.05229058f, -0.05461853f, 0.09615093f, -0.03639132f, 0.11372432f, 
    0.20713940f, 0.08852711f, -0.13694824f, -0.01169393f, 0.13142888f, -0.13207392f, 0.08687956f, 0.12637371f, 
    0.00417808f, 0.00242967f, 0.06401316f, -0.10871470f, -0.02853945f, -0.09207629f, 0.00488119f, 0.09853062f, 
    -0.02441913f, -0.05455117f, -0.05090591f, 0.12561999f, -0.02423971f, 0.42662439f, -0.32854423f, -0.26510313f, 
    0.01553933f, -0.20146397f, -0.20017554f, -0.02875859f, -0.09656504f, 0.14434873f, 0.02026028f, 0.03453661f, 
    -0.04705546f, -0.00033138f, -0.04757999f, -0.04828959f, -0.15464596f, 0.11742448f, -0.07767988f, 0.11443517f, 
    -0.39644587f, -0.09303901f, -0.44136521f, -0.26968071f, -0.12339260f, -0.03100425f, -0.02806596f, -0.07584412f, 
    -0.01285629f, 0.15205018f, -0.03182745f, 0.11436106f, -0.09128948f, -0.02282602f, -0.12303161f, -0.03297397f, 
    -0.03601460f, 0.00749177f, -0.00514894f, 0.01480014f, 0.18730158f, -0.07623175f, 0.20034724f, 0.01233584f, 
    -0.17096248f, -0.00622381f, 0.09930335f, 0.09168611f, -0.17606488f, -0.09716001f, -0.00995171f, -0.02134512f, 
    -0.00319535f, -0.01980412f, 0.01512610f, -0.06465659f, 0.02252774f, 0.01203862f, 0.07479081f, 0.10179752f, 
    0.07958899f, 0.01680837f, 0.06783634f, 0.03168937f, -0.05466175f, 0.04025405f, -0.09172003f, -0.05330316f, 
    -0.04422622f, -0.02754012f, -0.21197391f, -0.02054426f, -0.08202821f, 0.02155538f, -0.05706387f, -0.01973729f, 
    0.05481801f, 0.03740127f, -0.01860324f, 0.01967815f, 0.19746892f, -0.15228216f, -0.27538279f, 0.00301471f, 
    0.08339431f, 0.03669993f, 0.13698038f, -0.01227437f, -0.01767497f, 0.05277916f, 0.01723008f, -0.03463432f, 
    -0.01628710f, -0.01777680f, 0.03139300f, -0.12316252f, -0.06376250f, 0.08657784f, -0.03731224f, -0.05417291f, 
    0.05619625f, -0.05901181f, 0.03230511f, 0.04782281f, 0.03128935f, -0.04771077f, 0.02522314f, -0.06054731f, 
    -0.04289012f, 0.02461513f, 0.13010468f, -0.14553000f, 0.16557367f, -0.02326449f, 0.07504125f, 0.14439906f, 
    0.01574657f, -0.00606815f, 0.06612064f, 0.05450951f, -0.19489430f, 0.29061502f, -0.14583571f, 0.02440097f, 
    -0.13892327f, -0.10205200f, -0.15968838f, 0.05889001f, -0.02720387f, -0.08921897f, -0.03389741f, -0.06636021f, 
    -0.05387835f, 0.00598197f, 0.09461498f, -0.23210596f, -0.15232322f, 0.07629198f, -0.15116242f, -0.19907522f, 
    0.17002903f, 0.02855667f, -0.10826388f, -0.06597828f, 0.11325540f, -0.00532039f, -0.01479082f, 0.04591661f, 
    -0.02254027f, 0.02479891f, -0.05360017f, -0.09335376f, -0.04342588f, 0.01639663f, -0.08102749f, 0.08307008f, 
    0.04838904f, -0.01717063f, -0.05195155f, -0.06024168f, -0.21384288f, -0.01205552f, -0.26171762f, 0.23354650f, 
    0.06125449f, 0.05531429f, -0.13635407f, -0.07694218f, -0.02145910f, -0.02764563f, -0.05923495f, 0.05996678f, 
    -0.04457619f, 0.05735975f, -0.05121369f, -0.02639961f, -0.06065712f, 0.15294018f, -0.09126931f, -0.02601744f, 
    0.00120173f, -0.08267182f, -0.04215303f, -0.01773582f, 0.03045986f, -0.14868347f, 0.05163773f, -0.07751849f, 
    -0.01914117f, 0.02555071f, 0.09836630f, -0.00266165f, 0.00557509f, -0.03568713f, 0.10383628f, 0.11647357f, 
    0.02251283f, -0.03217955f, -0.00154080f, 0.10396255f, -0.13118060f, 0.27865437f, 0.12050490f, 0.25486133f, 
    -0.01603180f, 0.05554112f, -0.08952314f, 0.07584876f, 0.11449756f, 0.04946348f, -0.05936457f, -0.02258452f, 
    0.04691032f, 0.02366612f, -0.15548278f, 0.04210671f, -0.11887290f, 0.02035058f, -0.07600695f, -0.01740320f, 
    -0.44446343f, 0.36495432f, 0.09621683f, 0.05699069f, -0.19269691f, 0.03963463f, -0.16692257f, -0.05910705f, 
    0.14219564f, -0.05659147f, 0.13707224f, -0.05001367f, -0.08171406f, -0.04220554f, 0.07138894f, 0.02071043f, 
    0.05244226f, 0.01529650f, 0.01953137f, 0.09595440f, 0.26538667f, -0.28140306f, 0.15234649f, 0.01903317f, 
    -0.08854674f, 0.29569557f, -0.07841083f, -0.05194943f, 0.03392828f, 0.19213450f, 0.08011761f, 0.08928300f, 
    -0.01532761f, 0.03400706f, 0.01803856f, 0.12138553f, 0.00490525f, -0.00133355f, 0.05744227f, 0.20586093f, 
    0.05074154f, -0.03119516f, -0.00339176f, -0.00091565f, 0.03415924f, -0.09176686f, 0.04073436f, -0.06436420f, 
    -0.10401062f, 0.00098820f, 0.08783858f, -0.10077588f, 0.08681154f, -0.04466460f, -0.00894549f, 0.08113111f, 
    0.08102164f, -0.04631839f, 0.01310346f, 0.10867976f, 0.21021980f, -0.08495641f, 0.10230285f, 0.02949082f, 
    -0.07226741f, 0.10894804f, 0.05903278f, -0.10582236f, 0.00026076f, 0.09556977f, -0.06548589f, 0.00087575f, 
    -0.04513124f, 0.07453497f, 0.00093621f, 0.00769024f, 0.06223776f, -0.02864156f, 0.08386425f, 0.23474665f, 
    0.08025447f, -0.03864845f, -0.33100918f, 0.20963424f, 0.05325667f, 0.05924520f, -0.07061505f, -0.01420014f, 
    0.04902253f, 0.00579552f, -0.09718763f, -0.02529485f, 0.05216318f, 0.06101667f, -0.04646090f, 0.24599056f, 
    0.02696187f, 0.10620259f, 0.04624134f, -0.07113077f, -0.63919538f, -0.03588951f, 0.10343695f, 0.40475881f, 
    -0.25733534f, -0.03148713f, -0.07324271f, -0.27054855f, 0.00664594f, 0.35170850f, -0.03716537f, 0.12612468f, 
    -0.05139507f, -0.05759715f, 0.10401456f, -0.03903432f, -0.07851450f, 0.04262488f, -0.07056877f, -0.01305462f, 
    0.06678883f, 0.13211243f, 0.18540622f, 0.03893610f, 0.05550294f, -0.07796882f, -0.05493143f, 0.19730529f, 
    -0.00259714f, -0.15559728f, -0.02466976f, 0.04282162f, 0.02580939f, -0.01817744f, -0.02394890f, 0.07252772f, 
    -0.04860607f, 0.10161671f, -0.05091799f, 0.02665763f, 0.04873545f, 0.02968923f, 0.13201575f, 0.01840457f, 
    0.06217709f, 0.16388598f, 0.04946253f, 0.08234450f, 0.01579348f, 0.03967337f, 0.02959308f, 0.01376397f, 
    0.04172740f, 0.01682672f, -0.08677153f, 0.04824964f, -0.06549717f, -0.04693873f, 0.04192582f, -0.08712268f, 
    -0.36664289f, -0.00355460f, -0.11465363f, -0.05909513f, -0.21529703f, 0.03210390f, -0.05109274f, -0.14230178f, 
    0.04678477f, 0.14780352f, -0.02034697f, 0.01976479f, -0.03312147f, -0.04382824f, -0.03119050f, -0.03353102f, 
    -0.00773719f, 0.12097149f, 0.02990503f, -0.01671483f, -0.34764859f, -0.13826804f, 0.08458107f, -0.23380871f, 
    -0.34613210f, -0.00157789f, 0.02224640f, 0.00394270f, -0.12691233f, 0.16750717f, 0.01252507f, 0.03233773f, 
    -0.08249165f, -0.00868749f, 0.03472075f, 0.01614245f, -0.01747294f, -0.04370702f, 0.01940524f, 0.09569962f, 
    -0.26644102f, 0.01932407f, 0.01144458f, -0.14256912f, -0.15185371f, 0.04967511f, -0.05807436f, 0.01330036f, 
    -0.12034816f, -0.02217795f, 0.02180127f, -0.01280089f, -0.02166084f, 0.06145960f, 0.01056448f, -0.04015325f, 
    -0.06627985f, -0.07991176f, -0.12211577f, -0.12260278f, -0.17749795f, 0.09559888f, 0.20985891f, 0.14717735f, 
    -0.15538630f, -0.03425637f, -0.14357240f, 0.11482960f, 0.05876051f, -0.15970877f, 0.02609044f, -0.01078736f, 
    0.03328649f, 0.02802286f, 0.02109734f, 0.03068781f, 0.00068973f, -0.22475149f, -0.32487407f, -0.50937343f, 
    -0.17260142f, -0.25081915f, -0.08250281f, -0.28015366f, -0.00809897f, 0.12246319f, -0.02385482f, -0.04019231f, 
    0.00666716f, -0.11088907f, 0.05367834f, 0.04853021f, 0.10867362f, -0.16910861f, -0.00451061f, -0.04648977f, 
    -0.00221917f, 0.10849164f, 0.00199049f, 0.01324703f, -0.32827735f, -0.24619630f, -0.12477357f, 0.05787212f, 
    0.05941887f, 0.04811813f, 0.02601326f, 0.02764421f, 0.02963353f, -0.01671789f, 0.06167717f, -0.05342956f, 
    -0.02016711f, 0.01967288f, -0.01360737f, -0.08248074f, -0.05165812f, 0.10215184f, 0.06119415f, -0.14510663f, 
    0.31381589f, -0.05458051f, 0.07699050f, 0.16873235f, -0.18841162f, 0.04142148f, -0.01482491f, -0.03661236f, 
    -0.11794033f, 0.06955519f, -0.06056527f, 0.00730304f, 0.01713952f, -0.03594518f, 0.03579517f, -0.03299464f, 
    0.07322709f, 0.01833983f, 0.05317362f, 0.09637022f, 0.48179188f, -0.34399095f, 0.02669740f, 0.09766218f, 
    -0.04269071f, -0.00446514f, -0.02436455f, -0.03657792f, -0.03238793f, 0.08898678f, -0.00812285f, 0.00469278f, 
    0.08757325f, 0.01017919f, 0.03898780f, -0.20246658f, -0.07664771f, -0.04965982f, 0.12650414f, -0.01842570f, 
    -0.06660205f, -0.07137856f, -0.18357994f, -0.09414908f, 0.05449247f, 0.02113978f, 0.02924318f, -0.10107312f, 
    -0.03913911f, -0.02293018f, 0.11365345f, 0.00575025f, 0.07906023f, 0.08286519f, 0.01904035f, -0.01863540f, 
    -0.02522277f, 0.05355980f, 0.04295554f, -0.01858401f, -0.40967220f, -0.08478602f, 0.32859552f, -0.35042429f, 
    0.02404014f, 0.11491500f, 0.03184516f, -0.04579525f, 0.00629483f, -0.01333930f, -0.01583312f, 0.01119804f, 
    0.00945500f, -0.08343488f, 0.13065267f, 0.01903545f, -0.04401717f, -0.17255475f, 0.18737882f, 0.04608805f, 
    0.13479677f, 0.00325641f, -0.18504997f, 0.02921382f, 0.12038025f, -0.00546535f, -0.04891261f, -0.14874423f, 
    -0.11277944f, 0.14731304f, 0.01209588f, 0.02720119f, 0.01851621f, 0.02747024f, 0.01124731f, 0.03349124f, 
    0.07440296f, -0.03026949f, 0.12592509f, 0.01423157f, 0.11944474f, -0.27778628f, 0.25022072f, 0.01203066f, 
    -0.32167763f, -0.05094192f, 0.06202564f, -0.09136515f, 0.06156632f, 0.06871849f, 0.23509203f, -0.01766744f, 
    -0.02551408f, -0.13306627f, 0.09787041f, 0.08755049f, 0.03140527f, -0.04324086f, -0.00189094f, 0.06309351f, 
    -0.12012491f, -0.03787667f, 0.05453612f, 0.10172651f, -0.24817365f, -0.03896001f, 0.01723627f, -0.01830199f, 
    0.03602679f, 0.00281969f, 0.11503802f, -0.10240486f, -0.10945565f, -0.03058686f, 0.11400130f, -0.03212479f, 
    0.04288426f, 0.11031076f, -0.07585783f, -0.08611339f, -0.24865501f, -0.09528507f, -0.19233514f, 0.09428215f, 
    -0.05551540f, 0.10338315f, -0.06302192f, 0.02996196f, -0.04325699f, 0.06320614f, -0.03430065f, -0.01283921f, 
    -0.03964771f, -0.00166960f, -0.01465775f, -0.05179088f, -0.04071461f, 0.14786831f, -0.08170501f, -0.05347896f, 
    -0.17150229f, 0.07170655f, 0.11346795f, -0.13971531f, -0.05928332f, 0.00847443f, -0.00481187f, 0.12399329f, 
    -0.13128485f, -0.08039900f, -0.05573222f, 0.01279682f, 0.00458199f, -0.05396252f, -0.00901341f, 0.02475009f, 
    -0.03333965f, -0.16294035f, -0.04437389f, -0.07476541f, -0.02951984f, 0.02538827f, -0.01144429f, -0.03905582f, 
    -0.10615248f, -0.02565531f, 0.00026217f, -0.00881596f, -0.03892219f, 0.05695982f, 0.15090561f, 0.00675343f, 
    -0.02022327f, -0.06390953f, 0.01171547f, 0.00923430f, 0.04464085f, 0.03294705f, 0.01127035f, 0.02218059f, 
    -0.25281617f, -0.00694927f, -0.39733064f, -0.07301749f, -0.23341334f, 0.00214724f, 0.07205859f, -0.05392287f, 
    0.00869303f, 0.05552219f, 0.11255229f, -0.06968039f, -0.00325671f, 0.02503133f, -0.01909420f, -0.09218781f, 
    0.00109131f, 0.00499761f, -0.04442611f, 0.00881948f, -0.02998210f, -0.10582158f, -0.30242762f, -0.11072771f, 
    -0.01112232f, 0.07784513f, -0.03675623f, -0.07590772f, -0.03181379f, 0.05112211f, -0.05903520f, 0.18519361f, 
    -0.16446462f, 0.12688567f, 0.09842100f, -0.00726283f, -0.06154897f, 0.06258208f, -0.01714390f, 0.10422363f, 
    -0.19843896f, -0.12286557f, 0.29332390f, -0.14436185f, -0.27103287f, -0.13734891f, 0.07823012f, 0.05316603f, 
    0.08847389f, -0.03888210f, -0.01253445f, -0.00237593f, -0.03871475f, 0.01170072f, -0.08428075f, 0.23235291f, 
    -0.13152266f, -0.05404374f, 0.03543186f, -0.04728741f, 0.35914090f, 0.26070362f, -0.39237708f, -0.36072272f, 
    0.02566742f, -0.04870765f, -0.03118418f, -0.03913776f, -0.04786059f, 0.02250731f, 0.05941549f, -0.14657702f, 
    -0.30987021f, 0.01419992f, 0.08022006f, -0.01968831f, -0.03129929f, 0.08861087f, 0.10806600f, -0.00568769f, 
    -0.42247629f, 0.67462248f, -0.05162458f, 0.19978544f, 0.02252986f, -0.04208278f, -0.05179701f, -0.08905012f, 
    0.09905192f, -0.00142820f, -0.00243405f, 0.00152267f, -0.14718920f, 0.02819119f, -0.20297988f, -0.17311238f, 
    -0.04136414f, 0.15366846f, 0.04362857f, -0.21060811f, 0.50379288f, 0.13527156f, 0.00457376f, 0.01396629f, 
    0.11752520f, -0.06554201f, 0.14409766f, -0.00477107f, 0.01558587f, -0.04879490f, 0.00271746f, 0.04918031f, 
    0.00438515f, 0.10908861f, 0.10296705f, 0.02577799f, 0.02941455f, 0.07360284f, -0.00891458f, 0.14737745f, 
    0.21569251f, 0.03472782f, 0.16071561f, 0.14724122f, 0.00632180f, 0.08908146f, -0.02528899f, -0.08344735f, 
    0.02261807f, 0.00827476f, 0.02678396f, 0.07831176f, 0.07106254f, 0.00027528f, 0.00818312f, -0.11591460f, 
    -0.05765576f, -0.23116806f, -0.22063269f, -0.31849664f, -0.06734285f, 0.08595236f, -0.10342558f, -0.21527730f, 
    0.09838586f, 0.03203115f, 0.03171092f, -0.16691862f, -0.10333496f, -0.02765396f, 0.32084608f, 0.09744056f, 
    0.09910804f, 0.15839244f, 0.09760670f, -0.02157096f, -0.00542461f, -0.03085360f, 0.12682256f, 0.02727754f, 
    -0.00125745f, 0.00289901f, -0.01997254f, 0.13151535f, -0.06580639f, -0.02095140f, -0.18970706f, -0.00033080f, 
    -0.00251714f, 0.06821641f, -0.11376499f, -0.01178479f, -0.06416801f, -0.08343884f, -0.00036418f, 0.03992680f, 
    0.03829275f, 0.09736454f, -0.05814433f, 0.03430636f, 0.07045388f, -0.09695251f, 0.18517224f, 0.00110680f, 
    -0.15717092f, 0.21988760f, 0.07566951f, -0.05970342f, 0.05437744f, -0.05118965f, 0.03456350f, -0.00551567f, 
    0.01680235f, 0.04366970f, 0.06380806f, 0.02391345f, 0.04744169f, -0.01053047f, 0.05306446f, 0.12504259f, 
    -0.04928444f, -0.00404075f, 0.02778146f, -0.11322053f, -0.06915153f, -0.02110911f, 0.00551412f, -0.00361892f, 
    0.03294997f, 0.03406185f, 0.16522381f, 0.08510990f, -0.05279448f, -0.03774603f, 0.04535758f, -0.00215579f, 
    0.01747920f, 0.02786155f, 0.04791754f, 0.08759920f, -0.17554453f, -0.10755876f, -0.00816839f, -0.04447334f, 
    0.07849508f, -0.05368673f, 0.12690488f, 0.01553161f, -0.14693759f, -0.10511790f, 0.04876002f, -0.12041783f, 
    0.15168373f, 0.18539296f, 0.09848826f, -0.00467568f, -0.04462619f, 0.03926060f, -0.00204069f, -0.01070752f, 
    -0.23060174f, -0.05091526f, 0.09627326f, -0.04796929f, -0.10367660f, 0.06106830f, 0.08852430f, 0.07894072f, 
    -0.12124602f, 0.04506079f, 0.08873267f, 0.06977814f, -0.02232160f, -0.06909285f, -0.01417565f, 0.04290340f, 
    -0.05451217f, 0.00024124f, 0.02887281f, 0.04964957f, -0.23739076f, 0.32516173f, -0.11854487f, -0.01851915f, 
    0.01333930f, 0.00447288f, -0.08287658f, 0.02177792f, -0.00215618f, 0.10112096f, 0.01315693f, 0.01514384f, 
    -0.04667140f, -0.02481128f, -0.08308853f, 0.00875401f, 0.04338368f, 0.05286421f, -0.02631260f, -0.02385753f, 
    -0.25029522f, 0.29101318f, 0.06769288f, 0.17383613f, -0.08725609f, 0.07050088f, -0.26358077f, 0.22263376f, 
    -0.01849012f, -0.03021606f, -0.07033701f, 0.02636723f, -0.03557552f, -0.03677170f, -0.03487726f, 0.07583792f, 
    -0.06364024f, 0.31294197f, -0.05432729f, 0.01751238f, -0.09484798f, 0.06857390f, -0.00903211f, -0.16314583f, 
    -0.09202758f, -0.03778805f, 0.00326744f, 0.05422662f, -0.07581841f, 0.12696639f, 0.05731121f, 0.02090415f, 
    -0.06217957f, -0.05558835f, -0.00769846f, -0.03235497f, -0.01366591f, 0.04447438f, -0.02659890f, 0.01443880f, 
    -0.14564809f, -0.04074262f, -0.20665629f, -0.11840081f, 0.08707004f, 0.01611090f, -0.02549570f, -0.04226343f, 
    -0.05764224f, -0.10796634f, 0.03227766f, 0.06799694f, -0.08714606f, 0.15061933f, 0.13828780f, -0.04836417f, 
    0.05577337f, 0.23444201f, -0.00503089f, -0.09035111f, 0.27425596f, 0.02623031f, -0.11207642f, -0.05181848f, 
    0.05748633f, -0.02154807f, -0.02030940f, -0.02543388f, 0.03441507f, -0.02288567f, -0.07002152f, 0.01968121f, 
    -0.09586283f, -0.05464725f, -0.03988377f, 0.05478077f, 0.10600244f, 0.05713134f, -0.14649837f, 0.15100966f, 
    -0.00988415f, -0.31847891f, 0.12685713f, 0.25117406f, -0.25957537f, 0.13311200f, 0.11530930f, -0.05674543f, 
    0.13891059f, 0.10919569f, 0.06383692f, 0.04343133f, -0.10757216f, 0.03446416f, 0.11871450f, 0.03955342f, 
    0.02185067f, 0.04228202f, -0.04459744f, 0.12635571f, -0.00681059f, 0.04055658f, -0.25870088f, -0.13809404f, 
    0.21614024f, -0.00140910f, -0.03718823f, -0.01681259f, -0.03603562f, -0.01593792f, 0.07708640f, -0.04839169f, 
    -0.03927212f, 0.03680639f, -0.00327613f, -0.08268125f, 0.01490198f, 0.06086341f, 0.04938175f, -0.00076192f, 
    0.14974584f, 0.09758885f, 0.00118247f, 0.26415443f, -0.09718056f, 0.09186804f, -0.02813933f, 0.05790859f, 
    -0.04266966f, -0.09907979f, -0.01108806f, 0.00654149f, -0.00146602f, 0.08918962f, 0.01720986f, -0.07538165f, 
    -0.06277765f, 0.08181206f, -0.01490171f, -0.08889090f, 0.11072278f, -0.09890942f, 0.22194715f, -0.07710902f, 
    -0.22203410f, 0.16762806f, 0.07764141f, 0.06900319f, -0.06386378f, -0.26924455f, 0.02500227f, 0.00826952f, 
    0.01082589f, 0.01085160f, 0.05290037f, 0.00072264f, 0.03366444f, 0.00947770f, 0.06484900f, 0.11032920f, 
    0.14745551f, 0.02291747f, -0.01426636f, -0.02759421f, -0.06968149f, 0.01373385f, 0.02354165f, 0.10337557f, 
    0.04361708f, -0.22325549f, -0.00612660f, 0.03536021f, -0.02953096f, 0.04525170f, 0.05734832f, -0.04291246f, 
    0.00597772f, 0.00017635f, -0.21370378f, -0.07148018f, -0.26446390f, 0.32143393f, 0.27722484f, 0.00760624f, 
    0.07618153f, -0.03803891f, -0.04269311f, -0.06465506f, -0.01924471f, 0.07904489f, -0.09241062f, -0.10729805f, 
    0.03048490f, 0.11771432f, 0.05825385f, 0.00875837f, 0.01046860f, -0.05527117f, -0.04489915f, -0.01133618f, 
    -0.55589581f, -0.56714511f, -0.28488374f, -0.18702534f, -0.05040785f, -0.27778083f, -0.14385289f, -0.07193407f, 
    -0.14153844f, -0.22888987f, -0.00575884f, -0.01758447f, -0.01984649f, -0.02755304f, 0.02779421f, -0.00381048f, 
    -0.00631071f, 0.02347094f, 0.10836553f, 0.04295564f, 0.28657445f, 0.02222283f, -0.24582788f, -0.24357504f, 
    0.01673916f, -0.01142022f, -0.04380494f, 0.12657784f, 0.12027488f, 0.00317086f, 0.05274891f, -0.01341315f, 
    -0.03010044f, -0.11015040f, -0.03129864f, -0.08072709f, -0.02502904f, -0.00589587f, 0.01273946f, 0.11650842f, 
    0.09713092f, 0.01999078f, 0.11552848f, -0.01798534f, 0.05582118f, 0.03077124f, -0.02625794f, -0.01834751f, 
    0.02721163f, -0.01219796f, 0.09970769f, -0.04685987f, -0.04348069f, 0.06485746f, -0.01862840f, 0.04049099f, 
    0.06375663f, -0.02581750f, -0.05096876f, 0.03380206f, -0.15469664f, -0.03375555f, 0.23448433f, 0.08685080f, 
    0.10112007f, -0.08011238f, 0.00095612f, -0.01526535f, -0.13488333f, 0.16660979f, -0.05911835f, 0.12040634f, 
    0.02329545f, 0.01011171f, -0.07542354f, 0.01963910f, 0.05497234f, -0.03511485f, 0.04067811f, 0.01990728f, 
    0.15270816f, 0.04215603f, -0.07309949f, 0.05265427f, 0.01251198f, 0.06382737f, -0.02440878f, 0.04993485f, 
    0.05353175f, -0.14282465f, -0.01584756f, 0.01073353f, -0.09173443f, 0.05594351f, 0.03447103f, -0.07574683f, 
    0.01205210f, 0.05499416f, -0.17514774f, 0.01470981f, -0.17977454f, 0.06399988f, -0.00495560f, -0.02995938f, 
    0.38688958f, -0.03389417f, 0.00022668f, -0.01316651f, 0.07796932f, -0.13291556f, 0.05579797f, 0.08245494f, 
    0.00083491f, 0.16968459f, -0.03872364f, 0.01181890f, -0.00559593f, 0.02260849f, -0.02564991f, 0.07989865f, 
    -0.62350440f, 0.63077986f, 0.39570585f, -0.03643996f, 0.22777866f, -0.08433978f, -0.08420227f, -0.04352730f, 
    -0.12135419f, 0.22914501f, -0.01469653f, 0.07760775f, 0.03758059f, 0.06166293f, -0.00112629f, 0.00050409f, 
    -0.04166278f, -0.02642076f, -0.00392444f, 0.00161751f, -0.50752819f, -0.48449409f, -0.15319437f, 0.06914450f, 
    -0.13559616f, -0.23130897f, 0.03087741f, -0.07251596f, -0.08388185f, -0.26513779f, -0.03257686f, -0.02628318f, 
    -0.00223732f, -0.06030020f, 0.04304958f, -0.00189445f, 0.01175214f, 0.04727457f, 0.13046221f, -0.14312091f, 
    -0.04524528f, 0.08632818f, 0.16739565f, -0.01588407f, 0.00288064f, -0.06445236f, 0.00434698f, -0.13681066f, 
    -0.12701686f, 0.04345840f, 0.07746369f, -0.06140229f, -0.05372486f, -0.02461474f, 0.03714924f, -0.00978735f, 
    -0.02928945f, 0.00998008f, 0.00110842f, -0.11104764f, 0.24078134f, -0.15105014f, -0.12254933f, -0.18893239f, 
    0.09214475f, -0.05491180f, 0.04016873f, 0.10905391f, 0.01070866f, -0.12367384f, -0.02846504f, -0.00658131f, 
    -0.03340926f, 0.00446323f, 0.03545978f, -0.02307891f, -0.12334655f, 0.01972883f, 0.04682636f, 0.13323723f, 
    -0.06425209f, 0.01244075f, 0.05561766f, 0.09445576f, -0.02453071f, -0.06393241f, -0.00120367f, -0.05444542f, 
    0.03492881f, 0.05840289f, 0.07585506f, -0.07776552f, 0.11920223f, 0.06769324f, 0.04922052f, -0.01040188f, 
    -0.02624518f, -0.04989104f, -0.00782756f, -0.00515098f, 0.00721300f, -0.18634479f, -0.13876642f, -0.10536708f, 
    0.54097652f, -0.14187288f, -0.01354428f, -0.00699755f, 0.07334948f, 0.14903612f, 0.02349885f, 0.07637041f, 
    0.11487874f, 0.10178967f, -0.15159819f, -0.01114830f, 0.06702600f, -0.00373396f, 0.13868359f, 0.00255758f, 
    0.13947746f, 0.00473360f, -0.04417266f, -0.06210084f, -0.07128973f, 0.04372351f, -0.00041570f, -0.03753551f, 
    -0.01681877f, -0.08663253f, -0.00674578f, -0.20415966f, -0.10805804f, -0.07396675f, 0.01422072f, -0.02826022f, 
    -0.09632651f, 0.02055988f, -0.09225401f, -0.00607052f, 0.10013996f, -0.02360419f, -0.17811242f, -0.03269758f, 
    0.05132626f, 0.02370659f, -0.01871674f, 0.07715242f, 0.03207750f, 0.04496280f, 0.00076967f, 0.00498396f, 
    0.04544574f, -0.08719405f, -0.01390765f, 0.02243013f, -0.02079814f, -0.01276887f, 0.05570241f, 0.07195051f, 
    0.05936646f, -0.13964461f, -0.01681163f, 0.01383945f, 0.05186180f, 0.02667300f, 0.06436988f, 0.02853920f, 
    0.04012595f, -0.00892946f, 0.08563350f, -0.05866285f, -0.06127356f, -0.01122865f, -0.00740672f, 0.03295716f, 
    0.00439871f, -0.04471899f, -0.00269648f, -0.05635300f, -0.11284587f, 0.02695794f, -0.00898167f, 0.02021122f, 
    0.29199716f, -0.04839425f, -0.00264517f, 0.01299489f, 0.11648313f, 0.10873777f, 0.03747937f, 0.00954010f, 
    0.01881383f, -0.05919665f, 0.01246964f, 0.04357366f, 0.04854233f, 0.04044813f, 0.10050710f, 0.03390322f, 
    -0.10758836f, -0.10565478f, 0.18676211f, -0.04917142f, 0.02022814f, -0.10850424f, 0.01765776f, 0.05362930f, 
    -0.00289361f, 0.06438990f, 0.06102559f, -0.01594611f, 0.01558595f, 0.09125381f, -0.08250730f, -0.03910892f, 
    0.03242559f, -0.06608564f, 0.08553225f, -0.02557395f, 0.02607834f, 0.30004591f, -0.07062396f, 0.02741269f, 
    0.10120938f, -0.00936967f, 0.10486781f, -0.05630757f, 0.14419132f, 0.20505041f, -0.13100444f, 0.05719395f, 
    -0.00815038f, 0.07091747f, 0.09006568f, 0.02920372f, 0.00602335f, -0.04357563f, 0.06689210f, 0.03148208f, 
    0.03173836f, 0.01898321f, -0.01484382f, 0.00365969f, 0.02717222f, -0.01142622f, -0.06685261f, -0.05603341f, 
    -0.05255058f, -0.08273944f, -0.01523776f, -0.22035998f, -0.12624092f, -0.01277605f, 0.02698066f, 0.00759727f, 
    -0.06172323f, 0.05490845f, -0.13388120f, -0.12811610f, -0.10591494f, 0.21350598f, -0.15443937f, 0.03918756f, 
    -0.04658619f, -0.12868117f, 0.04657394f, -0.07935227f, 0.03340173f, 0.02029300f, 0.04222603f, -0.00397410f, 
    -0.03455851f, -0.01689863f, 0.02893941f, 0.02161014f, 0.00867247f, 0.01123954f, 0.02897020f, -0.00705461f, 
    0.05373555f, 0.04387709f, -0.06668387f, -0.09599283f, 0.12571758f, 0.02035561f, -0.03859076f, 0.11220268f, 
    0.01929422f, 0.05471021f, 0.01536309f, -0.00097940f, -0.01234003f, -0.04416022f, -0.00950793f, -0.01711662f, 
    0.08471491f, -0.07231789f, 0.00892992f, 0.04143881f, -0.34480959f, -0.00257452f, -0.36952868f, -0.08241016f, 
    0.21810645f, -0.07166605f, 0.14422363f, 0.07484846f, 0.01613718f, 0.18772176f, -0.04603546f, 0.10823447f, 
    0.09156107f, -0.07470900f, 0.04572459f, 0.01668104f, -0.09026181f, -0.18187676f, 0.14627506f, -0.09185287f, 
    -0.29369822f, -0.48737246f, -0.56328613f, -0.10806277f, 0.05837566f, 0.04870827f, 0.13216244f, 0.11448953f, 
    0.06688528f, -0.31796932f, 0.03147957f, -0.00293504f, -0.02391074f, -0.02862331f, 0.06799398f, -0.01482755f, 
    0.02621855f, 0.08068549f, 0.15898660f, -0.03053888f, -0.04126274f, -0.23497644f, -0.26807097f, 0.03572573f, 
    0.22189777f, 0.00147681f, 0.04190067f, -0.14591606f, 0.07232740f, -0.05310840f, 0.01811822f, -0.03192797f, 
    -0.02417058f, -0.01467982f, -0.02849210f, -0.00770529f, -0.00001075f, 0.02927602f, 0.13116270f, 0.00554370f, 
    0.28311664f, -0.87766540f, -0.71537042f, -0.26202577f, 0.13607727f, -0.06097934f, 0.20623150f, 0.27983603f, 
    -0.07680224f, -0.17335442f, -0.02214215f, -0.03780556f, -0.00532277f, -0.00751230f, 0.03306025f, -0.02019675f, 
    0.02952146f, -0.03780307f, 0.08778158f, 0.01764675f, -0.43386039f, -0.44891268f, 0.16230634f, -0.25866103f, 
    -0.42331034f, 0.02120984f, -0.12359916f, -0.07011618f, -0.16924132f, -0.04832464f, -0.03194316f, 0.02405263f, 
    -0.00462653f, 0.00060912f, -0.03425277f, 0.01035847f, -0.04209022f, -0.03123423f, -0.02428409f, 0.04632407f, 
    -0.20509399f, -0.42098525f, -0.65026307f, -0.25212494f, 0.16705817f, -0.04983117f, -0.16545096f, -0.14281644f, 
    -0.13584177f, -0.04359453f, -0.03922087f, 0.04290204f, -0.01402534f, 0.01114887f, -0.12124006f, -0.06590844f, 
    -0.02276370f, 0.02898926f, 0.01643083f, -0.06146511f, -0.13789885f, -0.29710731f, -0.66433173f, -0.24329104f, 
    0.19961229f, -0.23254858f, -0.01605073f, -0.13338257f, -0.03863066f, -0.19183713f, -0.04301268f, -0.03285879f, 
    -0.02815643f, 0.04762104f, 0.02934461f, -0.03295150f, -0.01656458f, 0.12585938f, 0.14871667f, 0.04865624f, 
    -0.34073359f, 0.60226190f, 0.06267837f, 0.02721345f, 0.19043128f, -0.04900859f, 0.05488333f, 0.00852433f, 
    0.07302532f, 0.03389622f, 0.11503407f, -0.03337181f, 0.08389410f, -0.06782208f, -0.02546450f, 0.04474002f, 
    -0.00575648f, 0.00891315f, -0.00935931f, -0.01852308f, 0.05662744f, -0.17869574f, -0.04273131f, 0.02434991f, 
    -0.02919034f, 0.01680095f, 0.06524724f, 0.09350091f, -0.09873664f, -0.03132194f, -0.03904280f, -0.05843043f, 
    -0.04726632f, 0.00557548f, 0.00356978f, -0.00770961f, 0.00073907f, 0.00492363f, 0.00116323f, 0.03712570f, 
    -0.10124448f, 0.06914776f, -0.08857621f, -0.04233542f, 0.05037656f, -0.10721580f, 0.01821941f, -0.01441937f, 
    0.03127842f, 0.03432824f, -0.01573807f, 0.03204099f, 0.02527438f, -0.02731484f, 0.05150491f, 0.03336234f, 
    -0.01965589f, -0.05370330f, 0.16383341f, -0.18492611f, -0.10646353f, 0.22528638f, -0.26012883f, -0.06230263f, 
    -0.10370255f, -0.00107160f, 0.02957530f, 0.05135018f, 0.01992262f, 0.07236937f, 0.08201893f, 0.01865439f, 
    0.07834149f, 0.03765925f, -0.00897833f, -0.05451790f, 0.14787029f, -0.02304360f, 0.15136911f, 0.09565884f, 
    0.09125298f, -0.00011737f, 0.00040987f, -0.07369960f, -0.05944936f, 0.02411472f, 0.02183286f, 0.03474437f, 
    -0.06039072f, 0.00467722f, -0.02279999f, -0.06286701f, -0.02635400f, -0.12808859f, -0.05868668f, -0.00793809f, 
    -0.10484277f, -0.04162551f, -0.03958596f, -0.00679881f, -0.23695236f, 0.46556824f, 0.32238472f, 0.02353176f, 
    0.24612550f, -0.01658634f, -0.04319659f, 0.05455324f, 0.14883870f, -0.03224679f, 0.05292710f, 0.06793936f, 
    0.12089690f, 0.10484291f, 0.15818843f, 0.01475609f, 0.02466374f, 0.06370901f, -0.01977112f, 0.06401999f, 
    0.15195349f, 0.11737645f, -0.03886137f, 0.05005553f, -0.02047991f, 0.05156442f, -0.03143539f, 0.01624381f, 
    0.07947082f, 0.03057074f, 0.04801629f, 0.01277982f, 0.03913367f, -0.21459338f, -0.08073631f, -0.02213092f, 
    0.04250644f, -0.14526878f, -0.00182993f, -0.00296496f, -0.44331411f, -0.29719096f, -0.06506453f, 0.14616649f, 
    0.11654831f, -0.04409451f, 0.10949825f, -0.04164452f, -0.01437729f, 0.07061152f, 0.15384863f, -0.01020961f, 
    0.01516088f, -0.00807998f, 0.00845356f, 0.00243604f, 0.00664278f, -0.00698304f, 0.10314547f, 0.00073895f, 
    -0.18856740f, 0.01087893f, 0.16248335f, 0.15102366f, -0.00521353f, -0.17744985f, -0.10350306f, -0.04410426f, 
    -0.09890716f, 0.09117195f, -0.09833813f, 0.01821915f, 0.12471703f, -0.00762789f, -0.00184773f, -0.00099615f, 
    0.04915173f, -0.08740424f, 0.06797238f, -0.03896609f, 0.18284608f, -0.21696201f, -0.29482058f, -0.21788640f, 
    0.10044421f, 0.02996202f, 0.05931104f, 0.15533847f, -0.02799759f, 0.07040691f, -0.02885962f, 0.00418458f, 
    -0.05795006f, -0.03417443f, 0.05676094f, -0.04175507f, 0.02717841f, -0.04389806f, 0.06080244f, 0.10525472f, 
    0.04288078f, -0.27386838f, -0.08153462f, 0.18676113f, 0.01851617f, 0.03536792f, -0.04141054f, -0.04486731f, 
    0.00141781f, 0.04268843f, -0.01703456f, 0.01884997f, -0.00386594f, -0.04245416f, -0.12351537f, 0.03010506f, 
    0.02734548f, 0.10559862f, 0.03539955f, -0.03542248f, -0.22346950f, 0.08496896f, 0.27026725f, -0.04522234f, 
    -0.06646634f, -0.06782310f, -0.04514108f, -0.09269716f, -0.05167186f, 0.09984785f, -0.07899012f, -0.03643119f, 
    0.01654497f, 0.01829972f, 0.02051124f, -0.00116688f, 0.01267489f, -0.06051413f, -0.07588073f, -0.04723797f, 
    -0.44668362f, 0.13328700f, 0.05565674f, -0.14953622f, 0.20536797f, -0.29498565f, -0.11135866f, -0.05161966f, 
    -0.03573540f, 0.23608465f, 0.01968831f, 0.00129248f, 0.09195684f, -0.02980095f, 0.01392797f, 0.01793675f, 
    -0.00180877f, -0.04650816f, 0.06405269f, 0.01405665f, -0.19569893f, 0.26623556f, 0.20784548f, -0.01430892f, 
    0.13430437f, -0.05534059f, -0.02915018f, -0.04402826f, -0.07929550f, 0.19354279f, -0.03250892f, 0.05205573f, 
    0.07518373f, 0.04985877f, -0.03342835f, 0.02310273f, -0.04305362f, -0.02594892f, 0.01189777f, -0.00162597f, 
    0.07148817f, -0.32180867f, -0.37754065f, 0.12272631f, -0.36740145f, -0.01032912f, -0.03238896f, -0.15903923f, 
    -0.10745606f, -0.01106855f, -0.04983572f, -0.01886072f, 0.05339843f, 0.03746352f, -0.08713055f, 0.01011764f, 
    0.01649994f, 0.18619460f, 0.02806352f, 0.11107593f, -0.11336294f, -0.01986524f, 0.16870648f, -0.10388078f, 
    0.08686624f, -0.00240110f, -0.06692673f, -0.04026405f, 0.06962508f, -0.08634303f, 0.01568991f, 0.00327594f, 
    0.02906478f, 0.18321525f, 0.07567982f, 0.01093332f, 0.03451858f, 0.10086273f, -0.11343729f, 0.00694304f, 
    -0.12612584f, 0.02186494f, 0.17182921f, -0.03928536f, 0.15196630f, -0.01219510f, 0.00584622f, 0.00451017f, 
    0.04782384f, 0.09859657f, 0.01766058f, 0.02769869f, 0.06918152f, -0.01752311f, 0.05429158f, -0.01300091f, 
    0.08553834f, -0.00755692f, 0.04863005f, -0.00380197f, 0.20746759f, -0.61534804f, -0.75739878f, -0.08926823f, 
    -0.12310685f, -0.04515187f, 0.03440215f, 0.03781793f, 0.02860321f, -0.46802294f, 0.08432394f, 0.01465824f, 
    -0.03547728f, -0.06085955f, 0.04868365f, 0.01095861f, 0.03480322f, -0.01940081f, 0.01154527f, 0.10497009f, 
    -0.55246574f, -0.38406047f, -0.43124080f, -0.25739127f, -0.14424631f, -0.17921376f, 0.08699475f, 0.00951609f, 
    -0.00794412f, -0.19139042f, 0.03409892f, -0.03690085f, -0.00024311f, 0.00458630f, 0.03917689f, -0.02941570f, 
    0.01350423f, 0.07030755f, 0.15701413f, 0.09633310f, 0.02436951f, -0.04676991f, 0.01748724f, 0.03894654f, 
    -0.15333375f, 0.08821508f, -0.02719154f, 0.01387592f, -0.11626962f, 0.03551298f, -0.00286718f, -0.13713297f, 
    0.13211608f, -0.13847931f, -0.11735789f, 0.05581469f, 0.02202419f, -0.04544554f, -0.12034327f, -0.04658080f, 
    0.01316201f, -0.09341085f, -0.11583521f, -0.11463709f, 0.13755792f, -0.13421057f, 0.04978044f, 0.01678155f, 
    0.08396632f, 0.00923069f, -0.09644380f, 0.00101416f, -0.02575027f, -0.02695993f, 0.06115837f, -0.00020108f, 
    0.00166068f, -0.03985744f, 0.10277218f, -0.02639387f, -0.26952702f, -0.46640655f, -0.38076270f, -0.25311685f, 
    -0.16477470f, -0.04565271f, -0.03900187f, -0.06350464f, -0.24139781f, -0.16477112f, -0.01494918f, -0.01803268f, 
    -0.04954610f, 0.01288693f, 0.01399718f, 0.00989982f, 0.00700714f, -0.00286328f, 0.12300185f, 0.03142191f, 
    -0.16394795f, 0.01983921f, 0.21361488f, -0.01965882f, -0.00433736f, -0.02962639f, -0.08515795f, -0.01491484f, 
    -0.04431496f, -0.03806576f, 0.08622064f, 0.03145350f, -0.05262754f, 0.01329975f, 0.00420396f, -0.01272847f, 
    0.00280527f, -0.01961751f, -0.10060848f, -0.03612404f, -0.11432018f, 0.09715354f, 0.20183139f, 0.04302412f, 
    -0.02142987f, 0.02950610f, -0.00926036f, -0.03392848f, -0.02612215f, 0.12473077f, -0.04507618f, -0.00165809f, 
    0.05782188f, -0.06587021f, 0.05396217f, 0.02839883f, 0.04407924f, -0.03712234f, -0.04098663f, 0.01349081f, 
    -0.58982891f, 0.21129216f, 0.34987593f, 0.01411784f, -0.19447152f, -0.12718959f, -0.08652178f, -0.13163190f, 
    0.00165925f, -0.04102721f, 0.00009377f, -0.00357549f, 0.02735639f, 0.03351437f, 0.02843345f, -0.00395828f, 
    0.00360397f, 0.06926438f, -0.07358239f, -0.01914293f, -0.28607515f, 0.07569578f, 0.26206443f, 0.11207902f, 
    -0.00709625f, -0.09646338f, -0.05138649f, -0.02183856f, -0.01745687f, 0.09741247f, 0.02158041f, 0.01877910f, 
    -0.02476607f, -0.00556078f, 0.04463005f, -0.00445124f, -0.00555099f, -0.01129833f, 0.02244832f, -0.02821470f, 
    -0.02278425f, -0.54580921f, -0.58051842f, -0.23964489f, 0.16026396f, -0.02573640f, 0.08913662f, 0.19815718f, 
    0.06606157f, -0.19110972f, -0.01417152f, -0.01738569f, 0.01980735f, -0.04323914f, 0.03600668f, 0.02380982f, 
    0.02865899f, 0.07328804f, 0.10672749f, -0.08283695f, -0.21886040f, 0.14720015f, 0.20716651f, -0.02878684f, 
    -0.03062423f, -0.07217011f, -0.07952010f, -0.06563849f, -0.09066157f, -0.02559525f, -0.00518993f, -0.04036990f, 
    -0.01960677f, 0.08385962f, 0.06231669f, 0.01829402f, -0.02086560f, -0.02780423f, -0.06221842f, -0.03299914f, 
    -0.00911991f, 0.10828859f, 0.07906854f, 0.01084192f, 0.00379062f, 0.01053215f, -0.04750904f, 0.00034663f, 
    0.05464973f, 0.00128337f, 0.03229161f, 0.08022585f, 0.09159095f, 0.00482865f, -0.02119976f, 0.05969568f, 
    -0.00661087f, -0.02171926f, 0.04127038f, -0.03736947f, 0.25629857f, 0.07308681f, -0.35386410f, -0.01142077f, 
    0.04110863f, -0.10221235f, 0.09687817f, 0.12627150f, 0.08712703f, -0.12611122f, 0.05359282f, 0.01756291f, 
    -0.18058954f, -0.02813596f, 0.05276042f, -0.02356883f, -0.00111626f, 0.11065827f, -0.11109647f, 0.01934799f, 
    -0.19104518f, -0.23253329f, -0.55361581f, -0.14467797f, 0.38057896f, -0.05920282f, -0.04366735f, 0.08457293f, 
    -0.10765130f, 0.08631951f, -0.01792190f, 0.02778943f, 0.03425476f, 0.02008262f, 0.04844391f, 0.01403535f, 
    0.00360481f, -0.03371651f, 0.19202694f, -0.04828401f, -0.03052470f, -0.03476659f, 0.02809765f, 0.13974303f, 
    -0.04537655f, -0.01944328f, 0.01816401f, 0.03165890f, -0.03403365f, -0.06780723f, -0.01056327f, -0.02119931f, 
    -0.00441658f, -0.03677432f, -0.00898660f, 0.02149163f, 0.01083819f, 0.00173893f, -0.05667382f, 0.01232857f, 
    0.01957971f, 0.01331740f, -0.07565996f, 0.03820014f, 0.08053491f, -0.05048472f, -0.04656651f, 0.08840191f, 
    -0.06536882f, 0.09758294f, -0.02373783f, 0.03001504f, 0.04623343f, -0.08238678f, 0.03891733f, -0.00840101f, 
    -0.02040075f, 0.01457876f, 0.08507691f, -0.03174670f, -0.55458176f, -0.46848196f, -0.36733174f, -0.41491672f, 
    0.13719690f, -0.16378415f, -0.04161813f, -0.29401213f, -0.17739257f, -0.36984363f, -0.04716870f, -0.05061708f, 
    -0.01934826f, 0.00852504f, -0.00436535f, -0.02491694f, 0.01077046f, 0.03515096f, 0.09391227f, 0.08839289f, 
    -0.07161810f, 0.05070568f, 0.19898404f, -0.06178399f, 0.09660169f, 0.00224456f, -0.00940389f, 0.00036860f, 
    -0.02989836f, 0.00223361f, 0.06435712f, -0.02650769f, 0.05527900f, 0.03005760f, -0.04659197f, 0.02774921f, 
    -0.08682477f, -0.00816075f, -0.08480747f, 0.01317408f, 0.18737137f, -0.02249586f, -0.19142346f, -0.10697147f, 
    0.03001470f, 0.01611617f, 0.01964884f, 0.00611611f, -0.01494148f, -0.04443687f, 0.06085599f, -0.03792319f, 
    0.01328515f, 0.01863752f, -0.03988942f, 0.03406011f, -0.00460063f, -0.01133726f, 0.05338975f, 0.02551842f, 
    0.28775379f, -0.38159791f, -0.30549452f, 0.21131667f, -0.12085000f, -0.01908882f, -0.00038005f, -0.08143812f, 
    0.03662556f, 0.00647359f, -0.01469987f, 0.02217310f, -0.01611266f, -0.00443822f, -0.00758950f, -0.00280218f, 
    0.00799814f, -0.02552828f, -0.04457880f, -0.06425488f, -0.04522082f, 0.11559355f, -0.08509421f, -0.01406115f, 
    -0.01384356f, 0.00931018f, -0.03237285f, -0.01807383f, -0.05993541f, 0.00248119f, 0.08060571f, 0.02535432f, 
    -0.00056559f, 0.04580337f, 0.06168348f, 0.08460731f, -0.12446115f, -0.00720704f, -0.00092378f, 0.03608912f, 
    0.05958635f, 0.09980720f, 0.07616570f, -0.01192005f, -0.00100874f, 0.00251842f, -0.00641262f, 0.04241341f, 
    -0.00741797f, -0.02070239f, -0.00485299f, -0.13279091f, -0.02393686f, -0.11423794f, -0.02509790f, -0.07070721f, 
    -0.05720370f, -0.01777268f, -0.03940158f, 0.03172877f, 0.25272456f, 0.19055235f, -0.31693801f, -0.18639500f, 
    -0.30580571f, 0.00785895f, 0.00394661f, -0.03199576f, -0.03982225f, 0.10464727f, 0.02483073f, 0.01325469f, 
    0.08653235f, -0.14487869f, -0.03482680f, -0.03277456f, 0.01072518f, -0.02764900f, 0.01490565f, -0.01266265f, 
    -0.10504596f, 0.04930564f, 0.14020541f, -0.01271674f, 0.02816156f, -0.03746431f, -0.01892754f, -0.01726737f, 
    0.01278767f, 0.02006183f, 0.03867071f, -0.06473098f, -0.01199655f, 0.01557395f, -0.07710918f, 0.04803419f, 
    -0.10593673f, -0.10367853f, -0.08417317f, 0.05176778f, -0.13679160f, -0.36731327f, 0.25195178f, 0.04091852f, 
    0.07195663f, 0.01699617f, -0.01860949f, 0.16994125f, 0.11738752f, 0.05670691f, 0.06415941f, 0.04331436f, 
    -0.01535582f, 0.06333914f, 0.13590901f, -0.13931705f, -0.00550908f, 0.04208111f, 0.03449734f, 0.10434115f, 
    0.25433770f, -0.19017424f, -0.37043056f, -0.12797825f, -0.20574482f, -0.01951513f, -0.05344608f, 0.04671386f, 
    0.06013977f, -0.05506616f, -0.02452961f, -0.01893284f, 0.01074135f, 0.02744993f, 0.06351797f, -0.01355990f, 
    0.00218420f, 0.02060976f, 0.06362073f, 0.03595104f, -0.01475356f, -0.37115800f, -0.22356777f, 0.29164132f, 
    0.05606093f, -0.02203455f, 0.07147232f, 0.02415310f, 0.03424438f, 0.09137283f, 0.04936242f, -0.00407738f, 
    0.05101380f, 0.00113192f, 0.01575184f, 0.01178930f, 0.06100112f, -0.03610525f, -0.01235893f, -0.08869933f, 
    0.00786322f, -0.07357222f, -0.12855195f, -0.03223895f, -0.02489335f, 0.07887749f, -0.08806191f, 0.04771039f, 
    0.02417674f, 0.01310098f, 0.02601033f, 0.07043736f, 0.11770422f, 0.00652547f, 0.03304514f, 0.04023623f, 
    0.03793778f, 0.00666015f, -0.06123120f, -0.04822148f, -0.12234539f, 0.12046933f, -0.00658970f, -0.02055453f, 
    -0.05791827f, 0.00986796f, 0.01054231f, -0.03643432f, -0.04016563f, -0.01225308f, 0.06253383f, -0.01506488f, 
    0.03536982f, 0.02794486f, 0.00717079f, 0.07467005f, -0.02903940f, -0.07857799f, 0.03668412f, 0.03646253f, 
    0.01240314f, 0.00119231f, 0.03357509f, -0.07482968f, -0.00916397f, 0.00125529f, 0.04983659f, -0.02736155f, 
    -0.00437886f, -0.06228583f, -0.05825295f, -0.06885302f, 0.05229197f, -0.01777135f, -0.01942978f, -0.04097293f, 
    -0.02519273f, -0.00379560f, -0.00089216f, -0.00998643f, 0.27980620f, -0.43919164f, -0.52704000f, -0.20867819f, 
    -0.43487543f, -0.00825811f, -0.07408984f, -0.04159947f, 0.15722753f, 0.01563823f, 0.01626299f, 0.04193975f, 
    -0.04185360f, 0.11792929f, 0.02917437f, -0.12294012f, -0.08223853f, 0.04275204f, 0.04822793f, 0.06082008f, 
    -0.02772531f, 0.00728112f, 0.06651977f, 0.01882575f, 0.02513463f, -0.01634203f, 0.01573675f, 0.00006960f, 
    0.03875907f, 0.01835948f, 0.06997821f, -0.09620837f, 0.08677217f, 0.01964504f, -0.02235427f, 0.02667730f, 
    -0.04553434f, 0.01035153f, 0.03367821f, 0.00919343f, -0.07174706f, 0.10401684f, 0.05398654f, 0.03826597f, 
    -0.12120100f, -0.11534891f, 0.09774414f, -0.04887512f, -0.06002959f, -0.03265859f, 0.01499414f, 0.00608851f, 
    0.02280029f, -0.03008808f, -0.01593456f, -0.12531570f, -0.00685495f, -0.04784494f, -0.03261062f, 0.01729498f, 
    -0.03166914f, 0.01840037f, 0.02598068f, -0.02462660f, -0.05217798f, -0.03029091f, 0.05419981f, 0.04559139f, 
    0.01394696f, -0.01668710f, 0.00604989f, -0.00987793f, 0.03052798f, -0.01769198f, -0.02565767f, -0.01270219f, 
    -0.02182721f, 0.00470763f, 0.02763173f, 0.02084156f, -0.05573801f, -0.05267511f, -0.44635323f, 0.17938320f, 
    -0.19159111f, 0.03931288f, -0.08867180f, 0.02440246f, -0.17395592f, 0.01570161f, -0.00157253f, -0.01731191f, 
    -0.01288931f, -0.10899211f, -0.02075852f, 0.01218320f, -0.01686387f, 0.01667956f, -0.03760353f, 0.03294004f, 
    0.18417923f, 0.19526750f, -0.15604690f, -0.02896267f, -0.30793363f, 0.00303182f, -0.00699354f, 0.02628375f, 
    0.00763184f, 0.01465068f, -0.16171239f, 0.07206283f, 0.00425678f, -0.10401264f, -0.03948741f, -0.09249080f, 
    -0.02522992f, -0.03291118f, -0.05930103f, -0.09537199f, 0.28376055f, -0.16575995f, -0.11490832f, 0.01702451f, 
    0.04548617f, -0.03320968f, 0.08101878f, -0.23480120f, -0.05723293f, -0.15357751f, 0.03658511f, -0.08095197f, 
    0.03701382f, -0.07529199f, -0.10902111f, -0.08156998f, -0.10162193f, 0.03453213f, -0.03097526f, -0.05468538f, 
    -0.06633005f, 0.00335731f, 0.12792353f, 0.00509566f, 0.06379259f, -0.03150749f, 0.06026199f, 0.04084400f, 
    0.03887091f, 0.04580835f, -0.14870179f, -0.10647257f, -0.00748919f, 0.08120154f, 0.03375223f, 0.03343730f, 
    -0.02990371f, -0.06881730f, 0.03443728f, 0.01275426f, -0.37056956f, -0.46722269f, -0.23316014f, 0.05038769f, 
    0.10094685f, 0.00233235f, -0.04523925f, 0.01953950f, -0.02973406f, -0.10650117f, -0.04888496f, 0.03746606f, 
    -0.03546840f, -0.01645402f, 0.01980422f, 0.01626132f, 0.01605506f, 0.02759874f, -0.06827226f, -0.08111133f, 
    -0.02411431f, 0.14236131f, -0.03237054f, 0.03668822f, -0.10943246f, -0.04982011f, -0.04669864f, 0.04240153f, 
    -0.09853906f, -0.00619239f, 0.01585089f, 0.00097611f, 0.02742748f, -0.01693646f, -0.02018812f, 0.00236825f, 
    -0.10153094f, 0.03764889f, -0.05490531f, 0.07267439f, 0.41772702f, 0.31440985f, -0.21549492f, 0.19733775f, 
    -0.31081432f, 0.06038758f, 0.20053354f, 0.14781836f, -0.05570261f, -0.20285192f, -0.14851549f, 0.13640270f, 
    -0.03441454f, -0.01478631f, 0.04404937f, -0.09340110f, 0.02862214f, 0.02103673f, -0.08221633f, -0.14380531f, 
    -0.49316475f, -0.27224895f, 0.04062129f, 0.16383825f, -0.02653306f, -0.03258936f, -0.03358123f, 0.02396584f, 
    -0.06040237f, 0.09660112f, 0.03399263f, -0.00277895f, 0.00488354f, 0.00129135f, -0.01009743f, 0.05128982f, 
    -0.02505422f, -0.11910925f, 0.00244806f, -0.04823004f, -0.38626811f, -0.20852089f, 0.01269556f, -0.20059118f, 
    0.00936131f, -0.02972313f, 0.02295920f, 0.06976812f, -0.02432136f, 0.01041904f, -0.02188860f, -0.02363665f, 
    -0.03787586f, -0.00866155f, -0.05167962f, 0.04462511f, 0.00535319f, 0.03220212f, -0.01471962f, -0.02576561f, 
    -0.43638167f, 0.13802083f, -0.07086265f, 0.09884200f, -0.12166800f, 0.07311454f, 0.03690624f, -0.17569752f, 
    -0.11545915f, 0.06527612f, 0.05676980f, 0.01604312f, 0.05002685f, 0.02405686f, -0.00034318f, 0.13483471f, 
    0.10134821f, -0.22235686f, -0.07010122f, 0.00472752f, 0.44513372f, -0.69076329f, -0.09597588f, -0.50136578f, 
    -0.20778750f, -0.07405785f, 0.14445899f, -0.13970758f, 0.40278462f, 0.01133041f, -0.01289217f, 0.05540298f, 
    -0.01638637f, -0.03750093f, 0.06223357f, -0.06344193f, -0.01729304f, -0.02684833f, 0.06675465f, 0.03782535f, 
    0.11753327f, -0.39227095f, -0.17302285f, -0.34484658f, -0.21361497f, -0.08309280f, -0.01585244f, -0.05309976f, 
    0.25248671f, 0.06033192f, -0.01705191f, 0.01329057f, -0.05266107f, -0.06507790f, -0.00488959f, -0.06266998f, 
    -0.00265671f, -0.01606539f, 0.07189758f, -0.01596119f, -0.13916752f, -0.29691753f, -0.31214529f, 0.07795199f, 
    -0.19139364f, 0.01997854f, -0.03201915f, -0.08812115f, 0.03263366f, 0.12109088f, -0.00803951f, -0.02370444f, 
    -0.11461809f, -0.11471339f, -0.09053779f, -0.03803062f, 0.12269446f, 0.02385215f, 0.09212431f, 0.06247451f, 
    -0.22762556f, -0.24194163f, -0.05076277f, -0.12506978f, -0.01692986f, 0.01700054f, -0.14638630f, 0.15057322f, 
    0.03412808f, 0.02987777f, -0.20086476f, 0.06455734f, 0.00490341f, 0.11763813f, 0.02268800f, 0.03063464f, 
    0.00514136f, -0.00267170f, 0.05661165f, -0.01467704f, -0.05141661f, 0.09251582f, 0.06298311f, -0.04606771f, 
    -0.07396781f, -0.00236026f, -0.00112155f, 0.01180425f, -0.07325020f, -0.02240176f, 0.05430674f, -0.00124177f, 
    0.05914513f, -0.02181277f, -0.00273386f, 0.00827997f, -0.08987453f, -0.06506980f, 0.04786481f, 0.00030664f, 
    0.08838992f, -0.34815609f, -0.26695785f, 0.15608497f, -0.04609781f, 0.01238038f, -0.00215447f, 0.03750413f, 
    -0.02457634f, 0.01071597f, -0.00268468f, 0.02550939f, 0.06212674f, -0.00733384f, 0.00040538f, -0.03263222f, 
    -0.00322750f, -0.01740017f, -0.03325024f, -0.08703931f, 0.06613592f, -0.00502312f, 0.08304463f, 0.05213676f, 
    0.06756050f, -0.00031599f, 0.05095146f, 0.09849299f, -0.12074802f, -0.00878274f, -0.01987904f, 0.01119962f, 
    0.00569222f, 0.02482965f, 0.03102628f, 0.05082683f, 0.03590099f, 0.02340842f, -0.00984584f, 0.09143963f, 
    0.01271232f, 0.06290919f, 0.07770319f, -0.00760687f, -0.02582002f, -0.00874827f, 0.00024714f, -0.00742349f, 
    -0.02470047f, -0.02389319f, 0.03351888f, -0.03594968f, 0.01877205f, -0.02113759f, -0.03662322f, -0.00494068f, 
    -0.02956796f, 0.00754500f, 0.00252599f, 0.00072829f, -0.28426206f, -0.31370014f, 0.20506747f, -0.06716895f, 
    0.26773646f, 0.05840498f, 0.01825967f, 0.16408111f, -0.04852861f, 0.04640894f, -0.02201490f, -0.00973201f, 
    -0.02757855f, 0.01824661f, -0.02163424f, -0.10036048f, 0.01409778f, 0.06593496f, 0.03417709f, -0.00203482f, 
    0.03234153f, 0.08641748f, 0.01429040f, -0.03829306f, -0.04687991f, -0.03346846f, 0.04687431f, -0.01347406f, 
    -0.05264380f, -0.05360306f, 0.00778514f, 0.02413315f, -0.00807003f, -0.07852954f, 0.04168633f, 0.01595941f, 
    -0.08027990f, 0.01238505f, -0.01746157f, 0.02386477f, 0.36111107f, -0.34927353f, -0.03021306f, 0.33715650f, 
    -0.11130031f, 0.10581463f, 0.19580565f, 0.05569874f, -0.03955403f, -0.17531270f, -0.11427715f, 0.02458708f, 
    0.10330243f, 0.00338427f, 0.02020887f, 0.01997141f, 0.03588918f, 0.03876933f, -0.06223689f, -0.10717725f, 
    0.36401078f, 0.07238480f, -0.11429469f, -0.12232459f, -0.05114233f, 0.03705217f, -0.02846238f, -0.10551018f, 
    -0.00990038f, -0.01865355f, 0.07432569f, 0.05263548f, 0.05690607f, -0.06561237f, 0.08686158f, -0.01465088f, 
    -0.08035630f, 0.00455467f, 0.02041901f, -0.09556129f, -0.04733368f, 0.01840914f, -0.00976338f, 0.02208808f, 
    -0.08102632f, 0.02385325f, 0.03172917f, -0.14054029f, -0.04958408f, -0.02234841f, 0.04818185f, 0.01910296f, 
    0.01030011f, -0.00855481f, -0.00338567f, -0.08981103f, -0.02910847f, -0.09177998f, -0.00586059f, 0.01462791f, 
    0.04176172f, -0.36446363f, 0.01577390f, -0.33971897f, -0.10111415f, -0.08298147f, 0.01072188f, -0.10545332f, 
    0.15894169f, 0.05191039f, -0.01610987f, -0.04104429f, -0.01820667f, -0.10138482f, 0.05503257f, -0.05638913f, 
    0.02733719f, -0.00549707f, 0.03807786f, 0.02960160f, 0.20539311f, -0.07377944f, -0.03340595f, -0.08826710f, 
    -0.04844379f, 0.04655668f, 0.03651809f, 0.02854413f, -0.03108210f, 0.01028135f, 0.02112064f, -0.02496695f, 
    0.02911091f, 0.02733676f, 0.02249610f, 0.00098778f, -0.01805941f, -0.01283005f, 0.05486896f, -0.04333243f, 
    0.50620151f, -0.34572378f, -0.48002335f, -0.23901936f, -0.32324100f, 0.04513365f, -0.14983790f, -0.09247465f, 
    0.19237339f, -0.04968405f, -0.00240699f, 0.04406019f, -0.00084501f, -0.01718854f, -0.03369589f, -0.01915039f, 
    -0.01263526f, 0.01797801f, 0.05403747f, -0.00962874f, 0.12962741f, 0.13836075f, -0.21240723f, -0.11079603f, 
    -0.18362780f, 0.01143185f, -0.02965904f, -0.03799733f, -0.03212478f, -0.05136670f, 0.00723832f, -0.00868759f, 
    0.03023345f, -0.05980999f, -0.00410698f, 0.01507098f, -0.00918396f, -0.00117895f, -0.00517055f, 0.00955542f, 
    0.38778090f, -0.58462870f, 0.59559590f, -0.23685491f, -0.06447831f, -0.18749176f, 0.10765135f, -0.21378994f, 
    0.26809657f, 0.14604220f, -0.02793959f, 0.02400771f, -0.01429055f, -0.07665532f, -0.03234643f, 0.07732739f, 
    0.12025832f, -0.02391313f, 0.02090555f, 0.02937835f, 0.01814763f, 0.05874617f, 0.03572686f, 0.05770921f, 
    0.09457020f, -0.01236620f, 0.04265471f, 0.10184892f, -0.00003217f, 0.00020978f, 0.03774945f, -0.07353946f, 
    0.00982451f, -0.07671207f, -0.08805272f, -0.08380544f, -0.02752225f, -0.07345548f, -0.02743676f, 0.02968290f, 
    0.23753782f, 0.20170778f, -0.24011368f, 0.07434167f, -0.44141859f, -0.00156585f, 0.05912321f, 0.03959423f, 
    -0.04885495f, -0.04477887f, -0.09151337f, -0.03628283f, -0.03706809f, -0.05159834f, -0.01178987f, -0.00764380f, 
    -0.08822832f, 0.03529089f, -0.11311281f, 0.01240369f, -0.67796838f, -0.35394466f, 0.31563878f, 0.20171341f, 
    0.18890017f, 0.16777179f, 0.11665268f, 0.03710233f, 0.10640742f, 0.02016905f, 0.04612634f, -0.05648701f, 
    0.00960534f, -0.10473674f, -0.02830980f, -0.01947426f, 0.00799409f, -0.07700388f, -0.09178341f, -0.17087777f, 
    -0.39019766f, 0.03400411f, 0.06431217f, 0.19760543f, 0.26465568f, 0.20561130f, -0.00184733f, 0.08027923f, 
    -0.03121648f, 0.02675495f, 0.01984994f, -0.00644547f, -0.05194269f, -0.01103887f, 0.02671210f, 0.17547841f, 
    0.15440300f, 0.03660347f, 0.05981309f, -0.01741516f, -0.02446058f, 0.05726507f, 0.12023836f, -0.15265837f, 
    0.00511606f, 0.04362999f, 0.02776594f, 0.02286026f, -0.02330987f, 0.02117606f, -0.04863377f, -0.22821462f, 
    -0.10966764f, -0.18486199f, -0.04953638f, 0.01625536f, -0.00987510f, -0.04607842f, -0.00719823f, 0.01168126f, 
    0.01872356f, -0.03436880f, -0.15501326f, 0.09684421f, -0.12959570f, 0.06082953f, -0.01673578f, 0.10781230f, 
    -0.00212406f, 0.01200977f, 0.01247397f, 0.06405951f, 0.04091110f, 0.04108644f, -0.01896542f, 0.01971116f, 
    0.04730663f, 0.01131842f, -0.01932755f, -0.01358788f, 0.30338249f, -0.35406938f, -0.11676682f, 0.13243333f, 
    -0.08753561f, 0.07949810f, 0.13237886f, -0.02993677f, 0.11090694f, 0.05722140f, 0.02684955f, -0.02665971f, 
    0.00064534f, -0.02808968f, -0.03963461f, 0.02059134f, -0.00739784f, 0.01497304f, 0.15266219f, -0.01706260f, 
    0.16105588f, 0.02714032f, -0.04499593f, -0.10438673f, -0.02877870f, 0.00696672f, 0.02542763f, 0.01572525f, 
    -0.03743599f, -0.03824004f, -0.01512843f, -0.06692995f, 0.09745719f, 0.02768479f, 0.03635160f, 0.00987865f, 
    -0.03282089f, -0.00736368f, 0.00708207f, -0.01505961f, 0.14899774f, -0.17180771f, 0.12238504f, -0.32010475f, 
    0.02545168f, -0.02894048f, -0.01219666f, -0.03537462f, 0.01038126f, 0.01321014f, 0.03026195f, -0.03244226f, 
    -0.00395454f, -0.04539730f, 0.03388995f, 0.00675257f, 0.00417172f, -0.08239058f, 0.03508748f, -0.03447719f, 
    0.11697192f, -0.53776407f, 0.38908264f, -0.34985560f, -0.07866824f, -0.18047278f, 0.08660389f, -0.03916538f, 
    0.17784539f, -0.06713648f, 0.02521495f, 0.00650642f, 0.01212296f, -0.00119641f, 0.01345150f, -0.03880011f, 
    0.01060900f, -0.03593443f, 0.03614184f, -0.00560909f, 0.40776744f, 0.04738780f, -0.17639266f, -0.07792524f, 
    -0.15197605f, 0.02586970f, -0.04327612f, -0.04495811f, -0.12072597f, 0.05903765f, 0.01196115f, -0.12880708f, 
    0.06513208f, -0.00298943f, -0.02302735f, -0.00728367f, -0.01243751f, 0.01973333f, 0.00759792f, -0.02450069f, 
    -0.23815003f, -0.17070286f, -0.37941277f, 0.13546990f, -0.19899219f, -0.07272346f, -0.00448558f, -0.01895478f, 
    -0.04481275f, 0.02847748f, 0.04280669f, -0.00466444f, 0.00447451f, 0.02317549f, -0.02012812f, 0.02168054f, 
    0.02199163f, -0.05640743f, -0.09430208f, -0.04406100f, 0.22175802f, -0.04785073f, -0.00829184f, -0.06824601f, 
    -0.00602090f, 0.00241993f, 0.03589438f, 0.00796901f, -0.03598653f, -0.02135223f, 0.01620809f, -0.08086047f, 
    0.04970209f, 0.01456327f, 0.03929001f, -0.02676991f, 0.00758039f, 0.00597670f, 0.00123454f, -0.02449708f, 
    -0.01710871f, 0.07907863f, -0.07018025f, -0.03831149f, -0.07782831f, 0.03504242f, -0.02933356f, 0.04357551f, 
    -0.04678962f, -0.00024284f, -0.15577751f, -0.07875542f, -0.06805009f, -0.14468424f, -0.11629241f, -0.00088374f, 
    -0.02502875f, 0.03318045f, 0.02599465f, 0.05224757f, -0.22370824f, -0.11794537f, 0.11119731f, 0.04337798f, 
    0.01060827f, 0.08249412f, -0.07693539f, -0.01241198f, 0.11862379f, 0.08315391f, 0.05939828f, 0.01444468f, 
    -0.04180508f, -0.05276341f, -0.02842796f, 0.08566768f, -0.00264660f, -0.03837293f, -0.11827018f, 0.07968730f, 
    0.37858585f, -0.15183139f, -0.43685371f, 0.48377541f, -0.07821529f, 0.08137488f, -0.04419686f, 0.08957721f, 
    -0.02451460f, -0.09419851f, 0.02064957f, 0.10047531f, 0.06311347f, -0.05220180f, -0.03919258f, -0.00059534f, 
    -0.03231185f, 0.05308084f, -0.02107680f, -0.02375727f, 0.01291077f, 0.07389200f, 0.00399661f, 0.05440817f, 
    -0.06685878f, -0.00043135f, 0.00666026f, -0.00312543f, -0.01876770f, -0.00010216f, 0.06551073f, 0.01757811f, 
    0.01035616f, -0.01214029f, -0.01572717f, -0.07512843f, -0.06103780f, -0.07920959f, -0.07245366f, 0.01503380f, 
    -0.07183843f, -0.22682773f, 0.18455051f, 0.11950871f, -0.18525565f, -0.12608227f, 0.05792177f, 0.06711543f, 
    0.06170378f, 0.05634577f, -0.08675214f, 0.02229741f, -0.07719617f, -0.05235700f, -0.05664295f, -0.17291263f, 
    0.07357105f, -0.09010930f, -0.02943261f, 0.01729875f, 0.03866791f, -0.27173945f, 0.08564320f, 0.37296885f, 
    0.04800767f, -0.07521389f, 0.09457395f, -0.02908934f, 0.08347002f, 0.14494927f, 0.01101514f, -0.01119395f, 
    -0.04465470f, -0.01377574f, -0.03630804f, -0.01383811f, 0.01193144f, -0.03209667f, 0.15432161f, -0.00693570f, 
    -0.61260277f, -0.21030839f, 0.07773920f, 0.12478960f, 0.00992407f, -0.01634937f, -0.03631200f, -0.01931233f, 
    0.02445787f, -0.05277450f, 0.01292641f, -0.01910497f, 0.03431926f, -0.02676117f, -0.02946861f, 0.00800994f, 
    -0.02652526f, -0.00194651f, -0.03881103f, 0.06976318f, -0.09584925f, -0.20308650f, -0.23594433f, -0.10367723f, 
    -0.02512946f, 0.04824056f, 0.00507524f, 0.08391893f, 0.02533258f, 0.07911110f, 0.04296803f, 0.08435187f, 
    -0.05059819f, -0.06029815f, -0.04834367f, 0.00019783f, 0.00202274f, 0.03785467f, -0.00553009f, 0.03152826f, 
    -0.01788070f, -0.43788680f, -0.42077813f, -0.36599144f, -0.01992944f, -0.02425644f, -0.10866104f, -0.03738957f, 
    0.09299503f, -0.00200343f, -0.04862545f, -0.02731154f, -0.02746762f, 0.00299843f, -0.00193022f, 0.00723787f, 
    0.02476037f, 0.06999673f, 0.06966591f, 0.17019552f, -0.39857355f, 0.01113648f, 0.12399922f, 0.08994773f, 
    0.01600469f, -0.09349301f, -0.04090878f, -0.06919002f, 0.03867053f, -0.05142222f, -0.01352764f, -0.09138101f, 
    0.02950914f, 0.02406733f, -0.04119148f, -0.00636785f, 0.00607028f, -0.00165900f, 0.06794441f, 0.05907863f, 
    -0.19764520f, -0.10515098f, 0.05276638f, 0.03307639f, 0.00081225f, 0.00849838f, -0.03388463f, -0.01681382f, 
    0.02247095f, 0.01546280f, 0.05241280f, 0.09407662f, -0.02733663f, 0.07181906f, 0.07983432f, 0.02059430f, 
    0.12274059f, -0.02814357f, -0.03260872f, 0.09745421f, 0.00443877f, 0.05782252f, -0.22804645f, -0.07233281f, 
    -0.08211491f, -0.05049578f, 0.09117817f, 0.03690121f, 0.10637364f, 0.03229906f, 0.15547925f, 0.03500706f, 
    -0.02354954f, -0.04767758f, 0.02162556f, 0.07339665f, -0.00675306f, -0.02462984f, 0.00083867f, -0.06345605f, 
    -0.28067398f, -0.12151134f, 0.01735276f, 0.07381031f, -0.00844198f, 0.03386226f, 0.04005896f, -0.00896349f, 
    0.03991541f, 0.04296015f, -0.02440590f, 0.04460093f, 0.06565893f, 0.10212129f, 0.04387444f, 0.06473751f, 
    0.07988507f, 0.06027786f, 0.06400844f, 0.08924067f, 0.08999410f, -0.29348072f, -0.09636818f, 0.11222153f, 
    0.31973210f, -0.04526025f, 0.10755370f, -0.02843725f, 0.02400722f, 0.01783154f, 0.00684929f, 0.00588502f, 
    -0.04215859f, 0.06602815f, 0.02223401f, 0.05009629f, -0.00618575f, -0.12496243f, -0.02857624f, -0.02615339f, 
    -0.23926449f, -0.57842338f, -0.36212543f, -0.14384158f, 0.05713414f, -0.12108001f, 0.04960176f, 0.08671040f, 
    0.09520487f, 0.10393068f, 0.04797808f, -0.03675133f, -0.06723266f, -0.02328687f, -0.07541034f, -0.04085984f, 
    0.00225019f, -0.00854497f, -0.00838635f, -0.03182211f, 0.10267367f, -0.17080171f, -0.29728231f, -0.06736941f, 
    -0.05657348f, -0.03151023f, -0.02828398f, 0.03508336f, 0.05735123f, 0.04103516f, -0.07069051f, -0.00141086f, 
    0.01048295f, 0.01293003f, 0.02983720f, 0.00120297f, 0.07938322f, 0.05530292f, 0.06465506f, 0.05549237f, 
    -0.00033115f, -0.09587312f, -0.07936472f, -0.05784172f, 0.05396116f, -0.08185098f, -0.00944347f, 0.05876258f, 
    0.03107329f, 0.04907556f, -0.00024851f, -0.06060129f, 0.01888374f, -0.05385032f, -0.03811534f, -0.03461936f, 
    0.06725906f, 0.06237109f, 0.10038345f, 0.05669730f, -0.62334347f, -0.03744626f, 0.19812249f, 0.15882744f, 
    -0.13023320f, 0.00158596f, -0.09118163f, -0.05153541f, -0.03337162f, -0.08994274f, -0.03357837f, -0.05604048f, 
    0.01348924f, -0.03011449f, -0.06733765f, -0.05870489f, -0.15276149f, -0.03837723f, -0.09860587f, -0.02587664f, 
    0.02788666f, -0.08417743f, -0.11434867f, -0.06384559f, -0.04281611f, -0.02138097f, 0.02238076f, -0.02854247f, 
    -0.01724862f, 0.04304740f, 0.03075252f, 0.06372515f, 0.08798355f, 0.03891274f, 0.01859036f, -0.00353631f, 
    0.13441072f, -0.01096944f, 0.08149689f, 0.10364021f, 0.01721515f, -0.01986231f, -0.33951911f, -0.11942314f, 
    0.04066035f, -0.10338854f, 0.09895899f, -0.07241239f, 0.08691128f, -0.00986462f, 0.00052252f, -0.01711800f, 
    -0.06872776f, -0.06530555f, -0.05100027f, 0.12467041f, -0.04579002f, -0.07629352f, -0.11090571f, -0.17951182f, 
    -0.18976729f, -0.08270793f, 0.02120119f, 0.02974981f, -0.00374740f, -0.06438572f, -0.07395229f, -0.07303625f, 
    -0.02939871f, -0.03373771f, -0.03541444f, 0.02304745f, 0.02077241f, 0.03713838f, -0.00456757f, -0.10038126f, 
    0.07124829f, 0.10670482f, 0.12505816f, 0.06689136f, 0.02925687f, 0.23406339f, 0.08658607f, -0.07006315f, 
    -0.02161304f, -0.01240225f, -0.01571323f, 0.02075313f, 0.03171457f, -0.06366970f, -0.02900854f, -0.02317664f, 
    0.02843154f, -0.00537581f, 0.02131526f, -0.02289703f, 0.05579073f, 0.09104298f, 0.09056219f, 0.04982489f, 
    0.04084245f, -0.04285459f, 0.05090142f, -0.01043246f, -0.08451920f, -0.06868707f, -0.05562040f, -0.07558703f, 
    -0.01804429f, -0.01279205f, -0.05089825f, 0.03306451f, 0.02225727f, -0.00369848f, 0.11593320f, 0.03503345f, 
    0.12121233f, 0.05761339f, 0.06231545f, 0.10597828f, 0.36283427f, 0.15247333f, 0.00161226f, -0.00220342f, 
    0.05573012f, 0.09771594f, 0.12056629f, 0.06872994f, 0.10135239f, -0.01830239f, 0.07874772f, 0.00506422f, 
    -0.01201035f, -0.00274602f, 0.09302780f, 0.13374116f, 0.01409514f, -0.05390611f, 0.01909425f, -0.07254037f, 
    0.05877654f, 0.05265605f, -0.03669616f, -0.10266693f, -0.21260312f, -0.04080048f, -0.06160508f, 0.01950018f, 
    0.03078479f, -0.07769224f, 0.03409895f, 0.15557770f, 0.03301166f, 0.13212223f, 0.14073212f, -0.07621861f, 
    -0.02681873f, -0.01766822f, 0.00254196f, 0.11455439f, 0.38027957f, -0.13442610f, -0.23784521f, 0.01080036f, 
    -0.05635312f, 0.15726128f, 0.08536939f, 0.15903443f, 0.05432460f, 0.09817356f, -0.01133873f, 0.02738935f, 
    -0.04134244f, 0.05137641f, -0.00896381f, 0.00763979f, -0.04904990f, -0.00123502f, 0.05411837f, 0.00042073f, 
    -0.05176096f, -0.10505129f, -0.08426930f, 0.00003758f, -0.07901559f, -0.08721302f, -0.05885834f, -0.08383418f, 
    -0.04674369f, -0.01028714f, -0.01072669f, 0.08954486f, 0.03013515f, -0.03793203f, 0.04124226f, -0.01907006f, 
    0.10826430f, 0.13636640f, 0.08962408f, 0.14049996f, 0.35821801f, -0.13161361f, -0.17489819f, -0.04755098f, 
    0.14843382f, 0.07447255f, 0.02013079f, -0.02410031f, 0.01401013f, 0.08514818f, -0.02566354f, 0.02118739f, 
    -0.00709393f, -0.01912372f, -0.00075693f, -0.00364911f, 0.01806281f, 0.10028720f, 0.03833790f, 0.08780806f, 
    -0.10071941f, 0.08655696f, 0.08611082f, 0.06438293f, -0.11679744f, 0.01980105f, 0.08920461f, -0.03944912f, 
    0.04769721f, -0.00410965f, -0.03161025f, -0.01666377f, -0.02754493f, 0.03126274f, 0.03622798f, 0.01526941f, 
    0.15948831f, 0.02483528f, 0.08723263f, 0.03160618f, 0.69913042f, 0.16160981f, -0.13227987f, -0.10141020f, 
    0.01195187f, 0.11961038f, 0.01662081f, -0.01501080f, -0.01085645f, -0.18287753f, 0.02948488f, -0.00132224f, 
    0.07474061f, 0.03539743f, -0.04006411f, -0.00286702f, -0.04704485f, -0.12710010f, 0.17586224f, -0.01556165f, 
    0.22163127f, 0.10315646f, 0.21575721f, -0.02419931f, -0.25259998f, 0.03111443f, 0.02810777f, -0.05802963f, 
    0.03270066f, -0.19536583f, -0.04569808f, 0.01613864f, 0.04673646f, 0.00038868f, 0.05627337f, 0.01843204f, 
    0.09013125f, 0.07483145f, 0.08052103f, -0.15528210f, 0.09006769f, -0.21076156f, -0.19895606f, 0.04590127f, 
    0.11211827f, 0.06192971f, 0.00459159f, 0.02556837f, -0.01714207f, -0.07207845f, 0.01901953f, -0.05553241f, 
    0.03232323f, 0.01228916f, 0.03535848f, 0.02008183f, 0.05402631f, -0.05408680f, -0.09890833f, -0.07548475f, 
    -0.01907104f, 0.23503961f, 0.17708716f, 0.04572825f, -0.23076649f, 0.15480463f, -0.14625432f, 0.00606321f, 
    -0.08053999f, -0.28978410f, -0.05713916f, -0.02675062f, 0.01786672f, -0.06745535f, -0.04778861f, -0.11322764f, 
    -0.03321865f, -0.02830550f, -0.15944733f, -0.21563408f, -0.18182589f, -0.26925784f, -0.77225208f, -0.43559703f, 
    -0.06063512f, 0.05552547f, -0.05918685f, 0.20864341f, 0.09159993f, 0.01994543f, -0.04098589f, -0.06460741f, 
    -0.05629264f, 0.03406135f, -0.00702101f, 0.05401168f, 0.00019959f, 0.03453656f, -0.00485711f, 0.01198227f, 
    -0.06831314f, -0.18948269f, -0.48149002f, -0.34368348f, -0.01528576f, -0.15737882f, -0.07538100f, 0.06150817f, 
    -0.02988942f, -0.21936172f, -0.02696466f, -0.02434800f, -0.03631861f, -0.01007615f, 0.06019397f, -0.00101186f, 
    -0.02593370f, 0.04348687f, 0.01926963f, -0.10429840f, 0.05667745f, -0.06486963f, -0.31814703f, -0.42734551f, 
    -0.21133925f, -0.16102551f, -0.18612950f, -0.10714770f, -0.07815524f, -0.25590104f, 0.02394056f, 0.00091516f, 
    -0.02606814f, 0.03391052f, 0.04668573f, 0.05985660f, 0.07295474f, 0.11007453f, -0.09520563f, -0.38367012f, 
    -0.03163743f, -0.57633764f, 0.01352990f, -0.03628650f, 0.16391730f, -0.05085140f, 0.08451233f, 0.07280768f, 
    0.01399843f, 0.11171567f, 0.05381004f, 0.02773030f, -0.02262381f, 0.11958187f, -0.00567693f, -0.07467228f, 
    0.06769016f, -0.01497909f, -0.00034653f, -0.01955872f, -0.15927625f, 0.10240006f, 0.10722996f, 0.06351498f, 
    -0.17870775f, -0.05728614f, 0.01577052f, -0.10607989f, -0.02355565f, 0.02414843f, -0.03191473f, -0.01578078f, 
    -0.03874314f, 0.00436019f, 0.00611460f, -0.15176360f, 0.04940697f, 0.01365151f, -0.11345691f, 0.01147653f, 
    0.31326303f, 0.07527359f, -0.15854412f, 0.00970957f, -0.01622549f, 0.07626408f, -0.00908548f, -0.06011523f, 
    0.03969182f, 0.00278607f, 0.02223213f, 0.03058554f, 0.04059045f, 0.00859123f, 0.01894935f, -0.02312180f, 
    0.03458088f, -0.01970710f, 0.08598264f, 0.03538750f, 0.43046439f, 0.18003330f, 0.10173096f, 0.00470770f, 
    0.06685283f, 0.02702578f, -0.02350481f, 0.02033148f, 0.00068574f, 0.03953734f, 0.06725625f, -0.02748578f, 
    0.05637640f, 0.01110793f, -0.03721876f, -0.05841797f, -0.02606079f, 0.00629503f, -0.18463057f, -0.11100952f, 
    -0.27227151f, -0.02729977f, 0.09743890f, 0.00840680f, -0.07230785f, -0.04613151f, -0.03901955f, -0.02793314f, 
    -0.02458078f, 0.02885695f, -0.03092933f, -0.02400161f, -0.02269370f, 0.04105023f, -0.01484652f, -0.00650555f, 
    0.06479686f, 0.05594926f, 0.02152483f, 0.04753888f, -0.29412615f, -0.74919027f, -0.19384556f, 0.08219706f, 
    0.23346433f, 0.13023798f, -0.04914365f, 0.03289614f, -0.04580589f, 0.00343072f, 0.14755520f, 0.01045082f, 
    0.03819916f, 0.12466551f, 0.05141691f, -0.03642323f, -0.03359766f, -0.06664103f, -0.18844266f, 0.01914484f, 
    -0.02696275f, 0.06046968f, 0.03595321f, 0.00756993f, 0.02272509f, -0.03143160f, 0.02139684f, 0.00949302f, 
    0.01221433f, -0.04651701f, -0.00286460f, 0.00635052f, 0.00979713f, 0.03239812f, 0.06314517f, -0.01394211f, 
    0.00659541f, -0.00342163f, 0.04934202f, 0.01765670f, 0.45766512f, -0.14809059f, -0.19031627f, -0.25927567f, 
    -0.09745958f, 0.01234863f, -0.23001474f, -0.06620046f, -0.10227739f, 0.11083451f, -0.08209353f, 0.14325686f, 
    0.09684852f, -0.00592503f, 0.01092356f, -0.01860479f, 0.02330442f, -0.01030737f, 0.11141998f, 0.11166170f, 
    0.00405193f, -0.02653917f, -0.34782100f, -0.18642858f, -0.09269907f, 0.04973780f, 0.02708615f, 0.06923024f, 
    0.11495972f, -0.02227830f, 0.03981367f, -0.06376762f, 0.02260687f, -0.00951097f, 0.00753745f, 0.03086443f, 
    -0.00758128f, -0.05463139f, 0.01749668f, -0.03116941f, -0.04964152f, 0.14178683f, 0.09283895f, 0.08026554f, 
    -0.05477857f, 0.04506266f, -0.07021526f, -0.00021883f, -0.01846828f, -0.08306563f, -0.03071497f, 0.01020187f, 
    0.04510654f, -0.02516436f, -0.01843191f, -0.06419735f, 0.07736855f, 0.13016871f, 0.03841706f, 0.00495729f, 
    0.08092432f, 0.08663812f, -0.24584720f, -0.00754714f, 0.05210666f, 0.04548784f, -0.03367724f, 0.08436742f, 
    -0.02424398f, -0.01635824f, -0.03188888f, -0.00121924f, -0.01406086f, -0.00977726f, 0.03877243f, 0.02574058f, 
    -0.02363353f, 0.08067478f, -0.02819826f, -0.12061923f, -0.15285100f, -0.18166862f, -0.16661701f, -0.13353397f, 
    -0.04446686f, -0.00792571f, 0.01512541f, 0.03481874f, 0.03167408f, 0.09970653f, 0.02391107f, -0.05804710f, 
    -0.01588625f, -0.10025258f, -0.01787887f, -0.00636282f, 0.07310843f, 0.02708096f, 0.01874192f, 0.07441053f, 
    -0.21987721f, -0.57054579f, -0.47154593f, -0.40651548f, 0.04899671f, -0.14071837f, 0.16950081f, 0.20493023f, 
    0.15011169f, -0.00163299f, -0.00897859f, -0.08845697f, -0.06668185f, -0.03575124f, -0.05274663f, 0.05225289f, 
    -0.02769021f, -0.06565684f, -0.01167970f, -0.03757104f, -0.01090907f, -0.21053776f, -0.04295499f, -0.06820263f, 
    -0.02195662f, -0.11458138f, 0.08926345f, 0.03973486f, 0.08028913f, 0.07302309f, 0.08007728f, 0.00592723f, 
    0.00330256f, -0.02873617f, -0.00506948f, 0.04283999f, 0.04246752f, -0.00399278f, 0.02946381f, -0.03478182f, 
    0.14566137f, 0.25095534f, -0.12938502f, -0.40155503f, 0.02523310f, 0.16863042f, -0.26869792f, 0.05981825f, 
    0.02527431f, -0.06865016f, 0.01748082f, 0.04230021f, -0.05980244f, 0.11422429f, 0.07495542f, 0.09647379f, 
    -0.06788914f, -0.02183502f, -0.26400426f, -0.36164898f, -0.28650740f, -0.17619362f, 0.09820444f, 0.08672041f, 
    0.07632999f, -0.07642329f, -0.07869495f, -0.03071902f, -0.03240459f, -0.10061055f, 0.04431600f, 0.04571209f, 
    0.12400125f, 0.03876960f, 0.08978945f, -0.11539000f, 0.03184345f, -0.05421075f, -0.12102751f, 0.03194668f, 
    0.25067043f, 0.04881556f, 0.04827946f, 0.00212862f, -0.09638853f, -0.08287739f, 0.05941054f, -0.07091402f, 
    0.04994875f, -0.10911099f, 0.02410587f, 0.07607126f, 0.03638368f, -0.00265064f, 0.04015922f, -0.02100389f, 
    0.03594302f, -0.11088464f, -0.03813684f, -0.05845782f, -0.30296212f, -0.27092546f, -0.15722030f, -0.11124620f, 
    0.29573655f, 0.15202141f, -0.03145253f, 0.01335048f, -0.16567279f, -0.28217268f, -0.04314117f, 0.04571221f, 
    0.06433006f, -0.03441907f, 0.03176754f, -0.00504709f, -0.03542294f, 0.10353458f, -0.13950075f, 0.04518776f, 
    -0.11618640f, -0.40656814f, 0.02415641f, 0.03855608f, -0.10362627f, 0.07500493f, -0.03385649f, -0.06898082f, 
    -0.07556354f, -0.06730225f, 0.04068660f, -0.04490036f, 0.01150922f, -0.03437459f, 0.01225934f, 0.04183129f, 
    -0.19368415f, -0.17870606f, -0.16610225f, -0.35782245f, -0.22044708f, -0.10397771f, -0.02164801f, 0.01503838f, 
    -0.00000738f, -0.03177579f, -0.03073309f, 0.05338182f, 0.04165771f, 0.03300444f, 0.05091386f, 0.02446225f, 
    -0.00056492f, 0.03006655f, 0.04004189f, -0.08621300f, 0.10406503f, 0.05324512f, 0.05210201f, 0.11816046f, 
    0.25922048f, -0.01789052f, -0.08762030f, -0.01161173f, -0.07346697f, -0.04116762f, -0.04543893f, -0.10618690f, 
    -0.06047384f, -0.10947743f, -0.02888716f, 0.01519204f, 0.09056117f, 0.01148184f, -0.01239742f, 0.02175777f, 
    0.08756337f, 0.11441363f, 0.11900546f, 0.13466960f, -0.09752824f, -0.27476099f, -0.46452761f, -0.33241731f, 
    -0.21818711f, -0.06611997f, -0.08556592f, 0.07255199f, 0.02374893f, -0.10933508f, -0.03535717f, -0.04490077f, 
    -0.04612852f, -0.05590902f, 0.00291975f, 0.04189500f, 0.02092098f, 0.05793607f, 0.08682737f, 0.05385541f, 
    -0.03219484f, -0.11570716f, -0.10192829f, -0.04634028f, -0.06851079f, -0.03888451f, -0.04169880f, 0.05962168f, 
    -0.01583548f, 0.05806736f, 0.03620153f, 0.03319674f, -0.00929269f, -0.01037093f, 0.02368165f, -0.02655192f, 
    0.07874634f, 0.06158737f, 0.07587522f, 0.07420867f, -0.01666209f, -0.05542359f, -0.19802622f, -0.01668583f, 
    0.09636793f, 0.06796881f, -0.01856619f, 0.09880193f, 0.10320591f, 0.00055368f, 0.12048980f, -0.01898183f, 
    0.00996375f, 0.00287594f, 0.03011799f, -0.03078795f, 0.07847425f, 0.00212947f, -0.08372034f, 0.07075273f, 
    -0.01234974f, -0.46060094f, -0.51299876f, -0.05077918f, 0.17901051f, 0.07026460f, 0.00970678f, 0.06001084f, 
    0.05388447f, 0.17651886f, -0.05739193f, -0.09419466f, -0.02420949f, -0.04863232f, -0.02925996f, -0.02090475f, 
    0.08180201f, 0.01264924f, -0.06941786f, 0.05093208f, 0.01921795f, -0.20441581f, -0.11168837f, -0.04894771f, 
    -0.00319407f, -0.07451475f, 0.07077684f, 0.10196726f, 0.09035271f, -0.01093470f, 0.01277487f, 0.04183275f, 
    -0.06422950f, -0.07520100f, -0.05095147f, -0.01387101f, 0.02106362f, 0.01067642f, 0.02935691f, 0.03064553f, 
    0.41101387f, 0.18425882f, 0.08754297f, -0.03064116f, -0.09195626f, 0.05167227f, -0.02112006f, 0.03337517f, 
    0.01097637f, -0.24158293f, -0.03104192f, 0.03837145f, 0.04839631f, 0.00160847f, 0.01987706f, 0.02412105f, 
    0.05104100f, 0.07553881f, 0.04879583f, -0.02321012f, -0.12066176f, -0.15391938f, -0.15078904f, -0.05698716f, 
    -0.05698549f, -0.06569667f, 0.01995832f, 0.02046551f, 0.01267468f, 0.11021868f, -0.01034400f, 0.02229362f, 
    -0.04210670f, -0.07282603f, -0.01383385f, -0.03312715f, 0.08291588f, 0.02974150f, 0.04635133f, 0.05825434f, 
    -0.21088251f, -0.11890477f, 0.10390861f, -0.05219300f, 0.00721075f, -0.06021214f, 0.05192551f, -0.00483872f, 
    0.03941627f, -0.03662919f, -0.00245705f, 0.10790677f, 0.01876850f, 0.06999332f, 0.03070720f, -0.02110222f, 
    0.02394188f, -0.00885702f, 0.08220486f, 0.01509066f, -0.17661551f, -0.13834183f, -0.09359090f, 0.12275116f, 
    -0.03873535f, 0.04849923f, 0.03505863f, -0.07131691f, -0.03211820f, -0.04955794f, -0.04574720f, 0.05255734f, 
    0.09405172f, 0.03943494f, -0.04961588f, -0.02849462f, 0.04373810f, 0.09498323f, 0.09419906f, 0.14792082f, 
    0.41237029f, 0.10862923f, -0.22153592f, -0.24791521f, -0.03191769f, 0.20605737f, 0.01782907f, 0.04490463f, 
    0.13548273f, 0.09342586f, 0.02697277f, -0.00215660f, 0.04042256f, 0.04251700f, 0.02974954f, 0.02143412f, 
    -0.01359844f, -0.02892050f, 0.06593482f, -0.06108141f, -0.37348095f, 0.02180365f, 0.12158916f, 0.11871739f, 
    -0.04360831f, -0.05776742f, -0.01886121f, -0.04840473f, -0.02108471f, -0.00299051f, -0.05321292f, -0.01645000f, 
    0.00912697f, -0.02480649f, 0.04350948f, 0.05694078f, -0.07224419f, -0.05523650f, -0.01046225f, 0.02286269f, 
    0.25348839f, 0.26336226f, -0.07422469f, -0.14218448f, 0.07498505f, 0.09409527f, 0.11663370f, 0.05945906f, 
    0.01154728f, 0.00204750f, -0.00372435f, 0.11377654f, 0.09063020f, 0.03353609f, 0.11032470f, -0.05532761f, 
    0.04322126f, 0.11227652f, 0.24890439f, 0.09467767f, -0.07214522f, -0.48805740f, -0.36756015f, -0.21118656f, 
    -0.19438535f, -0.03737615f, -0.09753514f, -0.05731165f, 0.00639492f, -0.12024014f, -0.01936554f, 0.00039066f, 
    -0.01219411f, 0.01949861f, 0.01956763f, -0.01248281f, 0.06134348f, 0.07356128f, 0.05124704f, 0.10783269f, 
    -0.08111523f, 0.03644801f, -0.12513740f, -0.12680642f, -0.02591929f, 0.01569999f, -0.02248698f, 0.09958167f, 
    -0.05847518f, 0.18139173f, -0.02710786f, -0.01281928f, -0.09109992f, 0.00631654f, 0.04863973f, -0.03247791f, 
    0.06905905f, 0.16518995f, -0.06268820f, 0.01362093f, 0.25129026f, 0.17843826f, 0.00095602f, 0.21521127f, 
    -0.26747727f, 0.01044967f, -0.01410577f, -0.20280375f, -0.04090174f, -0.09552167f, 0.02757971f, 0.00306371f, 
    0.02582775f, 0.00503733f, 0.01708658f, 0.02002816f, -0.01450315f, -0.01262995f, -0.03013976f, -0.09016804f, 
    -0.22416949f, -0.06144087f, 0.22557007f, 0.00003555f, -0.25505888f, 0.18006830f, -0.23586948f, 0.04033384f, 
    0.01264758f, 0.16237290f, 0.03248303f, -0.02953856f, -0.00321137f, -0.02339692f, -0.04572549f, 0.02410371f, 
    -0.03297696f, 0.01216701f, -0.06172877f, -0.21143144f, -0.40230104f, 0.22581662f, -0.23531504f, -0.06320492f, 
    0.00012582f, -0.06015562f, 0.04654029f, 0.13560176f, 0.00035401f, -0.00687301f, 0.03048062f, -0.00136142f, 
    -0.00362018f, -0.07818691f, -0.02030720f, 0.03739763f, 0.06393759f, -0.15484174f, 0.05507938f, -0.07520104f, 
    -0.04618075f, 0.02562898f, -0.16510469f, -0.08255898f, 0.03365672f, 0.09421121f, -0.00664020f, 0.11240771f, 
    -0.05539086f, -0.02649019f, 0.02675321f, 0.07281946f, 0.01511597f, -0.02343286f, -0.12538810f, 0.05913459f, 
    -0.01653800f, -0.04936418f, -0.04122490f, 0.01653961f, -0.29723790f, 0.15316530f, -0.02216517f, 0.32351729f, 
    0.10408653f, -0.06845376f, 0.11729497f, -0.27427208f, 0.13941835f, -0.10040917f, 0.06612168f, -0.02662990f, 
    0.07564612f, -0.00679164f, -0.00731038f, 0.08604839f, 0.02868942f, -0.00079028f, -0.00640231f, 0.00926323f, 
    -0.06080568f, 0.13386704f, -0.00379280f, -0.16357660f, -0.11672173f, 0.00162097f, -0.00124996f, -0.01599226f, 
    -0.01891042f, 0.04955241f, 0.05629669f, -0.02555366f, -0.04542641f, 0.03987511f, 0.08902851f, -0.03740996f, 
    -0.05602460f, 0.02174962f, 0.00798424f, -0.02437660f, 0.14857003f, 0.06109634f, -0.15534292f, -0.09939671f, 
    -0.30436867f, -0.08003259f, -0.02754729f, -0.09596191f, 0.01501413f, 0.07011382f, -0.09848429f, 0.08627781f, 
    -0.05010825f, 0.01890721f, -0.04085689f, -0.00778953f, 0.07326375f, 0.08084162f, 0.00246426f, 0.06211209f, 
    0.30149803f, 0.06739262f, 0.28470188f, 0.30921075f, -0.41668501f, -0.00281451f, -0.11756204f, -0.30905795f, 
    -0.04528876f, -0.21341592f, 0.00860518f, 0.02364925f, 0.09756044f, 0.10380328f, 0.08914395f, 0.01973442f, 
    0.01718221f, 0.02251846f, 0.00787145f, 0.04120196f, -0.08741767f, -0.03652994f, 0.26683721f, -0.00682385f, 
    -0.25528419f, 0.09081943f, -0.17172809f, 0.07247383f, 0.03342493f, 0.12592119f, -0.02580810f, -0.00955667f, 
    -0.01109072f, 0.03037897f, -0.02070679f, 0.01891540f, -0.01076466f, -0.02919766f, -0.08246344f, -0.03744695f, 
    -0.03767140f, 0.05448155f, 0.20219548f, 0.05899994f, -0.08029736f, 0.11628157f, -0.11736761f, 0.05700867f, 
    -0.02932647f, 0.02516238f, 0.03322087f, 0.00959104f, 0.06880222f, -0.00414948f, -0.04346281f, 0.01796131f, 
    -0.01605296f, -0.08888277f, -0.01658238f, -0.04113105f, -0.14796473f, 0.03813220f, -0.39388949f, -0.01143493f, 
    -0.13268258f, 0.11773758f, -0.00917685f, 0.11843650f, -0.03969140f, 0.09528828f, -0.04967702f, -0.02164872f, 
    -0.03125440f, 0.03225106f, 0.03267219f, -0.01975762f, 0.06539623f, 0.02689064f, 0.03109579f, -0.00902978f, 
    0.04466144f, -0.03116507f, 0.03997204f, -0.04032057f, 0.04772559f, 0.04027637f, 0.04906343f, -0.10502736f, 
    -0.07552991f, -0.12345615f, 0.01551658f, 0.06069400f, -0.02314698f, 0.03932898f, -0.00887146f, 0.08775399f, 
    -0.08102990f, -0.11656384f, -0.08013821f, -0.04083756f, -0.07673144f, 0.21462545f, -0.06899270f, 0.53396451f, 
    -0.15031825f, 0.15405482f, -0.20428143f, -0.11922538f, 0.00521157f, -0.10726276f, 0.05252492f, -0.07069163f, 
    0.10083956f, -0.07853856f, 0.07685135f, 0.09406576f, 0.08986589f, 0.06914680f, 0.06921795f, 0.09419953f, 
    -0.10040739f, 0.11571103f, 0.23990454f, -0.23430553f, -0.10715751f, -0.06705221f, -0.04419813f, -0.05867002f, 
    0.19672270f, 0.04956043f, 0.07508951f, 0.03722602f, -0.01437468f, -0.07169912f, -0.03860338f, 0.01200036f, 
    0.12996159f, -0.17988282f, -0.02265782f, -0.01385950f, -0.25127652f, -0.05317524f, -0.37883636f, -0.10901763f, 
    0.13668059f, -0.11654738f, 0.10235435f, 0.16664271f, -0.02576078f, -0.04614909f, 0.01196145f, 0.05276082f, 
    -0.04188163f, -0.01926415f, -0.00894932f, 0.04612514f, 0.05611300f, -0.10441732f, 0.03561867f, 0.02264063f, 
    0.10088222f, -0.07189728f, -0.08210942f, 0.13523991f, 0.00265054f, -0.01756852f, 0.17353138f, 0.11252869f, 
    0.01590112f, 0.00006046f, -0.06923477f, 0.03882868f, -0.05687644f, -0.08916074f, -0.01598089f, 0.05354822f, 
    -0.05825720f, 0.00206225f, -0.13693596f, -0.00780277f, -0.20289105f, 0.09189388f, -0.24696885f, -0.08066687f, 
    -0.11846618f, 0.14371426f, -0.15991451f, 0.05805229f, -0.14029290f, 0.06214463f, -0.05190724f, 0.00637922f, 
    0.01382217f, 0.07807757f, -0.02106013f, -0.00236468f, -0.08453541f, 0.05400611f, 0.02984804f, 0.08118244f, 
    -0.54820013f, -0.14121880f, -0.13028015f, 0.35749218f, 0.07977461f, -0.11728863f, 0.13438255f, -0.24070501f, 
    -0.05072213f, -0.02536912f, 0.04430061f, -0.07455995f, -0.02340900f, -0.14921193f, 0.04424951f, 0.06771060f, 
    -0.09904238f, -0.05320738f, -0.07912754f, -0.06779215f, -0.01220875f, 0.20735599f, -0.28790042f, 0.08618374f, 
    -0.13638386f, -0.15172853f, -0.11674204f, -0.04293411f, -0.13575931f, -0.08938026f, 0.01175875f, 0.01227301f, 
    0.00413355f, 0.02736923f, -0.02235775f, -0.10303905f, 0.03836294f, -0.01054204f, -0.04321795f, 0.03195933f, 
    0.18734206f, -0.04201391f, 0.12420505f, 0.01772971f, -0.12456231f, -0.02848829f, 0.04906875f, -0.03681968f, 
    0.07289618f, 0.02071062f, 0.03771041f, 0.07839263f, 0.05266691f, -0.00579637f, 0.03686504f, 0.04283219f, 
    -0.01689776f, -0.08466897f, -0.14709161f, -0.04346795f, 0.07925999f, 0.06641514f, 0.24321932f, -0.15984574f, 
    -0.18745594f, 0.12303347f, -0.18833622f, 0.08107167f, 0.07843006f, 0.02454541f, -0.01629242f, -0.02337523f, 
    -0.03384077f, -0.00615414f, -0.01573640f, -0.01890921f, 0.01721017f, -0.02760842f, -0.03362576f, -0.14441493f, 
    -0.24407557f, -0.01786767f, -0.04573654f, -0.18702072f, 0.01149414f, 0.01728264f, 0.07198749f, 0.02529216f, 
    0.08458399f, -0.03819880f, 0.13657069f, -0.10212678f, -0.05358996f, -0.01589768f, -0.02134498f, 0.08827552f, 
    -0.05489999f, 0.02242572f, 0.04414532f, -0.02711247f, -0.54898274f, -0.08681384f, -0.68182135f, 0.23633204f, 
    -0.18517900f, -0.11959437f, 0.02672521f, 0.03569261f, -0.25609899f, -0.07362972f, 0.07226899f, 0.01088104f, 
    -0.01745516f, -0.05446891f, -0.05509388f, 0.01550173f, 0.05558320f, -0.08609852f, 0.07576033f, 0.14186700f, 
    0.09228562f, 0.15712631f, -0.31752566f, -0.11465386f, -0.01776648f, -0.03603780f, 0.03601603f, 0.14208937f, 
    -0.05716968f, 0.14215752f, 0.00385238f, 0.00832167f, -0.06047083f, 0.00494679f, -0.09775513f, 0.03764021f, 
    0.02857671f, -0.01949538f, -0.05455688f, -0.03437439f, 0.18846056f, -0.06674794f, 0.00761551f, -0.07165071f, 
    -0.27903250f, -0.06114766f, -0.23487285f, 0.12209848f, 0.03077399f, 0.05071837f, -0.06889820f, 0.03636969f, 
    0.00158998f, 0.00330875f, 0.00681988f, 0.00850885f, 0.05232697f, 0.08088923f, -0.04996570f, 0.11109697f, 
    0.14751685f, 0.26188713f, -0.70027477f, 0.22499028f, -0.08913627f, 0.06483530f, 0.14472859f, 0.27198178f, 
    -0.06384938f, 0.23330496f, 0.01216219f, -0.01158052f, -0.04506172f, 0.02794683f, -0.06350203f, 0.01142377f, 
    0.07266248f, -0.11573918f, 0.04885588f, -0.01269814f, -0.26807100f, -0.25383490f, -0.41688004f, 0.10800454f, 
    -0.50573903f, -0.34491509f, 0.24014944f, -0.11402263f, 0.15233161f, 0.03458675f, 0.07831483f, -0.06343465f, 
    0.05347080f, 0.03433058f, 0.03750094f, -0.03411765f, 0.05521820f, 0.03326524f, 0.00911603f, -0.05267270f, 
    0.08419166f, -0.18434881f, 0.09242931f, 0.26472980f, -0.57680190f, -0.11706087f, -0.03617379f, -0.10514532f, 
    0.15150748f, 0.06025419f, 0.07516284f, 0.00694060f, 0.04948415f, 0.00965303f, 0.01061262f, -0.01236601f, 
    0.05557308f, 0.08427595f, 0.07074087f, 0.05827239f, -0.13448872f, -0.15168369f, 0.08465008f, 0.26489803f, 
    -0.23159716f, 0.07309844f, -0.11296172f, -0.08902022f, -0.08210911f, 0.13927308f, 0.03309398f, 0.01212766f, 
    0.09618185f, 0.11148196f, 0.00448443f, -0.06535058f, 0.02545721f, 0.17302196f, 0.17096981f, 0.14250834f, 
    0.02567872f, -0.36417550f, 0.51058674f, -0.03439827f, -0.42604429f, 0.12654389f, -0.25465411f, -0.14318882f, 
    0.14252828f, -0.08157420f, -0.08664508f, 0.10923795f, 0.07108492f, 0.07576021f, 0.03471674f, 0.05176180f, 
    0.00218373f, -0.03767437f, -0.05175099f, 0.07609181f, -0.01630561f, -0.18850756f, -0.26924297f, -0.27961919f, 
    0.10711753f, 0.05586496f, 0.06244028f, 0.04997142f, 0.04763179f, 0.09355234f, 0.06223413f, -0.00460439f, 
    0.00634162f, -0.00637923f, -0.04994409f, 0.05522234f, -0.00094985f, -0.02217275f, -0.03160349f, 0.08383489f, 
    0.03946003f, 0.00063415f, 0.07835270f, 0.18096113f, -0.16281325f, 0.03309352f, -0.00044127f, 0.04542176f, 
    -0.06004321f, -0.11478958f, -0.03099474f, -0.03874694f, -0.01178306f, 0.02664939f, -0.05325330f, 0.01020936f, 
    -0.00243298f, -0.07444204f, 0.06343268f, 0.03325549f, -0.20615013f, -0.34455970f, -0.15612857f, 0.03320730f, 
    0.05599109f, -0.01364761f, -0.07705846f, 0.06571697f, 0.01345938f, -0.08232394f, -0.06095303f, 0.01591277f, 
    -0.01959612f, -0.09465820f, 0.05185059f, 0.06445536f, 0.01415116f, -0.11278725f, 0.05866555f, 0.09652244f, 
    -0.00407860f, -0.10120796f, -0.10271482f, -0.11917681f, 0.03571108f, -0.04603766f, 0.07182367f, 0.07898041f, 
    0.12431893f, -0.00063570f, 0.04542888f, 0.04541630f, 0.03217472f, -0.09449559f, -0.00141884f, 0.07537823f, 
    0.04604838f, -0.02149632f, -0.01864740f, -0.00035747f, -0.01890525f, -0.54897350f, -0.27645695f, -0.45214081f, 
    -0.30157700f, 0.01565998f, -0.20544828f, 0.10106977f, 0.06492832f, -0.00869413f, -0.09954313f, 0.04556145f, 
    0.00009846f, 0.05231695f, -0.14427257f, 0.09927732f, -0.01181921f, 0.02981019f, -0.13162974f, -0.00783277f, 
    -0.18489704f, -0.01516501f, -0.17504892f, -0.00835928f, 0.06050366f, -0.04511572f, 0.07174206f, 0.13375820f, 
    -0.12889327f, -0.11835136f, -0.00838468f, 0.06816543f, -0.01228579f, -0.04381815f, 0.04797038f, -0.03258023f, 
    0.11165597f, -0.10419177f, -0.01199879f, 0.13866572f, -0.14333399f, 0.05089929f, -0.38581744f, -0.07214488f, 
    -0.24258922f, -0.28146017f, 0.02630554f, 0.05687399f, -0.06869347f, 0.03671986f, -0.08319116f, -0.08594330f, 
    -0.05685525f, -0.09584432f, -0.03923328f, 0.09137946f, -0.05388992f, -0.04570916f, 0.03311403f, -0.11150776f, 
    -0.28855470f, 0.10604639f, 0.08637470f, 0.40899339f, -0.06073886f, 0.12864710f, -0.00199929f, -0.11993001f, 
    -0.05173712f, -0.06302530f, 0.11128820f, -0.00554554f, -0.05365126f, 0.01918727f, 0.04555437f, 0.05932676f, 
    -0.06357172f, -0.05334714f, 0.05106533f, 0.08392547f, -0.01532420f, 0.11953370f, -0.43710917f, 0.01900746f, 
    0.05675336f, 0.04570255f, 0.10663746f, 0.16695435f, 0.12051688f, 0.08357390f, 0.00512459f, 0.00542104f, 
    -0.03721961f, -0.02006624f, -0.04503572f, 0.07658160f, -0.02216305f, -0.09549095f, 0.04304388f, -0.01725520f, 
    0.00529750f, -0.02033595f, -0.04099954f, -0.02625143f, -0.13324665f, -0.19030431f, 0.04811456f, -0.07622004f, 
    0.01424740f, 0.04415557f, 0.09990217f, -0.00993838f, 0.00866719f, 0.04047998f, -0.00413385f, 0.04487610f, 
    0.12973094f, 0.10209192f, 0.00121259f, 0.02638794f, 0.08122806f, -0.07360072f, 0.20277435f, 0.15217760f, 
    0.02055772f, 0.05548692f, -0.02903741f, -0.17748573f, -0.09977217f, -0.09196462f, 0.06422795f, 0.02972051f, 
    0.12170470f, 0.02268611f, 0.04788644f, 0.05203975f, -0.09220616f, -0.05026920f, 0.00740576f, -0.05728759f, 
    -0.05037235f, 0.01756971f, 0.32319549f, 0.62539065f, -0.74566346f, 0.25631264f, -0.25105551f, -0.28810364f, 
    -0.07267688f, -0.22029427f, -0.01025163f, 0.02633517f, 0.04202863f, 0.05187702f, 0.04490944f, 0.02953649f, 
    0.01960736f, 0.00301673f, 0.00074639f, 0.04979768f, 0.01215825f, 0.06801182f, 0.15825982f, 0.38159585f, 
    -0.09092021f, 0.03314382f, 0.01177513f, -0.19149081f, -0.02307583f, -0.28086916f, 0.07057665f, -0.02232824f, 
    0.05471775f, 0.08177076f, 0.04101004f, 0.07857650f, 0.04253662f, -0.06317114f, -0.00645476f, 0.04145351f, 
    -0.49661177f, -0.42382231f, -0.18036865f, 0.12096209f, -0.08495544f, -0.31432760f, 0.24544069f, -0.08875929f, 
    -0.06246823f, 0.19189364f, 0.08238342f, -0.06422959f, 0.05602403f, 0.11152619f, -0.00876449f, 0.01363773f, 
    0.02002832f, -0.07226221f, 0.07131132f, 0.07911494f, -0.00962599f, -0.12705098f, -0.03653667f, 0.01584632f, 
    0.01596620f, -0.06116659f, 0.03672351f, 0.06739207f, -0.15311106f, 0.01468034f, -0.01133732f, 0.11037175f, 
    0.03828868f, -0.01420949f, -0.03940836f, 0.10934654f, 0.09930557f, -0.01113306f, -0.01844587f, 0.03251662f, 
    -0.23164794f, 0.01668519f, -0.21104340f, 0.20189932f, 0.10579693f, 0.01780996f, -0.05498882f, 0.03431094f, 
    -0.14529645f, 0.05040869f, 0.08506004f, 0.00068010f, 0.06087973f, 0.01195858f, -0.02656742f, 0.07944613f, 
    0.02145845f, -0.01098616f, 0.01521093f, 0.12486178f, 0.09165979f, 0.24678926f, -0.23998670f, -0.30361798f, 
    -0.08769908f, -0.17501064f, -0.23922922f, -0.00135246f, -0.06809083f, 0.20171635f, -0.07262870f, 0.08845767f, 
    -0.13681401f, -0.06288797f, 0.12231459f, -0.06128701f, -0.01684247f, 0.16539705f, -0.00639620f, -0.01486389f, 
    0.14430076f, -0.50297016f, -0.59578568f, -0.00589579f, 0.04611595f, 0.10135035f, -0.16475666f, 0.16209888f, 
    0.06111256f, 0.11573150f, 0.01203371f, 0.05493070f, 0.02548744f, 0.00310074f, 0.03517554f, 0.03060320f, 
    0.08940978f, 0.19817545f, 0.03840676f, 0.21062960f, -0.04966395f, -0.10853924f, 0.04048716f, -0.14555089f, 
    0.16978504f, -0.03118812f, 0.03821313f, -0.09554370f, 0.04625716f, -0.01844238f, 0.12918721f, 0.17583622f, 
    -0.00154693f, -0.04663755f, 0.14577247f, 0.00652662f, 0.06692917f, -0.12612084f, -0.02975371f, 0.05919071f, 
    -0.12656930f, 0.23341231f, -0.18045859f, 0.08946326f, -0.12866475f, -0.00874550f, 0.06170079f, 0.13121766f, 
    -0.04108528f, -0.09346008f, 0.06376164f, 0.04499047f, -0.04095961f, -0.09915975f, -0.06212773f, 0.04469828f, 
    -0.00524006f, -0.07753077f, 0.04446121f, -0.13380644f, -0.22431101f, -0.21032183f, -0.12609221f, 0.18113716f, 
    -0.31813490f, -0.09522489f, -0.14743532f, 0.08326197f, 0.04500185f, 0.18095750f, 0.04560711f, 0.03978444f, 
    0.00807274f, 0.00209387f, -0.05842966f, -0.03538926f, 0.01158902f, 0.09475940f, 0.03469263f, -0.05295391f, 
    0.00608950f, -0.00287436f, 0.07590390f, 0.14842556f, 0.08788041f, -0.05877258f, 0.16208026f, -0.12983571f, 
    -0.08009782f, -0.05187709f, -0.03217970f, 0.04324756f, 0.09375367f, 0.02418418f, 0.06674095f, 0.03927637f, 
    -0.01967551f, -0.01841746f, -0.08638351f, -0.07725777f, 0.12748997f, -0.02739348f, 0.19925165f, 0.06582206f, 
    -0.02414951f, -0.02861631f, -0.06211074f, -0.11347028f, -0.05054652f, -0.02601746f, 0.14446266f, 0.00173142f, 
    0.07949819f, 0.02122117f, 0.04105221f, 0.07769572f, -0.02906034f, -0.06194547f, 0.02042346f, 0.03373685f, 
    0.18410926f, -0.22923245f, 0.10396751f, -0.24831687f, -0.24331434f, -0.13629055f, -0.03984132f, -0.13340285f, 
    0.14194833f, 0.00678054f, 0.01639981f, -0.01424765f, 0.06630470f, 0.03207004f, 0.02621416f, 0.02633622f, 
    -0.01036647f, -0.04926744f, -0.00200305f, -0.00661414f, -0.09607011f, 0.16345069f, 0.21421412f, 0.07200224f, 
    -0.09127014f, 0.19110531f, -0.05939246f, -0.06227283f, -0.17884910f, 0.01099623f, 0.02644050f, 0.05086144f, 
    0.05829154f, 0.06202570f, 0.05024629f, -0.01619662f, -0.03799127f, -0.10616934f, -0.00818459f, 0.00329063f, 
    -0.22318307f, 0.42222831f, -0.62895459f, -0.00703797f, -0.04355075f, 0.04752976f, 0.02738719f, 0.06826476f, 
    -0.08907050f, 0.14056565f, 0.01945969f, -0.01222454f, -0.04834496f, 0.01205599f, -0.05654450f, 0.06307365f, 
    -0.00001849f, -0.06901430f, 0.03301991f, 0.00814495f, 0.04674039f, 0.07219219f, 0.25519034f, -0.04599507f, 
    -0.00808357f, 0.02440169f, 0.01402026f, -0.20806208f, -0.06709139f, -0.02925901f, -0.02037146f, 0.09899213f, 
    0.12901321f, 0.04978273f, 0.08605590f, 0.01103708f, -0.05283236f, -0.03021877f, -0.05915663f, -0.03159253f, 
    0.02007590f, 0.00699637f, 0.09646693f, -0.06766929f, 0.07671918f, -0.03544431f, 0.02026014f, 0.04129058f, 
    0.02506620f, -0.07055141f, -0.05290820f, 0.10013410f, 0.07661558f, -0.06805457f, 0.04278552f, 0.08190646f, 
    0.08882479f, -0.13805211f, -0.04478303f, 0.11037058f, -0.10560112f, 0.31742424f, 0.07459147f, -0.30208215f, 
    -0.12089929f, 0.08133656f, -0.04701018f, 0.09465709f, 0.06144322f, 0.01386836f, 0.06916454f, -0.07227704f, 
    -0.02872108f, -0.02812581f, 0.00013952f, -0.04589247f, -0.00706274f, -0.07624464f, -0.01167271f, -0.18093458f, 
    -0.48877251f, 0.11895628f, -0.42983022f, 0.20858540f, -0.32631212f, 0.09520186f, -0.15321365f, 0.01285903f, 
    -0.02943303f, 0.00264736f, 0.01803240f, 0.05004387f, -0.03883133f, -0.06414280f, -0.07066837f, 0.01600578f, 
    -0.05625915f, -0.00803572f, 0.01477020f, 0.06267107f, -0.08340155f, -0.11905722f, -0.08510315f, -0.26823902f, 
    0.10874981f, 0.04542278f, 0.04817546f, 0.08606904f, 0.02457336f, 0.04575238f, 0.02194311f, 0.09351759f, 
    0.00379427f, 0.01074385f, -0.00411381f, 0.02036538f, 0.07744063f, 0.07830477f, -0.03503718f, 0.05097352f, 
    -0.18991660f, -0.19735980f, -0.02846424f, 0.11579089f, 0.00278092f, 0.01662620f, -0.01784495f, 0.05611596f, 
    -0.04980936f, -0.02003367f, 0.05217270f, 0.00087641f, -0.02640371f, -0.08026062f, -0.06603305f, 0.06801839f, 
    0.04242874f, -0.09863883f, 0.05233795f, 0.05487908f, -0.08195857f, -0.12356276f, 0.06658334f, 0.19215618f, 
    -0.14085905f, -0.08522894f, -0.22212848f, 0.20256820f, 0.08815218f, 0.20063294f, 0.00696672f, 0.00068115f, 
    0.01051910f, 0.01279540f, -0.07264183f, 0.04436696f, 0.00051260f, 0.05053602f, 0.07392555f, -0.14467709f, 
    0.06011382f, -0.01385746f, -0.20253333f, 0.11804552f, -0.16525577f, 0.00823740f, -0.03094121f, 0.06940205f, 
    -0.06032103f, 0.02857186f, -0.00665445f, -0.00710420f, -0.00569377f, 0.00195723f, -0.05600708f, 0.00958885f, 
    0.10619033f, -0.03515933f, 0.04571217f, -0.02941351f, -0.04123902f, -0.20963474f, 0.14179333f, 0.19129686f, 
    -0.01037559f, 0.00578541f, -0.00795614f, -0.03778090f, -0.18605165f, 0.04793757f, -0.11383364f, 0.04521900f, 
    -0.08811391f, -0.02728572f, -0.01714716f, 0.05621060f, -0.07232458f, -0.03683687f, 0.01703607f, 0.14057924f, 
    -0.42117864f, -0.13307460f, -0.00068519f, 0.03115850f, 0.15801081f, -0.18628050f, 0.02266917f, 0.13458695f, 
    -0.01307530f, -0.09536786f, -0.03408489f, 0.05159255f, 0.03643503f, 0.06587451f, 0.02566593f, 0.05003678f, 
    -0.03887684f, -0.06510567f, 0.00900485f, 0.05739088f, -0.19201823f, -0.24942380f, -0.10108151f, -0.07382818f, 
    -0.16801745f, 0.06224335f, -0.05120882f, 0.13077956f, -0.00677042f, -0.14260714f, -0.14775816f, 0.04448736f, 
    0.05707797f, 0.07064630f, 0.08963730f, 0.04071120f, -0.00682681f, 0.12603980f, -0.04600951f, -0.06803943f, 
    -0.00664558f, 0.03384983f, 0.11501701f, 0.27308828f, -0.01203961f, 0.02183730f, 0.06360302f, 0.02632550f, 
    -0.09039609f, 0.07943851f, -0.08917373f, 0.08142547f, 0.13089491f, 0.02275660f, -0.06686997f, -0.05887870f, 
    -0.09046200f, 0.11403274f, 0.09681883f, -0.01557594f, 0.21619071f, 0.08242697f, 0.18275414f, 0.04812517f, 
    -0.02910374f, 0.03230147f, -0.10475584f, -0.01639118f, 0.01793737f, -0.02064716f, -0.05303947f, 0.07660779f, 
    -0.05387412f, 0.04984916f, -0.03119655f, -0.12998630f, 0.02746987f, 0.01983809f, -0.10433593f, -0.11259674f, 
    0.01499972f, 0.01201122f, -0.06340369f, -0.00164074f, -0.15421052f, 0.05668412f, 0.07158208f, 0.03318744f, 
    0.02450171f, 0.02195530f, -0.05280400f, -0.08261898f, 0.08913794f, -0.02145980f, -0.01257607f, 0.02054946f, 
    0.10009436f, 0.04554588f, 0.10907168f, 0.03903688f, 0.12444828f, -0.00545960f, 0.05690793f, 0.09663679f, 
    0.00776161f, 0.04527579f, -0.03442698f, 0.12787814f, -0.07736465f, 0.00372598f, 0.04081294f, 0.04905915f, 
    -0.06548098f, 0.01266223f, -0.13277748f, 0.03766519f, 0.03909545f, -0.01554900f, -0.00023190f, -0.11854277f, 
    -0.06564568f, 0.18726592f, -0.08267026f, 0.03786684f, -0.00438094f, 0.08502261f, -0.08792981f, -0.07897037f, 
    -0.03304842f, 0.02950971f, -0.06437136f, 0.07072411f, -0.04532654f, -0.02469586f, -0.12830278f, -0.01991194f, 
    -0.04198055f, -0.06836618f, -0.03946046f, -0.05027365f, -0.39021766f, 0.07654362f, 0.08872799f, -0.08458702f, 
    0.04798499f, -0.00787261f, -0.05561061f, -0.03841082f, 0.03293287f, 0.00001760f, -0.14314258f, 0.00326757f, 
    0.04604778f, -0.01272191f, 0.00735195f, 0.07319357f, 0.00734374f, -0.03622041f, 0.01201429f, 0.10359598f, 
    -0.14638843f, -0.06778235f, 0.04404160f, 0.06482533f, 0.01263323f, -0.05086418f, 0.03209730f, 0.00225267f, 
    0.00936995f, 0.00272431f, 0.07710720f, -0.01890585f, 0.02696836f, -0.02627672f, -0.02921963f, 0.06247941f, 
    0.04734590f, 0.08185153f, 0.02319205f, 0.19314227f, -0.01845421f, -0.14336392f, -0.36433056f, 0.01272687f, 
    -0.13556795f, -0.09918381f, -0.16104394f, -0.04512255f, -0.05586987f, -0.19400948f, -0.09875350f, -0.01349097f, 
    -0.03502081f, -0.04110381f, -0.03111235f, 0.04947935f, -0.12216241f, -0.08702333f, 0.00568463f, -0.14459164f, 
    -0.16243835f, -0.04938648f, -0.01123489f, 0.18341462f, -0.04779012f, -0.00436141f, 0.00496356f, 0.05747486f, 
    -0.03578967f, 0.06339591f, -0.01852211f, -0.00498600f, 0.00273861f, -0.03060683f, -0.00579520f, -0.05562164f, 
    0.08763133f, 0.09162498f, 0.08090506f, 0.19629072f, 0.09750833f, -0.08891371f, 0.06678735f, -0.00261658f, 
    -0.12457935f, 0.04165921f, 0.04897517f, 0.02280309f, 0.11145797f, -0.10417809f, -0.03244785f, -0.00953437f, 
    -0.01903302f, -0.13523152f, -0.20983295f, -0.08080640f, -0.14685202f, 0.02311536f, -0.14478789f, -0.12742275f, 
    -0.05672474f, -0.26543745f, 0.18474869f, -0.06880654f, -0.19388103f, -0.06240338f, 0.05665042f, 0.00404141f, 
    0.03498877f, -0.01352337f, -0.07337238f, -0.14293273f, 0.01841619f, 0.00583839f, 0.07932508f, -0.08971491f, 
    -0.10987902f, 0.24546407f, 0.08193976f, 0.15339479f, 0.04887766f, -0.24272755f, 0.06129763f, 0.08686631f, 
    0.03815710f, 0.03302341f, -0.06639443f, 0.03491903f, -0.03046149f, -0.06209920f, -0.05531733f, 0.06786449f, 
    -0.08115507f, 0.08063325f, 0.03499154f, 0.03368703f, 0.01059640f, 0.05247763f, -0.05380606f, -0.02893272f, 
    -0.20213920f, -0.16702618f, -0.10564531f, -0.01122512f, -0.11093810f, 0.01478864f, -0.03487924f, 0.13412385f, 
    -0.07897519f, 0.00446498f, -0.00688414f, 0.05407587f, 0.06251933f, 0.02920203f, 0.02174789f, -0.04610010f, 
    0.05919539f, 0.07609922f, 0.06700266f, 0.12722322f, 0.08530875f, -0.04774814f, 0.20465341f, 0.07213020f, 
    0.01304801f, -0.06437730f, 0.06850979f, 0.12149455f, 0.19237432f, -0.02759122f, -0.05170799f, 0.13074315f, 
    0.04232687f, -0.00293842f, 0.01001325f, -0.03371130f, -0.00253216f, 0.01074554f, 0.06897034f, -0.15818775f, 
    0.36191431f, -0.24608704f, 0.27290922f, -0.10754045f, 0.07398302f, 0.04472930f, -0.11604487f, 0.05685201f, 
    0.00009908f, 0.01033555f, 0.00895832f, 0.06932960f, -0.10914333f, 0.03820457f, 0.07374961f, -0.09528754f, 
    -0.01400176f, 0.01216842f, -0.05493350f, 0.03158864f, -0.12213355f, -0.08375587f, 0.19492866f, 0.23983042f, 
    0.10103031f, -0.02504324f, -0.02809257f, -0.12017561f, 0.19569388f, 0.10468234f, 0.02130934f, -0.12076865f, 
    0.01894076f, 0.03790096f, -0.11705190f, 0.20743936f, 0.10303201f, 0.01847566f, 0.13258305f, 0.02368655f, 
    -0.15944114f, -0.09799083f, -0.31169066f, 0.05211188f, -0.10022730f, -0.02661787f, -0.03667094f, 0.03605201f, 
    0.02766989f, 0.11020288f, -0.08441576f, 0.01374046f, 0.01078261f, 0.03121344f, -0.05169581f, -0.01444332f, 
    0.02679026f, -0.04160272f, 0.12501390f, 0.20256869f, -0.23540574f, 0.04031225f, 0.04282816f, 0.21029539f, 
    0.10286170f, -0.07078140f, 0.03003499f, -0.09626944f, 0.11469918f, -0.05643762f, 0.05152834f, -0.02035319f, 
    -0.00069552f, 0.06288488f, 0.09285663f, 0.08849921f, 0.02018805f, -0.11618931f, 0.02437443f, 0.13777453f, 
    -0.18814425f, -0.04197494f, 0.24636923f, 0.08146456f, 0.02012250f, 0.08715567f, 0.03714101f, -0.04168493f, 
    0.10371421f, -0.01813451f, -0.18700458f, 0.01131868f, 0.09402478f, -0.09656586f, 0.07201585f, -0.04864002f, 
    0.20957404f, 0.06402959f, 0.05967151f, -0.06041587f, 0.18122816f, -0.15881391f, 0.18378536f, -0.16731526f, 
    0.03252399f, -0.19864735f, 0.02585687f, 0.14181739f, 0.04448770f, -0.03684217f, -0.05775393f, 0.00065090f, 
    -0.01631921f, 0.05400828f, 0.12106145f, 0.08271832f, -0.11183423f, 0.03698168f, -0.02935340f, -0.10044479f, 
    -0.26596087f, -0.11338858f, 0.24265178f, 0.04990920f, 0.10028905f, 0.00225029f, -0.11935961f, 0.15083779f, 
    -0.04032712f, -0.08960644f, 0.04015491f, 0.03709111f, 0.08963546f, -0.00845252f, -0.00468553f, -0.03050575f, 
    -0.05603866f, 0.05105359f, -0.01081267f, 0.03749885f, -0.15063141f, 0.10104258f, 0.04892316f, 0.08222952f, 
    0.09702484f, 0.02567029f, 0.02182715f, 0.00594288f, -0.04773910f, -0.06166531f, 0.02626763f, 0.06584759f, 
    -0.02922799f, -0.02829270f, -0.06532197f, -0.00577407f, -0.03925180f, -0.05656856f, -0.08748439f, -0.01044431f, 
    -0.30745763f, -0.49460304f, -0.22097218f, -0.07450105f, 0.11076062f, 0.00586641f, -0.31357235f, 0.14082129f, 
    -0.04553886f, -0.09016921f, -0.08430279f, 0.07052881f, -0.09005146f, -0.03615101f, -0.04193679f, 0.12939954f, 
    -0.22729021f, -0.07822518f, 0.04756699f, 0.13857581f, -0.21274263f, 0.17308752f, -0.21490584f, 0.01134288f, 
    0.20628689f, 0.04647313f, -0.12213427f, -0.00448144f, -0.11101823f, 0.07227129f, -0.08293651f, 0.08908236f, 
    0.07628109f, -0.09216106f, -0.00333722f, 0.03023032f, 0.03960408f, -0.14316763f, 0.02347031f, -0.04465260f, 
    -0.32716382f, 0.00781613f, -0.57883734f, -0.02507276f, -0.02617356f, -0.02176303f, -0.05023688f, 0.07178862f, 
    -0.06993969f, 0.03723377f, -0.01887200f, 0.06316786f, -0.01508825f, -0.13042566f, -0.09719950f, 0.04687481f, 
    -0.02668365f, -0.04637863f, -0.01456484f, -0.08754916f, -0.26392695f, -0.08871424f, -0.41354239f, -0.05478239f, 
    -0.00083652f, -0.10760064f, 0.00526317f, -0.01931796f, -0.01345085f, -0.11534137f, -0.01534490f, 0.04813109f, 
    0.01742988f, 0.00049333f, -0.00281111f, 0.08300483f, -0.17148983f, -0.10415129f, -0.12786023f, -0.17643687f, 
    -0.42365107f, 0.31505969f, -0.06852695f, 0.14066924f, 0.02082059f, 0.04629138f, -0.00223108f, -0.05363050f, 
    0.08084526f, 0.07661099f, -0.01554721f, -0.04994309f, 0.02267762f, -0.09664806f, -0.00844349f, -0.07792386f, 
    -0.07011004f, -0.05091580f, 0.10616225f, -0.01221189f, 0.07259023f, -0.10169780f, 0.22152653f, 0.05426978f, 
    -0.06459539f, 0.03076484f, -0.23957355f, -0.04379328f, 0.01756396f, -0.06735991f, -0.22563721f, 0.01170472f, 
    0.08913099f, -0.11569002f, 0.03290486f, -0.03279612f, -0.02350387f, 0.04619081f, -0.06349018f, 0.05632013f, 
    -0.32360363f, -0.05163949f, 0.08293608f, -0.04234213f, 0.00528121f, -0.06510692f, 0.00030861f, 0.08909994f, 
    0.12144779f, -0.00261758f, -0.03351211f, -0.01151421f, 0.00144498f, 0.03434154f, 0.04622656f, 0.12972504f, 
    -0.00730477f, 0.07595409f, -0.00261391f, 0.06915073f, -0.20803364f, -0.05937122f, 0.00219114f, -0.00689370f, 
    0.01845407f, 0.06439964f, 0.04964963f, -0.02024842f, 0.11092346f, 0.02625725f, -0.10891837f, -0.00946672f, 
    -0.00883840f, -0.03088105f, 0.02116799f, 0.12753016f, -0.13898455f, -0.02897629f, -0.26518944f, -0.07329703f, 
    -0.01879786f, -0.21277960f, 0.09029812f, 0.01925528f, -0.24137585f, -0.09463399f, -0.12036327f, -0.09777171f, 
    -0.05650377f, 0.03292671f, -0.09742930f, 0.03844221f, 0.02576141f, -0.02159255f, 0.03069318f, -0.04769714f, 
    0.04980331f, 0.07790282f, 0.03077928f, 0.10434733f, -0.49241698f, 0.22576103f, -0.07781602f, 0.32153693f, 
    0.33540687f, 0.02396934f, -0.10415830f, -0.03065205f, 0.10714444f, 0.15288167f, 0.02723956f, 0.03160015f, 
    -0.02947643f, -0.00378908f, 0.04525851f, 0.04723704f, 0.01660408f, -0.15156139f, 0.09289530f, 0.06150867f, 
    0.00350917f, -0.13288528f, 0.05288009f, 0.05148625f, 0.01939179f, 0.00674656f, 0.02188815f, 0.08001682f, 
    0.01517171f, -0.06332577f, -0.05595531f, -0.01810640f, -0.02060772f, 0.10823043f, 0.08359631f, 0.06237125f, 
    -0.02511518f, 0.08500306f, -0.10869234f, 0.02320818f, 0.09020102f, -0.00349450f, 0.26534361f, 0.08345935f, 
    0.14454779f, 0.00877424f, 0.13932824f, 0.10560723f, -0.02290809f, 0.16262957f, -0.15681919f, 0.02179277f, 
    -0.05123602f, 0.12112800f, 0.08709526f, 0.03543668f, -0.03635199f, 0.02743776f, 0.03547902f, 0.10173136f, 
    0.17014955f, 0.21588419f, 0.08928107f, 0.01329582f, -0.01428612f, -0.05843185f, -0.06028927f, 0.06516506f, 
    -0.02834935f, -0.01542667f, -0.01748500f, 0.04111034f, 0.00741885f, -0.01960098f, 0.02712762f, 0.06551811f, 
    -0.06127537f, 0.04348861f, 0.04096951f, 0.02744983f, -0.10881160f, -0.23863122f, -0.13043927f, -0.05495755f, 
    -0.04833557f, 0.04933545f, -0.10053454f, 0.07124875f, 0.07099718f, -0.04903718f, -0.14918566f, 0.10385057f, 
    0.00449180f, -0.03435652f, 0.00796476f, 0.04156832f, -0.06926125f, 0.02872341f, 0.08626251f, 0.06146695f, 
    -0.04845064f, 0.04552981f, 0.01746366f, 0.10261595f, 0.00873119f, 0.03121898f, 0.01810703f, 0.05862286f, 
    0.01488237f, 0.03921393f, -0.01614465f, 0.02167712f, 0.07520920f, -0.02856693f, 0.02242529f, -0.03543019f, 
    0.00726266f, -0.10215616f, -0.01284433f, -0.05447977f, -0.04704085f, 0.00338197f, -0.18891691f, 0.04646521f, 
    0.08109363f, -0.07021165f, 0.03676946f, -0.00129813f, -0.04310331f, 0.05149129f, -0.09812992f, -0.01416453f, 
    -0.06877288f, -0.00602674f, 0.00424092f, 0.01965690f, -0.00548158f, -0.01689262f, 0.09025457f, 0.11520676f, 
    -0.07809408f, -0.15429281f, 0.12531872f, -0.21045788f, -0.05325970f, -0.06858221f, -0.11993074f, -0.17209595f, 
    0.07813938f, -0.02134879f, 0.01227255f, 0.00336223f, -0.12482163f, -0.11671132f, -0.19236323f, -0.03793659f, 
    -0.04575598f, 0.05737337f, -0.02854378f, -0.06011263f, 0.04697702f, 0.14367105f, 0.14497986f, -0.13137895f, 
    -0.02785194f, 0.04373695f, -0.08660968f, -0.01971399f, 0.06558395f, -0.01539437f, -0.09573181f, 0.07234072f, 
    -0.09127896f, 0.09090223f, -0.05797556f, -0.10146352f, -0.08152128f, -0.01702494f, -0.06606892f, -0.09395959f, 
    0.01935136f, 0.07516815f, -0.54193193f, 0.15478142f, 0.20031568f, 0.02919417f, 0.08302927f, 0.05606681f, 
    -0.18235715f, -0.04124620f, -0.08271345f, -0.00318336f, -0.02041904f, -0.04221778f, 0.18828462f, 0.02346611f, 
    -0.12086514f, -0.28218082f, -0.03962166f, -0.10169200f, 0.41415203f, -0.14918220f, -0.29265535f, 0.19787505f, 
    -0.07474766f, -0.02912106f, 0.04309603f, 0.11540466f, -0.16243170f, -0.03975359f, 0.02750774f, 0.07953580f, 
    -0.12512457f, -0.00166684f, -0.02970696f, -0.10217486f, 0.08726773f, 0.12755108f, 0.06291523f, -0.05740736f, 
    0.34500882f, -0.21146862f, 0.23857908f, -0.06659650f, -0.03178868f, -0.13025056f, 0.07739881f, 0.07558578f, 
    0.07016265f, 0.01390582f, 0.00136627f, 0.03308340f, -0.02004407f, 0.02407926f, -0.02983404f, -0.00208631f, 
    0.01090570f, -0.02265673f, -0.04558167f, -0.18354557f, 0.01418274f, -0.02419924f, -0.22484247f, 0.40231687f, 
    0.03274364f, 0.02004293f, -0.11098117f, 0.29846686f, -0.21993977f, -0.20854472f, 0.03332614f, 0.09146021f, 
    -0.01004301f, 0.13012907f, 0.08815958f, 0.04782562f, -0.07925361f, 0.02698899f, -0.18884344f, 0.04532134f, 
    -0.19755459f, -0.05332234f, -0.51568460f, 0.05139432f, 0.07341090f, -0.06654128f, 0.04260947f, -0.03612434f, 
    -0.12582180f, -0.19472361f, 0.03934577f, 0.10705211f, -0.00368812f, 0.07588048f, -0.05144633f, 0.10716275f, 
    -0.22930381f, -0.22115159f, -0.51117277f, -0.34977141f, -0.03564064f, -0.02892420f, 0.19797154f, 0.16922764f, 
    -0.06341786f, -0.05191211f, 0.03264144f, -0.19515480f, -0.07064986f, 0.06592150f, -0.26761618f, -0.02957827f, 
    0.10859245f, -0.05385585f, 0.08632536f, -0.14790791f, 0.03561907f, 0.03759730f, 0.01374705f, 0.11668561f, 
    -0.31055635f, -0.39972869f, 0.07320730f, -0.15971945f, -0.12673405f, -0.02407330f, -0.01361700f, 0.07556779f, 
    0.04527082f, 0.00368303f, -0.06488418f, 0.07397733f, -0.08663635f, 0.08500336f, 0.06174703f, 0.09686933f, 
    0.05005322f, 0.13120210f, 0.09756763f, 0.10386139f, -0.35059950f, -0.11785890f, 0.07853143f, -0.10662765f, 
    0.18237279f, -0.11685782f, -0.10190951f, -0.36332691f, -0.03543843f, 0.03021191f, -0.04819305f, 0.03341953f, 
    0.04657630f, 0.01181823f, 0.03001511f, 0.06215921f, 0.00340102f, -0.10871349f, 0.04326797f, -0.07358902f, 
    0.06528282f, -0.02681156f, 0.07451909f, -0.01585354f, 0.00653043f, 0.02524574f, 0.06489720f, 0.05714817f, 
    -0.00477547f, -0.00231066f, -0.01348115f, 0.08330639f, -0.01436042f, -0.05099766f, -0.00018408f, 0.00935054f, 
    0.06883273f, 0.02386463f, 0.07049388f, 0.07492871f, 0.06779166f, 0.08770303f, 0.02553172f, 0.19886692f, 
    0.13847694f, -0.05100719f, 0.02035424f, -0.01047459f, -0.12744892f, 0.02869626f, -0.18782485f, 0.02696306f, 
    -0.12292480f, -0.07433169f, 0.05618020f, -0.06213675f, -0.08301175f, -0.05376231f, 0.09835283f, 0.07028711f, 
    -0.15401763f, 0.16585800f, -0.40473554f, 0.17441276f, 0.26092276f, 0.05199130f, 0.04536258f, 0.12510908f, 
    -0.11318220f, 0.02516082f, -0.20607620f, 0.00767168f, 0.00338944f, -0.01628314f, -0.04932754f, 0.04509133f, 
    0.00668582f, -0.27157104f, 0.06476291f, 0.08907659f, 0.30423492f, -0.13343568f, 0.14979596f, -0.06254665f, 
    -0.08120233f, -0.08859431f, 0.04554813f, 0.07894876f, 0.22259346f, -0.02478518f, 0.03112480f, -0.00053465f, 
    -0.03380193f, -0.10893907f, -0.11925721f, 0.01515039f, 0.01506183f, 0.11983556f, 0.14710963f, 0.04741343f, 
    -0.17482017f, -0.20670483f, 0.21717778f, -0.00057187f, 0.04245397f, 0.00440639f, -0.08692802f, 0.22890379f, 
    -0.04059905f, -0.03163322f, -0.00849644f, 0.06983951f, 0.01090555f, 0.02777434f, 0.01383832f, -0.01962859f, 
    0.03447723f, 0.05029855f, -0.00336754f, -0.00354226f, 0.04541446f, -0.09165614f, -0.11457692f, 0.06686939f, 
    -0.00061904f, -0.02446331f, 0.06975568f, 0.01803808f, 0.05311584f, 0.02178567f, -0.10249630f, 0.01512063f, 
    0.05208952f, -0.10011032f, -0.06748827f, 0.04885713f, 0.03153473f, 0.07600915f, 0.07781003f, 0.07305812f, 
    0.08906691f, -0.04881215f, 0.11669922f, 0.10685555f, -0.14400125f, 0.01347316f, -0.02313766f, 0.03134415f, 
    -0.05222181f, -0.02473706f, 0.04644624f, -0.03492573f, -0.06954151f, 0.02231928f, -0.03077882f, -0.12605977f, 
    -0.09525488f, 0.06360149f, -0.14638421f, -0.11057039f, -0.19951008f, -0.23584841f, -0.04142011f, 0.19129395f, 
    -0.10604602f, 0.06268084f, 0.15683278f, -0.03492478f, 0.12625413f, -0.05768189f, -0.11608013f, -0.17068395f, 
    0.06840956f, 0.07670978f, -0.02414896f, -0.00865076f, 0.07754148f, -0.04090331f, 0.13858625f, 0.16275491f, 
    0.07439000f, 0.06384317f, 0.21042278f, 0.09160761f, 0.11485120f, -0.15406837f, -0.02920254f, 0.03530931f, 
    0.05008418f, -0.07701220f, -0.10224605f, 0.01903212f, -0.02982257f, 0.06035695f, 0.07537062f, 0.07824378f, 
    0.02393211f, 0.00702641f, 0.02968134f, -0.13692534f, 0.10411806f, -0.07372939f, 0.20243782f, 0.06742825f, 
    -0.12711483f, -0.03226618f, -0.03969051f, 0.00591363f, -0.08338042f, -0.16438316f, 0.03293164f, 0.03381357f, 
    -0.08544652f, 0.07160088f, -0.01649391f, 0.02884017f, 0.07215813f, 0.03161720f, -0.07847995f, -0.01779916f, 
    -0.03294587f, -0.08879182f, 0.13930963f, 0.17160574f, 0.10919324f, -0.06721778f, -0.03462096f, 0.06123016f, 
    0.05566209f, 0.13412809f, -0.05465582f, -0.01106698f, -0.15545289f, 0.12731045f, -0.05980566f, -0.04278527f, 
    -0.06383568f, 0.13610394f, -0.06601638f, 0.11697742f, -0.43684414f, -0.04618530f, -0.17230257f, -0.17346072f, 
    0.09577926f, -0.07046896f, -0.08102179f, -0.03843152f, -0.02501977f, 0.01846503f, -0.05894347f, 0.08847298f, 
    -0.04953345f, 0.07062986f, -0.01419532f, 0.05983591f, -0.04888941f, -0.12235049f, 0.05521955f, -0.00121140f, 
    0.13150603f, -0.03891366f, 0.19512914f, 0.09553101f, 0.02114456f, -0.03629181f, 0.07909799f, -0.03278234f, 
    0.11830971f, 0.06819855f, -0.05192757f, 0.00206934f, 0.01347874f, -0.00601781f, -0.00678587f, 0.06798345f, 
    0.06284367f, 0.12376273f, 0.07154942f, -0.10228903f, -0.06815068f, -0.10747603f, 0.10278921f, 0.04616212f, 
    -0.09494676f, -0.04178233f, -0.05288159f, 0.03087112f, 0.03350296f, 0.08732363f, -0.02833922f, -0.04860999f, 
    0.03729912f, -0.12809999f, -0.04106467f, -0.07927004f, -0.03717478f, -0.13249926f, -0.06165161f, -0.10750011f, 
    0.09106234f, -0.25182492f, -0.15857399f, -0.11352427f, 0.04570822f, -0.14707989f, -0.26279444f, -0.12806039f, 
    -0.00605462f, -0.09334290f, 0.01897600f, 0.05984380f, 0.01374743f, -0.07288852f, -0.05927192f, 0.01090675f, 
    0.00364385f, -0.01972567f, 0.04689106f, -0.05300494f, 0.40157983f, -0.10467976f, 0.25182435f, 0.21435821f, 
    -0.02604762f, -0.03961097f, 0.16285969f, -0.13064092f, 0.19025430f, -0.06368247f, -0.18661125f, 0.02381552f, 
    -0.01285311f, 0.02689063f, -0.01524563f, -0.00575185f, 0.04339384f, 0.02029424f, 0.03283259f, 0.06355989f, 
    -0.02014780f, -0.12835354f, 0.00465654f, -0.00361534f, 0.05006986f, 0.03918228f, 0.06403524f, -0.12160942f, 
    0.08915553f, 0.02718578f, -0.07421565f, 0.01621872f, -0.18068975f, 0.01090432f, 0.00501448f, 0.04236372f, 
    -0.07653530f, 0.02315951f, 0.03184479f, -0.06195336f, -0.21631300f, -0.05565782f, -0.22922418f, 0.05605498f, 
    0.11531883f, 0.15365598f, 0.11617814f, 0.08028835f, -0.17807893f, 0.10329644f, -0.06194253f, -0.11199310f, 
    0.00267956f, 0.11769246f, 0.06001904f, -0.07383246f, -0.05582056f, -0.00013455f, 0.01488919f, 0.03975949f, 
    0.14314929f, -0.06017990f, 0.16366510f, 0.08629196f, 0.06219400f, -0.02381493f, 0.11036650f, -0.05173884f, 
    0.10459393f, 0.03630995f, -0.00653555f, 0.04927484f, -0.06884126f, 0.02628445f, 0.03906354f, -0.00292737f, 
    -0.00548333f, 0.05264149f, 0.03569253f, -0.11168881f, -0.26448399f, 0.29529443f, -0.01451647f, 0.27456045f, 
    0.02590938f, 0.10459921f, 0.08836577f, -0.04938907f, 0.10161880f, -0.01656148f, -0.08710574f, -0.00456691f, 
    0.02476127f, 0.02637631f, 0.07762552f, 0.01166127f, -0.12204548f, -0.01299877f, 0.08196326f, 0.16978015f, 
    -0.63379920f, -0.21288484f, -0.29564527f, 0.14858329f, -0.35621545f, -0.01465592f, -0.00293961f, -0.04405209f, 
    0.11066285f, 0.01105200f, -0.07181027f, -0.09387343f, 0.06760996f, -0.05636664f, 0.00435901f, 0.00765157f, 
    -0.01126282f, -0.09882521f, -0.06818151f, -0.00871975f, 0.09602198f, -0.18581432f, -0.21116006f, -0.03142227f, 
    -0.03931751f, 0.00207840f, -0.10626922f, -0.02859130f, -0.04060711f, -0.06887785f, 0.07239819f, 0.03433462f, 
    -0.08201985f, -0.04112389f, -0.01143388f, 0.04745848f, -0.02956767f, 0.05759608f, 0.03042064f, -0.16601039f, 
    -0.00847608f, 0.00904892f, -0.19141172f, 0.10914391f, 0.08246737f, -0.07009631f, 0.04383121f, 0.03837789f, 
    -0.00447536f, -0.07215009f, 0.02528273f, 0.06718381f, 0.03943987f, -0.06657238f, -0.01023419f, 0.03225977f, 
    -0.08189319f, -0.08578493f, -0.03366620f, -0.10416397f, 0.39458555f, -0.04933849f, 0.36791581f, -0.02067013f, 
    -0.32318538f, 0.00876557f, 0.00434494f, -0.17345481f, 0.07225849f, -0.05862269f, -0.08823580f, 0.05445688f, 
    0.04470120f, -0.03741144f, -0.02783776f, 0.03232298f, 0.19375578f, 0.06035819f, 0.08161134f, 0.04528553f, 
    -0.13463055f, 0.04634473f, -0.02999359f, 0.07944059f, -0.10627047f, 0.05350846f, -0.02876365f, 0.09207529f, 
    -0.03166769f, -0.00968973f, -0.00961501f, -0.00110757f, -0.09735762f, 0.00387364f, 0.00811932f, -0.00729631f, 
    -0.09894191f, -0.01827663f, -0.10699318f, -0.12323963f, -0.01453758f, -0.11176769f, -0.08426420f, -0.08638205f, 
    -0.17995766f, 0.11615240f, 0.21799935f, 0.04968469f, -0.16864170f, 0.00702808f, -0.05040061f, -0.07485956f, 
    0.07838755f, 0.10650215f, 0.01695436f, -0.10722674f, 0.09973852f, 0.04682399f, 0.07097375f, 0.09185075f, 
    0.02621075f, -0.09995174f, -0.12338492f, 0.31328171f, 0.10776501f, -0.05574983f, 0.16080123f, 0.00612979f, 
    0.06060718f, 0.05012095f, -0.07971157f, 0.06893168f, -0.01141514f, 0.03633023f, 0.12026703f, -0.07627770f, 
    -0.04126805f, 0.00042024f, -0.07639781f, -0.10851052f, 0.13570988f, 0.02660224f, 0.13105583f, 0.02711239f, 
    0.03507069f, -0.14457345f, -0.00327944f, -0.08358902f, 0.03309083f, -0.04355363f, -0.07117914f, -0.10103821f, 
    -0.00188426f, -0.14226550f, -0.04248497f, 0.02526869f, -0.03518806f, -0.06013279f, 0.04102096f, 0.04627041f, 
    0.07563874f, 0.14744169f, 0.07977132f, 0.03670735f, -0.18195808f, -0.04691213f, 0.02618628f, 0.09140185f, 
    -0.10059162f, -0.01263827f, -0.10694900f, 0.02980510f, -0.07343800f, 0.02278223f, -0.00772348f, -0.05847083f, 
    -0.08269290f, 0.01781571f, 0.00341698f, -0.01099202f, 0.04171159f, -0.26178497f, -0.02023644f, -0.16151233f, 
    0.13919364f, 0.00568212f, 0.06015838f, -0.12234559f, 0.00599953f, -0.06356990f, -0.08385945f, 0.02538339f, 
    0.08257915f, 0.10129485f, 0.01786130f, 0.05652209f, 0.07646883f, -0.03982273f, 0.04015461f, 0.00331201f, 
    -0.46932113f, -0.15165737f, -0.19372991f, -0.03418004f, 0.29154837f, -0.04210509f, 0.15996243f, 0.10205855f, 
    -0.11575198f, 0.19676878f, -0.05649487f, 0.15480436f, 0.05407289f, -0.00577140f, -0.07235908f, 0.01639147f, 
    0.07097372f, 0.06688691f, 0.07995965f, -0.01297289f, 0.21944219f, -0.15703176f, 0.30985582f, -0.07256623f, 
    -0.00546440f, 0.10964514f, 0.12283794f, 0.02096025f, 0.05413340f, -0.07475904f, 0.11262696f, -0.01481804f, 
    0.10657838f, 0.02544633f, 0.08908325f, -0.00779628f, 0.03931458f, -0.11145419f, -0.08365375f, -0.21309641f, 
    -0.09473246f, 0.02663100f, -0.02511018f, 0.17563421f, -0.11923744f, -0.19230013f, -0.00470885f, 0.11696092f, 
    -0.03187805f, 0.00473647f, -0.07445458f, -0.02533215f, -0.04946050f, 0.05651101f, 0.08570481f, -0.04419197f, 
    -0.08986885f, 0.06043163f, -0.19296972f, -0.24596483f, 0.05892566f, -0.22649452f, 0.09970393f, 0.02742303f, 
    0.00782551f, -0.14322840f, -0.14598569f, -0.00560459f, -0.05636339f, -0.06362665f, 0.05211926f, 0.03049647f, 
    -0.04504029f, -0.06409376f, 0.00527079f, 0.00382857f, -0.02007345f, 0.03013736f, 0.06819615f, -0.10639486f, 
    0.27215219f, -0.02788135f, -0.12434410f, 0.19371386f, 0.12201815f, -0.08758919f, 0.23603462f, -0.06012858f, 
    0.06838764f, -0.06047846f, -0.10682476f, 0.10504594f, 0.04672850f, 0.03172866f, -0.05505902f, -0.03005104f, 
    -0.09700543f, 0.07872558f, -0.06681500f, -0.02155955f, 0.02534730f, -0.13016188f, 0.34510878f, -0.47801933f, 
    0.43053946f, 0.19705799f, 0.14872690f, 0.07419209f, 0.06844790f, 0.03508891f, -0.06142037f, -0.03022385f, 
    0.01960282f, 0.03309313f, -0.05185146f, 0.08559383f, 0.17840168f, 0.04623770f, -0.30629477f, 0.09507228f, 
    0.23871773f, -0.20255318f, 0.04422666f, 0.21970917f, 0.09068439f, -0.03279712f, -0.06026029f, -0.12338047f, 
    -0.04900732f, -0.07440235f, 0.00882255f, 0.07881188f, -0.03898141f, 0.09542970f, 0.04482500f, -0.06957804f, 
    -0.12202538f, 0.03076894f, 0.05762190f, 0.14210977f, -0.03633673f, -0.08099937f, 0.17987591f, 0.01356899f, 
    -0.20671637f, 0.02615535f, -0.12895671f, -0.05939158f, -0.02901790f, -0.07222163f, 0.00301492f, 0.03041947f, 
    -0.01816003f, -0.01260689f, 0.02441646f, 0.09739112f, -0.02202300f, 0.12789638f, 0.09963579f, -0.02231197f, 
    0.59062713f, 0.02799913f, 0.48564309f, 0.05750684f, -0.24528825f, -0.04950918f, -0.06037261f, -0.13376340f, 
    -0.02571003f, -0.23091890f, -0.09978850f, 0.01706836f, 0.03514462f, -0.02562115f, -0.06921558f, -0.08770031f, 
    0.03949120f, 0.04313704f, -0.02498954f, 0.15641946f, -0.32504308f, -0.12894550f, -0.16625653f, 0.27951297f, 
    -0.40035853f, 0.10166221f, -0.15108858f, 0.00080847f, -0.13053815f, 0.07984842f, -0.01519894f, -0.07590163f, 
    0.03216547f, 0.09187343f, 0.05895290f, -0.01360431f, -0.02395094f, 0.11527849f, 0.02495433f, 0.06588772f, 
    -0.08981390f, -0.11399018f, -0.13147572f, -0.17447042f, -0.33305922f, -0.09705275f, 0.01868956f, 0.07336412f, 
    -0.04051448f, -0.01144554f, 0.00658522f, -0.01521927f, 0.10468673f, 0.05151017f, -0.00368275f, 0.06173262f, 
    0.03620267f, 0.04037881f, 0.02721892f, 0.10721360f, 0.06118650f, -0.32763028f, -0.37904468f, -0.50887257f, 
    0.01406556f, -0.14909537f, -0.09907442f, 0.04402277f, -0.07523793f, -0.04730484f, -0.00211637f, -0.00834404f, 
    0.04550968f, -0.13038370f, -0.03492386f, 0.06609052f, -0.01731724f, -0.16775990f, 0.08854694f, 0.01364344f, 
    -0.72209692f, -0.11316255f, -0.45654020f, 0.48834032f, -0.22090741f, 0.00142813f, 0.24017224f, -0.04398508f, 
    0.26403031f, -0.03751410f, -0.12607338f, -0.03877240f, -0.04839671f, 0.05270247f, 0.06428510f, 0.02069065f, 
    -0.02848628f, 0.12179875f, -0.04076934f, 0.13977991f, 0.16588983f, 0.14684758f, 0.00286882f, 0.20977458f, 
    -0.08932412f, -0.02921225f, 0.03238602f, -0.02925139f, 0.11082640f, -0.01054706f, -0.07665169f, 0.02732732f, 
    -0.00265388f, -0.05529297f, -0.06406265f, 0.12736046f, -0.00763659f, 0.04493686f, -0.00247807f, 0.07071988f, 
    0.11779144f, -0.15263782f, 0.19273396f, -0.00916625f, 0.13834918f, 0.11618677f, -0.00283244f, -0.02162814f, 
    0.05127204f, -0.17643180f, 0.03433223f, -0.06738324f, -0.03559666f, 0.01057548f, 0.07447115f, 0.02133785f, 
    0.00234705f, 0.03287396f, -0.01402604f, -0.15208429f, 0.08635686f, -0.28121394f, 0.16371167f, 0.25414965f, 
    0.06224484f, 0.03375551f, 0.04750726f, -0.09084707f, 0.06252907f, -0.14610021f, -0.00631068f, -0.14191893f, 
    0.05401091f, -0.02000970f, -0.02235957f, 0.01619029f, 0.01379825f, 0.03996221f, 0.04908195f, -0.06502170f, 
    0.03214018f, 0.01528835f, -0.04674285f, 0.13261425f, 0.07033487f, -0.07782584f, 0.07345143f, -0.01324372f, 
    0.01711186f, 0.07678036f, -0.14686352f, -0.00535995f, 0.01849210f, 0.07392874f, -0.12224146f, -0.00994097f, 
    0.06457012f, 0.06599719f, -0.17317589f, -0.10942582f, -0.54193771f, -0.46848843f, 0.05167908f, 0.25838134f, 
    -0.38827139f, -0.08336984f, -0.00189169f, -0.01714489f, 0.07277474f, -0.00496172f, -0.13739748f, -0.10011561f, 
    -0.01736465f, -0.03427682f, 0.04073424f, 0.04593585f, -0.01338147f, 0.26543763f, 0.04868374f, -0.16688249f, 
    0.11806855f, -0.07179584f, 0.10083153f, 0.07094957f, 0.00261375f, -0.06060903f, 0.03694171f, -0.00084537f, 
    0.10985424f, -0.06749520f, -0.03131404f, -0.09339467f, 0.00867193f, 0.02326639f, -0.04574314f, -0.01304565f, 
    -0.03049407f, 0.05263718f, 0.00051805f, -0.06675733f, -0.14888155f, -0.33448416f, 0.05215579f, -0.07843641f, 
    0.17602730f, 0.14425847f, -0.02742338f, -0.00659567f, -0.01513615f, -0.06918906f, 0.00318990f, -0.08021730f, 
    -0.04773536f, 0.06127845f, -0.17627983f, -0.00413365f, 0.03599258f, -0.11514609f, -0.10515486f, 0.02507968f, 
    -0.06098455f, -0.28799760f, 0.01949782f, -0.04545377f, 0.05317514f, 0.13914952f, 0.10151533f, 0.00719958f, 
    -0.07889272f, 0.12931305f, -0.00506641f, -0.01671918f, 0.07179586f, 0.10140938f, -0.02075284f, 0.03924377f, 
    0.03950133f, 0.06162770f, -0.00882320f, 0.06007403f, 0.21823442f, 0.14363140f, 0.31289530f, 0.00771872f, 
    -0.14566714f, -0.06121735f, 0.00406685f, -0.04242312f, 0.04791949f, -0.09381692f, -0.09676710f, -0.04552494f, 
    0.05079070f, -0.03578626f, -0.03924523f, 0.03339663f, -0.05121126f, -0.09401827f, -0.00473023f, 0.08223937f, 
    -0.15813307f, 0.04649058f, -0.09488375f, 0.08036246f, -0.07776710f, 0.01081658f, -0.01885255f, 0.07833133f, 
    -0.15317217f, 0.03849830f, -0.03949811f, -0.02179812f, 0.03580584f, 0.09783414f, 0.10388427f, 0.03477469f, 
    0.05790998f, 0.08921350f, 0.01984355f, 0.07943725f, -0.14957136f, -0.08535627f, -0.14605594f, 0.20175117f, 
    -0.01935222f, -0.01408300f, -0.07301636f, 0.07934883f, -0.09850634f, 0.06865257f, -0.04158521f, -0.03523944f, 
    -0.00553817f, -0.06421743f, -0.10167810f, -0.02936589f, -0.07427093f, -0.08387360f, -0.09936815f, -0.20155010f, 
    -0.13719845f, -0.25579628f, 0.06425479f, -0.17509976f, -0.51407397f, -0.01759314f, 0.05918809f, -0.15605357f, 
    -0.06113902f, -0.05697795f, -0.02199149f, -0.02859117f, 0.13590366f, 0.03614070f, -0.04826820f, -0.03175720f, 
    0.05984880f, 0.01340626f, 0.01134041f, 0.03283665f, -0.33319378f, 0.02279311f, -0.26958388f, 0.18785043f, 
    -0.15951163f, 0.07492389f, 0.05458246f, -0.00597456f, -0.06788245f, 0.00518572f, -0.01084286f, -0.08939641f, 
    -0.00357509f, 0.05096384f, -0.07146119f, -0.01061067f, -0.02487425f, -0.01084951f, -0.03881525f, 0.00923482f, 
    -0.29790202f, -0.44529042f, -0.20514892f, 0.33504164f, -0.06193857f, 0.05167612f, -0.17893040f, 0.21283036f, 
    -0.22021769f, 0.01226654f, -0.02006762f, -0.00401542f, 0.03194731f, 0.13007760f, 0.13330100f, 0.06473987f, 
    0.03061141f, 0.09388719f, 0.16718279f, 0.03213370f, -0.29412764f, -0.07924989f, -0.00388861f, 0.07863183f, 
    0.10587564f, 0.02135190f, 0.17268115f, -0.18484867f, 0.12670565f, 0.05095302f, -0.17129661f, 0.06882803f, 
    -0.00822807f, -0.00741982f, 0.01162557f, 0.07383293f, 0.00311423f, -0.00285756f, 0.07721223f, -0.07764632f, 
    -0.06661055f, -0.22028017f, -0.13516389f, -0.23230368f, 0.23093997f, 0.00082559f, 0.13771215f, -0.05957725f, 
    0.04695319f, 0.03501519f, -0.10924225f, 0.07822281f, 0.04025103f, 0.10357638f, 0.02993410f, -0.02188188f, 
    0.02835187f, 0.02737024f, 0.01572462f, 0.03707043f, 0.02645330f, -0.52636945f, 0.35696107f, 0.09717157f, 
    0.25690311f, -0.13806695f, -0.23968516f, -0.09468570f, 0.12835376f, -0.14004736f, 0.02942990f, -0.11453132f, 
    0.09093015f, -0.03482043f, -0.02012393f, 0.01680655f, -0.00172150f, 0.07008108f, 0.21358728f, -0.01152721f, 
    0.05723803f, -0.40800306f, 0.01551237f, -0.05169832f, 0.01351923f, -0.12210097f, -0.18701814f, -0.08455745f, 
    0.03463243f, -0.22473820f, -0.04426908f, -0.01031488f, 0.07512621f, -0.05283368f, -0.02556265f, 0.16940442f, 
    -0.02084305f, 0.01545782f, 0.13183022f, -0.06035877f, -0.11145331f, 0.07605108f, -0.10415930f, 0.19175872f, 
    0.03291534f, -0.03578262f, 0.02621971f, 0.07395316f, -0.01657815f, 0.06756768f, -0.11739158f, -0.04687983f, 
    -0.06245645f, 0.14471938f, -0.12529036f, -0.02465553f, -0.04766352f, 0.23280931f, -0.07418402f, -0.12631677f, 
    0.20658417f, -0.03341462f, 0.18686490f, -0.13971724f, 0.07276588f, 0.12573773f, 0.14438558f, -0.07869463f, 
    0.08741181f, -0.15641952f, -0.02632418f, 0.01604022f, 0.04012753f, 0.07055709f, 0.02401872f, -0.03982446f, 
    -0.03262323f, -0.03351503f, -0.21473923f, 0.04201965f, 0.07020587f, -0.16687261f, -0.03582781f, -0.30606964f, 
    -0.03355534f, 0.00499043f, -0.16929536f, -0.15945481f, 0.09795585f, -0.04315767f, 0.01607097f, 0.02080809f, 
    0.08837429f, -0.04497338f, -0.11657862f, 0.03067232f, 0.01545672f, -0.01668658f, -0.00601640f, -0.07476071f, 
    -0.17630325f, -0.04464410f, -0.13165429f, 0.13849609f, -0.02365982f, 0.00261876f, -0.00368223f, 0.00379976f, 
    -0.08224865f, 0.01305657f, -0.03306894f, -0.00504277f, -0.08607318f, -0.04286657f, -0.03756547f, -0.02290167f, 
    -0.12702861f, -0.04835106f, -0.04624595f, -0.10574273f, -0.12544723f, 0.01636849f, 0.07635418f, 0.14689520f, 
    -0.13385262f, 0.04182109f, -0.02328181f, 0.03461419f, -0.03018070f, 0.15455069f, -0.07474268f, -0.08603160f, 
    0.05566790f, 0.05469878f, -0.06151218f, -0.03633350f, 0.01861048f, 0.11623304f, 0.07675022f, -0.05274926f, 
    -0.03081429f, -0.06602535f, -0.10301920f, 0.28970930f, -0.27809393f, -0.09134991f, -0.25912711f, -0.05618383f, 
    -0.03772356f, 0.10812866f, -0.03838095f, -0.09472023f, -0.08125807f, -0.09247563f, -0.09279200f, 0.03694608f, 
    0.02491510f, 0.08159550f, 0.04099317f, -0.07246885f, -0.15717869f, 0.04937929f, -0.18940873f, -0.01517531f, 
    0.12305654f, 0.02184278f, 0.02599208f, -0.14088298f, 0.01136529f, 0.04268003f, 0.08043086f, 0.09993347f, 
    0.04169390f, -0.06810118f, -0.00599475f, 0.04409933f, -0.05792955f, -0.07421680f, -0.03756583f, -0.02737141f, 
    0.44330069f, -0.11506521f, 0.26255754f, 0.05827745f, 0.01874495f, 0.06118552f, -0.08481494f, -0.20687446f, 
    0.08477938f, -0.02089281f, -0.07303468f, 0.02462689f, -0.00164128f, 0.01835608f, 0.01726350f, -0.04743314f, 
    -0.02437642f, -0.15710248f, -0.01664590f, 0.15658304f, -0.22181693f, -0.08514060f, -0.14974067f, 0.19286905f, 
    0.04798792f, -0.00223532f, -0.03520613f, 0.01441307f, -0.01647236f, 0.04994833f, -0.05586606f, -0.02027474f, 
    -0.13307387f, -0.12997201f, -0.00817973f, -0.04738771f, -0.08780205f, -0.09320269f, -0.09826555f, -0.20917386f, 
    -0.23993397f, 0.02079191f, -0.26293302f, 0.11716935f, 0.03213155f, -0.04175657f, 0.18648426f, 0.01590501f, 
    0.08978847f, 0.09403770f, -0.13424596f, -0.05823173f, 0.08823363f, 0.09794365f, -0.07102827f, 0.02197384f, 
    0.02250947f, -0.04127975f, -0.04090304f, 0.08160831f, 0.34135914f, -0.07713651f, 0.31915748f, 0.08193707f, 
    0.09081444f, -0.06770786f, 0.05048243f, -0.04464296f, 0.15485777f, -0.08434559f, -0.08453696f, 0.05566399f, 
    -0.03109340f, 0.02019014f, 0.09032349f, -0.05481267f, 0.04133611f, -0.00397931f, 0.14075817f, -0.03377807f, 
    0.06972694f, -0.57041085f, 0.36391094f, -0.29791984f, 0.29965758f, 0.07891457f, 0.07207204f, 0.03796255f, 
    0.01344037f, -0.06974237f, -0.02836069f, 0.02072330f, 0.10146892f, 0.06855474f, 0.02935515f, -0.04729058f, 
    0.15624122f, 0.02538549f, -0.00661032f, 0.08106611f, 0.05236571f, 0.05562720f, -0.07652698f, 0.06503084f, 
    0.02205671f, 0.04146000f, 0.03253680f, -0.03995366f, 0.00700196f, -0.02827774f, -0.04790384f, -0.00201675f, 
    0.00957803f, -0.06214168f, -0.03516245f, 0.11381166f, 0.03907453f, 0.00765861f, 0.05493040f, -0.06208124f, 
    -0.03269723f, 0.06817211f, -0.06879929f, 0.10192677f, 0.03910987f, -0.23667553f, -0.01220814f, -0.03768803f, 
    -0.00189244f, 0.05546822f, 0.11259758f, 0.04645503f, 0.02604811f, -0.14491577f, 0.01016670f, 0.08541483f, 
    0.07001663f, 0.00008710f, 0.19942360f, -0.03856767f, -0.03951541f, -0.25312245f, -0.21493141f, -0.13038759f, 
    -0.04733205f, -0.00444050f, -0.27487853f, 0.01133357f, -0.20382692f, -0.13486755f, 0.04813177f, 0.03228622f, 
    -0.01813531f, -0.01956728f, -0.07582150f, 0.00320227f, -0.05950993f, 0.01165860f, 0.04843834f, -0.06930383f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11536719f, 0.12438574f, 0.02069241f, -0.05308075f, -0.01076915f, 0.00386413f, 0.01549788f, -0.07070256f, 
    0.04371008f, 0.03649853f, -0.01708756f, -0.01238310f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
