#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24587005f, -0.69408143f, -0.50466156f, 0.26019621f, -0.21898662f, -0.28498417f, 1.02164376f, 0.27815375f, 
    -0.62824517f, 0.56968653f, -0.14101990f, 0.35726044f, 0.14722510f, 0.48562595f, 0.44255400f, -0.23304318f, 
    -0.14973778f, -0.24458563f, -0.00305824f, -0.19949609f, -0.00782193f, 0.15506600f, -0.01179151f, -0.09746786f, 
    0.06230550f, 0.37685373f, 0.58827180f, 0.18275522f, 0.16806683f, 0.75452000f, 0.71000522f, 0.26463142f, 
    -0.57340813f, 0.06504601f, 0.25015566f, 0.20051289f, -0.31374654f, -0.06954072f, 0.11060227f, -0.14126599f, 
    -0.26982859f, -0.32337853f, -0.02869216f, -0.10475200f, 0.00205989f, -0.37919649f, -0.04993227f, -0.42622566f, 
    0.18583280f, -0.30374643f, -0.82478088f, -1.04381669f, -0.14776783f, 0.63898951f, 0.02830803f, 0.44864807f, 
    0.16835700f, -0.00044102f, 0.44224113f, 0.04811274f, 0.10437290f, 0.04857462f, -0.38678679f, 0.69806200f, 
    0.41135666f, 0.19945420f, 0.09871246f, -0.25327402f, 0.04060963f, 0.04562234f, 0.25157589f, 0.10929445f, 
    0.05343379f, -0.06035350f, 0.09438881f, -0.76981676f, 0.44905084f, 0.06551339f, 0.34744319f, 0.26019886f, 
    0.11382017f, 0.63785267f, -0.17751451f, -0.73910975f, -0.25552571f, -0.36858463f, 0.07413258f, 0.41333711f, 
    0.49509108f, 0.61752945f, 0.19806151f, -0.00399565f, 0.13347410f, 0.21917756f, 0.26465657f, 0.25983229f, 
    0.11512564f, -0.01169803f, 0.05208771f, -0.08598605f, -0.81154048f, 0.43239883f, 0.68569463f, -0.77200270f, 
    -0.61369818f, 0.74234390f, 0.22366352f, 0.42119464f, 0.50871915f, 0.11548022f, 0.24377505f, -0.19843209f, 
    0.00658999f, 0.03676210f, 0.21797135f, 0.01691099f, -0.10432108f, -0.19459210f, -0.05853696f, 0.16370107f, 
    -0.33221555f, -0.19101459f, -0.09619614f, 0.00026699f, 0.08501586f, -0.23193179f, 0.52822584f, -0.40716144f, 
    -0.64653593f, -0.77614462f, 0.94428951f, -0.25752553f, -0.20822625f, -0.03166720f, 0.15282221f, 0.39491665f, 
    -0.51981670f, 0.19415969f, 0.20277596f, -0.05331679f, 0.12850714f, -0.14085974f, 0.18403366f, -0.29455209f, 
    -0.15269780f, -0.14195225f, 0.02115740f, 0.38595530f, 0.29682803f, -0.22594887f, -0.10737980f, -0.17817022f, 
    0.47414446f, -0.56108522f, 0.60786706f, -0.69206470f, -0.12844993f, 0.34822509f, 0.54894739f, -0.17488146f, 
    -0.10431191f, 0.12059572f, 0.14089654f, -0.30865693f, 0.22762288f, 0.32596987f, -0.51902467f, 0.27142638f, 
    0.20737123f, 0.31726807f, -0.06969813f, 0.15346372f, -0.08570126f, -0.22114554f, -0.00093960f, -0.22514823f, 
    -0.39327663f, -0.30326244f, -0.09200045f, -0.64015371f, 0.43099695f, 0.63111937f, -0.19972754f, 0.48357120f, 
    0.07623209f, 0.21725531f, -0.14632742f, -0.07275531f, -0.24435250f, 0.01981260f, 0.10965337f, -0.14546098f, 
    0.05134225f, -0.14431781f, -0.13568184f, -0.11465118f, 0.11630429f, -0.02851326f, 0.60911393f, 0.06853075f, 
    -0.85093164f, 0.73501486f, 0.60331535f, -0.56194758f, -0.22811431f, -0.59159070f, 0.68698651f, 0.48375231f, 
    -0.46400779f, -0.40593335f, -0.30662608f, 0.43889406f, -0.03049450f, 0.02271496f, -0.02382166f, -0.31538779f, 
    -0.15791397f, -0.45442447f, -0.15703462f, 0.03630170f, 0.26498941f, 0.08380065f, 0.01646385f, 0.15275703f, 
    -0.13561299f, -1.41649473f, 0.44324255f, 0.67094874f, -0.61843699f, 0.27958894f, 0.66597295f, 0.31140792f, 
    0.53949690f, 0.45285326f, -0.32075465f, -0.26973724f, 0.00686763f, -0.20516013f, 0.01495694f, -0.20219275f, 
    0.17045155f, -0.39112431f, -0.13696189f, -0.21655673f, 0.12386159f, -0.05927250f, 0.13814576f, -0.00013457f, 
    0.15305464f, 0.06866105f, 0.41324708f, -0.40187120f, -0.72969043f, -0.56862479f, -0.51318651f, -0.57551414f, 
    0.67228478f, 0.49553767f, 0.17593567f, 0.34806192f, 0.17731859f, -0.21629828f, -0.12170433f, -0.40900895f, 
    -0.09336194f, 0.09382106f, 0.14948019f, -0.06702529f, 0.08574340f, -0.03084834f, -0.19131368f, -0.04164736f, 
    0.23214459f, 0.03169236f, 0.22873926f, -0.55933177f, -0.45950675f, -0.44210774f, -0.48981488f, -0.49029467f, 
    0.25587070f, 0.78055114f, 0.33428562f, -0.00427066f, 0.58172858f, -0.15189804f, 0.04459054f, -0.24452636f, 
    -0.17335624f, -0.46828479f, 0.04579808f, 0.05573676f, 0.03534595f, 0.00673719f, 0.14155555f, 0.18865800f, 
    -0.06234456f, -0.32046854f, -0.44533190f, 0.02853023f, 0.54573923f, 0.48560050f, -0.28833207f, -0.46522972f, 
    -0.42895845f, -0.45191661f, -0.33434945f, -0.41023132f, 0.20014921f, -0.15064453f, -0.06404149f, 0.09783652f, 
    0.08961024f, 0.10526754f, 0.22543079f, 0.37806106f, -0.41398600f, -0.43920329f, 0.04174760f, 0.19676155f, 
    0.31682712f, 0.34036109f, -0.01967575f, -0.28001785f, 0.25692415f, 0.01192360f, -1.09410107f, -0.10684013f, 
    0.15263408f, -0.43224779f, 0.05628936f, 0.50850224f, 0.62035853f, -0.27907115f, -0.19921687f, -0.03251754f, 
    -0.05148568f, -0.19303399f, 0.37743378f, -0.30732512f, -0.12959576f, -0.16618882f, -0.15173694f, -0.25983867f, 
    -0.01932272f, 0.08944460f, 0.21238509f, -0.00425114f, 0.01201572f, 0.16775614f, -0.00398688f, -0.08134199f, 
    -0.09466255f, 0.42520598f, 0.65032810f, 0.63487613f, 0.46016151f, -0.09121872f, -0.01568956f, -0.62696815f, 
    0.25983220f, 0.33636397f, -0.34818667f, -0.20210557f, -0.02919979f, 0.21943127f, -0.12487163f, 0.28453201f, 
    0.05532815f, -0.29296607f, 0.46040514f, 0.10785003f, -0.40051323f, 0.22070490f, 0.23265551f, -0.08804564f, 
    -0.41760954f, -0.32479435f, -0.74701267f, -0.59964919f, -0.15504940f, -0.07583796f, -0.35452610f, -0.53139335f, 
    -0.08918484f, 0.37183124f, -0.25544369f, 0.45902410f, 0.13702461f, -0.00642721f, 0.16556561f, 0.18979143f, 
    0.09011534f, 0.13357580f, 0.27951294f, -0.03526193f, 0.31497774f, -0.18527380f, -0.11830404f, -0.07012624f, 
    -0.54342514f, 1.23449790f, -0.46421379f, -0.80862445f, 0.46363023f, 0.44121721f, -0.19224805f, -0.75653028f, 
    -0.35420549f, -0.57530791f, 0.22682741f, 0.21628736f, -0.22243296f, 0.01675418f, -0.05710061f, -0.30309448f, 
    0.20728572f, -0.10981216f, -0.27278855f, -0.03124602f, 0.01640923f, 0.00888279f, 0.17579624f, 0.01284463f, 
    0.25408819f, 0.78188437f, 0.65187871f, 0.28140688f, 0.38437802f, -0.20569438f, -0.68165070f, -0.66238666f, 
    -0.22776116f, -0.19233817f, 0.00581531f, 0.27844381f, -0.11680499f, 0.02590345f, -0.16401899f, 0.24652988f, 
    0.02419029f, -0.06179453f, -0.00138699f, -0.08520012f, 0.40391764f, 0.06494951f, 0.33131245f, -0.08014550f, 
    -0.06225618f, 0.07503988f, 0.43818039f, 0.63916761f, 0.81415975f, -0.16161875f, -1.08503771f, -0.16169252f, 
    -0.55834889f, 0.45308819f, -0.08509990f, 0.12193885f, 0.41694525f, 0.17061949f, -0.09414610f, 0.17936994f, 
    0.01690776f, -0.38557258f, 0.13749921f, -0.05005383f, 0.06774295f, 0.10479329f, -0.09014947f, -0.06361961f, 
    0.01112783f, 0.26522440f, 0.17647943f, 0.67897928f, 0.29116556f, 0.01876629f, -0.06441417f, 0.38666964f, 
    -0.78802764f, 0.55546254f, -0.34267700f, -0.27499989f, -0.12936835f, -0.07790511f, -0.29453927f, -0.32734972f, 
    -0.10072288f, -0.38087577f, 0.13079205f, -0.30222264f, -0.41113728f, 0.09546893f, -0.24784978f, -0.37842998f, 
    -0.03429972f, -0.29819253f, 0.29205453f, -0.36557662f, 0.68845701f, -0.71844065f, -0.38645038f, -0.01189456f, 
    0.94633806f, 0.79250216f, 0.56464744f, 0.32131496f, 0.56033778f, 0.28754932f, -0.29376006f, 0.17237742f, 
    -0.24275406f, 0.12126445f, 0.08196325f, -0.08388414f, -0.32832438f, 0.12341839f, 0.07059651f, -0.04173443f, 
    0.07190277f, -0.04833140f, 0.10878839f, -0.11128764f, -0.17060602f, -0.70433593f, -0.33170727f, -0.22018600f, 
    -0.10458616f, -0.14992099f, -0.77752131f, -0.40804315f, -0.41579312f, -0.30884060f, -0.32244003f, -0.31517568f, 
    0.00211316f, 0.24957328f, -0.11012170f, -0.18067592f, 0.08341844f, -0.38860980f, 0.11401717f, -0.54674214f, 
    -0.58432889f, -0.23416530f, 0.24509823f, -0.00644598f, 0.23213807f, -0.05734093f, 0.20167874f, -0.15386477f, 
    0.69470519f, 0.81557304f, -0.60382396f, 0.19793339f, -0.41152287f, 0.16000263f, 0.36975655f, 0.27412149f, 
    -0.26832885f, 0.05791106f, 0.24552472f, -0.35442111f, 0.10970510f, 0.05156434f, -0.27977127f, -0.11877539f, 
    0.18300211f, 0.10811576f, 0.26012081f, 0.07694189f, -0.01088939f, -0.13954996f, -0.43356287f, 1.01434577f, 
    0.68012857f, 0.48765993f, -0.57854676f, -0.66353911f, -0.18372299f, -0.70848972f, -0.01712659f, -0.39793697f, 
    0.29088095f, 0.03784725f, -0.03575011f, 0.17087525f, 0.07058411f, -0.09705225f, -0.31322041f, -0.06822473f, 
    -0.09503154f, -0.25367069f, -0.27900282f, -0.13736893f, 0.14946151f, 0.22147344f, -0.36140242f, 0.04290296f, 
    -0.46723396f, -0.58745819f, 0.46730849f, -0.52807391f, -0.48688868f, 0.55404133f, -0.58695477f, 0.14642963f, 
    -0.43338770f, -0.32334974f, -0.15375122f, -0.32966834f, 0.08673777f, 0.05020573f, -0.17872439f, 0.03826635f, 
    0.33580694f, -0.08293835f, 0.27868518f, 0.39268404f, -0.10041035f, -0.16651538f, 0.17594950f, 0.07131835f, 
    0.06252261f, 1.01667607f, 0.12354297f, -0.62239867f, 0.82075340f, -0.31646115f, 0.31765091f, 0.26938409f, 
    0.17890088f, 0.14982502f, 0.47902954f, -0.17104846f, 0.09169351f, 0.24848425f, -0.52061158f, 0.06171259f, 
    -0.06088771f, -0.11304888f, -0.17857461f, -0.14689310f, 0.27205086f, -0.03998168f, -0.14252518f, 0.08046556f, 
    0.00227117f, -0.36136273f, 0.62273097f, -0.30340403f, 0.93158942f, -0.00097308f, 0.01397649f, -0.37982926f, 
    0.14836718f, -0.84468895f, -0.51113218f, -0.43372974f, 0.25229618f, -0.03051647f, 0.10045835f, 0.26584077f, 
    -0.25154352f, -0.29092750f, -0.18754245f, -0.28823823f, -0.05426070f, -0.06039784f, -0.20115899f, 0.12514348f, 
    0.06554294f, -0.00490773f, 0.13391879f, -0.90626538f, -0.20557888f, -0.19989133f, -0.23257820f, 0.35714468f, 
    0.35995787f, 0.89041960f, 0.30613449f, 0.26429760f, 0.41035601f, 0.13868810f, -0.18619289f, 0.06958614f, 
    -0.37341052f, -0.13539127f, 0.31712365f, -0.02760384f, 0.17817898f, -0.21042514f, -0.05248517f, 0.13923024f, 
    -0.25921735f, 0.06355680f, 0.26200578f, 0.15602551f, -0.12408537f, 0.71660459f, 0.57991296f, 0.87746477f, 
    0.25395969f, 0.01453466f, 0.51146084f, -0.49448764f, 0.17199583f, 0.34559745f, -0.15395495f, 0.13922378f, 
    0.09607496f, 0.09884681f, -0.40953746f, -0.09818443f, 0.10345574f, 0.26773107f, 0.06466139f, -0.20841286f, 
    0.10925210f, -0.08417058f, -0.14601725f, -0.28251281f, 0.11444449f, 0.72968686f, 0.31067064f, 0.51830113f, 
    0.08052403f, 0.50376600f, -0.54805464f, -0.33279753f, -0.57311302f, -0.66196179f, 0.33216181f, -0.14913662f, 
    0.34637791f, 0.12008136f, -0.03116936f, -0.26952013f, -0.36089233f, 0.23136906f, 0.08129442f, 0.01888892f, 
    0.08893792f, 0.02483167f, 0.37968352f, -0.12925072f, -0.22137782f, 0.16839153f, -0.64568508f, 0.25915542f, 
    0.02057893f, -0.12566401f, 0.39227802f, -0.88667750f, 0.44637948f, -0.41587317f, -0.58993924f, -0.20857891f, 
    -0.06349011f, 0.33372283f, 0.34097672f, 0.21895498f, 0.31440800f, 0.16877721f, 0.17815033f, 0.37485233f, 
    0.15321165f, -0.23537208f, -0.22076982f, 0.06541152f, 0.15707763f, 0.37021619f, -0.07098481f, -0.10154779f, 
    -0.55141068f, 0.36074048f, 0.12713002f, 0.65244418f, -0.85218954f, -0.50725251f, -0.55409455f, -0.77172381f, 
    -0.35017776f, 0.30616745f, 0.37316403f, 0.02881527f, 0.01523493f, -0.42263114f, 0.19057189f, -0.13135581f, 
    0.17998321f, 0.25457036f, -0.22665086f, -0.04740607f, -0.21321715f, -0.25365111f, -0.08308994f, 0.14346337f, 
    0.92982090f, 0.40977800f, 0.50725794f, 0.84900236f, 0.79564267f, 0.04004147f, 0.15133189f, -0.09920812f, 
    0.18259142f, -0.53533971f, -0.20656593f, -0.21818691f, -0.25257489f, 0.05488733f, -0.00992785f, -0.00172234f, 
    -0.14242332f, 0.30455804f, 0.06278012f, 0.03024978f, 0.06379645f, 0.35286114f, 0.06574348f, -0.04118327f, 
    0.10689160f, -0.55081862f, -0.28433377f, 0.34742036f, 0.51593316f, 0.06388680f, -0.33418542f, -0.13502003f, 
    -0.02853080f, 0.24526237f, -0.31819117f, -0.35918885f, 0.37709004f, 0.17577216f, 0.10451930f, -0.22220816f, 
    0.27130210f, -0.20223807f, 0.32990542f, 0.32820234f, -0.15142697f, -0.02602889f, 0.28224522f, -0.51589167f, 
    -0.09462852f, 0.19594605f, 1.02452850f, 0.79703343f, -0.15690839f, 0.22057106f, 0.38741758f, 0.64048105f, 
    -0.56917787f, -0.13047890f, 0.46276066f, 0.42966184f, -0.35340208f, 0.06766240f, -0.23993313f, -0.11760850f, 
    -0.12842689f, 0.12994775f, -0.06803785f, -0.15741001f, -0.06772178f, 0.17220175f, 0.08344737f, 0.08329719f, 
    0.03193263f, -0.44606513f, 0.12450162f, -0.47227898f, -0.95545191f, 0.07143677f, 0.33476329f, -0.10953019f, 
    0.56959867f, 0.24694587f, 0.32118821f, -0.07312966f, -0.56064606f, 0.09265777f, 0.29953009f, 0.10191755f, 
    -0.06792352f, 0.29150221f, -0.30655620f, 0.07720738f, -0.19960020f, -0.57053137f, 0.01584205f, 0.17355727f, 
    0.12163830f, 0.12189727f, -0.10693355f, 0.23703313f, 1.05230844f, -0.17181413f, -0.41720700f, 0.79105848f, 
    0.49896997f, -0.65365714f, 0.21261837f, -0.05937441f, -0.03242014f, 0.00115440f, -0.26434758f, 0.08123942f, 
    0.03564506f, -0.07501803f, 0.14360811f, -0.08426942f, -0.12650934f, -0.03679251f, -0.18797532f, -0.16406932f, 
    0.42319286f, 0.23679826f, 0.08197407f, -0.21188763f, -0.05755745f, -0.02532482f, -0.35606223f, -0.68026239f, 
    -0.62369984f, -0.23065408f, 0.55677110f, 0.11246800f, 0.17245395f, 0.44831926f, 0.20101134f, -0.49230033f, 
    -0.38509482f, -0.40138420f, -0.45313501f, -0.25597191f, 0.05138028f, -0.16981927f, -0.14697562f, 0.02634094f, 
    0.03827392f, -0.02629367f, -0.21040083f, -0.10868352f, -0.07775380f, -0.06542289f, -0.08308269f, -0.38293725f, 
    0.44979826f, 0.67050606f, 0.24306290f, -0.35245329f, -0.31892499f, -0.51631778f, -0.65465271f, -0.39235631f, 
    0.57956618f, 0.17695577f, 0.12468032f, 0.03406888f, 0.21632917f, -0.40194291f, -0.01447765f, 0.33085439f, 
    0.01124130f, 0.31112704f, 0.01896643f, 0.03873524f, 0.45099667f, -0.19101466f, -0.31959602f, -0.24499874f, 
    -1.11660779f, -0.05225526f, 0.59957242f, -0.04428409f, -0.29449934f, 0.52475691f, 0.38313302f, -0.25664189f, 
    0.40978947f, 0.28463358f, -0.05824120f, 0.03009086f, -0.17222850f, -0.24536817f, -0.34275937f, -0.28212199f, 
    0.09887338f, 0.20470102f, -0.34862852f, 0.31251797f, 0.22699930f, -0.09026510f, 0.28890204f, -0.35300097f, 
    -0.28170678f, -0.75717902f, -0.19472700f, 0.01339657f, -0.33753005f, -0.84942490f, -0.15791723f, 0.63041323f, 
    -0.37968290f, -0.05093373f, 0.46598971f, 0.37818182f, 0.26436996f, -0.22651139f, -0.06666603f, -0.05436414f, 
    0.32416111f, 0.01814920f, -0.17362404f, 0.08891109f, -0.16082373f, -0.33006781f, 0.20331568f, 0.13396616f, 
    0.42621186f, 0.22684395f, 0.63856375f, 0.30722719f, 0.40190765f, 0.91178942f, -0.00653631f, 0.58692658f, 
    0.32320717f, -0.10956845f, 0.28682867f, -0.38582188f, 0.10548917f, 0.52242482f, -0.15331526f, 0.27224720f, 
    0.25636491f, 0.24227507f, 0.06569841f, 0.41747272f, 0.21457994f, 0.17540282f, -0.14194666f, -0.05268367f, 
    0.07576608f, 0.01581960f, -0.04761109f, -0.00638966f, -0.63398832f, -0.14663413f, 0.57025397f, -0.30440059f, 
    -0.54550034f, 0.78192699f, 0.05343335f, 0.03697706f, 0.07041845f, -0.07548182f, -0.41824028f, 0.15926053f, 
    -0.26574686f, -0.00587327f, 0.07841055f, 0.21968941f, 0.41350862f, 0.00461579f, -0.26292917f, -0.30767182f, 
    -0.12968449f, -0.00590581f, 0.42599586f, -0.94346321f, 0.26878926f, -0.23794423f, -0.14254020f, -0.33869025f, 
    0.13235787f, 0.55142581f, -0.61896825f, 0.25670889f, -0.37123847f, 0.01695448f, -0.22371966f, 0.08094868f, 
    0.20563546f, -0.31916615f, -0.51029748f, -0.23465179f, 0.13706157f, -0.35240319f, -0.66297960f, 0.23037672f, 
    -0.11348968f, -0.03126609f, 0.25487205f, -0.09469043f, 0.24067846f, -1.29183304f, 0.52857631f, 0.91566110f, 
    0.02403649f, -0.84227735f, 0.59621871f, 0.48949435f, -0.25109422f, 0.15789595f, -0.14254817f, 0.10832230f, 
    0.00660942f, 0.06279743f, 0.26191628f, -0.41397390f, 0.10960571f, -0.17436062f, 0.05445271f, -0.19871514f, 
    -0.22922984f, 0.02363602f, -0.10869346f, 0.01694676f, 0.19323975f, -0.09400076f, -0.86587161f, 0.64428920f, 
    0.66487914f, -0.44994566f, -0.11032793f, -0.24262401f, 0.40840450f, -0.27945781f, -0.44046322f, 0.03495089f, 
    -0.34887367f, 0.07464232f, 0.08009286f, 0.23906089f, -0.09538956f, 0.33923897f, 0.27650738f, -0.16126025f, 
    0.23790045f, 0.26437786f, 0.28875607f, -0.08312780f, 0.07615094f, 0.01635765f, 0.81238073f, 0.71173787f, 
    0.03439014f, -0.82187510f, -0.24693437f, 0.52957845f, 0.23555422f, -0.37093934f, -0.42462042f, -0.35651451f, 
    0.03857552f, 0.08343033f, -0.02464946f, 0.03345049f, -0.17927463f, 0.07479005f, 0.23984592f, 0.28999987f, 
    0.35998201f, 0.08930091f, -0.04809517f, -0.02506155f, -0.08294327f, -0.12424783f, 0.28317800f, 0.52962011f, 
    -0.46388116f, -0.42452276f, -0.49483410f, 0.50789934f, 0.66677117f, 0.43735185f, -0.43483704f, -0.52026987f, 
    -0.21556172f, -0.47946572f, -0.08566465f, 0.17869806f, 0.23807223f, 0.15907007f, -0.33829632f, -0.01965125f, 
    -0.05478503f, 0.18002819f, -0.19358230f, 0.00976928f, -0.23598057f, 0.03176710f, -0.07515069f, -0.15522513f, 
    0.74309528f, 0.92460036f, 0.85468066f, 0.41953960f, -0.16385116f, -0.34655759f, 0.35445970f, -0.30006778f, 
    -0.09482712f, 0.38768172f, 0.21903560f, 0.05632522f, 0.00564814f, 0.38512003f, 0.33444273f, 0.16189793f, 
    -0.07504473f, 0.06600947f, -0.07082216f, 0.02233990f, 0.04501431f, 0.26662257f, 0.09536945f, 0.17583014f, 
    0.24610960f, -0.02987240f, 0.78097045f, -0.66474903f, -0.68294531f, -0.31145453f, -0.15402712f, -0.27088422f, 
    0.18616313f, 0.52956706f, -0.58865440f, -0.29423016f, -0.09040581f, 0.18407284f, -0.05689963f, -0.56573427f, 
    0.18084334f, 0.17335652f, 0.18909782f, 0.16907699f, -0.23513287f, 0.02289973f, -0.33315891f, 0.33528450f, 
    0.03797742f, 0.13448383f, -0.44126755f, 0.37279102f, 0.57965952f, 0.48741323f, -0.49060732f, -0.73288828f, 
    0.00728049f, -0.55457032f, -0.47431028f, -0.32234043f, 0.24454206f, -0.06647962f, -0.28022340f, -0.28503412f, 
    -0.35513470f, -0.27519736f, -0.13004537f, 0.19114573f, -0.49281862f, -0.00764756f, 0.32699424f, -0.15784772f, 
    -0.02132280f, -0.15514532f, 0.14434099f, 0.84426755f, 0.11761751f, 0.89045405f, 0.00404852f, -0.23646393f, 
    0.59373158f, -0.70046645f, 0.31759572f, 0.44355389f, 0.61412388f, 0.39901921f, -0.02773917f, -0.41696709f, 
    0.10963091f, -0.39697435f, 0.23589800f, -0.04293475f, 0.08087926f, -0.25500613f, -0.02068239f, 0.44458681f, 
    0.31976801f, 0.12085205f, 0.26341516f, 0.37100855f, -0.11750544f, 0.06663150f, -0.27834257f, -0.41600671f, 
    0.70201463f, -0.14044218f, 0.11331362f, 0.67202544f, 0.08680478f, 0.59109384f, -0.57366484f, 0.13095567f, 
    -0.26417217f, -0.51106977f, -0.35709420f, 0.14476389f, -0.26535365f, -0.05827838f, -0.39403582f, -0.10660425f, 
    -0.26661289f, 0.13965797f, -0.07043248f, -0.05819683f, -0.14891547f, -0.04391357f, 0.38983336f, 0.12363655f, 
    0.30494639f, 0.31727681f, 0.25553498f, 0.50156957f, 0.15944092f, -0.52950859f, 0.36779749f, 0.00720570f, 
    -0.12196719f, 0.20747869f, -0.50485140f, 0.05871291f, -0.32191965f, -0.18044983f, -0.45708713f, 0.08053868f, 
    -0.46590951f, 0.23080133f, 0.41801423f, 0.42027348f, 0.16670436f, 0.34837198f, -0.60348654f, -0.86996347f, 
    -0.85431021f, -0.35039535f, -0.30607358f, -0.22587401f, 0.39687541f, -0.22554886f, 0.03223025f, 0.46248016f, 
    0.01612009f, -0.01996572f, 0.16222316f, -0.07521397f, 0.28461677f, -0.21870376f, 0.00934350f, 0.08653180f, 
    0.14189069f, -0.05799168f, -0.09867104f, -0.14177607f, -0.22985937f, 0.09419289f, -0.14161618f, 0.47000149f, 
    0.51356643f, -0.68623841f, -0.85651648f, -0.51499540f, 0.23470251f, 0.59102780f, -0.14980696f, 0.40025246f, 
    0.57091820f, -0.19242342f, 0.13900344f, -0.39433679f, -0.05784871f, -0.24899265f, -0.08928164f, -0.08074164f, 
    -0.07230699f, 0.18507828f, 0.17119539f, -0.25300908f, -0.15072735f, -0.36119971f, -0.22467175f, -0.13237724f, 
    0.87465501f, 0.73363024f, 0.49762222f, 0.70281214f, 0.90718412f, -0.58768451f, 0.34608439f, 0.24837443f, 
    -0.32930994f, -0.39518312f, -0.18569402f, -0.15035751f, 0.24109238f, 0.13419916f, 0.35134664f, 0.07181171f, 
    0.20067713f, 0.15028638f, -0.00914280f, 0.31140518f, -0.17868689f, -0.14054118f, -0.17278412f, 0.12151317f, 
    -0.02632752f, 0.45496219f, -0.77687043f, -0.29571092f, -0.49193722f, -0.35102054f, -0.10942370f, -0.01605341f, 
    0.36479300f, 0.26434717f, -0.57980442f, 0.04998660f, -0.42459384f, -0.14061412f, 0.45646787f, -0.35259199f, 
    -0.28531516f, -0.01270514f, -0.05618180f, 0.19427058f, 0.35618311f, -0.02212748f, -0.02715186f, -0.13749121f, 
    -0.27229273f, -0.39264017f, -0.58092588f, -0.56544042f, -0.41857255f, -0.26784575f, -0.01915728f, 0.39995101f, 
    -0.26009989f, 0.11889888f, -0.10203567f, 0.27385315f, 0.13977605f, 0.26246122f, 0.44219199f, -0.07386929f, 
    -0.32300201f, -0.42978975f, 0.31410247f, 0.29990196f, -0.07412045f, -0.15743950f, -0.12338263f, 0.15275611f, 
    -0.05368247f, 0.34424904f, 0.12079791f, -0.30507126f, -0.40265286f, -0.80305290f, -0.52676654f, -0.22134784f, 
    0.52272326f, -0.67444998f, -0.28840032f, 0.06908347f, 0.18494010f, -0.26163143f, -0.28104091f, 0.43144777f, 
    -0.02216527f, 0.16241916f, 0.40551984f, 0.07421933f, -0.14909194f, 0.28023210f, 0.18569139f, -0.21504633f, 
    -0.22168799f, 0.08572287f, -0.21806067f, 0.01844443f, 0.52356362f, -0.01364018f, -0.80797064f, -0.17436010f, 
    -0.39733055f, -0.49943528f, 0.15620527f, -0.35754970f, -0.16189034f, -0.41465521f, 0.23350807f, 0.38264188f, 
    -0.35228851f, 0.02908864f, -0.12681893f, 0.20461960f, 0.07462095f, -0.09591697f, -0.07237504f, 0.36284456f, 
    -0.28699657f, -0.19339319f, 0.36084279f, 0.37887311f, -0.04092785f, -0.26637542f, -0.66210663f, -0.56237066f, 
    -0.24202849f, -0.36993617f, -0.07140455f, 0.43873635f, 0.36913589f, 0.15750432f, 0.49318153f, -0.22876297f, 
    0.21335258f, -0.25089982f, 0.12281380f, -0.08222697f, 0.10202923f, -0.03219071f, -0.43240353f, 0.02562479f, 
    0.30500463f, -0.14506069f, 0.18308552f, 0.31643671f, 0.22448987f, -0.28675404f, 1.03973830f, -0.35899088f, 
    0.11805857f, 0.47006920f, -0.07776348f, -0.16612469f, 0.51192719f, -0.07131650f, -0.07219159f, 0.22309637f, 
    0.15158252f, 0.31855655f, -0.07085567f, -0.11370039f, -0.05563815f, -0.37525567f, -0.01065139f, 0.04059482f, 
    0.27834481f, -0.18571080f, 0.10692138f, -0.18115494f, 0.13457638f, 0.17260292f, 0.26999894f, -0.72698271f, 
    0.77363557f, -0.53344488f, -0.64581835f, 0.03426744f, -0.01099328f, 0.21807899f, -0.14530124f, 0.05749706f, 
    0.12247460f, -0.19800282f, -0.06116010f, -0.07652435f, -0.18914947f, 0.29394695f, 0.31594154f, 0.40674347f, 
    0.15966609f, 0.18963559f, -0.14269744f, 0.42961517f, 0.27316505f, 0.25020435f, 0.03678697f, 0.34116086f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07241337f, 0.24395147f, 0.11463783f, 0.09383989f, 0.13051763f, 0.18683907f, 0.10477843f, 0.11097720f, 
    -0.02614189f, 0.09096585f, 0.09289578f, 0.01123468f, 0.19807819f, 0.14366919f, 0.26262963f, 0.20443943f, 
    -0.00087710f, 0.06166725f, 0.27506146f, 0.08361953f, -0.03292018f, -0.03576226f, -0.01913750f, 0.32942176f, 
    0.16862479f, 0.23417209f, 0.00636676f, 0.05864339f, 0.12691499f, 0.12421089f, 0.28065416f, 0.11008791f, 
    0.11465935f, 0.17327012f, 0.20270270f, 0.19867143f, 0.11939144f, -0.19477794f, 0.08107685f, 0.19114207f, 
    0.26925245f, 0.10900657f, 0.00560469f, 0.17718919f, -0.00587676f, 0.23190022f, 0.15249336f, 0.12286472f, 
    0.08077821f, 0.09650096f, 0.25583905f, 0.17426957f, 0.19708651f, 0.29156125f, 0.22223239f, 0.19042520f, 
    0.07052837f, 0.07973956f, 0.13753651f, 0.23570828f, 0.22728127f, 0.04558295f, 0.25248003f, 0.20403402f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.36170974f, 0.02944703f, 0.00492346f, -0.07945959f, -0.06659689f, -0.05864338f, -0.13007066f, -0.07610310f, 
    0.07437044f, 0.06766345f, 0.01808501f, 0.10759875f, 0.04765344f, -0.06881984f, 0.19753076f, 0.04863353f, 
    -0.18823949f, -0.04298766f, 0.10966223f, 0.16315998f, 0.05637957f, -0.00472105f, -0.04165257f, -0.08473565f, 
    -0.31184307f, -0.07643665f, -0.08711743f, 0.10944779f, 0.08900177f, 0.10561340f, -0.09513525f, 0.09623379f, 
    0.12958233f, -0.10117076f, 0.02231957f, 0.00969010f, -0.19275436f, 0.14309992f, 0.04344477f, -0.01758034f, 
    -0.01684976f, 0.01109939f, 0.00735413f, -0.03848656f, 0.11672010f, -0.05113199f, -0.05373259f, 0.01034263f, 
    0.26456547f, 0.01707000f, 0.10791855f, 0.02978931f, -0.14849421f, -0.01809598f, -0.00777506f, 0.00203012f, 
    0.02309182f, -0.00900889f, 0.01262662f, 0.05930981f, 0.36526018f, -0.17199269f, -0.06639723f, -0.21868703f, 
    -0.23109420f, 0.19312225f, 0.01743099f, -0.00968603f, -0.10586341f, 0.01228490f, -0.08781427f, -0.02163445f, 
    -0.04872788f, 0.04046411f, -0.10838369f, -0.24898492f, -0.12201823f, -0.01720629f, -0.02977648f, 0.13428374f, 
    0.01327941f, -0.09273816f, 0.01889123f, 0.06287009f, 0.24425764f, 0.17396635f, 0.01708916f, -0.17117542f, 
    0.01654090f, 0.17808072f, 0.01026710f, 0.01672772f, 0.00585840f, 0.01445512f, -0.00081142f, -0.00049687f, 
    -0.34493718f, 0.16965953f, 0.17063151f, 0.04058694f, 0.06396616f, 0.11352062f, -0.00205656f, 0.04075757f, 
    0.07321179f, -0.04425995f, 0.04130971f, 0.03653491f, -0.02830001f, -0.01328213f, 0.24618426f, 0.04411618f, 
    -0.04047985f, 0.03378418f, 0.10482167f, -0.07389707f, -0.02340247f, -0.05410034f, 0.00621606f, -0.07070412f, 
    -0.34108758f, 0.08845145f, 0.02096595f, -0.27359056f, 0.00013358f, -0.04070286f, 0.06334358f, -0.10880730f, 
    0.07950076f, 0.01666382f, 0.02452270f, 0.03307145f, 0.12955937f, 0.15342925f, 0.07629676f, -0.24895646f, 
    0.10865176f, 0.06265709f, 0.01874755f, 0.07941509f, 0.00905361f, -0.01474516f, -0.03105019f, 0.09981532f, 
    -0.23874807f, -0.03172423f, 0.00404829f, -0.26000643f, -0.04121295f, 0.11335965f, -0.02545714f, 0.03129037f, 
    0.04499711f, -0.07014048f, 0.03564746f, 0.09099764f, -0.14913575f, 0.06446885f, -0.11547433f, -0.03063393f, 
    -0.13652016f, 0.04322826f, -0.05828424f, -0.00091136f, 0.01709167f, -0.02055502f, -0.11501344f, -0.11823785f, 
    -0.23735224f, -0.01959340f, 0.08853222f, -0.04906841f, -0.10486761f, -0.03706016f, 0.06653114f, 0.03489853f, 
    -0.07367896f, -0.08623020f, 0.06109330f, -0.05949849f, -0.33964062f, -0.16437276f, 0.17797011f, -0.03643949f, 
    -0.03410935f, 0.08951143f, 0.06908022f, 0.02456184f, -0.08481333f, -0.13135004f, 0.00033849f, 0.00955253f, 
    -0.13406825f, 0.07629724f, 0.22188777f, -0.20417421f, -0.05349207f, -0.04668802f, 0.12292717f, -0.03883280f, 
    -0.00185504f, -0.13313514f, 0.03997165f, 0.02259072f, 0.11683469f, 0.00382612f, -0.00441406f, 0.02037931f, 
    0.00819424f, -0.01949438f, -0.09379666f, 0.09533753f, 0.01801919f, -0.01213390f, -0.07313934f, 0.04655417f, 
    -0.26532587f, 0.11248430f, -0.02289810f, 0.04013902f, 0.00501050f, -0.05209844f, -0.00155373f, -0.17277488f, 
    -0.07642023f, -0.08597693f, -0.01203759f, 0.04696056f, 0.19790193f, 0.00612841f, -0.01020874f, -0.00097915f, 
    -0.04534756f, -0.06349758f, -0.11236101f, 0.11959336f, -0.08041698f, -0.11534260f, 0.14514560f, -0.22615038f, 
    0.15054056f, 0.07902478f, 0.07360642f, 0.04448195f, 0.06240526f, 0.07097958f, 0.08561259f, -0.05304157f, 
    -0.01462749f, 0.02383501f, 0.03593965f, -0.03185691f, -0.36089388f, -0.20568134f, -0.00147071f, 0.14686739f, 
    0.05055606f, -0.10014231f, -0.04030667f, 0.08392949f, 0.09291457f, 0.08915108f, 0.05038558f, -0.00984911f, 
    0.05560218f, 0.00641257f, -0.22691341f, 0.39695999f, 0.12145198f, 0.06510574f, 0.07152896f, -0.03904510f, 
    -0.00655659f, 0.05590402f, 0.04488420f, 0.00709959f, -0.05728325f, 0.00441046f, 0.04146325f, -0.17875874f, 
    -0.09559558f, -0.15141308f, 0.00353518f, 0.05135145f, -0.08549401f, -0.02026545f, -0.01341431f, -0.00698352f, 
    -0.20939331f, 0.03706136f, 0.04479039f, -0.09058909f, 0.06036137f, -0.02681065f, -0.07965948f, 0.05745196f, 
    -0.11288023f, 0.05640404f, 0.04723408f, 0.01044497f, -0.06937046f, -0.03461457f, -0.10520227f, 0.17380856f, 
    -0.08578785f, 0.03694775f, -0.11808946f, 0.10126258f, -0.13308549f, -0.02427542f, 0.05509509f, 0.02882712f, 
    0.22021140f, 0.13540433f, 0.09038373f, 0.09579758f, -0.18341082f, -0.09108649f, 0.01926871f, 0.05418000f, 
    -0.05549584f, 0.03551927f, -0.07777247f, 0.08741111f, 0.15459241f, 0.19176111f, 0.17274313f, -0.14384641f, 
    0.13261214f, 0.09603141f, -0.09995242f, 0.09284058f, -0.07128510f, 0.05814830f, -0.02728084f, -0.00171877f, 
    -0.03609534f, 0.07569779f, 0.04323835f, 0.19780833f, -0.14229047f, -0.01836774f, 0.01748021f, -0.04917353f, 
    0.02645629f, 0.01971316f, -0.16406916f, 0.05933823f, 0.17815606f, 0.07486520f, 0.04359983f, -0.14381179f, 
    -0.12179198f, 0.00152783f, -0.00650012f, 0.06968962f, -0.12000802f, 0.00315295f, -0.12102447f, 0.06307666f, 
    -0.18724342f, -0.07597584f, -0.05575959f, -0.01622021f, 0.15215142f, -0.06022313f, -0.01713312f, 0.01140803f, 
    -0.06830195f, 0.03869174f, -0.12303574f, -0.12151755f, -0.11229140f, -0.28640324f, 0.01600253f, 0.08380010f, 
    -0.15653996f, -0.05387248f, 0.08953777f, 0.03843589f, 0.05468459f, 0.07615135f, -0.05973452f, 0.04393071f, 
    0.18817094f, 0.00480130f, -0.08965131f, 0.15932705f, -0.12968463f, -0.03545264f, -0.01109637f, 0.04938878f, 
    0.00381585f, -0.05826858f, -0.13635655f, -0.07945196f, -0.20538265f, -0.02470292f, -0.08344259f, 0.12022509f, 
    -0.04491800f, 0.05012392f, 0.02509222f, 0.08329035f, -0.05245081f, 0.00992874f, -0.08595699f, 0.01526846f, 
    0.17450362f, -0.22893271f, 0.10986809f, 0.04732528f, -0.06358675f, -0.02796440f, -0.02584538f, 0.09280979f, 
    0.07163947f, 0.01922985f, 0.08844645f, -0.04679608f, -0.09358917f, 0.05856359f, 0.05974989f, 0.00272688f, 
    0.05607886f, 0.01994514f, -0.09429634f, 0.04773642f, -0.07175223f, 0.01736949f, 0.13333492f, 0.00120645f, 
    0.11451499f, -0.03467345f, -0.03089740f, 0.23311260f, -0.08422513f, 0.06538372f, -0.07031395f, -0.00215906f, 
    0.00453070f, 0.05638765f, 0.03089065f, -0.03392591f, 0.21906763f, 0.04786092f, -0.03888523f, -0.15994538f, 
    0.09324140f, -0.01516214f, 0.16558544f, -0.00559803f, -0.08392624f, 0.01067201f, 0.08212616f, 0.07378805f, 
    0.10759237f, 0.01288155f, -0.21957213f, 0.12050179f, 0.01147661f, 0.02755130f, 0.00168925f, -0.02443665f, 
    0.12384977f, -0.00827387f, -0.08304900f, -0.05892152f, -0.26102656f, 0.04147700f, -0.26399171f, 0.16150199f, 
    -0.01337636f, -0.03609267f, -0.00592641f, 0.06916311f, 0.04650286f, 0.01162817f, -0.10691229f, -0.03352398f, 
    -0.21338548f, -0.13821666f, -0.10937400f, 0.08886899f, -0.00682082f, 0.06426105f, -0.02806367f, 0.00148811f, 
    0.06986110f, 0.12381491f, -0.02731002f, -0.10816523f, -0.07396667f, -0.15843993f, -0.02991227f, 0.04819167f, 
    -0.12884969f, 0.05102931f, -0.02307545f, 0.05443663f, 0.05171321f, 0.03985439f, -0.02755663f, 0.09682696f, 
    0.06550783f, 0.08631339f, 0.16589126f, -0.12513557f, -0.00874484f, -0.03520491f, -0.05121535f, 0.05316515f, 
    0.09934407f, 0.09297720f, 0.06380897f, -0.02764947f, 0.30816641f, -0.04862981f, -0.01771022f, -0.10688739f, 
    0.04078380f, 0.00675530f, 0.02182391f, 0.05651378f, -0.00795565f, 0.03196906f, -0.01005574f, 0.11023162f, 
    0.13358916f, -0.09386855f, -0.11662104f, 0.28025603f, -0.12180193f, 0.02697808f, 0.13986333f, -0.13930735f, 
    -0.02066878f, 0.04659738f, -0.01594358f, 0.04732878f, 0.06739764f, 0.00215739f, -0.10741580f, 0.27895650f, 
    0.02512368f, 0.04647223f, 0.05924290f, 0.08192613f, -0.00402572f, -0.09165313f, -0.06559322f, -0.03281940f, 
    -0.06855536f, 0.24573557f, 0.14188068f, -0.23178287f, -0.03200456f, 0.02649868f, -0.00841750f, 0.05163488f, 
    0.02797744f, 0.02140552f, -0.01934431f, 0.11304889f, -0.11197258f, -0.03434275f, 0.19261096f, -0.21053240f, 
    -0.04831113f, -0.04529257f, -0.02875132f, -0.08929435f, 0.06524198f, 0.05459369f, 0.03172122f, -0.06292648f, 
    0.10216025f, 0.03568444f, -0.08007579f, 0.01870130f, -0.15989226f, -0.07801571f, 0.04306906f, 0.02987425f, 
    -0.03105065f, 0.00521057f, -0.06662927f, -0.00150957f, -0.06179933f, 0.19926111f, 0.04707785f, -0.24109541f, 
    -0.06723572f, -0.09965014f, 0.01201558f, -0.11701757f, -0.06251474f, 0.04095703f, 0.05856877f, -0.02871911f, 
    -0.09269745f, 0.04296330f, 0.01131597f, 0.09289263f, -0.03548965f, -0.02591434f, 0.03281214f, -0.14691511f, 
    -0.01783937f, -0.06279693f, 0.00577200f, 0.02576252f, 0.16050844f, -0.18723409f, -0.02284205f, 0.06513552f, 
    -0.12128125f, -0.12627187f, -0.04089086f, -0.09350029f, -0.00235378f, 0.05335095f, -0.13935384f, -0.00445469f, 
    -0.04153439f, 0.11741605f, -0.03451419f, -0.22606808f, -0.08347648f, 0.02045345f, -0.02225212f, -0.10004180f, 
    -0.09112667f, 0.07463234f, -0.04116643f, -0.03827860f, 0.00846201f, 0.09508934f, 0.13105382f, -0.09468278f, 
    -0.01697241f, -0.09789035f, -0.01352030f, -0.13540243f, -0.03843035f, 0.00124814f, -0.09295412f, 0.07446329f, 
    0.07926262f, -0.01247023f, -0.05279138f, -0.20342022f, 0.04972247f, 0.04121336f, 0.01416819f, 0.00627456f, 
    0.01193637f, -0.08389012f, -0.04376435f, 0.05965689f, 0.16162482f, -0.04592551f, -0.00372531f, -0.38349462f, 
    0.05917975f, 0.00363930f, 0.03715820f, -0.00619028f, -0.07731269f, 0.07027408f, 0.07594672f, 0.01516211f, 
    0.19010672f, 0.09721662f, -0.14901492f, 0.01454924f, -0.19548807f, -0.03280300f, -0.01602395f, 0.11375327f, 
    0.04577972f, -0.08962473f, 0.03153236f, -0.11224541f, 0.03012742f, 0.03832765f, -0.03929748f, -0.19272090f, 
    0.04161132f, 0.01382200f, 0.03915298f, -0.01428603f, 0.08015282f, -0.12321233f, -0.14549704f, -0.02319269f, 
    0.01904080f, 0.02794802f, -0.18882659f, -0.12536283f, 0.01876424f, 0.04770784f, 0.03493664f, 0.02078627f, 
    -0.10962889f, 0.00723398f, -0.09303427f, -0.04468535f, 0.30477768f, -0.33150312f, 0.05929118f, -0.14324902f, 
    -0.07986519f, -0.05263599f, -0.07466305f, 0.05643443f, -0.06980900f, -0.04791019f, -0.09549341f, 0.02835967f, 
    -0.18052851f, -0.01337284f, 0.11701142f, 0.11523016f, -0.09403621f, 0.04002793f, 0.02289688f, -0.00576169f, 
    0.06599482f, -0.00726595f, 0.12530835f, -0.18469988f, -0.01938791f, 0.02265679f, -0.07690236f, -0.23805325f, 
    -0.04019055f, -0.01995229f, 0.06421095f, 0.00520398f, -0.04024691f, -0.01802207f, 0.08913819f, -0.03162319f, 
    0.06628361f, -0.11499142f, -0.04264394f, 0.18033166f, -0.07017325f, -0.12015539f, -0.01687956f, 0.02300602f, 
    -0.11455683f, 0.10922668f, -0.02638847f, 0.00527325f, 0.30325949f, 0.01049535f, -0.02809076f, -0.18832822f, 
    0.11913839f, -0.02802032f, -0.07857061f, 0.04080020f, 0.01947233f, -0.07909051f, 0.03010194f, -0.02745247f, 
    0.12581027f, 0.01678430f, -0.00938315f, 0.09899641f, -0.07077224f, 0.02759949f, 0.02789728f, -0.00804426f, 
    -0.01202565f, 0.01686013f, -0.15565568f, -0.08319491f, 0.08886912f, 0.02451955f, 0.00496049f, 0.01791451f, 
    -0.05571388f, -0.01632032f, -0.06114447f, -0.07857987f, -0.17705740f, -0.00505459f, 0.03496524f, -0.07580926f, 
    0.25328603f, 0.20508495f, -0.22577322f, 0.01326493f, 0.02469943f, 0.03021061f, 0.06812321f, 0.05657883f, 
    -0.15167069f, 0.11912464f, -0.09528767f, 0.08439640f, -0.06532004f, 0.11757369f, -0.07573690f, 0.07084838f, 
    -0.07745016f, 0.03947656f, -0.08440782f, -0.09683164f, 0.03775547f, 0.10383581f, 0.00436938f, 0.03130268f, 
    -0.57335854f, 0.00723012f, -0.05370359f, -0.09598445f, 0.03395384f, -0.02521662f, 0.02151958f, -0.11272029f, 
    -0.14042364f, 0.08605170f, 0.03730521f, -0.06014829f, -0.21229583f, -0.13251498f, 0.05967186f, -0.17218675f, 
    0.09656534f, -0.18326291f, 0.07869890f, -0.02776231f, -0.00475825f, 0.03124333f, 0.02374814f, 0.02960755f, 
    -0.20490967f, -0.13674425f, -0.01262896f, 0.05139136f, 0.21814735f, 0.01951989f, -0.01463628f, -0.03291861f, 
    -0.04307846f, -0.05579489f, -0.15042830f, 0.00022070f, -0.11678258f, -0.26350167f, -0.07798976f, -0.07760143f, 
    -0.03516156f, -0.06252936f, -0.02711121f, -0.03758736f, -0.02918041f, -0.00182266f, -0.07496782f, 0.15128437f, 
    -0.30335087f, 0.14169154f, -0.19616352f, -0.26258799f, 0.09422830f, -0.04849172f, -0.01892032f, -0.02407853f, 
    -0.01647935f, -0.00184800f, -0.08306833f, -0.23838490f, -0.36033398f, -0.01009195f, -0.25643057f, -0.09900855f, 
    0.08787221f, 0.10206601f, -0.01849542f, -0.13224660f, 0.10859615f, 0.13251391f, 0.00046483f, -0.03127429f, 
    0.44485155f, -0.30270880f, -0.07939638f, -0.20418805f, -0.06737844f, -0.02990325f, -0.05237120f, 0.05203648f, 
    -0.02700770f, -0.03518644f, -0.03654453f, -0.01629338f, -0.06726240f, -0.07885876f, -0.11366118f, -0.09023870f, 
    0.09531851f, -0.23657377f, 0.01796205f, 0.00258818f, 0.08031717f, 0.07804761f, -0.04841175f, -0.08832311f, 
    0.01443589f, -0.14562123f, -0.08634400f, -0.18853658f, 0.04793928f, -0.07081620f, 0.03979195f, 0.12608334f, 
    -0.16458441f, 0.06846226f, -0.12694895f, 0.02078369f, 0.07054020f, -0.24695480f, -0.16618234f, 0.12707794f, 
    -0.12107825f, -0.00052279f, -0.02572299f, 0.09888355f, 0.06538195f, -0.04504325f, 0.00482256f, 0.01416870f, 
    0.06925965f, -0.11060738f, 0.06168198f, 0.06491856f, -0.07152464f, 0.04302731f, -0.02568305f, -0.05591482f, 
    -0.02565305f, 0.09468124f, -0.00586600f, 0.03862797f, 0.09152427f, 0.04972949f, -0.04692471f, 0.03810162f, 
    0.00425286f, 0.00434566f, 0.03939799f, 0.01489665f, 0.02619037f, 0.11078831f, 0.05656720f, -0.00972552f, 
    -0.18768038f, -0.10634881f, -0.19941825f, -0.46730894f, -0.04116479f, 0.00519722f, 0.06960563f, -0.08343506f, 
    0.01231312f, 0.14933503f, 0.09354100f, -0.01642192f, 0.10824588f, -0.03982223f, -0.06916521f, 0.09339817f, 
    -0.07813901f, -0.03233475f, 0.08392613f, -0.02036256f, -0.15227938f, 0.04396064f, 0.03896825f, 0.13866962f, 
    -0.20385015f, 0.02558004f, -0.10872295f, -0.00576760f, -0.13971210f, -0.05229389f, 0.01110074f, 0.02225186f, 
    -0.06580897f, 0.07376739f, 0.10810833f, -0.00599698f, 0.14031394f, -0.01122270f, 0.05349969f, -0.05809330f, 
    0.03784832f, 0.05805996f, 0.00369271f, -0.01206292f, 0.08136734f, 0.05039797f, -0.30674645f, 0.07843979f, 
    0.42823452f, -0.28248027f, 0.10903622f, -0.04498844f, 0.05994318f, -0.00538520f, -0.12545156f, 0.02873026f, 
    0.00489775f, 0.07263222f, -0.04339813f, -0.02743238f, 0.02146866f, -0.09810737f, 0.02344317f, -0.25835040f, 
    -0.04700638f, 0.00888473f, -0.05400310f, 0.12840120f, -0.05149655f, -0.16376726f, -0.13029243f, -0.07934828f, 
    -0.19955823f, 0.06338783f, -0.01071894f, 0.19042960f, -0.12910661f, -0.07067396f, 0.01791134f, -0.17281306f, 
    0.06303481f, -0.13131522f, 0.05931676f, 0.00389888f, 0.13793975f, 0.07007983f, -0.09101707f, -0.10710400f, 
    0.03966035f, -0.10809121f, 0.04779289f, 0.01578884f, -0.02514260f, -0.03654800f, 0.02450575f, -0.06013481f, 
    -0.07904641f, -0.03470808f, 0.02855675f, 0.11473668f, 0.05099113f, 0.06096798f, 0.17889871f, 0.04319192f, 
    0.11842611f, 0.16555712f, -0.05569528f, 0.11593397f, 0.26763257f, -0.01092436f, 0.14832461f, 0.11058933f, 
    -0.02955460f, -0.04465887f, 0.03936691f, 0.00378846f, 0.00856824f, 0.05421412f, -0.05508583f, 0.13555413f, 
    -0.17244454f, -0.10100242f, -0.03935664f, -0.12991902f, 0.09407930f, -0.02954857f, 0.04926229f, -0.03911592f, 
    0.14586188f, -0.01572654f, 0.01290857f, -0.16104843f, -0.02988021f, -0.02459714f, -0.02495253f, -0.04666112f, 
    -0.02245964f, -0.00309843f, -0.06401190f, -0.06169087f, 0.11390564f, 0.00358770f, -0.01230862f, 0.04410115f, 
    0.24671178f, 0.02002079f, 0.00168762f, 0.12685201f, -0.05196910f, 0.01989264f, -0.04464658f, -0.03041811f, 
    0.07439361f, -0.08220998f, 0.14844559f, -0.09457547f, 0.11989803f, -0.02618390f, 0.10770493f, 0.11140133f, 
    -0.00108285f, 0.04713774f, 0.02141158f, 0.04444046f, 0.10427167f, -0.03476230f, 0.09517056f, -0.17717046f, 
    -0.13591558f, 0.08122373f, -0.01767696f, -0.08410026f, -0.10626210f, 0.04651185f, -0.00348551f, 0.01228373f, 
    0.08504921f, 0.05070153f, 0.12768362f, 0.05318846f, -0.17220265f, -0.19635820f, 0.04966316f, -0.10194364f, 
    0.04812937f, 0.07148520f, -0.07994626f, 0.08464721f, 0.01862667f, -0.01839938f, -0.05620099f, -0.04969767f, 
    0.19743617f, -0.09442072f, 0.15240642f, 0.37554836f, -0.07545716f, -0.03024808f, 0.05822443f, 0.03944364f, 
    -0.09071035f, 0.02564492f, -0.00922727f, 0.11618001f, 0.05489093f, -0.04186833f, -0.20570222f, -0.02487077f, 
    -0.05504376f, 0.01525773f, -0.13185048f, -0.08068182f, -0.12680510f, -0.05554056f, 0.11299507f, -0.00152781f, 
    0.14767717f, -0.05930830f, 0.11223135f, 0.02937797f, -0.06201346f, -0.12359749f, -0.03771732f, -0.04350424f, 
    -0.05642278f, -0.05671612f, -0.03827859f, 0.03881589f, 0.02123292f, 0.12911339f, -0.10638853f, 0.12656502f, 
    -0.02680596f, 0.10713981f, 0.04122009f, -0.06242932f, 0.03770002f, -0.10253203f, -0.02965301f, -0.04043971f, 
    0.12300318f, -0.19368136f, 0.13857752f, 0.04666994f, -0.09111698f, 0.06998242f, -0.01926694f, 0.00015918f, 
    0.02541035f, 0.09999687f, -0.04664981f, 0.09032182f, -0.05640050f, -0.13962071f, 0.12038603f, -0.08206669f, 
    0.07552734f, -0.00242462f, -0.14417915f, -0.00161363f, 0.08838731f, 0.05888565f, -0.11518353f, -0.02876065f, 
    -0.22034748f, -0.11253406f, -0.03857793f, -0.01344408f, -0.01066520f, -0.06454064f, 0.00918831f, -0.00024884f, 
    -0.06325287f, -0.00864909f, 0.16110626f, 0.03502272f, 0.04826751f, -0.03369807f, -0.12120513f, 0.22994812f, 
    -0.10466214f, 0.00241399f, 0.04328665f, -0.05996023f, 0.10018113f, -0.16300544f, 0.00344144f, 0.14037991f, 
    0.06852615f, -0.11432441f, -0.11514994f, 0.05898840f, -0.01187526f, 0.02465214f, -0.09261435f, 0.12856047f, 
    -0.04423262f, -0.04524303f, 0.11834314f, 0.04230683f, 0.26959491f, 0.30850399f, -0.01007159f, 0.14931181f, 
    -0.13581020f, -0.00013186f, -0.05070971f, 0.02532365f, 0.10091139f, 0.05133385f, -0.04206682f, 0.01519893f, 
    0.02084578f, -0.19070433f, -0.02090764f, -0.06214086f, 0.00484874f, 0.06645088f, -0.08064331f, 0.14951321f, 
    -0.07970925f, -0.15496126f, -0.02544487f, -0.03958756f, -0.35536900f, -0.04959965f, -0.19152726f, 0.01619815f, 
    0.01991534f, 0.08005264f, -0.00931507f, 0.11829636f, -0.02304012f, -0.24551521f, -0.03584532f, -0.05169661f, 
    -0.28508341f, -0.09279960f, 0.03152074f, 0.17116812f, -0.06137398f, 0.00084186f, -0.07797205f, -0.03346170f, 
    -0.01007399f, 0.00526208f, -0.02005431f, -0.08537530f, -0.54464048f, 0.17249364f, -0.07522926f, 0.08599737f, 
    -0.07782325f, 0.03517013f, -0.04918350f, -0.00722888f, 0.13715516f, 0.13026746f, 0.03974365f, 0.03923109f, 
    0.22490120f, 0.05220839f, 0.07950943f, -0.15854681f, -0.08012140f, -0.02191303f, 0.00709680f, -0.03396678f, 
    -0.03258403f, -0.06352101f, 0.02474131f, -0.05178087f, 0.23410422f, -0.08394346f, -0.02398641f, -0.25130615f, 
    0.03357760f, -0.00994427f, -0.05933827f, 0.05407300f, 0.00711741f, -0.00051206f, -0.10304075f, -0.02717785f, 
    0.13145450f, 0.10848497f, 0.10338049f, 0.04151379f, -0.07103833f, -0.10928615f, 0.09818594f, 0.00830445f, 
    -0.03187764f, -0.00904622f, 0.00886178f, 0.02761047f, -0.13093038f, -0.23998211f, 0.04516308f, -0.28372952f, 
    -0.07152266f, 0.02481997f, -0.03053483f, 0.20195390f, 0.15089515f, -0.20992385f, -0.07666069f, -0.04034188f, 
    -0.22239701f, -0.00857069f, -0.54231590f, -0.06242908f, 0.05842067f, 0.09563903f, 0.03836150f, 0.06466621f, 
    -0.06542409f, -0.09403860f, 0.06144451f, -0.00630111f, -0.06712480f, 0.16620560f, 0.12832424f, 0.05236671f, 
    0.01095811f, -0.09531336f, 0.00880344f, 0.02948015f, 0.01120310f, -0.06102966f, 0.04464828f, -0.05811193f, 
    0.01680481f, 0.02019633f, 0.08111514f, -0.07295819f, 0.12752841f, 0.04241426f, 0.04502961f, 0.05564661f, 
    0.12850609f, -0.16881685f, -0.04542829f, -0.02729091f, 0.13650262f, 0.12279472f, 0.03633612f, 0.13021061f, 
    0.02869822f, 0.16912727f, 0.00616149f, 0.04943871f, 0.04491089f, 0.00263312f, 0.02879540f, -0.01850779f, 
    0.29180431f, 0.03237640f, 0.03444427f, -0.01909204f, 0.04600285f, -0.04365246f, 0.14716795f, 0.01817678f, 
    -0.02979423f, 0.03944876f, 0.04457984f, 0.00878299f, 0.08036119f, -0.01656122f, 0.04069936f, -0.25185385f, 
    0.10568443f, -0.08476467f, -0.06957764f, -0.06286665f, -0.09972940f, 0.02483308f, -0.04893047f, -0.00649002f, 
    0.16242151f, 0.10602976f, 0.05921870f, 0.19016968f, -0.00207178f, 0.04835007f, -0.00310332f, 0.00646595f, 
    0.00597911f, 0.06086478f, -0.08607559f, 0.15536664f, 0.14636444f, -0.25064826f, 0.11158813f, -0.05199507f, 
    -0.03722513f, 0.00149374f, -0.02865958f, 0.09365200f, -0.01466136f, 0.10668539f, 0.01449402f, -0.05825863f, 
    0.14186978f, -0.05495960f, -0.06223993f, 0.06825209f, 0.08183610f, -0.03946314f, 0.03192317f, 0.10432317f, 
    0.09504097f, -0.15408385f, 0.03850591f, 0.07819998f, -0.15660451f, 0.07263208f, 0.01005526f, -0.13602541f, 
    0.06570544f, -0.07558414f, 0.12907936f, -0.03516154f, -0.02444245f, 0.01223234f, 0.07101338f, -0.04339229f, 
    0.21075867f, -0.14324285f, -0.17589201f, -0.00653303f, -0.03787105f, 0.09217672f, 0.04887139f, 0.02122633f, 
    -0.03787985f, 0.04711235f, 0.13548361f, 0.12681966f, 0.13456382f, -0.07454729f, -0.02829113f, -0.02711071f, 
    0.02582275f, -0.00948958f, 0.03346554f, -0.05328373f, 0.00705211f, 0.14326422f, -0.10138949f, 0.06890032f, 
    0.30084637f, -0.03974918f, 0.01742867f, 0.08991234f, -0.07134606f, 0.03497517f, -0.04260566f, -0.03642048f, 
    0.03777945f, -0.07824817f, -0.00129577f, 0.01442018f, -0.25712276f, 0.08140654f, -0.11025938f, -0.37753057f, 
    -0.03505992f, -0.02391937f, 0.02703349f, 0.06114364f, 0.18179660f, 0.03747220f, 0.06303992f, 0.03866404f, 
    0.33601752f, 0.01995408f, 0.08619156f, 0.02999204f, -0.08516636f, -0.05758791f, 0.03104706f, 0.02966836f, 
    -0.00864379f, -0.02167917f, 0.00158192f, -0.04529107f, 0.14858742f, -0.13502221f, 0.07672001f, -0.03337348f, 
    0.07575794f, 0.02075835f, -0.00503218f, -0.06927525f, 0.07614206f, 0.02768566f, -0.01782964f, 0.07765441f, 
    0.28634799f, -0.12919028f, -0.04479909f, -0.05306627f, -0.06138714f, 0.09240165f, -0.13387889f, -0.01064701f, 
    -0.01439683f, -0.10752117f, 0.04961241f, -0.11242177f, -0.01595345f, 0.00920253f, -0.06944762f, -0.15409718f, 
    -0.03483530f, 0.03579785f, -0.06192536f, 0.06641621f, 0.06944168f, -0.03988583f, -0.08384077f, 0.00816901f, 
    0.16093358f, 0.10869353f, 0.02023692f, -0.07002352f, -0.02770753f, -0.00568585f, 0.01647272f, 0.08842562f, 
    -0.08861851f, -0.03210940f, 0.02284062f, -0.06127999f, -0.01769233f, 0.21659552f, 0.10562006f, -0.04624516f, 
    -0.05520634f, 0.05499486f, -0.09298801f, -0.00105212f, -0.02269125f, -0.07005164f, 0.00615707f, -0.05585099f, 
    0.09528876f, -0.00675768f, -0.19850010f, -0.02142097f, -0.04054011f, 0.13479534f, 0.03004365f, -0.11981173f, 
    -0.01907625f, -0.05725961f, -0.04302886f, 0.01655130f, 0.09248276f, -0.05162114f, 0.17813912f, 0.07747796f, 
    -0.03267086f, -0.10681278f, -0.02021877f, 0.10236380f, -0.03334075f, -0.01209263f, 0.02486081f, -0.00819186f, 
    0.32155481f, 0.11304379f, -0.38352656f, -0.00097222f, -0.04312244f, -0.04145727f, -0.03281624f, -0.04658417f, 
    0.01721865f, -0.03717695f, 0.11912703f, -0.05170766f, 0.35471529f, 0.04872362f, -0.17716379f, 0.12565237f, 
    -0.06551283f, 0.01578484f, 0.03687411f, -0.03688696f, -0.06535418f, 0.07384308f, 0.02282890f, 0.00872554f, 
    0.09532179f, 0.02863780f, 0.11023037f, 0.27811074f, -0.11606020f, -0.13619983f, 0.02024443f, 0.06253823f, 
    -0.06715661f, 0.05171622f, 0.01166994f, 0.01575606f, 0.25145945f, 0.10146298f, 0.09355766f, 0.12650864f, 
    -0.08765837f, -0.10536800f, 0.05927417f, 0.07763593f, -0.01817419f, 0.03159317f, -0.01565643f, -0.02007432f, 
    -0.20996463f, 0.08508390f, 0.00308654f, -0.15391856f, -0.05646572f, 0.07290817f, 0.04532951f, -0.03784142f, 
    0.07443097f, 0.00554529f, 0.02266722f, -0.02406143f, 0.04002788f, 0.00736008f, 0.05182946f, 0.01928733f, 
    -0.06348754f, -0.03930062f, 0.04674079f, 0.01196209f, 0.06442382f, 0.04886173f, 0.06172939f, -0.08921999f, 
    -0.09498161f, -0.13814905f, 0.04702660f, -0.00988801f, 0.06185801f, -0.02518443f, 0.03364456f, -0.00818870f, 
    0.02492749f, -0.07101961f, -0.04050315f, -0.01515714f, -0.10101099f, -0.16921511f, 0.06378327f, -0.23486787f, 
    -0.12511849f, -0.09500498f, -0.01301369f, -0.04840865f, 0.04810496f, -0.07043590f, -0.11145916f, -0.03936294f, 
    -0.04156327f, -0.11572641f, -0.14254837f, -0.33160806f, 0.04282338f, -0.08243062f, 0.02197929f, -0.14988387f, 
    -0.00725529f, -0.00041650f, 0.05120802f, 0.08033837f, -0.01764517f, 0.15170859f, -0.02610653f, -0.07444839f, 
    0.01286196f, 0.02121639f, 0.03745047f, -0.02534244f, -0.03844383f, -0.03581762f, -0.02360201f, 0.01381360f, 
    -0.23072983f, -0.00371459f, 0.01726925f, -0.05291293f, -0.10417660f, 0.06918073f, -0.03320770f, -0.01167503f, 
    -0.05626688f, -0.01545926f, 0.02217029f, -0.00878089f, 0.07123608f, 0.12306314f, -0.05818768f, -0.19676876f, 
    0.00421418f, 0.08106703f, 0.06214720f, 0.01136043f, -0.04968762f, -0.06447481f, -0.02214820f, -0.06630401f, 
    -0.13857928f, 0.10651279f, 0.09552461f, 0.07814900f, 0.05266713f, 0.08298779f, -0.01541964f, 0.04829463f, 
    -0.02208768f, -0.14604692f, 0.00931574f, 0.03330651f, 0.05897972f, -0.17302684f, -0.28719318f, -0.19822556f, 
    0.00991827f, 0.00941053f, -0.20922779f, -0.12916303f, 0.12716143f, 0.11346436f, 0.07012568f, -0.15429795f, 
    -0.12942314f, -0.08993543f, -0.03828418f, -0.05035778f, -0.12499948f, 0.06163298f, -0.01324696f, -0.02583295f, 
    0.01651898f, -0.01507073f, 0.08784784f, -0.05799359f, -0.33417487f, -0.03525625f, 0.01290597f, -0.17579871f, 
    0.03784978f, 0.03426391f, 0.02884028f, -0.04712302f, -0.05724388f, 0.04082759f, -0.02466598f, -0.04075612f, 
    -0.27996907f, 0.03064111f, 0.02744813f, -0.22631966f, 0.01575003f, -0.01022801f, -0.18905894f, -0.03602410f, 
    -0.06807014f, -0.04792769f, 0.06809451f, -0.03995826f, 0.07436024f, -0.07775915f, -0.00504783f, -0.09778427f, 
    0.00579353f, -0.02759588f, -0.00180090f, 0.10580913f, -0.05433962f, 0.02674152f, 0.09852932f, 0.03399073f, 
    -0.21735133f, 0.14419283f, -0.26784492f, -0.15516239f, 0.02480100f, 0.07605331f, 0.05910874f, 0.00282804f, 
    0.02833188f, 0.07493129f, -0.10717488f, -0.05901023f, 0.20251733f, 0.00381069f, 0.05601788f, 0.08096184f, 
    -0.05516882f, -0.04891029f, -0.12325313f, 0.00692878f, 0.01241327f, 0.04291975f, -0.02665013f, -0.07242091f, 
    0.15165021f, -0.05400184f, -0.05447188f, 0.03070546f, 0.01540296f, 0.08392882f, -0.01200101f, -0.13824430f, 
    -0.05979225f, 0.04408577f, 0.01528268f, 0.00275534f, -0.14926320f, 0.16309807f, 0.02205352f, -0.06158439f, 
    0.02340012f, -0.04282974f, 0.01918048f, -0.11741619f, -0.07994335f, 0.10051789f, -0.08594950f, -0.00239594f, 
    0.27806228f, -0.03401075f, -0.16446696f, -0.22779243f, 0.07248979f, 0.07697342f, -0.06694619f, 0.00702281f, 
    -0.06630803f, -0.11323970f, -0.04323272f, -0.09194949f, 0.29167897f, -0.09281655f, -0.14291576f, 0.04003222f, 
    0.06464945f, -0.04457017f, 0.04738500f, -0.08113819f, -0.07203658f, -0.09411976f, -0.03326669f, -0.18582590f, 
    -0.11946253f, 0.00449307f, -0.09772389f, -0.02071367f, 0.14715488f, -0.04186043f, -0.00727821f, -0.02416252f, 
    0.01576461f, 0.04366888f, 0.02781628f, -0.06292755f, 0.05413609f, -0.09799315f, 0.04007597f, -0.02176764f, 
    -0.14974129f, -0.00656037f, 0.08243138f, -0.08447899f, -0.06558394f, 0.05922759f, -0.18970713f, -0.00350585f, 
    0.25144440f, -0.14130208f, 0.02039104f, -0.02187801f, 0.08657043f, 0.01868818f, 0.06473167f, 0.00210723f, 
    -0.00059662f, 0.04959239f, 0.02776673f, -0.07637142f, 0.09711772f, -0.00958127f, 0.01193098f, -0.10646369f, 
    -0.17654580f, 0.02338208f, -0.11017901f, -0.05462285f, 0.10174257f, -0.05733011f, -0.09272397f, -0.16805793f, 
    0.16759475f, 0.01628217f, 0.00535403f, -0.13630019f, 0.14026819f, 0.00627958f, 0.07083575f, -0.08205484f, 
    0.04119104f, 0.01316282f, -0.02579806f, -0.03550915f, -0.04573847f, 0.00336527f, 0.01722077f, 0.26608902f, 
    -0.02338126f, 0.09172687f, 0.07551172f, 0.11257462f, -0.01162746f, -0.02486398f, -0.02355834f, 0.02036192f, 
    0.05569036f, -0.04849701f, -0.02006781f, 0.00251524f, -0.04340271f, 0.04891517f, -0.09437123f, 0.03088161f, 
    -0.00912955f, -0.06087011f, -0.12156535f, 0.00201748f, 0.29474401f, -0.18926649f, 0.03968448f, 0.12482554f, 
    -0.14050777f, 0.01327067f, 0.00100593f, -0.00352972f, -0.02149790f, 0.08362453f, -0.00002300f, 0.02172935f, 
    0.37235010f, -0.05903730f, 0.02424571f, 0.04421818f, -0.10899806f, 0.02323083f, 0.00749775f, -0.03360371f, 
    -0.04590290f, -0.03609735f, -0.02264804f, -0.05391560f, 0.06944363f, -0.11523137f, 0.05328303f, -0.01956937f, 
    0.09728370f, 0.04443760f, 0.03623704f, -0.14585586f, -0.02523538f, -0.13320048f, 0.03972124f, 0.05428418f, 
    -0.12582788f, -0.06921799f, -0.00681736f, 0.05504820f, -0.05241905f, -0.05317459f, 0.03972968f, 0.06302643f, 
    -0.02393316f, 0.00635680f, 0.05438285f, 0.08614552f, 0.15311973f, 0.07037427f, -0.11644164f, -0.11472142f, 
    -0.05960809f, 0.05625830f, -0.11695197f, -0.00812244f, -0.01944445f, 0.03286391f, -0.02923621f, 0.05640196f, 
    0.43327096f, -0.04538111f, -0.08069933f, -0.00030502f, -0.01133900f, 0.04055370f, 0.03173813f, 0.03351216f, 
    0.05458298f, 0.06609254f, -0.01338359f, -0.02701092f, 0.08696137f, -0.13483469f, -0.25388688f, -0.06771487f, 
    -0.21738285f, 0.04077237f, -0.05670419f, -0.01056312f, 0.10761566f, -0.03075429f, -0.01964827f, -0.03781591f, 
    -0.14218748f, -0.12937376f, 0.08327989f, -0.19523396f, 0.06909411f, -0.06060508f, 0.05266454f, -0.04818870f, 
    -0.04002605f, 0.01929981f, 0.03566469f, 0.01128193f, -0.25487962f, -0.15903814f, 0.13880649f, -0.14440480f, 
    0.01389937f, -0.04783131f, 0.01893869f, 0.00078540f, -0.04110963f, -0.03546610f, -0.11249370f, 0.04352252f, 
    -0.02455325f, 0.10599434f, 0.01801324f, -0.12822945f, -0.01711220f, 0.10034654f, 0.01022763f, 0.00232050f, 
    -0.04460692f, 0.00906226f, -0.03081371f, -0.02615196f, -0.31653312f, 0.07341198f, -0.13597955f, 0.01972101f, 
    0.02845222f, 0.01657837f, 0.06970997f, -0.02511476f, -0.02175736f, 0.11041396f, -0.03031340f, 0.01018007f, 
    -0.02314593f, -0.01003931f, -0.20765512f, -0.08239304f, -0.00600279f, 0.00283543f, -0.07061268f, -0.00698499f, 
    -0.00101601f, 0.01593534f, 0.01955131f, 0.00738317f, -0.05586541f, 0.07518397f, 0.06900840f, 0.03545961f, 
    -0.00819591f, 0.04187651f, 0.01907623f, 0.01981097f, -0.01792150f, 0.02833584f, 0.06143622f, -0.01140546f, 
    0.17669953f, -0.10287258f, -0.09306366f, -0.00602949f, -0.00705325f, 0.05162960f, 0.00728431f, 0.01407639f, 
    0.01071986f, 0.08263947f, -0.05009314f, 0.10290341f, 0.08070964f, -0.04654014f, 0.05129309f, -0.02037791f, 
    0.07446752f, -0.01969767f, -0.09813888f, -0.14102080f, -0.01063627f, 0.06083674f, 0.07751183f, 0.03136360f, 
    0.21020003f, -0.13471343f, 0.14119780f, 0.07253978f, -0.13741376f, -0.06361838f, -0.06733579f, 0.06342093f, 
    -0.02702349f, -0.00992303f, 0.03293301f, -0.01664313f, 0.10189733f, -0.04209122f, 0.06871573f, 0.00958494f, 
    -0.05766226f, -0.06231669f, 0.06783228f, 0.02286740f, -0.07262213f, -0.03749076f, 0.09363083f, -0.16360356f, 
    0.14200088f, 0.01576110f, -0.17059229f, 0.10037303f, 0.14190681f, 0.02613174f, 0.02494764f, -0.03880516f, 
    0.06888156f, -0.01980003f, -0.02287503f, 0.01451190f, -0.35869685f, 0.09713659f, -0.12844671f, 0.12108506f, 
    -0.01485726f, 0.00194959f, 0.03853917f, 0.10146312f, 0.04615686f, 0.03315677f, -0.04741028f, 0.03998759f, 
    -0.02003568f, 0.01296404f, 0.13485718f, -0.04710540f, -0.04136401f, -0.12886609f, -0.10455312f, -0.06599578f, 
    -0.07941844f, 0.04070972f, -0.01826940f, -0.01324127f, -0.20470902f, 0.03968733f, 0.06141341f, 0.01195241f, 
    0.03915728f, -0.07524332f, -0.06204109f, -0.01791825f, -0.05871271f, -0.00618219f, 0.02315702f, 0.03922657f, 
    -0.14430492f, -0.03861087f, -0.15253122f, -0.26526296f, -0.08696771f, 0.00456108f, 0.02315873f, -0.01607718f, 
    -0.03738280f, -0.02392187f, -0.00307509f, -0.02135509f, 0.21691829f, 0.00748079f, 0.09728058f, 0.15655583f, 
    -0.15852931f, -0.06010646f, 0.03532163f, 0.08905660f, -0.05357092f, -0.03005367f, 0.03399937f, 0.03735923f, 
    -0.09250792f, 0.06656126f, 0.08935607f, -0.10946426f, -0.04505631f, 0.01146894f, 0.05134897f, 0.08821779f, 
    -0.06230975f, 0.03060084f, 0.04803164f, -0.07264488f, -0.04624263f, -0.03872245f, -0.09131513f, -0.04025064f, 
    -0.02804111f, -0.07982896f, -0.03732275f, -0.07374277f, -0.07994599f, -0.00524499f, -0.02425574f, 0.10773436f, 
    -0.00074314f, -0.09573469f, -0.04892262f, -0.06396438f, 0.04230919f, -0.02358417f, -0.04172708f, -0.12855424f, 
    -0.06234052f, 0.02870410f, -0.07032035f, 0.10807218f, 0.16445287f, -0.10391999f, -0.06355164f, -0.00543931f, 
    -0.07554489f, -0.00706023f, -0.12868989f, 0.05271462f, 0.03500070f, 0.00852091f, 0.06482177f, 0.02348174f, 
    0.09236675f, 0.09452231f, -0.03090880f, -0.03289574f, 0.02086608f, 0.01025856f, -0.01525949f, -0.06276703f, 
    0.06437614f, -0.07922772f, 0.10657092f, -0.07837611f, 0.00711667f, 0.14960992f, 0.16401933f, 0.06767961f, 
    0.07380665f, 0.05676759f, -0.00412449f, 0.02365346f, -0.05586411f, -0.03356378f, -0.09811778f, 0.05504148f, 
    -0.13821165f, -0.00113388f, 0.16033429f, -0.21225925f, 0.08191712f, 0.00713716f, -0.03097549f, 0.00579182f, 
    0.06000567f, -0.05131295f, -0.04954029f, 0.00299183f, 0.07865505f, 0.15362717f, -0.07954933f, -0.07399787f, 
    -0.04362338f, -0.05665999f, -0.00129859f, -0.00600261f, 0.00318169f, -0.12372865f, -0.03957523f, 0.02271350f, 
    -0.19133142f, 0.18163198f, 0.09063177f, 0.08346535f, 0.01395518f, 0.06513058f, 0.12157124f, -0.03667613f, 
    0.00500787f, -0.00995799f, 0.06242492f, -0.01038938f, 0.06298600f, -0.06728332f, -0.01371300f, -0.05607318f, 
    0.01706887f, 0.01568555f, 0.07015916f, -0.03429612f, 0.05963700f, -0.09521219f, 0.01353156f, 0.01182619f, 
    -0.08158796f, 0.38146126f, 0.20155406f, -0.10169426f, 0.05324490f, 0.03630709f, 0.17426698f, -0.04364927f, 
    -0.02436416f, 0.08384179f, -0.04033006f, 0.08151573f, -0.23039551f, 0.15083602f, 0.06006636f, 0.00442787f, 
    -0.00528857f, -0.14096271f, 0.08023562f, 0.05022740f, 0.01120223f, -0.05713518f, 0.07978692f, -0.02535925f, 
    0.05687693f, -0.14287181f, -0.07245982f, -0.02264356f, -0.08876529f, 0.00690533f, -0.00979847f, 0.01716684f, 
    -0.03775771f, 0.02375130f, -0.08609537f, 0.06761070f, -0.15833092f, -0.02096408f, -0.02368062f, -0.19116351f, 
    -0.05132537f, -0.07172788f, 0.03805458f, 0.06795263f, -0.06655304f, -0.05631494f, -0.02816347f, -0.05115595f, 
    0.11624963f, 0.04285377f, 0.01124195f, -0.04946686f, -0.10028537f, 0.05499706f, 0.05778839f, 0.00380773f, 
    0.03119613f, -0.02008488f, 0.07228334f, -0.05829632f, 0.19899176f, -0.10289703f, 0.08008282f, 0.10638352f, 
    -0.01663900f, -0.02452352f, -0.05870123f, 0.13561904f, -0.10079571f, -0.03531828f, -0.03582406f, 0.06143572f, 
    -0.02979335f, -0.11678433f, -0.07250725f, 0.11219800f, -0.00221152f, -0.08813113f, 0.00041835f, -0.02445439f, 
    -0.07714872f, 0.09432064f, -0.05347681f, -0.02474694f, 0.07548950f, -0.15209274f, -0.02160089f, -0.01919074f, 
    -0.08795808f, 0.04563933f, -0.02711524f, -0.04254895f, 0.05190885f, -0.01394051f, -0.04663174f, 0.08546751f, 
    0.68135977f, 0.26930806f, 0.13926446f, -0.03592313f, -0.05158693f, 0.01013373f, -0.01529818f, 0.10022511f, 
    -0.03790062f, -0.03862603f, 0.01485315f, -0.12624094f, 0.34095696f, -0.26914850f, -0.27079338f, 0.06245098f, 
    0.00017151f, 0.05346789f, -0.02988043f, 0.07720631f, 0.07978842f, 0.00774423f, -0.00099822f, -0.15461777f, 
    -0.01032794f, -0.32921445f, -0.12596987f, -0.02852030f, -0.07468261f, 0.01321394f, 0.07658529f, 0.07052594f, 
    -0.05767993f, -0.06159392f, 0.04665500f, 0.00765065f, -0.27197140f, 0.08240718f, 0.11879194f, -0.06648580f, 
    -0.04787429f, 0.04824809f, 0.03518445f, 0.03163378f, 0.02798589f, 0.06742629f, 0.20021807f, -0.02019234f, 
    -0.19375342f, 0.15118700f, -0.34735456f, -0.16887647f, 0.01752472f, 0.07757674f, -0.08658081f, -0.07952951f, 
    -0.07585666f, -0.03659077f, 0.06927875f, 0.00279540f, 0.13838442f, 0.16737629f, 0.05395784f, -0.00037429f, 
    -0.00277360f, -0.06671101f, -0.10287758f, 0.00866418f, -0.02827394f, 0.08736660f, 0.07217243f, -0.03078376f, 
    -0.04895276f, -0.09270614f, -0.02557872f, 0.05765674f, 0.08616895f, -0.08581754f, -0.02541612f, -0.00316171f, 
    0.02834844f, 0.03269804f, 0.02547841f, -0.03107611f, 0.17503485f, -0.21167687f, -0.18265101f, 0.03880335f, 
    -0.00651838f, -0.01053554f, -0.06082014f, 0.04655376f, 0.05760549f, 0.11242560f, 0.00677190f, 0.02437354f, 
    0.17528121f, -0.14356314f, -0.05622261f, -0.03350654f, 0.10596426f, -0.00716492f, 0.00000782f, 0.03080472f, 
    -0.05125215f, -0.02484307f, -0.04471571f, -0.05492125f, 0.20912555f, -0.20027989f, -0.14146303f, -0.06493960f, 
    -0.03687244f, -0.04464284f, 0.01003767f, -0.00051147f, 0.07262921f, -0.00816359f, 0.03173627f, -0.09489410f, 
    -0.21505807f, 0.19947465f, 0.05347101f, 0.20887606f, -0.01604299f, 0.03427637f, 0.01737796f, 0.05818068f, 
    0.01965480f, 0.05617141f, 0.04504476f, -0.05326052f, -0.23136714f, 0.08562006f, -0.01471308f, -0.00641017f, 
    -0.05371587f, -0.13094202f, 0.00611720f, 0.03277695f, -0.02681983f, -0.00095271f, -0.03327443f, -0.08179649f, 
    0.01972743f, -0.00522680f, -0.19189689f, 0.20530999f, -0.00876982f, -0.02341311f, 0.13702892f, 0.03412249f, 
    -0.04714343f, 0.00886355f, -0.04205794f, 0.07796018f, -0.12904182f, -0.06520172f, -0.12183172f, 0.23791119f, 
    0.01511476f, 0.07494336f, -0.06616508f, -0.04796401f, -0.02031652f, -0.03258768f, -0.04135529f, 0.06910248f, 
    -0.19073020f, 0.17601445f, 0.21234320f, 0.05732807f, 0.01521030f, 0.06973473f, -0.06614150f, 0.05893498f, 
    -0.03058149f, 0.04688137f, -0.07840259f, -0.04138458f, -0.11729426f, 0.18169026f, 0.19146718f, 0.28430456f, 
    0.09808938f, 0.02524438f, 0.05314209f, -0.09679690f, -0.05783034f, 0.03384608f, -0.06145370f, -0.09373996f, 
    -0.22919527f, -0.49563420f, -0.07399841f, 0.00022567f, -0.04165972f, 0.07989126f, -0.04966245f, -0.05488745f, 
    -0.02876306f, -0.14645857f, 0.09584565f, -0.03428470f, -0.08893176f, 0.05518888f, 0.15126476f, 0.04513062f, 
    -0.04812402f, -0.11834314f, 0.07814302f, 0.00425421f, -0.00410950f, -0.06629646f, -0.05458832f, 0.03099179f, 
    -0.00666062f, -0.02660880f, -0.46202904f, 0.16178024f, -0.12373817f, 0.02065860f, 0.02013263f, -0.03840275f, 
    -0.00275748f, -0.04315910f, -0.11243237f, 0.05719972f, 0.20657305f, 0.04098856f, -0.15181357f, -0.01453121f, 
    -0.04456374f, -0.06366643f, 0.03760397f, -0.07563243f, -0.00375265f, 0.04821523f, 0.02591435f, 0.02467979f, 
    0.07237498f, -0.09182222f, 0.13919306f, -0.03379282f, 0.01171303f, 0.12349132f, -0.02119203f, -0.05697809f, 
    0.09069659f, 0.01084935f, 0.04022061f, -0.09515730f, -0.16196245f, 0.04268688f, -0.04281579f, -0.16361997f, 
    -0.07694185f, 0.02819805f, 0.04191496f, -0.04287231f, -0.02571893f, 0.00048585f, 0.11473561f, -0.11880457f, 
    -0.03705487f, 0.03179203f, 0.14960600f, 0.15860511f, 0.07389473f, 0.10546464f, -0.17110543f, 0.03311466f, 
    0.00604120f, 0.06477216f, -0.03446326f, -0.18037567f, 0.01067066f, 0.04326240f, 0.11712667f, -0.04838209f, 
    0.01794683f, 0.05762917f, -0.02883141f, 0.08769721f, -0.01837380f, 0.04912719f, -0.05657393f, -0.04533457f, 
    0.09987234f, -0.02327551f, 0.13160022f, 0.01325633f, -0.04521273f, -0.11356534f, -0.08482946f, 0.00033472f, 
    -0.07016315f, -0.07178289f, -0.04395144f, 0.01434537f, -0.47426882f, -0.25768185f, 0.06205329f, 0.02727035f, 
    -0.06352462f, -0.04728970f, 0.03308806f, -0.09261786f, 0.00378923f, -0.00350947f, -0.05152292f, 0.13341770f, 
    0.00739723f, 0.04907019f, 0.10156459f, 0.04538300f, -0.16778080f, 0.03810728f, 0.12740529f, -0.08886436f, 
    -0.02895294f, -0.00690733f, -0.06128564f, 0.03315829f, 0.18432568f, 0.22145425f, 0.03570239f, 0.05200688f, 
    0.00726101f, -0.03975053f, -0.00823982f, 0.02088316f, -0.09569351f, 0.10303325f, -0.02169985f, 0.06657424f, 
    -0.12899071f, 0.13447718f, 0.10178420f, -0.04104863f, -0.05798295f, 0.09919158f, 0.04551522f, -0.01204564f, 
    -0.04722084f, -0.05052222f, -0.07131145f, 0.01173770f, 0.12055279f, -0.00280379f, 0.06307799f, -0.03886541f, 
    -0.04682703f, -0.04707896f, 0.01048597f, 0.02957261f, -0.10468531f, -0.01810933f, -0.02224660f, 0.04316287f, 
    0.00712495f, -0.06458682f, 0.00806103f, -0.02681356f, -0.10283764f, -0.08235238f, -0.07415070f, 0.11520926f, 
    -0.00246130f, -0.01349564f, 0.01666522f, 0.08299240f, -0.05686284f, -0.02926107f, 0.17824233f, 0.12906644f, 
    0.01011788f, 0.11722337f, -0.01654301f, 0.03208025f, -0.05415980f, -0.06609788f, 0.04223106f, 0.05269083f, 
    -0.67699021f, -0.32581389f, -0.22194460f, 0.02798345f, -0.11356644f, -0.10414114f, -0.06257388f, 0.01596802f, 
    -0.04871370f, -0.05188881f, -0.02237547f, -0.05076336f, 0.11852530f, 0.10344403f, 0.07376862f, -0.05653563f, 
    -0.12132179f, 0.07098202f, 0.04837433f, 0.01740852f, -0.02269388f, 0.11287000f, -0.06973943f, 0.00914426f, 
    -0.15545832f, 0.22936608f, -0.03887186f, 0.13948072f, 0.04701170f, 0.03726986f, 0.00283068f, 0.01636720f, 
    0.01142085f, -0.00499531f, -0.02152080f, 0.03153677f, -0.40469229f, -0.23313555f, -0.34689084f, 0.01283493f, 
    -0.09289934f, 0.02145948f, 0.01977610f, -0.01705920f, -0.06463955f, 0.06713495f, -0.08782061f, -0.05270069f, 
    -0.23166347f, -0.02363950f, -0.01435812f, 0.00016714f, -0.02279732f, -0.07824921f, -0.12304518f, -0.08382583f, 
    -0.00714941f, 0.12576899f, 0.02269916f, 0.02412564f, -0.32445303f, -0.10540769f, 0.06734101f, -0.12269773f, 
    -0.00542843f, -0.06726687f, -0.12564982f, -0.03334115f, -0.04195840f, 0.02892230f, 0.04323651f, 0.06161330f, 
    0.05946866f, -0.02913905f, -0.05478031f, -0.06867661f, -0.10153221f, -0.07117339f, -0.00648396f, 0.01976183f, 
    -0.00642084f, -0.07634322f, -0.03318885f, 0.04068654f, -0.05052740f, -0.02132526f, 0.03663194f, 0.01005288f, 
    -0.14739662f, 0.07043335f, -0.02196579f, -0.00628625f, -0.05939919f, 0.03797500f, 0.02198037f, 0.08426061f, 
    -0.47744957f, -0.25344452f, 0.14088428f, -0.07191411f, -0.08607443f, 0.04540689f, 0.08397802f, -0.03416976f, 
    0.01070491f, -0.12704679f, 0.02416934f, -0.02798715f, 0.03971677f, -0.13449825f, 0.07164797f, 0.06768408f, 
    0.00293697f, 0.00739088f, -0.07071633f, 0.11783170f, 0.01874371f, 0.02903979f, 0.01600829f, 0.16978028f, 
    0.17053846f, 0.19448300f, -0.03793616f, -0.11650072f, -0.07194900f, -0.16575736f, -0.01346599f, 0.02708753f, 
    -0.03685677f, -0.04031681f, -0.01305747f, 0.07921878f, 0.07026716f, 0.03813225f, -0.08569256f, -0.00306220f, 
    -0.06121742f, 0.08160768f, -0.09467732f, -0.02423400f, 0.01472045f, 0.04320943f, 0.06350785f, -0.04378517f, 
    0.07932284f, -0.00269656f, 0.08515677f, -0.12279882f, -0.04806040f, 0.01120937f, -0.02472880f, 0.10238336f, 
    -0.01384218f, -0.01304419f, 0.08472048f, -0.03823311f, 0.03594539f, -0.01122384f, -0.03963747f, 0.01115003f, 
    -0.05282075f, -0.02544513f, -0.01228996f, 0.07019548f, 0.01439789f, -0.11070614f, 0.08626625f, -0.06004791f, 
    -0.05526556f, -0.20104146f, -0.18821090f, 0.03064815f, -0.08628073f, -0.00464371f, -0.03894485f, -0.00126418f, 
    -0.00614549f, 0.07555101f, 0.02461014f, 0.03706279f, 0.06636147f, 0.09110534f, 0.04322823f, -0.16166380f, 
    -0.02458567f, 0.00235382f, 0.05115402f, 0.06409089f, 0.02835866f, -0.04891303f, -0.10218725f, 0.01902938f, 
    -0.44939470f, 0.32360336f, 0.06484710f, 0.00146142f, 0.09381906f, -0.01807753f, 0.08041265f, 0.01689805f, 
    0.03121032f, -0.04923872f, -0.10276851f, 0.16092229f, -0.01702572f, 0.09837379f, -0.23016533f, 0.00145146f, 
    -0.06758583f, 0.06325449f, -0.03929408f, 0.11501243f, -0.00860202f, -0.10895558f, 0.04881749f, 0.08918513f, 
    -0.22242977f, 0.12770371f, -0.03890150f, -0.14484052f, 0.03000466f, -0.00423489f, -0.02546124f, 0.12027796f, 
    0.04623392f, -0.18930535f, -0.00383610f, -0.10714473f, -0.33043319f, 0.03428474f, 0.08784828f, -0.08310063f, 
    0.16859843f, -0.00863459f, 0.03611825f, 0.01626465f, 0.02024774f, -0.01100229f, -0.01885387f, 0.06795093f, 
    0.34143782f, 0.16629286f, -0.10015953f, -0.06183134f, 0.02347761f, 0.00486134f, -0.03166322f, 0.03100235f, 
    -0.06006169f, 0.04450895f, 0.01063920f, 0.01026185f, 0.10912161f, -0.01453103f, -0.04430262f, 0.11557620f, 
    0.13221179f, -0.03672773f, 0.00312414f, -0.03750940f, -0.07647669f, 0.07533573f, -0.08978288f, -0.02312438f, 
    0.20025823f, -0.09366814f, -0.20700893f, 0.01342627f, -0.04563097f, -0.00257450f, 0.12658218f, -0.04523693f, 
    0.02679265f, -0.02305551f, 0.08300891f, -0.06090324f, -0.32843000f, 0.02452045f, 0.05278153f, 0.08447902f, 
    0.07310373f, 0.05236395f, 0.00041518f, 0.07690596f, -0.12304159f, -0.16175547f, 0.04509084f, 0.02222192f, 
    0.08127176f, -0.00174028f, 0.10176813f, -0.06838708f, -0.10186399f, -0.11880590f, 0.07413054f, -0.04920293f, 
    -0.08313622f, -0.12556168f, 0.09146296f, -0.01687584f, 0.46898291f, 0.34049711f, -0.40199140f, -0.15121302f, 
    -0.12559961f, -0.12665001f, 0.09386353f, 0.01198990f, -0.05833958f, -0.02141005f, -0.01293200f, 0.03595283f, 
    -0.37298441f, -0.02891048f, 0.16407575f, 0.04623127f, -0.03524438f, 0.03952182f, 0.00108327f, 0.08088993f, 
    -0.01641643f, 0.05139002f, 0.11691993f, -0.01025232f, -0.37143385f, -0.01868804f, 0.18703409f, 0.18137327f, 
    0.04104455f, 0.07131156f, 0.00764333f, 0.02358323f, 0.06276620f, 0.07038006f, 0.05381658f, 0.02860886f, 
    0.02176964f, -0.02111170f, -0.00279773f, 0.00880006f, -0.03898900f, -0.20308846f, 0.10748971f, -0.04129666f, 
    -0.04402062f, 0.00262923f, 0.00864331f, -0.14000125f, -0.49105334f, 0.02259046f, -0.00024634f, -0.09244578f, 
    0.05521005f, 0.04521765f, 0.00202929f, 0.10808840f, -0.11605863f, 0.07044943f, 0.12252916f, 0.01654434f, 
    0.03746781f, 0.05689966f, -0.16277820f, -0.21393593f, -0.03730496f, -0.06802388f, 0.05943710f, -0.06068940f, 
    0.00810899f, 0.05017808f, 0.03812905f, -0.14262350f, 0.16229820f, 0.01887346f, 0.18157028f, 0.08179490f, 
    0.04844558f, 0.01865669f, 0.13009290f, 0.10446725f, 0.00527528f, 0.00511116f, -0.06470084f, 0.01692011f, 
    0.03345034f, 0.06893278f, -0.07561237f, -0.20987424f, 0.00753153f, 0.02399935f, -0.02403096f, -0.04706315f, 
    0.00704272f, -0.04874859f, -0.04577049f, -0.08125439f, -0.27174163f, -0.28482893f, 0.18128195f, 0.14439826f, 
    -0.15860301f, -0.05215396f, -0.01925303f, -0.15388149f, 0.10461768f, 0.02024719f, -0.06052433f, -0.12653930f, 
    -0.01529069f, -0.26121551f, 0.04906171f, -0.18472786f, -0.00296894f, 0.11376662f, -0.08338465f, 0.01134053f, 
    0.07897507f, 0.05354610f, -0.03078420f, -0.05279230f, -0.03286080f, 0.02085942f, 0.09849864f, -0.00951776f, 
    -0.00729134f, -0.06706773f, -0.01356604f, 0.01521742f, -0.01363694f, 0.01919081f, -0.01854534f, -0.00571758f, 
    -0.31633905f, -0.10432173f, -0.15253216f, 0.05794390f, 0.04026743f, 0.03838326f, 0.17567471f, -0.12873067f, 
    -0.02194816f, 0.01800686f, 0.02569265f, 0.06253300f, 0.04801723f, -0.13487580f, 0.16676962f, -0.00067817f, 
    0.01722336f, 0.02689605f, 0.11284092f, 0.00609125f, -0.13920590f, -0.06575031f, -0.06674609f, 0.15023394f, 
    -0.14953588f, -0.01347817f, 0.03573140f, -0.27763596f, 0.02813039f, 0.08695522f, 0.01734685f, 0.11861546f, 
    0.01460558f, -0.09626203f, 0.03072283f, 0.00234683f, -0.12120006f, -0.19040354f, 0.08447850f, 0.02156364f, 
    -0.13583861f, 0.10268877f, 0.02062679f, -0.02121004f, 0.06842700f, 0.04858403f, 0.03169157f, -0.00725003f, 
    0.17614509f, 0.03793293f, 0.10579754f, -0.00531920f, 0.01527121f, 0.01441556f, -0.02917232f, -0.07363137f, 
    0.01814818f, 0.01356903f, 0.04686444f, 0.06384343f, 0.02265575f, 0.07157199f, -0.07118239f, 0.10009801f, 
    -0.02091475f, 0.04346104f, -0.04455902f, -0.05831005f, -0.00118927f, -0.02233438f, 0.00718287f, -0.09461408f, 
    -0.18860316f, -0.04969387f, 0.18931015f, -0.09207243f, 0.07319172f, 0.05313731f, 0.01128834f, -0.08113023f, 
    0.01783628f, -0.14607002f, 0.04056478f, -0.04811952f, -0.21269895f, 0.12438455f, -0.10467077f, 0.07346209f, 
    0.04170823f, 0.00870199f, 0.04721830f, -0.03501544f, -0.04848817f, -0.06762708f, 0.13624902f, 0.03648319f, 
    -0.23015627f, 0.10615062f, 0.00058672f, 0.06737916f, -0.04055768f, 0.19277231f, 0.05572988f, 0.05431845f, 
    0.00371693f, 0.04641598f, -0.03710851f, 0.04063323f, -0.27875632f, -0.16560249f, 0.17225428f, 0.08911812f, 
    -0.07340138f, 0.03099411f, -0.09567311f, -0.01730414f, 0.13986161f, -0.07076071f, 0.00356630f, 0.03174566f, 
    -0.16661787f, 0.07150853f, 0.29649839f, 0.12464940f, -0.02686320f, -0.01946080f, -0.04090014f, -0.03035587f, 
    0.14806731f, -0.07247700f, -0.06188845f, -0.01037869f, -0.08487003f, -0.06916316f, 0.23908524f, 0.02754803f, 
    0.14408813f, -0.08278731f, -0.03373437f, 0.00641590f, 0.05405305f, 0.04237782f, 0.09907623f, -0.09503502f, 
    0.33830440f, 0.12078932f, 0.06490674f, 0.03859260f, 0.04202989f, 0.03013132f, 0.01713705f, 0.01317222f, 
    0.07636739f, 0.02388589f, 0.03040203f, 0.10102975f, 0.00028994f, 0.01763795f, -0.05854550f, 0.11305104f, 
    0.16118315f, -0.06579379f, 0.01390627f, 0.04783427f, 0.06921134f, -0.03453797f, -0.01173136f, 0.07608635f, 
    -0.02727901f, -0.10673099f, -0.05153980f, 0.11647942f, -0.13379166f, -0.05372855f, 0.13282536f, 0.04030715f, 
    -0.00046764f, -0.06948254f, 0.00090587f, -0.01446791f, -0.35373345f, 0.06108681f, -0.22403581f, -0.34725037f, 
    -0.02550113f, -0.05376328f, -0.11298818f, 0.05293218f, -0.02701499f, 0.02799140f, -0.05269006f, 0.02039812f, 
    0.22733229f, 0.07327101f, 0.07529122f, 0.06432359f, -0.04756420f, -0.08407404f, -0.05851498f, -0.08416927f, 
    -0.03534369f, -0.04082751f, -0.04616179f, 0.08944490f, -0.31791162f, -0.20223185f, 0.07967463f, 0.23004618f, 
    0.03112445f, -0.02749580f, 0.02715567f, -0.04220420f, 0.02135906f, 0.00915986f, 0.09548472f, 0.06175089f, 
    -0.38063508f, -0.09641276f, 0.14744481f, -0.01183260f, 0.01741851f, 0.01794119f, -0.17008272f, -0.15617745f, 
    0.01537287f, -0.09809193f, -0.11380155f, 0.05281664f, -0.47192341f, 0.08652741f, 0.00909225f, -0.15161137f, 
    0.07822343f, 0.02175017f, -0.02362440f, 0.01508755f, -0.05694014f, 0.02622818f, 0.11692783f, -0.06420229f, 
    -0.08164556f, -0.14920925f, -0.06673036f, -0.03044274f, 0.01556356f, -0.01937744f, 0.01304139f, 0.10889734f, 
    -0.01762541f, 0.09081758f, -0.09270861f, -0.04610237f, -0.03621991f, 0.00774954f, -0.02915857f, 0.00496359f, 
    -0.01413749f, -0.14960618f, 0.01827864f, 0.07860073f, -0.01635839f, -0.03176532f, -0.04331645f, -0.18636794f, 
    0.03641233f, -0.14356090f, -0.38936925f, 0.01980507f, 0.05771827f, -0.10752574f, 0.08271492f, -0.07232229f, 
    -0.04223761f, 0.03380469f, 0.12118635f, 0.04303443f, 0.02808352f, 0.01477847f, 0.01207028f, -0.26980230f, 
    0.01890697f, 0.01156723f, 0.12448833f, -0.03387579f, 0.10396231f, 0.05983312f, -0.09981647f, 0.02368871f, 
    -0.55692416f, 0.24380137f, 0.00454440f, -0.12071194f, -0.02379998f, -0.00930422f, -0.05421981f, 0.05553645f, 
    -0.05164824f, -0.02912781f, -0.00054252f, -0.02886547f, -0.04395965f, 0.04477352f, -0.00641078f, -0.26744106f, 
    -0.02926932f, 0.06570528f, -0.06839414f, 0.02065559f, -0.10538439f, 0.04488672f, -0.05609810f, 0.03772239f, 
    -0.13341986f, -0.00717148f, 0.11830892f, -0.03409022f, 0.01545982f, 0.06366417f, -0.02644886f, 0.09933294f, 
    0.01775759f, -0.03267886f, -0.01426741f, -0.01475442f, -0.09446617f, 0.08193275f, -0.00026556f, -0.03257072f, 
    0.02889687f, -0.04633352f, 0.04633677f, 0.00667449f, -0.03447889f, 0.01695894f, -0.05701901f, 0.04300125f, 
    -0.39650533f, -0.03883498f, 0.06759277f, 0.04555182f, -0.07168128f, -0.03188233f, -0.10435954f, 0.06593348f, 
    0.13325982f, -0.05165668f, 0.01177223f, -0.11496492f, 0.21864055f, -0.12437239f, -0.15375547f, -0.00816631f, 
    -0.10562446f, 0.00783508f, 0.05486961f, 0.00881530f, -0.04774510f, 0.00385026f, -0.06884337f, 0.09274850f, 
    -0.08960000f, -0.20897935f, 0.11312787f, -0.10388712f, -0.01480513f, 0.05711720f, -0.02995213f, 0.00553535f, 
    0.06621794f, 0.01203153f, -0.11090570f, 0.08669458f, -0.16578722f, -0.03876273f, 0.12894182f, -0.02224302f, 
    0.00321097f, -0.05199694f, -0.16926198f, 0.01660282f, 0.02849884f, -0.03286030f, -0.03000962f, -0.00824028f, 
    0.00422493f, -0.02305147f, -0.01472676f, 0.20143382f, -0.07725195f, 0.07398223f, 0.09320877f, -0.02214438f, 
    -0.12155189f, 0.08114729f, 0.03151772f, 0.13096674f, -0.07954642f, 0.11240417f, -0.02269094f, 0.00932983f, 
    0.03114468f, -0.08934409f, -0.08994672f, 0.03509190f, -0.00889795f, -0.05683890f, 0.02994314f, -0.03532296f, 
    -0.20558648f, 0.03076900f, 0.05769256f, 0.22092398f, 0.07494855f, -0.00306750f, 0.00956460f, 0.08891544f, 
    -0.02173848f, 0.00661264f, 0.03738405f, -0.05987448f, -0.19613299f, -0.11687250f, 0.09229492f, 0.15259384f, 
    -0.04135444f, 0.01572161f, 0.04948671f, 0.01255257f, 0.08627933f, -0.04813310f, 0.06181717f, 0.06442097f, 
    0.23580433f, 0.07794929f, 0.11172831f, 0.07664414f, 0.07032679f, -0.02855666f, 0.03368980f, 0.03060396f, 
    0.03080280f, 0.04906220f, -0.02593905f, -0.06926879f, -0.12892944f, 0.24188687f, 0.12292507f, -0.00178478f, 
    -0.19501632f, -0.00167466f, 0.05086331f, -0.09925420f, 0.03291777f, -0.13898635f, 0.15730520f, 0.04708828f, 
    -0.00792583f, 0.03627693f, -0.03498043f, -0.02348340f, 0.11725602f, 0.02949210f, -0.05327121f, -0.01473376f, 
    0.06306808f, 0.05557558f, -0.05114458f, -0.11609214f, 0.06849360f, -0.13437852f, 0.02850712f, 0.32840568f, 
    -0.06770784f, -0.00122790f, 0.11598750f, 0.07727204f, 0.05596497f, -0.03158095f, 0.00790050f, -0.04384695f, 
    0.01002105f, 0.12979965f, 0.01664707f, -0.02656493f, 0.04015010f, -0.07437032f, 0.11627088f, 0.04231557f, 
    -0.00089850f, 0.05173676f, 0.00674165f, -0.09426978f, -0.33726263f, 0.06561584f, 0.04697269f, 0.19555533f, 
    0.08910009f, 0.12981719f, -0.04481403f, 0.11606397f, -0.02986090f, 0.09523106f, -0.07039618f, -0.04956627f, 
    -0.18341361f, 0.13108213f, 0.12999399f, -0.12751940f, -0.02680442f, 0.05345085f, -0.00137040f, -0.06384002f, 
    -0.01676410f, -0.05239459f, -0.07029731f, -0.06274885f, 0.16824315f, 0.01302285f, 0.04645821f, 0.03010398f, 
    -0.03574011f, -0.10327897f, 0.12659533f, 0.04636010f, 0.01695267f, 0.01119613f, -0.10535858f, 0.02994482f, 
    -0.36163417f, -0.09709565f, -0.10531101f, -0.13888112f, 0.01129060f, 0.00033069f, 0.00580555f, 0.12735276f, 
    -0.05605020f, -0.06328564f, 0.18003109f, -0.07792456f, 0.05379666f, 0.02350477f, 0.17907719f, -0.00210779f, 
    0.16403222f, -0.03864331f, 0.01259408f, -0.12814453f, -0.06182064f, -0.01378025f, -0.08678769f, -0.13534074f, 
    -0.53932738f, 0.01348971f, -0.06292940f, -0.06044538f, 0.10555129f, 0.02532409f, 0.09139952f, -0.15714280f, 
    -0.02418068f, 0.11146382f, -0.06869196f, 0.08321355f, -0.10197113f, -0.09231780f, 0.16112258f, -0.02173676f, 
    -0.00785054f, 0.00757392f, 0.10704663f, 0.05115168f, -0.11451140f, 0.10025182f, 0.20734297f, -0.02399718f, 
    -0.06407721f, -0.19920836f, -0.05918765f, 0.04583546f, 0.09474331f, -0.02597553f, 0.00691556f, -0.16447701f, 
    -0.01713889f, 0.04321867f, 0.01777495f, 0.01124270f, -0.17169417f, -0.03749351f, -0.04934579f, -0.00825812f, 
    0.07595907f, -0.10091604f, 0.00001556f, 0.10578637f, 0.13978179f, -0.12258479f, -0.01777859f, -0.16697519f, 
    0.24148668f, 0.04776708f, -0.01383154f, -0.23432599f, -0.06059470f, -0.10263344f, -0.04918285f, -0.09267259f, 
    0.00425722f, 0.01898646f, 0.04526868f, 0.07640687f, -0.14305528f, 0.09648030f, -0.35391104f, 0.07751321f, 
    0.03610652f, 0.02312883f, 0.11232504f, -0.03856289f, 0.14456579f, 0.04952818f, -0.02045164f, -0.15131208f, 
    -0.22701867f, -0.24394470f, -0.11531313f, 0.27903807f, 0.00900655f, 0.01030316f, 0.02273403f, 0.18203454f, 
    0.13038088f, 0.18663397f, -0.14275917f, 0.06069805f, -0.05394533f, -0.09427303f, 0.39948663f, 0.12437611f, 
    0.02607171f, -0.01304751f, -0.01780193f, -0.06725791f, 0.01878884f, -0.02536955f, -0.12899609f, 0.02384908f, 
    -0.08016668f, -0.06370036f, -0.20578054f, -0.02039080f, 0.02650682f, 0.10301658f, 0.04644626f, -0.01747909f, 
    -0.00811926f, -0.11694806f, -0.24649501f, 0.11352964f, 0.07546429f, -0.04215794f, -0.30586109f, 0.02448035f, 
    0.02085459f, 0.06428979f, -0.13769579f, -0.00272875f, 0.10457676f, -0.09884635f, -0.05500740f, 0.01929312f, 
    0.01133122f, 0.07313320f, 0.05224944f, 0.18820812f, 0.01098249f, 0.01513452f, -0.01986188f, -0.11446858f, 
    0.00283453f, 0.05511985f, 0.01354102f, -0.02826658f, -0.37905100f, 0.10284625f, -0.24411947f, 0.01801459f, 
    0.13934693f, -0.11028259f, 0.06795039f, 0.00057400f, -0.06302525f, 0.03920026f, -0.05628911f, -0.09660397f, 
    -0.06871006f, 0.05765595f, 0.16813779f, -0.07174581f, 0.04240927f, 0.05321549f, -0.15711632f, 0.04039444f, 
    0.10786550f, -0.00174020f, 0.03087457f, 0.06634979f, -0.22611393f, -0.15153559f, -0.01338374f, 0.12541002f, 
    0.11678375f, -0.06104584f, -0.10781017f, 0.07737906f, 0.08227082f, 0.08795504f, -0.00365307f, 0.07702842f, 
    -0.26111642f, -0.13456014f, 0.22276984f, 0.30746555f, -0.10847465f, -0.00801727f, 0.00167698f, -0.03801308f, 
    -0.02655032f, -0.00416650f, -0.03951822f, 0.04028919f, 0.02276799f, -0.00011193f, 0.07554169f, 0.08643635f, 
    -0.07549673f, -0.01774381f, -0.01856119f, 0.01712150f, -0.01172244f, 0.02664075f, 0.06689687f, 0.05826230f, 
    0.09766030f, 0.06493843f, -0.11940891f, 0.05715229f, -0.00488495f, 0.00113083f, 0.01082990f, 0.14454488f, 
    -0.02956805f, -0.02343955f, 0.12168159f, -0.02669916f, -0.01971770f, -0.12886631f, 0.11856817f, 0.09367667f, 
    0.04692931f, -0.05047667f, 0.10894930f, -0.07486875f, -0.06141115f, 0.01186138f, -0.04203684f, -0.02339047f, 
    -0.13070065f, 0.17000341f, 0.04246898f, -0.25755498f, 0.01628290f, -0.08315570f, -0.16364852f, -0.01064018f, 
    0.06749248f, -0.14410040f, -0.06463857f, 0.01200691f, 0.03858534f, 0.13444446f, 0.03085888f, 0.19541819f, 
    0.08801091f, 0.08873604f, 0.11058615f, 0.00682446f, -0.02215259f, 0.03029004f, 0.04480539f, -0.09765333f, 
    0.28252044f, 0.06149403f, -0.01579920f, -0.11009569f, 0.04097304f, -0.22817700f, -0.05653029f, 0.12009501f, 
    -0.04844724f, 0.07189312f, -0.12910223f, -0.04348367f, -0.01612288f, 0.10861375f, 0.05183900f, 0.09313863f, 
    0.02996896f, -0.12188698f, 0.03509179f, 0.05825141f, 0.08766724f, -0.19847451f, -0.02121760f, -0.14593127f, 
    -0.27114791f, -0.30980405f, -0.10886119f, 0.08736201f, -0.00352832f, -0.05659630f, 0.01768227f, -0.06470708f, 
    -0.00968856f, 0.00187673f, 0.11927687f, 0.00865327f, 0.24261662f, 0.06716496f, 0.11785357f, -0.23365977f, 
    -0.09458765f, -0.08488487f, -0.13001062f, -0.06330525f, -0.09177889f, -0.00709933f, -0.09985350f, -0.15581580f, 
    -0.06708356f, -0.02091471f, 0.12051652f, 0.30308628f, -0.12548883f, 0.09556984f, 0.11679453f, 0.10304163f, 
    -0.18459338f, -0.03906238f, -0.06447494f, 0.01925944f, -0.15698680f, 0.03769727f, 0.00699826f, -0.04041016f, 
    0.08318098f, 0.12483750f, 0.02166245f, -0.00705678f, 0.11653539f, -0.12004565f, -0.07554291f, -0.09749195f, 
    -0.08032425f, -0.09659591f, 0.16183208f, -0.08452509f, 0.14972712f, -0.00938310f, -0.01530693f, -0.02772584f, 
    0.02219887f, -0.05913201f, -0.01816739f, 0.01433845f, 0.01069462f, -0.05153543f, 0.09278655f, 0.09280395f, 
    -0.00309407f, -0.13612099f, -0.00251699f, 0.06223175f, 0.06377661f, -0.11946217f, 0.03714338f, 0.07251754f, 
    0.08304053f, -0.02181447f, -0.02581122f, -0.01791912f, 0.05548282f, -0.10598365f, -0.00348964f, 0.02708725f, 
    0.01881940f, -0.00385998f, 0.09295944f, 0.14945500f, 0.11730136f, 0.06751912f, -0.12099449f, -0.00377895f, 
    -0.05555907f, 0.04609147f, -0.05356303f, -0.03456204f, -0.00776939f, -0.01747111f, 0.10960206f, 0.27875027f, 
    0.04579037f, 0.00597735f, 0.07162219f, -0.05371382f, -0.06496860f, 0.00272130f, -0.03271488f, -0.04640276f, 
    0.07777460f, 0.05700650f, 0.04453520f, 0.07935329f, 0.14919141f, -0.01850091f, -0.07479605f, -0.05987273f, 
    0.14487579f, -0.03610310f, -0.03093568f, 0.06228367f, 0.03714133f, 0.01825867f, 0.18292738f, -0.01320969f, 
    0.09381493f, 0.08049202f, -0.00546889f, -0.03325489f, -0.00082820f, -0.02513872f, 0.03924620f, -0.02008110f, 
    -0.04741564f, 0.07772223f, -0.06973133f, 0.04117426f, -0.40886456f, -0.09035388f, -0.00578720f, -0.04495812f, 
    -0.03029909f, 0.05844511f, 0.10853446f, 0.01010470f, -0.06021709f, 0.09355401f, 0.00729578f, 0.04987480f, 
    -0.10824287f, -0.02857967f, 0.04937011f, -0.14944005f, -0.00408464f, -0.07547535f, 0.01680972f, 0.14989124f, 
    0.01210184f, -0.07756219f, -0.03782779f, -0.09763712f, 0.29700339f, 0.11112175f, -0.30133539f, -0.12633468f, 
    0.10427608f, 0.02754452f, -0.12024937f, -0.00786726f, 0.01029195f, -0.00448680f, -0.13394621f, -0.13113661f, 
    -0.01630199f, -0.02800654f, 0.05013605f, -0.09401399f, 0.03009372f, 0.00852958f, 0.06053534f, -0.01912219f, 
    -0.08863109f, 0.03726375f, 0.09804463f, 0.10159867f, -0.24417049f, 0.00852862f, -0.00577207f, -0.10470290f, 
    0.11883662f, -0.21640682f, -0.02827514f, 0.12773323f, -0.02644358f, -0.04105273f, 0.10552039f, -0.12169747f, 
    -0.16527715f, -0.07341690f, -0.10188345f, 0.02360093f, 0.00185357f, 0.01830095f, 0.13007635f, -0.00618700f, 
    0.16814511f, -0.11381815f, -0.02172071f, 0.27627093f, -0.07263129f, 0.08105706f, 0.20805743f, -0.26309788f, 
    0.12999898f, 0.01350349f, 0.02941399f, -0.07073756f, -0.03381893f, 0.04415669f, 0.07053705f, 0.13675494f, 
    -0.04593350f, 0.14571145f, 0.12318699f, -0.15356438f, 0.02523427f, 0.13469541f, -0.20874751f, -0.11117636f, 
    -0.00912178f, -0.04023795f, 0.01157537f, 0.05335343f, -0.28398609f, -0.06045165f, 0.05780558f, 0.11415703f, 
    -0.05228618f, -0.05543819f, 0.05488915f, 0.00159165f, -0.02694745f, -0.07362394f, 0.10828873f, -0.32407439f, 
    -0.24175309f, 0.12788987f, -0.05994603f, -0.18568732f, 0.00297768f, -0.01297748f, -0.10775239f, 0.01513507f, 
    -0.08357424f, -0.11559031f, 0.07571932f, -0.16574509f, -0.05651864f, -0.06780054f, -0.03758783f, -0.01139613f, 
    0.07660402f, -0.00885675f, -0.04278763f, 0.03995434f, -0.04877840f, 0.03788863f, 0.15186948f, -0.00341618f, 
    -0.02049421f, -0.06475744f, -0.03367417f, 0.14556295f, 0.00513434f, 0.04328866f, 0.03138486f, -0.00948605f, 
    0.05682207f, 0.04466646f, 0.11205196f, -0.01059195f, -0.01714430f, 0.17813095f, 0.00542991f, 0.07718005f, 
    0.02489453f, 0.10816099f, 0.04646185f, -0.01563864f, 0.11305494f, -0.06286373f, 0.26623613f, -0.02593609f, 
    0.10146394f, 0.00519809f, 0.05080818f, 0.04366080f, -0.07919387f, 0.09332316f, 0.03602721f, 0.06636977f, 
    -0.06303671f, 0.02998755f, 0.14340803f, 0.11934671f, 0.06252690f, 0.00204078f, -0.02408518f, 0.17836839f, 
    0.11259110f, 0.04227564f, -0.10688911f, -0.12666781f, -0.03364271f, -0.06567799f, -0.05595991f, -0.01819863f, 
    0.07816602f, 0.00788771f, 0.12727933f, 0.22067180f, -0.00978880f, -0.10676332f, -0.09017792f, 0.02494542f, 
    -0.00973190f, 0.12328191f, 0.01580856f, -0.05704015f, 0.07037570f, -0.04100329f, -0.10483406f, 0.19500688f, 
    0.04056208f, 0.08700000f, -0.01321870f, -0.00709847f, 0.20673397f, -0.01801899f, 0.00270580f, 0.08850449f, 
    0.13397792f, -0.00651210f, 0.14380988f, -0.19665374f, 0.03566532f, -0.00176655f, -0.03789424f, -0.04371807f, 
    -0.14404449f, -0.12756224f, -0.17139198f, -0.20847946f, -0.15842643f, -0.07155593f, 0.11899716f, 0.01257857f, 
    -0.23556365f, 0.02643472f, 0.14634764f, 0.16923878f, 0.08993647f, 0.04686793f, -0.07727771f, -0.30431855f, 
    -0.61478835f, -0.21741904f, -0.29964703f, -0.00271231f, 0.10060034f, 0.06157347f, 0.00537055f, -0.06385612f, 
    0.01653253f, 0.05144752f, 0.01435337f, 0.01966738f, 0.29244873f, -0.22772542f, -0.25404215f, 0.00910787f, 
    -0.05131797f, -0.02775730f, -0.19028911f, -0.09628152f, -0.00896277f, -0.10415434f, -0.03331531f, -0.04040582f, 
    -0.00040135f, 0.01874814f, 0.12797925f, 0.05234415f, -0.07290618f, 0.06133042f, 0.10317254f, -0.08020785f, 
    -0.09912380f, 0.00345616f, 0.13439263f, 0.14683141f, -0.12136560f, -0.22663198f, -0.16036242f, 0.16076860f, 
    0.10104438f, 0.06763843f, -0.09178824f, -0.06909794f, -0.01101765f, 0.07740616f, -0.01279711f, -0.04227539f, 
    -0.24535799f, -0.11002883f, -0.02075037f, 0.13878690f, 0.02236754f, 0.17419958f, 0.03929650f, -0.05990338f, 
    0.01397007f, -0.06089783f, 0.08369610f, -0.04403401f, -0.20757787f, -0.11002918f, -0.03926183f, -0.12063035f, 
    0.02844189f, 0.11210679f, -0.13594975f, -0.00590182f, -0.01348831f, 0.09559399f, 0.08976407f, 0.00384858f, 
    -0.10815729f, -0.16889754f, 0.09121822f, 0.01559944f, 0.16377957f, -0.13810694f, 0.12711677f, 0.02058559f, 
    -0.00751700f, -0.12223905f, -0.18286631f, 0.16254173f, -0.11339033f, -0.00789344f, -0.17196670f, -0.13666211f, 
    0.08335418f, -0.05188356f, 0.08498112f, -0.07774885f, -0.06516499f, 0.00802852f, -0.16265343f, 0.03085665f, 
    -0.08926278f, 0.04979714f, 0.13776386f, 0.06592853f, -0.03945787f, 0.09446127f, 0.07720585f, 0.05901429f, 
    0.10217492f, -0.14185074f, -0.03255025f, -0.08342924f, -0.22172128f, -0.13623522f, 0.11838371f, 0.06279479f, 
    0.04863519f, 0.16817713f, -0.06371532f, -0.05874661f, 0.05221649f, 0.11950318f, 0.09246200f, -0.01784386f, 
    -0.02799663f, -0.25514266f, 0.05661772f, -0.02159853f, -0.02521781f, 0.03335754f, 0.06869321f, -0.11775926f, 
    0.03320853f, -0.03001554f, 0.09077404f, 0.05370831f, -0.08010892f, 0.00497042f, -0.01665624f, -0.06810308f, 
    -0.09814624f, -0.00756050f, 0.08147009f, -0.02075865f, -0.01454092f, 0.08602183f, 0.06432067f, 0.13256074f, 
    0.03341362f, -0.17587063f, 0.11568265f, -0.18937556f, 0.01375795f, -0.09696978f, -0.05932898f, -0.00827592f, 
    -0.10266766f, -0.05904845f, 0.08529475f, -0.20261383f, 0.08367977f, -0.17489935f, 0.05814167f, 0.05719868f, 
    0.02654059f, -0.04756644f, -0.04671886f, -0.00303374f, -0.04643386f, -0.06871238f, -0.12712021f, -0.18940546f, 
    0.08265498f, -0.26067740f, -0.21679237f, 0.25345060f, -0.08857488f, 0.09606367f, -0.00137604f, 0.02819521f, 
    0.01195179f, -0.02116332f, -0.00523144f, -0.03848556f, 0.18934898f, 0.10664314f, -0.13557304f, 0.20497490f, 
    -0.16934869f, 0.11829759f, -0.01155733f, -0.06525452f, -0.20047507f, 0.12871927f, 0.03236798f, 0.13541581f, 
    -0.01182439f, -0.01536064f, 0.21388307f, 0.21547359f, 0.11705344f, 0.19285583f, 0.04324745f, 0.03470993f, 
    -0.05861834f, -0.05398854f, 0.07577953f, 0.00285248f, 0.22131644f, -0.01371912f, 0.08360205f, -0.17582586f, 
    -0.02068985f, 0.02145974f, -0.01303636f, -0.09767523f, -0.10266970f, 0.05073162f, 0.00603041f, -0.01262515f, 
    -0.04266711f, -0.26070097f, -0.06932831f, 0.12712663f, 0.04695988f, -0.01207527f, 0.01741558f, -0.14673336f, 
    -0.10604026f, -0.08792926f, 0.08033270f, 0.14948653f, 0.10072868f, -0.36404303f, -0.12412929f, 0.16013315f, 
    -0.03948971f, 0.03587442f, -0.02265333f, -0.04375424f, 0.03728787f, -0.00144762f, -0.11384946f, 0.09901518f, 
    -0.07341936f, -0.07353214f, 0.03568353f, -0.08472908f, 0.14893168f, -0.06489018f, -0.07090345f, -0.01865125f, 
    0.09495793f, -0.04061415f, 0.17945027f, -0.11154056f, -0.11076845f, -0.23189396f, -0.19592056f, -0.06418299f, 
    0.03466169f, -0.00601798f, 0.05834088f, -0.08654140f, -0.01381739f, 0.01510129f, 0.04913583f, 0.11004417f, 
    -0.06858994f, -0.16330162f, -0.06476287f, 0.08878004f, -0.00118467f, 0.08469775f, 0.01739619f, 0.09454107f, 
    -0.01307584f, -0.02836316f, 0.10338300f, -0.03463434f, 0.12472411f, -0.15576065f, 0.08255281f, -0.07273444f, 
    0.09120851f, 0.05204168f, 0.09919046f, -0.19194537f, 0.04740212f, -0.02527955f, 0.14681031f, 0.15647331f, 
    0.22520287f, -0.08377177f, -0.15010197f, 0.01778423f, 0.06915512f, 0.06897479f, 0.08696681f, 0.18152362f, 
    0.00601349f, 0.03286144f, -0.05115926f, -0.00575884f, -0.05836413f, 0.01818163f, -0.22515616f, -0.05598540f, 
    -0.09215829f, 0.01103241f, -0.03833591f, -0.10654999f, -0.07207695f, -0.04347907f, 0.03551738f, -0.10005686f, 
    0.08893572f, -0.23471648f, -0.06410081f, 0.19277260f, 0.02977849f, -0.07715732f, -0.03574162f, 0.08330870f, 
    -0.07168781f, -0.04734534f, -0.12700307f, 0.04680712f, -0.22202332f, 0.21699995f, 0.00453314f, -0.08769020f, 
    0.02577185f, 0.05159282f, 0.01335007f, 0.12408603f, 0.02000847f, -0.10982563f, -0.00465351f, -0.06543051f, 
    -0.29189393f, 0.04333230f, 0.11832359f, 0.24331380f, 0.05465278f, -0.00071264f, 0.01158309f, 0.08235368f, 
    0.07118940f, -0.08306170f, -0.25511402f, -0.02829075f, -0.07925361f, 0.13740560f, 0.04579200f, -0.06004831f, 
    0.10677882f, 0.14424412f, 0.05768302f, 0.08150994f, -0.02980242f, 0.02096401f, 0.15900072f, 0.02111343f, 
    -0.07436516f, -0.35090154f, 0.14058383f, -0.01372520f, -0.05114964f, -0.01256592f, 0.07855304f, 0.17048860f, 
    0.03636867f, -0.02355981f, -0.04485152f, 0.13209310f, -0.19017796f, 0.03534414f, -0.28985187f, -0.23648964f, 
    0.03041412f, -0.08791814f, -0.04066242f, -0.11577682f, 0.02109807f, 0.00869929f, 0.06666360f, 0.10222159f, 
    0.01553571f, -0.00728568f, 0.15727107f, -0.11975247f, -0.06182948f, 0.08209020f, 0.11447060f, 0.00564150f, 
    -0.06852309f, -0.05349642f, -0.02897918f, -0.07727844f, -0.09528935f, 0.06958837f, -0.06964412f, 0.26584175f, 
    0.06545740f, 0.17184308f, -0.14864253f, 0.08710254f, -0.01356338f, 0.07018768f, -0.01467886f, 0.04891342f, 
    -0.03191809f, -0.06426838f, 0.04897358f, 0.01818080f, -0.11773998f, 0.01360527f, 0.01703458f, -0.03559301f, 
    0.00118395f, -0.09164126f, -0.07961717f, 0.05098127f, -0.17952807f, 0.00834119f, 0.15847830f, -0.01032090f, 
    -0.01867555f, 0.07193748f, -0.07999213f, 0.03416789f, 0.02070071f, -0.03313912f, -0.04402029f, 0.03073408f, 
    0.11025191f, 0.05890775f, -0.04851340f, -0.06140887f, 0.04494581f, -0.06565974f, -0.08860221f, -0.07206181f, 
    0.01727464f, 0.00728190f, 0.16693678f, -0.02517914f, -0.01124470f, -0.38500735f, -0.08151693f, -0.04732857f, 
    -0.02876283f, -0.08040772f, 0.02518287f, -0.03030149f, -0.01999581f, 0.07493723f, -0.05223377f, 0.16946693f, 
    0.18754365f, 0.13597636f, 0.05424136f, -0.22449529f, -0.05127326f, 0.02278522f, 0.12956384f, -0.00358704f, 
    0.08872861f, 0.06849647f, -0.06478126f, -0.04005373f, 0.10874521f, 0.20519485f, 0.01631949f, -0.09683664f, 
    0.03308888f, 0.09197830f, -0.06476238f, 0.01481080f, -0.08628302f, -0.00876001f, -0.03337666f, 0.06134471f, 
    -0.11971166f, -0.07128882f, -0.01340740f, -0.00425369f, 0.03159923f, 0.07144675f, 0.01537449f, 0.02093427f, 
    -0.03847038f, 0.05534087f, -0.15812315f, -0.06124404f, 0.23741382f, 0.04683703f, -0.09513918f, -0.28706020f, 
    -0.08368798f, 0.06492197f, -0.02796280f, -0.00773386f, 0.02668172f, -0.12983739f, -0.10455275f, -0.06831487f, 
    -0.12788233f, 0.20128044f, 0.17819066f, -0.35779226f, 0.05665621f, 0.05280315f, -0.00544381f, 0.13663140f, 
    -0.08065499f, -0.09213522f, 0.05745968f, -0.05120524f, -0.06590027f, -0.08089858f, 0.06531472f, -0.19629583f, 
    0.10355941f, 0.12425889f, 0.00308634f, -0.05413755f, 0.04577828f, 0.00173864f, -0.04669936f, -0.10118257f, 
    -0.39087310f, 0.25499141f, -0.02201403f, -0.04269386f, -0.14007124f, 0.16453174f, -0.00847655f, 0.06690542f, 
    0.07626721f, -0.00383947f, 0.01893577f, -0.02161851f, 0.20272577f, -0.23121010f, 0.14982519f, -0.03803838f, 
    -0.05777590f, 0.04951041f, -0.01348012f, -0.05236945f, -0.00042667f, 0.04441935f, 0.02271974f, -0.06143071f, 
    0.13633409f, 0.13424894f, 0.03693141f, -0.07866275f, -0.06321819f, -0.00211496f, 0.07167014f, 0.13379465f, 
    -0.20834100f, -0.04610209f, 0.07035007f, 0.02479647f, -0.27318794f, -0.01141610f, -0.17350103f, -0.16848019f, 
    -0.16271308f, -0.03254170f, 0.05394890f, -0.02253409f, -0.02015212f, 0.02430040f, 0.01769024f, 0.10860673f, 
    0.23095980f, 0.05289883f, -0.03932847f, -0.22450566f, -0.04799211f, 0.04320550f, 0.07595187f, 0.10088785f, 
    0.01863040f, 0.04149309f, -0.11725003f, -0.03484099f, 0.39904365f, -0.21650973f, 0.05634797f, -0.19729456f, 
    -0.12294202f, -0.05358440f, 0.09430048f, -0.08884019f, -0.05158267f, 0.02930486f, -0.02477020f, 0.15565088f, 
    -0.15552087f, 0.04155358f, -0.02045512f, -0.00259846f, 0.02467914f, -0.01040406f, -0.01722435f, -0.05403734f, 
    0.02323740f, 0.06420320f, -0.07729014f, -0.23073190f, -0.22989249f, 0.02165087f, 0.13930550f, -0.12569095f, 
    -0.12753135f, -0.01109210f, 0.01343717f, 0.07700496f, -0.03472652f, -0.09276260f, -0.09262503f, -0.21862729f, 
    -0.07771619f, -0.03986173f, 0.05490787f, -0.23988801f, 0.09813564f, -0.04933821f, 0.16583318f, -0.03673797f, 
    0.07630963f, 0.08727829f, -0.02748109f, -0.10132790f, 0.22144786f, -0.01449679f, 0.11614826f, -0.01439417f, 
    -0.01603297f, -0.02509985f, -0.11988633f, 0.01971384f, 0.01402004f, 0.10948455f, -0.04436614f, 0.13355954f, 
    0.54356635f, -0.21520244f, 0.14366680f, -0.01592487f, 0.09326904f, 0.01989137f, 0.11759114f, 0.02968296f, 
    0.08676451f, 0.00802811f, 0.06163661f, 0.02439336f, 0.06134191f, -0.23478746f, 0.12616584f, -0.13402894f, 
    0.09344060f, 0.03654794f, 0.04396273f, -0.02674222f, -0.02636373f, -0.09367125f, -0.06478073f, 0.07743508f, 
    0.11863757f, -0.09825100f, -0.20423536f, 0.19091667f, -0.04408501f, -0.07580764f, 0.05307293f, 0.02504708f, 
    0.03213257f, -0.05076043f, -0.07292457f, -0.08969196f, 0.07209755f, -0.27168620f, -0.07743043f, -0.13205011f, 
    -0.00177882f, 0.04991063f, -0.07636511f, 0.01146896f, 0.06271306f, 0.02927787f, -0.00410710f, 0.07616241f, 
    -0.20531382f, 0.20539387f, 0.20555246f, 0.09455663f, 0.05939702f, -0.01937027f, -0.02535944f, 0.05103551f, 
    0.04201812f, -0.00757662f, -0.05123353f, -0.06057965f, -0.05330720f, 0.08998924f, 0.06654828f, 0.24261795f, 
    0.08161826f, -0.10164527f, 0.04665316f, -0.18807054f, 0.00232476f, 0.08793735f, 0.02924187f, -0.02765306f, 
    0.11415257f, -0.10379175f, 0.04853972f, -0.33589360f, 0.10141955f, -0.00668770f, 0.02547749f, 0.01631223f, 
    0.02231600f, -0.05645636f, 0.02043203f, -0.04885637f, -0.26795873f, 0.26015410f, 0.11276840f, 0.20923530f, 
    -0.07538343f, -0.11917312f, 0.09052508f, 0.02314332f, -0.14907074f, -0.02175159f, 0.13353671f, -0.06261276f, 
    -0.26371375f, -0.13993716f, 0.06820921f, 0.09214266f, 0.03005526f, 0.05121061f, -0.02572724f, 0.08078664f, 
    -0.00978210f, 0.04274058f, 0.07672759f, 0.16739868f, 0.09191256f, -0.08055007f, -0.07051381f, 0.06375305f, 
    0.06459060f, -0.10465576f, -0.02358472f, 0.04921402f, -0.01626224f, 0.02703652f, 0.02215822f, 0.10014454f, 
    -0.20137429f, -0.01152327f, -0.14421563f, -0.22991028f, -0.02361468f, 0.09925280f, -0.07213795f, -0.06747915f, 
    0.00638119f, 0.03241940f, -0.03842269f, 0.11039577f, -0.42859873f, -0.05184988f, -0.17167768f, 0.28802893f, 
    0.09713282f, 0.00839079f, 0.10292074f, 0.03747010f, 0.09383773f, 0.00958635f, 0.07566862f, -0.03027722f, 
    0.02621388f, 0.24874870f, 0.22179167f, -0.33128506f, -0.09764615f, -0.07779059f, 0.00767194f, 0.01835908f, 
    -0.01039509f, -0.02351281f, -0.00742229f, -0.13810232f, -0.23144382f, 0.12140156f, -0.26230022f, -0.00378094f, 
    -0.00325000f, -0.06783155f, 0.11019991f, -0.03111077f, 0.02550651f, -0.14976071f, 0.00834727f, 0.13087721f, 
    0.02311946f, -0.16473754f, -0.19879511f, -0.17831382f, -0.10320327f, 0.04965076f, -0.03191462f, -0.10806406f, 
    -0.02251434f, 0.10037354f, -0.12827486f, 0.13354243f, -0.05869571f, -0.00886925f, -0.13992654f, -0.01974444f, 
    -0.06015491f, 0.03528285f, -0.01590784f, -0.04937647f, -0.04468073f, -0.04650314f, -0.15546899f, 0.06088075f, 
    -0.06439809f, 0.01007962f, -0.21883914f, 0.16707827f, 0.07460894f, 0.01549540f, -0.26613003f, -0.00268566f, 
    -0.00463439f, 0.01430642f, -0.00974835f, -0.11834870f, 0.05703439f, -0.11856423f, -0.02176742f, -0.12612852f, 
    -0.07378180f, 0.05640639f, -0.00274863f, -0.03822339f, 0.08149832f, 0.00795107f, 0.11673148f, 0.04704602f, 
    0.25575289f, -0.00612766f, 0.10137744f, -0.22613913f, -0.01052150f, -0.05204864f, -0.15338838f, -0.08836796f, 
    -0.02754036f, 0.15979433f, 0.02625271f, -0.02921803f, -0.11774855f, 0.06836001f, 0.07153954f, 0.19698061f, 
    -0.05557240f, -0.05362638f, -0.03671839f, -0.00049338f, -0.12287050f, -0.02560867f, -0.14752509f, -0.11474506f, 
    0.17463329f, -0.04490428f, 0.11477695f, -0.12325595f, -0.03855740f, 0.06706930f, -0.02273262f, 0.03511224f, 
    0.00353657f, -0.01480986f, -0.02869684f, 0.01231872f, -0.24806675f, 0.11906615f, -0.03484507f, -0.07911971f, 
    -0.10553636f, -0.06375840f, 0.00648008f, -0.03302160f, -0.00273691f, -0.01425253f, -0.04044402f, -0.04304373f, 
    -0.09730744f, -0.03199966f, 0.12081078f, 0.00605127f, -0.03103515f, -0.02100597f, -0.04358219f, -0.03303098f, 
    -0.05143980f, 0.03623302f, -0.01049001f, -0.07359634f, 0.05472550f, -0.09985157f, 0.02179737f, -0.01406449f, 
    -0.04764439f, -0.09200460f, 0.07800500f, -0.04135782f, -0.02446682f, 0.00744556f, -0.03546312f, -0.01273523f, 
    0.04950686f, 0.08993127f, -0.01328255f, 0.14564559f, 0.05919357f, -0.03866507f, 0.01895851f, 0.05442931f, 
    0.03274588f, -0.06071624f, -0.09534781f, -0.04001187f, -0.08613072f, 0.11397602f, 0.00298661f, 0.15692537f, 
    0.04487960f, -0.03008021f, -0.07110842f, 0.07448530f, 0.02658779f, -0.05639114f, 0.00022450f, 0.01620021f, 
    0.10271026f, -0.19850063f, -0.10758840f, 0.06395565f, -0.06377270f, -0.06749026f, -0.08018076f, -0.05644576f, 
    0.01104194f, -0.01500521f, 0.06315283f, -0.03399495f, -0.01562584f, 0.22707900f, 0.12346613f, 0.09875033f, 
    0.00876036f, 0.02577759f, 0.00732439f, 0.06002186f, -0.06000459f, 0.03175673f, 0.01803458f, -0.06432000f, 
    0.30622303f, -0.29252037f, 0.15765715f, 0.10227925f, 0.10029022f, -0.00537508f, -0.01531112f, -0.11387126f, 
    0.03762501f, -0.07008801f, -0.00921741f, -0.07293724f, -0.01152021f, -0.03769276f, 0.04791561f, -0.00299768f, 
    0.06494987f, 0.03617669f, 0.06783272f, -0.09340423f, 0.03283618f, -0.04809723f, -0.04434499f, -0.03216343f, 
    0.11479929f, 0.17021725f, 0.12255333f, -0.04469534f, 0.07049987f, 0.04405199f, 0.03040759f, -0.00831248f, 
    -0.07029533f, 0.07981399f, -0.02164425f, -0.07043754f, 0.11044128f, 0.16258125f, 0.16215563f, 0.11436498f, 
    0.06441224f, 0.06113241f, 0.10500351f, -0.04815000f, 0.02180522f, -0.00342686f, 0.00345719f, -0.03839260f, 
    -0.04059481f, -0.00569347f, -0.06488839f, 0.15335885f, -0.02879947f, -0.02658528f, -0.06109739f, -0.05587048f, 
    -0.02830977f, -0.08514981f, 0.08569686f, -0.05108565f, 0.16504940f, -0.03114207f, 0.18657522f, 0.05939814f, 
    -0.04842223f, 0.04023817f, 0.01268475f, 0.07000279f, -0.02278325f, 0.08394237f, -0.04619727f, 0.00366477f, 
    -0.20425804f, 0.00378298f, -0.06595053f, -0.13201723f, -0.08098540f, -0.03977683f, -0.04710942f, -0.01424776f, 
    0.00426059f, -0.00813474f, 0.04190323f, -0.04593379f, 0.02965995f, 0.14730050f, 0.04684723f, 0.12692811f, 
    0.04699020f, -0.02414735f, -0.09647731f, 0.00084698f, -0.00778574f, -0.04177520f, -0.05391912f, -0.09025844f, 
    -0.20067774f, 0.09726565f, 0.03235776f, 0.16631515f, -0.02183298f, -0.10653502f, -0.09574639f, -0.00097983f, 
    0.03331678f, -0.01243825f, -0.02897624f, -0.01661052f, -0.23697379f, -0.03521653f, -0.15054120f, -0.08561616f, 
    -0.04412307f, -0.06690645f, -0.12733172f, -0.02373333f, -0.13031039f, -0.01476539f, 0.05515371f, -0.02571371f, 
    -0.04062711f, -0.14392135f, -0.03992620f, -0.05024046f, 0.02471343f, -0.03961942f, 0.00264386f, -0.08566029f, 
    -0.03346345f, -0.01240727f, -0.06282990f, -0.01431694f, 0.04178512f, -0.19041440f, -0.05079499f, 0.07504863f, 
    -0.06403752f, -0.05645090f, -0.02853331f, -0.00458594f, -0.05693389f, -0.03063714f, -0.05464903f, -0.01951044f, 
    -0.10904294f, -0.07596548f, -0.00191120f, -0.00070331f, -0.17689560f, -0.02088721f, -0.08229715f, -0.17943068f, 
    -0.05534852f, 0.07192846f, -0.05533683f, -0.16187388f, 0.14580816f, 0.07030450f, 0.13439149f, 0.02621105f, 
    0.06058963f, -0.04674128f, -0.02850793f, -0.09836924f, -0.01375330f, 0.04268994f, -0.02161700f, -0.06416798f, 
    0.18332933f, 0.05274910f, -0.13133825f, -0.11145245f, 0.07416413f, 0.04216180f, -0.00214882f, -0.00574879f, 
    0.01047788f, -0.03715272f, -0.04810119f, -0.07827704f, -0.12370369f, -0.09799884f, -0.04995318f, -0.07697336f, 
    0.01585075f, -0.06901557f, -0.00700407f, -0.04278603f, -0.15989211f, 0.06768718f, 0.02237041f, -0.01101185f, 
    0.07923918f, 0.13638540f, 0.04445378f, 0.21893343f, 0.08464181f, 0.02684593f, -0.04370929f, 0.05181501f, 
    -0.00704616f, -0.01497578f, -0.04901630f, -0.03415228f, -0.31853631f, 0.10098521f, -0.07188204f, -0.14144213f, 
    -0.02947126f, 0.01796996f, -0.10733767f, 0.02559277f, 0.00662022f, 0.02074619f, -0.09460893f, -0.10991565f, 
    0.17519727f, -0.26702046f, 0.06556950f, 0.09263328f, -0.14801629f, -0.05036164f, -0.03405531f, -0.00395681f, 
    -0.05998636f, -0.01233411f, 0.01453885f, 0.06122190f, -0.20423789f, -0.00001131f, 0.08056601f, 0.02922497f, 
    0.03693625f, -0.03533753f, 0.04244048f, 0.04279897f, -0.02956364f, 0.02204593f, 0.10860251f, -0.01799656f, 
    -0.23440774f, -0.03861274f, -0.08076199f, -0.16401687f, 0.06693720f, -0.01228121f, -0.07402392f, -0.01498921f, 
    -0.08669453f, -0.00881042f, -0.02249822f, -0.05896248f, -0.04987599f, -0.22720045f, -0.12088777f, 0.00916827f, 
    -0.02313625f, -0.11756115f, -0.05486623f, 0.01506889f, -0.14331211f, 0.03807391f, 0.02725798f, -0.03110138f, 
    0.11711011f, -0.07157917f, 0.13215533f, 0.02097033f, -0.00061739f, -0.05400171f, -0.05803270f, -0.03434467f, 
    0.00369286f, 0.01515854f, -0.03812541f, -0.05154836f, 0.00904161f, -0.13070388f, 0.05795337f, 0.11399153f, 
    -0.12236157f, -0.02787091f, -0.00673779f, -0.01375367f, 0.01914429f, 0.02130123f, 0.00921688f, -0.07904413f, 
    -0.19480318f, -0.05649033f, -0.04429284f, -0.04660057f, -0.07221455f, -0.05995131f, -0.05621129f, -0.07715533f, 
    -0.06044297f, 0.01738300f, 0.02221504f, 0.00873147f, 0.01780973f, -0.12259606f, 0.00582555f, -0.17854542f, 
    0.07656131f, 0.00872401f, 0.00895003f, -0.15334266f, -0.08746868f, 0.06642529f, 0.02909935f, -0.02781125f, 
    0.00739160f, 0.15549652f, -0.08193660f, -0.11886339f, 0.02192504f, -0.05627927f, -0.04555607f, -0.05430269f, 
    -0.02717865f, 0.06795700f, 0.04849431f, 0.00586088f, 0.05685426f, -0.07658076f, 0.12456875f, -0.02804639f, 
    0.02723737f, 0.02409609f, -0.03094945f, 0.02567263f, -0.00733802f, 0.04467102f, -0.05777024f, -0.01066860f, 
    -0.02127106f, 0.06051557f, -0.08386582f, -0.01506066f, -0.04325892f, -0.05062384f, -0.02559218f, -0.09118069f, 
    -0.07615957f, -0.02539297f, -0.01542959f, -0.05558998f, 0.21306822f, 0.19342762f, 0.04995728f, 0.08915021f, 
    0.01587888f, 0.06414689f, 0.02085405f, 0.03395676f, -0.02041376f, -0.00199919f, -0.02242110f, 0.04595351f, 
    0.09685913f, -0.15888189f, -0.03279207f, 0.02676524f, -0.12379365f, -0.06260437f, -0.00220678f, -0.01527251f, 
    -0.08186124f, -0.02724702f, 0.00773437f, 0.00582313f, 0.15739521f, 0.03811235f, 0.08351646f, -0.11179876f, 
    0.05363058f, 0.00562197f, -0.04359855f, -0.05295267f, -0.02100813f, 0.04025615f, -0.04690996f, -0.10549151f, 
    0.24351911f, 0.01358392f, 0.11491283f, 0.01740738f, -0.02474051f, -0.03719480f, -0.03088968f, -0.04497853f, 
    -0.02492125f, 0.07303920f, -0.03983985f, 0.00129922f, -0.08079811f, 0.08717537f, -0.00388485f, 0.01702604f, 
    -0.08066093f, 0.04233387f, -0.01452044f, -0.02794652f, -0.03423845f, -0.03042763f, -0.06522244f, -0.02896374f, 
    0.08905877f, 0.02882295f, 0.04710237f, -0.01729194f, 0.04753486f, -0.05977105f, -0.04169603f, -0.01203393f, 
    0.03532253f, 0.07584559f, 0.04712607f, 0.00609404f, -0.10799511f, 0.10787392f, 0.13013889f, 0.05985357f, 
    0.07745552f, -0.02849836f, 0.02324721f, 0.01638721f, -0.00266946f, 0.01138840f, -0.03362173f, -0.00481928f, 
    0.38167158f, 0.01209158f, 0.02190378f, -0.25277272f, -0.06145763f, 0.03851439f, -0.00388295f, 0.01781094f, 
    -0.02538715f, 0.01185205f, -0.04633193f, 0.01697564f, 0.24064367f, -0.04566561f, 0.07546473f, 0.08259321f, 
    0.03635810f, -0.00195378f, 0.06728967f, 0.00968863f, 0.00142964f, -0.00152622f, 0.00812043f, -0.02088327f, 
    -0.06012614f, 0.00557114f, -0.13041902f, 0.01736564f, -0.02988272f, -0.10276102f, -0.03949827f, -0.01105291f, 
    0.01345885f, 0.01063222f, -0.00550630f, 0.00138844f, -0.06119386f, 0.05784728f, -0.01158917f, 0.00052411f, 
    -0.06785249f, 0.05232977f, 0.07076219f, -0.04472533f, -0.06506319f, 0.02938249f, -0.03164618f, -0.03149282f, 
    0.02867698f, -0.22124323f, -0.15976481f, -0.33923841f, 0.00091491f, 0.06881316f, -0.03468025f, -0.02493425f, 
    0.00583605f, -0.06363603f, -0.02982002f, 0.03821379f, 0.21402811f, 0.18043350f, -0.04739088f, 0.19419207f, 
    0.04298108f, -0.09288636f, -0.08513092f, -0.02056079f, -0.02230237f, 0.06097281f, -0.02696189f, -0.02569915f, 
    0.11460973f, -0.15157107f, 0.03897727f, 0.11699765f, -0.05304934f, -0.11870309f, -0.03728840f, -0.08494274f, 
    -0.00956056f, -0.02655191f, 0.01496097f, -0.08284599f, -0.30081969f, -0.04758934f, -0.03355743f, -0.15370181f, 
    0.06755167f, 0.00409075f, 0.01674174f, -0.01787302f, -0.05969847f, 0.04887726f, -0.04968191f, -0.01670463f, 
    0.07446185f, -0.13544483f, 0.03764153f, 0.08103894f, -0.10735258f, -0.03190168f, -0.05993957f, -0.02190596f, 
    -0.03713634f, -0.05377037f, 0.04877099f, -0.03797932f, -0.09320156f, -0.15250905f, -0.00396747f, -0.17078084f, 
    -0.05404616f, -0.03784179f, -0.07575326f, -0.04620575f, -0.07374137f, -0.07377189f, -0.08668432f, 0.00462842f, 
    0.02795647f, 0.14747788f, 0.10650231f, 0.08591322f, 0.09766255f, 0.06186513f, 0.03368960f, -0.04222996f, 
    -0.02252837f, 0.01944080f, 0.01882799f, -0.05786614f, -0.07257303f, 0.14068496f, -0.06917988f, 0.04183235f, 
    0.03620818f, -0.05659736f, 0.01620866f, 0.01890027f, 0.08305927f, -0.00238242f, 0.01726730f, -0.02131592f, 
    -0.01446437f, -0.15112312f, 0.01595167f, -0.05500033f, -0.05061271f, 0.00260390f, -0.01514094f, -0.05161246f, 
    -0.02654139f, -0.01735206f, -0.01365372f, -0.07548531f, 0.07279086f, 0.13966000f, -0.00470037f, 0.06357758f, 
    -0.02060498f, 0.07252199f, 0.02623172f, -0.06685977f, 0.03002215f, 0.05960680f, -0.09295991f, -0.04676368f, 
    -0.13344334f, 0.02177056f, 0.06191263f, 0.07435024f, 0.04806434f, 0.00774412f, 0.03697083f, 0.02954303f, 
    -0.09916254f, 0.08584478f, -0.03597737f, -0.05665910f, 0.06259535f, 0.14041144f, 0.02018823f, 0.10426430f, 
    0.07684195f, 0.01689001f, -0.03997040f, 0.00702511f, 0.01522297f, -0.06128926f, -0.01072860f, -0.03170601f, 
    -0.04151617f, 0.01912020f, -0.08758569f, 0.05654948f, -0.04732963f, -0.01556123f, -0.00149249f, 0.02501720f, 
    -0.01769327f, 0.03599473f, -0.03446312f, -0.16180110f, 0.02711529f, 0.08552864f, 0.15744190f, 0.11285666f, 
    0.10357697f, 0.09666640f, 0.02873535f, 0.02588083f, -0.00185109f, 0.03600251f, -0.00950185f, 0.05546750f, 
    -0.02549791f, 0.09374765f, -0.12179912f, -0.11800833f, -0.08435214f, -0.04309777f, -0.05062912f, 0.02266389f, 
    -0.04310074f, -0.01094384f, -0.08659275f, -0.13856067f, 0.04132007f, 0.11510814f, 0.05980192f, 0.11612935f, 
    0.12716736f, -0.03907632f, -0.06593569f, -0.02605976f, -0.07731592f, -0.06577032f, 0.02147906f, 0.02479115f, 
    0.11983833f, 0.03526867f, 0.02526697f, 0.00080454f, 0.05607922f, 0.02762804f, -0.03724204f, 0.01084534f, 
    0.02130728f, 0.03504513f, 0.08186422f, -0.04894514f, -0.01072273f, 0.03185089f, -0.04506577f, 0.20312712f, 
    0.12755670f, 0.00757353f, -0.08690215f, -0.07063680f, 0.02849530f, -0.06056115f, -0.00239252f, 0.00017056f, 
    -0.13463244f, -0.17138493f, 0.29146975f, 0.06127540f, -0.04009846f, -0.05520054f, -0.02738502f, -0.00318763f, 
    -0.00168161f, 0.09212913f, 0.00431463f, 0.06840293f, 0.04235836f, -0.11112837f, -0.09899413f, -0.05089184f, 
    -0.00401202f, -0.12214963f, 0.01965587f, -0.02908207f, 0.00807542f, 0.08985569f, 0.02415378f, -0.08256722f, 
    0.16368428f, 0.09650378f, 0.03533356f, -0.01518141f, 0.00368455f, -0.07768814f, 0.03147258f, -0.02140051f, 
    -0.00532377f, -0.00651749f, -0.00412698f, 0.06578992f, -0.01530843f, 0.21087807f, -0.00560851f, -0.14579192f, 
    0.05903482f, -0.13304661f, 0.08813962f, -0.01837392f, -0.04976173f, -0.02247475f, 0.04068851f, -0.00214218f, 
    -0.09652019f, -0.12060966f, 0.17732266f, -0.04885994f, -0.07783091f, -0.04707812f, -0.17854990f, 0.02860790f, 
    -0.05630354f, 0.10462866f, 0.02588918f, 0.00888067f, 0.05498987f, -0.01070671f, 0.06861575f, 0.07167008f, 
    -0.05110127f, 0.02655041f, -0.00276471f, 0.00111064f, -0.12535679f, -0.04962347f, -0.02820585f, -0.04809597f, 
    0.16389279f, 0.02296657f, -0.00326755f, 0.00060831f, 0.06884743f, 0.04215194f, -0.02694814f, -0.08321985f, 
    0.06261194f, 0.00155505f, -0.11322183f, 0.06041682f, 0.06548088f, -0.12140646f, 0.09807505f, 0.01113476f, 
    -0.02863651f, -0.03655863f, -0.07982282f, 0.01623825f, -0.05646111f, -0.02144076f, -0.02257416f, -0.03285207f, 
    -0.15109158f, 0.26199654f, -0.04037607f, 0.05607744f, -0.01813944f, 0.07039149f, -0.01773800f, -0.03655325f, 
    0.04941571f, 0.04312652f, -0.04480790f, 0.07969507f, -0.00819409f, -0.00353517f, 0.08352106f, 0.10888493f, 
    -0.12079822f, -0.01177853f, -0.11325926f, 0.07956037f, 0.00264046f, -0.13868906f, 0.02794111f, 0.02524040f, 
    -0.00202952f, 0.08609640f, -0.16341570f, -0.09857398f, 0.04766311f, 0.01997931f, -0.04029219f, 0.03606438f, 
    0.08529916f, 0.06422450f, 0.00595689f, 0.04423419f, -0.10823884f, -0.06394794f, 0.15559737f, -0.15030621f, 
    0.03715639f, -0.03220470f, 0.02984175f, 0.09060436f, 0.04642383f, -0.10960105f, -0.12554333f, -0.03189140f, 
    0.05613349f, 0.04477314f, -0.05360969f, 0.08576584f, -0.10962784f, -0.05211019f, -0.04869535f, 0.12959458f, 
    0.05075537f, -0.04523949f, -0.07001364f, 0.15307112f, -0.09564681f, 0.12626116f, -0.07878776f, -0.25182194f, 
    0.04668187f, -0.03817231f, -0.04657554f, -0.02780982f, 0.02847547f, 0.06815135f, 0.08004157f, 0.03927721f, 
    -0.05628266f, 0.14192934f, -0.17596188f, -0.03741461f, 0.07981148f, 0.05863389f, -0.11403520f, 0.00479848f, 
    0.13895555f, 0.01135561f, 0.05327250f, 0.07148866f, -0.05778122f, -0.18227655f, -0.11900617f, -0.04635660f, 
    0.11333217f, 0.01854614f, 0.07666133f, 0.01604025f, 0.14112145f, 0.10843164f, -0.02642172f, -0.04373511f, 
    0.18814035f, 0.04790094f, -0.11407458f, -0.09291699f, 0.01766728f, -0.03999643f, -0.01673576f, -0.02572254f, 
    -0.01460630f, -0.08667926f, -0.00389365f, 0.09391063f, -0.08362564f, 0.01395531f, -0.24966162f, -0.04926790f, 
    0.08190195f, -0.10973921f, 0.00666689f, -0.15164346f, -0.01273310f, -0.02763604f, -0.09149825f, 0.02328697f, 
    0.07164185f, 0.11166420f, 0.07212360f, 0.14723389f, -0.13448054f, -0.02056968f, -0.04808237f, -0.05932045f, 
    -0.03041029f, 0.07041086f, 0.04453504f, -0.04229944f, -0.17543367f, -0.01185718f, -0.07884665f, -0.13989623f, 
    -0.02690630f, -0.05933210f, 0.05846506f, -0.05066150f, 0.04250065f, -0.14558081f, 0.07520846f, -0.01153129f, 
    0.11580917f, -0.18875594f, 0.00277605f, 0.04016964f, 0.11434370f, -0.04136761f, -0.08771358f, -0.05246625f, 
    -0.01043005f, 0.09832931f, -0.00157907f, -0.00859248f, -0.00394469f, 0.14019716f, -0.21261214f, -0.14185174f, 
    0.03135872f, 0.06595123f, -0.07823200f, -0.03653503f, 0.11556765f, -0.04653895f, 0.00745968f, -0.03328165f, 
    -0.06041220f, 0.11281420f, 0.00337391f, -0.29623345f, -0.06954347f, -0.03711604f, 0.05661404f, -0.01881108f, 
    0.01784691f, -0.04393746f, -0.02273713f, -0.08419841f, 0.10307293f, 0.03114119f, 0.01213836f, 0.09560138f, 
    0.02845886f, -0.10056481f, -0.02895378f, -0.06387158f, 0.01333302f, 0.14241156f, -0.09219486f, 0.03440894f, 
    -0.13747956f, -0.17748430f, -0.36293012f, -0.00391749f, 0.06320303f, 0.01093595f, 0.01239762f, -0.13928360f, 
    0.03397269f, -0.01508809f, 0.03089482f, -0.02852197f, 0.10644392f, -0.05853320f, 0.07821470f, 0.12501146f, 
    -0.09356835f, -0.03365142f, -0.05546720f, -0.05832822f, -0.01689198f, -0.04525605f, -0.01920835f, -0.02387638f, 
    0.12029135f, 0.00680042f, -0.08873471f, 0.14722332f, 0.04893643f, -0.06621238f, -0.08067460f, -0.05025503f, 
    0.08300778f, -0.09183587f, 0.10980057f, -0.01691294f, -0.08106722f, -0.09112042f, -0.25459176f, -0.02559888f, 
    0.02618737f, -0.00013597f, -0.03973100f, -0.05166069f, 0.10386431f, -0.00958695f, 0.08337826f, -0.00565387f, 
    -0.07026488f, -0.01477732f, -0.16703013f, -0.02154395f, -0.10403315f, -0.05947884f, 0.01566491f, -0.17305490f, 
    0.05660035f, -0.00241962f, 0.02504735f, -0.02641224f, -0.18923090f, -0.14707370f, -0.31030217f, -0.21686047f, 
    -0.05936424f, -0.03225236f, -0.05780380f, -0.12094378f, -0.04111833f, 0.02713084f, 0.05395083f, 0.08129776f, 
    0.01989589f, -0.09446660f, 0.13116172f, 0.27586198f, 0.13727696f, 0.02459320f, -0.04391854f, 0.00823739f, 
    0.03118537f, 0.03650797f, 0.06475191f, -0.04141383f, -0.03237960f, -0.23444870f, 0.12955049f, -0.04306355f, 
    -0.03480396f, -0.03420254f, -0.06471065f, 0.00955941f, 0.03894776f, -0.05533089f, 0.05726257f, -0.02014429f, 
    0.00067134f, -0.02126998f, 0.02655202f, 0.10155604f, 0.07542231f, 0.03557512f, -0.10757340f, 0.00290746f, 
    -0.02654775f, 0.03151746f, -0.05806075f, -0.08027234f, -0.03666476f, -0.09833188f, 0.12379806f, -0.06512085f, 
    -0.02256673f, -0.05219089f, 0.05506266f, 0.05386703f, 0.00729296f, 0.08216172f, -0.17161761f, -0.00203736f, 
    -0.06591410f, 0.08566571f, -0.09547321f, 0.06460953f, -0.09098163f, -0.09293597f, -0.02990002f, 0.10138165f, 
    0.13341510f, -0.07511455f, -0.10810176f, -0.08465508f, -0.05151169f, 0.08759945f, 0.10659089f, -0.02367698f, 
    -0.07266999f, 0.07992858f, -0.05480031f, -0.01344677f, 0.01823254f, 0.00397696f, -0.02477798f, -0.05686187f, 
    -0.07472824f, -0.19261284f, -0.14465831f, -0.10267799f, -0.06152794f, -0.02755701f, 0.10895104f, -0.03995814f, 
    -0.00195796f, 0.18457155f, -0.02436030f, 0.02666647f, -0.07991763f, -0.25158516f, 0.13539602f, -0.08045968f, 
    0.00830858f, 0.03249361f, 0.03311023f, 0.12260275f, 0.04315054f, -0.05313652f, -0.01472766f, -0.00433409f, 
    -0.01470018f, 0.02908238f, 0.10650197f, -0.11802623f, 0.04136800f, -0.06941437f, 0.00757908f, -0.05921639f, 
    0.01059994f, -0.10306197f, 0.00860426f, 0.15009224f, 0.17322296f, 0.02032509f, -0.02591858f, 0.10452224f, 
    0.11518576f, -0.05452271f, -0.03756007f, -0.06934190f, -0.05926540f, 0.01458765f, 0.05651670f, 0.03799380f, 
    -0.20099244f, 0.05909775f, -0.06878879f, 0.03462627f, -0.07829577f, 0.09738418f, -0.07940394f, -0.15836170f, 
    -0.08545905f, -0.08063332f, 0.07945456f, 0.06659276f, 0.00971882f, -0.27635118f, -0.04398187f, -0.09144969f, 
    0.01443305f, -0.11741367f, -0.04140518f, -0.02847494f, -0.02335169f, -0.00497766f, 0.10196692f, -0.05938297f, 
    0.06037641f, -0.10530955f, 0.01708397f, -0.10323061f, 0.05213843f, -0.06837070f, -0.00913346f, 0.01788253f, 
    0.11606129f, -0.02673020f, 0.00220787f, 0.04910893f, -0.10068438f, -0.08814203f, 0.09397785f, -0.15364592f, 
    0.05423089f, -0.06382151f, -0.00544292f, 0.06076380f, 0.02168890f, 0.09631500f, 0.00479739f, 0.05066519f, 
    0.12628819f, 0.18054149f, -0.19903895f, -0.05946187f, -0.06609224f, -0.01273795f, -0.07766859f, -0.04658619f, 
    0.01337098f, -0.02019521f, 0.04673487f, -0.02148505f, -0.08391574f, 0.05227080f, -0.08067907f, -0.11678369f, 
    -0.07348712f, -0.12356535f, -0.03671592f, -0.08591641f, 0.00443232f, -0.07031152f, 0.01014081f, -0.12450169f, 
    0.13981079f, -0.15415889f, -0.21981303f, 0.14528358f, 0.12306122f, 0.05994938f, -0.01452879f, -0.07026571f, 
    0.01160418f, -0.02199991f, 0.11885518f, -0.03795803f, -0.16110384f, 0.11986525f, -0.22618754f, -0.17462516f, 
    0.06529707f, -0.00039065f, -0.16749485f, 0.08544976f, -0.01736498f, -0.07617132f, 0.11479298f, 0.02758333f, 
    -0.11879568f, -0.13242997f, -0.07870753f, -0.12168381f, 0.00502982f, -0.11204791f, 0.02819350f, 0.02687591f, 
    0.07014494f, 0.07243807f, 0.01553675f, -0.01605206f, 0.14077935f, 0.12953985f, -0.05206883f, 0.01256483f, 
    0.02460781f, 0.06560451f, -0.00033774f, -0.05672419f, 0.04723184f, -0.05524552f, -0.00507739f, 0.03640814f, 
    0.16146985f, 0.03602308f, -0.00728340f, 0.09452633f, -0.02447415f, -0.10697605f, -0.07576481f, -0.13707349f, 
    -0.02091429f, 0.03562767f, -0.12099189f, -0.01969026f, 0.11376118f, 0.01029727f, -0.11704554f, 0.07615028f, 
    -0.00890199f, 0.02903901f, 0.05763521f, -0.01540789f, 0.00184597f, -0.08426636f, -0.16043179f, -0.03813293f, 
    -0.23367338f, 0.07721057f, 0.14905073f, -0.02792724f, 0.01520483f, -0.07103320f, -0.05613813f, -0.09064654f, 
    -0.01232301f, 0.00791367f, 0.01138708f, -0.05108761f, 0.11901964f, 0.25103724f, -0.19849193f, 0.14032663f, 
    -0.01712067f, 0.03278872f, -0.19545563f, -0.04997905f, -0.05551442f, -0.04548205f, -0.07997371f, 0.11204505f, 
    0.00946150f, -0.23776230f, 0.04871028f, 0.19986980f, 0.11203959f, -0.03647087f, -0.08264994f, -0.10053758f, 
    0.04420887f, 0.08398022f, 0.01145481f, 0.02927150f, -0.15874396f, 0.15228839f, -0.03824463f, -0.11916894f, 
    0.01727053f, 0.00719448f, -0.03519251f, 0.07694986f, 0.01788725f, 0.02415981f, 0.10712118f, -0.20509923f, 
    -0.18649596f, 0.05273224f, 0.20946424f, -0.01491914f, -0.04739762f, 0.07180870f, -0.01467161f, 0.02368368f, 
    0.07219916f, -0.16834798f, 0.12768206f, 0.05846018f, -0.19920795f, 0.00895559f, 0.00669948f, -0.13147229f, 
    -0.00791466f, 0.02523295f, -0.12066098f, -0.06294256f, 0.06270957f, 0.02567311f, 0.04619120f, -0.08132071f, 
    -0.06498989f, 0.07514067f, -0.31710020f, -0.10146785f, -0.01170199f, -0.08126093f, 0.02575967f, -0.05489866f, 
    -0.00042205f, -0.05277470f, 0.01401439f, 0.10552882f, -0.08914114f, -0.00128365f, 0.11085490f, 0.07496760f, 
    0.00429153f, -0.10006234f, 0.04755884f, 0.02599004f, -0.00505312f, -0.07902303f, -0.04908024f, 0.08008117f, 
    0.15170828f, 0.01190328f, -0.11776949f, -0.04157808f, 0.04456197f, -0.01235798f, 0.00262934f, 0.00836823f, 
    0.02454627f, -0.05865395f, 0.06516562f, 0.08609410f, -0.07919484f, 0.10704529f, -0.08170979f, 0.02271134f, 
    0.04460995f, -0.01727228f, 0.01067419f, 0.06072211f, 0.05459525f, 0.05295037f, 0.06893104f, -0.01555588f, 
    -0.03837553f, -0.17994721f, -0.01025366f, -0.06689943f, -0.03327517f, -0.03455946f, -0.03218147f, -0.14086004f, 
    0.04193181f, 0.19049281f, -0.01753436f, -0.06043651f, -0.25755107f, 0.19132864f, -0.04992615f, -0.17720087f, 
    0.00002007f, 0.06121970f, -0.07087240f, 0.09985233f, 0.05045400f, 0.01141720f, 0.04830068f, 0.00053523f, 
    0.19455145f, -0.07690305f, -0.20244703f, 0.14236966f, -0.02937743f, -0.01071387f, 0.06523649f, -0.10479435f, 
    0.15764660f, 0.04096702f, 0.00868010f, -0.06601808f, 0.52169120f, -0.03533592f, -0.18690257f, -0.05621374f, 
    -0.07139432f, -0.03538984f, 0.06679511f, 0.05048316f, 0.02677897f, -0.14322028f, -0.26264265f, -0.02482000f, 
    -0.18524176f, 0.01829700f, 0.10568937f, -0.09491024f, -0.04182839f, -0.02991156f, 0.01827577f, 0.06455700f, 
    0.10525832f, -0.05215730f, 0.02417730f, 0.05793102f, -0.38940802f, -0.03627301f, 0.32267573f, -0.00725599f, 
    0.01978513f, 0.01259302f, -0.06392167f, 0.02339751f, 0.16201712f, -0.06653637f, 0.08035865f, 0.02034653f, 
    0.05350919f, -0.25931102f, 0.06503765f, 0.09684699f, 0.05544574f, -0.06500076f, -0.06765750f, 0.00430591f, 
    -0.02676708f, 0.06094599f, -0.06703243f, -0.15493116f, -0.11596847f, 0.02364353f, 0.02587350f, 0.06344828f, 
    0.08802464f, -0.03761007f, -0.16549274f, -0.00814924f, 0.13394316f, 0.06362198f, 0.03572251f, 0.03258367f, 
    0.42023233f, -0.42704743f, 0.22685242f, 0.02092972f, -0.03795974f, -0.04112367f, -0.00294765f, 0.00789805f, 
    -0.04695666f, 0.06146924f, 0.01809894f, 0.00273480f, -0.09608272f, -0.33241311f, 0.02553924f, 0.09661599f, 
    0.11182159f, -0.06566038f, -0.00953688f, 0.14855796f, 0.00466020f, -0.11634861f, 0.21951954f, -0.01660667f, 
    -0.04862314f, 0.02524536f, -0.08795339f, 0.18867229f, -0.00613810f, 0.00627196f, -0.08827106f, 0.05638611f, 
    -0.10029723f, 0.01557175f, -0.00314001f, 0.02193825f, -0.15566520f, -0.20189911f, -0.04822705f, -0.12990840f, 
    -0.00579473f, 0.04047644f, 0.00438617f, 0.01718616f, -0.04810403f, 0.01642622f, -0.03852269f, -0.02317377f, 
    -0.07966132f, -0.02037938f, 0.20620154f, 0.04220880f, 0.01363616f, 0.08345684f, 0.00450566f, -0.10335417f, 
    -0.03160069f, -0.05690731f, -0.08533228f, -0.02647824f, 0.29557762f, 0.23468567f, -0.00250560f, 0.07322931f, 
    0.03919412f, 0.07582515f, -0.03808130f, -0.00866033f, -0.10291027f, 0.01244284f, -0.05557138f, 0.09309392f, 
    -0.17966607f, 0.23652674f, -0.20738158f, 0.17818078f, 0.08800870f, -0.07563184f, 0.07372145f, -0.14381090f, 
    -0.00513655f, 0.08066321f, -0.05415653f, -0.13515876f, -0.11664993f, -0.07013854f, 0.00472492f, -0.02481656f, 
    0.06352419f, 0.09680799f, -0.07594117f, -0.00557636f, -0.03560686f, -0.00396658f, -0.02360748f, -0.05101979f, 
    -0.13489455f, -0.11465460f, 0.07477044f, -0.21022843f, -0.00963677f, 0.02836151f, -0.04428747f, 0.01970636f, 
    -0.06821909f, -0.04256077f, -0.01725200f, -0.06323785f, -0.11492750f, 0.01301807f, 0.18969592f, -0.24345547f, 
    0.03112799f, 0.00729400f, 0.04900393f, -0.07568233f, -0.02375365f, -0.08498619f, 0.01525187f, -0.09491559f, 
    0.29068622f, 0.11386457f, 0.24691376f, 0.00523341f, 0.05920142f, 0.01795897f, 0.05758912f, -0.06128220f, 
    -0.02140735f, 0.02768104f, 0.07205879f, 0.06518196f, -0.09160024f, -0.14073612f, -0.05866943f, 0.01734989f, 
    -0.12920132f, -0.06891319f, -0.11950379f, -0.00330608f, 0.02434631f, 0.07827184f, -0.03875067f, 0.12606709f, 
    -0.10072719f, 0.40544069f, -0.17684831f, 0.15866682f, 0.11392500f, -0.01146948f, -0.01343857f, 0.04187136f, 
    0.01241952f, 0.09408213f, 0.02360575f, 0.00005696f, -0.05086931f, -0.15595204f, -0.15107821f, 0.15585096f, 
    -0.13968757f, 0.09648181f, 0.01565604f, 0.06756878f, 0.02267954f, 0.02810943f, 0.00955453f, 0.01006446f, 
    0.12347687f, 0.17359152f, -0.01354806f, -0.10975460f, -0.08030116f, -0.00711777f, -0.00732938f, 0.05197933f, 
    0.02752302f, 0.05412301f, -0.05447459f, -0.00149330f, 0.17288022f, -0.04315366f, 0.21144298f, 0.09735726f, 
    0.04189985f, 0.04990507f, 0.01165345f, -0.07882983f, -0.11516577f, -0.00352478f, -0.02680809f, 0.06996664f, 
    0.25981671f, 0.01567126f, -0.10116126f, -0.15645571f, 0.14135361f, -0.00351487f, -0.05201931f, 0.12058301f, 
    -0.08729136f, -0.06341608f, -0.00712919f, 0.00436151f, -0.35086608f, 0.18333448f, -0.15926200f, -0.07796272f, 
    0.07875207f, 0.06568916f, 0.14070395f, 0.00700275f, 0.07539249f, -0.02815340f, 0.14365110f, 0.11846714f, 
    -0.01223478f, -0.01104940f, -0.18339868f, -0.36001503f, -0.03546474f, -0.00877753f, -0.11380970f, 0.05780067f, 
    -0.08525955f, 0.05029836f, 0.04317782f, 0.17547707f, 0.10514614f, -0.23544148f, -0.02539245f, 0.09534371f, 
    0.01921505f, -0.00487142f, 0.00364749f, 0.08031458f, -0.05127580f, 0.00930380f, 0.06972285f, -0.00239171f, 
    0.00824928f, 0.00422388f, 0.13070033f, -0.18608217f, 0.05061059f, -0.12433297f, -0.11184684f, 0.12573966f, 
    -0.08056293f, 0.07369149f, -0.13603792f, 0.00494221f, -0.10562845f, 0.00386845f, 0.02187097f, -0.28571913f, 
    0.03660638f, 0.03186247f, 0.05454900f, -0.07583663f, -0.12484215f, 0.07014070f, -0.06637525f, 0.01281801f, 
    0.20628931f, -0.21939375f, -0.17172514f, -0.01838640f, -0.02633536f, 0.03461953f, 0.03693435f, 0.04696513f, 
    -0.00316429f, -0.03338724f, 0.00755303f, -0.06463776f, -0.13872087f, 0.05500355f, -0.14575636f, -0.06815125f, 
    0.00385715f, -0.06009069f, 0.12922472f, -0.04776230f, 0.12361100f, 0.17761330f, 0.04025637f, -0.04367627f, 
    -0.26322597f, 0.08063187f, -0.28527412f, -0.15162499f, 0.01287860f, -0.07731289f, 0.08608748f, -0.13277198f, 
    -0.10882802f, -0.04941714f, -0.14710431f, -0.07745294f, 0.02848570f, 0.05081371f, 0.03757443f, 0.15600307f, 
    -0.14324319f, -0.01702537f, 0.01796759f, -0.08247104f, -0.03348148f, -0.00292630f, -0.17143297f, 0.03714825f, 
    -0.25744456f, 0.24824484f, 0.14500280f, -0.09589314f, 0.01423278f, 0.06709589f, 0.02009244f, -0.00410254f, 
    0.01737040f, -0.03242014f, 0.04515762f, 0.04288413f, 0.25930890f, 0.10057925f, -0.18981627f, 0.26632333f, 
    0.12693900f, -0.06034255f, -0.01181647f, -0.01873165f, -0.02723128f, 0.02658047f, -0.05566864f, 0.12222973f, 
    -0.45896405f, 0.08557735f, -0.21738189f, -0.08393659f, 0.04711860f, -0.01413945f, 0.07673237f, -0.12730499f, 
    -0.04025141f, 0.00502902f, 0.05994001f, 0.08155318f, -0.05611661f, 0.15141658f, 0.09145363f, 0.04408237f, 
    0.06402487f, 0.03893534f, -0.04487836f, 0.05874749f, 0.00630930f, -0.01366853f, 0.11731339f, 0.04472681f, 
    -0.03723830f, 0.21096873f, -0.10516452f, -0.19999439f, -0.04810677f, -0.08344233f, -0.02138172f, 0.10273503f, 
    0.01389448f, -0.01616511f, -0.11968108f, -0.03686999f, 0.01840289f, -0.02311730f, 0.07162901f, -0.03793127f, 
    -0.00685888f, 0.17482218f, -0.07209162f, -0.01456134f, 0.01856278f, 0.10972501f, -0.12303437f, 0.08402657f, 
    0.00347639f, 0.02935889f, 0.03262878f, 0.12403594f, 0.00699769f, 0.01292072f, -0.07265507f, 0.03856094f, 
    -0.08165126f, -0.05422651f, -0.06660356f, -0.11819366f, 0.26897463f, -0.08737066f, -0.16898556f, -0.08092950f, 
    0.09355542f, 0.02759515f, 0.02797562f, -0.06313320f, 0.03315199f, 0.00498562f, -0.01381747f, -0.07247100f, 
    0.02001520f, -0.12323365f, -0.03439077f, 0.13765201f, -0.14112166f, -0.09672687f, 0.06354944f, 0.06964386f, 
    -0.04193811f, 0.14560871f, 0.04410081f, -0.00507196f, -0.20288257f, -0.28647470f, 0.04889079f, 0.11714657f, 
    0.06664470f, 0.02419607f, 0.04970622f, -0.02299715f, 0.02394783f, 0.08262989f, 0.03428416f, 0.07240739f, 
    -0.11323243f, -0.15637022f, 0.02496266f, -0.14922673f, 0.00521118f, -0.14540526f, 0.05240589f, -0.03604322f, 
    -0.04972192f, -0.10440372f, -0.00948610f, 0.08991396f, 0.30449325f, 0.18070407f, -0.20141484f, -0.06246829f, 
    -0.00158931f, -0.09542535f, -0.03744512f, -0.00482853f, -0.01572205f, -0.08320510f, -0.07350928f, -0.03843819f, 
    -0.01485389f, 0.11285850f, 0.12038647f, 0.05338268f, 0.02211079f, -0.00694865f, -0.07251938f, 0.05498041f, 
    -0.02447506f, 0.06178822f, -0.04389863f, 0.01349804f, -0.08627386f, 0.28910899f, -0.30120435f, 0.20112808f, 
    0.05036354f, -0.02624683f, -0.08194786f, 0.04936363f, -0.11982960f, -0.00376964f, -0.07749370f, -0.03480598f, 
    -0.01393248f, -0.00890391f, 0.18767081f, -0.06963827f, 0.10779190f, 0.09879201f, -0.06694411f, -0.11067758f, 
    -0.06728471f, -0.13752809f, -0.11769804f, -0.00844892f, -0.06329449f, -0.27922484f, 0.18144698f, -0.03315117f, 
    -0.04472402f, 0.02787288f, -0.05994225f, 0.19098127f, 0.05735585f, 0.05582630f, 0.00364678f, 0.01063416f, 
    -0.01320431f, 0.05979092f, 0.02380738f, -0.07667515f, -0.07915594f, 0.00626343f, 0.06337507f, -0.01312528f, 
    0.09509254f, 0.03761804f, -0.01745118f, -0.02507853f, 0.47611168f, 0.01728316f, 0.15052792f, -0.24318527f, 
    0.00214766f, 0.09877077f, 0.10796431f, -0.06523226f, -0.06893817f, -0.00091746f, -0.00450244f, -0.04300177f, 
    0.08894055f, -0.12579302f, -0.13933462f, 0.05633016f, 0.02845579f, -0.07879280f, -0.06353622f, 0.03753407f, 
    0.10425231f, 0.04636364f, 0.09759399f, -0.06895589f, 0.12426723f, -0.06297585f, -0.06149045f, -0.13811299f, 
    -0.00675191f, -0.00561741f, 0.03836843f, -0.07637893f, -0.06187597f, 0.02877411f, -0.00228128f, 0.18852241f, 
    -0.22318886f, -0.39324927f, 0.06289290f, -0.03271335f, -0.01479765f, 0.01732690f, -0.03429019f, 0.01262298f, 
    0.01139353f, -0.00702780f, -0.05723738f, -0.00642554f, -0.20089667f, 0.03848818f, 0.22741981f, 0.01442860f, 
    0.01055861f, 0.08381774f, 0.02039658f, 0.13781033f, 0.08122700f, 0.09977403f, -0.02187640f, 0.02549758f, 
    -0.02217795f, -0.11887468f, -0.19403183f, -0.15509667f, 0.00221752f, 0.00738351f, 0.03251729f, -0.02726812f, 
    -0.03325749f, -0.04279323f, -0.06426290f, -0.08218868f, 0.38732731f, -0.03256919f, -0.01881537f, 0.16295581f, 
    0.03324795f, 0.03699193f, -0.06652351f, -0.05627248f, 0.00025905f, -0.01206982f, -0.09621778f, -0.00444191f, 
    -0.13664551f, -0.08934028f, 0.05089103f, 0.04143713f, 0.03080108f, 0.04041531f, -0.01693681f, 0.03804019f, 
    0.04118587f, 0.05266187f, 0.02665256f, -0.02095723f, -0.13263319f, -0.06931572f, 0.10619162f, -0.11133824f, 
    0.05515916f, 0.02545744f, 0.02665227f, 0.09859011f, 0.06464443f, -0.01052015f, -0.02855276f, -0.00061290f, 
    -0.25710592f, 0.11608009f, 0.13681720f, 0.07438479f, -0.04116903f, 0.04655775f, -0.05491701f, -0.03674525f, 
    -0.01162733f, -0.06592815f, 0.03383080f, 0.06043551f, -0.16026020f, -0.11223993f, 0.01103796f, -0.05510869f, 
    0.05261204f, -0.01056717f, -0.18878394f, -0.02328382f, 0.03984406f, -0.14219327f, 0.07507446f, -0.11195821f, 
    -0.22894874f, 0.05293613f, -0.09304424f, 0.07835174f, 0.08190021f, -0.04820836f, 0.03569153f, -0.02118575f, 
    -0.06152321f, 0.05192248f, 0.03045538f, 0.06424116f, 0.04820081f, -0.52583325f, 0.01483905f, -0.02093101f, 
    -0.01560061f, 0.02109160f, -0.01121930f, 0.04071962f, -0.16222110f, -0.14491105f, 0.02166228f, 0.03744627f, 
    0.18637373f, -0.00982871f, -0.05564745f, 0.10691619f, -0.07139638f, -0.03510556f, 0.01798414f, 0.15602189f, 
    0.01776062f, 0.01789820f, -0.03096182f, -0.04229636f, -0.20176230f, -0.16706404f, -0.11116961f, -0.18222629f, 
    0.09871017f, 0.01769195f, -0.02520182f, -0.05818003f, 0.14061244f, -0.05935514f, -0.11285459f, 0.06604466f, 
    0.21774638f, -0.11929630f, -0.02699644f, 0.09197129f, -0.02778715f, -0.07819512f, 0.06727530f, 0.14196020f, 
    0.09488335f, 0.09420445f, -0.04612936f, 0.09581235f, -0.08445965f, -0.07587531f, -0.19346079f, 0.03531423f, 
    -0.07601432f, -0.09714353f, 0.00401491f, 0.06043718f, -0.02071761f, 0.09607257f, 0.13287102f, 0.01236806f, 
    -0.03657494f, -0.00177963f, -0.03033734f, -0.04325278f, -0.03329909f, 0.02815911f, 0.06520506f, -0.09239867f, 
    0.00009450f, 0.03666683f, -0.06562248f, -0.02974505f, -0.13347204f, -0.04925191f, -0.07036964f, -0.04519007f, 
    0.00278160f, 0.01879175f, 0.03279640f, -0.03421046f, -0.01035532f, 0.03569081f, 0.04813126f, 0.01897456f, 
    0.05937072f, 0.10920038f, 0.07728960f, -0.08631150f, 0.01035994f, -0.10644960f, -0.03850427f, 0.05521221f, 
    -0.01953883f, 0.14634074f, -0.00372549f, 0.10299264f, 0.10497543f, 0.03841158f, -0.02837618f, -0.01328449f, 
    -0.09910090f, -0.06496838f, 0.06161822f, 0.01798863f, 0.14592619f, 0.00771660f, 0.03450067f, 0.06641991f, 
    -0.25679010f, 0.04354477f, -0.25783250f, -0.08798116f, 0.00514984f, 0.03731403f, 0.01002257f, -0.00237150f, 
    0.04522093f, 0.03567126f, -0.13445771f, -0.09642431f, -0.04377187f, 0.17446573f, -0.07475193f, -0.24629365f, 
    -0.01142657f, 0.01197033f, -0.12954484f, 0.01834779f, -0.01290968f, 0.00812557f, -0.06154390f, -0.03526017f, 
    0.01770722f, -0.12000646f, 0.05183920f, -0.04972033f, 0.00586638f, 0.00560215f, 0.06531996f, -0.12615655f, 
    0.08426676f, -0.04095972f, -0.02135407f, -0.13091664f, 0.15598798f, 0.01478219f, -0.00924413f, -0.01245848f, 
    -0.13950482f, -0.03038798f, -0.07686738f, -0.03279216f, 0.01027260f, -0.03213997f, -0.03809341f, 0.01363363f, 
    0.04319192f, -0.03343506f, 0.12727118f, 0.01446753f, 0.15316015f, -0.01339996f, -0.02098170f, 0.07855213f, 
    -0.05970278f, 0.06688797f, -0.04089625f, 0.13613865f, 0.15164901f, -0.00118669f, 0.03016239f, -0.13725603f, 
    -0.10303967f, -0.02304997f, -0.03053853f, -0.10232301f, 0.02047751f, -0.08619244f, -0.00471127f, -0.04828980f, 
    0.12398276f, -0.04891978f, -0.02358055f, -0.02328084f, 0.02461155f, 0.10660765f, 0.03124725f, 0.10796693f, 
    0.06735557f, -0.08142959f, 0.10281423f, 0.11156560f, 0.08778113f, 0.16290992f, -0.06555050f, -0.06288251f, 
    0.04456640f, 0.02345979f, -0.01382281f, 0.01596274f, -0.09456149f, 0.04229695f, 0.14407443f, 0.02667555f, 
    -0.21458574f, -0.03502068f, -0.15052007f, 0.03439381f, 0.18138203f, 0.00202490f, 0.02588869f, -0.01468202f, 
    0.10696722f, 0.15395346f, -0.08669689f, -0.03027240f, -0.31357273f, 0.04998482f, 0.15261166f, -0.00881257f, 
    0.07464531f, 0.04464442f, -0.06401714f, 0.01158196f, -0.03048172f, 0.07856748f, 0.02592454f, 0.10781995f, 
    -0.30467901f, 0.10562844f, 0.07996733f, 0.12609096f, 0.14604554f, 0.01551753f, 0.04705094f, -0.06446066f, 
    0.09689281f, 0.15812109f, -0.04233613f, 0.00420494f, -0.13773665f, -0.18691216f, 0.02310078f, 0.03975186f, 
    0.00469135f, 0.06831810f, 0.03062488f, -0.07007559f, 0.05365751f, -0.08243956f, -0.22673692f, -0.04306505f, 
    0.06621258f, -0.11741411f, 0.01083083f, -0.00342144f, -0.03674426f, -0.06407645f, 0.09142112f, 0.07990098f, 
    -0.00759356f, -0.01003356f, -0.02810435f, -0.04658892f, 0.22108796f, 0.08416735f, 0.03095033f, 0.02968058f, 
    0.04848152f, 0.06687685f, 0.03545963f, -0.09206829f, -0.00495130f, -0.11985733f, 0.00987629f, 0.01049582f, 
    -0.32470328f, -0.13791901f, -0.05318657f, 0.09033808f, -0.05577771f, -0.06407179f, -0.10114553f, -0.06524506f, 
    0.03212332f, 0.04720348f, -0.02427392f, 0.15796553f, -0.37556019f, 0.03297099f, 0.15025508f, 0.10921426f, 
    0.09524021f, 0.07899775f, 0.02906869f, -0.00452822f, -0.00211118f, -0.11396869f, -0.02405610f, 0.07316671f, 
    -0.00777530f, 0.14437537f, -0.03192551f, 0.07468782f, -0.10094629f, -0.00144557f, 0.10660011f, -0.10978331f, 
    0.04360872f, 0.05265451f, 0.02492345f, 0.01186905f, -0.27781487f, -0.29487878f, -0.11132587f, 0.00308930f, 
    0.03738350f, 0.01056762f, 0.03309273f, -0.06358559f, 0.06160514f, -0.09687316f, -0.06403968f, 0.08459812f, 
    -0.04968394f, 0.05993494f, 0.12201282f, -0.24515925f, 0.02090992f, -0.00648860f, 0.00511651f, 0.00112574f, 
    0.01581803f, -0.01604428f, -0.17027159f, -0.10637380f, 0.19932057f, 0.09268107f, -0.13170917f, -0.02868752f, 
    -0.03216178f, 0.00136803f, -0.05957895f, 0.03048136f, -0.06858367f, -0.01533043f, -0.00677781f, 0.05422707f, 
    -0.32797128f, -0.08910994f, -0.10525275f, -0.20442805f, -0.01316370f, -0.03769647f, -0.12611781f, 0.02751812f, 
    -0.02866222f, -0.03597810f, 0.14290029f, -0.01029561f, -0.10383878f, -0.07872326f, 0.04171871f, -0.24640630f, 
    0.03177762f, -0.00706314f, -0.00547042f, 0.05098154f, 0.08180903f, 0.06407076f, 0.06837209f, -0.01019693f, 
    0.14011480f, -0.01844527f, -0.12683277f, 0.05931325f, -0.08791976f, 0.02712827f, 0.12505677f, 0.02515190f, 
    -0.01155433f, 0.07304776f, 0.07070880f, 0.11378289f, 0.30333042f, 0.20267928f, 0.02642120f, -0.14991127f, 
    -0.02126998f, 0.04477119f, -0.06622413f, 0.17009880f, -0.07884526f, 0.03497349f, 0.04060422f, 0.03702327f, 
    -0.45549181f, -0.19840962f, -0.07990114f, -0.27221578f, -0.04183999f, -0.07773177f, 0.06050590f, 0.06843442f, 
    -0.02753302f, 0.13233584f, -0.03590254f, 0.01183970f, 0.05928613f, 0.15610996f, -0.10795741f, -0.07940613f, 
    0.02265736f, 0.03816712f, -0.07010812f, 0.08746109f, -0.02560520f, 0.00907900f, 0.06324817f, 0.01551178f, 
    -0.53095847f, -0.43976358f, -0.04970334f, -0.18139713f, 0.11519691f, 0.00312825f, 0.02071693f, -0.04634550f, 
    0.10576893f, -0.02235023f, -0.00860020f, 0.10116773f, 0.13004406f, 0.03981750f, 0.00165811f, 0.09270657f, 
    0.06768571f, 0.00371028f, 0.02727345f, 0.03520765f, 0.07463424f, -0.01139640f, 0.02340722f, -0.03288728f, 
    -0.27029437f, -0.24204728f, -0.03663634f, 0.05521131f, -0.03411001f, -0.04197989f, 0.00394821f, 0.10523397f, 
    -0.02720764f, 0.02226146f, 0.05330955f, 0.05706887f, 0.02167783f, -0.08760142f, 0.02459483f, 0.00083194f, 
    -0.05586795f, -0.04116978f, 0.00852707f, -0.05803859f, 0.04244117f, -0.10388629f, -0.20986554f, -0.07208303f, 
    0.20236135f, 0.26924887f, 0.01956295f, 0.03394545f, 0.02035933f, -0.04854053f, 0.08031302f, 0.02550821f, 
    0.02021725f, 0.12457900f, 0.09885528f, 0.04465246f, 0.29298857f, 0.04525854f, -0.00713653f, 0.04721502f, 
    -0.06420366f, 0.01724498f, -0.10456017f, -0.02192359f, 0.02545932f, -0.02122050f, -0.03497596f, 0.01816535f, 
    0.00391379f, 0.17482048f, -0.02811853f, -0.11454362f, 0.09208146f, 0.11336865f, 0.09702782f, -0.02070624f, 
    0.01914062f, -0.02005306f, 0.12169636f, 0.12261134f, -0.33689848f, -0.12836622f, -0.19336632f, -0.24052441f, 
    0.06691895f, 0.01431666f, -0.13132817f, 0.07521950f, 0.01045101f, 0.05644970f, 0.10998315f, 0.05020324f, 
    0.06270400f, 0.07373888f, 0.04702826f, -0.07034831f, 0.04012873f, 0.01172896f, -0.07683122f, 0.06230903f, 
    0.06684735f, 0.01914193f, -0.10700103f, -0.05909467f, 0.04191244f, 0.04526660f, -0.03805106f, 0.07693119f, 
    -0.07512597f, -0.02972094f, -0.01251436f, 0.05003552f, 0.01937431f, -0.14355534f, 0.01941136f, -0.18366739f, 
    -0.06157210f, -0.10626950f, -0.12242863f, 0.12646057f, 0.06132384f, -0.02749921f, -0.08187304f, -0.04501305f, 
    -0.05119003f, 0.06690299f, 0.00056302f, -0.03828363f, -0.09967647f, 0.07991292f, -0.01299583f, 0.05151908f, 
    -0.05292623f, 0.07446601f, -0.04331084f, -0.04334056f, 0.06064017f, 0.12559465f, 0.06430437f, 0.04237260f, 
    -0.36543635f, -0.16382830f, -0.04945224f, -0.00756626f, 0.09422075f, 0.00103681f, -0.07134050f, -0.09290158f, 
    0.11776040f, -0.02701177f, -0.00758852f, -0.02702990f, 0.12847626f, 0.03809728f, -0.06318016f, 0.13345122f, 
    -0.01989490f, -0.09660248f, 0.02319581f, -0.04725234f, -0.01554481f, 0.04472993f, -0.01682178f, -0.12946798f, 
    -0.48468503f, -0.26960909f, -0.03045084f, -0.10931139f, 0.08619233f, 0.06114218f, 0.01474916f, -0.02929902f, 
    0.02979909f, 0.08523917f, 0.02664240f, 0.10297375f, -0.18766995f, -0.15869333f, 0.11904635f, -0.09376776f, 
    0.01093325f, -0.02761290f, 0.01267998f, -0.04083807f, -0.12268300f, -0.14076367f, -0.02743709f, -0.01425523f, 
    0.04100114f, 0.16821519f, 0.17626622f, -0.00644127f, -0.03021887f, 0.00979599f, 0.03413958f, 0.06496564f, 
    -0.01614979f, -0.02441963f, 0.00607277f, 0.00498633f, -0.55168974f, -0.19724040f, -0.03565104f, 0.04178856f, 
    0.06788760f, 0.01437127f, 0.00430181f, 0.06290873f, 0.10547857f, 0.00460447f, -0.02026452f, 0.20887783f, 
    0.07325703f, 0.11117835f, -0.02377325f, -0.02177004f, -0.08088905f, -0.05604996f, 0.06349487f, 0.03152545f, 
    0.02578385f, -0.15013787f, -0.11303949f, -0.04834017f, 0.08743868f, 0.04120206f, -0.11396529f, 0.07216716f, 
    0.01537320f, 0.03651556f, 0.05095488f, 0.13098143f, 0.16808726f, 0.09668391f, 0.02215902f, 0.00788042f, 
    0.19878711f, 0.02338014f, -0.08578712f, -0.04263014f, -0.03426793f, -0.05421728f, -0.01668362f, -0.01069521f, 
    -0.00349557f, 0.02926404f, -0.03970771f, -0.02591056f, -0.10536343f, 0.00557360f, -0.10696714f, -0.03801025f, 
    0.01484845f, -0.02504523f, 0.02458533f, 0.01780961f, 0.04886359f, -0.14374918f, 0.01049422f, -0.10962596f, 
    -0.71748620f, -0.28954765f, -0.21337055f, -0.18206872f, -0.00775583f, -0.07907321f, -0.15261142f, 0.02940044f, 
    -0.00273165f, 0.13211626f, -0.01077568f, 0.07370258f, 0.12059120f, -0.14444377f, 0.12233886f, -0.15642053f, 
    -0.00389911f, -0.00444205f, -0.03342378f, -0.04483891f, -0.07509930f, 0.07665149f, -0.04430709f, -0.14179586f, 
    0.03730068f, 0.15939370f, -0.01664907f, 0.10550642f, -0.11595371f, 0.02496838f, 0.03632104f, -0.00408827f, 
    0.00617508f, -0.05539910f, 0.16515945f, -0.01551845f, 0.10650513f, 0.06725819f, -0.04787348f, -0.00517080f, 
    0.04323612f, -0.02004736f, 0.05559955f, -0.10987348f, 0.02145232f, 0.00707609f, -0.06589857f, 0.02293289f, 
    0.00636655f, -0.09463426f, 0.07213195f, 0.02996923f, -0.00018602f, -0.00220222f, 0.05588958f, -0.09135658f, 
    0.10255983f, 0.02072471f, -0.08035786f, 0.03599711f, 0.14141549f, 0.01982309f, -0.06128237f, -0.08446655f, 
    -0.11145144f, -0.05475966f, 0.09017276f, -0.11517476f, 0.05217079f, 0.02705874f, -0.03853036f, 0.03112425f, 
    -0.34807947f, -0.25390482f, 0.00833165f, 0.01957759f, -0.01099779f, 0.03672617f, 0.04417101f, 0.03300317f, 
    0.08593327f, 0.08227520f, 0.04519650f, 0.00966597f, -0.00282505f, -0.00938452f, 0.02413254f, 0.11770664f, 
    -0.00268575f, 0.02389306f, 0.00695117f, -0.05773638f, 0.02873093f, 0.15263797f, 0.04658778f, 0.05475527f, 
    -0.00020696f, 0.06922097f, -0.07678705f, 0.13842310f, 0.10499995f, -0.04073205f, 0.02384895f, 0.02569421f, 
    -0.01553558f, -0.13210978f, 0.06977708f, -0.06148674f, 0.07028104f, -0.23382451f, -0.14107113f, 0.09342653f, 
    0.06330752f, 0.06261744f, 0.06356709f, -0.02289728f, 0.04599096f, 0.02928488f, 0.00940017f, 0.04362411f, 
    0.05626702f, 0.04401005f, 0.10717484f, -0.08375921f, -0.10809547f, 0.05747675f, -0.07300197f, -0.02122043f, 
    -0.11782902f, -0.05412794f, 0.02353005f, 0.06139182f, -0.09147638f, -0.05168808f, 0.08561843f, 0.14353848f, 
    0.00129072f, 0.10198455f, -0.06316613f, 0.04496265f, -0.05503329f, -0.15855224f, 0.07152928f, 0.07633688f, 
    -0.24101670f, -0.21611626f, -0.04818845f, 0.04413619f, -0.00425618f, 0.07973964f, -0.02484173f, 0.09530662f, 
    0.04469695f, -0.02293858f, -0.00384086f, -0.03912782f, 0.11537525f, -0.32556522f, -0.12385029f, 0.10761848f, 
    -0.08217108f, 0.02038320f, -0.15397465f, -0.07164500f, 0.02238894f, 0.09429200f, -0.00727398f, -0.00093559f, 
    -0.19523296f, 0.19354782f, -0.11973570f, 0.08027807f, -0.13148761f, -0.00207437f, -0.02045903f, 0.10249620f, 
    0.05445060f, -0.11297385f, -0.03736087f, 0.04032615f, 0.01605077f, -0.12508993f, 0.00970010f, 0.03625720f, 
    -0.01691450f, -0.03165335f, -0.05609250f, -0.01534037f, -0.15786456f, 0.02129574f, -0.00538468f, -0.15358265f, 
    -0.27535880f, 0.11385120f, 0.05163982f, 0.06068362f, -0.11252709f, -0.03645709f, -0.03533994f, 0.05510658f, 
    -0.03329087f, -0.05807374f, 0.10721218f, -0.00554786f, -0.51889694f, 0.08245477f, 0.15272704f, 0.04945687f, 
    -0.00410554f, 0.11551183f, -0.11399764f, 0.12676886f, -0.08540007f, 0.02152673f, 0.04620890f, 0.07436068f, 
    -0.11734957f, 0.23428109f, 0.09935196f, 0.02592902f, 0.06655096f, -0.12313330f, -0.01612860f, -0.04804739f, 
    -0.04521458f, 0.06834076f, 0.00010947f, -0.05614136f, -0.06169617f, -0.00463316f, -0.07432723f, 0.02874509f, 
    -0.03684858f, 0.07574666f, 0.05929140f, -0.02799227f, -0.04290564f, -0.02757795f, -0.04208029f, -0.07284655f, 
    0.14447641f, 0.09026618f, -0.05326722f, 0.04827720f, 0.01265004f, 0.02756762f, -0.08055007f, -0.05607683f, 
    0.06042250f, -0.03328217f, -0.05076131f, 0.01296362f, -0.23750119f, 0.09355132f, 0.06336145f, -0.05266782f, 
    -0.03702736f, 0.00802364f, -0.04029611f, -0.18111563f, 0.14830221f, -0.04350754f, -0.00565413f, -0.09786737f, 
    0.17530493f, -0.12933029f, 0.17351869f, 0.06474502f, 0.03263484f, 0.02804629f, -0.02634755f, -0.11664152f, 
    -0.08784600f, -0.01511465f, -0.01135599f, 0.00755455f, 0.16920495f, -0.01104213f, -0.08901935f, 0.04420518f, 
    -0.05661451f, -0.00570598f, -0.09100530f, 0.02657188f, -0.06247052f, -0.02273483f, -0.05343815f, -0.12505446f, 
    0.00299052f, -0.07833631f, -0.08309679f, 0.38472572f, 0.08971865f, 0.08557223f, -0.09215230f, 0.00732337f, 
    0.00558141f, 0.02583906f, 0.05014611f, 0.00370542f, 0.29221183f, 0.22465906f, -0.07847911f, -0.00703261f, 
    0.06340478f, 0.06817305f, -0.00095710f, -0.02640660f, 0.03886706f, -0.00480933f, 0.04428422f, 0.05571779f, 
    0.33565649f, -0.04287143f, -0.06500960f, -0.05494370f, 0.04679048f, -0.10316148f, -0.21897706f, -0.01726006f, 
    0.06089141f, 0.00474453f, 0.11952926f, -0.00382836f, 0.16375662f, 0.18390293f, -0.19552554f, -0.01624892f, 
    -0.01262622f, -0.02137235f, -0.01040957f, -0.03311320f, 0.05544042f, 0.02798135f, 0.12265303f, 0.06296276f, 
    -0.22997171f, -0.32950670f, -0.12529166f, -0.05271728f, -0.04909176f, 0.02849298f, 0.10358474f, 0.06170199f, 
    -0.01649683f, 0.10900567f, -0.04284906f, -0.00179014f, -0.28083014f, 0.09256203f, -0.07545411f, -0.14153527f, 
    -0.10649389f, 0.00067945f, 0.06613784f, -0.01745871f, 0.00946296f, 0.06017463f, -0.02301872f, 0.03221462f, 
    -0.05425246f, -0.00789879f, 0.08395130f, -0.19242859f, 0.07947392f, 0.07828914f, 0.05718236f, 0.04547060f, 
    0.03795937f, -0.05574099f, 0.10191063f, 0.10002249f, 0.34522864f, 0.14403474f, -0.07619642f, -0.08561811f, 
    -0.03437812f, -0.07996996f, -0.04362914f, 0.05749287f, 0.08787121f, 0.11555525f, 0.06313016f, 0.00746825f, 
    -0.04289873f, -0.03650896f, -0.09870416f, 0.11296499f, -0.22321625f, -0.00456960f, 0.00246546f, -0.01172723f, 
    0.00272048f, -0.10911936f, -0.08049827f, -0.09725754f, -0.32956344f, -0.04852380f, 0.05057084f, -0.03304765f, 
    0.16259350f, 0.02992576f, 0.05304576f, 0.07914164f, 0.03544757f, -0.08346234f, 0.02155299f, 0.05594622f, 
    0.32113180f, 0.03171308f, -0.26119140f, 0.17293260f, 0.09269836f, -0.11533335f, -0.04462377f, -0.03086175f, 
    0.10141055f, 0.04549284f, 0.03792582f, 0.09498478f, -0.16952039f, -0.06474998f, 0.00211285f, -0.09420791f, 
    -0.08613410f, 0.03314890f, 0.06823833f, 0.06204572f, -0.03595565f, 0.03968415f, -0.01513135f, -0.12113386f, 
    0.12768044f, -0.13238697f, -0.11004480f, -0.23000833f, -0.01921548f, -0.01764450f, 0.05193794f, 0.01037038f, 
    -0.08287722f, -0.00118344f, 0.02996093f, 0.06947745f, 0.23134410f, 0.09700798f, -0.37072897f, 0.11738744f, 
    -0.00322965f, -0.05808290f, 0.08092311f, -0.02849382f, -0.01894984f, 0.10148444f, 0.01408368f, -0.02251269f, 
    -0.10051519f, 0.07503593f, -0.05556003f, 0.10924835f, 0.01756052f, 0.00222892f, -0.03928221f, 0.07534532f, 
    -0.14353688f, -0.06741312f, 0.00202782f, -0.00132609f, -0.16177812f, -0.00322532f, -0.20234862f, 0.10513432f, 
    0.11361168f, -0.06555282f, 0.05944014f, 0.11953381f, -0.08670600f, -0.07393088f, -0.04689825f, -0.03741254f, 
    0.10888804f, -0.10363832f, -0.07954282f, -0.22045077f, -0.00863218f, 0.10334356f, -0.08781189f, 0.00370843f, 
    0.02288845f, -0.08639582f, -0.10429739f, -0.04532776f, -0.02219359f, 0.16725135f, 0.08028100f, -0.14227167f, 
    -0.16925837f, 0.00883586f, 0.04361348f, 0.01614218f, 0.14832917f, -0.00123016f, -0.04279886f, -0.03807909f, 
    0.18838465f, 0.07541894f, -0.11977288f, 0.00532461f, 0.17106615f, 0.05319239f, -0.01360229f, 0.05752697f, 
    0.02467923f, 0.00667014f, 0.04689192f, 0.08022135f, -0.11303560f, -0.19926886f, 0.21691622f, 0.02082952f, 
    -0.01257271f, 0.01036437f, -0.04518199f, -0.03986517f, 0.04886108f, -0.10708826f, 0.09376416f, 0.06682517f, 
    -0.20565763f, 0.19984633f, -0.07029991f, -0.04203568f, 0.11921205f, -0.03287325f, 0.05142219f, -0.13436839f, 
    0.03322434f, -0.04110730f, -0.04733137f, -0.02366596f, -0.00562715f, -0.11654874f, -0.06065512f, -0.02350697f, 
    -0.05057983f, -0.12972686f, 0.00030530f, 0.02673453f, -0.06657691f, -0.01437904f, 0.01542297f, -0.00719402f, 
    0.07667716f, -0.06213368f, -0.04665112f, 0.08086434f, 0.08010972f, 0.01596467f, 0.06870774f, 0.01528778f, 
    -0.01349822f, -0.09185722f, 0.07879439f, -0.12367246f, -0.34752274f, 0.10566320f, -0.16639793f, -0.03768465f, 
    0.09174822f, 0.06545693f, 0.09545187f, -0.12494599f, 0.00490401f, -0.01955999f, 0.02165427f, -0.00502294f, 
    -0.34807527f, 0.20813365f, 0.05283206f, 0.00930314f, -0.05788038f, 0.01076953f, 0.03732041f, -0.07014062f, 
    -0.05118861f, 0.02692287f, -0.01034390f, -0.07473022f, -0.15049304f, -0.07391361f, -0.19875388f, 0.08965512f, 
    0.06716046f, -0.00473699f, 0.07149597f, 0.03831748f, -0.03942169f, -0.06585371f, 0.00187492f, -0.08466565f, 
    -0.05295008f, 0.11837092f, -0.14128977f, 0.21962708f, 0.13509822f, 0.05216306f, 0.09936234f, -0.08556386f, 
    -0.04052656f, -0.03843548f, -0.12443633f, -0.03995874f, 0.04082625f, -0.03333100f, 0.03504090f, 0.00709464f, 
    -0.12941164f, 0.08141647f, -0.06733548f, -0.11217599f, 0.00411304f, 0.02456122f, 0.06139579f, 0.15247475f, 
    -0.48758501f, 0.20610496f, -0.11229624f, -0.03772688f, 0.13628133f, -0.14637850f, -0.01371530f, 0.01643805f, 
    0.05558864f, 0.10671211f, 0.07978082f, 0.11572767f, -0.27696553f, -0.00679685f, 0.13908279f, -0.01476773f, 
    -0.05152543f, -0.08772217f, -0.00140786f, -0.08215857f, 0.02023066f, -0.14527628f, -0.04549666f, -0.04457040f, 
    0.09841508f, -0.14440170f, -0.22811674f, 0.14627060f, 0.00919434f, 0.03249806f, 0.03124225f, 0.01419359f, 
    -0.02866615f, 0.07280954f, -0.00497139f, -0.02227855f, 0.09763935f, -0.22451760f, -0.00914369f, 0.17902221f, 
    0.06005180f, 0.03667058f, 0.08412356f, -0.07209073f, -0.04332289f, 0.06905737f, -0.02921692f, 0.05971206f, 
    0.50436461f, 0.05788020f, -0.20557541f, -0.00984538f, 0.03557639f, -0.14232607f, 0.02373671f, 0.00601088f, 
    -0.00627361f, 0.00603566f, 0.00932703f, 0.03416906f, 0.03602142f, 0.10577367f, -0.00784228f, 0.09582902f, 
    -0.02744177f, 0.16017170f, -0.00452513f, -0.21865211f, 0.02898351f, 0.02159352f, -0.00415801f, -0.08564496f, 
    0.28192857f, -0.01248443f, -0.07950149f, 0.04546222f, -0.11185659f, 0.03013852f, -0.00933769f, -0.02632454f, 
    0.01249143f, 0.03645670f, 0.03786800f, 0.07214112f, 0.23538014f, -0.25739649f, -0.15829520f, -0.30778575f, 
    0.04710662f, -0.04692882f, 0.02732012f, 0.11779304f, -0.08754536f, 0.06700993f, 0.01368548f, -0.08352593f, 
    -0.29213548f, 0.08487355f, -0.14156087f, -0.03219373f, -0.00600763f, -0.08106992f, 0.03785254f, 0.05013487f, 
    0.03317485f, 0.09120601f, 0.06638384f, -0.07697017f, -0.05650005f, -0.19717154f, -0.15375130f, 0.03440202f, 
    0.09354469f, -0.00936072f, -0.05764069f, -0.03280981f, -0.01801484f, 0.02708754f, 0.06193997f, -0.05851498f, 
    0.16986366f, 0.04652709f, 0.00494624f, 0.03497170f, -0.08712465f, -0.00899746f, -0.01826564f, -0.02698756f, 
    0.06925108f, 0.00130632f, -0.00503602f, -0.01956203f, -0.02040082f, -0.00524045f, -0.03690657f, 0.04295754f, 
    -0.02238578f, 0.01749206f, 0.04845853f, 0.00662594f, 0.01768974f, 0.06274305f, -0.03724286f, 0.01717600f, 
    -0.15899298f, 0.07345891f, -0.11470361f, -0.09661128f, 0.09342541f, -0.02563326f, -0.00417401f, -0.04295990f, 
    0.03248633f, 0.02103039f, -0.09935213f, -0.03722618f, -0.13272959f, 0.01819467f, 0.01831114f, -0.05917573f, 
    0.04943746f, -0.05682794f, 0.07557286f, -0.12545869f, 0.00197666f, 0.05795054f, -0.04869256f, -0.03530822f, 
    0.10378193f, -0.12914048f, 0.02577755f, 0.00750152f, -0.09106011f, -0.02908364f, -0.00757584f, 0.01892799f, 
    0.02323759f, -0.01204302f, -0.16638619f, -0.02662645f, 0.26407078f, 0.04270814f, -0.02625297f, 0.07646672f, 
    -0.12293340f, -0.10148618f, 0.01482199f, 0.03319047f, 0.02485283f, -0.06909002f, -0.04523608f, 0.01945730f, 
    0.02930845f, -0.05823095f, -0.02055579f, 0.01607696f, 0.07604799f, -0.05114637f, -0.14609070f, -0.07921481f, 
    -0.10410491f, 0.03626272f, 0.01019267f, -0.06729694f, -0.08468460f, 0.18738970f, -0.04483259f, 0.08273083f, 
    -0.00729332f, -0.01895639f, -0.10171352f, 0.01739817f, 0.00165422f, 0.03880091f, 0.08489102f, -0.07096977f, 
    -0.01923680f, 0.06473204f, -0.03261907f, -0.18214341f, 0.20208257f, -0.09703711f, 0.03003051f, 0.09265132f, 
    0.03386207f, -0.03304391f, -0.03211303f, 0.07331948f, 0.07847490f, 0.05393317f, -0.08288615f, 0.13335662f, 
    -0.03252161f, 0.06256296f, 0.02644684f, -0.12315314f, -0.08852465f, -0.03185132f, 0.00102348f, -0.04107156f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06198015f, 0.02041067f, -0.04282809f, 0.00998893f, 0.02751678f, 0.02408840f, 0.00165912f, -0.03511113f, 
    -0.03147938f, -0.01287262f, 0.06056294f, 0.01803139f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
