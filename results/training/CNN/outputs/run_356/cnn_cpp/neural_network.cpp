#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.06146961f, 0.10323823f, 0.20347118f, 0.04397304f, -0.53218043f, 0.24791691f, 0.12385274f, 0.23901334f, 
    0.35385853f, 0.19718546f, 0.36178634f, 0.47744510f, -0.17623037f, 0.10971880f, 0.22022092f, 0.02260059f, 
    -0.22777085f, 0.32698104f, -0.13781165f, -0.12783705f, 0.16792366f, 0.35804287f, 0.04707219f, 0.32836229f, 
    -0.13858017f, -0.33321565f, -0.44737476f, -0.46019000f, -0.46746767f, -0.56783414f, 0.04962449f, 0.00930440f, 
    0.18200995f, 0.07483497f, 0.35989141f, 0.13756393f, -0.26381361f, -0.20870726f, 0.01997412f, -0.03163635f, 
    0.09641327f, 0.22914128f, -0.09925438f, -0.05430466f, 0.42275655f, 0.12647931f, -0.29608253f, -0.02680434f, 
    -0.21854702f, 0.08646283f, 0.05970743f, -0.66393882f, -0.45534325f, -0.20705070f, -0.08795629f, -0.33101475f, 
    -0.75415647f, -0.15043119f, 0.07093929f, 0.15870290f, -0.37776017f, 0.12244046f, -0.14854687f, -0.09475016f, 
    -0.27116641f, 0.15929624f, 0.11658752f, 0.28968459f, 0.12020945f, 0.13516161f, 0.13491413f, 0.23178625f, 
    0.18845853f, -0.05095449f, -0.12120231f, -0.07285558f, -0.70883888f, -0.64719498f, -0.28166589f, -0.15252724f, 
    0.11138117f, 0.83419722f, -0.02452554f, -0.25312272f, 0.31997862f, -0.07036144f, -0.00757456f, 0.01932178f, 
    0.03665660f, -0.09363745f, -0.26014614f, 0.15354940f, 0.06451553f, -0.11547954f, -0.17921259f, 0.07012183f, 
    -0.17170012f, -0.11473919f, -0.05214693f, -0.10039434f, 0.16534184f, 0.90074044f, -0.47000563f, -0.51122814f, 
    -0.56553310f, 0.70606500f, 0.05717831f, -0.29639134f, -0.10726359f, -0.12111049f, 0.41557914f, -0.14408833f, 
    -0.04602641f, -0.00450839f, -0.17720307f, 0.03997434f, -0.04051904f, -0.02769204f, 0.08405923f, -0.03198821f, 
    0.03444842f, -0.07055676f, 0.14532466f, -0.12345798f, 0.13396837f, -0.28807104f, 0.72566766f, -0.52387935f, 
    -0.20957497f, 0.37851870f, -0.37199879f, -0.36616459f, -0.26567900f, -0.48363864f, -0.02985788f, 0.07608634f, 
    -0.06579173f, 0.14231591f, -0.04808867f, 0.23829579f, 0.11438245f, 0.08103143f, -0.13972372f, 0.04309014f, 
    0.04646763f, 0.36767763f, 0.12929472f, 0.14143804f, 0.04820136f, -0.04560072f, -0.61676896f, -0.23594132f, 
    -0.51281524f, 0.28701019f, 0.44726452f, -0.55936050f, 0.51919299f, 0.64255601f, 0.01700811f, -0.02632511f, 
    -0.19438249f, -0.25254372f, 0.14127050f, -0.14225861f, -0.05796177f, -0.04634301f, -0.07855613f, 0.08839149f, 
    0.05900453f, -0.08081259f, -0.05306895f, 0.07225322f, -0.10248830f, 0.06320188f, -0.27257490f, 0.94200039f, 
    0.24357617f, -0.31903413f, 0.89444840f, 0.33580190f, 0.11789329f, 0.20025142f, -0.11494324f, 0.31988716f, 
    -0.00710666f, -0.32749820f, -0.17025457f, 0.03078608f, -0.00842842f, -0.29438156f, -0.08804788f, -0.03290667f, 
    -0.12504575f, 0.00391443f, 0.06461860f, -0.03807119f, -0.01226304f, 0.07453761f, -0.04886046f, -0.03544758f, 
    -0.66967916f, -0.66148597f, -0.17201492f, 0.31181580f, 0.39148501f, 0.42264178f, 0.53769243f, -0.39413926f, 
    0.16695063f, -0.25150979f, 0.27923796f, 0.05883031f, -0.20959519f, 0.25816128f, 0.22162341f, -0.00613383f, 
    0.00344167f, -0.31728196f, -0.15929718f, 0.18164346f, 0.03494462f, 0.22255807f, 0.17653036f, 0.17980890f, 
    0.16077517f, -0.14929430f, 0.12182636f, -0.00462853f, 0.59196073f, 0.60553986f, -0.63616931f, 0.02211360f, 
    -0.24391265f, -0.13410711f, -0.45393449f, -0.02190291f, 0.12532638f, 0.22578865f, 0.04789538f, 0.33382976f, 
    -0.03165867f, 0.17530158f, -0.08326454f, 0.30294278f, 0.27114233f, -0.17426194f, 0.01885885f, -0.10093852f, 
    -0.21771802f, -0.20858303f, -0.51537740f, -0.24149568f, 0.14342476f, -0.14595746f, -0.36832890f, -0.05492269f, 
    -0.13558550f, 0.50165606f, -0.14760932f, -0.09193535f, -0.00628100f, 0.19252327f, -0.03334873f, -0.10784829f, 
    -0.26835233f, -0.23234133f, 0.25450245f, 0.12885290f, 0.07017200f, -0.39105517f, -0.01470348f, -0.23306471f, 
    -0.33493745f, -0.32149297f, -0.00144362f, -1.02858293f, 0.08243287f, 0.04387030f, -0.46532679f, -0.49620506f, 
    0.48198697f, 0.32144654f, -0.18863706f, -0.00548658f, 0.18496852f, -0.16918306f, -0.04041027f, 0.11843833f, 
    0.27065057f, 0.29622295f, -0.09813444f, -0.14026542f, -0.09063157f, -0.14818372f, 0.02136767f, 0.03388201f, 
    -0.03517980f, 0.07449890f, 0.08820894f, 0.03962385f, 0.80727381f, 0.68104279f, 0.79514259f, 0.52814043f, 
    0.44763327f, 0.07515270f, -0.04029707f, -0.60077167f, -0.16594441f, -0.02420769f, 0.23738493f, 0.23387228f, 
    -0.04793726f, 0.07305474f, 0.08802035f, 0.07584785f, -0.04538319f, 0.10418346f, -0.04352062f, 0.03515160f, 
    -0.02120070f, 0.18706775f, 0.13528526f, 0.08518817f, 0.15742570f, -0.24904017f, 0.07644562f, -0.06952447f, 
    0.65590745f, 0.33717608f, 0.43505678f, 0.31262645f, 0.36001024f, 0.27844620f, 0.32394093f, 0.26098129f, 
    -0.20435828f, -0.17683458f, -0.06587185f, -0.17966825f, -0.36514926f, -0.11681797f, -0.23513223f, -0.05534737f, 
    -0.10846082f, -0.03715833f, 0.25661561f, -0.15591130f, -0.24422385f, 0.14478128f, -0.16895646f, -0.23960546f, 
    -0.19741425f, 0.12424479f, -0.35471311f, -0.30081573f, 0.00031171f, 0.31830689f, -0.27136660f, -0.31938609f, 
    0.10014798f, -0.14584939f, -0.19008724f, 0.15279457f, -0.35901311f, 0.17039129f, 0.00686704f, -0.07177282f, 
    -0.21021967f, 0.26858309f, 0.11419658f, -0.17087425f, 0.48506731f, 0.37763152f, -0.07268490f, -0.60341674f, 
    -0.17830302f, -0.29516959f, -0.36114317f, -0.06070851f, -0.28643811f, -0.16970189f, -0.29668823f, -0.03957748f, 
    -0.33535135f, 0.28134766f, 0.43865338f, -0.31137767f, 0.05936989f, -0.16098607f, -0.05918351f, 0.13225333f, 
    0.07008639f, -0.20943084f, -0.18194979f, -0.03024422f, -0.01001886f, 0.10822704f, -0.17611726f, -0.08506564f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06236286f, 0.06648728f, 0.22751112f, 0.13475132f, 0.19090560f, 0.33038536f, -0.14736675f, 0.17771499f, 
    0.31265470f, -0.03148470f, 0.06681023f, 0.12846953f, 0.20612840f, 0.12292147f, -0.01232494f, 0.32424790f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20655428f, 0.04344946f, -0.16981420f, -0.38589215f, -0.03988963f, -0.04395710f, -0.02482762f, -0.07563464f, 
    0.03283135f, 0.05092235f, 0.09575248f, -0.11100149f, 0.11516915f, 0.10613302f, 0.06454339f, 0.18428300f, 
    0.06866371f, 0.12400097f, 0.12464287f, -0.00359348f, 0.02909174f, 0.00946506f, 0.00019625f, 0.08292102f, 
    0.22554263f, 0.20728756f, -0.07238904f, 0.13926624f, 0.05368129f, 0.05345202f, 0.02907178f, 0.02200231f, 
    -0.03526070f, 0.23306422f, 0.00845026f, 0.03474909f, -0.16246232f, -0.02645496f, 0.03423724f, 0.06312155f, 
    0.05274770f, -0.00812851f, 0.19259274f, 0.06357683f, 0.00869268f, 0.09047888f, -0.07857101f, 0.07129110f, 
    0.05118120f, 0.04003347f, -0.00417026f, 0.13608135f, -0.10425719f, -0.03064587f, 0.08045947f, 0.00132052f, 
    0.06960987f, 0.03888576f, -0.03908002f, -0.13384619f, -0.07062013f, -0.03347568f, -0.01332101f, 0.08714286f, 
    -0.07721072f, 0.03279888f, -0.14005372f, -0.08583573f, -0.05451999f, -0.05371258f, -0.08588222f, -0.04851798f, 
    -0.06269942f, -0.07027936f, 0.00888207f, -0.13559921f, 0.16055019f, 0.15544067f, 0.00122675f, 0.02526375f, 
    -0.06614401f, -0.02102257f, -0.10036137f, -0.09070233f, 0.35140648f, 0.08438294f, 0.01096243f, -0.13808438f, 
    -0.00128545f, 0.04924475f, 0.08245400f, -0.06744246f, -0.07919840f, -0.06221038f, -0.07564427f, 0.07335587f, 
    -0.24818850f, 0.23248561f, 0.04591480f, -0.25786504f, 0.08280330f, -0.01375658f, 0.00841734f, 0.02202032f, 
    -0.05070682f, -0.09595914f, 0.03564983f, 0.06554741f, -0.10757280f, 0.04089177f, 0.20006281f, -0.01525849f, 
    0.07417630f, 0.02046700f, 0.03082105f, -0.18218429f, 0.07066443f, -0.00696083f, -0.10753277f, -0.00498388f, 
    0.08468311f, 0.05420583f, 0.16117607f, -0.07816325f, 0.11652538f, 0.17169635f, -0.01827547f, 0.08512237f, 
    -0.05611396f, 0.05945218f, 0.05040282f, -0.05817593f, 0.15853910f, -0.01932301f, -0.19745094f, 0.01724966f, 
    0.05929906f, 0.07445995f, 0.05671113f, 0.13463107f, 0.04034117f, -0.12831965f, -0.14350927f, -0.06743556f, 
    -0.10437380f, -0.20195936f, -0.00920031f, 0.15421818f, -0.05272214f, 0.08336991f, -0.05177284f, -0.14170079f, 
    -0.02217087f, -0.15233682f, -0.05096831f, -0.02061541f, -0.23901761f, -0.02980582f, 0.03930245f, -0.10953020f, 
    0.02788819f, -0.01708477f, 0.05429434f, -0.19770461f, 0.09569342f, -0.09240509f, -0.00696751f, -0.03359583f, 
    0.05492476f, -0.12151039f, 0.17165646f, 0.02577827f, 0.12741646f, -0.07507493f, -0.03775824f, -0.02062851f, 
    0.05064481f, 0.08208063f, 0.05078377f, -0.03037985f, 0.10738511f, 0.28812200f, 0.24699980f, 0.16338736f, 
    -0.01671549f, -0.09090568f, -0.02677029f, -0.03546639f, 0.01024832f, 0.06255817f, 0.01701443f, 0.00671198f, 
    -0.06306110f, -0.00367991f, -0.05920366f, 0.04557559f, -0.02214137f, 0.04726646f, -0.05354054f, -0.00469014f, 
    0.02700276f, -0.00948842f, -0.00372564f, -0.05533219f, -0.04619471f, 0.05723675f, -0.01274395f, -0.06455438f, 
    0.00519799f, -0.04678793f, 0.00975085f, 0.04193576f, -0.02649381f, -0.00167984f, 0.01013597f, -0.01069547f, 
    -0.01546924f, 0.00170544f, 0.04796156f, -0.05985049f, -0.03821909f, -0.04875127f, -0.04587664f, -0.03685575f, 
    0.05957151f, 0.03166686f, 0.00273369f, 0.00430038f, -0.04980398f, -0.03980388f, -0.06366349f, -0.01458848f, 
    -0.00168350f, 0.05372742f, 0.05684910f, -0.04392859f, 0.00836624f, -0.06031097f, -0.02904888f, 0.00910928f, 
    -0.06887295f, -0.03733214f, -0.07319827f, 0.04132214f, -0.04615375f, -0.05455720f, 0.03567062f, -0.03129593f, 
    -0.05790599f, -0.04075559f, -0.07979443f, 0.04252033f, 0.04345785f, 0.06194980f, 0.00386411f, 0.01140079f, 
    0.03396649f, 0.05147943f, -0.06653515f, 0.00161287f, -0.00158464f, 0.02731367f, 0.03256137f, -0.02527007f, 
    0.04699471f, -0.02399289f, 0.03331306f, 0.01266093f, -0.02762658f, -0.03180296f, 0.05102341f, 0.01524284f, 
    0.01619107f, -0.02122134f, -0.06951503f, 0.02029663f, -0.02012438f, -0.01088453f, 0.02237717f, -0.04436481f, 
    0.03517378f, -0.07456100f, 0.01145390f, 0.02892707f, 0.03560327f, -0.04570650f, -0.00781734f, 0.02731607f, 
    0.04430844f, -0.01391622f, 0.05396103f, -0.07520035f, 0.01571900f, 0.00729107f, -0.02802915f, -0.00598836f, 
    -0.06821769f, -0.00776083f, -0.07391010f, -0.04535886f, 0.02912154f, -0.00128202f, -0.00017852f, 0.05154621f, 
    -0.03808898f, -0.04675534f, 0.02363396f, -0.05592457f, -0.04822505f, -0.05982799f, 0.05703553f, 0.00295709f, 
    -0.00252799f, -0.00795151f, 0.03762951f, -0.03251007f, -0.03212845f, -0.00188129f, -0.06843570f, 0.04400173f, 
    0.00974088f, -0.07970107f, -0.00765457f, -0.06967559f, 0.04264767f, -0.04578969f, 0.02425961f, 0.01736343f, 
    -0.03786131f, -0.04740073f, 0.04443112f, -0.04467624f, -0.06155343f, -0.05672773f, -0.05054241f, 0.03701853f, 
    -0.02756081f, 0.02247290f, 0.03943950f, -0.05755565f, -0.06887148f, 0.01696659f, -0.06527779f, 0.02537757f, 
    0.05447559f, -0.00714582f, 0.04736000f, -0.02102766f, -0.08052587f, -0.03129847f, -0.04131357f, -0.03266736f, 
    -0.04242466f, -0.07368877f, -0.02436119f, 0.01730845f, -0.03036547f, -0.07343633f, 0.04160957f, -0.03014247f, 
    -0.03060621f, -0.04682556f, 0.03843680f, 0.06279717f, 0.05640988f, 0.00728118f, 0.03940203f, -0.05290884f, 
    -0.02840140f, 0.05433479f, -0.05223651f, -0.03751861f, 0.01965517f, -0.01428581f, 0.01507551f, -0.01527764f, 
    0.03527742f, 0.05606612f, 0.03555364f, 0.02155169f, -0.05509180f, 0.05445823f, 0.06232159f, -0.00924927f, 
    0.09420588f, -0.06375737f, 0.09626422f, 0.10323470f, 0.05505591f, 0.02034190f, 0.07975280f, -0.03756130f, 
    -0.09053084f, 0.06912778f, -0.01589088f, 0.02608314f, 0.12145589f, 0.07265414f, -0.05322140f, -0.17888331f, 
    -0.04666544f, 0.02513586f, 0.11291027f, -0.07115523f, 0.03942371f, -0.02119596f, 0.02342864f, -0.01682771f, 
    -0.09531303f, 0.10527284f, 0.07350600f, -0.15596825f, -0.00710415f, -0.02066411f, 0.07098039f, 0.01319197f, 
    0.05044432f, 0.06385536f, 0.01458314f, 0.03516939f, 0.40413636f, 0.06170001f, -0.19999275f, -0.05730535f, 
    0.02926881f, 0.03272675f, 0.10593190f, 0.00538169f, -0.00401904f, -0.03413031f, 0.05309528f, 0.02753338f, 
    -0.11404164f, -0.20161702f, -0.04975620f, 0.06999975f, -0.05176952f, 0.04359197f, 0.00403387f, -0.02480682f, 
    0.04190110f, -0.00180993f, -0.02530906f, 0.07418022f, 0.21158591f, 0.03557722f, -0.14022057f, 0.04166829f, 
    0.14914459f, 0.11058486f, 0.09062288f, 0.13477752f, 0.04261991f, 0.08965358f, 0.03522941f, 0.10911450f, 
    0.27915344f, -0.28109127f, -0.17388569f, -0.07460294f, 0.15587299f, -0.02585913f, -0.05503281f, 0.10338135f, 
    -0.05076433f, 0.00750126f, 0.10580534f, 0.02629677f, -0.41121313f, -0.13328154f, 0.00837538f, -0.22676255f, 
    -0.00625538f, -0.06576734f, 0.03319789f, 0.03951103f, 0.07132217f, 0.01168751f, -0.00811279f, 0.02786916f, 
    0.50525171f, -0.05328640f, -0.16466045f, 0.13599658f, 0.05019800f, -0.03492406f, 0.04891120f, 0.05306099f, 
    0.06801698f, 0.08804031f, 0.00533984f, 0.09280916f, 0.01316813f, 0.13659708f, -0.12305667f, 0.00601360f, 
    -0.09628839f, -0.05369829f, -0.00522774f, -0.00980772f, 0.01932568f, -0.02037823f, 0.01788096f, 0.09553173f, 
    0.04214865f, 0.06319804f, 0.02586302f, 0.01652015f, -0.02588629f, -0.02198146f, 0.11386600f, 0.09655927f, 
    0.04031754f, 0.03491572f, 0.06964150f, -0.09813219f, -0.02269722f, -0.00015503f, -0.15312800f, 0.09990484f, 
    -0.10078266f, -0.03780725f, -0.07175548f, 0.04964326f, -0.08420020f, 0.04612461f, 0.08261992f, 0.05550374f, 
    -0.20753615f, 0.14007199f, -0.05767423f, -0.20207904f, 0.08258950f, -0.11311880f, -0.11741804f, -0.06997045f, 
    0.00917354f, -0.01440792f, 0.09037215f, 0.03428015f, 0.05629908f, -0.10592958f, -0.10838932f, -0.08181424f, 
    0.03755302f, -0.13971058f, -0.02519070f, 0.06268191f, 0.10792622f, 0.02758871f, -0.03395320f, 0.07163719f, 
    0.05439571f, 0.18367130f, 0.05473652f, 0.04153113f, 0.01872225f, 0.15989214f, -0.03788313f, -0.01551233f, 
    0.06708045f, -0.04518657f, 0.07824378f, 0.05937045f, 0.17224397f, -0.02274069f, -0.05554869f, -0.09033439f, 
    0.17750843f, 0.09054304f, 0.14705969f, 0.04747053f, 0.10780255f, -0.04903206f, -0.02799535f, -0.13144167f, 
    -0.03006279f, 0.08592431f, -0.09313352f, -0.03035899f, -0.00829081f, 0.07984714f, 0.03748646f, 0.03791756f, 
    0.12000434f, -0.09925686f, -0.03535828f, 0.08468351f, 0.10821628f, 0.13340825f, 0.08407264f, -0.14439240f, 
    0.04611109f, -0.02858346f, -0.01997699f, 0.05726051f, 0.02896223f, 0.11588763f, -0.03952044f, 0.04670415f, 
    -0.12642467f, -0.35504311f, 0.21892692f, 0.01316615f, 0.05721542f, -0.02725252f, 0.16725956f, 0.05896198f, 
    0.02771381f, -0.10551424f, 0.06339020f, 0.01664455f, 0.31937915f, -0.03366915f, 0.03907902f, -0.17033961f, 
    -0.11679951f, -0.05259869f, -0.06335971f, 0.03614661f, 0.05771057f, -0.13777640f, 0.10326482f, -0.04955946f, 
    0.03582815f, -0.04882135f, 0.06869214f, -0.37827110f, -0.07578759f, 0.06833110f, 0.08071446f, 0.07201488f, 
    -0.04002054f, 0.01627671f, -0.10023306f, -0.02227784f, -0.00869480f, 0.19864875f, 0.10444992f, -0.27905557f, 
    0.03275744f, 0.03327326f, -0.01662822f, 0.00470116f, 0.12536202f, 0.16224651f, 0.04995132f, 0.01911268f, 
    0.05724681f, 0.08783343f, 0.06261303f, -0.12326458f, -0.08240870f, 0.04006912f, -0.07889729f, 0.04838267f, 
    -0.02150874f, -0.04584368f, -0.05804675f, 0.05091283f, 0.34240732f, -0.16424423f, 0.11203393f, 0.17352973f, 
    0.00613447f, 0.03974130f, -0.12117621f, 0.03792404f, -0.01004973f, 0.07922235f, 0.04670448f, 0.05860636f, 
    0.04267300f, -0.06295495f, -0.08453885f, 0.04846357f, 0.06936943f, 0.07652615f, -0.05797867f, -0.01409856f, 
    0.04304888f, 0.11133333f, -0.01410394f, 0.01539945f, 0.28288785f, -0.03909573f, -0.04923961f, -0.03706169f, 
    0.07869095f, 0.08493897f, -0.13568383f, 0.01781101f, -0.09780202f, 0.11582976f, -0.04854608f, 0.01826536f, 
    -0.14214610f, 0.11924373f, -0.06695253f, 0.11221524f, 0.08494496f, -0.02881683f, -0.10041476f, 0.02357207f, 
    -0.03210498f, -0.13577266f, -0.08462921f, -0.08430813f, -0.03094692f, 0.12112979f, 0.02713410f, -0.17728668f, 
    -0.02620809f, 0.02844743f, 0.02258399f, -0.05426269f, 0.00495846f, -0.03592577f, -0.09393592f, -0.07785829f, 
    0.02808153f, -0.08066715f, 0.21193774f, 0.19878092f, 0.03237781f, -0.02314896f, 0.10828787f, -0.08549114f, 
    0.06584593f, 0.02843117f, 0.05691847f, 0.03142263f, 0.17919648f, 0.25284943f, 0.04116009f, 0.16533838f, 
    -0.01048241f, 0.13086487f, -0.02041090f, -0.08985360f, 0.03573900f, 0.06651534f, -0.01699062f, -0.14227155f, 
    0.01855519f, -0.03287143f, -0.07166062f, 0.05410508f, 0.00319637f, 0.02094598f, 0.03329082f, 0.04528116f, 
    -0.05667420f, -0.00544130f, 0.00589743f, 0.12217502f, -0.07634286f, 0.00445984f, -0.04148242f, -0.05101921f, 
    0.02469436f, 0.04206303f, 0.09756997f, 0.11391728f, -0.03664928f, 0.01675544f, 0.07620967f, 0.11136743f, 
    -0.05030829f, -0.01635022f, -0.02296147f, -0.02447299f, -0.07008173f, -0.05217967f, 0.01434734f, 0.01325654f, 
    0.01736134f, -0.07639445f, 0.05803512f, -0.05916108f, -0.03258035f, 0.01466907f, -0.02779098f, -0.03702106f, 
    0.01529876f, -0.07191493f, 0.03586161f, -0.01332975f, -0.00883908f, -0.06976903f, -0.00689940f, -0.02880408f, 
    -0.01720725f, 0.00383763f, 0.06578121f, 0.02791977f, 0.00398740f, -0.03899894f, 0.01151427f, 0.04041107f, 
    -0.02920362f, -0.05717982f, -0.06523590f, -0.06237560f, 0.04824660f, -0.05272958f, -0.01735357f, 0.02850749f, 
    0.04632377f, 0.04253201f, -0.05767025f, -0.02658489f, -0.03606681f, -0.04547171f, 0.05773291f, -0.05319947f, 
    -0.00294336f, -0.05894364f, -0.01399790f, 0.05955810f, 0.03692154f, 0.04646634f, 0.06561255f, 0.02552156f, 
    0.03669965f, -0.05055894f, -0.02281885f, -0.05448858f, -0.01799642f, 0.06084378f, 0.04434630f, -0.01316432f, 
    0.00829914f, -0.03467219f, 0.01102869f, 0.01508203f, -0.01271112f, -0.01287173f, 0.01692663f, -0.05768981f, 
    -0.06800465f, 0.05745406f, -0.03758406f, -0.05325327f, -0.06013404f, 0.02977159f, -0.04822571f, 0.04877535f, 
    0.05870713f, -0.00730823f, 0.00560478f, -0.01821153f, 0.05034378f, 0.04144828f, -0.00573588f, -0.07357857f, 
    -0.07046631f, 0.03137983f, -0.01372117f, -0.02475320f, -0.02409001f, -0.04626116f, -0.06487450f, -0.03015610f, 
    0.01315927f, 0.00737284f, 0.00428769f, -0.04515259f, -0.00015963f, 0.00790370f, 0.06282040f, 0.01343780f, 
    -0.03104716f, 0.01208827f, 0.04880600f, -0.01176309f, -0.06469167f, 0.03749794f, -0.06341839f, 0.04379943f, 
    -0.01107806f, -0.05250344f, 0.03112422f, 0.05842187f, 0.02152812f, -0.06980615f, -0.01344365f, -0.02418798f, 
    0.03956125f, -0.06803372f, 0.04750778f, -0.01919451f, -0.05432674f, -0.02829735f, 0.03096520f, -0.03375814f, 
    -0.02219326f, -0.01336922f, -0.07217968f, 0.04764157f, 0.00944661f, -0.03191749f, -0.03401441f, 0.05733599f, 
    -0.07079478f, -0.00033128f, -0.01866141f, 0.01577516f, -0.05622056f, 0.03283705f, -0.05575383f, -0.05297836f, 
    0.00977874f, 0.05253889f, -0.00866185f, -0.02339909f, 0.00465421f, 0.03473493f, -0.00446733f, -0.03240610f, 
    0.00830582f, -0.02092447f, 0.00616426f, 0.03439263f, 0.01184210f, -0.06402978f, -0.05674775f, 0.03700128f, 
    -0.04951449f, 0.02713003f, 0.01709924f, 0.01658241f, -0.07134624f, 0.05759672f, -0.02902816f, 0.05883126f, 
    0.04295156f, 0.00313954f, 0.01014570f, -0.05494632f, 0.01686691f, -0.03000524f, 0.03087537f, 0.01065128f, 
    -0.04781599f, -0.05144484f, -0.04593438f, 0.00418654f, -0.01117822f, 0.00139509f, -0.02610275f, -0.04890983f, 
    0.04600441f, 0.02599356f, 0.04813018f, -0.07086810f, -0.03292615f, -0.01520640f, -0.02478112f, -0.06035159f, 
    0.03940560f, -0.03995631f, 0.00672917f, -0.06029964f, -0.03312376f, 0.00029346f, 0.06049436f, -0.00016590f, 
    -0.03183400f, 0.05123679f, 0.03698751f, -0.04549563f, 0.00229030f, 0.00272623f, 0.01849334f, 0.00474030f, 
    0.03361735f, -0.03989388f, -0.06962004f, 0.02341795f, -0.03763590f, -0.04938589f, -0.06505439f, -0.05016507f, 
    -0.08022185f, -0.07594682f, -0.05868061f, -0.00813731f, -0.06983299f, 0.00467259f, -0.06411616f, 0.05199330f, 
    -0.02970170f, 0.03294231f, 0.05378137f, 0.04176804f, -0.04105975f, 0.04334933f, 0.02655333f, -0.06055334f, 
    -0.06309463f, -0.01562254f, -0.07113439f, -0.04065970f, -0.03637364f, 0.01669423f, -0.04527491f, -0.06929997f, 
    0.03841196f, 0.04174393f, -0.01506319f, 0.02327638f, -0.04770775f, 0.02149027f, 0.00925379f, -0.04184698f, 
    -0.02304497f, -0.03928367f, 0.05791476f, -0.07554542f, -0.07247894f, 0.04759052f, -0.05816191f, -0.02166558f, 
    0.04178933f, 0.05636013f, 0.03858625f, -0.06455363f, 0.06095874f, 0.01518630f, 0.02867769f, -0.01120268f, 
    -0.01181368f, -0.00191051f, 0.04609356f, -0.02245833f, -0.07006595f, 0.04086616f, -0.06020006f, -0.04709113f, 
    -0.01204724f, -0.06405041f, -0.01402245f, 0.00131784f, -0.01142267f, 0.05593612f, -0.01229930f, 0.01894244f, 
    -0.06528808f, 0.00518138f, -0.00861990f, -0.06247867f, -0.04357250f, -0.06153465f, -0.03281004f, -0.05012803f, 
    -0.01286584f, 0.05663085f, 0.03598986f, 0.04852527f, 0.00409091f, 0.00075865f, 0.02092610f, -0.07710381f, 
    0.02255924f, -0.04215001f, 0.02410238f, -0.03417218f, 0.04349181f, 0.04914540f, 0.01055486f, 0.00914331f, 
    0.02404525f, 0.00110046f, 0.00162951f, -0.02313077f, 0.01150461f, 0.02178765f, -0.07722984f, -0.07787637f, 
    -0.02671538f, -0.07631481f, -0.00107596f, 0.05197653f, -0.00717272f, -0.05685079f, -0.01959600f, 0.03081952f, 
    -0.06476150f, -0.06960870f, -0.06047316f, -0.05593565f, -0.06080884f, 0.04641142f, 0.05225854f, -0.04547876f, 
    0.00822640f, -0.05861806f, 0.00354527f, -0.00897006f, -0.01775633f, -0.03064520f, 0.01473435f, -0.08043551f, 
    0.00196133f, -0.02331319f, -0.05807844f, 0.06482398f, -0.03844059f, 0.06058188f, -0.05728232f, 0.00366349f, 
    -0.03573809f, 0.06894892f, -0.03751031f, 0.04300815f, 0.00577205f, -0.05471735f, -0.06622697f, 0.01067873f, 
    -0.01755090f, -0.00338274f, -0.01810692f, 0.06160457f, 0.01373074f, -0.02867311f, -0.05996791f, -0.02548949f, 
    -0.03391597f, 0.01213827f, -0.01195078f, 0.00499051f, 0.06131160f, -0.04236702f, 0.05303942f, 0.04844802f, 
    -0.03501486f, 0.05797177f, -0.01579607f, 0.05324292f, -0.00312155f, 0.00877489f, 0.02582747f, 0.00010869f, 
    0.04618172f, 0.06368485f, 0.01009783f, 0.04027765f, -0.00254627f, -0.06389762f, 0.02020230f, -0.03387428f, 
    0.08567502f, 0.06404117f, 0.04286250f, 0.03556657f, 0.10036193f, -0.06783724f, 0.01590167f, -0.18330550f, 
    -0.07276471f, -0.11274382f, -0.08603593f, -0.18308650f, -0.09727360f, -0.24953356f, 0.02424295f, -0.02545317f, 
    -0.03656591f, 0.14563100f, 0.18976362f, 0.06453012f, -0.03352934f, -0.11487806f, 0.09669878f, -0.10818215f, 
    0.15527198f, -0.01171123f, -0.07215704f, 0.06376855f, 0.02432525f, -0.02534172f, -0.10874490f, 0.01170247f, 
    -0.19289781f, 0.11241282f, -0.15401895f, -0.04391253f, -0.25589675f, -0.21611877f, 0.13991211f, 0.13143699f, 
    -0.00013066f, -0.05057216f, 0.11630815f, 0.02094493f, -0.05628205f, 0.10888173f, -0.02515087f, 0.20571412f, 
    0.15301134f, -0.07313421f, 0.16437615f, 0.02509660f, -0.05172541f, 0.04251862f, 0.03514330f, 0.06524727f, 
    -0.07721838f, 0.10687372f, 0.17259663f, 0.08889220f, 0.21812993f, -0.03596402f, -0.04965610f, 0.00410304f, 
    0.00280629f, 0.05838490f, -0.09819961f, -0.03914766f, -0.01781507f, -0.06747171f, -0.08669519f, 0.03154623f, 
    0.07598481f, -0.01251763f, -0.12520872f, 0.22352189f, -0.12382214f, -0.05755144f, 0.15320408f, 0.05237141f, 
    -0.06231590f, -0.05146838f, 0.01900706f, 0.04770724f, -0.00572142f, 0.16959578f, -0.12290221f, -0.00475868f, 
    0.10352962f, 0.07394909f, -0.02174675f, 0.03036419f, -0.06244306f, -0.03338243f, 0.04731824f, 0.15203008f, 
    0.16344155f, 0.08967995f, -0.04511143f, 0.08869846f, 0.06058254f, -0.12340511f, -0.09849986f, 0.04681221f, 
    0.04366008f, -0.06819042f, 0.14601544f, -0.00428197f, 0.01087054f, 0.01095363f, 0.07494046f, 0.25773665f, 
    -0.03791023f, 0.11439893f, 0.15495174f, -0.02913219f, 0.16065110f, -0.13773088f, -0.03914699f, -0.17568927f, 
    0.17921245f, -0.08569343f, 0.04211656f, -0.14110897f, -0.07106853f, -0.00355797f, 0.15622903f, 0.08211949f, 
    0.10279274f, 0.27141869f, 0.07826476f, 0.08411762f, 0.56979418f, 0.15869696f, -0.10664742f, -0.22755836f, 
    0.07021782f, -0.00879143f, -0.06681988f, 0.11538424f, 0.03271904f, -0.08938711f, 0.01803003f, 0.10578164f, 
    0.03020954f, 0.21125355f, -0.01686668f, -0.08651306f, 0.02660492f, -0.09802688f, -0.23765770f, -0.06574384f, 
    -0.01118078f, -0.16000803f, -0.02901165f, -0.11594037f, 0.03444885f, -0.14847128f, -0.17630251f, -0.03106215f, 
    0.10661792f, 0.09987503f, 0.09292908f, 0.00908687f, -0.08162495f, 0.11712875f, 0.05701949f, 0.07116935f, 
    0.05347567f, 0.10505032f, 0.03958939f, 0.08872365f, -0.02884720f, -0.02143290f, -0.20768599f, -0.06196287f, 
    -0.09677858f, 0.02174051f, -0.05393322f, -0.02416129f, -0.11206608f, 0.06269298f, 0.00398196f, -0.00479075f, 
    -0.01986899f, 0.04817392f, -0.03329706f, -0.00171301f, -0.02825187f, 0.01737943f, 0.05973757f, -0.14694947f, 
    -0.16576150f, 0.02702842f, -0.09906213f, -0.00455661f, 0.13382712f, 0.11193932f, 0.06914153f, -0.01139611f, 
    -0.02035093f, 0.01007753f, -0.09313969f, 0.12443777f, 0.04607151f, 0.00333380f, 0.16912447f, -0.11955460f, 
    0.09969657f, -0.08775373f, 0.05022522f, 0.09303214f, -0.04048744f, 0.09461498f, 0.00752405f, 0.13197668f, 
    0.01742754f, -0.08174434f, 0.12037802f, -0.03666065f, -0.00388902f, 0.07332398f, 0.18271708f, 0.05265132f, 
    -0.03639929f, -0.01411515f, -0.04290120f, -0.00388151f, 0.25205344f, 0.03906451f, -0.10305004f, 0.11011799f, 
    0.03885440f, -0.01118107f, 0.08496375f, 0.08016063f, 0.09033805f, -0.06615124f, -0.01114839f, -0.19803095f, 
    -0.04654367f, -0.19689570f, 0.15197320f, -0.14546511f, -0.15896271f, -0.06798059f, -0.06996016f, 0.02950740f, 
    -0.05661255f, 0.13034697f, 0.00865987f, -0.07181195f, 0.19773702f, -0.04385565f, 0.06797604f, -0.04201784f, 
    -0.03752785f, 0.11887114f, 0.06737874f, -0.02964275f, 0.07765006f, 0.02056531f, -0.04518729f, 0.15278074f, 
    0.05939458f, 0.14312762f, -0.11285006f, -0.02456359f, 0.06770556f, 0.11114705f, -0.05944471f, 0.20465760f, 
    -0.06439634f, -0.03029486f, 0.00720255f, -0.02073064f, 0.21330908f, 0.00704300f, 0.05499934f, 0.18667594f, 
    -0.05952778f, -0.04437976f, 0.05201315f, 0.09843950f, 0.14505816f, 0.09261514f, -0.03304088f, 0.11861292f, 
    -0.04146117f, 0.20035119f, -0.36675775f, 0.04660539f, 0.17944001f, 0.18763962f, 0.00197005f, 0.03705298f, 
    -0.12547709f, -0.01372442f, -0.04058897f, -0.10784689f, -0.03409809f, -0.12906151f, -0.13526016f, -0.07060620f, 
    0.02575700f, 0.06760780f, -0.14536190f, 0.03221707f, -0.02972178f, 0.03387719f, 0.03973474f, 0.13637602f, 
    -0.01572878f, 0.10694596f, -0.06338584f, 0.05329589f, 0.09075758f, -0.03727837f, 0.00362955f, -0.09135934f, 
    -0.06142436f, -0.02441952f, -0.02863124f, 0.02007006f, -0.48260304f, -0.05704245f, 0.04653727f, 0.01068944f, 
    0.03760644f, -0.08514155f, 0.08722312f, -0.11610188f, 0.02092903f, -0.00367830f, -0.07884900f, 0.00789005f, 
    0.17137372f, 0.04200362f, 0.27703118f, -0.02617233f, -0.26689368f, -0.12509233f, -0.02770329f, 0.03778753f, 
    0.09670749f, 0.10397350f, 0.02487470f, 0.03015969f, -0.01224986f, 0.14576378f, -0.08222704f, 0.09717249f, 
    -0.05565958f, 0.20059216f, 0.05653790f, 0.07910458f, -0.07962904f, 0.07292610f, 0.01611023f, -0.12924446f, 
    -0.03384281f, -0.08863337f, 0.00151055f, 0.13386284f, -0.05921746f, -0.11231574f, -0.02644945f, 0.01011275f, 
    -0.03299381f, -0.10619352f, -0.11384855f, 0.00460077f, 0.08423668f, 0.19638784f, 0.01970323f, 0.03124000f, 
    -0.00243982f, 0.14104058f, 0.05923467f, 0.20972338f, 0.00207445f, -0.14534566f, 0.06842992f, -0.04045848f, 
    -0.08781792f, 0.03967174f, -0.01835821f, 0.15177199f, 0.02598384f, -0.00271652f, -0.00831229f, 0.01783906f, 
    0.05190271f, -0.03953332f, -0.13683952f, -0.16258101f, 0.00440538f, 0.04960782f, -0.19275248f, 0.01166986f, 
    0.17299378f, 0.02297719f, 0.04908672f, 0.04150409f, -0.05506262f, -0.00220863f, 0.01742654f, 0.04949440f, 
    -0.07298063f, -0.12776989f, -0.08914161f, -0.17171615f, -0.03914432f, 0.02825412f, 0.04063872f, 0.12228256f, 
    0.01527866f, -0.17557985f, 0.00937115f, 0.11319747f, -0.03178774f, -0.12412578f, 0.01734938f, -0.05751961f, 
    0.11982688f, 0.09914412f, -0.14185131f, 0.02727965f, 0.14704476f, 0.07292812f, -0.00574645f, 0.00896618f, 
    0.10541914f, 0.04870078f, -0.09169228f, 0.05562811f, 0.11365321f, -0.02786351f, 0.00620862f, -0.01334586f, 
    -0.07186098f, -0.04616016f, 0.05120571f, 0.04762591f, -0.22716220f, -0.12063571f, 0.13550808f, -0.03044673f, 
    -0.01263186f, -0.09989551f, 0.07431381f, -0.01049459f, 0.00024067f, -0.07138729f, -0.00927910f, 0.08476593f, 
    0.12147389f, 0.00961224f, -0.03729896f, -0.08807021f, 0.06957482f, 0.13393620f, 0.03910228f, -0.04791619f, 
    0.06342085f, -0.02652394f, 0.10374158f, 0.00025707f, -0.09182560f, 0.21812110f, 0.11357194f, 0.03202390f, 
    0.01376221f, 0.10805826f, -0.02103798f, -0.06889693f, -0.05043395f, 0.01265077f, -0.07580779f, 0.04783538f, 
    0.02143531f, 0.02917691f, -0.08811437f, 0.02596194f, 0.03202004f, 0.12592724f, 0.10146019f, -0.07862329f, 
    0.03289649f, 0.05901798f, 0.03126324f, 0.02480004f, 0.21347086f, -0.03629902f, 0.10417197f, -0.16697592f, 
    -0.01632366f, -0.03823717f, 0.02333681f, 0.04698326f, -0.00768681f, 0.07392792f, 0.06639710f, 0.06689535f, 
    0.08197156f, 0.00592895f, -0.21011138f, 0.18165651f, 0.12453786f, -0.00923265f, 0.02894369f, 0.01711750f, 
    0.04096090f, -0.02739773f, 0.05241191f, 0.10497373f, -0.27392638f, -0.01370933f, 0.04401525f, -0.05542890f, 
    0.03316207f, 0.00728289f, -0.02475142f, -0.03443229f, -0.04803569f, 0.05363911f, -0.02483916f, 0.00233615f, 
    0.08569833f, 0.24691138f, 0.18360478f, 0.03409752f, -0.02750747f, 0.14919111f, 0.08196244f, 0.03264543f, 
    -0.03551666f, 0.09926000f, -0.06399862f, -0.00127716f, 0.05514217f, -0.02145949f, 0.21453093f, 0.10114659f, 
    -0.08598822f, 0.06334783f, -0.03721152f, -0.02903243f, 0.06524458f, 0.03233482f, 0.09464139f, -0.15026371f, 
    0.10178366f, -0.04780241f, -0.18030289f, -0.01557373f, 0.09987079f, -0.09083786f, 0.02208636f, 0.01357788f, 
    -0.04256799f, -0.03975317f, 0.00066991f, 0.02094195f, -0.01250408f, -0.12328022f, 0.02082052f, 0.09027971f, 
    0.15280995f, 0.08447420f, -0.04013149f, -0.02632104f, 0.08474885f, 0.01951631f, 0.03257341f, 0.11798381f, 
    -0.13022134f, -0.02450873f, 0.03772607f, -0.08269411f, -0.02952188f, -0.05375291f, -0.02992612f, 0.09524924f, 
    0.01216161f, 0.04778635f, -0.01012863f, 0.10584359f, 0.12683849f, 0.05148061f, 0.02774760f, -0.00194828f, 
    -0.00717661f, 0.01947891f, 0.06783042f, -0.02777275f, 0.06688062f, -0.05594370f, 0.00512932f, 0.07274533f, 
    0.09143678f, 0.12634039f, -0.05065638f, 0.10117569f, 0.07690346f, 0.07793842f, 0.10190026f, -0.12133122f, 
    0.05947086f, 0.13445404f, 0.05114147f, -0.00252324f, 0.28585032f, 0.04703683f, -0.16732988f, 0.05315163f, 
    -0.20466508f, -0.00027989f, 0.02676020f, 0.10582235f, -0.02912357f, -0.02197832f, 0.08719084f, 0.00746578f, 
    -0.14217509f, 0.01245550f, 0.09749956f, 0.17633405f, -0.02969125f, 0.03498509f, -0.01063769f, 0.11801682f, 
    0.09504664f, -0.03227970f, -0.09441081f, -0.02240860f, 0.27174789f, 0.12401906f, -0.12695488f, 0.01842420f, 
    0.07787846f, 0.05693313f, -0.06847715f, -0.03126374f, 0.06682322f, 0.00623343f, 0.18519625f, 0.06310188f, 
    0.06583024f, -0.15203916f, 0.01818354f, -0.11267837f, -0.00854007f, -0.08651289f, 0.03372366f, 0.11032927f, 
    -0.04051144f, 0.00492156f, 0.01292041f, 0.11277502f, -0.20909078f, -0.28754434f, -0.01451875f, -0.16245626f, 
    -0.01819784f, 0.01754972f, 0.00529055f, -0.02874861f, 0.00260290f, -0.04215289f, 0.02554474f, 0.02656170f, 
    0.29595464f, 0.13740724f, -0.14449707f, -0.07749750f, -0.04281591f, -0.07556354f, 0.07090786f, -0.00180853f, 
    -0.01579694f, 0.03106497f, 0.03971168f, 0.02660236f, -0.15277319f, 0.28366736f, 0.03242561f, -0.01864182f, 
    0.01119768f, -0.03989380f, -0.05893924f, 0.00047649f, -0.00985516f, -0.08142982f, -0.06598473f, -0.03982903f, 
    0.07602306f, 0.00363978f, 0.06358746f, -0.11467879f, 0.04539359f, 0.00986593f, 0.02277226f, 0.06655400f, 
    0.13617867f, -0.03006508f, -0.07527006f, -0.02764779f, 0.27282619f, 0.03155803f, -0.08806588f, -0.05217252f, 
    -0.03386134f, -0.14234899f, 0.08061441f, 0.12678155f, -0.01089118f, 0.00663282f, 0.00063357f, 0.05255328f, 
    -0.64140326f, -0.23014565f, 0.01360250f, -0.15414965f, 0.08919247f, 0.08486318f, -0.12033889f, -0.03404908f, 
    -0.00195700f, -0.08891626f, 0.01083188f, 0.04212060f, 0.01231685f, -0.07966056f, -0.18247786f, -0.07350326f, 
    -0.02629681f, -0.09509473f, 0.00966192f, -0.07316327f, -0.00614815f, 0.01908999f, -0.02115608f, 0.03675593f, 
    0.05736726f, -0.12388646f, 0.07782752f, 0.00759844f, 0.01054849f, 0.06425580f, 0.03704406f, 0.01710250f, 
    0.03782778f, 0.14028232f, 0.09541826f, 0.12497284f, 0.24017805f, 0.24607892f, -0.07885896f, -0.02485458f, 
    0.04877957f, 0.06058452f, 0.11105677f, 0.14313693f, 0.03219345f, 0.16420524f, -0.00186820f, 0.11026967f, 
    -0.08898748f, 0.04481354f, -0.17735928f, -0.03217501f, 0.07757401f, -0.02160231f, 0.08412732f, 0.04955617f, 
    0.25158378f, 0.05929362f, 0.03803480f, 0.06370138f, 0.20036797f, 0.10060561f, 0.07171018f, 0.08277363f, 
    0.09215230f, -0.01067947f, -0.00881748f, -0.03760185f, -0.07477352f, 0.13980018f, -0.09856097f, 0.05649629f, 
    0.03900219f, -0.04764356f, 0.18957046f, 0.26896504f, 0.16318206f, 0.12622361f, 0.01273191f, 0.00857202f, 
    0.03209418f, -0.07998347f, 0.04869824f, -0.06844024f, 0.17625120f, 0.20002764f, -0.06291607f, -0.08995926f, 
    -0.12317549f, 0.09201264f, 0.07450515f, 0.08470847f, -0.00027291f, -0.02458301f, -0.04652943f, -0.09966954f, 
    -0.03563582f, 0.31565896f, 0.21969454f, -0.29356414f, 0.09199732f, -0.10171073f, 0.10619771f, 0.05579513f, 
    -0.03204395f, -0.05036513f, 0.05590662f, -0.06955411f, 0.03137679f, 0.07202213f, 0.19690534f, 0.00706001f, 
    0.04102046f, -0.15086822f, -0.03121986f, -0.03485304f, -0.02584642f, -0.02202211f, 0.06662131f, 0.01499235f, 
    0.13549751f, 0.15925464f, 0.08346150f, -0.22854263f, 0.03832410f, 0.17086960f, -0.10140900f, 0.13750347f, 
    -0.02527839f, 0.05537355f, -0.03063713f, -0.02694788f, 0.25060391f, -0.13529472f, -0.05561106f, 0.02862476f, 
    0.01692428f, -0.08688412f, -0.09231024f, -0.21065311f, 0.00153284f, 0.03866057f, 0.01345466f, -0.13742346f, 
    -0.33187750f, 0.21602747f, 0.15730645f, -0.06650736f, 0.08353029f, 0.01599278f, -0.01485193f, 0.00134223f, 
    -0.03907638f, 0.06147572f, -0.04167975f, 0.05206821f, 0.08532905f, -0.05640285f, -0.03491086f, -0.06188532f, 
    0.09532913f, 0.02535701f, -0.05262710f, 0.09827244f, -0.01864790f, 0.00703696f, 0.09190042f, 0.11127527f, 
    -0.01577068f, 0.06743643f, 0.11471861f, 0.13068408f, 0.06377117f, 0.07934304f, -0.09558956f, 0.14690295f, 
    0.03915602f, -0.07727215f, -0.10719653f, 0.01229735f, 0.07898135f, 0.12698312f, 0.09398158f, -0.07777835f, 
    0.10112128f, 0.04984987f, 0.17999381f, -0.01002416f, 0.03905312f, -0.01962522f, -0.05294925f, -0.02163437f, 
    -0.27076691f, -0.18664375f, 0.02759368f, 0.12129369f, -0.13626772f, -0.06636746f, 0.00499841f, -0.11604929f, 
    -0.15292570f, 0.12930007f, 0.04994709f, 0.09322021f, -0.10025031f, 0.20777383f, -0.13677669f, -0.14643270f, 
    0.04015069f, 0.08987064f, -0.02314267f, -0.10040485f, 0.00379120f, -0.07977409f, 0.01952956f, -0.04336289f, 
    0.20279716f, -0.05009866f, 0.04632862f, 0.16600834f, 0.01362012f, -0.08345124f, 0.06229921f, -0.01056628f, 
    0.03688249f, 0.08879871f, 0.08115311f, 0.06266732f, -0.03243355f, 0.06673998f, 0.17894277f, 0.17219631f, 
    0.02523907f, 0.05986955f, -0.03688766f, 0.07867624f, -0.07686026f, 0.02196827f, 0.03492735f, 0.08803372f, 
    0.12452184f, 0.00502633f, 0.05588911f, -0.08210852f, 0.08234911f, 0.03056761f, -0.01752583f, 0.07171731f, 
    -0.01749259f, -0.00949187f, 0.07544857f, -0.02331396f, -0.02218695f, -0.10084142f, 0.05954990f, 0.24279270f, 
    0.04481190f, 0.05406967f, 0.05481852f, -0.03978575f, 0.00519266f, 0.00849736f, -0.03530401f, 0.05371530f, 
    0.08044976f, 0.22165391f, -0.22161332f, 0.03102745f, 0.04886967f, -0.03684967f, -0.13159990f, -0.00831933f, 
    -0.05865688f, 0.16541715f, -0.11839858f, -0.03707170f, -0.30350929f, 0.11928175f, -0.02100316f, 0.22202091f, 
    0.01796241f, -0.02394142f, 0.04042874f, -0.01655334f, 0.02705190f, 0.06301501f, -0.11673339f, 0.02018006f, 
    -0.08797285f, -0.00168851f, 0.02583975f, 0.34387949f, 0.09721985f, -0.07157128f, -0.03052034f, 0.03598897f, 
    0.02539920f, 0.09172933f, 0.08071009f, 0.04288710f, 0.05131541f, -0.13590911f, -0.02499872f, 0.27725965f, 
    -0.02927207f, -0.09695399f, -0.10638822f, 0.02033969f, 0.00403023f, -0.07149176f, 0.00243227f, 0.00816399f, 
    0.15567358f, -0.17602819f, -0.00882383f, 0.04951195f, 0.05681580f, -0.00827499f, 0.03742697f, -0.04827528f, 
    -0.02017267f, 0.04073683f, 0.01905186f, -0.03701387f, -0.10827122f, 0.31441098f, 0.00210453f, -0.22537859f, 
    0.08718478f, -0.04073646f, 0.07204787f, -0.06526636f, 0.03334313f, -0.06823085f, 0.07719465f, 0.00749096f, 
    -0.16394432f, 0.11203571f, 0.06375926f, -0.03252057f, -0.01820186f, -0.11127717f, 0.04824733f, 0.01598374f, 
    -0.03087333f, -0.07968590f, 0.01681353f, -0.03271380f, -0.24977654f, -0.02171206f, 0.05320283f, -0.04985002f, 
    0.00941366f, -0.02352421f, 0.17979904f, -0.03309930f, 0.01319535f, -0.10775401f, 0.09462684f, -0.07124457f, 
    0.19010411f, -0.09303681f, 0.00368381f, -0.11287560f, 0.02842237f, 0.14216042f, 0.01709644f, 0.03814537f, 
    -0.09444072f, 0.08613296f, 0.10310463f, 0.02913951f, 0.00729200f, -0.11145639f, -0.07597038f, 0.18756761f, 
    0.10931811f, 0.03080617f, 0.01352520f, 0.01201021f, -0.01016309f, -0.02555449f, -0.01231853f, 0.07621126f, 
    -0.03962333f, 0.02405763f, -0.07227787f, 0.01549836f, 0.15894035f, 0.11442555f, -0.13074638f, -0.02395919f, 
    0.01591810f, -0.04728744f, 0.03475901f, 0.00321337f, -0.10370792f, -0.10538340f, 0.07006689f, -0.15466660f, 
    0.15788297f, -0.01247584f, 0.02942426f, 0.06269373f, 0.05304330f, -0.06150897f, 0.02125188f, 0.07435811f, 
    0.09023385f, -0.04961872f, 0.08501569f, 0.02035574f, 0.09964608f, -0.16575438f, 0.04068756f, 0.09500045f, 
    0.06207599f, -0.04956388f, 0.03784315f, -0.03468554f, 0.12645902f, 0.05015723f, 0.01694566f, 0.06458327f, 
    0.05614048f, 0.03386324f, -0.08932774f, -0.07124174f, 0.11291131f, 0.05250931f, 0.04459305f, -0.02067430f, 
    0.06433278f, 0.04486110f, -0.08135990f, -0.14926521f, -0.00840264f, 0.04640222f, -0.04484298f, 0.04182864f, 
    0.09980940f, -0.16341487f, 0.01407564f, 0.04181967f, 0.15012802f, 0.01443863f, 0.17670512f, 0.24947053f, 
    -0.08411088f, 0.03612037f, -0.00416055f, 0.13610575f, -0.02717391f, 0.00047036f, 0.11403336f, 0.02242259f, 
    -0.10855053f, -0.36188713f, 0.05535489f, 0.12222352f, -0.00714545f, 0.03411003f, 0.04179196f, 0.07351221f, 
    0.14840166f, -0.05221145f, -0.00248614f, 0.09489100f, -0.18957236f, -0.06372801f, 0.35893640f, 0.06301768f, 
    0.02077826f, -0.03081906f, 0.01314476f, 0.12928790f, 0.03341310f, -0.03054166f, 0.00162083f, -0.09849027f, 
    0.12135474f, -0.19389710f, 0.11159210f, -0.26699463f, 0.09567960f, -0.09597546f, 0.05348844f, -0.17082819f, 
    -0.10213423f, -0.09425565f, -0.02828505f, -0.16781913f, -0.15772890f, -0.10664986f, -0.00457181f, -0.15780264f, 
    -0.03375851f, -0.02912199f, 0.08788748f, -0.17917350f, 0.04912845f, -0.02100245f, 0.00388222f, -0.04031603f, 
    0.18576086f, 0.18040623f, -0.25511116f, 0.05477585f, -0.09246196f, 0.15279528f, -0.14958237f, 0.07226977f, 
    0.10539346f, -0.11186527f, 0.04097888f, 0.03565912f, 0.54764903f, -0.07066583f, -0.07247771f, 0.26783437f, 
    0.07436763f, 0.03690949f, 0.11423791f, 0.23424518f, -0.09652880f, 0.11570331f, -0.00168671f, -0.03342723f, 
    -0.14433552f, -0.07399988f, -0.00023396f, -0.12639889f, -0.03720363f, 0.09581628f, -0.15766709f, -0.03020824f, 
    -0.03916720f, -0.09649198f, -0.03339200f, -0.04761189f, 0.13842556f, -0.05723715f, -0.05601233f, 0.16573100f, 
    0.16471380f, 0.12340321f, -0.10884354f, -0.09084445f, -0.00385680f, 0.05272103f, -0.02659738f, 0.02626709f, 
    0.08753593f, 0.04014835f, -0.04174114f, 0.13213554f, 0.03666295f, -0.04258076f, 0.01723740f, -0.02541446f, 
    -0.01284002f, -0.00223819f, 0.01793347f, -0.03319768f, 0.09550353f, 0.12637164f, 0.07119904f, -0.12445514f, 
    -0.05511700f, -0.06523268f, -0.05826839f, 0.14132540f, 0.17562185f, -0.08907720f, -0.12415744f, 0.03014538f, 
    0.05530415f, 0.04110190f, 0.23977786f, 0.25109518f, -0.04129287f, 0.01932695f, 0.12727535f, 0.04011394f, 
    0.07032520f, 0.02559250f, 0.09790444f, 0.01424457f, 0.17606418f, 0.13270453f, 0.05326764f, 0.15275890f, 
    -0.00351945f, 0.15818562f, 0.10847658f, -0.01269762f, 0.00772578f, 0.03806287f, 0.04311760f, -0.00938317f, 
    -0.07789084f, 0.01121335f, -0.23214574f, 0.03173867f, -0.11169980f, 0.01964787f, 0.00720003f, -0.04240799f, 
    -0.04018318f, 0.03420509f, -0.02036417f, -0.01441629f, 0.07675219f, -0.13265602f, 0.05062962f, -0.07981604f, 
    -0.03541787f, 0.00235264f, -0.07442097f, 0.00395023f, 0.08500006f, -0.05588075f, -0.00360845f, 0.02506876f, 
    -0.07897374f, -0.04122885f, -0.05353236f, -0.02098949f, -0.05099357f, 0.03697045f, 0.00973353f, -0.03003377f, 
    0.04801116f, 0.00303138f, 0.06241862f, -0.05984839f, 0.02786382f, -0.06146919f, -0.04571713f, 0.04522257f, 
    -0.00090456f, 0.04745079f, -0.07688905f, -0.07827373f, -0.02823757f, 0.05708956f, 0.04687864f, -0.02948722f, 
    0.02247796f, 0.06076341f, 0.01702023f, -0.02979242f, 0.04242375f, -0.06913556f, -0.02994435f, -0.02411280f, 
    0.01962572f, -0.06326984f, -0.04420404f, -0.04533381f, 0.04763827f, 0.05521182f, -0.00361848f, 0.03163715f, 
    -0.04103574f, 0.02803631f, -0.05221208f, -0.05856853f, -0.06595725f, 0.02761401f, 0.03319354f, -0.06620143f, 
    -0.04098193f, 0.02167197f, -0.03329960f, -0.06703438f, 0.01718936f, -0.00882924f, 0.03056952f, -0.01973695f, 
    0.03469594f, -0.07585762f, 0.00007719f, 0.00502966f, 0.01577624f, -0.05465663f, -0.01110172f, -0.00599947f, 
    -0.00654533f, -0.05126863f, 0.01737097f, -0.07119378f, 0.01103493f, -0.05373218f, -0.06224189f, 0.00028207f, 
    0.06140358f, -0.06842796f, 0.02484910f, -0.02648035f, -0.04411143f, -0.03550500f, 0.00902622f, 0.01284521f, 
    -0.04284056f, 0.04513254f, -0.02422410f, 0.02508428f, 0.03861110f, 0.00233484f, -0.02156544f, -0.01206349f, 
    -0.00356187f, -0.03325055f, -0.04662655f, 0.01024731f, -0.04058671f, -0.03780927f, -0.05754884f, -0.08074915f, 
    0.05548844f, 0.00598118f, -0.00255991f, 0.06188344f, 0.06313998f, -0.03066001f, 0.04008729f, -0.01092881f, 
    -0.06960242f, -0.04825634f, -0.01526920f, -0.03048403f, 0.01610407f, 0.02985527f, -0.03554009f, 0.03934108f, 
    -0.01158517f, -0.01407355f, -0.03181751f, 0.02849589f, 0.01475678f, 0.04259476f, -0.07277872f, 0.05518555f, 
    -0.08129296f, 0.04303863f, 0.01762251f, 0.03203334f, 0.05195599f, -0.06085768f, -0.01616237f, -0.06589301f, 
    -0.05398124f, -0.04106115f, 0.01936100f, -0.02186785f, 0.06250334f, -0.02327856f, -0.06026162f, -0.03964793f, 
    0.01006641f, -0.03649506f, -0.00339747f, 0.00122483f, -0.03738686f, 0.00854543f, -0.01639005f, 0.02678186f, 
    0.02274390f, 0.01263412f, 0.00561401f, 0.06306964f, -0.03215628f, -0.03474041f, -0.01504231f, -0.04774557f, 
    0.04979716f, -0.01584071f, -0.04597442f, -0.02241267f, -0.03114809f, -0.06013693f, 0.02787148f, 0.00742868f, 
    -0.00610549f, -0.00607136f, -0.00726520f, -0.04936383f, -0.03335615f, 0.01265564f, -0.06890716f, -0.07416260f, 
    0.03997366f, 0.02196354f, 0.05471544f, 0.02205714f, -0.07286984f, 0.00018010f, -0.06294339f, 0.03624398f, 
    0.00102664f, -0.05904367f, -0.06565195f, 0.03273691f, -0.03556448f, -0.01234198f, -0.03756080f, 0.04160863f, 
    -0.06411706f, 0.02104806f, -0.06370199f, 0.02159088f, -0.03780698f, -0.06143091f, -0.00056285f, 0.01717343f, 
    -0.08441146f, 0.04086699f, -0.13307396f, -0.19505516f, 0.03140058f, -0.13684110f, -0.07462122f, -0.12582366f, 
    0.21755429f, 0.10001416f, -0.02326530f, -0.10116427f, 0.05476676f, -0.13259758f, -0.15599820f, -0.06151342f, 
    0.16356908f, 0.11906843f, 0.03526415f, 0.04061609f, 0.04182484f, 0.09806426f, -0.05894361f, 0.05580739f, 
    0.16345267f, -0.13081753f, -0.10321010f, 0.10812481f, 0.18981984f, 0.06659020f, -0.01062670f, -0.04620865f, 
    -0.11186533f, -0.03367131f, 0.03006378f, 0.10695258f, -0.13073917f, 0.06273971f, -0.13145964f, 0.01484166f, 
    0.04965347f, 0.10785748f, -0.09282734f, 0.04836965f, -0.03180883f, 0.12687334f, -0.01048096f, -0.12626895f, 
    -0.05861015f, 0.17454572f, 0.14248012f, -0.19362986f, 0.00864456f, -0.08777307f, -0.06681217f, 0.10328391f, 
    -0.01831250f, 0.02133476f, 0.13181768f, -0.01483115f, 0.15719140f, -0.06500074f, 0.33162305f, 0.10851009f, 
    -0.01235407f, -0.00492095f, -0.00302178f, 0.00470583f, 0.01218646f, -0.11748243f, -0.07629455f, 0.11546113f, 
    -0.21794137f, 0.37967190f, -0.12545849f, -0.04869661f, -0.07472014f, -0.08202247f, 0.06875636f, 0.10407998f, 
    -0.04136365f, -0.08450950f, 0.06501298f, -0.02230298f, -0.15194973f, 0.09362648f, -0.13595042f, 0.01176072f, 
    0.04616055f, -0.08540335f, -0.01717122f, -0.14389394f, 0.02945406f, -0.01351779f, -0.03243957f, -0.17439911f, 
    -0.39128828f, 0.07048728f, 0.20953260f, 0.09355062f, 0.11571053f, -0.08185443f, 0.05458834f, 0.05019669f, 
    0.03371266f, -0.03261880f, 0.09598008f, 0.06543902f, 0.14691086f, -0.08513876f, -0.15038985f, -0.15036637f, 
    0.13901809f, -0.03923758f, 0.02654761f, 0.05516651f, 0.16805834f, -0.07017643f, 0.03731159f, 0.04260273f, 
    -0.00124510f, 0.07054791f, -0.02332737f, 0.16290121f, -0.08680964f, 0.03962293f, 0.05203436f, -0.00465545f, 
    0.03134918f, -0.07222137f, 0.01126155f, 0.09521990f, 0.00989874f, -0.33263433f, 0.07351963f, -0.05586896f, 
    0.05436814f, 0.06747565f, 0.03689203f, 0.01055220f, 0.10360705f, -0.07615785f, 0.19694078f, 0.06854812f, 
    0.26343355f, -0.02717429f, -0.10132273f, -0.10093033f, 0.10893510f, 0.01117369f, -0.00858038f, -0.01869587f, 
    -0.23539855f, -0.03589341f, -0.18156327f, 0.01851427f, -0.03274112f, 0.21651065f, 0.08726998f, -0.24564326f, 
    0.04769187f, -0.16512764f, 0.07357831f, -0.00020797f, -0.07929532f, -0.03443361f, -0.12356239f, -0.06557344f, 
    -0.07181199f, -0.05743651f, 0.04575292f, 0.10897761f, 0.02807716f, -0.10321566f, -0.03071943f, 0.01658752f, 
    0.12658729f, -0.04621755f, 0.24589778f, -0.00493726f, -0.13019954f, -0.00771850f, 0.01594678f, 0.31500897f, 
    0.00001409f, -0.06405325f, 0.16590750f, 0.03046663f, -0.01915039f, 0.03825692f, 0.07967621f, 0.21727178f, 
    -0.10017280f, -0.05902090f, -0.06350799f, -0.01910573f, 0.10703754f, 0.04287820f, -0.08011564f, 0.01222475f, 
    0.02955672f, -0.02182336f, -0.04001354f, 0.06483942f, -0.03171755f, -0.12448074f, -0.06122871f, -0.25878876f, 
    -0.13133414f, -0.13454632f, 0.14329055f, 0.06173019f, 0.02506738f, 0.07031050f, -0.01380614f, 0.06941058f, 
    -0.10235035f, -0.10026718f, 0.06823044f, -0.16231948f, -0.00674936f, -0.00110397f, 0.09892783f, 0.02343082f, 
    0.06577736f, 0.01666593f, -0.00904369f, 0.11697558f, 0.15747592f, -0.13537855f, -0.19883551f, -0.06559939f, 
    0.03147064f, 0.01798292f, 0.10248829f, 0.09246414f, 0.03138592f, -0.01142502f, 0.10292975f, 0.03814070f, 
    0.17597459f, -0.23169611f, 0.05472618f, -0.19414201f, -0.08819629f, 0.15892407f, 0.04258603f, -0.01028623f, 
    0.08315413f, 0.10796887f, 0.04834821f, 0.09458267f, 0.11431259f, 0.13637550f, 0.00540001f, 0.00488588f, 
    0.07774489f, 0.17551541f, 0.13159510f, 0.04947317f, 0.15920007f, 0.14759637f, 0.01485417f, -0.03740657f, 
    -0.29990777f, 0.12474924f, -0.10271715f, 0.03536157f, 0.09006898f, -0.04651289f, 0.07633510f, 0.15812042f, 
    -0.04000673f, 0.02953076f, 0.03736546f, 0.04352047f, 0.19967686f, -0.34102178f, -0.00555252f, 0.18002962f, 
    0.00352250f, 0.02626146f, 0.04036976f, 0.09248511f, 0.09784288f, 0.03131066f, -0.08883730f, 0.11089981f, 
    0.35653064f, 0.09629484f, -0.20369864f, 0.18044756f, 0.11003525f, 0.01872542f, -0.00012853f, 0.02497187f, 
    0.00170559f, 0.04269972f, 0.07224855f, 0.00353208f, 0.01738052f, 0.00532709f, 0.00987932f, 0.15634172f, 
    0.01532283f, 0.12681565f, -0.05244239f, -0.02968264f, 0.01270684f, 0.03023805f, -0.07060711f, 0.00929044f, 
    -0.19352749f, 0.03371714f, -0.08425785f, -0.06004769f, -0.11014862f, -0.08027687f, -0.02150760f, 0.04721230f, 
    0.09010462f, 0.05171164f, 0.00490124f, -0.06771100f, -0.23411621f, -0.01703332f, -0.01276617f, -0.08011984f, 
    -0.07131507f, -0.02431806f, -0.03176962f, 0.10087601f, -0.00499567f, 0.04290315f, -0.00714916f, 0.02036258f, 
    0.33855742f, -0.09749907f, 0.14270563f, 0.15489033f, -0.03099083f, -0.04526306f, 0.04780535f, 0.02127738f, 
    0.17740530f, -0.10119292f, 0.01380004f, -0.07933560f, 0.14711295f, -0.04416337f, -0.14953023f, 0.05355585f, 
    0.05508384f, 0.11403666f, 0.05404311f, 0.04989917f, 0.03519614f, 0.11860058f, 0.09998085f, 0.06769722f, 
    -0.10874164f, 0.08987969f, -0.06269680f, 0.05914534f, -0.13295375f, -0.03550748f, -0.02425934f, -0.01210508f, 
    0.01691802f, -0.08573411f, -0.13244170f, 0.09643463f, 0.03030384f, 0.04985943f, 0.05593577f, -0.06423979f, 
    -0.03125263f, 0.05977560f, 0.05653181f, 0.10748371f, 0.09785405f, -0.12822175f, 0.07015997f, 0.06267060f, 
    -0.17094855f, 0.04074934f, -0.12297000f, -0.18489839f, 0.12313867f, 0.01556167f, 0.00347624f, 0.02635009f, 
    0.07974605f, -0.05699625f, 0.01364178f, -0.06413417f, -0.11195577f, -0.02625659f, 0.04947736f, 0.11287948f, 
    -0.06809007f, 0.07174735f, 0.02356819f, 0.17043667f, -0.05763722f, 0.12293661f, 0.00555795f, 0.02695100f, 
    0.19316132f, -0.10327749f, 0.04977105f, 0.20012423f, 0.01971319f, 0.02135820f, 0.00021169f, 0.09412656f, 
    -0.05426151f, -0.07121330f, -0.09536520f, 0.06025517f, -0.24648933f, -0.08198068f, 0.21611080f, -0.06912460f, 
    0.10102732f, 0.02191753f, 0.01102482f, 0.03416654f, -0.04310234f, 0.11047500f, -0.02500523f, 0.15612499f, 
    0.23633446f, 0.14823091f, -0.00656666f, -0.15608034f, 0.00243684f, 0.02142698f, 0.12686139f, -0.00053488f, 
    -0.02838319f, 0.01594740f, 0.00402035f, -0.05892201f, -0.11041950f, 0.04072791f, 0.10649388f, 0.08781563f, 
    -0.05086197f, 0.03897101f, -0.05204309f, -0.10667675f, -0.02164251f, -0.01519460f, -0.02696382f, -0.11546969f, 
    -0.26524165f, 0.33998016f, -0.06793416f, -0.03530103f, 0.01711570f, 0.00091274f, 0.13716707f, -0.01884268f, 
    -0.01712643f, -0.05822393f, 0.01338137f, 0.06625630f, 0.62711698f, 0.13969390f, -0.04149368f, 0.32498485f, 
    -0.03255847f, -0.06504359f, -0.01495923f, 0.08100893f, -0.03168061f, 0.07183389f, 0.15430653f, -0.01147173f, 
    -0.32891271f, 0.09116075f, 0.03604040f, -0.18980773f, 0.02273862f, 0.04351584f, -0.00141484f, -0.01825057f, 
    -0.08105121f, -0.06743599f, 0.11762110f, 0.02091560f, -0.11961207f, -0.08301612f, 0.19029674f, 0.18156293f, 
    0.11194636f, 0.12011633f, 0.10797580f, -0.02365748f, 0.01468262f, -0.07975814f, -0.03576361f, 0.04063385f, 
    -0.09825713f, 0.01423447f, 0.11149290f, -0.07282552f, 0.07726678f, 0.05926711f, 0.00883621f, 0.09836704f, 
    -0.08359969f, 0.04963782f, 0.06850768f, 0.08294269f, 0.11548898f, 0.00948421f, 0.08648032f, -0.16869001f, 
    0.15093897f, 0.08075187f, 0.07150295f, 0.09996211f, -0.02838992f, -0.08430853f, -0.02519141f, 0.00186536f, 
    0.30270728f, 0.02081396f, 0.14386657f, 0.31127360f, -0.18427283f, -0.07421622f, -0.06135754f, 0.07879857f, 
    0.06748066f, -0.01780351f, -0.03371831f, -0.01217716f, -0.04575050f, 0.18117143f, 0.10828696f, 0.03254316f, 
    0.06307086f, 0.13110007f, 0.16280760f, 0.04655455f, 0.04462828f, 0.12091491f, 0.13056991f, 0.10451341f, 
    -0.09128776f, -0.03314578f, 0.02379121f, 0.08173250f, 0.11654780f, -0.09789323f, 0.00820450f, 0.00536561f, 
    -0.10214563f, 0.08072821f, -0.11692841f, -0.07508747f, -0.10959485f, 0.03942679f, 0.07997438f, 0.05408202f, 
    -0.03211686f, -0.06795558f, -0.08834390f, -0.04915159f, 0.00588103f, 0.03940926f, 0.02981864f, -0.04339147f, 
    0.30731112f, 0.06858806f, -0.02364089f, -0.05304333f, 0.05283532f, 0.04706275f, 0.11694329f, 0.00799231f, 
    -0.05118462f, 0.04094562f, -0.03626018f, 0.00932498f, -0.14692342f, -0.07900791f, 0.00004100f, 0.03534615f, 
    -0.03686171f, -0.02565346f, 0.14767098f, 0.14680022f, -0.00030573f, -0.04996293f, -0.07808243f, 0.09672288f, 
    -0.37003285f, -0.18787676f, 0.01005673f, -0.05576757f, 0.02281605f, 0.05154057f, 0.08355159f, 0.03419982f, 
    0.05308304f, 0.00956726f, -0.00365914f, 0.15276974f, -0.13163385f, 0.08815497f, -0.13113026f, -0.01756897f, 
    0.16499658f, 0.01819705f, 0.10196186f, 0.23855206f, 0.13314143f, -0.03921883f, 0.03195987f, 0.00938415f, 
    0.07266144f, -0.07419737f, 0.12943181f, -0.16618204f, 0.01865151f, 0.00078623f, 0.06572326f, -0.10315184f, 
    0.09964786f, 0.09904138f, 0.19119364f, 0.07500506f, -0.01161352f, -0.15133798f, -0.04106155f, 0.07261510f, 
    -0.05756657f, 0.01630629f, 0.11121722f, 0.01492726f, 0.07506035f, -0.07809088f, 0.02482521f, 0.09704623f, 
    0.11228647f, -0.08648734f, -0.23660682f, 0.10888434f, -0.01842391f, -0.02858046f, -0.13367534f, 0.10940172f, 
    0.02537755f, -0.05098508f, 0.08207547f, 0.04482652f, 0.14993432f, 0.12061464f, 0.10417993f, 0.03421117f, 
    0.15687241f, -0.02879278f, 0.04348340f, -0.05340157f, 0.18695419f, 0.14036360f, 0.03787827f, 0.05707668f, 
    0.11345606f, 0.09055330f, -0.03048975f, 0.03624757f, 0.23565134f, 0.03364238f, 0.06234318f, 0.08600670f, 
    -0.00451248f, 0.11687101f, -0.02156127f, 0.07778802f, 0.08786042f, -0.02599349f, -0.00743314f, 0.09053145f, 
    0.10663544f, 0.01945058f, -0.03734497f, 0.00750744f, -0.01025123f, 0.09296574f, -0.02288660f, 0.12670667f, 
    -0.11484931f, -0.05684635f, -0.16607130f, -0.13924997f, 0.11192029f, 0.01677060f, 0.10356849f, 0.09713430f, 
    0.05100594f, 0.12413670f, 0.11937886f, 0.09945282f, -0.34340516f, -0.17314193f, -0.20771556f, -0.14213082f, 
    -0.08665781f, -0.02858860f, 0.05799486f, 0.06918541f, 0.03632724f, 0.06248771f, -0.02510091f, -0.05171126f, 
    0.18278265f, 0.27527410f, 0.30689707f, 0.17644292f, 0.18501037f, 0.05262091f, 0.00158104f, -0.02497760f, 
    0.06990577f, 0.08636992f, 0.09779029f, -0.03088946f, 0.24169366f, 0.10513265f, 0.07912797f, 0.14138147f, 
    0.15755154f, 0.02925876f, 0.07084664f, 0.04878636f, 0.17331018f, 0.03219636f, 0.15359861f, 0.07671072f, 
    -0.05573564f, -0.12400905f, -0.11798417f, -0.01399213f, -0.03580076f, -0.02921982f, 0.05846286f, 0.00847027f, 
    -0.04872850f, -0.05696462f, -0.11018272f, 0.21663167f, -0.11872728f, -0.08566853f, 0.04047750f, -0.16275577f, 
    0.02919359f, 0.08030706f, 0.01486472f, 0.06079462f, 0.05111392f, 0.06329449f, 0.07530730f, 0.09107915f, 
    -0.24439421f, 0.10436149f, -0.00783810f, 0.24597524f, 0.07174119f, 0.01129231f, -0.03287857f, -0.03773668f, 
    0.09573764f, -0.03449434f, -0.07240393f, -0.14928927f, -0.17874479f, -0.05373871f, -0.21031509f, -0.18623875f, 
    0.09484188f, 0.08028723f, -0.05225214f, -0.05028081f, 0.09882806f, 0.09156668f, 0.14340273f, -0.05295341f, 
    0.01509014f, -0.00265912f, 0.03324338f, -0.05521488f, -0.05422100f, 0.04728381f, 0.06339573f, 0.08705928f, 
    -0.06163791f, -0.13225648f, 0.02328601f, 0.03292574f, 0.03023850f, -0.31751943f, -0.01538978f, -0.09896967f, 
    0.07517398f, 0.00012365f, -0.02261540f, 0.04738846f, -0.07550365f, 0.04533689f, 0.07052722f, 0.21053058f, 
    0.16503802f, -0.06506838f, 0.01268791f, 0.13760021f, -0.06134544f, 0.10131589f, -0.02319457f, 0.14846383f, 
    -0.20426242f, -0.02468894f, -0.01367476f, 0.06439077f, -0.07978190f, -0.05793166f, 0.13328989f, 0.03508193f, 
    0.02294046f, 0.02851708f, -0.02582271f, 0.04528161f, -0.16385150f, 0.05363894f, -0.04890196f, 0.02514274f, 
    -0.38173956f, 0.07483941f, -0.02316057f, 0.01378574f, 0.11363033f, -0.01732290f, 0.07817724f, -0.06913913f, 
    -0.10883527f, -0.02192042f, -0.00941914f, 0.04114905f, -0.07187574f, 0.09058158f, 0.11493374f, 0.06350926f, 
    -0.23380142f, 0.13191643f, 0.08779050f, 0.06767065f, -0.04646112f, 0.02922253f, -0.01767861f, 0.02959054f, 
    0.05508669f, -0.01234517f, -0.15845656f, 0.11761476f, 0.09089591f, -0.00865101f, 0.01601234f, -0.05747561f, 
    0.02536926f, -0.03742205f, 0.04352590f, -0.14292926f, 0.20073816f, 0.16136596f, 0.29290470f, 0.04345209f, 
    -0.03978287f, 0.14996830f, 0.04270282f, -0.00690403f, 0.04787925f, -0.00043269f, -0.06172067f, -0.04491935f, 
    0.03514091f, -0.10091330f, 0.10174922f, 0.01454813f, 0.12448028f, -0.10314267f, -0.02416985f, 0.06960958f, 
    -0.02167688f, 0.15173486f, -0.01601565f, 0.08734388f, -0.01559873f, 0.12301950f, 0.10150812f, -0.08609799f, 
    -0.05829468f, -0.01132924f, -0.02265480f, -0.00453510f, -0.02046175f, 0.08193031f, 0.02854587f, 0.02128679f, 
    0.01507283f, 0.24935083f, 0.18026294f, -0.04008994f, -0.14622465f, -0.07049783f, -0.02638179f, 0.06811135f, 
    0.02284817f, 0.00450095f, -0.02341559f, -0.10988566f, 0.02878945f, 0.00414086f, -0.01573768f, 0.11975101f, 
    -0.01554192f, 0.03374932f, 0.07599863f, 0.00199796f, -0.02740675f, 0.09284976f, 0.02185712f, -0.01890247f, 
    -0.05650179f, 0.00859060f, 0.04026800f, -0.03490715f, -0.05424562f, 0.07148008f, -0.00382305f, 0.08556017f, 
    -0.07526526f, 0.11085641f, 0.02565694f, -0.01386284f, -0.04518252f, 0.07547469f, -0.00075369f, 0.11376195f, 
    -0.02642024f, -0.09262016f, -0.06763920f, 0.02485161f, -0.07092776f, 0.08517633f, -0.04551630f, -0.09383707f, 
    0.17480247f, 0.05534908f, -0.10503515f, -0.10240892f, 0.01545534f, -0.08536512f, 0.00467140f, 0.12602679f, 
    0.07064677f, -0.07107006f, 0.07371270f, 0.13595769f, -0.02061498f, 0.10900214f, 0.19617458f, 0.21438725f, 
    -0.03930663f, -0.00031682f, -0.07150834f, -0.02221693f, 0.00434836f, 0.06826448f, -0.11080985f, 0.17537196f, 
    -0.23073378f, -0.12513328f, 0.16568525f, 0.11324486f, -0.02750224f, 0.09991343f, 0.03186297f, 0.05074928f, 
    0.23433536f, -0.10365704f, 0.03684158f, 0.03591358f, -0.06229096f, 0.27030525f, -0.03515451f, 0.11663931f, 
    0.00567464f, -0.06386676f, -0.01364056f, 0.01095695f, 0.00492113f, -0.08765133f, -0.02130502f, -0.12717175f, 
    -0.03501674f, 0.28672880f, -0.09724224f, -0.16772108f, 0.06881114f, -0.08691910f, 0.06391225f, 0.05929985f, 
    0.03829055f, -0.02785710f, -0.03965261f, -0.03766325f, -0.09461677f, 0.07708078f, -0.02806100f, -0.11158773f, 
    -0.09186137f, -0.08705961f, -0.01892383f, -0.09808163f, 0.16165741f, 0.00206346f, 0.05999114f, 0.06432482f, 
    0.09569120f, 0.03768665f, 0.01682856f, -0.06925460f, -0.07240412f, -0.05126316f, -0.04479659f, -0.07963348f, 
    -0.03155534f, -0.10988044f, 0.00143432f, 0.00876575f, 0.54383898f, -0.23985526f, 0.08170414f, 0.21406962f, 
    0.01705652f, -0.06821569f, 0.10381370f, 0.00702744f, -0.01642158f, -0.00313927f, -0.05077080f, -0.12101421f, 
    -0.15367360f, -0.07387860f, -0.07727196f, -0.17953098f, -0.03639114f, 0.06549615f, -0.00876306f, -0.04220554f, 
    -0.02911458f, 0.05118514f, -0.08580677f, 0.08213703f, -0.09919320f, -0.13972603f, -0.02539227f, 0.08323557f, 
    0.16818582f, -0.09279905f, -0.02940146f, -0.00085121f, -0.01755330f, 0.06428976f, 0.07375554f, 0.09736418f, 
    -0.13706081f, 0.04447896f, -0.01211671f, 0.01031642f, -0.06172942f, -0.00281621f, -0.19156854f, 0.07668834f, 
    -0.05166050f, -0.15945379f, 0.04283754f, -0.01093900f, -0.21314162f, -0.02585757f, 0.00181646f, -0.09628341f, 
    0.06149508f, -0.07708395f, 0.06357471f, 0.08597295f, -0.06706050f, 0.07002276f, -0.05377894f, -0.00760634f, 
    -0.13512617f, -0.20489238f, 0.19547603f, 0.28493494f, 0.19658132f, 0.10730322f, 0.00269658f, -0.00914127f, 
    0.02801996f, 0.01345861f, 0.09410040f, 0.14365433f, 0.19941075f, 0.22370842f, -0.00422875f, 0.25897056f, 
    0.05600947f, 0.04765140f, -0.05158703f, 0.00771234f, 0.13214800f, -0.01355029f, -0.00750141f, -0.14482607f, 
    0.02572250f, -0.14682420f, -0.06103627f, -0.09044565f, 0.00800149f, -0.03651991f, 0.21812733f, -0.01313413f, 
    -0.01341291f, -0.09364072f, 0.01699335f, 0.16104823f, 0.11846064f, -0.04012970f, 0.01542097f, -0.25513569f, 
    0.05120438f, -0.02551213f, -0.07004773f, -0.02897559f, 0.09425628f, 0.04667079f, 0.07316991f, 0.24569124f, 
    0.02703611f, 0.07916246f, 0.14650545f, 0.11607991f, -0.08685871f, 0.09817587f, 0.02595183f, -0.02995652f, 
    0.03608728f, 0.00082604f, 0.08100131f, -0.05966589f, 0.14821297f, -0.05908034f, -0.10134235f, 0.13221629f, 
    0.08154415f, 0.05113539f, 0.09957218f, -0.03719020f, -0.03005485f, -0.11464120f, -0.00490294f, 0.04513317f, 
    0.00085003f, 0.15957652f, -0.08835219f, 0.10294165f, 0.03951387f, 0.10131928f, 0.01399095f, -0.12639049f, 
    -0.05662314f, 0.13381517f, 0.05866462f, -0.06549410f, 0.03145638f, 0.04466154f, 0.17417267f, 0.04626431f, 
    -0.03399478f, -0.00216179f, 0.05072132f, -0.01987523f, -0.06499702f, 0.13623659f, -0.03804106f, -0.02490813f, 
    -0.19533804f, -0.14159700f, 0.16609386f, 0.19153784f, 0.04960451f, -0.06134208f, 0.10093447f, 0.02418326f, 
    -0.07326485f, 0.09066735f, 0.11837992f, -0.10496863f, 0.05947602f, -0.25845882f, -0.06841964f, 0.12116440f, 
    0.09013547f, 0.00325792f, 0.07566477f, 0.01827157f, -0.06462775f, -0.14733396f, 0.05098484f, 0.12068908f, 
    0.43139187f, -0.35670522f, -0.07085633f, 0.12304601f, 0.10120894f, 0.12486205f, -0.00291571f, 0.10088080f, 
    0.03114956f, 0.00500671f, 0.03540573f, 0.01144705f, -0.41806218f, 0.15766932f, 0.01641582f, -0.29570341f, 
    0.16666330f, 0.03858545f, 0.08091049f, -0.01072151f, -0.01962109f, 0.07219417f, -0.00096267f, 0.04142094f, 
    0.25006595f, -0.01884852f, 0.01040572f, 0.04164447f, -0.02917776f, 0.01247109f, 0.03634822f, -0.01354116f, 
    0.05642501f, -0.01122357f, -0.02773967f, -0.03812589f, 0.15313531f, 0.13423055f, -0.00728353f, 0.02625635f, 
    -0.01931586f, 0.03323995f, 0.04944431f, 0.05691328f, 0.08101179f, -0.01844439f, 0.03113467f, 0.04610223f, 
    0.22505631f, -0.06084235f, -0.04261377f, -0.00513221f, 0.06657606f, -0.03283638f, 0.07991355f, 0.05193472f, 
    0.03461210f, 0.08469503f, -0.05473022f, -0.07616172f, 0.24790081f, 0.00051708f, -0.11861841f, 0.09805512f, 
    0.09505340f, -0.00445144f, -0.02687174f, 0.03698226f, -0.01982929f, -0.05400464f, -0.01222244f, -0.06091551f, 
    -0.31842068f, 0.20743576f, 0.01935957f, -0.33253318f, 0.11504795f, 0.05764562f, -0.03180446f, -0.03312844f, 
    0.01874843f, 0.01232326f, 0.08410483f, 0.04061119f, -0.05495232f, -0.02875557f, 0.04331085f, -0.14683016f, 
    0.14764270f, -0.10948803f, 0.00090302f, -0.08671024f, 0.13290156f, -0.05869064f, 0.08613331f, 0.03574692f, 
    0.19163370f, 0.09150357f, -0.14388101f, -0.03315575f, 0.01723886f, 0.06819298f, -0.02271528f, -0.02255247f, 
    0.08623023f, -0.03628159f, 0.02178017f, 0.01129562f, 0.11326316f, -0.08402175f, -0.06002513f, 0.00082107f, 
    0.05373092f, 0.07141661f, 0.02276233f, -0.00773112f, -0.00025303f, -0.01548940f, 0.00192420f, -0.02665608f, 
    -0.06260863f, -0.08335885f, -0.13102305f, -0.05899893f, -0.08651093f, 0.08230229f, 0.01730919f, 0.01968847f, 
    0.03599755f, 0.11953566f, -0.07837363f, -0.00349736f, -0.08882308f, -0.16826737f, -0.09506312f, 0.16450939f, 
    0.13582253f, -0.01037441f, -0.00965604f, 0.06005690f, -0.06822168f, 0.05783068f, -0.05280349f, -0.01861800f, 
    -0.16086008f, -0.01416895f, -0.12102052f, 0.17208666f, 0.09452905f, 0.02163379f, 0.08786025f, 0.04602573f, 
    0.01024889f, 0.04567029f, 0.12793927f, -0.03922355f, -0.26260477f, -0.04868691f, -0.17781472f, -0.17425871f, 
    0.09057218f, 0.10283136f, -0.03604501f, 0.04103864f, -0.07250900f, -0.00122418f, 0.08733322f, -0.10432211f, 
    -0.27956590f, -0.23746149f, 0.15151577f, 0.03553559f, -0.03626924f, -0.03782625f, -0.03573797f, 0.10048467f, 
    0.06626404f, 0.07337964f, 0.06858301f, 0.01839471f, -0.00010471f, -0.14107788f, 0.09350934f, 0.25303039f, 
    -0.04292563f, -0.02433494f, 0.13117234f, -0.00321954f, -0.03572346f, 0.11707459f, 0.11956554f, 0.21656360f, 
    0.18129577f, -0.25304925f, -0.29812714f, -0.00725801f, 0.07512520f, 0.12334044f, -0.10267620f, -0.02628957f, 
    0.04611322f, -0.02591518f, 0.06286063f, -0.02908352f, -0.32656491f, 0.06828915f, 0.12239635f, -0.30908135f, 
    -0.00574493f, -0.05462602f, 0.08330920f, -0.06177144f, 0.02300263f, -0.00497407f, -0.02985402f, 0.11388169f, 
    -0.05902719f, 0.01992374f, -0.16402467f, -0.00533159f, 0.14167209f, 0.07444378f, 0.14334831f, 0.05226269f, 
    -0.02182450f, 0.13427956f, 0.08509554f, 0.02345122f, 0.10081127f, 0.00614313f, -0.02897311f, -0.00197448f, 
    -0.08651461f, -0.12477059f, -0.01194398f, -0.03837961f, 0.00815780f, 0.12040232f, 0.11232182f, 0.19619603f, 
    0.00723906f, -0.04218810f, -0.07746091f, 0.14711742f, 0.11463660f, 0.12132878f, 0.03459007f, -0.01035347f, 
    0.02811802f, -0.07024398f, 0.06884041f, -0.02048386f, -0.45060298f, -0.33707076f, -0.16095605f, 0.14906119f, 
    0.03177549f, 0.01640214f, 0.09399609f, -0.08803936f, -0.03646510f, 0.07084855f, 0.13371122f, -0.06715682f, 
    -0.15566385f, 0.11665286f, 0.27787206f, -0.14021733f, -0.02955179f, 0.01337563f, -0.02916079f, -0.01522664f, 
    0.00012083f, 0.14981011f, 0.03526876f, 0.05229785f, -0.02348453f, -0.07851452f, -0.02619771f, -0.17789537f, 
    0.06456210f, 0.02832765f, -0.00514133f, -0.00646355f, 0.05175089f, -0.09646115f, -0.02289675f, 0.02792935f, 
    0.08825739f, -0.09119730f, 0.00882813f, 0.16791855f, 0.09770592f, -0.05802306f, 0.08532355f, -0.03543925f, 
    0.13251384f, 0.04020900f, 0.14325266f, -0.03276226f, -0.01519012f, -0.10380451f, -0.01420537f, 0.21934117f, 
    0.07812268f, 0.13002805f, 0.02755034f, -0.02963890f, 0.01825730f, 0.05524499f, 0.14556247f, 0.28272340f, 
    0.04367571f, 0.04171094f, 0.00895947f, -0.04212085f, -0.03932348f, 0.03031848f, 0.00496426f, 0.02078083f, 
    -0.00562051f, 0.03082438f, -0.06437705f, -0.04150399f, -0.04113106f, -0.06099717f, -0.05874206f, -0.01665357f, 
    0.01996949f, 0.02076994f, 0.02436541f, 0.00315416f, -0.05440233f, -0.04191479f, 0.00441382f, 0.07215567f, 
    -0.00963314f, -0.01765694f, -0.05829176f, 0.00569636f, -0.04732018f, 0.04731141f, 0.04916263f, 0.04221340f, 
    0.05069432f, 0.02342157f, -0.01768257f, 0.01675994f, -0.01596982f, 0.00786208f, -0.04322977f, -0.03999298f, 
    -0.02490498f, 0.06381619f, -0.06133249f, -0.04951186f, -0.05659208f, 0.02350211f, -0.07102151f, -0.00049421f, 
    -0.04475753f, -0.00926058f, -0.04772641f, -0.05633513f, 0.01311296f, -0.06680514f, -0.03292608f, -0.02119564f, 
    -0.02627646f, 0.05984513f, 0.01105587f, 0.06142830f, 0.00950554f, -0.03023224f, -0.04068642f, -0.06237082f, 
    -0.07048631f, 0.06378368f, -0.03222812f, -0.06255364f, 0.06777918f, -0.06690781f, 0.01668920f, -0.04113654f, 
    0.00870869f, 0.06406008f, 0.05628649f, -0.03260440f, -0.03495257f, -0.03045800f, 0.02917937f, 0.06543759f, 
    -0.04089388f, -0.05747649f, -0.02724737f, 0.06450312f, -0.02642298f, -0.00340939f, 0.02400121f, -0.06816875f, 
    -0.06959230f, -0.04259137f, 0.02277718f, 0.00880373f, -0.00441420f, 0.04344109f, -0.04960825f, -0.03967084f, 
    -0.01285260f, 0.06816988f, 0.00151904f, -0.06861285f, 0.00759155f, -0.00741227f, 0.06257929f, -0.02581490f, 
    -0.06435400f, 0.05563203f, -0.05648656f, -0.05138676f, -0.04400980f, 0.03463053f, 0.04841495f, 0.00696027f, 
    -0.03892794f, 0.00353866f, -0.05676482f, 0.00224608f, -0.01206643f, -0.06517059f, -0.03567890f, 0.02887864f, 
    -0.01972788f, 0.00240263f, -0.02474127f, -0.06729757f, -0.05121468f, 0.00823462f, 0.02296806f, 0.04888925f, 
    -0.00106909f, 0.06169936f, 0.05931256f, 0.04794172f, -0.04392342f, -0.07011510f, -0.06716780f, 0.04060275f, 
    -0.05760935f, 0.02041988f, -0.00704935f, 0.02472100f, -0.07138512f, -0.02280618f, -0.02934337f, -0.01895174f, 
    -0.01527975f, -0.04737587f, 0.01680878f, -0.03679048f, -0.03424253f, -0.01377063f, 0.05738430f, 0.01056528f, 
    -0.06411374f, 0.03221723f, -0.05873857f, 0.05474265f, 0.00645017f, -0.01838548f, -0.02536786f, 0.02866280f, 
    -0.01854647f, -0.07013557f, -0.01332520f, -0.06850737f, -0.03940689f, 0.05770155f, 0.01257764f, -0.05176450f, 
    -0.00952018f, -0.01030209f, 0.03191391f, -0.05093804f, 0.06092593f, 0.06088867f, -0.05194927f, 0.03129982f, 
    0.03468414f, 0.01678139f, 0.06384653f, -0.04004572f, -0.05928059f, -0.03316691f, 0.05560033f, 0.05380720f, 
    -0.01128916f, -0.00980788f, -0.04903570f, -0.03711824f, 0.04500198f, -0.03226781f, 0.06039162f, 0.01161067f, 
    -0.11867139f, 0.05276158f, -0.14162119f, 0.00734636f, -0.03793240f, 0.07940010f, 0.19333756f, 0.01436145f, 
    0.17948340f, -0.07536317f, -0.02653921f, -0.07573035f, -0.09994592f, -0.07013128f, -0.07635471f, -0.09033734f, 
    0.18045756f, -0.03989848f, 0.06661768f, 0.13887110f, 0.02711410f, 0.10844257f, 0.00325139f, 0.04255465f, 
    -0.18333502f, -0.39745966f, -0.03961981f, -0.00253590f, 0.00760746f, 0.06185815f, -0.03066084f, -0.04299453f, 
    0.06086603f, -0.10566156f, 0.04807623f, 0.08184393f, 0.03158674f, -0.08905825f, -0.15537436f, -0.12948339f, 
    0.08055104f, 0.03808657f, -0.09770463f, 0.15997967f, -0.04945177f, 0.15378289f, -0.03944436f, -0.03739030f, 
    -0.16054425f, -0.05257633f, 0.30765018f, -0.22936015f, 0.01078144f, 0.04769060f, 0.05832180f, 0.14024255f, 
    -0.01344200f, -0.07056417f, 0.04170693f, 0.00662697f, 0.00937708f, -0.28825289f, 0.17897570f, -0.06041835f, 
    -0.00874727f, -0.03948798f, 0.03238007f, 0.02141609f, 0.10132687f, 0.00135979f, 0.09678029f, 0.08554096f, 
    0.12609041f, 0.06295694f, -0.26950306f, -0.00711243f, 0.11425498f, 0.07242630f, -0.05243279f, 0.06439824f, 
    -0.09267706f, 0.01996198f, 0.05242692f, 0.07448482f, 0.01311621f, 0.06447412f, 0.08141111f, -0.04616848f, 
    -0.05579647f, -0.04317062f, 0.00322286f, -0.08560308f, -0.08100992f, -0.00153457f, -0.10465832f, 0.05621845f, 
    -0.15240124f, -0.01931723f, 0.00231291f, 0.19596909f, -0.01427192f, 0.16412129f, -0.09948178f, 0.01159844f, 
    -0.03818599f, 0.07540260f, 0.08585977f, 0.03392167f, 0.32005844f, -0.09926356f, -0.10950328f, -0.05495134f, 
    0.07065371f, -0.04630360f, -0.07966342f, 0.18443991f, -0.00919801f, 0.25766000f, 0.07232605f, 0.16750357f, 
    -0.09143836f, 0.02133639f, -0.23749398f, 0.23294920f, 0.17879423f, -0.05347095f, -0.07505138f, 0.02866946f, 
    -0.03056248f, -0.06717569f, -0.06605273f, 0.05388181f, -0.55772245f, -0.09333650f, -0.05609297f, -0.21162412f, 
    -0.04274608f, 0.08593110f, 0.10601922f, -0.14466971f, 0.20730942f, 0.02018145f, 0.03488079f, -0.02094140f, 
    0.17600955f, 0.17316905f, 0.15150137f, 0.04968664f, -0.01271943f, 0.00991931f, 0.03100848f, -0.01067775f, 
    -0.02990911f, -0.01100478f, -0.07665145f, -0.05154192f, 0.02052084f, 0.13801675f, -0.05094378f, -0.19650824f, 
    0.05267756f, 0.03935296f, 0.08830882f, 0.06206993f, 0.01110410f, 0.01644297f, 0.10690831f, -0.03356775f, 
    -0.00523496f, -0.06146739f, -0.11542654f, 0.21563554f, 0.02586720f, 0.03159012f, 0.01623959f, 0.07281145f, 
    0.07729112f, -0.08576159f, 0.07658704f, 0.04409622f, -0.39817968f, -0.19437359f, -0.04667682f, 0.32767272f, 
    0.06795052f, 0.06458291f, 0.01126768f, 0.11836918f, 0.03130369f, 0.00200199f, 0.12683436f, 0.11749665f, 
    -0.02076078f, -0.04880669f, -0.01552895f, -0.03371351f, -0.06352998f, 0.08199375f, -0.05329950f, -0.06455727f, 
    0.04846750f, -0.13885345f, 0.01638105f, 0.00900201f, -0.02460757f, -0.00661885f, -0.02442625f, -0.27703288f, 
    -0.06575564f, -0.05560243f, 0.05128927f, 0.01780599f, 0.07737501f, -0.03740605f, 0.07181115f, 0.02091636f, 
    0.08392799f, -0.07526026f, 0.20458844f, -0.15270005f, -0.00135002f, 0.02360633f, 0.10905931f, 0.01109651f, 
    0.04386855f, 0.05812088f, 0.05939059f, 0.15361434f, 0.36018977f, -0.25558269f, -0.00116334f, -0.17438000f, 
    -0.03564320f, 0.03674342f, 0.01355914f, 0.08542059f, 0.09983294f, 0.04660839f, 0.05539899f, 0.03098304f, 
    0.00480848f, 0.03814723f, 0.02702944f, -0.35412046f, -0.13207576f, 0.07928079f, -0.02138375f, 0.04197383f, 
    0.02395500f, -0.16453865f, -0.05541687f, 0.08293675f, 0.21801527f, 0.18755439f, -0.17939979f, -0.25503293f, 
    0.15070164f, 0.06403328f, -0.05228823f, 0.03534514f, -0.01181887f, 0.12305155f, 0.06595813f, -0.08730281f, 
    0.17664170f, 0.13735445f, -0.05780587f, 0.05137807f, 0.05779570f, -0.12752286f, 0.07993663f, 0.02450366f, 
    0.04523738f, 0.13698156f, -0.15325648f, 0.12148621f, 0.20262727f, -0.16272299f, -0.01159803f, 0.11687416f, 
    -0.04901474f, -0.04286973f, -0.01330744f, 0.00540784f, -0.10650971f, 0.05877549f, 0.06208710f, -0.10296065f, 
    0.25275174f, -0.11159348f, -0.09183776f, 0.06753993f, 0.04698312f, 0.02526524f, -0.15420158f, 0.03704021f, 
    0.03711370f, -0.00836028f, 0.06175397f, 0.05706675f, 0.02071218f, -0.04398223f, -0.14816165f, 0.25717399f, 
    0.11254089f, 0.19024628f, -0.01502185f, 0.01556518f, 0.07121648f, 0.07758014f, -0.00780860f, -0.04375881f, 
    -0.06403647f, 0.10046486f, -0.00879101f, -0.08424127f, -0.05327956f, 0.01838237f, -0.00124695f, 0.02178506f, 
    0.13507216f, 0.07259876f, -0.09784149f, -0.03811982f, 0.20274749f, 0.34472552f, 0.06657679f, -0.26095790f, 
    -0.01745966f, 0.00600978f, -0.02960858f, 0.09841439f, 0.03050912f, -0.05520241f, -0.00314165f, 0.07731485f, 
    -0.01313028f, -0.22739732f, 0.00121970f, 0.16704565f, -0.10431850f, -0.11317839f, -0.05740681f, -0.13038595f, 
    0.00044210f, -0.05128062f, 0.06786024f, 0.00680714f, 0.13103034f, 0.01805380f, -0.17353360f, -0.00123447f, 
    -0.09981133f, -0.00738990f, -0.07631417f, -0.10205261f, 0.00809410f, 0.09294667f, -0.03021822f, 0.05467311f, 
    0.06529351f, 0.21844496f, 0.05765476f, -0.05245869f, -0.05810161f, 0.08063275f, -0.05562659f, -0.02443990f, 
    -0.01387490f, -0.01184582f, -0.03764810f, 0.05244236f, -0.04795577f, 0.03726756f, 0.04933891f, -0.07022998f, 
    0.00440220f, 0.00870119f, -0.02485799f, 0.08778111f, 0.01327781f, -0.04494946f, 0.04140284f, -0.13552777f, 
    0.00465690f, -0.03350244f, 0.00817317f, -0.01181134f, -0.07420167f, -0.05151092f, 0.03558832f, 0.00084418f, 
    -0.03070703f, -0.03696098f, -0.04997209f, -0.06003642f, 0.05938955f, 0.03714841f, 0.02927405f, 0.00988445f, 
    -0.00139883f, 0.01742058f, 0.02850896f, -0.03595944f, -0.05212953f, -0.03270811f, 0.02208043f, 0.03941398f, 
    -0.04585363f, -0.02689645f, 0.01666162f, 0.00267278f, 0.04729171f, 0.04426692f, -0.03468237f, -0.04362526f, 
    0.00609431f, -0.04126769f, 0.06604050f, -0.03949858f, 0.01737245f, -0.01650306f, 0.00328185f, 0.05482505f, 
    0.01961626f, -0.00267241f, 0.02146014f, -0.07493338f, 0.05685024f, -0.06721622f, -0.06654328f, -0.05369299f, 
    0.02263577f, -0.05328866f, -0.02380939f, 0.06457485f, -0.05742513f, 0.04459626f, 0.04212416f, -0.05692850f, 
    -0.04732043f, 0.02367267f, -0.06223647f, 0.01953870f, 0.01502510f, -0.05377023f, -0.06817660f, 0.04418054f, 
    -0.05653602f, -0.06160882f, -0.03186923f, -0.04856049f, 0.00148889f, -0.04131357f, -0.05250563f, 0.03676327f, 
    0.00808584f, -0.00752716f, -0.06579923f, -0.00538674f, -0.02599371f, -0.06885533f, 0.05285012f, -0.03018236f, 
    0.01445625f, -0.03481090f, -0.06535640f, 0.05464145f, 0.02460552f, -0.06485902f, -0.07556818f, -0.04417902f, 
    0.00677739f, -0.03260322f, -0.05428099f, -0.05198633f, -0.03843618f, -0.01217324f, -0.04274072f, -0.04297791f, 
    -0.01093239f, 0.00540193f, -0.01400810f, 0.00831007f, 0.05017800f, 0.04217203f, -0.01521116f, -0.02806288f, 
    0.04957572f, -0.01015172f, -0.02486562f, -0.02534584f, -0.01761101f, -0.04229400f, -0.07709004f, -0.01218579f, 
    -0.04144815f, -0.04601604f, 0.04130067f, 0.04381647f, 0.02804676f, 0.00305724f, 0.02434725f, 0.06228038f, 
    -0.06106855f, 0.05825914f, -0.02528163f, -0.02140870f, -0.04164704f, -0.00178849f, -0.06766538f, -0.05811757f, 
    0.05756858f, 0.04345431f, -0.00419352f, 0.03700338f, -0.00948465f, 0.02408821f, -0.02790946f, -0.07746644f, 
    -0.00063022f, 0.06089625f, 0.00303100f, -0.04239829f, 0.03147531f, 0.00058189f, -0.00175386f, 0.00312104f, 
    0.02864850f, 0.02839423f, -0.00495963f, -0.02961911f, 0.04097773f, 0.03241165f, -0.01229690f, 0.04654280f, 
    0.05730092f, 0.03650423f, -0.03453662f, -0.01338903f, -0.04097705f, 0.01928326f, -0.01615524f, -0.03924422f, 
    -0.06371736f, 0.03087097f, -0.06486444f, 0.02659856f, -0.05701265f, -0.07660424f, 0.04118323f, -0.00257586f, 
    0.02505907f, -0.06454678f, -0.03217160f, 0.00512682f, -0.05561488f, -0.00280851f, -0.01227628f, 0.00289316f, 
    0.03969266f, 0.00747101f, 0.06189682f, 0.05384123f, -0.03191484f, 0.05943930f, 0.04438908f, -0.02268980f, 
    -0.02068673f, -0.04450032f, -0.06404542f, -0.03585690f, 0.05339771f, 0.01539917f, -0.00753449f, 0.03600861f, 
    -0.23043840f, -0.00184693f, -0.09865794f, 0.04979216f, -0.00107804f, -0.06360893f, 0.01189239f, 0.04735393f, 
    0.05853920f, 0.07129074f, 0.07327833f, -0.17301551f, -0.10931930f, 0.04787291f, -0.26888108f, 0.15881060f, 
    0.12790783f, 0.04631392f, -0.16593474f, -0.08456512f, -0.02932933f, 0.09477312f, 0.06214842f, -0.03096510f, 
    0.13706894f, 0.17251952f, -0.10256029f, -0.00077342f, 0.06362034f, 0.04580871f, 0.03688696f, -0.04247091f, 
    -0.06369036f, 0.00112740f, 0.06650820f, -0.10581767f, -0.27473012f, -0.01970057f, 0.04018163f, -0.19060601f, 
    0.03057658f, 0.13057669f, -0.02260824f, -0.12106022f, 0.07866810f, -0.02137481f, -0.02608202f, 0.10399530f, 
    0.04934763f, 0.05794881f, -0.22312446f, 0.36124536f, -0.00301656f, 0.08383065f, -0.00074553f, -0.05044718f, 
    0.02816816f, -0.04953447f, 0.05331418f, 0.05531105f, -0.26316085f, -0.06576686f, 0.22124670f, 0.24211045f, 
    -0.00744530f, -0.01203828f, 0.02928104f, 0.07385858f, -0.11406316f, -0.00478106f, 0.07586224f, -0.01956815f, 
    -0.36805826f, 0.24641460f, 0.03846651f, -0.03621611f, 0.15279961f, 0.06349576f, 0.07707397f, -0.08991621f, 
    0.10962638f, -0.04445304f, -0.05678578f, 0.06251060f, -0.07887881f, 0.22064057f, 0.14803948f, -0.13627924f, 
    -0.08466345f, 0.11582173f, -0.04012218f, -0.06226748f, 0.00533673f, -0.03564028f, 0.03513120f, -0.01990477f, 
    -0.17906296f, 0.07726015f, 0.13689986f, -0.10330606f, -0.02256199f, -0.03306752f, 0.05187192f, 0.02917865f, 
    0.02523681f, 0.02921596f, 0.00013728f, -0.04040068f, 0.09793188f, 0.16623782f, 0.25886005f, -0.16920081f, 
    -0.06908816f, 0.02242458f, 0.11733458f, 0.12615189f, 0.09885908f, -0.02022110f, 0.05871563f, 0.14514026f, 
    -0.08047077f, 0.06179980f, -0.03562400f, -0.04360859f, 0.13166051f, 0.06977025f, -0.06130837f, 0.06984475f, 
    0.08335622f, -0.02890555f, 0.08601139f, -0.02248641f, 0.07350414f, -0.03078873f, -0.06039264f, 0.11262663f, 
    0.02533830f, 0.15138105f, 0.09709215f, 0.10955627f, -0.10649508f, 0.02417972f, 0.01194333f, 0.03060615f, 
    0.06416445f, 0.19509602f, 0.10166784f, -0.01777847f, -0.01739586f, -0.06926502f, 0.00161717f, -0.00847126f, 
    0.01594647f, 0.09946074f, -0.06974587f, 0.03661592f, -0.03683901f, -0.14171533f, 0.15844285f, -0.10198588f, 
    0.00276466f, -0.05312926f, -0.03212176f, 0.01811505f, 0.02075786f, -0.08154733f, 0.05140388f, 0.02914697f, 
    0.00920437f, 0.00961141f, -0.06598911f, -0.04265434f, 0.08842284f, -0.08625335f, 0.10525689f, -0.03828336f, 
    -0.04476073f, 0.14738490f, 0.03847804f, -0.07074363f, 0.00420778f, 0.11902709f, 0.07009038f, 0.08502487f, 
    0.11071043f, -0.03913527f, -0.01618664f, -0.02045758f, 0.01446717f, 0.08260003f, -0.03041188f, 0.11821839f, 
    -0.03294875f, -0.03379238f, -0.00091673f, -0.25802174f, 0.06758647f, 0.08698133f, -0.08855379f, 0.04936261f, 
    -0.01713506f, 0.02293951f, -0.07947285f, -0.02423847f, 0.26069948f, 0.04377131f, 0.18478796f, 0.29950416f, 
    -0.05476462f, -0.10039315f, 0.04428472f, 0.00809829f, 0.05507378f, 0.15144448f, -0.13317902f, -0.05970696f, 
    0.21627535f, 0.04734909f, -0.01796920f, 0.06152347f, 0.09767005f, -0.01282353f, 0.00901267f, -0.04004224f, 
    -0.06346551f, -0.04672982f, -0.00352843f, 0.00193705f, 0.35405803f, 0.05728827f, -0.08148173f, 0.12123109f, 
    -0.03637972f, -0.00292883f, 0.07889646f, 0.12009886f, 0.08625548f, -0.17101693f, -0.03899704f, -0.08410042f, 
    0.02369230f, -0.31004539f, -0.10932650f, -0.09278347f, 0.01511662f, -0.00467781f, 0.09200777f, 0.00346999f, 
    -0.01287678f, 0.09137183f, -0.00243265f, 0.02068390f, -0.03271699f, 0.04581020f, -0.14018433f, 0.13728094f, 
    0.00997578f, 0.01264505f, -0.03274772f, 0.00685601f, -0.01246932f, -0.08880378f, -0.01936295f, 0.01565897f, 
    0.08062317f, 0.15579426f, -0.00575356f, -0.23574528f, 0.04064698f, 0.03767536f, -0.06775040f, 0.11157079f, 
    0.05576814f, -0.05730227f, -0.12344172f, -0.07919642f, 0.45531914f, -0.17575362f, 0.02526635f, -0.09420090f, 
    0.15248789f, 0.03340834f, -0.05598759f, 0.03134418f, 0.05601505f, -0.04484789f, 0.00449063f, 0.02551800f, 
    0.08422474f, 0.13270359f, 0.06923615f, -0.12463596f, 0.06132414f, 0.01001873f, -0.01201345f, 0.01744596f, 
    -0.14752640f, -0.02138981f, 0.01267662f, -0.02962994f, -0.06983083f, -0.09466473f, -0.07477273f, -0.12659413f, 
    0.12647070f, -0.02260777f, -0.19977029f, -0.06771144f, -0.06436153f, -0.00169223f, -0.01097166f, -0.03317825f, 
    -0.03967468f, 0.14205094f, 0.01472065f, 0.20017837f, -0.00945292f, 0.04345348f, -0.04907635f, 0.03277421f, 
    -0.16778773f, -0.04638514f, 0.00160440f, -0.14226389f, -0.08537868f, 0.03350009f, 0.10032763f, 0.13444589f, 
    -0.03711294f, 0.07793055f, -0.06067728f, 0.17843482f, 0.12566979f, 0.08603330f, -0.02672500f, 0.04356739f, 
    0.36193955f, -0.30294913f, -0.04532977f, 0.22868824f, -0.06293823f, -0.02735284f, 0.01963486f, -0.13663386f, 
    0.08574793f, -0.07553764f, 0.01871393f, 0.06542980f, -0.02748132f, 0.09749684f, 0.06737007f, -0.05675525f, 
    0.02071024f, 0.14046259f, 0.09190171f, -0.08085369f, 0.04550141f, 0.01731927f, 0.02309550f, -0.03876750f, 
    -0.02585530f, 0.02563197f, -0.03747466f, 0.14695622f, 0.07521893f, -0.01888189f, -0.16410278f, 0.00196447f, 
    0.09259154f, -0.01901499f, 0.02717388f, -0.02854834f, 0.10542102f, 0.12224012f, 0.12042544f, 0.06149958f, 
    -0.09635532f, 0.00831048f, -0.02811733f, -0.00307909f, -0.01376043f, -0.00334122f, 0.01712228f, -0.00169432f, 
    0.04117718f, 0.09829260f, 0.21352439f, 0.05520270f, 0.08633590f, 0.02742623f, -0.06216864f, -0.12996139f, 
    -0.02174269f, -0.12586302f, 0.04275169f, -0.05796494f, 0.01649511f, 0.14343196f, 0.07752999f, 0.25917161f, 
    -0.00808327f, 0.03166519f, -0.04633009f, -0.04737953f, -0.03695413f, -0.05170191f, 0.17499995f, 0.00432166f, 
    0.18535544f, 0.18684189f, 0.03917835f, 0.04581781f, 0.00107312f, 0.00017601f, 0.08766838f, -0.02656984f, 
    0.00572980f, 0.05431140f, 0.01013866f, -0.07047289f, 0.16254726f, -0.05648792f, 0.16120553f, 0.02033431f, 
    -0.06947517f, 0.03043551f, 0.08177857f, -0.08943605f, -0.02351472f, 0.02766267f, 0.00273012f, 0.15027626f, 
    -0.10892005f, 0.00200521f, -0.22084099f, 0.32019082f, 0.10613405f, 0.02127757f, -0.04440199f, 0.07011565f, 
    0.00592912f, 0.08931205f, 0.02581980f, -0.02239736f, -0.21015495f, -0.05642157f, -0.11760671f, 0.07349384f, 
    0.06198279f, -0.04480208f, -0.10978455f, -0.06785039f, -0.12083710f, -0.10622394f, -0.04311662f, -0.06152023f, 
    0.06889943f, -0.41296619f, 0.00851589f, -0.02442166f, 0.02436162f, 0.02939943f, 0.16448843f, -0.09407166f, 
    -0.00202057f, 0.03844988f, -0.03009792f, 0.08842816f, 0.15587741f, 0.13502824f, 0.19017078f, -0.11165255f, 
    0.08381601f, -0.04533738f, 0.06502746f, 0.11589591f, -0.10164136f, 0.03236214f, 0.07728742f, 0.07278469f, 
    0.23548467f, -0.04205458f, 0.10098921f, -0.20299324f, -0.09013022f, -0.09891208f, 0.08472601f, -0.11176443f, 
    -0.00758258f, -0.12404368f, 0.05985525f, -0.08593127f, -0.12266333f, 0.04133571f, 0.12586127f, 0.05178608f, 
    -0.02681631f, 0.10345358f, 0.05824361f, -0.10245975f, -0.01583249f, -0.08660556f, -0.15999682f, -0.13344215f, 
    0.07691654f, -0.02953002f, 0.09390845f, -0.00669114f, -0.00220743f, 0.05122090f, 0.02975199f, 0.14840607f, 
    0.00384644f, 0.09766040f, -0.01170720f, 0.07006251f, 0.47010297f, 0.18115070f, -0.01963941f, 0.11372377f, 
    0.06241205f, -0.01790281f, -0.13260008f, 0.04737953f, -0.11687384f, 0.00335774f, -0.05561498f, 0.10062653f, 
    -0.20948730f, -0.01001347f, -0.02905446f, -0.00679641f, -0.05780394f, 0.04249572f, -0.02861705f, -0.01516404f, 
    -0.00694783f, -0.01763664f, 0.01117284f, -0.06665267f, 0.03324610f, -0.15047820f, 0.02862224f, 0.01755162f, 
    -0.09600598f, -0.08989623f, 0.04485463f, -0.06110331f, 0.11231841f, -0.02168198f, 0.07105651f, 0.09553287f, 
    0.05717724f, 0.09252971f, -0.00059927f, -0.12023746f, 0.05326316f, 0.06590855f, -0.00050232f, -0.07202765f, 
    -0.09918277f, 0.11995089f, 0.00771981f, -0.02235602f, 0.25881755f, 0.19881606f, -0.06064703f, -0.02350659f, 
    -0.02047389f, 0.01494256f, -0.04838999f, 0.04538899f, 0.05367174f, 0.11374597f, -0.03022802f, 0.02978040f, 
    -0.12456790f, 0.06383833f, 0.08085485f, -0.20749965f, 0.05701289f, 0.04096505f, -0.02063139f, 0.02135022f, 
    -0.07045709f, -0.10045893f, 0.07628709f, 0.02146110f, -0.04024137f, 0.06807962f, 0.15906098f, 0.26999894f, 
    -0.02477165f, -0.01489429f, -0.01815707f, -0.01257271f, 0.13200070f, 0.00005919f, 0.08064504f, 0.14188194f, 
    0.21429242f, 0.15183130f, -0.09741896f, 0.20456792f, 0.01559373f, 0.07158708f, 0.08048123f, 0.06914650f, 
    -0.01762574f, 0.07540338f, -0.03833648f, 0.15141259f, -0.10695179f, -0.16504779f, 0.17823786f, 0.11088888f, 
    0.04154773f, 0.01600514f, -0.00121295f, 0.05714938f, 0.06647871f, 0.10272630f, 0.06614820f, 0.18110083f, 
    -0.11143714f, -0.03051123f, -0.14232565f, 0.27490681f, 0.03052200f, 0.02708770f, -0.01306541f, -0.00466554f, 
    -0.01082194f, 0.12218889f, -0.02334246f, -0.06238041f, -0.02214498f, 0.08471880f, -0.16587014f, 0.06653709f, 
    0.05737199f, -0.01179723f, -0.15534022f, -0.10940056f, -0.10137164f, -0.03457155f, -0.09724846f, 0.00615983f, 
    0.00892074f, -0.21455018f, -0.05482106f, -0.07009121f, 0.11092725f, 0.00145151f, 0.18668047f, -0.01850762f, 
    0.05065155f, 0.06791529f, -0.06134233f, 0.07604957f, 0.50851882f, -0.04147092f, 0.09350407f, -0.15364800f, 
    -0.07449280f, -0.04556841f, 0.14068072f, 0.10056037f, 0.00112562f, 0.01180223f, 0.05123679f, 0.01546504f, 
    0.02680514f, -0.03335327f, -0.14444563f, -0.27133483f, -0.08002637f, -0.07993276f, -0.01647434f, 0.03594173f, 
    -0.11198216f, -0.16510808f, 0.03272410f, -0.00392322f, -0.24913533f, 0.06670992f, 0.24513352f, 0.12005028f, 
    0.07832472f, 0.19805574f, 0.08281974f, -0.15134238f, -0.02886808f, -0.02245371f, -0.07557558f, -0.10674754f, 
    0.14906505f, -0.02526234f, 0.12935382f, -0.03996772f, 0.10593286f, 0.12085633f, -0.05801872f, 0.03641569f, 
    -0.04049339f, 0.15209092f, 0.12102643f, 0.00366477f, 0.19475569f, 0.21776792f, -0.02944834f, 0.09494633f, 
    0.08941963f, -0.05581871f, -0.03264297f, 0.13811819f, -0.05505797f, 0.03563829f, -0.13401334f, 0.04806889f, 
    -0.35208932f, -0.24323469f, 0.08092195f, 0.13828135f, -0.06814932f, -0.07811795f, 0.00494049f, 0.07484830f, 
    0.07306002f, -0.07728077f, -0.00653867f, 0.04531100f, 0.04998577f, -0.00752148f, -0.03560403f, 0.01536706f, 
    -0.13368407f, 0.05162605f, 0.03244540f, 0.01318997f, 0.09061991f, 0.00852368f, 0.13758244f, 0.01108196f, 
    0.20394941f, -0.13171341f, 0.02244227f, -0.09107659f, 0.10737845f, -0.03067278f, 0.05475255f, 0.03687588f, 
    -0.07022793f, 0.10935815f, -0.04298447f, -0.08553030f, 0.23700149f, 0.30439165f, -0.04852660f, -0.07017487f, 
    -0.03542640f, -0.03597637f, 0.04727898f, 0.08223352f, 0.09257794f, 0.03379196f, -0.03718701f, -0.01054077f, 
    0.10119295f, 0.00647201f, 0.03437689f, 0.18153851f, -0.02318315f, -0.03512578f, 0.10680720f, -0.00958966f, 
    -0.02744598f, 0.02985562f, -0.03675893f, -0.14256091f, -0.05063119f, -0.04088803f, -0.09140165f, -0.29365849f, 
    0.02403437f, 0.04847651f, 0.02522204f, 0.01501130f, 0.07949620f, -0.18183221f, 0.02733049f, -0.20182964f, 
    0.04267610f, -0.01297886f, 0.11706579f, -0.06863993f, -0.11873484f, 0.05995154f, -0.02180237f, -0.05878852f, 
    -0.02832284f, -0.01224800f, -0.08184298f, -0.02410316f, 0.18346071f, -0.28501898f, -0.02118198f, -0.13369006f, 
    -0.06791825f, 0.07434744f, 0.02837586f, 0.01200194f, 0.01738409f, 0.09344906f, -0.05303966f, 0.20060344f, 
    0.12684275f, 0.25610471f, 0.07883621f, -0.00210216f, -0.09792568f, 0.19792016f, -0.01590452f, 0.09600365f, 
    -0.04809497f, 0.01013274f, -0.02656552f, 0.13732384f, 0.06144234f, 0.19242884f, -0.04078708f, -0.23296621f, 
    0.13454998f, 0.08273198f, -0.04460485f, -0.06355484f, -0.02275336f, 0.01596608f, 0.04431408f, -0.00574258f, 
    0.03980880f, 0.09438445f, 0.20281816f, 0.05803603f, 0.00735466f, -0.02590291f, 0.06782842f, 0.03010058f, 
    0.01036754f, 0.06192924f, 0.08593804f, 0.15742442f, -0.12823689f, 0.02503959f, -0.12028594f, 0.04650366f, 
    -0.02195637f, 0.08515766f, -0.08060984f, -0.09924809f, -0.04151827f, 0.03960834f, 0.13739222f, 0.02756289f, 
    0.27715155f, -0.29221937f, 0.07241323f, 0.18163134f, -0.03793929f, -0.09858800f, -0.09987008f, 0.02638347f, 
    0.03926457f, 0.04646474f, 0.08157974f, -0.07895473f, 0.15687974f, 0.17731351f, 0.10645040f, 0.13275735f, 
    -0.04572111f, 0.06682210f, 0.02621529f, 0.00972938f, 0.02762875f, -0.19661906f, -0.08704382f, -0.21260796f, 
    0.03655974f, -0.06851423f, 0.13367628f, 0.05209427f, -0.14130853f, -0.05783814f, 0.21656053f, 0.09110598f, 
    0.10244419f, 0.13769490f, -0.05398137f, -0.00204807f, 0.72192776f, 0.19362831f, 0.07096750f, -0.18202448f, 
    0.03974129f, -0.02191941f, 0.05064041f, 0.06139733f, -0.01695058f, -0.08251514f, 0.08150747f, 0.06772832f, 
    0.22651032f, 0.25574368f, -0.10796834f, 0.00523199f, 0.05579954f, -0.10013982f, -0.21176209f, -0.14639007f, 
    -0.00436800f, -0.05419114f, -0.06145692f, -0.15460680f, 0.18244866f, -0.09206801f, -0.19402552f, -0.26860252f, 
    -0.06824894f, 0.00698476f, -0.13998510f, 0.03462468f, -0.01865238f, 0.09925433f, 0.05891151f, 0.05721628f, 
    0.03209098f, 0.16321690f, 0.08133847f, -0.02427385f, 0.02205035f, 0.12105439f, -0.13915604f, -0.13158241f, 
    -0.01984273f, 0.04206401f, 0.17209822f, -0.04270896f, -0.14807785f, -0.18641652f, -0.09385068f, 0.08199097f, 
    0.00310856f, 0.07892156f, 0.00935296f, -0.07252409f, -0.12266362f, 0.02145004f, 0.06670622f, -0.16261415f, 
    0.20049012f, 0.07147003f, -0.00295590f, -0.10759981f, -0.00707953f, -0.05639325f, 0.03098039f, 0.12663937f, 
    -0.05016830f, 0.05208755f, 0.04124729f, 0.18941800f, -0.00403013f, -0.03758189f, 0.16821292f, 0.02298484f, 
    -0.06561615f, 0.03578036f, 0.14843887f, 0.02639578f, -0.06423634f, -0.12345693f, -0.04865308f, 0.06011010f, 
    -0.08020911f, 0.04663718f, 0.03194140f, 0.23953538f, 0.06883602f, 0.05324741f, -0.02707816f, 0.06270517f, 
    0.12140016f, 0.08808901f, -0.13500667f, 0.10228596f, -0.13415605f, 0.25176102f, -0.00393431f, 0.10317060f, 
    -0.06907973f, -0.00001101f, 0.13687357f, 0.07207514f, 0.00705305f, 0.05516997f, -0.02517459f, -0.04894812f, 
    -0.05791928f, 0.13709354f, 0.22016843f, 0.04930016f, 0.02470111f, -0.03209198f, 0.14860708f, -0.05148786f, 
    0.01393406f, -0.05425941f, 0.11840003f, 0.02731532f, 0.30881527f, 0.08520117f, -0.05135844f, 0.07993271f, 
    0.03277796f, 0.08885559f, 0.03538120f, -0.10450730f, 0.09522766f, -0.05446791f, 0.17754067f, 0.13593441f, 
    0.29612201f, -0.24188004f, -0.04584537f, 0.23805366f, -0.14230077f, -0.08293232f, -0.03167900f, 0.10619777f, 
    0.01757120f, 0.04626387f, -0.08555660f, -0.02234340f, -0.11337474f, -0.13452289f, -0.02608274f, -0.02031302f, 
    0.10816318f, -0.05616193f, 0.06355246f, -0.08923185f, 0.14740320f, 0.00971189f, -0.01241622f, 0.06402607f, 
    0.13874324f, 0.08262595f, -0.08741245f, 0.00034128f, 0.06921105f, -0.12942311f, 0.03611149f, 0.09792572f, 
    0.03859690f, -0.06895734f, 0.02809844f, 0.10746682f, -0.12243014f, 0.07431217f, -0.01074290f, 0.23699148f, 
    0.00920744f, -0.01251702f, -0.03701784f, 0.02993692f, 0.10955865f, 0.01887680f, -0.05320426f, 0.08594592f, 
    0.12119733f, -0.00941430f, 0.09244329f, -0.25647441f, -0.02997584f, 0.09102733f, 0.03710182f, 0.10508171f, 
    0.04260642f, -0.02301481f, 0.01308234f, 0.04568468f, 0.09377921f, -0.00434467f, -0.15828471f, -0.09216531f, 
    0.06311787f, -0.06846071f, 0.09116337f, 0.04257799f, 0.00460630f, -0.11522032f, -0.06046757f, -0.06320618f, 
    -0.58973700f, -0.02603750f, 0.07331125f, -0.04616374f, 0.17125621f, 0.04710187f, -0.13568315f, 0.04155092f, 
    0.13143642f, 0.07127183f, 0.13481550f, -0.02831111f, 0.19389005f, -0.03666835f, -0.18561628f, 0.07303205f, 
    0.05296334f, -0.08706695f, -0.03061834f, 0.03313295f, 0.04816035f, -0.02168026f, 0.09241013f, 0.12634155f, 
    0.13940503f, -0.05820854f, 0.16152775f, 0.01881116f, -0.02267686f, -0.07127883f, 0.12104499f, 0.03046621f, 
    -0.06206367f, 0.06618825f, -0.00270654f, 0.15894812f, 0.15243378f, 0.06668189f, -0.05035079f, -0.15542476f, 
    0.03697952f, 0.03679822f, 0.10920930f, 0.05809179f, 0.03284570f, -0.03091769f, -0.02708755f, 0.04037938f, 
    0.34813544f, -0.00129378f, 0.08803702f, -0.09092747f, 0.03826556f, 0.04520014f, 0.03551469f, 0.07207328f, 
    0.01141352f, 0.01516628f, -0.05146872f, -0.00080709f, -0.08445498f, -0.08915539f, 0.14886346f, -0.03900026f, 
    -0.22184214f, 0.02284535f, 0.10805512f, 0.09726626f, 0.03878034f, -0.01722681f, 0.00620813f, -0.00613951f, 
    -0.18043046f, -0.11625704f, -0.06095666f, -0.03593496f, -0.00243517f, -0.07967769f, -0.10009767f, 0.06774891f, 
    0.11398950f, -0.02003017f, 0.06167137f, 0.08895868f, -0.06110570f, -0.08347215f, -0.07763062f, 0.00611564f, 
    0.10303718f, 0.01038131f, 0.10327617f, 0.05298862f, 0.09770794f, -0.07740738f, 0.05411016f, -0.05741845f, 
    0.13632829f, -0.21341218f, 0.14871170f, -0.05588828f, 0.09452989f, -0.01378309f, 0.07849573f, -0.06684203f, 
    0.01170952f, 0.07686982f, 0.10626996f, 0.09945442f, -0.11244102f, -0.07101820f, -0.05189962f, 0.00622567f, 
    -0.01984380f, 0.04982731f, -0.02531146f, 0.05618385f, 0.02530423f, 0.04708776f, 0.00063999f, -0.01774671f, 
    0.03852811f, -0.02333397f, -0.12755494f, 0.13738374f, 0.02284584f, -0.10709769f, -0.05592546f, 0.10986824f, 
    0.12674005f, -0.05470167f, 0.19725630f, 0.03182774f, 0.16029561f, 0.04326096f, -0.00467970f, 0.03470852f, 
    0.24558374f, 0.01378170f, 0.10840528f, 0.03359849f, 0.04104551f, 0.10048452f, 0.05700447f, 0.10664497f, 
    0.10521628f, -0.06205716f, 0.00257188f, 0.04551728f, 0.12518154f, -0.00086616f, 0.00878229f, 0.05389627f, 
    -0.06089728f, -0.01429235f, 0.05099760f, 0.07207298f, -0.04713022f, -0.17860600f, -0.16628040f, 0.17013086f, 
    0.05097911f, 0.02293928f, -0.00333838f, -0.01010079f, -0.04225772f, 0.04245652f, 0.03462344f, 0.03801820f, 
    -0.01728055f, 0.02146838f, 0.00738781f, -0.07377254f, -0.04412249f, -0.03389262f, 0.13550061f, 0.03491936f, 
    0.01579017f, 0.01142025f, 0.08637232f, 0.00015539f, -0.08130560f, -0.09118884f, -0.17363548f, -0.14782831f, 
    -0.00582268f, 0.10782818f, -0.00882770f, 0.06040287f, 0.05349261f, -0.02536003f, -0.03454756f, 0.06096726f, 
    0.56364602f, 0.19528086f, 0.05337119f, 0.21841682f, 0.11943262f, 0.13492285f, 0.02863226f, -0.00358433f, 
    0.11920795f, -0.06644139f, 0.11983299f, 0.04752836f, 0.09039859f, 0.05573848f, -0.02815698f, -0.01825890f, 
    0.09184302f, 0.03683913f, 0.12518069f, 0.07350118f, 0.09198818f, 0.12162351f, 0.10046283f, 0.09984376f, 
    -0.13947757f, -0.02519885f, -0.10008005f, 0.03313786f, -0.08994291f, 0.00346820f, -0.11333069f, 0.01335598f, 
    0.02354549f, -0.15180250f, -0.05039354f, 0.12686867f, -0.03588966f, -0.20089783f, -0.01149737f, -0.11224630f, 
    -0.04231410f, 0.08154824f, -0.05589537f, -0.10755225f, 0.06717510f, -0.05033858f, 0.07415789f, -0.02359420f, 
    0.12696740f, -0.08872998f, -0.00665138f, -0.21060115f, 0.03094760f, 0.04450760f, -0.08772115f, 0.12060548f, 
    -0.00257524f, 0.08182041f, 0.07812198f, 0.14939338f, 0.11203805f, -0.01780103f, 0.29755265f, 0.27124667f, 
    -0.15688404f, 0.01319275f, 0.01575102f, -0.08682052f, -0.04558796f, 0.00513017f, -0.17685516f, -0.07154730f, 
    0.13970506f, 0.13222630f, -0.11047068f, 0.12248932f, 0.06754734f, 0.01698349f, -0.14719059f, -0.04345647f, 
    0.11525175f, 0.20802642f, -0.07392407f, -0.01278560f, 0.13115871f, 0.20949617f, -0.19310497f, 0.24437629f, 
    0.11620747f, 0.04783439f, 0.14629398f, 0.01224678f, 0.07086504f, -0.04900755f, -0.10743868f, -0.06669978f, 
    -0.02577837f, 0.03094511f, 0.06741973f, -0.02614420f, -0.05222484f, -0.04922039f, -0.08028930f, 0.02265788f, 
    0.09299975f, -0.07972174f, 0.07283834f, 0.07076222f, 0.19447401f, 0.14901982f, -0.18425991f, 0.07150672f, 
    0.01758114f, 0.03036272f, -0.05381296f, -0.01580907f, 0.18762387f, 0.07500552f, -0.02515831f, 0.09950938f, 
    0.08975458f, 0.05614305f, 0.03628828f, -0.11556644f, -0.00771276f, -0.14710630f, 0.10170586f, 0.03176291f, 
    0.05438795f, 0.05725574f, -0.08908856f, -0.03272128f, 0.13002084f, -0.18472993f, -0.12509938f, -0.10969062f, 
    0.18698099f, -0.03350665f, -0.00063713f, -0.01900614f, 0.06226043f, -0.00250471f, -0.03193868f, 0.01560459f, 
    0.00436750f, 0.04772548f, 0.16717443f, 0.05983754f, -0.00573284f, -0.02036845f, 0.00579209f, 0.01515181f, 
    -0.03436238f, 0.04958490f, 0.02693414f, 0.08146445f, -0.23675855f, -0.12824339f, -0.09261675f, -0.01875835f, 
    -0.02097228f, -0.13434502f, -0.06833226f, 0.02178890f, 0.07947740f, 0.01504794f, -0.02156815f, 0.01705606f, 
    0.00943026f, 0.10273734f, 0.04074610f, 0.01276865f, -0.02635345f, 0.12357286f, 0.06703873f, 0.03028847f, 
    -0.01899280f, -0.07616338f, 0.03610798f, -0.09567758f, -0.02032804f, -0.05537313f, 0.07174519f, 0.17944954f, 
    0.05968997f, 0.14434138f, 0.08058494f, 0.15978907f, 0.05215085f, -0.07289740f, 0.01229903f, 0.12753458f, 
    0.16279244f, -0.32828206f, -0.24032789f, 0.13507621f, 0.11518736f, 0.01663566f, 0.01271524f, -0.06893142f, 
    0.01161838f, -0.07175879f, 0.08347374f, 0.15099750f, -0.06513898f, -0.05404496f, -0.06302295f, -0.20970674f, 
    0.03984135f, -0.05174022f, 0.05561022f, -0.00399548f, -0.11652795f, 0.02851855f, -0.02452036f, -0.01244181f, 
    -0.01060652f, -0.03842326f, 0.26646736f, 0.10139231f, 0.01625063f, -0.07876578f, -0.09319667f, 0.01440086f, 
    0.06403010f, -0.06629442f, -0.06227799f, -0.05406046f, 0.15332593f, 0.15628046f, -0.05362309f, -0.05880827f, 
    -0.05681345f, -0.00017869f, 0.09740186f, -0.01599473f, 0.02841563f, 0.05354975f, 0.07858481f, 0.00630167f, 
    -0.02047388f, -0.05531111f, 0.04384447f, -0.08276672f, 0.04124455f, 0.03799631f, 0.00591949f, -0.00788487f, 
    -0.06954222f, 0.02694754f, -0.01927769f, -0.00576388f, 0.01082179f, 0.02015214f, -0.04505405f, -0.00550004f, 
    0.04699682f, -0.01783587f, 0.00115643f, 0.00060667f, -0.03180052f, -0.08253172f, 0.03276166f, -0.07292044f, 
    -0.05120561f, -0.03171776f, -0.03985732f, -0.05662260f, -0.06384165f, 0.01238062f, 0.03514926f, 0.02099505f, 
    -0.04191472f, 0.06438567f, -0.03534345f, -0.01276842f, 0.04224499f, -0.09848227f, 0.01672520f, -0.06883363f, 
    0.04521626f, 0.02637137f, -0.02453920f, 0.04251212f, 0.03660708f, -0.02146081f, 0.03339452f, -0.00463868f, 
    0.03903326f, 0.02629652f, -0.03096180f, 0.02798540f, -0.01621592f, -0.00083429f, 0.01017848f, 0.02412624f, 
    -0.07426648f, -0.01114788f, -0.04303604f, -0.07709246f, -0.06241996f, -0.08641575f, 0.02392370f, -0.05046363f, 
    0.03744482f, 0.02778469f, -0.00692313f, 0.02583408f, -0.01276704f, -0.04487346f, 0.03816657f, -0.07584400f, 
    0.04361301f, -0.06531303f, -0.00327113f, 0.03449321f, -0.04202410f, -0.05802627f, 0.03156977f, -0.00065616f, 
    0.02024664f, -0.05430261f, -0.02557690f, -0.05879488f, 0.00240294f, 0.05457849f, -0.03080112f, -0.04877119f, 
    0.03400914f, -0.06427383f, -0.08451653f, 0.04185737f, -0.01441853f, -0.04880819f, -0.05141630f, 0.03834380f, 
    -0.03544431f, -0.03003876f, -0.09984220f, 0.01408004f, 0.00179972f, 0.03737465f, -0.08646737f, -0.07335266f, 
    -0.08032946f, 0.00002739f, -0.08406056f, 0.02097219f, 0.02600578f, -0.01453152f, 0.02983247f, 0.03425551f, 
    -0.04484511f, 0.02220160f, 0.02485274f, -0.08111551f, -0.03462706f, 0.01002063f, -0.00026341f, -0.00713456f, 
    -0.09572671f, -0.04140624f, -0.01187583f, -0.04791785f, -0.07846303f, -0.04884439f, -0.00379659f, -0.02641099f, 
    -0.00240225f, -0.07223444f, 0.00959711f, -0.05218139f, -0.03082068f, -0.08729862f, -0.04960768f, 0.01720864f, 
    -0.05937203f, -0.08753730f, -0.01367372f, -0.02055317f, -0.03874199f, -0.04640930f, -0.08124487f, -0.04941369f, 
    -0.06721776f, -0.02844133f, -0.01633734f, 0.04507458f, -0.03824702f, -0.02888308f, 0.03577078f, 0.04158422f, 
    0.05152358f, -0.06004973f, 0.00299135f, -0.03334757f, -0.02388611f, 0.03868511f, -0.01779552f, -0.08422149f, 
    -0.04000196f, 0.00583961f, 0.05159663f, 0.03736638f, -0.07722916f, 0.04002117f, -0.04446515f, 0.04090692f, 
    -0.00076537f, -0.02152023f, -0.02150885f, -0.02948594f, -0.06841341f, -0.05328409f, -0.05567737f, -0.02271564f, 
    0.03959559f, 0.01151204f, -0.03721195f, 0.01152136f, -0.03585718f, 0.01283632f, 0.04887815f, 0.05537826f, 
    0.02929659f, -0.07415614f, -0.05362482f, -0.09649100f, -0.04075842f, 0.05014798f, -0.05246324f, -0.05919452f, 
    0.05091205f, -0.07915249f, -0.10604078f, 0.17582977f, 0.08017793f, -0.04414218f, 0.05336833f, -0.02223442f, 
    -0.14975087f, -0.03347949f, -0.06468999f, 0.05971413f, -0.04878866f, 0.02229005f, -0.02569460f, -0.06064368f, 
    -0.08242228f, -0.10297596f, 0.01071549f, -0.02112696f, 0.05176944f, -0.00434372f, -0.03976944f, 0.10048162f, 
    -0.07973295f, 0.00517792f, 0.08665617f, -0.15493162f, -0.05795469f, -0.01841270f, 0.12718169f, 0.00289883f, 
    0.08266132f, -0.03207595f, 0.15675919f, -0.00179775f, 0.15216306f, 0.06583751f, -0.15113935f, 0.01299706f, 
    0.07721444f, 0.03861619f, 0.08143375f, 0.02153012f, 0.07968097f, -0.08752755f, 0.09419423f, 0.15963244f, 
    0.04614751f, -0.19829118f, -0.23862669f, 0.23325038f, -0.05771101f, 0.15544130f, -0.07411351f, 0.04395090f, 
    0.01964644f, 0.11782236f, -0.01825323f, 0.06862693f, -0.17829569f, -0.05155889f, -0.13022269f, 0.07217831f, 
    0.01875434f, 0.08518523f, 0.01528838f, 0.10865571f, 0.05140150f, -0.00517779f, -0.02581302f, 0.03187262f, 
    -0.20332222f, 0.04348735f, -0.07975778f, -0.01933553f, 0.11315840f, 0.00030879f, -0.05112382f, 0.06954706f, 
    0.06530335f, 0.08707479f, 0.14396188f, 0.01651193f, -0.00610073f, 0.03656000f, 0.20233497f, 0.02154561f, 
    -0.00611842f, 0.06684874f, -0.00305643f, 0.06644890f, 0.14777142f, 0.02593943f, 0.04803722f, -0.01199031f, 
    0.30249530f, -0.08985315f, -0.23455156f, 0.02698969f, 0.18173485f, 0.03262546f, -0.01857693f, -0.02513934f, 
    -0.03112983f, 0.01264766f, 0.01018273f, 0.06384067f, -0.08032566f, -0.06741036f, -0.10132121f, -0.03319110f, 
    -0.12123255f, -0.13299650f, -0.06939510f, -0.00924943f, 0.01003271f, 0.02252326f, -0.01863447f, -0.01837014f, 
    -0.16521721f, 0.05672199f, -0.00329515f, -0.05977828f, -0.03061921f, 0.01093606f, 0.04221197f, -0.06785351f, 
    -0.01680198f, -0.00331842f, 0.13834460f, 0.01505313f, -0.21056312f, -0.13900611f, -0.02297286f, 0.11328066f, 
    -0.13814059f, -0.02685471f, 0.05394321f, -0.08036762f, 0.00052614f, 0.13796946f, 0.03205184f, 0.03444450f, 
    0.36883792f, 0.22135022f, 0.18203530f, -0.00767544f, -0.00682715f, -0.03242362f, 0.04634944f, -0.02588415f, 
    0.16492456f, -0.00137893f, -0.00719749f, -0.06479000f, 0.24877064f, -0.14231037f, 0.01836868f, 0.09467803f, 
    -0.08627288f, 0.08252296f, -0.04815003f, 0.12427177f, 0.07174933f, 0.02281809f, 0.06982096f, 0.03095567f, 
    -0.10123774f, -0.02205076f, -0.10303952f, -0.11549530f, 0.00367008f, -0.00013391f, -0.08148463f, -0.04093521f, 
    0.01101653f, -0.08580866f, 0.04845928f, 0.16491668f, 0.11409168f, 0.04085419f, 0.03496194f, -0.16188441f, 
    0.16228959f, -0.01692449f, 0.07919310f, -0.02267243f, -0.03698727f, -0.02487549f, 0.12742178f, 0.10218925f, 
    -0.07590180f, 0.03604111f, -0.16734938f, -0.06945209f, 0.06913514f, -0.16903368f, 0.05961829f, 0.13495879f, 
    0.03857586f, 0.07467344f, 0.07963105f, 0.09000646f, -0.01267241f, 0.12090899f, 0.00810138f, 0.12007059f, 
    -0.08491362f, 0.00912097f, -0.12768348f, -0.08728727f, -0.07669870f, 0.09490265f, -0.03644015f, 0.17801005f, 
    0.00889369f, 0.01026255f, 0.14172488f, 0.19683053f, 0.00393679f, 0.08660591f, 0.02389162f, 0.11417872f, 
    0.07142648f, 0.03802216f, -0.02243945f, -0.04147317f, -0.12706834f, 0.22629336f, -0.10141163f, -0.07424792f, 
    -0.20416225f, 0.07958252f, 0.02017727f, -0.00528488f, 0.04706307f, -0.04571255f, 0.06006743f, -0.06732934f, 
    0.03832775f, 0.42082661f, -0.05931129f, 0.03200272f, 0.07366847f, -0.02788328f, 0.06351092f, 0.03959610f, 
    0.12928255f, -0.14088735f, -0.05946362f, -0.01155317f, 0.01205503f, 0.17229302f, 0.20548294f, 0.12558180f, 
    0.04566594f, -0.01699942f, -0.00808320f, -0.06927720f, 0.06190735f, 0.08413524f, 0.16323501f, 0.12784441f, 
    -0.17283730f, 0.24885067f, 0.04189761f, -0.14500791f, -0.01454884f, -0.09169123f, 0.00984916f, -0.02579945f, 
    0.02677116f, -0.06859060f, -0.12652321f, -0.09860875f, 0.20580360f, -0.27785879f, 0.04027779f, 0.17175294f, 
    -0.04964697f, -0.09850664f, -0.06905871f, -0.10350926f, 0.07649863f, 0.11201660f, 0.03176312f, -0.13915256f, 
    -0.26708761f, 0.11259203f, 0.02623257f, -0.11492986f, -0.09871436f, -0.00328403f, 0.06951147f, 0.02378681f, 
    0.07909732f, -0.01731485f, -0.01923560f, 0.01747020f, -0.06181384f, -0.01264612f, 0.02843648f, 0.00969649f, 
    0.05305823f, -0.04558709f, 0.04354687f, 0.07734447f, 0.09323980f, 0.10476642f, 0.03012800f, 0.19000503f, 
    -0.09957123f, 0.06543728f, 0.01935500f, -0.11493780f, -0.06694011f, -0.00335040f, -0.11817390f, 0.07478843f, 
    0.07570387f, -0.19884703f, 0.02769703f, 0.12377898f, 0.02675028f, 0.03447324f, 0.14381748f, 0.00705374f, 
    -0.07544366f, -0.08300337f, 0.13894390f, -0.10946596f, -0.09313480f, 0.00487365f, 0.05265304f, 0.03118042f, 
    -0.43042442f, -0.24333493f, 0.07305039f, 0.15781419f, 0.05341839f, 0.12539469f, -0.00865169f, -0.05291472f, 
    -0.02701943f, 0.14923412f, 0.07780199f, 0.20271446f, -0.03732311f, 0.10026134f, 0.01183246f, 0.10208239f, 
    -0.05283109f, -0.07414171f, -0.08541707f, 0.08444088f, -0.01105196f, -0.05905959f, -0.10875846f, -0.13721594f, 
    -0.00806026f, -0.07771115f, 0.13139439f, -0.10608713f, 0.10310759f, -0.10323209f, 0.21963221f, -0.03410309f, 
    -0.00974808f, 0.11935271f, 0.05831810f, 0.19818798f, 0.15916000f, 0.15728502f, 0.05090244f, -0.02453068f, 
    0.11910211f, -0.09988470f, -0.02987687f, 0.02106994f, 0.01306205f, 0.12478080f, -0.03175376f, 0.26229003f, 
    -0.10326342f, -0.00675521f, 0.02113430f, 0.03566221f, 0.05200990f, 0.10306124f, -0.07504489f, -0.09108993f, 
    -0.04134585f, 0.08781932f, -0.05626034f, -0.02568284f, 0.14889209f, 0.01150885f, 0.18005386f, 0.02183339f, 
    0.02671946f, 0.11480537f, 0.05113572f, 0.01332474f, 0.01024173f, -0.02720678f, 0.03026650f, -0.14014313f, 
    0.28208336f, 0.05179546f, 0.05181151f, -0.10184896f, 0.04922063f, 0.03247054f, -0.02702877f, -0.09519181f, 
    -0.08794394f, 0.00223397f, 0.00761626f, -0.03185760f, 0.37262499f, -0.13444558f, 0.10522411f, -0.11953615f, 
    -0.05746142f, 0.04579995f, 0.11907105f, 0.00491116f, 0.00248780f, 0.04784575f, 0.08262854f, 0.20582481f, 
    0.04636219f, -0.29333419f, -0.03524255f, -0.01093693f, -0.04690403f, 0.07495787f, 0.00770201f, -0.00425854f, 
    -0.00912533f, -0.00950158f, -0.09108526f, 0.01629752f, -0.10453912f, 0.01817315f, -0.12722510f, -0.14562277f, 
    0.13833298f, 0.14035209f, -0.05478087f, 0.02185892f, -0.03634056f, 0.02921413f, -0.05727241f, -0.02941970f, 
    0.06010856f, -0.04240160f, 0.00905437f, -0.02305627f, 0.04806168f, 0.07086942f, -0.06016220f, 0.05068696f, 
    -0.03425732f, 0.06687627f, 0.07279074f, 0.22534570f, 0.14530180f, -0.15234318f, -0.08552136f, -0.05586581f, 
    -0.03300686f, 0.01242663f, -0.12338281f, 0.14475825f, -0.00759939f, 0.02180101f, 0.08281486f, -0.00195106f, 
    0.41495526f, -0.04517178f, 0.14788353f, 0.06036204f, 0.11041340f, 0.00951438f, -0.12049545f, -0.00687737f, 
    -0.02071311f, -0.03636993f, 0.06908402f, 0.00551940f, 0.03022497f, 0.15053396f, 0.06019425f, 0.06068824f, 
    0.06151288f, 0.02698618f, -0.08272011f, -0.02448257f, -0.09255298f, -0.10369151f, -0.09220406f, -0.15508831f, 
    -0.01543299f, 0.15427379f, 0.10549100f, 0.15214972f, -0.09610904f, 0.06863020f, 0.17304203f, -0.03001021f, 
    -0.04253596f, 0.13352495f, -0.06529064f, -0.21102417f, 0.45042649f, 0.20467919f, 0.04003704f, 0.10292463f, 
    0.02081887f, 0.10819087f, -0.04794801f, 0.12345047f, 0.02150984f, 0.03945878f, 0.00150300f, 0.07074206f, 
    0.35697389f, -0.02544411f, -0.13018849f, -0.12105748f, -0.08703095f, -0.13100788f, 0.04958849f, -0.00038203f, 
    0.10961752f, -0.04353605f, 0.06605084f, -0.00961512f, 0.05908271f, -0.12948073f, -0.09882713f, -0.06135875f, 
    -0.02945344f, 0.09431953f, 0.05356853f, 0.02509904f, 0.02161903f, 0.13534597f, -0.04835900f, 0.12973382f, 
    0.02678499f, 0.20338945f, 0.06165833f, 0.05325125f, -0.04674350f, 0.24724431f, -0.27153611f, -0.09456078f, 
    0.02321478f, 0.04561488f, 0.10556641f, -0.06369169f, 0.11014439f, 0.09643885f, 0.07154864f, -0.01575856f, 
    -0.04024144f, -0.02742396f, -0.02472250f, 0.02343406f, -0.08793511f, -0.07011988f, 0.02796696f, -0.15376586f, 
    -0.22308330f, 0.05967058f, 0.19141813f, 0.10429174f, -0.00186832f, -0.01257585f, -0.00651029f, 0.06269319f, 
    0.04810276f, -0.03593853f, -0.14091183f, -0.05201027f, -0.06488300f, -0.04276710f, -0.26172680f, -0.10140474f, 
    0.02204704f, 0.06974496f, -0.03945734f, 0.03376870f, -0.07587869f, 0.02703094f, 0.05798056f, 0.04121125f, 
    0.22464237f, 0.29072514f, -0.22344036f, -0.18831041f, 0.06252321f, 0.11787119f, -0.05833738f, 0.00223017f, 
    -0.06536879f, 0.01720293f, -0.02238889f, 0.09861557f, -0.11621523f, -0.15306598f, -0.16869411f, 0.13268536f, 
    0.14528844f, 0.00569407f, -0.08047517f, 0.00935561f, -0.01217617f, 0.20898578f, -0.00597038f, 0.09343396f, 
    -0.02864478f, -0.09409036f, 0.12180049f, 0.27051637f, -0.11148596f, 0.10269161f, -0.08404520f, 0.13899709f, 
    -0.11348651f, 0.09500125f, 0.04149227f, -0.05263621f, 0.20626247f, -0.13168047f, -0.07228181f, 0.18246408f, 
    -0.07295370f, 0.10120316f, 0.10544438f, 0.13186434f, -0.10374632f, -0.07176053f, -0.00638344f, 0.09831923f, 
    -0.20060255f, -0.08348388f, 0.02812820f, -0.02507056f, 0.04658505f, -0.05797102f, 0.20189613f, -0.03146406f, 
    -0.02590432f, 0.09244411f, -0.12096173f, 0.00867030f, -0.27924013f, 0.15651320f, 0.02189532f, -0.08304546f, 
    -0.05007456f, 0.01476268f, 0.11636230f, 0.04454992f, 0.04631842f, 0.03418327f, -0.00867607f, 0.14245184f, 
    -0.01721873f, 0.20981216f, -0.19448641f, 0.16024394f, 0.05998813f, -0.03161250f, 0.02287304f, 0.01573078f, 
    0.06088337f, -0.04336504f, 0.02517658f, -0.14462744f, -0.10881219f, 0.18772443f, 0.25296044f, -0.11280510f, 
    0.03524143f, 0.16572310f, 0.21641243f, 0.05289607f, 0.08723378f, -0.09207749f, -0.12144721f, -0.03544732f, 
    0.14001751f, -0.14554158f, 0.08044276f, -0.07677981f, 0.08467280f, 0.05016955f, 0.01648838f, 0.04061224f, 
    0.03295075f, 0.10575705f, 0.03961288f, 0.09759384f, -0.00793792f, -0.01005305f, -0.00081539f, 0.00118020f, 
    0.00503527f, 0.05423974f, -0.11850475f, 0.10974308f, -0.01143447f, -0.06694990f, 0.04938640f, -0.02805196f, 
    -0.06906272f, -0.03622137f, 0.02547213f, 0.08950203f, -0.09385366f, 0.05738040f, -0.03621920f, 0.09323443f, 
    -0.02802533f, 0.00158657f, -0.12625079f, -0.21749899f, -0.14371726f, 0.03207489f, 0.05984800f, -0.13255437f, 
    -0.06723706f, -0.05635624f, 0.10631401f, -0.01946244f, 0.00428502f, 0.06116122f, 0.04466581f, 0.07836515f, 
    0.11108366f, -0.05598710f, 0.01336859f, -0.03787284f, 0.10508295f, -0.11695971f, -0.04474833f, 0.07839506f, 
    -0.07982060f, -0.07260329f, -0.02191133f, 0.01125499f, 0.07924482f, 0.23584580f, -0.11238346f, 0.15393731f, 
    -0.04502236f, 0.09677380f, -0.03193795f, 0.08705068f, -0.03523511f, 0.00036656f, 0.04720159f, 0.04877293f, 
    -0.08338986f, -0.00692320f, -0.03070584f, -0.04287258f, -0.06795345f, -0.07700814f, -0.07307908f, -0.01470152f, 
    -0.02807051f, -0.01468873f, -0.01390416f, 0.05276502f, 0.02871932f, -0.00336030f, 0.01898428f, 0.01019894f, 
    0.04133879f, 0.04181218f, 0.00980017f, -0.03967559f, -0.06563520f, 0.01393112f, -0.03161850f, 0.05739636f, 
    0.03426412f, 0.02137731f, -0.05378673f, 0.03317545f, -0.01721311f, -0.04863301f, 0.02658894f, 0.05493494f, 
    -0.04248301f, 0.04571033f, 0.01149471f, -0.02609400f, 0.01775609f, -0.03261652f, -0.03561265f, -0.06513833f, 
    0.02928601f, -0.05533256f, -0.07663464f, -0.07411540f, -0.03593055f, -0.01937868f, 0.04149916f, -0.05126449f, 
    0.03456185f, -0.08301597f, -0.05866069f, 0.05615048f, -0.03785967f, 0.04425447f, 0.05534089f, -0.00457386f, 
    0.03287461f, -0.06511657f, 0.04988270f, -0.05540816f, -0.05135138f, -0.07847276f, 0.04654944f, 0.01752574f, 
    0.00714922f, 0.01071669f, 0.00208162f, -0.04567451f, -0.00436372f, -0.02844491f, -0.02539799f, -0.07339462f, 
    -0.03322339f, 0.00121218f, -0.04151790f, 0.00983484f, -0.07234374f, 0.03387452f, 0.00619794f, 0.05076186f, 
    0.02663118f, 0.05495610f, 0.03088937f, -0.07546578f, -0.05665082f, 0.00334224f, -0.06786228f, 0.02627151f, 
    -0.05541780f, -0.03773577f, -0.00799527f, -0.01634747f, 0.03022460f, 0.04253441f, -0.03983492f, 0.04765212f, 
    -0.01636522f, 0.05127232f, 0.02562659f, 0.00538156f, 0.01965284f, -0.04448080f, 0.05583407f, -0.05842883f, 
    -0.06774896f, -0.02171178f, 0.04758199f, 0.02933313f, 0.00224991f, 0.04092283f, -0.00169025f, 0.01118166f, 
    -0.00177912f, -0.03020147f, 0.00438268f, -0.01510307f, 0.00111404f, 0.00121395f, -0.00066371f, -0.04121188f, 
    0.04914873f, -0.02456290f, 0.00028848f, 0.03463756f, 0.02863710f, -0.03437461f, -0.06917997f, -0.08399414f, 
    -0.00601010f, 0.05673080f, 0.03151771f, 0.02553184f, 0.02424172f, 0.01334183f, -0.05729115f, -0.03335084f, 
    -0.01392038f, 0.00878243f, 0.03924716f, -0.03251825f, 0.01743210f, 0.00313265f, -0.00712045f, -0.05851361f, 
    -0.07184219f, 0.03138980f, -0.01642442f, -0.00734778f, -0.06917939f, -0.06259138f, -0.03491694f, -0.04908356f, 
    -0.01994279f, 0.01277422f, -0.06189972f, 0.01201447f, -0.01624973f, -0.05381585f, 0.03169795f, -0.03123789f, 
    0.00891462f, 0.03221478f, -0.03214396f, 0.02140888f, -0.06379040f, 0.02419310f, 0.03475776f, 0.05785035f, 
    -0.03747265f, 0.01865559f, 0.02368705f, -0.03500226f, 0.05808437f, -0.00842050f, -0.02880534f, 0.02757086f, 
    -0.00949973f, 0.01084021f, -0.05563153f, 0.04994985f, -0.02524605f, -0.06200053f, 0.01670588f, -0.02769027f, 
    -0.07840703f, -0.08012517f, -0.02216514f, -0.02487304f, -0.01632141f, 0.05889206f, 0.01777481f, 0.00455424f, 
    0.01178850f, 0.05033264f, -0.03869142f, -0.04655249f, 0.00727690f, 0.01551322f, -0.01622936f, -0.04263070f, 
    0.06516168f, -0.03218956f, 0.05006117f, -0.05272418f, -0.07593024f, 0.01217458f, 0.01932075f, 0.03395877f, 
    0.00214090f, 0.06018472f, -0.02051866f, 0.01115279f, -0.07563555f, 0.00399242f, -0.04533559f, -0.05226224f, 
    0.01704761f, 0.06867397f, 0.04698178f, -0.03436989f, -0.06253774f, -0.00555480f, -0.00864771f, -0.01323126f, 
    0.05065443f, -0.06259888f, -0.05901346f, -0.07505487f, -0.01070781f, -0.01761643f, -0.08280791f, -0.05390736f, 
    -0.02177336f, -0.01128287f, -0.01554248f, -0.05096957f, -0.04667760f, -0.06775579f, 0.00229998f, 0.04643198f, 
    -0.03452143f, -0.08432189f, -0.01379320f, -0.04526537f, -0.00720559f, 0.03254620f, -0.04462336f, -0.06603909f, 
    -0.05297194f, -0.04147696f, -0.00830150f, -0.03704659f, 0.01697030f, -0.07142913f, -0.02469610f, 0.02314614f, 
    0.01675791f, -0.05234046f, -0.04477225f, -0.01996820f, -0.07385146f, 0.03492441f, 0.01207870f, 0.03335509f, 
    0.02023075f, 0.00463755f, -0.01176486f, 0.02977365f, -0.00863521f, 0.01057892f, -0.02805268f, 0.01094159f, 
    0.03322892f, -0.07084566f, 0.06817551f, -0.05733030f, -0.03255825f, 0.00858867f, -0.02019804f, 0.01545366f, 
    -0.05642293f, -0.05511000f, -0.05297726f, 0.00644946f, -0.02012423f, -0.00148636f, -0.00838877f, -0.07146826f, 
    0.02673605f, 0.01909225f, 0.00776254f, 0.06064774f, -0.03861808f, 0.02417811f, 0.02280018f, -0.07075244f, 
    0.00043683f, 0.02163296f, -0.01008618f, -0.06725825f, 0.04554529f, -0.04856629f, 0.00857257f, 0.03395325f, 
    0.04293552f, 0.02076269f, 0.05985233f, 0.06952043f, 0.04879659f, 0.05807062f, -0.05529407f, -0.01464486f, 
    0.01394872f, 0.02129760f, 0.04324488f, 0.01436039f, -0.05469208f, -0.04303508f, -0.05672469f, -0.04378897f, 
    -0.01051013f, -0.06307028f, 0.04215430f, 0.03794126f, 0.03644649f, -0.06439842f, -0.03815855f, 0.04504447f, 
    -0.07059900f, 0.02724665f, 0.01869611f, 0.01485200f, -0.02742712f, 0.04798572f, 0.03247783f, 0.02424743f, 
    0.02315358f, 0.02710378f, -0.00943382f, -0.02925661f, 0.02846797f, 0.03103473f, -0.07123900f, -0.05873897f, 
    0.05500681f, -0.04368090f, 0.00665438f, -0.04488632f, 0.06882659f, 0.00268034f, -0.05957412f, -0.06706046f, 
    0.04131558f, -0.01265619f, 0.02506693f, 0.02345245f, -0.06778510f, 0.02688603f, -0.00374999f, -0.07333074f, 
    -0.02512708f, -0.07080322f, 0.04936755f, 0.03335166f, -0.04597571f, 0.02808728f, -0.04941261f, 0.00253193f, 
    -0.07221167f, -0.07460956f, -0.06832264f, 0.01609772f, 0.01052665f, 0.05158673f, 0.02441485f, -0.04548125f, 
    0.05037832f, -0.03315207f, -0.05190551f, -0.01660407f, -0.00034268f, -0.05416015f, 0.00347639f, -0.05955045f, 
    0.02863187f, 0.01710946f, -0.12912384f, 0.06959757f, 0.02868168f, 0.02858999f, 0.07674187f, 0.02606403f, 
    0.09394088f, -0.00533344f, 0.05906703f, -0.10316492f, -0.05552450f, -0.14690165f, -0.24458462f, -0.17922679f, 
    0.04128571f, -0.03759046f, 0.00888856f, 0.13214633f, -0.06578250f, 0.07480223f, -0.02748599f, -0.03282396f, 
    -0.15670896f, -0.13038008f, 0.07495332f, -0.07706671f, 0.00944955f, -0.01510880f, -0.03613891f, 0.04160928f, 
    0.09120850f, -0.10038491f, 0.11107552f, 0.07157890f, -0.28968173f, -0.14831737f, -0.18647614f, -0.05627124f, 
    0.12835482f, 0.02087349f, 0.00794821f, -0.01454017f, 0.06589455f, 0.08083635f, -0.03565347f, 0.03891275f, 
    0.24961847f, 0.06304845f, 0.08787615f, -0.17028746f, 0.10297791f, 0.10409673f, 0.04037301f, 0.04170819f, 
    -0.02002905f, 0.01563092f, 0.13573675f, 0.11614176f, -0.12899064f, 0.00201470f, 0.12021093f, -0.01288106f, 
    0.03542554f, 0.03819440f, 0.08666687f, 0.08508777f, -0.03853615f, 0.09693373f, 0.03039192f, -0.04558109f, 
    -0.24969797f, 0.35522306f, -0.09389646f, 0.23745558f, -0.01224652f, -0.06505358f, 0.06938463f, 0.03904383f, 
    -0.00327766f, -0.08835354f, 0.08693949f, 0.16839284f, 0.04747058f, -0.09695277f, -0.09292020f, 0.16678570f, 
    0.01561461f, 0.03880728f, 0.13892990f, -0.07341852f, -0.05608770f, 0.16946265f, 0.02077566f, -0.00584601f, 
    -0.11637023f, 0.05996496f, 0.11281598f, 0.16128565f, 0.05966093f, -0.00098693f, 0.04230503f, 0.01541386f, 
    0.08815803f, 0.12288018f, 0.10837357f, 0.04161179f, 0.18848686f, 0.02937083f, 0.10970347f, 0.06525989f, 
    0.04504923f, 0.04029400f, 0.07384874f, 0.09373618f, 0.05769651f, 0.08097051f, 0.05750605f, 0.10981806f, 
    -0.07928294f, 0.04819700f, -0.08889473f, 0.04875384f, -0.07890537f, -0.08836953f, -0.02537555f, 0.00600234f, 
    0.13214704f, 0.02050453f, 0.00730970f, 0.08840441f, -0.13426785f, -0.10647702f, -0.09300859f, -0.19715968f, 
    -0.06238222f, -0.00867060f, 0.09351637f, 0.05041378f, 0.05151598f, -0.05010863f, 0.11036671f, 0.00059663f, 
    0.34126797f, 0.09012218f, 0.08302401f, 0.25657818f, 0.03815728f, 0.11081059f, -0.01927336f, 0.03180005f, 
    -0.06158186f, 0.08691640f, 0.01864729f, -0.00505583f, -0.03233970f, 0.02025009f, 0.10599471f, 0.06749564f, 
    0.11202759f, -0.00993541f, 0.07932789f, 0.07904574f, 0.06678245f, 0.07754001f, 0.02959486f, 0.06092034f, 
    -0.17770860f, 0.04659186f, -0.02318088f, 0.00555184f, 0.05503168f, -0.11041059f, 0.05928629f, 0.00007087f, 
    0.05849132f, -0.06314455f, -0.03095520f, 0.13080356f, -0.25168529f, -0.09828221f, -0.04635237f, -0.02984395f, 
    -0.08503968f, -0.05166446f, -0.10565694f, 0.03042995f, 0.04732625f, 0.13812530f, -0.00474647f, 0.13644813f, 
    -0.09988094f, -0.07681105f, 0.02864596f, 0.00205307f, 0.06140674f, -0.06753400f, -0.04307355f, 0.18117389f, 
    0.07862785f, 0.06845634f, -0.02884275f, 0.02931122f, 0.04512946f, 0.02626243f, -0.01293520f, 0.12546712f, 
    0.16610490f, 0.07682653f, -0.04656594f, -0.03167208f, 0.06251606f, 0.12142417f, -0.14095470f, -0.01478128f, 
    0.11173528f, 0.12831922f, -0.08730286f, -0.12045918f, 0.11565169f, -0.04108575f, -0.05482487f, -0.02309296f, 
    -0.05399015f, -0.01034122f, 0.05765400f, 0.04555325f, 0.10278891f, -0.00984843f, -0.17676781f, -0.00063151f, 
    0.19253406f, 0.14079702f, -0.03754405f, -0.01973740f, 0.00891907f, -0.00608343f, -0.00296728f, -0.10299759f, 
    0.07800616f, 0.13823782f, -0.01562934f, 0.03009659f, 0.05547930f, -0.00104244f, -0.04201319f, 0.13407724f, 
    0.08939705f, -0.01043532f, 0.09000499f, 0.03607861f, -0.10846324f, 0.01484686f, 0.08200316f, 0.01835564f, 
    0.01674239f, -0.03956189f, 0.00060207f, 0.11951448f, -0.01094864f, -0.03006742f, -0.02349503f, 0.02184078f, 
    -0.25439382f, 0.26960781f, 0.26770154f, -0.14009899f, 0.05570300f, 0.02576675f, -0.01984950f, -0.00234728f, 
    0.06287679f, 0.12193702f, -0.08975157f, -0.04993898f, 0.08007661f, 0.05000418f, 0.05312606f, -0.06412409f, 
    0.00172956f, 0.00662814f, -0.06546046f, -0.05726448f, 0.05340903f, -0.05096665f, 0.01843449f, -0.05974156f, 
    -0.31400707f, 0.06691548f, 0.25617912f, 0.17265196f, 0.06498536f, 0.03048988f, 0.10628717f, -0.06065673f, 
    -0.08540858f, 0.06736577f, 0.00508775f, 0.02654714f, 0.12707618f, -0.15444477f, -0.05161277f, -0.22129191f, 
    0.09455954f, -0.01918101f, 0.01121977f, 0.02086693f, -0.01873822f, -0.04124254f, 0.11512257f, 0.00184600f, 
    -0.16863349f, 0.02830180f, -0.06457308f, 0.15677856f, -0.03462892f, 0.11270585f, -0.10252938f, 0.06503508f, 
    0.03166560f, -0.02148732f, -0.01115565f, -0.03414519f, -0.37121361f, -0.14814021f, 0.15766959f, 0.05604959f, 
    -0.05454612f, 0.06810921f, 0.02671114f, 0.02800489f, 0.10007533f, -0.02540718f, 0.07080837f, -0.04000385f, 
    0.55337280f, -0.15744446f, -0.12914151f, 0.18594190f, 0.05863036f, 0.07723316f, 0.07771640f, 0.00167286f, 
    -0.07318253f, 0.02604272f, -0.02980300f, 0.07356549f, -0.20958105f, 0.04020769f, 0.08601401f, -0.07374364f, 
    0.01338139f, 0.03627497f, -0.01307344f, -0.04562589f, -0.04639914f, -0.05598751f, -0.00652069f, -0.11756819f, 
    0.02516756f, 0.03644041f, 0.01944084f, 0.07038072f, 0.14615485f, -0.20787355f, 0.01547942f, 0.06969433f, 
    0.05302469f, -0.07819214f, -0.01245718f, -0.01535789f, -0.07983100f, 0.04638133f, 0.06628056f, 0.15719816f, 
    -0.08253210f, -0.04304656f, -0.04159594f, -0.06579363f, 0.01589521f, 0.07256155f, 0.12162635f, 0.13937379f, 
    0.04016472f, 0.04333300f, -0.14869815f, 0.14058989f, -0.02878252f, -0.01238949f, 0.11871057f, -0.07409474f, 
    -0.08454095f, 0.03453826f, 0.08071009f, -0.07211754f, -0.22537959f, -0.12602448f, -0.15222889f, -0.05734438f, 
    0.00552728f, -0.00482025f, -0.02447782f, 0.12921748f, 0.05926938f, -0.07024547f, 0.14161651f, 0.01414969f, 
    -0.07559793f, -0.05252203f, -0.07206616f, 0.14603692f, -0.00537795f, 0.11477906f, 0.00295234f, 0.17160168f, 
    -0.18701415f, 0.04172166f, -0.04254252f, 0.00315789f, -0.57892746f, 0.10183977f, 0.03546312f, 0.00087407f, 
    0.04136932f, -0.00416584f, -0.03544163f, 0.04313622f, 0.01354788f, 0.16645578f, 0.02755392f, 0.17323820f, 
    -0.00383598f, 0.12619542f, 0.05945399f, 0.10948939f, 0.03721967f, 0.08299369f, 0.00562911f, 0.08489151f, 
    0.01093062f, 0.00120425f, 0.10324798f, -0.07405427f, 0.05028467f, -0.24394788f, 0.13174649f, 0.07845917f, 
    -0.09915861f, 0.02850450f, 0.12201272f, -0.02674414f, -0.00062358f, 0.01079408f, 0.04651400f, -0.00622712f, 
    -0.19779418f, -0.08611219f, -0.16543244f, 0.16475566f, -0.02964333f, -0.01600006f, 0.00524602f, -0.02054277f, 
    0.03447162f, -0.03857714f, -0.00463289f, 0.03469242f, -0.06239571f, 0.36115381f, -0.01437694f, 0.26077813f, 
    -0.09390403f, 0.11345585f, 0.05998692f, 0.03607629f, 0.10235090f, -0.01732141f, -0.03934062f, 0.09983998f, 
    -0.30616072f, 0.07401991f, -0.21186186f, 0.03965299f, 0.11975204f, -0.03736970f, -0.05426941f, 0.06836084f, 
    0.05093449f, -0.09203213f, -0.00676951f, 0.04447738f, -0.07310322f, 0.05464323f, -0.08528206f, 0.03364959f, 
    -0.16475210f, -0.08089330f, 0.07927826f, 0.05982954f, 0.19300988f, 0.09727353f, -0.01338947f, 0.04084672f, 
    0.14033149f, -0.01558003f, 0.15720618f, -0.23597050f, 0.05713623f, 0.03151476f, -0.04883295f, 0.06853212f, 
    -0.05861199f, 0.18810691f, 0.00879088f, 0.11607375f, -0.02478015f, -0.19903141f, 0.00011701f, -0.08506754f, 
    0.08324008f, -0.05604026f, 0.03602498f, -0.02031372f, 0.09671027f, -0.01131014f, -0.01867012f, 0.04582326f, 
    -0.17480795f, 0.36335328f, 0.19496790f, -0.16712134f, 0.01588871f, -0.10758006f, -0.07515353f, 0.06555418f, 
    0.07572951f, -0.05396491f, -0.00002349f, -0.20176679f, 0.11887084f, -0.00143232f, -0.00530626f, 0.12624344f, 
    0.00276229f, 0.11977527f, 0.01846450f, -0.01471298f, -0.11914061f, -0.09630770f, 0.09159155f, 0.02197880f, 
    -0.08574320f, -0.11027472f, 0.09676070f, 0.00028567f, -0.04395002f, 0.00238425f, 0.10273472f, 0.03658299f, 
    -0.12931073f, 0.10357632f, 0.01133471f, 0.02503743f, -0.14670672f, -0.07876207f, 0.15425751f, 0.07854950f, 
    0.07147589f, 0.01684439f, 0.03220629f, 0.09351830f, -0.05513255f, 0.09537887f, 0.06528033f, -0.00215922f, 
    0.02017068f, -0.06345947f, -0.01244010f, 0.05599146f, -0.03459409f, -0.03188466f, 0.00576329f, 0.00429227f, 
    0.04205550f, -0.07033788f, -0.05249934f, 0.02392036f, 0.01123962f, 0.01524663f, 0.02155928f, -0.06614026f, 
    -0.01626555f, -0.04880126f, 0.00803897f, -0.02690868f, 0.04725345f, -0.01670596f, -0.04571626f, 0.05369269f, 
    -0.07138791f, -0.08274991f, 0.04187459f, -0.03579393f, -0.06050155f, -0.01872082f, -0.07487501f, -0.02165168f, 
    0.00016575f, 0.05486128f, -0.06744354f, 0.00034187f, -0.00743542f, 0.02731738f, -0.04847916f, -0.01244752f, 
    -0.03643158f, 0.04848219f, 0.03884724f, 0.04819099f, -0.02703081f, 0.02957579f, 0.01036422f, -0.05811603f, 
    -0.06531482f, 0.04755345f, -0.02170139f, -0.02658405f, -0.04821913f, 0.01726427f, -0.01995182f, -0.03607488f, 
    0.04486708f, -0.02736579f, -0.06273839f, 0.02837653f, 0.02305283f, -0.07415101f, -0.05436016f, 0.02037968f, 
    0.00781943f, -0.03272892f, -0.00752097f, 0.04572114f, -0.00740356f, -0.05748743f, -0.02084141f, 0.06464222f, 
    -0.07038625f, 0.00208157f, 0.05947917f, 0.05924461f, -0.01172416f, -0.01377356f, -0.05251559f, -0.05919302f, 
    0.05919309f, 0.02004931f, -0.01500153f, -0.05357330f, -0.07390337f, -0.08439673f, -0.06473485f, -0.04152714f, 
    -0.03675403f, 0.03711825f, 0.00349964f, -0.05801644f, 0.02538903f, -0.01606520f, -0.05460713f, -0.04396400f, 
    0.03359983f, 0.02403173f, -0.04475013f, -0.06055856f, 0.01910421f, 0.01758722f, 0.04498381f, 0.03498685f, 
    0.03870371f, 0.03345139f, -0.02112583f, -0.02567866f, -0.03353692f, 0.02207157f, 0.05033007f, 0.04326364f, 
    0.02792730f, -0.07649510f, -0.03197734f, 0.03160925f, 0.00949720f, -0.07710329f, -0.07468826f, -0.07620630f, 
    0.05287014f, -0.04009106f, -0.01671269f, -0.02713684f, -0.07294676f, 0.04531884f, 0.03789806f, -0.00270662f, 
    -0.05290158f, 0.02684906f, 0.04228288f, -0.07132641f, -0.04559799f, -0.01270377f, 0.02804081f, 0.01255735f, 
    -0.04368538f, -0.00721286f, -0.05860291f, 0.00988934f, -0.02897364f, -0.05689656f, -0.02417755f, 0.04694100f, 
    0.00549079f, -0.01356633f, 0.00176692f, -0.03089738f, 0.03242952f, 0.01128160f, 0.03929498f, 0.03103052f, 
    0.00622776f, -0.00268724f, 0.02977420f, 0.01610757f, -0.08087030f, -0.07479274f, 0.01648113f, -0.06138270f, 
    -0.08085451f, -0.02556027f, 0.05674773f, -0.01676095f, 0.00858215f, 0.01657992f, -0.05944772f, -0.04269734f, 
    -0.04208455f, -0.00213830f, -0.01427657f, 0.01115506f, -0.07113825f, 0.03584951f, 0.06582710f, 0.02303109f, 
    -0.07417168f, 0.04685040f, -0.04115342f, -0.05102736f, 0.05744952f, -0.00706854f, 0.05122551f, 0.03114507f, 
    0.06019761f, 0.02602667f, -0.03477493f, -0.05524538f, -0.00518628f, -0.01827515f, 0.06552280f, 0.01666172f, 
    -0.37291414f, -0.07493543f, -0.12562697f, 0.01737591f, -0.03783120f, -0.03745183f, -0.01596653f, 0.01602792f, 
    -0.05321263f, 0.08467185f, 0.12967755f, -0.03934618f, 0.01468827f, -0.13787806f, -0.30470926f, -0.09230549f, 
    -0.04337821f, 0.04498269f, -0.06552444f, -0.03111075f, 0.13339067f, -0.00409537f, 0.07377677f, 0.02964496f, 
    0.09523389f, 0.05820005f, 0.03777993f, 0.04948036f, 0.06980485f, -0.05129922f, 0.08272046f, -0.03531731f, 
    0.09328254f, 0.06545506f, 0.12794495f, -0.02056596f, -0.07396013f, -0.26252699f, -0.10562109f, -0.17194767f, 
    -0.01699804f, 0.06107946f, 0.14472307f, -0.06164575f, -0.03605537f, -0.10212576f, 0.12179419f, 0.13390797f, 
    0.17808408f, -0.23459041f, -0.28300884f, 0.05091529f, -0.04892189f, 0.11393437f, 0.01848826f, 0.00175495f, 
    0.00264667f, 0.00471222f, 0.00923078f, 0.08946314f, 0.09135648f, 0.19003801f, 0.08569244f, 0.20484491f, 
    0.09063250f, 0.03097972f, 0.01587332f, -0.01042360f, 0.08938717f, 0.15287043f, -0.02103267f, -0.00562710f, 
    -0.59595627f, 0.43378490f, -0.25453216f, -0.06835909f, 0.07496887f, -0.13263257f, 0.07592412f, -0.02967728f, 
    0.14600408f, 0.00861534f, -0.06113290f, 0.06104940f, 0.10492225f, -0.19648555f, 0.06275662f, -0.00078156f, 
    -0.03092020f, 0.03806168f, 0.02290839f, 0.08611308f, 0.07538477f, 0.11180770f, 0.08330349f, 0.11528803f, 
    0.22789350f, 0.05047607f, 0.05113970f, 0.02267905f, -0.04732589f, -0.05132927f, 0.07160251f, 0.10681664f, 
    0.08308849f, 0.05132345f, 0.05302202f, 0.03874723f, 0.22614343f, 0.25588492f, 0.22648145f, 0.16420998f, 
    0.12973985f, 0.10536840f, 0.07291505f, 0.08159018f, -0.05623208f, 0.03533750f, 0.05658393f, 0.16155171f, 
    -0.32148838f, 0.21298702f, -0.03164045f, -0.19032356f, -0.03912517f, 0.04113202f, -0.02528589f, 0.07400355f, 
    0.06465644f, -0.00059841f, 0.04765668f, -0.06213583f, 0.08434060f, -0.00920806f, -0.08585599f, -0.15871318f, 
    -0.14391144f, 0.06433847f, 0.03405638f, 0.12431560f, -0.03056267f, 0.00455900f, 0.11665564f, 0.07872289f, 
    0.28891069f, -0.06677256f, 0.09814523f, 0.12618555f, -0.03477891f, -0.04574537f, 0.08467542f, 0.04723502f, 
    0.12549965f, 0.04207648f, 0.05904352f, 0.15241621f, 0.11381998f, -0.18019317f, 0.06265824f, -0.11289692f, 
    -0.11122923f, -0.04293984f, 0.05109677f, 0.10257747f, 0.11702191f, 0.06858890f, 0.01662909f, 0.04444978f, 
    -0.13709457f, 0.24029036f, -0.06677881f, -0.03595690f, 0.11889513f, 0.07495095f, 0.02001055f, -0.04711263f, 
    0.04764909f, 0.05217519f, 0.07399100f, 0.07118209f, 0.09219118f, 0.27040577f, 0.04310817f, -0.18922254f, 
    0.11939809f, -0.06761031f, 0.05071845f, -0.06534340f, 0.02032476f, 0.10426334f, 0.04189542f, 0.01360225f, 
    0.00318967f, -0.12887388f, 0.03502638f, 0.28810140f, 0.08239913f, 0.11565728f, 0.14681317f, 0.01612001f, 
    0.05010789f, -0.15300786f, -0.05292997f, -0.06837382f, -0.30338249f, -0.13734037f, -0.22799735f, 0.08625874f, 
    0.14989638f, -0.06907979f, -0.04506738f, -0.10639755f, 0.20416217f, 0.08360689f, 0.01607985f, -0.14498077f, 
    -0.31476799f, -0.04536368f, 0.01314889f, -0.06858012f, 0.03170935f, -0.02622328f, -0.00212824f, 0.00749972f, 
    -0.00416106f, -0.11130150f, 0.02102137f, 0.04318513f, 0.03743551f, -0.29107335f, -0.09442890f, -0.25358501f, 
    0.05641287f, 0.04530542f, -0.12344711f, 0.18005474f, 0.10264662f, 0.06785110f, 0.12816612f, -0.02047525f, 
    -0.03614895f, 0.10406904f, -0.20539419f, 0.24912113f, 0.16399999f, 0.10583477f, -0.01913316f, 0.06032362f, 
    -0.01357602f, -0.11560284f, 0.04178940f, -0.02951669f, -0.16713659f, -0.07168757f, -0.11756159f, 0.06730578f, 
    0.03072282f, 0.05702649f, -0.01108323f, 0.06910853f, 0.02123478f, -0.06252910f, 0.06627266f, 0.01047272f, 
    -0.14818062f, -0.11093362f, 0.00344511f, -0.26489547f, 0.16882610f, -0.05734925f, 0.09992481f, -0.04762223f, 
    -0.04442841f, 0.03173801f, 0.06869505f, -0.06224348f, -0.08444293f, 0.19544253f, 0.28926501f, -0.15913104f, 
    -0.07814527f, -0.00170674f, -0.11049840f, -0.01999509f, -0.02507690f, -0.00067845f, -0.06249505f, 0.05529905f, 
    0.16316916f, -0.26452261f, 0.07081974f, 0.02256083f, 0.17096984f, -0.07687358f, 0.07510924f, 0.00790049f, 
    0.03812132f, 0.08461428f, -0.06331578f, -0.02779080f, 0.33938876f, 0.13047998f, 0.14586854f, -0.17396086f, 
    0.03146265f, -0.00222523f, -0.00305650f, 0.00843970f, -0.03837155f, 0.03838686f, 0.08334008f, 0.14962347f, 
    -0.22307025f, -0.14763001f, -0.21133293f, 0.04398350f, 0.00454324f, -0.08818893f, -0.20537938f, 0.01371506f, 
    -0.02736174f, 0.02668430f, 0.10127906f, 0.08827710f, -0.15668091f, -0.20774278f, 0.03413327f, -0.04003771f, 
    0.05074899f, 0.05338155f, 0.02269656f, -0.01178316f, -0.04883717f, 0.01910819f, 0.12436812f, -0.15839580f, 
    0.15799884f, 0.24223983f, 0.20988418f, 0.23855099f, 0.16750385f, 0.03424758f, 0.05658913f, -0.11565090f, 
    -0.04934141f, -0.04096487f, -0.01843996f, -0.02075193f, 0.25143644f, 0.01747793f, 0.08362526f, -0.12048606f, 
    -0.04555931f, -0.11617917f, -0.19293578f, 0.05293402f, 0.11379705f, -0.01674465f, -0.03022095f, -0.12506144f, 
    0.03963561f, -0.03582062f, -0.08081572f, -0.03709378f, 0.17781045f, -0.05178417f, 0.19958954f, -0.14163171f, 
    -0.04246340f, -0.14431396f, 0.00512860f, 0.13525854f, -0.16919115f, -0.15737583f, -0.11408123f, -0.07647426f, 
    0.21888635f, 0.05374217f, -0.07044894f, 0.01277319f, -0.01166317f, 0.15951049f, 0.05418994f, -0.01216036f, 
    0.02409082f, -0.00729387f, 0.05684876f, -0.01272328f, -0.06502512f, -0.01215259f, 0.02571834f, 0.02075492f, 
    -0.05653258f, 0.06659567f, -0.00669555f, 0.01061366f, 0.05016086f, 0.03172108f, -0.05532574f, 0.02337074f, 
    0.00608467f, -0.06843431f, 0.05223964f, 0.04968571f, 0.06344127f, -0.03620803f, -0.05458340f, -0.07550468f, 
    -0.02870400f, 0.00096873f, -0.00002748f, 0.02942885f, 0.03759089f, 0.05534234f, -0.07354999f, -0.02539078f, 
    -0.05529543f, -0.05731962f, -0.01864453f, -0.00159429f, -0.06871860f, 0.04431877f, -0.06861776f, 0.04422804f, 
    -0.06863442f, -0.01818321f, 0.05166260f, -0.06014155f, -0.02280477f, 0.05309683f, -0.07305299f, 0.01193477f, 
    -0.03325503f, 0.06358785f, 0.03875315f, -0.03661903f, -0.05401535f, -0.05627333f, -0.06051058f, -0.05579117f, 
    0.02547704f, 0.01905411f, 0.04937432f, -0.02301862f, 0.05847841f, -0.04162856f, 0.05332865f, -0.00056010f, 
    0.03078471f, -0.04522448f, -0.07510176f, -0.02560151f, 0.03387177f, -0.02881595f, -0.07687687f, -0.00098642f, 
    -0.02479808f, -0.01154307f, -0.01963620f, -0.02690454f, -0.02833852f, -0.03028147f, -0.03528396f, -0.01061250f, 
    -0.04210865f, 0.00224294f, -0.02868452f, -0.00331498f, -0.04218665f, -0.03240088f, 0.04464887f, 0.01476245f, 
    -0.00829665f, -0.04004330f, -0.00051677f, -0.01673801f, -0.03521694f, 0.01038859f, -0.04710932f, -0.04249540f, 
    -0.02231671f, -0.05385692f, -0.04289373f, 0.03277658f, 0.04630039f, -0.01003878f, -0.05891949f, -0.04252732f, 
    -0.04095565f, 0.06172565f, -0.04670371f, -0.02812913f, 0.02769822f, 0.00679537f, 0.01002611f, 0.04924826f, 
    0.01663599f, 0.04355673f, -0.03137111f, -0.00415969f, 0.03019778f, 0.00589837f, -0.01153693f, -0.02702837f, 
    -0.06963485f, -0.03613413f, 0.01083655f, -0.04948142f, 0.01201699f, 0.02209075f, 0.03171442f, 0.00956271f, 
    -0.00973969f, 0.00843152f, -0.06569931f, 0.01409050f, 0.02458477f, 0.05647387f, -0.02283531f, -0.00494640f, 
    -0.04812193f, 0.00198395f, 0.02216712f, -0.00862832f, 0.01239954f, -0.06817664f, 0.05257623f, 0.05157638f, 
    0.05359130f, -0.04225763f, 0.07334996f, -0.04418489f, -0.00908776f, -0.00720120f, -0.05224542f, -0.06113593f, 
    -0.06204185f, -0.06518162f, 0.00288993f, 0.00634716f, 0.05203481f, -0.04655538f, -0.05612274f, 0.00838406f, 
    -0.02456655f, -0.05090131f, 0.03326896f, -0.03942089f, -0.01609869f, -0.04330205f, -0.04196772f, -0.03431087f, 
    -0.03182838f, -0.01678356f, 0.02549309f, -0.01509784f, -0.02735557f, 0.00948365f, 0.06208505f, -0.06407858f, 
    -0.04293253f, 0.02633719f, 0.00169661f, 0.05268902f, 0.04305613f, -0.02485507f, 0.01881641f, -0.05730588f, 
    -0.01502974f, 0.03717463f, 0.04582285f, 0.06202564f, 0.00279639f, -0.02390199f, -0.01042545f, 0.06068455f, 
    0.30628937f, 0.07560320f, 0.03386114f, 0.11830053f, 0.03489651f, 0.03403290f, 0.02177042f, 0.07440691f, 
    0.04972792f, -0.02750800f, 0.03827745f, 0.07121464f, -0.08767083f, 0.03438494f, 0.08807188f, -0.12293008f, 
    -0.12171862f, -0.00651680f, 0.08465920f, -0.02635219f, -0.03624495f, -0.13216247f, 0.00831854f, 0.04303163f, 
    -0.45365727f, -0.17331384f, 0.13434921f, -0.09084171f, -0.10856547f, 0.02141092f, 0.15221597f, 0.07520675f, 
    0.01505876f, -0.06679701f, 0.06313653f, 0.00817489f, 0.19123878f, 0.05270644f, 0.12267137f, -0.10979602f, 
    -0.17080253f, -0.05074940f, 0.00040641f, -0.01497965f, -0.06225093f, -0.09095346f, 0.06258577f, 0.01462034f, 
    0.00811469f, 0.30331409f, -0.02102350f, -0.08459502f, 0.11660261f, 0.04673729f, 0.11208019f, -0.02058116f, 
    0.02394073f, -0.07525068f, 0.01800404f, -0.01748459f, -0.15215386f, 0.07302205f, -0.14296548f, -0.25627983f, 
    0.11283234f, -0.03139498f, 0.00635213f, 0.04849498f, 0.11798619f, 0.01936586f, 0.11542186f, -0.03369078f, 
    0.23103587f, -0.16695330f, 0.07955440f, 0.08169263f, -0.06976094f, 0.02825400f, 0.02729931f, -0.03428400f, 
    -0.06528228f, -0.02468117f, 0.11992441f, 0.05961071f, 0.09649794f, 0.02522422f, 0.18801527f, 0.32300144f, 
    0.00981376f, -0.09447414f, 0.03147801f, 0.02671307f, 0.02751524f, 0.07137194f, 0.02699517f, -0.03953449f, 
    0.16749881f, -0.07196894f, -0.01637391f, -0.06390186f, 0.02795332f, 0.02235460f, -0.08500018f, -0.09718651f, 
    0.06877621f, 0.08890560f, 0.02259460f, 0.10302712f, 0.14392465f, 0.02898044f, -0.14634246f, 0.06721809f, 
    0.07105250f, -0.06188953f, -0.13258120f, -0.00885429f, -0.01057322f, 0.04075372f, -0.02938937f, -0.05206163f, 
    -0.10381785f, -0.00722370f, -0.09428966f, 0.05691848f, -0.00387096f, -0.07911266f, -0.01849016f, -0.02807371f, 
    0.00598694f, -0.05283652f, 0.03561372f, 0.08614147f, 0.14234912f, -0.01056766f, -0.09566187f, -0.22619510f, 
    -0.04643437f, 0.02547221f, 0.05221846f, 0.02405403f, 0.03459406f, -0.01451280f, -0.14726035f, -0.11010510f, 
    -0.09766747f, 0.22741644f, 0.19525172f, 0.12057632f, 0.18368061f, 0.13001040f, -0.04881322f, -0.12405151f, 
    0.01955052f, 0.04603685f, -0.02287430f, -0.00216242f, 0.27623639f, 0.17004526f, -0.01740712f, 0.25265127f, 
    0.12480728f, -0.10617272f, -0.07365336f, 0.13266815f, 0.08948821f, 0.09998143f, 0.08831700f, 0.02460092f, 
    -0.02081897f, -0.05776086f, -0.14661065f, -0.14856514f, -0.09540242f, 0.10551506f, 0.08648641f, -0.08890116f, 
    -0.03819967f, 0.03925893f, 0.06605344f, 0.08361994f, -0.12428618f, -0.15687935f, -0.15446815f, -0.37420598f, 
    -0.00090169f, 0.07077065f, -0.04723203f, 0.01169468f, 0.07226299f, -0.03063911f, -0.03804728f, 0.00940067f, 
    -0.06844013f, 0.01825714f, -0.02169018f, -0.01664987f, -0.04952454f, -0.02707857f, 0.01236342f, -0.05501713f, 
    0.02937287f, -0.03952989f, -0.04461366f, -0.04015570f, -0.07088736f, -0.02780950f, -0.07398272f, -0.03756917f, 
    -0.02291194f, -0.00448748f, 0.03209357f, 0.03306199f, 0.05760782f, 0.00146353f, 0.01037601f, 0.05658959f, 
    0.07101016f, 0.06788173f, -0.05088265f, -0.05060421f, 0.03077512f, -0.01873760f, 0.03228118f, -0.07086653f, 
    0.01315319f, 0.03860239f, -0.00956070f, 0.04618031f, -0.00121153f, -0.02993939f, -0.01850905f, -0.01455184f, 
    0.00820812f, -0.00871453f, -0.02133548f, -0.04199968f, 0.01003128f, -0.02073516f, -0.05252958f, 0.00910449f, 
    -0.00900419f, -0.00844041f, -0.01966449f, 0.00982023f, 0.06818111f, -0.04755424f, 0.01834323f, -0.03380075f, 
    -0.03146220f, -0.01072655f, -0.06604229f, 0.02219303f, 0.02692633f, 0.02244700f, 0.00516989f, -0.06220869f, 
    0.03410929f, 0.02084335f, 0.01669694f, 0.07039136f, 0.06270372f, -0.01641137f, -0.01572249f, -0.07380007f, 
    -0.02259235f, -0.04257455f, 0.04797934f, -0.00654977f, -0.05663571f, -0.03012636f, -0.04954774f, 0.02619906f, 
    0.01500473f, -0.04899579f, 0.02041406f, -0.01403064f, 0.01688566f, -0.05679861f, -0.03139088f, 0.00820397f, 
    0.06081427f, 0.03131981f, -0.05817153f, -0.06938011f, -0.07161528f, 0.07165735f, -0.02834285f, 0.04224028f, 
    0.00904483f, -0.02542419f, -0.00205751f, -0.04481589f, -0.04105857f, 0.06686283f, 0.03300523f, -0.01424341f, 
    -0.02625090f, -0.03669409f, -0.03448348f, -0.04764546f, -0.01438678f, 0.00658627f, -0.01392042f, -0.03248974f, 
    0.02311964f, 0.04940515f, -0.02159953f, 0.00041403f, 0.02168400f, -0.06908321f, 0.00341634f, -0.03192239f, 
    -0.07568022f, -0.02406776f, 0.04828740f, -0.05384986f, 0.04485992f, -0.03864549f, 0.05125905f, 0.04311851f, 
    -0.03925927f, 0.05456553f, -0.03140918f, -0.03991203f, -0.07265983f, -0.04887772f, 0.05619029f, -0.05105476f, 
    -0.01052398f, -0.02425367f, -0.06475942f, 0.03137568f, 0.04333922f, 0.01728407f, -0.07009598f, -0.07244536f, 
    0.05653102f, 0.03747801f, -0.01427202f, 0.05537600f, -0.00311954f, 0.01208555f, 0.04931193f, -0.06293565f, 
    -0.01059788f, 0.02086887f, -0.03687417f, 0.04749798f, 0.03868316f, -0.01241734f, 0.02074813f, -0.00256281f, 
    0.03232689f, -0.01663511f, 0.00252706f, -0.07144839f, 0.05992737f, -0.02517215f, -0.03895293f, -0.03415799f, 
    -0.00612703f, -0.03919047f, -0.01552311f, -0.02473824f, -0.04220911f, -0.00826762f, -0.04917864f, -0.06787714f, 
    -0.01490351f, -0.01728450f, -0.00733189f, -0.05858009f, 0.00446403f, -0.06714866f, -0.00586393f, -0.03529609f, 
    -0.02788717f, 0.05945287f, 0.01061907f, 0.00429347f, 0.03530077f, -0.06620131f, 0.00553334f, -0.01720029f, 
    0.01485037f, -0.06819662f, 0.01381588f, 0.04853039f, 0.06019746f, 0.15930772f, -0.04893358f, -0.05536367f, 
    0.05573291f, -0.00788201f, -0.08268264f, 0.02347019f, -0.08241501f, -0.17860124f, 0.04095179f, -0.39981371f, 
    -0.10995167f, 0.05734240f, 0.09716928f, 0.10910977f, 0.02821326f, 0.04323735f, 0.14545563f, 0.04437281f, 
    0.03262936f, -0.11085422f, 0.07780135f, -0.01478300f, -0.13642381f, -0.04108601f, 0.05647816f, 0.08177493f, 
    -0.05355059f, 0.06635813f, -0.06846081f, 0.06948843f, 0.13705967f, -0.15060093f, 0.05493480f, -0.00988032f, 
    0.06201766f, -0.05380406f, 0.02361463f, 0.10564332f, 0.02960869f, 0.15191706f, 0.00344625f, 0.07031453f, 
    0.08683963f, -0.02327461f, 0.23026817f, -0.21920568f, -0.02338177f, 0.01140938f, -0.00497458f, 0.03216656f, 
    -0.12751612f, -0.06815748f, -0.02678471f, 0.08206134f, 0.22826131f, 0.18130381f, -0.00889652f, -0.28864706f, 
    0.02534598f, 0.22543913f, -0.00286393f, 0.07573525f, 0.02728264f, 0.16666245f, 0.01551614f, 0.04959649f, 
    -0.07391924f, 0.19503444f, -0.04384632f, 0.13732849f, -0.02098701f, -0.01701864f, -0.01774735f, 0.07586645f, 
    0.00399590f, 0.01198414f, -0.02060872f, 0.14853695f, 0.01400069f, -0.20445196f, -0.12885205f, 0.27292868f, 
    -0.02920264f, -0.00903189f, 0.00908037f, 0.07014222f, 0.02941887f, 0.03376557f, -0.02653336f, -0.01205854f, 
    0.10706180f, -0.00964824f, -0.09636097f, 0.28248322f, -0.01501665f, 0.07308270f, -0.03068888f, 0.05406081f, 
    0.04422168f, -0.05122576f, 0.12827106f, -0.03604753f, -0.02617570f, 0.10197560f, 0.01279089f, 0.18107159f, 
    0.06604820f, 0.12960200f, -0.05589894f, -0.03457800f, 0.02183069f, 0.10525336f, -0.05854068f, -0.11859401f, 
    0.06200670f, -0.07524384f, 0.11829562f, -0.13630193f, -0.13492459f, -0.10763682f, 0.05402644f, -0.05708738f, 
    0.00374744f, 0.12720482f, 0.04672576f, 0.04580565f, 0.16211736f, 0.19135706f, 0.04789234f, -0.22834983f, 
    -0.03331773f, -0.11579114f, -0.05367946f, 0.06750743f, 0.04115899f, -0.06618263f, -0.03315652f, 0.04723018f, 
    0.19109906f, -0.04615725f, -0.09298272f, 0.06597927f, -0.12695448f, -0.00946669f, 0.02187851f, 0.13514501f, 
    0.03145174f, -0.09157817f, 0.02267952f, -0.16222341f, 0.03340241f, 0.02707753f, -0.19900268f, -0.01000811f, 
    -0.00481930f, 0.07091460f, 0.06471770f, -0.01815430f, -0.10950632f, 0.13346562f, -0.05517593f, 0.06325281f, 
    -0.09031880f, 0.08738578f, 0.11556528f, 0.00434526f, -0.06253356f, 0.12319436f, -0.11512648f, 0.07407667f, 
    -0.07416160f, 0.06126403f, 0.04969151f, 0.05409681f, -0.16487189f, 0.05566032f, -0.05147601f, 0.03190587f, 
    -0.15605491f, -0.03186075f, 0.01912664f, 0.13346680f, -0.02786040f, 0.00408582f, 0.09053250f, -0.20640215f, 
    0.04403481f, 0.03335492f, -0.06210114f, -0.04937385f, 0.04472625f, -0.01560514f, -0.00170563f, -0.01949800f, 
    0.05956759f, 0.04126283f, -0.06899408f, -0.06788775f, -0.01581215f, -0.05513044f, 0.00014919f, 0.03697847f, 
    -0.01036567f, 0.01230169f, 0.00699132f, -0.02649727f, 0.02474800f, 0.00093678f, 0.02590381f, -0.05559516f, 
    0.06938250f, 0.00160161f, 0.00255305f, -0.03878910f, -0.06587600f, -0.00612324f, -0.07349110f, -0.03305263f, 
    0.06030612f, -0.03810502f, 0.04401607f, 0.03048656f, 0.04677569f, 0.00364497f, -0.02492864f, -0.03455728f, 
    0.01063542f, 0.00259543f, 0.03161085f, 0.02581404f, 0.01418778f, 0.07510070f, -0.03204143f, -0.05031676f, 
    0.00048104f, 0.00727733f, -0.05650070f, 0.04666635f, -0.00312101f, 0.04836348f, -0.00191460f, -0.03389152f, 
    0.00632160f, 0.05843248f, -0.07243654f, 0.03413589f, 0.03593898f, -0.05062105f, 0.05951871f, -0.07606997f, 
    -0.07421345f, 0.05961445f, 0.04250744f, -0.04984713f, -0.07438185f, 0.02136644f, 0.01979981f, -0.03506342f, 
    0.06394764f, -0.04347672f, -0.07480425f, 0.00687576f, -0.00076347f, 0.02690665f, -0.01078652f, -0.05270515f, 
    -0.07793390f, 0.03925598f, 0.05738451f, -0.03669868f, -0.05215952f, 0.01947672f, -0.00396215f, -0.04812634f, 
    0.05321115f, -0.03220288f, -0.06226026f, 0.02281713f, -0.01358955f, -0.06132398f, 0.04404140f, -0.01373719f, 
    0.01205702f, -0.04623117f, 0.05267419f, -0.05978297f, 0.06343657f, 0.02159381f, -0.06266847f, -0.03921810f, 
    0.04735163f, -0.05376927f, -0.02887673f, -0.07399596f, -0.05620366f, -0.02562748f, -0.00757810f, -0.06672467f, 
    -0.05084112f, 0.03333727f, -0.00460308f, -0.00150628f, -0.05410623f, 0.01623266f, 0.03005319f, 0.02700378f, 
    0.01584938f, 0.00335755f, -0.05095572f, 0.01919749f, 0.04140463f, 0.03631638f, -0.02701849f, 0.05460717f, 
    -0.03480579f, -0.07624727f, -0.06996462f, 0.02720798f, -0.04254643f, -0.02164947f, -0.05049909f, -0.07480699f, 
    -0.06104347f, 0.04264488f, 0.04286265f, 0.05141515f, 0.05047262f, -0.01418073f, -0.04584789f, 0.04058276f, 
    0.02296798f, -0.00331581f, -0.06162434f, 0.04898346f, -0.08129109f, -0.00251007f, -0.06007846f, -0.04706752f, 
    0.05018280f, -0.02380080f, -0.04221588f, 0.01699699f, -0.06553681f, 0.04155121f, 0.01960629f, -0.01128803f, 
    -0.05311627f, -0.03658137f, -0.06774490f, 0.03108458f, -0.02231763f, 0.01857908f, 0.01324560f, -0.06639484f, 
    -0.03835262f, -0.05835027f, 0.04042974f, -0.01041322f, -0.00865644f, 0.01426660f, 0.02327030f, -0.06184649f, 
    0.01310659f, 0.01152766f, -0.06404404f, -0.07486385f, -0.00936282f, -0.00027764f, -0.03455117f, 0.01636666f, 
    -0.07678750f, -0.06423660f, -0.03730190f, -0.01532446f, -0.02831142f, -0.01464227f, 0.06188640f, 0.00504169f, 
    -0.26104093f, 0.10169213f, -0.18410002f, 0.03675453f, 0.06254365f, -0.03599355f, 0.09817659f, -0.04876319f, 
    0.00324837f, 0.05008943f, 0.07889225f, -0.03051051f, 0.00750279f, 0.05153984f, -0.15587497f, 0.16386303f, 
    0.16953073f, -0.03638336f, -0.00225767f, -0.04163542f, -0.04828604f, 0.12634701f, 0.03310400f, 0.14685933f, 
    0.11455388f, 0.02193170f, -0.00825254f, 0.18673059f, 0.15632641f, -0.00353633f, 0.09101864f, 0.07268886f, 
    -0.05401536f, -0.06916886f, -0.05375595f, -0.13398223f, -0.29628363f, 0.11392418f, -0.14138563f, -0.10170756f, 
    0.01307473f, 0.09779278f, 0.01146806f, -0.02321693f, 0.05397192f, 0.03884639f, 0.03682264f, 0.03518868f, 
    0.06794538f, 0.18085895f, -0.02941063f, 0.18589531f, -0.00967642f, 0.09246504f, 0.08994624f, 0.01361972f, 
    -0.02654370f, 0.02093453f, -0.00435153f, 0.04170912f, 0.01721589f, -0.04770214f, 0.27289468f, 0.35430902f, 
    -0.02042064f, -0.08133303f, 0.02228479f, -0.00495238f, -0.02824432f, 0.01216288f, 0.02451786f, -0.02701270f, 
    -0.27047762f, 0.32382184f, 0.02292259f, -0.16551182f, 0.00127623f, 0.05746234f, 0.03425904f, 0.03024878f, 
    0.11051387f, 0.00169508f, -0.04150919f, -0.03634096f, 0.14153035f, 0.08542286f, 0.10660047f, 0.04320410f, 
    -0.11810200f, -0.03921519f, -0.06623072f, -0.14717284f, 0.15397887f, 0.09131467f, -0.04220972f, -0.00259199f, 
    -0.31767219f, 0.17637533f, -0.04922817f, -0.11440711f, 0.11421051f, -0.00572855f, 0.06517962f, 0.08751230f, 
    0.07336996f, 0.03034664f, 0.07493038f, -0.05579530f, 0.03380797f, 0.04017866f, 0.12355267f, -0.09851441f, 
    0.03504761f, -0.00650182f, 0.06326352f, 0.04201261f, 0.08001863f, -0.00019961f, 0.06248717f, 0.09244548f, 
    -0.08348238f, 0.09930263f, 0.01165586f, -0.14414679f, 0.08072382f, 0.00598664f, -0.01295076f, 0.09266726f, 
    0.07929076f, -0.01850786f, 0.00832491f, 0.09276189f, -0.09756517f, -0.12126657f, 0.00686566f, 0.09211332f, 
    0.07033303f, -0.01588652f, 0.10955517f, 0.06725843f, -0.06163688f, -0.05018564f, 0.02664675f, -0.01621243f, 
    -0.04940275f, 0.14882815f, 0.11121890f, -0.01960736f, -0.06925236f, -0.11144308f, -0.08049148f, 0.06602364f, 
    0.02292411f, 0.05408586f, 0.04817617f, 0.06017049f, -0.02230451f, 0.09359001f, -0.02262323f, -0.02655631f, 
    -0.02381002f, 0.06777621f, 0.02250960f, -0.01804136f, -0.01648875f, 0.03944741f, 0.00421942f, -0.06289759f, 
    -0.04050121f, -0.08093291f, 0.06324718f, -0.00076500f, 0.16486956f, -0.13993542f, 0.08627383f, -0.00752461f, 
    0.03681739f, 0.13924563f, 0.07210787f, 0.02140697f, 0.04101545f, 0.14276098f, 0.10985585f, 0.20663156f, 
    0.09076405f, 0.01218165f, -0.07940871f, 0.05682491f, -0.02698481f, 0.14195675f, -0.07578200f, 0.06370880f, 
    0.07693078f, -0.01967780f, 0.10251649f, 0.14267512f, 0.00119301f, 0.04164801f, 0.05232253f, -0.04964069f, 
    -0.05564426f, 0.10598791f, -0.19297051f, -0.02473805f, 0.14462011f, 0.13646044f, 0.17101373f, -0.03833646f, 
    -0.03365146f, 0.02662157f, 0.03100129f, -0.06536992f, -0.08573747f, 0.01622014f, -0.00173930f, -0.05545316f, 
    0.22179657f, 0.25337872f, -0.05549965f, -0.15299003f, 0.07303098f, 0.07178208f, -0.04396056f, -0.04659545f, 
    -0.06754691f, 0.06393951f, 0.06620529f, -0.00704156f, 0.38511559f, 0.10911824f, -0.10478201f, 0.05741421f, 
    0.07835727f, 0.01881057f, 0.03625813f, 0.14274271f, 0.03619620f, 0.10647116f, 0.08185951f, 0.04375627f, 
    -0.11512300f, -0.21055037f, 0.10599685f, 0.15417467f, -0.00862205f, 0.04429633f, -0.07471929f, 0.10106830f, 
    0.00047334f, 0.08509076f, 0.03303023f, 0.10224234f, 0.19020450f, 0.05308634f, -0.23362744f, 0.01266134f, 
    0.04563408f, 0.08496944f, 0.00223694f, 0.01697087f, -0.00201184f, -0.01591266f, 0.04703663f, 0.17063087f, 
    0.25853083f, -0.14932266f, 0.15996365f, -0.04622298f, 0.07625369f, -0.01237419f, -0.01721454f, 0.13732979f, 
    -0.14511991f, 0.08597173f, -0.03790312f, 0.00829598f, -0.52730256f, 0.09759684f, -0.07164476f, -0.28757170f, 
    0.06822623f, 0.16584601f, -0.05246073f, -0.05109010f, 0.08483671f, -0.20776734f, 0.01954811f, 0.00865499f, 
    0.22152145f, 0.01454353f, 0.06987132f, 0.20109712f, 0.11759461f, -0.06412975f, 0.10136117f, -0.08368259f, 
    -0.08689875f, -0.05911753f, 0.02175153f, 0.02954442f, -0.20445782f, 0.02458661f, 0.04819333f, -0.16453308f, 
    -0.04178688f, -0.03950373f, -0.01187257f, 0.00995308f, 0.04273853f, -0.00961832f, -0.03210464f, -0.11654993f, 
    0.20636249f, 0.07213515f, 0.10141694f, 0.06364824f, -0.07603882f, 0.03641263f, 0.13242663f, 0.12840800f, 
    0.01198429f, 0.11733932f, -0.06546717f, -0.03012957f, 0.03053546f, 0.04285579f, 0.01618645f, 0.17086440f, 
    -0.01406698f, 0.00756023f, -0.01001086f, -0.08950659f, -0.06507185f, 0.01498612f, 0.05199025f, 0.07483527f, 
    0.02342361f, 0.02177189f, -0.32001483f, -0.27814764f, 0.00460042f, -0.01579486f, 0.00562897f, -0.08653904f, 
    -0.03974813f, -0.11577530f, 0.07012387f, -0.05338234f, -0.22626811f, -0.24814475f, -0.15486683f, -0.17390656f, 
    -0.04518455f, -0.05108628f, 0.00942835f, 0.02618574f, 0.01059633f, -0.01693311f, 0.10309164f, 0.08379275f, 
    0.03129994f, 0.19857700f, 0.14349915f, -0.01196571f, -0.02468367f, 0.06596731f, -0.20892097f, 0.02183194f, 
    -0.00684217f, -0.02740762f, 0.06629831f, 0.01381727f, 0.16952141f, 0.09381399f, 0.04100494f, 0.18695284f, 
    -0.08643848f, 0.11344513f, -0.00538865f, 0.00446858f, -0.01743646f, -0.03123095f, 0.10082586f, -0.16149931f, 
    0.10942703f, -0.01573847f, 0.05249800f, 0.20072128f, -0.03240174f, -0.06807240f, 0.09550627f, 0.18945806f, 
    0.05695803f, 0.10682456f, 0.03058011f, 0.15245795f, 0.11290687f, 0.19192490f, -0.07843326f, 0.03499784f, 
    0.11188415f, -0.07418960f, -0.02371918f, -0.04921803f, -0.00834610f, 0.00237899f, -0.13519818f, -0.00427059f, 
    -0.33501735f, -0.02476132f, 0.18849748f, 0.00005509f, 0.01831809f, -0.02277352f, -0.00564966f, -0.05987005f, 
    0.21133977f, -0.15236816f, 0.09706431f, -0.05183448f, 0.31070793f, 0.10971472f, -0.11702085f, -0.12666668f, 
    -0.13426492f, -0.00852625f, -0.06218483f, 0.07830774f, 0.04672885f, -0.18864444f, 0.02601278f, -0.10936624f, 
    -0.03229158f, 0.26237985f, -0.14774379f, 0.11365625f, 0.04786205f, 0.00703540f, 0.05319019f, -0.02463903f, 
    0.17051654f, -0.03812141f, 0.04321315f, 0.02281869f, -0.03356623f, 0.20781189f, -0.03824059f, 0.01718001f, 
    0.19851705f, -0.12466732f, 0.05602613f, 0.07155035f, 0.05256850f, 0.16457175f, 0.21211281f, 0.04859484f, 
    0.08977598f, -0.07023033f, 0.19099553f, -0.13546850f, 0.01674671f, 0.03734815f, -0.10050672f, -0.09779299f, 
    0.06458203f, -0.08374725f, -0.00311360f, -0.00557194f, -0.30286592f, -0.19454104f, 0.12074275f, -0.19356324f, 
    0.10273837f, -0.07902964f, -0.10915918f, -0.12273218f, -0.00020487f, -0.01517062f, 0.04569615f, -0.08420890f, 
    0.14486907f, -0.04886221f, 0.24120252f, 0.10691953f, -0.06398509f, 0.02459463f, 0.06972854f, -0.05528532f, 
    0.05835725f, 0.06350300f, -0.12766208f, 0.04269703f, 0.25899485f, 0.10090599f, -0.14999069f, -0.11707824f, 
    -0.00201583f, -0.14230925f, -0.08209249f, 0.10734300f, 0.02515092f, 0.03420418f, 0.05643600f, 0.15474725f, 
    -0.12361531f, 0.06686836f, -0.10915571f, 0.19650477f, 0.01779506f, 0.02242811f, -0.01277363f, 0.00811239f, 
    0.10843247f, -0.13662723f, -0.10164898f, -0.03122760f, -0.04150429f, -0.09238543f, 0.12852333f, 0.05129915f, 
    0.04665228f, 0.03488144f, 0.14037545f, -0.06134991f, -0.11145774f, 0.11243638f, 0.09114696f, -0.02822632f, 
    -0.09292511f, -0.00589150f, -0.07341525f, -0.05538967f, 0.16528286f, 0.17823322f, 0.14756647f, -0.10080981f, 
    -0.05871041f, 0.21015370f, 0.07709844f, 0.08387720f, -0.02289419f, 0.03127817f, 0.03005121f, -0.01695976f, 
    -0.05645666f, -0.20436762f, -0.14240240f, 0.10034629f, 0.05584242f, -0.08825301f, -0.15556845f, -0.07429282f, 
    0.01219874f, 0.04098840f, -0.02260001f, -0.09367850f, -0.00045108f, -0.10793068f, 0.26420379f, -0.03166306f, 
    0.13454743f, 0.04773299f, 0.09961296f, 0.15257789f, -0.05324377f, -0.15492024f, 0.07265278f, -0.10576970f, 
    0.06108620f, -0.06343952f, -0.03985494f, -0.00465265f, 0.00374115f, 0.02418051f, -0.09117562f, 0.09112617f, 
    0.14370729f, 0.09836525f, 0.02865927f, -0.02509621f, 0.02096425f, 0.01017634f, 0.08552289f, 0.10414740f, 
    0.13498738f, -0.02833139f, 0.07228021f, -0.00172881f, -0.05483811f, 0.06570404f, 0.11743858f, -0.01021131f, 
    0.03919616f, 0.08421089f, 0.05351167f, -0.02413769f, 0.03090082f, 0.00848264f, -0.02121306f, -0.08238532f, 
    0.06078240f, 0.15797871f, -0.05828250f, 0.00664555f, -0.05483918f, 0.03905733f, -0.12077682f, -0.02420872f, 
    -0.10398117f, -0.00622387f, -0.06718858f, -0.01163222f, -0.07488573f, 0.15646397f, 0.05421171f, 0.13813138f, 
    0.05663832f, 0.01900463f, -0.02995832f, 0.06573687f, 0.06264539f, 0.23599964f, -0.07603171f, -0.05557040f, 
    -0.01554041f, 0.35619473f, 0.17450748f, 0.01182159f, -0.00544183f, -0.06374990f, -0.08156675f, 0.13184756f, 
    0.06921946f, 0.03050073f, 0.14003246f, -0.02306455f, 0.11364318f, -0.02876353f, 0.04674572f, 0.05040617f, 
    0.07310214f, -0.01999992f, -0.01652860f, 0.00394233f, -0.09433948f, 0.01659288f, 0.09320743f, 0.07447623f, 
    0.16064359f, -0.06901772f, 0.24461561f, 0.15041485f, -0.04610198f, -0.05532132f, 0.04740105f, 0.06533177f, 
    -0.04815837f, 0.17423388f, -0.01270818f, -0.05981981f, -0.26518819f, 0.26776230f, -0.13699037f, -0.14813808f, 
    0.14564280f, 0.06529963f, -0.07973297f, -0.13513193f, 0.06281189f, 0.03418436f, 0.14008953f, -0.07363248f, 
    -0.15688452f, 0.11788002f, 0.18715890f, 0.08804400f, -0.03429100f, 0.00020534f, 0.08938227f, -0.04219404f, 
    0.04009093f, 0.03058230f, 0.04946907f, 0.06430587f, -0.12220917f, -0.06413601f, 0.10136101f, -0.05838194f, 
    -0.00536600f, 0.01888219f, 0.15237364f, -0.01098468f, 0.04815291f, 0.05495561f, 0.01169646f, 0.01278482f, 
    0.17618105f, -0.06937110f, 0.18434721f, -0.08054656f, 0.00870295f, 0.02526846f, 0.03227789f, 0.05186044f, 
    0.04445216f, 0.05166322f, 0.06020544f, 0.10869789f, 0.08589639f, 0.08359794f, 0.00413421f, 0.02693304f, 
    0.19053078f, 0.08314962f, 0.08511005f, 0.02502646f, 0.02175408f, -0.03219124f, 0.04179252f, 0.04023355f, 
    -0.07110416f, -0.07605922f, -0.26652816f, 0.05648394f, 0.07818428f, 0.03121118f, -0.10228675f, -0.06151972f, 
    -0.10318016f, 0.05220065f, -0.04723942f, -0.07418400f, -0.24465972f, -0.00151677f, -0.01576846f, -0.08629207f, 
    0.17177543f, 0.04915943f, 0.05023184f, 0.00833290f, -0.05654361f, -0.00996721f, 0.10437952f, 0.05744920f, 
    0.16268997f, -0.01467212f, 0.27630919f, 0.05415696f, 0.07418918f, -0.03837172f, -0.02949868f, 0.01636801f, 
    0.01072064f, -0.02077750f, -0.09320376f, -0.04222813f, -0.07325797f, 0.01309402f, 0.04357984f, 0.19117276f, 
    -0.12325848f, 0.05770839f, -0.02522449f, 0.01670074f, -0.03861609f, 0.01538579f, -0.01495186f, -0.07536018f, 
    0.15173295f, 0.12290134f, 0.08146951f, -0.00880300f, -0.01584700f, 0.10420609f, -0.01025051f, -0.06494321f, 
    -0.04803019f, 0.01278118f, -0.00377095f, 0.06154791f, 0.12061153f, -0.08749561f, 0.17505518f, -0.07108290f, 
    0.03208821f, 0.01762729f, 0.10612122f, 0.06512812f, -0.01536420f, -0.07970209f, 0.03332011f, 0.07405955f, 
    -0.11899606f, 0.01017663f, 0.10244194f, 0.02571597f, 0.04293728f, -0.00023898f, -0.00893282f, -0.01223282f, 
    0.13765192f, 0.09252521f, -0.01323618f, 0.11836737f, 0.13187882f, 0.06484594f, 0.07891391f, 0.09553868f, 
    -0.06397838f, 0.00516145f, -0.00444403f, 0.07473366f, -0.14194304f, 0.03247353f, 0.04103841f, -0.11094541f, 
    -0.07859308f, -0.02698075f, 0.18628012f, -0.16274731f, -0.05069098f, 0.05444517f, 0.04017065f, 0.00500937f, 
    -0.04602742f, 0.04457109f, -0.02697067f, 0.00562787f, 0.29692775f, 0.03089938f, -0.08643091f, -0.15605031f, 
    0.04409925f, 0.13640213f, 0.04297621f, 0.03915162f, -0.04229506f, 0.10117667f, 0.10618062f, 0.05882609f, 
    0.29056954f, -0.26362583f, -0.04269216f, 0.12125088f, -0.06060518f, -0.09215658f, -0.03445739f, 0.09491947f, 
    -0.05115761f, -0.02959098f, -0.01774249f, 0.05299016f, -0.36116019f, -0.23418437f, -0.12344031f, -0.14979996f, 
    0.16649356f, 0.04057391f, 0.10857074f, 0.03867343f, 0.02820561f, 0.00472169f, 0.02248073f, -0.00007987f, 
    0.29301605f, 0.06573942f, -0.03234320f, 0.11761945f, -0.02609300f, -0.04510332f, -0.05808529f, 0.01145407f, 
    0.13106427f, 0.00191044f, 0.01619367f, -0.03813885f, 0.05537427f, 0.05724502f, -0.03371776f, 0.06763153f, 
    -0.06535599f, 0.01754671f, 0.02698050f, 0.08482984f, 0.05300749f, -0.08088769f, 0.04210076f, -0.02841360f, 
    0.15442951f, -0.06598242f, 0.08374283f, -0.06952122f, -0.02487127f, 0.01600160f, 0.04181635f, 0.06282733f, 
    0.05293417f, 0.09130711f, -0.03667295f, 0.03571928f, 0.32830814f, 0.06547105f, -0.06007618f, -0.19436608f, 
    -0.04702004f, -0.02398660f, -0.05084057f, 0.08541071f, 0.03244473f, -0.05746894f, 0.00554619f, 0.03342590f, 
    -0.48991346f, -0.04189507f, -0.05465609f, -0.16976254f, 0.11641888f, 0.12015942f, 0.00514520f, 0.04255906f, 
    -0.02488768f, -0.02375854f, -0.01823809f, -0.16122001f, 0.07851559f, -0.04926921f, -0.15744972f, -0.05860274f, 
    0.16005135f, -0.04212661f, 0.01180491f, -0.01681685f, -0.06516269f, 0.04591459f, 0.00373978f, 0.07030665f, 
    0.22350594f, 0.08069716f, 0.08582288f, 0.01243515f, -0.09313782f, 0.16359709f, -0.05869191f, -0.11235851f, 
    -0.03993441f, 0.06000227f, 0.04338640f, 0.07197443f, 0.05455391f, 0.04946729f, -0.01557913f, 0.05944549f, 
    0.03876244f, 0.06895971f, 0.04223346f, 0.00341873f, -0.04261636f, -0.08649227f, 0.06123253f, -0.07805590f, 
    0.08948364f, 0.08752058f, -0.05509264f, -0.08819181f, 0.04979743f, -0.00067342f, 0.05405016f, -0.20012990f, 
    0.04683196f, -0.07143484f, -0.03120829f, -0.29941171f, 0.10474414f, -0.16604383f, -0.02085186f, -0.14152919f, 
    0.06387887f, 0.23799543f, 0.18398999f, 0.11700755f, -0.06009518f, -0.13199010f, -0.06849077f, -0.08847757f, 
    0.17526485f, -0.21906936f, 0.00961464f, 0.19523028f, 0.01947846f, 0.01633550f, -0.03663212f, -0.04862332f, 
    -0.17460583f, 0.01581325f, -0.09400076f, -0.10886771f, -0.28226802f, 0.06185642f, 0.17456442f, -0.09182128f, 
    0.02512717f, 0.11858094f, 0.01903637f, 0.03564582f, 0.04308787f, 0.22487061f, -0.10317535f, 0.09236581f, 
    0.20999342f, 0.17275715f, 0.19528949f, -0.33320960f, 0.04060758f, -0.00109577f, -0.03349457f, -0.07474177f, 
    0.07835163f, 0.01324466f, 0.06231321f, 0.10941953f, 0.00222655f, -0.08807038f, 0.04166785f, -0.29460016f, 
    0.03289607f, -0.00345846f, -0.05705505f, -0.09118445f, -0.04217748f, -0.13016868f, 0.03729145f, 0.04178634f, 
    0.14542751f, 0.30227262f, -0.01455596f, 0.24787864f, -0.14969043f, -0.06566945f, 0.06274014f, 0.06844115f, 
    0.01404058f, -0.01233804f, 0.14550801f, 0.16942103f, 0.11933298f, 0.12764129f, -0.21227346f, 0.13979447f, 
    0.07878195f, -0.03043452f, -0.02987255f, -0.03592278f, -0.07068203f, 0.12801513f, 0.10528037f, 0.00307698f, 
    -0.07033068f, 0.04779378f, 0.27420366f, -0.04195587f, 0.01665071f, -0.10607509f, -0.17471789f, 0.00141820f, 
    0.06910106f, -0.03814939f, 0.14506418f, -0.06237521f, 0.00265333f, -0.08207913f, -0.10949854f, 0.08030950f, 
    0.02270036f, -0.06653163f, 0.11901315f, 0.01321098f, 0.10801808f, -0.04183090f, -0.03439657f, -0.17216536f, 
    0.16974479f, -0.00990198f, 0.09777822f, -0.00370714f, -0.09542967f, 0.08569123f, 0.27495891f, 0.09526432f, 
    0.04833256f, 0.16043808f, -0.03078433f, -0.00976595f, 0.60863036f, 0.08113953f, 0.06906744f, -0.19114441f, 
    -0.01071528f, -0.02010703f, 0.02277676f, -0.01106971f, 0.00870212f, -0.10134248f, -0.04903686f, 0.07435468f, 
    0.26561397f, 0.18925162f, -0.10897043f, -0.05537302f, 0.06197276f, -0.07501530f, -0.14515522f, -0.03887067f, 
    -0.10991351f, -0.03475117f, -0.07452744f, -0.03539110f, -0.03547493f, 0.06338228f, -0.03790272f, -0.17749481f, 
    0.09341442f, 0.00588825f, -0.01024551f, -0.03014618f, -0.14964637f, 0.01521664f, 0.05107855f, 0.12129076f, 
    0.00563872f, 0.16698717f, 0.02567880f, 0.16225746f, -0.00570301f, 0.02186795f, -0.22265743f, -0.06450940f, 
    -0.18062299f, 0.07929451f, 0.13409933f, -0.08180758f, -0.24022172f, -0.10987516f, 0.06326063f, 0.11641908f, 
    -0.09468938f, -0.07589871f, 0.00140606f, -0.05792597f, -0.01196650f, 0.01218575f, 0.08444747f, -0.07684764f, 
    0.08161553f, 0.10215401f, 0.11516937f, -0.04224392f, -0.02999731f, 0.04966571f, 0.02860520f, 0.01523968f, 
    0.06442878f, 0.03009298f, 0.07212877f, -0.07475256f, 0.10055965f, -0.03556459f, 0.05218744f, 0.01799051f, 
    -0.03657551f, 0.04475588f, 0.11245993f, 0.04072006f, -0.07521275f, -0.12735493f, 0.02437245f, -0.06750716f, 
    0.15039387f, 0.18157604f, -0.01024694f, 0.12629862f, 0.05265157f, 0.00903892f, -0.08031356f, -0.02360275f, 
    -0.06805795f, 0.19332373f, -0.11666184f, -0.08009182f, -0.11344643f, 0.18039022f, 0.15393656f, 0.14566359f, 
    -0.04813617f, -0.02651152f, 0.04062831f, 0.13106684f, -0.03137533f, 0.15795548f, -0.02087006f, -0.06988057f, 
    -0.08311842f, -0.03291364f, 0.22135483f, 0.01000607f, 0.02022841f, -0.03169318f, 0.09730827f, 0.04270365f, 
    0.03891820f, 0.08524868f, 0.16764767f, 0.02214852f, 0.26168153f, -0.11912671f, -0.00460913f, 0.10686059f, 
    0.06020473f, -0.01602689f, -0.03107617f, 0.06526486f, 0.05423756f, -0.01385770f, -0.01672679f, 0.08598220f, 
    0.30909050f, -0.16269203f, -0.01424624f, 0.26322356f, 0.02615125f, -0.09027019f, -0.06380516f, 0.16888814f, 
    -0.07181462f, -0.05363061f, 0.00025228f, -0.04952661f, -0.33556557f, 0.11571210f, -0.18708174f, -0.13106300f, 
    0.16550528f, -0.02822825f, 0.07500441f, -0.03415583f, 0.13304487f, 0.00242801f, 0.09318102f, 0.02601463f, 
    -0.06169317f, 0.04077783f, 0.14915721f, 0.09766599f, 0.03920425f, -0.10426170f, 0.05754440f, 0.03488293f, 
    0.04047736f, 0.00517313f, 0.05421189f, 0.04122540f, -0.21807835f, 0.06000684f, 0.02804322f, 0.12432136f, 
    -0.05188786f, -0.07074300f, 0.10079228f, -0.01460084f, 0.04559969f, -0.04393022f, 0.05187520f, -0.02681298f, 
    0.24455053f, -0.00525990f, 0.12673156f, -0.14094317f, -0.06359440f, -0.01875611f, 0.19006373f, 0.00235201f, 
    -0.01105956f, 0.05987406f, -0.05451900f, -0.00384150f, 0.18145971f, -0.01369170f, -0.05489914f, 0.10948039f, 
    0.12093949f, 0.01087462f, 0.02450538f, 0.08999417f, 0.01797852f, -0.07667761f, -0.09070961f, -0.02881696f, 
    -0.23233843f, 0.11276167f, -0.08382670f, -0.19533305f, 0.02709501f, 0.03067652f, -0.10906186f, 0.03548238f, 
    -0.01176906f, 0.03968200f, -0.04101053f, -0.02026445f, -0.11820491f, 0.02466441f, -0.06295691f, -0.20552251f, 
    0.12584841f, 0.07064651f, 0.04648030f, -0.01913704f, 0.00553451f, 0.06030097f, -0.01678273f, 0.12185969f, 
    0.05726094f, 0.01690570f, 0.21187496f, 0.05414548f, 0.00046632f, -0.03352790f, -0.05441115f, 0.07198924f, 
    0.05190435f, 0.06379170f, -0.03803202f, 0.01999369f, -0.02299474f, -0.08089787f, -0.06454070f, 0.02047681f, 
    0.00337068f, -0.08008434f, -0.05523642f, -0.07779552f, 0.01095898f, 0.00788552f, -0.07976773f, -0.11974744f, 
    -0.00575773f, 0.03408555f, -0.00809909f, -0.03583976f, -0.04816341f, -0.06448167f, 0.04694655f, 0.02100636f, 
    -0.07071368f, -0.03993471f, -0.04192452f, 0.03910593f, 0.01601268f, -0.03757898f, 0.03059951f, -0.05697759f, 
    -0.03081629f, -0.01603225f, -0.00268325f, -0.00670760f, 0.01140338f, 0.06382766f, -0.06189424f, -0.01705821f, 
    0.00670912f, 0.00065604f, -0.04212802f, -0.05779150f, -0.02264294f, 0.04386361f, -0.06507619f, -0.01944380f, 
    -0.05148129f, -0.07486344f, -0.02392448f, 0.04136838f, -0.00899017f, 0.03345597f, -0.05863039f, -0.05673770f, 
    0.06304973f, 0.02746318f, -0.05293034f, 0.00614441f, -0.07250579f, -0.01855826f, 0.00101021f, 0.02313964f, 
    0.06450196f, -0.01741543f, 0.02066314f, 0.02379621f, 0.03069853f, -0.02581797f, -0.00125169f, 0.00876106f, 
    0.04871173f, -0.00164838f, 0.02755775f, 0.01658540f, 0.01725585f, 0.02753897f, 0.02440202f, 0.00062657f, 
    0.04572744f, -0.03076383f, -0.07290649f, -0.04035816f, -0.03083178f, -0.06964157f, -0.05054573f, -0.05152237f, 
    0.02586692f, -0.01973645f, 0.05513872f, 0.06337752f, 0.04243178f, -0.03822864f, 0.03639792f, 0.02827774f, 
    0.06418826f, 0.03619630f, 0.05454857f, 0.00746729f, -0.00425658f, 0.05241263f, 0.02980345f, -0.01469547f, 
    0.03262592f, -0.05660729f, 0.05463760f, -0.07593955f, -0.03984212f, 0.01436629f, -0.02271966f, -0.04760487f, 
    -0.03706953f, -0.05428015f, -0.04014295f, 0.01464903f, -0.01755724f, -0.03345333f, -0.05585106f, 0.00348334f, 
    -0.02085222f, -0.06337846f, -0.05030874f, -0.05981355f, -0.01006385f, 0.02093516f, -0.02266999f, -0.04482603f, 
    0.03124304f, -0.04975595f, 0.02461429f, 0.01854638f, 0.02977096f, -0.03926792f, 0.04963971f, -0.01462011f, 
    -0.02294204f, -0.03883122f, -0.07403926f, -0.01104343f, 0.01748387f, -0.05340909f, -0.02457709f, 0.02725389f, 
    -0.02864755f, -0.01074233f, 0.03906492f, 0.03098819f, -0.05980786f, -0.01185871f, 0.00493946f, -0.05304315f, 
    -0.03294326f, 0.03710832f, -0.03828738f, 0.05595630f, 0.06212108f, -0.04893456f, -0.03834708f, 0.00807636f, 
    -0.02756150f, 0.04384777f, 0.06443726f, -0.02050603f, 0.05980591f, -0.01229465f, -0.00042271f, -0.06104447f, 
    -0.00139156f, -0.04945727f, -0.07383536f, -0.04990418f, -0.04233504f, -0.04556106f, -0.04661369f, 0.03942218f, 
    -0.07351174f, 0.04549123f, 0.02083546f, 0.01930564f, 0.02445887f, 0.00141133f, -0.01887431f, 0.05952117f, 
    -0.04508531f, -0.03955154f, -0.00953820f, 0.01210703f, 0.00356902f, 0.00605404f, -0.00420326f, -0.06262054f, 
    -0.06874997f, 0.00689257f, -0.07093678f, -0.02418602f, 0.06587818f, -0.04154494f, -0.02283679f, -0.06528777f, 
    -0.01164503f, -0.07062834f, -0.04754469f, 0.06448489f, -0.05453070f, -0.00434142f, 0.03162240f, -0.04776849f, 
    0.06307653f, 0.01509707f, 0.06462117f, -0.07672530f, -0.01242922f, 0.11963649f, -0.10823894f, -0.02877264f, 
    -0.12590919f, 0.02282335f, 0.08370782f, -0.12373662f, -0.04852765f, -0.11998554f, -0.04216653f, 0.19539393f, 
    0.03085762f, -0.01711012f, 0.03652770f, 0.04963792f, -0.01379956f, -0.18355970f, 0.03250183f, -0.10050192f, 
    0.10841493f, 0.04693777f, -0.09179946f, 0.05438341f, 0.12196917f, -0.11285699f, -0.10732225f, 0.01964634f, 
    -0.01710259f, 0.02866350f, 0.00277188f, -0.11513794f, -0.19259533f, -0.09449767f, 0.03163707f, -0.09031577f, 
    0.12802340f, 0.04476870f, 0.09574469f, -0.03089034f, -0.06240693f, -0.04389535f, 0.06173062f, 0.14249542f, 
    -0.00834820f, -0.38894176f, -0.17729595f, 0.18439949f, 0.00450873f, 0.15141577f, 0.07384013f, -0.09445206f, 
    0.05259498f, 0.16002473f, 0.03447704f, 0.12731612f, -0.25030413f, -0.14020613f, -0.07735299f, 0.25293577f, 
    0.04297198f, 0.07429708f, 0.08084793f, -0.08385159f, -0.00968489f, -0.10155671f, -0.02795386f, 0.04629177f, 
    -0.11036721f, 0.06887347f, -0.17508413f, 0.16000633f, 0.11459150f, 0.03176185f, -0.08799486f, 0.02093838f, 
    0.10108996f, -0.04253924f, -0.00359368f, 0.06828362f, -0.13415228f, 0.15733117f, -0.12304416f, -0.21922185f, 
    0.15677871f, 0.12116181f, 0.01931795f, 0.03882329f, -0.01171212f, 0.03104396f, 0.00702731f, 0.14667657f, 
    0.15910064f, -0.08932740f, 0.18633188f, -0.01808089f, 0.14259689f, -0.06102316f, -0.03252981f, 0.08930389f, 
    0.01429167f, -0.03280031f, 0.00661628f, 0.01276777f, 0.05258217f, -0.01057127f, 0.07719974f, 0.07364336f, 
    -0.13536397f, -0.01601889f, 0.03688834f, -0.08350197f, 0.10238340f, -0.06925900f, 0.05574771f, -0.01389222f, 
    -0.10885828f, 0.13509400f, 0.02624232f, -0.06719548f, -0.06508555f, 0.14785483f, 0.06858616f, 0.05452305f, 
    0.00205303f, 0.09718307f, 0.03290804f, -0.12409247f, 0.16355371f, -0.19264324f, -0.27329901f, -0.01562669f, 
    0.06143218f, 0.12271421f, -0.06518167f, 0.07709316f, 0.03166920f, 0.13144560f, -0.02348603f, -0.01225972f, 
    0.51253897f, 0.34918341f, 0.04150103f, -0.10546988f, 0.17985226f, -0.03543983f, -0.03640366f, -0.15784535f, 
    0.05321746f, -0.09837153f, 0.09818137f, 0.09471172f, 0.16234651f, -0.33214217f, 0.05224262f, -0.03271231f, 
    0.10232820f, 0.04271010f, 0.08196685f, 0.16261117f, 0.08847483f, -0.05824305f, 0.05617899f, 0.14249945f, 
    -0.11410724f, 0.15369086f, 0.01130986f, -0.04454141f, 0.04819652f, -0.03457900f, -0.15204337f, -0.14312613f, 
    -0.03463562f, 0.07668960f, 0.08399130f, -0.10704395f, 0.09878036f, -0.09646586f, 0.01485080f, -0.20965759f, 
    0.11607005f, -0.01671016f, -0.01192039f, -0.09132218f, 0.03498949f, -0.03364414f, -0.02576682f, -0.08873446f, 
    0.11483242f, -0.05787433f, 0.13693307f, -0.07346610f, 0.02311034f, 0.05127769f, -0.13029565f, 0.17639811f, 
    -0.08242352f, -0.01079193f, 0.02597746f, 0.13659336f, 0.05390296f, 0.03067880f, 0.22836106f, 0.06203806f, 
    -0.22557363f, -0.03522844f, -0.06638467f, -0.02594681f, 0.07449243f, 0.10975373f, -0.17166211f, -0.07217073f, 
    0.05457092f, 0.05745311f, -0.01754469f, -0.15551157f, -0.13052373f, -0.07221441f, -0.06537921f, -0.09440283f, 
    0.12754242f, 0.04262294f, 0.09024327f, 0.09617270f, 0.31776977f, 0.01242608f, -0.12559301f, 0.17339993f, 
    0.06165145f, 0.05811760f, 0.09958440f, -0.00088110f, 0.03429127f, -0.12030081f, -0.01782371f, -0.04447951f, 
    0.06315930f, -0.05634119f, -0.11800025f, 0.07857123f, 0.11971241f, 0.04728021f, -0.10894815f, 0.09377094f, 
    0.16630353f, -0.01818212f, -0.01601719f, 0.12162179f, -0.02252852f, 0.16931736f, -0.20663622f, 0.03046291f, 
    0.05965874f, -0.00544195f, -0.11938098f, 0.08392103f, 0.15478420f, 0.03442074f, 0.03353048f, -0.02028435f, 
    -0.18957135f, 0.01696293f, 0.07814655f, -0.00851280f, 0.04638692f, -0.10944220f, 0.12268137f, 0.03813538f, 
    -0.01145569f, 0.09219500f, 0.01308157f, -0.02545387f, 0.17828511f, -0.26233667f, -0.06203590f, -0.07923568f, 
    0.18992762f, -0.04933529f, 0.04209366f, -0.00769580f, -0.02189470f, -0.00539559f, 0.03532574f, -0.04565727f, 
    0.32385740f, -0.01919767f, 0.09775930f, 0.09863815f, -0.01529431f, -0.03089689f, 0.10239109f, -0.01034410f, 
    -0.09007272f, -0.07753721f, -0.00281398f, 0.08578881f, -0.12529010f, -0.11138439f, -0.02002008f, 0.01064515f, 
    0.09705262f, -0.06455719f, -0.08040251f, -0.00036138f, -0.03969267f, -0.04133892f, 0.01920040f, -0.10402669f, 
    -0.20362636f, 0.08838097f, 0.09718820f, -0.00203500f, -0.19491562f, 0.09566443f, -0.02952014f, -0.00032929f, 
    -0.01902903f, -0.06344910f, 0.02573180f, -0.12018789f, -0.10888016f, 0.00434261f, 0.01797562f, 0.07360256f, 
    -0.02116339f, 0.12133523f, 0.04784373f, 0.06205751f, 0.05144694f, 0.08911712f, 0.08157813f, 0.08006776f, 
    0.34365171f, -0.28670308f, -0.15895948f, 0.23543744f, 0.15618761f, 0.09851640f, -0.00736253f, -0.12223285f, 
    0.03413022f, -0.12316266f, 0.05038855f, 0.13741751f, -0.06097493f, -0.13343361f, -0.07630882f, 0.03014633f, 
    -0.05977016f, -0.05588860f, 0.10904213f, 0.07431195f, 0.14352642f, 0.02474276f, -0.00254078f, -0.01079299f, 
    -0.06704463f, 0.09756143f, 0.14015502f, -0.03251585f, 0.05479112f, 0.00724440f, -0.12274697f, 0.06591498f, 
    0.06806877f, -0.11055070f, -0.12589668f, 0.02712406f, 0.12500007f, 0.10396589f, 0.01170290f, -0.25001428f, 
    -0.09583637f, -0.02733721f, 0.05567759f, -0.14731041f, 0.00318623f, -0.02235525f, 0.08700014f, 0.04524578f, 
    0.20008928f, 0.01411567f, -0.07280775f, 0.06720181f, 0.07248776f, -0.01526918f, 0.12144905f, 0.05426767f, 
    -0.01496563f, 0.11941125f, 0.01585932f, -0.12502323f, -0.14062831f, -0.11831115f, -0.11451232f, 0.02678604f, 
    -0.01605701f, 0.02312654f, -0.02144269f, -0.03992456f, 0.05540470f, -0.03504600f, 0.04170620f, -0.03631456f, 
    -0.08718058f, 0.11172897f, 0.02376358f, 0.06279356f, 0.02768212f, -0.11665215f, -0.11435553f, -0.01809229f, 
    -0.05049697f, 0.02655257f, 0.05465970f, -0.09302520f, -0.35390034f, 0.03637549f, -0.08949304f, -0.08535012f, 
    0.12290529f, 0.07666611f, 0.05168623f, 0.03861124f, 0.02829568f, 0.01216525f, 0.04008764f, 0.22641158f, 
    0.23517644f, 0.16774695f, -0.03496127f, 0.18513061f, 0.16347183f, 0.16181006f, 0.00230693f, 0.06633264f, 
    0.10152037f, 0.04744763f, 0.07683709f, 0.21874049f, -0.08740497f, 0.04526398f, 0.02544296f, 0.22748891f, 
    -0.07253040f, -0.07820807f, 0.06187559f, 0.01578525f, 0.01100906f, 0.03082487f, 0.09500458f, 0.02418604f, 
    -0.26437134f, 0.11512665f, 0.06229459f, 0.24737372f, -0.01573502f, -0.15680756f, 0.14622991f, -0.02990450f, 
    0.00828055f, -0.02214711f, 0.11915714f, 0.06897602f, -0.18906921f, 0.25983578f, -0.00226069f, -0.10335414f, 
    0.14254075f, 0.05396876f, 0.02361690f, -0.12598890f, 0.03052165f, 0.08681951f, 0.12807451f, 0.06537709f, 
    -0.06890652f, 0.04508648f, 0.17174490f, -0.00564650f, 0.08336663f, -0.02338413f, 0.03514649f, 0.04705993f, 
    0.06185543f, 0.09762731f, 0.13170715f, 0.01573086f, -0.01847023f, 0.07683766f, 0.05011254f, 0.01458620f, 
    -0.00117423f, -0.11330491f, 0.16384234f, 0.08616007f, 0.04020204f, 0.04084656f, 0.00868247f, 0.05269564f, 
    -0.11896737f, 0.02512358f, -0.06097716f, -0.01503838f, -0.07175634f, 0.11994541f, 0.08599197f, 0.13188139f, 
    0.07501068f, 0.04848677f, 0.06116171f, 0.08020547f, 0.12460164f, -0.20333570f, -0.12044898f, -0.00215995f, 
    0.02708527f, 0.15801875f, 0.05794792f, 0.03123335f, -0.06010917f, 0.02566266f, 0.08680482f, 0.10417236f, 
    0.33815596f, 0.27293658f, -0.08177023f, 0.07203832f, 0.24388120f, 0.15991776f, -0.09537413f, -0.06702200f, 
    -0.05415546f, 0.04633957f, -0.06727146f, 0.01098369f, 0.07162067f, -0.16260973f, 0.13732314f, -0.13228199f, 
    0.05500265f, -0.06600564f, -0.05552311f, 0.11916707f, 0.06621432f, -0.00621842f, 0.09206052f, 0.08528180f, 
    -0.14893453f, 0.17325915f, 0.06684454f, 0.03724157f, 0.03257310f, -0.12725957f, -0.03617105f, -0.00756672f, 
    -0.01681455f, 0.05313889f, 0.04811267f, 0.00104833f, -0.12498203f, 0.02367491f, 0.10897034f, -0.09809662f, 
    -0.00946235f, -0.01272297f, -0.04709160f, -0.15962280f, 0.11003118f, 0.09793580f, 0.03948693f, 0.05225772f, 
    0.26521930f, 0.10523783f, 0.12492421f, 0.04116835f, -0.12741551f, -0.00212750f, 0.00797182f, -0.08002350f, 
    -0.03672802f, -0.06258591f, -0.13972919f, -0.13425860f, 0.02965410f, 0.14859606f, 0.17306395f, 0.12247629f, 
    0.12176523f, 0.03628848f, 0.05666035f, 0.10278848f, -0.03208080f, 0.01059497f, 0.00843234f, -0.05618224f, 
    -0.25171390f, -0.19653256f, -0.05773567f, 0.02613334f, -0.07855412f, 0.00812009f, 0.11206263f, 0.09718303f, 
    -0.03243276f, -0.03877729f, 0.09359080f, 0.03321149f, 0.23782930f, -0.06968746f, 0.17451617f, -0.02651952f, 
    -0.05280584f, 0.11555858f, -0.13032492f, 0.12800553f, 0.07142309f, 0.03486246f, 0.08127613f, -0.04347490f, 
    -0.14870809f, 0.04091979f, 0.23336217f, -0.08539946f, 0.08991607f, -0.08397415f, -0.05981540f, 0.00122134f, 
    -0.00950656f, 0.06118414f, 0.04960110f, 0.00474609f, -0.21672317f, -0.21703573f, -0.12024454f, -0.20243986f, 
    0.00949932f, -0.04654596f, -0.04554432f, 0.03009851f, -0.10343999f, -0.12191502f, -0.00044364f, 0.12761992f, 
    0.65210426f, -0.31341061f, 0.15461850f, 0.01301480f, -0.13931282f, 0.08234945f, 0.08038313f, 0.15692605f, 
    -0.17457575f, 0.00146729f, 0.10564055f, 0.03079153f, -0.14633252f, 0.15712714f, 0.04659621f, -0.27898061f, 
    0.10342072f, 0.05283472f, -0.00563561f, 0.00248360f, -0.11028892f, -0.07728745f, 0.01038158f, 0.05464048f, 
    0.23486240f, -0.19888119f, 0.05451271f, 0.04907030f, -0.03670195f, 0.02624314f, -0.02780342f, -0.11634507f, 
    -0.05792125f, 0.12870868f, -0.13202192f, 0.07356182f, 0.12300090f, -0.06244964f, 0.01545777f, 0.04079278f, 
    -0.03262416f, 0.02382683f, -0.02501098f, -0.10448229f, -0.08143373f, -0.00532340f, -0.01471354f, -0.05915231f, 
    0.15086251f, -0.01705233f, -0.04935645f, 0.31273589f, 0.15689826f, -0.09556542f, 0.10847645f, -0.01972995f, 
    0.02271086f, 0.08207712f, -0.02709179f, 0.05133508f, 0.15948269f, -0.00236633f, 0.07839593f, -0.00333852f, 
    0.10700627f, 0.00583645f, -0.04895258f, -0.10645326f, -0.00895441f, 0.03032224f, 0.12256790f, -0.04225712f, 
    -0.14689456f, 0.19516985f, -0.01576181f, -0.08212235f, 0.15955046f, 0.07023741f, 0.03978740f, -0.05722834f, 
    -0.22861227f, -0.01410027f, -0.01527223f, -0.12917709f, -0.02989777f, 0.03534504f, 0.03641698f, 0.02404477f, 
    -0.02389489f, -0.01454080f, -0.02695751f, 0.00351508f, -0.01656234f, -0.04638571f, 0.06103189f, 0.02631414f, 
    0.11903558f, 0.09838022f, -0.12557927f, -0.01601211f, -0.02964249f, 0.09008261f, -0.09120255f, 0.07585105f, 
    0.01248740f, -0.05336535f, 0.03589010f, 0.04196099f, 0.02829202f, -0.26278630f, -0.09075800f, 0.08023255f, 
    0.08522736f, 0.16640043f, 0.06123810f, -0.06484346f, -0.02754762f, -0.03421073f, 0.07842933f, -0.03921072f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04942183f, -0.01233616f, 0.09554247f, 0.02149364f, -0.06656887f, -0.04467386f, 0.05216063f, 0.02827435f, 
    0.01474296f, 0.02060303f, -0.08401589f, -0.01352683f, -0.11306773f, -0.01951822f, 0.03782640f, 0.08920650f, 
    -0.06859886f, 0.20235711f, -0.00418811f, -0.04639358f, 0.01357407f, 0.05066584f, -0.00541929f, 0.00039485f, 
    -0.01886182f, -0.07152840f, -0.01281531f, 0.06391062f, -0.09486383f, -0.06133435f, 0.02921208f, 0.03440087f, 
    0.09173933f, 0.09412693f, -0.00716825f, 0.11860629f, 0.03129801f, -0.00227154f, -0.00838379f, -0.02104438f, 
    0.03110027f, -0.01992038f, 0.04989701f, -0.04054042f, -0.04589514f, 0.00432183f, -0.04076052f, -0.06654651f, 
    -0.04180421f, 0.02479526f, 0.08879678f, 0.00815579f, 0.04187270f, 0.06917927f, 0.08369116f, -0.02851050f, 
    0.13980357f, 0.02015316f, 0.06042557f, 0.00784599f, 0.09165608f, 0.11058912f, 0.01889849f, 0.02961767f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10540929f, 0.06130296f, -0.04294515f, 0.01416591f, -0.04546274f, -0.03690293f, 0.09494916f, -0.11569770f, 
    -0.02985816f, -0.04912985f, -0.11927330f, -0.06989847f, -0.00467123f, 0.09684819f, -0.03608011f, -0.02593053f, 
    -0.11536368f, 0.09413037f, 0.12008138f, 0.04842187f, -0.01089132f, -0.05621445f, -0.06350105f, -0.07269461f, 
    -0.09445799f, -0.05129506f, 0.12484371f, -0.05777479f, -0.11093871f, 0.05175362f, -0.02683719f, -0.09898479f, 
    0.07617703f, -0.06546538f, -0.10478643f, 0.08534586f, -0.00458493f, 0.05552777f, 0.00184564f, -0.06921764f, 
    0.00295177f, -0.07661694f, -0.10005386f, -0.01135845f, -0.08122054f, -0.02888616f, -0.03047179f, 0.11076941f, 
    -0.04871817f, 0.09156598f, -0.06158224f, -0.09442174f, -0.00956297f, 0.04352574f, -0.10339724f, -0.06620597f, 
    -0.02999689f, -0.07052767f, 0.04009156f, 0.08270913f, -0.05636594f, 0.02741120f, 0.02946011f, -0.06300370f, 
    -0.03622186f, 0.02299690f, 0.07795781f, -0.11583181f, -0.05412844f, -0.09263165f, -0.11616263f, -0.08384494f, 
    -0.11095452f, -0.02017660f, -0.11002877f, -0.01304351f, -0.02545099f, 0.11520649f, -0.09495154f, 0.11967307f, 
    -0.11951342f, -0.06917179f, -0.09101756f, -0.10934842f, 0.12046070f, -0.06153806f, -0.09659828f, 0.04731405f, 
    0.00321642f, 0.08036347f, -0.10185468f, -0.08169967f, -0.09222834f, -0.08672327f, 0.04480433f, -0.05003551f, 
    0.01015201f, 0.01086882f, 0.06273556f, -0.04210597f, -0.10889934f, -0.09062640f, 0.08924764f, 0.01684833f, 
    -0.12153059f, -0.07545495f, 0.03412853f, -0.07569841f, -0.04905854f, 0.08120489f, -0.02877170f, 0.01461129f, 
    0.06886022f, -0.03364003f, -0.07798012f, 0.02640623f, -0.10896242f, 0.07120448f, 0.05019666f, -0.07252315f, 
    0.05305040f, 0.10189584f, 0.08315307f, -0.11991844f, -0.02189186f, -0.08937246f, -0.02372159f, -0.03417657f, 
    -0.37646481f, 0.01761575f, 0.09764407f, 0.25201675f, -0.00290139f, 0.06308952f, -0.04995605f, 0.04565189f, 
    0.26928926f, 0.03240144f, -0.04721080f, -0.12487262f, 0.06158505f, 0.00696129f, -0.15900785f, 0.10085616f, 
    -0.10320128f, 0.16379362f, 0.21889064f, -0.15189396f, 0.19887111f, -0.01859046f, -0.09078878f, 0.23737563f, 
    0.14058913f, 0.10129974f, 0.07240713f, -0.16229793f, 0.06664205f, -0.29165921f, 0.39893600f, -0.23621945f, 
    0.12553328f, -0.17733756f, 0.12774482f, 0.16395457f, -0.34308192f, 0.17835693f, 0.14454716f, -0.11104549f, 
    0.10799686f, 0.05548454f, 0.01019287f, 0.10539907f, 0.03206725f, -0.01699921f, 0.33001453f, 0.13344081f, 
    0.16984457f, -0.04243699f, 0.06340726f, -0.08286752f, -0.13420169f, 0.10571008f, 0.06978246f, -0.06004197f, 
    0.04247889f, 0.01500551f, 0.01721675f, -0.07303250f, 0.07411309f, -0.01804314f, 0.02057396f, 0.45503947f, 
    0.03212369f, -0.06567801f, -0.11348770f, -0.10295285f, 0.06319309f, 0.03205979f, 0.36809155f, -0.02515688f, 
    0.08507009f, 0.08940100f, -0.04361865f, -0.02822673f, -0.16364358f, 0.03077860f, 0.12440689f, 0.17784788f, 
    0.01664844f, 0.09821654f, 0.35183522f, -0.15633044f, -0.20318112f, -0.10600540f, -0.07072663f, 0.05085386f, 
    0.27777496f, 0.00414367f, 0.06826473f, -0.24731131f, -0.08045761f, 0.09117327f, 0.23018631f, 0.08619726f, 
    -0.00180092f, -0.05658805f, 0.04243718f, 0.05854733f, 0.15089042f, -0.15036255f, 0.34082606f, 0.01236817f, 
    -0.02200644f, 0.17998204f, -0.09949385f, 0.33646435f, -0.07644176f, -0.06769281f, -0.12666725f, 0.07216904f, 
    -0.16160715f, 0.13525106f, 0.40651032f, 0.04443053f, 0.02522372f, 0.05855413f, -0.09981708f, 0.09269970f, 
    0.12988952f, 0.25817010f, 0.06443098f, -0.04835735f, -0.31210861f, -0.13742945f, 0.01582959f, -0.25175673f, 
    0.14056294f, -0.02371581f, 0.10504423f, 0.29824978f, -0.03070375f, -0.09012361f, -0.26952493f, -0.06673937f, 
    -0.05790706f, 0.36787111f, 0.31069311f, 0.01088591f, 0.08589245f, -0.04675075f, 0.20689526f, -0.00405697f, 
    0.09592460f, -0.05752843f, -0.02942725f, 0.14049007f, 0.20067075f, 0.14688537f, 0.11101042f, 0.08303020f, 
    0.10039472f, -0.00457972f, 0.04307543f, -0.03218312f, 0.13714175f, -0.06001518f, 0.01848818f, 0.20474501f, 
    -0.14359088f, 0.04070741f, -0.04547756f, -0.04304278f, 0.37461838f, -0.08721812f, -0.13470905f, 0.07026225f, 
    0.05216458f, 0.06606015f, -0.12091715f, -0.20676143f, 0.09414247f, 0.18384825f, 0.18456149f, -0.06999976f, 
    0.23107570f, 0.07458211f, -0.11983484f, 0.10426944f, 0.19780989f, -0.12585327f, 0.28659365f, -0.06850103f, 
    0.11932544f, -0.15495229f, -0.06379776f, -0.03086383f, -0.11103368f, -0.06326623f, -0.05237580f, -0.06613600f, 
    -0.23453592f, 0.09167284f, 0.33312279f, -0.02625799f, 0.00892527f, 0.07873185f, 0.16312964f, -0.15909243f, 
    -0.07550792f, 0.14412992f, -0.20086530f, 0.04607025f, -0.08636877f, -0.07489215f, 0.13726960f, 0.24667925f, 
    -0.16040379f, 0.11738119f, 0.11159831f, -0.01130564f, -0.04370638f, -0.15651162f, -0.11794896f, -0.25261727f, 
    0.18344311f, 0.11137091f, 0.09492469f, 0.01487043f, -0.05803525f, -0.17964004f, 0.41577339f, 0.07180142f, 
    0.00963756f, 0.16578576f, -0.01845785f, 0.08439459f, 0.04667334f, 0.16271819f, 0.03412103f, -0.08706421f, 
    -0.00003179f, 0.20256793f, 0.25903338f, -0.12418411f, 0.03771004f, 0.19478697f, 0.29225996f, 0.07660843f, 
    -0.13248911f, -0.01501673f, 0.19731615f, -0.05942812f, -0.13943766f, 0.05371514f, 0.13126136f, -0.10471731f, 
    0.12633130f, -0.00307166f, 0.02782956f, -0.00929335f, 0.07040749f, 0.34487140f, 0.24542147f, 0.00818799f, 
    0.24869639f, -0.10222053f, -0.40516993f, 0.13301018f, 0.06985505f, 0.10128583f, -0.09437221f, 0.04650211f, 
    0.10043998f, -0.10022023f, 0.27628005f, -0.15937564f, 0.37367365f, 0.12994406f, 0.35172397f, 0.06747574f, 
    0.18214259f, 0.05389840f, -0.09092790f, 0.40612701f, -0.24382785f, 0.00847777f, 0.00734785f, 0.22742248f, 
    -0.12977321f, -0.10265105f, 0.06824329f, 0.12198909f, -0.27193084f, -0.08144952f, -0.16421708f, -0.00220257f, 
    0.10074942f, 0.02060230f, 0.04084778f, -0.03421038f, 0.27903122f, -0.13212687f, -0.11646201f, 0.03344185f, 
    -0.10192018f, 0.18814230f, 0.16890666f, 0.20161013f, -0.00021722f, -0.03348924f, 0.02366140f, 0.09898572f, 
    0.13838539f, 0.11467561f, -0.12637970f, 0.04565662f, 0.21439449f, -0.51923895f, -0.05875069f, -0.07678510f, 
    -0.27398315f, 0.07081979f, 0.04269652f, -0.08189328f, -0.05719417f, -0.13224660f, 0.07878369f, -0.16631612f, 
    -0.38513926f, 0.02996256f, 0.16119544f, 0.01668326f, 0.09267333f, -0.00664378f, 0.18615305f, -0.05533030f, 
    0.04966975f, -0.16981636f, -0.05225766f, -0.09163266f, -0.14662535f, -0.05018095f, 0.04871292f, -0.07594432f, 
    -0.00013569f, 0.00566287f, -0.03335109f, -0.37390277f, 0.02036462f, -0.03734501f, 0.11868198f, 0.23039801f, 
    0.14997652f, 0.09536502f, -0.10137451f, -0.10104248f, -0.24486041f, -0.47497460f, 0.46070996f, -0.02886801f, 
    0.19302508f, -0.02528641f, 0.09262008f, 0.05963439f, -0.14330164f, 0.19864391f, -0.17023332f, -0.04493226f, 
    0.02103443f, 0.14512235f, 0.13765506f, -0.03532815f, 0.03475551f, -0.04697477f, 0.04552506f, -0.05049075f, 
    0.01318231f, 0.01449162f, 0.21811816f, 0.09815220f, -0.08735318f, 0.23181237f, 0.23371415f, 0.07887622f, 
    -0.06603987f, 0.36321384f, 0.09803562f, 0.11070086f, 0.19120918f, 0.00797429f, 0.23490801f, 0.23698324f, 
    -0.10691556f, 0.03332792f, 0.06490971f, 0.01714254f, 0.12439126f, -0.11579634f, 0.03241551f, -0.07665944f, 
    0.10339010f, 0.07834530f, -0.09623346f, 0.03108383f, 0.05856752f, -0.07679249f, -0.06650309f, -0.11546154f, 
    -0.12708433f, -0.05335896f, 0.03068696f, -0.08520089f, -0.11986855f, 0.00762842f, 0.12435864f, 0.08594505f, 
    -0.04942845f, 0.08610293f, 0.10386505f, 0.10395227f, -0.11638918f, 0.03055021f, 0.08540263f, -0.04187860f, 
    0.07435418f, 0.08132150f, -0.09137861f, -0.09719158f, 0.03844851f, 0.06363632f, -0.05538121f, -0.02745719f, 
    -0.08749139f, 0.09417699f, -0.01275994f, -0.12903565f, -0.01439005f, -0.01352251f, -0.09526743f, 0.08125757f, 
    -0.04197173f, -0.01233664f, -0.11244699f, 0.01735945f, 0.02460499f, -0.06918575f, -0.10150719f, -0.10669159f, 
    -0.06241907f, 0.12393151f, -0.08012059f, -0.03620285f, -0.05107113f, 0.05554950f, -0.09629493f, 0.04515648f, 
    0.08115479f, -0.00987782f, 0.06508695f, 0.16121106f, -0.01124930f, -0.02006081f, -0.00721058f, -0.18328539f, 
    0.04698245f, 0.14501487f, 0.17888907f, -0.01790592f, -0.07003379f, -0.06211691f, 0.04367000f, -0.15663125f, 
    0.07054452f, -0.13527881f, -0.03936362f, 0.04269721f, -0.04141984f, -0.37581033f, -0.10262558f, -0.17382115f, 
    0.21716233f, 0.10608625f, -0.02146726f, -0.01585523f, 0.28989816f, 0.15702029f, 0.39184633f, 0.00531755f, 
    0.03971366f, 0.01949790f, -0.00425792f, -0.25615519f, 0.16310251f, 0.14857624f, -0.05711672f, -0.08534014f, 
    0.01316360f, 0.05839339f, -0.01135925f, -0.35756943f, -0.00656309f, 0.07043215f, 0.07070171f, -0.12716380f, 
    0.05630157f, 0.08319879f, -0.05827839f, -0.07507718f, -0.13622199f, 0.03735653f, 0.30077600f, 0.17512490f, 
    0.10550380f, 0.14312254f, 0.05628885f, -0.03701604f, -0.27022505f, 0.26572195f, 0.11975162f, 0.22861044f, 
    0.39613768f, -0.05548856f, 0.02575542f, -0.11233386f, -0.07747575f, 0.07658922f, 0.18386714f, -0.24176359f, 
    -0.11609203f, 0.13787827f, 0.16860266f, 0.22676076f, 0.07750013f, -0.10506863f, -0.05963653f, -0.03486368f, 
    0.06307633f, 0.08747209f, -0.24398386f, 0.36897913f, 0.08406737f, 0.01659086f, 0.09871665f, -0.23002438f, 
    -0.03826478f, -0.01265183f, 0.19216666f, 0.03135910f, 0.15497455f, 0.34866923f, -0.24952921f, 0.25501218f, 
    0.09018044f, 0.07055355f, -0.05955122f, 0.04496166f, 0.28335962f, 0.03286910f, -0.17766061f, -0.08644529f, 
    0.02330478f, -0.09367938f, -0.23396912f, 0.03406167f, -0.11030000f, -0.00711229f, -0.30840620f, -0.06460804f, 
    0.04238667f, 0.03486595f, -0.22045128f, 0.01005542f, 0.00407513f, -0.20901088f, -0.02505877f, 0.08144580f, 
    0.07150090f, 0.19930331f, 0.24085069f, 0.09788825f, 0.07126334f, -0.01941209f, 0.14822988f, -0.27372161f, 
    -0.01486502f, 0.09386285f, 0.04986016f, -0.00893001f, 0.11671996f, -0.05888057f, 0.05454746f, -0.09488222f, 
    -0.11070380f, -0.02564642f, -0.09365129f, -0.10943897f, 0.05873909f, -0.11843856f, -0.03756164f, -0.06330344f, 
    -0.09449738f, -0.12725209f, 0.06584638f, 0.11302508f, -0.10605611f, 0.14024588f, 0.03288133f, -0.14285672f, 
    -0.13856271f, -0.05167745f, 0.04493964f, -0.00894518f, -0.10061492f, -0.11703914f, 0.01299379f, -0.17837325f, 
    -0.09982080f, -0.01440031f, 0.05989461f, 0.02455390f, -0.08746724f, -0.12259677f, -0.05161625f, -0.08074664f, 
    0.08966586f, -0.04211168f, 0.10094894f, -0.07670685f, -0.05107465f, -0.05212317f, -0.10381094f, 0.04664357f, 
    0.06976807f, 0.03189826f, 0.09039823f, -0.04779570f, -0.12372513f, -0.02883741f, 0.11808907f, 0.08389590f, 
    -0.06386020f, 0.05022971f, 0.07873150f, 0.04651964f, -0.10127062f, -0.10202892f, -0.15141270f, -0.09880479f, 
    -0.08971103f, -0.09596069f, 0.17824200f, 0.15362351f, -0.10414906f, 0.01697704f, 0.00128515f, 0.27544200f, 
    -0.06941067f, 0.06648286f, 0.00277330f, 0.01776542f, -0.16382574f, -0.06132247f, -0.38567492f, 0.28092888f, 
    0.07794213f, 0.15971510f, -0.08723006f, 0.25979757f, -0.17927846f, -0.01166573f, 0.05562575f, 0.04357615f, 
    0.17289500f, 0.11038268f, -0.33611378f, -0.01049310f, -0.06143266f, 0.18714352f, -0.13350105f, 0.13136461f, 
    0.02194226f, 0.13306287f, -0.04514950f, 0.06934687f, 0.13735320f, -0.10794217f, 0.09489862f, -0.05344859f, 
    0.03901580f, 0.02946441f, 0.03405611f, 0.19944002f, 0.07683278f, -0.09636450f, -0.08928671f, -0.10359302f, 
    0.08918505f, 0.08399406f, 0.17614998f, 0.11915843f, -0.05846315f, 0.16342935f, -0.15504031f, 0.03976823f, 
    0.07893777f, -0.38510296f, -0.12895831f, -0.10159354f, -0.26600006f, 0.11387517f, 0.12234790f, -0.19685984f, 
    -0.08010963f, -0.02936555f, 0.06144394f, -0.03251059f, -0.06333076f, 0.08916414f, -0.16915368f, 0.11537841f, 
    0.01065676f, 0.17740768f, -0.19013505f, -0.01975981f, -0.06977855f, -0.06667383f, -0.33248588f, 0.07149473f, 
    0.03943242f, -0.02560248f, 0.08467113f, 0.29667532f, -0.18971507f, -0.05094566f, -0.00738758f, -0.10605682f, 
    -0.04528905f, -0.13164991f, 0.13190214f, 0.08806930f, 0.22219491f, 0.17336349f, -0.10386073f, 0.17443202f, 
    0.17211425f, 0.20866445f, -0.01896179f, 0.31472912f, 0.25343937f, 0.11847311f, -0.21231291f, 0.03963408f, 
    0.08389350f, -0.04742232f, -0.14943424f, -0.02530685f, 0.10462282f, 0.26299086f, 0.17953861f, -0.03895362f, 
    0.20631126f, -0.07589176f, -0.03305558f, 0.06169256f, 0.01935621f, -0.02581161f, -0.06935786f, -0.13102116f, 
    -0.14235684f, -0.34635940f, -0.13543785f, -0.05741699f, 0.22038336f, 0.26036417f, 0.16164660f, -0.34245867f, 
    0.20642014f, 0.12162464f, 0.14454295f, -0.21624190f, 0.04590315f, 0.09770801f, 0.40961364f, -0.02065815f, 
    -0.10800372f, 0.02011199f, -0.21510668f, 0.26202160f, 0.01797725f, -0.11648828f, -0.34090972f, 0.07659350f, 
    0.04200324f, 0.16133283f, 0.05784455f, -0.24600440f, 0.20860606f, 0.00419325f, -0.02204008f, -0.23862240f, 
    0.07917336f, 0.07602175f, -0.17615452f, 0.18389399f, 0.23223552f, 0.21046609f, 0.06255529f, 0.10132323f, 
    0.19882354f, 0.08784589f, -0.08208533f, 0.13464478f, -0.41873351f, 0.12107667f, -0.05270151f, 0.07213803f, 
    -0.00841522f, -0.11318667f, -0.16161537f, 0.01703125f, 0.02848727f, -0.02305393f, -0.24497512f, -0.08468559f, 
    -0.06268691f, 0.09518546f, 0.14256634f, 0.09858671f, -0.05364130f, 0.27126437f, -0.13068318f, 0.10701740f, 
    0.19296406f, 0.07516703f, 0.26401749f, -0.07909650f, 0.37279612f, 0.14377420f, 0.16838489f, 0.07452650f, 
    -0.06619266f, 0.03338567f, -0.05371920f, 0.16863354f, -0.01800655f, 0.07780913f, 0.18865491f, -0.24484736f, 
    -0.02918177f, 0.04267835f, -0.15789182f, 0.08629069f, 0.25343984f, -0.12009683f, -0.13381556f, -0.00571189f, 
    0.04006640f, 0.18281436f, -0.26311168f, 0.33693376f, 0.13100432f, -0.13985704f, 0.02731122f, -0.22630769f, 
    -0.00706342f, -0.02051142f, -0.34117070f, -0.08875968f, 0.12803872f, -0.14714496f, -0.00303683f, 0.18151976f, 
    0.25212085f, 0.02454888f, -0.08256140f, 0.02084609f, 0.03629432f, -0.23123246f, -0.13927773f, 0.00959584f, 
    -0.00687415f, 0.00120054f, -0.37582096f, 0.04676534f, 0.07153831f, -0.14426316f, -0.15844275f, 0.08206368f, 
    0.51843601f, -0.07059523f, 0.00905620f, -0.06183030f, -0.06300506f, -0.20333062f, 0.04118472f, -0.11720956f, 
    0.19488250f, 0.14559048f, 0.05793726f, -0.06299410f, -0.04148800f, 0.11274875f, 0.07176172f, 0.33826041f, 
    -0.27376905f, 0.08859693f, -0.10478434f, 0.30533493f, 0.05667916f, -0.06133281f, 0.05940868f, 0.02431957f, 
    0.11623365f, -0.25185260f, 0.15379770f, -0.31382379f, 0.19522110f, -0.03535078f, 0.11826340f, 0.14387713f, 
    0.18753637f, -0.03793105f, 0.06821145f, -0.11486036f, 0.08532472f, -0.03263423f, -0.04406892f, 0.18256892f, 
    0.23763190f, -0.00918733f, -0.01568590f, 0.00286981f, -0.20170487f, -0.23714344f, 0.17798924f, -0.12123917f, 
    0.08561512f, 0.11417779f, 0.06884684f, 0.03825516f, -0.00821662f, 0.04815590f, -0.22863355f, -0.08822067f, 
    0.11491065f, 0.07869774f, -0.05075718f, 0.17826493f, 0.06864119f, 0.01438962f, -0.41773185f, 0.08198901f, 
    0.16385421f, 0.01647207f, 0.23855633f, -0.04712012f, -0.05310738f, -0.10220157f, -0.07023659f, -0.05575363f, 
    0.17323874f, 0.25916693f, 0.03439430f, 0.07139719f, -0.14639901f, -0.31525609f, -0.08864924f, 0.05022543f, 
    0.07418017f, 0.08317940f, -0.00604019f, 0.09114653f, 0.06210329f, 0.10116709f, 0.29374501f, 0.28181931f, 
    0.25283781f, -0.09890549f, -0.01517469f, -0.00592088f, 0.25148812f, 0.08892851f, -0.32953677f, 0.16110760f, 
    0.11560415f, 0.06515585f, 0.29862487f, -0.17721565f, 0.10795750f, 0.14163616f, 0.01056983f, 0.24743606f, 
    0.07139278f, 0.10831818f, 0.02149291f, -0.08676897f, 0.14929856f, -0.04628554f, 0.11070190f, 0.01851583f, 
    0.06406858f, -0.36124697f, 0.04791410f, 0.20312242f, -0.23575900f, 0.00885713f, 0.07869519f, -0.03571738f, 
    0.04001751f, 0.02679977f, -0.09468798f, 0.18259467f, -0.09189121f, -0.09729661f, 0.03719003f, 0.07070351f, 
    -0.04392243f, 0.09799747f, 0.16548671f, 0.08960064f, 0.17379908f, -0.00371654f, -0.33589476f, 0.14259234f, 
    -0.10432711f, 0.21461365f, 0.00914491f, -0.11549740f, 0.19261493f, -0.25765082f, 0.05729786f, 0.09358995f, 
    -0.38106981f, 0.01724050f, -0.22226617f, 0.11937357f, -0.08073797f, 0.11390585f, 0.10213859f, -0.08347300f, 
    -0.03912342f, -0.23884854f, 0.14324521f, -0.13558336f, 0.27974465f, -0.06658407f, 0.21603641f, 0.01506300f, 
    0.20849106f, 0.03621933f, -0.12375325f, 0.02288803f, -0.24761266f, -0.12082863f, -0.05437128f, 0.21850376f, 
    0.31944174f, -0.07498210f, -0.22053698f, -0.08672699f, -0.20026299f, -0.45307851f, 0.27739215f, -0.11264666f, 
    0.07385952f, -0.02651222f, -0.05148667f, -0.00738229f, 0.03802389f, 0.17823230f, -0.35142913f, 0.08036666f, 
    0.04746391f, 0.17312217f, -0.07604513f, 0.03442915f, -0.01874835f, -0.13883202f, -0.08443993f, 0.06379869f, 
    0.28124851f, -0.03998331f, 0.31731993f, -0.11762918f, 0.01980733f, -0.21836430f, -0.04615222f, 0.15702111f, 
    0.18343188f, 0.54355615f, 0.06769162f, -0.06278557f, -0.03743006f, 0.01111325f, 0.07012144f, 0.22383720f, 
    -0.04889496f, -0.04869571f, 0.03609896f, 0.09673464f, 0.09981270f, 0.09994426f, 0.02157634f, 0.05862646f, 
    0.02370499f, -0.03769176f, 0.00312283f, 0.07750417f, 0.06704380f, -0.11734542f, -0.01584467f, -0.13550684f, 
    -0.02949589f, -0.07595213f, -0.02414203f, 0.00402245f, 0.00645542f, 0.03514193f, 0.00668950f, -0.06586334f, 
    0.04809329f, 0.04336239f, -0.06965818f, -0.12117759f, -0.09737831f, -0.10106551f, -0.12531789f, -0.01235204f, 
    0.04478267f, 0.00285102f, 0.03951544f, 0.03051135f, 0.02379231f, -0.11180966f, 0.02460821f, -0.01751924f, 
    0.07213723f, -0.10428779f, -0.08709887f, -0.00748546f, -0.10425394f, 0.05314826f, -0.07377671f, 0.06109422f, 
    0.03911893f, 0.04642707f, -0.02979886f, 0.03890948f, 0.10271481f, 0.11114463f, 0.08960089f, -0.12451760f, 
    -0.09042084f, -0.05898146f, -0.02444084f, -0.06757283f, 0.01529404f, -0.01131988f, -0.04333734f, -0.05147975f, 
    0.27753514f, -0.07238559f, -0.27855209f, -0.18566169f, -0.03093577f, -0.02495594f, 0.15457042f, 0.10930023f, 
    -0.02350616f, 0.08481969f, -0.07821352f, 0.15509638f, 0.07799909f, -0.00419772f, 0.05203816f, 0.07520169f, 
    0.27261591f, 0.02154742f, 0.04597466f, -0.01625942f, -0.07325356f, -0.04221267f, -0.00037473f, 0.06422678f, 
    -0.15149786f, 0.12327036f, 0.24400446f, -0.02219102f, 0.10193203f, 0.19062683f, -0.11323874f, -0.00445117f, 
    0.09196226f, -0.03148530f, -0.10391758f, -0.00672546f, 0.16386968f, -0.10456021f, 0.31010714f, 0.00658527f, 
    -0.00260700f, 0.17113081f, 0.00497427f, 0.28570953f, -0.07857741f, 0.25142160f, -0.10967723f, -0.09056655f, 
    -0.30930883f, 0.06205227f, -0.02893726f, -0.09438128f, 0.22914383f, -0.14877248f, -0.29581586f, -0.01495979f, 
    -0.21922559f, 0.09729214f, -0.00985471f, 0.03050340f, 0.06692944f, 0.11317115f, 0.09291280f, -0.40252787f, 
    0.03948627f, 0.02620910f, -0.06643850f, -0.15872811f, 0.07908437f, 0.06912161f, -0.13939384f, 0.13644090f, 
    -0.04409776f, -0.01730677f, -0.09526199f, 0.15660571f, -0.01854651f, 0.08042099f, 0.33740500f, 0.21246542f, 
    -0.04345414f, 0.03335741f, 0.00131831f, 0.06398160f, -0.17697148f, 0.14074174f, -0.10683872f, -0.01847907f, 
    -0.08502712f, -0.04727557f, -0.00330989f, -0.20239395f, -0.25733480f, -0.17205575f, -0.23244442f, 0.21505086f, 
    -0.01360482f, 0.18510643f, -0.12602060f, 0.12847060f, 0.21399799f, -0.24548042f, 0.16455722f, 0.08796484f, 
    0.11599010f, 0.22799569f, 0.01191701f, 0.22285041f, -0.08138319f, 0.17163707f, -0.18434817f, -0.07430203f, 
    -0.08729453f, 0.08474863f, 0.14728253f, 0.00962302f, 0.17012252f, -0.09260336f, 0.10258494f, 0.14362857f, 
    0.16409734f, -0.15061596f, 0.10736856f, -0.06827809f, -0.03502401f, 0.16782422f, 0.12686771f, -0.23781332f, 
    0.31664112f, 0.07003002f, -0.13473874f, -0.10738876f, -0.10335393f, -0.01930207f, 0.06388862f, -0.02308203f, 
    -0.09037565f, -0.24022187f, -0.06686475f, 0.26653275f, 0.09159723f, -0.06168987f, 0.38229859f, -0.11849415f, 
    0.15659502f, 0.09529191f, -0.03708238f, -0.11054373f, -0.06486567f, 0.06765093f, -0.07477894f, 0.01409515f, 
    -0.32821190f, 0.04337207f, 0.04565909f, 0.09099828f, -0.01502277f, -0.10127419f, -0.10294480f, 0.04844671f, 
    0.14457411f, 0.21229050f, 0.02700116f, 0.02394811f, -0.09415556f, 0.08242451f, -0.08836316f, -0.07188515f, 
    -0.08489811f, 0.06522057f, 0.14198089f, 0.19755366f, -0.05447531f, 0.05872972f, -0.20972744f, -0.08053149f, 
    -0.22201283f, -0.10671631f, -0.06301794f, 0.06242006f, -0.04958618f, -0.03383960f, -0.26915228f, 0.00212762f, 
    -0.12609036f, 0.21449111f, 0.07933217f, -0.09718132f, 0.33381346f, 0.06342015f, 0.16354984f, -0.07792145f, 
    0.13658059f, -0.04881155f, -0.06867884f, -0.16021964f, 0.10549353f, 0.08017173f, -0.03609121f, 0.07602873f, 
    -0.15177351f, 0.10566899f, 0.07377507f, 0.34680381f, -0.26919040f, 0.05777000f, 0.22977829f, -0.01055551f, 
    0.16178414f, -0.07634776f, -0.11252851f, -0.04029953f, -0.00122662f, -0.27842084f, -0.09684570f, -0.11053052f, 
    0.03899220f, 0.01636413f, -0.13543242f, 0.34677526f, 0.20553350f, -0.04047705f, 0.11313659f, 0.03441897f, 
    -0.00984018f, 0.33695647f, 0.09114910f, 0.04675780f, -0.10673529f, 0.04372287f, 0.25747722f, 0.03412061f, 
    -0.08663711f, -0.16182652f, 0.37445334f, -0.21406047f, -0.03952773f, -0.18578605f, -0.06769270f, -0.03951308f, 
    -0.32746908f, -0.03043844f, 0.01251900f, 0.05261693f, 0.05450800f, 0.38600540f, -0.11239585f, 0.23835987f, 
    -0.02338772f, 0.05834609f, 0.09766717f, -0.06376261f, -0.15681399f, 0.18136379f, 0.03644068f, -0.02531283f, 
    0.43239021f, 0.02021384f, -0.23412339f, 0.03874509f, -0.07314085f, 0.01861270f, 0.16313165f, 0.16536704f, 
    0.07555748f, -0.10752340f, 0.17570989f, 0.12946858f, 0.22325596f, 0.02028093f, 0.32951847f, 0.01362523f, 
    0.17427588f, 0.09411852f, 0.13146624f, -0.10391045f, 0.22063443f, 0.06553022f, 0.04522288f, 0.26322231f, 
    -0.02242878f, 0.02587873f, -0.11039249f, 0.19478762f, -0.01458657f, 0.16437644f, -0.17296220f, 0.06282852f, 
    0.15210903f, 0.00999591f, 0.01847308f, -0.14429502f, -0.20819810f, 0.09881601f, 0.21374096f, -0.02765720f, 
    -0.00276296f, 0.11461709f, 0.04398571f, -0.00495627f, -0.10618734f, -0.03122669f, -0.25030935f, 0.08204978f, 
    -0.23792168f, 0.11526742f, 0.13801092f, 0.04954506f, 0.04926001f, -0.08465990f, -0.28150782f, 0.06224192f, 
    0.10886472f, 0.23911801f, 0.18633598f, 0.03052155f, -0.07722278f, -0.19941941f, -0.13006289f, -0.03672311f, 
    -0.29041648f, -0.12531736f, -0.20518360f, 0.23739477f, -0.02905272f, -0.09268834f, -0.36790064f, 0.10183775f, 
    0.06871600f, -0.30508491f, 0.21399955f, -0.17070957f, 0.00926335f, 0.10198874f, 0.18174566f, 0.06445350f, 
    0.12848924f, 0.10838980f, 0.06975771f, 0.18483317f, -0.35253558f, 0.00579222f, 0.05487470f, 0.23542918f, 
    0.13598278f, 0.06690026f, 0.08936532f, -0.09139195f, -0.38323098f, -0.24234705f, -0.11477943f, -0.06608207f, 
    0.02086928f, 0.02367621f, 0.07636797f, 0.18134797f, 0.13726263f, -0.12365835f, -0.20265183f, -0.03429419f, 
    0.03334103f, 0.16393436f, 0.37062612f, 0.17110437f, -0.00991431f, 0.05526879f, 0.36091152f, -0.03226328f, 
    0.15313885f, 0.05541752f, -0.03938985f, -0.05845701f, 0.08390885f, -0.31296512f, 0.22045720f, 0.12418076f, 
    -0.36084494f, -0.09171186f, -0.21214609f, 0.07772260f, -0.16094518f, 0.01794174f, 0.15799230f, -0.01627563f, 
    -0.11764611f, 0.08051017f, 0.01537971f, -0.04940896f, -0.02103895f, 0.01382894f, -0.00314168f, 0.08176266f, 
    -0.02495693f, 0.03374111f, -0.04504817f, -0.00481896f, -0.12528327f, -0.08282014f, -0.06318678f, -0.00856878f, 
    0.05377212f, -0.01109643f, 0.02710246f, -0.01715670f, -0.06469001f, -0.02267417f, 0.09297657f, 0.00291376f, 
    0.10031278f, 0.03670710f, -0.12742312f, 0.05749860f, -0.08306626f, -0.00735977f, 0.06597224f, -0.13325921f, 
    -0.09635512f, 0.05671584f, 0.02781573f, -0.06008632f, 0.05297233f, 0.06314729f, -0.12756878f, 0.12944132f, 
    0.07151553f, -0.03157030f, -0.08610700f, -0.04350429f, 0.12321066f, -0.04334472f, 0.11196765f, 0.06853011f, 
    -0.04042013f, -0.09820089f, -0.09623409f, 0.09750897f, 0.03542404f, -0.00453711f, 0.08491121f, -0.05882030f, 
    -0.09604891f, -0.06394812f, -0.00958260f, 0.07172259f, -0.04811572f, 0.09660938f, 0.07763696f, -0.08413634f, 
    -0.11274669f, 0.07969881f, -0.11336440f, 0.33940333f, 0.10092305f, 0.07533427f, -0.08733319f, -0.04092164f, 
    -0.12550664f, 0.24071252f, 0.14516138f, -0.20743974f, 0.25877896f, 0.03694046f, -0.18781887f, 0.04763052f, 
    -0.02988916f, 0.04348500f, -0.13836981f, 0.35733151f, -0.07284715f, -0.26598930f, 0.06447145f, -0.03108671f, 
    0.41321665f, -0.09331705f, -0.15078995f, 0.06322780f, 0.16501658f, 0.25559875f, 0.22050360f, 0.20308495f, 
    0.04322241f, 0.16927998f, 0.02107512f, -0.10448071f, 0.11558332f, 0.00199555f, -0.17260674f, -0.05938100f, 
    0.01753422f, -0.07250375f, 0.05855280f, -0.10570302f, 0.08773661f, 0.05208235f, -0.06675603f, 0.06243666f, 
    0.35903057f, -0.04579096f, 0.12129384f, -0.10985442f, 0.11668532f, -0.24112290f, 0.29562953f, 0.12198733f, 
    0.28705665f, 0.09756374f, -0.02172936f, -0.05064338f, -0.29087803f, 0.05702684f, -0.09503214f, -0.03165881f, 
    -0.13871866f, 0.03730602f, -0.36452013f, 0.24105172f, 0.10659742f, -0.04314940f, -0.03008890f, 0.11082901f, 
    0.14139922f, -0.27711338f, -0.02821901f, -0.09840196f, 0.34549886f, 0.10245802f, -0.13673715f, -0.01923406f, 
    0.23910069f, 0.26601556f, 0.18493327f, 0.29814580f, 0.03244928f, 0.26864958f, -0.00538233f, 0.50909442f, 
    -0.22195265f, 0.00386907f, 0.06027694f, 0.00606113f, -0.12283260f, -0.17919403f, 0.05481857f, 0.08206967f, 
    0.19510426f, -0.27206162f, 0.03470564f, -0.05988557f, 0.01982023f, -0.10905703f, -0.18076062f, -0.07754019f, 
    -0.01305405f, 0.21810564f, 0.09638385f, 0.36774266f, -0.09562736f, 0.06916160f, 0.19581631f, 0.07170905f, 
    0.34101498f, 0.04399758f, -0.15221517f, 0.09597614f, 0.08882564f, -0.17855917f, -0.07138833f, -0.05700269f, 
    -0.10777462f, -0.01877619f, 0.03917683f, -0.11853623f, 0.04250565f, -0.15513377f, 0.18158990f, 0.17508680f, 
    -0.23761317f, 0.05063078f, 0.36098310f, 0.20133442f, 0.04733494f, 0.04145880f, -0.17456390f, 0.24764889f, 
    0.06840563f, 0.05681069f, 0.00508302f, -0.26467231f, 0.10372397f, 0.07038859f, -0.18348630f, 0.29374409f, 
    0.02697609f, 0.07229986f, 0.06540821f, 0.03948420f, -0.02063238f, 0.17500971f, -0.00058748f, 0.06009500f, 
    0.24288388f, 0.10566366f, -0.24748072f, 0.17038670f, -0.14564009f, -0.02841073f, 0.05257569f, 0.15073596f, 
    0.14225703f, -0.00732451f, 0.02042452f, 0.03604573f, -0.07154895f, 0.19883935f, -0.05856039f, 0.03767023f, 
    -0.12111551f, -0.04468466f, -0.11264634f, -0.24323809f, 0.10917035f, 0.22512551f, 0.12612519f, 0.02221493f, 
    0.10300019f, 0.13748047f, 0.23145804f, -0.10755856f, -0.02269466f, 0.02731466f, 0.04607740f, -0.09825952f, 
    0.22607844f, -0.28599474f, -0.12123618f, 0.08791304f, -0.09452577f, 0.17173819f, -0.06249451f, 0.17316778f, 
    0.00616436f, 0.09521401f, 0.17253953f, 0.13288999f, -0.00437294f, 0.11065186f, 0.05409738f, 0.19843224f, 
    0.02229118f, 0.13895135f, 0.02325698f, -0.20024586f, 0.23120299f, -0.00855881f, -0.31728289f, 0.20947209f, 
    0.08342315f, 0.17491356f, -0.08648708f, 0.21248525f, -0.00100722f, -0.19875281f, 0.09063786f, 0.08232503f, 
    0.25907734f, -0.02472346f, -0.46916741f, 0.24385633f, 0.11263539f, 0.07389643f, -0.22362100f, 0.13951263f, 
    0.17245859f, 0.11939114f, -0.13272962f, 0.15556064f, -0.15106079f, 0.08196295f, -0.04107902f, -0.04568635f, 
    -0.07876289f, 0.04052179f, -0.27534190f, -0.19260006f, 0.00237468f, -0.00435277f, 0.02143959f, 0.10056642f, 
    0.16559252f, -0.02805847f, 0.15347317f, -0.03462118f, -0.20134215f, 0.04758715f, -0.24860248f, -0.12765183f, 
    0.26316583f, -0.34334525f, -0.01205419f, 0.03160453f, -0.15678026f, 0.01538370f, -0.19605081f, 0.20208056f, 
    0.26720503f, -0.02138807f, -0.12204548f, -0.13195586f, 0.02455883f, -0.02937296f, 0.17208546f, -0.10677715f, 
    0.11728495f, -0.01797211f, 0.21215515f, 0.19550925f, -0.14544937f, 0.09875956f, 0.57719004f, -0.19302359f, 
    -0.07754496f, 0.07416072f, 0.06238113f, -0.22594838f, 0.22767168f, 0.12552042f, -0.11750758f, 0.08911973f, 
    -0.29932767f, 0.06575764f, 0.28280821f, -0.07777461f, 0.04340407f, -0.10800218f, 0.16291250f, 0.01146169f, 
    -0.13453370f, 0.04787911f, -0.02678571f, -0.11437102f, 0.22366820f, -0.09873575f, 0.20840353f, 0.04232437f, 
    -0.05028324f, 0.03391203f, 0.19081311f, 0.24554193f, -0.09575316f, 0.04920822f, -0.03014441f, -0.08176712f, 
    -0.17650698f, 0.04145840f, -0.13320805f, 0.01042584f, 0.21759598f, 0.04014079f, 0.21095744f, 0.22414434f, 
    -0.11305200f, 0.41990346f, 0.14740399f, -0.00223452f, -0.06066975f, -0.27547660f, 0.10825571f, -0.01930106f, 
    0.10817204f, -0.06118108f, 0.23370564f, 0.06747971f, 0.07025028f, 0.08582585f, -0.26210594f, 0.23581685f, 
    0.08820564f, -0.01100859f, 0.23215051f, 0.11710774f, 0.11062910f, 0.02392018f, -0.11559265f, -0.31561536f, 
    -0.10539421f, -0.21871933f, -0.06161856f, -0.08041187f, 0.14874925f, 0.31563538f, 0.05103901f, -0.00556221f, 
    -0.14814165f, -0.04831106f, -0.07884240f, 0.24216834f, 0.32186654f, 0.23914428f, -0.25287643f, 0.04157500f, 
    -0.18073097f, 0.16948712f, 0.02377095f, 0.16633087f, 0.11351534f, 0.17550194f, -0.02854517f, 0.10109727f, 
    -0.04767131f, -0.39868936f, -0.12146500f, -0.05564230f, -0.00414328f, -0.33505234f, -0.08622257f, -0.08188730f, 
    0.00961279f, -0.07341056f, -0.14294775f, 0.05127322f, 0.14579761f, 0.41977811f, 0.00494740f, 0.09808802f, 
    0.08244830f, -0.11277760f, 0.10775013f, 0.08461671f, -0.01814395f, -0.02064103f, -0.24111354f, 0.49329641f, 
    -0.01824918f, -0.11488611f, -0.05439362f, -0.05415307f, -0.10969676f, -0.11565892f, -0.09277482f, -0.02150213f, 
    -0.10006296f, -0.06123319f, -0.01531776f, 0.11568295f, -0.08593657f, 0.07256743f, -0.08627696f, -0.04395548f, 
    -0.12947030f, 0.10699355f, -0.00675929f, -0.02345312f, 0.05812114f, 0.09464824f, -0.09069501f, 0.01552493f, 
    -0.09047945f, 0.07902627f, -0.00535735f, -0.11640380f, -0.11921127f, -0.09459580f, 0.04805298f, -0.13030237f, 
    -0.08313210f, 0.05475488f, 0.03456213f, -0.10188809f, -0.11111481f, 0.08961548f, -0.01472019f, 0.12094076f, 
    -0.07543896f, -0.02680968f, -0.03313244f, 0.04311593f, 0.11523840f, -0.02099504f, 0.05662247f, -0.04435757f, 
    0.11463798f, -0.08079720f, 0.04509125f, 0.06692556f, -0.12449980f, -0.05704280f, 0.06325293f, -0.07560986f, 
    0.04992007f, -0.11039890f, -0.04687438f, 0.03246361f, -0.08471975f, 0.08415624f, -0.06074879f, -0.07989936f, 
    0.15109901f, 0.03220440f, 0.00625362f, -0.03494120f, -0.02038069f, -0.11610521f, -0.16218194f, -0.15513611f, 
    0.14315619f, -0.05417485f, -0.12991014f, 0.06445598f, -0.12053212f, -0.09830036f, -0.10024244f, -0.14572710f, 
    0.03895102f, -0.05214345f, 0.12408542f, -0.06104186f, 0.11981779f, 0.10409510f, 0.10099138f, 0.14983968f, 
    -0.17518288f, -0.11604003f, 0.29343608f, 0.15792391f, 0.27301270f, 0.23593979f, 0.10531522f, -0.12113632f, 
    0.04732866f, 0.06325484f, -0.06335097f, 0.15320978f, -0.15880506f, 0.11167300f, 0.13048139f, 0.02875677f, 
    -0.02717751f, 0.04571738f, 0.12663200f, -0.13838618f, -0.10455447f, 0.06980830f, 0.47058162f, -0.03190077f, 
    0.03610186f, 0.11405475f, -0.29632342f, 0.02855593f, 0.14494345f, -0.03361329f, 0.07125878f, 0.06963626f, 
    -0.14161159f, -0.24924225f, -0.05077255f, 0.09378584f, 0.10607507f, 0.27525374f, 0.10534669f, 0.29468375f, 
    0.29575032f, -0.09603311f, 0.14086197f, -0.14996600f, -0.07688801f, -0.10625198f, 0.02409093f, 0.18959959f, 
    -0.20133598f, 0.28970444f, 0.26435003f, 0.28166464f, -0.19555953f, 0.00012252f, 0.13144439f, -0.26818299f, 
    0.09469559f, 0.00855973f, -0.11978591f, -0.16762012f, 0.13724393f, 0.05126420f, 0.10456873f, -0.11020142f, 
    -0.10050292f, 0.05884023f, 0.08694383f, 0.27973837f, 0.06629987f, 0.11868338f, -0.28678524f, 0.24851713f, 
    -0.23064712f, 0.33097243f, -0.11365297f, -0.14304230f, 0.03036292f, 0.15841475f, 0.20517303f, 0.05690739f, 
    -0.12812775f, -0.36872622f, 0.01090322f, 0.02829683f, -0.00030239f, -0.16945365f, -0.21982186f, 0.04538986f, 
    -0.28613687f, 0.02194035f, -0.03609841f, -0.10167781f, 0.16009110f, 0.32069561f, 0.06304929f, 0.21282493f, 
    0.11950361f, -0.15643519f, 0.34094483f, 0.04361673f, -0.08354261f, -0.06139950f, -0.13559052f, 0.15029679f, 
    0.08094172f, 0.09446748f, 0.04763278f, -0.10242973f, 0.05724622f, 0.04203114f, -0.01814731f, -0.19141136f, 
    -0.25791809f, 0.13648801f, 0.17455359f, 0.06677531f, -0.24617533f, -0.06500615f, 0.17703183f, 0.15565705f, 
    -0.10698565f, -0.03336705f, -0.05659398f, -0.04428039f, -0.13025384f, -0.31786871f, -0.12069397f, -0.31749907f, 
    0.07496376f, -0.03848963f, -0.03910770f, 0.34731993f, 0.17619500f, -0.00308470f, 0.03558971f, -0.06842140f, 
    0.08211409f, 0.24657272f, 0.10931110f, 0.03929131f, 0.02810244f, 0.19511420f, 0.06961476f, -0.09042247f, 
    -0.08206139f, -0.13047479f, 0.26635215f, -0.38900557f, -0.03256271f, -0.07086032f, -0.16228905f, 0.04650730f, 
    -0.11988821f, -0.01062525f, -0.00306198f, -0.00473304f, 0.00059785f, 0.39286822f, 0.06639898f, 0.21895841f, 
    -0.00541162f, -0.08645128f, 0.17567474f, -0.10391167f, -0.09426242f, 0.38321280f, -0.01345299f, -0.15013118f, 
    -0.07268371f, 0.10127392f, -0.16169237f, -0.23473339f, -0.11284554f, -0.10992948f, 0.19127876f, -0.22210611f, 
    0.22869565f, -0.20997889f, -0.14535667f, 0.15789674f, 0.11167792f, 0.05657658f, 0.14671066f, -0.02319857f, 
    0.10322383f, 0.18905434f, 0.00782692f, 0.09448842f, 0.03376530f, -0.07653041f, 0.03910346f, -0.14991586f, 
    -0.28288403f, 0.06215544f, 0.31666592f, -0.10996488f, 0.16777046f, -0.00268990f, 0.16048485f, -0.03244356f, 
    0.11414859f, -0.04492119f, 0.08541436f, 0.15533122f, -0.15194982f, -0.00290347f, -0.03572420f, -0.01679496f, 
    -0.00800876f, 0.15899299f, 0.16996558f, 0.11166982f, 0.02236309f, 0.10069715f, 0.34790719f, -0.12266235f, 
    0.01825445f, 0.01398248f, -0.19264603f, 0.02515768f, 0.02471812f, -0.12741527f, 0.20564146f, 0.12790006f, 
    -0.05101522f, 0.34178516f, -0.08195902f, -0.09219635f, 0.37306854f, 0.02356020f, 0.26295832f, 0.08036976f, 
    -0.21574455f, -0.03642982f, 0.28152564f, 0.04297839f, -0.12106104f, 0.03076387f, -0.05827449f, 0.16976704f, 
    -0.08226033f, -0.05872390f, 0.02719545f, -0.23008053f, -0.20922509f, -0.08447943f, 0.14483780f, 0.19934024f, 
    0.08739822f, 0.14762528f, 0.20234071f, -0.33569956f, -0.14903361f, 0.08171280f, 0.04752164f, 0.03133824f, 
    0.15168139f, -0.01282657f, 0.12758437f, 0.10282206f, -0.19675228f, -0.16564338f, 0.11329807f, -0.14333715f, 
    0.00959810f, 0.04019404f, 0.12708175f, 0.27118582f, -0.04960221f, 0.21932334f, 0.08704728f, 0.09414800f, 
    -0.11482711f, 0.08830927f, 0.09478007f, -0.15974353f, -0.01974621f, 0.36493444f, 0.03258963f, -0.01417471f, 
    -0.29606402f, -0.07443416f, 0.27311134f, 0.00195371f, 0.16867001f, 0.00897984f, 0.04131647f, 0.06015253f, 
    -0.13308308f, -0.00631357f, -0.13262086f, -0.07559855f, 0.19568692f, -0.03143298f, 0.15018913f, -0.42871454f, 
    -0.01068184f, -0.09632376f, -0.10960725f, 0.07700362f, 0.09362143f, -0.08790328f, -0.10323440f, -0.11604968f, 
    0.02820542f, -0.10406046f, 0.05658279f, -0.07618194f, -0.05331168f, -0.04014763f, 0.06042504f, -0.10564625f, 
    -0.06640634f, -0.08571954f, -0.04168986f, 0.06361722f, -0.07173519f, 0.04024088f, 0.08660991f, -0.09241910f, 
    -0.02776396f, -0.07864067f, -0.10236466f, 0.09634003f, 0.00090503f, -0.13629299f, 0.04564584f, -0.10299760f, 
    -0.01766169f, -0.11404815f, -0.05479261f, -0.01601673f, 0.03338417f, -0.12130875f, 0.11215618f, -0.10973044f, 
    0.03901976f, -0.13152540f, 0.05409950f, -0.03600110f, 0.07938977f, -0.04460135f, -0.00343297f, -0.06088263f, 
    -0.04902299f, 0.06167471f, -0.08265109f, 0.10746142f, 0.08799821f, 0.00254731f, -0.06153645f, 0.07660174f, 
    0.08617850f, -0.07245772f, -0.02649601f, -0.06238882f, 0.08511647f, -0.04786930f, 0.00051782f, -0.00139587f, 
    0.00257310f, 0.04787304f, -0.13753863f, 0.10237844f, -0.13091765f, -0.04782282f, 0.12652783f, 0.09543303f, 
    -0.10579849f, -0.12132751f, 0.04133692f, -0.11726932f, 0.13973287f, -0.05377541f, -0.12760842f, 0.25196940f, 
    0.26055560f, 0.02795115f, 0.20690949f, -0.00544574f, -0.29594529f, -0.23827702f, -0.06756382f, -0.05009032f, 
    0.32275638f, -0.08153591f, -0.10276654f, 0.19372983f, 0.13507643f, 0.22662963f, 0.04001288f, -0.10688232f, 
    0.22807984f, -0.00082601f, -0.11838274f, 0.18406641f, -0.05803466f, 0.13599129f, 0.16315287f, 0.10629295f, 
    0.00684732f, 0.09901961f, 0.23332049f, -0.08437797f, 0.00034653f, 0.24501438f, 0.08158551f, 0.06668410f, 
    -0.18868792f, -0.03705752f, 0.17723645f, 0.00385685f, 0.03500270f, -0.04121556f, -0.13925357f, -0.10232362f, 
    -0.10667679f, -0.14655732f, -0.26267207f, 0.09885712f, 0.19023423f, 0.30425012f, -0.09289049f, -0.12550716f, 
    0.17694424f, -0.05666487f, -0.31384647f, 0.16734761f, -0.04328399f, 0.04874039f, 0.15826534f, 0.00162450f, 
    0.10195232f, -0.31579366f, -0.02331661f, -0.11972499f, 0.28869769f, -0.09620789f, 0.31937334f, 0.12472977f, 
    0.26525861f, -0.00551233f, -0.00890418f, 0.03856917f, -0.07280756f, -0.14025985f, 0.03902712f, 0.18171503f, 
    0.23697634f, -0.12217049f, 0.04971433f, 0.32748359f, -0.12147965f, -0.04638303f, 0.01725625f, -0.10911056f, 
    0.22334506f, 0.20131546f, 0.05411023f, -0.14977433f, -0.22894381f, 0.11360876f, 0.00749707f, -0.03837525f, 
    -0.07752153f, 0.16139005f, 0.34403101f, -0.30802780f, 0.11918374f, 0.08209392f, -0.19820988f, -0.01908881f, 
    -0.23575449f, 0.10120717f, 0.24066065f, 0.03056804f, -0.07056449f, -0.04737865f, -0.17509219f, 0.09599852f, 
    -0.24663681f, 0.42800927f, -0.08867885f, -0.04102018f, 0.22973953f, 0.13593337f, 0.08593830f, -0.11079849f, 
    -0.05038097f, -0.05222745f, 0.10473464f, 0.24321768f, 0.03267930f, -0.05578497f, 0.15197852f, 0.05850091f, 
    -0.08118620f, -0.06995443f, 0.00384658f, -0.18176255f, 0.11944576f, -0.07271226f, -0.06041213f, 0.26043570f, 
    0.15817991f, 0.12355591f, 0.13824722f, -0.06166441f, -0.26850513f, 0.04285922f, -0.00315668f, -0.08091918f, 
    0.36701354f, 0.02751254f, 0.14124337f, 0.31850785f, -0.04114276f, 0.19779606f, 0.05094917f, -0.16749381f, 
    -0.01349897f, -0.04965706f, -0.04985850f, 0.13948289f, -0.01532253f, 0.21394777f, -0.08673269f, 0.00484992f, 
    0.12865478f, 0.00437763f, -0.07529170f, 0.03335552f, 0.01419216f, 0.30820462f, -0.20488858f, -0.05161974f, 
    -0.17073046f, 0.04953322f, 0.10126422f, 0.09095855f, 0.16668522f, -0.10145970f, -0.27845398f, -0.25125217f, 
    -0.17169468f, 0.11172865f, -0.11177531f, -0.11658709f, 0.25878757f, 0.03994410f, 0.04438391f, -0.37981766f, 
    0.33490089f, 0.09664851f, -0.03292661f, 0.02100628f, -0.09316228f, -0.02736882f, 0.28121912f, 0.14112517f, 
    -0.00081239f, 0.12544520f, 0.05980854f, -0.05320983f, 0.07268319f, 0.02708145f, 0.33348286f, -0.02379877f, 
    0.15757300f, -0.01838236f, 0.19290508f, -0.04285965f, 0.21865122f, -0.01040144f, 0.12461887f, 0.09001909f, 
    -0.10413415f, -0.00865495f, 0.14606558f, -0.14766403f, -0.17789760f, -0.00261734f, -0.13472146f, 0.17086826f, 
    -0.00884356f, -0.15217844f, 0.08503852f, -0.15587696f, 0.04930997f, -0.06239219f, 0.25460950f, 0.00422428f, 
    -0.02095998f, 0.10635231f, -0.13582644f, 0.22595827f, 0.04103551f, 0.10791419f, -0.23536280f, -0.04193855f, 
    -0.23889630f, 0.08792874f, 0.20297085f, 0.08829291f, 0.07631809f, -0.15898311f, -0.18642412f, 0.08449232f, 
    0.17929427f, 0.12768285f, 0.17928350f, 0.05157964f, -0.17154901f, -0.24434882f, 0.11748169f, -0.09761260f, 
    -0.18804108f, 0.04544763f, 0.38343856f, -0.10512331f, -0.00716490f, -0.02414571f, 0.31162620f, -0.04285339f, 
    -0.07852837f, 0.13609736f, -0.02801872f, -0.14965647f, 0.01793807f, -0.09756677f, -0.34181693f, -0.02365479f, 
    -0.13795868f, 0.16220807f, -0.00819268f, -0.05829739f, 0.35630628f, 0.10479156f, 0.01510002f, 0.00573676f, 
    0.04316439f, 0.08114852f, -0.10374831f, -0.25091022f, -0.00046212f, -0.12561169f, 0.16494456f, 0.25903213f, 
    0.03906758f, -0.17732297f, 0.11127848f, 0.09641478f, -0.17338824f, 0.04441169f, 0.02610424f, -0.02464206f, 
    -0.02597911f, -0.02886779f, -0.38208345f, 0.10187604f, 0.04278430f, 0.04223186f, 0.08314782f, 0.05809334f, 
    0.32249612f, -0.12375876f, 0.12498158f, -0.08339110f, -0.11888046f, 0.11810004f, 0.19179206f, 0.03954661f, 
    0.39541337f, 0.05654557f, 0.08795166f, -0.06149313f, 0.18110521f, -0.11181579f, -0.01314760f, 0.15042163f, 
    0.25733548f, 0.01426404f, 0.18795361f, -0.13151702f, 0.10895178f, 0.07929483f, 0.26871628f, 0.04300166f, 
    -0.18123697f, 0.04644413f, 0.12877207f, 0.16224195f, -0.16868064f, -0.05711282f, 0.04965016f, 0.06684013f, 
    -0.03265449f, -0.07635809f, -0.13480416f, -0.19501014f, 0.23126313f, 0.17717421f, -0.11525197f, -0.05403350f, 
    -0.03097687f, 0.07251370f, -0.16218194f, -0.18971717f, -0.08724195f, -0.01661824f, 0.13085145f, 0.26167735f, 
    0.08135013f, 0.22714943f, 0.05291060f, -0.12021029f, -0.11358235f, -0.09044220f, 0.21982706f, -0.11950432f, 
    0.13788268f, 0.00430939f, -0.01924908f, 0.11270072f, -0.03192994f, 0.04299794f, -0.45917982f, -0.04795780f, 
    -0.02837518f, -0.08814053f, -0.00532738f, 0.01136223f, 0.09084833f, 0.22587025f, -0.10340250f, 0.10019001f, 
    0.22736865f, 0.11241100f, 0.37553635f, 0.03269044f, -0.04467342f, 0.04352556f, 0.04537424f, -0.03179456f, 
    -0.17195682f, 0.10774884f, 0.38041949f, 0.25551236f, -0.03562991f, -0.04707840f, -0.14212076f, 0.14142260f, 
    0.08078859f, 0.22037248f, -0.02239038f, -0.15942025f, 0.16617608f, 0.11051771f, -0.36249626f, 0.12392184f, 
    -0.18842737f, 0.06755134f, -0.02070681f, -0.07505754f, 0.22444479f, 0.26881272f, -0.01224463f, 0.08530182f, 
    0.18087986f, -0.03533975f, -0.20658422f, 0.08890978f, 0.13850150f, 0.04614786f, 0.00377035f, 0.08051569f, 
    -0.09225743f, -0.15050796f, -0.10377311f, 0.06084735f, 0.01710081f, 0.17048900f, 0.00530098f, 0.09490163f, 
    -0.00785281f, 0.05195798f, -0.23380858f, -0.18512198f, -0.04783606f, 0.05812461f, 0.18726797f, 0.07538857f, 
    0.15124266f, -0.07090985f, 0.08495571f, 0.01544935f, -0.04670804f, 0.06672291f, 0.12426875f, -0.12130194f, 
    0.24742629f, -0.39506039f, -0.08514820f, -0.01232384f, 0.04819613f, -0.09079978f, -0.17814648f, 0.22725131f, 
    -0.05912770f, 0.09983113f, 0.29854983f, -0.10492259f, -0.02782434f, -0.01784888f, -0.07735144f, 0.17756927f, 
    0.02091610f, -0.18293732f, 0.03771577f, 0.12097680f, -0.18817982f, -0.02405883f, 0.07127917f, 0.18557304f, 
    -0.12251291f, 0.08636813f, -0.12856629f, -0.32372060f, 0.21513639f, 0.46073246f, -0.02776998f, 0.22853753f, 
    -0.25008962f, 0.02797764f, 0.24209289f, 0.01087844f, -0.19457580f, -0.19924216f, -0.16586173f, -0.17193784f, 
    0.21237001f, -0.09317253f, 0.10158658f, 0.29433757f, -0.21655442f, 0.02594610f, -0.04510189f, -0.00217584f, 
    0.12158825f, 0.16594356f, 0.05426596f, -0.15636703f, -0.02726187f, 0.13946132f, 0.28241760f, 0.06836323f, 
    -0.24559647f, -0.10894444f, -0.19435698f, -0.07642215f, 0.02709498f, 0.25812441f, 0.15558085f, -0.04356421f, 
    -0.12041429f, -0.13504930f, 0.15058503f, -0.04930873f, 0.59648794f, 0.13250807f, 0.23096119f, 0.10490188f, 
    0.15802866f, 0.06795466f, 0.00310547f, 0.05446193f, -0.01675375f, 0.11655396f, 0.08954436f, 0.18707150f, 
    0.19224973f, -0.09868502f, 0.05389265f, 0.08355516f, -0.03044169f, -0.02299458f, -0.01524907f, -0.18698588f, 
    0.11920279f, -0.04486073f, 0.08808280f, 0.11249964f, 0.12813352f, 0.03096046f, 0.11073171f, -0.07795218f, 
    0.05409981f, -0.08758897f, 0.23089974f, 0.00264342f, 0.16291730f, 0.29035178f, -0.21533927f, -0.04429058f, 
    -0.17486745f, 0.02750056f, 0.06522745f, -0.02111371f, 0.12350216f, -0.04958341f, 0.00642355f, 0.04557790f, 
    -0.08822319f, -0.14421110f, 0.05305621f, 0.03055498f, -0.11512044f, -0.07837129f, -0.45174366f, -0.11792116f, 
    0.02891106f, 0.05916844f, -0.15031908f, -0.09413321f, 0.10841619f, 0.05474425f, -0.05256900f, 0.19826634f, 
    -0.13058777f, 0.21216938f, 0.02000408f, -0.04209934f, -0.00349661f, -0.23735236f, -0.16610469f, -0.05543068f, 
    0.12118263f, -0.13025084f, -0.06334261f, 0.15764402f, 0.00010435f, -0.04240087f, -0.21772045f, 0.27707106f, 
    0.07821680f, 0.08582745f, 0.06062854f, -0.10361801f, 0.29061925f, 0.06011972f, 0.12272862f, 0.14899349f, 
    -0.00007940f, 0.18067747f, -0.20462063f, 0.26265275f, 0.11826889f, 0.24858551f, -0.11148454f, 0.08952035f, 
    -0.10974995f, -0.01650410f, -0.08080268f, 0.27512094f, -0.05558651f, -0.04057623f, -0.41884667f, 0.10465095f, 
    0.08024434f, 0.16938224f, 0.07896265f, 0.02075874f, 0.17913483f, -0.00027443f, -0.18391529f, -0.00598593f, 
    -0.08451414f, -0.09201781f, 0.06127654f, 0.00630944f, 0.11399668f, 0.02058339f, 0.03554241f, -0.08909041f, 
    -0.00035577f, -0.11464925f, -0.16006018f, 0.07652159f, 0.07031577f, 0.02427214f, -0.00243075f, -0.14395884f, 
    0.05545926f, -0.09343279f, -0.06395711f, -0.09647782f, -0.02778178f, 0.03032966f, -0.07837421f, 0.06205400f, 
    0.04865769f, -0.12294716f, -0.25630501f, 0.25355059f, 0.12211569f, -0.06083335f, 0.11303413f, -0.04774586f, 
    -0.08293509f, 0.13729519f, 0.11619794f, 0.00928727f, 0.37700221f, 0.06945020f, -0.18567854f, -0.06737380f, 
    0.28106177f, 0.04338271f, 0.05526478f, 0.32226279f, -0.12005427f, -0.25435838f, 0.00797842f, -0.18262325f, 
    0.33243567f, 0.02269484f, -0.25388613f, 0.11561063f, -0.04177660f, 0.28569531f, 0.23182303f, 0.09308647f, 
    0.02017757f, -0.00890549f, -0.00504556f, -0.04643934f, 0.10260298f, 0.14758976f, -0.12302078f, 0.03630773f, 
    -0.10876893f, 0.02642978f, -0.15310135f, 0.00280231f, 0.04349037f, 0.13292255f, -0.45741624f, 0.01161875f, 
    0.27757719f, 0.01264104f, 0.30903029f, -0.01442694f, -0.07121687f, -0.18220253f, -0.21470109f, 0.11230566f, 
    0.17167607f, 0.31957000f, 0.02532590f, 0.06375367f, -0.04057070f, 0.17665201f, -0.10837395f, -0.04650342f, 
    0.40992177f, 0.10189717f, -0.12181693f, -0.02701065f, -0.11675392f, -0.02243055f, 0.06675526f, 0.08214597f, 
    0.09332238f, 0.02418665f, -0.01462667f, 0.24385320f, 0.06692635f, 0.03551620f, 0.22322005f, -0.01785806f, 
    -0.03833522f, 0.12049186f, -0.02120482f, 0.15064453f, 0.02252195f, -0.07455295f, 0.01070715f, 0.05196922f, 
    0.07217354f, 0.06410082f, -0.13083124f, 0.13910739f, -0.13233465f, -0.00851506f, -0.15496281f, 0.01561702f, 
    -0.04107666f, 0.07535109f, -0.08535864f, -0.13486195f, -0.08664107f, -0.16907816f, 0.04167683f, -0.10185469f, 
    -0.06806859f, 0.03300117f, 0.07233160f, 0.13627723f, -0.10357080f, 0.00315097f, -0.30906627f, 0.07362457f, 
    0.13976076f, -0.04948795f, 0.02981983f, -0.01120890f, -0.07855544f, -0.02651339f, -0.04406646f, 0.14175345f, 
    -0.12457098f, 0.08687503f, 0.20543218f, 0.05654098f, -0.16269194f, 0.05109447f, 0.16010843f, -0.16326417f, 
    -0.01193036f, 0.11934484f, -0.33944210f, 0.33383724f, -0.11680351f, -0.00231423f, -0.17477453f, 0.29807428f, 
    0.02355005f, -0.16342661f, 0.20306185f, -0.17996585f, 0.04662332f, 0.08287244f, -0.06758400f, 0.11351968f, 
    0.30191815f, 0.08990180f, 0.11611033f, 0.18436153f, -0.32200786f, 0.14530441f, 0.06747805f, 0.38283518f, 
    0.07934552f, 0.02446726f, 0.24492951f, 0.02508074f, -0.17984128f, -0.21988280f, -0.02690989f, 0.00786534f, 
    -0.03303643f, -0.17003825f, -0.03783837f, 0.02126998f, 0.05445424f, -0.03892106f, -0.05938850f, 0.02771755f, 
    0.05376441f, 0.19796814f, 0.03079026f, 0.21117350f, -0.04306144f, 0.01723051f, 0.23726694f, -0.00420906f, 
    0.27798915f, -0.02621949f, 0.04004005f, 0.10835791f, 0.17613603f, -0.39306700f, 0.11698161f, -0.11825018f, 
    -0.29010326f, -0.06695315f, -0.22778907f, 0.06999368f, 0.01245315f, -0.02448102f, 0.10260811f, -0.27148625f, 
    0.08069714f, 0.01017996f, 0.20389046f, -0.05478095f, 0.02615846f, -0.06784553f, -0.16528346f, 0.07000101f, 
    0.12236416f, 0.10226816f, 0.00664229f, 0.18190309f, -0.08788355f, 0.02491415f, 0.09169146f, -0.01452533f, 
    -0.23123501f, 0.17594969f, -0.21930374f, 0.14418466f, 0.18638265f, 0.20317809f, -0.07846595f, 0.22593597f, 
    -0.02146353f, 0.12628624f, -0.10669634f, 0.13067614f, -0.26797333f, -0.24129225f, -0.27319387f, 0.16117032f, 
    0.18211964f, 0.21085863f, -0.07564351f, 0.08521686f, 0.02742685f, -0.13934958f, -0.01308260f, -0.00474336f, 
    0.09557468f, 0.07709046f, 0.03928654f, -0.15848956f, -0.08399398f, -0.01486332f, 0.14941879f, 0.04742330f, 
    -0.03146787f, -0.10901485f, -0.19351843f, 0.01382116f, 0.02317057f, 0.22334845f, 0.31745121f, 0.14244820f, 
    0.14038062f, -0.12675492f, 0.07325901f, -0.01901756f, 0.15579288f, 0.29375163f, 0.05871355f, 0.28041935f, 
    -0.00474346f, -0.06260997f, 0.11972915f, -0.08098515f, -0.04094186f, 0.00146938f, 0.03059370f, -0.11308113f, 
    -0.09717713f, 0.11134921f, 0.06008270f, -0.13435866f, 0.12446123f, -0.03393883f, -0.08548319f, 0.09510045f, 
    -0.02756640f, -0.07808089f, -0.07882447f, -0.10872642f, 0.05348691f, 0.06679422f, 0.06470747f, -0.06403533f, 
    -0.08881187f, 0.03293452f, -0.11592557f, 0.00044841f, -0.05073885f, 0.11070462f, 0.08161317f, -0.09881565f, 
    0.00736954f, -0.00777806f, -0.10826140f, -0.11814921f, -0.02000898f, -0.05716614f, 0.08477666f, -0.07498121f, 
    0.09285976f, -0.00077264f, -0.06869998f, -0.03587804f, -0.03242327f, -0.11419479f, -0.08311408f, -0.01940572f, 
    -0.02601739f, 0.07899843f, -0.09039852f, -0.07277354f, -0.03840191f, -0.05099514f, -0.03527407f, -0.08184966f, 
    0.02989776f, 0.06043109f, 0.07068438f, 0.02581863f, -0.10768078f, -0.02667738f, 0.06726822f, -0.03509468f, 
    0.12715992f, -0.09298991f, -0.03847295f, -0.17700806f, 0.07942990f, 0.03512424f, 0.23510969f, -0.16242054f, 
    -0.04861781f, 0.17315048f, 0.08197469f, 0.23215389f, -0.01536122f, -0.04962049f, -0.35224235f, -0.22592892f, 
    0.14164616f, 0.08152711f, -0.00124127f, 0.15886496f, 0.11343928f, -0.02759020f, -0.12013796f, -0.26464173f, 
    -0.17512234f, 0.12258559f, 0.05222712f, -0.29413301f, 0.27763042f, 0.30081901f, 0.02202873f, 0.24831790f, 
    0.00552000f, -0.07914896f, 0.07781878f, -0.01300386f, 0.06415793f, -0.03919439f, 0.01681918f, -0.10158117f, 
    -0.08842952f, -0.03733886f, -0.25910613f, 0.37630010f, -0.07715882f, -0.20165527f, -0.01444037f, -0.03802203f, 
    0.30457041f, -0.06146731f, -0.13322811f, 0.03827367f, 0.02973575f, 0.02093994f, -0.18807864f, 0.12518026f, 
    0.13482270f, 0.22570409f, 0.08227528f, 0.06809534f, 0.14413233f, -0.20596157f, 0.15427950f, 0.07952204f, 
    0.05243420f, 0.00215324f, -0.09299320f, 0.11568490f, 0.02171359f, 0.12330486f, -0.45815751f, -0.00041705f, 
    0.07070161f, 0.08063125f, 0.28734809f, -0.02213631f, -0.04915601f, 0.07147856f, 0.12948574f, -0.05154673f, 
    0.03356406f, 0.16671193f, -0.08445194f, 0.34965202f, -0.20494039f, 0.29753873f, -0.04351321f, 0.24717855f, 
    -0.24407348f, -0.02847333f, -0.05157977f, 0.23362181f, -0.24840227f, -0.20254844f, -0.36010563f, -0.02670682f, 
    0.03977432f, 0.08136570f, -0.08735839f, 0.14301179f, 0.28646260f, -0.12759827f, -0.12358126f, 0.10399050f, 
    0.04228124f, 0.01006290f, 0.24710403f, -0.10815943f, -0.12391897f, -0.01160310f, 0.10974403f, -0.00535257f, 
    0.01242162f, -0.06026927f, -0.10011093f, 0.03684031f, 0.05823835f, -0.24123369f, 0.20587131f, 0.09443861f, 
    -0.25865674f, -0.17813832f, -0.19413351f, -0.07870195f, -0.20973876f, 0.14526632f, 0.13558930f, 0.12614259f, 
    0.25310975f, 0.05130997f, 0.05505311f, -0.10535177f, -0.03282541f, 0.05310690f, 0.21517119f, -0.28049073f, 
    0.07737046f, 0.20909305f, 0.05750065f, 0.17198129f, -0.17070626f, -0.08441797f, 0.21500356f, -0.03701008f, 
    -0.01032312f, 0.07443784f, 0.02161418f, -0.26614732f, 0.37415102f, 0.09217043f, 0.12191628f, -0.05827445f, 
    -0.24106358f, 0.07859996f, 0.31447244f, -0.14172003f, 0.14314930f, 0.19908465f, 0.13679300f, 0.10625186f, 
    -0.06647118f, -0.13047475f, -0.09322982f, -0.07910588f, 0.08870658f, -0.04412021f, 0.02783034f, -0.11164550f, 
    -0.06483593f, -0.05587894f, 0.03082488f, 0.12626009f, -0.04200716f, 0.02905405f, 0.29936638f, -0.11507619f, 
    0.04507472f, -0.07780370f, -0.22104126f, 0.12492274f, 0.01859507f, 0.18002105f, 0.02384865f, 0.20411083f, 
    0.02797066f, 0.08774126f, 0.11107057f, -0.01233824f, 0.31228983f, -0.17385988f, 0.21197031f, 0.22269507f, 
    -0.04013478f, -0.09457017f, 0.19719924f, -0.14035049f, 0.03322022f, 0.01565945f, 0.22630596f, -0.15462498f, 
    0.05446865f, 0.17992535f, -0.05898040f, -0.02126750f, -0.20293434f, 0.00539444f, 0.10711025f, 0.00492672f, 
    -0.03750577f, -0.06499651f, 0.19198328f, -0.15391929f, 0.20600961f, -0.08358517f, 0.03257909f, -0.24306647f, 
    -0.11819036f, -0.01200262f, 0.36648485f, -0.19780912f, 0.14037862f, -0.06487157f, 0.25804159f, 0.05308828f, 
    -0.18794434f, -0.17875144f, -0.00561213f, 0.02453549f, 0.24100213f, 0.15197031f, 0.17990185f, -0.02191407f, 
    0.07791232f, -0.09911331f, -0.09599791f, 0.24297261f, 0.01387409f, 0.19653247f, 0.15219025f, -0.10851162f, 
    0.16961846f, -0.00648468f, 0.08371772f, 0.07739064f, 0.18558146f, 0.12516476f, 0.27550343f, 0.06505223f, 
    0.21957889f, 0.08668201f, 0.09452572f, 0.02720170f, 0.04193231f, -0.19583569f, 0.14808778f, -0.10860192f, 
    -0.06343849f, 0.08978455f, 0.14464976f, -0.12002014f, -0.04185803f, 0.12061535f, 0.09355058f, -0.08691896f, 
    0.25231183f, 0.06188707f, -0.02685139f, 0.14023359f, -0.17794707f, -0.05055185f, 0.08756895f, 0.02591861f, 
    -0.12456888f, 0.15543485f, 0.21738900f, -0.21262220f, 0.08363026f, 0.39665207f, 0.11110564f, 0.36830962f, 
    -0.28913388f, -0.07407318f, 0.18396710f, -0.29371616f, -0.06302581f, -0.00286863f, -0.11460615f, 0.08354790f, 
    0.09939789f, -0.40864673f, 0.02262002f, 0.13968411f, -0.18376546f, -0.17970489f, 0.17098074f, -0.06421319f, 
    -0.08889976f, 0.00925576f, -0.13090242f, 0.28866798f, 0.07831336f, -0.04850062f, 0.51771861f, -0.09882705f, 
    0.04377094f, 0.06118372f, -0.22816977f, -0.00787380f, 0.11349580f, -0.00444662f, -0.00228476f, -0.09585764f, 
    -0.02314147f, -0.26631314f, -0.08998597f, 0.06824373f, 0.17776771f, -0.26919189f, 0.05595157f, 0.41281736f, 
    -0.06829615f, -0.06722198f, 0.06700134f, -0.08197781f, -0.08538203f, -0.05430911f, -0.04905324f, -0.11008529f, 
    -0.04730449f, 0.06285372f, -0.12810706f, -0.06449962f, 0.07633175f, -0.06549124f, -0.12397898f, -0.10670140f, 
    0.08708063f, -0.00845548f, -0.07379805f, -0.00993080f, -0.00408698f, -0.03785383f, -0.11881956f, -0.07488070f, 
    0.06891912f, -0.04947406f, -0.06722926f, 0.01987033f, -0.04805585f, 0.11066180f, -0.01354801f, -0.08887745f, 
    0.00724703f, -0.06790791f, 0.04859831f, -0.00589510f, -0.09972356f, -0.05229072f, -0.08099699f, 0.08265469f, 
    -0.04737427f, 0.04883318f, 0.02068472f, -0.09326361f, 0.09240326f, 0.07466114f, 0.06966801f, 0.02515717f, 
    -0.03874335f, 0.08876652f, -0.03740885f, -0.02544634f, -0.03040597f, 0.00637664f, 0.06428450f, 0.08965920f, 
    -0.06732304f, -0.00608845f, -0.09549326f, -0.01339451f, 0.08223140f, -0.04396617f, 0.02071974f, -0.11034906f, 
    -0.15177369f, -0.00085865f, 0.36977154f, 0.10778015f, 0.02446450f, -0.06763966f, -0.04097655f, 0.19982347f, 
    -0.01838112f, 0.12655066f, 0.08950714f, -0.13805375f, -0.24094972f, -0.08217287f, 0.02794012f, 0.08570296f, 
    -0.26789111f, 0.07260177f, -0.09435555f, 0.05683251f, 0.05762600f, 0.17709775f, -0.02659626f, 0.20260493f, 
    -0.04498860f, 0.11340726f, -0.30385938f, -0.07138044f, -0.29878980f, -0.31810242f, 0.09897687f, 0.16066630f, 
    0.12446158f, 0.05914815f, 0.09456231f, 0.07144043f, -0.08607224f, -0.06737024f, -0.05032511f, 0.00953608f, 
    -0.09481639f, 0.01594772f, 0.02356092f, 0.17822319f, 0.07494875f, -0.17919120f, -0.01893765f, -0.09740003f, 
    0.21959178f, 0.02652438f, 0.18442143f, 0.10420783f, -0.07268654f, 0.23696584f, 0.12759258f, 0.15944265f, 
    0.31154391f, -0.12194911f, 0.19903441f, -0.11913677f, -0.20211545f, -0.08402151f, -0.10951611f, 0.16802552f, 
    -0.08010193f, 0.01799143f, -0.10278444f, -0.00549527f, 0.07310930f, 0.10040177f, -0.18052562f, -0.04987032f, 
    0.17516737f, -0.17038655f, -0.14847434f, 0.18222800f, -0.04389556f, 0.05100132f, 0.28204757f, 0.02458103f, 
    0.20195507f, 0.14864247f, -0.00677213f, 0.17979151f, -0.11948754f, 0.12374148f, 0.06853853f, -0.05512721f, 
    -0.25371546f, 0.10022247f, 0.34533662f, 0.08350681f, -0.09659638f, -0.16612834f, -0.19692634f, -0.03293317f, 
    0.15132578f, 0.08913506f, -0.01777054f, 0.21948066f, 0.10657573f, -0.14936703f, 0.05470836f, -0.01058959f, 
    0.10056852f, 0.16123797f, 0.21070407f, 0.26876208f, -0.08990835f, 0.13613984f, 0.27747381f, -0.07996646f, 
    -0.14779571f, 0.04202630f, -0.03448166f, -0.10430030f, 0.22002742f, -0.23581980f, -0.12951705f, -0.00294773f, 
    -0.34694844f, 0.00193726f, -0.04728341f, -0.09052988f, 0.22847851f, -0.03071229f, 0.05079133f, -0.19713984f, 
    -0.04989411f, 0.08540499f, 0.04756495f, -0.00685466f, -0.03533876f, 0.03608888f, 0.29013681f, -0.14434342f, 
    -0.22378509f, 0.14056818f, 0.06230003f, -0.01042821f, -0.18516760f, -0.08483876f, 0.02122542f, -0.03092169f, 
    0.04923752f, -0.04452499f, -0.05015593f, -0.41810802f, 0.07913178f, 0.02628414f, -0.04969442f, -0.20899668f, 
    0.17800695f, 0.01302403f, 0.04766527f, -0.00315460f, -0.04033634f, -0.18274899f, 0.47964844f, 0.09291203f, 
    0.08445743f, 0.07452615f, -0.09199153f, 0.04665548f, -0.11519502f, 0.19534847f, -0.12583996f, -0.02782681f, 
    0.04145379f, 0.04396951f, -0.27313501f, 0.19066274f, 0.03861515f, 0.19713700f, -0.07720076f, 0.10423768f, 
    -0.00373176f, -0.04049194f, 0.07669939f, -0.09295578f, 0.08235614f, 0.19428718f, -0.20111820f, -0.00426906f, 
    0.19856116f, 0.43949619f, 0.23443410f, -0.05581939f, 0.12577127f, -0.07929951f, 0.13444971f, -0.04375334f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10760003f, -0.08947568f, 0.15340653f, 0.11652207f, 0.07477768f, 0.06168356f, 0.00736267f, 0.11057902f, 
    -0.08146887f, -0.16675742f, -0.05953130f, 0.02218300f, 0.09648044f, 0.02813451f, 0.02348766f, 0.14796436f, 
    -0.07396061f, 0.03635779f, -0.02417138f, -0.09819252f, 0.10627238f, 0.09723340f, -0.08174084f, 0.11403377f, 
    0.02735359f, 0.15085652f, -0.04803745f, 0.11443621f, 0.03586006f, 0.19781896f, -0.02087812f, -0.08331396f, 
    0.03567523f, -0.06937855f, 0.09284094f, -0.06909654f, 0.06491984f, -0.05874354f, 0.04168843f, -0.05331925f, 
    0.08900465f, -0.00825842f, 0.02622892f, -0.09078068f, 0.01296196f, 0.19209972f, 0.11703593f, 0.15060128f, 
    -0.08720516f, -0.00160083f, -0.01137510f, 0.13162236f, -0.10099805f, 0.20705873f, 0.01180853f, 0.04067925f, 
    0.04637621f, -0.04521849f, 0.09577654f, -0.04346450f, -0.08954092f, 0.18831627f, 0.11039979f, 0.06660360f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.04123643f, 0.11286174f, 0.02204129f, 0.19578056f, -0.04492183f, -0.01021082f, 0.21160892f, 0.26557666f, 
    0.03560772f, -0.10867576f, -0.20320454f, -0.16998976f, -0.20522520f, -0.16021487f, -0.29215172f, -0.32860145f, 
    0.34747291f, 0.10346365f, 0.40738821f, 0.10475381f, 0.07061578f, -0.04171946f, 0.03419250f, -0.46882430f, 
    0.11747612f, 0.08108777f, 0.10866221f, 0.03998288f, 0.02937600f, -0.01961190f, -0.22822155f, 0.03952028f, 
    -0.05113308f, -0.05076447f, -0.29720509f, -0.31715739f, -0.52523404f, -0.05291893f, 0.16331802f, -0.13292457f, 
    0.09984670f, 0.19808730f, 0.25637013f, 0.10064735f, -0.22003540f, -0.19249953f, -0.18715246f, -0.09399064f, 
    0.24622020f, -0.06690849f, 0.11730573f, -0.07975183f, 0.22122216f, -0.50644261f, -0.04216355f, -0.47602615f, 
    -0.22311634f, -0.22706325f, 0.03970639f, -0.29687598f, 0.08598768f, -0.22906244f, 0.01234564f, 0.24234828f, 
    0.09612662f, -0.04540963f, 0.16861157f, -0.14237586f, -0.06011594f, -0.13423997f, 0.09055093f, -0.10635668f, 
    0.05020162f, -0.17905882f, -0.30107743f, 0.07736454f, 0.31457266f, 0.11249980f, -0.06162459f, -0.11249089f, 
    0.03350193f, 0.13279100f, -0.09363574f, -0.03666474f, -0.08936342f, -0.11376975f, -0.21725708f, 0.26844233f, 
    0.06039006f, 0.22312085f, 0.00567221f, -0.01876319f, 0.18594208f, 0.16046403f, 0.40800124f, -0.53854007f, 
    0.38102213f, 0.06032714f, 0.01185014f, 0.14878953f, 0.19399360f, -0.16142917f, 0.06268961f, -0.04377609f, 
    0.19453627f, 0.02512910f, 0.21267681f, -0.18095404f, -0.12919140f, -0.31627047f, 0.25762036f, 0.06092351f, 
    -0.14711946f, 0.23827486f, -0.03605623f, -0.12192013f, 0.29831716f, -0.00696100f, 0.08110166f, -0.27171013f, 
    0.14323260f, -0.33513117f, -0.43350992f, 0.04538818f, -0.10397612f, 0.12698106f, -0.01189620f, -0.43301436f, 
    0.00897067f, 0.08711576f, 0.16437179f, -0.35773718f, 0.05061435f, 0.14572909f, -0.15626346f, 0.12703946f, 
    -0.08738309f, 0.22922474f, 0.01721857f, -0.13328454f, -0.30708203f, -0.19449601f, 0.20702980f, 0.31424108f, 
    0.09966630f, -0.01826750f, 0.15988055f, -0.03195715f, -0.42402649f, -0.30825424f, -0.23364615f, -0.53065842f, 
    0.14398572f, -0.53178763f, -0.05968209f, 0.23315223f, 0.09558982f, 0.10212703f, 0.21610683f, -0.30055621f, 
    -0.50605601f, -0.07308073f, 0.00910299f, -0.63935280f, -0.34417966f, 0.14454380f, -0.25557330f, -0.07716257f, 
    -0.04273351f, 0.18111776f, -0.18212312f, -0.05195719f, 0.27863359f, -0.08454117f, 0.19733946f, 0.00971407f, 
    -0.11267355f, 0.06112857f, 0.23095840f, -0.12414641f, -0.39045474f, 0.02435760f, 0.07627580f, -0.00399781f, 
    -0.35958010f, 0.02840993f, -0.15723018f, -0.30169350f, 0.03625283f, -0.12348433f, -0.44221714f, 0.01045736f, 
    -0.06460290f, 0.03406507f, -0.49155974f, 0.44568959f, 0.04062255f, 0.14875340f, -0.29622477f, -0.41165659f, 
    -0.00986923f, 0.13878587f, 0.04657891f, -0.13529140f, 0.26549903f, -0.08637417f, 0.02583379f, -0.27098057f, 
    -0.15916446f, -0.13547088f, -0.16386989f, 0.09800036f, 0.18757562f, 0.09816956f, -0.27201489f, 0.21752909f, 
    0.17877114f, -0.29700506f, 0.07041716f, 0.16726993f, -0.75440568f, -0.06839381f, 0.10050262f, -0.00656903f, 
    -0.51641625f, 0.01929391f, -0.07386159f, 0.06015602f, 0.07333501f, -0.24703358f, 0.01275298f, -0.00477068f, 
    0.17063919f, 0.02246547f, 0.19624235f, 0.18973742f, -0.20967388f, 0.08461493f, -0.16825669f, -0.41693345f, 
    -0.08385258f, -0.39178449f, 0.24662597f, 0.15419471f, -0.48160204f, -0.15453444f, 0.05252721f, 0.04727881f, 
    -0.23057449f, -0.01075862f, 0.04372114f, -0.27721801f, 0.00389688f, -0.22254826f, -0.38501123f, 0.02226532f, 
    0.10858460f, 0.00411369f, -0.33865154f, 0.00194379f, -0.11751411f, -0.20573835f, 0.18241678f, -0.45219997f, 
    0.06022948f, -0.43538967f, 0.29224613f, -0.04978175f, 0.06887143f, 0.15996705f, 0.14781538f, 0.29516366f, 
    -0.05771782f, 0.15385042f, -0.14576232f, -0.00620548f, 0.27998358f, 0.10358531f, 0.27362019f, -0.21029694f, 
    0.16352102f, -0.34578228f, 0.09347389f, -0.18674776f, 0.06884821f, -0.18115421f, 0.13153751f, -0.05332015f, 
    0.01109821f, -0.09999667f, -0.11507789f, -0.01153747f, -0.31279096f, 0.08890269f, -0.12294656f, -0.04271530f, 
    -0.02353190f, -0.07257148f, 0.15151516f, 0.13037978f, -0.01296454f, -0.01900281f, -0.18229185f, 0.01459077f, 
    0.21980645f, 0.10800698f, 0.10067223f, 0.07416616f, -0.03510946f, -0.14075403f, 0.06685791f, 0.28476387f, 
    -0.29367226f, 0.01821505f, -0.04322535f, -0.13006556f, -0.03214328f, -0.32617107f, 0.09253946f, -0.01443087f, 
    0.07846083f, -0.09055628f, -0.09030809f, -0.17081395f, 0.21589310f, 0.00278697f, 0.25856116f, -0.16417925f, 
    0.06862750f, -0.01597256f, -0.07009439f, 0.04657512f, -0.20365109f, -0.14712383f, -0.37629637f, -0.08916925f, 
    -0.21758932f, -0.07847948f, -0.36161107f, 0.06671556f, 0.13401785f, 0.09252428f, 0.08362040f, -0.04273648f, 
    0.12239634f, 0.16320261f, 0.08348753f, -0.23588467f, 0.16521803f, -0.09768788f, -0.33769387f, 0.18592680f, 
    -0.57802725f, 0.07164262f, 0.17302667f, -0.22657537f, 0.16701703f, 0.15315963f, 0.01744156f, -0.11569994f, 
    -0.07473719f, 0.03628780f, -0.13654506f, 0.09605955f, -0.29226759f, -0.27740610f, -0.06958050f, 0.17468286f, 
    -0.23327962f, 0.21326280f, -0.46022695f, -0.03166857f, 0.12343720f, 0.15818056f, -0.10888492f, -0.38511604f, 
    0.39010954f, 0.06475690f, -0.05858807f, 0.27624843f, 0.07260293f, -0.09294853f, 0.18540540f, -0.42247799f, 
    0.06785482f, -0.02971943f, 0.26976579f, 0.12517233f, -0.06711640f, 0.22269641f, -0.29820412f, 0.15761535f, 
    -0.03096405f, 0.16584644f, -0.16998534f, -0.11599902f, -0.17960778f, 0.17848013f, 0.01254666f, -0.43211979f, 
    -0.32220992f, 0.19184703f, -0.48279527f, -0.09373110f, 0.09240609f, -0.10156561f, -0.14749840f, -0.33131766f, 
    -0.12225086f, -0.16674882f, -0.00781777f, -0.25626901f, 0.05305464f, -0.03096818f, -0.29401854f, 0.00614287f, 
    -0.13277476f, 0.01825756f, 0.19297895f, -0.62955946f, -0.13498223f, 0.24072093f, 0.11994340f, 0.04731711f, 
    0.04000631f, -0.24702565f, 0.00832426f, -0.05727436f, 0.17670278f, -0.21813002f, 0.03734264f, 0.13945268f, 
    -0.28383017f, -0.36970824f, -0.32804582f, -0.40473798f, -0.01363469f, -0.19331817f, -0.02246616f, 0.10566184f, 
    -0.41997156f, 0.20554794f, 0.33942720f, 0.27195027f, -0.00856226f, -0.38098186f, 0.05709890f, 0.18448354f, 
    -0.11800627f, -0.01623246f, 0.07626516f, -0.35807043f, 0.10421621f, -0.36565894f, -0.01065972f, -0.01790148f, 
    0.07646647f, 0.20558523f, 0.16804700f, -0.04789098f, -0.30598220f, -0.20432802f, 0.07360863f, 0.05620828f, 
    0.16237161f, -0.08248442f, 0.05372140f, -0.10280190f, -0.14532132f, -0.52320415f, 0.04400886f, 0.17915589f, 
    0.11322217f, 0.20634001f, 0.04240843f, 0.02268356f, 0.13219176f, -0.35144886f, -0.20465514f, 0.25853941f, 
    0.09298453f, -0.09677692f, 0.17059612f, 0.13054934f, 0.17587560f, -0.13346690f, -0.49995369f, -0.03309349f, 
    -0.42314476f, -0.18970411f, -0.37803808f, -0.08226330f, -0.19035393f, 0.03867975f, -0.17847835f, -0.19962634f, 
    0.25109938f, -0.13608758f, -0.01184809f, 0.07932114f, 0.19570354f, -0.06105630f, -0.05658605f, 0.27348021f, 
    0.00806907f, 0.26174441f, 0.14460096f, -0.05369232f, 0.07266898f, -0.22811756f, -0.22342455f, 0.04568664f, 
    -0.09076711f, 0.00375733f, -0.16826960f, -0.23926078f, 0.15894610f, 0.12594345f, 0.28706631f, -0.06798396f, 
    0.08013885f, 0.20478408f, 0.07151681f, 0.01311896f, 0.24367073f, 0.28355229f, -0.40668076f, 0.38959956f, 
    -0.32360527f, -0.49974078f, 0.12601060f, 0.10293827f, -0.19687322f, 0.13594981f, -0.22137837f, -0.17063387f, 
    -0.51081109f, 0.34106272f, -0.07253715f, 0.33796847f, 0.06444482f, -0.05404268f, 0.00126016f, -0.12120190f, 
    -0.09274823f, 0.04986388f, -0.05687688f, -0.27221581f, -0.02021940f, 0.17481443f, -0.32645425f, -0.11732178f, 
    -0.03187115f, -0.15752347f, -0.39783302f, -0.49189898f, -0.07275593f, -0.34153524f, -0.20190875f, -0.24193600f, 
    -0.16138522f, 0.06432599f, 0.09442768f, 0.00859870f, 0.19144641f, 0.04293748f, 0.04473649f, 0.26230937f, 
    0.32966456f, -0.21778189f, -0.07290632f, -0.25791088f, -0.02247990f, 0.00023998f, 0.10526408f, -0.25712392f, 
    0.10270341f, -0.03238915f, 0.17868128f, 0.20356326f, -0.35815278f, -0.00557967f, -0.17748158f, 0.30340743f, 
    0.01280671f, -0.30222797f, -0.24765305f, -0.00215617f, 0.06313132f, -0.48027837f, 0.10976563f, 0.15719704f, 
    0.11738790f, 0.19256710f, 0.31689784f, 0.05475987f, -0.08515514f, 0.10939962f, 0.07278040f, 0.13450612f, 
    0.11843440f, -0.16969976f, -0.04797655f, -0.32842404f, 0.09174518f, -0.08691826f, -0.08717436f, 0.13790706f, 
    0.33980250f, -0.11311928f, -0.17950258f, 0.17773652f, -0.25495416f, 0.03409139f, -0.12029798f, -0.08186784f, 
    -0.30453768f, -0.11713775f, -0.49105036f, 0.16019922f, 0.18448380f, 0.16788858f, -0.12863229f, 0.12964669f, 
    0.19645897f, -0.11273079f, -0.24061026f, 0.06027806f, -0.25457776f, 0.17317179f, 0.04303911f, 0.04272965f, 
    -0.24162230f, 0.04394164f, 0.02107507f, 0.21436881f, -0.11117307f, 0.48064649f, -0.10373666f, 0.04464076f, 
    0.08249628f, 0.04668391f, 0.08212863f, -0.17201056f, 0.30750206f, 0.15386619f, -0.34257096f, -0.18832017f, 
    0.05610127f, -0.14994432f, 0.04460101f, -0.02399946f, 0.13423632f, 0.13738203f, -0.01526470f, 0.20978963f, 
    -0.13612662f, -0.45888051f, -0.50803638f, 0.08485057f, -0.28388944f, 0.17056367f, -0.29138094f, -0.10881679f, 
    -0.12016719f, -0.32071459f, -0.05446028f, 0.11520660f, -0.25195396f, 0.19099461f, 0.12123983f, -0.08116739f, 
    -0.07019624f, 0.02373932f, -0.20229648f, 0.07577901f, 0.07184926f, -0.48366439f, 0.11486842f, -0.10622249f, 
    -0.29031938f, -0.71215504f, -0.02637552f, -0.02709112f, 0.29794168f, 0.16075262f, 0.31937152f, 0.17671104f, 
    -0.35815281f, 0.16595878f, -0.10862114f, -0.13703939f, -0.38700762f, 0.23931012f, -0.00496082f, -0.10942466f, 
    0.02684360f, -0.00803780f, 0.18169273f, -0.27873787f, 0.05772993f, 0.39992616f, -0.19736551f, 0.17087932f, 
    0.10818200f, 0.10679875f, -0.05269794f, -0.22197081f, -0.41421968f, 0.27664128f, -0.34637231f, 0.20202971f, 
    -0.03265426f, -0.10277306f, -0.09707145f, 0.04518745f, -0.05425474f, 0.11874607f, 0.25528163f, -0.15576540f, 
    -0.26107568f, -0.17855850f, -0.19815259f, -0.03170091f, 0.07777912f, 0.04401585f, 0.31983328f, 0.21376401f, 
    0.01548440f, -0.14584428f, 0.04735352f, -0.28379142f, -0.35882705f, -0.04974332f, 0.02459799f, -0.09678165f, 
    -0.43971324f, -0.11261851f, 0.12610705f, -0.17907304f, 0.25630993f, 0.15486285f, 0.15405142f, 0.06469288f, 
    0.20452829f, 0.32518619f, 0.22711334f, -0.20055808f, -0.23448123f, -0.00363376f, -0.15214321f, 0.31100869f, 
    -0.27785394f, -0.08669420f, -0.13342072f, -0.03640245f, -0.46469960f, 0.17224596f, 0.02985002f, -0.38484725f, 
    -0.12912223f, -0.03859130f, -0.13453954f, -0.45324081f, -0.03465666f, -0.21170853f, 0.13013978f, 0.10960528f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.18183030f, 0.01585105f, 0.00717783f, 0.08447703f, 0.05055392f, -0.07412723f, -0.06007747f, -0.08833108f, 
    0.07878634f, -0.02978071f, 0.19183010f, 0.09599553f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
