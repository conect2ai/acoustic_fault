#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.82105017f, -0.84687465f, -1.13679993f, 1.08145392f, 0.17057788f, 0.58047199f, 0.79208285f, -0.58797973f, 
    0.63267285f, -0.76256096f, 0.11370194f, 0.34614611f, -0.30696473f, 0.48571423f, -0.31416160f, 0.03760944f, 
    -0.24805909f, -0.42584959f, -0.18313904f, -0.12716213f, -0.12150767f, 0.22894266f, -0.13716944f, -0.14520782f, 
    -0.28542337f, 0.08155721f, 1.16647649f, 0.86204153f, 0.31714663f, 1.01610434f, 1.40989065f, 0.85443854f, 
    -0.63424420f, -0.52733648f, -0.70579422f, 0.34598899f, 0.31131470f, 0.18597482f, 0.14527640f, -0.74033982f, 
    -0.05754589f, 0.14585674f, 0.43642172f, -0.19670407f, -0.00338862f, -0.00096880f, 0.00779022f, -0.26147890f, 
    -0.28956032f, 0.03711648f, -0.24676599f, -2.05134845f, -0.09429231f, 0.80711269f, 0.24366218f, -1.41940045f, 
    1.05039012f, 0.91740531f, -0.53760743f, 0.11673700f, 0.30745947f, 0.25580615f, -0.16422749f, -0.15840545f, 
    -0.02499267f, -0.30550826f, -0.00542673f, -0.20965503f, 0.01192061f, -0.24192053f, 0.01034494f, -0.06871331f, 
    -0.12751549f, 0.18019018f, -0.09970361f, 1.15890086f, 0.21846740f, 0.70965707f, 1.44569957f, 1.00658381f, 
    0.32265913f, 0.20493591f, -0.12688994f, 0.35021046f, 0.54314286f, -0.01956784f, 0.08180656f, -0.58414912f, 
    -0.23574451f, -0.29340509f, -0.47322327f, -0.16716804f, -0.57022601f, -0.34188652f, -0.48099911f, 0.13737714f, 
    0.40840173f, -0.28471494f, -0.33254132f, 0.18418416f, 1.65733063f, -0.11082139f, -1.01195264f, -1.26720154f, 
    -0.37114066f, -0.28178513f, 0.15433155f, -0.58276409f, -0.30491009f, -0.30286226f, 0.14034869f, -0.50765222f, 
    -0.03174818f, -0.30932593f, -0.18364421f, 0.05768383f, 0.14965393f, -0.54836202f, -0.09635701f, 0.21261820f, 
    0.11164022f, -0.01098655f, 0.07524409f, -0.14907083f, 0.01762837f, -0.69985825f, -1.33586252f, -1.23208296f, 
    -0.78283215f, -0.91048503f, -0.09325645f, 0.92061514f, 0.89128458f, 0.25591701f, 0.94816834f, 0.00025449f, 
    -0.21478471f, -0.10371796f, -0.06167816f, -0.31144086f, 0.00433646f, 0.18833114f, 0.00264238f, -0.15670882f, 
    0.12258224f, -0.22466321f, 0.09926440f, 0.02187548f, 0.06195847f, 0.47393432f, 0.80628806f, -0.13206893f, 
    -0.83356065f, 1.85275638f, 1.01093554f, 0.55764627f, 0.41522872f, -0.05970989f, 0.44883752f, -0.24047373f, 
    -0.22478822f, -0.05941793f, -0.15918496f, 0.05980520f, -0.18672442f, 0.47827467f, 0.34883985f, 0.00814863f, 
    -0.09537417f, 0.06702382f, 0.21913873f, 0.18655707f, -0.02304507f, 0.25031400f, 0.43813562f, 1.12842548f, 
    0.79505765f, 1.18437779f, -0.13525875f, -1.61226082f, -0.20130256f, -0.34621206f, 0.47963157f, 0.31903952f, 
    0.56413877f, 0.59184617f, 0.17116620f, -0.36701182f, 0.06887603f, 0.20602900f, -0.08751658f, 0.09883993f, 
    -0.22852665f, -0.35344109f, -0.05824054f, 0.10711293f, 0.15424165f, 0.09164400f, 0.05915273f, -0.15187833f, 
    1.64871132f, -0.03026049f, 0.81881005f, -0.37969953f, 0.23011272f, -0.18680640f, 0.08777926f, -0.26034623f, 
    0.34443074f, 0.66592580f, -0.27890718f, 0.35206661f, -0.22022544f, 0.29771608f, 0.13264622f, 0.34212157f, 
    0.37574300f, 0.27745378f, 0.28804404f, 0.85665983f, -0.31529287f, 0.03058079f, 0.31262508f, 0.10719026f, 
    0.47499457f, 0.72571433f, -1.70464158f, 0.93026721f, 0.74703944f, -0.56760544f, 0.38286003f, 0.54872894f, 
    0.80539113f, 0.37622964f, -0.73857713f, -0.31148708f, -0.28510475f, 0.16245645f, 0.19759667f, -0.33725059f, 
    -0.03606739f, -0.01553488f, -0.42267302f, -0.59853101f, -0.32587326f, -0.27373984f, 0.39707136f, 0.40759069f, 
    0.31762224f, 0.20537633f, 0.30796728f, 0.40284717f, 0.21502551f, -1.54035878f, 1.21829593f, -0.37873057f, 
    0.79495645f, 0.74529392f, -0.31842190f, -0.73552072f, 0.12308838f, -0.35331249f, 0.13488834f, 0.09271164f, 
    0.22331123f, 0.39439344f, -0.71803343f, 0.06719567f, -0.17098448f, 0.20270593f, 0.23478940f, -0.21704783f, 
    -0.07391737f, -0.24572274f, 0.49431834f, 1.03788233f, 0.82132995f, 1.20810080f, 1.01783562f, 0.60180581f, 
    -1.16463637f, 0.75076449f, -0.86744791f, -0.84259713f, 0.17327619f, 0.49850938f, 0.31544423f, -0.11598329f, 
    0.23734312f, 0.18642604f, -0.12907660f, 0.24213859f, 0.30746698f, 0.32157299f, -0.18721648f, -0.03951519f, 
    0.19107917f, 0.16853076f, 0.11533051f, 0.24075799f, 0.82060498f, 1.07250512f, -0.89725113f, -0.66439903f, 
    0.62923092f, 0.47118202f, 0.10017779f, 0.93711919f, 1.00783527f, 1.03816438f, -0.11309142f, 0.13188662f, 
    -0.51088548f, -0.55617058f, -0.15570459f, 0.04181643f, -0.31167546f, 0.10932057f, 0.38289097f, -0.21861295f, 
    -0.71349043f, -0.14229375f, -0.48506135f, -0.16704074f, -0.38074663f, 1.51354480f, 0.81563419f, 0.17789620f, 
    1.16089511f, 0.07726885f, 0.37956345f, -0.15392230f, 0.61559212f, 0.16384397f, -0.28398678f, 0.25403690f, 
    0.13075507f, 0.22985981f, -0.02133040f, -0.06511150f, 0.37247378f, -0.37248176f, 0.52718323f, 0.18237329f, 
    -0.00895370f, -0.10613444f, 0.01628052f, 0.26331383f, 0.46675292f, -0.28180480f, 0.79301435f, 1.14798510f, 
    -0.02702995f, 0.25874254f, -0.78329426f, -0.58561224f, -0.88913554f, -0.77226228f, -0.76867473f, -0.49343684f, 
    -0.21877696f, 0.29882941f, 0.83855164f, 0.07712174f, 0.06692699f, 0.09728481f, -0.16799924f, 0.13834445f, 
    0.19490190f, 0.02367904f, 0.16135225f, 0.49699289f, 0.23573688f, -0.12038198f, -0.04086211f, -0.86232305f, 
    -1.55765843f, -0.92134607f, -0.01875768f, -0.03335020f, 0.42005828f, -0.21816890f, -0.43194687f, 0.38562268f, 
    0.16650119f, -0.21831618f, 0.70611477f, 0.16723986f, 0.56941921f, 0.58153182f, -0.09484494f, 0.02940987f, 
    0.33641422f, 0.18382429f, -0.04872517f, -0.14681527f, -0.09190643f, -0.01394935f, -0.21815407f, -0.24847054f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.45405981f, -0.01442097f, 0.21823356f, 0.26752061f, 0.30712640f, 0.42309779f, 0.34532195f, 0.29805499f, 
    0.23821799f, 0.23873906f, 0.30719253f, 0.18548335f, 0.17364213f, 0.45873344f, 0.28295970f, 0.64306784f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.57183576f, 0.36880991f, -0.36947429f, -0.11311537f, 0.13681264f, 0.04323326f, -0.18223397f, 0.07867546f, 
    -0.00867111f, -0.09346151f, 0.08364368f, -0.14493904f, -0.29075471f, -0.02007011f, 0.12800920f, 0.10591848f, 
    -0.14261767f, -0.06249427f, 0.33097130f, 0.06753345f, 0.08089731f, 0.06145766f, -0.09191173f, 0.06803329f, 
    -0.39430049f, 0.15239845f, -0.34770620f, 0.41801447f, 0.02304733f, 0.07383576f, 0.08075209f, 0.06874668f, 
    0.00424461f, 0.05967778f, -0.06554706f, 0.01744008f, 0.45359367f, -0.11326051f, 0.03085714f, 0.46023265f, 
    -0.19874433f, -0.22390208f, -0.08493010f, 0.04104009f, -0.25865689f, 0.13675171f, 0.14927800f, 0.04056124f, 
    -0.29612970f, -0.05899134f, 0.66592956f, -0.74293083f, -0.15774587f, -0.15826266f, 0.22881955f, 0.06621123f, 
    -0.03080285f, -0.23179209f, 0.08164668f, -0.05160972f, 0.09849654f, 0.53150523f, -0.20355316f, -0.82358867f, 
    0.03167182f, -0.05722572f, 0.06616186f, 0.03267932f, 0.04998633f, -0.04980601f, 0.08150126f, 0.11012104f, 
    0.01686053f, 0.15324342f, -0.23157734f, 0.65233827f, 0.02808869f, 0.08641242f, -0.08099250f, -0.04674347f, 
    0.07346068f, 0.19524728f, -0.14884202f, 0.04092052f, -0.17501955f, -0.19426537f, -0.21753575f, 0.27558571f, 
    -0.11077516f, -0.30452940f, -0.21618427f, -0.06075856f, -0.06042432f, -0.06847429f, -0.07575059f, 0.06449575f, 
    0.43406707f, -0.32093599f, -0.09765218f, -0.39060190f, 0.03301525f, -0.48045531f, 0.14069258f, 0.30161870f, 
    0.12409575f, 0.22180003f, -0.01174137f, 0.17246889f, 0.19985770f, 0.19442071f, -0.05878524f, 0.47236383f, 
    0.10022500f, 0.22613645f, -0.06235860f, -0.22482078f, -0.15095475f, 0.08128080f, -0.09176258f, -0.24981038f, 
    -0.58673942f, 0.08658387f, 0.25764796f, -1.02505338f, -0.39629170f, -0.29086900f, -0.04004662f, 0.01338509f, 
    0.34830496f, -0.05709529f, 0.02728127f, 0.21729748f, 0.35059768f, 0.23892467f, -0.03514314f, 0.09831072f, 
    -0.25207949f, -0.29185316f, -0.02960146f, 0.10596130f, -0.10422739f, -0.04227355f, -0.37127918f, -0.14788410f, 
    0.55677843f, -0.06267904f, 0.30222791f, -0.26246172f, 0.00545713f, 0.05913347f, 0.38487455f, 0.10855500f, 
    -0.16983674f, 0.02960527f, -0.19724818f, -0.11904204f, 0.44415131f, -0.11500842f, -0.19239260f, 0.01954682f, 
    -0.27761739f, 0.02561816f, -0.16950655f, 0.03919645f, -0.21186589f, -0.20333044f, -0.09542058f, -0.10678735f, 
    0.03225502f, 0.22958750f, 0.44153476f, -0.26795697f, -0.05904671f, 0.20715496f, 0.00966328f, 0.03548849f, 
    -0.13472344f, -0.04913453f, -0.21334246f, 0.13977987f, -0.24397409f, -0.17918561f, 0.11958122f, -0.24892904f, 
    0.04250826f, -0.08729378f, 0.13808610f, 0.01989362f, -0.03210015f, 0.00675074f, -0.09385591f, -0.10072344f, 
    0.37111378f, -0.29556915f, -0.70136482f, 0.03470683f, 0.14840189f, 0.04849721f, -0.06024947f, -0.03775849f, 
    -0.08254176f, 0.12557791f, -0.14827095f, -0.15254809f, 0.44447413f, 0.24173234f, 0.37298274f, -0.08311971f, 
    -0.28268242f, 0.02865252f, -0.18459146f, -0.12601182f, -0.17452951f, -0.31797683f, 0.14336719f, -0.09786601f, 
    -0.13603330f, -0.52671862f, 0.04655303f, 0.26595867f, -0.21393269f, -0.00243118f, -0.11339916f, -0.09330875f, 
    0.04631907f, -0.15856935f, -0.07403081f, 0.00176650f, 0.28799579f, -0.01507217f, 0.28421435f, 0.25711447f, 
    -0.09215726f, 0.08298933f, 0.13916145f, 0.10094155f, -0.05419834f, -0.05226178f, -0.15660354f, -0.12239636f, 
    0.46573365f, -0.58124864f, -0.15072761f, -0.69020128f, -0.04686046f, 0.02964437f, -0.02083175f, 0.00450220f, 
    -0.20331402f, 0.10078600f, 0.00052067f, 0.14060928f, 0.14411397f, -0.37166190f, -0.14704905f, -0.17159654f, 
    -0.03617462f, -0.11112793f, -0.09336130f, 0.05761996f, -0.05054244f, -0.00008816f, -0.06313291f, -0.04420438f, 
    0.28998876f, -0.26230407f, -0.04073433f, 0.07091117f, -0.07889037f, 0.04171677f, -0.25152954f, 0.18182902f, 
    0.12625411f, 0.17605135f, 0.01066166f, -0.03747769f, -0.14872335f, 0.21430725f, -0.36616614f, -0.08516129f, 
    -0.28413048f, -0.24551766f, 0.10184935f, -0.10684902f, -0.08308664f, -0.06562129f, 0.11618144f, -0.01670145f, 
    0.70187777f, -0.19668542f, 0.04217022f, 0.23966636f, -0.00262380f, -0.14688903f, -0.00067856f, -0.21294323f, 
    -0.16891032f, -0.05599543f, 0.18017696f, -0.09399283f, -0.17354050f, -0.20773578f, 0.05683569f, 0.08438633f, 
    -0.17870048f, 0.15166821f, 0.00903054f, 0.04284133f, 0.22111236f, -0.07960562f, 0.04722638f, 0.00195498f, 
    0.12184467f, 0.12078517f, -0.09194726f, -0.20031977f, 0.13359264f, 0.00407257f, -0.08034489f, -0.03533329f, 
    -0.09911977f, -0.09851911f, -0.19562410f, 0.11293514f, 0.23337097f, 0.10389931f, -0.17819390f, 0.13830340f, 
    -0.24608183f, 0.11028190f, 0.03991205f, 0.00042955f, 0.12421831f, 0.01516069f, 0.12976490f, -0.02026832f, 
    0.35861889f, -0.03772362f, 0.21894923f, -0.22139856f, 0.21513446f, -0.20293619f, -0.19636488f, 0.04877539f, 
    0.26988241f, -0.14995830f, 0.05934412f, -0.02532447f, -0.02968885f, -0.07694160f, 0.17769147f, 0.53602713f, 
    -0.08173984f, -0.17543100f, 0.14436692f, -0.05090294f, 0.19673157f, 0.12356650f, -0.05460090f, 0.37205726f, 
    -0.04905909f, -0.45153680f, -0.15349837f, -0.19509165f, -0.02661122f, -0.17496565f, 0.06352681f, 0.04278035f, 
    0.14239664f, -0.01062695f, 0.05082663f, -0.01876992f, 0.52742857f, 0.02262965f, -0.22564268f, -0.03306117f, 
    0.08363517f, -0.20215014f, 0.15783478f, 0.08818017f, -0.05209756f, -0.03839004f, 0.20306331f, 0.28002927f, 
    0.45492825f, -0.65331501f, 0.08913843f, -0.10653213f, -0.17589022f, -0.01239133f, -0.12002268f, 0.06244388f, 
    0.13807563f, -0.03294877f, -0.25550249f, -0.01270611f, 0.29077622f, -0.71428424f, 0.20282586f, -0.03811533f, 
    0.09202082f, -0.04637487f, -0.04599815f, -0.06947809f, 0.10089725f, 0.12565155f, -0.22197337f, 0.19335912f, 
    1.26187778f, -0.20523845f, -0.09960759f, 0.11393262f, 0.00605597f, 0.08716284f, -0.13249847f, -0.03528667f, 
    -0.03854522f, -0.19966422f, 0.18315475f, -0.15368463f, -0.00645770f, 0.30937028f, -0.15075855f, -0.04332668f, 
    0.10380574f, -0.01633863f, 0.01019115f, -0.17715466f, 0.03066013f, 0.20668399f, 0.10275265f, -0.06007566f, 
    -0.79271090f, -0.02499011f, -0.26889035f, -0.51303452f, 0.00623794f, -0.34017169f, 0.28305408f, -0.17518507f, 
    -0.00431880f, -0.01208173f, 0.24970320f, 0.07663042f, 0.55922788f, 0.23669809f, 0.39318639f, 0.48266324f, 
    -0.31814554f, -0.35156307f, 0.01339093f, 0.17150024f, 0.06248400f, -0.03089106f, 0.05675962f, -0.01014013f, 
    -0.08092179f, -0.40848452f, -0.19783835f, -0.07992469f, 0.18975984f, -0.13690104f, -0.13119261f, 0.03701071f, 
    0.08182336f, -0.09168604f, 0.04613522f, -0.28823641f, -0.19589256f, 0.08405721f, 0.32200214f, -0.02839874f, 
    -0.22626270f, 0.04520809f, 0.19491744f, 0.14410840f, -0.14120461f, -0.03618685f, 0.02540021f, -0.08131696f, 
    -0.27406895f, 0.35944653f, 0.14654787f, -0.14590873f, -0.06824981f, 0.29378951f, 0.23898563f, 0.17220740f, 
    -0.18249831f, -0.18292041f, -0.10710563f, -0.15337852f, -0.43337044f, -0.10886229f, -0.07915757f, 0.04904037f, 
    -0.22658665f, 0.02388397f, -0.15199874f, 0.07946923f, 0.01099102f, 0.27082169f, -0.07896477f, -0.18484594f, 
    -0.30128583f, -0.08283038f, -0.40769848f, -0.19518712f, 0.17492239f, -0.03762556f, -0.02270062f, -0.19338788f, 
    -0.10583436f, -0.14310992f, -0.13200855f, 0.21293148f, 0.27129033f, 0.16726498f, -0.08366950f, 0.02154219f, 
    0.22526266f, 0.17017351f, 0.03811782f, -0.03518220f, -0.28771099f, -0.07833513f, -0.13583732f, -0.08708294f, 
    0.26703978f, 0.08875514f, -0.06004157f, 0.14928128f, -0.20251189f, -0.14972854f, 0.42769310f, 0.10468853f, 
    -0.08305440f, -0.02527295f, 0.09268554f, -0.09311775f, 0.14765334f, 0.20949104f, -0.02930656f, -0.11498883f, 
    -0.06773099f, 0.03242122f, 0.00258450f, 0.04718817f, -0.14585719f, 0.12432004f, 0.16209282f, -0.31479093f, 
    -0.65099430f, -0.07673633f, 0.00396190f, -0.63926607f, 0.12639616f, 0.08298291f, 0.05078614f, -0.14512178f, 
    0.16571486f, 0.08670142f, -0.06970150f, -0.01274537f, 0.23092762f, -0.29835147f, 0.14383158f, -0.07903351f, 
    -0.17306699f, -0.10650910f, -0.02324429f, 0.05538616f, -0.21946478f, -0.17304915f, -0.19036748f, -0.14237092f, 
    0.27556530f, 0.11624620f, -0.11420010f, 0.07340382f, 0.14765206f, 0.11994150f, 0.15669182f, 0.02112048f, 
    0.03996905f, 0.07159899f, -0.00611367f, -0.02014990f, 0.98252976f, -0.70856893f, 0.17860408f, 0.26009709f, 
    -0.17382266f, 0.03226706f, -0.10637977f, 0.09701379f, -0.00674700f, 0.02172441f, -0.02708591f, -0.05411010f, 
    0.01257949f, 0.49080914f, 0.25491166f, 0.15025258f, 0.14140609f, 0.12085184f, 0.07214320f, 0.14149587f, 
    -0.17882997f, 0.23486519f, -0.01939673f, 0.01787487f, -0.66132534f, -0.55947697f, -0.42201144f, -0.15852624f, 
    -0.09327824f, 0.03063877f, -0.02987596f, -0.20668960f, 0.10862993f, 0.15783361f, 0.07950315f, 0.04481449f, 
    0.10881104f, 0.05393684f, 0.44041988f, 0.18380350f, -0.06474067f, -0.10037678f, 0.12054932f, 0.24854113f, 
    -0.17702504f, 0.08552597f, -0.07536246f, 0.21325833f, 0.21320093f, -0.15906353f, -0.03237492f, -0.12442301f, 
    -0.20808186f, 0.01201256f, 0.10003314f, -0.12945436f, -0.17630801f, -0.06324693f, 0.07241299f, -0.02672774f, 
    0.10926588f, -0.04210479f, -0.01762277f, 0.00441941f, -0.03026942f, -0.12480719f, 0.09489911f, -0.09045687f, 
    0.19530402f, -0.11757939f, -0.10938652f, 0.03055808f, -0.44904065f, -0.38960987f, -0.13931361f, 0.01592306f, 
    -0.16923483f, 0.17230518f, -0.17806318f, 0.21215118f, -0.10032915f, -0.04380507f, -0.03901976f, 0.11137199f, 
    -0.51695216f, -0.11346292f, -0.87514162f, -0.15414245f, -0.06301087f, -0.10776582f, 0.20029521f, 0.10625269f, 
    0.08631715f, -0.06246428f, -0.17061533f, 0.13580081f, 0.29960185f, -0.09754547f, -0.28396764f, 0.10781252f, 
    -0.08476695f, 0.09362255f, -0.08810399f, 0.24470484f, -0.06974047f, 0.12797286f, -0.07021035f, -0.03111419f, 
    -0.50695175f, 0.32926121f, 0.08687745f, 0.37197891f, 0.09040459f, -0.12478320f, 0.00539286f, 0.16066904f, 
    0.02175301f, -0.18024082f, 0.15011811f, 0.16221707f, -1.50062823f, -0.26128021f, 0.23840804f, 0.42054927f, 
    0.00701573f, 0.28489858f, -0.04090446f, -0.07775427f, -0.24950276f, -0.11880795f, -0.09357203f, -0.17074755f, 
    -0.57407558f, -0.10772085f, -0.37891987f, -0.25972164f, -0.05201798f, 0.10226837f, -0.20114411f, 0.00810710f, 
    -0.07797124f, -0.08786647f, -0.13609204f, 0.24823970f, 0.12549321f, -0.66954285f, -0.25696510f, -0.07441650f, 
    -0.10731331f, -0.01241780f, -0.00582328f, 0.16863349f, 0.15960300f, -0.11160439f, 0.15913102f, -0.08049615f, 
    0.76223761f, -0.55867821f, 0.09102711f, 0.14148068f, -0.09116935f, 0.36604196f, -0.13382682f, 0.07517692f, 
    0.03279774f, 0.16345763f, -0.13106064f, 0.14237212f, 0.19156750f, 0.00480047f, -0.05813784f, -0.10112316f, 
    -0.06786431f, -0.07601099f, -0.13969749f, 0.00895924f, -0.09565786f, -0.07911935f, 0.14222932f, 0.14107822f, 
    -0.30671099f, 0.37820983f, -0.11930416f, -0.25836450f, -0.08243514f, 0.08033135f, 0.09147851f, 0.12540950f, 
    0.16270363f, -0.11468928f, 0.05396032f, 0.07353815f, -0.25480184f, 0.40748322f, -0.45053196f, -0.19636190f, 
    0.00589737f, 0.11642350f, 0.05638384f, 0.27231896f, -0.07652492f, 0.18305570f, -0.08018656f, 0.10120997f, 
    -0.84916013f, 0.13345648f, -0.22090374f, -0.12184787f, 0.05622768f, 0.04310279f, 0.02097569f, 0.02120662f, 
    -0.13868612f, 0.01815774f, -0.01208410f, 0.06358622f, 0.15611599f, 0.09076801f, 0.15077071f, 0.25127918f, 
    -0.17607005f, 0.11986210f, 0.12657900f, 0.08697192f, 0.17376737f, -0.01615694f, -0.00361601f, 0.16424341f, 
    0.24186382f, 0.14061241f, 0.07144368f, 0.15984482f, 0.01365073f, 0.06425864f, 0.28922847f, 0.12442446f, 
    0.10298588f, -0.03001909f, -0.02724318f, -0.16678141f, -0.87670964f, -0.08640594f, 0.11951405f, 0.53391343f, 
    0.12104425f, 0.10180160f, 0.01179337f, 0.27826306f, 0.00547829f, -0.01174150f, 0.20708103f, 0.16813333f, 
    0.57862884f, 0.16488671f, -0.12458875f, -0.12939864f, -0.17797601f, 0.11316090f, 0.06471941f, 0.03937136f, 
    -0.23010507f, 0.03815859f, -0.05165244f, -0.00257680f, -0.28441027f, -0.52570385f, 0.26506534f, -0.41500542f, 
    0.07051331f, 0.10452802f, -0.18199030f, -0.00884645f, 0.12631296f, 0.15006319f, -0.08009898f, 0.06462552f, 
    -0.38315853f, 0.09521737f, -0.03219921f, -0.20079370f, 0.23643717f, 0.10318632f, 0.05535084f, -0.11329371f, 
    0.14495960f, -0.08984429f, -0.18046139f, -0.10644871f, -0.54071605f, 0.35500172f, -0.04140402f, -0.45882344f, 
    -0.10265397f, -0.09474598f, -0.03162672f, 0.02589905f, -0.15430835f, -0.06160511f, 0.01427613f, 0.05675750f, 
    0.47892579f, 0.31634352f, -0.21910948f, -0.19838841f, -0.01282490f, -0.06164713f, 0.10787737f, -0.20208119f, 
    -0.05983374f, -0.14296991f, 0.07757511f, -0.24072847f, -0.84057117f, -0.23066126f, 0.53229535f, 0.02560288f, 
    -0.09273642f, 0.07105558f, -0.12310341f, -0.00639279f, 0.31636679f, -0.02276008f, -0.14243065f, -0.15971264f, 
    -0.24434613f, -0.50714976f, -0.12504102f, 0.23784658f, -0.23184992f, -0.03331153f, 0.03402239f, 0.03866665f, 
    -0.18032791f, 0.08973159f, 0.09560689f, 0.11874935f, 0.38032514f, 0.20276295f, 0.02153230f, -0.02418171f, 
    -0.24332632f, -0.36951658f, 0.02351917f, 0.04791601f, 0.00488406f, -0.02490924f, -0.02390222f, -0.15389188f, 
    -0.28652823f, -0.02446015f, 0.10746284f, 0.18874235f, -0.24242589f, -0.00413732f, -0.02709779f, -0.29076645f, 
    0.09236942f, -0.03972146f, 0.09531805f, -0.05155423f, 0.00398410f, 0.25019389f, 0.00304464f, 0.07542212f, 
    0.08241879f, 0.09698291f, -0.03262516f, 0.08276963f, 0.31503272f, 0.00760755f, -0.08220323f, 0.01234726f, 
    -0.67328829f, 0.09957016f, -0.06552076f, -0.47271293f, -0.09825912f, 0.00445834f, 0.08275443f, -0.22665706f, 
    -0.18623300f, 0.18733999f, 0.07770327f, -0.04370255f, -0.31931075f, -0.14654905f, 0.36061370f, 0.36875373f, 
    0.06600644f, 0.00265114f, -0.00437700f, -0.11116298f, 0.15429947f, -0.05063891f, 0.15757222f, 0.00249194f, 
    -0.62390506f, 0.08974288f, -0.17361556f, -0.62497860f, 0.14104393f, -0.08301642f, 0.06358235f, 0.11853957f, 
    0.07085811f, -0.09625564f, -0.06663306f, -0.23127882f, -0.11504120f, -0.10743408f, 0.16413406f, -0.02672885f, 
    -0.11774953f, -0.14717935f, -0.07882372f, 0.16466165f, 0.14026830f, -0.14427517f, -0.15284802f, -0.11487854f, 
    0.15129796f, -0.07674338f, 0.02444086f, 0.25674108f, -0.09789963f, 0.03243273f, -0.12610507f, -0.00619735f, 
    0.06925604f, 0.08488348f, -0.24518576f, -0.08398411f, -0.38101408f, -0.18626742f, -0.59041882f, -0.03877389f, 
    0.14731380f, 0.16434598f, 0.07129484f, -0.07247102f, 0.10026457f, 0.12551913f, -0.21433207f, 0.23276094f, 
    -0.10832042f, 0.32386950f, 0.50331891f, -0.54156995f, -0.06312541f, 0.05161579f, 0.11772647f, -0.12787637f, 
    0.26705870f, -0.08329756f, -0.02310020f, 0.25779194f, 0.43445745f, 0.15692376f, -0.19041675f, 0.02393352f, 
    -0.02843348f, -0.11556006f, 0.21622448f, 0.08489062f, -0.04850455f, 0.00828369f, -0.17254238f, -0.15488897f, 
    -0.15205397f, 0.07247908f, 0.08652024f, -0.08920830f, -0.24606128f, -0.17678256f, -0.01799648f, -0.06179703f, 
    0.10884190f, 0.02414166f, 0.02321264f, 0.17766078f, -0.45515364f, 0.03448268f, -0.02558078f, 0.44876415f, 
    -0.11308724f, 0.01359954f, 0.29790378f, -0.04113569f, -0.05143359f, -0.09919578f, -0.30714548f, -0.19136736f, 
    0.18693615f, 0.05305140f, 0.19525111f, 0.06338942f, -0.15331264f, 0.19100115f, 0.02100267f, 0.01903111f, 
    0.07175168f, 0.29294828f, 0.07754368f, 0.01563270f, 0.10297656f, -0.00074120f, 0.11710258f, -0.09933693f, 
    -0.09841814f, -0.05299950f, 0.09159984f, 0.01584649f, -0.05751121f, -0.17956033f, 0.23480466f, 0.25185916f, 
    0.41057330f, 0.16789749f, 0.09139471f, -0.21486320f, 0.06733117f, -0.07404255f, -0.40015537f, -0.30260193f, 
    -0.25901905f, -0.09565168f, -0.05994447f, 0.05600453f, -0.07430255f, 0.12216663f, 0.02393306f, 0.00062452f, 
    0.26642960f, 0.24614215f, 0.03417009f, 0.05954973f, 0.10153474f, -0.27719089f, 0.08093439f, 0.16304886f, 
    0.25858736f, 0.40630850f, 0.16016568f, 0.24142979f, -0.05429301f, -0.30577394f, -0.01490650f, 0.16566320f, 
    -0.10182429f, -0.08656573f, 0.19986300f, 0.09111556f, -1.21231902f, -0.26487902f, -0.11089521f, 0.07420319f, 
    0.05231222f, 0.08414937f, -0.16182114f, 0.09537919f, 0.06497816f, 0.10743999f, 0.26860988f, 0.02218044f, 
    0.11040630f, 0.02987436f, 0.51111913f, 0.20088898f, 0.08344612f, 0.08425929f, 0.11308057f, -0.10574501f, 
    0.10156509f, -0.12777494f, 0.12715857f, 0.07577790f, 0.21439542f, -0.28411862f, -0.26710463f, -0.29759967f, 
    -0.10433803f, 0.08928236f, 0.05749357f, 0.20439880f, 0.01991865f, -0.04008259f, -0.20924480f, 0.00219177f, 
    0.78697681f, -0.34569225f, 0.18731764f, 0.05361747f, -0.26100808f, 0.10901857f, 0.14709571f, -0.03167482f, 
    0.07548293f, -0.06381267f, 0.18962812f, 0.08413153f, 0.20198655f, 0.24711293f, 0.12695180f, -0.49852014f, 
    -0.24845576f, -0.10809806f, 0.01921291f, -0.02336143f, -0.08939039f, 0.10097757f, 0.33476251f, 0.28639710f, 
    -0.29975572f, -0.38803199f, -0.77222353f, 0.16062097f, -0.04947248f, 0.04977540f, -0.07448474f, 0.06704322f, 
    0.04878782f, -0.17672887f, 0.16771300f, -0.07527917f, -0.39470264f, -0.26473048f, -0.30743676f, -0.52844548f, 
    -0.02895957f, -0.00104900f, -0.09473108f, -0.16802271f, 0.14335217f, 0.02780471f, 0.20228504f, 0.12314168f, 
    -0.17023009f, -0.07162652f, -0.15992600f, -0.15265156f, -0.13095559f, 0.03354767f, 0.07910989f, -0.02856597f, 
    0.06233038f, -0.08456692f, -0.04235177f, -0.54783487f, -0.95051295f, 0.14440423f, 0.00086127f, 0.55210394f, 
    0.08212486f, 0.15900077f, -0.02420948f, 0.01421652f, -0.07016928f, -0.03090619f, -0.06519581f, -0.18252286f, 
    -0.31305411f, 0.36317116f, 0.25403965f, 0.52851290f, -0.17693841f, -0.05047572f, -0.07622524f, -0.06415093f, 
    0.02035625f, 0.03708696f, 0.01847817f, -0.24490759f, 0.42472592f, -0.34795615f, 0.17933847f, -0.19928224f, 
    0.25248966f, -0.20144200f, -0.06557709f, -0.23520975f, -0.06774368f, -0.08402832f, 0.15657137f, 0.06094037f, 
    0.04271972f, -0.00410529f, 0.11606441f, 0.40275535f, -0.08413847f, 0.07081266f, 0.01174383f, -0.01357021f, 
    0.03656648f, -0.16173685f, 0.01089583f, -0.08296620f, 0.17629376f, 0.32415026f, 0.12303542f, -0.15599823f, 
    0.15511645f, -0.03552501f, 0.09300854f, 0.03910856f, -0.15911211f, 0.09385637f, -0.08682144f, 0.08881983f, 
    -1.08790421f, 0.06987733f, -0.15392241f, 0.03915477f, 0.23245557f, 0.03731994f, 0.12056950f, 0.10905743f, 
    0.11996596f, 0.09754282f, -0.01403730f, 0.14721295f, -0.13211259f, -0.01152277f, 0.19363183f, -0.31733632f, 
    -0.09163389f, 0.26722392f, 0.05059022f, 0.03045966f, -0.10555471f, 0.15535882f, -0.18421914f, 0.03176002f, 
    -0.15010737f, -0.12270978f, -0.05213349f, 0.23138697f, 0.15529069f, 0.06116953f, -0.02999370f, 0.08316544f, 
    0.05284571f, -0.10312802f, -0.13594785f, 0.09770358f, -0.41870937f, -0.01691673f, 0.05424942f, -0.34286121f, 
    -0.02393467f, 0.12049121f, 0.02355686f, -0.09809963f, -0.00027048f, 0.07846897f, -0.17855942f, -0.01673327f, 
    -0.31094229f, -0.01586021f, 0.47995040f, 0.09283726f, -0.00086482f, -0.03112312f, -0.08203977f, 0.13540667f, 
    -0.15306126f, 0.17213845f, -0.14196678f, 0.00324559f, -0.43624377f, 0.51171219f, 0.19389169f, -0.06774303f, 
    -0.10249750f, -0.12257136f, 0.07051198f, -0.06981128f, 0.11190344f, 0.17610903f, 0.04664984f, 0.02337643f, 
    0.82451028f, -0.29855943f, 0.31554168f, -0.27607176f, 0.02115734f, 0.05430630f, -0.07542039f, -0.10035783f, 
    -0.14442122f, 0.14491822f, -0.08295112f, -0.08118698f, -0.40218771f, 0.06368762f, -0.42420992f, -0.22620426f, 
    -0.04065708f, 0.01284331f, -0.07466125f, -0.29410604f, -0.17049290f, -0.21268110f, -0.07265486f, 0.07065783f, 
    -0.06363470f, 0.29441750f, -0.33316106f, 0.27427840f, -0.08669057f, 0.10380097f, -0.23564382f, -0.01281503f, 
    -0.03792825f, 0.08332680f, -0.07816326f, -0.23857170f, 0.34232453f, 0.36902723f, 0.45885080f, 0.44656700f, 
    0.33806905f, 0.07408953f, 0.23648076f, -0.05545403f, 0.09407701f, 0.11098008f, -0.01591538f, -0.11747657f, 
    -0.47541672f, 0.33509269f, 0.08593863f, -0.24148878f, 0.00716333f, -0.06801873f, -0.01723442f, -0.03125600f, 
    -0.10800020f, -0.08091014f, -0.03095976f, 0.01661180f, -0.25018641f, -0.16044515f, -0.05981742f, -0.39104071f, 
    0.15758608f, 0.15525034f, -0.18024762f, -0.11354184f, 0.00936472f, -0.02000942f, 0.04723559f, -0.07412664f, 
    -0.21777011f, 0.05320003f, -0.47078642f, 0.04274835f, -0.13783878f, 0.13621904f, -0.13327064f, -0.00329951f, 
    -0.16652615f, 0.01102664f, -0.05512700f, -0.08480208f, 0.42326951f, -0.14288932f, -0.04051779f, -0.10965510f, 
    -0.13049199f, 0.05843290f, -0.12364292f, -0.06134119f, -0.02768586f, -0.08344939f, -0.09121304f, 0.16224910f, 
    0.15104245f, -0.61142588f, 0.04214398f, 0.50291228f, -0.03105348f, 0.00514128f, 0.03569819f, -0.14836577f, 
    -0.10412220f, -0.10779123f, -0.13758206f, -0.15407965f, 0.36577117f, -0.37856999f, -0.41907376f, -0.18049124f, 
    -0.05546302f, -0.14236571f, -0.02756838f, -0.05695478f, 0.09211121f, 0.04538116f, -0.06723223f, -0.08869635f, 
    -0.06082487f, 0.07783842f, -0.12726898f, -0.08907598f, 0.03492743f, 0.04070361f, -0.14312850f, -0.00478026f, 
    0.09125622f, 0.06721147f, 0.05122200f, -0.04433372f, -0.21374643f, 0.10510823f, -0.17335461f, -0.36454591f, 
    0.02675961f, 0.11153009f, -0.09289765f, -0.05676726f, -0.20042102f, -0.07496192f, 0.03852478f, -0.15585080f, 
    -0.14115530f, -0.04441164f, 0.02498891f, 0.27131194f, -0.12566586f, -0.15653731f, -0.11882762f, 0.05902334f, 
    -0.18278261f, -0.01043282f, -0.12492380f, 0.04066635f, -0.11707014f, 0.30189350f, 0.35649028f, 0.15044960f, 
    0.10137141f, 0.29729497f, 0.00916887f, -0.18245924f, 0.03601135f, -0.12817010f, -0.09306534f, -0.29357564f, 
    -0.04752713f, -0.74891025f, 0.10169636f, 0.00362064f, -0.31014490f, -0.30590796f, -0.28395721f, -0.08919307f, 
    0.03224445f, -0.21525975f, -0.24476515f, 0.13995466f, 0.32123923f, 0.09473578f, -0.06328344f, 0.38299111f, 
    0.06765947f, -0.14395612f, -0.25701585f, -0.12686716f, 0.19053425f, 0.01446840f, 0.27501351f, 0.05382187f, 
    -0.37785369f, -0.17375809f, 0.14354347f, -0.26769912f, 0.17261511f, -0.21839705f, 0.07552785f, -0.11209165f, 
    0.07049645f, 0.05479508f, -0.25929445f, 0.14091638f, -0.07530056f, 0.00191726f, 0.12610829f, 0.44270501f, 
    0.25352299f, -0.12331340f, -0.19738920f, -0.01054933f, 0.02076123f, 0.06234144f, -0.15966256f, -0.35589549f, 
    -0.28835824f, 0.37783402f, -0.53204012f, -0.62353635f, -0.24769779f, -0.03731985f, -0.22178546f, -0.09455536f, 
    0.20128815f, 0.13650168f, -0.13051565f, 0.00548140f, -0.30023509f, 0.11518235f, 0.44969940f, 0.18340784f, 
    -0.35327002f, 0.18909591f, -0.04212926f, -0.08921240f, -0.03979313f, -0.08780970f, -0.26259160f, 0.01001935f, 
    0.33216199f, -0.38714951f, 0.12448531f, 0.29099771f, -0.14822939f, -0.01907394f, 0.09789921f, -0.04370226f, 
    0.02834107f, -0.12107485f, 0.11118799f, 0.14062326f, 0.46920115f, -0.17171773f, -0.14298798f, -0.05239815f, 
    0.18448572f, -0.05724049f, 0.11888332f, 0.03703235f, 0.12052638f, -0.11864142f, -0.17671165f, 0.05301087f, 
    0.21847597f, 0.13122070f, -0.29469988f, 0.12827188f, -0.14129959f, 0.20675384f, -0.15954104f, -0.26878899f, 
    0.15037996f, -0.18422665f, 0.20537290f, 0.28190911f, 0.14069754f, -0.04779465f, 0.19589587f, -0.11547756f, 
    -0.05236700f, -0.21432514f, 0.05971022f, -0.10025537f, 0.07244196f, -0.04539640f, -0.11512425f, 0.07186700f, 
    0.25858700f, 0.17050102f, -0.24161144f, -0.25075227f, 0.20160432f, 0.08747363f, -0.21196659f, -0.12544227f, 
    -0.05651492f, 0.07615834f, -0.01979935f, 0.01813827f, 0.00547869f, -0.12225685f, -0.36474025f, 0.14383438f, 
    0.28466573f, -0.00612751f, -0.00637700f, -0.17088422f, 0.08675850f, 0.01882563f, 0.25169146f, 0.14407949f, 
    0.14323841f, 0.26679033f, -0.23408334f, 0.28984568f, -0.08432689f, -0.19095349f, -0.39072227f, -0.15728454f, 
    -0.27976555f, -0.03508548f, -0.09335481f, -0.10005163f, 0.23582928f, 0.11774642f, 0.07437807f, 0.30561125f, 
    0.15613011f, -0.03757505f, -0.03450475f, -0.06193436f, -0.12225527f, -0.05714635f, 0.18624197f, -0.03416445f, 
    0.15875390f, -0.32194149f, -0.55278170f, -0.33014619f, 0.13596439f, -0.30757764f, -0.09002225f, -0.09543193f, 
    0.07848849f, 0.15029731f, 0.28648657f, -0.19710091f, -0.29458728f, -0.07087205f, 0.42638400f, -0.18687680f, 
    -0.08991883f, -0.05197779f, -0.22562668f, -0.07040653f, 0.06368396f, 0.16409354f, 0.26506606f, 0.06957895f, 
    -0.53668058f, 0.09670725f, -0.08592976f, 0.71924084f, 0.01215513f, 0.14146414f, -0.08916351f, -0.10537732f, 
    0.02191976f, 0.03188357f, -0.05517226f, 0.02275368f, -0.47094849f, 0.53282964f, -0.27609771f, -0.33323690f, 
    0.25652885f, -0.11456837f, -0.00135507f, 0.18758649f, -0.02867336f, 0.14101720f, -0.12551966f, -0.02189912f, 
    -0.06444000f, -0.16799833f, 0.04295377f, -0.01808321f, -0.07537948f, 0.12145180f, -0.02515143f, -0.21055885f, 
    -0.07367408f, 0.09128770f, 0.26428583f, -0.01891949f, -0.65428901f, 0.41642123f, -0.12083148f, -0.43330005f, 
    0.26508403f, 0.10836042f, 0.02581022f, -0.20009911f, -0.03365152f, -0.17523727f, 0.04548782f, 0.17347293f, 
    -0.27705616f, 0.45117098f, 0.05373891f, 0.42456740f, 0.06879509f, 0.00394954f, -0.43603441f, 0.05473097f, 
    -0.08780799f, -0.14321676f, 0.17070256f, 0.14281815f, -0.08202203f, -0.57616401f, -0.01741849f, -0.14875430f, 
    0.11576826f, -0.06365627f, -0.04575475f, 0.00928792f, -0.01963518f, 0.07998298f, -0.08287290f, -0.10273179f, 
    -0.62938464f, 0.52457917f, -0.49615231f, -0.14523211f, 0.29735571f, -0.13571838f, -0.08434081f, -0.28776732f, 
    -0.15495250f, -0.28532243f, 0.11574730f, -0.03280383f, 0.70199335f, 0.42929041f, 0.38351569f, 0.09184255f, 
    0.12046523f, 0.07709014f, 0.14053158f, -0.12891264f, 0.06033937f, -0.08344438f, 0.08935131f, -0.01907925f, 
    0.15293640f, 0.14373504f, 0.22110358f, -0.04319534f, 0.09342491f, 0.22292444f, -0.19275397f, 0.14700791f, 
    -0.05084600f, -0.22061448f, -0.09030902f, -0.08097938f, 0.84769183f, 0.16887462f, -0.12125682f, -0.14475451f, 
    -0.07910135f, 0.02047934f, -0.11043760f, 0.07755233f, -0.21169049f, 0.05654592f, 0.11521995f, 0.44483006f, 
    -0.11009985f, -0.54154915f, -0.38799503f, 0.06234678f, 0.18646689f, 0.06357099f, -0.08611105f, -0.04908839f, 
    0.02571839f, 0.18622468f, 0.14548968f, -0.16993961f, -0.38477308f, 0.03829731f, 0.07589723f, -0.41897407f, 
    0.00655941f, -0.21894509f, -0.13787383f, -0.04970685f, -0.05540430f, -0.06022613f, 0.08404301f, -0.06279174f, 
    0.11684055f, 0.30626079f, 0.12084778f, 0.06036982f, -0.08696004f, 0.07285278f, 0.11609647f, 0.29854059f, 
    0.12192747f, 0.11176263f, 0.13314320f, -0.02913749f, -0.50929624f, 0.33418873f, -0.03206103f, -0.29385033f, 
    0.18172209f, -0.07516922f, 0.03051971f, -0.08773290f, -0.03328091f, 0.11688478f, -0.13062122f, -0.20429626f, 
    -0.22576585f, 0.16112413f, -0.21254350f, -0.26839146f, -0.12357379f, 0.07755665f, 0.03309442f, 0.06446530f, 
    -0.21382251f, 0.00145336f, -0.19949664f, -0.05170991f, -0.14601378f, -0.44804859f, -0.20236450f, 0.21357098f, 
    -0.04307375f, 0.05960560f, 0.06027860f, -0.14417477f, -0.04562555f, 0.03377554f, -0.14892064f, -0.09243471f, 
    0.74035704f, 0.04095923f, 0.04259687f, 0.26682830f, 0.02519012f, -0.25949654f, 0.06645908f, 0.24466626f, 
    -0.09617130f, -0.27193663f, -0.14563416f, 0.07624111f, -0.70099586f, -0.22909552f, -0.58277583f, -0.50883144f, 
    0.02849352f, -0.08107128f, -0.29409009f, -0.15689178f, -0.14330089f, -0.32599261f, 0.12021759f, -0.00369445f, 
    0.02854216f, 0.05560430f, -0.00489205f, 0.16467650f, 0.02952963f, -0.05972097f, -0.15602946f, -0.01100484f, 
    -0.14787214f, -0.19010082f, -0.14037958f, 0.05986524f, -0.51782453f, -0.25149408f, -0.05874327f, -0.50136793f, 
    0.13831985f, 0.00674235f, -0.12240057f, -0.07947940f, 0.01740852f, -0.09697765f, -0.25027779f, -0.14656803f, 
    -0.46250781f, -0.32467926f, 0.28565422f, 0.11058408f, 0.20298676f, 0.14771503f, 0.02274244f, -0.01009142f, 
    0.27344966f, -0.00922053f, -0.03992850f, -0.05399859f, 0.53090465f, 0.17049594f, 0.00708578f, -0.12177797f, 
    -0.34014383f, -0.15065418f, -0.03588602f, 0.04629022f, 0.05967740f, -0.03675833f, -0.07909520f, -0.09217209f, 
    -0.09261831f, -0.56953669f, -0.19325888f, -0.07993424f, -0.04902573f, -0.08956464f, 0.17559631f, 0.20764957f, 
    0.01573878f, 0.06682884f, 0.22526275f, 0.23132087f, -0.71971881f, 0.13054138f, 0.23568742f, 0.48007965f, 
    0.27500209f, 0.04913902f, 0.06662460f, -0.22136207f, -0.02327279f, 0.16505390f, -0.14277478f, 0.17094959f, 
    -0.76113927f, -0.84321171f, 0.33261770f, 0.35574993f, 0.08865899f, 0.00643765f, -0.05878891f, -0.17685841f, 
    0.12877418f, 0.28333360f, 0.35693794f, 0.06014393f, -0.09775374f, -0.18171668f, 0.37582245f, -0.16097192f, 
    0.07342298f, 0.20708926f, 0.26737210f, -0.01089465f, 0.20725231f, -0.00940914f, 0.12527138f, 0.01899098f, 
    0.35867825f, -0.04985335f, 0.22860144f, -0.15008441f, -0.04495149f, -0.03480375f, 0.08064270f, 0.03966724f, 
    0.11860652f, 0.24223426f, -0.03004043f, 0.18932892f, -0.58680147f, 0.04651445f, -0.25831005f, -0.16806787f, 
    0.03273381f, 0.17076416f, -0.05097448f, 0.07995234f, 0.02603481f, 0.21579595f, 0.16520785f, -0.05706624f, 
    -0.30109900f, -0.41530001f, -0.11380788f, -0.01695626f, -0.05859732f, 0.14863645f, 0.05432435f, -0.39724877f, 
    -0.01344363f, -0.28440878f, -0.28375590f, -0.12745813f, -1.12441123f, -0.76577938f, -0.06925115f, -0.19666581f, 
    0.07917187f, 0.06892740f, -0.01438997f, -0.01209906f, 0.02567393f, 0.21030094f, 0.03947602f, 0.21940127f, 
    -0.40232575f, 0.15948324f, 0.21226354f, 0.03187209f, 0.33648267f, 0.05175149f, -0.03940722f, 0.04940838f, 
    -0.01867010f, 0.23948349f, 0.13834171f, 0.10282051f, 0.46368626f, 0.28547803f, -0.16721360f, 0.00404763f, 
    0.17790033f, -0.09224189f, 0.22062308f, 0.04276333f, 0.03583323f, 0.22153482f, 0.14448680f, 0.13281195f, 
    0.38674378f, -0.30236214f, 0.07110094f, -0.36435232f, 0.03266117f, -0.10232376f, 0.15903091f, -0.11784434f, 
    0.10795132f, -0.08393703f, 0.10890808f, 0.12433691f, 0.29110625f, -0.44992676f, -0.14742352f, -0.04696712f, 
    0.05333505f, 0.05512605f, -0.00555809f, -0.20645046f, -0.19940744f, 0.05756247f, 0.09665483f, -0.08713259f, 
    -0.89349675f, 0.47999892f, -0.40563732f, -0.15761195f, 0.30720624f, 0.07616872f, 0.04487954f, -0.01028562f, 
    0.09158865f, 0.00062742f, -0.01091401f, 0.02212888f, 0.19278158f, -0.01606777f, -0.40196815f, -0.75540721f, 
    0.07308745f, -0.24747694f, 0.04892764f, 0.13780935f, 0.17860371f, 0.17056260f, 0.00435228f, 0.08272284f, 
    0.19404234f, 0.22098830f, -0.39881220f, 0.28691834f, 0.19074985f, -0.09049328f, -0.03590888f, -0.33465874f, 
    0.02623387f, 0.15379956f, -0.01209905f, 0.06092947f, -0.19501965f, 0.30551687f, 0.05635734f, 0.16793482f, 
    -0.05391347f, -0.17555186f, 0.04354405f, 0.01951533f, -0.12627700f, 0.04018296f, 0.12251048f, -0.44237691f, 
    -0.17440501f, -0.26861238f, 0.46330985f, 0.12370217f, 0.11543683f, -0.04015775f, 0.17180064f, 0.17473257f, 
    -0.15164626f, 0.09487172f, 0.01590063f, 0.01002241f, 0.57484728f, -0.18228805f, 0.16542582f, -0.33598107f, 
    0.08216170f, -0.14444946f, -0.27349722f, 0.05462005f, -0.02298345f, -0.05161252f, 0.26925886f, 0.12055360f, 
    0.13102116f, 0.09883140f, -0.20015828f, -0.02838748f, -0.00085174f, -0.29541436f, 0.03397528f, 0.00080586f, 
    -0.03022694f, 0.07351246f, 0.04026416f, -0.07748114f, -0.80039465f, -0.23505850f, 0.04744267f, -0.08417865f, 
    0.37995809f, -0.23253326f, -0.16105196f, 0.10912708f, -0.12366372f, -0.00590390f, 0.00935392f, 0.05173789f, 
    -0.41193679f, 0.14738894f, 0.23186222f, 0.42682073f, 0.06310387f, 0.15508418f, 0.16214339f, 0.14937013f, 
    -0.21100301f, -0.05204144f, -0.00634678f, -0.13170329f, 0.73507655f, 0.10307885f, -0.50990152f, -0.04972976f, 
    0.08431807f, -0.18824731f, 0.18610850f, -0.03910439f, -0.11959092f, 0.13448931f, -0.08705186f, 0.03617644f, 
    -0.58440310f, -0.01489270f, -0.13983952f, -0.04549264f, 0.16384071f, 0.08413338f, 0.10275508f, 0.11624982f, 
    0.07234655f, 0.13392897f, -0.07589283f, -0.14546622f, -0.04004781f, -0.33949107f, -0.21153086f, -0.25277725f, 
    0.05874785f, 0.04305182f, 0.07059357f, -0.12850887f, -0.11777113f, -0.04459533f, -0.25827771f, -0.11570515f, 
    0.32274884f, 0.22161666f, -0.34356403f, 0.19064939f, 0.01470429f, -0.04340924f, -0.13367788f, 0.00387061f, 
    0.25780421f, 0.03641645f, 0.05315240f, -0.03609317f, 0.45316860f, 0.08488087f, -0.19354212f, 0.05511321f, 
    0.07100277f, -0.10119749f, -0.10220258f, 0.01736699f, -0.00310661f, -0.13285786f, -0.24208236f, 0.01096568f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17292909f, 0.08623625f, -0.15050463f, 0.01199828f, 0.09308734f, 0.03173774f, 0.01602061f, -0.12899454f, 
    -0.14529480f, 0.11980206f, 0.28414097f, -0.03044339f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
