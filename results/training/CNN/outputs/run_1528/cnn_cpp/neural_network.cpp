#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.55795288f, -0.16135496f, 0.78339159f, -0.00639204f, 0.16882196f, 0.67697632f, -0.09513295f, -0.02415794f, 
    -0.06539669f, 0.20316702f, -0.07431944f, 0.62127322f, -0.19381943f, 0.47582838f, -0.10851472f, -0.32618034f, 
    0.45954943f, -0.15195015f, -0.23815657f, -0.28506270f, -0.25623679f, 0.52733672f, 0.10153423f, -0.50136763f, 
    -0.30370462f, -0.25008100f, 0.00359662f, 0.70108533f, 0.54336429f, 0.19374543f, -0.48240599f, -0.30094990f, 
    -0.23823810f, 0.30234250f, 0.07982798f, 0.09841794f, -0.39790797f, 0.23691857f, 0.19894166f, -0.50430530f, 
    -0.38678521f, -0.23296171f, 0.29158738f, 0.30832610f, 0.29254130f, -0.63010669f, -0.63124317f, 0.02854670f, 
    0.00713751f, -0.07240082f, -0.09656449f, 0.10912103f, -0.10804671f, -0.33025530f, 0.36447147f, -0.69359797f, 
    -0.23979555f, -0.00100331f, 0.40135550f, 0.41116777f, -0.08327316f, 0.21088198f, 0.13233808f, 0.14719532f, 
    0.38891664f, -0.62045586f, -0.05932740f, 0.49691957f, -0.24558198f, 0.23857388f, 0.07216289f, 0.10545783f, 
    0.51189923f, 0.61987066f, 0.05511298f, -0.07520580f, -0.50858289f, 0.00022375f, -0.12613606f, -0.11946704f, 
    -0.30866322f, -0.73860615f, -0.29438934f, -0.14783630f, -0.48856017f, -0.02275313f, 0.27978569f, 0.25168094f, 
    0.01993712f, -0.09088657f, -0.04298819f, -0.21995468f, 0.48745328f, -0.46362099f, 0.05568175f, 0.30730581f, 
    0.39555621f, -0.09572312f, 0.22952633f, -0.01272649f, 0.33012483f, 0.40034738f, 0.02076952f, 0.17480311f, 
    -0.34374636f, -0.23926349f, -0.33441237f, -0.34583211f, -0.07519900f, -0.07892071f, -0.62500000f, 0.05005091f, 
    0.65958798f, 0.11548805f, -0.06062156f, -0.22826016f, -0.31380260f, -0.05069683f, 0.18548518f, -0.48524505f, 
    0.09070437f, -0.66335386f, -0.47423673f, -0.26102537f, 0.48745486f, 0.04930056f, 0.26358712f, 0.66898841f, 
    0.01847880f, 0.45396796f, 0.31616929f, 0.42563322f, -0.24943809f, 0.02540302f, 0.03689903f, 0.42268658f, 
    -0.57920200f, 0.00074176f, -0.44651416f, -0.37409514f, -0.34440854f, -0.18347074f, -0.47417638f, 0.09390588f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.30662236f, -0.25458544f, -0.15747944f, 0.13929446f, 0.05171503f, 0.06417924f, 0.37936726f, -0.05130558f, 
    -0.27011704f, -0.27104959f, 0.20568332f, 0.38770214f, -0.15752937f, 0.17546159f, -0.07689087f, 0.14504547f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02358486f, -0.19691356f, -0.24572977f, -0.11706194f, -0.17833675f, -0.10534552f, -0.01734410f, -0.01336114f, 
    0.10334355f, -0.16964936f, 0.08091237f, -0.09335667f, -0.08837871f, -0.12007764f, 0.01497193f, -0.08798766f, 
    -0.04967345f, -0.14228387f, -0.13833515f, -0.21647869f, -0.00934278f, -0.14221635f, -0.13778602f, -0.10942223f, 
    0.10953414f, -0.03385612f, 0.03207118f, 0.09045331f, -0.23847748f, -0.18169977f, -0.15899867f, 0.07088515f, 
    0.03335577f, 0.11302879f, 0.07700010f, -0.09795640f, -0.08556034f, -0.42845169f, -0.29117522f, -0.14629963f, 
    0.00742976f, 0.01092183f, 0.07091738f, -0.07342231f, 0.09166014f, -0.06021235f, 0.12488899f, 0.35257694f, 
    0.05777998f, 0.06730987f, 0.00265328f, -0.12843101f, 0.12076747f, 0.13121444f, 0.39063025f, 0.26581842f, 
    0.19461440f, -0.01602728f, 0.07045240f, 0.07605040f, 0.09386408f, 0.09275682f, 0.08483792f, 0.32179371f, 
    0.01266466f, -0.41383722f, -0.07471887f, -0.04943696f, 0.06040058f, -0.02818019f, 0.08318323f, -0.15513109f, 
    -0.22230729f, -0.40146816f, 0.15860496f, -0.05827735f, 0.09778337f, -0.15637918f, -0.08358718f, 0.00378367f, 
    -0.05233188f, -0.44200191f, -0.00239657f, 0.31043795f, -0.04356149f, 0.07819056f, -0.19253507f, -0.11941525f, 
    0.02169162f, -0.06181671f, 0.14455335f, -0.11198390f, -0.21851972f, 0.17004931f, 0.12271468f, 0.09047621f, 
    0.06562668f, 0.17150852f, 0.07439619f, -0.02260826f, -0.07807511f, 0.15785620f, 0.02745201f, 0.11620612f, 
    -0.01820513f, 0.09667690f, 0.13521793f, 0.19144985f, -0.10783360f, -0.03306213f, 0.14186861f, 0.00554570f, 
    -0.03243859f, -0.06822023f, 0.03582611f, -0.00389349f, -0.08889770f, 0.01150816f, -0.18222833f, -0.21094854f, 
    0.03218189f, 0.01657230f, -0.09069772f, 0.09613723f, 0.06343927f, -0.00062499f, -0.04106371f, -0.07717510f, 
    0.18330902f, -0.24490111f, -0.01499190f, -0.18402050f, -0.08174449f, 0.13611911f, 0.10033896f, -0.06979267f, 
    -0.15943946f, -0.22017908f, 0.09167887f, -0.02175264f, -0.03142302f, 0.07590486f, -0.08553208f, 0.12706462f, 
    0.16212521f, 0.23457015f, -0.06786989f, -0.31268051f, -0.10463821f, -0.00887289f, 0.00473004f, 0.25424403f, 
    0.04296418f, -0.30722359f, 0.13446867f, 0.16045079f, -0.04886983f, 0.04553622f, -0.03671581f, -0.05482475f, 
    0.01789765f, -0.06638142f, 0.01379943f, 0.15765506f, 0.31922987f, 0.02139785f, 0.01893963f, -0.21181506f, 
    -0.04534909f, 0.10467250f, 0.11718514f, -0.23111583f, -0.19811726f, -0.00522682f, 0.05337015f, 0.16492864f, 
    -0.00964741f, -0.02281314f, -0.06241502f, -0.04243440f, 0.02745900f, 0.18714951f, 0.33780366f, 0.10551215f, 
    -0.02591159f, 0.08822724f, -0.02454404f, -0.20062305f, -0.09080340f, -0.01378216f, 0.01458386f, 0.07048335f, 
    0.00101342f, -0.05940900f, -0.14459984f, 0.08155821f, -0.04220700f, -0.00770024f, -0.37810633f, 0.09653889f, 
    0.28411329f, 0.01545010f, 0.02134279f, -0.15458500f, 0.04795320f, 0.00549922f, 0.13128044f, -0.17193562f, 
    0.03032356f, 0.27508354f, -0.31055060f, -0.21241264f, -0.00877765f, -0.17752802f, 0.13313566f, 0.01604860f, 
    -0.16343264f, -0.37743667f, -0.16183041f, 0.11780672f, 0.06839862f, -0.04179131f, -0.04461817f, -0.07775114f, 
    -0.14667273f, 0.01356863f, 0.05031503f, -0.00323271f, -0.20453960f, -0.23241682f, -0.05545192f, -0.01453562f, 
    -0.09724757f, 0.16337679f, -0.10935529f, 0.08665890f, 0.02453736f, -0.24814889f, 0.06520428f, 0.04954795f, 
    0.03146266f, 0.04923525f, -0.24639033f, 0.05696470f, -0.11427245f, 0.02483104f, 0.17226365f, 0.11905844f, 
    0.05843738f, 0.18838707f, -0.09229919f, -0.08070558f, -0.13483319f, 0.13722393f, 0.12731080f, -0.10206507f, 
    -0.19829860f, 0.04825997f, 0.04782940f, 0.08007276f, -0.03043400f, -0.08142398f, -0.09084319f, 0.37732196f, 
    -0.06133391f, 0.08839285f, 0.08003744f, -0.00948426f, -0.12362543f, -0.02460008f, 0.16497298f, -0.04323959f, 
    -0.06355363f, -0.09837775f, -0.09983009f, -0.04339181f, -0.04896843f, 0.07410334f, 0.06414092f, -0.00903473f, 
    0.30235237f, 0.40592417f, 0.06672648f, -0.11227685f, 0.02854438f, -0.13198678f, 0.08376100f, -0.04891350f, 
    -0.11528084f, 0.20990662f, -0.15553924f, 0.06498741f, -0.00222265f, -0.08645328f, 0.04205710f, -0.06246777f, 
    0.00675065f, 0.18671365f, -0.02921661f, -0.03167479f, -0.10270053f, 0.11174711f, -0.12871252f, -0.00503459f, 
    0.23858702f, -0.13324848f, -0.01705442f, -0.55399889f, -0.08951230f, 0.12331350f, -0.03103939f, 0.00730627f, 
    -0.19090627f, -0.05871690f, 0.10156444f, 0.46940252f, 0.10413237f, -0.06031679f, -0.02236720f, -0.02226652f, 
    -0.05664281f, -0.01673369f, 0.12524223f, -0.04843392f, -0.31923848f, -0.35528386f, -0.34343845f, 0.10879917f, 
    0.15125345f, -0.03435975f, -0.02349790f, 0.09555671f, 0.14580956f, 0.37001261f, -0.25909331f, -0.21655521f, 
    -0.19299039f, 0.09144244f, 0.08643870f, -0.06834774f, -0.02876713f, 0.02889945f, 0.04349282f, 0.02139581f, 
    -0.11057857f, 0.11638698f, 0.01004242f, 0.17122991f, -0.02148847f, -0.07375465f, -0.02677853f, 0.10224809f, 
    -0.17452693f, -0.26316974f, 0.06487933f, 0.09075046f, 0.08754483f, 0.00045640f, 0.21188574f, 0.08848771f, 
    0.04868973f, -0.00257678f, -0.23738071f, -0.12228673f, -0.01528767f, -0.05701504f, 0.16103090f, 0.00768392f, 
    0.08596258f, -0.12769951f, 0.19750585f, -0.05176316f, -0.10055639f, 0.12939592f, -0.15148136f, 0.03744243f, 
    -0.06654169f, 0.05568053f, 0.01129408f, 0.01325156f, 0.18866067f, 0.04733094f, 0.00927594f, 0.00700802f, 
    -0.01717891f, 0.23228495f, -0.07004215f, 0.14639401f, 0.11264200f, -0.11067027f, -0.06194970f, 0.04878874f, 
    -0.09677870f, 0.10845514f, -0.00233604f, 0.27901408f, -0.55258244f, -0.13253213f, -0.32933682f, 0.13863400f, 
    -0.03639906f, 0.02613324f, -0.18182752f, -0.07396215f, 0.18266226f, -0.18315707f, -0.17295218f, -0.18796088f, 
    0.07513104f, -0.05952104f, -0.13170779f, 0.12953998f, -0.15364276f, 0.08078379f, 0.11624444f, 0.15741307f, 
    0.05644801f, -0.08744963f, -0.08895019f, 0.04843541f, -0.15431900f, -0.07473142f, -0.15452327f, 0.02339196f, 
    -0.33723280f, -0.27839547f, 0.04753087f, 0.16741243f, -0.10817432f, 0.05918778f, 0.01331804f, 0.02505745f, 
    -0.06390251f, -0.05081661f, -0.04520427f, -0.01464139f, 0.06015727f, -0.01824807f, 0.01850577f, 0.02851780f, 
    -0.01386969f, -0.08110546f, 0.05914821f, -0.06757191f, -0.07358012f, -0.05807592f, -0.07072609f, -0.09556256f, 
    -0.02599222f, -0.06264624f, -0.03615954f, 0.00888979f, -0.07540629f, -0.09552657f, -0.00898901f, 0.06317609f, 
    0.02863560f, 0.04315382f, -0.05602680f, 0.03731085f, -0.07810839f, -0.09554686f, -0.07662871f, 0.00012965f, 
    0.00967973f, -0.02430177f, 0.02777246f, 0.02406610f, -0.08279593f, 0.00064443f, 0.03687501f, 0.02680460f, 
    0.06926066f, -0.08725435f, -0.02987272f, -0.03234543f, 0.06975338f, 0.05301654f, -0.06725024f, -0.02975524f, 
    -0.07336365f, -0.03654272f, 0.03064742f, -0.03350148f, -0.03019788f, -0.08929453f, -0.01430621f, -0.04164784f, 
    -0.00477671f, -0.04917284f, -0.02101602f, -0.03683762f, -0.05067598f, 0.00628027f, -0.09090257f, 0.00303095f, 
    0.02398623f, -0.05459245f, -0.00709596f, 0.01565593f, -0.02440975f, 0.04786798f, -0.06315709f, 0.00088682f, 
    -0.03991108f, -0.08051041f, -0.04498373f, -0.00978975f, 0.01918981f, 0.03872084f, -0.05028301f, -0.05817754f, 
    -0.00710181f, 0.05648717f, 0.00097776f, 0.03766336f, -0.01001380f, -0.06858110f, -0.02760326f, -0.05070712f, 
    -0.01948482f, -0.03094880f, -0.01009678f, -0.08682522f, -0.04359597f, 0.00285166f, -0.06383853f, 0.05106833f, 
    -0.05212985f, -0.06727394f, -0.03990178f, -0.09523620f, -0.01634967f, -0.02160900f, 0.00393440f, 0.02445446f, 
    0.01731778f, -0.05364631f, -0.05120651f, -0.00218352f, 0.00236103f, 0.05586990f, 0.02193712f, 0.01829989f, 
    -0.05560002f, -0.06390990f, -0.03333242f, -0.07220267f, 0.01939255f, -0.05127217f, -0.02292069f, -0.03538796f, 
    0.02898991f, -0.02052478f, -0.07155105f, 0.00343682f, -0.03404460f, -0.02411180f, 0.05969717f, -0.02036121f, 
    0.04862171f, 0.02111113f, -0.02506156f, -0.00182366f, -0.02691310f, -0.00550991f, -0.07050236f, -0.05305282f, 
    -0.02105404f, 0.06678945f, 0.01670756f, -0.05747440f, 0.04520017f, 0.05474826f, -0.04201840f, -0.08870684f, 
    0.13315573f, -0.57886153f, -0.45238888f, 0.14232330f, 0.05005492f, 0.09209330f, -0.09589024f, 0.04888330f, 
    0.18489549f, 0.05584939f, -0.44892934f, -0.16899428f, 0.06086044f, 0.01484469f, 0.11108992f, 0.07030704f, 
    -0.09144105f, 0.05699551f, -0.12559353f, 0.10682157f, 0.34239021f, -0.04643851f, 0.02814818f, -0.24631226f, 
    -0.03922020f, -0.02042393f, 0.02220550f, -0.04599371f, -0.25554860f, -0.32493472f, 0.09557173f, 0.02108802f, 
    0.03793771f, 0.02829850f, -0.03511244f, 0.09755176f, 0.03731789f, 0.02255593f, 0.00035366f, -0.10907921f, 
    0.00176577f, -0.06148996f, 0.07756364f, 0.05372789f, 0.02076996f, -0.05540254f, -0.04170468f, 0.27771500f, 
    -0.07595738f, -0.02402721f, 0.09769166f, 0.07317386f, 0.02756997f, -0.07147254f, 0.15460636f, -0.23053317f, 
    -0.30705956f, 0.10604339f, 0.07933188f, 0.05425531f, 0.03244296f, 0.21141975f, 0.00302091f, -0.19540952f, 
    -0.28720891f, -0.41475290f, 0.11483368f, -0.17049484f, 0.04979103f, 0.18881132f, -0.17587559f, 0.05898144f, 
    0.41399828f, -0.11363412f, -0.41658029f, 0.04491073f, -0.02514660f, 0.09644104f, -0.02145406f, 0.08953205f, 
    -0.04253985f, -0.15839194f, -0.04593526f, 0.12727377f, 0.00699761f, -0.20179154f, 0.08798423f, 0.10111992f, 
    0.02740045f, -0.05476834f, 0.01945272f, -0.03642069f, -0.01599267f, 0.21091029f, -0.08840529f, 0.01975913f, 
    0.03110212f, -0.12772480f, -0.14801455f, 0.02141024f, -0.12195297f, -0.00614488f, 0.08154801f, -0.04397997f, 
    0.03524143f, 0.11123668f, -0.09900077f, -0.10586493f, -0.45580682f, 0.10762726f, -0.08164009f, -0.12108425f, 
    -0.12847789f, 0.12923697f, 0.05879466f, 0.05036174f, 0.11675336f, 0.21084878f, 0.09979802f, 0.14582522f, 
    -0.09248416f, -0.03292692f, 0.04640007f, -0.02431453f, 0.11691737f, -0.00199290f, 0.05428515f, 0.12792601f, 
    -0.54046911f, -0.00696754f, 0.09156150f, -0.01492094f, -0.01016183f, 0.03791865f, -0.03810417f, 0.36592847f, 
    0.29812026f, -0.08727400f, 0.10493839f, 0.21937041f, 0.06925127f, 0.01088861f, -0.16518369f, 0.06707010f, 
    0.08751211f, 0.16472225f, 0.09267291f, 0.03409678f, 0.11846129f, 0.09668290f, 0.07944227f, -0.23846063f, 
    -0.10530974f, 0.12379199f, 0.25600865f, -0.29407579f, 0.04903704f, -0.15038086f, 0.17969492f, 0.04627241f, 
    -0.08373895f, 0.01485787f, -0.07500351f, 0.07996409f, -0.14889677f, -0.02263767f, -0.01567047f, 0.05222975f, 
    0.00257114f, 0.15395516f, 0.10813764f, 0.16752796f, 0.27790031f, 0.30025837f, 0.00289542f, 0.03149041f, 
    -0.07165503f, -0.01386228f, 0.02949298f, -0.03244754f, -0.03126658f, 0.11042213f, -0.13153963f, 0.12477647f, 
    0.09082519f, -0.10203966f, -0.09226217f, -0.13483095f, -0.14525834f, 0.16947779f, 0.08132346f, 0.01143319f, 
    -0.02189454f, 0.05530314f, 0.07241988f, 0.08776218f, 0.03680433f, 0.09699132f, -0.22488357f, -0.10650527f, 
    0.24959719f, -0.11013030f, 0.03518439f, 0.06332120f, -0.07125412f, 0.10768793f, -0.11028472f, 0.24134253f, 
    0.13914683f, -0.01185547f, -0.14526835f, -0.11591265f, 0.01237501f, 0.25208417f, 0.01831058f, -0.02076464f, 
    0.18286352f, -0.07616725f, 0.21384905f, 0.13276374f, -0.01320667f, -0.19737023f, 0.01621475f, 0.03396912f, 
    -0.05084457f, 0.37697959f, -0.26183730f, 0.28147763f, 0.02311961f, 0.09807578f, -0.05989674f, -0.08757825f, 
    -0.26122853f, -0.00602870f, 0.21363345f, 0.07364007f, 0.02547553f, 0.04038669f, 0.10762213f, -0.00883519f, 
    0.33766136f, 0.10965516f, 0.02455672f, 0.13935390f, 0.24223836f, 0.10024744f, 0.02603360f, -0.00955391f, 
    -0.06201041f, 0.08169156f, -0.03522197f, -0.08226941f, -0.08539723f, -0.03833401f, 0.12735343f, -0.28586307f, 
    0.16028100f, -0.00434939f, -0.05223219f, 0.14536560f, 0.40951747f, 0.12590192f, 0.09249823f, 0.25490564f, 
    0.04147102f, -0.12158468f, -0.17216429f, -0.02095507f, 0.14147824f, -0.03492863f, -0.01921193f, -0.06926616f, 
    0.12430459f, -0.14352934f, 0.03237042f, 0.05854657f, 0.00406713f, 0.08054627f, -0.14563194f, -0.02044866f, 
    0.09709401f, 0.19814545f, 0.15101860f, -0.08040162f, -0.12189958f, -0.05735282f, 0.15636887f, -0.10505749f, 
    0.13942555f, -0.10447481f, -0.28359553f, 0.08231404f, 0.05076911f, 0.14080627f, 0.15018617f, -0.05645419f, 
    -0.22941412f, 0.12772167f, 0.01199168f, -0.06206268f, -0.03403005f, -0.07892349f, 0.07343743f, -0.10865520f, 
    0.13082704f, 0.14677536f, -0.03324747f, -0.02567424f, 0.20015459f, -0.13763545f, -0.11923464f, 0.01310369f, 
    -0.04237577f, -0.06321702f, -0.29437593f, -0.09911211f, -0.08162409f, 0.32542732f, -0.06996375f, -0.03526399f, 
    -0.03968446f, 0.03044601f, 0.07304970f, 0.10117483f, -0.04304854f, -0.03465088f, -0.07429952f, -0.00068154f, 
    0.18132707f, 0.00943865f, 0.08154255f, 0.15315387f, 0.26182863f, -0.24529912f, -0.16722348f, 0.18231669f, 
    -0.11108617f, -0.08909825f, 0.08749712f, -0.14230025f, -0.04087799f, -0.00892784f, 0.15094765f, 0.07995626f, 
    0.06481182f, 0.12114438f, 0.11013748f, 0.20826411f, 0.00805193f, -0.12257691f, 0.15308069f, 0.07080466f, 
    -0.01681272f, -0.05334937f, 0.02111659f, 0.11965182f, 0.32242337f, 0.11515307f, 0.27763593f, 0.32845518f, 
    -0.03388859f, -0.35752159f, -0.01615447f, 0.10651140f, 0.02867194f, -0.01009601f, -0.17517260f, -0.10402190f, 
    -0.11496887f, -0.07064537f, -0.10866615f, -0.08118248f, 0.06928904f, -0.11553857f, -0.20083439f, -0.01835527f, 
    0.07350080f, -0.02172877f, 0.08193659f, -0.03714374f, 0.02232413f, 0.07138883f, 0.12991813f, -0.05111296f, 
    -0.01049357f, 0.06597319f, 0.25857380f, -0.07551734f, -0.05981282f, 0.07868848f, 0.05201055f, 0.02559822f, 
    0.10728170f, 0.09405646f, -0.08703377f, -0.24942964f, -0.12186154f, 0.17208995f, -0.00030987f, -0.07167351f, 
    0.02821586f, -0.07021543f, -0.26333311f, -0.28337532f, -0.32482037f, 0.01399023f, -0.14329943f, -0.03226662f, 
    0.05815467f, 0.08861942f, 0.14698724f, 0.13915794f, 0.15274981f, 0.15489630f, -0.23757495f, -0.47200817f, 
    -0.05334942f, -0.03226651f, -0.06783328f, -0.10804375f, -0.01382496f, 0.18340458f, -0.07242154f, -0.01067568f, 
    0.10251454f, 0.10805494f, 0.22476496f, -0.03004957f, 0.11400882f, 0.03059880f, 0.08977439f, -0.02647300f, 
    -0.02025108f, 0.11898854f, -0.25512299f, -0.18853340f, 0.03971961f, -0.20498025f, 0.06250560f, -0.01993638f, 
    0.07351633f, 0.06593157f, 0.20037289f, 0.24526846f, -0.25333303f, -0.04695718f, -0.11587842f, 0.06909204f, 
    -0.01723070f, 0.00232309f, 0.39904720f, 0.21026911f, 0.22723286f, -0.12157267f, 0.04572808f, -0.24844354f, 
    0.09961492f, -0.13024731f, -0.07017215f, -0.59884018f, -0.28209248f, 0.16336152f, 0.07467592f, -0.00898291f, 
    -0.01632959f, 0.06001832f, 0.06048722f, 0.09558419f, -0.04986871f, -0.08857998f, -0.02101725f, 0.01685221f, 
    0.02453106f, 0.04094306f, 0.05476104f, 0.05132302f, 0.22413304f, 0.40626770f, -0.20093732f, 0.02521741f, 
    0.02264297f, 0.14813513f, 0.13572170f, -0.04981404f, -0.05026856f, -0.10304061f, 0.27011675f, 0.05565580f, 
    -0.07379413f, -0.16369176f, 0.09229640f, 0.18304618f, 0.17524518f, 0.18243536f, 0.08425424f, -0.22221769f, 
    0.27003023f, -0.05030628f, -0.07864346f, 0.01316153f, 0.08459873f, 0.03966227f, -0.03736546f, 0.03731527f, 
    -0.42489445f, -0.14919250f, -0.14250332f, 0.01255138f, -0.08329285f, -0.00574471f, 0.01391955f, 0.14977573f, 
    0.15147765f, 0.36610779f, 0.03659531f, -0.33908305f, 0.07823207f, -0.06636429f, 0.17531475f, 0.19954014f, 
    0.00182972f, -0.10075994f, -0.17266209f, 0.16909587f, -0.09174056f, 0.07365478f, 0.10115799f, -0.02908567f, 
    -0.02519678f, -0.01784541f, 0.14812435f, -0.02544803f, 0.31227079f, -0.00317149f, 0.17486592f, -0.00626356f, 
    -0.09201568f, 0.07328676f, -0.02600749f, -0.01202954f, 0.10581580f, 0.12483361f, -0.03997742f, -0.09478744f, 
    -0.06402474f, -0.18058515f, 0.04336951f, -0.20987603f, -0.09151966f, -0.19216362f, -0.13917534f, 0.05508016f, 
    -0.20156261f, 0.03080751f, -0.05964513f, 0.06396209f, 0.05837670f, 0.17639026f, -0.28293040f, -0.25635514f, 
    0.00187016f, 0.01249479f, 0.13040297f, -0.10494259f, 0.05056713f, -0.13254467f, -0.05891654f, 0.13346788f, 
    0.08517946f, 0.01384953f, -0.00737814f, 0.00019085f, -0.11075081f, -0.07133675f, 0.07060689f, 0.01919844f, 
    0.24970329f, 0.20668204f, -0.13103457f, -0.01744583f, 0.24692516f, -0.08874784f, -0.11627260f, 0.03190508f, 
    -0.01098022f, 0.11861744f, -0.35625491f, -0.35773283f, 0.06892563f, 0.00762718f, 0.12754826f, -0.11596571f, 
    -0.01989008f, 0.09135124f, -0.00210380f, -0.26977000f, -0.02296268f, -0.07213464f, -0.12493438f, -0.06647614f, 
    -0.09673730f, 0.04103498f, 0.12005810f, 0.11341443f, 0.23194040f, -0.29747626f, 0.11155443f, -0.14727813f, 
    0.18588410f, 0.13185918f, 0.12970020f, -0.02413556f, -0.13303179f, 0.13489689f, -0.20487569f, 0.03289315f, 
    0.03950974f, 0.06439727f, -0.10446490f, -0.16366500f, -0.34110776f, -0.17305121f, -0.05282282f, 0.05054051f, 
    0.11843389f, -0.17566478f, 0.03911876f, 0.07476097f, 0.01605690f, 0.18603240f, -0.14599068f, 0.00886575f, 
    -0.01619702f, 0.04399565f, -0.08077209f, 0.15469320f, -0.10292491f, -0.11780521f, -0.01534099f, 0.11825265f, 
    0.03088899f, 0.01998632f, -0.06442381f, 0.01116694f, -0.14811356f, -0.00261356f, 0.12645373f, -0.11877789f, 
    0.21500261f, 0.03382959f, -0.03867083f, 0.18131062f, -0.04681964f, -0.11824244f, 0.05920617f, 0.07118647f, 
    0.02993130f, 0.10302820f, -0.32028344f, -0.37125781f, 0.04314542f, 0.01767201f, -0.04072952f, 0.07790046f, 
    -0.16643304f, 0.05420538f, 0.08106329f, -0.20736648f, -0.13550644f, 0.08518752f, -0.02392161f, 0.25128695f, 
    -0.05172367f, 0.02919786f, -0.19863103f, 0.10591051f, -0.08591746f, -0.08089881f, -0.12814456f, 0.00975750f, 
    -0.06763569f, 0.07402171f, 0.14485535f, 0.10044203f, -0.18180364f, -0.03970770f, -0.01783882f, -0.24523601f, 
    0.15992609f, 0.01527515f, -0.16716483f, 0.03683395f, 0.18934086f, 0.16855285f, -0.08519904f, 0.02204581f, 
    0.27502853f, 0.15544963f, 0.09416980f, 0.15385790f, -0.07040193f, 0.04058803f, -0.16399132f, -0.11050264f, 
    -0.31422687f, 0.17897749f, -0.01805501f, 0.15609396f, 0.01186121f, -0.05176888f, 0.04251390f, -0.04082074f, 
    0.05461022f, 0.17368026f, 0.24502879f, 0.05833139f, 0.05134409f, 0.04716542f, 0.00129869f, -0.01176792f, 
    -0.44411609f, 0.11698361f, 0.03015728f, -0.17053516f, -0.01449448f, 0.12477334f, -0.15238896f, 0.13651448f, 
    -0.01856608f, -0.20793393f, -0.01227043f, 0.08120668f, 0.01837027f, -0.10729340f, -0.12340489f, 0.09816399f, 
    0.03312252f, -0.12438146f, 0.03267815f, -0.43289232f, -0.30289069f, -0.48172778f, -0.07817484f, -0.19493642f, 
    -0.07046207f, 0.01313903f, -0.02236761f, 0.04422221f, 0.08709375f, -0.13963397f, 0.08435991f, 0.04279839f, 
    0.22758050f, -0.09268981f, 0.10048328f, 0.04111646f, 0.12415258f, 0.38250247f, -0.22327574f, -0.08102124f, 
    -0.08655910f, -0.04320356f, 0.09179556f, -0.05646915f, 0.20994963f, -0.21112859f, -0.25631326f, 0.22197215f, 
    0.07195102f, -0.02690612f, -0.06483770f, 0.11825150f, -0.14907545f, 0.16464520f, 0.14010800f, -0.17834088f, 
    0.30975351f, 0.06937589f, 0.01121887f, 0.03649864f, 0.06464126f, 0.07427855f, -0.00519214f, -0.03077598f, 
    0.15559410f, 0.12313888f, 0.07864172f, -0.09500603f, 0.16047280f, -0.07670781f, 0.10078131f, -0.30738890f, 
    -0.18546537f, -0.16490376f, -0.17190643f, 0.07919476f, 0.01700592f, 0.07009274f, -0.05969671f, -0.16799039f, 
    -0.05819622f, -0.53596467f, -0.33025888f, 0.37899888f, 0.03066440f, -0.02577258f, -0.01322662f, 0.16771461f, 
    0.03143816f, 0.11119986f, 0.12523644f, 0.15016581f, -0.03206173f, -0.01986016f, -0.00166926f, 0.14760800f, 
    -0.04562281f, 0.14960317f, -0.07853116f, -0.31995127f, 0.05277730f, -0.00514970f, 0.07312965f, -0.06861484f, 
    0.09032398f, 0.11316337f, 0.01697336f, 0.02235685f, 0.24970430f, -0.00734352f, -0.21907197f, -0.09290340f, 
    -0.10783859f, -0.05532607f, 0.09381569f, -0.07741603f, -0.10196795f, 0.07141735f, 0.08839019f, -0.45575058f, 
    -0.09555995f, 0.12930821f, -0.08286478f, 0.04051984f, 0.13863756f, 0.01177339f, -0.15869616f, 0.03984486f, 
    0.25523809f, 0.02796488f, -0.18731861f, 0.21896192f, 0.05902470f, 0.23144281f, -0.11328185f, 0.25246945f, 
    -0.27295575f, 0.07049294f, 0.09992989f, -0.13291362f, 0.07388778f, 0.07161460f, -0.03918957f, 0.13498820f, 
    0.10116880f, 0.19388551f, -0.13238141f, -0.13438596f, -0.12007900f, -0.06854629f, -0.02976800f, 0.07176317f, 
    0.07098734f, 0.19296297f, 0.02014049f, 0.22646065f, 0.05696088f, 0.04560526f, -0.26319081f, 0.12118781f, 
    0.10053719f, 0.09708814f, 0.06530953f, 0.10870905f, -0.37201780f, -0.02273359f, -0.06266549f, -0.00410960f, 
    -0.06839232f, 0.06313393f, -0.09154632f, 0.16255908f, -0.11642051f, 0.03740713f, -0.06647728f, -0.10030618f, 
    0.00586844f, -0.03125776f, 0.01404962f, 0.19693828f, -0.69955629f, -0.01227281f, 0.59320128f, 0.01552279f, 
    0.09083154f, 0.08092393f, 0.14802133f, 0.05638368f, 0.10290503f, -0.23635620f, -0.21284313f, -0.37359375f, 
    -0.12777720f, -0.09288541f, 0.01459664f, 0.14805104f, 0.04378999f, -0.08559360f, -0.01529583f, -0.08102134f, 
    -0.02852447f, 0.04078600f, 0.18040819f, -0.07225430f, 0.04686535f, 0.09338483f, 0.00667695f, -0.02997399f, 
    0.18839078f, -0.09432299f, 0.07874452f, 0.09659491f, 0.00759518f, 0.06738991f, -0.05038279f, -0.01497236f, 
    0.13302019f, -0.01731958f, -0.08356278f, -0.05731719f, 0.07695452f, 0.04270545f, -0.13937221f, 0.05542116f, 
    -0.15527759f, -0.46493232f, 0.35528558f, 0.07821076f, -0.06952398f, 0.07258458f, -0.03947368f, -0.02868117f, 
    -0.13873377f, -0.00831739f, -0.05348642f, 0.05057161f, 0.11137857f, 0.09211411f, -0.07190616f, -0.02917402f, 
    -0.01127767f, 0.08803886f, 0.21802005f, 0.00476654f, 0.16081738f, -0.02739086f, 0.17209469f, 0.01041147f, 
    -0.13869908f, 0.00260564f, -0.05442774f, -0.01246574f, -0.25858128f, 0.03777115f, -0.30514759f, -0.01445423f, 
    0.02365529f, -0.14156403f, -0.09686235f, -0.11884284f, 0.03464090f, -0.29212597f, 0.21379359f, -0.04733468f, 
    0.08416008f, 0.01160755f, 0.02073938f, 0.05249588f, -0.11993914f, 0.21120495f, 0.08343907f, 0.20039223f, 
    0.24636370f, -0.18365285f, -0.00405473f, -0.07039083f, 0.01916942f, -0.13767907f, -0.08723551f, -0.56294966f, 
    -0.16993594f, 0.22209370f, -0.01881925f, 0.10315306f, -0.00875434f, 0.06040266f, 0.04951807f, -0.05623213f, 
    -0.07063084f, -0.00539130f, 0.07418714f, 0.07344588f, 0.01581429f, -0.07675986f, 0.01275463f, 0.00080011f, 
    0.02554949f, -0.05691777f, 0.04931955f, -0.06401791f, -0.05220259f, 0.00944058f, 0.03143165f, -0.05691284f, 
    0.00201966f, 0.05185222f, -0.01106195f, 0.01456574f, -0.02118348f, 0.06606704f, 0.04644305f, -0.08926466f, 
    -0.00249689f, -0.04625567f, 0.04057769f, 0.05755864f, -0.02083965f, -0.01443589f, 0.03351282f, -0.04852264f, 
    -0.01133023f, -0.05012574f, 0.04435767f, -0.00756571f, -0.06811318f, -0.00668996f, 0.04283439f, -0.09046244f, 
    0.06156663f, 0.04605954f, 0.01704529f, -0.06142247f, -0.08457465f, -0.07288855f, -0.01933854f, 0.07306243f, 
    0.03091676f, 0.05102516f, -0.03560302f, -0.09170185f, -0.04339082f, 0.02876188f, 0.02634822f, -0.07491083f, 
    -0.03637641f, 0.02348952f, -0.07502732f, 0.02162405f, 0.01782879f, 0.05624891f, -0.08969879f, -0.02417987f, 
    -0.01885389f, -0.04388447f, 0.03323917f, -0.07308710f, -0.06350301f, -0.06282156f, -0.06053023f, -0.00636701f, 
    0.03193115f, 0.06353958f, -0.01069743f, 0.00486809f, 0.07118224f, -0.01878396f, 0.03624610f, -0.06860886f, 
    0.06908078f, 0.04483110f, -0.04506890f, 0.05392753f, -0.05814440f, 0.06445838f, -0.01259971f, -0.00726885f, 
    -0.05221280f, -0.05985308f, -0.04907507f, -0.07151274f, 0.04635083f, -0.02952871f, 0.06560792f, -0.09090992f, 
    -0.02558911f, 0.05352764f, -0.05735414f, -0.07812952f, 0.06617222f, -0.06556074f, -0.09096529f, 0.07352968f, 
    0.02023682f, -0.01929802f, -0.08100092f, -0.05302411f, 0.00365543f, 0.03930032f, -0.02000849f, -0.03267512f, 
    0.05591486f, -0.01832445f, -0.05941750f, -0.08959629f, 0.07143805f, -0.02957050f, 0.01412009f, -0.04376306f, 
    -0.07072986f, -0.06878695f, -0.09308293f, 0.03793023f, -0.06008564f, 0.06750177f, 0.05570499f, -0.03749905f, 
    -0.00582969f, -0.07504958f, -0.02052249f, 0.02211886f, -0.05992484f, -0.06690883f, -0.00870315f, 0.05233016f, 
    -0.02969226f, 0.00344571f, -0.05355321f, 0.03356566f, -0.00135550f, -0.08339658f, -0.06431509f, 0.03491668f, 
    -0.07088784f, -0.06153425f, 0.38370669f, 0.03449961f, 0.09389155f, -0.12796332f, -0.12748919f, -0.18196832f, 
    -0.12099747f, 0.05735622f, 0.18872134f, 0.08324867f, 0.11621820f, 0.00653433f, -0.21454698f, -0.01320637f, 
    -0.06769768f, -0.13470669f, -0.24557631f, 0.05644727f, -0.02464875f, -0.14026238f, 0.08396043f, -0.03208766f, 
    -0.15080231f, -0.27017334f, 0.10462826f, -0.00039736f, -0.23626873f, 0.11763143f, 0.20844157f, -0.08992995f, 
    0.10607237f, 0.22789998f, 0.11832450f, 0.14691082f, 0.09809236f, -0.04680917f, 0.24033998f, 0.25174317f, 
    0.07245806f, 0.11981291f, 0.16848549f, 0.11396104f, 0.10460921f, -0.22730738f, 0.13440229f, 0.02200496f, 
    -0.12157371f, -0.06474213f, -0.06414147f, 0.01105887f, 0.09922440f, -0.10499606f, 0.25181463f, -0.17422140f, 
    -0.24925375f, -0.00193622f, -0.08217148f, 0.01719604f, -0.02994584f, -0.05344965f, 0.02726367f, -0.04462292f, 
    -0.06704141f, 0.15396103f, -0.04496331f, 0.01563052f, 0.05751153f, 0.11097250f, 0.07654320f, -0.02519885f, 
    0.29576918f, -0.35257006f, 0.17368285f, -0.00400772f, 0.09867272f, 0.09471432f, -0.09690855f, -0.05999614f, 
    -0.06534123f, -0.26251075f, -0.03976985f, 0.02951096f, -0.00069710f, -0.17051578f, -0.06726131f, -0.01374721f, 
    -0.06652321f, 0.04957086f, -0.17143391f, 0.14548002f, 0.09562716f, 0.08298839f, 0.00023863f, 0.03252213f, 
    0.05041257f, 0.14333253f, 0.11218227f, -0.03339759f, -0.43249264f, -0.03000105f, 0.17237501f, -0.02649191f, 
    -0.05902024f, -0.14993806f, -0.09147083f, -0.15319468f, 0.16531824f, 0.27121416f, 0.06487409f, -0.10390077f, 
    -0.01200948f, 0.05521941f, -0.26483691f, -0.33856270f, -0.20657063f, 0.00649452f, 0.00920329f, -0.03819017f, 
    -0.00429075f, 0.09815635f, 0.14998002f, 0.15582711f, -0.12217537f, -0.13548081f, 0.10933678f, 0.04427814f, 
    0.16969950f, -0.07952014f, -0.03431875f, 0.01735896f, 0.03503883f, -0.18565157f, 0.02541358f, 0.06946553f, 
    0.27665326f, -0.08878260f, 0.09622984f, 0.15894689f, -0.10829349f, 0.08596192f, 0.11992415f, -0.19849366f, 
    0.08707301f, -0.27168512f, 0.11087700f, -0.13466083f, -0.21805581f, 0.00853782f, 0.07540281f, -0.03037226f, 
    0.00693307f, -0.39792740f, -0.22579217f, -0.21966992f, 0.14178869f, 0.07868204f, -0.10643876f, -0.15617418f, 
    0.03554287f, 0.12606061f, 0.29210913f, 0.08614764f, -0.17477246f, -0.00347358f, 0.03148324f, -0.00126183f, 
    0.03404165f, -0.03677825f, 0.02682486f, 0.02617502f, -0.40011990f, -0.25044036f, 0.07727165f, 0.03005696f, 
    -0.02714092f, 0.02078746f, 0.00788713f, 0.12916224f, 0.08494215f, 0.26827291f, 0.26403856f, -0.21059026f, 
    0.00992921f, -0.10608414f, -0.10383241f, -0.00534391f, 0.19454981f, 0.52500367f, 0.25547343f, 0.07444643f, 
    0.07929769f, -0.02104469f, 0.19671725f, -0.06839545f, -0.05243037f, -0.01812528f, 0.13150056f, -0.30917329f, 
    -0.25520203f, 0.01490634f, -0.05586286f, -0.00138914f, 0.06865840f, -0.00092744f, 0.03394328f, -0.15854421f, 
    0.21336436f, -0.44325420f, -0.18095817f, -0.13923918f, 0.14654203f, 0.07255738f, 0.13863014f, 0.04773242f, 
    -0.29536745f, 0.15099120f, 0.06466627f, -0.12002696f, 0.00783189f, -0.01372748f, 0.08097932f, -0.13526775f, 
    -0.21534023f, 0.18076888f, 0.05728933f, 0.24088953f, -0.02238550f, 0.05720950f, -0.04366630f, -0.02267513f, 
    0.15111083f, 0.11400012f, -0.21615244f, -0.09945656f, 0.32733867f, 0.09763365f, 0.15484086f, 0.03293253f, 
    0.03829855f, 0.07262621f, 0.02369136f, -0.25903773f, 0.00046604f, -0.08361196f, -0.00941693f, -0.05761354f, 
    -0.00630451f, -0.01052377f, 0.00329821f, -0.02713380f, 0.29137471f, -0.30397227f, -0.11305366f, 0.11890144f, 
    -0.05006021f, -0.01910538f, 0.04205933f, 0.02450561f, -0.10236331f, 0.05751625f, 0.11307963f, -0.17585407f, 
    -0.02115267f, 0.02749528f, 0.15875791f, -0.06185207f, 0.05797318f, 0.10064879f, 0.04158453f, 0.09229162f, 
    -0.09919821f, 0.04468424f, 0.05938760f, 0.01597005f, -0.07259768f, 0.10929780f, 0.08408383f, 0.10986886f, 
    0.02023449f, -0.06860422f, 0.03093503f, 0.00209288f, -0.04175838f, 0.05023260f, 0.03765595f, -0.11894893f, 
    -0.02548604f, -0.06971741f, -0.54416108f, 0.14328691f, 0.31751826f, 0.06605011f, -0.03087820f, -0.06056798f, 
    0.13537861f, 0.04602367f, -0.24504060f, 0.18655874f, -0.00830114f, 0.14427142f, -0.09457053f, 0.08179086f, 
    -0.19781734f, -0.03968565f, -0.05886856f, -0.10298815f, 0.23507857f, -0.29436827f, 0.01141355f, -0.07897924f, 
    0.11635178f, -0.10152027f, 0.05975409f, 0.38639820f, 0.13252777f, -0.02758698f, -0.18324679f, -0.06234775f, 
    -0.23564956f, -0.04924955f, 0.02647245f, 0.03477740f, -0.19080277f, -0.35084537f, -0.33582759f, -0.00532994f, 
    -0.03273423f, 0.03717624f, 0.09048076f, -0.15375526f, -0.08159121f, 0.08461498f, -0.10897526f, -0.21782941f, 
    -0.12913492f, 0.05264983f, 0.09239949f, -0.03047202f, -0.01603251f, -0.02640893f, -0.21347335f, 0.05586908f, 
    0.05575643f, -0.07681081f, -0.00316685f, 0.12600361f, 0.06410956f, 0.02849620f, 0.05157278f, -0.36555976f, 
    -0.31721738f, 0.06910484f, -0.03980476f, 0.06601860f, 0.07463735f, -0.09863769f, -0.10471907f, -0.18599522f, 
    -0.06481072f, 0.06434359f, -0.12855287f, -0.13582288f, -0.01279427f, -0.24245723f, -0.10765507f, -0.05374221f, 
    0.05900193f, -0.49770170f, 0.35885021f, -0.20148514f, 0.05786650f, 0.08493275f, -0.08502119f, -0.05904306f, 
    0.01753228f, -0.06757644f, 0.16400763f, -0.21031933f, 0.28943610f, -0.07523214f, -0.00689696f, 0.03218383f, 
    0.04857178f, 0.23928297f, 0.01531903f, 0.06742815f, 0.08751697f, 0.13307145f, 0.04424546f, 0.13338833f, 
    -0.16503040f, 0.04018737f, 0.12830138f, 0.18274295f, -0.24018256f, 0.05114065f, 0.07109442f, 0.17747371f, 
    -0.06340808f, -0.04542034f, 0.05885123f, -0.14286549f, 0.23842831f, -0.35415113f, -0.00694270f, 0.25792983f, 
    -0.04881424f, 0.04188728f, -0.11575358f, 0.14619872f, 0.01122043f, 0.01463614f, 0.03752674f, 0.21290752f, 
    -0.07454637f, 0.00974499f, -0.10318998f, -0.05790575f, -0.05566991f, -0.06693564f, 0.04473679f, -0.00322601f, 
    -0.21247587f, -0.16166712f, -0.15807402f, 0.03930817f, 0.07816492f, 0.06457885f, 0.08265418f, 0.07133654f, 
    0.05876432f, -0.20808315f, 0.01797155f, 0.10128738f, 0.32142869f, -0.22106953f, 0.11004521f, 0.11321584f, 
    0.08217304f, -0.05807375f, -0.18833257f, -0.22017929f, -0.03621956f, -0.15825078f, -0.04126944f, 0.19940911f, 
    -0.16878706f, -0.20001544f, 0.01979424f, 0.09799290f, -0.00941631f, -0.14692897f, 0.00279823f, -0.02293956f, 
    -0.09956984f, 0.08829820f, -0.14152810f, -0.13886167f, -0.03289916f, 0.12422944f, -0.10849462f, -0.03763641f, 
    0.03076445f, 0.10282946f, 0.08120616f, -0.13317457f, 0.19203123f, -0.10556869f, 0.17159630f, 0.06909595f, 
    0.06613508f, 0.09363812f, -0.01514454f, -0.39536047f, 0.01216786f, 0.01253630f, -0.00511911f, -0.01000171f, 
    0.03942318f, -0.06670460f, 0.06491334f, -0.28382689f, 0.15318556f, -0.15966284f, 0.11064485f, 0.00898837f, 
    0.03326596f, -0.11753745f, -0.01110695f, -0.12329484f, 0.26874885f, -0.19138227f, -0.19109577f, -0.25848657f, 
    0.00791005f, 0.15358368f, 0.15645465f, 0.21834897f, 0.10415790f, -0.05088338f, 0.28848061f, -0.18700673f, 
    -0.17995064f, -0.08397790f, 0.06455330f, -0.46122295f, -0.30961984f, 0.02957316f, 0.07127310f, 0.17738065f, 
    -0.16075149f, 0.00070684f, -0.21745910f, -0.14420143f, 0.13846779f, 0.04612468f, 0.22562103f, 0.18220577f, 
    0.05433053f, -0.01538653f, -0.00468082f, -0.05686153f, -0.11034287f, 0.13680282f, 0.10276680f, -0.21857326f, 
    -0.01577469f, -0.07075963f, -0.08504803f, -0.26725864f, -0.16266602f, -0.00764645f, -0.09760264f, -0.04224134f, 
    -0.07552101f, 0.20336768f, -0.03821999f, -0.04829425f, 0.17737523f, -0.37675515f, 0.21545555f, 0.10478945f, 
    -0.33778936f, 0.14901114f, -0.03092740f, -0.04866761f, 0.08942376f, -0.08186021f, 0.03524531f, 0.04957462f, 
    -0.24424392f, -0.13473940f, 0.37529752f, -0.38552234f, 0.07332087f, -0.06273639f, 0.09791078f, -0.12121366f, 
    -0.12172098f, -0.01360807f, 0.05697529f, 0.00862829f, 0.11712233f, 0.11423096f, -0.12090248f, -0.15581404f, 
    -0.05334413f, -0.14573157f, -0.06462449f, 0.03127956f, 0.01892685f, -0.11034033f, 0.10112756f, -0.05157626f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.29325262f, -0.02743614f, 0.22971638f, -0.02241954f, 0.06685092f, 0.09816119f, 0.13688204f, 0.01589586f, 
    0.03770997f, 0.09950057f, 0.09876781f, -0.05087076f, -0.01672116f, 0.07307927f, 0.15844990f, 0.04285731f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16446036f, 0.12344827f, 0.34784052f, 0.09434564f, -0.10765152f, -0.20378709f, 0.45323431f, 0.42933789f, 
    0.17132623f, -0.34073609f, -0.18770373f, 0.06696382f, -0.00965326f, -0.30642274f, 0.40808919f, -0.02388181f, 
    0.33581209f, -0.27526420f, -0.21094649f, -0.02133813f, -0.01224998f, -0.12348793f, 0.41116658f, 0.21245664f, 
    -0.28295839f, -0.04727702f, -0.17057337f, 0.17341293f, 0.33678097f, -0.01640845f, -0.09143446f, -0.20536138f, 
    0.44724375f, -0.06272197f, -0.01351831f, 0.21138537f, 0.22012286f, -0.10605821f, 0.09100822f, 0.27411476f, 
    0.45662048f, -0.50546199f, -0.47685984f, -0.07309518f, -0.14245668f, 0.32140115f, -0.34079498f, 0.21055230f, 
    -0.04803458f, 0.39505970f, 0.11055499f, 0.00821235f, 0.50001889f, 0.14385635f, -0.21348368f, -0.07202074f, 
    0.00757306f, -0.06824092f, 0.02765194f, -0.02959958f, -0.08181816f, 0.07687499f, -0.40110132f, 0.01287188f, 
    0.62335622f, -0.04046534f, -0.31626809f, -0.13362616f, -0.00561525f, 0.31508684f, -0.10750769f, -0.15433294f, 
    0.13908517f, -0.16847499f, -0.19320011f, 0.01798211f, -0.14066438f, 0.07735523f, -0.13877355f, -0.41185334f, 
    -0.54347783f, 0.39013377f, 0.16851686f, -0.25138935f, -0.28906807f, 0.22563016f, 0.07874776f, 0.15157862f, 
    -0.36269134f, 0.20358036f, -0.06931453f, 0.21523696f, 0.09293493f, -0.20393328f, -0.06043525f, -0.00854348f, 
    0.05763447f, -0.23290792f, 0.06570050f, 0.02702263f, 0.02908936f, -0.17101109f, -0.20658094f, 0.06924191f, 
    0.10517117f, -0.02215210f, -0.10278106f, -0.20116210f, 0.02312917f, -0.10935295f, 0.15659073f, 0.10654604f, 
    -0.01959956f, -0.19545332f, 0.14025822f, 0.23334780f, -0.19579399f, -0.14764941f, -0.05635553f, 0.18167430f, 
    -0.23907208f, -0.15288870f, 0.03921626f, 0.14579138f, -0.20804366f, 0.04133854f, 0.14325060f, 0.06201857f, 
    -0.17358865f, -0.22482400f, -0.23369984f, -0.20438701f, 0.07187144f, 0.18846357f, -0.08441386f, -0.30016431f, 
    0.30436915f, 0.13281420f, -0.12189057f, 0.09794244f, 0.12571974f, 0.21336256f, -0.43186775f, -0.40726545f, 
    -0.20611039f, -0.23937936f, 0.06997053f, 0.05085292f, 0.17977794f, 0.41638443f, 0.17727174f, -0.00111834f, 
    -0.16906361f, -0.28461877f, -0.03978672f, -0.04319799f, -0.49221677f, -0.25486144f, 0.16829722f, -0.00354640f, 
    -0.00654624f, -0.41896340f, -0.03220034f, -0.08539662f, -0.17736375f, 0.28447801f, 0.05214158f, -0.84599066f, 
    -0.39507708f, -0.31674960f, 0.28460824f, -0.20348486f, 0.24155855f, -0.37735838f, 0.13793501f, -0.96091682f, 
    0.23116256f, 0.19036084f, 0.22821450f, 0.05450502f, 0.04671372f, 0.31878471f, -0.23501271f, -0.09667467f, 
    0.23288898f, -0.21964966f, -0.32259381f, -0.10127497f, -0.35306555f, -0.36911201f, 0.28592327f, 0.40554041f, 
    -0.12956163f, -0.19156584f, 0.63894486f, -0.20888442f, 0.12788029f, -0.03367292f, -0.21633427f, 0.27237201f, 
    -0.38706207f, 0.09481333f, 0.09921643f, -0.06375411f, -0.21717858f, 0.37040272f, 0.15629233f, -0.11379704f, 
    0.21249093f, -0.20087405f, 0.25603664f, 0.03158447f, -0.03477884f, 0.02571800f, -0.34281248f, 0.38675886f, 
    0.15541349f, -0.07172040f, -0.63544697f, -0.02604509f, -0.41134474f, 0.52800018f, -0.41518590f, 0.08400620f, 
    0.14080752f, -0.26362693f, 0.22992145f, 0.13711222f, 0.17313398f, 0.05622623f, 0.15067984f, 0.00838737f, 
    -0.11209514f, -0.06285291f, -0.09790704f, 0.23875621f, 0.37166494f, -0.10868706f, 0.42320231f, -0.14147440f, 
    0.28647375f, 0.46089503f, -0.41663250f, 0.20803462f, -0.18271828f, 0.17617825f, 0.18756449f, 0.04007836f, 
    0.11571684f, 0.12697122f, 0.08810419f, -0.05279117f, -0.27152786f, -0.41385716f, -0.18091321f, 0.03352744f, 
    -0.30932438f, 0.26754898f, 0.12720045f, 0.19474086f, -0.11020592f, 0.12938045f, -0.10510446f, -0.07582418f, 
    0.28726593f, -0.20319739f, -0.05437219f, 0.04330862f, 0.23077619f, 0.20198596f, -0.51650274f, 0.51226979f, 
    -0.02579503f, 0.09910648f, 0.07610371f, 0.17053732f, 0.10139707f, -0.21642977f, 0.23090427f, -0.04840864f, 
    0.15740520f, -0.17332162f, 0.02933916f, -0.17898005f, 0.19978240f, -0.30443421f, 0.20797162f, 0.01139981f, 
    -0.31251997f, -0.25419143f, 0.02997965f, -0.14839354f, -0.10392925f, 0.09446482f, 0.18995260f, -0.05648331f, 
    -0.27560484f, 0.33677641f, 0.16502862f, -0.13046238f, 0.31565797f, 0.44803759f, 0.01659074f, -0.20644554f, 
    0.02966625f, 0.14115296f, -0.12974729f, 0.20716149f, -0.25814217f, -0.06541108f, 0.07454790f, 0.32029903f, 
    -0.47450697f, 0.14105339f, 0.11246727f, -0.18860875f, 0.25368807f, -0.05041599f, -0.34646738f, -0.31203163f, 
    0.03250594f, 0.25918612f, 0.23196763f, 0.22394846f, 0.11275611f, -0.16620784f, -0.13364890f, -0.00163417f, 
    -0.15620112f, 0.37354425f, 0.13287903f, 0.19965917f, 0.30637407f, 0.08888867f, -0.20515345f, 0.03269830f, 
    0.55978680f, -0.07385378f, 0.11855329f, -0.11098860f, -0.04141508f, 0.08571722f, 0.06627967f, 0.16897774f, 
    -0.17985409f, 0.16807851f, 0.08120719f, 0.08963633f, -0.42045602f, -0.12776583f, -0.22882503f, 0.14583611f, 
    -0.36416107f, 0.44172621f, 0.32721806f, 0.25444642f, -0.35061488f, -0.01187829f, 0.20375998f, 0.49091989f, 
    0.16284712f, 0.03009486f, -0.19218123f, -0.20013088f, -0.20849085f, -0.33926848f, 0.02110837f, -0.14084652f, 
    0.00908553f, 0.00696565f, -0.20502211f, 0.12110788f, -0.16271105f, -0.12337851f, -0.06208059f, -0.12955819f, 
    0.12743759f, -0.07902931f, 0.08929712f, -0.01665817f, -0.09630011f, -0.10931800f, -0.03996820f, 0.13439277f, 
    -0.41916034f, 0.00580395f, -0.06065492f, -0.17867339f, -0.17916548f, 0.27462628f, -0.33942810f, -0.66653025f, 
    0.10984319f, 0.12980574f, 0.22669932f, -0.23024347f, -0.00857163f, -0.37489921f, 0.14323017f, -0.08876856f, 
    -0.02220587f, 0.45243883f, -0.49416077f, -0.13164051f, -0.03497937f, 0.00470133f, -0.12193916f, 0.01107803f, 
    -0.06054439f, 0.35694557f, -0.00734264f, -0.18301782f, 0.21491988f, -0.00328696f, -0.29044244f, 0.14207393f, 
    0.06081951f, -0.19044119f, 0.23047611f, 0.19626787f, -0.17441532f, -0.16874203f, -0.05285853f, -0.17118397f, 
    -0.17175332f, 0.10578567f, -0.15566289f, 0.03310785f, -0.02556348f, 0.11728364f, -0.05137828f, 0.02674907f, 
    -0.31481397f, 0.03524953f, 0.07256670f, -0.06738153f, 0.22073464f, 0.29770589f, -0.23782898f, -0.28544489f, 
    0.00988403f, 0.02539317f, 0.28754261f, -0.08683474f, 0.30338818f, 0.12098564f, 0.04951811f, 0.48748073f, 
    -0.28053442f, 0.30221012f, -0.06516401f, -0.19380227f, -0.02497938f, 0.09904510f, -0.11336974f, -0.03641782f, 
    0.15150470f, 0.42516801f, -0.12803552f, -0.02889375f, 0.18257335f, -0.11987965f, -0.08490737f, -0.06222321f, 
    -0.31320211f, -0.02614556f, 0.03060880f, -0.01864795f, 0.21426301f, -0.07082611f, -0.09117518f, 0.12109412f, 
    0.01369156f, -0.25302076f, 0.41814467f, -0.06788923f, 0.33221754f, 0.25371730f, 0.17025054f, -0.25074047f, 
    -0.01143646f, 0.48044279f, -0.56734514f, -0.04696485f, -0.50611383f, 0.16667356f, -0.03133515f, 0.23305854f, 
    0.01827310f, 0.14709601f, -0.16935760f, -0.17958790f, -0.27741653f, 0.07462984f, -0.19474153f, -0.16326228f, 
    -0.29231673f, 0.15799482f, 0.23720142f, -0.12152150f, 0.01807940f, 0.35100543f, -0.45280153f, 0.13817213f, 
    -0.07839417f, -0.69253099f, -0.09897237f, -0.00967197f, -0.37731194f, 0.05604446f, -0.72592199f, 0.11682947f, 
    0.56296921f, 0.08109462f, -0.22125649f, -0.14647645f, 0.25614819f, -0.05735773f, -0.14778183f, -0.04879438f, 
    0.02259155f, 0.40764499f, 0.25053394f, -0.00277805f, 0.07549042f, 0.12941243f, -0.43343556f, -0.23418963f, 
    -0.45503381f, 0.30901405f, -0.34649989f, -0.21434966f, -0.11384961f, 0.34210750f, 0.10155486f, 0.13607657f, 
    -0.16107728f, -0.09530064f, 0.00516847f, 0.09342611f, -0.29734963f, -0.43041816f, 0.46022534f, 0.13294800f, 
    0.67202169f, -0.23416342f, 0.11487682f, 0.02915747f, -0.08489740f, 0.00448722f, -0.19741146f, -0.05980839f, 
    -0.01032807f, -0.01371764f, 0.29094696f, 0.18445097f, 0.13759929f, -0.19242714f, 0.04774917f, 0.05069589f, 
    0.32865199f, -0.67225957f, 0.04517563f, 0.10992891f, -0.08096127f, -0.11899468f, -0.01961021f, -0.14687710f, 
    0.15176685f, 0.21723944f, 0.03967661f, -0.16430783f, -0.16257460f, -0.54644054f, 0.38910797f, -0.19753189f, 
    -0.14589061f, -0.13741527f, -0.22331880f, -0.11250335f, 0.23552278f, 0.08917647f, 0.25276059f, 0.31972286f, 
    0.29694787f, -0.21384279f, -0.30645186f, -0.04365462f, -0.09611617f, 0.08475193f, -0.21973871f, -0.15000992f, 
    0.39681292f, -0.00894422f, -0.33081919f, -0.10138714f, -0.33683643f, -0.31501219f, 0.33641776f, 0.43048900f, 
    -0.21753511f, 0.29496661f, 0.23356962f, 0.24427381f, 0.01640755f, 0.31753507f, 0.10730772f, -0.09191934f, 
    0.10957987f, -0.00686526f, 0.13437648f, -0.04485168f, 0.34348032f, -0.14467297f, 0.29926449f, -0.06910583f, 
    -0.35424075f, 0.03220972f, 0.27663937f, 0.21275713f, -0.09819491f, -0.15603243f, -0.07358472f, -0.14854656f, 
    0.41725439f, -0.18481249f, 0.19353427f, -0.19047968f, -0.02509941f, 0.19285147f, -0.20272185f, -0.12054256f, 
    0.11542092f, 0.23312885f, -0.05125905f, 0.08744001f, -0.09743790f, -0.18413928f, -0.00098361f, -0.47876647f, 
    -0.31178954f, 0.18189915f, -0.01045247f, -0.24514586f, 0.36254558f, 0.02489484f, -0.30634561f, 0.08875870f, 
    0.20456575f, -0.19409910f, 0.37130228f, 0.14795038f, -0.36413002f, 0.26926365f, -0.01869990f, -0.08385153f, 
    0.23805320f, -0.18254480f, 0.03232044f, 0.08173370f, -0.15304306f, -0.22097155f, -0.09985459f, -0.05244720f, 
    -0.16903803f, -0.00952983f, -0.07374775f, -0.21498969f, -0.20424604f, 0.13959822f, -0.18549120f, -0.06206799f, 
    -0.28135353f, 0.38424814f, 0.20126987f, -0.15368296f, -0.16609988f, -0.04137829f, -0.13023801f, 0.50114262f, 
    -0.20864190f, -0.05965653f, 0.18824278f, -0.18210584f, -0.13162783f, 0.25865644f, -0.04886775f, 0.28099900f, 
    0.08258345f, 0.28844386f, -0.49155536f, 0.06084960f, 0.14711398f, 0.16261108f, -0.20991546f, -0.18172725f, 
    0.22497110f, 0.05499198f, -0.27844569f, -0.17826870f, 0.23050545f, 0.22610860f, -0.57895201f, 0.16760242f, 
    -0.26296023f, 0.31158513f, 0.00959626f, -0.22612691f, 0.20477529f, 0.28241682f, -0.35842443f, -0.08562356f, 
    0.12869044f, -0.34871903f, 0.08792929f, 0.19194587f, 0.10867815f, -0.22536659f, 0.23898402f, 0.26773819f, 
    0.42820951f, -0.25232905f, -0.24040210f, 0.15289699f, 0.34500793f, -0.02128816f, 0.21518965f, 0.02378573f, 
    0.12078967f, -0.13347444f, 0.28039142f, 0.17827730f, -0.08828682f, -0.22404769f, 0.10332052f, -0.12546755f, 
    0.05137502f, 0.51875401f, 0.09282672f, 0.02872540f, 0.12592153f, -0.06678846f, 0.14202717f, 0.25483418f, 
    0.24091381f, -0.35885403f, 0.31682923f, -0.13664672f, -0.25242183f, 0.17752224f, -0.49628296f, -0.10575339f, 
    -0.21230268f, 0.20915413f, -0.59306425f, 0.14359587f, -0.06660232f, -0.11084750f, -0.03201638f, 0.41013369f, 
    -0.23022604f, -0.11671574f, 0.04028159f, 0.01951307f, -0.09810557f, 0.41073766f, -0.41191915f, 0.32841149f, 
    -0.10420086f, -0.20071001f, 0.05042336f, 0.13210249f, 0.00038162f, -0.04045814f, -0.18452202f, -0.38693318f, 
    -0.01462874f, 0.36748007f, 0.17226161f, 0.02126482f, 0.02796928f, 0.56599838f, -0.14037460f, 0.11592242f, 
    0.32055250f, 0.14224537f, -0.18679306f, 0.19657901f, -0.18033087f, 0.26106653f, 0.34898958f, -0.09371921f, 
    0.25060010f, 0.12922211f, -0.37939215f, 0.09156621f, -0.14298531f, -0.26942185f, 0.03356029f, -0.35351434f, 
    -0.04072362f, 0.23139858f, -0.01250004f, 0.13944761f, 0.19180837f, 0.21420820f, -0.06981007f, -0.32648513f, 
    0.33219984f, -0.13323878f, -0.17143893f, 0.22749238f, 0.09909262f, -0.31429979f, 0.30697420f, -0.05008690f, 
    0.15875706f, -0.01305815f, -0.06636064f, -0.05612776f, -0.26714146f, 0.23888384f, 0.15961725f, -0.33484605f, 
    -0.27725130f, 0.19116449f, -0.20348662f, 0.12789598f, 0.01546179f, 0.34477180f, 0.62278736f, -0.13194376f, 
    -0.00125532f, 0.01215568f, -0.18896866f, 0.01652886f, 0.16131139f, 0.01527242f, 0.40018541f, -0.42208871f, 
    0.34049103f, 0.12199229f, -0.02701800f, 0.00435817f, -0.19414458f, 0.06111000f, 0.48273027f, -0.36279947f, 
    -0.56455624f, 0.16755128f, 0.04455806f, -0.14229254f, 0.57467377f, -0.03347425f, 0.28783059f, 0.15485637f, 
    -0.32176432f, -0.23652115f, 0.26639140f, 0.01863780f, -0.14239021f, 0.09953852f, 0.36647370f, 0.36056358f, 
    -0.39266855f, -0.01263110f, -0.02180464f, 0.13512142f, 0.33048746f, 0.16981404f, 0.14494318f, 0.21763366f, 
    0.23011008f, -0.48980290f, 0.19075142f, 0.15841469f, -0.23830102f, -0.11441018f, -0.49651176f, -0.15945604f, 
    0.44697192f, -0.17519493f, -0.32125700f, -0.04261568f, -0.22852160f, 0.19125660f, 0.15854949f, 0.26821387f, 
    -0.08840255f, -0.42692938f, -0.37368083f, 0.19092114f, -0.02960359f, -0.15714833f, 0.51723123f, 0.01783646f, 
    -0.03251593f, 0.11329544f, 0.13818868f, 0.14275670f, 0.16298242f, 0.32898340f, -0.25640175f, -0.29626518f, 
    0.26561952f, 0.05241226f, -0.19798221f, -0.11709280f, -0.27965984f, 0.28196597f, -0.08602309f, 0.24260937f, 
    0.32408366f, 0.19114348f, -0.36437044f, 0.08617546f, -0.28538609f, -0.21763012f, 0.22988331f, 0.33475929f, 
    -0.25478071f, 0.03918988f, 0.18862873f, -0.02522457f, 0.17581829f, -0.03171606f, 0.40595627f, -0.10992038f, 
    0.14748047f, -0.06488723f, -0.11311863f, 0.11869616f, -0.34711209f, 0.12419289f, 0.24041151f, 0.32645518f, 
    -0.34555003f, 0.01760314f, -0.21375644f, -0.18152678f, -0.29136327f, 0.03651430f, 0.62000161f, 0.09662709f, 
    0.58725429f, -0.24335502f, -0.03219374f, -0.19140814f, -0.20065959f, -0.04686948f, 0.22062814f, 0.12662345f, 
    0.21365616f, 0.15139838f, -0.02339391f, -0.18357207f, -0.14708836f, -0.01687818f, -0.32339418f, -0.20678969f, 
    0.26239762f, -0.14552031f, -0.22098939f, 0.05205330f, 0.42168450f, -0.32437730f, 0.35109982f, 0.26494896f, 
    -0.35693845f, -0.23548563f, 0.02547533f, 0.16047738f, 0.15326096f, -0.07454120f, 0.35013509f, -0.36620891f, 
    -0.03203847f, 0.12040908f, -0.36688811f, -0.23354737f, -0.03549562f, 0.05633200f, 0.21402074f, 0.29328018f, 
    0.20945416f, 0.05031383f, 0.07068583f, -0.23506065f, -0.13065761f, -0.36590749f, 0.27599347f, -0.33694461f, 
    0.41303745f, 0.06953359f, 0.13073125f, 0.12177739f, -0.10673048f, -0.22588126f, 0.36304626f, 0.16155665f, 
    -0.38779050f, 0.12504409f, 0.18072741f, 0.23347247f, -0.06210818f, -0.03959742f, 0.06187817f, -0.20522444f, 
    -0.12398331f, -0.13323686f, 0.42106885f, -0.01440712f, -0.06213718f, 0.23305842f, 0.26003534f, 0.12607177f, 
    -0.34738737f, -0.24863815f, 0.30516714f, 0.05759441f, -0.31175315f, -0.19014280f, 0.13678017f, 0.09105774f, 
    0.13238275f, 0.14205942f, -0.05491814f, 0.23257422f, -0.18404227f, -0.00179842f, 0.11350896f, -0.10327397f, 
    -0.38786173f, 0.10544093f, -0.10202705f, -0.11918677f, 0.37528846f, -0.06005173f, -0.70754886f, 0.59000748f, 
    -0.17299357f, -0.05339529f, -0.23095372f, 0.09252262f, -0.22804378f, -0.26075700f, 0.11541621f, 0.07637940f, 
    -0.10405709f, 0.08030341f, -0.21630436f, -0.09014878f, 0.11344478f, -0.18419242f, 0.08488954f, -0.13671446f, 
    -0.33156767f, 0.21191564f, -0.08525309f, 0.24873032f, 0.45970240f, -0.11631162f, 0.20120884f, 0.06437190f, 
    -0.05841257f, -0.15814120f, 0.26431039f, 0.13312304f, 0.29588157f, -0.00432580f, 0.07166466f, -0.06592172f, 
    -0.25003508f, -0.01378813f, 0.00191521f, -0.23645245f, -0.06562403f, 0.12473853f, -0.11605631f, 0.22652288f, 
    -0.41153371f, -0.00296019f, 0.22623590f, -0.00236455f, 0.31268305f, 0.32167086f, -0.10623205f, 0.36828509f, 
    -0.19771174f, -0.04538134f, -0.24144533f, 0.19542745f, -0.12233597f, -0.13621026f, -0.14404729f, -0.11641034f, 
    -0.13741818f, 0.12283099f, 0.02872574f, -0.24936858f, -0.24670076f, -0.18050757f, -0.05002064f, 0.11097392f, 
    -0.74021429f, -0.04422997f, -0.05924480f, 0.19679943f, 0.16269970f, -0.16805184f, 0.00546490f, 0.00481189f, 
    0.47584590f, 0.64524347f, 0.18281005f, 0.08547360f, 0.20400006f, -0.18856609f, -0.88349801f, -0.02025280f, 
    0.49761716f, -0.00334249f, 0.24347526f, -0.22128578f, -0.20570159f, -0.07136594f, 0.04537281f, -0.21571158f, 
    -0.10207277f, 0.26415107f, -0.03910334f, 0.05430558f, -0.08293920f, 0.29281420f, 0.30166617f, 0.11945481f, 
    -0.27395219f, -0.40696028f, 0.04934821f, -0.06059647f, 0.32422137f, 0.06507367f, -0.17590986f, 0.13223340f, 
    -0.01206715f, 0.25308618f, 0.18113035f, 0.17598599f, 0.02569892f, 0.17984800f, 0.43019950f, -0.24937941f, 
    0.38454089f, -0.08341967f, 0.32478014f, -0.20319949f, -0.18732169f, -0.04682837f, -0.21206136f, 0.18973532f, 
    -0.40937835f, 0.33063349f, 0.06185725f, -0.08567294f, 0.03054590f, 0.47586140f, 0.41861898f, -0.40709025f, 
    0.21828036f, 0.42958990f, -0.06118480f, 0.15504400f, 0.32499975f, 0.02919917f, -0.01337138f, -0.40540701f, 
    0.21640676f, -0.05216011f, -0.15512732f, 0.08902975f, -0.23590782f, 0.22448798f, 0.00297535f, 0.09235556f, 
    -0.10209502f, -0.14190707f, -0.24179949f, 0.04064497f, 0.01792918f, 0.11792861f, -0.16234191f, 0.21716845f, 
    -0.19929333f, -0.05443532f, 0.19842564f, 0.17994305f, -0.12922344f, -0.10677141f, -0.04482938f, -0.04350911f, 
    -0.21786153f, 0.29945862f, 0.38787693f, -0.13134359f, 0.14918974f, 0.16786347f, -0.38778031f, 0.23085943f, 
    0.15373668f, -0.33613658f, 0.36623028f, -0.22677661f, -0.23741233f, 0.09277842f, -0.30852219f, 0.22269835f, 
    -0.15713660f, -0.23287855f, -0.13075930f, 0.23688194f, 0.14896825f, -0.05508587f, 0.11726917f, -0.10901759f, 
    -0.03716045f, -0.11359587f, -0.15875110f, -0.13981980f, -0.16331795f, -0.10300031f, -0.13940096f, -0.00920281f, 
    -0.09237635f, 0.13170877f, -0.08890104f, 0.03711620f, -0.07921702f, -0.18324050f, -0.16408433f, 0.17156769f, 
    -0.14100358f, 0.05676590f, -0.01320755f, -0.13572624f, -0.24167408f, -0.02018561f, -0.10457504f, -0.14335394f, 
    0.41892445f, -0.18103129f, 0.38918951f, -0.14127329f, -0.28753495f, 0.22730461f, 0.09184778f, 0.11273367f, 
    0.08612514f, -0.31192732f, -0.16141734f, 0.03573164f, -0.40882099f, 0.00548577f, 0.44628128f, -0.11332069f, 
    0.05408046f, 0.32760412f, -0.41022670f, 0.05273953f, -0.39775312f, -0.22606629f, 0.18592082f, 0.37496951f, 
    -0.24426565f, 0.30277324f, 0.23390555f, 0.08577111f, 0.10533947f, -0.08548344f, -0.09418937f, -0.01496722f, 
    -0.34647250f, -0.25753221f, -0.01555522f, 0.16572753f, -0.15022580f, -0.07936886f, -0.16668151f, -0.64768249f, 
    -0.35289380f, -0.24711354f, 0.32668042f, -0.12849766f, 0.28673947f, 0.07387144f, 0.13392895f, 0.14495724f, 
    -0.06836712f, -0.10370208f, -0.06799474f, 0.00585820f, 0.48280972f, -0.06945902f, 0.20317999f, -0.12878546f, 
    0.35177913f, 0.03506652f, -0.49598274f, -0.02599069f, 0.08797204f, 0.01882089f, 0.00697147f, -0.20907384f, 
    0.36523834f, 0.43517715f, -0.28133589f, -0.23110141f, -0.13492517f, 0.04402697f, 0.15466172f, -0.00505712f, 
    -0.21076810f, -0.25062224f, -0.15341483f, -0.08066513f, 0.01226427f, 0.21425025f, -0.30041584f, 0.15169616f, 
    0.03926052f, -0.25317407f, -0.20243013f, 0.09564206f, -0.27261040f, -0.03692332f, -0.15911740f, 0.13909459f, 
    0.16254608f, -0.09238787f, -0.06327809f, -0.03423601f, -0.12047710f, -0.11981924f, -0.05227247f, -0.13980192f, 
    0.26807797f, 0.04755877f, 0.25627756f, 0.14876238f, 0.08849928f, -0.36293539f, 0.24702075f, 0.12579837f, 
    -0.32088006f, -0.34146008f, 0.29361990f, -0.05266878f, 0.18920566f, 0.22071141f, 0.55051023f, 0.01525980f, 
    -0.15456122f, 0.03347430f, -0.13796784f, 0.10164156f, 0.37310192f, 0.14934744f, 0.11420777f, -0.47588226f, 
    0.06123552f, 0.01712383f, -0.11601306f, 0.16218516f, -0.03231565f, 0.14315251f, -0.04838424f, -0.34067532f, 
    -0.26636252f, -0.05831809f, 0.48142251f, 0.13468918f, 0.31353188f, 0.23872048f, 0.05555721f, -0.24083956f, 
    -0.33363849f, 0.28789529f, 0.27647719f, -0.16264954f, -0.38586405f, -0.14602326f, 0.21944606f, 0.38396311f, 
    -0.20827720f, -0.06161614f, 0.39437437f, -0.17223120f, 0.05720764f, 0.12298337f, 0.31568778f, -0.02077419f, 
    -0.41415429f, -0.31522200f, 0.11206231f, -0.03006796f, 0.22682332f, -0.05305037f, 0.55699480f, 0.40490249f, 
    0.23220199f, 0.17274031f, 0.02797578f, 0.21769047f, 0.34185162f, -0.29988176f, 0.21722874f, -0.11728171f, 
    -0.09934997f, 0.02686458f, 0.10118858f, 0.19034660f, 0.20558956f, 0.05726605f, -0.40971538f, 0.45682797f, 
    0.01249763f, -0.24422058f, -0.02687532f, -0.20632994f, -0.16010854f, -0.11658645f, -0.01286528f, -0.12882024f, 
    0.18639374f, -0.01203158f, -0.13022947f, -0.14915547f, 0.03272132f, -0.16206448f, -0.15671113f, 0.01274085f, 
    -0.01316461f, 0.50093406f, -0.41945067f, 0.02860055f, 0.35931477f, -0.06102318f, 0.30376261f, 0.20470282f, 
    0.01496558f, -0.12308352f, -0.41958788f, -0.18483113f, 0.22182921f, 0.15073502f, -0.09086561f, 0.35462692f, 
    0.45064482f, 0.19988243f, -0.10078973f, -0.20383951f, 0.11897764f, 0.15172133f, 0.03012006f, -0.10522363f, 
    0.02604503f, -0.09109754f, 0.07549497f, -0.06507555f, -0.07939672f, -0.33693129f, -0.26263845f, -0.06985827f, 
    -0.37744504f, 0.71420854f, -0.00018135f, 0.01655471f, -1.34944797f, -0.05548447f, 0.22380427f, -0.07464608f, 
    0.24944606f, 0.05258011f, 0.30333084f, -0.01729476f, 0.27418256f, -0.68207443f, -0.90986389f, 0.43018740f, 
    -0.10265505f, 0.34326601f, -0.49594018f, -0.08746561f, 0.44002229f, -0.12715183f, 0.11167402f, -0.14040913f, 
    0.02270993f, 0.33380941f, -0.16671655f, 0.17240401f, 0.24306870f, 0.33462009f, 0.09525578f, 0.16348687f, 
    -0.20863630f, 0.26980689f, 0.11199475f, 0.10861703f, 0.21687396f, -0.00382877f, 0.20408721f, -0.24108253f, 
    -0.03207302f, 0.29630834f, -0.23756810f, -0.19826502f, 0.16375040f, 0.39505547f, 0.03119088f, -0.16043782f, 
    -0.39878851f, 0.24133705f, 0.35348424f, 0.09673519f, -0.02913312f, -0.10046150f, 0.05768884f, 0.42915836f, 
    -0.21177782f, -0.15956895f, 0.29064244f, -0.04459314f, 0.00027813f, 0.02413934f, 0.49095422f, 0.20461592f, 
    -0.33545107f, 0.26805618f, 0.09838286f, 0.20306695f, 0.37800503f, -0.09927455f, 0.18939464f, 0.28259307f, 
    0.16881189f, -0.28799981f, 0.22948170f, 0.11101960f, -0.05125930f, -0.22784390f, -0.30466780f, 0.11074430f, 
    -0.05830887f, 0.09726539f, -0.04362905f, -0.15541530f, -0.19760583f, -0.20107420f, 0.22549716f, 0.02502218f, 
    -0.20630048f, -0.31193060f, 0.00419426f, 0.07373127f, 0.26457003f, 0.18331942f, 0.02475222f, 0.38104379f, 
    -0.54319102f, 0.00820449f, 0.36403626f, -0.00953506f, 0.22886468f, 0.18557562f, 0.32963580f, 0.21644156f, 
    -0.40648279f, -0.09961417f, 0.14436299f, 0.09319253f, -0.24959119f, 0.00909629f, 0.45191059f, -0.17885263f, 
    0.28196269f, -0.07311299f, 0.14417866f, -0.03366882f, 0.52519262f, -0.16421497f, 0.14616008f, -0.09459508f, 
    -0.25695497f, -0.00962625f, 0.10381558f, 0.21582574f, 0.19351584f, 0.00787334f, -0.27264410f, -0.15644461f, 
    -0.03294065f, -0.12953851f, 0.12830319f, 0.00667094f, -0.18870270f, 0.25312772f, 0.04757302f, 0.11728209f, 
    0.10596240f, -0.18661168f, 0.19342574f, -0.23315603f, -0.59226823f, -0.10806087f, 0.19095187f, 0.35247099f, 
    0.14909227f, -0.39549401f, -0.03657825f, 0.18104130f, 0.11761504f, 0.10998565f, -0.12068641f, 0.20854311f, 
    -0.55207974f, 0.26922488f, -0.08429370f, -0.02451280f, 0.01644834f, 0.43803686f, -0.04743433f, 0.19965334f, 
    -0.20923056f, 0.26677138f, -0.25758043f, 0.08458640f, 0.14115149f, 0.19170490f, -0.21852715f, -0.17629601f, 
    0.20923650f, -0.37862131f, 0.30123234f, -0.05364332f, 0.06362442f, 0.01044676f, -0.17792119f, 0.14528504f, 
    0.19982043f, 0.16297072f, 0.52729553f, 0.17100924f, -0.01352371f, -0.18911700f, -0.11716895f, 0.19272104f, 
    0.09527945f, -0.19332270f, 0.35331687f, 0.08035800f, -0.07848646f, -0.02974678f, 0.13143891f, 0.70824128f, 
    0.10636809f, 0.13103399f, -0.37732568f, 0.01483019f, 0.24196376f, -0.27924111f, 0.30463806f, 0.22141299f, 
    -0.19000001f, 0.09827431f, 0.10198167f, -0.13530791f, -0.17299096f, -0.03430282f, 0.18122350f, -0.14919703f, 
    0.14197142f, -0.00186599f, 0.18132329f, 0.10164092f, -0.43157375f, 0.41124251f, 0.04904764f, -0.19074608f, 
    0.02436204f, 0.16941005f, -0.33400553f, 0.17040102f, -0.21654895f, -0.00102490f, 0.37659347f, -0.10900435f, 
    -0.28770420f, -0.52873856f, -0.13474391f, -0.18695176f, -0.08140249f, 0.22597659f, -0.22945271f, -0.54268849f, 
    -0.20767383f, 0.34890106f, 0.02456662f, -0.12546709f, 0.13968422f, -0.16034496f, 0.39093891f, -0.38724217f, 
    0.08622629f, 0.23886846f, 0.15254724f, -0.01890222f, -0.08577818f, 0.24829823f, 0.29244605f, -0.19002031f, 
    0.03090471f, -0.18068951f, 0.12088238f, -0.03759135f, -0.14876437f, -0.29477888f, -0.24001814f, -0.18961629f, 
    0.16254520f, -0.12769637f, -0.02405261f, 0.23474534f, 0.22146617f, 0.16905509f, 0.29342496f, -0.28306147f, 
    0.37508988f, -0.22240964f, -0.09838378f, 0.04850258f, -0.14031930f, -0.24800339f, 0.18305677f, -0.30330053f, 
    -0.06885537f, 0.26358014f, -0.50567955f, -0.01119993f, -0.35642985f, -0.01145567f, 0.06321405f, 0.30133602f, 
    -0.42038113f, 0.19046843f, 0.14203487f, -0.05081280f, 0.10828862f, -0.03869847f, 0.32407191f, -0.40408844f, 
    -0.01776245f, 0.31133381f, -0.50376070f, -0.11276177f, 0.20216525f, -0.14814077f, 0.32607570f, 0.24423607f, 
    -0.13446054f, 0.24258049f, -0.27507159f, -0.11758972f, 0.34515783f, 0.25268036f, 0.00370456f, -0.04052912f, 
    0.01973141f, 0.05081182f, -0.36672938f, 0.18789858f, -0.05162335f, 0.26470441f, -0.17303769f, 0.18663311f, 
    0.10160311f, 0.22912413f, -0.33717290f, 0.21472646f, -0.05840622f, -0.22279564f, -0.16353245f, -0.29910952f, 
    -0.28904960f, 0.11470996f, -0.45828566f, -0.01540378f, 0.06117399f, 0.09040804f, 0.52615815f, 0.01836997f, 
    -0.14171059f, -0.08568842f, -0.14539002f, 0.10786738f, 0.23482171f, -0.33340895f, 0.45793042f, -0.47792253f, 
    0.08784302f, -0.07765403f, 0.14352259f, 0.07372823f, 0.33969238f, 0.00783983f, -0.05288420f, 0.24041605f, 
    -0.34932321f, -0.44187027f, 0.39424339f, 0.05044578f, 0.19181259f, -0.08677340f, -0.09042132f, -0.06231436f, 
    0.45614681f, 0.02208864f, -0.16472128f, 0.11671384f, 0.15935774f, -0.01973583f, -0.14092815f, -0.21211603f, 
    0.42995328f, -0.01366658f, -0.17739439f, -0.09850269f, 0.19433381f, -0.08569131f, -0.22532202f, -0.15260638f, 
    -0.69498724f, 0.13915381f, 0.06361946f, -0.12029666f, -0.06962328f, 0.02046329f, 0.18897960f, -0.18484716f, 
    0.30349830f, 0.02321010f, 0.29808766f, 0.06560656f, 0.18861715f, 0.08515727f, -0.09873777f, -0.37327701f, 
    -0.09922387f, 0.16170558f, 0.08597066f, 0.11209255f, 0.05460674f, -0.11088847f, 0.44090098f, 0.36064336f, 
    -0.26416975f, -0.26807165f, 0.23774076f, 0.22169511f, -0.17061876f, -0.34442437f, 0.46263790f, 0.08272903f, 
    -0.31451413f, -0.04827946f, -0.49325371f, -0.20104150f, 0.44129831f, 0.02951095f, 0.25036508f, 0.29083514f, 
    0.07555286f, -0.05288858f, -0.13915436f, -0.04384313f, 0.31717366f, 0.27188063f, -0.03202924f, 0.21162993f, 
    0.26319724f, 0.04439416f, -0.38431871f, -0.19423607f, 0.07291150f, 0.06786482f, 0.24291527f, -0.40426874f, 
    0.31099883f, 0.12478001f, -0.05581604f, 0.04920121f, -0.03335506f, 0.00661785f, -0.15331359f, -0.69900644f, 
    -0.18059810f, -0.33854279f, 0.09253259f, 0.14820385f, 0.01933078f, 0.25145257f, 0.26604572f, -0.08213452f, 
    0.31208581f, -0.30793816f, -0.32345650f, 0.14810543f, 0.25093427f, -0.01743193f, 0.48290527f, -0.04445492f, 
    -0.37935272f, 0.25555837f, -0.03473195f, 0.18132764f, 0.02738754f, 0.02202163f, 0.20172766f, 0.35269845f, 
    0.02918838f, -0.05689206f, -0.09273513f, -0.12476137f, 0.11532090f, 0.37327406f, 0.03773321f, 0.36936897f, 
    -0.07984514f, 0.01005688f, 0.33835176f, -0.00693191f, -0.17746896f, 0.19742993f, -0.12725140f, -0.23756924f, 
    -0.18470471f, 0.42936638f, -0.32447752f, -0.07522893f, 0.22758366f, 0.28848538f, 0.54227865f, 0.13681188f, 
    -0.28414264f, -0.09721459f, 0.32608226f, 0.19920847f, 0.14583658f, 0.02365838f, -0.31742170f, 0.20421705f, 
    -0.40257064f, -0.70496964f, -0.52050167f, -0.01863183f, -0.45103231f, 0.40147397f, -0.45614111f, -0.16994409f, 
    0.45575693f, -0.31853998f, 0.07041255f, -0.21914984f, 0.24397689f, 0.14872970f, 0.15643696f, -0.33418208f, 
    0.24483389f, -0.13326317f, -0.21851994f, -0.12215745f, -0.29665047f, 0.19431730f, -0.06680113f, -0.06412797f, 
    -0.14369501f, -0.24947135f, 0.07498385f, 0.17039798f, 0.01643308f, -0.12907079f, 0.12921792f, 0.24068184f, 
    -0.21369272f, -0.09321460f, 0.15977193f, -0.03303281f, 0.38255739f, 0.15831719f, 0.06632719f, -0.12018734f, 
    0.16482674f, 0.41711256f, -0.16928960f, 0.17293629f, 0.24001750f, -0.07426102f, -0.05353176f, -0.01438040f, 
    0.28370264f, -0.41461378f, 0.29580373f, -0.11016501f, 0.15711614f, -0.25889313f, -0.27814284f, 0.51644492f, 
    0.10553909f, 0.15399891f, -0.06098921f, 0.05162784f, 0.10003593f, -0.15251556f, -0.24559149f, 0.07405487f, 
    -0.12200625f, -0.21668857f, -0.01077269f, -0.13604361f, 0.17916536f, -0.21286362f, 0.11652053f, 0.05740899f, 
    -0.26504183f, -0.35734951f, 0.31120208f, -0.03209478f, 0.22854707f, -0.20493186f, 0.33709332f, -0.03836361f, 
    0.26670566f, 0.03094115f, -0.28657106f, 0.18089652f, 0.43779796f, 0.32877833f, 0.41265887f, -0.15191804f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.24172089f, 0.14693600f, 0.10349856f, 0.18400879f, 0.39958477f, 0.14720784f, -0.02076516f, -0.27688390f, 
    0.00346545f, 0.00824390f, 0.15282670f, 0.45763600f, -0.07811233f, 0.16995184f, -0.21713139f, 0.35427806f, 
    -0.12307912f, -0.20916335f, -0.29524264f, -0.11897146f, 0.09760254f, 0.24931546f, 0.26765639f, 0.09047733f, 
    0.02229577f, 0.06199991f, -0.13416901f, -0.15640759f, -0.29286584f, -0.27295855f, 0.33308718f, 0.11435692f, 
    -0.25660220f, 0.47875720f, 0.41835597f, 0.06150965f, 0.14282501f, -0.09351861f, 0.39118138f, 0.39495838f, 
    -0.12255657f, -0.09205511f, 0.29887345f, 0.20327842f, -0.09055158f, 0.36314103f, -0.23611332f, 0.07377192f, 
    -0.20937702f, 0.19524190f, 0.40573272f, -0.18837072f, 0.17151767f, 0.20581067f, -0.06795119f, 0.45702749f, 
    0.07625669f, 0.25407085f, 0.05959422f, 0.40586615f, 0.30154625f, 0.21188048f, 0.29354930f, 0.40187791f, 
    0.41916838f, 0.09752750f, -0.14887051f, -0.23643334f, -0.23798743f, -0.44133589f, 0.03292228f, -0.43002099f, 
    -0.16205847f, -0.08844858f, 0.16014488f, -0.29229206f, -0.00986006f, -0.19031794f, 0.45226845f, -0.16034582f, 
    -0.02794942f, 0.34315583f, 0.16110596f, 0.02861705f, 0.36356956f, 0.21764106f, 0.31038728f, 0.27282834f, 
    0.08056311f, 0.08842405f, 0.27468246f, 0.41340104f, -0.48345855f, 0.14661582f, -0.26939148f, 0.03277736f, 
    0.11290059f, -0.17258911f, 0.22001471f, -0.01848035f, 0.28847969f, 0.00390536f, -0.32054517f, -0.03421833f, 
    0.37081462f, 0.26458243f, 0.05954100f, 0.28961504f, 0.42555779f, 0.25605890f, 0.29864359f, 0.03769418f, 
    0.38813481f, 0.13045076f, 0.34445539f, -0.36988324f, 0.37800130f, 0.32445732f, 0.09247606f, -0.19709936f, 
    -0.09871302f, -0.12165862f, 0.08406406f, 0.24730627f, 0.04587388f, -0.00710140f, -0.18416892f, -0.11481655f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.16305429f, -0.09348680f, 0.12929285f, -0.04564222f, 0.21588182f, -0.06907339f, -0.00193582f, 0.10777376f, 
    0.06646452f, 0.67669970f, 0.13703188f, 0.17067760f, -0.10502356f, 0.05979923f, -0.16376624f, 0.24544518f, 
    0.11220514f, 0.02337339f, -0.19179702f, -0.52747321f, -0.52464616f, 0.14711550f, -0.02024799f, 0.00337023f, 
    0.40594333f, -0.33502352f, -0.03901689f, 0.04782028f, -0.39234850f, -0.02814172f, 0.07466360f, 0.13546331f, 
    0.00562415f, 0.37853971f, 0.02111830f, 0.56700981f, -0.05553932f, 0.15040280f, -0.10788742f, -0.02271570f, 
    0.27235746f, -0.08030258f, 0.02388012f, -0.07813530f, 0.17090474f, 0.12910795f, 0.13916056f, 0.12683389f, 
    0.01075332f, 0.03348532f, 0.02253184f, 0.04943340f, 0.10292719f, 0.12442040f, 0.30890900f, 0.35214558f, 
    0.17573865f, 0.17332114f, 0.34979528f, -0.03712452f, -0.21241248f, 0.09277795f, -0.16804443f, 0.21450217f, 
    -0.16690303f, -0.02014442f, -0.03575983f, 0.07696992f, -0.07184691f, -0.19658595f, -0.05937211f, -0.02726468f, 
    -0.19669102f, 0.02375032f, 0.10469472f, 0.27737266f, -0.03949345f, -0.05553219f, 0.10953761f, -0.16260809f, 
    -0.16567570f, -0.24262838f, 0.22592245f, 0.02333396f, -0.30158231f, 0.00602984f, 0.04728851f, 0.05207977f, 
    -0.21132813f, -0.06077107f, -0.00320186f, 0.19765633f, 0.27156761f, -0.15489592f, -0.35143730f, -0.03085587f, 
    0.04800839f, -0.05998237f, -0.03394493f, -0.63949597f, 0.55586565f, -0.09655704f, 0.32628220f, -0.09925584f, 
    -0.03090909f, 0.07470595f, 0.17012332f, 0.15998085f, 0.14585753f, -0.23470837f, -0.17812909f, -0.09861554f, 
    -0.00337635f, -0.03375688f, -0.12375224f, -0.00586000f, 0.10988566f, -0.07828741f, 0.02077075f, 0.07941651f, 
    0.02604245f, -0.36170584f, 0.21042594f, 0.18227154f, -0.37586993f, 0.18609864f, -0.06709573f, -0.84726626f, 
    0.10207118f, 0.00316921f, 0.21787275f, 0.09733641f, -0.02714945f, -0.02745336f, -0.00363205f, 0.10099877f, 
    0.16186583f, 0.36354774f, -0.35772747f, -0.34937587f, 0.13642715f, 0.10476193f, 0.03980399f, -0.36290169f, 
    0.16355149f, -0.03070913f, -0.07438543f, -0.16292569f, 0.00156652f, -0.22273982f, 0.03393970f, -0.06680995f, 
    0.10205691f, -0.18042290f, -0.03854313f, 0.10032307f, 0.10067259f, 0.11747967f, -0.17907305f, 0.13929015f, 
    -0.01737631f, -0.00022551f, -0.04618214f, -0.01843591f, 0.15730940f, -0.28806859f, -0.11380564f, -0.05085007f, 
    0.31551585f, -0.01395058f, -0.01108897f, 0.11730800f, 0.23625068f, -0.04759171f, -0.01289445f, -0.10238254f, 
    -0.00120844f, -0.10733295f, 0.08749574f, -0.28123811f, -0.02297339f, 0.20192651f, 0.31112006f, -0.08888719f, 
    -0.02638875f, -0.17102414f, -0.09328453f, -0.10531034f, 0.00167942f, -0.19368277f, -0.26436013f, -0.00259693f, 
    0.02713164f, 0.03677909f, 0.11718755f, -0.09692072f, -0.06914953f, 0.08614565f, -0.13820082f, 0.16047981f, 
    -0.09866090f, 0.12240584f, -0.07245951f, 0.18768230f, -0.10791811f, 0.03070804f, -0.16545224f, -0.33919719f, 
    -0.07576447f, 0.14761508f, 0.01243606f, 0.02102670f, 0.01308423f, 0.09253568f, -0.01581231f, -0.02436403f, 
    0.16712312f, 0.02412028f, 0.11915256f, -0.13797565f, -0.12774990f, -0.00930821f, 0.09416703f, 0.04464873f, 
    0.13843927f, -0.13159609f, 0.05223876f, 0.11050586f, -0.14210343f, -0.05209979f, -0.07586232f, 0.10925787f, 
    0.01883726f, -0.22576959f, 0.03092954f, -0.06731913f, 0.13743334f, -0.55617732f, -0.04114605f, -0.04422665f, 
    0.05564494f, 0.06165054f, 0.08403262f, 0.12250738f, 0.04431254f, 0.15658794f, -0.01058451f, 0.25642544f, 
    0.01344754f, 0.03925641f, 0.12329400f, 0.15526679f, 0.14842816f, 0.04684133f, -0.10060384f, 0.34048480f, 
    -0.08220939f, -0.04905605f, 0.04321859f, -0.04796900f, -0.04589007f, -0.04365997f, -0.07853096f, 0.04981215f, 
    -0.05130987f, 0.04336531f, -0.03540708f, -0.09593339f, 0.01431449f, 0.04904189f, 0.01116855f, -0.04239513f, 
    0.00444227f, 0.00238564f, -0.00583323f, -0.05855667f, -0.00857806f, -0.11797701f, -0.07086854f, -0.07682352f, 
    0.04959184f, -0.08507822f, -0.04486993f, -0.12301285f, -0.09314498f, -0.08050121f, 0.08350825f, 0.03339793f, 
    -0.07053649f, 0.05316914f, 0.05421457f, -0.02113884f, 0.05274212f, -0.04285741f, -0.05248026f, -0.08524671f, 
    -0.01776862f, 0.05055711f, -0.09872932f, 0.00845838f, 0.00243164f, -0.00214450f, -0.03385821f, -0.07844108f, 
    0.01012990f, -0.10826462f, 0.05035652f, -0.09971039f, 0.02940309f, -0.07285456f, -0.12203083f, -0.05608354f, 
    0.00797080f, 0.02566582f, -0.02383923f, 0.04660887f, -0.03654961f, -0.10133974f, -0.04195151f, 0.00488965f, 
    -0.08942232f, 0.03294811f, -0.07272851f, -0.05084847f, 0.08751813f, -0.03840950f, -0.04100766f, 0.02757548f, 
    -0.00963432f, -0.04280923f, 0.06163466f, -0.00145420f, -0.05352181f, 0.03857089f, 0.04717201f, -0.03088931f, 
    0.03837685f, 0.01032360f, -0.09188970f, -0.05434761f, 0.05104074f, -0.04535011f, -0.06798543f, 0.02935060f, 
    -0.01269326f, -0.06540585f, 0.03031443f, 0.01300392f, 0.01226546f, -0.06585347f, -0.11923932f, -0.08633249f, 
    -0.07758234f, 0.01213490f, -0.05980938f, 0.02876649f, -0.04723931f, -0.00995803f, 0.00529859f, -0.06796099f, 
    -0.02910431f, -0.09309080f, 0.04458327f, -0.10001151f, -0.00942303f, -0.01130892f, -0.06007453f, -0.07269340f, 
    -0.08111802f, -0.09953052f, -0.02321273f, 0.01876923f, -0.03975176f, -0.08826963f, -0.03667427f, -0.04194699f, 
    0.07083832f, -0.03156937f, 0.07461780f, 0.02598384f, -0.03628856f, -0.04601758f, 0.05179901f, -0.04276791f, 
    -0.42958584f, -0.06781387f, 0.07787205f, 0.05746205f, 0.09499510f, -0.06957714f, 0.02479805f, -0.01014301f, 
    -0.07089709f, -0.05407225f, -0.29370877f, -0.55297083f, 0.50870764f, 0.39487380f, -0.15872765f, -0.41033372f, 
    0.01772886f, 0.00574715f, 0.19774236f, 0.00066419f, -0.02974835f, 0.06654029f, -0.13295838f, 0.02291837f, 
    -0.24556446f, -0.02545845f, 0.06328720f, -0.06273418f, 0.20993717f, 0.04894869f, 0.12246082f, 0.20372903f, 
    0.12263254f, -0.30923626f, -0.29027736f, -0.17733885f, 0.11253940f, 0.17543545f, -0.39603952f, -0.39902407f, 
    0.12338021f, -0.07224320f, 0.06780006f, 0.03956398f, -0.16869374f, -0.60123682f, 0.02359953f, 0.05499936f, 
    0.20642906f, -0.24850939f, -0.60146409f, 0.38177478f, -0.16329855f, -0.06436205f, -0.04637603f, -0.00572808f, 
    0.01045352f, -0.02054478f, 0.10285224f, -0.01118317f, -0.14547791f, -0.38321447f, -0.09536563f, -0.09822779f, 
    -0.20417584f, -0.00197041f, 0.07229267f, 0.16404973f, 0.00830264f, 0.23433302f, 0.26803085f, 0.16958587f, 
    0.47618961f, 0.06288474f, -0.12109690f, 0.01754539f, 0.07268727f, -0.06275369f, 0.05592814f, -0.02522793f, 
    -0.27833468f, 0.02560704f, 0.10128770f, -0.08478101f, -0.10352100f, 0.02653811f, -0.41357544f, -0.35132009f, 
    -0.21086882f, -0.01296442f, 0.09924325f, -0.56241131f, -0.12581013f, 0.09703156f, 0.17662254f, 0.03847761f, 
    -0.04446758f, -0.19029650f, 0.05700428f, -0.16740362f, -0.15553883f, 0.23278686f, -0.07035078f, 0.06392001f, 
    -0.07891173f, 0.17016418f, -0.08961148f, -0.50821149f, -0.48771939f, -0.00746792f, 0.13164631f, 0.09754124f, 
    -0.24612625f, 0.02467239f, -0.21921560f, -0.12321658f, -0.39292911f, 0.08534884f, 0.00418562f, -0.14819407f, 
    0.09364481f, 0.36405897f, 0.32434425f, 0.07120553f, -0.06956508f, -0.50241137f, -0.02878469f, 0.04372579f, 
    -0.36035717f, -0.01581548f, -0.01005342f, 0.20387687f, 0.33143756f, 0.00649763f, 0.01292086f, 0.02772307f, 
    -0.00398773f, -0.25034311f, -0.09366214f, 0.27444258f, -0.36057377f, -0.21810879f, -0.05379066f, 0.11717954f, 
    -0.17292134f, -0.18705381f, -0.08905417f, -0.15723577f, -0.06787643f, 0.08255822f, -0.37293264f, 0.01581683f, 
    0.12328592f, -0.00660300f, -0.07242087f, 0.02995781f, 0.05559846f, -0.11898924f, 0.09677630f, -0.42003447f, 
    -0.01193235f, 0.18713059f, 0.12256633f, -0.09181592f, -0.05050427f, -0.22293456f, 0.22625065f, 0.14669420f, 
    0.07218269f, -0.01961201f, -0.08462140f, 0.10151017f, 0.06472085f, 0.07798732f, 0.02990140f, 0.03597565f, 
    -0.10845833f, 0.18321045f, 0.11974393f, 0.06047604f, 0.21627732f, 0.08241338f, 0.03743597f, 0.04124587f, 
    0.18406059f, -0.03111829f, -0.05701721f, -0.05529207f, 0.16932651f, 0.04309829f, 0.11976163f, 0.13720594f, 
    0.12766220f, -0.02703441f, -0.01916477f, -0.14577964f, -0.08510898f, -0.36268872f, 0.09109590f, -0.22107434f, 
    -0.00571509f, 0.23503533f, 0.08388206f, 0.01235563f, -0.02737890f, -0.02033301f, -0.04290881f, -0.21837579f, 
    0.19398385f, 0.11936122f, 0.22415617f, -0.03018107f, 0.06704558f, 0.26503313f, 0.37944728f, -0.02373549f, 
    0.31708771f, 0.00006963f, 0.08838817f, 0.19689369f, -0.14623396f, 0.00617285f, -0.02484082f, -0.02229695f, 
    0.08216880f, -0.06742529f, 0.10859969f, 0.37986392f, 0.08735859f, 0.09094460f, -0.05658372f, 0.00779337f, 
    0.14371035f, 0.22109516f, 0.05666982f, 0.09967492f, 0.14868191f, 0.08273836f, 0.00042291f, -0.00289475f, 
    0.18160073f, 0.05130903f, 0.06811881f, 0.01183065f, 0.11381600f, -0.00100775f, 0.07846216f, -0.09618389f, 
    -0.09793398f, -0.05785514f, -0.32069713f, 0.27396342f, -0.15387017f, 0.05712262f, 0.09573969f, -0.19068462f, 
    0.28147042f, 0.07886840f, -0.06410717f, 0.07179223f, -0.05380644f, -0.09933427f, 0.05280940f, 0.03175963f, 
    -0.10885949f, 0.17476986f, 0.28191277f, 0.05276485f, -0.33343479f, -0.44292414f, 0.03329090f, -0.07412721f, 
    -0.18931931f, 0.16536553f, -0.05224265f, 0.00360693f, -0.13452064f, 0.06470414f, -0.01432664f, 0.02540971f, 
    -0.19771571f, -0.05270977f, -0.01935843f, -0.05845090f, -0.24596222f, -0.07551146f, 0.02515492f, -0.46110207f, 
    -0.29968712f, 0.23998304f, 0.01027135f, -0.20481107f, 0.02273738f, -0.03110683f, 0.24367447f, -0.06856058f, 
    -0.05241521f, 0.08656228f, -0.07195068f, -0.06958769f, -0.06037509f, 0.13691244f, -0.01212721f, 0.09983242f, 
    -0.14654750f, -0.11774328f, 0.01261689f, -0.01307488f, 0.04897191f, 0.24153221f, 0.02897207f, 0.15651472f, 
    -0.17604281f, 0.09422529f, 0.20284469f, -0.05933017f, 0.40636322f, 0.05378944f, 0.05783159f, 0.11368239f, 
    0.10966440f, -0.07266803f, 0.07736325f, -0.13171233f, 0.07999982f, -0.39402151f, -0.19976029f, -0.21022430f, 
    -0.16186351f, 0.04401029f, 0.07434588f, -0.15129328f, -0.02175628f, 0.07941511f, -0.09771518f, -0.05157102f, 
    -0.06502152f, 0.01545264f, 0.06524936f, -0.08898798f, 0.29621822f, 0.06956374f, 0.22530064f, 0.27522969f, 
    0.15768991f, -0.06581669f, 0.16759320f, -0.02821344f, -0.06600188f, 0.14548159f, -0.06229459f, 0.09541085f, 
    0.02753546f, 0.19073977f, 0.03392430f, 0.32615814f, -0.01626559f, -0.01764662f, -0.27315786f, 0.06343347f, 
    0.11598892f, 0.00497766f, -0.11532582f, -0.11531021f, 0.13785022f, 0.33059898f, 0.14624813f, -0.19438300f, 
    0.25659752f, 0.05273622f, -0.06989840f, 0.02481130f, 0.33220437f, 0.08729599f, -0.05302025f, 0.03270903f, 
    0.01406348f, -0.19821210f, -0.50316465f, 0.12445364f, -0.05830245f, 0.12673207f, 0.07524468f, 0.01689311f, 
    0.13035844f, 0.34915450f, 0.00009663f, -0.10484038f, 0.01363238f, -0.12765533f, -0.00212318f, 0.03514330f, 
    0.15935040f, -0.18934222f, 0.33004788f, -0.29712939f, 0.04060385f, -0.22728503f, 0.12856315f, -0.08035310f, 
    -0.16705842f, 0.07716659f, 0.10516657f, -0.06594107f, -0.01069083f, 0.04535269f, -0.37222829f, -0.03515527f, 
    -0.02367140f, -0.10954000f, 0.03728119f, -0.04870033f, -0.29758388f, -0.01118602f, 0.02808186f, -0.47928083f, 
    -0.24865083f, -0.25502339f, 0.18923523f, 0.13369066f, 0.04493198f, 0.33869663f, 0.19411963f, 0.00620698f, 
    -0.35663295f, 0.03720443f, -0.01843761f, 0.04588252f, -0.46399951f, 0.19068272f, -0.05262977f, 0.03649743f, 
    0.10016976f, 0.03912185f, -0.01540053f, 0.11373070f, 0.16816944f, 0.06527442f, -0.14126016f, 0.14194523f, 
    -0.02714121f, 0.09840178f, 0.25020146f, 0.19475304f, 0.39963257f, 0.01101080f, 0.20135733f, 0.18429349f, 
    -0.04743068f, 0.02182967f, 0.03540928f, -0.00544504f, 0.08793758f, -0.68263173f, -0.03871883f, 0.05629505f, 
    0.00727464f, -0.12711217f, -0.07183960f, -0.42612284f, 0.02601232f, -0.02194089f, 0.01914527f, -0.33615881f, 
    0.39895228f, 0.15163977f, 0.02892903f, 0.06941035f, 0.13722602f, 0.12968388f, 0.05819800f, 0.09051079f, 
    0.05101909f, -0.04853803f, 0.03764031f, -0.04899256f, -0.37901527f, 0.04358216f, 0.00960355f, 0.03594006f, 
    -0.10995938f, 0.03084825f, 0.12316950f, 0.33603173f, -0.00827818f, 0.17194749f, -0.36816743f, -0.08300630f, 
    0.23618604f, 0.10625518f, -0.07866330f, 0.02317297f, 0.14868650f, -0.07088771f, 0.12719862f, -0.11773722f, 
    0.11915544f, 0.08971791f, -0.03353444f, -0.17426530f, 0.03334299f, 0.14483579f, -0.02494901f, 0.03141265f, 
    -0.07247345f, -0.01122272f, -0.85273319f, 0.12057442f, 0.20079523f, -0.17901148f, -0.00939664f, 0.29696929f, 
    0.00620552f, 0.00019305f, 0.06545543f, 0.05127759f, 0.03216786f, 0.03507365f, -0.03695346f, 0.07186469f, 
    -0.07448588f, -0.05776107f, 0.04321019f, -0.05189362f, -0.07637061f, 0.07614769f, 0.00035040f, 0.02498217f, 
    -0.05434618f, -0.04712839f, -0.04387278f, -0.05140957f, -0.05858245f, 0.05465717f, -0.08566655f, -0.03079327f, 
    0.05587849f, -0.00171548f, 0.06358395f, 0.01896111f, -0.06719562f, 0.04420741f, -0.01428672f, -0.00013804f, 
    -0.02784319f, -0.00778083f, -0.09069027f, -0.01549658f, 0.03799948f, 0.06392495f, -0.06086512f, 0.04723047f, 
    -0.08889300f, 0.01246338f, -0.02320156f, 0.01294782f, -0.08672357f, 0.03427207f, -0.07571562f, 0.03470051f, 
    0.00697737f, -0.08611929f, -0.04375581f, 0.01869949f, 0.00824760f, -0.04009351f, -0.08623168f, 0.00793137f, 
    -0.02903505f, -0.04172425f, 0.01218883f, -0.09267431f, -0.07789252f, 0.00554958f, -0.02238232f, 0.00594119f, 
    0.01648805f, -0.01464934f, -0.06209616f, -0.00391190f, 0.03391646f, 0.02936681f, 0.00799554f, 0.00240845f, 
    0.06462470f, -0.08237659f, -0.01221322f, -0.02755270f, -0.05625259f, 0.05670477f, -0.04959516f, -0.03012793f, 
    -0.10864369f, -0.02655885f, 0.03120280f, -0.00293555f, -0.08329989f, 0.06942203f, 0.00634811f, 0.04174269f, 
    -0.05628128f, 0.08634356f, 0.00648960f, -0.04141519f, -0.03536936f, -0.04770419f, 0.04716140f, 0.01720808f, 
    0.06300767f, -0.05903743f, -0.05828624f, -0.05846812f, -0.05260686f, 0.03763806f, -0.07385562f, 0.05826384f, 
    -0.03794945f, -0.09118542f, 0.04617217f, -0.05807609f, -0.02940834f, -0.06046994f, 0.06165070f, 0.05338876f, 
    -0.02655222f, 0.04698590f, -0.04009691f, -0.05419631f, -0.05881318f, -0.01531820f, -0.01237747f, 0.06639378f, 
    -0.07837743f, 0.01199078f, 0.02496184f, 0.05411945f, -0.07718940f, -0.06445051f, -0.03026307f, -0.07797083f, 
    -0.11752651f, -0.11836417f, 0.00136873f, -0.04759924f, -0.02694503f, -0.00805975f, -0.02080449f, 0.01779616f, 
    0.04261627f, -0.06513213f, -0.03628101f, 0.03702969f, -0.03780213f, 0.03168157f, 0.06879102f, -0.06390478f, 
    0.05727872f, 0.03719235f, -0.07017189f, -0.07727501f, 0.00902845f, -0.04488828f, 0.02884629f, 0.02081193f, 
    -0.07107607f, 0.00816900f, -0.02298247f, -0.06657816f, 0.00857939f, -0.11048250f, 0.06783387f, -0.03369747f, 
    -0.05798585f, -0.07508232f, -0.07529736f, -0.05319080f, 0.01860613f, -0.02312533f, -0.03136113f, 0.07540232f, 
    -0.05458971f, -0.00550467f, 0.02773654f, -0.09103590f, -0.06250441f, -0.04257585f, 0.00035741f, 0.00411869f, 
    -0.01020448f, -0.06733510f, -0.03504611f, -0.00812722f, -0.08721846f, 0.02697812f, 0.00164234f, -0.08628187f, 
    0.04805928f, -0.04047127f, -0.01462942f, 0.01909084f, 0.03477475f, -0.08890956f, 0.03120422f, -0.02825420f, 
    -0.01606500f, 0.08032398f, -0.07516384f, -0.02635054f, -0.08166973f, -0.03776327f, -0.08749026f, -0.11286236f, 
    -0.06990062f, 0.04958890f, -0.00538716f, 0.01650421f, 0.03652118f, -0.03533589f, -0.07664607f, -0.05418162f, 
    -0.00052698f, -0.10092247f, -0.03141630f, 0.04374216f, 0.00317243f, -0.08378518f, -0.12574837f, 0.02044548f, 
    0.00744300f, -0.03699724f, -0.11621869f, 0.05689855f, -0.05281330f, 0.03205429f, 0.00645420f, -0.11974350f, 
    -0.09180909f, 0.05392492f, -0.09115528f, -0.02042626f, -0.07709094f, 0.04692141f, 0.07310988f, -0.04174377f, 
    0.02598254f, -0.03624187f, 0.07817601f, 0.03740375f, -0.07685796f, -0.08915277f, -0.00737212f, -0.01818075f, 
    0.04009840f, -0.03301788f, -0.06315022f, 0.07158551f, 0.05315164f, 0.04111051f, -0.00321360f, -0.02931510f, 
    -0.06377405f, -0.10902497f, -0.06664302f, -0.09032302f, -0.02979754f, 0.05576166f, -0.08438644f, -0.06981462f, 
    0.10880623f, 0.03616380f, 0.06009674f, 0.02285540f, 0.07782258f, 0.08723821f, -0.05346185f, -0.00857053f, 
    0.17072470f, 0.44285461f, 0.05341038f, 0.27194777f, -0.08559302f, -0.18175195f, -0.04180509f, 0.15673953f, 
    0.00625645f, -0.48354179f, 0.02491987f, -0.32016724f, -0.25120240f, 0.01530064f, 0.05989937f, 0.04196091f, 
    0.16742340f, -0.03969103f, 0.07420218f, -0.07212009f, 0.04643925f, -0.12509045f, 0.02981190f, -0.14531569f, 
    -0.09370206f, 0.45239317f, 0.02360900f, 0.42073596f, 0.05400634f, -0.11024661f, 0.13758768f, 0.12675764f, 
    0.12071741f, -0.02412084f, -0.09609628f, 0.04665348f, 0.09957330f, 0.11559528f, -0.01742851f, -0.17110428f, 
    -0.25059599f, 0.29955989f, 0.24449936f, 0.10217454f, 0.27703193f, 0.07229870f, 0.22887343f, 0.21266542f, 
    0.13859667f, -0.00751458f, 0.09014112f, 0.04549003f, 0.07917564f, 0.16456884f, -0.04889652f, 0.23113257f, 
    -0.27028617f, -0.07371954f, 0.04737966f, -0.22748339f, 0.03335600f, 0.05938923f, -0.13628320f, -0.09996656f, 
    -0.13817137f, 0.07409573f, 0.08622053f, -0.07611375f, -0.09592798f, 0.00277884f, 0.14077443f, -0.39947200f, 
    -0.15024567f, 0.17975718f, -0.02348654f, 0.06268622f, -0.10301482f, 0.25668544f, 0.21201530f, 0.09062084f, 
    0.17176913f, 0.09001315f, 0.02566086f, 0.13014327f, 0.00612602f, 0.00089674f, -0.01841728f, -0.10718022f, 
    0.07094777f, -0.37497434f, 0.04517066f, 0.02857996f, 0.23985134f, -0.08454085f, 0.01629287f, -0.47237277f, 
    0.05088209f, 0.25579548f, 0.29275775f, 0.17309679f, 0.35067537f, -0.15609965f, 0.02274280f, 0.10674259f, 
    0.15713102f, 0.07175010f, -0.03815795f, -0.12454733f, 0.18769717f, 0.03521623f, 0.22530669f, 0.15541665f, 
    -0.11297271f, -0.13032483f, -0.10219788f, 0.12672044f, -0.08850583f, -0.28994352f, -0.09073125f, 0.10209096f, 
    -0.08218674f, 0.04532200f, -0.01430957f, 0.01122351f, 0.01083526f, -0.07720216f, -0.07586891f, 0.04252800f, 
    0.03959501f, 0.06394494f, -0.05324386f, -0.07526172f, -0.09364640f, 0.02079873f, 0.01915400f, -0.09656841f, 
    -0.00381409f, 0.07014773f, -0.09188385f, 0.06756904f, 0.00047082f, -0.01654001f, 0.05211158f, -0.08206274f, 
    -0.06080648f, -0.04565225f, -0.01758921f, -0.04591369f, -0.04092025f, 0.01084443f, -0.01224807f, -0.05846360f, 
    -0.03242391f, 0.07296781f, 0.02025045f, -0.07536109f, 0.06499004f, -0.01483778f, 0.02420068f, 0.04151319f, 
    -0.06452154f, -0.05819105f, 0.01901822f, -0.00486385f, -0.00040217f, 0.06777786f, 0.02213278f, -0.02586608f, 
    -0.02543621f, -0.12256414f, -0.02335886f, 0.02356385f, -0.10020191f, -0.04626502f, -0.03156520f, -0.10110033f, 
    0.03694732f, -0.01347476f, -0.01830624f, -0.04626070f, 0.02897457f, 0.00637127f, -0.02780689f, -0.01913016f, 
    0.02303584f, 0.03101673f, -0.09829206f, 0.03982664f, -0.02931152f, 0.02524582f, -0.04441713f, -0.08774060f, 
    0.02341272f, -0.01451167f, 0.00035011f, -0.07210254f, 0.08791937f, 0.05147841f, 0.04690006f, -0.08516126f, 
    -0.04484508f, -0.08618034f, -0.02785923f, -0.01655288f, 0.02192594f, 0.01062514f, -0.02003685f, 0.04372743f, 
    -0.03816246f, -0.07199567f, 0.04341178f, -0.03644696f, 0.01565741f, -0.09540039f, -0.01059087f, 0.00078417f, 
    0.03456046f, 0.04396693f, -0.06811355f, -0.05037544f, 0.05012636f, 0.02143887f, 0.05466587f, -0.05109828f, 
    0.02333774f, -0.02907061f, -0.03855278f, 0.04201668f, -0.03857425f, 0.06655906f, 0.03101182f, -0.02505462f, 
    -0.04558168f, -0.08063227f, -0.02213665f, -0.08324768f, -0.08097109f, -0.03376299f, -0.04221300f, -0.01862006f, 
    -0.08726844f, -0.00323678f, -0.08837389f, 0.00988177f, 0.06322515f, -0.04261404f, 0.01400831f, -0.02131075f, 
    -0.03475789f, 0.06723893f, -0.01473642f, 0.04225995f, -0.07557655f, -0.05382925f, 0.05337530f, 0.03191077f, 
    -0.06855445f, 0.07113422f, 0.07021155f, -0.03896720f, -0.03734599f, 0.01308556f, -0.05400380f, -0.07411367f, 
    -0.01681610f, 0.05255423f, 0.05183719f, 0.05716214f, -0.06202797f, -0.07548016f, 0.04237532f, -0.06654273f, 
    -0.08504732f, 0.06827895f, -0.00109021f, -0.00401921f, -0.00811255f, -0.10979605f, -0.07388745f, -0.06853617f, 
    -0.02814423f, -0.05015716f, 0.04221317f, -0.03625939f, -0.01095466f, 0.06786360f, 0.02506754f, 0.04164848f, 
    -0.07551369f, 0.06326213f, -0.08895588f, 0.04413874f, 0.04680747f, 0.05201300f, -0.01543100f, 0.05365605f, 
    0.00321536f, 0.03786640f, -0.07494786f, 0.06498124f, -0.04325364f, -0.06946033f, 0.05098141f, -0.05047222f, 
    0.03067484f, -0.01132264f, -0.10813978f, 0.04582528f, -0.03665058f, 0.05078051f, 0.01689481f, -0.06329291f, 
    -0.07332601f, 0.04017599f, -0.02028997f, -0.07548927f, -0.08551028f, -0.01284903f, -0.06794493f, -0.09659903f, 
    0.03314980f, -0.07328553f, 0.07163148f, -0.04427915f, 0.07386182f, 0.04625958f, -0.08748375f, -0.00797750f, 
    -0.05895251f, 0.03757444f, 0.02753216f, 0.06703353f, 0.02758595f, -0.01159450f, -0.01799054f, -0.04653622f, 
    0.01932342f, 0.06647287f, -0.05582307f, 0.00036541f, 0.06536844f, -0.01338132f, 0.02185068f, -0.08319668f, 
    -0.03995354f, -0.06979815f, -0.07557568f, 0.04602538f, 0.02541101f, 0.04067216f, -0.06096904f, -0.00291500f, 
    0.03815768f, 0.02832711f, -0.03426242f, 0.04836684f, 0.03447323f, -0.10422011f, -0.08210269f, -0.04034132f, 
    -0.02553259f, -0.01135209f, 0.03960581f, -0.07248738f, -0.06733786f, 0.05230112f, -0.02562646f, -0.01211071f, 
    -0.04100220f, -0.04794632f, -0.05969594f, 0.06694260f, 0.00545252f, 0.05637663f, -0.07360403f, -0.06980208f, 
    -0.08553348f, 0.01861697f, 0.00010717f, -0.11959373f, -0.07302462f, -0.01279813f, -0.05572683f, 0.07783125f, 
    -0.06789748f, -0.05081127f, 0.03806212f, 0.01861064f, 0.15763961f, -0.02244611f, -0.06613799f, 0.04815308f, 
    -0.02714725f, 0.09841942f, -0.03021849f, 0.01026719f, 0.05096430f, -0.07361428f, -0.01628956f, -0.00689953f, 
    0.05395708f, -0.09491415f, 0.01153955f, 0.02250302f, 0.06007203f, -0.06540514f, -0.01522177f, -0.05446380f, 
    -0.03682366f, -0.07874881f, 0.01724840f, 0.04382133f, -0.03279560f, 0.01172456f, -0.09414675f, 0.01679759f, 
    -0.03499506f, -0.04484094f, 0.05088234f, -0.11969420f, 0.05703349f, -0.08360077f, -0.11305613f, 0.02908332f, 
    0.08765233f, 0.00485255f, 0.02136660f, -0.03615832f, -0.07909171f, -0.08987993f, -0.01877705f, -0.09434665f, 
    -0.05149455f, -0.04192216f, 0.04075618f, -0.09727317f, -0.16517441f, -0.04948920f, -0.11029394f, -0.01276242f, 
    0.04865281f, -0.04904518f, 0.00080206f, 0.05481200f, -0.02838888f, -0.05260761f, -0.05971677f, -0.03178621f, 
    -0.09240927f, -0.11640533f, -0.05768074f, 0.03246219f, -0.01737329f, 0.06980298f, -0.02065212f, 0.02618405f, 
    0.12221422f, -0.05273402f, -0.11351391f, 0.01887061f, -0.10308684f, -0.10454937f, 0.04711478f, -0.08886933f, 
    -0.00707925f, -0.05297826f, -0.11687410f, -0.03285655f, 0.07007440f, -0.03040659f, -0.07675897f, 0.04638056f, 
    0.00602858f, 0.06327305f, 0.04554220f, -0.05177945f, -0.08855821f, -0.02556758f, -0.08210361f, 0.05794815f, 
    -0.11161724f, -0.04438438f, 0.02182915f, 0.00020103f, -0.08013161f, 0.03677823f, -0.11504986f, -0.06408485f, 
    -0.01913440f, -0.06127598f, 0.01439886f, -0.05845051f, -0.10075583f, -0.00284459f, 0.00880904f, -0.06363590f, 
    -0.11225837f, -0.09370643f, -0.00902146f, -0.11601901f, -0.03324439f, 0.03183787f, 0.07604980f, -0.12936865f, 
    -0.12139021f, 0.00347110f, -0.55961096f, 0.03647750f, -0.20107029f, 0.14256161f, -0.05079753f, -0.03691947f, 
    -0.05046778f, -0.24189977f, 0.10575281f, 0.44002369f, 0.18600608f, 0.19145256f, 0.06126007f, -0.04988895f, 
    -0.16553682f, 0.05035514f, -0.00722370f, 0.08964202f, 0.13854674f, 0.22414625f, -0.08637345f, 0.02361510f, 
    -0.13237168f, -0.12848930f, 0.07214903f, 0.09922555f, -0.00530129f, -0.15822592f, -0.02800203f, -0.45012456f, 
    -0.18498774f, 0.10079915f, 0.19581097f, -0.03527974f, -0.42313117f, -0.05745178f, 0.26517138f, 0.10276344f, 
    0.00474671f, -0.00311245f, 0.00641890f, -0.27794510f, 0.10303918f, 0.10109751f, -0.47775820f, -0.40912455f, 
    0.01134381f, 0.10203959f, 0.03019528f, 0.20204759f, 0.16848388f, 0.26018336f, -0.33474812f, -0.13131745f, 
    0.17817973f, 0.09299023f, 0.10484050f, 0.02668643f, -0.19475222f, -0.04673672f, 0.15220377f, 0.34594294f, 
    0.22728883f, 0.00121101f, -0.09051767f, -0.00988224f, 0.03114662f, -0.08571055f, 0.22849403f, 0.01843213f, 
    0.11541024f, 0.14121117f, -0.21886104f, 0.06747292f, 0.06731667f, 0.06426684f, 0.24775635f, 0.00668055f, 
    0.04640072f, -0.10134404f, -0.28167194f, 0.10422701f, 0.04745046f, 0.03485356f, 0.47831863f, 0.23920822f, 
    0.08929256f, -0.04937137f, -0.31202036f, 0.04728698f, -0.06863904f, -0.14084281f, 0.10265496f, 0.13686347f, 
    -0.20071979f, 0.23127538f, 0.23990010f, 0.09063182f, 0.32544684f, 0.13267800f, -0.01126103f, 0.06095688f, 
    -0.18881258f, 0.33097488f, -0.06024552f, 0.15056379f, 0.14215386f, 0.12365873f, -0.11083102f, -0.19479695f, 
    -0.14317295f, -0.03650882f, -0.14910503f, -0.17859225f, 0.05189233f, -0.31436670f, -0.06282979f, -0.21654195f, 
    -0.15601847f, 0.15083033f, -0.13704039f, 0.17201097f, -0.07937513f, -0.15383132f, 0.09763724f, -0.10655175f, 
    -0.35392329f, -0.03776698f, 0.07040495f, -0.02584869f, 0.10404187f, -0.04484298f, 0.00034302f, 0.03605309f, 
    -0.03575112f, 0.17941462f, 0.02200551f, -0.51528490f, 0.49711043f, 0.24466671f, -0.12362493f, -0.42141917f, 
    0.05740113f, -0.05081720f, 0.24530584f, -0.53457159f, -0.05824280f, 0.00342894f, -0.20855395f, -0.07376485f, 
    -0.05969451f, -0.11755630f, 0.01185091f, 0.03650734f, -0.08130402f, 0.09215589f, -0.00907718f, 0.27012497f, 
    -0.02047244f, -0.09532105f, -0.04881899f, 0.07811344f, 0.05899209f, -0.00515199f, -0.19971384f, -0.71175939f, 
    0.15506583f, 0.00891767f, 0.13412417f, 0.00504684f, -0.03665463f, -0.47491202f, 0.11166490f, 0.21476816f, 
    0.33541858f, -0.27584225f, -0.58374441f, 0.23051259f, -0.41179082f, 0.10918542f, -0.01092892f, 0.01310310f, 
    0.01818469f, -0.32402229f, 0.27356631f, -0.26139009f, 0.11375250f, -0.50704390f, -0.34496725f, 0.03153652f, 
    -0.36630458f, -0.08419234f, 0.07394394f, 0.28168240f, -0.02389888f, 0.08586748f, 0.14736658f, 0.29906613f, 
    0.38728306f, 0.01312020f, 0.04624029f, 0.08328145f, 0.06355714f, -0.05720193f, 0.02594349f, -0.74022496f, 
    -0.03882976f, -0.01538934f, 0.06828664f, -0.05284422f, -0.01703522f, 0.05620249f, -0.25665265f, 0.01623451f, 
    -0.12250482f, 0.05051980f, -0.01910893f, -0.49528006f, -0.06872489f, 0.08964287f, 0.12733676f, 0.04834404f, 
    -0.02576398f, -0.08703944f, 0.07115209f, 0.16797602f, -0.27802971f, 0.18293059f, 0.02266170f, -0.22841634f, 
    0.01579415f, -0.01259714f, -0.13612415f, -0.41552106f, -0.45108667f, -0.26801485f, 0.04325170f, 0.08266267f, 
    -0.12622364f, -0.00431495f, -0.45689499f, -0.40718046f, -0.26081395f, 0.00037616f, -0.31513226f, -0.02302732f, 
    0.12504573f, 0.31759107f, 0.44735840f, 0.06481046f, 0.10406956f, -0.46104595f, 0.06801303f, -0.10448627f, 
    -0.00299034f, -0.06913722f, 0.05623872f, -0.00855664f, -0.03745350f, -0.04749427f, 0.02181348f, -0.00135937f, 
    -0.07934085f, -0.08513317f, 0.04890952f, 0.04060940f, -0.01393925f, -0.11293191f, 0.03495928f, -0.01624730f, 
    0.04943461f, -0.02613189f, 0.06150172f, -0.10590149f, -0.07728694f, -0.11240692f, -0.03931326f, -0.00724581f, 
    -0.07509647f, 0.01621948f, -0.02762084f, -0.01099077f, 0.05199717f, -0.04467642f, -0.00146697f, -0.07264277f, 
    -0.09114150f, -0.04744963f, -0.08405208f, 0.08703548f, -0.07654939f, -0.10232795f, -0.08639929f, -0.04114315f, 
    0.00379165f, 0.00988722f, 0.02597732f, 0.04941188f, -0.09966016f, 0.00051083f, 0.04747733f, -0.10587535f, 
    0.03735084f, 0.02114815f, -0.10810620f, -0.07748169f, -0.01903682f, -0.04688487f, -0.03756317f, -0.08152340f, 
    -0.09378681f, -0.00848529f, -0.03894396f, -0.08193173f, -0.02531975f, -0.02933636f, -0.11262532f, -0.00579495f, 
    -0.06496844f, -0.08321341f, -0.06826697f, -0.00877189f, 0.08361001f, 0.09017026f, -0.04694854f, 0.04153905f, 
    -0.05195394f, 0.05232432f, 0.00840142f, -0.00700832f, 0.06300934f, -0.04611650f, -0.10246818f, -0.02265917f, 
    0.02025295f, 0.04719869f, -0.01061154f, 0.05496337f, -0.02887861f, -0.11347770f, -0.01436021f, -0.07116238f, 
    -0.03132658f, 0.04215385f, -0.05516311f, -0.02790380f, -0.05804606f, -0.03114095f, -0.03382588f, -0.01663545f, 
    -0.03209788f, 0.00226565f, -0.07476635f, -0.00956712f, 0.03788816f, -0.09233952f, -0.04015451f, -0.02123139f, 
    0.05695171f, -0.05015751f, -0.07396812f, -0.11163888f, -0.08867085f, -0.01710291f, -0.01435761f, -0.03781093f, 
    -0.02426682f, -0.10309833f, -0.03970066f, 0.01974042f, 0.05378766f, -0.02265004f, -0.03247900f, -0.08442315f, 
    -0.01488347f, -0.11560614f, -0.09053825f, 0.03517457f, -0.10948343f, 0.00419672f, -0.00289324f, -0.05809037f, 
    -0.02901176f, -0.09504966f, -0.04882038f, 0.05344916f, -0.03151327f, 0.04703244f, -0.08595547f, -0.06357729f, 
    -0.03592359f, -0.01366405f, 0.02123086f, 0.06134776f, 0.05212163f, -0.08131451f, -0.01148669f, -0.06389549f, 
    -0.04124000f, 0.06005344f, -0.02237253f, -0.05327428f, -0.02645567f, 0.02192497f, -0.00664900f, 0.00821836f, 
    -0.00813339f, 0.01487375f, -0.05187269f, -0.02791022f, -0.09076021f, 0.00227153f, -0.07932439f, 0.03565243f, 
    0.01660505f, -0.04740586f, -0.05419609f, 0.06860702f, -0.07769895f, -0.02009885f, -0.06371788f, 0.02706976f, 
    -0.05852953f, 0.05718735f, 0.02673482f, -0.06153903f, 0.00612523f, -0.06052212f, -0.01520308f, -0.08403599f, 
    0.04044374f, -0.02414668f, -0.07036538f, 0.06026650f, -0.09488028f, -0.04799611f, 0.00395872f, -0.08836239f, 
    0.02747332f, 0.07356539f, 0.00582061f, -0.04568467f, -0.08312222f, 0.04467884f, -0.08716499f, -0.07292689f, 
    -0.01498358f, 0.08266262f, 0.03100030f, -0.01742890f, -0.02152758f, -0.06060785f, -0.00641042f, 0.02887130f, 
    0.02798831f, 0.02015702f, 0.04060318f, 0.06315403f, 0.05376354f, -0.02339208f, -0.06865507f, -0.05557582f, 
    0.04834365f, -0.09373469f, 0.03285262f, -0.04474564f, 0.02588006f, -0.03720944f, -0.01374438f, -0.01939746f, 
    -0.07874131f, -0.03091938f, 0.01108160f, -0.00727358f, 0.04798598f, 0.06986053f, -0.04197598f, -0.04934288f, 
    -0.02958998f, -0.07733317f, 0.01115044f, 0.05047718f, -0.03704799f, -0.04128051f, -0.00381407f, -0.03166422f, 
    -0.00918151f, 0.08128640f, 0.01680966f, -0.07134438f, -0.08586027f, 0.04022817f, 0.05137495f, 0.02255964f, 
    0.05614913f, 0.03442781f, -0.03596760f, -0.00461870f, -0.01487780f, 0.06688227f, 0.00075394f, -0.02532413f, 
    -0.02668225f, 0.05755330f, 0.06420149f, -0.04745454f, -0.06336849f, -0.00990829f, 0.03615059f, -0.04659082f, 
    0.23393294f, 0.21650030f, 0.06823242f, 0.00777395f, 0.13500457f, -0.20776260f, 0.02521653f, 0.05626073f, 
    -0.04151484f, -0.36506972f, 0.00480671f, -0.10979374f, 0.07495919f, -0.17350589f, -0.11843660f, 0.04189546f, 
    -0.14825362f, -0.13231201f, -0.08110964f, -0.05970658f, -0.01715753f, 0.06790400f, 0.22155389f, -0.05724106f, 
    -0.24509811f, 0.05428625f, 0.03546743f, -0.34709543f, 0.09240429f, -0.17749040f, 0.10936487f, 0.06958640f, 
    0.17268166f, 0.05054380f, 0.02840117f, -0.02050851f, 0.20950820f, 0.26747069f, 0.05989669f, -0.01299926f, 
    -0.10995351f, 0.02438571f, -0.10017008f, 0.08576062f, -0.29819372f, 0.15843780f, -0.01407283f, -0.13301101f, 
    0.21741623f, 0.15857439f, -0.12109367f, -0.00432181f, 0.13582507f, -0.00639585f, -0.08662548f, 0.04139937f, 
    -0.06876763f, 0.20561443f, 0.11058581f, 0.21834439f, 0.27401337f, 0.17618619f, 0.11479370f, -0.17114978f, 
    0.12040803f, -0.02176026f, 0.05324272f, -0.14896958f, 0.07815487f, 0.17069490f, 0.14627285f, -0.10342561f, 
    0.13223590f, 0.08559334f, 0.05974897f, -0.23701878f, -0.07606647f, -0.07969404f, -0.07118143f, 0.11808549f, 
    -0.03403470f, 0.17688721f, 0.12954910f, -0.09584660f, 0.10142747f, 0.13002041f, -0.28647339f, -0.20503192f, 
    0.00967973f, -0.06325734f, 0.19929790f, -0.03553889f, -0.43626508f, 0.12092767f, -0.01468991f, -0.12236710f, 
    -0.07948245f, -0.34016502f, 0.05070907f, 0.14063424f, -0.16328317f, 0.04474367f, -0.23365706f, -0.12383474f, 
    0.31895652f, -0.07003015f, -0.00617701f, 0.06972800f, 0.05458902f, -0.08485647f, 0.21103576f, 0.05360338f, 
    0.17100678f, -0.03549096f, 0.18075870f, -0.08855760f, 0.02839660f, 0.13211440f, 0.05085455f, 0.05303642f, 
    0.05896988f, -0.14560686f, 0.10489832f, 0.07392842f, 0.16157915f, -0.18529449f, 0.01537316f, 0.11140257f, 
    0.42184827f, 0.12742849f, 0.06525948f, 0.03582071f, 0.05537726f, -0.01768170f, -0.07493021f, 0.05482946f, 
    -0.23839246f, 0.30859759f, 0.30293682f, 0.27830946f, -0.35160148f, -0.24269080f, -0.13572273f, 0.10902514f, 
    -0.11241572f, 0.21445264f, -0.27662277f, 0.05548720f, -0.26829746f, 0.08269870f, 0.42179283f, 0.02364204f, 
    -0.10635252f, -0.03168893f, -0.04742138f, -0.17037681f, -0.30345994f, -0.02420864f, 0.17000733f, -0.14307235f, 
    -0.37859631f, 0.36866364f, -0.01699373f, -0.07506638f, 0.14309816f, -0.02314032f, 0.02259414f, -0.08372440f, 
    -0.01665526f, 0.01617852f, 0.09033949f, -0.14430743f, 0.05049878f, 0.01853191f, 0.06471682f, 0.10402720f, 
    -0.15966821f, 0.08799589f, -0.03122492f, -0.06744548f, -0.09804597f, 0.16098218f, 0.02240286f, 0.41929370f, 
    -0.20805798f, 0.16995688f, 0.26349989f, -0.04664185f, 0.23343062f, 0.01198620f, 0.12900113f, 0.12827815f, 
    0.18031459f, -0.07534324f, -0.06941141f, -0.01946555f, 0.06600535f, 0.01100760f, -0.13063097f, -0.50337136f, 
    -0.34964553f, -0.10929670f, 0.04413107f, -0.04215211f, 0.05608040f, -0.04216578f, 0.10111053f, -0.09090131f, 
    -0.04836769f, -0.02784083f, 0.18494403f, 0.03845585f, 0.16602133f, -0.08966297f, -0.07495657f, 0.20166694f, 
    0.21868807f, 0.01419309f, 0.06660057f, 0.03459338f, 0.24286608f, -0.11492936f, -0.29417947f, 0.11026008f, 
    0.14004427f, 0.24403366f, 0.02647229f, -0.02112481f, 0.20306621f, 0.00124913f, -0.05795279f, 0.04307108f, 
    0.12179480f, -0.16572933f, -0.13170499f, -0.03295008f, 0.01737223f, 0.22270362f, 0.00323841f, -0.01599476f, 
    0.20091714f, 0.18386911f, -0.11605465f, -0.07675896f, 0.35166687f, 0.01533916f, -0.18493794f, 0.06454240f, 
    0.02617763f, -0.33881864f, -0.20606080f, -0.07988029f, -0.02476321f, 0.24609180f, 0.05753246f, -0.18329088f, 
    0.05627026f, 0.07442787f, 0.11095901f, 0.10220218f, 0.17127873f, 0.12935381f, -0.00079589f, 0.03248407f, 
    -0.03480459f, -0.02471602f, 0.14305086f, 0.15268123f, 0.07719053f, 0.04082070f, -0.22630158f, 0.31773809f, 
    0.12783998f, -0.06890058f, -0.09657967f, 0.03249304f, -0.01657046f, 0.09254991f, 0.45951629f, 0.02806069f, 
    -0.02965382f, 0.32809249f, 0.03194222f, -0.34808823f, 0.13999616f, -0.24972546f, 0.38116610f, 0.23665765f, 
    0.15894140f, 0.21183062f, -0.11581326f, -0.21259767f, 0.18958306f, 0.03959007f, -0.04439903f, -0.10101636f, 
    -0.04174349f, -0.07130817f, 0.11384333f, 0.24571286f, -0.09175281f, -0.15678583f, 0.23319992f, 0.16011265f, 
    0.17129262f, 0.15972604f, -0.03591812f, -0.01399854f, 0.00139327f, 0.00335194f, 0.11396498f, 0.11470754f, 
    0.10945731f, 0.09685145f, 0.03021692f, 0.09105217f, 0.08938877f, 0.06065479f, -0.05670994f, -0.04562766f, 
    0.24127045f, -0.02507625f, 0.03065607f, -0.04941912f, 0.04831069f, 0.22099245f, -0.12098699f, -0.41352922f, 
    -0.17997152f, 0.05561962f, 0.00835012f, -0.08475304f, 0.01244576f, -0.03693540f, -0.03146718f, 0.20276947f, 
    0.19226371f, 0.16434513f, 0.30513892f, 0.03830663f, 0.00843737f, 0.01229286f, -0.28884223f, -0.33910170f, 
    0.16844775f, -0.06332036f, 0.29815024f, 0.11466066f, 0.20110433f, 0.10943778f, -0.06931599f, -0.10266437f, 
    0.20122500f, -0.36328736f, -0.03006369f, -0.24975659f, -0.12157904f, -0.10036390f, -0.00296305f, -0.40925869f, 
    0.24657604f, -0.02516885f, 0.12787318f, -0.03330304f, -0.07012032f, 0.27446914f, 0.28930679f, 0.37919492f, 
    0.12994637f, 0.01783934f, 0.01789294f, 0.12884367f, -0.00950533f, 0.23900594f, -0.00976203f, -0.23422998f, 
    0.18887128f, -0.29369780f, 0.21982497f, 0.01282130f, -0.09074385f, -0.00798875f, -0.03734472f, -0.50805569f, 
    -0.21377651f, 0.00260437f, 0.15480268f, 0.05253245f, 0.11877538f, -0.35945067f, -0.00175954f, -0.08078726f, 
    0.07979334f, -0.15608186f, -0.01872174f, -0.18794852f, 0.36221990f, 0.34610391f, -0.09050355f, -0.44840080f, 
    0.06396549f, 0.00655985f, -0.12272998f, 0.00289167f, -0.43186006f, -0.16734251f, -0.13537547f, -0.08439994f, 
    -0.04857266f, -0.21452495f, 0.07259230f, -0.14362141f, -0.25385022f, 0.06423763f, -0.00893625f, 0.18154842f, 
    -0.21132824f, -0.12340986f, 0.22238646f, 0.00657234f, 0.13721406f, -0.02601213f, -0.35401753f, -0.05923758f, 
    0.15389368f, 0.03540240f, 0.11645650f, 0.04186932f, 0.03042971f, -0.46898955f, 0.05624130f, 0.04683429f, 
    -0.16356690f, -0.33533034f, -0.46151450f, 0.12769192f, -0.14405872f, -0.05212320f, 0.03411443f, 0.06373569f, 
    0.11424569f, -0.03895468f, -0.02173907f, -0.10380528f, -0.07825256f, -0.44581935f, -0.11233477f, -0.11488431f, 
    -0.03865102f, -0.04737457f, 0.02975944f, 0.01286185f, -0.06261750f, -0.20112522f, 0.22922862f, -0.00342947f, 
    0.26042360f, -0.01428298f, -0.08035020f, 0.08631218f, 0.00454017f, -0.07202007f, 0.17062381f, -0.18853942f, 
    0.06677444f, 0.01360556f, 0.06025799f, -0.08032269f, 0.09842072f, -0.09717013f, -0.34905532f, -0.05995873f, 
    -0.31116003f, 0.06187337f, 0.03540017f, -0.46683523f, -0.06556826f, 0.04942861f, 0.02707280f, 0.04596743f, 
    -0.06949557f, 0.29046884f, -0.06559410f, -0.24522778f, 0.20548525f, 0.02999130f, 0.02239860f, 0.23720168f, 
    -0.09244750f, 0.22074108f, -0.02648070f, -0.51269186f, -0.24168928f, -0.24660218f, 0.02311342f, -0.06326959f, 
    -0.33119527f, -0.01061466f, -0.19818053f, -0.07063038f, -0.26831630f, 0.08165730f, -0.18789570f, 0.00737316f, 
    0.07715120f, 0.04548858f, 0.42044702f, 0.04310612f, -0.01092609f, -0.19965501f, 0.02522233f, -0.01924098f, 
    -0.11598010f, -0.15258065f, -0.04209746f, -0.05741585f, -0.09885285f, -0.07093244f, -0.00539844f, -0.06321218f, 
    -0.00947597f, -0.03266728f, -0.04743846f, -0.05349643f, -0.07643493f, -0.10948015f, -0.02328040f, 0.01029351f, 
    -0.05093206f, -0.05117163f, -0.01281264f, -0.07555848f, 0.01649148f, -0.06875496f, -0.03969916f, 0.01740918f, 
    0.04251330f, -0.10006124f, 0.05700120f, 0.00154521f, -0.05901368f, 0.00062292f, -0.00203475f, -0.03841129f, 
    0.04992718f, -0.06379711f, -0.10708718f, -0.05316336f, -0.06143381f, -0.09686213f, 0.02110997f, 0.02332768f, 
    -0.01106993f, -0.00195239f, -0.11145321f, -0.09945869f, -0.01564387f, -0.07494098f, 0.00549830f, 0.02526944f, 
    -0.07056241f, -0.05277422f, -0.05247968f, -0.10185468f, 0.01587052f, 0.00359095f, -0.08617217f, -0.10245076f, 
    -0.02317631f, -0.07318339f, -0.04054577f, -0.08356810f, -0.07298622f, -0.06643946f, -0.00159141f, -0.11002631f, 
    -0.06134121f, 0.01772056f, -0.06135580f, -0.03352204f, 0.00713373f, -0.00183494f, -0.10909585f, -0.10162441f, 
    -0.03273355f, 0.05051812f, 0.05589702f, -0.09573099f, 0.01132207f, -0.02041393f, 0.00174514f, -0.03871002f, 
    0.01257843f, -0.11139956f, -0.12147003f, -0.00585782f, -0.00519809f, -0.06471565f, -0.04713427f, -0.13474537f, 
    0.06367770f, 0.02586643f, -0.05553452f, -0.03535988f, 0.02927071f, 0.00586628f, -0.10570975f, -0.08828153f, 
    0.00956978f, -0.01089385f, -0.13237588f, 0.01455794f, -0.10699955f, -0.06801637f, -0.13380828f, 0.02865426f, 
    0.01451664f, -0.00751016f, -0.02864482f, -0.12991868f, -0.06596890f, -0.01327775f, -0.10769802f, -0.08957096f, 
    -0.13818020f, 0.00596682f, -0.09693303f, -0.02253966f, -0.06016630f, -0.03286084f, -0.10696150f, 0.00001490f, 
    0.01173481f, -0.07439963f, -0.11034370f, 0.04009174f, -0.00856626f, -0.02669675f, -0.05296107f, 0.01426680f, 
    -0.66439480f, -0.13786763f, 0.04922363f, 0.08386563f, 0.17278148f, 0.05547611f, -0.07605454f, -0.03372005f, 
    0.06053295f, -0.23154011f, 0.53740382f, 0.19226943f, -0.14117286f, 0.08400417f, 0.03933770f, -0.23299509f, 
    0.08677709f, -0.04060326f, -0.01801278f, 0.02175878f, -0.08274642f, 0.01621729f, -0.14967221f, 0.07780751f, 
    0.10533947f, -0.19973068f, 0.05795295f, 0.10591568f, -0.12112280f, 0.03036711f, -0.30187464f, -0.00352426f, 
    -0.29340979f, -0.34778959f, 0.11173805f, -0.51792914f, -0.75725567f, -0.13086718f, 0.17978734f, 0.07155807f, 
    0.20119467f, -0.05625872f, 0.01468891f, 0.05033765f, 0.12368398f, 0.01272453f, -0.50001007f, -0.01497817f, 
    -0.09966648f, -0.19123021f, 0.09305421f, 0.06252267f, -0.04640239f, 0.16545875f, 0.16907099f, -0.71218747f, 
    -0.03777142f, -0.10913916f, -0.63139433f, -0.27329007f, -0.24023491f, -0.20648497f, -0.01332587f, 0.25989616f, 
    0.09984701f, -0.04503001f, -0.03237099f, 0.07010813f, -0.07121991f, -0.21796186f, -0.12533645f, -0.10908145f, 
    -0.02749569f, 0.13774182f, -0.00370445f, 0.05340772f, 0.06357364f, -0.01317934f, 0.19941390f, -0.19921790f, 
    0.18213461f, -0.32733709f, -0.14885928f, 0.00852610f, 0.34882325f, -0.00956902f, 0.09601103f, 0.16771726f, 
    -0.33551556f, 0.04308503f, -0.21466501f, 0.03335401f, -0.10332442f, -0.36429280f, -0.13784534f, 0.04223323f, 
    -0.07569885f, -0.10541350f, 0.11976925f, -0.02905791f, -0.08542394f, -0.15122032f, 0.06210014f, 0.10934726f, 
    -0.07374509f, 0.00604534f, 0.06952264f, 0.08866860f, 0.06965889f, -0.18292475f, -0.22989018f, -0.25573164f, 
    -0.24882281f, 0.16840044f, 0.00621747f, 0.02166845f, 0.02728437f, -0.90992481f, -0.14647567f, 0.14274050f, 
    -0.10612970f, 0.13498011f, -0.05511351f, 0.00738267f, 0.00735485f, 0.02504442f, -0.05193365f, -0.03851632f, 
    -0.03584552f, 0.01066354f, -0.05363634f, 0.02528824f, -0.02936874f, 0.02359103f, 0.00173984f, -0.05882764f, 
    0.01484213f, -0.01352310f, 0.05358359f, -0.02179501f, 0.05777689f, -0.08438930f, 0.02712296f, -0.09872200f, 
    -0.00520448f, -0.08675367f, 0.01749567f, 0.00518942f, -0.04186863f, 0.03098671f, -0.17551240f, -0.06597163f, 
    0.03727910f, 0.02101080f, 0.05920359f, -0.11248557f, -0.01903163f, -0.04315247f, -0.09022713f, -0.07642750f, 
    -0.00260043f, -0.09414584f, -0.04196602f, 0.00873426f, -0.11468913f, -0.05097028f, 0.00145908f, 0.00450134f, 
    -0.08652276f, -0.02258601f, -0.14114565f, 0.00381515f, -0.09904946f, -0.07437009f, -0.06239907f, 0.07678936f, 
    0.01864402f, -0.08948649f, -0.04396637f, -0.10099934f, 0.04985734f, -0.10513366f, -0.12637779f, -0.07985044f, 
    -0.07452655f, -0.04454106f, -0.07696514f, -0.06384894f, -0.06702009f, 0.01139815f, -0.05017424f, -0.07099105f, 
    -0.06408691f, 0.03678053f, 0.03331777f, -0.00448648f, 0.05015488f, -0.04027540f, 0.00720490f, 0.01429590f, 
    0.01076254f, -0.09646873f, -0.04390557f, -0.01832857f, -0.04363142f, 0.06905427f, -0.04567159f, 0.03511792f, 
    -0.03183334f, -0.04256926f, -0.05247669f, 0.04250406f, -0.06154930f, -0.02878937f, -0.00070163f, 0.01471966f, 
    -0.02149506f, 0.08670220f, -0.05468084f, -0.00162704f, -0.02779212f, -0.09869083f, -0.01127783f, -0.05844230f, 
    0.01175863f, -0.06228253f, -0.08254102f, -0.07409135f, 0.01337172f, -0.14769247f, 0.00846046f, 0.05242850f, 
    -0.00190853f, -0.05968938f, 0.05934685f, 0.02382469f, 0.04241120f, -0.10338854f, -0.13625948f, -0.02668871f, 
    -0.08495090f, -0.11942142f, 0.05907022f, 0.01885673f, 0.02349475f, -0.00626734f, -0.09498079f, -0.09986445f, 
    -0.05359511f, -0.08393098f, -0.07383215f, 0.04329408f, -0.09195561f, 0.05217725f, 0.00235220f, -0.05512892f, 
    0.46070093f, 0.22170264f, -0.09522502f, -0.12064493f, -0.06130396f, -0.02167987f, 0.05851228f, -0.08227055f, 
    -0.59977919f, 0.24372406f, 0.21457455f, 0.05087756f, 0.38240525f, -0.24949692f, 0.07592592f, -0.04944308f, 
    -0.32459483f, -0.03170954f, -0.08907283f, 0.19429991f, 0.01449758f, 0.08798942f, 0.08840144f, 0.03480785f, 
    -0.28518358f, -0.18914033f, 0.06542293f, -0.29894629f, -0.28693032f, -0.02914289f, -0.02861600f, -0.18636014f, 
    -0.23320563f, 0.12426920f, 0.26019546f, 0.14432938f, -0.02286289f, 0.21186016f, 0.33378944f, -0.04173925f, 
    -0.09440500f, -0.00364949f, 0.14745794f, -0.18538260f, -0.34646925f, 0.16272785f, -0.04705789f, 0.20374538f, 
    -0.41261989f, 0.04854168f, -0.05460509f, -0.10321204f, -0.06062386f, 0.13799012f, -0.17210111f, 0.42272028f, 
    -0.28954080f, 0.24156120f, 0.40222448f, 0.14417163f, 0.38616905f, 0.08064120f, 0.35797688f, 0.23568666f, 
    -0.45315182f, -0.08209876f, 0.09698188f, -0.13671337f, -0.05969796f, -0.34434760f, 0.06827187f, -0.12435687f, 
    0.22111301f, -0.07892412f, -0.06402157f, -0.03741762f, 0.04202422f, 0.03735698f, 0.27210659f, 0.17076930f, 
    0.04011891f, -0.13145591f, 0.11690851f, -0.04551269f, 0.48746404f, -0.16933578f, -0.02240566f, 0.25125086f, 
    -0.07390617f, -0.05472394f, 0.08112851f, 0.06158593f, -0.33766702f, 0.01653687f, -0.22214179f, 0.12483995f, 
    0.09979932f, -0.02543367f, 0.01975284f, 0.10922381f, 0.05416645f, 0.08364896f, -0.54007918f, 0.32280779f, 
    0.18482319f, -0.03254927f, 0.01480967f, -0.02111459f, 0.02642898f, 0.32025972f, 0.11577930f, -0.00062580f, 
    0.11605345f, 0.33016798f, -0.00941116f, -0.36397845f, 0.45482790f, 0.01312932f, -0.12417729f, -0.00608161f, 
    -0.06492186f, -0.08829902f, -0.12556769f, -0.04826819f, 0.04718836f, 0.08361322f, 0.04039286f, -0.12496265f, 
    -0.03247875f, -0.08299096f, 0.11602359f, 0.09874447f, -0.07504947f, -0.17851189f, 0.02076221f, -0.06250443f, 
    0.09801277f, 0.07497244f, -0.01621748f, -0.12024685f, 0.29755002f, 0.32364187f, 0.07046578f, -0.19117500f, 
    0.12974855f, 0.10761905f, 0.05412725f, -0.10321675f, -0.02701624f, -0.07700822f, -0.32285005f, 0.04202766f, 
    -0.11577135f, -0.04696294f, -0.04724982f, 0.02620809f, -0.00396702f, 0.21163467f, -0.14107959f, 0.21469440f, 
    -0.02992902f, -0.27149859f, -0.06402961f, -0.14628804f, 0.08682949f, -0.13666818f, 0.01066878f, -0.18208857f, 
    0.25955388f, 0.07448682f, -0.01956506f, 0.00689156f, 0.04301417f, -0.09924056f, 0.00988853f, 0.16779594f, 
    -0.02367597f, -0.18415280f, 0.11651149f, 0.02097586f, 0.00798377f, 0.13179961f, 0.14409618f, -0.08775365f, 
    0.12899348f, -0.09676582f, -0.15687333f, -0.19496098f, 0.14843765f, -0.02472026f, -0.03749768f, 0.04410837f, 
    0.07827773f, 0.05995012f, 0.05245846f, 0.07560413f, 0.02242953f, -0.06030915f, 0.04999105f, 0.10298821f, 
    0.02163459f, 0.12191599f, 0.17965862f, 0.12622949f, 0.03149643f, 0.07035311f, -0.00484940f, -0.12612565f, 
    -0.05281286f, 0.03864037f, 0.00857534f, -0.06134457f, 0.30627659f, 0.07879101f, 0.00858916f, 0.15301941f, 
    0.17682099f, 0.08040894f, 0.00838636f, -0.13338155f, 0.03421155f, 0.16958956f, 0.15393478f, 0.15552284f, 
    0.04169067f, 0.33551684f, 0.11142782f, 0.24568219f, 0.10215203f, 0.16938965f, 0.01532116f, 0.17676121f, 
    0.07560041f, -0.15813230f, -0.07727707f, -0.08810371f, 0.04545965f, -0.15336132f, 0.06371891f, -0.17962870f, 
    -0.25764769f, 0.26526448f, 0.10105515f, 0.02068803f, -0.00488566f, 0.15081775f, -0.08631945f, -0.09452766f, 
    0.18188204f, 0.03988611f, 0.16719460f, 0.04568425f, -0.05608774f, 0.10183004f, -0.04451724f, 0.23483609f, 
    0.30328244f, -0.14492327f, -0.04905711f, 0.05302206f, -0.04707251f, 0.30636418f, 0.08306316f, -0.01814936f, 
    0.04395262f, 0.45538878f, -0.16473384f, 0.35621229f, -0.55665076f, -0.22499989f, -0.00705275f, 0.38929597f, 
    -0.03831705f, 0.05774117f, -0.12629892f, 0.00226342f, -0.26381031f, -0.11008541f, 0.75904471f, -0.00216120f, 
    -0.31281868f, 0.06887275f, -0.08498956f, -0.07750520f, 0.09564012f, -0.12601398f, 0.19623592f, -0.01961753f, 
    -0.73784178f, 0.60528636f, -0.33476478f, -0.07743074f, 0.15000603f, -0.47693208f, -0.03932341f, -0.20517878f, 
    0.07840406f, -0.02940027f, 0.08841389f, -0.03826544f, 0.18059140f, -0.05416575f, 0.13735509f, -0.10710228f, 
    -0.39169592f, 0.28059027f, 0.09772354f, -0.06645880f, 0.18564123f, 0.14272092f, 0.29625776f, 0.15577553f, 
    -0.02790110f, -0.12583122f, 0.15924568f, -0.15200324f, -0.24243113f, 0.18111721f, -0.14973277f, 0.24570328f, 
    -0.17176405f, 0.07351800f, 0.08208656f, -0.16748637f, 0.08018059f, 0.13165325f, -0.23944421f, -0.29878059f, 
    -0.47441214f, 0.09041612f, -0.01173544f, 0.00296759f, -0.00186771f, -0.06903865f, 0.10679333f, -0.03319716f, 
    -0.21963836f, -0.02171653f, -0.06111384f, 0.02174856f, -0.19580618f, 0.17132549f, 0.02946542f, 0.04244560f, 
    -0.27868283f, -0.00652420f, -0.04322721f, 0.10230171f, -0.44118008f, -0.00837348f, 0.07283153f, 0.19464855f, 
    0.20203909f, -0.28049019f, 0.08685835f, -0.37239939f, 0.27465060f, -0.19085604f, 0.09399938f, -0.26864281f, 
    -0.09520213f, 0.22690031f, -0.20836507f, 0.16395760f, 0.19637486f, 0.06870852f, -0.10397954f, 0.09620094f, 
    0.32030281f, -0.13322116f, -0.28396174f, 0.02579555f, 0.27831000f, 0.02352769f, 0.05966863f, 0.12018611f, 
    0.08055573f, -0.09049708f, -0.15069377f, -0.05078008f, -0.33923769f, 0.05875936f, 0.07203815f, -0.08997004f, 
    -0.13172328f, 0.06895331f, 0.09280390f, 0.12767701f, 0.03714956f, 0.00785062f, -0.01324357f, -0.07953749f, 
    -0.00333606f, -0.34233418f, -0.23813669f, -0.21484584f, 0.29313993f, 0.26560777f, -0.14953548f, -0.03290382f, 
    0.13055792f, 0.03382131f, 0.09608293f, 0.02240583f, 0.02627711f, -0.08042143f, -0.03188036f, 0.06075800f, 
    -0.17384805f, 0.22403643f, 0.03904897f, 0.01236254f, -0.09131798f, 0.08732732f, 0.19663274f, 0.00549228f, 
    0.23556201f, -0.22398745f, -0.30939883f, -0.08566743f, 0.00835524f, 0.15869553f, -0.09925283f, -0.27956903f, 
    -0.01714399f, 0.01842135f, 0.27013671f, 0.23503129f, -0.04718573f, -0.27174333f, 0.07986442f, 0.24654597f, 
    -0.00143805f, -0.08729455f, -0.36006299f, 0.11320231f, -0.19448863f, -0.01548265f, -0.07389494f, 0.01176669f, 
    0.17204207f, 0.02907114f, 0.06065797f, -0.14499158f, 0.06033694f, -0.17794375f, -0.03286711f, -0.23290414f, 
    0.16081464f, 0.03539605f, 0.09602764f, 0.26951870f, -0.07511146f, -0.23688988f, 0.02535412f, -0.00341747f, 
    0.16076128f, 0.12803173f, 0.03022278f, 0.15912190f, 0.02250200f, 0.01607346f, -0.25568697f, 0.14058252f, 
    -0.15290223f, -0.01297172f, 0.16788313f, 0.02714709f, -0.00573250f, 0.03783236f, -0.25662109f, -0.08126015f, 
    0.03117276f, 0.06183210f, 0.08296324f, -0.11201108f, 0.01259512f, 0.15535194f, 0.14354901f, 0.01288743f, 
    -0.04494055f, 0.31162867f, -0.05405604f, -0.05854663f, -0.22914307f, 0.25800982f, 0.09104828f, 0.13084932f, 
    0.15540025f, -0.24583802f, 0.05646998f, -0.29068601f, -0.41361275f, 0.25455067f, 0.13441624f, 0.17790551f, 
    -0.06250770f, 0.08515923f, -0.10558844f, -0.14531437f, -0.15137970f, 0.17323060f, -0.12340078f, -0.23888572f, 
    0.22183637f, -0.04945700f, 0.01624315f, -0.17457758f, -0.00545151f, 0.03340529f, 0.05576776f, -0.11014871f, 
    0.18071392f, 0.10788722f, -0.07201181f, 0.16422006f, -0.30602977f, 0.05751973f, -0.07936133f, -0.00717640f, 
    -0.09611157f, 0.18114573f, 0.51413631f, -0.08227759f, -0.20123848f, -0.10210442f, 0.01989667f, -0.00623491f, 
    0.09833360f, 0.02499874f, -0.03948081f, 0.10383586f, 0.07648870f, 0.07819809f, 0.20044176f, 0.08334709f, 
    -0.11777769f, -0.01306906f, 0.04678169f, 0.02246966f, -0.05994866f, 0.25951883f, 0.05065008f, 0.04998124f, 
    0.00888624f, -0.01264240f, -0.05086032f, -0.09784722f, -0.03289553f, -0.12021679f, 0.07989733f, -0.18057926f, 
    0.23872641f, -0.03093916f, 0.22176668f, 0.01254718f, 0.17841499f, 0.09803902f, 0.24738057f, 0.30434752f, 
    -0.07116342f, -0.15493843f, -0.00589209f, -0.05537876f, -0.17707613f, 0.30880958f, 0.17867890f, -0.28208730f, 
    -0.05060938f, -0.01719298f, -0.06900115f, -0.07139660f, -0.04764269f, -0.10430433f, -0.00315226f, 0.27746719f, 
    0.37353078f, -0.04164016f, 0.16485046f, 0.07602930f, 0.05263050f, -0.23380175f, -0.16845798f, 0.07282722f, 
    -0.03832935f, -0.04427164f, 0.04102096f, 0.31012109f, 0.03155971f, 0.07729926f, 0.04063608f, -0.08463553f, 
    0.06427979f, -0.08098184f, -0.00462056f, -0.01919229f, 0.24631226f, -0.12161570f, 0.18724291f, 0.22633323f, 
    0.11968765f, 0.02620217f, 0.07271512f, 0.00304094f, -0.19629908f, -0.01628571f, 0.02265194f, 0.23454976f, 
    0.30243507f, 0.21075319f, 0.15459289f, 0.13125035f, 0.10417806f, 0.02344273f, 0.26137081f, 0.12594324f, 
    -0.01573121f, -0.14816779f, -0.10385138f, 0.13529295f, -0.10003293f, 0.11405757f, 0.07331280f, -0.21417990f, 
    -0.01683512f, 0.29757333f, -0.21418810f, -0.03671753f, 0.25285509f, 0.12252697f, -0.10254077f, -0.09611488f, 
    0.14270057f, -0.16774932f, -0.28604281f, -0.11124749f, 0.19712125f, 0.13422863f, -0.04858872f, -0.12829983f, 
    -0.28816989f, 0.03400356f, 0.26864234f, 0.17079085f, 0.28735459f, -0.13701355f, 0.05544397f, -0.02159457f, 
    0.12343932f, -0.58815950f, 0.11420082f, -0.01975583f, 0.11721600f, 0.31436548f, -0.09062894f, -0.14757730f, 
    0.14000784f, -0.00229145f, 0.04718269f, -0.07134706f, -0.03943229f, -0.04548018f, -0.70197719f, 0.04826229f, 
    -0.08890427f, -0.04757042f, 0.00569748f, 0.02100927f, -0.06904352f, -0.08521318f, -0.01338596f, 0.18230788f, 
    0.04446169f, -0.16475032f, -0.05419858f, 0.13444929f, 0.14375953f, -0.20894110f, -0.10186932f, 0.00406646f, 
    -0.18398574f, 0.01454616f, -0.20331302f, 0.21342194f, -0.38730940f, -0.15359840f, -0.07199824f, 0.10466623f, 
    0.16029721f, 0.00000657f, -0.06442694f, 0.20680813f, 0.03427590f, 0.01343828f, -0.17710482f, 0.05051847f, 
    0.15970300f, -0.18933795f, -0.21822345f, 0.05484133f, 0.17225696f, -0.26328352f, -0.11151236f, -0.09258474f, 
    0.38342702f, 0.00867485f, 0.01531304f, 0.03594544f, -0.08283137f, -0.10424528f, 0.20438793f, -0.14160088f, 
    0.04599013f, 0.20376053f, 0.03200323f, -0.30676448f, 0.01721529f, 0.07629048f, 0.00493715f, -0.21163353f, 
    0.14837636f, 0.06260492f, 0.36271611f, 0.01006051f, 0.03694828f, 0.21448638f, -0.00803906f, 0.02087046f, 
    0.21552855f, 0.06083188f, 0.16699767f, -0.07509897f, -0.12293872f, 0.19692628f, 0.26442698f, -0.32296205f, 
    -0.18017247f, 0.26640505f, -0.07870543f, 0.24253950f, -0.19578174f, 0.23066466f, -0.22632159f, -0.29414430f, 
    0.04547979f, -0.01925869f, 0.02164769f, -0.04650265f, 0.03208077f, -0.15103596f, 0.19532165f, 0.00558975f, 
    -0.00065875f, 0.02958573f, 0.21301989f, 0.02282104f, -0.39430085f, 0.12562129f, 0.07952014f, -0.01094811f, 
    0.04169941f, 0.21141103f, -0.01958047f, 0.18303759f, -0.01133882f, -0.05892194f, 0.05687964f, 0.17302282f, 
    0.09924506f, 0.03835945f, -0.05370170f, 0.26588807f, -0.06718572f, 0.02301797f, -0.03544612f, -0.01547603f, 
    -0.22527543f, -0.33393162f, -0.33369446f, -0.13192995f, -0.22601877f, 0.00139192f, -0.23370251f, 0.23364899f, 
    0.17012274f, 0.04126859f, -0.18911640f, 0.15479185f, 0.08418072f, 0.19026226f, 0.32998526f, 0.08151019f, 
    -0.34362128f, 0.32803085f, 0.05648065f, -0.17484224f, -0.12516215f, -0.11434855f, 0.33077598f, 0.06311222f, 
    0.32283592f, 0.14461736f, -0.20798652f, -0.17493837f, 0.11217641f, 0.08944410f, 0.02286745f, -0.24565861f, 
    -0.04455765f, -0.02356893f, 0.47388941f, 0.11928069f, 0.07012859f, -0.15876253f, 0.39036533f, 0.72534579f, 
    -0.26035753f, -0.12885194f, -0.18126610f, -0.12679547f, -0.17097014f, 0.18568914f, 0.03399658f, -0.04001665f, 
    -0.10635212f, 0.13450843f, 0.01078113f, -0.05732656f, 0.16942278f, 0.06500623f, 0.08593489f, -0.11430135f, 
    0.03650726f, -0.02369976f, 0.13617256f, 0.08359764f, 0.05730235f, -0.27850419f, -0.05221131f, -0.37507457f, 
    -0.04254604f, 0.01398571f, 0.11098641f, 0.28904760f, 0.10964245f, -0.02066964f, -0.19534960f, 0.14175016f, 
    -0.05006362f, -0.04067576f, 0.21152061f, 0.00890657f, 0.18134372f, -0.13770545f, -0.37814111f, -0.19324853f, 
    0.17172067f, 0.07534574f, 0.24141397f, 0.00006974f, -0.09620588f, 0.20332053f, 0.12779896f, 0.15360616f, 
    0.13362196f, 0.09319914f, -0.01848325f, -0.03480508f, -0.26356477f, 0.03039810f, 0.21255443f, 0.02175979f, 
    0.37921503f, -0.39398062f, -0.14114155f, -0.04255638f, -0.30094048f, 0.21912266f, 0.26869014f, 0.07878048f, 
    0.07163484f, 0.10447236f, -0.13546111f, -0.43903440f, 0.10038739f, 0.16183351f, -0.06434042f, -0.38014349f, 
    0.18850777f, -0.36925119f, -0.35141149f, -0.18455845f, -0.07285166f, 0.30023655f, -0.04890914f, -0.42864624f, 
    -0.16402318f, 0.01942892f, 0.30957207f, 0.14908546f, 0.28627610f, -0.30445266f, 0.00012237f, 0.00367686f, 
    0.08861923f, -0.20906833f, -0.12788302f, -0.27902213f, -0.41953766f, 0.28742510f, -0.18972301f, 0.03449735f, 
    0.14315411f, 0.00694309f, -0.11726827f, -0.14912935f, -0.00207565f, 0.01096093f, -0.26832843f, -0.02787090f, 
    -0.17952980f, 0.19092970f, -0.01330081f, 0.04836603f, -0.28863516f, -0.06009626f, 0.16712691f, 0.18897918f, 
    0.14606066f, -0.05251495f, -0.35620371f, 0.21292606f, 0.26061741f, -0.05780751f, -0.03683187f, -0.25291345f, 
    -0.02329509f, -0.01016113f, 0.20340948f, 0.38149384f, -0.03685554f, -0.17808829f, 0.25065559f, 0.33359221f, 
    0.21308327f, -0.03176796f, -0.13611224f, -0.06215081f, -0.10162410f, 0.21194765f, 0.11303335f, -0.00086345f, 
    0.15859836f, 0.04905877f, -0.10770626f, -0.03596026f, 0.12784193f, -0.22767383f, -0.04728708f, -0.29563397f, 
    0.00662556f, 0.01873681f, 0.14668314f, 0.12528956f, -0.06468490f, -0.56447756f, -0.10366983f, -0.27936351f, 
    -0.15970871f, 0.23006795f, 0.04813648f, -0.04533655f, 0.01199436f, 0.06780865f, -0.35246822f, -0.10353287f, 
    0.00878738f, 0.08558287f, 0.39362794f, -0.03900397f, 0.09753763f, 0.12846921f, -0.10119563f, -0.12848437f, 
    0.04900119f, 0.01636751f, 0.31728822f, -0.07374322f, -0.26613820f, 0.33755884f, 0.16181186f, -0.16291632f, 
    0.10343316f, 0.20579734f, -0.06336685f, 0.29191169f, -0.45942080f, 0.22957096f, 0.03837018f, -0.04472432f, 
    0.32869598f, -0.36834806f, 0.08491682f, -0.19753313f, -0.18718559f, 0.02923020f, 0.18949710f, 0.16611381f, 
    -0.08484732f, 0.10471110f, 0.05696168f, -0.12532458f, -0.09085698f, 0.22745608f, -0.03336301f, -0.34649619f, 
    0.16374868f, -0.19156085f, -0.17796791f, -0.05946967f, -0.08980956f, 0.32572952f, 0.05886257f, -0.10442344f, 
    -0.01309285f, -0.09969234f, 0.16504258f, -0.01494865f, 0.00774855f, -0.06360691f, 0.07397233f, -0.04405113f, 
    -0.10363484f, -0.06830662f, -0.33143395f, 0.58379585f, -0.07634136f, 0.25381270f, 0.00313702f, 0.16910036f, 
    -0.34384367f, 0.19249432f, -0.16215257f, 0.11406264f, -0.10453837f, 0.25582999f, 0.10032076f, 0.03735398f, 
    -0.10623561f, -0.35289019f, 0.02306740f, 0.10510489f, -0.09548070f, -0.19995116f, 0.00450145f, -0.17070341f, 
    -0.06165968f, 0.16527462f, 0.21043062f, -0.16591375f, -0.11903870f, -0.17918895f, 0.08577374f, 0.17842413f, 
    -0.04841480f, 0.01911012f, -0.09726108f, -0.28029653f, 0.16428545f, 0.20746598f, -0.33595115f, -0.35096294f, 
    -0.07641620f, 0.06776691f, 0.14527565f, 0.13108417f, 0.12781116f, 0.03412884f, -0.09661918f, 0.11458042f, 
    0.12329098f, 0.04734030f, 0.12865764f, 0.09097111f, -0.11345625f, 0.03466978f, 0.11164768f, 0.25050893f, 
    -0.26469707f, -0.02446651f, -0.32615095f, -0.26215938f, -0.08713082f, -0.11246194f, 0.13342553f, -0.02501457f, 
    0.00741170f, 0.24905621f, 0.00746876f, 0.00715987f, -0.01438314f, 0.08209243f, 0.31869441f, -0.01800892f, 
    0.79099464f, 0.24624045f, -0.03639194f, 0.08837380f, 0.00528394f, 0.09699094f, 0.31499857f, 0.02731785f, 
    0.15745585f, 0.04515973f, -0.17282054f, 0.24014527f, -0.02171234f, -0.24955539f, -0.25497431f, -0.06552300f, 
    -0.10704604f, 0.00836575f, -0.01883916f, 0.09956875f, 0.28433898f, -0.03271991f, -0.04953574f, 0.13702831f, 
    -0.17833254f, 0.21605827f, -0.05025676f, 0.14707375f, 0.25595304f, 0.14840238f, -0.30793390f, 0.04508698f, 
    -0.03194567f, -0.10524260f, 0.15558429f, -0.14525975f, 0.08334561f, -0.21270002f, 0.04714613f, 0.02664021f, 
    -0.26025870f, 0.13795361f, -0.30145016f, 0.11177666f, -0.22398864f, -0.09165416f, 0.02042557f, -0.24723724f, 
    0.06413759f, 0.13618331f, -0.06696427f, -0.01884491f, -0.00290549f, 0.04446331f, -0.01084134f, 0.02329807f, 
    -0.01232249f, -0.14361477f, 0.33804595f, 0.19392261f, -0.31742355f, -0.16889183f, 0.19893871f, 0.05211746f, 
    -0.07096902f, -0.10698570f, 0.12259588f, 0.03459979f, 0.11775214f, 0.09454342f, 0.27020186f, -0.04124556f, 
    -0.01581191f, 0.10359257f, -0.05702477f, -0.01123979f, -0.00839533f, -0.10006104f, 0.07592405f, 0.09556308f, 
    -0.10014017f, 0.10247993f, 0.05652633f, 0.31945214f, 0.10091578f, 0.16459274f, 0.06753904f, 0.05673123f, 
    -0.22646242f, -0.03802147f, -0.09395963f, -0.07612730f, -0.05820437f, 0.11880298f, -0.06907837f, -0.13060798f, 
    -0.12938236f, 0.32806662f, 0.03196427f, 0.06856030f, 0.26563036f, 0.08415914f, 0.01258879f, -0.02044676f, 
    0.02304729f, 0.00943788f, 0.14362691f, 0.16558374f, 0.01371949f, 0.16437809f, 0.03495254f, -0.00334942f, 
    -0.20310630f, -0.05927042f, -0.07493561f, -0.00768491f, 0.02410660f, -0.22452514f, 0.02255475f, 0.02957729f, 
    0.02371487f, -0.00434157f, 0.02776782f, -0.21172775f, -0.06380577f, -0.06087124f, 0.08321083f, 0.18181060f, 
    0.01735359f, 0.16230384f, 0.07544351f, 0.04245756f, -0.26477838f, 0.14807504f, -0.06600431f, 0.11173783f, 
    -0.13831823f, -0.08461873f, 0.14332359f, -0.01289205f, -0.47977537f, 0.06259129f, 0.03558860f, -0.09839688f, 
    0.07010943f, -0.34428114f, 0.06121382f, -0.20256966f, -0.14993647f, -0.05038121f, -0.18544967f, -0.36314687f, 
    0.10362576f, 0.23012440f, 0.11223201f, 0.01648243f, 0.17901137f, 0.11457849f, 0.22006482f, 0.10481661f, 
    0.23019636f, -0.08014156f, -0.02565221f, -0.11421595f, -0.08162507f, 0.16854285f, 0.13541728f, 0.21125484f, 
    -0.01577914f, 0.23117591f, -0.09645195f, -0.06752995f, 0.08246771f, -0.29063624f, -0.03346171f, 0.22100829f, 
    0.23862915f, -0.23404714f, 0.18860416f, 0.07858417f, 0.00646585f, 0.20407398f, -0.07366964f, -0.02527595f, 
    0.03491205f, 0.33612949f, -0.09392311f, 0.40942055f, 0.22441567f, 0.28033644f, -0.25576180f, 0.11767552f, 
    0.13005699f, 0.04155511f, -0.33324331f, -0.56457371f, -0.39087582f, 0.03374377f, 0.79024488f, -0.05996523f, 
    -0.26376143f, -0.15997599f, 0.05875958f, -0.08889089f, 0.33918169f, -0.22261007f, 0.21380982f, 0.34690532f, 
    -0.71721679f, 0.30682176f, -0.48406661f, -0.26605493f, 0.26622200f, -0.26597050f, -0.47947830f, -0.01236583f, 
    0.11637818f, 0.03308235f, 0.16056512f, 0.08337039f, 0.08917090f, -0.18430489f, 0.13832796f, 0.13832851f, 
    -0.26547769f, 0.11326872f, 0.03149430f, -0.07998814f, -0.00973270f, 0.07041645f, 0.21078622f, 0.14538524f, 
    0.15750587f, -0.38941801f, 0.11400611f, 0.10836998f, -0.44195214f, -0.04763116f, -0.24872240f, 0.03392552f, 
    -0.40239263f, -0.09109033f, -0.08676077f, -0.16314302f, -0.01414750f, 0.04449446f, -0.16897644f, -0.20087866f, 
    -0.33919150f, 0.05117630f, 0.03970755f, 0.11910393f, -0.05750725f, 0.01692146f, 0.26198822f, -0.13017279f, 
    -0.11654539f, 0.00125435f, -0.01333377f, 0.09675185f, -0.53774977f, 0.00984102f, -0.05359320f, -0.15241832f, 
    -0.52568823f, 0.04400034f, 0.12167444f, -0.18229815f, -0.56273687f, -0.00347524f, -0.04359332f, 0.02757305f, 
    0.05067614f, -0.07804199f, 0.14640695f, -0.60735941f, 0.41390592f, -0.05354366f, -0.05109560f, 0.11718286f, 
    -0.06283904f, 0.29922292f, -0.13634104f, -0.08509975f, -0.06568652f, -0.17544645f, -0.05335066f, 0.12388036f, 
    -0.10484442f, -0.07410881f, -0.15496531f, 0.13484034f, -0.03506125f, 0.04655555f, -0.19767268f, 0.17308812f, 
    0.11990453f, 0.32001716f, 0.35752627f, 0.06396269f, -0.38302618f, -0.09087343f, -0.00749127f, -0.13076285f, 
    0.09995620f, 0.02559913f, 0.04634301f, -0.06930488f, 0.05234664f, -0.13443996f, -0.04395932f, 0.03720866f, 
    0.01424377f, -0.02740564f, -0.10645186f, -0.02939841f, -0.00922796f, 0.02992408f, -0.07893968f, 0.02698912f, 
    -0.04456769f, -0.05423717f, -0.02834799f, 0.08510029f, -0.00228401f, 0.10283643f, -0.12276119f, 0.05937885f, 
    -0.08402098f, -0.08021959f, -0.05565264f, -0.07486482f, -0.01066646f, 0.01015096f, -0.08486780f, 0.06890078f, 
    0.07797694f, -0.11298160f, -0.04018427f, 0.07635868f, -0.07363929f, -0.07973816f, 0.06195968f, -0.01606137f, 
    -0.03906590f, 0.03631231f, -0.07200142f, -0.02792912f, -0.01687107f, 0.07374074f, 0.02815546f, 0.05198025f, 
    -0.03300761f, 0.01557802f, -0.00579891f, 0.00872551f, -0.05403126f, -0.05112262f, 0.02702362f, -0.07145845f, 
    -0.02799711f, -0.04699054f, -0.05621908f, 0.04718981f, -0.05771913f, -0.02336337f, 0.06508084f, 0.03140070f, 
    0.00839693f, 0.08705113f, -0.08182392f, -0.00135474f, -0.08819920f, 0.00819550f, -0.08317551f, -0.02669920f, 
    -0.04464437f, -0.01923116f, 0.00016274f, -0.01619096f, 0.06096756f, -0.01722515f, -0.04156956f, -0.05985012f, 
    -0.01402995f, -0.07878021f, 0.05122037f, -0.01945440f, 0.06151029f, -0.07009587f, -0.07320953f, 0.02920190f, 
    -0.05467382f, 0.02906907f, -0.07884660f, -0.06581883f, -0.02742663f, 0.04040803f, -0.04547003f, -0.11492107f, 
    0.00531400f, 0.03776215f, -0.01258560f, -0.01577749f, -0.04221405f, 0.04476231f, -0.12223140f, 0.00097625f, 
    -0.06617592f, -0.03955856f, 0.00096233f, -0.03122624f, -0.05251914f, -0.08161046f, 0.00049018f, 0.01441836f, 
    -0.07900477f, -0.08266196f, -0.01180360f, -0.07783501f, -0.02866787f, -0.06978464f, 0.01163422f, -0.09574258f, 
    0.02927271f, 0.01568913f, 0.08033846f, 0.05429687f, 0.04341812f, -0.01835678f, -0.03921468f, -0.03841892f, 
    0.19286874f, 0.14738238f, 0.02050409f, 0.05787982f, 0.12157702f, -0.16771890f, -0.01575916f, -0.08750802f, 
    0.08310279f, -0.13313963f, 0.44731444f, -0.08568188f, -0.23325196f, -0.27327743f, 0.05712360f, 0.13375935f, 
    -0.20820014f, -0.22748512f, -0.08824734f, -0.09798028f, -0.13604456f, 0.10385222f, -0.25143871f, -0.06842476f, 
    0.20435342f, 0.01685932f, 0.01746013f, -0.09424112f, -0.20165606f, -0.23100807f, -0.08932887f, -0.26606825f, 
    0.20704125f, 0.02820254f, 0.20592211f, 0.16684052f, -0.06752034f, 0.01376150f, 0.27491891f, 0.08993768f, 
    -0.03340503f, -0.01145781f, -0.18665200f, 0.11915810f, -0.03446316f, 0.26257518f, -0.05954115f, -0.16568999f, 
    -0.26375878f, 0.25519145f, 0.10583490f, -0.06214966f, 0.21006200f, 0.04262173f, 0.02461996f, 0.02279402f, 
    0.03368282f, 0.01897532f, -0.12449873f, 0.08724920f, 0.39902857f, -0.00340909f, 0.08447275f, 0.01888634f, 
    0.13813320f, 0.04876786f, 0.00742973f, -0.20464008f, 0.04257086f, -0.50948167f, 0.03368936f, -0.29297921f, 
    -0.09069705f, 0.19261260f, 0.06506210f, -0.18618390f, 0.02705553f, 0.06750087f, 0.02017157f, -0.37594506f, 
    -0.18254226f, 0.20344600f, 0.08655035f, -0.07120872f, 0.07933717f, 0.14545774f, -0.00464127f, -0.02596954f, 
    0.09331967f, -0.01294950f, 0.10592631f, 0.22122021f, -0.03059111f, 0.08374811f, -0.01417314f, -0.22817412f, 
    0.05325037f, -0.09743923f, 0.05957954f, 0.33082336f, -0.19487180f, -0.01783041f, -0.14191067f, -0.27832937f, 
    0.17957547f, -0.04481801f, 0.24334665f, 0.14174932f, 0.23465917f, -0.21078651f, 0.16283689f, 0.11791915f, 
    0.25480539f, -0.00424020f, 0.28671527f, -0.13050562f, -0.00909238f, 0.09136876f, 0.25336298f, -0.01381402f, 
    -0.05200377f, -0.17822406f, -0.16116464f, 0.14288294f, -0.07874303f, -0.01253504f, -0.05273886f, 0.04147159f, 
    0.09718412f, 0.02803560f, -0.25808391f, -0.04280477f, -0.13943735f, 0.16760522f, -0.02173626f, -0.01222883f, 
    -0.13248481f, 0.54268831f, -0.41114667f, 0.29053822f, 0.09290969f, 0.35584691f, -0.03079046f, 0.22629802f, 
    -0.00141166f, -0.15678796f, 0.07729372f, 0.17213580f, 0.06257118f, 0.16131257f, 0.51529449f, 0.08944708f, 
    -0.27608046f, 0.06499387f, 0.02895050f, -0.13364857f, -0.07637442f, -0.06412645f, 0.15471718f, 0.01031881f, 
    0.02803581f, 0.16414963f, 0.01767000f, 0.18777829f, -0.08527660f, 0.35905027f, -0.00733880f, 0.13834177f, 
    -0.08057095f, -0.03784861f, 0.27893960f, -0.11234138f, -0.05012509f, 0.09711143f, -0.05664340f, 0.17905304f, 
    -0.15396732f, 0.06924193f, -0.11129060f, 0.17713910f, 0.00561086f, 0.05079406f, -0.10867686f, 0.20523073f, 
    0.00944819f, 0.19160223f, 0.40348652f, 0.09499188f, -0.19417085f, 0.08442485f, 0.26730865f, 0.17707497f, 
    -0.06824078f, 0.03659146f, -0.14493883f, 0.08852871f, -0.03348118f, -0.04902932f, 0.05433012f, 0.03123031f, 
    0.24922831f, -0.20375057f, -0.01521285f, -0.02838404f, -0.02138152f, 0.04990212f, 0.13426758f, 0.33384973f, 
    -0.18380900f, -0.14749959f, -0.02765238f, 0.10774310f, -0.22533654f, -0.03082126f, 0.09853067f, 0.07401458f, 
    -0.11527181f, 0.03466335f, -0.05048024f, -0.02998509f, 0.11821713f, -0.12028213f, -0.02984157f, 0.03403626f, 
    -0.05407281f, 0.13596615f, 0.15518293f, -0.18344489f, 0.34559199f, 0.15764672f, -0.05093322f, -0.02764301f, 
    -0.16386622f, 0.23342840f, -0.21767169f, 0.16272669f, 0.05616104f, 0.33825186f, -0.00457428f, -0.01785383f, 
    0.07316381f, 0.03318486f, -0.19957829f, -0.08584595f, 0.01675464f, -0.10501911f, -0.06594726f, 0.07340433f, 
    0.15428501f, 0.08031391f, 0.02474307f, 0.01977760f, 0.01590849f, -0.02859631f, 0.06842246f, -0.08762555f, 
    -0.03399525f, -0.00060599f, -0.01795323f, 0.07292183f, 0.02343557f, -0.05466499f, -0.05322409f, 0.06332621f, 
    -0.00855991f, 0.03420500f, -0.08818981f, -0.00366893f, -0.02903678f, -0.01705999f, -0.08994266f, 0.04590323f, 
    0.07024294f, -0.06676020f, -0.09492920f, 0.06640352f, 0.06011356f, -0.08402401f, 0.02788398f, -0.01340111f, 
    0.03475536f, -0.02056404f, 0.02769960f, -0.08108674f, -0.02327348f, -0.01505027f, -0.02627950f, 0.01798726f, 
    -0.08054839f, -0.08236623f, -0.05701545f, 0.04105002f, -0.08254807f, 0.07432182f, 0.02516077f, -0.00697891f, 
    -0.01149520f, 0.00779309f, -0.01104574f, -0.05922532f, -0.01996796f, 0.01367519f, 0.05075358f, -0.05073590f, 
    0.06596239f, -0.05904138f, 0.01799527f, 0.04485356f, -0.04170037f, -0.04103061f, 0.07109903f, -0.02255131f, 
    -0.01525220f, -0.01244888f, -0.02599672f, -0.03945582f, -0.02232693f, 0.02965776f, -0.00916457f, 0.03897238f, 
    0.04286529f, -0.07579304f, 0.04287968f, -0.00039804f, -0.01631022f, 0.01746446f, -0.02983876f, 0.05760499f, 
    0.04682060f, 0.08486024f, 0.07791666f, 0.01196061f, 0.05508718f, -0.06037695f, -0.07904562f, -0.08717922f, 
    -0.03836978f, 0.01151412f, -0.09531518f, -0.04491049f, 0.02705240f, 0.05787754f, -0.05128502f, 0.04733741f, 
    0.00565438f, -0.01559963f, 0.05636589f, 0.01976280f, 0.05288776f, -0.07731536f, -0.04077177f, 0.00251925f, 
    0.04470026f, 0.03595568f, -0.09529784f, -0.03976234f, -0.10225270f, -0.05221346f, -0.08707143f, 0.07065560f, 
    0.00232411f, -0.03402253f, 0.06699432f, 0.04757079f, -0.02933654f, 0.06376405f, 0.04199951f, -0.03164257f, 
    -0.02939919f, -0.08370966f, 0.08191082f, -0.07752637f, -0.05418510f, -0.08422577f, -0.00187736f, 0.02286982f, 
    0.02571854f, -0.06793106f, -0.07115591f, 0.08147762f, -0.07115091f, -0.03910797f, 0.01261975f, -0.02759335f, 
    0.04922775f, -0.07058680f, -0.03188446f, -0.07158411f, 0.02132183f, 0.02119447f, 0.01130323f, -0.00205166f, 
    -0.03321195f, -0.01082172f, -0.06716042f, 0.05900003f, 0.04536945f, 0.03445981f, -0.04347017f, -0.05130217f, 
    -0.04195759f, -0.05198734f, -0.09142039f, 0.04934411f, -0.02459406f, -0.03359964f, 0.02130225f, -0.00345951f, 
    -0.05257200f, 0.06713293f, -0.04564026f, 0.04745608f, -0.09542871f, -0.09014089f, -0.04688729f, 0.00825718f, 
    -0.07112984f, -0.03812841f, -0.06063724f, 0.02951112f, 0.00638168f, 0.00257944f, -0.00322886f, 0.01385806f, 
    -0.00927487f, 0.08354268f, -0.03464803f, -0.05589229f, -0.02691943f, -0.06503872f, -0.06081272f, 0.05876218f, 
    0.07627732f, -0.00492310f, -0.09072731f, -0.07441135f, 0.00750665f, -0.01010072f, -0.05501457f, 0.06356287f, 
    0.06393149f, -0.09222154f, -0.05395883f, -0.03897507f, 0.01405202f, 0.06329987f, -0.03207261f, -0.01120266f, 
    0.07276692f, -0.01484578f, -0.02691459f, 0.05726307f, -0.06768198f, -0.07536072f, -0.08956831f, -0.04061290f, 
    0.00253839f, -0.01383878f, 0.04911005f, 0.01475032f, -0.00248624f, 0.03073128f, 0.00388643f, 0.04184043f, 
    0.01496635f, -0.05266811f, 0.00885258f, 0.06199500f, -0.02553640f, -0.01107344f, -0.03825239f, -0.06449121f, 
    0.03844962f, -0.07180447f, -0.05973993f, -0.01497488f, -0.01765780f, -0.08322661f, 0.05531891f, 0.02875075f, 
    0.03862514f, -0.07857929f, -0.00289222f, -0.01122737f, -0.01797916f, -0.04505469f, 0.03408867f, 0.05189216f, 
    -0.07707836f, -0.04546724f, -0.05002201f, 0.03121813f, 0.00854390f, -0.05781001f, 0.08000612f, 0.03058409f, 
    0.03303332f, -0.04644632f, 0.02037098f, -0.02785663f, -0.07114901f, -0.06854391f, 0.06559499f, -0.10086056f, 
    0.00193668f, 0.00168732f, -0.05947676f, -0.09328983f, 0.06460877f, -0.10465995f, 0.07820307f, 0.00415087f, 
    -0.03759497f, -0.19201833f, 0.15136985f, 0.04771451f, 0.38848954f, -0.04868864f, -0.02305479f, 0.09407776f, 
    -0.27022064f, 0.18028995f, -0.20614296f, 0.75117785f, -0.20041753f, 0.15668000f, -0.10204972f, 0.34849378f, 
    0.14554274f, 0.00106739f, -0.46627176f, -0.17265689f, -0.18939866f, 0.22844021f, 0.42138061f, -0.01106095f, 
    0.07626434f, -0.20196483f, -0.05352511f, 0.03074373f, -0.17351604f, -0.28755286f, 0.20198952f, 0.35851589f, 
    -0.25906575f, 0.35241646f, 0.02666949f, 0.05441378f, 0.15028165f, -0.16884743f, -0.20341933f, 0.07160092f, 
    0.10693401f, 0.04690119f, 0.13112944f, 0.10708518f, 0.17489842f, 0.08606922f, 0.11403764f, 0.05601597f, 
    -0.34362331f, 0.23303406f, 0.18233728f, -0.03954112f, 0.02686325f, -0.04125610f, 0.14224932f, 0.28929725f, 
    0.19980896f, -0.14177299f, 0.25942066f, 0.05663025f, -0.38383806f, 0.11287731f, -0.05130288f, 0.20441571f, 
    -0.29557911f, -0.04200778f, -0.22311881f, -0.26877382f, 0.03287439f, -0.58575219f, 0.04891431f, -0.30356857f, 
    -0.08845630f, 0.23348285f, 0.09651493f, 0.16221173f, 0.06489348f, -0.04363396f, 0.30133927f, -0.00461828f, 
    0.09820060f, 0.07470424f, 0.24040112f, -0.04125340f, -0.28788686f, 0.02096244f, -0.01672032f, -0.00951361f, 
    -0.18272695f, 0.02628822f, -0.00262606f, 0.25497386f, 0.37158683f, -0.30689064f, -0.23906472f, 0.00639794f, 
    0.00594723f, 0.10152145f, 0.07105418f, -0.50187165f, 0.50851488f, -0.07140591f, 0.11224572f, -0.05893860f, 
    -0.06789924f, 0.32153448f, -0.10411905f, 0.22345698f, 0.19607857f, -0.12395462f, -0.11920516f, 0.12394094f, 
    -0.08281212f, -0.03146282f, 0.15653604f, -0.31316704f, 0.07625579f, -0.12090360f, 0.09700572f, 0.11268044f, 
    -0.11133973f, -0.16278696f, 0.13633016f, 0.10453257f, -0.45420429f, 0.14021719f, 0.08341751f, -0.47190788f, 
    -0.40373829f, -0.04055067f, 0.17271478f, 0.02783432f, 0.22760317f, -0.02375315f, -0.05586994f, -0.02228222f, 
    0.04395661f, 0.11358303f, -0.10742586f, -0.76661873f, 0.54564911f, 0.28532735f, 0.06233803f, -0.37013331f, 
    -0.01638594f, 0.15736631f, 0.21061017f, -0.22608647f, -0.01597380f, 0.22388999f, -0.34412500f, 0.07065567f, 
    0.15354283f, -0.15632285f, 0.04864786f, 0.00878651f, 0.13389003f, -0.07738701f, 0.05667015f, 0.10847984f, 
    0.27481425f, -0.06750181f, 0.01796737f, -0.16691761f, 0.10902211f, 0.06887715f, -0.12178143f, 0.09768922f, 
    0.08242141f, 0.01688534f, 0.05170563f, -0.05190812f, -0.09177817f, -0.24139304f, 0.05023206f, 0.10213454f, 
    0.18434517f, -0.00269008f, -0.22466429f, 0.34141254f, 0.10765319f, -0.03791719f, 0.03326258f, -0.03446105f, 
    0.12680481f, -0.16528735f, 0.17255478f, -0.04820831f, -0.12250049f, -0.20359395f, -0.16158390f, 0.13003935f, 
    -0.44023106f, -0.06400237f, -0.02070166f, -0.00969977f, 0.02793225f, 0.04074785f, 0.11407183f, 0.43435153f, 
    0.26478761f, 0.01165253f, 0.20792088f, 0.03032693f, -0.08943584f, -0.05248277f, -0.00982430f, -0.36261329f, 
    -0.26522481f, -0.10862250f, 0.10380390f, -0.00752337f, -0.00902584f, -0.01682270f, 0.19035333f, -0.07043488f, 
    -0.30158508f, 0.04244376f, -0.07771678f, -0.34085134f, -0.20144193f, -0.03511331f, 0.18129499f, -0.18542528f, 
    -0.09493791f, 0.03928554f, 0.08916248f, -0.11768710f, -0.15911782f, 0.30009210f, -0.06698371f, -0.00835293f, 
    -0.07979121f, 0.41476178f, 0.39735189f, -0.15252307f, -0.19133243f, -0.15399574f, 0.02185650f, 0.05127458f, 
    -0.12270930f, -0.23696092f, -0.21832582f, -0.13591738f, -0.29815426f, 0.03530757f, -0.09549733f, 0.06138043f, 
    -0.02561447f, 0.46406472f, 0.20871724f, 0.16558048f, -0.10378751f, -0.41832694f, -0.01634752f, 0.06603348f, 
    -0.05923264f, -0.05057130f, -0.07933658f, 0.03384274f, -0.01661849f, -0.07181825f, -0.06363932f, -0.08063844f, 
    0.08488103f, -0.02712868f, -0.06316233f, -0.02554963f, 0.03110295f, -0.04979415f, 0.01798902f, -0.05993513f, 
    0.06596793f, 0.02939354f, -0.08961064f, 0.05680663f, -0.02471471f, 0.01763548f, -0.10527633f, -0.03483858f, 
    -0.01800558f, 0.00527885f, 0.08619118f, -0.00054712f, -0.03015901f, -0.06232315f, 0.04000357f, 0.01967688f, 
    0.06294806f, 0.04444788f, -0.09740927f, -0.08607810f, 0.06306462f, 0.00066736f, 0.03696830f, -0.07747725f, 
    -0.02939132f, -0.08695447f, -0.10306152f, -0.07471116f, -0.08812806f, -0.06823733f, -0.02219268f, 0.03959528f, 
    -0.05547633f, -0.05264955f, 0.01939746f, -0.08666657f, -0.01176039f, -0.10254226f, -0.02971044f, -0.03265664f, 
    0.00927719f, -0.05495318f, 0.00078730f, 0.03060006f, 0.04447304f, -0.00141516f, -0.09775552f, -0.01680763f, 
    -0.03187628f, -0.05160758f, -0.03949843f, 0.00818467f, -0.00718009f, -0.08716738f, 0.01593561f, -0.01366696f, 
    0.05824406f, 0.08049756f, 0.01097881f, -0.05596637f, 0.03377181f, 0.00001844f, -0.02432598f, 0.06140940f, 
    -0.01562998f, -0.04232404f, 0.01295354f, -0.05867335f, 0.03575340f, 0.04372783f, 0.05099464f, -0.04235586f, 
    -0.06142715f, 0.02586037f, 0.01891328f, -0.05843677f, 0.05318869f, -0.00702460f, -0.03883494f, 0.03157070f, 
    -0.03389662f, -0.05683458f, 0.01694777f, -0.00658116f, -0.03403983f, -0.10132106f, -0.08065049f, -0.07670219f, 
    -0.06856243f, -0.05258159f, -0.07352813f, 0.05362463f, -0.09022570f, 0.03331616f, -0.00260161f, 0.03175247f, 
    -0.04525109f, -0.08461522f, -0.03847482f, 0.03454744f, 0.05480847f, 0.00311114f, -0.06820523f, -0.02070661f, 
    0.01153251f, 0.03261004f, -0.05921292f, -0.06903396f, 0.05345556f, -0.07967997f, -0.03159982f, 0.05691625f, 
    0.02937988f, -0.00325809f, 0.03304893f, 0.08030586f, 0.05687304f, 0.08365171f, 0.02440685f, -0.05128866f, 
    -0.02894418f, -0.08613753f, -0.05075656f, 0.01397868f, -0.06558255f, -0.00792843f, -0.06038258f, -0.02637899f, 
    -0.07981919f, -0.07184926f, -0.06657611f, -0.07539094f, -0.05710126f, 0.03699031f, -0.03801147f, 0.03134174f, 
    -0.04894213f, -0.04593139f, -0.00949917f, 0.03982049f, 0.04415801f, 0.07538840f, 0.06523209f, -0.06695210f, 
    -0.02140023f, -0.01845893f, -0.06178910f, 0.08020712f, -0.05035441f, -0.00799158f, -0.02919676f, -0.07408584f, 
    0.06840908f, 0.00703330f, -0.03227020f, -0.04584026f, -0.01316009f, -0.00931655f, -0.05688391f, 0.05324792f, 
    0.01448091f, -0.06310052f, 0.06549982f, -0.06564802f, 0.02308903f, -0.06381601f, -0.04543647f, 0.08297490f, 
    -0.03534226f, -0.07047696f, -0.03525737f, -0.08473115f, -0.01584885f, 0.01727831f, 0.08603647f, 0.00303971f, 
    -0.04921805f, -0.07754044f, -0.04455693f, -0.01911983f, -0.08481460f, 0.08804738f, 0.06193926f, -0.00549691f, 
    0.09126425f, 0.04257247f, 0.03245413f, -0.04762562f, 0.03750727f, -0.02158167f, -0.05876232f, -0.07727765f, 
    0.05360073f, -0.01662144f, -0.07072470f, 0.06064058f, 0.07929372f, -0.05136978f, 0.02314378f, 0.00036602f, 
    0.02836842f, -0.02502654f, 0.02193855f, 0.01293149f, -0.05502480f, 0.04418828f, -0.04953291f, -0.04241214f, 
    0.02224635f, 0.07060264f, 0.07987552f, 0.06793210f, -0.02578863f, -0.06618293f, -0.04235089f, -0.03469604f, 
    -0.00119875f, -0.04832601f, -0.08054836f, -0.05916020f, 0.02870304f, 0.06451447f, 0.06927130f, -0.02284959f, 
    -0.06090037f, -0.01671873f, -0.02302151f, 0.00323480f, -0.04298773f, -0.05412532f, -0.09213982f, -0.09912361f, 
    -0.02168398f, 0.00424865f, 0.03098258f, -0.08865081f, -0.06985186f, -0.05271086f, 0.03801110f, -0.01344689f, 
    -0.03199346f, 0.03527944f, -0.00828224f, -0.06040405f, 0.04351721f, -0.00068709f, -0.03614095f, -0.07286158f, 
    0.03571628f, 0.07065663f, -0.00420043f, -0.09443408f, -0.06394051f, 0.06312887f, 0.00530626f, 0.04259827f, 
    -0.04212566f, 0.05457186f, -0.14079890f, -0.07395867f, -0.07712591f, -0.06543222f, -0.09841729f, 0.01505879f, 
    -0.09104629f, 0.01374114f, 0.00543117f, -0.01183807f, -0.13369831f, 0.04510277f, -0.06635092f, 0.04725470f, 
    -0.05240515f, -0.02484632f, 0.02033549f, 0.00820258f, -0.05742099f, -0.11163645f, -0.04936847f, -0.01032198f, 
    -0.06332285f, 0.07125637f, 0.01822134f, -0.10854756f, 0.01345371f, -0.11394630f, -0.10259721f, 0.03692320f, 
    -0.09093948f, 0.00778351f, -0.04330603f, -0.01618505f, -0.05064964f, 0.06610686f, 0.00011200f, 0.00559738f, 
    -0.06516263f, -0.01085997f, -0.08443028f, 0.03213938f, -0.04785307f, -0.08602045f, 0.00921294f, -0.01574553f, 
    0.01658156f, -0.02781208f, -0.10283123f, -0.12232617f, -0.05947595f, -0.06319644f, -0.00803885f, -0.06176114f, 
    -0.04382073f, -0.06199902f, -0.07045236f, -0.12107071f, -0.01606161f, -0.04949136f, 0.00023555f, -0.11663076f, 
    0.01741278f, -0.01864744f, -0.08926725f, -0.00734872f, -0.06060211f, -0.09407888f, -0.07871056f, -0.01657016f, 
    -0.05552914f, -0.06610613f, 0.02883077f, 0.03846816f, 0.03419406f, -0.02740889f, -0.10502463f, -0.01706213f, 
    -0.03060060f, -0.02350698f, -0.11041074f, -0.09577356f, 0.03742747f, -0.06421319f, -0.10425062f, 0.05151639f, 
    0.00686291f, -0.10833618f, 0.05360372f, 0.00931872f, -0.04496375f, 0.01585378f, -0.03902983f, 0.03468810f, 
    -0.08745860f, -0.03318586f, 0.04453606f, -0.00643982f, -0.02032222f, -0.04634266f, -0.08904927f, -0.04694052f, 
    -0.01520139f, 0.00091722f, 0.01253250f, 0.03945297f, 0.01875992f, -0.05297481f, 0.04391003f, -0.09707946f, 
    0.51705086f, 0.15961258f, -0.06734373f, 0.06820562f, -0.05869398f, -0.00614711f, -0.01557881f, -0.06181786f, 
    0.01969298f, -0.06269825f, 0.39172107f, -0.07988641f, 0.24588551f, -0.23353033f, 0.01337888f, 0.04778543f, 
    -0.02924503f, 0.09193957f, -0.04185548f, 0.09179434f, -0.05439607f, -0.08170033f, 0.21516235f, -0.04418926f, 
    0.07550400f, 0.07075422f, 0.01174392f, -0.03447495f, 0.05657969f, -0.01990829f, 0.03951214f, -0.14251599f, 
    -0.19201490f, 0.16404857f, -0.10442640f, -0.08706433f, 0.08216587f, 0.15499581f, 0.11131518f, -0.01024851f, 
    0.20250224f, -0.00925039f, -0.10074089f, 0.03151571f, 0.06514923f, 0.00106146f, 0.04698771f, -0.07585123f, 
    -0.02489209f, 0.11655603f, 0.06318305f, -0.13119982f, 0.17986856f, 0.11738634f, 0.04363942f, 0.00834958f, 
    -0.01685477f, 0.09307341f, 0.00587945f, -0.10238010f, 0.36773831f, 0.08976408f, 0.06022643f, -0.02791470f, 
    -0.28368554f, -0.04430094f, 0.06878084f, -0.09762405f, -0.08667137f, -0.00412327f, -0.15592515f, 0.12886785f, 
    -0.10865236f, 0.13973415f, 0.02648592f, -0.00413996f, -0.02629974f, -0.08094028f, -0.04058097f, 0.11817340f, 
    0.07811174f, 0.22706215f, -0.08523205f, 0.00604457f, 0.21212423f, 0.04236724f, -0.11276174f, -0.04764801f, 
    -0.29371241f, -0.07369038f, 0.07995490f, -0.09895314f, -0.32266545f, 0.17456767f, 0.07642916f, 0.09950503f, 
    0.07494894f, -0.17643964f, 0.10272339f, -0.11519241f, -0.25344473f, -0.02252545f, 0.05809184f, 0.00393110f, 
    0.23812327f, 0.00525051f, 0.22905713f, -0.01165956f, 0.07029048f, 0.15079115f, 0.13571241f, 0.14225419f, 
    0.22954410f, -0.02173797f, 0.07195997f, -0.00121662f, 0.17718792f, 0.13382357f, 0.09469901f, 0.02758906f, 
    0.06416919f, -0.09599547f, 0.14408240f, -0.04044027f, -0.05685008f, -0.13869523f, 0.04581738f, -0.03419800f, 
    0.52152056f, 0.24077065f, -0.02369969f, 0.04161641f, -0.12664178f, 0.00254001f, 0.06980102f, 0.03676297f, 
    0.10081601f, 0.38469383f, 0.43078306f, -0.05376022f, 0.48173425f, -0.08494060f, 0.16159427f, -0.18552332f, 
    -0.04127029f, 0.05196472f, 0.00304110f, -0.00025860f, -0.11353658f, -0.08596224f, 0.41438067f, 0.02002861f, 
    0.12867419f, -0.03570251f, -0.08642129f, -0.03314237f, 0.04929861f, 0.15966435f, 0.05001020f, 0.00875050f, 
    -0.45463219f, 0.11785752f, -0.20592634f, -0.09815029f, 0.18934245f, 0.06169634f, -0.08119611f, -0.12708063f, 
    -0.10666653f, 0.02488481f, -0.08514385f, -0.05929353f, 0.07125120f, -0.01619339f, -0.12956938f, 0.03728509f, 
    -0.07759942f, -0.04779009f, 0.00375915f, -0.00725665f, 0.02730831f, 0.24550115f, 0.15024221f, 0.07696390f, 
    -0.04066522f, 0.02174351f, 0.06454919f, -0.07929415f, 0.51258665f, 0.04498998f, -0.07703759f, 0.02518295f, 
    -0.14152671f, 0.01601144f, 0.06916945f, -0.09001991f, -0.04583804f, -0.05252698f, -0.07225864f, 0.15482460f, 
    -0.10059794f, -0.11572792f, 0.00039306f, -0.05391027f, 0.00305344f, 0.03531604f, 0.13450013f, -0.06708869f, 
    0.23505114f, 0.17182212f, -0.04869090f, -0.00111860f, 0.17943276f, -0.03120518f, -0.07211626f, 0.14938845f, 
    -0.52686357f, -0.09186942f, 0.25318813f, -0.07596716f, -0.38517123f, -0.05941978f, -0.00000746f, 0.26128119f, 
    0.10684619f, -0.06097856f, 0.16807503f, 0.05719463f, -0.02553268f, -0.06141517f, -0.03866718f, -0.00733499f, 
    0.34176299f, -0.11414520f, 0.15996726f, -0.05982850f, -0.03252816f, 0.21557605f, 0.27536225f, -0.01911357f, 
    0.21299785f, 0.11646377f, -0.09506834f, 0.06670856f, 0.15969557f, 0.30393282f, -0.08650467f, 0.32057226f, 
    0.16984805f, -0.05198715f, 0.02802982f, -0.08434489f, 0.25934526f, -0.18535997f, 0.03298855f, 0.27417856f, 
    0.03534199f, 0.01601830f, -0.10360403f, -0.10103812f, -0.00848523f, 0.01870501f, -0.06656268f, 0.00876883f, 
    -0.06910692f, -0.05460657f, 0.05088901f, -0.05482599f, 0.07761872f, -0.04301498f, -0.09415770f, 0.05155831f, 
    -0.09874329f, -0.00601564f, 0.03334309f, -0.09768223f, 0.00112065f, 0.01386891f, -0.08082359f, -0.04115256f, 
    -0.03409055f, 0.04099789f, -0.01489808f, -0.04827059f, -0.00473536f, -0.07893494f, -0.06353729f, -0.00187922f, 
    0.03648816f, -0.07350553f, -0.04792530f, 0.03928771f, 0.03942893f, 0.07021426f, 0.04162094f, 0.04832543f, 
    -0.02278937f, 0.03355282f, 0.00102547f, -0.08861332f, -0.02039428f, 0.05098766f, -0.10873697f, -0.02120184f, 
    -0.09545211f, 0.03043807f, 0.03894030f, -0.07874492f, -0.06722698f, -0.03901819f, 0.05713407f, 0.02024842f, 
    -0.08249437f, -0.10451043f, -0.04584311f, 0.03670139f, -0.02160262f, -0.03370243f, -0.05596397f, -0.05725377f, 
    -0.07048737f, 0.00329510f, -0.07501650f, -0.01329035f, 0.08387032f, -0.05904647f, 0.00729322f, 0.02788912f, 
    -0.06046946f, -0.09771411f, 0.01294655f, 0.05121171f, 0.01638657f, 0.02968016f, -0.03189652f, -0.02722213f, 
    -0.02614598f, 0.02890718f, -0.00686050f, -0.01326135f, -0.02567171f, -0.03229643f, -0.08421272f, -0.05560276f, 
    0.02814752f, 0.03614173f, -0.00218518f, 0.00350783f, 0.01925026f, -0.09873929f, -0.05396528f, 0.02960787f, 
    0.00620288f, 0.07316955f, -0.05890013f, 0.02311272f, 0.02746733f, -0.02117478f, -0.00864526f, -0.06582454f, 
    -0.09072603f, -0.03381348f, -0.09203562f, 0.05586798f, -0.05074935f, 0.06493069f, -0.00232734f, 0.01380959f, 
    -0.08994512f, 0.01874218f, -0.10568406f, 0.00255295f, -0.09030176f, -0.04837439f, 0.01852833f, 0.06086341f, 
    0.00485650f, -0.03656340f, 0.05315001f, 0.03527718f, 0.03043260f, -0.07595557f, 0.06668298f, -0.05594201f, 
    0.31633294f, 0.19993016f, 0.13984315f, -0.05731689f, 0.29354641f, -0.07772106f, 0.03693465f, -0.05309646f, 
    0.08604107f, 0.02560258f, 0.09597557f, 0.26880607f, -0.17897432f, -0.01375093f, 0.06987888f, 0.11277284f, 
    -0.05221630f, -0.07934154f, -0.04608836f, -0.06376156f, -0.10917858f, 0.02533809f, 0.07203237f, -0.04801675f, 
    0.15694478f, -0.09136475f, -0.06496534f, -0.05690677f, -0.03654844f, -0.12599191f, 0.06482451f, -0.16190839f, 
    -0.09233603f, 0.15624952f, 0.09390260f, 0.52018088f, 0.08031496f, 0.36412063f, -0.02887232f, 0.16211715f, 
    -0.20268303f, 0.07025895f, -0.13156436f, 0.01377638f, -0.11221671f, 0.09039263f, -0.21454068f, -0.29527479f, 
    -0.11325209f, 0.36771017f, 0.08539947f, 0.19478287f, 0.15831998f, -0.13392954f, -0.18839480f, 0.50688189f, 
    0.05533371f, 0.14893696f, 0.26950806f, 0.12240100f, 0.06484435f, 0.02555604f, 0.10256463f, -0.04503665f, 
    -0.22116175f, -0.08666626f, -0.17861030f, -0.13251168f, -0.06421918f, 0.06110155f, 0.15877257f, -0.07313283f, 
    0.19492427f, -0.00495532f, -0.03923573f, -0.20629893f, 0.02849481f, 0.04858822f, 0.37894407f, -0.00116164f, 
    0.16949937f, 0.20762125f, 0.10059050f, 0.05865883f, 0.00733990f, 0.19456975f, 0.05628601f, 0.08148313f, 
    -0.10479175f, -0.05792985f, 0.03660962f, 0.11671488f, 0.16804992f, -0.02650199f, -0.13765384f, -0.19244815f, 
    -0.18846053f, -0.15351693f, 0.06824526f, -0.28549588f, 0.25117302f, 0.05150067f, -0.18699767f, -0.14385211f, 
    0.01194660f, 0.30259040f, 0.06000659f, 0.12809576f, 0.13814527f, 0.18920408f, -0.01058513f, 0.07881282f, 
    0.26159856f, -0.12572369f, 0.19197850f, -0.03460135f, -0.03442878f, -0.12167473f, 0.13299294f, 0.25582975f, 
    -0.12846296f, 0.06689673f, -0.33947694f, 0.44012177f, -0.10281315f, -0.29720250f, -0.06148678f, 0.08280800f, 
    -0.14806955f, 0.07025100f, 0.15443273f, 0.09358724f, 0.22015126f, -0.26668036f, -0.07682218f, 0.04333401f, 
    0.07357889f, 0.08229765f, 0.03361976f, -0.34641004f, 0.50694466f, 0.38269284f, -0.22451766f, -0.25055996f, 
    -0.01595764f, 0.05439366f, 0.02723096f, -0.45638943f, -0.40139616f, 0.08522212f, -0.13831824f, -0.04103420f, 
    0.03554491f, -0.11407885f, -0.03881146f, -0.08064942f, -0.12665869f, 0.03200084f, 0.15174419f, 0.26828557f, 
    -0.08665109f, -0.02995121f, -0.07206441f, -0.36596006f, 0.11590710f, 0.14592621f, -0.27332711f, -0.10006212f, 
    0.16558272f, -0.01478482f, 0.12079658f, 0.07421000f, 0.00409549f, -0.27566189f, 0.19005759f, 0.08199660f, 
    0.10246092f, -0.20616841f, -0.58829057f, 0.09071878f, -0.25351936f, 0.09550270f, 0.15551691f, 0.12391832f, 
    0.08688716f, -0.15541290f, 0.25503990f, 0.09473857f, -0.13710573f, -0.11745798f, -0.19304065f, 0.06656121f, 
    -0.43394777f, 0.04988231f, -0.01045026f, 0.16108187f, -0.01095061f, -0.43020579f, 0.09173330f, 0.30763093f, 
    0.25327757f, 0.06810894f, 0.03290412f, 0.11581555f, 0.05020439f, -0.08452584f, 0.41116929f, -0.55998516f, 
    -0.35575607f, -0.03085193f, 0.03362870f, 0.05375174f, 0.01948402f, -0.05405779f, -0.33165511f, -0.25429347f, 
    -0.20479538f, 0.05183154f, -0.02192488f, -0.24378449f, -0.32726637f, -0.06966056f, 0.07403830f, 0.05687223f, 
    -0.05566366f, 0.03288205f, -0.03059615f, -0.20748663f, 0.46282068f, 0.23848677f, -0.04459670f, 0.23451009f, 
    -0.05529213f, 0.61371899f, -0.14473784f, -0.22817756f, -0.21051383f, -0.39757204f, 0.02895098f, 0.09996811f, 
    -0.30889553f, 0.07743037f, -0.29710254f, -0.40992302f, -0.15714796f, -0.05612316f, -0.10783871f, 0.08143415f, 
    0.12246851f, 0.15019031f, 0.36916769f, 0.03661210f, -0.01104275f, -0.38159910f, -0.08970170f, -0.15130955f, 
    -0.18429516f, -0.27996153f, -0.00068646f, 0.22010496f, 0.13085185f, 0.17800418f, 0.00427667f, 0.04880654f, 
    -0.06457482f, -0.62730932f, -0.12906936f, 0.47012430f, -0.21612935f, -0.08630078f, -0.11295406f, 0.16492456f, 
    0.15883918f, -0.06761555f, -0.00880521f, -0.02036382f, 0.01107374f, 0.02813199f, 0.36999747f, 0.01359004f, 
    -0.09505538f, -0.00202892f, 0.01328078f, 0.08163361f, 0.04675914f, -0.02775492f, 0.06682180f, -0.00523967f, 
    0.00418940f, 0.16232710f, 0.02577065f, -0.27416745f, -0.14425620f, -0.29327625f, 0.13565294f, 0.02946819f, 
    0.22575717f, -0.05211100f, 0.15269955f, 0.05702921f, 0.11256280f, 0.12397603f, 0.15778515f, 0.02866285f, 
    0.10905270f, 0.07795445f, 0.14492096f, -0.02796298f, 0.07502998f, -0.01797887f, 0.04371293f, -0.12050679f, 
    0.23124467f, -0.26301986f, -0.09217557f, 0.01673364f, -0.28359094f, 0.07750151f, -0.04382679f, 0.04096783f, 
    -0.03217144f, 0.00056699f, 0.05123032f, -0.02774806f, -0.02849249f, -0.01540314f, -0.06405771f, -0.02093565f, 
    -0.14552821f, 0.21343352f, -0.08108067f, 0.35562965f, 0.00741684f, -0.07847943f, -0.03820999f, -0.05498261f, 
    0.11995343f, -0.05149409f, 0.03873550f, -0.00748036f, -0.17994344f, -0.01910222f, 0.27447897f, 0.03408695f, 
    -0.01007860f, 0.00685166f, -0.10400470f, 0.08244814f, -0.06931294f, 0.02790010f, -0.04356573f, 0.02225750f, 
    0.15237170f, -0.00871755f, 0.10268759f, -0.05831362f, 0.10246207f, -0.07601093f, -0.00846828f, 0.16353175f, 
    -0.06825171f, 0.16439220f, -0.01326408f, 0.11329120f, 0.20021926f, -0.18264668f, -0.18504523f, -0.01447652f, 
    -0.18149409f, -0.04091559f, -0.02050332f, 0.11889853f, -0.00180992f, -0.15282515f, 0.03024460f, -0.10665206f, 
    0.01161615f, -0.05722902f, -0.11706455f, 0.07124152f, -0.13458297f, 0.17820528f, 0.01070228f, -0.13033405f, 
    0.16642828f, -0.11580651f, 0.19663759f, 0.09142651f, 0.11840621f, -0.23269512f, 0.01774735f, -0.06423622f, 
    0.14076188f, 0.29052031f, 0.06553737f, 0.06054797f, -0.23478931f, -0.24278626f, -0.01877456f, -0.05079472f, 
    0.06455349f, -0.04010696f, -0.19515510f, -0.25278863f, -0.15987156f, -0.06543265f, -0.04715620f, 0.04644090f, 
    -0.13575566f, -0.07028705f, 0.06925510f, -0.07055061f, -0.19368128f, 0.15842183f, -0.09035634f, -0.14198250f, 
    0.02557283f, -0.02744258f, 0.02248279f, 0.14387143f, 0.16176149f, -0.27896225f, 0.11603245f, -0.11204316f, 
    0.23746952f, -0.00828154f, -0.07284416f, 0.09872821f, 0.18641850f, 0.25398457f, 0.20547581f, -0.01979464f, 
    0.01347324f, 0.03323267f, 0.13504814f, -0.28560570f, 0.18919647f, 0.07616600f, 0.21305864f, -0.14826740f, 
    0.05991074f, -0.11480875f, -0.32369658f, -0.12226722f, 0.22255205f, -0.02764839f, -0.12192751f, -0.00318296f, 
    -0.01314195f, -0.06091022f, 0.22888482f, -0.15061569f, 0.05586917f, 0.08475660f, -0.22296344f, -0.02940482f, 
    -0.46085364f, 0.20744027f, 0.03766789f, 0.15132941f, 0.02050536f, 0.03156624f, -0.05377096f, -0.28690919f, 
    -0.44513029f, 0.23505580f, 0.00169553f, -0.10371663f, 0.04939044f, 0.09971365f, 0.01316547f, -0.03112104f, 
    0.24518634f, -0.00469854f, 0.13840292f, 0.09540281f, -0.10602594f, 0.12239807f, -0.07878104f, -0.07229339f, 
    0.19848900f, 0.05214877f, 0.01256456f, 0.39180943f, -0.09304342f, -0.05274705f, 0.07000106f, 0.07249659f, 
    -0.02477345f, -0.31147701f, -0.29417318f, 0.09657264f, 0.17133415f, -0.43331501f, 0.07671370f, -0.03154271f, 
    0.07180257f, 0.07590733f, 0.20645022f, 0.10449865f, 0.07743069f, 0.02373908f, 0.07567406f, 0.05063486f, 
    0.01506827f, -0.41619590f, -0.08866554f, 0.10670825f, -0.09796873f, 0.24095753f, 0.08148004f, 0.05786295f, 
    0.03061915f, -0.04245849f, -0.06665289f, -0.00163497f, 0.01109871f, -0.04752690f, 0.04180262f, 0.06528652f, 
    0.07259064f, -0.03832202f, 0.03521103f, 0.06345209f, -0.06720433f, 0.04785270f, 0.02116233f, 0.01050476f, 
    -0.06493936f, 0.04180520f, -0.00633764f, -0.06942117f, -0.04444180f, -0.01186937f, -0.01649565f, -0.00883849f, 
    0.02858089f, -0.03678979f, 0.08509097f, 0.03389807f, 0.02736827f, 0.03608972f, -0.04590460f, 0.04390168f, 
    -0.05393051f, -0.02315805f, 0.02799748f, 0.04731147f, -0.06983227f, -0.00163871f, -0.06837969f, -0.09543449f, 
    -0.05301080f, 0.02999116f, 0.00314734f, -0.03422621f, -0.05321061f, -0.00774996f, -0.06066298f, -0.01907555f, 
    0.01171184f, 0.01915362f, -0.06063878f, 0.05948696f, 0.07136878f, -0.00628605f, -0.06738749f, 0.01854144f, 
    -0.08037262f, -0.04932434f, -0.02648121f, 0.07187986f, 0.01517814f, -0.07697588f, 0.05719389f, 0.05555663f, 
    0.07155991f, 0.05915078f, -0.08727138f, 0.00132974f, 0.07269788f, 0.05311276f, 0.00248982f, -0.09165210f, 
    -0.06060433f, -0.01923037f, -0.06298435f, 0.01671757f, -0.03730271f, -0.03952301f, 0.01798487f, 0.05669212f, 
    0.01977617f, -0.05854791f, 0.04390365f, -0.02253185f, -0.00442980f, 0.03538848f, 0.04478640f, -0.06980063f, 
    0.04832765f, -0.05113025f, 0.00130508f, -0.09123073f, -0.08747157f, 0.02039650f, -0.05308436f, -0.09811005f, 
    -0.05371932f, 0.07772176f, 0.02853439f, 0.00212287f, 0.03691594f, -0.09369696f, -0.01717524f, -0.10192589f, 
    -0.03585679f, -0.03007701f, 0.04325736f, 0.03377510f, 0.01151616f, -0.04016946f, -0.07698894f, 0.02599704f, 
    0.01019682f, -0.05062489f, -0.00943163f, -0.03833216f, -0.09158370f, 0.03262386f, -0.07454299f, 0.00487104f, 
    -0.01846014f, -0.08261055f, -0.07683059f, 0.07267287f, 0.06557307f, -0.03119425f, -0.00055312f, -0.03863249f, 
    -0.05375703f, -0.05393372f, -0.03083800f, -0.06337188f, 0.00882242f, 0.01292318f, 0.07964995f, 0.07702789f, 
    -0.02443500f, 0.08270831f, -0.01744652f, -0.07580769f, 0.00810144f, -0.05266962f, -0.08417831f, -0.05690574f, 
    -0.08557455f, -0.01546068f, -0.01843064f, -0.09606183f, -0.05778651f, -0.02373760f, 0.01493192f, 0.03221864f, 
    0.00872664f, 0.06251005f, 0.02849259f, -0.04650843f, -0.10319895f, 0.04388369f, 0.01462337f, -0.03405516f, 
    -0.02950406f, 0.06905025f, -0.07901850f, -0.05430765f, 0.05854046f, 0.07894883f, -0.08768388f, 0.03900588f, 
    0.06718089f, 0.07128239f, 0.00322230f, -0.04259177f, -0.07507277f, -0.00735869f, 0.02173757f, 0.01632611f, 
    0.06343293f, -0.00380537f, 0.01026085f, -0.08315690f, 0.02495788f, -0.04320949f, -0.05578140f, -0.06217333f, 
    0.04471575f, -0.08134198f, -0.01408152f, 0.05611012f, 0.01608646f, -0.01567616f, -0.01750171f, 0.01366533f, 
    0.05844282f, -0.06384388f, 0.01181339f, -0.00958361f, -0.00461308f, 0.02563258f, -0.04316812f, 0.02108622f, 
    -0.08138955f, -0.02706224f, 0.00522256f, 0.06027935f, 0.06985761f, -0.02667156f, 0.00255784f, -0.06563807f, 
    0.00042284f, -0.07938663f, 0.00130519f, 0.00085687f, -0.09782308f, -0.06552367f, 0.03166108f, 0.00759967f, 
    0.07175369f, 0.04226683f, -0.03236514f, 0.06375697f, -0.05098766f, 0.09837134f, 0.02644185f, -0.01686766f, 
    -0.01113327f, -0.04465991f, -0.05698485f, 0.08187696f, -0.01474333f, -0.05115378f, 0.05515436f, -0.04566879f, 
    0.01080464f, -0.07844395f, -0.10355671f, 0.02597774f, 0.05383416f, -0.02807309f, 0.02619572f, -0.03210123f, 
    -0.09744810f, -0.07034255f, -0.07408172f, 0.03157877f, -0.07034657f, -0.01605621f, -0.05188144f, 0.02845434f, 
    0.09603108f, -0.08530287f, 0.00344892f, 0.02493625f, -0.08933231f, -0.10138972f, -0.06480157f, -0.03283904f, 
    -0.01887232f, -0.05660637f, 0.03484965f, 0.31145760f, 0.08468551f, 0.00793437f, 0.03343787f, 0.07424705f, 
    0.03435212f, -0.45847636f, 0.08678371f, 0.09016768f, -0.38062796f, -0.07576671f, -0.16239336f, 0.28980243f, 
    0.11026958f, -0.08910284f, -0.09723151f, -0.09891739f, -0.09294514f, 0.12889720f, 0.25529447f, 0.03108242f, 
    -0.16311531f, 0.11457831f, -0.07208391f, -0.02527176f, -0.05407049f, 0.17667753f, 0.15822810f, 0.01006409f, 
    0.24339741f, -0.08159816f, 0.08111707f, -0.24341695f, 0.02874897f, -0.07293066f, 0.12021586f, -0.05313085f, 
    0.24082962f, 0.05087909f, 0.32562870f, 0.22602628f, 0.15708347f, 0.16682647f, 0.42079452f, 0.05201310f, 
    -0.08117405f, 0.03035698f, -0.00038517f, -0.19178404f, 0.04290231f, 0.00362249f, 0.28676623f, -0.13370840f, 
    0.20206340f, -0.05906136f, -0.29656997f, 0.10950056f, -0.15294951f, 0.02577108f, 0.02830705f, 0.06822064f, 
    0.11339606f, 0.05584031f, 0.08551191f, -0.08295703f, -0.01837238f, -0.17128193f, -0.05083516f, -0.19829078f, 
    -0.07441038f, 0.21608493f, 0.05554689f, 0.41129673f, 0.08891483f, -0.02825919f, -0.00818433f, 0.00573633f, 
    0.09433423f, -0.13528788f, 0.17504339f, -0.04048957f, 0.02429381f, 0.06077676f, 0.03875615f, -0.03843077f, 
    0.04575869f, -0.03473964f, -0.00019983f, 0.15170780f, -0.06999440f, 0.00069679f, -0.10045559f, 0.13559689f, 
    0.29305449f, -0.21126682f, 0.05675179f, 0.08047289f, -0.04512480f, -0.17777535f, 0.28550899f, 0.17378503f, 
    0.08929588f, -0.21336876f, -0.33698839f, 0.11077455f, 0.09349518f, -0.12436305f, 0.05516648f, -0.00628440f, 
    -0.16164781f, 0.19583921f, 0.10232883f, 0.15303585f, 0.12930657f, 0.00188762f, 0.15294971f, -0.23675492f, 
    -0.01166086f, -0.23192938f, -0.19100268f, -0.00962726f, 0.00387919f, 0.28542307f, -0.05444080f, -0.32348216f, 
    -0.04501704f, 0.02254002f, 0.14041927f, 0.04335118f, -0.03269163f, -0.08732525f, -0.03020634f, -0.00132592f, 
    0.07958431f, 0.17562351f, -0.45881662f, -0.39774612f, 0.56646448f, 0.17350358f, -0.07294324f, -0.18955299f, 
    0.10060436f, 0.06858738f, -0.06389102f, -0.15334018f, 0.10459177f, 0.00518052f, -0.26271179f, 0.01672593f, 
    -0.01928181f, -0.12652518f, -0.07296765f, 0.10283718f, 0.06123973f, 0.15974559f, -0.27923769f, -0.01162564f, 
    0.09492823f, -0.01409705f, -0.02649572f, -0.54742801f, 0.04584642f, -0.10767182f, 0.01177670f, -0.04162185f, 
    0.36951864f, 0.05742208f, -0.00074521f, 0.14156152f, 0.12696193f, -0.11727613f, 0.08785786f, 0.04279154f, 
    -0.06821574f, -0.21352476f, -0.05347667f, -0.15563947f, -0.10374933f, 0.11228853f, 0.28033969f, -0.18216163f, 
    0.03909156f, 0.00352664f, -0.13230968f, -0.02754421f, 0.10309534f, -0.16086368f, -0.09917969f, 0.13960598f, 
    0.12098120f, -0.03423830f, 0.16001962f, -0.03464225f, -0.02496772f, 0.05875190f, -0.01019633f, 0.08205450f, 
    -0.07295892f, 0.18020931f, 0.03902415f, 0.26957974f, -0.09242700f, -0.07914302f, -0.05197909f, -0.11967668f, 
    -0.06862687f, 0.09612194f, -0.11555697f, 0.08278958f, 0.20349723f, 0.02064706f, -0.12432135f, 0.03818478f, 
    0.17087245f, 0.00296206f, -0.00254442f, -0.17350262f, 0.11179589f, 0.04988191f, 0.04696125f, 0.12970254f, 
    0.20217793f, -0.00577496f, 0.09266867f, 0.25713664f, 0.10388470f, 0.00584042f, 0.15480067f, 0.14687587f, 
    -0.01036775f, -0.29986393f, -0.18101330f, -0.09107395f, 0.02489507f, -0.42719907f, -0.07002068f, -0.30437714f, 
    -0.02262846f, 0.14858767f, 0.11064904f, 0.08739385f, 0.15638092f, 0.00957170f, 0.00134442f, 0.04484044f, 
    0.15550518f, -0.10036240f, 0.14166412f, 0.11088632f, 0.08705190f, 0.18413010f, 0.07523375f, 0.28365555f, 
    -0.02741283f, -0.05606902f, 0.02572944f, -0.00460739f, -0.05722011f, -0.09718166f, -0.00966826f, -0.00568766f, 
    0.02306245f, 0.02130219f, 0.08731644f, -0.07182897f, -0.05590415f, 0.06593180f, -0.00014678f, 0.06761213f, 
    0.00370300f, 0.01701188f, -0.09932797f, -0.06061052f, -0.01286981f, -0.04198685f, -0.08257908f, 0.08289230f, 
    -0.07011341f, 0.06579448f, 0.02792179f, -0.05557459f, 0.01243328f, -0.09520161f, 0.05943210f, -0.03262549f, 
    0.00387146f, 0.03084570f, 0.01625642f, -0.04082162f, 0.00709120f, -0.03748053f, -0.08740535f, -0.07752012f, 
    -0.06395561f, -0.08595730f, 0.04547246f, 0.05745346f, -0.05420248f, 0.05433146f, -0.09510880f, 0.00811574f, 
    0.00711281f, 0.04231787f, -0.01353326f, 0.04635935f, -0.03072930f, 0.05323409f, -0.03468855f, 0.00181189f, 
    -0.07221117f, 0.05295864f, 0.01397636f, -0.06969408f, 0.02858873f, -0.01090783f, -0.10532272f, -0.04154430f, 
    0.05361130f, -0.07256486f, -0.00312059f, 0.02374907f, 0.04394758f, -0.01744988f, 0.02166192f, -0.03014519f, 
    0.04336683f, 0.00993457f, -0.02209811f, 0.04715075f, 0.08652595f, 0.04622429f, -0.03170641f, -0.05997767f, 
    -0.06161771f, 0.06346902f, -0.04331014f, -0.06082245f, -0.05050737f, 0.04350747f, 0.03843481f, -0.08430327f, 
    -0.07757924f, -0.03220806f, -0.08628456f, 0.00049152f, 0.06536371f, 0.07265294f, -0.03622597f, -0.07915962f, 
    -0.06170681f, 0.04944785f, -0.01733736f, 0.07553772f, 0.06716131f, -0.05328117f, -0.03615879f, -0.09262485f, 
    -0.06299370f, -0.09588617f, -0.08474670f, -0.01800647f, -0.09216705f, 0.01345865f, -0.04329516f, -0.00464836f, 
    0.02935473f, -0.09575480f, -0.06313323f, -0.02292547f, -0.06253269f, -0.03692573f, 0.01148073f, -0.00038374f, 
    -0.02301166f, 0.05163466f, -0.03147362f, -0.07374924f, -0.00779999f, 0.00967804f, -0.02048219f, 0.06004005f, 
    0.10050268f, -0.14663780f, 0.14395621f, 0.13294113f, -0.00958630f, -0.10950062f, -0.03119273f, -0.02182758f, 
    0.05080851f, 0.12291605f, 0.16401653f, -0.44810611f, 0.12810932f, -0.10769640f, 0.02103861f, -0.06487507f, 
    -0.13680741f, 0.12066609f, -0.06357046f, -0.13351931f, -0.04038569f, -0.15787363f, -0.38332582f, -0.00769813f, 
    0.30999488f, 0.03241889f, -0.06959835f, 0.17596239f, -0.07950386f, 0.22438513f, -0.17454867f, -0.17003381f, 
    0.21590166f, -0.07060353f, 0.15395670f, 0.14451411f, 0.03301249f, -0.29607213f, 0.24359724f, -0.00148300f, 
    0.33499315f, -0.03738377f, -0.04447463f, -0.04438358f, 0.07236775f, 0.18581882f, 0.15525748f, 0.10696660f, 
    0.17575388f, -0.19181949f, -0.04445872f, -0.11836343f, 0.13850188f, 0.13615283f, 0.16318017f, 0.05069938f, 
    -0.09629041f, 0.01757128f, -0.19021025f, -0.08726446f, 0.32927716f, -0.10928477f, -0.00161541f, -0.00062137f, 
    -0.14309891f, 0.07050497f, 0.15806361f, -0.04804754f, -0.04162223f, 0.18390615f, -0.00894821f, 0.08670496f, 
    0.02053218f, 0.23819000f, -0.15309504f, 0.07202453f, 0.02444306f, -0.08122100f, -0.26202661f, -0.21415763f, 
    0.17625907f, -0.05797768f, 0.01192757f, -0.01585115f, 0.45603245f, 0.05033875f, 0.16303757f, 0.07565704f, 
    -0.02499912f, -0.00303961f, 0.03320119f, 0.00333007f, 0.21887043f, 0.10080137f, 0.08758627f, 0.00892886f, 
    0.10278596f, 0.24568833f, -0.06370188f, 0.25895303f, -0.31187889f, -0.04906565f, 0.06807635f, 0.28211507f, 
    0.21939565f, -0.29203951f, 0.28856295f, -0.04267320f, 0.08476730f, -0.15536800f, -0.14590044f, -0.16427858f, 
    0.03299674f, 0.10448788f, 0.13800816f, 0.07595111f, 0.28253549f, 0.00154558f, 0.04781830f, -0.28020045f, 
    -0.04860330f, -0.13937907f, -0.02428136f, 0.07462507f, -0.09358779f, 0.15824831f, 0.04426846f, -0.06110687f, 
    -0.01474072f, 0.01632965f, -0.05174470f, -0.06290339f, -0.10066565f, 0.03533227f, 0.01749580f, 0.07328992f, 
    -0.05093521f, -0.02165229f, 0.07702337f, 0.01009542f, 0.01517195f, -0.02470934f, -0.10762231f, -0.02856286f, 
    0.02969011f, -0.07028817f, -0.05119992f, -0.09921586f, -0.05812175f, 0.05022509f, 0.02251263f, -0.03461949f, 
    0.05716842f, -0.04587780f, -0.00869626f, 0.00098170f, 0.05436898f, 0.00965923f, -0.00232083f, -0.03565884f, 
    -0.06888495f, 0.05390290f, 0.00379107f, -0.08624052f, 0.01251809f, -0.04267691f, 0.02280208f, 0.04731867f, 
    -0.04101215f, 0.07493104f, 0.00839205f, -0.03657442f, -0.02330481f, -0.07623006f, -0.05174506f, 0.03511546f, 
    0.02782912f, 0.02569322f, 0.02350586f, 0.00317399f, -0.00120786f, -0.08950167f, -0.03099504f, -0.00303963f, 
    -0.09611971f, 0.03397280f, 0.02332659f, -0.04725417f, 0.05579784f, 0.04258050f, -0.08275269f, 0.02436297f, 
    -0.05029669f, 0.06859224f, -0.02689726f, -0.01146013f, 0.00930616f, -0.03581149f, -0.02660319f, -0.04729988f, 
    -0.01641538f, -0.05540037f, -0.04633723f, -0.08340418f, -0.00165836f, -0.08114417f, 0.05006345f, -0.06523877f, 
    -0.04739955f, -0.00360158f, -0.03725883f, 0.07429203f, 0.05069651f, 0.00830213f, -0.02858736f, -0.05297981f, 
    -0.04125341f, -0.01941465f, -0.02347898f, -0.07606261f, -0.04572099f, 0.07159711f, -0.05741938f, 0.03981557f, 
    -0.09251516f, 0.06275724f, -0.08835147f, -0.05005286f, 0.01453918f, -0.05789320f, -0.06746777f, -0.04659123f, 
    -0.07027149f, -0.09629370f, 0.02889893f, -0.02737301f, -0.06790930f, 0.00075058f, -0.01293009f, 0.02344907f, 
    0.05957644f, -0.02891018f, 0.02153903f, 0.01151722f, -0.07247195f, -0.05069285f, -0.08496632f, -0.09423672f, 
    -0.08742752f, -0.04397900f, 0.01544199f, -0.07247585f, -0.00664547f, -0.06603406f, 0.00619374f, 0.06094101f, 
    0.65160322f, 0.15921311f, -0.17080407f, 0.02393592f, -0.26516965f, 0.05009940f, 0.05052741f, -0.03910237f, 
    0.00695392f, 0.67323321f, 0.43313545f, -0.06676029f, -0.40380171f, -0.17911702f, 0.02942888f, -0.11748351f, 
    -0.02110799f, 0.19876319f, 0.00170829f, 0.06672245f, -0.19521675f, -0.19389048f, 0.47823900f, -0.04398091f, 
    -0.11914067f, -0.06024165f, -0.08505865f, -0.06912589f, -0.07061324f, 0.23811166f, -0.08798505f, 0.03639236f, 
    -0.36966941f, 0.18008806f, -0.26824781f, -0.07839612f, 0.05123347f, 0.14702360f, 0.06275339f, -0.27089062f, 
    0.07293048f, -0.08029630f, 0.06292485f, -0.09706819f, 0.07884932f, 0.02562310f, -0.01651297f, 0.03293118f, 
    -0.30657309f, -0.12737727f, 0.01618556f, 0.02225314f, 0.12363048f, 0.29269642f, 0.23622754f, 0.00566102f, 
    -0.10456774f, 0.19338155f, 0.15603532f, -0.13955522f, 0.10804775f, 0.14308426f, -0.05666925f, 0.19859014f, 
    -0.09948310f, -0.06466600f, 0.39345285f, 0.06402375f, -0.02821925f, -0.13655268f, -0.18761986f, 0.15057695f, 
    -0.18655545f, -0.11207998f, 0.03116605f, -0.09688923f, -0.01304270f, -0.02719449f, 0.03662176f, 0.07835323f, 
    -0.07504386f, 0.23489325f, -0.21238175f, 0.07483263f, 0.16754721f, 0.16540046f, -0.05173930f, 0.28071177f, 
    -0.16974004f, -0.03440399f, 0.18141943f, -0.18415168f, -0.26922968f, 0.18277174f, 0.06123546f, 0.31715003f, 
    0.31922868f, -0.11451542f, 0.27411756f, 0.17255317f, 0.11161434f, -0.04506359f, 0.02587503f, -0.00447406f, 
    0.16925544f, -0.13715312f, -0.13604811f, -0.03754004f, 0.11530527f, 0.28238302f, 0.19175920f, 0.01097334f, 
    0.25441197f, 0.22733849f, -0.19985370f, -0.07931988f, 0.39883521f, 0.23888695f, -0.01593691f, 0.30849585f, 
    0.32297775f, -0.08193708f, -0.21028785f, -0.10909683f, 0.32953486f, -0.01714182f, -0.00928989f, 0.39335614f, 
    -0.00737943f, -0.00628751f, 0.02815624f, -0.03120583f, 0.01275747f, 0.04710356f, 0.07836144f, 0.00854911f, 
    -0.10454749f, -0.02201516f, -0.07861049f, 0.04428747f, -0.05113669f, -0.00295488f, 0.02839722f, -0.09453058f, 
    -0.01324210f, 0.00446374f, -0.10101200f, -0.06013452f, 0.03478392f, -0.03487938f, -0.02286600f, 0.00419152f, 
    -0.01686512f, 0.05200527f, -0.06603229f, 0.02707320f, 0.04694868f, 0.01786368f, -0.08602178f, 0.02820797f, 
    -0.05620575f, 0.03082623f, -0.03063887f, -0.07331242f, -0.05648289f, -0.07833494f, 0.05774835f, -0.07636965f, 
    -0.02050854f, 0.08633602f, -0.06795704f, -0.05687260f, -0.07933904f, -0.07875218f, 0.02214164f, -0.01266439f, 
    -0.07134117f, -0.01134472f, 0.04679271f, -0.01725966f, -0.08831107f, 0.02061230f, -0.10356496f, 0.02877435f, 
    -0.07479433f, 0.03255066f, -0.03370563f, -0.06067857f, -0.02429709f, -0.08299143f, -0.10288782f, -0.09499988f, 
    0.01885690f, -0.00836662f, -0.06569764f, -0.09849177f, 0.04532142f, -0.05658649f, -0.00220598f, -0.05787818f, 
    0.06800695f, -0.01352899f, -0.03258888f, -0.07987078f, -0.06614556f, -0.01071882f, -0.01996380f, -0.03289577f, 
    0.03622646f, 0.02114197f, 0.03285268f, 0.01327285f, 0.01026317f, -0.08454013f, 0.01502534f, -0.06729250f, 
    -0.05168132f, -0.05838421f, -0.01711907f, -0.04237675f, -0.02918668f, 0.02326431f, 0.02389516f, 0.04322855f, 
    -0.06203759f, -0.07462867f, 0.01059156f, -0.07889635f, -0.01814037f, 0.00779633f, -0.01001757f, 0.00435452f, 
    0.03357359f, 0.03336984f, 0.02771172f, -0.01724382f, -0.10861353f, -0.02062766f, 0.03805970f, -0.00899036f, 
    -0.10129549f, -0.09425792f, -0.02647376f, 0.04525023f, 0.00932386f, -0.03024261f, 0.03570002f, 0.03916002f, 
    0.06318756f, 0.05403038f, 0.03306123f, -0.05194504f, 0.05028299f, -0.03257784f, 0.00032237f, -0.07173667f, 
    0.14698876f, 0.05440358f, -0.07733152f, 0.13099371f, 0.07738608f, -0.07631153f, 0.06652902f, -0.00778616f, 
    0.05324582f, -0.39238942f, 0.31615716f, -0.19276290f, -0.17279930f, -0.21153210f, -0.08996710f, 0.07723480f, 
    0.01188866f, -0.06586867f, -0.04770009f, -0.07949635f, 0.03989030f, 0.08940687f, -0.16816822f, 0.04816441f, 
    0.01477171f, 0.05364284f, 0.03765702f, -0.13880558f, 0.08163679f, -0.10715908f, -0.01330232f, -0.24389434f, 
    0.04809450f, -0.09853367f, 0.16830742f, -0.05616587f, 0.06494601f, 0.10544193f, 0.05410866f, 0.13859521f, 
    0.02470960f, 0.02119008f, -0.08635315f, 0.19537587f, -0.00895471f, 0.19475666f, 0.11886823f, -0.16172078f, 
    -0.08253719f, 0.16658470f, 0.08279049f, -0.03596689f, 0.20892900f, -0.00175734f, -0.05258341f, -0.03862244f, 
    0.00449246f, -0.11780000f, -0.06791832f, 0.19816799f, 0.17686476f, 0.11166592f, 0.05968067f, 0.01166526f, 
    -0.05446348f, -0.06354345f, 0.04214388f, -0.04692696f, -0.05261320f, -0.20175675f, 0.04525004f, -0.06725947f, 
    -0.12778805f, 0.15425941f, -0.02692737f, -0.08530381f, -0.06813939f, 0.03407895f, -0.10677695f, -0.18349071f, 
    -0.13852744f, 0.03306676f, -0.08379856f, 0.06691199f, 0.06011840f, 0.16432187f, -0.09003358f, -0.06524781f, 
    -0.16884652f, -0.04167790f, 0.08521272f, 0.15352388f, -0.25219277f, 0.12631604f, 0.02657934f, -0.14934584f, 
    -0.08669151f, -0.33014831f, -0.07419109f, 0.10161244f, -0.31166384f, 0.00725665f, -0.06382972f, -0.21036966f, 
    0.12733461f, 0.05909133f, 0.13992353f, 0.10177474f, 0.10949028f, -0.11339513f, 0.09092806f, 0.13358852f, 
    0.19505502f, 0.00663968f, 0.27121064f, -0.05625970f, -0.09048438f, 0.12120410f, 0.21521299f, 0.01813018f, 
    0.02041136f, -0.11686789f, -0.10017523f, 0.13425678f, -0.08320834f, -0.09180579f, -0.06805886f, -0.21009493f, 
    -0.22164701f, -0.18735062f, -0.26406571f, 0.06057589f, -0.01724060f, 0.16681959f, 0.05796718f, 0.07433600f, 
    -0.07441857f, -0.62252307f, 0.21103555f, -0.06996088f, -0.20106699f, -0.64237505f, -0.17623407f, 0.20418991f, 
    -0.07129757f, 0.00648380f, 0.03210591f, 0.10181660f, 0.05108227f, 0.01751477f, 0.11568470f, -0.06223131f, 
    0.04980057f, 0.19881235f, 0.00337155f, 0.09846485f, 0.00165736f, -0.11360297f, 0.24637274f, -0.41132975f, 
    0.00419435f, 0.33908135f, -0.06188278f, -0.02936025f, -0.17084540f, -0.00038050f, -0.03301070f, 0.06913351f, 
    -0.17101033f, -0.02628107f, 0.06617274f, 0.03747037f, 0.03912018f, -0.18677098f, 0.02515614f, -0.07311471f, 
    0.07831462f, -0.08289514f, 0.06273159f, 0.31001332f, 0.04699616f, 0.06651483f, -0.17381932f, -0.03228984f, 
    0.03708292f, 0.10818295f, 0.07766971f, -0.25989184f, -0.00262309f, 0.03517486f, -0.06736317f, -0.01538002f, 
    -0.03482207f, 0.04201377f, 0.04338970f, 0.12814890f, -0.02177368f, -0.50822592f, 0.14281073f, -0.12805286f, 
    0.14830503f, 0.11300703f, 0.12848379f, -0.11613917f, 0.02814641f, -0.05908694f, -0.21248111f, 0.02841059f, 
    -0.06101121f, -0.09828074f, 0.06200205f, 0.06485887f, 0.09313019f, -0.09400462f, 0.24146622f, 0.09918000f, 
    -0.05954392f, 0.05026503f, 0.15287043f, 0.01738713f, -0.55537242f, 0.10814785f, -0.05027130f, 0.16502298f, 
    0.00076136f, -0.09521596f, -0.01106043f, -0.24327751f, -0.19796495f, 0.10339455f, -0.10986494f, 0.14237957f, 
    0.11574134f, 0.16249333f, 0.38306621f, 0.02708238f, -0.06047679f, 0.37619841f, 0.06430168f, -0.02546266f, 
    0.06598029f, -0.13113478f, -0.26991183f, -0.08045410f, 0.02769027f, 0.06094500f, -0.06137165f, -0.15461077f, 
    0.09940176f, 0.26123071f, -0.61793476f, -0.22190003f, -0.14457943f, 0.08454836f, 0.10663843f, -0.29006034f, 
    0.28668618f, -0.00649406f, -0.44393870f, 0.03126721f, -0.17255996f, 0.09591840f, -0.03210502f, 0.01232025f, 
    -0.21615265f, -0.20168337f, 0.13375543f, -0.02310284f, 0.21269803f, 0.09589732f, -0.02336334f, 0.06297649f, 
    -0.06933539f, 0.11872954f, -0.03941392f, -0.01791132f, 0.03959344f, 0.20211031f, 0.16480777f, -0.08781219f, 
    -0.00693520f, -0.26546493f, 0.06324275f, 0.07179454f, -0.11219440f, 0.11610723f, -0.08039451f, -0.05893323f, 
    -0.16974796f, -0.07225854f, 0.12141480f, -0.64379770f, -0.32654786f, 0.01473200f, 0.36626303f, 0.13889481f, 
    0.40757126f, 0.08502538f, 0.22594419f, -0.55099690f, 0.11956830f, 0.07700482f, 0.09387726f, -0.57430333f, 
    -0.12273660f, -0.13684003f, 0.09440081f, -0.06318705f, 0.08711249f, 0.15371740f, 0.24127613f, -0.27935982f, 
    -0.08944162f, 0.03359519f, -0.03084776f, 0.08659282f, -0.07793491f, -0.07448496f, 0.30236745f, 0.33771348f, 
    0.17085633f, 0.02479176f, -0.06438509f, -0.10467222f, -0.05488887f, -0.19224229f, 0.01217322f, -0.04181697f, 
    0.06858032f, 0.15291311f, -0.05293678f, 0.24114715f, -0.06939620f, 0.07731315f, 0.24451244f, -0.11757644f, 
    0.13223439f, -0.24180649f, -0.40380061f, 0.11191230f, 0.27552378f, -0.22510681f, 0.26143333f, 0.23098622f, 
    -0.19014473f, 0.02133494f, -0.44718304f, 0.10851378f, 0.02889799f, -0.41272640f, -0.21245690f, 0.28738800f, 
    0.14869121f, -0.02036576f, 0.18784356f, 0.13941661f, 0.26437831f, -0.07299695f, 0.04498625f, 0.41189289f, 
    -0.08750977f, 0.10016307f, -0.27626941f, 0.22993839f, 0.05897127f, 0.08332340f, -0.34240809f, -0.55001163f, 
    -0.05901980f, 0.23067291f, -0.23569173f, -0.04121169f, 0.28205043f, -0.39200655f, 0.01204891f, -0.06153152f, 
    -0.20418559f, -0.17061797f, 0.04978243f, 0.07932474f, -0.00170054f, 0.08114943f, -0.02278455f, -0.20861925f, 
    0.08589382f, -0.02177529f, 0.25179574f, 0.21537812f, 0.09647786f, -0.23458982f, 0.00580086f, 0.00053292f, 
    0.04695094f, -0.24408382f, 0.16723275f, 0.20100744f, -0.13132294f, -0.24007727f, 0.02134925f, 0.05662417f, 
    -0.12266658f, 0.06104100f, -0.32240495f, -0.23311603f, -0.10783376f, -0.05121614f, -0.16271202f, -0.01778797f, 
    0.15343419f, -0.05381894f, 0.04054291f, -0.09039760f, -0.01726554f, 0.05395762f, -0.13942175f, -0.13424096f, 
    0.01589399f, 0.04003885f, 0.16556321f, 0.05762559f, 0.20141129f, -0.33640212f, 0.19369234f, -0.10807416f, 
    0.07232361f, -0.05139386f, -0.04086242f, 0.18847091f, 0.19977066f, 0.12400833f, 0.09868197f, -0.09176728f, 
    -0.02350409f, -0.03937560f, 0.24763072f, -0.23233610f, 0.18484861f, 0.18170616f, 0.19641083f, 0.06247162f, 
    0.01665695f, -0.15009274f, -0.29349455f, -0.20025863f, 0.35225400f, 0.02430562f, -0.04093860f, -0.16944121f, 
    -0.22017783f, -0.02358660f, 0.13238914f, -0.14200786f, -0.01360977f, 0.03341702f, -0.13090661f, -0.09590425f, 
    -0.34791309f, 0.26052523f, -0.07169858f, -0.00570242f, 0.04234233f, 0.02871705f, -0.21869124f, -0.33035558f, 
    -0.19895390f, 0.29415214f, 0.13887151f, -0.09638312f, 0.17284453f, 0.19029093f, -0.04352135f, -0.09119856f, 
    0.22590531f, -0.07302375f, 0.21116029f, 0.11227047f, -0.16104393f, 0.08164021f, 0.00936979f, -0.13536717f, 
    0.08661434f, -0.03661068f, 0.09308171f, 0.44441748f, -0.34963119f, -0.05289289f, -0.02340092f, 0.07746632f, 
    0.09854333f, -0.28047374f, 0.16671680f, -0.01347414f, 0.26033777f, -0.32541364f, -0.03099447f, -0.08111744f, 
    0.07043234f, 0.16347197f, 0.31037557f, 0.09912015f, 0.02083442f, 0.10811890f, 0.12075244f, 0.07775616f, 
    -0.14149524f, -0.18357112f, -0.23195019f, 0.22131528f, -0.24682570f, 0.26462895f, -0.04467230f, 0.00494513f, 
    0.17404579f, 0.15935536f, -0.20405890f, -0.25485539f, -0.20427060f, 0.00483256f, 0.03661398f, -0.01442716f, 
    -0.09874216f, 0.31727949f, 0.18659376f, 0.18716292f, -0.29328865f, 0.22844866f, 0.07489917f, -0.08351067f, 
    -0.10256851f, 0.01501827f, 0.21542907f, 0.14943218f, -0.04652445f, 0.03168826f, 0.11701153f, 0.05556682f, 
    -0.22646464f, -0.12235598f, 0.02556190f, -0.02430953f, -0.20204972f, -0.07011519f, -0.02380026f, -0.39374238f, 
    -0.31742477f, 0.04011669f, -0.08906624f, -0.10199453f, -0.10835196f, 0.17131984f, 0.01817802f, -0.06476983f, 
    -0.64298445f, -0.04717692f, 0.13606249f, -0.24070343f, -0.22155249f, -0.11748136f, -0.19265138f, 0.30898821f, 
    -0.11810056f, -0.00617071f, -0.12161098f, 0.23608805f, -0.08827567f, -0.01954637f, -0.15076500f, 0.14370202f, 
    -0.16404043f, 0.16143262f, 0.40882096f, 0.00831165f, 0.00558994f, -0.03478206f, 0.16431841f, 0.22695054f, 
    -0.07227921f, 0.05984905f, -0.04921494f, 0.22514208f, -0.05732029f, -0.10200660f, 0.02910383f, 0.14991958f, 
    0.11186270f, -0.26602885f, 0.12329509f, -0.29513308f, 0.05208569f, 0.08498795f, 0.08521929f, 0.15276864f, 
    0.38323009f, -0.02050037f, 0.01691495f, 0.00185142f, 0.03741698f, -0.08366486f, 0.16398916f, 0.14986210f, 
    -0.04368931f, 0.06067142f, 0.09017583f, -0.24737026f, -0.09542950f, -0.09095233f, -0.04244478f, 0.18815504f, 
    -0.09914646f, 0.20710674f, 0.17095000f, -0.11726457f, 0.20724408f, 0.26127762f, -0.28994694f, -0.19748066f, 
    -0.03064286f, 0.16532122f, -0.10378439f, -0.07819874f, -0.19150235f, 0.25069436f, 0.14990565f, -0.07214623f, 
    0.11028843f, -0.06130736f, -0.28937304f, -0.10348674f, 0.13815866f, 0.05418443f, -0.13553774f, 0.23184885f, 
    0.11038651f, 0.22818103f, -0.81531733f, -0.14092588f, 0.28173470f, -0.10571854f, -0.03783595f, 0.20831499f, 
    -0.12529677f, 0.08164418f, -0.09078202f, 0.19385880f, 0.15064205f, -0.02546045f, 0.06303757f, -0.01572921f, 
    0.26463979f, 0.18098566f, -0.05511190f, -0.05478543f, -0.23332669f, -0.28242683f, 0.06175986f, 0.11326525f, 
    0.01137754f, -0.32478872f, -0.06021370f, -0.40791124f, -0.10761647f, 0.03636352f, -0.48247334f, 0.06374229f, 
    0.12383888f, -0.07636826f, -0.00300354f, -0.01418607f, -0.05289039f, -0.14047770f, 0.07238551f, -0.26789641f, 
    0.01041556f, 0.25892931f, 0.05917306f, 0.18045560f, 0.04577692f, -0.05994099f, 0.22289695f, 0.10774080f, 
    0.05479739f, 0.00493938f, -0.16833638f, 0.01046371f, 0.06636678f, 0.13943116f, -0.00884142f, -0.25011784f, 
    -0.33317852f, 0.13240463f, 0.13813393f, 0.04427448f, 0.37640783f, 0.09049804f, 0.05257395f, 0.01259928f, 
    0.16909605f, -0.12841399f, 0.03953412f, -0.00699650f, 0.01299479f, 0.10629343f, 0.06618745f, 0.08433603f, 
    -0.02364146f, 0.07004602f, 0.00427696f, -0.11768230f, -0.07965292f, -0.22764103f, -0.01547146f, -0.02786297f, 
    -0.16992375f, 0.28245381f, -0.01834162f, -0.13457248f, -0.10016459f, -0.07076997f, 0.03668274f, -0.36364394f, 
    -0.20292149f, 0.18857996f, -0.13231392f, -0.01493636f, -0.07630053f, 0.31106570f, 0.19541878f, 0.01074227f, 
    0.03480067f, 0.07912099f, -0.03703247f, 0.12662263f, -0.18048777f, 0.05431487f, 0.11751095f, -0.29189023f, 
    -0.00560303f, -0.20694372f, 0.13851117f, 0.25050709f, 0.03099539f, -0.02417441f, -0.11298253f, -0.39115408f, 
    0.10022490f, 0.21957004f, 0.06367419f, 0.20073618f, 0.32320479f, -0.19857934f, -0.04543998f, 0.08844020f, 
    0.18574469f, 0.04404807f, 0.15931650f, -0.12256379f, 0.11208365f, 0.01943573f, 0.19296663f, 0.21669896f, 
    -0.15779060f, -0.07085936f, -0.12257376f, 0.33136657f, -0.14114410f, -0.11941576f, 0.06581444f, 0.01710782f, 
    -0.03469986f, 0.01971051f, -0.06076803f, -0.03527661f, 0.00993821f, 0.05174282f, -0.08341687f, 0.04456412f, 
    -0.03282452f, -0.05187400f, 0.08071600f, 0.07427765f, 0.08444251f, 0.07382426f, 0.07950413f, 0.02273020f, 
    -0.03457828f, -0.07461452f, -0.06412985f, -0.01650200f, 0.02332964f, 0.02534930f, 0.08187647f, -0.06868096f, 
    -0.05252536f, -0.04848494f, -0.04720341f, 0.06064225f, -0.01734908f, 0.02183066f, 0.05053562f, -0.08734077f, 
    -0.05814726f, -0.04632727f, 0.01540018f, -0.00687116f, -0.06561074f, -0.04388292f, 0.04699923f, -0.00252742f, 
    -0.07993738f, 0.08374161f, -0.09110858f, 0.00515867f, -0.09395155f, 0.06456310f, 0.06014393f, 0.07786590f, 
    -0.07695649f, -0.08057677f, 0.08067815f, -0.00710583f, -0.00831046f, -0.02346740f, 0.00837057f, 0.04772873f, 
    -0.03913563f, -0.07853530f, 0.02490463f, -0.09205754f, 0.04662340f, 0.01950863f, -0.02389384f, -0.04818864f, 
    -0.02937266f, -0.07834853f, 0.02948498f, 0.00110890f, 0.05385143f, 0.03000909f, -0.01562034f, -0.12878999f, 
    0.05374352f, -0.02355445f, 0.02482173f, -0.05602051f, 0.00858946f, -0.07479421f, -0.00381925f, -0.04846355f, 
    0.04127324f, 0.05824158f, 0.07110294f, -0.00175039f, -0.02418996f, -0.09563027f, -0.07084084f, -0.09616441f, 
    -0.08236668f, 0.04480221f, 0.00749994f, -0.07008184f, -0.04938939f, 0.03713758f, -0.02655820f, -0.10174143f, 
    0.01280670f, -0.03867238f, 0.04904875f, -0.05342329f, -0.05462182f, -0.01315133f, -0.01563565f, -0.04734860f, 
    0.04590009f, -0.02675351f, -0.08874368f, -0.07102037f, 0.06463286f, 0.00584678f, -0.09207583f, 0.01039651f, 
    -0.08373407f, 0.01520716f, -0.02950366f, -0.01486497f, -0.00168380f, 0.06565197f, -0.07332656f, -0.02481163f, 
    0.01749260f, 0.05023304f, -0.03270470f, 0.01545461f, -0.04332076f, -0.07115944f, 0.01338595f, -0.02017905f, 
    -0.04796796f, 0.01018098f, 0.21536401f, 0.05441278f, 0.04138563f, -0.08863785f, 0.07299197f, 0.00832016f, 
    0.15107206f, 0.04328548f, 0.05979049f, 0.05481292f, 0.23796111f, 0.39993376f, 0.06927544f, -0.07283214f, 
    0.01750209f, -0.02381294f, 0.15070826f, -0.60685581f, -0.25436130f, 0.01909202f, -0.05406861f, 0.04147770f, 
    0.09145001f, -0.28519410f, 0.02241401f, -0.08426545f, -0.15752596f, 0.07570951f, 0.14573194f, 0.20177594f, 
    -0.33045208f, 0.02953939f, -0.01387618f, -0.08760910f, 0.10144352f, -0.10546383f, -0.22519876f, 0.02317227f, 
    0.01797369f, 0.03831654f, 0.01362549f, 0.02693995f, -0.03618863f, -0.26554623f, 0.13233022f, 0.14273612f, 
    -0.01646263f, 0.07441110f, -0.16538374f, 0.24883443f, -0.03078917f, -0.04801255f, 0.02311934f, 0.10631441f, 
    0.17738543f, -0.08438577f, 0.16885649f, 0.08229932f, -0.18288885f, -0.11121101f, -0.01181905f, 0.08807182f, 
    -0.38100690f, -0.02908193f, -0.08056193f, 0.09213778f, -0.04937937f, -0.47412193f, 0.29044387f, -0.06094538f, 
    0.29342124f, -0.01359648f, 0.09239331f, 0.06162366f, 0.01017009f, 0.07863331f, 0.32280368f, -0.51870179f, 
    -0.01542229f, -0.10661099f, 0.10827729f, -0.03460301f, -0.14105199f, -0.00747008f, -0.10158321f, 0.02176333f, 
    -0.43580428f, 0.05274354f, 0.05495709f, -0.22973098f, -0.31794664f, -0.17924829f, 0.15179703f, 0.08012929f, 
    -0.11954580f, 0.12359084f, -0.03406033f, -0.43551046f, 0.25467965f, 0.08249512f, -0.08645269f, -0.06505068f, 
    -0.07306776f, 0.49589545f, -0.01931755f, 0.07149950f, 0.00695201f, -0.22114062f, -0.07373647f, -0.06398311f, 
    -0.11669141f, 0.01604555f, -0.14928187f, -0.28465945f, -0.22455382f, -0.03625896f, -0.15529139f, 0.19414246f, 
    0.14014073f, 0.34217420f, 0.35871258f, 0.12561724f, 0.03409224f, -0.52126402f, 0.05145629f, 0.11322203f, 
    -0.10667236f, -0.10624653f, 0.02237451f, 0.01114192f, 0.07388279f, 0.06983386f, -0.08088628f, 0.01893157f, 
    0.08232858f, -0.12244848f, 0.07014674f, 0.03707363f, 0.05771537f, 0.08327169f, -0.02583344f, -0.00083343f, 
    -0.04335761f, -0.04571193f, -0.03367345f, -0.00483514f, 0.02666465f, 0.01026841f, 0.02187808f, -0.02373002f, 
    -0.04704307f, -0.02721046f, -0.07458281f, 0.03186611f, -0.08938088f, 0.05220576f, -0.08529174f, -0.00427835f, 
    -0.06973492f, 0.04705199f, -0.09193376f, -0.03328280f, -0.05120185f, -0.09735241f, -0.08781148f, 0.00300865f, 
    0.00005526f, 0.06444246f, 0.01906710f, -0.05675589f, -0.02611755f, 0.04361251f, -0.09540334f, 0.00028511f, 
    -0.02436962f, -0.01842435f, -0.04170972f, 0.04474194f, -0.08143427f, 0.03808068f, 0.05515444f, -0.02105901f, 
    0.01055951f, -0.04894406f, -0.04341194f, -0.03506469f, -0.00229824f, -0.08943748f, -0.02124670f, -0.03009749f, 
    -0.05441700f, 0.00761715f, -0.08311357f, -0.07800497f, 0.01194524f, -0.04598743f, -0.07966209f, -0.06201992f, 
    -0.01817874f, -0.02580274f, 0.03302092f, -0.02263517f, -0.00134532f, 0.00918808f, -0.11458960f, 0.06013744f, 
    0.01826179f, 0.03887615f, 0.01371014f, 0.06416823f, -0.11446323f, 0.04189476f, 0.06629428f, -0.00476316f, 
    -0.05967663f, 0.00170428f, -0.02284752f, -0.07370200f, 0.01609357f, -0.06613809f, 0.01659053f, 0.01752444f, 
    0.05394642f, -0.02288951f, -0.02265053f, -0.03821273f, -0.05067160f, 0.01106851f, -0.06106579f, -0.10511389f, 
    -0.01524909f, 0.01673815f, -0.00059848f, 0.00323466f, -0.02055594f, -0.03039337f, -0.03560700f, -0.00413275f, 
    -0.05301460f, 0.01853515f, 0.04523794f, 0.03701769f, -0.07000261f, 0.02215703f, 0.07874685f, -0.00231835f, 
    -0.06460991f, 0.03668357f, -0.01609479f, -0.05538040f, -0.01576004f, -0.02583720f, -0.00007639f, 0.05960887f, 
    -0.02854888f, 0.03506995f, 0.17495951f, -0.08428898f, 0.31252050f, -0.13898127f, -0.02886051f, 0.04300504f, 
    -0.01957441f, -0.49516690f, 0.09054521f, 0.12771441f, -0.30328849f, -0.04109545f, 0.03434214f, 0.11355751f, 
    -0.09418958f, 0.09904385f, -0.08780205f, 0.02041344f, -0.01066986f, 0.05431940f, -0.35245994f, 0.04969990f, 
    0.03712832f, 0.07441349f, -0.03503549f, -0.10079348f, -0.04412728f, -0.09376649f, 0.05354100f, -0.21089071f, 
    0.00776443f, -0.25958216f, 0.15952662f, 0.01940147f, 0.06530555f, 0.37189451f, 0.10955482f, 0.13205448f, 
    -0.43404374f, 0.03284073f, -0.04462581f, 0.12946680f, -0.04052671f, 0.03916855f, -0.17578983f, 0.00718763f, 
    0.02846634f, 0.19645937f, 0.09163275f, 0.20236933f, 0.08970369f, -0.19350579f, -0.29031935f, 0.26695311f, 
    0.04136306f, 0.37106031f, 0.12960863f, 0.07420300f, 0.22908828f, 0.00142231f, 0.20458843f, -0.10152444f, 
    -0.05260902f, 0.01816296f, -0.10610317f, -0.12033178f, -0.04184181f, -0.03342469f, 0.06111666f, -0.10982017f, 
    0.11615535f, 0.12581952f, -0.17214061f, -0.32491440f, -0.09137032f, 0.04912519f, 0.25882339f, 0.01064906f, 
    0.08191058f, -0.04528135f, 0.33120075f, 0.04623690f, 0.16157067f, -0.01190823f, -0.00229193f, 0.12006699f, 
    0.16050242f, -0.03749800f, 0.13228220f, 0.11670567f, 0.16462429f, 0.08099120f, 0.02421774f, -0.09500652f, 
    -0.09355971f, 0.32766882f, -0.10005341f, 0.03738797f, -0.01151738f, 0.02333609f, -0.01868982f, 0.01373630f, 
    0.11712456f, 0.17030095f, -0.09442211f, 0.10083367f, 0.12191302f, 0.30058238f, 0.14686218f, -0.06254756f, 
    -0.08328266f, -0.02053330f, 0.19743347f, 0.07735151f, -0.04744532f, -0.03188068f, 0.15922244f, 0.00030554f, 
    -0.11872148f, 0.10836737f, -0.71871930f, 0.29468149f, 0.02005853f, 0.09294567f, -0.00627288f, 0.05827796f, 
    -0.06916502f, -0.10383412f, 0.20429006f, 0.20415148f, 0.26572677f, -0.11884321f, 0.07495033f, -0.05186081f, 
    0.26572451f, -0.34850603f, 0.16662709f, -0.04383435f, -0.22230043f, -0.08777162f, -0.09151231f, 0.08459461f, 
    0.07039313f, -0.03460468f, -0.09766161f, -0.33499184f, -0.13359258f, -0.03260042f, -0.31325969f, 0.04804350f, 
    -0.10286169f, 0.07244860f, -0.02035182f, 0.05999088f, 0.00088206f, 0.13884811f, 0.02326728f, 0.03330173f, 
    0.21886933f, -0.05567120f, 0.00577646f, -0.05472463f, 0.09463248f, -0.20120594f, -0.00371077f, 0.01028534f, 
    0.21438701f, -0.02038771f, -0.04862396f, 0.25078264f, 0.09075850f, 0.04907979f, 0.26049936f, -0.18911372f, 
    -0.01626196f, 0.11742349f, 0.03206420f, -0.13902494f, 0.13984515f, 0.13548504f, 0.33071536f, -0.21980867f, 
    0.19000189f, -0.16389510f, -0.33161592f, 0.11350554f, -0.08174359f, -0.07424422f, -0.07967586f, 0.05147870f, 
    0.11306871f, -0.04273048f, 0.10547515f, -0.02701494f, -0.01469347f, -0.22031792f, -0.02533379f, -0.07068178f, 
    -0.14051484f, 0.23980357f, 0.05012877f, 0.15411015f, 0.03596006f, 0.01304126f, -0.09229549f, -0.35116372f, 
    -0.31782323f, 0.16133220f, 0.03077965f, 0.08029030f, 0.00748843f, 0.18315190f, -0.09323850f, -0.10246036f, 
    0.13276680f, -0.06910380f, 0.07090767f, 0.08178293f, -0.50941145f, 0.12580891f, 0.06183606f, -0.09861294f, 
    0.08380982f, -0.14970565f, 0.02955090f, 0.18108524f, -0.03154785f, 0.01385995f, 0.19965199f, 0.06391814f, 
    -0.02811933f, -0.13968498f, -0.18419054f, 0.05674139f, 0.15097454f, -0.19288662f, 0.12344988f, -0.03703556f, 
    -0.06464402f, 0.11149000f, 0.25848207f, 0.19558343f, -0.17815901f, 0.12241940f, 0.16461278f, -0.08139537f, 
    0.08212730f, -0.28364292f, 0.01862776f, 0.18238473f, -0.05853268f, 0.16129886f, 0.04956237f, -0.04308883f, 
    0.00610363f, -0.04218252f, 0.05224187f, -0.09547184f, 0.04119929f, -0.04734263f, -0.03507274f, 0.03033190f, 
    -0.09588057f, -0.00015148f, 0.01571910f, -0.08996161f, -0.07946087f, -0.04696598f, 0.03628918f, -0.07770957f, 
    -0.06938285f, -0.00239384f, 0.05160912f, -0.10340779f, -0.04398401f, -0.04473152f, -0.02159492f, -0.03646585f, 
    -0.00543597f, -0.07841590f, 0.01139614f, -0.04854905f, 0.05709487f, -0.00911618f, -0.09088367f, -0.08736835f, 
    -0.07647337f, -0.03782221f, 0.00626631f, -0.06195735f, -0.02043899f, -0.07701825f, -0.00648049f, 0.03415748f, 
    -0.03365390f, 0.07370710f, -0.04982595f, 0.07640548f, -0.00405128f, 0.02141043f, -0.00370518f, 0.07081510f, 
    -0.10634206f, -0.02617279f, 0.01220685f, -0.02645289f, 0.07659977f, -0.01912320f, -0.00320775f, 0.05212167f, 
    0.06030738f, -0.04820312f, 0.00953791f, -0.03604751f, -0.04588274f, -0.05130706f, -0.09590570f, -0.10989380f, 
    -0.11086152f, -0.02532141f, 0.03776684f, -0.05009184f, 0.03835955f, -0.07172637f, -0.05679100f, -0.08832417f, 
    0.01556391f, -0.07722058f, 0.04502024f, -0.10970859f, -0.06755035f, -0.01283287f, 0.04150950f, -0.06931755f, 
    0.03798466f, -0.04324346f, -0.01843267f, -0.05137663f, 0.00995872f, 0.05551163f, -0.02885458f, -0.02130061f, 
    -0.03258639f, 0.00047369f, -0.06655829f, -0.07296617f, -0.03379893f, -0.05513572f, -0.01763297f, 0.01945597f, 
    -0.03997507f, 0.02184391f, -0.01334030f, 0.01382392f, -0.01410678f, -0.08487204f, -0.01624305f, 0.02591036f, 
    -0.02106009f, 0.02018958f, 0.03777599f, 0.03328867f, 0.04284163f, -0.07820635f, 0.03213279f, -0.02602651f, 
    -0.03609576f, 0.01786865f, -0.09180611f, 0.05345085f, 0.01986163f, -0.00832003f, -0.07529873f, -0.08717752f, 
    -0.06991778f, -0.08751995f, -0.02376045f, 0.03352796f, 0.01217950f, -0.10339265f, 0.00274438f, 0.02215942f, 
    0.28966054f, 0.17135504f, 0.35243696f, 0.19565520f, 0.35147119f, -0.21645853f, -0.08665785f, -0.06358339f, 
    -0.27919248f, -0.25445423f, -0.58002299f, 0.45251635f, 0.11465452f, -0.00508639f, 0.15604031f, 0.17000850f, 
    -0.05491355f, -0.08982150f, -0.53778571f, -0.04889560f, -0.02196459f, 0.25468794f, 0.02626377f, -0.03992002f, 
    -0.21602568f, -0.30973762f, 0.00544713f, -0.28002745f, -0.15729718f, -0.49711671f, 0.08546894f, 0.22988026f, 
    0.05225769f, -0.12474138f, 0.34078202f, 0.20641340f, 0.12116650f, -0.01542503f, 0.02131684f, 0.33647257f, 
    0.08465293f, -0.06609803f, 0.00099126f, 0.13248402f, 0.03100061f, 0.26472762f, 0.16097805f, -0.08470382f, 
    -0.31997162f, 0.20760894f, 0.22772130f, -0.01162206f, -0.03246544f, -0.11224956f, 0.02192878f, 0.36668712f, 
    0.21279718f, -0.04018199f, 0.04435519f, 0.32873571f, 0.09001500f, 0.04005620f, 0.14698692f, 0.10978232f, 
    -0.01335924f, -0.07640126f, -0.32122520f, -0.45543882f, 0.03390086f, -0.39233878f, 0.19623439f, -0.38841018f, 
    0.10058655f, 0.16924734f, -0.14557761f, -0.01238034f, 0.04928138f, 0.01000155f, 0.34526002f, -0.16599877f, 
    0.09718795f, 0.03620334f, 0.12554504f, -0.02256185f, 0.15043782f, 0.09284037f, -0.17214054f, -0.14487039f, 
    0.09687638f, 0.01496082f, 0.03157304f, 0.42111748f, -0.09961526f, -0.14318910f, -0.35378170f, -0.21155488f, 
    -0.08001174f, 0.01822898f, -0.07140874f, 0.03937980f, 0.06693406f, -0.09239525f, -0.26305339f, 0.12114882f, 
    -0.04958726f, 0.12223253f, 0.03038111f, 0.16785276f, 0.14881760f, -0.16852668f, -0.08268853f, 0.28451076f, 
    -0.18088077f, 0.04998458f, 0.55742460f, -0.56529725f, -0.07803916f, -0.17891349f, 0.09655309f, -0.07101648f, 
    -0.11305175f, 0.01523736f, 0.21916328f, 0.33220324f, -0.34235686f, 0.10193443f, -0.07609458f, -0.36321226f, 
    0.06365369f, 0.00044745f, 0.02124659f, 0.06275489f, -0.07216178f, -0.09029011f, -0.00706183f, 0.05065969f, 
    -0.09262657f, 0.01791240f, 0.00289545f, 0.00389311f, -0.05228980f, 0.04230412f, -0.02803157f, 0.05418881f, 
    -0.08399181f, -0.01114411f, -0.04878123f, -0.02076362f, 0.02172127f, -0.00171113f, -0.00425916f, -0.08780941f, 
    -0.05609538f, -0.05982764f, 0.05465424f, -0.09817860f, -0.08169238f, -0.04305923f, -0.07740299f, 0.00879124f, 
    -0.00274047f, -0.03438342f, 0.06787576f, -0.07186621f, -0.06954820f, 0.05810370f, 0.03865306f, -0.03721069f, 
    -0.05562736f, 0.08451261f, -0.06030674f, -0.03788769f, -0.05084131f, 0.07367482f, 0.03053443f, -0.03026092f, 
    -0.12923068f, -0.05266976f, -0.04311687f, -0.01462204f, -0.02132204f, 0.06998330f, 0.00875263f, 0.01816407f, 
    -0.05597549f, -0.03053033f, 0.00491501f, 0.03102035f, -0.03577918f, -0.02004479f, 0.00446054f, 0.05926071f, 
    -0.09824944f, 0.00192735f, 0.05893808f, -0.04912550f, -0.08153006f, -0.00582970f, -0.07187265f, -0.04961265f, 
    -0.08985463f, 0.02664355f, 0.00476275f, 0.02257063f, 0.00837044f, -0.07272625f, -0.05774895f, -0.00597577f, 
    -0.01455043f, -0.05181716f, -0.03316236f, 0.06996721f, 0.03825236f, -0.07624060f, -0.02313180f, 0.07093257f, 
    0.02833599f, 0.05382681f, 0.01091965f, -0.10247659f, 0.02648013f, 0.04575068f, -0.03060930f, 0.00141418f, 
    0.08583274f, 0.04409776f, 0.07527452f, -0.07224369f, -0.03056599f, 0.04758972f, -0.11829101f, -0.02519720f, 
    -0.03709465f, -0.01789981f, 0.04600125f, -0.08290008f, 0.02140207f, 0.00629001f, -0.06149882f, -0.01025721f, 
    -0.02830853f, -0.06139274f, -0.05042929f, -0.09562112f, -0.03716067f, -0.07472773f, -0.01716163f, 0.05144082f, 
    -0.01493176f, 0.00203608f, -0.00706181f, 0.03412705f, -0.05836902f, -0.10180870f, 0.08755536f, 0.01019942f, 
    0.07440832f, 0.02796107f, 0.01287783f, 0.08602867f, -0.17016371f, 0.01272370f, -0.02443433f, 0.08165186f, 
    0.14724767f, 0.37179875f, 0.15624496f, -0.01878005f, -0.24170922f, -0.02864369f, 0.07119076f, -0.12691668f, 
    0.00922506f, 0.03685763f, -0.07034776f, -0.18424496f, -0.11389650f, -0.12886505f, 0.28592339f, -0.05582805f, 
    0.04629578f, -0.05442674f, -0.08352129f, 0.21390088f, 0.01469565f, 0.01706148f, 0.05278461f, 0.31932163f, 
    -0.22864200f, 0.34947449f, -0.14445715f, 0.19798531f, 0.22496518f, -0.23439011f, 0.01930270f, -0.06245628f, 
    0.23844489f, -0.08773686f, 0.03763204f, -0.06313713f, 0.19073990f, -0.05850377f, -0.07851286f, -0.23163192f, 
    -0.02689265f, 0.14122778f, 0.03881231f, 0.08897651f, 0.28666100f, 0.23307088f, 0.18515807f, -0.20396510f, 
    0.16468579f, -0.20546186f, -0.04661232f, -0.09583281f, -0.13973917f, 0.03256667f, -0.18672715f, 0.15514570f, 
    -0.13835046f, 0.03095878f, -0.00427951f, -0.01891443f, 0.06717934f, -0.19336070f, -0.02404576f, 0.32798213f, 
    0.00106578f, 0.04776443f, 0.20886651f, 0.04420196f, -0.00352653f, 0.02352226f, 0.05842970f, -0.31031701f, 
    -0.20495977f, 0.13686882f, -0.19871692f, 0.11731902f, -0.06921091f, 0.22051756f, 0.04029294f, 0.06279360f, 
    -0.01403912f, -0.01341136f, 0.06297182f, -0.17982145f, -0.26238221f, 0.14711252f, 0.20176364f, 0.18439080f, 
    0.17248300f, -0.24513935f, 0.11791757f, -0.17204335f, 0.19879045f, 0.07161503f, 0.01551146f, 0.04018806f, 
    0.01967630f, 0.03967576f, -0.01870125f, 0.03542844f, 0.16224973f, -0.19111934f, 0.08494741f, -0.00097542f, 
    0.26258528f, -0.06040692f, -0.02534756f, 0.02455620f, 0.12523785f, 0.21896325f, 0.06493725f, 0.23144287f, 
    0.19656150f, 0.14553769f, 0.32965362f, 0.08047425f, -0.08767205f, -0.16061366f, 0.02448877f, 0.38088611f, 
    -0.07007975f, -0.09117487f, 0.07309300f, -0.08517879f, -0.05241439f, 0.02390112f, -0.08106727f, 0.03622226f, 
    -0.04355348f, -0.04304857f, 0.01039565f, -0.08137511f, -0.00852562f, -0.06270406f, -0.02769755f, -0.08984195f, 
    0.05914658f, 0.02428173f, -0.04327355f, 0.04277739f, -0.09774993f, -0.08559118f, 0.07839445f, -0.04090066f, 
    -0.06450644f, -0.08156101f, 0.00695515f, 0.07294605f, 0.01645769f, -0.07453205f, -0.09490903f, 0.05856314f, 
    -0.09605145f, -0.02582452f, -0.01899199f, -0.08500575f, -0.02051149f, 0.07341982f, 0.04369198f, -0.04950935f, 
    -0.04494997f, 0.04461823f, -0.02584999f, -0.01268722f, -0.07806004f, 0.07336001f, 0.03097739f, -0.00910210f, 
    0.04319086f, 0.06006640f, -0.05876831f, 0.02662513f, -0.07378983f, -0.07280903f, 0.05914020f, 0.01074295f, 
    -0.02291647f, 0.04174872f, -0.00528947f, -0.00746595f, -0.06213078f, -0.00946966f, 0.04461114f, -0.01527398f, 
    0.06126187f, 0.06954747f, -0.02381621f, -0.03759965f, -0.02066192f, -0.07116892f, 0.04642477f, -0.04432203f, 
    -0.03146455f, -0.05413988f, 0.07814677f, -0.04308542f, -0.06547457f, 0.08284398f, -0.00613376f, -0.07581438f, 
    0.00598936f, -0.05360884f, 0.01705266f, 0.08071473f, -0.06393578f, 0.06786960f, 0.01257301f, 0.05868200f, 
    -0.07038375f, 0.06380055f, 0.06957782f, -0.09680903f, 0.04451783f, 0.00739816f, 0.03414495f, -0.06835278f, 
    0.05246379f, -0.00185653f, 0.00309726f, 0.06427211f, -0.01259591f, -0.08264574f, 0.01328299f, 0.01774632f, 
    0.01774908f, -0.03237370f, -0.04215115f, 0.00257446f, 0.00926438f, -0.01467532f, -0.06674566f, -0.01827882f, 
    -0.08712842f, -0.09223200f, -0.09341022f, -0.01638824f, 0.06871223f, 0.07314841f, 0.00048225f, -0.05779985f, 
    0.01149801f, -0.06514362f, -0.02008843f, 0.02669556f, 0.04039034f, -0.04424503f, -0.07634183f, 0.07312761f, 
    -0.13702106f, -0.01038564f, 0.11847012f, 0.03815129f, -0.01875588f, -0.06395694f, -0.03471746f, 0.04381802f, 
    0.16777946f, -0.17895798f, 0.12197971f, -0.07606656f, 0.25965315f, 0.35767427f, 0.02515423f, -0.32227749f, 
    0.22413658f, -0.09943689f, 0.11381863f, -0.25858334f, 0.01714914f, -0.06241925f, -0.14015701f, -0.06345097f, 
    -0.25710559f, 0.01010620f, 0.06044293f, 0.06897252f, 0.01514995f, 0.21239455f, 0.07552351f, 0.37323517f, 
    -0.06957304f, -0.24053068f, -0.22473340f, -0.17502472f, 0.09933233f, -0.19397759f, -0.12043156f, -0.05786387f, 
    -0.16728790f, 0.04032281f, 0.13772050f, 0.15079482f, 0.09860615f, -0.21153589f, 0.02975597f, 0.15446092f, 
    -0.04387921f, 0.04676864f, -0.13407953f, 0.18173218f, 0.03687737f, 0.23368014f, 0.05192044f, -0.01618841f, 
    0.24158996f, -0.29500237f, -0.02213075f, -0.05813719f, -0.14231287f, -0.25121009f, -0.14597760f, 0.09831360f, 
    0.13376229f, 0.07670494f, 0.03999555f, 0.09586907f, 0.03684521f, -0.24558863f, 0.10056141f, 0.20032944f, 
    0.18852605f, 0.17485489f, -0.16311052f, 0.02170615f, -0.02149771f, -0.06885909f, 0.12749484f, -0.30354342f, 
    0.36506462f, 0.23258349f, 0.07594097f, 0.07919846f, -0.13298737f, 0.08377616f, 0.02046324f, 0.25104460f, 
    0.08146605f, -0.05380731f, 0.22206593f, -0.30208799f, -0.34932977f, 0.26201135f, 0.29633093f, 0.14722027f, 
    -0.06757185f, 0.33212721f, 0.20467752f, 0.05346367f, -0.09144215f, 0.27934629f, -0.03897769f, -0.07073907f, 
    -0.04819344f, 0.20164254f, -0.19577815f, -0.05631291f, -0.12779781f, -0.15749699f, 0.24427450f, 0.11682622f, 
    -0.03454770f, 0.12075006f, -0.01714170f, -0.12134185f, -0.12062907f, 0.24087109f, -0.03072929f, 0.23612311f, 
    0.27144480f, 0.36318696f, 0.27527356f, 0.20469077f, 0.17705375f, -0.31581613f, -0.02925954f, 0.60636693f, 
    0.22615333f, 0.13748620f, 0.25180164f, -0.10208323f, 0.37364414f, 0.14208165f, 0.02171743f, 0.07908571f, 
    0.08167297f, -0.01342512f, -0.29549551f, 0.37408876f, -0.29874706f, -0.05050755f, -0.02268454f, 0.28305754f, 
    0.03356152f, -0.09470475f, -0.02930580f, 0.06040582f, 0.05158939f, -0.03444395f, 0.29809573f, 0.03738612f, 
    0.19469890f, 0.10194781f, -0.04705343f, -0.04816126f, 0.15141505f, -0.10086439f, 0.17133115f, -0.21873307f, 
    -0.08973821f, -0.02852326f, -0.01376636f, -0.06839348f, 0.17882477f, 0.25787947f, -0.07704787f, 0.14452726f, 
    -0.30410585f, 0.04613028f, -0.03714255f, 0.04157493f, -0.10444879f, -0.02066300f, -0.15698411f, -0.23227835f, 
    0.12810923f, 0.36119169f, 0.08862421f, 0.19616809f, 0.17433849f, -0.27541038f, -0.17754447f, 0.31738988f, 
    0.10321665f, 0.25966305f, 0.30238172f, 0.17892350f, -0.00241227f, 0.17537001f, 0.09741164f, -0.05983206f, 
    -0.18124963f, 0.06694578f, -0.15350704f, -0.11685638f, -0.05883961f, 0.12290847f, 0.12623551f, 0.05355131f, 
    0.07851405f, 0.00661655f, 0.04238101f, -0.14072269f, -0.03169198f, 0.03944349f, 0.29004750f, 0.21274087f, 
    -0.11829067f, 0.16926029f, -0.01516306f, -0.08940647f, -0.08699249f, 0.09641121f, -0.15333170f, -0.04690098f, 
    -0.05185590f, -0.05602228f, 0.01759259f, 0.06532934f, 0.15298392f, -0.05253119f, -0.00648546f, -0.07113608f, 
    -0.14042291f, -0.13497412f, -0.12359433f, -0.28343794f, 0.16369753f, -0.04497801f, -0.08918428f, -0.23693597f, 
    0.04148795f, 0.21924302f, 0.14025147f, -0.03294842f, 0.06456223f, 0.32706326f, 0.00281672f, 0.24962419f, 
    0.24641576f, -0.27754503f, 0.20547508f, 0.01591956f, -0.09189190f, -0.13738060f, 0.08650449f, 0.17435424f, 
    -0.00849367f, 0.10561693f, -0.34671026f, 0.27760187f, -0.14888248f, -0.05797967f, 0.06770996f, -0.08805487f, 
    0.24497746f, 0.20817575f, -0.20592943f, 0.23590787f, 0.01136681f, -0.05965747f, -0.05095659f, 0.05269412f, 
    0.05326926f, 0.08540586f, 0.33913282f, -0.37250933f, -0.03317250f, -0.28452289f, 0.01874850f, -0.00937599f, 
    0.19436564f, 0.11860423f, -0.07044682f, 0.05236679f, 0.03973210f, 0.05551744f, 0.18802767f, 0.02156754f, 
    -0.00698631f, 0.10182359f, -0.07534299f, 0.11562692f, -0.07907626f, 0.11140744f, 0.03060260f, 0.14117512f, 
    -0.01357403f, -0.18866092f, 0.01565352f, -0.12013089f, 0.14103761f, -0.02503957f, 0.10414056f, -0.17397799f, 
    0.28059632f, -0.04728104f, 0.30721289f, 0.32626158f, 0.06909086f, 0.05150074f, 0.41909605f, 0.37032983f, 
    -0.13623007f, -0.10340941f, 0.01859307f, -0.16772571f, -0.20569237f, 0.01864875f, 0.29566616f, -0.19862190f, 
    -0.19300507f, 0.09817857f, -0.16190270f, 0.07627251f, 0.15974632f, 0.06321740f, 0.03093917f, 0.16674565f, 
    0.46279982f, -0.00640793f, 0.27467009f, 0.11144716f, -0.00827605f, -0.13005233f, -0.10244711f, -0.14460625f, 
    -0.03621985f, -0.27852577f, 0.09313565f, 0.22195259f, 0.09854757f, -0.04439060f, -0.11951847f, -0.09225689f, 
    0.03164813f, -0.07043561f, -0.08970780f, 0.00656807f, 0.44530794f, -0.10514443f, -0.08276206f, 0.06572074f, 
    0.14550120f, -0.05926895f, 0.05203626f, 0.00447043f, -0.05388517f, 0.05409562f, 0.04101549f, 0.08447340f, 
    0.29521206f, 0.24307126f, 0.12221700f, 0.30620995f, 0.02973766f, 0.11714587f, 0.15384620f, 0.26542416f, 
    0.28017387f, -0.23966676f, -0.10842982f, -0.01367659f, 0.04310347f, -0.06649472f, 0.27251586f, 0.08597023f, 
    -0.02521809f, 0.36780998f, 0.11362619f, -0.02986905f, 0.23816912f, 0.28170392f, -0.01696883f, -0.03001772f, 
    0.19631925f, -0.17213672f, -0.27735129f, -0.26545882f, 0.18178035f, 0.38238934f, -0.03901609f, 0.06439903f, 
    0.22152363f, 0.20860462f, -0.01619701f, -0.11164509f, 0.28704491f, -0.18582611f, -0.05425532f, -0.03334798f, 
    0.26000261f, 0.30744669f, 0.08215141f, 0.20758656f, -0.47634026f, -0.25886303f, 0.16161402f, 0.13906758f, 
    -0.04041937f, -0.24157843f, 0.00260207f, -0.32282895f, -0.34753475f, 0.07228324f, -0.21163531f, -0.02481959f, 
    0.14288451f, -0.43368828f, -0.08446531f, -0.03957876f, -0.39520606f, 0.02525429f, -0.08506199f, -0.21191134f, 
    -0.29796961f, 0.19034593f, 0.14580934f, 0.30733675f, 0.04984254f, 0.15956779f, 0.08143892f, 0.17616117f, 
    -0.09729721f, 0.03546921f, -0.25677970f, -0.04968831f, 0.10033613f, 0.35136086f, -0.07059563f, -0.34111103f, 
    -0.47619221f, 0.37099138f, 0.24565461f, 0.22212890f, 0.36432213f, 0.05954056f, 0.07656496f, 0.39909393f, 
    0.09078339f, 0.16009235f, 0.24326219f, 0.28339860f, -0.02901888f, 0.21462630f, 0.00644284f, 0.25537881f, 
    -0.17321642f, 0.02442276f, -0.03560038f, -0.16446351f, 0.01134425f, -0.19968598f, 0.08609510f, -0.10071405f, 
    -0.14618997f, -0.00510265f, -0.07050355f, -0.07502361f, -0.01011655f, 0.03058249f, 0.39342824f, -0.46926177f, 
    -0.19282687f, 0.15949008f, -0.00551496f, 0.03765712f, 0.12994969f, 0.15672103f, -0.07800516f, 0.21853043f, 
    -0.11715961f, -0.07915471f, -0.13579617f, 0.21346563f, -0.22658531f, -0.12871063f, -0.18274064f, -0.19571365f, 
    -0.01351369f, -0.02192329f, 0.14321901f, -0.22148602f, 0.52321863f, 0.07904256f, 0.06656530f, -0.24587059f, 
    -0.07178772f, 0.31186908f, -0.23539194f, 0.16628951f, 0.37661666f, -0.33116511f, -0.12797970f, -0.11385164f, 
    0.20056017f, 0.11304610f, 0.17544697f, -0.03121403f, 0.16036467f, -0.05616534f, 0.12785195f, 0.42390415f, 
    -0.08312501f, -0.27187344f, -0.55568182f, 0.24591552f, 0.14405799f, 0.01332723f, -0.02693182f, 0.30245104f, 
    0.00893425f, -0.01652688f, -0.09641021f, 0.06670059f, -0.02898578f, 0.02862135f, 0.01047253f, 0.07419867f, 
    -0.08755235f, 0.03750689f, 0.00902608f, -0.04639223f, 0.10737659f, 0.00399360f, -0.07945214f, 0.05311804f, 
    0.00645617f, 0.06436422f, 0.01286013f, -0.10356069f, 0.02381163f, -0.02114362f, -0.06735268f, -0.04917356f, 
    -0.10643701f, 0.05553768f, 0.04625556f, -0.09892192f, 0.04155741f, -0.08498459f, -0.00104187f, -0.06457829f, 
    0.04108774f, 0.00876845f, -0.09859622f, 0.06618279f, -0.08264986f, 0.00943060f, -0.05360263f, 0.03547565f, 
    0.01176183f, -0.05182967f, -0.01760875f, 0.05323323f, 0.04733732f, -0.11475706f, -0.05196229f, 0.03644916f, 
    0.00548337f, -0.01173282f, -0.08684812f, -0.00062169f, -0.10287321f, -0.09190631f, -0.02385820f, 0.01847023f, 
    -0.06577192f, -0.11691394f, 0.00892746f, -0.05529485f, -0.04897427f, -0.09690654f, -0.04371412f, -0.03450511f, 
    0.04863903f, 0.04318979f, -0.02496310f, 0.00123204f, -0.08252609f, 0.03837005f, -0.06920610f, 0.00929456f, 
    0.00458374f, -0.03089059f, 0.05716528f, -0.09174257f, 0.00674150f, 0.00328862f, 0.00303303f, -0.07718690f, 
    0.10671132f, -0.00665704f, -0.08536840f, -0.02685572f, -0.00458435f, -0.05292033f, -0.02429529f, 0.03766581f, 
    0.06633230f, 0.05964955f, -0.05197800f, 0.05292951f, 0.03894582f, 0.03982846f, -0.03669521f, -0.00164157f, 
    -0.06921120f, -0.04076209f, 0.06136494f, -0.04558354f, -0.07657760f, -0.07834591f, 0.02647694f, -0.10732655f, 
    0.02208973f, -0.02569011f, 0.02477645f, -0.07707132f, -0.01229069f, -0.00183489f, 0.02357698f, 0.01672377f, 
    0.01093770f, 0.03385655f, 0.03808878f, -0.06659546f, 0.03344695f, -0.06618462f, -0.07584412f, 0.01594635f, 
    0.06144384f, 0.03452899f, -0.08791824f, -0.07214566f, -0.07117981f, -0.04805857f, 0.02309928f, 0.05152918f, 
    0.50039870f, 0.35075009f, -0.10727745f, -0.17318791f, -0.18139304f, 0.14037983f, -0.03699155f, -0.08226556f, 
    -0.04098591f, 0.68025059f, 0.64033383f, -0.16245741f, 0.27818909f, 0.00349832f, 0.10874269f, 0.01489928f, 
    -0.18990271f, 0.11203798f, 0.15309152f, 0.09306564f, -0.09776466f, -0.08958972f, 0.24592538f, -0.02690979f, 
    0.17691527f, -0.03757760f, 0.02863401f, -0.04441664f, -0.21792562f, 0.04882109f, 0.07495824f, -0.02821161f, 
    -0.34225354f, 0.23445024f, -0.24513127f, -0.05699197f, 0.17440982f, 0.23257503f, -0.06898025f, -0.08521377f, 
    -0.07737631f, -0.05060202f, 0.16792357f, -0.12207916f, -0.15874799f, 0.00981859f, 0.03497078f, 0.20139098f, 
    -0.08610608f, -0.00204199f, -0.19001822f, 0.11029316f, -0.02011164f, 0.15921542f, -0.00529541f, 0.18711200f, 
    -0.11055396f, 0.21913628f, 0.32547596f, -0.01666282f, 0.27828938f, 0.10092342f, 0.01021872f, 0.16857538f, 
    -0.02026305f, 0.02005592f, 0.02690489f, 0.16103251f, -0.00118184f, -0.31220463f, -0.03469518f, 0.15141407f, 
    0.14385755f, -0.33479771f, 0.13549359f, -0.21169509f, 0.04241914f, 0.06026202f, 0.06170564f, 0.06755459f, 
    0.25405478f, -0.03058475f, 0.08568106f, -0.06230607f, 0.12243728f, -0.06600886f, -0.00100327f, 0.24571012f, 
    -0.35098225f, -0.09336995f, 0.17209302f, -0.16659395f, -0.10694696f, -0.05458228f, -0.06555776f, 0.25693199f, 
    -0.04984118f, 0.18256392f, 0.19883873f, -0.08965909f, 0.17014818f, 0.16722156f, -0.18212634f, -0.03590818f, 
    0.21679790f, 0.06681629f, 0.21839100f, 0.02002704f, -0.06786072f, 0.40491781f, 0.15293446f, 0.01198610f, 
    0.21136351f, 0.06572289f, -0.38205406f, -0.14228931f, 0.20023568f, 0.12550034f, -0.05235521f, 0.17654417f, 
    0.14452574f, 0.10101489f, 0.10045499f, -0.16504377f, 0.28178963f, -0.31088346f, -0.01563383f, 0.18271354f, 
    0.19729652f, 0.17647442f, 0.05394134f, 0.01203873f, -0.08294734f, 0.05153929f, 0.03312767f, -0.10093645f, 
    0.07632612f, -0.32280147f, 0.29389742f, -0.01234562f, -0.19579412f, -0.38580766f, -0.08008873f, 0.06842950f, 
    -0.16418529f, -0.05813352f, -0.08455408f, -0.02401872f, 0.05304709f, 0.08096599f, 0.29572394f, 0.03848292f, 
    0.06128472f, 0.13737169f, 0.01060794f, -0.14365213f, 0.02797372f, 0.02460467f, 0.24551833f, -0.02757286f, 
    -0.16602871f, 0.19925931f, -0.11654651f, -0.27778998f, 0.27995768f, -0.04036485f, -0.01657636f, -0.03215021f, 
    0.15750267f, -0.07549590f, 0.03195078f, 0.09536563f, 0.03770259f, 0.04693075f, 0.04045097f, 0.13275935f, 
    0.12075896f, 0.02750695f, 0.00861094f, -0.05303638f, 0.09443775f, 0.11816801f, 0.19042322f, 0.05622563f, 
    -0.09247665f, 0.08544085f, -0.01403582f, 0.05901896f, 0.33163273f, 0.11314175f, -0.08798598f, -0.03802016f, 
    0.15640138f, -0.04317471f, -0.10252084f, -0.00534023f, -0.00454108f, 0.04395430f, -0.17158778f, 0.00588121f, 
    -0.20435354f, -0.08336286f, -0.00106423f, -0.09411070f, 0.08331794f, 0.02765389f, 0.01209478f, -0.01148523f, 
    0.03284495f, 0.13762240f, 0.17682366f, 0.01936691f, 0.10711753f, 0.04058854f, -0.07664073f, 0.02187055f, 
    -0.06204103f, -0.00368352f, 0.29045501f, -0.02060840f, -0.27197918f, 0.22216125f, -0.16531867f, -0.07601175f, 
    0.04869240f, -0.26149169f, 0.00364185f, -0.11737122f, -0.13067390f, -0.04529343f, -0.05079924f, -0.16694139f, 
    0.36458340f, -0.01029850f, 0.25751001f, -0.08692672f, -0.08043942f, 0.27278131f, 0.16566168f, 0.13752706f, 
    0.15084316f, -0.07299874f, 0.04085385f, 0.00922614f, 0.14677504f, 0.24255197f, -0.08666488f, -0.12864435f, 
    -0.03200169f, 0.02212236f, -0.29359898f, -0.06657390f, 0.07234795f, -0.16799805f, -0.05496832f, -0.09036399f, 
    -0.01215517f, -0.02344802f, -0.03423872f, -0.03090986f, 0.06074325f, 0.06022134f, 0.08024299f, -0.03970960f, 
    -0.07261924f, 0.02580312f, 0.04397779f, -0.04652256f, -0.10353199f, -0.02288551f, -0.06845245f, -0.05837321f, 
    0.04288143f, 0.01241324f, 0.04039593f, 0.02053158f, 0.06733730f, -0.05654543f, -0.08652373f, -0.00729221f, 
    0.07861188f, 0.03226979f, 0.01630277f, -0.01262500f, -0.03453784f, 0.06057703f, 0.05402290f, -0.03727268f, 
    -0.17413937f, 0.05475290f, -0.07152906f, 0.05136436f, -0.08575889f, 0.06135055f, 0.02689905f, -0.06369911f, 
    -0.04071825f, -0.07495809f, 0.01467462f, -0.05336138f, -0.05444638f, 0.01313362f, 0.06934027f, -0.05845466f, 
    -0.08136630f, -0.01390345f, -0.09085550f, -0.01638314f, -0.02340415f, 0.06922740f, 0.05551903f, 0.03159641f, 
    0.03074602f, 0.04382899f, 0.03746984f, -0.03714592f, 0.04024201f, 0.05505427f, 0.03308482f, -0.05283090f, 
    0.05058573f, -0.02546119f, -0.09353913f, -0.07560883f, -0.03353934f, -0.12500595f, -0.07348406f, -0.12539928f, 
    -0.01107376f, -0.08072114f, -0.05038399f, -0.05389546f, 0.01846464f, 0.08151311f, 0.00706898f, -0.00602538f, 
    0.07079265f, 0.02209569f, -0.01679715f, 0.04652904f, -0.07317046f, 0.01448904f, -0.03368173f, -0.03835304f, 
    -0.01372927f, -0.02119570f, 0.07076459f, -0.08259395f, -0.07618351f, 0.01865198f, 0.00295745f, -0.00965865f, 
    -0.03303707f, 0.00813763f, -0.07080468f, -0.11790280f, -0.07263216f, 0.06521796f, 0.04825203f, 0.05080814f, 
    0.03487736f, -0.03528892f, 0.09114181f, 0.00935176f, -0.02319265f, 0.02925666f, -0.02727222f, 0.05854126f, 
    0.06529447f, -0.06357590f, -0.00398016f, -0.09227884f, -0.04464458f, -0.05739658f, -0.07870920f, 0.07607333f, 
    -0.03936473f, -0.05890043f, -0.00439506f, -0.08746322f, 0.05320389f, -0.01861083f, -0.03770427f, -0.03184940f, 
    0.00749236f, -0.20681146f, 0.15774858f, 0.16489142f, 0.11034215f, 0.27110881f, -0.01688625f, 0.02570301f, 
    -0.04548313f, -0.00550927f, -0.19223368f, 0.20196506f, 0.02504101f, 0.23611443f, -0.29062426f, 0.09287453f, 
    0.09516703f, 0.12510115f, -0.24444892f, 0.16014904f, -0.08324422f, -0.03042771f, 0.40314460f, -0.00887595f, 
    0.00647902f, 0.08566304f, -0.02732555f, -0.05070337f, 0.60057861f, 0.03695627f, 0.17338556f, 0.31698090f, 
    -0.13581596f, 0.30125976f, -0.88920420f, -0.10711826f, 0.14063263f, -0.28185809f, -0.44119817f, -0.09549493f, 
    0.26480976f, -0.05392040f, 0.15285464f, 0.04493555f, 0.36119956f, -0.30102310f, 0.17515266f, 0.15580983f, 
    -0.52535814f, -0.00788928f, -0.04182438f, -0.23218839f, -0.06106210f, -0.01873997f, 0.12188657f, -0.01256912f, 
    0.15782522f, -0.04193102f, -0.14736252f, -0.18822570f, -0.20151839f, 0.10278448f, -0.21275474f, 0.03157728f, 
    -0.14529967f, 0.06516927f, 0.06156399f, -0.02166384f, 0.03185456f, 0.19840753f, -0.36475283f, 0.06377640f, 
    -0.17919640f, 0.11316010f, -0.01186179f, 0.31203255f, 0.01734742f, 0.03730708f, -0.12395333f, 0.29556611f, 
    -0.04500061f, 0.12482472f, 0.12014084f, -0.07239942f, -0.25208068f, 0.05160510f, -0.09908664f, -0.45984203f, 
    -0.20451382f, 0.07595526f, 0.09132300f, -0.05910490f, -0.52169967f, 0.08637732f, 0.10409812f, 0.08697832f, 
    0.20915720f, -0.14077114f, 0.11038198f, -0.30425411f, 0.08964092f, 0.05387949f, 0.14680763f, -0.03383982f, 
    -0.04157879f, -0.08323339f, 0.11767005f, -0.07725393f, -0.16263613f, 0.09608364f, 0.00741976f, 0.30180219f, 
    -0.11191048f, 0.12902887f, -0.05574275f, 0.12027627f, -0.03121420f, 0.13500270f, -0.07652998f, -0.04584930f, 
    0.19778451f, -0.04156075f, 0.29848397f, -0.07848057f, -0.17241520f, 0.15089791f, -0.03470480f, -0.15699068f, 
    -0.03741800f, 0.27633804f, -0.03376720f, 0.18050881f, 0.15231025f, 0.01351789f, -0.07550818f, 0.06544148f, 
    0.07074562f, -0.43491989f, -0.04695077f, -0.11716309f, 0.08168603f, 0.12965181f, -0.12584509f, 0.26526058f, 
    0.05859995f, 0.26905617f, 0.02597202f, -0.03784170f, -0.04593959f, 0.08674543f, 0.29043150f, -0.03050103f, 
    -0.15096045f, 0.23054767f, 0.00827781f, -0.20650682f, -0.06564292f, -0.25568965f, 0.34739429f, 0.28063574f, 
    0.08274149f, 0.04836142f, -0.25134790f, -0.19593205f, 0.17796828f, 0.30756339f, 0.02768749f, -0.14794913f, 
    -0.07863516f, -0.00205356f, 0.30890983f, 0.33366340f, 0.01098468f, -0.04307843f, 0.40882620f, 0.05141107f, 
    0.01410681f, 0.24634613f, -0.01894202f, -0.04364720f, 0.04126047f, -0.16787803f, -0.06021683f, -0.03463147f, 
    0.06766100f, 0.11526737f, 0.12100860f, 0.08403914f, 0.16430555f, 0.02062048f, 0.14746322f, -0.18089385f, 
    0.44716489f, -0.04019789f, 0.02772900f, 0.09638635f, 0.05766525f, 0.11148862f, -0.03133310f, -0.32412818f, 
    -0.15702192f, -0.11031916f, -0.07388879f, -0.00666307f, -0.03758549f, -0.00944864f, -0.09476751f, 0.09582216f, 
    -0.41792914f, 0.08004587f, 0.35939220f, -0.02454459f, -0.09240101f, -0.04025582f, -0.15314680f, -0.19884762f, 
    0.40629157f, -0.01146154f, 0.27955025f, 0.06605659f, -0.04279587f, 0.38251239f, 0.19553265f, -0.10419460f, 
    0.31598926f, 0.00355017f, -0.06313603f, 0.00606145f, -0.23959285f, 0.29283860f, 0.07126825f, -0.40306956f, 
    0.34142449f, 0.08278038f, -0.05994603f, 0.02469204f, -0.10193136f, 0.15012234f, 0.40008581f, 0.30235648f, 
    0.01856775f, -0.18820299f, 0.09092949f, -0.06950773f, -0.08026099f, 0.33135620f, 0.16729243f, -0.08542218f, 
    0.33830714f, -0.04186255f, 0.10107899f, -0.14114031f, 0.04511390f, 0.17053096f, 0.04999367f, -0.03549391f, 
    0.35906574f, 0.20138234f, -0.02526384f, -0.03554114f, 0.04033305f, -0.05247742f, -0.06209414f, -0.05419873f, 
    -0.30036768f, 0.39746156f, 0.23814414f, 0.07898001f, 0.36866653f, 0.06775713f, -0.01200957f, 0.02010296f, 
    -0.19001643f, 0.10327971f, 0.14635837f, 0.06093647f, -0.05192795f, 0.08932169f, 0.13080738f, 0.00987295f, 
    -0.07064185f, -0.21821384f, 0.04056628f, -0.23286206f, -0.49183872f, -0.04959767f, 0.11270016f, -0.02402086f, 
    -0.22749476f, 0.10226538f, -0.03944635f, 0.05080217f, 0.07791156f, 0.21026820f, 0.00543832f, 0.01339808f, 
    -0.10069528f, -0.05896147f, 0.22448283f, -0.02893605f, -0.22665359f, 0.01708084f, -0.02308471f, 0.27766904f, 
    0.01911749f, 0.02360797f, -0.13218616f, 0.02900475f, -0.20691326f, 0.02793911f, -0.07620994f, 0.34281084f, 
    -0.20061617f, 0.16467667f, 0.48243257f, 0.14771670f, 0.24352539f, 0.01273212f, 0.23300073f, 0.23369417f, 
    -0.33709866f, -0.01511315f, -0.08996969f, 0.23517384f, -0.03206843f, -0.35605580f, 0.01244533f, 0.03737925f, 
    0.21426255f, -0.25251275f, -0.12489844f, -0.09191991f, -0.08130006f, 0.00949865f, 0.30620673f, -0.11535104f, 
    0.00796474f, 0.00357540f, 0.14440608f, -0.01865334f, 0.13742544f, -0.12465447f, -0.05810903f, 0.12207585f, 
    -0.14899738f, -0.06901782f, -0.00540466f, -0.10722604f, -0.31083941f, -0.04562322f, -0.18140014f, 0.20097095f, 
    -0.00047421f, 0.01382923f, 0.18140240f, -0.02530099f, 0.29370520f, 0.27107397f, -0.23143558f, 0.05608463f, 
    0.17736493f, 0.07776928f, 0.09735884f, -0.05465110f, -0.01766890f, 0.27328292f, 0.02993313f, 0.08093212f, 
    -0.00939637f, 0.20446107f, -0.17670117f, -0.47068688f, 0.24846324f, 0.04616341f, -0.19030769f, -0.01228410f, 
    0.06874494f, -0.08462545f, -0.01921439f, -0.02045325f, 0.31154338f, -0.20334661f, 0.09894366f, 0.04940798f, 
    0.04833436f, 0.02768223f, -0.02775957f, 0.00616042f, -0.08341578f, -0.12531771f, -0.04209887f, -0.00644415f, 
    -0.06023670f, -0.01172538f, -0.06826518f, -0.03039613f, -0.01827501f, 0.06244978f, -0.02087573f, 0.00313032f, 
    0.01791635f, -0.08338447f, -0.02819045f, -0.00518182f, -0.04265481f, -0.00907438f, -0.04499673f, -0.04590911f, 
    -0.00417182f, -0.08382207f, -0.02627215f, -0.08462629f, 0.02913919f, -0.07514650f, -0.11678321f, 0.02192991f, 
    -0.03375510f, 0.01166133f, -0.03539277f, -0.05828644f, -0.09897992f, -0.11133675f, -0.07056193f, -0.10770650f, 
    0.00022136f, -0.03720578f, -0.01337613f, -0.10560760f, -0.12603565f, 0.01307920f, -0.02938905f, -0.00503391f, 
    -0.09251476f, 0.04771684f, -0.03834833f, -0.12171971f, 0.08019706f, -0.01576415f, -0.00759030f, -0.00134323f, 
    0.00298304f, -0.02778257f, -0.03994693f, -0.12065616f, -0.10201245f, -0.05644998f, 0.00028077f, -0.01273383f, 
    -0.02479749f, -0.05646652f, -0.04919442f, -0.04742566f, -0.03996795f, -0.01976465f, -0.12727170f, 0.01296653f, 
    -0.00530480f, -0.07753957f, 0.00870301f, -0.04239906f, 0.02598123f, -0.05749679f, -0.02090105f, 0.03094365f, 
    0.02475821f, 0.06141449f, -0.05760275f, -0.02429645f, 0.03488186f, -0.09418184f, -0.01572321f, -0.08620333f, 
    -0.04522100f, 0.00246112f, 0.01329164f, -0.12566975f, -0.00016907f, -0.03263432f, 0.00325105f, -0.07232615f, 
    -0.00563256f, -0.02519093f, -0.06848685f, -0.00500196f, 0.04843717f, 0.06380541f, -0.14044741f, -0.08916267f, 
    0.01923526f, -0.11177163f, 0.03362940f, 0.04823342f, -0.01997447f, -0.12057381f, -0.02482588f, -0.02692306f, 
    -0.05093408f, 0.00831856f, -0.03019870f, -0.05588196f, 0.03688521f, -0.07164822f, -0.01027066f, -0.05419898f, 
    -0.06769661f, -0.03501408f, 0.06015202f, -0.03295894f, -0.00461154f, 0.00028816f, 0.05532127f, -0.06623147f, 
    0.08306371f, -0.08794072f, 0.02748974f, 0.01874010f, -0.05168235f, -0.04062337f, -0.01193926f, -0.04063074f, 
    -0.07431553f, -0.07479480f, 0.06149952f, -0.10795048f, 0.07742286f, -0.06044161f, 0.04735295f, -0.05076422f, 
    -0.01655538f, 0.05714406f, -0.06436913f, -0.06347449f, -0.00517485f, -0.04951759f, -0.08596187f, -0.06732319f, 
    0.05289086f, -0.01108095f, 0.05386769f, -0.09767962f, 0.02189872f, -0.00111506f, -0.04341003f, -0.05804581f, 
    -0.10198940f, -0.01004960f, -0.05220181f, 0.05471443f, -0.10545413f, -0.07101729f, -0.08056617f, 0.00100006f, 
    -0.10976990f, 0.04723241f, 0.05034093f, 0.02828351f, -0.09633295f, -0.08442044f, 0.00726275f, -0.06751603f, 
    0.04285704f, -0.01278172f, -0.03171699f, 0.03762532f, 0.03474588f, 0.01992277f, -0.04646633f, -0.07053810f, 
    -0.01436867f, -0.09747881f, -0.10372448f, 0.01302324f, -0.01099740f, -0.04895181f, -0.11329486f, 0.05065976f, 
    0.01294146f, -0.03205920f, 0.00373303f, -0.08765752f, 0.00085323f, 0.04844604f, 0.02771614f, -0.11652503f, 
    -0.08271562f, -0.10931046f, 0.05806272f, -0.00370557f, 0.00510869f, -0.04852460f, -0.07820336f, -0.06683353f, 
    -0.04851053f, -0.10645490f, -0.10169849f, 0.07150920f, -0.10121726f, -0.01564028f, 0.01752869f, -0.06687339f, 
    -0.07314443f, -0.03784339f, -0.02304172f, 0.00303713f, -0.03259676f, -0.10012628f, -0.06831221f, -0.04458865f, 
    -0.07950953f, -0.00625123f, 0.01972285f, -0.00200135f, -0.05872058f, -0.10983770f, 0.02498168f, -0.09027890f, 
    0.04998550f, -0.09228726f, 0.02247622f, -0.06887347f, -0.09339542f, 0.04513816f, 0.05448676f, 0.02919342f, 
    0.05116598f, -0.03931619f, -0.02269533f, 0.04146678f, -0.11346359f, 0.00681416f, 0.03317000f, -0.08154039f, 
    -0.02104507f, -0.06204295f, 0.01883949f, -0.10025380f, -0.06463596f, -0.08943905f, 0.06695361f, -0.06579358f, 
    -0.01078488f, 0.05758022f, 0.00910556f, -0.10155498f, -0.06435302f, 0.00994822f, 0.06889765f, -0.01838730f, 
    0.04484687f, 0.04748201f, -0.08478726f, -0.10900041f, -0.08762646f, 0.05914143f, -0.09236826f, 0.02694491f, 
    -0.09748784f, -0.03260573f, 0.00224287f, -0.05767511f, -0.03463133f, 0.02278453f, 0.01980965f, 0.04036426f, 
    -0.10204506f, -0.04818936f, -0.07788485f, -0.01313431f, 0.05345539f, -0.04614116f, 0.05221206f, -0.06061853f, 
    -0.09092205f, -0.02891874f, -0.06518124f, 0.08708926f, -0.10091891f, -0.10580637f, -0.03360821f, -0.07056552f, 
    -0.09503891f, -0.01442251f, -0.06387354f, 0.01441602f, 0.05528967f, -0.08164380f, 0.00273178f, 0.07003769f, 
    0.08486960f, -0.11028801f, 0.02013026f, -0.01887141f, -0.07600717f, -0.01221252f, 0.02164805f, 0.05803676f, 
    -0.03949287f, -0.09291646f, 0.02947201f, -0.10169964f, -0.00488559f, 0.00113520f, -0.06518537f, 0.06036269f, 
    -0.01592706f, -0.03299585f, 0.01650080f, -0.04690007f, 0.01741863f, -0.08559398f, 0.00199353f, 0.02133733f, 
    -0.01295656f, -0.10206717f, 0.04631676f, -0.05676898f, 0.01367890f, 0.07843818f, 0.01803548f, -0.02938710f, 
    -0.03656549f, -0.07309768f, -0.08896992f, -0.05464853f, -0.03776358f, -0.04122175f, 0.03257247f, -0.10217791f, 
    -0.04368930f, 0.05031225f, -0.03189595f, 0.01848424f, -0.00587408f, -0.06550239f, -0.03077746f, -0.05108102f, 
    -0.02161242f, -0.03469895f, -0.02723242f, 0.06689803f, 0.01678098f, -0.01603100f, -0.08667548f, 0.03331319f, 
    -0.06665389f, -0.03629859f, -0.01654900f, -0.11530890f, 0.04521114f, -0.03257582f, 0.01706414f, 0.04869618f, 
    -0.03782009f, 0.05105165f, 0.00984937f, -0.03897912f, -0.07473426f, -0.04563953f, -0.07902181f, -0.08591958f, 
    -0.10050499f, -0.10526799f, 0.05317519f, -0.11008051f, -0.07876047f, -0.09734178f, 0.04347965f, 0.03934464f, 
    0.25821036f, 0.27564272f, -0.07592902f, -0.02087809f, 0.07860838f, 0.05623223f, -0.02914603f, 0.04631918f, 
    -0.40654546f, 0.18244208f, -0.20517366f, -0.07741684f, 0.26090282f, -0.44157264f, -0.03041855f, 0.09678157f, 
    -0.43761060f, 0.00170815f, -0.15220520f, 0.08176944f, -0.16582476f, 0.14613341f, 0.03137493f, 0.03288855f, 
    -0.48560578f, -0.24279837f, -0.04746250f, -0.19792604f, -0.29082227f, 0.00879545f, -0.00996107f, -0.40682048f, 
    -0.07368458f, 0.24134459f, 0.14459762f, 0.00204698f, -0.03882197f, 0.21068752f, 0.42351842f, 0.08450702f, 
    0.01777135f, 0.01296855f, 0.07200875f, -0.07276857f, -0.40591466f, 0.18973279f, 0.00638580f, 0.21401906f, 
    -0.39671117f, -0.02078293f, -0.16251650f, -0.02366327f, -0.13549109f, 0.10536141f, -0.08125668f, 0.24244982f, 
    -0.13813359f, 0.38946095f, 0.30077869f, 0.07069448f, 0.46104044f, 0.10720328f, 0.34267357f, 0.28745964f, 
    -0.18290214f, 0.06392390f, 0.06082388f, 0.09153794f, 0.02292956f, -0.10054948f, -0.01544012f, -0.20308857f, 
    0.06760152f, -0.15202123f, -0.10536081f, -0.07796788f, -0.07584146f, 0.04228677f, 0.14786968f, 0.00727873f, 
    -0.08467313f, -0.06404151f, 0.05905276f, -0.04561597f, 0.49470323f, -0.09991673f, 0.12839021f, 0.29257727f, 
    0.04223955f, 0.02353404f, 0.10645445f, 0.17394434f, -0.30111745f, 0.00803395f, -0.27685606f, 0.22962923f, 
    0.01172859f, -0.05774384f, 0.11295761f, 0.22871955f, 0.07160590f, 0.18039340f, -0.46882385f, 0.29115546f, 
    0.26982808f, -0.01300153f, 0.03627815f, -0.00975500f, 0.06328608f, 0.36771458f, 0.06141210f, -0.04974210f, 
    0.22067739f, 0.33609638f, -0.12670040f, -0.42288142f, 0.50074887f, -0.04497604f, 0.03644373f, -0.05621488f, 
    -0.09775370f, -0.47454485f, -0.28483626f, 0.02203717f, 0.16084772f, 0.02780536f, 0.07372957f, -0.15886162f, 
    -0.06664597f, 0.01594920f, -0.06260750f, -0.07129883f, -0.09208119f, 0.05209856f, 0.06452846f, 0.07396889f, 
    -0.07944255f, 0.03867749f, 0.04345949f, -0.07026333f, -0.03989256f, 0.07183459f, -0.01215672f, 0.04804966f, 
    0.06898995f, -0.02818734f, -0.03727947f, -0.03010773f, -0.07448122f, -0.07294911f, -0.05353088f, 0.02207650f, 
    0.02461313f, 0.02492746f, -0.01171201f, -0.08581699f, 0.07629091f, 0.03351179f, 0.05777646f, -0.09213663f, 
    -0.05763449f, -0.00713778f, -0.07095485f, -0.09063812f, -0.07292140f, 0.00228559f, 0.03512435f, -0.01667646f, 
    -0.00896535f, -0.04023981f, 0.05580812f, -0.01286141f, -0.04173094f, 0.05125710f, -0.04467539f, 0.00579275f, 
    0.01334073f, 0.06033939f, 0.01895838f, 0.05990131f, 0.06264194f, 0.02056584f, 0.03311156f, -0.00014306f, 
    0.02166880f, -0.03506947f, -0.01403903f, 0.06303775f, 0.01368008f, -0.08047830f, 0.03700250f, -0.06013162f, 
    -0.05256072f, -0.07063411f, 0.01134284f, 0.00542472f, 0.08362187f, 0.04986002f, -0.05172133f, 0.07579921f, 
    -0.08822194f, 0.01610710f, 0.00966596f, 0.06120484f, 0.02238997f, -0.03411564f, -0.09047125f, -0.04775659f, 
    0.00780481f, -0.08013697f, -0.08212766f, 0.03551737f, 0.07557507f, 0.03137023f, -0.07450622f, 0.00548323f, 
    0.04719103f, 0.01712289f, -0.00304330f, 0.01438931f, 0.02272987f, -0.07918283f, 0.00086497f, 0.04271369f, 
    -0.03895445f, -0.00676688f, -0.05471978f, -0.06500191f, -0.02669995f, -0.01748179f, -0.06727830f, 0.05614053f, 
    -0.00684279f, -0.05442424f, 0.06872620f, 0.06691851f, -0.01874661f, -0.07036083f, -0.01738578f, 0.07126125f, 
    0.00259452f, -0.08710057f, 0.03599117f, 0.00348475f, 0.06344564f, -0.05077075f, -0.03608365f, -0.03581415f, 
    -0.07396627f, -0.07622779f, -0.09388261f, 0.07113589f, 0.00226583f, -0.07361376f, -0.00568157f, -0.07826541f, 
    -0.08072129f, 0.05190308f, 0.01104802f, 0.00636360f, -0.07434179f, -0.04931510f, -0.01211308f, -0.00451673f, 
    -0.04456813f, 0.03323231f, -0.10174377f, -0.04524087f, -0.00353957f, -0.03835781f, -0.01297824f, 0.04030173f, 
    0.02789324f, 0.03375532f, -0.05963260f, -0.01056892f, -0.06945878f, -0.02280656f, 0.05550913f, 0.07173638f, 
    -0.02189918f, 0.00623966f, 0.02468970f, -0.07925010f, -0.11871231f, -0.06193683f, -0.03426963f, -0.05104070f, 
    0.00726865f, 0.01328805f, 0.00455688f, -0.00096122f, 0.07800035f, -0.14288132f, -0.14766385f, -0.11628563f, 
    -0.06500142f, -0.03265999f, -0.09141736f, -0.05341361f, -0.01474489f, -0.03915714f, -0.04106256f, 0.01404583f, 
    0.02725006f, -0.03501990f, -0.06228575f, -0.05781708f, -0.11620463f, 0.01508693f, -0.04583566f, -0.02003247f, 
    -0.03617918f, -0.13302103f, -0.05435763f, 0.02624511f, -0.05328335f, -0.01650510f, 0.01175562f, -0.10007937f, 
    0.04053682f, -0.01114624f, -0.04960151f, -0.07860194f, -0.08124862f, 0.03799886f, -0.01444762f, 0.00616987f, 
    -0.03330062f, -0.00076863f, 0.05273871f, -0.02002884f, -0.08066991f, -0.03064956f, -0.04863154f, 0.00612532f, 
    -0.04732279f, -0.01836777f, -0.05762493f, 0.01988452f, 0.04260705f, -0.00883231f, -0.00150538f, -0.09670271f, 
    -0.08253057f, 0.03256147f, -0.06687573f, -0.00619102f, -0.07902072f, -0.06026309f, -0.01529630f, -0.03802668f, 
    0.01149118f, -0.08447661f, -0.10049221f, -0.09310476f, 0.05195758f, -0.08908627f, -0.01344776f, -0.09759019f, 
    -0.01102910f, -0.09947309f, -0.00494196f, -0.06089434f, -0.01127723f, -0.06334438f, 0.04534720f, -0.06976151f, 
    -0.08132035f, -0.10288008f, -0.04761191f, -0.05614064f, -0.08982276f, 0.02634418f, -0.06929447f, -0.08137855f, 
    0.00287058f, 0.01923351f, 0.05593443f, 0.02309352f, 0.01160655f, 0.00333743f, -0.02370489f, 0.02705229f, 
    0.12527749f, -0.03862733f, 0.01985981f, 0.03243350f, -0.05017835f, -0.08907090f, -0.07980111f, -0.00895047f, 
    0.00986144f, -0.08966118f, -0.05922679f, 0.01277188f, -0.11314058f, 0.03438774f, -0.09917898f, 0.08939324f, 
    0.03989583f, 0.02907788f, -0.03543484f, -0.12458692f, -0.08090980f, -0.06742930f, 0.00012450f, 0.05140456f, 
    -0.08377224f, 0.10534795f, 0.05455994f, -0.05368033f, -0.02353415f, 0.05661134f, 0.06821144f, -0.04056276f, 
    0.05129271f, -0.16199119f, -0.08825381f, -0.09198343f, -0.05538170f, 0.10850531f, -0.01819724f, -0.05065169f, 
    -0.09354978f, -0.02870118f, 0.06034112f, 0.01528662f, -0.05301189f, 0.02068414f, 0.01481362f, 0.06669364f, 
    0.01763861f, 0.06723937f, 0.05946244f, 0.00798288f, 0.01828305f, -0.09165798f, -0.00138313f, 0.00985676f, 
    0.02357245f, 0.10073256f, -0.07705478f, -0.01140515f, -0.08175142f, 0.06271185f, 0.06860006f, -0.09019438f, 
    -0.05053015f, -0.08336069f, -0.03130042f, -0.12386920f, -0.04169926f, 0.01981225f, -0.07848784f, -0.07109844f, 
    -0.10503734f, 0.04250729f, 0.04294635f, -0.04370290f, -0.00250499f, 0.01033649f, -0.03070983f, -0.00075554f, 
    -0.08681464f, 0.01946816f, -0.03089680f, -0.03022092f, 0.09245997f, 0.05934986f, 0.00184942f, 0.01078065f, 
    -0.00827250f, -0.02900953f, -0.03164174f, -0.08193534f, 0.00247466f, -0.01349536f, 0.07966441f, -0.01395675f, 
    0.04063370f, 0.18344033f, -0.11630359f, -0.00014713f, -0.08816981f, -0.08893254f, -0.02479588f, 0.05663062f, 
    0.00114446f, -0.17641740f, -0.10239061f, -0.01741342f, -0.01789755f, -0.04122815f, 0.10893986f, 0.07732129f, 
    -0.02913936f, -0.09146935f, 0.03482124f, 0.00901785f, -0.03884700f, -0.06516428f, -0.00854692f, -0.07561887f, 
    -0.04990070f, -0.06450133f, 0.05626483f, 0.02513572f, -0.09843194f, 0.01607300f, 0.04962472f, -0.04498691f, 
    0.40799150f, -0.03149072f, 0.24500504f, 0.04572497f, 0.19068557f, 0.05772169f, 0.00680579f, -0.04058357f, 
    -0.19193378f, 0.37211972f, -0.28361079f, 0.43998575f, -0.16113880f, 0.03758794f, -0.10692175f, 0.28608745f, 
    -0.07314374f, 0.03293733f, -0.54151946f, -0.07152623f, -0.50500578f, 0.08432372f, 0.48599011f, -0.05107145f, 
    -0.32601202f, -0.18598872f, 0.03655376f, -0.21290195f, -0.46424356f, -0.29876250f, 0.28347051f, 0.25593168f, 
    -0.55752271f, 0.50897104f, -0.00223483f, -0.12244841f, 0.12666225f, -0.26855928f, -0.21691436f, 0.03809156f, 
    0.13732940f, 0.01751049f, 0.10251607f, -0.01500450f, 0.16106349f, -0.00981745f, 0.03087674f, 0.06371720f, 
    -0.60958809f, 0.17302963f, 0.12737070f, -0.07056348f, -0.10537189f, -0.01469338f, 0.16794510f, 0.40393725f, 
    0.11159524f, 0.04267907f, 0.27876675f, 0.07969578f, -0.06933561f, 0.14763878f, -0.05195891f, 0.18791793f, 
    -0.01017300f, -0.07922264f, -0.10762893f, -0.31047222f, -0.04301115f, -0.57201254f, -0.10830563f, -0.50316030f, 
    -0.27046189f, 0.10731421f, 0.07854056f, 0.21707031f, -0.04872340f, -0.06082315f, 0.32197291f, -0.04255192f, 
    0.04002357f, 0.02344360f, 0.10929066f, 0.04913715f, 0.00493069f, -0.09138854f, -0.12517074f, 0.08378645f, 
    -0.36434332f, -0.02818098f, 0.11878233f, 0.19494495f, -0.69918686f, -0.15963170f, -0.36362669f, -0.05259071f, 
    0.07749771f, -0.10100745f, 0.06749114f, -0.45930257f, 0.27648604f, -0.15298182f, 0.14795458f, -0.01689560f, 
    -0.07567915f, 0.25163072f, -0.25885910f, 0.04307516f, 0.14237152f, 0.15096687f, -0.18826036f, 0.18922441f, 
    0.20468532f, 0.06872495f, 0.10264386f, -0.36735877f, 0.29308617f, -0.08982942f, -0.08936805f, 0.10164373f, 
    -0.08385249f, -0.16450629f, -0.00730666f, 0.10477575f, -0.27986696f, 0.15705037f, 0.00708306f, -0.40282646f, 
    0.55491489f, 0.02217055f, -0.13958135f, 0.06138613f, -0.22629343f, -0.02058559f, 0.02706848f, -0.05356278f, 
    -0.12907851f, 0.27176648f, 0.03613769f, -0.11186264f, 0.30769014f, -0.16207355f, -0.04503528f, -0.11181228f, 
    0.00845069f, 0.05810756f, -0.08248307f, -0.15474024f, -0.00942336f, 0.01885485f, 0.25431037f, 0.00522071f, 
    -0.08122373f, -0.10856428f, -0.04399418f, -0.11013442f, -0.02182560f, 0.21613847f, -0.05463472f, -0.17779070f, 
    -0.18697056f, 0.06012925f, -0.09430303f, -0.03474540f, 0.06739590f, 0.18059562f, 0.12602952f, -0.24335067f, 
    0.25903779f, 0.05715689f, 0.05740276f, -0.08500375f, 0.12223995f, 0.10916445f, 0.05589167f, -0.04358819f, 
    -0.33518583f, -0.00751772f, 0.05976813f, 0.00209674f, 0.08628809f, 0.34152323f, 0.11197679f, 0.05525043f, 
    -0.03459315f, 0.12479031f, 0.20722847f, -0.13660546f, 0.23929881f, 0.04216165f, 0.09985562f, 0.01400062f, 
    -0.30923262f, -0.06142165f, 0.31533766f, -0.16808239f, 0.06758510f, -0.12240813f, -0.02350300f, 0.19677745f, 
    0.01074833f, -0.08922087f, -0.07456818f, 0.15821293f, 0.06928660f, -0.07806614f, 0.02350535f, 0.18859161f, 
    -0.35260758f, 0.08538935f, -0.12864718f, 0.00249149f, 0.41680196f, 0.09976432f, 0.02046976f, 0.07833648f, 
    -0.18551931f, 0.01357679f, 0.05761777f, -0.13633075f, -0.25445229f, 0.18587300f, 0.04661319f, 0.37097546f, 
    0.27236751f, -0.05901347f, 0.16210246f, -0.10190209f, -0.02577872f, -0.10813055f, 0.19422165f, 0.22110841f, 
    0.26470834f, -0.20056549f, -0.29268524f, 0.00702162f, -0.04060255f, 0.07947575f, 0.20141982f, -0.08666444f, 
    0.02021233f, 0.20800945f, -0.11458287f, -0.06104959f, 0.42408255f, 0.15167940f, 0.01867541f, 0.05286187f, 
    0.17528430f, -0.18996343f, 0.09464412f, -0.09099024f, -0.06376890f, 0.13562487f, 0.04971298f, 0.23531173f, 
    0.36415386f, 0.16188081f, 0.17683011f, -0.04097804f, -0.14021844f, -0.15245490f, 0.00938881f, -0.03097574f, 
    -0.10599855f, 0.33262557f, 0.36312267f, 0.10439207f, -0.30499652f, -0.13960519f, 0.06021650f, -0.13238665f, 
    -0.07451687f, -0.02154147f, -0.03204589f, -0.11858351f, -0.01940982f, 0.00636219f, -0.00339596f, 0.01836649f, 
    0.10419150f, -0.21523279f, 0.04768164f, -0.03360528f, -0.14466397f, -0.01981861f, -0.08622260f, -0.26509377f, 
    -0.08257078f, -0.06679309f, 0.07398563f, 0.63711023f, 0.18402423f, 0.02607602f, 0.19418442f, 0.01939084f, 
    -0.15286116f, 0.02350502f, -0.08009008f, -0.24114126f, -0.13850392f, 0.18823054f, -0.21283928f, 0.13328189f, 
    0.04076383f, 0.03345380f, -0.10581774f, -0.04179254f, 0.06717093f, 0.18517716f, -0.05783266f, 0.33226579f, 
    -0.06808648f, -0.06568251f, 0.07013892f, 0.05246891f, 0.32496819f, 0.12167815f, 0.03999570f, -0.02633586f, 
    -0.23856051f, -0.02411861f, -0.03371150f, -0.09624612f, -0.04758538f, 0.19550416f, 0.02272964f, 0.18812956f, 
    0.09630089f, -0.05673885f, 0.00343369f, -0.10422579f, -0.01801448f, 0.06202589f, -0.02467857f, -0.00833520f, 
    0.22420067f, 0.27325818f, -0.09270798f, 0.04990271f, 0.17251951f, 0.12280635f, 0.16899015f, 0.11179526f, 
    -0.16764624f, 0.00493141f, 0.05809307f, 0.03439728f, 0.11879911f, -0.02974923f, -0.03824819f, 0.11573815f, 
    0.09837423f, 0.19835353f, 0.06578058f, 0.15308014f, 0.04838606f, 0.07514941f, -0.17540067f, 0.22454917f, 
    0.07375151f, 0.02438605f, 0.10449126f, -0.00960661f, 0.05816335f, 0.04217185f, -0.07784016f, -0.11999112f, 
    0.12497731f, 0.02568307f, -0.02595169f, 0.04437949f, 0.15605485f, 0.12699060f, -0.04013211f, 0.16727844f, 
    -0.10818377f, 0.07900034f, -0.36180922f, -0.03112538f, 0.09344576f, -0.17274410f, 0.05804702f, 0.14123793f, 
    0.23618153f, 0.03064957f, 0.38142428f, 0.00176067f, 0.46882361f, -0.17175308f, -0.01358504f, -0.01771926f, 
    -0.12865481f, -0.13377561f, -0.37512627f, 0.54811335f, -0.21779197f, 0.30801269f, -0.11888470f, 0.32488513f, 
    -0.14331804f, -0.07383306f, -0.49604908f, 0.15299244f, -0.35967696f, 0.23383762f, 0.39105207f, -0.07557022f, 
    -0.13653891f, -0.08137529f, -0.01866679f, -0.48677078f, -0.27120045f, -0.82537091f, 0.28413692f, -0.08735956f, 
    -0.14600541f, 0.11459858f, 0.04293204f, 0.40399536f, 0.16419315f, 0.06780279f, -0.22901265f, 0.26370737f, 
    -0.23074748f, -0.06006615f, 0.00718143f, 0.21519946f, -0.22508384f, 0.03981103f, 0.11637979f, 0.27842858f, 
    -0.30036488f, 0.46650174f, 0.03728688f, 0.03442100f, 0.04926098f, -0.16822425f, -0.05321113f, 0.45868412f, 
    0.15451980f, 0.00954053f, 0.27098432f, 0.32950348f, -0.12726808f, 0.10320143f, 0.06282315f, 0.00840052f, 
    -0.18797675f, -0.03953280f, -0.37689343f, -0.39780128f, -0.05090639f, -0.52124721f, -0.07440168f, -0.41937664f, 
    -0.12249107f, 0.15862164f, 0.05346730f, -0.27991095f, -0.02579421f, -0.06568931f, 0.43814993f, 0.06743390f, 
    0.01011035f, 0.04285090f, 0.15108144f, 0.06168809f, -0.40422070f, -0.04766492f, -0.34174520f, -0.39741066f, 
    -0.40991315f, -0.01968292f, 0.02980232f, 0.18942232f, 0.11220902f, -0.17606409f, -0.39373448f, -0.41881564f, 
    -0.14292519f, 0.25020483f, -0.12095187f, -0.48512280f, 0.21755625f, 0.08536607f, -0.44930094f, -0.21780558f, 
    -0.00725120f, 0.34061673f, 0.28744492f, 0.02552104f, 0.17405203f, 0.10821464f, 0.06181889f, 0.38229984f, 
    0.03727186f, -0.05764711f, 0.25080571f, -0.66625077f, -0.01529284f, -0.06968513f, 0.08053394f, 0.01864028f, 
    -0.13042431f, -0.08679026f, -0.26184192f, 0.27656746f, -0.47350013f, -0.15335736f, -0.01854191f, -0.56250215f, 
    -0.47937533f, 0.16802217f, 0.00969236f, 0.07172421f, 0.26104897f, 0.11780619f, 0.05798289f, 0.01018554f, 
    0.17444190f, -0.64943933f, 0.16191505f, -0.31546032f, -0.07306879f, -0.09821579f, -0.12696853f, 0.20236742f, 
    -0.00897601f, -0.02415704f, 0.08538944f, -0.04290596f, -0.01790359f, 0.09490415f, -0.34067839f, 0.02919572f, 
    -0.06446886f, 0.13862464f, 0.04279855f, -0.07712483f, 0.06990844f, -0.32836017f, 0.25591919f, -0.38462654f, 
    0.22761846f, 0.08916529f, -0.14023459f, -0.23334204f, -0.00637889f, 0.11643044f, 0.12063993f, -0.02716760f, 
    -0.07251947f, 0.07662880f, -0.14374758f, 0.21569492f, -0.29213369f, -0.03663217f, 0.00731647f, -0.19575258f, 
    0.08541407f, 0.14867365f, -0.04874017f, 0.25154617f, 0.17172839f, -0.05047655f, -0.05751903f, -0.03998742f, 
    0.11288453f, 0.04522276f, 0.01868767f, 0.06558268f, 0.21730781f, -0.06943503f, 0.16048080f, 0.00912927f, 
    0.52300286f, -0.06486587f, -0.06158003f, 0.00639375f, -0.00978107f, -0.45360762f, 0.02022906f, -0.25640091f, 
    0.06201495f, 0.14131464f, 0.18052061f, -0.19985691f, -0.01278666f, -0.07916303f, -0.26478386f, -0.02467359f, 
    -0.16380602f, 0.08149042f, 0.16362615f, 0.10773385f, 0.07009044f, 0.17253368f, 0.05256394f, -0.09713078f, 
    0.11588325f, -0.03019530f, 0.23960379f, -0.00899241f, -0.29625475f, 0.30470675f, 0.14327443f, -0.37363419f, 
    -0.02209506f, 0.09312861f, 0.07746482f, 0.19047943f, -0.27321076f, 0.15461157f, -0.16007051f, -0.67780966f, 
    0.18942228f, 0.16170941f, 0.23542784f, 0.03754925f, -0.07766552f, 0.12999174f, 0.21918443f, 0.20345511f, 
    0.13683112f, -0.20490915f, 0.08919087f, -0.10678304f, -0.11051562f, 0.15906873f, 0.19850741f, -0.05166055f, 
    -0.09096222f, 0.11338991f, -0.14536412f, 0.06675912f, -0.16902290f, -0.16336073f, 0.07498261f, -0.15830255f, 
    -0.03426636f, 0.04591571f, 0.03318480f, -0.09084157f, 0.01323593f, 0.03422673f, 0.02867403f, -0.08661035f, 
    0.01772457f, -0.00545646f, -0.02576577f, 0.04665653f, 0.05476677f, 0.06535020f, 0.03217652f, 0.00644028f, 
    -0.06021832f, 0.03281176f, -0.06344012f, -0.03662676f, -0.01660365f, -0.07549309f, -0.04332138f, -0.07359764f, 
    -0.07778276f, -0.12635447f, 0.02110570f, -0.03663070f, -0.09000200f, -0.05729684f, -0.04063421f, 0.06224462f, 
    0.02199123f, -0.00173082f, 0.04161941f, -0.07020668f, 0.01788822f, -0.05356243f, -0.07587497f, -0.07774320f, 
    -0.07892257f, 0.01643123f, -0.02423747f, 0.01611637f, -0.03439393f, 0.01025478f, -0.07098897f, 0.04352755f, 
    -0.00895640f, -0.09388807f, -0.11564182f, -0.05382977f, -0.02408932f, -0.06506874f, -0.06437061f, 0.04488217f, 
    -0.10799120f, -0.06510322f, 0.04835395f, -0.05947844f, 0.00327874f, 0.02453309f, -0.13107750f, -0.03634523f, 
    -0.05902533f, -0.08656985f, -0.07943243f, 0.04031941f, 0.05906885f, -0.05165379f, -0.06506209f, -0.06116665f, 
    -0.11923455f, -0.03782435f, -0.07809576f, 0.03277129f, -0.02698166f, 0.01612204f, -0.05451519f, -0.01271501f, 
    -0.01224376f, 0.00134563f, -0.05168287f, 0.05615351f, -0.04428486f, -0.02756002f, 0.01423245f, -0.05393146f, 
    -0.03925464f, -0.08225655f, 0.05168807f, -0.08011004f, 0.01514340f, 0.03505522f, 0.04191618f, -0.00098655f, 
    0.00457943f, 0.03872147f, -0.08594077f, -0.09809495f, 0.05551390f, 0.01541857f, -0.12731437f, -0.05085138f, 
    0.04882844f, -0.02544666f, -0.09267575f, -0.10678679f, -0.00394280f, -0.02289889f, -0.07143793f, 0.02528951f, 
    0.03458104f, -0.10156340f, -0.07860327f, 0.04329598f, -0.09922951f, -0.04332064f, -0.12628248f, 0.01881641f, 
    -0.02979323f, 0.02901060f, 0.07833823f, -0.07013080f, 0.01668878f, 0.00067361f, 0.01226965f, -0.04654902f, 
    0.40899438f, 0.20796698f, 0.06880905f, 0.08192285f, 0.05786369f, -0.21345270f, -0.04562279f, -0.04568681f, 
    -0.37808496f, -0.37341595f, -0.32496828f, 0.06354973f, 0.11356954f, -0.25824064f, -0.14061335f, 0.17518891f, 
    -0.34890956f, 0.10568169f, -0.61353898f, 0.13401222f, -0.09684120f, 0.06519756f, 0.34666651f, 0.02132893f, 
    -0.43504813f, 0.05710290f, -0.01225773f, -0.56341320f, -0.09350860f, -0.16852698f, 0.19296764f, -0.34294942f, 
    0.11026549f, -0.00386359f, 0.01194251f, -0.46271667f, 0.15460259f, 0.11520711f, 0.19306163f, -0.01402435f, 
    0.02476052f, 0.06713426f, 0.01791980f, -0.06658097f, -0.29463342f, 0.17514607f, 0.27572909f, 0.15728796f, 
    -0.36964479f, 0.15738134f, 0.02033996f, -0.35229394f, 0.15011068f, 0.04191114f, 0.00182172f, 0.17689706f, 
    -0.02551233f, 0.12023990f, 0.08295834f, 0.02729654f, 0.50172031f, 0.13887060f, 0.21400619f, -0.08036175f, 
    -0.11930006f, 0.07520641f, 0.05814508f, -0.23374917f, 0.06431451f, -0.29407683f, -0.07411488f, -0.53241992f, 
    -0.24811670f, 0.11472411f, -0.02453038f, -0.05897564f, -0.06871106f, 0.07206001f, 0.06996268f, 0.23947908f, 
    -0.03389840f, 0.09169044f, 0.10341131f, 0.01663589f, 0.26954481f, 0.02601138f, -0.41162026f, -0.24156255f, 
    0.11758418f, 0.04233338f, 0.28452182f, 0.15728202f, -0.07728764f, 0.13770448f, -0.19322388f, -0.04242175f, 
    0.28456798f, -0.31656620f, 0.04945282f, 0.03753706f, -0.12970328f, -0.16957633f, -0.20580472f, 0.17018527f, 
    0.52430815f, -0.20854597f, -0.35990050f, -0.04802192f, 0.12873739f, 0.12927133f, 0.23025905f, 0.16054785f, 
    0.11314239f, 0.24460819f, 0.11887989f, -0.24882598f, 0.34682232f, 0.12506519f, 0.03098581f, -0.25155175f, 
    -0.01759160f, -0.69891071f, -0.12698998f, 0.00627390f, -0.17437814f, 0.46388832f, -0.05459645f, -0.40244702f, 
    -0.02921045f, -0.08460579f, 0.06313787f, -0.08029895f, 0.00818948f, -0.06235956f, 0.04784177f, 0.01764736f, 
    0.06379295f, 0.04949575f, 0.07218326f, -0.06992203f, -0.10953154f, 0.00441886f, -0.10740342f, 0.06251744f, 
    -0.00210451f, 0.04227225f, -0.04544383f, -0.08846821f, -0.07404190f, -0.06420065f, -0.02052143f, -0.05449288f, 
    0.00995804f, -0.00270962f, 0.06504799f, 0.06485696f, -0.02466133f, -0.05115730f, -0.01801417f, 0.00581667f, 
    -0.07293028f, -0.06383587f, 0.06950608f, 0.00251843f, 0.06923568f, 0.01044278f, 0.05444896f, 0.06596319f, 
    -0.03989874f, 0.07744054f, 0.01372838f, 0.05898980f, -0.01910761f, 0.03831473f, 0.00163464f, -0.10124731f, 
    0.04198896f, 0.01628286f, 0.07091357f, -0.09330672f, 0.01377584f, -0.07621745f, -0.08214326f, 0.00025489f, 
    -0.05565050f, -0.02374543f, -0.05984318f, -0.06180548f, 0.01934212f, -0.01474603f, 0.03598353f, -0.01558662f, 
    -0.06049106f, 0.04712470f, -0.11599284f, -0.10861154f, 0.05594492f, -0.07585108f, -0.01929649f, 0.04851708f, 
    -0.04388072f, 0.02095792f, 0.00848068f, 0.01917190f, 0.02024595f, -0.06448084f, 0.08728854f, -0.00274739f, 
    -0.10409519f, 0.00265285f, -0.06996451f, 0.03611816f, -0.13998529f, -0.01571170f, -0.07693048f, -0.07269985f, 
    -0.04916110f, 0.03889833f, -0.07050180f, 0.01103374f, -0.03792270f, -0.05740042f, 0.01816068f, -0.08323111f, 
    -0.08446286f, 0.07744312f, -0.10331831f, -0.01318080f, 0.06918951f, -0.02521895f, -0.09270096f, -0.09900775f, 
    0.02230763f, 0.00434231f, -0.06500168f, -0.04076515f, 0.01168520f, -0.08619274f, -0.05699295f, 0.02719501f, 
    -0.04893748f, 0.00135946f, -0.09478901f, -0.11180183f, -0.07128815f, -0.10296760f, -0.09880021f, -0.04444737f, 
    0.01046619f, -0.05000567f, -0.07484277f, -0.04729973f, 0.01326821f, -0.05082746f, -0.08264478f, -0.02154797f, 
    0.02034265f, -0.05091214f, -0.05863283f, -0.08996522f, -0.01079950f, -0.10545957f, 0.03847474f, 0.04652779f, 
    0.06211812f, -0.03623988f, -0.01028434f, 0.03586513f, -0.03313219f, -0.07088282f, -0.02687725f, -0.06534795f, 
    -0.04414957f, -0.05637002f, -0.06330380f, -0.05771555f, -0.03529143f, 0.04313340f, -0.11529225f, 0.00182782f, 
    -0.08433805f, 0.02273750f, 0.05573637f, -0.06605263f, -0.04380143f, -0.00840578f, 0.00793784f, -0.07442484f, 
    -0.07572977f, -0.00053052f, -0.05438979f, -0.03558446f, 0.03049760f, 0.07999895f, -0.02760416f, -0.08902735f, 
    -0.04580796f, -0.04745764f, -0.06566834f, -0.00915874f, -0.03996002f, -0.09070309f, -0.01661162f, -0.02573842f, 
    0.06272630f, -0.03420388f, -0.03697058f, -0.09435634f, -0.04047404f, 0.01158921f, -0.08887649f, 0.01189774f, 
    -0.10161399f, 0.02441186f, 0.02034658f, -0.02985878f, 0.04267211f, -0.09879440f, 0.03770210f, -0.07947172f, 
    0.07688076f, -0.05778333f, -0.00789803f, 0.05342843f, -0.03775408f, 0.04173199f, -0.01738780f, -0.07283523f, 
    -0.05216382f, 0.04726213f, 0.04604896f, 0.03260755f, 0.06268467f, -0.03878391f, -0.11514856f, 0.05579943f, 
    0.03815728f, -0.01873276f, -0.01871611f, -0.03449325f, 0.02528158f, -0.03085204f, 0.04580726f, -0.04481482f, 
    0.03872132f, 0.02017532f, -0.03849528f, -0.07455701f, 0.00696219f, -0.06655510f, 0.02887105f, 0.00328835f, 
    -0.09414019f, -0.08804400f, -0.03752814f, -0.05938967f, -0.04682110f, -0.01906138f, 0.05701118f, 0.05288072f, 
    0.06841964f, -0.09675135f, -0.03939362f, 0.04725235f, 0.02774521f, 0.09139928f, -0.02665563f, 0.04737550f, 
    -0.00310369f, 0.04472835f, -0.09753177f, -0.03042676f, 0.06508709f, -0.06405742f, -0.10569991f, -0.05078274f, 
    -0.04349159f, 0.05163535f, -0.00750365f, -0.02465046f, -0.09590853f, 0.00475478f, -0.07935188f, -0.08687482f, 
    -0.01980108f, -0.04544603f, 0.02155741f, -0.04289852f, -0.09165169f, -0.02467098f, -0.06182590f, -0.05854060f, 
    -0.03070568f, 0.01771029f, -0.00695996f, 0.06941450f, -0.03136645f, -0.00623920f, 0.05648005f, 0.00125652f, 
    -0.03350290f, 0.05006973f, 0.07362361f, 0.07152876f, -0.04676220f, 0.04029570f, -0.03333047f, -0.03179839f, 
    -0.05315590f, 0.02181976f, -0.02420253f, 0.06477477f, 0.05434632f, 0.06979620f, 0.00081907f, -0.09267373f, 
    -0.03317709f, 0.02956378f, 0.03023752f, -0.05036137f, -0.08458394f, 0.02116814f, 0.03976613f, -0.07531106f, 
    0.05941038f, 0.05542010f, -0.01477602f, 0.01700953f, 0.03149568f, -0.02765460f, 0.07105592f, -0.07826916f, 
    -0.07449336f, -0.07246821f, -0.02155912f, 0.04191427f, -0.03212552f, -0.02097522f, -0.02615361f, -0.00468080f, 
    0.02309215f, 0.00263820f, 0.01896971f, -0.03877540f, -0.03712175f, -0.05100976f, -0.04520375f, -0.05678761f, 
    -0.06552773f, -0.04281320f, -0.07638700f, 0.07566247f, 0.00085994f, -0.08564533f, -0.06057344f, -0.06588402f, 
    -0.01097258f, 0.04709148f, 0.07246646f, -0.07988636f, 0.06473339f, -0.00723495f, 0.01794917f, -0.06008390f, 
    -0.02464222f, -0.07103803f, -0.03376162f, -0.03176476f, -0.04994377f, -0.03403646f, -0.08131640f, 0.05217945f, 
    -0.01920710f, -0.04659623f, -0.01597591f, -0.07912019f, 0.03417535f, -0.01645047f, -0.04927226f, 0.00903769f, 
    0.04433163f, 0.07562530f, 0.04095658f, 0.04635656f, 0.03583649f, -0.04729561f, 0.00196890f, -0.01964772f, 
    0.06388369f, -0.02019001f, -0.02242250f, 0.00519401f, 0.04330918f, -0.08141073f, -0.09550267f, 0.03790883f, 
    -0.04495915f, -0.01267402f, -0.02617036f, -0.05496233f, -0.06750982f, 0.04525838f, 0.07791031f, 0.00387025f, 
    -0.03909046f, -0.06324695f, 0.06699418f, -0.00275197f, -0.09932560f, 0.04552910f, 0.06209437f, -0.04405984f, 
    0.09924292f, 0.00978989f, 0.06500483f, -0.02511915f, -0.03618306f, -0.05875161f, -0.06928906f, -0.06673018f, 
    -0.03252928f, 0.08097669f, -0.08392748f, -0.10937439f, -0.00666549f, -0.04698554f, 0.07129203f, -0.04611940f, 
    -0.08911937f, 0.05448667f, -0.06192819f, -0.02623644f, -0.05653167f, -0.02039713f, -0.01142427f, 0.03355477f, 
    0.05768545f, -0.06435923f, 0.08223088f, 0.02531548f, -0.05725591f, -0.07688179f, 0.02935470f, -0.00062361f, 
    -0.07241783f, -0.05788002f, 0.02841973f, 0.02072385f, -0.02304463f, 0.00671550f, -0.04818885f, 0.02058756f, 
    -0.05240240f, -0.02602235f, 0.00782824f, -0.10520534f, -0.11452755f, -0.06649187f, 0.02270999f, 0.00688489f, 
    -0.02240143f, 0.04300905f, -0.05124898f, -0.01190596f, 0.06677634f, 0.00216430f, -0.07617286f, 0.02180514f, 
    0.01613477f, -0.01275784f, 0.06158315f, 0.04269631f, -0.03062999f, -0.01800380f, 0.08397143f, -0.02436365f, 
    -0.04435368f, -0.02926542f, -0.04778273f, -0.04914614f, 0.06968027f, -0.05224166f, -0.02785180f, 0.03148337f, 
    -0.00296295f, -0.09035377f, 0.04955030f, -0.06690686f, 0.01578617f, -0.00924979f, 0.07888893f, -0.02304256f, 
    -0.07520403f, -0.06523985f, -0.03808516f, 0.05702786f, 0.04332350f, -0.08973429f, -0.01602108f, 0.01524580f, 
    0.01859637f, 0.07708025f, 0.03986432f, -0.07147948f, -0.01731415f, -0.08583117f, 0.01913556f, 0.04592641f, 
    0.01598709f, 0.04185911f, -0.08490660f, 0.02710252f, -0.07833314f, -0.00763214f, -0.11959416f, -0.07250323f, 
    -0.02037209f, -0.01154560f, -0.05969787f, -0.05963202f, -0.10703745f, 0.01035971f, -0.08370657f, -0.10072779f, 
    -0.08335455f, -0.01953065f, -0.06161809f, -0.00206903f, -0.11257481f, -0.04647056f, -0.06481648f, -0.06425501f, 
    -0.07185455f, 0.03774272f, 0.03427049f, -0.06146855f, -0.05936843f, -0.07852168f, 0.07420494f, -0.03241614f, 
    -0.39335263f, -0.07140994f, -0.02265343f, 0.20000871f, 0.15973775f, 0.09318636f, 0.08409790f, 0.01581072f, 
    0.13163042f, -0.47962463f, 0.54431713f, 0.08726821f, -0.43774706f, -0.12682986f, 0.02789388f, 0.01914210f, 
    0.09784836f, -0.12669489f, -0.07343770f, -0.06592522f, 0.05647181f, 0.02895993f, -0.43568286f, 0.03928331f, 
    0.04565119f, 0.13341099f, 0.07011693f, 0.18517990f, -0.00427115f, 0.05136945f, 0.07580332f, -0.10656089f, 
    0.01248132f, 0.07414431f, 0.04260228f, 0.07064224f, -0.12763549f, -0.28597385f, 0.13776794f, 0.16592692f, 
    -0.02423915f, -0.03609329f, -0.07972180f, 0.14776720f, 0.15619215f, -0.07968584f, -0.00457844f, -0.01083356f, 
    -0.22672252f, 0.07764722f, 0.11006627f, 0.23058501f, 0.25400540f, 0.00231115f, 0.02824072f, -0.25979394f, 
    0.24224338f, -0.19760226f, -0.15156193f, -0.10938288f, -0.17273267f, -0.06597482f, -0.03081959f, -0.07825812f, 
    0.27286717f, -0.05283567f, 0.04999910f, -0.09483691f, -0.05402006f, -0.60325658f, 0.12324295f, -0.11452417f, 
    0.06520090f, 0.17100604f, -0.13508441f, -0.04248751f, 0.00440228f, -0.00718217f, -0.06844798f, -0.24769147f, 
    0.39830029f, 0.08155017f, 0.16926117f, -0.03026219f, -0.10534719f, 0.25919196f, 0.30157143f, 0.16791378f, 
    0.07981580f, 0.01719538f, 0.10901315f, 0.08888289f, -0.16279621f, 0.17234801f, 0.20537044f, -0.12983808f, 
    -0.14010707f, -0.03433607f, 0.08218443f, 0.14082971f, -0.15780303f, -0.04019396f, 0.00127330f, -0.09893654f, 
    -0.01163885f, 0.17026542f, 0.06394106f, 0.04992694f, 0.14910062f, 0.00068804f, 0.04933863f, -0.00639757f, 
    0.04203746f, -0.07474016f, 0.06682134f, -0.08258875f, -0.17746402f, -0.11115927f, 0.12869489f, -0.09537593f, 
    -0.00791914f, 0.20298250f, -0.25578734f, 0.10089190f, -0.12790936f, -0.09703670f, -0.01579762f, -0.08872756f, 
    0.02529890f, -0.01692650f, 0.05212795f, -0.05875251f, -0.04243275f, 0.07092936f, -0.06264041f, 0.03005072f, 
    0.06540267f, 0.06604793f, -0.04390563f, -0.00180774f, 0.07528495f, 0.03831503f, -0.05731098f, -0.00207743f, 
    -0.04203070f, -0.04888935f, 0.05999340f, -0.09149779f, -0.07099161f, -0.06753596f, 0.03224598f, -0.08176631f, 
    -0.00000350f, -0.11361045f, 0.00533416f, -0.07879787f, 0.01307998f, -0.05152904f, 0.00091042f, 0.08845916f, 
    0.03894102f, -0.08451263f, -0.02695400f, -0.07303755f, -0.04928214f, 0.07758395f, -0.05899271f, 0.02002752f, 
    -0.02553682f, 0.05260292f, -0.03636690f, 0.00861357f, -0.05694844f, -0.04370170f, -0.03976436f, -0.05980346f, 
    -0.07600894f, -0.09562773f, 0.04348063f, 0.07122278f, 0.00276732f, 0.03972251f, 0.07229177f, -0.07326125f, 
    0.04796042f, -0.03112288f, -0.03445107f, 0.00798639f, 0.05538454f, 0.00165698f, -0.07786147f, 0.04474300f, 
    0.01236786f, -0.02601988f, 0.00978840f, -0.01059678f, 0.03382441f, -0.04611867f, -0.01728325f, -0.10978471f, 
    0.08639432f, -0.01620747f, -0.01567530f, -0.06553684f, -0.04033604f, 0.07655653f, -0.07194015f, -0.08424528f, 
    -0.09234007f, -0.06216858f, -0.00145949f, 0.00074796f, 0.03578282f, 0.06370565f, 0.05573101f, 0.03311206f, 
    0.01018427f, 0.03263041f, -0.03431547f, -0.07367533f, 0.05969174f, 0.05999457f, -0.08576614f, -0.03740188f, 
    -0.05555253f, 0.08143732f, -0.05586431f, 0.02456795f, 0.06416994f, 0.04708951f, -0.07096406f, -0.00482863f, 
    -0.04729766f, -0.00816897f, 0.02586108f, 0.07417714f, -0.06340742f, 0.04621250f, 0.04238876f, 0.06924836f, 
    -0.08071849f, 0.03965487f, -0.08940088f, -0.00683628f, -0.01938909f, -0.00408253f, 0.03536297f, -0.05783723f, 
    0.04211360f, 0.01548891f, 0.02580017f, -0.06511307f, -0.01779928f, -0.03267976f, -0.00540787f, -0.05261722f, 
    0.08090536f, -0.04630627f, -0.14721781f, 0.17402196f, -0.30636877f, 0.18864964f, 0.00300140f, 0.00918176f, 
    -0.04155360f, 0.45964968f, -0.13130231f, 0.16249152f, -0.41996065f, -0.31130752f, -0.03357948f, -0.03878582f, 
    0.04101489f, -0.05240297f, 0.10044020f, -0.03896473f, 0.03546956f, -0.04522659f, 0.50498700f, 0.06142097f, 
    -0.30962518f, 0.01339255f, -0.01615379f, -0.05887842f, 0.00113280f, 0.06657621f, 0.11917286f, -0.12052055f, 
    -0.10035283f, 0.17418391f, -0.17095149f, 0.02466483f, 0.16424526f, -0.17219009f, 0.12933673f, -0.16328794f, 
    0.12626140f, 0.07090326f, 0.32701734f, -0.04138732f, 0.01304116f, -0.02947719f, 0.12970988f, 0.34305060f, 
    -0.15108113f, -0.03628282f, -0.12574631f, -0.12071203f, -0.02907269f, 0.23970231f, 0.31805065f, -0.20302567f, 
    -0.02721161f, -0.09078763f, 0.05299867f, -0.15776394f, -0.17622620f, 0.01805446f, 0.00830800f, 0.21199921f, 
    0.04397336f, 0.06687859f, 0.04937808f, 0.08069710f, -0.02090180f, -0.03354036f, -0.00812804f, -0.02192933f, 
    -0.01533721f, -0.11724804f, 0.02807601f, 0.15224856f, -0.03176842f, 0.01338484f, 0.01990640f, 0.00855074f, 
    -0.06929450f, 0.10231874f, -0.10915126f, -0.02858056f, -0.07716990f, 0.00974542f, 0.29843444f, 0.20050642f, 
    0.15003337f, 0.05291979f, -0.05596050f, -0.07249684f, -0.13791084f, -0.02995296f, 0.12131207f, 0.15869606f, 
    0.20682797f, -0.12130111f, 0.20574158f, 0.03548824f, 0.16886106f, 0.11670723f, -0.13643619f, 0.13299447f, 
    0.09594297f, -0.07604451f, -0.11067510f, -0.01922633f, 0.00411310f, 0.04957409f, 0.00173067f, -0.05605863f, 
    0.08795070f, 0.01437095f, -0.39805442f, -0.12178770f, 0.28895956f, 0.23941816f, -0.16306925f, -0.11207951f, 
    0.27203631f, -0.02164707f, -0.35430282f, -0.12769710f, 0.03411563f, 0.06015512f, -0.01539073f, -0.13416260f, 
    -0.08111166f, -0.02759892f, 0.07539275f, -0.06636257f, -0.02913874f, -0.01070849f, 0.08756256f, 0.06648163f, 
    -0.02704076f, -0.11033344f, 0.01737881f, 0.04593768f, -0.03906062f, 0.03515783f, -0.10666317f, -0.07323325f, 
    0.01828175f, 0.03617229f, -0.03556595f, 0.05832868f, -0.07755467f, -0.02279642f, -0.02183885f, 0.08690519f, 
    0.05359387f, -0.03980500f, 0.06487724f, -0.03637161f, -0.10039451f, -0.05202468f, -0.06484503f, 0.03479066f, 
    -0.07159541f, -0.10499603f, 0.00876475f, 0.02993288f, -0.04301150f, 0.02335732f, 0.03062321f, -0.08079891f, 
    -0.08598130f, -0.07853995f, -0.08728211f, -0.09384420f, 0.02424687f, -0.03036468f, -0.08090623f, -0.03184430f, 
    -0.09376624f, -0.07735028f, -0.03609236f, -0.10313074f, -0.02938001f, -0.00884319f, -0.02651614f, 0.00709096f, 
    0.05226663f, -0.04438223f, -0.03134715f, -0.01916852f, -0.03451483f, -0.08646437f, -0.03116819f, -0.05416756f, 
    -0.07177816f, 0.08537337f, -0.06554950f, -0.11290759f, -0.05642943f, -0.05708895f, -0.00797969f, -0.03230228f, 
    -0.04825378f, 0.00009187f, -0.00777685f, -0.09926184f, 0.06563257f, -0.04784995f, 0.01986791f, 0.02771341f, 
    0.04396483f, -0.11067495f, -0.06881756f, 0.05424238f, 0.00390234f, -0.06950735f, 0.05848452f, 0.00507582f, 
    0.01610468f, 0.00566650f, -0.00991662f, 0.04347952f, 0.08427102f, -0.06317609f, 0.03640267f, -0.06310422f, 
    0.05151567f, -0.06415510f, -0.10927560f, -0.02924549f, -0.08413073f, 0.02599729f, -0.06238018f, -0.01856655f, 
    -0.03379147f, 0.02011071f, 0.06221155f, 0.03616377f, 0.03927794f, -0.03800510f, 0.02388732f, 0.03811144f, 
    -0.09562489f, -0.00226320f, -0.03461539f, -0.07127010f, -0.05732395f, -0.05577672f, -0.05002980f, -0.10568999f, 
    0.02609850f, -0.02887439f, 0.05487317f, 0.03678298f, -0.00001331f, 0.05740171f, -0.08189329f, 0.07210655f, 
    0.10259875f, -0.01813409f, -0.28305861f, 0.03491730f, -0.31502858f, 0.07513542f, -0.03121499f, 0.06587163f, 
    -0.26024798f, 0.74701351f, 0.02662283f, 0.06832341f, 0.07663327f, -0.02449590f, 0.07406824f, -0.01502070f, 
    0.00463841f, -0.00250125f, 0.05699946f, 0.08524904f, -0.00417231f, -0.08293726f, 0.38173854f, 0.02895790f, 
    -0.22268498f, -0.04809299f, -0.08144981f, -0.07222511f, -0.09944594f, 0.06761540f, 0.03958283f, 0.01817574f, 
    -0.19002627f, 0.15284105f, -0.25420207f, 0.11611456f, -0.08538292f, 0.12003650f, 0.10999639f, -0.16725491f, 
    0.04414515f, -0.05985375f, 0.36575022f, -0.14180450f, 0.02700833f, -0.11330669f, 0.18673976f, 0.21000814f, 
    -0.26639044f, -0.17190661f, -0.15134478f, 0.03328764f, -0.13655925f, 0.28314441f, 0.19030452f, -0.09307939f, 
    -0.06790011f, 0.16250649f, 0.21147086f, -0.14855014f, -0.20569482f, 0.05114860f, 0.01747460f, 0.30236080f, 
    0.09173251f, -0.05423838f, 0.21620199f, 0.22645187f, 0.07394322f, -0.30448505f, -0.06060060f, 0.07152846f, 
    0.10661685f, -0.21672887f, 0.02553464f, 0.16234384f, 0.03899081f, 0.03704047f, 0.04697087f, 0.16917014f, 
    -0.29197383f, -0.03262495f, -0.03742588f, 0.00536318f, 0.19985729f, -0.04635938f, 0.15291005f, 0.21910623f, 
    0.09972176f, -0.04470310f, 0.04332684f, -0.04197505f, -0.04648430f, -0.01647873f, 0.09887702f, 0.31563088f, 
    0.17559610f, 0.22960137f, 0.23113297f, -0.05386329f, 0.35329095f, 0.06460318f, 0.05206067f, 0.18153644f, 
    0.04108257f, -0.09151945f, -0.19021215f, 0.06126158f, -0.09048774f, 0.27372256f, 0.14664112f, -0.18491790f, 
    0.13447315f, 0.18831941f, -0.43251595f, -0.09614288f, 0.24058145f, 0.05967350f, -0.07508035f, 0.09712852f, 
    0.34550393f, -0.12185907f, 0.00120066f, -0.20865923f, 0.20343459f, -0.00163114f, -0.03817355f, -0.07592235f, 
    -0.09682666f, -0.04452740f, 0.00774632f, 0.03574925f, -0.05903874f, -0.01853585f, 0.05501563f, -0.04392707f, 
    0.09757701f, -0.40158334f, 0.67294645f, -0.20358820f, -0.19502532f, -0.15685119f, -0.02206870f, -0.00919798f, 
    -0.06466768f, -0.16132313f, 0.04843593f, -0.09952855f, 0.00155028f, 0.06531162f, -0.03161614f, 0.02507792f, 
    -0.02726634f, 0.06005786f, 0.07974768f, 0.07857154f, -0.03686884f, 0.11296365f, 0.16145262f, -0.06876896f, 
    0.05412434f, 0.10645969f, -0.05601917f, 0.09007897f, 0.00782257f, -0.04768950f, 0.03197784f, 0.01850992f, 
    0.02284323f, -0.03656184f, -0.02295954f, 0.11698598f, -0.04512789f, 0.11227508f, 0.02068195f, -0.15265544f, 
    0.05365608f, 0.13208537f, 0.12699726f, 0.18090247f, 0.33821386f, 0.05680921f, 0.04624917f, -0.22577719f, 
    0.16075465f, -0.19090679f, -0.15776545f, -0.00399984f, 0.07730106f, -0.00207921f, -0.00575067f, 0.12332913f, 
    -0.14798547f, 0.05613497f, 0.14938001f, 0.00308557f, 0.06347378f, -0.45189697f, 0.00563252f, 0.17089522f, 
    0.03808904f, 0.15060095f, 0.16397910f, 0.01949676f, -0.00775317f, 0.03584734f, -0.17339125f, -0.04402749f, 
    -0.04585133f, 0.19099043f, -0.01712209f, 0.02855324f, -0.13580093f, 0.18410952f, 0.04884040f, -0.03818311f, 
    -0.13469064f, -0.09206078f, 0.08933587f, -0.05906981f, -0.73887771f, 0.27254584f, 0.25953007f, 0.08543251f, 
    0.04986272f, -0.43432486f, 0.14135298f, 0.01584885f, -0.19968154f, -0.04387907f, -0.15285757f, -0.20092052f, 
    0.24138689f, 0.03784281f, 0.23225997f, 0.14566912f, 0.06695722f, 0.08861654f, 0.17527899f, 0.09674724f, 
    0.15536466f, 0.06013166f, 0.02581624f, 0.00427521f, -0.06489915f, 0.20460472f, 0.15579705f, 0.12263332f, 
    0.07505177f, 0.09125361f, -0.01996817f, 0.08798674f, -0.05205255f, -0.16748381f, 0.04769226f, 0.08952527f, 
    0.22448485f, 0.11324265f, 0.03074756f, 0.11714112f, 0.10837115f, -0.18757032f, -0.06882617f, 0.04066081f, 
    -0.22472101f, 0.05046140f, -0.15400195f, 0.05484638f, 0.08055797f, -0.23049742f, 0.14883858f, -0.15940076f, 
    -0.27329472f, -0.15690014f, -0.17819931f, -0.22594720f, -0.11178160f, 0.10598675f, -0.20211868f, -0.03482249f, 
    0.01191990f, -0.25075415f, -0.03797327f, -0.22842617f, -0.00645486f, -0.16632390f, -0.07933635f, -0.21939537f, 
    -0.13812141f, 0.13365254f, 0.09254882f, 0.31330341f, 0.07498262f, -0.03452915f, 0.30668595f, 0.02888240f, 
    0.15715598f, 0.01266079f, -0.09192205f, -0.01100773f, -0.10624156f, 0.23067261f, -0.09730732f, -0.14932218f, 
    -0.19153413f, 0.01691930f, 0.18661082f, 0.05838301f, 0.32333305f, 0.15689512f, 0.00509381f, 0.29514691f, 
    -0.02138572f, -0.06992171f, 0.09464887f, -0.00912998f, 0.38052174f, 0.03246088f, 0.13108003f, 0.00125973f, 
    -0.58054316f, 0.04665563f, 0.09908918f, -0.21883573f, -0.06885135f, -0.23676583f, -0.01587440f, 0.03191124f, 
    -0.11980042f, 0.26037225f, -0.16775697f, -0.19899978f, 0.03969567f, 0.01990469f, -0.03462154f, -0.30925182f, 
    0.08159868f, 0.32488602f, -0.01347587f, -0.06166426f, 0.12790637f, 0.14209670f, 0.17783754f, 0.07555943f, 
    -0.13705325f, 0.08641416f, 0.03878090f, -0.06822509f, -0.14907847f, 0.10812154f, 0.05409398f, -0.10727388f, 
    0.00069160f, -0.18077479f, 0.12463471f, 0.18475537f, -0.18440123f, -0.01130387f, -0.34181020f, -0.11320736f, 
    0.24851297f, -0.03362033f, 0.10776296f, -0.08753676f, 0.22113046f, -0.12921974f, 0.06669074f, -0.03558484f, 
    0.09137517f, 0.09540587f, 0.03607266f, -0.16597259f, 0.13699763f, 0.10577241f, 0.01815368f, 0.03247486f, 
    -0.06679891f, -0.04923927f, -0.00289531f, 0.21963234f, -0.10460657f, -0.15119840f, 0.02232082f, 0.15705730f, 
    -0.01243680f, 0.08044186f, -0.08312322f, -0.01088129f, 0.01646882f, -0.05147485f, 0.05415622f, 0.06941400f, 
    -0.04229766f, -0.02963346f, -0.01776057f, -0.08533348f, -0.06714450f, 0.00270838f, -0.00824796f, 0.07899939f, 
    -0.03030370f, -0.06327941f, 0.01086495f, -0.07702390f, 0.01679758f, -0.01768508f, -0.05626694f, 0.02607681f, 
    -0.02505267f, 0.02912663f, -0.00065021f, -0.07764212f, 0.02843025f, -0.00176520f, -0.00894366f, -0.08709129f, 
    0.00483902f, 0.02150499f, -0.08494375f, -0.07517327f, -0.06405302f, -0.06025098f, 0.03006093f, -0.08343127f, 
    0.00794974f, 0.03154151f, 0.05702675f, -0.08668322f, -0.07804665f, -0.04289288f, -0.02303890f, -0.06734041f, 
    0.04914797f, -0.04831266f, -0.02990187f, -0.05569292f, -0.06012089f, -0.03509095f, 0.06349789f, 0.06209342f, 
    -0.08031829f, -0.03872630f, -0.05371481f, -0.04522208f, 0.07822625f, -0.06706399f, 0.01681892f, -0.04218648f, 
    0.03044901f, 0.07643051f, -0.06523255f, 0.01377164f, 0.00895920f, -0.00907830f, 0.04573809f, -0.03965341f, 
    -0.04272402f, -0.02724527f, -0.05600529f, -0.08773448f, -0.04316352f, 0.04857652f, 0.02214302f, -0.07900686f, 
    -0.07092858f, -0.07699513f, 0.06552601f, 0.04916755f, -0.05879142f, 0.07847490f, 0.01231455f, 0.08207265f, 
    0.03272723f, -0.04398526f, 0.01748661f, 0.00697581f, 0.03674749f, -0.07414250f, -0.02750742f, 0.00142965f, 
    -0.06950492f, -0.03485641f, -0.04464100f, -0.02340718f, 0.02450409f, 0.08587221f, 0.05751094f, -0.04809427f, 
    -0.06124185f, -0.03690353f, 0.01233724f, -0.00007585f, 0.04184203f, 0.03008731f, -0.07577057f, -0.05489071f, 
    0.06278828f, -0.00811915f, 0.06593535f, -0.03411099f, 0.02931883f, -0.06320460f, -0.06008364f, 0.07076086f, 
    -0.02569177f, -0.03026380f, 0.08769468f, 0.00937635f, 0.03920788f, -0.08363651f, 0.08391057f, -0.02996213f, 
    -0.05343155f, -0.05897620f, -0.04949931f, 0.07857316f, -0.09000920f, -0.08134647f, -0.00904409f, 0.08830301f, 
    -0.06744412f, 0.08055327f, -0.03583702f, 0.04864249f, -0.09511854f, 0.06071179f, -0.08449432f, -0.07220172f, 
    -0.02501616f, 0.05817176f, -0.06223730f, -0.07038369f, -0.00906709f, 0.06848647f, -0.08181254f, -0.03945239f, 
    0.01365745f, 0.05830933f, 0.08213322f, -0.02819729f, -0.06473780f, -0.04618812f, 0.04406351f, 0.05128932f, 
    -0.03866713f, -0.02511979f, 0.00957934f, 0.08147215f, 0.00635072f, -0.04145252f, 0.04415985f, -0.06285524f, 
    -0.08100686f, -0.08147430f, 0.05934614f, 0.01106410f, -0.07616676f, -0.01854708f, -0.06816129f, -0.04871080f, 
    -0.01051751f, 0.01932884f, -0.07952499f, -0.02223023f, 0.02363064f, -0.05921737f, -0.00261595f, 0.06997988f, 
    -0.06065306f, -0.07104202f, -0.08686577f, -0.09026024f, 0.00684599f, 0.02279194f, -0.06897400f, -0.05235486f, 
    -0.03222948f, 0.07629007f, -0.07429853f, -0.02813411f, -0.05979788f, -0.06481121f, -0.02563407f, 0.03085256f, 
    0.05095002f, -0.05831109f, -0.03758596f, 0.01766497f, 0.04834515f, 0.04915125f, 0.03226197f, -0.07548708f, 
    -0.06760838f, -0.08914948f, -0.03221101f, 0.04256528f, 0.02401796f, 0.05616127f, 0.01038523f, 0.01423401f, 
    0.01428853f, 0.03397074f, 0.03784160f, -0.08847691f, 0.08596360f, -0.05228118f, 0.05291890f, -0.00254056f, 
    -0.05229772f, -0.04286375f, -0.09003345f, -0.07752958f, 0.00519486f, -0.05496948f, 0.00378819f, -0.08374267f, 
    -0.00245456f, 0.07243972f, -0.06968263f, 0.01418095f, -0.03988608f, 0.06476991f, 0.04198126f, -0.01514048f, 
    0.03049630f, -0.01410247f, -0.07563218f, -0.08348159f, 0.05880002f, 0.04629274f, 0.03249000f, -0.09200753f, 
    -0.00034884f, 0.01974865f, -0.01164764f, -0.07258860f, -0.05042868f, -0.00584078f, -0.08511783f, 0.02503447f, 
    0.23238544f, 0.22536969f, 0.07519451f, -0.07184238f, -0.23887223f, -0.36972180f, -0.06408533f, -0.08390998f, 
    -0.38157448f, -0.45586765f, 0.40219137f, -0.67216915f, 0.23359999f, 0.10830624f, 0.04604439f, -0.09022936f, 
    -0.30425411f, -0.03408993f, 0.16052301f, -0.23612250f, 0.04512561f, 0.05734523f, -0.19962041f, 0.01776828f, 
    0.20683058f, -0.25716451f, -0.07618839f, -0.26566729f, -0.41567066f, 0.01595211f, -0.06804553f, -0.28617206f, 
    0.10091309f, -0.29717594f, 0.07831505f, 0.13841431f, 0.03928819f, 0.46037856f, 0.11440635f, 0.00591878f, 
    -0.09331653f, -0.05667957f, 0.11905523f, -0.12260062f, -0.73872393f, 0.13094003f, 0.06617790f, 0.14183466f, 
    -0.33437833f, -0.13992850f, -0.29745105f, 0.13172066f, 0.29992479f, 0.11818305f, -0.19301613f, -0.05573774f, 
    -0.24589562f, 0.25371182f, 0.21651219f, 0.18839499f, 0.37767005f, -0.00489398f, 0.34959814f, 0.10719498f, 
    -0.37304637f, -0.03378332f, 0.05873762f, -0.08396047f, 0.03188840f, -0.75208557f, 0.21111493f, 0.33043513f, 
    0.21443106f, 0.03564304f, 0.12047525f, -0.19956784f, 0.01844466f, 0.04434299f, -0.04375086f, -0.17345174f, 
    -0.03394245f, 0.13405465f, 0.08904170f, -0.03809550f, 0.39669654f, -0.05284177f, 0.00644173f, 0.08524536f, 
    -0.09253738f, -0.07000047f, 0.13506067f, -0.25416628f, -0.41172421f, 0.16833498f, 0.06127190f, 0.09791826f, 
    -0.03283707f, -0.16522676f, 0.08532424f, 0.31104508f, -0.21288717f, 0.28357813f, -0.45988098f, 0.15502089f, 
    0.33203819f, -0.07506168f, -0.05296008f, -0.09079462f, -0.04751051f, -0.02517438f, 0.24299303f, -0.17936185f, 
    0.02279904f, 0.09115516f, -0.13670452f, -0.35476658f, 0.25134146f, 0.15121770f, 0.08098685f, -0.02619135f, 
    0.13346356f, -0.06451385f, -0.19814014f, 0.12459697f, 0.20720547f, -0.22198159f, -0.04628344f, 0.40005332f, 
    -0.03836870f, -0.08582886f, -0.03937566f, 0.07683609f, -0.04940739f, 0.05580613f, 0.05292422f, 0.01876474f, 
    -0.07407722f, 0.07247462f, 0.00185039f, 0.05325686f, -0.06591429f, 0.07679555f, 0.00993657f, -0.07630554f, 
    -0.07712969f, -0.03311640f, -0.07206436f, 0.02112537f, 0.04741786f, 0.06173691f, -0.06796951f, -0.05423587f, 
    0.04861291f, 0.02268926f, -0.01832289f, -0.03996057f, 0.06286523f, -0.04326880f, 0.02596195f, -0.02344798f, 
    -0.06568738f, 0.05199279f, -0.07363977f, -0.05859199f, 0.06945082f, 0.03407479f, 0.06506258f, -0.07697159f, 
    0.02247825f, -0.07892249f, -0.01324673f, -0.06520627f, 0.07348152f, 0.00950072f, 0.01622608f, 0.02666619f, 
    -0.01601255f, -0.07385998f, 0.07840777f, -0.03361618f, -0.06462327f, -0.01204212f, 0.04854209f, -0.05757580f, 
    -0.01228025f, -0.04636626f, -0.01809121f, -0.01212189f, 0.00815956f, 0.00225324f, -0.06350945f, 0.04720080f, 
    0.02438286f, 0.03159131f, -0.06575020f, -0.07074030f, 0.02313822f, 0.01867936f, 0.05568283f, 0.08117267f, 
    0.08540206f, 0.07244968f, 0.06363662f, -0.07127832f, 0.05191252f, 0.02679653f, -0.08592104f, 0.01029925f, 
    -0.07463598f, -0.02143042f, -0.00671591f, -0.03286761f, -0.03209955f, -0.07002392f, -0.04367727f, -0.07943805f, 
    -0.03706713f, 0.05220976f, 0.00206645f, -0.07336265f, 0.01180071f, -0.00535696f, -0.02719336f, -0.04873427f, 
    0.02479868f, -0.05354050f, -0.05508244f, -0.06283210f, -0.08108935f, 0.06968547f, -0.07450876f, 0.06230052f, 
    0.02459555f, -0.03719615f, -0.02227858f, 0.08088569f, -0.07389611f, 0.05362413f, 0.05904281f, -0.08619599f, 
    -0.08702531f, 0.04880064f, 0.04797355f, -0.04081057f, -0.05494668f, -0.00450775f, -0.04606581f, -0.06352054f, 
    -0.04229553f, 0.03845906f, 0.04332230f, -0.03151764f, -0.07439910f, -0.00076618f, -0.04075196f, -0.04823465f, 
    -0.06868862f, -0.05571533f, 0.05395086f, -0.07997319f, 0.01468300f, 0.06214498f, 0.01157468f, 0.08823969f, 
    0.00771969f, 0.01763555f, 0.06734028f, -0.07813833f, -0.02043765f, -0.04651746f, 0.00061188f, 0.01722961f, 
    0.03312743f, 0.05830251f, -0.05029110f, -0.06138257f, 0.00443411f, 0.06534798f, -0.01310378f, -0.06046183f, 
    -0.07454836f, 0.07753847f, -0.04826853f, -0.03726043f, 0.05607469f, 0.01582263f, 0.00921176f, 0.01579893f, 
    0.03650140f, 0.07532262f, -0.03859724f, 0.05071768f, -0.00320146f, 0.00255835f, -0.04106418f, -0.08271964f, 
    0.03248011f, 0.05700151f, -0.07862555f, -0.11144987f, -0.01172854f, 0.00759225f, -0.00983319f, 0.04864253f, 
    -0.02193950f, -0.03979498f, -0.07090762f, -0.04200663f, -0.03632671f, 0.06089865f, 0.02179207f, -0.01912167f, 
    -0.09356217f, 0.04798569f, -0.06688303f, -0.01383177f, -0.00105565f, -0.02330660f, 0.01478133f, 0.02389927f, 
    -0.09440349f, -0.03099442f, 0.08363447f, -0.04420642f, -0.00796480f, -0.06134960f, -0.07412522f, 0.03228396f, 
    0.02789455f, 0.04123979f, 0.09037453f, 0.05456319f, -0.00881810f, 0.00552286f, 0.02483765f, 0.05159320f, 
    0.09224987f, -0.07178397f, -0.09331542f, 0.06952563f, 0.05576103f, 0.03461540f, -0.06822100f, 0.01801037f, 
    -0.06012890f, 0.06911892f, 0.00902690f, 0.02619153f, -0.01400520f, -0.00118795f, 0.05421293f, -0.04643987f, 
    -0.09287130f, 0.06624167f, -0.05695679f, 0.03395169f, -0.03269085f, -0.04837618f, -0.02198780f, 0.01124475f, 
    0.03732847f, 0.01700049f, -0.06689455f, 0.01364847f, -0.05540519f, 0.01750318f, -0.08631728f, -0.02357695f, 
    -0.07772122f, -0.05155876f, 0.01199508f, 0.00771149f, 0.00883265f, -0.06858349f, 0.03348285f, 0.02019742f, 
    0.03834102f, -0.00759729f, -0.06593684f, 0.05431885f, -0.04332306f, 0.08722501f, -0.05854424f, -0.03735187f, 
    0.04571130f, -0.06911261f, -0.03317776f, -0.09650408f, -0.08066546f, -0.12284224f, -0.00352779f, -0.06931185f, 
    -0.01829592f, -0.01451230f, 0.06921870f, 0.02641810f, 0.03644558f, -0.05013046f, 0.01065862f, -0.10144334f, 
    0.04122103f, -0.00043649f, -0.01247440f, -0.02732082f, 0.03736434f, 0.02727510f, -0.10999123f, -0.08041217f, 
    -0.07648958f, -0.11818678f, 0.08447608f, -0.10907887f, 0.00260159f, -0.11847917f, -0.09869410f, -0.08731168f, 
    -0.02959927f, 0.03004411f, -0.11027779f, -0.07430543f, -0.03691714f, 0.02228239f, -0.04217164f, -0.11701535f, 
    -0.04143541f, -0.01441065f, -0.02769584f, -0.06138760f, 0.03159943f, 0.02519511f, -0.07335269f, 0.00041112f, 
    -0.05831350f, -0.04536854f, -0.01840894f, -0.10775410f, -0.05526159f, -0.04316922f, -0.00777461f, 0.01370186f, 
    -0.03939886f, -0.05425510f, -0.09629766f, -0.09485468f, -0.08531309f, -0.13126744f, 0.00128175f, -0.03415724f, 
    0.04917743f, -0.01230936f, -0.07330295f, -0.11972822f, -0.02099270f, 0.04176836f, 0.01608449f, 0.02407078f, 
    -0.12907052f, -0.09576140f, 0.06585064f, -0.02825872f, -0.01398849f, 0.01765434f, 0.04529431f, 0.00358214f, 
    -0.04861541f, -0.01006521f, 0.06856342f, -0.03580161f, -0.08873962f, 0.02992493f, -0.08724233f, -0.09944373f, 
    -0.01940363f, 0.05984121f, -0.04903162f, -0.01031576f, 0.03190882f, 0.03557799f, 0.04340248f, -0.02049435f, 
    -0.10749269f, -0.05322262f, 0.07473880f, -0.00558497f, 0.01171595f, 0.03424826f, -0.04610298f, -0.04938894f, 
    0.05475178f, -0.08797610f, -0.10956366f, 0.01006326f, -0.08475230f, 0.03298635f, -0.08363115f, 0.01812789f, 
    -0.00130179f, 0.04826296f, -0.04102804f, 0.00455667f, -0.04868415f, 0.01316472f, -0.01048722f, -0.08281478f, 
    0.02209654f, 0.00976010f, -0.03344722f, -0.05721470f, -0.08886913f, -0.02097192f, 0.08692829f, 0.00414865f, 
    0.01736934f, -0.02113239f, -0.03403483f, -0.03342209f, 0.04181265f, 0.00605764f, 0.06894898f, -0.02642343f, 
    -0.07460058f, -0.05746600f, -0.02399965f, 0.05322239f, 0.01648921f, -0.07201546f, -0.07117943f, -0.01445868f, 
    -0.03785554f, 0.03037295f, 0.02918114f, -0.05197783f, -0.05928313f, 0.03327339f, 0.05564174f, 0.04642342f, 
    0.07004850f, -0.10617286f, 0.00006059f, 0.01108148f, 0.04131113f, 0.02950026f, -0.09694224f, -0.01158268f, 
    -0.09656409f, 0.04412372f, -0.02989783f, -0.08761783f, -0.03287507f, -0.02902958f, 0.00077945f, -0.06770994f, 
    -0.05229299f, 0.06255636f, -0.07473807f, -0.05257274f, -0.06653146f, -0.04899589f, 0.05156697f, -0.04932672f, 
    -0.03615122f, -0.11022615f, -0.04512862f, -0.03383145f, 0.00182800f, -0.00148264f, -0.00652709f, -0.02138321f, 
    -0.04485149f, -0.06337629f, 0.01577306f, -0.02101023f, 0.06136440f, -0.03431195f, 0.04298434f, -0.00609806f, 
    -0.02685117f, -0.08274025f, -0.10870815f, -0.04468325f, -0.03636596f, -0.01986932f, 0.00737481f, -0.01408750f, 
    -0.10990091f, -0.11190329f, -0.04951804f, -0.03769043f, -0.05583451f, 0.02211146f, -0.04758016f, 0.01972386f, 
    -0.00635495f, 0.04727071f, 0.05801826f, 0.04174023f, -0.00803807f, 0.01833778f, -0.07632881f, -0.09011913f, 
    -0.06828192f, -0.03014905f, 0.05644823f, -0.03893844f, 0.02767612f, -0.06572834f, 0.02205995f, 0.04965366f, 
    -0.02034401f, 0.03476158f, -0.09209275f, -0.05010618f, -0.08251232f, -0.01020795f, -0.03354373f, 0.00593193f, 
    0.02280802f, 0.03000010f, -0.05240993f, -0.02345243f, 0.00644652f, 0.04976762f, -0.07098827f, 0.02171754f, 
    -0.05367834f, 0.00980136f, 0.01731773f, 0.08438014f, -0.10984863f, -0.08492355f, -0.10414554f, -0.04448205f, 
    -0.09794783f, 0.07444460f, 0.03589046f, 0.00337138f, 0.01926308f, -0.07146674f, 0.03819722f, 0.03753287f, 
    0.02458641f, 0.22859925f, -0.63231564f, 0.06936428f, 0.19075751f, -0.18921314f, -0.07392144f, 0.04601583f, 
    -0.23192467f, 0.35004047f, -0.59671080f, 0.00572503f, 0.22416236f, -0.28668821f, 0.01381375f, -0.02106633f, 
    -0.35562330f, 0.04003787f, -0.07970729f, 0.05807395f, -0.04358058f, 0.37987208f, -0.45496571f, 0.07018315f, 
    -0.59048116f, -0.50879312f, 0.04127305f, -0.09882782f, -0.47599334f, -0.03311470f, -0.14028019f, 0.13863848f, 
    0.33110845f, -0.08960617f, 0.28913549f, 0.12314790f, -0.32838967f, 0.21490100f, 0.26059502f, 0.18555909f, 
    0.54379725f, 0.03025839f, 0.13837866f, -0.37133321f, -0.22687481f, 0.30770621f, 0.44274446f, -0.14404517f, 
    -0.45182228f, -0.03857706f, -0.09735309f, -0.14886875f, -0.05171073f, 0.08344507f, 0.17503965f, -0.09161498f, 
    -0.01230354f, 0.14788157f, -0.06942921f, 0.30015200f, -0.40395820f, -0.00880241f, 0.26727769f, 0.22784711f, 
    0.30588779f, -0.00183552f, -0.10314513f, -0.05937484f, 0.06075108f, -0.53609645f, 0.03393708f, -0.09590434f, 
    0.11268477f, 0.01007097f, 0.11180862f, 0.20058554f, -0.05816491f, -0.02273534f, 0.23255235f, -0.15820883f, 
    0.59839565f, -0.28527698f, -0.49998802f, 0.05134194f, 0.22499356f, -0.13665301f, 0.16214874f, -0.00507110f, 
    0.52708107f, 0.06214921f, -0.66193414f, 0.14237256f, -0.41623241f, -0.47717527f, -0.54258436f, 0.01779517f, 
    0.16275141f, 0.03539525f, 0.06963899f, 0.35931328f, 0.28050712f, 0.26800913f, -0.05981362f, 0.30291167f, 
    -0.53534067f, -0.11695244f, -0.41479796f, 0.05237184f, 0.14809571f, -0.23852411f, -0.51564276f, -0.07548466f, 
    -0.12552729f, 0.28949854f, 0.15926464f, -0.67637116f, 0.07061575f, -0.33914459f, -0.05976978f, -0.19412819f, 
    -0.25404790f, -0.31449521f, 0.00136164f, 0.29293418f, -0.01062342f, 0.17056404f, 0.08233474f, -0.52431852f, 
    -0.26664555f, -0.17070916f, 0.14670201f, 0.03438183f, 0.22335900f, -0.40214691f, -0.04700742f, 0.05054840f, 
    0.07966327f, -0.08791937f, 0.07504228f, -0.49173316f, 0.49554226f, 0.52408588f, -0.31182981f, -0.20216723f, 
    -0.06970386f, 0.00573782f, -0.05863152f, -0.36553773f, -0.21638569f, 0.15283743f, -0.29362580f, 0.01687480f, 
    -0.04652987f, -0.00050175f, 0.02999227f, -0.06281136f, 0.37360924f, -0.00701551f, 0.14299297f, 0.14622107f, 
    0.14694084f, -0.35714403f, -0.09864496f, 0.02110480f, 0.13546349f, 0.12065317f, -0.27123544f, -0.14349774f, 
    0.14749186f, -0.02801291f, 0.12317912f, 0.11279234f, -0.28386605f, -0.19252169f, 0.04281203f, 0.20053105f, 
    0.24869095f, -0.12072311f, -0.74582750f, -0.08367246f, -0.05098399f, 0.08006772f, 0.08737897f, -0.08196153f, 
    0.17668568f, -0.21205159f, 0.00135429f, 0.11305624f, -0.01469593f, -0.19920735f, -0.13011515f, -0.09594914f, 
    -0.50845969f, -0.08139735f, -0.06621763f, -0.03438095f, -0.08813713f, 0.21688114f, 0.14109103f, 0.41689578f, 
    0.26748258f, 0.08679412f, -0.09809928f, 0.15501526f, -0.03611329f, 0.07437623f, 0.15261890f, -0.21214105f, 
    -0.05743117f, 0.08609866f, 0.03563867f, 0.01165791f, -0.13806891f, -0.03928178f, -0.29572442f, -0.46543431f, 
    -0.04109149f, 0.01846645f, 0.11931279f, -0.38391161f, -0.18975595f, 0.07235334f, 0.02625543f, -0.14706334f, 
    -0.11976442f, -0.06555851f, 0.04000412f, -0.09621925f, 0.12873785f, 0.19642520f, -0.23332825f, -0.20918070f, 
    0.01019817f, 0.19710739f, 0.01285586f, -0.41498047f, -0.23467508f, -0.45893705f, 0.04187742f, 0.05104338f, 
    -0.37630713f, -0.04406674f, -0.05023476f, -0.57073390f, -0.44607621f, 0.04665995f, 0.06470247f, -0.16562523f, 
    0.19005971f, 0.23244314f, 0.40680298f, 0.17327456f, -0.26711762f, -0.67645049f, -0.07265255f, -0.05602062f, 
    0.05631815f, 0.05998747f, -0.02509267f, 0.00804736f, -0.04316179f, 0.00122182f, -0.06780707f, 0.05641696f, 
    -0.05827524f, 0.01429200f, -0.06165230f, -0.05478963f, 0.03187574f, 0.07274944f, 0.01996249f, 0.03397484f, 
    -0.10456751f, 0.06026002f, 0.05950084f, 0.02898805f, -0.10310092f, 0.03867396f, -0.06224018f, 0.08153642f, 
    -0.05484993f, 0.03157963f, 0.00985084f, -0.05034528f, -0.04213450f, -0.02336427f, -0.08436939f, -0.06270096f, 
    -0.10054725f, 0.00436197f, 0.02262203f, 0.06108147f, 0.00648177f, -0.04361657f, 0.06296352f, -0.03637828f, 
    0.05793702f, -0.00841973f, -0.07871712f, 0.04578788f, -0.02747333f, -0.05673877f, 0.03167650f, 0.06922378f, 
    -0.00611988f, 0.06249012f, -0.04745651f, -0.10338407f, -0.07724088f, -0.00492962f, -0.00107883f, -0.00831862f, 
    -0.01614493f, -0.09556612f, -0.08015625f, -0.06135400f, 0.05704808f, -0.07965985f, -0.02266254f, -0.10248015f, 
    -0.03383686f, 0.06382415f, 0.05318554f, -0.00801120f, 0.02259475f, 0.06112017f, -0.05880899f, -0.00543922f, 
    0.00623976f, 0.02532527f, -0.06597649f, -0.06940471f, -0.01108864f, 0.04479909f, -0.06220439f, 0.05747380f, 
    -0.00772040f, 0.01023674f, -0.05881825f, -0.06633729f, -0.08307579f, 0.00702917f, 0.05047495f, -0.08051977f, 
    0.04418750f, -0.04906014f, -0.04867687f, 0.05503437f, 0.03617027f, -0.03594954f, -0.03639217f, 0.03383680f, 
    -0.07244483f, 0.01271157f, 0.00549975f, -0.05879807f, -0.03125555f, 0.01980591f, 0.04886467f, 0.06365335f, 
    -0.03514784f, -0.04207492f, -0.03678336f, -0.09048744f, 0.02429540f, -0.03078449f, -0.08765796f, 0.05617917f, 
    -0.05884929f, -0.05854976f, -0.08682121f, 0.04396520f, 0.04089416f, -0.09836506f, 0.03725209f, 0.06199629f, 
    0.04430402f, -0.02305661f, -0.04467527f, -0.04407587f, 0.02674182f, -0.02543413f, -0.00705385f, -0.02087115f, 
    -0.00792421f, 0.01518459f, 0.21220282f, 0.23520370f, 0.13610518f, -0.43466651f, 0.04984237f, -0.02875644f, 
    0.02304828f, -0.35881189f, -0.00457667f, -0.28020313f, -0.00224079f, 0.25700092f, -0.14282551f, -0.13254991f, 
    0.08067594f, 0.03816806f, -0.18703054f, 0.04607137f, 0.03393658f, -0.07318029f, -0.44270384f, -0.03077593f, 
    0.06155824f, -0.04855904f, 0.00294445f, 0.00672917f, -0.39907923f, 0.13260092f, -0.08165090f, 0.02964142f, 
    0.21403001f, -0.36123285f, -0.00093343f, -0.07921656f, 0.02186655f, 0.06803413f, -0.03790152f, -0.34776881f, 
    0.01287677f, -0.03786846f, 0.05991664f, 0.15565638f, -0.07837220f, 0.04172075f, 0.23768921f, 0.23028892f, 
    0.06430968f, -0.20071878f, -0.18522772f, -0.09083286f, -0.08649491f, 0.14199223f, 0.03723252f, 0.04049611f, 
    0.01778855f, 0.03845624f, -0.11528796f, -0.12241478f, 0.24413748f, -0.25758693f, 0.01821646f, -0.23122200f, 
    0.03828466f, 0.01119602f, 0.05437310f, 0.08559529f, -0.05180492f, -0.51581341f, -0.00469204f, -0.16251191f, 
    -0.02020735f, 0.24724802f, 0.00691423f, 0.08110614f, 0.10387615f, 0.08697880f, -0.38184407f, -0.01117159f, 
    0.04772520f, 0.14090006f, 0.14686951f, -0.07242309f, 0.31357607f, -0.02841594f, -0.15725863f, -0.11157874f, 
    0.16035071f, 0.00557564f, 0.10803109f, -0.12733310f, -0.11829475f, 0.25429618f, 0.20605437f, -0.13315521f, 
    -0.00348115f, 0.19585337f, -0.03950333f, 0.16899902f, -0.55028743f, 0.03827007f, 0.12160735f, 0.36683768f, 
    0.10650119f, -0.73126191f, -0.08052871f, -0.33729431f, -0.21206957f, -0.11958160f, 0.05242281f, -0.01905798f, 
    -0.07239065f, 0.17700581f, 0.04902405f, 0.05151191f, -0.08034643f, 0.19244960f, 0.01956557f, -0.19604658f, 
    0.15418185f, -0.33444545f, -0.07482108f, 0.10665467f, -0.10874316f, 0.37122336f, -0.02269753f, -0.05702142f, 
    -0.35121879f, -0.26149851f, -0.73369318f, 0.11902623f, -0.05829921f, 0.16703166f, -0.01232994f, 0.10164397f, 
    0.07466216f, 0.24118312f, -0.51405156f, 0.19731149f, 0.10226056f, -0.81098628f, -0.12898502f, 0.14957710f, 
    -0.08974001f, 0.07145707f, 0.02553863f, -0.02305748f, 0.02554912f, 0.09389683f, 0.09679268f, 0.03025868f, 
    -0.09771779f, 0.01095934f, 0.03088011f, 0.13978469f, 0.00026705f, 0.08341686f, 0.34228560f, -0.90074432f, 
    -0.12303705f, 0.57795405f, 0.12055159f, -0.05998176f, -0.10810926f, -0.16700347f, 0.03082214f, 0.07052507f, 
    -0.27386880f, 0.07140815f, 0.36836803f, -0.07262615f, 0.22401722f, -0.05973071f, 0.03642677f, -0.36418295f, 
    -0.02096603f, -0.02334689f, 0.18083552f, 0.23409849f, -0.04795205f, 0.18412197f, 0.13372156f, -0.10137736f, 
    0.12196182f, -0.06132993f, 0.23072831f, -0.03600776f, -0.40114924f, 0.09889867f, -0.01716435f, 0.29802409f, 
    0.06567926f, 0.04345592f, -0.13682391f, 0.09855197f, 0.02957571f, -0.15309516f, 0.03988970f, 0.10792304f, 
    0.12751541f, 0.06497607f, 0.09827426f, 0.19613360f, -0.07781607f, -0.06429382f, 0.09498328f, -0.17303473f, 
    -0.17924830f, -0.15466040f, -0.03099943f, 0.05504370f, 0.11338347f, -0.01752186f, 0.33792812f, 0.08697401f, 
    -0.06656969f, 0.07715044f, -0.16064559f, 0.13942043f, -0.07388414f, -0.04166950f, -0.03276272f, 0.23685984f, 
    -0.01256094f, 0.09276405f, 0.24917065f, -0.27979666f, 0.27086911f, 0.18272039f, -0.07810538f, 0.34494480f, 
    -0.11267889f, 0.26384142f, -0.07708539f, 0.10879135f, 0.03960937f, 0.28857198f, -0.18517554f, 0.10241894f, 
    0.13524064f, -0.21056734f, -0.19215719f, -0.16537145f, 0.25581661f, -0.05621721f, -0.09625711f, -0.09813280f, 
    0.04105159f, 0.12646098f, -0.72253531f, -0.09297409f, -0.03173963f, -0.04183986f, -0.04385337f, -0.25519103f, 
    0.07957892f, 0.04088423f, -0.01918584f, 0.04792004f, 0.03515695f, 0.04305672f, -0.02851710f, 0.06230769f, 
    0.04212585f, -0.01732231f, 0.01933552f, 0.01941414f, 0.01837450f, 0.05143525f, -0.08626594f, -0.09073566f, 
    -0.09559768f, 0.00329021f, -0.06035962f, -0.03107511f, -0.00690435f, 0.04342325f, 0.07992116f, 0.05076628f, 
    0.00307844f, -0.06991453f, -0.03860878f, -0.03954466f, -0.03223860f, 0.03899292f, -0.07593126f, 0.06771664f, 
    -0.08522922f, -0.06149934f, 0.04229337f, 0.01355002f, 0.06296968f, -0.03868872f, 0.08631856f, -0.09616160f, 
    0.00556306f, 0.04802106f, -0.00783135f, 0.06688684f, -0.00990645f, -0.00143447f, -0.07713459f, -0.04181033f, 
    0.05354828f, 0.05983933f, 0.02975888f, 0.02898051f, -0.06312783f, -0.01282737f, -0.07543509f, -0.01041807f, 
    0.02976926f, 0.03262489f, -0.06279773f, 0.03326111f, -0.08867545f, 0.07925215f, 0.04952221f, -0.04318301f, 
    0.05017668f, 0.08592341f, -0.08569138f, -0.01197493f, -0.06146995f, -0.08548550f, -0.05299314f, -0.00306262f, 
    -0.02002962f, 0.02444816f, 0.05610655f, -0.00011847f, 0.08636591f, -0.04268758f, -0.07886678f, -0.08278366f, 
    -0.08142694f, -0.03559438f, 0.03851193f, -0.03365638f, -0.09260248f, -0.04890007f, -0.03588695f, -0.07019456f, 
    0.02885987f, -0.06628907f, -0.08513981f, -0.07159542f, 0.01872136f, -0.01950728f, 0.01372679f, -0.06403908f, 
    0.04915350f, 0.08714467f, -0.00275523f, 0.01731708f, 0.04525030f, -0.03974663f, 0.07730402f, -0.07605533f, 
    0.05478012f, 0.05675414f, 0.01836822f, -0.00954025f, 0.07999940f, -0.02437768f, 0.02972384f, 0.06435844f, 
    0.03657841f, -0.03056879f, -0.06710297f, 0.06878936f, -0.05438817f, -0.02474309f, -0.05553522f, -0.01859270f, 
    0.00229435f, -0.04398095f, -0.07201856f, 0.04133657f, 0.00324654f, 0.06854542f, 0.03916217f, -0.07105833f, 
    0.03785785f, 0.06032775f, 0.00243043f, -0.07507823f, -0.07530677f, 0.04370092f, 0.02844848f, 0.08084973f, 
    0.05376622f, -0.01383265f, 0.06283306f, -0.05806688f, 0.03361092f, -0.07580278f, -0.05949707f, 0.03661672f, 
    -0.03699330f, -0.08459612f, 0.05131596f, -0.06752267f, -0.10649891f, -0.06914183f, -0.05876805f, -0.06411558f, 
    0.07518899f, -0.01681195f, 0.05145402f, -0.07593904f, 0.03693009f, -0.02104107f, -0.04462178f, 0.03628895f, 
    -0.02206822f, -0.01381837f, 0.04908268f, 0.03282221f, 0.03486359f, 0.01408812f, 0.06121923f, -0.01676342f, 
    -0.03577195f, 0.00458039f, -0.09558990f, -0.08777245f, -0.03060849f, -0.03806475f, 0.00922593f, 0.02237539f, 
    0.05115410f, -0.01773461f, -0.10003901f, 0.04316060f, 0.01953682f, -0.09986705f, -0.08790892f, -0.04330266f, 
    -0.02433857f, 0.03535103f, -0.09643067f, -0.02835583f, -0.06871950f, -0.11395847f, -0.00966663f, -0.11229893f, 
    0.01711693f, -0.08677155f, 0.07061839f, 0.03359872f, 0.02897027f, -0.05360278f, -0.08615155f, -0.07564370f, 
    -0.01673592f, 0.01252639f, 0.05936469f, 0.02770403f, -0.01473102f, -0.01096367f, 0.00125423f, -0.02884669f, 
    0.05617529f, -0.07084616f, -0.05374038f, 0.05704930f, 0.04342554f, 0.03987949f, -0.00520389f, -0.01877786f, 
    -0.02359085f, 0.02507939f, -0.03095222f, -0.01534104f, 0.06239232f, 0.01589912f, 0.03862860f, -0.01726554f, 
    -0.04960760f, 0.00511741f, 0.00504738f, -0.06477369f, 0.06109902f, 0.05634896f, 0.00758744f, 0.04685802f, 
    0.02161947f, 0.03286355f, -0.04602615f, -0.03262935f, -0.02679233f, 0.03654527f, 0.04752102f, -0.08104311f, 
    0.00902322f, -0.03892294f, 0.02769302f, -0.09607652f, -0.07206976f, -0.02810825f, 0.05760311f, 0.03975897f, 
    -0.08790718f, -0.08037141f, -0.03768024f, -0.05662202f, 0.04282961f, -0.08162138f, 0.06697207f, -0.07493787f, 
    0.00378041f, -0.02049696f, 0.08450691f, 0.00128990f, -0.04424739f, -0.04901586f, -0.03766939f, 0.01284990f, 
    -0.13555586f, -0.08318529f, -0.06744478f, -0.03492849f, 0.03619986f, 0.02961629f, -0.03781583f, -0.06305374f, 
    -0.07301893f, 0.03467549f, -0.01580801f, -0.06495512f, -0.02693914f, 0.03308533f, -0.07498584f, -0.07676524f, 
    0.00052786f, 0.03411813f, 0.03204127f, 0.02084148f, -0.04865387f, -0.10324755f, -0.08254654f, 0.07857551f, 
    -0.06635592f, -0.00453454f, 0.03614942f, 0.00285389f, 0.03035064f, -0.04467745f, -0.10403473f, -0.07977136f, 
    -0.00548423f, 0.07499574f, -0.06566983f, -0.10427420f, -0.08006160f, -0.09414221f, -0.01438628f, 0.07101072f, 
    -0.05442178f, -0.07650871f, -0.07344493f, -0.09451772f, -0.11445392f, -0.03195142f, 0.01001243f, -0.03752802f, 
    0.01535750f, 0.01288965f, -0.01746907f, -0.12643981f, -0.09298602f, -0.00651635f, 0.02893717f, -0.07875244f, 
    -0.05348759f, 0.02369124f, -0.12276886f, -0.06888027f, 0.05758178f, 0.04352450f, -0.03588193f, -0.03660160f, 
    -0.01964392f, -0.07837892f, -0.02882259f, -0.05441748f, 0.02413522f, -0.03488984f, -0.05901354f, 0.02032591f, 
    -0.07241773f, -0.00083843f, 0.01173846f, 0.06939717f, -0.02869550f, -0.02157611f, -0.01788279f, -0.04050223f, 
    -0.07557922f, -0.00785046f, 0.02379061f, -0.11525489f, 0.02461074f, -0.12503725f, 0.01660799f, 0.03105010f, 
    -0.08480386f, -0.03357632f, -0.04290261f, -0.01739783f, -0.10312515f, 0.00801302f, -0.02793421f, -0.01108424f, 
    -0.00799752f, 0.02641519f, 0.04249484f, -0.03137130f, -0.08871810f, 0.06858283f, 0.00093391f, 0.00194286f, 
    0.04288949f, 0.03683338f, -0.06412197f, 0.02368830f, -0.07979126f, -0.04570247f, -0.13250659f, 0.01540651f, 
    -0.06651539f, 0.03483419f, -0.07198384f, 0.01966764f, -0.08884197f, 0.00588977f, -0.07112567f, -0.03842144f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04611136f, 0.00953822f, -0.03373827f, -0.12812129f, 0.14582285f, 0.18322557f, 0.28822607f, 0.03518461f, 
    0.02692704f, 0.06065578f, -0.08303037f, -0.08870907f, -0.11983476f, 0.22940642f, -0.07946537f, -0.07513893f, 
    -0.05275540f, 0.16128762f, 0.14483021f, 0.02647813f, -0.11172138f, -0.16762395f, 0.20858869f, -0.07505252f, 
    0.10195557f, -0.06367354f, 0.11967140f, -0.10049528f, 0.00709424f, -0.04781978f, -0.03385997f, 0.02402912f, 
    0.10192964f, 0.09575949f, 0.12296005f, -0.09603044f, 0.22469294f, -0.05988156f, 0.04504558f, -0.03893201f, 
    0.08432020f, -0.10483994f, -0.04709527f, 0.01292651f, -0.04572909f, 0.07869509f, 0.14984405f, -0.01938251f, 
    0.15500583f, -0.13118763f, 0.06880801f, 0.09804846f, 0.06340383f, -0.01574669f, 0.05515637f, -0.06129064f, 
    -0.08462215f, -0.04294044f, -0.03465319f, 0.06380780f, 0.00324600f, 0.19541989f, 0.10363601f, 0.25555030f, 
    0.06343977f, 0.00697407f, 0.09769171f, -0.06827159f, 0.05879346f, -0.11672124f, 0.12275287f, 0.16647001f, 
    0.05526520f, 0.17756693f, -0.00407131f, -0.00444603f, -0.01338136f, 0.04269261f, 0.07857775f, 0.20961571f, 
    0.22212707f, -0.10906208f, 0.10382398f, 0.12664396f, -0.09984283f, 0.02577902f, 0.23779795f, 0.19546646f, 
    -0.11432970f, -0.08045854f, -0.00775743f, 0.20187019f, -0.06490728f, -0.00331267f, -0.05924713f, 0.19325292f, 
    0.04391094f, 0.04693002f, 0.23705649f, 0.08316174f, -0.02906352f, 0.12476169f, -0.10406001f, 0.04171669f, 
    -0.04605559f, -0.01916068f, 0.12025256f, -0.09676380f, 0.13987111f, -0.04975571f, 0.01948024f, 0.11964584f, 
    0.12303185f, 0.05011817f, -0.00353553f, 0.04288214f, -0.07581909f, -0.07673150f, -0.07714069f, -0.01257718f, 
    -0.00056429f, -0.19592489f, 0.01014266f, -0.10696413f, 0.28390205f, -0.06547353f, -0.05934092f, -0.01207915f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.22481398f, -0.01876688f, 0.02039904f, 0.42100653f, -0.30999231f, -0.36388341f, -0.38366050f, 0.00895732f, 
    -0.01954441f, -0.36738411f, 0.03810598f, -0.02736937f, -0.06220863f, -1.00416839f, 0.43091822f, -0.00964790f, 
    -0.02527552f, -0.02640851f, -0.40606123f, 0.17345907f, 0.31097537f, -0.14700186f, -0.04981454f, -0.07762586f, 
    -0.10294230f, 0.10821691f, -0.39709905f, 0.12715463f, 0.01661209f, 0.02485042f, 0.10217917f, 0.09109218f, 
    -0.06290737f, -0.24687502f, 0.12325498f, -0.04807003f, -0.45786881f, -0.11592192f, -0.03582127f, -0.01937522f, 
    -0.33730850f, 0.18818741f, -0.03992677f, 0.03426216f, 0.03092278f, 0.05214521f, 0.04486562f, 0.04603859f, 
    0.04526063f, 0.27660844f, -0.15994090f, -0.17273061f, 0.07865054f, 0.01019377f, -0.05141034f, 0.06500800f, 
    -0.01782729f, 0.00753338f, 0.02119645f, -0.05589610f, -0.06869365f, -0.12728496f, -0.02256434f, -0.02999615f, 
    -0.23288514f, -0.10838137f, -0.18783069f, 0.06161617f, 0.26504111f, 0.01762328f, 0.09128156f, -0.00543117f, 
    0.08165124f, -0.16503003f, -0.01362434f, 0.03430643f, 0.01110525f, 0.17786464f, 0.15774772f, 0.01198726f, 
    0.14646606f, 0.03186204f, -0.04197497f, 0.07022765f, 0.04514144f, 0.10518996f, 0.09197434f, -0.03718483f, 
    0.04579861f, 0.03461803f, -0.07735792f, -0.19690435f, 0.00024109f, -0.07890385f, 0.04766881f, -0.50437105f, 
    0.04781273f, -0.26442051f, 0.24032173f, -0.20534757f, -0.05447598f, -0.17719361f, 0.02137895f, 0.07749788f, 
    0.00062675f, 0.00571639f, -0.18129882f, 0.06283180f, -0.02018537f, 0.00617766f, 0.01821631f, -0.03162126f, 
    -0.25637630f, -0.02386565f, -0.03754314f, -0.07475045f, -0.07159192f, 0.05814359f, -0.05400637f, -0.01423548f, 
    -0.02922250f, 0.26008254f, -0.01261712f, 0.07665655f, -0.53490430f, -0.02341209f, 0.02021833f, -0.10203176f, 
    -0.59440678f, -0.12272736f, 0.05372392f, -0.41851771f, 0.01509164f, 0.17276953f, 0.15077250f, -0.02251565f, 
    0.06575497f, -0.24026808f, 0.01404579f, 0.04003198f, -0.00826344f, 0.26026934f, -0.39904234f, 0.03430022f, 
    -0.06305331f, 0.01932309f, 0.15444493f, 0.03539844f, -0.45170239f, 0.02021625f, 0.36996293f, -0.02039692f, 
    0.11971541f, 0.07047100f, -0.77507579f, 0.14672871f, 0.13196526f, 0.10863762f, 0.22812007f, 0.25713223f, 
    0.03282157f, -0.21581873f, -0.40475497f, 0.03798838f, 0.01229893f, -0.11912876f, -0.03696898f, -0.06794392f, 
    -0.33975461f, -0.16887520f, 0.05978556f, -0.03912183f, -0.03265549f, -0.07484362f, 0.01879934f, 0.03333720f, 
    -0.21452798f, -0.55465287f, 0.08895408f, -0.00139804f, 0.06175828f, -0.04898304f, 0.08830407f, 0.05622484f, 
    -0.01071710f, 0.11589127f, 0.02399391f, -0.04548068f, -0.09111863f, -0.02733690f, 0.02293634f, 0.31445700f, 
    -0.02442788f, 0.07787090f, -0.15973727f, -0.07489325f, -0.45036528f, -0.08352539f, 0.07547873f, -0.01137959f, 
    -0.06175228f, -0.17183298f, -0.07542491f, -0.28716236f, -0.02873995f, 0.04175040f, -0.15816233f, 0.17852153f, 
    -0.38073587f, -0.01521789f, 0.00879387f, 0.05892377f, 0.01026622f, -0.57956839f, 0.08401603f, 0.14874671f, 
    -0.01678056f, 0.00132778f, 0.07154494f, 0.14778847f, -0.04155483f, -0.04300531f, 0.06287612f, -0.26675662f, 
    -0.05632921f, -0.00155414f, -0.04995547f, 0.06837510f, -0.05222971f, 0.12238882f, -0.08370418f, 0.04389399f, 
    -0.06731429f, -0.06290463f, 0.10116054f, -0.06117867f, 0.01995510f, -0.09640291f, -0.02941914f, -0.12885630f, 
    -0.06362195f, -0.02172537f, -0.00658321f, 0.16302481f, -0.04831856f, 0.05509664f, -0.01881428f, 0.03565501f, 
    0.64468950f, -0.88875777f, -0.06343342f, 0.31004092f, 0.12044379f, -0.07029133f, -0.03895185f, 0.06713247f, 
    0.01916252f, -0.19406109f, -0.09282185f, -0.13230926f, -0.06907540f, 0.05877129f, 0.06218191f, -0.00670987f, 
    0.07595823f, 0.03591037f, -0.09346076f, -0.10886532f, 0.02873696f, -0.71280456f, -0.10824685f, 0.06169435f, 
    -0.07375629f, 0.15172264f, 0.27555314f, 0.08290447f, -0.23363082f, -0.08840440f, -0.00705004f, -0.02775985f, 
    0.17661045f, -0.18656394f, -0.04491340f, -0.38517207f, -0.34740800f, -0.01869768f, -0.27010918f, -0.29571414f, 
    0.01234531f, -0.02420552f, -0.32425833f, 0.12595907f, 0.11690387f, -0.11505496f, -0.07018838f, -0.03003700f, 
    0.11133407f, 0.12567337f, -0.04619081f, 0.07502203f, 0.04659297f, 0.09898312f, 0.05058175f, 0.01553207f, 
    0.10188264f, 0.30609015f, -0.02992496f, 0.09342615f, 0.07674194f, 0.03628471f, -0.06095803f, -0.23753574f, 
    -0.02172580f, 0.15713896f, -0.03109871f, -0.18050560f, 0.02828152f, -0.00639528f, -0.12071353f, -0.50512612f, 
    0.21565415f, -0.12407181f, -0.08240160f, 0.05492398f, -0.39766183f, -0.09746398f, 0.08182031f, -0.07217680f, 
    -0.04447212f, 0.25342894f, -0.03857332f, -0.41452578f, -0.00474077f, -0.71109998f, 0.13654649f, -0.11707034f, 
    0.11398957f, -0.06670595f, -0.16560122f, 0.10161629f, 0.04854367f, -0.88318944f, -0.05659408f, 0.18182234f, 
    -0.05984667f, -0.07362954f, -0.06360455f, 0.17591891f, 0.02133860f, -0.08238282f, -0.08198765f, 0.39556152f, 
    -0.09616707f, 0.13580798f, 0.35677898f, -0.07308385f, -0.08099222f, 0.41038728f, -0.05743382f, -0.01602818f, 
    -0.06589456f, 0.03429267f, -0.25373110f, 0.00803943f, -0.57998103f, 0.07658444f, -0.49988124f, -0.17911068f, 
    0.14516230f, -0.02669064f, 0.02660389f, -0.11383834f, 0.06338271f, -0.05365153f, -0.07348894f, 0.05508146f, 
    -0.49548724f, 0.27505016f, 0.06030601f, -0.32505617f, -0.64058644f, 0.04713599f, 0.05771359f, -0.04105929f, 
    0.18144307f, 0.10030046f, -0.02631784f, -0.00356922f, -0.30469951f, -0.28116769f, 0.03521778f, -0.00272805f, 
    -0.02219165f, -0.05365834f, 0.01342310f, -0.03788877f, -0.03587727f, -0.83989489f, 0.18259782f, -0.03388260f, 
    0.01097681f, 0.07569667f, -0.03261561f, 0.08082933f, -0.01380685f, -0.13328448f, -0.37682584f, -0.10922122f, 
    -0.43567362f, 0.01685561f, 0.27304539f, -0.09539079f, 0.07507518f, -0.01938617f, 0.04542784f, 0.02348008f, 
    -0.16119631f, 0.13213858f, 0.31109706f, -0.06309940f, -0.20667492f, -0.01217936f, 0.08266509f, 0.00419174f, 
    0.31085399f, -0.08587822f, -0.04385239f, 0.02416483f, 0.02303104f, 0.00837191f, 0.14079194f, -0.01066009f, 
    -0.14619151f, 0.06248289f, 0.00387337f, -0.03856678f, 0.02154477f, -0.06515826f, -0.04143231f, 0.03045258f, 
    0.01830596f, -0.28989035f, 0.05336198f, 0.15605243f, 0.05753865f, -0.09047600f, -0.77660292f, -0.35567716f, 
    -0.18508287f, 0.15924712f, -0.21024431f, 0.07212200f, 0.12813218f, -0.04956432f, -0.10590014f, 0.03960403f, 
    0.04301704f, 0.05296522f, 0.03088991f, 0.12629952f, 0.04033658f, 0.14092255f, 0.01255954f, 0.14334317f, 
    -0.06165959f, -0.11030970f, 0.11842271f, 0.11664826f, -0.09404580f, -0.01491985f, 0.07287043f, -0.05734644f, 
    -0.03719061f, -0.01078993f, 0.01076366f, -0.45705569f, -0.07628949f, -0.03255506f, -0.08028327f, 0.36546126f, 
    -0.03134910f, 0.02522720f, 0.32070509f, -0.19667175f, -0.00169662f, -0.12100681f, -0.09160479f, -0.03188821f, 
    -0.00987398f, 0.04016620f, -0.17230657f, -0.05405160f, 0.09407660f, 0.06799906f, 0.02289630f, 0.04654117f, 
    -0.30061692f, -0.04330251f, -0.00662883f, 0.02325289f, -0.01650207f, -0.00268840f, 0.01676851f, 0.02560846f, 
    0.10471547f, -0.03485990f, -0.07494475f, -0.16317576f, -0.62020701f, -0.00597571f, -0.08997150f, 0.06094650f, 
    -0.37448987f, 0.12030630f, 0.00425282f, -0.32643935f, -0.01944398f, -0.04629280f, -0.79476815f, 0.03817089f, 
    -0.01949538f, -0.08913299f, -0.05817258f, -0.05201041f, 0.00117672f, 0.02247881f, -0.57254648f, 0.00520625f, 
    0.02044470f, 0.02968116f, -0.10388895f, 0.07332383f, -0.01065286f, -0.01052265f, -0.06118352f, -0.03017177f, 
    -0.20161207f, 0.08122826f, 0.10764685f, -0.02200869f, 0.13316819f, 0.02600132f, 0.16876382f, 0.14353216f, 
    -0.49343866f, -0.00020218f, 0.08330625f, -0.00851438f, 0.01313872f, -0.29901972f, -0.04090754f, -0.08251711f, 
    -0.11587829f, -0.26467574f, -0.07757135f, -0.03544619f, -0.06127577f, 0.08816160f, -0.00504344f, 0.03197240f, 
    -0.57426184f, -0.27365962f, 0.22383873f, 0.17510696f, 0.00364652f, 0.03585277f, 0.16165383f, 0.08428049f, 
    -0.03849141f, 0.15786983f, 0.06946310f, 0.06388072f, -0.02118178f, 0.08378185f, 0.42540863f, -0.67667615f, 
    0.16315460f, 0.03165255f, -0.03596975f, -0.05650147f, -0.23144765f, 0.01520121f, -0.33755186f, 0.14444301f, 
    -0.02518521f, 0.09582561f, 0.02923485f, 0.11632725f, 0.01346403f, 0.01441539f, -0.40774029f, 0.10652553f, 
    -0.92439723f, -0.07021152f, -0.27993032f, 0.13069126f, -0.02919125f, 0.17188610f, 0.01436652f, -0.56462419f, 
    -0.07072152f, -0.04076288f, -0.08696432f, -0.28471541f, 0.01023176f, -0.07444952f, -0.06530416f, -0.15017821f, 
    0.01182430f, -0.02774638f, -0.29579359f, -0.04440574f, -0.00709770f, 0.05873155f, 0.01919241f, 0.02110753f, 
    0.01500233f, -0.02278114f, 0.12442452f, 0.05892904f, 0.08272532f, -0.05285855f, -0.08816238f, 0.18228410f, 
    -0.02395613f, 0.07354505f, 0.02888255f, -0.53848416f, -0.05546703f, -0.01143629f, 0.04437130f, -0.02253147f, 
    -0.53879380f, -0.05214071f, 0.01156549f, 0.17415597f, 0.13909231f, 0.00228366f, 0.04180817f, -0.04908268f, 
    -0.41987771f, 0.15258807f, 0.05617911f, 0.22317332f, 0.11150147f, 0.05089105f, 0.00430108f, 0.04409647f, 
    -0.06843331f, 0.14831318f, 0.06426076f, 0.02778129f, -0.05847476f, -0.34446973f, 0.27425599f, 0.00985256f, 
    -0.03307223f, 0.10363775f, 0.01723809f, 0.01992067f, -0.10443931f, -0.04152268f, -0.41116455f, 0.06791420f, 
    0.00512189f, -0.04082515f, 0.19439530f, -0.27796555f, -0.07272603f, 0.00779152f, -0.04625626f, 0.00981364f, 
    -0.37477499f, 0.01068413f, -0.44656414f, -0.02652149f, 0.18044260f, -0.28732589f, 0.08372546f, -0.04025875f, 
    -0.62664622f, 0.38255849f, -0.05623832f, -0.01904020f, -0.06831276f, 0.10837783f, 0.04300564f, -0.09219544f, 
    -0.03125216f, 0.13279293f, -0.09725792f, 0.17768478f, -0.01831290f, -0.00944220f, 0.00592779f, 0.13592699f, 
    -0.02547904f, 0.09729190f, -0.07582533f, -0.03542694f, -0.05882377f, 0.15127520f, 0.33928508f, -0.33061069f, 
    0.22125441f, -0.45919701f, 0.25012732f, -0.03050115f, -0.04496599f, -0.04872463f, -0.06994885f, 0.15004043f, 
    0.04140161f, -0.04885927f, -0.00534002f, 0.07828266f, 0.00933265f, -0.08829313f, -0.03342794f, 0.04585934f, 
    0.09746857f, -0.09107846f, -0.02988872f, 0.10002513f, -0.02210612f, -0.12019246f, 0.00358081f, -0.06904879f, 
    0.07572035f, -0.00176096f, -0.01701993f, 0.08478660f, 0.06329425f, -0.00698063f, -0.10802437f, -0.32572618f, 
    -0.01718026f, -0.03645742f, -0.69988692f, 0.16372147f, -0.10349122f, 0.12810974f, -0.05829205f, -0.04177668f, 
    0.05426128f, 0.01304746f, 0.08599414f, -0.01929594f, -0.02074113f, -0.02391828f, -0.19449210f, 0.15165128f, 
    0.16902639f, -0.00409248f, -0.07546307f, 0.16539808f, 0.07225548f, -0.06586511f, -0.07776508f, -0.06282898f, 
    -0.25087708f, 0.33640382f, 0.02684111f, 0.01421293f, 0.35406768f, -0.03106202f, -0.01175082f, 0.00619695f, 
    0.16295718f, -0.17052071f, -0.01700785f, 0.13184267f, 0.11802558f, -0.15743656f, -0.03352559f, -0.03993850f, 
    0.07208847f, 0.18874727f, 0.06100820f, -0.05021692f, -0.07824637f, 0.07316365f, 0.04092702f, -0.00702347f, 
    0.05680315f, -0.52743834f, -0.21703988f, -0.66813076f, -0.01136290f, 0.03416492f, -0.11961218f, -0.03275029f, 
    0.13423774f, -0.08738850f, -0.10420536f, -0.07450711f, -0.55928183f, -0.29048508f, -0.25888196f, -0.34524506f, 
    0.16092780f, -0.13028976f, -0.46005976f, 0.04654948f, -0.00017948f, 0.17404088f, -0.01542199f, -0.04993437f, 
    0.24957967f, 0.01137322f, 0.01660266f, 0.04209210f, 0.05427891f, -0.51492280f, -0.76260740f, 0.05298128f, 
    0.17330268f, -0.08601137f, 0.19463919f, -0.38204664f, 0.00132512f, -0.03601119f, -0.20151627f, 0.06869949f, 
    0.00672051f, -0.02771795f, 0.06183533f, -0.72085309f, 0.05704313f, -0.12681817f, -0.33766562f, -0.18540210f, 
    -0.17954120f, 0.08002307f, 0.17173436f, -0.02974877f, 0.04885248f, 0.03605420f, 0.11941580f, -0.27562368f, 
    0.06625015f, 0.23366243f, 0.07324316f, -0.30428517f, -0.01038851f, -0.65222323f, 0.29877919f, -0.50781208f, 
    0.15954424f, -0.03420500f, -0.29131627f, -0.68275368f, -0.00167908f, -0.17199066f, -0.72806132f, 0.12721604f, 
    -0.02998698f, 0.07363124f, 0.03256910f, 0.20331991f, -0.00974813f, 0.05119647f, 0.00395903f, 0.14894746f, 
    -0.54259968f, 0.08682011f, 0.39360440f, -0.52019966f, -0.11716095f, -0.39263591f, 0.00853802f, -0.03244351f, 
    0.02577080f, -0.04654753f, 0.04431788f, 0.02102743f, -0.14470135f, -0.00318397f, -0.45634356f, -0.50312936f, 
    0.11578112f, -0.04704159f, -0.07545139f, -0.04108108f, 0.07438419f, 0.00762811f, -0.00432050f, 0.06121024f, 
    0.42812830f, 0.02309851f, 0.02905218f, -0.02973827f, 0.12885921f, 0.01948487f, -0.02982298f, -0.01678134f, 
    0.45102805f, 0.05575689f, -0.04462713f, -0.18119082f, -0.02295540f, 0.09151047f, -0.34451774f, 0.00740017f, 
    0.03328500f, 0.03390427f, 0.06046376f, -0.12296142f, -0.05556799f, -0.06082012f, -0.14308318f, 0.03566354f, 
    -0.07686957f, -0.53470212f, 0.22855903f, -0.64844716f, -0.17951076f, -0.10101678f, -0.38438791f, -0.02536955f, 
    -0.40714809f, 0.03586102f, 0.31369579f, -0.00179003f, 0.22815555f, -0.13978432f, -0.28142142f, -0.57682759f, 
    -0.06459660f, -0.56199127f, -0.03694251f, -0.01885345f, -0.21045546f, 0.02770758f, 0.02253814f, -0.04366072f, 
    0.16270939f, -0.18432918f, 0.00971091f, 0.03374095f, -0.03148212f, -0.29159370f, -0.08699370f, -0.01212572f, 
    -0.29544064f, 0.28453609f, 0.02614665f, 0.16183646f, -0.04919155f, 0.01619271f, 0.13447046f, 0.14599206f, 
    -0.07711557f, 0.12996109f, 0.00162245f, 0.26124185f, -0.02425426f, -0.30568445f, -0.20251468f, 0.32080683f, 
    -0.07272825f, 0.06663951f, -0.01253949f, -0.08893722f, -0.12415327f, 0.06561314f, -0.25694385f, 0.02918756f, 
    0.03677067f, -0.81560814f, -0.03396519f, -0.04797573f, -0.01005122f, -0.54748195f, -0.42663905f, 0.21058813f, 
    0.06142306f, -0.07144980f, -0.01334550f, -0.13322411f, -0.02558079f, -0.40759352f, -0.80490768f, -0.22418140f, 
    -0.00917868f, 0.01185769f, 0.00405065f, -0.16345949f, 0.00578732f, -0.01417097f, 0.05588171f, 0.28123656f, 
    0.08972181f, 0.01009798f, -0.21731718f, -0.07922015f, -0.00176155f, -0.47851777f, -0.07470695f, -0.05031556f, 
    -0.03776230f, -0.01155953f, -0.21417773f, -0.00227081f, 0.25980812f, 0.01096734f, 0.38010141f, -0.33151641f, 
    -0.22231844f, -0.06467002f, 0.06961334f, -0.25494576f, 0.01641325f, 0.09485567f, -0.10082059f, 0.01263365f, 
    0.12750731f, 0.09986366f, 0.07103654f, -0.03984120f, 0.14245087f, 0.04135965f, -0.06336460f, -0.03611077f, 
    0.13978715f, -0.17229138f, 0.02097621f, -0.37581483f, -0.12380452f, 0.24756952f, 0.14408225f, -0.07897178f, 
    -0.02932485f, 0.08007608f, -0.00738680f, -0.11785924f, -0.13880038f, -0.07066758f, -0.09087271f, -0.00541024f, 
    -0.07393002f, 0.01252115f, -0.10584547f, -0.74415296f, -0.09531042f, 0.01409872f, -0.10570207f, -0.08470032f, 
    0.18876463f, -0.06194244f, -0.39027053f, -0.45401263f, 0.07310154f, -0.26198140f, -0.59597766f, -0.97269899f, 
    -0.20656878f, 0.09303041f, -0.45476019f, -0.11237645f, 0.11494236f, 0.04153434f, 0.04938118f, 0.02623796f, 
    -0.59502953f, -0.63408595f, 0.04869762f, -0.04149520f, -0.05582788f, 0.16621107f, 0.21350324f, 0.04047116f, 
    0.19671834f, -0.55474859f, -0.45035934f, -0.39006361f, -0.01588815f, -0.04307422f, -0.64268655f, -0.28242788f, 
    -0.03344504f, 0.08934973f, -0.04378869f, 0.33298379f, -0.07810956f, 0.05013374f, -0.11265921f, -0.23724145f, 
    -0.28529793f, 0.11520959f, 0.14093025f, -0.01755899f, -0.35169870f, 0.03493127f, 0.12119476f, -0.43502110f, 
    -0.06492557f, -0.44737384f, 0.04657003f, 0.09577044f, 0.01166307f, -0.05508155f, 0.04666636f, -0.07329408f, 
    0.12344390f, -0.00604079f, 0.25321421f, -0.00266972f, -0.02485720f, -0.36504397f, -0.25408342f, 0.20246471f, 
    0.01139540f, 0.04029046f, 0.02943511f, 0.04762563f, -0.03201910f, -0.05603318f, 0.01786362f, -0.66921371f, 
    0.27968091f, 0.22124466f, -0.26393986f, -0.39567384f, -0.07039511f, -0.24460191f, -0.11152280f, -0.07685984f, 
    -0.02487467f, 0.06176057f, 0.11142049f, -0.01430630f, 0.00884431f, 0.02963538f, 0.07223347f, 0.07289162f, 
    0.23004909f, -0.01243603f, -0.00297839f, 0.35566854f, -0.00039150f, 0.05691828f, 0.00822377f, 0.02691180f, 
    -0.21442129f, -0.26023939f, 0.00399474f, -0.52047795f, -0.23293467f, -0.00270081f, -0.07376567f, -0.10932413f, 
    -0.06364014f, -0.08263379f, -0.08582748f, -0.21670751f, 0.18814376f, -0.30535483f, 0.11257105f, -0.03529698f, 
    -0.06691802f, 0.07535538f, 0.03541847f, 0.02749776f, -0.12854780f, -0.05044361f, -0.15384100f, 0.04285057f, 
    -0.07095724f, 0.09843303f, -0.34755072f, 0.05652350f, -0.10502690f, -0.04205455f, 0.62655377f, -0.04226380f, 
    -0.50437707f, -0.23545773f, -0.26889023f, -0.60732949f, -0.20900373f, 0.47711301f, -0.46545956f, 0.02903238f, 
    0.03438557f, 0.14495029f, -0.24648668f, -0.06851674f, 0.14788710f, 0.06451686f, 0.06316611f, 0.06751581f, 
    0.13874912f, -0.25866693f, -0.05315131f, -0.09126330f, 0.02623867f, -0.25901055f, -0.34247470f, 0.00688155f, 
    0.16326205f, -0.22873211f, 0.10092667f, -0.05108484f, 0.03189503f, 0.03476170f, 0.06757270f, -0.17824239f, 
    -0.02866488f, -0.34964827f, 0.04361636f, -0.51624197f, 0.04659562f, 0.03798538f, 0.01514359f, -0.11867395f, 
    0.04288217f, -0.16617388f, 0.19417645f, 0.00577025f, 0.15629713f, 0.01842660f, 0.24202707f, 0.09213404f, 
    -0.00192508f, 0.11955339f, 0.01315298f, -0.06383552f, 0.04565396f, 0.23075724f, 0.08142789f, -0.23287126f, 
    0.15369888f, -0.02182638f, -0.62688684f, -0.15704593f, 0.01402986f, -0.27276266f, 0.14121003f, -0.33084306f, 
    -0.06705943f, 0.06394392f, 0.04996912f, -0.36919934f, 0.06479510f, -0.08738552f, -0.01775466f, -0.29482839f, 
    -0.64973944f, -0.09719546f, 0.15729348f, 0.38258728f, -0.05047908f, -0.09921981f, 0.03322035f, -0.05402367f, 
    -0.09468914f, -0.08330286f, 0.36726320f, 0.02135673f, -0.50146270f, -0.10512651f, -0.27662542f, 0.15627325f, 
    -0.01548736f, 0.00931286f, 0.04875643f, -0.35845026f, -0.02912270f, -0.07263986f, 0.01857945f, -0.06820945f, 
    -0.28796819f, -0.56877583f, -0.00518572f, -0.16742867f, -0.10613507f, -0.05180036f, -0.06758109f, -0.12814656f, 
    0.29819727f, -0.79797494f, 0.01480157f, -0.08195180f, -0.09258864f, -0.09821110f, 0.05941278f, -0.09154686f, 
    0.05204415f, -0.15155636f, 0.07013726f, -0.02922321f, -0.00261045f, -0.24128455f, -0.22354107f, -0.04327066f, 
    -0.03572816f, 0.04084279f, 0.08590984f, 0.20896822f, -0.27125710f, -0.14280733f, -0.07617823f, -0.07144275f, 
    0.14554624f, -0.56915271f, 0.08352576f, 0.13854557f, 0.12529938f, -0.76095754f, 0.38513383f, -0.17365378f, 
    -0.40992561f, 0.11642420f, 0.05772987f, 0.00876722f, -0.03138773f, 0.21879485f, 0.05330209f, -0.04082066f, 
    0.00683444f, 0.33968887f, 0.00088630f, 0.08445055f, -0.05812037f, 0.04563550f, 0.02903629f, 0.02589197f, 
    -0.10628543f, -0.47509575f, -0.10832830f, -0.38927108f, 0.01268629f, -0.06340284f, 0.05417147f, -0.65848690f, 
    -0.07002349f, -0.47358674f, -0.04270321f, 0.03488014f, 0.01986002f, 0.02033326f, 0.13195457f, -0.75738192f, 
    -0.47098798f, 0.16755918f, -0.07486695f, 0.05718259f, -0.46868625f, -0.03408898f, -0.18203162f, -0.36736304f, 
    -0.06046006f, -0.15696901f, 0.04531297f, -0.41232792f, -0.05033499f, -0.32932279f, -0.00290538f, 0.16737115f, 
    -0.23482069f, 0.02900936f, 0.15125822f, 0.05610020f, -0.05712076f, -0.21692164f, 0.09814164f, 0.16539536f, 
    -0.03576939f, 0.02327553f, -0.08989473f, 0.14948800f, -0.00224783f, -0.07715356f, 0.01118872f, -0.14247434f, 
    0.09533860f, -0.16091225f, -0.50122297f, -0.00467962f, -0.04648343f, 0.27959675f, -0.07611567f, -0.08555726f, 
    0.04545035f, -0.09226828f, -0.38386145f, -0.06556323f, 0.13010563f, 0.04564404f, 0.25662184f, 0.03263478f, 
    -0.04118951f, 0.02507673f, -0.03651926f, 0.10480661f, 0.04261496f, 0.00645070f, 0.02832288f, 0.01450866f, 
    -0.25608677f, -0.56799859f, -0.07518416f, -0.78331733f, -0.12697311f, -0.02688378f, 0.06719861f, -0.10079671f, 
    -0.24654013f, -0.01429694f, -0.03998869f, 0.46757630f, 0.10091756f, 0.14705677f, 0.02860862f, 0.05568944f, 
    0.07523189f, 0.08575186f, 0.05116517f, -0.03668916f, -0.04502536f, 0.17300801f, -0.07902117f, 0.00188023f, 
    0.06421715f, -0.32756510f, 0.20363677f, -0.01070620f, -0.10132267f, 0.06338853f, -0.39094839f, -0.12300815f, 
    -0.06305934f, -0.17211939f, 0.40006727f, 0.28276309f, -0.10999665f, -0.13573784f, -0.33861339f, -0.21171767f, 
    0.30919561f, 0.06866836f, 0.42941675f, -0.00490105f, -0.16357096f, 0.12921250f, -0.06866921f, -0.00804200f, 
    0.05713632f, -0.05549670f, -0.07025966f, -0.05088510f, 0.00969752f, -0.04324731f, 0.08263306f, -0.05763467f, 
    0.07738251f, -0.79091597f, -0.00392524f, 0.16284098f, -0.07172231f, -0.05701888f, -0.36939961f, -0.35682985f, 
    0.01843474f, -0.34109792f, -0.00721135f, 0.15200765f, -0.07705428f, -0.31857243f, 0.19661501f, -0.01231335f, 
    0.22670931f, 0.28429615f, 0.02403031f, 0.04967943f, 0.17019100f, 0.01467801f, -0.09237261f, -0.18937299f, 
    -0.08872901f, -0.20016505f, -0.00134427f, 0.05186871f, 0.00739683f, 0.09145388f, 0.04899504f, -0.49576119f, 
    0.02670992f, -0.07078695f, 0.17735010f, -0.00468953f, -0.03489456f, -0.48179087f, -0.29818484f, 0.05336147f, 
    0.00696877f, 0.03750338f, 0.05960883f, -0.04471405f, 0.00341718f, -0.05236411f, 0.00889932f, 0.20283514f, 
    -0.09008083f, 0.11056837f, -0.04377710f, -0.37131155f, -0.08822175f, -0.20248353f, -0.02231534f, 0.03208153f, 
    -0.05947872f, 0.02709394f, -0.02763743f, 0.03445028f, 0.15437013f, -0.01593107f, 0.04831006f, -0.01472383f, 
    0.17946211f, -0.00418041f, -0.04006435f, -0.65132612f, 0.04417418f, -0.03538794f, -0.06839622f, 0.02243982f, 
    -0.51427722f, -0.31704071f, -0.00282197f, -0.08302074f, 0.12775369f, -0.09568875f, -0.02833637f, 0.03640464f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.21530156f, 0.06129385f, -0.05589437f, 0.14191358f, -0.03036319f, 0.09435608f, 0.07839299f, -0.15055017f, 
    -0.06478763f, 0.11900358f, 0.03933786f, -0.16042028f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
