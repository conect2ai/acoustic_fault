#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.28185362f, 0.18218815f, 0.40402970f, -0.18189600f, -0.66988319f, -0.58754051f, -0.12566498f, -0.47376701f, 
    -0.24072978f, 0.04596220f, 0.10432124f, 0.64841789f, -0.36877817f, -0.42583519f, -0.35445929f, -0.02648559f, 
    -0.05900279f, 0.04810523f, 0.03489289f, -0.20859431f, -0.00515517f, -0.57604885f, -0.51125109f, -0.22413281f, 
    0.00196417f, -0.14855224f, 0.88722348f, 0.23759520f, -0.38410354f, 0.20422152f, 0.21492568f, -0.06963883f, 
    0.23916475f, 0.01216148f, 0.07439622f, -0.35099310f, -0.23231298f, 0.12948962f, -0.25501683f, -0.29107895f, 
    0.39915407f, 0.04408339f, 0.05478702f, -0.12542483f, -0.04782145f, -0.14740217f, -0.11199991f, -0.38540745f, 
    -0.46843949f, -0.72545391f, 0.56645447f, 0.42814350f, 0.51846224f, 0.12112161f, -0.21690869f, 0.22449605f, 
    0.05291425f, 0.25679410f, 0.18038833f, 0.05192996f, -0.19310308f, -0.72703236f, -0.22347516f, 0.34654951f, 
    -0.32800594f, 0.33804357f, 0.05696445f, -0.01872993f, -0.19031322f, -0.37346703f, 0.20816752f, -0.32090724f, 
    -0.12579203f, 0.15293081f, 0.20255193f, 0.15669917f, 0.01023678f, 0.37985402f, 0.42749751f, 0.56706476f, 
    0.27567863f, -0.18179390f, -0.12613329f, 0.24068864f, 0.40915987f, 0.17533784f, 0.07589323f, -0.12250257f, 
    -0.22148377f, 0.28252360f, -0.31001052f, -0.15992488f, -0.14328086f, 0.36938649f, -0.17548892f, 0.24348497f, 
    -0.08805086f, 0.03958054f, -0.16956544f, -0.26545286f, 0.68102103f, 0.33246091f, 0.38033924f, -0.91494060f, 
    0.14009228f, 0.24231583f, -0.21988598f, 0.05631251f, -0.35618001f, -0.43845344f, 0.03518568f, 0.11234798f, 
    0.06442594f, 0.18082486f, 0.01276325f, 0.07624818f, -0.40837768f, -0.28297421f, 0.44904643f, 0.07336038f, 
    0.07536059f, 0.36183745f, 0.06599694f, -0.42527109f, -0.18691219f, -0.03268325f, -1.03592849f, -0.82938558f, 
    -0.45743993f, 0.69855809f, -0.15889266f, -0.34835771f, -0.47821558f, -0.04172554f, -0.05156061f, -0.11985653f, 
    -0.16232094f, -0.01543233f, -0.35116008f, -0.07939870f, 0.01501957f, 0.00513044f, -0.07758374f, -0.09828883f, 
    -0.01918583f, -0.17971770f, -0.09803268f, 0.06891754f, -0.31972647f, -0.38970241f, 0.43154892f, -0.08535004f, 
    -0.44380084f, 0.10870252f, 0.13278542f, -0.36885223f, 0.26731813f, 0.40437686f, 0.34310165f, -0.13286480f, 
    -0.01371547f, 0.53252846f, -0.17902154f, -0.21989183f, -0.02374500f, -0.16955587f, 0.23630238f, 0.33913574f, 
    -0.54878813f, 0.11110355f, 0.14456455f, 0.30230308f, -0.12675349f, 0.10733575f, 0.37561545f, -0.58068264f, 
    -0.03907214f, 0.36554995f, -0.58586705f, -0.81874323f, 0.24215099f, 0.10278478f, -0.64418668f, -0.44211450f, 
    0.12599422f, 0.27180547f, 0.02397087f, 0.41931877f, 0.41818881f, 0.33042389f, -0.23294103f, -0.20194739f, 
    -0.24710134f, -0.26160538f, -0.49028233f, 0.06088251f, 0.35295588f, 0.24770848f, 0.03770978f, -0.01424857f, 
    -1.23308766f, -0.30073243f, -0.71652091f, 0.57238722f, 0.30787703f, 0.28524339f, -0.21503881f, 0.01137930f, 
    0.48799548f, 0.95448416f, 0.30916408f, -0.06767941f, -0.26244235f, 0.15998010f, 0.36936316f, -0.28358439f, 
    0.26927611f, 0.00835357f, -0.15837514f, -0.38622883f, 0.11714491f, -0.14074627f, 0.13292679f, 0.19815843f, 
    -0.02097456f, 0.57664752f, -0.09548429f, 0.45535004f, 0.15746260f, 0.57184523f, -0.09607871f, -0.48931649f, 
    -0.27317697f, -0.10906564f, -0.20001402f, -0.09149678f, -0.19161935f, 0.27668777f, -0.32700142f, -0.01325587f, 
    -0.21621989f, -0.05437776f, -0.07450507f, -0.17078657f, 0.14780352f, 0.27005231f, 0.04410554f, 0.06765418f, 
    0.39867792f, 0.29870203f, -0.99690872f, -0.06008492f, -0.37783560f, -0.80426645f, -0.61988729f, 0.77273202f, 
    -0.08192643f, -0.12552896f, -0.40586996f, 0.52953309f, -0.28628042f, -0.40717849f, -0.20409165f, -0.29101297f, 
    -0.30158040f, 0.23584858f, 0.10851913f, 0.08927210f, -0.07377228f, 0.17412944f, 0.05841604f, -0.01431504f, 
    -0.18452884f, 0.02781874f, 0.16466908f, -0.28776118f, -0.27558711f, -0.00752789f, 0.83331853f, 0.16767524f, 
    -0.07714073f, -0.38548329f, -0.32395580f, 0.03723265f, 0.04343794f, -0.23816197f, -0.12332770f, -0.22223116f, 
    -0.10271213f, 0.31784910f, 0.02851356f, -0.20378508f, 0.46967161f, -0.14421038f, -0.34153742f, 0.00855866f, 
    -0.07107315f, -0.39783314f, 0.36178198f, 0.22678687f, 0.56974649f, -0.27756929f, 0.26820090f, 1.06953418f, 
    -0.18335630f, -0.56778133f, -0.32512218f, -0.01747149f, -0.24334167f, -0.44672817f, 0.37818483f, -0.44294819f, 
    0.11025532f, 0.04586593f, 0.48167950f, -0.26241666f, 0.45686612f, 0.15507390f, -0.04802939f, 0.34071204f, 
    -0.16040120f, -0.10491803f, -0.10613394f, 0.12361530f, -0.14512284f, 1.10820758f, -1.01904821f, -0.83349186f, 
    -0.27352938f, -0.75552464f, 0.96697634f, 0.41583633f, 0.48296574f, -0.22971000f, -0.05272566f, 0.49371192f, 
    -0.00659915f, -0.16163036f, -0.22798476f, 0.02963883f, 0.12795192f, -0.23242718f, 0.04528625f, -0.09781320f, 
    -0.16635682f, -0.30945581f, 0.12087443f, 0.12347529f, -0.02591618f, 0.19105466f, -1.11922526f, 0.16278887f, 
    -0.04067424f, -0.96836251f, -0.51400113f, 0.18327385f, 0.19597577f, 0.28707513f, 0.56851447f, 0.14545448f, 
    0.23215678f, -0.06320861f, 0.00074443f, -0.29567111f, -0.24735008f, 0.10716601f, 0.02460312f, 0.03523272f, 
    0.01463245f, 0.02770065f, -0.03215637f, 0.18797940f, 0.03792034f, -0.22973861f, -0.37827682f, -0.56538200f, 
    -0.48692518f, -0.22271292f, 0.03040890f, 0.33720601f, -0.37437922f, -0.47992277f, -0.42106465f, -0.51439548f, 
    -0.81054616f, 0.61696392f, -0.07814956f, -0.02646230f, 0.53756613f, -0.19067687f, 0.09711883f, -0.02931741f, 
    -0.06665592f, 0.12114107f, 0.08371870f, -0.05798705f, 0.07365491f, 0.48750770f, 0.16024193f, 0.14701983f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.34088039f, -0.11133302f, -0.05293516f, 0.34606627f, 0.17788334f, -0.12049994f, 0.36691293f, 0.15891404f, 
    0.03426038f, 0.47492623f, 0.01110842f, 0.37597027f, 0.01221233f, 0.47120136f, -0.09263602f, 0.09844240f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04130282f, 0.00257428f, -0.00564564f, 0.02012806f, -0.07503717f, -0.01203301f, -0.01614745f, -0.05312891f, 
    -0.03416756f, 0.00812613f, -0.06487649f, 0.04457243f, -0.00004522f, -0.03570877f, 0.04043092f, 0.04512770f, 
    -0.02480295f, 0.05966011f, 0.06150036f, 0.06296557f, 0.02553903f, -0.06296231f, -0.03629707f, -0.07076419f, 
    -0.01336926f, -0.05523669f, 0.06524640f, -0.06534210f, 0.04054689f, -0.03366389f, -0.01946356f, -0.06808716f, 
    -0.01179644f, 0.01660521f, 0.00925030f, -0.05155778f, -0.05873017f, 0.06116356f, -0.00063002f, 0.06501298f, 
    -0.01109506f, 0.03080448f, 0.02945767f, -0.07764983f, -0.06962419f, -0.00977445f, -0.03539673f, -0.05705076f, 
    0.02518993f, -0.03515724f, 0.04409178f, -0.06094746f, -0.00651002f, 0.04766001f, -0.00437887f, 0.06507289f, 
    0.01607847f, 0.03452342f, 0.03337352f, -0.01049627f, 0.02463536f, -0.00186293f, -0.06664322f, -0.00684945f, 
    -0.02862915f, -0.04932801f, 0.03133923f, -0.07084328f, -0.02968428f, 0.03025137f, -0.03138093f, 0.06128863f, 
    -0.01765483f, -0.02474248f, -0.00758239f, -0.01851450f, -0.03200538f, -0.02783109f, -0.03827153f, 0.02628612f, 
    -0.00351630f, -0.01965665f, -0.01158261f, -0.05022587f, -0.03306038f, 0.01920145f, 0.02718797f, -0.00560571f, 
    -0.04790702f, 0.04704789f, -0.04786923f, -0.04996499f, -0.05969007f, 0.02831755f, 0.03206096f, -0.02244363f, 
    -0.02627317f, -0.03194132f, -0.00514608f, 0.00461793f, -0.06185744f, 0.02045165f, 0.01206113f, 0.00712736f, 
    0.06376006f, -0.03514951f, 0.00292498f, 0.02468740f, -0.01319454f, -0.04471826f, 0.03033223f, -0.03081045f, 
    -0.01117506f, -0.05471650f, 0.03901729f, -0.04798655f, -0.05848589f, 0.01559031f, -0.06551979f, -0.05474497f, 
    -0.05620063f, 0.02831864f, 0.04602421f, -0.05826932f, -0.03858851f, -0.01945636f, 0.04034046f, -0.02989156f, 
    -0.02455097f, -0.07768660f, 0.00837711f, 0.05198996f, -0.02789895f, 0.01600997f, -0.04270405f, -0.00837116f, 
    0.00149697f, -0.05689938f, -0.04140373f, 0.05008466f, 0.00403796f, -0.04386617f, -0.05499048f, -0.03353417f, 
    -0.02467731f, 0.05305883f, -0.00280011f, -0.05752599f, -0.05585909f, 0.04700764f, -0.00222766f, 0.00570543f, 
    -0.02537863f, -0.02127068f, -0.02529226f, 0.03106922f, 0.05602314f, 0.05253018f, 0.06289512f, -0.07162189f, 
    -0.02238638f, 0.00869270f, -0.03317029f, -0.02151665f, -0.04897209f, -0.03793992f, -0.07711769f, 0.04325100f, 
    -0.07474993f, 0.00984502f, 0.04681765f, -0.00834258f, 0.03050160f, 0.00144706f, -0.00378422f, 0.00024208f, 
    0.05064675f, -0.06943557f, 0.02391667f, 0.01912120f, 0.04508865f, -0.01417363f, -0.03457716f, -0.03025940f, 
    -0.02293245f, 0.05484940f, -0.01134146f, 0.06286589f, 0.04216941f, -0.02012109f, -0.01491788f, 0.03391463f, 
    0.23068632f, -0.11373229f, 0.11388301f, 0.22375600f, -0.01464211f, -0.00919142f, 0.08429729f, 0.02063680f, 
    0.12750144f, 0.09574644f, 0.23823790f, -0.08905733f, 0.38618907f, -0.24311076f, -0.02933112f, -0.16196662f, 
    -0.05603245f, -0.17355344f, 0.10539417f, -0.15632735f, 0.19423191f, -0.09371123f, 0.13233379f, 0.22400749f, 
    0.29945591f, -0.09473742f, -0.09301932f, -0.14058892f, -0.11139265f, 0.07361976f, -0.09248284f, 0.14014879f, 
    0.12277643f, 0.05593199f, -0.18018577f, 0.02107493f, -0.17054988f, 0.27500317f, -0.38678858f, 0.17265272f, 
    0.07498032f, -0.05814358f, 0.01603827f, -0.11469635f, 0.04184325f, 0.09980793f, -0.09694084f, 0.04859523f, 
    0.29831117f, -0.19590034f, -0.00433196f, -0.14208707f, 0.21690497f, 0.00849124f, 0.31717527f, -0.04122047f, 
    0.14112982f, 0.03422100f, -0.07604001f, -0.06452300f, -0.32012591f, -0.09153467f, 0.10714352f, 0.00689019f, 
    -0.16098471f, 0.14611219f, -0.23287536f, 0.16419423f, 0.03081913f, 0.14220843f, 0.21831444f, 0.10428737f, 
    0.26307553f, 0.21690241f, 0.19952720f, 0.08701820f, 0.04385430f, 0.21681300f, 0.11447179f, 0.03032777f, 
    0.09655586f, -0.29701138f, 0.10817904f, -0.20372297f, -0.08896247f, 0.34251624f, 0.09151254f, 0.09523793f, 
    -0.08622736f, -0.18725453f, 0.13049808f, 0.06126790f, 0.00373788f, -0.11634639f, -0.10819157f, -0.01322007f, 
    -0.49111742f, 0.50890547f, -0.34630737f, 0.18971400f, -0.23031598f, -0.23253056f, 0.07527944f, 0.14986777f, 
    -0.04891509f, -0.12526537f, -0.06622921f, -0.03090576f, 0.23980369f, -0.23015270f, 0.18658909f, -0.28899193f, 
    0.18661337f, 0.26779878f, -0.00520117f, 0.16291927f, -0.12549283f, -0.14083451f, 0.00575188f, -0.02319143f, 
    -0.35503864f, -0.04231885f, 0.14122069f, 0.11334819f, -0.08194719f, -0.12569550f, 0.05907050f, 0.12592770f, 
    -0.06779362f, 0.05303528f, 0.06705593f, -0.08462773f, -0.12247340f, -0.15119721f, -0.17067589f, 0.16325770f, 
    0.15387197f, 0.25613436f, 0.10429926f, 0.00390479f, -0.05435606f, -0.03085324f, -0.18236859f, -0.06863258f, 
    0.20047316f, 0.15395778f, 0.17991985f, 0.09269146f, 0.26881224f, 0.07785679f, -0.05027363f, 0.06149043f, 
    -0.21826938f, -0.13479215f, 0.00287061f, -0.05320065f, 0.10718399f, -0.03724216f, 0.20589043f, 0.26906776f, 
    -0.04556881f, -0.03765894f, -0.09146076f, 0.25630912f, 0.00506839f, 0.01148749f, -0.06570493f, -0.01185478f, 
    -0.10336400f, 0.12914437f, 0.10183926f, -0.03758207f, -0.10347230f, -0.42276594f, 0.08405562f, 0.17221342f, 
    0.09625603f, -0.10365079f, 0.04085686f, 0.03236355f, -0.22183041f, 0.13053834f, 0.28549379f, 0.21822530f, 
    -0.16555622f, -0.01742686f, -0.17195435f, 0.04796833f, -0.07441426f, 0.06862418f, -0.26322120f, 0.00145004f, 
    0.06827382f, 0.10952221f, 0.16269934f, 0.10065372f, 0.12002507f, 0.00449410f, 0.10875586f, 0.18401910f, 
    -0.13580076f, -0.02106205f, -0.00997113f, -0.09928952f, -0.37543911f, 0.08588297f, -0.31145552f, 0.01585849f, 
    0.02791030f, 0.03442680f, 0.22507870f, -0.11875914f, -0.10051925f, -0.27462703f, -0.01653252f, -0.40433541f, 
    -0.02079427f, 0.24239430f, -0.19781120f, 0.03369130f, -0.34611437f, -0.02723855f, -0.25066608f, -0.11197941f, 
    0.13465175f, 0.01220667f, -0.07102622f, -0.00585263f, -0.07266995f, -0.18680827f, 0.12158770f, 0.11472739f, 
    0.06631690f, -0.00121344f, -0.12129939f, 0.09372762f, -0.09179939f, -0.06411423f, 0.00762082f, -0.01578891f, 
    0.11693099f, -0.00576665f, -0.33002317f, 0.33433270f, 0.06789457f, 0.03543831f, 0.27378413f, 0.12062435f, 
    0.00368059f, 0.13598084f, -0.21239860f, 0.02393363f, 0.20077045f, 0.19098429f, -0.07860862f, -0.12416565f, 
    -0.00940699f, 0.20586263f, 0.04523058f, 0.02093454f, -0.08072631f, -0.13055491f, -0.12327666f, -0.02514469f, 
    -0.26836985f, -0.02744403f, -0.03319934f, -0.15674226f, -0.05070042f, 0.10989672f, 0.10415017f, -0.14460979f, 
    0.18372960f, 0.00839524f, 0.33036938f, 0.29383370f, 0.19450293f, -0.00661513f, 0.17914908f, -0.32365412f, 
    0.07123037f, -0.03840893f, -0.04129193f, 0.02128562f, 0.04687140f, -0.02193771f, -0.04686396f, 0.00495339f, 
    -0.36256453f, -0.03522440f, 0.24931249f, -0.15615596f, -0.16081002f, 0.24126211f, -0.10361646f, 0.21734363f, 
    0.09050737f, 0.18194124f, 0.19361278f, -0.00333647f, -0.29723588f, -0.32686561f, -0.04087603f, 0.10536022f, 
    -0.05518776f, 0.05709802f, -0.00677978f, 0.11004353f, 0.13613597f, 0.02258075f, 0.19563268f, 0.23194924f, 
    -0.05602167f, 0.12462160f, -0.08493384f, -0.10828912f, 0.22412933f, 0.16836685f, 0.15507734f, 0.11938711f, 
    -0.09341096f, -0.16434863f, 0.06437766f, -0.05546440f, -0.08489002f, -0.09005698f, -0.04087710f, 0.08914123f, 
    0.04572402f, 0.33257529f, 0.13086714f, 0.20144273f, 0.17564389f, -0.21430276f, 0.09905741f, 0.22203535f, 
    -0.35801515f, -0.58744520f, 0.02642763f, -0.18269475f, 0.15525576f, 0.46543333f, -0.11099619f, -0.05186569f, 
    -0.19183972f, 0.05965402f, 0.12342701f, -0.16743745f, 0.49141082f, 0.03745229f, -0.21749689f, 0.13668315f, 
    -0.05925539f, 0.04426859f, -0.03439194f, 0.08822184f, 0.19703995f, 0.08058263f, 0.00112183f, 0.02559850f, 
    -0.38354170f, -0.07201446f, -0.18347444f, -0.17407519f, 0.08114386f, 0.00749595f, -0.07146087f, 0.19780047f, 
    -0.09226498f, 0.05097430f, -0.11450209f, -0.20335308f, 0.03461394f, 0.33642873f, -0.14256857f, -0.25618708f, 
    0.18113708f, 0.06647433f, 0.18062747f, 0.03085186f, 0.05289908f, 0.02678421f, -0.19695273f, 0.18086578f, 
    -0.06606009f, -0.00022071f, -0.04461413f, -0.06134504f, 0.00986118f, -0.02273951f, 0.05538463f, -0.06091969f, 
    -0.03141022f, 0.04844736f, -0.03452127f, 0.01087288f, -0.08841864f, -0.09120616f, -0.00284271f, -0.00127781f, 
    -0.05775218f, -0.05041551f, -0.02754374f, -0.03889298f, -0.05958106f, 0.05159822f, 0.00958977f, -0.06789363f, 
    -0.05791164f, 0.03022761f, 0.03293249f, -0.00519154f, -0.07549800f, -0.02550922f, -0.00573286f, 0.02595647f, 
    -0.00435369f, -0.06702287f, 0.05821837f, 0.00870755f, -0.07379018f, -0.01003566f, -0.05038898f, 0.02714442f, 
    -0.03082670f, 0.00166026f, 0.03829330f, -0.01226168f, -0.01942755f, -0.00116960f, -0.01200348f, -0.01781983f, 
    -0.07200582f, 0.03334793f, 0.01605641f, -0.00890925f, -0.00399775f, -0.08534081f, 0.04397834f, 0.01419626f, 
    -0.03988222f, -0.03185674f, -0.03317478f, 0.02116392f, -0.10736914f, 0.01035931f, -0.09470477f, 0.05702876f, 
    -0.09182849f, -0.07542487f, 0.02184016f, -0.05964006f, -0.01737101f, -0.05665589f, -0.02844613f, -0.05266808f, 
    -0.06427272f, -0.05372128f, -0.00248606f, -0.02246304f, 0.06624770f, -0.05814906f, 0.01857371f, 0.03189477f, 
    0.01629885f, -0.02855740f, -0.02704298f, -0.00519651f, -0.07003465f, -0.02248739f, 0.04672233f, 0.03895648f, 
    0.00220311f, -0.03588230f, 0.01300938f, -0.06507525f, -0.07903768f, 0.02315000f, -0.04083063f, -0.00685177f, 
    -0.05450739f, -0.03167697f, -0.06145710f, 0.05543387f, 0.05350490f, -0.07378788f, 0.01777491f, -0.02274997f, 
    0.04855455f, 0.06054495f, -0.04892424f, -0.03830341f, -0.04568651f, -0.05184713f, -0.09025577f, 0.02687551f, 
    0.06941582f, -0.07127924f, 0.02493507f, -0.08103555f, 0.02741743f, 0.04532750f, 0.04660052f, -0.01348497f, 
    -0.08672041f, 0.06192258f, 0.06812120f, 0.00844577f, -0.10419150f, 0.03080224f, -0.02205905f, 0.01424924f, 
    -0.05447002f, -0.03179085f, -0.05413272f, -0.09830552f, 0.03222039f, -0.04378827f, -0.05273543f, -0.03442550f, 
    0.00042451f, -0.02202474f, 0.01026389f, -0.04456997f, -0.06338408f, -0.06992660f, 0.00116557f, -0.07458233f, 
    -0.04167810f, 0.03976363f, 0.00496931f, 0.00493503f, 0.02988984f, 0.02120445f, -0.01085767f, 0.10697711f, 
    0.02004858f, -0.03339175f, -0.00341470f, 0.04103952f, -0.00907208f, 0.02532665f, -0.01125141f, 0.05390964f, 
    0.03364968f, -0.00928943f, 0.00438150f, -0.08907037f, -0.00241907f, 0.03715874f, -0.02320688f, 0.02702735f, 
    0.02453690f, 0.05301114f, -0.04771909f, -0.00248826f, -0.08793484f, 0.02079690f, -0.02095722f, 0.05817574f, 
    0.04792073f, 0.05525325f, -0.07882217f, -0.04146238f, -0.05787194f, -0.01650512f, -0.05009029f, -0.07746232f, 
    0.00332123f, 0.05876146f, 0.01460708f, -0.03819869f, -0.06910157f, 0.02095164f, 0.01731781f, -0.09731895f, 
    -0.29450315f, 0.03216802f, 0.24750757f, 0.03572083f, -0.04723521f, 0.08431976f, 0.09984525f, 0.10832471f, 
    0.05047252f, 0.03652402f, -0.08972583f, 0.07043865f, 0.32383415f, 0.12268117f, 0.03823952f, 0.22570705f, 
    -0.06289157f, 0.05767214f, 0.08522368f, -0.01786049f, 0.26520011f, 0.06791062f, 0.00827034f, 0.07876913f, 
    -0.19813326f, -0.21057132f, 0.01132344f, 0.20621447f, -0.14507000f, -0.08263656f, -0.12776802f, 0.03955235f, 
    0.08351056f, 0.06638380f, -0.02475304f, -0.03738740f, -0.00626639f, 0.03597337f, 0.02617916f, -0.45843154f, 
    -0.23252836f, 0.01639831f, -0.12173367f, -0.25638145f, 0.07480878f, -0.03693895f, -0.27068892f, -0.16480660f, 
    -0.31372774f, 0.10868382f, 0.31817225f, 0.30043948f, 0.13489398f, -0.08373649f, -0.26718000f, 0.08906700f, 
    0.16358207f, -0.07056222f, 0.03081984f, -0.04654487f, -0.23266892f, 0.10801919f, -0.37868938f, 0.09538165f, 
    -0.02639518f, -0.06340975f, 0.18461804f, 0.05019008f, 0.03782601f, 0.16403836f, -0.09157301f, -0.03371669f, 
    -0.10685208f, 0.04934898f, 0.03152158f, -0.17185783f, -0.07910196f, -0.33137277f, -0.19481750f, -0.16681072f, 
    -0.22229192f, 0.15923998f, -0.01322235f, -0.02743962f, 0.27736056f, -0.20779838f, 0.18231714f, 0.34945083f, 
    -0.01595313f, 0.14157239f, 0.14891037f, 0.20461647f, 0.04032995f, -0.09290481f, -0.16529973f, 0.03368543f, 
    0.63299137f, 0.01494471f, -0.27310035f, -0.40416792f, 0.09146698f, 0.13593595f, 0.07339138f, -0.13321221f, 
    0.01712670f, 0.06154264f, -0.02492158f, 0.20422390f, -0.13653414f, 0.16392817f, 0.32574806f, -0.14612111f, 
    -0.05831680f, -0.16614474f, -0.08880681f, -0.01866719f, -0.06925161f, -0.00993645f, 0.16420308f, -0.07892113f, 
    0.18159905f, -0.27026457f, 0.03900197f, 0.21095173f, 0.01676781f, 0.02875417f, 0.02533183f, 0.04939831f, 
    0.00627187f, 0.09638808f, 0.14299667f, -0.00606070f, -0.09268028f, 0.18078922f, 0.04053207f, 0.17596039f, 
    0.12962203f, 0.02435098f, -0.02311299f, 0.09768387f, -0.01826030f, 0.10118191f, -0.09614670f, -0.10913321f, 
    0.04385053f, 0.32615650f, 0.19533503f, 0.09675898f, -0.00924768f, -0.00636232f, -0.05016284f, 0.07782606f, 
    -0.23130779f, 0.07996119f, -0.03890472f, 0.10018948f, -0.40187049f, 0.00455686f, 0.13742040f, 0.48328459f, 
    -0.01354263f, 0.00810804f, 0.11382654f, 0.03393282f, -0.05101390f, 0.07461164f, 0.08129876f, 0.12615187f, 
    1.01530242f, -0.27994347f, 0.02290628f, 0.21059899f, 0.15705252f, -0.00668614f, 0.14827316f, 0.14460194f, 
    -0.15526769f, 0.02999674f, -0.14292613f, 0.17111431f, 0.01041946f, 0.11635982f, -0.42479324f, 0.23644066f, 
    0.04245453f, 0.25548622f, -0.11492413f, 0.31517729f, -0.03668407f, 0.13374095f, 0.11011665f, -0.06396961f, 
    0.25884640f, -0.21644050f, -0.18445043f, -0.38298887f, 0.16319317f, 0.21238354f, -0.17471635f, 0.01588633f, 
    0.00781842f, -0.13549672f, 0.07732954f, 0.05280277f, 0.02564637f, -0.14442822f, -0.08476222f, 0.02206013f, 
    0.02598865f, -0.11704254f, -0.00284035f, 0.06353104f, -0.12678978f, 0.31360805f, 0.17901376f, -0.16730365f, 
    -0.15767685f, 0.12028106f, -0.00074279f, -0.43290097f, -0.06729037f, -0.06574380f, 0.00085067f, -0.09841042f, 
    -0.17180122f, 0.03488693f, -0.00052844f, 0.07159214f, -0.00959541f, 0.05825480f, 0.09488463f, 0.18343872f, 
    -0.10983233f, -0.08039864f, 0.00649140f, 0.18686678f, -0.05106857f, -0.06794968f, 0.21253365f, -0.05177497f, 
    0.30792752f, -0.12361526f, 0.10850120f, -0.16074547f, 0.01455306f, -0.18979038f, -0.13444464f, -0.08551460f, 
    -0.12260345f, -0.13435213f, 0.09850308f, 0.24611726f, -0.08990180f, 0.08103754f, -0.00083166f, 0.14346389f, 
    0.06395480f, 0.10687131f, -0.08231268f, 0.22461565f, 0.07683361f, -0.07234664f, -0.06523699f, -0.26802957f, 
    -0.04213421f, 0.07812603f, -0.04602747f, 0.06944343f, 0.08632807f, 0.09065951f, 0.19793306f, 0.02307130f, 
    -0.01630484f, 0.21249297f, -0.09267628f, 0.26224333f, -0.06453042f, -0.40742803f, 0.23487327f, -0.08432250f, 
    0.11083136f, -0.11720382f, -0.17173500f, -0.00704680f, 0.01913664f, -0.09881249f, 0.16793682f, 0.01358473f, 
    -0.38769937f, -0.15597972f, 0.27635935f, 0.12495589f, -0.03961140f, 0.06671107f, 0.05258861f, 0.19302034f, 
    -0.00232415f, 0.05385813f, -0.03279278f, -0.01257339f, -0.21453963f, -0.05560657f, -0.34500119f, 0.05431570f, 
    -0.08525709f, 0.09471989f, 0.10905661f, -0.01107776f, 0.03553609f, 0.14289500f, 0.08647346f, 0.14952038f, 
    0.15856373f, 0.02681406f, 0.25518203f, 0.18380983f, 0.22975752f, 0.11094303f, 0.03981326f, -0.03875041f, 
    -0.02960267f, 0.00569891f, -0.01454092f, 0.02182557f, -0.14719231f, -0.03075801f, -0.12295869f, 0.06390499f, 
    0.05607196f, 0.03152973f, 0.03966491f, 0.01798683f, 0.14744432f, 0.04208378f, 0.09817476f, 0.05087273f, 
    -0.39288852f, -0.04307245f, -0.39295742f, 0.00781805f, -0.18360645f, 0.03933024f, 0.05827695f, -0.37387607f, 
    -0.01592443f, -0.04292510f, 0.02150914f, 0.04659721f, 0.42712572f, 0.53667212f, 0.16030054f, -0.23751497f, 
    0.08116409f, -0.06469262f, 0.08770952f, -0.16472417f, 0.33069640f, 0.01777736f, 0.08083067f, -0.00908547f, 
    -0.15148818f, 0.33324784f, 0.04762044f, 0.00666205f, -0.09071957f, 0.13095537f, -0.29837990f, -0.06898474f, 
    0.02141310f, 0.21088423f, -0.00578743f, -0.00529437f, -0.35137561f, -0.23870687f, -0.00517056f, -0.17520081f, 
    0.21300045f, 0.03551514f, 0.09657271f, -0.16569135f, -0.00737823f, 0.00048318f, 0.14529917f, 0.02887797f, 
    -0.12531027f, -0.11806947f, -0.06925341f, 0.20375322f, -0.07525289f, -0.09399910f, 0.13487701f, -0.05322184f, 
    0.10983344f, 0.21076901f, 0.10553841f, 0.02887749f, 0.45442507f, -0.29287943f, 0.02787481f, -0.24615191f, 
    -0.13211776f, 0.03149325f, 0.04230336f, 0.11124799f, 0.35577312f, 0.25279650f, 0.16418153f, 0.29697663f, 
    -0.13580786f, -0.16011487f, 0.08196826f, -0.14937332f, -0.11686374f, -0.11255576f, 0.00630780f, -0.07173481f, 
    -0.08980323f, -0.01995235f, 0.27548441f, -0.03641164f, -0.03057800f, 0.05114997f, -0.10695584f, -0.25946724f, 
    -0.04159670f, -0.06983205f, -0.10680303f, -0.22013050f, 0.05728751f, 0.09735017f, 0.00121665f, 0.04279997f, 
    -0.06020647f, 0.16095307f, 0.30051506f, -0.08615209f, 0.13801813f, 0.09660291f, -0.23997484f, -0.17442457f, 
    0.25415567f, -0.15993622f, 0.21454114f, 0.02339820f, -0.25622857f, -0.00217031f, 0.16645108f, 0.07796767f, 
    -0.06203834f, -0.07803790f, -0.04444900f, 0.14130840f, 0.04817857f, 0.05718215f, 0.17691697f, 0.14349003f, 
    0.16478401f, -0.09940711f, -0.12635860f, 0.06309298f, 0.09582012f, -0.11065147f, 0.05354394f, 0.01857174f, 
    -0.26531619f, -0.18538442f, -0.26008648f, -0.27146649f, 0.02348053f, 0.10710198f, 0.07592721f, 0.28598684f, 
    0.00204638f, 0.05339037f, 0.19696052f, 0.10219495f, 0.05718381f, -0.09114911f, -0.26462835f, -0.07074429f, 
    0.03396951f, -0.04118789f, -0.00238155f, 0.07857474f, 0.10277901f, -0.12153251f, -0.06800972f, -0.05418476f, 
    -0.05644793f, 0.01883565f, -0.01346601f, 0.08065730f, 0.11399984f, 0.07067567f, 0.23801686f, -0.07353287f, 
    0.13017306f, 0.11252844f, 0.01731134f, -0.11712416f, -0.32566252f, -0.26640362f, -0.22633767f, -0.25639012f, 
    -0.21977003f, -0.28146297f, 0.17233048f, 0.22738731f, 0.03128502f, -0.18933500f, 0.01007899f, 0.01623661f, 
    -0.13450582f, 0.10365325f, -0.03455395f, 0.12828900f, 0.05312899f, -0.06075225f, 0.14619945f, 0.27064329f, 
    0.09539856f, -0.19154534f, -0.02366635f, -0.00789625f, -0.19163339f, 0.17500789f, -0.09756914f, -0.01560181f, 
    0.37416044f, 0.07241004f, -0.11833403f, 0.35892415f, 0.20094326f, -0.19257437f, -0.01460654f, 0.12726338f, 
    0.08875001f, -0.04733610f, -0.11925966f, 0.00979493f, -0.65323824f, 0.29681277f, 0.35288867f, 0.09077796f, 
    0.13823763f, 0.16827339f, -0.09009307f, 0.08547124f, -0.11913291f, 0.13914689f, 0.12147789f, 0.01645204f, 
    0.40643606f, -0.06741742f, 0.25605363f, 0.21860400f, 0.05607396f, -0.17131302f, 0.07812526f, -0.00859938f, 
    0.11217219f, -0.04617611f, 0.04597133f, 0.27056786f, -0.16161887f, -0.18660398f, 0.10125531f, 0.27440903f, 
    0.09626595f, 0.12951966f, -0.18765734f, -0.01672117f, -0.00325186f, -0.27274594f, -0.05811041f, -0.23264600f, 
    -0.18424365f, 0.02158001f, 0.04463262f, 0.15575635f, 0.00001997f, -0.01352108f, 0.25148645f, 0.09026469f, 
    0.23719855f, 0.20345633f, -0.06395962f, 0.13755032f, -0.01947077f, -0.06489588f, 0.04406044f, 0.19717623f, 
    -0.07619236f, 0.18668707f, 0.21390083f, -0.02279483f, 0.19974545f, 0.21248503f, 0.07052872f, 0.28397629f, 
    0.02410569f, -0.08034880f, 0.07992425f, 0.18438374f, 0.09388287f, 0.00298540f, 0.06162805f, -0.03921876f, 
    -0.03625424f, 0.14300041f, 0.11252740f, 0.01640267f, 0.08334536f, -0.21302260f, 0.12694149f, -0.12921657f, 
    -0.16195565f, 0.31801787f, -0.19203147f, -0.16358237f, 0.04903683f, -0.03144127f, 0.02732953f, 0.03679567f, 
    -0.14326560f, 0.30409798f, 0.11997827f, 0.17468975f, -0.02204053f, 0.02044701f, -0.02026384f, 0.02453852f, 
    -0.04111663f, -0.24619214f, 0.11025786f, 0.08276426f, 0.14403826f, 0.06447111f, -0.01925998f, 0.17411463f, 
    0.15674275f, -0.00720675f, 0.21211079f, 0.06572635f, 0.07848437f, 0.02041944f, 0.11029823f, 0.16203590f, 
    0.07440036f, -0.19654697f, -0.05985187f, -0.39738312f, 0.20751351f, -0.34816653f, -0.27849382f, -0.14155108f, 
    -0.23517960f, -0.13826193f, -0.21117516f, -0.26403022f, 0.28670734f, 0.07743345f, 0.00036134f, 0.01128387f, 
    -0.08561070f, -0.06803118f, -0.05865500f, -0.06009530f, -0.07792098f, -0.11243150f, -0.18304260f, 0.00354109f, 
    0.54290593f, -0.05983195f, 0.36275184f, 0.08592000f, 0.05982931f, 0.08109240f, -0.17325370f, -0.21592741f, 
    0.15820402f, 0.12444645f, -0.04704386f, 0.07763184f, -0.10888182f, -0.11213268f, 0.07146835f, 0.05565080f, 
    0.05986362f, -0.16260427f, -0.12274802f, -0.27114826f, 0.07187057f, -0.27360383f, -0.14480838f, -0.28474489f, 
    0.27440265f, -0.19097105f, -0.15719967f, -0.20533171f, -0.01649473f, -0.10489874f, -0.02505977f, 0.10119499f, 
    0.10807738f, 0.17996421f, 0.08887195f, 0.20162210f, 0.20294024f, -0.03224261f, 0.15407176f, 0.10258973f, 
    -0.00398791f, 0.00686513f, -0.04206100f, 0.06553836f, -0.17024149f, -0.04471500f, -0.15843020f, -0.14125238f, 
    0.32398224f, -0.39686030f, -0.13773465f, -0.01382845f, -0.02590407f, -0.11609606f, 0.02777545f, 0.16943003f, 
    -0.14019787f, 0.03796429f, -0.39417630f, -0.04064029f, 0.03202866f, 0.01724081f, 0.04566184f, -0.08037852f, 
    -0.01204149f, 0.00582168f, 0.14900370f, -0.08541740f, -0.08712623f, 0.03712314f, 0.12764142f, -0.10655484f, 
    0.36849609f, -0.19256160f, 0.17870462f, 0.29777080f, -0.03857041f, 0.13501963f, -0.04405192f, -0.19488364f, 
    0.10973214f, 0.08389862f, -0.03176670f, 0.31306905f, 0.08348512f, -0.05419210f, -0.30209008f, -0.04284159f, 
    0.05931348f, 0.02626520f, -0.01593848f, 0.18823682f, -0.08542845f, -0.04780594f, -0.01680904f, -0.18371846f, 
    -0.33403555f, -0.11070416f, -0.11935690f, 0.18548378f, -0.05195078f, -0.19449474f, 0.24372868f, -0.00966589f, 
    0.01478012f, 0.09805354f, -0.04591427f, 0.01135499f, -0.01122001f, -0.15739964f, -0.06412683f, -0.18808429f, 
    -0.11164827f, 0.15810272f, 0.14591019f, 0.23193306f, 0.14099562f, 0.10718380f, -0.01459417f, -0.02941982f, 
    -0.42255130f, 0.05156264f, 0.20692378f, -0.01793241f, -0.18909803f, -0.21843976f, -0.09033679f, -0.08978011f, 
    -0.07087822f, 0.00978713f, 0.33694169f, 0.05761427f, 0.04287276f, -0.18382512f, 0.06076897f, -0.50032216f, 
    -0.06987447f, 0.08378565f, -0.05552559f, -0.00806168f, 0.01592990f, -0.07279150f, 0.15739106f, 0.13514318f, 
    -0.28059435f, 0.22761904f, 0.25137144f, 0.02916227f, 0.08470825f, 0.21848340f, -0.17572372f, -0.14041586f, 
    0.06182066f, -0.17929015f, 0.00601202f, 0.19248801f, 0.13548148f, 0.04814002f, -0.12007812f, -0.08606751f, 
    0.08820481f, -0.10186863f, 0.26105088f, -0.02379393f, -0.00261918f, -0.08726317f, 0.07001209f, -0.06814610f, 
    -0.00134980f, -0.30276260f, -0.23615806f, -0.08652945f, 0.16230431f, -0.29355022f, 0.03018656f, -0.00152334f, 
    -0.08907443f, 0.21426466f, 0.01720432f, 0.04922894f, 0.18583880f, -0.12839696f, -0.02105712f, 0.11429619f, 
    0.04302444f, 0.11557730f, 0.05470320f, 0.12854306f, 0.12424649f, 0.25419065f, -0.18217215f, -0.01849517f, 
    0.60103011f, -0.32335502f, 0.15952957f, -0.18173596f, 0.16759759f, 0.23278095f, -0.05067709f, 0.05412258f, 
    0.18393131f, 0.12522897f, 0.14381509f, 0.13370016f, -0.06235023f, 0.03301320f, 0.18894653f, -0.04978186f, 
    0.16956326f, -0.14129202f, -0.05964618f, -0.20916171f, -0.05987352f, -0.02027219f, 0.00113885f, 0.02789554f, 
    0.00015632f, -0.33772454f, -0.16256192f, -0.11153945f, 0.11731365f, 0.01312833f, 0.04619765f, 0.13834666f, 
    -0.19656427f, 0.02987254f, -0.07932334f, 0.10507052f, 0.34717309f, -0.01651479f, 0.21714687f, 0.06851191f, 
    -0.05280780f, -0.12130741f, 0.12323523f, -0.08859230f, -0.11663807f, 0.16085172f, 0.08532149f, -0.00631717f, 
    0.50113624f, -0.28139371f, 0.00452047f, 0.34264272f, 0.19754416f, 0.07326489f, 0.13539220f, 0.20088489f, 
    0.22469246f, 0.06336885f, -0.12987800f, -0.05976050f, -0.46928945f, 0.01421299f, 0.09204490f, -0.01431215f, 
    0.03245541f, 0.14905071f, 0.05482210f, 0.10221586f, 0.06321456f, 0.06606858f, 0.14801434f, 0.05010586f, 
    0.27553248f, -0.28371838f, 0.00931852f, 0.15469553f, 0.19272575f, 0.26534197f, 0.09479176f, 0.13865444f, 
    0.06619309f, 0.03548250f, 0.04729665f, 0.05311508f, 0.09331927f, -0.21149093f, -0.26600379f, 0.05372687f, 
    0.03025931f, 0.12837651f, -0.11628963f, -0.04155811f, 0.02454191f, -0.10735004f, 0.09243105f, -0.11006796f, 
    0.00413028f, 0.04430467f, -0.01446394f, -0.02867248f, -0.03655385f, -0.01070973f, 0.01161782f, -0.05614250f, 
    -0.04373390f, 0.05599286f, -0.03189103f, -0.07914834f, -0.07345887f, -0.07492565f, -0.06656760f, 0.00314690f, 
    -0.07763129f, -0.00621064f, 0.00581086f, 0.05413797f, -0.03317271f, -0.00258847f, 0.04589606f, -0.05585959f, 
    -0.00529227f, -0.01526773f, -0.02119798f, 0.01654213f, -0.01392583f, -0.01570524f, -0.01752638f, 0.02630962f, 
    -0.00381054f, 0.03255440f, 0.06609809f, 0.00197260f, -0.05580564f, -0.06977329f, -0.01220838f, -0.01192486f, 
    -0.07203811f, -0.06162561f, -0.02807775f, 0.01344875f, 0.03514372f, -0.05337328f, -0.00247410f, -0.07030968f, 
    -0.02516478f, -0.07966809f, -0.04714192f, -0.05281693f, -0.04892601f, 0.03699174f, 0.04941968f, -0.05183149f, 
    0.03403326f, -0.07606157f, -0.07382841f, -0.00869619f, 0.06290689f, 0.00630608f, 0.01962291f, 0.04852120f, 
    -0.06416398f, -0.02075971f, 0.02931875f, -0.07373355f, 0.02801656f, -0.00026981f, 0.04573922f, -0.02947632f, 
    -0.05181435f, -0.01328297f, -0.04706248f, -0.05236169f, -0.03567654f, -0.05891307f, 0.00723420f, 0.02159855f, 
    0.01657982f, -0.05135247f, 0.05482386f, -0.03005559f, 0.01002579f, -0.00518814f, 0.02062516f, -0.05744104f, 
    0.06027818f, -0.02743001f, 0.04817348f, -0.00026282f, 0.00944768f, 0.02187826f, 0.02974776f, 0.05879569f, 
    0.04287976f, 0.03355103f, 0.00549546f, -0.02187581f, 0.03084162f, -0.02895708f, -0.07092111f, 0.02094016f, 
    0.03344690f, -0.01860557f, -0.02496104f, -0.07164928f, 0.03598997f, 0.03901302f, -0.06003176f, -0.04284564f, 
    -0.01591709f, 0.03518829f, -0.07494087f, 0.05620473f, 0.03048116f, -0.06588863f, -0.05599267f, -0.00250195f, 
    -0.02244068f, -0.05101844f, -0.04282528f, -0.03321384f, 0.06385879f, -0.02012884f, 0.03263135f, 0.02509196f, 
    -0.04370853f, -0.00678691f, 0.02544221f, -0.05764485f, -0.01776773f, 0.00818101f, -0.02722079f, 0.05439380f, 
    -0.03359191f, 0.05258166f, -0.05315636f, 0.02222633f, -0.05333600f, -0.03853575f, 0.00275909f, -0.02260135f, 
    -0.01367931f, -0.01627630f, -0.03322487f, 0.04580053f, -0.04521224f, -0.04075416f, 0.03375495f, 0.00654740f, 
    -0.05621246f, 0.03907575f, -0.01569405f, 0.05161593f, 0.00661743f, 0.03228317f, -0.07689866f, 0.01204091f, 
    0.01934906f, 0.04303220f, -0.04855192f, -0.02067512f, 0.03465997f, -0.01938028f, -0.07511061f, -0.04774937f, 
    0.03126534f, -0.05422535f, -0.06489028f, -0.05212622f, -0.02103268f, -0.03530526f, -0.04481624f, 0.02900437f, 
    0.05377057f, -0.00477802f, 0.00518709f, -0.01970015f, -0.00163032f, 0.06606843f, -0.03185381f, 0.03991609f, 
    -0.01800096f, 0.01858720f, 0.01270994f, -0.06465486f, 0.01110651f, -0.07556627f, -0.05932491f, 0.06122262f, 
    -0.07833125f, -0.02127442f, 0.04368201f, -0.00364220f, -0.06307899f, 0.02604461f, -0.01182351f, 0.01703190f, 
    -0.03216134f, 0.05776095f, -0.01195246f, 0.00106091f, -0.06724267f, 0.02348129f, 0.04853785f, -0.02030747f, 
    0.05065176f, 0.03657779f, -0.02117692f, -0.01276008f, -0.02316122f, 0.01733269f, 0.01845995f, -0.06807833f, 
    -0.06198439f, -0.06382740f, 0.02149292f, 0.02430691f, -0.01693868f, -0.03068686f, -0.00577696f, -0.00574059f, 
    0.04300799f, -0.08133247f, -0.00610015f, -0.07151163f, 0.02764495f, -0.00127606f, -0.07742405f, 0.04994426f, 
    -0.03135808f, -0.01748217f, -0.06890855f, 0.02052363f, -0.00052008f, 0.02499950f, 0.00822816f, 0.02832522f, 
    0.03411965f, -0.03954754f, -0.01927781f, -0.07778122f, 0.02594895f, -0.05589514f, -0.00494318f, -0.01272850f, 
    -0.04741136f, -0.01838339f, -0.02325418f, -0.06708859f, 0.04441153f, -0.07070123f, 0.02129621f, -0.06348529f, 
    0.04639000f, -0.06417771f, -0.06879028f, -0.01864358f, 0.01060118f, -0.07104762f, -0.04394363f, 0.05185143f, 
    0.00606676f, 0.05303118f, -0.01727649f, -0.02021182f, -0.07756101f, -0.01744055f, -0.01815645f, -0.05464243f, 
    0.03641380f, 0.05290150f, 0.00377269f, -0.02943659f, 0.00676027f, 0.03092089f, -0.05919998f, -0.00424281f, 
    0.02152031f, 0.00837327f, -0.04421085f, -0.05505871f, -0.06756514f, 0.02915037f, 0.04668688f, 0.01955395f, 
    -0.05284367f, 0.00305397f, -0.02952630f, -0.07365981f, 0.02894256f, 0.02491840f, 0.04407008f, 0.00486203f, 
    0.05550035f, 0.01110248f, -0.00645085f, -0.00445504f, -0.05133297f, 0.04861063f, -0.03309304f, -0.01924052f, 
    0.03128938f, -0.06425869f, -0.05105186f, -0.08778363f, -0.06995365f, -0.07840317f, 0.01527916f, -0.03706550f, 
    -0.04783995f, -0.02731716f, -0.00727725f, -0.05948529f, 0.05308834f, -0.01765517f, -0.04984150f, -0.07353669f, 
    -0.03236812f, -0.07910868f, -0.07246420f, -0.01471117f, -0.04046370f, -0.04579351f, -0.00827865f, 0.00845871f, 
    -0.02595835f, -0.05011173f, 0.04859690f, 0.00535824f, 0.00934054f, -0.08118520f, -0.03568237f, 0.03437344f, 
    0.04495544f, -0.08861357f, -0.05659112f, -0.01660898f, -0.01584950f, 0.01643487f, 0.00395901f, -0.05707197f, 
    -0.00387188f, 0.04403828f, 0.03593620f, -0.02254588f, -0.03559457f, 0.00494111f, -0.00560771f, -0.04059841f, 
    0.01144488f, 0.03182865f, -0.07192559f, 0.03039780f, -0.05594271f, 0.04415386f, 0.05038298f, -0.00909122f, 
    -0.00564970f, 0.01242356f, -0.05544242f, 0.02544683f, -0.06531353f, 0.05545822f, -0.05378446f, -0.03741380f, 
    0.04380115f, -0.04175727f, 0.02673720f, 0.04115172f, 0.01451268f, 0.03709959f, 0.00690493f, -0.02435053f, 
    -0.05518454f, -0.01362696f, -0.07816807f, 0.04091900f, -0.07823239f, 0.03962948f, -0.00773030f, -0.00005575f, 
    0.12583512f, 0.13871056f, 0.08961910f, 0.03860899f, 0.22184432f, 0.30469573f, 0.16699767f, 0.23862495f, 
    0.09313400f, 0.02978500f, -0.03516557f, 0.19916384f, -0.14324647f, -0.12134932f, 0.17081062f, -0.12839477f, 
    -0.05031466f, 0.05933416f, -0.07965475f, 0.25877380f, -0.21834344f, -0.18834937f, -0.19070195f, -0.15955393f, 
    0.10657014f, 0.31730929f, 0.33812621f, 0.18143699f, -0.20123836f, -0.07882059f, -0.09173521f, -0.07576628f, 
    -0.07974546f, 0.15393449f, 0.05664635f, 0.10173961f, 0.12014415f, 0.33435532f, 0.09885015f, 0.15364648f, 
    -0.10740387f, -0.06544444f, -0.02673192f, 0.00221612f, 0.02608581f, 0.01236043f, 0.11740380f, 0.12123132f, 
    0.30015475f, 0.08696509f, 0.20493607f, -0.20940210f, 0.06796376f, -0.07326258f, -0.23279926f, 0.11964233f, 
    -0.14869884f, -0.14146826f, 0.12788345f, 0.20767359f, 0.16563833f, 0.06924794f, -0.13511428f, -0.07662416f, 
    0.08350861f, -0.09225830f, 0.10350573f, 0.09873301f, 0.25928241f, 0.14774337f, 0.06021092f, -0.02264955f, 
    -0.03283835f, -0.00019565f, 0.01783222f, 0.09782292f, 0.06235026f, 0.22906826f, 0.03449767f, -0.03788081f, 
    0.02044558f, -0.03701100f, -0.03902280f, 0.18268983f, -0.45825484f, -0.42572296f, -0.01923073f, -0.14151263f, 
    -0.07619253f, 0.03351821f, 0.04453206f, 0.21736288f, 0.00346943f, 0.12288875f, -0.10725699f, -0.13412812f, 
    -0.43169251f, -0.01279646f, -0.18730666f, -0.12351970f, -0.11549490f, 0.02146076f, 0.03491555f, 0.03508691f, 
    0.04407746f, -0.22785978f, 0.18935409f, 0.02664661f, 0.33072600f, 0.23020200f, -0.13670692f, 0.06329439f, 
    -0.02833103f, -0.09723382f, -0.05225454f, -0.03709110f, -0.11993859f, -0.04829827f, 0.00001068f, 0.12952572f, 
    0.06002410f, 0.22540583f, -0.00937175f, 0.04899361f, 0.23697692f, -0.00348652f, -0.05291593f, -0.02701679f, 
    -0.09537636f, 0.02787929f, -0.03475022f, 0.07391050f, 0.31371710f, 0.30135500f, 0.10766045f, 0.08215206f, 
    0.20184661f, 0.15912071f, 0.16255848f, 0.02186860f, 0.11233453f, 0.24933997f, 0.14891170f, 0.02965480f, 
    -0.08432334f, 0.09023757f, -0.10501185f, -0.09058211f, 0.14689611f, 0.08370836f, 0.10967782f, -0.03103288f, 
    -0.07640303f, -0.06613605f, -0.11484687f, -0.20814502f, 0.37363285f, -0.07572783f, 0.04480744f, -0.05528514f, 
    -0.06727670f, 0.18125919f, 0.12476506f, 0.10479017f, 0.30208597f, 0.12133009f, 0.12220690f, 0.10400462f, 
    -0.35842088f, -0.04014631f, -0.15277714f, -0.22652504f, -0.06021352f, 0.15747583f, -0.03251599f, -0.07064251f, 
    -0.11934599f, 0.03143868f, -0.02787076f, -0.21369855f, -0.06410616f, -0.08945990f, -0.12771878f, -0.01983254f, 
    0.00309950f, 0.00510166f, 0.18561111f, -0.16222040f, 0.00028296f, -0.10493663f, 0.04131075f, 0.02925291f, 
    -0.02434660f, 0.37074772f, 0.23973420f, -0.00805714f, 0.35418841f, 0.03390158f, -0.21840701f, 0.07284664f, 
    0.06801634f, -0.02613257f, -0.03634920f, 0.18432513f, -0.28722513f, 0.02133585f, -0.10842738f, 0.22539783f, 
    0.00112163f, -0.02390687f, -0.27013266f, -0.23556210f, 0.01807110f, 0.03800746f, 0.04862057f, 0.02565363f, 
    -0.18540458f, -0.21530928f, -0.35309049f, 0.09241889f, 0.08156769f, -0.22899428f, -0.11363393f, -0.14423905f, 
    0.05808003f, -0.06856219f, -0.01119638f, -0.01304765f, -0.15403239f, -0.26519030f, 0.05189343f, 0.13417800f, 
    -0.14737152f, -0.32007682f, -0.14650640f, -0.07191182f, -0.05984525f, -0.10171758f, 0.07007144f, 0.03509621f, 
    -0.22610773f, -0.00406367f, -0.27468887f, 0.12868857f, 0.03695887f, -0.23197077f, 0.11571348f, 0.20617658f, 
    -0.00753371f, -0.07475678f, -0.01673577f, -0.18336985f, 0.28326142f, 0.09588046f, 0.15553947f, 0.13253428f, 
    0.11544166f, 0.17868140f, 0.07242613f, -0.00345261f, 0.08708899f, 0.01457172f, -0.08217049f, -0.03917011f, 
    -0.18412271f, -0.19226882f, 0.11655957f, -0.24535197f, -0.03691419f, 0.20194301f, 0.17626017f, -0.08571430f, 
    -0.02384167f, 0.14665945f, 0.04727207f, -0.00601507f, 0.34265357f, 0.03841244f, 0.08396138f, 0.10501333f, 
    -0.02992281f, 0.12586138f, -0.02343807f, 0.23194683f, 0.10580745f, -0.00649604f, 0.08121626f, 0.13348033f, 
    0.17414832f, 0.05279441f, 0.45153126f, 0.21816838f, 0.10604315f, -0.05172242f, -0.00391888f, -0.11444183f, 
    0.10217753f, 0.04015200f, -0.02733991f, 0.06012743f, -0.49459118f, -0.22420339f, -0.13502723f, 0.14156036f, 
    -0.02769977f, 0.06114590f, -0.06310068f, -0.11961731f, -0.02485108f, -0.02306475f, -0.04847597f, -0.19046801f, 
    0.33073837f, 0.38489541f, 0.10891124f, 0.19547099f, 0.08317218f, 0.34037405f, 0.01302826f, 0.09842196f, 
    0.02938498f, -0.04951874f, -0.02238032f, 0.04488432f, -0.12448095f, 0.22949785f, 0.16538301f, -0.09649333f, 
    0.10418327f, 0.01150151f, 0.10561834f, 0.04749675f, 0.09889030f, -0.18930432f, 0.17512201f, 0.08053043f, 
    -0.92784107f, 0.15941200f, 0.02911480f, -0.16297309f, -0.05367291f, -0.07168916f, -0.12610470f, -0.12041301f, 
    0.11749754f, 0.12121325f, 0.10216434f, 0.06590472f, 0.35105255f, -0.00410641f, -0.06938063f, -0.00597743f, 
    -0.20934881f, -0.05727004f, -0.02052667f, -0.06006453f, -0.03367307f, 0.06547566f, -0.04713341f, -0.06755371f, 
    0.01943528f, 0.36053228f, -0.11569747f, 0.05868028f, 0.04652546f, 0.04572993f, -0.04496358f, 0.03120365f, 
    -0.13433234f, -0.03593609f, 0.07137459f, -0.02905391f, 0.19228177f, 0.31294915f, 0.09687228f, -0.16969943f, 
    0.14007972f, 0.24322256f, 0.44776988f, 0.35339221f, -0.05096755f, 0.00250649f, 0.08646459f, -0.13167767f, 
    -0.13365550f, -0.05822031f, 0.01187463f, -0.02704609f, 0.08517899f, 0.17580007f, 0.14914504f, 0.14055803f, 
    0.01376072f, -0.07003641f, -0.09106252f, 0.22853453f, 0.01236922f, -0.10268851f, 0.10158081f, -0.34078419f, 
    -0.12202692f, 0.03328868f, -0.25042856f, 0.20255113f, 0.09460863f, 0.32750982f, 0.02369183f, 0.12719651f, 
    0.00865297f, -0.18947457f, 0.30599314f, 0.05739783f, -0.25540903f, -0.16741508f, -0.01563127f, -0.05567857f, 
    -0.07628644f, -0.08168013f, 0.32124409f, 0.01653274f, -0.06858196f, 0.42983785f, -0.26407620f, -0.01740571f, 
    -0.15168546f, -0.12134141f, -0.10511044f, -0.25071409f, 0.14848787f, 0.00497442f, 0.06656770f, 0.08676723f, 
    0.05773312f, -0.04095475f, 0.54881388f, -0.17591797f, -0.15758428f, 0.12517026f, -0.17836002f, -0.08678686f, 
    -0.12214843f, -0.11620823f, 0.25422156f, 0.26321507f, -0.01897944f, 0.24112396f, -0.10335236f, 0.24390021f, 
    0.31060064f, -0.01823178f, 0.16480148f, 0.18293011f, 0.11236407f, 0.22413900f, 0.00069279f, -0.05988713f, 
    0.13213725f, -0.04291292f, -0.21683544f, 0.36131233f, 0.09482145f, 0.15835248f, -0.00817160f, 0.19268928f, 
    0.03351929f, 0.20393555f, 0.01107847f, 0.02884719f, -0.28152612f, -0.23530973f, 0.23802136f, 0.26660421f, 
    0.01555786f, -0.01030778f, 0.24000233f, 0.20375469f, -0.09428447f, 0.15858962f, -0.00204860f, 0.08106326f, 
    -0.38894242f, 0.07693981f, -0.17323445f, 0.05285330f, 0.36894563f, -0.22584265f, 0.22037670f, -0.23415229f, 
    0.13675345f, -0.03644971f, 0.08938999f, 0.24299644f, 0.31385747f, 0.45116267f, 0.14646506f, -0.03831547f, 
    -0.07874881f, -0.11865783f, -0.14935455f, -0.21913835f, -0.10414931f, 0.08144869f, 0.04821254f, 0.00376535f, 
    0.19253016f, 0.28237763f, 0.16575579f, 0.28785977f, 0.22918060f, 0.19853944f, 0.03529681f, -0.13804775f, 
    -0.16594371f, -0.01071399f, -0.12708434f, -0.02130660f, 0.28651318f, 0.42694190f, 0.23933440f, 0.32643503f, 
    0.24478619f, -0.09879199f, 0.16497846f, 0.14475775f, 0.20821859f, 0.15523547f, 0.29825372f, -0.05255014f, 
    -0.08801156f, 0.38887328f, -0.20214623f, -0.00886070f, -0.07015891f, -0.20297740f, 0.19203590f, 0.17549220f, 
    0.22244655f, -0.08698669f, -0.16099206f, -0.18253189f, -0.50653774f, 0.46903187f, 0.16969381f, 0.42903507f, 
    0.04328256f, 0.24910212f, 0.08153515f, 0.00213015f, -0.03307343f, 0.27969012f, 0.13487647f, 0.19159861f, 
    0.55943662f, 0.04002916f, 0.15136160f, 0.16041458f, 0.08616582f, 0.08486303f, -0.03386932f, -0.33588833f, 
    -0.11894292f, 0.00826668f, 0.04557363f, 0.11639286f, 0.04135466f, -0.03812033f, 0.01713167f, 0.08744711f, 
    0.11736517f, 0.10632437f, 0.15014011f, -0.14509608f, -0.10838574f, -0.31114328f, 0.03801971f, -0.14254403f, 
    0.02336723f, 0.02456930f, -0.04522814f, 0.42017376f, 0.20394713f, 0.02590526f, 0.26008585f, 0.17742084f, 
    0.17545444f, 0.24080840f, 0.01927988f, 0.08334734f, -0.15822470f, 0.00675402f, -0.11425479f, -0.10002274f, 
    0.06793065f, 0.10481138f, 0.15166618f, 0.12228475f, 0.15845513f, -0.15584193f, 0.01734715f, -0.16266045f, 
    0.34246409f, 0.47960496f, 0.29271150f, 0.11143346f, -0.12578690f, -0.02542759f, -0.03189161f, -0.14472611f, 
    -0.03716633f, -0.03475468f, 0.10657778f, 0.05163251f, 0.12033080f, -0.06065537f, 0.06680376f, 0.02709817f, 
    -0.06841861f, 0.07225115f, -0.13567001f, -0.01676706f, -0.09343181f, -0.02793769f, 0.02620868f, 0.03730616f, 
    0.20461793f, 0.30833325f, -0.30766690f, 0.04684214f, 0.03540703f, 0.13076907f, 0.01683588f, 0.02501624f, 
    0.04596283f, 0.00706086f, 0.04076772f, 0.04727854f, 0.23872420f, 0.07010935f, 0.29140148f, -0.28907433f, 
    -0.06178354f, 0.04069003f, 0.20362569f, 0.09496334f, 0.17274193f, -0.07948285f, 0.09737238f, 0.14215186f, 
    0.03136362f, -0.18161245f, -0.15055475f, 0.03680279f, 0.10301997f, -0.06917710f, 0.02920482f, -0.13601948f, 
    0.07330924f, -0.13823220f, -0.08944441f, -0.00111929f, -0.13699500f, 0.17443827f, -0.04549750f, -0.21613073f, 
    0.11363641f, 0.09055989f, -0.00254068f, -0.01101840f, 0.22299622f, 0.16988580f, -0.15527156f, -0.17977278f, 
    -0.18631519f, -0.40128770f, 0.30984831f, 0.09292912f, -0.14782539f, 0.15093490f, -0.09659106f, 0.14499186f, 
    0.12389597f, -0.01690277f, 0.13224778f, -0.03395562f, 0.35946137f, 0.02383783f, 0.07505893f, 0.09861846f, 
    0.05179674f, 0.01446279f, -0.02607649f, -0.02431590f, -0.05880726f, -0.09728430f, -0.02967810f, 0.02529725f, 
    -0.42997864f, -0.11914325f, -0.21267000f, -0.44624606f, 0.04290741f, -0.02093339f, 0.04767616f, 0.34531218f, 
    -0.08513007f, 0.03207428f, -0.03886396f, 0.12550797f, 0.30060405f, -0.16267174f, 0.33969286f, -0.00798210f, 
    0.09509706f, 0.19832222f, 0.13659273f, -0.02587176f, -0.01600322f, 0.06226931f, 0.08277480f, 0.10764378f, 
    0.11746348f, -0.48944369f, -0.12407965f, -0.07157321f, 0.36244684f, 0.29513717f, 0.02957542f, 0.11205508f, 
    -0.00242126f, 0.05108555f, 0.02049330f, -0.06592731f, 0.15001284f, -0.13660297f, -0.04946975f, -0.38670072f, 
    0.17103732f, 0.22441949f, -0.04259809f, 0.16510734f, 0.17295848f, 0.07562455f, 0.18877541f, -0.08306115f, 
    -0.84589815f, -0.21187319f, -0.22688091f, -0.21450520f, 0.08007644f, 0.06033063f, 0.13946897f, 0.12668732f, 
    0.19944361f, -0.14301869f, 0.17975017f, -0.00822556f, -0.06264902f, -0.03418863f, 0.02784568f, -0.18161413f, 
    0.14983115f, 0.00330838f, 0.06501361f, -0.09622928f, 0.05248278f, -0.02520696f, -0.10107541f, 0.06926416f, 
    0.05763990f, -0.03432782f, -0.00533561f, 0.00009839f, -0.02712023f, -0.04760193f, -0.03007431f, 0.01394772f, 
    -0.02020574f, -0.06440622f, -0.07790832f, -0.07233095f, 0.01910205f, 0.00513666f, 0.01312304f, -0.00057086f, 
    0.02503818f, 0.03111165f, -0.06822129f, 0.06104078f, -0.00891181f, -0.04344751f, -0.03242936f, 0.01538193f, 
    -0.04895968f, -0.05511072f, 0.02523316f, -0.07132830f, 0.03774496f, 0.02183542f, 0.00129626f, 0.03262388f, 
    0.04320046f, -0.00679087f, 0.05692147f, 0.04570267f, -0.01360591f, 0.03314239f, 0.01077107f, -0.05258526f, 
    0.00507800f, -0.06728038f, -0.01732643f, -0.04572339f, -0.02445438f, -0.00038246f, -0.01109656f, 0.00941183f, 
    0.00791743f, 0.03900798f, 0.05692308f, -0.04197150f, 0.01847238f, -0.06228296f, 0.01743388f, -0.05474721f, 
    0.00005878f, 0.02091680f, -0.04292880f, 0.00874350f, 0.01755275f, -0.02095479f, 0.06403621f, -0.02327528f, 
    -0.04428353f, 0.01691136f, -0.00469495f, -0.06076206f, -0.05433440f, -0.00898756f, 0.04198474f, -0.02058551f, 
    0.01893471f, 0.03847606f, 0.03312792f, -0.00787321f, -0.04130277f, -0.01515065f, -0.07017674f, -0.06067638f, 
    -0.04373055f, 0.01144491f, 0.03355805f, -0.05164265f, -0.05290057f, 0.05258091f, 0.00081377f, -0.01421860f, 
    -0.07032248f, -0.02845504f, 0.00923020f, 0.01760175f, -0.07328293f, 0.02584598f, 0.02647628f, -0.05146753f, 
    -0.01647804f, -0.07356843f, -0.01038295f, 0.01847016f, -0.05237285f, -0.06303119f, 0.00811732f, 0.05160782f, 
    0.05867174f, -0.04290646f, 0.02398047f, 0.03178882f, 0.05587230f, 0.01365939f, -0.03568507f, -0.05026801f, 
    -0.03346092f, -0.06325602f, 0.02802944f, -0.02310086f, -0.01530473f, 0.03564269f, 0.01884123f, -0.04714565f, 
    -0.03113564f, -0.05724858f, 0.04922944f, 0.03281994f, -0.04919486f, -0.00172125f, -0.05112640f, -0.05023493f, 
    0.03079783f, 0.05839561f, -0.02572370f, -0.05586407f, -0.02546878f, 0.00470267f, -0.02367999f, 0.00255956f, 
    0.06027388f, 0.02592519f, -0.04948144f, -0.06379788f, 0.04301413f, -0.03193296f, 0.02084604f, -0.06583331f, 
    0.01557031f, 0.03511116f, 0.04479024f, -0.04981083f, 0.03241313f, 0.03358457f, 0.05741305f, 0.00630472f, 
    -0.03389840f, 0.00239317f, -0.03276251f, -0.06982593f, -0.04211066f, 0.01215335f, 0.02048954f, -0.03677911f, 
    -0.01972998f, -0.01050016f, -0.06809297f, 0.02561824f, -0.04905825f, 0.03439773f, -0.03454871f, -0.05705308f, 
    0.02505571f, 0.02188291f, -0.02295049f, -0.02720618f, 0.06314322f, -0.00599126f, -0.04813069f, -0.04612933f, 
    -0.02532949f, -0.03813785f, -0.01097694f, 0.04434776f, -0.06642967f, 0.03971563f, -0.04129772f, 0.01319586f, 
    0.02074093f, -0.07154937f, -0.00367072f, 0.02669344f, -0.03842172f, -0.04750109f, -0.01823903f, -0.03542960f, 
    -0.07288937f, -0.02887243f, 0.03026688f, -0.01419624f, -0.00893363f, 0.02614516f, -0.01692122f, 0.00974341f, 
    -0.01189306f, -0.07514769f, 0.02523214f, -0.07848579f, -0.04064729f, -0.02283755f, 0.00073137f, -0.03342915f, 
    0.03658739f, 0.03236357f, 0.01056008f, 0.04060920f, 0.00343489f, 0.06048263f, -0.04675854f, 0.03908670f, 
    -0.05941210f, 0.03127381f, 0.02458376f, -0.05895466f, -0.03929697f, -0.01668675f, 0.01160384f, 0.02228208f, 
    -0.04545293f, -0.06268611f, 0.01732149f, -0.07664977f, 0.05376186f, 0.00983388f, -0.03594941f, 0.05083855f, 
    0.05506399f, -0.05714585f, -0.01541190f, -0.04036717f, -0.03279813f, 0.01695774f, 0.03886944f, 0.01855346f, 
    -0.01508505f, 0.00000910f, 0.04236737f, -0.04455330f, -0.02066090f, 0.03617495f, 0.04923544f, -0.06879152f, 
    -0.01158387f, -0.06810667f, -0.02184602f, 0.02682820f, -0.05306481f, -0.05520552f, -0.06063825f, -0.06850858f, 
    0.00824073f, -0.08098134f, -0.02889759f, -0.06451467f, -0.02753941f, -0.07134952f, -0.07236072f, 0.05173153f, 
    0.03646947f, 0.04256879f, -0.06758582f, -0.03792169f, -0.07550757f, -0.06888246f, -0.01706206f, 0.00730406f, 
    -0.00587175f, -0.02810521f, -0.05574575f, 0.01922760f, -0.03917835f, 0.01666809f, -0.02936300f, -0.06116278f, 
    -0.00808451f, -0.00371438f, 0.00374488f, 0.00239533f, -0.03525511f, -0.04094090f, -0.01719644f, -0.01259815f, 
    0.01710085f, -0.02143280f, -0.01395180f, 0.06725156f, -0.01938711f, 0.00822205f, -0.04575158f, -0.08639538f, 
    0.06181167f, -0.00487883f, 0.00105082f, 0.00601390f, -0.03436859f, -0.03956934f, 0.04898908f, -0.01958070f, 
    -0.01493034f, -0.00072744f, 0.02091914f, 0.03196443f, -0.03550725f, 0.05590588f, -0.00122874f, 0.04198607f, 
    -0.06371289f, 0.06354123f, -0.02235207f, -0.01447013f, 0.01499337f, -0.00032926f, -0.05875587f, -0.06404960f, 
    -0.01519674f, 0.01389799f, -0.04544607f, -0.02677749f, 0.02843592f, -0.05645863f, 0.00675120f, -0.00702224f, 
    -0.07665443f, -0.03485952f, -0.00488368f, -0.00419836f, -0.00377068f, -0.00549490f, -0.02899509f, 0.04788171f, 
    0.00213907f, -0.02940406f, 0.00971951f, 0.05039816f, -0.03303628f, 0.05036739f, -0.07813594f, 0.05289602f, 
    0.00085094f, -0.01322952f, -0.04716549f, 0.03337567f, -0.04864683f, -0.02966958f, -0.03024172f, -0.03814233f, 
    -0.02529439f, -0.04658660f, 0.04185747f, 0.01531037f, 0.00623221f, 0.02953713f, -0.02841328f, 0.04187795f, 
    0.07093059f, 0.05587044f, 0.00748659f, 0.03418025f, -0.00140282f, 0.00104687f, -0.01445160f, -0.08388014f, 
    -0.01632132f, 0.05789217f, 0.01625560f, -0.01871376f, 0.03364227f, -0.06236518f, 0.02808608f, -0.01472059f, 
    0.05589734f, -0.03400760f, -0.06669969f, -0.01896623f, -0.00074568f, -0.02809688f, -0.05717077f, 0.01707902f, 
    0.09889893f, 0.11374017f, 0.20950849f, -0.12854925f, -0.11892325f, 0.01576613f, 0.02345099f, 0.08518930f, 
    0.00904186f, -0.00115669f, 0.06827417f, 0.10414644f, -0.10318746f, 0.13145396f, 0.03613579f, -0.03389771f, 
    0.02316003f, -0.13625234f, -0.06734446f, -0.09613653f, -0.24497005f, -0.20272964f, -0.19737110f, -0.16786984f, 
    0.18705140f, 0.18169354f, 0.04179719f, 0.06002555f, -0.08261581f, -0.05579891f, -0.13358784f, -0.03560915f, 
    0.17655231f, 0.05507202f, 0.09632356f, 0.16525479f, 0.20593281f, 0.16013920f, 0.21543385f, 0.00634579f, 
    0.00299554f, 0.00639979f, -0.07327139f, 0.08370406f, 0.10179287f, 0.27803224f, 0.09372427f, -0.06731292f, 
    0.23744854f, 0.13768840f, 0.10715254f, 0.04358204f, 0.00582284f, -0.31368592f, -0.15956859f, 0.32146537f, 
    -0.10890739f, 0.22914591f, 0.04683122f, 0.00634259f, -0.07471547f, -0.00483037f, -0.16291195f, 0.07154382f, 
    -0.06014615f, -0.11283010f, 0.12836573f, 0.21814752f, -0.03525067f, -0.23319578f, -0.12356196f, -0.07789157f, 
    0.02093693f, 0.24832965f, 0.06119312f, 0.03060468f, 0.02160803f, 0.30597156f, -0.05446022f, -0.01983718f, 
    0.17986740f, 0.17092282f, 0.17311004f, 0.31503356f, -0.24154527f, -0.25773415f, 0.08786719f, -0.13410553f, 
    0.03424500f, 0.05065243f, 0.03254777f, 0.08858474f, -0.16059415f, 0.13503313f, 0.26271665f, 0.00677916f, 
    0.29283708f, -0.23418355f, -0.12468943f, -0.18227620f, -0.02382851f, 0.04089417f, -0.01056751f, 0.16016230f, 
    0.03399090f, 0.00004707f, 0.10157822f, 0.01516165f, 0.15950103f, 0.16132255f, -0.03920455f, 0.22146639f, 
    -0.13972236f, -0.23139814f, -0.15457174f, -0.11863410f, 0.04585926f, 0.12929735f, 0.17341825f, 0.01140468f, 
    0.14861846f, -0.05053790f, 0.09646575f, 0.12996882f, 0.01653796f, 0.08132794f, -0.05750950f, 0.11797529f, 
    -0.04067450f, -0.22839248f, -0.17136250f, -0.19746487f, -0.05991905f, 0.12957475f, 0.02004986f, -0.07369818f, 
    -0.06544940f, 0.07922288f, -0.16543429f, 0.06094545f, 0.04679920f, -0.00679025f, -0.03524718f, -0.09428225f, 
    -0.26555249f, 0.11529037f, -0.24177179f, -0.30678830f, -0.21702895f, 0.06440081f, -0.02313093f, -0.13736962f, 
    -0.03937919f, 0.08564562f, 0.06301963f, -0.06130163f, 0.49873888f, -0.01381631f, 0.10497393f, -0.04698971f, 
    -0.03693953f, -0.08921812f, 0.31811789f, -0.10950738f, 0.27431631f, 0.12777720f, -0.07180592f, 0.26280296f, 
    -0.11582729f, 0.11584442f, -0.14035974f, -0.12769173f, -0.18951914f, -0.12414621f, -0.13879810f, -0.07148356f, 
    -0.11528047f, -0.21426599f, -0.08492533f, -0.09861881f, -0.22275105f, -0.00030007f, -0.23630111f, -0.00390158f, 
    0.07628593f, -0.06902335f, 0.32243434f, 0.16281630f, -0.02385909f, 0.11271895f, -0.08220188f, 0.00712125f, 
    0.18015359f, 0.11118521f, 0.14419037f, -0.25084063f, 0.00894735f, 0.11542828f, -0.12024099f, 0.11539187f, 
    0.06828921f, 0.01327391f, 0.02240460f, 0.10569058f, 0.02913990f, 0.12919700f, 0.05941356f, 0.19963442f, 
    -0.17089193f, 0.01194553f, 0.05308975f, 0.01182170f, -0.04690359f, 0.22253564f, 0.17981814f, 0.31530744f, 
    0.13890125f, -0.47141865f, -0.50436288f, -0.05567228f, 0.18269311f, 0.09764802f, 0.07756779f, -0.08322092f, 
    -0.23051023f, 0.07195830f, -0.03446534f, 0.16693325f, -0.27711383f, -0.18832903f, -0.24951242f, -0.16368806f, 
    -0.08620337f, 0.01822811f, 0.02184160f, -0.05534208f, -0.00951459f, -0.02739123f, -0.14378618f, -0.15351661f, 
    0.07315591f, -0.25619355f, -0.04609042f, 0.37644836f, -0.08730763f, -0.13288049f, 0.14433591f, 0.22426851f, 
    -0.18817142f, -0.12424844f, -0.15428223f, 0.05982266f, 0.00814536f, 0.08117747f, -0.20717020f, 0.26415312f, 
    0.06129812f, 0.19820651f, -0.08674650f, -0.10040084f, 0.00919475f, 0.01294356f, -0.10425287f, -0.09971688f, 
    -0.17164469f, 0.24801463f, 0.03103341f, -0.11031774f, -0.19675061f, 0.12924464f, -0.07172802f, -0.19903369f, 
    -0.20253366f, 0.16833529f, -0.23092008f, -0.05590785f, 0.22296830f, 0.02174073f, 0.21782188f, 0.06369223f, 
    0.08722547f, 0.08165877f, -0.02651201f, 0.07526797f, -0.04650426f, -0.05705980f, 0.15727764f, 0.09259310f, 
    0.01315508f, 0.47449091f, -0.07503479f, -0.14999497f, 0.03664608f, 0.02696822f, 0.09012029f, -0.04947082f, 
    0.00508826f, 0.03434217f, -0.03145754f, -0.06481730f, -0.67939228f, -0.06723046f, -0.08438326f, 0.02414406f, 
    -0.07231633f, -0.01463486f, -0.04405515f, -0.18988444f, -0.05202019f, 0.01046363f, 0.02300486f, 0.07535335f, 
    0.41752112f, 0.21170130f, 0.15050334f, 0.20389670f, -0.05936982f, 0.27705851f, -0.04944506f, -0.04027148f, 
    -0.00531478f, 0.04140975f, 0.02040177f, -0.18049406f, -0.28948757f, 0.25528431f, -0.20577161f, -0.06313299f, 
    0.14861970f, -0.13140705f, -0.02921724f, 0.00476546f, 0.04126019f, -0.21388939f, -0.03916742f, -0.05506542f, 
    -0.43604782f, 0.44616005f, 0.24788737f, -0.20357302f, -0.08966289f, 0.06549590f, -0.00361233f, -0.11334667f, 
    0.08039325f, 0.07242843f, 0.13688377f, 0.15761305f, 0.44913349f, 0.15444125f, -0.46569508f, 0.45344853f, 
    -0.12590380f, -0.31095120f, -0.01196163f, -0.03223198f, -0.05765520f, -0.05372544f, -0.04762840f, 0.20095167f, 
    0.42563000f, 0.11609837f, 0.03522277f, -0.06278170f, 0.01108273f, 0.15835311f, -0.03477057f, 0.03632456f, 
    -0.19483475f, 0.23062910f, -0.06640990f, -0.16890013f, 0.13826029f, 0.29441300f, -0.01525164f, 0.05602351f, 
    0.00285212f, -0.05462853f, 0.00880502f, 0.15446167f, -0.09636690f, 0.07322815f, 0.01961965f, -0.10445064f, 
    -0.04393117f, 0.00904176f, -0.07265717f, -0.03913908f, -0.02330722f, 0.06309824f, -0.07381316f, 0.06255331f, 
    -0.05342874f, 0.02254433f, 0.03498573f, -0.01455616f, 0.02425422f, -0.01442288f, -0.04307973f, -0.00563458f, 
    -0.00313533f, -0.06157880f, -0.03922777f, 0.00940574f, 0.02987748f, 0.00225513f, -0.06815670f, -0.03137638f, 
    0.04114366f, -0.00106117f, -0.02273046f, -0.03680273f, -0.00324223f, 0.01567536f, -0.05768467f, 0.02090261f, 
    0.02942800f, -0.03151354f, 0.01500627f, 0.05378910f, -0.04836228f, 0.01800351f, 0.01887200f, -0.03575238f, 
    -0.02682726f, -0.04832107f, -0.00239800f, 0.03764662f, -0.04952890f, 0.03497129f, -0.02508001f, -0.00034040f, 
    0.06186010f, 0.00440121f, 0.03276694f, -0.03112995f, 0.00882949f, 0.05363557f, 0.05006072f, -0.04105027f, 
    -0.07858025f, 0.00327526f, -0.06115371f, 0.01418024f, -0.02565964f, -0.07592955f, 0.03514688f, 0.00670041f, 
    -0.04528534f, -0.06541244f, 0.03459563f, 0.04293585f, -0.06363817f, 0.01339682f, -0.01689774f, 0.05737133f, 
    -0.04615031f, 0.05180024f, 0.04516455f, 0.06375315f, 0.06383172f, -0.07600315f, -0.05586903f, 0.05381637f, 
    -0.00817666f, 0.04921320f, 0.04649504f, -0.01732785f, -0.04243008f, 0.00644503f, -0.03086292f, 0.02782831f, 
    0.05202236f, 0.04803205f, 0.05399976f, -0.05497769f, -0.04901750f, 0.02391503f, -0.05325457f, -0.06939958f, 
    0.00364387f, -0.05069174f, 0.04121147f, -0.02340755f, 0.01171915f, -0.06055568f, -0.00801928f, 0.03027653f, 
    0.01899942f, -0.05252527f, 0.00587103f, -0.00900906f, -0.07146789f, -0.02232151f, 0.03521479f, -0.01376125f, 
    -0.04475724f, 0.00643831f, 0.01291808f, -0.04055158f, 0.02991796f, -0.00555300f, -0.02822834f, 0.02799168f, 
    0.05044616f, -0.07193827f, 0.01863676f, 0.01945855f, -0.00280510f, 0.05059571f, 0.01318617f, -0.03177291f, 
    -0.07800063f, -0.04789773f, 0.04023453f, -0.00000419f, -0.07095209f, 0.03516464f, -0.00061347f, 0.01686811f, 
    -0.06655448f, -0.02581257f, 0.01245314f, 0.01882054f, 0.03563972f, 0.03917223f, -0.07059489f, -0.03830952f, 
    -0.05231294f, -0.07433552f, -0.04013699f, 0.04946299f, 0.04610925f, -0.07248347f, -0.05325697f, -0.00568918f, 
    0.01521384f, -0.06232418f, -0.05254709f, -0.05107080f, 0.03840835f, -0.03366715f, 0.02457468f, 0.00512144f, 
    -0.02463722f, -0.03626267f, -0.02887233f, 0.03903328f, -0.02406699f, 0.06123484f, 0.01169065f, -0.04068583f, 
    0.01619445f, -0.05103400f, -0.01422711f, 0.03934915f, 0.03926183f, 0.04095745f, 0.04109896f, -0.04991739f, 
    0.04711422f, 0.04911259f, -0.06541905f, -0.05295277f, -0.04300658f, -0.04829160f, 0.05877696f, -0.05071540f, 
    -0.06207638f, 0.00098657f, -0.04621577f, -0.04596457f, 0.05671547f, 0.04309015f, -0.06209918f, 0.03156331f, 
    0.14240681f, -0.12216090f, -0.03716182f, 0.20054214f, 0.10210874f, 0.09495284f, 0.19790277f, 0.03935019f, 
    -0.06731326f, 0.27014861f, 0.09702487f, -0.24544492f, 0.34129891f, -0.30245697f, -0.07570653f, -0.30341205f, 
    -0.00956281f, -0.07770165f, 0.09782401f, -0.00962341f, -0.02823939f, -0.06201003f, 0.01700795f, -0.30456901f, 
    -0.50809056f, 0.14585347f, 0.27964950f, -0.40124637f, -0.14081961f, -0.08115568f, -0.21199739f, -0.01956117f, 
    -0.03561004f, -0.05243697f, 0.09284241f, -0.08709469f, -0.16145334f, 0.13961577f, -0.17427792f, -0.03278427f, 
    0.01444350f, -0.13422413f, -0.04088758f, 0.07236230f, 0.08148783f, 0.03256708f, -0.05288640f, 0.13109824f, 
    -0.03115152f, -0.19825055f, 0.10975479f, -0.12161293f, 0.17055593f, 0.22201197f, 0.10824087f, -0.23393661f, 
    -0.10623624f, 0.04080712f, -0.13796462f, 0.05341397f, -0.27955237f, 0.00109154f, -0.04204522f, -0.05919914f, 
    -0.11036119f, 0.08437227f, -0.09849209f, 0.22414169f, 0.07818972f, 0.04256142f, 0.08944086f, -0.04906226f, 
    -0.13556334f, 0.02124178f, 0.04843096f, 0.02616949f, 0.01442338f, 0.05637532f, 0.21603397f, 0.02144885f, 
    0.25446126f, 0.01537440f, 0.22279990f, 0.20401928f, -0.04264405f, -0.13434669f, -0.01790813f, 0.08092950f, 
    -0.06859177f, -0.07773633f, -0.05321708f, -0.00764988f, -0.02775174f, 0.08767699f, -0.14948420f, -0.06666009f, 
    -0.29851285f, -0.29870960f, -0.41601714f, -0.01842720f, -0.17488477f, 0.02094618f, -0.00814706f, 0.23554005f, 
    0.06761812f, 0.13805014f, 0.09197416f, 0.02442014f, -0.01135663f, -0.00313793f, 0.09824103f, -0.13155094f, 
    0.06397036f, 0.08983218f, -0.03039963f, 0.07434455f, -0.05253773f, 0.06348357f, 0.15439023f, 0.20138846f, 
    -0.43145716f, -0.27061594f, 0.22660388f, 0.41929358f, 0.15970045f, -0.14801593f, 0.15333937f, 0.06389498f, 
    -0.13546987f, -0.13436949f, -0.02008187f, -0.03820065f, 0.18117872f, -0.19985896f, 0.08807836f, 0.32111362f, 
    0.10191853f, 0.21043925f, 0.16958176f, 0.09556784f, -0.05514342f, 0.02757917f, 0.06584289f, 0.07581849f, 
    -0.15453719f, -0.02297091f, -0.09422530f, 0.35868308f, 0.04979761f, 0.15223517f, 0.14583786f, -0.00503904f, 
    -0.06205622f, -0.15565935f, 0.01002428f, -0.22564702f, -0.54451632f, 0.38587940f, 0.42533487f, 0.27332827f, 
    0.01591646f, 0.22396415f, -0.06072178f, 0.10567194f, 0.22608115f, 0.10556654f, -0.02080329f, 0.11661768f, 
    0.10238686f, 0.02830228f, -0.04348646f, 0.23229833f, 0.09880817f, -0.10222729f, 0.13510543f, 0.16979018f, 
    -0.06480685f, 0.07160731f, 0.03144019f, -0.12185690f, -0.25694278f, -0.07867909f, 0.05290064f, 0.11333165f, 
    -0.04272224f, -0.05846293f, -0.21482047f, -0.20119314f, 0.00132582f, -0.01478135f, -0.13763936f, 0.13114735f, 
    0.04128448f, 0.16506545f, 0.22264935f, 0.33192715f, -0.14636536f, -0.16500545f, -0.04491767f, -0.05676644f, 
    -0.07447891f, -0.07937913f, 0.05641785f, 0.06092595f, -0.34939554f, -0.12349412f, -0.06730893f, -0.07175937f, 
    0.04410923f, 0.15227689f, -0.15422641f, 0.01752391f, 0.08775821f, -0.04101856f, 0.18353626f, 0.18778160f, 
    0.14475796f, -0.58055669f, -0.41264778f, -0.16226584f, 0.11882776f, 0.02911054f, -0.05017385f, 0.03136710f, 
    0.05113100f, 0.11159685f, 0.15892187f, -0.03201235f, -0.44430178f, -0.22437812f, -0.25332236f, -0.09841391f, 
    0.05531776f, -0.04083737f, 0.02187670f, -0.13244300f, 0.11696018f, 0.10688929f, 0.02407819f, 0.11834295f, 
    -0.11404404f, -0.00624112f, -0.19757797f, 0.04219300f, 0.05688315f, 0.00276031f, 0.14806369f, -0.05156542f, 
    0.04779875f, -0.00253391f, 0.15753143f, -0.25795290f, 0.02078833f, 0.07411660f, 0.24935418f, 0.20463249f, 
    0.10995079f, 0.26436651f, -0.04206266f, 0.07651529f, -0.05767389f, 0.02877778f, 0.02501526f, 0.12563205f, 
    0.17837298f, -0.12800039f, -0.00916952f, -0.02186216f, -0.11515451f, 0.06282052f, 0.01487513f, 0.06494436f, 
    -0.09058961f, -0.13475163f, -0.06792679f, -0.19834721f, 0.18139999f, 0.26904550f, 0.07544263f, 0.08995473f, 
    0.17716585f, 0.21996836f, 0.05974638f, 0.05543963f, -0.00117913f, -0.09335550f, -0.00367495f, -0.00367617f, 
    -0.15460186f, 0.37479886f, 0.09135861f, 0.00177932f, 0.11565740f, -0.11237108f, 0.09861521f, 0.06501534f, 
    0.08593392f, 0.03530314f, -0.12699983f, 0.03440068f, 0.00481675f, -0.06368954f, 0.09505703f, 0.02070428f, 
    -0.00664371f, -0.05914122f, -0.02887045f, -0.02292743f, -0.01222743f, -0.05521085f, -0.11993053f, -0.04355810f, 
    0.10136385f, 0.43573189f, 0.12949724f, -0.05641475f, -0.05726049f, -0.00641382f, 0.09409274f, 0.06349530f, 
    0.05770902f, 0.01686574f, 0.04224987f, -0.04415133f, -0.02738743f, 0.21962515f, -0.01082037f, 0.09126146f, 
    -0.14346647f, -0.22405936f, 0.00855753f, 0.08038566f, 0.01072123f, -0.12148824f, -0.06376030f, 0.05504533f, 
    0.22647654f, 0.19079161f, 0.31266439f, 0.01988436f, 0.02133447f, -0.12171671f, -0.24838492f, -0.13064528f, 
    0.01552231f, 0.07090998f, 0.04787358f, 0.03299268f, -0.01450524f, -0.16387644f, -0.36479899f, 0.09506857f, 
    0.15172495f, 0.11450551f, -0.09879612f, -0.21203594f, 0.02412224f, -0.02099067f, 0.06303525f, 0.03412174f, 
    0.12333577f, 0.01807218f, 0.21902484f, -0.02939952f, 0.25976178f, 0.06523218f, -0.12273384f, 0.14442022f, 
    -0.00687737f, -0.05324320f, 0.12027143f, 0.01482327f, 0.56470573f, 0.46112189f, 0.70538223f, 0.40928078f, 
    0.07516503f, 0.04749519f, 0.10196119f, 0.05911186f, -0.02043144f, -0.01592997f, -0.07664257f, -0.10714024f, 
    0.17970914f, 0.23352708f, 0.14978640f, 0.11471172f, -0.02886264f, -0.03081926f, 0.00483057f, 0.06869916f, 
    0.07473334f, 0.03121770f, 0.21115986f, 0.13348457f, -0.16784510f, -0.11619261f, -0.26559842f, -0.09091552f, 
    0.08491050f, -0.01278118f, -0.04307977f, -0.16191979f, 0.16728477f, 0.10547058f, 0.28062949f, 0.26782590f, 
    0.17308189f, -0.15999237f, -0.36681393f, -0.01417563f, -0.03188390f, -0.01157981f, 0.09589236f, 0.00200647f, 
    0.14887065f, -0.02537660f, -0.01155424f, -0.05477951f, -0.15849638f, -0.09564190f, -0.08100248f, 0.24003382f, 
    0.13170053f, 0.10097561f, 0.06312295f, 0.07647353f, 0.13309194f, 0.04107317f, -0.11860615f, 0.14883740f, 
    0.16670370f, 0.10030554f, -0.14531705f, -0.13795945f, 0.00659763f, -0.03673138f, 0.28943783f, 0.09542935f, 
    0.17365311f, -0.04965886f, 0.03378391f, 0.08190773f, -0.12842473f, -0.08327319f, 0.49369541f, -0.14505975f, 
    -0.14613119f, 0.01507046f, -0.06064835f, 0.03677758f, -0.09215047f, 0.04173734f, 0.12464664f, 0.21969430f, 
    0.01148508f, -0.19165294f, 0.05514746f, 0.11966217f, 0.09350036f, 0.11930262f, -0.01468185f, 0.18870415f, 
    -0.03329267f, -0.13853142f, 0.07771011f, -0.30438063f, 0.11909786f, 0.52540636f, -0.04552764f, -0.04454326f, 
    -0.02648959f, -0.13993193f, 0.17677113f, 0.07057925f, 0.07248066f, -0.13828163f, -0.29489192f, 0.00763512f, 
    -0.47693008f, 0.23116569f, 0.44424295f, 0.72863489f, 0.01483444f, -0.15202244f, -0.02462011f, -0.08831532f, 
    0.03654631f, -0.02709978f, -0.00682559f, 0.16344485f, 0.19014058f, -0.26102236f, -0.11364149f, 0.02459898f, 
    0.12122567f, 0.36002183f, 0.13307808f, 0.18677574f, 0.00294209f, -0.23638208f, -0.17405519f, -0.21562618f, 
    -0.29461813f, 0.20849574f, 0.16651809f, -0.14441048f, -0.19676073f, -0.06024285f, 0.07638011f, 0.02997884f, 
    0.04942655f, -0.01030459f, 0.02498824f, 0.14419381f, 0.02114233f, -0.11009238f, -0.02069642f, 0.10117834f, 
    0.09145340f, 0.13996413f, 0.12876894f, 0.09272522f, -0.07828367f, -0.05009254f, 0.14153329f, -0.02936099f, 
    0.20142105f, -0.13663800f, 0.08376421f, -0.00065754f, 0.16098750f, -0.07766937f, -0.01470262f, 0.22401890f, 
    0.08969843f, -0.00635792f, -0.10201859f, -0.06773910f, 0.06900935f, -0.11169787f, 0.27559969f, -0.16631098f, 
    0.02238193f, 0.11052941f, -0.06019443f, 0.12314957f, -0.22025311f, -0.02724073f, -0.04711550f, -0.12726162f, 
    -0.42161688f, 0.39917439f, 0.11326424f, -0.03373305f, 0.08961447f, -0.21214761f, 0.08974268f, 0.05858261f, 
    0.25437826f, 0.02526495f, 0.25700396f, 0.11717100f, 0.01150496f, 0.12625794f, 0.47147134f, 0.00447490f, 
    -0.05067622f, -0.02427254f, -0.01457401f, 0.03407248f, 0.00580833f, -0.11223789f, -0.11134198f, -0.16007747f, 
    0.06039802f, 0.03335537f, -0.05145834f, 0.01984316f, -0.01721858f, -0.07249764f, 0.03366362f, -0.06320506f, 
    0.00797071f, 0.06024322f, 0.02618236f, -0.06060020f, -0.02651239f, 0.05486965f, -0.01175205f, 0.00701534f, 
    0.01153091f, -0.01543387f, 0.01174124f, -0.07413541f, -0.03809476f, 0.04028543f, -0.05683461f, -0.01886941f, 
    -0.02992194f, -0.07613542f, -0.02596582f, 0.04920077f, 0.05378739f, -0.06405226f, 0.05632141f, -0.03168633f, 
    0.01559903f, 0.01098191f, -0.04685970f, -0.04122487f, -0.06702790f, -0.03591685f, 0.00510332f, -0.00330823f, 
    -0.07269660f, -0.01148710f, 0.04337447f, -0.05916335f, 0.02503241f, 0.02506531f, 0.01800715f, -0.03744891f, 
    -0.05628917f, 0.03450614f, -0.02391254f, -0.06259551f, 0.03582408f, 0.01597117f, -0.01807779f, -0.08023834f, 
    0.01271497f, 0.05536021f, -0.02769266f, 0.04084415f, -0.02700792f, -0.03686461f, -0.05606167f, -0.06258612f, 
    0.01624920f, 0.01733493f, -0.01771534f, -0.00352649f, 0.05204584f, -0.06578677f, -0.02055446f, 0.06232105f, 
    0.02456332f, 0.06136880f, 0.01117399f, -0.01646546f, -0.00210767f, -0.07688142f, -0.04316042f, 0.03888282f, 
    -0.07286750f, -0.02237410f, -0.02847496f, 0.05228476f, -0.00701111f, 0.03251644f, 0.05941003f, -0.04362807f, 
    -0.04313631f, 0.04597880f, 0.05043956f, 0.05003007f, 0.02807838f, 0.04407055f, -0.07975607f, -0.00009139f, 
    0.01097654f, 0.04538901f, 0.03616071f, 0.01186268f, -0.07226009f, -0.04387932f, -0.02553809f, -0.00335744f, 
    0.00583342f, -0.00344488f, -0.03667636f, -0.03834851f, 0.03112540f, 0.02289215f, -0.05611616f, 0.02011281f, 
    -0.03623594f, -0.01612497f, 0.02325170f, -0.07946967f, -0.03355034f, -0.01882925f, -0.04467643f, 0.00059429f, 
    -0.04127801f, -0.04260515f, -0.04799409f, 0.04053072f, -0.04734329f, 0.04061519f, -0.05791730f, -0.04972040f, 
    0.04901432f, -0.03989294f, -0.01571077f, 0.05529034f, -0.02666211f, 0.05995389f, -0.04695978f, -0.06364052f, 
    0.02716636f, -0.01320833f, 0.00008054f, 0.00811610f, -0.05911728f, -0.03616320f, -0.07757753f, -0.04604490f, 
    -0.03814607f, -0.05667965f, -0.05375095f, -0.00730818f, 0.03310487f, -0.05389608f, -0.06493329f, -0.06374218f, 
    0.05095911f, -0.01523553f, 0.03871177f, -0.02769422f, -0.01606868f, -0.02905737f, 0.01631014f, 0.01800714f, 
    0.06224351f, 0.01887034f, 0.01820613f, -0.00485054f, -0.02755742f, 0.02831027f, -0.06174616f, -0.08104120f, 
    0.02996865f, -0.03984668f, 0.01619930f, -0.03141340f, -0.04670817f, -0.02283718f, -0.02675198f, -0.00984348f, 
    -0.06765173f, 0.04991880f, -0.07034432f, 0.06339644f, 0.03690941f, -0.05544236f, -0.01761879f, 0.04544279f, 
    -0.03612231f, 0.04311634f, -0.00449923f, -0.02482612f, 0.05130953f, -0.07322537f, -0.07290962f, -0.04225246f, 
    -0.12545478f, 0.35373983f, 0.42815158f, 0.01930097f, 0.10985476f, 0.12845609f, -0.03414296f, 0.15343212f, 
    0.00637124f, -0.08002175f, -0.04994015f, -0.00854672f, -0.22637406f, 0.11610483f, 0.08685441f, 0.19127582f, 
    0.02933102f, 0.03184403f, -0.05615785f, -0.25377262f, -0.06475564f, -0.25976506f, -0.20947021f, -0.08361456f, 
    -0.22557423f, -0.14052701f, -0.07617795f, 0.42763820f, 0.03319073f, -0.05801547f, -0.21695319f, -0.04916905f, 
    0.00956167f, 0.03425110f, 0.03595819f, 0.02244836f, -0.14066170f, -0.01873685f, 0.05417339f, -0.04173317f, 
    -0.11075541f, -0.03500118f, -0.02057078f, -0.07117649f, 0.00906633f, 0.15819041f, -0.07118111f, -0.01980666f, 
    -0.28780881f, -0.09028285f, -0.07262325f, 0.12550908f, -0.08851826f, -0.18904206f, 0.07560184f, 0.21175428f, 
    0.05306182f, 0.11298697f, -0.25012645f, -0.08832353f, 0.06539968f, 0.09556796f, -0.15146038f, 0.15817866f, 
    0.10808064f, -0.03293587f, 0.03575015f, -0.00250735f, -0.08232354f, -0.01459000f, -0.16159634f, 0.00282142f, 
    0.02225001f, 0.14666192f, 0.16961373f, -0.19458020f, 0.05536372f, 0.18913290f, -0.02800648f, 0.02425528f, 
    0.27270266f, 0.17665282f, 0.37412027f, 0.24212706f, 0.14657117f, -0.01804332f, 0.23415811f, 0.11211433f, 
    -0.02934577f, 0.02420564f, -0.04069130f, 0.00406829f, -0.03221169f, 0.11260143f, 0.02673748f, 0.06278208f, 
    0.37922180f, -0.01070153f, 0.00713395f, -0.00115881f, -0.05105887f, 0.02458180f, -0.02033435f, -0.10161634f, 
    -0.02157899f, -0.13437079f, 0.04649130f, 0.09844166f, -0.25602064f, -0.02557799f, -0.04616443f, 0.04363062f, 
    -0.08226649f, -0.04330452f, -0.15375680f, -0.08424209f, 0.10022601f, 0.13305692f, 0.13214023f, -0.01595206f, 
    0.32931677f, 0.29584512f, -0.01728352f, 0.24164213f, 0.08427327f, 0.30540848f, 0.01283186f, -0.02662284f, 
    -0.03688532f, -0.07501508f, 0.01042978f, 0.00237365f, -0.08987471f, 0.34819928f, 0.11820513f, -0.08159226f, 
    0.10122170f, 0.06586812f, -0.03581431f, 0.19312756f, 0.05765964f, -0.13898708f, 0.08725828f, -0.03695999f, 
    -0.31587377f, 0.29037166f, 0.05847717f, -0.05170357f, -0.04945867f, 0.04488704f, 0.01410277f, 0.20038918f, 
    -0.14560533f, 0.17235479f, 0.04087131f, -0.14636667f, 0.32615975f, -0.20489325f, 0.11447386f, 0.04557741f, 
    -0.12996940f, 0.02288657f, 0.11899620f, -0.00337374f, 0.05992357f, 0.15720461f, -0.16165371f, 0.03601585f, 
    0.28853968f, 0.06400774f, -0.33655849f, -0.14181463f, -0.04527691f, -0.25075155f, 0.00800391f, 0.03235159f, 
    -0.26415145f, -0.15930507f, -0.07081797f, -0.01069797f, 0.25835446f, 0.38429201f, -0.39577788f, 0.02544567f, 
    0.01331355f, 0.15997984f, 0.25367001f, 0.18410082f, -0.05645603f, 0.18321052f, -0.01527899f, 0.01991739f, 
    0.26745194f, 0.29597536f, -0.04295209f, 0.20429298f, 0.17289019f, 0.15462956f, -0.09494893f, -0.00034575f, 
    0.08152176f, 0.01455417f, -0.02460124f, -0.11714470f, -0.30196223f, -0.14758621f, -0.20788428f, -0.18324551f, 
    0.17272040f, 0.10955129f, -0.10296291f, -0.11287435f, 0.24730800f, -0.08756175f, 0.04502492f, -0.41238737f, 
    -0.64320320f, -0.16979374f, 0.09186544f, -0.06678267f, -0.05975561f, 0.00462082f, -0.16523077f, 0.04426447f, 
    0.01876330f, 0.02723988f, 0.16542612f, -0.34245729f, -0.25333217f, -0.23397832f, 0.03430267f, -0.11938664f, 
    0.11117356f, -0.30187553f, -0.08347925f, -0.05085762f, 0.06630891f, 0.05333032f, -0.01576409f, 0.10001004f, 
    -0.51156086f, 0.04009065f, -0.16199693f, -0.31705627f, 0.30839604f, -0.14038591f, -0.05717621f, -0.03473756f, 
    0.01246367f, 0.01013103f, 0.13156918f, -0.17452832f, 0.06871461f, -0.01377689f, 0.46272859f, -0.05817126f, 
    0.02918813f, 0.06869705f, 0.06298425f, 0.05548340f, 0.10320377f, -0.10986278f, 0.10273698f, -0.10000040f, 
    0.03654969f, -0.23015988f, 0.04390397f, 0.01116950f, -0.10061551f, -0.03787294f, 0.20517465f, 0.15143016f, 
    0.19727387f, -0.02559658f, 0.16783036f, 0.30832380f, -0.12119950f, -0.00452393f, -0.04220669f, 0.21946223f, 
    0.12149739f, 0.19392584f, 0.11631161f, 0.13055488f, 0.21863724f, 0.02696788f, 0.00473486f, 0.05376415f, 
    -0.03738227f, -0.72458631f, 0.26558042f, 0.35684919f, -0.12047531f, -0.05937864f, -0.00415235f, 0.16630429f, 
    0.23358376f, -0.14535105f, -0.33768162f, -0.05551543f, 0.19208924f, -0.08400379f, -0.09154356f, -0.10790957f, 
    -0.04728250f, -0.16375479f, 0.02387212f, 0.10865368f, 0.01397051f, 0.09083292f, -0.03918511f, -0.04589072f, 
    -0.11511442f, 0.20143212f, 0.23206472f, 0.11077408f, -0.00631634f, -0.15869623f, 0.00100298f, 0.03219254f, 
    0.13665104f, -0.08696867f, -0.05106642f, 0.31211138f, 0.27670464f, -0.07206946f, 0.40945864f, 0.00618296f, 
    -0.08421865f, 0.01482363f, 0.13598657f, 0.19451787f, 0.09812786f, 0.18055275f, 0.26181397f, -0.00017894f, 
    -0.27181032f, -0.09151254f, -0.13577053f, 0.09352099f, 0.06525153f, -0.22081463f, -0.07104564f, -0.18289648f, 
    -0.08926649f, 0.04331578f, -0.03226572f, -0.17834820f, -0.10851175f, 0.15514375f, 0.53571033f, -0.36905250f, 
    0.02788476f, 0.28165656f, 0.24332011f, -0.03587320f, 0.19744620f, -0.18571757f, -0.03583970f, -0.15448135f, 
    -0.32528487f, 0.34443638f, -0.24431297f, 0.20102291f, 0.19560531f, -0.18540169f, 0.14534189f, 0.05181860f, 
    -0.05965743f, -0.11017665f, -0.07354102f, 0.00917077f, 0.12773335f, 0.07634513f, 0.37768406f, -0.10591170f, 
    0.05149391f, 0.17209381f, 0.32342917f, 0.01034944f, 0.15148520f, -0.15259954f, 0.06853619f, 0.10301933f, 
    0.19483823f, 0.27547145f, 0.07978018f, 0.30036411f, 0.00672350f, 0.01090834f, 0.02042075f, 0.04502741f, 
    -0.07640797f, -0.03838206f, 0.10111053f, -0.08076460f, -0.55770212f, -0.19114855f, -0.19294760f, 0.06064666f, 
    0.00835359f, 0.20027488f, -0.07543447f, -0.04989965f, -0.02366118f, -0.11921385f, 0.09220813f, 0.11495061f, 
    -0.02983226f, -0.31174350f, -0.32277346f, -0.22584742f, 0.14658237f, 0.10861319f, 0.05532081f, -0.11013554f, 
    0.05573206f, -0.13275059f, -0.01188199f, -0.01901029f, -0.30694732f, -0.80704993f, -0.11184486f, -0.04401601f, 
    0.18174301f, -0.15396151f, -0.13651334f, -0.11420809f, -0.03174691f, -0.12695612f, 0.15867648f, 0.00522042f, 
    -0.02105017f, 0.00681621f, -0.60845315f, -0.06113380f, -0.03002393f, 0.11118608f, 0.13166963f, -0.11401474f, 
    -0.18063548f, 0.00817798f, 0.05792529f, -0.04768575f, 0.35689324f, -0.09701104f, 0.40681967f, -0.00687525f, 
    0.07462705f, 0.23845232f, -0.02745129f, -0.05292622f, -0.14081679f, 0.05940106f, 0.07602254f, 0.14126582f, 
    0.03369943f, -0.32666758f, -0.10335203f, -0.28312677f, 0.13070869f, -0.03410567f, 0.13741857f, -0.03132662f, 
    0.07817336f, -0.24005884f, -0.07135229f, -0.07477680f, 0.06008627f, 0.34487346f, -0.04774543f, 0.03298928f, 
    -0.01422423f, 0.09162413f, -0.06185002f, 0.07054284f, 0.14375550f, 0.05938925f, 0.17071883f, -0.06626218f, 
    0.18134919f, 0.07713135f, 0.01017360f, 0.07703316f, -0.03554570f, -0.16298917f, 0.01831767f, -0.02465509f, 
    0.03220007f, 0.09161805f, 0.04584117f, -0.17485984f, 0.14954777f, -0.37553945f, -0.04005644f, -0.03417480f, 
    0.03681529f, -0.04765039f, 0.08552507f, -0.05988557f, -0.00612542f, -0.06238510f, -0.21380305f, 0.05779796f, 
    0.07008769f, 0.24573098f, 0.08779706f, -0.29332745f, 0.03287360f, 0.05638895f, 0.10225965f, 0.30041459f, 
    0.19445308f, -0.09687546f, -0.02844980f, 0.12644315f, 0.23442738f, 0.05679625f, 0.29993039f, -0.10860562f, 
    -0.00818508f, -0.03776167f, 0.20985571f, -0.06465410f, -0.10888866f, 0.04529206f, -0.07301180f, 0.07040723f, 
    0.47546017f, -0.25362271f, 0.31192067f, -0.23430797f, 0.25812781f, 0.09672346f, 0.08709528f, 0.04789568f, 
    0.02556068f, -0.13564582f, -0.03175635f, -0.03271834f, 0.33204320f, -0.32364771f, -0.33269519f, -0.20346045f, 
    0.00731265f, 0.01814565f, 0.03914547f, 0.12974235f, 0.06030856f, -0.00802576f, -0.00507562f, -0.11036417f, 
    -0.39002514f, -0.09651524f, -0.06301459f, -0.14832211f, 0.08620727f, 0.16165371f, 0.17187558f, 0.15872005f, 
    0.00971834f, 0.01716067f, 0.06078004f, -0.00516037f, 0.57475412f, 0.17583258f, 0.70692718f, 0.05647755f, 
    0.03126330f, 0.06322419f, 0.08215529f, 0.11580650f, -0.00448887f, -0.01001984f, -0.09511465f, -0.08434403f, 
    0.02680495f, 0.03791309f, 0.06150899f, 0.02548276f, -0.05739091f, -0.00622516f, -0.07209238f, -0.05623506f, 
    0.01636942f, -0.03837786f, -0.01839286f, -0.02675198f, -0.01537930f, -0.04688711f, -0.02191336f, -0.06454227f, 
    -0.06005591f, 0.04910261f, -0.02732393f, 0.05526187f, -0.02971950f, 0.01161945f, -0.04110075f, -0.04959004f, 
    -0.01610818f, -0.06243218f, -0.04641334f, -0.06925236f, 0.01392870f, -0.00249892f, -0.04955933f, -0.07723046f, 
    0.05633355f, -0.05465628f, -0.02288152f, -0.05934457f, 0.06496446f, 0.00485913f, -0.03442211f, -0.03857627f, 
    0.01065932f, 0.05562820f, 0.03527273f, 0.02520971f, 0.01587944f, -0.06848954f, -0.02542767f, 0.06279373f, 
    -0.05955778f, 0.00569358f, -0.05670962f, -0.02614607f, 0.01548448f, -0.02804774f, -0.03905150f, -0.03227590f, 
    0.05036522f, -0.01619731f, -0.06496616f, 0.05612716f, 0.04840097f, -0.05387077f, -0.05829824f, -0.06215762f, 
    -0.02534995f, 0.06444967f, -0.05928743f, 0.02867965f, 0.05471858f, -0.05055259f, 0.01911501f, -0.07545898f, 
    0.04247552f, 0.00468559f, -0.01636412f, 0.03710496f, -0.05045953f, -0.03195529f, 0.02770197f, -0.00030168f, 
    0.06050748f, 0.05186928f, -0.06576499f, -0.05998852f, 0.05599320f, -0.01488872f, 0.03001491f, -0.06245499f, 
    0.02423846f, 0.03896575f, -0.04979935f, -0.05927292f, -0.00433450f, -0.07510953f, -0.06075342f, -0.04601812f, 
    0.03713566f, -0.06824965f, 0.02507548f, -0.06696057f, 0.01271775f, -0.01954164f, 0.00879227f, -0.07296833f, 
    0.01933506f, -0.05184562f, -0.06746403f, -0.05434062f, 0.04969628f, 0.02215158f, 0.04688139f, -0.04550559f, 
    -0.05673115f, -0.04328438f, -0.05131784f, -0.05207033f, 0.03679957f, -0.02317344f, 0.03426112f, -0.05436203f, 
    -0.05961959f, -0.01096779f, 0.04137413f, 0.05703977f, -0.00829448f, 0.01123935f, 0.04546313f, 0.02295887f, 
    -0.01972112f, -0.05781426f, 0.06742509f, -0.05684735f, -0.06498172f, -0.06651229f, 0.05906329f, -0.03220263f, 
    -0.00025887f, 0.02394363f, -0.03858655f, -0.03597824f, 0.00542966f, 0.00689963f, -0.03299853f, 0.02528912f, 
    0.02489213f, -0.03417844f, -0.01657750f, -0.06139251f, 0.04382702f, -0.02796079f, 0.01115270f, 0.00348063f, 
    0.00322400f, -0.06759299f, -0.04369697f, 0.00111106f, -0.02694641f, -0.04206284f, -0.01200924f, -0.03421301f, 
    0.00341625f, -0.04727406f, 0.00508518f, -0.02760497f, 0.00594457f, -0.03696601f, 0.06414413f, 0.02969679f, 
    -0.06829360f, -0.05787787f, 0.00214738f, 0.04854796f, 0.01757307f, 0.03476225f, -0.00115646f, 0.05552492f, 
    -0.05355891f, -0.03253236f, 0.03713260f, 0.01540770f, 0.03268634f, 0.05892875f, 0.05784969f, -0.03164812f, 
    -0.02473778f, -0.01568176f, -0.06421313f, -0.05776346f, 0.00957846f, -0.05198831f, -0.03011141f, -0.03992315f, 
    0.14663744f, -0.07785102f, -0.00467784f, -0.28180504f, 0.12464971f, 0.03023552f, -0.04776869f, -0.01430385f, 
    0.22378236f, 0.20735963f, 0.10929564f, 0.10760916f, 0.17655639f, -0.00450311f, -0.08056188f, 0.00125333f, 
    0.02241045f, -0.22541247f, 0.11537495f, -0.20021120f, 0.12016346f, 0.34629098f, 0.18685514f, 0.04332256f, 
    -0.12415768f, 0.20155163f, -0.44263935f, -0.35556129f, -0.07813282f, -0.11531428f, 0.06997252f, -0.08839992f, 
    0.18317923f, 0.08794495f, 0.14859946f, 0.10980614f, 0.05619038f, -0.27852529f, -0.12053075f, 0.10836240f, 
    0.07591120f, 0.15785605f, 0.06694416f, 0.11410712f, 0.00376111f, 0.07047297f, 0.13473153f, 0.12234582f, 
    0.45925885f, 0.11432013f, 0.12473660f, 0.00916088f, 0.16242075f, -0.34069800f, 0.07331792f, 0.17431656f, 
    0.16860193f, 0.04850560f, -0.04565934f, 0.05491202f, -0.37389097f, -0.12903175f, 0.22916189f, 0.20714730f, 
    -0.05460074f, -0.00500230f, -0.22467519f, 0.10052662f, 0.00142640f, 0.03679985f, 0.13843174f, 0.12678896f, 
    -0.00820514f, 0.10269177f, 0.10891119f, -0.04694702f, 0.03741544f, 0.14631419f, -0.02701937f, -0.01877196f, 
    0.16062887f, 0.07588466f, -0.34412450f, 0.12635055f, 0.29363909f, 0.18799952f, 0.21001877f, 0.00680157f, 
    -0.11486622f, -0.13186917f, -0.03402416f, 0.10819706f, 0.07064942f, -0.12133250f, 0.02951058f, -0.10363942f, 
    0.20878550f, 0.06593010f, 0.61724263f, 0.39113358f, -0.13700531f, -0.08784054f, -0.21634246f, 0.16701820f, 
    -0.13984568f, -0.00064806f, -0.01884829f, 0.14098418f, -0.11832805f, -0.16054136f, -0.31116098f, 0.14908926f, 
    0.00862568f, 0.25780651f, 0.08484637f, 0.05733180f, 0.05570922f, -0.08089340f, 0.02456880f, -0.16741262f, 
    -0.08874945f, -0.37082687f, 0.38819292f, 0.23319370f, -0.00734491f, -0.10191060f, 0.04587953f, -0.00942482f, 
    0.03271259f, 0.01840597f, -0.10756034f, 0.05057171f, -0.24941030f, -0.27149323f, -0.32319677f, 0.02956087f, 
    0.02958108f, -0.02071008f, -0.01528413f, 0.10461648f, 0.03299786f, -0.04471645f, -0.08729610f, 0.00819885f, 
    -0.63635784f, -0.35893762f, -0.58999962f, -0.02727664f, -0.00146591f, 0.14245079f, 0.03422877f, -0.21178134f, 
    -0.03078010f, -0.11560795f, 0.13431236f, 0.07399173f, 0.38157743f, 0.37942991f, 0.65870279f, -0.29955909f, 
    0.06973330f, -0.08205847f, -0.00416212f, 0.07296515f, 0.15926526f, 0.05554438f, 0.08434137f, 0.09258150f, 
    -0.12699412f, 0.60090572f, 0.13827941f, 0.41107422f, -0.20571648f, -0.20623900f, -0.17236811f, -0.06801095f, 
    0.00388968f, 0.01459836f, 0.03126425f, 0.25621119f, -0.63346678f, -0.30708253f, -0.10386476f, -0.21742278f, 
    -0.17077616f, -0.23638974f, -0.08843168f, 0.09842029f, 0.00923094f, 0.05130883f, 0.08644426f, -0.17009814f, 
    0.02930275f, 0.03012984f, 0.21216847f, -0.16741425f, -0.30843249f, -0.00969342f, -0.08029132f, -0.03877620f, 
    0.34895709f, -0.01929484f, -0.23989846f, -0.00201030f, -0.16672416f, 0.08009390f, -0.28821999f, -0.03223420f, 
    -0.21039213f, 0.04097203f, 0.21699759f, 0.13032845f, 0.09484121f, 0.09516829f, 0.07526323f, 0.14593561f, 
    -0.06600790f, -0.00797748f, -0.16929729f, -0.26546204f, -0.25878644f, -0.07732742f, 0.04932828f, 0.05342272f, 
    0.22562392f, 0.23443426f, 0.20111331f, 0.17169115f, -0.08460966f, -0.14058891f, -0.00819780f, -0.00390664f, 
    -0.08351548f, 0.07066505f, 0.04457819f, 0.07777129f, 0.10746957f, 0.04432961f, 0.16042018f, 0.06263072f, 
    0.32351640f, 0.27321094f, -0.41069007f, 0.14154348f, -0.01223349f, 0.01944139f, -0.22853196f, -0.03175584f, 
    0.01215074f, -0.02944373f, 0.06001346f, -0.05390221f, -0.07342926f, -0.26690185f, 0.02824939f, 0.15203847f, 
    -0.21760003f, 0.04805276f, -0.20046185f, -0.16410597f, -0.28149667f, 0.01779409f, -0.32950029f, -0.34714499f, 
    -0.00295944f, 0.10844794f, 0.02560095f, -0.01533824f, 0.10744678f, 0.05672577f, -0.05283954f, -0.04698562f, 
    0.04338861f, 0.01734075f, -0.09560664f, -0.11628700f, -0.00908020f, 0.06161214f, 0.07176416f, 0.00655238f, 
    0.30697462f, -0.12242615f, 0.06263233f, 0.12408826f, 0.19779135f, 0.17209266f, -0.21190320f, -0.29934421f, 
    0.06860586f, 0.06750847f, -0.00950686f, -0.01076904f, 0.01033066f, 0.00402056f, 0.13092613f, 0.09428651f, 
    -0.09907804f, -0.03587788f, -0.03059370f, -0.08359649f, 0.03034629f, 0.05085629f, 0.00362010f, 0.14794427f, 
    -0.06229427f, -0.17938399f, 0.08256315f, 0.09301814f, -0.03755543f, -0.14339936f, 0.00524868f, 0.12780151f, 
    0.17702872f, -0.12028567f, 0.01366081f, 0.00089934f, -0.00426537f, -0.02926584f, -0.05218812f, -0.09105516f, 
    -0.26793170f, -0.11420668f, 0.18603493f, 0.05153765f, -0.19920978f, 0.00100381f, -0.04136918f, -0.12573950f, 
    -0.24121590f, 0.04172548f, 0.20239069f, 0.05285852f, 0.04365190f, -0.01362542f, 0.07154381f, -0.05533556f, 
    0.10074051f, -0.04627126f, 0.01625317f, 0.07835055f, 0.09928574f, 0.15349685f, 0.07511892f, -0.06814467f, 
    -0.10512734f, -0.14411254f, -0.03395290f, 0.22090536f, 0.53298283f, -0.27829257f, 0.21578513f, -0.14575395f, 
    0.10155012f, -0.17015548f, -0.07177307f, 0.04723927f, 0.11261535f, 0.35473901f, 0.34757024f, 0.13091569f, 
    -0.26324296f, -0.16976815f, -0.21580008f, -0.25762960f, 0.11007566f, -0.22771189f, 0.05997773f, 0.19285806f, 
    -0.30058828f, -0.02284625f, 0.08687486f, -0.05407955f, 0.03620403f, -0.03042053f, 0.12267632f, 0.09991830f, 
    0.05233539f, -0.02917513f, -0.04922366f, 0.06976285f, -0.02564604f, 0.02583937f, 0.01278499f, -0.16846174f, 
    -0.06116766f, 0.19518122f, 0.11052436f, 0.21734825f, 0.07742502f, -0.03143490f, 0.05734825f, 0.11739284f, 
    0.22246219f, 0.09252939f, 0.04368608f, 0.13293098f, -0.29449806f, 0.00991463f, -0.26154354f, 0.17176010f, 
    0.08281992f, -0.01554208f, 0.02674362f, -0.27267826f, 0.12745728f, 0.11131740f, 0.13115722f, 0.24016353f, 
    0.02691398f, 0.03810787f, -0.14302747f, 0.15842710f, -0.00396865f, -0.13941908f, 0.13587588f, 0.05412472f, 
    -0.03748413f, -0.03779229f, 0.15153009f, 0.02484828f, 0.03794296f, -0.34466374f, 0.18544872f, -0.10745703f, 
    -0.00300078f, 0.13781950f, -0.05054795f, -0.14526939f, 0.05342738f, 0.06924105f, 0.09863276f, 0.21093109f, 
    -0.17377198f, 0.24088722f, -0.24655890f, 0.04450838f, 0.06368104f, -0.06715295f, 0.02105004f, 0.05032117f, 
    0.16019270f, -0.13776122f, -0.11023743f, 0.09116691f, 0.34856355f, -0.04520464f, 0.45119855f, -0.04790136f, 
    0.18166882f, 0.03149061f, 0.07630754f, -0.03421314f, 0.05636097f, -0.01004867f, 0.05918656f, 0.14506276f, 
    -0.00400582f, -0.25269106f, 0.06221833f, -0.19249366f, 0.16137095f, -0.08617620f, -0.04546406f, 0.06172878f, 
    -0.08049075f, -0.16347522f, 0.02404633f, -0.26287040f, 0.35044414f, 0.49691933f, -0.11421417f, -0.14168318f, 
    -0.10362143f, 0.03873390f, 0.17097577f, 0.01002258f, 0.05518057f, -0.02614700f, -0.26261485f, -0.05412488f, 
    0.47756177f, -0.03202962f, 0.61552727f, 0.33874184f, -0.15305075f, -0.05736247f, -0.22301708f, -0.06521492f, 
    0.15993921f, 0.04767907f, 0.02775406f, 0.04124700f, -0.14403892f, -0.23422317f, 0.06908967f, 0.05295282f, 
    0.16539022f, 0.07997361f, -0.09030521f, -0.11600798f, -0.08804175f, -0.37596855f, -0.13117898f, -0.29447657f, 
    -0.08767356f, 0.02278614f, -0.10773727f, -0.30814070f, -0.11522512f, -0.05275641f, -0.08270238f, 0.13002014f, 
    0.17674583f, 0.05372976f, 0.02862139f, 0.19617689f, 0.14056998f, -0.16962673f, 0.01392928f, -0.12457817f, 
    -0.00448806f, 0.18041776f, 0.07148620f, 0.00265311f, -0.15440133f, 0.01613132f, -0.01681255f, -0.07632793f, 
    0.09229341f, -0.65779305f, 0.00153479f, -0.07443272f, 0.10610306f, 0.08041152f, -0.02690268f, 0.07094102f, 
    -0.09310318f, -0.00978919f, -0.13064383f, -0.14956883f, 0.25702351f, -0.17687592f, 0.23297523f, -0.41780356f, 
    -0.06494705f, -0.05960459f, -0.15281713f, 0.08274911f, -0.01735626f, 0.05413968f, -0.03025030f, -0.15453391f, 
    -0.33747450f, 0.16668066f, 0.07920436f, 0.03346297f, -0.03518755f, -0.13219994f, -0.13175732f, 0.02040911f, 
    0.23006308f, -0.04077420f, 0.08377422f, 0.26877254f, 0.20024620f, -0.03334558f, 0.13528267f, -0.11184580f, 
    0.09473468f, 0.00763770f, 0.02946434f, 0.18314512f, -0.00344322f, -0.09206050f, -0.03651110f, -0.09486438f, 
    0.11065582f, -0.16733944f, -0.17651096f, 0.07545082f, -0.04104671f, 0.09207901f, 0.15395486f, -0.05426615f, 
    0.22612409f, 0.18664874f, 0.22053634f, 0.03388440f, 0.23064652f, -0.00881582f, -0.10901005f, -0.23067531f, 
    -0.03062289f, 0.04090701f, 0.09543247f, 0.02676870f, 0.18958324f, 0.20084417f, 0.24447408f, 0.29024813f, 
    0.35967198f, -0.03089045f, 0.06727383f, -0.14149256f, -0.11322813f, 0.00121011f, 0.11935231f, -0.14647684f, 
    0.05893952f, 0.04145541f, -0.04845877f, 0.11636560f, 0.03169310f, 0.13905878f, -0.14692104f, 0.11218538f, 
    -0.06257137f, 0.07053898f, 0.03611034f, 0.06088138f, 0.04515922f, -0.04048697f, 0.09663960f, 0.15596016f, 
    0.29336825f, 0.11191659f, 0.03791996f, -0.16882269f, -0.00332509f, 0.25303772f, 0.14936396f, -0.15457372f, 
    0.13611063f, 0.00538466f, 0.11699564f, 0.19372509f, -0.14088932f, -0.20216963f, 0.27355063f, -0.16571003f, 
    -0.13809639f, 0.04505223f, 0.00536534f, -0.01987598f, -0.03472969f, 0.15617511f, 0.18205696f, -0.10525143f, 
    0.17911291f, -0.06231967f, -0.11261540f, 0.20175673f, 0.07207960f, -0.06902525f, -0.03918700f, 0.15855573f, 
    -0.06215121f, -0.18941121f, -0.21545672f, -0.20027156f, -0.12292232f, 0.26585475f, 0.01804752f, -0.07243531f, 
    0.04386083f, -0.17229453f, 0.21245967f, 0.00418458f, 0.05292824f, -0.01129941f, -0.18020590f, -0.12711184f, 
    -0.03292605f, 0.26239347f, 0.04863288f, 0.12296987f, -0.14526899f, -0.07650387f, -0.14695503f, 0.28331575f, 
    -0.11623556f, 0.07319985f, 0.20245357f, -0.13488324f, 0.35495391f, 0.03157491f, -0.07244316f, -0.17887133f, 
    -0.04887298f, -0.00398513f, 0.06806009f, 0.12606153f, -0.23381828f, -0.18421458f, -0.17756595f, -0.06715871f, 
    -0.43091989f, -0.10389985f, -0.00765224f, -0.13116038f, -0.15389697f, -0.17159176f, 0.02628525f, 0.15617324f, 
    -0.01434628f, 0.13054678f, -0.07358560f, -0.00118789f, 0.05159292f, -0.21858151f, 0.06704387f, 0.11223134f, 
    0.07362804f, 0.14036179f, 0.10273392f, 0.08361996f, -0.06371430f, 0.10678243f, 0.03445757f, 0.11610957f, 
    0.15231183f, -0.24260399f, -0.04138192f, -0.08577921f, 0.09214374f, 0.13099828f, 0.16046247f, 0.17180051f, 
    -0.03845916f, -0.24689703f, -0.08199703f, 0.09245870f, 0.02441848f, 0.12202147f, 0.15104464f, -0.12137894f, 
    -0.01359491f, -0.06507429f, -0.03967050f, 0.16237046f, -0.06594793f, 0.08811431f, 0.18326184f, -0.07758697f, 
    -0.25746745f, 0.20499054f, 0.21542035f, -0.09775739f, -0.18403916f, -0.07507025f, 0.10189396f, -0.13233022f, 
    0.21556680f, 0.03492257f, 0.15622269f, 0.06467845f, -0.20296161f, -0.24563923f, 0.33977765f, 0.10640641f, 
    -0.13193840f, -0.09966515f, -0.43500900f, -0.08885459f, -0.08376264f, -0.13340254f, -0.13283080f, -0.14442798f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02384191f, 0.16045792f, 0.18461636f, 0.02384640f, -0.07446599f, 0.23931541f, 0.06987982f, -0.03702938f, 
    -0.11980307f, 0.00315390f, 0.04605167f, 0.37556112f, 0.10831162f, 0.19945781f, 0.21857829f, 0.02278906f, 
    -0.02906361f, 0.13880219f, -0.10191109f, -0.02274038f, 0.15404092f, -0.12094520f, 0.10377044f, 0.04157838f, 
    0.08731698f, 0.14197212f, 0.00313167f, 0.01972007f, 0.13860804f, 0.13593340f, -0.03482941f, 0.10463276f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08071024f, -0.20965941f, -0.24456352f, -0.00702795f, 0.54568636f, -0.04279608f, 0.46911609f, 0.35142183f, 
    0.47599849f, 0.15437609f, -0.02243530f, 0.01692721f, -0.16380224f, 0.34918296f, 0.19253506f, 0.10538088f, 
    -0.05324121f, -0.21174385f, -0.30963635f, 0.05090144f, 0.36117631f, -0.11069360f, 0.02888175f, 0.03277017f, 
    -0.14015311f, 0.10567484f, -0.38127762f, 0.01812398f, -0.31516767f, -0.24795339f, 0.02712353f, 0.10672311f, 
    -0.12798524f, 0.08809541f, 0.28651825f, 0.11565939f, 0.48437420f, -0.13070108f, -0.18589237f, 0.19513106f, 
    -0.12739669f, -0.05637899f, 0.02060409f, 0.09477234f, 0.18189500f, -0.14164405f, 0.06140829f, 0.10422068f, 
    -0.18066108f, 0.19176590f, 0.55901396f, 0.01733273f, -0.12443387f, -0.12768950f, -0.19718216f, 0.00084439f, 
    0.33588922f, -0.26838282f, -0.28118962f, 0.09839536f, 0.32634592f, 0.35068464f, -0.00000964f, -0.16709949f, 
    -0.02521659f, -0.01812080f, -0.41520548f, 0.13456309f, 0.11486077f, -0.14622623f, 0.09867791f, -0.01139394f, 
    0.04065926f, 0.07245267f, -0.07398225f, 0.28396639f, 0.33398438f, 0.46019945f, -0.09454677f, 0.06596091f, 
    -0.04340151f, -0.02148973f, 0.52613926f, -0.15918981f, -0.30001053f, 0.28767341f, -0.03413424f, -0.00517041f, 
    0.27749321f, 0.19543299f, 0.22126091f, 0.03968225f, -0.18551069f, 0.21548453f, -0.12024251f, -0.15640564f, 
    0.02238328f, 0.39817831f, -0.06232705f, 0.10520174f, 0.25013217f, -0.67954993f, 0.29333398f, 0.25301161f, 
    0.38411307f, 0.01140955f, -0.16235998f, 0.01652242f, 0.11230066f, -0.04725766f, 0.05288572f, 0.04810527f, 
    -0.12357849f, -0.39816606f, 0.14647071f, 0.05558654f, -0.07898244f, 0.07269321f, 0.07797998f, -0.08538293f, 
    -0.14987323f, -0.08119629f, 0.19939663f, -0.10247017f, -0.27519605f, 0.23083857f, 0.37367529f, 0.29909310f, 
    -0.04005198f, 0.47798517f, -0.22831905f, -0.00185064f, -0.17328149f, -0.41802159f, -0.10678370f, 0.21237986f, 
    -0.14416106f, 0.12039582f, 0.06240200f, 0.35275009f, -0.46386114f, 0.29554671f, 0.15985297f, -0.06166659f, 
    0.04618881f, -0.00387765f, -0.08295596f, 0.09809537f, -0.37467659f, -0.04227891f, 0.23718816f, -0.00136671f, 
    0.01307575f, -0.64515877f, 0.00285155f, 0.04808198f, -0.06975470f, 0.23922640f, 0.00012071f, 0.56145686f, 
    -0.12250420f, -0.15114565f, 0.66068083f, 0.15863402f, -0.03456290f, 0.16303469f, -0.18207830f, 0.01312338f, 
    -0.09790649f, 0.14638485f, -0.06004202f, 0.18705817f, 0.30020988f, -0.11423981f, 0.08837336f, 0.06062812f, 
    -0.12253066f, -0.07080827f, 0.04638216f, -0.02823841f, 0.02409010f, -0.18885456f, 0.21014076f, 0.13746108f, 
    0.18264361f, 0.02402762f, -0.22365591f, 0.05267815f, 0.35948059f, -0.02981866f, 0.00732072f, -0.11058240f, 
    0.09237733f, -0.42138985f, 0.68670762f, -0.16593245f, -0.18999708f, 0.10447545f, -0.43319538f, -0.18823782f, 
    -0.17536843f, 0.14964700f, 0.05479118f, 0.28200254f, 0.21811903f, 0.18084770f, 0.31862906f, 0.08115275f, 
    0.00347146f, 0.16702555f, 0.35394478f, 0.01662693f, -0.25800675f, 0.25447515f, -0.12621023f, -0.13891438f, 
    0.34473607f, -0.10432348f, 0.30362335f, -0.16101690f, -0.57692623f, -0.19631763f, 0.04657627f, -0.17385261f, 
    0.10530431f, 0.39896008f, -0.23739043f, 0.12909511f, 0.21858823f, -0.25340828f, 0.38878012f, 0.20281525f, 
    0.03542857f, 0.01361667f, -0.04542829f, -0.10838631f, -0.10464925f, 0.01462131f, 0.14763823f, 0.16393998f, 
    0.16386835f, -0.42230240f, -0.29241708f, 0.03833499f, 0.09984767f, 0.18338701f, 0.28600875f, -0.09308637f, 
    -0.19824554f, 0.12305155f, 0.03142525f, -0.13100290f, 0.34124655f, -0.06854020f, 0.24757364f, 0.16400124f, 
    -0.16587822f, -0.57722133f, -0.06567109f, 0.02972676f, -0.31744319f, 0.48780116f, -0.01437506f, 0.40955278f, 
    0.24561258f, 0.12906358f, -0.08556180f, 0.12713610f, 0.35514593f, -0.04236466f, 0.16137154f, -0.01156983f, 
    -0.13777113f, -0.15589009f, -0.03471257f, 0.06648152f, -0.06587604f, -0.14189883f, 0.08542442f, -0.14510801f, 
    -0.14161253f, 0.17795238f, 0.03445299f, -0.12770477f, 0.96308291f, 0.33694029f, 0.33496460f, -0.00849231f, 
    -0.01208276f, 0.34532186f, 0.37936941f, -0.12328869f, 0.07121789f, 0.01917460f, 0.07340489f, 0.14097929f, 
    0.14606085f, 0.13424447f, -0.00356580f, -0.00338866f, -0.26353854f, -0.02584761f, 0.35051924f, 0.08750594f, 
    -0.05277021f, 0.09496867f, 0.35967910f, 0.08155735f, -0.33158222f, -0.18312493f, 0.05799999f, -0.09551400f, 
    -0.21170595f, -0.64948314f, 0.45707819f, 0.01387529f, -0.14776072f, 0.43573281f, -0.02539249f, 0.47082043f, 
    0.14218356f, 0.27368176f, 0.13263598f, 0.10684190f, 0.14060549f, -0.01864791f, 0.10305208f, -0.12485035f, 
    -0.32266483f, -0.09421316f, 0.03755667f, -0.13661668f, 0.40723974f, -0.04311158f, -0.08616424f, 0.08174086f, 
    -0.12692598f, -0.12126034f, 0.27308235f, -0.07140505f, -0.18893811f, 0.39722741f, 0.29990855f, 0.16808532f, 
    0.31137553f, 0.11118045f, 0.15965062f, -0.16945775f, 0.09684182f, 0.23235308f, 0.04840785f, -0.08266062f, 
    0.08218262f, -0.40867242f, -0.20774560f, -0.01225765f, 0.37930056f, -0.18877438f, 0.02700055f, 0.32698196f, 
    0.16425806f, -0.07783756f, 0.00611862f, 0.18949154f, -0.11536128f, -0.15431556f, 0.16926213f, -0.16881993f, 
    -0.05084051f, 0.60098368f, -0.37924612f, 0.09729907f, -0.35202503f, -0.54352063f, -0.22083808f, 0.06556438f, 
    0.40092322f, 0.15105884f, 0.04965948f, 0.03474723f, -0.15326415f, 0.03891744f, 0.31652251f, -0.03411988f, 
    0.16355255f, 0.22877029f, 0.45496270f, -0.04027102f, 0.14594933f, -0.37634683f, -0.00850198f, -0.32728881f, 
    -0.15920004f, 0.06783504f, -0.14571317f, -0.01627808f, 0.30923182f, -0.07767736f, -0.08959745f, 0.13371795f, 
    0.12919295f, -0.19234408f, -0.09855355f, -0.02143309f, 0.33301309f, 0.07948225f, 0.20971146f, -0.00765493f, 
    0.25987801f, 0.40384567f, -0.04695968f, 0.12828860f, 0.17728485f, 0.02656317f, 0.24773853f, -0.36528936f, 
    0.11325621f, -0.04744942f, 0.11384957f, 0.09462376f, 0.04903224f, -0.18770112f, 0.09354105f, -0.13308312f, 
    -0.15133148f, -0.12258948f, -0.12345662f, -0.18579318f, 0.13427073f, -0.14832178f, 0.05892397f, -0.13893627f, 
    -0.08458892f, -0.17587109f, -0.19223556f, -0.10247448f, -0.09215009f, -0.19637333f, -0.01627905f, 0.09452587f, 
    0.06977632f, 0.10220396f, 0.07810928f, 0.07137151f, -0.10187330f, -0.07762022f, -0.01311449f, -0.10344186f, 
    -0.14153044f, -0.16720016f, 0.39970955f, -0.11504443f, -0.29176861f, -0.29990399f, 0.02865982f, 0.34889257f, 
    0.38765445f, -0.04905707f, 0.07142361f, -0.14062828f, 0.08730716f, -0.11464540f, 0.40571487f, -0.00240293f, 
    0.09336635f, -0.22591113f, -0.31302977f, 0.04327249f, -0.10902699f, 0.20698051f, 0.15075256f, -0.05874146f, 
    -0.05538095f, 0.14247942f, 0.48055455f, 0.06305768f, -0.16516970f, 0.18666661f, 0.67126876f, 0.01965534f, 
    -0.15967202f, 0.13780469f, 0.23501374f, -0.01950862f, -0.10248856f, 0.21513222f, 0.02928831f, 0.25329176f, 
    0.06287881f, -0.15223327f, -0.17886910f, 0.24623273f, -0.49986199f, -0.06621203f, 0.30202118f, -0.10865135f, 
    0.10239646f, 0.17900674f, -0.00400895f, 0.09516868f, 0.15129167f, -0.46320146f, -0.28603157f, 0.12894709f, 
    -0.46687230f, -0.57455921f, 0.00109780f, 0.06162343f, 0.17955776f, 0.10629263f, -0.13370025f, 0.27504501f, 
    -0.09849305f, 0.06398587f, -0.14818007f, -0.00524865f, 0.04634243f, -0.16686420f, -0.12266357f, 0.16516030f, 
    -0.07977740f, 0.08021561f, 0.05363267f, -0.11138310f, -0.19174086f, -0.11485700f, -0.02334746f, -0.14728454f, 
    -0.13409382f, -0.15637690f, 0.05802051f, 0.11682725f, -0.05395129f, 0.01565063f, -0.21226113f, -0.06551944f, 
    -0.00556647f, -0.12648433f, -0.10135632f, 0.10223384f, -0.16602096f, 0.13661501f, 0.09211693f, -0.17706609f, 
    -0.00570104f, -0.13254146f, -0.34820253f, -0.01165783f, 0.26532370f, 0.07464392f, 0.26058710f, 0.34269804f, 
    0.19093637f, 0.15728712f, 0.02975136f, -0.14597490f, 0.13302051f, 0.20492153f, -0.20097011f, -0.15030809f, 
    0.02311014f, -0.17013815f, 0.02958348f, -0.16799510f, -0.23281632f, -0.15334255f, 0.15763274f, -0.03767224f, 
    -0.27485240f, -0.19767511f, -0.00455040f, 0.10324610f, 0.51500624f, -0.12413622f, 0.26135120f, 0.36776149f, 
    0.07415222f, 0.14064921f, -0.11093260f, 0.02417104f, 0.34546494f, 0.18523793f, -0.12445013f, -0.02671214f, 
    -0.17930771f, 0.02828119f, 0.13928093f, 0.10557404f, -0.13761967f, -0.28134060f, 0.05147570f, 0.02319567f, 
    0.17385438f, -0.36352226f, 0.10387184f, 0.01994563f, 0.13238212f, -0.02591413f, -0.11482381f, 0.11472341f, 
    -0.21366455f, 0.05464049f, -0.27836460f, 0.06584659f, -0.15935218f, -0.25556868f, -0.21481939f, -0.05344050f, 
    -0.16727780f, 0.00031120f, -0.29540622f, 0.17718175f, 0.11469506f, 0.38128877f, 0.05818349f, 0.17320271f, 
    -0.04651055f, 0.11033398f, -0.04417769f, -0.02536418f, 0.05823491f, -0.05578206f, -0.14973956f, 0.01628904f, 
    0.11168829f, -0.05631832f, -0.01964682f, -0.09193032f, 0.13343963f, 0.15548745f, -0.33309972f, 0.02405904f, 
    -0.24185874f, -0.28434750f, -0.35082018f, -0.03470078f, 0.28043509f, 0.22213517f, -0.13150668f, -0.19140527f, 
    0.10959557f, 0.35267013f, -0.09244512f, 0.09548657f, -0.36677080f, 0.31825563f, 0.18473032f, -0.14534043f, 
    -0.39485800f, 0.01575224f, 0.06138264f, -0.03938875f, 0.18854406f, 0.18228920f, -0.01629863f, 0.00800476f, 
    -0.11435717f, 0.02690752f, 0.11720259f, -0.13783750f, -0.14516149f, 0.10800334f, 0.40467352f, -0.10887434f, 
    -0.11689916f, 0.29704762f, 0.04565376f, -0.15641499f, 0.72638470f, 0.05906790f, 0.30117396f, 0.25824112f, 
    0.13403583f, -0.21108478f, -0.20688006f, 0.06169866f, 0.12386258f, -0.20222585f, -0.04085979f, 0.37901333f, 
    -0.01201458f, -0.04005778f, 0.05600599f, -0.23749001f, -0.05380473f, -0.03636828f, 0.07081142f, -0.00161971f, 
    0.15340687f, 0.19940580f, 0.10154175f, 0.15832244f, -0.50333297f, 0.15854679f, 0.29465625f, 0.16864632f, 
    0.23386420f, -0.00107692f, -0.35395211f, 0.08545963f, 0.17983232f, -0.35185802f, 0.52957118f, -0.10461969f, 
    0.05339605f, -0.40737355f, 0.00646221f, 0.15534414f, 0.19144936f, 0.02245229f, 0.07462166f, 0.20007628f, 
    0.08669924f, 0.08303606f, 0.16131993f, -0.16481060f, 0.25519642f, 0.19019340f, -0.30848554f, -0.11337528f, 
    0.17063890f, -0.03134480f, 0.48707461f, -0.01289978f, -0.36881408f, 0.21922030f, 0.01563296f, -0.09378380f, 
    0.16702454f, -0.17925538f, 0.04560716f, 0.05802412f, -0.30218211f, -0.29353625f, -0.18150309f, -0.30136397f, 
    0.16221909f, 0.52292764f, 0.07130308f, 0.10933468f, -0.08918533f, 0.26187438f, 0.13424762f, -0.03895386f, 
    -0.13802406f, -0.13212024f, 0.15629338f, -0.23921825f, -0.07430183f, -0.15548413f, 0.11352626f, -0.08701117f, 
    0.11470619f, 0.10243319f, 0.18726605f, 0.04005873f, 0.31528169f, -0.07903887f, 0.13408095f, -0.08410496f, 
    0.03259840f, -0.06964953f, 0.02626986f, 0.07104951f, 0.70797861f, 0.23783749f, 0.12475948f, 0.21589473f, 
    0.04391967f, 0.10847378f, 0.16443315f, -0.08541148f, -0.50984704f, 0.23795125f, 0.12652355f, -0.39956975f, 
    0.18853173f, -0.04000921f, 0.01792413f, 0.30041716f, -0.05872361f, 0.17750657f, 0.29299977f, -0.04181054f, 
    0.10941742f, -0.06925594f, -0.56239361f, 0.00721671f, 0.25331107f, -0.06038506f, 0.34893671f, -0.11997541f, 
    -0.07576969f, 0.14711879f, -0.08841053f, 0.12833875f, -0.11845711f, -0.11239342f, -0.01325938f, 0.32408944f, 
    -0.04214725f, -0.06915737f, 0.05144497f, -0.04514002f, -0.00242081f, -0.17833956f, -0.12941290f, 0.05683623f, 
    -0.14883713f, 0.09133907f, -0.06297815f, -0.05281011f, 0.01230236f, -0.05666548f, -0.09619710f, 0.04568571f, 
    -0.03241734f, -0.17422725f, -0.05796639f, 0.05853124f, 0.06279632f, -0.07882684f, -0.17609960f, 0.09838543f, 
    0.01117518f, 0.07620539f, 0.09734004f, 0.10780274f, 0.11507533f, 0.06846583f, -0.10828615f, -0.07966015f, 
    -0.04184162f, 0.35041198f, -0.03792336f, -0.13928564f, -0.10851093f, -0.09535635f, -0.05786467f, -0.51494318f, 
    -0.26062286f, -0.09287558f, 0.01519678f, 0.33259976f, 0.15883540f, 0.01536223f, 0.09137340f, 0.03604504f, 
    0.14060639f, 0.08860599f, -0.05070343f, 0.07084676f, 0.59686965f, -0.08365627f, 0.13250774f, 0.07593830f, 
    0.07244541f, 0.18151715f, 0.16215619f, 0.02357689f, -0.12891391f, 0.10463856f, -0.37769687f, 0.07284762f, 
    -0.12715508f, 0.00673289f, 0.21654208f, -0.07121105f, -0.03263151f, -0.19825065f, -0.07165436f, 0.20716444f, 
    -0.03623617f, 0.02773170f, 0.06935040f, 0.25310332f, -0.17140204f, -0.10768392f, 0.37158754f, 0.15113942f, 
    -0.13302436f, 0.12865755f, 0.10526580f, 0.06931211f, -0.25611743f, -0.25514284f, 0.09220247f, -0.08868822f, 
    -0.01578739f, -0.31575066f, 0.33105946f, -0.05729510f, -0.05728577f, 0.22795941f, 0.11051975f, 0.01329794f, 
    -0.08178845f, -0.04403690f, 0.06276495f, 0.02810990f, 0.78369534f, -0.07909164f, 0.23308171f, 0.29398280f, 
    0.52542400f, 0.06324179f, -0.03221904f, -0.01895613f, -0.05667556f, 0.21430521f, -0.20356618f, -0.02650240f, 
    -0.09384838f, 0.10094664f, 0.13541645f, -0.14196406f, 0.47136328f, -0.04972123f, -0.31142914f, 0.03215122f, 
    0.26610693f, -0.16044018f, -0.52357739f, 0.04627667f, 0.07698505f, -0.00196020f, -0.25008938f, -0.18957302f, 
    0.03124412f, 0.65561497f, 0.11641254f, 0.03092895f, 0.04288523f, -0.06283104f, 0.16568181f, -0.33860895f, 
    -0.11859426f, 0.15978676f, 0.07982275f, 0.16991341f, -0.15308180f, 0.26048598f, 0.18148607f, 0.13871537f, 
    0.04943994f, -0.22381748f, -0.26665059f, 0.15884072f, 0.72049290f, 0.07283710f, 0.04261392f, 0.16997086f, 
    -0.04840362f, 0.18935104f, -0.08216572f, 0.08072231f, -0.11174215f, -0.23011529f, -0.31687656f, 0.15324524f, 
    -0.07994460f, -0.31683996f, 0.26656908f, -0.13457939f, -0.17511728f, 0.10246374f, 0.00775026f, 0.05080615f, 
    0.45769134f, -0.13861120f, 0.09041914f, 0.13082409f, 0.00418263f, 0.02937282f, 0.36519513f, -0.14657003f, 
    0.07831573f, 0.04946296f, -0.40359688f, -0.13601518f, 0.17392766f, -0.18018894f, -0.16300736f, 0.10237002f, 
    0.25157014f, 0.17363924f, -0.09600953f, -0.14253384f, 0.23194122f, -0.14806604f, 0.00199776f, -0.05884844f, 
    0.01122927f, 0.26250693f, -0.14096919f, 0.03655105f, 0.08021592f, -0.62366968f, -0.05062296f, 0.44926584f, 
    0.10302005f, 0.10842460f, -0.14672557f, -0.22562392f, 0.16451736f, -0.16821337f, 0.14390552f, -0.03405929f, 
    0.10940946f, -0.64812416f, -0.07149144f, 0.06036616f, -0.12172884f, 0.24896188f, 0.16543594f, -0.08511718f, 
    0.10935792f, 0.09542987f, 0.42833719f, 0.01400525f, -0.16955349f, 0.17789367f, 0.30501303f, 0.07507490f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.11527032f, -0.13383682f, 0.06177997f, -0.15667458f, 0.17291065f, 0.25432441f, -0.03687878f, 0.13763829f, 
    0.24273644f, -0.15559921f, 0.01362338f, 0.08313971f, 0.08997020f, -0.01884363f, 0.09950323f, -0.14282773f, 
    -0.16167957f, -0.08345950f, 0.29916993f, 0.22966579f, 0.17221408f, 0.02573908f, -0.16732262f, 0.01606762f, 
    0.26283666f, -0.02457096f, 0.31071889f, -0.12754679f, -0.06275033f, 0.39926568f, 0.15779400f, -0.19868146f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.51113862f, 0.01849649f, 0.07096113f, 0.18499416f, -0.23431209f, 0.09039403f, 0.34333774f, -0.26426801f, 
    -0.20769879f, -0.26222569f, 0.00135414f, -0.65243471f, 0.02417528f, -0.04147099f, 0.20948036f, -0.00471391f, 
    0.04883835f, -0.05727007f, -0.83061796f, 0.30587852f, -0.05652655f, 0.18249407f, 0.35401747f, -0.21541730f, 
    -0.14178130f, 0.03014347f, -0.33873439f, -0.45744669f, -0.47735077f, -0.59305114f, -0.30291501f, 0.11651990f, 
    -0.70303762f, 0.03527580f, 0.35406098f, -1.01190066f, 0.39382994f, 0.08366811f, 0.24016599f, -0.41075480f, 
    0.01052342f, 0.31093442f, 0.16417232f, 0.10568613f, 0.01895074f, -0.15350911f, -0.38791257f, 0.28677532f, 
    -0.06378980f, -0.25420374f, -0.26568794f, -0.26985914f, 0.26905641f, -0.55441689f, 0.18714233f, -0.19258077f, 
    -0.17611432f, 0.00635972f, 0.08083411f, 0.29768297f, -0.35956112f, -0.06638333f, -0.00669343f, -0.66499937f, 
    0.26533666f, -0.20446739f, -0.16376849f, -0.28733557f, -0.27514765f, 0.13099940f, -0.45041534f, 0.04811562f, 
    0.18281488f, -0.95694023f, -0.04463575f, 0.01267720f, 0.09404086f, 0.08695971f, -0.24101211f, -0.60781771f, 
    -0.12045945f, 0.17484896f, -0.23512977f, -0.16071735f, 0.41735360f, 0.41499695f, -0.26347667f, 0.13438480f, 
    0.13369812f, -0.15167259f, -0.09412796f, -0.98280638f, 0.14233904f, 0.00763273f, 0.11937262f, -1.06489992f, 
    0.34793088f, -0.13746412f, 0.24637796f, -0.00378223f, -0.31627083f, -0.29925406f, -0.20163782f, 0.22018778f, 
    -0.19700716f, -0.13172142f, -0.05118328f, -0.34862769f, -0.00511240f, 0.15008156f, 0.00170104f, -0.93190295f, 
    -0.11196455f, 0.14193435f, -0.48395479f, -0.76910627f, -0.21408740f, -0.10737174f, 0.25667968f, -0.28821269f, 
    -0.59597266f, 0.01473456f, -0.20254537f, -0.09577592f, 0.64814568f, -0.12862089f, -0.02500972f, -0.01032714f, 
    -0.21006238f, -0.21262220f, 0.04385834f, 0.28868139f, -0.47129473f, -0.29121703f, -0.29131055f, 0.29176486f, 
    -0.33356577f, -0.34905407f, 0.12739955f, 0.45676613f, 0.12028814f, -0.07554308f, 0.08909918f, 0.31807414f, 
    0.08259048f, -0.13371997f, -0.28044710f, -0.50248802f, 0.21292377f, -0.06036514f, -0.11204945f, 0.25407544f, 
    -0.21372899f, 0.05257547f, 0.06018926f, 0.14066593f, -0.30103981f, 0.06165447f, -0.30045751f, 0.32076985f, 
    -0.16681199f, -0.37796876f, -0.12643372f, -0.25746670f, -0.41894180f, 0.18848184f, 0.28212869f, -0.13743058f, 
    -0.08381248f, -0.04114382f, -0.03102323f, -0.01181444f, 0.26109040f, -0.13586287f, 0.37752649f, -0.03766222f, 
    0.07552306f, -0.58220261f, -0.28576863f, 0.09788805f, 0.04217313f, -0.28388563f, -0.34920081f, -0.21355157f, 
    0.24737746f, 0.07652520f, 0.18054838f, 0.06540151f, -0.60213774f, 0.20458776f, 0.31704715f, 0.08903195f, 
    0.03765982f, -0.41904303f, -1.10357428f, 0.12674268f, -0.05457476f, 0.01318750f, -0.51468104f, 0.20617300f, 
    0.19023159f, 0.07689430f, -0.96411121f, -0.73697096f, -0.43746132f, -0.01077805f, 0.05416729f, 0.25099492f, 
    -0.20778660f, 0.16040911f, -0.07450802f, -0.35222459f, 0.18611349f, -0.37871012f, -0.23903795f, 0.38955405f, 
    0.27184561f, -0.09386183f, -0.19383459f, -0.32118115f, -0.17816830f, 0.20930700f, 0.12989277f, -0.60826433f, 
    0.16999692f, 0.07841147f, -0.49960592f, 0.29054302f, 0.04190937f, -0.19809112f, -0.11238933f, -0.25047636f, 
    -0.13795190f, 0.12622145f, -0.60181558f, 0.50630593f, -0.58579743f, -0.13336785f, 0.32253760f, -0.09710857f, 
    -0.12854697f, 0.02080348f, -0.34008801f, -0.57093608f, -0.51699299f, 0.37842032f, -0.21371122f, -0.21908826f, 
    -0.19669347f, -0.15577717f, -0.42506835f, -0.02775726f, 0.25533035f, -0.24875745f, 0.17315689f, -0.03807043f, 
    0.18382746f, -0.14795397f, 0.12674844f, -0.14950785f, -0.18817630f, 0.02819587f, -0.06948723f, -0.57222718f, 
    -0.07242551f, -0.23093691f, -0.72218722f, 0.18385473f, 0.05386920f, 0.02884254f, -0.31873044f, -0.23774786f, 
    0.10866834f, -0.57822400f, 0.40936339f, 0.51790226f, -1.13490796f, -0.54207158f, -0.16097498f, -0.54015380f, 
    0.05821094f, -0.06338508f, 0.20511870f, -0.14138769f, 0.52044976f, 0.23231235f, 0.30579692f, -0.08279634f, 
    -0.16120300f, -0.15795679f, -0.14706829f, 0.14278053f, 0.15418452f, 0.05065815f, -0.72159916f, 0.12144788f, 
    0.21445435f, -0.07555199f, -0.12216947f, -0.03523437f, 0.14715597f, 0.08877020f, 0.39610100f, -0.39589024f, 
    -0.23538597f, 0.18190864f, 0.01414511f, 0.11772096f, 0.18522668f, 0.31207517f, -0.71056324f, 0.20464538f, 
    -0.02861186f, -0.00099410f, -0.34200820f, 0.06268138f, -0.64130586f, -0.33109891f, 0.10886455f, -0.02018072f, 
    -0.17931075f, 0.54096711f, -0.19986382f, -0.32280770f, 0.03680928f, 0.33133525f, -0.06629328f, -0.29788557f, 
    -0.72511119f, -0.10997465f, 0.17092913f, -0.85151571f, 0.30018714f, 0.03145119f, -0.75519216f, -0.40132463f, 
    -0.06703929f, -0.43466309f, -0.19907397f, -0.78640062f, -0.25394598f, -0.10103829f, 0.05578521f, 0.44433254f, 
    -0.20998776f, 0.01003185f, 0.15625928f, -0.27063605f, 0.52455932f, 0.28949583f, -0.11163766f, -0.29591092f, 
    0.26670849f, -0.81773269f, 0.30170971f, 0.12303292f, 0.54596442f, -0.58968711f, -0.28447944f, 0.04448647f, 
    -0.54399085f, 0.04329565f, -0.11834135f, -0.33069187f, -0.33269751f, 0.08838294f, -0.32287425f, -0.24345054f, 
    0.01496486f, -0.00009250f, 0.15574986f, -0.71942830f, -0.13378841f, -0.00710701f, -0.01214537f, -0.35734439f, 
    0.32220215f, -0.18607235f, 0.19215384f, -0.26616690f, -0.26238909f, 0.41967812f, -0.10082959f, 0.09587092f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.25630629f, -0.25553536f, -0.04641526f, -0.03805415f, -0.02011183f, 0.06814301f, 0.03303625f, -0.20461045f, 
    0.35056242f, 0.10020668f, 0.00638461f, 0.05695688f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
