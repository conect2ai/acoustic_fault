#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.59443063f, 0.69589782f, -0.49186406f, -0.33336511f, 0.18659073f, 0.41325793f, -0.61370748f, -0.26568753f, 
    -0.54799670f, -0.32039163f, 0.36489633f, 0.36641294f, -0.05273792f, 0.12521499f, 0.06488521f, -0.18044427f, 
    -0.24041584f, -0.34422991f, -0.37774330f, 0.05787813f, -0.14266475f, 0.28784117f, 0.25004900f, -0.03090632f, 
    0.03695182f, -0.17005821f, 0.12316276f, 0.51519960f, 0.42904669f, 0.14564510f, -0.35062709f, -0.07318351f, 
    -0.43447039f, -0.43022752f, -0.46273866f, 0.47764036f, -0.08372343f, -0.14396366f, 0.35834315f, 0.35466436f, 
    -0.40295762f, 0.20154963f, 0.16922025f, 0.00371204f, 0.51802641f, 0.40837383f, 0.01739453f, 0.18168199f, 
    0.26758510f, 0.24129574f, -0.77387983f, 0.20056193f, -0.41982415f, 0.79729795f, 0.19927859f, 0.26946995f, 
    0.61177528f, 0.34200740f, 0.05702914f, 0.04579029f, -0.24387148f, -0.27320775f, -0.08056730f, 0.23193093f, 
    -0.25130171f, 0.02738191f, 0.09592703f, 0.14632496f, -0.02793345f, -0.22250660f, -0.07154429f, 0.03877124f, 
    -0.35877666f, -0.17939602f, -0.10666591f, -0.60597295f, -0.55896372f, -0.07255002f, 0.13523006f, -0.40557933f, 
    0.48826972f, 0.66964757f, 0.29642132f, -0.42237273f, -0.14187941f, -0.34691077f, 0.13029838f, -0.20356521f, 
    0.25053898f, 0.21554723f, -0.43513894f, 0.03812777f, -0.21841466f, -0.03563105f, 0.01521735f, 0.04640323f, 
    -0.13584679f, 0.18575777f, -0.03717024f, 0.02073732f, 0.22972259f, 0.77738994f, 0.02550382f, 0.23745847f, 
    0.83624202f, 0.89447957f, -0.18399818f, -0.64805949f, -0.04349572f, -0.06516694f, -0.37679559f, 0.00555806f, 
    -0.27519730f, 0.28615737f, -0.48114082f, 0.06050039f, -0.02625824f, 0.08025128f, 0.11101120f, -0.18035562f, 
    0.18804808f, 0.23493004f, 0.02926980f, -0.11961337f, 0.00604702f, -0.04004081f, 0.54199165f, 0.49716902f, 
    -0.89586335f, -0.32799724f, 0.21893491f, 0.17958041f, -0.53065377f, -0.53913850f, -0.51249206f, 0.11289923f, 
    0.31838492f, -0.25752935f, 0.20270102f, -0.25046325f, 0.01664582f, 0.02202440f, 0.07985615f, -0.15086745f, 
    0.09149487f, -0.13497727f, -0.06291367f, 0.02414119f, -0.17434458f, 0.13852090f, 0.40344319f, 0.07009528f, 
    -0.61984998f, -0.85016835f, -0.54159003f, 0.62868071f, 0.30501172f, -0.08024421f, 0.06718092f, 0.37057889f, 
    -0.32698524f, -0.18332638f, -0.29235575f, 0.13743544f, -0.14561048f, 0.00212500f, -0.06920571f, 0.08582693f, 
    0.01326637f, 0.21072212f, -0.01720416f, -0.21501192f, -0.31972945f, -0.07037123f, 0.17970502f, -0.22247455f, 
    0.71618831f, 0.71448112f, 0.52802002f, -0.12565491f, -0.82457137f, -0.23391038f, -0.28648737f, -0.23923050f, 
    -0.26648632f, 0.22805345f, 0.20835087f, 0.01890882f, 0.05395252f, 0.30666891f, 0.12924255f, 0.06164641f, 
    0.09409729f, 0.16026343f, -0.03597672f, 0.13519852f, 0.10145842f, -0.09038366f, -0.26601908f, -0.18126860f, 
    -0.40599337f, -0.36404663f, -0.42620501f, -0.31163770f, 0.02316298f, -0.14296144f, 0.03952860f, 0.14990346f, 
    0.06211806f, -0.30895823f, -0.47036150f, -0.03039567f, -0.38426337f, 0.00216231f, -0.24631546f, -0.37224519f, 
    0.43487272f, 0.11245352f, -0.06725147f, -0.15924127f, 0.52963567f, 0.14228514f, 0.09216582f, -0.15312457f, 
    -0.03931906f, -0.28617859f, -0.39168039f, -0.06917030f, 0.03340093f, -0.02235505f, -0.22726774f, -0.20241961f, 
    0.44895339f, -0.36412099f, -0.49384457f, -0.00395923f, -0.12356742f, -0.42623636f, -0.42651701f, -0.49469072f, 
    0.37791803f, 0.12829599f, -0.52937192f, -0.02596633f, 0.12961297f, -0.27813840f, -0.24962744f, -0.14019142f, 
    0.27644393f, -0.25122717f, -0.60278600f, -0.72104239f, -0.49827173f, 0.42914829f, 0.07457773f, 0.59160918f, 
    0.04778149f, -0.06726079f, 0.51613784f, -0.46032342f, -0.22027910f, 0.30989075f, -0.17389029f, 0.12399035f, 
    -0.33551511f, -0.01912839f, 0.22897430f, -0.29615340f, -0.13972136f, -0.14079458f, -0.10640565f, -0.03851720f, 
    0.14434345f, 0.11891375f, -0.11086752f, -0.73028761f, -0.11772819f, -0.43127334f, -0.30083710f, -0.30617809f, 
    0.51141632f, 0.94564426f, 0.25053427f, 0.36045939f, 0.59105742f, -0.17144872f, -0.13810408f, 0.00876007f, 
    -0.41791856f, 0.00967089f, 0.19800332f, 0.01046939f, -0.06824896f, -0.13851121f, -0.11377835f, 0.00132160f, 
    -0.07468357f, 0.08788422f, -0.16270977f, 0.33267644f, 0.82647204f, 0.60926491f, 0.39909944f, 0.76575303f, 
    0.30445656f, -0.41689092f, -0.41811186f, 0.16803688f, -0.25976515f, 0.12944917f, 0.13045529f, 0.13684796f, 
    0.01196839f, -0.04317752f, 0.18739492f, -0.07179133f, 0.14990197f, 0.34374031f, -0.30063069f, 0.23955080f, 
    -0.01723140f, -0.18017177f, 0.26924828f, 0.01970851f, 0.00105939f, 0.85229141f, 0.63205457f, 0.28312615f, 
    -0.51257992f, -0.30889371f, 0.29801598f, 0.24448492f, 0.03095361f, 0.21749847f, 0.19409281f, 0.41337112f, 
    0.28176636f, 0.11493511f, 0.02225578f, -0.19557546f, 0.12670237f, 0.15500899f, 0.27053902f, 0.03662638f, 
    -0.40932152f, 0.21860041f, 0.24178319f, 0.21280068f, 0.03240207f, 0.23254921f, 0.82142651f, 0.59720731f, 
    0.41042474f, 0.57717150f, 0.58472884f, 0.00418404f, 0.40845570f, 0.47631451f, 0.18987042f, -0.21472663f, 
    -0.24530418f, -0.04394364f, 0.15084246f, 0.07075834f, -0.26210925f, 0.33568174f, -0.22299398f, -0.08340401f, 
    0.11053881f, -0.26750061f, 0.04625198f, -0.35854834f, 0.19801578f, 0.11151852f, -0.17230114f, -0.67207366f, 
    -0.54728144f, -0.54841137f, -0.59350848f, -0.50356823f, -0.40818092f, -0.18432817f, -0.20354708f, -0.11376103f, 
    -0.21029764f, -0.13932146f, 0.18815985f, 0.08521472f, 0.39508393f, 0.10004175f, 0.35823447f, -0.09744879f, 
    0.13806431f, 0.20385915f, -0.08055524f, 0.10445920f, -0.02277435f, -0.04428696f, 0.01415824f, 0.26373973f, 
    -0.14864033f, 0.03822588f, 0.33035284f, 0.22573586f, -0.09559860f, -0.57876027f, 0.69616389f, 0.54189038f, 
    -0.30269495f, 0.28050652f, 0.17327444f, 0.27939010f, 0.41309926f, 0.02571348f, 0.34925348f, -0.00643704f, 
    0.12681018f, -0.17695154f, 0.30056712f, -0.04053221f, 0.19016796f, -0.37189585f, 0.15114541f, -0.07299853f, 
    -0.12543093f, 0.70372063f, 0.66563165f, 0.59883577f, 0.35414845f, 0.28659281f, -0.11526629f, -0.55979991f, 
    -0.06701963f, 0.02206845f, 0.19354449f, -0.05565625f, 0.00852903f, -0.31530148f, 0.08718226f, -0.16629218f, 
    0.23872723f, -0.04323229f, -0.19740807f, -0.03449257f, 0.03667210f, -0.00091558f, 0.39673254f, 0.23308021f, 
    -0.22469206f, 0.43927723f, -0.64100009f, -0.03069543f, -0.90308595f, -0.68126369f, 0.43791762f, -0.55099839f, 
    0.10474639f, 0.87243420f, 0.17010787f, 0.09059096f, 0.21091229f, -0.11118288f, 0.10672614f, -0.17442992f, 
    0.29145691f, -0.09811353f, 0.03094942f, -0.37749749f, 0.09357338f, -0.12270898f, -0.28058454f, -0.17911692f, 
    -0.17419724f, -0.07595279f, -0.06374700f, 0.55733013f, -0.06114516f, 0.35605466f, 0.68090367f, 0.45999038f, 
    0.39851463f, 0.34399956f, 0.09010967f, -0.03520819f, 0.43403548f, -0.47612730f, -0.55249387f, -0.34300452f, 
    0.00518527f, 0.14809476f, -0.41723844f, -0.10383471f, -0.05525080f, -0.00959929f, -0.22286299f, 0.13971411f, 
    0.21685228f, -0.20921579f, 0.29089269f, -0.09058017f, 0.74759573f, 0.66815698f, -0.51034749f, -0.36829475f, 
    -0.62073445f, 0.15127505f, -0.40593210f, 0.10873260f, -0.04931623f, -0.12342023f, 0.54820657f, -0.06081218f, 
    -0.21081175f, 0.07160778f, 0.02764771f, 0.16234122f, -0.06126750f, 0.17179172f, -0.14077275f, 0.20049833f, 
    -0.09363817f, 0.00924016f, -0.00788346f, -0.20649061f, -0.23990345f, 0.37512890f, 0.36399654f, -0.44059765f, 
    0.53283364f, 0.60698909f, 0.09193917f, -0.09121194f, -0.48442805f, -0.22686315f, 0.13647416f, 0.36726302f, 
    0.01856503f, 0.10406641f, 0.06664508f, -0.10205764f, -0.03556081f, -0.04055364f, 0.43696672f, 0.20659389f, 
    -0.05444925f, 0.17291361f, -0.47293529f, 0.13434957f, -0.09666730f, 0.11243029f, 0.60092479f, -0.33953524f, 
    -0.45434839f, 0.93098783f, 0.55578005f, 0.47168022f, 0.01221722f, -0.26818842f, 0.19079891f, 0.12241304f, 
    -0.29724413f, 0.04881225f, 0.07131891f, 0.06656247f, 0.07102601f, 0.19562502f, 0.13223779f, 0.08600275f, 
    -0.07926043f, 0.35304937f, -0.16842155f, 0.04153546f, -0.25696802f, 0.04368323f, 0.01131292f, 0.93923038f, 
    0.58933872f, 0.40514877f, 0.07619577f, -0.46036428f, 0.28370309f, 0.39406186f, -0.23706585f, 0.08538709f, 
    0.59958035f, 0.32890725f, 0.32086107f, 0.13359368f, 0.10076299f, -0.00664915f, 0.19338757f, 0.03087648f, 
    -0.19180959f, 0.10530292f, 0.07673856f, 0.22555670f, -0.03367776f, 0.24373344f, 0.25798586f, 0.01727949f, 
    0.28878191f, -0.03101615f, 0.82527089f, -0.11474571f, -0.93633711f, -0.34775189f, -0.73111659f, -0.16818932f, 
    0.14937104f, 0.06984040f, 0.02372170f, -0.05311658f, -0.39855763f, -0.21334134f, -0.08209267f, -0.05353827f, 
    -0.23783815f, -0.03027605f, -0.17523137f, -0.07573722f, 0.34365940f, -0.07973388f, 0.20753528f, 0.04619104f, 
    0.13261177f, -0.47898814f, -0.97265404f, 0.55714124f, 0.83303213f, 0.13869786f, 0.08409040f, 0.86896282f, 
    -0.26561388f, 0.23749097f, 0.05425816f, 0.20088688f, 0.01206649f, 0.06337429f, 0.21711218f, 0.14444521f, 
    0.11679842f, 0.23118651f, -0.24802558f, -0.03193456f, -0.14492801f, -0.14853701f, 0.07930338f, 0.04523486f, 
    -0.16927460f, -0.13194388f, -1.42240274f, 0.99000955f, 0.20980722f, -0.43574482f, 0.07986226f, -0.01935135f, 
    0.83325189f, -0.04177798f, -0.01941357f, 0.05873986f, -0.25816655f, 0.10144126f, 0.29844457f, -0.03200513f, 
    0.03609053f, -0.12349521f, -0.14480641f, -0.01223120f, -0.08027866f, -0.20677800f, 0.27249029f, 0.17963745f, 
    0.20412453f, 0.15701778f, 0.14490819f, 0.08745056f, 0.30492240f, 0.47861040f, -0.39207569f, -0.68156826f, 
    -0.30746520f, -0.16333039f, -0.58618516f, -0.47750664f, -0.16308466f, 0.15496382f, 0.34632888f, -0.18019857f, 
    -0.02301101f, 0.21914515f, 0.20533241f, -0.17367072f, -0.30441743f, 0.21208298f, -0.08285161f, -0.07771064f, 
    0.12152349f, 0.28125602f, -0.03714678f, 0.43383086f, -0.45788646f, -0.22317092f, 0.07495949f, 0.08037119f, 
    0.02499612f, -0.36351779f, 0.52024198f, -0.32849053f, -0.50273722f, -0.22919926f, 0.16800822f, -0.23436460f, 
    -0.36684409f, -0.30648816f, -0.23710687f, -0.02260443f, -0.18394300f, -0.40102699f, -0.48248160f, -0.33692646f, 
    0.07079620f, 0.04969159f, 0.19377059f, 0.39716187f, -0.51785153f, -1.07755435f, 0.38264316f, 0.23002791f, 
    -0.67547929f, -0.39209247f, 0.58298624f, 0.12255701f, 0.00500807f, 0.51092970f, 0.34675434f, 0.38769904f, 
    0.02192285f, -0.34443265f, 0.07034074f, 0.07837535f, 0.01499388f, 0.00990555f, -0.09070059f, 0.05968209f, 
    0.05621033f, 0.10777761f, 0.02474258f, 0.12213299f, 0.19927488f, 0.12011651f, 0.44879150f, 0.27204260f, 
    0.76190865f, 0.62614220f, 0.53380728f, 0.23333395f, -0.04061510f, -0.14755204f, -0.26764286f, -0.10242324f, 
    0.35216859f, -0.01617229f, -0.20563170f, -0.27199203f, 0.11914295f, -0.45238972f, -0.15360507f, -0.29593134f, 
    0.18896386f, 0.05366265f, -0.07210214f, 0.00454175f, 0.09361701f, -0.25011531f, -0.10573418f, 0.46997753f, 
    0.44239405f, 0.26695299f, 0.61294258f, -0.21449856f, 0.16142789f, 0.40733990f, -0.46965560f, 0.14893809f, 
    -0.14334650f, -0.18957938f, -0.00269719f, -0.17068291f, -0.12517381f, -0.00241817f, -0.42189068f, -0.43621314f, 
    0.28483275f, -0.23182237f, -0.21033216f, -0.39368749f, 0.34838614f, -0.41883248f, -0.00958533f, 0.32814279f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03387429f, 0.06282306f, -0.04201925f, 0.02627065f, 0.01702216f, 0.11711270f, 0.22972064f, 0.17791632f, 
    0.05539174f, -0.06885897f, 0.26756355f, 0.00559366f, -0.00328509f, 0.02418313f, 0.25753090f, 0.23212638f, 
    0.17901583f, 0.21202371f, 0.23427068f, 0.22972512f, -0.01506470f, 0.12566768f, 0.21190891f, 0.06344295f, 
    0.33628750f, 0.24901351f, 0.04114032f, 0.08582640f, -0.02820910f, 0.07195695f, 0.13177140f, 0.16678976f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00571555f, 0.03125160f, -0.03658135f, -0.00175192f, 0.04432518f, -0.01376499f, 0.01120738f, 0.00140829f, 
    -0.05182912f, 0.03185544f, -0.03174867f, -0.04026787f, -0.00815469f, -0.05496981f, -0.01760313f, -0.02020754f, 
    -0.01969070f, 0.02891061f, -0.02469822f, 0.04005723f, -0.03402543f, -0.04989265f, -0.00669338f, 0.02233064f, 
    -0.02386767f, -0.04494005f, -0.00291231f, 0.03915169f, 0.03763949f, 0.04341961f, -0.02497867f, -0.01635799f, 
    -0.02809996f, 0.01412260f, -0.03405264f, 0.03962530f, -0.01684461f, 0.01244090f, 0.01222053f, 0.02818218f, 
    -0.02601533f, 0.02309808f, -0.03329932f, -0.02307718f, -0.01154307f, 0.03944624f, -0.01246679f, 0.00170688f, 
    0.00497238f, -0.01548924f, -0.02905491f, -0.00393932f, 0.03010440f, -0.03452991f, 0.02770545f, 0.02348608f, 
    0.00663113f, -0.01637527f, -0.05674101f, -0.01444784f, -0.04253578f, 0.03508795f, 0.03288527f, 0.04638320f, 
    -0.00817647f, 0.01020558f, -0.04391168f, -0.03766087f, -0.01568138f, -0.01040889f, -0.04164736f, 0.02401690f, 
    -0.01104075f, -0.00787721f, 0.01290078f, -0.01840163f, 0.02372120f, -0.05227978f, -0.00481191f, 0.02728917f, 
    0.01338268f, 0.04441439f, 0.02931992f, -0.04950136f, 0.02605642f, 0.00412953f, 0.01056283f, 0.01606842f, 
    -0.04397152f, -0.05355070f, 0.04117952f, -0.04835496f, -0.02177967f, -0.01927591f, 0.04394466f, 0.02472484f, 
    -0.01342393f, -0.00091374f, -0.00669665f, -0.01026529f, -0.00135418f, -0.01939607f, 0.01212423f, -0.03334936f, 
    0.03450862f, 0.00215321f, -0.04702595f, -0.02565303f, -0.00467082f, -0.05017457f, -0.02686464f, 0.03105195f, 
    -0.05059905f, -0.04348190f, 0.01881758f, -0.02881319f, 0.02064042f, -0.03784603f, 0.02205075f, -0.04061902f, 
    -0.05030456f, -0.00045979f, 0.02527829f, 0.04391031f, -0.05947015f, -0.01683784f, 0.01252139f, 0.02418976f, 
    -0.01476531f, -0.01096893f, -0.05189102f, 0.03637154f, 0.00711520f, -0.05439704f, 0.04506384f, 0.01990458f, 
    0.01052472f, -0.00461801f, -0.02769740f, -0.00054516f, -0.04170472f, 0.03650031f, -0.00410484f, -0.04344364f, 
    -0.00583407f, 0.00851050f, 0.02736477f, 0.02893493f, -0.02544310f, 0.00631415f, -0.01274680f, 0.00238326f, 
    -0.01517413f, -0.05557422f, 0.00889634f, -0.05798585f, -0.02480958f, -0.03890040f, -0.00440029f, 0.04627485f, 
    -0.01242026f, 0.02013774f, 0.04018660f, -0.05197919f, 0.01080517f, -0.04380600f, -0.00962382f, 0.02600971f, 
    -0.01554647f, 0.00699930f, -0.03024415f, 0.02771314f, 0.03854229f, -0.02395913f, 0.01039123f, 0.02269565f, 
    0.01654750f, -0.03110491f, -0.03807136f, 0.01380870f, -0.06108559f, -0.01916885f, -0.01351894f, -0.02499071f, 
    -0.00824124f, -0.04260121f, 0.02597682f, 0.03765263f, -0.01438455f, -0.03959317f, 0.01245092f, -0.03341707f, 
    -0.02145919f, -0.01775397f, 0.01652703f, -0.05914124f, 0.04078929f, -0.04942452f, -0.02171303f, -0.03421229f, 
    -0.02854240f, 0.00006039f, -0.04866820f, -0.02032165f, -0.04098228f, 0.03758666f, 0.01447533f, -0.03800923f, 
    0.00070897f, -0.01243155f, 0.03036925f, 0.04581690f, 0.00845714f, -0.00273341f, -0.00990730f, -0.00908234f, 
    0.02414375f, -0.01918882f, -0.03375345f, -0.04311941f, 0.00582851f, 0.00968112f, 0.01886001f, 0.04093228f, 
    0.00901255f, -0.05033075f, 0.01335903f, -0.00784356f, -0.01571270f, -0.02072418f, 0.03557412f, -0.04862878f, 
    -0.00968869f, -0.02074080f, -0.04493117f, -0.03417718f, 0.00663109f, -0.05310527f, 0.00729339f, 0.02844524f, 
    -0.04165198f, 0.00054684f, -0.02082842f, 0.02205339f, 0.03334251f, 0.03984878f, -0.02584170f, -0.02946292f, 
    0.01819083f, 0.01101073f, 0.01561794f, -0.03426691f, -0.02080909f, -0.02942090f, 0.00707110f, -0.05015335f, 
    0.00089506f, -0.00990684f, -0.05453213f, -0.04134411f, -0.05108629f, 0.04275617f, 0.03399231f, -0.00696927f, 
    -0.02912334f, -0.00681863f, -0.02861917f, 0.00737041f, -0.02919150f, -0.03650350f, -0.02244105f, 0.01445374f, 
    -0.04895893f, -0.02612836f, 0.04065511f, -0.00467093f, -0.01118706f, -0.02738275f, 0.01884699f, 0.02412384f, 
    -0.00902077f, 0.03049649f, 0.01657936f, -0.05881166f, -0.03188166f, -0.00163320f, -0.04995517f, -0.02554739f, 
    -0.01529579f, -0.05031674f, 0.01041111f, -0.01243074f, 0.04477932f, -0.05012234f, -0.03026236f, -0.02606057f, 
    -0.00820640f, -0.01765889f, 0.01806834f, 0.03952155f, -0.05376862f, 0.03695906f, -0.03450562f, 0.02552166f, 
    -0.01711785f, -0.00750117f, -0.00604018f, -0.03517640f, 0.04636816f, -0.00155250f, -0.04555880f, 0.03188507f, 
    -0.04486646f, 0.00379253f, -0.02883778f, 0.02269783f, 0.05437520f, -0.00848703f, 0.00747591f, -0.01182313f, 
    0.02302905f, -0.04408355f, 0.00962329f, 0.03300224f, -0.02379688f, 0.00548384f, 0.02600818f, 0.03416213f, 
    -0.00490165f, -0.02702444f, -0.04228989f, -0.03835201f, -0.03123737f, -0.03764820f, 0.00191103f, 0.04556620f, 
    -0.04722090f, -0.01292808f, 0.03559016f, -0.01552621f, 0.00968006f, 0.02354212f, -0.02011255f, 0.04247293f, 
    0.02938939f, -0.04204514f, -0.03126725f, -0.01739393f, -0.04196474f, -0.02401530f, 0.04162011f, -0.03208977f, 
    -0.05296810f, -0.04417747f, -0.04393679f, 0.04331816f, 0.02494022f, -0.03206371f, -0.00222548f, 0.00835282f, 
    0.02062189f, 0.03868683f, -0.05651476f, -0.05230983f, 0.02729452f, 0.00615965f, -0.04386257f, 0.04033947f, 
    -0.03118213f, -0.02445835f, 0.02019752f, -0.03962448f, -0.00516168f, -0.04032547f, 0.02472324f, 0.04463231f, 
    0.02037390f, -0.00498630f, -0.04835777f, -0.04057519f, -0.02269583f, -0.05174378f, 0.02669298f, -0.00714896f, 
    0.00373695f, -0.11607452f, 0.33023509f, 0.09108859f, -0.04865050f, -0.05565624f, 0.04460729f, -0.00670211f, 
    -0.01949792f, -0.01475963f, -0.09713844f, 0.10236026f, -0.01862772f, 0.15283182f, 0.15645173f, -0.07450099f, 
    -0.11573981f, 0.02472194f, 0.05855912f, -0.03030184f, 0.02277677f, 0.19689654f, 0.10204255f, 0.14416113f, 
    -0.03867526f, 0.14076699f, -0.05654734f, -0.00805027f, 0.05725949f, 0.05349421f, -0.11468851f, -0.06385448f, 
    0.03082653f, -0.04649441f, -0.05197584f, -0.09460720f, -0.48386240f, 0.14457309f, -0.15858519f, 0.02413297f, 
    0.13586751f, 0.01918642f, 0.00673806f, 0.06470302f, -0.05659693f, 0.04653539f, -0.04458576f, -0.12365592f, 
    -0.20415787f, 0.04954198f, 0.03531929f, -0.07928102f, -0.02463412f, 0.01681687f, -0.00169252f, 0.05951654f, 
    0.04927192f, 0.00475723f, -0.04905701f, 0.14818326f, -0.39649859f, 0.00628382f, 0.15274738f, -0.19020523f, 
    -0.00467695f, 0.04429960f, 0.02295998f, -0.11770596f, 0.01159712f, 0.18421069f, 0.11092022f, 0.09221888f, 
    0.11478777f, -0.12677108f, -0.00131019f, -0.11606803f, 0.08100615f, 0.03198504f, -0.01926877f, 0.10326228f, 
    0.09808077f, 0.05610212f, -0.06218204f, 0.01046831f, -0.04000022f, 0.06855514f, 0.09957637f, 0.07327285f, 
    -0.09643908f, -0.01413629f, 0.00223017f, 0.00610588f, 0.03600585f, 0.05220695f, 0.11045929f, 0.16154023f, 
    0.14437187f, -0.04812213f, 0.03126733f, -0.04914425f, 0.08344653f, 0.13443951f, 0.01693204f, 0.06263432f, 
    0.19437142f, -0.11262473f, 0.07100271f, -0.17748913f, -0.19500886f, -0.04760759f, -0.06877647f, -0.03771090f, 
    -0.02528102f, 0.10899829f, 0.08187361f, 0.02180088f, -0.03549736f, 0.08157863f, -0.13938408f, 0.02590079f, 
    -0.19882332f, 0.10226451f, -0.16887538f, -0.08740452f, 0.17209941f, 0.08223440f, 0.18942006f, -0.05334312f, 
    -0.00072495f, -0.03086626f, -0.03030178f, 0.01703514f, -0.05165293f, -0.04759711f, -0.10321087f, -0.15293398f, 
    0.07173609f, 0.12177675f, 0.02794761f, 0.00041168f, 0.09917439f, 0.01032711f, -0.01853713f, 0.06199299f, 
    0.13950291f, -0.02178158f, 0.00064029f, 0.15253691f, -0.15334004f, -0.07758928f, 0.02316074f, 0.02190802f, 
    0.08809454f, 0.06683486f, 0.07936602f, 0.13900110f, 0.14003253f, -0.09795400f, -0.05835867f, -0.14593022f, 
    -0.06990644f, 0.08866448f, 0.00513993f, -0.04082496f, 0.18505983f, -0.08911508f, 0.02560140f, 0.08066290f, 
    0.30891678f, 0.14238228f, 0.00966880f, 0.01657446f, -0.05372785f, 0.06825516f, -0.05991659f, 0.03284902f, 
    0.15633368f, -0.12010803f, -0.01813678f, 0.00347822f, -0.06056697f, -0.11914012f, -0.00335603f, 0.10463415f, 
    0.17748736f, 0.16738339f, 0.09642158f, 0.20606565f, 0.07671807f, 0.03240288f, 0.10089178f, 0.05595280f, 
    -0.20086379f, 0.03170891f, -0.12707672f, 0.09313817f, -0.02690451f, 0.03693479f, -0.10957312f, 0.05232095f, 
    0.06854837f, 0.05185094f, 0.06607185f, 0.06178591f, 0.14852527f, 0.10621398f, 0.20441277f, 0.03687473f, 
    -0.06874078f, -0.10506286f, -0.03663462f, 0.02203180f, 0.19052374f, -0.06017368f, 0.02337302f, 0.12962234f, 
    0.09941553f, 0.08619305f, -0.03926063f, -0.18388888f, 0.07862429f, 0.05498327f, -0.08896762f, 0.02165275f, 
    -0.03746116f, 0.01145995f, -0.13762160f, 0.04827002f, 0.31395590f, 0.12047589f, -0.06963640f, 0.08690254f, 
    -0.05545905f, -0.01429527f, 0.03012775f, 0.11926629f, 0.01651519f, 0.08806591f, -0.03303061f, -0.03700963f, 
    0.16778979f, -0.00016108f, 0.13702978f, -0.08265560f, 0.06910255f, -0.07856908f, -0.04476679f, -0.12287595f, 
    -0.17703238f, 0.09029166f, -0.04219793f, 0.07470562f, -0.05218387f, -0.00669863f, -0.00676660f, -0.00237535f, 
    -0.09510556f, 0.01128310f, -0.09038825f, 0.16579409f, 0.04921636f, -0.00221891f, 0.10647523f, 0.07096358f, 
    0.24499655f, 0.06884905f, -0.16497417f, 0.05441267f, 0.02364093f, -0.02306179f, -0.07893855f, -0.00662363f, 
    0.02743933f, 0.10839358f, 0.03151092f, 0.19253477f, 0.11778136f, 0.00197459f, -0.11133288f, -0.13064623f, 
    0.08224018f, -0.02803055f, -0.01567932f, 0.04104479f, 0.12373679f, 0.05592720f, 0.03545981f, 0.14971489f, 
    0.14653160f, 0.18193202f, 0.17661591f, 0.04822202f, 0.03815908f, 0.02635921f, -0.06193141f, 0.04035477f, 
    0.03817816f, -0.04857139f, -0.04360742f, 0.07508359f, -0.51529646f, 0.36924437f, -0.11809963f, 0.04959082f, 
    0.10323654f, -0.04460786f, -0.02449150f, 0.07226162f, -0.02548544f, -0.06020863f, -0.05234545f, 0.05706934f, 
    -0.48730522f, -0.09534544f, 0.02016514f, 0.04917286f, -0.03446040f, -0.03996552f, 0.06982793f, -0.08084384f, 
    0.13947348f, -0.01946475f, 0.17532063f, -0.18759663f, -0.21628514f, 0.01823128f, 0.13011532f, 0.01815102f, 
    0.04014089f, 0.01796938f, 0.02128562f, 0.05653424f, -0.04791583f, -0.00282102f, 0.07202625f, 0.14205037f, 
    -0.33815876f, 0.01742617f, 0.03644941f, 0.13724327f, -0.01077125f, 0.01945284f, 0.10727457f, 0.08474391f, 
    0.04958189f, -0.06083303f, -0.15347911f, -0.06928532f, -0.15263072f, -0.20429848f, -0.08980434f, -0.12324854f, 
    0.01058309f, -0.03061225f, 0.00036949f, -0.04224075f, 0.11466991f, 0.12141473f, 0.00822404f, 0.00457668f, 
    0.06575006f, 0.00718615f, 0.01631540f, -0.00874201f, 0.02933800f, -0.02469973f, -0.02173776f, 0.01490721f, 
    -0.04418363f, -0.07234794f, -0.11116128f, 0.02923499f, 0.01965997f, 0.03177666f, -0.02430379f, 0.04282750f, 
    -0.10208382f, -0.00185324f, -0.04417582f, -0.00535993f, -0.04969915f, 0.03104304f, 0.01601782f, -0.11336978f, 
    -0.07375069f, -0.22395727f, 0.07871182f, -0.09105193f, -0.00765200f, -0.16137178f, 0.12853035f, 0.03442568f, 
    -0.03560198f, -0.03021826f, -0.04451085f, 0.09165736f, 0.02504343f, 0.16334935f, 0.08729597f, 0.09193536f, 
    -0.04987564f, 0.07996736f, -0.00668551f, -0.07751448f, 0.06877717f, 0.02286239f, 0.16421056f, 0.01962470f, 
    -0.13997704f, 0.09301579f, -0.05138791f, -0.00221900f, 0.08825903f, 0.14861281f, -0.09717057f, 0.14120792f, 
    0.10549664f, 0.02395451f, -0.02647539f, 0.00652292f, 0.12619966f, 0.18342337f, -0.01032087f, 0.18399899f, 
    -0.07971293f, -0.01044232f, -0.02300216f, 0.12740256f, 0.10642274f, 0.07049313f, -0.04424974f, -0.01181518f, 
    0.00364481f, -0.08319908f, 0.15480781f, -0.13860196f, 0.06133307f, -0.05694392f, 0.17658964f, 0.01352221f, 
    -0.00160169f, 0.13447568f, -0.04267949f, 0.06094278f, -0.23245123f, 0.02134635f, 0.14496721f, -0.00862828f, 
    -0.01638806f, 0.08612786f, 0.18495172f, -0.02340280f, -0.02513975f, -0.02004180f, -0.03827722f, -0.10033811f, 
    0.08720639f, -0.02988468f, -0.24402347f, -0.07529823f, 0.11746047f, -0.03366650f, 0.13113028f, 0.09463519f, 
    0.00882139f, -0.01987751f, 0.02233256f, -0.06682930f, -0.04447378f, 0.11987167f, 0.03276676f, 0.05228992f, 
    0.00860111f, 0.01972894f, 0.07438269f, -0.12444380f, -0.10532072f, 0.03255596f, 0.06700004f, 0.06362061f, 
    0.11303544f, 0.12821750f, 0.26289642f, -0.07075957f, 0.07731215f, -0.04613705f, 0.09260460f, 0.11291095f, 
    0.07971361f, -0.13404392f, 0.11122440f, -0.00122202f, -0.09090014f, 0.02661634f, 0.09600705f, 0.22157180f, 
    -0.04980120f, 0.22102879f, 0.02337616f, -0.03082514f, -0.00141766f, 0.04543178f, -0.08863635f, -0.16353109f, 
    0.01492568f, 0.10718688f, -0.13998426f, -0.12817697f, 0.10306202f, 0.05973873f, 0.09065697f, -0.02850921f, 
    0.08179674f, -0.03344747f, -0.02358145f, -0.12555856f, 0.24618478f, 0.05324507f, 0.01645411f, -0.15642950f, 
    0.02256227f, 0.00247170f, 0.05138394f, 0.08616007f, 0.08929238f, -0.02022489f, 0.02878359f, 0.03805847f, 
    0.22247225f, 0.15540759f, -0.03920929f, -0.01194535f, -0.23148064f, -0.05696326f, 0.00206512f, 0.10305424f, 
    0.03798040f, 0.04990238f, -0.06564831f, 0.10577853f, -0.39919227f, -0.05014565f, -0.17974293f, -0.15076612f, 
    -0.08885997f, -0.03401352f, 0.00208152f, -0.03722974f, 0.07841909f, 0.02668915f, 0.00343130f, -0.02517288f, 
    0.08508319f, 0.19893076f, 0.01985509f, -0.11850898f, -0.16259085f, -0.00158902f, 0.03871364f, 0.11395862f, 
    0.10712986f, -0.04773646f, 0.05633883f, -0.02244843f, 0.22983170f, 0.21461242f, 0.18244128f, 0.08215654f, 
    0.02253728f, 0.13802980f, 0.12058715f, 0.11262156f, -0.00553728f, 0.11215227f, 0.04209573f, -0.02267130f, 
    -0.11019984f, 0.04436649f, -0.03746330f, -0.02650767f, 0.02092303f, 0.10578944f, -0.15689178f, 0.00687373f, 
    0.07219876f, -0.12550549f, -0.07185652f, 0.02225233f, 0.06666441f, 0.14836968f, -0.00753193f, -0.05149932f, 
    -0.12320871f, -0.12073405f, 0.02726882f, 0.09693410f, 0.09815869f, 0.03915732f, 0.04772589f, -0.01050517f, 
    0.04041256f, 0.26234606f, 0.08421148f, -0.01011875f, 0.05692955f, -0.03351218f, -0.10039809f, -0.03368017f, 
    0.00334749f, -0.04956869f, -0.02081053f, 0.03712137f, 0.29705033f, -0.05458086f, 0.04765080f, 0.06498792f, 
    -0.08191309f, -0.01285267f, 0.09234720f, 0.10883740f, 0.00471399f, 0.09121820f, -0.02197990f, 0.08963495f, 
    -0.10127287f, -0.11614861f, -0.12934898f, 0.16587102f, -0.07754676f, -0.11203101f, -0.01537862f, -0.10427131f, 
    -0.16607824f, -0.00586985f, 0.05794747f, 0.11878836f, 0.11634795f, -0.15555829f, 0.03691278f, -0.01935421f, 
    -0.14842390f, 0.04777440f, 0.05379294f, 0.03081658f, -0.00748569f, 0.00469451f, -0.09412801f, -0.04347359f, 
    0.19680545f, -0.21126676f, -0.16341899f, 0.07263005f, -0.08635962f, 0.11137074f, -0.16475710f, 0.07780202f, 
    0.05379786f, -0.03923774f, -0.02801111f, -0.03722753f, -0.21474040f, 0.00065652f, 0.02606453f, -0.06393019f, 
    -0.01825547f, -0.01425527f, 0.05493529f, 0.07703690f, 0.09607346f, 0.07581608f, -0.00881312f, 0.00119024f, 
    -0.27948520f, 0.12993813f, -0.11261094f, 0.32249472f, 0.03528069f, 0.01817544f, -0.08522396f, -0.09131561f, 
    -0.05675523f, -0.03990017f, 0.05512549f, 0.03365083f, -0.04866574f, 0.11205970f, -0.01258876f, 0.06743316f, 
    -0.02288576f, 0.13431405f, -0.02190439f, 0.08977230f, -0.06484462f, 0.00233586f, 0.05181018f, -0.01784165f, 
    -0.16979906f, -0.04036782f, -0.05646073f, 0.00758247f, 0.01272469f, -0.06573272f, 0.12591551f, -0.02736162f, 
    0.06513159f, 0.07391395f, -0.02896280f, -0.03923405f, -0.28034386f, -0.08203930f, 0.10157669f, 0.16080150f, 
    0.01255908f, 0.13302764f, -0.05083594f, 0.09033971f, 0.05008402f, 0.04504988f, -0.05095840f, -0.01934595f, 
    -0.06095947f, 0.00826556f, 0.18143402f, 0.04083329f, 0.02126480f, -0.11711226f, -0.12112676f, 0.06629409f, 
    -0.10641526f, -0.05356934f, 0.09919471f, 0.07603831f, 0.30763841f, 0.22252059f, -0.11535858f, 0.07986238f, 
    0.01580808f, 0.11458616f, -0.04487965f, -0.05575542f, -0.03984547f, 0.14291531f, -0.00974840f, -0.02111403f, 
    0.09864803f, 0.09644960f, -0.00180341f, -0.10691699f, -0.17803122f, 0.01952910f, 0.03347415f, 0.05302220f, 
    -0.02401557f, 0.05144150f, -0.00492843f, -0.02034379f, -0.00199451f, 0.17933872f, -0.00778758f, -0.07790156f, 
    -0.06628375f, -0.07165755f, 0.12525947f, 0.02560826f, -0.04884563f, -0.04404672f, -0.13965923f, -0.04717084f, 
    -0.03838092f, 0.02853416f, -0.02695380f, -0.00920044f, 0.01909278f, 0.01020714f, 0.00396021f, 0.01464176f, 
    -0.04748362f, -0.01459991f, 0.01784831f, 0.00277225f, -0.00100636f, 0.02081889f, 0.03886073f, -0.03005363f, 
    -0.05976191f, -0.05354665f, 0.03924958f, 0.02078706f, 0.01388370f, -0.01952506f, 0.00612519f, 0.01196466f, 
    0.04308151f, -0.01340963f, -0.01486754f, -0.00776053f, 0.03976496f, -0.03219590f, 0.01570676f, 0.03884655f, 
    0.04154210f, -0.01801622f, -0.04449667f, -0.00358945f, -0.04503427f, -0.04507854f, 0.02835886f, 0.01579111f, 
    -0.01596893f, -0.03737418f, 0.01147956f, -0.02066757f, -0.02184415f, -0.02329523f, 0.02639500f, -0.01040315f, 
    -0.01914264f, -0.04107144f, 0.02551868f, 0.03027824f, -0.02933347f, -0.00714922f, 0.03442820f, -0.00785811f, 
    -0.04871267f, -0.04133615f, -0.04149589f, 0.03579358f, -0.00855931f, -0.00994954f, -0.03503283f, -0.03676143f, 
    0.04653144f, -0.02720072f, 0.03123431f, 0.01260185f, -0.03192697f, 0.00069856f, 0.01076486f, -0.02618309f, 
    -0.01049075f, 0.01774303f, -0.05150938f, -0.03725856f, 0.02820484f, -0.03596095f, 0.00135587f, 0.00708293f, 
    -0.00618197f, 0.02479627f, 0.01945071f, -0.05546063f, -0.03866943f, 0.00205769f, -0.04918757f, 0.03774213f, 
    0.00674928f, -0.01371292f, 0.02142923f, -0.02060791f, -0.04515588f, -0.01936360f, 0.01172613f, 0.00653192f, 
    0.00656903f, -0.01902807f, -0.00436170f, 0.04266474f, 0.02584365f, 0.04701310f, -0.04177832f, -0.01712323f, 
    -0.00605302f, -0.03737910f, -0.03071236f, -0.01646116f, -0.04960002f, -0.02805817f, 0.04277048f, -0.01408643f, 
    -0.04475016f, -0.02490822f, -0.00775888f, -0.05252633f, -0.00550766f, -0.00706169f, 0.04412738f, -0.05207390f, 
    0.00689271f, 0.04821305f, -0.04443400f, -0.01892648f, -0.03462071f, 0.03570641f, -0.00094861f, -0.01598934f, 
    0.02976622f, 0.00876905f, 0.01023635f, 0.01710332f, -0.00694678f, 0.03197829f, 0.02193110f, 0.02128154f, 
    0.02753044f, -0.01880836f, 0.04254115f, -0.03022075f, -0.05658582f, -0.02755230f, 0.02937707f, 0.02787579f, 
    0.00620764f, -0.02721551f, 0.02071595f, -0.05595653f, -0.03927272f, -0.04259060f, -0.04913779f, 0.00714871f, 
    -0.03500666f, -0.04364360f, 0.03597220f, -0.00204546f, -0.01759946f, 0.04288223f, 0.01740267f, 0.01904931f, 
    -0.02703699f, 0.02449608f, -0.03139901f, -0.02917290f, 0.00117654f, -0.03073463f, -0.04272157f, 0.02725385f, 
    0.00113305f, -0.05578028f, -0.01512428f, 0.03854704f, -0.04868243f, 0.03367743f, 0.00538962f, -0.02362080f, 
    -0.04050400f, -0.02125294f, -0.03827627f, 0.02057729f, -0.01954791f, -0.01451362f, 0.00590400f, 0.01237993f, 
    -0.00056712f, -0.00749482f, 0.03274738f, 0.01246500f, 0.00250405f, -0.00151704f, 0.00902130f, 0.03682198f, 
    0.02574224f, -0.02143041f, 0.00502721f, -0.05825442f, 0.01398889f, -0.03214392f, -0.02469036f, -0.01503749f, 
    -0.01626132f, -0.03645227f, -0.02373649f, 0.01869688f, 0.00434728f, 0.01414839f, -0.04854915f, -0.02436733f, 
    -0.01367315f, 0.00940003f, 0.03104913f, -0.04833450f, 0.03189754f, -0.00775129f, 0.02986738f, 0.01981223f, 
    -0.04217873f, 0.02631525f, 0.04577386f, 0.02179739f, -0.00433114f, 0.02503913f, 0.01147250f, -0.00802724f, 
    -0.02954728f, -0.00542350f, -0.02159648f, 0.04360716f, 0.02351740f, -0.03437585f, -0.05287570f, -0.02251962f, 
    -0.05126260f, 0.01809620f, -0.04837937f, -0.03967921f, 0.02346967f, -0.00230428f, -0.04229026f, 0.00515056f, 
    0.02237552f, 0.02297746f, 0.03565442f, -0.04265575f, 0.00361729f, 0.02491873f, -0.03586651f, 0.01298766f, 
    -0.04172553f, -0.03147323f, -0.03995151f, -0.00777864f, 0.02377650f, -0.00085437f, -0.03904669f, -0.04387548f, 
    -0.05289651f, 0.02432820f, 0.01875365f, -0.00294686f, -0.04103911f, 0.02999048f, -0.03627312f, -0.02926958f, 
    0.00169146f, 0.02612625f, -0.05388322f, 0.00788963f, -0.03846867f, -0.03741341f, -0.04980578f, -0.00627771f, 
    -0.04516840f, -0.02757347f, -0.02370340f, -0.02665872f, 0.03802783f, 0.02921010f, 0.02586497f, 0.01745597f, 
    -0.01586158f, -0.00825379f, 0.00866832f, -0.05780964f, -0.05345239f, 0.00767177f, -0.00891373f, 0.01585232f, 
    -0.00589882f, 0.03130484f, -0.05272883f, 0.03828815f, 0.00467240f, -0.01446839f, 0.02694452f, -0.03692903f, 
    -0.03793012f, -0.03176978f, 0.04339569f, 0.01010155f, 0.02846435f, -0.04914728f, -0.00084752f, -0.04910880f, 
    0.03203885f, 0.00055090f, -0.01613103f, 0.04188422f, 0.03323800f, 0.00206882f, 0.02824380f, -0.01477552f, 
    0.04004790f, 0.00846506f, -0.03914989f, -0.03552087f, 0.00275198f, 0.03683684f, -0.02351529f, 0.04416867f, 
    0.01554089f, 0.02838095f, -0.04564068f, -0.00869860f, 0.00132934f, -0.01759562f, -0.04444446f, 0.03679941f, 
    -0.02648665f, 0.02666461f, -0.00280759f, 0.01127667f, 0.03556345f, -0.02183414f, 0.02206336f, 0.00040199f, 
    0.04175755f, 0.02186981f, -0.04755365f, -0.00867295f, -0.04436630f, -0.03800198f, 0.02373326f, 0.00617733f, 
    -0.01509366f, -0.02897466f, 0.03237870f, 0.01564768f, 0.03541661f, 0.02395437f, 0.02254299f, -0.03513282f, 
    -0.00749586f, 0.01106921f, 0.04166386f, -0.03005756f, -0.03293547f, -0.02141361f, -0.00056851f, 0.02391916f, 
    0.02510305f, 0.00350512f, -0.04045735f, -0.00597415f, 0.00601586f, -0.02124195f, 0.03921460f, -0.03390624f, 
    -0.00533207f, -0.04364590f, 0.00859135f, 0.01228457f, -0.01172020f, 0.00015716f, -0.00112667f, 0.01881347f, 
    -0.02753084f, -0.02346324f, -0.04087023f, -0.04683388f, 0.02700114f, -0.02697533f, -0.00100561f, 0.01655528f, 
    0.16429028f, 0.07790454f, 0.07608788f, -0.07913308f, 0.16814645f, 0.06868993f, 0.04861615f, -0.02387640f, 
    0.16014905f, 0.11367830f, -0.07476048f, -0.03100341f, 0.00181704f, 0.07495635f, -0.18649757f, 0.13270320f, 
    0.09136054f, -0.00275773f, 0.04194435f, 0.07722513f, 0.04969414f, 0.07267275f, 0.03587441f, 0.16451313f, 
    0.09259901f, 0.13097489f, -0.00594654f, -0.02886900f, -0.05362941f, -0.09230281f, -0.15958562f, 0.02438914f, 
    0.03932574f, -0.03290964f, -0.06216903f, -0.16255124f, 0.55516189f, 0.15946573f, 0.08844990f, 0.18970913f, 
    -0.11092089f, -0.13569397f, -0.00218341f, -0.03568609f, 0.09159813f, -0.07595252f, -0.01230033f, -0.11994535f, 
    0.01329424f, -0.12630121f, -0.01968028f, -0.02804151f, 0.09476331f, -0.09819739f, -0.02725309f, -0.03670603f, 
    0.04211797f, 0.01255746f, 0.07747667f, 0.02602444f, 0.07305315f, 0.18814692f, -0.18358545f, 0.01572175f, 
    0.12326520f, -0.06909829f, -0.08086269f, 0.00298508f, -0.01238449f, 0.03997081f, 0.01161431f, 0.07672570f, 
    0.08717594f, 0.19181065f, 0.07498401f, -0.22082616f, -0.08083261f, 0.04341592f, -0.02725041f, -0.01131445f, 
    -0.05858189f, 0.02324981f, -0.05284312f, -0.06647071f, 0.11068497f, 0.13365473f, -0.24196109f, 0.09403002f, 
    0.08500290f, 0.04900644f, -0.04569301f, -0.04102441f, -0.08988132f, 0.07006522f, 0.04376857f, 0.00927558f, 
    0.01123935f, 0.00423398f, -0.00676281f, 0.16747993f, -0.06628371f, 0.05289906f, -0.02958271f, -0.00087394f, 
    0.17947790f, 0.04826178f, -0.04877631f, -0.00636352f, 0.14478332f, 0.12465216f, 0.21116890f, -0.00397005f, 
    -0.04510022f, -0.12798764f, -0.02835776f, -0.01931435f, -0.09703653f, -0.03759172f, -0.09599581f, 0.00595727f, 
    0.17005236f, 0.02835442f, 0.14253317f, 0.28953779f, -0.00235078f, -0.12060522f, -0.04596328f, 0.12253236f, 
    -0.00362283f, 0.01056896f, 0.09786067f, -0.03495774f, 0.28770068f, 0.28797421f, 0.11195507f, -0.02943609f, 
    -0.05797193f, -0.05327161f, -0.05447531f, 0.07875663f, 0.10936000f, 0.03792483f, -0.07904059f, -0.20236461f, 
    -0.09341304f, -0.12647706f, -0.22909051f, 0.00721418f, 0.11501786f, 0.04440986f, 0.08542684f, -0.04048153f, 
    -0.01732070f, -0.02810026f, 0.11424142f, -0.06163679f, 0.11770763f, -0.07050815f, 0.18957701f, -0.07739554f, 
    0.15480140f, -0.00595445f, -0.09851091f, -0.06781860f, -0.10280999f, 0.00417564f, 0.09885715f, 0.17126004f, 
    -0.15064542f, -0.23878735f, -0.19651160f, -0.09270404f, 0.12461465f, 0.14440358f, 0.01612485f, -0.12392720f, 
    -0.03988296f, -0.07578723f, 0.00328751f, 0.05769214f, 0.21490160f, 0.11814644f, 0.02396489f, -0.10645466f, 
    -0.12723635f, -0.03021755f, 0.02167306f, -0.03814769f, -0.04518509f, 0.07400901f, -0.01983906f, 0.05786490f, 
    0.33378688f, 0.11074972f, -0.09091365f, -0.07786209f, -0.02263551f, 0.04917308f, 0.10356344f, 0.00066414f, 
    0.03378285f, 0.06271295f, 0.00175077f, 0.08244051f, 0.01574636f, -0.24191803f, -0.22637627f, -0.07978256f, 
    0.24304336f, 0.04910845f, 0.09749939f, -0.07944229f, -0.11420929f, -0.04298047f, -0.00064261f, 0.15914604f, 
    0.21567594f, 0.08314763f, 0.22595005f, -0.03206037f, -0.00998742f, 0.00624261f, -0.01964081f, 0.11392470f, 
    -0.01755377f, 0.09367385f, -0.15170972f, -0.02376337f, -0.28938827f, -0.19217141f, -0.09004221f, -0.02028368f, 
    0.13013725f, 0.06715602f, 0.05427466f, -0.12376553f, 0.16805470f, -0.05612386f, 0.01733325f, 0.00010938f, 
    0.00208234f, -0.00169780f, 0.09800580f, -0.07494475f, 0.04097039f, 0.02935516f, 0.04182028f, 0.06088951f, 
    0.11422552f, 0.08676869f, -0.04539496f, 0.00768111f, -0.11091387f, -0.05833885f, -0.07730130f, 0.07717932f, 
    0.14307132f, -0.07619732f, -0.10331938f, 0.01808577f, -0.10394173f, 0.06318216f, 0.05116083f, 0.02444898f, 
    -0.12267581f, -0.15893346f, 0.09965238f, 0.13310651f, 0.10139599f, -0.15657224f, -0.05069164f, -0.02906306f, 
    -0.05264777f, 0.07801334f, 0.04026334f, 0.05405527f, 0.19530058f, -0.09004747f, 0.00463969f, -0.07201638f, 
    0.00322977f, 0.05830043f, 0.11592012f, -0.07013869f, -0.08809699f, 0.12088647f, 0.03893603f, 0.16825727f, 
    -0.06509903f, 0.05898966f, -0.02517627f, -0.00492628f, 0.05916997f, 0.06537561f, 0.09166123f, -0.01717744f, 
    -0.01008861f, 0.09087970f, 0.08530525f, 0.16709948f, 0.27260286f, -0.08367611f, 0.10702854f, 0.09534165f, 
    -0.05431680f, 0.02225951f, 0.00635114f, -0.12511665f, -0.07119709f, -0.01952777f, -0.06918385f, 0.00758119f, 
    -0.00952247f, 0.13712108f, -0.13475099f, -0.19989800f, 0.10568696f, 0.12541647f, -0.10483767f, 0.01112737f, 
    -0.00344796f, 0.10231185f, 0.13832934f, 0.11637188f, 0.15560168f, 0.18716572f, -0.09107840f, -0.00515945f, 
    0.16995047f, -0.07628223f, 0.00068806f, 0.07129295f, 0.00570226f, -0.01649401f, 0.09667617f, 0.15853459f, 
    0.18872796f, 0.04400076f, -0.09393709f, 0.12342041f, -0.01632483f, 0.08081739f, -0.06736299f, -0.13398837f, 
    0.20901327f, -0.07638092f, 0.00228689f, -0.12260574f, -0.26672488f, 0.15687783f, 0.16121072f, -0.02778855f, 
    0.07483034f, -0.05756553f, 0.08749471f, 0.12163875f, 0.14240214f, 0.04930166f, -0.03386479f, 0.11005834f, 
    -0.22876398f, -0.11410617f, -0.09260236f, 0.16184966f, 0.02733805f, 0.07298413f, -0.04305198f, -0.12596211f, 
    -0.08189832f, -0.01634636f, 0.00528858f, -0.01926015f, -0.04237716f, -0.19035046f, -0.14067306f, 0.01673056f, 
    0.06496305f, 0.12947184f, -0.08800489f, 0.00605963f, -0.01866814f, 0.01781473f, 0.05215291f, 0.07367282f, 
    0.00841968f, -0.02408306f, 0.00581579f, -0.05979521f, 0.02298527f, -0.02770047f, -0.06067124f, -0.05457759f, 
    -0.03286245f, 0.03647554f, 0.03643243f, -0.05002035f, 0.02368706f, 0.04421688f, 0.04910585f, -0.01103097f, 
    -0.02671512f, -0.00155472f, -0.01351843f, -0.02540856f, -0.01922023f, 0.03481932f, -0.03189670f, 0.03398933f, 
    -0.03512524f, 0.03642019f, 0.03317910f, -0.05528149f, -0.02205929f, -0.01884784f, -0.04120475f, 0.02971251f, 
    -0.05075862f, -0.01444050f, -0.05697722f, -0.03489996f, -0.04978081f, -0.02367561f, -0.00263388f, -0.02444628f, 
    -0.04354687f, 0.00881225f, 0.01438348f, -0.01152376f, 0.02211726f, -0.01831483f, -0.04429618f, -0.05027711f, 
    -0.04335694f, -0.03701971f, -0.01504944f, 0.03710306f, -0.00242991f, -0.05360540f, 0.03197986f, -0.02402364f, 
    0.04248704f, -0.01076555f, 0.00015029f, -0.05183930f, -0.03320602f, 0.00274395f, 0.02053731f, -0.01849569f, 
    0.01026251f, 0.02895289f, -0.05665600f, -0.01547932f, -0.05458250f, 0.02541925f, 0.01494658f, -0.06172556f, 
    0.01292693f, -0.05961604f, 0.01367718f, 0.01234041f, 0.03041615f, -0.02334345f, -0.05609247f, 0.00968333f, 
    -0.02087128f, 0.02108759f, -0.05607384f, -0.00087785f, -0.02808767f, -0.01745665f, 0.00589244f, 0.02085446f, 
    0.03668474f, -0.00969657f, 0.03011404f, -0.02270162f, -0.02711066f, -0.04719199f, -0.01049318f, -0.04111193f, 
    -0.04964346f, -0.02483872f, -0.03341127f, -0.00413199f, -0.04357903f, -0.00709773f, -0.03050664f, -0.04512829f, 
    -0.04825967f, -0.05374901f, -0.01296514f, -0.02957317f, 0.02008614f, 0.01569797f, 0.00374071f, -0.01579153f, 
    0.02654758f, -0.02366284f, -0.02368017f, -0.01805424f, -0.03008099f, 0.02388594f, -0.05957488f, -0.06085352f, 
    -0.03065091f, -0.06159410f, 0.02171932f, 0.03159996f, 0.02914471f, -0.06374726f, -0.06186169f, 0.00966253f, 
    0.02555932f, -0.02721323f, 0.03541075f, 0.00153927f, -0.06383327f, 0.00270122f, -0.03754858f, -0.00244286f, 
    -0.04174656f, -0.00084810f, 0.02404768f, 0.01545462f, -0.05626776f, 0.01775079f, -0.06151696f, -0.00351355f, 
    -0.05088058f, 0.03149706f, 0.00556719f, -0.05432089f, 0.00565821f, -0.01323585f, 0.00377103f, 0.04984692f, 
    -0.05528079f, 0.02435491f, -0.00403705f, -0.05752604f, -0.04244050f, -0.05054300f, -0.03104960f, -0.04069648f, 
    -0.06341495f, 0.02756744f, 0.04296498f, 0.01848249f, -0.02878345f, -0.02596195f, -0.00621524f, 0.02105290f, 
    0.03033403f, -0.02645811f, 0.02898926f, -0.00287388f, -0.05712496f, -0.01557789f, -0.04664448f, -0.00665833f, 
    -0.01957123f, 0.01967211f, -0.03432179f, -0.02818937f, 0.03412708f, -0.02602510f, -0.03338378f, 0.03321116f, 
    0.03717017f, -0.04794753f, -0.03484251f, -0.03477277f, -0.03050824f, 0.02866132f, -0.04797291f, -0.02645337f, 
    -0.03407203f, -0.03318075f, -0.01451209f, -0.01164901f, -0.01337279f, 0.01584514f, -0.02997103f, -0.03265523f, 
    -0.04203152f, -0.04675964f, -0.02702279f, -0.00016060f, -0.05771057f, -0.04179446f, 0.03043473f, 0.00648770f, 
    -0.02503171f, 0.02817677f, 0.00096310f, -0.03121829f, -0.01696871f, -0.05682604f, -0.02863572f, -0.02034106f, 
    -0.03305104f, 0.00166184f, -0.05065182f, 0.01821775f, 0.03319194f, -0.02373041f, -0.04766039f, -0.05169054f, 
    0.00252720f, -0.03829437f, -0.06207979f, -0.02103089f, -0.03156924f, 0.00375980f, -0.05526491f, 0.00484095f, 
    -0.03145907f, -0.00712203f, -0.00824688f, 0.03214306f, -0.02617151f, -0.02354904f, 0.01804404f, -0.05408800f, 
    -0.00388125f, -0.05855884f, -0.03610728f, -0.04020615f, -0.04635356f, -0.02430984f, -0.00266549f, 0.00143998f, 
    -0.06236472f, 0.02336394f, -0.00308738f, 0.02351994f, -0.06102084f, -0.06266766f, 0.03631651f, -0.02668869f, 
    -0.06056917f, -0.05828483f, -0.03497855f, -0.03835385f, -0.04576439f, -0.05352814f, -0.04338371f, -0.01564880f, 
    -0.05663238f, -0.03663015f, -0.04929086f, -0.00571592f, 0.00025537f, -0.01905021f, -0.06161035f, -0.03475939f, 
    -0.05562126f, -0.04996778f, -0.02271840f, 0.00591782f, 0.00532674f, 0.02622010f, -0.04634851f, 0.00558411f, 
    -0.04472348f, -0.05406444f, 0.01478163f, 0.04259124f, -0.01107305f, -0.02305674f, -0.05897944f, -0.04467776f, 
    0.00873019f, -0.04453067f, 0.03236414f, 0.02565985f, 0.03193865f, -0.00502412f, -0.01191354f, -0.05796181f, 
    -0.01667091f, -0.04566059f, -0.03623736f, -0.01269720f, -0.06350084f, -0.01074030f, -0.05138178f, 0.02092584f, 
    -0.02834409f, -0.00965427f, -0.04181207f, 0.04224755f, -0.04430504f, 0.03518846f, 0.02656744f, 0.02989615f, 
    -0.00460974f, -0.00766419f, 0.01235221f, 0.01691927f, -0.00616017f, -0.05396806f, 0.02782664f, -0.03031879f, 
    -0.04619532f, 0.01679410f, -0.04718303f, -0.03120563f, -0.03430768f, 0.01570310f, 0.03529271f, 0.02149754f, 
    0.01801792f, 0.02442609f, 0.02416056f, -0.04054379f, 0.00882686f, -0.01041280f, -0.05328317f, 0.02733196f, 
    0.01610452f, 0.01377986f, -0.04539455f, -0.05217921f, -0.00718666f, -0.00707178f, 0.01772542f, -0.06443551f, 
    -0.02082346f, -0.02482047f, 0.03532058f, -0.04325565f, -0.02277012f, -0.02842284f, -0.01298248f, -0.04112769f, 
    0.05001961f, -0.01229405f, 0.03676125f, 0.03492736f, -0.04626630f, -0.00087919f, -0.01177337f, 0.00067004f, 
    -0.03186791f, -0.03193362f, -0.05581698f, -0.01535146f, -0.06329262f, -0.06005590f, -0.05284172f, -0.04365309f, 
    -0.05651537f, -0.02032145f, -0.00813208f, 0.00326356f, -0.03415312f, 0.01530068f, -0.05309362f, -0.06343926f, 
    0.03165643f, -0.02000695f, -0.00553516f, -0.04910877f, -0.06344453f, -0.05471136f, 0.02515919f, 0.02625364f, 
    -0.09656513f, -0.13931760f, -0.20311293f, -0.09325808f, 0.20119530f, -0.03018415f, 0.02160286f, -0.04960822f, 
    0.03427306f, 0.03557929f, 0.05599454f, 0.08766877f, -0.01579275f, -0.13817593f, -0.02967359f, 0.01660985f, 
    0.04453784f, 0.09634400f, -0.05276875f, 0.06872682f, 0.03518178f, -0.03358176f, -0.00763970f, -0.07616463f, 
    -0.06586365f, -0.27064645f, -0.14413123f, 0.11975864f, 0.04491488f, 0.02659625f, -0.16595349f, 0.00585950f, 
    -0.02555822f, 0.16212885f, 0.13025786f, -0.03793424f, 0.03387469f, -0.15470016f, -0.04030247f, 0.03671454f, 
    -0.13601846f, -0.04082176f, -0.01735950f, -0.03096337f, -0.04575690f, 0.17038471f, -0.13883653f, 0.10754002f, 
    0.05607960f, 0.00573700f, -0.12666282f, -0.00633210f, -0.05083568f, -0.00668843f, -0.02629820f, 0.03570841f, 
    0.06081142f, 0.01625665f, 0.01967104f, -0.05766188f, 0.31579474f, -0.07664747f, -0.28441116f, -0.01479047f, 
    0.02221936f, -0.02297924f, 0.16372675f, -0.10389282f, 0.00210572f, 0.00955864f, 0.04422878f, 0.01306071f, 
    0.00897837f, -0.03398224f, 0.07142804f, 0.10637227f, 0.08207317f, 0.02680308f, 0.11211433f, 0.04193009f, 
    -0.01237768f, 0.00682917f, 0.04104846f, -0.02726058f, 0.03224000f, -0.29890040f, 0.06503782f, -0.13523054f, 
    0.10019669f, -0.10329928f, -0.03833994f, -0.07340328f, 0.13862690f, -0.05034806f, -0.02225980f, 0.02265219f, 
    -0.02487766f, 0.03247187f, 0.12372731f, -0.19843088f, -0.10464635f, -0.16851357f, 0.08735808f, -0.04449883f, 
    0.03228128f, -0.18755250f, 0.09037793f, -0.03200710f, -0.14223048f, -0.05241318f, -0.16268180f, -0.10443094f, 
    0.05064495f, 0.06803147f, -0.02964620f, -0.00193150f, -0.05295478f, 0.01553533f, -0.10512108f, 0.03987839f, 
    0.22995180f, -0.08165763f, 0.14041924f, -0.09308772f, -0.03694033f, -0.01921106f, -0.02200678f, 0.07906634f, 
    0.04205724f, -0.00493742f, -0.10547784f, 0.06783192f, -0.11249856f, -0.18346499f, 0.04678597f, 0.20503917f, 
    -0.06339923f, -0.08898085f, 0.01393994f, 0.15112245f, -0.01300807f, 0.05646897f, 0.04497618f, 0.03250579f, 
    -0.05191854f, 0.26976532f, 0.11552831f, 0.14124495f, 0.12198380f, -0.11030091f, 0.03631020f, -0.05429395f, 
    0.04831610f, 0.02764390f, -0.04423019f, 0.10531880f, 0.18268706f, 0.16162804f, 0.02698646f, 0.03309996f, 
    -0.02388271f, -0.01702340f, 0.00269819f, -0.05646777f, -0.02350907f, 0.00558654f, 0.03384811f, 0.02127451f, 
    0.19162332f, 0.15918142f, 0.03532939f, 0.05073104f, 0.05348862f, -0.03512463f, 0.13024108f, 0.14317867f, 
    -0.05591274f, 0.05384609f, -0.02142485f, 0.00496019f, 0.24553281f, 0.15991454f, 0.13185221f, -0.01672236f, 
    -0.07193024f, 0.05298266f, 0.11761216f, 0.05849006f, -0.08707227f, 0.07671339f, 0.07171687f, -0.07729837f, 
    0.16424210f, 0.15737692f, -0.02561021f, 0.07491468f, -0.06919477f, -0.02057874f, -0.12155631f, 0.01281356f, 
    -0.14437045f, 0.10653991f, 0.00928869f, -0.00294936f, 0.16811727f, 0.17569304f, 0.10700547f, 0.02642215f, 
    0.01398395f, -0.01860232f, 0.05358588f, 0.04575565f, 0.00761381f, -0.02332147f, -0.03681060f, -0.04874375f, 
    0.13343775f, 0.00281916f, 0.02372417f, 0.12225165f, 0.04977474f, 0.07743202f, -0.01922840f, 0.04796608f, 
    0.00829423f, -0.07792320f, 0.12607934f, -0.05408573f, 0.27702951f, 0.07621318f, 0.12493800f, 0.07372910f, 
    -0.00735679f, 0.00904916f, 0.10803242f, 0.06740911f, -0.00826353f, 0.04563636f, -0.14679880f, 0.22816338f, 
    0.10609132f, -0.09847765f, -0.08249867f, 0.01861337f, 0.05483830f, 0.00831978f, 0.03855500f, -0.11658026f, 
    0.09412981f, 0.04520595f, 0.09864408f, 0.18377668f, 0.09492863f, -0.13417873f, -0.12221435f, 0.03553680f, 
    0.06498246f, -0.04453066f, -0.06885978f, 0.03096674f, -0.06626275f, 0.04210252f, -0.01903857f, 0.00041889f, 
    0.09790204f, -0.25668332f, 0.03534136f, -0.04224800f, -0.05082685f, 0.12888399f, -0.06546557f, 0.07238091f, 
    0.01767321f, -0.13062225f, 0.02224870f, -0.12164700f, 0.22798663f, 0.12028977f, 0.11243810f, 0.01511236f, 
    -0.07716029f, 0.02632761f, -0.10837968f, -0.07995939f, -0.05316280f, 0.03880834f, -0.01608410f, -0.03236690f, 
    -0.20004797f, -0.03505551f, 0.00535338f, -0.24285097f, -0.02180301f, -0.03913540f, 0.07104470f, 0.01771071f, 
    0.02062129f, -0.03759669f, 0.08333449f, -0.00653254f, 0.25920272f, -0.09070709f, -0.05404548f, -0.06689572f, 
    0.02821909f, 0.03802905f, -0.03184688f, 0.02832654f, -0.04689457f, 0.01343536f, 0.01933471f, -0.00679792f, 
    -0.10172348f, 0.05147865f, -0.29636121f, -0.11358146f, -0.02922585f, 0.12486655f, -0.05902785f, -0.06179629f, 
    -0.05757581f, 0.01060968f, 0.03635830f, 0.07952017f, 0.16016905f, -0.20192084f, -0.23413137f, -0.18320134f, 
    -0.04034366f, -0.01740066f, 0.06426959f, -0.01645520f, 0.15089606f, 0.02254806f, -0.13727903f, -0.04390224f, 
    0.13410933f, -0.20086339f, -0.27752697f, -0.18552144f, -0.08722445f, 0.14065345f, 0.01886166f, -0.07932930f, 
    -0.02330841f, -0.15738064f, 0.05039010f, -0.02384553f, 0.02193687f, 0.22715236f, -0.10009222f, 0.17829975f, 
    -0.02726432f, 0.06167207f, -0.12785105f, 0.09419826f, -0.19686210f, 0.08120041f, 0.03010615f, -0.08965398f, 
    0.21334255f, 0.15062931f, 0.02215534f, 0.07529892f, 0.02565524f, -0.06410428f, 0.05324612f, -0.02818167f, 
    0.06878655f, 0.08273337f, 0.02126259f, -0.01150438f, 0.31209043f, 0.09953160f, 0.12996006f, -0.03626616f, 
    0.08751323f, -0.01279963f, 0.17100731f, -0.03877207f, 0.20221865f, -0.09964359f, 0.09857307f, 0.13829461f, 
    -0.04261729f, -0.02340420f, 0.03840321f, -0.01856817f, -0.04628004f, -0.01275780f, -0.02349811f, 0.02147007f, 
    0.03282958f, 0.02007670f, -0.02039399f, -0.01868679f, 0.03654740f, 0.02175483f, 0.03453493f, 0.02320885f, 
    -0.05142517f, 0.02428589f, 0.02040557f, 0.03104369f, -0.02072555f, -0.02688984f, -0.01224499f, -0.00576459f, 
    -0.00052134f, 0.00978636f, 0.03830150f, -0.04136915f, 0.02938366f, 0.00749650f, -0.04597468f, -0.01267998f, 
    -0.04167103f, 0.01923854f, -0.04053901f, 0.02753101f, 0.04188653f, -0.01323061f, 0.03107348f, -0.02885392f, 
    -0.01551341f, 0.03631653f, -0.02421837f, -0.05282744f, 0.00557010f, 0.03097485f, -0.00302981f, -0.01463098f, 
    -0.03230024f, -0.05363410f, -0.04440366f, 0.00592535f, 0.03600172f, 0.03014036f, -0.00545784f, -0.03681281f, 
    -0.01220278f, -0.04639417f, 0.01943368f, -0.02238736f, -0.01466461f, -0.03823146f, 0.00398514f, 0.02253020f, 
    -0.03385998f, -0.02658588f, -0.00546694f, 0.03217310f, -0.00285649f, -0.01397532f, -0.03697107f, -0.01314145f, 
    0.00859109f, -0.00434933f, -0.01326660f, 0.02345239f, -0.01025976f, -0.01282144f, 0.02929519f, -0.03772490f, 
    -0.05274906f, 0.02482564f, 0.00315770f, 0.03618338f, -0.04580253f, -0.02983643f, 0.02733926f, 0.02026044f, 
    -0.04691299f, -0.05031454f, -0.01857138f, -0.00888967f, -0.00565715f, -0.01518308f, 0.03776003f, -0.02754956f, 
    -0.02710333f, 0.03199169f, -0.00637405f, -0.02197421f, -0.00705704f, -0.04822076f, 0.00806261f, 0.00908965f, 
    0.00997999f, -0.04168174f, 0.04051484f, -0.04465948f, 0.03845047f, -0.02791750f, -0.00571196f, -0.00618716f, 
    -0.05783444f, -0.05103216f, 0.02120131f, -0.03930900f, 0.00553498f, -0.03404191f, 0.01439807f, -0.01724769f, 
    -0.05455000f, -0.00733200f, 0.01463360f, 0.00507685f, -0.03341353f, -0.00503145f, -0.00945907f, 0.00503610f, 
    0.01258473f, -0.01837959f, -0.02271838f, -0.02348142f, 0.00757981f, 0.02901910f, 0.00387007f, 0.02114205f, 
    0.00157844f, -0.03256978f, 0.04121557f, -0.05367053f, -0.05309218f, 0.00933151f, -0.04575415f, -0.02632434f, 
    0.02329165f, 0.00059198f, 0.03908018f, 0.03714055f, -0.02895495f, -0.00350265f, -0.03703503f, -0.02071758f, 
    -0.00743649f, 0.02235396f, -0.04572618f, 0.00613594f, -0.00044642f, 0.02854546f, -0.00881395f, -0.03574014f, 
    -0.02085930f, -0.01201698f, -0.04076935f, 0.01604564f, -0.01826052f, -0.02959124f, -0.02982222f, -0.00324557f, 
    0.03318506f, -0.04260375f, 0.04275445f, 0.04446346f, 0.00945594f, 0.04583946f, 0.00180927f, -0.01267399f, 
    0.02830791f, 0.01625108f, -0.04153550f, -0.04379397f, -0.02009594f, -0.01133235f, -0.00536755f, 0.04032143f, 
    0.00545760f, -0.02974870f, 0.04326980f, -0.05022641f, 0.00621010f, -0.04102892f, 0.00866668f, 0.00668864f, 
    0.02863360f, -0.01852318f, 0.00691887f, -0.01826991f, 0.04013254f, -0.01814474f, 0.04347380f, -0.03816938f, 
    0.03770394f, -0.03223269f, -0.03275339f, -0.04037504f, 0.01354908f, 0.00750381f, 0.00987919f, 0.01961203f, 
    0.03151726f, -0.00535788f, 0.03665016f, 0.02379057f, 0.01632230f, 0.03607258f, -0.00108740f, -0.00706442f, 
    -0.05277130f, 0.00117570f, 0.00475574f, 0.04183947f, 0.02376192f, 0.02582706f, -0.01293078f, 0.03826573f, 
    -0.02948556f, -0.05474469f, -0.02731913f, -0.02837145f, -0.00788180f, 0.04212067f, -0.04523718f, 0.01639744f, 
    -0.02856036f, -0.03106923f, -0.05624037f, -0.05146379f, -0.05407729f, 0.02832663f, -0.05408688f, 0.03039731f, 
    0.01856216f, -0.04829759f, -0.04209364f, 0.03215931f, 0.03339959f, 0.03391795f, -0.01948887f, -0.02697369f, 
    -0.04001016f, -0.05300159f, 0.00376401f, -0.00306037f, -0.03247778f, -0.03709229f, 0.02848772f, -0.03234600f, 
    -0.05366571f, -0.01137911f, -0.02357616f, 0.00419082f, -0.02594001f, 0.00086428f, -0.05562559f, -0.03460439f, 
    -0.05303050f, -0.02082599f, -0.01399361f, -0.01692932f, -0.04534264f, -0.03511153f, -0.02975240f, -0.03928888f, 
    -0.05080827f, -0.03165477f, 0.01413029f, -0.05512562f, 0.02435455f, -0.04626664f, -0.03582856f, 0.03069462f, 
    -0.03013004f, -0.00640533f, -0.02432719f, 0.00166346f, 0.00135261f, -0.01585404f, 0.03209613f, -0.04450001f, 
    -0.04767487f, 0.01463860f, 0.01827072f, -0.03093536f, -0.02364567f, -0.00704521f, 0.03634657f, -0.04397792f, 
    -0.00248648f, 0.03532403f, -0.04190699f, -0.03993990f, 0.02151030f, -0.03877909f, -0.01107983f, 0.03150082f, 
    -0.00354255f, -0.04890666f, -0.02349355f, 0.01985334f, 0.02931217f, 0.02501357f, 0.03948590f, -0.00926077f, 
    0.02372063f, 0.03545865f, -0.02261821f, -0.02811781f, 0.01432794f, 0.01449604f, 0.02487315f, -0.01392178f, 
    0.01170177f, -0.00616984f, -0.03337729f, -0.02095313f, -0.00502405f, -0.04071433f, 0.02487267f, 0.03881839f, 
    0.03089496f, -0.01649525f, -0.03263989f, 0.02953864f, 0.03746666f, 0.03272300f, -0.04725698f, -0.03659346f, 
    -0.00885289f, 0.04207915f, -0.02073075f, -0.00662434f, 0.01840862f, -0.00539476f, 0.01620255f, -0.02652891f, 
    -0.02227324f, 0.03211705f, 0.03645815f, -0.03906238f, -0.04529354f, 0.02866738f, 0.02684984f, 0.01619903f, 
    0.02576331f, 0.04114048f, -0.00383482f, 0.01510165f, 0.00641312f, 0.04220965f, -0.05624438f, -0.00630492f, 
    -0.05168445f, -0.05400386f, 0.02897768f, -0.02073323f, 0.01889941f, 0.01664030f, 0.03205690f, -0.02016898f, 
    0.00662791f, 0.00820573f, -0.00710451f, 0.01164377f, 0.04595385f, 0.00197936f, -0.02822469f, -0.02963995f, 
    0.01808645f, -0.02054854f, -0.04428796f, 0.03556794f, 0.02350897f, -0.03233053f, 0.02467872f, -0.00452209f, 
    -0.05346268f, -0.00169532f, -0.05215831f, 0.02115525f, 0.03328069f, -0.05332541f, -0.03334218f, -0.05656661f, 
    -0.00846977f, -0.01661630f, -0.00454568f, -0.03084534f, 0.02585860f, -0.05542302f, 0.01318859f, -0.01373990f, 
    -0.02000342f, -0.04672941f, -0.00605461f, -0.02081192f, -0.02347846f, 0.00153982f, 0.02668398f, 0.03115285f, 
    0.00945557f, -0.04381713f, -0.00938586f, -0.00935053f, -0.00816160f, -0.03277991f, -0.00936770f, 0.00096083f, 
    -0.03232034f, 0.01543704f, -0.05123959f, -0.02290798f, -0.05818788f, -0.02016486f, 0.00569062f, -0.00934940f, 
    0.01613533f, 0.01579823f, -0.05143753f, 0.04306782f, -0.03948651f, -0.04221406f, -0.00479078f, -0.02917344f, 
    0.00744198f, 0.03132964f, 0.02447866f, -0.02999081f, 0.00321046f, -0.01345730f, -0.05622172f, -0.00862597f, 
    -0.01130681f, -0.04323129f, -0.05074947f, 0.00410994f, -0.00941279f, 0.02810737f, 0.03666237f, -0.03341432f, 
    0.03673808f, 0.01084596f, -0.00586958f, -0.06019729f, 0.02352950f, -0.05491465f, -0.06731057f, -0.03498565f, 
    0.00800698f, -0.03613615f, -0.04980820f, -0.05509968f, 0.00977960f, -0.02225621f, 0.03609573f, -0.05351207f, 
    0.00393849f, -0.05159625f, 0.00645727f, -0.05060301f, 0.03949123f, -0.03044013f, 0.00444772f, -0.03124036f, 
    0.02771930f, -0.01787972f, 0.00725559f, -0.00689082f, -0.02443676f, -0.00131931f, 0.03612425f, -0.01454267f, 
    0.02047244f, -0.00023337f, -0.05100019f, 0.00012196f, 0.01314722f, 0.02775325f, 0.02477067f, 0.02846343f, 
    -0.05427685f, -0.00306461f, -0.03237811f, -0.01830679f, -0.01477734f, -0.04812545f, -0.05501927f, -0.05837477f, 
    0.00566048f, -0.04421663f, -0.02650409f, -0.00634780f, -0.03727980f, -0.01443124f, -0.05222712f, -0.04785639f, 
    -0.02644131f, -0.00193363f, -0.00531955f, 0.01015211f, -0.00075045f, 0.01162228f, -0.00143445f, -0.01899044f, 
    0.03354717f, -0.01270581f, 0.00000060f, -0.04022973f, 0.01810885f, -0.00656528f, -0.05542786f, -0.03321682f, 
    -0.02458414f, 0.02918193f, 0.00893988f, -0.02722798f, -0.05726387f, 0.04271643f, -0.05937404f, -0.00147997f, 
    0.02061006f, 0.02484738f, 0.03127185f, 0.01870130f, -0.01511109f, -0.05395588f, -0.03896976f, -0.00006758f, 
    -0.00205461f, 0.01835864f, -0.01406310f, -0.04867557f, -0.02562130f, 0.01944409f, -0.03015938f, 0.00404603f, 
    -0.03903924f, -0.03280419f, 0.00901053f, 0.02759516f, 0.01130453f, -0.04371655f, 0.02043641f, -0.00592369f, 
    -0.05520742f, -0.00070534f, 0.05364934f, 0.01341065f, 0.00836335f, -0.05659407f, 0.00229712f, -0.05250873f, 
    -0.04531526f, -0.01241615f, 0.01372600f, -0.04668917f, -0.04998986f, 0.00585366f, -0.04008536f, 0.00966946f, 
    0.00111055f, -0.03676206f, -0.03737850f, 0.03007378f, 0.03735235f, 0.01607853f, -0.00696340f, -0.00272833f, 
    0.02310610f, -0.00127146f, 0.00161542f, -0.05968121f, -0.05791850f, -0.03781179f, -0.02479953f, -0.05364794f, 
    0.02294376f, -0.02073063f, 0.01829142f, 0.00094538f, 0.02188865f, -0.00715521f, 0.04242632f, -0.05484824f, 
    0.03616353f, -0.02378046f, -0.03204888f, -0.06272497f, -0.00724718f, -0.00064522f, 0.00637374f, 0.01755355f, 
    -0.05399881f, 0.01175114f, -0.01186042f, 0.02534925f, 0.01701299f, 0.00668801f, -0.02326659f, -0.03495525f, 
    -0.01292680f, 0.02471021f, 0.01932945f, 0.02864918f, 0.04638968f, -0.01458339f, -0.01898471f, -0.02251728f, 
    0.00632604f, -0.04445039f, -0.05153108f, -0.01374367f, 0.02227655f, -0.03864808f, -0.02847691f, -0.04861793f, 
    -0.03876089f, -0.01743966f, 0.03265399f, 0.01576516f, 0.03197040f, -0.05688098f, 0.02191450f, -0.03505925f, 
    0.00043620f, -0.02743592f, 0.03859230f, 0.01859572f, -0.05375732f, 0.00914402f, -0.04169660f, 0.04492632f, 
    -0.01862978f, 0.03089547f, -0.04159742f, 0.01071310f, 0.01764529f, -0.04208802f, 0.02444078f, -0.04318575f, 
    -0.03292024f, -0.00575530f, 0.00235990f, -0.03609879f, -0.00031560f, -0.04738657f, -0.03585920f, -0.03799705f, 
    -0.01804679f, 0.00857892f, -0.02440638f, 0.03727809f, -0.01162171f, -0.04999969f, -0.03124773f, -0.01273005f, 
    -0.03934834f, -0.01686135f, 0.00251562f, -0.02598047f, -0.00508213f, 0.02680125f, -0.04217049f, 0.00613441f, 
    -0.05292889f, 0.03867655f, 0.00994442f, -0.04603207f, -0.04101960f, -0.04319753f, -0.05076581f, -0.00991390f, 
    -0.01761575f, -0.04659201f, 0.03445465f, 0.02661382f, 0.03853024f, -0.01917799f, -0.04830794f, -0.05680526f, 
    0.03132468f, -0.02289500f, -0.03691474f, -0.00113709f, -0.01436885f, -0.02068730f, 0.02023651f, -0.04667339f, 
    0.01352393f, 0.00827885f, 0.02680710f, 0.04060060f, 0.01290560f, 0.02439437f, 0.03712866f, 0.01260526f, 
    0.00225292f, 0.02248915f, 0.02417061f, 0.01132891f, -0.00841595f, -0.03434790f, 0.02329241f, 0.01609441f, 
    0.03232475f, -0.01372457f, -0.03721901f, -0.00045395f, -0.00801417f, 0.01917977f, 0.02776521f, -0.02964599f, 
    0.02371123f, -0.01136959f, 0.03809720f, -0.01456934f, -0.02693382f, -0.03452020f, -0.02936383f, -0.03245472f, 
    -0.01208192f, -0.04044685f, -0.05085300f, -0.02192511f, -0.03309862f, 0.00817078f, -0.02174181f, 0.02669066f, 
    -0.03993930f, 0.03075171f, -0.00198620f, -0.05407915f, -0.00017768f, -0.02561751f, 0.00100594f, -0.04998398f, 
    -0.00450027f, -0.00715962f, 0.00949952f, -0.01409461f, 0.00303222f, 0.00742494f, -0.00921540f, 0.00716122f, 
    0.01974497f, -0.05049242f, -0.00085297f, -0.05339713f, 0.04247097f, -0.04287324f, -0.01211021f, -0.03230092f, 
    -0.01539264f, -0.04952346f, -0.03309542f, 0.00443295f, -0.00246523f, -0.00262868f, 0.01023892f, 0.02504835f, 
    -0.00437665f, -0.05066953f, -0.00964284f, -0.01702701f, 0.01928552f, -0.03087786f, -0.01807328f, -0.04235241f, 
    0.01122814f, 0.00026878f, -0.02908767f, -0.04163477f, -0.02302521f, 0.04277310f, -0.03441318f, -0.04208584f, 
    0.02092827f, 0.01327405f, 0.00403949f, 0.04412881f, -0.02404841f, -0.00108190f, 0.04180673f, 0.01679654f, 
    0.02406614f, -0.05244393f, 0.04392478f, -0.05461438f, -0.03605282f, 0.03659536f, 0.02079394f, -0.00563263f, 
    -0.04869789f, 0.01449432f, -0.01789885f, 0.03251650f, 0.03958586f, -0.00523849f, 0.01228709f, -0.02588611f, 
    -0.02365768f, 0.03039956f, -0.05329098f, 0.03299672f, -0.01515933f, -0.01626705f, -0.04176143f, -0.04688932f, 
    -0.00384150f, 0.02339898f, -0.02742071f, -0.01014330f, -0.04601719f, 0.00894274f, -0.04584120f, 0.01335480f, 
    -0.01939612f, -0.03944362f, 0.03523861f, -0.04525463f, 0.00969987f, 0.03736616f, 0.00602324f, 0.01057553f, 
    0.02345043f, 0.00739584f, 0.02364927f, 0.01420782f, -0.04016392f, 0.01271064f, 0.00621123f, -0.04163328f, 
    -0.03475400f, -0.02213562f, -0.00246973f, 0.04214842f, -0.02094476f, -0.00448412f, -0.03837452f, -0.04540975f, 
    -0.01961046f, -0.05235100f, -0.04922756f, -0.05680598f, -0.05197731f, 0.02183671f, -0.00452422f, -0.04144981f, 
    0.03139599f, -0.04103983f, 0.03689142f, -0.04324911f, 0.01912472f, -0.00925369f, 0.03652992f, 0.02830853f, 
    -0.00686383f, 0.03757585f, 0.02851127f, 0.00483897f, 0.02005861f, -0.03789700f, -0.02726239f, 0.00397611f, 
    -0.04545226f, -0.05339354f, 0.01428340f, -0.03252656f, -0.04571423f, -0.01403031f, -0.03391020f, 0.01252217f, 
    0.02374237f, -0.03683005f, 0.00326654f, -0.03343910f, -0.03753472f, 0.02638382f, -0.05223114f, -0.00636768f, 
    0.03927281f, 0.04047814f, -0.01852023f, 0.00001030f, -0.02869422f, 0.02729973f, -0.04741193f, 0.03784583f, 
    -0.05113895f, -0.00055709f, -0.02659198f, -0.03475225f, 0.01176542f, -0.04239677f, -0.01122728f, -0.00821243f, 
    -0.03260227f, 0.01870796f, -0.04287147f, -0.04379304f, 0.02682988f, -0.02070419f, 0.00750992f, 0.02857733f, 
    0.02726669f, -0.01356142f, 0.04303512f, -0.05488941f, 0.04259356f, -0.02581122f, 0.01517991f, -0.00118974f, 
    0.00077538f, -0.01227018f, -0.01352169f, -0.04790157f, -0.01494831f, -0.00233825f, 0.01397237f, 0.00535411f, 
    -0.04791567f, 0.01837397f, -0.05590358f, -0.05580569f, -0.02582290f, -0.04729541f, 0.00006951f, 0.03231959f, 
    0.00884800f, -0.00768950f, -0.01268122f, -0.01980672f, 0.04364312f, -0.03109308f, -0.01793060f, -0.00959330f, 
    0.03451967f, -0.01189951f, -0.03441640f, 0.04205863f, -0.00882704f, -0.03295738f, -0.01395734f, -0.01805852f, 
    -0.04525031f, -0.01622831f, -0.00598620f, -0.03427260f, -0.04942559f, 0.04016785f, 0.01207244f, -0.03379441f, 
    0.00068069f, -0.01058314f, -0.00476353f, 0.03960733f, -0.01701977f, 0.01074227f, 0.01428380f, -0.04072828f, 
    -0.03296269f, 0.03954123f, -0.02375978f, 0.02556636f, -0.00062240f, 0.01017463f, 0.02968057f, -0.00134190f, 
    0.04482738f, 0.01184468f, -0.02795963f, -0.05286565f, 0.04307988f, -0.05075714f, 0.01458970f, 0.01940676f, 
    -0.04849816f, -0.05699630f, 0.02963393f, 0.04180789f, -0.03574466f, 0.04481271f, 0.01766190f, -0.02626202f, 
    -0.04748467f, 0.03150729f, -0.04448980f, -0.03027927f, 0.00771251f, 0.02749775f, 0.04084290f, 0.01328883f, 
    0.00961807f, -0.05333170f, 0.01701691f, 0.00201852f, -0.02446503f, -0.03979942f, -0.02495937f, -0.05318448f, 
    0.03466040f, 0.02877551f, -0.05031698f, -0.04389398f, 0.02404867f, 0.00877315f, 0.00111007f, 0.04409659f, 
    -0.05142760f, -0.00664607f, -0.01827063f, 0.00502415f, 0.02391468f, -0.03994443f, -0.05156056f, 0.02389614f, 
    0.02789699f, 0.03581339f, -0.04612314f, 0.00896803f, -0.04302184f, -0.04621539f, -0.05558479f, -0.01324541f, 
    -0.00819857f, -0.01252829f, -0.00740341f, -0.03843718f, 0.02026127f, -0.00863296f, -0.02473740f, 0.01237451f, 
    -0.02790486f, 0.04022318f, 0.03110422f, 0.04099545f, 0.02252620f, -0.03326597f, -0.00474180f, 0.03109956f, 
    -0.02352200f, -0.00846625f, -0.02174665f, -0.03844044f, 0.03797227f, -0.02723372f, 0.01942668f, 0.01791238f, 
    -0.04394086f, 0.00346829f, -0.00924566f, -0.01448475f, -0.04191310f, -0.02279656f, -0.05437083f, -0.00576448f, 
    0.03672662f, -0.05302787f, -0.01318630f, 0.04020311f, -0.01142833f, 0.03386031f, -0.02198743f, -0.00658341f, 
    0.04223169f, -0.05006297f, 0.00431441f, -0.05516360f, -0.05563145f, -0.04508287f, 0.00536281f, -0.02947147f, 
    0.01471215f, -0.03772157f, -0.01700906f, -0.02299538f, -0.01121956f, 0.02598841f, 0.00374183f, -0.00756917f, 
    0.00071027f, -0.03552081f, 0.03479651f, -0.00167607f, -0.01909949f, -0.01964131f, 0.02914515f, 0.03284777f, 
    0.03313654f, 0.02795873f, 0.02165963f, 0.03838278f, 0.03790229f, 0.01885523f, -0.00060262f, -0.02081109f, 
    -0.00198446f, 0.03412746f, -0.00497595f, -0.04968827f, 0.02639850f, 0.00258176f, -0.03726428f, 0.04260208f, 
    -0.00072506f, 0.02208600f, -0.05159597f, 0.02396354f, -0.04780382f, -0.00083415f, -0.01707572f, -0.00659437f, 
    -0.04348455f, -0.01289184f, 0.03947742f, -0.04906306f, 0.00374927f, -0.02249511f, 0.02781767f, 0.02463299f, 
    -0.05543566f, -0.04428418f, -0.00216135f, 0.00173301f, -0.01250877f, -0.05323086f, -0.04367075f, -0.00022920f, 
    -0.03020679f, 0.01627938f, 0.00185114f, 0.00022272f, 0.02691767f, -0.03079404f, -0.00987440f, 0.03846770f, 
    0.03038741f, -0.00416632f, -0.04469818f, 0.00686788f, 0.02432133f, 0.03210721f, -0.03967056f, -0.00935755f, 
    0.03128434f, 0.00646067f, -0.03932428f, 0.04241595f, -0.02765188f, -0.01343794f, -0.03623604f, 0.00048557f, 
    -0.01567584f, -0.03445031f, -0.05308711f, 0.03164413f, -0.02573822f, -0.03616248f, 0.01905103f, 0.04161711f, 
    -0.02520239f, -0.00426332f, 0.00071247f, 0.01016757f, -0.05691967f, -0.00188700f, -0.00706442f, 0.02109187f, 
    -0.03176824f, 0.00842581f, 0.03616304f, 0.00967275f, 0.00964872f, -0.00873445f, -0.05617989f, -0.05508710f, 
    0.00141252f, 0.01463630f, -0.01533612f, 0.02503019f, 0.03444383f, -0.05441343f, -0.01381374f, -0.01916358f, 
    -0.04328132f, 0.02698326f, -0.04429191f, 0.02888738f, -0.00339198f, 0.02517691f, 0.04301769f, -0.03156011f, 
    0.03967479f, 0.01258479f, -0.03895428f, 0.02691299f, -0.04489042f, 0.02434167f, 0.02463113f, -0.01841591f, 
    0.01820247f, 0.03732578f, -0.05176862f, -0.00816616f, -0.02489192f, -0.00343585f, -0.05175254f, -0.00539404f, 
    -0.02201430f, 0.03226772f, -0.03561465f, 0.02572583f, 0.04349913f, -0.02198455f, 0.01395553f, -0.03026299f, 
    0.00611053f, 0.01546603f, -0.02063703f, -0.03035164f, -0.00439927f, -0.05315874f, 0.02620359f, -0.01694793f, 
    -0.02756149f, -0.04032711f, -0.01659513f, -0.02404476f, -0.05403534f, 0.03354755f, -0.04324996f, -0.04609847f, 
    -0.05505716f, -0.05534806f, -0.05086172f, -0.03885311f, -0.04602951f, -0.04471481f, -0.01673108f, -0.04222238f, 
    -0.02051931f, 0.04482090f, -0.00197735f, -0.04371092f, 0.03086536f, -0.03811547f, 0.01664754f, 0.00406550f, 
    0.02467219f, -0.01584039f, 0.04063887f, -0.05393030f, -0.01666724f, -0.01201974f, -0.03353270f, -0.02676710f, 
    -0.02496608f, -0.00520700f, 0.04330982f, -0.03841575f, 0.01149997f, 0.02177421f, -0.01735279f, 0.00010704f, 
    -0.05480545f, 0.02361624f, -0.03434937f, -0.01948374f, -0.02255619f, 0.03382573f, -0.01490081f, 0.04377774f, 
    0.00235932f, -0.02983029f, -0.03856596f, -0.02549217f, 0.03301755f, -0.00630770f, 0.03880938f, -0.03232042f, 
    -0.02892214f, -0.01066294f, -0.05284274f, 0.02754974f, 0.03243285f, -0.01304175f, -0.02685747f, -0.05684281f, 
    -0.01820060f, -0.02858786f, -0.02723614f, -0.02668628f, -0.01828423f, 0.01248753f, 0.00714113f, -0.01979616f, 
    -0.05659195f, 0.00688277f, -0.01829738f, 0.03575237f, -0.04976097f, 0.00022370f, 0.04027714f, -0.03464123f, 
    0.03870094f, 0.04016948f, 0.04345036f, -0.01956112f, -0.05384687f, -0.00462397f, 0.00707604f, -0.01660960f, 
    -0.01282235f, -0.01398222f, -0.00478314f, 0.03640610f, 0.02857609f, -0.04436862f, 0.02395533f, 0.00524557f, 
    0.04476484f, 0.00789541f, 0.00000157f, -0.04491453f, -0.01177992f, -0.02569265f, -0.04711873f, 0.01502491f, 
    -0.01247595f, -0.00398999f, 0.02855085f, 0.02345977f, 0.01702814f, -0.04252926f, 0.02138655f, -0.00521225f, 
    -0.01502879f, -0.00614221f, 0.00783475f, 0.04394580f, 0.01252836f, 0.00593796f, -0.04775167f, 0.03316660f, 
    0.01105761f, -0.05091199f, -0.01906276f, -0.05048249f, -0.02428839f, -0.01671093f, 0.02671038f, 0.02327667f, 
    0.00593558f, -0.01717658f, -0.02250449f, 0.01892991f, -0.03724789f, -0.03192052f, -0.04506385f, -0.01557930f, 
    -0.02075982f, -0.03108357f, -0.05158137f, 0.01042445f, -0.02753141f, 0.00369864f, -0.03896567f, -0.00493126f, 
    -0.03620285f, 0.01142680f, -0.04824121f, -0.05340266f, -0.00792632f, 0.00891640f, 0.04161140f, 0.02875075f, 
    -0.01827890f, 0.00771840f, -0.03238863f, -0.03916987f, 0.02889944f, -0.02335197f, -0.04668690f, 0.00090079f, 
    -0.01773105f, -0.05016332f, -0.03011416f, -0.02108932f, -0.03408964f, 0.01771794f, 0.00852281f, -0.01672236f, 
    -0.00615224f, 0.03883917f, 0.00722834f, -0.00106680f, -0.04305596f, -0.05244398f, 0.00254290f, -0.03294151f, 
    0.04398156f, -0.01822726f, -0.03228761f, 0.03434844f, 0.00521706f, -0.01550283f, -0.03067103f, -0.02585059f, 
    -0.00030222f, 0.00485748f, 0.01536172f, -0.00010352f, -0.01339342f, 0.01074103f, 0.03661853f, -0.04822903f, 
    0.00949359f, -0.01789354f, -0.01524945f, -0.02876046f, -0.01010133f, -0.04121620f, 0.00414079f, -0.05244970f, 
    0.01807356f, -0.00931610f, -0.02613783f, 0.03182486f, -0.03167825f, -0.01877972f, 0.00908188f, -0.00258131f, 
    -0.03246314f, -0.02530280f, -0.02925141f, 0.04410439f, 0.01619435f, 0.02085903f, 0.00013962f, -0.04516369f, 
    0.01749922f, 0.01073461f, -0.00741872f, 0.04309639f, 0.01535095f, 0.02195494f, 0.03135732f, -0.01883293f, 
    -0.03677532f, 0.03946270f, -0.02315303f, 0.01473895f, -0.04719071f, -0.03787562f, -0.05625505f, -0.03544129f, 
    0.01305684f, 0.02331188f, 0.03265259f, 0.02938066f, 0.02252311f, -0.05689665f, -0.04906387f, -0.00572349f, 
    0.03675539f, 0.01529177f, -0.05066083f, -0.02657477f, -0.03797830f, 0.01701930f, -0.01065222f, -0.01235938f, 
    -0.04927922f, 0.01220377f, 0.01388547f, -0.00229848f, -0.00597423f, 0.02280002f, -0.02675171f, 0.03415168f, 
    -0.04641907f, 0.01619424f, -0.04730342f, -0.00631672f, 0.02995351f, -0.01107530f, 0.00237935f, -0.03540148f, 
    0.03533332f, 0.01270730f, 0.01073068f, 0.04138192f, -0.00577094f, 0.03783187f, -0.05352357f, -0.03573737f, 
    0.02349144f, 0.02827424f, -0.02846650f, -0.03103825f, -0.02842603f, -0.03606623f, -0.03126518f, 0.02982524f, 
    0.03264506f, 0.04343782f, -0.04714767f, -0.04390176f, 0.03306258f, -0.00398675f, 0.03385579f, 0.04468437f, 
    0.00041617f, -0.00962327f, 0.02259344f, 0.02621436f, -0.02373199f, -0.02546854f, 0.00204674f, -0.02387539f, 
    -0.01526425f, 0.01894926f, 0.01525052f, 0.03400931f, 0.04245473f, -0.03065588f, 0.02860234f, 0.04456493f, 
    0.09301678f, -0.02326080f, 0.06379496f, 0.03248651f, 0.08529542f, 0.08096520f, -0.01726109f, 0.00727988f, 
    -0.09243200f, -0.02750991f, 0.08292528f, -0.04063664f, -0.28756070f, 0.16437824f, -0.01089681f, -0.09274764f, 
    0.10610230f, 0.10007257f, -0.00874321f, 0.10362143f, -0.02146049f, -0.15532923f, -0.05024558f, -0.27828485f, 
    0.09029033f, -0.06232464f, -0.24812482f, 0.19308501f, 0.00627567f, 0.11336767f, 0.17224869f, 0.12728471f, 
    -0.02243577f, 0.17547631f, 0.04952947f, 0.00064394f, -0.00549343f, 0.03358898f, -0.11770472f, 0.12498832f, 
    0.10774631f, 0.05611100f, -0.00425147f, -0.08119277f, -0.12062950f, -0.05587476f, 0.03713983f, 0.18825731f, 
    0.08544591f, 0.15915644f, -0.17095886f, -0.09666593f, -0.13619754f, 0.11632150f, -0.10849158f, 0.08997198f, 
    -0.14133415f, -0.13909076f, -0.06381328f, -0.02332390f, -0.02231716f, 0.09817202f, 0.01671446f, -0.21659046f, 
    0.06341694f, 0.07429142f, 0.08855449f, 0.01841410f, 0.11660487f, 0.01020556f, 0.01762432f, 0.04349405f, 
    -0.18256234f, -0.14149222f, 0.30266583f, 0.07542069f, 0.14631002f, 0.04272557f, 0.17443600f, 0.14352189f, 
    0.05102679f, -0.02457028f, -0.01254104f, 0.10333087f, -0.32397330f, -0.09813757f, 0.08400806f, -0.02466088f, 
    0.01890904f, 0.07031645f, -0.03132496f, -0.04654725f, -0.03116325f, -0.12112882f, -0.01597130f, -0.06019256f, 
    0.19235985f, -0.04859020f, -0.11389292f, -0.04887461f, -0.12896946f, -0.09226977f, -0.00145993f, -0.08191711f, 
    0.03394562f, 0.01569134f, 0.07670100f, 0.10150321f, 0.15842564f, -0.14535512f, -0.07475802f, -0.02768882f, 
    -0.09420875f, -0.11396214f, -0.03313243f, 0.16272523f, -0.05871369f, 0.06972165f, 0.03057088f, 0.09668933f, 
    0.20667171f, 0.07324722f, -0.17473252f, 0.21034592f, 0.00568205f, -0.00846195f, -0.03557177f, 0.16686063f, 
    0.14754421f, -0.01229480f, 0.12225492f, 0.18337010f, -0.29018432f, -0.16592325f, -0.09288041f, -0.04035990f, 
    0.05527455f, -0.08754683f, 0.02718784f, 0.00572441f, 0.06252145f, 0.11561573f, 0.09919874f, 0.08578705f, 
    -0.02123033f, 0.00546940f, 0.14326659f, 0.21691580f, 0.00879550f, -0.00327523f, -0.01789268f, 0.05568049f, 
    0.01211606f, 0.03494193f, -0.01979831f, -0.01344165f, -0.00053204f, -0.15545364f, 0.23535524f, 0.01872276f, 
    0.03065819f, -0.02674552f, -0.05859742f, 0.02466645f, -0.01719674f, -0.00805533f, -0.05149326f, -0.07391545f, 
    0.14029132f, -0.02542279f, 0.02174609f, 0.13965361f, -0.05463197f, 0.05045383f, 0.02550115f, 0.09420473f, 
    0.10498269f, 0.07285312f, -0.03879333f, 0.09768628f, -0.03148438f, -0.03791291f, -0.07542928f, -0.01754397f, 
    -0.12721464f, -0.06868217f, 0.18260284f, 0.07647426f, -0.02948939f, 0.07916141f, -0.13863426f, 0.08429410f, 
    -0.14157733f, -0.04865547f, 0.11138620f, 0.08615391f, 0.01740255f, -0.02120638f, -0.14959954f, -0.03713969f, 
    0.01827787f, 0.02853446f, 0.01029510f, -0.06573585f, -0.01293179f, -0.06954630f, 0.12962522f, 0.06883786f, 
    0.02004474f, 0.11063240f, 0.05886049f, 0.02030376f, 0.07899978f, 0.00001358f, -0.00396177f, -0.08436374f, 
    0.28858078f, -0.12222523f, -0.10440848f, 0.07517713f, -0.06211638f, -0.06249335f, 0.03486510f, 0.24746397f, 
    0.00149679f, 0.01078035f, 0.08656775f, -0.09242799f, -0.08803872f, 0.06596918f, -0.07284749f, 0.10953902f, 
    0.10848563f, 0.11808189f, 0.11021220f, -0.03413483f, 0.00183582f, -0.05464841f, 0.06256913f, 0.28125468f, 
    0.25201437f, -0.03302403f, 0.19925123f, 0.01951689f, -0.07898913f, 0.14883445f, 0.22529823f, 0.09451431f, 
    0.01028342f, -0.04094715f, 0.05086207f, 0.02355861f, 0.02379810f, 0.17418720f, 0.02264202f, -0.08832211f, 
    -0.04234273f, -0.04838611f, -0.07034790f, -0.00348639f, 0.00444112f, 0.06931277f, -0.07921693f, -0.13156261f, 
    0.17501175f, 0.08333957f, -0.23399341f, -0.01000975f, 0.12389875f, 0.06157771f, 0.05170092f, 0.00839899f, 
    0.04035939f, -0.10793853f, -0.00683963f, -0.09283469f, -0.15054402f, 0.08242221f, 0.09384914f, 0.07040060f, 
    -0.01417993f, -0.00280053f, -0.08665165f, 0.00099824f, 0.01289415f, -0.02789270f, 0.00567784f, -0.06746737f, 
    0.10018072f, 0.04022610f, 0.11144785f, -0.12918253f, -0.03198367f, -0.00309076f, 0.04427822f, 0.03500681f, 
    -0.01564379f, 0.09142514f, 0.05800733f, 0.02940762f, 0.05957794f, 0.04331282f, -0.10323245f, 0.11224591f, 
    0.03328759f, -0.01668119f, 0.00659949f, 0.02160146f, 0.17846259f, -0.08586767f, 0.05146135f, 0.00056883f, 
    0.15077291f, 0.14220664f, -0.07215822f, -0.20336744f, -0.07701174f, 0.01290106f, 0.04832305f, -0.01408608f, 
    -0.04079218f, -0.10793699f, -0.00093143f, 0.14731474f, -0.11989886f, 0.01373849f, -0.08172012f, 0.02603134f, 
    -0.05931452f, 0.01680018f, 0.02828918f, -0.02335914f, 0.04207157f, 0.00879719f, -0.06856485f, -0.05291354f, 
    0.03783110f, -0.07615797f, -0.05464319f, 0.03937516f, -0.13395964f, 0.10617296f, -0.11851486f, 0.04173396f, 
    -0.01136030f, -0.00437781f, 0.04404138f, -0.04323323f, -0.39440596f, -0.02259943f, -0.14769684f, -0.28028694f, 
    -0.01916630f, -0.01070072f, -0.04841214f, 0.12277041f, -0.07484452f, -0.05297016f, 0.11703128f, -0.04829388f, 
    -0.07580560f, -0.01054061f, 0.02468522f, 0.03338640f, 0.04850245f, 0.03749307f, -0.02416014f, 0.07672922f, 
    0.06063182f, -0.10788943f, 0.00475138f, 0.06873373f, -0.06958782f, 0.08480711f, -0.00687804f, -0.09048259f, 
    0.07687993f, 0.03286870f, 0.16287602f, 0.01383429f, 0.09159060f, -0.04076587f, 0.13911512f, 0.15569033f, 
    0.22534816f, -0.07769892f, -0.26368627f, 0.10674825f, 0.14503141f, -0.03711099f, -0.09275520f, 0.03895173f, 
    0.00913623f, 0.04268283f, 0.12504268f, 0.08564353f, -0.10237350f, -0.00019952f, 0.13978457f, 0.05166199f, 
    0.15180610f, 0.10859741f, -0.09266289f, -0.01355697f, 0.07610954f, -0.08622018f, -0.02410345f, -0.19467708f, 
    -0.17253403f, -0.19946851f, -0.22630028f, 0.09509632f, 0.08776377f, 0.05423551f, 0.00461552f, 0.12105620f, 
    -0.07740692f, 0.20088470f, 0.11328019f, 0.00285763f, -0.19382434f, -0.31999448f, -0.05194053f, -0.05747331f, 
    -0.02057125f, 0.05966887f, -0.07455479f, -0.03855759f, -0.05642125f, 0.02406643f, 0.00317849f, 0.23000763f, 
    0.29063481f, -0.05828044f, -0.26535541f, 0.10142973f, -0.03726577f, 0.03664995f, -0.02792720f, 0.10607679f, 
    -0.01569740f, -0.01155837f, -0.00560764f, -0.03208429f, 0.34488809f, -0.00949237f, -0.19050424f, 0.07288658f, 
    0.04435011f, 0.03846555f, 0.14387915f, -0.07905713f, 0.07153083f, 0.03752826f, 0.03737027f, 0.07657559f, 
    -0.04470318f, -0.26947337f, -0.03433976f, 0.13362901f, -0.02788556f, -0.01269684f, 0.12792519f, 0.00513285f, 
    0.04342695f, 0.05224853f, -0.02480660f, 0.09326558f, -0.04531696f, -0.13277444f, 0.11978107f, -0.02250981f, 
    0.06404176f, 0.03041488f, 0.06381314f, -0.00358122f, 0.06613133f, -0.09304147f, -0.07326216f, 0.01609243f, 
    0.12577258f, -0.03019449f, 0.14757487f, -0.14345039f, -0.17091112f, -0.23029102f, 0.06800035f, -0.02628153f, 
    -0.02015686f, -0.07084405f, 0.11493355f, 0.13527113f, -0.07422091f, -0.08042180f, 0.05866845f, -0.11751407f, 
    -0.04971335f, -0.06901456f, -0.09747238f, 0.03069975f, -0.09996817f, 0.02926527f, 0.03014052f, 0.06513023f, 
    0.34953037f, -0.09644940f, -0.06282233f, -0.28440034f, -0.10315976f, -0.02481022f, -0.01738308f, 0.09270445f, 
    0.14247388f, 0.05621666f, -0.02660485f, 0.10756532f, -0.48217407f, -0.24168560f, -0.20050599f, -0.00419994f, 
    -0.06046237f, -0.03142634f, 0.01851044f, 0.03988946f, -0.06740736f, 0.09185093f, 0.13289657f, -0.00346086f, 
    0.09447218f, 0.05668520f, 0.18514211f, 0.17092857f, 0.04683941f, -0.01411366f, -0.08784291f, 0.02402720f, 
    0.15425475f, 0.07463105f, -0.02374997f, 0.07958870f, 0.05995591f, -0.11957143f, -0.06416773f, 0.01583219f, 
    0.03726803f, -0.01693619f, -0.00600009f, -0.00472916f, 0.00254460f, 0.02603672f, -0.07419447f, -0.09153186f, 
    0.07228047f, 0.05078266f, 0.03339601f, -0.00860358f, -0.02744361f, -0.08564914f, 0.03565155f, 0.08963655f, 
    0.03918960f, 0.15448977f, -0.00188376f, 0.07852155f, 0.20515892f, 0.16114122f, -0.09238125f, -0.13929470f, 
    -0.16208802f, -0.07975039f, 0.05134147f, 0.03413101f, -0.05012200f, 0.05203238f, 0.06502366f, -0.03646882f, 
    -0.29764169f, 0.12100985f, 0.11999124f, 0.08665957f, -0.01749584f, -0.04721609f, -0.08138510f, 0.10621662f, 
    -0.05963425f, 0.06885608f, -0.08737551f, -0.02775049f, 0.21176140f, 0.06159962f, 0.03731051f, 0.19093980f, 
    -0.04888438f, 0.03456348f, 0.03259689f, 0.06978492f, 0.08172560f, -0.00797995f, -0.02127432f, -0.04001443f, 
    -0.07391425f, 0.09341107f, -0.01772581f, 0.07591151f, -0.00756091f, 0.00550611f, 0.13697207f, 0.08490338f, 
    0.05593272f, -0.05809616f, 0.13044871f, 0.02014607f, 0.07688084f, -0.10225981f, 0.01653761f, 0.03237420f, 
    0.06112370f, 0.01009653f, 0.10633925f, 0.03255324f, -0.00864775f, 0.01283185f, 0.02058334f, 0.33038461f, 
    0.21627587f, -0.09066486f, -0.16772276f, 0.13515908f, 0.07444870f, 0.09852602f, 0.06377418f, -0.09190723f, 
    0.14266901f, 0.00780706f, 0.01136361f, 0.10056899f, 0.32121587f, -0.01361744f, -0.04921888f, 0.13816926f, 
    0.02046824f, 0.05045920f, 0.03451541f, -0.02601156f, 0.05014626f, 0.06603223f, -0.04679325f, 0.01471753f, 
    0.22315563f, -0.16241278f, 0.02145630f, 0.00738701f, -0.07980399f, 0.13179901f, 0.05849225f, 0.04910140f, 
    0.04531096f, -0.02903542f, -0.01287417f, -0.05198918f, -0.00087257f, -0.07381405f, 0.07737135f, 0.12296986f, 
    0.04848665f, -0.06342296f, -0.17074710f, -0.01087987f, -0.11353880f, -0.01042029f, -0.03506736f, -0.02275011f, 
    -0.04773319f, 0.08279945f, 0.03006217f, -0.13487844f, 0.02395742f, 0.03890678f, 0.08755186f, 0.03624366f, 
    0.00228840f, -0.10048883f, 0.05482327f, -0.04356924f, -0.11860117f, 0.03601662f, -0.07377047f, -0.01341565f, 
    0.08801260f, -0.03328210f, -0.01057570f, 0.03875191f, 0.07910288f, 0.06686969f, 0.02111113f, -0.00049292f, 
    -0.28293735f, 0.33303773f, -0.17588875f, -0.05161572f, -0.03184658f, 0.16207011f, -0.01863854f, 0.05928620f, 
    -0.00763101f, -0.00510547f, -0.04430942f, 0.02130845f, 0.12272625f, -0.09006415f, -0.10383908f, -0.02752523f, 
    -0.08597603f, 0.04003579f, 0.09157982f, -0.02788209f, 0.16443488f, 0.00992197f, -0.07032167f, -0.08846948f, 
    -0.05933689f, -0.07900222f, -0.16034876f, -0.06946029f, -0.01986371f, 0.00063582f, -0.00280631f, 0.01777412f, 
    -0.12739578f, 0.00678032f, 0.03561353f, 0.10561004f, -0.08878209f, 0.09231441f, -0.11648053f, -0.08529576f, 
    -0.18455014f, 0.11577044f, -0.19324337f, 0.20441473f, -0.13244607f, 0.04161897f, -0.01593206f, -0.11730458f, 
    0.21644120f, 0.00194840f, 0.04309286f, 0.01680467f, 0.04446463f, -0.03678879f, -0.01985078f, 0.06339889f, 
    0.17764255f, 0.09933441f, 0.03654376f, 0.06350398f, 0.34632769f, 0.06536113f, 0.08575287f, -0.14652474f, 
    0.10247634f, -0.05792390f, 0.17723179f, 0.08097415f, 0.23751421f, -0.06993878f, 0.07813101f, 0.20300192f, 
    -0.00260119f, 0.04053610f, -0.05612657f, -0.02971623f, -0.03048557f, -0.00187409f, 0.01360556f, -0.02119376f, 
    -0.03993591f, -0.05374413f, -0.01570048f, 0.00419792f, -0.04115842f, 0.02253894f, -0.02191925f, -0.01004860f, 
    -0.04280700f, 0.03035845f, 0.02904349f, -0.00733611f, -0.05385876f, -0.04739837f, 0.04364944f, -0.02813829f, 
    -0.04416613f, -0.04353333f, -0.02395281f, -0.01369188f, -0.02758077f, -0.01587203f, -0.02758873f, -0.02482817f, 
    -0.03597494f, -0.01892043f, 0.02296540f, 0.02261055f, 0.02883550f, 0.00754183f, 0.03494827f, -0.05147325f, 
    0.01407570f, -0.02717006f, -0.05638307f, -0.02921206f, -0.01258418f, -0.00404096f, -0.02300156f, 0.00789435f, 
    -0.02375739f, -0.05172049f, 0.02215347f, -0.03255384f, -0.02631430f, -0.00783149f, -0.05005670f, 0.03442755f, 
    -0.02558578f, -0.02846609f, 0.04071432f, -0.01660235f, -0.02389145f, -0.00462519f, -0.03723728f, -0.03538769f, 
    0.01286616f, -0.04604756f, 0.01095156f, -0.05230635f, -0.05224527f, 0.00423585f, 0.00213779f, -0.04070001f, 
    -0.02780000f, 0.02814034f, -0.05055940f, 0.02903913f, 0.01182161f, -0.05490601f, -0.00454237f, -0.02508612f, 
    -0.01768478f, -0.02358297f, 0.03189966f, 0.01497458f, -0.04646379f, -0.00671141f, 0.03497815f, -0.02161484f, 
    -0.03872176f, 0.04920300f, -0.05091208f, 0.00500655f, 0.03104078f, -0.04130017f, -0.00117767f, 0.02527539f, 
    0.00527375f, 0.01845958f, -0.02227054f, -0.02260066f, -0.02443142f, -0.03869985f, -0.03965599f, -0.01283887f, 
    0.03365888f, -0.01859331f, -0.00001544f, -0.01826453f, 0.01829418f, -0.05056325f, 0.03703842f, -0.02330438f, 
    0.03718175f, -0.00923268f, -0.04884766f, -0.02340343f, -0.00148518f, -0.00075941f, 0.02087664f, -0.02484642f, 
    -0.04402276f, -0.03893887f, -0.01625382f, -0.03946512f, -0.02257381f, -0.04862306f, 0.04144386f, 0.00723263f, 
    0.04025467f, 0.01174362f, -0.00417397f, 0.03392504f, 0.00811021f, 0.02379733f, -0.03295217f, -0.01012571f, 
    0.00999537f, -0.02557934f, -0.00438634f, -0.01912365f, -0.01741658f, -0.03997907f, 0.00780979f, 0.03164848f, 
    -0.00975115f, 0.04983547f, -0.00541549f, -0.04995903f, 0.00318030f, 0.00842076f, -0.03199654f, -0.00399483f, 
    0.00806551f, -0.00177580f, 0.01198395f, -0.01306113f, -0.02987701f, 0.03512326f, -0.00832049f, -0.03117511f, 
    -0.00906499f, -0.01108733f, -0.03191490f, -0.04296433f, -0.04786573f, 0.01257650f, -0.00554224f, 0.03893528f, 
    -0.01376909f, 0.05010328f, -0.01357881f, 0.00090674f, -0.02019960f, 0.00936558f, 0.00585469f, -0.00573405f, 
    -0.04427748f, -0.01937038f, -0.01110045f, 0.03721804f, -0.02762209f, 0.04372992f, 0.03176366f, 0.01981557f, 
    -0.03826243f, -0.02115531f, 0.02377231f, -0.00761886f, 0.01930052f, 0.02076217f, -0.02526864f, 0.03657790f, 
    -0.03336055f, -0.04924794f, -0.03931981f, -0.04190595f, 0.01559985f, -0.00678268f, 0.00844022f, -0.02622770f, 
    0.02764163f, -0.03995363f, -0.03702518f, 0.04047933f, 0.03852128f, -0.01212997f, -0.05299561f, -0.01297979f, 
    0.02116274f, -0.01881423f, 0.00356967f, -0.04724410f, -0.00080547f, -0.02314716f, -0.04259258f, -0.05194851f, 
    -0.02361734f, -0.05336362f, -0.00652184f, 0.00748323f, -0.05614330f, -0.01120290f, -0.04897041f, 0.03076437f, 
    -0.04198500f, 0.03739239f, 0.01742050f, -0.01721944f, -0.03184403f, 0.01332055f, 0.01145156f, -0.03414175f, 
    0.04169328f, -0.04907871f, 0.03590878f, 0.01477645f, -0.04992485f, -0.01312787f, -0.04944408f, 0.03146381f, 
    0.03468113f, -0.04436666f, -0.02010136f, -0.02390704f, -0.05058920f, -0.00801907f, 0.00441128f, -0.00798003f, 
    -0.03161781f, 0.03249864f, -0.04349459f, -0.02461930f, -0.03197241f, 0.00139873f, 0.01524074f, 0.02602928f, 
    -0.01331782f, 0.00853887f, -0.05464460f, 0.03029038f, 0.01075407f, 0.04253402f, -0.04017797f, 0.02635083f, 
    -0.04405806f, -0.00344410f, 0.03850858f, 0.03309595f, 0.04018733f, 0.02103321f, -0.00994905f, -0.01098171f, 
    -0.00386671f, -0.02272702f, 0.03343610f, 0.01313791f, -0.05230456f, -0.00475102f, -0.03162668f, -0.00177957f, 
    0.02495067f, 0.03810966f, -0.03887442f, -0.04697770f, 0.02977730f, 0.04108078f, 0.02620411f, 0.02541717f, 
    0.00063487f, -0.04042418f, -0.00808770f, -0.03900691f, -0.04741354f, 0.02740633f, -0.03876633f, 0.00814306f, 
    -0.01983026f, -0.05200156f, 0.04471300f, -0.04006771f, -0.02615472f, 0.01841722f, -0.04138765f, -0.05163754f, 
    0.03564574f, -0.03787280f, 0.04127566f, -0.02543384f, -0.04109341f, 0.01267234f, -0.01878636f, 0.00382500f, 
    -0.00421890f, 0.00223266f, 0.01005249f, -0.02980745f, -0.05350580f, -0.05317226f, -0.04503554f, -0.05451103f, 
    0.03012069f, 0.02234079f, 0.00819452f, -0.02503960f, 0.00928561f, -0.00491385f, 0.02565941f, 0.04094186f, 
    -0.01096073f, -0.02730540f, -0.05150793f, 0.02008441f, -0.05354447f, 0.03973809f, 0.01060155f, -0.02377900f, 
    0.03671059f, 0.01683128f, -0.03050587f, 0.01945611f, -0.03613146f, 0.04385744f, 0.00747835f, -0.03091633f, 
    0.00430769f, -0.03408789f, 0.02936830f, -0.03178282f, 0.01870612f, 0.04229611f, 0.00786072f, -0.00319032f, 
    0.02553572f, 0.00322194f, 0.02827440f, -0.05424016f, 0.02632665f, 0.00243626f, 0.02653640f, -0.03479727f, 
    -0.02595294f, -0.03558576f, 0.00383202f, -0.03597108f, -0.05576023f, 0.01629930f, -0.00854476f, -0.02399475f, 
    -0.01821313f, 0.02228204f, -0.00141930f, 0.00732877f, 0.01204577f, 0.00662744f, 0.01851867f, 0.03737668f, 
    0.01307865f, -0.01695017f, 0.03260791f, 0.00528900f, -0.00903909f, 0.03992022f, 0.04375094f, -0.01011492f, 
    -0.12101113f, 0.20244263f, 0.12516382f, -0.17853947f, 0.01429774f, -0.03154468f, 0.00603565f, -0.08857890f, 
    -0.06258751f, 0.00623580f, 0.03973148f, -0.01500926f, -0.21880965f, -0.01689853f, -0.14237665f, 0.00682908f, 
    -0.00050916f, 0.05575053f, -0.00412973f, 0.01330746f, -0.07572793f, -0.01706707f, 0.02769369f, -0.01673953f, 
    0.17803015f, 0.00060455f, -0.15630446f, 0.13436140f, 0.02401378f, 0.03589499f, 0.08043606f, -0.11452919f, 
    -0.02628956f, 0.06150263f, -0.00110990f, -0.05940101f, -0.09333781f, 0.19949089f, -0.12953626f, 0.00729238f, 
    0.09976672f, -0.03051930f, -0.03674470f, 0.01297299f, -0.12310898f, -0.00824281f, -0.10237554f, -0.01950532f, 
    0.19240339f, 0.10062563f, 0.03419141f, 0.00185145f, -0.07591239f, 0.05800487f, -0.12293129f, 0.03350649f, 
    0.02878405f, -0.02562675f, -0.00104008f, -0.06371773f, -0.01278246f, 0.25464287f, 0.03083848f, -0.40982792f, 
    -0.02023667f, 0.01313740f, 0.01612047f, 0.02724949f, 0.01489009f, 0.10486627f, 0.02701783f, 0.05596022f, 
    0.00021703f, 0.18123734f, 0.45016551f, -0.06938070f, 0.10692861f, -0.01228968f, -0.03576086f, 0.11413239f, 
    0.00302793f, 0.02619556f, -0.07869128f, 0.05339049f, -0.14492187f, -0.27316096f, -0.02576757f, 0.05923513f, 
    0.01058056f, -0.03456301f, -0.07084117f, -0.07888957f, 0.14080916f, 0.01755919f, -0.02841079f, 0.02427562f, 
    -0.10681821f, -0.00597464f, -0.12748964f, 0.07501187f, -0.00069527f, 0.05463372f, 0.00545958f, 0.02716673f, 
    0.04741812f, -0.06732272f, 0.02421568f, -0.06654994f, 0.02476015f, -0.16790700f, -0.22794022f, -0.04202581f, 
    -0.06573558f, -0.03162709f, -0.02656567f, -0.11038709f, -0.05902491f, 0.06191508f, 0.00177616f, 0.08434030f, 
    -0.18296748f, 0.00936054f, -0.04879206f, 0.18614501f, 0.03245661f, 0.06131121f, -0.14332706f, -0.11798778f, 
    -0.01571532f, 0.00488756f, 0.00463009f, 0.05172677f, 0.00292383f, -0.04096121f, 0.23657188f, 0.25681531f, 
    0.18634886f, -0.08864560f, -0.07515692f, 0.06843613f, 0.08952711f, 0.08998180f, -0.05605107f, 0.00110971f, 
    0.07748108f, -0.11724778f, 0.04951342f, 0.32960665f, -0.00850709f, 0.01635647f, 0.09661831f, 0.04204062f, 
    -0.07035010f, -0.02352710f, 0.07716232f, -0.11205544f, 0.48804975f, 0.22635338f, 0.12240539f, -0.12682016f, 
    0.09642668f, 0.02929888f, 0.02695318f, -0.03598011f, -0.02075299f, -0.10271450f, -0.02057889f, 0.07044972f, 
    0.48653835f, 0.06567560f, -0.06960374f, 0.32367179f, -0.00597184f, -0.00994226f, 0.07649647f, 0.07916363f, 
    -0.00740187f, -0.02185668f, -0.01065430f, -0.02275178f, -0.02732487f, -0.02022257f, 0.13992362f, 0.24198282f, 
    0.11857543f, -0.06241104f, 0.01902412f, 0.20511268f, 0.06273498f, -0.03105513f, -0.12700835f, 0.06995024f, 
    0.28998828f, -0.07549052f, -0.06051357f, 0.09983281f, -0.00474093f, -0.06684097f, 0.04893442f, -0.10864558f, 
    -0.04303058f, 0.10311922f, 0.12569584f, -0.03712520f, 0.16004148f, -0.14974824f, 0.21596637f, 0.16497399f, 
    -0.04835332f, 0.07525155f, 0.01103889f, -0.06829466f, -0.00171073f, -0.03686469f, -0.00872778f, 0.02438608f, 
    0.37333754f, -0.14875682f, -0.07061628f, 0.12020791f, -0.01845623f, 0.03532805f, 0.06949859f, 0.13278499f, 
    -0.02503988f, -0.00997574f, 0.01181715f, -0.07125740f, -0.00546648f, 0.28405237f, -0.07034770f, 0.19602668f, 
    0.04856058f, 0.13157506f, 0.09505606f, 0.03484196f, 0.09258998f, 0.02656666f, 0.00774047f, 0.02988670f, 
    0.22178692f, 0.10272245f, 0.10322254f, -0.28305799f, -0.10421710f, 0.03561585f, 0.17768875f, 0.06966702f, 
    -0.02556518f, 0.01578076f, 0.11684138f, -0.03255550f, -0.09411933f, -0.12646404f, -0.07011906f, -0.11595824f, 
    -0.06811308f, -0.07939160f, -0.09564190f, -0.00619062f, -0.09904019f, -0.02371459f, 0.03113779f, -0.06952541f, 
    -0.01091269f, 0.03263764f, -0.10322192f, -0.02907945f, 0.12440110f, 0.11509050f, -0.05935221f, 0.04278764f, 
    -0.03462299f, -0.02876552f, 0.11548094f, -0.00697213f, 0.23841035f, 0.25796521f, 0.01385963f, -0.10240198f, 
    -0.16054597f, -0.04298818f, 0.04429194f, 0.01898692f, -0.08458851f, -0.01240615f, 0.05073703f, -0.02586976f, 
    0.08536807f, -0.14662983f, -0.02470044f, -0.26662621f, -0.13868770f, 0.02111373f, 0.04544064f, 0.06364357f, 
    0.06238595f, -0.01276412f, 0.02079465f, 0.01116033f, 0.03509336f, -0.06626583f, -0.12979554f, -0.02209616f, 
    -0.02630979f, 0.08985724f, -0.02660294f, -0.07137308f, 0.11435702f, -0.05047568f, 0.00716845f, 0.05715449f, 
    0.34701625f, 0.14781873f, -0.05467259f, -0.18985079f, 0.02715386f, 0.03826498f, 0.07252783f, -0.05435792f, 
    0.02276439f, -0.12451482f, 0.02271471f, 0.01152058f, -0.10810585f, -0.00869014f, -0.03165581f, -0.28952283f, 
    -0.07874497f, 0.04862473f, 0.01828162f, 0.04207754f, 0.02099811f, -0.09743859f, 0.02881444f, -0.07164972f, 
    -0.12995142f, -0.08790401f, -0.12617664f, -0.16318798f, -0.12304255f, 0.13850753f, -0.00252380f, -0.08141927f, 
    0.12096129f, 0.00223522f, -0.02289531f, -0.05937162f, 0.07466691f, 0.10040414f, 0.12105734f, -0.06093797f, 
    0.04118650f, -0.07039659f, 0.06137325f, 0.08039877f, 0.03302810f, -0.11574554f, 0.01323641f, 0.01002982f, 
    -0.10794391f, -0.00221610f, 0.00427472f, 0.27837563f, 0.11402227f, -0.00194998f, 0.01811403f, 0.06876308f, 
    -0.08758200f, -0.02840168f, 0.05745402f, -0.03247637f, 0.10466932f, 0.07137717f, -0.00077447f, -0.01952060f, 
    -0.05882619f, -0.03463006f, 0.05058162f, 0.01358393f, -0.03729585f, 0.03495076f, 0.01091880f, 0.01205096f, 
    -0.03455814f, 0.03612940f, 0.11467592f, 0.01039970f, 0.16542473f, 0.12652557f, -0.02474288f, -0.01963731f, 
    0.04013708f, -0.01927876f, 0.11197282f, 0.01353744f, 0.25829080f, 0.00139228f, -0.04521086f, -0.06559924f, 
    0.04692134f, 0.04510460f, -0.01871108f, 0.11844175f, 0.02037617f, -0.06333913f, -0.08939483f, 0.02352283f, 
    0.25952286f, -0.16634776f, -0.04458191f, -0.05287758f, -0.03622669f, -0.01267543f, 0.06649730f, 0.03957197f, 
    0.01248325f, 0.07033772f, -0.11119548f, 0.15070871f, -0.24507833f, -0.07834299f, 0.07706900f, -0.12305180f, 
    0.00303719f, 0.01534802f, -0.14311299f, -0.02406489f, 0.08209732f, 0.04081561f, 0.14241342f, 0.00258463f, 
    -0.29998028f, 0.09541612f, -0.12639984f, -0.07680336f, 0.17786898f, 0.12708104f, 0.07008877f, -0.01863572f, 
    0.01681904f, -0.01266668f, 0.00345151f, -0.03667045f, -0.11739948f, -0.20917116f, -0.07255399f, -0.12525780f, 
    0.07423720f, -0.02174335f, 0.02372107f, 0.03844794f, 0.12105505f, 0.05927588f, 0.08084457f, 0.07557837f, 
    -0.11053221f, -0.12133490f, 0.23792107f, 0.20444928f, 0.04055446f, 0.04336377f, 0.15265241f, 0.06452952f, 
    0.11865172f, 0.02173172f, -0.02571982f, 0.10008984f, 0.17360500f, 0.11307628f, 0.22964719f, -0.07568745f, 
    -0.09397474f, 0.09511945f, 0.00291020f, 0.02514141f, 0.07129156f, -0.01320134f, -0.03985911f, 0.00447449f, 
    -0.06923510f, -0.09457068f, -0.12825049f, -0.00856401f, -0.14191726f, -0.03450997f, -0.07440329f, -0.14517136f, 
    -0.00642267f, 0.06418993f, 0.11920190f, -0.01502225f, -0.14247629f, 0.00875296f, -0.26276863f, -0.12384313f, 
    0.13119602f, -0.07944327f, -0.08939312f, 0.04998208f, 0.10681306f, -0.04545731f, 0.15566263f, -0.01053096f, 
    -0.08812024f, -0.07804868f, 0.19602221f, 0.08216120f, -0.04605897f, 0.00153780f, -0.03216412f, -0.00746056f, 
    -0.01577976f, 0.07657787f, -0.01060596f, 0.19286616f, 0.03558500f, -0.19511475f, 0.06115675f, 0.14120920f, 
    -0.06536061f, -0.00236305f, 0.00725726f, 0.17889766f, -0.03723054f, -0.00597808f, 0.03420516f, 0.08526185f, 
    -0.13286202f, 0.09416232f, 0.01241833f, -0.26637384f, 0.15114106f, -0.02855159f, -0.03043482f, -0.02118463f, 
    0.05200086f, 0.02347025f, -0.00419972f, -0.03550470f, 0.19325569f, -0.03535664f, 0.16373467f, 0.06410494f, 
    -0.01276703f, 0.02520352f, 0.05628305f, 0.08116604f, -0.01096611f, 0.09545416f, 0.06709378f, 0.01223849f, 
    -0.09885897f, -0.00515151f, -0.16961904f, -0.13916242f, 0.09045352f, 0.06390712f, -0.07221678f, 0.01612487f, 
    -0.00853499f, 0.12987830f, -0.03026668f, -0.00192354f, -0.11224496f, -0.17110200f, -0.15775774f, -0.04991352f, 
    -0.07348659f, -0.14782366f, 0.03130291f, -0.00361994f, -0.00569445f, -0.03812946f, -0.07818718f, -0.04386808f, 
    -0.05667688f, 0.01359837f, 0.03757779f, 0.12722629f, -0.03203234f, 0.04291553f, 0.14733696f, 0.10489493f, 
    0.01929109f, 0.13700499f, 0.06724497f, -0.02840143f, 0.10737077f, 0.10304990f, 0.05968936f, -0.17920886f, 
    0.07434790f, 0.02633232f, -0.01718589f, -0.03040349f, 0.04136259f, 0.04153712f, 0.07157268f, -0.04003330f, 
    -0.07520822f, -0.13402189f, -0.09325454f, 0.11282127f, -0.06297273f, -0.02527388f, 0.08495869f, 0.17699003f, 
    0.08475338f, 0.11141396f, 0.11226526f, -0.07425492f, -0.22920175f, 0.09432769f, 0.00196871f, -0.15988386f, 
    0.24032897f, -0.00118870f, 0.02757168f, 0.06891277f, 0.03101168f, -0.00061194f, 0.02828137f, 0.13764049f, 
    0.05134337f, -0.08138762f, 0.25528568f, 0.00339674f, 0.06101450f, 0.01616583f, 0.18445779f, -0.12116569f, 
    0.04849946f, -0.00309694f, 0.02626583f, -0.06594592f, 0.07265141f, -0.04954631f, -0.04354344f, 0.17279413f, 
    0.13209359f, -0.01776726f, 0.08841099f, 0.06733597f, 0.02322963f, -0.00135050f, 0.05267427f, 0.06035886f, 
    -0.16936687f, 0.06074588f, 0.04779118f, -0.02590038f, 0.14134066f, -0.12063444f, 0.14875077f, 0.12742268f, 
    0.06674042f, 0.03263639f, -0.08514275f, 0.09192183f, 0.10607325f, 0.07647082f, 0.07903071f, -0.04236145f, 
    0.19653656f, 0.04805473f, 0.03073048f, 0.00733666f, 0.04127920f, 0.04902766f, 0.09176455f, -0.03570614f, 
    0.32001188f, 0.04918449f, 0.35882512f, -0.29509971f, -0.05732336f, 0.12504649f, -0.03276079f, -0.05699523f, 
    0.02385224f, 0.06371559f, 0.06777339f, 0.08844054f, 0.17736144f, 0.04795326f, -0.02531785f, -0.01694399f, 
    0.09931741f, -0.12749436f, -0.00809924f, 0.15396228f, 0.08711273f, 0.04148968f, 0.03512576f, 0.00143678f, 
    0.27600935f, -0.16392985f, -0.08642100f, 0.04994816f, -0.01125612f, 0.03074551f, -0.03366678f, 0.06476436f, 
    0.01131425f, 0.00983630f, 0.15782635f, 0.14107941f, 0.26039404f, -0.05166539f, 0.24196294f, -0.10873347f, 
    -0.03195310f, 0.09382600f, 0.09745786f, -0.02497308f, -0.01061094f, 0.00791476f, 0.04480330f, 0.03435338f, 
    -0.04003921f, -0.04148928f, -0.18975648f, -0.05042033f, 0.00381336f, 0.10099877f, 0.05604294f, -0.03445701f, 
    -0.01003317f, 0.00559257f, 0.16192813f, -0.06139413f, 0.14044251f, -0.28540102f, 0.00488987f, -0.00048144f, 
    -0.16102806f, 0.10795294f, 0.02086645f, 0.01576532f, -0.01321629f, 0.05377718f, 0.07766449f, -0.04667981f, 
    0.06935680f, 0.07805165f, -0.07799377f, -0.18715331f, 0.21181908f, -0.04730631f, -0.09087848f, 0.00220191f, 
    0.09242796f, 0.13409364f, 0.02885763f, 0.15325908f, 0.00961825f, -0.02838165f, 0.16415568f, -0.12665749f, 
    0.25176191f, 0.02561678f, -0.10598321f, -0.10320745f, 0.14758925f, 0.05005562f, -0.04437198f, 0.11183827f, 
    0.36004317f, -0.07917214f, 0.00700924f, -0.15681340f, 0.09999792f, 0.03775787f, 0.17074026f, 0.04360116f, 
    0.14958784f, 0.01121034f, -0.02661488f, -0.00367209f, 0.08899075f, 0.22186270f, -0.05983206f, 0.15610747f, 
    0.05621208f, -0.00822899f, 0.10167989f, 0.06538840f, 0.02919980f, -0.05225854f, 0.14021695f, 0.06393398f, 
    -0.06787717f, 0.11319192f, -0.02032527f, 0.09805100f, 0.02746242f, 0.00807414f, -0.18272929f, 0.15623555f, 
    0.06313622f, 0.02861958f, -0.03802285f, -0.07541045f, 0.25947979f, 0.00255015f, -0.00743303f, 0.06684305f, 
    -0.12846445f, 0.08260441f, -0.09932306f, -0.04605184f, 0.13773221f, 0.00165597f, 0.01066374f, -0.04527901f, 
    -0.04447105f, -0.29727399f, 0.19141549f, 0.00717905f, 0.04787535f, -0.00333815f, 0.04176777f, -0.02458295f, 
    0.11458303f, 0.12884420f, -0.02281668f, -0.08006359f, -0.18325308f, 0.03605290f, -0.21556666f, 0.00482861f, 
    0.04938613f, 0.06960381f, 0.11392098f, 0.01093932f, 0.01227673f, -0.08242865f, -0.04931020f, -0.04924801f, 
    0.12129004f, -0.11836577f, -0.18598238f, -0.22125211f, 0.00390734f, -0.05434694f, 0.08871407f, -0.00297018f, 
    -0.08564908f, 0.01363189f, 0.01310533f, 0.00332654f, 0.06740493f, 0.35829431f, -0.11251977f, -0.06580526f, 
    0.09003190f, 0.01083531f, 0.05369030f, -0.05547734f, -0.06466653f, 0.00580318f, -0.04249364f, 0.02912508f, 
    -0.04189812f, 0.03294627f, 0.03693403f, -0.09164235f, -0.05059083f, -0.04588043f, 0.02133672f, 0.00155720f, 
    0.19721670f, 0.03959231f, -0.02114439f, 0.03929278f, -0.06778790f, 0.15805194f, 0.06008751f, -0.06874327f, 
    -0.02942537f, 0.13829760f, -0.01775697f, -0.03005803f, -0.09770794f, -0.10651866f, -0.04375370f, -0.02971494f, 
    0.15598516f, -0.01002911f, -0.00455654f, -0.00183100f, 0.03575419f, -0.02716352f, -0.04542486f, 0.10690594f, 
    0.09231062f, 0.02752144f, 0.01477628f, -0.01933866f, 0.35159272f, 0.10777280f, -0.00461304f, -0.12682684f, 
    -0.06642991f, 0.02162481f, -0.00730873f, 0.09362842f, 0.00010608f, 0.08411054f, 0.00408275f, 0.06131425f, 
    0.12803786f, 0.20770475f, -0.05734516f, 0.09171600f, -0.10480292f, -0.01313766f, -0.09464859f, 0.04831391f, 
    -0.02440413f, 0.03121238f, -0.02769430f, 0.11603122f, -0.27575105f, -0.07722622f, -0.03410032f, 0.06104068f, 
    -0.01683687f, -0.06452499f, -0.08786858f, -0.10575935f, -0.09974184f, 0.06891152f, 0.03495991f, -0.05516932f, 
    -0.17211214f, -0.00753842f, -0.02864489f, -0.04778878f, 0.00540810f, 0.05091704f, 0.02943362f, 0.08145881f, 
    -0.00887931f, 0.08249389f, 0.08723038f, 0.02085747f, 0.12275037f, 0.02247109f, -0.18463199f, -0.23562476f, 
    -0.18712853f, 0.01314733f, 0.03964271f, -0.00360486f, -0.04222706f, 0.08896911f, 0.05390112f, -0.08126332f, 
    0.02708426f, 0.06659216f, -0.05378161f, 0.00447836f, 0.02673841f, 0.04104420f, -0.05550879f, 0.07842386f, 
    0.12335869f, -0.05030359f, -0.07216860f, 0.02433641f, 0.11097902f, 0.14998172f, -0.09096514f, -0.02968463f, 
    0.08106228f, -0.07110517f, -0.03253683f, 0.09618400f, -0.01355289f, 0.03694300f, 0.03872947f, -0.02067695f, 
    -0.13877384f, 0.33370799f, 0.18200427f, -0.15916686f, 0.07680655f, 0.03356373f, 0.04055265f, 0.04993205f, 
    0.01286039f, 0.02544596f, 0.02921068f, -0.00832815f, -0.00480186f, -0.23135552f, 0.17374037f, 0.13763589f, 
    -0.02185067f, -0.02031787f, 0.00504388f, 0.03745297f, 0.03081748f, 0.03943560f, 0.04274441f, 0.07941280f, 
    0.06891620f, -0.13098587f, -0.03511764f, 0.12711556f, 0.03783480f, 0.02099588f, 0.06373091f, 0.00172806f, 
    0.08529064f, 0.00030679f, 0.02797549f, 0.16728753f, 0.32632962f, -0.07120071f, 0.01676459f, 0.16089013f, 
    0.03292159f, 0.07079583f, 0.09370233f, 0.07743290f, 0.01871515f, 0.07433201f, -0.08358046f, 0.03560639f, 
    0.10044799f, -0.42119423f, 0.03890310f, 0.22496170f, 0.00304221f, 0.01363125f, -0.02969140f, 0.01776921f, 
    0.06515379f, 0.02181724f, -0.05435047f, 0.03095619f, -0.08058181f, -0.04811703f, 0.05803658f, 0.15701526f, 
    -0.02032262f, -0.02646510f, -0.06077951f, 0.02143102f, 0.00605043f, 0.09601676f, 0.05688386f, 0.00017050f, 
    -0.42550582f, 0.12576625f, -0.06956597f, 0.17189471f, 0.04248397f, 0.04248027f, 0.00309558f, 0.06719206f, 
    -0.03182298f, -0.02102936f, 0.12824938f, -0.04182011f, 0.44185165f, -0.21507370f, -0.02082864f, 0.17636384f, 
    -0.03264535f, 0.05735032f, 0.02491033f, -0.05766984f, -0.02312144f, 0.02018560f, 0.09210843f, -0.00771627f, 
    -0.10734690f, 0.07559945f, -0.08906849f, -0.08666120f, 0.07018487f, 0.08791951f, 0.02256864f, 0.01991087f, 
    -0.04243622f, 0.09215744f, 0.05134133f, 0.07647646f, -0.12756936f, 0.03961631f, -0.02580559f, 0.02136569f, 
    0.08474357f, 0.05519670f, 0.00896996f, 0.16038755f, 0.06777319f, 0.08430439f, -0.07679047f, 0.04504962f, 
    0.06760692f, -0.01047308f, -0.14188893f, -0.03079905f, 0.02329704f, -0.01434659f, -0.11790520f, -0.09244890f, 
    -0.01911176f, -0.04362053f, 0.09736143f, -0.02243685f, 0.02052473f, -0.08428780f, -0.08717729f, -0.05901933f, 
    -0.09547478f, 0.10695902f, -0.07461870f, 0.05850760f, -0.08895550f, 0.09419362f, 0.05932114f, 0.02640764f, 
    0.16134872f, 0.03573530f, -0.00263617f, 0.00119062f, -0.09719677f, 0.03397627f, -0.02963803f, -0.05457207f, 
    -0.00796803f, 0.04167947f, 0.06136777f, 0.10157031f, 0.15484571f, 0.00659629f, -0.04849945f, -0.00623785f, 
    0.02019639f, 0.08166352f, 0.07100201f, 0.07372405f, 0.08633341f, -0.02606963f, -0.04781685f, 0.00309097f, 
    0.14877918f, -0.03500853f, 0.04631814f, 0.21983621f, 0.03062845f, -0.05072175f, 0.05913083f, -0.04830551f, 
    0.04537097f, 0.00814958f, 0.06390508f, 0.07236285f, 0.09689408f, -0.20101704f, -0.04353340f, 0.06561255f, 
    0.01499233f, 0.05369925f, -0.01123871f, -0.03718832f, -0.01083553f, -0.00686778f, -0.01107624f, -0.04967487f, 
    -0.14369190f, -0.01041479f, 0.07636626f, -0.05770329f, 0.00813679f, -0.08407566f, -0.02492996f, -0.08991370f, 
    -0.04712567f, 0.00922384f, 0.10233501f, -0.05242489f, -0.19084817f, -0.04548430f, 0.08128446f, 0.22979593f, 
    0.05620371f, 0.05470376f, 0.00443393f, -0.04065913f, -0.10951588f, 0.01795496f, -0.04507433f, 0.10314491f, 
    0.00099067f, 0.16512634f, -0.04843426f, 0.07770563f, -0.07576342f, 0.03968835f, -0.03378526f, -0.03116266f, 
    0.02469569f, -0.04357505f, 0.08468051f, -0.07523131f, 0.24546088f, -0.07267322f, -0.12511440f, 0.28710440f, 
    -0.10354553f, -0.02964415f, -0.00193139f, -0.08369607f, -0.01255502f, 0.01899889f, 0.09509374f, 0.09546687f, 
    0.24301451f, 0.00277108f, 0.08596342f, -0.06695700f, -0.01389131f, 0.02068452f, -0.02859526f, -0.04852270f, 
    -0.04378821f, 0.05166944f, -0.05756150f, -0.02210919f, 0.29903632f, -0.09405448f, -0.12799680f, -0.10286795f, 
    0.00377016f, -0.06013228f, -0.03268120f, 0.00661157f, 0.09918294f, -0.07585690f, 0.04402513f, 0.09588069f, 
    0.00126946f, 0.01399536f, 0.03425915f, 0.11769278f, 0.05179190f, -0.01654063f, 0.07122703f, -0.20537491f, 
    0.12107482f, -0.04096905f, 0.01600595f, -0.05398011f, -0.06417871f, 0.02462205f, -0.04932028f, -0.11936402f, 
    0.01463411f, 0.00931972f, -0.03381917f, 0.02750799f, -0.08981348f, 0.08177269f, -0.12266784f, 0.01872409f, 
    0.12880315f, 0.04273691f, 0.02280539f, 0.02795445f, 0.04809704f, 0.02797444f, 0.04296789f, 0.04570742f, 
    -0.04306515f, -0.01359150f, 0.08700448f, 0.03055337f, -0.27438504f, -0.09321533f, -0.01458680f, 0.01453852f, 
    -0.00837768f, 0.04892585f, -0.09557693f, 0.01544656f, 0.02729109f, 0.03472945f, 0.02186343f, -0.17320266f, 
    0.15142687f, 0.15079616f, -0.04297767f, 0.09934642f, 0.09432586f, -0.06337979f, 0.04924990f, 0.03902065f, 
    0.06054144f, 0.00294783f, 0.07754433f, 0.01902474f, 0.50005800f, 0.05404539f, 0.11173908f, 0.00325465f, 
    0.11983821f, 0.01524359f, 0.01751558f, -0.09184392f, 0.03497147f, -0.00333625f, 0.01420450f, 0.02382753f, 
    0.21511844f, 0.07687390f, 0.02009182f, 0.15100764f, 0.06511336f, 0.02836224f, -0.00503465f, -0.12348405f, 
    0.04469212f, -0.01763451f, -0.08575410f, 0.08624461f, 0.01763400f, 0.11934922f, 0.02261862f, 0.18138383f, 
    0.05973272f, 0.07182166f, -0.02559276f, -0.01207541f, 0.00122196f, -0.01805997f, -0.05625698f, 0.06988832f, 
    0.23781140f, 0.24111414f, -0.00887311f, -0.01380282f, -0.01527410f, -0.00395962f, 0.00230280f, 0.05120619f, 
    -0.05658875f, 0.08506865f, -0.07052824f, -0.09794686f, 0.35743681f, -0.03772032f, -0.08276509f, 0.03552976f, 
    0.07770570f, 0.00074181f, 0.05236294f, -0.02087731f, -0.02894804f, -0.04738875f, 0.01189663f, -0.01807212f, 
    0.20541510f, -0.14371142f, 0.06240292f, -0.00403855f, 0.05941703f, 0.00448260f, 0.04500619f, -0.00824775f, 
    -0.01564819f, -0.02377125f, 0.00755368f, -0.07758319f, 0.12386706f, -0.03140331f, -0.09391404f, -0.01875175f, 
    -0.00738727f, -0.02668743f, 0.02645931f, -0.01465970f, 0.08718889f, -0.01938212f, -0.05570984f, 0.07331796f, 
    0.21751447f, 0.00896737f, 0.00645751f, -0.09464458f, 0.17997010f, -0.02213270f, -0.07562521f, 0.00023907f, 
    -0.01031808f, 0.17031343f, 0.01922264f, 0.06887452f, -0.21423908f, 0.01343342f, 0.02732458f, 0.04914718f, 
    0.19429342f, -0.15109847f, -0.06681232f, -0.02908923f, -0.10313941f, -0.09647700f, -0.01090097f, 0.01780308f, 
    0.08771930f, 0.01111609f, 0.20590256f, -0.11065827f, 0.10469477f, -0.06276968f, -0.03513282f, -0.06302503f, 
    -0.05356549f, 0.06969272f, -0.01942112f, 0.05378891f, 0.54270589f, 0.08884334f, 0.02502563f, -0.02444585f, 
    -0.13082044f, -0.00865474f, -0.11051220f, -0.05651079f, -0.03975532f, 0.01336445f, -0.05959773f, 0.07877073f, 
    0.29216892f, 0.01250366f, -0.14120470f, -0.14775717f, 0.00008997f, -0.03356507f, 0.04692975f, 0.04443081f, 
    0.09973244f, -0.04891823f, 0.08711278f, -0.02443442f, -0.12375674f, 0.13924149f, 0.00746834f, -0.12954576f, 
    0.13883094f, 0.00259656f, 0.02873398f, -0.09588496f, -0.09237929f, -0.02464771f, 0.04554757f, 0.09295085f, 
    -0.43263841f, -0.10436676f, -0.06066889f, 0.06985203f, 0.00637842f, 0.08906568f, -0.12528835f, 0.07994245f, 
    -0.09486347f, 0.02327670f, 0.16373932f, 0.06571661f, 0.26421767f, -0.13064682f, -0.18332711f, 0.08749365f, 
    0.03400451f, -0.07705679f, -0.01427503f, 0.03476479f, 0.01451366f, 0.02434445f, -0.02256797f, 0.04842548f, 
    0.08528093f, -0.09333308f, -0.11161250f, 0.09229720f, -0.05262417f, 0.13867357f, 0.12090637f, -0.01846278f, 
    0.00430896f, 0.00808396f, -0.04103408f, -0.10539809f, -0.50346053f, -0.15493602f, -0.00337750f, 0.05442175f, 
    -0.06960156f, 0.10413018f, -0.07300913f, 0.18626617f, 0.04267112f, 0.04482704f, -0.08928115f, 0.01946110f, 
    0.21889006f, -0.10483753f, -0.05978850f, 0.08297635f, 0.04319053f, 0.02224869f, 0.00974453f, -0.00790659f, 
    0.01726630f, 0.02224421f, 0.01651616f, 0.06518437f, 0.28493595f, -0.17002386f, 0.01560848f, 0.02738250f, 
    0.01806400f, -0.07893575f, -0.03881198f, 0.01714721f, 0.05748971f, 0.05536127f, 0.04201437f, 0.04668342f, 
    -0.05677650f, 0.01888973f, 0.01909566f, 0.01477651f, -0.05410938f, 0.04270524f, -0.02564510f, -0.01273104f, 
    0.03427070f, 0.00886992f, -0.03410145f, 0.01904940f, 0.04043702f, -0.03083987f, -0.03483395f, -0.01933880f, 
    0.00364543f, -0.05391607f, 0.03448733f, -0.03849733f, 0.01314019f, 0.00022783f, -0.00968529f, -0.04397488f, 
    0.04278551f, -0.01955882f, 0.00940257f, -0.02260695f, -0.05052051f, -0.03508284f, 0.00887321f, -0.04342111f, 
    -0.01938760f, -0.04099990f, -0.04610397f, 0.00475871f, -0.01588823f, -0.01672632f, -0.03311792f, -0.00533133f, 
    -0.03383422f, 0.01856666f, 0.01579864f, 0.00883673f, 0.01041781f, 0.03111666f, -0.04523768f, 0.00275487f, 
    0.00631000f, -0.00346780f, -0.03304999f, -0.00373391f, -0.03250375f, 0.02972487f, 0.02707610f, -0.00655546f, 
    0.00251610f, -0.03752135f, -0.05291139f, -0.05912983f, 0.00388300f, 0.04237981f, -0.01394889f, 0.01053738f, 
    -0.05659555f, -0.03080905f, 0.03011395f, 0.00714897f, -0.03451521f, 0.00083509f, -0.02025490f, 0.03357577f, 
    -0.03819050f, -0.05047319f, -0.04268638f, -0.00411215f, 0.01952587f, 0.00435577f, 0.00331294f, 0.03728401f, 
    0.03262025f, -0.03950301f, 0.02751964f, 0.03340837f, 0.03685688f, 0.02853522f, 0.00500098f, -0.00831709f, 
    -0.05282722f, -0.02211260f, 0.01588368f, 0.03755039f, 0.00130383f, -0.01933242f, 0.01624897f, 0.00145321f, 
    -0.02109563f, 0.00182225f, -0.04365534f, -0.03215959f, -0.05745113f, -0.02846405f, 0.03168863f, 0.03627411f, 
    -0.05589494f, -0.04300852f, 0.02791389f, -0.02425869f, 0.02692933f, 0.00831443f, -0.03727019f, 0.03609230f, 
    -0.03361904f, -0.00272108f, 0.03207037f, -0.04147942f, 0.02617559f, -0.00469392f, 0.02987327f, -0.00117533f, 
    -0.04301694f, 0.02191971f, -0.00651275f, 0.02211127f, 0.00813035f, -0.05506274f, 0.01917391f, -0.00242602f, 
    -0.03977179f, -0.03361116f, 0.01354974f, 0.02891115f, 0.03263910f, 0.02269078f, -0.04282371f, -0.04867689f, 
    -0.03671039f, 0.01088983f, -0.04572937f, -0.01586858f, -0.04148977f, 0.00261904f, 0.02203277f, 0.01618130f, 
    -0.02305146f, 0.03114303f, 0.02580856f, 0.00982761f, 0.03690500f, -0.05458412f, 0.01137976f, -0.00989303f, 
    -0.02469054f, -0.04621043f, 0.03392730f, 0.00058296f, -0.00921015f, -0.00106311f, -0.00357587f, -0.00969542f, 
    -0.05805579f, -0.01295817f, -0.03761190f, -0.03485583f, -0.01992042f, 0.02909768f, -0.04290191f, 0.04446345f, 
    0.00182126f, 0.00780994f, 0.03742601f, -0.00290197f, 0.03573044f, -0.04643806f, 0.02964830f, -0.01322708f, 
    -0.05054743f, 0.02876151f, 0.02655787f, -0.03844252f, 0.03374537f, 0.02942753f, -0.02992788f, 0.02756446f, 
    -0.00224974f, 0.00333068f, -0.05952679f, 0.04074873f, 0.03110602f, -0.03887500f, 0.03044124f, 0.01954642f, 
    0.01711461f, -0.03693627f, -0.04556623f, -0.03446939f, -0.02093347f, 0.02395919f, -0.04469188f, -0.04730511f, 
    -0.03137570f, 0.04144351f, -0.03444506f, 0.01959698f, -0.01287421f, -0.04192621f, -0.00975680f, -0.02855981f, 
    0.00192040f, 0.04001900f, 0.00879290f, -0.03561589f, 0.03389251f, 0.02540460f, -0.04967572f, -0.05673765f, 
    -0.03693081f, 0.00291180f, 0.03806448f, 0.02302257f, 0.01853278f, -0.00743670f, -0.02061197f, -0.05615904f, 
    -0.03387484f, 0.00527979f, -0.05146776f, -0.03136932f, -0.00607129f, 0.02119881f, 0.01750037f, 0.04495069f, 
    0.04302670f, 0.03366592f, 0.02794450f, -0.02319836f, -0.03967599f, -0.02142859f, -0.01347911f, -0.00518546f, 
    0.03716271f, -0.00438174f, -0.02727230f, -0.05358076f, -0.02986115f, -0.05295554f, -0.05485934f, 0.01722461f, 
    -0.01721697f, -0.05359646f, -0.05640397f, 0.01982895f, -0.02514231f, 0.01475803f, 0.02628443f, 0.01051787f, 
    -0.03227046f, -0.05521596f, -0.00707713f, 0.00144046f, 0.01822891f, -0.04502900f, -0.04837560f, -0.05440029f, 
    -0.01410324f, -0.00366222f, 0.02955834f, -0.03999466f, -0.00794593f, -0.03290050f, -0.05524227f, -0.01406529f, 
    0.02472071f, 0.00963331f, 0.03235978f, 0.01066388f, -0.05407227f, -0.03813713f, 0.01967060f, -0.02804437f, 
    0.01358483f, -0.05442762f, -0.05850296f, -0.03797546f, -0.04461779f, 0.01601366f, -0.03427049f, 0.00977016f, 
    0.03585925f, 0.00678845f, -0.04641671f, 0.00425293f, 0.00404833f, 0.02054289f, 0.03452982f, 0.02403276f, 
    0.03892225f, 0.03092574f, -0.05702433f, -0.01128657f, 0.02033080f, -0.00867598f, 0.03549207f, 0.00884689f, 
    -0.04720949f, -0.01274240f, -0.05233380f, 0.02859485f, 0.01317662f, -0.01037353f, -0.03222275f, -0.01322415f, 
    -0.01341106f, 0.01514926f, 0.00752793f, -0.03297782f, 0.02353165f, -0.01114054f, -0.00660237f, 0.00939810f, 
    -0.05347556f, -0.04514057f, -0.01861930f, -0.05512332f, -0.02572314f, -0.00056572f, -0.01629734f, -0.05856597f, 
    -0.00995483f, -0.01758902f, 0.00831683f, -0.02411562f, 0.00392865f, 0.01724080f, -0.04230846f, -0.01942271f, 
    0.03131770f, -0.00365626f, 0.01652118f, 0.02997258f, 0.01655950f, 0.02394037f, -0.04825163f, -0.02955771f, 
    0.02918821f, -0.01811311f, 0.00898986f, 0.03245926f, -0.05643877f, -0.02252478f, 0.04405786f, -0.03243186f, 
    -0.04974505f, 0.03848076f, 0.03240938f, 0.02723410f, -0.01447143f, -0.04998329f, 0.01536310f, 0.00546504f, 
    0.01124679f, -0.01704057f, -0.01656929f, 0.03488758f, -0.04642697f, -0.00769224f, -0.00336922f, -0.01206721f, 
    0.01776814f, -0.00867034f, 0.02943868f, 0.03412674f, -0.03576045f, 0.03227535f, 0.04125180f, 0.00876367f, 
    0.04229923f, -0.02666108f, -0.02703066f, -0.05036285f, -0.00310531f, 0.02268185f, 0.03859114f, -0.03348303f, 
    0.02613514f, -0.00184429f, 0.00099130f, -0.00558045f, 0.02780668f, 0.03450524f, -0.03496317f, -0.03705735f, 
    0.02014160f, 0.00290534f, 0.03981078f, -0.01162101f, 0.02469225f, -0.03835855f, 0.03713816f, 0.00246018f, 
    -0.03280690f, 0.02103279f, 0.02678214f, -0.01523418f, 0.00786385f, 0.01483441f, 0.01742599f, 0.02383040f, 
    0.02982230f, -0.02583468f, -0.02743511f, -0.04875334f, -0.00241338f, -0.02853166f, -0.03651547f, -0.01532317f, 
    -0.02281607f, -0.02947866f, -0.02857929f, -0.01834593f, 0.01217206f, -0.04449631f, 0.01762326f, -0.00526549f, 
    -0.05393942f, -0.01869421f, -0.05110577f, -0.01065058f, -0.04243900f, -0.04546397f, 0.01988645f, 0.03277067f, 
    -0.02516050f, -0.04165853f, 0.03744380f, 0.04045545f, -0.01859892f, -0.00344691f, -0.02868174f, -0.04791179f, 
    0.00303558f, 0.01452387f, -0.05007749f, -0.04695207f, 0.03915007f, 0.03396773f, 0.03432241f, 0.02702346f, 
    -0.05340834f, 0.02973180f, 0.03352141f, -0.00920961f, 0.01433565f, -0.05001505f, -0.01840110f, 0.00380065f, 
    -0.02575565f, -0.00831863f, -0.02713372f, 0.01775941f, -0.00833925f, -0.01755353f, 0.03643157f, -0.04647140f, 
    0.01112480f, -0.02204884f, 0.02532141f, -0.00311243f, 0.03143958f, 0.01527938f, 0.00412973f, 0.01878106f, 
    0.02987724f, -0.05630429f, 0.03009291f, -0.00307086f, -0.01114457f, -0.01235215f, 0.03742915f, 0.00668684f, 
    -0.02185843f, -0.04334201f, 0.03863177f, -0.04470688f, -0.00285068f, 0.02512554f, -0.05534841f, 0.00447655f, 
    -0.03240635f, -0.00786998f, -0.05766711f, -0.04983087f, -0.03648181f, 0.04105838f, 0.04162322f, 0.01126229f, 
    -0.02309532f, -0.00667874f, -0.04428718f, -0.01819841f, 0.00280687f, -0.00661259f, -0.03756553f, 0.01730207f, 
    0.00655119f, -0.02267682f, -0.03016244f, 0.00981156f, -0.01497049f, -0.03747986f, 0.00927705f, -0.03380126f, 
    0.02881646f, -0.05587145f, 0.01229624f, 0.01030262f, 0.03024871f, -0.04334182f, 0.04036482f, -0.05134992f, 
    -0.05157832f, -0.04741580f, -0.00207006f, -0.03644011f, 0.01985506f, 0.00134809f, -0.03977618f, -0.00153263f, 
    0.02595137f, -0.04648039f, -0.00722842f, 0.00999405f, 0.02954475f, -0.03242303f, 0.03109846f, -0.03186571f, 
    -0.04452789f, -0.03702916f, -0.01490597f, 0.03401029f, -0.04935123f, 0.01309251f, 0.02744489f, -0.01799016f, 
    0.00706875f, 0.01753943f, 0.02975000f, -0.03499132f, 0.00656553f, 0.01158004f, 0.00705658f, 0.02223177f, 
    -0.00182822f, -0.06057833f, 0.01972753f, -0.03992881f, 0.00253960f, -0.00836841f, -0.03444950f, 0.03228334f, 
    -0.01698456f, 0.04046291f, 0.01412443f, -0.00041270f, -0.03536874f, 0.02825059f, -0.05902176f, -0.03528760f, 
    -0.04023985f, -0.05521373f, -0.03073150f, -0.05115473f, 0.00178523f, -0.04858972f, -0.01612943f, 0.02636171f, 
    -0.01675621f, -0.02152943f, -0.03604691f, -0.02959011f, -0.01504082f, 0.02621725f, -0.03451676f, -0.03661015f, 
    0.03056311f, -0.05317586f, 0.00008236f, -0.04010978f, -0.05760959f, 0.03818104f, 0.03010936f, 0.03391365f, 
    0.03721995f, -0.03445824f, -0.02549875f, 0.01605132f, 0.02156678f, -0.00427815f, -0.01399727f, -0.04037298f, 
    -0.02387209f, 0.03589559f, -0.03183342f, 0.00192566f, 0.01043678f, -0.04330374f, -0.01337978f, -0.02339975f, 
    -0.02616319f, 0.01821993f, 0.01018625f, -0.03920315f, -0.01235765f, 0.02483953f, -0.05403501f, -0.03381899f, 
    -0.04557543f, 0.01239156f, 0.03653639f, 0.01396951f, 0.01278652f, 0.01197878f, 0.01883719f, -0.03013897f, 
    0.00320777f, -0.01206008f, -0.00537737f, -0.01134084f, -0.01033980f, 0.04154364f, -0.01208681f, 0.01399852f, 
    -0.03202885f, -0.00511887f, -0.01711909f, -0.05314290f, 0.00138977f, -0.05353796f, -0.05342101f, -0.02236942f, 
    0.03240095f, 0.02451358f, -0.01964354f, -0.04394009f, -0.05408785f, 0.00152780f, -0.02813365f, -0.04294449f, 
    -0.01386473f, 0.01540228f, -0.05370738f, -0.02857069f, -0.01366931f, 0.03822482f, -0.05111028f, -0.02165058f, 
    -0.00824187f, -0.01026493f, -0.00473615f, 0.01280634f, -0.02676341f, -0.04816623f, 0.01637215f, 0.01676536f, 
    -0.02374374f, -0.05481188f, 0.02339008f, -0.04233940f, -0.01665425f, 0.02830954f, -0.03201011f, -0.03006566f, 
    -0.02503363f, -0.00706811f, -0.00189791f, 0.01081398f, 0.02516068f, -0.04731900f, 0.02783874f, -0.00612129f, 
    0.01448764f, -0.04361442f, 0.02694117f, 0.01375507f, -0.01719869f, 0.01799880f, -0.00024558f, -0.05026259f, 
    -0.02522812f, -0.00440388f, -0.03110722f, -0.04556671f, -0.06016960f, 0.02375580f, 0.00918722f, -0.02620635f, 
    -0.02108698f, -0.00297139f, -0.01010484f, 0.02334360f, -0.01736727f, -0.01086523f, -0.00038774f, -0.00853742f, 
    -0.00539934f, 0.01907341f, 0.01158404f, 0.00796016f, -0.02644772f, -0.00379075f, -0.00413074f, -0.03660038f, 
    -0.03818291f, -0.03375969f, 0.00820136f, -0.03716137f, -0.00328660f, -0.01491519f, 0.02696838f, 0.03441694f, 
    -0.05053519f, -0.04035494f, -0.00516243f, -0.01045081f, 0.02256691f, -0.02148767f, 0.03611327f, -0.00040289f, 
    -0.03115137f, -0.00096198f, -0.04512646f, 0.00049102f, 0.01882070f, -0.01892612f, -0.01215737f, -0.04193561f, 
    0.04188926f, -0.03119400f, -0.01847412f, 0.00605277f, 0.03602204f, -0.02103205f, -0.05745732f, -0.05780470f, 
    0.03999906f, -0.04457932f, 0.01436925f, 0.00949866f, 0.03091684f, 0.03167465f, 0.00855806f, -0.04933722f, 
    0.02773483f, -0.01660829f, 0.04074976f, -0.02307931f, -0.03635236f, -0.01077730f, 0.03596256f, -0.05257042f, 
    -0.00369954f, -0.05837929f, 0.02664823f, -0.03453600f, -0.04782926f, 0.02111097f, 0.00674667f, -0.00056514f, 
    -0.01522701f, -0.02762584f, 0.01838267f, -0.02309295f, -0.00822474f, -0.00196817f, -0.04738064f, 0.00048168f, 
    -0.04653509f, -0.02237021f, -0.04241471f, 0.02827784f, -0.03596691f, -0.04403056f, 0.02291783f, 0.00680434f, 
    0.01252762f, -0.03577432f, 0.02203015f, -0.02534202f, -0.04443802f, 0.02353163f, 0.00672890f, -0.01041451f, 
    -0.04342727f, -0.05191170f, 0.00715081f, -0.00910014f, 0.01632528f, -0.03674216f, 0.02586734f, 0.03075428f, 
    -0.01841968f, 0.02623016f, -0.01446099f, -0.04611592f, -0.01532170f, -0.01429793f, -0.02476666f, -0.01910645f, 
    -0.02101752f, -0.02777495f, 0.00905651f, 0.02277856f, 0.04434692f, -0.01618589f, 0.01054027f, -0.01814882f, 
    -0.03961973f, -0.04997506f, -0.00326560f, -0.03733406f, 0.03595833f, -0.01348206f, 0.00238883f, 0.00514292f, 
    -0.01820339f, -0.00289567f, 0.00054669f, 0.00963280f, 0.03039212f, 0.01921863f, -0.01337769f, 0.00985864f, 
    -0.05272947f, 0.01229623f, 0.02964638f, -0.05396357f, -0.02144001f, -0.02981118f, 0.03633158f, 0.03469959f, 
    0.00713636f, 0.03520461f, 0.01260306f, -0.03445227f, 0.00446205f, 0.01373146f, -0.03695885f, -0.03459544f, 
    0.00135890f, -0.00545223f, -0.05070057f, -0.01878540f, 0.01458846f, -0.01124625f, 0.03047504f, -0.04386425f, 
    -0.05032491f, -0.04989227f, 0.00148271f, 0.03142484f, -0.04581846f, 0.03532581f, -0.02413722f, 0.03478945f, 
    -0.01104396f, 0.01927630f, -0.03734276f, -0.01040035f, -0.02402403f, -0.02830577f, -0.02608280f, 0.00546561f, 
    -0.02132359f, -0.03280970f, 0.01160037f, -0.01794177f, -0.04833591f, -0.02453851f, -0.03296820f, 0.01107799f, 
    -0.03959521f, 0.02448656f, -0.01657380f, 0.02523840f, -0.03420285f, 0.04336670f, 0.00419424f, -0.03476009f, 
    -0.05563735f, 0.02754950f, -0.04788713f, -0.02407728f, 0.03472791f, -0.04855293f, 0.00983420f, -0.04632309f, 
    0.02508729f, -0.04900895f, 0.02899381f, -0.04747380f, -0.05496088f, 0.01353812f, -0.01406670f, -0.03918636f, 
    -0.00001001f, 0.03430363f, -0.00009102f, -0.00171427f, -0.01255597f, -0.02891496f, -0.03753643f, 0.00931716f, 
    0.03505996f, -0.02906573f, 0.01099568f, -0.01392430f, 0.02782624f, -0.01413895f, -0.00159036f, 0.03156982f, 
    0.04183467f, -0.02643623f, -0.01541383f, 0.03780753f, -0.00633095f, 0.01422022f, -0.01564519f, -0.04171442f, 
    -0.04265433f, -0.04580863f, -0.04918364f, 0.02924039f, -0.01117324f, -0.04230604f, -0.03213833f, -0.01774933f, 
    -0.02167768f, -0.02623919f, -0.00420741f, 0.02492790f, 0.01693776f, -0.01183740f, -0.03147894f, 0.02021216f, 
    -0.01618949f, -0.03770456f, 0.04099514f, -0.01540130f, 0.03022059f, 0.02513515f, -0.04895211f, -0.01923706f, 
    -0.00605099f, -0.04387092f, -0.00774786f, -0.04885979f, 0.00422772f, 0.01406935f, 0.01387347f, -0.00941205f, 
    0.03577229f, -0.05138945f, -0.02859751f, -0.00347068f, 0.01680341f, 0.02661752f, 0.03780971f, 0.01834852f, 
    -0.00076762f, -0.04456799f, -0.00453134f, 0.02902423f, -0.02782831f, 0.02414763f, -0.05443839f, 0.02898388f, 
    0.04511156f, -0.00015617f, 0.00010442f, 0.00427572f, -0.04372643f, -0.05452552f, 0.01513609f, -0.00627178f, 
    0.03931585f, -0.04417873f, 0.03335403f, 0.02125546f, 0.01155718f, -0.02130618f, -0.04142235f, 0.00528015f, 
    0.01059061f, -0.02646375f, -0.05483963f, -0.04519157f, -0.05021299f, -0.04193657f, -0.00789238f, 0.01182884f, 
    0.01948760f, 0.02957738f, -0.05454365f, -0.05518172f, 0.00913570f, 0.02697565f, -0.01193126f, -0.01457192f, 
    0.00687753f, 0.03544549f, -0.00290411f, 0.00152134f, -0.03528020f, -0.04905032f, -0.02480981f, 0.02529378f, 
    -0.01978473f, -0.01255267f, -0.00856458f, -0.03820062f, -0.05564998f, -0.01593263f, -0.01016764f, -0.04144181f, 
    -0.05197612f, -0.02269593f, -0.01107467f, -0.01643583f, -0.01655041f, -0.01058676f, -0.00610068f, 0.04073474f, 
    -0.04773349f, -0.00740819f, 0.02500765f, -0.04746693f, 0.01770935f, -0.01536367f, -0.01480865f, -0.01576794f, 
    0.03209639f, -0.03792670f, -0.04213243f, -0.00031857f, 0.01464334f, 0.01023586f, -0.02172538f, -0.03635466f, 
    -0.03264140f, -0.04763112f, 0.02325617f, 0.00223604f, -0.04660887f, -0.00244609f, -0.03262126f, 0.03517275f, 
    0.02751609f, -0.00503993f, -0.00969651f, 0.01149566f, 0.02997367f, -0.01528925f, -0.04081522f, 0.04548401f, 
    -0.03862720f, -0.00963225f, -0.05179396f, 0.01955643f, -0.00794255f, -0.05077024f, -0.02316660f, -0.02174425f, 
    0.00768346f, 0.01001719f, -0.03081007f, 0.00860705f, 0.02736716f, -0.00230180f, -0.03511100f, 0.01002667f, 
    -0.01862953f, 0.03417142f, 0.03932865f, 0.03363955f, -0.03317157f, 0.00882566f, 0.01556823f, 0.04094178f, 
    0.04553292f, 0.00876869f, -0.00096615f, 0.01013053f, 0.03640012f, 0.01114448f, -0.01859743f, -0.03378620f, 
    -0.04662465f, 0.00181137f, 0.01604318f, -0.01045832f, -0.03977600f, -0.00758564f, -0.00211178f, -0.00084960f, 
    0.01498855f, -0.01572577f, 0.01052871f, 0.00837255f, -0.00081090f, -0.00419815f, -0.00309552f, -0.00244533f, 
    -0.04676576f, 0.01127416f, 0.03511494f, -0.02081773f, 0.02043357f, 0.03971305f, -0.02869307f, -0.01806922f, 
    0.02519432f, -0.01851152f, -0.03383908f, -0.02349793f, 0.02441337f, 0.02473211f, 0.02727223f, -0.03637296f, 
    0.01367119f, -0.02442428f, -0.05379879f, 0.01718719f, -0.01076447f, 0.01591792f, -0.00078944f, -0.01572697f, 
    -0.02084358f, 0.03711369f, 0.03463050f, -0.01963343f, -0.04627758f, 0.02228844f, -0.01695968f, -0.02532192f, 
    0.02406432f, 0.03734982f, -0.04811883f, -0.01726200f, 0.01628545f, -0.00399890f, 0.03978864f, -0.03472577f, 
    0.00202057f, -0.01627006f, 0.15963268f, -0.29358864f, 0.11239491f, 0.04309638f, 0.09014304f, 0.01915026f, 
    -0.03753145f, 0.03383717f, -0.07462403f, 0.02013276f, -0.23089056f, 0.09365703f, -0.07853205f, -0.01608712f, 
    0.02657105f, 0.07444982f, 0.00923651f, 0.03285205f, 0.02976433f, 0.02471936f, 0.19435826f, 0.10348499f, 
    0.15328769f, 0.12632322f, -0.07257009f, 0.17872362f, 0.01521855f, 0.05632863f, -0.27960768f, -0.05045401f, 
    0.01062791f, 0.06667903f, 0.01562542f, -0.22391778f, 0.06226193f, 0.20790525f, -0.08902860f, 0.14716731f, 
    -0.10150596f, -0.09594921f, -0.12741725f, 0.03037581f, 0.03088696f, 0.05475237f, -0.17482181f, -0.13523436f, 
    -0.08673139f, -0.08617074f, 0.20730630f, -0.03205717f, -0.07246377f, -0.02938944f, 0.00105459f, 0.10687707f, 
    0.04494474f, -0.03781116f, -0.00052990f, 0.02341063f, -0.36145514f, 0.23890777f, -0.02820993f, -0.32768896f, 
    0.05357637f, 0.06982530f, 0.07449390f, -0.03520989f, -0.04913371f, 0.05154329f, 0.02970269f, 0.04944308f, 
    0.03488319f, 0.09305423f, 0.07478221f, -0.28925109f, 0.19997539f, -0.03722101f, 0.02823759f, 0.12201034f, 
    -0.04109510f, -0.07444772f, -0.06034020f, 0.02369958f, -0.33893511f, -0.00842873f, -0.08098026f, -0.01179156f, 
    0.10307270f, -0.01727689f, -0.07305988f, -0.11277024f, 0.08879201f, 0.04795632f, 0.06691380f, 0.09216924f, 
    -0.06163828f, -0.05581152f, 0.02460411f, -0.17839299f, 0.03789923f, 0.04089007f, -0.05598302f, 0.16254270f, 
    0.18420342f, -0.14791752f, 0.07929625f, -0.12367603f, -0.14559783f, -0.15077569f, -0.08565400f, -0.01097572f, 
    -0.02731530f, 0.07184679f, -0.00285131f, -0.02036023f, -0.14788592f, -0.05375618f, -0.14276333f, 0.05439920f, 
    -0.01385757f, 0.10332336f, -0.07557897f, -0.02341118f, 0.08962658f, -0.01301173f, 0.00131562f, -0.04268702f, 
    -0.03430012f, -0.12734546f, -0.04191583f, -0.10141730f, 0.43501318f, 0.23796475f, 0.08637391f, 0.01830913f, 
    -0.01362102f, -0.03416655f, -0.07173852f, 0.01416413f, 0.15087196f, 0.01479319f, -0.00465235f, 0.03296766f, 
    0.11551087f, 0.00318860f, -0.02360447f, 0.33292001f, -0.11516187f, -0.08403030f, 0.06644199f, -0.04886286f, 
    -0.03883994f, -0.04890513f, 0.00731761f, 0.07740285f, 0.03435460f, 0.21232550f, 0.00713798f, -0.06142391f, 
    -0.01342262f, 0.05625900f, -0.07155548f, -0.07407719f, 0.01064645f, -0.16649783f, 0.04377305f, 0.10230806f, 
    0.27534464f, 0.12613451f, -0.03491393f, 0.25165084f, -0.02742631f, 0.07061683f, 0.00012552f, 0.01786202f, 
    0.07225519f, -0.11650474f, 0.02570902f, -0.01915902f, 0.10072596f, -0.00623596f, 0.10582003f, -0.10166696f, 
    -0.02727174f, 0.09122052f, 0.00283583f, 0.18245362f, -0.03260329f, 0.11628936f, -0.03271687f, 0.04969735f, 
    0.17660089f, 0.08438988f, -0.14575544f, 0.06725436f, 0.04754334f, 0.07975638f, -0.07959072f, -0.04125021f, 
    0.10149840f, 0.00829099f, 0.13127398f, 0.06842094f, 0.10939411f, -0.08060299f, 0.20826373f, 0.16169773f, 
    0.05326664f, -0.06370195f, -0.02551520f, 0.03967759f, 0.04911711f, -0.06704046f, -0.03722150f, 0.13218883f, 
    0.35893890f, 0.20205981f, 0.03202864f, -0.12757587f, 0.00706299f, -0.10067415f, -0.09372037f, 0.10986520f, 
    -0.13926829f, -0.02174329f, -0.13519767f, -0.00792054f, 0.22757280f, 0.12870929f, 0.09453750f, 0.38032937f, 
    -0.08811766f, 0.00649891f, 0.14453734f, 0.04408950f, 0.01761258f, 0.04658436f, -0.11603039f, 0.07875819f, 
    0.02439700f, -0.02254641f, -0.05194206f, -0.26358831f, -0.05403959f, -0.06872761f, 0.07809757f, -0.02931118f, 
    -0.13183390f, 0.05008438f, 0.01762572f, 0.16493531f, 0.02191489f, -0.17467047f, -0.10657055f, -0.01684642f, 
    -0.04597216f, -0.02070200f, -0.09427956f, -0.00716997f, -0.03326099f, 0.06535067f, 0.08730080f, -0.14915812f, 
    0.15241249f, -0.13527305f, -0.18792479f, 0.26116839f, 0.07493158f, 0.03480160f, -0.05517431f, 0.04195873f, 
    -0.01064742f, 0.05801791f, 0.07203719f, 0.10038669f, 0.14279395f, 0.09778851f, -0.00157051f, 0.03562739f, 
    0.06533532f, -0.06509384f, -0.01613401f, -0.03191439f, -0.05703564f, 0.15758738f, 0.02784224f, 0.13424312f, 
    -0.32398930f, 0.02460635f, -0.17369466f, -0.01400785f, 0.04333752f, -0.02391829f, -0.01911442f, 0.01389173f, 
    0.01875692f, -0.09403680f, -0.00634668f, 0.05950711f, -0.05493248f, 0.08685286f, -0.05775160f, 0.11808841f, 
    -0.13691348f, 0.04908188f, -0.02585218f, -0.02150784f, -0.08031151f, -0.08335652f, 0.00994627f, 0.02737024f, 
    -0.04633581f, 0.28103280f, -0.09052575f, -0.16267541f, 0.06648494f, -0.00611666f, 0.11896592f, -0.15922220f, 
    0.13117971f, 0.03730076f, 0.14726023f, -0.18011416f, -0.28215858f, 0.02472908f, -0.11671165f, -0.12827368f, 
    0.01670972f, 0.10380145f, 0.08796423f, 0.10533930f, 0.04710240f, -0.07181180f, 0.07172395f, 0.08982748f, 
    -0.23222922f, -0.13480684f, -0.11095718f, -0.03769911f, -0.17821474f, -0.00987772f, -0.05468167f, -0.07679099f, 
    0.06584159f, -0.16854721f, -0.06834767f, 0.02242838f, 0.08470250f, 0.18601434f, -0.04833544f, -0.01845858f, 
    0.00054498f, -0.10276403f, -0.03265521f, 0.01393505f, 0.04742875f, 0.11232273f, 0.03695181f, 0.01818436f, 
    -0.00918725f, 0.02310898f, 0.04802723f, 0.25358149f, -0.05074552f, 0.04237618f, 0.00777633f, 0.01134088f, 
    -0.08424816f, -0.07670938f, -0.02450035f, -0.03040910f, 0.13556606f, 0.07411879f, 0.01410067f, 0.09711298f, 
    -0.11199468f, 0.07664421f, 0.08574101f, 0.05268142f, 0.00102554f, -0.03399627f, -0.15786944f, 0.00377348f, 
    0.06899681f, -0.00745940f, -0.09519127f, 0.24601214f, 0.08635262f, -0.02489319f, -0.04267859f, -0.09148242f, 
    0.00272926f, 0.10063711f, -0.10702226f, -0.07291567f, -0.20111428f, -0.04975635f, 0.22411993f, 0.13805091f, 
    0.10191128f, 0.02571180f, -0.09258261f, -0.09470633f, 0.05239863f, 0.21634923f, 0.03643205f, 0.13393314f, 
    -0.20133199f, 0.12789015f, 0.10417305f, -0.18864208f, 0.06072072f, -0.05938661f, -0.01877598f, 0.00688617f, 
    -0.08986957f, 0.03776855f, 0.09248770f, -0.13111520f, 0.00585412f, -0.07634336f, -0.00211890f, -0.10945319f, 
    -0.09929010f, -0.06132560f, 0.28478727f, 0.19197752f, -0.06293781f, 0.04727272f, -0.05176425f, -0.01525822f, 
    0.41800842f, -0.23992069f, -0.08930230f, 0.23878238f, -0.00873466f, -0.08999366f, -0.03560985f, 0.01046806f, 
    0.10347764f, -0.02371895f, 0.09438267f, 0.10948139f, 0.44761711f, 0.08840608f, -0.00682411f, 0.32940972f, 
    0.08230607f, -0.05183536f, 0.06420630f, -0.02436275f, 0.03914090f, 0.08682749f, 0.02503098f, 0.00084608f, 
    0.05851826f, -0.13231921f, -0.04453552f, 0.14198533f, -0.09791302f, 0.07364662f, -0.08846124f, -0.09347600f, 
    0.03933062f, 0.00942540f, 0.02700168f, -0.02731387f, -0.10638066f, -0.11670691f, -0.02937280f, 0.26850152f, 
    0.04311471f, 0.05765598f, 0.04024320f, 0.15383340f, 0.05697925f, -0.07909377f, 0.08126795f, 0.12022769f, 
    0.23178853f, 0.02334330f, 0.15730029f, 0.11824925f, -0.00570006f, 0.02893059f, 0.04728334f, 0.02875916f, 
    0.09694315f, 0.02253086f, 0.01605197f, -0.08765694f, 0.04011546f, -0.01735225f, 0.39329526f, -0.02031334f, 
    0.06266546f, -0.08107476f, 0.08626387f, -0.11744897f, -0.02809118f, 0.06137197f, -0.09002475f, 0.12132104f, 
    0.12915783f, 0.00935133f, 0.07775859f, -0.14606974f, -0.11341275f, -0.05102476f, 0.15867336f, 0.06891596f, 
    -0.00318680f, 0.03128363f, 0.06529438f, 0.00952087f, -0.39091009f, 0.10556743f, -0.17502874f, -0.03258385f, 
    -0.19526580f, -0.00540114f, 0.06912003f, 0.00489945f, 0.01958323f, -0.02679605f, -0.07048605f, -0.11906144f, 
    -0.06039939f, -0.21497105f, -0.02042882f, 0.26643223f, 0.16794673f, 0.05480449f, -0.01520810f, -0.03341160f, 
    0.06968253f, -0.08177529f, 0.14118806f, 0.11546526f, -0.08684868f, -0.18335423f, -0.19568390f, 0.03614261f, 
    0.08945315f, 0.03210174f, 0.11824936f, 0.03136862f, 0.03454400f, -0.05161326f, 0.08960509f, 0.06568854f, 
    -0.00773297f, -0.16289723f, 0.07459617f, 0.03929352f, 0.15751092f, 0.01546357f, 0.07362743f, -0.06475189f, 
    0.02145486f, -0.06411647f, -0.07261351f, 0.01889281f, 0.25135225f, 0.13776016f, 0.07564588f, 0.05653274f, 
    0.11021174f, 0.04635443f, -0.04054096f, -0.01613472f, 0.06939762f, 0.04899896f, 0.27739823f, 0.11870574f, 
    -0.02149136f, 0.29135239f, 0.05614184f, -0.18877470f, -0.08286584f, -0.07055754f, 0.01857455f, 0.06005113f, 
    -0.07912672f, -0.01635464f, -0.06071285f, 0.10370477f, -0.12264901f, -0.10483906f, -0.14028683f, 0.36415261f, 
    0.12118953f, 0.05118826f, 0.11452942f, -0.09946688f, 0.05433035f, 0.04222320f, -0.02899643f, 0.09400186f, 
    0.06484058f, 0.09290470f, 0.16332193f, 0.01449229f, 0.04706031f, 0.09152412f, 0.09745994f, -0.15409416f, 
    -0.10386226f, -0.01038067f, -0.08269700f, 0.13986470f, -0.04166099f, -0.13010143f, -0.07771915f, -0.07742779f, 
    -0.05023610f, -0.01068075f, 0.00680305f, 0.07137807f, 0.15343255f, 0.00922354f, 0.01067910f, 0.03850324f, 
    -0.07559913f, -0.00278026f, -0.26265636f, 0.08887994f, 0.28395179f, 0.00599073f, -0.14157650f, -0.04996581f, 
    0.07397509f, 0.19815271f, -0.05756974f, -0.02791140f, 0.03196562f, -0.03767785f, 0.01100789f, 0.10588183f, 
    0.10485537f, 0.05941768f, 0.02762206f, 0.00555466f, 0.08082584f, 0.05232471f, 0.08576305f, 0.18567392f, 
    0.12697995f, -0.04855621f, 0.11584159f, -0.12198476f, -0.04689444f, -0.10301402f, 0.12506838f, -0.02269105f, 
    -0.04208218f, 0.09795544f, 0.10476387f, 0.12451732f, -0.07417297f, -0.28867704f, -0.17871203f, 0.06498110f, 
    0.08873988f, 0.01992927f, 0.00067123f, 0.01161426f, -0.06553586f, -0.05578693f, -0.06072145f, 0.20150864f, 
    -0.02790119f, 0.07039891f, -0.03091512f, 0.04995141f, 0.22074322f, 0.10379895f, 0.04464503f, 0.09639759f, 
    0.09357356f, 0.02994266f, -0.04344088f, 0.10186473f, -0.40637887f, 0.17336351f, -0.00207042f, -0.07022401f, 
    0.05899248f, 0.03564562f, -0.11031758f, 0.04002472f, -0.08209880f, -0.01494283f, -0.09879576f, 0.06409863f, 
    -0.65255088f, 0.45318854f, -0.11765444f, -0.03273910f, -0.04689368f, 0.06173386f, -0.06767832f, -0.00233745f, 
    0.10922441f, 0.08250036f, -0.00841832f, -0.17810321f, 0.20796336f, 0.12207501f, -0.04745577f, 0.12077349f, 
    0.01365358f, -0.07820545f, 0.07017266f, 0.03096449f, 0.07373218f, -0.02130972f, 0.02289877f, 0.10381994f, 
    -0.10932878f, 0.26112524f, 0.14019091f, 0.11328479f, 0.05969469f, -0.07693823f, 0.30054972f, 0.15922096f, 
    0.04058474f, 0.05742812f, -0.17838445f, 0.10166142f, 0.01392936f, 0.31323749f, 0.25373170f, 0.05646921f, 
    0.06775778f, -0.02260736f, -0.00149626f, -0.00197535f, 0.11765618f, 0.08255195f, -0.12775464f, 0.13511349f, 
    -0.09571569f, -0.14101315f, 0.20705834f, 0.11062261f, 0.06760852f, 0.02851522f, -0.05228298f, -0.09921119f, 
    0.00865648f, -0.03272063f, 0.06823041f, -0.11935474f, 0.01425468f, -0.14626318f, -0.08706947f, 0.02044686f, 
    -0.00073174f, 0.17613892f, -0.04716327f, 0.05332202f, 0.05992343f, -0.10220566f, 0.09106889f, -0.00826759f, 
    -0.07753438f, 0.04687411f, -0.08194564f, 0.26112443f, -0.03387959f, 0.16149583f, -0.14997634f, 0.02105570f, 
    0.05231083f, 0.05677462f, -0.03097298f, 0.01603197f, 0.20521241f, -0.10502049f, 0.06211827f, -0.02109043f, 
    0.03810956f, -0.03816576f, 0.08761975f, 0.02705664f, 0.03127915f, 0.21546717f, -0.04751097f, 0.11816937f, 
    0.02547744f, -0.04308844f, 0.16590169f, -0.20589037f, -0.07077114f, -0.13717276f, -0.01618779f, 0.01357436f, 
    0.02713527f, -0.05874876f, 0.00765917f, 0.09286159f, 0.14262547f, -0.13795680f, 0.09513485f, 0.15811318f, 
    -0.00407970f, 0.02141289f, 0.12773593f, -0.06683661f, -0.00693887f, -0.00066491f, 0.03270327f, -0.03383068f, 
    -0.42678830f, 0.25830379f, -0.12748261f, -0.08189310f, 0.06053272f, 0.06203103f, 0.00030186f, 0.00642223f, 
    -0.05485390f, -0.01302158f, 0.15220666f, 0.09449800f, 0.19003168f, -0.27933547f, -0.01683198f, 0.37056610f, 
    -0.05919891f, 0.00126411f, -0.04032459f, 0.02753530f, -0.05914729f, -0.03344858f, -0.04878440f, -0.02170450f, 
    0.08989391f, 0.10886928f, -0.13153836f, 0.11553939f, -0.15050213f, 0.09163333f, -0.10254681f, -0.04843285f, 
    0.07608648f, 0.00605914f, 0.04761828f, -0.06346407f, 0.22283010f, 0.05411081f, 0.16020627f, -0.05950752f, 
    -0.01092182f, -0.04355398f, 0.02035095f, 0.18195876f, -0.02268439f, -0.01991762f, 0.09974913f, 0.05046509f, 
    0.09924447f, 0.05495598f, 0.06996278f, 0.10676344f, 0.07952909f, 0.13411810f, -0.00181361f, -0.12887856f, 
    -0.01875983f, 0.11674759f, -0.04468386f, -0.08270540f, 0.05242622f, 0.21379778f, 0.15873963f, 0.00493124f, 
    0.09983630f, -0.12736298f, 0.02503947f, 0.09903107f, 0.11218464f, -0.03137726f, 0.03909688f, 0.03498488f, 
    0.05078632f, 0.08291057f, 0.28175613f, 0.00726402f, 0.04057221f, -0.01368464f, 0.18340068f, 0.05287388f, 
    -0.03306818f, 0.07678475f, 0.00440745f, -0.01673651f, -0.16472596f, -0.00514509f, -0.08356836f, -0.04234444f, 
    -0.07075952f, 0.08474085f, 0.01983112f, -0.08015827f, -0.01116141f, -0.11483981f, -0.05235227f, -0.00571948f, 
    -0.32956797f, 0.02013426f, -0.02235779f, -0.35674432f, 0.26016006f, 0.02273903f, -0.00515338f, -0.06573161f, 
    0.04456006f, 0.03005593f, 0.08445613f, 0.09397183f, -0.14407288f, -0.08910523f, -0.03877077f, 0.14464968f, 
    0.06404325f, 0.02442436f, 0.01006092f, 0.11226844f, 0.09641676f, 0.04396224f, 0.02939629f, 0.08429612f, 
    -0.29698667f, -0.12238072f, 0.01807186f, -0.18909754f, 0.06915773f, 0.02007599f, -0.02331583f, -0.15245287f, 
    0.00766661f, -0.03476577f, -0.05213734f, 0.04069725f, 0.09657183f, -0.01685525f, 0.01719109f, 0.05169313f, 
    0.04226660f, 0.16922340f, -0.02788091f, -0.17920201f, 0.00283951f, -0.04532206f, 0.19761357f, -0.03464023f, 
    0.05061215f, 0.01189888f, 0.05211837f, -0.04269175f, -0.01160269f, 0.03372838f, 0.12179295f, 0.08932801f, 
    0.01495591f, 0.05724283f, 0.05587141f, 0.01917863f, -0.12475714f, 0.04381886f, -0.07466932f, -0.19102472f, 
    0.18523785f, 0.04234086f, 0.01799442f, -0.04319560f, -0.07983903f, 0.05513740f, 0.01761651f, 0.08972969f, 
    -0.20370300f, -0.15951180f, 0.10770149f, 0.00505042f, 0.05404381f, 0.01803148f, -0.00278556f, -0.04216713f, 
    0.05275887f, 0.08815042f, -0.06737412f, 0.08012207f, -0.02897983f, -0.06129603f, -0.10695052f, -0.22019756f, 
    0.10223248f, 0.00465953f, -0.01976175f, -0.02232745f, 0.03942044f, 0.00972439f, -0.00476739f, -0.10661565f, 
    -0.20007877f, 0.04331027f, -0.01877794f, 0.14091530f, 0.27765188f, -0.01656515f, -0.19086188f, -0.02796048f, 
    -0.01633625f, 0.08585361f, -0.02241776f, -0.00302416f, -0.15663585f, 0.09198778f, 0.05064515f, 0.04414681f, 
    0.12330931f, -0.01614334f, 0.01500399f, 0.04900076f, 0.04895004f, 0.01849828f, 0.10008863f, 0.13138796f, 
    -0.19161063f, 0.19752191f, 0.17793334f, -0.24403371f, -0.00567394f, -0.12949170f, 0.14714803f, 0.04239853f, 
    -0.03923755f, 0.04342352f, 0.06095119f, 0.13887188f, -0.02144764f, -0.12155005f, -0.05520021f, 0.04422469f, 
    0.13583134f, 0.12325061f, 0.00619529f, -0.03658435f, 0.09670720f, 0.00119285f, 0.10292732f, 0.11549462f, 
    0.29866821f, 0.06615065f, 0.10576096f, 0.06261290f, 0.13666672f, -0.02507947f, 0.00840711f, -0.03726304f, 
    -0.00021145f, 0.11380111f, -0.07394513f, 0.04003854f, -0.14931831f, 0.12893197f, 0.16243024f, -0.05300660f, 
    0.14400554f, -0.17006093f, -0.02666717f, 0.09286578f, 0.01040867f, 0.03349886f, -0.04149384f, -0.01059001f, 
    -0.26357654f, -0.29119900f, 0.09272727f, 0.26823878f, -0.02277396f, -0.04159291f, -0.01195676f, 0.08528817f, 
    0.02853733f, 0.12480044f, 0.07888508f, -0.00904767f, 0.24123675f, 0.06721927f, -0.01731201f, 0.19887057f, 
    0.03749505f, -0.08488271f, 0.05116167f, -0.10746431f, -0.04097398f, 0.07324599f, 0.09157363f, 0.16578300f, 
    0.09626456f, 0.10602670f, 0.01728776f, 0.18268476f, 0.14890017f, -0.00977012f, 0.23972216f, 0.05484924f, 
    -0.02260962f, 0.00671027f, -0.12968855f, -0.02279257f, -0.19690186f, -0.09405494f, 0.13557728f, 0.24565350f, 
    0.05268299f, 0.01457013f, 0.12673625f, -0.09580088f, 0.10817081f, 0.07512999f, -0.02089623f, 0.09513427f, 
    -0.04257850f, -0.05559052f, -0.04642262f, -0.26218104f, 0.02290587f, -0.00449639f, -0.02386690f, -0.02458618f, 
    0.00187177f, 0.07565527f, -0.05860923f, 0.02557581f, -0.18852156f, -0.12261581f, 0.09233279f, 0.03112573f, 
    0.19979362f, -0.02688625f, -0.12576751f, -0.03279705f, -0.00441642f, 0.07089021f, 0.01865044f, -0.11032167f, 
    -0.37291571f, 0.03539722f, 0.03412372f, 0.09586808f, -0.02588533f, 0.02015221f, -0.13159485f, -0.03899801f, 
    -0.03418237f, -0.03627385f, 0.04451114f, -0.01396531f, 0.10614356f, -0.08870938f, 0.09005158f, -0.17492808f, 
    -0.17274216f, -0.04358615f, 0.01991319f, -0.18731511f, 0.02135163f, -0.10943191f, -0.15957373f, -0.15465167f, 
    0.23248504f, -0.23444521f, 0.07020151f, -0.09619878f, 0.04627579f, 0.03698302f, 0.19018471f, 0.02165145f, 
    -0.01028284f, 0.01569766f, 0.04229781f, 0.20788188f, -0.05510344f, 0.04110128f, 0.14711919f, -0.08732667f, 
    0.19556649f, 0.06242581f, 0.03562191f, 0.19080816f, 0.17781894f, 0.03761510f, 0.01933460f, 0.08989597f, 
    -0.15742815f, 0.35862538f, -0.00292407f, -0.02242062f, 0.13025288f, -0.03846644f, 0.01431055f, -0.10902943f, 
    -0.05627458f, -0.08448871f, 0.00065810f, 0.08998385f, 0.04428450f, -0.16351514f, 0.27021945f, -0.07642858f, 
    -0.00441305f, 0.01443497f, 0.06093008f, 0.03532006f, 0.05090472f, 0.11276755f, -0.00867138f, -0.00215779f, 
    -0.12047126f, 0.15455574f, 0.05800062f, 0.31106779f, 0.09072899f, 0.01633231f, 0.21002784f, 0.07536943f, 
    0.14851135f, 0.00970869f, -0.00841506f, 0.13562062f, -0.00169647f, -0.14531715f, 0.13263984f, 0.01578684f, 
    -0.03905145f, 0.14373699f, 0.02457953f, -0.08703989f, 0.02377430f, -0.14107361f, -0.01809569f, -0.11499708f, 
    -0.00885332f, 0.06593306f, 0.04931970f, 0.14760497f, 0.09024839f, 0.03433193f, 0.00390179f, 0.00323792f, 
    -0.17871006f, 0.09468133f, 0.03186932f, 0.07220160f, 0.04970226f, -0.00317110f, -0.00012060f, 0.14699085f, 
    0.09484253f, 0.09188033f, -0.07895193f, 0.15728331f, 0.13157707f, 0.12353893f, 0.16823341f, 0.04450909f, 
    -0.09276942f, 0.04778950f, 0.19668497f, 0.04787001f, 0.10047170f, -0.00427457f, 0.11075877f, 0.13573444f, 
    -0.01467254f, 0.06021483f, 0.02390355f, 0.08957442f, -0.08887448f, -0.11006062f, -0.01988380f, 0.04091711f, 
    0.15534601f, -0.02870428f, 0.06850234f, 0.14937265f, -0.10278735f, -0.07336640f, 0.15229493f, 0.16299723f, 
    -0.06678487f, -0.02623522f, 0.04827854f, -0.15334241f, 0.14774439f, 0.00552449f, -0.07137050f, -0.23986906f, 
    -0.11706568f, 0.05063051f, -0.06723110f, -0.04586059f, -0.22609968f, -0.03448799f, -0.13192347f, -0.13297747f, 
    0.04056347f, 0.06807417f, 0.05355963f, 0.05407858f, 0.13555296f, 0.07822277f, -0.10292667f, -0.02214127f, 
    0.06509354f, 0.10642900f, -0.01454445f, -0.14900997f, -0.03836435f, -0.00159492f, -0.13998966f, 0.00802735f, 
    -0.05085818f, 0.00167066f, 0.06446220f, -0.04971020f, 0.21636087f, 0.08281256f, 0.21441260f, 0.26362842f, 
    0.15625684f, -0.02769854f, -0.04704162f, 0.01298819f, 0.13329431f, -0.05790733f, -0.03535687f, -0.11354923f, 
    -0.01464735f, -0.14528275f, 0.02302755f, -0.15002516f, -0.02960848f, 0.03316994f, 0.14682390f, -0.01320020f, 
    0.04896604f, -0.09081022f, -0.04561364f, -0.07031476f, -0.16904110f, 0.10789970f, 0.17081507f, -0.11062481f, 
    0.00715186f, 0.05915598f, -0.16794583f, -0.20268008f, -0.02612488f, -0.03297941f, 0.10034654f, 0.08963083f, 
    -0.03858079f, -0.08268986f, -0.18742281f, 0.21265872f, -0.05034123f, 0.01510459f, 0.02147705f, 0.05794528f, 
    0.07720625f, 0.03150379f, 0.11052748f, 0.16565306f, -0.01851889f, 0.13042870f, -0.00055893f, -0.24362190f, 
    0.04163556f, -0.00168940f, -0.06223894f, -0.09597507f, -0.07502888f, -0.03247046f, 0.08816675f, 0.06036365f, 
    -0.34512857f, 0.13266517f, 0.09786268f, 0.13731454f, -0.03775476f, 0.10629138f, 0.20278440f, -0.05449957f, 
    0.05605463f, -0.09774169f, -0.00709331f, -0.18818958f, -0.15529488f, 0.08528994f, 0.02034001f, -0.12300000f, 
    0.06897763f, 0.07015930f, 0.00519901f, -0.03118667f, 0.08363597f, 0.05076765f, 0.13963817f, -0.09234362f, 
    -0.00227946f, 0.40238428f, 0.02791259f, -0.09426827f, 0.09926326f, -0.08009490f, 0.00855086f, 0.00428252f, 
    0.17761569f, -0.08474705f, -0.01908543f, -0.02867815f, -0.40713260f, -0.02480957f, -0.03241244f, -0.20860304f, 
    0.11209267f, 0.06716934f, 0.02995823f, -0.00866703f, 0.06605551f, -0.19826989f, -0.03168266f, -0.14453256f, 
    0.24245360f, -0.26755947f, 0.11454587f, 0.15843064f, -0.02982419f, 0.15279533f, -0.00052594f, -0.15457882f, 
    -0.01825685f, 0.01233061f, 0.03696719f, 0.19699287f, -0.10221344f, 0.16558273f, 0.11667582f, -0.23068795f, 
    0.10025188f, 0.00431398f, -0.12354398f, 0.04801087f, -0.00690368f, 0.14483997f, 0.05653797f, -0.03141003f, 
    0.50805503f, -0.18533504f, 0.06179415f, 0.12719363f, 0.05304632f, -0.10300017f, 0.03419242f, -0.02122833f, 
    0.02095452f, -0.04838038f, -0.19672646f, 0.06948222f, 0.07053072f, -0.27221772f, 0.29154193f, 0.08064722f, 
    -0.10510729f, 0.00748126f, -0.10080267f, -0.17991425f, 0.06970999f, -0.01179734f, 0.08681313f, -0.03369372f, 
    0.02555273f, -0.04316414f, 0.24291766f, 0.02083414f, 0.11205209f, 0.03898709f, 0.03998743f, 0.06895448f, 
    -0.09248703f, 0.09773080f, 0.09365930f, 0.15858911f, 0.61236346f, 0.19983688f, 0.02569312f, 0.14960587f, 
    0.11033385f, -0.02018064f, 0.03422877f, -0.04766290f, -0.14051460f, -0.02918809f, 0.05338326f, 0.09227472f, 
    0.07616303f, 0.17775972f, 0.03646292f, -0.11285754f, 0.18225501f, 0.00863039f, -0.13232858f, -0.20277332f, 
    0.04214996f, -0.02993455f, -0.01601537f, 0.07042938f, -0.29222986f, 0.30088285f, 0.13992876f, -0.10755555f, 
    0.06559315f, -0.16406628f, -0.05495344f, -0.16510832f, -0.01695929f, -0.02846071f, -0.09793404f, 0.06893451f, 
    -0.00770760f, -0.03082917f, 0.01165219f, 0.00755293f, 0.01602686f, -0.02852954f, -0.05635530f, -0.02022040f, 
    -0.03829200f, 0.00080998f, 0.01757951f, -0.05332128f, 0.01880781f, -0.05260837f, -0.03609540f, 0.00139555f, 
    -0.03423284f, -0.00877712f, -0.04040241f, 0.02081740f, 0.04274500f, -0.00841141f, 0.00949044f, -0.05220998f, 
    0.02131701f, -0.05722269f, 0.03423271f, 0.00789986f, -0.04896333f, 0.00022476f, -0.03168200f, 0.02520071f, 
    0.00153533f, 0.03720152f, -0.02559485f, 0.03570928f, 0.00193687f, 0.03623987f, -0.01259930f, 0.03711784f, 
    -0.04312475f, -0.00998657f, 0.02088764f, -0.01226423f, -0.00620534f, -0.00184016f, -0.02299383f, -0.00219845f, 
    -0.03359693f, -0.03015654f, 0.03234407f, 0.00903047f, -0.04003203f, -0.05001737f, -0.04766103f, -0.01527652f, 
    -0.02444282f, -0.00048145f, -0.01858876f, 0.01751035f, -0.01162524f, 0.02180215f, -0.01043222f, -0.02161494f, 
    -0.05615278f, -0.01330517f, -0.03063586f, 0.02118293f, -0.03274818f, -0.02607249f, -0.03363271f, -0.01700782f, 
    -0.04678834f, -0.00000856f, 0.00763698f, -0.04636667f, -0.02719996f, -0.03469834f, 0.01044543f, 0.00154334f, 
    -0.05341559f, 0.01520198f, 0.03360061f, 0.04228762f, -0.01212863f, 0.02480712f, -0.00899737f, -0.04346457f, 
    0.03924873f, -0.01843053f, 0.03151045f, -0.02526626f, -0.02411301f, 0.02155461f, 0.04180654f, 0.00278537f, 
    0.00052556f, -0.03316572f, 0.00779059f, 0.02115217f, -0.03135752f, -0.00619058f, -0.04760718f, -0.02630651f, 
    -0.01704198f, -0.01852765f, 0.03134641f, 0.04011524f, -0.03160314f, -0.00697340f, 0.01819065f, -0.01846835f, 
    0.01980470f, 0.01822349f, 0.02405895f, -0.04736450f, 0.01799811f, -0.03321553f, -0.03871168f, 0.03566983f, 
    -0.05175848f, -0.03332100f, 0.01932037f, -0.00548948f, -0.01536628f, 0.02803777f, 0.00741509f, -0.05139287f, 
    -0.05673154f, -0.05139498f, -0.01664169f, -0.03692117f, 0.02735073f, 0.02235241f, 0.04227417f, 0.02170527f, 
    -0.01309692f, -0.04030422f, 0.01522829f, 0.03909791f, -0.03976482f, 0.03316156f, 0.03674965f, -0.01306221f, 
    -0.05210667f, 0.02971046f, -0.02963914f, 0.04341093f, -0.02066957f, -0.03270521f, 0.00416939f, 0.03304635f, 
    0.03843099f, -0.00066337f, -0.03148928f, 0.01518698f, 0.00212553f, 0.03549205f, 0.01677041f, 0.00759249f, 
    0.03568899f, 0.02289936f, 0.01558897f, -0.00115592f, -0.00127221f, -0.03925882f, 0.01070008f, -0.01592251f, 
    -0.03942915f, -0.02047348f, 0.02494168f, 0.01097111f, 0.01889516f, 0.01851830f, -0.01825114f, 0.01916686f, 
    -0.05345294f, 0.01473473f, -0.00343509f, 0.03076551f, -0.00084050f, 0.01661629f, -0.01746689f, 0.03736675f, 
    -0.00409833f, 0.04142843f, 0.01377442f, -0.00476633f, -0.04716654f, 0.00316987f, -0.03593643f, 0.03937448f, 
    0.02305747f, -0.02845440f, 0.02625566f, 0.03386007f, 0.01701083f, -0.00746021f, -0.00045584f, -0.01895403f, 
    -0.02157135f, 0.00600454f, -0.02999410f, -0.04428311f, 0.03272153f, 0.03641728f, 0.03404206f, -0.04668653f, 
    -0.00691467f, -0.02817714f, -0.04059092f, -0.05274636f, -0.00326615f, -0.05405985f, -0.01823809f, 0.01671491f, 
    0.02951813f, 0.03313138f, 0.03388964f, -0.00915748f, 0.01579582f, -0.02416664f, 0.02305751f, -0.04530076f, 
    0.02708442f, -0.05369295f, -0.02801539f, -0.04565307f, -0.02835802f, 0.00642591f, 0.02490151f, 0.02490368f, 
    0.03925256f, 0.02276430f, 0.01865843f, -0.01033514f, -0.01040886f, -0.04493339f, 0.02149550f, -0.00915601f, 
    -0.05574884f, -0.00515039f, 0.01917084f, -0.04243598f, 0.03575639f, 0.03390978f, -0.00142003f, -0.05083074f, 
    -0.05623119f, -0.03059070f, -0.00472497f, -0.04346755f, 0.02391906f, -0.03421623f, -0.03180958f, -0.04776387f, 
    -0.00192807f, 0.00114959f, -0.01539960f, -0.01138901f, -0.03246424f, -0.04067603f, -0.01054745f, 0.01958849f, 
    -0.02574738f, 0.02896867f, -0.02338668f, -0.04776953f, 0.00416528f, 0.00102315f, 0.00175891f, -0.03357950f, 
    -0.00872912f, -0.05557467f, -0.04504693f, 0.04337341f, -0.00481648f, -0.02580274f, -0.04814051f, -0.02904685f, 
    0.01066934f, 0.00582371f, -0.00873514f, 0.03611987f, 0.00370163f, 0.02984710f, -0.00843197f, 0.00548272f, 
    -0.03537334f, 0.00437874f, -0.02651311f, -0.04266719f, -0.02096348f, -0.05609511f, -0.00490792f, -0.03793410f, 
    -0.04416645f, -0.00344667f, 0.03432267f, 0.04125427f, -0.03577875f, 0.00450885f, -0.01668924f, 0.02503329f, 
    0.03541959f, 0.01560694f, -0.02476412f, -0.00454151f, -0.01215153f, -0.02588140f, -0.05375312f, 0.02061811f, 
    -0.03983866f, 0.02921938f, 0.00993093f, -0.03267729f, -0.05469118f, 0.00273597f, 0.00433609f, 0.00180103f, 
    -0.05614624f, -0.03537967f, 0.04309986f, 0.01172380f, 0.01563678f, -0.02998002f, -0.00756109f, -0.02218871f, 
    0.03110923f, -0.00051213f, -0.00596004f, -0.02848565f, -0.04052241f, 0.01421336f, -0.04429326f, 0.00269520f, 
    0.04301406f, 0.03291333f, -0.04088099f, 0.03718141f, -0.02816501f, -0.00203279f, -0.02890521f, -0.00702053f, 
    -0.05739756f, -0.05241548f, -0.01799828f, -0.01641801f, 0.02357305f, 0.04087529f, -0.05278850f, -0.05392652f, 
    -0.05041614f, -0.00587527f, 0.04268532f, -0.03016761f, -0.04773476f, -0.00804620f, -0.01702599f, 0.04237799f, 
    0.00663242f, -0.02180927f, 0.01881281f, -0.00816467f, -0.02478034f, -0.02566300f, -0.05248709f, -0.03617650f, 
    -0.01879192f, 0.03426771f, -0.00510466f, -0.03962003f, -0.04259178f, -0.00608087f, -0.05676644f, 0.01659531f, 
    0.00546501f, -0.02824738f, -0.04251888f, -0.00307786f, 0.02633424f, 0.03370623f, 0.01449591f, -0.05625478f, 
    -0.03800415f, 0.00303250f, -0.00128676f, -0.01024382f, 0.04878291f, -0.02588880f, -0.04158958f, 0.03123191f, 
    -0.04261196f, -0.05113993f, 0.00063339f, -0.00857107f, -0.02773516f, 0.03164581f, 0.02813946f, 0.03609186f, 
    0.02174721f, -0.00993339f, -0.01632818f, 0.00566073f, 0.04859162f, -0.00940235f, -0.01374947f, -0.01999282f, 
    -0.05787347f, 0.01163618f, -0.04578617f, 0.00008799f, -0.03876450f, 0.04452689f, -0.01540607f, -0.01126773f, 
    -0.05449458f, 0.01555640f, -0.01040533f, 0.04370295f, -0.04855133f, -0.00152135f, -0.02925748f, -0.01985654f, 
    -0.02845810f, -0.03026736f, 0.01511966f, 0.01227484f, -0.05661647f, -0.02190526f, -0.03647397f, 0.03745697f, 
    0.00971704f, 0.00634481f, -0.03939432f, -0.04406480f, -0.05482421f, -0.03152047f, 0.02977904f, 0.01200578f, 
    -0.05449960f, -0.02731287f, 0.02837151f, 0.03574177f, 0.04273703f, -0.04679681f, -0.01830124f, -0.01174309f, 
    0.03629574f, -0.04881372f, 0.00116643f, -0.03945071f, -0.00450275f, -0.05340743f, -0.04414336f, -0.01623661f, 
    0.01586451f, -0.03265139f, -0.01359491f, -0.00696595f, 0.01125559f, -0.02733052f, 0.00964053f, 0.01458204f, 
    -0.02413536f, 0.02470276f, 0.01357323f, 0.00730698f, -0.00264580f, -0.04296999f, 0.00993762f, 0.03422533f, 
    0.02579118f, 0.01403426f, -0.04808624f, 0.03628078f, 0.00711517f, 0.01723525f, -0.04549347f, -0.03956455f, 
    -0.03324083f, 0.01597717f, 0.00529275f, -0.02405927f, -0.02843654f, 0.00304195f, -0.01447384f, -0.04576836f, 
    -0.00893158f, 0.00122984f, -0.05143412f, -0.04327538f, -0.03839254f, -0.04249797f, -0.03695608f, -0.00221198f, 
    0.04002549f, -0.01581814f, 0.02606219f, 0.02742402f, 0.00676807f, -0.00241591f, 0.01613137f, 0.01372852f, 
    0.01396970f, -0.05226691f, -0.03973704f, -0.00346528f, -0.05113885f, 0.03393069f, 0.00576585f, 0.00389749f, 
    -0.03676811f, -0.02981763f, -0.00819443f, 0.02589254f, -0.05156663f, 0.00997287f, -0.04952256f, 0.01904250f, 
    0.05342708f, 0.03682022f, -0.01653087f, -0.04417032f, -0.02311429f, -0.03820987f, -0.02161807f, -0.03692301f, 
    0.00399331f, -0.01022968f, 0.01947452f, 0.00371364f, -0.05291201f, -0.02988172f, -0.04355211f, -0.02561008f, 
    0.03093071f, -0.01493008f, -0.04975459f, -0.05578051f, 0.02037791f, 0.02774787f, -0.02301480f, 0.01600800f, 
    -0.01420384f, -0.00584932f, 0.00971935f, 0.04052564f, 0.00475175f, -0.01565685f, 0.02823344f, -0.01735317f, 
    -0.04599660f, 0.02002993f, 0.03402103f, -0.00943077f, 0.04288279f, -0.03954340f, -0.01904432f, 0.00428535f, 
    0.01815628f, 0.04917726f, 0.02345641f, -0.05161964f, -0.03039690f, 0.02120681f, -0.01747135f, 0.01254350f, 
    -0.01168374f, 0.01533818f, -0.05460957f, -0.01126185f, 0.02891391f, 0.00552004f, 0.01830544f, 0.01741316f, 
    0.00682614f, -0.05346873f, 0.00841557f, -0.01388390f, 0.03959516f, 0.01048438f, -0.03104444f, -0.02324512f, 
    -0.05017363f, 0.01807818f, 0.01544346f, 0.00151344f, 0.00117527f, 0.04087503f, -0.03741092f, 0.03892965f, 
    -0.00675446f, -0.01819684f, 0.04263984f, -0.02799419f, -0.00813059f, 0.01198832f, -0.03603591f, 0.03980619f, 
    -0.05845036f, -0.03169132f, -0.04741814f, -0.02608380f, 0.02459518f, -0.04179142f, -0.04614031f, 0.04445403f, 
    0.02013702f, 0.01908660f, 0.00613433f, -0.00832653f, -0.01576377f, -0.04366185f, -0.05054912f, 0.02479946f, 
    -0.04436976f, -0.05688256f, 0.00529398f, -0.02811747f, 0.05150716f, -0.01611958f, -0.02986723f, -0.02389354f, 
    -0.03640890f, 0.03886005f, 0.00183850f, -0.02944929f, 0.03558100f, -0.02632361f, 0.00509583f, 0.03494503f, 
    -0.00512739f, -0.03164483f, 0.04629999f, -0.02952266f, -0.04843479f, -0.02856150f, -0.03839803f, 0.02574152f, 
    -0.01963446f, 0.02076437f, -0.03832573f, 0.04671817f, 0.00879799f, -0.01218721f, -0.03439901f, 0.04034093f, 
    0.00774093f, -0.03354928f, -0.04971528f, 0.03502684f, 0.04348606f, -0.01237736f, -0.03954544f, 0.04531228f, 
    0.00003800f, -0.05476392f, -0.02180742f, -0.03263937f, -0.02232212f, 0.00376140f, -0.04622670f, -0.01417940f, 
    -0.00251427f, 0.00251708f, -0.03039189f, 0.03842612f, -0.00788121f, 0.01332805f, 0.01351894f, 0.01837348f, 
    -0.03755224f, 0.04039795f, 0.00664545f, -0.00812719f, -0.05634763f, 0.02987291f, -0.00974653f, -0.01321977f, 
    0.00992320f, 0.00506100f, -0.02906678f, 0.01612838f, 0.00507735f, 0.00020201f, -0.03191877f, -0.02720377f, 
    -0.04544738f, -0.04161155f, 0.03712691f, -0.04793163f, -0.03690951f, 0.01710664f, -0.05787251f, -0.02662707f, 
    -0.00539342f, -0.00505564f, 0.03195661f, 0.04208310f, 0.04460775f, -0.04232006f, -0.06234176f, -0.00629373f, 
    -0.00160712f, -0.02994962f, -0.04892094f, -0.05640785f, 0.01589573f, -0.02793244f, 0.00646393f, -0.05708374f, 
    -0.05595369f, 0.02571041f, -0.04905561f, -0.02746104f, -0.05934972f, -0.03601766f, 0.00784919f, -0.01686293f, 
    -0.04423063f, 0.03347562f, -0.03206396f, -0.04938426f, 0.03395990f, -0.01772764f, -0.03992882f, -0.04267083f, 
    -0.04109664f, 0.02209254f, -0.04827017f, 0.01328134f, 0.01198165f, -0.03393533f, -0.00770167f, -0.00056521f, 
    -0.03451091f, 0.02298384f, 0.03211848f, -0.00628489f, 0.01618578f, -0.04965305f, 0.01168250f, -0.05365545f, 
    -0.02403022f, -0.01828055f, 0.01503482f, 0.02683183f, -0.05270992f, -0.05666285f, 0.01498108f, -0.04508470f, 
    -0.01707771f, -0.00121923f, 0.02590166f, 0.03355019f, -0.04948389f, 0.00349828f, -0.02964430f, -0.04658360f, 
    -0.02465669f, -0.03935104f, 0.03697715f, -0.03857344f, -0.03638653f, -0.05898900f, 0.02067014f, -0.03433001f, 
    -0.05004509f, 0.03922993f, 0.04351066f, -0.04625616f, 0.00193583f, -0.01657567f, 0.03639384f, -0.01919361f, 
    -0.02647131f, 0.02212128f, -0.04563661f, 0.02907942f, -0.04692042f, -0.00218901f, 0.01743198f, -0.01544114f, 
    0.01186049f, 0.02522806f, -0.01209029f, 0.01055536f, 0.02627286f, 0.02086825f, -0.00467494f, 0.02902844f, 
    -0.00447708f, 0.00172887f, 0.03617670f, 0.03245394f, -0.01887307f, -0.03944032f, -0.00550785f, 0.04009048f, 
    -0.04628875f, -0.03016569f, 0.03214489f, -0.04131660f, 0.00937619f, -0.03781119f, -0.03025494f, 0.03607084f, 
    -0.04761110f, -0.02600412f, -0.00188543f, -0.02417675f, -0.05139747f, 0.02384712f, 0.01608920f, 0.03262373f, 
    0.02011243f, -0.03601275f, -0.00662706f, 0.01291770f, -0.03384101f, 0.03423239f, -0.04624458f, -0.01662639f, 
    0.04516739f, 0.02023480f, -0.02418444f, 0.02774539f, -0.05278599f, -0.04236398f, 0.02989853f, 0.01889543f, 
    -0.00289667f, -0.02565861f, 0.00245430f, 0.00626084f, -0.01425529f, -0.01614761f, 0.03976697f, 0.00656002f, 
    -0.03407386f, 0.02812054f, 0.02395281f, 0.02560752f, -0.04437156f, 0.04070238f, 0.01373114f, 0.00499073f, 
    0.01496766f, -0.01354345f, -0.04739939f, -0.00246589f, 0.01205842f, -0.03866163f, -0.04916701f, 0.03819990f, 
    -0.03206110f, -0.01033327f, 0.00797678f, -0.04230750f, 0.02153827f, 0.04342707f, -0.01358663f, 0.01396569f, 
    -0.04715691f, 0.01073058f, -0.00885049f, -0.01300554f, 0.02433169f, 0.02490418f, 0.03809135f, -0.03429456f, 
    -0.01641862f, 0.00031290f, -0.04067217f, -0.01593903f, 0.02362621f, 0.01074263f, -0.02675411f, -0.00250778f, 
    -0.04175136f, -0.03387596f, 0.00443788f, -0.01091059f, -0.00222982f, 0.00631289f, -0.04090523f, -0.05050871f, 
    0.04273892f, -0.01748377f, 0.02389143f, -0.05452043f, -0.03606715f, -0.04361371f, 0.01530034f, -0.00300253f, 
    -0.00289725f, -0.01014765f, 0.02794014f, -0.04208455f, -0.00922651f, 0.00081852f, 0.02084080f, 0.04180354f, 
    -0.04002798f, -0.00410536f, -0.00374007f, -0.03808174f, -0.05456429f, 0.00913910f, -0.01553501f, -0.04650223f, 
    -0.01937129f, 0.03394999f, 0.02055175f, -0.01091687f, -0.03074783f, -0.01543435f, -0.05320075f, 0.00566603f, 
    0.02553389f, -0.00945208f, -0.02228365f, -0.00342563f, -0.03441207f, -0.03581034f, 0.02027608f, 0.04466652f, 
    -0.04437069f, -0.03114394f, 0.00093886f, 0.03035503f, 0.00999946f, -0.02408962f, -0.04246506f, -0.02081430f, 
    0.02520937f, -0.00004555f, -0.05068009f, 0.00417907f, 0.02684374f, -0.04678740f, 0.03447979f, -0.02176302f, 
    0.03834857f, -0.01493746f, 0.03534809f, 0.03441821f, -0.01543950f, -0.00712630f, -0.04431691f, -0.00389070f, 
    0.01138486f, -0.03166614f, -0.05077946f, -0.02286166f, -0.05114150f, -0.03332439f, -0.05571307f, -0.02086956f, 
    -0.05012043f, -0.02067576f, -0.04643041f, 0.02379899f, 0.00375633f, -0.01809704f, -0.05488953f, -0.00529180f, 
    -0.04383202f, 0.03214081f, -0.01740518f, -0.00650963f, -0.04725396f, 0.04559623f, 0.03505003f, 0.02665585f, 
    -0.02210301f, 0.03966359f, 0.00721246f, 0.01168539f, -0.02055560f, -0.00510103f, 0.03233597f, -0.02625410f, 
    0.03310593f, 0.03973812f, 0.03870083f, 0.02823045f, -0.02616031f, 0.04211882f, 0.02917822f, -0.01580316f, 
    -0.03740174f, -0.02751199f, -0.02732652f, -0.04901394f, 0.02279013f, -0.02137087f, -0.01700759f, 0.01246328f, 
    0.02557249f, -0.03954655f, -0.02928848f, -0.04944228f, -0.02641982f, -0.05333545f, -0.02778096f, -0.00576237f, 
    -0.00587795f, -0.00076638f, -0.00544519f, -0.05464909f, -0.00201021f, 0.00115442f, -0.02869636f, 0.03086477f, 
    0.02485591f, -0.05038498f, -0.00564379f, -0.00446326f, -0.05491715f, -0.00892214f, -0.04941417f, 0.02131160f, 
    0.03935976f, 0.00940373f, -0.01693918f, -0.04041415f, -0.04827402f, -0.00618550f, -0.02260432f, -0.03514671f, 
    0.00376217f, 0.01423873f, 0.01480263f, -0.01906251f, -0.03450904f, -0.00628165f, -0.02709108f, 0.00251046f, 
    0.00525228f, -0.04871974f, -0.04251122f, 0.00354352f, 0.02333248f, -0.02425272f, -0.05157220f, -0.04173022f, 
    -0.05003169f, -0.01692621f, 0.02726727f, -0.02211515f, -0.02300883f, 0.03552645f, -0.01574654f, -0.04205875f, 
    0.00293239f, -0.04324504f, -0.04518776f, 0.02246378f, 0.00030131f, -0.00886511f, -0.03990727f, 0.02281220f, 
    0.01780252f, 0.02378490f, 0.02502657f, -0.04103863f, -0.00426611f, -0.02804681f, 0.00687290f, 0.02995330f, 
    0.00846717f, -0.04599319f, -0.04193071f, -0.00884101f, 0.01818888f, 0.04339331f, -0.02385494f, 0.00633717f, 
    0.04728606f, -0.04568589f, -0.04374658f, -0.00656857f, -0.03433984f, -0.03160081f, -0.04515803f, 0.01656045f, 
    0.00965381f, -0.01855597f, -0.04708185f, -0.01394516f, 0.03407833f, -0.00798311f, 0.00227465f, -0.05532099f, 
    0.02260614f, -0.03540922f, 0.01044050f, -0.00272528f, -0.00555935f, -0.02426691f, -0.02124024f, 0.00292563f, 
    0.03869069f, -0.02507007f, 0.00421302f, 0.03892427f, -0.03853393f, 0.03367691f, -0.01237989f, -0.03369403f, 
    -0.00760409f, -0.05153965f, 0.02747932f, 0.01953843f, -0.04807498f, 0.00198989f, 0.03813260f, -0.01880487f, 
    -0.01610722f, 0.00966117f, -0.02885599f, -0.02274093f, -0.03573810f, -0.05294101f, 0.04487192f, 0.03316997f, 
    -0.00227687f, 0.01028250f, 0.02654579f, -0.00957960f, 0.01054926f, 0.01379710f, -0.01690495f, 0.03748952f, 
    -0.01899415f, 0.02065548f, -0.00878430f, 0.02436145f, -0.00194020f, -0.05063299f, -0.05510825f, -0.02270249f, 
    0.00804382f, -0.03693579f, 0.00826834f, -0.03548050f, -0.02971993f, 0.03895421f, 0.00106917f, 0.03095426f, 
    -0.16747142f, 0.05118149f, 0.24122845f, 0.09721365f, -0.06876722f, 0.00476537f, 0.07014383f, -0.03145666f, 
    -0.06697881f, 0.00430916f, 0.00249316f, 0.06591424f, 0.16357669f, 0.02526634f, -0.09208684f, -0.13401826f, 
    0.01312083f, 0.04247030f, 0.02013825f, 0.07829484f, -0.05685198f, 0.01542040f, 0.00701581f, -0.02297979f, 
    0.02775599f, 0.05645712f, 0.01295794f, -0.03789281f, -0.03619115f, 0.05294167f, 0.08743626f, -0.13310146f, 
    0.02420367f, 0.01426730f, 0.04103481f, 0.01836617f, -0.15823664f, 0.13576815f, -0.11924525f, 0.12012699f, 
    0.14174332f, 0.03761207f, -0.02941727f, -0.07931289f, -0.07094534f, -0.01137016f, -0.03925044f, -0.09015258f, 
    -0.32871187f, 0.21988817f, 0.06703889f, -0.11835855f, 0.03249266f, 0.05137646f, 0.02289579f, -0.04287594f, 
    -0.09746093f, 0.01271575f, 0.00466725f, 0.01613356f, -0.31003165f, -0.18546624f, 0.06165885f, 0.08432545f, 
    -0.04750650f, -0.00136115f, -0.06614888f, -0.01694471f, 0.06056149f, 0.06684545f, 0.02043508f, 0.08274682f, 
    0.06830900f, -0.02416190f, 0.12679866f, -0.07082488f, 0.09751593f, -0.03147263f, -0.08273449f, 0.06710763f, 
    0.03895150f, 0.03916175f, 0.04467587f, -0.03723845f, 0.26389641f, 0.06511419f, -0.02571357f, -0.20343179f, 
    -0.03950634f, 0.05762139f, -0.01055546f, 0.04813651f, -0.06866338f, 0.00498675f, 0.05947384f, 0.02115847f, 
    0.11281332f, -0.07461186f, -0.25416464f, 0.18374087f, 0.10495301f, 0.09905457f, 0.07570872f, -0.11751312f, 
    0.02202151f, 0.09041404f, -0.09897149f, -0.10744657f, 0.12556668f, 0.06954428f, -0.20030567f, 0.05505710f, 
    0.02334477f, 0.01368698f, 0.05962176f, 0.07327619f, 0.06809046f, 0.05643177f, -0.07188189f, -0.01307744f, 
    -0.17145012f, 0.05961197f, -0.08643799f, 0.22540618f, 0.14419663f, 0.07922999f, 0.07145412f, -0.00119068f, 
    -0.02868082f, 0.02429152f, 0.03943823f, 0.09877880f, -0.05398909f, -0.16269340f, -0.08142701f, 0.01786384f, 
    0.15211856f, 0.08451457f, 0.04174082f, 0.01280533f, 0.14177123f, 0.05850780f, -0.03566075f, 0.03175391f, 
    -0.06005059f, 0.18909806f, -0.02231359f, -0.12477180f, -0.01550845f, 0.07660633f, 0.07864604f, 0.04031707f, 
    -0.00106891f, 0.02749955f, 0.12596126f, 0.09616489f, 0.30468807f, 0.10100135f, 0.25396433f, 0.02565659f, 
    -0.02341776f, -0.00829206f, 0.00066816f, 0.02016804f, 0.10331929f, -0.00638495f, 0.00271887f, 0.00248514f, 
    0.08501481f, 0.19781309f, 0.15043558f, -0.01174192f, 0.01019575f, 0.08809871f, -0.01028772f, -0.09499072f, 
    0.07597628f, -0.01971110f, -0.09662227f, 0.12123494f, -0.29203719f, -0.21268411f, -0.09062983f, 0.25636047f, 
    0.04484442f, 0.05964404f, 0.02378616f, 0.04326461f, -0.04365750f, 0.01296722f, -0.09326839f, 0.05361829f, 
    0.27616122f, 0.01315564f, -0.00041073f, -0.04085761f, 0.01191512f, 0.10068861f, 0.05003086f, 0.04948124f, 
    0.04324083f, -0.01804051f, 0.06987678f, -0.08316775f, 0.14688328f, 0.15541202f, 0.14244306f, -0.10249367f, 
    0.02345307f, 0.05584427f, 0.09128758f, -0.01663890f, -0.00698150f, -0.06927654f, 0.07189927f, 0.04079461f, 
    0.20883638f, -0.28608206f, -0.12421442f, -0.06868149f, 0.12214765f, 0.02301302f, -0.00130501f, 0.18068376f, 
    0.03394186f, -0.01564174f, -0.02171276f, -0.03479946f, -0.01312858f, 0.14634702f, 0.05779090f, -0.12381718f, 
    0.07587098f, 0.14939909f, -0.04840329f, 0.07325754f, 0.10822510f, -0.02224148f, 0.05089942f, -0.04286540f, 
    0.18128340f, -0.07396357f, 0.25992832f, -0.00296053f, 0.11020095f, -0.08416702f, 0.12209354f, -0.01555068f, 
    -0.04284828f, 0.03183378f, 0.01787810f, -0.01647671f, -0.24981190f, 0.10535914f, 0.10474601f, -0.23262182f, 
    0.07255008f, -0.06321830f, -0.07214975f, 0.10202564f, 0.02656027f, -0.06570134f, -0.01870182f, 0.04346702f, 
    -0.06417746f, 0.14019701f, 0.04226763f, -0.33101976f, 0.17609085f, 0.00835409f, -0.09670866f, -0.06073820f, 
    -0.06094101f, 0.06448759f, -0.01511231f, 0.06852359f, 0.33769313f, 0.19828008f, 0.19434914f, -0.07564932f, 
    -0.12336335f, 0.09108980f, 0.12362790f, -0.01597708f, 0.10331661f, 0.01655587f, 0.01605227f, 0.03608445f, 
    0.22364855f, 0.06923389f, 0.03683348f, -0.07711413f, -0.07647582f, -0.08955561f, 0.06518374f, 0.03678634f, 
    0.01838845f, 0.06123156f, 0.00297390f, -0.02109820f, 0.12849015f, 0.19242331f, -0.00398530f, -0.05380544f, 
    0.11904494f, 0.01063617f, -0.03998953f, -0.01581082f, 0.05658198f, -0.02184013f, 0.01477255f, 0.04055056f, 
    0.01710784f, -0.42860338f, 0.04530555f, 0.13513607f, 0.01680528f, -0.01469116f, 0.05797045f, -0.01044688f, 
    -0.01423664f, 0.03061027f, 0.14534038f, 0.12890369f, -0.15409055f, -0.00840947f, 0.09551658f, 0.04986736f, 
    0.02438307f, 0.06561210f, -0.05136776f, 0.02482639f, -0.06026930f, 0.07124183f, 0.03006688f, 0.03618085f, 
    0.10639007f, -0.07599533f, -0.13082120f, 0.00019144f, 0.02977852f, 0.17657235f, 0.17442212f, 0.11500299f, 
    0.05160736f, -0.01066407f, -0.01256201f, -0.03293576f, -0.40405798f, -0.40565425f, -0.11226723f, 0.06054815f, 
    0.09300382f, -0.04591060f, 0.07549373f, 0.00875241f, 0.02822878f, -0.02981411f, 0.01637893f, -0.01050358f, 
    0.06660767f, 0.07465188f, -0.01821447f, -0.08599671f, -0.03536389f, 0.01616355f, 0.05924215f, 0.03891163f, 
    -0.05994637f, 0.00219038f, -0.00719921f, 0.09180187f, -0.04734570f, 0.01516560f, 0.10063806f, -0.00555100f, 
    0.08129841f, -0.01557180f, -0.09831576f, -0.07224774f, -0.14033121f, 0.09627477f, 0.08262618f, -0.02423007f, 
    0.03636616f, -0.07613343f, 0.03273080f, -0.00193197f, 0.05116810f, -0.02718717f, 0.02714748f, -0.02966891f, 
    -0.03463336f, 0.03065611f, 0.00487141f, 0.02303313f, 0.00512833f, 0.00470239f, 0.00154253f, 0.02628776f, 
    0.04121740f, -0.02596482f, 0.00917349f, -0.05199797f, -0.00059339f, -0.02921215f, 0.02606314f, -0.01952512f, 
    0.00693407f, -0.02322551f, -0.07426216f, -0.05675019f, -0.00598669f, -0.00843826f, -0.03032101f, -0.03100142f, 
    0.00121975f, 0.05102810f, -0.03374963f, 0.01960343f, -0.02796834f, -0.01992066f, -0.03927901f, -0.00185220f, 
    0.05504033f, 0.01036524f, -0.05715188f, 0.04123765f, -0.06077303f, 0.00064096f, 0.02160574f, -0.02736237f, 
    0.07232642f, 0.01665299f, -0.04491423f, -0.01881861f, -0.00270894f, 0.03593031f, -0.04372157f, 0.02846077f, 
    0.01757186f, 0.04995259f, -0.01963489f, -0.00865347f, 0.04850433f, -0.03582640f, -0.00442985f, 0.04618597f, 
    -0.00587004f, 0.03738327f, -0.02607914f, -0.01856421f, -0.02860807f, -0.00189900f, 0.00795988f, -0.06258625f, 
    0.02150520f, -0.04331038f, -0.03365578f, -0.05776625f, 0.00783510f, -0.01916971f, -0.01027157f, -0.00747064f, 
    -0.06123647f, -0.00403397f, -0.01400436f, -0.01383370f, 0.00684115f, -0.02240400f, 0.00513718f, 0.03592489f, 
    0.01538714f, -0.07155814f, 0.00395895f, -0.04499224f, 0.00218404f, -0.06283082f, 0.00168174f, 0.05076843f, 
    -0.03562785f, 0.00407355f, 0.01024909f, 0.06458566f, 0.01320409f, -0.05910911f, -0.01944629f, -0.04222539f, 
    -0.03880338f, -0.06160516f, 0.04643662f, 0.00896292f, 0.01922305f, -0.04097336f, 0.00342451f, 0.04806912f, 
    0.03013824f, 0.00101025f, 0.05873568f, -0.05083821f, 0.02043555f, 0.00929588f, 0.00246574f, -0.03631166f, 
    0.04168184f, 0.02602891f, -0.03334345f, -0.00007190f, -0.00576582f, -0.01304575f, 0.02043412f, -0.05917245f, 
    -0.04810870f, -0.01412415f, -0.00061900f, 0.00814586f, -0.01048599f, -0.06887002f, -0.08785304f, -0.04260659f, 
    0.03838734f, 0.00835167f, 0.04133677f, 0.02983593f, 0.02697861f, 0.04053568f, -0.01360073f, 0.00580957f, 
    0.04318330f, -0.03599898f, -0.06458816f, 0.00961153f, -0.05878354f, -0.03692082f, -0.07616707f, -0.04211142f, 
    -0.00626177f, 0.02611596f, -0.02073038f, 0.03784421f, 0.02829619f, -0.03573514f, -0.05845656f, -0.03453907f, 
    -0.03560588f, 0.04137782f, -0.03914564f, -0.00607585f, 0.01935551f, -0.04570478f, -0.01096231f, -0.07177456f, 
    0.02312357f, -0.04677985f, -0.04995722f, -0.03357010f, 0.01899499f, -0.00638788f, -0.00829492f, 0.00440472f, 
    0.02456745f, 0.05267987f, 0.03671816f, -0.00418590f, 0.00952593f, -0.00554754f, 0.03359146f, -0.02308080f, 
    -0.01751682f, 0.00988549f, 0.00057407f, -0.01498531f, -0.02238464f, 0.00823387f, -0.05486792f, -0.05056689f, 
    -0.04164783f, -0.00228295f, -0.05138760f, -0.01582232f, -0.04495494f, -0.00988191f, 0.01767646f, 0.05613450f, 
    -0.01150303f, -0.02525523f, -0.02357707f, 0.00042699f, 0.01607595f, -0.05471007f, -0.02273698f, -0.01257959f, 
    -0.05233871f, 0.00290900f, -0.03458301f, -0.02577872f, -0.05037826f, 0.02984641f, -0.04454486f, -0.06123516f, 
    -0.04028034f, 0.02259478f, 0.00521175f, -0.01136536f, -0.03574810f, -0.07333525f, 0.00126045f, 0.04905980f, 
    -0.01584308f, -0.03721087f, -0.00214396f, -0.00527072f, -0.03397212f, 0.00049873f, -0.04184610f, -0.04918915f, 
    -0.05556025f, 0.01536636f, -0.00270987f, 0.00188169f, 0.00227205f, 0.01394249f, -0.03856568f, 0.05660177f, 
    0.00567353f, -0.02306025f, -0.05188916f, -0.05412798f, 0.01274231f, -0.00082949f, -0.03868959f, -0.04909955f, 
    0.04621058f, 0.00306351f, 0.03266693f, -0.04333757f, 0.03921866f, -0.06460563f, 0.02018050f, 0.04383358f, 
    0.03281468f, -0.05875636f, -0.05984123f, -0.07639774f, -0.04310242f, -0.01351083f, -0.04161930f, -0.04373593f, 
    0.05356985f, -0.01770462f, -0.01957260f, 0.03162543f, -0.01267196f, 0.00606738f, -0.00624715f, -0.02625935f, 
    0.01061750f, 0.00419955f, -0.01026955f, 0.04738015f, 0.00392110f, 0.00307368f, -0.05559408f, -0.06058286f, 
    -0.01529611f, -0.01500819f, -0.02319084f, -0.03883401f, -0.05128599f, 0.02493519f, 0.00242779f, 0.01189362f, 
    -0.04508846f, 0.00986332f, -0.02986592f, 0.01544204f, -0.01437251f, -0.02859646f, 0.02189558f, -0.04952878f, 
    0.02565683f, 0.00952210f, -0.03268800f, -0.03750818f, -0.06786808f, 0.01488871f, -0.06392869f, 0.01327705f, 
    -0.02095571f, 0.03479790f, 0.02172759f, -0.03027616f, 0.00234689f, 0.04414324f, 0.00210014f, 0.00035383f, 
    -0.01971476f, 0.07006816f, -0.03231091f, 0.00897098f, 0.01396884f, 0.01544356f, -0.02882744f, 0.05093886f, 
    -0.04248551f, 0.03920957f, -0.00109396f, 0.03164218f, 0.00780276f, 0.00694279f, -0.00965657f, -0.00424020f, 
    0.02902497f, 0.00017601f, -0.00258655f, 0.00847978f, -0.05838080f, -0.03656211f, 0.00577573f, -0.04433895f, 
    0.00046733f, 0.04193547f, 0.02222762f, 0.04065611f, -0.03350405f, -0.04408552f, -0.05217235f, -0.04977682f, 
    -0.02524229f, -0.01259125f, 0.01807844f, -0.01029682f, -0.03668521f, 0.06572005f, 0.03349262f, -0.01040755f, 
    0.04916816f, 0.00153248f, -0.06129431f, 0.01433343f, 0.02219092f, 0.03881535f, 0.02624658f, 0.03561162f, 
    -0.02563048f, 0.01138898f, -0.03052095f, -0.06736389f, -0.03465519f, -0.00541583f, -0.00414188f, -0.05366876f, 
    -0.01209434f, 0.02677365f, 0.03254573f, -0.05355385f, 0.00925103f, -0.04326919f, -0.00560310f, -0.02947068f, 
    -0.02536468f, 0.00794964f, -0.06259492f, -0.04599178f, -0.00335266f, -0.01936384f, -0.04054664f, -0.01118724f, 
    0.01358973f, -0.00866675f, 0.03452248f, 0.04262639f, 0.00903040f, -0.04501722f, -0.01628803f, -0.01037329f, 
    -0.05521425f, -0.05673173f, -0.00882688f, -0.05039544f, 0.00547321f, -0.00468379f, 0.01777869f, -0.03774793f, 
    -0.01190558f, -0.04792408f, -0.01350290f, -0.01806897f, -0.04624569f, 0.01807074f, -0.00952749f, 0.03090564f, 
    0.02882193f, 0.01997964f, -0.04885784f, -0.04491462f, -0.04108179f, 0.00417958f, -0.03874358f, 0.02294217f, 
    0.03160641f, -0.01328697f, 0.00407447f, -0.01244422f, 0.03237229f, -0.02971725f, -0.00888493f, 0.01543825f, 
    -0.04251326f, -0.05269510f, -0.04445594f, 0.00410120f, -0.04397998f, -0.03191098f, 0.01245565f, -0.00255829f, 
    0.04303512f, 0.01900492f, 0.03442714f, -0.02354392f, -0.04323583f, -0.01368792f, -0.00486380f, -0.01208851f, 
    -0.02294757f, 0.02811523f, -0.03736029f, 0.01943395f, 0.03323435f, -0.02788916f, 0.00713500f, 0.00167787f, 
    -0.03211898f, 0.00769116f, -0.03134005f, -0.04056826f, 0.00525439f, -0.05557027f, -0.00709460f, 0.02889968f, 
    -0.03805154f, 0.01518848f, 0.03566006f, -0.05373304f, 0.04604686f, 0.01569596f, 0.02575986f, 0.02543318f, 
    0.01602457f, -0.04832352f, -0.04819894f, -0.03158662f, 0.00666350f, -0.00818225f, 0.00327332f, 0.02129014f, 
    -0.00184063f, 0.02893687f, -0.02109415f, -0.02505857f, -0.02645660f, 0.00819356f, -0.02664274f, -0.02922820f, 
    0.04497656f, -0.02029336f, -0.04127792f, -0.03889149f, -0.02425353f, -0.02623248f, 0.00442189f, 0.03825550f, 
    -0.02446559f, 0.02529785f, 0.01350720f, 0.02229349f, -0.01844788f, 0.00410487f, 0.02362512f, 0.03879701f, 
    -0.03928611f, -0.03271593f, -0.04984207f, 0.01737671f, -0.00496383f, -0.00880903f, -0.00483126f, 0.00780588f, 
    0.04791872f, -0.04043625f, -0.02561013f, -0.02083678f, 0.03795307f, -0.03160524f, 0.02026593f, 0.04248263f, 
    0.01777880f, 0.04342246f, 0.01017281f, 0.04441671f, 0.04775874f, -0.05062994f, -0.04364943f, -0.04182361f, 
    0.03809332f, 0.02136112f, -0.03964128f, -0.04642254f, -0.04383847f, -0.02341701f, 0.03791422f, 0.04324432f, 
    0.04117057f, 0.03763331f, 0.02725128f, -0.03781752f, 0.02937474f, -0.03878347f, -0.04614816f, -0.00950086f, 
    -0.04934392f, -0.02314048f, -0.04742333f, 0.03477233f, -0.03916465f, -0.02823658f, -0.05651296f, -0.01030095f, 
    -0.03640570f, -0.03110724f, -0.00377097f, 0.00903879f, -0.00356421f, -0.02628794f, -0.02324420f, -0.04439540f, 
    -0.02131719f, -0.03319482f, 0.04343345f, 0.02379748f, -0.03002469f, 0.02318457f, -0.02138650f, -0.03352931f, 
    -0.03273647f, -0.04785650f, -0.04370046f, -0.04111275f, 0.01100185f, 0.01881095f, 0.03092712f, 0.04541356f, 
    0.01820458f, 0.00865312f, -0.00865148f, -0.02065366f, -0.03580191f, -0.02410112f, -0.03700223f, -0.05359687f, 
    -0.00676084f, 0.00524329f, 0.02697649f, -0.02849487f, 0.00723073f, -0.01532603f, 0.00571486f, -0.00749073f, 
    0.03173655f, -0.01173526f, -0.01222190f, 0.02664068f, 0.04629973f, 0.02387007f, 0.00273324f, -0.02689129f, 
    0.00520316f, -0.01605684f, -0.04993924f, -0.05537941f, 0.01424563f, -0.00891568f, -0.02287132f, -0.01647560f, 
    0.01175492f, -0.03163982f, 0.03764055f, 0.01309528f, -0.04413620f, -0.02553633f, -0.04054132f, -0.01927746f, 
    0.01434277f, 0.02016860f, -0.03103636f, -0.05206433f, 0.04522127f, -0.05210771f, -0.00366763f, -0.02962283f, 
    0.02905487f, -0.05135445f, -0.00812862f, -0.01148628f, 0.03358264f, 0.04016069f, 0.03292174f, -0.04373842f, 
    0.01826251f, -0.02596675f, 0.03585316f, 0.03836810f, -0.02165651f, -0.04941950f, -0.01666323f, -0.00928546f, 
    0.00247332f, 0.02075505f, -0.02502174f, -0.03444247f, -0.00293360f, -0.00803021f, -0.05244772f, -0.05266029f, 
    -0.02794416f, 0.00703367f, -0.03076616f, -0.04245266f, -0.00372532f, 0.02895889f, 0.03417991f, -0.04280832f, 
    -0.01511647f, -0.00450152f, 0.04313488f, -0.03209031f, 0.03051019f, -0.02374248f, 0.00953338f, 0.04426835f, 
    0.02480506f, 0.04634036f, 0.00980076f, -0.00258119f, 0.03167293f, -0.04913572f, -0.03427465f, -0.01627019f, 
    -0.04761492f, 0.03412162f, 0.01210824f, 0.00905117f, -0.00294159f, -0.04505501f, 0.04060639f, 0.02831617f, 
    -0.01623223f, -0.01202328f, -0.03400446f, -0.03890677f, -0.02882501f, -0.01540968f, 0.01899103f, -0.02243838f, 
    0.00482804f, 0.02774377f, -0.05330320f, -0.05220384f, -0.02507412f, -0.01893184f, 0.01041147f, 0.01891037f, 
    -0.01148374f, 0.02111099f, -0.05397886f, 0.02093259f, 0.03656274f, -0.00817569f, 0.04366066f, 0.01940797f, 
    0.02866919f, -0.04173491f, 0.00898906f, 0.00804496f, -0.01166847f, 0.01832715f, 0.00484080f, -0.01316161f, 
    -0.04769622f, 0.03593830f, -0.03008560f, -0.00841336f, -0.00941690f, -0.04602158f, -0.00699589f, 0.03423538f, 
    0.03843572f, -0.05453274f, 0.03932089f, -0.04397816f, -0.03552423f, 0.02302292f, 0.02562653f, 0.03010020f, 
    -0.03849482f, -0.01379395f, -0.04941894f, 0.03315296f, 0.03745515f, -0.05393551f, 0.04751534f, -0.05202587f, 
    0.03608451f, 0.03860445f, 0.01256820f, 0.02250779f, 0.00209832f, 0.00080252f, -0.04490046f, 0.02698223f, 
    0.01813012f, -0.03997190f, 0.03039685f, 0.01841689f, 0.01817602f, -0.03023993f, -0.04504056f, -0.04234777f, 
    -0.04894969f, -0.04571050f, 0.03890988f, -0.02653565f, -0.05757384f, 0.04247087f, -0.05564300f, -0.00392955f, 
    -0.03249960f, -0.04324164f, 0.02136101f, -0.03442783f, 0.03368131f, -0.04037696f, 0.01418166f, -0.03758233f, 
    0.04529587f, 0.04171592f, -0.00613595f, 0.03017237f, -0.02143549f, 0.02541375f, -0.04342002f, 0.04117664f, 
    0.30914828f, -0.00099574f, -0.01290621f, 0.05870093f, 0.05809499f, -0.03069463f, 0.15116999f, 0.10998825f, 
    0.14720073f, 0.02972651f, 0.03032492f, 0.06384029f, 0.32903856f, -0.01981295f, 0.01357198f, 0.23936887f, 
    0.05921432f, -0.08682673f, 0.03164316f, -0.08696035f, 0.01169837f, 0.02485924f, -0.01695416f, 0.13557363f, 
    -0.12283520f, 0.15143260f, 0.23959552f, -0.17712696f, 0.04433747f, 0.00543051f, -0.01707573f, 0.04170515f, 
    0.03425915f, -0.11316203f, -0.00948685f, 0.03501360f, -0.09172397f, -0.18219924f, 0.09852691f, -0.22014660f, 
    -0.12577626f, 0.08032563f, -0.10291490f, 0.08838108f, 0.16969794f, -0.02474026f, 0.10830647f, -0.02557547f, 
    -0.02504052f, -0.33313495f, 0.25065336f, 0.12730856f, 0.14933981f, -0.02469704f, 0.11166425f, -0.08353522f, 
    0.11036861f, 0.15301019f, -0.00743940f, -0.00727065f, -0.06339416f, -0.12228870f, -0.14505818f, 0.30352762f, 
    0.01489979f, 0.02292630f, -0.02873777f, 0.01187417f, -0.04463670f, -0.10794125f, 0.00154332f, -0.08639334f, 
    0.28946295f, -0.14173201f, -0.28877160f, -0.08574351f, -0.08153433f, 0.01309277f, -0.05368449f, -0.15204975f, 
    0.01805909f, 0.02386892f, 0.11317874f, -0.01026194f, 0.32016236f, 0.31721777f, -0.05745798f, 0.04405155f, 
    -0.03762203f, 0.03892523f, 0.10779940f, 0.08580819f, -0.02182743f, 0.07611836f, -0.00090588f, 0.03625583f, 
    -0.16129434f, 0.03096760f, 0.04051415f, -0.01653067f, 0.09617296f, -0.01467832f, 0.00280673f, -0.05928138f, 
    0.07799371f, 0.01675086f, -0.10060739f, -0.00334251f, -0.22653393f, 0.06282798f, 0.05142750f, -0.07271162f, 
    0.03058302f, 0.09243219f, 0.04294544f, -0.05974009f, 0.11729558f, -0.06506323f, -0.03760410f, -0.08525468f, 
    -0.12967204f, -0.14386044f, 0.06293953f, -0.25448117f, -0.03419649f, -0.01299337f, 0.03172397f, -0.07547553f, 
    0.03118056f, 0.03386758f, -0.03951107f, -0.03060253f, 0.20125052f, 0.12659684f, 0.00793859f, -0.06593900f, 
    -0.08510944f, 0.04734393f, 0.00849937f, 0.00202554f, -0.03804272f, -0.02154594f, -0.05298473f, -0.01508082f, 
    0.21909375f, 0.13707788f, -0.02299273f, -0.12296191f, -0.05255781f, 0.05237131f, -0.06622751f, 0.03370325f, 
    0.03483412f, 0.00045253f, -0.04082542f, 0.08994981f, -0.07654033f, 0.00396643f, -0.14101732f, 0.12886709f, 
    0.00885934f, -0.01919795f, 0.07946444f, -0.07813446f, -0.01881938f, 0.02869347f, 0.05593598f, -0.03219633f, 
    -0.20175776f, 0.08558396f, 0.02770890f, -0.11503300f, 0.13377213f, -0.05569175f, -0.05691537f, -0.00643163f, 
    -0.06190576f, 0.04645132f, 0.09963760f, -0.00772774f, -0.18269348f, -0.02241557f, -0.25376916f, -0.20219913f, 
    -0.06026620f, -0.05073250f, -0.06556807f, -0.08542272f, 0.05122691f, 0.02485935f, 0.08184205f, -0.05577887f, 
    -0.03487354f, 0.05943230f, 0.00167573f, 0.02177554f, -0.02441221f, 0.07594770f, 0.08263211f, 0.14750056f, 
    0.00511883f, -0.09666577f, -0.01282666f, 0.02796142f, 0.15681206f, 0.21167476f, -0.21151999f, -0.00318926f, 
    0.07387820f, -0.02521074f, 0.02601466f, 0.10654153f, -0.02302028f, 0.04024701f, 0.04929212f, 0.06395434f, 
    -0.47097057f, 0.28412709f, 0.05515561f, -0.12308028f, 0.09330264f, 0.10736112f, 0.04564606f, -0.17284276f, 
    0.11338820f, 0.11234228f, -0.03892208f, 0.01905914f, 0.03850158f, -0.15795590f, 0.14829738f, -0.06357519f, 
    0.03270206f, -0.12814383f, -0.06973974f, 0.07396241f, -0.03768153f, 0.09408530f, 0.02469985f, -0.06943472f, 
    -0.00452250f, 0.02060179f, -0.20073278f, 0.11784711f, 0.11360529f, -0.05324453f, -0.08922834f, -0.02519149f, 
    0.04424402f, 0.05835427f, -0.07281525f, 0.06808504f, 0.22058645f, -0.05568662f, 0.12861566f, 0.24415030f, 
    0.11742066f, 0.10683701f, 0.18312572f, -0.02026972f, 0.01991892f, -0.06253942f, -0.00462938f, 0.20956317f, 
    0.00319700f, -0.27450815f, 0.26640606f, 0.08233576f, -0.01935082f, -0.01861722f, -0.02545576f, -0.05344053f, 
    0.04445218f, 0.06869443f, -0.08914665f, 0.04280113f, 0.15421349f, -0.08553255f, -0.02451871f, 0.06049231f, 
    -0.03624549f, 0.04731043f, -0.00246646f, 0.13593657f, 0.01462002f, 0.02274151f, 0.05517369f, -0.02985683f, 
    -0.15298012f, 0.11166584f, -0.09686115f, 0.18883315f, -0.02051371f, 0.04162873f, -0.06215794f, -0.00421297f, 
    0.09889713f, 0.00033000f, -0.03464680f, -0.04029830f, 0.13842463f, -0.13366336f, 0.14384635f, 0.15678661f, 
    0.01973368f, 0.04462361f, 0.09723905f, 0.01525270f, -0.02718541f, 0.05958590f, 0.07220731f, -0.02440215f, 
    -0.18271562f, -0.03936787f, 0.00568237f, 0.22867668f, 0.04423224f, 0.10524596f, -0.04010319f, 0.03462060f, 
    -0.02356019f, 0.07074688f, 0.06933628f, 0.00140174f, 0.01785430f, 0.08426763f, 0.05891752f, 0.08020398f, 
    -0.00032345f, -0.01382886f, 0.04999057f, 0.09715269f, -0.02639402f, 0.07097986f, -0.07945728f, 0.00602395f, 
    0.05056367f, 0.05807748f, -0.04407240f, -0.05131088f, 0.18380335f, -0.14453149f, -0.01365199f, -0.01294333f, 
    -0.10980973f, 0.07735948f, 0.03897040f, 0.00958580f, 0.19724886f, -0.22748260f, 0.04501348f, 0.09359621f, 
    -0.13037944f, 0.17723192f, -0.07476503f, -0.05926242f, 0.01292474f, 0.08930638f, -0.03984067f, -0.00589252f, 
    0.27517527f, -0.01537571f, 0.12744993f, -0.04001715f, -0.09475855f, 0.03819936f, 0.03284097f, -0.02827428f, 
    0.00650090f, 0.13237324f, 0.03964700f, 0.02838690f, 0.19808821f, -0.13577005f, -0.02779460f, 0.08852446f, 
    0.00775354f, -0.00726158f, -0.09360632f, 0.05730304f, -0.02141498f, -0.04799075f, -0.00702258f, -0.03552010f, 
    0.15330762f, -0.10072631f, 0.04325313f, -0.21841322f, 0.05381802f, 0.02778775f, 0.08209563f, -0.00591407f, 
    -0.00675632f, 0.04320538f, -0.03468210f, -0.00433825f, -0.32040367f, 0.25447863f, 0.11762986f, 0.02492206f, 
    0.08378431f, 0.09074486f, 0.01140265f, -0.00034087f, 0.08589526f, 0.02162428f, 0.04304208f, -0.02953523f, 
    -0.04318377f, 0.00886469f, -0.22667103f, 0.12376945f, 0.08389707f, 0.04291369f, -0.05069986f, 0.09944406f, 
    -0.03437949f, 0.07520923f, 0.07719810f, -0.09690870f, 0.03642820f, 0.06325969f, -0.14528388f, -0.00370728f, 
    -0.07004634f, 0.01032725f, -0.03909853f, 0.07904420f, 0.01289842f, -0.00007316f, -0.04027464f, 0.06659494f, 
    0.24680585f, -0.23852487f, -0.08044872f, 0.00465370f, -0.01800349f, -0.03110061f, -0.05700063f, 0.06708884f, 
    0.00228849f, -0.05228353f, -0.03024923f, 0.07403675f, -0.02923315f, 0.29991508f, 0.09361223f, -0.35214511f, 
    0.12743738f, 0.06626691f, 0.14198501f, -0.01422702f, -0.01559717f, 0.04241923f, 0.04536626f, 0.00274818f, 
    -0.11152842f, -0.19131476f, -0.01196585f, -0.01029916f, 0.14170986f, -0.01189079f, 0.11503759f, 0.11074215f, 
    -0.01698670f, -0.00916073f, 0.01865458f, 0.07409196f, -0.50049341f, 0.05616761f, 0.08640159f, 0.19838269f, 
    0.10641428f, -0.00476058f, 0.00831901f, -0.04768408f, 0.06238640f, 0.03467904f, -0.02443138f, 0.04859991f, 
    0.16101639f, -0.00223768f, 0.10914118f, -0.15197535f, -0.08778296f, -0.10372452f, 0.00318887f, 0.16714230f, 
    0.14006074f, -0.07508237f, 0.11806373f, -0.03108129f, -0.04531404f, -0.19331169f, 0.05860762f, 0.06480250f, 
    -0.05551971f, 0.03726529f, 0.04043116f, -0.07566417f, -0.02597220f, -0.05288952f, -0.06196288f, 0.07375285f, 
    0.19105813f, 0.02662731f, -0.13274254f, -0.05833490f, 0.04024196f, 0.04462237f, 0.05069654f, 0.02182415f, 
    0.06263454f, -0.05180759f, -0.05370794f, -0.02335490f, 0.08563914f, 0.09723669f, -0.11678760f, -0.05898883f, 
    -0.06781459f, -0.01970989f, -0.00496877f, 0.03759516f, 0.00516691f, 0.08201732f, 0.01231977f, 0.04828579f, 
    0.07801695f, -0.20815384f, 0.07270946f, 0.32071537f, -0.06691454f, -0.04311275f, -0.01141059f, 0.03125767f, 
    0.02541314f, 0.02698863f, 0.00199528f, 0.04682634f, -0.21632379f, -0.21341516f, -0.11154489f, -0.14713360f, 
    -0.06193805f, -0.01988786f, -0.08699299f, -0.02794067f, 0.02534596f, -0.07230332f, -0.00471747f, 0.03647741f, 
    0.16675949f, -0.10612611f, -0.09588111f, 0.14761746f, -0.08027094f, 0.04890038f, 0.05767027f, 0.14146630f, 
    0.08301430f, -0.02982535f, 0.01094713f, 0.01843306f, 0.21320406f, 0.10912824f, 0.09623024f, -0.09873449f, 
    -0.04586633f, -0.02820549f, 0.11746820f, 0.11821707f, -0.00839190f, 0.09925836f, 0.12712929f, 0.06417710f, 
    -0.28115833f, -0.01284788f, -0.09687907f, 0.12088374f, -0.03237347f, 0.02462675f, -0.18283683f, -0.02321125f, 
    0.04386569f, 0.01905166f, -0.02275513f, 0.14949061f, -0.03805770f, -0.11804508f, 0.09674527f, 0.23988885f, 
    0.00364122f, -0.03986197f, 0.00427777f, 0.00890749f, 0.13254714f, -0.02117753f, 0.03462698f, 0.03517384f, 
    0.20196313f, 0.19528046f, 0.02053685f, -0.03578686f, -0.03545698f, -0.02667496f, -0.03284217f, 0.00030278f, 
    -0.01044990f, -0.04816092f, 0.00010825f, 0.06524454f, 0.02679539f, -0.04593799f, -0.04725691f, 0.23637746f, 
    -0.04202777f, 0.07284935f, 0.07407682f, 0.00758851f, -0.00635438f, 0.05115066f, 0.01481030f, 0.16129981f, 
    0.06419168f, -0.05466156f, -0.08296495f, 0.03354517f, -0.19120657f, 0.06754103f, 0.08005159f, -0.02376897f, 
    -0.01240118f, 0.02106638f, 0.07549400f, 0.08798088f, 0.26913875f, -0.14008014f, -0.08643021f, -0.00426203f, 
    -0.18934920f, 0.05131217f, 0.03086789f, 0.04138046f, 0.02271167f, 0.10092624f, 0.08160704f, -0.08804327f, 
    0.21633084f, -0.18805890f, -0.28881878f, 0.28113419f, -0.08348341f, 0.10612587f, -0.01446469f, 0.04697282f, 
    0.06713808f, -0.02717340f, 0.10698299f, -0.00418972f, -0.39511889f, -0.18216424f, -0.02269839f, 0.00675176f, 
    0.09647681f, -0.07243900f, -0.01442634f, 0.01686826f, -0.01764050f, 0.08772711f, -0.02702343f, 0.02239768f, 
    -0.21259375f, 0.08191980f, 0.10364326f, 0.08724166f, 0.10222892f, 0.05537641f, 0.07111602f, 0.00409507f, 
    -0.02304234f, -0.00160365f, 0.04704611f, 0.11208971f, -0.25309741f, 0.11207472f, -0.18211043f, 0.19072986f, 
    -0.03230258f, 0.05972541f, -0.07952200f, 0.08428111f, -0.03267546f, 0.02134743f, 0.02286071f, 0.05098269f, 
    -0.18132715f, 0.55711758f, -0.24580510f, -0.28704700f, -0.00831067f, 0.05676373f, 0.07203361f, -0.00697075f, 
    0.08989786f, 0.01241738f, -0.05991907f, -0.08824387f, -0.15509115f, 0.03936964f, 0.04444114f, -0.10356406f, 
    0.02826687f, -0.00454721f, 0.03262722f, 0.07106808f, 0.16667792f, -0.08726475f, 0.07356942f, -0.05435473f, 
    -0.19302760f, 0.11534115f, 0.01765727f, 0.02992555f, -0.08384897f, -0.06931753f, -0.09941747f, 0.03231337f, 
    0.04286427f, -0.08676216f, -0.06663491f, 0.09426622f, 0.13602944f, 0.26838607f, -0.07548224f, -0.27743298f, 
    0.02069154f, -0.03819325f, -0.03921032f, 0.10430522f, -0.00658723f, 0.08638424f, 0.00650910f, -0.04193806f, 
    -0.15599361f, -0.00757235f, 0.03357174f, 0.17197423f, 0.07060923f, 0.05706032f, -0.00206580f, -0.03223062f, 
    0.06893940f, -0.06390008f, -0.01083837f, -0.01995759f, -0.03517150f, 0.13604529f, -0.03692874f, 0.03068212f, 
    -0.10888936f, 0.12507512f, 0.16568008f, 0.03021087f, 0.18502168f, -0.07928177f, -0.02042249f, 0.07293411f, 
    -0.18904261f, 0.04471051f, -0.21403101f, -0.22562695f, 0.10457607f, 0.09363661f, 0.02024293f, -0.02081806f, 
    0.01141680f, -0.00047022f, 0.08651944f, 0.05159009f, 0.00292569f, -0.15159366f, -0.11351068f, 0.03641837f, 
    0.06466383f, -0.01444168f, 0.05358886f, 0.02729132f, 0.04157336f, -0.05220307f, -0.02093872f, -0.03933147f, 
    0.16345471f, -0.23134416f, 0.15122499f, 0.14022404f, -0.05896817f, 0.02217299f, -0.06044199f, -0.02930722f, 
    -0.03267445f, 0.14457047f, 0.09001604f, 0.10317529f, 0.33092633f, -0.02912766f, 0.18410541f, 0.04817120f, 
    -0.05223618f, -0.05096280f, 0.00432267f, 0.02065068f, 0.07484584f, 0.07396240f, -0.08718094f, 0.04496568f, 
    -0.07257739f, 0.19428734f, 0.00262041f, 0.02037676f, -0.02995783f, -0.00563760f, -0.02074149f, -0.03840161f, 
    0.00236072f, 0.00622949f, 0.04714426f, -0.07662863f, 0.19344410f, 0.01989305f, -0.13142404f, -0.12596044f, 
    0.03927444f, 0.02616339f, 0.02740168f, 0.11742900f, 0.03236976f, 0.01318202f, -0.04463561f, -0.02558493f, 
    -0.09862832f, 0.27627400f, 0.05177414f, 0.13175865f, 0.01020000f, -0.00354408f, 0.09278452f, 0.00576618f, 
    0.01431458f, -0.05818049f, 0.06098672f, 0.03403430f, -0.10184386f, -0.21211375f, 0.03970359f, -0.07980669f, 
    0.05646792f, -0.06110390f, 0.00510434f, -0.11016044f, 0.01476636f, 0.09635308f, -0.06265122f, -0.05541678f, 
    -0.21884231f, 0.06383639f, 0.12824228f, -0.00550367f, 0.02333157f, -0.04788939f, 0.00174955f, 0.03655645f, 
    -0.12765196f, 0.02066827f, 0.04802212f, 0.12034798f, 0.11845469f, -0.03564082f, -0.11098633f, 0.04183443f, 
    0.12054162f, 0.09762840f, -0.03933083f, 0.00107385f, 0.02286042f, 0.06798794f, 0.15171736f, -0.08076148f, 
    0.04757676f, -0.06483509f, 0.21318346f, 0.07548235f, -0.10418637f, -0.03791502f, -0.14646882f, -0.04261925f, 
    -0.06028567f, -0.03044586f, -0.08528454f, 0.02755775f, 0.30939284f, 0.07934396f, 0.19346841f, 0.27086198f, 
    0.00518879f, -0.07579072f, -0.04639223f, 0.12454181f, -0.00999459f, 0.08449249f, 0.05520038f, 0.03372864f, 
    -0.06750113f, 0.05528978f, 0.01353727f, -0.01553532f, 0.06646866f, -0.02051854f, -0.02642711f, 0.00954940f, 
    -0.05779474f, 0.03926800f, -0.06950026f, -0.08057486f, -0.05526843f, 0.19148976f, 0.02509594f, 0.06690543f, 
    0.06421471f, 0.01307821f, -0.05104005f, 0.05359130f, -0.08158074f, -0.01338070f, 0.03599015f, -0.00115238f, 
    0.04211817f, 0.04913362f, -0.04236246f, 0.10804307f, -0.00537545f, -0.05729070f, 0.03116089f, -0.00137743f, 
    -0.11907966f, 0.06959764f, 0.04310606f, -0.10784983f, 0.02952626f, 0.05300829f, 0.11834358f, 0.05514806f, 
    0.02483214f, -0.07849433f, -0.01786250f, -0.03598510f, -0.00012388f, -0.02577606f, -0.09852475f, -0.12945025f, 
    0.19581510f, -0.08902254f, 0.00417641f, 0.02081489f, 0.00346999f, 0.00167865f, 0.01117896f, -0.00350407f, 
    0.02746112f, 0.05640440f, -0.00245177f, 0.09058759f, -0.12276713f, 0.05560980f, 0.05987258f, -0.03016926f, 
    0.00325953f, 0.07129776f, -0.03615546f, 0.03757858f, -0.00376999f, 0.03956307f, 0.00126230f, -0.12456928f, 
    0.00827675f, -0.00910588f, 0.06397866f, 0.11688696f, -0.10152893f, -0.00312576f, -0.00977582f, 0.09788498f, 
    0.08585174f, -0.02608898f, 0.09915069f, -0.00056927f, 0.02060874f, 0.14744611f, 0.13076690f, 0.02085845f, 
    -0.04787249f, -0.03316117f, -0.00525184f, 0.04704647f, -0.09722637f, -0.00222185f, -0.01334225f, 0.04050901f, 
    -0.30659202f, 0.11768732f, -0.07666816f, -0.06918659f, -0.10772429f, -0.02275206f, 0.08277161f, 0.03167182f, 
    0.11805861f, -0.05202397f, 0.04355338f, 0.02665425f, -0.04990052f, -0.04887250f, -0.07419471f, -0.02822835f, 
    0.01627872f, -0.01446393f, 0.01940133f, -0.09344481f, -0.01806839f, -0.04387156f, -0.00385020f, -0.08232171f, 
    -0.09473833f, 0.03328927f, 0.03280272f, 0.03676851f, -0.03942734f, 0.01354368f, 0.04303877f, 0.05459479f, 
    0.05046170f, -0.12185919f, -0.06959798f, -0.14380854f, -0.01686339f, 0.19083478f, 0.00835352f, 0.02271826f, 
    -0.01435507f, 0.03503355f, -0.03443787f, 0.00276989f, -0.05347062f, 0.00111470f, 0.02395757f, -0.10705556f, 
    -0.14665002f, -0.22733226f, -0.12370614f, -0.10153583f, -0.06185171f, 0.04283148f, 0.05422446f, 0.01652926f, 
    -0.00974361f, 0.00691966f, -0.03410431f, -0.04361022f, 0.31814295f, -0.33332542f, 0.11221987f, -0.10396147f, 
    -0.10768433f, -0.00511789f, -0.02460973f, 0.00665316f, 0.10136140f, 0.01078277f, -0.02153565f, 0.01228049f, 
    0.56389761f, 0.00735009f, -0.00777182f, -0.03208893f, 0.04323710f, 0.03866361f, 0.02007691f, -0.03085539f, 
    -0.07007881f, -0.00967026f, -0.12657937f, 0.00358441f, 0.15470833f, -0.12404619f, -0.04564241f, -0.19054918f, 
    0.02093384f, -0.01404252f, 0.01225782f, -0.01774228f, 0.02947814f, 0.01395293f, 0.03275714f, -0.01620582f, 
    0.25251228f, -0.11623521f, -0.04108737f, -0.18395928f, -0.04004928f, 0.08192991f, -0.15287048f, -0.14842895f, 
    0.01949809f, -0.02311656f, 0.18406042f, 0.05128808f, 0.30554804f, 0.26730230f, 0.08321280f, 0.21324675f, 
    0.07587754f, -0.01649463f, 0.13008453f, 0.05398664f, -0.09023579f, -0.06077224f, 0.04421461f, 0.00962957f, 
    -0.04001975f, 0.17466600f, -0.05255913f, 0.11635767f, 0.06530492f, -0.06521405f, -0.02396434f, -0.04015319f, 
    -0.00123350f, 0.08952925f, -0.03183363f, 0.03179569f, 0.06046312f, 0.15364750f, 0.11876492f, -0.02148451f, 
    -0.01762138f, -0.02662471f, 0.06320854f, 0.02361610f, 0.10166151f, 0.02146616f, -0.06955238f, 0.12946126f, 
    -0.04066099f, 0.02167927f, 0.04668176f, -0.04904012f, 0.02393400f, -0.03566407f, -0.01887154f, -0.03850418f, 
    0.00553775f, 0.03509611f, 0.03077673f, -0.02305531f, -0.04516719f, -0.01162791f, 0.01539865f, -0.04210159f, 
    0.04368961f, -0.01327577f, -0.03473492f, -0.04222634f, -0.02034933f, -0.01436430f, -0.00413536f, 0.02088482f, 
    0.04207863f, -0.04419576f, -0.04579921f, -0.01707931f, -0.05786446f, 0.03441229f, 0.02542766f, -0.02339183f, 
    0.00791984f, 0.01047077f, -0.03617736f, 0.03502803f, -0.04322735f, -0.00572986f, -0.01766187f, -0.01499248f, 
    0.00769727f, 0.01805450f, -0.00054769f, -0.04684021f, 0.00313083f, -0.05505074f, 0.01787122f, 0.04010805f, 
    -0.04687956f, 0.03705885f, 0.02053474f, 0.02971056f, 0.04201993f, 0.00199207f, 0.04178401f, -0.04060717f, 
    -0.05210081f, -0.01680486f, 0.02206528f, 0.02534506f, -0.00549805f, 0.00501517f, -0.05301964f, -0.01356832f, 
    0.04639970f, -0.03553032f, -0.04990657f, -0.05732109f, 0.03542200f, -0.02884402f, -0.04028499f, -0.05176998f, 
    0.02888243f, 0.04318210f, 0.02894937f, 0.03305516f, 0.00527230f, -0.04390548f, -0.05314206f, -0.01870932f, 
    0.00776347f, 0.01270126f, -0.01825849f, 0.01998572f, 0.00026936f, -0.01507889f, -0.01414258f, 0.03331285f, 
    0.02727530f, -0.01658669f, 0.00318116f, 0.03830050f, 0.00740507f, -0.02018608f, -0.04420523f, -0.02547647f, 
    -0.02987869f, -0.03590579f, -0.02795375f, -0.02082573f, -0.00443671f, -0.04870042f, -0.05417227f, 0.04149048f, 
    -0.04281498f, -0.03012930f, 0.00816531f, -0.05345453f, 0.02881189f, 0.00005036f, 0.01549979f, -0.00898113f, 
    0.03011088f, 0.04070373f, -0.02503421f, -0.04605957f, -0.04485503f, 0.05331668f, 0.00561971f, -0.04249368f, 
    -0.04913720f, -0.04808926f, 0.03782228f, 0.01304130f, 0.03889772f, 0.01518471f, 0.01611726f, 0.02525286f, 
    0.02522819f, 0.02626883f, -0.02187482f, -0.03525200f, -0.05582866f, -0.04145756f, -0.04433305f, -0.02668542f, 
    -0.04868351f, 0.03076648f, -0.00966462f, 0.00468640f, -0.01966375f, 0.03803873f, 0.03604000f, -0.00001973f, 
    -0.00508237f, 0.02598334f, 0.04055136f, 0.04259321f, -0.00044040f, 0.01371009f, -0.05367133f, -0.05457287f, 
    -0.04699202f, -0.01163683f, 0.04254465f, -0.05002312f, -0.03550143f, 0.03095290f, -0.01733994f, -0.01575336f, 
    -0.01479790f, -0.00355761f, -0.00356313f, -0.01839245f, -0.00146741f, 0.01873255f, 0.01850779f, 0.03512910f, 
    0.02280875f, 0.00109572f, -0.03518524f, 0.00443852f, 0.00408582f, 0.00611545f, 0.00989221f, 0.00976375f, 
    -0.01199275f, 0.01183191f, -0.01302100f, -0.02414626f, 0.00976868f, -0.04760657f, -0.00273305f, -0.03431768f, 
    -0.00602608f, 0.03169572f, -0.01472897f, -0.03347294f, -0.04144698f, 0.03309485f, 0.00731107f, -0.03524501f, 
    -0.05697386f, -0.00588230f, -0.02010591f, 0.01155042f, 0.00871009f, -0.01146953f, -0.03745076f, -0.02210277f, 
    0.01428357f, -0.05410795f, -0.00144600f, -0.01993578f, 0.03610159f, 0.02940818f, -0.02957270f, 0.03284590f, 
    -0.02190914f, -0.03577370f, -0.04835782f, 0.01174202f, -0.01523022f, -0.04032373f, 0.00153363f, -0.01399878f, 
    0.02034110f, 0.02767490f, -0.02687636f, 0.01847321f, 0.02423293f, -0.01553174f, -0.02017428f, 0.03255913f, 
    0.02091081f, 0.00842853f, 0.00861473f, 0.02059534f, 0.03878251f, -0.02490628f, -0.03505620f, 0.00970928f, 
    0.00239335f, 0.00424989f, -0.01522373f, 0.03726922f, 0.03387392f, -0.00669009f, 0.02731197f, -0.02355195f, 
    -0.02672140f, -0.03201528f, 0.01408962f, -0.00573121f, -0.01440080f, 0.01489393f, -0.00986420f, 0.00750323f, 
    -0.04953398f, 0.03555592f, 0.01408511f, -0.03137659f, -0.00964124f, 0.01682617f, -0.01369136f, -0.03972626f, 
    -0.02990763f, 0.02621855f, 0.03912378f, 0.01681282f, 0.00023487f, -0.03586808f, -0.00768350f, -0.05460130f, 
    -0.05292434f, -0.00609164f, 0.03095801f, -0.05025838f, -0.05704840f, -0.03883693f, -0.03477817f, 0.00198065f, 
    0.04239434f, -0.04570994f, 0.02479655f, 0.00716376f, 0.01882533f, -0.01576695f, -0.00951713f, -0.03793774f, 
    0.01090070f, 0.04164639f, -0.01463708f, -0.01879024f, -0.02029840f, 0.03418721f, -0.02224249f, -0.04729901f, 
    0.02609841f, -0.02636681f, 0.04108287f, 0.00845433f, -0.04239766f, -0.03108319f, -0.03488098f, -0.04595891f, 
    0.01309184f, -0.03379143f, 0.04532102f, -0.03339898f, -0.01482486f, 0.02054770f, 0.00927123f, 0.00659334f, 
    0.02116337f, -0.04351569f, 0.04074776f, 0.01931434f, -0.04852380f, -0.01803313f, -0.01911598f, 0.02647755f, 
    0.02690237f, 0.04306820f, -0.01523718f, -0.04959186f, 0.04019460f, 0.00854823f, -0.05344259f, 0.02723651f, 
    -0.00292899f, 0.00528185f, 0.04194805f, -0.03457554f, -0.02251926f, 0.03892453f, -0.04477980f, -0.04595113f, 
    -0.02148378f, 0.01226386f, 0.04278569f, 0.00744976f, 0.03429238f, -0.00453342f, 0.03453153f, -0.05683965f, 
    0.03727216f, 0.01625372f, 0.01447999f, -0.05411601f, -0.05221430f, 0.00962180f, -0.04595163f, -0.04273163f, 
    0.03207066f, 0.02440704f, -0.00403886f, 0.02953114f, 0.01893897f, -0.00916011f, -0.04837687f, -0.01609059f, 
    0.01508869f, -0.00123360f, 0.02355583f, -0.03089799f, 0.02342666f, 0.00004142f, 0.02222892f, 0.02750419f, 
    0.02131838f, 0.03854928f, -0.02379980f, 0.03036060f, -0.01431710f, 0.02860913f, 0.04350505f, 0.00284087f, 
    -0.04063641f, -0.02972186f, -0.04738963f, 0.01295967f, -0.02399619f, 0.02663128f, -0.04445736f, -0.03484491f, 
    -0.00994402f, -0.02461397f, -0.03444842f, 0.02415299f, 0.00209778f, -0.03452642f, -0.00746350f, 0.03083318f, 
    0.03525301f, 0.02852853f, -0.02897486f, -0.02883792f, 0.00614567f, -0.01519564f, 0.03783393f, -0.01218988f, 
    0.03087066f, -0.00955947f, -0.05444847f, 0.02928619f, -0.05186319f, -0.03270164f, -0.01632534f, 0.03877796f, 
    -0.00212606f, 0.03631649f, -0.05433659f, -0.02092669f, -0.00360844f, -0.05389269f, 0.00461844f, 0.00644043f, 
    0.01536720f, -0.00188924f, -0.02651155f, 0.01840819f, -0.01784823f, -0.02311025f, -0.03669488f, 0.03009080f, 
    0.02175611f, -0.05147285f, -0.04684119f, -0.04514373f, -0.04205307f, -0.03575867f, -0.01971658f, 0.03666073f, 
    0.03483387f, 0.02176397f, -0.03550246f, -0.02407388f, -0.01909602f, -0.00982003f, 0.01520526f, -0.03931070f, 
    -0.01620827f, -0.04834095f, -0.04894331f, -0.01561064f, -0.04666353f, 0.01788574f, 0.04230940f, 0.00408773f, 
    0.00760287f, -0.01223679f, -0.04125430f, 0.00733930f, 0.01813477f, -0.03515511f, -0.03601887f, -0.05512831f, 
    -0.02713775f, -0.02634526f, -0.03723376f, -0.00655151f, -0.01666207f, 0.03883388f, -0.02804295f, 0.00203156f, 
    -0.04206423f, 0.00950730f, 0.03970312f, 0.02205372f, -0.05381404f, -0.04340510f, -0.00585149f, 0.02726818f, 
    -0.03846850f, -0.05230112f, -0.02862405f, 0.04408904f, 0.01958109f, 0.03006595f, -0.04694471f, -0.03406952f, 
    -0.04244037f, 0.00910398f, -0.01747032f, -0.01923425f, -0.00555829f, 0.02538137f, -0.01647978f, 0.02567979f, 
    0.01340521f, -0.04522333f, -0.04178946f, -0.05202645f, -0.05399711f, -0.04678347f, -0.01888373f, -0.04031067f, 
    0.04435476f, 0.01701280f, -0.00271757f, 0.04054361f, 0.01667070f, -0.00317653f, 0.00893797f, 0.02045399f, 
    -0.02983727f, -0.01388532f, -0.00250776f, 0.00379816f, -0.02298005f, 0.03500002f, -0.03586884f, -0.03424283f, 
    -0.02850445f, 0.01588021f, -0.02990105f, -0.03227765f, 0.01861759f, -0.02506516f, -0.05598443f, 0.02006300f, 
    -0.05325763f, -0.03751756f, -0.05396263f, -0.03624197f, -0.03047117f, -0.00013870f, 0.03150982f, -0.01656980f, 
    0.01036390f, -0.02377549f, 0.02422962f, 0.01447766f, -0.00148567f, -0.01492692f, 0.02691269f, 0.00409790f, 
    0.04583647f, 0.03830288f, -0.00389652f, -0.05130803f, 0.00790914f, 0.02173248f, 0.00953755f, 0.03506465f, 
    0.03682264f, 0.04003217f, -0.00978960f, -0.00795491f, -0.02558179f, 0.03308233f, -0.02815291f, -0.01915705f, 
    -0.03959077f, 0.03837879f, -0.02724493f, -0.00394807f, -0.03695656f, -0.00437241f, -0.03603715f, 0.00001438f, 
    -0.02428522f, 0.03099702f, 0.03369298f, -0.01893027f, -0.02660973f, -0.03126556f, 0.02928093f, -0.01776906f, 
    -0.04268868f, 0.02105680f, -0.01721403f, 0.02218113f, -0.03654745f, 0.01169400f, -0.02170755f, -0.03415558f, 
    -0.01535540f, -0.02884491f, 0.00100600f, 0.00331004f, -0.03482625f, -0.01360661f, -0.05505975f, 0.01693162f, 
    -0.02026773f, 0.02871854f, 0.02404484f, -0.01139009f, 0.00392687f, -0.02944424f, -0.00943263f, -0.04414510f, 
    -0.03793367f, -0.00384116f, 0.04184330f, -0.04773837f, -0.02944090f, -0.02400101f, -0.00781593f, 0.01984647f, 
    -0.02858084f, 0.01173645f, -0.00610273f, 0.01922386f, 0.04365771f, -0.03303044f, -0.02395303f, 0.02748477f, 
    -0.04012489f, -0.05204315f, 0.00550626f, -0.04825055f, -0.02624507f, -0.00678343f, 0.02049015f, -0.03859435f, 
    -0.03114740f, -0.05606011f, -0.03446272f, -0.02335098f, -0.03178377f, -0.04578162f, -0.04913240f, 0.04437535f, 
    -0.00893986f, -0.02464769f, -0.03720136f, -0.05496752f, 0.01376048f, -0.04894116f, -0.03249739f, -0.04386917f, 
    -0.00314315f, 0.02674892f, -0.05394337f, -0.02069703f, 0.00764121f, 0.01805447f, 0.01077513f, 0.04943876f, 
    0.04052050f, -0.02225850f, 0.03223803f, -0.03712144f, 0.01356932f, -0.01643892f, 0.03973303f, -0.00398491f, 
    -0.01831338f, 0.02384993f, 0.03661350f, 0.03256099f, -0.04915895f, 0.00054844f, 0.01282069f, -0.02115455f, 
    -0.01822875f, -0.00220493f, -0.00974165f, -0.03693799f, 0.00491876f, -0.01715415f, 0.04313532f, -0.02499103f, 
    -0.00884221f, -0.04022099f, -0.02010714f, -0.04820731f, -0.02971131f, 0.01672077f, 0.02353005f, -0.01056427f, 
    -0.00201569f, -0.00976724f, -0.03265541f, 0.04466338f, -0.00464461f, -0.00210672f, -0.04099530f, 0.02135578f, 
    0.03331362f, 0.04759793f, 0.04344385f, 0.03661182f, -0.04715021f, 0.02244855f, -0.00804233f, 0.00122524f, 
    -0.03530357f, 0.00446162f, 0.03331187f, 0.03147250f, -0.00541411f, -0.02484033f, 0.01909061f, -0.00006770f, 
    -0.01804085f, 0.03360739f, -0.04556555f, -0.04912614f, -0.02387041f, -0.01028689f, -0.02888712f, 0.01021904f, 
    0.00689429f, 0.03312092f, 0.00040127f, -0.02257710f, -0.00232315f, -0.00892557f, 0.03285643f, 0.00599991f, 
    0.01086820f, -0.05589553f, -0.00241272f, 0.03150136f, -0.01504613f, 0.03016041f, -0.04190959f, 0.01152199f, 
    -0.02352337f, -0.01079718f, 0.01568157f, 0.03049988f, 0.03617061f, 0.03703108f, -0.00987359f, 0.02264957f, 
    -0.03852775f, 0.00612088f, 0.00287196f, 0.02958817f, 0.00438059f, -0.03641177f, -0.01429185f, -0.02172967f, 
    -0.00573361f, -0.01209904f, 0.02802981f, -0.02668206f, -0.05265714f, -0.03675135f, 0.04521821f, -0.00569971f, 
    0.04300227f, 0.00392413f, -0.04661267f, -0.04438302f, -0.04611514f, 0.02316149f, -0.00273252f, 0.02713463f, 
    0.01974509f, 0.03045787f, -0.03940610f, -0.04002065f, 0.02324174f, 0.00806945f, 0.03287761f, -0.01312650f, 
    -0.00864713f, 0.00818562f, 0.01228312f, -0.00850481f, -0.03865988f, -0.02683309f, 0.00097376f, 0.02587520f, 
    -0.03763542f, -0.02480246f, 0.04001416f, -0.01485066f, -0.05214708f, -0.01786770f, -0.05436340f, 0.02934860f, 
    0.03641783f, -0.00432259f, 0.04215986f, -0.00246686f, 0.01534241f, -0.03514312f, -0.00669932f, 0.02297012f, 
    0.01790498f, -0.05116742f, -0.03781480f, -0.03912583f, -0.03957774f, 0.03396362f, 0.00249555f, -0.01881653f, 
    0.00041300f, -0.05058831f, -0.02124462f, 0.00983564f, -0.04985437f, -0.02034028f, -0.00289463f, -0.04700536f, 
    0.04098536f, -0.03508750f, -0.03469093f, 0.04311869f, 0.04629771f, 0.03236884f, 0.00506830f, 0.01513703f, 
    -0.02673568f, -0.00976113f, -0.01485081f, 0.00450280f, -0.03152181f, 0.04210811f, 0.01749002f, -0.05626021f, 
    -0.00865341f, 0.02576794f, 0.00697852f, 0.02248714f, -0.02416359f, -0.05223694f, 0.04028258f, -0.03664184f, 
    -0.03597604f, 0.00543154f, -0.00234372f, -0.01237220f, 0.02022775f, -0.01879514f, -0.00700525f, 0.03878094f, 
    0.03235087f, -0.03104430f, -0.04709609f, -0.00235745f, -0.03745368f, -0.03267119f, -0.05212279f, -0.04310234f, 
    0.02027365f, 0.03144231f, -0.04656236f, 0.01796895f, 0.03842029f, 0.00175892f, -0.05870381f, 0.01382256f, 
    -0.04969413f, -0.04000347f, 0.00739537f, -0.01385030f, 0.00930715f, 0.04533109f, 0.03042397f, -0.01560053f, 
    0.03155218f, -0.03227735f, -0.01865438f, 0.00064645f, 0.03296261f, -0.02665708f, -0.03663998f, -0.04818350f, 
    -0.00141436f, -0.04066061f, -0.01019968f, -0.05423494f, -0.01083097f, -0.04202575f, -0.04264841f, 0.04185592f, 
    -0.01518374f, -0.01180804f, 0.00117709f, -0.03151853f, -0.04200286f, 0.02444274f, 0.03956725f, 0.03447389f, 
    -0.02846117f, -0.03321556f, -0.02894396f, -0.04572454f, 0.00282499f, -0.05443863f, 0.00805592f, -0.02654262f, 
    -0.03310211f, -0.04620562f, 0.02530821f, -0.01667939f, -0.04965972f, -0.02387626f, -0.02520524f, -0.03471651f, 
    0.00617730f, 0.03527132f, 0.04007752f, -0.01646855f, -0.00041460f, -0.00991589f, -0.00035836f, -0.03542289f, 
    -0.03570667f, -0.03732502f, -0.04288155f, 0.02357726f, -0.02333234f, -0.02339721f, 0.00356907f, 0.01977705f, 
    0.00670090f, 0.02541517f, 0.03358625f, -0.04650598f, -0.00331489f, 0.00965956f, 0.02866089f, -0.01803861f, 
    0.03290785f, 0.00670537f, 0.02619179f, 0.00003825f, 0.03032438f, -0.05225462f, 0.04025163f, -0.05494726f, 
    0.03430378f, 0.03356094f, 0.02033842f, -0.05226006f, -0.04706983f, 0.03762613f, 0.02624551f, 0.01858728f, 
    -0.00400607f, 0.00113269f, -0.00003329f, 0.02697567f, 0.04565761f, 0.00939560f, 0.02999737f, 0.03448793f, 
    0.01338746f, -0.05621722f, -0.00864851f, 0.02985867f, -0.03331330f, -0.02735334f, 0.01212293f, -0.03690150f, 
    -0.05430308f, -0.05345978f, -0.00391612f, -0.05125232f, -0.02570896f, 0.01352952f, 0.01644719f, -0.04835823f, 
    -0.04064804f, 0.00861581f, -0.00728698f, -0.04913390f, 0.01302499f, 0.02214304f, 0.02052410f, -0.03683447f, 
    0.03233062f, -0.04967649f, -0.05559116f, -0.05437580f, -0.00538436f, -0.05214047f, 0.03430205f, -0.00918194f, 
    -0.01802132f, -0.04980429f, 0.02942224f, 0.04515266f, 0.02988785f, -0.04215536f, 0.02741616f, 0.00463667f, 
    -0.01964323f, -0.05449079f, 0.02413465f, 0.00209888f, 0.02531233f, -0.01965014f, -0.04970281f, -0.04926164f, 
    -0.00348118f, -0.01032932f, 0.02053259f, 0.01023688f, -0.00885586f, 0.03400017f, 0.00290955f, -0.04694409f, 
    -0.00893257f, -0.00601283f, -0.05184287f, -0.02177349f, 0.04416273f, -0.01230590f, -0.04538770f, 0.00114554f, 
    0.03378135f, -0.00954524f, 0.04053012f, -0.03162211f, 0.02792358f, 0.00438835f, 0.03619995f, -0.05564544f, 
    -0.02183001f, -0.04689752f, -0.02899956f, -0.02267664f, -0.02014734f, -0.02534410f, -0.00843443f, 0.03727707f, 
    0.02602429f, -0.00411909f, -0.00325542f, -0.03762284f, -0.02499209f, -0.05136906f, -0.04641068f, 0.01093730f, 
    0.01461962f, -0.05037749f, 0.01234937f, -0.00719432f, 0.03390579f, 0.00345551f, 0.01594309f, -0.05287292f, 
    -0.03966988f, 0.02987382f, -0.04500552f, 0.02676060f, -0.02942178f, -0.04225673f, -0.02687078f, 0.01036057f, 
    0.02318874f, 0.03711602f, -0.01990690f, -0.02975365f, 0.04366934f, 0.01987318f, -0.04288981f, 0.00146918f, 
    0.00752672f, -0.01244383f, -0.03611629f, 0.00146703f, -0.03239758f, -0.02164949f, 0.00374477f, 0.03221206f, 
    -0.02600059f, -0.05645972f, 0.02505865f, -0.02992020f, -0.04827136f, 0.03103276f, -0.03416354f, 0.00554744f, 
    -0.04525061f, -0.03849395f, 0.02789448f, 0.02278162f, 0.00752452f, 0.02403919f, 0.03045517f, 0.03233045f, 
    0.00837748f, 0.03399348f, -0.04121696f, 0.02989057f, -0.04052696f, 0.04214298f, -0.02320164f, 0.02261836f, 
    -0.03032535f, -0.02389880f, 0.01323618f, -0.02454704f, -0.02632052f, 0.03048264f, 0.03126726f, -0.04134425f, 
    0.01682297f, 0.00480836f, 0.04126821f, 0.02182505f, -0.04076808f, -0.00042012f, -0.00035813f, -0.01338832f, 
    0.02081882f, -0.01165838f, -0.02191513f, -0.02787558f, 0.00900517f, 0.00620282f, 0.01620206f, 0.03553949f, 
    0.01941115f, -0.01743771f, 0.03121635f, 0.00245213f, 0.03032976f, -0.02711545f, 0.00645149f, -0.03823546f, 
    0.00595168f, 0.03504723f, -0.03175172f, -0.02274045f, -0.00921761f, -0.02164944f, -0.04089381f, 0.00858775f, 
    -0.01498137f, 0.00727644f, 0.02416267f, -0.01549534f, -0.02163031f, 0.02518953f, 0.02303341f, -0.05696100f, 
    0.04409943f, 0.01121961f, -0.00512856f, 0.00867483f, -0.01233854f, 0.04361970f, -0.04515206f, 0.03726236f, 
    0.04098380f, -0.03065135f, 0.01686470f, -0.05545035f, 0.01345482f, -0.00161848f, -0.05235357f, -0.01737957f, 
    0.03178176f, -0.00348067f, -0.00385767f, 0.03279813f, 0.02076164f, 0.04007212f, -0.04779793f, 0.03939220f, 
    -0.29905614f, 0.01474510f, -0.21078748f, 0.19195695f, -0.09628442f, -0.01512602f, -0.19279471f, 0.00940928f, 
    -0.09449742f, -0.03017984f, 0.03439306f, 0.00255309f, 0.00869896f, -0.06623744f, 0.08234783f, -0.17304283f, 
    -0.01341785f, 0.01186165f, 0.02420351f, 0.04226285f, 0.02983029f, -0.03752030f, 0.05134903f, -0.19245046f, 
    0.04084674f, -0.26910862f, 0.05655970f, 0.04717591f, 0.00433595f, 0.00171746f, 0.11670140f, 0.01568238f, 
    0.08091130f, 0.02166742f, 0.05680939f, 0.16072085f, 0.20734666f, -0.06228540f, 0.09293579f, 0.20525908f, 
    0.02264314f, 0.00879010f, 0.14108649f, -0.11816204f, -0.03808746f, 0.03997932f, -0.00914329f, 0.10393327f, 
    -0.21432093f, 0.36401975f, -0.11122578f, -0.20023635f, -0.03003167f, 0.10030954f, 0.07507666f, 0.08061127f, 
    -0.10574989f, 0.04322246f, -0.01804925f, 0.08888944f, 0.20679599f, -0.18781194f, 0.08794474f, 0.19910380f, 
    -0.04770731f, 0.00926637f, -0.00769692f, 0.10656703f, 0.00649038f, -0.05023288f, -0.04199224f, 0.04914259f, 
    -0.14939013f, 0.05977035f, -0.04598576f, 0.19138867f, 0.02970888f, 0.03934185f, 0.08428964f, 0.03401926f, 
    0.08372217f, 0.02241426f, 0.06352390f, -0.01280341f, 0.02084612f, -0.11988117f, 0.20229375f, -0.13376462f, 
    0.10300063f, 0.01868952f, 0.02038055f, 0.04450815f, -0.06484410f, -0.05898572f, 0.02037865f, -0.07461427f, 
    0.15821028f, 0.12366206f, 0.08527246f, 0.09391478f, 0.09067563f, -0.04554686f, 0.08574308f, -0.03063093f, 
    -0.08253152f, 0.06460144f, -0.00676123f, 0.05046878f, 0.20884743f, 0.10503639f, 0.06044233f, 0.17869200f, 
    0.01687498f, 0.00312424f, 0.03075747f, 0.17043547f, 0.03890918f, 0.03212829f, 0.16571710f, -0.00269295f, 
    0.20623034f, 0.10567708f, 0.12625144f, 0.11216106f, 0.03245825f, 0.01891212f, 0.09030916f, 0.07382784f, 
    0.01004275f, 0.05179023f, 0.08386186f, 0.08518418f, -0.28959641f, -0.21202281f, -0.11535419f, 0.06614201f, 
    -0.01167766f, -0.05040368f, 0.06911321f, -0.04672329f, 0.02302506f, 0.00261856f, 0.12111571f, 0.15207633f, 
    -0.18846843f, 0.15016444f, 0.13859254f, -0.27583212f, 0.13470238f, 0.10085270f, -0.02421566f, -0.02158285f, 
    -0.01076002f, 0.03164516f, -0.00460144f, 0.03988595f, -0.26556709f, -0.03268823f, 0.06703214f, 0.22044173f, 
    -0.02002266f, 0.07244275f, 0.04817537f, 0.09040704f, 0.02517618f, 0.19749084f, 0.03404573f, -0.02396368f, 
    -0.14702801f, 0.07837256f, 0.11620674f, -0.13394038f, -0.07032203f, -0.00374382f, 0.08003667f, 0.05956761f, 
    0.01027170f, 0.11216645f, 0.02208979f, 0.11180197f, 0.11629213f, 0.10573281f, 0.07113121f, 0.20477028f, 
    0.07971229f, 0.14838760f, 0.07973486f, -0.11714277f, -0.12595062f, -0.09752154f, -0.00010125f, -0.12148923f, 
    0.03667599f, -0.15224741f, 0.14254314f, -0.00878909f, 0.05083208f, 0.00815214f, -0.01472670f, 0.03771928f, 
    0.03521128f, -0.04020143f, -0.04495439f, -0.05831867f, -0.31242886f, 0.19547276f, 0.03289512f, -0.21554197f, 
    -0.06968793f, 0.08481408f, 0.01723306f, 0.00550613f, 0.00568316f, 0.04713873f, 0.03711803f, -0.06893455f, 
    -0.09151524f, -0.24393742f, -0.06299013f, 0.03615260f, 0.07560651f, -0.01158556f, 0.01045868f, 0.08694784f, 
    0.05773089f, -0.07160815f, 0.13905746f, -0.07181856f, -0.02951073f, 0.04542868f, -0.03074221f, -0.27717838f, 
    -0.00801324f, 0.09592742f, -0.03284933f, 0.00770038f, -0.08898563f, -0.02353432f, -0.01541784f, -0.00062347f, 
    -0.22291675f, 0.06563591f, 0.00492919f, 0.21891983f, 0.04585955f, 0.06571472f, -0.01632907f, -0.01492057f, 
    0.04034479f, -0.03032075f, -0.00395199f, -0.05969526f, -0.20761676f, 0.18399136f, 0.10994510f, -0.16031788f, 
    0.03021542f, -0.04487441f, 0.01286292f, 0.11417514f, 0.11113223f, -0.03069303f, -0.01874330f, 0.04127643f, 
    -0.05761195f, 0.30815342f, 0.04917678f, -0.32575700f, -0.07212445f, 0.09002724f, -0.00348845f, 0.00333885f, 
    0.06171091f, 0.00725200f, -0.02355309f, -0.18604912f, -0.28997922f, 0.16389471f, 0.22004904f, 0.04353757f, 
    0.01960438f, 0.16255488f, 0.01570161f, 0.01342148f, 0.13899930f, -0.00954289f, 0.04859925f, -0.06730279f, 
    0.06409068f, 0.00640392f, -0.04037768f, 0.07066252f, 0.05839086f, -0.03793244f, 0.04620284f, -0.04523475f, 
    -0.04311097f, 0.08977498f, 0.03343667f, -0.03292207f, 0.22908491f, 0.07524784f, 0.06860348f, -0.10966268f, 
    0.05560162f, -0.02437391f, 0.04528746f, 0.07345466f, 0.11665694f, 0.03561737f, 0.06569902f, -0.12610064f, 
    0.24069652f, -0.37674540f, 0.12763751f, 0.26764953f, -0.00137791f, -0.10800333f, 0.06831590f, 0.01193456f, 
    -0.05895384f, -0.01415386f, -0.10189396f, 0.09886727f, -0.06139976f, -0.06297782f, -0.05232149f, 0.17734779f, 
    -0.02332196f, -0.01719082f, -0.07175010f, -0.14960034f, -0.02870167f, 0.11673054f, -0.02593457f, -0.09222857f, 
    0.26114050f, -0.06087915f, 0.06434163f, 0.16866185f, 0.12016787f, 0.05484066f, 0.09053578f, 0.14641199f, 
    -0.05908424f, -0.03318429f, 0.00728181f, 0.03959269f, -0.04955412f, 0.12845902f, -0.05307901f, 0.20178765f, 
    0.05346120f, -0.02409298f, 0.02136396f, -0.08645618f, -0.05401135f, 0.02350944f, 0.06831785f, -0.09091570f, 
    0.00707535f, 0.15476017f, 0.00284788f, -0.27471286f, -0.00276466f, -0.03102531f, -0.01846719f, -0.03098772f, 
    0.03169458f, -0.01780452f, -0.02364261f, 0.08442727f, -0.25014278f, 0.19225353f, 0.18151495f, -0.08607157f, 
    0.16592447f, 0.04292292f, 0.06887642f, -0.01456513f, -0.00171121f, -0.02325763f, 0.13627276f, 0.02541707f, 
    0.14300776f, 0.23577864f, -0.03412985f, 0.14349927f, -0.17571929f, 0.03342266f, -0.04978073f, 0.09139263f, 
    0.11777546f, -0.07920812f, -0.03706073f, 0.10135869f, 0.16129585f, -0.17776883f, -0.00118872f, 0.03990282f, 
    -0.01338986f, -0.01652581f, 0.04102262f, -0.00152233f, -0.05042674f, 0.06401169f, -0.03621404f, 0.01934172f, 
    -0.01964358f, 0.11176614f, 0.20457411f, -0.00349081f, 0.00972939f, -0.06124633f, 0.06460089f, -0.08165178f, 
    0.06291346f, -0.06460747f, -0.00040563f, 0.13213846f, -0.22436167f, -0.04846934f, 0.11612169f, -0.09425512f, 
    0.19291706f, 0.06799839f, 0.06002099f, 0.04345566f, -0.03318830f, -0.01860954f, 0.10196744f, 0.06754007f, 
    -0.00421539f, 0.12597172f, 0.11748805f, 0.11789177f, -0.06101734f, -0.02581741f, 0.04150726f, 0.02212887f, 
    0.04455299f, 0.03745153f, -0.02392120f, -0.01303651f, 0.09875886f, -0.02726403f, 0.13157085f, 0.14162657f, 
    -0.08709338f, 0.05496125f, -0.14935060f, 0.05226551f, -0.10332425f, -0.06932265f, 0.03300074f, -0.02226799f, 
    0.13785280f, 0.11214582f, -0.19962059f, -0.11404660f, -0.10178056f, 0.09514517f, -0.23753099f, -0.18384883f, 
    0.00491290f, 0.10564540f, 0.05712944f, 0.05431892f, 0.24900793f, -0.01278202f, -0.13411212f, 0.02555130f, 
    0.03539307f, -0.05992822f, 0.03503065f, 0.11345942f, 0.02019192f, 0.08440972f, -0.01142470f, -0.02378914f, 
    -0.21497856f, 0.01854264f, -0.03462241f, 0.01332060f, 0.14405531f, 0.18318237f, -0.02502532f, -0.02029757f, 
    -0.06697874f, 0.11273380f, -0.15278748f, 0.05797606f, -0.10861137f, 0.09750505f, 0.01463773f, 0.01110234f, 
    -0.00391839f, 0.04522144f, 0.04117330f, -0.10757633f, 0.16809307f, 0.05547994f, 0.14656360f, -0.00078810f, 
    -0.20329942f, -0.07022635f, 0.04688113f, -0.15657701f, -0.00253245f, -0.01353027f, 0.09031893f, -0.05157852f, 
    -0.08178765f, 0.14397211f, 0.05670503f, -0.01794074f, -0.04850568f, 0.10776836f, 0.04638512f, -0.06665335f, 
    0.08149266f, 0.13742982f, -0.05986471f, -0.08464344f, -0.02868705f, -0.10710502f, -0.01383917f, -0.05775081f, 
    0.21184960f, 0.02144529f, -0.07045073f, -0.13280672f, -0.00546557f, 0.12219752f, -0.04136803f, 0.01770272f, 
    0.04749057f, -0.01341008f, 0.03589259f, -0.07559864f, 0.25168219f, 0.27760306f, -0.17582557f, 0.08803036f, 
    0.09184694f, 0.08795553f, 0.07351208f, 0.02227524f, 0.00212138f, 0.09547255f, 0.00201969f, 0.01821439f, 
    -0.07275613f, 0.09258340f, 0.13943064f, 0.03474274f, -0.02131857f, -0.04073771f, 0.01360729f, 0.00224571f, 
    -0.07509838f, 0.05206047f, 0.02958708f, 0.04608444f, -0.28195858f, -0.06265267f, 0.00413034f, 0.03842882f, 
    0.06136174f, -0.03725400f, -0.07707909f, -0.05771780f, 0.12237567f, -0.09159607f, 0.04451265f, 0.05987658f, 
    -0.03936741f, 0.00667615f, 0.07564777f, -0.00300022f, 0.10048986f, 0.00208156f, 0.14310876f, -0.04050165f, 
    0.00969588f, 0.00260848f, 0.07410564f, 0.02554489f, 0.02207520f, -0.00903034f, -0.16855147f, 0.02031018f, 
    0.03303278f, 0.07757835f, -0.03009963f, 0.09806056f, 0.01490772f, -0.05521969f, -0.02493658f, -0.00187291f, 
    -0.47827515f, 0.02089110f, -0.03917103f, -0.09962756f, 0.05466100f, 0.02973420f, 0.06856728f, -0.22002494f, 
    0.00158951f, 0.10496712f, -0.00801554f, 0.14501257f, 0.14602801f, -0.07779948f, -0.02618650f, 0.08909189f, 
    -0.02689859f, -0.04887344f, -0.09676096f, 0.01959811f, -0.06704187f, -0.00118224f, 0.01830997f, -0.26802981f, 
    0.02569443f, 0.25769749f, -0.17689268f, -0.03195918f, 0.07430706f, 0.13984758f, -0.22186248f, 0.16821618f, 
    0.00091439f, -0.01865946f, -0.03044247f, -0.05719869f, -0.04430183f, 0.24736694f, 0.18976592f, 0.10087755f, 
    0.04898268f, 0.10235658f, 0.10655886f, -0.05492180f, 0.16482207f, -0.10866237f, -0.08332666f, 0.09200175f, 
    -0.11595883f, 0.17121372f, 0.20802537f, 0.00466038f, -0.05791017f, -0.00082076f, 0.09273479f, -0.11665558f, 
    -0.03962297f, 0.07927322f, -0.07186534f, 0.06677604f, 0.20184210f, 0.16067290f, -0.16582923f, 0.02025819f, 
    -0.03604235f, 0.06758229f, 0.06970876f, 0.08227826f, -0.02095351f, -0.12792079f, 0.01048448f, -0.05802358f, 
    0.14027768f, -0.08899428f, -0.15876552f, 0.10251919f, -0.05873412f, -0.00343749f, 0.02721071f, 0.01421169f, 
    0.06375697f, -0.00595180f, -0.13582113f, -0.12836760f, -0.15468326f, 0.02060454f, 0.17160664f, 0.17130983f, 
    0.12729625f, -0.00874990f, 0.12504131f, 0.00163999f, -0.02880131f, 0.05392585f, 0.03177949f, 0.04480845f, 
    0.12730376f, -0.13091157f, 0.33089221f, 0.28997177f, 0.04449046f, -0.03962952f, -0.03690464f, 0.07399305f, 
    0.02623546f, -0.05966089f, -0.02797413f, 0.01378787f, -0.03804351f, 0.08201504f, -0.01302550f, 0.03660424f, 
    -0.00187808f, -0.05707847f, -0.01493787f, 0.02696721f, -0.11853380f, -0.02957935f, -0.04147771f, -0.05503068f, 
    -0.17378606f, 0.06306256f, 0.15022755f, 0.07021690f, 0.17713398f, -0.17407489f, 0.05951118f, 0.10235925f, 
    -0.12991846f, 0.22171418f, -0.11624597f, 0.07932505f, 0.04344348f, -0.19077453f, 0.05319654f, 0.12240088f, 
    -0.05440059f, 0.05361445f, 0.02110917f, -0.14659764f, 0.15682296f, -0.11284765f, 0.05705739f, 0.10835241f, 
    0.17700894f, -0.11946053f, 0.02599305f, -0.01633290f, -0.04711269f, -0.01681956f, 0.02260489f, 0.04384604f, 
    -0.04968986f, 0.09538812f, 0.00167387f, 0.03742182f, 0.09560103f, -0.01609932f, -0.05181188f, 0.16350372f, 
    0.02039168f, -0.12951918f, -0.03792092f, 0.02149854f, -0.20404670f, 0.02935961f, -0.03292384f, -0.17799851f, 
    -0.05640160f, 0.00191783f, 0.01394282f, 0.00186640f, -0.01008255f, 0.04237450f, -0.05102840f, -0.05649316f, 
    -0.00444118f, -0.01991325f, 0.03748814f, 0.00420209f, 0.02275151f, -0.04152243f, 0.02906368f, 0.00686344f, 
    -0.00642217f, 0.01007008f, -0.02400504f, -0.01690453f, 0.02176481f, -0.04375102f, -0.02283517f, 0.00587714f, 
    0.02481311f, -0.05579450f, 0.03018576f, 0.04305357f, 0.03009984f, -0.04651271f, 0.02053664f, -0.03982101f, 
    -0.01347487f, 0.04130262f, 0.02511545f, 0.01574776f, -0.04271778f, 0.04007824f, -0.00132194f, -0.04409047f, 
    -0.00243806f, 0.00937630f, -0.05282544f, -0.02678707f, 0.04556995f, 0.01486894f, -0.00566032f, -0.00246142f, 
    0.00729670f, -0.00447484f, 0.00872409f, 0.03555902f, 0.01565283f, 0.03870624f, 0.00177854f, -0.03543272f, 
    -0.01965559f, -0.03823318f, 0.01986366f, 0.02945248f, -0.04355130f, -0.02978329f, 0.00205739f, 0.01801312f, 
    -0.05460417f, -0.02520637f, -0.00771121f, -0.00689339f, -0.00878389f, 0.03123618f, 0.04082472f, 0.03849008f, 
    -0.05162190f, 0.02453620f, -0.00236592f, -0.04589257f, -0.04005684f, -0.01065849f, -0.00591564f, 0.01477040f, 
    -0.00279068f, 0.03361234f, 0.00538291f, 0.02806098f, -0.05061259f, 0.02430514f, 0.00112096f, -0.03935514f, 
    -0.01868551f, 0.02130676f, -0.02978915f, -0.05216862f, 0.03472273f, 0.01827787f, -0.02608855f, -0.01976536f, 
    -0.01474942f, -0.03436602f, -0.04046226f, -0.04411793f, -0.01722830f, -0.01053911f, -0.00477010f, -0.04366998f, 
    -0.04078966f, -0.01873296f, 0.02289544f, 0.00648067f, -0.00868906f, 0.04540701f, 0.01613945f, 0.00076155f, 
    -0.01520975f, -0.01820351f, -0.02050593f, 0.00209640f, -0.00271678f, 0.02088218f, -0.00844536f, 0.01997703f, 
    -0.01997910f, 0.03974181f, -0.00060361f, -0.01856527f, -0.04976425f, -0.05003618f, 0.00874018f, -0.01583096f, 
    -0.01460633f, 0.03293716f, -0.03438788f, -0.00527708f, -0.01971574f, -0.01180203f, 0.03452379f, -0.05304300f, 
    -0.01954884f, 0.03511184f, -0.01669030f, -0.01735708f, -0.04784583f, -0.00820119f, 0.00548219f, -0.01718523f, 
    -0.03760741f, 0.01152008f, 0.04322372f, -0.01541646f, -0.03041796f, 0.00678639f, 0.03632016f, -0.02462131f, 
    -0.01107553f, -0.03226524f, 0.01069401f, 0.03072193f, -0.00643419f, -0.01807192f, -0.03581504f, 0.03634911f, 
    -0.01926244f, 0.00311776f, -0.00609788f, -0.00700250f, -0.00796872f, 0.03779348f, -0.00866849f, 0.00977894f, 
    0.00447919f, 0.01878063f, -0.00522424f, 0.02413996f, 0.01098468f, -0.04288275f, -0.02001415f, 0.04392614f, 
    -0.05328587f, -0.00772563f, -0.04856407f, -0.04274739f, -0.04237696f, 0.00783678f, -0.02167326f, -0.03228081f, 
    0.02297567f, 0.00301472f, -0.02334919f, 0.01801685f, -0.01420183f, -0.01438098f, 0.03777567f, -0.02488132f, 
    0.02036010f, 0.01118669f, -0.03808157f, -0.01859236f, -0.05785320f, -0.02037160f, 0.00499089f, 0.04237872f, 
    0.01559823f, 0.01170721f, -0.02442362f, -0.00820113f, 0.04321267f, -0.04168995f, 0.02628841f, 0.01083632f, 
    -0.05035642f, -0.04098164f, -0.04447821f, 0.01385864f, 0.02413718f, 0.03786365f, -0.02761964f, -0.00518582f, 
    0.02198141f, 0.00787686f, -0.03370590f, -0.03934157f, -0.03822831f, 0.00666849f, 0.02116785f, -0.01194603f, 
    -0.03514367f, -0.03964325f, 0.01249175f, 0.02958546f, 0.01027784f, -0.04256720f, -0.05042972f, 0.01622834f, 
    0.02439859f, 0.04190824f, 0.00973793f, -0.04812539f, -0.05725385f, 0.01603849f, 0.00340310f, 0.03009489f, 
    -0.00201221f, -0.01273902f, 0.03875876f, -0.01709508f, -0.04155747f, 0.01608852f, 0.00177845f, 0.01993534f, 
    0.01866118f, 0.04143744f, -0.02837362f, -0.05247918f, 0.03576020f, 0.00897262f, 0.03544791f, 0.04383842f, 
    -0.00815801f, -0.04702643f, -0.04016884f, -0.00570892f, 0.00238760f, 0.04241288f, -0.04057384f, -0.04018553f, 
    -0.00467874f, 0.02837846f, 0.00921915f, -0.04747465f, 0.00621629f, -0.01443077f, 0.01054585f, -0.05409798f, 
    0.01214762f, -0.02402302f, 0.01697385f, 0.02991772f, 0.01696341f, 0.04155728f, -0.02561686f, -0.03385625f, 
    0.02451261f, 0.02815391f, -0.04138321f, 0.02886654f, 0.03429392f, -0.02664667f, 0.03655959f, 0.01789833f, 
    -0.03650190f, -0.03165631f, 0.02588429f, -0.02641114f, -0.04730374f, 0.01733944f, 0.03860041f, 0.04397772f, 
    -0.02915464f, 0.04039597f, 0.04195680f, 0.03986798f, -0.01535870f, -0.00076407f, -0.03975767f, 0.00580614f, 
    -0.00333347f, -0.05678306f, 0.02836474f, -0.03729360f, -0.04592100f, 0.01589651f, 0.04546652f, -0.04671929f, 
    -0.03578885f, 0.02530334f, 0.02691605f, -0.00491587f, 0.03334984f, -0.02725232f, -0.05696770f, 0.00763785f, 
    0.00458989f, 0.00037196f, -0.00358417f, -0.04267411f, -0.01382347f, 0.00319102f, 0.04542805f, 0.02341388f, 
    -0.02637381f, -0.04502386f, 0.00539211f, 0.00680229f, 0.02466264f, 0.03974731f, 0.02579230f, 0.02313217f, 
    -0.04651180f, 0.03273469f, -0.04706458f, -0.02726500f, 0.00932289f, 0.00105031f, -0.02966546f, 0.00427327f, 
    -0.05252588f, 0.02192196f, 0.03581952f, -0.03767743f, -0.02116984f, 0.01861282f, 0.02769045f, 0.04135315f, 
    -0.00072271f, -0.04360397f, 0.04169645f, 0.00397791f, -0.04148430f, -0.02903206f, 0.00398360f, 0.02017181f, 
    -0.05019464f, -0.01943262f, -0.04332109f, -0.02034402f, 0.00095552f, 0.04004955f, -0.01493326f, -0.00778761f, 
    -0.02857962f, -0.02951659f, 0.02973711f, 0.04538395f, 0.03738691f, -0.03728653f, -0.05124862f, -0.02203665f, 
    -0.02034617f, -0.00361414f, -0.04466788f, -0.00340641f, 0.03961679f, 0.03190273f, -0.01588024f, 0.00023581f, 
    0.16971502f, 0.13149185f, -0.04361229f, -0.05790696f, 0.02695306f, 0.13202769f, -0.00777440f, 0.06574969f, 
    0.08008888f, 0.04025598f, 0.20227377f, 0.05751408f, 0.19730781f, -0.06272521f, -0.10952786f, -0.02530337f, 
    0.03821153f, -0.08535963f, 0.06608232f, -0.03451210f, 0.01568012f, -0.22881699f, -0.17497157f, -0.22860481f, 
    0.32932869f, -0.13906851f, -0.05805184f, -0.01692942f, -0.06818955f, -0.01808090f, 0.15196317f, 0.10616096f, 
    0.05669020f, 0.04241716f, 0.02741084f, 0.17614950f, -0.05966019f, -0.08197092f, 0.17698209f, -0.14995155f, 
    0.10641400f, -0.01923592f, -0.12445046f, -0.08644766f, 0.06696616f, -0.06723852f, 0.14387701f, 0.21209009f, 
    -0.02459865f, 0.14333169f, -0.11290463f, 0.01963675f, 0.03693048f, -0.05799597f, -0.10536055f, -0.07605595f, 
    -0.06453396f, -0.13303447f, 0.06992925f, -0.04859986f, 0.13867171f, 0.00175514f, -0.01283111f, -0.17104743f, 
    -0.00729064f, 0.02887283f, -0.00602360f, 0.07860391f, 0.02382400f, 0.02211680f, 0.10987213f, 0.04415158f, 
    -0.15630259f, 0.11815403f, 0.15597494f, 0.03768307f, -0.06366433f, -0.01657488f, 0.11232261f, 0.01649627f, 
    0.03203342f, 0.01337937f, 0.00462232f, 0.22051245f, 0.09220781f, -0.09626272f, 0.05521183f, -0.03024511f, 
    0.02983815f, 0.10180554f, -0.00910837f, 0.00112033f, -0.01695837f, -0.07947926f, -0.10383311f, -0.10696087f, 
    -0.19540967f, -0.06372783f, -0.06240610f, 0.08100941f, -0.12080153f, -0.06996473f, -0.05461048f, -0.12124172f, 
    -0.16237526f, 0.14382353f, 0.05081458f, 0.22241299f, 0.01648107f, -0.01821081f, -0.08497591f, 0.02709711f, 
    0.08220416f, -0.16309541f, -0.03279880f, 0.17026322f, 0.00413495f, 0.00691199f, 0.31903622f, -0.02871808f, 
    0.10138127f, -0.15313329f, 0.14035010f, 0.13490401f, 0.02099415f, -0.08002977f, -0.12291865f, 0.14487302f, 
    -0.03677170f, 0.04617830f, 0.07420744f, 0.04911211f, 0.13797818f, -0.05794574f, 0.12716366f, 0.02528654f, 
    0.08074894f, 0.00299868f, 0.08661568f, 0.12144602f, -0.15558156f, -0.01407932f, 0.07365414f, 0.00364573f, 
    0.02465287f, -0.08603190f, -0.06114035f, -0.10595460f, 0.11786201f, 0.00609924f, -0.00075733f, -0.01557990f, 
    0.09815901f, 0.03859678f, 0.01074967f, -0.14853431f, 0.15928499f, 0.08218733f, 0.09467310f, -0.10160092f, 
    0.04267477f, 0.14176066f, -0.00328586f, -0.05229560f, -0.06657580f, 0.12437139f, -0.10751669f, -0.05887033f, 
    -0.10765968f, -0.14410837f, -0.18789172f, -0.10774417f, 0.03111135f, 0.00579227f, -0.09437137f, 0.00289343f, 
    0.01148962f, 0.05087812f, 0.13208297f, -0.12872028f, -0.07204220f, -0.02598969f, -0.01189924f, -0.09444335f, 
    -0.10794207f, -0.19648524f, -0.02480295f, -0.05367354f, 0.01118069f, -0.10751716f, -0.26030132f, -0.04684020f, 
    -0.10576411f, -0.05475094f, 0.05355148f, 0.02932710f, 0.08908394f, 0.03644961f, 0.15766466f, -0.00060691f, 
    0.05578762f, 0.07779233f, -0.05942398f, -0.01911354f, 0.14694865f, -0.10011359f, -0.05780331f, -0.00726832f, 
    0.04114121f, 0.06623586f, -0.15074089f, 0.01198356f, -0.03898852f, 0.00327473f, 0.03881216f, -0.08276311f, 
    -0.04498811f, -0.05714864f, -0.10733481f, 0.13729453f, -0.13994768f, -0.12012818f, 0.17286777f, 0.10449287f, 
    0.01136366f, 0.07048503f, 0.06137794f, 0.00776532f, -0.18732861f, -0.05352736f, -0.09928844f, -0.05916348f, 
    0.07043823f, -0.08343057f, -0.06317831f, -0.17337181f, -0.04341841f, -0.02013033f, 0.14032654f, 0.10165160f, 
    0.00904340f, 0.03676581f, 0.20241079f, -0.08604772f, -0.08705791f, 0.26595309f, 0.10421851f, 0.11752225f, 
    0.07647234f, -0.11371756f, 0.01589744f, -0.10169573f, 0.02678856f, 0.17219205f, 0.03261616f, 0.24548329f, 
    0.06552251f, -0.02889453f, 0.05331546f, -0.10996503f, -0.05148096f, -0.00855539f, 0.05513515f, -0.10740387f, 
    -0.12277517f, 0.13398896f, 0.06592646f, 0.27247253f, 0.15621863f, -0.11346371f, 0.14992991f, 0.13274509f, 
    -0.01746579f, -0.09529321f, -0.10086641f, -0.02644994f, 0.06471463f, 0.04161524f, -0.03759241f, -0.01375056f, 
    0.14193925f, -0.02559149f, 0.01370228f, -0.04743217f, -0.03678352f, -0.02831231f, 0.04060478f, -0.04912673f, 
    0.32645637f, -0.11944103f, 0.13136819f, -0.16086526f, -0.03847448f, 0.01771967f, -0.02329696f, -0.05577960f, 
    -0.00954050f, 0.13281693f, 0.04928952f, 0.13315547f, 0.03530276f, -0.10182945f, 0.06237772f, 0.05744006f, 
    -0.00012123f, -0.06385233f, 0.08303678f, -0.01532196f, 0.01034965f, 0.06154018f, -0.03510922f, 0.00510401f, 
    0.57141298f, 0.03647093f, 0.07877494f, -0.02883360f, -0.01390871f, 0.00781074f, -0.05353807f, 0.04140953f, 
    0.01733823f, -0.10833900f, 0.07104801f, 0.27472851f, 0.27356049f, 0.02478683f, 0.13854614f, -0.07306205f, 
    0.06407152f, 0.01300626f, 0.01283815f, -0.07543851f, 0.07542047f, 0.00935342f, 0.04327833f, -0.09303150f, 
    0.05435774f, -0.00396576f, 0.00441089f, -0.05592871f, -0.06126906f, -0.04073143f, -0.14546861f, -0.03434491f, 
    -0.01206220f, 0.15367228f, 0.23899524f, 0.06551239f, 0.12038260f, -0.11094505f, 0.09812836f, -0.10127369f, 
    -0.13294955f, 0.09989524f, 0.08111622f, 0.04401764f, -0.03754232f, -0.12888905f, 0.07535004f, 0.02168706f, 
    0.05190677f, 0.01291819f, -0.16085117f, 0.02176349f, 0.14664488f, -0.08521325f, -0.13699517f, -0.01286737f, 
    0.12422760f, 0.12417814f, 0.11583430f, 0.15823627f, 0.02041149f, 0.04070214f, 0.00804926f, -0.01372650f, 
    0.09082323f, -0.12806131f, -0.12287926f, -0.05017038f, 0.18713786f, 0.14262241f, -0.01275315f, 0.15783116f, 
    0.07311282f, -0.05093285f, 0.02535687f, -0.01314342f, 0.05385602f, -0.01963712f, -0.05597889f, 0.03780409f, 
    0.01661286f, 0.03327441f, 0.03532683f, -0.05155043f, 0.05729796f, 0.02763781f, -0.05546478f, 0.06925725f, 
    -0.00202460f, -0.02209762f, -0.04015555f, 0.03515763f, -0.05558274f, 0.02502135f, 0.04530552f, -0.06382587f, 
    0.00644544f, -0.04150104f, -0.05088231f, -0.02999268f, 0.02196607f, -0.03217597f, 0.00131920f, -0.00347835f, 
    -0.01615052f, -0.04529192f, 0.00733109f, 0.00005554f, -0.04999144f, 0.02647630f, 0.02988520f, 0.00443563f, 
    -0.04454381f, 0.02999733f, -0.00109559f, 0.03999094f, -0.02100465f, 0.01220615f, -0.04479822f, -0.05150896f, 
    0.03215173f, -0.06607708f, -0.04326575f, 0.02221397f, -0.01887769f, -0.03694412f, 0.00548221f, -0.02575106f, 
    0.01756193f, 0.00305493f, -0.07336535f, -0.06489956f, 0.00133113f, 0.01642449f, -0.01371453f, -0.04918253f, 
    -0.04606866f, -0.01818273f, -0.02959619f, -0.01196328f, 0.00040523f, 0.00265531f, -0.05326056f, -0.03590530f, 
    0.05241745f, -0.00929057f, -0.00124972f, -0.08986212f, -0.00906654f, -0.05725860f, -0.00927128f, -0.04006991f, 
    0.02320825f, -0.03068841f, -0.01541785f, -0.05448464f, -0.01054486f, -0.00425314f, -0.06953480f, 0.03846692f, 
    -0.05368695f, 0.02469994f, -0.04329918f, -0.04755320f, -0.00681268f, -0.00751749f, -0.01760376f, -0.03278838f, 
    -0.05841329f, 0.03914154f, -0.03539178f, 0.03846603f, -0.00298519f, 0.04485868f, 0.02103745f, 0.00082345f, 
    -0.03530268f, 0.01699494f, -0.01170847f, -0.04018831f, 0.03811272f, -0.01757245f, -0.02255850f, 0.02333604f, 
    0.01390312f, 0.00961107f, -0.03769695f, -0.04041174f, -0.03167082f, 0.04839008f, -0.04642458f, -0.00451760f, 
    0.05111650f, -0.00174017f, 0.00061235f, -0.02506841f, -0.03559826f, -0.06180267f, -0.04057895f, 0.01430470f, 
    -0.04805567f, -0.05399497f, -0.01920672f, -0.05158682f, -0.03841776f, 0.02104739f, 0.06979960f, -0.02078090f, 
    -0.01160301f, 0.01646905f, -0.00481475f, -0.00521767f, -0.01146888f, -0.01633364f, -0.00841857f, -0.06702457f, 
    0.01801154f, -0.02399841f, 0.01126325f, 0.03123805f, -0.05969673f, -0.00278649f, 0.00130562f, 0.03866674f, 
    -0.04292246f, 0.02343473f, 0.02020625f, 0.00838996f, 0.00718631f, 0.00808497f, 0.00955582f, 0.01534789f, 
    0.05118530f, 0.02278941f, 0.03604363f, 0.00505127f, -0.02658917f, -0.05456827f, -0.07876394f, -0.04063292f, 
    -0.04518755f, -0.05442577f, -0.01464432f, -0.00882844f, -0.01694727f, 0.00523563f, -0.03277273f, -0.02742156f, 
    0.01437113f, 0.00319616f, -0.04356363f, -0.03249692f, -0.02756088f, 0.04169936f, 0.00087891f, 0.00620235f, 
    -0.05299054f, -0.04491582f, -0.00933236f, -0.06350604f, 0.03676998f, 0.03189551f, -0.00851997f, -0.02652983f, 
    -0.02929394f, 0.00876472f, -0.03788957f, 0.03051210f, 0.04175378f, -0.03645031f, -0.00654328f, 0.04760689f, 
    -0.02759962f, -0.06446844f, -0.02230574f, -0.04473456f, 0.05302086f, -0.04880359f, -0.05257618f, -0.02617438f, 
    0.02769069f, -0.04937037f, 0.02617214f, -0.02145912f, -0.03068022f, 0.02614420f, 0.02121455f, -0.02677056f, 
    -0.03345580f, -0.01237858f, 0.05269528f, 0.01771394f, -0.00229576f, -0.02938464f, 0.01386695f, 0.03430300f, 
    -0.03564485f, 0.03079613f, -0.02961007f, -0.02948185f, 0.00946800f, -0.02208687f, -0.04656332f, 0.01099781f, 
    0.02689061f, 0.02255159f, 0.04461616f, -0.03938601f, -0.02009234f, -0.05667115f, -0.05663441f, 0.00420036f, 
    0.06121381f, 0.02004327f, 0.04874648f, -0.05693913f, 0.02634887f, -0.02481887f, 0.01615510f, -0.03990414f, 
    0.03158670f, 0.02699912f, 0.04341028f, 0.01676495f, -0.03917389f, -0.01979517f, 0.01050147f, 0.01541676f, 
    0.04979939f, -0.01514661f, -0.00895626f, -0.06097018f, 0.00539139f, 0.03018622f, -0.04126736f, -0.07034244f, 
    -0.00842705f, -0.04427035f, -0.00779763f, 0.05520346f, 0.03018889f, -0.01399897f, 0.03563981f, -0.03028041f, 
    0.01965652f, -0.04088999f, 0.02905485f, -0.03507254f, 0.01521811f, -0.02902921f, -0.00757908f, -0.00676270f, 
    0.03350807f, 0.00053757f, -0.04974762f, -0.02481961f, -0.00240191f, -0.04049974f, -0.02558197f, -0.01588122f, 
    0.05909764f, 0.02983110f, -0.07544526f, -0.04401894f, -0.01151302f, -0.00458746f, 0.01181683f, -0.03970842f, 
    -0.00639305f, 0.02583650f, -0.01832568f, -0.04782520f, 0.02409421f, -0.03949212f, -0.02228248f, 0.06678751f, 
    -0.02252668f, 0.00605031f, 0.02451990f, 0.00371564f, -0.01511899f, 0.06534734f, 0.03225189f, 0.03036787f, 
    -0.00875854f, 0.03409126f, 0.02122327f, 0.00074035f, 0.03711863f, -0.00014017f, 0.01143026f, -0.00181351f, 
    -0.01370934f, -0.05622815f, 0.01355538f, 0.02677727f, -0.00344254f, -0.06243150f, -0.00700606f, -0.03379566f, 
    -0.03491885f, 0.05963949f, 0.00651522f, 0.02618300f, 0.04265833f, -0.00782543f, -0.01652095f, -0.00988763f, 
    0.03903098f, -0.01091731f, -0.05044425f, 0.00294525f, -0.04411064f, 0.02039745f, -0.04067317f, 0.02845513f, 
    -0.04602613f, -0.00901625f, 0.01385775f, -0.05143438f, -0.01930878f, 0.00802722f, 0.02617190f, 0.01511601f, 
    0.03435409f, 0.00411909f, -0.00200391f, 0.01149399f, -0.06313295f, 0.01842294f, 0.06141192f, -0.03467723f, 
    -0.03166871f, -0.02093914f, -0.06539068f, 0.03697805f, -0.02547146f, -0.01200111f, 0.03379805f, 0.01891757f, 
    0.03496989f, -0.03481234f, -0.05053243f, -0.05456739f, 0.04088094f, -0.06724452f, -0.04217837f, -0.04473950f, 
    -0.02121910f, 0.01130714f, 0.01404339f, -0.01162634f, 0.04423546f, -0.02945257f, -0.01966648f, -0.02102568f, 
    0.11422405f, -0.05072882f, 0.24499805f, 0.04974740f, -0.04855327f, -0.12689589f, 0.04673290f, 0.10138076f, 
    -0.14247972f, -0.07505880f, 0.07852702f, -0.07444628f, -0.11327729f, 0.09474222f, -0.00437717f, 0.02632247f, 
    -0.02402706f, 0.03756512f, 0.00157763f, 0.00504023f, -0.02018125f, -0.18757363f, -0.02039866f, -0.23785937f, 
    -0.07717588f, 0.32902518f, -0.09761927f, 0.06245290f, 0.12491196f, 0.17596793f, 0.21865539f, -0.01264371f, 
    0.04930802f, 0.04105112f, -0.03949428f, 0.06029359f, -0.20329896f, 0.19682115f, -0.06596144f, 0.12124439f, 
    0.17632565f, 0.08612501f, -0.11220337f, 0.04528170f, -0.00011856f, -0.12112134f, 0.08417234f, 0.12651470f, 
    0.37371227f, 0.03678600f, 0.08311401f, 0.08326586f, -0.12186883f, -0.02456461f, 0.06471644f, -0.03096705f, 
    -0.04363952f, 0.00139215f, -0.11969054f, 0.05410462f, -0.12468074f, 0.17660637f, 0.34432000f, -0.01995379f, 
    -0.02864451f, 0.10878847f, -0.02758211f, 0.00440951f, 0.03627878f, -0.01351852f, 0.12449872f, -0.03146520f, 
    0.07817372f, -0.14543882f, 0.08905226f, -0.09329500f, 0.14601626f, -0.13705340f, 0.00363507f, 0.08131522f, 
    0.02204058f, 0.05918668f, 0.01360517f, 0.09526745f, -0.18549007f, 0.01292721f, -0.13061114f, 0.19108991f, 
    -0.08097459f, 0.05800902f, 0.01169624f, -0.02930900f, -0.05208316f, -0.01635728f, -0.05329205f, -0.03747888f, 
    0.07413325f, 0.03410546f, -0.03147241f, 0.09113186f, 0.01170942f, 0.01323926f, 0.03093415f, 0.01747164f, 
    0.04822539f, -0.05170046f, 0.02398871f, 0.08981057f, 0.10262860f, -0.05591040f, 0.03674988f, 0.21437383f, 
    -0.08441237f, 0.10293319f, -0.06401006f, 0.11129764f, -0.00521266f, 0.01465239f, 0.06940615f, -0.13238682f, 
    0.02432127f, 0.07844872f, -0.27839324f, 0.00979493f, 0.13404831f, 0.13256140f, -0.09014885f, 0.03190102f, 
    0.04851566f, -0.00335004f, 0.09248159f, 0.02820682f, -0.07590074f, 0.08048771f, 0.05252058f, -0.14409199f, 
    0.23373826f, 0.08087852f, 0.04718610f, 0.03585799f, 0.02212379f, 0.02232373f, 0.06720687f, 0.03471022f, 
    0.45970896f, -0.04679634f, 0.08030442f, 0.30198458f, -0.26558352f, 0.08749447f, 0.03696509f, 0.11903246f, 
    0.02332607f, -0.01382195f, 0.00360586f, -0.07838239f, 0.01995061f, -0.06304625f, 0.19939245f, -0.18424948f, 
    -0.07620169f, -0.02415442f, 0.04002370f, -0.05861382f, -0.00519636f, -0.00049662f, -0.13863042f, -0.11033639f, 
    0.26020893f, 0.08925077f, 0.05198846f, 0.07286024f, -0.10113928f, 0.04144990f, 0.02577283f, 0.05554854f, 
    0.08479294f, 0.06272542f, -0.01156208f, 0.06252519f, -0.10921317f, -0.03452927f, -0.02255858f, 0.17554164f, 
    -0.01419772f, -0.04296602f, 0.05194077f, 0.18461666f, 0.13011377f, 0.07388881f, -0.15036090f, 0.08452263f, 
    -0.28489918f, -0.00468134f, 0.03294920f, 0.02243892f, 0.06018238f, -0.06611044f, -0.06566236f, -0.08143643f, 
    0.02552111f, -0.00257931f, -0.08712865f, 0.00255511f, 0.24724904f, -0.05528923f, -0.01861838f, 0.11694238f, 
    -0.09278233f, -0.07076210f, 0.02454719f, 0.01828435f, 0.01130176f, -0.01902250f, 0.12641209f, -0.00923286f, 
    0.13980410f, 0.07989573f, -0.11335941f, -0.02468392f, -0.03299234f, -0.10824312f, 0.08563455f, 0.10237906f, 
    -0.03646988f, 0.04007933f, -0.02100133f, 0.03668749f, 0.03186067f, 0.00653599f, -0.05345534f, 0.15077178f, 
    -0.10239876f, 0.04954432f, 0.03520896f, -0.05107773f, -0.01565868f, 0.06991556f, 0.06827076f, 0.08011582f, 
    0.25399461f, 0.05420838f, 0.13445406f, -0.01934003f, -0.25522962f, 0.10968278f, 0.15496908f, 0.10708692f, 
    -0.03470384f, -0.07514743f, 0.05947833f, -0.06167544f, -0.00488098f, 0.09759424f, 0.20330168f, 0.01260043f, 
    -0.07700073f, 0.06338127f, 0.00406103f, -0.06123928f, -0.04127206f, -0.02621705f, -0.10680702f, -0.07690720f, 
    0.19660978f, 0.07051624f, -0.14352527f, 0.10304067f, 0.08300316f, 0.13886777f, -0.07489637f, 0.00477389f, 
    -0.02350223f, 0.01101542f, -0.01437327f, -0.08796137f, -0.07415225f, 0.05088389f, 0.10595204f, -0.11381547f, 
    -0.17059700f, -0.14762940f, 0.00773477f, 0.06464627f, 0.01665610f, 0.02704686f, -0.07194890f, -0.08390374f, 
    0.17834708f, -0.03294073f, -0.19186243f, 0.15494315f, -0.13755019f, 0.04860695f, -0.00514233f, 0.01169982f, 
    0.04383767f, 0.01405767f, 0.02368103f, -0.00176857f, -0.15219726f, 0.24777354f, -0.07221828f, 0.08253087f, 
    0.02847807f, 0.16563362f, 0.10581776f, -0.03385456f, 0.04594722f, 0.01938332f, 0.06471758f, 0.00638003f, 
    0.24912433f, 0.15100130f, 0.18545599f, -0.08864190f, 0.00684094f, -0.06150388f, 0.05892109f, -0.01282644f, 
    0.00261578f, -0.03013342f, -0.05042762f, 0.14173310f, -0.27806270f, -0.09381027f, 0.07268853f, 0.14682585f, 
    -0.03532616f, 0.01524976f, -0.02688745f, 0.02774715f, 0.04329829f, 0.00527286f, -0.07287153f, -0.20717382f, 
    -0.14166798f, 0.03906884f, 0.22532938f, 0.07913961f, -0.03284276f, 0.04645516f, -0.20718800f, 0.07697354f, 
    -0.02847165f, 0.19275361f, 0.19827172f, 0.09011922f, -0.00009568f, 0.04936127f, -0.01066222f, -0.25365338f, 
    -0.02508586f, 0.04102390f, -0.07701223f, 0.01660173f, 0.01811738f, -0.11496282f, 0.07393701f, -0.02384849f, 
    0.08474791f, -0.05619308f, 0.05143733f, 0.15230869f, -0.05731123f, 0.07981654f, 0.11013145f, 0.12689234f, 
    -0.09477051f, -0.09560500f, -0.01156598f, 0.00275794f, 0.06332836f, 0.13518837f, -0.13232653f, 0.05681669f, 
    -0.16688685f, -0.00626018f, 0.09515727f, 0.09108834f, -0.06617066f, 0.04279114f, -0.07100025f, -0.04556879f, 
    -0.08924843f, 0.20404650f, -0.17520916f, 0.07542811f, -0.01736995f, -0.06457119f, -0.11938217f, -0.05300672f, 
    -0.03571440f, -0.03578481f, 0.03056675f, 0.03138024f, -0.18374787f, -0.15794021f, 0.14213580f, 0.00305252f, 
    0.12205736f, 0.00929487f, -0.04847335f, 0.02311453f, 0.01205125f, 0.06324461f, 0.02934126f, -0.05355548f, 
    -0.18934837f, -0.14059460f, 0.00287978f, 0.10811811f, 0.04750872f, -0.05454435f, 0.07667156f, -0.00018181f, 
    -0.05799806f, 0.08212496f, 0.20773691f, -0.05444814f, 0.06020257f, -0.13078542f, -0.12059908f, -0.17249677f, 
    0.04378273f, 0.04227915f, 0.22513172f, 0.00194225f, -0.16349965f, 0.01665783f, -0.04369914f, 0.13353038f, 
    0.33717352f, -0.10620889f, -0.07079392f, 0.09148970f, -0.12547097f, 0.02650632f, -0.05645921f, 0.01926830f, 
    0.04102744f, 0.00406862f, 0.10460634f, -0.06323882f, 0.42284015f, 0.08186108f, 0.02009122f, 0.02574827f, 
    0.09531358f, 0.05277372f, 0.03784344f, 0.02351674f, -0.00080097f, 0.02425540f, -0.09870965f, 0.11386676f, 
    0.01124226f, 0.09751423f, 0.01035833f, 0.14386104f, -0.07569848f, 0.05155551f, -0.08927135f, 0.04486882f, 
    -0.00913210f, 0.05462993f, 0.03869795f, -0.04027658f, -0.04908359f, -0.28951487f, 0.04079623f, -0.07279009f, 
    0.10965300f, -0.02284495f, 0.02055565f, 0.04907420f, 0.08386258f, -0.01823397f, -0.04151937f, 0.05201484f, 
    0.02843278f, 0.03088365f, 0.02893926f, -0.05857421f, 0.07754069f, -0.15863231f, 0.03211514f, 0.04265141f, 
    -0.04414989f, -0.03440919f, -0.13483985f, 0.09785990f, 0.03824798f, -0.04042745f, 0.12913601f, -0.13577406f, 
    -0.05887156f, -0.02502783f, 0.02530021f, -0.04398972f, 0.03857039f, 0.05222607f, -0.03498836f, 0.20128377f, 
    -0.02982814f, -0.11935436f, -0.04329996f, -0.13555913f, -0.11349522f, 0.02538447f, 0.11207061f, -0.00308865f, 
    0.04069049f, 0.10407256f, 0.04474799f, 0.02747171f, -0.38208726f, -0.13836668f, -0.09168356f, 0.11100323f, 
    -0.07726455f, 0.02126904f, 0.06040917f, -0.01733118f, 0.03792848f, -0.03271648f, 0.00347171f, 0.07605873f, 
    0.04841342f, 0.02080325f, 0.21089390f, 0.12537894f, 0.03235063f, 0.13188396f, -0.07886977f, 0.00805820f, 
    0.07551429f, -0.02601316f, 0.04271503f, 0.01135945f, 0.07530152f, 0.15663515f, -0.14595878f, 0.10805230f, 
    0.10555334f, -0.02149042f, 0.13657871f, 0.01451732f, 0.04055399f, -0.05760073f, 0.01845755f, -0.04395909f, 
    0.12286317f, 0.13712268f, 0.24517952f, 0.20427312f, 0.05912002f, -0.09006721f, 0.15154797f, 0.03133725f, 
    -0.09354542f, 0.02036602f, 0.00449631f, 0.16414277f, -0.07530966f, -0.00404426f, 0.10305355f, 0.07899782f, 
    0.08430149f, -0.03089573f, 0.00426959f, 0.00522850f, 0.01021163f, 0.01815120f, 0.15549363f, 0.01310420f, 
    0.19130741f, 0.04475214f, 0.09899770f, 0.00806218f, -0.02369847f, -0.08838513f, -0.05405105f, 0.02174865f, 
    -0.01709232f, 0.01452937f, 0.01758010f, -0.03368340f, -0.19267681f, 0.07552987f, 0.01412024f, 0.27892375f, 
    -0.11168768f, 0.09808891f, 0.00342380f, -0.00493438f, 0.02272733f, 0.00520874f, -0.01690942f, 0.01834608f, 
    -0.15645258f, -0.13268192f, -0.01125700f, 0.01599895f, 0.02067588f, 0.11058104f, 0.09286135f, -0.15979241f, 
    0.01427209f, -0.13212033f, 0.08543635f, 0.12130322f, 0.14543457f, 0.12423556f, 0.06626166f, 0.05421702f, 
    -0.07978091f, 0.01078313f, -0.01013116f, 0.00917841f, 0.00932918f, -0.01823029f, 0.03058372f, -0.07948675f, 
    0.11505160f, 0.18138009f, -0.29399240f, 0.04255702f, 0.11100217f, 0.12906389f, -0.03106358f, 0.04854523f, 
    0.04024341f, 0.01051539f, 0.00269566f, 0.09190123f, 0.04860379f, 0.14298007f, -0.00300286f, -0.10126182f, 
    -0.05691126f, 0.03449294f, -0.11083451f, -0.03202393f, 0.12759748f, -0.01437864f, -0.00596412f, 0.04778947f, 
    0.11252561f, 0.05478858f, -0.03781731f, -0.26158065f, -0.11161918f, 0.07352586f, 0.05834400f, -0.09643837f, 
    -0.01784316f, 0.01709341f, 0.08742622f, -0.10050985f, -0.04851861f, 0.14668472f, 0.02325264f, 0.04879030f, 
    -0.06013050f, 0.04154017f, 0.01326492f, -0.06648403f, -0.08551612f, -0.09309646f, 0.02123582f, -0.01593192f, 
    -0.27122757f, -0.17009489f, -0.08298366f, 0.01126788f, 0.01240450f, -0.02812181f, 0.11420601f, 0.04992368f, 
    -0.00840272f, 0.00884648f, 0.04892262f, -0.02594733f, -0.02918912f, -0.11435269f, -0.06178694f, -0.02375576f, 
    0.04553206f, -0.00417274f, 0.00725402f, -0.04636172f, 0.04546057f, -0.02522056f, 0.11406428f, -0.06925683f, 
    -0.04931781f, 0.17371632f, 0.02615428f, 0.01769746f, 0.00502528f, 0.06752464f, -0.01563176f, 0.04098500f, 
    0.00856702f, 0.00357682f, -0.14827535f, -0.09688310f, -0.01369848f, 0.05923485f, -0.15216216f, -0.08371671f, 
    -0.04034356f, -0.08001900f, 0.08020252f, 0.03647998f, 0.03397447f, -0.05051536f, -0.11929259f, -0.07682390f, 
    -0.00324906f, -0.09665290f, -0.01753958f, -0.06419359f, 0.03984226f, 0.03223074f, 0.18828854f, 0.09488892f, 
    -0.07601979f, 0.08156424f, -0.15127896f, 0.17105639f, 0.04184947f, 0.05797268f, -0.01378381f, 0.08582445f, 
    0.06225260f, -0.08720679f, -0.00193190f, 0.00963796f, -0.03321660f, -0.07567598f, -0.03295098f, 0.02595164f, 
    0.05986011f, 0.04549018f, 0.20910257f, 0.19480148f, -0.02703662f, -0.04632565f, 0.04781216f, -0.02760286f, 
    0.06647047f, -0.03622436f, 0.01309048f, -0.03148383f, 0.14878929f, 0.05814866f, 0.03773395f, 0.01047335f, 
    0.00686677f, 0.03374661f, 0.06657887f, 0.09454338f, -0.08200069f, -0.14519796f, 0.20375888f, 0.11537264f, 
    0.00864296f, -0.03369626f, -0.05564295f, -0.01305891f, -0.01291009f, 0.04579610f, -0.04118204f, 0.02805050f, 
    0.02723027f, -0.05064444f, -0.04539651f, 0.03459313f, -0.02776970f, -0.01657695f, -0.02809289f, 0.01695496f, 
    0.04137411f, 0.00037994f, -0.00460910f, 0.03099922f, -0.02221469f, -0.02967157f, -0.01059990f, 0.03119368f, 
    -0.00895004f, -0.00344349f, 0.03166927f, -0.00442578f, -0.01497649f, 0.02867538f, -0.01828993f, -0.01974711f, 
    0.02249239f, -0.00965305f, -0.05366749f, -0.00067552f, 0.00507621f, 0.00027288f, 0.00331129f, 0.03917213f, 
    -0.00593608f, 0.01810374f, -0.04926283f, -0.00847294f, 0.00841856f, 0.02269629f, 0.00762527f, -0.04563029f, 
    0.04180494f, -0.03911156f, 0.03806753f, -0.00076998f, 0.02444280f, -0.02515045f, -0.01112459f, 0.03214660f, 
    -0.01849390f, -0.01371080f, -0.04746771f, 0.02365740f, -0.01683539f, -0.05155907f, -0.04859836f, 0.03565487f, 
    0.01099425f, -0.03245021f, -0.00303481f, -0.01489039f, 0.00429969f, 0.04323849f, -0.02686740f, 0.02996837f, 
    -0.04977437f, -0.02063733f, -0.05230649f, -0.02913647f, -0.03507772f, 0.01912513f, -0.02153933f, -0.04281405f, 
    -0.02476605f, 0.02382543f, -0.03276919f, -0.03621936f, -0.00206721f, -0.02024646f, -0.03871980f, -0.02249409f, 
    0.03421842f, -0.02221954f, 0.02287195f, -0.00170708f, -0.01970885f, -0.02144370f, 0.00626483f, -0.03832787f, 
    0.00455843f, -0.00301058f, -0.04222809f, 0.02081837f, 0.01224655f, 0.02398265f, -0.04977790f, 0.00697983f, 
    -0.00178022f, 0.02133632f, -0.03223146f, -0.04664379f, -0.02184693f, -0.03730414f, -0.03020927f, -0.00014399f, 
    -0.03957839f, -0.04987593f, 0.00894591f, 0.02036875f, -0.04542601f, -0.05210425f, -0.00001044f, 0.03707830f, 
    0.01259595f, 0.03311548f, 0.01082219f, 0.02530319f, -0.03982059f, 0.04039855f, 0.00294903f, 0.05195501f, 
    -0.04750993f, -0.01228069f, -0.00915716f, 0.03252758f, -0.00105826f, -0.00133052f, 0.02272075f, 0.00727881f, 
    0.00661303f, -0.02845409f, -0.03642516f, 0.00690863f, -0.04432214f, 0.02861782f, 0.00295306f, -0.04129536f, 
    0.04436631f, -0.02430447f, 0.02640698f, -0.01981421f, 0.03986533f, 0.01626667f, -0.04027381f, 0.01878448f, 
    -0.02324022f, -0.00831861f, -0.05783807f, -0.01631140f, -0.05509429f, 0.02912181f, -0.00070654f, -0.03781707f, 
    -0.04217415f, -0.02444728f, 0.02638317f, 0.03215423f, -0.00067149f, -0.04895515f, 0.02335266f, 0.03659772f, 
    -0.02747277f, -0.04814984f, -0.02764091f, -0.00430651f, -0.05716915f, 0.03896785f, -0.01043855f, 0.01307659f, 
    0.00093482f, -0.03301575f, -0.02658638f, -0.04538490f, 0.02239559f, -0.02608330f, 0.02467185f, -0.03964604f, 
    0.03237792f, -0.04164541f, 0.01155727f, -0.02045832f, -0.00572188f, 0.03098542f, 0.00052196f, -0.01311882f, 
    -0.05635844f, 0.02273742f, -0.04753380f, 0.01755808f, -0.01290058f, 0.03283175f, 0.02464917f, -0.03178820f, 
    -0.01137717f, -0.03715070f, -0.01265089f, -0.03346388f, -0.04954509f, -0.04135473f, 0.01375687f, 0.01297788f, 
    -0.00261241f, -0.00255296f, 0.03197566f, 0.00445159f, 0.03654927f, -0.05236793f, -0.05170096f, -0.01112986f, 
    -0.03792365f, 0.00566460f, 0.01821495f, -0.03946658f, -0.03889021f, -0.01745220f, 0.02638769f, -0.05478460f, 
    -0.01791384f, 0.03325242f, 0.05084468f, -0.02220620f, 0.00671291f, -0.00766315f, 0.03109740f, 0.03447801f, 
    0.02288988f, -0.02521009f, 0.01302102f, -0.01303074f, 0.00160216f, -0.03138914f, -0.04263744f, -0.04389806f, 
    0.04063547f, -0.02308474f, -0.05004450f, -0.03170693f, 0.03109270f, -0.05306802f, -0.02811526f, -0.01958383f, 
    0.02126061f, -0.03733809f, 0.01755252f, -0.02619194f, -0.04309332f, -0.00775842f, 0.03074076f, -0.05636719f, 
    0.00566794f, 0.00626856f, -0.01921327f, -0.00595902f, 0.03153394f, -0.03048762f, -0.04070059f, -0.03558129f, 
    -0.03376468f, 0.02997504f, -0.04013308f, -0.01364327f, 0.03017011f, 0.03696398f, 0.02546094f, -0.05116275f, 
    -0.04346039f, -0.05223317f, -0.04888644f, 0.00965624f, 0.02807786f, 0.02742163f, 0.03660331f, 0.00580112f, 
    -0.01552517f, -0.03358374f, -0.03347008f, -0.00238024f, 0.02583295f, -0.04326199f, 0.03391468f, 0.01903923f, 
    -0.02090755f, 0.00764572f, 0.02872046f, 0.01698259f, 0.01589870f, -0.01650592f, -0.04096470f, -0.02705633f, 
    0.00522545f, -0.02005793f, -0.00911552f, 0.03045237f, -0.00980986f, -0.03809419f, 0.03184147f, -0.04790642f, 
    0.03668695f, -0.05430900f, 0.03817603f, -0.02217135f, -0.04753928f, -0.02644875f, 0.01906274f, -0.03333296f, 
    0.01548901f, 0.02004961f, 0.00976711f, -0.03521599f, -0.04155907f, 0.02334589f, 0.03015499f, -0.03863247f, 
    -0.04473754f, -0.01848310f, -0.01623302f, 0.00367050f, 0.02898830f, 0.00408187f, 0.01092048f, -0.03827821f, 
    0.02187635f, -0.03741132f, 0.02805879f, 0.04350844f, -0.03910376f, 0.02524703f, 0.02735502f, 0.04939520f, 
    -0.05573278f, 0.03039465f, -0.05098991f, -0.02520140f, -0.00939432f, -0.00866117f, -0.03013737f, 0.03504580f, 
    -0.04604211f, -0.05183196f, 0.02450177f, -0.05281169f, 0.00554131f, -0.04218527f, 0.01630556f, 0.00310964f, 
    -0.00736290f, -0.03019624f, -0.02954204f, -0.03878429f, 0.01737631f, -0.02994402f, -0.03629012f, -0.03027175f, 
    -0.04133023f, 0.01534001f, -0.01716617f, -0.05314282f, -0.04470777f, 0.03275689f, -0.05257639f, -0.05248661f, 
    0.03802995f, 0.03285770f, -0.03987357f, -0.01608222f, -0.02290317f, -0.04040544f, -0.00629030f, 0.02731119f, 
    0.03756559f, -0.00827900f, -0.01495712f, 0.03022689f, -0.03038149f, -0.00442995f, -0.01923185f, -0.03262174f, 
    0.02361822f, -0.04161724f, 0.00351977f, -0.05314183f, 0.01580785f, -0.05500762f, 0.04082395f, -0.03639515f, 
    -0.00299673f, -0.01642334f, -0.02187028f, -0.02008311f, -0.02229664f, 0.01275337f, -0.00975197f, -0.03989488f, 
    -0.02488779f, -0.00305697f, 0.03133301f, 0.03998382f, 0.03669820f, -0.00690293f, 0.01610759f, 0.02168603f, 
    -0.02849347f, 0.00081478f, -0.01248191f, -0.04714341f, -0.03664026f, 0.03940747f, 0.03975390f, 0.03937553f, 
    -0.05163588f, -0.02166062f, 0.02885049f, -0.05283117f, -0.04988482f, 0.03365793f, -0.03940054f, 0.01387060f, 
    0.03233226f, -0.00523495f, 0.01794049f, 0.03113524f, 0.02070776f, -0.03948297f, -0.05218247f, 0.00856504f, 
    -0.03222504f, 0.01332613f, -0.05487663f, -0.01126250f, 0.03383887f, 0.02183465f, -0.03917955f, -0.03339359f, 
    -0.01180068f, -0.04425727f, 0.03987995f, -0.05952543f, -0.01754160f, -0.05044948f, 0.03401501f, 0.02351671f, 
    -0.04367454f, -0.04031664f, -0.02831288f, -0.03393065f, -0.03466107f, 0.00413730f, -0.00599017f, 0.02170279f, 
    -0.05183966f, -0.01533041f, 0.00638971f, -0.04991367f, -0.03773172f, 0.02006508f, -0.04784736f, -0.00859597f, 
    0.02149150f, 0.00912200f, -0.05168808f, -0.03795728f, -0.01057311f, -0.05903181f, -0.04607804f, 0.02798630f, 
    -0.02631267f, -0.02588455f, -0.02898849f, -0.05409142f, -0.02536551f, -0.00844607f, -0.02302196f, -0.00549501f, 
    -0.05831307f, 0.00408614f, -0.01409166f, -0.01306121f, -0.04845546f, -0.02736064f, 0.00045762f, -0.00593341f, 
    0.04341578f, -0.03981635f, 0.01655663f, 0.01687462f, -0.03844270f, -0.01415371f, -0.05242518f, -0.02463461f, 
    0.01701710f, 0.00207562f, 0.02870539f, -0.00253219f, -0.02913176f, -0.01561156f, 0.02618687f, -0.05131104f, 
    0.01438205f, -0.04617219f, 0.02478280f, -0.01409655f, 0.03429651f, 0.02459943f, -0.02605048f, 0.04071430f, 
    -0.01142398f, -0.01091062f, 0.01999171f, 0.00759002f, -0.02517441f, 0.00465374f, -0.01719456f, 0.00216742f, 
    -0.00589578f, -0.01373604f, 0.01550433f, 0.03037391f, -0.00049535f, -0.00375786f, -0.00122580f, 0.01029041f, 
    -0.03207116f, -0.05290149f, -0.03002353f, -0.01645388f, -0.00559624f, 0.03909984f, 0.01998284f, -0.01936536f, 
    -0.01483493f, 0.02074408f, 0.02230184f, -0.02636379f, -0.04141081f, 0.01399633f, 0.01361895f, 0.02475222f, 
    -0.03934541f, 0.01342696f, -0.05146826f, 0.01054628f, 0.01291831f, -0.01946490f, -0.03411903f, -0.04785714f, 
    0.01231275f, -0.03522100f, -0.01973540f, 0.00608316f, 0.01590663f, 0.00618643f, 0.00567676f, -0.01602379f, 
    -0.05514562f, 0.03792487f, -0.05434538f, 0.03466779f, 0.01975382f, -0.02270585f, 0.00350610f, 0.00944370f, 
    -0.02248488f, -0.01677288f, 0.01909138f, -0.01896097f, 0.03015081f, 0.04012408f, 0.02506091f, 0.04113438f, 
    -0.02776374f, -0.05457353f, -0.02587752f, -0.05821049f, 0.01435345f, 0.01794460f, -0.01297621f, 0.01014044f, 
    -0.03456445f, -0.05854094f, -0.00113952f, -0.00985237f, -0.01570005f, -0.01598457f, 0.00777749f, -0.02514548f, 
    -0.00734077f, -0.01705728f, -0.02776556f, 0.01503331f, -0.04681790f, -0.05000674f, 0.03611843f, -0.03006629f, 
    -0.02797974f, -0.00861486f, 0.01378602f, 0.00386586f, 0.02766334f, -0.03990468f, -0.02170528f, -0.03819314f, 
    -0.02004746f, -0.04183096f, -0.04427460f, -0.05905798f, 0.01512668f, 0.02132964f, 0.01961875f, -0.06023457f, 
    0.03827731f, 0.03136605f, -0.03480767f, 0.02127041f, 0.04249664f, -0.04537823f, -0.03213410f, -0.00531513f, 
    0.01020601f, -0.00039878f, 0.03888613f, -0.01777056f, 0.03565002f, -0.01110433f, 0.03836007f, -0.03591752f, 
    -0.05216838f, -0.04947001f, -0.04558036f, 0.01177885f, -0.02457591f, 0.00186628f, 0.02089279f, -0.02992982f, 
    0.02721424f, 0.00297312f, -0.03903602f, -0.01540254f, -0.01098474f, -0.01554388f, 0.01042064f, -0.02277835f, 
    0.03278287f, 0.00895535f, -0.04137498f, -0.00488597f, 0.03430875f, -0.03958955f, 0.01564825f, -0.03701303f, 
    -0.01241245f, -0.05691593f, -0.01423280f, 0.00551273f, 0.00975868f, 0.04111202f, -0.03290876f, 0.03011082f, 
    -0.03720164f, 0.02226695f, 0.02224920f, 0.00528765f, 0.01294430f, -0.05645904f, -0.04236520f, 0.00374910f, 
    0.01132402f, -0.01008338f, 0.00143307f, 0.00446035f, -0.05837402f, 0.00836793f, 0.04055793f, 0.00826105f, 
    -0.01875665f, -0.05118461f, 0.02322797f, -0.05603448f, 0.01477165f, -0.00612580f, 0.02377287f, -0.02665381f, 
    0.01225424f, -0.04265146f, -0.04202704f, -0.00777401f, -0.05729422f, -0.01207489f, 0.02292806f, 0.01898488f, 
    -0.01291376f, -0.00140174f, 0.03985712f, 0.03019327f, -0.03930513f, 0.02283799f, 0.01925307f, -0.03582295f, 
    -0.00862166f, -0.04888321f, -0.01061588f, 0.00608372f, 0.00738496f, 0.00940776f, 0.01461245f, 0.02009795f, 
    -0.02219038f, -0.00653196f, -0.05222043f, 0.03185581f, 0.00448493f, -0.04511122f, 0.02545691f, -0.01287642f, 
    0.03561706f, 0.03399643f, 0.03397603f, 0.02779197f, 0.02888741f, -0.00223422f, -0.02813173f, -0.02134807f, 
    0.01336734f, 0.00685480f, 0.03533186f, -0.03633874f, -0.01947806f, -0.04749822f, 0.00522957f, -0.02829067f, 
    -0.00646638f, -0.00801129f, 0.00145044f, -0.01430021f, -0.01699531f, 0.02032489f, -0.01490248f, 0.02494143f, 
    0.01439434f, -0.01001044f, -0.02703739f, 0.03418013f, -0.02439263f, -0.02949725f, 0.00713864f, 0.01792796f, 
    -0.03753416f, 0.02714793f, -0.01457415f, -0.02523706f, 0.00660693f, 0.00558259f, 0.00772564f, -0.00074620f, 
    -0.04840792f, -0.04954829f, -0.02140404f, -0.00078805f, -0.03582744f, -0.01070990f, -0.05349945f, -0.03683678f, 
    0.32656285f, 0.08943108f, -0.01623336f, -0.01812310f, -0.03374773f, -0.09737651f, -0.01176613f, 0.19525753f, 
    0.00042279f, 0.05389404f, 0.09838624f, 0.01886230f, -0.10206617f, -0.10829249f, -0.00876238f, 0.05390977f, 
    -0.00216985f, -0.07733077f, -0.01926448f, -0.08490817f, 0.07915386f, -0.06791108f, 0.06194491f, -0.07866019f, 
    -0.08799978f, 0.15300667f, 0.05291691f, 0.02674936f, 0.10155763f, -0.12069175f, -0.09089604f, 0.01876786f, 
    -0.00917979f, 0.04094159f, 0.10693412f, -0.03605472f, 0.14201628f, 0.07662471f, 0.04995447f, 0.19165578f, 
    0.11170329f, 0.09096739f, -0.08088173f, -0.08492100f, -0.04601296f, -0.01782098f, 0.03048302f, 0.25079086f, 
    0.22435664f, 0.05790205f, -0.01156270f, 0.10984083f, -0.12858869f, -0.06413996f, -0.14582719f, 0.04132141f, 
    0.03709928f, -0.02951410f, -0.07183637f, -0.06210009f, 0.20027088f, 0.22162654f, -0.05577510f, 0.21852161f, 
    -0.05422956f, 0.07615700f, -0.04615673f, -0.04394639f, -0.07012325f, -0.13551874f, 0.05276692f, -0.00317580f, 
    0.14330007f, 0.10429461f, -0.09175304f, -0.30191657f, 0.00498247f, -0.03920543f, -0.05730730f, -0.08237629f, 
    -0.02529120f, 0.09534644f, -0.02552170f, -0.02147244f, -0.03626967f, -0.06967879f, -0.16212799f, -0.01183119f, 
    0.05278896f, -0.03914436f, 0.02357311f, -0.02230213f, 0.04741982f, -0.00537984f, -0.04681712f, -0.08396930f, 
    -0.03359014f, 0.08731811f, 0.10462655f, 0.00370232f, -0.03680967f, -0.06065305f, -0.03294432f, 0.04626883f, 
    0.01934960f, -0.01519274f, 0.02288475f, 0.11219463f, -0.00673123f, 0.07553525f, 0.13996539f, 0.08145330f, 
    -0.08792281f, 0.00743942f, -0.06292403f, 0.02631919f, -0.02402007f, 0.09140014f, 0.00252078f, -0.05256295f, 
    0.32294485f, -0.00719658f, -0.10774548f, -0.03889262f, 0.07259275f, 0.00079415f, -0.07827467f, 0.02672571f, 
    0.07883004f, 0.06536759f, 0.13772547f, -0.05234012f, -0.03520911f, 0.15216203f, 0.07700156f, -0.13895564f, 
    0.08661625f, 0.03659951f, -0.08771624f, -0.05486135f, 0.01010033f, 0.09345312f, 0.04037390f, -0.11685484f, 
    0.34868264f, -0.03228846f, -0.03917205f, 0.16337287f, -0.05202474f, -0.03993422f, -0.03324123f, 0.09793955f, 
    -0.00881748f, -0.06967678f, 0.02765391f, -0.00146725f, 0.17568280f, 0.07224362f, -0.01521817f, -0.07460307f, 
    0.06590944f, -0.00445637f, -0.13665339f, -0.05927912f, -0.06785128f, 0.02163896f, -0.06886213f, -0.05827279f, 
    0.13332689f, -0.09749083f, 0.07308456f, 0.21479639f, -0.08067366f, 0.05985563f, -0.02057156f, -0.00233893f, 
    0.03980019f, 0.01823949f, -0.00120188f, 0.05376952f, 0.07498841f, 0.09003394f, 0.07059860f, -0.02190422f, 
    -0.06737541f, -0.04428929f, 0.05515504f, 0.03476568f, 0.05147911f, 0.01343227f, -0.11012913f, 0.04626856f, 
    -0.08818946f, 0.00984183f, 0.08786289f, -0.00239402f, 0.15155932f, 0.00162217f, -0.01281886f, -0.07349779f, 
    0.01221594f, 0.00923326f, -0.08146126f, 0.03849117f, 0.21830504f, -0.20904425f, -0.09685661f, 0.10185766f, 
    0.05244745f, -0.01409759f, -0.04408316f, 0.08214395f, -0.08663318f, -0.09005239f, 0.03532213f, -0.01284047f, 
    0.04815753f, 0.09318052f, 0.09516183f, -0.09807308f, -0.00752772f, -0.01795653f, 0.07541838f, -0.00781876f, 
    -0.02481728f, 0.03878653f, -0.02201978f, -0.05766469f, 0.15093680f, -0.16997871f, -0.06220401f, 0.17459843f, 
    -0.15258071f, -0.06917045f, 0.08956739f, -0.08919797f, 0.01740781f, -0.02959623f, -0.00611220f, 0.03056539f, 
    0.15626019f, 0.14909759f, -0.06508637f, -0.06180797f, -0.00702278f, 0.14861143f, -0.13344544f, 0.14164045f, 
    0.09599221f, 0.04324084f, -0.00178374f, 0.03070655f, -0.03579807f, 0.19794182f, 0.06429336f, 0.12911072f, 
    0.03886824f, 0.04169722f, -0.10252346f, -0.07681313f, 0.03339012f, -0.01200945f, -0.10087487f, -0.12088652f, 
    0.12202866f, -0.09390518f, 0.03276902f, 0.26093447f, 0.02999760f, 0.01137653f, 0.03551151f, -0.04957661f, 
    -0.00349560f, 0.03026801f, -0.02646930f, -0.06074202f, 0.26758981f, 0.00811178f, -0.01541956f, 0.07687270f, 
    -0.06420752f, -0.07640288f, -0.13686334f, -0.01183114f, -0.06155718f, 0.00735361f, -0.05355666f, -0.01765040f, 
    0.03553317f, 0.01360054f, -0.29876766f, 0.02551496f, 0.01221327f, -0.06203585f, 0.07477722f, -0.04134622f, 
    -0.03118822f, 0.02432961f, 0.06647332f, -0.11547176f, -0.09030733f, -0.01295741f, 0.11977210f, 0.17486000f, 
    0.01686345f, 0.03521548f, 0.13079317f, -0.15142804f, -0.08985703f, 0.03571057f, -0.02006041f, 0.05256195f, 
    0.02027336f, 0.08272174f, 0.12001577f, -0.08772860f, 0.00529613f, 0.02124184f, -0.06911010f, 0.02112727f, 
    -0.00466785f, -0.06482821f, 0.03500445f, 0.07642984f, 0.01698031f, 0.02476534f, -0.20699586f, 0.16818410f, 
    0.07984147f, -0.06390749f, 0.00558194f, 0.07923502f, 0.05241881f, 0.03906899f, -0.05802860f, -0.04475415f, 
    0.04376255f, -0.06225847f, 0.07289488f, 0.05282261f, 0.00225548f, -0.05734062f, -0.22035997f, -0.04269147f, 
    -0.02146328f, 0.06229280f, 0.07302787f, -0.01787805f, -0.34926578f, 0.02660345f, 0.04278100f, -0.03543520f, 
    -0.06031854f, 0.02606818f, -0.03477097f, 0.13844080f, 0.01987605f, -0.04540224f, 0.02613845f, 0.01728280f, 
    0.18993722f, -0.16732359f, -0.05479618f, 0.11649007f, -0.14602266f, -0.00596413f, 0.13088560f, 0.01778103f, 
    -0.00124236f, 0.00727017f, 0.02678387f, -0.03249058f, 0.32889339f, 0.00829899f, -0.16844486f, 0.16983831f, 
    -0.12628108f, -0.03390208f, 0.08612621f, 0.05727284f, 0.00127198f, 0.07378252f, -0.04365220f, 0.03122041f, 
    0.00641938f, -0.04682672f, 0.03667555f, 0.02028099f, -0.04570997f, 0.02613283f, -0.01744069f, -0.04122591f, 
    0.00451923f, -0.04154475f, -0.05438858f, -0.00370256f, -0.03956891f, 0.01974374f, -0.05785521f, -0.01348041f, 
    0.03115964f, -0.01412604f, -0.03323507f, -0.03207948f, -0.05579813f, -0.02429531f, -0.00374671f, 0.01255926f, 
    -0.01972395f, -0.04831971f, 0.01234539f, 0.03404164f, 0.03065557f, 0.01997828f, -0.05554887f, -0.01584141f, 
    0.03978685f, -0.01231951f, -0.00915504f, -0.05077288f, 0.01535708f, -0.02395309f, -0.04326455f, -0.03337019f, 
    0.02211067f, -0.01519476f, 0.02433649f, -0.03015350f, -0.01271119f, -0.01940566f, 0.03957786f, 0.03095890f, 
    -0.05808407f, 0.00528232f, 0.01237390f, -0.01765464f, 0.03760324f, -0.00628830f, -0.04026814f, -0.00164662f, 
    -0.01730002f, -0.01447725f, -0.04731688f, 0.01545801f, -0.00084068f, 0.03157297f, -0.04482835f, 0.00867255f, 
    0.03030979f, 0.02009899f, 0.01192868f, -0.00418285f, 0.00526112f, -0.04349451f, -0.00858177f, 0.01259754f, 
    0.00791360f, -0.01477304f, 0.02643584f, 0.02715364f, 0.03460677f, 0.00882174f, -0.03389274f, 0.02325525f, 
    -0.05668566f, 0.00798736f, 0.01726343f, 0.03921143f, -0.03437940f, -0.01907185f, 0.00103381f, -0.01390194f, 
    0.04049022f, 0.03353367f, 0.01639470f, 0.02034239f, -0.04812127f, -0.05081156f, -0.01862219f, -0.00602223f, 
    -0.03876678f, -0.03848800f, 0.00083772f, 0.02420727f, -0.04179854f, 0.04318465f, 0.00629038f, 0.00779569f, 
    -0.00643150f, -0.01252480f, -0.00628368f, -0.01899323f, -0.03835911f, -0.00435835f, -0.00978476f, -0.05713126f, 
    -0.01506630f, -0.00289074f, 0.01257925f, 0.00256346f, 0.04027513f, 0.00068979f, -0.03958119f, 0.01541010f, 
    0.02884218f, 0.02493401f, -0.05232517f, -0.03079288f, -0.03030727f, -0.03681744f, -0.00684929f, 0.01507466f, 
    -0.05118665f, 0.02404056f, -0.01169887f, 0.03177439f, -0.01513147f, -0.01007198f, -0.02581724f, 0.03041279f, 
    0.01780503f, -0.02369035f, -0.00756042f, 0.01993014f, 0.02911228f, -0.02639116f, -0.00840006f, 0.03960669f, 
    -0.00631727f, -0.02904454f, 0.03777529f, 0.00825170f, 0.02080496f, -0.00742476f, -0.05062157f, -0.01554968f, 
    0.03388943f, 0.02715135f, -0.01998803f, -0.05240676f, 0.04523166f, 0.02994703f, -0.05889948f, -0.03571274f, 
    -0.02776616f, 0.01234663f, 0.04413411f, -0.04180183f, 0.02525467f, 0.03042106f, 0.02451653f, 0.03189828f, 
    -0.05016465f, 0.02852185f, -0.01240954f, -0.01209439f, -0.04910859f, -0.01844105f, 0.01401058f, -0.02599007f, 
    0.01722055f, 0.01231485f, 0.01109266f, -0.03048288f, -0.01344616f, 0.00077248f, -0.01452812f, 0.00348560f, 
    -0.02381979f, -0.01282835f, -0.04700971f, 0.03486953f, 0.01823550f, -0.04077675f, -0.04251453f, 0.01987180f, 
    -0.00152391f, 0.01608605f, -0.02679591f, 0.01475559f, -0.04702577f, -0.03394086f, -0.05917902f, 0.03299988f, 
    0.01499845f, 0.01896416f, 0.02802843f, -0.04891305f, -0.05247234f, -0.00483711f, -0.01494602f, -0.01482837f, 
    -0.04281392f, 0.00759337f, 0.03578251f, -0.03490103f, 0.02693382f, -0.05465555f, -0.02728910f, -0.01728618f, 
    0.01275499f, -0.05497013f, 0.02235474f, -0.04225251f, 0.02815491f, 0.03647311f, -0.00056938f, 0.04016643f, 
    -0.00352729f, -0.04904423f, -0.04311611f, -0.00726957f, 0.02725982f, -0.01195515f, -0.04529310f, -0.00079852f, 
    0.03955234f, -0.04125351f, 0.00570948f, 0.00928732f, 0.02200600f, -0.01209672f, 0.00467552f, -0.00752156f, 
    -0.03126505f, 0.03037061f, 0.02838822f, -0.02504934f, 0.01000485f, 0.00665207f, 0.01074908f, 0.01149660f, 
    0.03282336f, 0.03174492f, -0.02609658f, 0.01068278f, -0.05417006f, -0.02594874f, 0.04032078f, -0.04271739f, 
    -0.01824484f, 0.02083813f, 0.01034200f, -0.01229504f, 0.03892649f, -0.05120533f, 0.00598749f, 0.00304003f, 
    0.00968383f, 0.03747990f, -0.04871814f, -0.04453911f, -0.00452481f, -0.02404487f, -0.01839493f, 0.03706488f, 
    0.02558836f, 0.01169142f, -0.03557263f, -0.02314125f, -0.05270497f, 0.00413110f, -0.00721410f, -0.04061868f, 
    0.01663058f, 0.03016514f, 0.01810774f, 0.03411597f, -0.04560376f, 0.00772925f, -0.01013380f, 0.00186952f, 
    -0.00508673f, 0.02506046f, 0.03118546f, 0.03462959f, -0.04969101f, -0.01561207f, -0.04576193f, -0.04840707f, 
    0.01452873f, 0.02519885f, -0.02715805f, 0.02916930f, -0.02399256f, 0.00848478f, -0.02560218f, 0.01161584f, 
    -0.03555447f, 0.02217775f, -0.05069735f, -0.00183044f, -0.02808411f, -0.05585438f, -0.03259145f, 0.00589535f, 
    0.03527429f, -0.01059629f, -0.04515531f, -0.00890861f, 0.03739291f, -0.02691677f, -0.05518067f, 0.01838805f, 
    0.03282072f, -0.04356670f, -0.02083818f, -0.05253878f, 0.01433761f, 0.01504177f, -0.05583728f, 0.04251160f, 
    0.00435831f, 0.00443144f, 0.01759163f, 0.00024130f, -0.04316205f, -0.05018519f, -0.04261602f, 0.02955941f, 
    0.02013870f, -0.05725719f, -0.03955036f, -0.05606080f, -0.02327566f, -0.05411601f, 0.01215027f, 0.01558202f, 
    -0.00613610f, -0.05523447f, 0.02670326f, 0.02638586f, -0.03555281f, -0.05100406f, -0.04216908f, 0.02066159f, 
    0.03055124f, -0.03998788f, -0.01871920f, 0.04061990f, 0.01683022f, -0.03553925f, -0.03622248f, 0.03833193f, 
    -0.04049864f, -0.02949663f, -0.05542347f, -0.05014633f, -0.00287269f, -0.04871716f, -0.05449016f, -0.01981937f, 
    0.01482188f, -0.00019367f, 0.03037086f, 0.03728460f, -0.03327462f, 0.01863049f, 0.00522960f, -0.03523759f, 
    -0.02775063f, -0.04878675f, -0.05011436f, 0.00700861f, -0.04920462f, 0.03131144f, -0.01673890f, -0.05172639f, 
    0.05608597f, 0.08363330f, 0.00383748f, -0.08657406f, 0.01886485f, 0.09931681f, 0.07265251f, 0.00257851f, 
    0.19102414f, 0.05810037f, -0.03621774f, 0.08159886f, 0.18534258f, -0.00759039f, -0.11339033f, -0.03154233f, 
    0.07632729f, -0.07829177f, 0.09724355f, 0.10609917f, -0.03712937f, 0.04445809f, 0.04222700f, 0.11137371f, 
    0.10349323f, -0.00654672f, 0.12729837f, 0.00033844f, -0.06978577f, -0.07728705f, -0.20343676f, -0.04016647f, 
    0.07053640f, -0.04617849f, -0.01524823f, -0.02793490f, 0.08666810f, -0.15258162f, -0.03433071f, -0.05645873f, 
    -0.02606065f, 0.02992753f, -0.01047989f, -0.12242936f, 0.03723661f, 0.06013124f, 0.04876975f, -0.08903471f, 
    -0.39891982f, 0.00767284f, 0.12902889f, -0.12823156f, 0.13652632f, 0.03510897f, 0.01178054f, -0.06269432f, 
    0.05796422f, 0.10433493f, 0.07882863f, -0.06811383f, -0.18220775f, -0.19791548f, -0.30830032f, 0.03603725f, 
    0.04665840f, 0.00700617f, -0.01143402f, -0.04956632f, 0.03800848f, 0.00647182f, 0.00179401f, 0.03021939f, 
    0.17542991f, 0.11456105f, -0.03485480f, -0.14959493f, -0.04846773f, 0.07977240f, -0.03221244f, 0.10598549f, 
    -0.05250522f, 0.00486602f, 0.02898872f, -0.02435583f, 0.31854430f, 0.15033633f, -0.04386880f, -0.23857567f, 
    0.07273442f, -0.03034325f, 0.03171226f, 0.01978949f, -0.00408950f, 0.09900276f, 0.07740539f, 0.00588157f, 
    -0.03354176f, -0.09074696f, -0.12782013f, 0.01648196f, 0.08405007f, 0.04205000f, -0.01219070f, -0.07963806f, 
    0.15570650f, 0.09194492f, -0.12573421f, -0.09945747f, -0.10880320f, 0.17033193f, -0.16544242f, -0.13264120f, 
    -0.01582784f, 0.07390908f, 0.03198541f, 0.04412352f, 0.04069118f, 0.04817427f, -0.08083045f, 0.06356075f, 
    -0.13759260f, -0.11156353f, 0.10552363f, 0.07441971f, 0.04387833f, 0.02563177f, 0.08273182f, -0.01153532f, 
    -0.03453372f, -0.00065147f, 0.01985840f, 0.09479931f, 0.29300991f, -0.07730041f, -0.02987956f, 0.04872406f, 
    -0.06607895f, -0.02191247f, 0.00241440f, 0.04062597f, 0.09862539f, 0.03999806f, -0.02131494f, 0.08875968f, 
    -0.10578877f, 0.31649375f, 0.01200076f, -0.17531285f, 0.14984386f, -0.05652856f, -0.02833545f, 0.04210310f, 
    -0.04331347f, 0.02844661f, 0.02801872f, 0.10475983f, 0.26668862f, 0.27074808f, 0.01106487f, 0.23900917f, 
    0.00012804f, 0.01005479f, 0.01598255f, -0.03619349f, 0.00098867f, 0.02213646f, 0.09651025f, -0.02640099f, 
    -0.12457545f, 0.10666786f, 0.16072631f, 0.03209108f, 0.12141690f, 0.09679590f, -0.04126170f, -0.02305145f, 
    0.01375538f, -0.03234498f, 0.00568803f, 0.10815755f, -0.15374750f, -0.14151137f, -0.11763646f, -0.07786568f, 
    -0.01136957f, 0.08810942f, 0.01898128f, -0.00282008f, -0.17608264f, 0.01443995f, 0.00972533f, 0.03833095f, 
    0.46922088f, 0.02242433f, -0.05141170f, -0.00431912f, 0.06925742f, 0.08476808f, 0.03998538f, 0.04877124f, 
    0.01347830f, 0.03671928f, 0.07907627f, -0.03899923f, 0.10020310f, 0.21835294f, 0.07444752f, -0.08414403f, 
    0.06319456f, 0.05384528f, 0.10573231f, 0.00188018f, -0.04219531f, -0.06872421f, -0.02911718f, 0.02741291f, 
    -0.07954407f, -0.04093559f, 0.05939958f, -0.14643402f, 0.10121141f, 0.11164446f, -0.06851775f, 0.08128074f, 
    0.05159500f, 0.06673361f, 0.02119775f, -0.04707691f, 0.04556793f, 0.08411168f, 0.18824704f, 0.01323201f, 
    0.07603996f, 0.05638367f, -0.04631630f, 0.01716922f, 0.08625769f, 0.04645653f, 0.01680918f, -0.04732033f, 
    -0.00050725f, -0.07364503f, -0.02934958f, -0.03710779f, 0.15394311f, -0.07303570f, 0.03353126f, -0.06621949f, 
    -0.00495518f, 0.05865480f, 0.02666187f, 0.11848579f, -0.02096376f, 0.04230684f, -0.03801221f, 0.02112470f, 
    0.09407014f, -0.10765306f, -0.03910782f, 0.13543849f, -0.03599659f, -0.04258090f, -0.01699145f, 0.08169533f, 
    -0.08945957f, -0.08355993f, 0.14450340f, -0.25269395f, 0.01862566f, 0.01759775f, -0.13241594f, -0.03768194f, 
    -0.00531360f, 0.11636283f, 0.05693879f, 0.01672512f, 0.44419000f, 0.16770773f, 0.07803516f, 0.08584636f, 
    -0.03059404f, 0.09792920f, 0.00726359f, 0.00585998f, -0.00561399f, 0.04403001f, 0.05356034f, 0.04921504f, 
    -0.12314206f, 0.11199973f, 0.05552927f, -0.10331891f, -0.01040773f, -0.07837000f, 0.10857998f, 0.05089460f, 
    -0.05940370f, 0.04566774f, 0.05035309f, -0.10126853f, 0.47919205f, -0.16832775f, 0.06436292f, 0.06455620f, 
    -0.02277516f, -0.05610234f, 0.00108540f, -0.06029762f, -0.00764673f, -0.04289410f, 0.05029884f, 0.00280899f, 
    0.00783139f, -0.38224870f, -0.09655932f, 0.08965715f, 0.03422025f, 0.11833952f, -0.03328272f, 0.01724280f, 
    -0.03234978f, 0.04341116f, 0.13054752f, 0.06602942f, -0.02346061f, 0.05650521f, -0.02868074f, -0.16925782f, 
    0.12794471f, 0.08114836f, 0.03861052f, 0.10053432f, -0.03290486f, 0.06460010f, -0.02518933f, 0.17998283f, 
    0.19803520f, -0.12375139f, -0.22702038f, -0.11572082f, 0.10807569f, 0.08800658f, 0.15472847f, -0.04514441f, 
    0.09596284f, -0.05219043f, -0.00342753f, -0.05763619f, -0.24691646f, -0.35083756f, -0.05864842f, 0.13226011f, 
    -0.06511252f, 0.00082181f, 0.02806189f, 0.02782543f, -0.06743398f, 0.08732086f, 0.01686532f, 0.05252608f, 
    0.12859814f, 0.13840251f, 0.08051018f, -0.05023771f, -0.09664133f, -0.07111865f, -0.01088031f, -0.03090053f, 
    -0.05441492f, 0.13463888f, -0.04352304f, 0.07106300f, 0.08688831f, -0.05790320f, 0.09292393f, 0.08799536f, 
    0.01633877f, 0.05507937f, -0.08881978f, 0.02124492f, -0.09383304f, 0.05256775f, 0.02959305f, -0.03337330f, 
    0.02462591f, -0.05498649f, 0.03124946f, 0.03429911f, 0.01227287f, 0.02448221f, 0.02437574f, 0.02586826f, 
    -0.02411083f, 0.02823882f, -0.01122875f, 0.02950204f, 0.00773745f, 0.01919002f, -0.01703147f, 0.01375576f, 
    0.02086541f, 0.01892069f, -0.03338170f, -0.01933476f, 0.00594710f, -0.03045343f, 0.00763514f, 0.02572265f, 
    -0.01453100f, -0.05030397f, -0.01286108f, -0.00503982f, -0.02313984f, 0.03904027f, 0.04515998f, -0.01756791f, 
    0.01978738f, 0.01837933f, -0.01753684f, -0.02745122f, -0.02174121f, -0.03991872f, -0.01673413f, 0.02597050f, 
    -0.01211482f, 0.01405656f, -0.00166612f, -0.02521768f, -0.00490173f, 0.01488991f, 0.00855556f, -0.03751798f, 
    0.02856125f, -0.03791308f, -0.03520570f, -0.02379738f, -0.00134782f, -0.00941957f, -0.05067069f, 0.01839579f, 
    -0.01793127f, -0.00553373f, -0.01295284f, 0.00410765f, -0.04437757f, -0.00466334f, -0.04755664f, -0.01485894f, 
    0.02606354f, -0.02274417f, 0.02314909f, -0.03001913f, 0.03806709f, -0.05009158f, 0.03058327f, 0.03299521f, 
    -0.02963557f, -0.05299941f, -0.02199323f, -0.01294995f, -0.03011971f, -0.01380852f, -0.04238292f, 0.02639499f, 
    -0.03159660f, 0.04213217f, -0.00811671f, 0.02063560f, 0.04448470f, 0.04028870f, -0.04819664f, -0.02619900f, 
    -0.01849189f, -0.00071363f, -0.01573065f, -0.03805469f, -0.05502941f, -0.02353718f, -0.02878444f, 0.00590184f, 
    -0.02210067f, 0.01730853f, 0.01169592f, -0.01178162f, 0.01727144f, 0.00016521f, -0.05419945f, 0.01234338f, 
    0.01088070f, -0.04256197f, 0.02755338f, 0.03624070f, 0.00924485f, -0.04215765f, -0.04054063f, -0.03876814f, 
    -0.05277660f, -0.02725700f, -0.00348508f, -0.01720387f, -0.04011113f, 0.02686205f, -0.02131694f, -0.04489495f, 
    0.00797622f, -0.03111569f, 0.01384655f, -0.04775739f, -0.05550104f, -0.03376875f, -0.03527175f, -0.04319240f, 
    -0.00500783f, -0.00426738f, -0.05225199f, -0.04557929f, -0.01978733f, -0.02888742f, 0.00892322f, 0.04672716f, 
    -0.03302553f, 0.03718240f, 0.03811682f, -0.03213786f, -0.02815738f, 0.02599198f, 0.04163512f, 0.00150699f, 
    0.00245238f, 0.02242921f, 0.02055606f, -0.04164417f, 0.02386909f, 0.02621311f, 0.03178990f, 0.04295214f, 
    0.02918194f, -0.03258039f, 0.02316726f, 0.04111973f, 0.00253823f, -0.01922166f, -0.03054208f, 0.04201459f, 
    -0.00709949f, -0.02626007f, -0.04225280f, -0.01450248f, -0.02925953f, -0.03385774f, 0.04138599f, -0.03036667f, 
    0.02858507f, 0.01357850f, 0.01546356f, 0.00160927f, -0.03866144f, -0.02343605f, -0.01583518f, -0.03408489f, 
    -0.03411060f, -0.00467504f, 0.03435717f, 0.00514129f, 0.00014518f, -0.02550535f, 0.05554066f, 0.03110694f, 
    0.00034741f, -0.05908443f, -0.01256136f, -0.02507975f, -0.00072812f, -0.05202738f, 0.00558233f, -0.01940501f, 
    0.03526897f, -0.05712343f, -0.02144869f, 0.03627304f, -0.03820056f, -0.03841169f, -0.03990242f, -0.03899202f, 
    0.01291050f, -0.05791423f, 0.04265580f, 0.04277800f, 0.01257154f, -0.02054935f, 0.00247081f, -0.04672658f, 
    -0.04357362f, -0.00829016f, -0.03229029f, -0.03804519f, 0.04202456f, -0.05726765f, 0.02054003f, 0.03180864f, 
    -0.05500856f, 0.00036982f, -0.02743376f, 0.03335546f, 0.02765388f, 0.00905193f, 0.01644095f, -0.03268857f, 
    0.02145107f, 0.03244730f, 0.03086752f, 0.04072581f, -0.02365149f, 0.02081080f, -0.04507415f, 0.03340174f, 
    -0.00447115f, 0.02661550f, -0.04413581f, -0.05778001f, 0.00652081f, -0.03066500f, 0.01268653f, 0.04091067f, 
    -0.02210684f, 0.04367059f, 0.03108462f, -0.02477313f, -0.00362556f, -0.05058495f, -0.01559793f, -0.02486155f, 
    0.00883200f, -0.00865558f, -0.03598651f, 0.03832224f, -0.03477709f, -0.04362648f, -0.01670201f, 0.01814918f, 
    0.04066993f, -0.05121154f, -0.01082301f, -0.04529987f, 0.00556228f, 0.03850136f, 0.01400897f, 0.02705097f, 
    -0.03013194f, 0.01896686f, -0.02043042f, 0.01350326f, 0.00797568f, 0.01827947f, -0.01966800f, 0.00756765f, 
    0.04505002f, -0.00928826f, -0.04155183f, -0.03188505f, -0.02693410f, 0.03966838f, -0.03013551f, -0.00976692f, 
    0.04108407f, -0.05297131f, -0.01913495f, -0.03883487f, 0.02917275f, 0.01386672f, -0.02429858f, 0.00649702f, 
    -0.03238560f, -0.05566107f, -0.05210481f, -0.02782807f, 0.00687642f, 0.02732136f, 0.02402207f, 0.00266150f, 
    -0.04673492f, -0.02511006f, -0.05528272f, -0.00561073f, -0.01168857f, 0.01074454f, -0.05590093f, 0.00809808f, 
    0.01690858f, 0.03507125f, 0.02158714f, -0.03980901f, -0.05278128f, 0.03360641f, 0.03948242f, -0.00075512f, 
    0.03713327f, -0.02906498f, -0.03113636f, -0.02328751f, -0.03765121f, 0.03508583f, -0.02728056f, -0.01383961f, 
    0.01382986f, 0.02390631f, -0.04349268f, -0.02300258f, -0.01757156f, -0.03633369f, -0.03674787f, 0.00781325f, 
    -0.05080472f, -0.02745572f, 0.03513434f, 0.01190713f, 0.01681173f, -0.02878283f, -0.05359409f, -0.02043076f, 
    0.01925105f, -0.02176498f, -0.03149384f, 0.01559025f, 0.01039342f, 0.00217939f, -0.03934914f, -0.02104601f, 
    -0.03836680f, 0.03903266f, -0.01418971f, 0.02229235f, 0.01319848f, 0.02424519f, -0.05553138f, 0.01790660f, 
    -0.01596706f, -0.05845978f, 0.01020773f, 0.02901920f, 0.00113848f, 0.05245703f, -0.00056587f, 0.01992955f, 
    -0.04514967f, -0.05479212f, -0.03827615f, -0.01438641f, 0.01926468f, 0.04011104f, 0.01929816f, -0.01815348f, 
    0.01094825f, -0.05374391f, -0.03368440f, 0.01083741f, -0.04437754f, -0.02728684f, -0.04453938f, 0.03052783f, 
    -0.01078864f, 0.03676448f, 0.00755420f, -0.00826345f, -0.05037671f, -0.05086391f, -0.02657839f, -0.00733275f, 
    -0.02765185f, -0.02512549f, 0.02989436f, -0.01263966f, 0.02794289f, -0.01745111f, -0.04864357f, -0.01447669f, 
    -0.01470829f, 0.03440170f, -0.01153858f, -0.02051429f, -0.05563051f, -0.05722311f, 0.04186280f, -0.02030964f, 
    0.01365444f, -0.00128196f, -0.02392873f, -0.05639829f, -0.00242118f, -0.02191916f, 0.00877423f, -0.00069114f, 
    -0.03101797f, -0.00946715f, -0.03841279f, 0.00600950f, 0.02861083f, -0.01490154f, -0.03474889f, 0.00570404f, 
    -0.04893034f, -0.05619441f, -0.00729673f, 0.01254585f, 0.02000839f, 0.03832303f, -0.00983712f, 0.03911921f, 
    -0.04473067f, -0.03905195f, 0.00021736f, -0.05490033f, 0.00928731f, -0.00458390f, -0.02047231f, 0.03456114f, 
    0.01182919f, -0.00097082f, 0.03258930f, 0.03417155f, -0.05400368f, -0.05093804f, -0.01626009f, -0.02992663f, 
    -0.01479264f, 0.04008603f, -0.00274199f, -0.04807205f, 0.02696876f, -0.04402699f, 0.03697210f, -0.01851306f, 
    -0.01887439f, 0.00306358f, 0.01036836f, -0.02827387f, 0.04326688f, 0.03321028f, -0.02498965f, -0.02290146f, 
    0.04010713f, -0.00715041f, -0.05393394f, 0.03294329f, -0.01271345f, 0.00405073f, -0.04920802f, -0.02391902f, 
    -0.00113513f, -0.01586225f, -0.01084904f, -0.01117839f, 0.04164717f, -0.03008985f, 0.02486958f, 0.01610383f, 
    0.03156234f, -0.00886136f, 0.03964521f, -0.00560057f, -0.00000631f, -0.02509650f, 0.01681011f, -0.02437900f, 
    -0.02245612f, -0.04363989f, -0.00635302f, -0.00502001f, -0.00461322f, -0.03698760f, -0.05211431f, -0.00083123f, 
    0.02673166f, 0.00209338f, -0.03715685f, -0.00725080f, -0.01070220f, -0.00981966f, 0.03287263f, 0.02974693f, 
    0.02088019f, 0.00666735f, -0.05319545f, 0.01401527f, -0.01265216f, 0.03219882f, -0.05024933f, 0.03731648f, 
    -0.02547177f, -0.04910454f, 0.00355959f, 0.00503700f, 0.03636635f, 0.01361604f, -0.04052391f, 0.01175155f, 
    -0.05601695f, -0.01912990f, -0.01158148f, -0.00523456f, 0.00476723f, -0.04085905f, -0.03904818f, -0.01887884f, 
    -0.00030134f, -0.02703525f, 0.03764024f, -0.00600508f, 0.03014651f, 0.03862837f, 0.03209417f, -0.03338087f, 
    -0.05136191f, 0.02468987f, -0.04733232f, -0.05584970f, -0.03034657f, 0.01488697f, 0.00095558f, -0.01356146f, 
    -0.02369971f, -0.00784873f, -0.02527362f, -0.05845718f, -0.00086705f, -0.04403503f, -0.05299320f, -0.01086397f, 
    0.00966373f, -0.04436281f, 0.04287237f, 0.02423455f, -0.00121746f, -0.04191898f, -0.04288900f, 0.02401112f, 
    0.02517022f, -0.02977691f, -0.03255881f, -0.00004720f, -0.04586548f, 0.02164068f, -0.03862721f, -0.00249739f, 
    0.01952786f, 0.01809359f, -0.05882183f, -0.01841362f, 0.03934171f, -0.01614362f, -0.03891054f, -0.04165173f, 
    -0.00897339f, 0.04280951f, 0.00428790f, -0.00904844f, -0.04953978f, 0.03076384f, 0.02451736f, -0.03500683f, 
    0.03876713f, -0.05787241f, 0.01361137f, 0.00248654f, 0.03625654f, -0.04705627f, -0.00987872f, 0.00844440f, 
    -0.02223402f, -0.05120166f, -0.02196081f, 0.01771712f, 0.01532508f, -0.00038503f, -0.02650577f, -0.02290382f, 
    -0.04895595f, -0.02229593f, -0.03780123f, -0.04582310f, -0.01084813f, -0.01055039f, -0.03083437f, -0.03990419f, 
    0.00694056f, -0.02938804f, -0.04141805f, -0.01178497f, -0.05629946f, -0.05572380f, 0.02900259f, -0.00604356f, 
    -0.05766281f, 0.00874432f, -0.00957454f, 0.00016917f, 0.03220581f, -0.01055509f, 0.03728725f, -0.04406423f, 
    -0.00037500f, -0.02135182f, -0.03167394f, -0.01221055f, 0.00488376f, 0.03290518f, 0.02273285f, -0.00744085f, 
    -0.01860440f, 0.02922152f, -0.04828585f, -0.05197805f, 0.01252237f, -0.03856248f, -0.03057694f, 0.03868747f, 
    0.01606452f, -0.01246701f, -0.03252319f, 0.01572685f, 0.03303670f, 0.03489171f, -0.04191192f, -0.00727783f, 
    -0.03903896f, -0.02259383f, -0.03640524f, -0.05707270f, -0.03163540f, 0.02007499f, -0.04297742f, -0.02339023f, 
    -0.02991918f, -0.00588763f, 0.01486905f, -0.00341052f, -0.04832024f, -0.01584957f, -0.05374725f, 0.02119685f, 
    -0.02910621f, 0.01731447f, 0.01717182f, 0.03295514f, -0.00503785f, 0.02977927f, 0.00921619f, 0.02864570f, 
    -0.01553030f, 0.01210376f, 0.01516638f, -0.00801664f, -0.05875254f, 0.00536357f, 0.01106648f, 0.03306194f, 
    -0.05126375f, 0.01589924f, -0.00059038f, -0.03681720f, 0.01512925f, 0.00565176f, 0.03646615f, -0.00214868f, 
    -0.00894865f, -0.04314764f, 0.02068643f, -0.01345460f, 0.03485452f, -0.04661338f, -0.00321820f, -0.04223388f, 
    0.02828685f, -0.03076021f, 0.02623270f, 0.00302267f, -0.02201379f, 0.00508194f, -0.04224716f, -0.05012182f, 
    -0.05607650f, -0.01325038f, -0.01425335f, -0.05554956f, -0.00044912f, -0.01808122f, 0.04276665f, -0.04560013f, 
    -0.02161581f, 0.00643918f, 0.03318035f, -0.02627994f, -0.05576292f, -0.00893729f, 0.02719839f, -0.00823808f, 
    0.03291992f, 0.03186877f, -0.00717057f, 0.00747207f, -0.01019906f, -0.04612162f, 0.02261420f, -0.03567864f, 
    -0.04219707f, 0.02489314f, 0.00599638f, -0.04790416f, 0.03847917f, -0.02654457f, 0.04211906f, 0.02350762f, 
    0.01113778f, 0.03380501f, 0.00850243f, -0.04947942f, -0.05768286f, 0.00709515f, -0.05932478f, -0.00359339f, 
    -0.03451246f, -0.01881724f, 0.00755480f, -0.03156384f, 0.04320958f, 0.03672925f, -0.03013545f, 0.03323142f, 
    0.03192202f, -0.01535843f, -0.05219417f, 0.02412139f, 0.03519617f, -0.00833966f, -0.01258379f, -0.05826211f, 
    -0.01686403f, -0.01601422f, 0.00608232f, -0.01970433f, -0.01562965f, -0.03488143f, -0.01081437f, 0.02108067f, 
    -0.05006107f, 0.02632116f, -0.02350573f, -0.01585708f, 0.02811981f, 0.02526675f, -0.05485233f, -0.03230812f, 
    -0.04107854f, 0.17671205f, 0.13807178f, 0.03325983f, -0.09307896f, 0.11291715f, -0.08374126f, 0.03321384f, 
    0.05336667f, -0.10100739f, -0.16046841f, 0.11761031f, -0.06565386f, -0.08768525f, 0.08847918f, -0.13749248f, 
    -0.09178619f, -0.00904081f, 0.00225762f, -0.02408721f, -0.05468445f, 0.17947927f, 0.10042772f, 0.14656681f, 
    0.03132743f, 0.18558928f, 0.13100277f, -0.01233939f, 0.00346268f, -0.07936123f, -0.08297928f, -0.13526921f, 
    0.06968952f, -0.11094329f, 0.04562643f, -0.07120528f, -0.28752121f, -0.03454491f, -0.18742037f, -0.06535380f, 
    0.09952346f, 0.06273486f, 0.13539116f, -0.01447766f, -0.13186854f, 0.01607105f, -0.05538702f, -0.11042478f, 
    -0.15071568f, 0.19431596f, 0.06203979f, 0.03791508f, 0.01867686f, 0.01701032f, -0.02755068f, 0.01951147f, 
    -0.02085491f, -0.02846432f, 0.01155315f, -0.01843804f, -0.11841177f, 0.04754657f, 0.07406443f, -0.15358303f, 
    -0.04941651f, 0.02365591f, -0.08271437f, -0.04047161f, -0.02581139f, 0.01435527f, 0.02499332f, 0.14584973f, 
    0.05929578f, 0.02254578f, -0.13800375f, -0.23436014f, 0.03252998f, 0.10099092f, -0.12121110f, 0.16404431f, 
    0.07391772f, 0.09158892f, -0.03185833f, 0.00609545f, 0.00840755f, -0.07806270f, 0.19687527f, -0.03338715f, 
    0.04573770f, -0.11863596f, -0.05640052f, 0.04513554f, 0.10994927f, 0.20774381f, 0.12361278f, 0.06643500f, 
    -0.12803309f, -0.16593350f, -0.10240644f, -0.12169585f, 0.21371360f, 0.16177240f, -0.00575862f, 0.11701524f, 
    0.02272418f, 0.02010800f, -0.14001063f, -0.14617816f, -0.16009104f, -0.00099158f, 0.06407288f, -0.00292801f, 
    -0.00576228f, 0.06899929f, 0.13944158f, -0.01957418f, 0.09398832f, 0.05881955f, -0.10004911f, 0.26961526f, 
    -0.31912953f, -0.00764104f, -0.04805294f, -0.09592651f, 0.13482569f, 0.01015897f, 0.10044501f, -0.15900283f, 
    -0.04594935f, 0.00937494f, 0.01967598f, 0.10207690f, 0.01148286f, -0.07626782f, -0.14029336f, -0.18048084f, 
    0.07641632f, 0.06512374f, 0.01776388f, 0.03838788f, 0.07655691f, -0.02364486f, -0.06534052f, 0.05572880f, 
    -0.02324806f, -0.00023835f, 0.09983914f, 0.15027983f, 0.01059557f, 0.01757883f, 0.02067132f, -0.05460722f, 
    -0.07383316f, -0.01193072f, 0.04252483f, 0.07424649f, 0.18872891f, 0.24590538f, -0.09904949f, 0.09318531f, 
    0.10831334f, 0.11886892f, 0.04751714f, -0.02847444f, 0.08952201f, -0.09836841f, 0.11939722f, 0.03077174f, 
    0.24282424f, 0.17574255f, 0.18482651f, 0.26888880f, -0.02429701f, 0.07400952f, -0.07271342f, -0.15999867f, 
    0.08164340f, -0.06672897f, -0.07940563f, 0.09452689f, -0.29890940f, -0.32014444f, -0.14447963f, -0.03812654f, 
    0.24451099f, 0.17152123f, 0.00880917f, 0.07809261f, 0.05085376f, -0.05868813f, 0.10052405f, 0.07644254f, 
    0.12488822f, -0.10218801f, -0.08122111f, -0.02398396f, 0.04193813f, 0.01497866f, -0.00778121f, -0.02899989f, 
    0.08432966f, 0.09821136f, 0.11436657f, 0.02212950f, -0.07560170f, -0.02040242f, 0.32638240f, 0.20187248f, 
    0.10397137f, 0.04696524f, 0.01054601f, -0.09740775f, 0.05808022f, -0.06606864f, -0.06167405f, 0.13380164f, 
    0.02329328f, -0.22632420f, -0.01972770f, -0.24990480f, 0.15297174f, 0.03887628f, -0.15320484f, 0.05376282f, 
    -0.03985031f, -0.01700595f, -0.01655009f, 0.03955461f, 0.41256514f, 0.27639738f, 0.06034968f, 0.17845644f, 
    -0.05492983f, 0.06526487f, 0.00456635f, 0.04515379f, 0.01643694f, 0.03148880f, -0.04316575f, -0.21732549f, 
    -0.00008813f, 0.15186006f, -0.00339442f, -0.12815797f, -0.02231690f, -0.06796715f, -0.04482041f, 0.00176794f, 
    -0.08531189f, 0.11138082f, -0.02874834f, 0.10217813f, -0.24487068f, 0.16546357f, 0.03879621f, -0.00237061f, 
    -0.00812837f, -0.01786242f, -0.13379084f, 0.06293236f, 0.09391562f, -0.00547194f, 0.10938562f, 0.02453729f, 
    0.04055471f, 0.21254678f, 0.01846953f, 0.02970133f, -0.02565336f, -0.12220231f, 0.03150326f, -0.15035166f, 
    0.04221459f, 0.09566887f, 0.13866769f, 0.20572464f, 0.12877162f, 0.11289474f, -0.04631223f, 0.06704417f, 
    0.03624402f, 0.01418674f, 0.07145456f, 0.02004078f, 0.09085781f, 0.03827357f, 0.09231678f, 0.06395713f, 
    -0.04133784f, -0.10056920f, -0.01860528f, 0.13894275f, -0.07162935f, -0.02866248f, 0.10756458f, 0.02284080f, 
    -0.01689935f, -0.03968923f, -0.05145581f, 0.01099093f, -0.30234450f, 0.14129724f, -0.03608429f, 0.15096912f, 
    -0.00282815f, -0.08213247f, -0.07313842f, 0.02285964f, -0.06126787f, 0.01731876f, 0.00885031f, 0.07045502f, 
    -0.09075131f, -0.20458759f, 0.07146185f, 0.13793831f, -0.05407554f, 0.03618607f, 0.10981312f, -0.06680550f, 
    0.12695581f, 0.00343751f, 0.03594927f, -0.18320301f, -0.19352983f, 0.08620783f, 0.00734096f, -0.07573612f, 
    0.05051078f, 0.02081444f, -0.02002686f, 0.00755655f, -0.12088140f, 0.02119874f, 0.05021156f, 0.17984624f, 
    -0.23525158f, -0.06060757f, -0.01807584f, 0.09320004f, 0.04324158f, 0.01404611f, 0.15553100f, 0.01718745f, 
    0.11015577f, 0.00903103f, -0.30417201f, 0.01274918f, -0.20057383f, -0.35990521f, -0.07173263f, -0.08888640f, 
    0.11089730f, -0.14632867f, 0.13475792f, -0.02904681f, 0.08340657f, -0.07345095f, 0.02203508f, 0.09019309f, 
    0.01482538f, 0.15152986f, 0.10640468f, 0.15169957f, -0.03807476f, -0.09463984f, -0.05025730f, -0.02745974f, 
    -0.06888439f, -0.00825047f, -0.05471241f, 0.08678438f, -0.09716975f, 0.04753708f, 0.07170361f, 0.24120492f, 
    0.02496242f, 0.03185701f, -0.12872656f, -0.05436662f, -0.14940381f, -0.03773291f, 0.02004096f, -0.16132146f, 
    -0.24755368f, 0.05886139f, -0.02601151f, -0.14450157f, 0.09497599f, -0.09874137f, 0.05804197f, -0.16502060f, 
    -0.01880050f, 0.12653922f, -0.07987062f, -0.11027990f, -0.15592843f, -0.10868523f, 0.07988612f, 0.02846660f, 
    0.06420837f, 0.13295379f, 0.03090839f, -0.08787293f, 0.02080092f, 0.14642182f, 0.05564221f, 0.30971751f, 
    -0.00114185f, 0.04023350f, -0.01587708f, -0.08546209f, 0.12429225f, -0.07030426f, -0.08023012f, -0.08144549f, 
    -0.00001217f, 0.00994797f, -0.05032673f, -0.18059900f, -0.04591639f, 0.03727873f, -0.13596812f, -0.20895964f, 
    -0.07357778f, -0.09721740f, 0.12105216f, 0.20080982f, 0.03501324f, 0.01717686f, -0.09764567f, -0.19883738f, 
    0.18977799f, -0.23569053f, 0.09300464f, 0.07882339f, 0.09152745f, -0.04172641f, 0.02689328f, -0.04983667f, 
    0.08766388f, 0.01891865f, 0.14669774f, 0.04272368f, 0.05376083f, -0.15746845f, -0.14596394f, -0.13358358f, 
    0.00704578f, -0.05807249f, 0.12061180f, 0.04020875f, 0.08777376f, 0.05527170f, 0.00167972f, 0.00440447f, 
    -0.01254170f, -0.04425194f, 0.27010307f, 0.10849036f, -0.01246647f, 0.02736154f, -0.09562505f, -0.00054018f, 
    0.06103578f, -0.06011590f, -0.03515469f, -0.01605786f, -0.14173460f, -0.14936759f, -0.14311098f, 0.10071684f, 
    0.01645553f, 0.02232586f, -0.05567331f, 0.06911013f, 0.03140821f, -0.00272402f, 0.07345147f, 0.06394032f, 
    0.05053508f, -0.09556863f, -0.12385241f, 0.12389657f, -0.01390043f, -0.05668810f, 0.05366195f, 0.06987330f, 
    0.08044504f, -0.05826613f, -0.07894926f, -0.12056779f, -0.13137606f, -0.14377129f, -0.08880104f, -0.13396916f, 
    0.17828105f, -0.03359380f, 0.05619219f, -0.14385587f, -0.08030792f, -0.03040850f, -0.15763284f, 0.12446513f, 
    -0.24215387f, -0.09311531f, -0.03723152f, -0.03021665f, -0.05222462f, 0.02955673f, 0.11180870f, -0.12895426f, 
    0.00868554f, -0.07525370f, -0.02574651f, -0.02059712f, 0.00435341f, 0.05752680f, 0.05141848f, 0.25659984f, 
    -0.11312896f, -0.07590282f, -0.07944153f, 0.07895332f, 0.02730115f, -0.09265711f, -0.05719775f, -0.02698273f, 
    -0.22663040f, -0.13775103f, 0.03155470f, 0.29330078f, 0.17992383f, 0.05673483f, 0.06682684f, -0.06639948f, 
    -0.15600100f, -0.06301156f, 0.15097833f, 0.10662612f, 0.09179608f, 0.11452851f, -0.07183629f, 0.02078081f, 
    0.07752869f, 0.02644019f, 0.09873736f, 0.06320500f, 0.05569145f, -0.13316244f, 0.08758574f, 0.08805415f, 
    0.05679823f, 0.07882052f, 0.06807109f, 0.07810128f, 0.17210981f, -0.04591814f, 0.10427124f, -0.00663069f, 
    0.02672201f, 0.01746369f, -0.06753877f, 0.01319713f, 0.08953173f, -0.14052334f, -0.03136956f, 0.01159616f, 
    0.06879683f, 0.00802120f, -0.12114955f, 0.10057565f, -0.04478201f, 0.08110371f, 0.17923804f, 0.03800722f, 
    0.30562887f, 0.21137297f, -0.11322594f, -0.05414096f, -0.20742059f, 0.08398663f, 0.05603337f, 0.06838513f, 
    -0.08057012f, 0.08481666f, 0.14170226f, -0.00546117f, -0.23027384f, 0.04455883f, -0.00639296f, 0.23902373f, 
    0.05587427f, -0.03837416f, 0.06029780f, -0.13940616f, 0.03011587f, 0.00387350f, -0.08132450f, 0.14782530f, 
    0.19929194f, -0.10311490f, -0.03119541f, 0.14171459f, 0.05161518f, 0.10064238f, 0.02770951f, -0.16274895f, 
    -0.07310422f, 0.07254864f, -0.13277082f, 0.13578267f, -0.02569080f, 0.07952736f, 0.02040011f, 0.02184805f, 
    0.03580764f, 0.08173522f, 0.01870447f, 0.05822344f, 0.19010876f, 0.09328885f, 0.05314402f, -0.08427794f, 
    -0.08254533f, 0.01902482f, -0.17385387f, -0.18455090f, 0.15049718f, -0.14087521f, 0.08809346f, -0.08093183f, 
    -0.08567288f, 0.10991610f, 0.01556851f, 0.01962384f, 0.08923797f, -0.25665742f, -0.07646293f, -0.00178164f, 
    0.10264800f, -0.01613723f, -0.00742955f, -0.02466741f, 0.02776004f, 0.10465203f, 0.10538964f, 0.15543705f, 
    -0.02959580f, -0.08031622f, 0.07305720f, -0.12635669f, 0.02169546f, 0.01409567f, -0.00507027f, 0.03334063f, 
    -0.06541621f, 0.09566113f, 0.08284185f, 0.07611322f, 0.09860688f, -0.03090075f, 0.00719745f, -0.04716848f, 
    -0.02141398f, -0.00802391f, 0.13057271f, -0.00780684f, 0.02000572f, -0.03672979f, 0.05161252f, 0.07397600f, 
    -0.30493614f, -0.08779727f, -0.05711045f, -0.10659976f, 0.10669868f, 0.08326456f, 0.03016950f, 0.13183640f, 
    0.06206647f, 0.03379391f, -0.06550860f, 0.13072266f, 0.00685009f, 0.03254929f, -0.09513459f, -0.24258691f, 
    0.06649838f, 0.02622852f, -0.06296454f, 0.09186794f, 0.00724240f, -0.02735014f, 0.00110135f, 0.00784622f, 
    -0.31701994f, 0.34200931f, -0.23508143f, -0.05551407f, -0.04352250f, 0.01105643f, -0.00182973f, -0.06050939f, 
    0.16206163f, 0.08633732f, 0.09071053f, -0.20761228f, -0.07025561f, -0.02567482f, -0.08332707f, -0.24087085f, 
    -0.06802651f, -0.08475064f, 0.07123340f, 0.00130071f, -0.01867338f, -0.02864614f, -0.00271117f, 0.08454769f, 
    -0.04680231f, 0.02003113f, -0.20629936f, -0.15867531f, -0.07204959f, 0.06502125f, 0.39527613f, 0.11434335f, 
    0.14105098f, -0.09890684f, -0.20968641f, -0.06406055f, 0.32439002f, 0.19466533f, 0.22208740f, 0.07517401f, 
    0.12812231f, -0.11244035f, -0.06886838f, 0.03192968f, 0.06834297f, 0.03084095f, -0.07135187f, 0.14679900f, 
    -0.12210525f, -0.01754055f, 0.19270617f, 0.17077097f, 0.17589121f, 0.04200349f, -0.05052317f, -0.05099861f, 
    0.04964858f, 0.02168752f, 0.00252524f, -0.09316638f, 0.02691292f, -0.05628503f, -0.01914376f, -0.03069757f, 
    -0.00326987f, 0.21165964f, -0.07052103f, 0.06839934f, -0.04012531f, -0.04246447f, 0.04677285f, -0.01291139f, 
    -0.06884362f, 0.26169029f, -0.04604045f, 0.08048180f, -0.19267684f, 0.10507530f, -0.10194466f, 0.09130211f, 
    0.02224247f, -0.05593206f, -0.03018080f, -0.00841813f, -0.06883643f, -0.01962840f, 0.11704836f, -0.08022097f, 
    -0.02562488f, -0.00986218f, 0.09620648f, -0.03600348f, -0.06427154f, 0.05979773f, -0.09522059f, 0.00159683f, 
    0.14761330f, -0.01109205f, 0.15879141f, -0.00154002f, 0.01473653f, 0.06960791f, 0.18296167f, 0.02473317f, 
    0.06785090f, -0.08274259f, 0.00075860f, 0.13372712f, -0.21376440f, 0.03428876f, 0.00254625f, -0.31698030f, 
    0.10883381f, 0.01290704f, 0.02557085f, 0.09343678f, -0.01664897f, 0.01118349f, 0.15288974f, 0.01004400f, 
    0.11528301f, 0.10657465f, 0.00590660f, 0.13052009f, -0.04759957f, 0.03306383f, -0.03176151f, 0.04308999f, 
    0.09338120f, -0.00940850f, -0.07227431f, 0.08787068f, 0.03906672f, 0.16977419f, 0.20469953f, -0.16106035f, 
    0.05080807f, 0.02234894f, -0.11147470f, 0.12253121f, -0.03370274f, 0.04387888f, -0.01031970f, 0.04287229f, 
    -0.14856012f, 0.10494620f, -0.03144467f, 0.10535739f, 0.01419449f, 0.01676653f, -0.13750894f, -0.04116360f, 
    0.11997968f, 0.06348530f, 0.05491255f, 0.15556131f, -0.19951262f, -0.07154019f, 0.08138992f, 0.16019312f, 
    -0.04920426f, 0.04226876f, 0.03704913f, 0.13582103f, 0.03693923f, 0.05779000f, -0.05092517f, -0.05162279f, 
    -0.01700331f, -0.08325099f, -0.07670220f, -0.12174018f, 0.01387172f, 0.11694660f, -0.02913783f, 0.14643897f, 
    -0.12677789f, 0.05030829f, 0.00507203f, 0.04714897f, 0.00901028f, -0.08196861f, 0.09794988f, 0.02794924f, 
    0.07885596f, -0.09455861f, 0.06435138f, -0.06498568f, 0.18151073f, 0.05940350f, 0.19311653f, 0.07119078f, 
    -0.25773996f, -0.07760335f, 0.07212295f, -0.11075226f, 0.00254629f, 0.08453465f, -0.02642064f, -0.06688434f, 
    -0.00928788f, 0.03462320f, -0.02458265f, 0.01597180f, -0.02801344f, 0.09453446f, -0.00476393f, 0.04584598f, 
    0.06634328f, 0.03275757f, 0.07154942f, -0.03303867f, -0.03380614f, -0.10798134f, -0.03235010f, 0.08182050f, 
    -0.00877259f, -0.25281385f, 0.02412903f, 0.07313983f, -0.01938705f, 0.06607468f, -0.00763803f, -0.00121582f, 
    0.05236621f, 0.01843219f, -0.00208484f, -0.07875136f, -0.01843326f, 0.05680917f, -0.22180612f, 0.02277555f, 
    -0.02828867f, 0.09541807f, 0.13788380f, 0.05064307f, 0.07268114f, 0.00219279f, -0.07420570f, 0.04214482f, 
    0.04674347f, -0.01605071f, 0.04042496f, 0.06175720f, -0.02607170f, -0.06381218f, -0.00431301f, 0.01399321f, 
    -0.04760004f, 0.02203890f, 0.08758666f, -0.03603946f, -0.24360511f, -0.17069918f, 0.01139850f, 0.06332405f, 
    0.07117752f, -0.00967234f, -0.01684827f, -0.02126755f, 0.17610720f, -0.05933698f, 0.08980825f, 0.05038954f, 
    -0.24784908f, -0.13064210f, 0.05445857f, 0.02217737f, 0.01486133f, -0.03099446f, 0.14690503f, -0.05955122f, 
    0.01617264f, 0.05226280f, 0.04381939f, 0.00496492f, -0.22642206f, -0.07981119f, 0.04993669f, 0.11621799f, 
    -0.02878629f, 0.01084561f, -0.04047955f, 0.04358403f, 0.06725447f, 0.00409336f, -0.00337289f, 0.00499864f, 
    -0.26903835f, -0.01695670f, -0.02703754f, 0.05878438f, -0.06361969f, 0.03448809f, -0.03048834f, -0.11252575f, 
    0.06835846f, 0.06745717f, 0.06605911f, 0.18544567f, -0.02263849f, 0.15300107f, 0.03155281f, 0.09131540f, 
    -0.01701943f, -0.02947538f, -0.12363396f, -0.02701473f, -0.12623215f, -0.00004570f, 0.15447325f, -0.17282934f, 
    -0.08869853f, 0.25407460f, -0.01658249f, -0.01028563f, -0.13804257f, 0.10294985f, -0.08430845f, 0.08261414f, 
    -0.00547475f, -0.07058101f, -0.06148803f, -0.03021320f, 0.06963958f, 0.14193024f, 0.05232226f, 0.03822041f, 
    -0.14704534f, 0.10033514f, 0.15663877f, 0.00613179f, 0.14470221f, -0.05710185f, 0.02040489f, 0.02775492f, 
    -0.09473960f, 0.29134983f, -0.02370502f, 0.08599980f, -0.11667313f, -0.07058696f, 0.10701583f, 0.05764958f, 
    0.04782668f, 0.02367290f, 0.05647976f, 0.00823392f, -0.29336086f, -0.03950173f, -0.16658279f, 0.09298272f, 
    0.07417852f, -0.05431163f, 0.05559515f, 0.09547279f, 0.02356816f, -0.04611281f, 0.04663221f, -0.01622910f, 
    0.11015814f, -0.12154147f, 0.10552989f, 0.11147033f, -0.05905302f, 0.09541897f, 0.01045682f, 0.02957787f, 
    0.05227640f, 0.00500609f, -0.07835646f, 0.03555340f, -0.34156841f, 0.04429125f, 0.09312382f, 0.12769306f, 
    -0.01514696f, 0.02463345f, 0.01928965f, 0.14156415f, 0.09494153f, 0.02460108f, 0.01430061f, 0.02542334f, 
    0.34048456f, 0.10119955f, 0.25251988f, 0.12568466f, -0.08474324f, -0.14647566f, 0.03741746f, 0.01780998f, 
    0.10208283f, -0.10529938f, -0.09741560f, -0.07243409f, -0.17373286f, 0.11805054f, 0.14247495f, -0.08000886f, 
    -0.06683614f, -0.02469960f, 0.03902707f, -0.05792071f, -0.08612810f, -0.04166491f, 0.05262786f, -0.06585587f, 
    -0.28048700f, 0.10967014f, 0.23542842f, -0.02413841f, 0.11353488f, -0.17458458f, 0.03418662f, 0.10377889f, 
    -0.00576912f, 0.18680558f, -0.15030247f, 0.10444181f, 0.36418232f, -0.04734231f, 0.11740959f, -0.06604249f, 
    0.06223807f, -0.08127914f, 0.09058749f, -0.10541248f, 0.04208103f, -0.13417463f, 0.08825200f, 0.14074612f, 
    -0.10169867f, 0.07728812f, 0.14023493f, 0.07792675f, 0.14834803f, -0.02488210f, -0.02965579f, 0.06453300f, 
    0.02608010f, -0.01465579f, 0.04647184f, -0.03382016f, -0.12233346f, 0.11042973f, 0.02246702f, 0.06674558f, 
    -0.05910218f, -0.08531955f, -0.06358087f, 0.00194820f, -0.08366194f, 0.05710473f, -0.03736874f, -0.06648530f, 
    0.01437327f, -0.01610190f, -0.04569650f, 0.24366918f, -0.06360009f, -0.09807210f, -0.08395332f, -0.05488832f, 
    -0.05396377f, -0.00175282f, -0.06421289f, -0.00597755f, 0.02828085f, -0.16767280f, 0.25057590f, 0.10160468f, 
    -0.02564090f, 0.05140600f, -0.09918740f, -0.17013285f, -0.02532531f, 0.10535635f, -0.02574128f, 0.15188360f, 
    -0.19346674f, 0.10078283f, 0.09995189f, -0.10750080f, 0.10694449f, 0.02965679f, 0.05764754f, -0.00063845f, 
    0.01575396f, -0.04787097f, 0.02045754f, -0.01255955f, -0.48236781f, 0.03630491f, 0.05330550f, -0.11399008f, 
    0.08517712f, 0.01071537f, 0.06805965f, 0.14213070f, 0.01630210f, 0.08587793f, 0.00722314f, 0.00735365f, 
    0.29842150f, -0.00017164f, 0.00674382f, 0.26509452f, -0.00049928f, -0.06206322f, -0.05388471f, 0.08322483f, 
    0.07927402f, 0.02547204f, 0.06580459f, 0.12246041f, 0.24462123f, 0.12092017f, 0.22161335f, 0.11837200f, 
    -0.02641763f, 0.02359184f, 0.02284735f, -0.04111463f, -0.03368630f, 0.06923141f, 0.03902648f, -0.03050764f, 
    0.10045734f, -0.10297337f, -0.10461802f, 0.10015035f, 0.02027267f, 0.05877023f, -0.04780013f, -0.03618348f, 
    0.01088584f, 0.06773653f, -0.02134317f, 0.00020953f, -0.09875239f, -0.17333438f, 0.06224701f, 0.30187166f, 
    -0.04716527f, -0.06449129f, -0.01032199f, 0.04742002f, 0.08221827f, -0.00297840f, 0.01426981f, 0.10475710f, 
    0.07120807f, 0.06474827f, 0.16078751f, -0.08662816f, 0.06306595f, 0.11531918f, 0.00479037f, 0.06727989f, 
    0.02546768f, -0.09123833f, 0.10747021f, -0.04209556f, -0.13897897f, -0.10924259f, 0.28098187f, 0.06714700f, 
    0.09535667f, 0.02627074f, 0.08356465f, -0.05940974f, 0.02257042f, 0.07431101f, -0.11378670f, -0.00143956f, 
    -0.01327223f, 0.03149166f, -0.05633233f, -0.28892368f, 0.02615567f, 0.07392813f, 0.14402951f, -0.07246583f, 
    -0.02642855f, -0.05624624f, -0.06666376f, -0.00777132f, -0.38239887f, 0.07409849f, -0.05563857f, -0.01874635f, 
    0.02084289f, 0.13718933f, -0.01519037f, -0.02936312f, -0.01103202f, -0.06160735f, 0.03054073f, -0.09631769f, 
    0.12344461f, -0.17233734f, -0.01119360f, 0.15551879f, -0.05105513f, -0.03405234f, 0.01167798f, 0.01434743f, 
    0.09842192f, -0.10773869f, 0.04599664f, 0.05006545f, -0.03617372f, -0.14193922f, -0.22488829f, -0.13390626f, 
    -0.05016913f, 0.08204491f, 0.06351099f, 0.08880703f, 0.19078293f, -0.10255812f, -0.09051872f, 0.09993570f, 
    0.28944564f, -0.02799245f, 0.03035675f, 0.07345583f, 0.01980119f, -0.04899688f, 0.03676564f, -0.01239575f, 
    0.10006823f, -0.03903394f, 0.02074727f, -0.10209236f, 0.07853493f, 0.17177173f, 0.20248863f, 0.10702623f, 
    0.14163676f, 0.03306793f, -0.01740914f, 0.06576113f, 0.14749530f, -0.00866462f, 0.17922968f, 0.03249547f, 
    -0.34539071f, 0.14153950f, 0.03688627f, -0.07602949f, -0.02861056f, -0.02789311f, -0.02458445f, 0.01910050f, 
    0.00050800f, -0.01349440f, 0.03871955f, 0.07581057f, 0.02670213f, -0.07605945f, 0.00915564f, 0.25002047f, 
    -0.07150607f, -0.11113556f, -0.06806471f, 0.03960742f, 0.05786394f, 0.06289691f, 0.00140485f, 0.11984096f, 
    -0.12463366f, 0.23875141f, -0.03585291f, 0.04027861f, -0.04031552f, 0.08318118f, -0.01391844f, -0.17804693f, 
    0.02270107f, -0.07028263f, -0.06383529f, 0.11840747f, 0.17863528f, -0.02113597f, -0.11159271f, 0.00674509f, 
    -0.02495926f, -0.09596036f, 0.02186692f, 0.07796553f, 0.05824527f, 0.04548848f, 0.01902883f, -0.03704494f, 
    -0.02227098f, 0.16746369f, -0.21877860f, 0.00488037f, -0.00059547f, -0.12790419f, -0.23493460f, -0.08813380f, 
    -0.08221845f, 0.09752463f, 0.00951710f, -0.00100501f, -0.00004044f, -0.04490479f, 0.00186516f, 0.14655837f, 
    -0.04014010f, 0.13216479f, 0.05501306f, -0.03894963f, 0.02821004f, 0.01010305f, 0.10272392f, 0.06262049f, 
    0.18982276f, 0.12048521f, 0.08008810f, 0.15289555f, -0.08556715f, -0.06613269f, 0.00802965f, 0.03723510f, 
    0.02621411f, 0.06831286f, 0.05327968f, 0.15867309f, -0.02965195f, -0.18118076f, -0.15787689f, -0.11302885f, 
    0.07494169f, -0.09294310f, -0.05055195f, 0.04395673f, -0.01691273f, -0.00314068f, -0.04354706f, 0.12913358f, 
    0.20457006f, -0.00348150f, 0.04088132f, 0.08856589f, 0.05982504f, 0.10486022f, -0.10566637f, 0.04550756f, 
    0.09970941f, -0.09357800f, -0.03010483f, 0.03241393f, -0.59734672f, 0.31708655f, -0.00634694f, -0.05847337f, 
    0.05859135f, -0.00150021f, -0.07027797f, 0.09714090f, -0.10037670f, 0.10682508f, -0.03364836f, 0.10661479f, 
    -0.39396042f, 0.30969054f, 0.03347897f, 0.09973479f, 0.01812480f, 0.01646016f, 0.00533195f, -0.00593983f, 
    0.10523629f, 0.03183830f, -0.01698343f, -0.17304505f, 0.13739046f, 0.03590013f, 0.02252812f, 0.18003047f, 
    -0.06002408f, -0.02625170f, 0.10917608f, -0.07492007f, -0.00859247f, -0.08178750f, -0.02917178f, -0.02024813f, 
    -0.28654462f, 0.15896818f, 0.28139561f, 0.11071789f, 0.03957377f, -0.16279247f, 0.05624916f, 0.14571492f, 
    -0.09177641f, -0.01011895f, -0.12307534f, 0.08003218f, 0.25297192f, 0.20492338f, 0.13878781f, 0.09671111f, 
    0.00080462f, 0.02088331f, -0.05968638f, -0.05793440f, 0.10790237f, 0.04843107f, -0.06408322f, 0.12702166f, 
    0.12866761f, -0.09468727f, 0.02069748f, 0.04419104f, 0.07146186f, 0.03687561f, 0.03592597f, 0.03670619f, 
    -0.00115454f, 0.04092618f, 0.04656961f, -0.04468582f, 0.09310436f, -0.03951509f, -0.02684787f, 0.11156233f, 
    -0.05682451f, -0.11169916f, -0.00354610f, 0.05812052f, 0.02309463f, -0.06140929f, -0.00929245f, -0.13442762f, 
    -0.18289791f, -0.00917835f, -0.04918903f, 0.16013400f, 0.02272561f, 0.04512635f, -0.12759303f, 0.01486947f, 
    -0.07676265f, 0.03805058f, -0.00278809f, -0.08293051f, -0.06065785f, 0.06147968f, 0.07984077f, 0.02250020f, 
    -0.08451542f, -0.01914714f, -0.07369087f, 0.06462128f, 0.05636841f, 0.06662374f, -0.06023947f, -0.08645950f, 
    0.10238422f, -0.05430975f, -0.07278820f, -0.05369364f, -0.07606468f, 0.08058787f, 0.15228958f, 0.07533454f, 
    -0.03558832f, 0.07020099f, 0.01359257f, 0.11544837f, 0.02475269f, 0.05342926f, 0.14809424f, 0.18628792f, 
    0.03120467f, 0.00346012f, 0.12706113f, 0.08606719f, -0.02250172f, -0.01092081f, -0.03006930f, 0.03546453f, 
    -0.09518974f, 0.26940817f, -0.29572091f, -0.06272592f, -0.00984019f, 0.06605133f, -0.06046322f, 0.06215268f, 
    -0.06496581f, -0.09119181f, -0.03472885f, 0.17955782f, 0.16435395f, 0.08415291f, 0.18173093f, 0.05120717f, 
    -0.02217884f, -0.03664398f, -0.08611966f, 0.04709607f, 0.08429313f, 0.06984153f, 0.05586332f, -0.06516162f, 
    -0.14253162f, 0.05714503f, 0.12073010f, 0.30788127f, 0.05530735f, 0.07155302f, 0.07325018f, 0.00841371f, 
    0.05384571f, -0.02145264f, -0.01966135f, 0.05522351f, -0.10383460f, -0.15178646f, 0.12971149f, 0.13850783f, 
    -0.04473861f, -0.02299260f, -0.04622324f, 0.00351374f, -0.11239623f, -0.11112595f, 0.03388581f, -0.01583544f, 
    0.15782654f, 0.13346827f, 0.07320976f, 0.17837742f, -0.06644298f, 0.03759855f, -0.01735687f, -0.03857421f, 
    -0.11734902f, 0.08412115f, 0.13560104f, 0.02779518f, 0.20680033f, 0.02110494f, 0.13869154f, 0.22083057f, 
    0.13948594f, -0.06636288f, 0.00048746f, 0.14365558f, 0.00754422f, 0.00608952f, 0.01915284f, -0.14245547f, 
    0.25901660f, 0.15064284f, 0.10701719f, 0.15724427f, 0.02469811f, -0.04330207f, 0.00744588f, 0.06130603f, 
    0.01750601f, 0.02368868f, 0.00981771f, 0.02402150f, -0.25150010f, 0.02246470f, 0.03138611f, 0.10210409f, 
    -0.02857598f, 0.02533926f, 0.03132403f, 0.08530230f, -0.04298793f, 0.04311513f, 0.01435387f, -0.01852012f, 
    -0.27922532f, -0.27179629f, -0.06328038f, -0.03607863f, 0.09226054f, 0.05129806f, 0.05069890f, -0.02708886f, 
    0.03249265f, -0.00879107f, -0.00397697f, 0.00613496f, -0.30587047f, -0.37141851f, 0.12723240f, -0.10057561f, 
    -0.04243650f, 0.09646586f, -0.05792687f, 0.17283465f, -0.03719895f, 0.04086407f, -0.11918223f, 0.08531500f, 
    -0.15994909f, -0.20944774f, -0.22461168f, -0.13507053f, 0.00922742f, 0.07896146f, 0.02153740f, 0.02655768f, 
    0.03958273f, -0.02171731f, -0.05044283f, -0.01960012f, 0.25881791f, 0.13860509f, 0.17084676f, 0.14749478f, 
    0.08266298f, 0.01431771f, 0.06991240f, -0.01307617f, 0.03162307f, -0.07239728f, -0.05679107f, -0.04534325f, 
    -0.14968602f, -0.04214831f, 0.01973906f, -0.01491360f, -0.10057104f, 0.04428267f, 0.05849298f, 0.05689238f, 
    -0.01002847f, 0.05911062f, 0.00811402f, 0.07847535f, -0.18496667f, -0.20318137f, -0.04757120f, -0.09207115f, 
    0.05291826f, -0.03450053f, -0.04122137f, 0.00669024f, -0.06247620f, 0.10897353f, 0.01355040f, -0.03422565f, 
    0.23922960f, -0.11840453f, 0.00534123f, 0.14591789f, -0.02669815f, -0.05140986f, 0.00197979f, 0.09414112f, 
    -0.00436701f, 0.00335732f, 0.00842568f, -0.00425348f, -0.22207364f, -0.04801124f, -0.21353577f, -0.24434716f, 
    0.15973821f, 0.03084143f, 0.01486394f, -0.02475063f, 0.02195498f, -0.08026417f, 0.03515615f, 0.12887552f, 
    -0.14127320f, -0.06032332f, 0.16911240f, 0.02458130f, -0.08744175f, 0.04103210f, 0.01187428f, 0.04939771f, 
    0.00964666f, -0.02360597f, -0.01465702f, -0.20447282f, -0.21622421f, 0.00961509f, -0.02450976f, -0.02222398f, 
    0.01751709f, -0.05998216f, 0.08517460f, 0.00097152f, -0.09599671f, 0.08279882f, 0.03102068f, -0.04735503f, 
    -0.09902350f, 0.28127474f, -0.09317926f, -0.01944926f, 0.07082255f, -0.06817165f, 0.10356960f, 0.10143596f, 
    0.02710890f, -0.03016261f, -0.03701379f, 0.03791283f, -0.32546827f, -0.13458392f, -0.01838381f, -0.08165486f, 
    0.12851608f, 0.07907295f, -0.02921594f, 0.04492411f, -0.01486616f, -0.03507349f, -0.03562934f, 0.03674845f, 
    0.44488218f, -0.02007457f, 0.20961271f, -0.03693201f, 0.10965832f, 0.03724401f, 0.00858001f, -0.01496746f, 
    0.00458926f, 0.06873365f, 0.00810464f, 0.10984630f, -0.28973511f, 0.25504598f, 0.05291925f, -0.08280464f, 
    0.11430983f, -0.06735300f, -0.02665501f, 0.16598590f, 0.06185367f, 0.00235355f, -0.03725281f, 0.08805339f, 
    -0.01957023f, 0.07582583f, -0.05690455f, -0.07413425f, -0.00583200f, -0.02371232f, -0.03422537f, 0.03287302f, 
    -0.01719008f, 0.06424668f, 0.05059838f, -0.01720266f, 0.29390121f, 0.04201715f, 0.14615485f, 0.17763165f, 
    0.02488267f, -0.09115374f, -0.01177708f, -0.09577524f, 0.05863577f, -0.03555784f, 0.04402237f, -0.01034216f, 
    0.08006588f, 0.17174365f, 0.20951484f, 0.15349989f, -0.07001325f, 0.03570603f, -0.02124760f, -0.05550894f, 
    0.06341321f, -0.04961253f, 0.05045733f, -0.08201627f, -0.02926908f, 0.24624971f, 0.08926146f, 0.03233702f, 
    0.04872701f, -0.00906116f, 0.13376118f, 0.14089455f, 0.08345983f, -0.03995525f, 0.05366504f, -0.00426775f, 
    -0.22231229f, -0.07990120f, -0.22104001f, -0.13026516f, 0.15051174f, 0.00054062f, -0.05188096f, 0.00288276f, 
    0.02392453f, -0.09176283f, -0.06868088f, -0.05398846f, -0.20850867f, 0.00460474f, 0.00273730f, -0.10268819f, 
    0.11528776f, 0.06903411f, 0.02346351f, -0.01364570f, 0.13544844f, 0.05710970f, -0.04226909f, 0.05704498f, 
    0.04279863f, 0.05163606f, 0.04234698f, 0.01758839f, 0.00119688f, 0.03323336f, -0.06909153f, 0.01948575f, 
    0.00123871f, 0.05769500f, 0.09760985f, -0.02776941f, 0.03486782f, 0.00007718f, 0.00822081f, -0.00820981f, 
    -0.14039101f, 0.02663828f, -0.01409247f, -0.00519268f, 0.00028018f, -0.07860114f, -0.03539831f, -0.06170388f, 
    0.19094472f, 0.00517080f, 0.01093703f, 0.01202021f, -0.05733334f, -0.01811674f, 0.13715845f, 0.04093910f, 
    0.02475890f, 0.00393451f, -0.11626239f, 0.17769285f, 0.02737066f, 0.15559684f, 0.23246300f, 0.07254869f, 
    0.12306125f, 0.00815080f, -0.03506973f, 0.03420460f, 0.09421907f, -0.09345441f, 0.05360821f, 0.07455806f, 
    -0.02426955f, 0.20576832f, -0.00290599f, 0.07020417f, 0.06713957f, 0.06660607f, -0.00493726f, 0.00571741f, 
    0.01410737f, -0.01004430f, -0.04779030f, 0.03871114f, 0.00625820f, 0.14994976f, 0.17065196f, -0.15154925f, 
    0.02629892f, 0.00208924f, -0.03129498f, 0.01314735f, -0.00114530f, -0.02441767f, 0.05554185f, 0.05926678f, 
    -0.06064720f, 0.14394921f, 0.07469919f, 0.12097172f, 0.00240015f, 0.00388332f, 0.03521733f, -0.01283143f, 
    0.07872135f, 0.03721704f, 0.02420630f, 0.15955545f, -0.16897550f, 0.04006122f, -0.01226230f, 0.14562848f, 
    -0.06293073f, -0.00320405f, 0.00570530f, 0.01303000f, 0.02937533f, -0.04291211f, -0.03858628f, -0.07154027f, 
    -0.02168701f, 0.09178919f, 0.13206257f, 0.09281003f, -0.06069819f, 0.08751803f, -0.06307784f, 0.04022555f, 
    -0.07043230f, 0.07710521f, 0.16859625f, 0.09957637f, 0.02264710f, -0.07043868f, 0.03124221f, 0.14640149f, 
    0.07521004f, -0.03846584f, 0.00874279f, 0.08966609f, 0.07874711f, -0.04348249f, 0.17894876f, -0.13111450f, 
    0.12891933f, 0.06625905f, 0.14502934f, 0.13365830f, 0.07875331f, -0.04834181f, -0.07537591f, 0.08816943f, 
    0.02534570f, -0.01327747f, 0.05232251f, -0.01742031f, 0.07362436f, 0.12907134f, 0.16143392f, 0.06074760f, 
    0.04102287f, -0.00167949f, 0.04909519f, 0.00293000f, -0.00613186f, 0.07859662f, 0.06509080f, -0.05397741f, 
    -0.00578481f, -0.23172623f, -0.11777122f, -0.00728353f, 0.02238205f, -0.00257021f, 0.06438999f, -0.04126792f, 
    0.00895716f, 0.02661881f, -0.04180180f, -0.10646582f, -0.04074544f, -0.15897763f, 0.07832421f, -0.20871031f, 
    -0.01580616f, 0.11235116f, -0.07978517f, 0.05573639f, -0.04855971f, 0.09383634f, -0.06333493f, 0.04730203f, 
    -0.03982698f, -0.20012975f, -0.25090545f, -0.11228319f, -0.05811070f, -0.00827055f, -0.09822604f, -0.00569344f, 
    0.05285393f, 0.06248859f, 0.03585529f, -0.12307400f, 0.14000799f, 0.11184552f, 0.10786827f, 0.00176434f, 
    -0.00584466f, -0.03115410f, 0.06486333f, 0.01492497f, 0.06457631f, -0.05786201f, -0.10103711f, 0.03566131f, 
    -0.26744139f, -0.03111721f, -0.01523654f, 0.03057409f, 0.02040197f, 0.04924323f, 0.06913522f, -0.03371494f, 
    0.07156786f, 0.02111085f, 0.04371741f, 0.04065988f, 0.03020059f, -0.19803804f, -0.02637793f, -0.06837799f, 
    0.10130649f, -0.05542878f, -0.11560247f, 0.07653264f, 0.08216693f, 0.03432201f, 0.07268471f, -0.04853523f, 
    0.06471065f, 0.00351018f, -0.04643293f, 0.10405323f, -0.14908308f, -0.05152705f, 0.00581696f, 0.04694322f, 
    0.00303753f, 0.06100849f, -0.04704555f, 0.03191695f, -0.19508201f, -0.04119604f, -0.18098935f, -0.00785708f, 
    0.07936597f, -0.00911912f, 0.02866997f, -0.05033605f, -0.01224592f, 0.00572717f, 0.04518665f, 0.04111191f, 
    -0.09216788f, 0.02898924f, 0.20407654f, -0.14179236f, -0.14196882f, 0.04030540f, 0.06862208f, 0.01622946f, 
    0.01951880f, -0.05677621f, 0.05335833f, -0.14299199f, -0.05291735f, -0.00767994f, 0.03357984f, 0.14391953f, 
    0.02648554f, 0.05893829f, 0.11707813f, -0.02832830f, -0.07001894f, 0.08074731f, 0.00061489f, -0.04308304f, 
    -0.03997822f, 0.20813338f, 0.02294949f, 0.32656240f, 0.16559643f, -0.08639891f, 0.09354401f, 0.11702608f, 
    -0.00380355f, -0.00376816f, -0.02213649f, 0.04566008f, -0.12493619f, -0.08957139f, -0.08334298f, -0.11091322f, 
    0.12846786f, -0.04423444f, -0.00323174f, 0.09419043f, -0.05674976f, 0.01327943f, 0.04227404f, 0.02865206f, 
    0.43236578f, -0.09659389f, 0.09976587f, -0.04695482f, 0.06421649f, 0.03906729f, -0.01861978f, -0.00133437f, 
    0.07734778f, 0.10248029f, -0.00979299f, 0.12471492f, -0.24179077f, 0.08446673f, 0.08371710f, 0.03133065f, 
    0.02437400f, -0.07574347f, 0.01339249f, 0.10857633f, 0.05389451f, 0.04130419f, -0.10514220f, 0.07258955f, 
    0.36576012f, 0.10242514f, 0.10413484f, -0.05523611f, 0.01616234f, -0.03204568f, 0.01363016f, 0.01673123f, 
    0.05871923f, -0.04221625f, 0.04145826f, 0.05645955f, 0.24399400f, -0.00826306f, 0.22104329f, 0.07335705f, 
    -0.02899822f, -0.02260142f, 0.03494196f, -0.05932228f, 0.09314246f, -0.03597637f, 0.10772573f, 0.02446427f, 
    -0.06668261f, 0.18881238f, 0.18530156f, 0.08914770f, -0.04299341f, -0.01720707f, -0.13335344f, -0.04074368f, 
    -0.00013803f, 0.06823605f, 0.13479105f, 0.05934214f, 0.15750372f, 0.18637872f, 0.18140242f, 0.03966720f, 
    -0.04722593f, 0.06482537f, 0.06808327f, -0.00915592f, 0.05127336f, -0.10156933f, 0.08906253f, 0.02938787f, 
    -0.11682901f, -0.02371431f, -0.16401143f, -0.00800948f, 0.21178304f, 0.05026804f, -0.06142524f, 0.06611559f, 
    0.04605567f, 0.02528705f, -0.00243242f, -0.00636074f, -0.08208224f, 0.03251163f, -0.02892402f, 0.03055710f, 
    0.06535775f, -0.04113071f, -0.02868628f, -0.02092755f, 0.14241292f, 0.10962039f, -0.09626757f, -0.00977791f, 
    -0.03721876f, 0.08306172f, -0.28723592f, -0.07510999f, -0.04244365f, 0.01730944f, 0.05278403f, 0.07807366f, 
    -0.02564337f, 0.04057520f, 0.10673442f, 0.03472978f, 0.07848560f, -0.04440581f, 0.03089269f, 0.04404913f, 
    0.02998209f, -0.06171106f, 0.00758903f, 0.03151237f, 0.00810988f, -0.16772453f, -0.02367255f, -0.07026231f, 
    0.05169560f, -0.15592635f, 0.09881648f, 0.04880149f, -0.00746110f, 0.09471131f, 0.13515073f, 0.06264383f, 
    0.02672875f, 0.01034710f, -0.02856083f, 0.16676396f, 0.38923600f, -0.11939687f, 0.21588999f, -0.12071569f, 
    0.01969273f, -0.04393810f, 0.00696947f, 0.08116809f, 0.06266082f, -0.00712445f, 0.12364402f, 0.09629347f, 
    0.17111528f, -0.07024547f, -0.00365470f, 0.06609354f, 0.11209214f, 0.07078585f, 0.04995466f, -0.00624253f, 
    -0.01011736f, 0.08911516f, -0.00300553f, -0.02256604f, 0.25390324f, 0.00267175f, -0.02553684f, 0.13131963f, 
    0.06401910f, 0.02102606f, 0.01429724f, 0.11436219f, 0.06956325f, -0.13058235f, -0.08632270f, -0.06535365f, 
    -0.16979542f, 0.12048764f, -0.16164622f, 0.16454446f, 0.01492447f, -0.04479474f, 0.08977724f, -0.07044533f, 
    0.03868087f, -0.02464493f, 0.12719490f, 0.05067629f, 0.05114427f, -0.03209941f, 0.05360207f, 0.04355551f, 
    0.10254215f, 0.07882828f, 0.10758460f, -0.06892624f, -0.06437469f, -0.01624902f, -0.11292833f, -0.12797034f, 
    -0.10259878f, 0.10590355f, 0.11574879f, 0.00072274f, -0.02468709f, -0.14371020f, 0.01926393f, 0.07842916f, 
    -0.19373327f, 0.07411785f, -0.00684811f, 0.21122180f, 0.09244490f, 0.06152058f, -0.02123630f, 0.14530890f, 
    0.02211330f, 0.06959061f, -0.02437640f, -0.01445181f, 0.10501470f, 0.00893043f, 0.25695565f, -0.14179488f, 
    0.11420374f, -0.04528201f, 0.13171992f, -0.04179391f, -0.15014976f, -0.00762329f, -0.07726894f, 0.07368268f, 
    0.03018344f, 0.07981893f, -0.00958072f, 0.00230352f, 0.10447939f, 0.03004311f, 0.09209763f, 0.14429685f, 
    -0.07078536f, -0.08753070f, 0.00439427f, 0.09790844f, -0.08117234f, -0.03361690f, 0.05648741f, 0.11136166f, 
    0.01495997f, 0.07460472f, 0.06159632f, -0.22819933f, 0.00139255f, 0.09842964f, -0.06083268f, 0.03420758f, 
    0.00475614f, -0.00049406f, -0.08114638f, -0.04807706f, -0.35848743f, 0.02781762f, -0.04170336f, 0.14666133f, 
    -0.03962052f, -0.04288275f, 0.10035849f, 0.01088774f, -0.06222041f, 0.08578804f, -0.06240313f, -0.10541894f, 
    -0.28726038f, 0.02913060f, -0.01687128f, -0.11293282f, 0.00356790f, -0.06888301f, 0.08252592f, 0.10319356f, 
    -0.10717481f, 0.17290893f, 0.16649911f, -0.04177798f, -0.00497240f, 0.04170223f, -0.01514351f, -0.04298411f, 
    -0.12345868f, -0.13718382f, -0.06100273f, -0.07951745f, -0.03592116f, -0.04998403f, -0.03179446f, -0.07380030f, 
    0.05620473f, -0.12835592f, 0.03677257f, -0.00554670f, 0.03105225f, 0.00562792f, 0.05888121f, 0.06763898f, 
    0.04001569f, -0.02688023f, -0.04433905f, -0.00044093f, -0.14464298f, 0.13337542f, -0.11939363f, -0.09545182f, 
    -0.02511029f, 0.10864227f, -0.03341100f, -0.00591976f, 0.00194214f, 0.02991755f, 0.03192707f, -0.15572871f, 
    -0.37745440f, 0.05496355f, -0.06582851f, 0.21826877f, -0.05295130f, -0.03542329f, 0.05870624f, -0.03726400f, 
    0.09481470f, 0.00183737f, 0.09171665f, 0.05360979f, -0.16310549f, -0.12896362f, 0.14486794f, -0.16652066f, 
    -0.02751323f, -0.00270409f, -0.03743232f, 0.00819567f, -0.09662407f, 0.04795791f, 0.11685992f, -0.00522558f, 
    -0.20908853f, 0.11723709f, -0.11968684f, 0.19535939f, -0.08782419f, 0.09491619f, 0.02461411f, 0.11923934f, 
    0.09515033f, -0.10245520f, 0.04712900f, -0.09028262f, 0.16074777f, 0.11856337f, 0.10467196f, 0.02065496f, 
    -0.05795030f, 0.11483797f, 0.11681398f, -0.09911351f, 0.05089953f, 0.03369244f, -0.11038311f, 0.04569881f, 
    -0.14413638f, -0.00954291f, 0.10579085f, -0.06017150f, -0.07912769f, 0.05044179f, 0.11685223f, 0.00415771f, 
    0.00642928f, -0.16819054f, -0.04608835f, -0.17500803f, -0.35563841f, 0.02326025f, 0.02175631f, 0.07372815f, 
    -0.04148298f, 0.11528270f, 0.00656400f, 0.00722102f, 0.00454210f, -0.07122181f, 0.08525986f, -0.13743049f, 
    -0.29529390f, -0.07015985f, -0.05168092f, 0.08627447f, -0.06820240f, 0.04167273f, 0.04108066f, -0.06981158f, 
    -0.05294748f, 0.02737879f, 0.03327496f, -0.07287972f, 0.44694370f, -0.31988645f, 0.09736083f, -0.05912976f, 
    -0.05043969f, 0.09739354f, 0.11251887f, 0.04210206f, 0.10146167f, 0.07581732f, 0.04167049f, -0.08572315f, 
    0.55347919f, 0.08621834f, 0.14518391f, 0.03861369f, 0.02699535f, 0.00529907f, 0.02072890f, 0.08213867f, 
    -0.10976020f, -0.05494898f, -0.26201585f, 0.17087300f, -0.06020650f, -0.11330169f, 0.06445760f, 0.00942998f, 
    -0.03238788f, 0.01186201f, -0.01460069f, -0.00731221f, 0.02031804f, 0.02114879f, -0.00518287f, -0.15870546f, 
    0.27567774f, -0.00632577f, 0.17287689f, -0.11847427f, 0.04809945f, -0.06188387f, -0.12509574f, -0.03833129f, 
    -0.15179871f, 0.19195443f, 0.20168948f, 0.11459901f, 0.49066719f, 0.24140492f, 0.05237909f, 0.12414107f, 
    -0.00881939f, 0.04602887f, 0.03243120f, -0.06730884f, -0.07981155f, -0.05729093f, 0.09248384f, -0.00256944f, 
    0.08528057f, 0.10756414f, 0.07088357f, -0.03897021f, -0.01480514f, -0.00284553f, 0.00987617f, 0.02020355f, 
    0.11176636f, 0.05568196f, 0.04397309f, 0.02041212f, -0.03343703f, 0.08646764f, 0.08473661f, -0.10138067f, 
    0.08081084f, -0.07409132f, 0.11692606f, 0.04914327f, 0.04173873f, 0.02678759f, -0.06618569f, 0.06569355f, 
    0.07362664f, -0.14831828f, -0.05148770f, 0.10535781f, -0.04317664f, 0.03505604f, -0.07218021f, -0.01090410f, 
    -0.06966423f, -0.04568248f, -0.02383867f, -0.00022115f, -0.06178243f, 0.06545191f, 0.01520836f, -0.11968766f, 
    0.09854163f, 0.04093367f, 0.04146589f, 0.04549530f, -0.03306739f, 0.01930911f, 0.04173462f, -0.11045969f, 
    -0.10978413f, 0.01763188f, -0.07077554f, 0.05591435f, -0.00876615f, 0.04117163f, -0.03847733f, 0.05327869f, 
    -0.00582256f, 0.03846770f, 0.08843708f, -0.02292176f, 0.29341793f, -0.03077113f, -0.18325257f, 0.15099008f, 
    0.00295129f, 0.00555969f, 0.11309445f, -0.12453691f, -0.04598248f, 0.07976799f, 0.01471760f, 0.00294687f, 
    -0.10467375f, 0.05155204f, -0.09634931f, -0.13975121f, -0.04391055f, 0.05716643f, -0.00521238f, 0.06043803f, 
    -0.09905163f, 0.00880826f, 0.08561628f, 0.04017452f, -0.01932183f, -0.10358209f, -0.07731207f, 0.19264832f, 
    0.05768015f, -0.00022589f, 0.07391468f, 0.03940819f, -0.04146175f, 0.01492218f, -0.00550876f, 0.04684456f, 
    0.01436486f, -0.11736441f, -0.04255156f, -0.02625770f, 0.03404955f, 0.13132763f, 0.00332036f, 0.07628288f, 
    0.02247974f, -0.07263326f, 0.05932914f, 0.00199403f, -0.01142861f, 0.08314875f, 0.07285140f, -0.17446148f, 
    0.12417382f, 0.02941521f, -0.04958953f, -0.01150779f, -0.08559964f, -0.02972143f, 0.09728931f, 0.03221972f, 
    0.25788677f, -0.04848710f, -0.07599474f, 0.05690657f, 0.06918439f, -0.03175459f, 0.07342801f, -0.03321019f, 
    0.04914360f, 0.11032084f, -0.13333969f, 0.03939678f, 0.27515075f, 0.17959276f, 0.05722260f, 0.05604422f, 
    -0.09800232f, 0.00486775f, 0.02862831f, 0.11395497f, -0.05696307f, 0.01939451f, -0.08008932f, 0.12138069f, 
    0.14607540f, 0.09091617f, -0.08466088f, 0.17407086f, -0.02076095f, 0.03155202f, 0.17627788f, 0.12469564f, 
    0.08978633f, 0.07792845f, 0.07650070f, 0.08858369f, -0.09126115f, -0.14054371f, -0.24091095f, -0.12602277f, 
    -0.00287190f, -0.05079647f, -0.00880190f, -0.10005352f, 0.12030224f, -0.01386640f, -0.01454736f, 0.09234385f, 
    -0.17897461f, 0.09554594f, 0.09853601f, -0.11284444f, 0.14179778f, 0.11779334f, -0.01708026f, 0.01682420f, 
    0.03083802f, -0.00401163f, 0.05882964f, 0.18121594f, -0.17385918f, -0.16449645f, 0.13168199f, 0.21794271f, 
    -0.03916422f, -0.08887506f, -0.04432149f, 0.05237631f, 0.05125232f, 0.02585092f, 0.13378787f, -0.03244442f, 
    -0.19917227f, -0.00240935f, 0.15928926f, -0.00116412f, -0.05564259f, 0.04049094f, 0.01593376f, -0.01477669f, 
    0.08274709f, 0.05714380f, -0.02112052f, 0.17267305f, 0.04094064f, -0.08002079f, -0.16323313f, -0.00422319f, 
    -0.04825367f, 0.10047697f, 0.03483691f, -0.02472049f, -0.09869507f, 0.00111546f, 0.12327252f, 0.08549330f, 
    0.08137880f, 0.01721485f, 0.12795909f, -0.01092453f, 0.02478346f, 0.02437351f, -0.06983797f, 0.00085236f, 
    0.08397060f, 0.00935350f, -0.06600787f, -0.06743814f, -0.18157484f, 0.07358005f, 0.05720652f, -0.05656388f, 
    0.00208583f, 0.09996773f, 0.09073488f, -0.05133968f, -0.01958178f, 0.00312792f, -0.02102770f, 0.04390856f, 
    0.09157770f, -0.11127344f, -0.03415300f, -0.07310698f, 0.14372174f, -0.11448872f, -0.07318905f, 0.03761658f, 
    0.01292800f, -0.00217567f, -0.00277090f, 0.01845409f, -0.00959701f, -0.02794189f, 0.03503387f, -0.11361470f, 
    -0.00479109f, 0.11482739f, -0.06439561f, 0.04554202f, 0.11564893f, -0.00615326f, 0.03499598f, 0.01421090f, 
    0.05213296f, -0.09111315f, 0.00752077f, 0.26083449f, 0.10473372f, 0.09812675f, 0.08797878f, 0.01822362f, 
    -0.03579699f, 0.09465336f, 0.00924308f, 0.05928832f, 0.00344443f, 0.19147493f, -0.01215326f, -0.20952144f, 
    0.07572284f, 0.00613462f, -0.10548241f, 0.12368568f, 0.11400074f, 0.03213410f, -0.07682653f, 0.07490968f, 
    0.03092293f, 0.03690690f, -0.00664528f, -0.33041272f, -0.01885989f, 0.01202501f, -0.08322046f, 0.00420223f, 
    -0.01266068f, -0.00327417f, 0.10247578f, -0.00143785f, -0.17649455f, 0.04034861f, 0.15691170f, 0.18167195f, 
    0.04067659f, 0.17391853f, 0.00794288f, -0.00883349f, 0.08873492f, 0.02050923f, 0.06111282f, 0.01988611f, 
    -0.20194657f, 0.15489951f, -0.00031208f, 0.05535761f, 0.11199127f, -0.10196310f, 0.11645565f, 0.05385241f, 
    -0.05193441f, 0.07997911f, -0.01868694f, -0.01712194f, 0.28830913f, 0.11413631f, -0.03979076f, 0.03623020f, 
    0.08644865f, 0.01310133f, 0.02327541f, -0.03331880f, 0.08707369f, 0.00493577f, 0.03734163f, -0.03268059f, 
    -0.26574913f, -0.12893510f, 0.04887429f, 0.05014440f, -0.01739139f, -0.01069545f, -0.01904101f, 0.01212808f, 
    -0.07141463f, 0.06161417f, -0.07416784f, 0.01166445f, -0.19039457f, 0.03779073f, -0.12738799f, 0.10659086f, 
    0.10892784f, 0.02398613f, 0.01242749f, 0.00212549f, -0.03670749f, 0.07789306f, -0.04341318f, -0.00099312f, 
    0.17994532f, -0.07940605f, -0.02070036f, 0.17845313f, 0.00010589f, 0.05762300f, 0.09023371f, 0.10270000f, 
    0.01329574f, -0.03034687f, -0.16900125f, 0.05749120f, -0.45668641f, -0.03647464f, -0.08428960f, -0.10460449f, 
    0.07348530f, -0.10616206f, -0.05150805f, -0.00570179f, -0.04377662f, 0.03606353f, -0.08825202f, -0.01434978f, 
    -0.14509369f, 0.00467648f, 0.11750383f, -0.02531950f, -0.07821522f, 0.01083183f, 0.04089269f, -0.05181473f, 
    -0.04142949f, 0.00071537f, -0.02208534f, 0.04899689f, -0.17716074f, -0.00319028f, 0.11096347f, 0.05384645f, 
    0.12347210f, 0.11334230f, -0.00596748f, 0.01715380f, 0.00445760f, 0.00977142f, 0.21829616f, 0.00952916f, 
    0.00507642f, 0.03643319f, -0.11820573f, -0.30731460f, 0.07435209f, 0.15431674f, 0.05427079f, -0.00939064f, 
    0.08860132f, -0.00630142f, -0.09062053f, -0.01527060f, -0.08879655f, 0.24220194f, -0.09061421f, -0.04945782f, 
    0.10170662f, 0.01141645f, 0.07420179f, 0.13788640f, 0.10926558f, 0.08594374f, 0.18464100f, 0.12777615f, 
    0.13270040f, -0.11638881f, -0.03297476f, 0.17964731f, -0.06194800f, 0.02230632f, -0.22640643f, 0.10243145f, 
    0.04562975f, 0.03269501f, 0.06053209f, -0.02584144f, 0.50247818f, 0.01557617f, -0.10914833f, -0.02330252f, 
    -0.10183741f, 0.05164539f, 0.01153756f, -0.07872956f, 0.02831515f, 0.10411737f, -0.12224822f, -0.03808086f, 
    -0.12995732f, -0.21554576f, -0.00683146f, -0.22499965f, 0.01669331f, -0.01545264f, 0.01593518f, 0.06756683f, 
    0.02121378f, 0.04813664f, 0.07645606f, -0.05705163f, -0.17448874f, 0.17105883f, -0.23888719f, -0.25673094f, 
    0.11881747f, 0.09166195f, 0.12950823f, 0.04346010f, 0.01453253f, -0.05478803f, -0.04163578f, 0.06784560f, 
    -0.04675054f, 0.12801756f, -0.05055605f, -0.08998135f, 0.09995215f, 0.15390904f, 0.09384988f, 0.15550393f, 
    -0.05509770f, -0.05368645f, 0.07070146f, 0.00304297f, -0.13483463f, 0.13546067f, 0.08454663f, -0.18553625f, 
    0.19589846f, -0.04355339f, 0.00772589f, -0.01733026f, -0.00676342f, 0.13337414f, 0.01279906f, 0.06929168f, 
    0.08959533f, 0.03514944f, 0.00756980f, -0.05945310f, -0.00025894f, -0.00587658f, 0.03859056f, 0.20391443f, 
    0.15465145f, -0.01374598f, -0.05476695f, -0.01571590f, 0.09039247f, 0.12701826f, -0.03698310f, -0.07221197f, 
    -0.05346319f, 0.10612205f, 0.11261272f, -0.06599834f, -0.03774963f, -0.02045422f, -0.05141306f, 0.19179402f, 
    0.01639508f, -0.01130934f, 0.06187171f, 0.17581233f, -0.03728085f, 0.00175773f, 0.07593833f, 0.06938788f, 
    0.08041324f, -0.01806910f, -0.10027872f, 0.04691652f, 0.40943521f, 0.05109416f, 0.00913109f, 0.03293254f, 
    -0.02150125f, -0.06149742f, 0.00619582f, 0.00092155f, 0.10331930f, 0.03682590f, -0.04072174f, 0.12041260f, 
    -0.18373218f, 0.05543192f, 0.05708369f, 0.07050074f, 0.07360046f, -0.00270006f, -0.02576214f, -0.06149895f, 
    -0.02179557f, 0.03688171f, -0.04349403f, 0.15516213f, -0.22746414f, 0.13944958f, -0.11266915f, 0.18515733f, 
    -0.00865187f, -0.02642003f, -0.09750527f, 0.00574053f, -0.01387945f, -0.00765255f, 0.12779643f, 0.07336795f, 
    -0.13470738f, -0.04389407f, 0.00780504f, 0.02679686f, 0.00720101f, 0.02066223f, -0.02954173f, -0.01808404f, 
    -0.02643034f, 0.01629463f, 0.06912833f, 0.12805092f, 0.18943131f, -0.00525288f, 0.02312051f, -0.15239686f, 
    -0.04195939f, 0.11772210f, 0.03044426f, -0.01612485f, -0.17552586f, 0.06012085f, 0.11247889f, -0.07953273f, 
    0.25026083f, -0.10711043f, -0.10815149f, -0.00940826f, -0.00333878f, 0.05674930f, -0.12187850f, -0.06742211f, 
    0.13077384f, 0.05819879f, 0.13065246f, 0.09369445f, -0.22887048f, 0.05598614f, 0.08050402f, -0.01284439f, 
    0.06126251f, 0.00870351f, 0.07627881f, -0.02981385f, 0.02468664f, -0.02529618f, -0.05802569f, 0.05035824f, 
    0.10076769f, 0.11016519f, 0.20664038f, -0.06501401f, 0.05324817f, 0.02517638f, -0.09917143f, 0.10060949f, 
    -0.01902726f, 0.00820636f, 0.02469827f, -0.00702338f, 0.05802586f, -0.03625243f, 0.19583717f, 0.20328239f, 
    -0.01894402f, 0.06734554f, 0.02763500f, 0.04957602f, 0.07678535f, 0.01065070f, 0.06389145f, 0.01026721f, 
    -0.15782441f, -0.00673620f, -0.08288415f, 0.07735447f, 0.00257036f, 0.06231763f, 0.07345770f, 0.04346634f, 
    0.00929023f, -0.00490252f, 0.01486813f, 0.13848689f, 0.17383505f, -0.02633190f, -0.17566194f, -0.06230528f, 
    -0.05994706f, -0.01219318f, -0.06608895f, 0.09765655f, 0.07439557f, 0.10207580f, 0.01585576f, -0.02570523f, 
    -0.02006138f, -0.23490092f, -0.14962570f, 0.04911391f, -0.09908727f, 0.03341069f, -0.04664961f, 0.02330065f, 
    0.07628155f, 0.01651353f, 0.12375540f, 0.06630559f, -0.21171418f, -0.01109321f, -0.04825158f, 0.14478947f, 
    0.03631697f, 0.04410701f, 0.07926624f, -0.02034721f, 0.04171455f, 0.14846335f, 0.10126395f, -0.00643293f, 
    -0.51539469f, 0.07029226f, 0.11601873f, 0.07850896f, 0.01793165f, 0.00209106f, 0.09303412f, 0.03947507f, 
    -0.05258027f, 0.05910131f, 0.04274642f, -0.00969787f, 0.56618559f, -0.30613369f, -0.04234632f, 0.16211137f, 
    -0.04481662f, -0.02241669f, -0.03814090f, -0.01651277f, 0.02470685f, -0.08812904f, -0.00780919f, -0.04167100f, 
    0.11608370f, 0.03615992f, -0.23760912f, -0.09249372f, 0.03465348f, -0.01175503f, -0.01677227f, -0.07048385f, 
    0.07177503f, 0.06491470f, -0.01100611f, -0.09383953f, -0.13934945f, 0.18577425f, -0.11893146f, -0.19390167f, 
    0.14555241f, 0.11520794f, 0.02766119f, 0.05035866f, 0.00039121f, 0.00099475f, -0.01340536f, 0.09960724f, 
    0.12469116f, -0.03960273f, -0.13950314f, -0.03477921f, -0.03280080f, 0.04433912f, 0.01649615f, -0.07739814f, 
    0.07109080f, -0.14908831f, -0.07840877f, -0.00447726f, 0.01155171f, -0.01276518f, -0.03204602f, -0.00588222f, 
    0.05894863f, -0.08660396f, 0.06539094f, -0.05574491f, -0.02167416f, 0.08201495f, 0.05801579f, 0.02101568f, 
    -0.20890841f, 0.14201178f, 0.01405764f, 0.08652677f, -0.01687200f, 0.05793216f, -0.02719282f, -0.02691338f, 
    -0.00928584f, 0.06344318f, 0.00950287f, 0.02102503f, -0.17825677f, 0.02417377f, 0.03792144f, 0.06369054f, 
    0.04206963f, 0.09582251f, 0.02012106f, 0.04465637f, 0.07297926f, -0.05264189f, 0.02088388f, 0.09323138f, 
    0.15123801f, 0.17429242f, 0.32071301f, -0.07602385f, -0.10608783f, -0.11175569f, 0.20349139f, -0.00193868f, 
    -0.03140085f, -0.10316622f, -0.12385986f, -0.10675383f, -0.03520342f, 0.14001784f, -0.00787151f, 0.09838276f, 
    0.01777142f, 0.04213161f, -0.01742027f, -0.08470557f, -0.09501456f, -0.01758408f, 0.03887451f, 0.06379826f, 
    -0.02606711f, 0.40605250f, 0.09635921f, -0.04111962f, 0.07206637f, 0.08909219f, 0.06573661f, -0.04456598f, 
    0.09333491f, -0.09608030f, -0.03430722f, -0.05952988f, -0.12119277f, 0.23989914f, -0.18233308f, -0.14698565f, 
    0.00763249f, 0.01291587f, -0.02440748f, 0.10078184f, 0.03988210f, -0.03365928f, 0.04272632f, -0.10838392f, 
    0.24610086f, -0.31244630f, 0.31623733f, 0.18246685f, 0.06427225f, -0.03517861f, 0.07029916f, -0.11718145f, 
    0.00218671f, 0.04440931f, -0.07940496f, -0.01314861f, -0.30218664f, 0.20700704f, 0.22026576f, -0.03534596f, 
    0.04890217f, 0.03385294f, -0.08622459f, -0.00048311f, 0.01912985f, 0.01921311f, -0.01981477f, 0.01696686f, 
    0.19216017f, -0.05355343f, 0.08298008f, -0.22318034f, 0.09117795f, -0.05002977f, -0.07947583f, 0.00778906f, 
    -0.01124186f, 0.07446390f, 0.05436970f, -0.01043873f, 0.05212175f, 0.20477213f, -0.18124832f, 0.19727392f, 
    -0.00437888f, 0.09044288f, 0.01999579f, 0.02244840f, -0.07550456f, 0.06731950f, -0.00548223f, 0.05042273f, 
    -0.01430080f, -0.06179526f, -0.21364805f, 0.05041064f, 0.12620588f, 0.09728215f, -0.00986855f, 0.02020863f, 
    0.15734762f, 0.01741777f, -0.13376024f, 0.01794746f, -0.01354184f, 0.01500721f, -0.00734905f, 0.03509641f, 
    -0.03761179f, 0.10040037f, 0.09480368f, -0.07536793f, 0.05451469f, 0.08339321f, -0.02878872f, 0.02758172f, 
    -0.36493602f, -0.03404552f, -0.20564282f, -0.00521264f, 0.07078046f, 0.13230038f, -0.08977840f, -0.05343550f, 
    -0.00682996f, 0.01732521f, 0.00844410f, 0.00301067f, 0.25300047f, 0.16672772f, 0.02535011f, -0.18964493f, 
    0.08331624f, 0.09528421f, -0.01590451f, -0.03429196f, 0.04735031f, -0.01239344f, -0.02604991f, -0.03177455f, 
    0.29132384f, -0.02516602f, -0.05091942f, 0.33074868f, -0.27821141f, 0.07148948f, 0.04496232f, 0.08792085f, 
    -0.05471021f, -0.03534408f, 0.01812530f, -0.04480027f, 0.13303146f, 0.10277417f, 0.01743039f, -0.04548809f, 
    -0.08728092f, -0.12363631f, 0.06402883f, -0.05153032f, 0.00551665f, -0.10754877f, -0.02099327f, -0.02076331f, 
    0.15534739f, 0.18565609f, 0.11190922f, 0.17292097f, -0.02123029f, -0.00767985f, 0.00605406f, 0.01442632f, 
    0.06007856f, -0.05017838f, 0.05107016f, 0.11331741f, -0.27266112f, -0.18165708f, -0.19214901f, -0.00551639f, 
    0.03078842f, -0.01408360f, -0.06586032f, 0.11824100f, 0.11840028f, 0.02863089f, -0.01270487f, 0.13848287f, 
    0.15869907f, 0.05409771f, -0.07533602f, -0.08957057f, 0.04163009f, 0.03222580f, 0.06723333f, -0.02008143f, 
    -0.02017228f, -0.10964853f, 0.00318708f, -0.02342950f, 0.16042776f, -0.03452372f, -0.02480507f, 0.20702434f, 
    -0.10697998f, 0.01271041f, 0.07469899f, 0.01465464f, 0.00320088f, -0.09162685f, 0.03478326f, 0.05909975f, 
    -0.02941431f, 0.11204325f, -0.07247942f, -0.02487185f, 0.02597667f, -0.04939885f, -0.00610718f, -0.07459445f, 
    0.00124016f, 0.08621816f, -0.07223290f, 0.12859608f, -0.02571304f, 0.06643102f, 0.05653701f, 0.16304243f, 
    -0.09225321f, 0.08917470f, -0.00822595f, -0.05282587f, 0.08903518f, 0.08137638f, 0.11973871f, -0.13904086f, 
    0.25527421f, 0.06714532f, -0.04098651f, -0.01342388f, -0.10175558f, -0.00070249f, 0.02382809f, 0.12699072f, 
    -0.09020437f, 0.07072064f, 0.03268419f, -0.02521187f, 0.12916428f, -0.01467566f, 0.19625862f, -0.00474278f, 
    -0.00122978f, 0.09449417f, 0.00952387f, -0.05829445f, 0.07751565f, 0.00571213f, -0.01062341f, 0.03191078f, 
    0.04586688f, -0.05372273f, 0.04371385f, 0.01908184f, 0.05584905f, 0.06794373f, -0.12014221f, -0.09883961f, 
    -0.02261047f, 0.12520058f, 0.07090323f, 0.08586917f, 0.18040942f, 0.07246069f, 0.04137665f, -0.03022201f, 
    -0.18096554f, -0.05147752f, 0.10633335f, 0.12183361f, -0.01183488f, -0.05939502f, -0.01521386f, 0.01579270f, 
    -0.11278950f, 0.08183508f, -0.06977718f, 0.19136149f, -0.04842173f, 0.10055631f, -0.03334755f, 0.16047646f, 
    0.04452455f, -0.00316017f, 0.05507550f, -0.01820888f, 0.04335956f, 0.02448023f, -0.06282885f, 0.15602486f, 
    -0.09521855f, 0.19491686f, 0.00756111f, -0.05958297f, 0.05307023f, -0.10188538f, 0.08017457f, -0.02333830f, 
    -0.06168212f, 0.09893891f, 0.13525738f, -0.05055893f, -0.00574417f, -0.01514800f, 0.06682937f, -0.00207977f, 
    0.02357112f, 0.01124850f, 0.07401314f, 0.07229162f, -0.38722783f, 0.12962767f, 0.09792021f, -0.02372969f, 
    -0.00084820f, 0.03318241f, -0.04569254f, 0.17147873f, -0.03079293f, -0.04124668f, -0.03354880f, -0.07611996f, 
    -0.15951592f, 0.12594414f, 0.06354573f, -0.03519024f, 0.03430551f, 0.08979997f, 0.02782653f, 0.03968126f, 
    0.11116726f, 0.17694134f, -0.04106777f, -0.00149036f, 0.09410769f, -0.15813766f, 0.10569332f, -0.19481514f, 
    0.10863937f, -0.09084456f, -0.02257429f, -0.09753434f, 0.12501560f, -0.04273496f, 0.06822404f, 0.05531984f, 
    0.02275314f, -0.06674314f, 0.18090598f, 0.21353129f, -0.12719195f, 0.04172384f, -0.01415563f, -0.00427464f, 
    -0.16414259f, -0.04846844f, 0.06658842f, -0.02683304f, 0.08905128f, -0.07361984f, -0.15946418f, 0.15257670f, 
    -0.17930761f, 0.05551932f, -0.04486513f, 0.10431959f, -0.27003270f, 0.01225493f, 0.05853089f, -0.15921828f, 
    -0.13535793f, 0.00602357f, -0.05942043f, 0.10438889f, -0.00550854f, 0.02580989f, 0.09168172f, 0.01048674f, 
    0.05141114f, -0.02499006f, -0.02878926f, 0.13694198f, 0.15096883f, -0.14625640f, 0.04236460f, -0.02609893f, 
    0.08991130f, 0.05437225f, 0.01939216f, 0.01902979f, -0.06279859f, 0.03234744f, -0.02136664f, 0.01782474f, 
    -0.01342876f, -0.22925310f, 0.09269339f, -0.01409947f, 0.02041866f, -0.01157951f, -0.03198935f, -0.04305483f, 
    0.02813767f, 0.00788624f, 0.07001405f, 0.05306176f, -0.26747140f, -0.10194433f, -0.14634918f, -0.14615685f, 
    -0.02842405f, 0.06252992f, -0.03069607f, 0.08761958f, 0.01926945f, 0.08176704f, -0.01285662f, -0.07134864f, 
    -0.12814927f, 0.00988093f, 0.04740436f, -0.04776118f, 0.07682863f, 0.07133718f, 0.06974443f, -0.00573556f, 
    -0.01113067f, 0.04316159f, 0.05878706f, -0.02114267f, 0.10891937f, -0.24143283f, -0.19127405f, 0.08046376f, 
    0.00778640f, 0.01282584f, 0.05428563f, 0.03117821f, 0.05543132f, 0.04655352f, -0.04667853f, 0.07654476f, 
    0.07121882f, 0.00781077f, -0.01096198f, 0.08113100f, 0.03900850f, 0.03542601f, 0.00253196f, 0.01572667f, 
    0.07209297f, 0.05627905f, 0.00886880f, -0.01412913f, 0.33842111f, -0.13784999f, 0.17325361f, -0.26767337f, 
    0.01942004f, -0.07650141f, 0.02456668f, 0.02884921f, 0.02965389f, 0.00667087f, 0.04426365f, 0.05227717f, 
    -0.06359947f, -0.07294571f, -0.06559043f, 0.00586353f, 0.10315341f, -0.08271389f, 0.05270018f, -0.05979072f, 
    0.03705788f, -0.06455759f, -0.02210003f, -0.01093360f, -0.10004590f, 0.00662360f, -0.19314526f, -0.08303990f, 
    0.00611333f, 0.13055059f, 0.06529441f, -0.03995498f, 0.09730992f, 0.12854868f, -0.08269405f, 0.11308645f, 
    -0.21611178f, -0.11713383f, 0.04711265f, -0.10169397f, 0.01963376f, 0.05517612f, 0.09618989f, -0.06294850f, 
    0.04863575f, 0.02353485f, -0.06751535f, 0.12973809f, -0.09568477f, -0.21637174f, -0.07520689f, 0.14158872f, 
    0.00197030f, 0.01634748f, -0.00719846f, 0.09969941f, -0.03926365f, 0.02223637f, 0.01056735f, 0.13029528f, 
    -0.02962462f, 0.28041965f, 0.18773006f, -0.04840150f, 0.06022016f, -0.00618791f, -0.03561131f, 0.01953559f, 
    0.03076812f, -0.01217759f, 0.03287012f, 0.16626310f, 0.29024369f, 0.34038356f, -0.10668223f, 0.21670631f, 
    -0.07965524f, 0.02373860f, 0.11601936f, -0.01037149f, 0.08821825f, 0.00996893f, 0.11023902f, -0.03726372f, 
    0.12140408f, 0.30826417f, 0.18887825f, 0.05180969f, 0.03898340f, -0.07281313f, 0.01574489f, 0.06156873f, 
    -0.00596052f, 0.07343385f, 0.04401750f, 0.08223260f, -0.15300481f, -0.05361580f, 0.00866976f, 0.06349571f, 
    0.11349110f, 0.02282768f, 0.03044247f, 0.02177927f, -0.01599682f, 0.02612417f, 0.03947795f, -0.07871010f, 
    0.26952001f, 0.01493152f, -0.02935555f, 0.02047910f, -0.04998186f, 0.01401380f, 0.04869846f, 0.06551819f, 
    0.00351807f, -0.00224190f, 0.09540596f, -0.05597408f, 0.06910188f, 0.33981618f, 0.12454958f, 0.00180806f, 
    -0.05278598f, 0.01909343f, 0.06318814f, -0.04356920f, -0.02768108f, 0.02003864f, -0.02640358f, 0.02832188f, 
    -0.11191465f, -0.09387574f, -0.09255826f, 0.03402003f, 0.14710680f, 0.06509562f, -0.00494054f, -0.00931368f, 
    0.05975941f, -0.00203912f, 0.12820135f, -0.04567638f, 0.34825405f, 0.20274708f, 0.21401501f, -0.04322888f, 
    0.02975802f, -0.02018040f, 0.01244522f, 0.08441006f, 0.00615728f, 0.04761328f, -0.09665900f, -0.01761596f, 
    0.09820332f, 0.10438916f, -0.09114484f, 0.02760239f, 0.07690119f, -0.09437570f, 0.05589394f, -0.13226572f, 
    0.05155364f, 0.00286931f, -0.02991003f, 0.15588382f, 0.02113786f, 0.01807941f, 0.05995215f, -0.07966344f, 
    0.01454296f, -0.10205418f, -0.06598703f, 0.07971027f, -0.03280208f, -0.12809640f, 0.04211522f, 0.13750090f, 
    0.05582246f, -0.02015003f, 0.09583520f, -0.34351033f, -0.07070313f, 0.10552623f, -0.09517169f, -0.04194912f, 
    0.00615917f, 0.03353745f, 0.00690831f, -0.05971908f, 0.40265399f, 0.27840009f, 0.07940173f, 0.03473361f, 
    -0.10848483f, 0.14532381f, -0.02046246f, -0.04374095f, 0.03576326f, 0.00491256f, 0.00167420f, -0.06561676f, 
    -0.18653859f, 0.00291166f, 0.04671307f, -0.12722170f, -0.04719878f, 0.06303091f, 0.05619886f, 0.03617448f, 
    0.01647255f, -0.02066673f, 0.06574001f, -0.04470642f, 0.16112119f, -0.18929231f, -0.05786221f, -0.07152689f, 
    0.06068362f, 0.00598319f, 0.03332856f, -0.00226808f, 0.06664721f, 0.00457556f, 0.08661865f, -0.04308507f, 
    -0.04031236f, -0.24841487f, -0.11873686f, 0.14471394f, -0.04818441f, 0.08507418f, -0.00755506f, -0.05121778f, 
    -0.02846460f, -0.04925894f, 0.00747940f, -0.03051042f, 0.02818953f, -0.11636276f, -0.01353660f, -0.08716203f, 
    -0.14405410f, 0.05131635f, 0.07773586f, 0.06466754f, -0.00098607f, 0.11835352f, -0.07364672f, 0.07198431f, 
    0.02701671f, -0.23244470f, -0.21042116f, -0.16636400f, 0.06420147f, 0.04807101f, 0.26181057f, -0.01701774f, 
    -0.03060277f, -0.02388910f, -0.03766068f, 0.00143930f, 0.05980803f, -0.17602569f, -0.15351525f, 0.15958843f, 
    -0.02551846f, -0.00997776f, -0.04821464f, 0.01041791f, -0.13896868f, 0.07452919f, -0.02582954f, 0.00240492f, 
    0.20550562f, 0.20052420f, 0.15651958f, -0.04803471f, -0.02465478f, -0.02864211f, 0.00950559f, -0.04696999f, 
    0.08951786f, 0.07576834f, 0.01276736f, 0.05115817f, 0.25256550f, 0.02891470f, 0.28159508f, 0.07116149f, 
    0.01868124f, -0.00384073f, 0.01765993f, 0.00277075f, 0.00022898f, -0.06276602f, 0.15169796f, 0.03333995f, 
    -0.04677839f, 0.02353559f, -0.02135053f, -0.03596559f, -0.02263695f, -0.03964867f, 0.03614929f, 0.03362131f, 
    -0.00412465f, -0.02784387f, 0.01384486f, -0.02088310f, -0.04717543f, -0.01176704f, 0.02887603f, -0.03389004f, 
    0.03379828f, -0.03277490f, -0.04886448f, -0.00186338f, 0.03868759f, -0.03680903f, 0.01531517f, -0.03771357f, 
    0.01651515f, -0.05243169f, -0.02547849f, -0.01584635f, 0.02845693f, -0.02476025f, 0.03522411f, -0.03660128f, 
    0.01430871f, -0.02885035f, 0.01490524f, 0.04222791f, -0.01570419f, -0.02959801f, 0.00289843f, -0.03823076f, 
    0.03231474f, 0.03096884f, -0.00386829f, -0.04499102f, -0.04167936f, -0.04292111f, 0.00576585f, -0.00734121f, 
    -0.00043966f, 0.03001853f, 0.03581804f, 0.04216046f, -0.04521984f, 0.03919891f, -0.04738419f, 0.01942582f, 
    -0.05193366f, -0.05638283f, 0.01955756f, -0.00851746f, -0.02732440f, 0.04505991f, -0.01885619f, 0.02515651f, 
    -0.00495960f, -0.04498673f, -0.03666010f, 0.05208852f, -0.05245976f, -0.02698121f, 0.04018524f, 0.01808964f, 
    0.00219013f, -0.02200034f, -0.05395267f, -0.01129002f, 0.02321754f, 0.03411199f, -0.04559482f, -0.05693029f, 
    0.04057214f, -0.03407468f, 0.04219181f, -0.01108317f, 0.03350029f, -0.03057966f, -0.02908535f, -0.01039213f, 
    -0.01128539f, 0.01033961f, 0.01987320f, -0.03150594f, 0.04435245f, -0.03897898f, 0.03873809f, -0.03752849f, 
    0.01060155f, 0.00360841f, -0.03310922f, 0.02881243f, -0.01636592f, 0.04477936f, -0.06234822f, 0.02585709f, 
    -0.00232173f, -0.04370376f, 0.02419929f, -0.03609264f, -0.02038909f, -0.01603956f, 0.01384601f, -0.02301113f, 
    0.05228698f, -0.00428317f, -0.02878939f, 0.01757601f, -0.00680160f, 0.00661578f, 0.00664318f, 0.02844471f, 
    -0.04794028f, -0.03304126f, 0.03900214f, -0.02750814f, -0.04777035f, 0.00613731f, -0.03911907f, -0.00332607f, 
    0.00232602f, -0.03456309f, 0.00106168f, -0.00122569f, -0.01726540f, -0.05262505f, 0.03178900f, -0.00283905f, 
    -0.02829309f, -0.02710119f, -0.02516032f, -0.03694563f, 0.00378521f, -0.04757562f, 0.04193867f, -0.02624339f, 
    -0.04132215f, -0.04275715f, -0.02699494f, -0.03853241f, 0.01307008f, 0.02617998f, 0.04191744f, -0.01034957f, 
    -0.02110116f, -0.02497903f, -0.04262395f, 0.00495188f, -0.00178418f, 0.04807840f, 0.02129066f, -0.04830674f, 
    0.00941093f, -0.03126713f, 0.02287085f, -0.02329959f, -0.05520869f, 0.02285053f, -0.04782391f, -0.04441645f, 
    -0.02689615f, 0.04732197f, -0.04705929f, 0.01377675f, -0.01264617f, -0.01506462f, 0.02204342f, -0.05405096f, 
    -0.04314663f, 0.04550230f, -0.02487945f, -0.05054332f, 0.00902648f, 0.01450516f, 0.03588327f, -0.03568634f, 
    0.04903454f, 0.00493022f, 0.04589190f, -0.05199331f, 0.02895826f, 0.00487491f, -0.03660389f, 0.02000486f, 
    -0.00838164f, -0.03014416f, 0.04541487f, -0.02933333f, -0.01894339f, -0.04452673f, 0.01147207f, 0.03207937f, 
    0.02284044f, 0.01602777f, -0.02941716f, 0.01635739f, -0.04762542f, -0.02515970f, 0.01969262f, 0.02021727f, 
    0.00550234f, -0.03272032f, 0.03394530f, -0.03781452f, -0.02279880f, -0.00134157f, -0.01006125f, -0.04688562f, 
    -0.00030907f, 0.00539132f, -0.00315300f, -0.00027050f, 0.03826125f, -0.01665139f, -0.02490050f, 0.04157568f, 
    0.03381812f, -0.01051824f, -0.02972556f, 0.04169500f, -0.04619244f, -0.03251952f, 0.04004172f, -0.06409834f, 
    0.01722222f, 0.03500316f, 0.00028285f, -0.03767179f, -0.01221327f, -0.04350464f, 0.03364721f, -0.02381306f, 
    0.00160435f, 0.03180460f, 0.01025399f, -0.01992289f, -0.02688254f, -0.00310937f, -0.01780839f, 0.00922909f, 
    0.02918999f, -0.04343465f, -0.04412161f, 0.01353183f, 0.02436518f, 0.01665864f, -0.00852630f, 0.01281972f, 
    0.02566605f, -0.00492962f, 0.01984452f, 0.03807871f, 0.02560749f, -0.01364675f, -0.00736258f, 0.04535329f, 
    0.02785737f, 0.04923436f, 0.03124443f, 0.03394124f, -0.02417565f, 0.04302924f, 0.02700469f, -0.00532835f, 
    0.00163391f, -0.01385162f, -0.00889234f, -0.03414848f, -0.04141401f, 0.00396787f, -0.04780700f, 0.03408121f, 
    -0.04185038f, -0.01547972f, -0.03807638f, -0.03143020f, 0.02511946f, -0.00258066f, -0.04318578f, -0.05508619f, 
    -0.01259096f, 0.03580076f, -0.05023133f, 0.03226514f, -0.02834554f, -0.03922349f, -0.01121899f, 0.02626734f, 
    0.02280830f, -0.02356576f, 0.00024240f, -0.03358961f, -0.02863514f, 0.00376033f, 0.03700848f, 0.00419709f, 
    0.04219087f, -0.02297395f, 0.01750646f, -0.01433745f, 0.02171251f, -0.03209721f, -0.00346410f, -0.05228399f, 
    0.01998097f, 0.00040580f, -0.01096848f, -0.00516992f, -0.02629405f, 0.03164615f, 0.04256122f, -0.02599294f, 
    -0.02243008f, 0.03354229f, -0.01516878f, -0.05568554f, 0.04712187f, -0.03657754f, 0.02606944f, -0.04003105f, 
    0.03809975f, -0.04796180f, 0.00416604f, -0.01979359f, -0.01704265f, -0.02828403f, 0.03568615f, -0.02033412f, 
    -0.00918854f, 0.04634858f, 0.05012728f, 0.02989780f, -0.01296673f, -0.02941154f, 0.01992375f, -0.03090414f, 
    -0.03330155f, 0.02928520f, -0.02562389f, -0.03373703f, 0.02716182f, 0.02872827f, -0.04789498f, -0.01216932f, 
    0.02236437f, 0.00352999f, 0.00340441f, 0.03151913f, 0.00075067f, -0.05324582f, -0.00208196f, 0.01314405f, 
    0.02305261f, -0.03156937f, 0.00969834f, -0.02822624f, 0.04263540f, -0.00311775f, -0.03475531f, -0.00173749f, 
    0.01782255f, 0.02271134f, -0.04863759f, -0.03952577f, 0.02892386f, 0.02080212f, 0.00148062f, 0.01545816f, 
    0.03816710f, -0.03827530f, -0.02896792f, 0.00234881f, -0.02944512f, -0.04211649f, 0.02809007f, 0.00518414f, 
    0.01952315f, 0.04339117f, 0.02203680f, -0.01198919f, 0.04172683f, -0.02634440f, -0.05787466f, 0.00510580f, 
    0.00316823f, -0.03285771f, -0.05143183f, -0.01612998f, -0.04489923f, 0.02509510f, 0.04791243f, -0.01494940f, 
    -0.05015251f, 0.00131117f, 0.00739527f, -0.03848568f, 0.02277170f, -0.01914672f, -0.02116234f, -0.03292361f, 
    -0.04044655f, -0.00803399f, 0.02346125f, -0.00518832f, -0.04327616f, -0.04247158f, -0.05124503f, -0.00621690f, 
    -0.05630392f, -0.02580320f, 0.02054819f, 0.02383072f, 0.02045849f, 0.04358067f, 0.03959720f, -0.04525511f, 
    0.01963572f, -0.02681848f, -0.05608071f, -0.03461047f, 0.01121042f, 0.00525726f, 0.04013442f, -0.00190968f, 
    -0.04371184f, 0.02691494f, 0.03782710f, -0.00822842f, 0.04580223f, -0.00369389f, -0.00095682f, -0.03226712f, 
    0.01152543f, -0.00631524f, 0.03930386f, -0.05947674f, -0.04653975f, 0.01675101f, 0.01747899f, 0.01603941f, 
    0.01757632f, 0.02241948f, 0.02141829f, -0.02852728f, 0.04314509f, 0.02556232f, -0.02842519f, 0.00763603f, 
    -0.01880902f, 0.03246292f, 0.05162410f, -0.03812061f, -0.05957668f, 0.04248354f, -0.03719139f, 0.01467981f, 
    0.01312697f, -0.02300156f, -0.03350447f, -0.02661016f, -0.01718985f, 0.00967968f, -0.02956626f, -0.03402666f, 
    -0.01736590f, 0.01207722f, 0.01073321f, 0.01345790f, -0.05163688f, 0.01567470f, 0.03340628f, 0.02696623f, 
    -0.04568388f, -0.05850443f, 0.02407856f, 0.01058181f, -0.00864620f, -0.01980471f, 0.03009220f, -0.03397893f, 
    -0.03828645f, -0.05019859f, 0.00749424f, 0.02932143f, -0.03146026f, -0.01490523f, -0.02668263f, -0.00693802f, 
    -0.05841321f, 0.03415008f, -0.04025115f, -0.02706875f, 0.02074025f, -0.01207485f, -0.05616403f, 0.00504584f, 
    0.01888396f, 0.03466514f, -0.01473107f, -0.05342786f, 0.00898716f, -0.04026188f, 0.02007863f, 0.03232388f, 
    -0.02494243f, -0.00645051f, 0.01077482f, -0.01655482f, -0.01399393f, 0.00781670f, -0.03900263f, -0.03570908f, 
    0.04241006f, 0.00373844f, 0.02066506f, -0.04787774f, -0.01534855f, -0.01278934f, -0.01765147f, 0.04155387f, 
    -0.02165582f, -0.01142191f, -0.03229412f, -0.00997158f, -0.00997952f, 0.02772100f, 0.04035140f, 0.01037771f, 
    -0.03727835f, 0.01592382f, -0.04337556f, 0.02668064f, 0.04210943f, -0.03485825f, 0.02016953f, -0.03702721f, 
    0.02112943f, -0.04308761f, -0.00555986f, 0.01373872f, -0.02572028f, 0.02537709f, -0.00188243f, -0.03601487f, 
    -0.00201112f, -0.04564979f, 0.00478452f, -0.05152208f, 0.00722038f, 0.01975598f, -0.01525249f, 0.03293307f, 
    -0.00257199f, 0.00350911f, 0.01394913f, 0.02091669f, -0.00716921f, 0.03251445f, 0.03374112f, -0.03579614f, 
    -0.04854745f, 0.02885270f, -0.04051950f, -0.05270050f, -0.02281836f, 0.03689539f, -0.01558381f, 0.00308716f, 
    -0.01194752f, -0.00799670f, 0.02728975f, -0.00061637f, -0.00205696f, -0.05560783f, 0.00000768f, -0.03026462f, 
    -0.05357294f, -0.03067534f, 0.03843138f, 0.03895378f, 0.03235930f, 0.00869055f, 0.01495323f, -0.03976404f, 
    0.00069220f, -0.00100521f, -0.03704626f, -0.04113136f, 0.00049557f, -0.01293351f, -0.01173227f, -0.04013639f, 
    0.03035212f, -0.04517952f, -0.04876391f, -0.01458734f, -0.00141145f, -0.01211142f, -0.01189833f, -0.05383874f, 
    -0.04046032f, -0.00870320f, 0.03666447f, -0.05105083f, -0.02209830f, -0.03080252f, -0.03280232f, 0.01645678f, 
    0.03315751f, -0.02446965f, 0.02146600f, -0.04925094f, 0.01878360f, -0.04178023f, -0.04631164f, 0.02603813f, 
    0.02369936f, -0.03705622f, 0.01670436f, -0.04773977f, -0.02921506f, 0.03924535f, 0.00609936f, -0.02818102f, 
    0.01832033f, -0.04874936f, 0.03080287f, -0.04805680f, 0.00452330f, 0.04361618f, -0.04007477f, -0.03878925f, 
    0.03746606f, -0.02993049f, 0.01060009f, 0.02143415f, 0.04496043f, -0.03560638f, 0.03620953f, -0.02069181f, 
    0.04045724f, -0.03281317f, -0.01931159f, 0.03291034f, -0.05333267f, -0.01789257f, -0.01919922f, 0.00112064f, 
    -0.02653360f, 0.02895420f, 0.03457342f, -0.00547678f, 0.02161087f, 0.00988986f, 0.01406469f, 0.00263722f, 
    -0.05084053f, -0.02559407f, 0.00002304f, -0.02538467f, 0.01520271f, 0.01169356f, -0.02020954f, 0.00994615f, 
    -0.01506715f, -0.00758859f, -0.01712975f, -0.00936377f, 0.04717195f, 0.00178827f, 0.04236896f, -0.03281045f, 
    -0.04207042f, 0.03979931f, 0.01317504f, 0.02295350f, 0.00662376f, 0.03149161f, 0.03007104f, 0.03401668f, 
    -0.03798118f, -0.01401778f, 0.03772541f, 0.02003830f, 0.02976766f, -0.00249591f, 0.01878466f, -0.00058986f, 
    0.02915577f, -0.06082014f, 0.03494135f, 0.02702639f, 0.00360293f, -0.04905025f, -0.04409468f, -0.02645739f, 
    -0.02662672f, -0.01366568f, -0.01533584f, -0.05357649f, 0.00998007f, -0.00340350f, -0.04733280f, -0.00931216f, 
    -0.02039812f, 0.02752325f, 0.01993565f, -0.01432232f, 0.03432673f, -0.03170378f, -0.00610962f, 0.00141815f, 
    0.02705629f, -0.04377428f, -0.05353886f, -0.05633772f, -0.00229878f, -0.01472134f, -0.03208934f, -0.04101662f, 
    -0.01604996f, -0.06302479f, -0.05312026f, 0.01014654f, -0.00335537f, 0.03345992f, -0.04431366f, -0.05286346f, 
    -0.04978250f, 0.04714306f, 0.02870901f, 0.00874675f, -0.01897667f, 0.00565877f, -0.02078168f, 0.00478271f, 
    -0.00030907f, -0.01169252f, -0.04334919f, -0.05395324f, -0.00511975f, -0.02463776f, 0.03467826f, -0.05167942f, 
    0.00561188f, 0.01425222f, -0.05269020f, -0.04889166f, 0.02829575f, -0.02918577f, -0.02148019f, 0.00662000f, 
    0.02438186f, -0.03776110f, 0.00428033f, -0.04975308f, 0.00332401f, 0.01491176f, 0.01978932f, -0.02869449f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03403970f, 0.11436248f, 0.02507124f, 0.02359273f, 0.02210019f, -0.04467336f, -0.03885632f, -0.04912421f, 
    -0.04770653f, 0.00027785f, 0.03058841f, 0.09199443f, 0.02757622f, 0.00900614f, -0.08738521f, 0.09839362f, 
    0.03351148f, -0.02954184f, 0.00136911f, 0.00577916f, -0.00622104f, -0.03143243f, 0.06831213f, 0.03554402f, 
    0.04419151f, -0.01904926f, -0.00117395f, -0.03674059f, -0.00386865f, -0.02936935f, -0.01299960f, -0.02882376f, 
    0.07558272f, -0.09562539f, -0.02665923f, 0.04482731f, -0.00972546f, 0.06734022f, -0.05558759f, 0.02750189f, 
    0.03875081f, -0.02491438f, -0.03469189f, 0.03989273f, -0.02654823f, -0.03029802f, -0.05207412f, 0.02528395f, 
    0.07520052f, -0.04068055f, -0.02137218f, 0.04385835f, 0.09338840f, 0.01361223f, 0.05641639f, 0.08737563f, 
    -0.03516347f, -0.00413711f, 0.12428986f, 0.03836691f, 0.01703468f, 0.05516073f, -0.01978728f, -0.02135060f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05418287f, 0.17115057f, 0.29012179f, 0.04718770f, -0.11863896f, -0.01366272f, -0.32382703f, -0.10998242f, 
    -0.04485111f, -0.09675310f, 0.06253354f, -0.14265166f, -0.21521980f, 0.02828748f, -0.00101904f, -0.10512660f, 
    0.26386604f, -0.34188619f, 0.01971657f, 0.11032674f, -0.10673777f, 0.32251623f, -0.37209755f, -0.40642688f, 
    -0.04563363f, 0.05333506f, 0.09469417f, -0.12945111f, -0.12763251f, 0.00565653f, 0.05122945f, 0.19570196f, 
    0.21741979f, -0.06236964f, -0.04652484f, 0.10404422f, 0.04133791f, -0.39246044f, 0.17699063f, 0.07087240f, 
    0.11110294f, 0.10247773f, 0.21253258f, -0.32292977f, -0.01847562f, 0.00084649f, 0.23406525f, 0.05368939f, 
    -0.07941775f, 0.10224965f, -0.10153632f, 0.09819050f, -0.39637220f, 0.20416962f, 0.04783773f, -0.35912722f, 
    0.17375773f, 0.00354876f, -0.34100187f, 0.03762084f, 0.28487200f, -0.16197170f, -0.07187986f, 0.03095208f, 
    0.02690504f, 0.16658776f, 0.12584364f, -0.01208675f, 0.02821200f, 0.05520289f, 0.26270607f, -0.04681136f, 
    0.11077380f, -0.05272785f, 0.08110081f, 0.23085141f, 0.21315208f, 0.10727374f, 0.21240185f, -0.22987108f, 
    0.10259250f, 0.19787136f, -0.06275653f, -0.01705936f, 0.10792554f, 0.32811302f, 0.01678524f, -0.34677801f, 
    -0.72877073f, 0.04983977f, 0.10707332f, -0.05560111f, 0.07441573f, 0.09316630f, 0.04538656f, -0.17909916f, 
    0.26898685f, -0.20143381f, -0.05834669f, 0.07338288f, -0.07079726f, -0.20942445f, -0.21838166f, -0.06098246f, 
    -0.44321877f, 0.00472222f, 0.10603652f, 0.12150898f, -0.10719686f, -0.06017828f, 0.22741823f, -0.08967248f, 
    0.04554849f, 0.05291254f, 0.11294590f, 0.18047586f, 0.03200085f, -0.37287647f, -0.04778595f, -0.19392703f, 
    -0.29746351f, -0.46957418f, 0.14961098f, 0.09820163f, 0.13169326f, 0.05258623f, 0.04542098f, 0.04185516f, 
    -0.11038987f, -0.42061785f, -0.02141198f, -0.03983017f, 0.25518784f, -0.13351443f, 0.11880969f, 0.02876504f, 
    0.00380339f, -0.01039706f, 0.03632332f, -0.12424144f, -0.17908007f, 0.03967157f, 0.26975402f, 0.14797297f, 
    0.18752877f, -0.27095872f, -0.01151958f, 0.06028510f, -0.01363196f, -0.01841553f, -0.17072585f, -0.45597956f, 
    0.04650210f, -0.04702599f, -0.09030838f, -0.08817824f, -0.00109645f, -0.10230360f, 0.04007360f, 0.15808956f, 
    -0.09496736f, 0.31521386f, -0.04473823f, 0.06317180f, -0.04380176f, -0.30619922f, -0.29816470f, -0.03869346f, 
    0.05951605f, 0.03010078f, -0.04029997f, -0.07525493f, -0.03933716f, 0.02076113f, -0.44595546f, 0.11216031f, 
    0.15392713f, -0.11422354f, -0.04110820f, -0.46005535f, 0.30807111f, -0.17784478f, -0.44420531f, -0.23834851f, 
    -0.09028523f, 0.36724761f, -0.23867485f, 0.19233415f, 0.25115532f, 0.09406749f, 0.09348178f, 0.01256579f, 
    0.05532675f, -0.32473490f, -0.15992029f, 0.09881375f, 0.18930198f, 0.09230775f, -0.56451106f, -0.10492484f, 
    0.08957023f, 0.07356108f, 0.02184493f, 0.22502390f, 0.23054841f, -0.11985654f, -0.16681111f, -0.26263458f, 
    -0.01234074f, -0.20017718f, -0.08575185f, -0.03873036f, -0.00535750f, -0.43193701f, 0.35159677f, -0.10831241f, 
    -0.17233185f, -0.00906479f, -0.00912938f, 0.10864303f, -0.44728479f, 0.04042732f, -0.11338169f, -0.03951487f, 
    0.29102534f, -0.26931250f, 0.03062639f, 0.01351286f, -0.10241755f, -0.16835101f, 0.06614368f, -0.03927458f, 
    0.11445391f, 0.05285497f, 0.17317222f, 0.23442489f, -0.04440059f, -0.04131056f, 0.31010315f, -0.10649832f, 
    -0.55039710f, -0.01674977f, -0.07786031f, -0.57639694f, 0.02341692f, 0.27722275f, 0.13778904f, 0.11624865f, 
    0.13745736f, 0.17672320f, 0.10777037f, -0.13559206f, 0.18028471f, -0.62732458f, 0.05422161f, -0.02613904f, 
    0.04125649f, 0.13109696f, 0.04934383f, 0.00406727f, -0.55142510f, -0.04203738f, 0.13178842f, -0.09275661f, 
    -0.03866820f, -0.06969260f, 0.11058447f, 0.13880615f, 0.26895764f, -0.00361789f, 0.18469119f, 0.06964520f, 
    -0.37556380f, -0.21450028f, -0.00552197f, 0.00951051f, -0.07656694f, 0.05712668f, 0.04504412f, -0.17629670f, 
    0.30909669f, 0.08468944f, -0.10241899f, 0.08631803f, -0.12481651f, 0.01919292f, 0.09682299f, -0.28947699f, 
    0.26864013f, -0.00230251f, 0.01374988f, -0.05997010f, 0.01724262f, -0.00245456f, -0.13174546f, 0.05931659f, 
    0.00766666f, -0.03209668f, 0.05434845f, 0.15521395f, 0.01053620f, 0.04838966f, -0.30119252f, 0.08081798f, 
    -0.33522055f, -0.04166802f, 0.02264341f, -0.02680358f, 0.21032444f, 0.27786005f, 0.29032138f, 0.16902243f, 
    0.11193440f, -0.03549713f, -0.16866755f, -0.21186785f, -0.13907106f, 0.04099586f, 0.06162339f, -0.09696037f, 
    -0.06170259f, 0.24369994f, 0.01749695f, -0.10396686f, -0.14897086f, 0.01087537f, -0.35772514f, 0.05571079f, 
    0.10780454f, -0.02306599f, 0.05734763f, -0.26312798f, -0.24246240f, 0.04714392f, -0.14269254f, -0.05821719f, 
    -0.15517163f, 0.06883298f, -0.04363006f, 0.01874253f, -0.12683529f, -0.24035671f, 0.13881695f, 0.19184516f, 
    -0.04984854f, 0.09057885f, -0.01381424f, 0.01163006f, 0.25802568f, -0.03260451f, 0.06414326f, 0.19454733f, 
    -0.39109561f, -0.49681050f, -0.06934873f, 0.02885339f, 0.01081852f, -0.04091000f, 0.27008861f, -0.06357734f, 
    -0.39796063f, -0.08119264f, 0.00411273f, 0.08161132f, -0.03755361f, 0.00266311f, -0.20045750f, 0.11604757f, 
    0.13515370f, 0.02480127f, 0.00896625f, 0.34208158f, 0.23100141f, 0.14605565f, 0.16479826f, -0.24969433f, 
    -0.25970939f, -0.31618410f, 0.14910343f, -0.18506941f, 0.28853151f, 0.13581917f, 0.01435781f, 0.08171099f, 
    0.02884448f, -0.25928804f, 0.09956002f, -0.04109848f, -0.41307414f, -0.09685281f, 0.21243609f, -0.05794846f, 
    0.02770477f, -0.02621848f, -0.09851884f, -0.01540745f, 0.25334150f, -0.01587504f, -0.42713764f, 0.00254061f, 
    0.22897670f, -0.22419247f, 0.01587737f, -0.07589720f, -0.00590192f, -0.57007420f, -0.24039009f, 0.04887560f, 
    0.05393981f, -0.05922802f, 0.00765671f, -0.02914478f, -0.03593073f, 0.02070733f, 0.09567317f, 0.22576937f, 
    -0.25228193f, 0.12671827f, -0.02939799f, 0.06013162f, -0.05329535f, 0.29371241f, 0.11116410f, 0.00008520f, 
    -0.03241081f, -0.08556493f, -0.09991460f, 0.23618595f, -0.03572228f, -0.06554390f, -0.07205433f, 0.08464688f, 
    0.17482273f, 0.08231873f, 0.10820697f, -0.10553106f, -0.45373169f, -0.02109240f, -0.28608203f, -0.33768818f, 
    -0.33179751f, 0.49171162f, 0.26315227f, 0.17947868f, -0.17260884f, 0.22573774f, 0.02292686f, -0.00008669f, 
    0.07238489f, -0.33411503f, 0.17274021f, 0.08330023f, 0.12525687f, 0.10935570f, 0.03013005f, 0.08782052f, 
    0.09128767f, 0.01437805f, -0.06839205f, -0.34383121f, -0.39506000f, 0.11754818f, -0.08977371f, -0.35171193f, 
    -0.37830353f, 0.09255922f, 0.12085851f, -0.08140699f, -0.02383944f, 0.03550443f, 0.06829254f, 0.22662131f, 
    0.38732982f, 0.07240070f, -0.11463957f, -0.07372555f, -0.05998581f, 0.07744806f, 0.07537478f, -0.28646138f, 
    -0.40507883f, 0.33534095f, -0.03962714f, -0.03108968f, -0.07893750f, 0.32293877f, 0.05709704f, 0.06805319f, 
    -0.07363490f, 0.05206915f, -0.01897510f, -0.02025994f, 0.09282019f, -0.10581526f, 0.18167648f, -0.06183364f, 
    -0.20873559f, -0.03541088f, 0.05433765f, -0.10712509f, -0.19667128f, -0.16355295f, 0.10218492f, 0.26644897f, 
    0.19559106f, 0.18427327f, -0.05667035f, -0.25191367f, -0.39726016f, -0.15746823f, 0.11064012f, -0.05319572f, 
    0.06528626f, -0.15290175f, -0.38932544f, 0.02412404f, 0.17519230f, -0.01746106f, 0.13889699f, 0.03893086f, 
    -0.00492015f, 0.03482308f, -0.04856239f, -0.45330921f, -0.09451163f, 0.05731195f, 0.21682031f, -0.06949884f, 
    -0.16408964f, 0.08065595f, -0.07110173f, -0.08652858f, 0.00366407f, 0.13188013f, 0.11474980f, 0.02694470f, 
    -0.30672547f, -0.07046874f, -0.10454761f, -0.05398718f, -0.25030378f, -0.07703082f, 0.01558671f, 0.02972089f, 
    -0.16909115f, 0.26110452f, -0.02529288f, -0.02335097f, -0.02317541f, -0.43933821f, 0.22800194f, -0.08499434f, 
    0.10577416f, -0.03015169f, -0.40575248f, 0.26263532f, 0.12286718f, 0.03795970f, 0.10001955f, 0.07019559f, 
    0.16731462f, 0.07011997f, 0.02346064f, 0.36272740f, 0.23074898f, 0.19644885f, 0.04226517f, -0.33165026f, 
    -0.11668345f, -0.20408800f, -0.32482386f, 0.18169565f, -0.13568252f, 0.13729984f, 0.05105745f, 0.01339881f, 
    0.11078716f, -0.05414873f, -0.30860409f, 0.06875394f, 0.08639637f, 0.02972340f, -0.17732789f, 0.08785132f, 
    -0.02418022f, -0.06467348f, 0.07151507f, 0.32655370f, -0.19107865f, 0.01042013f, 0.23261495f, 0.27788767f, 
    -0.26750845f, 0.01549838f, -0.02221136f, 0.09757309f, -0.08726823f, -0.30674565f, -0.49998811f, 0.08331838f, 
    0.13099241f, 0.04880679f, 0.08426471f, 0.00850775f, 0.31896508f, -0.12340794f, -0.10915953f, -0.37174323f, 
    -0.41933402f, 0.05506364f, 0.08990764f, -0.02074724f, -0.02459962f, 0.15327612f, -0.04764441f, 0.10053124f, 
    0.32997093f, 0.01348783f, 0.02326591f, -0.21456507f, 0.02019335f, -0.04030290f, -0.09872213f, -0.05977147f, 
    0.14253740f, -0.10872628f, 0.11656822f, 0.12387124f, -0.57035571f, 0.02346382f, -0.48432139f, 0.16272861f, 
    0.19479600f, -0.10793824f, 0.15569641f, -0.04069351f, -0.11600325f, -0.00626362f, 0.11920513f, 0.05188521f, 
    -0.00943885f, 0.11777189f, 0.16911286f, 0.03073506f, 0.28371876f, 0.08696493f, -0.10616753f, -0.11034670f, 
    0.05813000f, -0.06152860f, -0.11766026f, -0.10880841f, -0.04633766f, -0.02753877f, -0.61330080f, 0.09878001f, 
    0.24814826f, -0.34258899f, 0.07244198f, -0.10251717f, 0.11878040f, 0.18484963f, 0.20895229f, 0.26435581f, 
    -0.09344130f, -0.06587426f, 0.07196651f, -0.08814276f, -0.18719189f, 0.03178262f, 0.06274659f, 0.02379401f, 
    0.32545552f, -0.20107087f, 0.00664440f, 0.00409877f, -0.09417940f, -0.03935928f, -0.50949007f, 0.06341807f, 
    -0.21234101f, -0.00330494f, -0.29949293f, -0.42200774f, -0.01891699f, -0.03494837f, -0.41336134f, 0.06102097f, 
    0.03766671f, 0.11753580f, 0.01513556f, -0.07148459f, 0.18361458f, -0.20639768f, -0.02294344f, 0.19900563f, 
    0.08454169f, -0.18732090f, 0.25110945f, 0.37846795f, -0.31989616f, -0.24141845f, -0.06780954f, 0.10164119f, 
    -0.03411592f, 0.00474098f, -0.07189297f, 0.06420753f, 0.05499902f, 0.07388667f, 0.22610243f, 0.01302943f, 
    -0.06320225f, 0.01810526f, -0.02390794f, -0.14370462f, 0.41773850f, -0.12865350f, -0.35189280f, 0.23375274f, 
    0.11675082f, 0.45977068f, -0.01335271f, -0.05113205f, 0.09411597f, -0.46417889f, 0.09637469f, 0.12881774f, 
    -0.23214613f, -0.09737210f, 0.09001635f, 0.09829035f, -0.02110459f, 0.05589978f, -0.08918490f, 0.34234431f, 
    -0.30740103f, -0.26788658f, 0.03615103f, -0.04691399f, -0.08292101f, -0.24512030f, 0.07013017f, 0.04553756f, 
    0.25045186f, 0.11073028f, -0.03287569f, -0.20911480f, 0.06526693f, 0.01851337f, 0.20577306f, -0.08869555f, 
    0.05431187f, 0.05547203f, -0.04983917f, -0.50705653f, -0.21620966f, -0.39920899f, 0.16363139f, -0.00532400f, 
    0.10318553f, -0.16211435f, -0.23185918f, -0.50452650f, -0.18446721f, 0.04869329f, -0.03560320f, -0.03936661f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01888974f, -0.07121588f, -0.11143164f, -0.03509746f, 0.08213153f, -0.07781266f, -0.07519843f, -0.08129638f, 
    -0.07848397f, 0.11744781f, 0.08646393f, 0.00715429f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
