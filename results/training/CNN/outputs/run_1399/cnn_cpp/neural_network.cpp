#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.41370523f, 0.08671413f, -0.33901769f, -0.59327513f, -0.30572468f, -0.41253334f, -0.56630284f, 0.02340904f, 
    0.06328559f, 0.59369445f, -0.05643184f, 0.43591949f, -0.09262894f, 0.24381423f, -0.11466589f, -0.22069162f, 
    -0.08553966f, 0.06066054f, 0.23099706f, -0.22550826f, -0.14508057f, -0.37984788f, -0.09574856f, 0.25047687f, 
    -0.16522941f, -0.92348647f, -0.53444600f, -0.11889017f, 0.06783140f, -0.23068379f, 0.15506005f, 0.26561728f, 
    0.20634890f, 0.59475195f, 0.43005523f, 0.17969461f, 0.15999661f, 0.06124554f, 0.29848540f, 0.07942243f, 
    0.07956025f, -0.18633966f, -0.15094271f, -0.20311460f, -0.02148961f, -0.05894602f, 0.06112762f, 0.49751669f, 
    -0.10545512f, -0.30510780f, 0.03342606f, 0.40300041f, 0.30150193f, -0.51318061f, 0.12917170f, 0.01093413f, 
    -0.12943539f, -0.10960715f, 0.15098511f, -0.04886328f, 0.20197919f, -0.29046580f, -0.16329102f, 0.24604450f, 
    -0.33739540f, 0.08570299f, 0.10302743f, 0.13593160f, 0.20714225f, -0.29696056f, -0.02324129f, 0.12693734f, 
    -0.15763099f, -0.23997235f, 0.34855586f, -0.11203851f, 0.25656763f, -0.26679921f, 0.15962428f, -0.26876247f, 
    -0.35533157f, -0.18857707f, -0.44050300f, 0.53549677f, -0.50589383f, 0.04135551f, -0.28588259f, 0.30990669f, 
    0.26779574f, -0.16745628f, 0.20330442f, 0.07079404f, 0.32857776f, -0.14001310f, 0.04906777f, -0.11393386f, 
    0.04365170f, -0.32234821f, -0.19541110f, 0.34774190f, 0.39156681f, -0.73213887f, -0.44278044f, 0.06112753f, 
    0.00453704f, 0.06761811f, 0.50580758f, 0.52225602f, -0.33533126f, -0.43951681f, -0.25696647f, -0.33096334f, 
    -0.14087220f, -0.21486755f, 0.43702316f, -0.14707771f, 0.16562381f, 0.08959956f, 0.03629259f, -0.12985420f, 
    -0.03428924f, -0.18543054f, -0.37993327f, -0.13762468f, -0.07579386f, -0.41905925f, -0.06493378f, -0.19504172f, 
    -0.17734145f, 0.24311706f, -0.30944794f, -0.29099986f, 0.13610844f, 0.15058325f, -0.28306317f, 0.21696638f, 
    -0.18939489f, -0.02995066f, 0.17254993f, 0.16146654f, 0.02818136f, -0.36349812f, 0.19125764f, -0.12184229f, 
    -0.23675591f, 0.12875547f, 0.32922584f, 0.13901441f, 0.12861650f, 0.42547950f, -0.61169130f, -0.22251624f, 
    0.34853083f, 0.72698778f, -0.32929957f, -0.19887759f, -0.58356041f, -0.69461685f, -0.30167097f, -0.15006490f, 
    -0.22337852f, 0.07308383f, -0.17006329f, -0.38413700f, 0.11275692f, 0.01188375f, 0.12294111f, 0.28302005f, 
    0.15944867f, -0.05698533f, 0.30848828f, -0.37607282f, -0.20300539f, 0.27380714f, 0.37656820f, -1.09931552f, 
    0.02255903f, -0.18610838f, -0.82882679f, -0.52584517f, 0.34563601f, 0.56467944f, -0.21455452f, -0.11075444f, 
    0.05598928f, -0.12749402f, -0.17839879f, -0.32761827f, -0.41075364f, -0.16768214f, 0.32253781f, 0.18192993f, 
    0.07550821f, 0.26600775f, 0.10173901f, 0.04919175f, 0.05297418f, -0.01767253f, -0.04205671f, -0.09738334f, 
    0.32518077f, 0.72160023f, -0.09060941f, -0.54381245f, -0.16210118f, -0.53633422f, -0.27449673f, 0.25575274f, 
    0.44798774f, 0.05398888f, -0.07259437f, 0.12399105f, 0.30632526f, -0.32151976f, 0.03719053f, 0.16063650f, 
    -0.06927630f, -0.15666141f, -0.14264484f, 0.08113262f, 0.09801436f, 0.09584058f, 0.13331108f, 0.03961666f, 
    -0.29532105f, -0.03594759f, -0.25009418f, -0.07629260f, -0.07116126f, -0.19675952f, 0.30186480f, 0.37461066f, 
    0.20257580f, -0.34840685f, -0.16850321f, 0.29188555f, -0.31088334f, -0.01609269f, 0.41537467f, -0.31828818f, 
    -0.00134741f, 0.23253722f, 0.08377454f, -0.55429208f, -0.01777873f, 0.09718623f, -0.05711560f, -0.12114427f, 
    0.21839310f, 0.42235669f, -0.57335889f, -0.57894713f, -0.30631280f, 0.59874243f, 0.64272934f, 0.45069855f, 
    -0.04387049f, -0.29057592f, -0.19170071f, -0.31868166f, -0.05791502f, -0.01702417f, 0.13422790f, -0.18182880f, 
    0.08736964f, -0.09198793f, -0.04115412f, 0.09245294f, 0.06772905f, -0.15882130f, 0.36362213f, -0.19353071f, 
    0.27800545f, 0.18926877f, -0.12912618f, -0.11237825f, 0.33251435f, -0.47227591f, 0.14783077f, 0.44178861f, 
    -0.10334761f, -0.33312786f, 0.23669817f, -0.19603942f, -0.24260435f, 0.11333577f, 0.05696362f, -0.05081571f, 
    0.05349829f, 0.05443162f, 0.02006815f, -0.11691326f, -0.24041396f, -0.02548586f, 0.27007997f, -0.04877713f, 
    0.32662210f, -0.13864538f, 0.24424450f, 0.24163984f, 0.35720718f, -0.41903836f, 0.30437294f, -0.46498927f, 
    -0.69853085f, 0.24136139f, 0.10342448f, 0.11435851f, -0.33322194f, 0.34400862f, -0.20670985f, -0.10277168f, 
    0.34062967f, -0.09338960f, -0.02689132f, -0.41437691f, 0.25839531f, 0.09728124f, -0.18292800f, 0.34433421f, 
    0.03535720f, 0.09983920f, -0.29791293f, -0.20059939f, -0.03661025f, -0.48495653f, -0.66986221f, -0.24340419f, 
    0.16368751f, 0.64309663f, -0.09145092f, -0.34562048f, 0.07227624f, 0.49219817f, 0.30783367f, 0.14569467f, 
    -0.02693436f, 0.01574459f, -0.34632471f, 0.13359527f, -0.14620513f, -0.15380338f, 0.07580991f, 0.17649713f, 
    0.04945123f, -0.04076316f, -0.09752136f, -0.04970142f, -0.00428429f, 0.41459209f, 0.15321866f, -0.43492588f, 
    -0.31106105f, -0.10245714f, -0.46816614f, -0.36192510f, -0.25106049f, -0.22576834f, -0.48721671f, -0.05421225f, 
    0.29022357f, -0.01772195f, -0.06850693f, -0.35901308f, -0.24215630f, 0.06547230f, 0.22733994f, -0.12052243f, 
    -0.09056841f, 0.00160095f, -0.33869174f, 0.14117695f, 0.10712484f, 0.14678383f, -0.23448786f, -0.68916929f, 
    0.64625728f, 0.68232399f, -0.46636149f, -0.12140062f, -0.29095745f, -0.40277487f, 0.14824262f, 0.37684709f, 
    0.33048129f, -0.48338947f, 0.12608303f, 0.04417368f, 0.31654543f, -0.40984416f, 0.05592895f, -0.08865086f, 
    -0.33986232f, 0.13311671f, 0.38245586f, -0.24934615f, 0.30603474f, 0.20364568f, -0.33933973f, -0.36301661f, 
    0.19967361f, -0.00688047f, -0.09372087f, 0.04729914f, 0.36390853f, 0.32768822f, 0.13121241f, 0.08932325f, 
    -0.40563819f, -0.09135948f, -0.39191955f, -0.34225076f, -0.01750044f, -0.16214809f, 0.17074412f, 0.13008341f, 
    -0.40420368f, 0.13212602f, 0.11173619f, -0.46134862f, -0.02714200f, 0.14471202f, -0.04004469f, 0.12524748f, 
    0.44126838f, -0.62012702f, -0.12097345f, -0.23451778f, -0.47855619f, -0.31340870f, 0.32310775f, -0.27873436f, 
    -0.28375924f, 0.11570381f, -0.29641655f, -0.10369163f, -0.09414831f, -0.18460609f, -0.46283558f, -0.27377826f, 
    -0.20288134f, -0.28595331f, -0.09589505f, -0.07922406f, -0.06152024f, -0.01491788f, 0.29141030f, 0.24006021f, 
    -0.16979365f, 0.00913221f, -0.49472341f, -0.59816033f, -0.02447130f, 0.28017601f, 0.16152109f, -0.15464148f, 
    -0.17691943f, -0.53971279f, -0.56842232f, -0.00862284f, 0.00188450f, -0.26410982f, 0.21745788f, -0.42745316f, 
    -0.26176080f, -0.11866347f, 0.05631497f, -0.30589363f, -0.07249279f, 0.18491015f, 0.29139176f, -0.32364225f, 
    -0.36173511f, 0.08963356f, -0.08151467f, -0.21046065f, -0.22527991f, -0.50137556f, -0.33798590f, -0.05937595f, 
    -0.19738078f, -0.02413111f, -0.43126658f, -0.38800162f, -0.14261700f, -0.05106647f, -0.26842412f, 0.24148691f, 
    0.48345014f, -0.03920209f, -0.30792144f, -0.24759376f, -0.27474895f, -0.43949649f, -0.47906891f, 0.17923169f, 
    0.15008397f, 0.32082790f, -0.25989017f, -0.11995088f, -0.54406548f, 0.35145217f, -0.26483476f, 0.37676430f, 
    0.25006357f, 0.49217215f, 0.10192239f, -0.53286088f, -0.37717363f, 0.20779280f, 0.36636242f, -0.25949198f, 
    0.06452079f, -0.03766513f, -0.09403778f, -0.13294224f, 0.11466238f, 0.00655590f, 0.17294016f, -0.12696746f, 
    -0.15166013f, 0.22767742f, -0.12365371f, 0.08721289f, -0.24872406f, -0.31538928f, -0.45502254f, -0.17206669f, 
    -0.23615524f, -0.40154067f, 0.27480033f, -0.15434405f, -0.50522679f, -0.16454835f, -0.42600724f, -0.15486066f, 
    0.20797130f, -0.07987507f, 0.08010606f, -0.18719871f, -0.19312178f, 0.26219243f, 0.06269599f, -0.22827590f, 
    -0.13443585f, -0.23928757f, 0.26225635f, 0.30850589f, 0.20559241f, 0.14436337f, -0.16933452f, 0.08680382f, 
    -0.76021135f, -0.93793851f, -0.25532910f, 0.68875188f, 0.40592399f, 0.86607325f, -0.11809078f, -0.05539624f, 
    -0.23872088f, 0.05064402f, -0.42051512f, -0.28627929f, -0.39752850f, -0.16672231f, -0.01247673f, 0.20900293f, 
    -0.09091124f, -0.01738344f, 0.17531112f, -0.19842854f, -0.33116645f, 0.12323058f, -0.05193865f, -0.46986139f, 
    -0.25061864f, -0.22571611f, -0.34030652f, -0.27672198f, -0.00042349f, -0.28229812f, -0.06473948f, 0.34746718f, 
    0.26915279f, -0.03644195f, -0.28027794f, -0.47625074f, 0.02335692f, -0.10329591f, -0.17726639f, 0.10999358f, 
    -0.11280228f, -0.08677509f, -0.29261392f, 0.18954808f, -0.15116878f, -0.18303986f, 0.07578137f, -0.17154860f, 
    -0.01913246f, 0.37636998f, -0.20446959f, -0.10797172f, -0.14610177f, -0.06072265f, -0.15127444f, -0.09041073f, 
    0.03373750f, -0.04608323f, 0.06358971f, -0.08243997f, 0.09931645f, -0.14906867f, -0.21722008f, 0.23207627f, 
    -0.07233889f, -0.28853205f, -0.32492083f, 0.30107856f, 0.01500462f, 0.17582318f, -0.00788413f, 0.16632749f, 
    0.37823814f, 0.02342651f, 0.53006375f, 0.38470221f, -0.09658363f, 0.03614845f, -0.04803337f, -0.50465465f, 
    -0.19937879f, -0.00452054f, -0.06811745f, 0.28940028f, -0.19942546f, -0.03542841f, 0.03466734f, -0.03025681f, 
    -0.47232622f, 0.37215799f, 0.07972249f, 0.23805721f, 0.20587151f, 0.09867010f, 0.05753884f, -0.45395309f, 
    -0.36377624f, -0.23560753f, -0.36814347f, -0.45577237f, -0.15663548f, 0.15347075f, 0.45641670f, -0.16481100f, 
    -0.19782007f, 0.47960466f, 0.10589116f, 0.36283633f, -0.04683938f, -0.05671532f, 0.37342143f, -0.28979129f, 
    -0.01556791f, -0.12586339f, -0.00579003f, -0.22931425f, -0.18890235f, -0.05783216f, 0.38972384f, -0.36519894f, 
    -0.24207480f, 0.39610538f, 0.41609091f, -0.27059254f, -0.16505975f, -0.44141591f, -0.56037229f, -0.56329495f, 
    -0.38380370f, -0.14392495f, 0.43488160f, -0.15434670f, -0.13209167f, -0.01730462f, -0.12803322f, -0.10656887f, 
    -0.30869222f, -0.30128548f, -0.04169989f, 0.06659407f, -0.06710684f, -0.22740526f, 0.12890014f, -0.14726169f, 
    -0.17656159f, -0.23679063f, 0.11564835f, -0.17521937f, 0.30996627f, 0.23310228f, 0.47474128f, -0.03957024f, 
    0.60527515f, -0.61878401f, -0.30193037f, 0.21451135f, -0.26313967f, -0.36953497f, -0.39243618f, -0.31723195f, 
    -0.02280307f, 0.21371162f, 0.22250709f, 0.15154549f, -0.20767629f, -0.04342820f, 0.02611038f, 0.20181529f, 
    0.03875969f, 0.17191157f, -0.22124927f, 0.09615041f, -0.20643377f, -0.42442349f, -0.29723635f, 0.15369254f, 
    0.30859759f, 0.45079264f, 0.13212962f, 0.44219512f, 0.11845179f, -0.12396117f, 0.39425376f, 0.08159894f, 
    -0.13237862f, -0.10276277f, -0.13764785f, 0.27147701f, 0.00506041f, -0.05120562f, -0.23416799f, 0.08314732f, 
    -0.17006120f, -0.04900116f, 0.13121763f, 0.03865888f, 0.07550494f, -0.21116823f, -0.55526197f, -0.04208871f, 
    -0.04375496f, 0.03354563f, 0.33356169f, -0.54615992f, -0.39979213f, 0.52355498f, 0.24357112f, -0.08653478f, 
    0.12119582f, -0.05672865f, -0.21369344f, -0.05126014f, -0.05148211f, 0.47914687f, -0.42033768f, -0.06902884f, 
    0.02486109f, -0.10928315f, -0.17269903f, -0.16215628f, -0.20388703f, 0.05120663f, 0.25338069f, 0.56125319f, 
    0.20981966f, -0.31651729f, 0.19174781f, 0.09988638f, -0.18167552f, -0.02386204f, 0.13077223f, 0.05720058f, 
    -0.08637028f, -0.17708544f, 0.33938953f, -0.01915697f, -0.20028904f, -0.13942344f, -0.18043925f, 0.06128085f, 
    0.05788671f, 0.07547385f, -0.22557138f, -0.16007638f, -0.24875249f, 0.25019354f, 0.17199345f, -0.17666768f, 
    0.34806031f, 0.43419045f, 0.36624703f, 0.03226699f, -0.12617415f, -0.42576557f, -0.19660243f, -0.08386818f, 
    -0.29332358f, -0.06370368f, 0.23572731f, 0.15291958f, 0.23772478f, 0.02214332f, -0.01622659f, 0.09032152f, 
    0.19207430f, -0.24179661f, 0.10664390f, -0.36864731f, -0.18505573f, 0.11356638f, 0.12423739f, 0.17078659f, 
    0.19205397f, 0.67993855f, 0.42086977f, -0.30624500f, -0.64713174f, -0.91326761f, 0.01066396f, 0.13353780f, 
    0.36207068f, 0.20636724f, -0.15581849f, 0.50091285f, -0.52588505f, -0.07383275f, 0.23502789f, -0.27087730f, 
    0.04414123f, 0.11363290f, -0.32939506f, -0.12521447f, 0.20318034f, 0.06966715f, -0.03928154f, -0.04597937f, 
    -0.10540092f, 0.24371089f, 0.62272638f, 0.34924281f, 0.28881308f, 0.23542626f, -0.17033805f, -0.52006561f, 
    -0.16030864f, -0.17988965f, -0.32513073f, -0.03205073f, -0.26279423f, -0.04687158f, -0.19234206f, -0.16009822f, 
    0.27048635f, 0.11059683f, 0.29652256f, 0.35925612f, 0.05125200f, 0.01570705f, -0.17360488f, -0.25702825f, 
    -0.35655618f, -0.14598741f, -0.05468950f, -0.15574197f, -0.63132882f, -0.37673914f, -0.20975855f, -0.24630977f, 
    -0.03291342f, -0.19591431f, 0.24419253f, 0.41012511f, -0.17151368f, 0.06111506f, 0.42182037f, 0.42242074f, 
    0.13068266f, 0.28497246f, 0.19156352f, -0.16871536f, -0.31620461f, -0.28944877f, -0.31083485f, -0.06946790f, 
    -0.26242203f, 0.06603248f, 0.08270677f, -0.21253955f, 0.79771852f, 0.64781386f, -0.20917326f, -0.59115207f, 
    -0.05849892f, 0.08918525f, -0.48747176f, -0.23577033f, -0.81470335f, -0.70016348f, -0.06841152f, 0.30971444f, 
    -0.02395804f, 0.23314184f, 0.03663070f, -0.22218417f, -0.40252322f, 0.13074499f, 0.15168260f, 0.16090842f, 
    0.16363940f, -0.06189583f, 0.02850401f, 0.08416160f, -0.14525917f, 0.27795193f, -0.32909256f, -0.60228878f, 
    -0.57120818f, 0.05590498f, 0.42233559f, -0.20152512f, 0.42183089f, 0.01562187f, -0.19249760f, 0.30472112f, 
    -0.13079384f, -0.11386461f, -0.21293598f, 0.29643545f, -0.31157851f, 0.01130922f, -0.14994641f, -0.35194245f, 
    0.06248374f, -0.38238195f, -0.17339697f, 0.23174447f, 0.43667030f, 0.33847758f, -0.12635036f, -0.54689193f, 
    -0.31676286f, 0.51218396f, 0.29216990f, -0.05043127f, -0.59083766f, -0.71912539f, -0.20430380f, -0.21923445f, 
    0.19583082f, 0.24354048f, -0.09764182f, 0.48420700f, -0.30582812f, 0.13851480f, -0.09363710f, -0.29757529f, 
    -0.17403108f, -0.28776747f, -0.09157611f, -0.05322929f, -0.02379158f, -0.15154113f, -0.48287171f, 0.22432657f, 
    -0.24555883f, 0.12856477f, -0.01414220f, -0.02931763f, 0.06883922f, 0.27283666f, -0.21097618f, 0.01712059f, 
    0.13081619f, 0.35823861f, -0.34981608f, -0.08375622f, 0.06827669f, 0.07822262f, 0.15281676f, 0.01781051f, 
    -0.23917139f, 0.15091664f, -0.01611011f, 0.18261200f, 0.01084988f, 0.14811088f, 0.18344471f, -0.27704966f, 
    -0.62878382f, -0.49469256f, -0.57990283f, -0.19176209f, 0.32762888f, -0.15892062f, 0.07677697f, -0.25109619f, 
    -0.33241248f, -0.12638158f, 0.38656637f, 0.55138421f, 0.29088658f, 0.26826754f, -0.27712050f, -0.27766487f, 
    -0.12197225f, -0.36077347f, 0.02083719f, 0.21823290f, -0.11258510f, -0.06178150f, 0.09189686f, 0.04051609f, 
    -0.36565930f, -0.05512979f, 0.25546604f, 0.32619771f, 0.02597028f, 0.08973385f, 0.39472061f, 0.32798457f, 
    0.02801399f, -0.15230440f, 0.23727685f, 0.27832031f, 0.06828810f, 0.08838303f, -0.30805996f, -0.31881109f, 
    -0.18514144f, -0.13936304f, -0.05298546f, -0.05431145f, 0.14966689f, 0.20274678f, -0.23155011f, -0.18898597f, 
    0.00324029f, 0.20428567f, -0.18777199f, 0.23730659f, 0.48136479f, -0.20631798f, -0.00285285f, -0.19098796f, 
    -0.05442699f, 0.47713134f, -0.41083604f, -0.09886271f, -0.28389505f, 0.03674345f, -0.15997152f, 0.32712275f, 
    -0.19240054f, -0.21780457f, 0.37040117f, -0.20654690f, 0.14545386f, -0.03668170f, 0.16420877f, -0.10709637f, 
    -0.42167231f, 0.29753625f, 0.29753509f, -0.09680704f, 0.19441971f, 0.41710433f, -0.07626249f, -0.03790788f, 
    -0.50139475f, -0.22723293f, 0.05224044f, 0.26795602f, 0.20811866f, -0.27836788f, -0.06742603f, 0.00350937f, 
    0.60527062f, -0.58954453f, 0.21023189f, -0.13337860f, 0.03457941f, 0.30749753f, -0.27028278f, -0.06025363f, 
    -0.30544230f, 0.12843129f, 0.31143853f, -0.16152787f, 0.73385394f, 0.07408489f, 0.06517470f, -0.12381312f, 
    -0.47675401f, -0.30471176f, -0.12419926f, 0.25415164f, 0.20582935f, 0.21375506f, -0.08018432f, 0.19213283f, 
    0.14752796f, 0.35844144f, -0.26893929f, 0.00852295f, 0.07399087f, -0.25907460f, -0.19290076f, -0.10714878f, 
    0.06458347f, -0.09500974f, 0.05268817f, 0.16611344f, -0.08726279f, -0.28426614f, 0.05531044f, -0.12782867f, 
    -0.45962384f, -0.49325359f, -0.09054918f, 0.18000396f, -0.25284517f, -0.11370743f, 0.19726633f, -0.18304415f, 
    0.48382995f, -0.09182212f, 0.14523523f, -0.26463065f, 0.20943560f, 0.08776985f, -0.23885690f, -0.21437524f, 
    0.11544279f, -0.09225215f, 0.00787887f, -0.07282083f, -0.31995097f, -0.31064597f, -0.58090937f, -0.98692602f, 
    -0.53972632f, 0.12825480f, 0.27147213f, 0.35217661f, 0.34080943f, -0.03216456f, -0.11627521f, 0.22317933f, 
    0.08124937f, -0.03739345f, -0.09112334f, 0.10601931f, 0.08452835f, -0.01632929f, 0.06791909f, -0.01484889f, 
    -0.06131668f, -0.07074010f, -0.46729395f, -0.07947300f, -0.08025820f, -0.01689966f, -0.08917039f, 0.52196515f, 
    0.10660073f, 0.16600379f, -0.08376732f, 0.15349454f, -0.01161270f, -0.05376301f, -0.14836511f, 0.06648385f, 
    -0.03146898f, 0.03260767f, -0.21195462f, -0.12027024f, -0.13503997f, -0.08501483f, 0.03866129f, 0.25598294f, 
    -0.07507548f, -0.00178883f, -0.41797763f, -0.02227711f, 0.14223111f, 0.05110655f, 0.11599046f, 0.01992305f, 
    0.55169523f, 0.77585030f, 0.03202048f, -0.60277331f, -0.40234065f, 0.09897207f, -0.11039779f, 0.39827740f, 
    -0.24933535f, -0.26240888f, -0.19915341f, -0.10028520f, 0.44267583f, -0.21859585f, -0.16530462f, 0.11323602f, 
    0.30273056f, 0.26979628f, -0.35470536f, -0.10633297f, 0.17920317f, -0.11633483f, -0.66227233f, -0.08302875f, 
    0.12269669f, 0.45659760f, -0.16722964f, -0.39433277f, -0.36193317f, -0.25916776f, 0.36041874f, 0.29746696f, 
    0.07455580f, -0.39265919f, -0.12864216f, 0.19174026f, 0.66734743f, -0.04554217f, -0.24634062f, -0.44209588f, 
    -0.21543783f, -0.12888962f, -0.00869563f, -0.15884659f, 0.06688355f, -0.10507160f, 0.18662800f, 0.19985192f, 
    0.25614151f, 0.17159359f, 0.54182327f, -0.47493720f, -0.45449597f, -0.46941394f, -0.77723998f, 0.38044706f, 
    -0.00266229f, -0.12282906f, 0.16626008f, 0.12667516f, 0.00547139f, 0.08290052f, 0.04684337f, 0.22574057f, 
    0.03579071f, -0.23014562f, 0.09474060f, 0.24036866f, -0.30610025f, -0.04267086f, -0.26215190f, -0.19179650f, 
    -0.05003640f, 0.06998366f, -0.42186612f, 0.04734674f, 0.40313533f, 0.50779098f, 0.23645243f, -0.02240015f, 
    -0.26538646f, -0.34101197f, -0.32887328f, 0.21624322f, 0.15210766f, 0.12439425f, -0.15860613f, 0.00600690f, 
    -0.06712328f, 0.02162537f, 0.25430667f, 0.22976285f, -0.29673740f, -0.10494594f, -0.14087182f, 0.04768459f, 
    0.03277328f, 0.04215418f, 0.10124513f, -0.25243804f, -0.14280599f, 0.00367322f, 0.01640594f, 0.42153516f, 
    -0.37987736f, -0.30096382f, -0.14424229f, 0.13522288f, -0.06346435f, 0.18778834f, 0.39303285f, -0.09843303f, 
    0.09983410f, -0.24272414f, 0.03261819f, -0.05830040f, -0.13158062f, 0.14365366f, -0.37434712f, -0.29275209f, 
    0.28741133f, 0.22768690f, 0.01970698f, 0.45908538f, 0.20617580f, 0.49159101f, -0.16490638f, -0.61914909f, 
    -0.17980026f, -0.29524919f, 0.00822477f, 0.39582300f, 0.28708598f, 0.05676759f, -0.08591155f, -0.40259773f, 
    -0.44553411f, -0.16987841f, 0.00950426f, -0.18023978f, 0.07025553f, -0.22421467f, -0.05093392f, 0.22734092f, 
    -0.12326421f, 0.16743651f, -0.04609737f, -0.16456395f, -0.24416760f, -0.43873212f, 0.03213296f, -0.07676072f, 
    0.41805854f, -0.15722845f, -0.68521297f, -0.27368346f, 0.09070602f, 0.24880923f, 0.12839288f, 0.10225533f, 
    0.07035212f, -0.27104983f, 0.66580766f, -0.46468338f, -0.03334292f, -0.11959592f, 0.00766396f, -0.33825484f, 
    -0.03688603f, 0.34596515f, 0.08279058f, -0.04028501f, 0.15775427f, -0.24884315f, 0.28691611f, 0.21897322f, 
    -0.17133415f, -0.12104458f, 0.35893324f, 0.23924556f, 0.30332983f, 0.50070572f, -0.25876302f, -0.46416897f, 
    0.05948522f, -0.11624998f, 0.18602046f, 0.01430886f, -0.29728377f, 0.09160641f, 0.25787875f, -0.24887781f, 
    0.26140091f, -0.08372980f, -0.21720125f, 0.13412912f, -0.05770085f, -0.17908569f, -0.06340688f, -0.03641383f, 
    0.25759903f, 0.44405332f, 0.01993117f, 0.13925242f, -0.07419976f, -0.27604625f, 0.14172038f, 0.08493755f, 
    0.06189484f, 0.09257340f, 0.18167354f, -0.37935424f, 0.07478277f, -0.14223495f, -0.06440814f, 0.13933335f, 
    0.40075880f, -0.00976287f, -0.11552355f, -0.28705168f, -0.06514462f, 0.01648208f, -0.37772822f, -0.07707486f, 
    -0.07091514f, -0.42203268f, -0.07334372f, 0.12476512f, -0.45758131f, -0.31142077f, -0.32789278f, -0.52200574f, 
    -0.26402506f, -0.21040781f, 0.15164293f, 0.25202832f, 0.38692644f, 0.47647914f, 0.09590427f, -0.11079993f, 
    0.08332603f, -0.08275697f, -0.20049468f, 0.12795728f, -0.14119424f, 0.11577750f, 0.30400407f, -0.29148868f, 
    0.03228179f, 0.34408501f, 0.34452283f, 0.23581161f, 0.28440055f, 0.21600656f, 0.30043212f, 0.06843293f, 
    -0.00159330f, 0.04940994f, 0.06035205f, -0.04597988f, -0.26913226f, -0.11879737f, 0.01740066f, 0.08404522f, 
    0.22063379f, -0.08929314f, 0.08607510f, -0.08848649f, -0.03300711f, -0.19406475f, -0.24785846f, -0.09559857f, 
    -0.27039102f, -0.42914212f, -0.14812745f, 0.03419678f, -0.50413364f, -0.64850903f, -0.37195823f, -0.59715402f, 
    0.39052126f, 0.15632884f, 0.32084718f, 0.09357679f, 0.18597041f, 0.30306590f, 0.00197999f, 0.39782938f, 
    -0.25126320f, 0.16306959f, -0.18138763f, -0.30446026f, -0.02262163f, 0.13438925f, 0.05563541f, 0.10489833f, 
    -0.04319550f, 0.09445915f, -0.19872744f, 0.31050780f, -0.55867964f, -0.17072542f, -0.09127861f, -0.45925909f, 
    0.22483352f, -0.13516828f, -0.30234104f, -0.35921258f, 0.04353567f, 0.30675411f, -0.25267223f, -0.26229554f, 
    -0.21254592f, 0.23148715f, -0.47197384f, 0.38836536f, -0.02641906f, -0.16798675f, 0.09262185f, -0.22804321f, 
    -0.20438778f, -0.11443616f, -0.25216508f, -0.21548808f, -0.33841512f, -0.66012067f, -0.63684970f, 0.16634989f, 
    0.91727853f, 0.27950004f, 0.55797160f, -0.15901023f, -0.65018862f, -0.60917324f, -0.23403171f, -0.13430919f, 
    -0.18583657f, -0.01766494f, 0.50261319f, -0.19870873f, -0.47776318f, -0.08420052f, 0.43310493f, -0.14243795f, 
    0.39757082f, -0.00075284f, -0.40927842f, -0.03236788f, 0.00771301f, 0.19209528f, 0.10185757f, -0.27214146f, 
    -0.38380551f, -0.51306552f, -0.06579329f, 0.37638402f, 0.06164589f, 0.08794235f, 0.27311248f, 0.16335391f, 
    0.08793768f, -0.29623926f, 0.02037267f, -0.37452793f, 0.34874734f, -0.17704599f, 0.03432215f, -0.06067793f, 
    0.01027684f, 0.01324945f, 0.35012341f, 0.03989064f, -0.32637224f, 0.11120027f, 0.49545652f, 0.65835166f, 
    -0.43075249f, -0.28322005f, -0.16142304f, -0.31789637f, 0.55892384f, 0.27539268f, 0.19791581f, -0.47802827f, 
    0.14477265f, 0.12295109f, 0.13287812f, -0.02965578f, -0.27518925f, -0.01992905f, 0.20715635f, -0.14314350f, 
    -0.03369604f, -0.18349403f, -0.03674406f, -0.15733223f, 0.07558952f, -0.00769268f, -0.02334279f, -0.13406202f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24640326f, -0.03036214f, 0.03697473f, -0.11403674f, -0.10292745f, 0.10408651f, -0.01868320f, -0.10404931f, 
    0.13017973f, -0.22728601f, 0.00815274f, -0.12784231f, 0.09458308f, 0.16625772f, 0.02655475f, 0.17807275f, 
    -0.09338833f, -0.08740373f, 0.17540054f, -0.12513851f, -0.01236931f, -0.13754238f, -0.24093485f, -0.07989217f, 
    0.24841985f, 0.05267859f, -0.00443825f, 0.00100603f, 0.21562110f, 0.26102313f, 0.17579162f, 0.15194280f, 
    0.08922693f, 0.28596297f, -0.04721566f, -0.02453673f, 0.06403483f, 0.18683921f, -0.12017483f, -0.02301527f, 
    -0.07839048f, -0.01076390f, 0.04668187f, 0.10362303f, 0.23068541f, 0.08042365f, -0.03765211f, 0.04995330f, 
    0.35684577f, 0.29759896f, -0.06974261f, 0.18342099f, -0.13545726f, 0.01923043f, 0.22185990f, 0.21669100f, 
    0.14757633f, -0.06256504f, -0.21240109f, 0.39530444f, -0.28731391f, 0.22252999f, 0.07268872f, 0.14729102f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00288447f, 0.25620118f, 0.07334219f, 0.09652534f, -0.12510300f, -0.02524046f, 0.11529981f, -0.10330724f, 
    -0.04318904f, 0.19883198f, 0.04708476f, 0.07384028f, 0.30277959f, 0.30196276f, 0.24896163f, 0.38942870f, 
    -0.21793519f, -0.12334156f, 0.03294465f, -0.03368063f, 0.05835142f, -0.03978368f, 0.00489657f, 0.09249151f, 
    0.00544152f, -0.10944313f, -0.00026067f, -0.10693377f, 0.14916274f, 0.00352663f, -0.14789888f, -0.02218398f, 
    -0.05094570f, -0.10727790f, 0.03359314f, -0.20286131f, -0.22826500f, -0.17344876f, -0.16486514f, 0.03584766f, 
    -0.08230606f, 0.04586816f, 0.00562101f, -0.01659080f, 0.09086446f, 0.08710166f, -0.06857970f, -0.11470505f, 
    -0.18934938f, -0.06145093f, 0.02720157f, 0.07957444f, 0.02038886f, -0.07206052f, 0.07347333f, 0.15615682f, 
    0.22547752f, 0.10851320f, 0.13803844f, 0.18945362f, -0.06218453f, -0.10449887f, -0.05568426f, 0.08004621f, 
    0.03515294f, -0.14797053f, -0.08857278f, -0.03007462f, -0.11681527f, -0.17118011f, 0.02742090f, -0.17060930f, 
    -0.13086583f, -0.16989282f, 0.00391772f, 0.17752424f, -0.01587867f, 0.03041885f, 0.04988147f, -0.01340478f, 
    -0.07020446f, 0.00934523f, -0.18777665f, -0.02426196f, -0.19581369f, -0.20094004f, 0.09392130f, 0.15254863f, 
    -0.01544920f, -0.10328171f, 0.01338141f, 0.03637294f, -0.01004476f, -0.05315116f, 0.10536294f, 0.08203544f, 
    -0.08402895f, 0.24583174f, -0.14867088f, 0.09499610f, 0.07496938f, 0.07291441f, -0.08045010f, -0.01102194f, 
    0.06408972f, 0.09377990f, -0.02776732f, -0.00045014f, 0.00442706f, -0.00262242f, 0.13271120f, -0.06569876f, 
    0.07774539f, -0.05934915f, -0.05716053f, -0.05304702f, -0.07718182f, -0.09521238f, 0.04671918f, -0.02863049f, 
    0.15611914f, -0.08762436f, 0.07293778f, 0.00469334f, 0.10334011f, 0.00100118f, -0.15277554f, 0.09994043f, 
    -0.18593207f, -0.11380596f, -0.21023558f, -0.11516475f, -0.01116100f, -0.03366780f, -0.21715298f, -0.07230542f, 
    -0.12813567f, 0.06481249f, -0.07260203f, 0.11836914f, 0.00281702f, -0.24625431f, -0.22869299f, -0.29317299f, 
    -0.06915046f, 0.26503941f, 0.10670672f, 0.02551265f, 0.00917105f, 0.09594796f, 0.09891831f, -0.00094933f, 
    0.03523105f, 0.00609538f, -0.07426002f, 0.24555477f, 0.17508243f, 0.01655673f, -0.00977516f, 0.11668711f, 
    -0.07279874f, -0.02673775f, -0.00986971f, 0.09334988f, -0.00082966f, 0.11559077f, -0.05057641f, -0.15753116f, 
    -0.15461777f, -0.02715504f, 0.01516555f, 0.04317624f, -0.12422749f, 0.00562845f, 0.14415219f, 0.05397170f, 
    -0.01175762f, -0.01248348f, 0.07169579f, -0.06388514f, 0.32079861f, 0.15276951f, -0.29788244f, 0.14102668f, 
    0.09552601f, 0.10983895f, -0.03874024f, -0.09911113f, 0.13847995f, -0.06101173f, 0.24153867f, 0.21296822f, 
    0.00313893f, -0.08400121f, 0.06089775f, -0.08883823f, 0.15168552f, -0.17939091f, -0.20907056f, 0.08977450f, 
    -0.20111869f, 0.08481652f, 0.04035897f, -0.40316677f, -0.25117922f, -0.14442718f, 0.01803633f, 0.04129054f, 
    -0.03116771f, -0.12398185f, -0.02797149f, 0.04786290f, -0.02674179f, -0.11447739f, 0.02291476f, -0.05518030f, 
    -0.11865281f, -0.11447999f, -0.08515138f, 0.11311151f, -0.00300790f, 0.01638918f, 0.02879784f, 0.02363354f, 
    0.05332806f, 0.03396232f, 0.02540606f, 0.14327151f, -0.10171979f, -0.11025252f, -0.03132091f, 0.02396224f, 
    -0.05200419f, -0.07347739f, -0.07411972f, -0.01727792f, 0.06534491f, -0.07728789f, 0.07802323f, 0.08633018f, 
    0.16685310f, -0.18362315f, 0.09349659f, -0.06998385f, 0.10823548f, -0.02540535f, -0.18663123f, 0.00206179f, 
    -0.00561733f, 0.13344640f, 0.01045479f, 0.06659803f, -0.20521475f, -0.17703755f, -0.05751491f, -0.01106167f, 
    -0.10674678f, 0.05225059f, -0.00110486f, -0.03820793f, -0.02530678f, 0.05388129f, -0.08306745f, -0.08734038f, 
    -0.14271770f, 0.01372363f, 0.47450888f, 0.13247816f, 0.04945233f, -0.21831177f, 0.01279426f, 0.14731565f, 
    0.08628547f, 0.09445178f, 0.04600390f, 0.03140933f, 0.00894173f, 0.09564238f, 0.04950595f, 0.26754451f, 
    -0.04097412f, -0.03319211f, 0.14654635f, -0.05906631f, 0.03376315f, 0.07351841f, 0.08335110f, 0.26117560f, 
    -0.02067889f, 0.07516088f, 0.03780692f, 0.07435489f, 0.02964389f, 0.06599022f, -0.05377821f, 0.19186601f, 
    -0.06263855f, -0.10349978f, -0.20592226f, -0.22085519f, 0.10312068f, -0.07789332f, -0.06867904f, -0.11759352f, 
    0.11878905f, 0.16555917f, -0.13522193f, 0.07133113f, 0.25951493f, 0.07609617f, 0.00863913f, 0.34028885f, 
    0.40797165f, 0.10614499f, -0.21812253f, 0.08910741f, -0.13966051f, -0.12699491f, -0.02679054f, 0.08414342f, 
    -0.17253761f, 0.08253945f, -0.13886937f, -0.21188793f, -0.19797276f, 0.09613485f, 0.06062353f, 0.03785656f, 
    -0.04402424f, -0.10462597f, 0.09794903f, 0.13793233f, 0.06253988f, 0.00541321f, 0.05960890f, 0.10852665f, 
    -0.12190439f, 0.11815261f, -0.12994754f, 0.19087242f, 0.05649458f, -0.02398787f, -0.00365775f, -0.01700960f, 
    0.04340984f, -0.13834184f, -0.02969914f, -0.01234315f, 0.06332401f, 0.03541557f, 0.01383745f, -0.03296423f, 
    -0.00837877f, -0.07788139f, 0.01626426f, 0.06220488f, -0.04389970f, -0.00710710f, 0.03223748f, 0.03169050f, 
    0.04311593f, 0.03154160f, -0.18773346f, 0.10037237f, 0.02768785f, -0.08758010f, 0.03276686f, 0.06882768f, 
    0.09513457f, 0.12994418f, 0.07318155f, 0.01803775f, -0.18905795f, -0.09503189f, 0.02404059f, -0.03395148f, 
    -0.15363868f, -0.05687388f, -0.07806226f, -0.10839389f, -0.07688443f, -0.00960678f, -0.03883015f, -0.04589935f, 
    -0.16024590f, -0.10572635f, 0.04735045f, 0.06926958f, 0.00946592f, 0.02278760f, -0.02083862f, -0.01846554f, 
    -0.16592558f, -0.22721435f, -0.11857735f, -0.29933801f, -0.25248548f, 0.41674036f, 0.25569463f, -0.08774854f, 
    0.00130113f, 0.02277644f, -0.01970939f, 0.15328419f, 0.04763241f, 0.00417816f, 0.02971260f, -0.03630954f, 
    -0.16320719f, -0.02065922f, 0.01409196f, 0.06143785f, 0.02984324f, 0.06131680f, 0.04282670f, 0.01158753f, 
    0.18973246f, 0.21463211f, -0.00929961f, 0.15747361f, 0.19357069f, 0.24307688f, 0.17378160f, 0.16531342f, 
    -0.22049919f, -0.07073920f, -0.04352418f, -0.13374434f, 0.04372595f, 0.09406965f, -0.03625336f, 0.16660455f, 
    -0.30515918f, 0.28796569f, 0.25864565f, -0.02492250f, 0.20614173f, 0.08743486f, 0.10527941f, -0.10772174f, 
    0.07955106f, -0.05144956f, -0.03770400f, -0.08630235f, -0.08815702f, 0.10482094f, 0.18259715f, 0.07166007f, 
    -0.01330977f, -0.10937346f, -0.06501526f, -0.03261274f, -0.14833441f, 0.03213892f, -0.07635567f, -0.12366433f, 
    -0.14963639f, -0.27519408f, 0.16236526f, 0.15921094f, -0.00464130f, -0.02911584f, -0.08498496f, 0.00189801f, 
    0.14440188f, 0.11350721f, 0.13436082f, 0.19758800f, 0.07638748f, -0.06694778f, 0.00101383f, -0.06631315f, 
    0.12350101f, -0.13479610f, 0.06869692f, 0.07072414f, -0.00489005f, -0.22739483f, -0.11763625f, -0.10303319f, 
    0.02393694f, -0.07415067f, 0.13351901f, 0.08279591f, -0.07452839f, -0.14258607f, -0.07368726f, 0.07543696f, 
    0.04483576f, 0.03951446f, 0.04773746f, 0.09739634f, -0.03577062f, -0.05289851f, 0.01311390f, -0.26463187f, 
    0.01662738f, -0.00533690f, -0.06866234f, 0.01642164f, -0.04827949f, 0.05413968f, 0.00177314f, -0.07847530f, 
    -0.04751090f, 0.07277509f, -0.24833348f, -0.03354691f, -0.05322251f, -0.03611180f, -0.00977547f, -0.16834526f, 
    -0.37135515f, -0.12135614f, -0.10472142f, -0.29453614f, -0.09962784f, -0.25426283f, -0.10227444f, 0.10981737f, 
    0.08715253f, 0.08664587f, 0.11468653f, -0.10914934f, -0.17573909f, 0.03159778f, 0.20063838f, -0.01819357f, 
    -0.18294919f, 0.21653260f, -0.00950609f, 0.03534469f, 0.01948286f, -0.04932285f, -0.09252969f, -0.13119021f, 
    -0.02916420f, -0.00040961f, 0.07845534f, 0.05163248f, 0.03439873f, 0.02754521f, 0.03412943f, 0.06337209f, 
    -0.08700278f, -0.02764479f, 0.10451072f, 0.03364115f, 0.10110704f, 0.09474129f, 0.08537419f, 0.26145065f, 
    0.10671653f, -0.08034293f, 0.29812729f, 0.20155855f, -0.11701784f, -0.00298740f, -0.07488170f, 0.13547957f, 
    0.05096100f, 0.13373099f, 0.06121871f, 0.13847819f, -0.06469409f, -0.10691896f, 0.01954600f, -0.07317090f, 
    0.06190500f, -0.13239817f, -0.08094317f, -0.04203825f, -0.09699758f, -0.09247781f, -0.15435311f, -0.09478443f, 
    -0.13459601f, 0.24386555f, 0.13355254f, -0.21490407f, 0.03039915f, 0.00474636f, 0.07448215f, 0.07033131f, 
    0.05916983f, 0.04899397f, 0.10641832f, 0.01597531f, -0.07593115f, 0.11073960f, 0.20280553f, -0.00020048f, 
    0.05534489f, -0.05047231f, -0.05487750f, -0.02660402f, 0.01100721f, -0.09764289f, 0.00737428f, -0.06688922f, 
    -0.07262181f, 0.35425720f, 0.30040425f, 0.19179347f, -0.11672892f, -0.07331353f, 0.08984222f, -0.03634981f, 
    0.03484879f, -0.00769584f, -0.00992202f, 0.25200704f, 0.04531947f, -0.04416049f, -0.09440722f, 0.11086921f, 
    0.01374476f, 0.07331073f, -0.05080580f, -0.11466435f, 0.04362954f, -0.10669247f, -0.03596307f, 0.01804914f, 
    -0.00000867f, -0.01646953f, -0.22077507f, -0.05884747f, 0.08546428f, -0.15562753f, 0.08829442f, -0.08677651f, 
    -0.19247268f, -0.07477325f, -0.34817940f, -0.31172064f, -0.20743974f, 0.01679143f, 0.05372836f, 0.03365210f, 
    0.02762744f, 0.01284537f, 0.12488497f, 0.09577902f, 0.12481561f, 0.03139719f, 0.20331171f, 0.17837153f, 
    -0.02544050f, 0.31674844f, -0.13205153f, 0.05650973f, 0.13105559f, 0.07626401f, 0.00814561f, 0.02527728f, 
    -0.03071267f, 0.00008595f, -0.06559241f, -0.13936381f, 0.01503007f, -0.12446852f, 0.01183030f, -0.04867206f, 
    0.06266049f, -0.14230017f, -0.00677621f, 0.10715222f, -0.01682781f, 0.18289872f, 0.09233029f, 0.05137801f, 
    -0.07497977f, -0.10323511f, -0.15885396f, -0.12527281f, 0.09827504f, -0.02669661f, 0.16567160f, 0.03987064f, 
    0.25380877f, 0.26788265f, 0.11294922f, 0.14631152f, -0.05128219f, 0.12366855f, -0.13125016f, 0.03563165f, 
    -0.05596312f, -0.11725578f, -0.00102126f, -0.06119355f, 0.00172162f, -0.01360069f, -0.08285422f, -0.07878429f, 
    -0.15729114f, -0.17583038f, -0.15981215f, -0.05853308f, -0.09360904f, -0.08899391f, -0.03743347f, -0.04328638f, 
    0.13314493f, 0.25510195f, 0.17239346f, 0.27563205f, 0.18959077f, 0.37726361f, 0.33925053f, 0.16220234f, 
    -0.09813363f, -0.19852757f, 0.00046491f, -0.01595642f, -0.02592795f, -0.02650272f, -0.09103211f, -0.02804819f, 
    -0.10286240f, -0.28458714f, -0.00100043f, 0.01417665f, -0.01771116f, -0.00182434f, -0.08390900f, -0.00212161f, 
    0.15406390f, 0.11896960f, 0.22493052f, 0.15351363f, -0.10481475f, -0.05233144f, 0.25957635f, 0.00427229f, 
    0.01219692f, 0.08240329f, 0.00445085f, 0.08404194f, -0.15557608f, 0.19242722f, -0.09519099f, -0.01346793f, 
    0.22116724f, 0.08860309f, 0.25393802f, 0.23684256f, -0.05896459f, -0.00819999f, 0.06780902f, 0.05568640f, 
    -0.10388933f, -0.03455878f, -0.20037213f, -0.09092660f, -0.15341720f, 0.07225568f, 0.23176673f, 0.06559844f, 
    -0.06835032f, -0.04382852f, 0.02053535f, 0.03314088f, 0.12237354f, 0.11126219f, 0.03623521f, 0.25082123f, 
    -0.10970971f, -0.13345185f, 0.00469048f, 0.03061061f, 0.10223751f, 0.09988683f, -0.11838363f, -0.04671465f, 
    0.08839041f, -0.09289212f, -0.02965247f, 0.01637233f, -0.04066245f, -0.08714435f, -0.06503491f, -0.15065597f, 
    -0.02615488f, 0.05188556f, 0.12969577f, 0.10789198f, -0.18355113f, 0.03931696f, -0.03273830f, -0.11352802f, 
    -0.03218282f, 0.01592278f, 0.17671281f, -0.06121780f, -0.04380137f, 0.05105336f, -0.06396554f, 0.07601913f, 
    0.03123078f, -0.05393228f, 0.10514718f, 0.06717162f, -0.00644628f, -0.13605267f, 0.15454289f, -0.16480748f, 
    0.05956000f, -0.05898711f, -0.03688652f, -0.12867998f, -0.07063698f, -0.08830905f, 0.02714561f, 0.00421649f, 
    0.28605080f, -0.03512538f, 0.14323100f, -0.03640445f, 0.02272978f, 0.08779864f, -0.13084273f, -0.21345180f, 
    0.04629830f, -0.02988452f, -0.08133107f, -0.12289737f, -0.00097097f, 0.13707539f, 0.05543664f, 0.02173060f, 
    -0.01083012f, 0.18704578f, 0.12016492f, 0.03336250f, -0.02221035f, 0.07092442f, 0.01478750f, -0.01045882f, 
    -0.02690515f, 0.22204167f, -0.08704848f, -0.22915255f, 0.01153664f, 0.02234295f, -0.09318497f, 0.09879842f, 
    0.05086179f, 0.00918736f, 0.01462700f, -0.01062486f, 0.25384390f, 0.25404215f, 0.07435137f, 0.05824753f, 
    0.06509697f, 0.05390812f, -0.06254941f, -0.01729667f, -0.00719201f, -0.03059667f, -0.08524437f, -0.01053713f, 
    -0.11893586f, -0.20869875f, 0.25899687f, 0.07789919f, -0.00353024f, -0.04255095f, 0.12202446f, -0.06302156f, 
    0.03532655f, -0.01026358f, -0.11321864f, 0.23431316f, 0.00200478f, 0.01395945f, 0.08132982f, -0.01322744f, 
    -0.03377650f, 0.07160024f, 0.06922033f, -0.01772205f, 0.04095369f, 0.01418114f, -0.00106861f, -0.06907430f, 
    0.03128941f, 0.10283211f, -0.01387959f, 0.12315358f, -0.15423676f, -0.07212310f, 0.19949761f, 0.00343000f, 
    0.10063727f, 0.03273205f, 0.02270392f, 0.06099469f, 0.02879207f, 0.03303934f, 0.00234400f, 0.06423167f, 
    0.07812270f, -0.05999930f, 0.00819376f, -0.09660541f, -0.19348441f, 0.12570289f, 0.01586341f, 0.11831176f, 
    0.17611575f, -0.05947787f, -0.04595226f, 0.06496772f, -0.05775388f, 0.04624349f, -0.19951640f, -0.06257865f, 
    -0.03936301f, 0.03611349f, 0.19293186f, -0.13557020f, -0.07256188f, 0.17303105f, -0.24861987f, -0.05287230f, 
    -0.05469380f, 0.20193437f, 0.02276897f, -0.02719708f, 0.07275659f, 0.05140116f, 0.00798955f, 0.04629837f, 
    0.13880971f, 0.04975917f, -0.03877771f, 0.00072057f, 0.05430796f, -0.05138216f, 0.01026991f, -0.08574670f, 
    -0.03887448f, -0.02527423f, -0.10051731f, 0.11886775f, -0.08979946f, -0.16566786f, 0.16297397f, -0.00117220f, 
    0.05211530f, -0.02583453f, -0.16503857f, 0.14713259f, -0.07683546f, 0.07881658f, -0.09041929f, -0.10388081f, 
    0.21708827f, 0.13452518f, 0.04493130f, 0.22996864f, -0.19148181f, 0.01628521f, 0.08234149f, -0.02929493f, 
    0.03047600f, -0.01287993f, 0.07622137f, 0.06326369f, 0.11922834f, 0.28971627f, -0.01087700f, 0.08735009f, 
    0.02867818f, 0.17766108f, 0.05960783f, 0.09785896f, -0.05592063f, 0.04013998f, -0.09021171f, 0.02408395f, 
    0.17137808f, 0.14236814f, -0.04215307f, -0.06632589f, 0.06758758f, 0.01030493f, 0.06703164f, -0.05455463f, 
    -0.00175391f, -0.08176449f, -0.03586806f, -0.00845811f, -0.01003995f, 0.02131134f, 0.08525708f, 0.08211692f, 
    0.08562250f, 0.03817832f, 0.08431653f, 0.07355528f, 0.00159208f, -0.09837016f, -0.01774039f, -0.14273281f, 
    0.00644331f, 0.16767126f, -0.04740911f, 0.07861362f, -0.09673767f, -0.00379371f, 0.04551071f, 0.07417368f, 
    -0.08429628f, -0.03541612f, 0.10025700f, 0.06796315f, 0.13213184f, 0.10147258f, 0.10971568f, 0.11132184f, 
    0.02795088f, 0.04951098f, 0.05966881f, 0.14981844f, -0.04830291f, -0.03177349f, -0.01939682f, 0.12964773f, 
    0.28807837f, 0.26854452f, 0.05472322f, 0.00186199f, -0.14480758f, 0.09782882f, 0.02710813f, -0.18584833f, 
    0.03465534f, -0.10298864f, -0.04812390f, -0.14038388f, 0.05212576f, 0.03263624f, 0.02766983f, -0.06479545f, 
    -0.04431756f, 0.01141318f, -0.02112867f, 0.08904454f, 0.01484934f, -0.02338444f, -0.02613105f, -0.12837532f, 
    0.01671227f, 0.10276357f, -0.02481386f, -0.00726382f, 0.01784468f, 0.03642578f, -0.03968688f, -0.13849810f, 
    -0.05706894f, 0.00519869f, 0.02656186f, 0.17020172f, -0.09616978f, 0.11750357f, 0.15943435f, -0.05295266f, 
    -0.00210186f, -0.08177659f, -0.03837028f, 0.05964846f, -0.04319891f, -0.05876426f, 0.00151565f, -0.10538344f, 
    -0.26919356f, -0.00373882f, -0.11762270f, 0.13680434f, -0.05663531f, 0.21354675f, 0.11726157f, -0.05068018f, 
    0.29131442f, -0.01021710f, 0.10590330f, 0.07949381f, 0.16342892f, 0.14827049f, 0.05699691f, 0.09335031f, 
    0.02873506f, 0.07697707f, -0.01385611f, -0.09391898f, -0.00521965f, -0.04871025f, -0.06938495f, -0.01272776f, 
    0.13475962f, 0.16694118f, 0.10509240f, -0.05219875f, -0.12373920f, -0.12209108f, -0.15505023f, -0.05130643f, 
    -0.00787830f, 0.04682862f, -0.01056593f, -0.02110174f, 0.10958597f, -0.07287826f, 0.01867276f, 0.05470365f, 
    -0.07135259f, 0.01805822f, 0.01067083f, -0.01089034f, -0.05486028f, 0.02129960f, -0.02465133f, 0.04590198f, 
    0.04526618f, 0.03517174f, 0.00419546f, -0.02950012f, 0.05370283f, 0.17813183f, 0.03292023f, 0.00642710f, 
    -0.02245390f, 0.04363142f, -0.03023863f, 0.06081345f, 0.10459261f, 0.12050658f, 0.19509190f, 0.12800331f, 
    -0.04134381f, -0.00184630f, 0.01985662f, -0.07206561f, -0.04200132f, 0.05782955f, 0.08193348f, 0.12621970f, 
    -0.09181852f, 0.03375519f, 0.05594307f, 0.01250034f, -0.04830179f, -0.08201128f, 0.01655457f, -0.07979265f, 
    0.02007175f, 0.02825974f, 0.07149050f, 0.14443064f, 0.09243710f, -0.05189957f, 0.07147424f, 0.00855480f, 
    -0.00376367f, -0.03781524f, 0.02897688f, -0.09953777f, -0.11462921f, -0.07041221f, -0.01058889f, 0.03216540f, 
    -0.11164580f, 0.05692733f, 0.19924991f, -0.02375404f, 0.09455149f, 0.00398227f, -0.21229964f, -0.08090022f, 
    -0.04765859f, -0.04088089f, 0.02003439f, -0.05427342f, -0.10731476f, -0.25196472f, -0.14944743f, -0.05662432f, 
    0.02044466f, 0.11848664f, 0.14835992f, 0.01223725f, -0.00687676f, 0.04406354f, -0.00629165f, -0.12692542f, 
    0.01297610f, -0.17957640f, -0.13420552f, -0.02778454f, -0.11068134f, -0.13570200f, -0.04171351f, 0.05091103f, 
    -0.11981127f, 0.00264330f, 0.00175645f, 0.04256627f, 0.04361428f, 0.09042262f, -0.02456219f, 0.04717702f, 
    -0.11360844f, 0.13590533f, 0.10465838f, -0.12506685f, 0.09367152f, 0.05880395f, -0.12615199f, -0.01492296f, 
    0.02113624f, 0.12159719f, -0.19579671f, -0.07222468f, -0.10386357f, -0.05885396f, 0.16362548f, 0.04795966f, 
    0.01361988f, -0.04078845f, -0.01244432f, -0.03006431f, 0.04229352f, 0.03439521f, 0.02710486f, 0.04708441f, 
    -0.11939914f, 0.12721312f, 0.04368849f, 0.05251002f, -0.03371535f, 0.07304509f, 0.15395415f, 0.10673954f, 
    0.18507288f, 0.06371886f, -0.23019032f, 0.10158627f, -0.01737363f, 0.01949043f, 0.21599567f, 0.08659798f, 
    -0.03729674f, 0.02786432f, -0.01308024f, -0.01316790f, 0.22339229f, 0.16045895f, -0.05233605f, 0.01417623f, 
    -0.03596361f, 0.04780398f, 0.05699880f, 0.06593339f, 0.04392965f, -0.00864782f, 0.15888311f, 0.05681086f, 
    0.01290657f, 0.04464211f, 0.15116274f, 0.04767952f, 0.06997091f, 0.01675401f, -0.05129701f, 0.04206172f, 
    0.14390300f, -0.08362987f, 0.11003221f, -0.02112330f, -0.00164595f, 0.05109483f, 0.12120717f, -0.05549572f, 
    0.02061183f, 0.00589051f, 0.04276341f, -0.06283906f, 0.16122758f, -0.16968003f, 0.16834867f, -0.04717236f, 
    -0.05147758f, -0.10732164f, 0.00504651f, -0.04319369f, -0.10814320f, 0.11014400f, 0.04841825f, 0.01548256f, 
    0.07968658f, -0.09569750f, -0.06055401f, 0.10799021f, 0.11627785f, -0.05818755f, -0.08805794f, 0.08707385f, 
    0.03110895f, 0.06519084f, -0.02717818f, 0.01678884f, -0.01379472f, 0.00942427f, -0.10053188f, -0.07735556f, 
    0.15592594f, -0.00982190f, -0.11435705f, -0.04032678f, -0.00844188f, 0.05610240f, 0.13420328f, -0.11826237f, 
    0.06339253f, -0.02173468f, 0.02347099f, -0.02640562f, -0.01358011f, 0.15138172f, 0.13020346f, 0.20640901f, 
    -0.08999739f, -0.02592879f, 0.04797415f, -0.00839686f, 0.00456400f, 0.01439896f, 0.09429134f, 0.10031061f, 
    0.16963015f, -0.31938994f, 0.18492502f, 0.08226338f, 0.00866974f, 0.02603909f, -0.09249043f, 0.01244380f, 
    -0.08050513f, 0.01660604f, -0.00593831f, -0.04201270f, 0.15314487f, -0.04031833f, -0.11936305f, -0.03511235f, 
    -0.01051435f, 0.04674734f, 0.09561942f, 0.03702953f, 0.01345555f, -0.00667852f, -0.10212151f, 0.11296476f, 
    0.06979740f, -0.18006238f, -0.02595529f, -0.04024009f, 0.04239286f, 0.05133443f, 0.12593769f, -0.05631107f, 
    0.04790096f, 0.11714398f, 0.07132373f, -0.11286453f, -0.13352494f, 0.03632416f, 0.20896739f, -0.06019793f, 
    -0.00274678f, -0.06559145f, 0.01966190f, 0.05827075f, -0.01373381f, 0.01710941f, 0.04857922f, 0.12503953f, 
    -0.07005709f, 0.05904587f, 0.12414918f, 0.00138172f, 0.14233644f, 0.15880048f, -0.07563292f, 0.05921381f, 
    -0.09564795f, -0.02437795f, 0.16600235f, 0.19322693f, 0.18441314f, 0.11067378f, 0.08220223f, 0.19969150f, 
    0.00951049f, -0.03417559f, -0.10792091f, -0.05404766f, 0.00001277f, -0.03878525f, -0.08134612f, -0.08964940f, 
    0.06829075f, -0.01871914f, -0.02700262f, -0.06272094f, -0.12005372f, 0.04500564f, 0.10415341f, -0.05711937f, 
    -0.01267669f, 0.08118851f, 0.01183763f, 0.05520333f, 0.03923812f, 0.12893716f, -0.03972862f, 0.08564372f, 
    -0.07603183f, 0.03130277f, -0.05921516f, 0.01868178f, 0.00599831f, -0.06464049f, 0.02793332f, 0.07091951f, 
    -0.05372455f, -0.08533528f, 0.10921150f, 0.03996363f, 0.01019333f, 0.03550961f, -0.01658544f, -0.01716287f, 
    -0.05472379f, -0.15062304f, -0.08330482f, 0.02976555f, 0.13587461f, -0.18009117f, 0.01061898f, 0.14395325f, 
    0.00341814f, 0.12508045f, -0.09662405f, 0.08410951f, -0.07017273f, -0.06699599f, 0.09913491f, 0.06669701f, 
    0.00996580f, 0.05694872f, 0.08866502f, 0.02746704f, 0.04542778f, 0.01845702f, -0.03968932f, 0.00990254f, 
    -0.04520508f, -0.00580653f, -0.15741122f, -0.20852490f, -0.06165598f, -0.18655564f, -0.18733682f, 0.00992409f, 
    0.10201322f, 0.14559942f, 0.15142395f, 0.03484232f, 0.02499590f, -0.02455167f, 0.03611715f, -0.03382101f, 
    0.04307403f, 0.17978917f, -0.03372515f, 0.10606352f, 0.11245688f, 0.04382958f, -0.04381651f, -0.03269106f, 
    -0.05219159f, -0.14699098f, -0.00657947f, -0.00443821f, 0.11200614f, 0.25583097f, -0.22232489f, -0.11273523f, 
    0.01520171f, -0.06689708f, 0.05520695f, -0.05283969f, 0.15241323f, -0.04350490f, 0.11460014f, -0.01713924f, 
    -0.04831983f, 0.06453672f, -0.06380683f, 0.06797350f, 0.03190957f, 0.09812605f, -0.07483799f, 0.05007342f, 
    -0.07367642f, 0.07542198f, -0.00868914f, -0.04727581f, 0.25238055f, -0.10496911f, -0.06595811f, 0.02004724f, 
    -0.08017534f, -0.00623534f, 0.03608183f, 0.01643621f, -0.01473920f, -0.12582931f, -0.08734617f, -0.10621931f, 
    0.01369032f, -0.00659077f, 0.00175284f, 0.01912329f, 0.03473073f, -0.03023309f, 0.01355420f, 0.02093097f, 
    -0.01694150f, -0.01095059f, -0.00306380f, -0.03377975f, -0.04032354f, 0.01858785f, -0.02511517f, -0.01330970f, 
    -0.00481190f, -0.00918356f, -0.02888849f, 0.00181978f, -0.03860404f, -0.01769714f, 0.01059093f, -0.03775478f, 
    -0.02816445f, -0.00957592f, 0.02252652f, -0.00406113f, -0.01001723f, 0.02906002f, -0.02044288f, -0.01392487f, 
    -0.03956756f, 0.00536279f, -0.03559699f, 0.02818991f, -0.00985966f, -0.01422174f, 0.02109714f, 0.02219211f, 
    -0.01250082f, -0.01462936f, -0.02693914f, -0.04066553f, 0.02230180f, -0.02646732f, -0.02844383f, -0.02847695f, 
    -0.03319366f, -0.03157027f, 0.00136795f, -0.03170586f, 0.01957444f, 0.01996843f, -0.00168367f, 0.00436250f, 
    -0.01584209f, 0.01308663f, 0.02345558f, 0.00220530f, -0.03434429f, -0.02083100f, -0.00736675f, 0.01114992f, 
    0.02671921f, -0.02684511f, 0.01269056f, -0.03904983f, -0.00963333f, 0.00685488f, -0.01737663f, -0.01172748f, 
    -0.00118019f, 0.00264835f, -0.01198821f, 0.01718934f, -0.03586041f, -0.03168343f, -0.02915353f, 0.01386662f, 
    0.00097795f, -0.02162074f, 0.00665348f, -0.03810854f, -0.01973977f, 0.02152307f, -0.01566307f, 0.01215234f, 
    0.01942118f, -0.00442573f, 0.01591301f, 0.02754182f, -0.02824354f, -0.03832354f, -0.02945726f, -0.02520062f, 
    -0.01372099f, 0.00000619f, 0.00020782f, -0.02265481f, -0.02967098f, -0.00771631f, -0.00917242f, -0.03153699f, 
    -0.02784653f, 0.00739572f, 0.02513545f, -0.01894865f, 0.01812326f, 0.00345618f, -0.01141295f, -0.02362199f, 
    -0.01148704f, -0.00338901f, 0.02155103f, 0.00043233f, -0.01398274f, -0.01205796f, -0.00202425f, -0.04009704f, 
    -0.03385163f, -0.02912281f, 0.00289886f, 0.01669811f, 0.02504054f, 0.03197981f, 0.01310567f, -0.02347076f, 
    0.00250197f, 0.01132901f, -0.00288888f, 0.03046232f, -0.02627986f, 0.02107510f, -0.02349017f, -0.01821302f, 
    -0.03098907f, 0.01187720f, 0.00417975f, 0.02357512f, 0.02087651f, 0.01969597f, 0.00470423f, -0.00430046f, 
    0.01663799f, -0.02291908f, -0.03690740f, -0.03041721f, -0.00582679f, -0.02044146f, 0.02949405f, -0.02714796f, 
    -0.02512541f, 0.02821878f, -0.04079298f, 0.02095908f, -0.01101417f, 0.01707748f, 0.01091565f, 0.01747108f, 
    0.02707726f, 0.02012989f, -0.02762769f, 0.00727522f, -0.02640757f, -0.02655651f, 0.02704075f, -0.01552388f, 
    0.01902719f, -0.01630801f, 0.02331208f, -0.03515716f, 0.00349878f, 0.00141036f, -0.02464003f, 0.01111966f, 
    0.01036338f, 0.03427226f, 0.02549232f, 0.00304066f, 0.02230539f, 0.02851807f, 0.02572137f, -0.02182781f, 
    -0.02109140f, 0.02485218f, -0.03219479f, -0.03074810f, 0.02170041f, 0.00616459f, 0.00640574f, 0.00006159f, 
    -0.00184513f, 0.01916106f, -0.01032373f, -0.01282192f, 0.00604489f, -0.03956868f, 0.02974589f, -0.02552099f, 
    0.01246514f, -0.03488331f, -0.01225163f, -0.02852341f, -0.02070463f, 0.01090684f, -0.01777084f, 0.02998234f, 
    0.00528603f, -0.00038659f, -0.01909653f, -0.02859889f, -0.00947760f, -0.01865316f, -0.00263729f, 0.00491815f, 
    0.01206796f, 0.03210400f, 0.03221850f, -0.01139660f, 0.00578114f, 0.01741687f, -0.00390183f, -0.03056393f, 
    -0.01417932f, 0.01222428f, -0.02460556f, -0.02623848f, 0.01860658f, 0.01087243f, 0.02373593f, -0.02817790f, 
    0.00288871f, 0.01767652f, 0.01963996f, -0.00512052f, -0.02099881f, 0.01821747f, 0.02043226f, -0.03112178f, 
    0.02309406f, -0.03813810f, -0.00939180f, -0.03373430f, 0.03010848f, -0.04117296f, 0.00465147f, 0.02306262f, 
    -0.02218742f, -0.02677463f, -0.03857610f, -0.00293530f, 0.02122278f, 0.01101449f, -0.03593647f, 0.01927462f, 
    -0.02605512f, 0.03170443f, -0.00213266f, 0.02612855f, -0.03036192f, 0.01125136f, -0.02345192f, -0.03667398f, 
    -0.02156558f, -0.02985377f, 0.00337507f, -0.02456763f, -0.02174410f, -0.00092797f, -0.01700527f, 0.02146918f, 
    -0.01114021f, -0.02293315f, -0.00563838f, 0.01566657f, 0.00945133f, 0.00604259f, -0.01795724f, -0.01282043f, 
    -0.01844112f, 0.00687956f, 0.02202944f, 0.00106790f, 0.00213439f, -0.01526155f, -0.02305140f, 0.03392013f, 
    -0.02175136f, -0.00090436f, -0.00550585f, -0.00419486f, -0.03793011f, -0.03849716f, -0.01834929f, -0.02867055f, 
    0.00111170f, -0.03777554f, 0.00362891f, 0.00263919f, -0.03029425f, 0.00694519f, -0.00953882f, 0.00034859f, 
    0.02297696f, -0.02191457f, 0.02339630f, -0.00740342f, -0.01479153f, 0.00757127f, -0.02856987f, -0.00565700f, 
    -0.01209531f, -0.00649221f, -0.03573110f, 0.00126860f, -0.01928685f, 0.00002579f, -0.01308981f, -0.00722646f, 
    0.02299479f, -0.01447715f, 0.00768281f, -0.01428789f, 0.01205557f, 0.03452051f, -0.03068208f, 0.02277110f, 
    0.00969414f, -0.03349416f, -0.01273934f, -0.01286346f, 0.01234358f, -0.00811135f, 0.03498236f, -0.03512694f, 
    -0.02115663f, -0.00419212f, 0.02769925f, -0.04131776f, 0.00754097f, -0.00796802f, -0.01562293f, 0.00510578f, 
    -0.02305012f, -0.02505151f, -0.02251018f, -0.03958749f, -0.00381240f, -0.03997620f, -0.00768399f, -0.01857432f, 
    -0.01715537f, -0.02257798f, -0.03457467f, 0.00700459f, -0.02537219f, 0.00560646f, 0.00752293f, 0.00035354f, 
    0.00826429f, 0.01907997f, -0.01856623f, -0.02233897f, -0.00522924f, 0.01418155f, -0.01942820f, 0.03580599f, 
    -0.00322318f, 0.00719514f, 0.02242307f, 0.01389898f, 0.02173431f, 0.02701976f, 0.00695124f, -0.02410393f, 
    0.01360697f, -0.02521421f, -0.03840131f, 0.00249344f, -0.02997541f, -0.01326300f, 0.00375663f, 0.00257211f, 
    0.01752505f, -0.01108219f, -0.01963155f, 0.02120052f, 0.02908473f, 0.01364906f, 0.01167111f, 0.00762901f, 
    0.00600255f, 0.02273976f, -0.01711543f, 0.01213912f, -0.02519515f, -0.01686369f, -0.01942620f, -0.02140669f, 
    -0.03396066f, -0.00837667f, 0.01946188f, -0.00091211f, 0.00883411f, 0.00043866f, -0.01968008f, 0.02618744f, 
    -0.02890557f, -0.02962189f, 0.02563314f, 0.02496621f, 0.01850350f, 0.02460540f, -0.01266940f, 0.01630026f, 
    -0.01481757f, -0.02290543f, -0.02487483f, -0.02600148f, 0.00712162f, 0.02215643f, 0.03119140f, -0.02838643f, 
    0.01565156f, 0.03119341f, 0.02948657f, -0.02778432f, 0.00349009f, -0.01909444f, -0.00750746f, -0.00739186f, 
    -0.03097796f, 0.00391283f, -0.01824579f, 0.01621431f, 0.02616175f, -0.02227293f, 0.01067003f, 0.00678447f, 
    -0.02272241f, 0.02143561f, 0.00325561f, 0.01773817f, -0.04011044f, 0.01460988f, -0.00913419f, -0.03156410f, 
    0.03442233f, 0.00169807f, -0.02915687f, 0.02015467f, -0.03081137f, 0.01987857f, -0.03218938f, -0.01800963f, 
    -0.00844145f, -0.01744470f, -0.01066576f, 0.00638826f, -0.00775886f, -0.00002790f, 0.01551260f, -0.03327156f, 
    0.01446992f, -0.00383816f, -0.01111303f, 0.03392429f, -0.03684849f, -0.01635469f, -0.00081318f, -0.00629380f, 
    -0.02396602f, -0.03912689f, -0.02959754f, 0.01345766f, -0.03205731f, 0.02553097f, -0.03100090f, -0.03742655f, 
    0.00541018f, 0.02281349f, -0.02692050f, -0.03580917f, 0.01960131f, -0.02244212f, 0.03314623f, 0.02469034f, 
    0.01852373f, -0.02223717f, 0.01110792f, 0.01689148f, 0.00681960f, 0.01563719f, 0.02322495f, -0.00597728f, 
    0.01695113f, -0.04138355f, 0.02302239f, -0.03831287f, 0.00659856f, -0.02046968f, -0.03974813f, -0.01391140f, 
    -0.02130869f, 0.01045405f, -0.00875102f, -0.03121088f, 0.02636371f, 0.00817297f, -0.03806485f, -0.04119221f, 
    -0.00419123f, -0.02772797f, 0.00427612f, -0.00566761f, 0.00694720f, 0.01190415f, -0.01400260f, -0.02417581f, 
    0.02539041f, 0.02319082f, -0.02551589f, 0.01017258f, -0.02399554f, -0.01396417f, -0.02351469f, 0.00980808f, 
    -0.02274642f, -0.02205900f, 0.01641167f, 0.02176434f, 0.01645467f, -0.01067823f, -0.04016002f, -0.03409595f, 
    -0.01849213f, -0.03143867f, -0.03529408f, -0.01516601f, -0.00844823f, -0.03108463f, 0.02322350f, -0.01223526f, 
    -0.02989708f, 0.00886586f, 0.01957382f, -0.01539982f, 0.02888548f, -0.00322023f, -0.01145154f, -0.03347551f, 
    0.01146306f, -0.00876007f, -0.01097597f, 0.02587772f, -0.02548099f, -0.02052533f, 0.01464458f, -0.03916904f, 
    -0.02875910f, 0.02892410f, -0.00583850f, -0.00608176f, -0.00373145f, 0.02334367f, -0.00611687f, -0.03592646f, 
    -0.02357876f, -0.02912007f, -0.02336323f, -0.03218395f, 0.00882765f, 0.00184692f, -0.03380515f, -0.01830664f, 
    -0.02159522f, 0.01848867f, 0.02688061f, -0.03852474f, 0.00045231f, -0.00313420f, 0.02660886f, 0.00702469f, 
    0.00201883f, -0.02568802f, -0.00306375f, 0.01339760f, -0.01098442f, -0.01595763f, -0.02876267f, 0.00739300f, 
    0.00498455f, 0.00076883f, -0.03623563f, 0.01075181f, 0.00487446f, -0.00666694f, -0.01707550f, -0.00949943f, 
    -0.01455610f, 0.00721852f, 0.02375786f, -0.03580570f, 0.00271128f, -0.01717261f, 0.02676357f, 0.01389575f, 
    0.00038780f, 0.01960100f, 0.00305863f, 0.00820121f, 0.02529992f, -0.03246401f, 0.01728467f, -0.02053351f, 
    0.03040574f, -0.02844252f, -0.03383696f, 0.01066064f, 0.02515073f, 0.02798692f, -0.03118550f, -0.02849027f, 
    -0.01496069f, 0.01506886f, -0.01565846f, -0.03220991f, -0.01316154f, -0.00607432f, -0.00635535f, -0.00468653f, 
    -0.03392105f, -0.01613508f, -0.02439547f, -0.01433967f, -0.01150572f, 0.03328894f, -0.00057659f, -0.01891024f, 
    -0.03309229f, 0.01277796f, -0.00672274f, -0.02191247f, -0.02558766f, -0.01096183f, -0.00948822f, -0.02912950f, 
    0.02842446f, 0.00771491f, 0.01054709f, -0.00940493f, 0.03049484f, -0.01192586f, 0.02828745f, 0.01831975f, 
    -0.03866450f, -0.02553307f, -0.00890141f, -0.02293833f, 0.01744884f, 0.02584161f, -0.02190411f, -0.03510829f, 
    -0.03765344f, -0.01053945f, 0.02853731f, 0.01227601f, -0.03626565f, 0.00498738f, -0.01869288f, -0.01679784f, 
    -0.01325040f, -0.00406946f, -0.02625808f, 0.01204172f, 0.01630432f, -0.01457403f, 0.01004515f, 0.00802673f, 
    -0.00709337f, -0.03519990f, 0.00432577f, 0.02912751f, -0.02254594f, -0.01671788f, 0.00442881f, -0.01323262f, 
    0.02234949f, -0.02264005f, -0.00146382f, -0.03263098f, 0.01794802f, 0.00601018f, -0.01373534f, -0.04093795f, 
    0.02368009f, 0.01292909f, -0.04119440f, 0.02818672f, -0.03644360f, -0.03347978f, -0.03487435f, 0.01888228f, 
    0.02587634f, -0.00778618f, 0.01152419f, 0.02765439f, -0.00150853f, -0.03463526f, -0.00224153f, -0.00712552f, 
    -0.00930577f, -0.00532418f, 0.01995309f, -0.02009111f, 0.02802201f, -0.04072663f, 0.02096408f, -0.00781523f, 
    -0.00170870f, -0.01047626f, -0.00614899f, -0.02745720f, 0.00833933f, -0.03348885f, 0.03233844f, 0.02549716f, 
    0.02029221f, -0.01570862f, -0.00775036f, -0.01983954f, 0.00968812f, -0.03166121f, -0.00286921f, 0.01142743f, 
    0.00630519f, -0.00709977f, -0.00926948f, 0.00553855f, -0.00993607f, -0.00395227f, 0.00352150f, -0.02602622f, 
    -0.01301431f, 0.01212841f, 0.02859465f, 0.01058460f, -0.00381607f, -0.04039058f, -0.03671371f, -0.00058957f, 
    0.01226697f, -0.01034660f, -0.02703220f, -0.01224509f, 0.02904280f, 0.02860634f, -0.02038311f, 0.02878249f, 
    0.02493932f, -0.02649028f, -0.01465770f, 0.02545836f, 0.01267668f, -0.00533775f, 0.00809069f, -0.01342568f, 
    0.00921154f, -0.01065673f, -0.02267739f, 0.01747694f, 0.01509011f, -0.01908166f, -0.02331641f, -0.02070886f, 
    -0.03583241f, 0.02263476f, 0.00573840f, -0.01686550f, 0.00847163f, 0.02428253f, -0.02042171f, 0.02522636f, 
    -0.01722674f, -0.03710412f, -0.00827965f, 0.00804280f, 0.00689952f, -0.00322482f, 0.02984490f, 0.02726433f, 
    0.00771029f, -0.01268194f, -0.03342951f, 0.00455200f, 0.00122901f, -0.03451330f, -0.01872555f, 0.00985128f, 
    -0.01113889f, 0.02490616f, 0.01374066f, 0.00731593f, 0.01697381f, 0.01010353f, -0.00561316f, 0.00612714f, 
    -0.02241185f, 0.01107728f, 0.00209068f, 0.03643708f, -0.01188532f, -0.00797975f, -0.02141603f, -0.02291172f, 
    -0.01178572f, 0.02532390f, -0.00118823f, 0.01567430f, -0.03147674f, 0.00803216f, 0.01586258f, -0.03126453f, 
    0.00332547f, 0.02045256f, 0.01634014f, 0.00607474f, -0.00097877f, -0.04045896f, -0.00304473f, -0.00196900f, 
    -0.00141948f, -0.04182422f, 0.00918019f, 0.02955393f, -0.03503757f, 0.00467668f, 0.02684586f, 0.00654611f, 
    -0.00505104f, -0.04095162f, 0.00104016f, 0.01024986f, -0.01975571f, -0.02632843f, 0.00177019f, 0.02322223f, 
    0.02269106f, -0.00131973f, -0.04030872f, 0.02706420f, 0.01950337f, -0.02867182f, -0.02832898f, 0.01505261f, 
    -0.02712402f, -0.01521918f, -0.01154865f, -0.01679618f, 0.01367983f, 0.00742247f, 0.00874513f, -0.03663453f, 
    -0.01362958f, -0.03725244f, -0.03305849f, 0.00392347f, -0.03456527f, -0.02852248f, 0.01968736f, -0.02834826f, 
    -0.01324853f, 0.00788223f, 0.02207174f, -0.01035899f, -0.02824424f, 0.02963053f, -0.03531615f, 0.03143177f, 
    -0.01721335f, -0.02333736f, 0.01426542f, 0.01726317f, 0.00760221f, -0.02673265f, -0.00783693f, -0.00646971f, 
    -0.01327896f, -0.01745248f, 0.01137508f, -0.02788798f, -0.03228028f, 0.00160366f, 0.01901284f, 0.01681621f, 
    -0.04181862f, -0.00804638f, -0.02758183f, -0.02422334f, -0.00760541f, -0.02649647f, 0.01487909f, -0.03815060f, 
    -0.03219878f, 0.03748343f, 0.00183849f, 0.00745946f, -0.00424083f, 0.01879811f, -0.03750096f, -0.00000758f, 
    0.02222255f, -0.00902936f, -0.01664081f, 0.01866728f, -0.02511527f, 0.01615431f, -0.00361228f, 0.00824053f, 
    0.01142369f, -0.00599350f, -0.03148391f, -0.00323985f, -0.00378451f, 0.00033001f, 0.02809677f, -0.04091567f, 
    0.00256646f, 0.01089397f, -0.00955221f, 0.00965287f, -0.01170107f, 0.03807857f, -0.02660488f, -0.03249269f, 
    -0.03969246f, 0.00036659f, -0.04069244f, -0.01201643f, -0.02239261f, 0.02184922f, -0.01785026f, -0.01168577f, 
    -0.01552617f, -0.03803971f, -0.03107101f, 0.00401634f, -0.00055877f, -0.03702030f, -0.02008446f, 0.02991218f, 
    -0.01913486f, 0.00352152f, -0.03005367f, 0.01889992f, 0.00984736f, 0.02040934f, -0.02960971f, -0.02878651f, 
    -0.02757332f, -0.01438894f, 0.00117220f, -0.03742576f, -0.01103819f, -0.01955212f, -0.03986328f, -0.02764276f, 
    -0.01560518f, 0.01460965f, -0.02065762f, 0.00354784f, -0.00097702f, 0.00983126f, -0.01596181f, 0.01904222f, 
    -0.01155723f, -0.04162714f, -0.02943630f, -0.02494504f, 0.00277269f, -0.03461384f, 0.00761836f, 0.02383411f, 
    -0.02266156f, -0.03111412f, 0.01867389f, -0.00185148f, 0.02578166f, -0.01736802f, -0.04175889f, -0.01782449f, 
    -0.01802536f, -0.00742801f, -0.01866609f, 0.02654122f, -0.01739389f, -0.00358143f, -0.00963838f, -0.00889790f, 
    0.01832784f, -0.03553529f, -0.01382844f, -0.03101879f, -0.01095302f, -0.04153690f, 0.02984086f, 0.02218795f, 
    -0.00843411f, -0.03253634f, 0.01242436f, -0.01574348f, 0.02423559f, 0.01904579f, 0.02050128f, 0.01412921f, 
    0.03783209f, -0.01418551f, -0.02078293f, -0.04076806f, 0.00462348f, -0.01331090f, -0.00895275f, -0.02994503f, 
    -0.00056853f, -0.02584045f, -0.03651095f, 0.00197869f, -0.03446979f, 0.02293799f, -0.01600769f, 0.02284967f, 
    -0.00262465f, 0.00084564f, 0.01308118f, -0.02737107f, -0.00362184f, 0.01476186f, 0.00345281f, -0.00688523f, 
    0.00995576f, 0.01052396f, -0.01984219f, 0.01224095f, -0.01139363f, 0.02477293f, -0.00026633f, -0.01280947f, 
    -0.00167268f, 0.00378623f, 0.02004657f, -0.00729912f, -0.01439425f, -0.02648580f, 0.01189520f, -0.00735925f, 
    -0.00873332f, -0.01039262f, 0.01009477f, -0.00085985f, 0.00280093f, 0.02181437f, -0.03366046f, 0.01523163f, 
    -0.00663338f, 0.00399368f, -0.02297015f, -0.01569222f, -0.00307875f, -0.01471080f, -0.03900129f, 0.03395081f, 
    -0.03370338f, -0.02628602f, 0.00677575f, -0.01383673f, -0.00639237f, 0.02169293f, -0.03106807f, 0.02259142f, 
    -0.00517287f, 0.01007188f, -0.03742437f, -0.01728772f, -0.04143006f, 0.02069473f, -0.00508615f, -0.02332329f, 
    -0.03853517f, 0.02940921f, -0.03571786f, -0.02501718f, -0.04189254f, -0.02499860f, -0.01748933f, 0.02105517f, 
    -0.03542059f, -0.00610409f, -0.02825363f, -0.00586555f, -0.01532250f, 0.02889767f, -0.04009341f, -0.01365081f, 
    -0.04121871f, -0.03437315f, -0.00863810f, -0.01208173f, 0.02896758f, -0.00897188f, -0.02025101f, 0.01298365f, 
    0.02828725f, 0.00910945f, 0.00317877f, 0.00480133f, -0.03352765f, -0.02723074f, -0.00280834f, -0.00023984f, 
    0.02103081f, -0.01037999f, -0.03390573f, -0.00907358f, -0.00100524f, -0.02416464f, 0.00077970f, 0.01717375f, 
    0.00967987f, -0.02484159f, 0.01026940f, -0.04092035f, 0.02993473f, 0.00662725f, 0.02701400f, -0.01780605f, 
    -0.01308823f, -0.03836069f, -0.04139986f, 0.00442596f, 0.02983841f, 0.02047266f, -0.01502222f, -0.02825729f, 
    -0.03942674f, -0.00345419f, 0.01677539f, 0.00799354f, 0.00626500f, -0.03600129f, 0.01568216f, -0.00638878f, 
    -0.00265912f, 0.02559558f, -0.01247806f, 0.01535479f, 0.02472025f, 0.03995352f, 0.01851001f, 0.00052824f, 
    -0.02553356f, -0.02456690f, -0.04055984f, 0.01399341f, -0.01961977f, -0.02601325f, 0.02764591f, -0.03732335f, 
    0.00268758f, -0.00020039f, -0.04145214f, -0.02678181f, 0.02177815f, 0.02931156f, -0.04193118f, -0.00772547f, 
    -0.04047542f, -0.02817462f, -0.01757558f, 0.01545440f, -0.01526073f, -0.02311596f, -0.00059318f, -0.01919272f, 
    -0.03968671f, 0.02556290f, -0.02190226f, 0.02893467f, -0.00686277f, 0.02306075f, -0.03440311f, -0.02412553f, 
    0.02528368f, -0.03751005f, -0.02464231f, -0.02497942f, 0.01598522f, 0.00618508f, -0.03930847f, -0.00418300f, 
    -0.01947388f, 0.00727237f, -0.00167964f, -0.02237070f, -0.03084655f, 0.02168326f, 0.01062580f, -0.01712467f, 
    0.02771030f, -0.02344012f, -0.02596072f, 0.02282551f, -0.02568321f, -0.03592614f, 0.01859285f, 0.02178857f, 
    0.01603598f, -0.04009488f, -0.02604335f, 0.00232621f, -0.00138521f, 0.01413938f, 0.01533370f, 0.00253369f, 
    0.02554565f, -0.01347157f, 0.02022431f, 0.02267086f, -0.01282847f, 0.01535776f, -0.00669448f, -0.03719033f, 
    0.00484728f, -0.01944682f, -0.02845800f, -0.02558870f, 0.04105864f, 0.03501312f, -0.02421853f, -0.00824199f, 
    -0.01060439f, 0.04175095f, 0.04127199f, -0.00438237f, 0.01598176f, -0.04001962f, 0.00794684f, 0.02261862f, 
    -0.00515731f, 0.02161879f, -0.00642943f, 0.01206308f, -0.00628947f, -0.02734771f, -0.01088706f, 0.01072437f, 
    -0.02828848f, 0.02860878f, -0.01023293f, -0.03143938f, -0.01566308f, 0.02590308f, 0.01835658f, -0.02937107f, 
    -0.00829134f, -0.01842722f, 0.02100973f, -0.00038330f, -0.00056440f, -0.03362966f, -0.01534905f, -0.02788796f, 
    0.01086292f, -0.01843143f, -0.00379047f, 0.02864711f, -0.03625160f, -0.01264951f, 0.02067526f, 0.01130955f, 
    -0.03071892f, 0.01275143f, 0.02844990f, -0.00402158f, 0.02552233f, 0.02888239f, 0.01457836f, 0.01218056f, 
    -0.03081677f, 0.00060979f, 0.01797665f, 0.01568343f, -0.02481508f, -0.01810874f, -0.00652222f, 0.02703870f, 
    -0.01646581f, -0.01243978f, -0.00080924f, 0.01803057f, 0.02275419f, -0.03398464f, 0.00879838f, 0.02149550f, 
    -0.03694473f, -0.00164782f, -0.00792308f, 0.02715097f, 0.02825082f, -0.01403584f, -0.03820134f, -0.03495064f, 
    -0.02077677f, -0.02246273f, -0.02067804f, -0.04066709f, 0.02610062f, 0.00117037f, 0.01802973f, -0.00423199f, 
    -0.03069526f, -0.00306382f, 0.00621555f, -0.03207096f, 0.01570538f, -0.04012303f, 0.01347023f, -0.03339448f, 
    -0.02520274f, -0.03878540f, -0.02158063f, 0.00230297f, -0.00360488f, 0.01937548f, 0.01819600f, 0.00196331f, 
    0.00690330f, 0.00210073f, -0.02668669f, -0.02803280f, -0.04113587f, -0.00821160f, 0.02417108f, -0.01900948f, 
    0.01223087f, -0.02276625f, 0.00810667f, 0.01838906f, 0.01705201f, 0.00829857f, -0.00193225f, -0.01288456f, 
    0.00185209f, 0.02330542f, -0.00482168f, 0.01299632f, 0.02953285f, -0.03237545f, 0.02052163f, -0.00854498f, 
    -0.01208671f, 0.02995459f, 0.00494914f, -0.03363147f, 0.01392986f, -0.01357437f, 0.02828884f, -0.02451207f, 
    -0.03994313f, 0.02896839f, -0.03901262f, 0.00948391f, 0.02095074f, -0.01863397f, 0.00001273f, -0.02519813f, 
    -0.00303907f, 0.01012960f, -0.03134473f, 0.01705096f, -0.00275819f, -0.00958540f, -0.01646291f, 0.00300978f, 
    0.00402680f, 0.01117706f, 0.01907424f, 0.02355909f, -0.00997976f, 0.00035064f, 0.00081599f, 0.00567795f, 
    -0.00025421f, -0.00026761f, -0.03615530f, 0.01588553f, -0.04086547f, 0.01504206f, -0.02524743f, -0.02352283f, 
    0.01693448f, -0.03029791f, -0.01829796f, -0.01008615f, -0.02341682f, 0.02323584f, 0.02472665f, 0.01595245f, 
    -0.03206017f, 0.02575773f, 0.00238698f, 0.00647553f, 0.00746401f, -0.04195587f, -0.03984070f, -0.04006830f, 
    0.01706913f, -0.01187159f, -0.00539815f, -0.02714447f, 0.01670002f, -0.03274118f, 0.02091569f, -0.01817661f, 
    -0.03496188f, 0.01736792f, 0.01710919f, 0.00593956f, 0.01909463f, -0.03771787f, 0.02742021f, 0.01419790f, 
    -0.02924127f, -0.00267323f, -0.04206152f, -0.01399756f, -0.01399653f, -0.01264349f, -0.02043920f, -0.03072309f, 
    0.04183097f, -0.02444816f, -0.00903453f, -0.01460625f, -0.01239976f, -0.00531976f, 0.00005173f, 0.00829660f, 
    -0.00459374f, 0.03750695f, -0.00930001f, -0.00691343f, -0.04020555f, -0.01439839f, -0.00967283f, 0.00039547f, 
    0.03000727f, -0.01857937f, 0.00390582f, -0.02683554f, -0.00472120f, -0.00250629f, -0.02632142f, -0.01567124f, 
    -0.00892216f, -0.03638272f, 0.00262904f, 0.02589894f, -0.01603155f, 0.00520053f, 0.01868793f, 0.02500837f, 
    0.02903189f, -0.02004798f, 0.01821304f, -0.03280814f, 0.00522139f, -0.00560749f, -0.02201035f, -0.02868999f, 
    0.00433277f, -0.02328266f, -0.04138485f, -0.00251748f, 0.00598349f, -0.01776010f, 0.00733970f, -0.02496161f, 
    0.02436542f, -0.01456631f, -0.01498132f, -0.00308655f, 0.00812001f, -0.02946853f, 0.02336802f, -0.03470175f, 
    0.01248779f, -0.01797809f, 0.02010614f, 0.01615310f, -0.02810096f, 0.01593471f, 0.01970113f, -0.03163319f, 
    -0.02233894f, 0.00777672f, 0.01616855f, -0.04058242f, 0.02379831f, 0.01290953f, -0.01402686f, -0.03177386f, 
    -0.04144318f, -0.01740886f, 0.01110166f, 0.00411623f, 0.00433206f, -0.02183297f, 0.03151365f, -0.00014799f, 
    0.02650226f, 0.00432798f, -0.02714243f, -0.03559734f, -0.01957531f, -0.03406758f, -0.01238978f, -0.00398309f, 
    -0.00487046f, -0.02874527f, 0.00661021f, -0.03245609f, -0.01542688f, -0.03799728f, 0.00035686f, 0.02313136f, 
    -0.02880902f, 0.11969758f, -0.19377171f, 0.20779590f, 0.08524243f, 0.06413312f, 0.01259378f, 0.08720936f, 
    0.16454560f, 0.00872291f, -0.00401071f, -0.04959223f, -0.01318994f, -0.06652995f, 0.08508002f, -0.04126508f, 
    -0.11295182f, 0.04038988f, -0.01182550f, 0.13959274f, 0.02194484f, 0.10206329f, 0.17442635f, -0.00038518f, 
    0.08987805f, 0.09066682f, 0.11964009f, -0.33824131f, 0.15226719f, -0.08403253f, -0.03740749f, 0.02363993f, 
    0.12752876f, -0.03288244f, 0.03169303f, 0.06472684f, -0.28258103f, -0.16220003f, -0.23729251f, -0.02993654f, 
    -0.00335829f, 0.05151170f, -0.03413566f, -0.24895436f, -0.01325828f, 0.00503734f, -0.10197830f, 0.01516684f, 
    -0.09470665f, 0.13479179f, 0.01559706f, 0.12659813f, -0.03323478f, 0.02650247f, 0.09649791f, -0.19193064f, 
    0.03951890f, -0.05020632f, -0.03980025f, -0.09903248f, -0.16580549f, -0.17223236f, -0.05540941f, 0.08735219f, 
    0.00744533f, 0.03096206f, 0.05720607f, 0.10951540f, -0.02648907f, 0.07987441f, -0.00392646f, 0.07221893f, 
    -0.25107440f, -0.14111538f, 0.01163011f, 0.17854704f, 0.00151583f, 0.09964141f, -0.08631112f, -0.08057789f, 
    -0.08691820f, -0.08313365f, -0.04732897f, -0.02630788f, 0.02678329f, 0.06570347f, 0.25588745f, 0.16960177f, 
    0.08627435f, -0.19835992f, -0.03380701f, -0.06444898f, -0.07678533f, -0.04822719f, -0.05521427f, -0.07479492f, 
    0.50666761f, 0.22183892f, -0.20808779f, 0.07812878f, -0.04896795f, 0.07159365f, -0.01130752f, 0.06957300f, 
    0.07996456f, 0.06899703f, 0.04525625f, -0.08930780f, 0.04460688f, -0.10905467f, 0.14911889f, -0.19692387f, 
    0.07122875f, 0.07540751f, 0.19039525f, -0.21644595f, -0.03812721f, 0.01606176f, 0.08756628f, 0.01628766f, 
    -0.02117849f, -0.27610198f, -0.04235132f, 0.12919988f, -0.12563118f, -0.07222536f, -0.01813086f, 0.16540535f, 
    0.07674289f, 0.19197114f, -0.01196498f, 0.01032375f, -0.11054330f, -0.14966838f, 0.02111975f, 0.02560834f, 
    -0.00649929f, -0.09986755f, 0.05941528f, 0.04148055f, -0.01760349f, 0.01715243f, 0.01467635f, 0.11216281f, 
    0.37729156f, -0.02506827f, 0.02727140f, 0.21405891f, 0.06945436f, 0.02877572f, -0.14395279f, 0.03912386f, 
    0.01103602f, 0.05907589f, 0.05899358f, 0.07673761f, -0.06685203f, -0.00003801f, -0.24697483f, 0.09066217f, 
    -0.05192287f, 0.12016358f, -0.07174339f, 0.17956391f, -0.04981076f, 0.06333719f, -0.06540073f, 0.13664298f, 
    -0.20918530f, -0.18468788f, 0.00261506f, 0.26561415f, -0.07875576f, 0.11483755f, 0.13567948f, -0.17693855f, 
    -0.00117488f, -0.16193174f, -0.06399207f, -0.04949391f, 0.41987160f, -0.01613244f, -0.04413175f, 0.18694617f, 
    0.01295005f, 0.13571565f, -0.10861803f, -0.01820104f, -0.02820419f, 0.13269874f, 0.20987682f, 0.01073274f, 
    0.07733265f, 0.03177754f, 0.02338386f, 0.02057661f, -0.06253853f, -0.00506531f, -0.04153327f, 0.01161018f, 
    0.06884807f, 0.06659217f, -0.04984564f, -0.12309715f, -0.28411642f, -0.09558734f, 0.02535915f, 0.18682750f, 
    0.08472851f, -0.09983314f, 0.04345309f, 0.00410684f, -0.08378899f, -0.09872691f, -0.04014360f, -0.02931407f, 
    -0.15080686f, -0.07991114f, 0.02868074f, 0.19392836f, -0.01804112f, 0.13682103f, 0.07195154f, -0.07527412f, 
    -0.01735841f, 0.00838187f, -0.00991634f, 0.10506521f, -0.20448232f, -0.24152593f, 0.17656298f, 0.08032757f, 
    0.17854054f, 0.05400173f, 0.05545053f, 0.06208132f, -0.04270006f, 0.06535602f, 0.05595515f, 0.00073680f, 
    0.12882122f, -0.02860944f, -0.02007098f, -0.05517286f, 0.13605420f, -0.00635989f, -0.03498002f, 0.17729855f, 
    0.02967033f, 0.18086807f, -0.05625453f, 0.06110688f, -0.13814521f, -0.07147489f, 0.18862154f, 0.01619415f, 
    0.00842306f, -0.04060098f, 0.07065138f, -0.17952667f, -0.03952020f, 0.01920559f, -0.02392511f, -0.02975188f, 
    -0.26015750f, 0.04910948f, 0.21414705f, 0.06565545f, 0.02626482f, -0.26979592f, 0.09388056f, -0.04876627f, 
    -0.00408203f, -0.03049012f, -0.21682549f, -0.07207306f, -0.18220577f, 0.05993053f, -0.02946217f, 0.15259272f, 
    -0.09820072f, 0.12073027f, 0.15683788f, 0.03299646f, -0.04519246f, -0.00184858f, -0.03959750f, -0.02461345f, 
    0.13197212f, 0.05466582f, 0.02870132f, 0.08914409f, 0.11820416f, -0.04774245f, 0.10941423f, -0.02258733f, 
    0.07866283f, 0.03813274f, -0.01118508f, 0.03741065f, 0.10886243f, 0.02071505f, 0.04244709f, -0.17452940f, 
    -0.01995735f, 0.03517222f, -0.07514840f, 0.00951338f, 0.05152500f, 0.05636846f, 0.13452077f, 0.13886070f, 
    0.16945015f, -0.15622500f, -0.23386663f, 0.08480206f, -0.26060295f, 0.09858654f, 0.12226029f, 0.11267040f, 
    0.20351593f, 0.04532516f, -0.03024334f, 0.08817457f, -0.12708947f, 0.08950454f, -0.01492195f, 0.21160264f, 
    -0.05553370f, 0.06087001f, 0.08430810f, -0.13675904f, 0.02269501f, -0.07062149f, -0.05809030f, -0.02122058f, 
    -0.14521673f, 0.08737024f, -0.18571796f, 0.19212876f, -0.22329527f, -0.12178007f, -0.01025264f, -0.00798445f, 
    -0.01735563f, 0.01862617f, 0.05464598f, -0.04354309f, 0.30332214f, -0.03656867f, 0.08693744f, -0.12042610f, 
    0.02103819f, 0.02561914f, -0.02499802f, 0.12694213f, 0.06497263f, 0.11022890f, 0.08013789f, 0.06408864f, 
    0.05217969f, 0.06884694f, -0.40342870f, 0.15148346f, 0.01177503f, 0.06144169f, 0.18037355f, 0.07624972f, 
    -0.01732718f, 0.11918323f, -0.00626350f, -0.00687396f, 0.17707816f, 0.25026050f, 0.22655435f, -0.13788903f, 
    -0.09759004f, -0.09584408f, 0.01056077f, -0.03732853f, 0.06336875f, 0.11848180f, 0.02670041f, 0.06362877f, 
    0.12337714f, -0.14381152f, 0.00303182f, -0.03042876f, -0.02910133f, -0.08671854f, 0.05079417f, -0.00550044f, 
    0.09868282f, -0.00910673f, -0.08001368f, -0.02215812f, 0.37690207f, 0.57476842f, 0.10118542f, 0.11112186f, 
    0.24592687f, -0.04062760f, 0.04590769f, 0.07221929f, 0.16169493f, -0.03957973f, 0.01737230f, 0.04447162f, 
    0.07323340f, -0.13849708f, 0.01745899f, -0.04177497f, -0.23253836f, -0.07804628f, -0.13862948f, -0.19888820f, 
    0.07655634f, -0.06588633f, -0.12961823f, 0.07933501f, -0.22286071f, 0.25671083f, -0.11568155f, 0.04059002f, 
    -0.05617804f, 0.06194744f, 0.02095911f, -0.02645200f, -0.03959085f, -0.04194753f, 0.16163579f, 0.06644926f, 
    -0.29874951f, -0.02130731f, 0.22629704f, -0.29625994f, 0.18651791f, 0.03714058f, -0.15762022f, -0.17513844f, 
    -0.02075439f, -0.09674050f, 0.02010279f, 0.22054590f, -0.21004754f, 0.22815168f, 0.01198609f, 0.24369098f, 
    -0.09985179f, 0.09276660f, 0.12381306f, 0.10343812f, 0.30734891f, 0.14398229f, 0.00750391f, -0.01518886f, 
    -0.26337034f, -0.18895160f, 0.03722965f, -0.04243345f, 0.06127066f, 0.15922038f, -0.04407681f, -0.04191874f, 
    0.01197143f, 0.03982401f, 0.13135874f, 0.05922853f, 0.03820019f, -0.01765670f, -0.00008164f, 0.00972314f, 
    -0.00762392f, 0.02361186f, 0.08341759f, 0.10343326f, 0.08927350f, -0.02769260f, 0.06137266f, -0.02705207f, 
    -0.32027078f, -0.22611915f, 0.31351361f, 0.25862995f, 0.01352889f, 0.02529883f, -0.01028161f, 0.00552719f, 
    -0.00586408f, 0.02557545f, -0.07350933f, 0.04165285f, 0.37377551f, 0.20875750f, 0.10009360f, -0.11940753f, 
    0.02507916f, -0.08385855f, -0.05493272f, -0.01720414f, 0.11428243f, -0.06540102f, -0.06980956f, 0.00457921f, 
    0.03619817f, 0.05714577f, -0.21488585f, 0.03415299f, -0.13801479f, -0.00130832f, 0.09393899f, -0.12472814f, 
    0.06389007f, -0.07080777f, 0.02694347f, -0.00315179f, 0.08698990f, -0.19756779f, -0.12145748f, -0.18451694f, 
    -0.25595212f, 0.03782710f, 0.02396283f, 0.06404616f, -0.02236072f, 0.00826525f, 0.14674614f, -0.09770123f, 
    0.25528434f, 0.36631018f, -0.10223898f, -0.09543390f, -0.08545354f, -0.04269699f, 0.00284615f, -0.04965690f, 
    0.14608839f, 0.00656966f, 0.06020083f, -0.00917796f, 0.20445442f, 0.01162956f, 0.12037944f, 0.38520074f, 
    0.10890650f, 0.06580643f, 0.03176631f, 0.07159017f, 0.05607358f, -0.02732353f, 0.08452050f, 0.08811091f, 
    -0.18488599f, -0.05766835f, 0.33558142f, -0.12123682f, -0.14032203f, 0.00089013f, -0.08076406f, 0.11649679f, 
    0.00549321f, -0.00868848f, -0.04977519f, -0.08136999f, 0.02433931f, 0.12669165f, 0.18225405f, -0.07580312f, 
    -0.07852715f, -0.11627398f, -0.01428309f, 0.01797873f, 0.05224159f, 0.03474914f, -0.03929894f, 0.00670800f, 
    0.40288797f, 0.09869670f, 0.07526527f, -0.22417396f, 0.04826503f, 0.00940174f, 0.13161667f, -0.06095127f, 
    0.12782554f, 0.08976487f, 0.03284900f, 0.08145767f, 0.02162450f, 0.03945236f, 0.11879849f, 0.10608201f, 
    0.06982017f, -0.03725935f, 0.12753649f, -0.04958211f, 0.05015604f, -0.00092623f, -0.11576012f, 0.01754677f, 
    0.06977636f, 0.23105606f, 0.17796212f, -0.00942492f, -0.01784632f, -0.00433295f, 0.04299571f, -0.05295648f, 
    0.07520976f, -0.15183242f, 0.11628586f, -0.07436366f, 0.18353924f, 0.09720121f, -0.06698331f, -0.07092549f, 
    -0.19970116f, -0.09137996f, -0.00861433f, 0.02559097f, 0.01048300f, 0.06345063f, -0.08787200f, 0.00588876f, 
    0.07705449f, -0.00532119f, -0.04142650f, -0.10934123f, -0.05958600f, -0.10983753f, -0.01240857f, -0.01016589f, 
    -0.01443639f, 0.01263025f, -0.08096009f, -0.04319757f, -0.10347348f, 0.11285687f, 0.12302329f, -0.04739152f, 
    -0.04993616f, 0.00410907f, -0.00667203f, -0.14135981f, -0.04893575f, -0.01086041f, 0.10632630f, -0.08179361f, 
    0.31790558f, 0.24899949f, -0.20214857f, 0.49029851f, -0.02328368f, 0.06066617f, 0.12140057f, -0.15907550f, 
    -0.00497160f, 0.06812040f, -0.00597530f, 0.02755119f, 0.27507016f, -0.06220533f, 0.05491534f, 0.10922240f, 
    0.00761513f, 0.01319590f, 0.02211503f, 0.01406642f, 0.10943171f, 0.06100573f, -0.02761878f, 0.00918028f, 
    0.06891194f, 0.10636467f, -0.00497609f, -0.13662413f, -0.01438134f, -0.01191477f, 0.03172338f, -0.00187377f, 
    0.10326469f, 0.05080873f, -0.04132749f, 0.05471938f, -0.14342596f, -0.27759901f, -0.15133931f, 0.27615657f, 
    0.09665081f, 0.19881344f, -0.20964032f, -0.14901283f, -0.11354779f, -0.06613365f, -0.02574928f, -0.02129812f, 
    0.03758134f, 0.08925079f, -0.04443670f, -0.04764082f, -0.09754137f, -0.02759131f, -0.01885300f, -0.07431690f, 
    0.03602515f, 0.00876041f, -0.03390468f, 0.03478391f, -0.11980534f, 0.26610035f, 0.15211020f, 0.28548476f, 
    -0.10652898f, 0.03854708f, 0.07755893f, 0.09829675f, 0.10739982f, -0.01965380f, 0.07460988f, 0.05359573f, 
    -0.19882475f, -0.31221130f, 0.05719936f, 0.15114540f, 0.03647892f, -0.07671680f, -0.04290532f, -0.01943533f, 
    -0.05673512f, -0.04530123f, -0.04007159f, -0.03232745f, -0.25143477f, 0.19766393f, 0.00104190f, 0.16671628f, 
    -0.05890917f, -0.02228669f, 0.01432496f, 0.18005234f, -0.00142042f, 0.07291763f, -0.00888853f, 0.01242810f, 
    -0.05676544f, 0.13137889f, 0.06525889f, 0.22306415f, 0.00810481f, 0.02368293f, 0.04195220f, 0.28258172f, 
    0.03435694f, 0.02881145f, -0.01383316f, 0.05616851f, 0.19901425f, 0.12030233f, 0.15609971f, -0.04469539f, 
    -0.05236171f, 0.01493261f, 0.00564896f, 0.03175526f, 0.13886996f, -0.10618716f, -0.04189007f, 0.10646413f, 
    0.30195275f, 0.01463145f, -0.21115623f, 0.19029573f, 0.11432461f, 0.15701322f, -0.00780521f, 0.14773828f, 
    0.26762319f, -0.07195216f, -0.03522674f, -0.03161108f, -0.25543869f, -0.15362595f, -0.03889214f, -0.16341971f, 
    -0.00161570f, 0.19775707f, -0.11841857f, 0.02971236f, 0.12308976f, 0.11649155f, 0.24132887f, -0.04487788f, 
    -0.16936031f, 0.15274158f, 0.03509380f, -0.22060756f, 0.06673726f, -0.04653911f, 0.05023330f, 0.11726038f, 
    -0.03280054f, 0.04970983f, 0.08475183f, 0.04626729f, -0.29824501f, -0.08510983f, -0.22235297f, -0.28983718f, 
    0.08569302f, 0.08709822f, 0.14249943f, -0.06871305f, 0.07234597f, 0.01754830f, -0.08826688f, 0.10964137f, 
    0.14841972f, -0.23955926f, -0.08544939f, 0.16515397f, -0.08645898f, -0.03439505f, 0.23283887f, -0.13863423f, 
    0.27482340f, -0.05618092f, 0.10366738f, 0.01217544f, -0.16651203f, -0.02222937f, -0.08782633f, -0.19578993f, 
    0.11501432f, -0.02474617f, 0.02370682f, -0.08744794f, -0.06205623f, 0.14735137f, 0.00644669f, 0.05973075f, 
    0.04164891f, 0.12566225f, -0.27009922f, -0.18800212f, 0.05492390f, -0.04741121f, -0.06949185f, -0.12868206f, 
    -0.01000917f, -0.06053994f, 0.08035214f, 0.06148909f, 0.13650353f, 0.09955993f, -0.03904548f, 0.04276227f, 
    0.08853465f, 0.23885071f, -0.05779793f, -0.01044567f, -0.08680046f, 0.02472441f, 0.01701401f, -0.12018417f, 
    0.11356619f, -0.11652198f, -0.11009865f, 0.11935277f, 0.03490234f, -0.03031045f, 0.04386168f, 0.15215929f, 
    -0.08914203f, 0.03856966f, 0.02139162f, 0.12097616f, -0.16586550f, -0.07595593f, 0.09865905f, -0.30183271f, 
    -0.07954758f, -0.09483001f, 0.18325922f, 0.08634131f, 0.03386635f, 0.04194320f, 0.04000269f, 0.04287534f, 
    0.06609340f, -0.20345314f, -0.04600954f, 0.03907418f, -0.16999811f, -0.13043895f, 0.06516983f, -0.06484502f, 
    0.18761584f, 0.19891649f, 0.13653710f, 0.02852395f, -0.08164507f, -0.00626487f, -0.02723348f, -0.01225577f, 
    -0.00175372f, -0.13899609f, 0.03326798f, -0.19862412f, -0.03541048f, 0.10862303f, 0.15615825f, 0.09335463f, 
    0.33983496f, -0.18813103f, -0.09679306f, 0.26827419f, 0.10372227f, 0.22826988f, 0.10612880f, 0.12273279f, 
    0.05492244f, 0.04433711f, -0.07202528f, -0.06214143f, 0.04551801f, 0.12245984f, -0.00998795f, -0.02915963f, 
    0.02173224f, -0.14182226f, 0.00673996f, 0.11366601f, 0.07142495f, 0.04297300f, 0.11619610f, 0.09745339f, 
    0.08214580f, -0.01964615f, -0.21626200f, -0.09946027f, -0.03601776f, 0.02201714f, 0.02067959f, -0.21222718f, 
    0.01456616f, -0.01314367f, -0.01472546f, -0.04800608f, 0.13007024f, 0.02286899f, -0.00768519f, 0.15256809f, 
    -0.00318983f, 0.15912338f, -0.30624765f, 0.19810422f, -0.06448948f, 0.12558819f, 0.18878874f, 0.06651121f, 
    -0.10026232f, -0.03606717f, -0.00977252f, -0.06471809f, -0.05752392f, -0.09196653f, 0.06853453f, -0.05395576f, 
    0.02592751f, 0.05574363f, -0.02404108f, 0.08302519f, -0.06622102f, 0.05843005f, -0.16387695f, -0.07181222f, 
    0.09676988f, -0.03277459f, -0.16048273f, -0.08818448f, -0.06384841f, -0.00189695f, -0.02065180f, 0.01898635f, 
    0.35609689f, 0.03406381f, -0.08219347f, -0.02264528f, -0.01699551f, 0.01690383f, 0.17982589f, -0.22072180f, 
    0.02463011f, -0.00196937f, 0.09675691f, -0.01191389f, -0.16234837f, -0.09939813f, 0.00537190f, -0.23373847f, 
    0.20459719f, 0.11409542f, 0.02420885f, -0.06448066f, -0.03357562f, 0.17585827f, -0.01807883f, 0.10239840f, 
    0.09010727f, -0.06573866f, 0.04230443f, -0.15132938f, -0.02528307f, -0.05006771f, 0.14309508f, 0.09082834f, 
    0.06636176f, 0.03106288f, -0.06719130f, 0.00625822f, -0.03198123f, -0.19978212f, -0.08343025f, -0.09872201f, 
    0.12234305f, -0.04260729f, -0.16954158f, -0.17019323f, -0.03080202f, 0.00860208f, 0.00558656f, 0.10269428f, 
    0.02689620f, -0.14598784f, 0.01754886f, 0.15875593f, -0.12670784f, 0.02156436f, 0.08699827f, -0.15572061f, 
    0.01578635f, 0.12015730f, 0.02559683f, 0.07183723f, 0.09155491f, 0.01921038f, 0.03765533f, 0.00954721f, 
    -0.00406814f, 0.07420500f, 0.01101125f, 0.04994441f, 0.04921114f, 0.05438728f, -0.00601767f, -0.19018409f, 
    -0.04475413f, 0.03404273f, 0.00031503f, 0.02537339f, 0.03624030f, -0.09414523f, 0.15782692f, 0.04832784f, 
    -0.03126328f, 0.04268698f, 0.16522200f, -0.05491198f, -0.01601100f, -0.01593161f, -0.05244711f, -0.17006022f, 
    0.03851701f, 0.10713986f, 0.08502574f, 0.16292810f, -0.30815190f, -0.04689695f, 0.06645047f, -0.02918147f, 
    0.03356263f, -0.00907538f, -0.16182020f, 0.02058459f, -0.05208182f, -0.15898080f, 0.21004479f, -0.02203697f, 
    0.25931692f, 0.14756216f, 0.18586466f, 0.12927918f, 0.06537357f, 0.04258831f, -0.05790851f, 0.06892639f, 
    -0.01177329f, 0.19196509f, -0.04551024f, -0.16811030f, 0.02245761f, -0.06799626f, -0.02710675f, -0.04376474f, 
    -0.20006631f, 0.06753854f, -0.14181758f, 0.06102614f, 0.01473292f, -0.04145416f, 0.03209975f, -0.30879891f, 
    -0.08342183f, -0.02880242f, 0.05116785f, 0.02671595f, 0.06793009f, -0.22370742f, -0.01597736f, -0.08489771f, 
    -0.10667746f, 0.04418946f, -0.00477137f, 0.05521881f, 0.12927228f, 0.10906395f, 0.16091160f, 0.19709882f, 
    0.13165103f, 0.08725387f, -0.26703072f, 0.06479852f, -0.02660925f, -0.03215615f, 0.18644622f, 0.13269596f, 
    -0.07612265f, 0.14346080f, 0.14763713f, 0.02882499f, -0.10000439f, 0.10549808f, -0.02880973f, -0.14790268f, 
    -0.02866382f, -0.06507467f, -0.00991543f, 0.02322948f, -0.04991049f, 0.10010127f, -0.02104123f, 0.12459186f, 
    -0.01147915f, -0.07851646f, -0.06368303f, -0.06484518f, -0.12317982f, -0.09696310f, 0.02352095f, -0.06940323f, 
    0.04761532f, 0.13216256f, -0.03183466f, 0.05881283f, 0.31132799f, 0.17199594f, 0.10172936f, 0.11860473f, 
    0.11120027f, -0.03023641f, 0.19105944f, 0.04564669f, 0.10341602f, -0.06028143f, 0.18763810f, -0.12866093f, 
    -0.08714283f, -0.12067570f, -0.11389915f, -0.23736475f, -0.02973412f, -0.00932591f, 0.08540703f, -0.13903573f, 
    -0.07128278f, -0.13343737f, -0.05733297f, 0.03539381f, -0.10167028f, 0.18843770f, -0.15936697f, -0.19658040f, 
    -0.00889226f, 0.06468101f, -0.06498001f, 0.02021228f, 0.07305343f, -0.00821443f, 0.17235588f, 0.06795934f, 
    -0.03244384f, -0.21170162f, -0.08845065f, -0.26752672f, 0.08430714f, -0.11886692f, -0.12002931f, -0.09184103f, 
    -0.04976760f, -0.05013645f, 0.00970316f, 0.18768153f, -0.04031373f, 0.10842410f, 0.04378218f, 0.00534422f, 
    -0.00715530f, 0.00454775f, 0.14503996f, 0.26096818f, 0.26089162f, -0.00047118f, 0.16772585f, -0.09110956f, 
    0.05329021f, -0.22166638f, -0.24228606f, -0.20943294f, -0.03426298f, 0.04295183f, 0.13482207f, -0.09207446f, 
    0.09248903f, 0.05276291f, 0.12247460f, -0.11032238f, -0.00974698f, 0.00566312f, 0.00192844f, -0.14896148f, 
    -0.04948014f, 0.06729096f, -0.08088396f, 0.00805980f, 0.04741338f, -0.05906226f, 0.11969794f, 0.03727233f, 
    0.03350129f, 0.06332210f, 0.23626198f, 0.13441420f, -0.03400806f, 0.10669100f, 0.02499715f, -0.08896878f, 
    -0.13770902f, 0.05533183f, -0.02784535f, 0.05530545f, 0.07283840f, 0.03119813f, 0.01650389f, -0.13160011f, 
    -0.05367142f, -0.10753507f, 0.01477370f, -0.03799789f, -0.09985469f, 0.03313551f, 0.09851042f, 0.00340403f, 
    -0.11665039f, 0.08819004f, -0.06407744f, -0.08042801f, 0.09466992f, -0.08996114f, -0.00019708f, 0.01513855f, 
    0.20660700f, -0.15610829f, 0.07969102f, 0.15479264f, 0.13610615f, -0.06503005f, -0.07304066f, -0.12532723f, 
    0.05686983f, 0.04762910f, -0.05430607f, 0.12155457f, -0.01726743f, -0.03687124f, -0.00248561f, -0.01696133f, 
    0.12998454f, 0.15929312f, -0.14854667f, -0.05180796f, 0.06553842f, 0.00061089f, -0.03564426f, -0.02468210f, 
    0.02915353f, 0.03463935f, 0.04624360f, 0.08105064f, 0.01972442f, -0.08815603f, 0.08253974f, 0.18299396f, 
    -0.00279676f, 0.25122195f, -0.06262800f, 0.09560908f, -0.10853459f, 0.01125024f, -0.02849407f, -0.06786155f, 
    0.03860608f, -0.04724466f, 0.11923006f, -0.15419285f, -0.01307988f, 0.04783715f, 0.20283522f, 0.08448594f, 
    0.07994740f, -0.00055612f, 0.07323130f, -0.07411291f, -0.17216708f, 0.09590805f, -0.00047104f, -0.17502642f, 
    -0.05579073f, -0.08214545f, -0.05632019f, -0.00679835f, 0.02257270f, 0.04538145f, -0.01141878f, 0.10398947f, 
    0.03769948f, -0.04999847f, -0.06673688f, -0.02873951f, 0.00707878f, 0.03935694f, 0.18737265f, 0.09855202f, 
    -0.01935392f, 0.14071544f, -0.07237364f, 0.15585880f, 0.07687375f, -0.00011544f, -0.02031089f, 0.17779605f, 
    -0.00711235f, -0.00700758f, 0.08472773f, 0.02310045f, -0.04655531f, -0.00868194f, -0.16653997f, 0.06688236f, 
    0.24905637f, 0.06486155f, -0.01454927f, -0.02544289f, 0.06950027f, 0.12088322f, 0.04086479f, -0.10354319f, 
    0.04210589f, -0.07666100f, 0.09231478f, -0.02313553f, -0.01476536f, -0.07822400f, -0.09503959f, -0.18901666f, 
    -0.05343789f, -0.02945079f, 0.06659691f, 0.03090030f, -0.04086766f, 0.05395266f, -0.00493769f, -0.09138390f, 
    -0.07516084f, -0.07708732f, -0.06296750f, -0.11380470f, 0.03181232f, -0.03105130f, 0.04193304f, -0.01870796f, 
    -0.07147940f, 0.08428330f, 0.06846485f, 0.16766286f, 0.03452245f, 0.03082583f, 0.10284274f, 0.17649861f, 
    -0.05555153f, 0.04449597f, 0.02185909f, -0.18089502f, 0.10171129f, 0.03985260f, 0.00306543f, 0.03664444f, 
    0.10197686f, 0.11834396f, -0.14883560f, 0.43627030f, -0.07405401f, 0.07753747f, 0.11011248f, -0.05098593f, 
    -0.07363860f, -0.11335891f, -0.10367767f, 0.08905847f, 0.11254421f, -0.20867172f, 0.09049416f, 0.08906912f, 
    -0.01416946f, -0.04642099f, 0.14527282f, -0.04325628f, -0.05317726f, -0.00334364f, -0.01208446f, -0.08116692f, 
    -0.08948570f, 0.04951592f, 0.01647558f, -0.06164740f, -0.04797708f, -0.02545206f, 0.05967065f, 0.03662961f, 
    -0.16950122f, 0.03224264f, -0.01407761f, -0.08176421f, 0.05889865f, -0.37573120f, -0.22571582f, 0.05007125f, 
    0.08752267f, -0.05112333f, -0.12118602f, -0.08089156f, -0.05769866f, 0.05910890f, -0.01301046f, 0.02018098f, 
    -0.07842638f, -0.02438244f, -0.06583267f, -0.07306607f, -0.05871460f, -0.00680545f, -0.05161400f, -0.02397311f, 
    -0.26314723f, -0.22187729f, -0.14803888f, -0.09268644f, -0.08110701f, 0.10914304f, -0.10401720f, 0.07380139f, 
    0.03659351f, 0.07308433f, 0.10006347f, 0.00628928f, 0.06688815f, -0.01006758f, -0.00281820f, 0.09240963f, 
    0.16099006f, -0.12403636f, -0.03297748f, 0.01024209f, -0.10578389f, 0.11986778f, -0.01743335f, 0.11571235f, 
    -0.06326792f, -0.01083313f, -0.15345535f, -0.14027682f, 0.06891052f, -0.09794519f, -0.18597110f, 0.02216943f, 
    0.05757054f, -0.13544121f, 0.03096637f, 0.02466336f, 0.22272220f, -0.07935378f, 0.03525782f, 0.17940751f, 
    -0.11809823f, 0.03509982f, 0.02310477f, 0.16732313f, 0.03903104f, -0.08024532f, 0.14880204f, 0.07121354f, 
    0.13797832f, 0.05426296f, 0.04195853f, -0.00952149f, 0.09521149f, -0.00109461f, -0.02420553f, 0.06470204f, 
    -0.03581597f, 0.02895675f, 0.01685921f, -0.04186079f, -0.00838958f, -0.02163261f, 0.15259500f, 0.10499170f, 
    0.01320041f, 0.01888436f, 0.18976220f, -0.12060255f, 0.05333263f, 0.04920407f, -0.12898107f, -0.02101026f, 
    -0.06305829f, 0.15959784f, 0.06602988f, 0.06326123f, 0.21745151f, 0.00745664f, -0.09874523f, 0.17592941f, 
    -0.04749729f, -0.10892671f, -0.07137502f, -0.13939410f, 0.11413936f, -0.02656262f, 0.11740522f, 0.07356048f, 
    -0.16369052f, 0.00909449f, -0.04104936f, 0.21745954f, 0.09268099f, -0.11215772f, -0.03880681f, 0.06774623f, 
    -0.00219312f, -0.10835140f, -0.10969712f, 0.09637529f, -0.07687041f, 0.04837174f, 0.04111098f, 0.04715765f, 
    0.04893876f, 0.00606944f, 0.11600692f, 0.04770495f, -0.00276046f, -0.11280174f, 0.09174152f, 0.02726171f, 
    0.19537987f, -0.32516041f, 0.07957269f, -0.08440191f, 0.13401225f, 0.00006426f, 0.01479577f, -0.01905054f, 
    -0.02453098f, 0.00770635f, 0.02789724f, -0.00396365f, -0.01082204f, 0.12005623f, 0.19207993f, 0.09603068f, 
    0.10644032f, 0.06963615f, 0.14883389f, 0.04125427f, -0.06282794f, -0.02356376f, -0.04549384f, 0.04330133f, 
    0.09864580f, 0.17114437f, 0.27142033f, -0.15619665f, 0.07882594f, 0.04970305f, 0.08760827f, 0.15412545f, 
    0.06851612f, 0.00274649f, 0.13170187f, 0.06470218f, -0.28511527f, 0.44413525f, -0.06914058f, -0.19018325f, 
    0.00989963f, -0.02471648f, 0.03888971f, 0.07853661f, 0.06430003f, -0.02078365f, 0.01559451f, 0.01234344f, 
    -0.37503105f, 0.00786150f, 0.02720143f, -0.09589305f, 0.02934449f, 0.06324113f, 0.06507058f, -0.15118986f, 
    0.22201049f, 0.00386312f, 0.03236271f, -0.01136725f, 0.06370150f, 0.00422191f, -0.25888208f, -0.03505461f, 
    -0.08795641f, 0.26190662f, 0.01410398f, 0.02710431f, 0.02274668f, -0.15508024f, 0.01983949f, -0.02960441f, 
    0.31297210f, -0.33414742f, 0.29991159f, -0.05298651f, -0.08474199f, 0.00752169f, 0.28349859f, 0.18108082f, 
    0.13449810f, 0.11758669f, -0.01478363f, -0.03324664f, -0.04537091f, 0.11809547f, -0.18208653f, -0.03805021f, 
    -0.02935091f, 0.03271094f, 0.06359754f, -0.12959175f, -0.05325611f, 0.00716169f, -0.09666511f, 0.00199847f, 
    0.09698401f, -0.00395631f, -0.16980037f, -0.26259845f, -0.02020021f, 0.12337794f, -0.12883015f, -0.09629068f, 
    0.04782476f, -0.06879984f, 0.09575665f, -0.00375631f, 0.14681752f, -0.09491538f, 0.07560842f, 0.04290204f, 
    -0.03640644f, 0.17433403f, 0.01983433f, -0.02736236f, -0.00868903f, 0.02238805f, -0.04472635f, 0.15195556f, 
    0.31247312f, 0.33296275f, 0.19189711f, -0.00940205f, 0.13764575f, 0.06648610f, 0.06036610f, 0.11142679f, 
    -0.06356377f, -0.02028490f, 0.05347068f, 0.05209339f, -0.56282973f, 0.00106671f, -0.20357725f, 0.06606120f, 
    0.12349083f, -0.01533389f, 0.02474248f, -0.03816133f, -0.02876022f, -0.03448101f, 0.05127993f, 0.07014018f, 
    0.20190153f, -0.18973048f, 0.03323660f, -0.01593984f, -0.04426201f, -0.02574573f, 0.00353284f, -0.03811575f, 
    -0.04374756f, -0.00949138f, -0.09149060f, 0.00310690f, -0.09720921f, 0.33295164f, 0.06690384f, 0.01271376f, 
    -0.06684463f, 0.12111559f, 0.06413240f, 0.11963247f, 0.02948233f, -0.04644492f, 0.04854702f, 0.05025972f, 
    0.21118975f, 0.17189960f, 0.15763061f, -0.09578915f, 0.06783915f, -0.03606197f, 0.04813576f, 0.06196268f, 
    0.03960806f, -0.00383105f, -0.05022492f, 0.04384187f, 0.07984543f, 0.14308721f, 0.19884680f, -0.00405940f, 
    0.03239042f, 0.15338081f, 0.08432657f, 0.09789751f, 0.06377967f, -0.13452655f, 0.04402164f, -0.09283271f, 
    0.21377483f, -0.07164502f, 0.04494810f, -0.02013155f, -0.10614277f, 0.00328213f, -0.10222274f, -0.12830691f, 
    0.01430578f, -0.01907597f, 0.00821046f, -0.00666188f, 0.17752413f, 0.11544514f, 0.14414814f, -0.09676435f, 
    0.02265547f, 0.15777852f, -0.00069595f, 0.27947226f, 0.10091359f, -0.06678502f, 0.08929966f, -0.05417741f, 
    -0.30913246f, 0.31578982f, -0.12860976f, -0.29936174f, -0.06370878f, -0.04019287f, 0.03639541f, -0.07414883f, 
    0.07952384f, -0.04962232f, 0.02499629f, -0.01668151f, -0.04142085f, 0.15565088f, 0.21081792f, -0.00435117f, 
    0.11784766f, 0.00089244f, -0.00276828f, 0.01815035f, 0.05553676f, -0.02995764f, -0.03630668f, -0.01035480f, 
    -0.10231154f, 0.09942857f, -0.06046169f, -0.03633226f, 0.06769792f, 0.14052865f, 0.04542135f, 0.00595719f, 
    0.04701231f, -0.02207924f, -0.06690578f, 0.24058953f, -0.09610185f, 0.08895672f, -0.18215245f, -0.02044332f, 
    0.09615827f, -0.09331285f, 0.10928398f, 0.10609545f, 0.17713881f, -0.08092162f, 0.05319943f, -0.03954661f, 
    0.11488052f, -0.13830374f, -0.08525293f, 0.13669178f, -0.02579868f, 0.09602334f, 0.07523680f, -0.10219797f, 
    -0.00100033f, -0.02991438f, -0.16096002f, 0.02299045f, 0.04126704f, 0.33215657f, 0.03923347f, 0.02250470f, 
    0.14055070f, 0.02502127f, 0.11262959f, 0.03037900f, -0.05234976f, -0.02097281f, 0.04832956f, 0.05775741f, 
    0.00803020f, 0.18851858f, -0.11878278f, -0.03746348f, 0.07304744f, -0.09666011f, 0.01589499f, 0.13397881f, 
    -0.02367602f, 0.03839120f, -0.08832646f, -0.10876407f, 0.16454311f, -0.17583868f, 0.03642661f, 0.23523839f, 
    -0.10004416f, -0.07275237f, -0.06049987f, -0.04915372f, -0.05881866f, -0.00952407f, -0.04523540f, -0.02804148f, 
    -0.21474722f, 0.17614479f, 0.09768519f, 0.26050663f, 0.15295477f, 0.09460963f, 0.01299190f, -0.08218952f, 
    0.01866761f, -0.05994174f, -0.09726813f, 0.02438010f, 0.15257791f, -0.02870712f, -0.03780554f, -0.03961939f, 
    0.06394845f, 0.01902712f, 0.07189070f, -0.05589032f, 0.02058903f, -0.17246297f, -0.03262426f, -0.07656977f, 
    -0.29757160f, 0.04527604f, -0.10512348f, 0.06265163f, 0.03938317f, 0.00077899f, 0.07178581f, 0.07424635f, 
    0.02690611f, -0.16591118f, 0.03359825f, 0.00849834f, -0.04695490f, 0.08944253f, -0.00695175f, -0.42899245f, 
    0.05564588f, 0.03034417f, -0.02767012f, 0.09422588f, -0.09789594f, 0.04753337f, 0.08607960f, 0.15278365f, 
    -0.08873256f, 0.03516405f, -0.19752678f, -0.17283645f, 0.21253750f, 0.05869958f, -0.10978694f, 0.11525656f, 
    -0.04773388f, -0.01938155f, 0.13612284f, -0.03112698f, 0.31273222f, -0.17055389f, 0.12899145f, 0.15365416f, 
    -0.04482422f, -0.08558752f, -0.01597279f, -0.16862912f, 0.04313779f, 0.12988001f, 0.06777830f, 0.02293744f, 
    0.23653440f, 0.47352785f, -0.55595815f, -0.16149698f, -0.13485436f, -0.07962348f, -0.00041191f, 0.18998559f, 
    -0.03350888f, 0.03485275f, -0.04152725f, -0.08149348f, 0.24969567f, -0.09357799f, -0.03897291f, -0.13040426f, 
    0.06994940f, 0.16603610f, 0.11826800f, -0.17342287f, 0.00434903f, -0.04717379f, -0.01093545f, -0.03688381f, 
    0.12032899f, -0.06180159f, 0.27890837f, -0.08773885f, 0.05468769f, -0.00656857f, 0.14986536f, 0.04007066f, 
    -0.00617054f, -0.02453324f, -0.04170983f, -0.06545234f, 0.03353745f, -0.13861291f, -0.04310418f, -0.14918464f, 
    0.01942376f, -0.02409332f, 0.03807910f, 0.10733894f, 0.08200176f, 0.09093507f, 0.13041174f, 0.03318954f, 
    0.38839838f, 0.21277432f, -0.03728271f, 0.07029075f, 0.08613442f, -0.13780838f, 0.07191840f, 0.04617121f, 
    0.06664488f, 0.00438663f, 0.00351138f, 0.07769711f, 0.02534704f, 0.07045759f, -0.01074185f, 0.11219768f, 
    -0.12712453f, 0.02207454f, -0.00540082f, -0.06432985f, -0.00148644f, 0.06191288f, 0.07508639f, 0.09206745f, 
    -0.15630388f, -0.10032574f, -0.27244270f, 0.13161364f, 0.19800407f, -0.01362590f, 0.03468091f, 0.09749621f, 
    -0.04102173f, -0.01585166f, -0.03568929f, -0.01679263f, -0.32036924f, 0.05841775f, -0.00300579f, 0.25545475f, 
    0.13937537f, -0.02102076f, 0.09577007f, -0.11051826f, 0.16500494f, -0.11623522f, -0.13156359f, -0.00349924f, 
    -0.05903601f, -0.11864516f, -0.08636440f, 0.15045911f, -0.00806315f, -0.02057246f, -0.07311008f, -0.02060235f, 
    0.17209263f, 0.03011241f, -0.05085655f, 0.01012831f, -0.05044093f, 0.04298281f, -0.10533726f, -0.01962543f, 
    0.12716234f, 0.13397160f, -0.03342610f, 0.04797957f, 0.01789249f, 0.01382611f, 0.08947162f, -0.03998040f, 
    0.49858069f, -0.39348400f, 0.27027610f, 0.15436248f, -0.01066520f, 0.07911409f, 0.09666193f, -0.15306461f, 
    0.18686357f, -0.01801113f, -0.04045234f, 0.01411338f, 0.20191792f, -0.12015514f, 0.00069475f, 0.15771313f, 
    0.02798144f, -0.01989767f, 0.05319538f, -0.04785203f, 0.01390751f, -0.14521994f, -0.05075851f, 0.00380312f, 
    -0.03608865f, 0.24595948f, -0.28569743f, 0.11046911f, 0.10538502f, 0.01363144f, 0.03457178f, 0.02177535f, 
    0.05146771f, -0.01304514f, 0.12556244f, -0.02058973f, 0.18273737f, 0.10410457f, -0.00056742f, -0.11944830f, 
    0.17754659f, 0.11707474f, 0.14947844f, 0.03671465f, 0.05376678f, 0.05635315f, -0.02120570f, 0.03848698f, 
    0.18625435f, -0.08383769f, 0.12396310f, -0.22620034f, -0.03264073f, -0.01438728f, -0.06476492f, -0.00168870f, 
    -0.01124088f, 0.01006516f, 0.15730628f, 0.03362173f, -0.17445329f, -0.01945336f, -0.10598347f, 0.17491250f, 
    0.12170539f, -0.09376930f, -0.03334485f, 0.07842335f, -0.00768233f, -0.11634240f, 0.02727033f, -0.01997910f, 
    -0.11967067f, -0.04515456f, -0.04300525f, 0.04157018f, 0.13705513f, 0.18461598f, -0.11153591f, 0.01315603f, 
    -0.04061570f, -0.08365062f, 0.01545151f, 0.08324955f, 0.03693584f, -0.02734674f, 0.05283516f, -0.03926734f, 
    0.03041493f, -0.04138207f, -0.01511262f, 0.00253704f, -0.00763965f, -0.01046025f, -0.02991482f, 0.06880984f, 
    -0.13354456f, 0.05168604f, -0.40610343f, -0.19286290f, 0.03387723f, 0.08582297f, 0.09879840f, -0.03723962f, 
    0.03456421f, -0.01053239f, -0.03549189f, 0.16285841f, 0.15516533f, -0.22974198f, 0.08090468f, -0.13707715f, 
    -0.05485388f, -0.02832159f, 0.02337536f, 0.03750244f, -0.02595781f, 0.00772555f, 0.12784137f, 0.07447327f, 
    -0.02023476f, -0.02167832f, 0.01800475f, 0.10663930f, 0.07847938f, 0.01365478f, -0.10614515f, -0.03636955f, 
    0.09348328f, -0.12299193f, 0.01150044f, 0.12322118f, 0.11825916f, 0.22749744f, 0.16824588f, 0.14227892f, 
    -0.04407847f, 0.18532969f, -0.00984673f, 0.09130422f, -0.10942836f, -0.07219459f, -0.00481858f, 0.07910822f, 
    0.07167270f, -0.11221243f, 0.03424958f, 0.07977277f, -0.00963307f, -0.03132375f, -0.05589813f, -0.11773171f, 
    -0.01451313f, -0.03002484f, -0.05836876f, -0.05273971f, 0.24941592f, -0.15029062f, -0.10626388f, -0.32007942f, 
    0.01751920f, -0.00869270f, 0.02453360f, -0.00553974f, 0.01879449f, 0.04690496f, 0.03048905f, 0.03020689f, 
    -0.17931451f, 0.02923163f, 0.18267341f, 0.16552559f, 0.06541847f, 0.04941534f, 0.03243776f, 0.06292679f, 
    0.08908530f, -0.09197515f, -0.06768382f, 0.01889177f, 0.41225368f, -0.27606550f, 0.20758224f, -0.42473993f, 
    0.04018866f, 0.07812423f, 0.09499949f, 0.12310281f, 0.07045146f, -0.07907866f, 0.06944341f, -0.05026009f, 
    0.08362097f, -0.23574452f, -0.08942010f, -0.24585579f, -0.00807332f, 0.09966639f, 0.02087075f, 0.01075685f, 
    0.09165082f, 0.11980057f, 0.02361262f, 0.00993021f, 0.36903691f, -0.28556213f, 0.10277779f, -0.01673507f, 
    0.00528759f, -0.11482172f, -0.07133439f, -0.05428390f, 0.00338886f, 0.06535183f, 0.03869222f, -0.03943128f, 
    -0.02412664f, -0.02352645f, 0.00397979f, -0.02113554f, 0.02682407f, -0.02550162f, -0.04134539f, 0.01085094f, 
    0.02567626f, -0.02319940f, 0.02907675f, 0.01856241f, -0.03510893f, 0.02235810f, -0.03330583f, -0.03873539f, 
    -0.02152280f, -0.03025991f, 0.00431320f, -0.04046727f, 0.01485769f, -0.01381002f, 0.00090744f, 0.01089257f, 
    -0.01052911f, -0.01911437f, 0.00697102f, -0.03436473f, -0.03838657f, 0.02673669f, 0.02051882f, -0.02635174f, 
    -0.00932879f, -0.02595134f, 0.00619100f, 0.00175626f, 0.01764015f, -0.00469561f, 0.00792424f, -0.00804495f, 
    -0.00079670f, 0.02128612f, -0.01404253f, -0.01384439f, -0.03626614f, 0.01191946f, -0.00515298f, -0.02968056f, 
    -0.01817567f, -0.02321113f, -0.03632092f, -0.03276876f, -0.03608202f, 0.02233702f, 0.02745841f, -0.00545938f, 
    -0.03984451f, -0.04044450f, 0.00564365f, -0.01493187f, -0.02523023f, -0.01129796f, -0.00740732f, 0.01357276f, 
    0.02332300f, 0.02984893f, 0.01032731f, -0.03243734f, 0.00389577f, 0.01340191f, -0.00761482f, -0.03689790f, 
    -0.03697732f, -0.03257059f, -0.03567947f, 0.00966640f, -0.02845665f, -0.03128468f, -0.02345294f, -0.04095606f, 
    -0.00216776f, -0.00582521f, 0.02681466f, 0.01514998f, -0.02110814f, -0.00314823f, 0.01689133f, 0.02190284f, 
    0.01836503f, -0.02215612f, 0.00069337f, -0.03430379f, 0.01746407f, 0.02100699f, -0.01256962f, 0.01555243f, 
    0.02995035f, 0.01911290f, -0.00508057f, -0.02966127f, -0.02931128f, -0.00471241f, 0.00821427f, -0.01640145f, 
    0.00230912f, -0.02536587f, 0.00621847f, 0.00558090f, 0.00454515f, -0.03956792f, 0.02776751f, -0.02348862f, 
    0.00572302f, -0.00309276f, -0.00628100f, 0.00627859f, -0.02019206f, -0.00576040f, 0.00238470f, 0.02605858f, 
    -0.04130626f, -0.03327050f, 0.00576309f, -0.04188580f, -0.02330351f, -0.03583686f, -0.01350919f, 0.01566132f, 
    0.02673686f, 0.02463044f, -0.01355371f, 0.01616503f, -0.03744047f, -0.02037682f, 0.01127413f, -0.03587914f, 
    -0.01600817f, 0.02443521f, 0.01802525f, -0.03284918f, 0.02273386f, 0.01494825f, -0.02144845f, 0.01713160f, 
    0.00357220f, 0.02823775f, 0.00900824f, 0.02184251f, -0.01336523f, 0.01059146f, 0.01346144f, -0.02259862f, 
    -0.02815287f, -0.02997938f, 0.01341761f, 0.01073658f, -0.00921278f, 0.01159074f, 0.00308194f, 0.02138134f, 
    -0.04007917f, -0.02155460f, -0.00621590f, 0.01053187f, 0.00287295f, 0.02997772f, 0.00230338f, 0.01306869f, 
    0.01277152f, -0.03426990f, -0.01882445f, -0.03648874f, 0.01180187f, 0.01236670f, 0.02077140f, -0.00945348f, 
    -0.03208137f, 0.02338928f, 0.00414732f, -0.03500102f, -0.02601378f, -0.00182949f, 0.00812752f, -0.03275419f, 
    -0.03975103f, 0.01148648f, -0.00913153f, -0.03497467f, -0.03996720f, -0.03361454f, 0.00782864f, -0.02546994f, 
    0.01117943f, 0.00353314f, -0.02707097f, -0.00826769f, 0.00035471f, -0.02242036f, 0.01370658f, 0.02485682f, 
    0.00228071f, -0.02537798f, -0.00338864f, -0.02497414f, 0.01261073f, -0.04004487f, -0.03950508f, -0.04003112f, 
    0.00606307f, -0.00023624f, 0.01919946f, -0.03265675f, -0.02495988f, -0.01555649f, -0.00185833f, 0.02929210f, 
    -0.00642857f, 0.02855516f, -0.00142410f, -0.00592566f, 0.01943799f, 0.00523624f, 0.00054690f, -0.03895016f, 
    -0.01827328f, 0.01801194f, -0.02819712f, 0.02764537f, -0.00102334f, 0.02924497f, 0.01305952f, -0.00164439f, 
    0.02183502f, -0.01876091f, 0.02459697f, -0.03325501f, 0.00606564f, -0.00085712f, -0.01480699f, -0.00421867f, 
    -0.02750578f, -0.02867603f, -0.00104695f, -0.03999652f, -0.02530501f, -0.02291360f, -0.00898775f, -0.03323709f, 
    0.00711696f, 0.00076239f, -0.01075382f, -0.00721790f, 0.01607366f, 0.02975332f, -0.00330739f, -0.03605811f, 
    0.02332796f, -0.01438166f, -0.00816619f, -0.02612091f, -0.00190151f, -0.02052716f, -0.03898256f, -0.02811716f, 
    0.02624720f, -0.02649291f, -0.03961571f, -0.01927983f, 0.02284302f, 0.00714356f, -0.03144015f, 0.00710858f, 
    -0.02407956f, -0.02411477f, 0.01118702f, 0.01571577f, 0.02294259f, 0.00967790f, 0.02004958f, 0.01328107f, 
    -0.01660544f, -0.01414596f, 0.01145209f, -0.01424772f, 0.01386320f, 0.02393607f, 0.01297004f, 0.02270018f, 
    -0.02111510f, 0.01616661f, -0.02810605f, 0.02045297f, -0.00302948f, -0.02572738f, 0.01107099f, -0.00048739f, 
    -0.00707774f, 0.01146344f, -0.02337660f, -0.03499954f, -0.01754359f, 0.02526252f, -0.00265959f, 0.00840637f, 
    -0.02472552f, 0.00337949f, -0.00743552f, 0.00960827f, -0.01188552f, 0.01976608f, -0.01299157f, -0.01383207f, 
    0.00782794f, -0.01800447f, 0.01234827f, 0.01604379f, 0.00473964f, 0.00067473f, -0.01003934f, -0.03587422f, 
    -0.00387483f, -0.02465455f, -0.02252782f, 0.02353260f, -0.03463949f, 0.02942027f, 0.01698608f, 0.02093071f, 
    -0.01804350f, -0.00653909f, -0.01890536f, -0.02046634f, -0.02106879f, -0.01174768f, -0.03777277f, -0.01422295f, 
    -0.01191441f, -0.03879828f, 0.01440250f, 0.02615803f, -0.01926121f, 0.00459546f, -0.02933599f, -0.02081694f, 
    -0.02808168f, -0.04111480f, 0.01038289f, -0.02981636f, -0.03538548f, -0.03259939f, 0.02612200f, 0.01079726f, 
    -0.02869729f, -0.02623643f, -0.02912625f, -0.00271025f, -0.00518617f, -0.02920509f, 0.01981099f, -0.00168079f, 
    0.02090905f, -0.02891487f, -0.04189087f, -0.01423945f, 0.02150743f, 0.01466791f, -0.03389728f, -0.02899260f, 
    0.01480244f, 0.00155578f, -0.02783592f, -0.02244021f, 0.02228570f, 0.02809698f, 0.02340746f, -0.03330928f, 
    -0.01615848f, -0.02948869f, -0.02294441f, -0.00143485f, -0.02065130f, 0.00450748f, 0.01628944f, 0.02798306f, 
    -0.00339611f, -0.01790447f, 0.02958554f, -0.03815208f, 0.02351805f, 0.00577132f, 0.02953259f, 0.02807449f, 
    -0.02194782f, -0.03055428f, -0.03690319f, -0.00109724f, -0.03942678f, 0.02899067f, 0.01001597f, -0.03020309f, 
    -0.00020992f, -0.00558218f, -0.00116142f, 0.01026967f, -0.02632088f, -0.01595192f, -0.00193319f, -0.01005481f, 
    0.00740346f, 0.00516499f, 0.00885883f, -0.00614910f, -0.04168122f, -0.02882698f, -0.03101146f, 0.02291007f, 
    -0.03731325f, -0.01221407f, 0.01395203f, 0.02728592f, 0.01854548f, -0.02130415f, 0.01703895f, -0.01237082f, 
    0.01332807f, -0.03872494f, -0.01454404f, 0.02954293f, -0.00882383f, -0.03108606f, -0.01523437f, 0.02648149f, 
    0.01159518f, -0.02674451f, -0.03312447f, 0.01328451f, -0.02222468f, -0.00287910f, 0.00282961f, 0.02591552f, 
    -0.02936996f, 0.01484876f, 0.01374949f, -0.00220531f, -0.04131249f, -0.02849955f, 0.02371825f, -0.02839868f, 
    0.01448999f, -0.02468440f, -0.00064364f, -0.00651644f, -0.01124909f, -0.00962067f, -0.02251050f, -0.02896105f, 
    0.02786921f, 0.02220160f, 0.00541213f, -0.04000489f, -0.03838404f, -0.03266811f, -0.01840449f, -0.03377363f, 
    -0.02885806f, 0.02835890f, 0.02930898f, -0.01516058f, 0.02518215f, -0.03007671f, 0.00293986f, -0.00153703f, 
    0.01049537f, 0.02524690f, 0.02772640f, -0.02496275f, 0.01508856f, -0.02307403f, 0.02966380f, -0.01006372f, 
    -0.00863380f, 0.00922527f, -0.03040356f, 0.00013124f, -0.01666369f, 0.01030477f, -0.02341622f, 0.01246923f, 
    -0.01008642f, 0.02237398f, -0.02727637f, 0.02676335f, -0.03693836f, -0.02605894f, -0.03390413f, -0.00515001f, 
    0.00030996f, 0.01822084f, 0.02246854f, 0.02223380f, -0.03722196f, -0.03397050f, -0.00124424f, -0.03605180f, 
    0.00179210f, -0.00889285f, -0.03528820f, -0.02522285f, -0.00034736f, -0.02478356f, 0.02924902f, -0.01984719f, 
    -0.01004063f, -0.00416091f, -0.01768802f, -0.03413813f, 0.01976399f, -0.00487299f, 0.01883571f, -0.01830171f, 
    0.02289523f, 0.02512861f, 0.01651852f, -0.00486309f, 0.00563960f, -0.02972640f, 0.02288605f, -0.02571306f, 
    -0.01996096f, 0.00972558f, -0.02600035f, -0.03515032f, -0.04063237f, -0.00687584f, -0.03471797f, -0.01092094f, 
    0.01192832f, -0.01254849f, -0.03493112f, 0.00624160f, 0.02153860f, -0.03805667f, 0.01785006f, 0.01326970f, 
    0.00680385f, -0.01596547f, -0.04007873f, -0.02120430f, 0.00412713f, -0.01857116f, -0.03441944f, 0.01396288f, 
    -0.02926143f, -0.00215892f, 0.00195438f, -0.03905059f, 0.02708338f, -0.01307217f, -0.00218036f, -0.01248469f, 
    0.00318544f, 0.02159142f, -0.02227769f, 0.01291989f, 0.02818613f, -0.00243986f, -0.03810466f, 0.00416793f, 
    0.00286785f, 0.00345559f, 0.02994557f, 0.01026822f, -0.03568935f, -0.00622955f, 0.00606045f, -0.01589042f, 
    0.00089556f, 0.02740899f, -0.02712541f, -0.01559293f, -0.02911417f, -0.00785105f, -0.02757844f, -0.02061854f, 
    -0.04133003f, 0.01941092f, -0.02668400f, 0.00129720f, -0.01196218f, -0.03865882f, 0.01067339f, -0.00426143f, 
    -0.02354555f, -0.03061147f, -0.01735968f, -0.01573512f, -0.01089741f, -0.00850911f, -0.01385150f, -0.00766071f, 
    0.02009536f, -0.03098432f, -0.00539660f, -0.02719374f, 0.02635610f, -0.02804709f, -0.01148674f, -0.01712524f, 
    -0.01975248f, -0.02810818f, -0.01818771f, 0.02561223f, -0.02063169f, 0.01582913f, 0.00834484f, -0.03248848f, 
    0.02216436f, -0.02165956f, 0.01285002f, -0.02464408f, -0.03810665f, 0.01247344f, -0.01521235f, 0.02667232f, 
    0.00924601f, 0.01960109f, -0.02381822f, 0.02014479f, -0.00684029f, 0.00511583f, 0.02680123f, 0.00014828f, 
    0.01529391f, -0.00467000f, 0.01587766f, -0.03816515f, 0.01385771f, -0.02454598f, -0.01428139f, -0.00258622f, 
    -0.04198093f, -0.03643309f, 0.00465890f, -0.01221218f, -0.02135065f, -0.00223914f, -0.01116602f, 0.00507090f, 
    -0.02695017f, 0.01000820f, 0.01860459f, 0.01758725f, -0.00111246f, -0.02818021f, 0.01141298f, 0.02509310f, 
    0.00073175f, -0.00209153f, 0.01099857f, 0.02655624f, -0.03613415f, 0.02134515f, -0.03644250f, -0.01901921f, 
    0.02373226f, 0.02040241f, 0.02608557f, -0.02044614f, 0.01511081f, -0.01748859f, 0.00495151f, -0.00707513f, 
    -0.01336335f, -0.02586361f, 0.02207928f, 0.00811462f, -0.02040613f, -0.02512812f, -0.03909914f, -0.02849095f, 
    -0.01769987f, -0.00324951f, -0.01516533f, 0.00603218f, 0.00419752f, -0.02939384f, 0.00265717f, -0.02770557f, 
    -0.01890718f, 0.02799706f, 0.01420201f, -0.02500098f, 0.02589561f, -0.02069112f, 0.01677781f, 0.00847318f, 
    -0.00837872f, -0.00103905f, -0.02381982f, -0.02247740f, 0.02169085f, -0.04096655f, -0.00636628f, 0.02579513f, 
    -0.02203967f, -0.03957995f, 0.01858346f, -0.01766110f, -0.02682131f, -0.01884601f, 0.01980381f, -0.03801850f, 
    0.01245073f, -0.02365931f, -0.02493498f, -0.04049949f, 0.02863307f, 0.02342954f, -0.04202703f, -0.03594430f, 
    -0.03730613f, -0.00830062f, -0.03997989f, -0.01641314f, -0.01341645f, -0.02602379f, 0.01941819f, -0.01552698f, 
    0.02969635f, -0.03024987f, 0.01007881f, 0.01593397f, 0.02495976f, 0.01001163f, -0.00125677f, 0.01888866f, 
    0.01709037f, -0.02230255f, 0.00250390f, -0.02387680f, -0.03610604f, 0.00131719f, -0.03360495f, 0.02132305f, 
    -0.02772732f, 0.02471609f, -0.02122229f, 0.01127689f, -0.03666733f, -0.02705442f, 0.02536729f, -0.01363832f, 
    0.02190620f, 0.00982932f, -0.03905999f, 0.01895802f, -0.03873524f, 0.02171962f, -0.03533861f, 0.01425314f, 
    -0.04132446f, -0.04029812f, -0.00871265f, -0.02957468f, -0.03338195f, 0.02541990f, 0.02055858f, 0.00256698f, 
    -0.01371321f, 0.10778280f, 0.04539943f, -0.10022416f, 0.03643798f, 0.02393396f, 0.01405129f, -0.01594815f, 
    0.07749341f, 0.04205817f, 0.12649630f, 0.12781364f, 0.09741877f, 0.24099790f, 0.17798479f, 0.04892623f, 
    -0.01179273f, -0.10491613f, -0.10989199f, 0.09570352f, -0.12708519f, 0.03395682f, 0.03034676f, 0.11245648f, 
    -0.17980406f, -0.01025459f, -0.18395330f, 0.07545917f, -0.06514918f, -0.02378958f, 0.03881779f, -0.01040426f, 
    0.03290851f, 0.10988240f, -0.07136595f, 0.04166164f, 0.04730300f, 0.21257834f, 0.01192504f, -0.03977426f, 
    0.00707389f, 0.09975212f, 0.12955479f, 0.11542400f, -0.02396366f, 0.05552386f, 0.03474379f, 0.02274916f, 
    0.28367451f, -0.03670597f, 0.10328688f, -0.00689493f, 0.13256660f, 0.08467458f, -0.16597784f, 0.06270786f, 
    0.11699253f, 0.07816806f, 0.06095876f, 0.01731221f, 0.13180692f, 0.22397622f, 0.02382541f, 0.02242125f, 
    0.00640573f, 0.15500413f, 0.18928491f, 0.01273387f, 0.03034486f, -0.01165005f, 0.01391183f, -0.01023832f, 
    0.19267796f, 0.20106898f, -0.05530361f, -0.22118509f, 0.08990543f, 0.13852958f, 0.09696208f, 0.19623245f, 
    0.02469296f, -0.00443622f, 0.08477718f, -0.02944196f, 0.20122692f, 0.23847030f, 0.22729132f, 0.04374161f, 
    0.11741004f, 0.07023174f, 0.02137958f, 0.17667706f, -0.07665285f, -0.08276219f, -0.06614412f, 0.03450061f, 
    -0.27543324f, -0.02050802f, -0.00336660f, -0.01026045f, -0.11751913f, -0.14426781f, 0.02973774f, -0.05692543f, 
    0.04191405f, -0.04320721f, -0.07611515f, 0.13810787f, 0.10445030f, -0.16563313f, -0.13221470f, -0.05914140f, 
    0.01520532f, 0.03792161f, 0.02873508f, 0.06635902f, 0.00347416f, -0.00456116f, 0.06192734f, -0.05889743f, 
    0.02391179f, 0.32644901f, -0.03382531f, -0.12623394f, 0.08931554f, 0.05376381f, 0.10940337f, -0.01242143f, 
    0.00431237f, 0.03945763f, -0.01018368f, 0.06669538f, -0.15024386f, -0.08710285f, -0.13203008f, -0.00487740f, 
    0.09655762f, 0.00044373f, 0.17714922f, -0.08575550f, -0.09163315f, -0.02088098f, -0.00178482f, -0.05030551f, 
    0.14450055f, -0.10436870f, 0.04261438f, 0.02079688f, -0.02863989f, -0.06682314f, -0.04816134f, 0.03424837f, 
    0.14397997f, 0.05453126f, 0.08087894f, 0.02745903f, -0.15952744f, 0.16633531f, 0.20018472f, -0.13034084f, 
    -0.08454983f, 0.06873442f, -0.00442921f, -0.07423189f, -0.03288276f, -0.12168059f, -0.01624010f, -0.00908007f, 
    0.13087049f, 0.14419779f, 0.05469728f, 0.03759195f, 0.28950503f, 0.03725966f, -0.00315593f, 0.06074132f, 
    -0.05886282f, -0.00211961f, 0.02114275f, 0.12967183f, -0.34608331f, 0.15353668f, -0.00715617f, 0.11402094f, 
    -0.09851269f, -0.15918696f, -0.10430404f, 0.13573587f, 0.14661436f, 0.11551436f, -0.07923289f, -0.00137642f, 
    -0.23490544f, -0.08967053f, 0.06120265f, 0.17667437f, -0.14839661f, 0.00765344f, 0.01077612f, -0.05508931f, 
    -0.04770531f, -0.02591942f, -0.04704431f, 0.15681900f, 0.20359513f, 0.24077551f, 0.05481195f, 0.06651708f, 
    0.03193994f, 0.20197023f, 0.07648216f, 0.16978814f, -0.08153276f, 0.01212414f, 0.00006328f, 0.16121164f, 
    0.23027201f, 0.21734954f, -0.04863030f, -0.07662103f, 0.26020658f, 0.07261134f, 0.02523249f, 0.09132588f, 
    0.00773509f, -0.00605041f, 0.03688264f, -0.01496575f, 0.25333461f, 0.20042448f, -0.03312753f, 0.02279118f, 
    0.16616264f, 0.12157530f, 0.06308893f, 0.15995537f, -0.03255626f, -0.02302026f, -0.04286954f, 0.01039191f, 
    -0.04437315f, -0.10367841f, 0.10616273f, -0.01488530f, 0.02027218f, -0.04654419f, -0.05031611f, -0.13517375f, 
    0.10008443f, -0.06671725f, -0.00007875f, 0.04666077f, 0.22092119f, 0.16765636f, 0.06315246f, 0.08567802f, 
    0.09770140f, 0.10276157f, 0.12440096f, 0.21195613f, 0.01695314f, -0.07424993f, -0.01024527f, 0.11760250f, 
    0.42452049f, 0.17732994f, -0.00280000f, 0.20576563f, 0.07480486f, 0.07787997f, -0.01180698f, -0.10475691f, 
    0.09585968f, 0.00699280f, 0.05971405f, 0.06973060f, 0.16079760f, 0.21916331f, 0.14397670f, 0.08366419f, 
    0.11564633f, 0.10791133f, -0.03020839f, 0.03309914f, 0.04653930f, -0.06424174f, -0.00859594f, -0.08004424f, 
    -0.02720036f, -0.02035555f, -0.17226985f, 0.02623454f, 0.03421935f, 0.12621568f, 0.09392852f, -0.12747173f, 
    0.00636441f, -0.09488805f, 0.07547302f, 0.12401566f, -0.26001722f, -0.02452033f, -0.23260216f, 0.08378563f, 
    0.01377042f, -0.06313287f, 0.10950860f, -0.07606417f, 0.13508075f, 0.04930978f, -0.02969068f, -0.13173941f, 
    -0.11690407f, 0.15867957f, 0.18787019f, 0.15528667f, -0.06394301f, 0.05377765f, -0.02109540f, -0.14680964f, 
    0.08902939f, -0.08992814f, 0.02112444f, 0.01445083f, 0.17610127f, 0.12557213f, 0.01305322f, 0.07204652f, 
    0.17789449f, 0.16736111f, -0.06474886f, 0.00102065f, -0.06678341f, -0.00878089f, 0.00711018f, 0.04213317f, 
    -0.19840761f, -0.13066155f, 0.03549200f, 0.13699648f, 0.05843161f, 0.05537708f, 0.10820601f, 0.04162902f, 
    -0.07646172f, -0.01117701f, 0.01875837f, -0.16214660f, 0.06217978f, 0.10385618f, 0.30683666f, 0.11809167f, 
    -0.12601218f, -0.10066768f, -0.14007649f, -0.12664814f, -0.03553559f, 0.06841928f, -0.04051129f, 0.03009050f, 
    -0.03071859f, 0.23921721f, 0.13993841f, 0.06779243f, 0.02183722f, 0.18191069f, 0.10995030f, 0.06788880f, 
    -0.02164328f, -0.01533001f, -0.03271793f, 0.00799489f, -0.31395617f, -0.08642332f, -0.00913939f, -0.00859421f, 
    -0.06490803f, 0.00158094f, 0.00273413f, -0.09706471f, 0.00505955f, -0.07851668f, 0.03853920f, 0.11119974f, 
    -0.29211929f, -0.21137980f, -0.15591969f, -0.03621296f, 0.07421155f, 0.04961227f, 0.01554885f, -0.07623802f, 
    -0.02393025f, -0.02349056f, -0.08120038f, 0.04949660f, 0.13109072f, -0.06102724f, -0.17382948f, -0.05368076f, 
    0.01997974f, 0.04223767f, 0.07655166f, -0.02938254f, 0.07850122f, 0.07266829f, -0.03671537f, 0.01119434f, 
    -0.47939155f, -0.13755141f, 0.01067710f, 0.01104906f, 0.06277198f, 0.05486815f, -0.03704804f, 0.02697322f, 
    -0.07076694f, 0.10892899f, 0.10923396f, -0.07737074f, 0.18117946f, 0.18821262f, 0.04533892f, 0.02946415f, 
    -0.08443402f, -0.00866510f, 0.02017304f, -0.04449306f, -0.03001494f, 0.14065446f, 0.04919606f, 0.02568363f, 
    0.10598891f, -0.24860343f, -0.30108258f, 0.15072238f, 0.04039406f, 0.03469735f, 0.11602010f, 0.06890959f, 
    -0.05001729f, -0.04349056f, -0.05527224f, -0.09977926f, 0.41351750f, 0.10161088f, -0.08925635f, 0.17598367f, 
    0.00544218f, 0.06699739f, -0.00233861f, -0.08745235f, 0.10212659f, 0.06440637f, 0.03244115f, 0.07512628f, 
    0.26551211f, 0.39100727f, -0.03266638f, 0.03929725f, 0.15267153f, 0.01677682f, 0.04880560f, 0.11979566f, 
    0.06459514f, 0.02815834f, 0.03330577f, 0.01352410f, -0.13726625f, -0.13965665f, -0.09891108f, -0.03653548f, 
    -0.03820315f, -0.02813709f, -0.04489326f, -0.08583616f, -0.03586459f, 0.11452729f, 0.09668956f, 0.06255487f, 
    0.10737314f, 0.30213404f, -0.01795076f, -0.02259531f, 0.14499378f, 0.05469379f, 0.11286020f, 0.19356027f, 
    -0.08438410f, -0.02385372f, 0.04014730f, -0.01899571f, 0.04751365f, -0.09852313f, -0.07878087f, 0.10017610f, 
    -0.08285074f, -0.14015104f, -0.07281860f, -0.07962450f, 0.10252012f, -0.08664580f, 0.05311430f, 0.10102144f, 
    -0.12476797f, -0.20741558f, -0.12976398f, 0.11374010f, 0.08269434f, -0.03610636f, -0.07112687f, 0.05519739f, 
    0.13804677f, -0.05040389f, 0.02479522f, -0.02336016f, -0.36095744f, 0.33742061f, -0.02480147f, -0.02453172f, 
    -0.07827340f, -0.06023446f, -0.07127824f, -0.05232109f, 0.12098825f, -0.02339372f, 0.05143461f, -0.04843679f, 
    -0.17068355f, -0.00429076f, -0.06133311f, 0.05921463f, -0.17194054f, -0.01536558f, -0.03963241f, -0.12365983f, 
    0.04935748f, 0.05663138f, -0.11389340f, 0.05911371f, 0.18121989f, 0.02796191f, 0.13251969f, 0.12313844f, 
    0.16717812f, 0.12666073f, 0.00406944f, 0.18002211f, -0.08201738f, 0.08764538f, -0.02724991f, 0.13100262f, 
    0.18158656f, 0.15278369f, 0.09724702f, 0.10610712f, 0.17798267f, 0.07942529f, 0.01501634f, -0.02979689f, 
    0.02711963f, 0.02222598f, 0.06310110f, 0.00462908f, -0.32837805f, -0.13509876f, -0.06741735f, 0.13822721f, 
    -0.14764494f, -0.06531385f, 0.01654378f, -0.06555220f, -0.04128460f, 0.00831674f, 0.01730518f, 0.08617894f, 
    0.03907093f, -0.16782957f, -0.17409600f, 0.39552248f, 0.00100583f, -0.06730480f, 0.07270747f, -0.03795519f, 
    0.04685271f, 0.09030197f, 0.01245534f, 0.20202117f, 0.23759016f, 0.03578288f, -0.00831322f, -0.01658213f, 
    0.12781852f, 0.00236933f, 0.09751975f, 0.09745073f, 0.02335093f, 0.00687060f, 0.03541315f, 0.12423335f, 
    0.14649603f, 0.03082710f, -0.04662312f, 0.04285763f, 0.10014086f, 0.03469241f, -0.00049217f, 0.10823779f, 
    0.01796530f, 0.14912201f, 0.13834117f, 0.15132360f, -0.32744437f, -0.19881655f, 0.08909703f, 0.10630748f, 
    0.04822947f, 0.00690058f, -0.02335105f, -0.05320250f, -0.04454945f, -0.08288185f, 0.02332763f, -0.02132112f, 
    -0.08747294f, -0.12192331f, 0.18054444f, 0.02281947f, 0.06150160f, 0.22061388f, -0.00705152f, -0.12861362f, 
    0.01128673f, -0.12794651f, 0.17206019f, 0.18508886f, 0.28852409f, 0.13294417f, 0.08429807f, 0.07060795f, 
    0.03586612f, -0.06423984f, -0.02668248f, 0.00926359f, 0.12749392f, 0.05850671f, -0.10572050f, 0.02937165f, 
    -0.05938072f, -0.02992260f, 0.12243447f, 0.01285033f, -0.00291974f, -0.00380873f, 0.05706671f, 0.06322267f, 
    0.04561402f, -0.03404095f, 0.06299515f, 0.23300476f, -0.04601897f, -0.05740901f, 0.15571301f, -0.16077451f, 
    -0.08862045f, -0.03666724f, -0.21168244f, -0.03680965f, 0.08459108f, -0.04302623f, 0.09610258f, 0.10844352f, 
    -0.19219139f, -0.09701013f, -0.13433030f, 0.12111554f, -0.06079212f, -0.05988653f, -0.11802197f, -0.11019602f, 
    0.02280329f, 0.01532083f, -0.02940222f, 0.17318363f, 0.24916857f, 0.19664013f, 0.13083901f, 0.03525456f, 
    0.06348694f, 0.13454868f, 0.09309084f, 0.20626222f, 0.02454433f, -0.04061231f, -0.00500029f, 0.08205855f, 
    -0.15212329f, -0.02279871f, 0.02463566f, 0.07980800f, -0.04538127f, -0.07166167f, -0.05793723f, -0.09188972f, 
    -0.05742366f, 0.02995041f, 0.04301687f, -0.01422033f, 0.14042255f, 0.16431068f, 0.00110088f, 0.00295138f, 
    0.06884274f, 0.05910614f, 0.01513509f, 0.01682606f, -0.01949081f, 0.02620348f, 0.10493553f, 0.09281302f, 
    0.13414212f, 0.29259050f, 0.06395681f, 0.20665272f, 0.08807348f, 0.15409811f, 0.03946280f, 0.09066894f, 
    -0.00968007f, -0.02390528f, -0.02915078f, -0.00262610f, 0.33899102f, 0.24376501f, -0.30052567f, -0.10049181f, 
    0.07590539f, 0.08353295f, 0.04410829f, 0.06278393f, 0.10056646f, -0.03492897f, 0.03199780f, -0.01374242f, 
    0.03792029f, 0.00772092f, -0.08938934f, 0.01820098f, -0.00224634f, 0.10428853f, 0.01299084f, -0.10591997f, 
    0.03640970f, -0.01059221f, 0.04541429f, -0.07875468f, 0.24749242f, -0.12988064f, 0.04398541f, 0.03779381f, 
    0.06573511f, -0.02615623f, -0.10826441f, -0.03582031f, -0.00383301f, 0.07860830f, 0.00915648f, -0.00832663f, 
    0.04738019f, -0.10253866f, -0.09355202f, 0.00658572f, 0.01500384f, -0.04576818f, 0.09837162f, 0.14845227f, 
    -0.08495431f, 0.08305052f, 0.01508852f, 0.07317372f, 0.03407838f, -0.58077878f, -0.18037495f, -0.05199350f, 
    0.02766836f, 0.04738270f, -0.10081622f, 0.04162099f, 0.21753234f, 0.11906848f, 0.14696775f, -0.12344661f, 
    -0.16801231f, 0.20380253f, 0.02468574f, 0.14415410f, 0.11043692f, -0.07970957f, -0.08573112f, 0.13015053f, 
    -0.03990094f, 0.11532796f, 0.17312326f, 0.28811055f, -0.00568848f, -0.03948843f, -0.08461506f, 0.11570056f, 
    0.10202042f, 0.17652996f, 0.07130477f, 0.03777904f, -0.03325508f, -0.14603800f, 0.08468940f, 0.19521159f, 
    0.02829523f, -0.19365953f, -0.18132544f, -0.02882820f, -0.07425544f, -0.09587488f, 0.08748675f, 0.09856597f, 
    -0.16910814f, -0.01904498f, -0.11351494f, -0.08268187f, 0.06374459f, -0.13360523f, -0.05213401f, -0.07409444f, 
    0.13159935f, 0.05969543f, 0.10495270f, -0.09103423f, 0.07152570f, 0.09628958f, -0.07295723f, 0.12791038f, 
    0.20810425f, 0.19945025f, 0.29829770f, -0.06848452f, 0.22853868f, 0.10966243f, 0.03769132f, -0.00993653f, 
    0.04335126f, -0.00375445f, 0.09211780f, 0.04269185f, -0.32153699f, 0.27863342f, -0.19364050f, -0.22756588f, 
    -0.04077986f, 0.05141203f, 0.11561577f, 0.15420894f, -0.05456303f, -0.09574144f, 0.01958921f, 0.03672474f, 
    -0.03202948f, 0.22744386f, -0.17523704f, 0.21001825f, 0.01312420f, 0.07662636f, 0.10460187f, -0.12456358f, 
    0.00832737f, 0.01019186f, 0.01360787f, -0.01417076f, -0.03764025f, 0.11650252f, -0.23014249f, 0.09120782f, 
    -0.13954274f, 0.28371692f, -0.14057311f, 0.08226813f, 0.08445424f, 0.14585605f, -0.10885636f, 0.17273881f, 
    0.46950778f, 0.01904062f, 0.01724595f, -0.31280950f, -0.15629017f, -0.08426011f, 0.18717474f, 0.00352043f, 
    0.14150925f, 0.24581301f, 0.10810990f, -0.00649093f, -0.08844995f, 0.07497737f, -0.04871104f, 0.02986677f, 
    -0.11337452f, 0.11183655f, 0.23144892f, -0.20574029f, 0.13893035f, 0.03110716f, -0.01101941f, 0.11313047f, 
    0.17041042f, -0.21338482f, -0.31942123f, 0.16708115f, -0.00289164f, 0.12829137f, -0.02599522f, 0.08459411f, 
    -0.00861631f, -0.05669323f, -0.03116692f, 0.01277123f, 0.27571610f, -0.25667751f, 0.08608761f, -0.01846395f, 
    0.00751437f, -0.02765090f, 0.04154208f, 0.02917810f, 0.03072274f, -0.04390935f, 0.14878124f, 0.22134897f, 
    0.10007671f, 0.13545750f, 0.09472054f, 0.05319924f, 0.13131110f, 0.16655375f, 0.06088858f, -0.00545179f, 
    0.01670649f, -0.02555360f, 0.08511204f, 0.05791400f, -0.26043066f, -0.27559426f, -0.11187918f, 0.27912888f, 
    0.10791011f, 0.01361007f, 0.00203496f, 0.06433917f, 0.01065687f, 0.17200626f, -0.01573448f, -0.05651973f, 
    0.12058736f, 0.10060983f, 0.09719575f, -0.03152825f, -0.11659522f, -0.07336382f, -0.05613762f, -0.04039425f, 
    0.04869621f, -0.05795360f, 0.01917192f, 0.21834646f, -0.18135439f, 0.09522049f, 0.00124140f, -0.11234433f, 
    -0.04068591f, 0.09600662f, 0.17647530f, 0.06859042f, 0.03100097f, 0.02991651f, 0.13076386f, 0.13255569f, 
    0.16366386f, 0.13754417f, 0.16214590f, -0.13954619f, 0.14035133f, -0.00851878f, 0.06861219f, 0.18413557f, 
    -0.01398849f, -0.01514550f, -0.00634539f, 0.08274750f, 0.01869927f, 0.02887243f, 0.09867416f, -0.21565633f, 
    0.07136709f, 0.05135436f, 0.01246936f, -0.01698879f, -0.09272790f, 0.09023537f, -0.03141704f, -0.03757287f, 
    0.25631547f, 0.00198158f, 0.16591355f, -0.29114482f, -0.03146406f, 0.00790858f, -0.02009127f, 0.10076644f, 
    0.17110004f, -0.08359280f, -0.10177782f, -0.11621358f, -0.07876466f, 0.02953302f, 0.01914780f, -0.19866253f, 
    0.10190864f, 0.07867542f, -0.04717361f, 0.10573793f, 0.13240686f, 0.07006485f, 0.04845703f, 0.03689047f, 
    -0.51555592f, 0.26391032f, -0.50655746f, -0.20979784f, -0.02514916f, -0.01886366f, 0.10609179f, -0.02839485f, 
    -0.03256428f, -0.19940703f, 0.07803393f, 0.07607750f, -0.13591470f, -0.01069049f, 0.05379488f, -0.08919967f, 
    0.10023757f, 0.00805126f, 0.05870944f, 0.06100488f, 0.10551863f, -0.08774989f, -0.01875813f, -0.15081611f, 
    -0.07588397f, 0.06771225f, 0.05991301f, 0.08622840f, 0.02432919f, 0.06260403f, -0.01190044f, -0.11396221f, 
    0.10575455f, 0.10294650f, 0.07700417f, 0.17952524f, -0.12996955f, 0.03714138f, -0.05107002f, 0.02090448f, 
    0.01368660f, -0.19150534f, 0.08114631f, 0.18521199f, 0.02477646f, 0.11176941f, 0.05133777f, -0.15014589f, 
    0.29909810f, -0.25091249f, -0.09935483f, -0.02679201f, 0.11322632f, -0.05357482f, 0.02972488f, -0.04159809f, 
    -0.03859492f, -0.04524869f, 0.02372810f, 0.11713391f, 0.03150862f, 0.21748841f, -0.14057349f, 0.04281894f, 
    0.08865231f, -0.00729917f, 0.03625234f, 0.01212726f, -0.09031525f, -0.09096322f, 0.06846360f, 0.00152532f, 
    -0.14790519f, -0.05769599f, 0.12011222f, 0.17566864f, 0.10704944f, -0.04652564f, 0.04023067f, -0.06024118f, 
    -0.01830348f, 0.05509030f, -0.10282884f, -0.05919656f, 0.11490764f, -0.07979876f, 0.05159887f, -0.01890031f, 
    -0.02879391f, -0.15908760f, -0.09196290f, -0.00328596f, 0.14224534f, 0.03241568f, 0.05415525f, 0.03093227f, 
    0.11533643f, -0.00936440f, 0.05624121f, 0.24664080f, 0.23103207f, -0.01928984f, 0.07105118f, -0.01361779f, 
    0.02030493f, -0.10590361f, -0.00416967f, 0.01854862f, 0.14542174f, 0.16536430f, 0.07782221f, -0.03402340f, 
    0.06698410f, 0.05992721f, 0.06391479f, -0.03519891f, 0.17961337f, -0.04661530f, 0.05527085f, 0.09981012f, 
    -0.24385975f, 0.12449182f, 0.01643850f, 0.09184125f, 0.15807003f, -0.10388926f, -0.08407009f, 0.01278531f, 
    0.15170096f, -0.04168412f, 0.03418273f, 0.05776393f, -0.03394783f, 0.25055262f, -0.11445930f, -0.16985650f, 
    0.01284355f, 0.13537703f, -0.05208366f, -0.06713296f, 0.03211123f, 0.02373946f, 0.04060065f, 0.15682361f, 
    -0.18632330f, -0.13086312f, 0.07435332f, 0.04676731f, 0.01248791f, -0.02490243f, -0.17517608f, 0.12194330f, 
    -0.05915758f, -0.11107556f, 0.11224693f, -0.17843565f, 0.10194460f, -0.21231315f, -0.06831486f, -0.03276877f, 
    0.03589100f, -0.05686339f, 0.03430584f, 0.02236133f, 0.15961443f, -0.00386883f, -0.05831510f, -0.11620037f, 
    -0.25473693f, 0.30479300f, -0.14469302f, -0.16823977f, -0.04095355f, -0.01997514f, -0.12828295f, 0.13080703f, 
    -0.06355671f, -0.00581082f, -0.04514830f, -0.11128256f, -0.08970586f, -0.10078327f, -0.01010733f, -0.19092220f, 
    -0.03256257f, 0.13948511f, 0.02162415f, -0.10087393f, 0.24624604f, -0.08923592f, -0.01722057f, 0.12254539f, 
    0.04745631f, 0.00521638f, 0.24870344f, -0.19057345f, 0.06924072f, -0.03799994f, 0.03234706f, -0.11099765f, 
    0.08613382f, -0.14497556f, -0.05425338f, -0.19648927f, 0.03347165f, -0.03022376f, -0.04527735f, -0.15556890f, 
    0.08237208f, -0.03236720f, -0.10432022f, 0.05404944f, 0.16274275f, 0.16351025f, 0.08125708f, 0.06684662f, 
    0.20977703f, -0.01548279f, -0.07454308f, -0.08760391f, 0.03004657f, -0.03165113f, 0.13548008f, 0.09875577f, 
    0.01140394f, -0.02075769f, -0.04317158f, -0.14173986f, 0.08012261f, 0.23939686f, -0.03238165f, 0.07841484f, 
    -0.02227105f, -0.05381515f, -0.05867279f, 0.01446426f, 0.01111600f, 0.04332875f, 0.16950332f, 0.12050324f, 
    0.06968673f, 0.06038834f, -0.20585367f, 0.18326432f, 0.07704258f, -0.15005708f, -0.08139464f, 0.01188003f, 
    -0.13028553f, 0.01853963f, 0.07773971f, 0.22105950f, 0.05668744f, 0.10725769f, -0.02192491f, 0.17321511f, 
    0.02650464f, -0.14175166f, 0.03247098f, 0.09458410f, 0.01436610f, 0.08917861f, -0.03247108f, -0.01401261f, 
    0.01483474f, 0.12071475f, -0.18445717f, 0.17728634f, 0.06678681f, -0.02776846f, -0.01732453f, -0.02129055f, 
    0.13494585f, 0.09742327f, -0.07370064f, -0.09128699f, -0.13101697f, -0.10836124f, -0.16445522f, -0.00640986f, 
    0.03388756f, 0.20971702f, -0.04215455f, 0.02967159f, -0.10824345f, -0.11420213f, 0.01445315f, -0.12152309f, 
    0.11315401f, -0.32125777f, 0.12408612f, -0.29703516f, 0.03312571f, -0.03761005f, 0.04117778f, 0.06863166f, 
    0.05913285f, -0.18844642f, -0.16855864f, 0.03209050f, 0.10319949f, 0.10880668f, 0.23178487f, 0.14374253f, 
    0.00374166f, -0.04358028f, -0.07471552f, -0.03919178f, 0.12278285f, -0.02492419f, 0.07002402f, 0.11557865f, 
    -0.11591449f, 0.36817804f, -0.27882382f, 0.39061010f, 0.08558171f, 0.13513680f, -0.05251731f, 0.14210711f, 
    -0.05534402f, -0.06359076f, 0.18507399f, -0.00489791f, -0.22687662f, 0.07256040f, 0.03575936f, 0.06211847f, 
    -0.02676599f, 0.14002597f, 0.06698553f, 0.00524066f, 0.19682144f, -0.03804001f, 0.14107610f, -0.05412840f, 
    -0.11078610f, -0.24192266f, -0.05047080f, -0.27095497f, 0.00384137f, 0.19937254f, 0.09396844f, 0.06881595f, 
    -0.02319873f, -0.09632330f, 0.13670027f, -0.13458575f, -0.10712207f, 0.12771866f, 0.18299888f, 0.19344725f, 
    0.06742305f, -0.07886725f, -0.10689462f, 0.03606111f, 0.04540293f, 0.01062317f, 0.01728878f, -0.00722081f, 
    0.20146476f, -0.06855603f, -0.12217713f, 0.13852578f, 0.04174946f, 0.13892335f, -0.07861340f, -0.06342046f, 
    0.03197827f, -0.00957221f, 0.02840385f, 0.16974586f, 0.03336055f, -0.01138452f, 0.00294033f, -0.04214325f, 
    -0.05021428f, -0.00202952f, 0.18786067f, 0.12755604f, 0.00906814f, 0.01697241f, 0.02793419f, -0.26544255f, 
    -0.03836150f, -0.11308487f, -0.25907668f, 0.18395233f, 0.13725647f, 0.07118225f, 0.02054381f, -0.02268411f, 
    0.09530444f, 0.02975189f, 0.14461918f, 0.27991256f, 0.00068174f, 0.07289462f, 0.15189447f, -0.10991655f, 
    -0.07411983f, -0.05167298f, 0.01306802f, 0.04725467f, 0.08873048f, 0.09692759f, 0.08545978f, -0.03712678f, 
    0.00114379f, 0.08502438f, 0.03201577f, 0.08807022f, 0.06344040f, -0.01597439f, -0.03968394f, -0.05844693f, 
    0.13439310f, -0.11154526f, 0.09520803f, 0.04448234f, 0.06524144f, -0.20605201f, -0.04966016f, 0.04799364f, 
    0.10617422f, 0.21036007f, 0.01205913f, 0.07187641f, -0.05384428f, -0.05932300f, 0.01158140f, 0.01290651f, 
    0.12550727f, -0.06760007f, 0.05107216f, 0.02718280f, 0.02174858f, -0.03316003f, 0.06171822f, -0.06938387f, 
    0.11958505f, 0.00273869f, -0.03310128f, -0.20262429f, -0.14996780f, -0.27724746f, -0.08074880f, -0.14993618f, 
    0.00557013f, 0.16737399f, 0.07661930f, 0.08485287f, 0.03572737f, 0.05477944f, 0.07531305f, -0.00298881f, 
    -0.24245296f, -0.02455223f, 0.10925318f, -0.21322925f, 0.01588912f, -0.07055715f, 0.00486288f, 0.18652515f, 
    -0.04336745f, -0.20017184f, -0.20386499f, -0.10616461f, 0.50161910f, 0.20378011f, -0.01683963f, -0.30493999f, 
    -0.01142559f, 0.07235827f, 0.05538300f, 0.10125113f, 0.04564347f, -0.09443153f, 0.05058978f, 0.04717760f, 
    -0.16619104f, -0.28258169f, -0.08890018f, -0.10961386f, -0.01960563f, 0.07348584f, 0.12667108f, -0.02849150f, 
    0.15900585f, 0.02123191f, 0.07108414f, 0.22058520f, -0.11955085f, -0.13977097f, 0.09209708f, -0.05012168f, 
    0.03265204f, 0.07864735f, 0.04143679f, 0.01704074f, 0.05380135f, 0.06180447f, -0.07780328f, -0.17314143f, 
    0.06733777f, 0.10963673f, -0.14477846f, 0.05112654f, -0.11555716f, 0.04221999f, 0.05865830f, -0.00023046f, 
    0.10188986f, -0.01023395f, -0.05304397f, -0.10436002f, -0.46286213f, -0.08707897f, -0.01003886f, 0.03340538f, 
    0.06701725f, -0.05116333f, 0.03844075f, -0.00491889f, -0.20417541f, -0.11402050f, -0.10199363f, 0.13493493f, 
    0.28731194f, -0.01150417f, 0.17326312f, -0.05731477f, 0.11548986f, 0.09133932f, 0.05247045f, 0.01347612f, 
    0.01788855f, 0.00100487f, 0.04306908f, -0.01083739f, 0.06467603f, -0.06457037f, 0.13219984f, -0.32115915f, 
    -0.06177771f, -0.16077411f, -0.09517677f, -0.10071751f, 0.05546512f, -0.04029861f, -0.00010976f, -0.11283792f, 
    -0.30296025f, 0.04819166f, -0.01200040f, -0.08565516f, -0.11870986f, 0.10146620f, -0.07243887f, -0.12725201f, 
    0.03601458f, 0.10291064f, -0.08259908f, 0.17135721f, -0.21506901f, -0.08246738f, 0.14823158f, -0.15669760f, 
    -0.11986426f, 0.00022991f, -0.10275628f, -0.01623334f, -0.01094403f, -0.08000068f, -0.02160507f, -0.09859483f, 
    -0.06879832f, -0.24728152f, -0.26386034f, -0.19249389f, 0.12225422f, -0.01174620f, 0.08097801f, -0.15867996f, 
    -0.13965389f, -0.10402410f, -0.03234127f, 0.04306643f, -0.30776450f, -0.09422462f, -0.12113068f, -0.12906364f, 
    0.09715373f, -0.13535762f, 0.07536370f, -0.22903118f, -0.00582616f, -0.00903050f, 0.00166437f, -0.06015235f, 
    0.33485594f, -0.01942325f, 0.21359180f, 0.01056727f, 0.05588474f, 0.06467474f, 0.00233144f, 0.13775836f, 
    0.08020607f, -0.00121708f, 0.02995378f, -0.08638813f, 0.04422831f, -0.12305288f, 0.14028168f, -0.01719332f, 
    0.12328523f, -0.02832920f, -0.03147798f, -0.08952936f, -0.03240260f, -0.07234018f, 0.06265119f, -0.07493906f, 
    -0.18185596f, -0.03206087f, -0.02075908f, 0.19710928f, 0.23420307f, -0.03742988f, 0.22525781f, 0.02336615f, 
    0.11655080f, 0.00741492f, -0.13847205f, -0.06589250f, 0.01679147f, 0.00654587f, 0.06488115f, 0.07279133f, 
    0.04997031f, -0.03711483f, -0.09567858f, 0.15785301f, -0.01386477f, -0.07974782f, -0.04234930f, 0.03249542f, 
    0.07743712f, -0.12616688f, 0.02941090f, -0.15512064f, -0.04981968f, -0.07123253f, 0.07984345f, 0.08364477f, 
    -0.07999869f, -0.00490206f, 0.05408357f, -0.01566735f, -0.20371015f, 0.11118586f, 0.06613711f, 0.10738687f, 
    -0.04204658f, 0.04100747f, 0.00746117f, 0.00073040f, -0.01494416f, -0.12411603f, -0.11469407f, 0.10140549f, 
    0.14233315f, 0.13480315f, 0.12653734f, -0.02552251f, -0.04261827f, 0.13342318f, 0.00209605f, -0.23337330f, 
    -0.02756152f, -0.02921610f, -0.12674710f, -0.07379692f, -0.24935403f, -0.23572402f, 0.34247255f, -0.19359024f, 
    0.05623259f, 0.06040522f, 0.09958479f, -0.02600244f, 0.13819312f, -0.03304132f, -0.01344587f, -0.06025545f, 
    0.11563078f, 0.10583067f, 0.04752638f, 0.09691906f, 0.05954312f, 0.03644995f, -0.02957997f, 0.03647511f, 
    -0.03996707f, -0.04186279f, -0.05293364f, -0.07090268f, 0.06111587f, 0.14538676f, 0.06073022f, -0.05127920f, 
    0.02760128f, 0.12861256f, 0.09557623f, -0.16172120f, -0.11405711f, -0.12788501f, -0.07684522f, -0.13472323f, 
    -0.04618452f, -0.05925635f, 0.03837619f, 0.14459245f, 0.18051192f, 0.03996922f, 0.02868656f, -0.03150658f, 
    -0.12719966f, -0.09741826f, -0.06910950f, -0.03275709f, 0.02183477f, 0.25689337f, -0.04348243f, -0.07785769f, 
    0.09948578f, 0.02468126f, -0.05368044f, -0.15956597f, -0.07163911f, -0.14305803f, -0.00126478f, -0.13299102f, 
    -0.07298266f, 0.16904238f, 0.03191204f, 0.21431994f, -0.00749515f, 0.00657551f, 0.01790557f, 0.05702790f, 
    -0.03945015f, -0.11074666f, 0.07619617f, 0.00948142f, 0.09121815f, 0.26573995f, 0.05784930f, -0.05112612f, 
    0.03092826f, 0.05474307f, 0.08707617f, -0.48569664f, -0.09752589f, -0.08086062f, -0.00992682f, -0.13145944f, 
    -0.38400707f, -0.15532583f, -0.28122899f, -0.32554632f, 0.01003799f, 0.03875400f, -0.07078735f, -0.06935037f, 
    0.01897940f, -0.00365596f, -0.05555806f, -0.05038499f, -0.20863844f, -0.02142758f, 0.00011026f, -0.12393849f, 
    -0.11714502f, 0.01834090f, 0.02589882f, -0.00223265f, -0.16290972f, -0.00058641f, 0.09956011f, 0.07845451f, 
    0.04295767f, 0.01866171f, -0.04155218f, -0.04787387f, -0.03410828f, 0.01687084f, -0.04088961f, -0.01187925f, 
    0.03137364f, -0.04412750f, -0.11978208f, 0.04539961f, 0.09366835f, -0.02544426f, 0.13567986f, 0.15950480f, 
    0.12609220f, 0.04309198f, 0.03798383f, 0.11352453f, 0.21395792f, 0.06282962f, 0.05897562f, 0.12394207f, 
    -0.23662269f, 0.05662141f, 0.24077532f, 0.10670934f, -0.05249295f, -0.04350930f, -0.03969312f, 0.00377077f, 
    -0.09326169f, -0.01526280f, -0.03123122f, 0.11047852f, 0.03596961f, -0.08505504f, 0.23380075f, -0.13460572f, 
    0.08411196f, 0.22491683f, 0.02431997f, -0.10709396f, -0.05400179f, -0.05517109f, -0.05969618f, -0.09665200f, 
    0.11831749f, 0.11159711f, 0.22023787f, 0.05140965f, -0.02559332f, 0.12310132f, -0.11926659f, 0.24796593f, 
    -0.00702022f, 0.02790884f, 0.00857107f, 0.04711767f, -0.03194004f, 0.19968918f, 0.09264871f, 0.17771183f, 
    0.04892879f, -0.03672193f, 0.08533055f, 0.04062119f, -0.05989373f, -0.10026794f, -0.10323966f, -0.08168329f, 
    -0.44082370f, -0.05755069f, 0.49078119f, -0.25384998f, -0.14532980f, -0.00482288f, -0.12832673f, 0.09898014f, 
    0.04251102f, -0.06337301f, 0.12913287f, 0.21041720f, 0.35452551f, 0.07099895f, 0.12800235f, 0.17507091f, 
    0.10302589f, 0.01115290f, 0.05184755f, 0.06433327f, -0.02796277f, 0.02830401f, -0.06020283f, -0.05356774f, 
    0.28917840f, 0.10259128f, 0.03527116f, -0.00788427f, -0.00726573f, 0.09347444f, -0.00522648f, 0.00504031f, 
    -0.08902761f, -0.00676659f, 0.00599368f, -0.01190614f, 0.72865814f, -0.28147766f, -0.12118179f, -0.00435858f, 
    0.20941772f, -0.05405701f, -0.13738133f, -0.02422379f, 0.07567956f, -0.01028027f, 0.05067021f, -0.08589154f, 
    0.20854652f, 0.03666809f, 0.05641497f, 0.15159149f, 0.10311509f, 0.06006731f, 0.04887101f, 0.05870774f, 
    0.07892381f, 0.15481423f, 0.06224134f, 0.12467453f, -0.22870162f, 0.04657999f, 0.01310014f, -0.02739019f, 
    -0.01443902f, 0.00187537f, 0.03214183f, -0.03586729f, -0.06642592f, -0.08043059f, 0.15402848f, 0.00796933f, 
    0.50252873f, -0.27299526f, -0.07629348f, 0.11659784f, 0.05249789f, 0.10392351f, 0.06585950f, -0.22925821f, 
    -0.00631457f, 0.07581615f, 0.03113372f, 0.06615027f, -0.11415628f, -0.02629716f, -0.14621569f, 0.01190801f, 
    0.09960043f, 0.03107367f, 0.00187823f, -0.02891573f, 0.01105717f, -0.02761169f, -0.04464349f, -0.12504429f, 
    -0.39425364f, 0.06452452f, 0.05760565f, 0.05413518f, 0.08190326f, -0.02522159f, -0.02295735f, -0.00764194f, 
    0.01925082f, -0.01905992f, 0.10953282f, -0.01024422f, 0.08418292f, 0.03998972f, 0.06684598f, 0.12033960f, 
    0.08551513f, -0.00803711f, 0.07957987f, 0.00649447f, -0.01458553f, -0.01361820f, -0.08739962f, -0.09109224f, 
    -0.45626891f, 0.13061965f, 0.08972204f, -0.10893258f, -0.06857023f, 0.01545162f, -0.16144955f, -0.06920310f, 
    -0.04027534f, 0.00016787f, -0.06629917f, 0.05579878f, 0.19921094f, 0.14832805f, 0.04762479f, 0.22830448f, 
    0.03664728f, -0.00677093f, 0.02082199f, -0.01790186f, -0.05337195f, 0.00219591f, -0.12396965f, 0.02651438f, 
    0.13334423f, -0.08979828f, 0.19322413f, 0.00866524f, 0.07094862f, 0.04340377f, -0.04454689f, 0.01589402f, 
    -0.10933257f, 0.03304459f, -0.11965188f, 0.07430901f, 0.05361281f, -0.00330430f, 0.24671333f, 0.06400900f, 
    -0.03871457f, 0.00094557f, 0.07983852f, 0.03654103f, -0.02685167f, 0.04808709f, -0.04809435f, -0.03150564f, 
    0.42422879f, 0.03748634f, 0.15776552f, 0.02501547f, 0.05347201f, 0.07854954f, 0.11078583f, 0.08209242f, 
    -0.05720209f, 0.01180655f, 0.04672970f, -0.10385409f, -0.19029659f, -0.06724272f, 0.01382673f, -0.20556138f, 
    -0.13081904f, -0.09159987f, 0.06041583f, -0.16071677f, 0.03439454f, 0.10154363f, 0.08485125f, 0.01492298f, 
    -0.84682626f, 0.13714582f, -0.20815066f, -0.06387811f, 0.04307086f, -0.06364616f, 0.04166361f, -0.09373959f, 
    0.06025127f, 0.14077188f, -0.01737603f, 0.10370606f, 0.35077879f, 0.13618036f, 0.00651559f, -0.01203630f, 
    0.04142245f, 0.03452095f, 0.02901100f, 0.04216297f, -0.00913439f, -0.02133286f, -0.05688266f, -0.06362558f, 
    0.49239299f, -0.18172090f, 0.13603666f, -0.39287195f, 0.10882432f, 0.07705511f, -0.08905084f, 0.00101207f, 
    0.08480120f, 0.05018739f, 0.05035922f, 0.08021880f, 0.06733192f, -0.00525158f, -0.12138547f, -0.09813533f, 
    0.09026933f, 0.10455015f, -0.09684633f, -0.02924838f, -0.05888607f, 0.04032065f, -0.01174581f, 0.05627671f, 
    -0.02701140f, 0.02641660f, -0.11452012f, 0.02427941f, 0.01904505f, -0.04612835f, -0.08751394f, -0.17935883f, 
    0.10019679f, -0.04280918f, 0.08896591f, -0.02012204f, 0.21970905f, 0.17882165f, 0.12436132f, 0.07917293f, 
    0.00571985f, 0.08270688f, 0.10080985f, 0.04350361f, 0.01968716f, 0.00509968f, -0.01073001f, 0.02496045f, 
    0.00612192f, 0.04462831f, 0.08552267f, -0.01312892f, -0.18810786f, -0.11090814f, 0.03546360f, -0.00040422f, 
    -0.07096586f, -0.03538469f, -0.13028008f, -0.16006967f, 0.08825949f, 0.13250987f, -0.24204698f, -0.33524597f, 
    -0.02420085f, 0.03610264f, -0.10494053f, -0.02158635f, -0.10126271f, -0.03470092f, 0.06867643f, 0.04077188f, 
    0.16458279f, -0.12363648f, 0.22410098f, 0.06666981f, -0.05652770f, 0.03590766f, 0.00209865f, 0.01419810f, 
    0.05525618f, -0.01005205f, -0.02498113f, -0.00546599f, 0.10691219f, 0.17377688f, -0.08223261f, 0.20908330f, 
    0.03183495f, -0.00481608f, 0.00425656f, 0.00453320f, 0.10186016f, -0.04409916f, 0.07465763f, 0.03018567f, 
    0.16278955f, 0.05638535f, 0.11534840f, 0.15558781f, 0.08347555f, 0.05855633f, 0.07302897f, 0.10400115f, 
    0.10885702f, 0.12018812f, 0.00127286f, 0.14670989f, -0.12091400f, 0.08879907f, 0.13024136f, -0.36437196f, 
    0.02799831f, 0.05387254f, -0.16217791f, -0.20444185f, 0.05160875f, -0.04939517f, -0.05723998f, -0.00442290f, 
    0.17051381f, 0.11570869f, 0.11561105f, 0.15600713f, 0.06991974f, 0.00064570f, 0.01021302f, 0.06105448f, 
    0.10871777f, 0.10075217f, -0.02453820f, 0.07405747f, -0.13451090f, 0.04571129f, -0.09677351f, -0.05175552f, 
    0.01479809f, -0.00749384f, -0.11971100f, -0.23561500f, 0.04262377f, 0.02218661f, 0.04179493f, 0.08782634f, 
    -0.00589141f, 0.10506564f, 0.11026801f, -0.10287571f, -0.04048599f, 0.08300152f, 0.04437820f, -0.07063346f, 
    -0.14189434f, 0.00326478f, 0.10899601f, 0.13374507f, -0.22355893f, -0.10467000f, -0.03139476f, 0.30726084f, 
    0.08911957f, -0.15114397f, -0.00442892f, 0.09883071f, 0.09458241f, -0.02985867f, 0.02966757f, 0.04805616f, 
    -0.09927305f, -0.04395421f, 0.03531924f, -0.02481265f, 0.00940048f, 0.00351796f, -0.12386585f, 0.02135542f, 
    0.01205694f, -0.09334300f, -0.02902705f, -0.02628143f, 0.19297087f, 0.11639359f, -0.27085528f, -0.03526855f, 
    0.05273634f, 0.00540485f, 0.05328229f, -0.01051754f, -0.06059407f, -0.10947526f, -0.00483843f, -0.07002387f, 
    0.04988418f, -0.26719064f, 0.23131150f, -0.08682430f, 0.13651714f, 0.11076256f, 0.10620847f, 0.03849545f, 
    0.12197562f, -0.13321483f, -0.01164762f, 0.06307956f, -0.34864634f, 0.10437789f, -0.09262792f, -0.07103219f, 
    -0.06313181f, -0.05722320f, 0.09024414f, -0.03888929f, -0.06662290f, 0.09016461f, 0.06799805f, -0.03618442f, 
    0.09467208f, -0.01231227f, 0.20025581f, -0.01295915f, 0.01209603f, -0.07993050f, 0.07422423f, -0.00212504f, 
    -0.02652402f, 0.04048061f, -0.00290009f, -0.02024276f, -0.13344371f, -0.07386793f, 0.06069464f, -0.00751203f, 
    0.29829246f, -0.18169965f, -0.10493599f, -0.12709053f, -0.06245649f, -0.09562679f, -0.06911411f, -0.00754875f, 
    0.08346740f, 0.12078581f, 0.22599266f, 0.11056307f, 0.11694801f, 0.12642404f, -0.00304440f, -0.08118287f, 
    0.09361038f, -0.06762211f, -0.06421668f, -0.09854250f, -0.05696219f, -0.05814262f, -0.10311351f, -0.09047754f, 
    0.01881752f, 0.06734760f, 0.09766658f, 0.17027998f, -0.06247319f, -0.00839795f, -0.02689179f, -0.00599357f, 
    -0.26101875f, -0.07010317f, -0.29596722f, -0.09139605f, -0.07442068f, -0.08192381f, -0.07264405f, 0.05742413f, 
    0.00331110f, -0.01858278f, 0.03563524f, -0.02979251f, 0.27249116f, 0.01120455f, 0.10431054f, 0.04000368f, 
    -0.04682429f, 0.07403635f, -0.09156582f, -0.12441887f, -0.04692427f, 0.04142703f, -0.07918257f, 0.03910250f, 
    0.18137461f, -0.00108733f, 0.38665846f, 0.00678239f, 0.10027410f, 0.09410641f, 0.08230066f, -0.01853294f, 
    -0.09443711f, 0.15642543f, 0.00231189f, 0.05921961f, -0.12309231f, -0.12126282f, 0.06221136f, -0.11499083f, 
    0.06776421f, 0.05110556f, 0.11872813f, -0.09217145f, 0.06948189f, -0.04541668f, -0.01553684f, -0.10739606f, 
    -0.38227662f, -0.03719216f, -0.30186200f, 0.19786547f, 0.07313814f, -0.02237723f, 0.13354219f, 0.05092777f, 
    0.07357351f, 0.00365549f, 0.06212008f, 0.00043867f, 0.05125163f, -0.05048911f, -0.03143832f, -0.10609691f, 
    0.22239445f, 0.02039572f, -0.13303180f, 0.07141038f, -0.15789124f, 0.01013681f, -0.02557306f, 0.11810382f, 
    0.06862930f, 0.14303853f, -0.06668713f, -0.06934202f, -0.02902478f, -0.02728461f, -0.17547339f, -0.01675404f, 
    0.04321881f, 0.15082899f, 0.20602204f, -0.00921017f, -0.22954477f, -0.00115698f, -0.23627406f, 0.12655291f, 
    0.07534397f, 0.05090923f, 0.01752217f, -0.04373647f, 0.07697487f, 0.06640293f, 0.02920439f, 0.11324706f, 
    -0.02931865f, -0.09849823f, -0.02239367f, -0.00111329f, -0.17122145f, -0.06318238f, -0.01788856f, -0.03772346f, 
    0.03012095f, 0.00071890f, -0.07187939f, 0.11590693f, 0.21200590f, 0.04471624f, 0.20817924f, -0.00472347f, 
    0.11008411f, 0.02337071f, 0.03649889f, 0.10841896f, 0.06397843f, 0.13726175f, 0.14307304f, -0.00491530f, 
    0.12908408f, 0.00882150f, 0.13547669f, 0.11996846f, -0.27663743f, -0.08109393f, -0.03760908f, -0.10706911f, 
    0.01112782f, -0.05446207f, -0.01670965f, -0.01263944f, 0.03681366f, 0.03519287f, -0.01198536f, 0.01994163f, 
    0.00202854f, -0.09057809f, 0.02169944f, 0.04969750f, -0.03550895f, 0.04655443f, -0.01832727f, 0.04851025f, 
    -0.19019245f, 0.02645882f, -0.18950354f, 0.03502158f, -0.08709739f, -0.08409653f, 0.05120515f, -0.08221319f, 
    0.02857098f, 0.00675983f, 0.13363472f, 0.09638140f, -0.19127572f, -0.21585359f, 0.01310912f, 0.02161756f, 
    -0.11457936f, -0.05544846f, 0.03284463f, 0.03650455f, 0.07230148f, 0.12855804f, 0.00253480f, -0.04500365f, 
    -0.13326384f, 0.10841755f, -0.09901109f, 0.07995735f, -0.05667781f, 0.03017339f, -0.02077433f, 0.04333114f, 
    -0.02874800f, 0.11648031f, 0.04472870f, -0.04069015f, -0.11511515f, -0.03301030f, 0.03653878f, 0.06933744f, 
    -0.08399967f, -0.04273023f, 0.09080727f, 0.04616240f, -0.07744791f, -0.04634718f, -0.05682999f, 0.13642506f, 
    0.27629933f, -0.02529330f, 0.23435074f, -0.09820718f, -0.03158435f, -0.06254354f, 0.03962610f, -0.05952128f, 
    0.04547088f, 0.02358739f, -0.01660418f, -0.02945253f, 0.03385238f, -0.02690896f, 0.00845522f, 0.00871647f, 
    0.04883684f, -0.10773133f, -0.01528681f, 0.07578207f, 0.05983406f, 0.07079236f, 0.06950597f, -0.09293150f, 
    0.02759699f, 0.02938674f, 0.04741880f, -0.06531616f, 0.04567748f, 0.03966787f, 0.00446351f, -0.02107777f, 
    -0.09486917f, 0.05695262f, -0.02412190f, 0.04920794f, -0.06097838f, 0.01864356f, 0.17010425f, -0.15262711f, 
    0.08682580f, 0.06001622f, -0.06164028f, 0.01924907f, -0.14670813f, -0.08912187f, -0.13487339f, -0.07449448f, 
    -0.31659561f, -0.14826635f, -0.05083462f, 0.12778205f, 0.05630818f, 0.00187133f, 0.01025012f, -0.12696414f, 
    0.36634111f, -0.01336918f, 0.11774784f, 0.06452140f, 0.06619573f, -0.03297329f, 0.13560987f, 0.01990037f, 
    -0.10113578f, -0.00609306f, -0.05323164f, -0.11917648f, 0.09376390f, 0.07655244f, -0.03158639f, 0.00284738f, 
    0.44591606f, 0.16300137f, 0.09766378f, -0.03067557f, 0.08180526f, -0.01984196f, -0.05446606f, 0.08245215f, 
    -0.10072399f, -0.01774075f, 0.00184980f, 0.00611494f, -0.07199100f, 0.05812607f, 0.03465058f, 0.13806407f, 
    -0.03414842f, 0.02778241f, -0.01585771f, -0.02987692f, 0.09945355f, 0.10414506f, 0.15957542f, 0.05753105f, 
    -0.02957097f, -0.04974873f, -0.05452795f, 0.00516381f, 0.16016622f, 0.15823579f, 0.07279899f, -0.02683965f, 
    0.13069959f, 0.09257663f, -0.03421180f, 0.00974523f, 0.35736948f, 0.15929042f, 0.27299896f, 0.39846379f, 
    -0.07540809f, -0.02690526f, -0.03263154f, -0.02822559f, -0.02755238f, 0.10118910f, 0.07753368f, 0.12884910f, 
    0.20591632f, 0.04318736f, 0.02132615f, -0.09718166f, 0.10318659f, 0.04494583f, -0.01560162f, -0.06909885f, 
    -0.00960151f, -0.01063827f, 0.07458752f, 0.08653736f, 0.03330935f, -0.09188124f, 0.18255563f, 0.00106495f, 
    0.02919271f, 0.11837592f, 0.15323332f, 0.16173439f, -0.00748260f, -0.05371091f, -0.04708794f, 0.02501691f, 
    0.00345496f, 0.01289997f, 0.12802818f, 0.04109518f, 0.01650595f, -0.03489369f, -0.01928152f, -0.01137786f, 
    -0.02001366f, -0.14139479f, -0.20158337f, -0.08036860f, -0.34343421f, -0.22386280f, -0.11963300f, -0.05737658f, 
    -0.07611308f, -0.04621729f, 0.02204109f, -0.02078177f, -0.00276466f, -0.08332108f, 0.09590786f, -0.09474959f, 
    0.09626042f, -0.44664547f, 0.32976705f, -0.18482289f, -0.07593257f, 0.13089761f, -0.12003087f, -0.00688899f, 
    -0.08911330f, -0.04306514f, 0.00350775f, 0.21987312f, -0.06289283f, 0.01233060f, 0.15651114f, -0.04689437f, 
    -0.02230677f, -0.02815694f, 0.10208865f, 0.09703771f, 0.06271390f, 0.01571836f, -0.05670588f, 0.16394147f, 
    -0.19300625f, -0.04164141f, -0.34604514f, 0.01922151f, -0.08844756f, -0.04200253f, 0.19647755f, 0.15628712f, 
    0.00963258f, 0.01249896f, 0.06125633f, 0.07112563f, 0.00475461f, 0.04142530f, -0.02078570f, 0.04267956f, 
    0.01304316f, 0.12408390f, 0.00148348f, -0.04913812f, 0.04569191f, -0.01250989f, 0.14098860f, 0.05297171f, 
    -0.30104080f, -0.31207910f, -0.00536669f, 0.09711163f, -0.11438552f, 0.07402885f, 0.12576587f, 0.05957894f, 
    -0.04487673f, -0.01558701f, -0.04161904f, -0.02728688f, 0.06315420f, 0.02100087f, 0.13947299f, 0.11885303f, 
    -0.15927587f, -0.01018408f, -0.06192318f, 0.00690210f, 0.02341460f, 0.04068509f, 0.09074375f, 0.07633566f, 
    0.06195842f, 0.00681363f, 0.14837326f, -0.05624375f, 0.09642664f, -0.14879598f, 0.16363746f, -0.06229126f, 
    0.16836241f, -0.07675881f, 0.03112618f, -0.08757547f, 0.35381737f, 0.01458627f, 0.15301535f, 0.06942542f, 
    0.14750940f, -0.15511598f, 0.04696834f, 0.05566164f, 0.19144414f, -0.06653970f, 0.16660471f, -0.07484574f, 
    0.21695085f, 0.12692764f, 0.28350434f, -0.12025273f, -0.00565138f, 0.09301003f, 0.10168941f, -0.03490655f, 
    0.11480057f, -0.02780948f, 0.12104310f, 0.12762354f, 0.02478576f, 0.04636849f, 0.01979067f, 0.01685411f, 
    -0.00375220f, 0.05762456f, -0.00109557f, 0.05607536f, 0.10479487f, 0.04082318f, 0.00639420f, 0.00203218f, 
    -0.33164167f, 0.03768825f, -0.03373257f, 0.14390619f, 0.00313989f, -0.07624879f, 0.01767383f, 0.02574213f, 
    -0.11263266f, -0.07398447f, 0.02319483f, -0.08542575f, 0.15825664f, 0.24950129f, 0.10443518f, 0.12151276f, 
    -0.08913863f, -0.10881544f, 0.00147513f, -0.03715932f, -0.09811290f, 0.01510627f, -0.02255019f, 0.01225952f, 
    0.18516649f, -0.09308186f, 0.45831057f, -0.06571906f, 0.09497250f, 0.00249351f, 0.12657109f, 0.15972528f, 
    0.01084169f, 0.15095893f, -0.00036078f, 0.02348506f, 0.12519851f, -0.08168417f, 0.06879323f, -0.04213821f, 
    0.01633328f, 0.06662901f, 0.02721956f, 0.17605217f, -0.02515943f, 0.21528022f, -0.13416290f, 0.11806238f, 
    0.00495846f, -0.05573420f, 0.13416812f, -0.00183641f, -0.10435981f, 0.01045237f, 0.09889409f, 0.03431763f, 
    -0.05180225f, 0.02803587f, 0.05407083f, -0.09460231f, 0.32264522f, 0.30029434f, 0.19402102f, 0.04021135f, 
    0.00851318f, -0.07167114f, 0.03932373f, -0.00455074f, -0.05392240f, -0.01550933f, -0.00681256f, 0.04659603f, 
    -0.07986180f, 0.10494828f, -0.04553675f, -0.14621586f, 0.09447139f, -0.07140518f, -0.10933922f, 0.03932057f, 
    -0.05953540f, -0.00501548f, 0.06800673f, 0.02348623f, 0.15128367f, 0.00921397f, 0.03281668f, 0.12489188f, 
    -0.04041507f, 0.06859386f, -0.05190149f, 0.07895070f, -0.07399570f, 0.12199949f, -0.00068598f, -0.08706336f, 
    0.18029523f, 0.15282297f, 0.13722053f, -0.07041954f, -0.02407481f, 0.06436040f, 0.12555052f, -0.07625168f, 
    0.00152731f, 0.13704018f, 0.09739739f, -0.04858938f, 0.12556963f, 0.14206141f, 0.01789542f, 0.14640059f, 
    -0.08883684f, 0.03298681f, 0.03356242f, -0.02607590f, 0.06750212f, 0.05481855f, 0.02298435f, 0.08494242f, 
    0.01909316f, 0.10476562f, 0.06602558f, -0.00497695f, -0.05444885f, -0.02926982f, 0.03321445f, -0.01091991f, 
    -0.03823405f, -0.01499119f, 0.02924172f, -0.07899424f, -0.08672803f, -0.15410474f, 0.01392606f, -0.02864583f, 
    0.01432262f, 0.12164140f, -0.10381246f, 0.08601033f, -0.20834842f, -0.04576194f, 0.04687041f, -0.03942811f, 
    0.04242028f, 0.18631493f, 0.12373614f, -0.00142161f, -0.02382520f, -0.05080040f, -0.08063105f, -0.05283004f, 
    0.04550183f, 0.07560151f, -0.07461322f, -0.09619291f, -0.12099590f, -0.09721895f, 0.09367404f, -0.03095760f, 
    0.01403559f, 0.06312022f, 0.10623270f, 0.13775796f, 0.03736294f, 0.08959967f, 0.05899760f, -0.06257635f, 
    0.00749141f, 0.04080614f, -0.07448140f, 0.12002516f, 0.19963253f, -0.17382570f, -0.09922519f, -0.08621982f, 
    0.07586117f, 0.07844734f, 0.07357933f, 0.00904847f, -0.37851477f, 0.29612336f, -0.09707350f, 0.18126123f, 
    0.08510638f, 0.02996131f, 0.07834788f, -0.10623594f, 0.10963684f, -0.04260764f, 0.12176071f, 0.05806527f, 
    -0.16053763f, 0.01799972f, 0.02300689f, -0.04354378f, 0.17868020f, 0.03411596f, -0.01513618f, 0.04468640f, 
    -0.14573033f, -0.10943802f, -0.04434967f, -0.06291451f, 0.10963066f, 0.13055643f, 0.02607550f, -0.04252999f, 
    -0.06890600f, -0.04229828f, -0.04353872f, 0.05084718f, 0.05282537f, -0.03132852f, -0.00511731f, -0.03376594f, 
    -0.18216340f, 0.02462129f, 0.04281616f, 0.02215782f, 0.08626984f, 0.11829948f, 0.16819312f, 0.26296431f, 
    0.13394709f, -0.01562909f, 0.03678061f, -0.03997861f, 0.08819977f, 0.22762448f, -0.01019749f, -0.14677966f, 
    -0.02161716f, 0.05164995f, 0.04348790f, -0.05758525f, 0.12480374f, 0.01335083f, 0.06740104f, 0.18518312f, 
    -0.04980461f, 0.14480396f, 0.04696786f, -0.04211158f, -0.02052255f, 0.04784769f, 0.11335639f, -0.04902044f, 
    0.02973481f, 0.11413599f, 0.06933863f, -0.01117710f, -0.33962035f, 0.13450442f, -0.06754109f, -0.00639924f, 
    0.03773244f, 0.09280641f, 0.01665210f, 0.00390538f, -0.02432166f, 0.04028555f, -0.08138947f, -0.00729914f, 
    -0.22499980f, 0.18095705f, 0.07151347f, 0.09621630f, 0.04921135f, 0.00494372f, 0.13725504f, 0.10821657f, 
    0.10382419f, 0.07525731f, 0.20061432f, -0.10653909f, -0.01027751f, -0.13687651f, -0.19195147f, -0.07293895f, 
    0.01753508f, -0.01116330f, -0.02028135f, 0.27567947f, -0.00802695f, 0.05982412f, -0.01232687f, 0.07379457f, 
    -0.23275962f, -0.32575858f, -0.18174225f, 0.18738392f, -0.02157870f, -0.01997936f, -0.04656544f, -0.06965219f, 
    -0.05080599f, -0.03504644f, -0.00590289f, -0.02572828f, -0.09411441f, -0.45800924f, 0.10244188f, 0.20481341f, 
    -0.01053330f, 0.05588603f, -0.11868975f, -0.07391338f, -0.04274328f, -0.01055212f, -0.08776242f, -0.10750357f, 
    0.07217812f, 0.14580281f, 0.06144145f, 0.00986169f, 0.02990592f, 0.24279997f, 0.15745270f, 0.22425275f, 
    -0.13488181f, -0.00983121f, 0.15132101f, 0.06704052f, -0.17479247f, -0.02564630f, 0.13052069f, -0.03874939f, 
    -0.03073563f, 0.02694569f, 0.17585157f, 0.12199132f, 0.01853383f, -0.03179929f, 0.07318235f, 0.06912853f, 
    -0.03874449f, -0.23476921f, -0.23962994f, 0.01822059f, -0.11022431f, 0.10975057f, -0.06569604f, 0.07352481f, 
    -0.02115026f, 0.03039760f, 0.14772095f, 0.09029529f, 0.04818778f, -0.03668909f, 0.02799258f, -0.08932536f, 
    -0.02655595f, -0.05185612f, 0.07514679f, 0.17236766f, 0.04066754f, 0.10286264f, 0.14200389f, -0.02667698f, 
    -0.29878923f, 0.07882923f, 0.13929509f, 0.13581371f, -0.03947065f, -0.05021787f, 0.14255156f, 0.19506723f, 
    0.04503050f, 0.11182842f, 0.07667584f, -0.07720494f, 0.13364159f, -0.03833024f, -0.07763676f, 0.02623189f, 
    0.13721733f, 0.05996248f, -0.06025336f, -0.01309829f, 0.00642541f, 0.10867519f, 0.13565025f, 0.02823428f, 
    -0.16093361f, -0.19254220f, -0.10818333f, 0.11927647f, -0.08267007f, -0.02277864f, -0.00931815f, 0.03991091f, 
    0.00060943f, -0.06129727f, -0.05600179f, -0.04522964f, 0.54006732f, 0.38273382f, -0.06984388f, -0.06653251f, 
    -0.01741857f, 0.08978364f, 0.19202350f, 0.05804074f, 0.01582500f, 0.23244783f, 0.15465318f, 0.18980184f, 
    -0.13713719f, -0.07717664f, 0.01132582f, -0.10981064f, -0.09559266f, 0.01948284f, 0.02006411f, -0.06130521f, 
    0.05282499f, 0.04035307f, 0.01733519f, 0.01850373f, -0.08318604f, -0.25818455f, -0.11259487f, -0.03492094f, 
    0.10541277f, -0.10603545f, -0.02295467f, -0.00452883f, -0.03894021f, 0.00172108f, -0.03536982f, -0.10661037f, 
    -0.11040176f, -0.26019880f, -0.09057294f, 0.18931161f, -0.06010896f, 0.11326552f, -0.09051347f, -0.11972713f, 
    -0.00125651f, -0.01719731f, 0.10003524f, 0.00793193f, -0.20718834f, -0.15529424f, -0.11430156f, -0.05284416f, 
    -0.05486204f, -0.05062686f, 0.00730864f, -0.00004006f, 0.00963085f, 0.20492674f, 0.01240246f, 0.11049893f, 
    0.04827756f, -0.01447952f, 0.00877522f, 0.04431361f, 0.04020505f, -0.05657225f, 0.12582518f, -0.02176179f, 
    -0.08208074f, 0.20329501f, -0.01083621f, 0.05889680f, -0.17659777f, -0.11917741f, -0.09435273f, 0.07227221f, 
    0.00209929f, -0.01648857f, -0.03457420f, -0.11509689f, -0.08145022f, 0.04113613f, -0.01351585f, 0.04366915f, 
    -0.06589185f, -0.57112545f, 0.40623194f, 0.35549283f, -0.02143390f, -0.22668938f, -0.00107877f, 0.03964038f, 
    0.03346005f, 0.17628440f, -0.04776587f, -0.07548275f, -0.10412620f, -0.10024460f, -0.16498297f, 0.02633091f, 
    0.06540240f, -0.00110630f, 0.05116674f, 0.11514405f, 0.00879332f, -0.00144463f, -0.03493530f, -0.00171237f, 
    -0.01663161f, -0.09711426f, 0.07944023f, 0.03968112f, -0.01582899f, 0.02707741f, 0.16471578f, 0.13526030f, 
    0.00206517f, 0.06352815f, 0.11097045f, -0.05465060f, 0.03843294f, 0.00411773f, -0.04474710f, -0.07018209f, 
    0.05439328f, 0.16147278f, 0.06763770f, 0.01579282f, -0.27040750f, 0.05980688f, 0.04399400f, 0.04401443f, 
    0.23116882f, -0.08401755f, 0.12167072f, -0.02059743f, 0.07037622f, -0.02081338f, -0.14056034f, 0.08464532f, 
    0.21947150f, -0.01234082f, 0.21625303f, 0.00969479f, -0.14587213f, -0.24308017f, 0.02126832f, -0.04308901f, 
    -0.07698430f, 0.03659587f, 0.01237407f, 0.04700569f, 0.06259049f, -0.01429658f, -0.03504665f, -0.06737253f, 
    0.20053908f, 0.22124986f, -0.04446022f, 0.00285691f, 0.01321795f, 0.19406939f, 0.23937321f, 0.07029042f, 
    0.01667358f, 0.01618543f, -0.03188304f, 0.05770491f, 0.12319262f, 0.15758036f, 0.08090714f, -0.00758686f, 
    -0.06967801f, 0.15839724f, 0.08557454f, -0.02758313f, 0.21493822f, 0.11230616f, 0.12416907f, 0.14535360f, 
    0.15408351f, -0.10474318f, -0.14036718f, -0.02745984f, -0.01197090f, 0.07733630f, -0.02035291f, 0.09656794f, 
    0.11814067f, 0.12832691f, 0.06189195f, 0.02862067f, 0.10172056f, 0.18152684f, 0.20404546f, 0.04737354f, 
    -0.00976460f, 0.00465894f, -0.05087585f, 0.00588850f, -0.01248774f, 0.02495838f, 0.05992744f, -0.04592621f, 
    0.10123203f, -0.00047297f, 0.07143914f, -0.01194112f, 0.04547237f, 0.14368714f, 0.09094941f, 0.11024126f, 
    -0.00923210f, 0.13612235f, 0.02877895f, -0.04961500f, -0.08827974f, 0.03665482f, 0.29853094f, 0.28613123f, 
    -0.00585754f, 0.06003132f, 0.22606525f, 0.28324091f, 0.05236183f, 0.04487285f, -0.02243281f, -0.03362570f, 
    0.00549386f, 0.06098767f, -0.06325906f, -0.09599317f, -0.02081070f, 0.00160008f, 0.22118655f, -0.06997192f, 
    -0.06829756f, -0.07755706f, -0.12362772f, -0.03319338f, -0.21349283f, 0.13621435f, 0.01850359f, -0.14843842f, 
    -0.03800614f, -0.03414430f, -0.16028354f, 0.03317223f, 0.03681925f, -0.17832866f, 0.13198642f, 0.11739114f, 
    -0.25848970f, -0.19206607f, 0.50601077f, -0.00947369f, 0.15850674f, 0.06419334f, -0.09384517f, 0.07662802f, 
    0.06713912f, 0.01459626f, 0.05290113f, 0.02763382f, -0.13925394f, 0.06816803f, 0.13362989f, 0.22893976f, 
    0.00941910f, -0.00985787f, 0.01158966f, 0.28143832f, -0.05879504f, 0.11320427f, 0.04446718f, 0.16639800f, 
    -0.16297306f, -0.18873648f, -0.14072682f, 0.07996654f, 0.12419426f, 0.18644692f, -0.05720528f, 0.04322925f, 
    -0.00126551f, 0.04114323f, 0.06753606f, 0.07547585f, 0.05226772f, 0.08287577f, 0.07435892f, 0.01396815f, 
    0.09505492f, 0.09834662f, 0.11384772f, 0.07027404f, 0.11993865f, 0.00934174f, 0.00768785f, 0.17038512f, 
    -0.28855988f, -0.26770321f, 0.20061617f, 0.02018441f, -0.13179882f, 0.03677093f, -0.23423752f, -0.03652205f, 
    -0.04172979f, 0.12225427f, 0.02595134f, -0.04364943f, 0.05270467f, 0.10395604f, 0.34126136f, 0.12826526f, 
    -0.08537433f, -0.06631894f, -0.02138872f, 0.02426034f, 0.07093213f, 0.04993894f, -0.08597563f, -0.05739597f, 
    0.05360737f, 0.17698659f, 0.09916982f, -0.04856386f, -0.05834152f, 0.00758185f, 0.22454633f, 0.05383763f, 
    0.10676385f, 0.09238370f, 0.06160519f, -0.04900552f, 0.35052109f, 0.10092406f, 0.05403036f, 0.04005042f, 
    -0.01077163f, 0.15458120f, 0.02702033f, 0.05268417f, -0.04172943f, 0.19935402f, 0.09878578f, 0.11433355f, 
    0.02554390f, 0.34271550f, 0.15099630f, -0.05845881f, 0.05841129f, 0.13108879f, 0.01592184f, 0.04206145f, 
    0.02116368f, 0.01977301f, 0.22529806f, 0.04483046f, -0.06107340f, -0.09924676f, 0.16710760f, 0.01492733f, 
    0.02249336f, -0.05462653f, 0.03379120f, 0.12675411f, 0.13395314f, 0.02264076f, 0.04047294f, -0.00382534f, 
    -0.13675059f, 0.03129951f, -0.12633598f, -0.06880212f, -0.11280449f, -0.10856216f, -0.13116060f, 0.05933056f, 
    -0.11155751f, 0.07754907f, 0.03440807f, -0.06157495f, -0.01160114f, 0.14222901f, 0.04696180f, -0.13487868f, 
    -0.01746806f, 0.00925360f, 0.01779988f, -0.05815069f, -0.00676153f, 0.04818586f, -0.01315360f, 0.00174000f, 
    -0.15557393f, 0.03812599f, 0.25492257f, 0.01633066f, 0.00634309f, -0.00313506f, 0.32745039f, 0.24256872f, 
    0.10752016f, -0.01659914f, 0.06205061f, 0.03088725f, -0.11613451f, -0.10634030f, 0.29529977f, 0.20751008f, 
    -0.10612586f, -0.00450206f, 0.07809782f, 0.12024903f, -0.10602467f, 0.09163314f, 0.11136974f, 0.01543273f, 
    -0.15327929f, 0.13146752f, -0.11828765f, -0.07238496f, -0.11036517f, -0.14386867f, -0.02224465f, 0.14807847f, 
    -0.02261543f, -0.01549268f, -0.10854183f, -0.06112486f, 0.40632200f, 0.24092133f, -0.04820784f, -0.01742123f, 
    -0.02965451f, 0.09874164f, 0.06498821f, -0.04662448f, -0.05678490f, 0.01843920f, 0.00335778f, -0.00911425f, 
    0.02883082f, -0.01647263f, -0.02091529f, 0.03186407f, -0.01957534f, -0.00905559f, 0.13039415f, 0.03438295f, 
    -0.00750056f, 0.05213403f, 0.01971068f, 0.17237674f, -0.19356667f, -0.14850157f, 0.08142388f, 0.08638740f, 
    -0.07504684f, -0.09218775f, 0.02086713f, -0.03187389f, 0.07387812f, 0.19578943f, 0.01342954f, -0.03735336f, 
    0.07850277f, 0.18605243f, 0.25373948f, 0.15349156f, 0.00821010f, 0.06259447f, 0.04037999f, 0.16921696f, 
    0.04041176f, 0.03920553f, 0.05712024f, -0.06648447f, 0.16947187f, 0.05326626f, 0.28072223f, 0.20889057f, 
    0.06086570f, 0.04888954f, 0.11955414f, -0.00351248f, 0.02929266f, 0.05361785f, 0.04376102f, 0.11389871f, 
    0.05981310f, 0.16706318f, 0.01508556f, -0.05955814f, -0.09033033f, -0.00882581f, 0.07523500f, -0.00892429f, 
    -0.06848656f, 0.10063750f, 0.13333338f, -0.00240037f, -0.24378087f, -0.18295382f, -0.04380417f, -0.12152607f, 
    -0.11148832f, -0.08084951f, 0.03168307f, -0.07686174f, -0.09561188f, 0.03373996f, 0.05475831f, -0.04334754f, 
    0.13866176f, 0.24730825f, 0.07989033f, -0.06428653f, -0.06639501f, -0.04492880f, 0.02417774f, -0.01876000f, 
    -0.01527824f, 0.06833194f, 0.13405962f, 0.17741141f, 0.13723853f, 0.07308575f, 0.13500786f, 0.15774299f, 
    -0.15041085f, -0.07062948f, 0.03474375f, 0.15613188f, 0.08732165f, 0.07403005f, 0.04926179f, 0.04938531f, 
    0.02590148f, -0.06739505f, -0.17478532f, -0.02382259f, 0.12275716f, -0.00257890f, 0.03994003f, -0.05470866f, 
    0.06788390f, 0.13140206f, -0.01011440f, 0.04068645f, -0.30962342f, -0.01818062f, 0.01884607f, 0.27412271f, 
    0.06471197f, 0.16409087f, 0.04505282f, 0.03231306f, 0.03902559f, 0.11206542f, 0.01429506f, 0.04286245f, 
    0.00047939f, 0.07007595f, 0.06611308f, 0.11482645f, -0.01674427f, -0.00094215f, 0.22299889f, 0.17868523f, 
    0.00663055f, 0.06640304f, 0.04339743f, -0.06498308f, -0.11523449f, 0.18036063f, 0.25133857f, 0.09926519f, 
    -0.09698608f, -0.03439355f, 0.01656007f, 0.07432036f, -0.00779359f, -0.01632619f, -0.01256450f, 0.07130432f, 
    0.16303386f, -0.06185608f, 0.31694579f, -0.18530180f, 0.12102892f, 0.13354380f, 0.02928882f, -0.01800587f, 
    0.06919505f, 0.00245429f, -0.01852648f, 0.10077493f, -0.23027894f, 0.35849479f, 0.03411744f, 0.14170446f, 
    -0.09592625f, -0.09709280f, -0.09660976f, -0.01196392f, -0.05770240f, -0.09816325f, 0.06267915f, -0.00007045f, 
    0.14561026f, -0.00318001f, 0.07312065f, -0.04323668f, 0.09634504f, -0.03590798f, -0.03201868f, -0.04978997f, 
    0.08237229f, 0.00796417f, -0.12073442f, -0.07118619f, -0.31156462f, 0.03759765f, -0.01914364f, -0.16841565f, 
    0.21488217f, -0.38107204f, -0.01736661f, -0.07555483f, -0.09528164f, -0.03063408f, -0.09859395f, -0.11284065f, 
    0.08024975f, -0.22178634f, 0.17686948f, 0.11302550f, 0.10526482f, 0.15229699f, 0.01385660f, -0.04930917f, 
    0.17480816f, -0.09509387f, -0.02577997f, 0.13402425f, -0.14079612f, 0.09203175f, 0.08241355f, -0.03748598f, 
    0.03235031f, -0.09564003f, -0.00891570f, 0.03383729f, -0.18998723f, -0.04485798f, 0.02629012f, -0.10746057f, 
    -0.19273540f, -0.15144721f, -0.32798204f, -0.15388124f, -0.12639436f, -0.14692652f, 0.04719730f, 0.06057910f, 
    0.05329379f, -0.04171173f, -0.02517770f, -0.02068207f, -0.08693887f, -0.00872623f, -0.04321627f, -0.13420959f, 
    0.00194058f, 0.07311229f, -0.04703050f, -0.11241525f, 0.00224820f, -0.05425331f, -0.05715374f, -0.01017193f, 
    0.00782477f, 0.03271118f, 0.23169561f, -0.10334378f, 0.13762020f, 0.12872440f, 0.03518831f, -0.00174064f, 
    0.07495039f, 0.16593485f, 0.13336487f, -0.09053285f, -0.00873736f, -0.11203574f, 0.07467066f, -0.04197701f, 
    0.14380245f, 0.02710661f, 0.15175688f, -0.16499619f, 0.03832061f, -0.16171762f, 0.06411509f, -0.15105228f, 
    -0.28218496f, -0.41518018f, 0.07379323f, 0.29144856f, 0.19004251f, 0.06184417f, -0.01645490f, 0.17742893f, 
    -0.05539782f, -0.02787360f, -0.03421712f, -0.06596144f, 0.11842074f, 0.06340838f, -0.03772949f, 0.00492848f, 
    0.17383203f, -0.09961815f, -0.23190287f, -0.01157263f, -0.13598938f, -0.05199840f, -0.11559644f, -0.01207083f, 
    -0.01239792f, 0.21352173f, -0.12689568f, -0.46663958f, -0.06317900f, 0.09689821f, -0.11756842f, -0.13219082f, 
    0.01263324f, -0.07150875f, 0.05993859f, 0.19572714f, -0.16356836f, 0.18672526f, 0.10583661f, 0.22212583f, 
    0.10199441f, -0.02149943f, 0.02640133f, 0.00938850f, -0.00337036f, 0.09710635f, -0.07034803f, -0.00823725f, 
    0.17266652f, 0.12425909f, 0.03628950f, -0.14475188f, -0.05298303f, -0.02811818f, 0.03914293f, 0.05374069f, 
    -0.06191713f, -0.00862630f, 0.00250170f, -0.03834369f, -0.29198653f, 0.12344681f, -0.03313116f, -0.12178723f, 
    0.13082957f, 0.22875035f, -0.00416032f, -0.01290194f, 0.11498784f, -0.07753415f, 0.26729903f, 0.15040399f, 
    0.17126584f, -0.20735024f, 0.24918987f, 0.06775443f, -0.10389213f, -0.05004319f, -0.00028030f, -0.04120226f, 
    -0.07331154f, -0.00250262f, -0.08962721f, -0.11173402f, -0.04366757f, 0.07519080f, -0.04105022f, -0.11625604f, 
    0.00959106f, -0.10675892f, 0.00379975f, 0.07132225f, -0.11246717f, 0.00237125f, -0.07378550f, -0.00763255f, 
    -0.04218763f, -0.03068064f, -0.11604147f, 0.06597451f, -0.10617650f, -0.11515430f, 0.10159981f, -0.03883978f, 
    0.04689411f, 0.05346118f, -0.00210040f, 0.01241173f, -0.18764976f, -0.04913963f, -0.03515966f, -0.07243471f, 
    -0.03560968f, -0.00485570f, 0.00931661f, 0.01191959f, 0.02429503f, -0.06519505f, -0.00773617f, -0.07840408f, 
    -0.08096145f, -0.06699158f, -0.03462683f, 0.24211803f, 0.01645103f, 0.16988750f, -0.05746440f, -0.01558984f, 
    -0.03140013f, 0.12810482f, 0.10362957f, 0.06207505f, -0.01717122f, -0.04408028f, -0.10962739f, -0.02468130f, 
    0.00098357f, 0.01779414f, -0.05929125f, 0.10650250f, -0.11785666f, -0.09648529f, -0.04128566f, -0.07387556f, 
    0.02005956f, -0.11099441f, 0.22971581f, -0.33203724f, 0.01362281f, -0.10212944f, -0.08996128f, 0.00596224f, 
    -0.00686414f, 0.14842273f, 0.04407731f, 0.12657066f, 0.11842687f, 0.05069572f, 0.10751743f, 0.12971909f, 
    0.16239440f, -0.05914314f, 0.01935926f, 0.03121201f, -0.05700314f, 0.06248678f, 0.10523204f, 0.12921318f, 
    0.03581286f, 0.07016609f, -0.00668221f, -0.02034417f, 0.02217717f, 0.01483606f, -0.05105749f, -0.00683411f, 
    -0.07530306f, -0.01794106f, -0.07491051f, -0.04708960f, 0.03554418f, 0.04268350f, -0.05632513f, -0.02465301f, 
    0.07835393f, 0.12922785f, 0.09712873f, -0.08082698f, 0.10924538f, -0.11505125f, -0.06372456f, 0.26649490f, 
    -0.22378898f, 0.13982427f, 0.03691338f, 0.20495813f, -0.03103184f, -0.03939131f, 0.11929697f, -0.02467896f, 
    0.08277591f, 0.09757917f, -0.08310176f, -0.02606235f, -0.05543976f, 0.04649907f, 0.14097746f, -0.18268345f, 
    0.05094279f, -0.01112258f, 0.13895920f, 0.02247451f, -0.02237821f, 0.06433313f, 0.02897646f, 0.09913792f, 
    0.39393258f, 0.36016095f, -0.16020492f, -0.10771263f, 0.09903731f, -0.15280108f, 0.02590450f, 0.06232688f, 
    -0.06650533f, -0.03777606f, 0.05136914f, 0.09461299f, -0.00415909f, -0.00145118f, 0.11398703f, 0.30186331f, 
    0.04659598f, 0.09957089f, -0.02076259f, -0.00984872f, -0.05597974f, 0.02353117f, 0.09994639f, -0.01553605f, 
    -0.49122936f, 0.02201147f, 0.02933720f, 0.07999936f, 0.10509446f, 0.03308861f, 0.02558364f, -0.03722693f, 
    0.11936227f, 0.16936730f, 0.02386845f, -0.02899948f, 0.35180601f, -0.02425611f, 0.10050995f, 0.22232637f, 
    -0.05681061f, -0.03313333f, -0.00989744f, 0.04190464f, -0.08244362f, 0.13591406f, 0.04229109f, -0.02999749f, 
    0.28303155f, 0.04688236f, 0.00976679f, -0.09823573f, 0.01686567f, 0.04669979f, 0.06111332f, 0.04914320f, 
    -0.07139616f, -0.06959166f, -0.05304235f, -0.03880041f, -0.00016238f, -0.22128044f, 0.08707470f, -0.33928508f, 
    0.11452875f, -0.04970986f, 0.16084111f, 0.22307274f, -0.08518209f, 0.05575437f, 0.12875023f, -0.13133414f, 
    0.19085909f, 0.13743246f, -0.13568920f, -0.03769943f, -0.03743699f, -0.06146409f, 0.14713709f, 0.00208558f, 
    0.09832239f, 0.10286831f, -0.03737634f, 0.16921693f, -0.20854476f, -0.08286516f, 0.13397804f, -0.09633698f, 
    -0.03082560f, -0.08910340f, -0.01417983f, -0.01389431f, -0.08079726f, 0.11026933f, 0.15270713f, -0.02129242f, 
    0.55569148f, -0.04911637f, -0.15812072f, -0.07031882f, -0.14943273f, 0.01034773f, 0.00280352f, -0.08654060f, 
    -0.03500335f, -0.01120438f, -0.05604761f, 0.12545937f, 0.07023253f, -0.23149855f, 0.13993622f, -0.04216482f, 
    0.02803600f, -0.12923454f, 0.13716224f, 0.10759868f, -0.04110634f, -0.01228172f, 0.06518700f, -0.02134268f, 
    -0.19314235f, -0.28540540f, -0.05889335f, 0.13112238f, -0.01446204f, -0.00029007f, 0.17377843f, 0.17525157f, 
    0.05647006f, 0.17709666f, 0.00752190f, -0.03204395f, 0.04147476f, -0.03502045f, 0.03280300f, 0.09183670f, 
    0.09418568f, 0.04697185f, 0.12654154f, -0.02239715f, 0.01985984f, -0.15973318f, 0.12228563f, -0.05327030f, 
    -0.17800757f, -0.14753510f, 0.10862143f, 0.08254927f, -0.04683604f, 0.00965346f, -0.06416096f, -0.04412528f, 
    0.10851904f, 0.05731312f, -0.03066089f, 0.11828001f, -0.01500478f, -0.06917789f, 0.15610197f, 0.18401001f, 
    -0.06149372f, 0.07935988f, 0.00363150f, -0.01774981f, 0.01564552f, 0.19191404f, 0.01939031f, 0.08193970f, 
    -0.09214643f, -0.10088696f, -0.00561978f, -0.03697855f, 0.09424339f, -0.02402916f, 0.24139164f, -0.15342130f, 
    0.04934934f, -0.03829660f, -0.05434455f, -0.05525854f, 0.09204577f, -0.10046127f, 0.10060967f, 0.14362988f, 
    0.30733064f, -0.10530043f, 0.10626829f, -0.00106355f, 0.09819766f, -0.09816679f, 0.02282601f, 0.01880935f, 
    0.29739410f, -0.04728115f, 0.28744411f, -0.08933391f, 0.02071064f, 0.06725845f, 0.04459167f, 0.01151858f, 
    0.07366098f, -0.01911986f, 0.09469998f, 0.12317302f, -0.21746668f, 0.21784475f, 0.09723184f, -0.23615165f, 
    0.02359174f, 0.07005529f, -0.09157529f, 0.07908209f, 0.11314597f, 0.07060013f, 0.17717393f, -0.01252011f, 
    0.17217770f, -0.13999957f, 0.16687354f, 0.37049812f, -0.04867133f, -0.01520693f, -0.02547823f, -0.06508557f, 
    0.05454880f, 0.02280255f, 0.07034625f, 0.01241845f, 0.26248980f, -0.02898956f, -0.06321041f, 0.01134204f, 
    -0.03861282f, -0.02465436f, 0.04181030f, -0.05872963f, -0.01189261f, 0.02709668f, -0.03080609f, -0.02849600f, 
    0.11170394f, 0.08939451f, 0.14721182f, -0.38337848f, 0.09680950f, -0.07958634f, 0.19629924f, 0.01754381f, 
    0.13798030f, 0.17458282f, -0.12416234f, 0.10312647f, 0.27423394f, -0.00037020f, 0.08651047f, -0.22834478f, 
    0.18264744f, 0.08412267f, 0.03291801f, 0.13847582f, -0.04169980f, 0.24925657f, -0.18436530f, 0.06085341f, 
    0.29650581f, 0.06523472f, 0.20979805f, -0.17313896f, -0.16966246f, -0.13730672f, 0.02064104f, -0.02039351f, 
    0.03884242f, 0.08026548f, 0.02785512f, 0.07551803f, 0.34002489f, 0.12724049f, -0.23169683f, 0.09527959f, 
    0.04868586f, 0.01437686f, 0.05317188f, 0.00703084f, 0.00087515f, -0.01556115f, 0.09204330f, 0.08441661f, 
    -0.12125193f, 0.14018789f, -0.00675548f, -0.09564879f, 0.06840171f, -0.06194394f, -0.10468143f, 0.00451182f, 
    -0.04391759f, -0.03837109f, -0.05431515f, -0.12189254f, 0.10668316f, -0.09078135f, 0.00615845f, -0.03730329f, 
    0.02278735f, 0.03881811f, -0.03017054f, 0.02425805f, -0.13386825f, 0.04651494f, 0.02341064f, 0.25226039f, 
    -0.03652708f, 0.27476645f, -0.21509010f, -0.22973996f, -0.08637549f, 0.08149005f, 0.07473405f, -0.03892210f, 
    0.00278208f, 0.12087248f, -0.01004157f, -0.12784772f, 0.30122447f, -0.12224058f, 0.10362934f, 0.11490849f, 
    -0.05379047f, 0.13416517f, 0.06530359f, -0.00776378f, 0.09127620f, 0.11127484f, 0.12178896f, 0.10291980f, 
    -0.02547463f, 0.06906536f, -0.03665335f, 0.03691598f, 0.04312737f, -0.04864236f, 0.07983546f, 0.03867740f, 
    0.15666530f, 0.27555627f, 0.03376004f, 0.14598830f, -0.16481505f, 0.22569355f, 0.10241000f, -0.23775543f, 
    -0.10064545f, -0.10861228f, -0.10637126f, -0.03141165f, -0.02723083f, 0.03029232f, -0.00177075f, 0.00368138f, 
    0.09154671f, 0.04497330f, 0.02281280f, 0.06768934f, 0.02027339f, -0.01604489f, -0.01479682f, 0.01722592f, 
    0.09056658f, 0.22454500f, 0.09867354f, 0.30296817f, 0.23983122f, 0.09872130f, 0.09182677f, -0.30901125f, 
    -0.01935090f, -0.15193503f, 0.02835882f, -0.05770968f, 0.05431036f, -0.00945424f, -0.07037766f, 0.02442381f, 
    -0.01687989f, -0.08541489f, -0.02475462f, 0.37244990f, 0.17087297f, -0.01456778f, 0.01099603f, -0.09273782f, 
    0.11307120f, 0.11403501f, 0.12953106f, 0.12460078f, -0.27115640f, -0.44626412f, 0.24745928f, -0.01249630f, 
    0.02828532f, 0.02643710f, 0.03227881f, -0.04323981f, 0.08483595f, 0.02943298f, 0.03176131f, -0.00018712f, 
    0.18830431f, 0.02188391f, 0.11396677f, -0.04720128f, 0.06825361f, -0.05604715f, 0.02376767f, 0.00311597f, 
    -0.08554760f, -0.05010187f, -0.08488853f, -0.18372650f, 0.37785548f, -0.05450544f, 0.05760054f, -0.09497054f, 
    -0.07673420f, -0.11962862f, 0.02578628f, 0.02731155f, -0.00267488f, 0.10804953f, 0.21669738f, 0.17202686f, 
    -0.01456226f, 0.01610781f, 0.04797442f, -0.20375365f, -0.16351976f, -0.09923704f, 0.07647941f, 0.05750553f, 
    -0.10677382f, 0.11510003f, 0.02716338f, -0.02638025f, 0.20222859f, 0.05245456f, -0.11881597f, -0.05245704f, 
    -0.06883721f, -0.13996668f, -0.17779215f, -0.08610988f, 0.10208575f, -0.06316811f, 0.01286377f, 0.08252825f, 
    0.11557090f, 0.07341692f, -0.19812213f, 0.13460512f, 0.04764888f, -0.01094738f, 0.06849298f, -0.14963323f, 
    0.00994546f, 0.09780243f, -0.11744779f, 0.04330641f, -0.10516694f, 0.29485929f, -0.15868556f, 0.16498962f, 
    -0.10890445f, 0.03231999f, 0.10642201f, 0.12444890f, 0.02117899f, 0.08288576f, 0.00187138f, 0.01171229f, 
    -0.20052756f, -0.02959955f, -0.18601213f, -0.10972250f, 0.02623764f, -0.00936029f, -0.01364119f, 0.09343932f, 
    -0.14071560f, 0.01581974f, 0.02593216f, 0.08591276f, 0.05084853f, -0.01785201f, 0.13123234f, 0.11550375f, 
    0.03778839f, -0.14157993f, -0.00823532f, 0.05921615f, 0.09758923f, 0.01507548f, 0.04289815f, 0.01261822f, 
    -0.07954551f, -0.32168928f, 0.28153118f, 0.29181677f, 0.07294892f, 0.07595485f, 0.08074329f, 0.04068490f, 
    -0.05238882f, 0.03433659f, -0.01889525f, 0.07460006f, -0.45725456f, -0.24238972f, -0.06458065f, -0.15669997f, 
    -0.00810598f, -0.17098771f, 0.05107753f, 0.01278444f, 0.06997250f, 0.03017713f, 0.05410082f, -0.01945045f, 
    0.08832557f, 0.30322331f, -0.31040415f, -0.22897659f, -0.00750056f, 0.10329445f, 0.00490332f, -0.06460091f, 
    0.12766273f, -0.02771093f, 0.19769184f, -0.24757569f, 0.14235049f, 0.08352628f, -0.05366497f, 0.07336892f, 
    0.09387167f, 0.14323033f, -0.06396062f, -0.06448476f, -0.02488306f, -0.00557581f, 0.01655665f, 0.05519242f, 
    0.10101478f, -0.35149580f, 0.23607713f, -0.02437891f, 0.14721195f, 0.13007303f, -0.15705317f, 0.16355945f, 
    -0.08321304f, -0.03600551f, 0.02067044f, 0.04717591f, 0.01822955f, -0.03143460f, 0.01994841f, 0.02214671f, 
    0.05070842f, 0.03993732f, 0.05176887f, 0.08466880f, 0.09667049f, -0.09593591f, -0.04240301f, -0.13886017f, 
    -0.16024105f, 0.01817069f, -0.04066793f, -0.29820502f, -0.02182255f, 0.00129760f, 0.08665726f, 0.02122519f, 
    -0.05686355f, -0.12982766f, -0.10549485f, 0.10220947f, 0.14334995f, -0.18173195f, 0.26467210f, 0.07957894f, 
    -0.02875143f, -0.09914000f, 0.01877378f, -0.06955730f, -0.07267261f, -0.04976713f, -0.08114207f, 0.03653113f, 
    -0.01436162f, 0.01159141f, 0.17156667f, 0.09131446f, 0.07658429f, 0.09045998f, 0.01800026f, 0.24859548f, 
    -0.00679451f, -0.03231781f, 0.13907307f, -0.05609085f, -0.22132821f, 0.20027746f, -0.30653119f, -0.07636528f, 
    0.02404537f, 0.01526257f, 0.21498898f, -0.11779974f, 0.05841826f, -0.11688562f, -0.00577975f, 0.03639023f, 
    0.17952797f, -0.07731173f, 0.19772243f, -0.01130021f, 0.15684846f, 0.01364386f, -0.03892320f, 0.00201085f, 
    -0.01937809f, 0.07159209f, -0.12054528f, -0.01255178f, -0.14957185f, -0.11186433f, 0.10314436f, -0.06718419f, 
    -0.08274576f, -0.10753513f, 0.04423594f, 0.06750160f, 0.04759238f, 0.01832742f, 0.07985841f, -0.02113261f, 
    -0.24681976f, -0.18772687f, 0.24057145f, 0.12364727f, -0.04727225f, 0.00129874f, -0.12479806f, 0.05169470f, 
    -0.01174583f, 0.02075431f, -0.04568722f, 0.07928947f, 0.00073227f, 0.21367542f, 0.04352153f, 0.12346399f, 
    -0.03540789f, 0.02439168f, -0.08561736f, 0.03804039f, 0.01282225f, -0.03544066f, 0.11497930f, 0.09106185f, 
    0.03784460f, -0.12390175f, 0.07020809f, 0.10059080f, 0.06625455f, -0.02285093f, -0.07718910f, -0.11918914f, 
    0.11325157f, 0.12160940f, -0.07653259f, -0.01216769f, 0.04338539f, 0.12322247f, 0.10934942f, 0.03951834f, 
    0.04008118f, 0.07382862f, -0.00447993f, 0.04843095f, 0.05901084f, 0.06430950f, 0.12463854f, -0.16213658f, 
    -0.31533405f, -0.19023882f, -0.10431151f, -0.20424104f, 0.18967137f, -0.02885623f, -0.03740611f, 0.13614222f, 
    0.01261324f, 0.06767806f, -0.00565171f, 0.07428882f, -0.20053136f, -0.04341434f, -0.08570030f, -0.01250865f, 
    0.04143290f, -0.04761785f, 0.01690647f, -0.01781494f, -0.08812213f, 0.01180761f, -0.05812388f, 0.12311170f, 
    -0.01787167f, 0.04055609f, -0.02417792f, 0.08376464f, -0.04376812f, 0.07033057f, 0.05768396f, 0.00750389f, 
    0.12638126f, -0.01053919f, -0.02687558f, -0.03684505f, 0.11509259f, -0.02319735f, -0.21882540f, 0.28554028f, 
    0.00017861f, 0.00237838f, 0.15063648f, -0.11868894f, 0.19029094f, 0.09222791f, 0.07016078f, 0.16555707f, 
    0.18520845f, 0.00004727f, 0.18019067f, 0.01354562f, -0.05927601f, -0.03358108f, -0.11488470f, 0.12940751f, 
    -0.24331437f, -0.05936880f, -0.16169605f, -0.05330643f, -0.27264887f, -0.09885520f, -0.06699388f, -0.05234534f, 
    0.00443297f, -0.03728704f, 0.06948771f, 0.15539837f, 0.01641474f, 0.02108061f, 0.06865699f, 0.05466703f, 
    -0.06785712f, -0.03563763f, -0.20146503f, 0.13132225f, 0.04028583f, -0.00978232f, 0.08693358f, 0.11187508f, 
    -0.00681716f, -0.05785513f, 0.03403498f, 0.01541410f, 0.15986575f, 0.12800919f, 0.08111142f, 0.07199343f, 
    0.07175239f, -0.01980600f, -0.07274898f, -0.08223117f, -0.03010912f, 0.06491370f, -0.01259567f, -0.12751263f, 
    -0.36113966f, -0.08759116f, 0.05710097f, 0.13599834f, -0.04556837f, -0.11208165f, -0.11525413f, -0.02839604f, 
    0.01676581f, -0.05231153f, -0.02452146f, -0.04582846f, 0.14582412f, 0.00571002f, -0.05826745f, -0.13120870f, 
    0.06049520f, 0.01443391f, 0.01006513f, -0.00088743f, 0.07195232f, -0.01836617f, 0.01249151f, -0.12015623f, 
    0.11002393f, 0.06037804f, -0.11965082f, 0.05397048f, 0.10086896f, 0.05605945f, -0.01972115f, 0.06761038f, 
    -0.02007685f, -0.04447084f, -0.05771423f, -0.06115635f, 0.07343075f, -0.08625698f, -0.13649143f, -0.22119640f, 
    0.02152011f, 0.02670918f, 0.11473703f, 0.10764982f, 0.01535368f, 0.08061336f, 0.05350637f, -0.01904239f, 
    0.29769966f, 0.03349688f, -0.23309217f, 0.14821176f, -0.10074480f, 0.03152186f, 0.19223057f, 0.15190804f, 
    0.00931702f, 0.17422283f, 0.03452254f, 0.12216395f, 0.11208472f, 0.07854524f, 0.09542579f, -0.09571844f, 
    0.07154719f, -0.14781651f, -0.11425079f, 0.00907645f, 0.02172216f, 0.01600613f, 0.13306537f, 0.03816396f, 
    0.39215976f, 0.57367963f, -0.08734769f, 0.22537252f, 0.01186944f, 0.06399433f, 0.13407609f, 0.01742441f, 
    0.07562891f, -0.00461101f, -0.01229403f, -0.07228990f, 0.10969709f, -0.13897239f, -0.04320183f, 0.06270944f, 
    0.07997763f, 0.01175123f, 0.04608018f, 0.10218610f, -0.00398520f, 0.01345138f, 0.23019819f, 0.01275678f, 
    -0.09508295f, -0.00854510f, 0.41708332f, 0.13532993f, 0.11027805f, 0.09756579f, -0.05549220f, 0.08476639f, 
    0.06586517f, 0.06996001f, -0.02753069f, 0.04875268f, 0.03779482f, -0.03019429f, 0.02182823f, 0.01374911f, 
    0.09844057f, -0.09309751f, 0.02117446f, 0.03330047f, 0.07431973f, 0.03808006f, -0.11490068f, -0.10779826f, 
    -0.21051708f, 0.03892808f, 0.29322246f, -0.03648931f, 0.10670688f, 0.05319564f, -0.19508405f, 0.08254963f, 
    0.16432786f, -0.02180209f, 0.05140252f, 0.12081704f, 0.04273169f, 0.02696878f, 0.14921385f, 0.26688853f, 
    0.02455002f, 0.03459213f, -0.01447468f, -0.13497382f, 0.03183474f, 0.12308855f, -0.18600591f, -0.02363977f, 
    0.01292117f, -0.06326866f, -0.15918447f, 0.14098708f, -0.05672780f, 0.02080897f, 0.08664446f, -0.14757986f, 
    -0.14572605f, 0.10652035f, -0.07400290f, -0.00973292f, -0.13885960f, 0.11107591f, -0.07644114f, 0.13149935f, 
    -0.03790354f, -0.03541645f, -0.02341605f, -0.09397669f, -0.00857200f, 0.13455310f, -0.22671928f, 0.08212366f, 
    0.19505051f, 0.08657948f, -0.04537076f, -0.00465887f, 0.03756663f, -0.04622169f, -0.05305190f, 0.04184339f, 
    -0.01174593f, 0.05808057f, 0.06744507f, -0.19609654f, -0.22603166f, 0.15507047f, 0.13547435f, -0.17405963f, 
    0.01647610f, -0.08549425f, 0.03901073f, 0.04463583f, 0.02993789f, -0.03107511f, 0.18603833f, -0.00412006f, 
    0.07429952f, -0.10375692f, 0.07900066f, 0.02738778f, -0.03794686f, -0.11141862f, -0.13751628f, 0.00999843f, 
    0.06415899f, 0.08725277f, -0.03211088f, -0.00119597f, 0.28418511f, -0.05498640f, -0.06208502f, 0.04983383f, 
    0.07919294f, 0.01780992f, 0.00281040f, -0.01420493f, 0.07922328f, 0.01696446f, -0.03738411f, -0.06524065f, 
    0.08635402f, 0.37747049f, -0.33885962f, 0.05291317f, -0.00738740f, -0.00337511f, 0.10302445f, -0.07338265f, 
    0.11820033f, -0.00066623f, 0.04275303f, 0.03465601f, 0.00280883f, 0.08538676f, 0.27097952f, -0.00833368f, 
    0.07313075f, 0.07593146f, 0.06270522f, -0.02540066f, 0.00628259f, 0.02619772f, 0.14128761f, 0.04989796f, 
    0.09049521f, 0.02488869f, -0.01378661f, -0.23566884f, -0.09685104f, -0.08971342f, -0.08641154f, 0.17560165f, 
    -0.01291100f, -0.12237576f, 0.06688870f, -0.00291403f, 0.26801935f, -0.07320650f, -0.29509029f, 0.24372798f, 
    -0.01665977f, 0.01999949f, -0.10797390f, -0.01572718f, 0.01811837f, -0.01110785f, -0.01023558f, -0.02879431f, 
    0.16339684f, 0.09512636f, 0.06147094f, 0.04202395f, -0.12399130f, 0.03693633f, 0.05907773f, -0.03926844f, 
    0.04695987f, -0.01490730f, -0.10704172f, -0.12524843f, -0.18578669f, -0.10520927f, -0.15796329f, -0.19718012f, 
    0.06342630f, -0.05574452f, 0.12642647f, 0.04970996f, -0.10964464f, 0.04996315f, 0.00240377f, 0.12017380f, 
    -0.12390013f, 0.05443083f, -0.04866883f, -0.03562411f, 0.09868953f, 0.01502925f, -0.05769426f, 0.14558019f, 
    0.11441707f, 0.00568377f, 0.11872692f, -0.07891490f, 0.16266835f, -0.09486456f, 0.21662408f, -0.00591538f, 
    0.06777998f, 0.02583345f, -0.01247904f, -0.07136655f, 0.13812046f, 0.06714400f, -0.00667211f, 0.06243197f, 
    0.23759545f, 0.15745385f, 0.00617970f, 0.05629974f, -0.02642601f, -0.01372346f, 0.04770879f, -0.06776926f, 
    0.18617575f, 0.13584635f, 0.11907274f, 0.11159933f, -0.30090752f, 0.31637421f, 0.24404268f, -0.14719906f, 
    -0.06815565f, 0.00346989f, 0.09815580f, -0.01617474f, 0.06729063f, 0.06207936f, 0.03942188f, 0.01645686f, 
    0.24731220f, -0.00109987f, 0.08066172f, 0.18244965f, -0.02633574f, -0.05011445f, 0.02285756f, -0.00531552f, 
    0.17306887f, 0.06389517f, 0.25899523f, 0.27407041f, 0.34056509f, 0.05704877f, 0.07747887f, -0.27247953f, 
    -0.07396775f, -0.18517271f, -0.16833118f, -0.01774716f, 0.02800166f, -0.02027007f, 0.03689303f, 0.13758224f, 
    -0.25990435f, -0.08512793f, 0.08904494f, 0.03879075f, -0.03899215f, -0.00438575f, 0.09991616f, 0.00656950f, 
    0.06210549f, 0.08840848f, -0.09302431f, 0.12686346f, 0.02649728f, -0.49389753f, 0.38993776f, -0.00931985f, 
    -0.08462376f, 0.25240609f, -0.09298705f, 0.06145826f, -0.13413824f, 0.04023685f, -0.07381100f, -0.01668881f, 
    0.21055523f, -0.05869822f, 0.05181827f, -0.17375252f, -0.11690488f, -0.15040760f, 0.05107496f, 0.04882272f, 
    0.08289319f, 0.05712784f, 0.05625930f, -0.00565174f, 0.19473954f, -0.02943136f, 0.15880488f, -0.13794474f, 
    0.02686836f, 0.00186057f, -0.04880633f, 0.04614571f, -0.00358454f, 0.09683470f, 0.03951175f, -0.03592243f, 
    0.06212399f, -0.15613164f, -0.24814005f, 0.07599220f, -0.06324310f, -0.01918112f, 0.25466910f, 0.06134373f, 
    0.07614607f, -0.12205072f, 0.06933320f, 0.05175181f, 0.00355965f, -0.07938267f, 0.12965637f, -0.08842153f, 
    0.08721964f, 0.13664506f, -0.14371349f, 0.04400377f, 0.09124281f, 0.12598686f, 0.05600236f, 0.08744187f, 
    0.09154540f, 0.14953876f, -0.00899408f, -0.04506833f, -0.05025369f, -0.05861915f, 0.04322924f, -0.10337803f, 
    -0.04772469f, 0.11499283f, 0.04296746f, -0.11652033f, 0.21791843f, -0.16534579f, -0.20499085f, -0.00208001f, 
    0.04479220f, 0.00311081f, -0.02359685f, 0.08017932f, -0.07324588f, 0.03642364f, -0.09883613f, -0.01841664f, 
    -0.10496320f, 0.16636479f, -0.33261392f, 0.19016688f, -0.03121609f, 0.00207874f, 0.22743458f, 0.05882990f, 
    0.09816577f, -0.02564433f, 0.00483896f, 0.04853555f, 0.09153594f, -0.13464960f, -0.16750495f, -0.04516771f, 
    -0.02687071f, -0.14015287f, -0.06178407f, 0.05102008f, 0.04364761f, -0.05140007f, 0.05075393f, -0.05856889f, 
    0.12245411f, 0.02560734f, -0.09738196f, 0.14147931f, -0.02605002f, -0.04683341f, 0.02858295f, -0.11484835f, 
    -0.06300320f, -0.06244042f, -0.11800060f, -0.04307058f, 0.31627768f, -0.29448316f, -0.15510993f, 0.05303588f, 
    0.01066301f, 0.15198530f, -0.02599653f, -0.00067537f, -0.05639312f, 0.00381856f, 0.04306873f, 0.07711714f, 
    0.29832730f, 0.22737986f, -0.21500899f, 0.01874095f, 0.06004344f, 0.02411401f, -0.08325141f, 0.13592228f, 
    -0.08038392f, -0.00602115f, 0.08735377f, -0.00298974f, -0.17617595f, -0.04377522f, 0.04554252f, 0.03579577f, 
    0.25254112f, -0.09286550f, -0.01759655f, 0.00380928f, -0.00421487f, 0.17594787f, -0.11139710f, 0.05066719f, 
    0.05892147f, 0.26273024f, -0.30130616f, -0.23421803f, 0.14938243f, 0.09889875f, -0.16695671f, -0.20094787f, 
    -0.16631509f, -0.08449829f, 0.00812334f, 0.10037836f, -0.07122804f, -0.11980628f, 0.03370701f, 0.05673063f, 
    0.15873295f, -0.03577767f, 0.06834041f, 0.12109888f, 0.08759036f, -0.14973536f, 0.06166424f, -0.15163679f, 
    -0.17433144f, -0.20381948f, -0.05904673f, 0.24416324f, 0.10273007f, -0.05766037f, 0.10532546f, 0.10481258f, 
    -0.01080912f, 0.09747188f, -0.11676571f, 0.13067400f, 0.01089463f, 0.13062781f, 0.08013076f, -0.20222363f, 
    0.11857115f, -0.30296022f, 0.02458761f, -0.02866774f, 0.07368694f, 0.01129356f, 0.15535496f, -0.00178661f, 
    -0.15415873f, -0.21913746f, -0.06841615f, -0.02128635f, -0.05193095f, 0.01086575f, 0.00736585f, -0.06712148f, 
    -0.01437936f, 0.02411037f, -0.04974553f, 0.02323066f, 0.52948666f, 0.08628120f, 0.14195426f, -0.08233202f, 
    -0.15203835f, 0.16362892f, -0.18613344f, 0.08898357f, 0.14736111f, 0.04740391f, 0.17796879f, 0.03783669f, 
    -0.26224115f, 0.36169201f, 0.04777022f, 0.04191159f, 0.20144063f, -0.05311626f, -0.04776603f, -0.07521639f, 
    -0.07150653f, -0.03026720f, -0.00836593f, -0.02366200f, 0.19123358f, -0.35042995f, -0.09321843f, 0.00756278f, 
    0.08884851f, -0.10451411f, 0.01845106f, -0.00188605f, -0.06470216f, 0.05475486f, 0.03849981f, 0.09465198f, 
    -0.07117151f, 0.07111506f, -0.15020430f, 0.04204744f, 0.02316080f, 0.02397960f, 0.02768872f, -0.02572084f, 
    -0.03929771f, 0.07332495f, 0.05855899f, -0.02078089f, 0.10473180f, -0.14725307f, -0.21225978f, -0.01154201f, 
    0.10549945f, 0.04589226f, 0.02805840f, 0.07578614f, -0.03186366f, 0.17110844f, 0.05049372f, 0.14569430f, 
    -0.05812269f, -0.00943584f, 0.11521024f, -0.23773310f, 0.04591367f, 0.09456300f, -0.01513240f, -0.07206259f, 
    0.05097496f, -0.00910901f, 0.06360855f, 0.14005184f, -0.11391374f, -0.19461177f, -0.23633935f, 0.03902715f, 
    0.08271598f, -0.09288462f, 0.01932559f, -0.06372406f, -0.05170075f, 0.08430295f, -0.15525506f, 0.11881365f, 
    0.35564741f, -0.35115144f, -0.33310637f, 0.16443314f, 0.14800973f, 0.05281418f, 0.05865248f, 0.14129248f, 
    -0.05965357f, 0.11042189f, 0.10679837f, 0.20003939f, 0.10447204f, -0.28576586f, -0.12350652f, 0.08207735f, 
    0.04967997f, 0.03917625f, 0.09072647f, 0.01437993f, 0.02298990f, 0.04237345f, 0.12682100f, 0.21003255f, 
    -0.02162688f, -0.10790554f, -0.06844656f, 0.08810230f, -0.04214608f, -0.10995239f, -0.02508219f, -0.01438445f, 
    -0.01059807f, 0.12154639f, 0.07920211f, -0.25220338f, -0.01140056f, -0.11332395f, 0.19004302f, 0.03365066f, 
    -0.06792364f, 0.26901293f, 0.02169132f, -0.10841591f, 0.03866426f, 0.16542782f, -0.09510868f, 0.00834505f, 
    0.03773351f, 0.21922837f, -0.01327696f, -0.10398730f, 0.19788565f, -0.24866177f, 0.10915311f, -0.05804260f, 
    -0.00124595f, 0.10656404f, 0.12248180f, 0.14805406f, -0.03556213f, -0.27430677f, -0.21906802f, 0.07103110f, 
    -0.02915690f, -0.04699674f, -0.06107423f, 0.05318367f, 0.00405427f, 0.05637140f, 0.00141823f, 0.13577420f, 
    -0.03012837f, -0.15491855f, 0.23952897f, 0.20744327f, 0.15828486f, 0.06255558f, 0.10186227f, -0.11352037f, 
    0.03659795f, -0.10602853f, 0.08197762f, 0.04223752f, 0.07463827f, 0.32177049f, -0.00448830f, -0.29715696f, 
    0.01277580f, 0.05025212f, -0.02968072f, -0.00934496f, 0.14970717f, -0.04769069f, 0.11210875f, 0.11630253f, 
    0.23250997f, -0.10689449f, -0.14290507f, -0.08361568f, -0.02801604f, -0.10496496f, 0.14028934f, 0.10800771f, 
    -0.03652056f, 0.04041641f, 0.16814601f, -0.01452563f, -0.22997232f, 0.13305116f, 0.07078367f, 0.02156020f, 
    0.00990785f, -0.07753012f, -0.06800993f, 0.02874672f, 0.03001392f, 0.11676386f, -0.11640643f, 0.10982241f, 
    0.27866974f, -0.02902467f, -0.00342739f, 0.02706900f, 0.08037802f, 0.05357500f, -0.09492236f, -0.01908091f, 
    0.03471546f, 0.11047667f, -0.19003773f, -0.06751505f, -0.13581628f, -0.01414055f, -0.02954594f, 0.43964761f, 
    0.08704669f, 0.06337194f, 0.05680452f, -0.02594553f, 0.13681358f, 0.09964619f, 0.15775697f, -0.15057690f, 
    -0.06103312f, -0.17840312f, 0.19151208f, 0.30267888f, -0.11773945f, 0.01142427f, 0.30431494f, -0.00733236f, 
    0.20596732f, 0.19760709f, -0.13580090f, 0.03963848f, -0.11109626f, 0.10554110f, -0.08735296f, -0.11188368f, 
    0.04222063f, 0.00474870f, -0.02449384f, 0.12478448f, 0.06953459f, 0.02962257f, 0.02386091f, 0.07862335f, 
    -0.22687146f, -0.12167645f, 0.43671855f, 0.26661849f, 0.26477894f, 0.12966904f, 0.19509408f, -0.10299797f, 
    0.00709920f, -0.09529376f, 0.00051438f, 0.10728095f, -0.15031247f, -0.07423115f, -0.01490401f, 0.03231570f, 
    0.10023405f, -0.14431027f, -0.01747257f, 0.20823430f, 0.12316301f, 0.01014621f, 0.16420180f, 0.14490220f, 
    0.10943682f, -0.01987137f, -0.14180890f, 0.10053063f, 0.02629228f, 0.10886256f, 0.03281465f, 0.05430320f, 
    0.01391623f, 0.09458942f, 0.10134757f, 0.11544049f, -0.01160444f, 0.02240307f, -0.03740431f, -0.04167753f, 
    0.00383272f, 0.08556417f, -0.08652280f, -0.09231775f, 0.05589235f, -0.11813807f, -0.00909198f, -0.13246541f, 
    -0.14864498f, -0.14965349f, -0.01685276f, -0.08617343f, 0.03736366f, 0.16583295f, 0.02558464f, -0.06344550f, 
    -0.09978868f, 0.06621978f, 0.03946700f, 0.12421291f, -0.02996534f, 0.07983838f, 0.21950771f, 0.11726085f, 
    0.02992514f, -0.03651941f, 0.05876802f, -0.11084408f, -0.02238458f, 0.07920964f, -0.04378426f, -0.01238495f, 
    -0.00914736f, 0.13447851f, 0.09659625f, -0.12084644f, -0.13724102f, -0.08754227f, 0.02515087f, -0.15573850f, 
    0.09358747f, -0.11494808f, -0.06930664f, 0.07895938f, 0.39779434f, -0.00866791f, -0.12008399f, -0.23261990f, 
    -0.05277929f, -0.09615140f, -0.06596635f, 0.04485500f, -0.09204180f, -0.02978806f, 0.07206253f, -0.00633592f, 
    0.10962670f, 0.14837855f, 0.03454482f, -0.01426258f, -0.00039154f, -0.13609858f, 0.02975607f, -0.00687231f, 
    -0.02023525f, 0.14561205f, 0.08355063f, -0.00809160f, -0.02259191f, -0.11388570f, 0.01506505f, 0.05810500f, 
    -0.04938624f, 0.08035571f, 0.02160948f, 0.02430403f, 0.00915321f, 0.02710339f, 0.01635667f, 0.16295475f, 
    -0.21960749f, 0.25804266f, -0.26175326f, -0.17609051f, 0.10098764f, 0.02571096f, -0.02363009f, 0.01886751f, 
    -0.22820470f, 0.03680711f, -0.00206212f, 0.08561394f, -0.26177162f, 0.17599669f, 0.11963357f, 0.02757102f, 
    -0.00999307f, -0.03125427f, -0.07555675f, -0.03924970f, -0.09402367f, 0.11353725f, -0.08182086f, -0.01739866f, 
    -0.20301566f, -0.06403988f, 0.09488577f, 0.23926547f, -0.04460120f, 0.02014641f, 0.09685444f, 0.07210344f, 
    0.04162838f, 0.19390061f, -0.10028521f, 0.13411002f, -0.22696128f, -0.02468607f, -0.16667394f, 0.23819779f, 
    -0.04408526f, -0.05301244f, 0.02484339f, -0.04514534f, -0.03694474f, 0.11404269f, 0.08372387f, 0.04301646f, 
    -0.14366156f, -0.15677232f, -0.12350015f, 0.19496433f, 0.07564919f, 0.05604835f, 0.08119969f, 0.00133926f, 
    0.05094812f, 0.03899581f, -0.00214838f, 0.21328479f, 0.27178606f, 0.06302656f, 0.25894052f, -0.05541915f, 
    -0.03780900f, 0.08283310f, -0.00750080f, -0.01678698f, -0.02006623f, 0.03641947f, -0.05195403f, -0.04177195f, 
    0.19548836f, -0.02602074f, -0.05290670f, -0.02104175f, 0.05574045f, -0.14619085f, 0.10877974f, -0.06452485f, 
    0.11205260f, 0.20956686f, -0.11018171f, -0.07289638f, -0.02788419f, 0.00575822f, -0.08303711f, 0.07531897f, 
    -0.05694075f, 0.07735300f, 0.06672494f, 0.09108854f, 0.00863492f, 0.12209466f, 0.05738619f, 0.03043064f, 
    0.04795700f, 0.01056177f, 0.07628976f, 0.32581693f, -0.03757207f, -0.04022834f, -0.12507981f, -0.00525902f, 
    -0.00075797f, 0.15268467f, 0.03597442f, -0.12874818f, -0.10270608f, 0.22132015f, -0.05501107f, 0.19338843f, 
    0.10353275f, -0.04316425f, 0.05282845f, -0.13816990f, 0.01845959f, 0.16142792f, -0.04396921f, -0.03277026f, 
    -0.11951018f, 0.08428652f, -0.02385708f, -0.05496288f, -0.07184722f, -0.03766619f, -0.00433926f, 0.05707639f, 
    -0.04757912f, 0.32297781f, 0.08346003f, 0.03433581f, -0.02176094f, -0.10163284f, -0.23440582f, -0.02666451f, 
    0.10956476f, -0.12235593f, -0.04140277f, -0.01669283f, 0.01507350f, 0.09566975f, -0.04436410f, -0.09747169f, 
    -0.09529533f, 0.05381509f, 0.10362308f, 0.02850692f, -0.03891948f, -0.03876628f, 0.00731070f, 0.00610030f, 
    0.04572875f, 0.08708473f, 0.22711667f, 0.20454170f, -0.09934916f, -0.01929163f, -0.04147649f, 0.16787171f, 
    0.06074662f, -0.02690440f, -0.03484933f, -0.00423723f, 0.05718894f, -0.00353316f, 0.05612488f, 0.00940325f, 
    0.16743676f, -0.13941267f, -0.03179015f, -0.09748219f, 0.00559803f, 0.09015598f, 0.04095000f, 0.01461744f, 
    -0.03616573f, 0.11571927f, 0.14635661f, 0.06851721f, -0.16344917f, 0.19032434f, -0.11114295f, 0.34830123f, 
    0.06458768f, 0.03608334f, 0.05605097f, -0.02703809f, -0.09654021f, -0.08033036f, -0.06494456f, 0.16553496f, 
    -0.05409398f, 0.07425755f, -0.11080446f, 0.09795777f, 0.11682243f, -0.10378430f, 0.17033796f, -0.00893314f, 
    0.01036439f, -0.13503075f, -0.01220914f, 0.04896915f, -0.42502269f, 0.21017362f, -0.11592036f, 0.05829890f, 
    0.01754712f, 0.14078233f, -0.04065137f, -0.02975062f, 0.05973386f, 0.03828925f, 0.10125540f, 0.00362503f, 
    0.01261312f, 0.02828051f, -0.03371546f, -0.00325902f, -0.00084062f, 0.02874671f, 0.01331598f, 0.02391208f, 
    -0.03036431f, 0.00812387f, -0.02102752f, -0.03816332f, 0.00293546f, 0.01309565f, 0.01853408f, 0.00879621f, 
    -0.00313703f, -0.02233163f, 0.00418595f, -0.01968843f, -0.01470962f, 0.01720148f, -0.02910214f, 0.02546313f, 
    0.01857675f, -0.02391723f, -0.00270644f, -0.03766783f, -0.00777575f, 0.00034830f, 0.02673670f, -0.01310923f, 
    0.02731225f, -0.04147780f, -0.01139621f, 0.02749344f, 0.00235378f, 0.02743032f, -0.02607395f, 0.01631069f, 
    -0.02511191f, -0.00986698f, -0.03352962f, 0.00443122f, -0.04033242f, -0.02562409f, 0.01460378f, 0.00762536f, 
    -0.00343547f, -0.04259622f, 0.01649134f, -0.02330215f, -0.02691256f, 0.02869665f, 0.01683576f, 0.02310068f, 
    0.01875466f, 0.02050536f, 0.02252352f, 0.00558910f, 0.01944156f, 0.01817599f, 0.01281722f, 0.01781191f, 
    -0.03224699f, -0.00229940f, 0.00623871f, 0.02407775f, -0.02695816f, 0.02111874f, 0.01394603f, 0.00012189f, 
    -0.03759120f, -0.02459502f, 0.00943890f, 0.00598352f, -0.00241018f, 0.01831069f, -0.00243360f, -0.01808044f, 
    0.00585455f, 0.02761670f, 0.01936174f, -0.03456414f, 0.02333507f, 0.02408544f, 0.02111975f, -0.01947502f, 
    -0.02202374f, 0.02195001f, -0.01082123f, -0.01783655f, 0.00256973f, -0.00363041f, 0.00964512f, 0.00391274f, 
    -0.00985933f, -0.03668184f, -0.03332525f, -0.03931882f, -0.00545815f, -0.03679550f, -0.03489224f, -0.00431957f, 
    -0.01062352f, -0.03232761f, -0.02286234f, -0.02034205f, -0.03317082f, -0.03358310f, 0.01314121f, 0.01942685f, 
    -0.00883453f, 0.00937381f, -0.03625616f, 0.02457007f, -0.04274056f, -0.01976946f, -0.02045347f, -0.01582595f, 
    0.01069190f, -0.03866422f, -0.03698054f, -0.00705826f, -0.03154890f, -0.02963435f, -0.00022067f, 0.01436509f, 
    -0.01174045f, -0.03343432f, 0.02667747f, -0.00462960f, 0.00746493f, 0.02327367f, 0.01430552f, -0.00353267f, 
    -0.01758820f, 0.00388411f, -0.01257555f, 0.01396754f, -0.01312487f, -0.02833390f, 0.02771743f, -0.03193017f, 
    -0.02423276f, -0.01314704f, 0.00846260f, 0.01445379f, 0.02388827f, -0.01537394f, -0.01239647f, 0.01715727f, 
    -0.01941056f, 0.02789987f, -0.03432709f, -0.02451154f, 0.03708792f, -0.01642799f, 0.01699738f, -0.01213517f, 
    0.01922379f, 0.01830641f, 0.02690063f, -0.01410888f, -0.01853193f, -0.02404713f, -0.02820164f, -0.01858853f, 
    -0.00627907f, -0.00736371f, 0.01566288f, -0.02683932f, -0.00888873f, -0.00237656f, 0.01669838f, 0.02672872f, 
    0.01387029f, -0.02552291f, -0.03016949f, -0.03323996f, -0.01306928f, -0.03744982f, 0.00331834f, -0.02338788f, 
    -0.00596692f, -0.04098608f, -0.03303530f, -0.02375725f, -0.00803787f, -0.02834236f, -0.03984312f, 0.01986653f, 
    -0.02895330f, -0.03804393f, 0.01272025f, -0.01352364f, 0.02505748f, -0.02027147f, -0.02170731f, 0.02457411f, 
    0.02897856f, -0.03081038f, -0.01274297f, -0.00432011f, 0.02167489f, 0.01632861f, -0.01857370f, 0.01683777f, 
    -0.03029819f, -0.00037035f, -0.00523287f, 0.00720020f, -0.01932231f, -0.02732707f, 0.00971272f, -0.00846301f, 
    -0.00703414f, -0.03466168f, -0.01036443f, 0.02298885f, -0.03920358f, -0.01134815f, 0.02955930f, 0.02375769f, 
    -0.03607161f, -0.03097230f, 0.00543804f, -0.01091552f, 0.00228974f, -0.00846834f, -0.03991719f, 0.02038317f, 
    -0.01313740f, 0.02878390f, -0.00312405f, -0.00919690f, 0.00938587f, 0.01241125f, -0.00871507f, -0.01424642f, 
    -0.02690521f, -0.00652051f, -0.01753582f, 0.01602643f, 0.00268951f, -0.02343897f, -0.00956625f, -0.02140965f, 
    -0.03770364f, 0.02745152f, -0.03758805f, -0.01134862f, 0.02194489f, -0.02342410f, 0.02043056f, -0.03417375f, 
    -0.00929723f, 0.00380484f, 0.00386293f, -0.00835012f, -0.01821555f, -0.00540932f, -0.00893995f, -0.01821235f, 
    0.00343108f, -0.01991517f, 0.01807211f, 0.02651556f, 0.01372428f, -0.01412915f, 0.00153136f, 0.02201455f, 
    -0.04275198f, 0.01889448f, -0.00648944f, 0.01964486f, -0.03082211f, -0.00690559f, 0.01892676f, -0.00502340f, 
    -0.01002843f, -0.01641900f, 0.02318183f, -0.01579050f, -0.00520817f, -0.00108757f, 0.02620877f, -0.03222146f, 
    0.02563293f, 0.02723669f, -0.00272033f, 0.01915991f, -0.01175360f, -0.00791973f, -0.02730736f, -0.01069554f, 
    -0.00865020f, -0.03737600f, -0.03977728f, 0.00827131f, -0.01106335f, -0.03174702f, 0.02929582f, -0.03813639f, 
    0.02535600f, -0.02189148f, 0.02229981f, 0.01676751f, 0.01003809f, -0.03432661f, -0.00109582f, -0.02968713f, 
    0.00478978f, -0.00965477f, -0.03891959f, -0.02577032f, -0.00306729f, -0.00539926f, 0.01410775f, 0.00216229f, 
    -0.03850464f, 0.01100009f, -0.03322803f, -0.03537863f, 0.01607260f, -0.03763182f, -0.03505783f, -0.02855883f, 
    0.02220629f, 0.00304462f, -0.02521112f, -0.00995137f, 0.00943032f, -0.00561187f, 0.00619672f, -0.03656165f, 
    0.00614540f, 0.00234883f, -0.03515976f, 0.01333822f, -0.02666803f, -0.02664845f, 0.01088841f, -0.04196384f, 
    -0.02916992f, -0.01557987f, -0.03643436f, 0.01487051f, -0.01108747f, -0.01990116f, 0.02567339f, -0.03622109f, 
    -0.01110341f, 0.02559958f, -0.02741531f, -0.03779792f, -0.03923937f, 0.02565837f, -0.01018510f, 0.00502442f, 
    -0.02038417f, 0.02842261f, -0.00708782f, 0.00297699f, 0.01919408f, -0.03920185f, 0.02379757f, -0.02606378f, 
    0.00800868f, -0.02949606f, 0.00033714f, -0.01191504f, 0.02922971f, -0.02841950f, -0.02069410f, -0.02607140f, 
    0.00200098f, -0.00645441f, -0.01912773f, -0.02231191f, -0.02251763f, 0.02118280f, -0.01449230f, -0.02161525f, 
    -0.01865439f, -0.03571255f, 0.02159448f, -0.02751645f, 0.01015949f, 0.02871218f, -0.02462912f, -0.04320448f, 
    -0.00470830f, 0.02282270f, -0.02490202f, -0.01427419f, -0.01579006f, 0.02052778f, -0.03980455f, -0.00605075f, 
    0.02814851f, -0.03944638f, -0.04085204f, 0.00260297f, -0.00273897f, -0.01203571f, -0.03084450f, -0.02158385f, 
    0.02345662f, 0.01502821f, 0.02635968f, 0.00503255f, 0.03417696f, -0.00778853f, -0.01495334f, -0.02173696f, 
    -0.02056772f, -0.02831112f, -0.01681104f, 0.02361280f, 0.00901152f, 0.02692434f, -0.03284282f, 0.01213792f, 
    0.02152154f, -0.03541601f, 0.01766261f, -0.01986731f, 0.03217029f, 0.00669435f, -0.01430291f, -0.03464003f, 
    -0.00087077f, 0.00447255f, -0.02398772f, -0.01194645f, -0.00741022f, 0.00480564f, -0.02369041f, 0.02118930f, 
    -0.02185908f, -0.02153342f, 0.00632704f, 0.00633127f, 0.01504152f, -0.03770558f, -0.03499112f, -0.02219573f, 
    -0.03783018f, -0.01678343f, -0.03752363f, -0.01175318f, -0.00730134f, -0.02165678f, -0.02808235f, -0.03547060f, 
    0.00144849f, 0.02729575f, -0.03199818f, -0.02216891f, -0.01978303f, -0.03531742f, -0.02023745f, -0.01566866f, 
    -0.00607892f, 0.01186412f, -0.01248945f, 0.01568988f, 0.00981070f, 0.02037816f, -0.01617272f, 0.00965610f, 
    -0.02072064f, 0.01378416f, 0.02057710f, -0.00621295f, 0.00781574f, -0.01018014f, 0.00836070f, -0.01375089f, 
    -0.03193678f, -0.00084066f, -0.01365480f, 0.02144107f, 0.02803533f, -0.00549537f, -0.04144263f, 0.00096775f, 
    0.02094830f, -0.03586667f, 0.01927669f, -0.00011402f, 0.01704335f, 0.00121371f, -0.01209887f, 0.01798484f, 
    0.00125379f, 0.01506107f, 0.01347504f, -0.01012374f, 0.00839361f, 0.00225160f, 0.01965314f, -0.03979411f, 
    -0.02348264f, -0.01411548f, -0.02413554f, 0.02139412f, 0.02306493f, 0.00502141f, 0.02139956f, -0.00312953f, 
    0.00954897f, -0.02259020f, -0.03656377f, -0.03297690f, -0.00509437f, -0.00447842f, 0.02085869f, -0.00268803f, 
    0.03070716f, -0.01940553f, 0.02162301f, -0.02800894f, 0.00936918f, -0.02264776f, -0.02622939f, -0.02932236f, 
    0.02996092f, -0.03300051f, -0.00922170f, 0.01004358f, -0.00839105f, 0.02733744f, -0.02617250f, -0.02371493f, 
    -0.00596343f, -0.00006896f, -0.02684052f, 0.01339610f, -0.01461136f, -0.01239148f, 0.00395687f, -0.00767545f, 
    0.01853622f, -0.03672793f, 0.02835028f, -0.02789448f, -0.01984349f, -0.00184457f, 0.00572833f, 0.01877339f, 
    -0.00600542f, 0.02485988f, 0.02712453f, 0.02228706f, 0.02193492f, -0.04147819f, 0.01265715f, -0.04008492f, 
    0.02325981f, -0.03777411f, -0.00004965f, 0.02278884f, 0.02526806f, -0.00495372f, -0.00104782f, 0.01665603f, 
    -0.02100264f, 0.02344344f, 0.02224455f, 0.01688412f, 0.00279968f, -0.01121932f, 0.00588316f, -0.01113690f, 
    -0.04263983f, -0.01788651f, -0.00705930f, 0.00312547f, -0.01272891f, 0.01244396f, 0.00719681f, -0.04042521f, 
    -0.03835882f, -0.03360970f, 0.02535692f, -0.02661206f, 0.01820393f, -0.03695612f, 0.01477249f, -0.00670358f, 
    -0.00423255f, -0.03544991f, -0.03499375f, -0.03442993f, -0.01908538f, -0.01764726f, -0.02935893f, -0.00470060f, 
    0.01471540f, -0.02934207f, -0.03257517f, -0.00568312f, 0.00861288f, 0.02609616f, -0.03160674f, -0.04009004f, 
    -0.03367893f, 0.02308091f, -0.02326983f, -0.02947266f, 0.00223612f, -0.03689181f, -0.03915080f, -0.02736426f, 
    -0.03464163f, 0.00789532f, -0.00589572f, 0.00237982f, 0.00382229f, 0.02436442f, 0.02168419f, -0.00684287f, 
    0.02706826f, -0.01505415f, -0.00273212f, -0.00418330f, -0.00518535f, -0.02754990f, -0.03932961f, -0.03296345f, 
    0.00050145f, -0.00199156f, -0.02760866f, 0.01435595f, 0.02623193f, -0.01828156f, -0.01019932f, -0.03312491f, 
    -0.03530390f, -0.01961313f, -0.01288261f, 0.00034540f, 0.01414317f, 0.02314837f, 0.00490304f, 0.01912622f, 
    0.02748651f, 0.01050173f, 0.01660243f, 0.02558342f, 0.00084988f, -0.01481086f, -0.01133518f, 0.02536644f, 
    -0.03596033f, 0.01756820f, 0.00822798f, -0.03891239f, -0.01095746f, -0.01405378f, 0.03697902f, 0.00619361f, 
    -0.03403182f, 0.02523388f, -0.03010343f, 0.00735886f, 0.02101603f, -0.03905282f, -0.01204525f, 0.00231979f, 
    -0.00234318f, -0.02510753f, 0.02326412f, -0.02181448f, -0.00052028f, 0.02777932f, 0.00720511f, -0.02242372f, 
    -0.00164565f, -0.01405486f, -0.01668196f, 0.02762880f, -0.04187714f, -0.03658305f, -0.02684385f, -0.00582657f, 
    -0.03512339f, -0.00773167f, -0.03756631f, -0.00683454f, 0.01795069f, -0.00225000f, -0.03913821f, -0.01795657f, 
    0.00500867f, -0.00210132f, 0.01770078f, -0.01957919f, 0.02182405f, 0.02283772f, 0.00168985f, 0.01185132f, 
    -0.01971792f, -0.03176275f, -0.02227762f, 0.01293011f, 0.00638350f, -0.00727775f, 0.01076300f, 0.00355100f, 
    -0.00747522f, -0.03693628f, 0.01841841f, -0.02244890f, -0.03596221f, 0.01371749f, -0.03535086f, -0.02392688f, 
    0.00885848f, 0.01124309f, -0.03007601f, -0.03803932f, -0.00256808f, -0.00194245f, -0.00424666f, -0.03885799f, 
    -0.01120796f, -0.02480739f, 0.00488010f, -0.00784470f, -0.00691344f, -0.01629373f, 0.00975927f, -0.00450309f, 
    -0.01453191f, 0.01885808f, 0.02221834f, 0.00950889f, 0.02880519f, 0.00599380f, -0.01771519f, 0.00763384f, 
    0.02788601f, 0.02336120f, 0.01806977f, 0.02058429f, -0.01053294f, 0.01599752f, 0.01802523f, -0.03730356f, 
    -0.02863266f, -0.01889299f, -0.00599991f, -0.00607525f, -0.01716153f, -0.03099276f, -0.02213857f, -0.02545629f, 
    -0.00062077f, -0.03274960f, -0.00392239f, 0.01919744f, -0.00772166f, 0.01512921f, -0.02480504f, -0.03311457f, 
    -0.01549335f, -0.01638603f, -0.03553535f, -0.00142156f, -0.02312602f, 0.02432203f, -0.03125154f, -0.00170527f, 
    -0.02905325f, -0.00659572f, 0.00162765f, -0.02152893f, -0.02254969f, -0.00585511f, -0.02699468f, -0.00309071f, 
    -0.02892683f, -0.01588373f, 0.02694710f, 0.02448299f, 0.02108902f, 0.02272540f, -0.03275066f, -0.02861045f, 
    -0.03969146f, 0.01720376f, -0.01297868f, -0.00230653f, -0.02327437f, -0.02264500f, 0.01542990f, -0.02036882f, 
    -0.01197487f, -0.00017783f, -0.03534468f, -0.03696305f, -0.00753159f, 0.00022743f, -0.03577846f, 0.01809025f, 
    -0.02482387f, 0.02188218f, 0.01118980f, -0.02603463f, -0.02389536f, -0.02913206f, 0.00298899f, 0.00452041f, 
    0.00980970f, -0.03829561f, -0.02737812f, 0.01982109f, -0.00813334f, 0.00108463f, -0.00612154f, 0.03484908f, 
    -0.01197355f, -0.02120735f, 0.00540927f, 0.00805555f, 0.02397555f, -0.01511583f, 0.01748107f, 0.00564265f, 
    -0.03582984f, -0.03814066f, 0.02694738f, -0.03095933f, -0.01764226f, -0.04208653f, 0.02310316f, -0.04115469f, 
    -0.00056777f, -0.00496349f, 0.01732409f, -0.00192570f, 0.00238700f, -0.00126036f, 0.00745932f, -0.00513435f, 
    -0.00061743f, -0.02635383f, 0.01510457f, -0.00484661f, -0.00209394f, -0.00367693f, 0.00747648f, 0.01839373f, 
    -0.03926326f, -0.02242639f, 0.02749498f, -0.03747794f, 0.00110988f, 0.00359625f, 0.02884194f, -0.01021900f, 
    -0.02372889f, 0.03956981f, 0.00290100f, 0.02735579f, -0.03099997f, 0.02967499f, 0.00226844f, 0.01677841f, 
    0.01619714f, -0.00071370f, -0.03988003f, 0.03928287f, 0.03875714f, -0.00001329f, -0.01001883f, 0.00194707f, 
    0.00478228f, 0.01836138f, -0.02327603f, -0.03537866f, -0.01631035f, -0.02953301f, -0.01704388f, -0.04033460f, 
    -0.04201651f, -0.00385935f, -0.01453546f, 0.02655695f, -0.04179608f, -0.00657033f, 0.02345159f, -0.00616927f, 
    -0.02614936f, 0.00012039f, 0.01633240f, -0.03032265f, 0.01301591f, -0.01311975f, -0.01754534f, -0.02171672f, 
    -0.00316145f, -0.01538516f, 0.02687822f, 0.03866792f, 0.00192487f, 0.01813809f, -0.02289890f, -0.02280421f, 
    -0.02953084f, 0.00937059f, -0.02196111f, -0.01196407f, 0.01134576f, -0.02720676f, 0.01903134f, 0.02007510f, 
    0.02799780f, 0.02899496f, -0.01061173f, -0.01660738f, -0.01671796f, 0.01719606f, -0.01822928f, -0.02269138f, 
    -0.01716065f, -0.02010586f, -0.00151155f, -0.01204663f, 0.00378756f, -0.01722833f, 0.00670333f, -0.00423776f, 
    0.00211041f, -0.01052883f, -0.04152027f, -0.03539803f, 0.01733870f, 0.02978713f, -0.02126002f, -0.02926173f, 
    0.02117155f, 0.01221240f, -0.02718403f, -0.02059942f, -0.01882697f, -0.02855683f, -0.02895684f, 0.00595826f, 
    -0.01051030f, -0.00105601f, -0.02383516f, 0.03140254f, -0.03668188f, -0.00906062f, -0.03566412f, -0.03538145f, 
    -0.02674358f, -0.01177717f, -0.01067607f, -0.03189123f, -0.01715882f, -0.02988213f, 0.01203970f, -0.00878162f, 
    0.00013442f, -0.02734684f, 0.00601825f, 0.03680987f, -0.00341525f, -0.02032389f, 0.02213063f, -0.01311134f, 
    0.00002907f, 0.02209331f, -0.00157469f, 0.01546195f, 0.02975090f, -0.02883223f, -0.02860064f, 0.02619668f, 
    -0.00738863f, -0.03555450f, -0.03100146f, -0.02839622f, 0.00815249f, -0.03251097f, 0.00405848f, 0.00691767f, 
    -0.01810977f, 0.02273628f, -0.04018502f, -0.01973414f, 0.01638791f, 0.02036397f, 0.01669203f, -0.01482987f, 
    -0.02930733f, -0.01520237f, 0.02896161f, -0.03797611f, -0.03099844f, 0.01563919f, 0.02959775f, -0.00785922f, 
    -0.03035674f, 0.04046073f, 0.01191936f, 0.03468041f, -0.01950122f, -0.03990943f, 0.04140889f, -0.00799541f, 
    0.00238248f, 0.01015612f, 0.03582961f, -0.00441323f, 0.00260097f, -0.02037241f, 0.00577777f, 0.00570242f, 
    -0.01609602f, 0.01653489f, -0.03615038f, 0.02851380f, -0.00325027f, -0.01774471f, -0.02000696f, 0.02008780f, 
    -0.02138080f, 0.01645417f, 0.02416194f, -0.04059851f, 0.01452440f, -0.03002051f, 0.02155670f, 0.03468656f, 
    -0.01952419f, -0.01599951f, 0.02591561f, -0.01950594f, 0.01734394f, 0.00818336f, 0.02474137f, -0.01125712f, 
    -0.04166003f, -0.02715771f, 0.01199333f, 0.01870157f, 0.00339759f, -0.02799419f, -0.03754074f, 0.03125817f, 
    0.00345565f, -0.03718115f, 0.01390136f, -0.02637387f, -0.00149240f, -0.04110218f, 0.00965484f, -0.01202602f, 
    0.01146651f, 0.02332209f, -0.00416230f, 0.01320158f, 0.01548506f, -0.00743270f, 0.02823611f, 0.02147869f, 
    0.00322674f, -0.03975835f, 0.00219000f, -0.03810912f, -0.03000498f, 0.02161260f, 0.00078643f, -0.01801318f, 
    0.00288188f, -0.02738813f, -0.01664310f, 0.02630722f, -0.02308236f, 0.01906147f, -0.00508094f, 0.02855488f, 
    -0.01638271f, 0.00995795f, 0.01064525f, -0.04055427f, -0.03916991f, 0.02206261f, -0.03879909f, -0.03288687f, 
    0.02681349f, -0.01479193f, 0.01279837f, -0.03165892f, 0.01591954f, 0.00944323f, -0.00689059f, 0.01299799f, 
    0.01853420f, 0.02505759f, 0.02150667f, -0.00838459f, 0.00323357f, 0.02044578f, -0.04013836f, -0.03662667f, 
    0.01569190f, -0.01107729f, 0.04074062f, -0.00361621f, -0.03438405f, -0.02717310f, -0.04065795f, 0.00114810f, 
    -0.01595291f, -0.00713830f, 0.00735317f, -0.01676850f, 0.00405061f, -0.04005995f, 0.02772399f, -0.03754988f, 
    0.02000451f, -0.03458954f, -0.01696196f, -0.00827154f, -0.01821661f, 0.00152540f, 0.00856224f, -0.04047503f, 
    -0.02721379f, 0.02331977f, -0.00877169f, -0.01354156f, 0.01271339f, -0.01731411f, 0.01526049f, 0.00399038f, 
    0.01250053f, -0.01890642f, -0.03243059f, 0.00864249f, 0.00823664f, -0.01361838f, -0.01977332f, -0.03173249f, 
    -0.00570722f, -0.01053272f, 0.00778153f, 0.02065251f, -0.03065178f, 0.01256988f, -0.02502947f, 0.01649491f, 
    0.00849293f, 0.02061793f, -0.02302898f, 0.00369019f, 0.00494468f, -0.01295269f, 0.00209768f, 0.01362357f, 
    -0.03806080f, -0.00820357f, 0.01659849f, 0.00876555f, -0.02575454f, 0.03534332f, -0.02753388f, 0.02353854f, 
    0.02092135f, 0.01232640f, 0.01675134f, 0.01672102f, 0.02233785f, -0.01221487f, -0.01041931f, -0.00100468f, 
    0.00546832f, 0.02884909f, 0.03461092f, 0.03128823f, -0.00958333f, 0.00185287f, -0.02517211f, 0.01167305f, 
    -0.00719947f, 0.01842376f, 0.00523102f, 0.01255618f, 0.01490323f, -0.02431924f, 0.01842985f, 0.00593597f, 
    -0.02379819f, 0.01940012f, -0.01555609f, -0.01424293f, 0.02907497f, -0.00627515f, 0.00520608f, -0.00865153f, 
    -0.01907663f, 0.01994741f, -0.00144472f, -0.00529075f, -0.03614595f, -0.01826642f, -0.01877978f, -0.00552427f, 
    -0.01405988f, -0.02286796f, 0.02157030f, -0.02040379f, -0.01521544f, 0.00614970f, 0.02816787f, -0.02288949f, 
    0.02820266f, -0.03443792f, 0.01745809f, 0.00839354f, 0.01163394f, -0.01359686f, 0.01179745f, -0.01782264f, 
    -0.00311654f, 0.02676149f, -0.00280352f, 0.00438586f, 0.02355359f, -0.02517737f, -0.00490506f, -0.01299382f, 
    0.03866037f, -0.03923985f, 0.01106818f, 0.02775905f, -0.02668227f, -0.02748894f, 0.01875100f, -0.00236167f, 
    -0.01972123f, 0.02205603f, -0.03442927f, -0.01183112f, 0.00613323f, -0.00332385f, 0.00951030f, 0.00469338f, 
    0.01617619f, 0.01256280f, -0.00658897f, -0.01690714f, 0.02037876f, -0.02527865f, -0.00236854f, -0.03031171f, 
    -0.00890906f, 0.00519822f, 0.01409011f, 0.01701514f, -0.03215341f, 0.01489293f, -0.00423586f, 0.02601619f, 
    0.03406711f, -0.01991209f, 0.01385492f, -0.02298959f, 0.01641079f, -0.01724886f, -0.00384741f, -0.02411798f, 
    0.01691792f, 0.00592791f, 0.02821408f, -0.02985284f, 0.01308760f, -0.02343205f, 0.02402821f, -0.01406733f, 
    0.02656471f, -0.00317881f, 0.00630543f, -0.02079187f, -0.02585273f, 0.00788092f, -0.01311389f, 0.01657625f, 
    0.02927721f, -0.03358799f, -0.01109947f, -0.00170511f, -0.01607659f, -0.04143361f, -0.00999889f, 0.03592459f, 
    0.01747677f, -0.02839065f, 0.01356491f, -0.00127219f, 0.01179883f, -0.03426805f, 0.02025203f, -0.03608719f, 
    -0.00298476f, -0.03808286f, -0.04055531f, -0.01763988f, 0.00755840f, -0.02415503f, 0.00234998f, 0.01462312f, 
    0.00754001f, -0.01847816f, -0.02120709f, 0.00770825f, -0.02928190f, -0.00857025f, -0.00903700f, -0.02331600f, 
    0.01427343f, 0.02225055f, 0.00826437f, 0.02406881f, 0.02150122f, -0.02956196f, -0.02240607f, 0.01044892f, 
    -0.00373531f, 0.00242821f, -0.02669173f, -0.02274321f, -0.01427838f, 0.00118306f, 0.02993768f, -0.03903421f, 
    0.02395630f, 0.00205216f, -0.01723489f, -0.00686251f, -0.02735643f, 0.00909958f, 0.03642543f, -0.02411392f, 
    0.00881910f, -0.01641021f, -0.03160482f, 0.02006518f, 0.02937096f, -0.04161775f, -0.02235026f, -0.04046479f, 
    0.02369536f, -0.01177636f, -0.01224030f, -0.02285600f, -0.01457150f, -0.02091848f, 0.01851557f, 0.02694140f, 
    0.00630409f, -0.02342880f, -0.00313399f, -0.01830831f, -0.01497457f, -0.00149118f, -0.00017331f, 0.01807940f, 
    -0.01794340f, 0.00409773f, -0.02266893f, 0.02248694f, 0.01783532f, -0.01810354f, -0.02103023f, 0.01843035f, 
    0.00284226f, -0.01852142f, -0.01722472f, -0.01961992f, -0.01058542f, -0.03990718f, 0.02603211f, 0.02828878f, 
    0.01839961f, -0.00272008f, -0.03518197f, -0.01774541f, -0.03758882f, -0.02539679f, -0.00071496f, 0.01857100f, 
    0.00756377f, 0.03432527f, 0.03825274f, -0.03462607f, 0.02210618f, -0.03140685f, 0.01379758f, -0.01125648f, 
    -0.02639602f, -0.00140007f, -0.00324407f, -0.02761914f, -0.02582546f, 0.02039362f, 0.00814044f, -0.02248095f, 
    -0.01074830f, -0.01756894f, 0.02305412f, 0.00295480f, -0.01189567f, -0.04197004f, -0.03335035f, -0.02565700f, 
    -0.02135882f, -0.01372784f, -0.00038840f, 0.01515694f, -0.01225631f, -0.00931725f, -0.00364901f, -0.00481205f, 
    -0.01357631f, 0.03140119f, 0.02248101f, -0.00929766f, -0.02990062f, 0.01353525f, 0.01827950f, -0.01630182f, 
    -0.00715271f, 0.02189413f, 0.02691122f, -0.01351384f, 0.02316114f, -0.00958665f, 0.00810799f, 0.01169300f, 
    -0.03152735f, 0.00641538f, -0.02226359f, 0.01142626f, 0.02428597f, -0.03774417f, -0.03636628f, 0.00515767f, 
    -0.00931828f, -0.01991587f, -0.01227559f, 0.02052968f, -0.01981132f, -0.03743125f, -0.00812737f, -0.02334330f, 
    -0.04067009f, 0.00746316f, -0.00069475f, 0.00055038f, -0.00317939f, 0.02907141f, 0.00724867f, -0.02597432f, 
    0.02740267f, 0.00702326f, -0.01834845f, -0.03739935f, -0.00306157f, -0.00257751f, 0.01823237f, 0.00084691f, 
    0.00655445f, -0.02699356f, 0.02887797f, -0.00110836f, -0.00588021f, 0.01361276f, -0.02808113f, 0.01258819f, 
    -0.00283524f, 0.01760690f, -0.03016408f, 0.02319881f, -0.03573351f, 0.01575733f, 0.00862614f, 0.00248294f, 
    0.01475855f, -0.03002198f, -0.01212750f, -0.00880935f, -0.00610358f, 0.01948815f, 0.00985243f, -0.00637116f, 
    -0.01501095f, -0.02507856f, -0.01904423f, -0.00674702f, 0.00387506f, 0.00908123f, 0.02773027f, 0.03448547f, 
    0.02930774f, -0.04005263f, 0.00964208f, -0.03268118f, -0.03594852f, -0.01250907f, 0.00355418f, -0.00718767f, 
    0.02540126f, 0.02788401f, -0.01940248f, -0.03555116f, -0.00187466f, 0.02910474f, 0.02629124f, 0.00820798f, 
    -0.03605410f, -0.02430098f, -0.02444783f, -0.04072612f, 0.01369847f, -0.00767876f, -0.03966467f, -0.00883723f, 
    0.03791201f, 0.07563186f, -0.03417807f, -0.00885583f, 0.02478009f, -0.09045049f, -0.11409169f, -0.10021938f, 
    -0.17864875f, -0.05340466f, -0.08534494f, -0.09085725f, 0.08569898f, -0.04595317f, 0.02164959f, 0.04593614f, 
    0.06657322f, 0.06995367f, 0.05327566f, 0.09413571f, -0.16390204f, -0.14240974f, -0.07806754f, 0.01234979f, 
    0.17420369f, 0.00200703f, 0.04757350f, -0.05384353f, -0.04542943f, 0.06924412f, -0.01568763f, -0.02376142f, 
    0.05492248f, 0.09605519f, -0.01218311f, 0.01890380f, 0.20386089f, 0.10001041f, 0.22381432f, 0.03440651f, 
    0.02728725f, -0.08153163f, -0.21169586f, -0.20171465f, -0.05412077f, -0.02840014f, 0.01317123f, -0.00275822f, 
    -0.16312543f, -0.04490033f, -0.12259397f, -0.05662835f, -0.06632123f, -0.04532412f, -0.09581813f, -0.13888483f, 
    -0.36438373f, -0.10416809f, -0.10255883f, 0.00595577f, 0.26404044f, 0.17230274f, 0.16905107f, 0.08998656f, 
    -0.00329823f, 0.15012105f, 0.07774555f, -0.02299489f, 0.12751903f, -0.02091419f, 0.07261883f, 0.02817149f, 
    0.19232734f, 0.24290539f, 0.11539322f, 0.17401074f, -0.27647159f, -0.32739532f, -0.31398621f, -0.22473119f, 
    -0.01551893f, -0.06590226f, -0.03595744f, -0.04241494f, 0.28436458f, 0.26672837f, 0.14050974f, -0.07574142f, 
    -0.09744432f, -0.11488848f, 0.03980249f, -0.11013533f, -0.07434778f, 0.00672411f, -0.01846837f, 0.01934471f, 
    0.07506359f, 0.08182818f, 0.04626500f, 0.07378256f, -0.03616456f, -0.03562520f, -0.13082629f, 0.00116905f, 
    0.17053157f, 0.04199908f, -0.02039885f, -0.05867209f, 0.08793209f, 0.01976869f, 0.01627823f, 0.03628192f, 
    0.17894788f, 0.01133303f, -0.02021910f, -0.13132721f, -0.05002965f, 0.02938802f, 0.02952689f, 0.02793348f, 
    0.17050488f, 0.15817143f, 0.21710648f, 0.15475854f, 0.13263431f, 0.03088858f, -0.06241218f, -0.05514806f, 
    0.01553402f, -0.01902457f, -0.09518850f, 0.02755033f, 0.07115933f, 0.08685559f, 0.09542870f, 0.09614290f, 
    -0.05901035f, -0.02581976f, 0.00600225f, 0.09599414f, 0.00943929f, -0.01501714f, -0.00027324f, 0.03729607f, 
    0.09062499f, 0.15005726f, 0.07614419f, 0.05691020f, -0.06555981f, -0.10970178f, -0.10837842f, -0.03024999f, 
    -0.32541993f, -0.08396430f, -0.04545167f, 0.04879787f, 0.04342927f, 0.04949964f, -0.05551644f, -0.05381339f, 
    -0.01193305f, 0.11700611f, 0.04852937f, -0.05147950f, -0.09176505f, -0.07455384f, -0.05260091f, 0.08544566f, 
    -0.02154668f, 0.06427973f, 0.04640928f, -0.13527417f, -0.06168871f, -0.11471876f, -0.13622601f, -0.13819632f, 
    -0.06040116f, 0.00615098f, -0.02810566f, -0.04286112f, -0.04620943f, -0.07527152f, 0.05021112f, -0.02960762f, 
    -0.04162507f, -0.05529066f, 0.05004528f, 0.03263419f, 0.12018085f, -0.33714503f, -0.31209260f, -0.18297105f, 
    0.15085177f, 0.12923968f, 0.05565871f, 0.05693757f, 0.06904515f, -0.01382414f, -0.02474821f, 0.00680971f, 
    0.06891406f, 0.05821862f, -0.00360482f, -0.02026872f, 0.24188423f, 0.08878154f, 0.02583585f, -0.14649712f, 
    -0.28949273f, -0.23414257f, -0.19573541f, -0.07485791f, -0.00083104f, -0.04538199f, -0.05420437f, 0.01316969f, 
    -0.06033041f, -0.00263961f, 0.02961851f, -0.04124867f, -0.03655279f, -0.20284130f, -0.38388655f, -0.20269315f, 
    -0.08169828f, -0.08716036f, -0.09034701f, -0.05703420f, 0.26112109f, 0.10243446f, -0.13996716f, 0.09682677f, 
    0.15940234f, 0.13783143f, 0.07834058f, -0.07828647f, -0.14660291f, -0.15459548f, 0.00323170f, -0.09677990f, 
    -0.09697671f, -0.01234988f, -0.09189516f, 0.00285374f, 0.00122000f, 0.04850623f, -0.03825407f, 0.04286817f, 
    -0.09093676f, 0.00395533f, 0.02279109f, 0.04762306f, 0.28250605f, 0.15721358f, 0.12986283f, -0.08454804f, 
    -0.08013196f, -0.31912065f, -0.09395002f, -0.18885115f, -0.00665691f, -0.01018314f, -0.03643192f, -0.02834554f, 
    0.03755652f, 0.30875680f, -0.19750164f, -0.09450756f, 0.09394415f, 0.16351266f, 0.09178920f, 0.09680051f, 
    -0.06378926f, 0.04096796f, 0.02750847f, 0.01726405f, -0.07125437f, -0.11517218f, -0.08868197f, -0.08595080f, 
    -0.25684819f, 0.02518726f, 0.01424737f, -0.00186099f, -0.13246725f, -0.04297098f, 0.04778579f, 0.16383027f, 
    0.13874425f, 0.06152306f, 0.02479221f, 0.04800259f, -0.06460118f, -0.00198652f, -0.05561506f, -0.04218688f, 
    -0.00422353f, -0.01545957f, -0.03274655f, 0.04401461f, 0.08543795f, 0.09061202f, 0.10945144f, 0.11717328f, 
    -0.07262044f, -0.07662591f, -0.20854583f, -0.09576374f, 0.39499280f, 0.23518573f, 0.06963883f, 0.12954976f, 
    0.11772198f, 0.16056791f, 0.04227846f, -0.13548243f, 0.12091336f, 0.10022762f, 0.01048250f, 0.08796319f, 
    -0.05845863f, -0.14538164f, 0.01445108f, 0.18516961f, -0.05630848f, 0.02996331f, -0.05158877f, 0.00210618f, 
    -0.06204236f, -0.05924908f, -0.08792263f, -0.01619688f, -0.04446434f, -0.02843199f, -0.06511910f, -0.00300983f, 
    -0.09341720f, 0.08524510f, -0.01835500f, 0.06901782f, -0.29742855f, -0.30499929f, -0.25359684f, 0.13946795f, 
    0.15170547f, 0.06849299f, 0.10404983f, 0.03801190f, 0.06587441f, 0.02643723f, -0.06684506f, -0.06309609f, 
    0.08201730f, 0.07156350f, 0.01084215f, 0.10626248f, -0.16339476f, -0.12045972f, -0.15133095f, -0.13992494f, 
    -0.17545062f, -0.05416523f, -0.01431144f, -0.17432676f, -0.36953965f, -0.03584955f, -0.20599687f, 0.05182733f, 
    -0.04547938f, -0.33845630f, 0.00739443f, 0.09445431f, 0.00449666f, 0.00792431f, -0.16374430f, -0.03967623f, 
    0.02640154f, 0.00955963f, 0.01810585f, 0.00611292f, 0.06934789f, 0.05408341f, 0.01040781f, 0.06013500f, 
    0.09295394f, 0.02904840f, 0.06534162f, 0.09831206f, -0.05678660f, -0.02219864f, -0.04191490f, -0.01981288f, 
    0.06758516f, 0.01746910f, 0.02058436f, 0.03098523f, 0.01493682f, -0.10423856f, -0.16838801f, -0.13963899f, 
    0.04019190f, -0.05906061f, -0.14624019f, -0.27354315f, -0.05743400f, 0.25606421f, -0.02777554f, 0.03483816f, 
    0.13899915f, 0.06160467f, 0.05446720f, 0.12605226f, -0.20841506f, -0.15637943f, -0.34546933f, -0.13365860f, 
    0.29295105f, 0.26469085f, 0.17208478f, 0.12045722f, -0.20651962f, -0.15329017f, 0.01793386f, 0.13333069f, 
    0.09218204f, 0.10101663f, 0.11390761f, 0.01859014f, -0.10899133f, -0.19224189f, 0.02614527f, -0.05954490f, 
    0.05984379f, -0.02419736f, -0.23133709f, 0.06259825f, -0.15069871f, -0.07319895f, 0.04502724f, -0.10538839f, 
    0.06641804f, 0.11750142f, 0.10469475f, 0.04633914f, 0.03531494f, -0.11325815f, -0.12819125f, -0.03720981f, 
    0.17976546f, -0.02734276f, -0.07237493f, -0.11162154f, -0.00914193f, 0.13736275f, 0.07277463f, 0.07197478f, 
    -0.11352407f, 0.08810686f, 0.16695134f, -0.23643629f, 0.05528514f, -0.00757137f, -0.09242572f, 0.04474619f, 
    -0.06825356f, 0.01644261f, 0.08692493f, 0.04589311f, 0.09679030f, 0.01702302f, 0.05788929f, 0.08535631f, 
    -0.02244262f, -0.03092336f, 0.06313725f, 0.02669775f, -0.04098454f, 0.00375765f, -0.05117106f, -0.05298851f, 
    -0.01157975f, 0.06412097f, -0.15344824f, -0.04002798f, 0.31801257f, 0.16010891f, 0.09255359f, 0.00398596f, 
    -0.13431531f, -0.09200957f, -0.03291265f, 0.01183075f, 0.04500325f, 0.06770909f, -0.08252989f, -0.03920913f, 
    0.03827973f, 0.04246976f, 0.06653351f, 0.02710891f, 0.11458172f, 0.07121730f, -0.07384662f, -0.02252867f, 
    0.06909081f, 0.09731624f, 0.02410948f, 0.14433141f, -0.22624239f, 0.00325115f, -0.04535285f, -0.05827770f, 
    0.02656951f, 0.05697778f, -0.06055677f, 0.07895647f, 0.05563492f, -0.00856874f, 0.03423845f, -0.12553337f, 
    -0.11970180f, 0.01137915f, -0.02924516f, 0.06059069f, 0.11118640f, -0.11296660f, 0.04315773f, 0.04661870f, 
    -0.06987842f, -0.15575980f, -0.00251994f, 0.04999756f, 0.00492662f, 0.00091036f, -0.02136781f, -0.00498611f, 
    -0.00244158f, -0.02138453f, -0.06319800f, -0.08702479f, 0.07584480f, 0.07901528f, -0.03762339f, 0.02871680f, 
    0.00968110f, -0.02921250f, 0.09066586f, -0.22829562f, -0.12726289f, -0.03957366f, -0.06742464f, 0.01775524f, 
    -0.36096588f, -0.08539554f, -0.03011212f, 0.08093510f, 0.07284777f, -0.00579525f, 0.06256744f, -0.06840192f, 
    -0.32231164f, -0.09554257f, -0.09637927f, -0.08633142f, 0.09482893f, 0.05197703f, 0.01827044f, 0.00148361f, 
    -0.02611129f, -0.02188943f, 0.05104709f, 0.02907887f, 0.01757277f, 0.03795170f, 0.03255290f, 0.00814324f, 
    0.14073755f, 0.04423310f, -0.00175472f, -0.25505888f, -0.13082260f, 0.04073014f, -0.22491649f, -0.29045454f, 
    0.05754564f, 0.18051723f, 0.01639174f, -0.10673878f, 0.11035839f, 0.05547130f, -0.23105118f, -0.14656208f, 
    0.19312353f, 0.07865753f, -0.12047233f, -0.20666124f, -0.05119015f, 0.14501752f, 0.10876767f, 0.01659972f, 
    -0.04691523f, 0.00136646f, 0.05004381f, 0.10100572f, 0.08803693f, 0.07588965f, 0.00162092f, -0.12169314f, 
    -0.23283495f, -0.05384486f, -0.04833413f, -0.09147657f, 0.00121200f, 0.02541331f, -0.01127029f, 0.04014183f, 
    -0.03264274f, -0.00430215f, 0.01692770f, 0.02817695f, 0.09262504f, 0.03023823f, 0.04756175f, 0.08611439f, 
    0.13995551f, 0.08340845f, 0.13661683f, -0.00256519f, 0.00325784f, 0.04451078f, 0.06491841f, 0.02098714f, 
    0.00732081f, -0.03422595f, -0.06872008f, -0.07650781f, -0.03770868f, 0.05210733f, -0.10981581f, -0.05549340f, 
    0.01825525f, 0.00968377f, 0.06908465f, -0.05353809f, -0.11084853f, -0.08833721f, 0.05809652f, -0.03417956f, 
    0.12777224f, -0.08454239f, -0.06863606f, -0.11670068f, 0.02072295f, -0.00285297f, -0.03049035f, -0.15612297f, 
    0.14380993f, -0.04671226f, -0.00417169f, -0.05358122f, -0.08213477f, -0.01485412f, -0.07145870f, -0.07532873f, 
    0.05325926f, 0.02789544f, -0.02778193f, 0.02132559f, 0.07855200f, 0.11733679f, 0.11089030f, -0.01750121f, 
    -0.01379325f, -0.04282372f, 0.05524594f, 0.02792014f, -0.00535373f, 0.05256257f, 0.03415749f, -0.00169491f, 
    0.26775107f, 0.26067963f, -0.08435287f, 0.12157783f, 0.08690079f, 0.25746951f, -0.02322646f, -0.02947895f, 
    0.19519511f, 0.18677489f, -0.03237617f, -0.02713903f, 0.10443766f, 0.01475672f, -0.00710030f, 0.03951350f, 
    -0.05833602f, -0.07284120f, -0.02659031f, -0.05981937f, 0.00856296f, 0.01493220f, 0.00247132f, 0.04075075f, 
    0.33040452f, 0.36144644f, 0.14883548f, 0.14600348f, 0.07660846f, 0.02263353f, 0.00290797f, 0.07229666f, 
    0.13026272f, 0.06648059f, -0.01365095f, -0.08997378f, 0.04646004f, 0.02041066f, 0.12579662f, 0.03171375f, 
    0.05458236f, 0.13271436f, 0.17674664f, 0.00948817f, -0.30803302f, -0.00351719f, 0.06678952f, -0.07802063f, 
    -0.08611988f, -0.13511668f, 0.01715202f, 0.09720548f, -0.03440478f, -0.06690229f, 0.04178221f, 0.16113617f, 
    -0.11880122f, -0.45636505f, -0.18428604f, 0.13606033f, -0.08386082f, -0.02771387f, -0.04645329f, 0.06345804f, 
    0.12617670f, 0.05343979f, 0.08423570f, -0.05007018f, -0.03118996f, -0.00189496f, -0.10760286f, 0.04119395f, 
    -0.09373881f, -0.00356114f, 0.03750255f, 0.06783584f, -0.09978960f, -0.09980474f, -0.11703340f, -0.07249252f, 
    0.02221276f, 0.06453914f, 0.00139850f, 0.01144990f, -0.31279305f, -0.16117966f, -0.14610264f, -0.25197071f, 
    -0.11236694f, 0.00420256f, -0.05214920f, 0.06407882f, 0.09864321f, 0.05771277f, 0.10038955f, 0.03466339f, 
    -0.10497706f, 0.09157176f, 0.10778127f, 0.06860369f, 0.08432213f, -0.27383614f, 0.04122232f, 0.14451303f, 
    -0.02943014f, 0.02366779f, 0.01472468f, -0.12551859f, 0.05550082f, 0.03851486f, 0.07958798f, -0.03548818f, 
    -0.06304967f, -0.07066027f, 0.26105684f, 0.07316609f, -0.02867857f, 0.05451338f, -0.01853534f, 0.09015756f, 
    -0.11859441f, -0.03924452f, 0.14633864f, 0.10768547f, 0.11615420f, -0.16738996f, 0.05853717f, 0.02387734f, 
    0.13205184f, 0.12346560f, -0.02867148f, 0.03268244f, 0.01416277f, -0.08393529f, 0.13838322f, 0.07724797f, 
    0.04844040f, 0.06332028f, 0.05357622f, -0.00391519f, 0.04892727f, -0.03239646f, 0.14770657f, 0.11327442f, 
    -0.14898357f, 0.15162016f, -0.03112742f, -0.00276949f, 0.08416360f, -0.11146388f, -0.16756743f, -0.12265109f, 
    0.10114418f, 0.08634835f, 0.00037668f, -0.03357616f, 0.01498504f, -0.03816038f, -0.09154240f, -0.02904857f, 
    0.01849777f, 0.19457589f, 0.05348920f, -0.16255775f, 0.10383772f, 0.03388377f, 0.03444768f, 0.06747788f, 
    -0.03849005f, 0.03294162f, 0.03140169f, 0.05423484f, 0.01527707f, 0.16097528f, -0.05175218f, -0.07232961f, 
    -0.00717502f, 0.02895158f, 0.07486915f, 0.11636011f, -0.04911743f, -0.01080127f, 0.01634428f, 0.01479249f, 
    0.10223200f, 0.01981876f, 0.25989190f, 0.18097420f, -0.02264128f, 0.04343601f, -0.02009684f, -0.04879482f, 
    -0.01102437f, 0.08245694f, -0.05394939f, 0.10820980f, -0.14835815f, 0.01348053f, -0.12684120f, 0.13770898f, 
    -0.07762109f, 0.08091679f, -0.09386723f, 0.16717833f, -0.02617899f, 0.09302767f, -0.17558162f, 0.10433806f, 
    0.11007980f, 0.40778118f, -0.24927545f, -0.14160077f, -0.01030746f, -0.08100443f, 0.15041423f, -0.05792186f, 
    -0.05885606f, 0.04708526f, -0.05893941f, -0.21850188f, -0.01906477f, 0.09574053f, -0.08166438f, -0.08834654f, 
    -0.10336087f, 0.09502582f, 0.09357873f, 0.08655670f, 0.06046334f, 0.04348449f, -0.14239681f, 0.07763735f, 
    0.06236693f, 0.04893202f, -0.12872981f, 0.23018861f, -0.08245196f, -0.01847032f, 0.05661234f, 0.02475462f, 
    0.02831499f, 0.13901219f, 0.12647311f, 0.06487983f, 0.08073092f, -0.10596864f, -0.17667155f, 0.00981701f, 
    0.07642271f, 0.14464234f, -0.03436681f, -0.06175254f, 0.07184876f, -0.00324029f, 0.12797087f, -0.01594912f, 
    -0.03634769f, 0.03601674f, -0.06875490f, -0.08082917f, 0.00965379f, 0.04942457f, 0.02545760f, -0.05829397f, 
    -0.03448266f, 0.00603212f, -0.01736956f, 0.05821310f, 0.22051287f, -0.17110763f, 0.20220627f, 0.19983901f, 
    0.02947749f, 0.09740453f, 0.06835704f, 0.03224636f, 0.10363967f, 0.21916184f, 0.10961382f, 0.03781508f, 
    0.07540403f, 0.15935844f, -0.21383962f, -0.13248196f, -0.13557887f, -0.06426016f, -0.07893180f, -0.01649851f, 
    -0.03917126f, -0.09743472f, 0.08027577f, 0.08646233f, -0.10613265f, -0.00894437f, -0.02658268f, -0.09371492f, 
    0.02533725f, 0.07483838f, 0.02349645f, -0.01603668f, 0.02302403f, 0.00616840f, 0.02801022f, 0.00485104f, 
    0.04428856f, 0.16506387f, -0.03645012f, -0.13502815f, 0.15783910f, 0.03977869f, 0.07090928f, 0.23199548f, 
    -0.01639285f, 0.03292008f, 0.01241995f, -0.03009450f, -0.00685641f, -0.13303412f, -0.03166315f, -0.16884245f, 
    0.00058815f, -0.05312273f, -0.00553516f, -0.09981537f, -0.03458316f, 0.03656009f, -0.04172692f, -0.05714853f, 
    0.08074725f, 0.15940934f, 0.07985076f, -0.12959138f, 0.02566045f, -0.05858572f, 0.02178127f, 0.08593835f, 
    0.07315662f, -0.17534414f, 0.08658282f, -0.07424017f, -0.20927308f, -0.12857988f, -0.08829903f, -0.16807972f, 
    -0.06869821f, 0.05288507f, -0.08165755f, -0.00231085f, 0.04559383f, -0.05121744f, -0.07700951f, -0.01013852f, 
    -0.25892451f, 0.34054700f, -0.19130994f, -0.07994381f, -0.06398441f, -0.06269975f, 0.07967870f, -0.03109034f, 
    -0.02056519f, -0.13497326f, 0.13052450f, 0.06829929f, -0.01670289f, 0.00241577f, 0.04395438f, -0.04506993f, 
    0.04583717f, -0.00958495f, 0.07310659f, 0.04611868f, 0.11564249f, -0.03226992f, 0.08902972f, 0.04677571f, 
    -0.01891232f, -0.05138033f, 0.09037814f, -0.02607571f, 0.08371074f, 0.03607580f, -0.02081798f, 0.06989569f, 
    0.06077164f, 0.10934894f, -0.15232228f, 0.06712715f, -0.14318788f, -0.00413802f, 0.23639598f, -0.23717041f, 
    -0.12660290f, -0.00450859f, -0.07733090f, 0.23127422f, 0.04569813f, 0.03843096f, -0.00060543f, -0.13288492f, 
    0.10760417f, -0.12576017f, -0.07461388f, -0.08225347f, 0.14201844f, 0.06981080f, -0.08798780f, -0.06774246f, 
    -0.08225527f, -0.03961363f, 0.03803540f, -0.03411200f, 0.05420651f, 0.16112721f, -0.07543266f, -0.01264427f, 
    0.04402700f, -0.08390374f, 0.04074284f, 0.08159260f, -0.03550711f, -0.01634164f, 0.08068230f, -0.03494987f, 
    0.13125902f, 0.08230920f, 0.21178444f, -0.01758428f, -0.02765052f, -0.00714093f, 0.01659311f, 0.07541369f, 
    0.03735936f, 0.02876548f, -0.08029437f, -0.03749884f, -0.03613108f, 0.10728640f, -0.11930751f, 0.01935536f, 
    0.01510840f, -0.08800161f, -0.04683746f, -0.07217178f, 0.02707636f, -0.05727782f, 0.01946455f, 0.06748402f, 
    0.27122876f, -0.02265396f, 0.07299042f, 0.02352794f, 0.26961088f, 0.10516562f, 0.03769341f, 0.00063914f, 
    0.01305789f, -0.06161190f, 0.07558428f, 0.17784357f, 0.18096091f, 0.16080424f, 0.15421341f, 0.24075040f, 
    0.05029033f, -0.04158012f, 0.02048836f, 0.02305692f, 0.03307234f, -0.01255063f, 0.04275464f, 0.06285470f, 
    -0.20446126f, 0.09879017f, 0.18316077f, -0.00318634f, 0.05519231f, -0.08968097f, -0.08519854f, -0.02012962f, 
    0.01278250f, -0.12911712f, 0.11706898f, 0.01279507f, -0.16948391f, 0.25470227f, 0.07023275f, 0.09053445f, 
    -0.08825099f, 0.17013855f, -0.07794412f, -0.02966690f, 0.06367659f, 0.11003239f, -0.07920934f, 0.26276311f, 
    -0.32241735f, -0.08655650f, 0.22592247f, -0.05061872f, 0.00389444f, -0.05507722f, -0.07792631f, 0.17367335f, 
    0.03024146f, -0.07882217f, 0.11242600f, -0.14882599f, -0.02335260f, -0.23855188f, 0.00088005f, 0.06843075f, 
    -0.05624713f, -0.03992008f, 0.09691811f, -0.09033287f, 0.06310704f, 0.02117725f, -0.11379059f, 0.01296320f, 
    -0.44364893f, -0.03918001f, 0.25524083f, -0.16067988f, -0.10549620f, -0.04710388f, -0.15975311f, 0.15095018f, 
    0.03634243f, 0.07360302f, -0.05005209f, -0.10076761f, -0.18279529f, 0.00012107f, 0.08318327f, -0.20740491f, 
    0.02412292f, 0.12472462f, -0.06119720f, -0.19740523f, -0.02965591f, -0.04769550f, -0.23605804f, 0.03277281f, 
    -0.07752468f, -0.04563814f, -0.09622691f, -0.06100474f, 0.05251769f, -0.07393288f, -0.00779463f, -0.05500664f, 
    -0.03162108f, -0.07922610f, 0.04511564f, -0.00986815f, -0.12112038f, -0.05434905f, -0.03708402f, -0.00616866f, 
    -0.05233106f, -0.05656749f, -0.03049362f, -0.03305294f, 0.09440482f, 0.11130999f, 0.03588340f, 0.09364633f, 
    0.16997015f, -0.12840852f, -0.22934571f, -0.11381555f, -0.01593463f, -0.04964877f, 0.14135584f, 0.12920897f, 
    -0.02318330f, -0.05798069f, -0.06342036f, -0.12593155f, -0.05620110f, 0.22981259f, -0.01922905f, -0.12656355f, 
    -0.07918330f, -0.05080418f, -0.06337910f, 0.03872307f, 0.05921278f, -0.00847223f, 0.12462204f, 0.02362300f, 
    0.20457651f, 0.06256829f, 0.04836006f, -0.07302305f, 0.01192775f, -0.01505232f, -0.02863573f, 0.08714367f, 
    -0.17313586f, -0.02737411f, -0.06057930f, 0.10135676f, 0.24465494f, 0.09591684f, 0.17161927f, 0.09411883f, 
    -0.09560252f, -0.07014711f, 0.14525466f, 0.01127358f, -0.03948247f, 0.00255293f, 0.10558938f, -0.09129247f, 
    -0.09510721f, 0.09571078f, 0.11524294f, 0.12888473f, -0.07226693f, -0.00621732f, 0.11131541f, -0.00535991f, 
    0.01628612f, 0.02737680f, 0.09206821f, 0.08852021f, 0.03921475f, -0.09181435f, -0.21388239f, 0.00695769f, 
    -0.01911535f, 0.12092742f, 0.10417352f, -0.01698553f, 0.05084372f, 0.03806558f, 0.01063176f, 0.04030710f, 
    0.01121894f, -0.07347765f, 0.04335120f, -0.15657490f, 0.06553222f, -0.06495693f, -0.02719805f, 0.03141955f, 
    -0.08134934f, -0.01244608f, -0.05042147f, -0.00046906f, 0.00113969f, 0.08726411f, 0.19712216f, 0.10616183f, 
    -0.09894544f, -0.03076540f, -0.08417193f, -0.05665440f, -0.03158818f, -0.13137728f, 0.04684443f, -0.02761446f, 
    -0.13202144f, 0.13767822f, 0.22045746f, 0.26436657f, 0.00290115f, 0.08296279f, -0.06047454f, 0.16835481f, 
    0.05217115f, 0.04036507f, 0.23244062f, -0.04217652f, -0.24288659f, 0.03299743f, -0.08155724f, 0.05866812f, 
    -0.09283994f, 0.04114392f, 0.09278342f, 0.14285010f, 0.12028366f, -0.03566104f, 0.04764735f, -0.20327759f, 
    -0.28904834f, -0.09621632f, 0.03904265f, -0.01444041f, -0.10130113f, 0.12342461f, 0.15304792f, 0.00335767f, 
    0.02565367f, 0.05532194f, 0.05092290f, 0.04258088f, 0.08327660f, 0.26010013f, 0.43813449f, 0.04842495f, 
    -0.00269337f, -0.14535408f, -0.03624215f, -0.02878269f, -0.07694788f, -0.09298351f, -0.06351743f, -0.04846713f, 
    0.06038836f, -0.10237899f, -0.18990298f, 0.06333520f, -0.01565912f, -0.03212750f, -0.03786660f, 0.02995250f, 
    0.07092697f, -0.11246105f, -0.00928785f, -0.08195633f, 0.05155326f, 0.01175675f, 0.08169055f, 0.18609513f, 
    -0.01624111f, 0.00443645f, 0.06119495f, 0.05212361f, 0.03258610f, 0.05543042f, 0.19482063f, -0.15180829f, 
    0.10383097f, -0.11628756f, 0.03521246f, 0.00710470f, 0.20044115f, 0.01508122f, 0.02198803f, -0.10344817f, 
    0.12079220f, 0.09215882f, 0.07015939f, 0.15358716f, -0.11539605f, 0.33436364f, -0.12798600f, 0.00917410f, 
    -0.06866075f, -0.03027407f, 0.07789742f, 0.11008044f, 0.08868641f, 0.06290134f, 0.10031301f, -0.05070507f, 
    0.03840962f, -0.02679891f, 0.05940961f, 0.02285803f, -0.00226653f, -0.00191780f, 0.01877695f, -0.01841915f, 
    0.09115936f, -0.08476759f, 0.10167466f, 0.07942957f, 0.16141577f, -0.22011296f, -0.15323605f, -0.07149741f, 
    0.13958283f, 0.11259757f, 0.03810904f, 0.04670541f, -0.02255426f, -0.09963527f, 0.00373730f, -0.05606815f, 
    0.04486225f, -0.00389579f, 0.01353846f, -0.04732476f, -0.01588546f, 0.02053039f, -0.01909605f, -0.01690509f, 
    0.07147852f, 0.02019396f, -0.01997010f, -0.17049202f, -0.21501331f, -0.10224359f, 0.00102578f, 0.15171733f, 
    -0.02899302f, 0.03583691f, 0.06312194f, 0.08540870f, -0.08942927f, -0.01912471f, -0.00174568f, -0.12354022f, 
    -0.06211171f, -0.05662404f, -0.05155737f, -0.24035583f, 0.02497166f, -0.06911443f, 0.02131862f, 0.04731547f, 
    0.00720976f, -0.16287708f, 0.03518144f, -0.00568457f, 0.24283184f, 0.52476364f, -0.11505899f, -0.12193995f, 
    0.06042330f, -0.01336336f, 0.11097062f, 0.06857079f, -0.12696412f, 0.08009157f, 0.13480917f, -0.05107762f, 
    -0.27739444f, -0.11819953f, -0.13882072f, -0.04442446f, 0.01804905f, 0.11117911f, 0.01120160f, 0.04783499f, 
    -0.08032957f, -0.04065730f, 0.01424450f, 0.14613700f, -0.29229376f, 0.02307181f, 0.08570065f, 0.06369100f, 
    -0.01439794f, -0.00319355f, 0.04211184f, -0.02399196f, 0.09241257f, 0.13765773f, -0.07849370f, -0.00888070f, 
    0.02423346f, -0.02272218f, -0.03495243f, 0.00071357f, -0.01800480f, 0.01467047f, -0.03324625f, -0.02647682f, 
    -0.01717826f, -0.02025186f, 0.01037876f, 0.03086453f, 0.01815174f, -0.02269171f, 0.00341046f, 0.00544169f, 
    0.00700170f, 0.01086943f, 0.01303721f, 0.01837579f, 0.02467085f, -0.00749012f, 0.02134406f, 0.00816626f, 
    -0.01206430f, -0.03956549f, -0.03559851f, 0.00296494f, 0.01722248f, 0.02335832f, -0.03970162f, -0.01382287f, 
    0.01200921f, -0.03483097f, -0.01365853f, -0.00722572f, -0.00597980f, -0.03177564f, -0.02236404f, 0.01580063f, 
    -0.02238494f, 0.00941304f, -0.00825074f, 0.00211204f, -0.00546499f, -0.02278257f, -0.02942683f, 0.01466958f, 
    -0.02090205f, -0.00296329f, 0.01718011f, -0.00679835f, -0.03597324f, -0.01712674f, 0.02698443f, 0.01040404f, 
    -0.02460184f, 0.01831866f, -0.03071872f, -0.01467678f, 0.00134663f, 0.02339544f, 0.02556222f, -0.02959718f, 
    -0.01382872f, 0.00778831f, -0.02371684f, -0.02205701f, -0.01985000f, 0.00906142f, 0.00574464f, -0.00317197f, 
    0.02739012f, -0.01940960f, 0.00126465f, -0.02068300f, 0.01689545f, -0.01917311f, -0.01815863f, -0.01279009f, 
    -0.00755931f, 0.00861565f, -0.02726905f, 0.01489809f, 0.02998460f, -0.00783312f, -0.00952425f, -0.01780001f, 
    -0.00965542f, -0.00007659f, 0.02297685f, 0.03179197f, -0.03724521f, -0.00541421f, -0.03392080f, -0.00055548f, 
    -0.03345510f, 0.00985540f, 0.02916079f, 0.02720159f, 0.01169626f, -0.01149003f, -0.00165295f, -0.00189927f, 
    0.01308159f, -0.00689278f, -0.02109041f, 0.02976190f, 0.02658120f, -0.02868976f, -0.00928788f, 0.01349360f, 
    0.02609249f, 0.01263451f, -0.04124842f, 0.01741003f, 0.01429060f, -0.02907664f, -0.00913078f, -0.01977925f, 
    -0.02745806f, 0.03610143f, -0.01273814f, -0.02160919f, -0.00030752f, 0.00468053f, 0.02743136f, 0.01735618f, 
    0.02411435f, 0.00574337f, -0.00173795f, 0.02273572f, 0.00646983f, 0.02588159f, -0.03483893f, -0.00223568f, 
    -0.01546425f, -0.01607645f, -0.00741878f, 0.00501108f, 0.01925854f, -0.01791280f, -0.02770809f, -0.00146685f, 
    -0.00336742f, 0.00314205f, 0.01994205f, -0.03379648f, -0.00337288f, 0.02705372f, 0.00901054f, 0.01681405f, 
    -0.02903039f, -0.03006116f, -0.00755828f, -0.00056171f, -0.00048691f, -0.02710873f, -0.01968097f, 0.01617185f, 
    0.02311843f, 0.01269714f, 0.00674798f, -0.01372835f, -0.00739316f, -0.03334493f, 0.02647719f, -0.02455783f, 
    -0.01177256f, 0.02922141f, -0.02408943f, 0.02390279f, 0.03327284f, -0.01402331f, 0.00970476f, -0.02658161f, 
    0.00314358f, -0.04100819f, 0.00705240f, 0.01347588f, -0.00034869f, -0.02920328f, 0.03260867f, 0.00448815f, 
    0.02025379f, 0.00130958f, 0.00176815f, 0.02300306f, 0.00930931f, -0.04721751f, -0.00443107f, 0.01350590f, 
    -0.01624166f, 0.01030240f, 0.00476829f, 0.00953391f, 0.00469787f, 0.00515049f, 0.01574859f, -0.00133087f, 
    -0.01241883f, 0.00011758f, -0.03848343f, 0.02238100f, 0.00181574f, -0.03217766f, -0.03171261f, 0.00408484f, 
    0.01379999f, 0.02579938f, -0.01869132f, 0.02726170f, 0.03036226f, 0.00411589f, 0.01296348f, -0.01429392f, 
    0.03292032f, -0.00695720f, -0.03518041f, 0.02393495f, -0.01760120f, -0.01800034f, 0.01474588f, 0.00064216f, 
    -0.01313148f, -0.02853095f, -0.00750031f, 0.02834863f, -0.00693604f, 0.01640813f, -0.01443203f, 0.02050361f, 
    -0.03837338f, -0.03226237f, 0.00895389f, 0.00807320f, -0.03381252f, 0.01676413f, -0.02960494f, -0.00047813f, 
    0.00499494f, 0.01759845f, 0.00638359f, 0.02867302f, 0.00900479f, -0.00218459f, -0.01905083f, 0.02867799f, 
    -0.00485624f, -0.03049967f, -0.02697776f, -0.03198897f, 0.02493294f, 0.02215522f, 0.02927711f, -0.03041034f, 
    0.02854071f, 0.01138497f, -0.02555984f, 0.00274283f, 0.00920377f, 0.01232943f, -0.01814865f, -0.03828000f, 
    -0.01527383f, 0.03007900f, -0.02056237f, 0.01152904f, 0.00023742f, 0.01766624f, 0.01008806f, 0.02765533f, 
    0.00389973f, 0.00439144f, -0.01295482f, 0.00371742f, -0.01172235f, 0.03032018f, -0.02693655f, -0.00040543f, 
    0.02161215f, 0.02414878f, 0.00549896f, 0.01612001f, -0.00262217f, 0.02219525f, -0.01350221f, 0.02311227f, 
    0.00646757f, -0.02531978f, -0.00266655f, 0.01363901f, 0.03363276f, 0.01662719f, 0.00176432f, 0.00197299f, 
    0.03095956f, 0.00773095f, -0.00272831f, -0.01307112f, -0.00962195f, -0.02050005f, -0.01611565f, -0.01077873f, 
    0.03269363f, 0.02305957f, -0.02945972f, -0.00890033f, -0.00532672f, 0.00285373f, -0.00810236f, -0.00160054f, 
    -0.02990375f, 0.01998135f, -0.00096905f, 0.01091449f, -0.01934565f, 0.00943711f, 0.03750417f, -0.02730953f, 
    0.01366888f, -0.02020608f, 0.01628687f, 0.01163409f, -0.00065008f, 0.01440869f, 0.01033390f, 0.00551385f, 
    -0.01621911f, -0.01704014f, -0.00634867f, -0.02455053f, -0.03006292f, -0.03464870f, -0.01645441f, -0.00223510f, 
    0.02819353f, 0.00118471f, 0.02866643f, -0.01173758f, -0.04182111f, -0.03806792f, -0.03067405f, 0.01712717f, 
    0.01256066f, 0.01983806f, 0.01682751f, 0.01071114f, -0.01855826f, -0.01427615f, -0.00619632f, -0.02087608f, 
    -0.01300565f, -0.04401624f, -0.00213620f, 0.01751621f, 0.01327766f, -0.04223370f, -0.02357631f, -0.00734811f, 
    -0.01941583f, 0.03441000f, -0.03559815f, -0.01594561f, -0.00736762f, -0.01489924f, 0.01404087f, -0.03542158f, 
    -0.01130686f, -0.03380299f, -0.02252072f, -0.00192387f, 0.01383559f, 0.02333784f, 0.02559285f, -0.03620007f, 
    0.00063286f, -0.04500746f, -0.03087470f, 0.01232387f, 0.01603068f, -0.03514888f, -0.01630047f, 0.00976652f, 
    -0.02550835f, -0.02631470f, 0.01574259f, -0.02354029f, 0.02042913f, -0.02543847f, 0.04503966f, -0.02821167f, 
    -0.00566849f, 0.01049869f, -0.02970518f, 0.01442466f, -0.00348330f, -0.00960065f, -0.00488006f, -0.00498427f, 
    -0.00340566f, 0.01193326f, 0.01101118f, -0.03350559f, -0.03703284f, 0.01731163f, -0.01015415f, -0.02490643f, 
    -0.01806942f, 0.01164414f, -0.01914455f, 0.00471363f, -0.00133956f, -0.02322202f, -0.00174514f, 0.00840859f, 
    -0.02663807f, -0.02205323f, -0.00397653f, -0.02174854f, 0.00697052f, -0.01035120f, 0.02562702f, 0.02570776f, 
    -0.00270193f, 0.00723099f, -0.02351848f, 0.00450230f, -0.01999411f, 0.02346068f, -0.01760750f, 0.01765176f, 
    -0.00832672f, 0.02800714f, -0.02811459f, 0.00702800f, 0.02179991f, -0.01401419f, 0.00392148f, -0.01881500f, 
    0.01826787f, -0.04525399f, -0.03565026f, 0.01328955f, -0.00063698f, -0.02533964f, -0.01619466f, 0.00752292f, 
    -0.01099525f, -0.02312181f, 0.00774502f, -0.00170441f, 0.01171136f, -0.02532741f, -0.00494953f, -0.02443777f, 
    0.00385759f, -0.01417043f, -0.02770969f, 0.02459472f, -0.01985931f, -0.00624578f, -0.03448277f, 0.01325796f, 
    0.00120338f, 0.02505667f, 0.02806468f, 0.00244469f, 0.02401130f, -0.00266763f, -0.03191277f, 0.02220586f, 
    -0.00988165f, 0.00826589f, -0.00408275f, -0.02023774f, -0.02852302f, -0.02962831f, -0.03197993f, 0.00952605f, 
    -0.01503698f, -0.03090894f, -0.04012186f, 0.03760267f, -0.02459668f, -0.02961287f, -0.03825967f, -0.02484778f, 
    -0.00861564f, -0.03022845f, 0.02279352f, -0.02520391f, 0.00124625f, 0.00386375f, -0.00805135f, -0.01185375f, 
    0.02780048f, -0.00727092f, 0.02142531f, -0.00773267f, -0.01823148f, -0.00746886f, 0.02153001f, -0.02941628f, 
    0.02820975f, -0.00732066f, 0.02304387f, -0.01136972f, -0.01948524f, -0.01539229f, -0.01051510f, 0.01985242f, 
    0.01101318f, -0.00074732f, 0.00938024f, -0.00187711f, 0.01104360f, 0.02435481f, 0.01756601f, -0.00459908f, 
    0.00950558f, 0.03411241f, -0.03184984f, -0.00372322f, -0.00290572f, 0.02086842f, 0.01498448f, -0.00561063f, 
    0.02285164f, 0.00907035f, -0.02181785f, -0.01949275f, -0.03199595f, -0.01752894f, -0.02614782f, -0.01598675f, 
    0.00250787f, 0.00586456f, -0.00432615f, 0.00476976f, -0.00720705f, -0.02386376f, -0.00468788f, -0.02107936f, 
    0.02956076f, -0.02764582f, -0.02982748f, 0.00893975f, -0.00947490f, 0.02419271f, 0.00015009f, 0.02926700f, 
    -0.02920070f, 0.02510402f, -0.01358680f, 0.01202911f, -0.03247771f, -0.04349032f, 0.01384467f, 0.01376471f, 
    0.03527724f, -0.00323741f, -0.00696239f, -0.02162942f, 0.00516726f, -0.02640570f, -0.03609459f, 0.01382518f, 
    -0.02764498f, -0.01027369f, -0.00813187f, 0.01523897f, 0.01151065f, 0.01728305f, -0.02639887f, 0.00174380f, 
    -0.01337587f, -0.01619673f, 0.01509809f, -0.03583424f, 0.01653940f, -0.00247060f, 0.02548359f, 0.02141357f, 
    -0.03104007f, 0.02997393f, -0.03373761f, 0.02076546f, -0.01386323f, 0.02873485f, -0.04125537f, -0.00439250f, 
    -0.00239710f, -0.02464707f, 0.00111148f, -0.00981374f, -0.00199039f, -0.02508431f, -0.02856729f, -0.02264075f, 
    -0.02299219f, -0.03097309f, -0.00437085f, -0.02094617f, 0.02541336f, -0.00128537f, -0.00159519f, 0.02437290f, 
    -0.00274103f, -0.02294024f, -0.00063319f, 0.02479919f, 0.02735352f, -0.01957413f, 0.00412811f, -0.02733936f, 
    -0.03158166f, 0.01596747f, -0.04365895f, 0.02392224f, 0.00351573f, -0.03257486f, 0.00535303f, 0.02415709f, 
    0.01383986f, -0.02062848f, 0.03401916f, -0.03938798f, -0.01210625f, -0.02899403f, -0.03030493f, -0.03119263f, 
    0.01592876f, -0.01340978f, -0.04036186f, 0.00167899f, 0.00221248f, 0.02183983f, 0.02529756f, -0.01477850f, 
    0.01256796f, -0.00423113f, 0.02783306f, 0.00752046f, -0.03269887f, -0.03424364f, -0.00679661f, -0.00548506f, 
    0.00189726f, -0.03589570f, -0.02360689f, 0.01897810f, -0.01435841f, -0.00378958f, -0.02476797f, -0.02766550f, 
    -0.01672461f, -0.01948701f, -0.03135782f, 0.02552694f, -0.01098853f, -0.04076694f, 0.01532210f, 0.02026490f, 
    -0.02778616f, -0.00817074f, -0.01454622f, 0.00035210f, -0.02878393f, -0.02583726f, -0.01806416f, -0.03004379f, 
    -0.02575536f, 0.01410136f, -0.00203626f, 0.02080922f, 0.01976551f, -0.03873818f, -0.03582338f, -0.03849163f, 
    -0.01472349f, -0.02205603f, -0.00751668f, 0.01107658f, -0.01960197f, 0.02388332f, 0.01627996f, -0.02303086f, 
    0.02882092f, -0.01739462f, 0.00893245f, -0.01771248f, -0.00640738f, 0.02894191f, -0.01332305f, 0.02999249f, 
    0.01664088f, -0.00250077f, -0.01866646f, -0.01204217f, -0.02247354f, 0.02211985f, -0.02195876f, -0.00219772f, 
    -0.02315191f, -0.00099395f, 0.00547256f, -0.03342178f, -0.01358309f, -0.01197365f, -0.00211335f, -0.02680604f, 
    -0.02364501f, 0.00386193f, 0.01261969f, 0.01412021f, 0.01912648f, -0.00079830f, -0.00728807f, -0.01490503f, 
    0.01879325f, -0.00454234f, -0.01763393f, 0.02287111f, -0.00499158f, -0.00151727f, 0.02629073f, 0.01663771f, 
    0.01664252f, 0.01178234f, -0.02640443f, -0.01888512f, 0.03003408f, -0.03825818f, -0.02204282f, 0.02835078f, 
    0.00935959f, -0.00672434f, -0.01623647f, -0.02901356f, -0.02413705f, 0.02556252f, -0.02507044f, 0.01581080f, 
    -0.03300771f, -0.04483592f, 0.01756052f, 0.00912757f, -0.02243899f, 0.02903425f, -0.00941396f, -0.03950762f, 
    0.01990121f, -0.01271217f, -0.00041578f, -0.00713908f, -0.02069218f, -0.03608643f, 0.00404061f, -0.01408103f, 
    -0.02274848f, -0.01877111f, 0.02021241f, -0.04165311f, 0.01424211f, -0.02744824f, -0.00805798f, 0.02771624f, 
    -0.00506390f, 0.02170388f, 0.03059340f, -0.00526540f, -0.02302635f, 0.00894422f, -0.02658110f, -0.00864187f, 
    0.00480875f, -0.00146960f, 0.01095801f, 0.00134504f, 0.01611127f, -0.03628835f, -0.02622855f, -0.01134200f, 
    0.00565216f, -0.00774861f, 0.01009923f, -0.02164570f, -0.00571768f, -0.02454877f, -0.01976747f, -0.03145443f, 
    0.00089933f, -0.01811339f, 0.01187242f, 0.02556392f, 0.00892950f, 0.02329527f, 0.02457649f, -0.02658451f, 
    -0.01981477f, 0.03375259f, -0.01431344f, -0.01779879f, 0.01596455f, -0.02888576f, 0.02325914f, 0.01459712f, 
    -0.02980389f, -0.02074379f, 0.02734011f, 0.03017323f, 0.03423519f, -0.03972176f, -0.02279242f, 0.01716091f, 
    -0.03472042f, -0.02373806f, 0.00214769f, 0.02667728f, -0.01734615f, -0.03557757f, 0.01315230f, 0.00383492f, 
    -0.04273442f, -0.03653046f, -0.02704349f, 0.00089045f, 0.01236019f, 0.02432626f, 0.01695710f, -0.00630032f, 
    0.02832088f, 0.01351161f, -0.01926979f, -0.02616082f, -0.02948831f, -0.02497209f, 0.02956246f, 0.01168415f, 
    0.01154828f, -0.00439926f, 0.01966426f, -0.02525826f, 0.02673975f, 0.00247781f, 0.01580972f, -0.00208765f, 
    0.01512173f, -0.01763376f, -0.00946765f, 0.00663785f, -0.00842264f, 0.01693478f, -0.02254951f, -0.02957446f, 
    -0.00308326f, 0.01443726f, 0.03556819f, 0.01554326f, -0.01499438f, -0.01176812f, 0.01721541f, 0.02906228f, 
    -0.02871578f, -0.00980687f, 0.02681428f, 0.02691502f, -0.02619889f, -0.01487089f, 0.02008548f, 0.00356867f, 
    -0.01364328f, 0.01423613f, 0.00454210f, 0.02488486f, -0.04159506f, 0.00273630f, -0.00319579f, 0.00090710f, 
    -0.00634851f, 0.03514291f, -0.02908545f, -0.03020944f, -0.02077403f, -0.02115868f, -0.02992142f, 0.00451289f, 
    -0.03642832f, 0.01423524f, 0.00002296f, -0.02936410f, 0.03695106f, -0.02251059f, -0.00124836f, 0.01944729f, 
    -0.03377837f, 0.00804227f, 0.00881737f, 0.00819979f, 0.00955986f, 0.02252329f, -0.01805002f, -0.00402657f, 
    -0.00017849f, 0.03068493f, 0.02228805f, 0.00289350f, -0.01286619f, -0.01948570f, -0.01653392f, -0.00072129f, 
    -0.00956714f, 0.03049134f, 0.01458663f, 0.01797173f, 0.01415563f, 0.00974755f, -0.03150552f, -0.01134994f, 
    0.00410852f, -0.02640582f, 0.00248689f, -0.01866790f, -0.04333521f, 0.00329612f, -0.01183029f, 0.01065513f, 
    -0.02905620f, -0.00136233f, 0.03296606f, 0.01460639f, -0.03148135f, -0.03449326f, -0.02408280f, 0.00279231f, 
    0.01581248f, -0.01498037f, 0.00064638f, -0.02442195f, 0.02592319f, 0.02470637f, 0.00247416f, 0.01471814f, 
    -0.01571056f, -0.00532967f, 0.01892065f, -0.02711762f, -0.01639874f, 0.02493989f, 0.01884761f, -0.00820065f, 
    0.01957197f, -0.02930227f, 0.02528857f, -0.00336950f, -0.00452485f, 0.00307552f, 0.00753212f, 0.01941088f, 
    0.02407492f, -0.04312665f, -0.00630451f, 0.00483829f, 0.00023722f, -0.00362178f, -0.02649591f, -0.01169219f, 
    -0.02729437f, 0.00361919f, -0.02763729f, -0.00686771f, -0.00323110f, -0.00588029f, 0.02689376f, -0.00838421f, 
    -0.01470216f, 0.00152437f, 0.00196568f, -0.02495858f, -0.01830296f, -0.04117921f, -0.04468964f, 0.00471482f, 
    -0.01111634f, -0.00651551f, -0.02103445f, 0.02947225f, 0.00630325f, 0.01949765f, -0.03648395f, -0.01284051f, 
    -0.01086819f, -0.01349532f, 0.02293946f, -0.03275878f, -0.01117462f, 0.00801565f, 0.01545411f, 0.01205044f, 
    -0.01427195f, -0.03017427f, -0.01142866f, 0.03227906f, 0.01906763f, -0.00907068f, 0.02147084f, -0.03904003f, 
    -0.03854084f, 0.00264591f, 0.00641456f, -0.02683055f, -0.03663421f, 0.03421468f, -0.02191224f, 0.00592091f, 
    -0.02497136f, 0.02065484f, -0.00274408f, 0.03651007f, -0.02068766f, 0.02575050f, -0.02675422f, 0.03833864f, 
    0.01921879f, -0.00870054f, 0.02016579f, 0.02605920f, 0.00780275f, 0.02415168f, 0.01032394f, -0.00068286f, 
    0.01239296f, -0.01774119f, -0.02682782f, -0.02022342f, -0.00303144f, 0.02049054f, -0.03574512f, -0.01899931f, 
    0.01994026f, -0.01378113f, -0.01590860f, -0.03076734f, 0.03501100f, 0.03257194f, -0.02287752f, -0.01557224f, 
    0.01122281f, 0.02189992f, 0.02847104f, -0.03414499f, -0.00151442f, -0.03783692f, 0.01150671f, -0.02774765f, 
    -0.00324364f, 0.01898828f, -0.02648696f, 0.00971075f, -0.01182842f, 0.01973780f, -0.00607595f, -0.00998946f, 
    0.00382864f, -0.03308598f, -0.00992408f, -0.00790266f, -0.00278247f, -0.01203262f, -0.00764338f, 0.02363916f, 
    -0.00678182f, 0.03044231f, -0.00555921f, -0.03404452f, 0.00602261f, 0.02703051f, 0.01286663f, -0.00703565f, 
    -0.01009986f, 0.00687539f, -0.00019686f, -0.00030306f, 0.01195981f, -0.03145726f, -0.03110310f, 0.00323482f, 
    -0.01852520f, 0.01757074f, -0.03646905f, -0.02702588f, 0.01383980f, 0.01245674f, 0.02292403f, 0.02121438f, 
    -0.03241275f, -0.03968616f, 0.00456630f, -0.02918716f, 0.00718799f, -0.01398358f, -0.04146773f, -0.02269184f, 
    0.00986828f, 0.00010414f, -0.03964295f, -0.00894677f, 0.02146826f, 0.02213437f, -0.01097000f, -0.01040629f, 
    0.00998276f, 0.01474555f, -0.03655862f, -0.02381956f, 0.02273133f, -0.01345219f, 0.00509189f, -0.00745354f, 
    -0.02159386f, 0.02886084f, 0.01823574f, -0.04120803f, 0.01567211f, 0.01991800f, 0.01552692f, -0.00874901f, 
    -0.02545976f, -0.03178721f, -0.01616868f, -0.03197190f, -0.01187897f, -0.04198905f, -0.01464607f, -0.03574931f, 
    0.00377064f, -0.03750029f, 0.02538633f, -0.02598021f, -0.00899562f, -0.00911347f, -0.00499284f, -0.03266264f, 
    -0.03598516f, -0.03502787f, -0.03866755f, 0.02676903f, 0.02411028f, 0.03035816f, -0.01943337f, -0.03181639f, 
    -0.02963572f, -0.00079090f, 0.01019791f, -0.01173285f, -0.01512842f, -0.01904924f, -0.01348783f, -0.02321726f, 
    -0.01633566f, 0.01561720f, -0.00394744f, -0.01378148f, -0.03062239f, -0.00979191f, -0.01732933f, -0.03093659f, 
    -0.02234338f, -0.00001474f, -0.02657194f, 0.00404320f, -0.01924392f, -0.03500855f, -0.00015992f, 0.01066655f, 
    0.03273540f, 0.01536239f, -0.01977406f, 0.00382999f, -0.03126215f, -0.03206668f, -0.03333733f, 0.00945990f, 
    -0.02008667f, -0.02271901f, -0.00248920f, -0.00686645f, 0.02120918f, -0.01569171f, -0.01246221f, -0.02427044f, 
    -0.01695656f, -0.02986289f, -0.03721475f, 0.00395983f, 0.00434562f, -0.01086116f, 0.02119800f, -0.01103996f, 
    0.02375473f, 0.01821972f, -0.01878596f, 0.02716249f, -0.01157907f, -0.01951296f, 0.00222192f, 0.02859732f, 
    -0.00504985f, -0.00779799f, 0.01453936f, 0.02444960f, 0.00930493f, 0.02398742f, -0.03037782f, -0.00681556f, 
    0.03025737f, -0.01794223f, -0.00750278f, -0.03680672f, -0.00707966f, -0.04598355f, -0.03468583f, -0.02187127f, 
    -0.01858043f, -0.00581278f, 0.00162888f, 0.02731304f, 0.01756966f, -0.01356995f, -0.00399312f, -0.02485960f, 
    -0.02115653f, -0.02520054f, -0.02687454f, -0.01198651f, -0.03249226f, -0.02556110f, 0.02302647f, 0.02073951f, 
    -0.03222917f, 0.00567549f, -0.02738811f, 0.03512502f, 0.02712214f, 0.00507401f, -0.03346161f, 0.00536438f, 
    0.01702227f, 0.00967664f, 0.02581061f, -0.00828323f, 0.00022020f, -0.03537175f, -0.02807046f, 0.01056581f, 
    -0.02418732f, -0.02394278f, 0.00142869f, -0.04233263f, 0.01860346f, 0.00790031f, -0.01880509f, -0.01122087f, 
    -0.02927305f, -0.00170766f, -0.03221311f, -0.03130398f, -0.01254575f, 0.01070237f, -0.00129101f, 0.01407163f, 
    -0.01866466f, 0.02139520f, -0.02890012f, 0.01466027f, -0.00809645f, -0.01524217f, 0.00844268f, -0.00338371f, 
    -0.02206142f, -0.01457562f, 0.02898571f, -0.02182116f, -0.03520393f, -0.01860386f, 0.02128104f, 0.00180773f, 
    0.03564705f, 0.00258790f, -0.02570571f, 0.02895275f, 0.00270411f, 0.02855832f, 0.00701295f, 0.00354114f, 
    -0.02173836f, -0.03915718f, -0.03226945f, -0.03801775f, 0.03172246f, -0.01657012f, -0.04342372f, -0.03194660f, 
    -0.02508799f, 0.02978425f, -0.02496827f, -0.03772858f, -0.00614622f, 0.02683531f, 0.01579176f, -0.01686200f, 
    0.00903636f, 0.02216321f, -0.02572713f, 0.02141272f, 0.00030518f, 0.03224191f, -0.00772550f, -0.03763212f, 
    0.01628669f, 0.00602156f, -0.02792431f, 0.02237885f, 0.02641405f, 0.03087392f, -0.04415073f, -0.00689415f, 
    0.03016580f, -0.01746764f, 0.02352059f, -0.00554869f, -0.03870329f, 0.01489634f, 0.02242940f, 0.01583000f, 
    -0.02956141f, -0.02545769f, -0.01106602f, 0.02402335f, -0.01011483f, 0.03114345f, 0.00056677f, -0.01122839f, 
    -0.01383017f, -0.03904063f, -0.02802734f, -0.02434896f, -0.02736852f, -0.02112329f, 0.00839830f, -0.02238533f, 
    -0.02210138f, 0.02058480f, -0.01434196f, -0.01761312f, -0.01848754f, 0.00026080f, -0.01604906f, -0.01459639f, 
    -0.02919452f, -0.01546295f, -0.03303564f, -0.00388800f, -0.02067844f, -0.01578010f, 0.01837988f, -0.00631127f, 
    -0.02244093f, 0.00503459f, 0.00667205f, -0.00998369f, 0.02322082f, -0.00754583f, 0.00898565f, -0.00893223f, 
    0.02968874f, -0.02015797f, 0.02550838f, -0.00580832f, 0.01943061f, -0.01437865f, -0.04423081f, -0.00298231f, 
    -0.00031855f, -0.03709343f, 0.01960550f, 0.01131891f, -0.01464540f, -0.03387900f, 0.00733240f, -0.03193613f, 
    0.02622168f, -0.01304370f, 0.00114176f, -0.00981608f, -0.00988516f, -0.01813511f, 0.00987690f, 0.02666600f, 
    -0.01041210f, 0.01395131f, -0.01387676f, -0.03091236f, 0.00295920f, -0.02758235f, -0.02259919f, 0.00774485f, 
    -0.03582516f, -0.01900057f, -0.00258352f, -0.02065587f, -0.02312568f, -0.01702735f, 0.02463088f, -0.03800643f, 
    0.02290677f, 0.02693873f, -0.02420049f, -0.03581807f, -0.00548749f, -0.03350760f, 0.00492606f, 0.00611234f, 
    0.01884972f, 0.01866952f, 0.01502491f, -0.00050068f, -0.04223542f, -0.01022042f, 0.02232798f, -0.04604015f, 
    0.02074306f, -0.03097071f, -0.01816402f, -0.00610766f, 0.01904635f, 0.03058995f, 0.00832782f, -0.03480389f, 
    0.00483619f, -0.00319253f, -0.00062745f, 0.01466055f, -0.01104498f, -0.00354456f, 0.00067742f, -0.03264875f, 
    -0.03450215f, 0.03096211f, -0.00055459f, -0.01567908f, 0.02701040f, -0.02307165f, -0.02529755f, -0.03333804f, 
    0.02772659f, -0.00900788f, -0.01779740f, 0.01808236f, -0.00935863f, -0.01621013f, 0.02547188f, -0.03901082f, 
    -0.03328107f, 0.01938148f, -0.01908066f, -0.00545525f, 0.01012786f, -0.03757730f, 0.01595782f, -0.03009437f, 
    -0.03019759f, -0.01664824f, -0.03783401f, -0.01670151f, 0.03016602f, -0.02114976f, 0.02462003f, -0.02278635f, 
    0.03065209f, -0.01869445f, -0.02134039f, -0.02918730f, 0.01705982f, 0.03335109f, 0.02905603f, 0.01674081f, 
    0.02332461f, 0.00793649f, 0.02064581f, 0.01263963f, -0.02846080f, -0.04292913f, 0.01989002f, -0.00536701f, 
    0.01919381f, 0.01400148f, 0.00541731f, -0.00354328f, 0.01740460f, -0.02183674f, -0.03867928f, -0.03472992f, 
    -0.01414399f, -0.01487962f, 0.02383769f, -0.00631572f, 0.02481195f, -0.00076431f, -0.02385409f, -0.00163878f, 
    0.00945176f, 0.00581578f, -0.03337407f, 0.03414911f, 0.03087577f, -0.02671509f, 0.02895420f, 0.02057743f, 
    -0.00858161f, 0.02473515f, 0.01336082f, 0.03301523f, -0.02507992f, 0.01383694f, 0.00638304f, -0.04301098f, 
    0.00808022f, -0.02424294f, -0.02449401f, -0.02133932f, 0.02867986f, 0.03122071f, -0.00369466f, -0.00775378f, 
    0.01640310f, 0.01245270f, -0.00574856f, -0.04144313f, -0.00263692f, -0.00366536f, -0.02101974f, -0.00347723f, 
    0.00359383f, 0.00707110f, -0.00059125f, -0.04156386f, -0.00237507f, -0.03172880f, 0.00011192f, -0.01505700f, 
    -0.02266750f, -0.01687073f, -0.02804646f, 0.02950347f, -0.00020303f, -0.01594153f, -0.00061145f, -0.02770084f, 
    -0.03791891f, -0.02346954f, 0.01632970f, -0.03240375f, -0.02902433f, -0.01584856f, -0.01408622f, -0.01415155f, 
    -0.00781669f, 0.00010530f, -0.01228884f, -0.03136525f, -0.02350059f, 0.02587617f, 0.03043226f, -0.03971769f, 
    -0.01701024f, -0.00477001f, 0.01974136f, 0.00654573f, 0.01823343f, 0.00246788f, 0.03232214f, 0.01879853f, 
    0.00786782f, -0.02101043f, -0.02531232f, 0.01720639f, -0.01875435f, -0.00004411f, 0.02744780f, 0.00714283f, 
    0.01028523f, -0.01317267f, -0.00232053f, -0.01432634f, 0.00995683f, 0.02872896f, -0.01884200f, -0.00307340f, 
    -0.00318951f, -0.03016688f, -0.01551483f, 0.01137346f, -0.02002145f, -0.03405939f, 0.00559176f, 0.00193006f, 
    0.02560013f, 0.02245983f, -0.00601586f, 0.00720220f, -0.01460211f, -0.03329504f, -0.02487055f, 0.02365009f, 
    -0.02697024f, -0.04085397f, -0.02283045f, -0.03815451f, -0.01765860f, -0.00121179f, 0.00678350f, 0.00297033f, 
    -0.00610968f, -0.03228542f, 0.00275698f, 0.01831442f, -0.02550495f, -0.00483569f, -0.04090270f, 0.00661912f, 
    0.00765769f, -0.04148094f, 0.01363549f, -0.03872129f, -0.00282333f, -0.00225780f, 0.02542759f, -0.01702710f, 
    0.02488193f, 0.01202068f, -0.01000065f, -0.02358096f, 0.01763651f, -0.02923561f, 0.02681733f, 0.01424779f, 
    -0.02689047f, -0.00148693f, -0.00902242f, 0.02857862f, 0.03028724f, 0.00943406f, -0.00382065f, 0.00703627f, 
    -0.02268193f, 0.01196440f, 0.00140499f, -0.00888616f, -0.00911890f, -0.03124801f, 0.01482007f, 0.02220923f, 
    0.02106771f, 0.00998725f, 0.00205902f, 0.01737976f, -0.01543496f, -0.00660899f, -0.00028128f, 0.00450755f, 
    0.00558376f, -0.00071029f, 0.02417750f, -0.00265957f, 0.01750515f, -0.03687518f, 0.00317244f, 0.01074612f, 
    -0.01081525f, -0.02526269f, -0.00539058f, 0.02632540f, 0.00597782f, -0.00429975f, -0.01272926f, 0.01797906f, 
    -0.01599357f, 0.00610943f, -0.04118231f, -0.01102054f, -0.01383448f, 0.01800741f, 0.01999082f, -0.00343085f, 
    -0.03034545f, 0.02843036f, 0.02934304f, 0.01610045f, 0.02225493f, -0.00913567f, 0.01854574f, 0.02596586f, 
    -0.01813745f, -0.01551491f, -0.01433712f, -0.01344278f, -0.02646398f, -0.03573666f, -0.01642880f, -0.01473421f, 
    -0.00587124f, -0.01596369f, -0.01813738f, -0.01420403f, -0.01528484f, 0.01231827f, -0.01323871f, -0.02224084f, 
    -0.04085620f, -0.01914465f, -0.01942022f, 0.02492678f, 0.01496490f, -0.01298035f, -0.03161905f, 0.00289534f, 
    -0.03283526f, -0.02885165f, -0.03856979f, -0.00574827f, -0.02056293f, -0.00257932f, -0.03727550f, -0.02532383f, 
    0.01975516f, 0.02154718f, -0.00535757f, -0.03523654f, -0.03850802f, -0.01540414f, -0.00632925f, 0.01969657f, 
    0.00691761f, -0.01749887f, 0.01449884f, -0.02428451f, -0.02951677f, 0.00855079f, -0.00575911f, -0.03118530f, 
    -0.03601129f, 0.01517548f, -0.01618641f, 0.02931262f, -0.02184994f, 0.01568031f, -0.03100617f, -0.03750010f, 
    -0.00378305f, 0.02842516f, -0.01749408f, -0.02064481f, -0.00441025f, -0.02466524f, 0.00746776f, 0.02850823f, 
    -0.02550131f, -0.04104355f, 0.01199335f, 0.00253790f, 0.03030167f, -0.00026505f, -0.03596656f, -0.01365436f, 
    0.02854438f, -0.00517299f, -0.01506677f, 0.00113959f, -0.01475830f, -0.03079040f, -0.04147702f, -0.03223619f, 
    -0.02608058f, 0.00419149f, 0.00665921f, -0.01200646f, 0.00072385f, -0.02127714f, -0.00432745f, -0.01402385f, 
    -0.03412132f, -0.00030764f, -0.02259013f, -0.01836343f, 0.02564309f, -0.03679642f, -0.01614854f, -0.01114620f, 
    -0.00193477f, -0.00279555f, 0.02562329f, -0.01712164f, 0.00589325f, -0.01069058f, 0.02497307f, -0.02835545f, 
    0.02637368f, 0.02474970f, 0.01889084f, 0.02395311f, -0.01010248f, -0.00322387f, -0.01095008f, 0.01504151f, 
    -0.02787562f, -0.03215808f, -0.03707256f, -0.02380651f, -0.02153605f, 0.01263135f, -0.01032128f, 0.00245346f, 
    0.02750462f, -0.02913166f, -0.00560188f, -0.02613429f, -0.01595955f, -0.00185839f, -0.02013607f, -0.00123586f, 
    0.00048584f, 0.00773477f, 0.02942000f, 0.00993848f, 0.02366170f, -0.00750081f, 0.02978293f, 0.00542687f, 
    -0.01098605f, -0.00599913f, -0.01168703f, -0.03627509f, -0.02792852f, -0.00049648f, -0.02316087f, 0.00708470f, 
    0.02005530f, 0.03266712f, 0.00375091f, -0.02587470f, -0.00097492f, 0.00660791f, -0.02160305f, -0.00809450f, 
    -0.02274420f, 0.00451879f, 0.02085683f, -0.02910664f, -0.02917699f, -0.03809839f, 0.00886368f, 0.00958349f, 
    0.02692201f, -0.02193794f, -0.03941095f, 0.02340063f, -0.02099547f, -0.03138399f, -0.01588751f, -0.03543004f, 
    -0.03092642f, -0.03058470f, -0.03648237f, -0.00971409f, -0.01816669f, 0.01304066f, -0.02896505f, 0.01406878f, 
    -0.00976177f, 0.00787117f, -0.03356204f, -0.03737898f, -0.02156606f, -0.00344078f, -0.00774389f, -0.02550645f, 
    0.00499306f, -0.00312046f, -0.04137765f, 0.01009887f, -0.01013758f, 0.01574771f, -0.00058139f, 0.00806274f, 
    -0.03161378f, -0.00912707f, -0.03784657f, 0.01547629f, 0.00118259f, -0.02180637f, 0.00805342f, -0.02291810f, 
    0.02820449f, 0.00365761f, -0.04122253f, -0.00827904f, -0.02400581f, 0.00239436f, -0.00685603f, 0.00421456f, 
    -0.03513844f, 0.02816287f, -0.01720897f, 0.00859763f, -0.02397755f, 0.01694879f, 0.01043585f, -0.00704967f, 
    -0.01376575f, 0.01328104f, 0.00796344f, -0.01437153f, 0.02074914f, -0.04059420f, -0.00944676f, 0.02227174f, 
    -0.03544750f, 0.02706593f, -0.01013982f, 0.00737082f, -0.03140302f, -0.00162762f, 0.01866445f, -0.02406036f, 
    -0.02091855f, -0.03479197f, -0.01862314f, 0.01636693f, -0.02834070f, -0.01391442f, 0.00555103f, -0.01168817f, 
    -0.03574357f, -0.01071682f, -0.01305406f, -0.00046410f, 0.01231654f, -0.03283554f, -0.02929431f, -0.02959824f, 
    0.01585835f, 0.00972418f, -0.04046553f, -0.02406529f, -0.00928882f, -0.01729256f, -0.00390403f, 0.00179617f, 
    0.00655045f, -0.04054390f, 0.02413998f, 0.02458028f, 0.02077794f, 0.01351232f, -0.00547797f, 0.02481154f, 
    -0.03468260f, -0.02398478f, 0.02755445f, -0.03275217f, -0.02827258f, 0.01010726f, 0.00769987f, -0.00391113f, 
    -0.02305767f, -0.03853921f, -0.01907431f, -0.03674770f, -0.04001237f, -0.03912361f, 0.00433527f, -0.00441011f, 
    -0.00274139f, 0.00877986f, 0.01930435f, -0.03837153f, 0.00907292f, 0.01031714f, 0.02199541f, 0.00123588f, 
    0.02180216f, -0.02656349f, 0.01621835f, -0.01874727f, 0.01829824f, -0.02790998f, 0.01490976f, 0.01196989f, 
    0.01294629f, -0.02561967f, -0.02717637f, 0.00033757f, -0.01663778f, 0.00719001f, 0.02635351f, 0.00772889f, 
    0.00768815f, 0.02689647f, 0.00238559f, -0.03362809f, -0.03398219f, 0.02586049f, -0.03919873f, -0.03154083f, 
    -0.01730185f, -0.02779042f, 0.00907676f, 0.01170275f, 0.00553099f, -0.03264297f, 0.01843527f, 0.00026705f, 
    0.01428036f, 0.00930097f, 0.01576054f, -0.02868686f, -0.01975111f, 0.02845075f, 0.00496764f, -0.01391575f, 
    -0.02155134f, -0.02366578f, -0.00022125f, -0.00531897f, -0.03083141f, 0.00762322f, 0.01393696f, -0.01755697f, 
    0.02573005f, 0.00121208f, -0.00787283f, 0.02214554f, 0.01105935f, -0.00649549f, 0.01590879f, -0.03398176f, 
    0.00786299f, -0.02580494f, -0.00170264f, 0.02781603f, -0.03628677f, 0.00815652f, 0.00419461f, 0.02378844f, 
    0.00647248f, 0.00423294f, -0.03323492f, -0.01394049f, -0.02652012f, -0.01468989f, -0.02885731f, 0.01202786f, 
    -0.01661469f, 0.01375039f, -0.03109981f, -0.00904582f, 0.00881612f, -0.02008508f, -0.00321799f, -0.02745822f, 
    -0.00755165f, -0.03407716f, -0.02521703f, 0.02938807f, -0.03026246f, 0.00581479f, 0.01713704f, 0.00870551f, 
    -0.03150574f, 0.02700580f, 0.01648198f, 0.01470581f, -0.00176002f, 0.02862437f, 0.01263462f, 0.03093739f, 
    0.02033363f, -0.02132989f, -0.00903319f, 0.01797590f, -0.01805848f, -0.02873845f, -0.02131106f, -0.01163774f, 
    0.01425738f, -0.02577992f, -0.01713176f, 0.00346102f, -0.02375903f, -0.01693977f, 0.01025392f, 0.01144339f, 
    -0.02740974f, -0.02559739f, -0.02182066f, 0.02384614f, -0.01174858f, -0.02380847f, 0.02685203f, 0.00076121f, 
    0.01865949f, -0.03617435f, -0.01130289f, -0.01026634f, 0.00828426f, 0.01050089f, -0.03395597f, 0.02716624f, 
    -0.00799603f, -0.03189297f, -0.03222482f, 0.02129549f, 0.02700555f, -0.03891083f, -0.00107465f, -0.02208670f, 
    -0.02067959f, 0.02651060f, -0.00856265f, -0.02174730f, -0.02273018f, -0.02574131f, 0.00858153f, 0.02509360f, 
    0.00524350f, -0.02588835f, -0.01423302f, -0.01922481f, -0.03119228f, 0.02121539f, -0.01599520f, 0.02588990f, 
    -0.03103891f, 0.02332833f, 0.02592290f, -0.02994642f, -0.02710104f, 0.03050775f, -0.02268492f, -0.03466447f, 
    -0.03910585f, -0.00350179f, 0.00240044f, -0.02573544f, 0.01590812f, 0.01906241f, -0.00865449f, 0.01078345f, 
    -0.01348421f, 0.00243097f, 0.01390860f, 0.02750709f, -0.03717718f, -0.02527243f, -0.00474993f, 0.00536114f, 
    0.01744755f, 0.01839184f, -0.01753975f, -0.03533068f, 0.00054942f, 0.01457295f, 0.01121802f, 0.01458576f, 
    -0.01544180f, -0.02937942f, 0.00929679f, 0.00750132f, 0.01535994f, -0.00121851f, 0.01908867f, -0.02466775f, 
    -0.03555226f, -0.03631013f, -0.02361370f, -0.01321785f, -0.00891291f, -0.02119943f, 0.00244520f, 0.00284208f, 
    0.01918949f, -0.00406948f, 0.00346580f, -0.02405053f, -0.03979347f, -0.02687780f, 0.01679641f, -0.03487068f, 
    0.02478330f, 0.02144966f, 0.02489578f, 0.02374334f, -0.00360367f, 0.01771346f, -0.03652854f, -0.02917787f, 
    -0.00694864f, 0.00096764f, -0.01623919f, 0.01333624f, -0.01530057f, -0.01873350f, 0.00334305f, -0.03723074f, 
    0.00721455f, -0.03017272f, 0.02690767f, -0.01469152f, 0.01628041f, 0.00429549f, -0.01148217f, 0.00234204f, 
    0.00834340f, -0.02553941f, -0.00019569f, 0.00734027f, 0.00876893f, 0.01788974f, -0.03577585f, -0.01903462f, 
    0.03008494f, -0.00507035f, 0.02046694f, -0.03025539f, -0.03904654f, -0.01595834f, 0.01188789f, -0.03386002f, 
    0.00977589f, -0.03037157f, 0.02016004f, -0.02334422f, -0.02628840f, -0.01962651f, 0.02939332f, -0.01009523f, 
    -0.01210442f, 0.01769193f, -0.01334270f, -0.00309676f, -0.03646677f, 0.00853070f, -0.00895749f, -0.04163579f, 
    -0.02145834f, 0.02351229f, -0.00250176f, 0.03037725f, -0.00061020f, 0.01073847f, 0.02532061f, 0.00509025f, 
    0.02007079f, -0.03182122f, -0.02975471f, 0.01711172f, -0.03493529f, 0.01982034f, -0.02672574f, -0.02672205f, 
    -0.02267547f, 0.00260293f, -0.00578465f, 0.01621246f, 0.00497161f, 0.02186329f, -0.03178596f, -0.00298275f, 
    -0.00254467f, 0.01796403f, -0.03759880f, 0.02417911f, -0.03712738f, -0.03389109f, -0.00572164f, -0.02705885f, 
    -0.00387722f, -0.03772755f, -0.02805501f, -0.02549958f, -0.01633601f, 0.02531742f, 0.03040898f, -0.03029140f, 
    0.02858529f, 0.01473605f, -0.01178390f, 0.00267144f, -0.03325033f, -0.03327410f, 0.00428940f, -0.02747554f, 
    0.00162929f, -0.03455663f, 0.02174187f, -0.03636211f, -0.03820720f, -0.03028359f, -0.03112946f, -0.02832057f, 
    -0.01802072f, -0.02233909f, 0.02173675f, 0.02524399f, -0.04022429f, -0.02892546f, 0.01038556f, -0.03560692f, 
    -0.00330643f, -0.01330636f, -0.03121633f, 0.01558372f, -0.02853104f, 0.00956558f, -0.00054241f, -0.02314260f, 
    0.02597003f, -0.00118983f, -0.03518734f, -0.02275233f, 0.03854568f, 0.01410952f, -0.01576797f, 0.02724324f, 
    -0.00945714f, -0.02763477f, -0.02296567f, -0.00360407f, 0.02319152f, -0.02608437f, 0.02085253f, -0.02960282f, 
    0.02684941f, 0.01622121f, 0.02202808f, 0.00787482f, 0.01300613f, -0.00298669f, 0.02927965f, -0.03678957f, 
    -0.00011232f, 0.00967491f, -0.03937710f, -0.00090466f, -0.01464903f, -0.01325180f, -0.02225897f, -0.00681133f, 
    0.01659752f, 0.03023896f, -0.03025738f, -0.02365969f, -0.03824895f, -0.00466606f, -0.03129277f, 0.02566624f, 
    -0.00028489f, 0.01848470f, -0.03748460f, 0.01958819f, 0.00126908f, -0.03205325f, -0.02060963f, -0.02558179f, 
    0.02221067f, -0.01764731f, -0.02415324f, -0.01018832f, -0.02151867f, -0.01457996f, -0.01613981f, -0.02499317f, 
    -0.01105843f, 0.00298824f, -0.00802802f, 0.01484811f, -0.01215767f, -0.01833844f, 0.01884345f, -0.03048401f, 
    0.02645490f, -0.01235125f, -0.00095646f, 0.02977200f, -0.01933991f, 0.01418948f, 0.01101266f, 0.01559959f, 
    -0.01762986f, 0.00888846f, -0.00897240f, -0.03511836f, -0.00916366f, -0.03200218f, -0.02583600f, -0.02769844f, 
    -0.03604049f, 0.02213335f, -0.01458626f, -0.01730646f, 0.02906606f, 0.03898762f, 0.02559137f, 0.02164160f, 
    0.00167442f, 0.02557794f, -0.00611255f, 0.02603682f, -0.02911572f, -0.00131378f, 0.00386027f, -0.01110621f, 
    0.01962505f, 0.00627023f, 0.02852570f, -0.02733050f, -0.00343608f, 0.01500838f, 0.01423245f, -0.02978103f, 
    0.00284081f, -0.02092762f, -0.00280668f, -0.00018345f, 0.02124293f, 0.02158735f, -0.00097018f, -0.01036185f, 
    0.02258500f, 0.02618859f, -0.01269946f, -0.01925156f, -0.01935514f, 0.00781284f, -0.02903972f, 0.02057207f, 
    0.02099555f, -0.01466193f, 0.01415293f, -0.02367136f, 0.01237768f, 0.01951809f, -0.04109387f, -0.00823693f, 
    -0.02855615f, -0.03365944f, 0.00232790f, 0.02772192f, -0.03642844f, 0.00074663f, -0.00106088f, 0.00766816f, 
    -0.02482193f, 0.00024254f, -0.02858034f, -0.02268224f, -0.02989671f, 0.03058477f, 0.02147060f, 0.00403889f, 
    -0.00346876f, -0.02566660f, 0.02585543f, -0.03796085f, 0.00602811f, 0.00431029f, -0.03459298f, -0.03268015f, 
    -0.02478803f, 0.01423257f, -0.03034815f, 0.01712508f, -0.02685180f, -0.01022055f, -0.01145520f, -0.00508960f, 
    0.02539102f, 0.00185501f, 0.02895292f, -0.00467956f, -0.00843817f, 0.00648947f, -0.02439196f, 0.04034930f, 
    0.02697178f, 0.03073350f, -0.01405452f, 0.03617822f, -0.02638186f, -0.00374990f, -0.02780448f, 0.02813448f, 
    -0.01254449f, -0.01569736f, -0.02592527f, -0.00560382f, -0.02256147f, 0.01336315f, 0.00595834f, -0.02873551f, 
    0.03019694f, -0.00978768f, -0.00498066f, -0.03007321f, -0.03030860f, -0.02508079f, 0.00854568f, 0.02361012f, 
    -0.02151067f, -0.02254799f, -0.03171945f, -0.03483378f, -0.02573122f, -0.03866783f, 0.02443629f, -0.00506860f, 
    -0.02449256f, -0.00619405f, -0.02054671f, 0.00507997f, 0.01741792f, 0.00764820f, -0.04062397f, 0.02607217f, 
    -0.02150971f, -0.02375571f, -0.01010752f, -0.01499562f, 0.01595499f, 0.02023540f, -0.02753628f, 0.01124939f, 
    -0.00464129f, -0.02596229f, 0.01221253f, -0.00376869f, -0.02289517f, -0.03186740f, 0.03671839f, -0.00064990f, 
    -0.01739536f, 0.01713712f, -0.03715533f, -0.02520087f, 0.02212788f, 0.00194516f, -0.01248952f, 0.02800915f, 
    0.02994789f, 0.00117867f, -0.03432978f, -0.02064735f, -0.00768123f, -0.02581060f, -0.00753794f, 0.02914141f, 
    0.02103026f, 0.02550858f, -0.03305982f, 0.01718097f, 0.02302930f, 0.02333575f, -0.00205860f, -0.03784133f, 
    -0.03423240f, -0.02112760f, -0.02305556f, 0.02399376f, 0.01246933f, -0.00768940f, -0.00738983f, 0.02692797f, 
    -0.00306383f, -0.01021480f, -0.03429190f, 0.00638635f, -0.00463340f, 0.01294484f, -0.01955167f, -0.01264305f, 
    0.00853476f, 0.01954087f, -0.01735487f, -0.01720363f, 0.01696756f, -0.02979140f, 0.00755894f, 0.02842731f, 
    0.01659922f, 0.01139293f, -0.02200511f, 0.00711358f, -0.02919666f, 0.02234221f, -0.00891939f, 0.02679878f, 
    0.00837455f, 0.00056919f, -0.01109457f, -0.01324947f, 0.01438210f, -0.01632744f, -0.00695457f, -0.02917229f, 
    -0.02669721f, -0.01909343f, -0.02429248f, -0.00717363f, 0.00262627f, -0.02835054f, 0.01238356f, 0.03156117f, 
    -0.03843131f, -0.00615398f, 0.02812553f, 0.03222271f, -0.02351465f, 0.02131317f, 0.00765685f, -0.02682453f, 
    0.02304319f, -0.00979614f, 0.01209116f, 0.02234276f, -0.02278766f, -0.02014120f, 0.00798652f, 0.01629063f, 
    0.01596348f, 0.02390943f, 0.01537925f, 0.01287631f, -0.03414752f, -0.00392667f, -0.01450275f, -0.03086563f, 
    0.01856019f, -0.02884015f, -0.02944352f, -0.02830050f, -0.02033747f, -0.01574690f, -0.04090609f, 0.01682759f, 
    -0.02622746f, -0.02916850f, 0.01521367f, -0.01805553f, -0.04097262f, -0.02639750f, 0.01377812f, -0.03181390f, 
    -0.00798758f, 0.01648445f, -0.00174802f, 0.00994346f, 0.02426639f, 0.02794199f, -0.03217328f, 0.00769862f, 
    -0.00688586f, -0.00840604f, 0.02967472f, -0.00703366f, 0.00587483f, -0.03709347f, 0.02636641f, -0.03296475f, 
    0.01596984f, -0.00486304f, -0.02274957f, -0.00998732f, 0.01919861f, 0.02641286f, -0.03513668f, 0.02479756f, 
    -0.00156218f, -0.00281707f, 0.03315743f, -0.01258668f, -0.00738660f, 0.00062834f, -0.03116201f, 0.01644802f, 
    0.02390469f, -0.03998497f, 0.03350596f, -0.02554751f, -0.01868802f, 0.02227647f, -0.03755485f, 0.01911872f, 
    -0.01253499f, -0.02419450f, -0.03489602f, 0.01675951f, -0.02692026f, -0.00083636f, -0.02359377f, -0.01425014f, 
    -0.02132852f, -0.01167994f, 0.00223837f, -0.00750600f, 0.00085995f, 0.02441508f, 0.02833764f, -0.01993843f, 
    -0.03718212f, -0.00001079f, -0.02529425f, -0.00651758f, 0.00232425f, -0.01045328f, -0.02268677f, -0.02350002f, 
    -0.02738250f, -0.02656431f, -0.00679684f, 0.02416479f, -0.03863741f, 0.01194193f, -0.03071716f, -0.02902811f, 
    0.02507552f, -0.01443967f, 0.00513108f, 0.00196856f, -0.01941349f, 0.01415572f, -0.00331643f, -0.01694231f, 
    -0.01478796f, -0.03199879f, 0.01857166f, -0.01267253f, -0.04116864f, 0.02505155f, -0.04021509f, -0.00679729f, 
    0.00356787f, 0.01093986f, -0.00719515f, -0.03901247f, -0.01424281f, -0.03531631f, -0.00559277f, 0.02612656f, 
    0.01063442f, -0.03713511f, -0.01177626f, -0.00249537f, 0.01020924f, 0.00764522f, -0.03139846f, 0.00068379f, 
    0.02629567f, -0.01713032f, 0.01578495f, 0.01494715f, 0.03582582f, 0.03197441f, 0.03226288f, -0.03086420f, 
    -0.02103237f, 0.01862262f, -0.00253290f, -0.01027332f, -0.01349778f, 0.02154945f, -0.01634781f, -0.00607480f, 
    0.01093823f, 0.01293503f, -0.02117275f, -0.03991123f, -0.02638170f, 0.00907868f, 0.02000079f, 0.00129753f, 
    -0.03102090f, -0.02572487f, -0.00818946f, 0.02394028f, 0.00835915f, 0.02250743f, -0.01218207f, -0.01323813f, 
    0.00735133f, 0.01605297f, 0.02571351f, -0.03348685f, -0.00212144f, 0.01499073f, 0.00233878f, -0.01291697f, 
    0.01115817f, 0.02209164f, -0.01476322f, -0.00328952f, 0.03633849f, 0.02566078f, -0.04135846f, -0.00673105f, 
    -0.01085826f, -0.03118730f, 0.00485652f, 0.00152085f, 0.01040414f, 0.00859762f, 0.00373074f, 0.00199734f, 
    0.00415339f, 0.01298621f, -0.00820031f, 0.01444097f, -0.03847378f, -0.03689846f, 0.03012088f, 0.00826933f, 
    0.02189912f, -0.01084016f, -0.00736587f, -0.03423155f, -0.02936523f, -0.02961927f, 0.01236502f, -0.02802619f, 
    -0.01085196f, 0.02889413f, -0.00931949f, 0.00802251f, -0.00534692f, 0.00070744f, -0.00444865f, -0.03031221f, 
    -0.01350630f, -0.03709786f, 0.02868067f, 0.02256207f, -0.00057752f, -0.02062346f, -0.02053859f, 0.01476570f, 
    0.02646240f, 0.01342086f, -0.00458197f, -0.02865483f, -0.03962336f, -0.01406620f, 0.03050758f, 0.01611531f, 
    0.02108421f, -0.03849722f, -0.02183080f, 0.00892567f, -0.03810162f, -0.00399189f, 0.02242093f, -0.00566161f, 
    0.01353666f, 0.03769337f, -0.04038752f, 0.00146012f, -0.01999291f, 0.00398637f, 0.00692349f, 0.00390195f, 
    0.02731282f, 0.00763637f, -0.03675362f, -0.00003329f, -0.00891196f, 0.02847171f, -0.03573351f, -0.01157392f, 
    -0.00882033f, 0.01508150f, -0.01808668f, -0.03227445f, 0.01670181f, -0.03497474f, -0.03176918f, -0.02948546f, 
    -0.03992692f, -0.01641661f, -0.00692728f, 0.01823751f, 0.00944274f, -0.01660026f, -0.03944926f, -0.03168324f, 
    -0.01220766f, -0.01982155f, 0.00440691f, -0.02548317f, -0.02098665f, -0.01049702f, -0.00826525f, -0.01676067f, 
    0.01827861f, -0.01848534f, -0.02882766f, -0.00859157f, -0.02644769f, -0.01688091f, 0.00432038f, -0.00767986f, 
    -0.01778730f, -0.00554499f, -0.03762505f, 0.00345969f, 0.00606423f, -0.03676178f, 0.02643442f, 0.02028923f, 
    -0.00408783f, -0.03516204f, -0.02645774f, 0.01619377f, -0.01889526f, -0.02599467f, 0.03284059f, -0.00985806f, 
    0.03587053f, -0.00594066f, 0.01928255f, -0.00013517f, -0.02588589f, -0.02352894f, 0.01193654f, 0.00986956f, 
    0.02554339f, 0.01016436f, -0.00240957f, 0.02345181f, -0.03115018f, 0.01028398f, -0.01473020f, -0.02073223f, 
    -0.00030062f, 0.00232421f, -0.02919075f, -0.00336646f, 0.00822295f, -0.04005198f, 0.02074175f, 0.02122314f, 
    0.01564379f, -0.02404730f, 0.02974251f, 0.00155803f, 0.01986091f, -0.01042912f, 0.00226236f, 0.00904624f, 
    0.00084995f, -0.01917917f, -0.01227558f, -0.02850840f, 0.01234465f, -0.00292418f, 0.00312256f, -0.02380189f, 
    -0.03765574f, 0.00832238f, 0.00864535f, 0.01570922f, 0.00011659f, -0.00262582f, -0.03129528f, 0.01149330f, 
    0.01841815f, -0.01779257f, 0.01011381f, 0.00273297f, -0.01709346f, -0.02716251f, 0.03290349f, 0.01669982f, 
    0.00216112f, -0.00655067f, -0.00263217f, -0.03020039f, -0.00336942f, 0.01327507f, -0.02682921f, 0.01922212f, 
    -0.03960115f, 0.01171289f, -0.00450778f, -0.02369128f, -0.01093601f, 0.01481418f, -0.01912456f, -0.00458995f, 
    0.01828367f, -0.02877961f, 0.02531673f, 0.00013530f, -0.03054182f, -0.00345664f, 0.02142564f, -0.01027112f, 
    0.00622576f, -0.01295530f, 0.00984742f, -0.01176278f, 0.00531664f, 0.01040470f, 0.02867792f, 0.01154942f, 
    0.02716333f, -0.03615841f, -0.03628814f, -0.00567752f, -0.01625574f, 0.00146439f, -0.04112962f, 0.02271456f, 
    0.02763423f, -0.01442981f, 0.01828568f, -0.01798263f, -0.03963272f, -0.00124902f, -0.01720058f, 0.00783458f, 
    -0.00830546f, -0.03382893f, -0.03469232f, 0.00617545f, 0.00712014f, -0.00167753f, 0.02483254f, 0.00355357f, 
    0.01167638f, -0.00983945f, -0.01636917f, -0.03711976f, 0.00849105f, -0.03921406f, 0.02443479f, -0.02276438f, 
    -0.00954238f, -0.02998972f, -0.03374505f, 0.00767181f, -0.02285840f, -0.02706597f, -0.02162795f, 0.01265114f, 
    0.02499770f, -0.00138117f, 0.02282634f, -0.03170496f, -0.01944089f, -0.02601942f, -0.02619142f, -0.02621610f, 
    0.00396315f, -0.13312110f, 0.25920695f, 0.00673041f, 0.05903443f, 0.02182207f, 0.07502314f, -0.02329448f, 
    0.03583312f, -0.09273585f, 0.03105194f, 0.04516441f, -0.14309731f, 0.06427453f, 0.03209968f, 0.16426155f, 
    0.15406960f, -0.00979968f, 0.05373928f, -0.13543352f, -0.13427781f, 0.03997941f, -0.02244004f, 0.02165994f, 
    0.06647585f, -0.23274921f, 0.20798366f, 0.08993766f, -0.08060163f, 0.03275982f, -0.07961600f, -0.06502108f, 
    -0.01557098f, 0.00950380f, -0.01833949f, -0.13140517f, 0.24071601f, -0.16462900f, 0.21605434f, 0.12162101f, 
    0.15039513f, -0.15142600f, -0.13729848f, 0.09136149f, -0.08686904f, -0.00870818f, -0.07185879f, -0.10335031f, 
    0.13653424f, 0.23447610f, 0.16041256f, 0.29465824f, 0.05466306f, 0.03419231f, -0.05447091f, 0.03057679f, 
    0.03507298f, -0.04913220f, -0.07350437f, 0.00912844f, 0.16006804f, 0.10111695f, 0.11138872f, 0.06241480f, 
    -0.05022455f, -0.00477756f, 0.01789677f, 0.14992017f, -0.02177797f, 0.06182810f, 0.09697586f, -0.06349926f, 
    0.03425202f, 0.16345641f, 0.06557246f, 0.13855331f, -0.15937662f, -0.20333788f, -0.05813732f, 0.12044305f, 
    0.05750573f, 0.01934103f, -0.07526726f, -0.03557030f, 0.46761495f, 0.13172522f, 0.11202565f, 0.26746303f, 
    0.02087698f, 0.13850474f, -0.01790809f, 0.01717681f, 0.04309751f, 0.06793300f, 0.00285141f, 0.03023167f, 
    0.03456347f, -0.25646800f, 0.44417226f, -0.01156690f, 0.17891222f, 0.05969026f, -0.07693523f, -0.00650200f, 
    -0.07940447f, 0.11734453f, 0.02102308f, 0.19391306f, -0.14526272f, -0.00766946f, -0.06542854f, 0.04119812f, 
    0.16804734f, -0.05503069f, 0.18554533f, 0.10432717f, 0.19398628f, 0.03667156f, -0.01110748f, -0.17692085f, 
    -0.36032048f, 0.31581712f, 0.01191342f, -0.01042411f, 0.12570202f, 0.04476981f, 0.07775809f, 0.06242982f, 
    0.00324914f, -0.03285502f, -0.01263034f, -0.02461864f, 0.26323301f, 0.01753395f, -0.01129582f, -0.13105236f, 
    0.18939829f, 0.10211982f, -0.14502925f, 0.20689258f, 0.04753483f, 0.05657736f, -0.03142045f, 0.05509477f, 
    -0.10889751f, 0.26630259f, 0.09234515f, -0.16899666f, -0.04667764f, 0.01130594f, 0.03234076f, -0.03415990f, 
    0.02432531f, 0.05564168f, 0.02390079f, 0.00944320f, -0.13618402f, -0.01282099f, -0.25874838f, 0.05416770f, 
    0.13914311f, -0.07460190f, 0.00326061f, -0.03078937f, 0.09430618f, 0.15748836f, 0.00258056f, -0.06776682f, 
    0.09254293f, 0.11949874f, 0.19270858f, 0.09497423f, -0.11926037f, -0.10434019f, 0.01424360f, 0.08035391f, 
    0.01104339f, 0.01103173f, -0.07969978f, -0.00754994f, 0.26222464f, -0.06508440f, 0.24958976f, -0.04216003f, 
    -0.04638841f, -0.03333589f, -0.08527932f, 0.06739943f, 0.02939652f, -0.00705406f, 0.01732379f, 0.04596089f, 
    -0.09005650f, 0.10569475f, -0.11855324f, -0.09157078f, 0.00394462f, -0.04385849f, -0.04129546f, -0.05739871f, 
    -0.04794931f, -0.05402442f, 0.01647995f, -0.08964825f, 0.30063435f, 0.10370947f, 0.23274769f, 0.28597027f, 
    0.05522071f, -0.00528644f, 0.05249115f, 0.05255615f, -0.02796540f, -0.00116468f, -0.07203019f, -0.08262198f, 
    -0.04201934f, 0.20380947f, 0.01837342f, 0.13914426f, -0.02380292f, -0.04455171f, 0.06063918f, 0.08622548f, 
    -0.02645507f, -0.06616519f, -0.07216155f, -0.03649906f, 0.04881246f, -0.07571862f, 0.11848060f, 0.26236236f, 
    -0.12493036f, -0.04499481f, 0.13330422f, 0.11226897f, 0.03993163f, -0.11902970f, 0.01536372f, 0.03028362f, 
    -0.23133095f, 0.05519858f, -0.20842271f, -0.00529720f, -0.05900288f, 0.02916118f, -0.02340368f, -0.07184698f, 
    0.06836118f, -0.06359059f, 0.22945516f, 0.04588953f, 0.11988433f, 0.19945423f, 0.18774980f, 0.30701196f, 
    -0.05462831f, -0.02693654f, 0.11209758f, 0.18071678f, -0.01467672f, 0.03176305f, -0.05332540f, -0.00195163f, 
    0.46221101f, 0.21186619f, 0.27051619f, -0.00218404f, 0.01858931f, 0.16974612f, 0.09070600f, 0.09967830f, 
    0.00548653f, 0.02341404f, 0.15556531f, 0.06518684f, 0.34038258f, 0.01863893f, 0.20307603f, 0.18541084f, 
    0.04155431f, -0.09910370f, 0.01340685f, 0.00623394f, 0.01313246f, -0.00527873f, 0.04390906f, 0.11534504f, 
    0.02893994f, -0.01759275f, 0.09150470f, -0.00755245f, 0.00766816f, 0.07496550f, -0.08314106f, 0.10512401f, 
    -0.04376103f, 0.11026791f, -0.04886748f, -0.05298256f, 0.05013897f, 0.11442172f, 0.18086809f, -0.14713867f, 
    0.00437328f, 0.04591519f, -0.08020654f, 0.00914373f, -0.07724901f, -0.03830726f, -0.14218928f, -0.00248170f, 
    -0.16028720f, 0.02264304f, -0.09106658f, 0.06742150f, 0.23696469f, -0.04273054f, 0.02274027f, -0.02757457f, 
    0.05714391f, 0.13393967f, -0.08387256f, 0.01092804f, 0.19907889f, 0.06847710f, 0.25950146f, 0.09217653f, 
    -0.01614572f, -0.09667781f, 0.01214822f, 0.06633791f, -0.02033747f, 0.01686619f, -0.09748972f, 0.04769273f, 
    0.49028739f, -0.02521890f, 0.13567740f, -0.18797202f, 0.05212975f, 0.03562610f, -0.12319083f, 0.05050276f, 
    -0.03611667f, 0.00796690f, 0.01700587f, 0.06440098f, -0.28392383f, 0.07055523f, -0.23885664f, 0.01915226f, 
    0.10822283f, 0.04371568f, 0.05406909f, -0.08357042f, -0.00509503f, 0.01824284f, 0.09274282f, 0.02304370f, 
    0.25209799f, -0.02743301f, 0.09244205f, 0.02547568f, 0.04584834f, -0.01671576f, -0.04444995f, -0.02452008f, 
    0.05112425f, 0.06909508f, -0.10339787f, 0.00860640f, 0.06532712f, -0.07628337f, -0.00203799f, 0.18873900f, 
    -0.06589557f, -0.04465799f, -0.12860340f, -0.02985100f, -0.19282249f, 0.14597720f, -0.07094493f, -0.03342687f, 
    0.11836834f, 0.15934300f, 0.19564657f, -0.09312898f, 0.09809467f, 0.09527028f, -0.09192750f, -0.00046235f, 
    -0.01795779f, 0.11769980f, 0.17710961f, 0.07465664f, -0.15184657f, -0.13788715f, 0.27631474f, 0.20902339f, 
    0.01965817f, 0.09614266f, 0.04445564f, 0.03297718f, -0.09719345f, -0.01505390f, -0.10230333f, 0.08980621f, 
    0.10461850f, 0.23598200f, 0.19720246f, 0.00306375f, 0.11353303f, -0.07297083f, -0.07032237f, 0.11730686f, 
    -0.01513833f, 0.10402080f, -0.03808302f, -0.07068181f, -0.12203768f, -0.42750701f, -0.05336942f, 0.12059348f, 
    0.04392435f, 0.05664710f, 0.07055111f, -0.08219863f, -0.04984115f, 0.01821257f, -0.06541655f, 0.05116523f, 
    0.05675698f, -0.21187770f, 0.29473457f, 0.13855760f, -0.06400707f, 0.05714304f, -0.01281280f, -0.03705088f, 
    -0.00260542f, 0.07959753f, 0.06296465f, 0.11911976f, 0.08738122f, 0.10586940f, 0.24972443f, -0.02662592f, 
    0.14520589f, -0.07543946f, 0.09822690f, 0.02268728f, -0.07771041f, -0.01384312f, -0.07883709f, 0.09152477f, 
    0.06243476f, 0.08719075f, -0.10918031f, 0.24868976f, -0.01280240f, -0.02407000f, 0.19622423f, 0.16711335f, 
    -0.14336370f, -0.02895219f, -0.02046678f, 0.11181632f, -0.13751076f, 0.01922167f, -0.00083315f, 0.05387285f, 
    0.09943835f, 0.14580169f, 0.05247117f, -0.03209549f, 0.08403938f, 0.00107557f, 0.18409190f, 0.11227918f, 
    0.04171649f, -0.11369839f, -0.23506615f, 0.08424213f, -0.07585528f, 0.05501282f, 0.16956228f, -0.00595300f, 
    -0.00254295f, 0.00354468f, 0.02356254f, 0.00287352f, -0.27562538f, -0.15806936f, -0.05192230f, -0.03725475f, 
    -0.09766741f, 0.05210072f, 0.00031420f, 0.07168221f, -0.05887063f, 0.07365625f, 0.06792088f, 0.00171978f, 
    0.05509792f, -0.05525702f, 0.25160697f, -0.17359342f, 0.08695815f, -0.07046123f, -0.04657239f, 0.01905211f, 
    0.04073614f, -0.03105761f, -0.02398037f, -0.12076665f, 0.29029322f, -0.04166562f, 0.20487078f, 0.02624035f, 
    0.14893918f, -0.06263983f, -0.09914824f, -0.07940191f, 0.06464779f, 0.04930912f, 0.11743046f, -0.01406597f, 
    0.00680084f, -0.23990834f, 0.31015548f, -0.00058653f, 0.04857892f, 0.08328593f, 0.06846174f, -0.05502500f, 
    -0.03162978f, 0.03065478f, 0.04610105f, 0.20329215f, 0.03699497f, 0.12023530f, -0.03681070f, 0.01251561f, 
    -0.02051574f, -0.06213348f, 0.03049959f, -0.06064491f, -0.01159342f, 0.03126246f, -0.08354366f, -0.01624355f, 
    -0.15044147f, 0.16538635f, -0.07980210f, 0.36700916f, 0.10099837f, -0.12582910f, -0.06392033f, -0.13817605f, 
    -0.06545240f, 0.03170114f, 0.03838902f, -0.01685218f, -0.04966872f, 0.00563449f, -0.03387410f, 0.02891435f, 
    0.02054175f, -0.03255971f, -0.04681482f, -0.09873486f, -0.18201874f, -0.01955306f, 0.05557019f, -0.11594832f, 
    0.00910877f, -0.03592817f, 0.37925392f, -0.11999813f, -0.08676214f, 0.02773334f, -0.04245056f, -0.01637473f, 
    -0.03306998f, 0.02364105f, 0.00754267f, -0.02746857f, 0.05137170f, 0.05408835f, -0.08207592f, 0.04585554f, 
    -0.05402042f, 0.04438218f, 0.08635329f, 0.19833493f, -0.05723288f, 0.12891650f, 0.03548597f, -0.04329758f, 
    -0.30740482f, -0.26624435f, 0.15247406f, 0.22002541f, -0.14509591f, -0.05047893f, 0.05391072f, 0.00726586f, 
    -0.01103430f, 0.08741118f, -0.12600544f, 0.10235970f, 0.12559043f, 0.11959241f, 0.19939919f, -0.02440165f, 
    0.11023327f, -0.03087852f, -0.10242192f, -0.06183575f, 0.00770832f, -0.02717217f, 0.12475819f, 0.00097055f, 
    -0.14788328f, 0.13505855f, -0.02968390f, -0.02826270f, 0.14271539f, -0.12392659f, 0.05224052f, 0.09126088f, 
    0.00330949f, 0.22244146f, 0.12152299f, 0.03074808f, 0.19101287f, 0.19168179f, 0.05032271f, 0.29867840f, 
    -0.02166684f, 0.08332027f, -0.04919067f, 0.09635644f, -0.06143977f, 0.04602737f, -0.01650218f, 0.06802733f, 
    0.06392770f, -0.01723790f, 0.18651947f, -0.25512874f, 0.04847164f, 0.09154183f, 0.07456580f, -0.04495944f, 
    -0.09040259f, 0.14660548f, 0.02132773f, -0.04844128f, -0.12865143f, 0.15909126f, -0.23576201f, 0.06829279f, 
    -0.01547395f, -0.02192788f, 0.01686891f, -0.05626910f, -0.06493553f, 0.03041271f, -0.01298641f, 0.05273944f, 
    -0.07166945f, -0.05621632f, 0.06391659f, -0.05228707f, -0.03285197f, -0.04220648f, -0.10561017f, -0.02402575f, 
    -0.14909875f, -0.03720858f, 0.05435791f, -0.08185910f, 0.17656201f, 0.08937177f, 0.10147899f, 0.14104602f, 
    0.05266744f, -0.04419879f, 0.12009224f, 0.14973539f, -0.05709970f, 0.10166917f, 0.02887141f, 0.06683069f, 
    -0.06815432f, -0.03081521f, -0.04277866f, -0.12402704f, 0.02820961f, 0.02717847f, -0.11684534f, -0.02167089f, 
    -0.13086480f, -0.03063684f, -0.02332198f, -0.04057328f, -0.03579742f, -0.09105303f, -0.03157506f, 0.00988100f, 
    0.09302530f, 0.05896581f, 0.08094361f, -0.02389674f, -0.01750020f, 0.10064624f, 0.00007987f, -0.07803995f, 
    0.19504784f, 0.12429931f, 0.06418560f, 0.21999206f, 0.12244067f, -0.05751151f, 0.01062038f, -0.04715832f, 
    -0.11079939f, -0.03220674f, 0.09298175f, 0.00738957f, -0.26178613f, 0.27983880f, 0.04104872f, 0.17790726f, 
    0.07564191f, -0.07350015f, 0.18585341f, -0.12376885f, 0.08971233f, 0.02501956f, 0.01998871f, -0.05217659f, 
    -0.02985620f, 0.01651127f, 0.00082052f, -0.04919033f, 0.19087583f, 0.17287438f, 0.09024488f, 0.03156324f, 
    -0.09084502f, 0.01446704f, -0.00805480f, -0.09126463f, -0.25531995f, 0.01222819f, -0.13446271f, 0.00811929f, 
    -0.01439261f, 0.02778907f, -0.07163948f, -0.06925728f, -0.00504282f, -0.01578137f, 0.04510545f, -0.00335224f, 
    0.02108431f, -0.04109101f, -0.01486117f, 0.01021293f, 0.00070496f, -0.03675307f, -0.02489061f, 0.01784099f, 
    -0.02575804f, -0.03673625f, 0.02531019f, -0.03890948f, -0.00096369f, 0.01287379f, -0.02814608f, 0.03944014f, 
    -0.01884487f, -0.02912926f, -0.02960902f, -0.01418118f, 0.02674140f, -0.01586755f, -0.02499893f, 0.01628464f, 
    0.00360620f, -0.00297563f, -0.00936279f, -0.03141335f, 0.02186876f, -0.01123385f, -0.01927766f, 0.01332856f, 
    -0.03758060f, -0.02541067f, 0.01195002f, -0.03234078f, 0.01301889f, -0.03592135f, -0.00875488f, -0.00153635f, 
    0.01141084f, -0.01374320f, -0.04121422f, 0.02620491f, -0.04156632f, -0.02037311f, -0.02869887f, 0.00398615f, 
    0.02164316f, -0.01060216f, 0.00788220f, 0.01545840f, 0.01226183f, 0.02316365f, 0.00211634f, -0.01932618f, 
    0.00934029f, -0.03455045f, 0.00648812f, -0.00812172f, -0.02919219f, -0.02842228f, 0.00408651f, -0.02241162f, 
    -0.00968456f, -0.02728749f, -0.02093607f, -0.00964159f, -0.00091546f, -0.03979450f, -0.00826119f, 0.01387337f, 
    -0.03844842f, -0.00869184f, 0.02517112f, 0.01849143f, -0.00585784f, 0.00172775f, -0.03843981f, -0.03387089f, 
    0.00250130f, -0.02622900f, 0.01263841f, -0.01566947f, 0.02093916f, -0.01839669f, -0.00494557f, 0.00815132f, 
    0.02826657f, -0.01555661f, -0.02304888f, 0.01386190f, 0.02758255f, 0.00928050f, -0.01592859f, 0.01368213f, 
    0.00435352f, 0.01956101f, -0.02746851f, -0.03105561f, 0.02136014f, -0.01295549f, 0.00387874f, -0.03359690f, 
    0.01975739f, 0.00515067f, 0.01697182f, -0.01235403f, 0.02673103f, -0.02487243f, 0.03097604f, 0.01455045f, 
    -0.02773265f, 0.02701686f, 0.00100268f, -0.00968070f, 0.00019538f, -0.02471822f, 0.00294184f, -0.02417503f, 
    -0.03184322f, 0.01434847f, -0.02070236f, 0.02342791f, 0.01995473f, -0.00711957f, -0.03516057f, -0.01283004f, 
    -0.04232353f, -0.03196186f, -0.04130421f, 0.02657962f, 0.02495222f, 0.00689100f, 0.01133773f, 0.01138884f, 
    -0.00845841f, 0.02712837f, 0.01476745f, 0.02595511f, -0.02714835f, 0.01241739f, -0.01107592f, 0.01888071f, 
    0.02776610f, 0.01601290f, -0.01328152f, -0.03605569f, -0.01157467f, -0.03109176f, -0.02234622f, 0.02858216f, 
    0.00932201f, -0.01617496f, -0.03839481f, -0.00145817f, -0.00338940f, -0.00256772f, 0.00965817f, 0.02444316f, 
    0.02793337f, 0.00176771f, 0.03334725f, -0.03852067f, -0.02238045f, -0.00810715f, -0.00557068f, 0.02989939f, 
    -0.00223453f, -0.02290740f, -0.01240713f, -0.02757377f, -0.04215065f, -0.01632263f, -0.00477909f, -0.04289440f, 
    0.00786765f, -0.01017496f, 0.00263127f, -0.00619252f, -0.01250442f, -0.03537992f, -0.03998246f, 0.04303737f, 
    0.01439524f, -0.00739890f, -0.03168634f, -0.02695530f, -0.02400413f, 0.01751976f, 0.00372365f, 0.01489699f, 
    0.02913482f, -0.02675853f, 0.02768912f, 0.01322035f, 0.00076530f, -0.03203041f, 0.01139707f, -0.01207565f, 
    0.01833108f, 0.01349368f, -0.02966065f, 0.00957208f, 0.01102058f, -0.03555496f, 0.00662299f, -0.01083793f, 
    -0.02814588f, -0.02732625f, 0.02218610f, 0.00877437f, -0.01745928f, -0.01169960f, 0.01136598f, 0.01191344f, 
    0.01769933f, -0.03697072f, -0.01530892f, -0.00026868f, 0.00122431f, 0.00155016f, 0.02140674f, 0.02634829f, 
    -0.04169588f, -0.03608181f, -0.03329540f, -0.01130723f, -0.03446279f, -0.03682570f, 0.02242527f, -0.01211266f, 
    -0.03739783f, -0.01316881f, -0.01428703f, -0.01260573f, -0.03845033f, 0.00785161f, -0.00808604f, -0.03130965f, 
    -0.03075264f, -0.01923283f, 0.00952393f, -0.00782556f, 0.02074676f, -0.01171190f, -0.04361657f, -0.01704233f, 
    0.00414106f, -0.01396067f, 0.00001118f, -0.01353051f, 0.01646685f, -0.02217958f, -0.01140254f, -0.01090143f, 
    0.01948386f, -0.00021294f, 0.01942516f, 0.02446730f, 0.02273009f, -0.03464873f, 0.02224073f, -0.01487626f, 
    -0.01467865f, -0.02991354f, -0.00365163f, -0.01620867f, -0.02830906f, -0.03440744f, -0.00239620f, -0.03207140f, 
    0.01258705f, 0.02584224f, -0.00151713f, -0.01184401f, -0.02268712f, -0.01466213f, -0.03904062f, -0.01680058f, 
    -0.04118685f, -0.01389077f, -0.03040293f, 0.01467928f, -0.00251753f, -0.01499507f, -0.04098069f, 0.02815927f, 
    -0.04125343f, -0.00264938f, 0.01992499f, -0.02242903f, 0.00567451f, -0.03850290f, 0.01274896f, -0.02065860f, 
    -0.02159181f, -0.01643950f, -0.02711246f, -0.03327366f, 0.01239514f, -0.00645373f, -0.01017006f, 0.01075028f, 
    -0.01413641f, -0.03601316f, -0.00888325f, -0.03123097f, -0.00878907f, -0.03807617f, -0.01364575f, 0.00771834f, 
    0.01756817f, -0.04108888f, 0.01011064f, -0.02258099f, -0.00306515f, -0.01769863f, -0.02091516f, 0.01034094f, 
    0.02226608f, -0.01064211f, 0.00024334f, 0.02510726f, 0.01805500f, -0.02658909f, 0.00996624f, 0.02620093f, 
    0.00316776f, -0.01083828f, -0.00311940f, -0.02977032f, -0.01777642f, 0.01710247f, 0.01843282f, -0.00291945f, 
    -0.00629851f, 0.02657006f, -0.00536976f, -0.03721070f, 0.01753116f, -0.02660732f, -0.00501752f, -0.04245635f, 
    0.00045856f, 0.01090707f, -0.03341869f, 0.01837311f, -0.03981640f, -0.02470484f, -0.03695073f, 0.02414401f, 
    0.02461184f, -0.00931538f, 0.02331895f, -0.02152335f, -0.02344935f, -0.02901723f, -0.01603011f, 0.02161459f, 
    -0.01269982f, -0.04379646f, -0.01782944f, 0.02159605f, 0.00874767f, -0.03539426f, -0.00800240f, -0.00360708f, 
    -0.00919239f, 0.01738282f, -0.03969944f, -0.02530095f, 0.02948276f, -0.02863251f, -0.01155910f, 0.02574610f, 
    -0.00917528f, -0.00583923f, -0.00834856f, 0.00493831f, -0.01633169f, 0.03003601f, 0.00185792f, -0.02414038f, 
    0.00451995f, -0.02764275f, -0.01867524f, -0.01899454f, 0.02607971f, 0.00247597f, 0.02655803f, 0.00329847f, 
    -0.02149348f, -0.03052749f, 0.02547391f, -0.01803386f, 0.00022605f, -0.02663104f, 0.02028445f, 0.01062529f, 
    0.02403339f, 0.02452802f, -0.00671538f, -0.01203031f, -0.01518932f, -0.03834919f, -0.02904051f, -0.00268686f, 
    0.01154033f, -0.01667435f, 0.01089747f, -0.03854157f, -0.00579994f, -0.00453977f, 0.00203066f, 0.01232749f, 
    0.01558706f, 0.00160804f, 0.01012525f, 0.02177985f, 0.00993609f, -0.00299025f, -0.00373684f, 0.01906961f, 
    -0.02441403f, -0.02899772f, 0.01116279f, 0.01623043f, -0.00863455f, 0.01154190f, -0.02609032f, 0.02229786f, 
    -0.03055701f, -0.02793835f, 0.01035526f, 0.02573756f, -0.02538537f, -0.01929265f, -0.00034355f, 0.01534261f, 
    -0.02362915f, -0.01397450f, -0.02774059f, -0.03530501f, 0.01916398f, -0.03778381f, -0.00922298f, 0.01207708f, 
    -0.01133135f, 0.02190146f, 0.02020088f, -0.00559068f, -0.02615718f, -0.02322800f, -0.00071946f, -0.02056987f, 
    0.01646872f, 0.02521477f, -0.00950863f, -0.01470150f, 0.01303954f, 0.00040343f, -0.03888651f, -0.00793275f, 
    0.00315934f, -0.03766373f, 0.01026056f, 0.00348329f, -0.03825785f, 0.00857940f, -0.02585074f, -0.01913908f, 
    -0.01078746f, 0.02567144f, -0.00757324f, 0.02641569f, 0.02589408f, 0.00707691f, -0.01372099f, 0.02525652f, 
    0.01198173f, -0.00958992f, 0.02661942f, -0.01404687f, 0.00737097f, -0.03259154f, -0.00553395f, -0.02967249f, 
    0.00853865f, 0.02536844f, 0.02313689f, -0.03966235f, -0.04158057f, -0.03927646f, 0.02472919f, 0.00428020f, 
    0.01574468f, -0.01950765f, -0.01615333f, -0.02869017f, 0.03936747f, 0.02059706f, -0.02012877f, 0.00214228f, 
    0.00097358f, -0.00383051f, -0.01118511f, -0.03617999f, -0.03146898f, -0.01468513f, 0.01900524f, -0.02264958f, 
    -0.01840445f, 0.02282703f, 0.04128005f, -0.03638680f, -0.01159062f, 0.00586561f, 0.02620543f, 0.00138715f, 
    0.00411911f, 0.00614339f, 0.00807407f, -0.01295370f, -0.01737409f, -0.02527649f, -0.03944501f, -0.04046203f, 
    -0.04228401f, 0.00468475f, -0.00099350f, -0.01963796f, 0.01907415f, -0.02059738f, -0.02258425f, -0.01377146f, 
    0.02426450f, 0.01471873f, 0.00350309f, 0.01923741f, -0.02603875f, 0.01849871f, -0.02852192f, -0.01663647f, 
    0.01293587f, -0.04307621f, 0.00665902f, -0.01060964f, -0.02156828f, -0.01610751f, -0.03633577f, 0.02207454f, 
    -0.00629687f, 0.01220123f, -0.01297822f, -0.01934205f, -0.01149782f, -0.02217451f, -0.00044113f, 0.00024027f, 
    -0.03778601f, -0.03786009f, -0.00195421f, -0.01544746f, -0.02146416f, -0.02863283f, -0.02944922f, -0.02513116f, 
    -0.03364765f, 0.00063882f, 0.01964291f, 0.01351197f, 0.00486353f, 0.00728613f, -0.00481078f, -0.02757174f, 
    -0.02531664f, -0.01047223f, -0.03520117f, 0.00134490f, -0.01003202f, -0.01205671f, 0.02784871f, 0.00609567f, 
    0.02069547f, 0.01636123f, -0.00099633f, 0.03298739f, 0.02058607f, 0.02107502f, 0.00320879f, -0.00865087f, 
    -0.00047393f, 0.00176347f, 0.00729456f, -0.03518019f, 0.00037200f, -0.03581813f, 0.01497154f, -0.00823621f, 
    -0.03474601f, -0.01541262f, -0.00770698f, 0.02689462f, -0.00474696f, 0.02155987f, -0.01220735f, -0.02104835f, 
    -0.00577169f, -0.00681029f, -0.02541439f, -0.03372722f, -0.01765132f, 0.02947970f, -0.00274281f, 0.01940632f, 
    -0.02583058f, -0.00471902f, 0.01445458f, -0.03651020f, -0.02032693f, 0.01253075f, -0.02589935f, 0.02855238f, 
    -0.02957331f, -0.02505998f, 0.03197552f, -0.00300107f, -0.01986915f, 0.00879658f, -0.02970484f, 0.00941052f, 
    -0.03534410f, -0.00300536f, -0.01166726f, -0.00985608f, -0.00416383f, -0.00357691f, 0.00222132f, -0.03595652f, 
    -0.00509886f, 0.00241509f, -0.01243922f, -0.03453683f, 0.02620241f, 0.02230240f, -0.00783548f, -0.03451607f, 
    0.01245861f, -0.00054403f, -0.01763747f, -0.01672737f, -0.00007681f, -0.02690053f, -0.01805733f, 0.02693982f, 
    0.01263573f, -0.04195831f, -0.01727541f, 0.02651888f, -0.02589028f, -0.01651885f, -0.01579850f, 0.01726041f, 
    -0.03151761f, -0.03604577f, 0.00459365f, -0.00601459f, -0.03913179f, 0.00793715f, -0.00728461f, -0.00728993f, 
    0.01898841f, 0.02538208f, 0.01465184f, -0.00372015f, -0.01126977f, -0.01206274f, -0.00499027f, -0.03687407f, 
    0.00016441f, 0.02333864f, -0.04270659f, 0.02147531f, -0.03121041f, 0.00619745f, -0.03281534f, -0.02432667f, 
    -0.00503758f, 0.02774398f, -0.00279143f, 0.01266358f, 0.00782337f, 0.01253351f, 0.02274744f, -0.00847991f, 
    -0.02821921f, -0.01972321f, 0.02520750f, -0.02791645f, 0.00700606f, 0.00763397f, 0.01992045f, -0.02039129f, 
    0.01754135f, -0.02362344f, -0.00345494f, -0.00337247f, 0.01998729f, -0.01405235f, 0.00764665f, 0.02670402f, 
    0.02157320f, 0.00584943f, -0.01463721f, -0.00719777f, -0.00878387f, 0.02120912f, -0.03606379f, -0.03531640f, 
    -0.03207382f, 0.01229820f, -0.03875696f, 0.02698128f, 0.01162888f, 0.01014562f, 0.00350293f, 0.00667608f, 
    -0.01155991f, -0.03746806f, -0.01767140f, 0.00317594f, -0.00623194f, 0.01777650f, -0.04293295f, 0.01150905f, 
    0.02678401f, -0.02089331f, -0.00156330f, 0.02492974f, -0.01147066f, -0.03657000f, -0.00252187f, 0.02038194f, 
    -0.03505414f, -0.03401146f, 0.00965045f, 0.01852559f, 0.01848595f, -0.03715957f, -0.02487466f, 0.02568610f, 
    -0.01475527f, 0.02433606f, -0.02029427f, 0.01724011f, 0.00048845f, 0.02241906f, -0.02058843f, -0.02621946f, 
    0.00060773f, -0.02016037f, -0.01866632f, -0.02030210f, 0.00496285f, 0.00082128f, 0.02222079f, -0.01640199f, 
    0.05746588f, 0.20092982f, -0.04261114f, 0.20519498f, 0.01231426f, 0.03984448f, 0.08365154f, -0.05347729f, 
    -0.07006542f, 0.18269207f, 0.01498982f, 0.07307650f, 0.24488346f, -0.10808352f, 0.04675236f, 0.24976778f, 
    0.12194178f, 0.04843395f, 0.08731108f, -0.01199898f, 0.22284208f, 0.02328283f, -0.03828750f, 0.04768925f, 
    -0.04093007f, -0.05431258f, -0.00916799f, 0.07344245f, 0.02049747f, -0.03352979f, -0.15871581f, -0.08914448f, 
    -0.08557783f, -0.13898915f, 0.00122253f, -0.18286562f, 0.34700841f, -0.16842960f, 0.16469987f, 0.08481408f, 
    -0.08962585f, 0.12947617f, 0.04583454f, 0.17247812f, 0.07156739f, 0.07534395f, 0.05649985f, -0.06681817f, 
    -0.08767506f, -0.00823914f, -0.11127274f, -0.06238744f, 0.03507452f, -0.05483503f, 0.19364063f, 0.13559876f, 
    0.06025926f, 0.05080188f, 0.08661801f, 0.23236410f, 0.05819964f, -0.02906303f, 0.11570730f, 0.09694766f, 
    0.11022623f, -0.04758186f, -0.13127857f, -0.06311925f, 0.03339909f, -0.21832919f, -0.07261948f, -0.22289050f, 
    0.30296808f, 0.17895314f, 0.31506476f, 0.22270092f, -0.01680746f, -0.10622316f, 0.13261805f, -0.06863473f, 
    -0.00032890f, 0.07007838f, -0.19808789f, 0.03526042f, -0.12796181f, 0.06037349f, -0.09963498f, 0.07010816f, 
    0.01451491f, -0.01078766f, 0.06899830f, 0.07260533f, -0.01140007f, -0.05481964f, 0.11269408f, 0.04843413f, 
    -0.11614140f, 0.00389473f, -0.23459424f, -0.04123341f, 0.07252359f, 0.17915814f, -0.10675585f, 0.04361614f, 
    0.11977721f, -0.09915955f, 0.07316423f, -0.07514992f, -0.00990249f, 0.15959623f, -0.15084569f, 0.07124048f, 
    0.11673004f, -0.04994801f, -0.07331639f, -0.00954132f, -0.17224246f, -0.21737656f, -0.13575545f, -0.05850892f, 
    0.33479047f, -0.07113640f, 0.22048955f, -0.06268232f, 0.09665632f, 0.03303908f, -0.01935324f, -0.08034706f, 
    -0.17234860f, -0.18201844f, -0.23178981f, -0.18260258f, 0.08306238f, 0.08826359f, -0.00796519f, -0.03461566f, 
    -0.07724823f, 0.04887962f, -0.08482131f, 0.05715739f, 0.15342826f, -0.24354884f, -0.26494011f, -0.27215588f, 
    -0.21487428f, 0.08145580f, 0.01738100f, -0.09204618f, 0.10313205f, 0.17111881f, 0.15928861f, -0.02220819f, 
    0.00869058f, -0.01103624f, -0.14845280f, 0.16147248f, 0.26651257f, -0.03774606f, 0.03760190f, -0.11171360f, 
    0.07292547f, -0.04529857f, -0.00037699f, 0.00685576f, 0.08720215f, 0.04975682f, 0.01633123f, -0.13833192f, 
    0.12280852f, 0.22657683f, 0.16160327f, 0.02440606f, -0.02739978f, 0.06211827f, 0.08171953f, 0.02419601f, 
    -0.03592274f, -0.01290688f, 0.11013160f, -0.05369259f, 0.11514277f, -0.16363177f, -0.14327894f, -0.10935929f, 
    0.07149979f, 0.11615456f, 0.00662208f, -0.12241668f, 0.18014288f, -0.16235641f, 0.10252089f, 0.14213125f, 
    -0.00731755f, 0.14432439f, -0.12083951f, -0.15114927f, 0.41329888f, -0.13121127f, -0.19143358f, 0.20130587f, 
    -0.21032657f, 0.07034516f, 0.04080549f, -0.24035034f, 0.02572560f, -0.02631332f, 0.16247639f, 0.05441219f, 
    0.00600630f, 0.00441678f, -0.07360657f, -0.02904185f, -0.01682560f, -0.07276595f, 0.07215782f, -0.03785434f, 
    0.12064335f, 0.06837077f, 0.13346823f, 0.04966840f, 0.03654173f, -0.01654240f, 0.04412224f, 0.08457167f, 
    0.05708661f, 0.04707989f, -0.04495134f, 0.10608741f, 0.13021399f, 0.09673750f, 0.13841428f, 0.12218209f, 
    0.04979558f, 0.10268359f, -0.00280664f, -0.04904671f, 0.06229441f, -0.10087084f, 0.09077995f, 0.06572237f, 
    0.08263891f, 0.00135880f, -0.03364358f, -0.12305474f, 0.09655914f, -0.12261840f, -0.15204473f, 0.03352479f, 
    0.03002051f, 0.00197952f, 0.09396367f, 0.07532328f, 0.09996077f, 0.01716195f, 0.01883376f, 0.03708483f, 
    -0.01707292f, 0.06300246f, -0.01072666f, -0.03796427f, -0.06345598f, -0.06858092f, -0.10591003f, -0.14687344f, 
    -0.33614767f, 0.19048338f, -0.03536252f, -0.02369276f, 0.04291787f, 0.00978336f, -0.08247980f, 0.16611968f, 
    -0.04179256f, 0.11358865f, 0.23747617f, 0.17435957f, 0.09592482f, 0.04795286f, 0.15904923f, 0.17523122f, 
    0.03835171f, 0.03338543f, 0.06487384f, -0.04699928f, 0.07292670f, 0.12826766f, 0.13384065f, 0.33982989f, 
    -0.03640235f, -0.00693976f, -0.00743738f, 0.04204524f, 0.07970247f, 0.03072026f, -0.14193475f, 0.12893508f, 
    -0.08862254f, -0.08144338f, -0.17882174f, -0.18827802f, 0.05060727f, -0.06163407f, -0.02539243f, 0.02908935f, 
    0.05089198f, 0.11390788f, -0.09675940f, 0.10438572f, 0.34099615f, -0.05904955f, -0.08429987f, 0.19471858f, 
    0.34215975f, 0.04624444f, -0.11424816f, -0.13226898f, 0.13916539f, -0.10276274f, 0.00772224f, 0.14227644f, 
    -0.21954502f, 0.15759858f, -0.18492861f, -0.15781645f, -0.01194812f, 0.13533844f, 0.08081719f, 0.02817193f, 
    0.06993625f, -0.08214623f, 0.13089606f, 0.13816141f, -0.00950502f, 0.01001996f, 0.05958276f, 0.11491915f, 
    0.02427237f, 0.19690906f, 0.22685285f, 0.05822288f, 0.04309117f, 0.07484560f, -0.02387183f, -0.02828005f, 
    0.12627074f, -0.08840756f, -0.03032435f, 0.00804971f, -0.08188660f, 0.01051146f, -0.23619877f, -0.13501817f, 
    0.18743575f, -0.01780166f, 0.07100389f, -0.00251175f, 0.05560024f, -0.00902513f, 0.02104442f, 0.04954009f, 
    0.16109738f, 0.04709146f, 0.16976313f, -0.02646335f, 0.07303630f, -0.08707027f, -0.01556168f, -0.01606885f, 
    0.13064702f, 0.00658252f, 0.14386334f, 0.13316387f, -0.05203306f, -0.08544271f, -0.17913258f, -0.00580413f, 
    0.04659131f, -0.03995660f, -0.08284467f, 0.08678631f, -0.05763436f, -0.03129705f, -0.10563844f, -0.05791400f, 
    -0.05627878f, 0.12787159f, 0.07208272f, 0.18511288f, -0.02813554f, 0.02130652f, -0.05122870f, 0.10111734f, 
    -0.14202993f, -0.13434495f, -0.04121930f, -0.25320885f, -0.27867919f, 0.21473487f, 0.10954317f, -0.00307173f, 
    0.06659137f, 0.04696144f, -0.16359620f, 0.01680908f, -0.16202785f, 0.05500526f, 0.10305700f, 0.05550221f, 
    0.18751499f, 0.04221740f, -0.06890991f, 0.06971098f, 0.04924269f, 0.03513134f, 0.06507645f, 0.12179077f, 
    0.32882202f, 0.26167023f, 0.02882441f, 0.09820337f, 0.35863474f, -0.01984200f, 0.17013417f, 0.23764162f, 
    0.05819473f, 0.06062590f, 0.10313823f, 0.00399479f, 0.14632650f, 0.14860132f, -0.03896437f, 0.15164736f, 
    -0.04434159f, 0.52749258f, -0.05971365f, 0.09643506f, 0.08683278f, -0.01396260f, 0.04288515f, -0.06450395f, 
    0.03575198f, 0.12204043f, -0.04594099f, -0.19986455f, -0.02484460f, -0.06629519f, 0.14870566f, -0.01272778f, 
    0.18841730f, 0.03759690f, -0.12162089f, -0.06878996f, -0.15973723f, -0.19929788f, 0.00513939f, -0.11592497f, 
    0.17148890f, -0.11863931f, 0.43208414f, 0.10948788f, -0.05718499f, 0.01889687f, -0.03233054f, -0.01246979f, 
    0.12205511f, 0.11550365f, 0.16093758f, 0.20772448f, -0.04125610f, -0.09642050f, -0.01275629f, -0.06398805f, 
    0.10060494f, -0.08065511f, 0.05526490f, -0.02176382f, -0.01808275f, -0.13859172f, -0.15848123f, -0.22157271f, 
    0.35502073f, 0.12208277f, 0.02395181f, 0.12548696f, 0.08367385f, -0.06284179f, 0.03519048f, -0.03078009f, 
    0.12991293f, 0.05005574f, 0.02802698f, 0.09509143f, -0.11987253f, 0.03231248f, -0.10318563f, -0.18119302f, 
    0.12472129f, 0.10021009f, 0.10676566f, -0.03024885f, -0.15810509f, 0.10610894f, 0.04618794f, 0.07413281f, 
    0.00898369f, 0.07498000f, -0.10997653f, -0.10943559f, 0.06443135f, 0.00160442f, -0.14167026f, 0.01072502f, 
    -0.30148625f, -0.08436398f, -0.30728137f, -0.12605478f, -0.06544917f, -0.26491058f, -0.03494528f, 0.13849230f, 
    0.06825071f, 0.01804373f, -0.04007762f, -0.05248877f, -0.06024495f, -0.05954392f, -0.00532805f, -0.00597218f, 
    -0.13148560f, -0.22288382f, -0.03706988f, 0.13370410f, 0.11626550f, -0.07189172f, -0.04573528f, 0.00589967f, 
    -0.11465225f, 0.08407874f, 0.17914534f, 0.01220237f, 0.04948047f, 0.05743577f, -0.04436154f, 0.06381340f, 
    0.01379843f, 0.03757774f, 0.18674141f, -0.00831682f, 0.05943372f, 0.12688981f, 0.00645063f, 0.11904844f, 
    0.24615556f, -0.11039732f, 0.13437383f, 0.12130169f, 0.01074273f, 0.08656090f, 0.16756184f, -0.01783032f, 
    0.06906310f, 0.13667002f, 0.07066786f, 0.22720380f, 0.04739472f, -0.08797932f, 0.03036721f, -0.01555390f, 
    0.16198607f, 0.00574520f, -0.13374820f, 0.03147333f, -0.10130853f, -0.04812196f, -0.09858717f, -0.22753499f, 
    -0.17683150f, 0.28725660f, -0.05739267f, -0.21644342f, -0.03388828f, 0.04221315f, -0.15707240f, 0.09126742f, 
    0.03874805f, 0.08923616f, 0.07405666f, -0.01228723f, -0.15747802f, 0.19247164f, -0.12645109f, 0.06101576f, 
    0.05273465f, 0.09357918f, -0.06464088f, -0.09987843f, -0.03415048f, -0.10330100f, 0.01964309f, -0.21343657f, 
    -0.16707925f, 0.08325637f, 0.18297240f, 0.22727145f, 0.07296100f, 0.06506522f, 0.07651589f, -0.02658622f, 
    0.12603420f, 0.06877557f, -0.03307991f, 0.22498673f, 0.03414007f, -0.00924846f, 0.00465163f, 0.06821842f, 
    -0.03387576f, 0.02719499f, -0.12497461f, -0.04958455f, -0.04134890f, -0.08447022f, 0.04498501f, -0.04881248f, 
    -0.00996359f, -0.10382519f, -0.19095226f, -0.00623578f, 0.08302418f, -0.01283904f, 0.11214567f, -0.00159016f, 
    -0.14601871f, 0.02257969f, -0.36526191f, -0.39505315f, -0.15742889f, 0.03763599f, 0.01015815f, -0.00724140f, 
    0.00249867f, 0.11834691f, 0.07768722f, 0.05299578f, 0.13595226f, 0.05393811f, 0.21965005f, 0.26588044f, 
    -0.08644724f, 0.03881323f, -0.13275824f, -0.07953165f, 0.20102070f, 0.02164779f, -0.11712133f, -0.06482733f, 
    -0.04388239f, -0.02818862f, -0.18027309f, -0.10829518f, -0.09411083f, 0.03621997f, -0.19791842f, -0.00967204f, 
    0.07125327f, -0.12247346f, 0.01616904f, 0.00699313f, -0.11807212f, 0.16570696f, 0.08058927f, -0.03627020f, 
    0.02192137f, -0.15947185f, -0.08138782f, -0.12513714f, 0.02970497f, -0.05407614f, -0.02658121f, 0.07090414f, 
    0.20274483f, 0.23571207f, 0.08821511f, 0.10871681f, 0.10397879f, 0.28615725f, 0.02133040f, 0.06930091f, 
    0.00651895f, -0.04676107f, 0.07730221f, -0.07792267f, 0.08814193f, 0.10229318f, -0.18896316f, -0.12264759f, 
    -0.02380992f, -0.23127952f, -0.14292739f, -0.01151044f, -0.00660120f, -0.07776994f, -0.03329946f, -0.00256308f, 
    0.10909168f, 0.25237405f, 0.23058009f, 0.22476870f, 0.04732513f, 0.06637736f, 0.05686890f, 0.01562715f, 
    0.02873763f, -0.00032787f, -0.02274902f, -0.00563076f, -0.04828469f, -0.03562852f, -0.19224089f, -0.14293686f, 
    0.06846859f, -0.16313924f, 0.20139298f, -0.10050300f, -0.03336075f, 0.14986925f, 0.11906086f, 0.00452859f, 
    0.13171776f, 0.09267169f, 0.29566297f, 0.14053638f, 0.30317903f, -0.17484733f, 0.35199186f, -0.02815579f, 
    0.02539192f, -0.10334254f, 0.03613143f, 0.09743427f, -0.09064763f, 0.11664029f, -0.17500615f, -0.03834221f, 
    0.09350074f, -0.11099627f, 0.03666009f, -0.05533153f, -0.02676111f, 0.05397401f, 0.02579378f, -0.02220047f, 
    -0.14564109f, -0.12594026f, -0.22040665f, -0.10084471f, -0.32552597f, -0.04267516f, -0.07310610f, 0.04807549f, 
    -0.00324670f, 0.03966254f, 0.05801208f, -0.07379520f, 0.08841629f, 0.10398452f, 0.11954914f, 0.18428703f, 
    0.21967664f, 0.31662583f, 0.07101533f, 0.10479950f, -0.00183451f, -0.16083564f, 0.13173227f, 0.17727295f, 
    -0.04349468f, 0.16435806f, -0.03872648f, -0.01073995f, -0.42890263f, 0.08651137f, 0.19619222f, 0.43551496f, 
    -0.00204669f, -0.00084840f, -0.00279873f, 0.00612466f, 0.22525246f, 0.06301760f, 0.02413019f, -0.02060515f, 
    0.04613456f, 0.00735842f, -0.25977972f, -0.03155201f, 0.12700446f, -0.02466732f, 0.05306004f, 0.00995032f, 
    0.00074478f, 0.10417176f, 0.07099677f, 0.11354292f, -0.03636261f, 0.23997085f, -0.08965447f, 0.15042335f, 
    0.02914387f, 0.08629127f, 0.11346465f, 0.00370435f, 0.08755369f, -0.00755997f, 0.04882339f, 0.05360213f, 
    -0.21031794f, -0.09407067f, 0.03389535f, -0.12100109f, -0.04055205f, -0.05526742f, -0.01672507f, 0.27075824f, 
    -0.05009656f, -0.02512824f, 0.13979657f, 0.06856588f, -0.07965408f, -0.06948698f, -0.00857946f, 0.02194895f, 
    0.09407047f, -0.09936807f, -0.08594804f, -0.07250351f, 0.07142940f, -0.02822354f, 0.00657857f, 0.06894255f, 
    -0.04829355f, -0.25612062f, 0.05712501f, 0.07507195f, 0.02984372f, 0.11625067f, 0.10953804f, -0.12273505f, 
    -0.03621747f, 0.06832880f, 0.13787031f, 0.08344698f, -0.47630417f, 0.00695988f, 0.06187493f, -0.12436336f, 
    -0.07550291f, -0.04959132f, 0.22602241f, 0.01081986f, 0.03630561f, 0.02023011f, 0.14993569f, 0.03863864f, 
    0.18978302f, 0.29618192f, -0.18478513f, 0.04580161f, -0.01583856f, -0.05473690f, -0.04198798f, -0.02097170f, 
    0.02576251f, 0.05936867f, -0.00415446f, -0.18825395f, 0.00651202f, -0.00855878f, -0.08811703f, -0.04372281f, 
    -0.05143094f, -0.04028163f, -0.22251710f, 0.07637421f, 0.03468351f, 0.03907614f, 0.05809607f, 0.03074072f, 
    -0.14466318f, -0.09844405f, 0.03513210f, 0.02443828f, 0.10091037f, -0.13512108f, -0.16441083f, -0.04926560f, 
    -0.01075106f, 0.07053754f, -0.03213616f, -0.03763452f, -0.02777136f, -0.03103394f, 0.01566639f, 0.01486030f, 
    -0.05356221f, 0.23188402f, 0.08785062f, 0.06379040f, 0.23187339f, -0.05226732f, 0.02581738f, -0.02064526f, 
    0.12283579f, 0.22011146f, 0.00675160f, 0.01288550f, 0.11587662f, -0.08485768f, 0.18889989f, 0.16569209f, 
    0.08458006f, 0.05351546f, -0.10920738f, 0.15063912f, -0.24526225f, -0.24315533f, 0.30977899f, 0.29167905f, 
    0.02034007f, -0.05867216f, 0.04413016f, 0.09463590f, 0.08444945f, 0.03106651f, 0.04705532f, 0.09476510f, 
    -0.10582738f, -0.00833245f, 0.13104272f, -0.09069230f, 0.08480169f, 0.19663689f, 0.03414266f, 0.01736891f, 
    0.05531551f, 0.00413685f, 0.12587713f, -0.06125544f, -0.23710933f, 0.05738299f, -0.21487749f, 0.21036799f, 
    0.02969951f, -0.10466548f, 0.19977042f, -0.00285898f, 0.14048254f, 0.02376125f, -0.10525060f, 0.07598498f, 
    -0.19651300f, -0.14316145f, 0.11653262f, -0.34069282f, 0.04107594f, 0.07816267f, -0.03128449f, 0.07874542f, 
    0.03800745f, -0.04728268f, -0.02784363f, 0.05851190f, -0.26062638f, -0.02510925f, 0.04864777f, -0.13774703f, 
    0.02320681f, 0.01092956f, 0.07036381f, -0.14145419f, 0.10396472f, 0.02730157f, 0.16529414f, 0.01026022f, 
    -0.15798742f, -0.08990578f, 0.15923758f, 0.03945991f, 0.01386718f, 0.05079475f, -0.03108983f, 0.15909351f, 
    0.00871336f, 0.10502091f, 0.08268105f, 0.04382309f, -0.04651020f, 0.09040617f, -0.01780195f, -0.17480579f, 
    -0.02819114f, -0.02978567f, -0.12957616f, -0.08323338f, 0.08423432f, 0.08614119f, -0.02426369f, 0.08386853f, 
    -0.01006144f, -0.20638219f, 0.08720296f, 0.04261103f, 0.09319446f, -0.04924237f, -0.00862103f, 0.09127262f, 
    0.11710064f, -0.02926456f, -0.15772706f, -0.15334544f, -0.19447896f, 0.00816064f, -0.08438945f, -0.26305300f, 
    0.00305501f, -0.03421031f, 0.01480652f, -0.15003079f, 0.08959378f, 0.04092817f, 0.00307148f, -0.04358617f, 
    -0.55950528f, 0.12212963f, 0.12705168f, -0.18194246f, 0.13392204f, -0.16074482f, -0.09279286f, -0.03525706f, 
    -0.08617600f, 0.02642866f, 0.06244213f, 0.11359345f, -0.16430517f, 0.20569162f, 0.04246612f, 0.08283526f, 
    0.00172703f, -0.09676384f, 0.13330671f, -0.00603536f, -0.01709916f, -0.00660120f, -0.00586260f, -0.07339802f, 
    0.07468606f, 0.05413476f, 0.07594123f, -0.09652589f, 0.06719910f, 0.04245393f, 0.03763140f, 0.11972110f, 
    0.14961447f, 0.05883889f, 0.02914457f, 0.00146410f, 0.08527946f, -0.09044480f, -0.18602549f, 0.04891840f, 
    0.19074368f, -0.04594988f, 0.03059023f, 0.09468182f, 0.07496507f, 0.04455595f, -0.03662190f, -0.00781519f, 
    0.03119613f, -0.22755621f, 0.03578602f, 0.02201828f, 0.01288731f, -0.17635554f, -0.17033073f, 0.11684950f, 
    -0.19295010f, 0.00780035f, 0.01807560f, -0.10315137f, -0.16146876f, 0.14516173f, -0.03100793f, -0.04337801f, 
    0.00820554f, -0.05380198f, 0.10275147f, 0.01683249f, -0.00525312f, 0.04064487f, 0.13139941f, -0.12539625f, 
    -0.29284838f, -0.44794765f, -0.01038977f, 0.24615438f, 0.20345278f, 0.18037692f, 0.22538692f, 0.11385030f, 
    0.06463056f, 0.03258295f, -0.07045992f, 0.06225059f, -0.30946273f, 0.00396153f, 0.19608121f, 0.20700690f, 
    0.07299881f, -0.02194045f, -0.03294991f, 0.06634813f, 0.08984724f, 0.04767086f, 0.04553508f, 0.03498312f, 
    -0.12537476f, 0.00991169f, 0.04399031f, 0.19635577f, 0.02816939f, -0.13148895f, 0.01539896f, 0.04498390f, 
    -0.01282604f, -0.02670966f, 0.09070034f, 0.00170098f, 0.14538802f, -0.21042143f, -0.18502289f, -0.03976843f, 
    0.09594045f, 0.03529418f, -0.02778584f, 0.04868439f, 0.03823064f, -0.12210061f, 0.03702361f, -0.02100385f, 
    -0.02786118f, -0.10632496f, -0.06970406f, 0.02001265f, 0.09092039f, 0.12621908f, 0.05932185f, 0.09148943f, 
    0.05929186f, 0.00773442f, -0.00092032f, -0.03464832f, 0.12824140f, 0.35045096f, -0.21348935f, -0.34177941f, 
    -0.09524120f, -0.03747213f, -0.10950197f, -0.00928428f, 0.18571003f, 0.09806690f, -0.03792587f, 0.06546276f, 
    0.00479250f, -0.21722744f, -0.22602366f, -0.05189439f, 0.08219015f, 0.11774536f, 0.09250851f, 0.07473454f, 
    -0.10127138f, -0.16482165f, 0.05970202f, -0.03353320f, 0.00908920f, 0.41241112f, 0.23281701f, 0.27321389f, 
    -0.00787800f, -0.06244320f, -0.06596002f, 0.02959056f, -0.02460092f, -0.01539067f, -0.13790450f, 0.04815023f, 
    -0.06009928f, -0.04860618f, -0.01640581f, -0.23634875f, 0.10192114f, 0.30735934f, 0.00014909f, -0.12819161f, 
    0.12625508f, 0.00337938f, -0.00676056f, -0.06124596f, 0.02828425f, 0.03154249f, 0.07935024f, -0.05596522f, 
    0.11804383f, -0.17208908f, -0.14300030f, 0.01012037f, -0.00897601f, -0.08123571f, 0.09641450f, 0.07080752f, 
    -0.19461735f, -0.05350895f, 0.17165001f, -0.09156061f, 0.09920038f, -0.07220065f, -0.12352324f, -0.15654516f, 
    0.04666945f, -0.10673255f, -0.13069771f, -0.04559645f, -0.01894263f, -0.05114870f, -0.01346971f, 0.07902822f, 
    0.10291897f, -0.06114793f, -0.04168625f, -0.02867186f, 0.06725553f, 0.03265462f, -0.06293506f, -0.02920244f, 
    -0.36396515f, -0.03682255f, 0.38872230f, -0.11571978f, 0.00945875f, -0.02731694f, -0.20374350f, 0.04041194f, 
    0.01911293f, -0.09056581f, -0.05403372f, -0.10026633f, -0.15644689f, -0.31153196f, 0.03047065f, -0.03232956f, 
    0.08053670f, 0.02022267f, -0.04143821f, -0.02811057f, -0.03802228f, 0.01146602f, 0.03219402f, -0.00299985f, 
    0.04897805f, -0.15964462f, -0.09344435f, 0.10706646f, 0.06153082f, 0.03559408f, -0.04340482f, 0.07623447f, 
    -0.12502392f, 0.07323281f, -0.05541030f, 0.16755781f, -0.14241980f, 0.06428204f, -0.00645885f, 0.19561598f, 
    -0.01831037f, -0.00906632f, 0.02582312f, 0.14186700f, -0.06571598f, 0.20295212f, -0.06824026f, 0.06209595f, 
    0.11835705f, 0.51840740f, -0.01668928f, 0.18775438f, 0.11211753f, -0.03839811f, -0.07887191f, 0.02551940f, 
    0.00891003f, 0.15127511f, 0.10990409f, -0.10884220f, -0.13116087f, 0.11133781f, 0.12352728f, -0.10361794f, 
    0.00313853f, 0.03964117f, 0.04997079f, -0.02660410f, 0.04849545f, 0.00670247f, 0.00233249f, -0.03548656f, 
    -0.37908474f, -0.08979601f, 0.45488751f, 0.11126746f, 0.04172190f, -0.03756655f, -0.10310589f, 0.18593231f, 
    0.01488420f, -0.05015900f, -0.03381402f, 0.05316918f, 0.06719301f, -0.11282241f, -0.15770684f, -0.18953675f, 
    0.02215447f, 0.05694734f, -0.02317170f, 0.04829262f, 0.06524020f, -0.03871541f, 0.04275870f, -0.06021031f, 
    -0.00264331f, 0.36535782f, -0.22201978f, -0.26986018f, 0.10816181f, -0.02335368f, -0.00416653f, -0.05791318f, 
    0.00821430f, 0.01009027f, 0.07021836f, -0.03210253f, -0.05887847f, 0.07574480f, 0.31108621f, -0.21757333f, 
    0.03216417f, 0.09573817f, -0.15744197f, -0.05627078f, 0.16535443f, -0.05215195f, 0.06664319f, -0.15963556f, 
    0.08409669f, 0.40305468f, 0.10987896f, -0.04899512f, -0.01364692f, 0.02797814f, -0.03863465f, 0.01308884f, 
    0.00073378f, -0.12130690f, 0.01076810f, -0.00933562f, -0.09127055f, -0.05594240f, -0.26174989f, 0.16968748f, 
    0.04636968f, 0.09143605f, 0.05487338f, 0.01007804f, -0.00422688f, 0.02067018f, -0.04526581f, -0.07167956f, 
    0.02862679f, -0.02278795f, -0.17478934f, 0.03393460f, -0.06808374f, -0.00970857f, 0.01787065f, 0.00178921f, 
    0.14581299f, -0.02440482f, 0.04548928f, -0.07925916f, -0.08558100f, 0.06977513f, -0.02622681f, -0.39584422f, 
    0.05129147f, 0.01599509f, 0.09003869f, 0.02829738f, 0.05369694f, 0.02171374f, 0.12011094f, -0.00192800f, 
    0.10393608f, 0.08790515f, 0.11579604f, 0.17052482f, 0.26708889f, -0.04453929f, -0.06516769f, 0.16344486f, 
    0.09165572f, -0.10468345f, 0.11024968f, 0.14715299f, -0.09264074f, -0.23575245f, 0.00916585f, -0.24978255f, 
    0.05954480f, 0.03522809f, -0.00381222f, 0.12937593f, 0.03138745f, 0.03073344f, -0.02579952f, -0.09852006f, 
    0.14311767f, 0.00530205f, -0.17129053f, -0.00146969f, 0.05793262f, 0.05331717f, 0.04213294f, 0.06860229f, 
    0.14813955f, 0.10026460f, -0.00481441f, -0.08093759f, -0.16063379f, 0.08932500f, 0.04700428f, -0.09888914f, 
    0.02348545f, -0.02086687f, 0.05467989f, -0.09435330f, 0.04073123f, -0.01444203f, -0.07129844f, -0.01685710f, 
    -0.07641491f, -0.12644817f, -0.10886556f, -0.03205310f, 0.01178699f, 0.07872295f, 0.10895558f, 0.11752057f, 
    0.04395674f, -0.14557026f, -0.00002450f, -0.09431162f, -0.07790902f, 0.31287581f, 0.50101662f, 0.07769474f, 
    0.02559449f, 0.00458638f, -0.07720141f, 0.02624056f, 0.00003120f, 0.03197759f, 0.04981330f, 0.07949065f, 
    -0.31127128f, -0.10913057f, 0.14051932f, -0.14359996f, -0.14872561f, -0.17926811f, 0.01472020f, 0.11380707f, 
    0.10644846f, 0.01148318f, -0.10840389f, -0.15581471f, 0.03731351f, -0.18400504f, 0.18810257f, 0.19697079f, 
    0.06425411f, 0.05960341f, -0.00852585f, 0.17496721f, -0.04988119f, 0.04455297f, -0.09735441f, 0.03635658f, 
    -0.07472404f, -0.03660862f, 0.12990375f, -0.00756811f, 0.05302808f, -0.03456570f, 0.06082333f, 0.02286633f, 
    0.13529748f, 0.00680763f, 0.11145822f, 0.20942439f, -0.17140335f, 0.04181698f, 0.21865728f, -0.10529014f, 
    0.05211108f, 0.06120074f, -0.03954780f, -0.00561109f, 0.03930490f, 0.15658589f, 0.08013396f, 0.02049559f, 
    -0.03933067f, -0.04171646f, -0.05915380f, 0.16527767f, 0.03716164f, 0.04541601f, 0.13119604f, 0.23094194f, 
    -0.03245482f, 0.05430418f, -0.02257217f, -0.01708602f, 0.02685857f, -0.37878788f, -0.10226009f, -0.11696877f, 
    0.00473237f, -0.02856330f, -0.04968273f, -0.10591643f, 0.08108517f, 0.04299096f, 0.00641702f, -0.01386002f, 
    0.13174532f, 0.02937983f, 0.10663976f, -0.07846037f, -0.13630022f, 0.03307962f, -0.06845380f, -0.14218153f, 
    -0.11309297f, 0.08060291f, 0.15909278f, 0.12402141f, 0.17965782f, -0.02768177f, 0.11003587f, 0.18031976f, 
    0.13184759f, 0.14172007f, 0.00705129f, 0.13796271f, 0.01514796f, 0.02389644f, -0.03510212f, 0.03414506f, 
    -0.17041820f, 0.34404260f, -0.12752801f, 0.10191780f, -0.00344355f, -0.07858435f, 0.19199607f, 0.11520657f, 
    -0.11562012f, 0.06054387f, -0.06417506f, -0.01988489f, 0.06218841f, -0.17240110f, -0.12770365f, -0.01318205f, 
    0.10820587f, -0.06024156f, -0.00851847f, 0.05717887f, 0.08125981f, 0.00024622f, 0.00225425f, 0.02089089f, 
    -0.00441328f, -0.11378354f, 0.19837360f, 0.28260872f, 0.10682993f, 0.05033559f, 0.00286789f, -0.05977979f, 
    -0.06213474f, 0.04361918f, -0.15868025f, -0.01333660f, 0.03555577f, -0.17985660f, -0.06504747f, 0.04011162f, 
    0.05473787f, -0.02451909f, 0.12692980f, 0.01477726f, -0.02234162f, -0.05576535f, 0.04354385f, -0.01118998f, 
    0.47466290f, 0.13289276f, -0.11290402f, 0.02745138f, -0.03173577f, 0.09104554f, -0.08012450f, 0.18277650f, 
    -0.03090005f, 0.08704278f, 0.01137723f, -0.14455333f, -0.20465823f, 0.07494840f, 0.00172077f, 0.11808477f, 
    0.04349086f, 0.07048176f, -0.21470910f, -0.08225916f, -0.04204433f, 0.22904415f, -0.16926824f, 0.19630900f, 
    -0.03836499f, 0.20626567f, -0.13011257f, -0.03724613f, 0.11314416f, 0.10004567f, -0.14349604f, -0.06755494f, 
    -0.11291746f, -0.04897888f, 0.03381173f, -0.01293278f, -0.01263893f, -0.02098268f, 0.07961415f, -0.17248054f, 
    -0.03642825f, 0.11377517f, 0.08179671f, 0.10241263f, 0.11468793f, -0.08812341f, -0.12040509f, -0.11219364f, 
    -0.10951091f, -0.03191670f, 0.01427155f, 0.20283860f, 0.11280131f, -0.09270246f, 0.18554525f, 0.11761119f, 
    -0.08071353f, 0.08410154f, 0.01980681f, 0.11761858f, 0.04903561f, -0.19574557f, -0.09436543f, -0.00826116f, 
    0.02288920f, -0.02936342f, -0.00104940f, -0.14112635f, 0.13615155f, -0.00255097f, 0.07067602f, 0.06163786f, 
    -0.13282216f, -0.14368927f, 0.05552423f, 0.17838073f, -0.02608143f, 0.03792477f, 0.11763504f, 0.06477552f, 
    0.05942475f, -0.03054833f, -0.09647275f, -0.06912808f, 0.53234458f, -0.08054339f, 0.16122285f, -0.06511625f, 
    -0.00220422f, 0.10378397f, 0.18934831f, -0.05309844f, 0.14795335f, 0.12368222f, 0.02499426f, -0.03906621f, 
    0.01821766f, 0.20430815f, -0.18062089f, -0.21655507f, 0.08803571f, 0.02061715f, -0.12432794f, -0.13950360f, 
    0.01282728f, -0.01846000f, 0.03777426f, 0.04416704f, 0.00766701f, -0.21015231f, 0.02440595f, 0.01141504f, 
    0.07385302f, -0.10316721f, 0.10063855f, 0.01377832f, 0.09650595f, 0.01688458f, 0.05920523f, -0.08715790f, 
    -0.19022492f, -0.00438677f, 0.16785435f, 0.13105525f, 0.06247032f, 0.08753824f, -0.01710533f, 0.14615472f, 
    0.03750058f, 0.05235413f, -0.00719904f, 0.05929194f, -0.06610034f, -0.10393703f, -0.00823293f, 0.06845072f, 
    0.00097544f, -0.05241372f, -0.00742640f, -0.01727105f, -0.01885125f, 0.15472589f, -0.01205598f, 0.00251285f, 
    -0.12304580f, 0.14107811f, -0.03087842f, -0.30337343f, -0.04789516f, 0.09714695f, 0.04640722f, 0.06381014f, 
    0.11319073f, 0.00043126f, 0.09696974f, -0.10106845f, -0.17727467f, -0.05341245f, 0.05086391f, 0.09967858f, 
    -0.00914362f, 0.02639267f, 0.10081641f, -0.07903111f, 0.06071476f, 0.06774699f, -0.07937022f, -0.03577395f, 
    -0.15881513f, -0.10042702f, -0.28209609f, -0.02403342f, 0.11733537f, -0.12218510f, 0.12416869f, 0.01237022f, 
    0.00047833f, -0.07715230f, 0.08266629f, 0.09873954f, -0.00918770f, -0.19175473f, -0.06327588f, 0.00098547f, 
    -0.01114671f, -0.06307803f, 0.09236211f, 0.04314449f, 0.01738496f, 0.03417502f, 0.08074932f, 0.15752701f, 
    0.10106790f, -0.07731512f, 0.15808393f, 0.04555706f, 0.00910851f, -0.00379636f, 0.00437587f, 0.12110696f, 
    0.07201615f, 0.15139121f, -0.06964513f, -0.18309247f, 0.08818971f, -0.15695733f, 0.21588138f, -0.16795652f, 
    -0.20347939f, 0.00708940f, -0.01611170f, -0.05982667f, -0.01659569f, 0.16618529f, -0.03083772f, -0.08424518f, 
    0.03629078f, -0.10982227f, 0.08198066f, -0.20116886f, 0.12715989f, -0.04912210f, -0.20310690f, -0.05854908f, 
    0.00534054f, -0.01298183f, 0.06743163f, 0.16065544f, 0.00226320f, -0.12752883f, -0.05462916f, 0.10592121f, 
    -0.00986710f, -0.04051862f, 0.02623726f, 0.08609971f, 0.07140495f, 0.02954094f, -0.00032832f, 0.02947618f, 
    0.15236221f, -0.04714271f, 0.17032064f, 0.02577640f, 0.01037459f, 0.06791026f, 0.04532168f, 0.04850079f, 
    -0.00261209f, -0.06186175f, -0.03341841f, 0.04122620f, -0.12938707f, 0.24428578f, -0.29063147f, -0.30667198f, 
    0.07666522f, -0.01826773f, -0.06465762f, -0.08735860f, 0.14061584f, 0.00147929f, 0.05660658f, -0.01098315f, 
    0.23587759f, -0.12723082f, 0.02371260f, -0.02386237f, 0.08658008f, 0.01083197f, 0.05329423f, 0.03637696f, 
    0.11398950f, -0.00876192f, 0.06668667f, 0.08738412f, 0.25536940f, 0.19563428f, 0.10232221f, 0.04708405f, 
    0.01763365f, -0.03233370f, -0.08031797f, 0.08541768f, 0.14023560f, 0.09800027f, -0.01448779f, 0.04984513f, 
    0.18388307f, -0.02579178f, 0.02048536f, -0.08847238f, 0.08114254f, -0.05324294f, -0.08774252f, -0.10486923f, 
    -0.04854362f, -0.03676808f, -0.09427637f, -0.11893898f, 0.07096604f, 0.12247365f, 0.08046265f, 0.45910788f, 
    -0.01090642f, 0.09339049f, -0.04760877f, -0.02107949f, 0.09556638f, 0.06245086f, 0.06403556f, 0.07200711f, 
    0.26774508f, -0.14378573f, 0.07810131f, 0.11268904f, -0.23977520f, -0.11383294f, 0.14771995f, 0.08448824f, 
    0.03002128f, 0.00932286f, -0.06662843f, -0.06108070f, -0.16579376f, -0.13868260f, -0.00242544f, -0.08656266f, 
    0.01059580f, -0.06357683f, -0.06492784f, 0.09067687f, 0.13856910f, -0.07967094f, -0.06341108f, -0.07451707f, 
    -0.19892852f, 0.26116103f, 0.59231180f, 0.10719226f, 0.12773505f, 0.07368116f, -0.06456848f, 0.05103796f, 
    0.00568097f, -0.06418034f, 0.02458840f, 0.00112830f, -0.26829135f, 0.06227390f, 0.13242532f, -0.00278633f, 
    0.06929971f, -0.01380310f, -0.08738186f, 0.05346175f, 0.08828410f, 0.05776947f, 0.04082656f, 0.14945836f, 
    -0.09824804f, -0.01244399f, 0.09723926f, 0.14178063f, -0.00891085f, 0.03304071f, -0.06118180f, 0.04146738f, 
    -0.01265926f, -0.00391247f, 0.04654832f, -0.00104052f, -0.11027394f, -0.02403190f, -0.11003844f, -0.08537760f, 
    -0.08670136f, -0.04649309f, -0.10568246f, -0.13955511f, 0.05103290f, 0.07391678f, -0.15362082f, -0.19376518f, 
    -0.07486484f, -0.14329308f, 0.08883625f, -0.10082234f, 0.05292169f, 0.11225802f, -0.05740536f, 0.03147585f, 
    0.09972029f, 0.00909450f, 0.06875347f, -0.03153292f, -0.03068937f, 0.18572959f, 0.07002773f, 0.01149307f, 
    -0.03581356f, -0.03972155f, -0.14219646f, -0.12897538f, 0.06878071f, 0.06311321f, -0.05935558f, -0.08472797f, 
    0.20416069f, 0.13278031f, 0.20404118f, -0.14380048f, -0.06445309f, 0.04070693f, 0.13071953f, -0.23233671f, 
    -0.23367113f, 0.14913981f, -0.08646546f, 0.20723850f, 0.35897604f, -0.01769316f, 0.01694461f, -0.09387808f, 
    -0.11948891f, -0.07488973f, -0.02343778f, 0.01504226f, -0.12365662f, 0.22313057f, -0.00824407f, 0.01911932f, 
    0.24379349f, 0.04916178f, 0.06765508f, -0.01299408f, 0.07598625f, -0.04997937f, 0.02864453f, 0.09123670f, 
    0.00502583f, 0.11780273f, 0.09984214f, -0.10291936f, -0.08283205f, -0.05478777f, -0.04039502f, 0.08480471f, 
    -0.04489467f, -0.00186071f, 0.11714441f, 0.00091726f, 0.11643448f, -0.01567969f, 0.08298144f, 0.04919438f, 
    -0.30722502f, 0.13503511f, -0.18498246f, -0.17554078f, 0.06119347f, -0.05580186f, -0.09828546f, 0.09036471f, 
    -0.01763068f, 0.05271592f, -0.07535429f, 0.05980921f, 0.06575516f, 0.07914267f, 0.08663943f, -0.09526502f, 
    -0.06816924f, 0.01512374f, -0.18621251f, -0.09854908f, -0.06260899f, 0.00747076f, -0.03895693f, -0.06743675f, 
    0.05169201f, 0.11966909f, 0.20804495f, 0.07682028f, 0.03924427f, -0.01597902f, 0.04120180f, 0.20538458f, 
    0.03951179f, 0.06877924f, 0.08896160f, -0.01674130f, -0.28030500f, 0.08939146f, 0.10148059f, 0.21679714f, 
    -0.09151181f, -0.02067768f, 0.01435943f, -0.00128019f, 0.04642077f, 0.09340038f, 0.21779351f, -0.13944443f, 
    -0.24868545f, -0.13465248f, -0.12630105f, 0.04481628f, -0.06384267f, 0.04367916f, -0.01923430f, 0.19412950f, 
    0.02998526f, -0.06106566f, -0.07556654f, -0.01436410f, 0.32938832f, 0.13984403f, 0.16726083f, -0.05754296f, 
    -0.17146274f, -0.08355442f, -0.06107308f, -0.11852209f, 0.00141697f, 0.00788261f, -0.10642934f, -0.03321717f, 
    0.21053194f, -0.03488335f, -0.24963094f, 0.03874933f, -0.14038348f, -0.07933930f, 0.11062939f, 0.01074779f, 
    0.13481951f, 0.04460602f, -0.18462932f, -0.29949918f, -0.04674412f, -0.00247080f, -0.03951950f, 0.13907692f, 
    0.01110891f, -0.01827649f, 0.07097890f, 0.12012351f, -0.05353711f, 0.11359411f, 0.18054879f, -0.13179259f, 
    0.22876553f, -0.12743339f, 0.24084060f, 0.19784637f, 0.12944694f, -0.01601230f, -0.09255138f, -0.03811678f, 
    0.13514805f, 0.24930954f, 0.18402341f, 0.04031074f, -0.19143879f, 0.34441212f, -0.24702328f, 0.11873388f, 
    0.04453477f, -0.09013971f, 0.02003862f, -0.08860894f, 0.01775470f, 0.07608628f, -0.05412868f, -0.08016443f, 
    0.19885691f, -0.02789743f, 0.05419282f, -0.07045512f, -0.06976064f, -0.06705932f, 0.07391527f, -0.01470625f, 
    0.02352066f, 0.10239772f, 0.07524484f, -0.04646103f, -0.14280692f, -0.18856269f, 0.00537035f, -0.00020255f, 
    0.15204774f, 0.06780078f, 0.02669223f, -0.04328682f, -0.02824217f, 0.02240612f, -0.05216050f, -0.09651508f, 
    0.16251726f, 0.01555360f, -0.04857016f, -0.09568293f, -0.09772719f, 0.01658206f, -0.04057521f, -0.02142700f, 
    0.14785181f, -0.01491518f, 0.07515524f, -0.02554416f, -0.22722106f, -0.10996766f, 0.02447158f, 0.10260672f, 
    -0.04698618f, -0.04217147f, -0.07134467f, 0.06019897f, 0.03945123f, 0.06207286f, 0.06564360f, -0.02306541f, 
    -0.01517225f, -0.08648067f, -0.00101919f, -0.17506588f, 0.03787746f, -0.01424861f, 0.07538297f, 0.04147771f, 
    0.02801580f, 0.05051602f, 0.04733466f, 0.01578544f, -0.15421280f, 0.32377464f, 0.14110540f, 0.26730752f, 
    0.05151958f, 0.15606727f, -0.00542670f, 0.04842095f, -0.10905035f, 0.08179507f, 0.02654402f, 0.01393172f, 
    -0.27227753f, 0.00777935f, -0.10872703f, -0.05163575f, 0.04139676f, -0.05678006f, 0.00867003f, -0.04399386f, 
    -0.07415662f, -0.10715549f, 0.03642750f, 0.15504913f, -0.42153010f, 0.22220618f, -0.11603748f, 0.02211005f, 
    0.01007363f, 0.05693069f, 0.04629183f, 0.06542636f, 0.09314156f, 0.07423119f, 0.04813738f, -0.04923282f, 
    -0.05192513f, 0.26368490f, 0.20757148f, 0.25337741f, 0.05028351f, 0.01821823f, -0.02587597f, 0.08283377f, 
    0.10616776f, 0.04279939f, 0.07762881f, -0.13159525f, -0.17811680f, 0.12589970f, 0.05924550f, 0.15539391f, 
    -0.02274963f, -0.12786460f, 0.06843566f, 0.14218859f, 0.03269523f, -0.00301112f, -0.11320113f, -0.02639417f, 
    0.07371806f, -0.16749315f, -0.02449883f, 0.01809848f, 0.08969685f, -0.03940774f, 0.04276488f, -0.00768954f, 
    0.12041441f, 0.10001783f, -0.00377764f, 0.03651037f, 0.07715723f, 0.27440101f, 0.26379094f, 0.30307117f, 
    -0.20357451f, 0.15694678f, -0.05639959f, 0.05453345f, -0.02866899f, 0.03864287f, -0.05407050f, 0.00186194f, 
    -0.22296031f, 0.35910758f, 0.17162220f, -0.10564831f, 0.10100034f, 0.11434986f, -0.14943057f, 0.23755477f, 
    0.03105891f, -0.04575018f, 0.04051714f, -0.08963092f, 0.09977856f, 0.09999549f, 0.20924376f, 0.23465931f, 
    -0.13963966f, 0.11226345f, 0.08900385f, 0.21277711f, 0.10861568f, -0.05043192f, 0.03863650f, 0.01188526f, 
    -0.03421153f, -0.14273879f, 0.34476614f, 0.44736525f, 0.06828423f, 0.14667891f, -0.01922158f, 0.04349490f, 
    -0.10689389f, 0.01908799f, -0.05550935f, -0.10863402f, -0.03492038f, -0.03789669f, 0.41637951f, 0.39298040f, 
    0.09709054f, -0.20834503f, 0.01356974f, -0.03006714f, -0.10213072f, -0.04948380f, -0.07669564f, -0.01070786f, 
    0.19294699f, -0.09414271f, 0.06261821f, 0.01357427f, 0.10254366f, 0.01394860f, -0.02310085f, 0.07014031f, 
    0.02803597f, -0.14960967f, 0.05562390f, -0.03504827f, 0.09903262f, 0.02167120f, 0.04288215f, -0.04377127f, 
    0.11838689f, -0.12390609f, 0.06506231f, -0.05568345f, 0.01116662f, -0.11630754f, 0.01067253f, -0.11913835f, 
    -0.33473432f, 0.12379376f, 0.08758501f, 0.11258528f, 0.12021291f, 0.09917886f, 0.04129688f, 0.14050725f, 
    0.02073215f, -0.00433383f, -0.04275222f, 0.12721981f, 0.05572495f, -0.16489434f, 0.04935339f, -0.03743744f, 
    -0.03801944f, 0.18199864f, 0.10813379f, 0.25540727f, 0.02659057f, -0.09341305f, -0.00338483f, -0.00791949f, 
    0.04098558f, 0.21938616f, 0.36295828f, -0.03972105f, 0.07802980f, 0.02914412f, 0.15337770f, 0.19496739f, 
    -0.03757478f, 0.14502738f, 0.04013519f, 0.02352437f, -0.25771275f, -0.12239797f, 0.04393657f, 0.22369248f, 
    -0.13176225f, 0.04479156f, -0.00092452f, 0.10998194f, -0.03748580f, -0.06189422f, -0.02217256f, -0.07852831f, 
    -0.11357553f, 0.05850957f, 0.23232679f, 0.36016339f, -0.01275792f, 0.00139235f, -0.08431618f, 0.01252998f, 
    -0.01994472f, -0.02793615f, 0.04915905f, 0.07011146f, 0.14443499f, 0.03392462f, -0.01336090f, 0.10017207f, 
    0.08404811f, -0.22769120f, 0.26705876f, 0.04460497f, 0.09361637f, 0.11173555f, -0.20491943f, -0.00042446f, 
    -0.19393410f, -0.10573770f, -0.09314233f, 0.01531673f, 0.00938694f, 0.04756081f, -0.11753612f, 0.01647730f, 
    0.01229421f, 0.06559004f, -0.00604506f, 0.01222281f, -0.04075082f, 0.01369483f, 0.26988837f, 0.32687435f, 
    0.03911788f, 0.03076052f, 0.03798113f, -0.05767617f, -0.02362334f, 0.00510309f, 0.06287016f, 0.04231038f, 
    -0.16296108f, -0.09518910f, 0.26305458f, 0.30419523f, -0.01360723f, 0.14065033f, -0.09976266f, 0.09152307f, 
    0.02017078f, 0.04795133f, 0.01149260f, 0.08988724f, 0.03271054f, 0.16638507f, 0.20565929f, 0.32005730f, 
    -0.09977874f, -0.02724535f, 0.02487123f, 0.11845849f, 0.08288647f, -0.02389685f, 0.03935285f, 0.16296054f, 
    -0.26978028f, -0.05219191f, -0.13175011f, 0.07756915f, 0.18324660f, -0.13884124f, -0.03360241f, 0.12009489f, 
    0.14969762f, 0.17494640f, -0.08757693f, 0.05356655f, 0.09704726f, 0.30244893f, 0.36940244f, 0.31511489f, 
    -0.02883287f, -0.05777639f, 0.24701963f, -0.10076606f, 0.03282776f, 0.00224001f, 0.01051665f, -0.01819832f, 
    -0.06935489f, 0.05329016f, 0.55910605f, 0.36800423f, 0.05049662f, -0.05273950f, -0.14716633f, 0.06981666f, 
    -0.09159650f, -0.06498262f, -0.10031418f, -0.19376984f, -0.15560576f, 0.16073309f, 0.07941618f, 0.09656604f, 
    -0.06830901f, -0.00749145f, 0.08311405f, -0.03435533f, 0.07998151f, 0.02133946f, -0.01950007f, -0.00896590f, 
    0.09634741f, 0.04082602f, 0.03514425f, 0.02449997f, 0.02369840f, 0.05091463f, 0.01416262f, 0.08075506f, 
    0.08604416f, -0.07026751f, 0.01278086f, 0.12726933f, 0.12462080f, -0.03760538f, -0.18597069f, 0.00209154f, 
    0.13000233f, -0.06702283f, -0.01276714f, 0.00142743f, 0.23074520f, 0.13435112f, -0.05347634f, -0.03456040f, 
    -0.13742904f, -0.10126367f, 0.15222681f, 0.29008400f, -0.18515594f, 0.02774240f, -0.23546766f, 0.17157333f, 
    0.13777788f, -0.06305747f, 0.03726017f, -0.00969829f, -0.04259020f, -0.00176520f, 0.24895281f, 0.20354411f, 
    0.05694541f, -0.00158275f, -0.01563158f, 0.01428706f, 0.05917231f, 0.00994682f, -0.03974076f, -0.00974990f, 
    0.10998219f, -0.13628648f, 0.11885367f, 0.24040721f, -0.12974784f, 0.29042107f, 0.14384784f, 0.22983162f, 
    -0.02492474f, 0.00656238f, -0.03110156f, -0.06342656f, -0.25601122f, 0.06113872f, 0.03570530f, 0.03764191f, 
    0.08550382f, -0.12125103f, 0.01846425f, 0.06222082f, 0.14166799f, 0.20228478f, -0.04696503f, 0.08535409f, 
    -0.05724041f, -0.02666546f, 0.16872878f, 0.18474437f, -0.08277372f, -0.00617389f, -0.06480131f, 0.07700033f, 
    0.12011328f, -0.00487978f, -0.05868578f, 0.03041231f, 0.00345210f, -0.16353022f, -0.11056069f, -0.06718463f, 
    -0.11647408f, -0.08266362f, -0.09922972f, -0.04265494f, 0.06294197f, -0.06289316f, 0.07413101f, -0.01068505f, 
    -0.00305724f, -0.16315404f, 0.02497488f, -0.04959555f, 0.11386173f, 0.15520482f, 0.04497184f, 0.03805847f, 
    -0.17310677f, 0.02951133f, 0.02103849f, -0.08343433f, 0.29482731f, 0.15880355f, 0.14087397f, 0.23793109f, 
    0.01078888f, 0.10105980f, -0.02914529f, -0.03290273f, 0.03969307f, -0.02723468f, -0.12773882f, 0.24888609f, 
    0.04745366f, 0.02647115f, -0.08913399f, 0.12629707f, 0.03860651f, 0.04744419f, -0.08387130f, 0.10112689f, 
    -0.06222376f, 0.11932416f, 0.05825793f, -0.11962673f, 0.01165123f, 0.22981824f, 0.09887516f, 0.23476180f, 
    0.01766389f, 0.00278388f, 0.00358358f, -0.00496233f, -0.12921770f, -0.06905784f, -0.09883686f, -0.01739778f, 
    0.12549396f, 0.05034111f, 0.31843358f, 0.21032819f, 0.17744774f, 0.16430904f, 0.00880639f, 0.03981465f, 
    -0.02974011f, -0.07597849f, 0.00965556f, -0.12914832f, 0.10556868f, 0.43601888f, 0.12900284f, 0.31088075f, 
    0.03226568f, 0.02456810f, -0.08227432f, 0.03670409f, 0.05362971f, 0.10060050f, -0.03249307f, 0.10317370f, 
    -0.04121750f, 0.25959894f, 0.30767336f, 0.21583587f, 0.06894364f, 0.02517777f, -0.06557607f, 0.00593492f, 
    0.01403275f, 0.03387579f, 0.07244432f, 0.19003241f, -0.14075020f, 0.02243376f, -0.02365323f, 0.04513967f, 
    0.02786363f, -0.01975131f, 0.04224300f, 0.00468671f, -0.02040683f, 0.03005456f, -0.03367798f, 0.05719072f, 
    -0.23333749f, 0.16958274f, 0.38845295f, 0.28481117f, -0.00187878f, 0.01501561f, 0.03221788f, 0.03177893f, 
    0.03938663f, 0.14588389f, -0.02190837f, -0.06536162f, -0.10188329f, -0.24199015f, -0.14507511f, -0.11330865f, 
    0.07733430f, -0.01762072f, -0.14447458f, -0.02573866f, 0.06089532f, -0.11494677f, -0.18652499f, 0.05101386f, 
    0.01178252f, -0.21602577f, 0.08073310f, 0.16346103f, 0.02428311f, -0.02000912f, -0.09834107f, 0.01619811f, 
    -0.10483475f, 0.09276790f, 0.00046426f, -0.08789447f, -0.24770990f, 0.03662882f, 0.11801042f, 0.14400491f, 
    -0.14989090f, 0.09184051f, -0.12018010f, 0.01469435f, -0.01857665f, 0.22483203f, 0.08931312f, 0.00432654f, 
    0.01149112f, -0.00052235f, 0.02001058f, 0.00038895f, -0.03599683f, 0.06281387f, -0.07142441f, 0.07193773f, 
    -0.08658761f, 0.00691552f, 0.04464957f, -0.03076466f, 0.12163018f, 0.16851778f, 0.24037732f, 0.24369824f, 
    0.14668663f, -0.14836374f, 0.20689745f, 0.08374183f, -0.05380078f, 0.11799897f, -0.08624274f, 0.11131136f, 
    -0.47526428f, 0.13891670f, 0.11943991f, 0.13800843f, 0.02243006f, -0.00955380f, -0.06605777f, 0.23712170f, 
    0.05543345f, 0.10798115f, -0.04398783f, -0.02109540f, -0.02183387f, -0.22766325f, -0.06347926f, -0.04315701f, 
    -0.10315092f, 0.01149115f, -0.05256307f, 0.02664310f, -0.03036318f, -0.00278301f, -0.02089185f, -0.09884073f, 
    0.40566891f, 0.07560040f, 0.10204896f, -0.16139817f, -0.04808459f, 0.02239243f, -0.03816989f, 0.01093584f, 
    0.01236346f, -0.13525100f, 0.19262375f, 0.10135854f, 0.16931710f, 0.17136794f, 0.28479919f, 0.08574842f, 
    -0.02901053f, 0.05459765f, 0.01514231f, 0.03937995f, -0.00741277f, -0.10482270f, 0.06686060f, -0.05158300f, 
    -0.15708202f, 0.24573092f, 0.00946276f, 0.16175786f, 0.04036557f, -0.03531224f, 0.03591342f, 0.23286280f, 
    -0.00843641f, -0.07474634f, -0.19546862f, -0.12645589f, -0.10278360f, -0.22283281f, -0.07266016f, 0.10353316f, 
    0.02342131f, 0.08845646f, -0.03733753f, -0.05052702f, -0.08926791f, 0.00849182f, 0.03621797f, -0.13262160f, 
    -0.15322748f, 0.01943255f, 0.14503011f, -0.05167992f, -0.03008432f, -0.03406810f, 0.06347419f, -0.01604599f, 
    -0.12047458f, -0.06915540f, 0.06630005f, -0.06039516f, -0.02599404f, 0.23547843f, 0.03214988f, -0.16197646f, 
    0.04828754f, -0.01912468f, -0.04730648f, 0.02864425f, 0.11737507f, 0.01830557f, -0.03108323f, -0.01910208f, 
    0.18109164f, -0.02453776f, 0.39721194f, 0.09715791f, 0.14094654f, 0.07483070f, 0.02782685f, 0.09131513f, 
    0.06931053f, 0.03280145f, 0.10500985f, 0.21016067f, -0.06166816f, -0.01312696f, -0.12579715f, -0.13896394f, 
    0.00801451f, 0.01371358f, -0.18667819f, 0.00589373f, 0.09794636f, -0.09224876f, -0.01190364f, 0.14493529f, 
    0.13261296f, -0.19440985f, -0.18989885f, -0.07234940f, -0.06231725f, -0.02663711f, -0.06706983f, -0.04386150f, 
    0.13102917f, -0.00262333f, 0.10432005f, 0.02457423f, 0.10246843f, 0.23877764f, 0.40204361f, 0.31493506f, 
    -0.07700600f, 0.07888059f, 0.07914864f, 0.04115751f, -0.01255410f, 0.05400157f, -0.06365971f, -0.01707254f, 
    -0.10822275f, -0.06265716f, -0.21304567f, -0.16697001f, -0.04266114f, -0.02459811f, -0.07096478f, -0.00579196f, 
    0.07809997f, 0.09977660f, -0.12266972f, -0.07908066f, 0.07841107f, 0.36472172f, 0.33655164f, 0.28951818f, 
    -0.08253606f, 0.13693136f, 0.09625883f, 0.09196252f, 0.04842884f, 0.05544201f, -0.01760168f, -0.05963375f, 
    -0.11448866f, 0.07956340f, 0.17564933f, 0.09018699f, -0.03108736f, -0.11481104f, 0.03079413f, -0.00435227f, 
    0.00611701f, 0.07801586f, 0.04199314f, 0.07023223f, -0.21877037f, 0.14454713f, 0.15756911f, 0.38684249f, 
    0.05562541f, 0.09126502f, 0.10561270f, 0.08301987f, 0.14589784f, 0.18897530f, -0.13546103f, -0.05043448f, 
    0.00750011f, 0.06104767f, 0.05057026f, 0.10935029f, -0.07285918f, 0.12747981f, 0.02485658f, -0.04875040f, 
    -0.03705743f, -0.05875064f, 0.02806622f, -0.11779805f, -0.11146060f, 0.13276151f, -0.08480859f, -0.07611242f, 
    0.01801932f, 0.05302014f, -0.05884539f, 0.03352529f, 0.01372780f, -0.07663123f, -0.19416626f, 0.06400184f, 
    0.01631317f, -0.11505071f, 0.14466660f, 0.02946240f, 0.09028389f, -0.05774718f, 0.04283017f, -0.01434731f, 
    -0.02024844f, 0.00053187f, 0.01412411f, 0.03946803f, -0.01137183f, 0.01088985f, -0.06805012f, 0.06363676f, 
    0.11342232f, 0.04823541f, 0.05792121f, -0.03546850f, -0.01708456f, 0.08008813f, 0.09113266f, -0.11345726f, 
    -0.02233638f, -0.21477897f, 0.14362022f, 0.06297462f, -0.00209290f, 0.01151756f, -0.07736389f, 0.04383218f, 
    0.00497847f, -0.07042102f, 0.03196212f, 0.00153523f, 0.13987911f, -0.36879000f, -0.05725864f, 0.15975805f, 
    0.18792105f, -0.11671762f, -0.05117618f, -0.04404121f, 0.06652613f, 0.04044149f, 0.02317806f, -0.06652281f, 
    0.01470108f, 0.09268547f, 0.13315934f, 0.14565192f, -0.05952778f, -0.03762106f, -0.09748629f, -0.08768231f, 
    0.02708611f, -0.04180828f, -0.05932578f, -0.02865364f, 0.17716382f, 0.01752084f, -0.04418619f, 0.09605417f, 
    0.05208228f, -0.02072131f, -0.01423895f, 0.13571545f, 0.04552649f, 0.08735461f, 0.06170627f, 0.02227061f, 
    -0.07581771f, 0.06745093f, -0.02941940f, 0.14632598f, -0.11590585f, -0.14881885f, -0.00258723f, 0.06569041f, 
    0.14550680f, 0.05503578f, -0.02781660f, -0.04290106f, 0.28807566f, 0.11471760f, 0.03869221f, 0.12448077f, 
    -0.05997844f, 0.08758084f, 0.03560534f, -0.03064922f, 0.11577317f, 0.04216081f, -0.01870269f, 0.08752049f, 
    0.09202115f, -0.18619581f, 0.21762998f, -0.07699788f, 0.07716925f, -0.04510573f, -0.08361828f, -0.02709981f, 
    -0.00786205f, 0.22324678f, -0.00755823f, 0.11610363f, -0.14684987f, -0.00314231f, -0.12002730f, 0.03657023f, 
    0.02257508f, 0.05931934f, 0.11745378f, 0.05094818f, 0.14777012f, 0.02602611f, -0.08933510f, 0.06543352f, 
    -0.08551764f, 0.04957708f, 0.03170505f, 0.04288562f, -0.00113501f, 0.02279658f, -0.03188544f, 0.01034192f, 
    0.02570081f, -0.03531779f, 0.01746465f, 0.02338690f, 0.11171867f, -0.01826420f, -0.02648728f, -0.08536509f, 
    0.08920578f, 0.10841099f, -0.17075004f, 0.10695536f, 0.05636498f, 0.01997033f, 0.00958312f, 0.08536325f, 
    -0.03338718f, 0.22520052f, -0.01579249f, 0.00359906f, 0.04764754f, 0.17223543f, -0.12354248f, -0.14575565f, 
    -0.04979556f, 0.05552294f, 0.15630881f, -0.00223765f, 0.17466672f, -0.21690728f, -0.27094671f, 0.04550740f, 
    0.13950056f, -0.04390321f, -0.03255876f, 0.08705153f, 0.01482404f, 0.18442610f, -0.00279139f, 0.09532781f, 
    -0.00601708f, -0.00713403f, 0.11507983f, 0.00861519f, -0.20116703f, -0.06618493f, 0.14476481f, -0.01657348f, 
    0.07610194f, 0.07359382f, -0.10221054f, -0.01002040f, 0.37174389f, -0.14114256f, 0.06542546f, 0.07891320f, 
    0.09335499f, -0.05050898f, 0.00360837f, -0.01593536f, -0.15411137f, 0.04905754f, -0.04900860f, -0.07557005f, 
    -0.06187160f, 0.02381980f, -0.18028858f, -0.15346044f, -0.00857704f, 0.03572799f, 0.01341567f, 0.03310013f, 
    0.05275798f, -0.06244143f, 0.05976089f, -0.12649472f, 0.04771303f, 0.08431026f, 0.12298334f, 0.18226518f, 
    -0.04661247f, -0.03049950f, -0.02983822f, -0.09727899f, 0.08649477f, 0.07351664f, -0.02574802f, -0.03644104f, 
    -0.14724861f, 0.04511777f, -0.00997234f, 0.07918264f, -0.17613420f, -0.07530123f, 0.13325003f, 0.02181814f, 
    0.10010070f, -0.07147773f, -0.03796576f, 0.03441603f, -0.15262157f, -0.16192862f, 0.15435104f, 0.16732384f, 
    -0.18876711f, -0.15399946f, 0.06237784f, -0.00698858f, 0.08682569f, 0.08820990f, 0.07888754f, -0.05599966f, 
    -0.10973164f, 0.03745519f, -0.18630622f, -0.09474618f, 0.07350627f, 0.04600818f, -0.01825985f, -0.04287593f, 
    -0.03214956f, -0.00666205f, 0.04073530f, 0.02014325f, -0.09454480f, 0.07916434f, 0.16838917f, 0.13522087f, 
    -0.01653104f, 0.00623183f, 0.09971450f, 0.07662362f, 0.14043884f, 0.06057821f, -0.03356029f, 0.03479975f, 
    0.14417878f, 0.26370433f, 0.18122356f, -0.10517298f, -0.01667760f, 0.10689437f, 0.02545042f, 0.02094793f, 
    -0.02638607f, -0.13310067f, 0.13901244f, 0.01189274f, 0.14291483f, -0.00142573f, 0.06945086f, 0.08366299f, 
    -0.05095472f, -0.14286193f, 0.02207789f, -0.11205161f, 0.04466727f, 0.12683447f, 0.01979199f, 0.03693683f, 
    -0.02349033f, -0.07828236f, 0.15060714f, -0.03218842f, 0.04279764f, -0.02283287f, -0.14125091f, 0.07438346f, 
    -0.03921194f, 0.14618188f, -0.07191250f, 0.01337757f, 0.01978452f, 0.03922663f, 0.14030169f, -0.14755589f, 
    -0.02530604f, 0.05573614f, -0.09740356f, -0.06108417f, -0.27408823f, 0.12012355f, -0.02682514f, -0.14937490f, 
    0.14141709f, -0.20872416f, -0.17093940f, -0.01081522f, 0.17180295f, 0.05518160f, 0.03670436f, 0.00648138f, 
    -0.01362425f, 0.08693460f, -0.08869336f, 0.09714357f, 0.10563792f, 0.08023030f, 0.18169947f, 0.08164920f, 
    -0.11827144f, -0.12155481f, 0.07811290f, -0.00295419f, 0.04723920f, 0.10237850f, -0.01774240f, 0.05841172f, 
    0.38466665f, -0.16740942f, -0.03055898f, -0.17337123f, -0.05543960f, -0.01127318f, -0.17508198f, -0.01428302f, 
    0.05054194f, 0.07627621f, -0.00464572f, 0.03929385f, -0.24131145f, -0.04411288f, -0.29506651f, -0.08384594f, 
    0.07441999f, -0.01950328f, -0.02977240f, -0.02646854f, 0.01245945f, -0.03401853f, 0.04818940f, -0.03997494f, 
    0.15558651f, -0.11137322f, -0.07210905f, -0.06542604f, 0.13012300f, -0.09810224f, 0.03198224f, -0.09407216f, 
    0.02751486f, 0.08562890f, -0.00412514f, -0.00177162f, 0.06720941f, -0.10492769f, -0.05508951f, 0.14761277f, 
    -0.07611391f, 0.05045779f, 0.05281506f, -0.04283948f, 0.08440900f, -0.00868473f, -0.02869472f, -0.03154344f, 
    0.05106613f, 0.09857584f, 0.12125232f, -0.11756998f, 0.02422194f, -0.07972005f, -0.04590520f, -0.03117621f, 
    0.10340090f, 0.04838484f, 0.12561078f, 0.07133355f, -0.17547424f, 0.02559158f, 0.27109459f, 0.15386982f, 
    0.03300316f, 0.02288297f, -0.02761466f, -0.06036086f, -0.20766447f, -0.10315843f, 0.00328287f, 0.17049897f, 
    0.18403402f, 0.06109885f, 0.13465109f, -0.01503543f, -0.06327578f, -0.04744482f, -0.10614719f, 0.06196408f, 
    -0.06030542f, -0.04391163f, -0.02950330f, -0.09222276f, -0.09135091f, -0.27782372f, -0.01217031f, 0.14468400f, 
    0.09847727f, 0.02581689f, 0.06374755f, 0.04148173f, -0.00879297f, 0.09493054f, 0.11654411f, -0.07699465f, 
    -0.18958086f, -0.15380336f, 0.29927006f, -0.02608976f, -0.10450278f, 0.09311417f, -0.08336934f, -0.07756649f, 
    -0.02486832f, 0.02541555f, 0.08029884f, 0.14365430f, -0.14037409f, 0.02138682f, 0.20870353f, -0.20960096f, 
    0.03744715f, 0.10469122f, 0.11722185f, -0.08465250f, -0.14392671f, -0.00908715f, -0.10175422f, 0.15504235f, 
    -0.15117382f, -0.16261479f, -0.20229428f, 0.11838696f, -0.16766886f, -0.11890087f, 0.04263199f, -0.02622578f, 
    -0.11173362f, -0.07871738f, -0.00419462f, 0.02808530f, -0.04722911f, 0.04893873f, -0.07370752f, 0.00860150f, 
    0.02855425f, 0.04689924f, 0.00896203f, 0.06992363f, 0.06958400f, 0.05922548f, 0.07801837f, 0.10400912f, 
    0.00245775f, -0.21172254f, -0.11679871f, 0.08443426f, -0.03564500f, 0.00876059f, 0.10385537f, -0.08415323f, 
    0.08639498f, -0.11861581f, 0.09177587f, 0.05065811f, -0.32629919f, -0.09473271f, -0.02568456f, -0.23554820f, 
    0.01195759f, 0.11443582f, -0.03466710f, 0.04674226f, -0.13249744f, 0.00118640f, 0.09865744f, -0.01375047f, 
    0.11818760f, -0.05666890f, 0.08273641f, -0.19133066f, -0.00067311f, 0.06833033f, -0.09805144f, 0.09960993f, 
    -0.01184867f, 0.02986724f, 0.11643492f, -0.05084604f, 0.43197840f, -0.38319513f, -0.01872682f, -0.01307415f, 
    0.19479695f, -0.01788082f, -0.00207297f, 0.01778729f, 0.06423765f, -0.00947306f, 0.08925137f, -0.05893588f, 
    0.07745259f, -0.16704954f, 0.16992743f, -0.05846937f, 0.02221894f, 0.00485266f, 0.07729261f, -0.00380421f, 
    0.11912169f, -0.02309940f, 0.13668266f, 0.13603979f, 0.03019405f, 0.08357885f, -0.15814461f, -0.01901663f, 
    -0.03947849f, -0.07439569f, -0.00223344f, -0.11317184f, 0.04871546f, 0.05136193f, 0.02298057f, -0.09738529f, 
    -0.12397259f, -0.02877500f, -0.04103548f, 0.15400533f, 0.00693126f, -0.07736408f, 0.01473794f, -0.02319224f, 
    -0.06687997f, -0.07302036f, -0.00144948f, 0.05271159f, -0.08684777f, 0.01566364f, 0.00292921f, -0.03053953f, 
    -0.01147898f, -0.00847190f, -0.00238291f, -0.02074460f, 0.05868839f, 0.00164770f, 0.02836744f, -0.04585062f, 
    0.02474087f, 0.12537645f, 0.31387541f, -0.19160371f, -0.10525700f, 0.13159080f, -0.15068072f, -0.09257117f, 
    -0.12134739f, 0.07563825f, 0.07531705f, -0.20754272f, -0.10601030f, 0.03296530f, -0.08332173f, 0.06188041f, 
    0.01353748f, 0.06055572f, 0.00773046f, -0.04004189f, -0.00693683f, -0.02368127f, 0.09611211f, 0.00943132f, 
    -0.13499536f, -0.10436120f, 0.18066265f, 0.12403009f, -0.11128875f, -0.01473509f, 0.19898944f, 0.00771972f, 
    -0.07359610f, 0.06183708f, -0.07658567f, -0.00507387f, 0.19117460f, 0.13385367f, 0.10049409f, -0.10837729f, 
    0.09512115f, -0.12277921f, -0.04545467f, -0.00123150f, 0.11413014f, 0.07220615f, -0.01942837f, 0.00616640f, 
    -0.00966140f, 0.02703810f, -0.14847948f, -0.07914076f, 0.09253991f, -0.22743410f, -0.02103957f, 0.09074755f, 
    0.12660012f, 0.19655463f, -0.01176955f, 0.07331768f, 0.07816613f, 0.17113099f, 0.13518296f, 0.14112885f, 
    -0.00138537f, 0.07547719f, -0.12890314f, 0.05053525f, -0.07833380f, -0.03606033f, 0.13255329f, -0.01529523f, 
    0.16431250f, 0.02189604f, -0.02776758f, -0.06030744f, 0.04890975f, 0.08759292f, -0.02055208f, -0.03344522f, 
    -0.12389931f, 0.09209453f, 0.10184406f, -0.14423682f, -0.09226093f, 0.08107591f, -0.27617481f, 0.03385896f, 
    0.00987095f, -0.04353115f, 0.00187826f, 0.02423936f, -0.12361000f, -0.09960984f, -0.01329161f, -0.03231202f, 
    -0.03259846f, 0.06277172f, 0.02331770f, -0.10796322f, 0.01364969f, 0.01012856f, -0.09537316f, -0.04430305f, 
    -0.10735026f, -0.17503631f, 0.07661497f, -0.15674649f, 0.07074112f, -0.03163582f, -0.01468298f, 0.18753101f, 
    0.14034554f, -0.00058856f, 0.06235914f, 0.06213771f, 0.05511886f, 0.11453355f, 0.06396625f, 0.06066480f, 
    0.06974192f, 0.02355260f, -0.00575686f, -0.15501292f, 0.08173715f, 0.03779844f, -0.03681771f, -0.01558778f, 
    -0.07002903f, -0.09732027f, -0.08916959f, -0.21187165f, -0.14595798f, -0.11243990f, 0.07835797f, 0.06197590f, 
    0.05104426f, 0.12221844f, 0.08574112f, 0.11467342f, -0.11611365f, -0.01094328f, 0.07897872f, -0.01732539f, 
    -0.03737799f, -0.01885539f, -0.04761340f, 0.01956034f, 0.07958761f, -0.18587841f, -0.07822910f, -0.05144323f, 
    0.05590660f, 0.04025182f, 0.10770036f, -0.07233260f, -0.36234483f, 0.08821644f, 0.07357813f, 0.14863586f, 
    0.01611241f, 0.06298651f, 0.12477782f, -0.27543288f, -0.05379692f, -0.05611360f, 0.06676069f, -0.04764416f, 
    -0.00431048f, -0.00229025f, 0.01476562f, -0.03424890f, 0.17148161f, 0.16969772f, 0.03654335f, 0.03576622f, 
    -0.04429466f, 0.00185462f, 0.00787012f, 0.11468158f, -0.26592162f, 0.05802980f, -0.06212407f, -0.05780198f, 
    -0.00997668f, 0.08137579f, -0.01190406f, 0.00587040f, -0.00977644f, -0.01232501f, 0.09387729f, 0.05016779f, 
    -0.00248020f, 0.01743847f, 0.00875088f, 0.00393065f, -0.01547657f, 0.02683995f, 0.02182107f, 0.00686800f, 
    -0.03849778f, -0.02245754f, -0.01612362f, -0.03218388f, 0.02608126f, -0.02650160f, -0.00231132f, 0.00812899f, 
    -0.01154990f, -0.01252021f, 0.00021154f, 0.01431681f, -0.02099119f, -0.02151847f, -0.01573589f, 0.01018264f, 
    -0.00271605f, -0.02506305f, 0.02800750f, 0.00660548f, 0.00778778f, 0.01384872f, 0.02665173f, -0.00267431f, 
    0.02767032f, 0.01418244f, 0.00765898f, -0.01149663f, 0.00184260f, 0.01768926f, 0.02033442f, 0.01038582f, 
    -0.00631028f, 0.03263567f, 0.01130282f, -0.04391818f, 0.02665886f, -0.01435565f, -0.02707080f, 0.02570626f, 
    -0.02395759f, -0.02221097f, -0.00033325f, 0.01585864f, 0.01536183f, -0.00060264f, -0.04092388f, 0.02355701f, 
    0.00025441f, 0.02554733f, -0.02427813f, 0.01530899f, -0.02672767f, -0.03199367f, 0.00347911f, -0.01420748f, 
    0.00414049f, 0.00430001f, -0.02501840f, -0.00810559f, -0.03483936f, 0.02332686f, 0.00244858f, -0.03417243f, 
    0.01672068f, -0.01595657f, -0.01315336f, -0.00460229f, -0.01754127f, 0.00665536f, 0.01171126f, 0.01959366f, 
    -0.00935283f, 0.02649060f, -0.00484082f, 0.02710313f, -0.03288445f, 0.01557545f, -0.00221074f, 0.00068861f, 
    0.01536396f, -0.01894015f, -0.02710898f, -0.01626443f, -0.01153640f, 0.02425492f, -0.02581939f, -0.02560125f, 
    -0.01110344f, -0.00856335f, 0.01649068f, -0.00272046f, -0.01409415f, -0.01320224f, -0.02692431f, 0.02622007f, 
    -0.00707421f, -0.00526551f, -0.01592492f, 0.00418802f, -0.03266893f, 0.00799796f, 0.03263152f, 0.01453445f, 
    -0.02385792f, -0.01382121f, 0.01263003f, -0.00119861f, -0.02159476f, -0.03046917f, -0.02770670f, 0.02397703f, 
    0.02280638f, -0.01304798f, -0.00715779f, 0.02440309f, -0.00658650f, 0.00456672f, 0.02244025f, 0.00163937f, 
    -0.03546721f, 0.02382951f, 0.01093500f, -0.02249032f, -0.03936800f, -0.00181264f, 0.02051090f, -0.04008363f, 
    0.02335947f, -0.02420157f, -0.02457513f, 0.00911633f, -0.00769990f, -0.00538211f, 0.01433687f, -0.03350979f, 
    0.00004795f, 0.01679870f, -0.00904081f, -0.02997029f, 0.02603359f, 0.01697854f, 0.01445387f, -0.04309232f, 
    0.02153052f, 0.00501191f, -0.01652615f, 0.01088990f, 0.02794426f, -0.02340719f, -0.00385298f, -0.03847674f, 
    0.00939611f, -0.03323008f, 0.01544368f, 0.00963000f, -0.00251715f, -0.02327165f, -0.02823500f, -0.01452587f, 
    0.01510326f, 0.02779612f, -0.02636742f, 0.00996417f, 0.00885023f, 0.00829235f, 0.00738186f, -0.00091934f, 
    -0.00293389f, -0.02433447f, -0.01222729f, 0.01502875f, -0.00603130f, -0.02564397f, -0.03531658f, 0.00247491f, 
    0.01016998f, -0.03042029f, -0.03915409f, -0.00529119f, -0.01257295f, -0.00764942f, 0.00378468f, 0.01329047f, 
    0.03658530f, -0.02033328f, -0.03933394f, -0.02423578f, 0.01907081f, 0.01474990f, -0.01183287f, -0.03533249f, 
    -0.00532972f, -0.00760929f, 0.01775724f, 0.02179728f, -0.02785223f, 0.00380877f, 0.00749909f, 0.01764568f, 
    0.01437735f, -0.03870986f, -0.04285428f, -0.00845574f, 0.02084154f, 0.00808703f, 0.02401634f, -0.02398290f, 
    -0.02539763f, -0.01859642f, -0.00455091f, -0.03912412f, -0.01689371f, -0.01271184f, 0.01521270f, -0.02071108f, 
    -0.02402256f, -0.01469783f, 0.00886514f, -0.00484729f, -0.02205585f, -0.00145904f, -0.00653108f, -0.04051315f, 
    -0.00451534f, -0.01900052f, -0.00663419f, -0.02100474f, 0.02059466f, 0.02515139f, -0.02203802f, -0.02057312f, 
    -0.03325979f, -0.03219165f, 0.00188878f, -0.01413421f, -0.00687337f, -0.03125480f, -0.02362317f, 0.01825016f, 
    -0.02475155f, -0.02668256f, 0.01000194f, -0.02618823f, 0.00434281f, -0.03964670f, -0.01103686f, -0.01417394f, 
    -0.02925193f, 0.02268215f, -0.03536921f, 0.00767144f, -0.03920894f, 0.00277860f, 0.01827695f, -0.02679091f, 
    -0.02306063f, -0.00122503f, -0.01842350f, -0.03352915f, -0.02784330f, 0.01211178f, -0.01510684f, -0.03375927f, 
    -0.01689152f, -0.00189275f, -0.03937493f, -0.04046557f, 0.01400420f, 0.02103747f, -0.02745367f, -0.01932388f, 
    -0.03227024f, -0.01310918f, -0.04186330f, -0.02084822f, 0.02356021f, 0.01663578f, -0.04066167f, 0.00321449f, 
    -0.00246850f, 0.01386126f, 0.01561178f, -0.03147241f, -0.02613302f, -0.04249083f, 0.00924854f, 0.00408645f, 
    0.01101683f, -0.00614105f, -0.03103317f, -0.03038835f, 0.00420686f, -0.03451798f, -0.03445857f, 0.02967458f, 
    -0.01272829f, 0.03324015f, -0.02621735f, 0.02150544f, -0.00135031f, 0.02340941f, -0.00945652f, -0.03168203f, 
    0.02343017f, -0.03850800f, -0.00499008f, -0.00913198f, -0.02003893f, -0.00087942f, -0.00091190f, -0.00721218f, 
    -0.03586842f, 0.00028192f, -0.00062200f, -0.00659531f, 0.02018899f, -0.01189846f, -0.00997216f, -0.04324292f, 
    -0.02798739f, -0.02482470f, -0.03203543f, -0.03292697f, -0.00128134f, -0.02547139f, -0.00331318f, 0.01458660f, 
    0.01603153f, -0.01819412f, 0.01739928f, -0.02313377f, 0.00229020f, -0.03784003f, -0.00267866f, 0.02052492f, 
    -0.01037028f, -0.00901233f, -0.03391796f, -0.00534565f, 0.04181978f, 0.00802769f, -0.01477825f, -0.03734026f, 
    -0.03659046f, -0.02938915f, 0.01311308f, 0.02627941f, -0.02331849f, 0.01046497f, -0.01265096f, -0.01921955f, 
    0.01987237f, 0.01507626f, -0.00240672f, 0.02392097f, -0.01802776f, 0.02263440f, -0.02513509f, 0.00495646f, 
    -0.03486564f, -0.04042375f, -0.03280302f, -0.03956079f, -0.03670511f, 0.01312319f, -0.00833395f, -0.02296653f, 
    0.01628423f, 0.00114770f, 0.01618187f, -0.01585438f, -0.00950927f, -0.02536382f, 0.01153730f, -0.00308433f, 
    0.00076065f, -0.03853447f, 0.00272661f, -0.03711649f, -0.00678505f, -0.00122262f, -0.00474831f, -0.04081446f, 
    0.01783169f, -0.00174863f, -0.02369049f, -0.00465740f, 0.01310670f, -0.02161707f, -0.01247354f, -0.00845561f, 
    -0.03979042f, 0.00968816f, 0.01850184f, -0.02032746f, 0.00685454f, -0.01626617f, 0.01480098f, -0.03880985f, 
    -0.02090874f, -0.04147900f, 0.01170714f, 0.00103566f, -0.00171053f, -0.01334070f, 0.01605965f, 0.00592378f, 
    0.00670249f, 0.01757234f, -0.01327743f, -0.00212583f, -0.02625453f, 0.02338849f, -0.01532322f, -0.00929150f, 
    0.02420435f, 0.01505487f, -0.03576478f, -0.01301543f, 0.00133806f, -0.00081896f, -0.03566492f, -0.02391539f, 
    0.00518572f, -0.00439584f, 0.00794864f, 0.01808306f, 0.00690929f, 0.02615688f, 0.00219986f, 0.01179820f, 
    -0.01614484f, 0.00552787f, -0.01368550f, 0.00757385f, 0.00393797f, -0.03261877f, 0.02579115f, 0.01791178f, 
    -0.04041698f, -0.02030982f, 0.01807579f, -0.03835751f, 0.00101732f, 0.02091933f, 0.01363503f, 0.00451424f, 
    -0.03918685f, -0.00699202f, 0.02566902f, -0.00161807f, -0.02506857f, 0.00387441f, 0.02081823f, 0.02364933f, 
    -0.03239617f, -0.01554973f, -0.00598040f, 0.01852358f, -0.03200905f, 0.00247840f, 0.02166149f, 0.02137696f, 
    0.00608455f, -0.00086744f, -0.03978952f, -0.01746717f, -0.03684450f, -0.03152933f, 0.02452274f, -0.03629663f, 
    -0.02394055f, -0.03821388f, -0.03729802f, -0.01077712f, -0.03602684f, -0.01596002f, -0.02640775f, -0.00218440f, 
    0.00241826f, -0.02443573f, -0.00456842f, -0.02222563f, -0.01520519f, 0.02875252f, 0.00827518f, 0.00652297f, 
    0.02421785f, -0.01185234f, 0.02277925f, -0.01747977f, -0.03011426f, -0.02223749f, -0.03577686f, 0.00367429f, 
    -0.00258877f, -0.01594564f, -0.03563670f, -0.02956321f, -0.02616120f, 0.02637500f, -0.01871067f, -0.04120725f, 
    -0.00289582f, 0.02607461f, 0.03401922f, -0.03717959f, 0.00150667f, -0.00515397f, -0.01521375f, 0.01548636f, 
    -0.00554458f, -0.01971883f, 0.01227610f, 0.01672360f, 0.01860546f, -0.01912502f, -0.03012631f, 0.01152514f, 
    -0.00889646f, -0.01676829f, -0.00688907f, -0.01817658f, -0.00541988f, -0.03704075f, -0.02305274f, -0.03721513f, 
    0.00456506f, 0.02293183f, 0.01235726f, 0.01424336f, -0.01390275f, -0.00893611f, -0.00377709f, -0.02080006f, 
    -0.01154504f, 0.01383470f, 0.00616364f, -0.02656331f, -0.01612147f, 0.01946788f, -0.03329013f, 0.02867503f, 
    -0.02328747f, -0.01110910f, -0.03905732f, -0.02318741f, -0.01504467f, -0.01273249f, -0.02863811f, -0.01695865f, 
    -0.03659249f, -0.03982621f, -0.01616746f, 0.02462320f, -0.03280390f, -0.02266824f, -0.01075607f, 0.02267837f, 
    -0.02207400f, -0.03138806f, -0.02134513f, 0.01598741f, 0.00658503f, -0.03323663f, -0.01984665f, -0.00165472f, 
    -0.02299850f, -0.04056676f, 0.01572583f, -0.01449049f, -0.02084556f, 0.01999972f, -0.03818467f, 0.00724051f, 
    -0.04081074f, 0.00265186f, -0.02197567f, 0.01489069f, -0.03553803f, -0.02853923f, 0.01697821f, 0.00075164f, 
    -0.00217404f, 0.00583488f, -0.03062315f, -0.02698387f, -0.04342194f, 0.01727082f, -0.00347626f, 0.02096574f, 
    0.01910520f, 0.00857989f, -0.00567104f, -0.00649921f, -0.02999345f, 0.00260413f, -0.02676010f, 0.02718570f, 
    0.00605765f, -0.03376753f, -0.00762915f, -0.00861917f, -0.02164158f, 0.02493378f, -0.01725611f, 0.01704437f, 
    0.00297040f, 0.02619283f, -0.02017341f, -0.01932399f, -0.04004760f, 0.00174238f, 0.00355419f, -0.01608365f, 
    0.02119769f, -0.02635122f, -0.02626833f, -0.00446860f, -0.01983704f, 0.02342620f, -0.01417972f, -0.03652702f, 
    0.01255915f, -0.00230394f, -0.03489812f, 0.00896745f, 0.02044432f, -0.02005509f, -0.03471293f, 0.00189851f, 
    0.01021769f, -0.03084728f, -0.03795902f, -0.04302448f, -0.01802939f, -0.03647954f, -0.00280077f, -0.00807046f, 
    -0.01246241f, -0.03890081f, -0.04093923f, 0.00904506f, 0.02462528f, -0.04340302f, 0.02567975f, -0.01013814f, 
    -0.01320294f, 0.02648431f, 0.00915150f, -0.00768462f, -0.00850646f, 0.01667975f, -0.01949349f, 0.00299794f, 
    -0.00747468f, 0.00902226f, 0.00803306f, -0.00598244f, 0.01222598f, -0.03828534f, 0.00393026f, 0.00395557f, 
    -0.03073401f, 0.01013704f, -0.02432453f, 0.01166486f, -0.03039592f, 0.02595148f, -0.02479380f, -0.03123089f, 
    -0.01150954f, 0.02513999f, -0.03930739f, 0.00914581f, -0.02365099f, -0.03053981f, 0.00269839f, 0.00723924f, 
    -0.03409932f, 0.02963844f, -0.02395684f, -0.01484803f, -0.01401967f, -0.00918596f, -0.00346066f, -0.02851600f, 
    -0.00030925f, 0.02752734f, 0.00395467f, -0.03022742f, -0.02739494f, 0.00839736f, 0.02221419f, -0.04197560f, 
    -0.00105608f, 0.01719287f, -0.00934928f, 0.02593961f, -0.01821380f, 0.02444568f, 0.00732176f, 0.00434918f, 
    -0.02561046f, 0.00390990f, -0.01384798f, 0.02361476f, -0.01955792f, 0.02493211f, 0.00314046f, -0.01086328f, 
    0.00825967f, -0.03636783f, 0.01627135f, -0.01200752f, -0.00823199f, 0.01556699f, 0.03117105f, 0.00052241f, 
    -0.03103688f, 0.00282393f, -0.00785291f, -0.04365551f, 0.02514230f, -0.02338092f, 0.01933783f, -0.01966977f, 
    -0.01393093f, -0.02873441f, -0.03263694f, 0.00968400f, 0.01140452f, 0.00790373f, 0.00698359f, -0.03719369f, 
    0.02244928f, 0.01023116f, -0.00117774f, -0.04397492f, 0.02124436f, -0.03050199f, -0.02008709f, -0.03519396f, 
    -0.02514356f, 0.00628400f, -0.02003087f, -0.00407564f, -0.02178332f, -0.00623792f, 0.02414363f, 0.00827041f, 
    -0.00422186f, 0.02167826f, 0.01603310f, 0.01994395f, 0.01187571f, 0.01249180f, 0.00040261f, -0.03633173f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05284790f, 0.02519225f, 0.00565828f, -0.02819702f, 0.24599256f, 0.06483007f, 0.09586773f, -0.00978740f, 
    0.09084279f, 0.07539269f, 0.09590672f, 0.15145086f, 0.10049035f, 0.13842180f, 0.03673176f, -0.04223575f, 
    0.02683930f, 0.02918687f, -0.03091215f, 0.08118718f, -0.03488731f, -0.00741014f, 0.02906843f, -0.03961979f, 
    -0.05953816f, -0.03913379f, -0.06551265f, 0.09840614f, -0.00146394f, 0.13709304f, -0.07005445f, -0.02164979f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06476952f, 0.07728017f, 0.10229758f, 0.02088247f, 0.21287423f, 0.11737047f, -0.08245766f, -0.12444197f, 
    -0.02182072f, 0.14231309f, 0.32227468f, -0.00465643f, -0.10119495f, -0.13266431f, 0.05253045f, 0.08736050f, 
    0.03695491f, -0.03359906f, 0.07448236f, -0.01228778f, 0.03710617f, 0.02613328f, -0.10896375f, -0.16542168f, 
    -0.29174426f, -0.15741789f, -0.11557406f, 0.07812798f, -0.00895912f, 0.13863605f, -0.01495386f, -0.06367347f, 
    -0.05945734f, -0.13466564f, 0.01544448f, -0.02741164f, -0.18161976f, -0.08176932f, -0.32668424f, 0.05041579f, 
    0.10229190f, -0.25400838f, 0.17509650f, 0.27952152f, 0.28369996f, -0.01787806f, -0.18164282f, -0.00860709f, 
    -0.02604205f, -0.11401784f, -0.05184719f, 0.33521903f, 0.00664642f, 0.01379818f, -0.00948043f, -0.14738260f, 
    0.11283540f, 0.08336615f, -0.19337720f, 0.33576763f, 0.22539391f, 0.18560797f, -0.18989354f, 0.07652033f, 
    0.14674214f, 0.18263394f, -0.06819256f, -0.09382150f, 0.30714539f, -0.11598777f, -0.06450813f, -0.05627118f, 
    -0.15383214f, -0.08414939f, 0.13598640f, 0.16658978f, -0.01338905f, 0.09408405f, -0.32017198f, 0.28734332f, 
    -0.03042445f, 0.06098423f, 0.21788009f, 0.40649107f, -0.08907123f, 0.02400574f, 0.05812959f, -0.09887504f, 
    0.21913199f, -0.11473728f, 0.29546469f, -0.41826329f, 0.24003091f, -0.05325147f, 0.11277547f, 0.13880795f, 
    -0.22764041f, 0.08234864f, 0.05334933f, -0.07962380f, 0.18527503f, 0.25738305f, -0.07065109f, -0.05222495f, 
    0.21932076f, 0.25310501f, -0.20468540f, 0.10340926f, 0.07545093f, -0.21389775f, -0.20728512f, 0.48043394f, 
    0.16755240f, 0.16077006f, -0.15467969f, -0.09316209f, -0.09620345f, 0.01261743f, -0.06600322f, 0.05159395f, 
    -0.03983033f, -0.16572700f, -0.13820685f, -0.08702331f, 0.04989872f, 0.03224277f, -0.10289881f, -0.07167561f, 
    -0.05417512f, 0.06413894f, -0.15259428f, -0.07835377f, -0.16539812f, 0.07789366f, 0.01631032f, -0.12284858f, 
    -0.11399715f, -0.13620399f, 0.07377511f, -0.11009810f, -0.11687188f, -0.11983846f, -0.12778153f, -0.00482801f, 
    -0.00893265f, -0.03328337f, -0.09981834f, -0.16652375f, 0.14075375f, 0.12174305f, 0.08120296f, 0.04344242f, 
    -0.08453509f, 0.15961950f, -0.13146593f, -0.03474772f, -0.04710312f, -0.01937876f, -0.13623473f, -0.11375812f, 
    -0.11466398f, -0.09012624f, 0.01586119f, 0.05342193f, -0.00759334f, 0.11285593f, -0.05240744f, 0.14536417f, 
    -0.03625568f, -0.24090637f, 0.01537726f, -0.08663730f, -0.26970181f, 0.04837641f, -0.06292544f, -0.03389417f, 
    -0.05585137f, -0.09386284f, 0.00766095f, -0.02748333f, -0.14499915f, -0.10529368f, -0.11084075f, -0.16845745f, 
    -0.09121937f, 0.07547207f, -0.03117782f, 0.07220472f, 0.05735655f, -0.09383101f, 0.10733425f, -0.16246969f, 
    0.07760128f, -0.05130492f, 0.02318175f, 0.02880435f, -0.48167723f, 0.05367782f, 0.21212094f, 0.16647695f, 
    0.26912507f, -0.37266493f, -0.18941690f, -0.24481611f, 0.09922130f, 0.26508641f, 0.07062512f, 0.14218900f, 
    -0.14477333f, 0.01000402f, 0.04677370f, -0.11003009f, 0.05989601f, -0.12605818f, -0.09252697f, 0.07947672f, 
    0.21053436f, -0.16002564f, 0.29761550f, -0.46565846f, -0.37179089f, 0.11012082f, -0.15286765f, -0.04589941f, 
    0.17608938f, -0.16694173f, -0.14075756f, 0.11702221f, 0.09790452f, -0.07048395f, -0.27805364f, -0.06696258f, 
    -0.04347184f, -0.37188661f, -0.19040462f, 0.32402593f, 0.31597337f, 0.02441826f, 0.00544647f, 0.42454764f, 
    -0.06415009f, 0.15155177f, -0.17689507f, -0.07026558f, 0.00992263f, 0.15905710f, -0.00532705f, 0.07737239f, 
    0.26811561f, -0.10394601f, -0.20982440f, 0.01563007f, 0.10750598f, 0.23666312f, 0.18762617f, -0.12554446f, 
    -0.07681898f, 0.11283058f, 0.08411672f, 0.09042849f, -0.12965609f, -0.07042883f, 0.03432447f, 0.16837086f, 
    0.05387618f, -0.19620630f, 0.02151911f, -0.03370261f, -0.07976649f, 0.04738568f, -0.01066973f, -0.03347003f, 
    -0.13983342f, -0.02240512f, -0.19073659f, 0.07845301f, -0.11100230f, -0.13056362f, -0.04445809f, -0.11741970f, 
    -0.01033123f, 0.05097060f, -0.11563307f, -0.11568569f, -0.15688841f, -0.17709467f, -0.06850345f, -0.12478053f, 
    -0.04942164f, -0.00296398f, -0.11549212f, 0.08180275f, -0.01688110f, -0.10166678f, -0.09512522f, -0.01663864f, 
    -0.10967299f, -0.11576890f, -0.15261662f, 0.11651979f, -0.14567897f, -0.11068961f, -0.10078984f, -0.06107743f, 
    0.03624837f, 0.15434282f, -0.13795917f, 0.02239741f, 0.09533513f, 0.05151037f, -0.09863245f, 0.13477761f, 
    0.02274906f, 0.02466767f, -0.02395421f, 0.02954222f, -0.10659535f, -0.03447623f, -0.05619848f, -0.15355462f, 
    0.23563305f, -0.16394587f, 0.05137793f, -0.02317737f, -0.06470682f, 0.03447259f, 0.25695774f, 0.13620211f, 
    0.02269248f, 0.33277491f, -0.60457253f, -0.09287977f, 0.11387370f, -0.05041606f, 0.16067518f, 0.04729268f, 
    -0.04100431f, 0.05327518f, -0.06867232f, 0.15585941f, 0.04195042f, 0.03400164f, -0.01587752f, -0.09849291f, 
    -0.21687263f, 0.14977854f, 0.09214339f, -0.00206835f, 0.16581318f, -0.19911090f, -0.22401226f, -0.09284771f, 
    -0.12993173f, -0.02007835f, 0.13786767f, -0.17164411f, -0.16868898f, 0.06289621f, -0.10830306f, 0.00399418f, 
    0.11893698f, 0.09481877f, 0.08952626f, -0.10408795f, -0.13984255f, 0.05119098f, 0.08230235f, -0.22996782f, 
    0.02486286f, -0.10146087f, -0.09774822f, -0.11040889f, 0.12640090f, 0.11115761f, 0.10569268f, -0.00407362f, 
    -0.09069198f, 0.11331445f, 0.01422725f, 0.01937991f, -0.12808524f, -0.07543341f, -0.20042913f, -0.17781211f, 
    0.43846342f, 0.15242632f, 0.11315379f, -0.03329855f, -0.07150680f, 0.09360558f, 0.34319329f, 0.03740136f, 
    0.08955283f, -0.10436536f, 0.05744294f, -0.10028462f, 0.21253505f, 0.03598385f, 0.11293234f, -0.12812328f, 
    0.14768578f, 0.02678840f, -0.06816527f, 0.00942932f, -0.13378465f, -0.09084123f, 0.05875837f, -0.07275505f, 
    -0.04460678f, 0.14981653f, -0.06148072f, 0.00008863f, -0.28223285f, -0.13460535f, 0.13392644f, 0.14709839f, 
    0.43178171f, -0.07283586f, -0.06933682f, 0.03011266f, 0.27915344f, 0.14194466f, 0.06902876f, 0.14247575f, 
    -0.15941215f, 0.11418381f, -0.23336218f, 0.02432598f, 0.18136314f, 0.12421351f, 0.21360913f, 0.11371796f, 
    -0.04045982f, 0.03099952f, 0.04124683f, 0.13321048f, -0.08932552f, -0.07299051f, 0.17926840f, -0.09873994f, 
    -0.22753540f, -0.00232251f, -0.22241524f, -0.17900982f, 0.05479229f, -0.07444562f, -0.15012728f, 0.17846832f, 
    0.03645087f, 0.05084188f, 0.08637423f, -0.03973806f, 0.03781389f, -0.07617359f, 0.33904153f, -0.13800636f, 
    0.24921408f, 0.49700180f, -0.24361302f, -0.16123888f, 0.18186125f, -0.34869123f, -0.04244493f, -0.27498376f, 
    0.07312933f, 0.05034721f, -0.26968104f, 0.39494550f, 0.12693211f, 0.07397243f, -0.15829566f, 0.08586231f, 
    -0.11502776f, -0.04470789f, -0.09567067f, 0.11226282f, -0.08452518f, 0.10511297f, -0.32785246f, -0.04227843f, 
    -0.62452346f, 0.08201156f, -0.10048401f, 0.04111549f, 0.10018326f, 0.06506418f, 0.37350926f, -0.09085929f, 
    0.02831718f, 0.06637776f, 0.08443579f, 0.25421959f, -0.14998060f, 0.40645817f, 0.21197072f, -0.41833436f, 
    0.15010382f, 0.08137661f, -0.29136592f, -0.26771557f, -0.00511057f, -0.17087659f, -0.11689594f, 0.15050083f, 
    0.18713491f, -0.04296032f, -0.17581594f, -0.14189665f, -0.17101625f, 0.24979351f, -0.08736765f, -0.08615947f, 
    0.46252534f, -0.26930922f, 0.10814378f, 0.08944084f, 0.08948401f, -0.27599299f, 0.15326086f, -0.13193704f, 
    0.34729704f, 0.08760664f, 0.02974853f, -0.18383409f, -0.22366285f, 0.09312642f, 0.35749304f, 0.26255783f, 
    -0.06485350f, -0.10217380f, 0.21199945f, -0.08822374f, 0.17083977f, 0.03137360f, 0.04891217f, -0.15805821f, 
    -0.09204703f, -0.03283789f, 0.39951807f, 0.30738646f, -0.16753684f, 0.20766824f, -0.31493589f, 0.02900230f, 
    -0.06157487f, -0.17937298f, -0.17813903f, 0.15611464f, 0.13762745f, 0.42157999f, 0.00452184f, 0.17625113f, 
    -0.20297651f, 0.29201227f, -0.04414593f, -0.07504320f, 0.21191373f, -0.02267769f, -0.10766812f, 0.11332976f, 
    -0.13619277f, 0.13712281f, -0.12870343f, 0.07403155f, 0.00544112f, 0.06762243f, 0.08166417f, -0.07954866f, 
    -0.16572279f, -0.06448567f, 0.09703597f, 0.16957286f, 0.19565707f, 0.02537584f, -0.03409792f, -0.15707073f, 
    -0.27652854f, 0.10894601f, 0.07781677f, 0.07807154f, 0.16754501f, -0.10057756f, -0.00635532f, 0.13222297f, 
    0.23108630f, 0.18730503f, -0.18271331f, 0.13333201f, -0.04060026f, -0.41457960f, 0.00057383f, 0.21590774f, 
    0.00307159f, -0.05806965f, -0.03854835f, 0.29892230f, 0.07132681f, 0.13904297f, -0.10543228f, -0.13006727f, 
    0.19383366f, 0.05807589f, -0.18710402f, -0.23382081f, 0.34087411f, 0.18176815f, 0.17530189f, -0.01874661f, 
    0.02258439f, -0.10175385f, -0.16961327f, 0.12464052f, -0.03674689f, -0.00337262f, -0.03890793f, -0.16127622f, 
    -0.51422018f, -0.12024568f, 0.06919388f, 0.12265476f, 0.05994216f, -0.21802555f, -0.10538056f, 0.14989753f, 
    -0.10266601f, 0.04383513f, 0.14897645f, 0.18149909f, 0.10846110f, -0.05136913f, -0.06796249f, -0.04880055f, 
    0.26071718f, 0.01109965f, -0.42994198f, -0.05425365f, -0.16602693f, -0.22295463f, 0.14809851f, 0.10496884f, 
    -0.16140383f, -0.26498178f, 0.05992023f, -0.14108685f, 0.18957169f, 0.06502540f, -0.08914468f, 0.02720224f, 
    0.04541579f, -0.18639384f, 0.09377787f, 0.11489063f, 0.16754849f, 0.43700746f, 0.33861050f, 0.34796357f, 
    -0.17244262f, 0.14054899f, 0.06980324f, -0.10160087f, -0.09150817f, 0.12125264f, -0.17578529f, 0.12790534f, 
    -0.27706909f, 0.11412453f, -0.24260969f, -0.00094084f, 0.27304608f, -0.15249355f, -0.31767595f, -0.07617146f, 
    -0.05777005f, 0.02004950f, 0.13022263f, -0.14516689f, -0.13456708f, 0.09566380f, 0.01710480f, 0.00465669f, 
    -0.08799175f, -0.08434589f, 0.05591691f, 0.09412237f, 0.02540095f, -0.11930081f, 0.03104963f, -0.17974839f, 
    0.06797928f, -0.02698357f, -0.15238467f, -0.09065951f, 0.15268873f, 0.11419600f, 0.03915381f, 0.03740990f, 
    -0.05575576f, 0.06449152f, -0.13468295f, -0.15782413f, -0.08031729f, -0.14425081f, 0.00365317f, -0.15070164f, 
    -0.18678039f, 0.05719957f, -0.14485317f, -0.09006532f, -0.30263579f, -0.19002923f, 0.29310486f, -0.06837218f, 
    0.18303087f, 0.23038758f, 0.12600860f, 0.16959062f, -0.25055158f, 0.38229361f, -0.06787547f, 0.06923591f, 
    0.00013718f, -0.05127813f, -0.00612083f, 0.24658711f, 0.13274002f, -0.15567762f, 0.04287135f, -0.15324290f, 
    0.13854663f, 0.12621278f, -0.03335031f, 0.17467432f, -0.01658404f, -0.01275469f, 0.03007354f, -0.10394061f, 
    -0.32739604f, 0.03163232f, 0.13276325f, 0.04432335f, -0.16419969f, -0.15328385f, 0.33669522f, 0.14921604f, 
    -0.23293258f, 0.46596056f, 0.01544531f, 0.19916609f, 0.20056580f, 0.03918042f, 0.29762712f, -0.04861264f, 
    0.04386900f, 0.01452345f, -0.06027373f, 0.22762270f, 0.05791333f, -0.08660387f, -0.02672907f, 0.06273227f, 
    -0.04680479f, 0.03172810f, 0.06519130f, -0.15832476f, 0.15974280f, -0.10451010f, 0.02750061f, -0.08203797f, 
    0.15346618f, -0.05165560f, -0.05053865f, 0.16133784f, 0.29102802f, 0.33559498f, 0.12741749f, 0.09854963f, 
    0.02814167f, 0.22382370f, -0.28740937f, 0.44418225f, 0.05201146f, 0.44620347f, -0.34813544f, -0.05336653f, 
    0.13315885f, -0.17145936f, -0.38362074f, 0.28615120f, 0.11602845f, -0.11242443f, -0.14396504f, 0.02954949f, 
    0.14485943f, -0.09305625f, -0.11893650f, 0.12026783f, -0.19524562f, -0.19387592f, 0.27065638f, -0.03318205f, 
    0.03758926f, -0.16210435f, -0.06583253f, -0.14065741f, 0.01966725f, -0.19615461f, -0.10151402f, 0.01776210f, 
    -0.06678820f, 0.05081540f, -0.15185678f, 0.12110113f, -0.05776661f, -0.14516065f, 0.03416735f, -0.13116285f, 
    0.14104579f, -0.14325052f, -0.15850940f, -0.12611116f, 0.05798962f, -0.01832183f, 0.04290309f, 0.12389226f, 
    0.00064087f, -0.14214638f, -0.00342448f, -0.02195514f, 0.01673489f, -0.18386757f, 0.09423966f, 0.16037141f, 
    0.30895579f, -0.30579713f, -0.14603889f, 0.06139388f, -0.22052875f, -0.19000305f, -0.04530761f, -0.08195305f, 
    -0.04596931f, -0.01645740f, -0.08631173f, -0.21520582f, -0.00553138f, -0.01369909f, 0.14162219f, 0.16295767f, 
    -0.08517285f, 0.00338848f, 0.02907381f, 0.02368092f, 0.14169900f, 0.10862100f, -0.12359411f, 0.15132895f, 
    0.31829578f, 0.01874237f, 0.32011548f, -0.04179243f, 0.33213955f, -0.00799396f, 0.13269886f, 0.01655874f, 
    -0.06703354f, 0.07497249f, -0.00354577f, -0.03573273f, 0.06420775f, 0.10134573f, 0.40390381f, 0.00179569f, 
    0.28453383f, -0.02688353f, -0.19907567f, -0.16727974f, -0.16932532f, 0.10404222f, -0.16103455f, -0.39155310f, 
    0.02839633f, -0.14969030f, 0.06804898f, -0.05954328f, 0.05853448f, -0.05764348f, 0.13056853f, -0.01983502f, 
    0.20271723f, -0.14480567f, 0.12622711f, 0.17372204f, -0.33664107f, 0.12281444f, 0.21082669f, -0.01593366f, 
    -0.15910782f, 0.02966454f, 0.09912001f, 0.14379500f, -0.16891882f, -0.16236570f, -0.11062085f, 0.02361691f, 
    -0.10727421f, -0.15284623f, -0.00032839f, 0.03143975f, -0.06592616f, -0.05097375f, -0.11335109f, 0.08840045f, 
    -0.13092530f, 0.14000453f, -0.08428678f, -0.13963197f, 0.02735576f, 0.00153435f, 0.11124435f, -0.06543540f, 
    -0.09879139f, -0.12234549f, -0.01030591f, -0.15210484f, -0.15879351f, 0.12413624f, 0.03001286f, 0.15737385f, 
    0.49705952f, -0.28083533f, 0.04411584f, 0.05239686f, 0.32447997f, -0.18933493f, 0.17112128f, -0.15322655f, 
    -0.21769668f, -0.05971027f, -0.12316260f, 0.03239054f, 0.27319095f, 0.32473460f, 0.36893454f, -0.30989757f, 
    -0.12917159f, -0.02059137f, -0.05099922f, -0.05279477f, -0.14843373f, -0.08235903f, 0.01869575f, -0.07741653f, 
    -0.06725267f, 0.12938203f, 0.21827202f, 0.36765292f, 0.09088685f, 0.15750033f, 0.06637069f, -0.02940247f, 
    -0.01210551f, 0.04268263f, -0.04711158f, -0.11775802f, -0.07887912f, 0.00601787f, -0.17519878f, -0.01358519f, 
    0.06651924f, -0.12078688f, -0.12040931f, -0.19194080f, 0.13839284f, -0.00863913f, 0.08327091f, -0.02583518f, 
    -0.00657810f, -0.15681086f, -0.25542116f, -0.07038631f, -0.09327012f, 0.13687168f, 0.03239617f, 0.07082502f, 
    -0.10030776f, -0.16492702f, -0.03518641f, -0.17832248f, -0.13130639f, -0.01635803f, -0.16118264f, -0.04852510f, 
    -0.44319496f, 0.24134047f, -0.14358974f, -0.15686144f, 0.14330134f, 0.07431675f, -0.00741871f, -0.15946148f, 
    0.18536974f, -0.00420720f, 0.11024525f, 0.33479410f, 0.22641441f, 0.23272653f, -0.27787676f, -0.21136849f, 
    0.03601184f, 0.05559275f, 0.00767631f, -0.07417329f, -0.13569821f, 0.02037534f, -0.01666573f, 0.14925000f, 
    -0.09057064f, 0.01097553f, -0.35074672f, -0.20947734f, -0.05601284f, 0.00884601f, -0.15825266f, 0.01721856f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03006234f, -0.03355376f, -0.17544024f, 0.08208010f, 0.03314171f, 0.10262157f, 0.13926166f, 0.11916509f, 
    -0.07697397f, -0.05610177f, -0.02550307f, -0.09843710f, 0.24759898f, -0.06108375f, 0.18701659f, -0.05389786f, 
    0.24246866f, -0.11539593f, 0.13083857f, -0.06432155f, 0.06136654f, -0.00418943f, 0.01723390f, -0.00966500f, 
    0.08109491f, -0.26509878f, -0.15332267f, 0.03503306f, 0.03483329f, -0.07896561f, -0.09503574f, 0.05296723f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.05305556f, -0.09178850f, 0.19132957f, -0.02755285f, -0.06383720f, 0.04057071f, 0.38646498f, -0.49341813f, 
    -0.09904838f, -0.08035390f, 0.13682048f, -0.03550820f, -0.02902301f, -0.20934916f, 0.20412269f, -0.13883395f, 
    0.15570413f, -0.10329326f, -0.09323411f, 0.18459642f, -0.31585774f, -0.19695988f, 0.18793063f, -0.52127367f, 
    -0.23935224f, 0.06883684f, -0.22620200f, 0.10848346f, 0.02125256f, -0.63284588f, -0.09983096f, -0.13657156f, 
    -0.01493817f, -0.16046731f, 0.03126014f, -0.04830853f, 0.06110083f, 0.06823311f, 0.06048654f, -0.10001341f, 
    -0.10541520f, -0.05536456f, -0.17099249f, -0.14320987f, -0.06867737f, 0.19171122f, -0.09195047f, 0.33766183f, 
    -0.23124222f, -0.24693194f, 0.06621667f, 0.03384838f, 0.35143653f, -0.15487395f, 0.00052434f, -0.00723989f, 
    0.10001028f, -0.14617732f, -0.69276506f, 0.19501740f, 0.07782821f, -0.12993838f, -0.06953420f, 0.32847944f, 
    -0.10217878f, 0.24383172f, 0.16797797f, -0.17264585f, -0.16125701f, -0.09123255f, -0.48274586f, -0.13782194f, 
    0.09266537f, -0.04049681f, -0.18104303f, 0.03827774f, 0.08156198f, 0.15087457f, 0.25517726f, -0.36668909f, 
    0.12448528f, -0.13441791f, -0.16635491f, 0.13105580f, -0.53297192f, -0.06119011f, 0.00474547f, -0.58877218f, 
    0.36580914f, -0.18894547f, -0.17496887f, -0.12235523f, -0.12088592f, 0.13018544f, 0.00088715f, 0.02066317f, 
    -0.55970651f, -0.01120529f, 0.33656132f, 0.16721457f, 0.06655397f, -0.18388514f, 0.05095547f, 0.24732310f, 
    -0.01316908f, -0.08078133f, 0.00660954f, -0.11763284f, -0.43450320f, -0.23358329f, -0.15990648f, -0.43412372f, 
    0.09362764f, -0.20732623f, 0.25106797f, -0.42957845f, -0.35569414f, 0.11855011f, -0.06615857f, -0.28513166f, 
    -0.23480700f, -0.14585750f, 0.08631965f, -0.13624951f, -0.11591726f, -0.19518842f, -0.04850758f, -0.42789477f, 
    0.14932860f, -0.15607415f, 0.07539245f, -0.19275419f, 0.05962935f, -0.21675816f, 0.22441736f, -0.02033635f, 
    0.00365738f, -0.18085982f, -0.61117488f, -0.11593383f, -0.12092187f, -0.30105323f, 0.02682004f, -0.10264201f, 
    0.20700717f, -0.22095221f, -0.12578015f, -0.04646520f, -0.33316180f, 0.06384757f, -0.18855140f, 0.14330579f, 
    -0.37713537f, 0.02894304f, -0.03686566f, 0.01372198f, -0.15512107f, 0.27801904f, -0.00819565f, -0.05539539f, 
    0.04331099f, 0.04880112f, -0.21479689f, 0.01121299f, -0.13509184f, -0.10795090f, -0.40050599f, -0.37890100f, 
    0.12166715f, -0.09918780f, -0.16754439f, 0.04756281f, -0.20784675f, -0.37618509f, 0.36884758f, 0.11549298f, 
    0.10632562f, 0.22029921f, 0.18022057f, -0.38396183f, -0.27857715f, -0.09886667f, 0.20562115f, 0.21712205f, 
    -0.06034379f, -0.03090961f, -0.17470156f, 0.06250855f, 0.13517442f, -0.04146008f, 0.06846195f, -0.30670971f, 
    0.15624323f, 0.13542664f, -0.16225953f, -0.03546555f, 0.00357353f, 0.00473684f, -0.47930479f, 0.10960800f, 
    -0.16642213f, 0.16373904f, -0.15440249f, 0.01376646f, 0.03039976f, 0.06595588f, -0.51439750f, -0.16981132f, 
    0.04571555f, 0.29676306f, -0.49128330f, -0.09195092f, 0.21966086f, 0.07094239f, -0.39641550f, -0.41996858f, 
    0.07696240f, 0.09285010f, 0.02035003f, -0.55921823f, -0.04484572f, 0.08648932f, 0.02190761f, -0.21093559f, 
    -0.05276361f, -0.42209828f, 0.12811741f, -0.23088375f, -0.10141807f, -0.15043470f, -0.00028228f, -0.46726117f, 
    -0.08588987f, -0.04398088f, 0.44329137f, -0.18278968f, -0.01239129f, 0.20861149f, 0.17524713f, 0.02079671f, 
    -0.16841088f, 0.12343607f, 0.06201843f, 0.11713123f, -0.13926990f, 0.04611367f, -0.30513993f, 0.22727837f, 
    -0.08101954f, 0.04025228f, 0.18203481f, -0.37011075f, -0.01618284f, 0.07162510f, 0.12667988f, -0.14616349f, 
    -0.30737558f, -0.05811540f, 0.01129732f, 0.38230073f, 0.04060138f, -0.09749209f, -0.30363607f, 0.08462585f, 
    -0.08745205f, 0.16495331f, 0.21554917f, -0.12497015f, -0.09173017f, 0.11291992f, 0.17692512f, -0.40891951f, 
    -0.56189227f, 0.12223553f, 0.07250598f, -0.43718043f, -0.32924831f, 0.08363313f, -0.13290603f, 0.02257865f, 
    0.28021592f, 0.01319565f, -0.31164825f, -0.39015809f, -0.11056318f, -0.37518442f, -0.00923970f, 0.08191599f, 
    -0.32396749f, -0.08859379f, -0.63906515f, -0.55489749f, -0.05117680f, -0.03484062f, 0.08308747f, -0.02041385f, 
    0.09949604f, -0.05538176f, 0.12445204f, -0.13543308f, 0.19824328f, 0.05193925f, -0.19071396f, -0.04524435f, 
    0.14718147f, -0.24314094f, -0.70532662f, -0.14122212f, -0.01139876f, 0.09893013f, 0.25057295f, 0.07994835f, 
    0.16297998f, -0.13186838f, 0.12081581f, -0.21718368f, -0.08274684f, 0.24450782f, 0.01365886f, -0.14730380f, 
    -0.18997526f, 0.41637692f, -0.43675801f, 0.05880180f, 0.12781677f, 0.09025573f, 0.03458820f, 0.34641287f, 
    -0.01759055f, -0.01255381f, -0.65888250f, -0.06939674f, -0.35228899f, -0.01213914f, 0.16689010f, -0.02276927f, 
    -0.14680696f, -0.21348278f, 0.34202296f, -0.32571617f, 0.00139428f, -0.02746563f, -0.24199326f, -0.41098088f, 
    -0.25912213f, -0.18941419f, -0.43158087f, -0.21785744f, 0.16138835f, -0.02946850f, -0.17335428f, 0.35911322f, 
    -0.33279094f, 0.27490565f, 0.24179295f, -0.41851968f, 0.09728001f, 0.05416363f, -0.14390890f, 0.24907134f, 
    -0.02036374f, 0.03694089f, -0.37916690f, -0.11334908f, -0.49642897f, -0.14172696f, -0.58274835f, -0.07553819f, 
    -0.43251237f, -0.05651390f, -0.11659763f, -0.49057439f, -0.15623583f, 0.02747118f, 0.08015410f, 0.22843692f, 
    0.13486600f, 0.01904828f, 0.26132688f, -0.16882741f, 0.10201745f, 0.14288723f, -0.09209258f, -0.22172499f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00667035f, 0.09545379f, 0.13169090f, -0.19682497f, -0.10859142f, -0.10417553f, 0.14955169f, -0.05634891f, 
    0.09909899f, -0.01096692f, 0.00594308f, 0.04353740f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
