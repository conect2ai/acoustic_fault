#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24944139f, -0.14102410f, -0.18850489f, -0.31791893f, 0.01262733f, 0.27003965f, 0.13328102f, -0.25302169f, 
    -0.00124304f, -0.30568153f, 0.36600420f, -0.16125655f, -0.12456862f, 0.25810292f, -0.44586629f, -0.05611772f, 
    -0.18184204f, -0.23210594f, -0.16566826f, 0.17958160f, -0.04729495f, 0.04507200f, 0.31147188f, 0.32291141f, 
    0.32819045f, -0.09545879f, 0.33337495f, 0.26284888f, 0.73457921f, -0.11271400f, 0.18678373f, -0.27247569f, 
    -0.44659844f, -0.56470931f, -0.36927539f, 0.00778959f, -0.16578566f, -0.20752597f, -0.22403295f, -0.30177149f, 
    -0.38402703f, 0.19170313f, 0.08337741f, 0.12143065f, -0.07997883f, 0.02905999f, 0.04518167f, 0.05731258f, 
    -0.11926116f, -0.35037270f, 0.06190221f, -0.23601325f, -0.37314352f, -0.27533063f, 0.05436533f, -0.22950006f, 
    -0.05088346f, -0.19151849f, -0.17616394f, -0.02549356f, -0.09524160f, -0.40164816f, -0.01849096f, 0.35901922f, 
    -0.14531219f, -0.06645812f, 0.18392710f, -0.05786106f, -0.23476504f, -0.29609367f, 0.29057610f, 0.05640028f, 
    0.32584420f, 0.35900629f, 0.13562109f, 0.62936348f, 0.54869747f, 0.37495714f, 0.04931812f, -0.23631477f, 
    -0.03294101f, -0.02150694f, -0.00055906f, 0.05211232f, 0.20628811f, -0.07207048f, 0.09917649f, -0.01830184f, 
    0.06898737f, -0.03664467f, 0.18218356f, 0.12361874f, -0.18749852f, 0.05058439f, -0.48071650f, -0.11969695f, 
    0.28369433f, 0.06727076f, -0.12490039f, -0.19447276f, -0.90262556f, -0.26119933f, -0.16918829f, 0.22613093f, 
    0.54459244f, 0.11127740f, 0.27456191f, -0.08624640f, 0.45609790f, 0.16593704f, 0.33377346f, 0.01402186f, 
    -0.13157694f, 0.10881626f, 0.05821165f, -0.14967178f, -0.25397313f, 0.01068590f, 0.33205220f, -0.12778349f, 
    0.00130750f, 0.04143449f, 0.05629624f, -0.10966968f, -0.39208457f, -0.02367603f, 0.30476961f, 0.18095738f, 
    0.10671915f, 0.46160650f, 0.10518492f, 0.19668330f, -0.06974316f, 0.19708140f, 0.23844458f, 0.09681736f, 
    -0.42352325f, 0.21054487f, -0.36058614f, 0.00926541f, 0.07733890f, 0.07454468f, 0.00617001f, -0.15735704f, 
    0.02070147f, -0.16189086f, -0.11863817f, -0.22046444f, -0.23873907f, -0.28210670f, 0.56943613f, 0.85398954f, 
    -0.30482039f, -0.64091247f, 0.42376977f, 0.21381129f, -0.32482406f, 0.23037735f, -0.43948576f, -0.26085043f, 
    -0.32646364f, 0.22073601f, 0.10053421f, -0.07450707f, -0.11053011f, -0.04650235f, 0.01538534f, -0.15188091f, 
    0.05285667f, -0.07608064f, 0.05608994f, 0.02538240f, 0.04189458f, 0.17579968f, 0.02896160f, -0.58793581f, 
    0.91273952f, 0.06742572f, -0.89689714f, -0.43833566f, -0.06722011f, 0.36773148f, 0.54536229f, -0.00708687f, 
    -0.19696271f, -0.07443089f, 0.06515712f, 0.32958502f, -0.11934430f, -0.05695263f, -0.20755824f, 0.05770043f, 
    -0.05245734f, -0.19291282f, 0.25679922f, 0.02603218f, 0.08838030f, -0.29776660f, -0.16562413f, -0.22778229f, 
    0.88545483f, -0.18638945f, -0.10447188f, 0.17750178f, 0.06377903f, -0.26517099f, 0.30115628f, -0.03069007f, 
    -0.24205017f, -0.27262521f, 0.25614437f, 0.23116001f, -0.22076741f, -0.30973524f, 0.48382688f, 0.19813125f, 
    0.42393842f, -0.19050941f, -0.09427793f, -0.24144629f, 0.03159134f, 0.15199664f, -0.02284091f, 0.03334496f, 
    -0.18407507f, 0.71255708f, -0.52792144f, -0.60850525f, -0.59163827f, -0.48324832f, 0.44834009f, 0.30521291f, 
    0.43836695f, 0.05510354f, 0.38631505f, -0.14864658f, 0.37804779f, -0.23959506f, -0.24195428f, -0.09673423f, 
    -0.02119350f, 0.02510689f, 0.20349427f, -0.02317945f, -0.13839145f, 0.13596299f, 0.10104788f, -0.16435933f, 
    0.04297085f, 0.22333583f, 0.05206382f, -0.56443775f, 0.05649249f, 0.12983695f, 0.04138884f, 0.15614092f, 
    -0.23416524f, -0.63419610f, -0.46396074f, -0.31707621f, 0.29434320f, -0.15394863f, 0.01339892f, 0.44591612f, 
    -0.40730757f, 0.37614152f, 0.17572078f, -0.12676765f, -0.15407372f, -0.16421068f, -0.34796384f, -0.13445847f, 
    -0.22378767f, -0.14323808f, -0.36085960f, -0.40219435f, 0.14915842f, 0.14469615f, 0.40614691f, -0.03564838f, 
    0.11428723f, -0.24580036f, -0.12351669f, 0.06623836f, 0.29917023f, 0.01306783f, 0.18399304f, -0.04929357f, 
    -0.22070475f, -0.00609330f, -0.25607482f, -0.03773983f, 0.22782926f, -0.24031620f, -0.11318140f, 0.14867829f, 
    0.30432674f, 0.17318533f, 0.39507946f, 0.12639208f, -0.47046700f, -0.24828240f, -0.43916908f, -0.27403468f, 
    0.00342454f, 0.44014037f, 0.66678071f, -0.41505507f, -0.67424893f, -0.17554145f, -0.14740558f, -0.13405903f, 
    -0.24306984f, -0.39489931f, -0.28082085f, 0.21717738f, 0.12814176f, 0.12966248f, 0.06568950f, 0.07604360f, 
    0.06952023f, -0.07971551f, -0.05224473f, -0.24755506f, -0.05986375f, -1.04862332f, -0.37117478f, -0.18680292f, 
    -0.34613848f, 0.24968788f, 0.18751174f, 0.21189547f, 0.37993103f, -0.02795402f, 0.32632348f, 0.30372080f, 
    0.18344936f, 0.06122315f, -0.10589948f, 0.11072907f, 0.20879152f, -0.13599859f, -0.32736760f, -0.06791507f, 
    -0.02332629f, -0.00053986f, 0.12947458f, -0.09019943f, -0.00479193f, 0.18907462f, 0.53272063f, -0.52538419f, 
    0.03521744f, -0.08527274f, -0.50388414f, -0.36641335f, -0.49271369f, 0.44296584f, 0.39931893f, 0.16508515f, 
    0.05452145f, 0.07366647f, -0.05782358f, -0.18152681f, -0.04702815f, -0.04610906f, 0.05529279f, 0.30335185f, 
    -0.09634613f, -0.23975815f, -0.11486473f, -0.16062063f, -0.26551446f, -0.23369542f, -0.14580770f, -0.61383975f, 
    -0.33466205f, -0.23018305f, -0.34965324f, 0.10909469f, -0.50468010f, -0.49925572f, -0.19832897f, -0.14905217f, 
    0.09272997f, 0.06626426f, -0.20626538f, -0.18273026f, 0.18030754f, -0.01744404f, 0.00317960f, -0.48683593f, 
    0.11660214f, -0.28284848f, -0.52701193f, -0.20452583f, 0.11467969f, -0.12073575f, -0.19099838f, 0.12667166f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12316945f, 0.10464827f, 0.08080552f, 0.17983691f, 0.05911592f, -0.26140666f, 0.21099029f, 0.07074540f, 
    0.08863693f, -0.02087081f, 0.02486975f, 0.12767352f, -0.23261398f, 0.19691665f, -0.00754333f, -0.09672403f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02648971f, -0.05418412f, -0.00494225f, -0.06353186f, -0.01847319f, -0.05275382f, -0.06768849f, 0.02007638f, 
    0.02262846f, 0.02827353f, -0.00020317f, -0.02287724f, -0.02683915f, 0.06111978f, 0.01068471f, 0.05108482f, 
    -0.05594981f, 0.01708741f, 0.02064626f, -0.06780579f, -0.03955154f, 0.03402425f, -0.02611233f, -0.05519152f, 
    -0.00744375f, -0.04433131f, -0.01477369f, -0.04355920f, 0.00225756f, 0.02689406f, 0.03269671f, -0.07013693f, 
    0.03898629f, -0.05055556f, -0.00642518f, -0.04611592f, -0.07428615f, -0.07723710f, -0.04707411f, 0.05184309f, 
    0.01265791f, 0.00002975f, 0.01227793f, -0.02380273f, -0.06687395f, 0.02535349f, -0.01319020f, 0.02813181f, 
    -0.06731828f, -0.02534318f, 0.03063278f, 0.03567963f, -0.07336440f, -0.05758640f, -0.06158448f, -0.03744789f, 
    0.04949101f, -0.05023317f, -0.07158784f, -0.01950832f, 0.03376231f, -0.02100908f, -0.05407584f, 0.00699836f, 
    -0.01657621f, -0.03142723f, 0.04876863f, 0.06055143f, 0.00535802f, -0.00769134f, -0.02410944f, -0.05656939f, 
    0.00631739f, -0.01476776f, -0.02135455f, 0.04650904f, -0.05972261f, -0.00438503f, -0.02082180f, -0.06012814f, 
    0.01687275f, -0.02100234f, -0.01272812f, 0.02257058f, 0.01599518f, 0.02367655f, 0.01630599f, 0.03113098f, 
    0.06628251f, 0.01338916f, 0.00115706f, -0.05938946f, -0.06596051f, 0.02471879f, 0.03080061f, -0.00247663f, 
    -0.00137168f, 0.03400685f, -0.04598284f, 0.04711023f, -0.04320900f, 0.04060970f, 0.04629967f, -0.05893734f, 
    -0.04946985f, -0.07373577f, -0.02835461f, 0.02272496f, -0.04241350f, 0.01517135f, 0.03473863f, 0.06396341f, 
    0.01254893f, 0.02978399f, -0.05253939f, -0.05015555f, 0.02853060f, 0.06273866f, 0.00638851f, 0.00330317f, 
    0.07026362f, -0.05005580f, 0.00277828f, -0.00661465f, 0.06253693f, -0.01388640f, -0.03931431f, -0.04768298f, 
    -0.07052346f, -0.02920650f, -0.05377547f, -0.05207897f, -0.03220933f, 0.05145194f, -0.05523143f, -0.00152872f, 
    -0.02050567f, -0.02811136f, -0.02080667f, 0.06050149f, 0.04278919f, -0.00093022f, -0.01874705f, -0.05884687f, 
    -0.06610624f, -0.00352390f, -0.00737101f, 0.02840943f, 0.01012186f, -0.01899742f, -0.05418730f, 0.00642183f, 
    -0.04345989f, -0.02626533f, -0.01234700f, 0.00648965f, 0.03336873f, 0.02057601f, -0.03129268f, -0.02776144f, 
    -0.04240485f, -0.05888217f, 0.06046114f, -0.04464729f, -0.01850758f, 0.00695855f, -0.01133659f, 0.04396022f, 
    0.04143665f, -0.03014118f, -0.02791854f, -0.00895529f, 0.05098021f, -0.00573832f, -0.05846104f, -0.04823680f, 
    -0.00002514f, 0.03951589f, -0.06406564f, 0.00816410f, -0.06590027f, -0.05127361f, -0.02554271f, 0.07050795f, 
    0.02600182f, 0.01360816f, 0.00204924f, 0.00804449f, -0.02552893f, 0.05578065f, -0.02936736f, 0.05526888f, 
    -0.03906013f, -0.04558866f, -0.04993592f, 0.01078634f, -0.03208600f, 0.00832778f, 0.05752850f, -0.05998478f, 
    -0.03619178f, -0.04333461f, 0.01162347f, -0.07672186f, -0.01227676f, -0.07148232f, -0.06434224f, -0.07614009f, 
    -0.05675469f, -0.05961872f, -0.02656312f, -0.05240545f, -0.07848305f, 0.05220171f, -0.05491062f, 0.01586541f, 
    0.00367216f, -0.02058570f, 0.04297655f, -0.01862598f, 0.05752451f, 0.05015923f, 0.06088896f, -0.05729232f, 
    -0.00622754f, 0.03977260f, -0.03660175f, 0.00308379f, -0.05847380f, -0.01422318f, -0.00599576f, 0.01331700f, 
    0.04310073f, -0.06548883f, 0.00370781f, -0.04210518f, -0.00592081f, 0.03060704f, -0.00402812f, -0.06255089f, 
    -0.05754987f, 0.00340119f, 0.03142238f, 0.04962825f, -0.06701669f, -0.00541400f, 0.01516013f, -0.05703045f, 
    -0.04355238f, 0.02923894f, -0.07616867f, -0.03905361f, 0.04970871f, -0.00866391f, 0.01736870f, 0.01274852f, 
    -0.05603292f, 0.05896708f, -0.02003975f, 0.04543474f, -0.07041000f, 0.03553259f, -0.04368142f, -0.05891420f, 
    -0.05838281f, -0.06155063f, 0.04806017f, -0.05013641f, 0.01568739f, -0.02836679f, 0.03908795f, 0.04143253f, 
    0.04312344f, -0.03250327f, -0.08069345f, 0.02086421f, -0.01753740f, 0.02481279f, -0.02902844f, -0.05599368f, 
    0.06007064f, -0.01468060f, 0.05279582f, 0.00477494f, 0.02420134f, 0.02558321f, -0.02101557f, 0.04956302f, 
    0.05279087f, -0.03181154f, 0.04761545f, 0.02698239f, -0.00441575f, -0.07499889f, 0.00483121f, 0.01170683f, 
    0.00910261f, 0.05983981f, -0.01094252f, 0.04545314f, 0.02045234f, 0.02831177f, -0.08380680f, 0.00565937f, 
    0.00857702f, 0.00872063f, 0.04939895f, 0.02221529f, -0.01462388f, -0.02194696f, -0.03831176f, 0.02381117f, 
    -0.05173901f, 0.03200529f, 0.02496805f, -0.00851716f, -0.07318668f, 0.00122063f, -0.06445906f, -0.03988827f, 
    -0.07717621f, -0.07075004f, -0.07157426f, -0.03621130f, -0.00653723f, 0.05331308f, -0.04087655f, -0.07335026f, 
    0.04438318f, -0.06762772f, 0.03822995f, -0.02407330f, 0.02055253f, -0.02181396f, 0.01691448f, -0.03076180f, 
    -0.00187278f, -0.04233561f, 0.02009811f, -0.01973716f, -0.00136920f, 0.03988983f, -0.02186121f, -0.05840434f, 
    0.01502527f, -0.01396112f, -0.00552301f, -0.07071453f, -0.07452537f, -0.06766904f, -0.07031179f, -0.06578007f, 
    0.04964744f, -0.00672101f, 0.02813273f, 0.02683177f, -0.00405228f, -0.00881117f, 0.03092135f, -0.05635561f, 
    -0.04026463f, 0.00182206f, -0.04122574f, 0.05519608f, -0.04854825f, -0.02613165f, -0.06393034f, 0.02818988f, 
    -0.01109064f, 0.02809754f, -0.07491652f, -0.02085776f, -0.08321220f, -0.02574985f, 0.06868031f, -0.00057617f, 
    -0.05872367f, 0.05868761f, -0.07228574f, -0.01839202f, -0.05169483f, 0.07072464f, 0.05922182f, -0.00224616f, 
    -0.02693429f, -0.03868049f, 0.02881869f, 0.00900036f, 0.01587804f, 0.00705990f, 0.03783244f, 0.04622572f, 
    -0.03035917f, -0.05190434f, -0.06694880f, -0.06316722f, -0.04675252f, -0.00899398f, -0.00220852f, -0.06814812f, 
    -0.07679318f, 0.02750288f, 0.05629180f, 0.01243064f, -0.03809509f, 0.03502120f, 0.01454070f, 0.04831215f, 
    -0.03788607f, -0.04277866f, -0.05752695f, -0.06701541f, 0.05577781f, 0.04646299f, 0.01528248f, 0.00984410f, 
    0.03546522f, -0.03158163f, -0.07749823f, 0.02429572f, -0.02006961f, -0.06012027f, 0.03369601f, 0.00788872f, 
    0.02734205f, 0.05801369f, -0.00905122f, -0.04502257f, -0.01745950f, 0.04393357f, 0.02822371f, -0.04688010f, 
    -0.06897491f, -0.06433728f, -0.05439402f, -0.01794746f, 0.02757177f, 0.05253490f, -0.07350325f, 0.00961592f, 
    -0.01429688f, 0.03769642f, 0.03837382f, 0.02376248f, 0.03460639f, 0.02063427f, -0.07335509f, -0.05850345f, 
    -0.04222202f, -0.06560656f, -0.00983732f, -0.05292567f, -0.00797399f, -0.06377383f, -0.03317006f, -0.06135532f, 
    -0.00813531f, 0.03151342f, 0.02478657f, 0.01251255f, 0.04920822f, 0.01356556f, -0.04746653f, -0.05055591f, 
    0.02976599f, 0.04201514f, -0.01135831f, -0.01411348f, -0.03961964f, 0.04291049f, 0.04940248f, 0.02670787f, 
    -0.01307510f, 0.02938062f, -0.04295214f, 0.04919863f, 0.01364176f, 0.01300764f, -0.03928575f, 0.05274724f, 
    -0.01126659f, 0.04491052f, -0.06755491f, -0.00208049f, 0.00968106f, -0.07058844f, 0.03006252f, 0.06107907f, 
    -0.06069986f, -0.07946274f, 0.00638518f, 0.00388061f, -0.01216432f, -0.06660500f, 0.05727435f, -0.00552471f, 
    0.01511021f, 0.01865444f, -0.02573200f, 0.05114723f, 0.00022622f, 0.00241249f, -0.00084352f, 0.00894910f, 
    -0.02547235f, -0.04963822f, -0.01595313f, 0.04559419f, -0.07045554f, 0.00963052f, -0.00410630f, -0.01831435f, 
    -0.04304231f, -0.00850328f, -0.07048740f, -0.01637681f, -0.01863333f, 0.05048018f, -0.07808317f, -0.00521169f, 
    -0.06445884f, 0.03283490f, -0.03475274f, 0.05117305f, 0.05639660f, -0.07410445f, -0.06396991f, -0.07030655f, 
    -0.01222437f, -0.08119058f, 0.02477903f, -0.04373421f, -0.04803095f, -0.05099505f, 0.00141799f, 0.02947334f, 
    0.01551035f, -0.03009336f, -0.00919101f, 0.00276360f, -0.00835274f, 0.00400539f, -0.01791481f, -0.04450383f, 
    -0.01682619f, -0.01760490f, -0.03295746f, 0.00659888f, 0.05769124f, 0.04359355f, -0.05268902f, 0.05243541f, 
    -0.02818980f, -0.05959883f, -0.00029497f, 0.01993780f, -0.04800861f, -0.05181776f, 0.02673503f, -0.07237147f, 
    -0.08055291f, -0.07019156f, 0.04484824f, 0.00879780f, -0.07602141f, -0.07208803f, 0.02071827f, 0.00354951f, 
    -0.05653127f, -0.01935742f, -0.00051832f, 0.04209109f, -0.07336367f, -0.05887236f, 0.04244873f, -0.02732148f, 
    -0.03055055f, 0.12212673f, -0.18511821f, -0.13723278f, -0.03804809f, 0.20173144f, -0.10155974f, -0.01054246f, 
    -0.08701826f, -0.23623979f, 0.00063024f, -0.12657337f, 0.14323612f, 0.27170342f, 0.26029387f, 0.34701619f, 
    0.00165394f, -0.01286907f, 0.00761720f, 0.05075634f, -0.03393431f, -0.02046335f, -0.09893183f, 0.05333675f, 
    0.14414611f, 0.00221691f, 0.04645509f, 0.04167598f, -0.07110832f, 0.09070854f, 0.02706362f, -0.12560233f, 
    -0.14323863f, -0.07861950f, -0.00662132f, -0.00600663f, -0.29222658f, -0.08540212f, -0.20247148f, 0.09420680f, 
    0.10087112f, -0.01248831f, -0.20447837f, -0.23710330f, -0.05097520f, -0.21160555f, -0.01872526f, 0.10871152f, 
    0.33119088f, 0.24644120f, 0.04887214f, 0.23476045f, -0.02176496f, -0.18734671f, 0.02909274f, -0.10074910f, 
    -0.01757069f, 0.11212290f, 0.11343288f, 0.06501180f, -0.09274638f, -0.23129588f, -0.08599155f, 0.09864905f, 
    0.05212855f, -0.05245743f, 0.02649384f, -0.13998187f, 0.11293947f, 0.24509105f, 0.13244304f, 0.27259183f, 
    -0.24030910f, 0.01744116f, -0.25932053f, 0.07336053f, 0.13822396f, -0.05098937f, -0.12028352f, -0.15075490f, 
    -0.00097947f, -0.26362839f, -0.22471674f, -0.38388592f, 0.30696452f, -0.01797325f, -0.04248505f, 0.27607098f, 
    0.06328080f, 0.03225249f, -0.11688116f, -0.09861302f, 0.01274145f, 0.01769482f, 0.23337178f, 0.01682348f, 
    -0.32453012f, -0.22978193f, 0.07797936f, 0.12460218f, 0.01954320f, 0.09539047f, 0.02785031f, 0.02861282f, 
    0.07291704f, 0.01122037f, -0.21805364f, 0.12073795f, -0.39162922f, 0.23394729f, -0.05290001f, 0.36916170f, 
    0.16030435f, 0.16359879f, -0.20398094f, -0.10115196f, 0.15824892f, 0.02206249f, -0.03689571f, -0.07771937f, 
    0.25756285f, 0.03407146f, 0.07284392f, 0.06544085f, -0.03758223f, -0.05013762f, -0.13115241f, 0.06361189f, 
    0.13468319f, 0.14691275f, 0.12763384f, 0.17476597f, -0.03543788f, -0.00965957f, 0.05706286f, -0.16939169f, 
    0.12347887f, -0.21933404f, 0.03688648f, -0.11557803f, -0.36040428f, -0.22257985f, -0.16322635f, -0.25672376f, 
    0.12919848f, 0.04127747f, -0.22259255f, -0.01964157f, 0.09375593f, 0.10572230f, 0.08364236f, 0.16116630f, 
    -0.01165348f, 0.10715888f, 0.03966209f, 0.12581342f, 0.23519041f, 0.11347834f, 0.05976597f, 0.15223649f, 
    -0.02476808f, 0.00518645f, 0.01094385f, 0.08893901f, 0.03421814f, -0.12943870f, -0.10389522f, -0.05915247f, 
    -0.15324673f, -0.03285221f, 0.01395245f, 0.03296377f, 0.08322725f, 0.16585210f, 0.02430212f, -0.08535082f, 
    -0.05247203f, 0.20227684f, 0.12241093f, 0.07181180f, 0.14731224f, 0.09849190f, 0.11995587f, -0.01434953f, 
    0.09208988f, 0.12719569f, 0.00905378f, -0.03861736f, -0.07025514f, -0.03550809f, -0.01241425f, -0.08919376f, 
    0.10691156f, 0.09509773f, 0.11239696f, -0.02759577f, -0.10529949f, -0.03283885f, 0.00267615f, 0.04666715f, 
    -0.00226560f, -0.11734942f, -0.02980254f, -0.06315088f, 0.31759194f, -0.19455004f, 0.11010275f, 0.24581175f, 
    -0.05884372f, 0.20209219f, 0.01770909f, 0.07774316f, 0.02917910f, 0.07609019f, -0.05108359f, -0.03950205f, 
    0.06393377f, 0.18415770f, 0.12637633f, 0.22900054f, -0.09508750f, -0.10829738f, -0.06274509f, 0.01465830f, 
    0.00288434f, -0.11900922f, 0.15184510f, -0.17173781f, 0.06294876f, -0.08019727f, -0.18682520f, 0.08022598f, 
    -0.15250915f, 0.10338217f, -0.06441334f, -0.13086689f, 0.05076394f, 0.01633635f, 0.17858998f, 0.06857536f, 
    -0.09958754f, -0.00952415f, 0.06473050f, 0.47185239f, 0.21581618f, -0.06039323f, -0.22583115f, -0.11996994f, 
    0.10332060f, -0.01933409f, -0.07503734f, 0.12945381f, -0.21253975f, -0.06478080f, 0.04144531f, -0.07950933f, 
    -0.00138471f, 0.11699238f, 0.12544173f, -0.00984859f, 0.17710204f, 0.19271414f, -0.07734025f, 0.08986376f, 
    0.30466816f, 0.10481006f, 0.00865316f, -0.12725595f, -0.08125749f, -0.05870320f, -0.01478084f, -0.08149059f, 
    -0.03673813f, -0.05378017f, -0.12831081f, -0.19070993f, -0.26066571f, 0.30755502f, -0.05657447f, -0.37148175f, 
    0.04054165f, -0.09175638f, -0.04147251f, -0.12284947f, -0.01625120f, -0.03500510f, -0.06261251f, 0.17249990f, 
    0.07904548f, 0.35297313f, -0.05095003f, -0.06100775f, 0.07527752f, 0.10574781f, 0.00854124f, 0.18816154f, 
    0.02187586f, 0.04511337f, 0.05009255f, 0.10572982f, 0.13974395f, -0.05439549f, 0.27599809f, -0.27791858f, 
    0.07089709f, 0.02293944f, 0.10241640f, 0.03705193f, -0.25385281f, 0.06598898f, 0.12724589f, -0.07139229f, 
    -0.09988068f, 0.14074504f, 0.15045844f, 0.33662781f, -0.02973406f, -0.00382347f, -0.04333182f, 0.21842502f, 
    0.02335545f, 0.04529645f, 0.07768276f, 0.06547692f, -0.01838446f, 0.00539091f, -0.02760813f, -0.10548096f, 
    0.10364412f, 0.21206811f, -0.00548801f, -0.17411973f, -0.01672008f, 0.05924480f, -0.22149234f, -0.15170836f, 
    -0.24987036f, -0.02360180f, 0.27424836f, 0.14111091f, -0.23865080f, -0.00015434f, -0.10357792f, 0.26251686f, 
    0.11773248f, 0.02673009f, 0.12842840f, -0.02992683f, 0.06267175f, 0.08086778f, -0.06330834f, 0.19450076f, 
    0.16521928f, 0.05288261f, -0.21957293f, -0.12641597f, -0.03727361f, -0.00298028f, 0.03558465f, -0.01574831f, 
    -0.10987756f, -0.19738373f, 0.20679225f, -0.02369051f, 0.02218411f, -0.16168305f, -0.11825007f, -0.16217747f, 
    0.04879388f, -0.01878794f, 0.07356522f, 0.05745783f, -0.04193455f, -0.02800284f, 0.23950714f, 0.39686185f, 
    -0.00282945f, -0.11903599f, 0.06644154f, 0.05005623f, 0.06177859f, 0.02837287f, 0.08528589f, 0.04227225f, 
    0.18432964f, 0.13827355f, 0.07248928f, 0.01291160f, 0.03600074f, -0.15020148f, 0.07625294f, 0.14453892f, 
    -0.07827609f, -0.09318804f, -0.08633964f, -0.04871685f, 0.08461837f, -0.09476405f, -0.15903568f, 0.02949116f, 
    0.04615237f, 0.01891886f, 0.06242829f, -0.07038749f, 0.05794153f, 0.07280149f, 0.00091815f, 0.05683469f, 
    0.04369792f, 0.15006894f, 0.13078102f, 0.05945122f, -0.03807496f, 0.02731849f, 0.00910822f, 0.06278819f, 
    -0.04646576f, -0.03318558f, 0.12706469f, -0.25904068f, 0.11376330f, -0.04678380f, 0.00003211f, -0.08068274f, 
    0.00706520f, 0.02824232f, 0.00770506f, -0.01158546f, -0.32433987f, -0.00103128f, -0.02898244f, -0.03938564f, 
    -0.11668596f, 0.13578142f, 0.10225793f, 0.36295363f, 0.07326613f, 0.09380389f, 0.04603784f, 0.01272458f, 
    0.02537431f, 0.14484128f, -0.10508619f, 0.14112517f, -0.11365905f, 0.00554487f, 0.03720577f, -0.01806409f, 
    -0.06098832f, 0.04974353f, 0.05814011f, 0.02595308f, -0.11536896f, 0.07557781f, -0.03939878f, 0.08384408f, 
    0.16921869f, -0.25429079f, -0.22634882f, 0.05820010f, -0.12883994f, 0.04193797f, -0.11027522f, 0.24954951f, 
    -0.05002661f, 0.00449497f, 0.03276494f, -0.02734810f, 0.06516766f, -0.20126024f, 0.38014197f, -0.46117434f, 
    0.07023638f, -0.02185897f, 0.06935856f, 0.03510340f, 0.13822958f, 0.03657880f, 0.00083033f, 0.01237987f, 
    0.10647061f, 0.34568354f, -0.30299774f, 0.11684379f, -0.23105584f, -0.05589349f, -0.01876922f, 0.15352210f, 
    -0.07145672f, -0.04429666f, -0.05023846f, 0.02392712f, 0.25215355f, 0.41697726f, 0.06135871f, -0.12557541f, 
    -0.17074819f, -0.12275135f, -0.04999699f, 0.19522966f, -0.10099138f, -0.00847874f, -0.17336892f, -0.19070631f, 
    0.17834972f, 0.16070056f, 0.00831003f, 0.11314995f, 0.12691525f, -0.07889997f, 0.04796234f, 0.19978289f, 
    0.07786225f, 0.15939422f, 0.09548794f, 0.17065318f, -0.34246472f, 0.14061302f, -0.16732860f, -0.08320709f, 
    0.09603883f, -0.08664922f, 0.20273496f, 0.04561847f, -0.05738588f, -0.07126735f, -0.06130344f, -0.15492903f, 
    0.12144413f, -0.21191028f, 0.01382996f, 0.34643048f, -0.03513844f, 0.09344022f, -0.13276471f, 0.01752173f, 
    0.18038543f, 0.10900142f, 0.08861750f, -0.03434649f, 0.12788880f, 0.04581161f, 0.13046815f, 0.18489234f, 
    -0.13387099f, -0.03391410f, 0.06157082f, -0.06171565f, -0.10216583f, -0.04082600f, 0.13003168f, -0.10760418f, 
    -0.15453920f, 0.31555146f, 0.28538325f, -0.09216764f, 0.10501129f, 0.03844774f, -0.10936742f, 0.09875557f, 
    0.02165263f, 0.06516778f, 0.12222683f, 0.30425814f, -0.02437800f, 0.08704069f, -0.05295829f, 0.20550545f, 
    -0.05395149f, 0.06035974f, -0.09724259f, -0.13738085f, 0.00729647f, 0.17241812f, 0.20015107f, -0.03736662f, 
    0.23410839f, 0.28492537f, 0.10221095f, 0.21072902f, -0.05197554f, 0.06068028f, 0.18714051f, 0.13896479f, 
    0.06221468f, 0.12782119f, 0.14146772f, 0.14454752f, -0.47525099f, -0.00412845f, -0.21817096f, -0.23310995f, 
    0.05899239f, -0.07410498f, -0.08029893f, -0.01170239f, -0.00367707f, -0.10246462f, -0.03111952f, -0.00214191f, 
    0.02258172f, 0.12844379f, 0.26112428f, 0.15988767f, -0.06379171f, 0.09475464f, 0.21731861f, 0.06739894f, 
    0.02858165f, 0.10003837f, 0.15460944f, 0.05724030f, -0.39856011f, -0.17712237f, -0.14668292f, -0.28032956f, 
    -0.21090579f, -0.01889211f, -0.06257989f, -0.11013956f, -0.08774956f, 0.11305783f, -0.03659289f, 0.03657282f, 
    0.08734442f, 0.05821859f, -0.20803498f, -0.26571521f, 0.06141749f, -0.01114817f, -0.03661248f, 0.05650986f, 
    -0.05039283f, 0.02846024f, -0.17437445f, -0.05177723f, -0.09256774f, -0.05847447f, -0.04362543f, -0.24643318f, 
    -0.06442764f, -0.07214091f, -0.17578113f, -0.10381281f, -0.03997491f, 0.02636968f, 0.00650106f, -0.05562636f, 
    -0.22703192f, -0.28579578f, 0.03329238f, 0.19118901f, -0.07247055f, 0.01019536f, 0.07606536f, 0.01658324f, 
    0.03185854f, 0.04633635f, 0.04677359f, 0.05832597f, 0.53707492f, -0.06105347f, 0.24764177f, 0.12896833f, 
    0.04470650f, -0.10234627f, 0.02873834f, -0.07936173f, -0.10964067f, -0.01535703f, -0.03238636f, -0.17876036f, 
    -0.19851112f, -0.11697286f, 0.07859199f, 0.02010417f, -0.14985946f, -0.00908936f, -0.00301292f, 0.01451414f, 
    -0.24199124f, 0.04449239f, -0.07726882f, 0.01420956f, 0.39173570f, 0.29981953f, 0.31467199f, 0.05241413f, 
    -0.10783496f, 0.05333311f, -0.00157291f, 0.07580221f, -0.03538683f, 0.10004649f, 0.00176828f, 0.14209484f, 
    -0.05154829f, 0.13391808f, -0.14944980f, 0.14791727f, 0.03845308f, -0.08948925f, 0.04298611f, 0.11082248f, 
    -0.04823137f, -0.03734429f, -0.04189910f, -0.01515430f, -0.12620990f, -0.13103060f, -0.05971026f, -0.33867443f, 
    0.13971823f, -0.09678828f, -0.04106608f, -0.02494827f, 0.14696388f, 0.11669828f, 0.08461050f, 0.12337331f, 
    0.12679915f, -0.00375961f, 0.18722618f, 0.08040363f, 0.07674178f, 0.06295100f, 0.04139689f, -0.01028678f, 
    0.04749672f, -0.04247605f, -0.02496139f, 0.00480235f, 0.31188282f, -0.10583343f, -0.02632003f, 0.03046685f, 
    -0.00490859f, 0.10103847f, 0.04576753f, 0.00338035f, -0.01552241f, 0.10539023f, 0.12320708f, 0.13768333f, 
    -0.33651996f, 0.17701276f, 0.10384563f, -0.13828570f, -0.09556507f, 0.01233503f, -0.17776711f, 0.08121157f, 
    0.07560726f, -0.12066945f, -0.11963382f, 0.08686282f, -0.02286272f, 0.06927912f, -0.15889387f, 0.16015631f, 
    -0.00822375f, 0.18280174f, -0.03849783f, 0.14178987f, -0.10738275f, -0.02349917f, -0.01270417f, -0.13380025f, 
    -0.08139380f, -0.14484492f, -0.02834552f, -0.07693062f, 0.13021749f, 0.24510993f, 0.20919816f, 0.17240635f, 
    0.17022102f, -0.00516236f, -0.00199678f, 0.08673645f, -0.19911234f, 0.28020206f, -0.05747041f, -0.41522154f, 
    -0.02059716f, -0.17512690f, -0.01856382f, 0.21589448f, -0.05547690f, -0.02341879f, 0.06903212f, 0.03367686f, 
    -0.00484307f, -0.14672169f, 0.19812863f, -0.18138094f, 0.17001371f, 0.14670265f, 0.10114256f, -0.09806595f, 
    0.00025059f, -0.03173419f, 0.05801178f, 0.02816220f, -0.24813138f, 0.01593663f, 0.22605287f, -0.03165085f, 
    -0.02438216f, -0.09187012f, -0.03397578f, -0.10061131f, 0.12791055f, -0.05983852f, 0.01764803f, 0.01453467f, 
    0.08185722f, -0.10509764f, 0.10700859f, 0.25409731f, 0.01862449f, -0.16617885f, -0.03981422f, 0.13941731f, 
    0.01678033f, 0.04270032f, 0.12230610f, 0.04167102f, -0.01306163f, -0.10965317f, -0.08995191f, -0.06555483f, 
    -0.11190744f, -0.11016694f, -0.13278134f, -0.07210609f, -0.08443258f, -0.13886034f, 0.08956449f, -0.05058916f, 
    0.10720324f, -0.21498953f, 0.28972259f, -0.07999096f, -0.05594145f, -0.13860217f, -0.07978919f, 0.04858704f, 
    -0.02121980f, -0.01481520f, 0.20604390f, 0.01214042f, -0.10768844f, 0.36661878f, -0.03859220f, 0.12668468f, 
    0.00860081f, 0.02989560f, -0.08503564f, 0.11800241f, -0.01421213f, 0.24743196f, 0.19897300f, -0.03361996f, 
    -0.26931790f, -0.17130414f, -0.01668616f, 0.03616022f, 0.11172275f, -0.07846506f, -0.22342220f, -0.12921742f, 
    0.14138074f, -0.05501996f, -0.12154492f, 0.09101620f, 0.12439554f, 0.09240744f, 0.44751254f, -0.08580017f, 
    -0.18880081f, -0.10868821f, -0.22464962f, -0.07505024f, 0.11267432f, -0.11295834f, 0.06926382f, 0.20891719f, 
    -0.11391838f, -0.24154083f, -0.07551308f, -0.04741174f, 0.01638498f, 0.06593403f, 0.18904778f, 0.07271563f, 
    0.13201322f, -0.05799869f, 0.05561882f, -0.01854602f, -0.08880907f, -0.06075320f, -0.05517394f, -0.02827093f, 
    -0.00616027f, -0.12832470f, 0.02749139f, 0.09528707f, 0.06770729f, 0.05548261f, 0.12738211f, 0.11205798f, 
    -0.05657039f, 0.05730285f, 0.10948126f, -0.35001856f, -0.02759525f, -0.03932868f, -0.02582870f, 0.01208423f, 
    0.14526665f, -0.04936368f, -0.07960527f, -0.00424665f, -0.15953767f, 0.02298372f, 0.07209155f, 0.40002516f, 
    -0.11926456f, 0.02281226f, -0.14679933f, 0.13338044f, 0.06286386f, 0.05109802f, -0.11400387f, 0.14233874f, 
    0.00484070f, 0.22679995f, 0.00880375f, 0.13842249f, -0.01515569f, 0.00551746f, 0.06875166f, -0.17305148f, 
    0.17789546f, 0.18554445f, -0.02090443f, 0.04811185f, -0.15539926f, -0.00933794f, -0.10087743f, -0.03193253f, 
    0.16252884f, -0.01231351f, 0.00192948f, 0.21576338f, 0.05548776f, -0.05001086f, 0.07536840f, 0.06972730f, 
    0.01813668f, -0.00100067f, 0.01605974f, -0.06432503f, -0.03916408f, -0.02399581f, 0.01396196f, 0.03041591f, 
    -0.09467295f, -0.02256428f, 0.01270951f, -0.00927689f, 0.05020456f, 0.04155004f, -0.07036255f, -0.00770148f, 
    -0.04384460f, -0.00825842f, 0.01353608f, -0.01918863f, -0.02297004f, 0.03930608f, 0.02731287f, -0.01387002f, 
    0.06189036f, -0.05422433f, -0.04370734f, -0.03350512f, -0.03297205f, -0.05051211f, -0.03530568f, 0.00723427f, 
    -0.01966490f, -0.05297295f, -0.02224963f, 0.04085455f, 0.01673878f, -0.01040582f, 0.02076709f, -0.04470439f, 
    -0.02434881f, -0.01599236f, -0.07315061f, -0.10114533f, -0.08135804f, -0.02064293f, 0.01466644f, -0.00298358f, 
    -0.01028220f, -0.07915148f, -0.04196199f, 0.00062504f, -0.09848241f, -0.01411162f, -0.05175359f, -0.09026008f, 
    -0.05803448f, -0.06322977f, 0.02522468f, 0.03300956f, -0.08310113f, -0.09505412f, 0.02025258f, -0.00398972f, 
    0.00003111f, -0.06267931f, 0.02964797f, -0.02139389f, -0.00087038f, -0.06699191f, -0.03197822f, 0.01528024f, 
    0.03515390f, -0.04175990f, -0.07690053f, -0.01592027f, -0.07915732f, -0.02162032f, 0.03706782f, 0.02079609f, 
    -0.01973400f, -0.09092639f, -0.04724443f, -0.09180258f, -0.01873081f, -0.07531768f, 0.00944392f, -0.02485583f, 
    0.02251592f, -0.06679188f, 0.02226089f, -0.08703543f, -0.02229793f, -0.04377643f, -0.10396915f, 0.03620264f, 
    0.00714445f, -0.04532021f, -0.05454819f, -0.03607226f, -0.02121352f, -0.03862640f, -0.03303394f, -0.08576571f, 
    -0.05573182f, 0.01205695f, -0.04243110f, -0.01160863f, 0.02352313f, -0.02151815f, -0.07385843f, 0.01181871f, 
    -0.07441388f, 0.01109040f, -0.07474411f, -0.03678274f, 0.02451560f, -0.03201332f, 0.05367643f, 0.03178083f, 
    0.03129854f, 0.04208349f, -0.05484745f, -0.07316547f, -0.04211404f, 0.00188680f, -0.02217497f, -0.03178016f, 
    -0.01066132f, -0.05441494f, -0.02266493f, -0.03047570f, -0.00288172f, 0.02269358f, 0.00223781f, -0.07604218f, 
    -0.06317620f, -0.05650035f, -0.04102538f, -0.06580755f, -0.07456152f, -0.09719651f, -0.06234977f, -0.07127014f, 
    0.02774015f, -0.07689963f, 0.00183510f, -0.05132604f, -0.02709221f, -0.05317149f, -0.05981040f, -0.04479972f, 
    -0.01344902f, -0.00343870f, -0.04503294f, -0.04203915f, -0.04017377f, -0.04519191f, 0.06048672f, -0.01088044f, 
    -0.06888624f, -0.06629567f, -0.05529693f, 0.01326502f, -0.09355295f, -0.00325070f, 0.04108824f, 0.01781755f, 
    -0.05093721f, 0.02897825f, -0.03557014f, 0.02780752f, 0.04156855f, -0.09902655f, -0.05854519f, -0.05369501f, 
    -0.01861828f, -0.02507721f, 0.00729255f, -0.06889775f, 0.05512900f, -0.05819175f, -0.06886806f, -0.06365637f, 
    -0.02745151f, -0.06660686f, -0.00456023f, 0.05635892f, 0.04337363f, 0.01085232f, 0.02544125f, 0.02417400f, 
    -0.07561123f, -0.06241317f, 0.03808710f, 0.01093973f, 0.01418596f, -0.03434780f, -0.02492249f, 0.02124304f, 
    -0.03327126f, -0.04894947f, -0.05570210f, -0.06864704f, -0.06480947f, -0.07488856f, 0.06048658f, 0.03840232f, 
    -0.04238477f, -0.04568149f, -0.06261607f, 0.01173151f, -0.01985701f, -0.06521568f, 0.02734997f, 0.04238001f, 
    0.01336340f, 0.00532759f, 0.06189882f, -0.01351965f, 0.01056477f, 0.06199767f, 0.03201956f, 0.04271780f, 
    -0.07085477f, 0.00903221f, -0.03015370f, 0.02383332f, -0.03160683f, 0.05049092f, -0.06428459f, 0.01217425f, 
    -0.04235103f, 0.01242803f, 0.00122514f, 0.02953363f, 0.00188800f, 0.03642072f, 0.01127355f, -0.01317991f, 
    -0.05327377f, -0.03678157f, -0.00392136f, -0.06660702f, -0.08099076f, 0.04104237f, 0.02299307f, -0.03774173f, 
    0.06579570f, 0.01374746f, 0.01546128f, 0.00296672f, 0.05467587f, -0.01954910f, -0.00786547f, 0.00446476f, 
    -0.00314240f, 0.04604769f, -0.04130232f, 0.06328854f, -0.05480410f, -0.03903422f, -0.01741496f, -0.06009196f, 
    0.03688823f, -0.01181061f, -0.05237437f, -0.07853805f, 0.02073746f, 0.03404251f, -0.00728306f, -0.01928345f, 
    -0.03160991f, 0.01510227f, -0.01715917f, 0.01440457f, -0.02810819f, -0.06022632f, -0.03016498f, -0.00490459f, 
    0.04689103f, 0.04018033f, -0.06945946f, -0.02095486f, -0.02195714f, 0.00291417f, -0.01176328f, 0.05306399f, 
    -0.01124995f, -0.02806109f, -0.03786470f, -0.02952495f, -0.03735432f, 0.00608324f, -0.04592589f, -0.05818624f, 
    0.01706536f, -0.06781458f, 0.00173229f, -0.00514880f, -0.03476389f, 0.00279986f, 0.00817831f, 0.00065997f, 
    -0.06824153f, -0.03331858f, 0.02166551f, -0.00106899f, -0.01479753f, -0.01899416f, 0.00290351f, 0.06590108f, 
    0.04727660f, 0.01940966f, -0.05147157f, 0.06063002f, -0.07392088f, 0.01882595f, 0.05514328f, 0.04471733f, 
    -0.03339886f, -0.05314797f, 0.06055716f, -0.00117274f, 0.02484918f, -0.00541256f, -0.03778959f, -0.02709473f, 
    -0.00999186f, -0.03007592f, 0.05736330f, 0.00301251f, -0.01775168f, 0.02047324f, 0.00404021f, 0.05057273f, 
    -0.05120360f, -0.03939607f, -0.07574933f, 0.01601565f, -0.05309584f, -0.00617779f, -0.02141395f, -0.05644179f, 
    0.01126284f, -0.00042170f, 0.01571637f, -0.00738699f, -0.07461819f, -0.06819988f, -0.06670272f, 0.05185038f, 
    0.05596570f, 0.01668130f, -0.04425327f, -0.04125363f, 0.02831673f, -0.05735695f, -0.07048079f, -0.00484002f, 
    -0.07044258f, 0.02850969f, -0.02468681f, -0.01951076f, -0.02814056f, 0.03825666f, 0.00224856f, 0.03114381f, 
    -0.03425433f, -0.01128414f, 0.06045063f, -0.07201982f, -0.05507050f, 0.01016995f, -0.06808466f, 0.06483135f, 
    -0.04144112f, 0.04835603f, 0.04421052f, -0.07410953f, 0.04036897f, -0.02391933f, 0.05218564f, -0.06936780f, 
    -0.07979870f, -0.13444726f, 0.04782671f, 0.08927933f, -0.04336861f, 0.06094393f, 0.06232721f, 0.01111890f, 
    -0.02224707f, -0.09444591f, -0.06921031f, -0.00616381f, 0.16147968f, -0.08826099f, 0.15855156f, 0.30464041f, 
    0.00010545f, 0.09412279f, 0.22651957f, 0.09311521f, 0.00091526f, -0.03474446f, -0.10186067f, 0.00365667f, 
    0.00039739f, -0.05931176f, -0.02666130f, 0.09737167f, -0.06643938f, -0.05880031f, 0.02103371f, 0.11824662f, 
    -0.11384519f, -0.07203138f, 0.00232399f, -0.09398472f, 0.16865318f, 0.20370303f, 0.11087855f, 0.26175952f, 
    -0.05491173f, 0.09287054f, 0.03734797f, -0.11331046f, 0.20089434f, -0.02962724f, 0.18534601f, 0.08661560f, 
    -0.13595578f, 0.00502911f, 0.17862613f, 0.38596874f, 0.00605104f, -0.10015748f, -0.09866527f, -0.12028160f, 
    0.08053605f, -0.05826020f, 0.10727961f, 0.13697432f, -0.09085309f, -0.06489894f, 0.00350602f, -0.04421544f, 
    -0.04419498f, -0.02152199f, 0.00610933f, -0.03540590f, 0.31010211f, 0.27743870f, 0.08677087f, 0.14576119f, 
    0.35504395f, 0.17076632f, 0.37664267f, -0.05191622f, 0.12610050f, 0.00328270f, -0.13727251f, -0.05730662f, 
    -0.03170637f, -0.19701102f, 0.02385630f, -0.18511902f, -0.16404012f, 0.40172130f, -0.14248228f, -0.26613116f, 
    0.11436389f, -0.06016310f, -0.14493236f, -0.05249199f, 0.03761461f, 0.06154349f, -0.08794544f, 0.22473603f, 
    0.06329527f, 0.40951368f, -0.04055010f, 0.04256282f, 0.20963848f, 0.21395107f, 0.02218267f, 0.12489679f, 
    0.02288289f, 0.05351653f, -0.18324053f, 0.19917098f, 0.09014691f, -0.02054068f, 0.37404865f, -0.21871273f, 
    0.08804476f, -0.02745309f, -0.04078081f, -0.15700550f, -0.19398841f, -0.03898758f, 0.05274474f, 0.12087611f, 
    -0.18723224f, 0.00745198f, 0.18717888f, 0.21347629f, 0.01047855f, 0.17995130f, 0.17416392f, 0.17872277f, 
    0.15416598f, 0.15954766f, 0.14621013f, 0.03566667f, -0.08732962f, -0.01502870f, -0.05831475f, 0.07429441f, 
    0.08196416f, -0.01186770f, -0.13646241f, -0.14187163f, 0.04614007f, 0.04881154f, -0.13154350f, 0.00114755f, 
    -0.20873204f, -0.07582586f, 0.21207771f, -0.01672550f, -0.06757120f, -0.02258717f, 0.00805513f, 0.08579135f, 
    -0.01324103f, 0.00110239f, 0.02140099f, 0.13403952f, -0.18369047f, 0.05987683f, 0.08082430f, 0.24986193f, 
    0.09101408f, 0.01750840f, -0.18808512f, 0.03923130f, 0.01026132f, 0.01929875f, -0.07074268f, 0.17981318f, 
    -0.03801426f, -0.10872329f, 0.01973530f, -0.01640869f, -0.02326441f, -0.02701091f, -0.06174179f, -0.22330049f, 
    0.06702883f, -0.05820775f, 0.08583619f, -0.02252670f, -0.09843035f, -0.08705380f, -0.01789256f, 0.17976362f, 
    0.02480326f, -0.02823487f, 0.17057669f, 0.12792444f, 0.18163234f, 0.00500473f, 0.11155304f, 0.12464141f, 
    0.08433190f, -0.01681247f, -0.12543631f, -0.02863155f, 0.00918444f, 0.19348739f, 0.15977088f, 0.12115630f, 
    0.01100349f, 0.07469223f, -0.05924699f, 0.08026012f, 0.17470974f, 0.01836609f, -0.06241500f, -0.15291177f, 
    -0.09668957f, -0.08303227f, 0.00804625f, 0.09781017f, -0.03184848f, -0.01488982f, 0.14617105f, 0.03874207f, 
    0.11269426f, -0.02846704f, 0.08767729f, -0.00841706f, 0.19847183f, 0.04207540f, 0.15621911f, 0.08002803f, 
    -0.10256200f, -0.10102028f, -0.02103929f, -0.10294747f, 0.01255718f, 0.05314881f, 0.10626452f, 0.13908865f, 
    0.04354558f, -0.02347163f, 0.12367517f, 0.04886574f, -0.00039213f, 0.03584048f, -0.06855851f, 0.11747345f, 
    0.17455441f, 0.01596517f, 0.06847784f, 0.00713163f, -0.13031627f, -0.03637286f, -0.05055055f, 0.09464531f, 
    0.15362227f, -0.06998899f, 0.05810564f, 0.00028639f, 0.01739935f, -0.00012242f, 0.12955290f, 0.24485920f, 
    0.00281450f, -0.10868876f, -0.05561094f, 0.00776556f, -0.12639447f, -0.10440055f, -0.03247089f, 0.13679616f, 
    0.11970823f, 0.20372359f, -0.47291192f, 0.27785370f, -0.09101605f, -0.12495994f, 0.15259227f, 0.01971187f, 
    -0.06872734f, 0.04823650f, -0.00684376f, 0.11369224f, -0.51972616f, 0.07084867f, -0.21580160f, 0.06469494f, 
    -0.09474453f, 0.07429656f, -0.01468237f, 0.17497526f, 0.10814294f, 0.04177961f, -0.00178619f, -0.04798919f, 
    -0.07796492f, -0.19428025f, 0.08150211f, -0.17925364f, 0.07961304f, 0.16666956f, -0.02213668f, -0.09674164f, 
    -0.05073353f, -0.01216080f, -0.11999250f, -0.10119409f, 0.28602830f, -0.18331492f, 0.02295464f, -0.31459913f, 
    -0.11251437f, -0.05930677f, -0.22675790f, -0.11622027f, 0.09237723f, 0.05909498f, -0.03516851f, -0.13897505f, 
    0.14708483f, -0.07116466f, 0.00630713f, -0.18815926f, -0.06221909f, 0.01074715f, 0.22576153f, 0.12131947f, 
    -0.00439615f, -0.04486630f, -0.12504329f, -0.11488580f, 0.03914602f, -0.04334159f, 0.19157861f, 0.18623237f, 
    -0.11518604f, 0.09407938f, -0.09094375f, 0.00818069f, 0.05549043f, -0.00933590f, 0.18414833f, 0.02992320f, 
    0.25291091f, 0.15523770f, -0.09569641f, -0.25750881f, 0.11734768f, 0.00170992f, 0.20397545f, 0.15409259f, 
    0.07611438f, -0.05580135f, -0.02373529f, 0.01446868f, -0.07451041f, -0.05594374f, -0.18751320f, -0.02798049f, 
    -0.02681417f, 0.08096538f, -0.04661386f, -0.00822219f, 0.02712966f, 0.03424908f, -0.08374979f, 0.07177477f, 
    0.07478344f, -0.08697085f, 0.19745603f, -0.10538835f, 0.07648068f, -0.04443140f, 0.06199249f, -0.02442843f, 
    0.09807959f, 0.03724607f, -0.08632606f, 0.08600555f, 0.04858604f, 0.11445783f, 0.05626834f, -0.14168181f, 
    0.13178621f, 0.16242160f, 0.03982813f, -0.00434403f, 0.04766772f, -0.12970124f, -0.16150242f, 0.02611322f, 
    -0.20284629f, -0.21211372f, -0.03646180f, -0.13753423f, 0.06100382f, 0.18354572f, 0.03757352f, 0.07156854f, 
    0.04547220f, 0.00304691f, 0.00331989f, -0.10447912f, -0.07007676f, 0.27977881f, 0.14490610f, -0.12208333f, 
    0.02616027f, 0.13386482f, 0.05172578f, -0.00425131f, -0.03180468f, 0.00400893f, 0.06344710f, -0.08619155f, 
    -0.18909326f, -0.18862832f, -0.15066087f, -0.32332262f, 0.07767864f, 0.13260917f, -0.05920154f, 0.13997529f, 
    0.05768518f, -0.05766939f, -0.09295415f, 0.07697436f, 0.18248738f, 0.24619907f, 0.22913440f, -0.09144779f, 
    0.09086049f, 0.02091383f, 0.00537712f, 0.01518671f, -0.08002104f, -0.12629537f, 0.15672007f, 0.07871804f, 
    0.11886916f, 0.12463851f, -0.05723450f, -0.00466670f, 0.00794412f, -0.03617738f, -0.03702268f, 0.09821487f, 
    0.13112377f, 0.09942923f, 0.33733213f, 0.03246174f, 0.05473607f, -0.02179303f, -0.03782125f, -0.18478343f, 
    -0.07785283f, -0.04323069f, -0.10615838f, -0.03274889f, -0.05137979f, 0.12568291f, 0.15104131f, -0.02513678f, 
    -0.09605864f, -0.03888895f, 0.50200540f, -0.15228513f, 0.23779264f, 0.08229200f, 0.02117704f, 0.10343305f, 
    -0.09253118f, 0.01945567f, 0.05452723f, 0.03104957f, -0.03796406f, 0.23195212f, 0.15261553f, 0.11750749f, 
    -0.08323731f, 0.08572809f, 0.01438772f, 0.05270377f, 0.05164789f, 0.24411520f, 0.09627347f, 0.16345856f, 
    0.09781604f, 0.14168017f, -0.08245494f, 0.22124474f, -0.02794011f, 0.18258829f, 0.09774990f, 0.09345009f, 
    0.10841822f, -0.01770806f, 0.06339634f, 0.06138716f, -0.29285091f, 0.01469463f, 0.00004320f, 0.20258774f, 
    -0.08694234f, 0.03855970f, 0.11687599f, -0.03229832f, -0.06915800f, 0.15841654f, 0.10211992f, 0.08876681f, 
    -0.18771429f, -0.22071530f, -0.07422540f, -0.16145337f, -0.01744860f, 0.05304642f, 0.04369002f, -0.09144866f, 
    0.06079320f, 0.16126339f, 0.10304735f, 0.07987048f, -0.03787619f, -0.02527349f, 0.08838649f, 0.12494481f, 
    0.00775070f, -0.01717896f, -0.07752465f, 0.11148562f, 0.05226722f, -0.01375849f, 0.08242853f, -0.08773574f, 
    -0.20790076f, -0.19739182f, -0.15292837f, -0.15750803f, -0.04621394f, 0.06565356f, 0.05638789f, -0.08293604f, 
    -0.10491225f, 0.01276422f, -0.08782795f, -0.06189414f, 0.04032239f, 0.13960840f, 0.15614790f, 0.01027647f, 
    -0.10648166f, -0.05088416f, -0.04725961f, 0.09635922f, 0.19340660f, -0.00438307f, 0.06449058f, -0.02559094f, 
    0.06236752f, 0.04630213f, -0.16357632f, 0.14899339f, 0.04741147f, 0.00399891f, 0.12850407f, 0.10050295f, 
    0.15628955f, 0.01502338f, 0.17847863f, 0.01942624f, -0.15839320f, -0.28774604f, -0.23113395f, -0.23866329f, 
    -0.00411763f, -0.01819084f, 0.08212293f, 0.07294818f, 0.07747086f, -0.00132469f, 0.02306618f, 0.02244086f, 
    -0.14917046f, -0.10086481f, 0.05598200f, 0.09322387f, -0.03236919f, -0.01494333f, 0.05449865f, 0.05261549f, 
    0.00776873f, -0.00770156f, 0.05181835f, -0.03473004f, 0.47331756f, -0.35443982f, 0.17915741f, 0.24444927f, 
    0.00742158f, 0.21476284f, 0.12108161f, 0.04920948f, 0.10738350f, 0.07186269f, 0.10318588f, -0.09675680f, 
    -0.09145684f, 0.05832171f, -0.12376919f, -0.05463348f, 0.12385185f, 0.01389740f, -0.03968749f, 0.26623079f, 
    -0.01567142f, 0.01156574f, -0.08027977f, 0.03352110f, 0.22972964f, 0.15887159f, -0.02150527f, 0.15583004f, 
    -0.02721774f, -0.06781566f, 0.03410058f, 0.04411536f, 0.25435692f, 0.00652717f, 0.02044072f, -0.10954078f, 
    -0.04266577f, -0.08188692f, 0.30342802f, 0.05611969f, -0.01317183f, -0.10916667f, -0.06886133f, -0.19956471f, 
    0.26993293f, 0.03105069f, 0.03111294f, 0.13692251f, 0.01019006f, 0.13343318f, 0.09958025f, 0.10646237f, 
    0.05414145f, -0.09923505f, -0.00071076f, -0.07064424f, 0.12509401f, -0.03328260f, 0.02731172f, 0.11638744f, 
    -0.01884353f, 0.36273065f, -0.16263731f, -0.10323343f, 0.06942569f, 0.06476802f, 0.09175892f, -0.00279992f, 
    0.14049159f, -0.08002025f, 0.03359471f, -0.06541114f, -0.47879893f, 0.38736221f, -0.30135012f, -0.18729302f, 
    -0.11665930f, -0.03355277f, 0.22810496f, -0.05433795f, 0.12234206f, 0.03378532f, 0.03424892f, 0.09727693f, 
    0.10461569f, 0.04734741f, 0.17881958f, -0.27727279f, 0.28098568f, 0.15036668f, 0.10925470f, -0.03050352f, 
    0.15226585f, -0.06986804f, 0.33557969f, -0.17813306f, -0.21922919f, -0.46859998f, 0.16989745f, -0.26775470f, 
    0.03160206f, -0.07389034f, 0.07459489f, -0.04287812f, 0.06427820f, 0.05017620f, 0.17835376f, 0.04721660f, 
    -0.04065492f, -0.01082769f, 0.07163022f, -0.07956035f, 0.01840765f, 0.06924414f, 0.01999309f, 0.02228368f, 
    0.06875318f, 0.06947101f, -0.00904488f, -0.07061478f, 0.08673635f, -0.09095752f, -0.03578933f, 0.14857028f, 
    -0.13605480f, 0.20885265f, -0.00923732f, -0.00438091f, 0.12184072f, -0.02446818f, -0.01768290f, -0.04461176f, 
    -0.17204167f, 0.03211631f, 0.13640197f, -0.10813659f, -0.12133785f, 0.00868196f, 0.04448071f, 0.15876594f, 
    0.02291534f, 0.05579013f, 0.06950670f, -0.06638442f, -0.01777577f, 0.18038251f, 0.01189579f, -0.10828104f, 
    0.03691479f, -0.16132137f, -0.20624919f, -0.09627447f, 0.14798424f, -0.04985287f, 0.01272483f, 0.04060856f, 
    0.32436451f, -0.24928932f, -0.02059511f, 0.01147606f, -0.10889770f, -0.17594546f, 0.07214693f, 0.02545100f, 
    0.04274771f, -0.12551917f, 0.12108453f, -0.18906702f, -0.05045854f, -0.06978533f, 0.12456855f, 0.04568479f, 
    0.04435820f, -0.09312441f, 0.16527650f, -0.04512969f, 0.17682970f, -0.03624788f, -0.06508867f, 0.19010067f, 
    -0.02156710f, 0.18514100f, 0.16602792f, 0.29159483f, -0.01046478f, 0.12760316f, -0.22415562f, -0.25204930f, 
    0.10654859f, 0.05492590f, -0.14550145f, -0.07945988f, 0.32917255f, 0.14110222f, 0.27962029f, 0.10047830f, 
    -0.11056320f, -0.07157044f, 0.08758114f, 0.20894861f, -0.00550013f, -0.05867974f, 0.03379437f, -0.06629789f, 
    0.29827014f, 0.21308155f, 0.18439798f, 0.15868121f, -0.00360716f, -0.07865841f, -0.07822550f, -0.12836416f, 
    0.11742309f, -0.01529711f, -0.02079139f, -0.03733195f, -0.21804212f, -0.19473428f, -0.01308146f, 0.15212022f, 
    0.09969916f, 0.16993786f, -0.02033942f, -0.04075203f, 0.10148415f, 0.10332090f, 0.17004840f, -0.02861516f, 
    -0.04138094f, -0.14476974f, -0.19311695f, 0.13145339f, 0.04994199f, -0.08257959f, 0.02903504f, -0.05591214f, 
    0.14948276f, 0.03041703f, 0.20496109f, 0.08834100f, -0.21581905f, -0.19522662f, -0.12096664f, -0.13161302f, 
    0.06824514f, 0.11997022f, 0.06485593f, 0.11394352f, -0.06345244f, -0.11736062f, -0.05433733f, 0.09610663f, 
    0.16061194f, 0.18561341f, -0.20665926f, -0.08785173f, 0.04601759f, 0.18166982f, -0.25686309f, 0.17668736f, 
    -0.07647476f, 0.06485960f, 0.07872666f, -0.02723698f, -0.36259896f, 0.13466613f, -0.21024971f, 0.02250963f, 
    0.14085636f, 0.12744093f, -0.13546574f, 0.05659172f, 0.13868168f, -0.05669468f, 0.05392094f, 0.00048967f, 
    0.05339520f, 0.12456888f, -0.12570533f, -0.02386764f, 0.03066964f, -0.00975304f, 0.00057431f, 0.04126802f, 
    0.05105993f, -0.03209394f, 0.26968247f, -0.08772063f, -0.26659587f, -0.30389121f, -0.18356131f, -0.18024763f, 
    0.05729379f, 0.09928549f, -0.00793460f, 0.06978692f, -0.00988971f, 0.00250888f, 0.22274147f, 0.00957434f, 
    0.14426021f, 0.13175973f, 0.20493895f, -0.01474953f, -0.18447262f, -0.00607388f, -0.08008821f, -0.13502017f, 
    -0.00987935f, -0.04907821f, 0.09616189f, 0.11506595f, -0.00651097f, -0.01035602f, 0.09521931f, 0.00214633f, 
    0.00393247f, 0.05377993f, -0.05277932f, -0.07900605f, -0.02626617f, -0.01217190f, -0.02592742f, -0.06344930f, 
    -0.07360950f, 0.50490206f, -0.01676815f, 0.20476626f, -0.21289293f, -0.01593490f, 0.15254024f, 0.15336312f, 
    -0.06418014f, 0.03755438f, 0.13789620f, 0.08517445f, -0.32257742f, 0.03357366f, -0.25478721f, -0.08203173f, 
    0.11786138f, 0.14550976f, -0.08125953f, 0.13301189f, 0.12337989f, -0.06363180f, -0.05225161f, -0.18330634f, 
    0.02706273f, -0.29880103f, 0.04950343f, 0.13920934f, 0.09831736f, -0.02364805f, 0.15690920f, 0.13009892f, 
    -0.09967335f, -0.16612375f, 0.16333395f, -0.00228003f, 0.24362399f, 0.12316297f, 0.40230483f, 0.06649075f, 
    0.10700551f, -0.04336641f, -0.10729316f, -0.06636935f, 0.16560765f, -0.12723455f, -0.10296962f, -0.02434278f, 
    0.06357018f, 0.02957363f, -0.04912138f, -0.04903991f, -0.06173321f, 0.05332297f, 0.04322160f, 0.05557472f, 
    0.04776927f, -0.02155397f, 0.05790531f, 0.02659094f, 0.03792417f, -0.02012397f, -0.03403198f, 0.01447872f, 
    0.06238190f, -0.02991560f, -0.04707268f, -0.01251286f, 0.00840672f, -0.00825403f, 0.00087819f, 0.03753136f, 
    0.06736048f, 0.06323633f, -0.00464794f, 0.04763142f, -0.04344889f, -0.00254993f, 0.04612288f, 0.01062544f, 
    -0.06074525f, -0.04379762f, -0.06298025f, 0.00712368f, -0.07182702f, 0.00555755f, -0.01329743f, 0.03856580f, 
    0.02950972f, 0.00773540f, -0.02332136f, 0.01723992f, 0.04915103f, -0.08125928f, -0.07488602f, 0.02967120f, 
    -0.06109598f, -0.05860641f, 0.05425147f, 0.00087985f, -0.02468872f, -0.02579087f, -0.07531505f, -0.03626479f, 
    -0.00421008f, 0.00782118f, 0.03413986f, -0.02697507f, -0.03060297f, -0.02009184f, 0.04710097f, -0.00701532f, 
    0.00230882f, -0.02299005f, -0.08153834f, -0.01298907f, -0.00442474f, -0.06289531f, -0.04594176f, 0.02281075f, 
    -0.07086666f, -0.04220247f, -0.08323946f, -0.04166625f, 0.03484872f, 0.01223375f, -0.06787330f, -0.05419978f, 
    0.04732949f, 0.05966223f, -0.00556952f, -0.06497975f, 0.00954363f, 0.03568986f, 0.05854528f, 0.04846855f, 
    -0.02856300f, 0.05362365f, -0.01205325f, -0.06312709f, -0.01320105f, 0.05317418f, -0.05639621f, 0.01805682f, 
    0.05551083f, -0.04812379f, 0.02056600f, 0.03611630f, -0.04016465f, -0.02894829f, 0.06618387f, -0.03017713f, 
    -0.01332546f, 0.02229759f, 0.00964509f, -0.03684695f, 0.00734978f, 0.05666539f, 0.02884303f, -0.05770539f, 
    0.01470549f, 0.05008201f, -0.01002391f, -0.07722788f, -0.04090402f, -0.02840484f, -0.03115111f, -0.07284809f, 
    0.01554547f, -0.02540785f, -0.04495110f, 0.02245994f, 0.00871464f, -0.01666432f, 0.04209784f, -0.06165078f, 
    -0.06216406f, -0.07276774f, 0.04711442f, -0.06974481f, -0.00561975f, -0.05756443f, -0.03797349f, 0.02116678f, 
    -0.04685340f, -0.03821518f, 0.05015635f, 0.00379443f, -0.01615963f, -0.01435381f, 0.00236917f, -0.02249566f, 
    0.02924024f, 0.00533640f, -0.07578534f, -0.05545373f, -0.04489504f, -0.06511887f, -0.05391999f, 0.01089012f, 
    -0.03585882f, 0.03185761f, -0.00640599f, 0.05325407f, -0.04572174f, -0.01337183f, 0.02351443f, 0.02069059f, 
    0.00457772f, 0.01790212f, 0.00519927f, 0.00393192f, 0.00515129f, -0.05880927f, -0.02807920f, 0.03140073f, 
    0.02739035f, 0.00949889f, 0.05135972f, -0.04912033f, -0.03395325f, 0.05416142f, 0.02140265f, -0.03550330f, 
    0.03137651f, 0.04646783f, 0.02514402f, -0.01561362f, -0.06543430f, -0.06345385f, 0.05400772f, 0.02758004f, 
    -0.04278017f, 0.03040890f, -0.06272671f, -0.05941340f, 0.04402034f, 0.01662254f, -0.05718243f, -0.02091039f, 
    -0.01782077f, 0.01082035f, 0.05878950f, -0.02373123f, -0.02578663f, 0.00618980f, 0.01852218f, -0.04054674f, 
    -0.07340271f, 0.03973786f, 0.03867543f, -0.04254581f, -0.07176184f, -0.02538571f, 0.05264974f, 0.04313462f, 
    -0.05843655f, 0.05614230f, 0.04319235f, -0.01007842f, -0.07581180f, -0.05579303f, -0.04825530f, 0.01846685f, 
    -0.00917734f, 0.06172474f, 0.00997475f, 0.03375069f, 0.05838395f, -0.03904168f, 0.01828043f, -0.05089459f, 
    -0.00052840f, 0.03390653f, 0.00893331f, -0.05915256f, -0.01483852f, 0.02230112f, 0.01476668f, -0.06651879f, 
    -0.03275585f, 0.04155738f, 0.02495031f, -0.02471930f, -0.05954809f, 0.03047949f, 0.04325441f, -0.06501522f, 
    -0.06805477f, -0.00539758f, 0.02778920f, -0.02588516f, 0.05252692f, 0.03912448f, -0.03713488f, -0.03738511f, 
    -0.05191606f, 0.05340983f, -0.00282945f, -0.07185053f, 0.01913617f, 0.03770181f, 0.01748312f, 0.02056629f, 
    -0.03763148f, -0.06857478f, 0.03824714f, 0.05856752f, -0.01002168f, 0.05192095f, -0.06247437f, -0.00023943f, 
    0.01517136f, 0.01128712f, -0.01874139f, -0.05240073f, -0.06225451f, 0.02602576f, -0.01743102f, 0.00091328f, 
    -0.07265496f, 0.06300177f, 0.00661615f, -0.02577803f, 0.02381100f, -0.06782261f, -0.00186162f, 0.06175192f, 
    -0.01819520f, 0.06605992f, -0.06835489f, -0.00515257f, -0.01169723f, -0.04683948f, -0.00146080f, -0.04677795f, 
    -0.01468083f, 0.01795258f, -0.06147132f, 0.00097314f, 0.03615542f, 0.00636660f, -0.07576950f, 0.01757371f, 
    0.06004475f, 0.01722034f, 0.03160046f, 0.04818098f, -0.05694366f, 0.05421691f, 0.01999295f, 0.01182736f, 
    -0.05274089f, 0.01466106f, 0.06553776f, -0.04152355f, 0.00164143f, 0.00397489f, -0.00846659f, -0.03069723f, 
    -0.01770983f, -0.07244453f, 0.01957868f, -0.03764820f, 0.00266999f, 0.06595597f, -0.02570665f, -0.00295261f, 
    -0.01924132f, 0.01169249f, 0.04115954f, -0.05410233f, -0.01222221f, -0.05278143f, 0.02687347f, 0.02546079f, 
    -0.01366911f, -0.04333878f, -0.00330252f, -0.02673502f, -0.02031044f, 0.02540006f, -0.04598624f, -0.00365228f, 
    0.03957034f, -0.02638950f, 0.01078534f, -0.03011036f, 0.04506780f, -0.07082228f, 0.02025073f, 0.05256169f, 
    0.01155927f, 0.03177105f, 0.01027916f, 0.00954425f, -0.03249462f, -0.06471572f, 0.05464981f, -0.00983391f, 
    -0.01452369f, -0.03907630f, 0.06025658f, -0.02234497f, -0.06401769f, -0.02096287f, 0.04925649f, -0.01640966f, 
    0.00356367f, -0.01845980f, -0.07013199f, -0.02808985f, -0.03578576f, -0.04608284f, -0.03208305f, -0.05010195f, 
    -0.04139478f, 0.05563198f, -0.00999379f, 0.02823158f, 0.03644338f, -0.06525686f, -0.02140015f, -0.03916937f, 
    0.03109771f, 0.02369336f, -0.03754643f, 0.02551172f, -0.00728640f, 0.01919272f, 0.01972957f, -0.02243834f, 
    -0.02748905f, 0.18867423f, 0.20388284f, -0.06243331f, -0.00594536f, -0.01784526f, -0.23988484f, -0.05636257f, 
    -0.00009540f, -0.17797723f, -0.01608691f, -0.06356560f, 0.18813756f, -0.31389618f, 0.19967474f, 0.23614211f, 
    0.07877097f, 0.23968664f, 0.03050661f, -0.00509965f, 0.12949862f, -0.12592129f, 0.02984685f, 0.04509011f, 
    0.04867991f, 0.00751622f, -0.09419589f, 0.10182344f, 0.00848582f, 0.00792559f, 0.06220127f, 0.08677632f, 
    -0.06449442f, 0.01038030f, -0.07392503f, 0.00263939f, 0.09723672f, -0.12179107f, -0.11692309f, -0.02778753f, 
    -0.08384168f, 0.04394880f, 0.02227589f, -0.01258468f, 0.11663835f, 0.01054021f, 0.02244158f, 0.10326471f, 
    -0.03487701f, 0.16057262f, 0.42914188f, 0.10753945f, -0.11806896f, -0.31512752f, -0.04897011f, 0.09979691f, 
    0.20650430f, 0.03713417f, 0.07442002f, 0.08988873f, -0.00047113f, -0.10191211f, -0.00687881f, 0.03089015f, 
    -0.05819132f, -0.08099828f, 0.05918472f, -0.07223420f, 0.23992358f, 0.13931623f, 0.04361613f, 0.20047234f, 
    -0.09069235f, 0.13093677f, -0.04827378f, -0.12815641f, 0.10361556f, -0.00953188f, -0.05281978f, -0.25785780f, 
    -0.24967727f, -0.04072472f, -0.00099670f, -0.07454531f, 0.13581178f, 0.38588399f, -0.15268017f, -0.00730300f, 
    -0.04807039f, -0.04866088f, 0.10236136f, -0.07551447f, 0.11244626f, 0.00574918f, 0.03898717f, 0.12552758f, 
    0.01966329f, -0.24518940f, -0.02990792f, -0.18582186f, 0.22916745f, 0.05613526f, 0.10441913f, 0.02478496f, 
    0.09881577f, 0.04318314f, 0.06306404f, 0.20453446f, -0.13039890f, 0.04419633f, 0.17040399f, -0.04582803f, 
    0.02461947f, -0.06760869f, -0.01563490f, -0.05912022f, 0.00648698f, 0.02857378f, -0.03351609f, -0.00868851f, 
    -0.08419953f, -0.11740839f, 0.02219695f, -0.05892200f, 0.06845680f, 0.11332306f, -0.11192303f, -0.03681855f, 
    0.04827586f, 0.05571689f, 0.10113440f, 0.11821551f, -0.15357985f, -0.07486171f, -0.03333990f, 0.04603535f, 
    -0.13429813f, 0.14328645f, 0.02431957f, -0.07002995f, 0.03700607f, -0.10638901f, -0.10618289f, -0.19429167f, 
    -0.28733492f, -0.25633743f, 0.13984355f, -0.11657926f, 0.03815827f, -0.05063423f, 0.04355418f, 0.12826785f, 
    -0.07355718f, 0.07679521f, 0.02632225f, 0.10935883f, 0.00617191f, 0.29211295f, 0.43992943f, 0.23866983f, 
    -0.16530573f, -0.15613283f, -0.09199626f, 0.14105678f, 0.03604341f, -0.00804308f, -0.16174646f, -0.01997102f, 
    0.03231142f, 0.09561282f, -0.27682561f, 0.02913662f, -0.00969745f, 0.14323081f, 0.04292941f, 0.14300954f, 
    0.04249431f, 0.05160274f, 0.09355336f, 0.01645836f, -0.12913533f, -0.03351388f, 0.13796774f, -0.00149857f, 
    0.02680994f, -0.07262835f, 0.04285750f, -0.05558303f, 0.12378352f, -0.04682142f, -0.05790564f, 0.13193727f, 
    -0.02652179f, -0.02808239f, -0.02999461f, 0.02982266f, -0.03529168f, -0.05981224f, 0.00928268f, -0.04418020f, 
    -0.06605507f, -0.03169794f, -0.01134230f, 0.00649727f, 0.04512940f, -0.05635856f, -0.03990281f, -0.03063791f, 
    -0.00451160f, 0.02255310f, -0.00929821f, -0.01739897f, 0.03314339f, -0.02318316f, 0.02477499f, -0.05730756f, 
    -0.01174674f, 0.01623010f, -0.07398920f, -0.02213874f, 0.05454712f, -0.00675146f, -0.01727542f, -0.07155919f, 
    0.00078754f, -0.03770307f, 0.05596003f, -0.05094907f, -0.03006618f, 0.04324427f, 0.03744039f, -0.06883828f, 
    0.04132428f, -0.07541150f, 0.06503183f, -0.01969630f, -0.04602839f, 0.05350006f, 0.03413871f, -0.06371935f, 
    -0.06858192f, -0.02402156f, -0.07891060f, -0.07387643f, -0.04985871f, -0.06395146f, 0.05848324f, -0.02395695f, 
    0.02130430f, 0.06170632f, -0.04667762f, 0.00508854f, -0.01613017f, -0.03463217f, -0.00040212f, 0.04206955f, 
    -0.03310273f, 0.04813873f, 0.02460788f, -0.05251217f, -0.05484466f, -0.04731346f, 0.04157073f, -0.04283105f, 
    0.02264193f, -0.08494490f, -0.03744515f, 0.01907736f, 0.00833323f, 0.02374021f, 0.04672265f, 0.04868230f, 
    0.02435742f, -0.06493060f, 0.06492214f, 0.02039029f, -0.06671472f, 0.00656870f, 0.03800884f, -0.00911233f, 
    0.00114421f, 0.03754656f, -0.05080407f, -0.04761660f, -0.00312650f, -0.08320627f, -0.00689518f, -0.07150257f, 
    0.02365134f, 0.00943074f, 0.04436485f, -0.00515452f, -0.02239122f, -0.01992399f, 0.01017769f, 0.07502787f, 
    -0.04067006f, -0.02308671f, 0.00349411f, -0.00057316f, -0.05214730f, -0.06217795f, -0.06085458f, 0.05078154f, 
    0.06125692f, 0.05519364f, -0.05318253f, -0.03243265f, 0.05887128f, -0.05348422f, 0.01397412f, 0.02479701f, 
    0.04460037f, 0.01858501f, 0.01574158f, -0.05594800f, -0.00431187f, -0.02716944f, 0.05945195f, -0.02767922f, 
    0.00848112f, 0.03151818f, 0.05818029f, -0.06282058f, 0.03389614f, 0.01511151f, -0.08493937f, -0.03221219f, 
    0.00934683f, -0.04495389f, 0.00217733f, -0.01933793f, -0.04262435f, 0.02154469f, -0.02688002f, -0.05947913f, 
    0.03890003f, 0.02592461f, -0.04668903f, 0.01004068f, 0.05683650f, 0.03835483f, -0.02412632f, -0.06975111f, 
    -0.03495834f, -0.06315857f, 0.03063736f, 0.02754787f, -0.04642710f, 0.03380636f, 0.03246126f, -0.06372188f, 
    -0.02920560f, 0.05173790f, -0.00432586f, 0.00945172f, 0.03535371f, -0.04942746f, 0.00749834f, -0.00531064f, 
    0.00984091f, 0.02798482f, -0.05846863f, -0.02573875f, 0.03455730f, 0.02529993f, -0.00747447f, -0.01263334f, 
    -0.05218102f, -0.08532307f, -0.01627095f, -0.03192817f, 0.03980101f, -0.04401221f, -0.00662670f, 0.00542916f, 
    0.00573253f, 0.03032191f, 0.03933272f, 0.01002752f, -0.00956936f, 0.01899123f, 0.01311862f, -0.04934306f, 
    0.01056395f, 0.11905004f, 0.11196752f, 0.10944228f, 0.00041149f, -0.02214811f, -0.01888642f, -0.05490691f, 
    0.05750385f, 0.10230841f, -0.01401005f, -0.00003315f, 0.04233441f, -0.12866230f, 0.07335316f, 0.20773192f, 
    0.12132068f, 0.15138547f, 0.15385687f, -0.06035915f, 0.04053167f, 0.02005529f, -0.12224843f, -0.12402355f, 
    -0.13285030f, 0.12624413f, -0.05250338f, 0.11298472f, -0.07972714f, -0.03876521f, 0.03035366f, 0.22405374f, 
    0.09453740f, 0.08946070f, -0.11106122f, 0.03569967f, 0.25162688f, 0.07150312f, -0.11630540f, -0.02054813f, 
    -0.07029464f, -0.09565101f, -0.01121947f, 0.03006748f, 0.06886001f, 0.04270343f, 0.07856656f, -0.06133530f, 
    -0.45751750f, 0.00288111f, 0.20029908f, 0.04350202f, 0.08099868f, -0.08731736f, -0.09642781f, 0.02906464f, 
    0.02591004f, 0.02411921f, -0.03723824f, 0.15664452f, -0.13900676f, -0.07454920f, -0.20445402f, -0.22322240f, 
    -0.13422415f, -0.08844323f, -0.01065863f, -0.03092270f, 0.12502536f, -0.02669888f, -0.03430610f, -0.04631175f, 
    0.14710435f, -0.17450199f, 0.34539124f, -0.17273439f, 0.07640325f, 0.21192341f, -0.12232670f, 0.05360991f, 
    0.00418188f, -0.04699461f, 0.02692947f, 0.04805030f, 0.31313431f, -0.00497279f, 0.19254743f, -0.06422270f, 
    -0.00830557f, -0.16470809f, 0.08626013f, -0.04590156f, 0.00691720f, -0.06026794f, 0.04052632f, -0.03605320f, 
    0.15459266f, 0.31298929f, 0.11972596f, 0.06338058f, 0.21000150f, 0.00397346f, 0.09064715f, 0.19374464f, 
    0.10337728f, -0.06651101f, 0.14552195f, 0.08906180f, -0.08222883f, 0.22900350f, 0.17499304f, 0.07637531f, 
    0.04617359f, -0.05986376f, 0.02594884f, 0.03970319f, -0.12520055f, -0.07497935f, 0.14790212f, 0.02098648f, 
    -0.17449468f, 0.09969725f, -0.08828969f, 0.14638819f, 0.14267211f, 0.13094468f, -0.02795534f, 0.06534255f, 
    0.04435124f, 0.10764902f, -0.04687115f, 0.05624400f, -0.22217615f, -0.07926973f, -0.25873497f, -0.04805858f, 
    -0.09120207f, 0.04761421f, 0.08409699f, -0.07605112f, 0.08432651f, 0.02389708f, 0.03052787f, 0.13049026f, 
    -0.34044948f, -0.28892332f, 0.30454922f, 0.16228238f, 0.05787726f, -0.01836724f, -0.06199803f, -0.09382692f, 
    -0.05003447f, -0.00845196f, -0.02882894f, 0.05029086f, -0.04273553f, 0.10367682f, 0.45449951f, 0.09574173f, 
    -0.01529930f, -0.05696411f, 0.03817999f, 0.09776357f, 0.06510396f, -0.07044912f, 0.07804411f, 0.07177975f, 
    0.05036497f, 0.12510514f, -0.36325750f, 0.03709020f, -0.08481399f, -0.15222710f, -0.03943810f, 0.10729325f, 
    0.09427220f, -0.22107187f, 0.07626034f, -0.07531591f, -0.27650309f, -0.09631800f, -0.14367920f, 0.23592518f, 
    -0.15662447f, -0.05479743f, 0.21205515f, 0.04988690f, 0.06633208f, 0.00835429f, 0.11440174f, 0.01739740f, 
    0.25191605f, -0.02501461f, -0.09324990f, 0.03073114f, 0.03632143f, -0.00796211f, 0.21329069f, 0.03249526f, 
    0.08344167f, 0.13039471f, 0.06833060f, 0.14027391f, 0.17182866f, -0.31221426f, -0.14633726f, 0.12854742f, 
    0.03347910f, 0.09285679f, 0.03048135f, 0.01798757f, -0.01949336f, -0.12209719f, -0.14580885f, -0.21975417f, 
    0.04745921f, 0.03874053f, -0.08463980f, -0.00413031f, 0.05359899f, 0.05525058f, 0.21300250f, 0.09611323f, 
    -0.06991423f, 0.07673926f, 0.04809452f, -0.01746587f, 0.13909118f, 0.19696197f, -0.04499794f, 0.14225796f, 
    -0.10575313f, -0.16155124f, 0.03524152f, -0.13865510f, -0.09680487f, 0.13204916f, -0.03493037f, 0.17765939f, 
    -0.09103440f, -0.01587830f, 0.22916594f, 0.10785052f, -0.03818299f, 0.01446416f, -0.13430345f, -0.12287893f, 
    0.02972918f, 0.00108828f, -0.23496641f, -0.10584153f, -0.01380576f, 0.06733706f, 0.00510619f, 0.09947921f, 
    -0.18406425f, -0.13558216f, -0.14462556f, -0.32940918f, 0.00327406f, -0.16691649f, -0.27851751f, -0.10041633f, 
    0.27879202f, 0.04009502f, -0.19345535f, 0.28258014f, -0.18575206f, -0.02006617f, 0.21457124f, -0.02213644f, 
    0.04335024f, 0.06665112f, -0.07958418f, 0.05944554f, -0.21965007f, -0.15750046f, 0.18690115f, -0.21896437f, 
    -0.14638400f, -0.17623472f, 0.02520414f, -0.00315234f, -0.06827462f, -0.06127421f, -0.09403259f, -0.01273089f, 
    -0.06832554f, 0.27826691f, 0.11586587f, 0.06959573f, 0.05400600f, 0.10078192f, -0.11772864f, 0.13487546f, 
    -0.20966199f, -0.07512915f, 0.01155719f, 0.01872840f, 0.46273434f, 0.01596662f, 0.20133355f, -0.29883066f, 
    -0.04127867f, -0.14704305f, -0.12322263f, -0.18821405f, 0.03207545f, -0.06892249f, 0.08690174f, 0.05087069f, 
    0.06700518f, 0.16177219f, -0.19297332f, 0.03779395f, 0.17339294f, -0.04203901f, 0.00761895f, 0.20422630f, 
    -0.08993831f, 0.13675171f, -0.22597806f, -0.09626083f, -0.01120432f, 0.01965724f, -0.01050076f, 0.11793010f, 
    0.09440862f, 0.06498418f, 0.15781663f, -0.08935868f, 0.10832912f, -0.02163743f, 0.15995026f, 0.26145178f, 
    0.16826105f, -0.38016722f, 0.20967743f, 0.13277809f, 0.04320458f, -0.03085995f, -0.15239644f, -0.10343575f, 
    0.14873660f, -0.04080215f, 0.03308478f, -0.01859807f, 0.07149722f, -0.18071900f, 0.01010316f, 0.10691493f, 
    -0.02352860f, 0.19918661f, -0.00273913f, -0.07679720f, -0.12496500f, 0.16514327f, 0.09892967f, 0.15373819f, 
    -0.16831321f, 0.14813291f, 0.13326705f, -0.17094752f, 0.06886575f, -0.26738998f, -0.32998878f, -0.10619660f, 
    0.05712481f, -0.20831275f, -0.10808550f, -0.05151459f, -0.15086830f, -0.03580234f, -0.30987233f, 0.04208544f, 
    0.07424621f, 0.15436676f, 0.24767447f, 0.08575596f, 0.05142333f, 0.32089305f, -0.05152945f, 0.05485075f, 
    0.05796330f, 0.04201728f, 0.07760753f, 0.12320069f, -0.00207645f, 0.03208402f, 0.25427875f, 0.09730218f, 
    0.06064079f, 0.08945145f, 0.06549606f, 0.03099816f, 0.05579183f, -0.02814968f, -0.12383381f, -0.13871321f, 
    -0.01096988f, 0.04022284f, -0.02082963f, -0.02691337f, -0.07304621f, -0.07832963f, 0.07774398f, -0.12238731f, 
    0.04699923f, 0.03131058f, 0.12126198f, -0.05699957f, 0.19574809f, 0.06445141f, 0.11114635f, 0.07903977f, 
    -0.04472096f, -0.03137893f, 0.01932046f, 0.03197617f, 0.08983094f, 0.06496488f, 0.06574201f, 0.19642413f, 
    -0.01378332f, -0.09506404f, 0.13564913f, 0.00268338f, 0.14635670f, 0.12709346f, -0.14658411f, 0.08501627f, 
    -0.35298967f, -0.15367536f, 0.10285854f, -0.15945914f, -0.09306398f, -0.02630879f, -0.10310594f, 0.11926220f, 
    0.10947286f, 0.00289423f, -0.04634299f, -0.15094253f, 0.04165099f, 0.07589170f, -0.03774317f, 0.03338471f, 
    -0.01454718f, -0.11598568f, -0.10457034f, -0.06447727f, -0.24024086f, -0.25260469f, -0.13346148f, -0.15034127f, 
    0.04725467f, -0.00839164f, -0.18604960f, 0.00886175f, -0.15528797f, -0.01126825f, -0.02148439f, 0.08409922f, 
    0.03918733f, 0.09835219f, 0.07184657f, 0.04784417f, -0.41292912f, -0.12429944f, -0.05554490f, -0.09491773f, 
    0.05771232f, -0.06118954f, -0.07525583f, 0.05690397f, 0.04856955f, 0.07413273f, -0.06099542f, -0.05298287f, 
    -0.02611944f, -0.15933266f, 0.19145752f, -0.19704670f, 0.19049743f, 0.12243917f, -0.00285153f, -0.09818507f, 
    -0.00160336f, -0.07497676f, 0.32382309f, -0.04292385f, 0.23894136f, -0.17846660f, -0.10976087f, -0.15725908f, 
    -0.13348551f, -0.03144823f, -0.07451122f, -0.05013417f, 0.04058338f, -0.01549932f, 0.08003289f, 0.07590906f, 
    0.08302607f, 0.07578030f, -0.02692055f, -0.15696611f, 0.13915841f, 0.04087596f, 0.02819066f, -0.03227156f, 
    -0.01386740f, -0.08920927f, -0.15571114f, -0.05792716f, -0.04277356f, 0.00304435f, 0.11686223f, 0.18924730f, 
    -0.12390558f, 0.05104260f, -0.12102266f, 0.13585669f, 0.16961960f, 0.06634095f, 0.19389381f, 0.19199960f, 
    0.12226371f, 0.17886379f, 0.18358013f, -0.11972617f, 0.10436777f, 0.03228621f, 0.15053390f, 0.06801924f, 
    0.06570803f, -0.06000698f, -0.09545616f, -0.11120781f, -0.37253627f, -0.09641106f, -0.03010937f, -0.00455461f, 
    -0.13987243f, 0.02496200f, -0.01859105f, 0.07091384f, 0.08533889f, 0.09254649f, 0.14528266f, 0.04122979f, 
    0.30762130f, 0.08825348f, -0.21634018f, -0.06471565f, 0.04422833f, -0.09216612f, -0.16954036f, 0.08756015f, 
    0.13476092f, -0.05089172f, -0.02552254f, -0.03366517f, -0.00231322f, 0.10597260f, 0.08257765f, 0.05132701f, 
    0.15891226f, 0.14446829f, 0.32788551f, 0.06515233f, 0.04410873f, -0.02483676f, -0.24215977f, -0.05418659f, 
    -0.04150384f, -0.05859552f, -0.04241993f, 0.05674550f, 0.02953012f, 0.05710609f, 0.03703805f, 0.02521894f, 
    0.01921092f, 0.01609570f, 0.04870231f, -0.06352972f, -0.06110944f, -0.06623154f, 0.00570359f, -0.01902738f, 
    -0.06426602f, -0.02790030f, -0.03768907f, 0.02507582f, -0.04238993f, -0.07593241f, -0.01539802f, 0.02901937f, 
    0.04789838f, 0.01613218f, 0.02598392f, -0.06726333f, -0.03387791f, -0.03091965f, -0.00593455f, -0.05083124f, 
    -0.06509755f, -0.06628331f, 0.05001462f, -0.04032084f, -0.06844243f, 0.01408699f, 0.04771863f, -0.07302258f, 
    -0.02577228f, -0.02614546f, 0.02141095f, -0.01216011f, 0.06351724f, -0.06079287f, -0.02055021f, 0.05743507f, 
    0.04737376f, 0.04050085f, -0.01642298f, -0.07828750f, 0.04874613f, 0.05694955f, -0.04561371f, -0.06278720f, 
    -0.00563453f, 0.00421773f, 0.05499174f, -0.00136724f, 0.06087894f, -0.06455933f, -0.02523168f, 0.03601163f, 
    -0.06164042f, 0.02418159f, 0.02311918f, -0.04626230f, -0.06906636f, -0.03825394f, 0.01429150f, 0.00324839f, 
    0.00336908f, -0.05039899f, -0.04718367f, 0.06740583f, -0.01885301f, 0.03946635f, 0.04583136f, 0.00561383f, 
    -0.01958469f, -0.06171967f, -0.08090509f, 0.01242072f, 0.02670206f, -0.02305209f, -0.06327059f, 0.03154990f, 
    0.02335338f, 0.00741222f, -0.00380764f, 0.05689726f, 0.04422195f, 0.06387123f, 0.03438103f, -0.06881093f, 
    0.05336616f, -0.04744196f, -0.02283255f, -0.02708336f, 0.02861206f, 0.05533673f, 0.06278623f, -0.01881017f, 
    0.03940535f, -0.04601326f, -0.01834472f, -0.02966711f, -0.02849380f, 0.02880973f, 0.00256954f, -0.05247482f, 
    -0.03893335f, -0.00186271f, -0.05218785f, 0.00208069f, 0.04633214f, -0.04989053f, -0.06144516f, 0.04108841f, 
    -0.05458254f, 0.06614198f, -0.00328508f, -0.08070150f, -0.06756797f, 0.03324430f, 0.02695166f, -0.06125384f, 
    -0.07969443f, 0.03197343f, -0.03066410f, -0.03667396f, -0.04051147f, 0.00150567f, -0.04107666f, -0.06875082f, 
    0.02908343f, -0.01146589f, -0.00403794f, 0.00139804f, -0.08280709f, 0.03154627f, 0.05796011f, -0.07641669f, 
    -0.02279901f, 0.01302191f, -0.00694158f, -0.02942428f, -0.07984298f, 0.03600108f, -0.03907062f, 0.01353580f, 
    -0.01705698f, -0.06527556f, 0.05056046f, 0.05655151f, -0.04110714f, -0.02013400f, -0.05817463f, 0.01587725f, 
    0.03376062f, -0.03356295f, -0.03434101f, -0.05172432f, 0.02200044f, -0.08205898f, -0.00273566f, 0.00132764f, 
    -0.07716558f, 0.01087196f, -0.07622337f, -0.01537082f, -0.02154400f, -0.01401037f, -0.00347338f, 0.04900736f, 
    0.00398679f, 0.04981174f, -0.02122590f, -0.04103221f, 0.03029994f, 0.02866007f, 0.00183147f, 0.03762664f, 
    -0.06507945f, -0.05715758f, -0.05795433f, -0.05074993f, -0.04542124f, -0.06387986f, 0.01112489f, -0.03405359f, 
    0.07794513f, -0.02648890f, -0.04198460f, 0.04814232f, 0.08069284f, 0.09409682f, 0.21304619f, 0.07155786f, 
    0.08725376f, -0.04375723f, 0.02764693f, 0.16470896f, 0.24089001f, 0.01586322f, -0.10789151f, -0.17566861f, 
    -0.05935264f, -0.14826381f, -0.00585464f, 0.08689501f, -0.07722526f, -0.08468164f, -0.00584360f, -0.09568737f, 
    0.10423634f, 0.05535722f, 0.16277029f, -0.07135745f, 0.17740257f, 0.11973207f, 0.12622721f, 0.06376535f, 
    0.01087913f, -0.05992786f, 0.12892383f, -0.06807591f, 0.10641737f, -0.00684697f, 0.15786640f, 0.26983091f, 
    0.06025559f, 0.02737507f, 0.05330677f, 0.06157377f, 0.05050368f, 0.12756483f, 0.03203446f, 0.07058917f, 
    -0.21916203f, -0.09079528f, -0.05275685f, 0.02765115f, -0.10352314f, -0.08595368f, -0.01735411f, 0.04621646f, 
    0.00006964f, 0.07884013f, 0.06364093f, -0.02557085f, 0.03650968f, -0.03946194f, 0.05881393f, 0.18813087f, 
    -0.07389836f, -0.01615289f, -0.05385870f, -0.00550068f, -0.21394907f, -0.23401439f, -0.09020498f, -0.01165595f, 
    0.36621377f, -0.06522539f, -0.25928777f, 0.10206243f, -0.12229103f, 0.17458108f, -0.12152807f, 0.06294646f, 
    -0.07317269f, -0.05010315f, 0.07468130f, 0.10062062f, -0.44494325f, -0.31018987f, -0.05074272f, -0.19408251f, 
    0.06370346f, -0.04482776f, 0.04909960f, 0.15545298f, 0.02632293f, -0.08628318f, 0.10158558f, -0.15025613f, 
    0.10216188f, 0.09600406f, 0.00682377f, -0.02871120f, 0.09577284f, 0.06551195f, -0.07098438f, 0.10756579f, 
    -0.05899221f, -0.01939107f, 0.10711388f, 0.16224644f, 0.13206968f, -0.22418353f, -0.28917086f, -0.17939484f, 
    -0.10746803f, -0.09125068f, -0.27646914f, 0.06688125f, -0.04165164f, -0.17851958f, 0.07511438f, -0.08273592f, 
    0.19596788f, 0.01158222f, 0.10203514f, -0.16163830f, 0.05121069f, 0.02423525f, 0.13458344f, 0.04971332f, 
    0.08948942f, -0.06357334f, -0.05899116f, 0.04250925f, -0.07299422f, 0.07289913f, 0.08209555f, 0.21370541f, 
    -0.05273589f, -0.02584403f, 0.01125963f, -0.01616940f, 0.09212882f, -0.00663492f, 0.09015126f, 0.00048836f, 
    0.09682933f, 0.16609950f, -0.04915912f, -0.05627441f, -0.02265623f, -0.06744774f, -0.01868135f, -0.07010242f, 
    -0.05783337f, -0.03188910f, 0.06416538f, 0.06580777f, -0.37683913f, -0.12291554f, -0.24046732f, -0.08346888f, 
    -0.12336973f, 0.14548090f, 0.04887100f, -0.01420459f, 0.03488478f, 0.03420538f, -0.03600613f, 0.06142948f, 
    0.19786067f, 0.00086872f, -0.04660929f, -0.02985229f, 0.11224236f, 0.03460575f, 0.05337970f, 0.15008870f, 
    0.09021037f, -0.19059457f, 0.03058991f, -0.10416134f, 0.00303895f, 0.05252197f, 0.13207138f, -0.17991374f, 
    0.10623705f, 0.13244756f, 0.17624182f, 0.15144460f, 0.15102136f, -0.00472763f, 0.00468817f, 0.00614508f, 
    -0.55109948f, -0.44950601f, -0.08816415f, -0.60783261f, -0.07390690f, 0.00544306f, 0.13551320f, 0.42667541f, 
    -0.00475627f, 0.03575652f, -0.02388070f, 0.09454504f, -0.28368580f, -0.24264742f, -0.28178513f, -0.35476264f, 
    0.09077527f, 0.13896233f, -0.03236062f, 0.12877609f, 0.10102050f, 0.05841076f, -0.01628084f, -0.01686200f, 
    -0.47227016f, -0.78424722f, -0.60506749f, -0.64288431f, -0.26930285f, -0.10659845f, -0.13669893f, 0.32496184f, 
    0.07226557f, 0.06035062f, -0.04108493f, 0.11901867f, 0.09745075f, 0.06518836f, 0.06317250f, 0.05144249f, 
    0.01168027f, 0.02240817f, 0.02491290f, 0.08974012f, -0.08587920f, -0.24033171f, -0.17429623f, -0.16528089f, 
    0.07706846f, -0.09650975f, -0.08207451f, -0.00300833f, 0.02515860f, -0.02005496f, -0.01721100f, -0.15089940f, 
    -0.05602477f, 0.00972821f, -0.07118313f, -0.25567818f, 0.12746121f, 0.18068402f, 0.08473015f, 0.12517589f, 
    0.11019996f, -0.03728947f, 0.03303269f, 0.02562496f, -0.22962476f, -0.27606669f, -0.10683858f, -0.19330904f, 
    -0.69705051f, -0.37163746f, -0.19018872f, -0.20690219f, -0.13294108f, 0.23443367f, 0.05166218f, 0.11718991f, 
    0.11866188f, 0.05041125f, -0.09666699f, 0.02911311f, -0.06298769f, 0.31953245f, -0.20334578f, 0.00726135f, 
    -0.14562541f, 0.08460649f, 0.16970196f, -0.11934539f, 0.24344786f, -0.24056603f, -0.09733424f, -0.01931524f, 
    -0.01510654f, 0.02264328f, 0.19482465f, 0.17906965f, 0.15923443f, -0.04327279f, 0.09860878f, 0.17387480f, 
    0.18185884f, -0.09211308f, 0.22635268f, -0.00357617f, -0.08924645f, -0.04378946f, 0.13548966f, 0.08007816f, 
    -0.01759719f, 0.17552944f, 0.18134092f, 0.02671337f, 0.42671224f, 0.06359509f, 0.30529648f, 0.13390629f, 
    -0.06339278f, -0.17490157f, 0.09236338f, -0.28216636f, 0.25411466f, 0.14997882f, -0.41897923f, -0.36135641f, 
    -0.25340718f, -0.11831114f, -0.08809616f, -0.16451575f, -0.00490138f, -0.09384497f, 0.00342870f, -0.04637912f, 
    0.19484591f, 0.06011465f, 0.12949216f, 0.14988604f, 0.04813937f, 0.10415839f, 0.05608320f, -0.02475983f, 
    -0.60762393f, -0.58815366f, -0.05923560f, 0.32947549f, 0.37136102f, 0.36026779f, 0.10072439f, -0.00771738f, 
    0.09109627f, 0.03120839f, -0.15431327f, 0.08948000f, 0.35503161f, 0.06961076f, 0.08869082f, 0.00046474f, 
    0.09294238f, -0.21039478f, -0.12210043f, -0.15686478f, -0.09650855f, 0.09566858f, 0.14404120f, 0.09358222f, 
    0.07375056f, 0.18483520f, 0.07152133f, 0.15818131f, -0.11687074f, -0.18947667f, -0.07159726f, 0.03938360f, 
    0.09583524f, -0.05418761f, 0.00417536f, -0.14611281f, -0.19945605f, -0.28256252f, 0.01918697f, -0.21839654f, 
    -0.04201384f, -0.06716863f, 0.04365227f, -0.13144097f, -0.21702830f, 0.08331029f, -0.16188884f, -0.01006378f, 
    -0.14459167f, -0.04204994f, -0.17925860f, -0.01263830f, 0.05550245f, 0.22636345f, -0.01618440f, -0.09896709f, 
    0.03227088f, 0.08488058f, 0.09951132f, -0.03174843f, 0.03238975f, 0.14680253f, 0.15262291f, 0.01945523f, 
    -0.10128160f, 0.10466357f, -0.00686617f, 0.24483396f, -0.03945482f, -0.12578185f, -0.04190458f, 0.13437752f, 
    0.10263537f, -0.02023282f, -0.07038534f, -0.02231595f, 0.17323463f, 0.05921089f, -0.03273815f, -0.08721121f, 
    -0.09274177f, -0.07327059f, -0.19114108f, 0.15861082f, -0.05542806f, -0.04094782f, -0.04124929f, 0.13704151f, 
    -0.10691107f, -0.08473817f, -0.18075569f, 0.01072159f, 0.10036760f, -0.08302596f, -0.10083035f, -0.10976934f, 
    0.33319119f, 0.11385830f, -0.09496029f, -0.15038885f, 0.15179412f, -0.00700185f, 0.00710397f, 0.07145754f, 
    0.00113474f, 0.06021757f, 0.14704311f, -0.00826556f, 0.03883157f, 0.08335445f, 0.05784424f, 0.08043984f, 
    -0.16726963f, 0.00398357f, -0.01045024f, -0.02889295f, -0.08357166f, 0.02212792f, 0.04207552f, 0.03322271f, 
    0.02997282f, 0.24669670f, 0.08645274f, 0.15098220f, 0.01031127f, -0.15581593f, 0.11678776f, -0.09123188f, 
    0.07229873f, -0.00875615f, -0.10297242f, -0.06560262f, 0.06020415f, 0.32366535f, -0.19209430f, 0.44508323f, 
    -0.00568708f, 0.06187018f, -0.04031331f, 0.05527101f, 0.09555069f, 0.17232233f, 0.09027322f, 0.20561427f, 
    -0.18357152f, -0.17488068f, 0.01238020f, 0.08703218f, 0.07808013f, -0.02749569f, -0.08485124f, 0.08001415f, 
    -0.09385411f, 0.15571487f, -0.19622938f, -0.12961985f, -0.31805447f, -0.36248335f, -0.19458666f, -0.03276340f, 
    0.04474242f, 0.08392049f, 0.04035664f, -0.19596250f, 0.09638552f, 0.01793792f, 0.14389960f, 0.19064339f, 
    -0.00076565f, 0.00004069f, -0.01340242f, -0.01295067f, 0.00060857f, 0.19187434f, 0.14658816f, 0.00731292f, 
    0.18237744f, 0.07041810f, 0.10738977f, -0.03039908f, 0.17856164f, -0.28900754f, 0.17277545f, -0.11435408f, 
    -0.14436240f, 0.02350311f, -0.22402629f, 0.00972183f, 0.04428373f, 0.03637233f, 0.06438430f, 0.09922608f, 
    0.18971272f, 0.47721609f, -0.24919835f, -0.20787397f, 0.11138509f, 0.14207461f, 0.15403058f, 0.23028816f, 
    -0.08008359f, 0.06937397f, 0.00185014f, 0.07176316f, -0.03539358f, 0.07393663f, -0.29337177f, -0.18673050f, 
    0.26307100f, 0.03092013f, 0.00385413f, 0.09565780f, 0.08269053f, -0.02701391f, -0.07602220f, -0.01706272f, 
    -0.08328420f, -0.32664785f, 0.14391528f, 0.11207164f, 0.03727727f, 0.18410458f, 0.07299408f, -0.03608688f, 
    -0.04277630f, 0.03863288f, 0.03992990f, -0.00469115f, 0.18994465f, 0.06800961f, 0.10798105f, -0.10283487f, 
    0.17585017f, -0.00074255f, -0.02515788f, 0.06451869f, 0.03902464f, -0.16912128f, -0.10676096f, -0.07318539f, 
    -0.10285591f, -0.23614426f, -0.18577436f, -0.03714586f, 0.21744302f, -0.12218604f, 0.11017737f, 0.11433469f, 
    0.00150435f, 0.12654555f, 0.05321741f, 0.05467165f, 0.04943168f, -0.14273600f, 0.02799962f, 0.04093154f, 
    -0.02349494f, 0.08088105f, 0.17325340f, -0.09871717f, -0.09869725f, 0.02741844f, 0.08477932f, 0.05337567f, 
    -0.15307714f, -0.25073645f, -0.46546265f, -0.25923866f, 0.01305985f, -0.01091879f, 0.00709198f, 0.04838620f, 
    0.00787050f, -0.01525476f, 0.06614324f, -0.04334881f, 0.47696397f, 0.08152131f, 0.12803832f, 0.09032898f, 
    -0.09219712f, 0.05792464f, 0.08620065f, -0.03663428f, 0.02977440f, 0.05065626f, 0.08730528f, -0.09922450f, 
    -0.11099992f, -0.01116006f, 0.13200015f, -0.15020138f, -0.06966592f, 0.09589142f, -0.02643975f, 0.03969723f, 
    -0.11287237f, 0.07301630f, -0.15321824f, -0.12813585f, 0.16638291f, 0.07034192f, 0.11158440f, 0.20039056f, 
    -0.09271939f, -0.00706335f, -0.04085822f, 0.08083627f, 0.14208983f, 0.08618191f, 0.18222494f, 0.16295516f, 
    0.64825642f, 0.12872560f, 0.07117148f, 0.06887321f, -0.02843892f, -0.13634814f, 0.06152536f, -0.12476022f, 
    -0.07145549f, -0.10999519f, -0.04141915f, 0.12302339f, -0.06712693f, -0.31910104f, -0.12132777f, -0.23647352f, 
    -0.17556283f, 0.03545215f, 0.08994400f, -0.03664376f, 0.06980233f, -0.00670532f, 0.05159679f, 0.28537291f, 
    0.44323981f, -0.06135616f, 0.05014943f, 0.08967161f, 0.02165309f, 0.07774493f, 0.12321120f, -0.02208065f, 
    0.06483936f, 0.04513885f, -0.06235179f, 0.08073295f, 0.18627152f, 0.01658852f, -0.22261769f, 0.08257000f, 
    0.15104361f, -0.17117132f, -0.05437538f, 0.15231250f, 0.01667845f, 0.04186080f, -0.03793584f, 0.07497872f, 
    -0.22372949f, -0.08589039f, -0.05009350f, 0.13038909f, 0.15341802f, 0.07346313f, 0.20503390f, 0.08140498f, 
    0.11295816f, 0.16644856f, 0.04032149f, 0.01204637f, 0.02475671f, 0.09322415f, 0.12253519f, 0.11204033f, 
    0.02885205f, 0.06304085f, -0.03700542f, 0.00883542f, -0.05065415f, 0.00005289f, -0.10445505f, -0.02059716f, 
    -0.13450038f, -0.71822339f, -0.57472545f, -0.08942964f, -0.03023533f, -0.16682535f, -0.15705135f, -0.17778683f, 
    -0.07053749f, -0.10514835f, 0.01413732f, 0.03391542f, -0.12371986f, 0.07675444f, 0.20572890f, -0.16401336f, 
    -0.06090942f, -0.05028564f, -0.00106893f, -0.02676985f, -0.16652057f, 0.04272258f, 0.02457236f, 0.18732336f, 
    0.03104819f, 0.04802177f, -0.04460645f, -0.10028899f, -0.00946049f, 0.04957864f, -0.01669113f, 0.04176628f, 
    0.05612228f, 0.09096364f, -0.07277631f, 0.01545870f, -0.20203270f, -0.19123071f, -0.24584001f, -0.66890329f, 
    0.03648170f, 0.08693494f, 0.03849207f, 0.00809713f, -0.20183474f, 0.02427562f, 0.03868292f, 0.02216485f, 
    -0.19478157f, -0.13547599f, 0.14933279f, 0.15115443f, 0.12280307f, 0.03425315f, -0.02692052f, -0.19743609f, 
    0.09568415f, 0.17393684f, -0.13310018f, 0.14172359f, 0.02607130f, 0.32085392f, 0.04703463f, -0.04926276f, 
    0.20534866f, -0.10046602f, 0.02024893f, -0.05739878f, 0.07179493f, -0.05443807f, 0.03314383f, -0.01255296f, 
    -0.01443405f, -0.08336396f, 0.04485438f, -0.30663610f, 0.11480670f, 0.07089274f, -0.15370761f, -0.04695176f, 
    0.09016421f, 0.00817042f, -0.06855935f, 0.02599429f, 0.28281650f, -0.03634560f, 0.23098636f, 0.19233990f, 
    0.04746473f, 0.11438862f, 0.12964167f, 0.06273938f, 0.00017587f, 0.05596918f, 0.03737982f, -0.04649651f, 
    -0.26207396f, -0.09652408f, -0.06538496f, -0.00807848f, -0.01791472f, -0.11582421f, 0.15148562f, 0.14679411f, 
    0.01373190f, -0.00302097f, 0.01619503f, 0.00277823f, 0.10439106f, -0.07364858f, 0.04726345f, 0.17724033f, 
    -0.00637244f, 0.00863359f, 0.00861001f, 0.15429053f, -0.03874420f, -0.07327909f, 0.09736866f, 0.09626714f, 
    0.28977033f, -0.02533917f, 0.01620044f, -0.01054648f, 0.19872963f, 0.37296575f, -0.15080245f, 0.14248507f, 
    0.01292576f, -0.07864060f, 0.06692515f, -0.00184844f, -0.15741540f, -0.36294052f, -0.27139008f, 0.11142781f, 
    -0.11494567f, 0.28283575f, -0.04917933f, 0.06833629f, 0.13749962f, 0.06034220f, 0.03813929f, -0.03407096f, 
    0.22407290f, 0.05729321f, -0.08968804f, 0.19194043f, 0.17369176f, -0.13196151f, 0.02831164f, -0.03652012f, 
    0.06860357f, -0.02467299f, 0.17530924f, 0.00338149f, -0.41466409f, 0.09756687f, -0.35089612f, 0.37104651f, 
    -0.01921974f, 0.08817616f, -0.28833148f, -0.15620185f, 0.09176297f, -0.07675020f, 0.08178420f, 0.02048513f, 
    -0.08886544f, -0.15817143f, 0.06405168f, -0.24889848f, 0.12064520f, 0.06456341f, 0.09618604f, -0.25364479f, 
    0.03012294f, -0.04272829f, 0.13374454f, 0.00270783f, -0.08797312f, 0.09088495f, 0.04503230f, 0.28638849f, 
    -0.06541828f, -0.14315772f, -0.11512669f, 0.11079413f, -0.07020271f, 0.07870005f, 0.01114359f, -0.02822457f, 
    -0.18135864f, 0.00157221f, -0.49234021f, -0.13686027f, 0.04214418f, 0.06371355f, 0.05065806f, -0.13117403f, 
    -0.22002722f, 0.00888670f, 0.05189978f, 0.01597237f, -0.47478139f, -0.15278107f, 0.14317805f, -0.05317910f, 
    -0.02093566f, 0.07242552f, 0.19365510f, 0.08228590f, 0.00622970f, 0.02803190f, -0.10055715f, -0.02047752f, 
    0.15454827f, 0.02857799f, -0.30406612f, 0.15363646f, 0.21030112f, 0.05414342f, 0.18672335f, 0.33973163f, 
    -0.00999087f, -0.02113642f, 0.12090264f, -0.00542616f, 0.02046713f, -0.03063650f, 0.19284545f, -0.44997159f, 
    0.01616862f, -0.01908053f, 0.07383541f, 0.04829920f, -0.02712940f, -0.05887137f, 0.00061980f, 0.04463164f, 
    0.12269913f, -0.01635936f, -0.10722031f, -0.11589366f, -0.06031578f, 0.07434990f, -0.16263399f, 0.10589439f, 
    -0.16640672f, -0.17554021f, -0.11678915f, -0.20124455f, 0.34134594f, 0.12721194f, 0.18218271f, 0.22018623f, 
    -0.07249866f, 0.03175559f, 0.13907595f, 0.02512349f, -0.04509165f, -0.00936734f, 0.01091415f, 0.07593207f, 
    0.02037324f, 0.08093958f, -0.09061315f, 0.00167031f, 0.04357414f, 0.04991462f, -0.03829226f, 0.06074950f, 
    -0.01309120f, -0.01714176f, 0.05253682f, -0.17340828f, -0.10916018f, -0.06869604f, -0.18315287f, 0.20089948f, 
    0.01206393f, -0.05641861f, -0.05381734f, -0.16874234f, -0.32959786f, -0.22449091f, -0.03277747f, 0.18863226f, 
    0.36311778f, 0.18863449f, -0.01859268f, 0.09734643f, -0.08141850f, 0.07302358f, -0.03679635f, -0.25591809f, 
    0.05729939f, 0.22098830f, 0.15196858f, 0.04077409f, -0.25082058f, -0.10229468f, 0.03369930f, 0.01348437f, 
    -0.28903896f, -0.00282855f, 0.17325662f, 0.03714493f, -0.06662402f, 0.20560065f, 0.11870629f, 0.20275339f, 
    -0.17707908f, 0.11700825f, -0.64779127f, 0.05834967f, -0.00709398f, -0.02986610f, -0.13714632f, 0.05803126f, 
    -0.14042637f, -0.05992468f, -0.25059235f, -0.31444421f, -0.16298383f, -0.52532709f, 0.16922301f, 0.08751136f, 
    -0.05758028f, -0.09016731f, 0.05463409f, -0.09575263f, 0.10231713f, 0.05461587f, 0.12309836f, 0.10480223f, 
    -0.07460330f, 0.01489864f, -0.02164897f, 0.12918609f, -0.20166765f, 0.10539407f, 0.00735090f, 0.09502271f, 
    -0.11635799f, -0.06250550f, 0.01237616f, 0.00600972f, -0.75655454f, -0.26320776f, -0.38197899f, 0.29519552f, 
    0.09369253f, 0.03686799f, -0.16421382f, -0.08286121f, 0.02988971f, 0.04642968f, -0.01145979f, -0.08954110f, 
    0.27559513f, 0.09582594f, 0.01573685f, -0.02239139f, -0.03252593f, 0.06765047f, -0.06053876f, 0.18894801f, 
    0.11186596f, 0.20762150f, 0.11718874f, 0.20607747f, -0.17018719f, 0.15347891f, 0.16886559f, -0.16293313f, 
    0.18194225f, -0.06025850f, 0.01769104f, -0.34134805f, -0.33949289f, -0.20505939f, -0.23754604f, -0.36486918f, 
    0.22722554f, 0.04604000f, -0.20528665f, 0.17884895f, 0.11978453f, 0.05610898f, 0.08223602f, 0.19567589f, 
    -0.04528221f, 0.10311862f, 0.12554470f, 0.24774565f, 0.26869264f, 0.06326129f, 0.03570517f, 0.00493485f, 
    0.07992956f, -0.08020505f, -0.01821721f, -0.12675330f, 0.05376278f, -0.00692035f, -0.01934708f, -0.14375003f, 
    -0.05709079f, -0.04872961f, 0.17020839f, -0.06848353f, -0.03176183f, -0.04512910f, 0.00870486f, -0.07274592f, 
    0.13313839f, 0.19355027f, 0.21155255f, 0.27214423f, 0.28964701f, 0.16358027f, 0.17016807f, -0.03485607f, 
    0.03800157f, -0.00032552f, 0.02468444f, -0.08626681f, 0.01991894f, 0.01033011f, -0.02360029f, 0.12768969f, 
    -0.12316886f, -0.02847784f, -0.07196234f, 0.23791204f, 0.01959660f, -0.04823077f, -0.05545903f, -0.10184618f, 
    0.14280178f, 0.12518281f, 0.04701624f, 0.00713169f, 0.03454577f, 0.11101538f, 0.23636222f, 0.27353728f, 
    -0.03493815f, 0.23482135f, 0.09788805f, 0.05898041f, -0.01337685f, -0.03152088f, -0.08974809f, 0.06285254f, 
    0.04057787f, -0.03797442f, -0.11238685f, 0.16258198f, -0.06270467f, 0.01555221f, -0.14372180f, 0.07709686f, 
    0.11329052f, 0.09208415f, -0.12101611f, 0.12180997f, -0.02959841f, 0.06973964f, -0.05586625f, -0.18085656f, 
    -0.20056939f, -0.08066846f, -0.12099701f, 0.00670860f, 0.03877681f, -0.07334404f, 0.08815768f, 0.00647358f, 
    0.11037195f, 0.08452651f, -0.12187215f, -0.39065909f, 0.12238865f, 0.10955927f, 0.04358061f, -0.03462887f, 
    -0.00285155f, -0.02445725f, 0.15352213f, 0.04568449f, 0.01157825f, 0.04874424f, -0.06103191f, -0.26029363f, 
    -0.11950304f, 0.13370463f, 0.10242402f, 0.07302342f, 0.07205439f, 0.20241319f, 0.12027970f, -0.09025669f, 
    -0.02484126f, 0.17848229f, 0.51014012f, 0.14093739f, 0.09316660f, -0.15927681f, 0.05044249f, -0.02637747f, 
    0.09115865f, 0.06048347f, -0.02226061f, 0.01928348f, 0.36862510f, 0.00915378f, 0.11905650f, 0.27570552f, 
    -0.10666539f, -0.05506355f, 0.10489521f, -0.00079274f, -0.02620489f, -0.00102553f, 0.05792171f, 0.06562534f, 
    0.07877910f, 0.19679588f, 0.03071443f, 0.14887360f, 0.08644260f, -0.09599937f, 0.02248927f, 0.10460270f, 
    -0.13501301f, 0.10718280f, -0.01813086f, -0.01131589f, -0.40233484f, -0.05416312f, -0.23330624f, 0.33853969f, 
    0.13078904f, -0.07433122f, 0.15820296f, -0.00477167f, -0.06855896f, 0.08844066f, 0.11206873f, 0.13920234f, 
    -0.03883376f, 0.07884458f, 0.00505837f, 0.21288501f, 0.00585442f, 0.10415182f, 0.02450538f, 0.08384831f, 
    0.10159524f, 0.26230174f, 0.19705565f, -0.00258905f, 0.18410710f, -0.16658725f, -0.06281115f, -0.15420334f, 
    -0.05453780f, -0.04228871f, -0.07448575f, -0.14389522f, -0.00646055f, 0.03000645f, -0.01200898f, 0.12802701f, 
    -0.00594703f, -0.01907208f, -0.25786173f, 0.16762127f, 0.02418027f, 0.10700263f, -0.06114703f, -0.06768610f, 
    -0.12696579f, 0.08949839f, 0.05774727f, 0.03289948f, 0.16425313f, 0.03055864f, 0.00729338f, -0.23129390f, 
    0.06722653f, 0.03108913f, 0.07148249f, 0.00382482f, 0.11965991f, 0.02270694f, 0.07502225f, -0.03214097f, 
    -0.00044084f, -0.23166697f, -0.17457598f, 0.08026776f, 0.01704174f, 0.03844762f, 0.08893866f, 0.15883762f, 
    -0.14865205f, 0.02670642f, -0.06366611f, -0.09444676f, 0.14692333f, -0.21484685f, -0.25831777f, -0.02629594f, 
    0.04914440f, -0.03411387f, -0.02058083f, 0.01859514f, 0.07825432f, 0.02854260f, 0.19497135f, 0.09907378f, 
    0.01877961f, 0.04753724f, -0.01148691f, -0.00603629f, -0.07053373f, -0.06676863f, -0.03941656f, -0.04282410f, 
    0.03288229f, 0.00389224f, 0.00013749f, -0.06394039f, -0.03825625f, -0.04797122f, 0.06464975f, 0.04195734f, 
    -0.01984517f, 0.06906046f, -0.07226239f, -0.00349744f, 0.07238424f, -0.03901795f, -0.04811043f, -0.04128645f, 
    -0.04663592f, 0.04990463f, -0.07040071f, -0.00818094f, 0.05240899f, 0.04269490f, 0.02465609f, 0.01898747f, 
    0.04576139f, -0.06237362f, 0.03525031f, -0.05803797f, -0.05411142f, -0.02128827f, -0.02396261f, 0.06160638f, 
    0.04233577f, -0.04516651f, -0.06138853f, 0.01565263f, 0.05697689f, -0.00814479f, 0.00717769f, -0.04828560f, 
    0.00450567f, -0.04250569f, 0.01249849f, 0.04418865f, 0.01491498f, -0.06237889f, 0.06037486f, -0.04955530f, 
    0.04148246f, -0.02074727f, 0.00315634f, -0.08133412f, 0.00648149f, 0.04850980f, -0.05917520f, -0.04331456f, 
    0.02109236f, -0.06622869f, -0.07095549f, -0.04150936f, -0.00189978f, -0.00855958f, 0.04944479f, -0.07715753f, 
    -0.06556684f, 0.04360114f, -0.06831074f, 0.05983566f, 0.00249348f, -0.00208185f, -0.00471895f, 0.03533838f, 
    0.05138568f, 0.05103914f, 0.00442212f, -0.01987835f, -0.00169960f, 0.04675911f, -0.05459047f, 0.02034126f, 
    -0.04631013f, -0.05509763f, -0.01584318f, -0.07470390f, 0.06530835f, -0.03808005f, 0.00495520f, 0.04171355f, 
    0.03722171f, 0.06631202f, -0.01469518f, -0.06002833f, -0.02363536f, 0.06125292f, 0.01808844f, -0.03797589f, 
    -0.00532404f, 0.06912210f, -0.00249550f, -0.04619556f, -0.06755868f, -0.05480273f, 0.00615532f, -0.01339246f, 
    0.05721136f, -0.02438238f, -0.00569849f, 0.00997302f, 0.04928245f, 0.02243640f, -0.01932035f, -0.00364394f, 
    0.02181792f, 0.02864334f, -0.02933718f, -0.06317807f, -0.02926100f, 0.04697779f, -0.01683216f, -0.03151752f, 
    -0.01845076f, -0.00159071f, -0.04300752f, -0.04554171f, -0.05877538f, 0.05939938f, -0.05711436f, -0.02135140f, 
    0.01246731f, -0.06573093f, -0.06069711f, -0.08820209f, -0.03214699f, -0.08389129f, 0.00273668f, -0.03132456f, 
    -0.07395414f, -0.03503330f, 0.03634548f, -0.05520119f, 0.06145164f, -0.05567374f, -0.05988587f, -0.07757350f, 
    -0.02009978f, -0.05150665f, 0.00151991f, -0.05540758f, 0.04203168f, 0.03167090f, -0.05786577f, 0.04503286f, 
    -0.02487529f, -0.04799825f, 0.05317624f, 0.02815668f, 0.05784975f, -0.05522962f, -0.06221147f, 0.05908480f, 
    -0.05206594f, -0.06499559f, -0.02171341f, 0.00260688f, -0.06360982f, -0.03318996f, -0.05135970f, 0.02499926f, 
    0.06289378f, -0.05286817f, -0.05533365f, -0.04267799f, -0.03598566f, -0.00187303f, -0.01239185f, -0.01034008f, 
    -0.00821092f, 0.01711258f, 0.05951249f, 0.04108724f, 0.04924177f, 0.04279104f, -0.06055932f, 0.04678475f, 
    -0.05418908f, -0.06167065f, 0.19734703f, 0.07829490f, 0.00089909f, -0.07565097f, -0.07041121f, -0.09278579f, 
    0.00619509f, -0.07440289f, -0.06444378f, -0.10708229f, 0.04073390f, -0.05203065f, 0.03176951f, 0.09009442f, 
    0.13189809f, 0.09220682f, 0.08040654f, 0.00275990f, -0.04040736f, -0.01651906f, -0.07334001f, 0.03802281f, 
    -0.09203731f, -0.05188350f, -0.02079053f, -0.11964954f, 0.01421558f, 0.04051421f, 0.02333955f, 0.03791518f, 
    -0.00225007f, -0.04664830f, -0.10564552f, -0.05085770f, 0.28127515f, 0.11168972f, 0.12140127f, -0.07754683f, 
    -0.06911884f, 0.06677171f, 0.03875276f, 0.02322512f, 0.04971308f, 0.08614606f, 0.16139375f, -0.00593222f, 
    -0.26893806f, 0.03145130f, 0.09591945f, 0.09577199f, 0.02913015f, -0.02280696f, -0.03597326f, -0.01937286f, 
    0.07318893f, 0.02137799f, 0.03663726f, 0.07680491f, -0.03509497f, -0.09718784f, -0.11958934f, -0.14814447f, 
    -0.13771825f, -0.09865619f, 0.02704508f, -0.00330742f, 0.30216256f, 0.10190375f, 0.02612912f, 0.15547217f, 
    0.13843398f, -0.19968089f, 0.42853421f, -0.34561029f, 0.10996900f, 0.04632973f, -0.18579040f, 0.04718672f, 
    -0.15883325f, -0.09661989f, 0.06585415f, -0.05753249f, 0.06938787f, 0.07846943f, 0.18001805f, -0.13720483f, 
    -0.11907824f, -0.01085158f, -0.03392027f, -0.09071289f, 0.07803854f, 0.02064828f, 0.06748132f, 0.05270808f, 
    0.24296981f, 0.17129087f, 0.02357101f, -0.00740930f, 0.14388819f, 0.11188485f, 0.09951300f, 0.04607681f, 
    0.18791331f, -0.01932444f, 0.11208499f, 0.02303232f, -0.22145592f, 0.17388028f, 0.13188373f, 0.17566669f, 
    0.09145814f, -0.15587968f, 0.07786248f, 0.04675810f, -0.15300611f, 0.01600177f, 0.02326833f, 0.04154120f, 
    -0.23470081f, -0.07801474f, 0.11219736f, 0.16688158f, 0.11886397f, 0.10077193f, -0.03008046f, -0.06427949f, 
    0.01561412f, 0.17187621f, 0.14807540f, 0.06628071f, -0.06533093f, 0.05113376f, -0.12097810f, 0.06712649f, 
    0.00761824f, -0.02118732f, 0.04232236f, -0.05474522f, 0.00243453f, 0.02279217f, -0.15042314f, -0.11870588f, 
    -0.29615140f, -0.25228515f, 0.14416578f, 0.03862026f, -0.04296418f, -0.02201820f, -0.04877359f, -0.06804819f, 
    -0.06900562f, 0.02776002f, 0.06712903f, -0.05413045f, -0.03159744f, 0.23514183f, 0.47632349f, 0.23605418f, 
    -0.12429695f, -0.19067834f, -0.02902026f, 0.01921971f, -0.01572080f, 0.08767955f, 0.02183937f, 0.02672967f, 
    0.20848170f, 0.16334294f, -0.25201267f, -0.01498458f, 0.03716286f, 0.00632905f, 0.05314321f, 0.09986222f, 
    0.11660299f, 0.07783370f, 0.08795991f, -0.02312632f, -0.20844233f, -0.18083097f, -0.02795483f, 0.01406938f, 
    -0.11829747f, -0.07102391f, 0.07353799f, 0.05357651f, 0.12063866f, 0.03419720f, 0.11195756f, 0.07922650f, 
    -0.00524611f, -0.11935104f, -0.16429748f, 0.07521407f, 0.16411805f, 0.04484664f, 0.13253734f, 0.08417855f, 
    -0.06891920f, 0.10568617f, -0.05685203f, -0.05480985f, -0.11447730f, 0.47801360f, 0.09139058f, -0.16929455f, 
    -0.15834911f, -0.11148853f, 0.03152975f, 0.06940287f, -0.06957398f, 0.07747815f, -0.04091817f, 0.08987117f, 
    -0.02893572f, -0.14987615f, -0.03507714f, 0.04289668f, -0.00773817f, 0.09401644f, 0.06237685f, -0.13171284f, 
    -0.03944718f, 0.01851133f, -0.02348328f, -0.01152240f, -0.02576221f, 0.17580147f, 0.28796148f, 0.03662074f, 
    0.01826303f, -0.05015480f, -0.02963779f, 0.07998547f, 0.06151901f, -0.02078586f, 0.16354257f, 0.03585954f, 
    0.45561063f, 0.00229251f, -0.29338998f, -0.24179296f, 0.02805758f, 0.02239431f, 0.03729001f, -0.01277018f, 
    -0.16949256f, 0.04593674f, 0.12003631f, -0.08371533f, 0.08636454f, 0.11979127f, -0.00427033f, -0.15735509f, 
    -0.14085324f, 0.07054194f, -0.12032977f, -0.02001558f, -0.00215029f, 0.20134477f, 0.11071275f, -0.01622791f, 
    0.04615746f, 0.10175072f, 0.33201820f, 0.26994315f, -0.15687251f, -0.23935544f, 0.02890092f, 0.05167820f, 
    0.01823428f, 0.07493852f, -0.11772024f, 0.05295623f, 0.15571168f, -0.04533637f, 0.02222321f, 0.36649036f, 
    -0.03161485f, 0.11098456f, -0.15159813f, 0.02880157f, -0.05229482f, 0.04435216f, 0.10388661f, 0.13838837f, 
    -0.04554214f, 0.10162832f, 0.00460550f, 0.28928035f, -0.19886141f, 0.07288861f, 0.02196578f, 0.03711971f, 
    -0.03978517f, 0.11416909f, -0.24687046f, 0.17991814f, 0.07960822f, -0.06162651f, -0.16283639f, 0.22881030f, 
    0.00026264f, 0.10206168f, 0.02382462f, -0.10766519f, -0.05463075f, 0.01113856f, 0.00402020f, 0.02959992f, 
    -0.04453321f, 0.01250298f, -0.07805938f, 0.01051722f, 0.02557900f, 0.07154471f, 0.19792914f, -0.00799895f, 
    0.08638876f, 0.09173071f, 0.18869485f, 0.00288640f, 0.12558326f, 0.16071944f, 0.16329546f, -0.08150108f, 
    0.19509041f, -0.11012647f, -0.05490090f, 0.11420563f, -0.09619824f, -0.02657002f, 0.01850716f, 0.06108846f, 
    0.26915213f, 0.24365956f, -0.33071560f, -0.00641745f, 0.05340520f, 0.06730284f, 0.05564947f, 0.02212766f, 
    -0.07640930f, -0.10083713f, -0.08479669f, -0.02375661f, 0.23984186f, -0.19302459f, -0.30939665f, -0.12422679f, 
    0.13222839f, 0.16607565f, 0.03196102f, 0.03702276f, 0.01810907f, -0.04311742f, -0.07279499f, 0.02688978f, 
    -0.29109776f, -0.12853709f, 0.12677932f, -0.09172732f, 0.02278692f, 0.04698114f, -0.03900589f, -0.17363396f, 
    -0.15112968f, 0.13896529f, -0.05305553f, 0.17777145f, 0.12259278f, -0.08075229f, -0.15674789f, -0.03605586f, 
    0.17106377f, 0.03805501f, -0.17894763f, 0.15768541f, -0.12363251f, -0.05808583f, 0.08887724f, -0.05742573f, 
    0.12509909f, 0.13303569f, 0.15491208f, 0.06191752f, -0.04604992f, -0.07433351f, 0.13823287f, 0.03874448f, 
    0.02335264f, 0.11624313f, 0.21142484f, 0.17573854f, -0.13029934f, -0.20806977f, -0.08235013f, 0.06366724f, 
    0.16547912f, 0.09328596f, 0.01181237f, -0.04010519f, -0.08285344f, -0.02890638f, -0.03531210f, 0.04728655f, 
    -0.08813950f, 0.18946855f, -0.14061427f, 0.02535375f, 0.06132125f, -0.01533018f, 0.06889996f, 0.18295337f, 
    0.11399893f, 0.08555844f, 0.01533091f, 0.19375393f, 0.02935723f, 0.21840315f, -0.02704027f, -0.02115801f, 
    0.04841235f, -0.00124342f, 0.02607558f, -0.07021616f, 0.01265850f, 0.17195792f, -0.15029913f, 0.01077927f, 
    -0.23615116f, 0.08495113f, 0.13461934f, -0.31732413f, -0.13437417f, 0.03281011f, 0.06569383f, -0.01765339f, 
    0.02046211f, 0.04732684f, -0.03251245f, -0.08639329f, -0.03670743f, 0.02033236f, -0.04744071f, -0.04455472f, 
    -0.03986374f, -0.06050804f, -0.16652353f, -0.09719321f, -0.15462144f, -0.19687933f, -0.14263017f, -0.10192462f, 
    -0.23157850f, -0.02717561f, -0.05527436f, 0.10760128f, 0.07063633f, 0.09171763f, 0.02837565f, 0.01592832f, 
    0.01517759f, 0.12631759f, 0.06582445f, 0.15098406f, 0.14874028f, -0.34103715f, 0.24820325f, -0.01790747f, 
    -0.07618076f, -0.07544065f, 0.07133485f, 0.18312669f, -0.08896619f, -0.05796438f, -0.00351557f, -0.04604799f, 
    -0.10052496f, -0.04334562f, 0.09397317f, -0.13697356f, 0.07006644f, -0.01996006f, 0.00764139f, -0.06453660f, 
    -0.14694642f, -0.05190889f, 0.07777856f, -0.10454266f, 0.13598196f, 0.11828838f, -0.03264083f, 0.07075101f, 
    0.07826172f, -0.12393841f, -0.01624633f, -0.07028275f, 0.16375807f, 0.06401432f, 0.07342351f, 0.12395667f, 
    0.16506487f, 0.17319833f, -0.26207250f, -0.19052827f, 0.07266774f, 0.04989525f, 0.03490574f, -0.03120253f, 
    -0.12820399f, -0.03113683f, -0.22075602f, -0.10869946f, -0.03475279f, -0.09860065f, -0.03900642f, 0.10502382f, 
    -0.13464732f, 0.02494568f, -0.08630486f, 0.00712130f, 0.20314422f, 0.11183050f, 0.17496657f, 0.14685860f, 
    0.12423615f, -0.11200329f, 0.09703338f, -0.10449629f, 0.05575624f, 0.07824732f, 0.04468223f, -0.18757316f, 
    0.03229965f, 0.02946815f, -0.02100593f, -0.10176786f, -0.00994831f, -0.02554816f, 0.23199144f, -0.26787454f, 
    -0.05653623f, 0.02684218f, 0.07561472f, 0.08581878f, 0.05585903f, 0.01076993f, 0.25914320f, -0.02260222f, 
    0.11219481f, 0.23352832f, -0.26297912f, -0.05226276f, 0.03750405f, -0.14520793f, -0.05833986f, 0.13484690f, 
    0.03217546f, -0.22966297f, -0.06860283f, -0.11884052f, -0.17277481f, 0.04851766f, -0.15349573f, -0.14177884f, 
    -0.13642064f, 0.17508255f, 0.39121363f, 0.05185303f, 0.02231839f, 0.07071675f, 0.01264523f, 0.06125725f, 
    -0.02952579f, -0.05468307f, -0.04734730f, 0.02630479f, -0.06156150f, -0.05568861f, 0.04888913f, -0.00962514f, 
    0.01663532f, -0.05423217f, -0.05453321f, -0.05016481f, 0.02293059f, -0.01412453f, -0.07883973f, 0.01258067f, 
    -0.01097919f, 0.05957254f, 0.06452228f, 0.05260628f, -0.01857260f, 0.00608474f, -0.05525437f, 0.01700463f, 
    0.04449163f, -0.03042519f, 0.05295465f, -0.02620327f, -0.00267418f, -0.06613521f, -0.00416686f, -0.00643958f, 
    -0.05848387f, 0.04229860f, -0.01622121f, -0.04863888f, 0.06801707f, 0.04791953f, 0.02835260f, -0.04950710f, 
    -0.00428080f, -0.00334702f, 0.06605770f, -0.06307757f, 0.02143295f, -0.05963195f, 0.04958421f, -0.02708904f, 
    -0.01793103f, -0.03792636f, -0.05174216f, 0.02108643f, -0.01599670f, -0.01308436f, -0.03453878f, 0.01597711f, 
    0.00565748f, 0.02892456f, -0.06627390f, -0.02389948f, 0.02808942f, -0.01847114f, 0.04977500f, -0.03216258f, 
    -0.03787169f, -0.02004256f, 0.02225314f, -0.05023135f, 0.01180845f, -0.03672941f, -0.05856044f, 0.03633397f, 
    -0.03029664f, -0.04380807f, -0.01252347f, 0.00996871f, -0.02675002f, -0.06031050f, -0.06025213f, 0.04252611f, 
    0.04554183f, -0.02084687f, 0.01501714f, -0.03415863f, 0.03434896f, -0.03155370f, -0.01227363f, -0.05022598f, 
    0.05442773f, -0.07224265f, -0.04437062f, 0.05342400f, -0.04218742f, -0.04958285f, 0.00873325f, -0.05923047f, 
    -0.01096150f, -0.06210773f, -0.00467718f, 0.05240580f, -0.02358172f, -0.04091405f, 0.01330399f, -0.00405431f, 
    0.04059745f, 0.03000818f, -0.03134683f, -0.06223896f, 0.05482943f, -0.06759574f, -0.03339396f, 0.01485344f, 
    -0.03400850f, -0.06158959f, 0.06911117f, -0.03048139f, -0.04215292f, -0.07803258f, -0.07208138f, -0.04960664f, 
    -0.07129134f, 0.00429685f, -0.05271829f, -0.01930035f, -0.00185161f, -0.06291386f, -0.01258863f, 0.04939549f, 
    -0.04549465f, -0.03899904f, -0.06161106f, 0.04366568f, -0.01301568f, -0.03280265f, -0.02589817f, 0.06588365f, 
    0.04479005f, -0.06450157f, 0.05075853f, -0.03283247f, 0.07421283f, -0.07487831f, 0.06951841f, -0.04539102f, 
    0.00538764f, 0.05514107f, -0.04145436f, -0.06987231f, -0.01529537f, 0.00444632f, 0.00047891f, 0.01730187f, 
    0.06056139f, -0.01061434f, 0.04513653f, 0.01819867f, -0.05899103f, -0.00085537f, -0.05257739f, -0.00788812f, 
    -0.06830662f, 0.02902912f, 0.00323982f, 0.00785738f, 0.05042129f, -0.04156418f, 0.02707770f, -0.00273951f, 
    0.03931429f, -0.00146792f, 0.03939987f, -0.05262395f, -0.01831195f, 0.02990903f, 0.02310826f, 0.06237666f, 
    0.04849435f, -0.02073325f, -0.02874257f, -0.03534616f, 0.06479936f, -0.01421477f, 0.04081252f, 0.06100763f, 
    0.06359255f, 0.05817677f, 0.03021079f, -0.02546887f, -0.00159466f, -0.03414813f, -0.06876389f, 0.06120690f, 
    -0.18505563f, 0.09359799f, 0.16784120f, 0.17832938f, 0.06803953f, 0.14663488f, -0.19651783f, -0.16314647f, 
    0.10952312f, 0.00776883f, 0.08798337f, -0.10043937f, 0.01449463f, 0.07736903f, 0.10650333f, 0.32812080f, 
    0.07318272f, 0.30271524f, 0.08754238f, 0.05535077f, 0.03655893f, -0.03079523f, -0.14381695f, -0.12655869f, 
    0.12862572f, 0.15333784f, 0.00746944f, 0.18667534f, -0.10576980f, -0.06662362f, -0.03731564f, 0.05448140f, 
    0.10462475f, 0.03154618f, -0.13827968f, 0.16616394f, -0.14985108f, -0.08738193f, -0.12221019f, 0.07026772f, 
    -0.03683867f, 0.03262268f, -0.03195301f, 0.03140749f, 0.03037165f, 0.10525100f, 0.10831439f, 0.01811152f, 
    -0.33655161f, -0.00766288f, 0.16267416f, 0.24317023f, 0.14047159f, -0.03933967f, 0.02742976f, -0.02012065f, 
    0.01310141f, 0.05220547f, 0.13149229f, 0.11072754f, -0.17743134f, -0.07141538f, -0.07057761f, 0.01870870f, 
    -0.03563588f, 0.05981065f, -0.02287280f, 0.00873541f, -0.02600762f, -0.09327082f, -0.04596844f, 0.02275082f, 
    -0.08793375f, -0.08400184f, 0.17991935f, -0.08233865f, 0.20338896f, 0.44310763f, -0.25645396f, -0.03479110f, 
    -0.01269939f, 0.02351684f, 0.04757454f, -0.01976093f, 0.08616767f, 0.10194816f, -0.16529950f, 0.06097836f, 
    0.12715875f, 0.02990776f, -0.14994852f, -0.05941943f, -0.05530929f, 0.07968722f, 0.04740086f, -0.01907352f, 
    -0.08794358f, -0.06654007f, -0.01290676f, 0.05215921f, 0.19804527f, 0.06888258f, -0.03545984f, 0.05799047f, 
    0.03501120f, 0.09866783f, 0.31607428f, -0.11491407f, -0.02703557f, 0.00695124f, 0.05231286f, 0.09406612f, 
    0.14460057f, 0.09887415f, -0.07731549f, 0.02392586f, 0.03559181f, 0.09894617f, 0.33582765f, 0.11117399f, 
    0.05325535f, 0.19706532f, 0.05563895f, -0.01468130f, -0.05900373f, 0.01979608f, -0.03738017f, -0.14491974f, 
    -0.09791838f, -0.02952688f, 0.01842632f, 0.07085186f, -0.14285249f, -0.13311999f, -0.09281542f, 0.06964856f, 
    0.06185514f, -0.01151248f, -0.00788246f, -0.04226973f, 0.12506731f, 0.14105763f, 0.10130946f, 0.13427287f, 
    -0.15754175f, 0.36038080f, -0.00453886f, 0.03648851f, -0.07138372f, 0.12658411f, -0.02467139f, -0.15398268f, 
    -0.12967226f, 0.11151737f, 0.18060766f, 0.07300702f, -0.52293932f, 0.08249415f, 0.27362269f, 0.16046548f, 
    0.29226840f, 0.02270187f, 0.02644353f, 0.03727396f, 0.15717100f, 0.02584478f, -0.00722033f, 0.02021623f, 
    0.08594198f, -0.04766356f, -0.29109696f, 0.08013065f, 0.02279384f, -0.13077690f, -0.11941276f, 0.15310952f, 
    0.06544935f, -0.10708978f, 0.09184425f, -0.13032511f, 0.14660351f, -0.02647637f, 0.24098511f, 0.01499712f, 
    0.05623371f, 0.07148285f, 0.10965218f, -0.04399284f, -0.02787428f, 0.00755117f, 0.11824652f, -0.06642777f, 
    0.08036306f, -0.18113856f, 0.06520634f, 0.23851125f, 0.08399000f, 0.02243841f, 0.13570555f, -0.04226976f, 
    0.02770959f, 0.15501539f, -0.01303844f, 0.10491311f, -0.03922892f, 0.17641656f, -0.08384957f, -0.04825633f, 
    -0.00797838f, -0.18943828f, 0.08793963f, -0.07299552f, -0.06015263f, -0.02915434f, 0.05999800f, 0.08039817f, 
    -0.14864667f, -0.05035954f, 0.22374006f, 0.20874947f, 0.13835707f, 0.12620373f, 0.15431069f, 0.16846053f, 
    -0.04434458f, 0.04049904f, 0.13398470f, 0.01275334f, -0.01219350f, 0.13257279f, 0.20806873f, -0.08153133f, 
    -0.04732438f, -0.11373310f, -0.03091205f, 0.02852919f, 0.03302058f, 0.05481538f, 0.08606456f, 0.05966144f, 
    0.09944328f, -0.25785500f, -0.26890743f, -0.18960379f, -0.13695572f, -0.04245972f, -0.06960065f, -0.04383739f, 
    -0.01817448f, -0.01196476f, -0.03820994f, -0.02042288f, 0.02261613f, 0.06687723f, -0.06104882f, -0.14407159f, 
    -0.07586326f, -0.11255655f, -0.09399585f, -0.05309911f, -0.13371028f, -0.09937617f, -0.03656947f, -0.18990369f, 
    0.27478603f, 0.06411948f, 0.36506793f, 0.06586543f, -0.03129141f, -0.23007287f, 0.04933174f, 0.10668465f, 
    -0.04470040f, -0.03448919f, 0.04788638f, 0.01737379f, 0.23434834f, 0.01574402f, -0.09915987f, -0.08291077f, 
    -0.05127382f, -0.05300665f, -0.00744516f, 0.02529083f, 0.01394233f, 0.00003215f, -0.01764972f, 0.12450294f, 
    0.20449901f, 0.27013692f, 0.09403080f, 0.10115943f, -0.11150874f, 0.03428467f, -0.08001477f, 0.03420061f, 
    -0.09143045f, 0.02519764f, -0.02008491f, 0.06579939f, 0.22269970f, -0.10775906f, 0.18899907f, 0.03830225f, 
    -0.04002219f, -0.00480289f, 0.02530306f, -0.05660892f, 0.00444876f, -0.01392815f, -0.05252199f, 0.07452383f, 
    -0.16376358f, 0.04930143f, 0.24344483f, 0.28808075f, 0.16326617f, 0.06203951f, 0.11668437f, 0.04586719f, 
    0.00704805f, 0.04796515f, -0.08758543f, 0.02044265f, 0.10320500f, 0.05553629f, -0.08352046f, -0.06386324f, 
    0.18594672f, -0.12552038f, 0.00038299f, -0.08792011f, 0.00164721f, 0.07746994f, -0.01944554f, 0.06628669f, 
    -0.11440384f, -0.13734487f, 0.41126689f, 0.07430719f, 0.03679610f, -0.00228208f, 0.00315547f, 0.10082345f, 
    -0.05256982f, -0.07113397f, -0.06792205f, -0.09627277f, 0.14347436f, -0.22042443f, -0.40684059f, -0.02116280f, 
    -0.17802724f, 0.04643238f, -0.04092816f, -0.05481445f, 0.10549248f, 0.14028829f, 0.05540045f, 0.13238643f, 
    -0.00524372f, -0.17733453f, -0.00264426f, -0.03022450f, -0.04527165f, -0.00153955f, 0.00782356f, -0.27960584f, 
    0.05624688f, 0.00140711f, -0.03906319f, 0.02386031f, -0.14603868f, -0.20197012f, -0.09016699f, 0.30220684f, 
    0.07300392f, 0.01513388f, 0.07763261f, 0.26510948f, 0.20079012f, 0.13657272f, 0.05901696f, 0.11276329f, 
    0.03441987f, 0.36148062f, 0.08986769f, -0.00431964f, 0.03398299f, 0.20668654f, 0.17295319f, -0.01389313f, 
    0.08499274f, 0.02756369f, -0.02031708f, -0.08676383f, 0.01798720f, 0.16276449f, 0.02533723f, -0.12235160f, 
    0.01870795f, -0.23024559f, -0.23227109f, 0.08003796f, 0.08303805f, 0.03881476f, -0.03259066f, -0.03068832f, 
    0.09126140f, 0.00689021f, 0.39720148f, 0.26281965f, 0.13354716f, -0.02960388f, 0.18386464f, 0.01585572f, 
    -0.03760089f, -0.03250091f, 0.12343487f, 0.03385689f, -0.47228327f, -0.41055551f, 0.00090744f, 0.03934068f, 
    -0.05709621f, 0.10832851f, -0.06221778f, -0.13412175f, 0.12666753f, 0.00540233f, -0.03981254f, 0.05547162f, 
    -0.01332755f, 0.09327372f, -0.10293476f, 0.17695627f, 0.11192039f, -0.26613459f, 0.04093368f, 0.22637445f, 
    -0.04385750f, 0.01815066f, -0.04064213f, 0.03684586f, -0.23104231f, -0.30383846f, -0.23290786f, -0.13219213f, 
    0.11547494f, -0.10607399f, -0.09814069f, 0.00255345f, -0.02498624f, 0.00014359f, -0.03928549f, 0.06493316f, 
    -0.08289424f, -0.10534076f, -0.10574598f, -0.13551834f, 0.05843057f, 0.07646349f, -0.08670917f, 0.03893928f, 
    -0.07035019f, -0.07676926f, -0.01073840f, -0.09508090f, 0.15494464f, 0.17959896f, -0.12188336f, 0.36337477f, 
    0.24404451f, 0.08877959f, -0.14620292f, 0.08007025f, 0.11503319f, 0.01323352f, 0.01201069f, -0.00360445f, 
    -0.25535730f, -0.35278237f, 0.08189006f, 0.05164043f, 0.00464899f, 0.04520332f, -0.05941019f, -0.03574383f, 
    0.06339438f, -0.09744280f, -0.02851086f, 0.21414118f, 0.05157299f, 0.05794977f, 0.28039902f, -0.02245892f, 
    -0.08766805f, 0.13408607f, -0.11835360f, -0.05559788f, 0.00477699f, -0.00234513f, 0.08594795f, -0.06358860f, 
    -0.07702202f, 0.07730124f, 0.13914396f, -0.01711364f, 0.11733416f, 0.01092577f, -0.05795096f, -0.09806556f, 
    0.05535284f, -0.17530623f, -0.01162368f, 0.16168475f, -0.27920523f, -0.26026377f, -0.09074867f, -0.28401268f, 
    -0.00422568f, -0.09764223f, -0.04852705f, 0.15196358f, -0.04491363f, -0.02358297f, -0.00483596f, 0.01883370f, 
    -0.17431988f, 0.23489183f, 0.23589751f, -0.04626554f, 0.01125479f, 0.01462215f, 0.07470965f, 0.17983502f, 
    0.11048089f, 0.07674548f, -0.02878291f, 0.09929749f, 0.07618987f, 0.00261885f, 0.01301905f, 0.21341468f, 
    0.03057980f, 0.02884532f, 0.01590579f, 0.15804844f, 0.09626651f, -0.01087427f, -0.17192872f, 0.05148748f, 
    -0.15083568f, 0.00661251f, 0.03987383f, 0.09373686f, 0.07848147f, 0.06506856f, -0.14872447f, -0.05286067f, 
    0.15974334f, 0.04775256f, -0.07016744f, 0.19059293f, 0.01738187f, 0.21491922f, 0.23818880f, 0.24723685f, 
    0.13252151f, 0.05661818f, 0.00947755f, 0.10775571f, 0.02602722f, -0.06830083f, -0.05878437f, -0.13765652f, 
    0.03609746f, -0.04627883f, -0.03789936f, -0.00988977f, 0.02744249f, -0.01935172f, -0.02963359f, -0.05462432f, 
    -0.06460755f, -0.04874495f, -0.05852516f, -0.07630496f, 0.00202012f, 0.02419852f, -0.00367708f, -0.04884810f, 
    -0.02044108f, 0.00217957f, -0.00689814f, -0.04501235f, -0.03280019f, 0.04823159f, -0.05324330f, 0.01843736f, 
    -0.02575621f, 0.00562533f, 0.00419966f, 0.04029298f, -0.00724333f, -0.01074863f, 0.03428303f, -0.06431554f, 
    0.04837203f, 0.03560578f, -0.00083594f, 0.01188766f, -0.06561255f, 0.00873093f, -0.06953730f, -0.06123943f, 
    -0.05188842f, 0.02136407f, -0.07323363f, -0.07169892f, 0.01290369f, -0.03278555f, 0.00290813f, -0.07385485f, 
    -0.06468248f, -0.02694751f, -0.04838094f, -0.04546631f, -0.00172673f, 0.04209597f, 0.05664323f, -0.04323123f, 
    0.06030376f, -0.07305760f, 0.03562903f, -0.00012513f, -0.02093313f, -0.00988893f, -0.04559619f, 0.02672286f, 
    -0.03751810f, -0.00327939f, -0.00544246f, -0.05653262f, 0.01285742f, -0.02454836f, -0.00172954f, -0.01036163f, 
    -0.03140762f, -0.02507968f, -0.06137320f, 0.06015236f, -0.05659883f, 0.03688610f, -0.06227081f, 0.02865418f, 
    -0.04395130f, -0.04996591f, 0.03418348f, 0.00360454f, -0.02038085f, -0.02772477f, 0.00826353f, 0.01818591f, 
    0.04996366f, -0.06079132f, -0.06807815f, 0.01797587f, -0.05245364f, -0.03071199f, -0.02119792f, -0.06343395f, 
    0.01380858f, 0.00296569f, -0.00178101f, -0.05290367f, -0.01343996f, -0.00735715f, 0.01538595f, -0.04167857f, 
    0.03576563f, 0.06012137f, -0.03541649f, -0.05905062f, -0.00837107f, -0.07968948f, -0.02586404f, -0.01485849f, 
    0.03509096f, 0.02932726f, -0.04116832f, -0.06526320f, 0.05632138f, 0.03467808f, 0.03020500f, 0.02471032f, 
    -0.06605790f, -0.07611693f, -0.05887904f, -0.00530242f, -0.06105877f, -0.01382905f, 0.01276685f, -0.06511937f, 
    -0.04376109f, -0.05336796f, -0.01710674f, 0.05535444f, -0.07428500f, 0.02582587f, -0.00045713f, 0.04265717f, 
    0.04565295f, 0.02384412f, -0.04803735f, 0.00257220f, 0.03744805f, -0.01722658f, -0.06723919f, 0.03066002f, 
    0.05672002f, -0.06785432f, 0.01476586f, -0.01259056f, -0.01596892f, 0.05797108f, -0.02497871f, -0.04884701f, 
    -0.01388363f, -0.07598178f, 0.03128861f, 0.03342384f, 0.01044967f, -0.02561587f, 0.05975011f, -0.01984862f, 
    -0.00542284f, -0.00666424f, -0.02843821f, -0.07198828f, -0.02739860f, 0.05191852f, -0.00193337f, -0.07038029f, 
    -0.04470112f, 0.02168296f, 0.00448514f, -0.05772033f, -0.00956068f, -0.03460329f, -0.01087658f, -0.06602821f, 
    -0.07446659f, 0.05656094f, -0.00748445f, 0.02108396f, -0.00204668f, -0.04631821f, 0.02283335f, -0.04859319f, 
    0.02740074f, 0.01890536f, 0.05423016f, -0.02165352f, 0.04670938f, -0.07048789f, -0.00523859f, -0.03304084f, 
    -0.07551730f, -0.08523700f, -0.06311613f, 0.24046245f, 0.03622068f, 0.15780845f, 0.06057052f, -0.10113910f, 
    -0.01950949f, 0.23401000f, -0.11623069f, 0.15335496f, 0.10299541f, 0.17989789f, 0.06099046f, 0.04965959f, 
    -0.18064776f, -0.04728329f, 0.02943290f, -0.05651020f, 0.02399186f, 0.05530534f, 0.02884899f, -0.02332219f, 
    -0.16440690f, -0.06021701f, -0.07539763f, -0.05817194f, 0.10639007f, 0.04184733f, -0.08461187f, 0.10098268f, 
    0.12482566f, 0.13536701f, -0.02500628f, 0.11468208f, 0.05464797f, 0.16120595f, 0.13844925f, 0.05550667f, 
    -0.03435724f, -0.01449168f, -0.07478321f, 0.00040915f, 0.10392843f, 0.03658116f, 0.17279799f, 0.10610928f, 
    0.21448903f, -0.17257348f, -0.28852814f, -0.31292549f, -0.01334602f, 0.04881123f, 0.08165722f, -0.05871920f, 
    0.11963138f, 0.07318173f, 0.24087828f, 0.01156464f, -0.02734413f, 0.02774214f, 0.04860898f, -0.14690106f, 
    0.02099828f, -0.02595727f, -0.01139669f, 0.02998050f, 0.01722831f, 0.08318583f, 0.05103200f, -0.05606752f, 
    -0.05718094f, 0.23357756f, 0.10537040f, 0.08347580f, -0.10265399f, 0.03194141f, -0.03138307f, 0.13615978f, 
    0.09497943f, 0.03796119f, 0.10447391f, 0.06998858f, -0.21900526f, 0.05438292f, -0.18981569f, 0.12861675f, 
    -0.16854854f, 0.04205016f, 0.13000321f, 0.06226347f, -0.07911076f, 0.03064097f, 0.06538370f, -0.01804998f, 
    0.02595328f, 0.19543165f, 0.07230908f, -0.01228825f, -0.04017658f, 0.12072907f, 0.01678428f, 0.03421722f, 
    -0.01558376f, 0.01302019f, 0.24009526f, 0.00690770f, -0.39333135f, -0.29005283f, -0.27067521f, 0.14074041f, 
    -0.17475492f, 0.08578253f, 0.11216291f, -0.05560294f, 0.03468692f, 0.05622335f, 0.20358682f, 0.02842903f, 
    0.03569952f, -0.13414653f, 0.10116974f, -0.13590258f, 0.05435133f, -0.00075571f, 0.05840810f, 0.03338675f, 
    -0.00040436f, 0.10274802f, 0.02518769f, 0.09238591f, 0.10856196f, 0.17062017f, 0.10397994f, 0.01183171f, 
    -0.06467953f, -0.07773162f, -0.00146944f, -0.09384020f, -0.04709844f, 0.01807270f, -0.03065227f, -0.01112758f, 
    0.01934536f, 0.15045337f, -0.28273904f, -0.11476575f, 0.03359411f, -0.01372509f, 0.04830233f, -0.04778153f, 
    -0.16443472f, -0.06168834f, -0.05808380f, -0.13616613f, 0.25342551f, -0.24521773f, -0.28791171f, -0.31684667f, 
    -0.03394785f, -0.02058129f, 0.03509693f, 0.05074475f, 0.02667767f, 0.11118682f, 0.10130335f, -0.04740073f, 
    -0.01769943f, -0.33755964f, -0.05466969f, 0.07263908f, 0.08118897f, -0.00005778f, 0.12052175f, 0.08765928f, 
    -0.09393916f, -0.15870132f, -0.01569008f, -0.08078778f, -0.04652024f, -0.24858847f, -0.03576772f, -0.19490243f, 
    0.02968271f, -0.17505555f, -0.02548525f, 0.11707068f, 0.17389275f, 0.04566140f, -0.01041419f, 0.14016832f, 
    0.24521627f, 0.22466004f, 0.13318825f, 0.23269328f, 0.11640356f, 0.10633849f, 0.18188615f, 0.12885623f, 
    0.02070065f, -0.00101355f, 0.04443263f, 0.07507379f, 0.17126295f, 0.19511168f, -0.06430493f, -0.07253832f, 
    -0.11906049f, -0.19295631f, -0.02634021f, -0.00565340f, -0.00738509f, -0.06158573f, 0.05839782f, -0.02415651f, 
    0.10010148f, 0.15900405f, 0.34026754f, 0.12843354f, 0.11226768f, -0.02120162f, 0.08197482f, -0.01482813f, 
    -0.00991972f, -0.05617950f, 0.16333699f, -0.05201125f, -0.22383139f, -0.24306510f, -0.00555504f, -0.04917971f, 
    -0.07841729f, -0.10907789f, -0.03054805f, -0.07824961f, -0.11351253f, 0.03392430f, -0.03838392f, -0.04453970f, 
    -0.02286424f, -0.05176499f, -0.17493734f, 0.01039480f, -0.06222812f, -0.06134341f, -0.06942664f, -0.04492510f, 
    0.06761350f, 0.08384074f, -0.03792174f, -0.02772635f, -0.20769575f, -0.14163052f, -0.11496910f, -0.12396264f, 
    0.00036436f, 0.00876406f, -0.02160027f, -0.05441054f, -0.15253475f, -0.08616366f, -0.01876499f, -0.04981364f, 
    0.11030123f, -0.17745547f, -0.29797193f, 0.00061029f, -0.10763587f, 0.11110073f, -0.02373558f, 0.10503899f, 
    -0.02870918f, 0.14002055f, 0.07464679f, -0.07631648f, -0.17095222f, -0.26486692f, -0.01916325f, -0.03036828f, 
    0.13073866f, 0.05235418f, -0.01623619f, 0.03645190f, 0.10638451f, -0.07137731f, 0.03766124f, -0.08343622f, 
    -0.02892656f, -0.00173922f, -0.06103176f, -0.04986454f, -0.17733605f, -0.07948924f, -0.03498146f, 0.00024618f, 
    0.04873746f, -0.08787155f, 0.29500812f, 0.07255063f, 0.15821387f, 0.10959483f, 0.00830957f, -0.15317714f, 
    -0.05440608f, 0.18406586f, -0.04745812f, 0.05300632f, 0.16739041f, 0.02581604f, 0.11577114f, 0.02681417f, 
    0.27785659f, 0.21323094f, 0.04996326f, 0.05646468f, -0.04378089f, -0.12653477f, -0.04868835f, -0.01626644f, 
    0.04494627f, -0.11693128f, -0.00637440f, -0.04962540f, -0.13813651f, -0.10252248f, -0.01124358f, -0.02932637f, 
    0.16937527f, 0.03107112f, 0.09144765f, 0.07581627f, 0.08431100f, 0.12736486f, 0.07704922f, 0.06254949f, 
    0.11305295f, 0.19881411f, 0.18766046f, 0.20379017f, 0.07720570f, -0.12264465f, 0.11408083f, 0.13976076f, 
    -0.02563246f, -0.07465042f, 0.01244703f, 0.05227622f, 0.04865592f, -0.06250305f, -0.17657323f, 0.03316623f, 
    0.07083549f, 0.05712508f, 0.10783418f, 0.02767030f, 0.05536258f, 0.18053831f, 0.11933357f, 0.12680176f, 
    -0.04560881f, 0.01810571f, 0.10296631f, -0.20818642f, 0.08597390f, 0.03622859f, -0.09905310f, -0.05604634f, 
    0.02820123f, 0.04801305f, -0.03457055f, 0.05047812f, 0.03524601f, 0.23403588f, 0.15618378f, 0.20656826f, 
    0.08554537f, 0.15504944f, -0.03804683f, -0.01264044f, -0.10853540f, -0.22014347f, -0.22536352f, -0.18026313f, 
    0.15699282f, 0.26085669f, 0.04466674f, 0.00495643f, -0.05556079f, 0.06105524f, 0.03825078f, 0.05906988f, 
    -0.08840707f, -0.03215294f, -0.01664530f, -0.08625481f, 0.14268167f, -0.10330311f, -0.12788123f, -0.01837999f, 
    -0.05261281f, 0.10580323f, 0.06644841f, 0.24483967f, 0.06741895f, -0.06691182f, 0.06808974f, -0.05261337f, 
    0.17252843f, 0.13157140f, 0.07497057f, 0.19543836f, 0.03126762f, -0.00869130f, 0.08605972f, -0.05485581f, 
    0.02577053f, 0.00147807f, 0.03344848f, -0.07649203f, -0.15132296f, -0.30377665f, -0.16832948f, 0.15747692f, 
    -0.02929717f, 0.06929839f, 0.02310019f, -0.13460375f, -0.09060408f, -0.14331929f, -0.02892645f, 0.10675355f, 
    0.26467127f, 0.16833194f, -0.07122371f, 0.09362856f, -0.03813468f, -0.05221743f, -0.04714552f, -0.05460314f, 
    0.07003129f, 0.07832921f, -0.05952445f, -0.06690862f, -0.04453184f, -0.06482553f, 0.05857358f, 0.16272579f, 
    0.01234260f, 0.01141418f, 0.03602561f, -0.04086219f, -0.02119258f, -0.07357280f, -0.00025863f, 0.17017671f, 
    -0.09176993f, -0.01977224f, -0.53562140f, 0.19734064f, 0.00785143f, 0.04743157f, 0.17673171f, 0.05928941f, 
    -0.08795428f, -0.08208732f, -0.16810925f, -0.11500988f, -0.11094522f, -0.05688260f, -0.10170134f, 0.10613476f, 
    0.12108121f, -0.04262779f, 0.05571396f, -0.00138077f, 0.03120549f, 0.04858518f, -0.01791971f, 0.08959432f, 
    -0.19497803f, -0.22376487f, -0.00523081f, -0.03309752f, -0.03023228f, 0.06167970f, 0.04207399f, 0.06749003f, 
    -0.06561591f, 0.05614291f, 0.07844011f, -0.03828137f, 0.25257400f, -0.23062907f, -0.03360376f, -0.19767661f, 
    -0.07076934f, 0.11522782f, 0.03440316f, 0.01935685f, 0.07075324f, 0.05544110f, 0.03718020f, -0.06598178f, 
    0.24564621f, 0.23436363f, -0.01007656f, -0.05873762f, -0.01226522f, 0.02145796f, 0.02749986f, 0.06034658f, 
    0.01326330f, -0.00589274f, 0.06750440f, 0.11181296f, -0.21796824f, -0.16626211f, 0.12511089f, -0.07849902f, 
    0.12672256f, 0.18006074f, -0.00770261f, -0.11644256f, -0.14179358f, -0.09194874f, 0.00750595f, 0.05961024f, 
    0.25121388f, 0.17571469f, 0.01381625f, 0.08012899f, 0.02058629f, 0.07168712f, 0.03832041f, 0.19841444f, 
    0.09425625f, 0.10479836f, 0.12690009f, 0.13737410f, 0.32461247f, 0.06802694f, -0.18791132f, 0.04613777f, 
    0.03175017f, 0.12819423f, 0.03687823f, 0.05303600f, -0.00057531f, -0.03818868f, -0.03761502f, -0.06409882f, 
    -0.15453452f, -0.05844687f, 0.21222268f, -0.07198531f, 0.13105038f, 0.10041013f, 0.00403460f, 0.03590750f, 
    0.10155713f, 0.08470604f, -0.04053750f, 0.12714323f, 0.14810763f, 0.28849429f, 0.02712862f, 0.08619878f, 
    0.08504117f, 0.11220883f, 0.03374267f, -0.04652728f, -0.02742459f, -0.06798712f, -0.06201891f, -0.09388663f, 
    0.20429473f, 0.10044909f, -0.05714621f, -0.12356233f, -0.06730492f, 0.11682415f, 0.00381619f, 0.00023603f, 
    -0.15461144f, -0.19555143f, -0.01218049f, -0.15556693f, 0.20051488f, -0.07279275f, 0.03673473f, -0.02332187f, 
    -0.03126451f, -0.01797801f, 0.02555769f, 0.11909740f, 0.09906010f, -0.07619914f, -0.02669180f, -0.00517205f, 
    0.17487025f, 0.09515930f, 0.20345479f, 0.17188412f, -0.02399312f, 0.08166090f, 0.04326855f, -0.03347646f, 
    -0.12658431f, -0.16370325f, 0.05522257f, -0.13715385f, -0.34147948f, -0.11815795f, -0.08334597f, 0.22114657f, 
    0.17346494f, 0.07317288f, 0.03356509f, -0.01851451f, 0.00182502f, -0.09503901f, 0.07470438f, 0.14815660f, 
    0.23272508f, 0.15756480f, 0.06703685f, 0.33614999f, 0.05281505f, -0.07379758f, -0.02052229f, -0.02990319f, 
    0.01904323f, 0.02879243f, 0.01390358f, 0.06163478f, -0.16125591f, -0.02788063f, -0.01280104f, 0.19783574f, 
    0.12171059f, 0.08730011f, 0.13268264f, -0.03623883f, -0.05634606f, 0.07411489f, -0.01140170f, 0.20380810f, 
    -0.15848620f, 0.07799651f, -0.35908741f, 0.10164923f, -0.00252721f, -0.03360350f, 0.05076054f, -0.06250715f, 
    -0.01012697f, -0.08480746f, -0.08286408f, -0.25618121f, -0.20056233f, 0.22161515f, -0.02747325f, 0.13437195f, 
    0.11917251f, -0.11477801f, -0.18497559f, 0.06224313f, 0.02237583f, 0.04489865f, -0.07616263f, -0.04633697f, 
    -0.16350795f, -0.13982993f, 0.04795680f, -0.07848708f, -0.05393728f, 0.00703171f, -0.11095893f, 0.04977468f, 
    0.06631266f, 0.04034720f, -0.09979373f, 0.09663916f, 0.18406908f, -0.00481478f, 0.39100593f, -0.19233786f, 
    -0.10116634f, 0.08838946f, -0.12342959f, -0.05510032f, -0.01021225f, 0.01915498f, -0.11513182f, -0.06002457f, 
    0.11416067f, 0.11149328f, -0.05204198f, -0.03739554f, -0.06237518f, -0.03188166f, 0.03030798f, 0.15104339f, 
    -0.02066880f, 0.01506525f, 0.03910786f, 0.09236046f, -0.00854802f, -0.02116752f, 0.08927276f, -0.15686016f, 
    0.20363601f, 0.07587888f, 0.00844403f, 0.01293174f, -0.08642543f, -0.06858829f, -0.07804033f, -0.07190251f, 
    0.03410669f, 0.06369456f, 0.12667918f, 0.02862974f, -0.04768810f, -0.04684297f, -0.01655897f, 0.20984322f, 
    0.14307433f, 0.05896661f, 0.06231027f, 0.03340858f, 0.20744210f, 0.12533401f, -0.05919042f, 0.31325305f, 
    0.07102083f, 0.18032742f, 0.04858388f, 0.01151522f, -0.01042496f, -0.03067639f, -0.05365499f, 0.03762491f, 
    -0.13451108f, 0.01056574f, 0.27015495f, -0.04875974f, 0.09141371f, 0.05828362f, -0.01138702f, -0.16015893f, 
    0.08152331f, 0.11738445f, -0.01055509f, 0.11161817f, 0.16823412f, 0.26792341f, 0.16163884f, 0.04881372f, 
    0.13627598f, 0.13787425f, 0.01361507f, 0.02613271f, -0.03872211f, -0.08201724f, 0.01263705f, -0.03501441f, 
    -0.04458995f, 0.03804304f, -0.04760138f, 0.22671407f, 0.11138717f, 0.05733962f, 0.17600824f, 0.14985661f, 
    0.06472699f, 0.08343700f, -0.07028634f, 0.06965381f, -0.13239567f, 0.28547230f, 0.02079359f, -0.13252333f, 
    0.06853981f, -0.11077277f, 0.02134551f, 0.00400754f, -0.08121256f, -0.11546131f, -0.01685589f, -0.02546338f, 
    -0.05698130f, 0.08992835f, 0.05189002f, -0.09688292f, 0.08855125f, 0.12197238f, 0.05243751f, 0.08550655f, 
    0.06547598f, -0.09546576f, -0.04071610f, 0.00394993f, 0.16062756f, 0.00703141f, 0.24731793f, 0.03299487f, 
    -0.01872812f, -0.02036438f, 0.04564403f, -0.08315659f, 0.01546942f, 0.08131565f, 0.06047351f, -0.07641856f, 
    -0.21569578f, 0.06493106f, -0.31005546f, -0.19455995f, 0.01417847f, 0.00583444f, -0.07553624f, -0.12385964f, 
    -0.03069150f, 0.10610335f, 0.05862653f, -0.02099727f, -0.05969231f, -0.01029330f, 0.08846368f, -0.10275816f, 
    -0.10191111f, 0.06155103f, -0.06937567f, -0.03048309f, -0.01073668f, -0.08205833f, -0.06661786f, -0.19040613f, 
    0.31131637f, -0.11608984f, 0.24451092f, 0.11250672f, -0.04323179f, 0.20510480f, -0.07571668f, 0.15595333f, 
    -0.15625165f, 0.08535629f, 0.02625106f, -0.02064393f, 0.21607950f, -0.33429611f, 0.25784153f, -0.06030940f, 
    -0.12346689f, -0.07146315f, -0.01597781f, 0.00671604f, 0.01181425f, 0.08653616f, 0.10956024f, -0.08518192f, 
    0.06628166f, 0.23431952f, -0.04242035f, 0.24532819f, -0.13537247f, 0.00151487f, 0.03674845f, 0.14283694f, 
    -0.14636485f, 0.06186689f, 0.11451305f, 0.15217815f, -0.04352323f, 0.16860786f, -0.23361258f, 0.08871517f, 
    -0.08948059f, -0.03497495f, -0.15139031f, 0.14086238f, -0.06877031f, -0.12696011f, 0.09857718f, 0.05173344f, 
    0.00653690f, 0.26466757f, -0.08976118f, 0.10741185f, -0.00153789f, -0.03785584f, 0.06104472f, -0.06196073f, 
    0.00219289f, -0.06625117f, 0.05622811f, 0.14180034f, 0.03180295f, 0.08557488f, -0.05131865f, -0.00980436f, 
    0.07991602f, -0.00224133f, -0.00105369f, 0.05800506f, 0.03021819f, -0.07342206f, 0.07463536f, 0.04908269f, 
    0.11166704f, 0.19451858f, -0.19365789f, 0.16755109f, 0.14577216f, 0.01686616f, -0.00168559f, -0.19559248f, 
    -0.10891806f, 0.02187971f, 0.06633405f, 0.00671209f, -0.05056631f, -0.08665498f, -0.03504560f, -0.18882021f, 
    -0.06683196f, -0.00084773f, 0.13728698f, -0.03244992f, 0.04658765f, 0.11265381f, 0.08499773f, 0.02416680f, 
    -0.06397686f, -0.00118083f, -0.01762573f, -0.12212189f, -0.12151989f, -0.08719068f, -0.08862010f, 0.05440877f, 
    0.01117511f, -0.13461842f, -0.10338744f, 0.03313661f, -0.05922533f, -0.03112238f, -0.17790855f, -0.18041699f, 
    -0.04269709f, 0.05012741f, -0.07100565f, 0.08309916f, -0.06083605f, -0.01840974f, 0.11011039f, -0.13408314f, 
    0.04676188f, 0.10193934f, -0.05914240f, 0.14355254f, -0.04979754f, -0.00424613f, -0.01884132f, -0.01824688f, 
    -0.02862707f, 0.11760741f, 0.14377049f, 0.06707606f, -0.04287158f, 0.12593623f, 0.06749192f, 0.13254736f, 
    -0.00323899f, -0.01410189f, -0.07839999f, -0.02474413f, -0.06867296f, -0.07048193f, -0.07503251f, 0.09850168f, 
    -0.02648522f, -0.04603510f, -0.09567223f, 0.28576595f, 0.07062641f, 0.13314623f, 0.07030627f, 0.06913301f, 
    -0.06478558f, 0.05724644f, -0.11269885f, 0.09529211f, -0.09629777f, 0.10559929f, -0.03082078f, -0.00536931f, 
    -0.06339846f, -0.13307393f, -0.05504343f, 0.07888074f, 0.12835501f, 0.06543623f, -0.00661377f, 0.06164566f, 
    0.40324131f, 0.08713155f, -0.10066644f, -0.49258000f, -0.12000462f, 0.02821835f, 0.03910995f, -0.08625012f, 
    -0.13047841f, -0.01373527f, -0.11549602f, 0.06134457f, 0.04947006f, -0.00723155f, -0.00378286f, -0.05398760f, 
    -0.04489545f, -0.06450517f, -0.02836888f, -0.02272130f, 0.03750276f, 0.13312924f, 0.05357829f, -0.11426993f, 
    -0.09413780f, 0.27777585f, 0.16646968f, 0.29161578f, 0.09500455f, -0.29024133f, 0.23282173f, -0.12323391f, 
    0.11262331f, -0.06110093f, -0.04431023f, 0.01861949f, 0.70305234f, -0.02882232f, 0.06214113f, 0.31744322f, 
    0.01347916f, -0.13742225f, 0.08533254f, -0.01258417f, -0.03941559f, -0.14136113f, 0.00515589f, -0.00781827f, 
    0.03267970f, 0.04308328f, 0.21317057f, 0.01630780f, 0.02459716f, 0.00845681f, 0.08834956f, 0.07170506f, 
    -0.01801554f, 0.09595177f, -0.22102447f, 0.10422246f, -0.03272655f, 0.03278165f, -0.06172610f, 0.18838929f, 
    0.00793319f, -0.08136199f, 0.11753901f, -0.05297190f, 0.11019097f, -0.01277258f, 0.00767709f, 0.09263843f, 
    -0.11827317f, 0.17611763f, -0.02852144f, 0.12135664f, 0.07301842f, 0.11802343f, 0.02568407f, -0.00952162f, 
    0.00097206f, 0.14133036f, -0.06216861f, -0.02055265f, 0.19620489f, -0.07089619f, 0.03829176f, -0.15548797f, 
    -0.05262082f, -0.01608451f, -0.02431112f, -0.06626648f, -0.07437032f, -0.01967919f, -0.00963950f, 0.09381562f, 
    0.13261728f, -0.13618554f, 0.11969361f, 0.03209156f, 0.16907723f, -0.09247989f, -0.06360035f, 0.04826822f, 
    -0.11513084f, -0.10574868f, -0.03053575f, -0.07816269f, 0.51474172f, -0.10453208f, -0.07905281f, -0.19282141f, 
    -0.08029220f, 0.07430166f, 0.14148982f, 0.01433687f, 0.09071437f, 0.07176708f, -0.05539549f, 0.05327353f, 
    -0.28249741f, -0.17330092f, -0.01150639f, -0.13914293f, -0.01707426f, 0.02424615f, -0.16829905f, -0.00546503f, 
    -0.06541797f, -0.00035070f, -0.18137826f, 0.07423065f, 0.02410880f, -0.05937433f, -0.28092948f, 0.13195768f, 
    0.07972177f, 0.09938706f, 0.06692453f, 0.10455351f, -0.04820023f, 0.03613903f, -0.06464443f, 0.03579312f, 
    -0.06994933f, 0.01281693f, 0.02428479f, -0.07658291f, 0.01359625f, -0.01535830f, -0.04967887f, -0.05714523f, 
    -0.03563450f, -0.08203243f, -0.04082958f, -0.05849561f, -0.03738713f, 0.01562392f, -0.02028990f, -0.00296333f, 
    0.01525184f, -0.02963784f, 0.01111863f, -0.00085707f, -0.05711079f, -0.01986708f, 0.06716653f, 0.03908391f, 
    -0.06353609f, -0.07043896f, -0.04128180f, 0.04343013f, -0.07729862f, 0.00809870f, 0.06391674f, 0.01534861f, 
    0.01330590f, -0.07159276f, 0.01169875f, 0.04814544f, -0.08397665f, -0.07525408f, -0.04660159f, 0.01118346f, 
    0.03260818f, 0.03965829f, -0.00314087f, 0.03459864f, -0.03465466f, -0.02090923f, -0.02334861f, -0.06929195f, 
    0.02067846f, -0.01989191f, 0.03111594f, -0.01603612f, -0.05021930f, 0.00816085f, 0.04230651f, 0.06600863f, 
    0.00240623f, 0.01298792f, 0.00278234f, 0.04946195f, -0.05081920f, 0.03663648f, -0.02279860f, 0.00229885f, 
    -0.02217066f, 0.05125194f, 0.04960458f, 0.02629517f, -0.08084891f, 0.00879828f, -0.05622205f, 0.02563640f, 
    -0.05314955f, -0.02159870f, -0.00426352f, -0.06197609f, -0.02318482f, -0.02251001f, 0.04938021f, 0.03741300f, 
    -0.05070735f, -0.00672729f, 0.04060363f, -0.00787722f, 0.02067832f, -0.06488898f, -0.04908088f, -0.05711394f, 
    0.00399619f, 0.06855106f, -0.06968962f, -0.02064276f, -0.03516167f, 0.02519188f, -0.04530902f, -0.06907143f, 
    0.03005898f, -0.00049877f, -0.03459856f, 0.01068436f, -0.07870854f, -0.05950704f, 0.01316481f, 0.05845885f, 
    -0.05801753f, -0.06218491f, -0.06100977f, -0.08826764f, -0.01954734f, -0.05454341f, 0.00271627f, -0.01714827f, 
    -0.00517406f, -0.03520450f, -0.07777354f, -0.02874210f, 0.03130563f, -0.01605218f, -0.02334369f, 0.00215067f, 
    0.05452358f, 0.04646427f, -0.05719989f, 0.06840578f, -0.00128001f, -0.05245839f, 0.04688289f, -0.03298348f, 
    0.01945300f, 0.01960767f, 0.06196490f, -0.05504996f, 0.03993810f, -0.01245520f, -0.04254785f, -0.04540630f, 
    0.05522528f, 0.03527545f, -0.01549286f, -0.07583344f, -0.01949108f, -0.00486673f, -0.04912898f, 0.02902970f, 
    0.04816564f, -0.02379010f, 0.04304713f, 0.04126799f, -0.06477333f, -0.05797175f, -0.03129514f, 0.02063211f, 
    0.03639932f, -0.04156083f, -0.03056952f, 0.05671105f, 0.00185726f, -0.04089111f, 0.04070101f, 0.04490833f, 
    -0.04827729f, -0.03388380f, -0.01535134f, 0.01490860f, -0.00773145f, -0.06984647f, 0.00844972f, -0.02519155f, 
    -0.04795979f, 0.02349019f, 0.01587495f, -0.00770340f, 0.04045187f, -0.06244230f, 0.00205873f, -0.01761693f, 
    0.02289101f, 0.05642150f, -0.03441048f, -0.03129169f, 0.02931992f, -0.07739935f, -0.02595326f, 0.06249927f, 
    -0.03813240f, -0.00560596f, -0.03963468f, -0.01725569f, -0.05488372f, 0.02732668f, 0.06462670f, 0.01115213f, 
    0.17718504f, -0.02473118f, 0.10031787f, -0.02859886f, 0.11920001f, -0.03419217f, 0.20183137f, 0.01911199f, 
    -0.01466729f, -0.13119763f, -0.06144169f, 0.16825190f, -0.05706066f, -0.04165056f, -0.20664410f, 0.03355046f, 
    -0.25878698f, -0.21468242f, 0.14832582f, 0.13508847f, 0.05003517f, -0.01045539f, 0.03555733f, -0.07171160f, 
    -0.04017702f, 0.07628549f, 0.10796101f, -0.01954466f, -0.06810225f, -0.17837910f, -0.05830029f, -0.17135818f, 
    -0.16761377f, -0.17082162f, 0.12454044f, -0.28494760f, 0.05669424f, -0.02983111f, -0.00234568f, -0.02418801f, 
    0.10580875f, 0.09990437f, 0.08877507f, -0.03077909f, 0.08608505f, 0.10722393f, 0.02062013f, -0.10075506f, 
    -0.11154839f, -0.10816244f, -0.11663596f, 0.21047680f, -0.03354213f, 0.18622616f, 0.11446402f, 0.12495335f, 
    -0.05252774f, 0.07249542f, -0.23089756f, -0.05162999f, -0.00853525f, 0.04196031f, 0.01543526f, 0.09627865f, 
    0.03843745f, 0.02872159f, 0.04169107f, 0.14659683f, -0.02499975f, 0.02685330f, 0.07162212f, 0.03987795f, 
    0.46353456f, 0.05521869f, -0.15884663f, 0.09593204f, -0.22046769f, 0.05891578f, 0.13018963f, 0.04464268f, 
    0.05418053f, 0.11548679f, 0.01998669f, 0.11380377f, -0.29881841f, -0.08516034f, 0.13723417f, -0.35471034f, 
    0.01112084f, 0.16050315f, -0.15934743f, 0.02074473f, -0.00157658f, -0.07997617f, 0.01038090f, -0.10269701f, 
    0.27270240f, 0.14483790f, -0.23769455f, 0.06238362f, -0.11447851f, -0.05391558f, 0.01772737f, 0.05287339f, 
    0.30612212f, 0.31264907f, 0.04915511f, 0.02230372f, 0.29709512f, 0.23259701f, -0.07962298f, -0.01736092f, 
    -0.02067130f, 0.06043006f, -0.06506825f, 0.17499155f, -0.01744379f, 0.05165814f, -0.03506521f, -0.07089698f, 
    0.02278472f, -0.04069537f, 0.13180389f, 0.02769250f, 0.06399751f, -0.06004220f, 0.10482502f, -0.09443424f, 
    -0.07238812f, 0.13466756f, 0.12737596f, 0.05193030f, 0.13961031f, 0.23377509f, -0.03439686f, 0.09444771f, 
    0.20543100f, 0.09778993f, 0.03707328f, 0.04504772f, -0.01992569f, -0.08147057f, -0.08885569f, -0.04993922f, 
    -0.03417367f, 0.08505114f, 0.08747973f, 0.13468163f, -0.18382297f, -0.12833741f, -0.20105690f, -0.06869460f, 
    -0.11429840f, -0.06992892f, -0.13306655f, 0.04455227f, 0.01879205f, -0.04339585f, -0.12467311f, 0.02735157f, 
    0.06594093f, 0.17645478f, -0.00050719f, 0.00126505f, -0.09411216f, -0.01429241f, 0.02479732f, 0.13041662f, 
    -0.09461053f, 0.18865636f, 0.18969919f, -0.17706335f, 0.03674724f, 0.08681007f, -0.06752494f, 0.07058413f, 
    -0.03330601f, 0.07617857f, 0.09350236f, 0.14551425f, -0.10497435f, -0.01355766f, 0.07659612f, 0.01473601f, 
    0.06200765f, 0.11715887f, -0.26066059f, -0.12468435f, -0.16040544f, -0.19550386f, -0.03821223f, -0.15085703f, 
    0.02830100f, -0.08821308f, -0.05451749f, 0.15557450f, 0.01815492f, -0.03319822f, 0.18288428f, 0.07227170f, 
    -0.03524385f, 0.14161393f, 0.11604769f, 0.01908554f, -0.34264085f, 0.21610683f, -0.08936983f, -0.02660401f, 
    0.05559473f, -0.03451114f, 0.01577805f, -0.02895329f, -0.06653393f, 0.04501624f, -0.07701873f, 0.11058955f, 
    0.06787997f, -0.05790547f, -0.01730721f, -0.01670091f, 0.03598684f, 0.01016669f, 0.02285981f, 0.02748514f, 
    0.00896011f, 0.05120383f, 0.00596100f, 0.08186947f, -0.30822301f, 0.22934975f, 0.06425355f, -0.24243994f, 
    0.02457854f, -0.11158141f, -0.09776980f, 0.13846406f, 0.06124756f, 0.07267237f, 0.03411212f, 0.18928123f, 
    0.14540112f, 0.01136820f, -0.37929496f, -0.38875192f, -0.02090910f, 0.09395124f, 0.03460926f, 0.00730467f, 
    -0.02198303f, -0.06938848f, 0.08629999f, -0.01293056f, -0.19367334f, -0.08236244f, -0.05972654f, -0.29207784f, 
    -0.00062136f, -0.01985965f, -0.00852655f, -0.03832250f, -0.07167169f, 0.25954336f, 0.11211175f, -0.19739950f, 
    -0.43464553f, -0.28205416f, 0.51422870f, 0.06627583f, -0.09816810f, -0.09964545f, -0.06436256f, 0.05058309f, 
    0.04145539f, 0.12703130f, 0.07927316f, 0.20327136f, 0.26909944f, -0.25950512f, 0.28192598f, 0.27502322f, 
    0.04386242f, 0.02819300f, -0.07123142f, 0.02399837f, -0.15940376f, 0.09205568f, -0.01109659f, -0.04861113f, 
    -0.30727652f, 0.03150858f, -0.07567646f, 0.18705903f, -0.15902244f, -0.02593373f, 0.00176530f, 0.02444429f, 
    -0.13376434f, 0.12898095f, -0.16645405f, 0.02616395f, -0.02298571f, 0.23440954f, 0.15811330f, 0.33630472f, 
    0.02574850f, -0.00053571f, 0.10626347f, -0.02149305f, 0.00826817f, 0.13823679f, -0.01672298f, 0.16505776f, 
    -0.07898098f, -0.03167909f, -0.15611021f, 0.17476162f, 0.06124263f, -0.05481065f, 0.17611852f, 0.09000549f, 
    0.09004832f, -0.02630928f, 0.10133561f, -0.03308121f, 0.12575877f, 0.01317934f, -0.03130488f, -0.19230303f, 
    0.10329493f, -0.19181611f, 0.02364258f, -0.01471457f, 0.04322279f, 0.09831515f, 0.07854571f, 0.20634224f, 
    0.16889854f, -0.08477429f, -0.17528829f, 0.06505758f, 0.08207554f, 0.10727089f, 0.02764091f, -0.21949883f, 
    0.01151525f, -0.05076002f, -0.07435133f, -0.05679137f, 0.16724013f, -0.21598521f, -0.17343858f, 0.06342400f, 
    0.06945392f, 0.16693248f, 0.14939533f, -0.04735128f, -0.03931548f, 0.08329822f, 0.18898402f, 0.01286312f, 
    -0.27983549f, 0.00860586f, -0.05086954f, -0.00421621f, 0.01164313f, -0.05217036f, -0.09567609f, -0.07007781f, 
    -0.07060873f, 0.04493689f, -0.11093228f, 0.03096237f, 0.00722095f, -0.16055825f, -0.27470756f, -0.06601254f, 
    0.05907949f, -0.07012269f, 0.08208299f, 0.09500838f, 0.05273430f, 0.04621127f, 0.02538088f, 0.11477825f, 
    -0.14846344f, 0.10477296f, 0.14162126f, -0.11416221f, -0.01466002f, -0.13976882f, -0.12638885f, -0.10126816f, 
    0.01343452f, -0.16516879f, -0.05430936f, -0.00674074f, 0.16472070f, 0.00402695f, 0.26092014f, 0.09973929f, 
    0.07155321f, 0.00057000f, 0.03286655f, -0.02995379f, 0.04179343f, -0.02302771f, 0.08538526f, -0.02291940f, 
    0.01215174f, 0.06560536f, 0.04396896f, -0.01350533f, 0.02460943f, -0.06225259f, 0.00260302f, 0.01923199f, 
    -0.04703477f, -0.06664134f, -0.06366728f, -0.08880392f, 0.23974006f, -0.12537460f, -0.03549929f, -0.05330696f, 
    -0.14048962f, 0.09273931f, 0.06104764f, 0.08514642f, 0.08118807f, -0.01438264f, 0.03376568f, -0.08362195f, 
    -0.16879375f, 0.01504775f, 0.08553841f, 0.07283549f, 0.08159138f, -0.14704183f, -0.06101966f, 0.06914903f, 
    0.07710969f, 0.04601173f, 0.05803081f, 0.11339499f, -0.04515560f, -0.11622202f, -0.05129668f, -0.13087605f, 
    -0.07130336f, -0.06072529f, -0.03044393f, 0.03901602f, 0.19937909f, 0.03914103f, 0.07265861f, 0.06142216f, 
    0.28999326f, 0.10259813f, 0.16816072f, -0.35295418f, 0.21567403f, -0.06999421f, -0.12334944f, 0.03962277f, 
    -0.08564173f, -0.08107904f, -0.02891732f, -0.02551471f, 0.12211929f, 0.27450135f, -0.01013840f, -0.06312324f, 
    -0.04739925f, 0.10685244f, 0.10511513f, -0.07113016f, 0.12886094f, 0.06131123f, 0.03853696f, 0.16417131f, 
    0.19416973f, -0.02984023f, 0.00339699f, -0.06694383f, 0.15682714f, 0.05757719f, 0.09934612f, -0.01570583f, 
    0.12352734f, -0.05576426f, 0.21988904f, 0.03349514f, -0.31609452f, -0.06379615f, 0.01965155f, 0.06456310f, 
    0.05735000f, -0.03918344f, 0.06173589f, 0.02772926f, -0.08865745f, -0.11067162f, 0.13500372f, 0.05858671f, 
    -0.27988470f, -0.24527887f, 0.27553806f, -0.00272647f, 0.03214509f, 0.02854561f, -0.04473500f, -0.01101728f, 
    0.12928031f, 0.08934537f, 0.09645493f, 0.12038667f, -0.15177579f, -0.04858193f, -0.11584277f, -0.04002484f, 
    0.01714314f, 0.04266398f, 0.00372150f, 0.10408873f, -0.04197377f, -0.06309025f, -0.09328663f, -0.17260768f, 
    -0.33194825f, -0.10548082f, 0.14582147f, 0.03408201f, -0.04102637f, -0.10231876f, 0.00759262f, 0.08972098f, 
    0.00335182f, 0.08163720f, -0.01415830f, 0.01262461f, -0.02760427f, 0.20172945f, 0.42495051f, 0.17345956f, 
    -0.06180697f, -0.13685504f, -0.13669398f, 0.10234415f, 0.10531440f, -0.02129889f, -0.00993760f, -0.08882299f, 
    0.21661296f, -0.04215110f, -0.18378031f, 0.07914006f, 0.01407934f, 0.13609433f, 0.14314201f, 0.06941657f, 
    0.12020034f, -0.06372130f, 0.19535282f, -0.05104906f, -0.16068423f, -0.13459159f, 0.22363462f, 0.11490522f, 
    -0.00294604f, -0.10227586f, 0.05954718f, 0.02384948f, 0.08375344f, -0.10555208f, -0.07872797f, 0.08415326f, 
    -0.21042338f, -0.04856812f, 0.06519177f, 0.20124343f, 0.14972289f, 0.21355605f, 0.07553153f, -0.08255716f, 
    0.07812321f, 0.16991366f, -0.02744765f, 0.07434522f, -0.02932110f, 0.41495135f, 0.13825388f, 0.06745372f, 
    0.02251577f, 0.02286588f, 0.08439422f, 0.08990517f, 0.03886175f, -0.03857856f, -0.01870406f, -0.03132384f, 
    -0.15031356f, -0.14658737f, 0.04778422f, 0.12737486f, 0.13981467f, 0.20524588f, 0.12913714f, 0.07171577f, 
    0.04817005f, 0.10015091f, -0.11137556f, 0.12129860f, -0.09559650f, 0.08058684f, 0.21424615f, -0.05107415f, 
    -0.12047511f, -0.14564334f, -0.07102125f, -0.05540060f, 0.14799593f, -0.10400952f, -0.00063458f, 0.00779923f, 
    0.16152295f, -0.02071103f, -0.21344090f, -0.19119777f, -0.01341249f, -0.15120983f, 0.02472896f, 0.03275415f, 
    -0.03445754f, 0.04084768f, 0.13537762f, -0.00498749f, 0.00054874f, -0.07804456f, -0.01653766f, -0.28228274f, 
    -0.15071951f, -0.14045128f, -0.02381080f, -0.01231562f, -0.05067311f, 0.00306487f, 0.02646562f, -0.03332730f, 
    -0.07528555f, 0.06474980f, 0.56255859f, 0.04434677f, 0.15606691f, 0.10820363f, -0.14438052f, 0.06304643f, 
    0.01458404f, -0.03153935f, 0.15408824f, -0.03085315f, 0.49381745f, 0.10832584f, -0.00276424f, 0.24816151f, 
    -0.02568541f, -0.09093968f, -0.10521349f, 0.01721616f, -0.03691290f, 0.01078402f, 0.10247886f, -0.07497606f, 
    -0.15713933f, 0.12981601f, 0.14398172f, 0.24357218f, 0.14796627f, -0.09551631f, 0.02682920f, 0.13191371f, 
    -0.04998569f, -0.01892445f, 0.01057082f, 0.09355701f, -0.45571411f, -0.00840164f, 0.01156260f, 0.25126937f, 
    -0.08054934f, -0.04632848f, -0.07462157f, -0.15976617f, -0.00869524f, -0.07117882f, 0.16096491f, 0.18913054f, 
    -0.12474721f, 0.14683428f, 0.12666939f, 0.06847508f, -0.02773478f, 0.03851759f, 0.00032227f, -0.03497713f, 
    0.07068449f, -0.05015980f, 0.12011869f, -0.00747690f, 0.11968124f, -0.17182785f, -0.11130179f, -0.06995164f, 
    0.00104813f, -0.13638876f, -0.11060427f, 0.06862270f, 0.04511743f, -0.09903726f, 0.03052665f, 0.02470477f, 
    -0.28153446f, 0.09806696f, 0.16065036f, -0.07452247f, 0.12950654f, -0.05551151f, 0.09129124f, -0.08718760f, 
    -0.05745170f, 0.02356651f, -0.01397699f, 0.02603633f, -0.00669954f, -0.20067123f, -0.11999376f, -0.14430627f, 
    -0.00740280f, 0.01552381f, -0.08592679f, 0.11283763f, 0.24693114f, 0.07224443f, 0.01720980f, 0.17131554f, 
    0.00080484f, -0.03976276f, -0.14087936f, 0.09996971f, -0.01165313f, 0.03596399f, -0.02060616f, -0.01230789f, 
    0.07155053f, -0.12295943f, 0.06283616f, -0.06751990f, -0.15928763f, -0.19830354f, -0.10745438f, 0.07686128f, 
    0.05876484f, 0.05562373f, -0.01981729f, 0.12981234f, 0.06927206f, -0.06041112f, 0.07510171f, -0.00118071f, 
    0.03974957f, -0.10666472f, 0.01361704f, -0.11582772f, 0.03945781f, -0.20043568f, 0.05516221f, 0.19980434f, 
    -0.06817701f, 0.00967001f, 0.02041549f, -0.12741657f, -0.18608253f, 0.15442152f, -0.12077219f, -0.19445327f, 
    0.11257908f, -0.12329342f, -0.09251374f, -0.07221036f, -0.05501511f, -0.02582247f, 0.11781149f, 0.07300381f, 
    -0.12413778f, -0.04250404f, 0.09562220f, -0.09669539f, 0.03227877f, 0.02730132f, 0.09301738f, -0.15658401f, 
    -0.11572011f, -0.21213715f, 0.02722653f, -0.20114382f, 0.35419062f, 0.09898153f, 0.21323736f, -0.09639835f, 
    0.00617586f, 0.04696937f, 0.02860297f, 0.04772896f, -0.17752650f, 0.08024022f, 0.13710746f, 0.04790779f, 
    -0.00785195f, -0.05592687f, 0.03947118f, 0.06537145f, -0.08776534f, 0.10218599f, 0.02399905f, 0.13031437f, 
    0.00607522f, 0.02233586f, 0.01750641f, -0.01778902f, 0.05198451f, 0.09475770f, 0.08696850f, -0.06556240f, 
    -0.17772315f, -0.04293055f, -0.10241786f, -0.05137319f, 0.08780584f, 0.17912003f, 0.11585690f, 0.03294370f, 
    0.40309095f, -0.21448044f, 0.38881579f, 0.09917981f, 0.03819669f, -0.28938800f, -0.06418766f, 0.09687506f, 
    -0.13638583f, 0.04905415f, 0.06240553f, -0.00073412f, 0.41005918f, -0.20010795f, 0.26045409f, -0.21130414f, 
    -0.03503825f, 0.07000589f, -0.05246031f, -0.00352368f, 0.10262249f, 0.18580045f, 0.03483944f, 0.08660851f, 
    0.16958973f, 0.08161096f, -0.09454092f, 0.19349791f, -0.15788983f, 0.09076249f, 0.00390416f, -0.00965683f, 
    -0.01902731f, -0.00710135f, -0.16541678f, 0.15376988f, 0.33515105f, 0.40360591f, 0.11347764f, 0.19919901f, 
    -0.01787662f, -0.10781008f, 0.03094091f, 0.03426922f, -0.02092101f, -0.03553836f, -0.14553688f, 0.04474391f, 
    -0.20966971f, -0.06862835f, 0.00879111f, 0.21735190f, 0.07152174f, 0.02581969f, 0.08463935f, 0.08843772f, 
    -0.00025346f, 0.04265062f, 0.03316263f, 0.02911632f, -0.09003767f, 0.14801662f, -0.02887201f, -0.13396172f, 
    0.19571118f, -0.20417792f, 0.10894693f, -0.04074016f, -0.07620364f, -0.06974721f, -0.18862121f, -0.00661852f, 
    0.09697712f, -0.31406242f, 0.11466166f, 0.10768324f, 0.00083297f, -0.03394955f, 0.03153432f, -0.04730670f, 
    0.07715481f, -0.06197855f, 0.05671135f, -0.02091288f, 0.13194424f, 0.01848129f, 0.20241466f, 0.21412793f, 
    -0.22884689f, 0.00381020f, 0.02116289f, 0.04895044f, -0.07421508f, 0.10041702f, 0.12174883f, 0.04820995f, 
    -0.16644534f, 0.29842746f, 0.06282593f, -0.09938330f, -0.14969553f, 0.21287493f, 0.07407719f, -0.14533962f, 
    0.11987113f, 0.24384011f, -0.02893518f, 0.23076482f, -0.13276978f, -0.03132125f, -0.15072647f, 0.17023891f, 
    -0.06575198f, -0.00845676f, -0.12783121f, -0.01964045f, 0.02482222f, 0.16363579f, 0.22470671f, -0.11724461f, 
    -0.03811638f, 0.21064578f, 0.04567822f, 0.10493450f, -0.05358612f, -0.04921297f, -0.08283942f, -0.06182421f, 
    0.06706325f, 0.12843022f, -0.04898098f, -0.04782837f, -0.01098360f, -0.07790048f, 0.14869638f, 0.21425231f, 
    0.03005237f, 0.15955120f, 0.10513421f, -0.15098172f, -0.01930430f, 0.00082689f, -0.11507145f, -0.05808217f, 
    -0.00867661f, 0.24035069f, -0.18750861f, -0.01228984f, -0.09335967f, 0.02175619f, -0.12764871f, 0.02077847f, 
    0.16993883f, 0.15251999f, -0.11259510f, 0.08921608f, 0.07895851f, 0.09591316f, -0.01966239f, -0.13385849f, 
    -0.08167720f, -0.05048342f, 0.08538177f, 0.02394256f, -0.13379113f, -0.04075099f, 0.02155978f, -0.03224850f, 
    -0.28799555f, 0.12400528f, 0.04641206f, -0.08554533f, -0.00839969f, 0.03284749f, -0.06079971f, -0.09007100f, 
    -0.02833236f, 0.09172772f, 0.05280935f, 0.15474553f, -0.06614492f, 0.04477913f, -0.04544265f, -0.17020878f, 
    -0.11747975f, -0.00589664f, -0.03171895f, 0.02256217f, 0.16143593f, 0.09033573f, -0.07139989f, 0.01098863f, 
    0.07406671f, -0.16918986f, 0.33237633f, -0.02989244f, -0.01470226f, 0.13900594f, -0.15427817f, 0.07153475f, 
    0.00634545f, -0.03114577f, 0.03926787f, -0.04999107f, 0.44777337f, -0.22226018f, 0.31288534f, -0.06708135f, 
    -0.09945300f, -0.08047821f, 0.09379797f, -0.00472805f, -0.03261742f, -0.05834239f, -0.06973937f, -0.05595028f, 
    0.05026078f, 0.29647946f, -0.01087237f, 0.24254861f, 0.09645598f, -0.05629711f, 0.12069973f, 0.14500961f, 
    -0.08697904f, -0.06358133f, 0.14629178f, 0.03237205f, -0.31002671f, 0.30098429f, -0.11360116f, 0.18530633f, 
    0.10733610f, -0.01731438f, -0.03279630f, 0.08811197f, -0.01383416f, 0.01276084f, -0.00661239f, 0.07337905f, 
    -0.02510275f, 0.20416442f, -0.11441590f, 0.15269941f, 0.05641847f, 0.10236886f, -0.16352047f, -0.11484038f, 
    -0.07288048f, 0.09905939f, 0.13417956f, 0.10133553f, -0.01526699f, -0.03295435f, -0.15861674f, 0.04311856f, 
    -0.09115764f, 0.00797458f, 0.10072712f, -0.08317801f, -0.02432982f, -0.02467817f, 0.04274185f, 0.08858144f, 
    -0.12315486f, -0.22925457f, -0.04155432f, 0.25234991f, -0.00076354f, 0.08647841f, -0.01544204f, -0.29296499f, 
    -0.17502618f, 0.06081767f, 0.09713414f, -0.01660924f, 0.14786580f, 0.01190335f, 0.46789479f, -0.15827696f, 
    -0.08354903f, 0.01177507f, 0.09809193f, 0.03653806f, 0.04447573f, -0.13574593f, 0.15433595f, 0.02623531f, 
    -0.03419529f, 0.06851245f, -0.28827509f, 0.06124005f, -0.01382169f, -0.08782689f, -0.08822794f, 0.18525334f, 
    -0.10292609f, -0.14121754f, 0.06635690f, -0.06092909f, -0.02701351f, -0.08423153f, -0.18421511f, 0.09436748f, 
    -0.12120343f, -0.07528096f, -0.00138072f, -0.06913953f, 0.02307546f, 0.05081708f, 0.12676576f, -0.06988402f, 
    0.34143505f, 0.04767036f, -0.13073900f, 0.01003295f, -0.06039906f, -0.01654011f, 0.22631861f, 0.13618761f, 
    -0.08860647f, 0.00705614f, 0.07108279f, 0.11996886f, 0.10848178f, -0.21210901f, -0.14725456f, -0.01317908f, 
    -0.06470481f, -0.09461833f, 0.01664967f, 0.09389208f, -0.08879918f, 0.08531442f, 0.02172196f, -0.03085482f, 
    -0.03606245f, 0.10252335f, -0.14386211f, 0.06426139f, -0.03893667f, 0.05552337f, 0.13602521f, 0.09280546f, 
    -0.08065627f, 0.07348379f, 0.11133330f, -0.06021765f, -0.01255621f, 0.13595438f, -0.08521799f, 0.02473995f, 
    0.06293643f, -0.01636610f, 0.07329427f, -0.07015242f, -0.15013844f, 0.07603243f, 0.11053185f, 0.22586508f, 
    0.02381681f, 0.10730363f, 0.10530002f, -0.05712379f, -0.15381622f, 0.04829617f, -0.01789187f, -0.07874351f, 
    -0.13378145f, 0.03536483f, -0.09765021f, -0.01085045f, -0.02459065f, 0.14222577f, 0.11889672f, -0.06237244f, 
    -0.05970594f, 0.01678810f, -0.07026070f, -0.11981530f, -0.03110239f, 0.08080093f, -0.03163571f, -0.05320972f, 
    0.12616247f, 0.09659010f, -0.27033743f, 0.34257460f, -0.19955827f, -0.13776645f, 0.08895315f, -0.00136337f, 
    0.08540122f, 0.04029440f, 0.00763071f, 0.18770836f, -0.24377978f, -0.41612279f, 0.30701700f, -0.18885249f, 
    -0.01701323f, -0.07978836f, 0.07268269f, 0.06016888f, -0.01531809f, 0.01814623f, -0.18377645f, -0.03393226f, 
    0.01947705f, 0.19447716f, 0.06460910f, 0.02202212f, -0.15714222f, 0.16107844f, -0.11460362f, -0.05108193f, 
    -0.21526949f, -0.01012157f, -0.00872489f, 0.05320396f, 0.40879768f, 0.09510911f, 0.07773138f, -0.18878403f, 
    -0.08924337f, -0.02039192f, -0.00368926f, 0.08231146f, -0.05135795f, 0.16180748f, -0.05050407f, -0.04967425f, 
    0.16477413f, 0.04230072f, -0.33470803f, 0.11614712f, 0.10473958f, 0.06260790f, 0.09034596f, 0.26992580f, 
    -0.09753707f, 0.12020194f, -0.15131283f, -0.05299782f, 0.03141107f, 0.17164692f, 0.15014037f, 0.07413203f, 
    0.13836843f, 0.00928178f, 0.02688645f, -0.05790853f, 0.06467213f, 0.00429957f, 0.11108653f, 0.03632883f, 
    0.34693989f, -0.32208166f, 0.03392806f, 0.07123805f, -0.01301234f, -0.01044787f, -0.16176209f, -0.03834552f, 
    0.03895633f, -0.16101949f, -0.11537345f, 0.02346235f, 0.35934740f, 0.01143823f, -0.11370569f, 0.00207969f, 
    -0.08524122f, 0.17472655f, 0.10142414f, -0.08166769f, -0.10048585f, 0.03728581f, 0.15366851f, 0.08741572f, 
    -0.37173891f, 0.13243292f, 0.20613638f, -0.27100834f, 0.14067057f, -0.24091320f, -0.20298548f, 0.02975073f, 
    -0.01214802f, 0.04432676f, -0.05299867f, 0.07764228f, -0.03322610f, 0.08803042f, -0.35538161f, -0.03256920f, 
    -0.02515430f, 0.13805020f, 0.10927489f, 0.01841772f, -0.09426406f, 0.05480218f, -0.07046601f, -0.06237626f, 
    0.05692310f, -0.01117074f, 0.17523088f, -0.23786645f, -0.07287879f, -0.16164207f, -0.02772086f, 0.20019172f, 
    -0.09610600f, -0.14445801f, 0.12181722f, -0.13495465f, 0.02088942f, -0.43582115f, -0.06828360f, -0.01699278f, 
    0.10238848f, 0.21436970f, -0.08889069f, -0.13752803f, 0.06706642f, -0.03566109f, 0.02634638f, -0.04217366f, 
    0.01167202f, -0.04447342f, 0.03120861f, -0.07655150f, 0.02467028f, -0.08166286f, -0.01487012f, 0.03848451f, 
    0.05057751f, -0.00065903f, -0.00745327f, -0.07552977f, 0.17063563f, -0.02598408f, -0.22925623f, -0.08138680f, 
    0.02964053f, 0.01355259f, 0.09491695f, 0.04523047f, -0.06992707f, -0.01604812f, -0.15073031f, 0.04544025f, 
    -0.13391878f, 0.09992198f, 0.36185312f, 0.37245846f, -0.10240521f, -0.13981180f, -0.04788876f, 0.00779729f, 
    0.23257093f, 0.09652466f, 0.03424843f, -0.00225798f, -0.02615092f, -0.03719594f, -0.01733621f, 0.23590980f, 
    0.02961281f, -0.00128360f, 0.01529775f, 0.00356794f, -0.00857969f, 0.06441776f, 0.12134518f, 0.14203085f, 
    -0.14135878f, -0.26346305f, -0.25286990f, -0.24458599f, 0.19197966f, 0.10062045f, 0.08609833f, -0.05540187f, 
    0.00571930f, -0.03696245f, -0.03957137f, -0.01262321f, -0.28394085f, 0.23928326f, 0.00484423f, -0.09568456f, 
    -0.00080269f, -0.07046741f, 0.05366847f, -0.01311237f, 0.16161320f, 0.10932420f, 0.01493237f, -0.01670834f, 
    0.06888754f, -0.30057821f, -0.00791154f, -0.16505694f, 0.05304529f, 0.09089276f, -0.00448143f, -0.08576159f, 
    0.14876968f, -0.01351558f, 0.11865887f, -0.00971257f, 0.16593193f, 0.10057909f, 0.21193232f, -0.02126196f, 
    -0.00031187f, -0.09229692f, 0.03750765f, -0.01879795f, 0.09317885f, 0.07309128f, 0.05776169f, -0.06000298f, 
    0.15331857f, -0.22679824f, -0.02370745f, -0.20336421f, -0.00423768f, 0.03509334f, -0.15019560f, -0.02008710f, 
    0.03125235f, 0.01285944f, -0.03851571f, -0.00830651f, -0.22290333f, -0.14853975f, -0.13946292f, 0.16849019f, 
    -0.03012712f, 0.09611095f, 0.08667983f, 0.08892161f, 0.07560324f, -0.02220156f, -0.05949352f, -0.03437295f, 
    -0.02078228f, -0.23848559f, 0.14501902f, -0.08375195f, -0.11863459f, 0.00625778f, 0.00033896f, 0.04948477f, 
    0.01617438f, 0.09291997f, -0.01290493f, -0.01865283f, -0.19229425f, 0.27222010f, 0.39136457f, 0.40149873f, 
    -0.01698815f, -0.14429195f, -0.00167798f, -0.05754846f, -0.05851711f, 0.03711081f, 0.15012322f, -0.00196863f, 
    0.31408092f, 0.33083266f, 0.05510139f, 0.02064353f, -0.03134459f, 0.01409292f, 0.04036688f, 0.04270596f, 
    0.11826629f, 0.20282830f, 0.14353530f, 0.09646583f, -0.08758186f, 0.19930589f, 0.12889281f, -0.06241232f, 
    -0.11070342f, -0.08103912f, 0.06758997f, -0.07593253f, -0.07470959f, 0.03049511f, 0.07378597f, 0.07716231f, 
    0.01636593f, -0.05018811f, -0.01246487f, -0.29372329f, -0.17963828f, -0.10095742f, 0.23983979f, -0.02439395f, 
    0.10098914f, 0.06048143f, 0.08131970f, 0.23360056f, 0.18900569f, -0.43288669f, 0.02673304f, 0.14397970f, 
    0.01485775f, 0.03494698f, 0.07536621f, 0.05077017f, 0.00678248f, -0.02140537f, 0.03323153f, 0.06644592f, 
    -0.22163165f, -0.20443361f, -0.25482985f, 0.02835093f, 0.12623209f, 0.09203131f, 0.15918376f, 0.18012586f, 
    -0.10961846f, 0.01955180f, 0.06709564f, 0.02769584f, 0.11842691f, -0.00532018f, -0.01344671f, 0.10114998f, 
    -0.01959735f, -0.10196859f, 0.02463485f, -0.03780097f, 0.11221655f, -0.05993584f, -0.02707259f, 0.02339015f, 
    0.16089019f, -0.02469277f, 0.40641350f, -0.11636762f, -0.01889666f, -0.02078380f, -0.02971647f, 0.08275563f, 
    0.07138281f, -0.14000072f, -0.13204378f, -0.08461363f, 0.10183059f, 0.02748307f, 0.08303580f, 0.22056057f, 
    -0.04297479f, -0.03020497f, 0.05597740f, 0.00950982f, 0.25058594f, -0.04450478f, -0.10052855f, 0.06607791f, 
    0.11878416f, 0.41719699f, -0.25885254f, 0.22056945f, -0.14516538f, -0.30597892f, 0.23272364f, -0.09129763f, 
    0.01964698f, -0.03449226f, -0.03188007f, 0.10907815f, -0.14798014f, 0.12543625f, -0.22151724f, 0.13687177f, 
    -0.13859183f, -0.06214687f, 0.21458733f, 0.08452667f, 0.03919556f, -0.07666694f, -0.07400167f, 0.19512005f, 
    0.08923112f, -0.07467189f, 0.08420404f, -0.10928866f, 0.08692297f, 0.11795481f, 0.02629881f, -0.16614589f, 
    -0.01495590f, 0.03598185f, -0.15201895f, 0.07679796f, 0.17191631f, -0.10654861f, 0.22346543f, -0.31836686f, 
    0.14401837f, -0.12100683f, -0.04495273f, -0.18173811f, 0.11777971f, 0.06403419f, -0.00733639f, -0.05720475f, 
    -0.05054593f, -0.18055812f, -0.01908211f, -0.09497029f, 0.16213310f, 0.16453646f, 0.17004392f, 0.19542813f, 
    -0.07557863f, 0.04478716f, -0.18557300f, -0.09054360f, 0.08846629f, -0.14725858f, 0.09090904f, 0.02980609f, 
    -0.13680059f, -0.00134187f, 0.07517593f, -0.06547127f, 0.08325806f, -0.05469133f, -0.00630862f, 0.12583514f, 
    -0.03819973f, -0.40521896f, 0.13987273f, -0.36423013f, 0.01044885f, -0.15811409f, -0.12751731f, 0.21309401f, 
    -0.02342101f, -0.09049719f, -0.02439430f, 0.07207611f, 0.33468771f, 0.06174201f, 0.13004875f, 0.09446570f, 
    -0.05036926f, -0.06515103f, -0.04604966f, 0.01817544f, 0.01107241f, 0.10989176f, -0.11956956f, 0.13381802f, 
    -0.09578595f, -0.01016759f, 0.11425727f, -0.15347911f, -0.01742657f, 0.02163150f, 0.07243772f, -0.08166558f, 
    -0.01501391f, -0.06147411f, -0.10937583f, 0.03070230f, -0.23254684f, -0.01161989f, -0.07290619f, -0.09448361f, 
    0.06334827f, 0.25017160f, 0.29092762f, 0.19250278f, -0.13325755f, -0.05839165f, -0.02417662f, -0.01708694f, 
    -0.11891275f, -0.17822562f, 0.08941626f, -0.14409196f, 0.15341866f, -0.02670640f, 0.22144385f, 0.15071775f, 
    0.12147713f, -0.04737885f, 0.13245785f, 0.06267152f, -0.30543458f, 0.31742403f, -0.07944652f, -0.18219145f, 
    0.03343826f, -0.10546049f, 0.03118697f, -0.00482485f, 0.02386821f, 0.00395252f, 0.00225505f, 0.01570852f, 
    -0.17048055f, -0.22700128f, 0.03620860f, -0.17438135f, 0.01453240f, -0.02992217f, 0.12295794f, -0.12632953f, 
    -0.05014275f, -0.01309094f, 0.04186298f, 0.14809656f, -0.06305480f, 0.14011285f, 0.20793013f, -0.06032519f, 
    0.04489505f, -0.08415470f, -0.04994904f, -0.07191406f, -0.01497377f, 0.03763344f, -0.00465456f, 0.13959521f, 
    0.01202858f, -0.00033330f, -0.03192604f, 0.14230572f, 0.00515213f, -0.07509509f, -0.02566222f, 0.15946911f, 
    -0.00106246f, -0.03419980f, 0.05630968f, -0.05572187f, -0.05056691f, -0.00982559f, -0.06526379f, -0.09857419f, 
    -0.09577125f, -0.16164824f, -0.09826370f, -0.03999732f, -0.06417984f, 0.09615441f, 0.14310788f, -0.03693010f, 
    0.03723766f, -0.38889015f, 0.60477012f, -0.06069126f, 0.02007205f, -0.13199441f, -0.07614598f, -0.08760378f, 
    -0.04386900f, -0.01798734f, 0.08165380f, 0.15831003f, 0.25058249f, 0.08033709f, 0.03854852f, 0.15324335f, 
    0.10944825f, -0.01821172f, -0.04852691f, 0.06399462f, 0.00757643f, 0.25767717f, 0.15554594f, 0.02638328f, 
    -0.26726770f, -0.07854726f, -0.13430083f, 0.17277728f, -0.10836723f, 0.06075692f, -0.17514886f, -0.09065458f, 
    0.12617576f, 0.02262187f, -0.29902434f, 0.13015164f, 0.09367247f, 0.38096473f, 0.34723726f, 0.06462602f, 
    -0.06758050f, -0.07035442f, -0.07185171f, -0.04507095f, 0.01786438f, 0.00354219f, -0.07657775f, 0.19621632f, 
    -0.17540646f, -0.24603452f, -0.10550574f, 0.03562994f, 0.12888782f, 0.04559443f, 0.09818273f, 0.04314816f, 
    0.11894587f, -0.03931107f, 0.06908515f, -0.06463796f, -0.07278787f, 0.02558804f, -0.17441283f, -0.10497584f, 
    0.04778648f, -0.26711622f, -0.02831728f, 0.09208792f, 0.15263565f, 0.08157633f, 0.02295934f, 0.03073618f, 
    -0.00418474f, -0.25506425f, 0.09967513f, -0.28981125f, 0.05804278f, 0.01147615f, -0.03835346f, -0.06439646f, 
    0.11455068f, 0.05977704f, -0.05065510f, 0.03548679f, -0.04759440f, 0.04458822f, 0.13579437f, 0.35519844f, 
    -0.06068677f, 0.04306406f, -0.03426537f, 0.04654106f, -0.00381980f, 0.04303322f, -0.06705632f, 0.22751187f, 
    -0.12101290f, 0.27466029f, -0.07249290f, 0.06214983f, -0.02892198f, 0.01773111f, 0.02379831f, -0.18901637f, 
    0.08621221f, 0.15307386f, -0.03305887f, 0.09205019f, -0.12603456f, -0.15283398f, -0.10464016f, 0.02500303f, 
    0.04739757f, -0.01266165f, 0.01826106f, 0.15298437f, -0.04715213f, 0.04286288f, 0.03990462f, 0.06730227f, 
    -0.05940478f, -0.00592815f, 0.09960901f, 0.07518220f, 0.01625125f, 0.00916787f, -0.15999952f, -0.07425686f, 
    -0.05175853f, -0.24828415f, 0.07722668f, -0.09325638f, 0.04713502f, -0.26703203f, 0.16550320f, 0.29781809f, 
    0.06236100f, 0.31535354f, 0.08615192f, -0.08308909f, 0.03789307f, -0.15029857f, -0.06141416f, 0.18715099f, 
    0.04356192f, -0.04228298f, -0.02653996f, 0.24589214f, 0.03952253f, 0.04313147f, -0.03301113f, 0.06576858f, 
    -0.09455717f, -0.08770368f, -0.14736934f, 0.02845769f, -0.10785966f, -0.04281176f, -0.15399081f, -0.02385288f, 
    -0.00750492f, -0.02251831f, -0.04212473f, 0.00986106f, 0.16045232f, -0.01351627f, -0.02356825f, 0.04192718f, 
    0.10481186f, 0.20433904f, 0.16270201f, -0.01107475f, -0.14249600f, -0.08307308f, 0.00232880f, 0.00856138f, 
    0.15308443f, 0.11268098f, 0.11196395f, 0.11941727f, 0.02383334f, -0.07305819f, -0.02659094f, -0.05238289f, 
    -0.00285794f, -0.09765072f, 0.21361859f, 0.14557813f, 0.07109635f, 0.23583250f, 0.11410511f, 0.13811111f, 
    -0.25567499f, 0.14058150f, 0.02372972f, -0.05996431f, 0.23077437f, -0.24773863f, 0.02173533f, -0.28711373f, 
    -0.11460382f, -0.13688725f, -0.08669116f, -0.19520892f, 0.23438570f, 0.41032404f, -0.16260089f, 0.13037103f, 
    0.00898915f, -0.08908430f, -0.01852771f, -0.15214264f, 0.07069027f, 0.08097552f, 0.14138779f, 0.09992941f, 
    0.09889149f, -0.12762032f, -0.05304008f, -0.14193732f, 0.14148036f, -0.00264745f, 0.12352357f, -0.10226614f, 
    0.15010314f, 0.01538163f, -0.08773004f, 0.00593346f, -0.18460451f, -0.19113763f, 0.14505681f, 0.15402612f, 
    0.03763618f, -0.17689462f, 0.14586584f, -0.07098480f, -0.08498730f, 0.14292198f, 0.02797562f, -0.06422932f, 
    0.00136155f, -0.00547551f, 0.19756402f, 0.14778873f, -0.06175437f, 0.13612390f, -0.13474078f, 0.00971517f, 
    0.06970646f, 0.16437067f, 0.07132837f, 0.10910744f, 0.02367372f, -0.11003337f, -0.02956727f, -0.02019318f, 
    -0.04722210f, 0.05681689f, 0.00250097f, -0.35330576f, -0.10879311f, -0.10090850f, -0.30676275f, -0.14236611f, 
    -0.25097287f, -0.15980257f, 0.11921291f, 0.00920559f, 0.03685176f, -0.02033900f, 0.02069971f, 0.18544403f, 
    0.08791235f, 0.12070348f, 0.06205311f, 0.13067311f, 0.15631853f, 0.25851908f, 0.02921731f, 0.05105933f, 
    -0.03028437f, -0.16303092f, -0.04280977f, -0.07147063f, 0.18713252f, 0.01437092f, -0.04964949f, 0.00389023f, 
    0.07483643f, -0.16873457f, -0.03353967f, 0.11973868f, -0.12809604f, 0.06965606f, 0.19567873f, -0.08310527f, 
    0.06734033f, 0.13253880f, 0.10377572f, -0.02410508f, 0.01292842f, -0.03681769f, 0.04038355f, 0.24533276f, 
    -0.01380595f, -0.21449541f, 0.08461537f, -0.06766020f, 0.18064302f, -0.01479573f, -0.04214265f, 0.17708211f, 
    -0.07376149f, -0.04584616f, -0.01710637f, 0.14259107f, 0.20756377f, 0.18176077f, 0.30024418f, 0.01292537f, 
    0.09089572f, 0.14072967f, 0.03904151f, -0.00025229f, -0.02579789f, 0.51256949f, -0.08531477f, -0.23763117f, 
    0.09350900f, -0.24150015f, -0.02198531f, 0.01479883f, -0.13996761f, -0.06001799f, -0.02118402f, -0.05379253f, 
    -0.08255308f, 0.06835157f, 0.14809495f, -0.12506004f, 0.04329294f, 0.10310024f, 0.16976553f, 0.01948679f, 
    0.01237570f, -0.06999159f, -0.01225275f, -0.05904633f, 0.09101876f, 0.05916013f, 0.28167668f, 0.17361091f, 
    0.05499399f, -0.03244043f, 0.06144044f, -0.07197403f, -0.03994602f, 0.01232209f, -0.07617181f, -0.03615205f, 
    -0.05773867f, -0.00000695f, -0.28252462f, -0.09038249f, -0.04128516f, -0.07683557f, -0.01463316f, -0.00640363f, 
    -0.11912342f, 0.12183467f, 0.01257396f, -0.00591392f, 0.09867501f, 0.03975957f, 0.10796027f, -0.01581129f, 
    -0.14612472f, -0.11086998f, -0.18585616f, -0.10654732f, -0.05918043f, -0.15396397f, -0.01246077f, -0.19074591f, 
    0.17683339f, -0.10252050f, 0.17974237f, 0.09424068f, -0.02157165f, 0.13585624f, -0.10954653f, 0.22434244f, 
    -0.01681293f, -0.02989358f, 0.01822454f, 0.04936534f, 0.03655071f, -0.28748155f, 0.18712686f, -0.00828879f, 
    0.00082426f, 0.06747857f, -0.03539499f, 0.09309365f, 0.00525536f, 0.03202058f, 0.11650807f, -0.13340087f, 
    -0.08163313f, 0.21585280f, -0.11126436f, 0.28991523f, -0.11691473f, 0.05326653f, -0.02800672f, 0.06202897f, 
    -0.11043611f, -0.06483083f, -0.01206462f, 0.18351257f, 0.20698312f, 0.17155381f, -0.08314177f, 0.07146872f, 
    -0.12972945f, -0.05710286f, -0.09490937f, 0.01172692f, 0.04323934f, -0.10866784f, 0.13335830f, 0.14879709f, 
    0.03193182f, 0.16850799f, -0.09060392f, 0.07092663f, 0.00524216f, 0.00751209f, 0.08940972f, -0.06156013f, 
    0.01920502f, -0.06336046f, 0.11535721f, 0.00921258f, -0.06644781f, -0.00899806f, 0.08891174f, 0.03300857f, 
    0.01372477f, -0.08606370f, -0.12725152f, -0.01295565f, -0.06580029f, -0.00397583f, 0.09638324f, 0.15010138f, 
    0.17707461f, 0.28781158f, -0.11685163f, -0.04957709f, 0.01367429f, 0.15919593f, 0.02328013f, -0.14401022f, 
    0.01914698f, -0.01968247f, 0.05535068f, 0.02054216f, -0.16335097f, -0.16381213f, -0.13141213f, -0.00854201f, 
    0.03280652f, 0.12551798f, 0.07142816f, 0.07371321f, 0.02023329f, -0.01977880f, 0.04626826f, 0.10487358f, 
    -0.00410908f, 0.09974054f, 0.10298761f, -0.00056087f, 0.07084725f, -0.09202936f, -0.14636353f, -0.06126640f, 
    -0.07293800f, -0.04736723f, 0.00748207f, 0.10392199f, -0.01516454f, 0.03231500f, -0.12950766f, -0.17095663f, 
    0.01919596f, 0.13661416f, -0.00821905f, 0.18248017f, -0.12723805f, 0.03471507f, 0.06142070f, -0.05540576f, 
    -0.05359101f, 0.05396274f, -0.02833403f, -0.07907210f, -0.07051737f, 0.05002723f, 0.03180575f, 0.03205213f, 
    -0.01135864f, -0.00654913f, -0.07259710f, 0.05330456f, 0.00728525f, -0.07208186f, -0.01861050f, 0.03286153f, 
    -0.06959376f, -0.03751053f, 0.02677712f, -0.07623170f, -0.04376202f, -0.07944957f, 0.05847960f, -0.00954436f, 
    0.04285025f, 0.05797866f, -0.03669283f, -0.02157429f, 0.05510303f, -0.04224937f, -0.04749215f, -0.02744209f, 
    -0.00579533f, -0.05789398f, -0.03086433f, 0.02527949f, -0.01158341f, 0.06817171f, 0.05015613f, -0.07760704f, 
    -0.04671574f, -0.08129843f, 0.05227814f, -0.04059619f, -0.04068949f, -0.05728795f, -0.01757293f, -0.03274058f, 
    -0.04481966f, -0.03882968f, -0.06574648f, -0.07339109f, 0.03979985f, 0.02652955f, -0.05243527f, -0.04135193f, 
    -0.06868049f, -0.02177843f, -0.03833323f, 0.03651583f, -0.06206268f, -0.06016825f, -0.04825717f, 0.00943131f, 
    0.02321706f, -0.05947838f, -0.02616956f, 0.03997459f, 0.00385376f, -0.06448939f, 0.03048646f, 0.04629237f, 
    -0.00335524f, -0.08781294f, -0.03181620f, -0.03435670f, -0.00632938f, 0.00601614f, -0.07731405f, -0.03692722f, 
    0.06089529f, 0.00994183f, -0.06806101f, 0.03733460f, 0.06627103f, -0.01718676f, 0.03154481f, -0.00483175f, 
    0.02272099f, 0.00511683f, -0.03320166f, -0.03977720f, 0.00644656f, 0.05317933f, -0.07827101f, 0.02097105f, 
    -0.01833126f, -0.00844569f, -0.02210583f, -0.00766488f, -0.01272142f, -0.01034417f, 0.01774394f, 0.04594412f, 
    0.00034839f, -0.00853996f, -0.08153280f, 0.03887147f, 0.03002045f, 0.01240152f, 0.05610048f, 0.06488793f, 
    -0.08329074f, 0.00185826f, 0.04796062f, -0.05319289f, 0.06332979f, -0.00662536f, -0.01405476f, -0.06855697f, 
    0.03009771f, -0.05167492f, -0.04939019f, 0.00375791f, 0.04396834f, -0.06909539f, 0.00872530f, 0.01890750f, 
    0.00084641f, -0.01032941f, 0.00258479f, 0.01512207f, 0.03356477f, -0.04708032f, -0.00131625f, -0.03977749f, 
    0.02643675f, 0.01765022f, -0.05006069f, -0.04216588f, -0.01100662f, -0.00857306f, 0.05607397f, -0.01427299f, 
    -0.06019966f, -0.07792555f, -0.00951054f, -0.05809449f, -0.01429250f, 0.05657029f, -0.01509326f, 0.06596087f, 
    0.03791715f, -0.04099669f, -0.02220019f, -0.02485654f, 0.04983921f, -0.07675429f, 0.05518622f, 0.00276707f, 
    0.04759949f, 0.04979482f, -0.07678600f, 0.05278762f, 0.00547764f, -0.03217213f, 0.04940952f, 0.00127490f, 
    -0.06517833f, 0.02472886f, -0.03016818f, 0.03322103f, -0.04774681f, -0.02794133f, -0.02367148f, -0.02938255f, 
    -0.02787990f, 0.04021306f, 0.04745130f, -0.04322786f, -0.00548420f, -0.00143318f, 0.02125769f, -0.01172027f, 
    0.05434565f, 0.03783319f, 0.00382819f, -0.02592934f, -0.00372053f, -0.07480562f, 0.03922621f, 0.05271642f, 
    0.15512814f, 0.07493062f, -0.03046964f, 0.19132641f, -0.00645104f, 0.03394182f, 0.17066488f, 0.07428758f, 
    -0.04855075f, 0.04439949f, 0.03079008f, 0.10820282f, -0.20631126f, 0.05791777f, -0.05396839f, -0.00177524f, 
    -0.12040155f, 0.01777369f, -0.12348855f, 0.03776862f, 0.01683103f, 0.04490574f, 0.04032199f, 0.11991647f, 
    0.18123408f, 0.08721710f, -0.08367711f, 0.02416920f, -0.03976185f, -0.08652543f, 0.07230179f, 0.00512934f, 
    -0.04796652f, 0.10954110f, 0.06048323f, 0.04430762f, -0.49035567f, -0.20469506f, 0.03704846f, -0.13490875f, 
    -0.05575408f, -0.00494052f, 0.04601212f, -0.01160371f, 0.04718971f, 0.14985967f, 0.11821721f, 0.09959628f, 
    0.04892951f, 0.19381270f, -0.14041646f, -0.32495034f, -0.04446793f, 0.01398962f, 0.03381190f, 0.02552366f, 
    -0.18811855f, -0.08156382f, 0.01677831f, -0.19647451f, -0.27515978f, -0.07948002f, -0.02358758f, -0.15516040f, 
    0.06429689f, 0.05450735f, -0.08176724f, 0.06320607f, -0.06202248f, 0.18266222f, 0.19111308f, -0.06244571f, 
    -0.50777960f, -0.22591344f, -0.08900073f, 0.23828003f, -0.15425999f, -0.05091698f, -0.00512251f, -0.05559489f, 
    0.01755870f, 0.00996119f, -0.00033965f, 0.18225910f, -0.06191134f, -0.25611836f, 0.13346145f, 0.23198661f, 
    -0.05109615f, 0.05300394f, -0.11690925f, -0.05214859f, -0.16805126f, 0.08053877f, 0.03414406f, 0.01898432f, 
    -0.26426512f, -0.19816172f, -0.06957475f, -0.01021258f, -0.17814736f, 0.09348688f, 0.12327585f, -0.10859235f, 
    -0.28188118f, 0.00550362f, 0.16954887f, 0.04823217f, 0.29396787f, -0.11301644f, -0.15794545f, 0.04953261f, 
    -0.04627873f, 0.03833089f, 0.07805026f, -0.15798658f, -0.03577131f, 0.16635139f, 0.05128538f, 0.13469307f, 
    0.09523078f, 0.01203684f, -0.24857755f, 0.07224706f, 0.00873013f, 0.08660534f, 0.14735049f, 0.17095251f, 
    0.04254153f, 0.02986477f, 0.01982898f, -0.08137282f, 0.05175982f, -0.04743606f, 0.09236971f, -0.01102868f, 
    -0.03585965f, -0.04935826f, -0.03475328f, 0.00703061f, 0.04198831f, 0.15619616f, 0.09257171f, 0.11333282f, 
    0.36233240f, 0.24602853f, -0.14477129f, -0.08496050f, 0.10500926f, 0.17530505f, 0.04040696f, -0.02029273f, 
    -0.00687237f, -0.07351813f, -0.02056992f, 0.10047927f, 0.12079985f, -0.02828711f, -0.16912650f, -0.17772362f, 
    0.10127498f, 0.14469221f, 0.09767563f, 0.02236709f, -0.12979057f, -0.01455864f, -0.02515513f, 0.00590669f, 
    -0.23837315f, -0.22305924f, 0.04119601f, -0.07460391f, 0.07865145f, -0.14822416f, 0.05350192f, 0.14630903f, 
    -0.03475633f, 0.02483667f, -0.12588808f, -0.00733177f, 0.20931208f, 0.15477405f, -0.15245354f, -0.09826255f, 
    0.03226638f, 0.09063385f, 0.00994452f, 0.17604437f, -0.01455788f, -0.11365206f, -0.04503239f, -0.00422435f, 
    0.05822000f, 0.05284614f, 0.13559279f, -0.16563089f, -0.01441269f, -0.14474669f, 0.12135781f, 0.18257734f, 
    -0.06173382f, -0.16213614f, 0.05488574f, -0.08422135f, -0.00684628f, -0.11265188f, -0.24399784f, -0.26326796f, 
    0.08673226f, -0.20309049f, -0.03409386f, 0.00227540f, 0.00442026f, 0.06711595f, 0.07924242f, 0.12244838f, 
    -0.07246499f, 0.03252867f, 0.23191747f, -0.02721581f, 0.09924102f, -0.08057626f, 0.15192384f, -0.01476588f, 
    -0.04910440f, -0.03503212f, 0.18214826f, -0.19829164f, 0.05738142f, -0.07471989f, -0.03380320f, -0.22165747f, 
    0.05888046f, 0.01201556f, -0.02752863f, 0.03162750f, -0.08761033f, 0.01335584f, -0.08318040f, -0.05647906f, 
    -0.18108526f, -0.00871552f, 0.20744076f, 0.22203545f, -0.16100642f, 0.01714329f, -0.01700133f, 0.15022419f, 
    0.08090089f, 0.13600321f, 0.00419282f, -0.07485830f, 0.05586144f, -0.06686015f, 0.02526000f, 0.20382339f, 
    0.07752140f, -0.02345070f, -0.05561588f, 0.04165894f, -0.14546548f, 0.03776587f, 0.03416280f, 0.04879782f, 
    -0.02547449f, -0.29835972f, -0.41432455f, -0.19999240f, 0.00943330f, -0.04524217f, -0.01726556f, 0.07101917f, 
    -0.05678201f, 0.00906658f, 0.12884668f, 0.03058423f, -0.17202836f, 0.04382597f, 0.01648519f, -0.22437587f, 
    0.12770823f, 0.07479025f, 0.01065946f, 0.09577158f, 0.07318725f, 0.12149905f, 0.08925842f, 0.03828805f, 
    0.10808250f, -0.30008680f, -0.11716665f, -0.21794274f, -0.14899969f, 0.07922813f, 0.04413516f, -0.13733682f, 
    0.07936649f, -0.06003223f, -0.10545480f, 0.04469058f, 0.40534729f, 0.15548225f, 0.18651170f, -0.15915574f, 
    -0.01934336f, 0.01398258f, -0.05044415f, 0.07420521f, 0.12009293f, 0.00198790f, -0.12071663f, -0.14073397f, 
    -0.00453757f, -0.20021336f, 0.04687219f, -0.11894278f, 0.05972554f, -0.07481162f, -0.01739150f, 0.08571371f, 
    -0.01930566f, -0.14270827f, -0.09582718f, 0.09822260f, -0.16442817f, 0.06613043f, -0.18748769f, 0.00139573f, 
    0.09457020f, 0.00249082f, 0.13949201f, 0.19597118f, 0.02370937f, -0.09588306f, 0.03063516f, -0.01993803f, 
    -0.00060827f, -0.04382667f, 0.22389707f, -0.05010445f, -0.03414961f, -0.04933749f, -0.01021355f, 0.11170149f, 
    0.09826763f, 0.04420492f, 0.02894181f, 0.03151722f, -0.25169069f, 0.16467150f, 0.11794416f, 0.27756652f, 
    -0.17333031f, -0.03861081f, -0.10149101f, -0.00049770f, -0.00026366f, 0.12090610f, 0.06547261f, 0.05439236f, 
    0.16983308f, 0.29093075f, 0.17201076f, -0.03601099f, -0.04382725f, 0.12204647f, 0.04138470f, -0.10623818f, 
    0.17452209f, 0.27885127f, 0.13317573f, 0.23664598f, -0.19033258f, 0.15291210f, 0.23656259f, 0.11848772f, 
    -0.02695078f, -0.05921006f, -0.01986861f, -0.04587768f, -0.06978188f, -0.08296449f, 0.00627437f, -0.03138752f, 
    -0.17469436f, -0.00546944f, 0.20198436f, 0.03402550f, 0.08714402f, -0.05813076f, -0.09634519f, 0.04975287f, 
    0.01077817f, 0.03347581f, -0.01531318f, -0.09997981f, -0.11568414f, 0.14923629f, 0.11785675f, -0.12439767f, 
    0.07268279f, -0.04573332f, -0.03790981f, -0.04532781f, 0.09385858f, 0.08524470f, 0.10281512f, 0.06088543f, 
    -0.13724381f, -0.15650764f, 0.17436583f, 0.00134370f, 0.04107355f, -0.03189133f, -0.00852634f, -0.05550925f, 
    0.09940822f, -0.05994318f, 0.05123080f, -0.05512077f, 0.18853268f, -0.08560923f, 0.16107066f, -0.09094603f, 
    -0.18474533f, -0.10607077f, -0.10513903f, -0.02604290f, -0.03075116f, -0.00981780f, 0.06103921f, -0.15243194f, 
    -0.04353194f, -0.16081239f, 0.01734968f, 0.01649736f, -0.00127554f, -0.04924627f, -0.04264613f, 0.05053651f, 
    -0.02880866f, 0.15431169f, 0.05433778f, -0.05168821f, 0.13146125f, -0.02342305f, -0.00219611f, -0.07717746f, 
    -0.02850620f, -0.06056170f, 0.00683003f, 0.05223726f, 0.15752411f, 0.08531589f, 0.09074254f, -0.07245123f, 
    0.21007738f, -0.13674785f, 0.37236691f, -0.27084881f, 0.04758283f, -0.02446725f, -0.10653920f, 0.04020471f, 
    0.00158647f, 0.02102787f, 0.06175247f, -0.07421558f, 0.45295539f, 0.16747406f, -0.00851205f, 0.00744512f, 
    0.00836261f, 0.06644616f, 0.08350199f, -0.04438461f, 0.09064768f, 0.04949271f, 0.10621230f, 0.07705018f, 
    0.32336187f, -0.03983424f, -0.05167925f, 0.20607656f, 0.04568964f, -0.08413485f, 0.11560416f, 0.03812371f, 
    0.18602337f, 0.10130508f, -0.04110141f, 0.01398701f, -0.08760658f, 0.19542198f, 0.04372549f, 0.11478191f, 
    -0.02445661f, 0.05080798f, 0.12100336f, 0.06954797f, 0.08740953f, 0.04074967f, -0.01843412f, 0.01244856f, 
    -0.29357004f, -0.08096854f, 0.21874063f, 0.11847398f, 0.10809963f, 0.07273164f, -0.15925543f, -0.18374386f, 
    -0.03189569f, 0.03401798f, 0.09343058f, 0.13602521f, -0.05284695f, 0.06774867f, -0.11516338f, -0.09962404f, 
    0.01922164f, -0.13066365f, 0.01386925f, 0.02509419f, -0.04656676f, -0.07565029f, -0.07182682f, -0.11220752f, 
    -0.39978573f, -0.15761632f, 0.14368850f, 0.11659809f, 0.00552985f, -0.01100067f, 0.07830792f, 0.01488978f, 
    -0.00957920f, -0.04162678f, 0.00146504f, -0.06897259f, 0.11541240f, 0.05737444f, 0.25316510f, 0.12538539f, 
    -0.01968148f, -0.19403698f, -0.08268629f, 0.12366581f, 0.11141909f, 0.06009351f, 0.01039620f, 0.00091757f, 
    0.17203759f, 0.15046448f, -0.17947462f, -0.00177423f, -0.07535509f, 0.20714630f, 0.08025002f, -0.04892135f, 
    0.05155323f, 0.12053353f, 0.10645280f, 0.17115353f, -0.16103387f, -0.15164776f, 0.12491857f, 0.15184617f, 
    -0.07164736f, -0.03655638f, -0.03324334f, 0.05207815f, -0.00920499f, 0.01960946f, 0.04852672f, 0.01528216f, 
    0.22253469f, 0.23172726f, -0.00513685f, 0.05613613f, -0.03806754f, 0.12113475f, 0.22834773f, 0.21810547f, 
    -0.03665290f, 0.09698658f, 0.07788512f, 0.10221245f, -0.15304512f, 0.11824220f, -0.15228817f, -0.17996946f, 
    0.15493405f, -0.09555043f, -0.09780633f, 0.05997253f, -0.08798722f, -0.04925217f, 0.00529036f, 0.02715379f, 
    -0.01932778f, 0.10699441f, 0.06426115f, 0.04823972f, 0.08066028f, 0.21195307f, 0.16120689f, 0.10952967f, 
    -0.04149610f, 0.07906451f, -0.04225860f, 0.06070483f, -0.44156453f, -0.11212426f, 0.03196685f, -0.07888075f, 
    -0.06198164f, 0.00428375f, 0.06377423f, -0.07448127f, -0.18192282f, 0.02824768f, -0.08595785f, 0.04318419f, 
    0.02875252f, 0.23422143f, 0.03604086f, -0.05786799f, -0.10234346f, -0.06563708f, 0.06920319f, 0.05214036f, 
    -0.03542966f, 0.10431665f, -0.00489505f, -0.03202480f, -0.09725649f, -0.05318492f, -0.05581491f, -0.02040416f, 
    -0.09829780f, -0.10411315f, -0.15975600f, -0.21800219f, -0.11118032f, -0.14885782f, -0.12710033f, 0.07401359f, 
    -0.21705915f, -0.27979580f, -0.23147205f, 0.33356151f, 0.04292905f, 0.09716885f, 0.18830653f, 0.01636038f, 
    -0.09403877f, 0.11818803f, 0.02572128f, 0.01300890f, 0.19052285f, -0.20794962f, 0.25698811f, 0.20776248f, 
    -0.05371322f, 0.00850609f, 0.01592392f, 0.00503792f, 0.01484400f, 0.02472016f, 0.14097580f, -0.13700102f, 
    -0.41658878f, -0.27055237f, 0.22843322f, 0.02950550f, -0.11689831f, -0.07961076f, -0.08846605f, -0.03739200f, 
    -0.21864076f, -0.12170101f, 0.06062024f, -0.04250320f, 0.10953360f, 0.14954403f, 0.03515669f, -0.02151449f, 
    -0.16461819f, 0.08325610f, -0.13790964f, -0.03913708f, 0.20155174f, 0.00957639f, -0.00623932f, 0.05202576f, 
    0.18307538f, 0.17325877f, -0.10121647f, -0.11313241f, 0.06639017f, 0.04147502f, 0.12071839f, 0.12635756f, 
    -0.01329483f, -0.05165947f, -0.13062821f, -0.01329228f, -0.09494180f, -0.07000814f, 0.03503857f, -0.17642358f, 
    -0.02614510f, -0.06934363f, 0.04894338f, 0.02700792f, 0.16697767f, 0.07808036f, 0.18220843f, 0.09177961f, 
    0.28435409f, 0.05798045f, 0.08031857f, -0.08213469f, 0.18860933f, 0.03717706f, 0.16132529f, -0.02890956f, 
    0.01074712f, -0.04445566f, -0.05014544f, 0.00556190f, 0.26565248f, -0.05807526f, 0.01477748f, -0.07790106f, 
    -0.03644944f, 0.07511763f, 0.18706149f, 0.13873298f, -0.02713039f, -0.00195274f, 0.10793916f, 0.06899722f, 
    -0.17063944f, 0.09494639f, 0.03144892f, -0.08835571f, -0.01210348f, 0.02005940f, -0.10594831f, 0.15867028f, 
    0.14521375f, -0.09176845f, -0.08744546f, 0.05109337f, 0.11481130f, 0.23942828f, -0.13367176f, -0.08802355f, 
    0.07608676f, 0.13062577f, -0.06297783f, 0.09460434f, -0.08290844f, -0.08256832f, -0.12186620f, -0.07472496f, 
    -0.13349065f, 0.14524768f, 0.00216090f, 0.23331597f, 0.01300950f, 0.24891730f, 0.15959166f, -0.14405267f, 
    0.10878417f, 0.26458856f, 0.01201099f, 0.17514625f, 0.22624335f, 0.07539936f, 0.04392587f, 0.05132303f, 
    0.13337661f, -0.10323171f, 0.02686315f, 0.05935458f, -0.02066784f, -0.00011371f, -0.05398446f, -0.12239318f, 
    0.03312394f, 0.00002680f, 0.06101705f, 0.03865078f, 0.21421161f, 0.16053547f, 0.10805752f, 0.14541413f, 
    0.07051255f, 0.12217587f, 0.07067018f, 0.23088205f, -0.03144796f, -0.06749044f, 0.00413293f, 0.11172841f, 
    0.03266191f, 0.06566430f, -0.00445981f, 0.05592879f, 0.10494735f, 0.06025127f, -0.06521975f, 0.00514045f, 
    -0.21436256f, -0.06257507f, -0.08047136f, -0.08567457f, -0.00997251f, -0.07042837f, 0.08186302f, 0.06636298f, 
    0.07981183f, 0.05588141f, 0.07290229f, 0.05983124f, -0.06451373f, 0.00158383f, 0.00229552f, 0.06565394f, 
    -0.07584804f, -0.08359400f, -0.12967925f, -0.11782537f, -0.23030899f, -0.29692683f, -0.15251365f, -0.17665191f, 
    0.16925839f, 0.06295337f, -0.12190827f, 0.05556869f, 0.03776116f, 0.20165956f, -0.01561586f, 0.10285220f, 
    0.06710445f, -0.05584665f, 0.14176083f, 0.11541898f, -0.12205656f, 0.02922913f, -0.29131439f, 0.00453656f, 
    -0.01782066f, 0.06104871f, -0.03968589f, 0.16050847f, 0.00255469f, 0.04572634f, 0.12263920f, 0.01877769f, 
    -0.03241776f, -0.04442874f, 0.07388482f, -0.06272968f, 0.25643790f, -0.05621226f, -0.14207719f, 0.12756893f, 
    -0.11675414f, -0.15854096f, 0.15352367f, 0.05977065f, -0.04078953f, -0.42002907f, 0.01928296f, -0.29478580f, 
    -0.05232560f, -0.00743529f, -0.23764212f, -0.15736140f, 0.03696291f, -0.17822914f, 0.06192757f, 0.07463130f, 
    -0.04001245f, 0.11332504f, -0.04736500f, -0.11838655f, -0.03148991f, -0.01220124f, -0.01364120f, -0.01006962f, 
    0.04415404f, -0.19740231f, -0.18319780f, -0.00832199f, -0.08011574f, -0.08583267f, 0.01889150f, 0.23497200f, 
    -0.24836686f, 0.01976893f, -0.06108382f, -0.01979630f, 0.06549338f, -0.00169067f, 0.20599221f, 0.18747836f, 
    -0.06010259f, 0.23867275f, 0.12198653f, -0.09715653f, -0.06661606f, 0.02017110f, 0.12363335f, 0.02533355f, 
    -0.05096718f, -0.04154046f, -0.05503604f, 0.01196104f, -0.51679373f, -0.24356820f, -0.14123803f, -0.11948808f, 
    -0.04875223f, 0.00264310f, 0.04517685f, 0.04298966f, 0.13239121f, 0.07970402f, -0.04457027f, 0.06145757f, 
    0.21084809f, -0.10901516f, -0.09384540f, 0.08149280f, 0.08740015f, -0.11300685f, 0.02306452f, 0.10504898f, 
    0.03906141f, -0.24461928f, 0.04257034f, -0.16971035f, -0.02937367f, -0.02461210f, 0.14706179f, -0.10507461f, 
    0.02636874f, -0.00166049f, 0.16253151f, 0.19316258f, 0.24549417f, 0.11788934f, -0.07193306f, 0.06763906f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04757679f, -0.04596896f, 0.05561148f, -0.01602651f, 0.02121065f, 0.07713282f, -0.03160818f, 0.32638767f, 
    0.01131083f, -0.05067633f, 0.26944375f, 0.01505018f, 0.14905529f, 0.13707940f, -0.11381844f, -0.03877529f, 
    -0.04286081f, -0.03664137f, 0.05503524f, 0.20131853f, 0.17034994f, 0.12015175f, -0.03603295f, 0.21238436f, 
    -0.31675348f, 0.01581896f, 0.16171822f, 0.06931463f, -0.16905014f, -0.03837440f, 0.02405564f, 0.20416088f, 
    -0.02883423f, 0.15834141f, -0.01892169f, 0.12757407f, 0.18253018f, 0.12148646f, -0.01895399f, 0.04776008f, 
    0.09757347f, -0.11938656f, -0.10485567f, 0.16763991f, -0.04331249f, 0.02163511f, -0.12609221f, 0.10609764f, 
    0.08954229f, 0.09030131f, 0.19297445f, 0.01831554f, -0.00027715f, 0.03100157f, 0.03163641f, 0.19570872f, 
    -0.08401985f, 0.18357268f, 0.00639479f, -0.03985411f, -0.01622785f, 0.08388730f, 0.08469968f, 0.16300237f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06164556f, 0.03023280f, 0.10726552f, -0.32354155f, -0.11397234f, -0.13600592f, 0.23260508f, 0.00091384f, 
    0.02804574f, -0.09609193f, -0.00433106f, -0.00537688f, 0.07919893f, -0.00111346f, -0.15683502f, -0.06794320f, 
    -0.04628139f, 0.04757633f, 0.03519026f, 0.03447820f, 0.00576352f, 0.20497915f, 0.11237832f, 0.10387120f, 
    -0.26636118f, 0.06528789f, 0.25939584f, 0.01637411f, -0.46756938f, -0.01109571f, -0.00445045f, 0.01861529f, 
    -0.04346666f, 0.07406735f, 0.09475169f, -0.05450215f, 0.20682703f, 0.11019271f, -0.00179869f, -0.07415289f, 
    0.14927140f, 0.02084657f, -0.18928447f, 0.07918480f, 0.13528216f, -0.08818346f, -0.07363085f, -0.03366956f, 
    0.07949021f, 0.30229014f, 0.12920722f, -0.21850657f, -0.24888405f, -0.00633142f, 0.01659282f, 0.04471389f, 
    0.07428288f, 0.19229747f, -0.11495814f, 0.01401113f, 0.11584464f, 0.21725839f, 0.28405240f, 0.21787399f, 
    -0.02126180f, 0.10185120f, 0.03201748f, 0.12189484f, 0.16160761f, -0.18257955f, -0.01567587f, 0.08478832f, 
    0.05809828f, -0.00901071f, 0.17002045f, -0.16069701f, 0.29502341f, 0.14821896f, 0.29183796f, 0.09164935f, 
    -0.03547792f, 0.02727333f, -0.02126096f, 0.01302915f, -0.32256866f, -0.03727077f, 0.02215839f, 0.01291605f, 
    0.25262576f, 0.06163358f, -0.21374235f, 0.16606510f, -0.41140696f, 0.07054516f, 0.12139625f, 0.06972677f, 
    0.12265028f, -0.23021217f, 0.05792074f, 0.21284275f, -0.09324937f, 0.21160768f, 0.06648581f, 0.02676957f, 
    -0.07083486f, 0.06605531f, -0.05827933f, 0.09655052f, -0.08693089f, -0.04697645f, -0.13130215f, -0.14083517f, 
    0.20294836f, 0.28234145f, -0.32153860f, -0.08954328f, -0.47950932f, -0.14031439f, -0.14055507f, 0.13191923f, 
    -0.00905627f, 0.18322326f, 0.12189998f, 0.01629614f, -0.26282406f, 0.04888726f, -0.12932061f, 0.15999484f, 
    -0.05149829f, -0.10199111f, -0.05339621f, 0.14556207f, 0.23648839f, -0.06436530f, -0.00497934f, 0.08757792f, 
    -0.02475436f, -0.05136085f, 0.07295977f, 0.27543527f, 0.01641049f, 0.19182016f, 0.31080729f, 0.12924580f, 
    0.02164311f, 0.07948943f, 0.10512272f, -0.16144733f, -0.04814982f, 0.04416022f, 0.05125740f, 0.03335817f, 
    -0.08174198f, 0.34683907f, -0.03909298f, -0.42172897f, 0.30189583f, 0.06128813f, 0.11908830f, -0.09328439f, 
    0.23608963f, -0.20713556f, 0.05676901f, 0.07855762f, -0.00868548f, 0.24993786f, 0.00166711f, -0.12207289f, 
    0.25060824f, 0.30923501f, 0.29112086f, -0.10768814f, -0.18516794f, -0.09203912f, -0.13514096f, -0.23900881f, 
    0.05067749f, -0.15189677f, -0.14316779f, -0.32796296f, -0.05960086f, 0.04813254f, 0.12105067f, -0.05889561f, 
    0.21406047f, -0.09924866f, -0.12593566f, 0.14964867f, 0.02754092f, -0.00060083f, -0.08515318f, 0.03394781f, 
    0.05689894f, -0.11596715f, -0.09369492f, -0.12969667f, 0.19823876f, 0.25233555f, -0.04448454f, 0.16435388f, 
    0.04111481f, 0.03095223f, 0.22594258f, -0.11293805f, 0.07536023f, -0.10178114f, -0.15529700f, -0.07537148f, 
    0.07100804f, 0.04367197f, -0.08160435f, 0.16808926f, 0.22052370f, 0.00635595f, -0.00877825f, 0.18593368f, 
    0.03051490f, -0.11197321f, 0.18326113f, 0.04213279f, -0.22885153f, -0.08408856f, 0.03358791f, 0.27802691f, 
    0.00482097f, -0.02468416f, 0.09254779f, 0.00805470f, -0.02016161f, 0.11988802f, -0.06207068f, -0.05971680f, 
    0.19154386f, 0.06837067f, -0.00415419f, 0.17634673f, -0.23973955f, 0.05632702f, 0.02362173f, -0.27555314f, 
    0.04437700f, 0.04572814f, 0.31270140f, 0.23893327f, -0.06575429f, 0.19667131f, -0.05919366f, 0.16172050f, 
    -0.40801442f, 0.26098001f, -0.02383471f, -0.23783234f, 0.21100503f, 0.01858691f, 0.00120422f, -0.04642703f, 
    0.03296098f, 0.01256986f, -0.06253394f, -0.09302355f, 0.12491565f, 0.30499676f, 0.03944423f, -0.20829953f, 
    0.11807939f, -0.11275447f, 0.23923485f, -0.07419142f, 0.13955639f, 0.21116561f, -0.08197717f, 0.04288663f, 
    -0.03352098f, 0.31922042f, 0.03846468f, 0.47547847f, 0.12710273f, -0.01653878f, 0.02308871f, 0.01758282f, 
    -0.16129641f, -0.09471901f, 0.07488921f, 0.16290730f, -0.10414755f, 0.21783334f, 0.07388612f, 0.32099304f, 
    -0.24234201f, -0.00490714f, 0.13251929f, 0.21894085f, -0.13935038f, -0.04021432f, 0.08514297f, -0.09177183f, 
    0.02626900f, -0.14140250f, -0.12275106f, 0.16880088f, -0.07963815f, 0.07113923f, 0.06317204f, -0.20972018f, 
    0.31157869f, -0.05412958f, 0.18141808f, 0.48238099f, -0.05127814f, 0.18969183f, -0.07818170f, -0.10454191f, 
    0.18847597f, -0.06204339f, -0.07024606f, -0.08591302f, -0.15943132f, 0.09385405f, -0.19046888f, 0.03894182f, 
    0.02397406f, -0.10410038f, -0.09276134f, -0.10378356f, -0.01696237f, 0.10534229f, 0.34478229f, 0.18997455f, 
    0.12476991f, -0.09593005f, -0.01302698f, 0.14925693f, -0.02221369f, -0.20835169f, -0.22373775f, 0.12022019f, 
    -0.10423543f, -0.04034566f, 0.04710463f, -0.03887186f, 0.45278665f, 0.05677479f, -0.07674444f, 0.09760188f, 
    -0.27015868f, 0.03337259f, -0.00799748f, -0.07745904f, -0.42599458f, -0.15208870f, 0.03431475f, -0.07981151f, 
    0.15810584f, -0.05939039f, 0.09414025f, -0.00877292f, 0.02876218f, 0.22279680f, -0.06137791f, -0.11458176f, 
    0.11449128f, 0.21813880f, 0.07899811f, 0.01764316f, 0.21742937f, -0.02083815f, -0.04093682f, -0.14986289f, 
    0.05199014f, 0.04189494f, 0.17280838f, -0.20490295f, 0.21250820f, -0.04420301f, 0.18087417f, 0.12057827f, 
    -0.31847712f, 0.21997964f, -0.03965696f, 0.04245733f, 0.12137551f, -0.09486572f, 0.38580757f, -0.04484814f, 
    -0.01031996f, 0.00199308f, -0.08763033f, 0.23243479f, 0.13881014f, 0.00870422f, -0.03767724f, -0.35240039f, 
    0.02363054f, -0.08103863f, 0.04845960f, -0.03920910f, -0.06864438f, -0.08039124f, 0.14078072f, -0.08520454f, 
    -0.06320701f, 0.24250370f, 0.04947056f, 0.01757493f, -0.04261689f, -0.12182680f, 0.06540227f, -0.03007515f, 
    0.04264992f, 0.32114002f, -0.11832642f, 0.09193861f, 0.19002949f, 0.30940646f, 0.07435358f, -0.04503998f, 
    0.18763097f, 0.01565897f, 0.06180025f, 0.12979469f, -0.11340068f, 0.12632217f, 0.05838038f, 0.03815246f, 
    0.07173975f, 0.18989733f, 0.10215157f, 0.16348153f, 0.24722926f, -0.02869569f, -0.32703763f, -0.19167598f, 
    -0.01120985f, 0.01633008f, -0.34040445f, 0.15283059f, -0.09782704f, -0.21599787f, 0.12064715f, -0.37068090f, 
    0.11098695f, 0.04199732f, 0.02718813f, 0.15790816f, -0.55490577f, -0.20952982f, 0.28780296f, 0.17416905f, 
    0.08901904f, 0.10333112f, 0.09179675f, 0.14288791f, 0.28190276f, 0.21372135f, 0.16058187f, -0.03188342f, 
    0.01392965f, 0.05867078f, 0.04410844f, 0.02418449f, -0.26377845f, -0.19213998f, 0.07361713f, -0.09780949f, 
    -0.07446730f, 0.07308794f, -0.06017414f, -0.00530215f, 0.12218422f, -0.03572519f, 0.03762349f, -0.06953043f, 
    -0.26048198f, -0.09748765f, -0.03172872f, -0.24713975f, 0.45905378f, -0.12151901f, 0.00908649f, -0.11402147f, 
    -0.08250435f, -0.00492299f, -0.10473467f, 0.17545842f, 0.07706760f, 0.19710541f, -0.12207274f, -0.20444007f, 
    0.33939275f, 0.27648234f, 0.25556093f, 0.19008461f, -0.01786995f, 0.07108860f, 0.23173302f, -0.09476405f, 
    0.05990850f, -0.00425353f, 0.02766062f, -0.05576354f, 0.18613964f, -0.00787017f, -0.03682724f, -0.07721197f, 
    -0.03200601f, 0.14661805f, -0.07648940f, 0.08962201f, 0.10939451f, 0.16438758f, 0.12064246f, -0.12300955f, 
    0.08785750f, -0.01480272f, 0.07591008f, -0.13993722f, 0.30487680f, 0.12642808f, 0.19685739f, 0.12878318f, 
    0.05425663f, -0.00293811f, 0.06691986f, -0.10888916f, -0.15078311f, 0.20830682f, 0.23221192f, -0.00580592f, 
    -0.09984566f, -0.01344858f, 0.02273659f, 0.21058843f, -0.00026851f, 0.27664533f, -0.11033455f, 0.17475273f, 
    -0.25832036f, -0.07988527f, 0.13822691f, -0.16537556f, -0.35128772f, -0.18758553f, 0.04193544f, -0.06519197f, 
    -0.19354098f, -0.09567795f, 0.10661413f, 0.15975328f, 0.15764116f, 0.27851734f, 0.00049246f, -0.11059284f, 
    0.23033752f, 0.14684200f, 0.19967821f, 0.19678572f, -0.17239897f, 0.00964317f, 0.03527663f, -0.09442240f, 
    0.21662319f, 0.23195755f, -0.20903742f, -0.23735176f, -0.05134396f, -0.14778693f, -0.14739129f, -0.02849912f, 
    0.09011790f, 0.02126206f, 0.03753262f, 0.01857326f, -0.01040122f, 0.05930270f, -0.10690982f, 0.30258974f, 
    0.05065258f, 0.03747514f, -0.11477071f, -0.06955791f, 0.10762341f, -0.02012827f, -0.08647953f, -0.15546376f, 
    0.06981282f, 0.07532527f, 0.25687498f, 0.14532016f, 0.07553234f, -0.08447547f, -0.06013405f, 0.06599033f, 
    0.11469494f, -0.04049324f, -0.02753553f, -0.32026091f, 0.09528743f, -0.02336713f, 0.01547830f, 0.00809454f, 
    -0.15113047f, -0.04698291f, 0.10167125f, -0.04589391f, -0.10381309f, 0.07812542f, 0.07122025f, -0.00502913f, 
    0.14708011f, -0.18781985f, 0.09110435f, -0.07338446f, -0.06940642f, -0.10767014f, -0.10651626f, -0.04359965f, 
    -0.18551011f, 0.04849344f, 0.16866980f, -0.20339094f, 0.05168293f, -0.12180878f, 0.15077959f, -0.09866171f, 
    -0.03560027f, -0.30659935f, 0.25644097f, -0.10699224f, -0.11337277f, -0.11324124f, 0.16377410f, -0.27676713f, 
    -0.31732756f, -0.09846471f, 0.06368309f, 0.02323707f, 0.05455039f, -0.02987764f, -0.10004212f, -0.16386496f, 
    0.06793480f, -0.07464260f, 0.05069514f, 0.31735554f, 0.19549739f, 0.19725482f, -0.02665881f, 0.12297430f, 
    -0.13063630f, 0.03171965f, 0.19824556f, 0.05397704f, 0.10349063f, -0.00929062f, -0.17789550f, 0.04687322f, 
    0.07571071f, 0.11413513f, -0.04124409f, -0.01999079f, 0.11422952f, -0.38570648f, -0.05682856f, -0.31618893f, 
    -0.09840965f, -0.07153866f, -0.15206493f, -0.32500389f, 0.42348042f, 0.00386061f, 0.12825039f, -0.05251656f, 
    0.05356535f, -0.09989788f, 0.09290104f, -0.19121782f, -0.08308831f, 0.12471492f, 0.05248391f, 0.01899578f, 
    -0.07449196f, 0.17334753f, 0.31445611f, -0.24658033f, 0.05949898f, -0.06012189f, -0.16056590f, 0.07095549f, 
    0.05470448f, 0.05170674f, -0.02319661f, -0.03054666f, 0.43679509f, 0.06355997f, 0.07946855f, 0.18644498f, 
    0.14512633f, -0.11775037f, 0.05175857f, -0.08778493f, -0.15829787f, -0.09415863f, 0.00899564f, -0.14372145f, 
    0.04224819f, 0.11156986f, -0.11191532f, -0.36166725f, 0.12139724f, 0.09372355f, -0.39515668f, 0.02353075f, 
    0.00878638f, -0.10710601f, 0.17852460f, 0.10916527f, -0.01394475f, 0.15507667f, 0.05086862f, 0.00258037f, 
    0.02169726f, -0.05074963f, -0.03548333f, -0.02175288f, 0.32081237f, -0.22236428f, -0.08359630f, 0.13372225f, 
    -0.34651685f, 0.10349279f, 0.13501464f, -0.04331316f, 0.44082960f, 0.19688712f, 0.11202842f, -0.03986668f, 
    0.36500633f, -0.25172138f, -0.04225488f, -0.20656355f, 0.07946605f, -0.56481260f, 0.04694895f, 0.14494225f, 
    0.04265967f, -0.06247817f, -0.00258330f, 0.21880551f, 0.00344553f, 0.10608376f, 0.04565711f, 0.03819790f, 
    0.02247900f, 0.08856978f, 0.13327761f, 0.09551389f, -0.04480712f, -0.24677864f, 0.00667538f, -0.06623095f, 
    0.00603964f, 0.06938642f, -0.06674409f, -0.19230342f, -0.18512574f, 0.02367172f, -0.31304696f, -0.00955641f, 
    0.10080671f, -0.03877507f, -0.05091317f, 0.53261840f, -0.10115419f, -0.21388377f, 0.10828346f, 0.16709515f, 
    -0.12232471f, 0.07851223f, -0.05943123f, -0.06929080f, -0.05814327f, 0.08574531f, -0.21321340f, 0.02794130f, 
    -0.04466416f, 0.45355058f, -0.05072425f, 0.00436071f, -0.43661150f, -0.17991386f, 0.01525154f, -0.34305620f, 
    -0.21253231f, 0.26383817f, -0.18499586f, -0.09616964f, 0.34286582f, 0.20029524f, 0.04204562f, 0.12130105f, 
    0.18748023f, -0.17890202f, -0.08728402f, -0.07895473f, -0.17170255f, 0.06644833f, -0.04694855f, -0.01850887f, 
    -0.14281443f, 0.17066102f, 0.21059252f, -0.01681950f, 0.38032356f, -0.15426971f, -0.27341291f, -0.10812993f, 
    0.16191451f, 0.23814027f, 0.13182519f, -0.11354432f, -0.47580507f, 0.23554112f, 0.20980759f, 0.15760298f, 
    0.44190598f, -0.18784842f, 0.06095826f, -0.10380165f, 0.03734695f, 0.25767887f, 0.20041037f, -0.30894586f, 
    -0.09324399f, 0.05361731f, 0.13044381f, -0.17238168f, -0.10922424f, -0.03703055f, -0.17584778f, -0.08509000f, 
    0.08331889f, -0.06933590f, -0.01604929f, 0.05488909f, 0.15054160f, 0.03631407f, 0.01462012f, 0.06304645f, 
    -0.02309335f, -0.14527242f, 0.00631953f, -0.04829444f, 0.05996674f, 0.19671187f, -0.05188195f, 0.14194885f, 
    -0.13404171f, -0.03492884f, 0.09220081f, 0.10827833f, 0.29381248f, 0.22306679f, -0.00299715f, 0.03148053f, 
    0.12976955f, 0.02059126f, -0.10019092f, 0.07097339f, 0.06982261f, -0.52218854f, -0.11906086f, 0.15809624f, 
    0.11060405f, -0.11740077f, -0.24311237f, 0.13718696f, -0.06315877f, 0.03603046f, 0.23140307f, -0.01790310f, 
    -0.00653990f, -0.01686130f, 0.16350971f, 0.02024765f, 0.02243202f, 0.07022741f, 0.07867415f, -0.15822402f, 
    0.02870025f, -0.01864971f, -0.02934504f, -0.04639445f, -0.03921254f, 0.01760781f, -0.20873456f, 0.10148261f, 
    0.07204055f, 0.08825400f, 0.09360553f, 0.02423168f, 0.18640356f, 0.01321445f, -0.01338854f, -0.03188143f, 
    0.06016464f, 0.10607282f, 0.12103726f, 0.10612851f, 0.19809441f, 0.04956149f, 0.30036113f, 0.04517711f, 
    -0.09248567f, -0.12486174f, 0.05714619f, -0.22556366f, -0.21159440f, -0.18775131f, -0.09795077f, -0.01721373f, 
    -0.13763919f, 0.34986600f, -0.09759135f, -0.11474518f, 0.12374513f, 0.20823491f, 0.01710167f, -0.10140403f, 
    0.24907245f, -0.28574821f, -0.12953556f, -0.02072206f, 0.10958462f, -0.15456875f, -0.10544103f, 0.20448510f, 
    0.13321725f, 0.04560069f, 0.03263187f, 0.21836285f, -0.01010305f, 0.01482031f, 0.08154380f, -0.04264313f, 
    0.04649547f, -0.01693835f, 0.02672210f, -0.09963065f, 0.07860460f, -0.08259369f, -0.19698475f, -0.06264828f, 
    0.01194487f, 0.19305794f, -0.08960055f, 0.37300840f, -0.20261423f, -0.15514873f, -0.11523636f, -0.03375255f, 
    -0.08350070f, -0.08503184f, 0.00644133f, -0.06734123f, -0.03849918f, -0.24971975f, 0.18787315f, 0.08609452f, 
    -0.01900149f, -0.00621407f, 0.09681816f, -0.17064708f, 0.35934591f, -0.21137761f, -0.08514968f, -0.03609463f, 
    -0.11867473f, -0.13347164f, 0.09696981f, -0.05491954f, -0.17039789f, -0.27421021f, 0.02994611f, -0.36833984f, 
    -0.19544111f, 0.19477788f, -0.31819150f, -0.42039463f, -0.04763709f, 0.35395613f, -0.10122873f, -0.08013589f, 
    0.28900570f, 0.11777194f, -0.03299648f, 0.12904805f, 0.12406377f, -0.03640555f, -0.04877722f, 0.25746951f, 
    -0.11411153f, 0.02743650f, 0.03310207f, -0.08730238f, 0.27664497f, -0.07421662f, -0.26402137f, 0.56192219f, 
    -0.08101861f, 0.22161287f, 0.11437571f, 0.11479709f, 0.00967816f, -0.36456901f, -0.07844964f, 0.11578672f, 
    0.08519424f, 0.08196174f, -0.05599589f, 0.16480213f, -0.64577663f, 0.02794818f, -0.04018525f, -0.18578267f, 
    0.07585222f, -0.08337082f, 0.06105144f, 0.33071545f, 0.17250738f, 0.30686522f, 0.17086139f, -0.42221811f, 
    -0.00699845f, -0.01556309f, 0.03179635f, -0.35254791f, -0.25226200f, 0.00597519f, 0.20933858f, -0.01533359f, 
    0.03093897f, 0.02902698f, 0.09568281f, 0.04007284f, 0.09406347f, -0.31385970f, 0.03927315f, -0.07985721f, 
    -0.21645330f, -0.06866778f, -0.25966224f, -0.15811262f, 0.57850504f, 0.22878397f, 0.04171699f, 0.02847011f, 
    -0.04065802f, -0.04708920f, 0.07442533f, 0.14907947f, -0.03208929f, -0.01463527f, 0.01830526f, 0.04093098f, 
    0.25674674f, 0.26726434f, 0.17184538f, 0.28126115f, 0.09640003f, -0.01040549f, 0.19950145f, -0.19952601f, 
    0.00787458f, -0.01752845f, -0.05353010f, 0.18973522f, 0.08402575f, -0.14361139f, -0.29822940f, -0.28182051f, 
    0.07442693f, 0.14733788f, 0.01166009f, 0.02570200f, -0.15701902f, 0.12578617f, 0.06391440f, -0.13428533f, 
    0.01934730f, -0.11566246f, -0.12487878f, -0.01747853f, -0.04354960f, 0.06674597f, 0.11053417f, -0.07303910f, 
    -0.02881740f, -0.10699546f, -0.02975355f, -0.18559618f, 0.32880583f, -0.08185075f, -0.20122060f, -0.01707468f, 
    0.10332093f, -0.12828580f, -0.09942336f, 0.02623129f, -0.06950253f, -0.00612052f, 0.06303043f, -0.28067020f, 
    0.24333327f, 0.02853310f, -0.19692497f, -0.14722657f, -0.22170638f, 0.26004767f, 0.02409299f, 0.08376441f, 
    0.41992989f, 0.05581291f, 0.08241430f, 0.11650467f, 0.15507531f, -0.08589990f, -0.06123446f, 0.12589695f, 
    -0.04505974f, -0.09291842f, -0.19264095f, 0.20028920f, 0.21942891f, 0.03757463f, -0.18329993f, 0.41083556f, 
    -0.07038061f, 0.36589527f, 0.09081898f, 0.26210350f, 0.18530096f, -0.32987544f, -0.12666145f, 0.11027022f, 
    0.06315336f, 0.10743244f, 0.09322663f, 0.15768051f, -0.30220050f, 0.14823802f, -0.01305096f, -0.17718849f, 
    0.01503186f, -0.01881400f, 0.10504051f, -0.16180174f, -0.05991016f, -0.20646991f, 0.10772246f, 0.25993907f, 
    0.08145418f, 0.11698824f, 0.20768079f, 0.07559144f, -0.01295621f, 0.14711355f, -0.10738947f, 0.05439090f, 
    0.04268875f, 0.10006514f, -0.06232227f, -0.11041978f, 0.18362792f, 0.06576243f, 0.12543088f, 0.04612792f, 
    -0.17768763f, -0.00226258f, -0.01047232f, -0.01993383f, -0.49540442f, -0.18727373f, -0.10435985f, -0.10881642f, 
    -0.05317126f, 0.18373726f, -0.00251891f, -0.02931237f, 0.01165611f, 0.14816248f, -0.01259060f, -0.06711423f, 
    -0.00158446f, 0.08748355f, 0.22587825f, -0.10564318f, 0.04770533f, 0.07250529f, 0.01454477f, 0.05385540f, 
    -0.13257614f, 0.05093933f, 0.12881294f, -0.15097141f, 0.03739377f, 0.09873230f, 0.25049073f, 0.19330086f, 
    0.00988301f, 0.02242288f, 0.03567915f, 0.06795845f, 0.20751862f, -0.00890515f, 0.10029417f, 0.41903958f, 
    0.08380743f, -0.04083479f, -0.08921953f, -0.29838663f, -0.00985064f, -0.30456942f, -0.27609780f, 0.14544557f, 
    -0.01737577f, 0.04953654f, 0.13994868f, 0.06921858f, 0.12539952f, -0.02363225f, 0.06683923f, 0.09285512f, 
    0.00730447f, -0.17030813f, -0.05816132f, -0.05854233f, 0.25576630f, -0.02324445f, -0.00481146f, 0.13377561f, 
    -0.46930760f, 0.02234458f, 0.01438976f, -0.05525701f, -0.10207573f, 0.21529743f, 0.02077659f, 0.12440522f, 
    0.32578215f, -0.11790046f, 0.03550228f, -0.09817652f, 0.06633774f, -0.36229801f, -0.05453929f, 0.11873280f, 
    -0.01418440f, -0.12311874f, 0.01744503f, -0.04192146f, 0.09733101f, 0.07786265f, -0.02408514f, 0.21430634f, 
    -0.10549677f, 0.03062649f, -0.06847182f, -0.06085376f, 0.25177446f, -0.20121263f, 0.08917160f, 0.09422753f, 
    -0.01611855f, 0.08102974f, 0.07659291f, 0.25999224f, -0.19308908f, -0.06150876f, -0.08642437f, -0.03115522f, 
    0.02004075f, 0.11677666f, 0.03453879f, -0.09657481f, -0.09367212f, -0.12570581f, 0.01129693f, 0.07082928f, 
    -0.00342197f, 0.10970224f, -0.14514919f, 0.00041988f, -0.08080102f, -0.13403368f, -0.12666194f, -0.09630900f, 
    0.04228614f, 0.01973715f, 0.05033579f, 0.07941677f, -0.03544077f, 0.06888980f, 0.05108322f, -0.13754885f, 
    -0.01672195f, -0.01807589f, -0.11201698f, -0.09025628f, -0.12401147f, -0.00875747f, -0.02559630f, 0.08131211f, 
    -0.12629020f, -0.11131335f, -0.02366218f, -0.07915882f, 0.02126713f, -0.08261761f, 0.08803685f, 0.04941187f, 
    -0.05719738f, 0.03115586f, -0.03698853f, 0.08616730f, -0.03061073f, -0.00661539f, 0.02607614f, -0.05849481f, 
    -0.11625580f, 0.02993388f, 0.00266952f, 0.03685604f, -0.03724821f, -0.07359232f, 0.01306181f, 0.01243853f, 
    0.06972367f, 0.06126660f, -0.07351534f, -0.12159526f, 0.02232896f, -0.10031839f, -0.09334044f, -0.12408558f, 
    -0.03028895f, 0.00651493f, -0.07451716f, -0.09790638f, -0.05302658f, -0.19252656f, 0.08057214f, 0.09924125f, 
    -0.02119946f, -0.04480386f, 0.07643022f, -0.29217735f, 0.30934808f, -0.14279802f, 0.02257131f, -0.01611478f, 
    -0.04641118f, -0.00884215f, 0.09918440f, 0.30397439f, -0.15884185f, -0.06348515f, -0.06008599f, -0.08767261f, 
    0.06648519f, 0.03558759f, -0.36479616f, 0.06874324f, -0.19621992f, 0.25679240f, 0.00909227f, 0.10597834f, 
    0.06833114f, 0.17333004f, -0.10210215f, -0.01268194f, 0.17086749f, 0.09186871f, 0.02507231f, 0.06584828f, 
    0.11923458f, -0.14686100f, -0.09287893f, 0.18061191f, 0.22515978f, -0.12221865f, -0.34103954f, 0.23615524f, 
    0.05466874f, 0.49995503f, 0.12314443f, 0.32567060f, -0.23035406f, -0.28134724f, -0.20049818f, 0.08880617f, 
    0.07997191f, 0.26767224f, -0.02825187f, -0.03757191f, -0.31201836f, 0.12679105f, 0.12887841f, 0.18081254f, 
    -0.05559531f, 0.03642941f, -0.07168882f, -0.26685077f, 0.12111641f, -0.07094423f, -0.02468418f, 0.12922172f, 
    0.04235138f, -0.08140743f, 0.20900643f, 0.39542446f, 0.04243834f, 0.28986758f, 0.17374936f, 0.04227491f, 
    0.01959155f, 0.01589724f, -0.02461397f, -0.10324161f, 0.39679790f, 0.09593726f, 0.01540024f, 0.29112190f, 
    -0.06468881f, 0.18862416f, -0.06546898f, -0.20750046f, -0.17474887f, -0.11925676f, -0.10447434f, 0.06923159f, 
    -0.07208651f, -0.22557175f, 0.04845238f, 0.00052143f, 0.01668927f, 0.09331102f, -0.08409066f, -0.12688409f, 
    0.20989366f, 0.12925237f, 0.23605452f, -0.17527284f, -0.17507558f, -0.06094547f, -0.11011668f, -0.43166244f, 
    -0.13820620f, -0.12133091f, 0.05760659f, -0.35286602f, 0.19932999f, 0.09096941f, 0.18790019f, -0.04357797f, 
    0.08649714f, -0.08010384f, -0.09588552f, 0.00897517f, 0.00642668f, -0.20100231f, 0.01669603f, 0.19308950f, 
    0.08485223f, 0.04860802f, 0.03377503f, 0.26366055f, -0.18961012f, 0.24498630f, 0.22435935f, 0.10736127f, 
    -0.03659179f, 0.00041700f, -0.07591134f, -0.07731019f, -0.01700842f, -0.04273222f, 0.12131865f, -0.06147960f, 
    0.02975866f, -0.12060651f, 0.05303187f, -0.04589620f, 0.21947353f, -0.01309215f, -0.11225892f, 0.16103758f, 
    -0.16734356f, 0.07747087f, -0.32527319f, 0.10397201f, 0.27162868f, 0.08295844f, -0.07009881f, -0.09343809f, 
    0.15313359f, 0.11313802f, -0.11455486f, 0.02877929f, 0.14184272f, -0.01776532f, 0.03692438f, -0.05265620f, 
    0.03428624f, 0.02384468f, 0.00369021f, 0.19839232f, 0.10296339f, 0.05062135f, 0.06705045f, 0.22423702f, 
    -0.12799536f, 0.27690545f, 0.18438277f, 0.11346726f, 0.11618214f, -0.08377258f, 0.02810725f, 0.04836493f, 
    -0.20589915f, 0.22342131f, 0.10461246f, 0.24796304f, -0.16044356f, -0.00807877f, 0.42297608f, -0.08923274f, 
    0.01556713f, -0.06203407f, 0.00323448f, 0.05915925f, -0.04771664f, -0.03065970f, 0.01887123f, 0.09226451f, 
    -0.10093749f, -0.09616426f, 0.10297303f, 0.05014854f, -0.00820274f, -0.16899079f, 0.26342660f, 0.06718625f, 
    0.03294012f, -0.19557121f, -0.09395229f, -0.00740867f, 0.06077149f, -0.09399210f, -0.08101628f, 0.36085826f, 
    -0.06436913f, 0.11937860f, -0.02170200f, 0.21029487f, -0.07745399f, 0.07843309f, 0.05654407f, -0.11910214f, 
    0.24757090f, -0.09992634f, -0.00266965f, 0.10304271f, -0.04860830f, 0.01499208f, 0.08080140f, 0.16147195f, 
    0.17060308f, 0.02947400f, 0.12766856f, 0.28723496f, -0.11577649f, 0.03219788f, 0.07190878f, -0.10675120f, 
    -0.01134410f, 0.23271218f, -0.04329310f, 0.09643537f, -0.13426791f, -0.15507364f, -0.18871759f, -0.05260935f, 
    -0.29573560f, 0.41497013f, 0.00714746f, 0.22313529f, -0.10241761f, -0.04738812f, 0.26502872f, 0.27761811f, 
    0.01441975f, -0.04946385f, -0.12005825f, 0.07614344f, 0.10178479f, 0.07787597f, -0.02150287f, 0.02575554f, 
    0.00627256f, -0.12452495f, -0.12330508f, 0.02872245f, -0.14855129f, -0.01692879f, -0.00762285f, 0.02280276f, 
    0.09696287f, 0.07317860f, 0.03967905f, -0.03448813f, -0.11454969f, -0.03567529f, 0.06679754f, 0.04963772f, 
    -0.10161608f, -0.12554224f, -0.02015526f, -0.08842330f, 0.01511351f, 0.04843376f, 0.08690368f, -0.01101693f, 
    -0.04027076f, 0.09605375f, 0.03637968f, -0.12899855f, -0.02280896f, -0.04765560f, 0.12032305f, 0.02454811f, 
    -0.05496586f, -0.05362096f, -0.16133173f, -0.09465642f, -0.02357504f, 0.09936181f, -0.13502611f, -0.02920896f, 
    -0.03615466f, 0.07509544f, -0.09467652f, 0.07900978f, 0.10263511f, -0.14281593f, -0.14401843f, -0.04424225f, 
    -0.09347440f, -0.00536243f, -0.04473014f, 0.00999553f, 0.00388504f, -0.05993228f, -0.05504649f, -0.15001427f, 
    0.04704908f, 0.11294052f, 0.03824344f, 0.08668248f, -0.13513984f, 0.14095043f, -0.19702542f, 0.11694995f, 
    -0.07120664f, 0.03968279f, 0.13232464f, -0.06641544f, 0.22850847f, -0.07797639f, -0.11271302f, 0.07271855f, 
    0.02264763f, 0.14802432f, -0.03540211f, 0.07892816f, 0.01381502f, -0.15770285f, -0.09226308f, 0.06800148f, 
    -0.05417644f, 0.12747614f, 0.18652405f, 0.15067349f, -0.06371471f, 0.21166956f, 0.02491008f, 0.22569817f, 
    0.07170886f, -0.14866097f, 0.06237429f, -0.15146656f, 0.01924034f, -0.06586570f, 0.07630263f, -0.13143823f, 
    -0.24470513f, 0.01400262f, -0.16096242f, 0.11087567f, -0.02748633f, -0.03498963f, -0.06490362f, -0.11089303f, 
    0.00686113f, -0.03231798f, 0.21990386f, 0.06864221f, -0.04932953f, 0.15828860f, -0.01098220f, 0.05926134f, 
    0.09344716f, 0.08939888f, 0.08333215f, -0.29376379f, -0.07830964f, 0.25963312f, -0.19309843f, -0.23780796f, 
    -0.12482990f, -0.02609687f, -0.04690790f, 0.13930105f, -0.05444065f, 0.00563647f, 0.00556517f, 0.14315264f, 
    -0.03416470f, -0.05019562f, -0.03871164f, 0.26837006f, -0.00425743f, 0.15568767f, -0.02503122f, -0.09337680f, 
    0.03620422f, 0.09268643f, -0.01126877f, 0.05503274f, 0.46470296f, 0.28105319f, 0.08679345f, 0.15237018f, 
    -0.16007926f, -0.06859314f, 0.09153993f, 0.12716332f, 0.12619771f, -0.18749350f, -0.03086108f, 0.10726012f, 
    -0.19792780f, 0.18153405f, 0.05883164f, 0.11465905f, 0.10090707f, 0.07254803f, 0.10723941f, -0.19145390f, 
    0.12667836f, 0.22520876f, 0.21000408f, -0.05295067f, -0.06318385f, 0.00620978f, -0.07626104f, -0.30256042f, 
    0.16151574f, -0.22899041f, -0.02200361f, -0.12345222f, 0.22685023f, 0.22844979f, 0.20841879f, 0.03727248f, 
    -0.08095516f, 0.07504386f, -0.10639860f, -0.16562705f, 0.03327970f, -0.00715164f, 0.14282519f, 0.17084509f, 
    0.02505640f, -0.06013449f, -0.06622732f, -0.05048044f, 0.11814997f, -0.09256565f, 0.08110011f, 0.30052409f, 
    0.03643983f, 0.12255730f, 0.15234783f, -0.22169447f, 0.25630152f, 0.01958017f, 0.01309493f, -0.08038929f, 
    0.03940362f, 0.05800715f, -0.00397131f, 0.20893605f, -0.07931399f, 0.00195231f, 0.09884559f, -0.11793644f, 
    0.10465758f, 0.13380750f, -0.22709309f, -0.13871717f, -0.35894352f, 0.05391294f, -0.00128477f, 0.26052192f, 
    0.12517029f, -0.14601256f, 0.03240867f, 0.04269284f, 0.30221722f, 0.04979252f, 0.11946119f, 0.14928725f, 
    0.01006748f, -0.09188503f, -0.06798285f, 0.01771221f, 0.04815827f, -0.01518127f, -0.21081595f, 0.24896587f, 
    0.11623273f, 0.26239747f, 0.15723707f, -0.19232202f, -0.05595367f, -0.09835191f, -0.36225992f, 0.19676858f, 
    0.03816868f, 0.07786800f, -0.05966068f, -0.03572306f, -0.04883823f, 0.27074274f, -0.13487409f, 0.05052872f, 
    0.12416583f, -0.07924479f, -0.05357330f, -0.09550244f, -0.01492727f, -0.00909301f, -0.28031459f, -0.17695726f, 
    0.05986547f, 0.05038651f, 0.11553679f, -0.11123621f, 0.13736187f, 0.11983187f, -0.21219598f, 0.11010468f, 
    0.03996756f, 0.28372690f, 0.06557318f, 0.13176611f, -0.10481642f, 0.24024160f, -0.06631942f, -0.15074712f, 
    0.04279244f, -0.00064514f, 0.23469895f, -0.06056047f, -0.00227611f, -0.04360562f, 0.07041064f, 0.16052675f, 
    -0.24591556f, 0.07035258f, 0.00369419f, 0.12168743f, -0.20988989f, -0.48338553f, 0.03484218f, -0.08751086f, 
    -0.29254243f, -0.06019508f, -0.30613443f, 0.01788216f, -0.02891234f, -0.05213261f, -0.05998036f, -0.00491353f, 
    0.13416620f, -0.18296795f, 0.01077081f, 0.15267697f, 0.03575468f, 0.23839553f, 0.08402784f, 0.02277021f, 
    0.10237456f, -0.13908800f, -0.00376688f, -0.16247445f, -0.02160127f, 0.04778295f, -0.02876652f, -0.32682315f, 
    -0.02189708f, 0.03629040f, 0.10509907f, 0.08998855f, 0.11221906f, 0.24072023f, 0.25654745f, -0.20993170f, 
    -0.11240584f, -0.02049908f, 0.00438935f, -0.14819539f, -0.22235817f, -0.20431840f, 0.08116805f, -0.02447521f, 
    0.04440755f, -0.03790250f, -0.06496371f, -0.11495848f, 0.00346331f, 0.05617763f, -0.08729951f, -0.04061235f, 
    -0.01726633f, -0.02011622f, -0.40605128f, -0.32261661f, 0.37454924f, -0.07110012f, 0.07481967f, -0.13370085f, 
    -0.00613851f, -0.09029497f, 0.03428800f, 0.13028775f, 0.14416488f, 0.25296369f, -0.01066789f, -0.20598912f, 
    0.24011822f, 0.23326840f, 0.09888490f, -0.10993418f, -0.11969297f, -0.05946107f, 0.07334223f, 0.04806664f, 
    -0.08535726f, -0.11806660f, 0.08594356f, -0.14349502f, 0.05134697f, 0.16328296f, -0.35076639f, -0.08879621f, 
    0.08618060f, 0.05882583f, -0.12405862f, 0.21532573f, 0.11337380f, 0.12995858f, 0.11316203f, -0.23096740f, 
    0.07748618f, -0.08471694f, 0.00941636f, -0.22305015f, 0.19426593f, 0.22944938f, -0.01046990f, -0.05901672f, 
    -0.00801260f, 0.00921682f, 0.17159742f, -0.14350340f, 0.03545966f, 0.25505948f, 0.09277702f, 0.10104524f, 
    0.02671875f, 0.11175325f, 0.01417783f, 0.41271105f, 0.19235684f, -0.00987765f, 0.04273663f, 0.24185896f, 
    -0.23799439f, -0.16286032f, 0.32866746f, 0.08522823f, -0.25217018f, 0.05158314f, 0.04395157f, 0.24034704f, 
    -0.29989311f, 0.10801946f, 0.12072360f, 0.05921218f, 0.18323857f, 0.03478121f, -0.00237152f, 0.08180648f, 
    0.03322902f, -0.15138735f, -0.11159699f, 0.11563040f, 0.00808486f, -0.05632500f, -0.00599977f, -0.17717721f, 
    0.29721650f, 0.13130681f, 0.13339502f, 0.15749873f, -0.14669026f, 0.04995938f, -0.24362946f, -0.10823858f, 
    -0.06464931f, 0.14685604f, -0.02474400f, -0.23653829f, 0.08977593f, 0.23982882f, -0.04932986f, 0.00757303f, 
    -0.08572149f, -0.10861232f, -0.07738017f, 0.22317570f, 0.22996944f, -0.01971161f, 0.09340580f, -0.24110334f, 
    0.08643785f, 0.08981961f, 0.18600868f, -0.36720794f, -0.08829064f, 0.04438600f, 0.16621394f, 0.02176844f, 
    0.10791562f, 0.31744650f, 0.10652762f, 0.27120095f, 0.08047085f, -0.11491758f, -0.10010302f, -0.09353491f, 
    0.16871482f, 0.04997173f, -0.24604079f, -0.20013982f, 0.09179178f, 0.16329730f, 0.00298440f, 0.11817379f, 
    -0.06443273f, -0.01803838f, -0.06690683f, 0.21290950f, 0.15721180f, 0.01756776f, -0.07724160f, -0.10030368f, 
    -0.02520742f, 0.00663006f, 0.04506866f, -0.06523493f, 0.08680784f, 0.12202976f, 0.15260832f, -0.08799805f, 
    0.06644921f, 0.14394677f, -0.07889716f, 0.27856308f, -0.13244259f, -0.07794802f, -0.07954688f, -0.07566281f, 
    0.24467482f, -0.22494453f, -0.02379553f, -0.13746844f, -0.17630373f, 0.07828960f, -0.17290223f, -0.05696322f, 
    -0.07763604f, 0.03735637f, -0.11038385f, -0.05446667f, 0.01595097f, 0.06843694f, 0.03484287f, 0.04861053f, 
    0.08468648f, -0.07450198f, -0.03008146f, -0.05266400f, 0.10606397f, -0.12648688f, -0.13996223f, 0.06325283f, 
    0.00721562f, 0.11584346f, 0.09577815f, -0.05065966f, -0.11282865f, -0.05120629f, -0.06817486f, 0.03492851f, 
    -0.00290455f, 0.11049182f, 0.08032420f, 0.01054196f, -0.11585171f, -0.10716915f, -0.01421129f, -0.09346621f, 
    -0.00851120f, 0.07445429f, -0.04223072f, 0.04575177f, 0.08339439f, -0.09633967f, 0.01169632f, 0.01745862f, 
    0.03364167f, -0.06228527f, 0.00729994f, 0.01090551f, -0.05571885f, -0.00259896f, -0.00345369f, -0.06547097f, 
    0.10141590f, -0.10518292f, -0.08663119f, 0.06761981f, 0.01911943f, -0.05810893f, -0.12290667f, -0.08158144f, 
    0.00869186f, -0.10174840f, 0.04003616f, -0.08811897f, -0.09039325f, -0.01475246f, 0.08278517f, -0.12024714f, 
    0.01983289f, 0.09323928f, 0.04981934f, 0.41560453f, 0.13381550f, 0.12247506f, -0.24811698f, -0.01290111f, 
    -0.04032381f, -0.02549042f, 0.20441028f, -0.28932956f, 0.05318714f, 0.12944305f, -0.03362335f, -0.01315556f, 
    -0.05363439f, 0.10713074f, -0.12765193f, 0.09235620f, -0.29078266f, -0.46386051f, -0.05076732f, -0.22207700f, 
    -0.12869914f, 0.03777005f, -0.10492348f, -0.31243154f, 0.36936989f, 0.18067047f, -0.08607639f, 0.11719523f, 
    0.12422295f, -0.53633535f, 0.10979545f, 0.01219037f, 0.11191870f, 0.18356423f, 0.03181170f, -0.07639273f, 
    -0.00296801f, -0.04464388f, 0.16910248f, -0.29181021f, 0.11626085f, 0.03799007f, -0.16733779f, -0.13450871f, 
    0.21550135f, 0.20925204f, 0.23551920f, -0.14345087f, -0.39520481f, 0.04704541f, -0.15362722f, 0.09432812f, 
    0.41602880f, -0.22460504f, 0.10466218f, -0.24177587f, -0.04897607f, 0.11376368f, -0.21135381f, -0.29880491f, 
    -0.10502748f, -0.07150497f, -0.01700754f, 0.12511660f, -0.05126284f, 0.23241141f, 0.19218253f, -0.16619405f, 
    0.05730031f, -0.10750625f, -0.11203912f, 0.04694883f, -0.26882464f, -0.18371738f, -0.08812765f, -0.05721673f, 
    -0.06900328f, -0.07092544f, 0.07716593f, 0.04976605f, 0.24064048f, 0.04199931f, 0.00010996f, 0.17129740f, 
    -0.10599717f, -0.09739736f, 0.06797998f, -0.09123372f, 0.37836614f, -0.06824956f, -0.08654080f, -0.04183200f, 
    0.14502351f, 0.09768074f, 0.11621539f, -0.05675276f, 0.01146892f, -0.09947132f, -0.01805224f, -0.00764225f, 
    0.09141698f, 0.15340695f, 0.10680016f, 0.15611956f, 0.19355138f, -0.10863888f, 0.21393724f, 0.16693282f, 
    -0.29327637f, -0.19158334f, 0.26866201f, 0.03790774f, 0.30829188f, 0.09874326f, -0.03970679f, 0.08075237f, 
    -0.07017666f, 0.05153553f, 0.03043504f, 0.13653159f, 0.18167621f, -0.14617145f, 0.19687280f, -0.13202579f, 
    0.08600990f, -0.03522971f, -0.11765988f, 0.06132016f, -0.00229751f, 0.08269516f, -0.05758019f, -0.12310048f, 
    -0.04065048f, -0.01060034f, -0.12393820f, 0.00237289f, -0.14495294f, 0.06336483f, -0.13811976f, 0.08937965f, 
    -0.08023666f, -0.11577990f, 0.01373647f, -0.00023682f, -0.11936429f, -0.11355575f, -0.07450545f, -0.00057391f, 
    -0.04325198f, -0.11769723f, -0.00397346f, 0.01326645f, -0.08197277f, 0.03045516f, 0.11605317f, 0.01319952f, 
    -0.06574943f, 0.06157061f, 0.03944771f, -0.04531630f, -0.09429129f, -0.09750379f, 0.08575904f, -0.04937524f, 
    0.11853068f, 0.07851542f, -0.09246819f, -0.06578951f, 0.02978111f, 0.11493917f, -0.03337205f, -0.08721644f, 
    -0.01600382f, -0.07279214f, -0.12513879f, -0.16173710f, -0.11322193f, -0.05017361f, -0.00934433f, 0.08383343f, 
    0.03032605f, 0.03592829f, -0.08886128f, -0.00149378f, -0.17570113f, -0.00271331f, 0.02709272f, -0.08258373f, 
    0.00143811f, 0.10102095f, 0.08687451f, 0.14049943f, -0.04804126f, 0.02821089f, 0.04338314f, 0.09101798f, 
    0.09072650f, -0.02516787f, 0.17650975f, -0.01261919f, 0.18138602f, 0.01955994f, 0.06048998f, 0.12743463f, 
    0.10362207f, -0.07871086f, 0.06576797f, 0.12449518f, 0.15348542f, 0.09764747f, 0.04971618f, 0.04760021f, 
    -0.11551763f, 0.17397600f, 0.05740321f, 0.05876787f, -0.12934406f, -0.00643412f, -0.07727806f, 0.03773260f, 
    -0.11475968f, 0.18083248f, 0.01134176f, 0.19586347f, -0.14531498f, 0.04829323f, 0.09479978f, -0.06078107f, 
    -0.08642367f, -0.08827645f, -0.08157773f, 0.11711838f, -0.20238274f, 0.11927657f, -0.12964231f, 0.14618741f, 
    -0.11506982f, -0.07118110f, -0.12192844f, 0.10408514f, 0.05073924f, 0.00191899f, -0.10890465f, 0.28364187f, 
    -0.16027987f, 0.14980888f, 0.00272027f, 0.31734663f, 0.06612977f, -0.14697789f, 0.17137994f, 0.06787854f, 
    0.01121500f, 0.01738107f, 0.10562899f, 0.02265876f, -0.13737646f, -0.05060368f, -0.33880362f, -0.06917152f, 
    0.04791997f, 0.01731795f, 0.05309304f, 0.09220676f, 0.03691538f, -0.05028192f, -0.25728905f, 0.11441267f, 
    0.12213124f, 0.20057972f, -0.04490617f, 0.17144480f, -0.25087979f, 0.03097943f, -0.04676517f, -0.01649992f, 
    0.17328021f, -0.05182509f, 0.23911922f, -0.04404913f, 0.00680965f, -0.01039056f, -0.12043346f, 0.20368555f, 
    -0.05250147f, 0.13881543f, 0.08401963f, -0.13498914f, -0.06436371f, -0.13573731f, 0.06888826f, -0.08622687f, 
    -0.23277397f, 0.05494324f, -0.27604350f, -0.00035144f, -0.03541541f, -0.04885398f, 0.01073038f, -0.11572904f, 
    0.01594499f, -0.16705437f, 0.18283193f, 0.05222853f, -0.08788056f, 0.17282759f, -0.00855852f, 0.12665740f, 
    -0.01639557f, -0.12584479f, 0.10936698f, 0.02135806f, 0.08510864f, -0.00928318f, -0.09001014f, -0.21873783f, 
    -0.08558692f, 0.04683744f, 0.02665997f, -0.05141815f, 0.27947408f, 0.19412148f, -0.02459010f, -0.14203222f, 
    0.01909463f, 0.07411586f, 0.17465435f, -0.37038347f, 0.04302061f, 0.16870147f, 0.11174422f, 0.05258076f, 
    0.11289810f, 0.13499346f, -0.02565625f, 0.14715490f, 0.09078081f, -0.28642496f, -0.08208718f, -0.18387271f, 
    -0.19266383f, -0.06006426f, -0.04354755f, -0.25500470f, 0.29515681f, 0.13952225f, 0.09513810f, 0.28070790f, 
    -0.28495806f, -0.03623924f, 0.08657604f, -0.06351370f, 0.18597262f, -0.14135243f, -0.10359596f, 0.00105184f, 
    0.08824235f, -0.02595240f, -0.10880147f, -0.06852069f, 0.10155579f, -0.04545628f, 0.11400601f, -0.15702939f, 
    0.12620461f, 0.03800687f, 0.23645021f, 0.38178602f, 0.21094736f, -0.02096188f, -0.06238712f, -0.10389434f, 
    0.20115128f, -0.25007236f, 0.08904286f, -0.20276389f, -0.17267784f, 0.08157440f, -0.23084687f, -0.07703035f, 
    -0.02146271f, 0.07685766f, -0.06944618f, -0.17644460f, 0.18039629f, -0.05270085f, -0.17031062f, 0.04023432f, 
    -0.10288469f, 0.10742021f, 0.19992124f, -0.07755297f, 0.11269336f, 0.31083849f, 0.08894686f, -0.08349061f, 
    0.06283924f, 0.24355640f, -0.00691770f, 0.14101282f, -0.00271270f, 0.15797155f, 0.03458529f, 0.17031160f, 
    0.04085766f, 0.04510571f, 0.19577886f, 0.02351847f, -0.13467619f, -0.15796843f, 0.09283713f, 0.24642785f, 
    -0.21449947f, -0.02363895f, -0.07095474f, 0.12780671f, 0.17301345f, -0.03153146f, 0.08749431f, 0.19897887f, 
    -0.08139368f, -0.09371805f, 0.12703301f, -0.07506138f, -0.09727383f, -0.07951695f, -0.01814863f, -0.30278614f, 
    0.36750239f, 0.08373005f, -0.07534052f, 0.08424680f, -0.17597027f, 0.24358580f, 0.04158463f, -0.13295762f, 
    0.20622571f, -0.12420902f, -0.12178289f, -0.31878605f, 0.03019257f, 0.18980134f, -0.18991791f, 0.13097823f, 
    -0.08333208f, 0.11260708f, 0.08051087f, -0.01724016f, 0.07464805f, 0.15816739f, 0.03967869f, 0.14901720f, 
    -0.03342631f, -0.09679384f, 0.05474931f, 0.20878173f, -0.02710704f, -0.24139424f, 0.15791318f, 0.05702962f, 
    -0.05843225f, 0.06521130f, -0.04097548f, -0.02477060f, -0.16998014f, 0.17335722f, -0.02978724f, 0.25322706f, 
    0.01658993f, -0.11430860f, 0.02462681f, 0.20642540f, -0.20419373f, -0.33687079f, -0.06256563f, 0.00044795f, 
    -0.00427753f, -0.14546572f, 0.08088045f, -0.07478219f, 0.03935454f, 0.22407053f, -0.00281338f, -0.07411856f, 
    0.16344079f, 0.02021955f, 0.21200092f, 0.06981394f, -0.05999455f, 0.02603193f, 0.12767191f, -0.16463087f, 
    -0.06029005f, 0.19584201f, 0.22368541f, -0.26373485f, -0.17319433f, -0.05145562f, -0.07823525f, 0.19049746f, 
    -0.12583695f, 0.04393334f, -0.03816717f, -0.14116052f, 0.17118724f, 0.15442406f, 0.06236852f, 0.20925082f, 
    0.07845258f, -0.12635542f, 0.10272542f, 0.12814999f, 0.23547587f, -0.12797780f, -0.05430863f, -0.00742031f, 
    -0.06339585f, 0.09383532f, 0.16471194f, -0.01245053f, -0.12753482f, -0.02559992f, -0.10064199f, -0.02823001f, 
    -0.03751939f, 0.21922353f, 0.11329018f, 0.22826427f, 0.15525264f, -0.08398055f, 0.02018247f, -0.08464491f, 
    -0.18964154f, 0.13480264f, -0.04980852f, -0.42298937f, -0.08457026f, 0.12153138f, 0.09592083f, 0.11348815f, 
    -0.19080287f, -0.15180193f, 0.08354503f, -0.19055031f, 0.25130665f, 0.13699427f, -0.05030145f, -0.01517769f, 
    -0.03619532f, -0.09225965f, 0.08375009f, -0.12937018f, 0.21701941f, 0.10585181f, -0.27681819f, -0.17261939f, 
    0.25756821f, 0.17436628f, -0.04117747f, -0.10045673f, -0.09396984f, -0.11323363f, 0.18191852f, 0.10477246f, 
    0.33796257f, -0.05875879f, 0.10308182f, -0.26083738f, 0.05641982f, 0.17240320f, -0.03345092f, -0.02783758f, 
    0.04135581f, -0.05651778f, -0.02876175f, 0.15336533f, 0.07117131f, 0.13994634f, -0.04672844f, 0.18348931f, 
    -0.04283541f, -0.01851537f, 0.04399200f, -0.32853216f, 0.08734047f, -0.17902166f, -0.05149602f, 0.06393930f, 
    0.06470259f, 0.06771910f, 0.01490012f, 0.07235970f, -0.44642231f, -0.33499840f, -0.11941348f, -0.27739820f, 
    -0.06492023f, 0.08071278f, 0.14767833f, 0.06857495f, 0.05897871f, 0.11818242f, -0.02256126f, 0.28650257f, 
    0.19407357f, -0.28505680f, 0.09154451f, 0.01579283f, 0.11376928f, 0.03163917f, -0.00546048f, -0.08979325f, 
    -0.00400639f, -0.13949160f, 0.01117878f, 0.00535379f, -0.03074357f, 0.03863182f, -0.21195796f, -0.12033807f, 
    0.33020672f, 0.23885685f, 0.33400050f, 0.07446174f, -0.42556801f, -0.03894508f, -0.38766110f, 0.25130138f, 
    0.11168375f, 0.02333855f, 0.03972955f, -0.25977641f, 0.05607193f, 0.18597966f, -0.30968308f, -0.22046049f, 
    0.04999754f, -0.07520112f, 0.10292470f, 0.23171440f, 0.05986194f, -0.07890274f, 0.02623538f, 0.09797607f, 
    0.09189042f, 0.09234264f, 0.19361475f, -0.22851774f, -0.00383126f, -0.13242267f, -0.08605634f, -0.05497319f, 
    0.08451558f, 0.04155933f, -0.08752176f, 0.06721107f, -0.09670670f, -0.17442513f, -0.00000402f, 0.08159328f, 
    -0.16071884f, -0.12541474f, 0.08089066f, -0.01595672f, 0.01596156f, 0.08593250f, 0.01420453f, 0.24614275f, 
    0.08399153f, -0.20149095f, 0.01872824f, 0.22803038f, -0.10969703f, 0.11161311f, -0.08523724f, -0.19970116f, 
    0.12745102f, -0.23299369f, 0.10199503f, 0.00556657f, -0.07125457f, -0.06888554f, 0.04537912f, 0.11998376f, 
    -0.03825409f, 0.02177420f, 0.08561423f, 0.18680309f, 0.08423130f, 0.00184989f, -0.18579672f, 0.25146830f, 
    0.07396922f, 0.19613306f, 0.10776223f, -0.01996134f, -0.18509065f, 0.16782096f, -0.12455852f, -0.23859876f, 
    0.09902241f, 0.02762726f, 0.10224298f, -0.33998540f, 0.16038576f, 0.34856251f, 0.10413210f, 0.04962813f, 
    0.10441826f, -0.02431776f, 0.16459471f, 0.03972093f, 0.06894866f, -0.04973143f, -0.16501124f, -0.03809731f, 
    0.01520634f, -0.14640428f, -0.10915294f, 0.21226414f, 0.16960296f, -0.01940277f, -0.10928748f, -0.15735699f, 
    0.06499016f, -0.20641674f, 0.20057483f, -0.13393541f, -0.20879988f, -0.07693807f, 0.00164138f, 0.15130168f, 
    -0.05813425f, -0.01338359f, 0.01714508f, -0.01613610f, 0.12086017f, -0.08175114f, 0.03880323f, -0.21316937f, 
    0.03957595f, -0.11777090f, 0.01325227f, 0.09640784f, 0.05740386f, -0.11034160f, 0.06355956f, 0.11064713f, 
    0.18756291f, -0.08969409f, 0.43113020f, -0.00836172f, 0.05739567f, 0.22583181f, -0.09601200f, 0.20005193f, 
    -0.16752638f, 0.09637454f, -0.03616386f, -0.11027700f, 0.14137287f, 0.11573102f, 0.03394190f, -0.07936745f, 
    0.04445480f, 0.07539862f, -0.10952208f, 0.00859079f, 0.09587650f, 0.18029518f, 0.13883567f, 0.14317824f, 
    -0.00602353f, 0.01066248f, 0.06680787f, 0.07394334f, -0.12933740f, -0.31380638f, -0.02152913f, 0.03882573f, 
    -0.02946324f, 0.04480034f, -0.07764673f, -0.18028106f, 0.00542343f, 0.04554086f, 0.04278626f, -0.22280809f, 
    -0.23777199f, 0.06900378f, -0.00626186f, -0.66992790f, -0.06723655f, -0.31116295f, -0.02845868f, 0.04172397f, 
    0.23210101f, -0.09304557f, -0.05795208f, -0.09066223f, 0.09373136f, 0.26294199f, -0.03107153f, -0.34213254f, 
    0.17144291f, 0.16942810f, 0.23088464f, -0.05682949f, -0.14889844f, -0.05601861f, -0.02474192f, 0.09241363f, 
    -0.02925519f, -0.20437896f, 0.37896180f, -0.35284585f, 0.01420751f, 0.12727457f, -0.21839848f, 0.20502195f, 
    0.02523608f, 0.05592108f, -0.10068344f, 0.21855557f, 0.32078806f, -0.01171196f, 0.13210694f, -0.16322955f, 
    -0.10327917f, 0.06216865f, -0.11586998f, 0.32269800f, -0.03279209f, -0.21511316f, -0.03656944f, 0.10342979f, 
    0.03393905f, 0.02610964f, 0.04105213f, 0.10894690f, 0.10524334f, 0.19616024f, 0.09924258f, -0.02668437f, 
    0.00022361f, 0.37012234f, -0.00332100f, -0.15402752f, -0.19546649f, 0.08530293f, 0.09457778f, 0.09945247f, 
    0.19797115f, 0.28781083f, 0.15342420f, 0.16473082f, 0.10086901f, -0.09430406f, -0.01959174f, -0.06981168f, 
    -0.03863227f, -0.02707011f, 0.11239888f, 0.13601966f, -0.01869445f, 0.14117125f, 0.04339773f, 0.01185924f, 
    0.09731314f, 0.28352273f, 0.16753070f, -0.10255858f, 0.02317724f, -0.11106197f, 0.11335415f, -0.13521080f, 
    0.23993175f, -0.09957742f, -0.12822996f, -0.15785445f, -0.05875438f, 0.16531862f, 0.10233409f, -0.13036878f, 
    0.25946406f, -0.12685627f, -0.03771249f, -0.12448653f, 0.20797785f, 0.02718651f, -0.01900286f, -0.03881196f, 
    -0.06839971f, -0.04099603f, 0.01300533f, -0.20067412f, 0.09181789f, 0.02748101f, 0.04082147f, 0.26542103f, 
    0.10238999f, 0.03600784f, 0.21472083f, -0.04863273f, 0.17812246f, 0.35871682f, -0.04841554f, -0.02303876f, 
    -0.04289960f, 0.14522861f, -0.05326558f, 0.32529715f, 0.42247692f, 0.18298510f, -0.01741937f, -0.01860180f, 
    0.14698520f, -0.11590166f, -0.12287834f, -0.07238428f, -0.39999080f, 0.12641641f, -0.09040570f, 0.26234686f, 
    -0.27438211f, 0.26728764f, -0.07095795f, 0.14983152f, 0.12679034f, 0.02732189f, 0.10060823f, 0.05832333f, 
    -0.03696237f, -0.08887272f, -0.10819487f, -0.03921260f, 0.06074763f, -0.06661192f, -0.37687930f, 0.13541819f, 
    -0.05838030f, -0.00874310f, -0.18135493f, 0.02338287f, 0.01644949f, 0.19355655f, -0.00543001f, 0.25142318f, 
    0.07731074f, -0.05089628f, 0.06586152f, 0.00195216f, 0.01963759f, -0.10591616f, 0.10904617f, 0.39301300f, 
    0.12298666f, 0.06562009f, -0.10630143f, 0.11396878f, 0.16510145f, 0.07539889f, 0.07617867f, -0.14598729f, 
    -0.08122899f, -0.10133626f, 0.05781695f, -0.13032196f, -0.12950745f, 0.08332872f, 0.11349069f, 0.06106104f, 
    0.03821840f, 0.14967816f, -0.10307437f, 0.23841694f, 0.14521344f, 0.18824606f, 0.09007854f, 0.09174627f, 
    -0.09410235f, 0.06222042f, -0.27308908f, -0.11724783f, 0.15990244f, 0.07188137f, 0.01823833f, -0.11271556f, 
    -0.31455529f, 0.15167512f, -0.02792036f, 0.11459221f, -0.05744507f, 0.21116449f, -0.01017287f, -0.14223784f, 
    0.02654770f, 0.28209054f, 0.11474311f, -0.03516133f, 0.13356662f, -0.07473927f, -0.15222527f, -0.11343602f, 
    -0.05543757f, -0.01623173f, -0.30975556f, 0.24464634f, 0.18909881f, 0.02289276f, 0.22762701f, -0.26242250f, 
    0.11386664f, -0.07555936f, 0.07352149f, 0.02526945f, -0.10694054f, -0.09935746f, 0.19050476f, 0.04745070f, 
    0.01867775f, -0.08338140f, 0.03062408f, -0.22671832f, 0.01137858f, -0.03572688f, 0.37504482f, 0.00973370f, 
    -0.05387824f, -0.04731511f, 0.13692452f, -0.18225923f, -0.07446858f, -0.24521106f, -0.20794719f, -0.04041962f, 
    0.10778827f, -0.24622674f, 0.09559509f, 0.12121695f, 0.25483239f, 0.09898157f, -0.10557524f, 0.01879142f, 
    -0.30264020f, -0.15881126f, 0.23778383f, -0.01228433f, -0.15588918f, 0.23652920f, -0.06782690f, 0.09744716f, 
    0.20098974f, 0.16162515f, -0.07761537f, 0.08366829f, 0.19116519f, -0.05696746f, 0.10684273f, -0.04181015f, 
    0.12047316f, 0.06457836f, -0.08763497f, 0.16702420f, 0.22544983f, -0.08049296f, -0.10808610f, 0.15969548f, 
    -0.17811303f, 0.10096470f, 0.37112716f, 0.13001624f, 0.25039333f, -0.36975947f, 0.03944579f, 0.05357634f, 
    -0.11629699f, 0.10581724f, -0.08158594f, 0.25553253f, -0.16967420f, -0.07809587f, -0.01404023f, 0.01951142f, 
    0.06825919f, -0.06984308f, 0.03041619f, 0.13448618f, -0.10088220f, -0.10276924f, 0.04109758f, -0.09190930f, 
    0.01091148f, 0.02522828f, 0.09688457f, 0.04428614f, -0.20814167f, 0.12423939f, 0.18027411f, -0.10649154f, 
    -0.06874049f, -0.03042927f, -0.08313444f, 0.12790774f, 0.01830038f, 0.22372916f, -0.04852331f, 0.23729809f, 
    -0.24152678f, -0.00118122f, -0.01139890f, 0.15000214f, 0.01345634f, 0.02258567f, -0.05048837f, -0.12754391f, 
    -0.04008292f, 0.03014477f, 0.04911622f, 0.22607659f, 0.16142763f, 0.24570948f, 0.10700546f, 0.10576625f, 
    0.11762878f, 0.16891365f, 0.05668457f, -0.06190456f, 0.19324288f, -0.09417237f, 0.02814574f, 0.06552543f, 
    -0.13038099f, 0.18313397f, -0.41729972f, -0.06850615f, -0.14341034f, -0.21368094f, -0.03642312f, -0.19472153f, 
    0.26051056f, 0.09439857f, -0.01041082f, 0.06359436f, -0.18127224f, -0.10588638f, 0.24937531f, 0.20647888f, 
    -0.10493478f, -0.02631520f, -0.08054605f, -0.06187941f, -0.06161953f, -0.14863138f, -0.13469552f, -0.11542133f, 
    0.05779428f, -0.08405319f, -0.09553880f, -0.15138361f, -0.09036583f, -0.13599698f, 0.06911749f, -0.01407997f, 
    0.10038122f, -0.02399674f, 0.09657532f, -0.10723055f, -0.12637101f, -0.00462620f, 0.05400230f, 0.11266851f, 
    0.05755346f, -0.09214973f, 0.09387108f, -0.04640181f, -0.00725846f, -0.06195250f, 0.04964916f, -0.02171157f, 
    -0.01551717f, -0.00967088f, -0.01305039f, -0.13037506f, 0.02183972f, 0.06806976f, -0.03552433f, 0.00262848f, 
    0.07110450f, -0.13396920f, 0.04485330f, -0.07836618f, -0.08512706f, -0.12737499f, -0.09498932f, -0.05477781f, 
    -0.06172435f, 0.08873043f, 0.04489639f, -0.14032906f, -0.00203660f, -0.05728889f, 0.05361308f, -0.14449622f, 
    -0.00498137f, -0.03471219f, 0.08335193f, 0.03264942f, 0.09471952f, -0.04029898f, -0.01035348f, -0.13543428f, 
    0.03335962f, 0.10109171f, -0.10461732f, -0.15843871f, 0.08108088f, 0.11485514f, 0.28626144f, 0.27603546f, 
    0.05732731f, 0.00453121f, 0.08468814f, -0.04776704f, -0.01068026f, -0.17405567f, -0.24887449f, 0.01017263f, 
    0.08888313f, -0.16190915f, -0.01418692f, 0.02882311f, 0.34645522f, 0.01384928f, -0.04042930f, 0.02154267f, 
    -0.09041564f, 0.11464950f, 0.11198536f, -0.38253692f, -0.40804887f, -0.11501375f, -0.00918138f, -0.08913486f, 
    0.28756922f, -0.17826262f, 0.07715498f, -0.15109891f, 0.24466485f, 0.13862391f, -0.04991540f, -0.21429051f, 
    -0.06536686f, 0.03844704f, 0.05618001f, 0.07101599f, 0.06952124f, 0.10929966f, -0.08791634f, 0.19265829f, 
    -0.21547766f, 0.06022416f, 0.43656754f, -0.09528467f, 0.24187469f, -0.29317272f, 0.12281654f, 0.31284225f, 
    -0.32215962f, 0.28876933f, 0.12286942f, 0.08359908f, 0.08232810f, 0.15267220f, 0.16788535f, -0.04086874f, 
    0.07255998f, -0.05479182f, 0.06208144f, -0.09700608f, -0.03169627f, 0.01080623f, -0.07331012f, 0.03213500f, 
    -0.05404529f, -0.09976571f, 0.07173286f, -0.14441323f, -0.09225959f, 0.00192785f, -0.14659545f, -0.10430519f, 
    -0.09556396f, -0.11207424f, 0.04542898f, -0.07867858f, -0.06925919f, -0.02408143f, 0.02101359f, -0.13224733f, 
    0.01364052f, -0.02454294f, -0.10749292f, -0.01329589f, 0.02808221f, -0.01317604f, -0.07650543f, 0.04955066f, 
    -0.07863991f, -0.01012109f, -0.05886579f, 0.08129631f, -0.10611939f, -0.00579182f, -0.03721528f, -0.13621575f, 
    0.04286328f, 0.08446086f, 0.02385206f, -0.10320542f, 0.01314340f, 0.06478385f, 0.00862655f, -0.15504831f, 
    0.03680559f, 0.07562315f, -0.07535797f, -0.14229511f, -0.15111214f, -0.03789943f, 0.00558394f, -0.02981996f, 
    0.06872100f, -0.08467814f, -0.07842532f, 0.01964858f, -0.14036137f, -0.09634610f, -0.14588165f, -0.09431621f, 
    0.06775050f, -0.05351615f, 0.06224740f, -0.16302417f, 0.12296010f, -0.42760664f, 0.06488935f, 0.05079614f, 
    -0.05808786f, 0.12077364f, 0.16023779f, 0.22016752f, 0.02458127f, 0.27214339f, -0.18183921f, -0.08455345f, 
    0.02843291f, -0.05246269f, -0.08399149f, -0.16108882f, 0.35176504f, 0.23021349f, -0.09968977f, -0.03231072f, 
    0.00120383f, 0.15043610f, 0.13868977f, -0.03502152f, -0.10049774f, 0.09342342f, -0.00055703f, -0.01221831f, 
    0.28869820f, -0.03502933f, -0.05744287f, -0.29960558f, 0.25061199f, -0.20741729f, 0.05077857f, 0.28435504f, 
    -0.09854828f, 0.08600496f, -0.00086449f, -0.04734170f, 0.27963501f, -0.13764951f, 0.09398749f, -0.04297832f, 
    -0.10768533f, 0.05683045f, -0.16847394f, -0.22850490f, 0.24424155f, -0.16498716f, 0.27957568f, -0.03768016f, 
    0.12553149f, -0.10890212f, -0.12119154f, 0.16057223f, -0.10893151f, -0.00916915f, 0.01528467f, 0.01638871f, 
    0.04938436f, 0.02345674f, 0.12053967f, 0.09447188f, -0.09163582f, -0.17328340f, -0.05919468f, -0.05813076f, 
    -0.11173098f, 0.05907880f, 0.08572536f, -0.06692605f, -0.08975298f, -0.03043189f, -0.11203573f, 0.04861079f, 
    -0.10479724f, -0.11522228f, -0.12767541f, 0.00560885f, -0.14119923f, -0.06173599f, -0.01364131f, 0.00856272f, 
    0.08596911f, 0.04761177f, 0.02464419f, -0.10895567f, -0.10787859f, -0.02342755f, 0.03083619f, -0.06786070f, 
    0.10580905f, 0.05068914f, 0.10833110f, -0.12771523f, -0.12276749f, -0.03608529f, 0.01846631f, -0.11597814f, 
    0.04058316f, 0.02900136f, -0.17163140f, -0.12958831f, -0.11171238f, 0.05661313f, 0.08017799f, -0.13058217f, 
    -0.05178792f, -0.10151404f, -0.00276294f, 0.03707472f, 0.03663952f, 0.06891524f, -0.01841303f, -0.04502542f, 
    -0.08478195f, -0.06506816f, -0.02725929f, -0.05276101f, 0.00049009f, -0.02555301f, 0.11980056f, 0.01697860f, 
    -0.04683619f, 0.04874125f, 0.01650347f, -0.17410311f, -0.05076772f, -0.23464178f, 0.12919831f, 0.17679611f, 
    0.01676586f, -0.02653030f, 0.00138414f, 0.19906077f, 0.07986005f, 0.13868271f, 0.00090279f, 0.11539359f, 
    -0.08773708f, -0.04086496f, 0.01912756f, -0.01188918f, 0.24204771f, 0.25649115f, 0.02854261f, 0.18678179f, 
    -0.02717772f, 0.31699756f, -0.11752822f, 0.08327363f, -0.22587313f, 0.05645675f, -0.03519314f, -0.06084041f, 
    -0.01255661f, -0.00625352f, -0.09970970f, 0.06783774f, 0.12238069f, 0.02018789f, 0.10435315f, 0.15667973f, 
    0.19580625f, 0.01779088f, -0.00539550f, 0.02304232f, 0.09075429f, 0.03168294f, -0.36458769f, -0.06579081f, 
    -0.15802458f, 0.33799347f, -0.33474097f, -0.13431041f, -0.19028385f, -0.07735857f, -0.05482946f, 0.08962698f, 
    0.05816150f, 0.08723629f, -0.00873558f, 0.09559923f, -0.26090068f, -0.09161980f, 0.08670310f, 0.26190346f, 
    -0.01144987f, -0.06593207f, -0.10065629f, -0.07155644f, -0.13712095f, 0.02309042f, -0.00129303f, -0.12668069f, 
    0.06394365f, 0.09930529f, 0.05068692f, -0.11459540f, -0.01630765f, -0.00898196f, -0.07811871f, -0.09517746f, 
    -0.07600209f, -0.00662580f, 0.03009168f, -0.13057710f, -0.01192966f, 0.10296749f, 0.04123513f, -0.00028024f, 
    -0.04518802f, 0.03827776f, 0.01856259f, -0.13595414f, -0.03225712f, -0.10380185f, -0.11913043f, -0.01425242f, 
    0.07666939f, -0.02478286f, 0.00651321f, -0.09544785f, -0.13721761f, -0.00981407f, -0.03621279f, -0.08106933f, 
    0.00847289f, 0.01243112f, -0.08463902f, -0.08834039f, -0.14494257f, -0.10218892f, -0.04762992f, -0.00551019f, 
    0.00152940f, -0.07258163f, 0.05495175f, -0.00683632f, -0.09625214f, 0.06093943f, -0.05561579f, 0.09024898f, 
    -0.10880967f, 0.05688790f, 0.05402790f, -0.08146201f, -0.02956674f, -0.06131494f, 0.10283382f, 0.03038448f, 
    -0.06775211f, 0.01921711f, -0.08451521f, -0.17086874f, 0.15711416f, 0.02568097f, -0.29078904f, 0.12422346f, 
    0.08075892f, 0.02026285f, 0.15766500f, 0.10252378f, -0.00444716f, 0.31515044f, -0.18992084f, 0.08946444f, 
    0.10228236f, 0.18856543f, -0.10855660f, 0.15783845f, 0.27415168f, -0.01596146f, 0.05452637f, 0.00627919f, 
    -0.05414254f, 0.03423323f, 0.18318219f, -0.15265112f, 0.29903305f, 0.23981622f, -0.07380731f, -0.03076495f, 
    -0.22089218f, 0.11908903f, 0.09281722f, -0.14286321f, 0.10862703f, -0.37380904f, -0.00254569f, -0.00361506f, 
    -0.30780554f, 0.05261545f, -0.03436517f, -0.21734238f, 0.01455071f, 0.08284952f, -0.24629495f, -0.21805000f, 
    0.05449079f, -0.12661457f, 0.08380548f, -0.19191311f, 0.09816381f, 0.31673184f, 0.34754026f, 0.08470606f, 
    0.18247175f, -0.30042005f, 0.05683168f, 0.17305595f, 0.06699285f, 0.13376907f, -0.31181899f, 0.07604577f, 
    0.05276863f, 0.00255442f, -0.10927459f, -0.37856483f, 0.05538088f, -0.15565756f, -0.49384081f, -0.17946866f, 
    -0.00799846f, -0.04077498f, -0.11232622f, 0.01266752f, 0.14897057f, 0.21095744f, -0.10077785f, -0.01607514f, 
    -0.02355042f, -0.02875148f, -0.08098707f, -0.06375873f, -0.05487173f, 0.12785755f, -0.01974624f, 0.15088537f, 
    0.18907645f, 0.19102095f, 0.27347788f, 0.14768490f, 0.09093364f, 0.24689458f, 0.09158140f, 0.15726264f, 
    0.22764164f, -0.03792638f, 0.04835173f, -0.18043521f, 0.15316465f, -0.54154646f, 0.06760047f, 0.23732695f, 
    -0.11053184f, -0.08376318f, -0.51254922f, 0.14795573f, 0.23436534f, 0.02718383f, -0.02773083f, -0.03989480f, 
    0.21253590f, 0.18192232f, 0.14529000f, 0.04556751f, 0.10104076f, -0.12694354f, 0.19535662f, -0.10806629f, 
    -0.04855603f, 0.08174496f, 0.04084292f, -0.00327668f, -0.07917264f, 0.12557250f, -0.13508229f, -0.10694681f, 
    0.11096978f, 0.05386915f, 0.01372373f, 0.02468073f, 0.10000456f, -0.06828610f, -0.15552957f, 0.34506086f, 
    -0.12604091f, 0.05083330f, 0.19503859f, 0.08031587f, 0.24118462f, 0.03155193f, -0.19619679f, -0.09551717f, 
    -0.03978206f, 0.30775306f, 0.07832611f, 0.04083010f, -0.08907934f, 0.18159631f, 0.01797874f, -0.09908026f, 
    0.05172743f, 0.15522347f, -0.15629114f, 0.08365585f, -0.49280900f, -0.24253067f, 0.02810446f, 0.23136733f, 
    -0.19671522f, 0.04957199f, -0.10015048f, 0.20385955f, -0.20681332f, -0.06238557f, 0.03783138f, -0.21035910f, 
    -0.09533785f, -0.19312824f, 0.13279684f, -0.26186559f, -0.22874904f, 0.05629159f, 0.06530546f, 0.00469516f, 
    0.23335373f, -0.20749338f, 0.08985950f, -0.13740189f, -0.17234842f, 0.36962423f, 0.12987471f, 0.31611389f, 
    0.06290112f, -0.17996559f, 0.07874658f, -0.04256174f, 0.25651345f, 0.00845711f, 0.06814043f, 0.02817802f, 
    0.01204665f, 0.09970690f, 0.03173380f, -0.05246747f, 0.10600982f, 0.01432103f, -0.18191744f, 0.30345607f, 
    -0.08270614f, 0.04768747f, 0.17195812f, 0.19395526f, 0.08483347f, 0.17651512f, 0.24996087f, -0.06645487f, 
    0.00514409f, -0.30017194f, 0.06090961f, -0.21366410f, -0.19606888f, 0.23458001f, 0.05997903f, 0.27611387f, 
    -0.17368245f, 0.18388237f, 0.04532539f, 0.08436664f, 0.09432303f, 0.06892093f, 0.03387825f, -0.08331740f, 
    0.10821232f, -0.04143495f, -0.07905660f, -0.10507464f, 0.15189111f, -0.00648192f, -0.09169159f, 0.27599728f, 
    0.20359847f, 0.05068438f, 0.10963030f, -0.01784243f, -0.16175482f, 0.07361522f, 0.00439037f, 0.10628054f, 
    -0.10049385f, -0.05056386f, -0.00526805f, -0.30969313f, -0.13548180f, -0.16388382f, -0.13614820f, -0.01556575f, 
    -0.09250546f, 0.11775195f, -0.05576479f, 0.10770246f, 0.10411354f, -0.08522470f, -0.12728070f, 0.05821874f, 
    -0.04749210f, 0.05715202f, -0.00511207f, 0.23385726f, 0.17014286f, 0.03223228f, 0.21003361f, -0.02973915f, 
    0.02020106f, 0.08109786f, -0.00503454f, -0.01815700f, -0.14108975f, 0.10224526f, -0.16219153f, 0.13611703f, 
    0.05432671f, 0.18325736f, 0.03953042f, 0.18759967f, 0.32209548f, 0.09476676f, 0.08796774f, -0.14927951f, 
    -0.14990810f, -0.05041093f, -0.09956253f, -0.22258906f, 0.38552427f, 0.06988282f, 0.07038400f, -0.07165447f, 
    0.02307404f, 0.14714631f, -0.02603228f, 0.12526706f, -0.07006378f, 0.02911245f, 0.07189307f, -0.18914592f, 
    0.18462202f, 0.07023473f, 0.15890609f, -0.01371289f, 0.14827107f, 0.10590538f, 0.04259949f, -0.11998123f, 
    -0.13014698f, -0.02028724f, -0.04004742f, 0.15756175f, 0.29938683f, 0.13637964f, 0.19412345f, -0.06622275f, 
    0.07748105f, -0.09522728f, 0.04154376f, 0.18299153f, -0.17272203f, -0.03815544f, 0.07145110f, -0.00663878f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.17570800f, 0.09218297f, 0.03273994f, 0.20710295f, 0.28160653f, 0.07656976f, -0.06748386f, -0.12278902f, 
    0.04701206f, 0.23333867f, 0.03738706f, 0.03131719f, 0.05905476f, -0.01289483f, -0.16243520f, 0.06873463f, 
    -0.01020848f, 0.04757134f, 0.05532125f, 0.18930645f, -0.06428998f, 0.10301196f, 0.00226174f, 0.01366547f, 
    0.03442574f, -0.08324404f, 0.27704370f, 0.23586462f, 0.25781947f, -0.07290650f, -0.23349544f, 0.19985814f, 
    0.11483430f, 0.05141725f, 0.03739444f, -0.08460408f, 0.01006075f, 0.21071392f, -0.07738349f, 0.09479515f, 
    0.25341612f, -0.00398404f, -0.15310907f, -0.10142367f, 0.19146353f, 0.21620381f, 0.02228072f, -0.06848104f, 
    0.25200805f, 0.06286910f, 0.14710689f, 0.14597517f, 0.04697704f, -0.02870972f, -0.04793019f, -0.11536691f, 
    -0.15030302f, 0.04347482f, -0.02282227f, 0.09367569f, 0.11191330f, 0.11752355f, 0.04435549f, -0.07724528f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.33312473f, -0.19177838f, 0.18172050f, -0.09419969f, -0.28341773f, 0.08568949f, 0.24509704f, 0.18397076f, 
    -0.13274163f, -0.31088227f, 0.11095113f, -0.34942496f, 0.17968379f, 0.08855321f, 0.22840215f, -0.24875449f, 
    0.16538419f, -0.28787291f, 0.00289521f, -0.11691610f, 0.05550910f, -0.39426577f, -0.01317367f, 0.13343449f, 
    0.18525730f, 0.09850176f, 0.06524752f, 0.08408548f, -0.57649541f, 0.07363395f, 0.14006698f, -0.40749502f, 
    -0.20291656f, -0.08002988f, -0.05386754f, 0.24983993f, 0.06439035f, 0.08892383f, -0.20727599f, -0.33748728f, 
    -0.39780852f, 0.01557054f, -0.52527153f, -0.20628680f, -0.00087934f, -0.31179994f, 0.08047345f, 0.18087859f, 
    -0.52598792f, 0.05938384f, -0.23405726f, 0.06065052f, 0.04780428f, -0.29615128f, -0.06615818f, -0.31258291f, 
    -0.02511277f, -0.08682317f, -0.04622784f, 0.24792038f, -0.46084353f, 0.05740051f, 0.13458100f, 0.08568002f, 
    0.21017964f, -0.34800246f, -0.02805759f, 0.15817963f, -0.18352598f, 0.25152063f, -0.31951761f, 0.10537878f, 
    0.13502897f, 0.30361813f, -0.28074178f, 0.30948541f, -0.64248258f, 0.12316804f, -0.02137647f, -0.48297736f, 
    -0.11233845f, -0.22371511f, 0.14043471f, 0.28477487f, -0.11885738f, -0.22619405f, 0.18316485f, -0.02263087f, 
    0.06671259f, 0.05879646f, 0.21924943f, 0.09560518f, -0.07913664f, -0.07064047f, 0.23851179f, 0.05944072f, 
    -0.41874093f, 0.08358920f, -0.61382556f, 0.17065866f, -0.15931681f, -0.00721541f, 0.01636155f, -0.18301494f, 
    -0.04444575f, 0.17003316f, -0.12966637f, -0.15334302f, -0.03314463f, 0.14291979f, 0.31284383f, -0.08796424f, 
    -0.03547373f, -0.15075392f, 0.27305588f, -0.01886789f, 0.03888846f, 0.43592626f, 0.06839316f, 0.05337932f, 
    -0.02197375f, -0.04928595f, 0.01359506f, 0.03809723f, 0.08476462f, -0.08245267f, 0.09542461f, -0.09396553f, 
    0.04231120f, 0.17300652f, -0.16334489f, 0.23163484f, -0.05440380f, 0.17542441f, -0.59426636f, -0.01214286f, 
    -0.23221463f, -0.06158824f, 0.20004748f, -0.58973718f, 0.25742811f, -0.00631827f, -0.32963446f, 0.07293298f, 
    -0.28447908f, 0.03468117f, 0.11198659f, -0.25668383f, -0.00564195f, 0.23670714f, -0.28246006f, 0.02894561f, 
    0.03237504f, 0.10348649f, 0.15719803f, 0.07548977f, 0.15590827f, -0.24165159f, -0.43132338f, -0.06900288f, 
    0.07307119f, -0.00367355f, 0.15347140f, 0.00510770f, 0.03210934f, 0.00762504f, -0.16926065f, -0.18364498f, 
    0.05533214f, 0.17933547f, 0.03456559f, 0.21602297f, 0.24147765f, 0.11978915f, 0.07224568f, 0.14067040f, 
    -0.04961676f, -0.29468730f, -0.18682709f, -0.39645097f, -0.06185766f, 0.37266764f, 0.04989945f, -0.38971472f, 
    -0.12021294f, -0.20890822f, -0.08541816f, -0.48412028f, -0.43285197f, 0.18710409f, -0.16685858f, -0.09658876f, 
    -0.13557827f, 0.19466540f, 0.04987133f, -0.23111752f, -0.07662576f, -0.03238376f, 0.14823480f, 0.07680149f, 
    0.01948235f, -0.39205617f, 0.04953123f, -0.26874137f, 0.18277609f, -0.20126425f, 0.13473132f, 0.41405329f, 
    0.08581085f, 0.28362459f, -0.14063957f, -0.24674602f, 0.01369556f, 0.13503289f, -0.32799318f, 0.01618453f, 
    0.06158129f, 0.02452619f, 0.06353197f, -0.27550691f, -0.05920306f, -0.13014321f, -0.02351494f, -0.19884227f, 
    0.19068883f, 0.07054325f, 0.21123610f, 0.02194141f, -0.07013891f, 0.05099383f, -0.20191123f, -0.03480578f, 
    -0.26304087f, -0.11616851f, 0.07488578f, 0.18643074f, 0.16356319f, -0.23087007f, 0.00075882f, -0.14767320f, 
    -0.20794511f, 0.06932511f, 0.21219982f, 0.03527389f, 0.00785130f, 0.00246778f, -0.10884872f, 0.01301222f, 
    -0.18599011f, -0.05486430f, 0.03865911f, -0.20419922f, -0.24488653f, -0.29228157f, -0.09247899f, 0.07006804f, 
    -0.18785876f, -0.13749900f, -0.02841972f, -0.08105624f, 0.12162208f, -0.11713568f, -0.08917221f, 0.16971342f, 
    0.08632828f, -0.17899165f, 0.09893886f, -0.04977107f, 0.06497155f, 0.15524328f, -0.16698338f, -0.57234401f, 
    0.21371014f, -0.44334191f, -0.05042489f, 0.01918504f, -0.04816828f, -0.17311862f, -0.17967652f, 0.00942532f, 
    0.01577989f, 0.11209895f, -0.45020667f, 0.08959534f, -0.18783166f, -0.14432970f, 0.11652476f, 0.15559492f, 
    0.23998810f, -0.06816941f, 0.24277340f, 0.10450581f, -0.08530228f, -0.08147585f, -0.25382242f, 0.25339642f, 
    0.13837188f, 0.02809934f, 0.09052992f, -0.00239745f, 0.12285545f, -0.16533732f, -0.04538784f, 0.01200947f, 
    -0.20605768f, 0.06164447f, -0.20233084f, 0.17632589f, -0.05968475f, -0.41140765f, -0.05733601f, 0.15087900f, 
    0.00190168f, -0.23220906f, 0.10781322f, -0.76630795f, 0.10353699f, -0.28645560f, 0.05759455f, 0.03980722f, 
    0.15577762f, 0.37452000f, 0.08271515f, 0.10696555f, 0.06562493f, 0.06015211f, 0.08876260f, -0.00409801f, 
    0.24474704f, -0.52201700f, -0.26541385f, -0.23627095f, -0.20224229f, -0.16261190f, -0.00581450f, -0.27614161f, 
    -0.12155858f, -0.20118454f, 0.09009229f, -0.22173877f, 0.07980170f, 0.03626485f, 0.28241074f, -0.11786640f, 
    0.15731733f, -0.00594625f, 0.01746709f, 0.09504793f, -0.08380863f, -0.25271985f, -0.20317066f, 0.09776235f, 
    -0.01362521f, -0.04617489f, -0.42882189f, -0.29812005f, -0.02915818f, 0.07740938f, -0.11210679f, -0.38079676f, 
    0.18491872f, 0.05137296f, -0.15323970f, -0.35248670f, -0.03531536f, -0.29493091f, -0.17445213f, 0.12153956f, 
    0.04042275f, 0.16106303f, -0.19246411f, 0.16661057f, -0.02567769f, -0.34909040f, -0.00289430f, -0.03734839f, 
    -0.08998046f, 0.26053879f, 0.05494496f, 0.03075999f, -0.14980227f, -0.05042094f, 0.06198443f, -0.01100235f, 
    0.16971077f, -0.08699589f, -0.61756980f, 0.08336391f, 0.30802184f, -0.43634090f, -0.57698715f, -0.50388539f, 
    -0.61929047f, 0.03940627f, -0.26844254f, -0.27774194f, 0.13401915f, 0.06374849f, -0.36773127f, -0.05590037f, 
    -0.53431088f, 0.06193040f, -0.22652915f, -0.23109303f, 0.08547926f, -0.01122652f, -0.43921772f, -0.38752601f, 
    -0.47413665f, -0.06401575f, 0.20711498f, -0.08333685f, 0.01848888f, 0.32006153f, -0.37987736f, 0.20451795f, 
    -0.01239851f, -0.13880560f, 0.00507174f, -0.09869666f, -0.12650396f, -0.00969747f, 0.13674358f, 0.08633697f, 
    0.17841525f, -0.25920814f, -0.05361545f, 0.21650799f, 0.06344699f, 0.18196326f, -0.40001824f, 0.16691537f, 
    0.04035768f, -0.50970334f, -0.08744908f, -0.23055747f, -0.09705148f, -0.29756099f, 0.05585642f, -0.31559455f, 
    0.08724070f, -0.49979270f, -0.05811806f, 0.12731363f, 0.15342760f, 0.18794882f, -0.29582965f, -0.29168883f, 
    0.10403308f, 0.04117278f, 0.18001042f, -0.58454984f, -0.31435332f, -0.08087882f, 0.00182766f, -0.44084978f, 
    0.00435762f, -0.18307678f, -0.00223978f, 0.07673783f, 0.31710377f, 0.09758986f, 0.11069363f, 0.09180071f, 
    -0.40928560f, 0.19350825f, -0.07213631f, 0.05645897f, 0.00193446f, 0.03841225f, 0.14155868f, -0.08788095f, 
    -0.07717364f, 0.04214105f, -0.03279667f, -0.19420083f, 0.04466746f, 0.00678695f, -0.18737324f, -0.09427596f, 
    -0.00118359f, 0.02043181f, 0.15366872f, 0.13768220f, -0.02212892f, -0.53873777f, 0.05320153f, 0.02078267f, 
    0.01765794f, -0.21577585f, 0.23244125f, -0.05483822f, -0.60461473f, 0.03806754f, -0.38537142f, 0.07009498f, 
    -0.08889029f, -0.27344963f, -0.29456455f, -0.11971287f, 0.06492629f, 0.11032962f, -0.06737319f, 0.28871202f, 
    -0.01442310f, 0.03779878f, 0.02956593f, 0.19577754f, 0.24676274f, -0.25567800f, 0.05485618f, -0.22781439f, 
    0.11141168f, 0.02873466f, -0.36326978f, -0.33304438f, -0.21818000f, -0.03718353f, -0.15990642f, -0.66367763f, 
    -0.33489624f, -0.19533059f, 0.01328916f, -0.03776152f, -0.18864237f, -0.17367925f, 0.13824911f, 0.31007442f, 
    -0.32624227f, 0.34533113f, 0.10851000f, 0.34288433f, -0.01637214f, 0.28676912f, -0.24892366f, 0.18416035f, 
    0.09200112f, -0.02974578f, -0.26865175f, -0.19748072f, 0.08529736f, -0.16497816f, -0.57430357f, -0.04108049f, 
    -0.41522232f, -0.06488805f, -0.21950716f, -0.01019383f, 0.05025239f, 0.16782396f, -0.09604608f, -0.42181331f, 
    -0.17339610f, -0.23281150f, -0.27548054f, -0.11131069f, 0.05269375f, -0.05705938f, -0.39045602f, -0.38667119f, 
    0.26756266f, -0.34783998f, 0.18480523f, 0.18022309f, -0.06735034f, 0.05196018f, 0.02423696f, 0.07169537f, 
    0.05534134f, 0.29018232f, 0.00605842f, 0.01651786f, -0.02329283f, -0.00512522f, 0.18530938f, -0.47211629f, 
    -0.33114487f, -0.03386506f, 0.21265024f, 0.02297889f, 0.07237840f, -0.20190856f, -0.37268877f, -0.13372006f, 
    -0.09981496f, 0.17369592f, 0.29783794f, 0.01853484f, -0.11187792f, -0.10764332f, 0.00520527f, -0.23126669f, 
    -0.14467977f, -0.31701684f, 0.12961434f, 0.04602656f, -0.08415300f, -0.51222289f, 0.49337894f, -0.40358075f, 
    -0.45587480f, -0.01904569f, -0.10895494f, 0.14858316f, -0.03035636f, 0.09703941f, -0.09489536f, 0.02643997f, 
    0.12755291f, 0.05879279f, 0.20058858f, -0.18517639f, 0.00236038f, 0.09462696f, -0.06192141f, 0.21327597f, 
    0.18553077f, -0.32218200f, 0.10608251f, -0.06832883f, -0.01190641f, 0.10221426f, -0.04396927f, 0.01194807f, 
    0.19253497f, 0.07944273f, -0.28864208f, -0.33692858f, 0.04909305f, -0.10637245f, -0.02057164f, -0.04421783f, 
    -0.10904256f, -0.38053742f, -0.09913808f, 0.24641989f, -0.19003707f, 0.22061139f, -0.04723938f, 0.07571093f, 
    0.07957451f, -0.29574409f, -0.61107856f, 0.20037167f, 0.25661200f, 0.22288363f, 0.15603802f, -0.04783072f, 
    -0.16140562f, 0.13066664f, 0.10140824f, -0.25172174f, -0.23385149f, -0.42490435f, -0.42938575f, 0.00060128f, 
    0.05374562f, 0.24898584f, -0.04204909f, -0.42255691f, 0.04234297f, 0.27733594f, -0.52909988f, 0.17196308f, 
    0.05745993f, -0.11550252f, -0.21463171f, 0.10301308f, -0.11637020f, -0.04161145f, -0.30001161f, 0.15517652f, 
    -0.00879876f, 0.08955504f, -0.57049882f, 0.21374866f, -0.04994361f, 0.08009741f, -0.11114575f, 0.23852925f, 
    -0.17050134f, -0.33708128f, 0.00306859f, -0.22644959f, -0.12678748f, 0.18620408f, -0.17761327f, -0.60366225f, 
    0.13662098f, 0.23522174f, 0.31779304f, -0.05345219f, -0.13313127f, 0.28327069f, -0.01377417f, -0.17210419f, 
    -0.19514982f, 0.01861134f, 0.11155976f, -0.08090019f, -0.26685408f, -0.38168505f, -0.58316147f, 0.17442608f, 
    -0.10519831f, 0.27059162f, -0.03954986f, 0.27869797f, 0.16676633f, -0.37511837f, -0.11787938f, -0.00631468f, 
    -0.00601626f, -0.45507637f, -0.31494769f, 0.14669707f, -0.59485191f, 0.09123350f, 0.24065576f, -0.07663700f, 
    0.18187705f, 0.22499108f, -0.60400712f, -0.09318648f, -0.00293337f, 0.21121339f, -0.15070078f, -0.11568845f, 
    0.20516671f, -0.10320573f, 0.16615063f, -0.34579247f, 0.11105105f, -0.25338063f, -0.22335099f, 0.24090828f, 
    -0.00914407f, -0.03445730f, -0.07655220f, -0.44490126f, 0.00118270f, -0.02207228f, -0.23932967f, 0.15978462f, 
    0.16469190f, 0.03695262f, -0.39080763f, 0.26787218f, 0.11572856f, 0.15930070f, -0.16633530f, -0.30428767f, 
    -0.13879280f, -0.28240389f, -0.09165674f, -0.50032973f, 0.07389147f, -0.06531450f, 0.10471962f, -0.38410446f, 
    0.01673386f, -0.18831532f, -0.11517965f, -0.28481254f, 0.14086333f, -0.14432509f, 0.11578741f, -0.43207672f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03362421f, -0.01734391f, 0.20564021f, -0.17338607f, 0.00863235f, 0.13873607f, 0.10079300f, -0.18641701f, 
    0.06263151f, -0.04237515f, 0.03676863f, 0.11374191f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
