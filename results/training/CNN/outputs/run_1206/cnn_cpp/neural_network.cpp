#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.62606841f, -0.07238419f, 1.17445648f, -0.51524913f, 0.68260920f, -1.18117476f, -1.18226445f, -0.48399308f, 
    -0.46664304f, 0.06393085f, -0.21343900f, -0.36267778f, -0.13849808f, 1.01978171f, -0.18546864f, 0.04599884f, 
    -0.15988950f, -0.23266320f, -0.38952085f, -0.28802982f, -0.22469026f, 0.07207147f, -0.01974106f, -0.24066539f, 
    -0.34211430f, -1.13624418f, -1.17475176f, -0.09694601f, 0.69712389f, 0.14938793f, -1.13256764f, -0.73464483f, 
    0.90765285f, -0.09966061f, -0.80461520f, -0.23691596f, 0.33352315f, 0.00709416f, 1.24430203f, -0.93001884f, 
    0.21430412f, -0.01807948f, -0.17261706f, -0.60173440f, -0.16688202f, 0.29713339f, 0.04369155f, -0.12369999f, 
    0.00153254f, 0.39636973f, -1.29172957f, -1.30711818f, -0.81128013f, -0.13045217f, 0.24857707f, -0.07660375f, 
    -0.19533773f, -0.77620643f, -0.60293698f, -0.23500472f, 0.32172146f, 0.06588199f, -0.17790902f, -0.10319244f, 
    -0.33689082f, 0.00387488f, -0.40728506f, 0.06049154f, -0.09607349f, 0.14483276f, -0.32889238f, -0.53296125f, 
    -0.47507304f, -0.16902712f, -0.24229993f, -1.38907468f, -0.77197593f, -0.82710451f, -1.03143978f, -0.69847870f, 
    0.70863390f, -0.34505484f, -0.83851957f, -1.00994706f, -0.31155363f, -0.43617788f, -0.05089946f, -0.03939923f, 
    -0.05271580f, -0.01702690f, 0.32734525f, 0.04824484f, -0.04693377f, 0.24825506f, -0.00176881f, -0.00246230f, 
    0.33268631f, 0.34654558f, 0.38143748f, 0.19243932f, -1.79653943f, -0.63527983f, -0.65648502f, -0.15185520f, 
    -1.46402216f, 0.66118479f, -0.26383308f, -0.75704795f, 0.43270573f, 1.38536453f, -0.23996350f, -0.14099680f, 
    0.18010056f, -0.45014215f, -0.05188201f, -0.20475376f, 0.16138156f, -0.48788139f, -0.09414454f, 0.18258967f, 
    -0.14681816f, -0.02659879f, -0.09864162f, 0.17755927f, -0.04249999f, 0.35471898f, -1.17083788f, 0.63618141f, 
    1.16454566f, -0.65718496f, 0.25428894f, -0.55762166f, -0.91162801f, -0.96687335f, -0.98703837f, 0.32014397f, 
    -0.58908373f, -0.27476227f, 0.26717827f, 0.60162240f, -0.26172358f, 0.19437267f, -0.19014427f, -0.07778445f, 
    0.62697458f, -0.09136371f, 0.03644454f, 0.23113531f, 0.21830387f, -0.53092289f, -1.19032001f, -1.45769274f, 
    0.62498391f, 0.71060079f, 0.83667946f, 0.70989066f, -1.11793315f, -1.10171103f, -0.13189821f, -0.40078831f, 
    0.29638425f, -0.25652707f, -0.12210180f, -0.27150220f, -0.52246499f, -0.52660435f, 0.11841200f, 0.46725529f, 
    -0.36406615f, -0.16462739f, 0.05807496f, 0.22491883f, -0.07179423f, -0.13370693f, 0.08812248f, -1.40829742f, 
    -1.07678223f, -0.81271887f, -0.45836762f, 0.76295072f, 0.02887164f, 0.05316526f, 0.22543798f, 0.60146272f, 
    0.61557537f, 0.16447432f, -0.12196352f, 0.24068657f, -0.36016610f, 0.41279677f, -0.07172308f, 0.11750924f, 
    -0.20450237f, 0.03258820f, 0.00633716f, -0.15403858f, -0.23739754f, -0.26570943f, -0.23125796f, -0.09205292f, 
    -0.37894893f, -1.11907411f, -0.44853953f, 1.00281119f, 0.40853244f, 0.41128930f, 0.64084393f, -0.21556677f, 
    -0.01949511f, 0.54545617f, 0.40063268f, -0.58492923f, -0.76042473f, -0.20763861f, 0.79131442f, -0.17652559f, 
    -0.20638816f, -0.01169540f, 0.13043141f, 0.04462601f, -0.09337197f, -0.45609570f, 0.09090434f, 0.26007307f, 
    -0.05203624f, -1.13106418f, -0.88854581f, -0.68360746f, -0.59792304f, -0.02060733f, 0.03945317f, 0.55990446f, 
    0.35345086f, 0.48640180f, 0.08339151f, 0.43575233f, 0.47729969f, 0.17404555f, -0.25223145f, -0.21877411f, 
    -0.29937762f, -0.47410482f, -0.22426529f, -0.56318736f, -0.31834605f, -0.08430824f, 0.51268476f, 0.58712399f, 
    0.47086802f, 0.16908062f, -0.83041424f, 0.59016335f, -0.63389170f, -0.47135788f, -0.51387709f, -0.52589601f, 
    0.19762580f, 0.38562438f, -0.92356098f, -0.93663120f, 0.02005649f, -0.36825743f, -0.44864398f, -0.27299228f, 
    0.31926394f, -0.11376271f, -0.73813874f, -0.79865551f, -0.56451410f, -0.78597844f, -0.29472071f, -0.26557720f, 
    0.16850419f, -0.48008794f, -0.50752562f, -1.55132675f, 0.44160283f, 0.44676292f, -0.32685474f, 0.88465118f, 
    -0.11306456f, -0.36996019f, 0.37198392f, 0.68586141f, 0.47273824f, -0.44148692f, -0.73199785f, 0.19144897f, 
    -0.63809538f, 0.38439259f, 0.23479374f, -0.22759488f, -0.27393743f, -0.06232355f, -0.02262862f, -0.29744485f, 
    -0.34095660f, 0.22628725f, -0.23525827f, -0.57840961f, 1.41188788f, -0.18918076f, -0.32664281f, 0.21368103f, 
    -1.12184250f, -0.21799275f, -0.27313900f, 0.07780922f, 0.71897078f, -0.11088180f, -0.21413068f, -0.07772477f, 
    0.04610268f, 0.16282983f, -0.11299195f, -0.09929451f, -0.09580827f, -0.23724975f, -0.18415286f, -0.44428828f, 
    -0.79956096f, -0.36688188f, -0.59371489f, -0.62519240f, -0.77885723f, 0.69164652f, 0.45307833f, 0.55583882f, 
    0.13497925f, 0.53439504f, -0.23708072f, -0.44954291f, -0.14988232f, 0.59740353f, -0.34622681f, 0.42234644f, 
    -0.61470735f, -0.27872804f, 0.07941489f, -0.32394335f, -0.16735907f, -0.01455154f, -0.19900878f, -0.15651333f, 
    0.28885233f, 0.04960807f, 0.29514149f, 0.05640278f, 0.38577420f, 0.21463232f, -0.64453232f, -0.20969200f, 
    -0.26227275f, -0.34634519f, 0.69896078f, -0.43378443f, -0.22021945f, 0.63927138f, 0.25210348f, 0.54670864f, 
    0.27530983f, -0.02207019f, 0.30160564f, -0.40611956f, -0.43107811f, 0.08855481f, 0.37688559f, 0.16479196f, 
    0.30427197f, 0.45427591f, 0.42051727f, -0.01015266f, 0.04207036f, -0.06473093f, 0.11587472f, 0.60832369f, 
    0.17297493f, 0.19800104f, 0.17545921f, 0.17717737f, -0.28407216f, 0.13388012f, 1.01589859f, -0.13749415f, 
    -0.21257883f, -0.16529348f, 0.29850543f, -0.25165167f, 0.09097447f, -0.13632368f, 0.36290675f, 0.18103738f, 
    -0.36564344f, -0.43343011f, -0.02222926f, 0.00104539f, -0.44620296f, 0.24063194f, 0.40338770f, -0.33046424f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00053607f, 0.70763946f, -0.51638383f, -0.35815799f, 0.01357743f, 0.23186530f, 0.74929488f, 0.33882040f, 
    0.81552547f, 0.84031689f, -0.19947946f, 0.61657095f, 0.10343309f, 0.39255002f, 0.72181320f, 0.50639343f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05674038f, 0.40009105f, 0.17528008f, -0.23995358f, -0.02108076f, 0.04420081f, -0.04267187f, -0.10934009f, 
    0.10282284f, -0.06734478f, 0.03671019f, 0.08862707f, 0.18687110f, 0.35667139f, 0.10331333f, -0.43647146f, 
    -0.28192216f, -0.23045364f, 0.15896681f, 0.03396595f, -0.04772419f, -0.17380974f, -0.15773119f, -0.22303414f, 
    0.69153309f, 0.37935907f, -0.05889844f, -0.17400135f, 0.27735099f, 0.13213250f, 0.42937788f, 0.03308666f, 
    -0.05984188f, -0.22299665f, -0.09667843f, -0.09854285f, 0.51257378f, 0.30952883f, -0.36486819f, -0.32538590f, 
    0.07585972f, 0.38475871f, -0.00208724f, -0.05977915f, -0.01561186f, 0.05645018f, 0.10101546f, 0.07573619f, 
    0.50833011f, 0.14456211f, 0.14485048f, -0.30819905f, 0.18805356f, 0.29982007f, 0.23834947f, -0.26033628f, 
    0.01655206f, 0.08208961f, 0.01561723f, -0.04210872f, 0.26454785f, -0.47943997f, -0.13404742f, -0.82237780f, 
    0.01998292f, -0.08582217f, -0.12951601f, -0.05751880f, -0.03880067f, 0.00845486f, 0.00283577f, 0.12785590f, 
    0.64004129f, 0.25315601f, -0.09333372f, -0.64976394f, -0.12296246f, -0.25807589f, -0.22714964f, -0.24146251f, 
    0.09222844f, -0.10283767f, -0.12309612f, -0.02920671f, 0.15876845f, 0.27619052f, 0.06756806f, -0.06493053f, 
    0.12929405f, 0.27262878f, 0.30230799f, -0.02285781f, 0.24515276f, 0.03011780f, 0.07609278f, -0.07507184f, 
    0.03940183f, -0.35432720f, -0.13386223f, -0.10094514f, -0.14789343f, -0.13805820f, 0.07108910f, -0.17590527f, 
    -0.15144868f, -0.22672945f, -0.14123602f, 0.14005388f, -0.12175521f, -0.00277986f, -0.12874250f, -0.16321604f, 
    0.16825968f, 0.09639294f, 0.03693867f, -0.35925347f, -0.27645722f, -0.10639955f, -0.26627105f, -0.06976445f, 
    0.39794618f, 0.15606253f, 0.04176797f, -0.03280181f, -0.37855241f, -0.04462776f, -0.32920045f, -0.11103630f, 
    -0.23254468f, -0.14787263f, 0.06205573f, 0.09248819f, -0.92751759f, 0.00601457f, 0.03640095f, -0.34173068f, 
    -0.01588419f, 0.09131032f, 0.15533859f, 0.10126295f, -0.04800465f, -0.09237771f, 0.21463861f, -0.03151593f, 
    -0.33324483f, -0.37242877f, 0.08018661f, 0.02311763f, -0.10975488f, 0.00198510f, 0.02989535f, 0.11955471f, 
    -0.17924808f, 0.01072732f, 0.18225859f, 0.34201539f, -0.41700581f, -0.07680236f, 0.07354702f, -0.04744861f, 
    -0.02552675f, 0.11825364f, 0.00380257f, 0.04480384f, 0.01133102f, -0.08994542f, -0.04025569f, 0.02811094f, 
    -0.07109390f, 0.12716793f, 0.09702463f, -0.05232582f, -0.34477621f, -0.28790441f, -0.41539028f, -0.44001344f, 
    -0.05833622f, -0.06686653f, 0.10856554f, -0.01549808f, -0.77910143f, -0.57350105f, -0.28481811f, -0.09503135f, 
    -0.02496539f, -0.07817771f, 0.06653848f, 0.10182939f, -0.20021060f, 0.00663493f, -0.11463517f, 0.00521576f, 
    0.45686632f, -0.05384035f, -1.02537572f, 0.00384294f, 0.12166483f, -0.42841473f, -0.19660765f, 0.19320387f, 
    0.00931286f, -0.01690996f, -0.06926792f, -0.16124350f, -1.06035602f, -0.28061745f, -0.01107261f, -0.04536594f, 
    -0.05284659f, 0.12834188f, 0.44909567f, -0.10179036f, -0.11803981f, -0.11722668f, 0.11893840f, 0.15235902f, 
    0.05837412f, 0.00548847f, 0.15628456f, 0.14367017f, -0.06050706f, 0.09177732f, 0.16792986f, -0.08314844f, 
    0.22226435f, -0.15019356f, -0.22880884f, -0.02325438f, 0.46082225f, 0.33479694f, 0.61662352f, 0.42191052f, 
    -0.00007604f, 0.20593306f, -0.01837380f, -0.01513531f, -0.03161664f, 0.05089398f, 0.02755134f, -0.13496324f, 
    0.39638329f, 0.41491446f, -0.18881425f, -0.11968788f, -0.10999016f, 0.10938305f, -0.17762081f, -0.04466629f, 
    -0.10042825f, -0.01599326f, -0.02140550f, -0.18386647f, -0.18690713f, 0.02373219f, 0.08977386f, -0.92339116f, 
    -0.06463142f, -0.21727772f, 0.04218435f, 0.09698393f, -0.05550273f, 0.07381497f, 0.14869933f, -0.06467117f, 
    -0.40636870f, 0.23124842f, -0.65365684f, -0.29917893f, 0.08807675f, 0.01784438f, 0.21362855f, 0.30604389f, 
    0.18040743f, 0.01746245f, -0.06410263f, 0.01329367f, -0.23376541f, 0.03247173f, -0.37253731f, -0.03645423f, 
    0.01107659f, 0.05006446f, -0.03309691f, -0.09023065f, -0.11543755f, 0.01880891f, -0.02290820f, 0.17440349f, 
    0.26032534f, 0.28875810f, -0.01663429f, 0.07958114f, -0.01852896f, 0.13431564f, -0.06326771f, -0.08306576f, 
    0.22034037f, -0.00263041f, -0.00541265f, -0.11480210f, -0.40626496f, -0.11992273f, -0.26847440f, -0.22513847f, 
    -0.09217744f, 0.19451140f, 0.26796106f, 0.22893822f, -0.16502532f, 0.26921904f, -0.05480888f, 0.11235789f, 
    -0.27006817f, -0.34221131f, 0.36953250f, -0.21550567f, 0.01238349f, 0.05383422f, -0.13244280f, 0.04371516f, 
    -0.04265134f, -0.03946657f, -0.11629702f, 0.00294049f, -0.52292377f, 0.38801125f, 0.03572808f, 0.30789530f, 
    0.07178667f, 0.07004213f, -0.07200006f, -0.01827092f, -0.16106993f, 0.09160154f, -0.05861857f, -0.43738335f, 
    0.28802592f, -0.11601514f, -0.03396770f, -0.20225772f, 0.11199449f, -0.05163421f, 0.02061666f, 0.06264435f, 
    0.13101608f, -0.30294448f, -0.26722801f, -0.27470434f, 0.10267302f, 0.18829000f, 0.14716513f, 0.27338615f, 
    -0.06921167f, -0.16923536f, -0.03907989f, -0.08018253f, -0.08683374f, -0.01889013f, -0.05769440f, 0.07067645f, 
    -0.28593996f, 0.05817764f, -0.06094489f, 0.05348289f, 0.10882836f, -0.01103318f, -0.00043243f, -0.12542215f, 
    -0.18140376f, -0.19336008f, -0.09142080f, 0.14543350f, 0.47477707f, -0.04020901f, 0.45633784f, 0.33905646f, 
    -0.06156626f, -0.05494900f, 0.15178505f, -0.13017222f, 0.10563911f, 0.14114963f, 0.14107890f, 0.22796853f, 
    -0.94079840f, -0.85764867f, 0.11584882f, -0.09077176f, -0.04576802f, -0.13266462f, -0.29188704f, -0.29923984f, 
    -0.00726163f, -0.15873459f, -0.04675301f, -0.04604591f, -0.13135213f, -0.43931392f, -0.86635363f, -0.01944239f, 
    0.09583814f, 0.11683062f, 0.34016475f, -0.03999035f, -0.10178919f, -0.01556014f, 0.06218421f, -0.10858893f, 
    -0.66514289f, -0.64268851f, 0.22698785f, -0.23656577f, 0.11717236f, -0.28237337f, -0.24379784f, 0.09622165f, 
    0.02718455f, -0.01414134f, -0.01969496f, -0.00503192f, -0.73656863f, -0.82527030f, 0.36417726f, 0.19999155f, 
    -0.11910427f, -0.12699497f, 0.14293826f, 0.24642402f, 0.05327027f, 0.04773141f, 0.01269380f, -0.10670754f, 
    0.61026704f, 0.47637001f, 0.60652357f, 1.27629197f, -0.27017227f, -0.04847677f, -0.15708853f, 0.08066805f, 
    0.02437309f, -0.02267745f, -0.04540797f, 0.17482141f, -0.57846934f, 0.42325449f, -0.28275523f, -0.43295631f, 
    -0.15979168f, -0.37368345f, -0.00969164f, -0.24512576f, 0.04230009f, 0.09038791f, -0.11876226f, 0.09520698f, 
    -0.37321052f, 0.54651636f, -0.63709050f, -0.09495059f, 0.22482572f, 0.05803039f, -0.15128551f, 0.32100964f, 
    -0.09698569f, 0.02456966f, 0.13827375f, -0.04756021f, 0.08221911f, 0.07263185f, 0.27508777f, 0.45723984f, 
    0.02575584f, -0.04146115f, -0.10020655f, 0.11056407f, 0.00504588f, 0.20168658f, -0.04054881f, -0.01727252f, 
    -0.13732111f, -0.11107834f, 0.31211084f, -0.12508440f, -0.01887678f, 0.06296155f, 0.04709200f, 0.14848894f, 
    -0.05013735f, 0.14697020f, -0.34283292f, 0.12576053f, -0.05572524f, 0.25644919f, 0.24242470f, -0.14623788f, 
    0.03072817f, -0.07641018f, 0.08615229f, -0.15462443f, 0.04876218f, -0.30969277f, -0.04743239f, 0.03263070f, 
    -0.34357107f, -0.12978379f, 0.20298214f, -0.27089384f, 0.09975252f, 0.11128683f, 0.26965520f, -0.21445233f, 
    0.01099352f, 0.16312304f, -0.21359767f, -0.16745643f, -0.01958917f, -0.09154645f, -0.36366948f, 0.28703949f, 
    0.00611542f, 0.01249495f, 0.05868341f, 0.01810301f, -0.05110857f, 0.24523523f, -0.01063647f, -0.02082172f, 
    -0.22655514f, 0.32485688f, -0.11367100f, 0.10689446f, -0.07533899f, -0.06196989f, -0.01255550f, -0.14508757f, 
    0.33158186f, 0.27562559f, 0.10011023f, 0.34510687f, -0.25611991f, -0.11788001f, -0.05607881f, -0.44404772f, 
    -0.08346567f, 0.07341131f, 0.13514891f, 0.10210726f, -0.07787734f, -0.03750893f, -0.15902027f, 0.03673517f, 
    -0.05706589f, 0.06730867f, -0.05652128f, 0.21958001f, -0.03947529f, -0.01282352f, 0.01680971f, -0.08044254f, 
    -0.01906927f, 0.14770494f, 0.04822015f, 0.01431934f, 0.07196757f, -0.28661096f, -0.18897082f, 0.28298098f, 
    -0.11664255f, -0.08768851f, 0.16526726f, -0.06224057f, -0.15556374f, -0.05514915f, -0.17713036f, 0.24825300f, 
    -0.04375825f, -0.42377952f, 0.23331386f, 0.11841764f, 0.06689820f, 0.03776557f, -0.24726918f, 0.20569280f, 
    0.10861228f, -0.07163230f, 0.33278567f, -0.07611355f, 0.24745290f, -0.06575130f, -0.34388906f, -0.20854948f, 
    -0.09857821f, -0.13298368f, -0.15183511f, 0.30894911f, 0.03938320f, 0.00250534f, -0.06757319f, -0.07777414f, 
    -0.36194226f, 0.08404129f, -0.44388527f, 0.14262784f, 0.28580022f, 0.00287486f, 0.01529135f, 0.05894092f, 
    0.14150991f, -0.00474869f, 0.03257553f, 0.24394356f, 0.07217817f, -0.21607634f, -0.05363935f, 0.41247255f, 
    -0.02828010f, -0.07404940f, -0.05585232f, -0.02953731f, -0.07328802f, 0.15206254f, -0.04320869f, 0.04164721f, 
    0.21975690f, -0.29267558f, 0.14618410f, -0.00471567f, 0.16509317f, 0.08300788f, -0.24725690f, -0.06526451f, 
    0.07951924f, 0.05035272f, 0.04786740f, 0.27532980f, -0.12632497f, 0.11157347f, 0.10769643f, 0.77471179f, 
    -0.27947786f, -0.01501203f, -0.02220628f, 0.03760704f, 0.08890139f, -0.18374163f, -0.15570047f, 0.04069308f, 
    -0.35041013f, 0.66394275f, -0.25141186f, -0.05946048f, -0.01660156f, -0.00251651f, 0.02329248f, 0.05171392f, 
    -0.32918388f, -0.03834163f, -0.02023514f, 0.06748603f, 0.16968976f, -0.05353757f, -0.24846292f, -0.03380660f, 
    0.39281753f, -0.01923589f, 0.13370372f, 0.12972230f, -0.22498806f, 0.17143281f, -0.16361101f, -0.00505022f, 
    -0.60164332f, 0.64204061f, -0.42543814f, -0.93726701f, 0.20682316f, -0.12716518f, -0.01745348f, 0.01347209f, 
    -0.18906595f, -0.14407404f, 0.12499706f, -0.22792926f, 0.26172137f, 0.02215643f, -0.05013086f, 0.19250832f, 
    0.15328009f, 0.01055588f, 0.05823220f, -0.06460550f, 0.14144449f, 0.04102163f, -0.08490133f, 0.00936452f, 
    0.31966981f, -0.27510849f, 0.00485281f, 0.27547929f, -0.01373547f, 0.04022420f, 0.01546072f, 0.00379474f, 
    -0.16561130f, -0.04648335f, -0.00954520f, -0.00694617f, 1.37845278f, 0.00442153f, -0.25186121f, -0.93001902f, 
    -0.03294708f, 0.00172250f, 0.10637891f, -0.20425545f, -0.23787089f, -0.09183616f, -0.04202184f, -0.11940735f, 
    -0.51980340f, -0.14306217f, 0.22736108f, 0.13230412f, -0.35750604f, -0.16120385f, -0.21504495f, 0.05471198f, 
    -0.01993875f, 0.20403631f, 0.04730158f, -0.09871549f, -0.37390861f, -0.31420934f, 0.53169054f, -0.05802827f, 
    -0.09083563f, -0.19108124f, 0.12304708f, -0.03882560f, -0.16721183f, 0.23353623f, 0.09495705f, -0.22033755f, 
    0.76404440f, 0.14280520f, -0.22923024f, -0.32341549f, -0.10422235f, -0.02809343f, 0.03241551f, -0.22095878f, 
    0.12461036f, -0.14769740f, -0.17170829f, -0.01091042f, -0.41368788f, -0.06348496f, -0.01043095f, -0.46370465f, 
    -0.01978430f, -0.26346382f, 0.15052423f, -0.02282516f, -0.27574459f, -0.04225248f, 0.08198987f, 0.09975635f, 
    0.01581630f, 0.52465832f, 0.21578950f, 0.37242904f, -0.25156111f, 0.45149666f, 0.04668791f, -0.16042595f, 
    0.01095247f, 0.06187980f, -0.02215619f, 0.06697185f, 0.19671412f, -0.36175683f, 0.49191824f, 0.15003549f, 
    -0.28672573f, 0.05104217f, -0.22530676f, -0.23992422f, -0.12552549f, -0.02594597f, 0.05747780f, -0.14678796f, 
    0.10876646f, 0.04910618f, 0.31125063f, 0.17762412f, -0.13725585f, -0.00808049f, -0.26590860f, -0.06838328f, 
    -0.05038545f, 0.10240289f, 0.22765684f, 0.15461792f, -0.03358351f, -0.04472379f, 0.10638167f, 0.19379207f, 
    -0.21460979f, -0.17527452f, 0.09093653f, -0.09561069f, 0.03055010f, -0.04620973f, 0.08341460f, 0.03302012f, 
    0.06197437f, 0.21735257f, -0.15579043f, 0.07185866f, -0.29474762f, -0.06485959f, 0.32139093f, -0.13559400f, 
    0.02868109f, -0.09477246f, 0.08065443f, -0.05462907f, 0.14406364f, 0.28111646f, 0.12870921f, 0.10088335f, 
    0.06590001f, 0.10436697f, -0.17302121f, 0.11663119f, 0.00363579f, -0.12087523f, -0.09867527f, -0.05214638f, 
    0.20403630f, -0.62245345f, 0.29575458f, -0.06042292f, -0.05887848f, -0.00113460f, -0.20577464f, -0.36306283f, 
    -0.19137904f, -0.13607183f, -0.07156903f, -0.16814189f, -0.21112081f, -0.21573082f, -0.18679215f, 0.09398527f, 
    -0.33304900f, 0.10215899f, -0.08527338f, -0.01729900f, 0.08409482f, -0.14212407f, -0.16694297f, -0.09473957f, 
    0.22567752f, -0.34458783f, -0.46010724f, 0.05251091f, -0.19220147f, 0.06846616f, 0.00965703f, 0.07883672f, 
    -0.25599104f, -0.12425976f, -0.47571963f, 0.01314811f, 0.39065823f, 0.11770793f, 0.11151528f, 0.36684203f, 
    0.06998466f, -0.06877267f, -0.19226900f, -0.27554533f, 0.15464917f, -0.33452356f, -0.09338395f, -0.07568546f, 
    0.05220106f, 0.19001293f, -0.01033092f, 0.23386575f, 0.04796769f, -0.13886048f, 0.16305712f, -0.12329203f, 
    0.00053104f, 0.00050213f, 0.07473809f, 0.12049170f, -0.65069366f, -0.62921411f, -0.16844003f, -0.30193269f, 
    0.10564588f, -0.00232333f, 0.12259060f, 0.13939524f, -0.11681625f, 0.01034607f, 0.06451669f, 0.21154252f, 
    -0.03227375f, 0.12467545f, 0.01823013f, 0.04227965f, 0.04475253f, 0.12033752f, 0.00370672f, -0.12874182f, 
    -0.01521668f, 0.20497254f, 0.00019795f, 0.48739937f, 0.08625415f, -0.12442185f, 0.19645956f, 0.41545391f, 
    0.12979726f, 0.22303964f, 0.03437189f, 0.22963879f, 0.04529803f, -0.09332501f, -0.06358466f, -0.12389237f, 
    -0.06637406f, 0.05405745f, 0.17897518f, 0.16855137f, -0.37346265f, -0.06833876f, -0.17979327f, 0.24421857f, 
    0.12973471f, 0.28734636f, -0.22030146f, -0.23233953f, 0.07265019f, -0.09601840f, -0.22934413f, -0.34000063f, 
    0.04077466f, 0.06865969f, -0.03573535f, 0.11893035f, -0.04696341f, 0.02038023f, -0.03729515f, -0.26970255f, 
    -0.17091265f, 0.01661252f, 0.35355374f, -0.07663775f, 0.09555913f, -0.08230685f, 0.12599844f, -0.10137787f, 
    -0.00779047f, 0.10201348f, -0.11332726f, -0.02529114f, 0.59520954f, 0.13409409f, 0.08138151f, 0.21124437f, 
    0.27094060f, 0.07735953f, -0.00557481f, -0.03866341f, 0.09951550f, 0.11590337f, -0.01256255f, 0.13150236f, 
    -0.01582058f, 0.28262383f, 0.20514907f, -0.22096033f, 0.10072486f, -0.01924623f, -0.12108750f, 0.00664439f, 
    0.02860766f, -0.14141522f, -0.08423211f, -0.05306327f, -0.30126268f, 0.31483316f, -0.01940122f, -0.50730586f, 
    0.31135765f, 0.01612761f, 0.09433187f, -0.11250352f, 0.05419504f, 0.05955138f, -0.03716012f, 0.03635386f, 
    -0.69934541f, -0.44297519f, 0.07624325f, -0.17367241f, 0.14828375f, 0.02560790f, -0.19335762f, 0.21617731f, 
    -0.06127294f, -0.14053150f, 0.02243838f, -0.01466243f, 0.31782591f, -0.12255506f, -0.21107656f, 0.08266901f, 
    0.13709122f, 0.11033512f, 0.03403673f, -0.04438302f, -0.03529096f, 0.18938100f, -0.07093744f, -0.02607832f, 
    0.36435336f, -0.17488945f, 0.58653808f, 0.03584227f, -0.13059065f, 0.03250838f, 0.24702795f, 0.02584994f, 
    0.20898007f, -0.09519175f, 0.07731069f, 0.13198133f, -0.50619298f, -0.32377383f, 0.07069179f, -0.15323405f, 
    -0.12135974f, -0.19799335f, -0.04899172f, 0.20403969f, -0.02453567f, -0.26078546f, -0.02497245f, -0.01676854f, 
    -0.18564948f, -0.19240734f, 0.33947948f, -0.05319115f, -0.00651332f, -0.20817488f, 0.00552058f, 0.04766628f, 
    -0.00855761f, -0.05133613f, -0.19895418f, 0.00674056f, -0.28261119f, -0.22619885f, -0.09384291f, -0.06050925f, 
    -0.08194560f, -0.07773112f, -0.10968146f, -0.03539819f, 0.35910550f, 0.04342563f, 0.05499923f, -0.16443799f, 
    0.07074670f, 0.39126512f, -0.24974035f, 0.03802343f, -0.04634151f, -0.03759487f, -0.03813516f, 0.07450340f, 
    0.21390557f, -0.05776318f, -0.00198409f, -0.17009114f, -0.66612619f, -0.07810257f, 0.33930299f, 0.21996450f, 
    -0.12707888f, -0.01402342f, -0.08091822f, 0.04161691f, -0.02056241f, -0.11518887f, -0.33777916f, -0.08864269f, 
    0.25124833f, -0.32965165f, -0.36987433f, 0.02457673f, 0.09346165f, 0.10986641f, 0.01889890f, 0.00674714f, 
    -0.11807661f, -0.42495263f, -0.17040709f, -0.82034349f, -0.02376480f, -0.17963581f, -0.13362293f, -0.07070497f, 
    0.17733073f, -0.01151553f, 0.07750851f, -0.23009817f, 0.05924748f, 0.05497011f, 0.11508416f, 0.12569983f, 
    -0.01004093f, -0.25521830f, -0.04189957f, -0.05352625f, 0.37299114f, 0.06746031f, 0.20766294f, 0.14096139f, 
    -0.26265609f, 0.03272733f, 0.12841995f, 0.03763163f, -0.16020437f, -0.10944889f, -0.37362206f, 0.33972809f, 
    0.15538925f, 0.04938236f, -0.28324530f, -0.05719613f, 0.04000001f, -0.07125279f, 0.16279751f, -0.00346773f, 
    0.02204857f, -1.20463657f, -0.84375858f, -0.45567387f, -0.23527330f, 0.34211612f, 0.09876226f, 0.19600843f, 
    -0.04258225f, 0.01169185f, 0.07794149f, 0.04122295f, -0.55633938f, -0.41016793f, 0.14554295f, -0.35807818f, 
    -0.23488472f, -0.24991648f, -0.45307535f, -0.44770429f, -0.14711773f, -0.04692751f, 0.00426902f, 0.10333033f, 
    -0.33834651f, -0.36705580f, -0.23876755f, -0.35448974f, -0.49300340f, -0.07598507f, 0.19365031f, -0.32079911f, 
    -0.19564128f, 0.11136613f, 0.09563341f, -0.10107671f, -0.84956700f, -0.66599703f, -0.77428150f, -0.64142102f, 
    0.14023033f, -0.30138439f, -0.21908613f, -0.57996565f, -0.07713962f, -0.05995460f, -0.06425678f, 0.02912670f, 
    -0.88094062f, -0.63609630f, 0.55020207f, 0.56524616f, 0.12365241f, -0.06508290f, -0.12444708f, 0.11286290f, 
    -0.08843446f, 0.08294367f, -0.03697984f, 0.05630606f, -1.01260316f, -1.13888371f, 0.36516470f, 0.39826787f, 
    0.32359007f, 0.34163558f, 0.08029417f, -0.41609129f, 0.16024323f, -0.23289777f, 0.17937759f, 0.04779598f, 
    -0.26784176f, -0.86169958f, 0.13469495f, 0.45235655f, 0.12747991f, 0.20439491f, -0.23754662f, 0.00788150f, 
    0.16029270f, 0.10246085f, -0.00077132f, 0.04136844f, -0.34737357f, 0.69896626f, 0.49110669f, 0.26199603f, 
    -0.16153920f, -0.07480630f, 0.04513093f, 0.09540120f, -0.10010219f, 0.08807137f, 0.12904035f, 0.28632647f, 
    -0.10681251f, -0.12745178f, -0.17971389f, 0.13316733f, 0.18665311f, 0.07082786f, 0.01841246f, 0.17930007f, 
    0.04082453f, -0.00579499f, 0.29706010f, 0.03152499f, -0.41541854f, 0.75554532f, 0.52817267f, -0.23904827f, 
    -0.12588035f, -0.04850417f, -0.36279064f, 0.28202778f, -0.19184047f, 0.05349969f, -0.03784176f, 0.07489865f, 
    -0.66828352f, -0.72377491f, -0.29809675f, -0.64484882f, -0.24158314f, -0.12577173f, -0.05706749f, -0.05702735f, 
    -0.02693774f, -0.00951117f, 0.37331721f, -0.14084016f, 0.35989714f, -0.07625572f, 0.14698982f, 0.16667211f, 
    -0.01994134f, -0.01692571f, -0.00259578f, 0.18015981f, 0.19228031f, 0.12735398f, 0.54019231f, 0.28552702f, 
    0.31864548f, 0.36673552f, -0.08074744f, -0.10454332f, -0.07587706f, -0.02024660f, 0.02204242f, -0.02646274f, 
    0.05431090f, 0.42836660f, 0.09989801f, 0.12313727f, -0.18890914f, -0.02641381f, -0.41446349f, -0.34340370f, 
    0.13153212f, 0.03457763f, -0.03417213f, -0.03283291f, -0.04825699f, -0.10675738f, -0.01873864f, -0.22267438f, 
    0.04004520f, 0.08497381f, 0.06195310f, 0.20594385f, -0.10247243f, -0.11519302f, 0.08513811f, 0.44138241f, 
    0.10524905f, 0.07985851f, -0.04093343f, -0.08376199f, -0.10854985f, 0.05860097f, -0.04628658f, -0.32479945f, 
    0.11136701f, 0.07765280f, -0.09266996f, 0.09827849f, -0.07604028f, 0.04612416f, -0.13137773f, -0.31763837f, 
    -0.97768092f, -0.12282088f, -0.23755321f, 0.14978963f, -0.22318603f, -0.06092397f, -0.08904244f, -0.30185685f, 
    0.01707693f, 0.05576981f, -0.09845579f, -0.00609532f, -0.31866291f, 0.22668746f, 0.12202542f, 0.46080601f, 
    0.11848632f, 0.03980068f, 0.02084858f, 0.07757950f, -0.03708952f, 0.12960055f, -0.05805358f, -0.09392997f, 
    0.65191430f, -0.97898078f, -0.01055323f, -0.62006557f, -0.16177319f, -0.03469817f, 0.24953100f, 0.59967226f, 
    -0.10006193f, -0.11070441f, -0.02285442f, 0.02702794f, -0.83397108f, -0.67318547f, -0.29311675f, -0.58983421f, 
    0.25187537f, 0.04989651f, -0.19338837f, 0.30707091f, 0.06027773f, 0.03441679f, 0.05282348f, -0.00188099f, 
    0.86054480f, -1.09695971f, -0.43881345f, -0.42635989f, -0.04686152f, 0.05037340f, -0.14151783f, 0.34388521f, 
    0.01907704f, 0.03948716f, -0.01280731f, -0.12700598f, 0.18534586f, -0.04136562f, 0.27565715f, -0.24661636f, 
    -0.15350851f, 0.08965287f, 0.00826397f, -0.04691701f, 0.03528918f, 0.02188210f, -0.01092393f, -0.10311457f, 
    -0.27250347f, -1.52899504f, 0.87452042f, -0.14383169f, -0.19491373f, 0.16852312f, -0.46362907f, 0.24805033f, 
    -0.10470395f, 0.06303143f, -0.15638125f, -0.18977174f, 0.91792262f, -1.06226146f, -0.39220542f, -0.52532023f, 
    0.01728774f, -0.03706674f, 0.00555522f, -0.28182951f, 0.03331374f, 0.18173398f, -0.12934655f, 0.02469116f, 
    0.44020984f, -0.53693002f, 0.07067203f, -0.30170503f, 0.03215618f, 0.14494364f, -0.01201990f, -0.15401994f, 
    -0.12576723f, 0.50217777f, 0.01970117f, -0.04357871f, 0.93897539f, -0.53851610f, -1.12719679f, -0.56866080f, 
    -0.03489292f, -0.24928266f, 0.13689490f, 0.04215895f, -0.12377720f, -0.08303684f, 0.40884247f, 0.22128427f, 
    -0.84813958f, 0.90939993f, -0.51757765f, 0.60758638f, 0.14594942f, -0.23773175f, 0.25832632f, -0.14244452f, 
    -0.16137491f, 0.07600487f, -0.08451915f, -0.15543990f, 0.20354450f, -0.01063723f, 0.00364499f, -0.10778391f, 
    0.07356813f, 0.02171113f, -0.10348273f, -0.16437767f, 0.18463327f, 0.04435135f, -0.16812730f, -0.10719021f, 
    0.06443571f, 0.00207053f, 0.04349739f, -0.00740255f, -0.02925996f, -0.08263641f, -0.01380916f, 0.05391535f, 
    -0.09716574f, -0.10185499f, 0.13563427f, -0.10537399f, 0.04284314f, 0.14646183f, 0.10248251f, -0.04866824f, 
    0.01732331f, 0.07306322f, -0.01740568f, -0.09501521f, 0.11287840f, 0.01729528f, 0.07171306f, -0.03947347f, 
    0.34945726f, -0.04868803f, -0.12746042f, -0.13413720f, -0.35231116f, -0.65572536f, -0.36021450f, 0.02172251f, 
    0.00776864f, -0.02702976f, -0.02333537f, 0.06745702f, 0.14647661f, 0.17504415f, -0.11092747f, 0.05745789f, 
    -0.01609182f, -0.01952460f, 0.03842777f, -0.01786451f, 0.13303199f, 0.06145947f, -0.28008565f, -0.22026862f, 
    0.67053401f, -0.29761261f, 0.01427886f, -0.10694779f, 0.37918231f, -0.13310345f, -0.14686075f, 0.01815358f, 
    -0.09046553f, -0.01693841f, -0.03856195f, -0.06337241f, 0.89172262f, 0.05548190f, -1.09320676f, -0.06561709f, 
    0.19080275f, 0.27273858f, 0.24648055f, 0.06495663f, 0.35418105f, -0.12416222f, 0.21655282f, 0.06161472f, 
    0.34833387f, -0.17143968f, -0.62469751f, -0.55778104f, -0.32015431f, -0.44900572f, 0.35039955f, -0.36266297f, 
    -0.06476510f, -0.27899021f, -0.17224114f, -0.13946755f, -0.19659442f, -0.82299590f, -0.77489632f, 0.14383088f, 
    0.08486247f, -0.10897339f, 0.08188114f, 0.02341110f, -0.03231061f, -0.09014958f, -0.05788869f, 0.07766842f, 
    -0.56661063f, -0.69639379f, -1.09274757f, 0.29292369f, 0.47970426f, 0.19324799f, 0.21558067f, 0.18050486f, 
    -0.00613237f, 0.09929014f, -0.01277436f, -0.02511476f, 0.10988745f, 0.16519065f, 0.09740257f, 0.16583195f, 
    -0.07538734f, -0.11501341f, 0.38462204f, -0.34126943f, 0.08542156f, -0.02330738f, -0.04109068f, -0.07318407f, 
    0.74681842f, 0.74012691f, -0.23131020f, -0.50487769f, 0.01837913f, -0.43706694f, -0.00422577f, 0.08108374f, 
    0.10440815f, 0.41653404f, 0.03718928f, 0.28973481f, 0.10074135f, -0.29917893f, -0.60105032f, -0.27071828f, 
    -0.10632335f, 0.01991152f, 0.05920319f, -0.03392085f, -0.10371935f, 0.00499652f, -0.11540671f, -0.15159974f, 
    0.07359972f, -0.21195620f, -0.18261480f, -0.23986642f, -0.12393174f, -0.13695002f, -0.01207174f, -0.04508277f, 
    0.19250184f, -0.25002080f, 0.26856133f, -0.03762991f, -0.38205385f, -0.58728039f, -0.58596563f, -0.09064132f, 
    -0.15009482f, 0.33124223f, -0.02739357f, 0.00251428f, 0.16512868f, -0.00616882f, 0.08693939f, 0.06619858f, 
    -0.30435252f, -0.41101590f, -0.77626598f, -0.26236406f, 0.20161596f, 0.16835900f, 0.19090660f, 0.43698505f, 
    0.08103199f, 0.22263758f, -0.09382280f, -0.44466904f, 0.71959168f, 0.05166216f, -0.32517347f, -0.45448878f, 
    -0.17077096f, -0.13025634f, -0.09509619f, -0.01572858f, 0.08859913f, 0.04822534f, 0.03545544f, -0.00340777f, 
    -0.49330384f, -0.10029563f, -0.01403728f, 0.09649128f, -0.06233577f, -0.10360695f, 0.05126741f, -0.05112102f, 
    -0.11842608f, -0.26979858f, -0.29137546f, -0.55711466f, -0.14020900f, 0.15578821f, 0.14613827f, -0.39336541f, 
    0.07237285f, -0.33565554f, -0.09860974f, -0.01461457f, 0.11070473f, 0.13284072f, 0.23393162f, 0.12681839f, 
    0.14656912f, 0.03748956f, -0.29643378f, -0.13962588f, 0.11279186f, 0.03892113f, 0.15732358f, 0.05692419f, 
    0.08182549f, 0.03929272f, 0.07517171f, 0.08814502f, -0.51214987f, 0.15939938f, -0.08246712f, -0.21617870f, 
    0.04152455f, -0.03272999f, 0.00067989f, -0.06985693f, 0.08565770f, -0.13711436f, 0.08440009f, 0.02898920f, 
    -0.13275018f, 0.24331939f, -0.79489070f, 0.25504503f, 0.35688606f, -0.17090122f, 0.08542510f, -0.05117461f, 
    0.05513737f, 0.10216329f, -0.02166105f, 0.02017046f, -1.01562095f, 0.08042315f, -1.01320612f, 0.39337760f, 
    0.13267292f, -0.34345320f, 0.00402923f, 0.09239972f, -0.00706612f, -0.23383918f, 0.05100354f, -0.14971106f, 
    -0.40120491f, -0.19703333f, 0.56908190f, 0.41626179f, -0.08362177f, 0.02281680f, -0.07795421f, 0.25258759f, 
    0.15194850f, 0.08321306f, 0.04413087f, 0.02661745f, -0.28295666f, 0.01113321f, -0.03138402f, -0.14032659f, 
    -0.60764360f, 0.32221192f, 0.00422700f, 0.31798056f, 0.16589668f, -0.11056215f, 0.00764680f, 0.03541588f, 
    -0.29593620f, 0.11285824f, -0.34410709f, -0.59936631f, -0.44523478f, -0.21786951f, 0.04552994f, -0.20852268f, 
    0.15070845f, -0.07213844f, -0.04314164f, -0.03637706f, 0.98315060f, -1.10667658f, -0.21813883f, -0.36858815f, 
    -0.01071544f, 0.05440114f, -0.25558320f, 0.26587188f, -0.19234332f, -0.10115705f, -0.09389281f, -0.13473426f, 
    -0.33548203f, -1.16567600f, 0.04030824f, 0.25217292f, -0.08845445f, 0.03642492f, -0.20095116f, -0.03714515f, 
    -0.05665378f, -0.12436013f, 0.00043548f, -0.05402209f, 0.32667351f, -0.02865114f, 0.67974555f, 0.60867608f, 
    0.13148369f, -0.14268383f, -0.10014692f, -0.37361720f, 0.09604543f, -0.14223343f, 0.08310208f, 0.08497862f, 
    0.30108532f, -0.37001827f, 0.54812294f, 0.45206618f, -0.19509199f, -0.03368276f, -0.35484916f, 0.01851168f, 
    -0.11404373f, -0.11550734f, 0.21191216f, -0.09327472f, 0.22425917f, 0.42904457f, 0.50232184f, 0.34534955f, 
    0.21382283f, -0.28176078f, -0.30902821f, -0.19605860f, -0.24518348f, -0.24696706f, 0.02991733f, 0.02752170f, 
    -0.50443804f, 0.50520533f, 0.05745559f, -0.09936979f, 0.05312680f, 0.04508964f, -0.09254790f, 0.00332062f, 
    0.12009692f, 0.01413023f, -0.01823870f, 0.18167730f, -0.45236650f, 0.27212641f, -0.06098395f, 0.35720277f, 
    0.05923189f, 0.04461469f, -0.19625627f, -0.13634476f, 0.18353003f, -0.05683124f, 0.05054165f, 0.17938377f, 
    0.13663436f, 0.11029278f, 0.14327268f, -0.06694782f, -0.02483419f, -0.12783515f, 0.17391558f, -0.00126639f, 
    0.01668662f, 0.14556313f, 0.26525131f, 0.25269976f, -0.33329099f, -0.47224495f, -0.51622593f, 0.37764838f, 
    0.16187158f, 0.19251858f, 0.24855357f, -0.02503708f, -0.02189751f, -0.11186061f, -0.04716422f, -0.07082744f, 
    -0.17202106f, -0.05239993f, 0.35972559f, -0.00706522f, 0.08701006f, -0.09365507f, 0.07910056f, -0.26297969f, 
    0.08291168f, -0.07934672f, -0.06581292f, 0.03935806f, -0.34432301f, 0.31551155f, -0.24540642f, 0.17949770f, 
    0.27243876f, -0.09887623f, 0.01645212f, -0.05983996f, 0.26743567f, 0.01336601f, 0.06950610f, -0.25806850f, 
    -0.60378039f, 0.09337240f, -0.54156238f, 0.21473520f, -0.20524558f, 0.05570150f, 0.24770474f, 0.37357759f, 
    -0.02702910f, 0.26268816f, -0.31110004f, -0.01657730f, -0.34834713f, 1.01612389f, 0.30401486f, 0.27974421f, 
    -0.01934256f, 0.43509921f, -0.30271614f, 0.26957995f, 0.13718349f, 0.26955494f, 0.09057990f, 0.18507548f, 
    -0.31798968f, -0.31461978f, -0.68574226f, 0.01744814f, -0.01048345f, -0.04308539f, -0.59214246f, 0.24340338f, 
    -0.05160215f, 0.03454046f, -0.12611292f, -0.43167403f, -0.14137636f, -0.41474086f, -0.25493434f, 0.41151786f, 
    0.07365240f, -0.36537388f, -0.17077886f, 0.29296187f, -0.15856427f, 0.16221447f, 0.23753411f, 0.04641856f, 
    -0.26369196f, 0.02502099f, 0.33735675f, -0.13716963f, -0.01446121f, -0.13072953f, 0.03971491f, -0.05321465f, 
    -0.20266861f, 0.18685362f, 0.01586485f, -0.19885802f, -0.39264965f, 0.26989898f, -0.15804635f, 0.26658693f, 
    0.14160827f, 0.03149106f, -0.16236129f, 0.03433514f, 0.11286501f, 0.00632356f, -0.01843551f, -0.19766110f, 
    -0.66700840f, 0.13149796f, -0.57592416f, 0.44545463f, 0.23741636f, 0.15708607f, 0.36131859f, -0.12066338f, 
    -0.08915031f, -0.29033974f, -0.24593799f, 0.29112571f, -0.20793118f, 0.41669503f, -0.06159761f, -0.39092872f, 
    -0.18499258f, -0.01464101f, 0.09598972f, 0.04280903f, 0.01955931f, 0.08991226f, 0.05178982f, -0.31502339f, 
    -0.63528937f, 0.64016348f, -0.22943668f, 0.22555333f, 0.20801499f, 0.03178878f, 0.01743880f, -0.10796528f, 
    0.02321266f, 0.10554808f, -0.00495273f, 0.00318463f, 0.31720546f, 0.06934673f, 0.01461683f, -0.15234295f, 
    -0.25914985f, -0.08649251f, 0.09395579f, 0.05464944f, -0.06728470f, 0.15292355f, 0.04104393f, 0.10551795f, 
    0.39265257f, -0.56275761f, -0.21347453f, 0.28974110f, 0.14749828f, 0.19571520f, 0.27504060f, 0.13137347f, 
    0.02997919f, -0.03537682f, -0.31863740f, -0.02125777f, 0.40702331f, -0.10020688f, 0.35772160f, -0.37882221f, 
    -0.32790485f, 0.02497739f, 0.09960538f, -0.01532916f, -0.08397703f, -0.16053106f, -0.34528878f, -0.21284676f, 
    -0.32760823f, 0.41487736f, -0.19834778f, -0.42675471f, 0.03761180f, -0.09341954f, -0.01395100f, -0.01140007f, 
    -0.14433426f, -0.51115733f, -0.47450429f, -0.74576908f, -0.02621029f, 0.51640177f, -0.84030867f, -0.28197071f, 
    -0.48629758f, -0.20958385f, 0.12976342f, 0.08336228f, 0.00297765f, 0.20767507f, 0.01038672f, 0.22492728f, 
    -0.51224208f, -0.11994429f, 0.32625484f, -0.32191658f, -0.23457403f, 0.15241496f, -0.05787659f, 0.08754624f, 
    -0.28391007f, -0.04258607f, -0.01209675f, 0.11606141f, -0.28087458f, -0.51040560f, 0.40010679f, -0.73976487f, 
    -0.38247457f, 0.23727624f, -0.25476938f, 0.01828879f, 0.13737376f, -0.10463584f, 0.03669732f, 0.01527924f, 
    0.73453575f, -0.21616712f, 0.94310832f, -0.72891587f, -0.01315647f, 0.16103877f, 0.35973161f, 0.00771355f, 
    -0.14620090f, -0.00928485f, 0.21026281f, 0.11690694f, 0.47624570f, -0.63259828f, 0.62517452f, -0.03379025f, 
    0.21930365f, -0.27970287f, -0.48072317f, 0.20340252f, 0.24014412f, 0.00873634f, 0.00194550f, -0.05064487f, 
    -0.40870059f, -0.55124611f, -0.02357970f, 0.42441595f, -0.17821555f, -0.21199204f, -0.25833806f, -0.14531355f, 
    0.02967013f, 0.20682405f, 0.27620134f, -0.05436188f, -0.02976670f, 0.06717588f, -0.07156612f, -0.43602005f, 
    -0.11941846f, 0.00258267f, -0.21012677f, -0.36406580f, 0.06552646f, -0.08644933f, -0.20335028f, -0.17313790f, 
    0.18842825f, 0.55154651f, -0.10170892f, -0.33208513f, 0.17675623f, -0.54063636f, -0.00938762f, 0.06795949f, 
    0.09695704f, 0.02429958f, -0.13402607f, -0.15840338f, -0.16682112f, 0.48293564f, 0.31719509f, 0.35999221f, 
    -0.27345723f, -0.14512806f, 0.04921596f, 0.03630213f, 0.18131775f, -0.05157388f, -0.00247371f, 0.22373208f, 
    -0.73011100f, -0.48646921f, -0.22794259f, 0.72562248f, -0.06754234f, -0.04375213f, 0.26696429f, -0.28448322f, 
    0.06292146f, -0.05019914f, 0.11542076f, -0.19297852f, -0.35883313f, -0.26900461f, -0.37139854f, -0.21919651f, 
    0.20497335f, -0.14731279f, 0.08625467f, -0.01188976f, 0.00499299f, 0.08361489f, 0.30177000f, -0.00429719f, 
    -0.57069629f, 0.22026962f, -0.94076359f, 0.65138489f, 0.24822885f, 0.01207354f, 0.35691532f, 0.18064648f, 
    0.11814946f, -0.12854189f, 0.37097338f, 0.31654418f, -0.50275761f, -0.46551839f, -0.24637663f, 0.12222665f, 
    -0.00974174f, -0.09000590f, 0.00041998f, 0.10856809f, -0.41662481f, 0.00020358f, 0.07673748f, -0.27730221f, 
    -1.01503038f, -0.41221398f, 0.23550814f, -0.28026649f, -0.18952335f, -0.11256693f, -0.40499175f, -0.15720241f, 
    -0.01947209f, 0.00565747f, 0.02851524f, 0.19059116f, 0.18414712f, -0.25022930f, -0.21483468f, -0.42270064f, 
    0.14672484f, 0.03821209f, 0.09602086f, -0.04993631f, 0.11612290f, 0.09126110f, 0.10411846f, 0.03102013f, 
    0.07332385f, -0.22017819f, 0.31285772f, 0.14428441f, 0.10612342f, -0.07116821f, 0.05484312f, 0.19691242f, 
    -0.02448652f, 0.01586227f, 0.08612960f, 0.08673044f, 0.67256564f, 0.03567561f, 0.19614160f, -0.05148186f, 
    -0.21671836f, 0.11051338f, -0.32517251f, 0.10238587f, -0.28875083f, -0.13171719f, -0.20023514f, -0.33931801f, 
    0.03726210f, -0.02089473f, 0.20291379f, -0.19926748f, 0.07184583f, 0.45402706f, -0.05611589f, 0.02331270f, 
    0.14105168f, -0.11575963f, -0.02244032f, -0.40363345f, 0.45611021f, 0.01337037f, -0.07916324f, -0.30283567f, 
    -0.02238434f, 0.00156798f, 0.00556222f, 0.26398131f, -0.06497026f, 0.18014146f, 0.06522143f, -0.14721137f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.39218521f, 0.29561195f, 0.23716539f, -0.12950969f, -0.21430039f, 0.14292374f, 0.08463836f, -0.08624317f, 
    0.08884501f, -0.07951840f, 0.09743561f, -0.03724005f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
