#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.17195515f, 0.64598769f, 0.96784288f, 0.57761276f, 0.06444845f, 0.68005830f, -0.52580416f, -0.53683889f, 
    0.30744344f, -0.49542826f, -0.20793007f, -1.06543064f, -0.34431359f, -1.22955036f, -0.92525411f, -0.83534181f, 
    -1.03472817f, -0.04425525f, -1.14734876f, -1.14203286f, -0.90100914f, 0.28479546f, 0.51875645f, -1.38589418f, 
    0.60627353f, 0.58167475f, 0.19459713f, -1.27865744f, 1.77768934f, -0.97068143f, -0.07665884f, 0.33321080f, 
    0.23221885f, 0.52536148f, 0.03081924f, 0.71622127f, 0.08179966f, -0.02571365f, 0.64983529f, 0.60631746f, 
    0.37303740f, 0.00222075f, 0.53953975f, -1.21247303f, -0.31893307f, -0.47712409f, 0.15631936f, 1.31050932f, 
    -0.98850965f, -0.39901364f, 0.76246572f, -0.05493739f, -0.05889513f, -0.26531470f, 0.16018154f, -0.42846847f, 
    1.49935234f, -0.29668325f, 0.02294055f, 0.45770636f, 0.53233045f, 0.50820661f, 0.33824262f, -0.61903429f, 
    0.04954585f, 0.14431112f, -0.80672443f, -0.60176122f, 0.18177766f, 0.32891810f, 0.81450140f, 0.80997425f, 
    -1.54875970f, -0.27777541f, 0.50874674f, -0.11171193f, 0.03311764f, -1.39184546f, -0.49546078f, -0.71976441f, 
    -0.85839051f, 1.53354073f, -1.08772206f, 0.16544920f, -0.27575287f, 0.16213590f, 0.27704167f, -0.41342261f, 
    0.19484809f, -0.32974708f, 0.98572493f, 1.36492944f, -0.42202023f, -0.06000521f, -0.31963283f, -0.19151674f, 
    -0.57863390f, 0.72272068f, 0.87531835f, 0.47067556f, 1.35557032f, -0.14922030f, -0.26014164f, -0.24395229f, 
    0.26858714f, 0.15053450f, -0.61336696f, -0.45587853f, -0.83627981f, 0.34073082f, 0.93285912f, -0.48552495f, 
    -1.11059952f, -1.61423981f, 0.57891560f, -0.03201973f, -0.19808047f, 1.54804933f, -1.21002197f, -0.63589221f, 
    0.42220053f, -0.54891604f, -0.90913582f, -0.25540194f, 0.18974276f, -0.24193710f, -1.50734377f, -1.32782614f, 
    -1.15941834f, 1.33392763f, 0.79815692f, 0.43977565f, -0.19245116f, -0.18321718f, 0.40717044f, -0.55628175f, 
    -0.07892982f, -0.65773588f, 0.51026189f, 0.93741786f, 1.14651895f, 0.43643001f, 0.65266502f, 0.41627294f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.18739186f, 0.09558920f, 0.23910335f, -0.15250683f, 0.86652011f, 0.21436960f, 0.29992524f, 0.88903028f, 
    -0.74489808f, 0.81282526f, 0.93215525f, 0.07419574f, 0.64478725f, -0.19940533f, 0.37953126f, 0.66272461f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05445133f, 0.38190433f, 0.01821749f, 0.07188238f, 0.02196809f, 0.11780448f, -0.07352541f, -0.02384030f, 
    -0.10715443f, 0.23820074f, -0.03681027f, 0.29863626f, 0.05698999f, -0.19880047f, -0.09604353f, 0.06278728f, 
    0.04818374f, 0.19949278f, 0.04316258f, -0.13970543f, -0.38960701f, -0.01644202f, -0.12484588f, 0.10067501f, 
    0.03479642f, -0.06868360f, -0.06746487f, -0.08971151f, -0.10333902f, -0.37403533f, 0.22354794f, -0.00207101f, 
    -0.12134323f, 0.00726194f, -0.02091647f, -0.37261912f, 0.00805950f, -0.05947437f, -0.17701563f, -0.03695250f, 
    0.04257188f, 0.03065603f, 0.16378999f, 0.11334904f, -0.08486503f, 0.86282039f, 0.30613947f, -0.36111832f, 
    -0.17882499f, 0.09813450f, -0.15610655f, 0.08496186f, 0.32195941f, -0.06454981f, 0.25791630f, 0.00038086f, 
    -0.07649291f, -0.13671812f, 0.19542378f, -0.03333319f, 0.24669351f, 0.06562253f, -0.16558613f, 0.09192167f, 
    -0.01589515f, -0.06419972f, 0.06316902f, -0.14253010f, -0.15591368f, 0.19773607f, -0.14785476f, -0.33004168f, 
    0.45307511f, 0.30563173f, 0.13987862f, 0.03058000f, -0.08111102f, -0.13463229f, 0.09261310f, -0.05571648f, 
    0.10583295f, -0.82311165f, -0.34696710f, -0.21535482f, 0.08004174f, -0.04052478f, -0.07916655f, 0.04702618f, 
    0.09997469f, -0.05722976f, -0.04823087f, 0.05888892f, 0.27001256f, -0.02609556f, 0.15192658f, 0.06025990f, 
    0.16828366f, 0.13605358f, 0.01518252f, 0.20872062f, 0.05276473f, -0.25341389f, 0.12395015f, 0.13820724f, 
    0.12332573f, 0.18424267f, 0.18415658f, -0.08053347f, 0.61815524f, 0.30066165f, 0.16743484f, 0.15881169f, 
    0.28536212f, -0.13725017f, 0.06542114f, -0.06899173f, -0.03676670f, -0.26058072f, 0.07541688f, 0.28061804f, 
    0.08981160f, 0.01229899f, -0.05809393f, -0.11773276f, 0.26455462f, -0.16647337f, -0.06468490f, -0.72912711f, 
    -0.58453530f, 0.04956409f, -0.09060724f, 0.03101652f, -0.39631838f, 0.13516191f, 0.22074090f, -0.18439077f, 
    -0.08064898f, -0.19920452f, 0.15830497f, 0.24220611f, 0.11475331f, 0.03493011f, -0.09791857f, -0.04376871f, 
    0.00019437f, 0.03062504f, 0.06924941f, 0.04808445f, -0.00789441f, -0.04152233f, -0.06734812f, -0.03213903f, 
    -0.04462726f, -0.02385886f, 0.00776108f, -0.08560644f, -0.03358134f, -0.08367364f, -0.01172632f, -0.01337009f, 
    -0.03369077f, -0.07559007f, -0.06209731f, -0.07907721f, 0.00953078f, 0.06307527f, -0.03594767f, 0.06833823f, 
    -0.02164400f, -0.06065224f, 0.01662916f, 0.06538030f, -0.04511198f, -0.02444451f, -0.07738049f, 0.03118138f, 
    -0.02045676f, -0.04457969f, -0.07053228f, 0.02669933f, -0.02407365f, -0.04374097f, -0.01358571f, -0.05504326f, 
    0.05654588f, -0.01941992f, -0.04065527f, -0.03360816f, -0.02161522f, -0.03105868f, -0.07343170f, -0.04567987f, 
    0.01488050f, -0.06862457f, -0.04045937f, 0.02038523f, 0.06036361f, -0.05725304f, -0.01371537f, 0.07138734f, 
    -0.02948648f, -0.06937265f, 0.03649978f, -0.08618613f, -0.03949914f, -0.02617346f, -0.00952832f, 0.01712017f, 
    -0.01929204f, -0.00669650f, -0.01677754f, -0.00261749f, -0.02937421f, 0.03409015f, -0.06233503f, 0.00329379f, 
    -0.00883544f, -0.09336411f, 0.06991949f, -0.05363820f, -0.03498171f, 0.05119046f, -0.08112213f, 0.04532173f, 
    -0.07231144f, -0.09130161f, -0.01312148f, -0.02802888f, 0.02822971f, -0.07411793f, 0.02524977f, -0.00770422f, 
    -0.04520901f, -0.01285456f, -0.02436554f, 0.02418172f, 0.02476410f, -0.03826426f, -0.06607473f, -0.03808216f, 
    0.04073903f, -0.04126892f, -0.03571579f, -0.00095712f, -0.00873285f, -0.01547942f, -0.04530540f, -0.03125254f, 
    0.06478329f, 0.06016150f, 0.01489284f, -0.03943766f, 0.00544184f, -0.06929297f, 0.03412959f, 0.01590841f, 
    0.00597269f, 0.03629228f, 0.02469160f, -0.00262573f, -0.04948948f, 0.05408757f, 0.01146377f, -0.04072550f, 
    -0.05402693f, -0.02945038f, 0.03793150f, 0.05970042f, -0.03808767f, -0.05598975f, -0.08925874f, -0.00858132f, 
    0.03704496f, -0.00031105f, 0.01281040f, -0.00969595f, 0.04582438f, 0.07215433f, -0.06607980f, -0.06655261f, 
    -0.04491633f, -0.07838652f, 0.05773905f, -0.05320800f, 0.04465974f, -0.05193236f, -0.01883767f, -0.04175411f, 
    0.24511054f, -0.12929463f, 0.15450647f, -0.08446810f, -0.12679303f, -0.27319020f, 0.10711598f, 0.15755743f, 
    -0.03665641f, 0.19024608f, 0.26062921f, -0.22769661f, -0.01932294f, -0.19186006f, -0.04056507f, 0.04466921f, 
    0.16873206f, -0.11377791f, 0.18316238f, 0.16468209f, 0.10390092f, -0.21805014f, 0.06646614f, -0.18147002f, 
    0.14627144f, 0.12182885f, 0.00606969f, -0.38642266f, -0.18556991f, -0.35655341f, 0.02162699f, 0.02136835f, 
    0.06449589f, 0.14330240f, -0.32964963f, -0.00327542f, 0.07648527f, 0.09571481f, 0.15806787f, -0.00479470f, 
    -0.10516556f, -0.15331616f, 0.03893121f, 0.07534084f, 0.36296445f, 0.49716797f, -0.34360692f, 0.55237919f, 
    0.00765317f, -0.07532351f, 0.42603669f, -0.08741381f, 0.21116251f, 0.09004461f, 0.17233551f, 0.30384395f, 
    0.19259758f, -0.13495132f, 0.07772057f, 0.14438702f, -0.35986131f, 0.03105630f, 0.17549565f, 0.01228701f, 
    -0.02907803f, -0.23181181f, -0.04825973f, 0.08392724f, -0.01476292f, 0.08540513f, 0.27106509f, 0.26260090f, 
    -0.15855342f, -0.30107135f, 0.20019183f, -0.03616161f, -0.42187414f, 0.07295084f, 0.04245771f, 0.30776492f, 
    -0.05056814f, 0.73652810f, 0.18421443f, -0.13731867f, -0.09772960f, -0.05726687f, 0.26062274f, -0.17275646f, 
    -0.21150912f, 0.29428035f, 0.34255356f, 0.05042693f, 0.31131667f, 0.17328449f, 0.10081273f, 0.00978981f, 
    -0.03156929f, 0.19845606f, 0.01311944f, 0.54315734f, -0.02164282f, 0.03416290f, -0.14014609f, -0.24007981f, 
    -0.27763921f, -0.15567727f, 0.08648778f, -0.02976734f, -0.08218309f, -0.25041527f, 0.07042078f, -0.20717677f, 
    0.00487715f, 0.06587548f, 0.10100713f, -0.04814531f, 0.08397595f, -0.04684301f, -0.66165859f, -1.03879941f, 
    0.20032476f, -0.16015843f, 0.01175529f, -0.07145450f, 0.01265730f, 0.10182128f, -0.66477233f, -0.05792224f, 
    0.15811920f, -0.02448234f, 0.20202649f, -0.12612569f, -0.01742567f, -0.20133466f, -0.22249688f, -0.34864011f, 
    0.09108308f, 0.07617851f, 0.10231167f, 0.22941105f, -0.05849244f, 0.07639201f, 0.14609247f, 0.06662766f, 
    0.02653571f, 0.04611444f, 0.15336138f, -0.07561617f, -0.05425328f, -0.25906563f, 0.05766807f, -0.13307218f, 
    -0.35902908f, 0.09573910f, 0.37033671f, 0.20660342f, 0.02709632f, -0.00090639f, -0.07066002f, 0.00501608f, 
    0.00833124f, -0.15528379f, 0.45681486f, 0.32799566f, 0.30161399f, -0.24283816f, 0.02380428f, 0.04425323f, 
    0.09687424f, 0.03202457f, -0.08889798f, 0.50879049f, 0.28666010f, 0.01703262f, -0.07287869f, -0.01706714f, 
    0.06440749f, -0.01318896f, 0.01958580f, 0.26460898f, 0.20452780f, 0.07915238f, 0.24698710f, -0.16261433f, 
    0.10109740f, -0.26273945f, -0.40384197f, -0.29277286f, -0.29510352f, -0.51590377f, -0.21208340f, 0.21400274f, 
    -0.07897397f, -0.07369750f, -0.10419718f, 0.12423168f, 0.31748021f, -0.00685674f, 0.06349509f, 0.51407087f, 
    0.20210096f, -0.01421210f, -0.21759686f, -0.04762284f, -0.13087355f, 0.37448868f, 0.18182196f, -0.28440753f, 
    -0.24476090f, 0.11309819f, 0.48606151f, 0.27389988f, 0.24750187f, -0.03729825f, -0.14664370f, 0.04339210f, 
    0.01659549f, -0.26009017f, 0.14863829f, -0.16056715f, -0.04410898f, -0.00486164f, 0.21116619f, -0.29310110f, 
    -0.37676373f, 0.15235910f, -0.05000949f, -0.01591320f, 0.12900884f, -0.22609809f, -0.15002923f, -0.01137695f, 
    0.12242201f, -0.13680705f, -0.19409744f, 0.08688286f, -0.04670862f, -0.22451229f, 0.26450017f, 0.25942400f, 
    0.08364553f, -0.02327036f, 0.30291274f, -0.00306829f, 0.34667441f, 0.26871669f, 0.08295409f, 0.18893857f, 
    0.22563359f, 0.07044737f, 0.10637412f, -0.12672430f, -0.74370563f, 0.00817214f, -0.02293657f, -0.01701716f, 
    0.09268061f, 0.09563079f, -0.08065792f, 0.20122832f, -0.06995134f, 0.16161552f, -0.06502338f, -0.33678755f, 
    0.01151210f, 0.20791680f, 0.12780727f, 0.08396143f, -0.03327574f, -0.25549334f, 0.25412005f, -0.49429226f, 
    -0.20693517f, -0.27014524f, -0.24669063f, -0.36270493f, -0.02208786f, 0.03225652f, 0.18388100f, 0.21123327f, 
    0.06826597f, 0.06128592f, -0.03744122f, -0.34382543f, -0.17010851f, 0.20881094f, -0.10854341f, -0.04059516f, 
    0.04512804f, 0.04774706f, 0.12810582f, -0.22644404f, -0.10412238f, -0.13628441f, -0.12811959f, -0.16060448f, 
    0.11249270f, -0.03178965f, 0.02847195f, -0.25124243f, -0.19446048f, -0.01734296f, -0.19409041f, 0.16016154f, 
    0.04659683f, -0.00432840f, -0.10095173f, -0.58229268f, -0.41577050f, -0.26818246f, 0.12498538f, 0.00121057f, 
    0.09982987f, 0.01310924f, -0.01677871f, -0.02330516f, -0.20864181f, -0.49648663f, 0.03134023f, 0.25092843f, 
    0.10029589f, 0.29464415f, -0.04103987f, -0.20418957f, -0.15006609f, 0.07780036f, 0.26854983f, -0.10404487f, 
    -0.12083559f, -0.16581926f, -0.04622179f, 0.03195535f, 0.04362640f, 0.54778695f, 0.05810680f, 0.03966288f, 
    0.03278126f, 0.25745410f, 0.02998097f, 0.05445843f, 0.15328692f, 0.18741544f, 0.16820702f, 0.22025922f, 
    -0.23300140f, -0.02438813f, 0.05346396f, 0.05541179f, 0.16359906f, 0.05487516f, -0.25566033f, 0.03579769f, 
    -0.58651322f, -0.10638294f, 0.11916778f, 0.14354184f, -0.16771549f, 0.23149695f, 0.03714007f, 0.24556929f, 
    0.30421349f, -0.12167398f, -0.71764612f, -0.35345531f, -0.30999830f, 0.12071241f, 0.12161990f, 0.17559269f, 
    -0.00146999f, 0.60014737f, -0.02379699f, 0.27032486f, -0.01438931f, 0.35688952f, 0.13772567f, 0.13057351f, 
    0.08539159f, -0.02575491f, -0.11957604f, 0.42421803f, 0.10674894f, 0.09939633f, 0.14688061f, 0.26262483f, 
    0.26815867f, 0.13623405f, 0.11621608f, -0.14498655f, 0.79030758f, -0.13591433f, -0.21239622f, -0.02643703f, 
    -0.00750497f, -0.01461692f, -0.00957253f, -0.02066431f, -0.27393183f, 0.10493432f, 0.22056547f, -0.26666674f, 
    0.05717173f, -0.35624483f, 0.17520186f, 0.30425704f, 0.11854837f, -0.41773254f, -0.71236449f, -0.26220641f, 
    -0.54116577f, 0.17407651f, 0.50515085f, 0.16623525f, 0.06447649f, -0.01160428f, 0.05173797f, -1.42951274f, 
    -0.96763599f, -0.33492580f, -0.11517312f, 0.03844162f, -0.01193590f, -0.16277435f, -0.20813769f, -0.04798254f, 
    -0.14089566f, -0.24345413f, -0.04074070f, 0.05268697f, 0.10234584f, 0.23252897f, -0.07464381f, 0.02052320f, 
    0.09667601f, 0.02854063f, -0.23943214f, 0.12690803f, 0.01271196f, -0.11963655f, 0.10225601f, -0.07875638f, 
    0.32305416f, 0.28714904f, 0.72542602f, 0.53935540f, 0.05034377f, 0.18239906f, 0.01504341f, 0.15107875f, 
    0.09832214f, -0.01382040f, 0.42385849f, 0.19600366f, 0.52454007f, 0.01119256f, 0.08500067f, 0.14533427f, 
    0.02048099f, 0.11729712f, 0.22304572f, -0.35340512f, -0.80285650f, -0.91879028f, -0.23801574f, -0.09613168f, 
    0.27886578f, 0.11518370f, -0.12600568f, 0.30501086f, -0.35427907f, -0.28026429f, -0.32021347f, -0.24721248f, 
    -0.19393060f, -0.19214009f, 0.19691868f, -0.07256753f, 0.02119230f, -0.32869080f, -0.29626328f, -0.17190984f, 
    -0.08925834f, 0.11085779f, -0.29122174f, 0.39388797f, 0.17699221f, -0.08723781f, 0.15469833f, -0.25806275f, 
    -0.91712981f, -0.13572608f, -0.15465274f, -0.10967891f, 0.28288561f, 0.11989427f, 0.23135208f, 0.13879612f, 
    0.26628307f, 0.50026661f, -0.09385604f, 0.04348693f, 0.03776533f, -0.03311409f, -0.00124008f, 0.31437784f, 
    0.37833720f, -0.26319161f, 0.07521430f, -0.09019680f, -0.02963055f, -0.21023124f, 0.56336451f, -0.00731606f, 
    -0.27491489f, -0.05432497f, -0.70837957f, -0.59141541f, -0.16792461f, 0.04637700f, 0.17626676f, 0.12950185f, 
    -0.06494332f, 0.24010703f, -0.56998682f, -1.16859376f, -0.72421581f, 0.05105509f, -0.28054401f, -0.08339749f, 
    0.39712575f, 0.02047988f, -0.00767781f, -0.12671047f, -0.69257206f, -0.45518732f, 0.08027089f, 0.10559431f, 
    0.31692263f, 0.02851792f, -0.13285539f, -0.18274042f, -0.01246727f, 0.00816654f, 0.14336975f, 0.05372539f, 
    -0.04723200f, -0.06562158f, -0.20890154f, 0.09673066f, 0.03910159f, 0.34023926f, 0.44342896f, -0.02161222f, 
    -0.50263399f, 0.19535626f, -0.30722135f, 0.12880218f, -0.26988706f, 0.00591590f, 0.17910714f, 0.05862833f, 
    0.51422113f, 0.04058347f, -0.01801131f, 0.13816324f, 0.26336867f, 0.04746586f, 0.24048044f, -0.31471848f, 
    -0.36081323f, -0.20875086f, -0.02114439f, 0.14939427f, 0.13807997f, 0.17989697f, 0.09158573f, 0.11066593f, 
    -0.12543334f, -0.09463089f, 0.05486789f, 0.09811922f, -0.16241975f, 0.06301390f, -0.07274929f, -0.36230043f, 
    -0.12324250f, 0.27307019f, -0.01564164f, -0.30456123f, 0.14511026f, 0.03680053f, -0.02877038f, 0.03278286f, 
    0.25142595f, -0.17901517f, 0.40060699f, 0.07009642f, -0.14697987f, -0.00583520f, 0.15274383f, 0.01136552f, 
    0.21722072f, 0.13112451f, 0.32082713f, 0.03041056f, 0.55402529f, 0.30727488f, 0.01652688f, 0.20233080f, 
    -0.19221066f, 0.04297768f, 0.34460557f, 0.09331053f, -0.35595042f, -0.18809913f, 0.17346874f, -0.00156524f, 
    -0.05656832f, 0.24090138f, -0.56139499f, 0.06634481f, -0.19178507f, 0.20308274f, 0.31632435f, 0.02800880f, 
    -0.01046727f, -0.16339521f, 0.23914100f, 0.03368931f, 0.06271198f, -0.04695216f, -0.16845541f, 0.32752150f, 
    0.23068689f, 0.00923146f, 0.23031588f, -0.15591441f, 0.18651979f, 0.31199950f, -0.08506714f, 0.22057281f, 
    0.10740673f, -0.09551293f, 0.00678382f, -0.05230421f, -0.29695737f, 0.22880097f, 0.14303984f, 0.35874623f, 
    0.94462025f, 0.63685149f, -0.05382808f, 0.15613768f, -0.01594164f, 0.05136142f, 0.01932672f, 0.18513899f, 
    0.22373472f, -0.07740609f, -0.04507784f, 0.30140874f, -0.01791498f, 0.28482381f, -0.07512926f, -0.16060410f, 
    -0.19115180f, 0.02261683f, -0.66696775f, -0.20353857f, -0.00991338f, -0.06888247f, 0.32197428f, -0.01137306f, 
    0.31629258f, -0.01685895f, 0.38790208f, -0.35561720f, -0.05507953f, 0.09154008f, -0.01570300f, 0.09565635f, 
    -0.08195940f, -0.23586828f, 0.07121041f, -0.07718101f, 0.34176627f, 0.28641862f, -0.05507150f, 0.06986545f, 
    -0.01797293f, 0.08197913f, -0.10042257f, 0.37234733f, -0.50443530f, 0.16993229f, -0.15526855f, 0.35634118f, 
    -0.07061296f, 0.36045337f, 0.21354938f, 0.02904770f, -0.45881575f, -0.00601612f, 0.29668400f, -0.03433767f, 
    -0.22513697f, 0.25645638f, -0.04731280f, -0.15072496f, -0.06136362f, -0.01651471f, 0.12992428f, 0.00124936f, 
    0.13440824f, 0.13277535f, 0.27504715f, 0.05880143f, 0.06446271f, 0.03781859f, 0.04833118f, 0.18421189f, 
    0.13624962f, 0.21319085f, 0.20615573f, -0.04023125f, -0.03682920f, 0.01694341f, 0.15364899f, 0.24463414f, 
    0.24218056f, 0.04607029f, -0.15698658f, -0.57079434f, 0.14999624f, -0.03774166f, -0.07439034f, -0.06864682f, 
    0.13144583f, 0.15466861f, 0.23885800f, -0.10068978f, -0.68737298f, 0.10260835f, -0.25411791f, 0.16022080f, 
    0.10884174f, -0.18447077f, -0.11309475f, 0.18661140f, -0.17069419f, -0.55650771f, -0.03290637f, 0.03264619f, 
    0.01394315f, -0.10581310f, -0.15566733f, -0.23933189f, 0.05294904f, 0.26983586f, 0.17717057f, 0.15608886f, 
    -0.03661859f, -0.12718041f, 0.16084540f, 0.25213119f, 0.00813412f, 0.10780143f, -0.11969903f, 0.19011953f, 
    0.03624414f, 0.25436071f, -0.05881527f, -0.04449777f, 0.11122365f, -0.04482094f, 0.07253705f, -0.06880200f, 
    -0.32034966f, 0.14945839f, 0.29111984f, -0.22172892f, -0.16456845f, 0.02570453f, -0.24437244f, 0.20061971f, 
    -0.22851871f, -0.03497773f, -0.11089484f, 0.22452289f, -0.04603346f, -0.25541821f, -0.22457179f, -0.00388417f, 
    0.27422339f, 0.04809330f, -0.48378220f, 0.18140283f, -0.26336461f, 0.09894911f, -0.02610164f, 0.16845030f, 
    0.18155617f, 0.15044855f, 0.01635599f, 0.10358002f, 0.03746758f, 0.21333054f, -0.28085014f, 0.06007569f, 
    0.13642758f, -0.18975537f, 0.21659578f, -0.08635075f, 0.14405388f, -0.29286101f, -0.10276025f, 0.11502842f, 
    0.00683555f, -0.06717531f, -0.05271111f, -0.18982735f, 0.22938752f, 0.38283247f, -0.02822786f, 0.42850539f, 
    -0.09189816f, 0.07561520f, 0.00166031f, 0.21493536f, -0.01790302f, -0.04808844f, 0.35775191f, 0.06059177f, 
    0.05314912f, 0.18087068f, -0.14635283f, -0.16887744f, 0.02793002f, 0.04122869f, 0.12143358f, -0.11094417f, 
    0.02247722f, -0.11055160f, 0.18273851f, -0.03335771f, 0.11118610f, -0.34287858f, 0.41417399f, 0.07131171f, 
    -0.22871539f, 0.20255306f, -0.22582716f, 0.01981634f, 0.29908368f, 0.05469797f, 0.01861385f, 0.28377950f, 
    -0.04584519f, -0.06601664f, 0.12636985f, -0.09830789f, 0.06225501f, 0.08614895f, -0.16923349f, -0.10127100f, 
    0.29330125f, 0.06739303f, 0.12512775f, 0.29746264f, -0.05206781f, -0.09058893f, -0.02107081f, -0.09875938f, 
    -0.07545377f, 0.31159845f, 0.01264898f, 0.29665959f, 0.17893426f, -0.28616828f, -0.09325397f, -0.04882239f, 
    -0.07266952f, 0.02922113f, 0.12836935f, 0.14415182f, 0.18637834f, 0.13719401f, 0.01510153f, -0.06542794f, 
    0.05456677f, 0.10130648f, -0.18110165f, -0.32245743f, -0.08991667f, -0.04837849f, -0.15376897f, -0.16392544f, 
    -0.51961720f, 0.02661370f, -0.13991173f, 0.00229839f, 0.26735425f, 0.15911458f, -0.02961576f, 0.27662027f, 
    -0.09637775f, 0.22280227f, 0.18014529f, 0.28196201f, 0.14170708f, -0.12709212f, -0.31820178f, -0.45647386f, 
    0.25851262f, -0.08893699f, 0.10451411f, -0.08565804f, 0.00309367f, 0.09761801f, 0.42093685f, 0.18792023f, 
    0.25982627f, 0.02492001f, 0.02012685f, 0.14484233f, -0.02062075f, -0.09185035f, -0.39855269f, 0.13582441f, 
    0.09899431f, -0.11363664f, -0.02853095f, -0.01005014f, -0.17813724f, 0.14641835f, -0.31508356f, -0.14996149f, 
    0.10100269f, 0.23014925f, 0.13096163f, -0.26888335f, 0.14260355f, -0.23248102f, -0.28994599f, 0.08633156f, 
    0.10311095f, 0.58708549f, 0.29179287f, -0.14580035f, -0.02824874f, -0.03070478f, 0.14440763f, -0.12450927f, 
    0.11402701f, 0.50159240f, 0.59471589f, -0.10956112f, 0.13298786f, 0.30886793f, -0.01629023f, -0.06374481f, 
    0.01043762f, -0.30150267f, 0.23417416f, 0.32587400f, -0.64900738f, -0.08426455f, 0.37344822f, -0.08134097f, 
    0.15301634f, -0.00398936f, 0.25342935f, 0.09704172f, -0.41897088f, -0.36976266f, -0.14797877f, -0.19074850f, 
    0.06551564f, -0.10690366f, 0.14412233f, -0.02360126f, 0.01500634f, -0.01693461f, -0.09642222f, -0.43617979f, 
    0.33243161f, -0.12291168f, -0.11002351f, -0.00302570f, 0.22348075f, 0.37422800f, -0.31869519f, 0.34584799f, 
    -0.47446039f, -0.06444904f, -0.09633906f, -0.24660976f, 0.04468506f, 0.08886477f, 0.14483948f, -0.20287742f, 
    0.01851533f, -0.14669627f, -0.11280651f, 0.04601240f, -0.00961252f, -0.06829885f, -0.05348274f, 0.09058648f, 
    -0.42714477f, -0.04028049f, 0.24679272f, -0.16663116f, -0.10178541f, -0.03313047f, 0.29366872f, 0.06165484f, 
    0.18183403f, 0.44316301f, -0.53639060f, -0.23645073f, -0.13815518f, 0.00765672f, 0.19368161f, 0.10449182f, 
    0.16681132f, -0.04166514f, -0.74012065f, -0.34338656f, 0.49594226f, -0.06112619f, 0.23500690f, -0.03663053f, 
    -0.00245661f, 0.00333599f, 0.02104414f, -0.36710292f, 0.35511717f, -0.15817668f, -0.11535980f, 0.16167280f, 
    0.02973621f, 0.24740304f, -0.18007544f, -0.24358597f, -0.00077757f, 0.14097372f, 0.55873519f, -0.10980926f, 
    0.25383627f, -0.02767097f, 0.01102907f, 0.14330432f, 0.21865156f, -0.53862745f, -0.45884344f, -0.82491362f, 
    0.22747833f, 0.18285049f, 0.13165811f, -0.02373092f, -0.05731087f, 0.42775637f, 0.04786870f, 0.03845285f, 
    -0.26527333f, -0.06627260f, -0.03928275f, -0.17035156f, -0.01966451f, 0.14530650f, -0.00975308f, -0.12912343f, 
    0.19259533f, 0.09413162f, -0.12325563f, -0.19348741f, -0.00896235f, 0.06047857f, 0.07358405f, 0.08977292f, 
    -0.21499027f, 0.29120269f, -0.05383035f, -0.18654241f, -0.17649236f, -0.13883205f, 0.06302167f, 0.09287340f, 
    0.04034714f, 0.32327837f, -0.02373619f, 0.09340382f, 0.28272751f, 0.09246475f, 0.06956787f, 0.33420950f, 
    0.40847778f, 0.19851907f, 0.27342924f, -0.00892557f, -0.45288301f, 0.22543880f, 0.34890833f, 0.34310776f, 
    0.07762971f, 0.21771613f, -0.20791322f, -0.22363493f, -0.17851625f, -0.70221871f, -0.06987786f, 0.21726307f, 
    -0.13205418f, -0.18493684f, 0.02979482f, -0.22630697f, 0.14202973f, -0.37221932f, -1.06077194f, -0.10892988f, 
    0.10671318f, 0.07976384f, 0.13139871f, 0.20893845f, 0.00334674f, 0.59252524f, -0.79990381f, 0.09629405f, 
    -0.09721953f, -0.38992682f, 0.18846060f, -0.06742316f, -0.45594603f, 0.13532135f, -0.02063134f, -0.15256424f, 
    0.03101050f, -0.10439371f, -0.08666221f, -0.31923038f, -0.01747113f, -0.11763929f, 0.15354516f, 0.11932079f, 
    0.06529562f, 0.46276909f, -0.01943561f, -0.12809391f, -0.33016706f, 0.13651776f, 0.04233437f, 0.16295923f, 
    -0.02610108f, -0.03200781f, 0.00699809f, -0.02738474f, 0.06052796f, 0.07284291f, -0.03793645f, -0.04178951f, 
    0.04690954f, -0.05039164f, -0.03381962f, -0.01010331f, -0.08791285f, -0.07770836f, -0.07043593f, -0.02745314f, 
    -0.02485608f, -0.02898254f, 0.02559985f, -0.01580638f, -0.06975251f, 0.07366652f, 0.07243256f, -0.01269346f, 
    0.01949370f, -0.01059080f, -0.04973459f, 0.04256746f, -0.01131108f, 0.02119954f, -0.01331503f, -0.05428014f, 
    0.01070176f, -0.08042546f, 0.05046609f, -0.02635635f, -0.00465917f, -0.08433679f, -0.04669599f, -0.03019872f, 
    0.02924114f, -0.06951076f, -0.07818936f, 0.00893433f, 0.06908709f, 0.00752815f, -0.07692944f, 0.02729017f, 
    0.03452176f, 0.02016257f, -0.04526873f, -0.00517703f, 0.06180384f, -0.06488024f, -0.00469849f, 0.05345763f, 
    0.02689249f, -0.01819943f, -0.04507569f, 0.05992527f, 0.04773503f, -0.02826819f, -0.04076046f, -0.06738424f, 
    -0.03557168f, -0.03729169f, -0.07591310f, 0.03530597f, -0.03972812f, -0.05904572f, 0.01813729f, -0.06813402f, 
    0.07794061f, -0.05692095f, 0.03410486f, -0.03363528f, 0.05447790f, -0.02477947f, -0.07365916f, -0.04328301f, 
    -0.05558758f, 0.00132376f, -0.00092535f, 0.07606777f, -0.01398755f, -0.07450811f, -0.00964759f, -0.06168105f, 
    -0.09073438f, 0.05931039f, 0.04698376f, -0.06971448f, -0.02194287f, 0.00155712f, -0.03453713f, -0.08146127f, 
    0.01386281f, 0.03893601f, 0.04178981f, -0.05894870f, 0.08171002f, 0.04618528f, -0.02836750f, -0.02840832f, 
    0.03797237f, -0.08227615f, -0.08587302f, -0.05694737f, -0.04997806f, 0.04624441f, 0.04532181f, -0.05791641f, 
    -0.05674394f, -0.07405355f, 0.00156091f, -0.03264682f, 0.05981064f, 0.02431264f, -0.05366814f, -0.07129507f, 
    -0.05733227f, 0.06135136f, 0.02857742f, 0.02109878f, -0.07623618f, -0.08623770f, 0.03639616f, -0.07207941f, 
    -0.02411167f, 0.02918315f, -0.07226807f, -0.02280059f, 0.00194759f, -0.05365360f, 0.03597865f, -0.06161767f, 
    -0.03959440f, -0.00216025f, 0.07153564f, 0.01035995f, 0.03648842f, 0.04995805f, 0.03047842f, 0.01788121f, 
    0.12039063f, 0.11192217f, 0.22289753f, 0.40529209f, 0.34350342f, 0.13441931f, 0.11454909f, -0.00665080f, 
    -0.01833930f, -0.34751996f, -0.09552599f, 0.07669915f, 0.07401515f, 0.13492975f, 0.18140060f, -0.02243854f, 
    -0.00323728f, 0.34822637f, -0.10372617f, -0.66452903f, -0.31437504f, 0.08075787f, 0.01600783f, 0.28905764f, 
    0.24445787f, 0.07860564f, -0.20524330f, 0.05616142f, -0.06873955f, 0.26664451f, 0.01214906f, 0.06294303f, 
    0.04298345f, 0.11875317f, -0.50990355f, -0.05742032f, 0.14063957f, 0.14845897f, -0.24481864f, 0.27577460f, 
    0.30032197f, 0.05194796f, 0.09204019f, 0.16763641f, 0.13765079f, 0.33514476f, 0.43865517f, -0.30059519f, 
    -0.19998926f, 0.22050823f, 0.11160112f, 0.14797573f, 0.04713441f, -0.11513273f, -0.13439628f, -0.02188410f, 
    0.04242792f, 0.02383732f, 0.22087106f, -0.02111171f, -0.19913064f, -0.22123165f, -0.37804580f, 0.19801527f, 
    0.27972609f, 0.13008820f, 0.05160203f, -0.00874405f, -0.03098103f, -0.57080990f, -0.50008935f, -0.66770661f, 
    0.06221158f, 0.22058910f, -0.32627156f, 0.28750592f, 0.22997804f, 0.12875237f, -0.00442191f, 0.04416269f, 
    0.17585200f, -0.47067824f, -0.18898338f, 0.46268994f, 0.07174734f, -0.12862386f, 0.20437339f, 0.02619126f, 
    0.13984367f, 0.19547206f, 0.18458009f, -0.05730186f, 0.04558062f, 0.20049372f, -0.00477462f, -0.12830518f, 
    0.10922267f, -0.21889502f, -0.23057389f, 0.17435013f, -0.15603231f, 0.76543897f, 0.05544985f, -0.03375911f, 
    0.01247482f, 0.38414359f, -0.11841296f, 0.10454682f, 0.52788949f, 0.20437656f, -0.00767798f, 0.19623552f, 
    0.00777528f, 0.08924485f, -0.14116649f, -0.19785443f, 0.02107558f, -0.21949673f, 0.66611511f, 0.79013532f, 
    -0.35295227f, 0.19291741f, -0.20595853f, 0.00695224f, 0.31400025f, 0.07717484f, 0.16485077f, -0.04119642f, 
    0.52784550f, -0.05329849f, -0.16724159f, 0.01190388f, 0.28941959f, 0.11388909f, 0.27294350f, 0.06818684f, 
    0.02889767f, 0.33336291f, 0.07807259f, -0.19875437f, 0.04438999f, -0.36536267f, -0.19531928f, -0.21554305f, 
    -0.09971831f, 0.09377746f, -0.15071143f, -0.32057020f, -0.08121552f, -0.25174868f, -0.22022824f, 0.12578891f, 
    0.13373351f, -0.30511901f, -0.44682437f, -0.10903198f, -0.01316945f, -0.07608062f, -0.03874973f, 0.02086852f, 
    -0.03273183f, 0.25208947f, -1.69735098f, -0.26053134f, 0.60366929f, -0.20009434f, -0.07837670f, -0.04703943f, 
    -0.01933804f, 0.03743376f, -0.00126361f, 0.21563895f, -0.22188504f, -0.29016566f, -0.41689965f, -0.34045845f, 
    0.06576555f, 0.22507724f, 0.01089062f, -0.12777004f, 0.10894801f, 0.14002432f, 0.18119662f, 0.02279777f, 
    -0.07228968f, -0.15612927f, 0.44763201f, 0.14415054f, 0.74123448f, -0.03174362f, -0.00675291f, -0.23662817f, 
    0.26545140f, 0.41315639f, 0.22903049f, 0.21984878f, 0.16952908f, -0.06705638f, 0.14640096f, -0.21032494f, 
    -0.22356506f, 0.12344468f, -0.07770143f, -0.18808487f, 0.02342803f, 0.00046684f, 0.00442831f, 0.12985551f, 
    -0.22022700f, -0.32410860f, -0.25601754f, 0.15640056f, 0.03502911f, 0.02251973f, -0.02753783f, -0.05031998f, 
    -0.12083061f, -0.23173700f, -0.35346791f, -0.12565267f, -0.16739281f, -0.03232510f, -0.17401887f, 0.10972521f, 
    0.23704137f, -0.03705378f, 0.12408613f, 0.02898999f, 0.11392739f, 0.26674956f, 0.18021132f, 0.24894097f, 
    0.11906707f, 0.55045474f, 0.41014856f, -0.35827997f, -0.07420673f, 0.10581448f, -0.15140706f, 0.19443551f, 
    -0.08118765f, 0.13824560f, -0.12645410f, 0.04888478f, -0.31432626f, 0.03138991f, 0.02241123f, -0.17170593f, 
    0.09340750f, 0.27086189f, 0.25971696f, 0.19691625f, -1.04433882f, -1.14924157f, -0.45299429f, 0.18288672f, 
    0.08011711f, -0.18500568f, 0.35402602f, 0.00551705f, 0.00127673f, -0.50376862f, 0.55527836f, -0.84240240f, 
    -0.22835504f, 0.11765935f, -0.02076543f, 0.01156622f, 0.01077163f, -0.21105129f, -0.99046469f, 0.41775274f, 
    0.51889461f, 0.02073113f, 0.23309791f, 0.11452743f, 0.00806247f, 0.09376911f, 0.15225488f, 0.02678792f, 
    0.29903749f, 0.03708387f, -0.41180739f, 0.03160280f, -0.12811202f, 0.18171853f, 0.01718123f, 0.14922778f, 
    -0.13482195f, 0.02088814f, 0.19313075f, -0.12600836f, -0.17244190f, -0.19706646f, 0.16684484f, -0.19796062f, 
    -0.16107671f, 0.14302169f, 0.35030535f, 0.12984931f, 0.22152269f, 0.09277689f, 0.14601277f, 0.24333264f, 
    0.06647132f, 0.09537383f, -0.50044310f, -0.29158580f, 0.20941442f, -0.02111575f, -0.09153758f, -0.00884416f, 
    0.00009852f, 0.08423141f, 0.15785646f, -0.40399060f, -0.00216737f, -0.69588351f, 0.45989135f, -0.26315147f, 
    -0.04872272f, 0.26234236f, 0.08498724f, -0.10819855f, 0.04071203f, 0.01692335f, 0.16679817f, -0.15121362f, 
    -0.02920639f, 0.10174134f, -0.05598091f, 0.11831396f, -0.28675401f, -0.50760698f, -0.67241997f, 0.35630623f, 
    0.14038038f, 0.21188249f, 0.11115158f, 0.06194900f, 0.04527080f, -0.18877895f, 0.20046143f, -0.21179107f, 
    -0.22492206f, 0.12267110f, 0.07884472f, -0.20890987f, -0.06279399f, 0.10120143f, -0.02929925f, 0.11591118f, 
    0.13674979f, 0.26846671f, -0.14945923f, -0.06440672f, -0.07979769f, 0.17305380f, 0.13098393f, -0.03521733f, 
    -0.75392777f, -0.55065554f, 0.21716544f, -0.07388739f, -0.11294961f, 0.09341231f, 0.22342673f, 0.08511333f, 
    -0.03972269f, 0.39903411f, -0.44005093f, -0.16890098f, 0.07297597f, 0.11112601f, 0.27941149f, 0.38749397f, 
    -0.09465906f, -0.08814337f, 0.58191502f, -0.11906613f, -0.32053155f, -0.21637093f, 0.16054077f, 0.22731921f, 
    0.16144103f, -0.11301541f, 0.17143172f, 0.31127182f, -0.36876941f, -0.02875284f, -0.10847539f, -0.06640667f, 
    0.20262638f, 0.16939367f, 0.03891774f, 0.14972854f, -0.13295493f, -0.64991176f, 0.15920396f, 0.05563693f, 
    0.15859240f, -0.11881498f, 0.12606269f, 0.05299914f, 0.01232465f, 0.49485064f, -0.07763291f, -0.37157086f, 
    -0.30073056f, 0.37914935f, -0.14886352f, 0.03934250f, 0.03377335f, 0.04890913f, -0.54662257f, -0.05279525f, 
    -0.21561497f, -0.17074132f, -0.04995926f, -0.02001972f, -0.05726760f, -0.00058094f, 0.05601520f, 0.12484634f, 
    0.12919003f, -0.33353242f, 0.07276938f, 0.18480791f, 0.14209774f, 0.17013745f, 0.16289501f, 0.23316842f, 
    -0.03357388f, 0.06715035f, -0.10855214f, -0.05019004f, -0.04184840f, 0.12229123f, 0.11016890f, -0.00876462f, 
    -0.08861294f, 0.01299178f, 0.00406862f, -0.00692594f, 0.07914513f, 0.00561199f, 0.11257932f, 0.04105121f, 
    -0.02673769f, 0.04490719f, 0.11917184f, -0.26044974f, 0.03232668f, 0.27559114f, 0.09723283f, -0.12192538f, 
    -0.08141455f, 0.09374008f, -0.16830845f, 0.18979375f, 0.40433261f, -0.11653831f, -0.27969074f, 0.09412123f, 
    0.24098907f, 0.25469321f, 0.30577505f, -0.30541706f, 0.12632862f, -0.06567996f, 0.11592209f, -0.23668088f, 
    0.00728150f, -0.19017743f, -0.10747346f, -0.14181966f, -0.00602444f, -0.65913522f, 0.32066271f, -0.00878024f, 
    0.02007950f, 0.11405093f, -0.00622763f, -0.28180990f, 0.06407490f, -0.12879081f, -0.02817957f, 0.10880495f, 
    -0.15761334f, 0.01117011f, 0.04917837f, 0.30384696f, -0.04996245f, -0.10288571f, -0.16552779f, 0.13879411f, 
    0.10004064f, 0.06347536f, 0.16598055f, 0.05140254f, -0.02673024f, 0.10749706f, 0.08733183f, 0.07295797f, 
    -0.36937580f, 0.18176456f, 0.14739487f, -0.04464923f, 0.05670738f, -0.30380407f, 0.14128810f, 0.04842270f, 
    0.28153172f, 0.17207113f, -0.47352645f, 0.46049026f, -0.11256021f, -0.04749366f, 0.50237280f, -0.02003908f, 
    -0.11784695f, 0.34578744f, 0.26765308f, 0.41563562f, 0.03650871f, -0.15998116f, 0.06700169f, 0.06404478f, 
    -0.08012908f, 0.38365284f, -0.11398637f, 0.24140038f, 0.29748777f, -0.01136416f, -0.18853731f, -0.08666661f, 
    0.22534910f, -0.08917958f, 0.08797505f, -0.07034496f, -0.65066230f, 0.14017212f, -0.25093022f, -0.23932883f, 
    0.06800929f, -0.24822494f, 0.06863198f, -0.03950202f, 0.04287660f, -0.25231621f, 0.22423942f, 0.97138274f, 
    -0.36325425f, -0.20908326f, 0.29300046f, -0.09997160f, -0.05165916f, -0.01822045f, 0.33487627f, -0.47293997f, 
    -0.25544164f, 0.16007216f, -0.14736331f, -0.06873482f, -0.04078129f, -0.03500448f, 0.05187003f, 0.05221996f, 
    0.08352411f, -0.36313021f, 0.06451999f, -0.26734683f, -0.03355208f, 0.09746767f, 0.14339040f, 0.08834055f, 
    -0.86673981f, 0.17984724f, -0.07378957f, -0.15659420f, -0.20092663f, -0.30040282f, 0.04400972f, -0.26778045f, 
    -0.17423101f, -0.28883919f, -0.46934801f, 0.33232161f, 0.10919353f, -0.06341080f, 0.04730273f, 0.03129751f, 
    0.22029941f, 0.02215024f, -0.57732904f, -0.46119037f, 0.43735871f, 0.09237796f, -0.00941968f, -0.02741638f, 
    -0.03761898f, 0.10097820f, 0.11371842f, 0.37682366f, -0.07739551f, -0.59000027f, 0.06184699f, -0.10156384f, 
    -0.04234868f, -0.04925625f, 0.12422267f, 0.24379769f, -0.28024551f, 0.28472546f, 0.08768366f, 0.20736480f, 
    0.04611771f, 0.10172777f, 0.42079353f, 0.13059929f, 0.07178435f, 0.63279158f, 0.00785044f, -0.64522374f, 
    -0.11053800f, 0.00142127f, 0.03063943f, 0.11031605f, 0.06782555f, 0.24248971f, -0.05558877f, -0.31780204f, 
    -0.93869770f, -0.25828493f, -0.20122994f, -0.20817938f, 0.02726791f, 0.15894704f, 0.10886543f, 0.46753910f, 
    -0.00203315f, -0.37288406f, 0.01578099f, 0.09522451f, -0.07844288f, 0.19174410f, 0.11322010f, 0.03328492f, 
    -0.72029614f, 0.44925123f, 0.47764689f, -0.03364856f, -0.14202003f, -0.09108474f, 0.00721497f, 0.17715850f, 
    -0.10978291f, -0.02641067f, 0.27436438f, -0.46491304f, 0.15812509f, 0.09568773f, 0.08498380f, 0.37984908f, 
    0.07975139f, 0.15434064f, -0.48624286f, -0.07998074f, -0.01403270f, -0.22098409f, 0.11647287f, -0.18179770f, 
    0.05487720f, 0.03025342f, -0.00458834f, -0.48015323f, -0.49925542f, -0.46788344f, -0.23789690f, -0.14039971f, 
    -0.60548401f, -0.02529707f, -0.01974293f, -0.30547422f, 0.12031055f, -0.20050903f, 0.54035985f, 0.01586736f, 
    -0.05532939f, -0.03299220f, -0.00653317f, -0.08893187f, 0.02629793f, -0.00582158f, 0.45263347f, 0.13088681f, 
    -0.15627019f, -0.10792833f, -0.30350131f, 0.01668760f, -0.05485979f, -0.09718516f, -0.25624841f, -0.03477800f, 
    0.60873669f, 0.05742063f, -0.03061285f, 0.09541475f, 0.06579264f, -0.01511665f, 0.08772470f, -0.04152398f, 
    -0.16209961f, 0.62290996f, 0.17143762f, 0.14804961f, 0.14452040f, 0.03711895f, 0.14685778f, 0.33581343f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.16509883f, -0.04373148f, 0.47177306f, 0.07056249f, 0.34136450f, 0.09747122f, -0.17367151f, -0.03867714f, 
    0.18013673f, 0.68872398f, -0.06452285f, -0.22514255f, 0.44359469f, 0.64967513f, -0.22588131f, 0.54502875f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.31889626f, 0.23135453f, -0.34764162f, 0.16824168f, -0.63340294f, 0.59701407f, 0.26046401f, 0.22919652f, 
    0.06088158f, -0.26530561f, -0.19362833f, -0.01284048f, -0.11977625f, -0.73993373f, -0.47545674f, -1.86392581f, 
    -0.48554066f, 0.13018624f, 0.38020000f, 0.48498920f, 0.31080502f, 0.42389700f, -0.19216858f, 0.03113909f, 
    0.25319043f, 0.02742282f, 0.00528190f, -0.25610682f, -0.36075628f, 0.17858444f, -0.30442286f, -0.26676688f, 
    0.03719185f, 0.18844600f, 0.25066450f, 0.04870974f, -0.87159002f, -0.50527680f, -0.16975884f, -0.11621585f, 
    0.15577549f, -0.32976282f, 0.06619603f, 0.29459181f, 0.55354244f, -0.19899157f, -0.72502297f, 1.00281036f, 
    0.68917197f, -0.12878297f, -0.58180320f, -0.29485399f, -0.02116106f, -0.30959225f, 0.41068521f, -0.05948225f, 
    0.30164593f, -0.10372208f, -0.12437177f, 0.24941595f, -0.84996939f, -0.99713415f, -0.31713662f, 0.52234763f, 
    0.20806251f, -0.11583927f, 0.02937882f, 0.17600444f, -0.43744799f, 0.54195124f, -0.35691702f, 0.11885636f, 
    -0.10274376f, -0.44470313f, -0.24158604f, 0.36462584f, -0.11062673f, -0.11704178f, 0.27844512f, -0.40280601f, 
    0.15780383f, -0.05609384f, 0.15222441f, 0.09482419f, -0.19423074f, 0.07018586f, 0.08715025f, -0.41630545f, 
    0.52381784f, -0.40216985f, 0.18812767f, -0.36910310f, -0.35421428f, 0.59460336f, 0.16685198f, 0.02182676f, 
    0.13397497f, 0.01070835f, -0.19057566f, -0.44619843f, -0.66132736f, -1.53550160f, -0.36757830f, 0.08733014f, 
    0.42764598f, 0.09690801f, -0.03760464f, 0.09868773f, 1.07033932f, 0.24985015f, -0.23770995f, -0.10286844f, 
    -0.01489509f, -0.02396987f, -0.41763946f, 0.34745663f, 0.32303697f, 0.00624202f, -0.27020514f, 0.51781535f, 
    -0.41335750f, -0.49409062f, 0.11665685f, -0.10080811f, 0.33536458f, -0.02826901f, 0.77564752f, 0.03428690f, 
    0.29156327f, 0.21896958f, 0.17157176f, 0.01840166f, 0.95247686f, -0.57888991f, 0.35352719f, -0.04501893f, 
    -0.50030583f, 0.01714969f, 0.02219472f, -0.52818114f, -0.24506681f, 0.13665636f, -0.78378719f, 0.49076086f, 
    0.32709068f, 0.14712287f, -0.50758255f, -0.32413575f, -0.40970179f, -0.09804724f, -0.52575570f, 0.70387197f, 
    -0.10353266f, 0.85821527f, -0.05782366f, 0.21008864f, -0.17763592f, 0.25445974f, 0.06254791f, -0.00028426f, 
    -0.56905943f, -0.21744658f, -0.25811982f, 0.12091345f, -0.11889587f, -0.34979114f, 0.54174882f, -0.59402609f, 
    -0.98821723f, 0.57346982f, 0.03685135f, -0.11376609f, -0.31802088f, -0.32126129f, 0.68842727f, 0.10485055f, 
    -0.10494851f, 0.02608813f, 0.59023046f, -0.69260097f, 0.13219802f, -0.52687210f, -0.20457292f, -0.58981270f, 
    0.37146574f, -0.25420836f, 0.03356222f, 0.43670380f, -0.26117676f, 0.00185261f, 0.47464737f, -0.08583146f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.36782399f, 0.61735266f, 0.08222158f, -0.28804460f, -0.60392565f, 0.09154038f, -0.09507857f, -0.54871339f, 
    -0.20080394f, 0.03592639f, 0.30815619f, -0.08930886f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
