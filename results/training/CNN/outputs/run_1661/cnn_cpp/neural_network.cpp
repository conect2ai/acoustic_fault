#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.27337572f, 0.46656677f, 0.14415874f, -0.41635361f, 0.38327879f, -0.28247240f, -0.50803149f, 0.68901199f, 
    -0.23350228f, 1.03969741f, -0.98080981f, -0.87063891f, 0.41872364f, 0.39415324f, 0.84074223f, -0.34478968f, 
    -0.19119701f, 0.03051857f, -1.42598653f, -0.22801405f, -0.47885734f, 0.44148469f, 0.28154841f, 0.78347969f, 
    0.25947759f, -0.00856099f, -0.01494757f, -0.24995421f, -0.38746989f, 0.77520818f, -0.38061970f, -0.55467778f, 
    0.85117728f, -0.50384432f, 0.04939625f, 0.50768828f, 0.77270031f, 0.33214989f, -0.40976691f, 0.31436709f, 
    -0.62418604f, -0.22187012f, 0.42888600f, 0.20418476f, -0.49963349f, -0.13809073f, -0.87965453f, -0.03532887f, 
    -0.68522310f, -0.76446950f, -0.28090161f, -0.61510307f, -0.48843074f, -0.75196671f, -0.91089612f, -0.98056459f, 
    -0.58706772f, -0.58125651f, -0.40223721f, -0.49709353f, 0.10301196f, -0.38982150f, -0.37985104f, -1.02504063f, 
    0.38061032f, 0.03583030f, 0.78844470f, 0.00479795f, -0.40823004f, 0.10628092f, -0.36318800f, 0.33762220f, 
    0.96640891f, 0.68023694f, -1.10491705f, -0.75464714f, -0.25431436f, 0.70884109f, -0.52625638f, -0.46752822f, 
    0.18804230f, 0.66934407f, -0.36904845f, -0.21452634f, -0.22114740f, 0.32580772f, -1.03772628f, 0.52320278f, 
    0.46462020f, 0.02621196f, -0.65860337f, 0.68763369f, 0.47055882f, -1.21659613f, -0.04507950f, 0.93520516f, 
    -0.00652777f, -0.12408540f, -0.32491985f, 0.39394292f, 0.65246266f, 0.49972075f, -0.25448167f, -0.00975872f, 
    -0.09888677f, 0.22688597f, -0.28558740f, 0.11563392f, -1.23289895f, -0.50909007f, -0.29133895f, 0.34995860f, 
    0.08467832f, 0.30255625f, -0.31755909f, -0.59736979f, -0.63585305f, -0.47248849f, -1.03467762f, -0.16495033f, 
    -0.21580289f, 0.64346188f, -0.16599938f, -0.04366013f, 0.16457747f, 0.65194178f, 0.84603643f, -1.31542230f, 
    0.52018243f, -0.16151175f, -0.59992027f, -0.73639220f, -0.17602643f, -0.03791448f, 0.45110759f, 0.16298164f, 
    -0.77389604f, -0.18265428f, 0.38505197f, 0.99306697f, -0.56523156f, -0.23438199f, -0.45093149f, 0.47481412f, 
    0.58596152f, 0.36790714f, -0.79315269f, -0.67785698f, -1.10547030f, -1.20598125f, 0.07976010f, 0.35076711f, 
    0.19556215f, -0.25781548f, 0.60977149f, -0.24144925f, 0.15857546f, 0.68929446f, -0.06561758f, -0.01353704f, 
    0.21292005f, -0.13666554f, -0.99804366f, 0.40526143f, 0.26278967f, 0.12921625f, 0.25248820f, 0.00849797f, 
    -0.14791690f, 0.34699583f, -0.14568265f, 0.41940957f, 0.21314195f, 0.13734502f, 0.17896724f, -0.40131202f, 
    -0.18315487f, 0.42661187f, -0.42765266f, 0.02475155f, 1.18565452f, -0.97772539f, -0.81721985f, 1.02630103f, 
    -0.01957618f, -0.37624618f, -0.31483835f, -0.06100374f, -0.19105585f, -0.76186961f, 0.83906442f, -0.55967540f, 
    -0.31875071f, 0.88663828f, 0.64346856f, -0.41964304f, -0.55288893f, -0.48200715f, 0.34996435f, 0.18358058f, 
    0.12598899f, 0.23389585f, 0.29398641f, 0.09435366f, -0.05777584f, 0.01259831f, -0.12766495f, -0.39000165f, 
    1.14717615f, 0.73956108f, 0.16031693f, -0.77135301f, -0.48183873f, -0.18461163f, 0.04566981f, -0.14879955f, 
    0.52433884f, 0.39259690f, 0.46468174f, -0.07066672f, -0.38433060f, 0.36748531f, -0.08584375f, -0.34914690f, 
    -0.05078735f, 0.16892003f, 0.59513479f, 0.76951313f, -0.70570403f, -0.47799665f, -0.42609352f, 0.61120403f, 
    0.30745119f, 0.29236975f, -0.66919816f, -0.59480977f, -0.86114395f, 0.32335651f, 0.49103686f, 0.21602535f, 
    0.38169155f, 0.42672855f, 0.13395555f, -0.81803536f, -0.21891724f, -0.14441390f, -0.16137770f, -0.53865308f, 
    -0.39715028f, 0.42318016f, -0.62859714f, -0.63996655f, 0.54503119f, -0.82300746f, -0.90778512f, -0.10677358f, 
    0.59348136f, 0.58494538f, -0.11190050f, -0.24129671f, -0.54321295f, 0.53175008f, -0.56784707f, 0.27430752f, 
    -0.05830095f, 0.48969254f, -0.47592735f, 0.44014519f, -0.39975005f, -0.04022039f, -1.04840016f, -0.57180828f, 
    0.01390180f, -0.48101950f, -1.35831916f, -0.66359669f, 0.00376047f, 0.02253624f, 0.77726752f, -0.48135081f, 
    0.32223305f, 0.26590565f, -0.03661020f, 0.62780744f, -0.21775867f, -0.19587912f, -0.14703527f, 0.11800662f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22924012f, 0.14667948f, 0.13970107f, 0.32579362f, 0.02557269f, -0.08618838f, -0.54359037f, -0.07942764f, 
    0.11725222f, -0.00686303f, 0.17587394f, -0.28020081f, -0.21608934f, 0.30790198f, 0.33599654f, 0.00410351f, 
    0.06381577f, 0.16845261f, -0.04863181f, 0.37336725f, 0.17088293f, -0.17246182f, -0.22077620f, 0.09568191f, 
    -0.30841213f, 0.05607930f, 0.10836229f, 0.23462498f, 0.03206966f, 0.37449792f, 0.15983488f, 0.30784065f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.42885235f, -0.31417713f, -0.11549338f, 0.01250135f, -0.16454586f, 0.02607608f, 0.01894689f, -0.05950895f, 
    0.00922238f, 0.02047780f, -0.02850641f, 0.05421207f, 0.00091165f, -0.04332208f, -0.01606856f, -0.03582698f, 
    0.08408047f, -0.11015121f, -0.12250032f, -0.00578366f, 0.17102608f, -0.34100756f, -0.80940855f, 0.08223796f, 
    -0.00709728f, 0.03911219f, 0.05044384f, 0.01075192f, 0.00841548f, 0.04009665f, 0.06883180f, 0.06626233f, 
    -0.16770461f, -0.12970208f, -0.10211182f, 0.10377929f, 0.11443225f, -0.04378554f, 0.09161305f, -0.03353012f, 
    0.14850213f, -0.24735884f, 0.07861223f, -0.04121759f, 0.11554611f, 0.06720972f, 0.18067488f, 0.16194181f, 
    0.04087806f, -0.15213604f, -0.10057575f, -0.13439298f, -0.03747165f, 0.01992526f, 0.10891174f, 0.01848551f, 
    0.07601970f, 0.07492699f, 0.02088492f, -0.00406135f, -0.64799058f, -0.33397704f, 0.39237335f, -0.16282384f, 
    0.05176327f, -0.19568272f, -0.16337800f, -0.05101242f, -0.09460350f, -0.11258531f, 0.07102862f, -0.19640765f, 
    -0.01791755f, -0.06830326f, -0.24603541f, -0.19634368f, -0.14625327f, -0.07061415f, -0.01123729f, -0.18855767f, 
    -0.18212220f, -0.08673074f, -0.20009096f, 0.23480248f, -0.03443328f, -0.01497765f, 0.02345240f, -0.11769514f, 
    0.01156538f, 0.04244386f, -0.04097751f, 0.10909914f, 0.00522154f, 0.03574434f, 0.03363477f, -0.06529598f, 
    -0.08488026f, -0.01152723f, -0.10438368f, -0.07357660f, 0.30687708f, 0.21047108f, 0.27980465f, -0.30549198f, 
    -0.01051189f, 0.11413839f, 0.08494885f, 0.18771134f, -0.06029947f, 0.09914009f, -0.00658837f, -0.01219446f, 
    -0.05301449f, -0.10019401f, -0.17814755f, -0.00498496f, -0.20017210f, -0.04679658f, 0.17714363f, 0.10464244f, 
    0.45006740f, 0.28223974f, 0.17653953f, -0.35781762f, -0.01991242f, 0.28866732f, 0.25338912f, 0.31930310f, 
    0.06064248f, 0.07591321f, 0.00942691f, 0.00628915f, 0.00983500f, 0.03484974f, -0.01485698f, 0.00337163f, 
    -0.05447463f, -0.10755992f, -0.02357808f, 0.05052077f, 0.35749054f, 0.26429024f, -0.51324183f, -0.41470513f, 
    -0.03326863f, -0.07149624f, 0.09228005f, -0.07769302f, 0.08811984f, -0.16275483f, 0.01937596f, -0.19677618f, 
    0.00248361f, -0.02818665f, 0.11861742f, -0.15797454f, 0.06423198f, 0.02724516f, -0.01813180f, -0.05416325f, 
    -0.60429984f, 0.21278185f, 0.32922399f, 0.04359737f, -0.83396500f, 0.01205605f, -0.00641794f, -0.13605806f, 
    0.02310774f, 0.06540296f, 0.07469063f, -0.02476545f, -0.07096665f, 0.08425803f, 0.08442827f, 0.07342134f, 
    0.06345997f, -0.03073128f, 0.03985859f, -0.25366053f, 0.14527811f, 0.17331411f, -0.12904274f, -0.04145719f, 
    0.07273173f, -0.16544051f, 0.10551224f, -0.06958389f, -0.08461702f, 0.04480435f, -0.20500466f, 0.02224627f, 
    0.09499371f, 0.00078710f, -0.03151593f, -0.05222982f, -0.05648305f, -0.24432147f, -0.28482264f, 0.03650605f, 
    -0.92332172f, 0.08818218f, 0.58075094f, -0.01100182f, 0.00746992f, -0.04683131f, -0.10951116f, -0.14486836f, 
    0.09914921f, -0.02553963f, -0.02696867f, -0.01436191f, -0.05312978f, 0.06018360f, 0.02649598f, 0.03130536f, 
    0.09989829f, -0.09087346f, -0.17839922f, -0.03051336f, -0.15395011f, -0.07797793f, -0.16268535f, -0.01061477f, 
    0.05025143f, 0.07694201f, 0.02548805f, 0.00574157f, -0.01265639f, 0.01319012f, -0.00137030f, 0.09132457f, 
    0.07329383f, 0.11922383f, 0.13387564f, 0.14435367f, -0.06330176f, -0.03014191f, -0.04926766f, -0.02900116f, 
    0.50342494f, 0.23813505f, 0.15780257f, -0.27813590f, 0.02269737f, 0.00801722f, 0.19609556f, 0.07878075f, 
    0.12257428f, 0.05626192f, 0.00048259f, -0.00817523f, 0.01367115f, 0.00919159f, -0.10259844f, -0.01749408f, 
    0.05237437f, 0.11780007f, -0.04183333f, -0.06067118f, 0.30788872f, 0.35687044f, -0.15379910f, -0.10096706f, 
    0.00622060f, 0.10131119f, 0.08174593f, 0.17237067f, -0.36027396f, -0.15769306f, -0.13401651f, -0.07250872f, 
    -0.02411177f, -0.00314676f, 0.04006085f, 0.00369287f, 0.02656468f, -0.04935823f, -0.05947325f, 0.01722265f, 
    0.06565238f, 0.19196336f, -0.12975059f, -0.38565081f, -0.10118749f, -0.09963675f, -0.04203186f, -0.02901471f, 
    -0.24689433f, -0.08532726f, 0.02654939f, -0.03897061f, -0.01045476f, 0.03291142f, -0.03586663f, -0.07938170f, 
    0.00342417f, -0.13112743f, -0.06642631f, -0.00842870f, 0.34578177f, -0.00057318f, -0.23964955f, -0.05948521f, 
    0.05467561f, 0.10921977f, -0.07437136f, -0.00569493f, -0.34412476f, 0.04011782f, -0.04666553f, -0.00776877f, 
    -0.10286866f, 0.03559611f, 0.14006279f, -0.05201228f, 0.06546912f, -0.06191979f, -0.05226323f, -0.01974176f, 
    0.39923057f, 0.37974671f, -0.40968761f, -0.26626682f, -0.33032072f, 0.04607816f, -0.02529970f, -0.07225052f, 
    0.05431846f, 0.06716877f, 0.03965633f, -0.05063221f, 0.06403323f, 0.02253284f, 0.03981493f, 0.00834516f, 
    0.00397740f, 0.07393962f, -0.00894450f, -0.00966907f, -0.04715286f, -0.05636887f, -0.04812327f, 0.04375209f, 
    0.00965522f, 0.00461429f, -0.02415631f, -0.00610895f, 0.00665088f, 0.02265718f, -0.11057724f, -0.12000220f, 
    -0.09549937f, -0.05110423f, -0.18293241f, -0.00402931f, 0.03135211f, 0.01661183f, -0.05251284f, -0.00823982f, 
    -0.06083014f, 0.04240758f, 0.05273110f, 0.01232676f, 0.09502376f, -0.02617576f, 0.03564755f, 0.06546633f, 
    0.01990109f, -0.00935689f, -0.20373207f, -0.08114895f, -0.06768826f, -0.01436782f, -0.15311910f, -0.04345535f, 
    -0.02478201f, 0.07191052f, -0.09542791f, 0.02732492f, -0.53900123f, -0.39276877f, -0.16050802f, -0.06690195f, 
    -0.09358645f, -0.05632852f, -0.00577819f, -0.01706346f, -0.01719667f, -0.00183486f, -0.01343635f, 0.00464743f, 
    -0.05271790f, -0.02669937f, 0.01699751f, -0.04708990f, -0.06455117f, -0.11300904f, -0.02972950f, -0.05637834f, 
    0.18500566f, -0.09774390f, -0.32748425f, -0.02482547f, 0.00195484f, -0.10561247f, -0.03404601f, 0.07041351f, 
    -0.24020821f, -0.03504122f, -0.05531694f, -0.00640340f, -0.04562904f, -0.06472731f, -0.05077997f, -0.11714172f, 
    0.14341265f, 0.11425635f, -0.06069033f, 0.11973228f, -0.06389461f, -0.38838977f, 0.33624312f, 0.14222407f, 
    -0.04774489f, 0.04763784f, 0.06490858f, 0.03561636f, 0.10767979f, 0.07885358f, 0.11167967f, 0.13161135f, 
    0.10495237f, 0.09379075f, -0.00682197f, -0.14348343f, 0.06518153f, 0.02541173f, -0.20648701f, -0.12460365f, 
    -0.06649966f, -0.11530946f, -0.14432766f, 0.04297006f, 0.02484677f, 0.02229347f, 0.06182341f, 0.05804436f, 
    0.06231759f, 0.09655254f, 0.00605800f, 0.04379603f, 0.08825281f, 0.07587735f, 0.08454571f, -0.08280398f, 
    -0.20285600f, 0.02106587f, -0.01929572f, 0.05194363f, -0.56653064f, 0.52909571f, -0.50512421f, -0.09962576f, 
    -0.16915552f, 0.01400928f, -0.10647702f, -0.15947273f, 0.09926627f, 0.02408461f, 0.03545053f, -0.00951150f, 
    0.01851634f, 0.06203538f, 0.01722755f, -0.05977592f, 0.05716658f, 0.08325505f, -0.10355993f, 0.01093524f, 
    -0.04508705f, -0.10040696f, -0.07487193f, -0.10276733f, 0.11136552f, 0.07841120f, -0.02381018f, -0.03865360f, 
    0.06983878f, 0.01650722f, 0.08524834f, 0.03022840f, 0.04294118f, 0.08457036f, 0.07686142f, 0.11960938f, 
    -0.03245964f, -0.04221152f, 0.07559662f, -0.04240536f, 0.08368041f, -0.03711854f, 0.01128500f, -0.09070413f, 
    0.02768276f, -0.33627608f, -0.07637903f, 0.04311099f, -0.01674662f, -0.03376100f, 0.03994063f, 0.02141828f, 
    0.01510107f, 0.02862656f, -0.01628576f, 0.02477475f, -0.01040863f, -0.04781275f, -0.14893220f, -0.16192162f, 
    0.20105425f, 0.10960534f, -0.15699700f, 0.04294254f, 0.09901018f, 0.15660720f, 0.10682473f, 0.08329602f, 
    -0.02169109f, -0.10374968f, -0.09173547f, -0.04276755f, -0.08511753f, 0.05271216f, 0.06219888f, 0.04872862f, 
    0.03317544f, -0.03444967f, 0.00245992f, -0.02964099f, 0.33279946f, 0.23281004f, 0.11396299f, -0.37593028f, 
    -0.00487208f, 0.05305585f, 0.22786470f, -0.05801423f, -0.01995648f, 0.08658825f, 0.06259039f, -0.01255680f, 
    -0.01682179f, -0.11928666f, 0.00210144f, -0.05058499f, -0.01353644f, -0.06998444f, -0.10934311f, 0.10449466f, 
    0.30919918f, -0.07657658f, -0.23556986f, 0.08372480f, -0.14064640f, 0.03649672f, 0.02004202f, 0.11403152f, 
    -0.14532372f, -0.04628280f, 0.05402768f, 0.02355565f, -0.17644633f, 0.01531086f, -0.08787550f, 0.02350827f, 
    0.06960841f, 0.01314363f, 0.07149287f, 0.01834769f, -0.35315260f, -0.49775782f, -0.26341102f, -0.24035995f, 
    -0.13614988f, -0.13008255f, -0.08454215f, 0.00078941f, -0.13812180f, 0.01352475f, -0.09176185f, 0.00371889f, 
    0.01184265f, 0.09424943f, -0.01093391f, -0.20167330f, -0.23861654f, -0.21021812f, -0.11813656f, 0.05751022f, 
    0.37538192f, 0.31387037f, 0.08110400f, -0.52416408f, -0.08194922f, 0.01307611f, 0.03451588f, 0.00367200f, 
    0.01399418f, 0.09127183f, 0.02942755f, -0.09240618f, -0.01594915f, 0.06219778f, -0.00733415f, 0.01222940f, 
    -0.04060982f, 0.03067451f, 0.04148841f, 0.03581433f, -0.24760012f, -0.22489759f, -0.05252663f, -0.17728847f, 
    -0.06319589f, 0.02176734f, -0.07343239f, -0.03655512f, 0.06962394f, -0.03366929f, 0.02611906f, -0.00402903f, 
    0.02100748f, -0.02901611f, -0.13403367f, -0.16547145f, -0.21952127f, 0.04267288f, 0.00100704f, 0.07294530f, 
    0.32402033f, 0.03917477f, 0.02614983f, -0.20705085f, 0.00230861f, -0.03464504f, -0.02388284f, -0.08334514f, 
    0.00921316f, -0.00685610f, 0.02613999f, 0.06276723f, 0.01521961f, -0.01817218f, 0.01272592f, -0.19695894f, 
    0.30908740f, -0.20555039f, 0.13902949f, 0.04627996f, 1.19259238f, 0.09558623f, 0.04282983f, 0.17444420f, 
    -0.15623984f, -0.07983739f, -0.03660339f, 0.01343374f, -0.06318075f, 0.02423517f, 0.13786316f, -0.17082046f, 
    -0.11278240f, -0.04538574f, -0.10749681f, -0.01746814f, 0.02673983f, -0.10757689f, -0.07444070f, 0.06559930f, 
    -0.25260505f, -0.37589145f, -0.18328021f, -0.01032606f, -0.11631127f, 0.04414333f, 0.01069569f, 0.03014289f, 
    -0.05070234f, -0.09351560f, -0.09822125f, -0.00315011f, -0.02684824f, -0.07354349f, 0.02490194f, -0.00976695f, 
    0.02355579f, -0.05557089f, 0.02534237f, 0.01230306f, -0.40654555f, 0.17752621f, 0.09715238f, 0.03227680f, 
    0.12189595f, -0.13836108f, 0.11708365f, 0.12236411f, -0.11509466f, 0.16031376f, 0.16646527f, 0.15336829f, 
    0.11667931f, -0.05390137f, -0.08106390f, 0.01629511f, 0.30643803f, 0.07360938f, -0.01547897f, 0.12250314f, 
    0.07258496f, 0.04425393f, 0.12886697f, 0.08071001f, -0.09334183f, 0.06885187f, -0.04115034f, -0.04088562f, 
    0.04379928f, -0.10936817f, 0.01570926f, -0.04369891f, -0.04314321f, 0.03660346f, 0.02648716f, 0.01383566f, 
    -0.03346499f, 0.10786934f, 0.15895009f, -0.01499803f, -0.18790947f, 0.24265476f, 0.04392535f, -0.02056491f, 
    0.04913215f, 0.15520178f, -0.03084246f, -0.20129295f, -0.03118175f, -0.04028235f, 0.01490299f, 0.02413801f, 
    0.05149227f, -0.05992629f, 0.14538981f, -0.11681072f, -0.15912361f, 0.00261614f, -0.24479803f, -0.11561638f, 
    0.10241719f, 0.36110678f, 0.32249767f, 0.27065909f, 0.15297286f, -0.06258234f, -0.27952790f, -0.11252539f, 
    -0.17501467f, -0.19606148f, -0.02525385f, -0.00581757f, -0.00303592f, -0.09323518f, 0.05872483f, 0.02528886f, 
    0.04586229f, 0.11618949f, -0.13780956f, 0.02566080f, -0.41090241f, 0.03396510f, 0.02886650f, 0.05287305f, 
    0.18098465f, 0.10398617f, -0.05895573f, 0.01066593f, 0.04288533f, -0.31160158f, -0.10520212f, 0.15162514f, 
    -0.01050573f, -0.17118599f, -0.17740206f, 0.17135441f, 0.01387305f, 0.09776483f, 0.02338723f, -0.12018536f, 
    0.23459725f, 0.09874659f, 0.05587557f, 0.26615664f, -0.35951111f, -0.00778371f, -0.06950034f, 0.07211855f, 
    -0.15131761f, 0.05618123f, -0.03739538f, 0.10674279f, 0.01055487f, 0.09584469f, -0.04505951f, -0.05569782f, 
    -0.23009266f, -0.12002678f, -0.00405810f, -0.25304708f, 0.00975206f, -0.05899128f, -0.17375711f, -0.11311483f, 
    -0.18352732f, -0.00565369f, -0.02428682f, 0.03177617f, 0.16742128f, -0.10878132f, -0.02301240f, 0.10103441f, 
    0.02524033f, 0.09086926f, 0.10428546f, -0.04534829f, -0.06264171f, 0.02074602f, 0.25998479f, -0.07467877f, 
    -0.04563465f, -0.40857065f, 0.13086583f, -0.03316956f, 0.13327403f, 0.07705350f, 0.02116239f, 0.01145583f, 
    -0.05770349f, 0.03631169f, 0.03456038f, -0.01002822f, -0.05841474f, -0.00472932f, 0.06457835f, 0.09596413f, 
    -0.02577346f, 0.09944064f, 0.15752254f, -0.00952388f, 0.24308217f, 0.11510593f, 0.01353187f, 0.11092864f, 
    0.17427170f, -0.07334587f, -0.03204685f, -0.05024175f, -0.03387285f, -0.03038894f, -0.02041717f, 0.02967128f, 
    0.02545726f, 0.02683967f, 0.01826163f, 0.10733371f, 0.06299821f, -0.15189551f, -0.01141565f, -0.04086881f, 
    -0.11792847f, 0.13980450f, 0.25910902f, 0.01716818f, -0.06790291f, 0.05194639f, -0.13659802f, 0.10071923f, 
    -0.07317932f, -0.03496523f, 0.08997834f, -0.02666528f, -0.06189872f, -0.24028090f, 0.00671946f, 0.26981565f, 
    -0.10276689f, -0.13202712f, 0.01272781f, -0.11885895f, -0.25889391f, -0.13120094f, -0.04741883f, -0.07502393f, 
    -0.02543383f, 0.06157015f, 0.20863481f, 0.33736414f, -0.14113042f, -0.10488340f, 0.00105875f, -0.13734579f, 
    0.16193250f, 0.01060461f, -0.04997427f, 0.04447583f, 0.07566660f, -0.00499290f, -0.02554419f, -0.01163335f, 
    -0.56052512f, 0.18411492f, -0.50372273f, 0.06945215f, -0.15004316f, -0.23382168f, 0.00132402f, -0.13036288f, 
    -0.25001594f, 0.11558241f, -0.04104077f, -0.00617463f, 0.09191427f, 0.09962872f, 0.00459448f, 0.03798909f, 
    0.07597847f, 0.10183853f, -0.04277342f, -0.07474137f, 0.39324105f, -0.49996591f, 0.14909841f, 0.03591302f, 
    0.06697714f, 0.06807702f, 0.05590654f, 0.18327761f, 0.18094733f, -0.31264353f, 0.08751692f, -0.28363392f, 
    0.19031514f, -0.12062404f, -0.34894764f, 0.08350187f, 0.04053894f, -0.03103186f, -0.00822471f, -0.08506842f, 
    -0.20487282f, -0.25634986f, -0.30119038f, 0.15310079f, -0.57075977f, -0.08151141f, -0.36197618f, -0.18937095f, 
    -0.03624706f, 0.07561601f, -0.02840597f, -0.01155576f, 0.01359749f, 0.15318422f, 0.13790961f, 0.02144913f, 
    0.01683792f, 0.01343273f, -0.03372865f, -0.05049144f, 0.04191079f, -0.02418373f, 0.03616266f, 0.13340501f, 
    0.13041456f, -0.00397455f, -0.00327305f, -0.05425720f, 0.00682503f, 0.01190009f, 0.12191140f, 0.02224872f, 
    -0.04155746f, -0.04703084f, 0.12855870f, -0.03971965f, -0.01422551f, -0.15558581f, 0.02338890f, 0.00620030f, 
    -0.06496325f, -0.14975443f, 0.03113379f, 0.06692580f, 0.05527192f, 0.01959032f, 0.04737536f, -0.01168372f, 
    0.05090986f, 0.05674138f, -0.04655044f, -0.00481284f, -0.07906500f, 0.14042075f, 0.04783669f, -0.09498020f, 
    0.01198505f, -0.02566987f, -0.01762872f, -0.05151363f, 0.14442444f, 0.24921320f, 0.01652639f, -0.13916792f, 
    0.04990742f, -0.07680252f, -0.04226808f, -0.06409547f, -0.00485803f, -0.03026598f, 0.03501503f, 0.00525773f, 
    0.04460675f, 0.03115428f, 0.06413361f, 0.12465286f, -0.02489462f, 0.04020741f, 0.12707777f, 0.01270931f, 
    0.94316053f, 0.09050107f, -0.25962922f, -0.10444938f, -0.40922061f, 0.09458268f, -0.01580857f, -0.04771788f, 
    -0.01882260f, -0.07218593f, 0.09346376f, 0.01757395f, 0.02749138f, -0.04061989f, -0.06745532f, -0.01120904f, 
    -0.10403173f, -0.26611653f, 0.00803647f, 0.12042190f, -1.17563009f, -0.72591460f, 0.46893170f, 0.02411500f, 
    -0.04084760f, 0.03352434f, -0.02598238f, 0.04565295f, -0.11374297f, 0.01011155f, 0.02072381f, 0.08951403f, 
    -0.10427405f, 0.08682123f, -0.03239423f, 0.37481207f, -0.00921824f, -0.28694594f, 0.04985736f, 0.04837714f, 
    0.31319624f, 0.09208831f, 0.12804240f, 0.16228251f, 0.14840083f, -0.02215416f, -0.02879008f, 0.00642486f, 
    -0.05488975f, 0.00091136f, 0.02676686f, 0.01127030f, 0.00991668f, 0.03190364f, 0.04355903f, -0.04854536f, 
    -0.11476238f, -0.11991327f, -0.05081649f, -0.07629921f, 0.03439935f, -0.09091094f, -0.07635202f, -0.09328345f, 
    -0.12429012f, 0.07586470f, -0.11068179f, -0.13693957f, 0.13141522f, -0.07901093f, -0.04138137f, 0.00312071f, 
    0.10178830f, 0.06934731f, 0.06540538f, -0.00222663f, 0.17543608f, -0.14530268f, 0.14582285f, 0.04903410f, 
    0.32420397f, 0.19571924f, -0.00881709f, 0.10202581f, 0.23910324f, -0.01986598f, -0.00178848f, -0.00991361f, 
    -0.03090424f, -0.04228082f, -0.01143327f, 0.02687470f, 0.00414633f, 0.01848191f, 0.00143949f, -0.00980859f, 
    0.00451914f, 0.11981132f, 0.03140424f, -0.06779523f, 0.00838325f, -0.02092185f, 0.04368506f, -0.10217845f, 
    0.07159027f, 0.04696533f, 0.07971510f, -0.24697112f, 0.10156983f, 0.05467406f, -0.04296248f, -0.05147162f, 
    0.09738892f, 0.14744939f, -0.03207880f, -0.02832921f, -0.04736045f, -0.09252348f, 0.11920754f, -0.03349570f, 
    -0.04178026f, -0.16752204f, -0.27973941f, -0.00414828f, -0.12906516f, -0.05521313f, 0.03264381f, 0.06160427f, 
    0.01477227f, -0.06274144f, -0.04197076f, 0.11916985f, -0.04343792f, -0.00018582f, -0.00645960f, -0.02563234f, 
    0.02775285f, 0.01154211f, 0.01438104f, 0.07790363f, -0.03464913f, 0.17282511f, -0.08702461f, -0.13323002f, 
    0.09225140f, 0.20973930f, -0.07749936f, 0.05931206f, 0.03175646f, 0.00527613f, -0.04802400f, -0.00707748f, 
    -0.01269511f, -0.04712551f, 0.10784696f, -0.00214211f, 0.01402106f, 0.16006406f, -0.19393042f, -0.12299970f, 
    0.31420648f, 0.25698450f, 0.06729193f, 0.17931107f, -0.41086930f, 0.08957955f, 0.06356782f, 0.09275997f, 
    -0.11270179f, 0.14891416f, 0.01610173f, -0.14714456f, -0.00723940f, -0.17633881f, -0.15208654f, 0.05037596f, 
    -0.06698518f, -0.01464743f, -0.09196863f, -0.01684343f, 0.21231835f, 0.21704651f, -0.01947206f, -0.03036081f, 
    0.05151972f, -0.10582168f, 0.10878583f, -0.00816240f, -0.08471902f, -0.05008401f, -0.04421917f, 0.06119855f, 
    0.15771176f, -0.08032776f, 0.00220864f, 0.07182686f, -0.02724855f, 0.16726841f, 0.03415126f, -0.17225593f, 
    -0.53237092f, 0.13063017f, -0.23807710f, 0.35743621f, 0.12584470f, -0.02519888f, 0.03326885f, -0.00355786f, 
    -0.03135605f, -0.18561631f, -0.07490753f, 0.01351406f, 0.05856625f, -0.04674756f, 0.01601697f, -0.03219552f, 
    0.05233606f, 0.00348724f, -0.24475518f, 0.12013125f, 0.10439784f, -0.15935148f, 0.06970243f, 0.03469992f, 
    0.29920733f, -0.07581209f, 0.05320612f, 0.04894839f, -0.03673309f, 0.03008787f, 0.09530886f, -0.00421491f, 
    0.07549340f, 0.03422387f, 0.13331169f, 0.13365903f, -0.01768605f, -0.00750000f, -0.05948928f, -0.01746620f, 
    0.03394813f, 0.01160873f, 0.11373345f, -0.42288736f, 0.01192729f, -0.01586024f, 0.02000685f, -0.07947655f, 
    0.08351211f, 0.07122188f, 0.01240390f, 0.01131169f, -0.03814714f, 0.13132520f, -0.02129181f, 0.12256995f, 
    -0.21535462f, -0.03328532f, 0.07664175f, -0.01023053f, -0.23041636f, 0.37260017f, 0.48919907f, 0.12721266f, 
    0.14517641f, -0.00797795f, -0.04045259f, -0.00984974f, -0.07267467f, 0.09634230f, 0.09058584f, -0.04646323f, 
    0.06693952f, -0.15985829f, 0.00478897f, -0.02920202f, 0.01223550f, 0.13774444f, 0.04538463f, -0.11250000f, 
    -0.06053053f, 0.11301193f, 0.33492750f, 0.24583368f, 0.30905601f, -0.03054368f, 0.03786689f, 0.13835776f, 
    0.07298310f, 0.00060976f, 0.13192432f, 0.04504336f, -0.03633223f, 0.08502179f, 0.05050444f, 0.04031397f, 
    0.04571763f, 0.08296059f, -0.05226263f, 0.02018763f, 0.53184521f, 0.37031046f, -0.46206677f, 0.07184998f, 
    0.26239699f, -0.25423536f, 0.14015992f, -0.03960437f, -0.06807522f, -0.08159605f, -0.02940211f, -0.02067884f, 
    0.05812991f, -0.06923819f, 0.04153721f, -0.07895207f, -0.10715334f, 0.09350695f, -0.13377647f, 0.01268522f, 
    -0.30739957f, 0.10456181f, 0.19462685f, -0.21366902f, -0.17324130f, -0.02685583f, 0.01167269f, -0.06934658f, 
    0.02378140f, 0.08818565f, 0.03765846f, 0.01229884f, -0.04192638f, 0.09018081f, -0.05435707f, 0.03792970f, 
    -0.16666186f, -0.08482223f, 0.03800891f, 0.01903323f, -0.39173040f, -0.39161769f, -0.36413541f, 0.23892003f, 
    -0.30096650f, -0.05679764f, 0.02548983f, -0.06171362f, -0.03446862f, -0.11189513f, -0.02725411f, -0.02798021f, 
    -0.02003706f, -0.02304854f, 0.00734626f, -0.08148143f, 0.04209849f, 0.05353726f, -0.01370015f, 0.16386846f, 
    -0.50556022f, -0.58610779f, -0.11112238f, 0.10995504f, -0.40459481f, -0.08204733f, 0.01416302f, 0.02892755f, 
    0.09236667f, 0.01939581f, -0.00714122f, -0.00358623f, 0.01392262f, -0.05105710f, -0.06204251f, -0.02413302f, 
    -0.00201216f, 0.00232596f, -0.23422319f, 0.05917285f, 0.33777267f, -0.28994808f, 0.04038468f, 0.34255856f, 
    0.19779918f, 0.16482961f, -0.09655640f, -0.02070129f, 0.04460390f, -0.05205631f, -0.05260466f, 0.15531605f, 
    0.02126282f, -0.12974159f, 0.00316830f, -0.00070474f, -0.09686444f, -0.06104204f, 0.03299868f, -0.06786601f, 
    -0.48511088f, 0.10276953f, 0.04817501f, 0.44393408f, -0.17425515f, 0.00227587f, 0.03655438f, 0.05864053f, 
    -0.04108291f, 0.13044007f, -0.06379335f, -0.02307256f, -0.05807396f, -0.08127909f, 0.01665429f, 0.00099010f, 
    0.00520173f, 0.07432484f, 0.05151031f, 0.04601571f, -0.28529000f, 0.01436963f, -0.01886445f, -0.08823594f, 
    0.00991399f, -0.02145100f, -0.12980330f, -0.49278647f, -0.05195507f, -0.01613856f, 0.10956390f, -0.15676537f, 
    -0.13980894f, 0.09068340f, -0.02953363f, 0.09992503f, -0.01260288f, -0.25279909f, 0.09259667f, 0.03306098f, 
    0.20602617f, -0.19604416f, -0.33750772f, 0.00104515f, 0.07462290f, 0.04765062f, 0.09765469f, 0.02590711f, 
    -0.11316939f, 0.08173918f, 0.08795659f, 0.01912031f, -0.04077940f, 0.07054961f, -0.03077369f, -0.07907923f, 
    0.11387513f, 0.24613120f, 0.08369789f, 0.03747474f, -0.34856978f, -0.28108799f, 0.15900457f, -0.44178906f, 
    -0.04910334f, -0.03611625f, -0.08897108f, -0.05019857f, 0.01153685f, 0.04743527f, 0.01402077f, 0.00595922f, 
    0.01910337f, 0.07341349f, -0.02668658f, -0.14289343f, -0.12725522f, -0.07948718f, 0.07840417f, -0.03194543f, 
    -0.32745385f, -0.26607707f, 0.49579647f, 0.46778297f, 0.43604994f, -0.05622550f, -0.00397826f, -0.10682700f, 
    0.07245067f, 0.04465055f, -0.02502720f, -0.00463189f, -0.02751561f, -0.08736231f, -0.07403573f, -0.00190940f, 
    0.09771226f, 0.15879427f, -0.03765373f, 0.05976868f, 0.31538919f, 0.02153163f, 0.21475761f, 0.12115360f, 
    0.21459733f, -0.08625928f, -0.01405574f, 0.03803877f, 0.15104645f, -0.02644279f, -0.00959448f, 0.05337849f, 
    0.10893326f, 0.01280152f, 0.06342012f, 0.07633323f, -0.08782021f, -0.03971770f, 0.03994432f, 0.00472544f, 
    -0.15063041f, 0.26826096f, -0.31124964f, -0.01289329f, -0.27452117f, -0.04898296f, 0.03301566f, -0.06967326f, 
    -0.21376108f, -0.09309895f, 0.04563608f, 0.01616225f, 0.07981254f, -0.03398349f, -0.04140408f, -0.03643007f, 
    -0.00159429f, 0.09919813f, 0.08977017f, -0.07184833f, 0.04447156f, -0.18346162f, 0.23566979f, -0.04905003f, 
    0.06569916f, -0.01751543f, -0.02488569f, 0.12327446f, 0.11126489f, -0.06531715f, -0.03650381f, 0.02626731f, 
    0.16437221f, -0.21508749f, 0.15245654f, -0.02313315f, -0.11791119f, -0.04564546f, 0.19617425f, -0.19519094f, 
    -1.11324430f, -0.36402413f, 0.09242895f, -0.30248532f, -0.44524649f, 0.32364905f, 0.16048858f, -0.28817368f, 
    -0.13278738f, -0.40592328f, 0.00986312f, -0.00018658f, -0.01047441f, 0.01826719f, -0.07371689f, 0.05385401f, 
    -0.04467167f, -0.07095598f, -0.08335362f, 0.13963518f, 0.22472386f, -0.11393707f, -0.03614850f, -0.05338759f, 
    0.10541401f, 0.03625673f, -0.03232479f, -0.00286458f, 0.05249861f, 0.03489745f, -0.20026566f, -0.14106631f, 
    -0.01558333f, 0.04665735f, 0.02516763f, 0.08662380f, 0.00718909f, -0.05983248f, 0.09851284f, -0.02533939f, 
    0.17975864f, -0.05417274f, -0.05410504f, 0.09310937f, 0.14318722f, 0.02852145f, -0.02623812f, 0.06924300f, 
    0.08239413f, -0.08622529f, -0.24709564f, -0.00467742f, -0.14579242f, 0.06140131f, -0.16345604f, 0.08428039f, 
    -0.03676798f, 0.00755547f, -0.01199285f, -0.02324460f, -0.28575441f, 0.14269626f, 0.19128571f, -0.23520830f, 
    -0.07433571f, 0.02579417f, 0.07466462f, 0.05766313f, 0.00128741f, 0.03830672f, 0.06420373f, 0.01659512f, 
    -0.02259162f, 0.11239231f, -0.07464441f, -0.05164216f, -0.04274551f, -0.01299315f, 0.06770211f, -0.03616659f, 
    -0.46949041f, 0.50125903f, 0.61285990f, 0.06317099f, -0.69669896f, 0.08188673f, -0.21593136f, -0.20253055f, 
    -0.02406037f, 0.08174660f, 0.03519807f, 0.04420074f, -0.04941738f, -0.08752111f, -0.10042273f, 0.14357087f, 
    0.06796312f, 0.19677664f, 0.22374094f, -0.09533913f, 0.22180635f, -0.46332437f, 0.03493376f, -0.13909480f, 
    -0.01080692f, 0.02535903f, -0.03440238f, 0.00917370f, -0.07653204f, 0.05271864f, 0.03162303f, -0.08225852f, 
    0.12159463f, -0.06088560f, 0.09243022f, 0.06446414f, 0.15763804f, -0.05968706f, 0.16407444f, 0.06643118f, 
    -0.35104445f, -0.32135576f, -0.30024904f, -0.16072285f, -0.01159089f, -0.00457477f, -0.06579512f, -0.03369200f, 
    0.00266112f, -0.01202315f, 0.00094236f, -0.02475910f, 0.00590743f, 0.03157579f, -0.05277290f, 0.03932598f, 
    -0.01423830f, 0.02633379f, 0.07066174f, 0.02522106f, -0.25156802f, 0.02928188f, 0.27254108f, -0.59958470f, 
    0.30677286f, 0.09845226f, 0.01447394f, -0.20157994f, 0.12526709f, 0.06596144f, 0.04962286f, -0.01448823f, 
    0.06230166f, 0.02716693f, 0.00018733f, -0.06253433f, 0.04220298f, -0.16247506f, 0.18229964f, 0.12942846f, 
    -0.47166386f, -0.37976351f, -0.13528113f, -0.58449423f, -0.28340662f, -0.06858057f, 0.00172025f, 0.01611842f, 
    0.05145969f, 0.06185830f, 0.03601555f, 0.04137739f, 0.00147515f, 0.05042398f, -0.04199343f, -0.15396798f, 
    -0.03336187f, 0.18166716f, 0.00484788f, -0.07823709f, -0.19787884f, -0.12975331f, 0.16087478f, -0.14183521f, 
    0.08283652f, -0.06122825f, -0.19914819f, -0.51898360f, -0.01714237f, 0.11738821f, 0.08847103f, -0.02620448f, 
    0.03661946f, -0.00627667f, -0.08936191f, 0.08116675f, -0.07883584f, -0.03513081f, -0.14527929f, -0.02544762f, 
    0.08099611f, 0.09531599f, 0.37059718f, 0.12079626f, 0.25183618f, -0.06469148f, -0.06213368f, 0.04225063f, 
    0.09364089f, -0.22304814f, 0.00823052f, -0.09811784f, -0.00928516f, 0.01173638f, 0.08120478f, 0.02814529f, 
    -0.03799208f, -0.00594241f, 0.04391528f, -0.03939046f, -0.14629845f, -0.04909093f, -0.07943954f, 0.20724975f, 
    -0.05855303f, 0.04001857f, 0.07375892f, 0.03028842f, 0.14478776f, -0.00749018f, -0.01082686f, 0.04386790f, 
    -0.00749115f, 0.10570727f, -0.08001673f, 0.00683619f, 0.00756056f, 0.10160629f, -0.06941704f, 0.14026378f, 
    0.02488935f, 0.17162724f, 0.60872710f, 0.10092622f, 0.23758860f, 0.07105479f, -0.05063999f, -0.15485558f, 
    -0.10359204f, 0.23499185f, 0.02192316f, 0.08098604f, 0.05636737f, -0.05909524f, -0.01357882f, 0.06434921f, 
    0.13317783f, -0.07152830f, 0.11448921f, -0.01206783f, -0.13374482f, 0.11292618f, -0.06044350f, -0.01382142f, 
    0.03657685f, 0.09314709f, -0.04577894f, -0.04144284f, 0.01820051f, 0.10090874f, 0.01529119f, 0.03467947f, 
    0.00918783f, 0.04935773f, 0.08162321f, 0.23704849f, 0.11973727f, -0.01449615f, 0.06189371f, 0.01936743f, 
    -0.05506128f, -0.62438023f, -0.63245153f, 0.31736296f, -0.32982823f, 0.08146425f, 0.00288477f, 0.01094309f, 
    -0.11649773f, 0.01639437f, 0.04340349f, 0.02109791f, 0.03691747f, 0.02376159f, -0.03904433f, 0.01815970f, 
    -0.01241722f, 0.02304440f, -0.24280317f, -0.06329692f, 0.12212867f, 0.12723887f, -0.06087356f, -0.15760857f, 
    0.18138237f, 0.10224120f, 0.00526968f, -0.06225943f, 0.03115476f, 0.02833243f, -0.04972775f, 0.02160584f, 
    0.08834458f, -0.07827163f, 0.02653833f, 0.08513893f, 0.07992709f, -0.03088605f, 0.15623879f, 0.03984559f, 
    -0.40751767f, 0.27583891f, 0.55347705f, -0.27304691f, -0.18637280f, -0.34110305f, -0.31023034f, -0.16055410f, 
    -0.02115719f, -0.08408888f, 0.00153724f, -0.25448334f, 0.05619777f, 0.10673772f, 0.13025299f, -0.00502993f, 
    -0.02798382f, -0.13202493f, -0.06445768f, -0.01865958f, -0.25779426f, 0.91429967f, 0.10980666f, -0.05293862f, 
    0.26645550f, 0.34632409f, 0.12765202f, 0.07304221f, 0.04701506f, -0.08812651f, -0.08740769f, -0.12465971f, 
    -0.11149778f, 0.03690369f, 0.10442433f, -0.06956017f, -0.00305418f, -0.09974480f, -0.13693999f, -0.10394541f, 
    0.40129814f, -0.02872191f, -0.21428634f, -0.24233936f, 0.27602074f, 0.31128272f, 0.01268479f, 0.00018225f, 
    0.00036148f, -0.38759381f, -0.26309013f, 0.02735800f, 0.08444512f, 0.04607980f, 0.03882039f, -0.06987330f, 
    0.16526869f, -0.02139266f, -0.04893680f, 0.03570999f, 0.02419800f, 0.27761140f, -0.24700503f, -0.53959101f, 
    -0.02972683f, -0.19729021f, 0.03368904f, -0.24338752f, -0.15920207f, -0.25946379f, -0.00792233f, -0.00674736f, 
    -0.15436481f, -0.12200303f, 0.06646432f, 0.11867157f, -0.04603289f, 0.06114167f, -0.39600888f, -0.13216111f, 
    -0.80939239f, -0.21775803f, 0.00524871f, 0.08694831f, 0.07429988f, -0.16196202f, -0.03183339f, -0.15863553f, 
    -0.15177505f, -0.11471730f, -0.02147956f, 0.07347861f, -0.17757553f, 0.25004062f, 0.06251183f, 0.04862336f, 
    0.04896655f, 0.06591494f, -0.20804523f, 0.13863637f, -0.11449121f, -0.06923312f, -0.19338414f, -0.03265226f, 
    0.21126011f, -0.04380830f, 0.04616363f, -0.00900045f, 0.05244562f, 0.06123169f, -0.04654336f, 0.04907738f, 
    -0.01861433f, -0.06451132f, -0.02474627f, 0.02715038f, 0.08435243f, 0.15805927f, -0.17646876f, 0.00839927f, 
    -0.12651125f, -0.03691167f, -0.27967536f, -0.08296049f, 0.28291705f, -0.00036944f, 0.03417934f, 0.00223627f, 
    0.05505404f, -0.01409592f, -0.06381208f, 0.10778285f, 0.04395367f, -0.02833849f, 0.07249892f, -0.01473596f, 
    0.03172906f, 0.10855516f, -0.03267004f, 0.05341631f, 0.23457357f, 0.27516663f, 0.17351852f, -0.34952825f, 
    0.07358122f, 0.33733112f, 0.39968485f, -0.13497035f, -0.19892019f, -0.13179612f, -0.26529562f, -0.00148496f, 
    0.26288331f, -0.08002204f, 0.06638423f, -0.24140972f, 0.00170314f, 0.17106706f, 0.24962144f, -0.21926573f, 
    0.04922359f, -0.29122928f, -0.03420699f, 0.36037713f, 0.43207422f, -0.27010882f, 0.05954094f, -0.07523563f, 
    0.14308092f, -0.17388135f, 0.00411563f, 0.01784226f, 0.09837661f, -0.05849604f, 0.12683444f, -0.15387784f, 
    0.05185219f, 0.04139440f, 0.12068969f, 0.02482233f, -0.25181162f, 0.16875008f, -0.71079987f, 0.33567089f, 
    -0.17643447f, 0.13194880f, 0.09226429f, 0.23829773f, 0.02055227f, 0.15076776f, 0.00420090f, 0.06200240f, 
    0.02649795f, -0.01710887f, -0.21656972f, 0.10512064f, -0.02865177f, 0.05666063f, -0.01173287f, -0.15950687f, 
    0.76687318f, -0.00571002f, 0.14855203f, -0.62047482f, -0.27979541f, -0.08024283f, 0.03571330f, 0.09621812f, 
    0.08728287f, -0.07281709f, -0.10329928f, 0.01322302f, -0.03424079f, -0.02598378f, 0.08520182f, -0.07731637f, 
    -0.06899399f, 0.01086204f, 0.06372049f, 0.04974503f, -0.62759286f, -0.40832263f, -0.19350812f, -0.15313923f, 
    -0.31642780f, -0.09250448f, -0.32066822f, -0.20059761f, 0.16219871f, -0.06062314f, 0.14024070f, 0.09834741f, 
    0.14024909f, -0.07801637f, -0.04399850f, -0.02387796f, 0.07743974f, 0.01380553f, -0.02491192f, -0.04001988f, 
    0.32595405f, 0.11354578f, -0.20361662f, -0.24031334f, 0.29322413f, 0.20911935f, 0.03695076f, -0.00145854f, 
    0.18621078f, 0.00182610f, -0.09549391f, 0.07297233f, 0.13127369f, 0.06403071f, 0.15938821f, -0.12691803f, 
    0.17196693f, -0.02439624f, 0.06484541f, 0.16109510f, -0.37069055f, 0.18485031f, -0.15149006f, -0.14275350f, 
    0.29935500f, 0.19349816f, -0.17969950f, 0.05372155f, 0.02665823f, 0.03820614f, -0.08616494f, 0.05250185f, 
    -0.02565350f, -0.00787415f, -0.05411022f, 0.06471623f, -0.07851860f, 0.03656181f, -0.01667942f, 0.06391058f, 
    -0.44615373f, 0.02898916f, -0.25649709f, 0.29081070f, 0.06252842f, 0.09541437f, -0.12165762f, 0.14580746f, 
    -0.10353778f, 0.06039384f, -0.10326406f, 0.04946380f, -0.15464498f, -0.01612658f, -0.00451499f, 0.05051093f, 
    -0.14906371f, 0.22907884f, -0.21409394f, -0.22151189f, -1.06401539f, 0.88577133f, -0.45894817f, 0.01615491f, 
    0.03131831f, 0.50068718f, -0.00225134f, 0.04589386f, -0.12588507f, 0.12839414f, 0.05326463f, -0.07040364f, 
    -0.20001543f, -0.23039497f, -0.03898869f, 0.13871391f, -0.15485811f, 0.01351586f, 0.06662373f, -0.13651973f, 
    -0.14076844f, -0.19768493f, 0.04720731f, 0.24924178f, 0.55198807f, 0.04041741f, 0.12732454f, 0.15401646f, 
    0.02431571f, 0.15447299f, 0.07442187f, -0.01866801f, -0.04127526f, -0.08892284f, -0.00042842f, -0.05157055f, 
    -0.12443895f, 0.02321830f, -0.04809939f, 0.05659880f, -0.36293387f, -0.19101623f, -0.49517918f, 0.09271559f, 
    -0.52401507f, 0.27377728f, 0.00819683f, -0.09793259f, -0.14152572f, 0.03970764f, -0.17966196f, -0.18277608f, 
    0.08058334f, -0.12595586f, -0.08091151f, -0.12501685f, -0.09255144f, -0.18196650f, -0.01595880f, 0.06426245f, 
    0.51348323f, 0.92514652f, -0.44799587f, -0.01179559f, -0.12277061f, 0.21453407f, -0.16521092f, 0.06230856f, 
    -0.23684835f, -0.13530841f, -0.30330101f, -0.16433415f, 0.00612307f, 0.11901785f, 0.01714263f, -0.03097282f, 
    0.10145807f, -0.22624494f, 0.12641725f, 0.11660008f, -0.39703721f, -0.33705223f, 0.48477164f, -0.11720591f, 
    0.02993791f, -0.23002048f, 0.05308395f, -0.12128969f, -0.01344974f, -0.08646243f, 0.00703476f, 0.11852541f, 
    0.01387568f, -0.05929009f, 0.03501737f, -0.06097288f, 0.08192597f, 0.12231147f, -0.19442903f, -0.04357824f, 
    -0.46194190f, 0.28455105f, -0.22312687f, 0.23059568f, 0.42906865f, 0.11605234f, 0.05054533f, -0.00194845f, 
    -0.09255526f, 0.07788391f, -0.07664120f, 0.02925292f, 0.11044619f, 0.07320935f, 0.07373337f, 0.06507115f, 
    -0.01306721f, -0.05592668f, -0.04468461f, 0.06271128f, 1.00205302f, -0.04494180f, -0.14116445f, -0.03175869f, 
    -0.29856905f, 0.22654505f, 0.05348928f, 0.15659918f, 0.13495658f, 0.13636060f, -0.21767548f, -0.16349348f, 
    0.07013231f, 0.05847056f, 0.01493848f, -0.03401415f, 0.03802158f, -0.15492721f, -0.09900133f, 0.27073833f, 
    -0.67691994f, -0.58976144f, -0.38823754f, 0.09242323f, -0.21639675f, 0.40892723f, 0.07476118f, 0.20542707f, 
    0.25237310f, 0.11277480f, -0.07638904f, -0.06705939f, 0.14440845f, -0.03550938f, -0.02987006f, 0.02386346f, 
    -0.04174995f, -0.26663283f, -0.06175747f, -0.13150360f, -0.12847517f, 0.41804215f, 0.75980228f, -0.47309700f, 
    0.63774711f, -0.32460642f, 0.10422992f, 0.09007702f, -0.02420308f, 0.00501655f, 0.14755958f, -0.03894125f, 
    -0.09596768f, -0.02277720f, 0.17210688f, -0.01640776f, -0.19208960f, 0.03850161f, -0.12689848f, 0.02785774f, 
    -1.01317930f, -0.35376337f, -0.11041766f, -0.08896443f, -0.41258973f, -0.09369305f, -0.05141327f, -0.23285410f, 
    0.16361654f, 0.01245356f, 0.18819955f, 0.04158470f, 0.18347928f, -0.00212318f, 0.08689582f, 0.04368742f, 
    0.04664461f, 0.15342215f, -0.30296335f, -0.14624523f, 0.16103639f, -0.07797149f, 0.60198474f, -0.15397859f, 
    0.25804627f, -0.00414126f, 0.08630285f, -0.09233749f, 0.16542400f, 0.00242047f, 0.14970145f, 0.02926963f, 
    -0.07542253f, -0.10794292f, 0.03355310f, -0.06387605f, 0.01682054f, -0.05751751f, -0.12759404f, -0.00760471f, 
    -0.15724239f, -0.04502243f, -0.27963784f, -0.04070911f, 0.44671157f, 0.22315335f, -0.04400060f, 0.12355960f, 
    -0.13393275f, -0.02596696f, -0.11645120f, 0.05891218f, 0.06996919f, 0.04751860f, 0.10401285f, 0.09656156f, 
    -0.04837714f, -0.02634184f, 0.01088802f, 0.09758659f, -0.03467165f, -0.06030848f, -0.04898302f, -0.10478695f, 
    0.22256374f, -0.07629618f, 0.03464065f, -0.01665115f, 0.04383123f, -0.00705004f, 0.06222278f, -0.03490252f, 
    0.06145456f, 0.01463256f, 0.02416987f, -0.12401859f, -0.05203479f, 0.01462693f, 0.09748427f, 0.03627225f, 
    -0.01923090f, 0.36097977f, -0.08514600f, 0.11926933f, 0.25907072f, 0.05311403f, -0.07571233f, 0.03884431f, 
    0.06100180f, -0.04905390f, -0.08573852f, 0.01903664f, 0.01722482f, 0.03455836f, 0.01382793f, -0.01038850f, 
    -0.01285762f, 0.02379289f, -0.08126706f, -0.06364992f, -0.88244504f, 0.35102561f, -0.29798767f, 0.17744364f, 
    -0.34184504f, 0.15834039f, -0.17017080f, 0.01665515f, -0.06510172f, -0.19400218f, 0.07415456f, -0.00233067f, 
    0.03973535f, -0.10046071f, -0.23762223f, -0.04179687f, 0.12581877f, 0.19149086f, 0.09488865f, -0.13767171f, 
    0.04016890f, -0.10694524f, -0.38416526f, -0.05950609f, 0.21425489f, 0.22577015f, -0.05296744f, 0.00890432f, 
    0.07154656f, -0.02493637f, -0.07655607f, 0.01337637f, -0.09610840f, 0.15144274f, -0.05933433f, -0.00906452f, 
    -0.12366619f, 0.10546090f, -0.07838567f, 0.01856489f, 0.47497463f, 0.45659086f, -0.10648644f, -0.26281053f, 
    -0.56524187f, 0.00138109f, 0.00403976f, -0.07997249f, -0.09680500f, 0.11110184f, -0.11898259f, -0.14243045f, 
    0.22066627f, -0.06175765f, 0.00987408f, -0.14556754f, 0.00585243f, -0.12789656f, 0.00376288f, -0.03738231f, 
    0.01247471f, -0.20981732f, -0.36179209f, 0.18240258f, 0.12070761f, 0.15607671f, -0.02262800f, 0.09154054f, 
    -0.02703469f, -0.00132827f, 0.05434109f, 0.05961217f, -0.02579611f, -0.09344801f, 0.06905072f, 0.01006469f, 
    -0.13483274f, 0.08756065f, -0.13722348f, 0.05144592f, -0.52980715f, -0.36554977f, 0.10229488f, -0.16164403f, 
    -0.02548966f, -0.03832604f, 0.08261198f, -0.11784370f, 0.03504556f, 0.04393118f, -0.15207130f, -0.17879377f, 
    -0.03869127f, 0.09721396f, -0.10840005f, -0.03138346f, 0.02925812f, -0.06659115f, -0.08508369f, -0.06217013f, 
    0.07718953f, -0.25187472f, 0.20069326f, 0.16666299f, 0.07567335f, -0.23516147f, -0.06921669f, -0.07539647f, 
    -0.01950125f, 0.13695475f, 0.05072885f, 0.00651162f, -0.08882081f, -0.09281828f, -0.02601487f, 0.06369451f, 
    -0.00052746f, -0.01570228f, 0.02479463f, -0.01980387f, -0.26192555f, -0.20654966f, -0.00733725f, -0.16759908f, 
    -0.13800573f, -0.02758389f, -0.19059172f, 0.06605142f, 0.05676919f, 0.00541360f, -0.15591569f, -0.22110718f, 
    -0.02937480f, -0.08273890f, 0.15515853f, -0.30073568f, -0.38371021f, -0.07255656f, 0.01961541f, -0.00510668f, 
    0.01917415f, -0.19305013f, -0.06431969f, -0.20364021f, 0.10172036f, 0.07044789f, -0.06031543f, 0.22965688f, 
    -0.08764292f, -0.03348827f, 0.04521385f, -0.02269994f, 0.01910472f, -0.12886372f, 0.02837051f, -0.04473322f, 
    0.06974748f, -0.10665256f, -0.03305836f, -0.00399748f, -0.03061206f, 0.00195265f, 0.15882567f, 0.10020353f, 
    0.13798606f, -0.08441534f, 0.20112281f, -0.01826813f, -0.02228058f, 0.08368948f, -0.01567139f, 0.02184599f, 
    0.00099227f, 0.08913972f, 0.01670156f, 0.03401596f, 0.23126975f, 0.01660712f, 0.12057343f, 0.32110837f, 
    -0.01511868f, -0.01943404f, 0.17369376f, 0.28554744f, 0.17214713f, -0.17442949f, 0.10724935f, -0.12498985f, 
    0.00314629f, 0.08775437f, -0.02875071f, 0.02322093f, 0.00476880f, 0.12634882f, 0.02279124f, 0.05321813f, 
    0.00219682f, -0.07480045f, 0.02248403f, 0.00269121f, 0.35161325f, -0.31144223f, -0.35874045f, -0.07975385f, 
    -0.20236555f, -0.09850422f, -0.33545715f, -0.00685231f, -0.09519725f, -0.11986022f, 0.08147234f, -0.05089176f, 
    -0.06907527f, 0.08799012f, -0.02938336f, 0.04702603f, 0.04519511f, 0.01800426f, -0.22853035f, -0.01960010f, 
    -0.75954866f, -0.24511121f, -0.33356637f, -0.75602984f, -0.06705376f, 0.01179542f, -0.04520272f, 0.03069025f, 
    0.02706982f, -0.04125328f, 0.00794243f, -0.00015016f, -0.00302992f, -0.05147998f, 0.00396412f, -0.03579313f, 
    0.02819979f, 0.17466056f, -0.11492987f, 0.09520926f, 0.12259962f, -0.10154360f, 0.18321460f, -0.14621913f, 
    -0.02641761f, 0.14564238f, 0.00069725f, 0.16324148f, -0.04654582f, 0.10400915f, 0.07177712f, 0.17611472f, 
    0.10136174f, -0.06814130f, 0.09436685f, 0.01986225f, -0.04523192f, -0.10804891f, -0.38509959f, -0.25020191f, 
    0.28713274f, 0.07449470f, -0.35521048f, -0.19703722f, -0.22631598f, 0.13948487f, 0.00086981f, -0.09501133f, 
    0.11638547f, -0.04408870f, 0.12188085f, -0.08703301f, 0.01284127f, 0.01529091f, 0.03984512f, 0.00462632f, 
    0.05796577f, -0.06007835f, -0.22576883f, 0.17749268f, -0.01755282f, 0.01750501f, 0.00417496f, 0.11716473f, 
    0.18108231f, 0.04212208f, 0.11751101f, 0.04516844f, 0.03573792f, 0.02146457f, 0.10818785f, 0.06772796f, 
    0.03434073f, 0.05493197f, 0.09295359f, -0.09804513f, -0.02636705f, 0.02813188f, -0.01018363f, 0.02014635f, 
    -0.33965084f, -0.43611017f, -0.00888344f, 0.15684828f, 0.14414972f, -0.09903280f, -0.03063123f, 0.13820370f, 
    -0.18125843f, -0.03412991f, -0.01488640f, 0.02510793f, -0.08098410f, 0.05413139f, -0.03293977f, -0.08951288f, 
    0.07126050f, -0.00002634f, 0.10433672f, 0.16696179f, 0.15783273f, -0.12068953f, 0.11991120f, 0.23722509f, 
    0.08347715f, -0.10486294f, -0.10238890f, -0.09019519f, 0.02794229f, -0.05550138f, -0.07445044f, 0.03586148f, 
    -0.07404990f, 0.06534044f, 0.09229683f, -0.04887753f, -0.07023241f, 0.03503428f, -0.11211503f, -0.20920101f, 
    0.38335979f, 0.00578354f, 0.39120740f, -0.11201239f, 0.38517585f, -0.04555681f, 0.06425223f, 0.06159552f, 
    0.10849353f, -0.05607853f, -0.08253597f, 0.02913350f, -0.09656611f, -0.00717414f, -0.06325624f, -0.06411572f, 
    -0.08907488f, -0.16459715f, -0.10024591f, -0.05559855f, 0.19179781f, -0.37945479f, 0.14390652f, 0.01391429f, 
    0.01788963f, -0.14021781f, -0.09727387f, -0.01643111f, 0.10699382f, -0.10948159f, -0.14547555f, 0.00829717f, 
    0.16440600f, 0.06415873f, 0.10990623f, -0.05393983f, -0.04490959f, -0.00030980f, -0.15449946f, -0.25939807f, 
    0.03186296f, 0.27887228f, 0.53481072f, 0.21590443f, 0.19475070f, 0.01373307f, 0.00221900f, 0.10840532f, 
    -0.02223744f, 0.31775522f, 0.02641141f, -0.02228855f, -0.03747883f, -0.06238980f, -0.09279503f, -0.04015894f, 
    -0.03617806f, -0.15969817f, 0.09015958f, -0.09349525f, 0.14347130f, 0.01950799f, 0.02581045f, -0.11184162f, 
    -0.10908403f, 0.04799471f, -0.08558160f, 0.03704365f, 0.00394072f, 0.08024613f, -0.10044988f, -0.19574134f, 
    0.01032241f, -0.15614608f, 0.00210671f, 0.03100078f, 0.01802077f, 0.02605431f, -0.14721100f, 0.02319149f, 
    0.10922345f, -0.20502706f, -0.05277123f, -0.00260573f, 0.02929042f, 0.03116986f, -0.09386262f, -0.03677481f, 
    -0.00711165f, -0.00307335f, 0.14184721f, -0.05336813f, -0.01464241f, -0.05382425f, 0.01866563f, 0.01730579f, 
    -0.06094461f, 0.04665549f, -0.10517683f, -0.05243764f, 0.01463582f, -0.14384842f, -0.19647793f, 0.13832594f, 
    -0.10961041f, 0.06440856f, 0.02352365f, -0.03376464f, 0.05177902f, -0.01746435f, 0.00173618f, -0.08051300f, 
    -0.05135296f, -0.07935176f, 0.00143424f, -0.10822210f, -0.00777988f, -0.22562842f, 0.00335694f, -0.01697170f, 
    0.02668585f, -0.07921502f, 0.44073814f, -0.02799257f, -0.05389801f, 0.05721474f, 0.20041645f, -0.15747361f, 
    0.00199560f, -0.16058195f, 0.03151859f, -0.01775163f, -0.01118858f, 0.12573788f, -0.01249355f, -0.21813336f, 
    -0.02948215f, -0.20219015f, -0.17401156f, -0.03872702f, -0.21494384f, 0.11950102f, -0.28536242f, -0.31826863f, 
    -0.22617540f, 0.14919785f, 0.02197696f, -0.02932632f, 0.13393374f, 0.12301955f, -0.04412569f, 0.11558813f, 
    0.03698073f, -0.26496458f, 0.00070652f, -0.11207588f, -0.06482556f, 0.18016268f, -0.22370298f, 0.21308032f, 
    0.09088809f, 0.09466663f, 0.06042843f, -0.07964303f, -0.07877302f, 0.06965016f, 0.06098675f, 0.02139544f, 
    0.02737410f, 0.10879298f, 0.16045283f, 0.12587179f, 0.01277932f, -0.01356784f, 0.06412108f, 0.06113864f, 
    0.07861555f, -0.12317663f, -0.04813617f, 0.15414245f, 0.87841403f, -0.39398670f, -0.47946200f, 0.68422598f, 
    0.20138578f, 0.00201287f, 0.02328317f, 0.12009326f, -0.11910079f, 0.09677750f, -0.04148817f, 0.00756862f, 
    -0.03728568f, -0.01440893f, 0.03138635f, -0.00072822f, -0.04220186f, 0.10904606f, 0.06500847f, -0.12231008f, 
    0.06209481f, 0.06611355f, -0.08290061f, 0.11879023f, 0.18953116f, -0.00942506f, 0.01516199f, 0.03933549f, 
    0.04789965f, 0.03689660f, 0.09146087f, 0.02105480f, -0.02653632f, -0.03609864f, 0.04806927f, 0.01501238f, 
    0.08104650f, -0.06957529f, 0.03503631f, 0.21103075f, -0.12658243f, 0.03380414f, -0.01634343f, 0.28072432f, 
    0.11870946f, 0.05822248f, 0.21485858f, -0.15490499f, -0.04452039f, 0.13014778f, 0.09837687f, 0.01057314f, 
    0.04519797f, -0.05357330f, 0.03635726f, 0.05134685f, -0.04545490f, -0.17488082f, -0.10037988f, -0.04839655f, 
    0.11112251f, -0.03514232f, 0.22802055f, 0.09537321f, 0.02499299f, -0.04454539f, -0.04499621f, -0.08044020f, 
    0.02364780f, 0.05358976f, 0.22801100f, -0.06227853f, 0.06678489f, -0.02873553f, -0.01310885f, 0.13304630f, 
    0.01226981f, 0.11712214f, -0.05653600f, -0.09156431f, -0.06469142f, -0.03946020f, 0.11503545f, 0.14235695f, 
    -0.06857948f, -0.09090321f, -0.02737059f, -0.08518752f, -0.13480198f, 0.00644232f, -0.01746191f, -0.02954813f, 
    -0.06007552f, 0.05816110f, -0.13783504f, 0.04703493f, 0.07543867f, -0.03663506f, -0.01843248f, 0.09520132f, 
    -0.31224936f, -0.09298762f, 0.07528038f, -0.12040260f, 0.12911700f, -0.13887221f, 0.06327715f, -0.30186942f, 
    0.03557971f, -0.05269580f, -0.04781707f, -0.05389749f, -0.02839284f, 0.03559077f, 0.01877946f, -0.12756255f, 
    0.01663746f, -0.09617303f, 0.02700061f, -0.04777295f, 0.13864209f, -0.23196493f, 0.02175764f, -0.09615207f, 
    -0.23560143f, 0.06498446f, -0.08621566f, -0.05351482f, 0.05031173f, -0.08386550f, 0.02023053f, 0.03771287f, 
    -0.18231183f, -0.05874550f, -0.03437803f, -0.10844263f, 0.02088414f, -0.05804306f, -0.10135387f, -0.01059953f, 
    0.14234018f, 0.34196708f, 0.35468465f, 0.33539137f, 0.24010761f, -0.18593591f, -0.00455038f, 0.07316646f, 
    0.05353767f, 0.14854579f, 0.00750982f, 0.04372317f, -0.00199367f, 0.00547318f, 0.06324928f, -0.02650457f, 
    -0.06407858f, -0.09074755f, -0.03433777f, -0.30019030f, 0.18954811f, -0.29912761f, -0.07781623f, -0.12205107f, 
    -0.31709635f, 0.10253706f, 0.02513729f, 0.04950952f, -0.01905882f, 0.02264047f, 0.07965798f, -0.03207849f, 
    -0.19208358f, -0.11588705f, -0.03730446f, -0.12438310f, 0.02569553f, 0.02637399f, -0.11170903f, -0.01138521f, 
    -0.15658340f, -0.12388546f, -0.17669024f, 0.36969033f, 0.13409980f, 0.05125635f, -0.04843541f, 0.06073320f, 
    0.00589248f, -0.02611448f, 0.01162430f, -0.00745330f, 0.05617587f, 0.02649505f, -0.04418046f, 0.13920824f, 
    -0.24758515f, 0.19410215f, 0.08377332f, -0.16823836f, -0.58792168f, -0.37693545f, -0.19895729f, -0.37177303f, 
    0.14656842f, 0.03357708f, -0.04096789f, -0.09224448f, -0.00325047f, -0.00935551f, 0.00481967f, 0.13085359f, 
    0.15901244f, -0.17046998f, 0.14215624f, -0.00110556f, -0.06762825f, 0.12676379f, 0.03174721f, 0.10555632f, 
    -0.67365801f, 0.31147584f, -0.73962510f, -0.19763844f, -0.15395570f, 0.02176348f, 0.03260041f, -0.04025259f, 
    0.11341476f, -0.00421517f, 0.14081249f, -0.05333560f, -0.00528947f, -0.04700046f, -0.16572890f, -0.08067825f, 
    0.03292263f, 0.06652698f, -0.01187309f, 0.06814350f, 0.18323676f, -0.62099582f, 0.11168437f, 0.29547450f, 
    -0.23350196f, 0.26679564f, -0.03769942f, -0.12689656f, 0.10353496f, 0.09982506f, -0.02622192f, 0.07776070f, 
    -0.09952229f, 0.17506462f, 0.07330387f, 0.16275615f, -0.05224225f, 0.00187879f, 0.09842899f, 0.27901626f, 
    0.16802746f, 0.10132562f, -0.27180713f, -0.36181834f, 0.25970390f, 0.18243767f, 0.15329191f, -0.18117231f, 
    -0.10846998f, 0.06190481f, 0.08335102f, 0.09442551f, 0.12111919f, -0.05332283f, -0.07443999f, 0.09627567f, 
    -0.02418334f, -0.17406927f, -0.11301657f, -0.04253645f, 0.26754630f, -0.06760725f, 0.24876754f, 0.12221719f, 
    -0.15527770f, -0.02773734f, -0.08129479f, 0.11287788f, 0.08683091f, -0.01043350f, 0.10903393f, 0.04988686f, 
    0.02416427f, 0.03245005f, 0.00351057f, -0.00021440f, -0.04020037f, -0.22535942f, -0.29620218f, -0.44771621f, 
    -0.07298647f, -0.09386573f, 0.05032967f, 0.08165413f, -0.28699210f, 0.16309667f, -0.01504818f, 0.01480970f, 
    -0.00967978f, -0.07847737f, 0.07528992f, 0.01298192f, -0.00134838f, 0.06422754f, 0.08907067f, 0.02298070f, 
    0.07753111f, -0.04606320f, 0.06190064f, -0.21698534f, -0.56544203f, 0.21584430f, 0.27430913f, -0.22664222f, 
    -0.21328847f, -0.06128003f, 0.04979257f, -0.10680290f, 0.13456212f, 0.19386387f, 0.12036648f, -0.19194968f, 
    -0.12282185f, 0.12710950f, 0.04252923f, -0.07221299f, -0.05911715f, -0.07766529f, 0.19372380f, 0.23097822f, 
    0.90983897f, 0.09132639f, -0.15230201f, -0.12976882f, 0.07990283f, 0.10510550f, 0.08906165f, -0.04899437f, 
    0.01859578f, 0.17874210f, 0.09368986f, -0.01716156f, 0.08961289f, -0.09962769f, -0.06185018f, 0.04407080f, 
    -0.04247087f, -0.18524808f, 0.00238795f, 0.16810183f, 0.00305454f, 0.03884885f, 0.25052476f, -0.39866260f, 
    0.17090923f, 0.07432193f, -0.02210220f, 0.04271429f, -0.13724101f, -0.01128727f, 0.09165990f, -0.30112556f, 
    -0.05458081f, -0.07489607f, -0.02640073f, 0.03937245f, 0.07759518f, 0.09113795f, 0.02015222f, 0.01205044f, 
    -0.45078519f, -0.09591803f, -0.11320397f, 0.38206518f, -0.14797513f, 0.00765255f, -0.24505067f, -0.03078029f, 
    0.01109445f, 0.20494471f, -0.05339503f, 0.19182903f, -0.01458197f, -0.00838282f, -0.07051796f, -0.09919778f, 
    -0.18460123f, -0.00800026f, -0.04812768f, -0.17715071f, -0.22394593f, -0.19021910f, -0.02698544f, 0.12102827f, 
    0.13947883f, 0.18090411f, 0.00390429f, 0.02013132f, 0.02530831f, 0.08200034f, -0.05305452f, -0.08480105f, 
    -0.07055674f, 0.01999116f, -0.00012386f, 0.06183199f, -0.01906423f, 0.09279209f, -0.11654962f, 0.00831595f, 
    -0.59552640f, 0.13027601f, -0.17731497f, -0.14997050f, -0.39517424f, -0.24610652f, -0.12590070f, -0.09658758f, 
    -0.03388724f, -0.11403014f, -0.07115675f, -0.07367959f, -0.10480396f, -0.01873656f, 0.00735756f, -0.33689830f, 
    -0.16580297f, -0.01003034f, -0.19700392f, -0.16300784f, -0.03026036f, -0.17433044f, 0.01631132f, -0.09150822f, 
    -0.21370529f, 0.06497693f, 0.03172017f, -0.18272223f, 0.19391300f, 0.14332008f, 0.04153693f, 0.13100310f, 
    -0.12095106f, 0.01190911f, -0.04020708f, -0.00094142f, 0.01012350f, 0.03150723f, 0.02087074f, 0.21031973f, 
    0.36941838f, -0.08396572f, 0.40965602f, -0.07821280f, -0.10850369f, 0.16400579f, 0.11577293f, -0.04879678f, 
    0.11419242f, 0.06023723f, 0.09568138f, -0.07165006f, 0.05326656f, 0.02715101f, -0.01618846f, -0.02178875f, 
    0.01222403f, 0.02569586f, 0.08647534f, 0.33926296f, -0.22694191f, 0.26105398f, -0.37108499f, -0.47137070f, 
    -0.16612743f, -0.19389257f, -0.05837478f, -0.16227970f, -0.31057915f, 0.39680672f, -0.01409952f, 0.33652470f, 
    -0.17196530f, 0.04330053f, 0.03424864f, 0.00503832f, -0.07343980f, 0.12003821f, 0.07900208f, 0.33858562f, 
    0.35937497f, 0.20225386f, 0.29152331f, -0.31779489f, 0.05602943f, -0.08141895f, 0.14404891f, 0.01661622f, 
    -0.11040120f, -0.15715709f, 0.00230406f, 0.06205187f, -0.02930699f, -0.02763793f, -0.03785624f, 0.01544299f, 
    0.10398375f, -0.02782784f, -0.10617865f, 0.06077621f, -0.15416074f, 0.01132242f, -0.31849703f, -0.09138412f, 
    -0.00523467f, 0.10029610f, 0.01687767f, -0.03201633f, -0.02914096f, 0.03492825f, 0.14009331f, 0.18338321f, 
    -0.00453662f, 0.17938949f, 0.03100539f, -0.03554334f, -0.00500592f, 0.23260273f, 0.09180071f, 0.04824300f, 
    -0.27226710f, 0.15636916f, -0.14142811f, -0.10239751f, -0.08930413f, -0.04207871f, -0.00050376f, -0.13573131f, 
    0.06362086f, -0.00606089f, 0.25516009f, 0.02149281f, 0.13104591f, -0.15906155f, -0.09376139f, 0.05260832f, 
    0.03565783f, 0.13140830f, 0.05228620f, 0.06665473f, 0.16923445f, -0.05255044f, -0.25465247f, 0.02377817f, 
    0.14030883f, 0.22001813f, 0.03765561f, 0.01108611f, -0.03853332f, 0.05101555f, 0.00286540f, 0.00566889f, 
    0.02479579f, 0.03531871f, 0.06409522f, 0.02470755f, -0.04011033f, 0.02513479f, -0.13305044f, -0.02619585f, 
    -0.32087374f, 0.19295846f, 0.06342241f, -0.49712768f, -0.09555082f, -0.07823685f, 0.01871485f, -0.00259752f, 
    0.03641528f, 0.01047020f, 0.03690740f, -0.02054875f, -0.15584637f, -0.13698940f, -0.00660640f, 0.03203158f, 
    -0.14324173f, -0.12787592f, 0.07551794f, -0.20725855f, 0.19540577f, 0.89635569f, -0.52514040f, 0.00210616f, 
    0.11319470f, -0.08299436f, -0.06057210f, -0.05447249f, 0.02193253f, -0.06351640f, -0.00712857f, -0.13615832f, 
    -0.04023756f, -0.01073168f, -0.02382158f, -0.22687924f, -0.09157829f, 0.22122793f, 0.01693938f, -0.35033414f, 
    -0.08760168f, -0.04398758f, -0.06149530f, 0.05455535f, 0.12438852f, 0.02974915f, 0.01905689f, -0.03343140f, 
    -0.06444675f, -0.04118849f, 0.09488408f, -0.17297295f, -0.08465848f, 0.06960349f, 0.12052556f, -0.14518066f, 
    0.10237633f, 0.18577905f, -0.03354193f, -0.06769379f, -0.92829955f, -0.10554090f, 0.02748225f, -0.05251208f, 
    -0.21011893f, 0.06909001f, -0.01451116f, -0.12145612f, 0.01663308f, 0.04461544f, 0.02321233f, 0.10128910f, 
    -0.02159147f, -0.04929945f, -0.05126605f, 0.09464418f, 0.04560515f, 0.09423986f, -0.14615636f, -0.02800822f, 
    -0.12148356f, -0.19077051f, 0.06600486f, 0.17539427f, -0.02719283f, 0.14727311f, 0.05441089f, 0.00111668f, 
    -0.00281379f, 0.05970483f, -0.06009232f, -0.02799571f, -0.01896911f, 0.01661642f, -0.02166406f, -0.14972118f, 
    -0.12025067f, 0.04652211f, -0.07838867f, 0.01427961f, -0.12399976f, 0.03284574f, -0.09842539f, 0.14786300f, 
    -0.06614026f, 0.15520157f, -0.24260095f, 0.16522132f, -0.03135058f, 0.03221830f, -0.10904101f, -0.04332609f, 
    -0.10731018f, -0.13515437f, 0.11693910f, 0.05559640f, 0.08180436f, 0.27240306f, -0.19695836f, 0.02665079f, 
    -0.20313294f, 0.08149832f, -0.12623553f, -0.20584191f, -0.13027702f, 0.07227898f, 0.03277593f, 0.07260264f, 
    0.06364964f, 0.08373854f, 0.09941616f, -0.07706414f, -0.11747435f, -0.00163855f, -0.09541444f, -0.03937316f, 
    0.03197484f, 0.10434276f, -0.07855436f, 0.05705262f, -0.06947828f, 0.05013043f, 0.26534611f, 0.08608551f, 
    -0.05963211f, -0.08530119f, 0.01623444f, 0.13762704f, 0.03557857f, -0.17219411f, 0.05696402f, 0.01030602f, 
    0.05163947f, 0.10995998f, 0.07554969f, 0.01497384f, -0.04911974f, -0.12753925f, 0.10707965f, -0.13419402f, 
    0.00472117f, -0.14391881f, -0.08973757f, -0.27569085f, 0.03870131f, -0.03739800f, -0.06829240f, 0.03795081f, 
    -0.04260586f, -0.19593221f, -0.02013738f, 0.01735906f, 0.03395338f, 0.01092683f, 0.16417226f, -0.17048685f, 
    -0.12335564f, 0.08605483f, 0.02841009f, 0.03869019f, 0.22453885f, -0.15816882f, -0.08501322f, -0.16960032f, 
    0.19093473f, 0.10552394f, -0.04557558f, 0.16274601f, 0.01187272f, 0.00000703f, 0.08307765f, -0.01841342f, 
    -0.07804774f, 0.05073255f, 0.19743167f, -0.02397200f, -0.03490268f, -0.09666907f, 0.11075430f, 0.11351325f, 
    0.18726049f, -0.05561630f, 0.46919933f, -0.11909962f, -0.25532827f, 0.20504715f, 0.13917345f, -0.07432449f, 
    -0.03649298f, -0.05444393f, 0.17916359f, 0.04491409f, 0.00479842f, 0.03926788f, 0.02947144f, 0.00969191f, 
    0.06759097f, -0.07379630f, 0.17624645f, 0.19664863f, -0.31145695f, 0.23099932f, -0.12394407f, 0.16760510f, 
    -0.03420489f, -0.01012222f, -0.12562688f, -0.04324677f, 0.05632772f, -0.02404543f, 0.00158632f, 0.03299856f, 
    0.00192265f, 0.10437876f, 0.04259545f, 0.02041978f, -0.04355284f, 0.01021742f, 0.07233392f, 0.09868094f, 
    0.02073142f, -0.08859725f, 0.02535166f, 0.02266672f, 0.01234134f, -0.01423931f, 0.07369491f, 0.08506412f, 
    -0.04371024f, -0.04785032f, -0.08914156f, -0.05142162f, -0.03125555f, -0.02522603f, 0.04657731f, -0.09111007f, 
    -0.00246913f, -0.10386949f, -0.03433359f, 0.07394145f, -0.29805008f, 0.51995271f, 0.00869094f, -0.09359517f, 
    0.35162553f, -0.11532673f, -0.09767396f, -0.03605704f, 0.12583657f, 0.06919120f, 0.19002971f, 0.01196128f, 
    0.19162241f, -0.06194204f, -0.05019136f, 0.02462430f, -0.00979721f, 0.02253123f, -0.01858754f, 0.02904928f, 
    -0.56197339f, 0.22863032f, 0.38075477f, -0.00787690f, 0.27452010f, -0.13335076f, -0.06764757f, 0.02406752f, 
    -0.12864301f, 0.41876659f, -0.13466449f, 0.12213785f, 0.12425914f, -0.00880018f, 0.15104921f, -0.01441009f, 
    -0.01686898f, -0.08843650f, 0.01674703f, -0.06018583f, -0.01008489f, 0.09825101f, -0.15590616f, 0.01125216f, 
    0.26608071f, -0.00200631f, 0.02215730f, -0.00231703f, 0.24561758f, 0.22284289f, -0.10527453f, 0.01225807f, 
    -0.01578376f, 0.08807320f, 0.05108276f, 0.10385933f, 0.07067887f, -0.14820541f, 0.20956428f, -0.04767643f, 
    0.35879645f, -0.07316338f, -0.10379554f, -0.07281900f, -0.00832268f, 0.16048115f, 0.11656521f, 0.11875127f, 
    -0.04357368f, 0.01603764f, 0.03892826f, -0.05934596f, -0.04126298f, -0.16469292f, 0.10207784f, -0.03368960f, 
    -0.00971889f, -0.13325667f, -0.08700585f, 0.02411670f, -0.47684789f, -0.51634020f, -0.68832195f, -0.27168256f, 
    -0.00526446f, -0.17092867f, 0.00012226f, -0.02037768f, -0.18124096f, -0.15500112f, 0.00629837f, 0.01027638f, 
    -0.01671564f, 0.05912354f, -0.00114167f, -0.11767531f, -0.01663623f, 0.10784714f, 0.25194332f, -0.01343340f, 
    -0.65297478f, -0.37876192f, -0.75193375f, -0.30852288f, -0.19230075f, -0.30753681f, -0.03226444f, -0.10012154f, 
    -0.31679362f, -0.32271093f, 0.00615977f, 0.01746423f, 0.03394912f, 0.01347575f, -0.03622921f, -0.02786032f, 
    -0.05366582f, 0.01031769f, 0.11017226f, -0.09009073f, -0.39072576f, -0.24187970f, 0.55434114f, -0.01541783f, 
    0.03354385f, -0.01684679f, -0.32561776f, 0.11373042f, -0.05589877f, 0.17555740f, 0.08092316f, 0.06845518f, 
    -0.02977019f, 0.23338120f, -0.02217858f, -0.01367489f, 0.05534415f, -0.01136281f, -0.08852173f, 0.07943525f, 
    0.16898362f, 0.08994592f, -0.20115736f, -0.72439665f, 0.05546000f, -0.22741191f, 0.00420655f, 0.17388916f, 
    0.14641516f, -0.13977331f, -0.02564361f, 0.00315105f, -0.03441523f, 0.03452021f, 0.00694473f, 0.05603114f, 
    0.05916799f, 0.09169946f, 0.05595192f, 0.02641995f, 0.13651866f, 0.03870529f, -0.05875906f, 0.20618351f, 
    -0.00956748f, 0.08414658f, 0.08805755f, -0.04246875f, -0.19483399f, -0.12545447f, 0.01564156f, 0.03809676f, 
    -0.26513660f, -0.06427240f, 0.10901518f, 0.01319042f, -0.04334248f, 0.24300669f, -0.43727240f, -0.27553153f, 
    -0.13043670f, 0.17529854f, -0.68763596f, -0.19815764f, 0.21904919f, -0.03506449f, 0.06691497f, 0.13311195f, 
    0.06765006f, 0.13639966f, -0.04196383f, 0.05907398f, 0.08946704f, -0.02171522f, -0.00303074f, -0.03214669f, 
    0.08855819f, -0.25801215f, 0.12726027f, -0.01708710f, 0.16717798f, -0.14397618f, -0.21545640f, -0.17216249f, 
    0.13203619f, -0.00207837f, 0.04699757f, 0.11530776f, -0.02709997f, 0.00462728f, -0.14040466f, -0.03380602f, 
    -0.12821907f, -0.09011871f, -0.04767390f, -0.09363627f, -0.09433901f, -0.20494792f, 0.01112191f, 0.08181926f, 
    0.03485914f, -0.35563147f, -0.26682895f, -0.11414950f, 0.44507334f, -0.04283119f, -0.10769890f, 0.04156892f, 
    0.01502490f, 0.19573043f, -0.03045110f, -0.01743596f, 0.09881061f, -0.09083874f, -0.23710202f, -0.00107283f, 
    0.10668258f, -0.01309819f, 0.16246495f, -0.01731525f, -0.53415203f, 0.50083303f, 0.40119848f, -0.10844374f, 
    0.03233932f, -0.12426826f, -0.10773390f, -0.25394040f, -0.12388051f, 0.14689519f, 0.06221253f, 0.21490848f, 
    -0.04068085f, 0.06402142f, 0.03033292f, -0.03957835f, -0.10112214f, -0.01686639f, 0.03337868f, -0.03996079f, 
    -0.12355670f, -0.41428447f, -0.51547617f, -0.07013489f, -0.10742509f, 0.04800442f, 0.07424300f, -0.05307431f, 
    0.17816323f, -0.27916822f, 0.00902192f, -0.05761496f, -0.10771184f, 0.03540418f, 0.11654627f, 0.00239290f, 
    -0.02449955f, 0.23988393f, 0.13199160f, -0.02174654f, -0.41688597f, 0.32280031f, -0.02525528f, 0.14973125f, 
    0.18950042f, 0.00025400f, -0.08866502f, -0.06321383f, 0.00755695f, -0.12916377f, 0.06682827f, 0.19644722f, 
    -0.05712714f, 0.20317592f, 0.04944146f, 0.07470024f, 0.00387196f, -0.06375541f, -0.10163051f, 0.07041948f, 
    -0.08572248f, -0.79766357f, -1.15334046f, -0.27485156f, -0.12880269f, -0.19248049f, 0.14573145f, -0.03080312f, 
    0.00874114f, -0.80665696f, 0.11709463f, 0.02970038f, -0.16273464f, -0.08158028f, 0.05412446f, -0.00182747f, 
    -0.00471507f, 0.24418917f, 0.06679429f, -0.03572999f, -0.05412469f, -0.05951802f, 0.14835539f, -0.04840541f, 
    0.04501381f, 0.03850119f, -0.03399645f, 0.04544770f, 0.03473892f, 0.04382214f, -0.04154279f, 0.10337967f, 
    0.05543611f, 0.05503077f, 0.13813010f, 0.03527362f, -0.03009386f, 0.00450982f, -0.09785666f, -0.05078399f, 
    -0.22678229f, -0.05815116f, 0.30658263f, 0.05266411f, 0.00308798f, -0.01877299f, -0.09783038f, 0.02226174f, 
    -0.08682062f, 0.09815429f, 0.22155243f, 0.02081257f, 0.06955931f, -0.02983983f, 0.03536503f, -0.03062371f, 
    0.00854516f, -0.10133422f, -0.06094742f, 0.02964238f, 0.14247489f, 0.03690990f, -0.03834130f, -0.08116879f, 
    0.15727116f, 0.04745108f, 0.11868402f, 0.08766524f, -0.03613176f, 0.05660708f, -0.03965728f, 0.02325536f, 
    0.05079202f, -0.04896875f, 0.04945146f, -0.04078723f, -0.04073901f, -0.04810078f, -0.06780195f, 0.14163014f, 
    -0.63824040f, -0.18468873f, -0.25923958f, 0.00758942f, 0.10345448f, 0.09604035f, 0.13405286f, 0.09304411f, 
    0.06910080f, -0.09254821f, 0.05718004f, 0.07574610f, 0.14457746f, 0.09060878f, 0.13937081f, 0.02931858f, 
    0.09037992f, 0.21579151f, -0.07826250f, 0.01008223f, -0.22948414f, -0.05586825f, 0.21577920f, -0.27770069f, 
    0.28735963f, -0.10067005f, 0.04390946f, -0.03096385f, 0.11310575f, 0.05801712f, 0.06405385f, 0.06846880f, 
    0.18383105f, 0.00997202f, -0.01107500f, -0.02917044f, 0.10103069f, 0.12214451f, 0.22974406f, 0.04113564f, 
    -0.01352530f, -0.03352286f, 0.02453795f, -0.16551834f, -0.07713497f, -0.01944450f, -0.00238259f, -0.06072861f, 
    -0.12413934f, -0.02060997f, -0.15375264f, -0.12341139f, -0.14892960f, -0.19791038f, -0.10968583f, -0.26123556f, 
    -0.23468530f, 0.02653247f, -0.07592416f, 0.01232053f, -0.26597625f, -0.86386204f, -0.61484444f, 0.00648744f, 
    0.28138214f, -0.08999383f, 0.24363764f, 0.12437667f, -0.15837699f, 0.01009533f, 0.02967854f, -0.08414843f, 
    -0.00012615f, 0.03926239f, 0.01025193f, -0.00443181f, 0.12049685f, 0.06125553f, 0.25426430f, 0.11505543f, 
    0.07975774f, 0.08030438f, -0.03999972f, -0.19423865f, 0.09379554f, -0.01008439f, 0.03376726f, 0.03937532f, 
    -0.03762630f, -0.03093168f, -0.06120154f, -0.03813631f, -0.04968367f, -0.01696781f, -0.01812456f, -0.01788365f, 
    -0.12454342f, -0.31454650f, 0.04539460f, 0.16196184f, 0.31312788f, -0.44338760f, -0.30722016f, -0.16048673f, 
    0.21848862f, -0.10033923f, 0.07125711f, 0.07806402f, 0.05569477f, -0.07262833f, -0.04655868f, -0.01505308f, 
    -0.08065159f, -0.09393888f, 0.05829380f, -0.01499667f, -0.01632600f, 0.02667127f, 0.10232978f, -0.08257712f, 
    -0.46477905f, 0.36094102f, 0.38390315f, -0.02040381f, 0.07367538f, -0.17670467f, -0.03702858f, -0.13184135f, 
    -0.12799373f, 0.06693932f, -0.19291230f, 0.04393741f, 0.08082624f, 0.03271321f, 0.07450608f, 0.01091666f, 
    -0.04315815f, -0.09595782f, -0.04355303f, -0.07279689f, -0.47264421f, -0.76088423f, -0.34077436f, -0.00700528f, 
    -0.08589225f, -0.09815843f, -0.13953604f, -0.00804420f, -0.12027192f, -0.25364584f, -0.00978456f, -0.01291661f, 
    0.05683045f, -0.10554419f, -0.09444319f, 0.04152828f, 0.04460566f, -0.01390012f, 0.12849118f, 0.00423628f, 
    -0.31808048f, 0.33835959f, -0.06522453f, -0.13018446f, 0.51783216f, -0.05425590f, 0.04322043f, 0.09046116f, 
    0.15317483f, 0.00882215f, 0.15682058f, 0.02523330f, 0.08360613f, -0.13164800f, -0.14440739f, 0.00020305f, 
    0.06869465f, -0.00441125f, 0.10232798f, 0.00322879f, 0.08248262f, -0.01288996f, -0.03222975f, 0.02100929f, 
    -0.07669216f, 0.11381660f, 0.08647450f, -0.01699126f, 0.02867351f, 0.09086244f, 0.01510193f, -0.02853381f, 
    0.03121902f, 0.01139358f, -0.00286328f, 0.06788515f, 0.17495781f, -0.05234339f, -0.05901662f, 0.10916733f, 
    -0.95481449f, -0.90486598f, -0.32112154f, -0.16952427f, -0.10603724f, -0.17523974f, -0.09809719f, -0.14891176f, 
    -0.22788560f, -0.33555907f, 0.01013890f, -0.06019330f, -0.03212881f, 0.04954486f, -0.01196217f, -0.02322707f, 
    0.02205372f, 0.05998668f, 0.15072267f, -0.01946754f, 0.09929790f, 0.06083410f, 0.16040094f, -0.02089788f, 
    -0.01994828f, -0.01997822f, 0.08006297f, 0.03007020f, -0.02590156f, 0.02341460f, 0.02745184f, -0.11370063f, 
    0.01052745f, 0.06423936f, -0.10723900f, 0.02562105f, -0.02606859f, 0.00376715f, -0.00914355f, 0.03250397f, 
    -0.05932522f, 0.07753497f, 0.00751594f, -0.00447095f, -0.09912938f, -0.06687340f, -0.05538403f, -0.06842282f, 
    -0.06954081f, -0.02818194f, 0.04865877f, 0.01941456f, 0.05448043f, 0.01640684f, -0.00820479f, -0.06277201f, 
    -0.25087973f, 0.13012870f, -0.05994881f, 0.00889504f, -0.14295886f, -0.09627992f, -0.27692768f, 0.03458755f, 
    -0.10217219f, 0.02215856f, 0.05820134f, 0.20015632f, -0.07891314f, 0.05219696f, -0.19621931f, 0.18413702f, 
    -0.08866901f, 0.03727527f, -0.01844987f, -0.05223794f, -0.02538530f, -0.07571641f, 0.01943410f, 0.05230356f, 
    0.60817760f, 0.25501958f, -0.28336468f, -0.30413195f, -0.31769702f, -0.03092463f, -0.07755148f, -0.11291527f, 
    -0.02901063f, -0.09506823f, 0.10817372f, 0.04041148f, -0.02112977f, 0.04259198f, -0.02906103f, -0.00105652f, 
    0.01398317f, -0.05797270f, 0.06976732f, 0.00612887f, 0.24096484f, 0.07396977f, -0.31304932f, 0.06118638f, 
    -0.09829872f, 0.06946880f, -0.01543807f, -0.14178875f, -0.13752849f, -0.08015758f, 0.00685177f, 0.03149135f, 
    0.04863149f, -0.06967385f, -0.04369490f, -0.05345258f, -0.35295227f, 0.06035263f, -0.13820687f, -0.19278781f, 
    -0.06768786f, 0.05291754f, 0.12531127f, -0.03251556f, 0.01510523f, -0.06345500f, -0.00055245f, -0.03523302f, 
    -0.00730831f, 0.04075423f, 0.07388745f, 0.00218878f, 0.08545644f, 0.03151501f, -0.02277411f, -0.03588202f, 
    0.06062721f, -0.25918183f, 0.08917027f, 0.01297053f, -0.48189679f, -0.46795532f, -0.17272717f, 0.18406516f, 
    0.04705128f, 0.09218808f, 0.02172689f, 0.01942903f, 0.14845148f, 0.07474514f, 0.00279459f, -0.03644049f, 
    -0.10385917f, -0.11110946f, -0.07397438f, 0.10772628f, 0.15145427f, -0.08568863f, 0.17837435f, -0.01736340f, 
    0.28187031f, -0.41417229f, -0.41602895f, -0.39849129f, -0.24217661f, 0.06093966f, 0.04519580f, -0.03621352f, 
    0.30721697f, 0.15407941f, -0.03880732f, -0.01418122f, -0.05286898f, -0.10866423f, -0.03060290f, -0.08805420f, 
    -0.05500938f, -0.07022633f, 0.09348089f, -0.07704219f, 0.49785501f, -0.01740934f, 0.07239386f, -0.35036957f, 
    0.01846495f, -0.31149074f, 0.15558052f, 0.00817765f, 0.04759245f, -0.03682179f, 0.06063225f, -0.07902962f, 
    0.12272636f, 0.14109525f, 0.05805922f, -0.13160525f, 0.04415178f, -0.02229550f, -0.05145995f, 0.03181462f, 
    -0.40206006f, 0.30147383f, -0.09731545f, 0.09507867f, 0.11661358f, -0.08151341f, 0.11149094f, 0.04416407f, 
    -0.14035694f, 0.00641651f, 0.07914153f, 0.02395460f, 0.05860709f, 0.00158224f, 0.03581225f, 0.12404969f, 
    -0.02948345f, 0.16029644f, -0.18205345f, 0.03032325f, -0.18290088f, -0.09715525f, 0.19176503f, 0.01965909f, 
    0.10198632f, -0.02464744f, -0.01565690f, 0.04567585f, 0.03253832f, 0.14577198f, 0.09020699f, -0.08479419f, 
    0.04856734f, 0.03837072f, 0.03861504f, 0.01829028f, 0.01015875f, -0.07929430f, 0.01361845f, -0.00710370f, 
    -0.12874271f, 0.39867464f, 0.11049043f, 0.03953606f, -0.41787720f, -0.00493844f, 0.14378391f, -0.11114813f, 
    -0.11584437f, -0.09268745f, 0.01484223f, 0.04963007f, 0.02088223f, -0.01891382f, 0.02799661f, -0.14702643f, 
    0.00367231f, 0.04271975f, -0.15854947f, 0.02321767f, -0.02366656f, 0.12351511f, 0.06626759f, 0.00403279f, 
    -0.17181629f, -0.02366297f, 0.02711121f, -0.02698919f, -0.02087452f, -0.02457816f, 0.02421936f, 0.00907650f, 
    0.04700812f, 0.02667726f, -0.02021160f, -0.06075220f, -0.27139348f, 0.13875699f, 0.04763711f, 0.01477284f, 
    0.63408917f, -0.79794633f, -0.67149180f, -0.70238364f, -0.33306718f, 0.09183851f, -0.03135344f, -0.27606848f, 
    0.19550474f, -0.07879215f, 0.05596440f, 0.01791587f, -0.04764429f, 0.10197073f, 0.02476255f, -0.21835703f, 
    -0.15965438f, -0.26272190f, 0.04691259f, 0.05815572f, 0.56929231f, -0.69465512f, -0.32841855f, -0.48484719f, 
    -0.15846924f, 0.00036197f, -0.08249857f, -0.07613166f, 0.05327696f, -0.25429097f, 0.05046553f, -0.02096843f, 
    0.02922079f, 0.02824395f, 0.06058030f, -0.04594637f, -0.01714762f, 0.05589543f, -0.05660210f, -0.04433549f, 
    -0.93486398f, -0.86645108f, 0.59445906f, 0.00297772f, 0.48006988f, 0.10717127f, 0.00707124f, -0.07324781f, 
    -0.10988856f, -0.16246520f, 0.02822728f, -0.03001692f, -0.10956325f, -0.05615191f, -0.00104523f, 0.06380338f, 
    -0.05550346f, -0.24094053f, -0.10440747f, -0.15133947f, 0.09247392f, -0.06939220f, 0.15910532f, -0.10301346f, 
    0.07247633f, -0.09399992f, 0.11549298f, -0.02961113f, 0.07191994f, -0.01837217f, 0.02157608f, 0.07878336f, 
    0.07229678f, 0.02276352f, 0.14352407f, -0.07714962f, 0.02916611f, -0.09820328f, 0.01378533f, 0.02935405f, 
    -1.28063536f, -1.01431286f, 0.52097273f, 0.28862321f, 0.22366861f, 0.00926663f, 0.05150591f, -0.17458503f, 
    -0.00266773f, 0.13657588f, 0.06532588f, -0.01888444f, 0.04624015f, -0.02101638f, -0.05106676f, 0.04925622f, 
    -0.01032544f, -0.20711005f, -0.15014935f, -0.18667994f, 0.06532191f, 0.07439458f, -0.01831841f, -0.00292169f, 
    -0.10744858f, -0.02522819f, 0.00734053f, 0.02015058f, -0.04933540f, -0.06641658f, -0.11438540f, -0.31940743f, 
    -0.28356040f, -0.26487139f, -0.31165197f, 0.00494808f, 0.02192457f, 0.02575244f, -0.05460354f, -0.01929536f, 
    0.22044815f, 0.14601314f, -0.00622856f, -0.15783709f, -0.18060534f, -0.02572289f, 0.03567091f, 0.01387233f, 
    -0.08492523f, -0.05319043f, -0.02470031f, -0.17183864f, 0.23987760f, -0.00676732f, 0.00598032f, 0.04153820f, 
    -0.05690456f, 0.00512215f, -0.03125413f, -0.06122164f, -0.04504507f, -0.00002130f, 0.09856696f, -0.07824536f, 
    0.00672121f, -0.06033542f, 0.00132202f, -0.08770381f, -0.03592634f, -0.03061171f, -0.01663676f, -0.06864921f, 
    0.04149136f, -0.02704284f, -0.06179139f, -0.19765921f, -0.20981058f, -0.27255777f, 0.02148006f, -0.03508228f, 
    -0.19534779f, -1.15095484f, 0.71627086f, -0.57974195f, 0.73831773f, -0.04083902f, -0.15068907f, 0.26869076f, 
    0.08949463f, 0.07915993f, -0.07100106f, 0.11059604f, 0.00010645f, -0.00782893f, -0.15398841f, -0.18195991f, 
    -0.03288146f, 0.04309133f, -0.00458953f, -0.08946110f, -0.05443675f, 0.33703569f, -0.22988974f, 0.17569469f, 
    -0.58434874f, 0.03308476f, 0.05237302f, 0.11861654f, -0.04619439f, 0.00566246f, -0.10576992f, 0.00824873f, 
    -0.16870387f, 0.06117539f, -0.05103045f, -0.09386404f, -0.13848785f, -0.00608772f, 0.01945623f, 0.13913532f, 
    0.02403785f, 0.07886814f, 0.04190123f, 0.01061214f, -0.09757022f, 0.01806981f, 0.01742947f, 0.00659597f, 
    0.02488965f, -0.04356181f, 0.04166902f, 0.05517369f, -0.02764210f, -0.07478932f, -0.03588948f, 0.12878662f, 
    0.03547062f, 0.02918522f, 0.10257488f, 0.03916986f, -0.02277303f, 0.19058023f, 0.05080204f, 0.00566162f, 
    -0.23050712f, -0.00883608f, -0.05831895f, -0.20448083f, -0.02049369f, -0.07797024f, 0.03155386f, 0.06149419f, 
    0.08341642f, -0.02239642f, -0.03622640f, -0.00660996f, -0.06998246f, 0.14018974f, -0.03412119f, -0.08892340f, 
    -0.01069659f, 0.01218025f, 0.03181859f, 0.04321942f, -0.06891391f, 0.04088438f, 0.03904043f, -0.03449593f, 
    -0.04582416f, -0.00672553f, 0.08299230f, -0.00391813f, 0.06910968f, 0.01364623f, 0.02695377f, 0.01290990f, 
    -0.06036742f, -0.34679905f, 0.12473282f, 0.01943785f, -0.12705396f, -0.05781237f, -0.00972367f, 0.08429689f, 
    -0.19238661f, 0.01669606f, -0.02900366f, 0.16663067f, 0.03267943f, -0.03668137f, 0.06345813f, 0.07494114f, 
    0.01047487f, 0.01255104f, -0.08257744f, 0.07129575f, 0.03677256f, -0.01078987f, 0.04811833f, 0.03974153f, 
    0.26500738f, -0.04935642f, -0.20834626f, -0.13519615f, -0.14963144f, 0.01941029f, 0.00842626f, 0.03406813f, 
    -0.02672300f, -0.02463664f, 0.09836766f, 0.02492510f, 0.18519123f, 0.09710287f, 0.03673745f, 0.01106608f, 
    0.00664494f, 0.04108106f, 0.00704155f, -0.01405977f, 0.06614036f, -0.63975048f, -0.13861524f, 0.21078350f, 
    -0.26943409f, -0.05515767f, 0.06924354f, -0.06941666f, 0.16312331f, 0.16204117f, -0.05658859f, -0.05061097f, 
    -0.07655925f, -0.11310389f, 0.03128280f, -0.08826659f, 0.08851260f, -0.19913897f, 0.03917253f, -0.13861932f, 
    -0.62288004f, -0.21204054f, -0.43755084f, -0.11662266f, -0.22245686f, -0.07360970f, -0.05039766f, 0.34928223f, 
    -0.08736993f, 0.06942291f, -0.11096752f, 0.14684190f, 0.00026779f, 0.01076268f, -0.01414980f, -0.01158693f, 
    -0.09432483f, -0.03325773f, -0.01271845f, 0.05899573f, -0.05270100f, 0.01038018f, 0.08920885f, -0.16123766f, 
    -0.00755449f, -0.15171596f, -0.00710700f, -0.01673589f, -0.14044985f, -0.01700690f, 0.08218565f, -0.00317413f, 
    -0.12435588f, 0.00034570f, -0.18050402f, -0.23847879f, -0.01777842f, -0.19723810f, 0.08012391f, -0.07024153f, 
    0.21702944f, -0.61935973f, 0.20882423f, 0.53526497f, -0.21444665f, 0.05130104f, 0.19012675f, 0.01419169f, 
    0.03966961f, 0.07314489f, 0.03271515f, -0.00151903f, 0.03172277f, -0.04985277f, -0.02700240f, 0.04890298f, 
    -0.04698290f, -0.00417058f, 0.06335316f, -0.06478737f, 0.04504815f, 0.11620554f, -0.13591826f, -0.02311439f, 
    -0.20710416f, 0.02610462f, 0.04957097f, -0.01537980f, -0.05167699f, -0.05039043f, -0.13905911f, 0.03105154f, 
    -0.06351172f, -0.08746350f, -0.19129835f, -0.01027090f, -0.01833865f, -0.02830397f, -0.07600714f, -0.00775373f, 
    -0.31343186f, 0.19241698f, 0.17788295f, 0.06030422f, -0.23459697f, -0.03812724f, 0.00131399f, -0.11655239f, 
    0.00625149f, 0.02768360f, -0.08115242f, 0.04134191f, -0.07351203f, 0.04453244f, 0.00974269f, -0.01664988f, 
    0.08692917f, -0.05757286f, -0.00145314f, 0.02044994f, -0.35602471f, -0.55704647f, 0.12510388f, -0.01925559f, 
    0.15199837f, -0.05034325f, 0.08230051f, 0.09222460f, -0.06380763f, -0.02224408f, 0.11965350f, 0.11423818f, 
    -0.00462843f, 0.12994273f, 0.05363105f, 0.01851717f, -0.01022047f, -0.00297475f, 0.08731607f, -0.07503845f, 
    0.07756920f, -0.80613250f, -0.61238992f, -0.29488820f, -0.07660745f, -0.08740475f, 0.16316083f, 0.22964196f, 
    0.18411736f, 0.17974184f, 0.09747794f, -0.00060953f, -0.05894201f, -0.03944307f, -0.19382466f, -0.01479044f, 
    -0.02418038f, 0.02490214f, 0.03873304f, 0.00658790f, 0.49300706f, 0.13170084f, -0.09582166f, 0.03887152f, 
    -0.17737322f, 0.16737287f, 0.05399916f, 0.09218049f, 0.04129265f, -0.04415568f, 0.09382578f, 0.09858376f, 
    0.05187114f, 0.12164008f, -0.04050717f, -0.00028556f, 0.07724113f, -0.04659776f, 0.28932002f, -0.03428060f, 
    -0.43899599f, 0.06645957f, 0.07013088f, 0.18093924f, 0.01798657f, -0.05452590f, -0.09989126f, 0.14982292f, 
    0.05881640f, 0.00701989f, 0.00741435f, -0.01457620f, -0.03512723f, 0.01303710f, 0.03532696f, -0.10594212f, 
    0.05107270f, 0.15975212f, 0.02936311f, 0.08059480f, 0.37445480f, -0.09366214f, -0.21968462f, -0.26498589f, 
    -0.05707565f, -0.00855301f, -0.18464999f, 0.03245632f, -0.05787125f, -0.20018999f, 0.07716962f, 0.00754263f, 
    -0.01836769f, 0.10566108f, 0.04479735f, 0.13331543f, 0.06330806f, 0.09127238f, -0.21572940f, -0.43281397f, 
    -0.13882674f, -0.33742538f, -0.68905491f, -0.63945925f, -0.21941586f, -0.19974898f, -0.18902205f, 0.00101192f, 
    -0.09494914f, -0.34299779f, -0.03091088f, -0.02047290f, -0.06162270f, 0.04406058f, 0.05518917f, 0.11885344f, 
    0.03816042f, 0.11003570f, 0.03223711f, 0.03051402f, 0.15649007f, -0.03583583f, -0.48271474f, -0.30693516f, 
    -0.24804139f, -0.02130561f, -0.14412092f, 0.20276962f, 0.00102595f, 0.29011816f, 0.12318504f, 0.05568737f, 
    -0.04894447f, -0.11275133f, 0.11648743f, -0.06949119f, -0.04189334f, 0.01940260f, -0.16442470f, 0.20028812f, 
    -0.99618286f, -0.24432191f, 0.21610793f, 0.24719645f, 0.30939209f, 0.09035242f, 0.06044683f, -0.08521111f, 
    -0.12884849f, -0.08088613f, -0.00363372f, -0.09890600f, 0.04693129f, -0.07667926f, -0.04263902f, -0.13907488f, 
    -0.26384625f, -0.23728824f, -0.11262847f, 0.00043053f, 0.17640091f, -0.17898995f, -0.05807024f, 0.22487362f, 
    -0.04337729f, -0.07672302f, -0.10887885f, -0.07367437f, -0.22942816f, 0.01941093f, -0.01659143f, 0.16907772f, 
    0.05297740f, -0.02721475f, 0.07481769f, -0.09370728f, 0.12709691f, 0.21425804f, 0.30718392f, 0.29156002f, 
    0.65932268f, 0.48548716f, 0.11690168f, 0.04199994f, -0.06560656f, -0.02464180f, 0.04238250f, 0.01303637f, 
    0.01780417f, -0.13578397f, 0.01817030f, -0.03684718f, 0.05362558f, -0.07502698f, -0.00548322f, 0.02393193f, 
    -0.16833328f, -0.10901366f, -0.03257254f, -0.16241562f, -0.35936916f, 0.22452763f, 0.08412495f, 0.06185919f, 
    -0.22075143f, -0.06530388f, -0.08874916f, -0.03056331f, -0.01285022f, -0.14958467f, -0.09463489f, -0.05731435f, 
    0.02939336f, -0.06761697f, -0.03221090f, 0.02286104f, 0.06271339f, 0.06859429f, 0.02913301f, 0.01843205f, 
    0.10416086f, -0.18054745f, -0.78532255f, -0.32478729f, 0.05830605f, 0.15070555f, 0.11584618f, 0.10212633f, 
    0.22734059f, 0.12676182f, 0.00926646f, -0.03262506f, -0.01341669f, 0.03332403f, 0.00875645f, 0.16913563f, 
    -0.07952953f, 0.04053547f, -0.19710146f, -0.18813653f, 0.21721396f, -0.37842917f, -0.57475197f, -0.10778520f, 
    0.05537085f, -0.04851774f, 0.18734086f, 0.11205952f, 0.06186002f, 0.11240882f, 0.11615214f, -0.15183793f, 
    -0.11132424f, -0.07753912f, -0.08022339f, 0.06498457f, 0.06792536f, -0.01405397f, 0.12840989f, 0.00720866f, 
    1.01150358f, -0.49743229f, -0.02276895f, 0.11404365f, -0.04217278f, 0.08961551f, -0.10032318f, -0.13204186f, 
    -0.11245144f, 0.07306954f, 0.11409128f, 0.18190064f, 0.06738139f, 0.05190276f, 0.07682890f, 0.03304349f, 
    0.09233899f, 0.00847711f, -0.06442244f, 0.04609104f, -0.00736053f, -0.32055160f, -0.19596291f, 0.16876669f, 
    -0.04721228f, -0.15635614f, 0.21071878f, 0.15812863f, 0.07343317f, 0.19532593f, 0.09119570f, -0.06544848f, 
    -0.19129433f, 0.06481234f, 0.02392423f, 0.12219101f, 0.11453415f, 0.05679358f, 0.07784485f, 0.11783420f, 
    -0.08519481f, -0.38132620f, -0.09057435f, -0.09237775f, -0.22337094f, 0.09613694f, -0.02537869f, -0.03117281f, 
    -0.06493114f, -0.22466892f, -0.03947214f, 0.00325590f, 0.12213551f, -0.03248366f, 0.05299755f, 0.04065963f, 
    0.09010304f, 0.13218489f, -0.04082467f, -0.09010252f, -0.17319235f, 0.00209554f, 0.05328656f, -0.04797623f, 
    -0.11963904f, -0.10151020f, 0.05231157f, 0.10522405f, 0.09991072f, 0.01120331f, 0.08232254f, 0.16728954f, 
    0.11587664f, 0.08541618f, 0.15095882f, -0.00087423f, 0.06504984f, 0.06544184f, 0.09594530f, 0.06999986f, 
    -0.02034413f, -0.10004694f, -0.14338706f, -0.11549905f, -0.12446575f, -0.05005750f, 0.03673226f, 0.12103339f, 
    0.05832600f, 0.01540730f, 0.09189910f, 0.09306123f, 0.08300326f, 0.04372923f, 0.11723384f, -0.00229116f, 
    0.11461549f, 0.04122615f, 0.13756785f, 0.18220578f, -0.26576090f, 0.15289047f, 0.09826949f, 0.17372307f, 
    -0.02286063f, 0.00388158f, -0.03976763f, 0.02985696f, 0.05242737f, -0.02327519f, 0.00202828f, 0.02824654f, 
    -0.01192756f, -0.04427664f, 0.00119506f, -0.09772376f, 0.06154358f, 0.08872350f, -0.07682832f, 0.07110683f, 
    -0.12815756f, -0.95236534f, -0.43456665f, 0.09640523f, 0.42619711f, 0.02467735f, -0.09893645f, 0.14510289f, 
    -0.06836917f, -0.00052773f, 0.05934436f, -0.10554467f, -0.06501444f, 0.09393919f, 0.06430780f, 0.05839230f, 
    0.00641000f, -0.10634850f, -0.26514405f, -0.11546964f, 0.22278494f, 0.08455687f, 0.15309696f, -0.12801410f, 
    -0.06030995f, -0.09992276f, 0.07461251f, -0.17556415f, 0.03920154f, -0.08828608f, -0.07881094f, -0.01737768f, 
    0.04810762f, -0.20573358f, -0.01135665f, -0.00350658f, -0.14386131f, -0.34405044f, 0.06038079f, -0.27973840f, 
    -0.40182889f, 0.03573280f, 0.13109632f, -0.05281382f, -0.26015931f, -0.11042328f, -0.10459399f, -0.09357022f, 
    -0.02914620f, -0.07566494f, -0.14363042f, -0.06545529f, -0.04579990f, -0.01245488f, -0.02222869f, 0.03837714f, 
    0.07158065f, 0.07721981f, 0.02921354f, 0.03158217f, 0.30328861f, 0.08370474f, 0.26009184f, -0.10613199f, 
    -0.20952916f, -0.02149483f, -0.17950957f, -0.04583791f, -0.01089617f, -0.24681763f, -0.06145491f, 0.03992832f, 
    -0.01479505f, -0.08324172f, -0.00604042f, -0.02595646f, -0.11269615f, -0.33027336f, -0.07281622f, -0.17718767f, 
    -0.50558436f, 0.18965337f, 0.16178344f, 0.09372760f, -0.20641762f, -0.02896841f, -0.09354402f, -0.02952500f, 
    -0.02953900f, -0.09593071f, -0.07825456f, -0.05062240f, -0.01844149f, -0.04885692f, -0.02099753f, -0.02336703f, 
    0.01846644f, -0.12020785f, -0.01066549f, -0.03574463f, 0.13288493f, 0.17885353f, 0.03595999f, -0.00126590f, 
    -0.18974227f, -0.05683197f, -0.12404845f, -0.15378626f, -0.03974618f, -0.24895047f, -0.01535098f, 0.02997604f, 
    0.05776753f, -0.03146411f, 0.08445344f, -0.00974515f, 0.18259318f, 0.23446032f, 0.23388848f, 0.11919369f, 
    -0.15542069f, -0.30261940f, -0.23330937f, -0.11920103f, -0.04614433f, -0.07169221f, 0.09034813f, 0.10128617f, 
    0.09753914f, 0.18690203f, 0.04469042f, -0.00664571f, -0.01574105f, -0.16236676f, -0.11450435f, 0.01847475f, 
    0.06702565f, 0.09120253f, 0.12627737f, 0.03241584f, 0.11445948f, -0.09655825f, -0.34602955f, -0.26546332f, 
    -0.02528002f, 0.04390990f, -0.02980026f, 0.04574687f, -0.06363711f, -0.17189424f, 0.00395677f, 0.03417787f, 
    -0.00599880f, 0.09860583f, 0.07020619f, 0.07026229f, 0.07787150f, 0.09138980f, -0.21211816f, -0.14286129f, 
    0.01421059f, -0.69402856f, -0.01658746f, -0.22397363f, 0.38223749f, -0.12753569f, 0.10927953f, 0.05707194f, 
    0.04445093f, 0.01556236f, 0.02659759f, -0.08341893f, -0.03862153f, 0.08285947f, -0.16172823f, 0.02242287f, 
    0.04565405f, -0.04028278f, -0.13412832f, -0.16947569f, 0.22839184f, 0.04324685f, 0.09923922f, 0.12409391f, 
    0.04218729f, 0.03001951f, 0.04378157f, -0.07524960f, 0.06775914f, 0.04864914f, 0.04199392f, 0.00094082f, 
    0.10801841f, 0.00260557f, 0.14226806f, -0.06160391f, -0.00818673f, 0.10884569f, -0.11639310f, 0.13493364f, 
    0.08118496f, -0.57800245f, -0.68193114f, -0.27274597f, -0.21585396f, 0.04262285f, -0.12264303f, 0.07096808f, 
    0.03869105f, -0.04815178f, -0.01961532f, 0.01939805f, -0.01267536f, -0.03887645f, 0.04871926f, 0.06782047f, 
    0.04089230f, 0.07381587f, 0.10951990f, 0.11511458f, -0.00471146f, 0.16450231f, 0.08184575f, 0.08077709f, 
    -0.21905194f, -0.09323222f, 0.01105952f, -0.04347263f, 0.05550678f, 0.00077695f, 0.02469104f, 0.08978754f, 
    0.11071622f, 0.07680320f, 0.07972664f, 0.02615355f, -0.00899335f, 0.00711438f, 0.04702197f, 0.06199479f, 
    -0.02733870f, -0.01113794f, -0.31212604f, -0.28961217f, 0.14629766f, 0.14207627f, 0.14971410f, 0.18514703f, 
    0.08831920f, 0.11479072f, 0.13799930f, -0.06679125f, -0.06931786f, 0.00188182f, -0.06735753f, 0.06521833f, 
    0.01496572f, -0.02959975f, 0.00979659f, 0.03282587f, -0.02183711f, -0.09210262f, 0.23914643f, -0.10172297f, 
    -0.33606365f, 0.02600076f, -0.33278129f, -0.04813078f, -0.03738069f, -0.34437081f, -0.12972514f, 0.14961039f, 
    -0.03443655f, 0.12627578f, 0.02303047f, 0.10479384f, -0.03267159f, 0.07216419f, -0.05619435f, 0.11464318f, 
    0.07724738f, 0.22899546f, 0.37933820f, 0.51119918f, -0.38601020f, 0.02296001f, -0.21409316f, -0.43732354f, 
    -0.20020573f, -0.28251824f, 0.15651594f, -0.04758701f, 0.20753558f, 0.10080249f, 0.13166374f, 0.05994130f, 
    -0.01007777f, -0.04736274f, -0.03001426f, 0.01217681f, -0.24034548f, 0.14399399f, -0.61792988f, 0.15224540f, 
    -0.25058639f, 0.07088042f, -0.16190955f, 0.01702168f, -0.19002406f, -0.27013221f, 0.03724790f, -0.00725473f, 
    -0.00232195f, 0.03839678f, -0.02496024f, -0.12107603f, 0.08226939f, -0.06846561f, -0.05417706f, -0.00849089f, 
    0.13154763f, -0.09600529f, -0.37465873f, 0.00461750f, 0.12980339f, -0.25979915f, 0.11012144f, 0.21386047f, 
    0.09691349f, 0.18774837f, -0.00470143f, -0.03287501f, -0.12212203f, -0.04480959f, -0.03450263f, 0.04460150f, 
    0.09014351f, -0.01114060f, 0.06446236f, -0.11543929f, 0.03107696f, -0.14762102f, -0.16147707f, 0.21776272f, 
    -0.28822100f, -0.09106090f, -0.31759319f, -0.06443751f, 0.03159191f, 0.09545443f, 0.03051332f, 0.00214396f, 
    0.08214761f, 0.02961631f, 0.05800321f, -0.01356581f, 0.08770140f, 0.03925324f, 0.16152936f, 0.32401904f, 
    -0.41687426f, -0.52130866f, 0.29084691f, 0.19880375f, -0.72518432f, 0.08120513f, -0.25021714f, -0.01184232f, 
    0.12757702f, 0.32812122f, 0.01098411f, 0.04490396f, 0.10326957f, 0.02574231f, -0.03986471f, -0.04440683f, 
    0.02037472f, 0.07632516f, -0.02818383f, 0.08072040f, -0.57423007f, -0.20478186f, -0.30884176f, 0.44102123f, 
    -0.09454986f, -0.61126256f, 0.42596668f, -0.18166441f, -0.34247971f, 0.10867953f, 0.09922504f, -0.13801447f, 
    0.04059906f, -0.10679444f, -0.02160858f, 0.18676214f, -0.02744576f, -0.03428082f, -0.16850249f, -0.13536698f, 
    -0.70705795f, 0.03887427f, -0.91345191f, -0.21076535f, -0.04532620f, 0.20265003f, -0.37061766f, 0.13654670f, 
    -0.02328321f, 0.04430105f, 0.04177646f, 0.12433988f, -0.10794319f, 0.01866772f, 0.10779935f, -0.02354277f, 
    0.12531805f, 0.08870953f, -0.02513639f, 0.13635881f, 0.28116098f, -0.09793311f, 0.17954342f, -0.37622675f, 
    0.04060753f, -0.06367446f, -0.05740377f, -0.01745380f, 0.07657041f, 0.04374669f, 0.00547838f, -0.01613563f, 
    -0.00523423f, -0.05053821f, -0.16973011f, -0.06532342f, -0.07492094f, -0.36068901f, -0.24829151f, 0.13707732f, 
    -0.74802917f, -0.11811703f, -1.05341482f, 0.32917774f, 0.04252020f, -0.01021651f, 0.01803729f, 0.27498937f, 
    -0.09304906f, -0.28463936f, -0.00105200f, -0.05108528f, 0.00998579f, -0.03746364f, -0.01094656f, -0.11772766f, 
    0.07705382f, -0.06098048f, 0.15541764f, 0.15488769f, -0.18823963f, 0.13864814f, -0.49025649f, -0.06589023f, 
    -0.00660060f, -0.00555006f, 0.18341957f, 0.32681185f, 0.04054057f, 0.08589292f, 0.01793847f, -0.01277196f, 
    0.02821099f, 0.01859446f, -0.10643700f, -0.03587389f, -0.05982220f, 0.07485984f, 0.09592678f, 0.02070347f, 
    -0.10925836f, 0.18602489f, -0.00980575f, 0.66475928f, -0.56935418f, 0.04825183f, 0.02872414f, -0.23342475f, 
    -0.02924470f, -0.14407435f, 0.17289072f, -0.10631566f, 0.11153016f, 0.03606702f, 0.09886178f, 0.09695444f, 
    0.11465381f, 0.17486075f, 0.11362685f, 0.12791270f, -0.25261804f, -0.04118665f, 0.09809344f, 0.18783209f, 
    -0.36476532f, -0.04322243f, -0.04938879f, -0.30650339f, -0.02159067f, -0.12571561f, 0.02988218f, -0.05650457f, 
    0.05149382f, 0.11185975f, 0.01061868f, -0.00267326f, 0.06074984f, 0.01504256f, -0.02726692f, 0.00004858f, 
    0.03088498f, -0.40770534f, 0.00490440f, -0.07378879f, -0.13021626f, 0.07689628f, -0.01860224f, 0.11210166f, 
    -0.14585133f, 0.08127894f, 0.02863451f, -0.02118521f, 0.01368621f, -0.00755840f, -0.01959321f, 0.02055904f, 
    -0.05694508f, -0.01973166f, -0.10552636f, -0.02768742f, 0.14815228f, -0.06518616f, -0.03161429f, -0.18172820f, 
    -0.29702502f, -0.26561639f, 0.14983350f, -0.42630237f, 0.01612493f, -0.04718817f, 0.14062549f, -0.03438710f, 
    -0.07646199f, 0.15085435f, -0.03259092f, -0.04269564f, 0.04260381f, -0.06144492f, -0.17513257f, -0.00588398f, 
    0.35639763f, 0.18933921f, -0.28907773f, -0.11004984f, -0.18021119f, -0.13894442f, -0.14158741f, 0.10914450f, 
    0.10717837f, 0.34913021f, -0.04960197f, 0.11472519f, 0.03232548f, -0.07328128f, -0.05768071f, -0.01450701f, 
    0.00768932f, -0.03310516f, 0.01944443f, -0.13520823f, -0.02522091f, 0.19066440f, 0.19512431f, 0.11207987f, 
    0.21130152f, -0.14178121f, -0.04181261f, -0.06379198f, -0.20099631f, -0.10276767f, 0.14393321f, 0.04247634f, 
    0.05330794f, -0.07079378f, -0.13836946f, 0.17520601f, 0.09514239f, -0.08744264f, -0.07301567f, 0.00817156f, 
    -0.35576382f, 0.16850232f, 0.10162797f, 0.25754768f, 0.29501465f, -0.02698817f, 0.11594810f, -0.21444958f, 
    -0.10375219f, -0.07564173f, 0.09107383f, -0.02178250f, -0.02189379f, 0.00643930f, 0.08827059f, 0.15304060f, 
    -0.03399479f, -0.12974533f, -0.03955994f, -0.07190169f, 0.20301595f, -0.16997360f, -0.35265112f, -0.07241555f, 
    -0.00376889f, 0.00633211f, 0.07467079f, 0.23678127f, 0.08493861f, 0.13900954f, 0.00388246f, 0.02490975f, 
    -0.15294681f, 0.00663821f, -0.03629452f, 0.05416474f, 0.10143119f, 0.09233394f, 0.07437343f, -0.01202384f, 
    0.00718804f, -1.17038357f, -0.11238549f, -0.45553425f, -0.34803388f, -0.36911428f, -0.10227357f, -0.11836869f, 
    0.12939817f, 0.11675359f, -0.00015971f, 0.00968102f, -0.00517103f, 0.03840619f, -0.00444397f, 0.06593087f, 
    0.09792150f, 0.16633861f, -0.03169101f, 0.04797374f, -0.13316834f, 0.04490014f, -0.21731636f, 0.31453899f, 
    0.07022563f, 0.06950541f, -0.14593804f, 0.05451554f, -0.14461865f, -0.14747494f, 0.02695172f, 0.00468201f, 
    -0.01911644f, -0.06974460f, 0.00622152f, 0.07860933f, 0.12330071f, -0.04541966f, 0.08422820f, 0.16166757f, 
    -0.12685736f, -0.05399024f, -0.12583247f, -0.15346454f, 0.31480306f, -0.04460558f, 0.00791079f, 0.12920156f, 
    0.05686775f, -0.03889943f, -0.00229400f, -0.01826183f, 0.03264226f, -0.01975336f, -0.17400225f, 0.09917296f, 
    -0.07161396f, 0.04763687f, 0.02296497f, 0.05206587f, 0.09054775f, 0.15326184f, -0.50765842f, 0.17505828f, 
    -0.12099463f, 0.01065321f, 0.22377670f, 0.41150412f, -0.16150516f, 0.20665552f, -0.01724533f, -0.08248780f, 
    -0.12099427f, -0.08013712f, -0.14383848f, -0.03873090f, -0.08344100f, 0.01283833f, 0.02662781f, -0.02435067f, 
    -0.25776473f, -0.05319431f, -0.62329388f, 0.02583284f, -0.02995903f, 0.08606590f, 0.06814350f, 0.29884836f, 
    0.01328483f, -0.01053454f, -0.02703681f, -0.04447908f, 0.05047289f, 0.08124356f, -0.09560427f, -0.03357806f, 
    0.16693771f, -0.05171044f, 0.06280695f, 0.18090469f, 0.02567683f, 0.38532302f, -0.73575240f, 0.16203456f, 
    -0.12362693f, 0.03694772f, 0.17500870f, 0.30007321f, 0.04750510f, -0.04489041f, 0.06287730f, -0.01514461f, 
    -0.13812138f, -0.10956534f, -0.06730594f, 0.04858004f, -0.07787050f, -0.14863928f, -0.03265950f, -0.13971138f, 
    0.21572392f, 0.08608561f, 0.41290471f, 0.23368898f, -0.28780383f, 0.15750901f, -0.16102903f, -0.33767861f, 
    -0.24346812f, -0.12613983f, 0.07161046f, 0.10184859f, 0.11044666f, 0.11301407f, 0.09821828f, 0.01299334f, 
    -0.02252573f, -0.10144041f, -0.03518682f, -0.02656738f, -0.17942864f, -0.03196846f, 0.21721835f, 0.12915568f, 
    -0.39505276f, -0.01670585f, -0.10720052f, -0.09253339f, 0.00221733f, 0.27137697f, 0.03920274f, 0.00120509f, 
    0.02386140f, 0.05736543f, 0.06103498f, 0.02062515f, 0.04508659f, 0.01344263f, 0.13743584f, 0.06322915f, 
    -0.12886590f, -0.44149914f, 0.16495134f, 0.15313797f, -0.65839428f, -0.02505883f, -0.23358510f, -0.01377453f, 
    0.11516036f, -0.14199384f, -0.10020876f, 0.04487692f, 0.02515162f, -0.04626966f, 0.12513743f, 0.15435041f, 
    0.02284153f, 0.06239524f, 0.09311995f, 0.15384029f, 0.19604768f, -0.35251486f, 0.01072642f, -0.15719579f, 
    0.17657790f, -0.07257088f, 0.09259071f, -0.09423564f, 0.07381435f, 0.00709499f, 0.12844479f, -0.01972653f, 
    -0.01587076f, -0.11289628f, -0.10577053f, -0.01887517f, 0.02017963f, -0.10304502f, -0.12811692f, 0.07102725f, 
    -0.32225278f, -0.21582818f, -0.14247905f, 0.06971969f, -0.34860131f, -0.20290616f, -0.17026475f, 0.23831125f, 
    0.15303716f, 0.21427189f, -0.03518496f, 0.02500765f, 0.01263509f, -0.09276435f, -0.01082259f, 0.00079189f, 
    -0.03167911f, 0.08683620f, -0.05097919f, -0.34785512f, -0.30748269f, -0.06333487f, 0.05370623f, 0.17220326f, 
    0.18827090f, -0.03374333f, 0.04056812f, -0.02731301f, 0.07172114f, 0.01279289f, -0.02928194f, 0.04936662f, 
    0.01225864f, -0.01355170f, -0.05417599f, 0.13224310f, 0.07486679f, -0.02316459f, 0.02026162f, 0.01559580f, 
    0.03852100f, -0.10972840f, 0.49848884f, 0.17917408f, 0.08695693f, -0.02350959f, -0.10568535f, 0.06357273f, 
    -0.00243155f, -0.08310563f, -0.17215355f, 0.05505236f, 0.14553703f, 0.00609629f, 0.03263438f, -0.15443633f, 
    0.15035950f, 0.10172655f, 0.06418732f, -0.07868937f, -0.42070088f, 0.19087036f, 0.01577452f, 0.13244198f, 
    -0.08803246f, 0.04752373f, -0.08258564f, -0.08397296f, 0.16628833f, 0.03992820f, 0.13575955f, -0.05440722f, 
    0.04926150f, -0.08197788f, 0.00956094f, -0.03922174f, -0.14422700f, -0.05961033f, 0.20364654f, -0.09069151f, 
    0.48169714f, -0.01025016f, 0.31861517f, -0.07084248f, -0.01188387f, 0.00539594f, -0.05074229f, -0.12576343f, 
    0.00908006f, 0.15625015f, -0.17306910f, 0.13365041f, -0.13939215f, -0.18370573f, -0.20949291f, -0.01561929f, 
    -0.05754452f, 0.02144489f, 0.08179190f, 0.09814462f, -0.14855674f, -0.23765485f, 0.28330910f, 0.27954200f, 
    -0.00348701f, -0.07151704f, -0.03759639f, 0.03610709f, 0.24408579f, 0.00160281f, 0.09787352f, -0.04226988f, 
    -0.01317433f, 0.11864606f, -0.08245127f, 0.22230145f, 0.06791297f, 0.11954955f, 0.21972629f, 0.01063777f, 
    -0.04798590f, -0.25795558f, -0.06413876f, 0.23038141f, 0.04053283f, 0.10199724f, -0.12394183f, 0.03835131f, 
    -0.07700910f, 0.06377587f, -0.13197270f, 0.01994550f, 0.07096635f, -0.01468895f, 0.01509931f, -0.04685416f, 
    -0.10999997f, 0.09969621f, 0.00042368f, 0.13832864f, -0.42126876f, 0.06311481f, -0.47323915f, 0.14737000f, 
    -0.03060845f, -0.06097262f, 0.08101361f, 0.00246159f, -0.09788886f, -0.07498314f, -0.01812925f, 0.07806974f, 
    -0.02066596f, 0.01622201f, -0.03110158f, 0.07440180f, -0.05934291f, -0.06270469f, -0.24097669f, -0.18851499f, 
    -0.48443016f, 0.07224506f, -0.73483080f, -0.06195724f, 0.04100512f, -0.07188024f, -0.13457496f, -0.31776875f, 
    -0.15578631f, -0.06803183f, -0.02202611f, 0.15008371f, 0.02446170f, 0.00861435f, 0.03329385f, 0.04861529f, 
    -0.00720634f, -0.07642907f, -0.01716526f, -0.10960212f, 0.62728113f, -0.28818440f, 0.22654884f, 0.27222705f, 
    0.40437344f, 0.33560109f, -0.04104149f, 0.22300279f, -0.20241916f, 0.10684624f, -0.06560977f, 0.09061287f, 
    -0.06657116f, -0.06056440f, 0.02939238f, -0.14353582f, 0.04378967f, 0.03421128f, 0.12813608f, 0.09851251f, 
    -0.21082921f, 0.02041560f, -0.10986307f, 0.15613808f, 0.14302863f, -0.13367715f, 0.01543527f, 0.13874887f, 
    -0.07781164f, -0.21025446f, 0.00551619f, 0.03994285f, -0.01051355f, 0.10095834f, 0.02371441f, 0.03902953f, 
    -0.07430693f, -0.02146592f, -0.16998145f, -0.14993431f, -0.32864720f, 0.11191468f, 0.19418305f, 0.28059030f, 
    -0.19215977f, -0.01130506f, -0.05354315f, 0.02087848f, 0.01453449f, 0.01960029f, -0.26582807f, 0.01906098f, 
    0.20698804f, -0.00557958f, -0.05298937f, 0.07989416f, -0.00014965f, 0.24280006f, 0.23351879f, 0.41347995f, 
    -0.03540033f, -0.43796366f, 0.22263549f, -0.29631710f, 0.05839312f, -0.10676850f, -0.05249909f, 0.05822859f, 
    0.12426218f, -0.15828095f, -0.19716072f, 0.01890836f, 0.00795731f, 0.08497181f, 0.08929867f, 0.19996698f, 
    -0.13231087f, 0.11482528f, -0.04782151f, -0.19592731f, -0.08841114f, -0.55926561f, -0.49860787f, -0.13038063f, 
    -0.30951554f, -0.31973216f, -0.16687602f, 0.05194319f, -0.17330422f, -0.11585939f, -0.16501990f, 0.03266665f, 
    -0.15195860f, 0.00371381f, -0.01326614f, 0.15876970f, -0.08755100f, -0.03693176f, -0.05349959f, -0.17556943f, 
    0.09592781f, -0.00811497f, -0.01077773f, -0.03350860f, -0.10882995f, 0.05248171f, 0.08813924f, 0.07918902f, 
    0.06225283f, 0.10779895f, -0.08341273f, 0.06925769f, -0.14358902f, -0.26418212f, -0.24885148f, 0.04680037f, 
    -0.22556582f, 0.01257092f, -0.06901967f, -0.11581539f, -0.26760900f, 0.11101142f, 0.11985699f, 0.08506507f, 
    0.11660893f, -0.01301317f, 0.07804237f, -0.17419480f, -0.00486040f, 0.06336157f, -0.06645720f, 0.12760538f, 
    -0.00589479f, 0.06126996f, 0.00277083f, 0.07830179f, 0.13463905f, -0.02185274f, 0.09096539f, 0.10005148f, 
    -0.64703381f, 0.30946732f, -0.03656355f, 0.23766354f, -0.03940489f, 0.08376347f, -0.20979559f, 0.03367977f, 
    0.49023980f, 0.18171932f, -0.10878278f, 0.08788469f, -0.00374967f, 0.09495395f, -0.00273205f, -0.02070773f, 
    0.00848991f, -0.14554621f, 0.28611574f, 0.27960372f, -0.15686689f, 0.30149752f, 0.29707140f, 0.13156509f, 
    -0.00948883f, 0.19105101f, -0.03545796f, -0.12415445f, 0.26614133f, 0.00030181f, -0.27288255f, 0.01840751f, 
    0.12619823f, 0.05897686f, -0.00282396f, -0.10362964f, 0.09215093f, 0.09921687f, 0.22567515f, 0.12269162f, 
    -0.38578656f, -0.19247933f, -0.28801897f, -0.07887482f, -0.09085331f, 0.12496619f, -0.17737912f, 0.28410912f, 
    -0.08974136f, -0.14145865f, -0.04810866f, 0.00590733f, 0.10515389f, 0.09914746f, -0.05657743f, 0.04187564f, 
    -0.06555452f, 0.05475273f, -0.04395568f, -0.03164190f, 0.30824509f, -0.37969187f, 0.35036209f, -0.08714105f, 
    -0.30119210f, 0.06615266f, -0.00025147f, 0.15591410f, 0.09397399f, -0.08320016f, 0.02149475f, 0.10705008f, 
    -0.12184037f, 0.01076258f, -0.07120129f, -0.06672696f, 0.13501789f, 0.14449032f, 0.05547396f, -0.03988854f, 
    0.61616540f, -0.16306435f, 0.23072365f, -0.16417985f, -0.22724296f, 0.06187236f, -0.00375691f, 0.01480263f, 
    0.11488638f, 0.04509249f, -0.06346752f, 0.21311079f, -0.01019178f, -0.07272004f, -0.01474144f, -0.03697214f, 
    0.09772892f, 0.03712350f, 0.17165911f, 0.05110710f, 0.01743310f, -0.03811540f, -0.25612220f, 0.32867932f, 
    0.08767604f, 0.03174817f, -0.11077943f, 0.00738172f, -0.09669828f, 0.02676931f, -0.03367708f, 0.03094819f, 
    -0.06789555f, -0.00702456f, 0.10177977f, 0.13346942f, -0.15441577f, 0.02809271f, -0.01109222f, 0.06328451f, 
    -0.40894186f, 0.46662062f, -0.84473860f, 0.36560461f, 0.27126253f, 0.08340381f, -0.02961041f, -0.00217453f, 
    0.15412103f, 0.09416462f, -0.05744697f, 0.05773976f, -0.16586062f, -0.09259099f, 0.02531069f, -0.07910652f, 
    -0.01865238f, -0.72386020f, 0.03104606f, -0.01387292f, 0.38098550f, -0.39593714f, 0.18322806f, -0.02652477f, 
    -0.00151801f, -0.09479018f, 0.04289702f, 0.19448152f, -0.01171088f, -0.16248371f, 0.16358787f, -0.01704974f, 
    -0.23262271f, 0.11470445f, -0.09189329f, -0.07081258f, -0.10284833f, 0.04730559f, -0.28857300f, -0.26818183f, 
    0.06155653f, -0.43379501f, -0.51090109f, -0.41931444f, -0.83078951f, -0.01766807f, -0.19916314f, -0.26776490f, 
    -0.02160726f, -0.17043272f, -0.00477512f, 0.17269383f, 0.00486928f, -0.02198717f, -0.11042815f, 0.10622335f, 
    0.11028712f, 0.01500326f, -0.03185143f, -0.19084029f, -0.14563614f, -0.58716196f, 0.04020233f, 0.16599330f, 
    0.07797370f, -0.15252705f, -0.17635277f, 0.25507528f, -0.38198820f, -0.04957766f, -0.05260655f, 0.09519972f, 
    -0.06082745f, -0.01067302f, 0.05640301f, -0.03395325f, -0.28648403f, -0.11755174f, -0.04699297f, -0.02949427f, 
    -0.18433051f, -0.32233644f, -0.13802321f, -0.04895575f, -0.06217720f, -0.13249765f, -0.14182612f, -0.16653185f, 
    0.00899018f, -0.02954139f, -0.18197826f, -0.02603414f, -0.17046542f, 0.03127110f, 0.04314083f, 0.14389299f, 
    -0.20489618f, -0.03650440f, 0.00712504f, 0.03066221f, -0.44554114f, -0.52744228f, -0.23045759f, -0.14925186f, 
    -0.01084831f, 0.00807434f, -0.07317074f, 0.27701849f, -0.14578816f, 0.00386629f, -0.15561950f, 0.04811438f, 
    0.01110885f, 0.01814045f, 0.00953871f, 0.15399738f, -0.04399796f, 0.11313213f, 0.15480191f, 0.20314826f, 
    0.08557771f, -0.07760295f, -0.03837744f, -0.08051206f, -0.04218590f, -0.01636753f, 0.02877455f, -0.17287542f, 
    0.04531064f, 0.08391851f, -0.06474919f, 0.04405921f, -0.06724534f, -0.10181841f, -0.20836745f, 0.00075919f, 
    0.04157481f, -0.04637226f, 0.13006525f, 0.15559390f, -0.27198645f, 0.06040723f, -0.41127023f, 0.01122296f, 
    0.11011937f, 0.05664989f, -0.00058339f, -0.01275511f, -0.12982233f, 0.05912891f, -0.07449728f, 0.00538151f, 
    -0.09877846f, 0.03864887f, 0.03728938f, 0.05569825f, -0.13836202f, -0.08239426f, -0.09073711f, -0.02831429f, 
    -0.16706556f, 0.19724986f, -0.10499869f, 0.13806903f, -0.10793469f, 0.00861284f, 0.04375369f, 0.02193519f, 
    0.00088441f, -0.06926173f, 0.05873950f, -0.00128835f, -0.12770748f, -0.12735900f, -0.09479537f, -0.05023358f, 
    -0.21363151f, 0.01418091f, -0.21832640f, -0.14023255f, -0.04338082f, 0.27454346f, 0.30826992f, 0.33676243f, 
    -0.02081436f, 0.02139720f, -0.03409389f, 0.09953271f, 0.24184239f, 0.17850420f, -0.18326198f, 0.03830969f, 
    -0.00951154f, 0.03650728f, 0.01260401f, -0.03761576f, 0.05909798f, 0.18973438f, 0.04890382f, 0.06380842f, 
    -0.38632199f, 0.08961945f, 0.12911534f, -0.04648262f, 0.29594085f, -0.14608698f, -0.04601375f, -0.08702939f, 
    -0.11277862f, -0.05725152f, -0.09390289f, 0.13402219f, 0.03562410f, 0.07669942f, -0.01268880f, 0.11844724f, 
    0.04838149f, -0.15636517f, 0.15307006f, 0.09420632f, 0.30654991f, -0.32761377f, 0.44209421f, -0.09428862f, 
    -0.15984572f, -0.00817283f, -0.02771658f, 0.01670852f, 0.05400997f, -0.14731950f, 0.03799842f, 0.03522156f, 
    -0.17092533f, 0.02828417f, 0.08347385f, -0.03038349f, 0.03576082f, 0.18060942f, -0.11925512f, -0.06430375f, 
    0.20636597f, 0.07069080f, -0.03673772f, 0.21373640f, 0.05793705f, -0.18469711f, 0.13750088f, -0.05598601f, 
    0.06615242f, 0.07091965f, -0.04411288f, 0.13023771f, -0.05161407f, 0.00843466f, -0.01301496f, -0.02887130f, 
    0.04622400f, 0.08338596f, -0.06521074f, 0.11547708f, -0.46124637f, -0.24768293f, -0.13619819f, 0.08337601f, 
    -0.50966251f, -0.00506545f, 0.18606734f, -0.09321029f, 0.20115364f, -0.00529590f, -0.28406021f, -0.10502627f, 
    0.09740335f, 0.08425070f, 0.09975152f, 0.11406199f, -0.07049030f, 0.03540481f, -0.12427951f, 0.00975028f, 
    -0.45240217f, -0.28208339f, 0.08473959f, -0.10682106f, -0.37624255f, 0.05577217f, 0.08679204f, -0.04659765f, 
    -0.09210107f, 0.21050932f, -0.05128606f, -0.05965644f, 0.06558625f, -0.06399500f, -0.05409341f, -0.06961202f, 
    -0.01196898f, 0.01584427f, 0.05080985f, 0.05939024f, 0.16441017f, -0.14174902f, 0.45602521f, -0.22230409f, 
    0.11290762f, 0.23695335f, 0.21272975f, 0.05071278f, 0.08683133f, -0.20369634f, 0.06186292f, 0.05881011f, 
    0.22199740f, -0.00750908f, 0.08803016f, 0.04044382f, 0.02856077f, -0.06373933f, -0.18240397f, -0.08016200f, 
    0.20074746f, 0.08531025f, 0.25060201f, 0.31661874f, -0.09491488f, -0.21526749f, 0.03043817f, -0.07173239f, 
    0.02593504f, 0.02466304f, -0.16098398f, -0.01352707f, 0.02063051f, 0.13946711f, 0.01269695f, -0.01622647f, 
    0.07054999f, 0.12683259f, -0.02487003f, 0.00992235f, 0.11106263f, -0.43762326f, -0.01848086f, -0.28532815f, 
    0.10997759f, 0.05134252f, -0.27471569f, 0.05378327f, -0.04917696f, -0.13503991f, 0.04208174f, -0.03332020f, 
    0.10438141f, -0.01073305f, -0.06035962f, 0.15347348f, -0.06898107f, 0.06564175f, 0.06708693f, 0.02306003f, 
    0.10836668f, -0.24519634f, -0.22081645f, -0.37370196f, -0.22896478f, -0.10434633f, -0.13999991f, 0.05553474f, 
    -0.08087146f, 0.01329896f, 0.07265138f, 0.08872489f, 0.13526581f, -0.11110488f, -0.13626169f, 0.02004948f, 
    -0.00303009f, 0.01005598f, 0.04326960f, 0.04284471f, -0.72223771f, 0.03148833f, 0.05636264f, 0.28069738f, 
    0.18313581f, 0.09905162f, 0.10849091f, 0.19501330f, 0.01515281f, 0.20185429f, -0.21974254f, -0.04412433f, 
    0.05471059f, 0.02852413f, -0.20280506f, 0.11718379f, -0.00163618f, -0.09582305f, 0.16538419f, -0.13491565f, 
    0.78186852f, -0.78216571f, 0.49135661f, -0.25310877f, 0.10548594f, -0.04798714f, 0.16556150f, -0.29614499f, 
    0.24543218f, -0.21400164f, -0.15684955f, -0.00213774f, -0.05149947f, -0.00676753f, 0.03131709f, 0.08898243f, 
    0.15325128f, 0.08301942f, 0.21806931f, -0.09502998f, -0.23718418f, 0.18863781f, -0.30509412f, 0.37802160f, 
    0.06163509f, -0.19001667f, 0.12663192f, -0.05479506f, 0.10460736f, -0.05803630f, -0.13157073f, -0.01209485f, 
    -0.08562342f, -0.13033661f, 0.12541413f, -0.00715392f, -0.09096583f, -0.07478999f, -0.10918016f, -0.18077268f, 
    0.46489283f, -0.40506405f, 0.45465076f, -0.25730693f, 0.33458462f, -0.04538165f, 0.13764805f, -0.16627903f, 
    0.15067491f, -0.11514101f, -0.10245819f, -0.07411873f, -0.03004317f, -0.06465038f, -0.09478625f, 0.04496308f, 
    0.04326284f, 0.02956495f, -0.12599085f, 0.00780274f, 0.34999272f, 0.04002620f, 0.39787635f, -0.17129594f, 
    -0.33401376f, -0.05042580f, -0.04764431f, -0.18282987f, 0.15094419f, -0.01827340f, -0.08289682f, -0.03685389f, 
    0.01166262f, -0.05576395f, -0.04243718f, -0.10558587f, 0.06852566f, -0.08281312f, 0.14023681f, 0.06911463f, 
    -0.12246675f, -0.29767618f, 0.05996827f, -0.44759110f, -0.23005581f, 0.21670420f, 0.14829637f, 0.01989561f, 
    -0.19390315f, 0.07269781f, 0.01366743f, -0.03988907f, 0.21415758f, 0.32569721f, 0.05667594f, -0.06114759f, 
    0.18152694f, 0.11596584f, 0.16726184f, 0.16576210f, -0.10534139f, -0.03535322f, -0.22159043f, 0.50269949f, 
    -0.13177106f, 0.00145296f, -0.22048540f, -0.09389983f, -0.12278710f, 0.05158955f, -0.02468822f, -0.02955940f, 
    -0.00517377f, -0.05841027f, -0.07147210f, 0.04922195f, -0.07344081f, 0.06538188f, -0.11777268f, 0.01919497f, 
    -0.27522802f, 0.09042277f, 0.08237801f, 0.33590779f, -0.23978834f, -0.04218940f, -0.41940543f, 0.22239566f, 
    0.09978714f, -0.12874912f, -0.07287382f, 0.12214565f, -0.02508868f, 0.10280620f, 0.08001032f, 0.17724961f, 
    -0.10614863f, 0.04046049f, 0.18022943f, -0.11386393f, -0.60039383f, 0.40446153f, -0.28728297f, 0.64052272f, 
    -0.13589433f, 0.18862277f, -0.01777789f, 0.06297586f, 0.02754991f, 0.08998981f, -0.09059861f, -0.23821731f, 
    -0.17150541f, -0.01574930f, -0.10683274f, 0.10139857f, -0.13432786f, 0.01361360f, 0.00482167f, -0.00509677f, 
    0.05022202f, -0.40170166f, 0.00399522f, 0.19305544f, 0.10289982f, -0.11813187f, -0.19671166f, -0.16594242f, 
    -0.02542594f, -0.11495042f, 0.06564152f, 0.01853097f, 0.01314373f, 0.08759385f, 0.09433778f, -0.01109727f, 
    -0.01532723f, 0.06117474f, 0.18900754f, 0.07221479f, -0.33593625f, -0.15494198f, -0.22121237f, 0.06481016f, 
    0.16304702f, 0.01850747f, 0.20924281f, -0.06364314f, 0.10541654f, 0.14100435f, -0.11002125f, 0.03989796f, 
    0.02697070f, 0.02514659f, 0.03165470f, 0.01008454f, -0.05678124f, -0.07535815f, -0.00040113f, -0.07241424f, 
    -0.36886421f, -0.06835196f, -0.28825727f, -0.13967822f, 0.15130697f, 0.03234618f, 0.21702816f, 0.08084554f, 
    -0.01756904f, 0.17867681f, -0.08969294f, 0.17188434f, -0.02764768f, 0.08828422f, 0.06362409f, 0.09650904f, 
    -0.03143715f, -0.09057497f, -0.11095394f, 0.04064076f, 0.19990563f, 0.02986096f, 0.26531759f, 0.16221292f, 
    -0.30776587f, -0.12877475f, -0.14610536f, 0.00414489f, 0.04249800f, -0.07626495f, -0.00777505f, -0.12528011f, 
    0.01738632f, 0.00833423f, -0.09881279f, -0.03142047f, 0.04794094f, 0.00603087f, 0.03419230f, -0.00518749f, 
    -1.10195661f, -0.24326970f, -0.22554478f, 0.50566870f, -0.30305424f, 0.05131598f, 0.16446719f, 0.10921032f, 
    -0.00035187f, 0.10651362f, -0.11649851f, -0.00870214f, 0.02778225f, 0.05276234f, -0.01770445f, 0.21258320f, 
    0.09746877f, 0.39132908f, 0.06396498f, -0.03347816f, 0.02496436f, -0.11380158f, -0.24532272f, 0.13552336f, 
    0.29822975f, -0.00143164f, 0.26899916f, -0.08071841f, -0.02407315f, -0.19340687f, -0.10484849f, 0.03289364f, 
    -0.12109667f, 0.04266356f, -0.05657095f, -0.10139277f, -0.09870380f, 0.09371925f, 0.16390605f, 0.08124225f, 
    -0.02466146f, -0.16091377f, -0.11431354f, -0.08063450f, -0.01171755f, -0.05937318f, 0.08714947f, -0.03235720f, 
    0.11335884f, 0.02530067f, -0.30911213f, 0.00300953f, -0.00679535f, -0.01088858f, -0.14249289f, 0.05838933f, 
    0.07138834f, 0.01964545f, -0.05928091f, -0.15723701f, 0.50710779f, 0.14119184f, 0.51523262f, -0.04993284f, 
    -0.24338330f, -0.06812662f, 0.06735767f, 0.02375619f, 0.12244625f, 0.01066511f, -0.10755572f, 0.07192371f, 
    -0.12111720f, 0.03099154f, -0.08295023f, -0.04906663f, 0.11189952f, 0.07670900f, 0.05420255f, 0.14661705f, 
    0.46649125f, -0.27547336f, 0.27081037f, -0.27376065f, -0.20834891f, -0.07343341f, -0.10068145f, -0.04775213f, 
    0.09061158f, -0.00223618f, -0.05033832f, 0.03806152f, 0.09661942f, -0.19619097f, -0.10521260f, 0.05159374f, 
    0.08530159f, -0.00195917f, -0.02425435f, 0.01059730f, 0.37559903f, 0.35852697f, 0.43227714f, -0.05342527f, 
    -0.16180910f, 0.00374672f, 0.00570088f, 0.05287025f, -0.08191358f, -0.15673941f, -0.14937603f, 0.07576933f, 
    0.02912975f, -0.02885936f, -0.02790841f, -0.03890458f, -0.13869566f, -0.27797070f, -0.19208378f, 0.12167861f, 
    -0.43654805f, -0.15447733f, -0.36986315f, 0.21680489f, -0.10593504f, -0.11554240f, -0.02609181f, -0.08515777f, 
    -0.05834023f, 0.10139331f, -0.02680611f, -0.05408855f, -0.03922755f, -0.12680447f, -0.06549773f, 0.03605386f, 
    -0.08560654f, -0.16939580f, -0.16639452f, -0.10745437f, 0.10895253f, -0.24551502f, -0.13756715f, 0.07316990f, 
    0.12251895f, -0.12242743f, -0.21755098f, 0.01636418f, -0.13483685f, 0.10815701f, 0.00268225f, -0.00639584f, 
    0.17230156f, -0.05021821f, -0.06893702f, 0.06600222f, -0.15170391f, 0.06388573f, 0.09758343f, 0.04906043f, 
    -0.25877851f, -0.14712022f, -0.26684195f, 0.29384506f, -0.41349718f, 0.10525388f, 0.12850955f, -0.09748212f, 
    0.01124223f, -0.08008686f, -0.02785047f, -0.01696450f, 0.12314879f, 0.13954595f, 0.01502883f, 0.09407146f, 
    0.00529486f, 0.04860106f, 0.10705297f, 0.19215399f, -0.35248858f, 0.12948766f, -0.08995183f, 0.26473546f, 
    -0.12569286f, 0.01751431f, -0.01394320f, 0.22407137f, 0.01728427f, -0.03253868f, -0.07522192f, -0.09320927f, 
    0.00441705f, 0.04019635f, -0.01258233f, 0.17924747f, -0.13776168f, 0.02866522f, 0.06617831f, -0.07986510f, 
    0.02551880f, -0.49421215f, -0.09263857f, -0.17365438f, 0.05735183f, 0.02854313f, -0.38415328f, -0.10697100f, 
    -0.12163883f, -0.01209542f, -0.00664686f, -0.10041498f, -0.02420340f, 0.01250045f, -0.09161346f, 0.07969514f, 
    -0.05560003f, 0.02831605f, -0.10517053f, -0.13203302f, -0.14562047f, -0.12769522f, -0.23970965f, 0.09896145f, 
    0.26222157f, 0.11428573f, 0.08136440f, 0.09012415f, -0.03405771f, -0.00594755f, -0.11544915f, 0.05109127f, 
    -0.02183887f, -0.02922594f, -0.03233690f, -0.04062922f, 0.07180967f, 0.01249039f, 0.20630106f, -0.09744219f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14809968f, 0.14290951f, 0.03833256f, -0.12712856f, -0.03667782f, -0.00433358f, 0.04871713f, -0.16496062f, 
    0.01108897f, 0.02582628f, 0.05787997f, 0.01239396f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
