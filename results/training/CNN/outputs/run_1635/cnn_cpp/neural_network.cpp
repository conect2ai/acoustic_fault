#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.33406648f, -0.56505424f, 0.32856679f, 0.17191972f, -1.04643917f, -0.59779447f, 0.32557577f, 0.18963879f, 
    0.34220618f, 0.20480707f, -0.23770338f, 0.37821954f, -0.52952492f, -0.42731678f, 0.58323294f, 0.06944346f, 
    0.10390289f, 0.37602800f, 0.80251676f, 0.16987920f, 0.05967235f, -0.10048793f, -0.05625087f, 0.17335406f, 
    0.57823521f, -0.44135439f, -0.41641581f, -0.61939585f, 0.27189568f, 0.08104134f, 0.09643577f, -0.23623103f, 
    -0.78434676f, -0.37839282f, 0.13786171f, -0.54472977f, 0.88487566f, -0.87529236f, 0.06943081f, 0.31351265f, 
    -0.28628808f, 0.06097169f, -0.24820559f, 0.44376782f, -0.09151334f, -1.23529267f, -0.03530560f, 0.75811040f, 
    -0.12707590f, 0.05031899f, 0.30625898f, -0.24005075f, -0.30142584f, -0.08006693f, -0.77509636f, -0.26411796f, 
    -0.74179649f, 0.04417823f, 0.61432308f, -0.14247206f, 0.24294594f, 0.39352062f, 0.44878325f, 0.07935241f, 
    -0.04919220f, -0.16735670f, 0.41366935f, 0.43480340f, 0.72599787f, -0.44137651f, -0.13003048f, -0.51180351f, 
    0.13396928f, 0.86018288f, 0.02010455f, -0.67967451f, 0.07996725f, 0.13198529f, -0.21837179f, 0.23197800f, 
    0.13217941f, -0.03521868f, 0.86784059f, 0.21874033f, -0.36754966f, -0.58408445f, -0.04424039f, -0.24252053f, 
    -0.27326050f, -0.18254964f, 0.46916077f, -0.19421148f, -0.23987760f, 0.12098742f, 0.11453995f, 0.06125164f, 
    -0.48043346f, -0.26906186f, 0.60763109f, 0.62206304f, 0.83097458f, -0.81221986f, -0.03228887f, -0.25068787f, 
    -0.05882872f, 0.04097530f, 0.13040680f, 0.10175429f, 1.12803209f, -1.06838167f, -0.86143363f, 0.37755764f, 
    0.29425696f, 0.16948773f, 0.17990448f, 0.05372920f, -0.17158653f, 0.28873825f, 0.50009412f, 0.42488608f, 
    -0.05692010f, 0.43827409f, -0.08334605f, 0.17463568f, 0.46368983f, -0.24281803f, 0.40929720f, -0.43767244f, 
    -0.09634510f, 0.14108150f, 0.48428077f, 0.23757689f, 0.24801937f, 0.27288285f, 0.00937446f, -0.04156539f, 
    -0.65201288f, -0.46852908f, 0.13205285f, 0.29501858f, -0.37261182f, -0.35867497f, -0.26617166f, -0.19339484f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10889951f, -0.01328755f, -0.20327534f, -0.34010276f, -0.02918278f, 0.10591863f, -0.04586146f, -0.11166450f, 
    0.22587503f, 0.08215887f, -0.05712791f, 0.23352498f, 0.14358710f, -0.15340970f, -0.00216871f, 0.14463839f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03599594f, 0.00359510f, 0.03442527f, 0.01404856f, -0.04814089f, -0.03515019f, -0.02035805f, -0.04932701f, 
    -0.05550646f, 0.05142614f, -0.03536836f, -0.02435373f, -0.01681559f, -0.02889065f, -0.05144951f, 0.03751616f, 
    -0.01356170f, -0.03569254f, -0.02027065f, -0.05377520f, 0.01697074f, -0.02357640f, -0.01996792f, -0.01426634f, 
    0.03138043f, -0.02794327f, -0.01994614f, -0.01675734f, 0.02449241f, -0.04307211f, 0.01285715f, 0.02297520f, 
    0.04571144f, 0.02491802f, -0.02395350f, 0.04735058f, 0.01335958f, 0.01490881f, 0.00035616f, -0.02090850f, 
    -0.00841757f, 0.04594766f, -0.00040744f, 0.00717305f, 0.05118470f, 0.03380723f, -0.03674769f, -0.04244729f, 
    -0.03707042f, -0.00174723f, 0.03709611f, -0.04309596f, 0.00040812f, 0.01150712f, -0.03087245f, 0.03727754f, 
    0.02172366f, -0.02054029f, 0.04054542f, 0.01511074f, -0.02537484f, 0.00822395f, 0.01434594f, -0.04287755f, 
    -0.01400490f, -0.03136666f, -0.03666968f, 0.01430241f, -0.02683610f, -0.05411243f, 0.01185944f, 0.00084718f, 
    -0.03397423f, 0.03338008f, 0.02249384f, -0.04506522f, 0.01501451f, -0.04182355f, 0.00410427f, -0.00931108f, 
    -0.00303135f, -0.00434644f, 0.01126784f, 0.01108446f, 0.03713446f, -0.03660035f, 0.00072961f, -0.01849961f, 
    0.02016877f, 0.01846766f, 0.05563153f, -0.00362752f, 0.02443176f, 0.00107245f, -0.04570537f, -0.02248246f, 
    0.00165982f, -0.02399771f, 0.05118804f, 0.00512348f, -0.00650110f, 0.01837472f, 0.05166968f, 0.01533838f, 
    -0.05104643f, -0.03662957f, -0.04474408f, -0.04875242f, -0.05321620f, -0.00154262f, 0.01840240f, 0.05239040f, 
    -0.03715517f, 0.01362005f, 0.04997430f, -0.00643155f, -0.03297353f, -0.03685774f, 0.01563771f, 0.04291338f, 
    -0.04181111f, 0.00599258f, -0.03086119f, -0.00179722f, -0.02785133f, -0.03940817f, 0.05394375f, -0.03034794f, 
    0.00532917f, 0.00140864f, -0.00460707f, 0.02673891f, -0.03195419f, 0.04019776f, 0.01703058f, 0.02416553f, 
    -0.04843980f, -0.05154233f, -0.00121990f, 0.04101315f, -0.02775831f, -0.04446697f, -0.04637222f, -0.01741692f, 
    -0.04187071f, -0.02093606f, 0.01326226f, 0.00185122f, 0.02783000f, 0.03698997f, -0.04377855f, 0.02754287f, 
    -0.03513779f, -0.03929781f, 0.02796264f, 0.00064422f, -0.01971169f, -0.02576184f, 0.05062579f, -0.02405576f, 
    0.01431574f, 0.00224631f, -0.03653620f, 0.00027277f, -0.00304797f, -0.03256730f, -0.00680207f, -0.01667758f, 
    0.04196561f, -0.00764861f, 0.05282195f, 0.02394545f, -0.02676167f, -0.05332895f, 0.00379690f, -0.00703639f, 
    -0.01405344f, -0.00450345f, 0.05154907f, -0.03477456f, 0.03334343f, 0.02290637f, -0.00483145f, -0.02171182f, 
    0.02231949f, -0.02976619f, 0.01461124f, -0.04330424f, -0.03415380f, -0.02279135f, 0.02488670f, 0.01318505f, 
    -0.01275357f, 0.04363439f, 0.03467879f, -0.04716484f, -0.01361953f, 0.03624801f, 0.03647825f, -0.00560464f, 
    -0.00964462f, -0.04542751f, 0.01663994f, -0.03945599f, 0.01238635f, -0.04326481f, 0.02517611f, 0.00442590f, 
    0.04983361f, -0.00517804f, 0.04931639f, -0.03170210f, -0.00682205f, -0.04052753f, -0.04874194f, -0.04913716f, 
    0.04050728f, 0.00715667f, -0.00764298f, 0.03833412f, -0.05525849f, -0.03954411f, 0.04337635f, -0.02219538f, 
    -0.01727954f, 0.04386109f, -0.04413272f, -0.01730711f, -0.00869734f, -0.04670408f, 0.04112938f, 0.02817570f, 
    0.02261652f, 0.05573840f, -0.02566247f, -0.04693248f, -0.03264522f, -0.04671521f, 0.01046611f, 0.03810987f, 
    0.01327013f, -0.04461414f, -0.00763759f, -0.03330484f, -0.00877411f, 0.00033716f, 0.03293720f, -0.03303224f, 
    -0.04682971f, -0.04379635f, -0.03270701f, -0.02497751f, 0.03275441f, -0.01765050f, -0.00272649f, 0.04144822f, 
    -0.01306955f, 0.02092578f, 0.03519716f, 0.00501985f, 0.03981970f, 0.04047382f, -0.02151706f, -0.05548558f, 
    -0.03608002f, -0.02446996f, -0.00962078f, -0.03085843f, -0.00202214f, 0.00851749f, -0.04660703f, -0.01229732f, 
    -0.03614300f, -0.05225461f, -0.03605543f, -0.05028013f, -0.04569225f, -0.00591721f, 0.00930655f, 0.03427617f, 
    -0.04906355f, -0.02275076f, -0.01931616f, -0.02560501f, -0.04587559f, -0.02795363f, 0.05264064f, -0.03148508f, 
    0.00656918f, -0.03100643f, -0.01104722f, -0.01430018f, 0.01641244f, -0.05181864f, -0.03259712f, -0.02937290f, 
    -0.03234342f, -0.03031738f, 0.02469724f, 0.04423678f, -0.04322683f, -0.03938565f, -0.01253823f, -0.01411835f, 
    -0.01343493f, -0.01943580f, -0.02199957f, -0.02636163f, -0.02900236f, -0.04486153f, -0.02565189f, -0.03193838f, 
    -0.02497315f, 0.01230368f, -0.00971413f, -0.02114990f, 0.04184926f, -0.05201274f, 0.04838035f, -0.05370393f, 
    0.05637396f, 0.35295096f, 0.15437905f, 0.08846434f, 0.01059937f, -0.14046682f, -0.04218784f, 0.22247274f, 
    0.00047917f, 0.05195160f, -0.02580006f, -0.04297449f, 0.04205631f, 0.11825169f, 0.05602547f, 0.06248705f, 
    0.16180605f, -0.06800814f, 0.04691285f, 0.22133231f, 0.06986437f, -0.03967885f, 0.12640686f, -0.14886452f, 
    0.06406482f, 0.04493084f, 0.00986308f, -0.15328853f, -0.03471143f, -0.04441161f, -0.07594705f, -0.08932939f, 
    0.04144271f, 0.05553352f, -0.00299814f, -0.02266522f, 0.14365211f, 0.07466519f, 0.04433857f, 0.12679450f, 
    0.12995315f, -0.03150850f, -0.10118502f, -0.00166027f, 0.17200838f, -0.07113834f, 0.01261822f, 0.05645819f, 
    0.06179269f, -0.07023516f, -0.09842030f, -0.10777983f, 0.05060911f, -0.13325255f, -0.07742475f, -0.01544792f, 
    -0.08404401f, -0.01232683f, 0.00964287f, -0.07801547f, -0.05504834f, -0.09415300f, 0.16783388f, 0.20206465f, 
    -0.10909886f, -0.10808522f, -0.04473460f, 0.07375290f, -0.00378568f, -0.17378362f, 0.19864719f, 0.00985681f, 
    0.08722512f, 0.03193332f, 0.05107729f, -0.12992346f, 0.04221142f, -0.04907499f, -0.08785424f, -0.17866267f, 
    0.46886286f, -0.24158451f, -0.13976496f, -0.14535005f, -0.08478015f, -0.00150309f, -0.00372829f, -0.20610641f, 
    -0.03878368f, 0.04730321f, -0.07468173f, 0.00769803f, -0.04972918f, 0.10441993f, 0.04329357f, -0.07814566f, 
    0.08319072f, -0.12473073f, 0.12217593f, 0.08660100f, -0.28130069f, -0.20569123f, 0.16146512f, 0.04692390f, 
    -0.12337494f, 0.11071998f, 0.02372331f, 0.13216470f, 0.01455891f, 0.12383407f, 0.10682556f, 0.03939281f, 
    0.01065316f, 0.02102691f, 0.13310239f, 0.04344376f, 0.06070037f, 0.04547797f, -0.02589036f, -0.01746465f, 
    -0.25557059f, -0.12623745f, -0.23401010f, -0.09372266f, -0.34710661f, -0.01029355f, 0.26887640f, -0.03958146f, 
    -0.09483413f, -0.00817632f, 0.11091065f, -0.04769705f, -0.11205924f, -0.07764137f, -0.09652021f, -0.03598234f, 
    0.19551639f, 0.01647999f, 0.04547871f, 0.02948321f, -0.12982117f, -0.14658332f, -0.17712942f, -0.12930733f, 
    0.01078792f, -0.14737523f, -0.03134644f, -0.16959587f, -0.13810609f, -0.12121862f, 0.01503884f, 0.11746025f, 
    0.04422078f, 0.10645267f, -0.00866986f, -0.04953831f, -0.04117673f, -0.14905649f, -0.11299700f, -0.12776260f, 
    0.19853082f, 0.15584555f, -0.22696917f, -0.02357903f, -0.20828113f, 0.08815646f, -0.00571661f, 0.05407681f, 
    0.03791587f, 0.05848432f, -0.00754233f, 0.07997363f, -0.06451541f, -0.04291364f, -0.03196478f, 0.05994170f, 
    0.06608879f, 0.06710761f, 0.10502353f, 0.05460261f, 0.18713619f, 0.26348311f, -0.21338481f, 0.19853653f, 
    -0.22915027f, 0.09125238f, -0.08446752f, 0.09248595f, 0.02386038f, 0.03358803f, -0.05232313f, 0.06324376f, 
    0.04407971f, 0.10463081f, -0.02653726f, -0.02528716f, 0.06554250f, -0.03479169f, 0.00685791f, -0.08162294f, 
    0.16956586f, -0.16877513f, 0.10070724f, -0.06990055f, 0.08183469f, -0.09706225f, -0.00122390f, 0.00740690f, 
    0.12284301f, 0.04169601f, 0.02559616f, -0.04141027f, 0.06509439f, -0.00284647f, 0.01797191f, 0.14519446f, 
    0.05080995f, 0.10728014f, -0.05021859f, -0.01106875f, 0.15404226f, -0.09220274f, -0.23389313f, -0.10131636f, 
    -0.21561630f, -0.13259766f, -0.02050737f, 0.10210548f, 0.00864040f, 0.03916192f, 0.01129614f, 0.02893308f, 
    0.02897850f, 0.06445040f, 0.08709959f, -0.00664617f, 0.16131474f, 0.02555199f, 0.08244754f, -0.01921709f, 
    0.27778420f, -0.46139610f, -0.31893435f, -0.05798887f, -0.33325362f, -0.01813967f, 0.09340893f, -0.07127339f, 
    0.01048032f, 0.08076975f, 0.07669802f, -0.07831534f, 0.03356433f, 0.02391903f, -0.03569108f, -0.01455784f, 
    -0.01358864f, 0.03407498f, -0.05043774f, -0.02884575f, -0.04118199f, 0.01030892f, -0.17600028f, 0.09081224f, 
    -0.14034730f, 0.00701611f, 0.14619488f, 0.06979103f, -0.00028019f, -0.09445021f, -0.00025746f, 0.01824370f, 
    -0.00851714f, -0.09384254f, -0.00114928f, -0.10740784f, 0.16194427f, -0.02111388f, -0.01335842f, -0.04593446f, 
    -0.11378158f, -0.35039568f, -0.29036316f, 0.03774662f, -0.24113080f, 0.01523274f, 0.13392298f, -0.02059104f, 
    -0.12338257f, -0.03467745f, 0.00391683f, -0.04099538f, 0.12017818f, 0.07021094f, -0.03005771f, -0.04975256f, 
    -0.00317379f, 0.05858361f, -0.10050926f, 0.08856204f, 0.15477227f, 0.11468901f, 0.07414890f, -0.04217913f, 
    0.04130785f, 0.11038473f, 0.11625294f, 0.01229859f, 0.07417731f, 0.06111335f, 0.10067108f, -0.02593684f, 
    -0.01731026f, 0.05331919f, 0.02081832f, -0.01698641f, 0.01911306f, 0.02105862f, 0.11840229f, -0.06632125f, 
    0.24026553f, 0.37202939f, 0.41701746f, 0.13283500f, -0.06439993f, -0.10717564f, -0.01322640f, 0.25033265f, 
    -0.05249077f, 0.22079609f, -0.01465587f, 0.03446053f, -0.04900279f, 0.08597313f, 0.02649255f, -0.01677556f, 
    -0.11080582f, -0.26146278f, -0.01340824f, 0.01950728f, -0.23717932f, -0.17716423f, 0.30161124f, 0.00462371f, 
    -0.02376512f, 0.06610036f, -0.00340907f, -0.07398596f, -0.00930365f, -0.08525980f, -0.07888976f, -0.09271985f, 
    0.08036171f, -0.02663575f, -0.01106547f, -0.07991090f, -0.03473105f, -0.12710176f, -0.08744088f, -0.00529396f, 
    0.11196302f, -0.51785922f, -0.41714758f, -0.07955063f, 0.23222375f, -0.04525199f, 0.06735951f, 0.14924347f, 
    0.15734610f, 0.06302888f, 0.00526593f, 0.02109909f, -0.07614831f, -0.13276897f, 0.01085955f, 0.13833170f, 
    0.06576610f, -0.02615745f, 0.06750569f, 0.00595598f, 0.02387188f, -0.00450168f, 0.16303793f, 0.22183535f, 
    -0.01519552f, 0.01922514f, -0.01297438f, 0.15837501f, 0.04950341f, 0.00516014f, 0.13301353f, -0.03580592f, 
    0.02784570f, 0.00491757f, -0.08494185f, 0.10167873f, 0.01685433f, -0.05872169f, 0.05436330f, 0.12880960f, 
    0.06970853f, -0.39364401f, 0.13332669f, -0.00356385f, -0.07600892f, -0.04286417f, -0.10029167f, -0.11291294f, 
    0.04760467f, -0.17667198f, 0.03708475f, -0.08214286f, 0.02021639f, -0.04824314f, 0.02999632f, 0.04198973f, 
    0.02142329f, -0.12992704f, -0.07265662f, 0.00919162f, -0.31781638f, -0.26879200f, 0.15310688f, 0.24781443f, 
    -0.13968144f, 0.00320427f, -0.01348234f, 0.21555857f, 0.03529985f, -0.00369561f, 0.11491971f, 0.03067040f, 
    -0.05745066f, -0.02570153f, -0.02397929f, 0.03803843f, 0.02774934f, 0.04466195f, -0.00734008f, 0.14289565f, 
    0.29732686f, 0.21449538f, 0.14585470f, 0.23868485f, -0.20019819f, -0.08520492f, -0.00298368f, -0.12940715f, 
    -0.04063633f, -0.04780609f, 0.04773561f, -0.02151109f, 0.08181297f, 0.02175982f, -0.02768872f, -0.08099338f, 
    0.03972377f, 0.04524294f, -0.16941310f, -0.02789036f, -0.10900392f, -0.06924205f, -0.17762168f, -0.02341925f, 
    0.12736867f, -0.01824595f, -0.05566912f, -0.10944170f, -0.12387738f, -0.09126724f, 0.06120409f, 0.07497399f, 
    -0.10411249f, -0.01010292f, 0.01042758f, -0.02524927f, 0.11115675f, 0.07271516f, 0.01069741f, 0.13087437f, 
    0.06512985f, -0.01106312f, -0.45150626f, 0.20049345f, -0.10638566f, 0.25608727f, 0.02205630f, 0.09220491f, 
    -0.00362452f, 0.02755547f, 0.06070082f, 0.06482448f, -0.03601860f, -0.11864692f, -0.03600983f, 0.03877208f, 
    0.10948168f, 0.17188810f, -0.00573526f, 0.02391648f, 0.16938524f, 0.31170043f, -0.29803434f, 0.46644884f, 
    -0.07200529f, 0.21967894f, -0.05739176f, 0.07575987f, 0.10108982f, 0.13240065f, 0.01347536f, 0.07297661f, 
    -0.08534719f, -0.02137480f, -0.05390513f, -0.02033146f, 0.03274679f, 0.13183390f, 0.11849818f, 0.03140021f, 
    0.18714842f, -0.04529621f, 0.16811205f, -0.24816999f, -0.01652305f, -0.03859012f, 0.06696482f, 0.06605761f, 
    0.07017884f, 0.09790923f, 0.12403430f, 0.00724236f, 0.08987560f, 0.05060190f, 0.09360381f, 0.08565748f, 
    -0.04879539f, 0.04829279f, 0.00337148f, -0.10095686f, 0.26144958f, -0.10961247f, -0.48152238f, -0.25309038f, 
    -0.30861804f, 0.00856426f, 0.12424368f, 0.09332027f, 0.02802455f, 0.22747740f, -0.06472451f, 0.00896625f, 
    -0.02238008f, 0.00240892f, 0.01383722f, -0.04399430f, 0.10410696f, -0.06039255f, 0.01153337f, -0.00026881f, 
    0.16142942f, -0.50270200f, -0.16315982f, -0.11910637f, -0.39978984f, 0.00621091f, 0.02627577f, 0.03714742f, 
    0.17818509f, -0.05203329f, 0.00205350f, -0.03938353f, -0.11885735f, -0.02084694f, -0.04699244f, -0.08776686f, 
    -0.05113610f, 0.04094519f, 0.02510643f, 0.01625438f, 0.00262551f, -0.07542131f, -0.37314296f, 0.01590876f, 
    0.08573426f, 0.21327798f, 0.21616977f, 0.17367536f, -0.01524779f, 0.01212397f, 0.06308313f, 0.07807919f, 
    0.12531635f, 0.03593679f, 0.07300238f, 0.03961769f, 0.09149064f, 0.00966034f, -0.06182307f, -0.00565160f, 
    0.05472929f, -0.23916848f, -0.08500022f, 0.08647280f, -0.07159356f, -0.00590248f, 0.02988807f, -0.07756531f, 
    -0.05699277f, -0.09554999f, 0.04347454f, -0.04122857f, -0.04630263f, 0.03980988f, -0.07341307f, -0.03054387f, 
    0.02815394f, 0.05441850f, -0.19154108f, 0.07654244f, 0.08206569f, 0.07431650f, 0.22587451f, -0.02469673f, 
    -0.16714627f, 0.03625886f, 0.00559872f, -0.07596397f, 0.04903727f, -0.02348350f, 0.00590379f, -0.06569143f, 
    -0.04450137f, 0.13682331f, 0.10400928f, -0.01078029f, 0.09912276f, 0.05166321f, 0.13722919f, 0.11438100f, 
    0.00288793f, -0.02162351f, -0.04754430f, 0.00699723f, -0.04087290f, 0.00637905f, 0.00091219f, -0.05215007f, 
    -0.04721035f, -0.04121652f, -0.04633864f, -0.05584109f, -0.05439309f, 0.00604949f, -0.03195009f, -0.01253328f, 
    0.01782925f, 0.04514796f, 0.01176475f, -0.03063872f, 0.04892033f, -0.02938161f, -0.03868984f, -0.05792151f, 
    -0.03366739f, 0.00925853f, 0.01639906f, -0.01304629f, -0.00463974f, 0.05016679f, 0.00724265f, 0.03310766f, 
    -0.02142882f, -0.01792944f, 0.04422305f, -0.05512828f, 0.00289834f, 0.02593767f, -0.04075432f, 0.04103694f, 
    0.00458784f, -0.04966036f, 0.02686717f, -0.04118152f, -0.02189949f, -0.01919507f, -0.05003813f, 0.02108854f, 
    -0.02698675f, -0.01441228f, -0.01122123f, -0.00125118f, 0.00900823f, 0.04891890f, -0.01839413f, 0.00120137f, 
    0.03958413f, -0.01746041f, -0.04718833f, -0.02685247f, -0.00699043f, -0.00369244f, -0.02338077f, 0.01905836f, 
    0.03219963f, -0.00412496f, 0.02608952f, 0.01307976f, 0.03617134f, -0.06464463f, 0.03857877f, -0.03830369f, 
    -0.04304313f, -0.03720250f, -0.05707040f, 0.02732894f, -0.04210874f, 0.02158715f, 0.00777402f, 0.02787759f, 
    0.02190540f, -0.03032330f, -0.03078589f, 0.02778137f, 0.01835212f, -0.02246040f, 0.03639211f, 0.01305892f, 
    -0.00113917f, -0.01331807f, -0.01426032f, -0.02336614f, -0.04684046f, -0.05297093f, 0.02902756f, 0.01835535f, 
    -0.02550176f, -0.01834568f, -0.04669986f, 0.01903644f, 0.01365734f, -0.02752854f, 0.03125320f, 0.03777114f, 
    0.04202816f, 0.01689062f, 0.01741154f, -0.02901901f, -0.03725424f, 0.03531032f, -0.04304134f, -0.03559087f, 
    0.01279180f, 0.00885009f, 0.04067638f, 0.01208639f, -0.03118358f, -0.05672676f, -0.02329357f, 0.00819480f, 
    -0.02521790f, -0.04485969f, -0.00578189f, -0.03701106f, 0.01008758f, -0.05244750f, 0.04574512f, 0.01619325f, 
    -0.03537779f, 0.03270667f, -0.00031448f, 0.04608920f, -0.01381320f, -0.04211498f, -0.02123628f, -0.01695583f, 
    0.02424837f, 0.00804333f, 0.00401808f, -0.03746569f, -0.04885165f, 0.01027183f, 0.03054128f, -0.03677217f, 
    -0.02439773f, 0.04987569f, -0.05791015f, -0.04116492f, -0.02759478f, -0.02016932f, -0.01431813f, -0.01482580f, 
    -0.04260438f, 0.04140900f, 0.02036149f, -0.01604079f, -0.02942865f, -0.03752459f, -0.03574825f, -0.00522695f, 
    -0.00157450f, 0.01412311f, -0.05478712f, -0.02414945f, 0.02852102f, -0.01887264f, -0.05350308f, -0.05671826f, 
    -0.01181632f, -0.02335187f, -0.04808354f, 0.03913224f, 0.02161126f, -0.04663847f, -0.05101335f, 0.03587727f, 
    -0.04943325f, -0.02997298f, 0.02934015f, -0.03578295f, 0.03552580f, -0.05662053f, 0.01406259f, -0.02207611f, 
    -0.06114797f, 0.04496191f, 0.00181108f, -0.02265997f, -0.01330945f, 0.03466257f, 0.01329228f, 0.00605261f, 
    0.02200833f, -0.05263643f, 0.00161846f, 0.04346884f, -0.00372182f, 0.03248340f, 0.03727673f, -0.01633786f, 
    0.03116985f, -0.00342793f, 0.00775906f, 0.02410889f, 0.01195707f, 0.03664746f, -0.01163919f, 0.04303999f, 
    0.01226392f, -0.04182416f, 0.00049900f, -0.05988034f, 0.00400607f, 0.03154638f, 0.02511245f, 0.02054554f, 
    0.02446767f, 0.02012189f, -0.01570014f, -0.03118818f, -0.03916812f, 0.02450856f, -0.01968803f, -0.02353712f, 
    0.03863478f, 0.01578405f, 0.01253330f, 0.00095047f, -0.02115589f, 0.01196287f, 0.03060468f, -0.03235701f, 
    -0.04957895f, 0.04204024f, -0.00031347f, 0.00156293f, -0.05392632f, 0.04698246f, 0.01991294f, -0.02260703f, 
    0.02588793f, 0.01454342f, 0.02486167f, -0.05052820f, -0.04512655f, 0.02578744f, -0.05052235f, 0.02366665f, 
    -0.02972848f, 0.00251268f, 0.00185861f, -0.01996324f, 0.00160765f, -0.01124477f, -0.01139569f, 0.02009596f, 
    -0.01680332f, -0.01062132f, 0.03267789f, -0.05352106f, -0.05813073f, 0.02499286f, -0.05518616f, -0.01035505f, 
    -0.04843667f, 0.03793610f, 0.01503330f, 0.03021386f, -0.04267398f, 0.00500404f, -0.05290046f, 0.01718071f, 
    -0.00545101f, 0.00685891f, 0.03717792f, 0.03354858f, 0.03229080f, -0.03912408f, 0.01836349f, 0.01159110f, 
    0.00045991f, 0.02830593f, 0.00342623f, -0.02851007f, 0.00231794f, -0.03791123f, 0.03645553f, 0.02014233f, 
    0.02771795f, -0.01390771f, 0.03269557f, -0.05159086f, 0.02525160f, -0.05077694f, -0.00519601f, 0.02888307f, 
    -0.05396811f, -0.01656450f, 0.04826719f, 0.05230325f, 0.03968938f, -0.06004340f, -0.05149380f, -0.04809273f, 
    0.03395803f, -0.05446045f, -0.02765411f, 0.03614443f, -0.05129791f, 0.02784859f, -0.02347294f, -0.03132810f, 
    -0.05622141f, -0.02014132f, -0.01527822f, -0.00239719f, 0.03070971f, 0.01633788f, -0.05344772f, -0.00114185f, 
    0.02227787f, -0.02466826f, -0.05495033f, 0.01820986f, -0.00398808f, -0.00048933f, 0.04318911f, 0.00710863f, 
    0.04543884f, 0.00304559f, 0.02031789f, 0.02971442f, -0.00139060f, -0.00614159f, 0.01742710f, 0.02179341f, 
    -0.00561088f, 0.02307379f, -0.01682489f, -0.03526229f, -0.02430154f, -0.01739324f, -0.05608239f, 0.04802819f, 
    0.03990514f, 0.03240358f, -0.02087260f, -0.02439206f, 0.03560856f, 0.00704220f, 0.03181643f, -0.02906347f, 
    -0.02144359f, -0.03817113f, -0.01233645f, -0.04439298f, 0.02555682f, 0.04344671f, -0.06102159f, 0.00195904f, 
    -0.02062313f, -0.04592355f, -0.01837168f, 0.04203004f, -0.00920279f, -0.04502460f, 0.03385615f, 0.03533827f, 
    -0.02872926f, -0.00646389f, -0.02174936f, 0.04417163f, 0.03358928f, -0.05305574f, -0.06018432f, -0.05455441f, 
    -0.03858867f, 0.04575613f, -0.03729662f, -0.00752584f, 0.00100920f, -0.00992426f, -0.03154214f, 0.02650717f, 
    -0.01730817f, 0.03665318f, -0.05334258f, -0.04539878f, -0.05236706f, 0.00937685f, 0.03527408f, 0.02905958f, 
    0.04729646f, 0.03414902f, -0.01553185f, -0.05120629f, -0.04443207f, -0.02348488f, 0.04988873f, 0.05563924f, 
    0.01858752f, -0.04753244f, -0.01926736f, 0.04703137f, -0.04581327f, -0.00126372f, 0.03522870f, 0.01007770f, 
    -0.03775921f, 0.01506647f, 0.05018672f, -0.02875848f, 0.00824759f, -0.04532995f, -0.04872138f, 0.01250529f, 
    0.04203930f, -0.04275658f, -0.05860307f, 0.01726704f, -0.05257495f, 0.01519695f, 0.04265720f, -0.03565136f, 
    -0.00288171f, -0.01901568f, 0.04478012f, 0.04870823f, -0.00539172f, -0.00384677f, -0.00051667f, 0.01929810f, 
    -0.01944793f, -0.03736327f, -0.03820749f, 0.02849828f, -0.03378651f, -0.00889460f, 0.02413208f, 0.00214784f, 
    0.00435500f, 0.01335053f, -0.01955559f, -0.02018698f, 0.02639223f, -0.02307123f, 0.02904999f, 0.03688658f, 
    0.04236952f, 0.01251319f, -0.03017136f, 0.03107731f, -0.01139834f, -0.01285225f, -0.03480106f, 0.00787006f, 
    0.02467336f, -0.04995997f, 0.00693636f, -0.03597459f, -0.05259277f, -0.03626930f, 0.03104540f, -0.04115957f, 
    -0.05100651f, -0.03521341f, -0.03985929f, 0.04439457f, -0.02954487f, -0.02951808f, -0.01407022f, -0.01277131f, 
    0.03678766f, -0.05806010f, -0.00575720f, 0.05240570f, 0.03325725f, -0.05638606f, -0.00578147f, -0.00773118f, 
    0.01536832f, -0.04247325f, -0.04043804f, 0.02625515f, 0.03114747f, -0.02574958f, 0.03894801f, -0.03239265f, 
    0.00411578f, -0.02688533f, -0.05070025f, -0.04191807f, -0.01090841f, -0.03220254f, 0.02160909f, 0.00809747f, 
    0.00567845f, -0.02276454f, -0.05359330f, -0.03194470f, -0.02539933f, -0.00251624f, 0.03270903f, 0.01792227f, 
    -0.05665002f, 0.00990018f, 0.00471447f, -0.05262483f, -0.05220598f, -0.00077033f, -0.03738632f, -0.00877255f, 
    -0.00172442f, 0.04538819f, 0.00839520f, 0.02911736f, -0.04236828f, 0.04537486f, -0.02536492f, -0.03970094f, 
    -0.03886418f, 0.01011092f, 0.00805526f, -0.04109466f, -0.04137786f, -0.00251829f, -0.03028424f, 0.03412339f, 
    0.02489488f, -0.03070196f, 0.02685388f, -0.00284957f, -0.01935485f, -0.02024163f, -0.04018513f, -0.05248522f, 
    0.01642348f, -0.05126600f, -0.01118028f, 0.03134175f, -0.06078125f, 0.03402466f, -0.05427758f, 0.04178659f, 
    0.00555972f, 0.03247703f, 0.00098468f, 0.00904682f, 0.02431688f, 0.03147888f, 0.02527160f, -0.00277401f, 
    0.00275019f, 0.00966793f, 0.00866169f, -0.03324112f, 0.01683860f, -0.01475525f, -0.03487239f, 0.04695645f, 
    -0.01809105f, 0.00133358f, -0.02179020f, -0.04112780f, 0.00165426f, -0.00524628f, -0.03676388f, -0.01694952f, 
    -0.04842057f, 0.03528753f, 0.04910218f, 0.00818636f, -0.00328299f, -0.05362085f, 0.04146057f, -0.01133710f, 
    0.03432251f, -0.02696919f, -0.05504918f, -0.04015452f, 0.01118335f, 0.04821802f, 0.01312638f, -0.04918990f, 
    0.00937820f, -0.02988062f, 0.03720391f, 0.03151821f, 0.04215749f, -0.00338921f, -0.06476427f, -0.06363927f, 
    0.01426417f, 0.00227138f, -0.01207946f, 0.03175514f, -0.02640930f, 0.01676751f, 0.01872290f, -0.02573179f, 
    -0.01787921f, -0.01112699f, 0.04563529f, -0.01743018f, -0.00621877f, -0.04817399f, -0.00138208f, -0.05809942f, 
    0.01762146f, 0.00131129f, 0.00425531f, -0.02983545f, 0.02846592f, 0.00221758f, 0.02402720f, 0.01750263f, 
    -0.02338402f, 0.01943258f, -0.00928169f, -0.02844459f, -0.03817704f, -0.00717609f, 0.00864142f, -0.01746132f, 
    -0.03743023f, 0.03363900f, -0.02437923f, -0.04883584f, 0.00110990f, 0.00562197f, -0.03892384f, -0.00957007f, 
    -0.06530370f, -0.05904761f, -0.02412542f, 0.03901705f, -0.00356364f, 0.00325479f, 0.02686332f, -0.00560934f, 
    -0.04376043f, 0.03161199f, 0.01126875f, -0.03173703f, 0.03602524f, 0.01491651f, 0.02182959f, 0.02483591f, 
    -0.00671055f, 0.02476797f, -0.04618360f, 0.03996186f, 0.00432585f, -0.01932898f, 0.01714258f, 0.04888104f, 
    0.00690824f, 0.04423754f, 0.00085593f, -0.03694199f, -0.00131740f, -0.03063849f, -0.05492092f, 0.02047132f, 
    -0.01408641f, -0.03561448f, 0.04030220f, -0.00029808f, 0.02083217f, -0.05934202f, -0.01407742f, 0.02772247f, 
    -0.05527885f, 0.01124363f, 0.05026029f, -0.05956639f, -0.01128010f, 0.00811777f, -0.02766077f, 0.03557819f, 
    0.01350395f, -0.02028765f, -0.00539450f, 0.01379838f, -0.04176185f, -0.01572325f, -0.04765701f, 0.04608934f, 
    0.01264244f, -0.05403314f, -0.02888140f, -0.03179699f, 0.04972535f, 0.03048439f, -0.05250221f, -0.03499928f, 
    -0.04203622f, 0.02776117f, -0.00288487f, -0.01814944f, -0.03601849f, -0.02230550f, -0.05697486f, -0.00190957f, 
    0.00110359f, 0.01842087f, 0.00118412f, 0.02693104f, -0.03867573f, -0.01615845f, -0.02604595f, -0.01186314f, 
    0.03270649f, 0.04657965f, 0.03483370f, 0.01238141f, -0.03678560f, 0.02602514f, 0.01482232f, -0.05853675f, 
    -0.02537890f, -0.01835741f, 0.04868278f, -0.00485541f, -0.05241239f, 0.02046461f, -0.02888121f, 0.01909583f, 
    -0.01623703f, -0.05802345f, 0.03185316f, -0.04002502f, -0.04769939f, 0.02956222f, -0.03129314f, -0.02671683f, 
    -0.02938482f, -0.01783012f, -0.03652436f, -0.05596573f, -0.05099722f, -0.03199225f, -0.00783829f, 0.00037216f, 
    -0.03511650f, -0.03580119f, -0.05903923f, -0.05846539f, -0.04230237f, -0.01000775f, 0.04049048f, -0.00150773f, 
    -0.02695619f, 0.01897509f, -0.02609702f, -0.04894221f, -0.02206728f, 0.00736060f, 0.02012964f, -0.03682411f, 
    0.03392415f, -0.02836340f, 0.00498256f, -0.02390350f, 0.02757649f, -0.06031083f, -0.01627125f, 0.02898829f, 
    0.04114705f, 0.03118934f, -0.01008634f, -0.01346608f, -0.02086753f, -0.01942638f, -0.05340442f, -0.04488568f, 
    -0.04672787f, 0.04088789f, -0.05741437f, -0.01995203f, -0.01806920f, -0.01686037f, -0.01797362f, 0.02472928f, 
    -0.03222173f, -0.02546770f, -0.04930772f, -0.02818363f, 0.00135484f, -0.02788665f, -0.03548420f, 0.00847985f, 
    0.01259732f, -0.03645236f, -0.04812112f, -0.06089115f, -0.04743274f, 0.00837631f, 0.01304255f, 0.02799053f, 
    0.04770884f, 0.02989030f, -0.04632082f, 0.02120300f, -0.04864441f, 0.02905395f, 0.03432871f, 0.04078430f, 
    0.03809061f, 0.00044769f, -0.01114884f, 0.02968764f, -0.04646282f, 0.02232420f, -0.01938145f, -0.01740826f, 
    -0.00942256f, -0.04654678f, 0.00608654f, -0.02227934f, -0.01113646f, 0.00135395f, 0.01737213f, -0.03169630f, 
    0.03030082f, -0.00482617f, -0.02427318f, 0.00953022f, -0.00230804f, -0.06032563f, 0.04784838f, 0.03222195f, 
    -0.03207546f, -0.00848833f, 0.01839337f, 0.04805224f, -0.05700018f, -0.02404744f, 0.02050537f, -0.01727499f, 
    -0.04816656f, -0.02352901f, 0.03050929f, -0.02565373f, -0.03405641f, -0.00600715f, 0.00403071f, -0.01946805f, 
    0.04334880f, 0.04184454f, 0.04843723f, -0.04292944f, -0.01976850f, 0.00681144f, -0.04101334f, -0.02743286f, 
    -0.02803282f, -0.00074716f, 0.01763025f, 0.01095561f, 0.01386540f, -0.00290514f, -0.04812753f, -0.05569991f, 
    -0.03916167f, -0.01725101f, -0.04045627f, -0.04206417f, 0.04305648f, -0.01918971f, 0.01503393f, 0.00266110f, 
    -0.03321283f, -0.03893796f, -0.05953359f, -0.03042090f, 0.04477033f, -0.05104367f, -0.02888009f, 0.02539951f, 
    0.00021139f, -0.05138670f, 0.02501762f, -0.00751273f, -0.00041133f, -0.00031008f, -0.01402115f, 0.01381902f, 
    0.01375374f, 0.02237130f, 0.00883472f, 0.04132222f, 0.02726553f, -0.01560852f, -0.05887722f, 0.02716173f, 
    0.01097950f, 0.02379838f, -0.00519088f, -0.05371805f, -0.01997511f, -0.02327219f, -0.01138613f, 0.05527792f, 
    -0.01913340f, 0.05319444f, -0.01396139f, -0.04845001f, -0.01862914f, 0.01300264f, 0.00076028f, 0.00164547f, 
    0.03442027f, -0.05166759f, 0.00618470f, 0.01545031f, 0.02265787f, 0.03359402f, -0.05569292f, -0.01013672f, 
    0.00090672f, -0.04824605f, -0.02010764f, -0.04242708f, 0.01963384f, -0.02200400f, 0.04146791f, -0.00389377f, 
    0.01350453f, 0.01276570f, -0.04292993f, -0.01164756f, -0.05742411f, 0.02553655f, 0.01113853f, 0.01733850f, 
    -0.04548467f, 0.01700328f, -0.02478857f, 0.00309715f, -0.05271792f, 0.03547210f, -0.05803683f, -0.00532766f, 
    0.04058266f, -0.00912457f, 0.04109872f, 0.01177596f, 0.03183157f, -0.05168562f, -0.02519907f, -0.03049668f, 
    0.04360455f, 0.04350602f, -0.00053182f, -0.04428692f, 0.01185871f, 0.01434091f, -0.03214369f, 0.02098282f, 
    0.02187559f, 0.01668412f, 0.00812069f, -0.01526108f, -0.05801136f, -0.04223526f, -0.03925488f, 0.00480830f, 
    0.03515204f, 0.02711623f, -0.00691524f, 0.02990863f, 0.03973019f, -0.01640585f, 0.02404897f, -0.03952199f, 
    -0.01065909f, -0.02546521f, 0.04744291f, 0.00030880f, -0.04800626f, -0.05189906f, -0.00478780f, -0.01730374f, 
    0.02614386f, -0.02793499f, -0.01041677f, 0.03151889f, -0.01346759f, -0.03080879f, 0.01495282f, -0.00094021f, 
    -0.02638614f, -0.00272388f, -0.01171087f, -0.03769688f, -0.01022703f, -0.06645350f, -0.02496788f, -0.03523760f, 
    0.02366878f, 0.01291160f, 0.03762295f, 0.05239690f, -0.00695963f, -0.05648378f, 0.02934230f, 0.04043412f, 
    -0.03786937f, -0.00112988f, -0.04160724f, -0.06458353f, 0.01140933f, -0.02243770f, 0.00038246f, -0.03722392f, 
    0.03366581f, -0.05446116f, -0.00853570f, -0.02383084f, 0.04212536f, -0.03454113f, -0.02436370f, -0.01251831f, 
    -0.02522190f, 0.04668397f, -0.03401035f, 0.02641951f, 0.00199067f, 0.05646245f, -0.01958827f, -0.03537700f, 
    -0.00224466f, -0.00297958f, 0.04089121f, 0.00627834f, 0.00943301f, -0.04153563f, -0.04899377f, 0.03107932f, 
    -0.05025811f, -0.03031413f, -0.05697419f, -0.04853990f, 0.03193421f, -0.00167929f, -0.04714613f, -0.02829291f, 
    -0.01995476f, -0.05995472f, 0.03757512f, 0.02151250f, -0.06273464f, 0.03145252f, -0.00645521f, -0.01919884f, 
    -0.01553345f, -0.02581083f, -0.03237524f, -0.01816899f, -0.01202656f, -0.00555078f, -0.04529017f, 0.00718588f, 
    -0.05212896f, -0.01988548f, 0.04056311f, -0.04478538f, -0.02865656f, 0.02430078f, -0.02069958f, 0.03127204f, 
    0.04472865f, -0.04688933f, 0.04178335f, -0.00680045f, 0.00647168f, -0.00886281f, -0.03305750f, 0.00063327f, 
    -0.04279708f, 0.04283137f, 0.01538537f, -0.01531868f, 0.00638291f, -0.05859050f, 0.03665911f, 0.03101850f, 
    0.02120738f, -0.04209877f, 0.04562351f, -0.05265162f, -0.02275721f, -0.04613878f, 0.01690818f, -0.03393633f, 
    0.03040223f, -0.06236325f, 0.03467415f, 0.00919057f, -0.04754440f, -0.00941710f, -0.05790186f, 0.01952168f, 
    -0.02613226f, 0.03108585f, 0.04673005f, -0.04349459f, 0.01362292f, -0.02767471f, 0.00096752f, 0.01918363f, 
    0.03681123f, 0.02354055f, 0.01606549f, 0.04488964f, -0.05466816f, 0.01352144f, -0.02274040f, -0.04847214f, 
    0.03967750f, 0.01351147f, -0.01663525f, -0.05370164f, -0.05220130f, 0.02669185f, -0.03277879f, -0.02782780f, 
    0.03527607f, 0.04232302f, -0.03035557f, 0.02823236f, -0.03227492f, -0.03763238f, 0.00336485f, -0.05353902f, 
    0.01793397f, -0.03804955f, 0.04671503f, -0.04005380f, -0.05449132f, 0.02646875f, 0.04011631f, -0.05290350f, 
    -0.05228501f, -0.00812771f, 0.03001289f, -0.00151843f, -0.01477940f, 0.01890660f, -0.00344263f, 0.04181644f, 
    0.03268663f, 0.01034178f, -0.04334513f, 0.02710643f, -0.04571232f, -0.02269974f, 0.05218190f, 0.04681993f, 
    -0.05631268f, 0.03672596f, -0.01221236f, -0.05748019f, 0.01570836f, 0.00870580f, 0.03157606f, -0.01056855f, 
    0.03241595f, -0.01434921f, 0.01672101f, -0.01372543f, 0.01002084f, -0.00979161f, 0.04577728f, 0.02425912f, 
    -0.03276642f, 0.01188013f, 0.00330820f, 0.02228697f, -0.00406952f, 0.00896443f, 0.03812832f, 0.02732368f, 
    0.00975645f, -0.04226063f, -0.00589938f, 0.01718951f, -0.04061275f, -0.06335114f, -0.02367495f, 0.01328523f, 
    -0.01355694f, 0.03927454f, 0.00115198f, 0.04780750f, -0.00259433f, -0.05893050f, 0.02739223f, -0.00168636f, 
    0.03504611f, 0.04420666f, 0.01821012f, -0.03085460f, 0.01486709f, -0.01490540f, 0.00316500f, -0.00576067f, 
    0.04074391f, 0.03956671f, 0.01417960f, -0.04634886f, -0.02203613f, -0.02319052f, -0.02510306f, -0.03055733f, 
    0.02796979f, -0.06639643f, 0.01464828f, 0.01408207f, 0.03683223f, -0.04040924f, -0.04619750f, -0.02557123f, 
    -0.04247371f, 0.00547303f, 0.00726931f, -0.06345531f, 0.00706143f, -0.00126240f, 0.00205568f, -0.00490460f, 
    0.02924625f, -0.03644522f, -0.01525594f, -0.00667673f, 0.02876122f, -0.06705341f, -0.01953881f, -0.00931664f, 
    -0.02015370f, 0.01171767f, -0.01380626f, -0.05405959f, -0.02059940f, 0.01620515f, -0.01649770f, -0.05352346f, 
    0.03880547f, -0.03081657f, 0.02031447f, -0.04772677f, -0.00824636f, 0.02906896f, -0.04734552f, -0.04090397f, 
    0.01647697f, -0.01582847f, -0.00588900f, 0.02926793f, -0.00803994f, -0.02114005f, -0.02779545f, -0.03695811f, 
    0.04553524f, 0.01044424f, -0.02385633f, -0.02166511f, -0.00039709f, 0.02167935f, -0.03746191f, 0.02892739f, 
    -0.00719092f, 0.01657121f, 0.04188544f, -0.03986049f, 0.02496287f, -0.01883391f, -0.03358146f, 0.03758650f, 
    0.24092500f, 0.02016743f, -0.12410466f, -0.00505458f, 0.13020453f, 0.12145212f, -0.04442992f, 0.08729786f, 
    0.02625159f, 0.17391670f, 0.05444169f, 0.06180360f, -0.00870749f, 0.03383597f, 0.09695721f, 0.16276135f, 
    0.09245409f, 0.04750125f, 0.15081578f, 0.11861888f, 0.20094165f, -0.04109116f, 0.20814954f, -0.08829302f, 
    -0.25630856f, 0.02221718f, -0.04132218f, -0.06170389f, 0.12933207f, -0.19094530f, 0.03985774f, 0.01546326f, 
    -0.02740560f, 0.07682885f, 0.01557841f, 0.06394032f, 0.06916150f, 0.05116293f, 0.13667823f, 0.01623086f, 
    -0.25474393f, 0.17847481f, 0.30641529f, 0.25074527f, -0.01588654f, 0.00484868f, -0.12768058f, -0.03060052f, 
    -0.02053515f, -0.06360977f, -0.13152489f, -0.03288030f, -0.01020360f, 0.05925766f, 0.03475375f, -0.12135585f, 
    -0.05614634f, 0.09658147f, -0.08640306f, 0.01722925f, 0.13895255f, 0.26916778f, 0.02304558f, -0.29841813f, 
    -0.05587973f, -0.12473863f, -0.00773159f, 0.00847928f, -0.15307744f, -0.02646954f, 0.03744722f, 0.01507077f, 
    0.03210622f, 0.06383573f, 0.00034521f, 0.11637752f, 0.03421355f, -0.08145732f, -0.13432881f, -0.25371951f, 
    -0.30746338f, -0.25634733f, -0.00269740f, 0.30217227f, 0.12590297f, 0.02698778f, -0.07156509f, -0.01509174f, 
    0.14429291f, 0.14928536f, 0.01529377f, 0.01361408f, 0.06706047f, -0.02617468f, 0.11785144f, -0.09838384f, 
    0.05403473f, -0.00375702f, 0.01446475f, 0.14623998f, 0.49638468f, 0.27142456f, -0.02037229f, -0.45273063f, 
    -0.00385142f, 0.05074349f, 0.01258582f, 0.07306273f, 0.11645240f, 0.08956255f, -0.03070195f, 0.05525776f, 
    0.00405263f, 0.06069236f, 0.07695121f, 0.04555866f, -0.03817778f, 0.00373956f, 0.12528923f, -0.07873039f, 
    0.02647335f, -0.14980280f, -0.35226670f, -0.31458011f, 0.02100851f, -0.00679041f, 0.08086614f, 0.02929658f, 
    -0.11368992f, 0.13076240f, -0.07084942f, -0.07175816f, -0.11327913f, -0.10743872f, 0.01652514f, -0.00153334f, 
    0.04691220f, -0.00693189f, 0.06585253f, 0.00328428f, -0.11389099f, 0.13623579f, 0.22553752f, 0.16687874f, 
    -0.13900557f, -0.04729076f, -0.02647567f, 0.04673582f, 0.03875066f, 0.00895850f, -0.02673909f, 0.13670650f, 
    0.06213952f, 0.17604773f, -0.04244367f, -0.03351144f, -0.01736016f, 0.04171847f, -0.06937678f, -0.14865977f, 
    -0.16232476f, 0.17703924f, 0.24960338f, 0.11513120f, -0.16201892f, -0.11304548f, 0.08574934f, 0.00797104f, 
    0.02040689f, -0.10325918f, -0.23144342f, 0.02800316f, -0.02425557f, 0.00436756f, -0.01566626f, -0.03186671f, 
    0.04136994f, 0.07016128f, 0.04299412f, 0.00161385f, 0.01908277f, -0.00968398f, 0.25966620f, 0.05001695f, 
    0.10436623f, 0.00777114f, -0.03334312f, 0.13052674f, 0.05116362f, -0.04912368f, -0.05935213f, 0.02858547f, 
    -0.05595900f, -0.02370607f, -0.03809692f, -0.03858104f, -0.15963107f, -0.02975919f, -0.02916138f, 0.03227307f, 
    -0.27532160f, -0.22577731f, 0.10462488f, 0.18221122f, -0.14078780f, 0.02390972f, 0.00429649f, -0.07756715f, 
    -0.06332880f, 0.04184368f, 0.03682841f, -0.05089872f, 0.07775776f, 0.10448502f, 0.18551397f, -0.02557518f, 
    0.01513158f, 0.08079406f, 0.06543505f, -0.02918288f, -0.39196834f, -0.15581919f, -0.03864111f, 0.20570517f, 
    0.08677997f, -0.01693023f, -0.04427800f, 0.13681115f, -0.02522480f, -0.02257590f, -0.11355735f, -0.00204586f, 
    -0.01543121f, 0.02894117f, -0.09313047f, -0.16274481f, 0.02031373f, 0.22737214f, 0.13267466f, 0.00663112f, 
    -0.29810199f, -0.18102239f, -0.29241905f, 0.29358086f, 0.25716683f, 0.08865809f, -0.01766139f, 0.00843468f, 
    0.13175695f, 0.11679751f, 0.01810558f, 0.07548740f, -0.00909762f, 0.05047211f, 0.00945825f, 0.03114415f, 
    0.04933516f, 0.00063345f, -0.01330952f, -0.02079996f, -0.29365569f, 0.12151203f, 0.17585874f, -0.08909674f, 
    -0.28197682f, -0.14764705f, -0.06566209f, 0.04529563f, -0.06019096f, -0.18023193f, -0.24653870f, -0.07077112f, 
    -0.02065179f, -0.08622625f, -0.02530203f, 0.05136333f, 0.06309808f, 0.04688502f, -0.00432208f, 0.00789465f, 
    -0.18161926f, -0.05602724f, 0.00206855f, 0.06154982f, -0.12987413f, -0.06134951f, -0.03356518f, 0.01834005f, 
    -0.06171463f, 0.03303098f, 0.02532329f, 0.07229479f, 0.05135948f, 0.00959960f, 0.10068668f, -0.07449782f, 
    -0.02831947f, -0.00523206f, 0.07590191f, -0.04457735f, 0.02984267f, 0.07910371f, -0.38514641f, -0.02563159f, 
    0.06590682f, 0.04241563f, -0.03464743f, 0.09570441f, 0.03754630f, 0.16891465f, 0.04001376f, 0.08963038f, 
    -0.06087392f, 0.07311133f, -0.01380477f, 0.11819944f, -0.04882747f, 0.06328759f, -0.01579223f, -0.11629010f, 
    0.14269830f, 0.15040137f, -0.30701482f, -0.14189436f, -0.19948189f, 0.11073013f, 0.02481118f, -0.12324712f, 
    -0.02781976f, 0.00922359f, -0.01840619f, -0.00913938f, 0.15830921f, -0.02480734f, -0.08017609f, -0.02772437f, 
    0.05029298f, -0.05805796f, 0.06616849f, 0.05683805f, -0.09067708f, 0.01685135f, -0.00062270f, 0.15728059f, 
    0.11618397f, -0.13635033f, 0.11396804f, 0.00764222f, -0.32367811f, 0.17389123f, 0.06758601f, 0.01947999f, 
    -0.07493912f, 0.12742731f, 0.07866367f, -0.01538512f, -0.08418427f, -0.07245348f, -0.11876018f, 0.08518325f, 
    -0.26665843f, 0.12454338f, 0.01213898f, -0.00919112f, -0.09899908f, 0.01077178f, -0.05767782f, -0.11550175f, 
    -0.14415707f, -0.02827189f, 0.02085240f, 0.01840897f, -0.00643006f, 0.04068213f, -0.12534106f, 0.05773901f, 
    -0.10567617f, 0.13380879f, 0.12272325f, -0.10195090f, 0.03550749f, 0.26805881f, 0.13635978f, -0.14697918f, 
    -0.18163656f, 0.18183237f, -0.10504863f, -0.08868100f, 0.28156570f, -0.12972304f, -0.06346566f, 0.09228788f, 
    -0.06606384f, -0.01753034f, 0.12421451f, -0.06664358f, -0.00886782f, -0.02362548f, -0.10504881f, 0.00417101f, 
    -0.00008253f, 0.43623912f, -0.26582229f, 0.10222040f, 0.03517377f, -0.26944369f, 0.17669591f, -0.19604230f, 
    -0.07080971f, 0.16362615f, 0.03831718f, 0.02012246f, -0.00002744f, -0.05740547f, -0.01504603f, -0.05764072f, 
    0.03144056f, 0.07580704f, 0.27186614f, -0.17274417f, 0.28299081f, 0.06629100f, 0.29801849f, 0.06431252f, 
    0.25188500f, 0.09864202f, 0.07064647f, -0.02061431f, 0.23777927f, 0.00776799f, -0.02575582f, 0.03122552f, 
    -0.08210412f, -0.04918928f, 0.02063959f, 0.06616824f, 0.03269825f, 0.10502854f, -0.01083426f, 0.02195161f, 
    0.05801464f, -0.03186756f, -0.12062531f, -0.06306853f, 0.14596093f, -0.04779197f, -0.01154043f, 0.18636014f, 
    0.10807807f, -0.07478230f, -0.02068266f, 0.07957329f, 0.06274020f, -0.04345105f, 0.12152775f, 0.08880201f, 
    -0.00084833f, -0.14788409f, -0.02263809f, -0.07960502f, 0.15919149f, -0.17219783f, 0.10775077f, -0.04694793f, 
    0.03031459f, -0.20666911f, -0.07350126f, -0.05416161f, 0.04372362f, 0.07310326f, 0.08870620f, 0.01137940f, 
    -0.04051169f, -0.12384664f, -0.00759733f, 0.05195576f, -0.09081621f, 0.16564679f, 0.00110252f, -0.00356402f, 
    0.00850704f, -0.37258741f, 0.32362518f, -0.04799851f, 0.12733565f, -0.12019131f, 0.06002604f, -0.24822554f, 
    -0.04392948f, 0.12588841f, -0.09745108f, 0.02153902f, 0.03006233f, -0.02142831f, 0.08227517f, -0.02948004f, 
    0.03786780f, -0.02093375f, 0.05271675f, 0.17083232f, -0.26981521f, 0.00415110f, 0.47391942f, -0.22196026f, 
    -0.00772382f, 0.10037401f, -0.04884048f, -0.35220951f, -0.00953247f, -0.00516586f, 0.00023339f, 0.08529466f, 
    -0.03327115f, -0.04285168f, -0.04222143f, -0.15803859f, 0.07627060f, 0.09901717f, -0.00269805f, 0.00775251f, 
    0.14219019f, -0.14040597f, -0.09157373f, 0.22213979f, 0.13273624f, -0.04073934f, -0.06524831f, -0.09762166f, 
    -0.10894223f, 0.01626616f, 0.12330096f, -0.02201112f, 0.05409731f, -0.04128993f, -0.03525814f, 0.13548437f, 
    0.13018973f, -0.04892585f, 0.01135402f, 0.19105721f, -0.27967954f, -0.13605677f, 0.36444861f, -0.02744727f, 
    -0.01531223f, -0.01089633f, 0.01905083f, -0.22257096f, -0.10033917f, 0.02613351f, 0.00755321f, 0.01333611f, 
    -0.05998193f, 0.09985059f, -0.01758516f, -0.06276385f, 0.06669345f, -0.08767609f, 0.07353470f, 0.05332952f, 
    0.07644656f, 0.46600461f, 0.02265268f, -0.03317753f, 0.03518936f, -0.03710514f, -0.02824598f, -0.02748746f, 
    0.06844399f, 0.07369378f, 0.07294504f, 0.01776869f, -0.10316045f, -0.05115053f, -0.08865795f, -0.01520153f, 
    0.04487776f, 0.00886959f, 0.10904299f, 0.03041704f, -0.24136342f, -0.00690339f, 0.03766849f, -0.20826876f, 
    0.25976828f, -0.09209440f, -0.28203836f, -0.25557402f, -0.11063465f, -0.12822346f, -0.12124264f, -0.08336151f, 
    -0.15114707f, -0.03993579f, -0.09715807f, -0.06420659f, -0.08451291f, -0.00197484f, -0.14772438f, -0.06394237f, 
    0.01366049f, 0.13720877f, -0.08136126f, -0.13808917f, 0.11865640f, -0.10931335f, -0.07271891f, -0.10226178f, 
    0.14363211f, -0.02880573f, -0.02880762f, 0.01874706f, -0.09221095f, 0.01603528f, 0.04315440f, -0.05728008f, 
    -0.09914789f, -0.05375649f, -0.03081767f, 0.00711414f, 0.08881136f, 0.21344581f, 0.41292402f, 0.17757742f, 
    -0.08789116f, 0.14367652f, 0.11978007f, 0.14988144f, -0.05053318f, 0.07728658f, 0.10917354f, 0.04162835f, 
    -0.04419430f, -0.05337075f, 0.03258376f, 0.07464889f, -0.03157730f, -0.03585645f, 0.05121623f, -0.08797397f, 
    -0.04803694f, 0.06274239f, 0.00437410f, 0.01310491f, 0.03228953f, -0.00009021f, 0.03221380f, -0.04070486f, 
    0.02896057f, 0.03985934f, -0.03443273f, 0.01286234f, -0.03344030f, 0.00562841f, 0.04323373f, -0.01037371f, 
    0.03625750f, -0.06345087f, -0.06325869f, -0.05342679f, -0.03816912f, 0.01073932f, -0.04850446f, -0.03787299f, 
    0.03046609f, -0.05234592f, 0.01427387f, 0.02663373f, -0.01237137f, 0.02697515f, -0.02178876f, -0.00087666f, 
    -0.04358375f, -0.01748746f, -0.06131490f, 0.03716936f, 0.01183944f, 0.03781923f, -0.01027785f, -0.02016426f, 
    -0.00546979f, -0.02283528f, -0.01370383f, -0.03006485f, 0.02515475f, 0.03092603f, -0.02118918f, 0.01059679f, 
    0.04459471f, -0.04795098f, 0.00584376f, -0.06014773f, -0.00477484f, 0.04142810f, 0.00360682f, 0.02912979f, 
    -0.04540387f, -0.04379145f, -0.03487169f, 0.00390806f, -0.01732735f, 0.02638113f, -0.04267983f, 0.04506951f, 
    -0.02871893f, -0.01488845f, 0.00075413f, 0.04366771f, -0.05066638f, 0.00477001f, -0.03392041f, -0.01973430f, 
    -0.05790054f, -0.00274676f, 0.00045251f, 0.04513262f, 0.00351614f, -0.03867268f, 0.04273320f, 0.00880382f, 
    0.01745988f, -0.05931668f, -0.03976185f, -0.03112336f, -0.00369606f, 0.04642951f, 0.02828064f, -0.03947615f, 
    -0.01741095f, 0.03229176f, -0.00161751f, -0.03420196f, -0.06359930f, -0.06572942f, -0.00117034f, -0.05769132f, 
    -0.03880116f, 0.02338914f, 0.03434676f, -0.05891483f, -0.03182962f, 0.03212055f, -0.02032014f, -0.05195024f, 
    -0.02380903f, -0.05636056f, -0.06536952f, 0.00933829f, 0.00333896f, 0.03117203f, 0.00775010f, 0.01467017f, 
    -0.06419288f, 0.02929936f, 0.00756845f, 0.01441827f, -0.04205601f, -0.01638187f, -0.01459722f, -0.04720588f, 
    -0.02777492f, -0.05394730f, 0.02729910f, 0.05074682f, 0.03336664f, -0.02845886f, 0.03263007f, 0.03728789f, 
    0.02063505f, -0.03899959f, 0.01068889f, -0.00058799f, 0.03541361f, 0.04210130f, -0.01410991f, 0.04513168f, 
    -0.05522355f, 0.01260670f, 0.02088580f, 0.03091347f, 0.04421310f, 0.02275984f, 0.01510352f, 0.04260554f, 
    -0.01649740f, 0.05640495f, 0.04677409f, 0.03934506f, -0.03337128f, 0.00707495f, -0.00941876f, 0.04366410f, 
    -0.05230572f, -0.05806497f, -0.05177598f, -0.02743516f, -0.01486270f, 0.02371374f, -0.02365454f, 0.01348559f, 
    -0.01179612f, 0.04344628f, 0.00454162f, 0.00993325f, -0.05127207f, 0.02184747f, -0.05285256f, -0.02938799f, 
    -0.01227952f, -0.05704964f, -0.03337502f, -0.06474647f, 0.02681147f, 0.00087902f, 0.03478401f, -0.00046193f, 
    -0.01299496f, 0.01551360f, 0.00690008f, -0.03204919f, -0.05657767f, -0.00430386f, 0.04332780f, -0.04670944f, 
    0.01675135f, 0.04328154f, -0.02319065f, -0.02596898f, 0.04226527f, -0.04012106f, 0.03689890f, 0.02155772f, 
    -0.01059901f, -0.03388966f, -0.04633838f, 0.01783553f, -0.03598212f, -0.00268990f, 0.01171103f, 0.01104609f, 
    -0.01394312f, -0.03280313f, -0.01109071f, 0.02254436f, -0.04104610f, -0.02855639f, 0.03646963f, -0.03417265f, 
    0.02155284f, -0.00798971f, -0.06652256f, -0.00626756f, -0.04487088f, -0.06229305f, -0.01964500f, -0.04752305f, 
    -0.04601311f, 0.01317003f, 0.00441620f, -0.01122011f, -0.05153034f, 0.03520038f, 0.00609037f, 0.00703741f, 
    0.04373985f, 0.03419527f, 0.01813245f, -0.04906075f, -0.03766034f, 0.04114522f, 0.04312854f, -0.05826412f, 
    0.03085628f, -0.00280354f, 0.02060989f, 0.02910484f, -0.03615645f, 0.00021018f, -0.05558669f, -0.03001525f, 
    -0.00558562f, 0.03102639f, 0.04114858f, 0.01022340f, -0.01468664f, -0.05708700f, 0.04604090f, 0.01082658f, 
    -0.03417916f, 0.01703934f, -0.02046210f, -0.02400192f, -0.01826108f, 0.01497830f, -0.04240304f, -0.01576628f, 
    0.03595700f, 0.00081015f, -0.00192167f, -0.03332948f, 0.00648875f, -0.05129888f, -0.04987752f, -0.05339273f, 
    -0.04201293f, -0.05302525f, -0.03665055f, -0.04635426f, -0.03869034f, -0.02641729f, -0.02121212f, -0.01383408f, 
    0.01093412f, 0.01462872f, -0.02472898f, -0.00328691f, 0.02505648f, -0.03830804f, 0.02074276f, 0.01611806f, 
    0.00276383f, 0.01010391f, 0.01358824f, 0.01598043f, -0.02146844f, 0.01333482f, 0.02796998f, -0.00160389f, 
    -0.03803894f, -0.05263430f, -0.03234350f, -0.00997339f, 0.01115828f, 0.00445281f, -0.02796360f, 0.03617845f, 
    0.03830521f, -0.02618138f, -0.04832181f, 0.01097886f, -0.04439620f, -0.06207312f, -0.05107101f, 0.01808952f, 
    0.00583886f, -0.01660648f, -0.04475965f, 0.03479496f, -0.02178627f, -0.02621076f, -0.00364669f, -0.05344202f, 
    0.01017701f, 0.04412275f, -0.05505553f, -0.06624337f, -0.00418168f, -0.01978371f, 0.02550542f, -0.05071546f, 
    0.26299319f, 0.11453237f, 0.16134058f, -0.40837234f, 0.06914105f, 0.11891171f, 0.20778356f, -0.01082426f, 
    0.08673004f, 0.26255009f, 0.07335234f, -0.00741183f, 0.02963393f, -0.12982675f, -0.00945886f, -0.08003831f, 
    -0.06566394f, 0.01805363f, 0.01129217f, 0.02503978f, -0.12617232f, 0.00277006f, -0.30122831f, 0.24364482f, 
    -0.30121806f, 0.15690644f, -0.19012180f, 0.03513591f, -0.31483027f, -0.18053018f, 0.06739988f, 0.03881349f, 
    -0.06571539f, 0.06729938f, -0.16357903f, 0.10500101f, 0.08192766f, 0.13792896f, 0.05831664f, -0.05947174f, 
    -0.11140325f, 0.10023961f, 0.18334703f, -0.20346408f, 0.29374197f, -0.08070945f, 0.03483185f, 0.04202085f, 
    -0.09881403f, -0.20754093f, -0.00059887f, 0.08121178f, -0.03753755f, 0.09628996f, 0.08961640f, -0.08935039f, 
    0.02545161f, 0.11498632f, 0.05381477f, -0.01138813f, 0.16736606f, 0.40228826f, 0.13892281f, -0.22739543f, 
    0.01033248f, 0.00120668f, 0.02814798f, -0.15396509f, 0.07223700f, 0.06571604f, -0.09972619f, -0.08144898f, 
    -0.01798554f, -0.04676425f, -0.02589292f, -0.03581758f, 0.00685429f, -0.01612703f, 0.01772028f, -0.07664184f, 
    -0.05348979f, -0.23496556f, 0.36305350f, -0.26295766f, 0.16110142f, -0.03564809f, -0.09479573f, -0.11846551f, 
    -0.26692343f, -0.03546529f, 0.14970048f, 0.07470088f, 0.10847764f, -0.03355523f, 0.04971279f, 0.03281456f, 
    0.03156256f, 0.01106556f, 0.07688639f, 0.12538251f, 0.14709468f, 0.30405316f, 0.00901308f, -0.04914759f, 
    -0.18681194f, 0.07602283f, 0.01048721f, -0.12824692f, 0.14738636f, -0.02574226f, 0.06789408f, 0.03867134f, 
    -0.11048175f, 0.05591869f, 0.07359985f, 0.06016377f, -0.01468803f, 0.06116615f, 0.01971427f, 0.00459335f, 
    0.29467389f, -0.17076448f, -0.32291487f, -0.29480547f, -0.07360415f, 0.18665114f, 0.05750682f, 0.08961183f, 
    -0.01755231f, 0.09735334f, 0.03734735f, -0.02232075f, 0.02056900f, 0.00217961f, 0.03686581f, -0.00963648f, 
    0.08433414f, 0.04718436f, 0.11183387f, 0.11754064f, 0.22915743f, 0.18990709f, -0.06351039f, 0.15050675f, 
    -0.16155194f, -0.04287841f, -0.07641393f, 0.11163107f, 0.11881968f, -0.14514822f, 0.04247567f, -0.04865644f, 
    0.05355055f, -0.02520010f, 0.00359749f, -0.01006496f, 0.03046702f, 0.08701521f, 0.17028335f, 0.01609190f, 
    -0.35635945f, 0.28930435f, -0.07550930f, 0.29419625f, -0.09932322f, -0.05310587f, -0.08836479f, 0.05860944f, 
    -0.07884540f, -0.04208496f, 0.03728070f, -0.03169810f, 0.00033946f, 0.10132356f, 0.01520143f, 0.16542538f, 
    0.02516735f, 0.09947882f, -0.00519852f, -0.13330840f, -0.25412089f, 0.42156592f, 0.20851538f, 0.12659495f, 
    0.10733044f, -0.11950718f, 0.05559618f, 0.04861875f, -0.09404945f, -0.00047196f, 0.10769126f, -0.10909862f, 
    0.07949264f, -0.02807981f, 0.00677994f, 0.02952662f, -0.14392878f, 0.07026205f, -0.02934864f, -0.12245347f, 
    -0.17075920f, 0.01642661f, -0.13009208f, 0.31579792f, -0.09720477f, 0.16606614f, -0.00192410f, 0.00423785f, 
    -0.18280788f, 0.01122981f, 0.07095741f, -0.00237909f, -0.04889880f, 0.09795381f, -0.01675461f, 0.02290005f, 
    -0.10169422f, 0.20963827f, 0.05812068f, 0.22665377f, -0.36398488f, 0.24433094f, -0.15025146f, 0.06869188f, 
    0.13839315f, -0.06795684f, -0.02959172f, -0.14588067f, -0.02443350f, 0.07548136f, 0.08775417f, 0.00180468f, 
    -0.03498418f, 0.08326356f, -0.00804995f, 0.05108147f, 0.06383827f, -0.13504910f, -0.07093389f, -0.01302476f, 
    -0.07605591f, -0.31697410f, 0.06345787f, -0.15704842f, 0.05846626f, 0.06255256f, -0.23411088f, 0.11964995f, 
    -0.12117338f, 0.02939377f, 0.01438387f, 0.14901805f, 0.06681887f, 0.05073267f, 0.05418923f, -0.06055580f, 
    0.01626951f, 0.13136110f, 0.03751731f, 0.08140676f, -0.17289466f, 0.23054115f, 0.07846911f, 0.04037281f, 
    -0.03292405f, -0.09380189f, -0.07118744f, 0.02635104f, 0.04845424f, -0.26654148f, 0.09569041f, 0.00524298f, 
    -0.07246449f, 0.14001633f, -0.03603587f, 0.01127657f, -0.04392884f, -0.01452325f, 0.08003524f, -0.08219798f, 
    0.14929260f, -0.16414276f, -0.01201717f, -0.16497143f, -0.06907921f, 0.01511043f, -0.21779278f, -0.04681746f, 
    -0.11854513f, -0.19374752f, 0.04691505f, 0.02094844f, 0.00375748f, 0.11770424f, 0.16044681f, -0.01471591f, 
    0.04132455f, 0.03344922f, 0.12224199f, -0.00663825f, 0.15629801f, 0.03046959f, -0.09169117f, -0.18445352f, 
    -0.01050337f, 0.03689302f, -0.01803407f, 0.04266240f, 0.05008908f, 0.24681470f, -0.01359503f, 0.01334751f, 
    0.01234163f, -0.01532952f, 0.03035928f, 0.01807722f, 0.03058009f, 0.03390772f, 0.06057265f, 0.03271902f, 
    0.09071253f, 0.17426191f, 0.15004386f, -0.01490852f, -0.14897946f, 0.10985655f, 0.05844040f, 0.15487824f, 
    -0.05549233f, 0.19207998f, 0.00308915f, 0.13043447f, 0.01342982f, 0.13577464f, -0.00707248f, 0.04070942f, 
    -0.06494421f, -0.04934812f, 0.02869458f, 0.04932927f, -0.61987936f, -0.34779587f, 0.16685526f, 0.20324120f, 
    -0.11210336f, 0.00544894f, -0.06433877f, -0.08683457f, -0.07608477f, -0.07382961f, -0.11390048f, -0.07688581f, 
    -0.07943827f, 0.05545503f, 0.08461644f, 0.08445991f, 0.06103303f, 0.01939601f, 0.00587521f, -0.11412606f, 
    -0.21424827f, -0.42478743f, -0.44564506f, -0.06704875f, 0.10085205f, -0.17959704f, -0.01191707f, -0.15745026f, 
    -0.04221149f, 0.02052180f, -0.02924404f, 0.10041795f, -0.26055375f, -0.05835769f, 0.07567088f, 0.03353533f, 
    -0.00691781f, -0.00328900f, 0.00163455f, 0.09187481f, 0.03392739f, 0.08207592f, 0.23634855f, -0.10097317f, 
    -0.10795905f, -0.05635711f, 0.02515909f, 0.07944778f, 0.00273143f, -0.09340037f, 0.02663159f, 0.07106207f, 
    0.17592028f, 0.02598023f, -0.08455714f, 0.16889894f, -0.01680370f, -0.23610474f, -0.03565674f, 0.11984994f, 
    -0.54275739f, 0.24067478f, 0.27917996f, 0.19264019f, 0.04946845f, -0.17609715f, -0.04246146f, -0.13615720f, 
    0.18734410f, -0.10147990f, 0.05922804f, -0.09192403f, 0.12275029f, -0.15633176f, -0.00087971f, 0.11359825f, 
    -0.01968577f, -0.18499702f, 0.01689965f, 0.16331646f, 0.00979435f, 0.02401953f, 0.18423751f, 0.39012203f, 
    -0.01955435f, -0.07513620f, 0.14523964f, 0.03850655f, 0.24013187f, -0.03774394f, 0.07652796f, 0.01487688f, 
    -0.07193560f, -0.00679404f, 0.01146472f, 0.05626674f, -0.04195972f, 0.14399843f, -0.06061764f, 0.17778213f, 
    0.31321868f, 0.25813213f, 0.40921894f, 0.09794994f, 0.09764096f, -0.01549216f, -0.14447944f, -0.16035984f, 
    0.11141909f, -0.07576414f, -0.05226726f, -0.09789079f, 0.12911505f, 0.10394215f, 0.10311649f, 0.02179907f, 
    0.04891474f, 0.14756040f, -0.03113603f, 0.09004147f, -0.10804453f, -0.19831143f, 0.02484957f, 0.04682587f, 
    0.00532994f, -0.03160546f, -0.14462890f, -0.13551383f, -0.22453228f, -0.13669522f, 0.09857394f, 0.14023703f, 
    -0.20600976f, -0.08658256f, -0.01146313f, 0.01824809f, 0.01359685f, 0.25189075f, 0.03004296f, 0.04326261f, 
    -0.32043114f, -0.19639593f, -0.32700691f, 0.15219662f, 0.03687454f, -0.07947676f, -0.09880599f, -0.04224659f, 
    -0.06128822f, -0.07080908f, -0.04847711f, 0.04585020f, -0.06150715f, -0.06653842f, -0.04348462f, 0.09165458f, 
    0.06730160f, 0.24865599f, 0.05311135f, -0.08816507f, -0.23370460f, 0.10390152f, -0.13294031f, 0.29158625f, 
    0.07029925f, 0.02535080f, 0.03934895f, 0.06766304f, -0.04953408f, 0.16443767f, 0.05303502f, 0.07179794f, 
    -0.00334985f, -0.05935210f, 0.06010785f, 0.09071570f, -0.14458933f, 0.03840258f, -0.07403281f, 0.19543599f, 
    -0.08251881f, -0.00380599f, -0.05408831f, -0.06433412f, -0.15707518f, 0.03721237f, -0.07865588f, 0.00321565f, 
    -0.00718121f, 0.16230011f, 0.14586584f, 0.04689654f, 0.08291939f, 0.04053639f, 0.08795138f, -0.04153527f, 
    -0.00180980f, 0.01457151f, 0.32141098f, -0.03106320f, 0.10562498f, -0.03610442f, -0.41440743f, -0.09044176f, 
    -0.15566698f, -0.09405825f, 0.04732158f, 0.13028274f, -0.20765640f, 0.08182313f, -0.02980785f, 0.02690752f, 
    -0.01456634f, -0.03912398f, 0.01626225f, -0.01103781f, -0.02242203f, -0.00120495f, -0.01088801f, 0.02582176f, 
    -0.15621409f, 0.23335494f, 0.17226389f, 0.05018246f, -0.14274515f, -0.05983638f, -0.18424791f, -0.04514018f, 
    0.14765806f, 0.01721538f, -0.03371734f, 0.05036172f, -0.05724093f, -0.09417802f, 0.07479839f, -0.00707208f, 
    0.01668584f, 0.06219063f, 0.19868159f, 0.07352915f, -0.17751388f, -0.38493571f, -0.16836743f, -0.36798182f, 
    0.05781532f, 0.08322829f, -0.09166542f, 0.15625310f, -0.10014283f, 0.00209649f, -0.04127055f, -0.01105857f, 
    -0.03375477f, -0.07263433f, 0.01736543f, 0.01535049f, -0.15067859f, 0.14574166f, 0.04073735f, -0.00340067f, 
    0.04538460f, 0.03490333f, 0.00062668f, 0.03713597f, 0.11552174f, -0.04774695f, -0.15714516f, -0.19633007f, 
    0.03530525f, -0.09832641f, -0.01952464f, -0.06690913f, -0.13089664f, 0.05791504f, 0.11188545f, -0.01363988f, 
    -0.04414554f, 0.08555882f, 0.11771716f, 0.09954172f, -0.04964314f, 0.16666508f, 0.26615763f, 0.03835084f, 
    -0.10053404f, 0.00908969f, 0.01805013f, -0.00565400f, -0.06256250f, 0.04975784f, 0.05321464f, 0.04529247f, 
    0.09019326f, -0.06127219f, -0.03801018f, -0.01824045f, 0.10822516f, -0.03875289f, 0.06151660f, -0.01298580f, 
    0.14186344f, 0.27034763f, 0.16535529f, -0.17934920f, 0.26008621f, 0.10657020f, 0.10676929f, 0.10055813f, 
    0.01430584f, 0.21645930f, 0.12002482f, -0.01702295f, -0.05113988f, 0.04375597f, 0.01841036f, -0.04721565f, 
    -0.03330541f, 0.02125661f, 0.13960584f, 0.02118791f, -0.06770417f, -0.06622028f, 0.19166835f, 0.05921499f, 
    -0.26059151f, 0.07888041f, -0.02130998f, -0.12088614f, -0.01760819f, -0.35713661f, 0.00728942f, 0.03082711f, 
    -0.04622341f, 0.07775906f, 0.02694520f, 0.14701025f, -0.00081365f, -0.03184380f, 0.03407571f, -0.16758606f, 
    -0.06291743f, 0.11288334f, 0.11939039f, 0.17756799f, 0.05581696f, -0.08247801f, -0.01636429f, -0.07746105f, 
    -0.09636179f, -0.16639182f, -0.06501801f, 0.06506261f, 0.01815930f, 0.12546100f, 0.06254867f, -0.10947499f, 
    -0.02148577f, 0.05116270f, 0.02604363f, 0.03514083f, 0.22877721f, 0.44520390f, -0.04467048f, -0.14435700f, 
    0.03156594f, -0.13384250f, 0.12528585f, -0.02034187f, -0.02461441f, 0.24068862f, -0.15004763f, -0.11978581f, 
    0.06686269f, -0.05721072f, -0.09708630f, -0.00047815f, -0.06311025f, 0.06483795f, -0.00439465f, 0.00393374f, 
    -0.45159951f, -0.27414331f, 0.33224410f, 0.15310493f, 0.26459375f, -0.00478323f, 0.01831600f, 0.01641478f, 
    0.02068060f, 0.00080438f, 0.13040628f, 0.01434815f, 0.07758267f, -0.10417216f, 0.07231061f, -0.08070392f, 
    0.13642058f, -0.12026626f, 0.05300858f, 0.03678209f, 0.36613008f, 0.24603178f, 0.04104554f, -0.32774076f, 
    -0.06109337f, 0.00302133f, 0.08910499f, -0.01967312f, 0.12494747f, -0.07217401f, 0.03319023f, -0.04974807f, 
    -0.00923179f, 0.09209768f, -0.03220403f, -0.05441827f, -0.06808300f, -0.08528754f, 0.13287747f, -0.00727433f, 
    0.27780101f, 0.04340824f, -0.31834927f, -0.29292330f, 0.05774714f, 0.22832216f, -0.01415134f, 0.08763462f, 
    -0.11915091f, 0.08378471f, -0.02199767f, -0.02020319f, -0.06426346f, -0.09116358f, -0.00255517f, -0.03566620f, 
    0.00150240f, -0.06462774f, 0.01273997f, 0.02865997f, 0.13898395f, 0.15226853f, -0.01117936f, 0.15578794f, 
    -0.25332409f, 0.04998260f, 0.00839999f, 0.12320393f, 0.14295140f, -0.11287382f, -0.04951689f, -0.00326313f, 
    0.06243864f, 0.11841696f, -0.01970650f, -0.03028552f, -0.02875141f, 0.04677785f, 0.02425413f, 0.02539510f, 
    -0.28055033f, 0.11274612f, 0.10279354f, 0.17535445f, -0.17237757f, -0.11724521f, -0.14174701f, -0.03232691f, 
    -0.10204308f, -0.09479517f, -0.05590066f, -0.02440824f, -0.03887680f, 0.08027737f, -0.05493652f, 0.00906822f, 
    0.07278593f, -0.03314286f, -0.05468661f, -0.10277431f, -0.05700074f, 0.18108104f, 0.14360385f, 0.05180016f, 
    0.00686910f, -0.17419983f, 0.05867923f, 0.10974690f, -0.07638060f, -0.05039768f, 0.08076395f, -0.07614085f, 
    0.02868557f, -0.13849513f, -0.03015110f, 0.10016084f, -0.02053032f, -0.00225096f, 0.04054499f, 0.08095307f, 
    -0.23081356f, -0.05048143f, 0.05275789f, 0.21279754f, -0.24317066f, -0.02334205f, -0.06461136f, -0.08799557f, 
    0.01587630f, -0.08067308f, 0.10406774f, 0.00767307f, -0.08441956f, 0.03776041f, 0.09728440f, -0.00232545f, 
    -0.04452902f, 0.02110725f, 0.06744265f, -0.08851352f, -0.35481858f, -0.04329861f, -0.22153088f, 0.25606522f, 
    -0.01033944f, 0.01456533f, -0.03687695f, 0.14946666f, -0.05022535f, -0.04377035f, -0.01833222f, 0.10003342f, 
    -0.07984616f, -0.03815987f, -0.00119116f, -0.09647593f, -0.00989572f, 0.14090569f, -0.06918980f, -0.10767607f, 
    -0.18896845f, -0.08049392f, -0.41271231f, 0.23982300f, 0.16869286f, 0.13144425f, -0.05721776f, 0.11523236f, 
    0.04100991f, 0.12304646f, -0.03384764f, 0.08374499f, 0.05910176f, -0.03773247f, 0.12286396f, -0.06046150f, 
    0.01115815f, 0.04230033f, 0.05607199f, 0.02274217f, -0.08057037f, 0.15894102f, 0.10255861f, -0.00891671f, 
    -0.23551771f, -0.12119088f, -0.12535362f, 0.00333821f, 0.06342310f, -0.20916107f, -0.19200952f, -0.04763784f, 
    -0.08197686f, -0.08259743f, -0.03770113f, -0.04235125f, -0.06728473f, -0.09407987f, -0.15212035f, 0.02882867f, 
    -0.00880269f, -0.10830955f, -0.21051250f, 0.06158088f, -0.24524009f, 0.02385655f, -0.11873611f, -0.00363729f, 
    -0.06864804f, -0.02693064f, -0.02672498f, 0.02127280f, -0.07899542f, 0.02163837f, 0.09576379f, -0.12805325f, 
    -0.07376698f, -0.05569651f, -0.02205818f, -0.01032419f, 0.11084566f, 0.09664959f, -0.30156025f, -0.13342428f, 
    0.07111527f, -0.02976044f, -0.02106403f, 0.15144613f, 0.05667644f, 0.05919371f, -0.10228509f, -0.03587868f, 
    -0.09543224f, -0.00216170f, 0.03745031f, 0.04977224f, -0.12045620f, 0.07441620f, 0.03581706f, -0.05178065f, 
    0.10195406f, -0.26077324f, -0.14233355f, 0.20322891f, -0.31255645f, -0.08048914f, -0.04914437f, 0.18083481f, 
    -0.09013864f, 0.03154420f, -0.05575636f, 0.00142649f, -0.11867889f, -0.07404061f, 0.00462857f, 0.02227508f, 
    0.07035924f, 0.00308287f, -0.02384801f, 0.00158423f, -0.13091157f, -0.02755571f, -0.03225148f, -0.02817538f, 
    0.07176542f, 0.08788644f, -0.04943920f, -0.04880696f, 0.07423954f, 0.09818412f, 0.00959571f, -0.05493403f, 
    0.15998483f, -0.14592606f, 0.06788600f, -0.01060864f, 0.11556294f, -0.02706585f, -0.05402026f, 0.02530016f, 
    0.01844070f, -0.33733845f, -0.37024948f, -0.10709618f, 0.08216366f, -0.04268542f, 0.02672462f, -0.08442535f, 
    0.01971702f, 0.06637985f, 0.04112472f, -0.08279474f, -0.10892073f, -0.05899555f, -0.06320651f, 0.10217301f, 
    0.05075099f, -0.01390055f, -0.09768046f, -0.06904095f, -0.25898284f, -0.38159084f, 0.19193274f, 0.04767933f, 
    0.05919394f, 0.02378950f, -0.09312059f, 0.24095435f, 0.03030706f, -0.06841788f, 0.13485688f, 0.04523553f, 
    0.01097743f, 0.00736053f, 0.01636001f, 0.11533424f, -0.05130054f, 0.01608023f, 0.09902500f, 0.07096035f, 
    0.05784873f, 0.02222149f, -0.12435041f, -0.05076954f, -0.15884654f, 0.08840128f, -0.05027108f, -0.29986000f, 
    0.10589417f, -0.04626128f, 0.08596074f, -0.03516310f, 0.04757971f, 0.09078928f, 0.02599369f, 0.17508414f, 
    -0.03553507f, 0.02547132f, 0.08255962f, 0.01533315f, -0.47714838f, -0.11234885f, 0.07938673f, 0.40031573f, 
    -0.07060720f, 0.02584804f, -0.04732913f, 0.08818395f, 0.14496699f, 0.09446190f, 0.02927800f, -0.01697066f, 
    0.06438980f, -0.00924558f, 0.06608487f, 0.04672921f, 0.11408085f, 0.06453541f, -0.04803089f, 0.11998809f, 
    -0.36704051f, 0.06897217f, 0.42426565f, 0.12504488f, -0.11552360f, -0.18063393f, 0.01808950f, -0.20604205f, 
    0.01206496f, -0.00498404f, 0.01975508f, -0.01745814f, 0.12105875f, 0.02999158f, -0.04615292f, 0.00920564f, 
    0.04492185f, 0.07216044f, -0.08145137f, 0.03560744f, -0.29548389f, -0.16193350f, -0.04728995f, -0.12791397f, 
    0.23431817f, -0.05696356f, -0.11455969f, -0.25985178f, -0.11134249f, -0.12730967f, 0.01876045f, 0.00449587f, 
    0.00286748f, -0.01656691f, 0.00641097f, -0.00245647f, 0.04474301f, 0.21104227f, -0.07585091f, -0.02841403f, 
    0.09934181f, 0.01712925f, -0.29491940f, -0.06570596f, 0.23825131f, 0.15006104f, 0.12164588f, 0.06338526f, 
    0.01799100f, 0.03893997f, 0.01854757f, 0.00145113f, -0.01985938f, -0.12798932f, -0.02765190f, 0.06986594f, 
    0.02739156f, 0.12479828f, 0.07799344f, 0.02665855f, 0.20146844f, -0.06233723f, -0.20980728f, 0.18846744f, 
    0.14968489f, 0.22039728f, 0.00202533f, 0.02184839f, 0.09244240f, 0.11632974f, -0.04913916f, 0.08076812f, 
    -0.09261781f, 0.03853309f, -0.06501926f, 0.04356988f, -0.05055164f, 0.01259837f, 0.06765427f, 0.02820035f, 
    0.14038298f, -0.00648628f, -0.05283711f, -0.25963926f, 0.10468366f, -0.06519242f, -0.09991176f, -0.09421296f, 
    -0.04403106f, 0.23433107f, 0.00937084f, 0.01851808f, 0.04305786f, 0.03628981f, 0.00005152f, -0.00595358f, 
    0.02677240f, 0.06580787f, 0.04625655f, 0.16153279f, 0.46116543f, 0.12934302f, -0.09076276f, -0.23690507f, 
    0.02179688f, -0.07898341f, 0.17974180f, -0.06491791f, 0.06455463f, 0.13698034f, 0.08408751f, -0.01264431f, 
    0.04669415f, -0.02524591f, 0.05940308f, 0.14871222f, 0.18096991f, -0.01048416f, 0.08340894f, 0.04779597f, 
    0.07880040f, -0.01785755f, 0.42744094f, -0.23808612f, -0.18829826f, 0.03160476f, 0.07157277f, -0.30556691f, 
    0.14328280f, 0.02399204f, 0.01719715f, 0.07125933f, -0.00743585f, 0.05637440f, -0.03827797f, 0.05472933f, 
    -0.01820996f, -0.00460094f, -0.00782493f, -0.08228803f, -0.13192715f, -0.24657986f, -0.20712110f, -0.01470840f, 
    0.10833240f, 0.01398536f, 0.03032216f, 0.04054936f, -0.00745151f, 0.06387296f, 0.04528501f, -0.01017508f, 
    0.05929459f, 0.10485314f, 0.00094206f, 0.12763657f, 0.02791354f, 0.06561865f, 0.06956566f, -0.07878964f, 
    -0.05934467f, -0.10259582f, 0.08470938f, 0.05892631f, 0.14097649f, 0.12087723f, 0.04273337f, -0.19152528f, 
    -0.08514443f, -0.03667679f, 0.10977145f, 0.05566910f, 0.18688682f, 0.10967036f, 0.04687735f, -0.04547904f, 
    -0.05257173f, 0.07438781f, -0.07936110f, 0.02087210f, -0.05977215f, 0.08289365f, 0.06037912f, 0.09919050f, 
    0.00133614f, 0.02910060f, 0.13298532f, -0.12364066f, 0.15988420f, 0.04979529f, 0.08930989f, 0.00212696f, 
    0.08802018f, 0.06070299f, 0.02571467f, -0.03406570f, 0.08613139f, -0.03327106f, -0.00520935f, 0.05378893f, 
    0.37760508f, -0.34656826f, -0.11753631f, 0.05740540f, 0.01951214f, 0.03920571f, 0.04389954f, 0.00829188f, 
    0.06987918f, 0.01520036f, -0.00847133f, -0.03418871f, -0.17271125f, -0.14582986f, -0.01407750f, 0.04276824f, 
    0.06364608f, 0.08746700f, 0.19610539f, 0.00537528f, 0.02024053f, 0.19585937f, -0.25710681f, 0.07515638f, 
    -0.01684085f, 0.06517592f, -0.16199039f, 0.05683194f, 0.18753356f, -0.05938912f, 0.06831004f, -0.03108935f, 
    -0.00661736f, -0.15683417f, -0.03199895f, 0.03688410f, 0.15244150f, -0.01706894f, 0.20514154f, 0.14188032f, 
    -0.23191646f, -0.12244803f, -0.20505048f, -0.25565585f, 0.21746446f, 0.00294560f, 0.07097787f, -0.06860944f, 
    -0.01389932f, 0.08229988f, -0.02314966f, 0.05741020f, -0.08412481f, -0.02054754f, -0.01885330f, -0.07338398f, 
    0.08901639f, -0.06684272f, -0.21918890f, 0.11394224f, -0.03358506f, -0.12535790f, 0.13862173f, -0.10716525f, 
    0.12195259f, -0.08619130f, 0.13176823f, 0.15508744f, -0.09995224f, -0.10486547f, 0.05045644f, -0.03633193f, 
    -0.01105566f, 0.02766356f, -0.05969913f, 0.16128360f, 0.01317743f, 0.09454809f, 0.13213074f, -0.13238834f, 
    -0.25062063f, -0.07066710f, 0.12734619f, -0.09924391f, 0.03545496f, 0.12151940f, -0.02400776f, -0.03688712f, 
    0.00759990f, -0.04117080f, 0.16212325f, -0.08245206f, 0.23311383f, 0.03047025f, 0.11365426f, 0.03712836f, 
    0.08882716f, -0.12855458f, -0.00146073f, 0.09580367f, -0.02271366f, 0.22492367f, -0.15520266f, 0.20949604f, 
    -0.24738407f, -0.00406271f, -0.05024296f, -0.06685898f, 0.16916767f, 0.11284004f, 0.02584497f, -0.04838479f, 
    0.03885185f, 0.04699946f, 0.04956134f, -0.03167327f, -0.08809722f, -0.04386624f, 0.08012372f, 0.04915157f, 
    -0.26519570f, 0.14713028f, 0.36623025f, -0.20334297f, -0.05840138f, -0.03343405f, 0.05223850f, -0.12717523f, 
    0.14232115f, 0.24918847f, 0.11820678f, 0.03573119f, -0.12916723f, -0.10651829f, -0.10978187f, -0.10120854f, 
    0.12817195f, 0.07346166f, -0.01443897f, 0.04599098f, -0.15752566f, 0.27256155f, 0.13865994f, -0.07671896f, 
    0.06533267f, 0.05902568f, -0.05810094f, -0.15341219f, -0.06222684f, -0.14701888f, 0.05677522f, 0.13528927f, 
    0.10736795f, 0.07698990f, 0.00830783f, -0.16676334f, 0.00863693f, 0.09334876f, -0.00370721f, 0.06659506f, 
    -0.20806596f, 0.31073111f, -0.35818785f, 0.05315140f, 0.08471200f, 0.05259188f, 0.09478545f, 0.22969145f, 
    0.10176685f, 0.06268907f, 0.01841103f, 0.02411988f, -0.01860840f, -0.09497696f, -0.08405431f, 0.11768595f, 
    -0.06962250f, 0.08359343f, 0.00529241f, -0.13853450f, 0.02616670f, 0.08364210f, -0.41855484f, 0.35474885f, 
    0.21047440f, 0.06654686f, 0.19827014f, 0.26119933f, -0.01107007f, 0.04664732f, 0.04432609f, -0.03458877f, 
    -0.07846497f, -0.02727777f, -0.06032209f, 0.05191774f, -0.24959017f, -0.07510714f, -0.09701516f, -0.17019632f, 
    -0.29227713f, 0.00118682f, -0.25336584f, -0.09000656f, -0.04068280f, 0.01638313f, -0.01101132f, 0.01337661f, 
    -0.08491529f, 0.17639235f, -0.03138135f, 0.16603181f, -0.08984471f, 0.22927363f, 0.06747802f, 0.01245521f, 
    -0.14486372f, 0.13044319f, 0.04095234f, 0.11491855f, 0.10393013f, 0.25769928f, -0.23275985f, -0.04727730f, 
    0.14954388f, -0.07483843f, 0.18230276f, 0.15471382f, -0.01947636f, 0.02437367f, 0.07899959f, -0.01888091f, 
    0.07237278f, -0.08900574f, -0.02002523f, 0.00762184f, 0.01142095f, 0.06096249f, -0.02439931f, -0.03949322f, 
    -0.35323042f, -0.11707015f, 0.50974488f, -0.20830840f, 0.23627834f, 0.03145872f, -0.04824847f, -0.04418756f, 
    0.13753287f, 0.07136329f, -0.04027400f, 0.06244174f, 0.05383631f, -0.01924041f, 0.00756583f, -0.06325746f, 
    -0.00822845f, 0.00905167f, 0.00885695f, -0.04489051f, -0.17154290f, -0.10646352f, -0.10426085f, -0.10462411f, 
    -0.07673586f, 0.02053940f, 0.12565012f, 0.04449684f, -0.00835758f, 0.02382453f, 0.03749171f, 0.06020594f, 
    0.07146005f, 0.06885998f, 0.09347177f, 0.07658711f, 0.10999370f, -0.02689879f, -0.00288757f, 0.00685219f, 
    -0.08718503f, -0.00605989f, 0.22790727f, -0.02700048f, 0.05803143f, 0.04205823f, 0.00016016f, -0.07980179f, 
    -0.06866299f, 0.06317091f, 0.11190014f, 0.01202234f, 0.10390326f, 0.07212855f, 0.08374831f, 0.02772825f, 
    0.07995634f, 0.00364851f, 0.13445573f, 0.06789733f, 0.01490674f, 0.04776791f, -0.27730367f, -0.05232665f, 
    0.25373518f, -0.09383754f, -0.01215906f, -0.11533560f, 0.10271113f, 0.11779498f, -0.00467832f, 0.01123585f, 
    -0.05047397f, 0.09400272f, -0.03346828f, 0.08056629f, 0.02018145f, 0.15701973f, 0.00297226f, -0.01224931f, 
    0.17009780f, 0.16966151f, -0.36040673f, -0.24783556f, -0.05965770f, 0.03753809f, 0.06049808f, -0.09689111f, 
    0.07293346f, 0.03488726f, 0.02152440f, -0.11012377f, 0.12594925f, -0.01684760f, -0.08053570f, 0.13674660f, 
    0.20004824f, 0.10025579f, -0.15428527f, 0.19830696f, 0.14792655f, 0.18068002f, -0.08103681f, -0.00357417f, 
    -0.01478092f, -0.03883886f, -0.00156375f, -0.02453470f, -0.33103454f, 0.02943835f, 0.09709312f, 0.06262805f, 
    -0.07123914f, 0.15715019f, -0.10065821f, 0.00149780f, 0.00956235f, 0.02146952f, -0.01727100f, 0.09402326f, 
    -0.32137015f, 0.24429639f, -0.08376489f, -0.12767680f, 0.10799939f, -0.03036928f, 0.06234211f, 0.00920369f, 
    -0.18922910f, -0.16092058f, -0.01755432f, -0.09911790f, -0.05894285f, 0.12737085f, -0.10457679f, 0.05966548f, 
    -0.08610519f, 0.28076842f, 0.06290234f, -0.17942168f, -0.02998230f, 0.20946553f, 0.07354886f, -0.14503248f, 
    -0.13218093f, 0.03129121f, -0.02219950f, -0.04660583f, 0.18783616f, -0.08380356f, 0.10248055f, 0.09852921f, 
    0.08606409f, -0.05915141f, 0.12839799f, -0.17304564f, 0.01248557f, -0.16629243f, -0.19271477f, -0.27308941f, 
    0.26907355f, 0.29322582f, -0.35668513f, -0.17063260f, -0.01805616f, -0.15582769f, 0.15029044f, -0.31061864f, 
    -0.34691080f, 0.13323852f, 0.02458712f, 0.17209943f, -0.06735618f, 0.03016409f, 0.05591649f, 0.02197943f, 
    0.05473448f, 0.05540616f, 0.20411269f, 0.02649151f, -0.02352717f, 0.20368762f, 0.24342819f, 0.00799465f, 
    0.05058447f, 0.15160075f, -0.03670254f, -0.08238129f, 0.19862385f, 0.04244120f, 0.11505927f, 0.08965513f, 
    -0.05292432f, 0.02595874f, 0.13259932f, 0.15003783f, 0.11935563f, 0.04342801f, -0.02885602f, -0.03344274f, 
    -0.36952791f, -0.29841003f, -0.38126567f, -0.14711040f, -0.04043264f, 0.03152080f, 0.18952167f, 0.05823043f, 
    0.08134560f, 0.03825197f, -0.06938841f, -0.01017665f, 0.09397718f, 0.08527564f, 0.08559672f, -0.00386369f, 
    0.04070826f, -0.14549346f, 0.17839350f, 0.02511956f, 0.23355228f, -0.11189102f, -0.03932527f, -0.09737790f, 
    -0.02394527f, -0.16973379f, -0.02313449f, -0.01605517f, 0.01228285f, -0.16916405f, -0.00040026f, -0.01959308f, 
    0.00782149f, 0.01270607f, 0.02987968f, 0.13631599f, -0.01098138f, 0.09346430f, -0.05919930f, -0.16965416f, 
    -0.11044205f, 0.04851137f, 0.17160206f, -0.13679177f, 0.07172458f, -0.07496574f, 0.13178439f, -0.12549612f, 
    0.03657664f, 0.03070254f, -0.14116760f, -0.02598083f, 0.04384670f, 0.14893566f, -0.00208476f, -0.03053552f, 
    0.09150986f, -0.13306645f, 0.16517444f, 0.08686908f, -0.17667338f, -0.11975980f, 0.27921289f, -0.13250421f, 
    -0.07160591f, 0.09910305f, -0.02896252f, -0.25710410f, 0.06467614f, 0.02658116f, -0.03458906f, -0.00660089f, 
    0.00132912f, 0.05976195f, 0.00410604f, -0.16645874f, 0.00450920f, 0.00670587f, 0.06533457f, -0.10227510f, 
    0.12857422f, -0.27484268f, -0.14981288f, 0.15794800f, -0.02078458f, 0.05279028f, 0.02273770f, -0.07726895f, 
    -0.16304338f, 0.03641019f, 0.02747254f, -0.02488336f, -0.07407552f, -0.04711308f, -0.04642168f, 0.20926727f, 
    0.06941682f, 0.05309347f, 0.02423003f, 0.23392877f, -0.38580960f, 0.03304468f, 0.28455132f, 0.02601175f, 
    -0.02251054f, 0.00162702f, 0.12176535f, -0.28443897f, -0.03938814f, -0.07035030f, 0.11889039f, -0.05741672f, 
    -0.04738794f, 0.08106480f, 0.04216272f, -0.01572635f, 0.09111726f, -0.04971115f, 0.04752459f, -0.02464674f, 
    0.24869676f, 0.17481270f, -0.20116630f, -0.00344657f, -0.08520681f, -0.00998149f, 0.15803568f, -0.07568486f, 
    -0.06730309f, 0.19055294f, 0.17371184f, 0.04218259f, 0.10076095f, 0.03071630f, -0.03709634f, 0.05264891f, 
    -0.05331801f, -0.04416258f, 0.02243642f, 0.05504820f, -0.19496290f, 0.08544277f, -0.10761760f, 0.06156395f, 
    0.08979670f, -0.21336499f, -0.07688423f, -0.29264727f, 0.02088762f, -0.07650166f, -0.09292682f, -0.05837110f, 
    -0.13061032f, 0.11535884f, -0.13203540f, -0.05280266f, 0.10124021f, -0.02953609f, 0.16700685f, -0.01986744f, 
    0.06209423f, -0.17290698f, -0.20525101f, -0.05941552f, -0.02385629f, 0.02726264f, 0.10307921f, -0.11306141f, 
    -0.09363370f, -0.08962262f, 0.06256551f, 0.05472696f, 0.14074253f, 0.05580807f, 0.08167332f, -0.03884233f, 
    -0.02993794f, -0.01586460f, 0.04881537f, 0.07084583f, 0.20778656f, 0.22691683f, 0.13311259f, 0.11289536f, 
    0.02537960f, 0.17435175f, -0.00609062f, 0.12736197f, -0.00011021f, 0.16493960f, 0.08249002f, -0.00734048f, 
    0.07309515f, -0.11438316f, 0.02101585f, 0.12210638f, -0.05398356f, 0.02294030f, -0.00961273f, -0.09772629f, 
    0.03278194f, 0.03932440f, -0.05754341f, -0.04285720f, -0.05860599f, -0.01936847f, -0.03674478f, -0.03839090f, 
    0.01130593f, -0.06355061f, 0.04559112f, 0.01073925f, 0.03785902f, -0.01764345f, 0.01550096f, 0.01814374f, 
    0.04571215f, -0.03537723f, 0.03167771f, -0.06205089f, 0.01299743f, -0.03593093f, 0.03445232f, 0.00506439f, 
    -0.00249262f, -0.05145139f, -0.03213904f, 0.03003928f, -0.03294786f, 0.01171620f, 0.01975707f, -0.04200645f, 
    -0.02468077f, -0.04387999f, -0.02046896f, 0.04232642f, 0.01754265f, -0.05971308f, 0.04259222f, 0.05210062f, 
    0.03330180f, -0.04822192f, -0.04115556f, -0.03365823f, 0.02269058f, -0.05822804f, -0.01235077f, 0.01941926f, 
    -0.05125987f, -0.00071969f, -0.01702822f, -0.01828720f, -0.01437983f, -0.03333326f, -0.04642131f, -0.05548216f, 
    0.03065744f, 0.04386922f, 0.00129541f, 0.02846938f, 0.02231691f, -0.01778973f, -0.02745925f, 0.03396126f, 
    -0.01780009f, -0.05511636f, -0.06076672f, 0.03761503f, 0.04436786f, -0.06355309f, -0.01726396f, -0.01599249f, 
    0.02744580f, -0.03465270f, -0.06257800f, -0.05171185f, -0.04878446f, 0.01584788f, 0.02192804f, -0.01683069f, 
    -0.05235169f, 0.02442140f, -0.04492862f, -0.00346939f, -0.01965344f, 0.02337048f, 0.02753825f, 0.00452719f, 
    0.02597419f, -0.04771056f, -0.05451843f, 0.02642054f, -0.02673138f, -0.04369041f, -0.02013391f, -0.01481657f, 
    -0.04240940f, 0.03074968f, -0.03508682f, -0.04168761f, -0.00928135f, 0.04242372f, -0.01031295f, -0.03606150f, 
    -0.02024783f, 0.00923127f, -0.05641657f, 0.00749253f, 0.01834985f, -0.05577742f, -0.05607707f, -0.00859309f, 
    -0.01576602f, 0.04114297f, -0.00438888f, -0.01171893f, 0.03429166f, 0.03968867f, -0.02984549f, -0.02281712f, 
    0.02215514f, -0.04164223f, -0.02524498f, 0.05016908f, -0.04060657f, -0.00934941f, 0.00423318f, 0.02245534f, 
    -0.00935750f, -0.01993738f, -0.00151159f, -0.03609532f, 0.01112195f, 0.04191842f, -0.05389068f, -0.02266346f, 
    0.00092186f, -0.01976858f, -0.05952397f, 0.04579666f, -0.00608834f, -0.03362004f, -0.04033009f, 0.00992634f, 
    -0.03869364f, 0.03966757f, 0.03585635f, -0.04135887f, -0.01031888f, -0.05744252f, -0.00621043f, 0.03053415f, 
    -0.01856678f, -0.01837160f, -0.04236458f, -0.06460805f, 0.03628201f, 0.04366205f, -0.04110852f, -0.01053532f, 
    0.01393701f, -0.01647833f, 0.03726650f, -0.06275286f, -0.04051654f, 0.01619102f, -0.04453857f, 0.04074730f, 
    -0.03166547f, -0.03699526f, -0.00572473f, 0.00547680f, -0.00352018f, -0.01632839f, 0.04260477f, 0.00733360f, 
    -0.02488429f, 0.04078439f, 0.04509102f, 0.01423897f, -0.05648045f, 0.03656921f, 0.00282725f, -0.02188756f, 
    0.02485718f, -0.01063368f, -0.02836909f, 0.00128478f, 0.03022130f, -0.04527178f, -0.01839764f, 0.01901192f, 
    -0.04043649f, -0.02638247f, 0.01842292f, 0.02099327f, -0.00697105f, 0.01485812f, 0.02846807f, 0.00924878f, 
    0.00066387f, -0.00582995f, -0.00334887f, -0.05402151f, 0.02971721f, 0.00410698f, 0.01106601f, 0.00967960f, 
    -0.04593651f, -0.05903831f, -0.05115527f, -0.01468888f, 0.00263204f, 0.02003726f, 0.00587827f, 0.03111325f, 
    -0.05340352f, -0.00578444f, -0.00793467f, -0.04998168f, -0.04661542f, -0.01644721f, -0.02677816f, 0.03791437f, 
    -0.04598252f, 0.00608029f, 0.03566053f, 0.00251576f, -0.00449921f, -0.05483092f, 0.02225785f, 0.02453442f, 
    0.02933979f, -0.02523713f, -0.01253596f, 0.00354336f, 0.01248736f, -0.02720828f, -0.03185790f, -0.04728165f, 
    0.00628001f, -0.06101020f, 0.04005636f, 0.02151304f, 0.03599888f, -0.04041672f, 0.01284248f, -0.05730982f, 
    0.01166385f, -0.01812456f, 0.03055900f, 0.00181267f, -0.05755830f, 0.02110561f, 0.01989734f, -0.02226892f, 
    0.04818581f, -0.00324703f, -0.02727812f, -0.05574151f, -0.00083016f, 0.04385405f, -0.03412611f, 0.00805708f, 
    0.02643417f, 0.03508829f, 0.02719079f, -0.03461447f, -0.02229451f, -0.04153337f, 0.01213474f, -0.02228636f, 
    0.04999096f, -0.01847635f, 0.00347510f, 0.02088108f, 0.01453296f, -0.02873373f, 0.03177786f, -0.04151733f, 
    -0.02888401f, 0.04121004f, -0.05425969f, -0.05209108f, 0.01545689f, -0.01112097f, -0.04673584f, 0.03456896f, 
    0.03212371f, 0.04428437f, -0.00663818f, 0.03129760f, 0.00328475f, -0.05758315f, 0.04630966f, 0.03001312f, 
    -0.04998827f, -0.05635919f, 0.02714277f, 0.00258410f, -0.06131339f, -0.02333477f, -0.04686093f, -0.02491538f, 
    0.03934279f, 0.03415432f, -0.06348410f, -0.03574369f, -0.05376190f, 0.04006835f, -0.04719417f, 0.01298534f, 
    -0.01668485f, 0.01982248f, 0.04246576f, -0.00443158f, -0.00841122f, -0.00775207f, -0.00076140f, -0.02674677f, 
    0.08946583f, -0.05997657f, -0.24036929f, 0.33633244f, 0.23876974f, -0.00028169f, -0.14834392f, 0.15062509f, 
    0.21948521f, 0.05131388f, -0.01852381f, 0.02576574f, -0.11167295f, 0.02950548f, 0.03393514f, -0.03019337f, 
    -0.06746092f, 0.20757513f, 0.08407879f, -0.14356104f, -0.05104249f, 0.11788924f, -0.19678226f, -0.07153626f, 
    -0.02524033f, 0.10883308f, 0.05113546f, -0.08581720f, -0.06888199f, -0.15616745f, 0.10026763f, 0.04585809f, 
    0.01343081f, 0.01155636f, 0.08571127f, 0.13115977f, 0.08067216f, 0.02597086f, 0.12378946f, -0.03849455f, 
    -0.53972119f, -0.14546975f, -0.23126940f, -0.11036315f, -0.00937572f, -0.11758059f, -0.12825963f, 0.05919416f, 
    -0.00781982f, -0.11290921f, 0.06123347f, 0.09473482f, -0.05851510f, -0.02679904f, -0.07658260f, 0.05261600f, 
    0.15773585f, 0.02274341f, -0.04785530f, -0.02168402f, 0.15836439f, -0.06477091f, -0.07886491f, 0.25279799f, 
    0.29284304f, -0.04048127f, 0.05067733f, 0.01969992f, -0.16511287f, 0.18657507f, -0.06572933f, 0.05721997f, 
    0.04583830f, -0.03742543f, -0.02763055f, 0.05001651f, 0.08393342f, 0.01059353f, -0.02211425f, 0.09993720f, 
    -0.52526289f, -0.04640297f, 0.04237965f, -0.07122407f, -0.06907827f, 0.01489312f, 0.05270587f, -0.01803437f, 
    0.03676555f, -0.07784218f, 0.09932120f, 0.12968519f, -0.04587743f, 0.20662978f, -0.01182623f, 0.22819355f, 
    0.06000787f, 0.10370518f, -0.07823530f, 0.21348806f, 0.20076658f, 0.30312002f, -0.10067223f, 0.17611067f, 
    0.15405145f, 0.03451917f, 0.07729588f, -0.00069967f, 0.02370031f, 0.17754291f, -0.02591663f, -0.08900037f, 
    0.21080273f, 0.08972237f, 0.07782122f, 0.06360865f, 0.02848563f, 0.08168671f, 0.23554128f, 0.17372783f, 
    -0.02074537f, 0.09422021f, 0.19414686f, 0.21942535f, 0.27526203f, -0.02138435f, -0.16500907f, -0.12543929f, 
    -0.08296718f, 0.23851143f, 0.02692479f, 0.08680947f, 0.13935782f, -0.04031710f, 0.02916330f, 0.05757783f, 
    0.01210009f, -0.02607424f, 0.00033528f, -0.13537130f, 0.05437764f, 0.25066137f, 0.06632800f, -0.14823629f, 
    -0.30604199f, 0.12641636f, -0.00376465f, -0.02711366f, 0.03554207f, -0.01528896f, 0.05067404f, -0.02258158f, 
    0.14321618f, 0.00213176f, 0.03327281f, 0.04743065f, 0.10702123f, -0.02449147f, 0.07926793f, 0.13383463f, 
    -0.18391931f, 0.12118109f, 0.01192154f, -0.11192710f, -0.02877745f, 0.03245199f, 0.05565580f, -0.04340524f, 
    0.03001727f, -0.04093098f, 0.15578450f, 0.00891184f, -0.00275199f, 0.00692236f, -0.01570339f, 0.06400650f, 
    0.09706145f, 0.07275534f, 0.02777060f, -0.01086713f, 0.26454508f, -0.29139012f, -0.01979602f, 0.12981731f, 
    0.14936914f, -0.17546661f, -0.03320492f, 0.00667039f, 0.04204016f, 0.10624596f, 0.07778577f, -0.05997320f, 
    0.01649143f, -0.10215350f, 0.00180654f, -0.14436445f, -0.02215563f, -0.11457157f, 0.06641121f, 0.06509318f, 
    -0.23671962f, 0.04869897f, -0.25601280f, -0.28416863f, -0.19323540f, 0.10726393f, 0.05991960f, 0.14726104f, 
    -0.10345624f, 0.01743613f, 0.10122864f, 0.02063467f, 0.11140265f, 0.13319051f, -0.03971146f, -0.03660342f, 
    0.08590740f, 0.17871159f, 0.00152171f, 0.01239869f, -0.45186445f, 0.01190329f, 0.22169535f, 0.08809519f, 
    0.00976110f, -0.11151406f, 0.09230333f, 0.09862351f, -0.00083739f, -0.02865558f, 0.12847596f, 0.00170042f, 
    0.07422899f, -0.07784405f, 0.07198469f, 0.01718559f, -0.02583793f, 0.12248150f, 0.02866215f, -0.00462661f, 
    -0.36849287f, 0.19307178f, 0.66246444f, 0.03511082f, 0.04571873f, -0.04484127f, 0.03222959f, -0.11038878f, 
    0.17364226f, 0.04306754f, 0.04008420f, -0.01553192f, 0.14841537f, 0.23061556f, 0.03067324f, 0.04705516f, 
    0.13739419f, 0.02624954f, -0.07545062f, -0.05662418f, -0.21942765f, -0.17135626f, -0.09347181f, -0.21056055f, 
    -0.14466915f, -0.02318540f, 0.05298390f, -0.01138185f, -0.07460560f, -0.02602766f, 0.01503306f, 0.01134972f, 
    -0.00020783f, -0.01579708f, 0.01976019f, 0.22935681f, 0.25855035f, -0.04082264f, 0.02133193f, 0.06770166f, 
    -0.28499466f, -0.02166048f, 0.02774864f, -0.11132202f, -0.13086782f, -0.04707632f, -0.07565396f, -0.02669728f, 
    0.07034731f, 0.04233297f, 0.12166335f, 0.17412986f, 0.08976433f, 0.15667643f, 0.11675389f, 0.15935391f, 
    0.10939626f, 0.03997019f, 0.08307856f, 0.10533988f, 0.02535356f, 0.24944974f, 0.00552835f, 0.32632890f, 
    0.27996370f, -0.16383696f, -0.00026370f, -0.09623817f, 0.02758852f, 0.02136012f, -0.01181038f, 0.04329404f, 
    0.03417154f, 0.15999150f, 0.20067342f, 0.03258872f, 0.19921221f, 0.08367853f, 0.06153864f, 0.03117376f, 
    0.11441945f, 0.48732215f, 0.41954052f, -0.05848639f, 0.11018035f, -0.02040319f, 0.13737378f, 0.06618230f, 
    0.07740246f, 0.08149831f, 0.07148970f, -0.08834446f, -0.08905602f, -0.03874755f, 0.04536504f, -0.07733957f, 
    -0.05213508f, -0.07705420f, -0.00369569f, 0.04513038f, -0.27792430f, -0.19748601f, 0.02748754f, -0.04423736f, 
    0.02335548f, -0.05275944f, -0.01843810f, 0.01493307f, -0.03886345f, 0.14288801f, -0.01663077f, -0.07408734f, 
    0.12313839f, 0.05399853f, 0.07587431f, -0.02664609f, 0.04915763f, -0.10763280f, 0.03527563f, 0.04048026f, 
    -0.07631325f, -0.50074142f, -0.39525035f, -0.43462500f, -0.09405711f, -0.06105165f, -0.00376342f, -0.02360637f, 
    -0.00294931f, 0.02331073f, 0.10457254f, -0.04459065f, -0.02861353f, -0.13745511f, 0.13482611f, 0.03117714f, 
    0.05703858f, 0.01811316f, 0.08173933f, 0.07768567f, 0.13419518f, 0.03489047f, 0.18685196f, 0.35008109f, 
    -0.01278120f, 0.15783238f, 0.00129820f, 0.03752357f, 0.09629733f, 0.04902905f, 0.04750696f, 0.01570688f, 
    -0.04554467f, -0.06447832f, -0.07782959f, -0.11937025f, 0.05890276f, -0.04037793f, -0.04491371f, 0.06126532f, 
    0.31159160f, -0.27559152f, 0.03521743f, -0.30685684f, 0.01893203f, -0.02974815f, -0.07572072f, 0.02915524f, 
    -0.04676107f, -0.15774514f, -0.01614034f, -0.04833831f, -0.05325577f, 0.02354367f, -0.00624115f, 0.10806200f, 
    -0.00768019f, -0.03217034f, -0.09212820f, -0.04061623f, -0.18119289f, -0.16611339f, 0.15036586f, 0.19523202f, 
    -0.16987319f, 0.00641745f, 0.01830502f, 0.05408141f, 0.06073811f, 0.06094871f, -0.00065884f, -0.01487270f, 
    0.05958525f, 0.00395862f, -0.03369259f, 0.05440763f, 0.00800278f, -0.03556700f, 0.03384082f, 0.05650956f, 
    0.15566096f, 0.25757283f, 0.11331442f, 0.20218307f, 0.03149223f, 0.11693227f, 0.03330805f, 0.03653704f, 
    0.07901210f, 0.01238455f, 0.04462102f, -0.08041056f, 0.02494854f, 0.03754604f, 0.15252206f, -0.01762326f, 
    0.00028985f, 0.00091030f, -0.05604696f, 0.03586255f, 0.08366684f, -0.01307837f, -0.25344628f, 0.00294252f, 
    -0.12388200f, 0.08161633f, -0.04428667f, -0.00100103f, -0.02113468f, 0.15742448f, -0.03905560f, -0.02444673f, 
    0.01955822f, 0.05811646f, -0.08145253f, 0.01843759f, -0.01331614f, -0.16135041f, 0.01825162f, 0.11233512f, 
    -0.01659290f, -0.31169885f, -0.52254194f, 0.12245020f, -0.13586748f, 0.07882614f, -0.01144605f, -0.03114345f, 
    -0.04059777f, 0.06080662f, 0.16282563f, -0.00908977f, 0.02108547f, 0.00693257f, 0.07738856f, 0.05154688f, 
    0.08510522f, 0.06107402f, -0.00574747f, 0.05776178f, -0.09588379f, 0.23208836f, -0.23405088f, 0.32140687f, 
    -0.17879836f, 0.05994371f, 0.00385483f, -0.05822499f, 0.03833995f, 0.05544573f, 0.13015652f, 0.01219826f, 
    0.07017021f, -0.04161637f, 0.01448433f, -0.18542540f, 0.10795862f, 0.01589038f, 0.03584575f, -0.05328138f, 
    0.29033959f, -0.13002019f, -0.03144313f, -0.10885541f, 0.04168277f, -0.08095170f, 0.05911225f, 0.07752286f, 
    -0.05419990f, 0.03781568f, 0.10994928f, -0.00745605f, 0.07058796f, 0.14169116f, -0.00420413f, 0.01321629f, 
    0.13003419f, 0.02961971f, -0.12660652f, -0.03736158f, 0.14472273f, -0.22005013f, -0.50251424f, -0.23643503f, 
    -0.31253278f, -0.10841749f, 0.08808441f, -0.05532385f, -0.05821899f, 0.19000873f, 0.03092815f, -0.05369115f, 
    0.03197945f, 0.08246248f, 0.07031289f, 0.00560372f, 0.02678414f, -0.07159118f, -0.07317482f, -0.02800937f, 
    0.42379177f, -0.30746663f, -0.23144867f, -0.12057810f, -0.20438014f, 0.11312151f, 0.03530820f, 0.01289042f, 
    -0.04098930f, 0.00493322f, -0.01359392f, -0.03958428f, -0.04759004f, 0.07678597f, 0.01728918f, -0.01251988f, 
    -0.00819174f, 0.03739464f, -0.11094096f, 0.03870372f, -0.22041079f, -0.30875307f, -0.48896235f, -0.10353366f, 
    0.06617191f, 0.24750662f, 0.10521609f, -0.00441352f, 0.03419082f, 0.05529078f, 0.12064636f, 0.07212285f, 
    0.01565160f, 0.08566673f, 0.15756810f, 0.05391088f, 0.12970753f, -0.03078707f, 0.09573234f, 0.02840454f, 
    -0.05994529f, -0.24046987f, -0.21890438f, -0.14085864f, 0.01714949f, 0.10307338f, -0.09903613f, -0.06833258f, 
    -0.02593528f, 0.04210061f, -0.01985192f, -0.00671446f, -0.00388344f, 0.06499594f, -0.04669629f, 0.10290695f, 
    0.01152183f, 0.03663917f, -0.02193974f, 0.08955956f, 0.10247485f, 0.11556537f, 0.35844946f, -0.04557363f, 
    -0.05351938f, -0.00755552f, 0.12459421f, -0.03376566f, -0.04824333f, -0.06524746f, 0.06115283f, -0.00670605f, 
    -0.04498891f, 0.09561595f, 0.03269808f, -0.04033544f, 0.12067531f, -0.07339959f, 0.01213050f, 0.01917698f, 
    0.05640038f, -0.28489408f, -0.02471110f, -0.01327114f, -0.30849069f, -0.00620857f, -0.00806429f, -0.10117837f, 
    -0.26277640f, -0.14629070f, 0.18334705f, -0.06757263f, -0.10544277f, 0.00746355f, 0.00022157f, -0.05301888f, 
    0.23061593f, 0.05656422f, 0.08932671f, 0.14244795f, 0.13756618f, 0.08893090f, 0.16036305f, -0.03007521f, 
    0.18484710f, -0.01573886f, 0.06447624f, 0.05896978f, 0.19977608f, 0.23258291f, 0.10436342f, -0.07533272f, 
    0.03904182f, -0.04024425f, 0.16252954f, 0.00774352f, 0.05171362f, -0.08942719f, -0.01949336f, 0.05287916f, 
    0.20668457f, -0.00052891f, -0.21684378f, 0.09180194f, 0.10842599f, 0.09842902f, -0.01128344f, -0.05430487f, 
    -0.03039782f, 0.14334071f, 0.10137212f, -0.03068665f, -0.05134301f, -0.02098768f, 0.07439090f, -0.00276295f, 
    -0.00614948f, -0.09056375f, -0.03912197f, -0.03328000f, -0.14394665f, -0.09415649f, 0.13213348f, -0.19308548f, 
    -0.16023467f, -0.07186502f, -0.03364951f, 0.17006351f, -0.02278727f, -0.32836929f, 0.03203932f, -0.15819529f, 
    -0.08820697f, -0.00114162f, -0.01760109f, -0.02978486f, 0.01200856f, 0.02450932f, 0.00959722f, -0.07287142f, 
    0.07792059f, 0.07958566f, -0.25229043f, 0.09364630f, -0.00845688f, -0.02203113f, 0.03756786f, 0.01697057f, 
    0.06376898f, 0.18943802f, 0.10425850f, 0.04933507f, 0.02106892f, 0.06568695f, 0.20307589f, 0.02418865f, 
    -0.12190221f, -0.00419775f, 0.01301223f, 0.01786605f, -0.24980415f, -0.04565410f, 0.29002875f, 0.09257553f, 
    -0.04780677f, 0.09047997f, 0.15504596f, 0.20463479f, 0.08414446f, 0.13454676f, 0.05448707f, -0.11191823f, 
    -0.15062819f, 0.07926677f, 0.09047477f, 0.01441573f, 0.09860355f, 0.07314028f, 0.04933899f, -0.05716160f, 
    -0.65154791f, 0.26768172f, 0.32447699f, -0.15737312f, -0.19546202f, -0.20318882f, -0.00917900f, 0.01795509f, 
    0.11938783f, 0.09202494f, -0.11399657f, -0.06791453f, -0.17720655f, -0.12934788f, -0.18858694f, -0.23494203f, 
    -0.00849085f, -0.04612312f, -0.00465444f, 0.03079784f, -0.19578257f, -0.01746512f, 0.06510322f, -0.05953942f, 
    0.32880646f, -0.14282796f, -0.11245737f, -0.29642585f, -0.15564053f, -0.11137208f, 0.11514375f, 0.18240432f, 
    0.09061177f, 0.09945495f, 0.03533408f, -0.10165839f, -0.07267004f, 0.23020938f, 0.04040124f, -0.20697927f, 
    0.15328872f, -0.01994673f, 0.02596423f, 0.03114500f, 0.27813268f, 0.03946726f, 0.15518126f, 0.22013991f, 
    0.13503025f, 0.04625069f, -0.11612912f, 0.04659807f, -0.01445166f, -0.07961248f, -0.06549689f, -0.00296296f, 
    0.06623244f, 0.04028964f, 0.06611771f, 0.05738417f, -0.06020890f, -0.13019910f, 0.05684112f, -0.06846995f, 
    0.06792894f, 0.10117253f, -0.05034262f, 0.07326223f, 0.01107060f, -0.04116185f, -0.21321900f, 0.11298811f, 
    -0.08581745f, 0.03959290f, -0.04496345f, 0.00853370f, -0.09664556f, 0.02144628f, -0.01537400f, -0.00045429f, 
    0.11744224f, 0.01320780f, -0.00698584f, -0.08654572f, 0.31940493f, 0.00243018f, -0.18078823f, -0.13784167f, 
    0.18351525f, 0.13799669f, 0.07427610f, 0.29156488f, 0.07683768f, 0.14185855f, 0.10788903f, 0.04717174f, 
    -0.08251097f, -0.02632370f, 0.14353102f, 0.13988853f, 0.53466254f, -0.08657544f, -0.18649255f, -0.05887712f, 
    0.02586127f, 0.14466299f, 0.07191217f, 0.14891820f, 0.02043184f, -0.01863370f, 0.00961062f, 0.00019462f, 
    -0.03912450f, 0.06218582f, 0.00235953f, -0.02393490f, 0.08033118f, 0.01689346f, 0.08636915f, 0.04324931f, 
    -0.00012963f, 0.18450403f, -0.11405415f, -0.11221863f, 0.09795996f, -0.01551902f, 0.11791130f, -0.11105001f, 
    0.02444679f, 0.07757706f, 0.04765340f, 0.04047250f, 0.07321450f, -0.16828901f, -0.11660359f, -0.07978214f, 
    -0.05332807f, 0.14533959f, -0.08570544f, -0.07648129f, 0.12317597f, -0.20216179f, -0.08266713f, 0.08593803f, 
    0.17714965f, 0.08862095f, 0.01700690f, 0.09820970f, -0.02662792f, 0.10476889f, -0.07101877f, 0.01721023f, 
    0.04435413f, 0.10252529f, -0.00072791f, -0.06676745f, -0.07155428f, 0.10285930f, 0.00283227f, -0.10839533f, 
    -0.03123374f, 0.04496819f, 0.04702447f, 0.18460876f, 0.19986272f, 0.00860538f, -0.01045634f, 0.02338277f, 
    0.01210987f, 0.15037513f, 0.09340168f, 0.10270157f, 0.12041740f, 0.09278143f, -0.06393310f, -0.24091305f, 
    -0.10930119f, 0.00161862f, -0.06766238f, -0.02319569f, 0.07829176f, 0.08789397f, -0.12811443f, -0.01467773f, 
    -0.02758579f, 0.22628315f, 0.11308299f, -0.00069556f, 0.03147503f, 0.06740522f, -0.07368603f, -0.12549974f, 
    -0.00616169f, -0.00474292f, -0.10555949f, 0.14489675f, 0.00334165f, 0.10109801f, -0.00246649f, -0.05998475f, 
    0.39998963f, 0.22251701f, -0.07507592f, -0.38738835f, -0.07455745f, 0.11469113f, 0.20633058f, -0.00704929f, 
    -0.06513858f, -0.07200241f, 0.13635479f, -0.03208980f, 0.23096523f, -0.09090114f, 0.03528443f, -0.00030834f, 
    0.14270361f, -0.01649203f, -0.02588277f, 0.03458387f, -0.13347447f, 0.08846369f, -0.20521860f, 0.04487600f, 
    -0.00525415f, -0.02771213f, -0.01409646f, 0.08150769f, -0.31957430f, 0.02182278f, 0.01810069f, 0.03995625f, 
    -0.05240788f, 0.12968837f, 0.05481364f, 0.02138570f, 0.08369995f, -0.01898380f, -0.06867728f, 0.04261101f, 
    -0.22167775f, 0.02941045f, -0.07309455f, -0.19545260f, 0.19702873f, -0.10594977f, 0.03939963f, -0.02611075f, 
    -0.15149944f, -0.07508549f, 0.05807722f, -0.10032970f, -0.06147935f, 0.06339753f, -0.05050434f, 0.09984501f, 
    -0.11216997f, 0.17431411f, 0.14440642f, -0.09126417f, -0.01910054f, 0.33037141f, 0.18651178f, -0.18240479f, 
    -0.24850120f, 0.04431497f, 0.00034850f, -0.16276771f, 0.15042526f, -0.13637571f, 0.07772135f, 0.06136472f, 
    0.09694353f, -0.09398278f, 0.10101432f, -0.13257925f, 0.05227573f, -0.06412840f, -0.07792328f, -0.19045302f, 
    0.15464170f, 0.04740027f, -0.19770537f, -0.24635962f, 0.15947403f, -0.08836207f, 0.10541525f, -0.17989899f, 
    -0.27559790f, 0.02819360f, 0.20148422f, 0.12072018f, 0.03006250f, -0.07957552f, 0.13124333f, 0.04486163f, 
    -0.03518629f, -0.01913055f, 0.07718059f, -0.06046862f, 0.00951096f, 0.22894143f, 0.33954242f, 0.08046748f, 
    0.00987986f, 0.09246851f, 0.04378692f, -0.08052235f, 0.27205932f, 0.06376074f, 0.06442693f, -0.06282233f, 
    -0.14533250f, 0.03171036f, 0.01515349f, 0.02939277f, -0.00924822f, 0.09144209f, -0.18443932f, 0.11959678f, 
    -0.13219221f, 0.03706985f, -0.23683947f, -0.17731673f, 0.00337825f, 0.04604807f, -0.03832730f, 0.17315161f, 
    0.14219271f, -0.03335029f, -0.03930432f, -0.01491885f, 0.06910709f, -0.00499830f, 0.08447528f, -0.05763331f, 
    0.15605272f, -0.13501278f, -0.03367123f, 0.15098262f, 0.10909782f, -0.01914592f, -0.19369581f, -0.02754105f, 
    0.02366198f, -0.15018420f, -0.25758326f, -0.18418367f, -0.04403448f, -0.03702518f, -0.01328671f, -0.04910964f, 
    0.07500414f, 0.05150088f, 0.05442938f, 0.10605323f, 0.02649722f, 0.25679532f, 0.03982129f, -0.08194239f, 
    -0.22915938f, -0.18646905f, -0.06045265f, 0.09105118f, 0.02512867f, -0.07527728f, -0.01085523f, -0.09012101f, 
    0.06077048f, 0.08148887f, 0.00403985f, -0.05867759f, 0.00430092f, 0.10120973f, -0.06486572f, 0.09846273f, 
    -0.00747102f, 0.08476191f, 0.05007388f, 0.13365227f, -0.40757155f, 0.11802662f, 0.34281579f, -0.05003087f, 
    -0.09435079f, 0.00775589f, 0.06535683f, -0.23507476f, 0.08995324f, 0.08313140f, -0.07317273f, -0.00049335f, 
    0.00628866f, -0.09570593f, 0.01639559f, -0.05105716f, 0.06676093f, 0.16274899f, 0.08634967f, -0.14313723f, 
    0.10352886f, -0.15594611f, -0.16994482f, 0.11434981f, 0.13049638f, 0.11412981f, -0.16931748f, -0.11540992f, 
    -0.11628032f, 0.12648319f, 0.07767992f, 0.08387311f, 0.00125891f, 0.00930562f, 0.12719581f, 0.07494638f, 
    -0.09496769f, 0.16019689f, 0.01883684f, 0.33631214f, -0.10269341f, -0.11736163f, 0.01299313f, -0.19721435f, 
    0.05354831f, -0.03677817f, 0.05465347f, -0.25132909f, -0.12981157f, 0.05459375f, 0.08143892f, -0.09268513f, 
    -0.09651995f, 0.10538056f, 0.02544568f, 0.11600162f, 0.13429557f, -0.18096806f, 0.06760761f, 0.02697608f, 
    0.03093572f, -0.08973572f, -0.10606538f, -0.19864383f, -0.02748601f, 0.08524225f, -0.04013231f, -0.03035572f, 
    -0.06794133f, 0.06947543f, -0.00659820f, 0.10445675f, 0.08660070f, -0.07765502f, -0.02677566f, 0.05938622f, 
    -0.01671502f, 0.12908269f, 0.06869245f, 0.02824736f, -0.50775909f, 0.02546660f, -0.25093675f, 0.05508905f, 
    0.08111005f, -0.18949224f, -0.15153685f, -0.23163949f, 0.07774258f, -0.06413762f, -0.04039898f, -0.09394448f, 
    -0.11741545f, 0.20573044f, -0.16044097f, -0.04894891f, 0.07661086f, -0.06260404f, 0.15472978f, 0.07415316f, 
    -0.01494538f, -0.25892264f, -0.22815211f, -0.03612083f, -0.00388486f, 0.05468498f, -0.20540646f, -0.13383736f, 
    -0.10095197f, -0.12914111f, -0.02340221f, 0.04035980f, 0.09939742f, 0.10507386f, 0.05993016f, -0.02998249f, 
    0.03269472f, 0.15326856f, -0.12774457f, 0.14441779f, 0.28421497f, 0.22835274f, 0.21974416f, -0.07282418f, 
    -0.08759559f, 0.22719206f, 0.17175213f, 0.16950496f, -0.10006127f, 0.17706066f, 0.05125181f, 0.01844073f, 
    0.05805824f, -0.07661353f, 0.04112032f, 0.04759865f, -0.05857231f, 0.11758295f, 0.04909691f, 0.00448324f, 
    -0.57138973f, -0.42154610f, 0.02441606f, 0.37857831f, 0.23486480f, 0.13262363f, 0.10592514f, -0.12718609f, 
    0.11467810f, -0.02441236f, -0.22924531f, 0.17070842f, 0.02406309f, -0.02099739f, -0.05441269f, 0.03901475f, 
    -0.11020995f, 0.12839654f, 0.04203848f, 0.07484555f, -0.12318456f, -0.17841540f, -0.06557358f, 0.08622418f, 
    -0.04787588f, 0.00308398f, 0.14591455f, 0.08232333f, 0.00027625f, -0.00969093f, 0.12232582f, 0.09341659f, 
    -0.00067547f, 0.05834044f, 0.04945680f, 0.00354540f, -0.11835673f, 0.13859133f, -0.10026029f, -0.03916920f, 
    0.20795837f, 0.20122311f, 0.26810265f, 0.22225088f, -0.22003207f, -0.16822396f, -0.18164414f, -0.15265803f, 
    -0.08134828f, -0.10515928f, 0.13479903f, 0.06181420f, 0.04794946f, 0.09945890f, 0.01584898f, 0.07588778f, 
    -0.00898251f, 0.13513064f, 0.01761968f, -0.12591612f, -0.12133238f, -0.34408247f, 0.03211363f, 0.10513709f, 
    0.15508612f, 0.14299831f, 0.03083701f, 0.01981223f, 0.11044774f, 0.21532398f, -0.09704631f, 0.05785862f, 
    0.05673121f, 0.00618957f, 0.01993363f, -0.07639262f, 0.02842734f, -0.04814562f, -0.07620106f, 0.10247352f, 
    0.02633454f, 0.28057504f, -0.05999795f, -0.01881117f, -0.15384696f, -0.05594785f, 0.00073964f, 0.10348925f, 
    0.04688924f, 0.04297139f, -0.04444575f, 0.13786669f, -0.09050760f, 0.11400964f, -0.10145320f, -0.05081848f, 
    -0.02541908f, 0.10847230f, 0.18322892f, -0.09745914f, 0.33014521f, 0.09832195f, -0.11403392f, 0.17544544f, 
    0.33796182f, 0.05741034f, 0.14197050f, -0.01431669f, -0.04536370f, 0.08833192f, -0.06555685f, 0.09900927f, 
    0.04431842f, 0.05089599f, 0.06349859f, 0.15062739f, 0.11655646f, 0.07680305f, 0.02490214f, 0.00735329f, 
    0.21348734f, -0.48018363f, 0.02810133f, 0.16150551f, 0.18963237f, -0.02952403f, -0.09963723f, 0.09158903f, 
    0.16447192f, -0.01083671f, -0.07562508f, 0.06347418f, 0.00082146f, -0.10791192f, -0.02817976f, 0.01158897f, 
    -0.12683278f, 0.00081427f, 0.04383321f, -0.13609764f, -0.01613862f, -0.19941381f, 0.16522196f, 0.15621854f, 
    -0.17458300f, 0.03049641f, 0.01549019f, 0.05684597f, -0.02630789f, -0.06568062f, -0.02572158f, -0.01960320f, 
    0.01720221f, -0.03151665f, 0.08073655f, 0.01469700f, -0.07399041f, -0.13899535f, 0.09349805f, 0.02800074f, 
    0.09982481f, -0.12629299f, 0.41845128f, -0.09138162f, -0.00226119f, -0.12975518f, -0.09259171f, -0.11796869f, 
    -0.07253893f, -0.05539544f, -0.00060028f, -0.05412066f, 0.10567028f, 0.07582962f, 0.10626566f, -0.01735960f, 
    -0.07938200f, -0.01552385f, -0.06352095f, -0.00206318f, 0.10636267f, -0.22146134f, 0.35052198f, -0.31976131f, 
    0.00893977f, -0.14995043f, -0.01809857f, -0.11116494f, -0.00568721f, 0.00681990f, -0.04540269f, 0.02160177f, 
    0.04775961f, 0.07954704f, -0.03213040f, 0.01230747f, -0.02626507f, -0.01355051f, 0.03711464f, 0.05371899f, 
    0.14624642f, 0.20172621f, 0.13766757f, 0.16139449f, -0.02541108f, -0.06308769f, 0.07155821f, 0.00433446f, 
    0.08415438f, -0.10974873f, -0.00663683f, -0.13728356f, 0.14023548f, -0.08213332f, 0.01172642f, 0.03333820f, 
    0.02766138f, -0.07826123f, 0.11738381f, -0.14659050f, -0.19845697f, 0.00234017f, 0.51847720f, 0.20835565f, 
    0.02198518f, 0.09863196f, -0.01574000f, 0.00767308f, -0.00710420f, -0.04392990f, 0.16856641f, 0.00540338f, 
    0.10162798f, 0.11153015f, -0.01645601f, 0.11157784f, -0.02432325f, 0.05007858f, -0.01573294f, 0.02292816f, 
    0.03674177f, 0.38924909f, 0.31320587f, -0.01535771f, 0.05262539f, -0.11208470f, -0.08231017f, 0.04663532f, 
    -0.00644414f, 0.02111479f, 0.12851413f, -0.01819726f, 0.04309014f, 0.08400124f, 0.08398439f, -0.06046430f, 
    -0.01005329f, -0.12813573f, 0.05641575f, -0.04540442f, 0.05355862f, 0.02101068f, 0.24954988f, -0.03250141f, 
    -0.03548534f, -0.05202724f, -0.15426348f, -0.05658791f, -0.06467020f, -0.07930145f, 0.09236715f, 0.02875139f, 
    0.03493408f, 0.00048564f, -0.04148569f, -0.03589746f, 0.00562060f, -0.07539002f, 0.06804173f, -0.11000507f, 
    0.01916959f, 0.01388795f, 0.12133040f, -0.02408975f, -0.02846568f, -0.04273874f, -0.07114440f, 0.08974423f, 
    0.12457716f, 0.01534958f, 0.03694633f, 0.13115242f, -0.05405302f, 0.03157989f, 0.03354622f, -0.05428391f, 
    -0.13716052f, -0.14619440f, 0.08160422f, -0.09244491f, -0.23741378f, -0.08893560f, 0.25579068f, 0.25011760f, 
    0.11791252f, -0.02606944f, 0.03379757f, 0.04623824f, 0.14671454f, 0.00526038f, 0.04766856f, 0.05055160f, 
    0.08932737f, -0.01984524f, 0.01442780f, 0.01471506f, 0.09124976f, -0.03330356f, 0.01921546f, 0.10692240f, 
    0.08095057f, 0.31080151f, 0.18640399f, 0.01430034f, 0.10771748f, -0.00600324f, 0.03103729f, 0.11857054f, 
    0.05411636f, 0.10878646f, 0.09674580f, 0.05102406f, -0.02666287f, 0.00748935f, -0.01804979f, -0.05281520f, 
    -0.22862735f, -0.07672913f, 0.03996987f, -0.00718398f, -0.21534951f, 0.00547402f, 0.00906545f, 0.02843435f, 
    0.02826229f, -0.12557374f, -0.02362272f, 0.03453036f, -0.07245574f, -0.06242288f, -0.10607380f, 0.05088977f, 
    -0.01828056f, -0.04246397f, -0.03971771f, -0.14425670f, -0.12869690f, -0.16404361f, -0.15707403f, -0.25810498f, 
    -0.03057003f, -0.27105376f, -0.04945879f, -0.12372037f, -0.09445986f, -0.09318117f, -0.00564104f, 0.11969513f, 
    0.13989429f, -0.07600151f, -0.02638557f, 0.02451095f, -0.01769480f, -0.03247950f, 0.10299222f, 0.14898711f, 
    0.18080875f, -0.05962560f, 0.10227545f, 0.10584521f, 0.21098328f, -0.00541495f, -0.16089408f, 0.17347372f, 
    0.11769236f, 0.12005433f, 0.09602071f, 0.14015026f, -0.15352751f, 0.11681090f, -0.05416010f, -0.05116892f, 
    -0.10111898f, 0.01915366f, -0.13921691f, 0.20200062f, 0.11044341f, 0.10755207f, 0.13400526f, 0.36448643f, 
    -0.22240753f, -0.21507162f, 0.37804660f, -0.01191752f, -0.15938365f, 0.00446444f, -0.06008036f, 0.06981388f, 
    0.05628287f, -0.14645204f, 0.00467692f, -0.11604478f, 0.03108686f, -0.01288110f, -0.10138556f, -0.04706513f, 
    -0.00895098f, -0.11354437f, -0.22537166f, 0.00608503f, 0.02368208f, -0.11864551f, -0.17175305f, 0.01266405f, 
    0.07995205f, -0.12251298f, 0.05922028f, 0.09586997f, -0.06873271f, -0.09771857f, 0.06970192f, 0.02044548f, 
    0.08745442f, 0.02406066f, -0.04904115f, 0.06447352f, 0.17011045f, 0.01311760f, 0.13302012f, 0.23049198f, 
    0.65061003f, 0.33493105f, 0.15746762f, 0.18268804f, 0.01251115f, -0.11814473f, -0.19619431f, -0.13591886f, 
    -0.02704199f, -0.01103974f, 0.09190456f, 0.01733812f, -0.06759418f, -0.01622027f, 0.04460485f, 0.04055124f, 
    -0.11257478f, -0.00506217f, -0.16414273f, -0.12062084f, 0.12931325f, 0.15017943f, 0.11749099f, 0.07905057f, 
    -0.07170896f, -0.05727940f, -0.11329979f, -0.00110771f, 0.01582073f, 0.13991991f, 0.20641206f, 0.20781553f, 
    0.01599558f, 0.01623216f, 0.01811742f, 0.00849316f, 0.19009349f, -0.05248472f, 0.05434829f, 0.19285795f, 
    -0.12819585f, -0.04830915f, -0.10866900f, 0.00862783f, -0.11679887f, 0.08578558f, -0.03225856f, 0.09893256f, 
    -0.02940178f, -0.02139533f, 0.06240478f, -0.06971725f, -0.06382125f, -0.10408890f, 0.10431799f, 0.05793580f, 
    0.08275260f, 0.01424939f, -0.15893333f, -0.12419751f, 0.15695940f, 0.31713000f, -0.28152171f, 0.24363142f, 
    0.07629701f, 0.06689577f, 0.05687504f, 0.13148923f, 0.02285881f, -0.01962827f, 0.06103379f, -0.12705465f, 
    0.02252868f, -0.06795762f, 0.00051045f, 0.10257361f, 0.29411677f, 0.13115743f, 0.14991035f, 0.20024632f, 
    -0.08576750f, 0.09097081f, 0.11217438f, -0.15116476f, -0.26483333f, -0.02911803f, 0.06802306f, 0.15172425f, 
    0.02606965f, -0.16916861f, 0.02392995f, 0.11550833f, 0.06010858f, 0.07649727f, 0.03054428f, -0.12188448f, 
    0.06854802f, 0.10339146f, -0.08018883f, -0.29234049f, -0.13806340f, -0.02146783f, -0.08041871f, -0.09289959f, 
    -0.23635401f, 0.05215490f, 0.05445741f, 0.05332977f, -0.03680268f, 0.02987126f, -0.15488476f, 0.07003759f, 
    0.02559726f, -0.06625943f, 0.06231212f, -0.00864341f, -0.04490319f, -0.04630727f, -0.16927165f, -0.01105199f, 
    0.05460819f, -0.21283832f, 0.09272844f, 0.18807080f, -0.10044786f, -0.04544722f, -0.13104840f, 0.07924058f, 
    -0.03011751f, -0.04562525f, 0.05052321f, -0.16172136f, -0.03348193f, 0.06627449f, 0.00980345f, -0.06277229f, 
    -0.05924798f, -0.06840836f, -0.03631075f, -0.04483260f, 0.13322677f, -0.06367049f, 0.01914199f, -0.11788077f, 
    0.00367327f, 0.05144024f, 0.12530561f, 0.16794136f, -0.02349434f, -0.00641339f, -0.01666233f, -0.08104174f, 
    0.13303232f, -0.07823165f, 0.17458898f, 0.04277294f, -0.03239269f, -0.13327079f, -0.21340731f, -0.12381446f, 
    0.09181005f, 0.16825211f, 0.20249397f, 0.06005396f, 0.00072527f, -0.18927951f, -0.14829095f, -0.06756417f, 
    0.05422495f, -0.06495717f, -0.00321806f, -0.11236795f, -0.11815839f, -0.00127554f, -0.00796780f, 0.03749645f, 
    -0.06637318f, -0.03962838f, -0.12026577f, -0.12954578f, -0.00343075f, -0.09712151f, 0.10589175f, -0.00995350f, 
    0.05003714f, -0.03236292f, -0.01253830f, 0.00444585f, -0.04149638f, -0.09730989f, 0.07741754f, -0.06270121f, 
    -0.03919015f, 0.21034540f, 0.13163321f, 0.06126579f, 0.21421175f, -0.00249925f, 0.03258510f, 0.23698422f, 
    0.18235531f, -0.30708963f, 0.31617990f, 0.31806305f, -0.04119933f, -0.05968724f, -0.15660472f, 0.34286457f, 
    0.02384479f, 0.15044516f, -0.00220402f, -0.01006990f, -0.08325978f, -0.05738131f, -0.07715333f, 0.12258883f, 
    -0.20221280f, -0.03134091f, -0.15601566f, -0.33219999f, 0.17510377f, 0.08858483f, 0.20177400f, 0.19288354f, 
    -0.22660463f, 0.21780448f, 0.14855143f, -0.00926057f, -0.04636562f, -0.29243174f, 0.06954546f, -0.08692183f, 
    0.07230692f, -0.12544204f, -0.11653090f, 0.04840587f, 0.04833296f, 0.05211973f, -0.18164857f, -0.29424965f, 
    0.10853265f, -0.05765884f, 0.19804780f, 0.11976679f, 0.00953878f, -0.27591270f, 0.09296723f, 0.17749615f, 
    -0.00398088f, -0.21557422f, -0.15471585f, 0.05236717f, -0.01924700f, 0.07522689f, 0.03298936f, -0.07325421f, 
    -0.00355899f, -0.01420662f, 0.05207533f, -0.04836058f, 0.01119826f, -0.01415894f, -0.09313915f, 0.15164106f, 
    0.38036659f, -0.13456783f, -0.01646914f, 0.04588570f, -0.24467093f, 0.27265003f, 0.01819425f, 0.08800069f, 
    -0.04033791f, -0.09702519f, -0.03238423f, 0.18964735f, 0.06951441f, 0.10125841f, 0.03228377f, 0.12168100f, 
    -0.22322035f, -0.28964573f, 0.14106612f, 0.16845579f, -0.14011714f, -0.06517847f, -0.03873123f, -0.00467916f, 
    0.05163750f, -0.26660195f, -0.20426640f, 0.01681771f, -0.12555771f, -0.19976267f, -0.18955922f, 0.08091812f, 
    -0.13589036f, 0.06384403f, -0.07768046f, -0.15893796f, -0.08305304f, -0.02169054f, -0.09669840f, 0.09289543f, 
    0.07480486f, 0.19210914f, 0.14257307f, 0.01435187f, 0.00331509f, 0.00726446f, 0.15875149f, 0.00769983f, 
    0.03509306f, 0.03305414f, 0.09299421f, 0.05490591f, 0.11079877f, 0.08717361f, -0.02770890f, 0.28345734f, 
    0.22068444f, -0.30126834f, -0.25517273f, 0.30993584f, 0.05470581f, 0.04389645f, -0.12695448f, -0.18116465f, 
    -0.09218077f, -0.03869944f, -0.07499629f, -0.07464095f, 0.17210430f, 0.08111569f, 0.02622858f, -0.00613082f, 
    -0.10276204f, -0.01267551f, -0.11255932f, -0.01894496f, -0.06792073f, 0.14919813f, -0.06864655f, 0.14906695f, 
    0.01047610f, -0.05683082f, 0.01850913f, 0.15636173f, 0.07071222f, -0.24463142f, -0.11054251f, -0.08403832f, 
    0.10438111f, 0.04730515f, 0.09611262f, -0.08635513f, -0.03127532f, 0.01646152f, 0.03242810f, 0.23715232f, 
    0.06858296f, 0.33940285f, 0.30385575f, 0.12255762f, -0.00005233f, 0.10895821f, 0.05868579f, -0.18530793f, 
    0.00513615f, -0.07219592f, 0.02740814f, 0.08504604f, -0.00771015f, 0.09523671f, -0.06201134f, 0.01232811f, 
    0.09663997f, -0.17248924f, -0.16352241f, -0.02754096f, 0.51571715f, 0.04374862f, 0.16177283f, 0.09989545f, 
    0.02279638f, 0.03591116f, -0.04502315f, 0.02546424f, 0.12890802f, 0.16040580f, 0.03606771f, -0.02810838f, 
    -0.02051997f, -0.10733649f, -0.03114719f, 0.02385576f, 0.08724809f, 0.10018868f, -0.00060997f, 0.11899153f, 
    0.03612993f, 0.09476735f, 0.08987941f, 0.00306746f, -0.16593708f, -0.09526943f, -0.02069569f, -0.02825127f, 
    -0.09991729f, -0.01143692f, -0.01003857f, 0.01915472f, 0.09696218f, -0.18696737f, 0.04899599f, -0.10303727f, 
    -0.10657691f, 0.02849579f, -0.06417623f, -0.16144527f, -0.03290632f, 0.09042794f, 0.36185363f, 0.28507197f, 
    0.08824344f, -0.00076270f, 0.12056281f, -0.10150896f, 0.07861873f, 0.15569349f, -0.13613077f, 0.13425384f, 
    -0.01313860f, -0.10318812f, -0.07987801f, -0.13896269f, 0.13887562f, -0.10815951f, -0.05986295f, -0.05887908f, 
    -0.32239726f, -0.25988334f, 0.25183082f, 0.18532713f, -0.24596705f, -0.08967632f, 0.08429404f, 0.06944061f, 
    0.12691669f, -0.17916346f, -0.26603821f, 0.09789947f, 0.13553144f, 0.05377983f, 0.16495334f, -0.08998556f, 
    -0.02878088f, -0.01719604f, 0.03762612f, 0.12417085f, 0.05822198f, 0.30110759f, 0.06323726f, 0.03319699f, 
    0.04024446f, -0.13061732f, 0.11401907f, 0.03246571f, 0.04048067f, -0.01270238f, -0.11884230f, -0.06795127f, 
    -0.03040875f, 0.05270004f, -0.01369522f, 0.04264400f, -0.05655633f, -0.05900389f, -0.16654532f, -0.06486524f, 
    -0.13363157f, -0.04614537f, -0.06218236f, 0.06993169f, -0.16721575f, 0.02580416f, 0.04391587f, -0.08021313f, 
    0.01184200f, -0.29356110f, -0.26084194f, 0.09603067f, 0.01556858f, 0.07858935f, 0.11914634f, -0.13406619f, 
    -0.09223308f, -0.05559247f, -0.13574365f, -0.00810585f, -0.13694946f, 0.03963050f, -0.12784761f, 0.01175819f, 
    -0.08061720f, -0.04043617f, -0.02603395f, -0.05945233f, 0.12758011f, 0.11308361f, -0.08452748f, -0.04099904f, 
    0.05855314f, 0.04969386f, 0.14414291f, 0.16346006f, 0.02131857f, 0.07500756f, 0.06804035f, 0.19480370f, 
    -0.13074550f, 0.24490905f, -0.01979525f, -0.26381087f, 0.00822419f, 0.20047024f, -0.04310723f, 0.05537375f, 
    0.10937551f, 0.03472649f, -0.22795060f, 0.08893623f, 0.07622124f, -0.07507281f, -0.09158383f, 0.00159122f, 
    0.11461935f, 0.12358692f, -0.08159870f, 0.15895255f, -0.03879078f, 0.04774570f, 0.12458047f, 0.00312380f, 
    -0.04550579f, 0.05701936f, 0.04082950f, -0.01116629f, -0.06637067f, 0.00119185f, 0.08676845f, -0.02225826f, 
    -0.01980728f, 0.15697379f, -0.00526070f, -0.11533000f, 0.01845886f, 0.04562572f, 0.00479497f, -0.11602130f, 
    0.20107086f, 0.27912104f, 0.24229158f, 0.15054664f, 0.20983659f, -0.03875972f, 0.01162960f, -0.03328430f, 
    -0.02437752f, -0.08707254f, -0.07227780f, 0.12666164f, -0.00647609f, -0.02828046f, 0.00851048f, 0.09656234f, 
    -0.13051087f, 0.15276451f, 0.04033199f, -0.06514256f, 0.15392718f, 0.21281916f, 0.02607337f, 0.03879901f, 
    -0.09334822f, -0.02937902f, -0.00405401f, -0.12142692f, 0.15671177f, 0.02608171f, -0.01209037f, 0.14422804f, 
    0.09626848f, -0.00068403f, -0.06346195f, -0.10149752f, -0.07322703f, -0.04837978f, -0.19008212f, -0.03170449f, 
    0.46086976f, 0.08399595f, -0.01204207f, -0.07001020f, 0.03965844f, 0.03545970f, -0.06154484f, -0.04152912f, 
    -0.03917590f, 0.05382824f, 0.00773226f, 0.27200437f, -0.20291600f, 0.05902586f, 0.01700457f, -0.11453500f, 
    0.04097840f, 0.02079257f, -0.07180101f, -0.04501361f, -0.07917993f, 0.02877840f, 0.22105591f, -0.21927935f, 
    0.11045887f, -0.03693931f, 0.07360608f, 0.10085597f, 0.11375449f, -0.16189767f, 0.02769111f, -0.01703941f, 
    -0.02912934f, -0.02593435f, -0.01596335f, -0.03944695f, 0.05005942f, 0.01576721f, 0.02842098f, -0.16062787f, 
    -0.04026177f, -0.35751095f, -0.45648500f, -0.09078917f, -0.18077230f, 0.03511852f, 0.09417007f, 0.11359615f, 
    0.05031248f, -0.11727843f, -0.08099663f, 0.02759366f, -0.07110146f, -0.00906824f, 0.04132023f, -0.17361878f, 
    0.00063093f, -0.16659789f, 0.04032689f, -0.06388541f, 0.27911487f, -0.11123405f, 0.10574062f, 0.27383223f, 
    -0.00179744f, -0.09063897f, -0.16069050f, 0.01502428f, -0.01480082f, -0.08297153f, 0.13559645f, 0.06630824f, 
    -0.05133353f, -0.12467439f, -0.01612896f, 0.04745904f, -0.04650672f, -0.19011439f, -0.04288122f, -0.27700838f, 
    0.04810466f, 0.04915118f, 0.25579855f, 0.03972948f, 0.03052194f, -0.08109744f, -0.12377195f, -0.01797243f, 
    0.01502405f, -0.03166519f, -0.01499274f, -0.00112325f, -0.02050412f, 0.07124343f, 0.07496489f, 0.00848274f, 
    0.18002084f, -0.09615823f, 0.08578206f, 0.00991903f, -0.00418851f, 0.19432923f, 0.32153431f, -0.07263201f, 
    -0.11561430f, -0.13477956f, -0.16439867f, -0.08613980f, 0.02157862f, -0.09746913f, -0.15899114f, -0.03785019f, 
    -0.03873589f, 0.04034656f, 0.03413634f, 0.15041621f, 0.06354880f, -0.06091547f, 0.03751504f, -0.02970000f, 
    0.24330033f, -0.02143189f, 0.21039009f, 0.22553976f, -0.13287514f, -0.00114505f, -0.07186771f, -0.04761044f, 
    0.01565867f, -0.02002582f, 0.07599869f, -0.15672986f, 0.03512111f, 0.00008031f, 0.05022517f, 0.10052974f, 
    0.09174901f, -0.03404784f, -0.03922410f, -0.04614154f, -0.24211663f, 0.03865438f, 0.21987331f, 0.05508492f, 
    -0.12343039f, 0.10456538f, -0.06287208f, 0.04327511f, -0.01354234f, 0.01741793f, 0.03321043f, 0.04495171f, 
    -0.09097269f, 0.08381616f, 0.06955685f, 0.03155714f, 0.13605341f, -0.04348293f, 0.09813835f, 0.07614103f, 
    0.58522117f, -0.16058405f, -0.31342140f, 0.09894510f, -0.21094722f, 0.05374339f, -0.05272018f, 0.01047725f, 
    -0.13827592f, 0.11448491f, 0.15359581f, -0.00296814f, -0.05174104f, -0.00171271f, -0.02589912f, 0.01698311f, 
    -0.00712671f, -0.06138720f, 0.01620546f, 0.07726732f, 0.12848204f, 0.19258560f, 0.14741974f, 0.22463843f, 
    0.18697453f, -0.02828711f, -0.06132920f, -0.07311446f, -0.01658976f, -0.02658523f, 0.07069109f, 0.04823790f, 
    -0.09904773f, -0.04957817f, 0.05621200f, -0.13490956f, -0.00099054f, -0.21841986f, -0.06616670f, -0.01028301f, 
    0.22675334f, -0.03379399f, 0.03315121f, 0.12742038f, -0.04452843f, -0.08716907f, 0.03319045f, -0.01943425f, 
    -0.02521097f, -0.00471970f, 0.04139191f, 0.01408289f, -0.10859300f, -0.04584608f, -0.02823011f, -0.16053922f, 
    -0.13152497f, -0.10141128f, -0.05223480f, 0.00341876f, 0.22834550f, 0.01828621f, 0.06767127f, 0.07208499f, 
    -0.09704526f, 0.19723417f, -0.01515546f, 0.08227555f, -0.07093477f, 0.12634335f, -0.01633643f, -0.07556005f, 
    0.00993546f, -0.03306916f, -0.13503103f, 0.04094025f, 0.07119039f, -0.04650968f, 0.02614056f, -0.08171204f, 
    -0.22071512f, -0.27663457f, 0.08398583f, 0.25959826f, -0.13095950f, 0.05744598f, 0.05441498f, 0.03656903f, 
    0.16083249f, 0.14296909f, -0.28592664f, 0.12884378f, -0.04059251f, -0.08063371f, -0.06548652f, 0.11612270f, 
    0.13971470f, 0.06131586f, 0.04894792f, 0.11041101f, -0.28417048f, -0.17458500f, -0.12308326f, 0.26144740f, 
    -0.23655224f, 0.14538410f, 0.06655043f, 0.00535093f, -0.11141569f, -0.11579769f, 0.05012672f, -0.09596049f, 
    0.09224394f, -0.03803425f, -0.08238294f, 0.06965347f, 0.04949784f, 0.16912110f, 0.10056321f, 0.08118828f, 
    0.14613141f, 0.10438920f, 0.16854952f, 0.05728940f, 0.08588750f, -0.12465422f, -0.04814831f, -0.08752404f, 
    -0.11982376f, -0.08695167f, -0.00553120f, 0.01099291f, -0.08266779f, -0.00009089f, 0.02726287f, 0.03139572f, 
    -0.10206977f, 0.12879887f, -0.02106012f, -0.10648268f, -0.30775398f, -0.29028803f, 0.45882398f, 0.03640271f, 
    -0.02963274f, -0.01833206f, -0.17946838f, 0.02573069f, 0.25068733f, -0.04442305f, 0.02555653f, 0.03913883f, 
    0.09919655f, -0.03137950f, 0.03422417f, 0.12589091f, -0.06880476f, -0.31818885f, -0.19585586f, -0.27136678f, 
    0.29827294f, 0.24449231f, 0.07327674f, -0.06136882f, -0.16946729f, -0.08950791f, 0.06940018f, -0.26679313f, 
    0.14714189f, -0.03527939f, 0.06641661f, 0.08823517f, -0.03527870f, -0.03457690f, -0.00599127f, 0.05432009f, 
    0.10355877f, -0.17842872f, 0.18613045f, 0.00686323f, 0.11638869f, 0.05804451f, 0.01484319f, 0.52782083f, 
    0.01050230f, 0.05157029f, -0.07059119f, 0.00680649f, 0.28834474f, -0.01696971f, 0.04409130f, 0.06607544f, 
    -0.06207629f, -0.14409518f, 0.07907093f, 0.22517496f, -0.05804210f, 0.06313305f, -0.17010905f, -0.02251746f, 
    0.31410101f, -0.50247115f, 0.16166791f, 0.01070176f, -0.11834354f, -0.00179031f, 0.20700558f, -0.08755096f, 
    0.23583794f, -0.01162151f, 0.03890274f, -0.09651681f, 0.06645801f, 0.05320454f, 0.01935808f, -0.03800116f, 
    0.00675931f, 0.05986651f, 0.03948982f, -0.04868821f, -0.14901994f, -0.34269556f, 0.14090058f, 0.13851942f, 
    -0.07193553f, -0.19220348f, -0.13657713f, -0.10002561f, -0.22732820f, -0.30196807f, 0.09478184f, 0.01144876f, 
    -0.09260666f, -0.04247749f, 0.04297570f, -0.00697751f, -0.19226013f, -0.01279722f, -0.00911397f, -0.11292570f, 
    -0.01759347f, 0.12563828f, 0.05779982f, 0.07615335f, -0.04018712f, -0.02903216f, -0.00225651f, -0.04648943f, 
    -0.07555610f, -0.06525451f, -0.08398216f, -0.00380373f, 0.06634522f, -0.04143587f, -0.04749432f, 0.06521104f, 
    -0.00706892f, 0.10319290f, -0.03527285f, 0.06995592f, -0.01554675f, -0.01594936f, 0.10747452f, 0.03754551f, 
    -0.11107913f, 0.10095596f, -0.06172519f, -0.11254009f, -0.15387240f, 0.10777492f, -0.06349400f, 0.08209131f, 
    0.00361995f, 0.09848125f, -0.01130191f, 0.01747150f, -0.23415238f, -0.14026219f, -0.00611491f, -0.02445371f, 
    0.16366327f, 0.02225072f, 0.09621335f, 0.20156740f, -0.05482268f, -0.07986671f, -0.06861296f, 0.05503830f, 
    -0.03108370f, 0.07976897f, 0.06122917f, -0.13378485f, 0.02143192f, -0.08377395f, -0.01150886f, 0.09387977f, 
    0.01575281f, 0.11088440f, 0.19703668f, 0.08641771f, -0.08265901f, 0.15967241f, 0.23947135f, -0.02126697f, 
    -0.04513687f, -0.01354849f, 0.04374485f, 0.01913990f, -0.02534086f, 0.04511115f, 0.08086505f, 0.06859989f, 
    0.02006204f, 0.04599259f, 0.03002096f, 0.16261043f, 0.07910677f, -0.06669535f, 0.07223674f, 0.12290430f, 
    0.13844086f, 0.00817961f, 0.57381409f, -0.28902435f, -0.17700185f, -0.06962000f, -0.07814261f, -0.05050270f, 
    0.20459720f, -0.00190635f, 0.07486565f, 0.18652236f, -0.03089428f, 0.00947733f, 0.09551822f, -0.12689039f, 
    0.06023509f, -0.11193503f, 0.16346298f, 0.04326858f, -0.16120511f, 0.09591716f, 0.22059184f, -0.17533502f, 
    -0.02987940f, -0.16022788f, -0.15376867f, -0.13273007f, -0.07521638f, -0.13484710f, 0.11882453f, 0.08450528f, 
    -0.07726367f, 0.02922226f, -0.05703967f, -0.02744427f, -0.00066311f, -0.04618956f, 0.03781365f, -0.04782534f, 
    0.07422373f, -0.13840012f, 0.16961826f, -0.13361470f, -0.13988538f, -0.07963745f, 0.04697231f, -0.13083254f, 
    0.01002878f, -0.13465209f, 0.11299253f, 0.14776428f, 0.01742632f, 0.09456916f, 0.17076331f, -0.06856426f, 
    -0.05824323f, -0.08430338f, 0.23410094f, -0.01003061f, -0.12169006f, -0.00102953f, 0.28478706f, 0.18369994f, 
    0.03965247f, -0.03525671f, 0.03875658f, 0.00157887f, 0.32109123f, 0.09451924f, -0.00698141f, 0.05122445f, 
    0.08634674f, -0.16566744f, -0.02718810f, 0.06769227f, 0.08528741f, -0.03421504f, 0.06011070f, -0.00604606f, 
    -0.01716943f, -0.00919429f, -0.05129000f, -0.01042924f, -0.05188386f, 0.01923050f, -0.02928661f, -0.06166912f, 
    -0.02481529f, 0.02420572f, -0.00053056f, -0.05846929f, 0.02913400f, 0.03428430f, -0.00233006f, -0.03557970f, 
    -0.04389898f, -0.00683404f, 0.03627832f, 0.03097146f, -0.03108923f, 0.03904781f, -0.04241294f, -0.03997470f, 
    0.03765699f, -0.01695311f, 0.04333769f, -0.05297383f, -0.04706716f, 0.01122011f, -0.00937935f, 0.02785128f, 
    -0.01243344f, -0.04769294f, 0.01054733f, -0.00597229f, -0.05010572f, 0.02070869f, -0.02883207f, -0.02487794f, 
    0.04401113f, 0.04135999f, 0.05358891f, -0.00901430f, -0.04188423f, -0.02307915f, 0.00168884f, -0.00865811f, 
    -0.00574799f, -0.05972125f, -0.00379637f, -0.02028829f, -0.00840525f, 0.02833191f, -0.04552833f, 0.02972186f, 
    -0.03949765f, -0.00379583f, 0.00614929f, 0.03039417f, 0.01144335f, -0.04171044f, -0.00563048f, 0.04428632f, 
    0.01876951f, 0.00847951f, 0.01285080f, -0.03606240f, -0.00973103f, 0.00470650f, -0.05639810f, 0.03086721f, 
    0.03698531f, 0.00596178f, 0.02685784f, -0.03095483f, 0.01454445f, -0.02153374f, -0.01076249f, -0.01913448f, 
    -0.01225980f, 0.02223491f, 0.00389166f, -0.06356630f, 0.04292136f, -0.00376268f, 0.04584035f, -0.06015851f, 
    0.03454175f, 0.00951479f, 0.03518535f, -0.05383408f, -0.00427838f, 0.00935050f, -0.06296059f, -0.05030008f, 
    0.02373884f, -0.05931852f, -0.02715586f, 0.02056227f, 0.01345761f, 0.01935218f, -0.02573125f, 0.04540088f, 
    -0.04552637f, -0.06144369f, -0.03990276f, -0.05613334f, 0.00230838f, 0.04095205f, -0.00445545f, 0.02638536f, 
    -0.02664833f, 0.02784990f, -0.03557614f, -0.06256015f, -0.02623191f, -0.05749263f, -0.02096326f, -0.05082139f, 
    0.04877657f, -0.05135548f, -0.05631104f, -0.01608328f, -0.06075079f, -0.03908975f, 0.00571944f, -0.02662984f, 
    -0.04109361f, -0.05414083f, 0.01850655f, 0.00411709f, -0.04796544f, 0.02947940f, -0.05525899f, -0.01172608f, 
    -0.03021446f, 0.00771005f, -0.00072903f, -0.04659021f, 0.04736458f, -0.04358850f, -0.00316109f, -0.03297016f, 
    -0.02850214f, -0.04735589f, 0.01083523f, -0.05170391f, -0.01614448f, -0.03991076f, 0.02806474f, 0.01240068f, 
    -0.02614605f, 0.00818233f, -0.04232199f, 0.00277183f, -0.04445680f, -0.03390392f, 0.00137884f, -0.01943581f, 
    -0.04261512f, -0.05757121f, -0.00328719f, -0.06449281f, 0.04145134f, 0.01904885f, -0.03359316f, 0.00051701f, 
    -0.00378536f, 0.00925220f, 0.04244439f, 0.04826422f, 0.04288402f, -0.01733779f, -0.05975712f, -0.05717266f, 
    -0.05758997f, -0.04555875f, 0.02468651f, 0.03816955f, 0.03803356f, -0.03609059f, 0.01245055f, 0.00305301f, 
    -0.01907114f, 0.03748003f, -0.03426105f, -0.03214459f, 0.02811480f, -0.00879401f, -0.04255875f, 0.04235000f, 
    -0.04444943f, 0.02805729f, 0.03733355f, 0.01279559f, -0.05464614f, 0.04193967f, 0.00142399f, 0.03274170f, 
    0.00850725f, 0.03448283f, -0.01343672f, 0.00835886f, -0.01474176f, 0.02989871f, 0.04362613f, -0.05360994f, 
    0.04484247f, -0.00112948f, -0.05757466f, 0.03402862f, -0.05271037f, 0.04979971f, 0.00863027f, 0.04688634f, 
    -0.00153448f, -0.00494373f, -0.05898372f, -0.00691882f, 0.03073461f, -0.04303754f, -0.04413285f, 0.04470860f, 
    -0.05310299f, -0.00072211f, -0.01479731f, 0.04353906f, -0.06157767f, -0.02880295f, 0.02981313f, 0.04303258f, 
    -0.04889032f, -0.02180958f, -0.01787945f, -0.02842964f, -0.03658049f, -0.05998605f, -0.00473978f, 0.03647443f, 
    -0.04554955f, -0.03367398f, 0.04036816f, -0.02292930f, -0.01447796f, -0.03570310f, -0.02471999f, -0.02329130f, 
    -0.04504453f, -0.05545428f, -0.03419444f, -0.03081290f, 0.03989123f, -0.02658025f, -0.03328718f, -0.04374401f, 
    0.01662143f, 0.03863670f, 0.03228821f, -0.04541340f, -0.05935435f, -0.00279096f, 0.02865868f, -0.03345613f, 
    -0.04746237f, 0.04640721f, -0.01111807f, -0.05236443f, -0.01141911f, 0.00967965f, 0.01947858f, 0.04755042f, 
    -0.04035676f, 0.02376093f, 0.04888242f, 0.01527388f, -0.00393735f, 0.03110584f, 0.01986651f, -0.01988166f, 
    0.05425803f, -0.03478321f, -0.04946946f, 0.04101912f, -0.03336222f, 0.01589003f, -0.04617236f, 0.04811240f, 
    0.03239265f, -0.03970377f, -0.03381807f, 0.03076866f, -0.02968292f, 0.02732380f, 0.00276172f, 0.04497228f, 
    -0.05272415f, -0.00961458f, 0.02731564f, 0.03420321f, -0.02409338f, -0.02122481f, -0.05873650f, -0.05275385f, 
    -0.02182914f, 0.02691749f, 0.03112256f, -0.01032966f, 0.03411040f, -0.03265814f, 0.03290817f, 0.03941689f, 
    -0.06497166f, 0.01941810f, 0.02124762f, 0.03243641f, 0.00844045f, -0.00759708f, 0.00788059f, -0.05251698f, 
    0.10642160f, 0.09952375f, 0.33200192f, -0.22620426f, 0.17009418f, -0.03802491f, 0.20820835f, -0.10145796f, 
    0.07374620f, 0.03653673f, 0.10344885f, 0.02785858f, 0.06622070f, 0.02347290f, -0.03523933f, -0.21678247f, 
    -0.14486729f, -0.15072633f, -0.00961451f, -0.10983454f, 0.04464933f, -0.01069455f, -0.29616454f, 0.23823081f, 
    -0.10349908f, -0.03811094f, -0.07197680f, -0.03279638f, -0.11030504f, -0.29926854f, -0.07127665f, 0.06733835f, 
    -0.09503497f, 0.01835884f, 0.04162614f, -0.07961782f, -0.05442946f, -0.02411800f, -0.25367787f, -0.33886388f, 
    0.12207612f, 0.01767620f, 0.18567179f, -0.04049528f, -0.15609056f, -0.07901310f, 0.00487755f, 0.00459574f, 
    0.00837797f, -0.13424274f, 0.00264653f, 0.18206178f, 0.10630538f, 0.05074701f, 0.14591736f, -0.06801783f, 
    0.14189273f, -0.01152978f, 0.17007340f, 0.13568577f, 0.11047252f, 0.24072550f, -0.07956876f, -0.05518365f, 
    0.06719986f, 0.10228362f, 0.09097917f, -0.06243186f, -0.00233934f, 0.25798947f, -0.06350496f, 0.02760371f, 
    -0.05969989f, -0.04431404f, -0.08751488f, 0.09942378f, 0.07600648f, 0.12006316f, 0.13735208f, 0.19760284f, 
    -0.22199106f, -0.19219773f, 0.33976489f, -0.05987692f, 0.13691378f, -0.08203725f, 0.01562882f, 0.21543632f, 
    -0.12090010f, -0.21039636f, -0.01329917f, -0.03542096f, 0.14432582f, 0.09123842f, -0.02344672f, 0.03138101f, 
    -0.20379405f, -0.00688321f, -0.18299648f, -0.05541965f, 0.26249132f, 0.17050317f, -0.05373187f, -0.05891254f, 
    0.13512574f, 0.01041673f, 0.07219695f, -0.08991949f, 0.03085161f, -0.05390455f, -0.00522022f, 0.00806014f, 
    0.05224477f, 0.04322936f, -0.05665239f, -0.05828150f, 0.12443339f, 0.05749982f, 0.10257332f, 0.16321722f, 
    0.55229443f, 0.16552250f, -0.06347640f, -0.04118998f, 0.12622221f, 0.00973032f, -0.20682257f, 0.00223523f, 
    -0.17758472f, -0.15636833f, 0.05693309f, -0.01075330f, -0.05764623f, 0.00333571f, 0.08641803f, -0.04307660f, 
    -0.19083211f, -0.07389664f, -0.04572644f, -0.09821975f, 0.16317868f, 0.13237581f, -0.03955518f, 0.19580039f, 
    -0.22243796f, 0.07112730f, -0.12736394f, 0.10516486f, 0.02454757f, -0.12030084f, 0.03606679f, 0.02004826f, 
    0.14795621f, 0.15848002f, 0.08443739f, 0.09362759f, 0.12867717f, 0.04500271f, 0.12160163f, 0.08031085f, 
    -0.13438787f, -0.03983658f, -0.00455264f, 0.07991741f, -0.03603764f, 0.02007083f, -0.13104139f, 0.03128968f, 
    -0.11740664f, -0.02994423f, 0.00630569f, -0.01816066f, -0.08050669f, -0.01133443f, 0.03842454f, 0.13675928f, 
    -0.06643482f, -0.02338197f, -0.12433727f, -0.15403149f, -0.12710693f, 0.21693835f, 0.15401548f, 0.05547544f, 
    0.04784842f, -0.00199946f, 0.11500227f, 0.16006815f, 0.08896186f, -0.01525874f, 0.04191171f, -0.18102583f, 
    -0.00570221f, -0.08240651f, 0.07499120f, 0.17969690f, 0.02467732f, 0.07636852f, 0.11779325f, 0.23304948f, 
    0.01325610f, 0.14280586f, -0.00294469f, 0.26130590f, -0.17653361f, 0.04789302f, 0.04901149f, 0.01751314f, 
    -0.12027694f, -0.31061688f, -0.04178001f, 0.14921428f, -0.03872255f, 0.06805473f, 0.13798444f, 0.06741844f, 
    -0.03413103f, -0.00872921f, -0.01538285f, -0.30221227f, -0.07110121f, 0.07607093f, 0.06868877f, 0.10302751f, 
    0.11801119f, 0.12930708f, 0.00184619f, 0.08348942f, -0.08904608f, -0.09018634f, -0.02960417f, -0.11130840f, 
    -0.05924280f, -0.06283252f, -0.08604840f, 0.07998444f, -0.13839824f, -0.11665465f, -0.03547187f, -0.07786606f, 
    -0.05457720f, 0.04191811f, -0.03641649f, 0.17669871f, 0.15123782f, 0.02491018f, -0.12630911f, 0.27615458f, 
    -0.07912461f, -0.20344999f, -0.04766262f, -0.00092841f, 0.13225384f, 0.08481625f, 0.12569569f, 0.01384742f, 
    -0.07117771f, 0.01073952f, -0.00876195f, -0.06761548f, 0.05251935f, -0.03640313f, 0.17395662f, -0.02755274f, 
    -0.15118194f, 0.05043900f, -0.13950464f, -0.03238669f, 0.01332822f, -0.24414092f, -0.08257625f, -0.13267258f, 
    -0.00075507f, -0.08347672f, -0.15066820f, 0.01048102f, -0.11861978f, -0.08939283f, -0.02423041f, -0.08175101f, 
    0.05016273f, 0.13408953f, -0.04281178f, -0.05278785f, -0.07081575f, -0.10081475f, -0.27080098f, 0.08129377f, 
    -0.17532858f, -0.31785288f, -0.01008778f, -0.00223931f, -0.03297438f, -0.01066665f, 0.07138850f, 0.01043385f, 
    -0.24866526f, -0.16602495f, -0.07879068f, -0.16074605f, -0.00507545f, -0.11350656f, -0.03820108f, -0.10721852f, 
    0.00364588f, -0.06318838f, 0.04747305f, 0.18938890f, 0.01953659f, 0.06607145f, 0.05440650f, 0.09984517f, 
    0.03115459f, 0.04822999f, 0.08826917f, 0.05449934f, 0.12037603f, 0.13835476f, 0.06486013f, 0.12575814f, 
    -0.03446474f, -0.03061186f, 0.01297750f, -0.02677867f, -0.04910871f, -0.02625273f, 0.02626213f, 0.01806270f, 
    0.00726589f, 0.03317513f, 0.02094495f, -0.04321104f, -0.02944383f, -0.02681430f, 0.04982367f, 0.00641229f, 
    -0.00921556f, -0.01261254f, -0.00937311f, 0.00151439f, -0.03737517f, -0.04254547f, -0.00421492f, -0.04158621f, 
    0.03466466f, -0.04195483f, 0.03550969f, -0.01125879f, 0.01104425f, -0.05531738f, 0.02515814f, -0.01518788f, 
    -0.00846240f, -0.02895579f, -0.05092736f, -0.04914246f, 0.00983844f, -0.06091406f, 0.04295027f, 0.04797776f, 
    -0.02556150f, 0.04016604f, 0.00811570f, -0.02112496f, -0.04693698f, -0.05938059f, -0.02045905f, -0.03260146f, 
    -0.00281621f, 0.01715259f, -0.02064426f, -0.06130296f, 0.02058977f, -0.03266842f, 0.00125314f, -0.01194499f, 
    -0.02259865f, -0.04283481f, 0.02615407f, -0.04719001f, -0.03498616f, -0.02300656f, 0.00755455f, -0.05124816f, 
    -0.00349231f, -0.03254351f, -0.01314689f, 0.04070131f, -0.05421311f, 0.00354570f, -0.04766822f, -0.05497633f, 
    -0.04415230f, -0.02898013f, 0.01601743f, -0.04210509f, 0.03856590f, -0.00777770f, 0.04520960f, 0.01791311f, 
    0.04489628f, 0.02573404f, 0.03982333f, -0.04738406f, -0.00859264f, -0.03588459f, -0.03065341f, 0.04670763f, 
    0.00036878f, -0.00325034f, -0.02444506f, -0.03425210f, -0.04067557f, -0.04041902f, -0.03532345f, -0.02104742f, 
    0.04863708f, -0.04212075f, -0.03588590f, -0.04430991f, -0.00098862f, 0.04793793f, -0.01746142f, -0.03359491f, 
    0.00357151f, -0.00595310f, 0.01424967f, -0.03857076f, 0.00385512f, 0.00806581f, -0.00438014f, -0.04585811f, 
    0.01725875f, 0.02846864f, -0.05055229f, 0.00953045f, 0.04042677f, -0.00195780f, -0.05720488f, -0.01933922f, 
    0.03126936f, 0.01977240f, 0.03147960f, -0.03763831f, -0.03021794f, 0.04884358f, -0.05556883f, -0.02266466f, 
    0.01048196f, 0.00390022f, -0.01657012f, -0.04345204f, 0.00945783f, -0.06134600f, 0.01500804f, -0.00392709f, 
    0.01162411f, -0.05711381f, 0.03610674f, 0.04942204f, 0.03471157f, -0.02097471f, 0.04738980f, 0.04607684f, 
    0.02137858f, 0.02690367f, -0.02430186f, -0.02625526f, -0.06031398f, -0.03079215f, 0.00733741f, -0.03349297f, 
    -0.02048794f, -0.05439593f, 0.02145397f, 0.00024202f, -0.05116964f, -0.00921358f, -0.05794106f, 0.01998411f, 
    -0.01208789f, -0.05586391f, 0.03049478f, 0.03477871f, -0.00376103f, 0.01190333f, -0.00204172f, 0.02355528f, 
    -0.02490341f, -0.02125783f, 0.00731802f, -0.00298958f, -0.00945732f, 0.00460233f, -0.01831264f, -0.04395640f, 
    0.00064651f, -0.04945685f, -0.01573505f, -0.03006708f, -0.00969187f, 0.04161210f, -0.02058116f, -0.02946534f, 
    -0.00016708f, 0.02920753f, 0.00471562f, -0.05855814f, -0.02353221f, 0.00498034f, -0.03588110f, -0.00740280f, 
    -0.05553284f, 0.02283148f, 0.03424998f, -0.02943037f, -0.05037154f, -0.02808096f, -0.02243672f, -0.05804400f, 
    -0.02520725f, -0.04436181f, -0.00829210f, 0.02890139f, -0.04608959f, 0.04592917f, 0.01978504f, -0.05447211f, 
    0.00367215f, 0.04174167f, -0.02693830f, -0.01983936f, 0.03290545f, 0.02680479f, -0.01425195f, -0.02314743f, 
    0.02853959f, 0.03658709f, -0.04089447f, 0.04885621f, 0.04309825f, -0.02384969f, -0.00016369f, 0.02756680f, 
    0.04283155f, -0.05340338f, 0.01166811f, -0.01951594f, 0.00881241f, -0.05743457f, 0.04862584f, -0.02202955f, 
    0.00462696f, 0.02389570f, -0.03963911f, 0.03164129f, -0.04761949f, -0.00174961f, 0.01707808f, 0.05398855f, 
    -0.01912481f, -0.00424814f, -0.05276632f, 0.01218339f, 0.00002361f, 0.04058567f, -0.04922098f, -0.05160897f, 
    -0.02093257f, -0.00202685f, 0.01326259f, -0.02866466f, -0.02165875f, 0.00490520f, -0.01114303f, -0.01312343f, 
    -0.05662927f, -0.01330460f, 0.03874348f, -0.04682076f, 0.01590197f, 0.00230381f, 0.00603495f, -0.02932364f, 
    0.02799990f, -0.00502756f, -0.01119178f, -0.02221427f, 0.01902648f, -0.01586092f, -0.02800326f, 0.02284939f, 
    0.01259384f, -0.00517613f, 0.05240336f, -0.04056123f, 0.02207449f, -0.03162095f, 0.01822321f, -0.02119597f, 
    -0.06120798f, 0.03886605f, 0.01425378f, 0.04472793f, -0.00494242f, 0.01156094f, -0.03343495f, -0.03100833f, 
    -0.04334859f, 0.01315411f, -0.02305722f, -0.01768512f, 0.02371935f, 0.03882931f, -0.00845355f, 0.02184388f, 
    0.04178958f, 0.02418190f, -0.02224343f, -0.01217190f, -0.03501341f, -0.03882444f, -0.02669082f, -0.05890119f, 
    0.01416479f, 0.02294631f, -0.03359362f, -0.04771844f, -0.00148043f, 0.00866820f, -0.01991072f, 0.04628583f, 
    -0.00916936f, -0.01520333f, 0.00261082f, 0.00160807f, 0.00638757f, -0.05966685f, 0.02412574f, 0.02075241f, 
    -0.04764481f, 0.01024739f, 0.01721107f, 0.05737219f, -0.06553920f, -0.06447763f, -0.04994661f, 0.03940974f, 
    0.00354575f, 0.04154721f, 0.00174406f, -0.01313772f, -0.05302704f, -0.04059833f, -0.02461583f, -0.05610812f, 
    -0.03558210f, -0.04011284f, 0.01118386f, 0.00432106f, -0.06549720f, -0.04066165f, -0.02988527f, -0.03440334f, 
    -0.03539972f, 0.02385972f, 0.02476728f, 0.02242808f, 0.02234522f, 0.01478622f, 0.01854411f, 0.02891947f, 
    -0.01250483f, -0.06023432f, -0.02063593f, 0.01573330f, -0.05361660f, -0.04773461f, -0.00854166f, -0.02178540f, 
    0.01312182f, -0.02101819f, 0.04043677f, -0.03032211f, 0.02916853f, -0.02435628f, -0.00164487f, 0.01107618f, 
    -0.01750076f, 0.01958065f, -0.00621755f, -0.04499050f, -0.01644810f, -0.01315693f, -0.02410504f, -0.02470256f, 
    0.03902155f, -0.04687830f, 0.01207710f, -0.06334554f, 0.01303715f, 0.00973347f, 0.01327525f, 0.01055653f, 
    -0.00304749f, -0.03572054f, -0.02259363f, 0.02190634f, 0.01908264f, -0.00273826f, -0.01440500f, -0.05244926f, 
    -0.04933629f, -0.01809679f, 0.03515886f, 0.03841635f, 0.04422523f, 0.00761099f, 0.01107285f, -0.01643398f, 
    -0.02774275f, -0.00567587f, -0.00506265f, -0.00812420f, -0.00171651f, -0.05412815f, 0.02229958f, 0.02204097f, 
    0.02015951f, 0.00810463f, 0.03558854f, -0.01803098f, -0.01517021f, 0.02945233f, -0.02990169f, 0.00315095f, 
    -0.04947292f, 0.03058014f, 0.02272472f, 0.04882122f, 0.04094538f, -0.04290745f, 0.00554381f, -0.01533540f, 
    -0.00534926f, -0.03854061f, 0.01624096f, -0.05991463f, -0.05874632f, 0.01601911f, -0.01137742f, -0.02979453f, 
    -0.02642319f, -0.04100025f, 0.00175817f, 0.00880477f, -0.01598431f, -0.04454066f, 0.03421297f, 0.00317622f, 
    -0.01543584f, 0.01955855f, -0.05211250f, -0.01845160f, -0.03397642f, 0.04306410f, -0.02047852f, -0.03550566f, 
    0.03038378f, 0.03943090f, 0.03535438f, 0.00071441f, 0.03815431f, 0.01169431f, -0.01118810f, -0.05550634f, 
    -0.03429003f, 0.00865262f, -0.03680675f, -0.01266078f, 0.03191957f, 0.02537581f, -0.00989888f, 0.03628063f, 
    0.01092373f, -0.04155441f, -0.01620935f, -0.03920078f, -0.05617543f, 0.01758217f, 0.01265031f, 0.03499180f, 
    -0.05506462f, -0.06183017f, -0.01093936f, -0.02457075f, 0.03972533f, 0.04239792f, 0.00270237f, 0.04470498f, 
    0.01114857f, 0.04262146f, 0.02233166f, -0.00854891f, -0.03688323f, -0.05725578f, -0.05017493f, -0.04208356f, 
    -0.04909502f, 0.01460033f, -0.01689321f, -0.03544106f, 0.01315387f, -0.02703156f, 0.00482916f, 0.02396324f, 
    0.04284969f, -0.02114251f, -0.05004904f, -0.05906481f, 0.04234193f, 0.00691749f, -0.00169102f, -0.06104819f, 
    0.02171433f, -0.05224063f, -0.05929066f, -0.04144171f, 0.04418698f, 0.02260038f, 0.00735958f, 0.02220434f, 
    0.02370273f, -0.00782776f, -0.05016381f, 0.03254410f, -0.00863578f, 0.03624566f, 0.01058884f, -0.00226102f, 
    0.03332722f, -0.06211283f, 0.00771472f, 0.03126606f, 0.00443359f, -0.01877271f, 0.02050876f, -0.02047746f, 
    -0.03216626f, 0.01260560f, 0.02652006f, -0.05015888f, -0.01634313f, -0.05787116f, 0.04241630f, -0.03507764f, 
    0.00397399f, -0.05809120f, 0.01521754f, 0.01350115f, -0.00886907f, -0.01129311f, -0.03756791f, -0.05471184f, 
    0.00901076f, -0.02141793f, 0.03191141f, 0.04141582f, 0.02874097f, -0.00284947f, 0.01249753f, 0.01565135f, 
    0.00604575f, 0.04319927f, -0.00630222f, 0.03893423f, -0.03981397f, 0.00644358f, 0.04442434f, -0.02892341f, 
    0.03120871f, 0.00246254f, 0.00856166f, -0.02949199f, -0.05932176f, -0.05426073f, -0.00723361f, 0.03157323f, 
    -0.03228572f, -0.01976665f, -0.01114231f, 0.04021383f, -0.00192715f, -0.03579126f, -0.02782728f, -0.05319128f, 
    -0.01575169f, 0.04395556f, -0.01056581f, 0.03949590f, -0.02190703f, -0.01715855f, 0.03420769f, -0.02684221f, 
    -0.05871479f, 0.01796737f, -0.04351683f, -0.04733744f, -0.04104979f, 0.02694448f, 0.01789682f, 0.02223622f, 
    -0.01264817f, -0.05772109f, 0.03972742f, 0.05225390f, 0.01208294f, -0.01546634f, -0.02201171f, 0.02529266f, 
    0.03674040f, 0.00098035f, 0.03358332f, 0.04760549f, -0.02806492f, -0.01130067f, -0.00909369f, 0.04386650f, 
    -0.03490908f, -0.06072954f, -0.05285478f, 0.02200826f, -0.05817358f, -0.02557615f, -0.04625262f, -0.05108075f, 
    -0.01873052f, -0.03881340f, -0.04160792f, 0.01009859f, 0.02151728f, -0.02651038f, 0.03522759f, 0.01080863f, 
    0.02920679f, -0.01178204f, -0.01916146f, -0.05915441f, -0.04694064f, -0.06279246f, 0.02643713f, -0.00915987f, 
    0.03591131f, 0.00524220f, 0.03279056f, -0.02204706f, -0.01868992f, -0.05404383f, -0.02398166f, -0.05761342f, 
    -0.02205238f, -0.02150130f, -0.05056174f, -0.01599061f, -0.02245783f, 0.04144401f, 0.03876207f, 0.02984258f, 
    -0.00243607f, 0.00647627f, 0.01613214f, -0.01666047f, 0.01671226f, -0.02147400f, 0.02235880f, -0.02762439f, 
    -0.00214444f, -0.01515028f, 0.05232080f, 0.02174660f, -0.05023319f, -0.01320342f, -0.00262293f, -0.05556704f, 
    0.02209411f, 0.04581258f, 0.02599184f, 0.02746070f, -0.03200031f, 0.00928661f, 0.04255933f, -0.00115998f, 
    0.01112878f, 0.00174597f, -0.05582147f, -0.02019888f, -0.02231475f, -0.02329841f, -0.01187932f, 0.03717738f, 
    -0.00923949f, -0.01275758f, 0.05607934f, 0.00095256f, 0.01389500f, -0.01515060f, 0.00703322f, -0.02766545f, 
    0.02999814f, 0.04381482f, 0.03550527f, -0.04108222f, -0.03249476f, 0.04917561f, 0.02750368f, -0.03595285f, 
    -0.02067394f, 0.02459447f, -0.01645757f, 0.02758366f, 0.02139599f, 0.02064853f, 0.03250475f, 0.02145746f, 
    0.01361517f, 0.01224300f, 0.03225639f, 0.00527095f, -0.02131687f, -0.03880779f, 0.04985146f, -0.05033864f, 
    0.03553930f, -0.04608847f, 0.03408435f, 0.00020065f, -0.02349876f, 0.01266447f, -0.05519060f, -0.02915313f, 
    0.02000325f, -0.05288048f, 0.01990417f, -0.01930235f, -0.04055814f, -0.04715559f, 0.03049712f, 0.01534064f, 
    0.05029579f, 0.04145191f, -0.02324281f, -0.02027492f, -0.02213291f, 0.03905850f, -0.05207055f, -0.02409047f, 
    0.02633142f, -0.00757419f, 0.03725816f, -0.04080001f, -0.04714940f, 0.01145826f, 0.00890608f, 0.02476357f, 
    -0.06039126f, -0.00171615f, -0.02938925f, -0.05333998f, 0.04680282f, 0.04573682f, -0.00649463f, 0.04228971f, 
    0.01657407f, 0.04662387f, 0.02923235f, 0.02146650f, 0.04233482f, -0.03164172f, 0.01750445f, -0.03774819f, 
    -0.00642406f, -0.02065948f, -0.02829769f, -0.00071506f, 0.03475042f, -0.03583046f, 0.04418165f, 0.03663028f, 
    0.03368922f, -0.03894881f, -0.02875229f, -0.03466991f, 0.01084740f, 0.02503838f, 0.00836891f, -0.03088856f, 
    -0.00127945f, -0.00489002f, 0.01351314f, 0.04016426f, 0.04559308f, -0.01788360f, 0.03285363f, -0.00252004f, 
    0.01668052f, -0.02128414f, 0.00738535f, 0.03747746f, 0.01036849f, -0.04142645f, -0.02640700f, 0.01687248f, 
    -0.02680417f, 0.00064636f, -0.05119266f, 0.02212573f, -0.00570592f, -0.04691280f, -0.01830166f, -0.04098871f, 
    -0.04886832f, -0.00728282f, 0.00848619f, -0.03287515f, 0.03924891f, -0.05088598f, 0.01981747f, -0.05075742f, 
    0.03233564f, 0.01863916f, -0.01886796f, -0.05511165f, -0.03122870f, -0.00995468f, -0.02584785f, -0.06032082f, 
    -0.00545175f, 0.00977284f, -0.01731289f, -0.04215094f, -0.00791970f, -0.04405386f, -0.01493260f, -0.04952520f, 
    0.01371158f, 0.02992087f, -0.04284848f, -0.02016040f, 0.03371776f, -0.05630701f, -0.03113352f, -0.04782579f, 
    -0.05839108f, 0.00527558f, -0.05796932f, -0.02219533f, 0.03209673f, -0.06201839f, -0.04040673f, 0.01208239f, 
    0.04101615f, 0.03180712f, -0.00830218f, 0.02685184f, -0.01808428f, 0.01643853f, 0.01314492f, -0.01597258f, 
    0.03507816f, 0.03710451f, -0.05453616f, 0.01213312f, -0.01145177f, 0.00067278f, 0.01272608f, -0.01296276f, 
    -0.02824546f, -0.02008561f, 0.00536774f, -0.03732050f, -0.02952250f, -0.03717609f, -0.02316085f, -0.00888537f, 
    -0.05239365f, 0.00784778f, 0.02958606f, -0.05736008f, -0.01534710f, -0.04453912f, -0.02999693f, -0.04054612f, 
    -0.03692231f, -0.01899604f, 0.00969159f, -0.00699235f, -0.02594389f, 0.01465057f, -0.02433249f, 0.03684226f, 
    -0.04230264f, -0.01412625f, -0.03524236f, -0.00745515f, 0.03160239f, -0.06240854f, 0.00051605f, -0.02107468f, 
    0.00153215f, -0.01455021f, 0.03478700f, -0.00159208f, 0.03989346f, 0.04181742f, -0.02642033f, 0.04704497f, 
    0.03492725f, -0.05994691f, -0.00930401f, -0.03596077f, -0.05357030f, 0.00125696f, -0.05304039f, 0.01194801f, 
    0.00320838f, -0.03488188f, -0.03407763f, 0.02293461f, -0.04379034f, 0.00515004f, -0.04873289f, -0.04497647f, 
    -0.03948621f, 0.03505031f, -0.02424254f, -0.05925138f, 0.01188231f, -0.05662211f, -0.02959630f, 0.01050858f, 
    0.04678052f, 0.03309092f, 0.02862641f, 0.03455563f, -0.04668401f, 0.01748997f, -0.01210619f, -0.05117713f, 
    0.00436461f, -0.02357770f, -0.05235126f, -0.03568069f, -0.05515392f, 0.00580049f, 0.03764370f, -0.04507972f, 
    0.03857195f, 0.00858572f, -0.03091565f, -0.05535772f, -0.04251456f, -0.06441310f, -0.03362244f, -0.06301144f, 
    0.03747667f, -0.00729599f, 0.02040749f, -0.04409603f, -0.04963872f, 0.02543267f, 0.04569589f, -0.05366235f, 
    0.04104060f, 0.04508379f, -0.06100778f, -0.00381754f, -0.00253578f, -0.05363570f, -0.01139553f, 0.02167870f, 
    -0.02152407f, -0.03314298f, 0.00546684f, -0.00378680f, 0.02082725f, -0.02373235f, -0.05120840f, -0.05945381f, 
    -0.02228720f, -0.00353849f, -0.05692678f, -0.02090177f, 0.04825873f, 0.01101595f, -0.01847266f, 0.01540194f, 
    -0.05821992f, -0.03662097f, -0.05033870f, -0.04219657f, -0.00363402f, -0.04145663f, 0.04478749f, -0.05199376f, 
    -0.05524651f, -0.00345484f, -0.05035533f, -0.00726796f, -0.05104315f, -0.04123756f, -0.00328593f, -0.02518257f, 
    -0.03981977f, -0.00807986f, 0.01125921f, -0.02093299f, -0.04855607f, 0.01554016f, -0.03224586f, 0.03786959f, 
    0.00323650f, -0.00632582f, 0.00783452f, -0.03440379f, -0.00491681f, -0.02647186f, 0.04792772f, -0.03182777f, 
    0.00929523f, -0.01710365f, 0.02220408f, -0.06280262f, -0.00808911f, 0.02455571f, 0.03893998f, -0.02391261f, 
    -0.01353806f, -0.02536438f, -0.03052143f, -0.04395576f, -0.01139751f, 0.05175319f, 0.02731595f, -0.04477211f, 
    0.02193519f, 0.01930873f, 0.00492109f, -0.05565790f, 0.00249385f, 0.01579233f, -0.04680594f, 0.04606898f, 
    0.02794374f, -0.02102369f, -0.04534136f, 0.02458610f, -0.01288804f, -0.01538508f, -0.01249474f, 0.00866296f, 
    0.00901822f, 0.00144781f, -0.04239167f, -0.02525465f, 0.01580864f, -0.05345198f, 0.04651023f, 0.02613375f, 
    0.00002182f, -0.03340661f, -0.04023866f, 0.04465387f, -0.00842913f, -0.02117582f, -0.05020453f, -0.04572258f, 
    -0.01033166f, 0.04938687f, 0.00205234f, -0.05417529f, -0.01412136f, 0.04301266f, -0.01642893f, -0.01797523f, 
    -0.03521313f, -0.03059001f, -0.03051349f, -0.05122786f, -0.00141978f, -0.01412812f, -0.03232495f, -0.04693299f, 
    -0.02486176f, -0.02238750f, 0.03895387f, -0.04775030f, -0.02326793f, -0.06038564f, 0.03004711f, 0.00703481f, 
    -0.00178975f, 0.02233939f, -0.04308827f, 0.01207535f, 0.01535360f, -0.01911083f, -0.00149816f, -0.01787331f, 
    0.02680639f, 0.04543023f, 0.02472738f, -0.03041192f, -0.00263717f, 0.04288999f, -0.05788236f, -0.04473072f, 
    0.00685480f, 0.00860687f, -0.04268608f, -0.00633816f, 0.03161010f, 0.01975338f, 0.04035731f, 0.01225186f, 
    0.00250326f, -0.03202783f, 0.00082360f, 0.02430141f, 0.00380844f, 0.04619863f, 0.01877571f, -0.02759596f, 
    0.04277032f, -0.04771458f, -0.03337188f, 0.01148710f, -0.03942613f, 0.03578570f, -0.02617864f, 0.04384528f, 
    -0.02220967f, -0.04949321f, 0.02179398f, 0.02185893f, 0.01264159f, 0.02298368f, -0.04751474f, -0.02921065f, 
    0.02499229f, -0.05207929f, 0.03459781f, 0.02367786f, -0.05407348f, 0.00772264f, -0.02373145f, -0.03271567f, 
    0.03771324f, -0.01467961f, 0.02634985f, 0.00054682f, -0.03990934f, -0.03909691f, -0.00183461f, -0.02855799f, 
    0.03917392f, 0.00047877f, -0.00591846f, -0.02437847f, -0.04927320f, 0.04180570f, 0.01004596f, -0.02027251f, 
    0.02582531f, 0.03191949f, -0.06389672f, -0.04594640f, -0.03138886f, -0.00542986f, 0.00763274f, 0.00123017f, 
    -0.01366336f, -0.01212521f, -0.00555921f, 0.03472480f, -0.04619491f, -0.06189111f, 0.03135545f, 0.02647823f, 
    0.03375485f, -0.04977235f, -0.01417933f, 0.03851721f, 0.00296469f, 0.02549862f, 0.04329814f, -0.03604231f, 
    -0.00381051f, -0.05661199f, -0.02324457f, 0.01306530f, 0.01379225f, -0.01961689f, 0.03544288f, 0.00777337f, 
    0.03108291f, -0.02772756f, 0.03229490f, -0.00560918f, 0.03503006f, 0.03320819f, 0.01447198f, 0.02633389f, 
    -0.01717915f, -0.03167617f, -0.04236744f, -0.05767189f, 0.03791623f, -0.02997097f, -0.05840721f, 0.00043147f, 
    -0.00893999f, 0.01685235f, 0.00289782f, -0.06663619f, -0.00121132f, -0.01399090f, 0.04538111f, -0.00285354f, 
    -0.02551130f, 0.04095675f, -0.02361966f, 0.03659580f, -0.01735465f, -0.03039552f, -0.01059606f, -0.06315009f, 
    0.01493143f, 0.02805226f, 0.03080500f, -0.01830001f, -0.02320892f, 0.04351986f, -0.04223433f, -0.02952252f, 
    -0.05519401f, 0.00994983f, -0.01203782f, -0.00789450f, -0.03301651f, 0.03845800f, -0.01569185f, -0.05887422f, 
    -0.05657041f, -0.04908517f, -0.04861348f, 0.03079419f, -0.05782006f, -0.04876807f, 0.00672211f, -0.03968811f, 
    0.01805930f, -0.00285632f, 0.02233399f, -0.02032919f, 0.03110130f, 0.00969060f, -0.02931139f, -0.02692659f, 
    -0.00240964f, 0.02279502f, -0.04370943f, -0.05302183f, 0.04826332f, -0.02015306f, -0.05738482f, 0.00292966f, 
    -0.03373479f, 0.04253516f, 0.04190015f, 0.04249600f, -0.05717733f, 0.03002238f, 0.03825328f, 0.01526199f, 
    -0.04483514f, -0.02050937f, -0.04111223f, -0.04064018f, -0.03770301f, -0.01680540f, 0.01683279f, -0.02163970f, 
    0.03187206f, -0.01919658f, -0.03422405f, -0.03183747f, 0.00551707f, -0.04644075f, 0.02859467f, -0.00378681f, 
    0.43979907f, 0.27281028f, 0.21375725f, -0.06685577f, -0.00757493f, 0.10546818f, -0.05571247f, 0.01650597f, 
    -0.08358786f, 0.22395100f, 0.24663404f, -0.03421148f, -0.03102844f, -0.06688605f, -0.10994413f, -0.05262003f, 
    0.08839902f, 0.08154558f, 0.47812581f, 0.09831800f, 0.10186747f, -0.07427320f, 0.05460396f, 0.07665268f, 
    0.03918405f, -0.07870532f, -0.07418398f, -0.01556593f, -0.07441723f, 0.00007049f, 0.09549672f, 0.18783376f, 
    -0.21639341f, 0.04434652f, 0.07935450f, -0.02217229f, 0.00846979f, -0.04011572f, -0.04367151f, 0.18941365f, 
    -0.32800439f, 0.09563334f, 0.04528927f, -0.12566745f, -0.18007840f, 0.07481901f, 0.02930558f, -0.05305754f, 
    0.05756982f, 0.04547438f, -0.00174508f, -0.08213968f, 0.07074813f, 0.10674419f, 0.02153332f, 0.00706353f, 
    0.01279574f, 0.07445274f, -0.39990050f, -0.20660338f, 0.17875497f, 0.35218236f, 0.34684625f, 0.14259487f, 
    0.07863026f, 0.04814142f, -0.19975190f, 0.03956700f, 0.00189797f, -0.17113818f, 0.02646404f, 0.06095465f, 
    0.01335284f, 0.06278228f, -0.05717947f, 0.09363683f, -0.01994269f, -0.01579768f, 0.00901599f, -0.04812086f, 
    -0.16503973f, -0.08568323f, -0.29497093f, 0.12013105f, 0.00683852f, -0.08826993f, 0.05883937f, 0.00429317f, 
    -0.30736306f, -0.06677607f, 0.08719157f, 0.03749770f, -0.11393053f, -0.10797613f, -0.11830565f, 0.11669687f, 
    0.02769003f, 0.12512363f, -0.02277968f, 0.09787913f, 0.22020093f, 0.28757808f, 0.36334151f, -0.04861764f, 
    0.15961559f, 0.10590616f, -0.05054699f, -0.01936333f, 0.10364013f, -0.00822886f, -0.06358962f, 0.07655477f, 
    0.03739101f, 0.05794032f, -0.00912058f, -0.01260409f, 0.04503171f, -0.08568827f, 0.06892632f, 0.12448356f, 
    -0.12624040f, 0.04773061f, -0.25991517f, 0.13725127f, 0.26834694f, 0.11830501f, 0.05917588f, 0.25691986f, 
    0.18235610f, -0.04173420f, 0.16989684f, -0.13118698f, -0.22984093f, -0.16378796f, -0.01019893f, 0.04863770f, 
    0.08360013f, 0.08415839f, 0.08249621f, 0.03890327f, -0.10266220f, -0.08752339f, -0.06028367f, -0.46789840f, 
    -0.28655836f, 0.09536375f, 0.06152468f, 0.10209411f, 0.06372490f, 0.07379602f, 0.02015133f, 0.02352959f, 
    -0.02853948f, 0.00078931f, 0.10681345f, -0.15491694f, -0.09322821f, 0.14987440f, -0.09404466f, -0.25642189f, 
    0.06196078f, -0.16522196f, 0.07656121f, 0.09953158f, 0.10823064f, -0.04872879f, 0.03095780f, -0.09476801f, 
    -0.01224734f, -0.01720343f, -0.00037178f, -0.01852836f, -0.03759611f, 0.01574978f, 0.06780117f, 0.04176665f, 
    0.04288990f, -0.14480019f, -0.11229017f, -0.00383615f, 0.20819584f, -0.01540530f, 0.66116285f, -0.01010472f, 
    0.13081965f, 0.13383995f, -0.06560157f, -0.14372247f, 0.14147957f, -0.01720843f, -0.04168477f, -0.01106743f, 
    0.00516052f, 0.03181565f, -0.05160540f, -0.09645170f, 0.04048958f, 0.20440285f, 0.06158305f, -0.01144072f, 
    -0.16918804f, -0.24291119f, -0.28444606f, 0.02468572f, -0.00171388f, -0.03391268f, 0.09313884f, -0.07482800f, 
    -0.12648502f, 0.14541447f, -0.03417508f, -0.03555633f, -0.11630425f, 0.00309954f, 0.28432006f, 0.10895313f, 
    -0.13708307f, 0.08253159f, -0.06564602f, 0.07536972f, 0.05002616f, -0.07392545f, 0.09846301f, -0.02233655f, 
    0.14506127f, -0.01822547f, 0.10004623f, -0.09829643f, -0.12318139f, -0.03495765f, -0.06321457f, -0.06677278f, 
    0.04283651f, 0.06633473f, 0.01881062f, 0.00264155f, 0.07090277f, -0.01009806f, -0.11692622f, -0.06380177f, 
    -0.22863701f, 0.05168179f, -0.26959643f, -0.06575508f, 0.09047808f, 0.08262708f, 0.12330467f, 0.14505515f, 
    -0.22470793f, -0.24376243f, 0.05097981f, -0.00201230f, 0.04553806f, -0.08490466f, -0.19987974f, 0.05166697f, 
    0.00076883f, 0.12513548f, -0.00244231f, -0.01086846f, -0.10238339f, 0.01798142f, -0.16594575f, 0.05002209f, 
    -0.05909291f, 0.09184148f, 0.00225538f, -0.06295601f, 0.03717668f, 0.05498531f, 0.01161201f, -0.01923067f, 
    -0.04845442f, 0.05818920f, 0.06504758f, 0.15131986f, 0.00752742f, -0.11848195f, -0.09165892f, -0.00123253f, 
    -0.09297314f, -0.08194612f, -0.27995113f, -0.03543299f, -0.00449061f, 0.10549819f, 0.04851715f, 0.08053172f, 
    0.03694917f, -0.01119922f, 0.10291522f, 0.02125483f, 0.04586038f, 0.03566925f, 0.06351902f, 0.05868628f, 
    0.11387613f, 0.14095667f, -0.03395806f, 0.02536001f, 0.13564004f, 0.37564024f, 0.13458751f, 0.12030141f, 
    0.19940299f, -0.02340122f, 0.15777433f, 0.06124682f, 0.00511440f, 0.06319638f, -0.02661014f, -0.01963902f, 
    -0.02487938f, 0.06453626f, 0.12254588f, 0.14779529f, -0.16245405f, 0.06924427f, 0.05902468f, -0.03212201f, 
    -0.00413422f, -0.01435667f, -0.06774797f, -0.04658729f, -0.04358391f, -0.02534651f, -0.02586716f, 0.02198539f, 
    -0.04186751f, -0.04760914f, 0.04309168f, -0.04615939f, -0.06317147f, -0.00427770f, -0.01279771f, 0.04030986f, 
    -0.00079521f, 0.04227427f, 0.02308305f, 0.01895806f, 0.03304102f, -0.04928537f, -0.02688135f, -0.02043224f, 
    0.02450955f, 0.03713991f, -0.05388727f, 0.02048583f, -0.03565406f, 0.03365475f, -0.00634285f, 0.03512949f, 
    0.00889331f, 0.03235373f, 0.02486104f, 0.04062923f, 0.02622100f, -0.01907660f, 0.00807511f, -0.05050786f, 
    -0.05908344f, 0.02837326f, 0.02093113f, -0.05865667f, -0.06397311f, -0.04496311f, 0.03608317f, 0.03765837f, 
    0.00109551f, 0.01542278f, -0.03928381f, -0.02699221f, -0.03959602f, -0.03094415f, -0.02591642f, -0.01287018f, 
    -0.02965475f, -0.03962563f, -0.01537305f, -0.05780131f, 0.01227246f, 0.02087490f, 0.02108795f, -0.02215163f, 
    0.04354319f, 0.01118495f, 0.03787703f, 0.01953171f, -0.03847826f, -0.04055861f, 0.02729303f, -0.03465075f, 
    0.04473623f, -0.03621539f, 0.01396867f, 0.03186153f, -0.03492937f, 0.01366972f, -0.02992113f, -0.05292693f, 
    -0.01973742f, 0.04237806f, -0.00261641f, 0.02460878f, 0.01130432f, -0.04039669f, -0.01470844f, -0.06196469f, 
    0.03041739f, -0.03400252f, -0.04786672f, -0.05112694f, 0.00163716f, -0.02366739f, -0.04364426f, 0.03762680f, 
    -0.02430916f, 0.00807740f, 0.01856296f, -0.00701141f, 0.04480168f, -0.05714849f, -0.00191122f, -0.03017214f, 
    -0.06173224f, 0.02247670f, -0.04731223f, 0.02234552f, 0.00867942f, -0.05627690f, -0.06020405f, -0.02145962f, 
    0.00844911f, -0.04161716f, 0.02550181f, 0.03725594f, -0.00364019f, -0.04576916f, 0.02545315f, -0.04732555f, 
    0.00326379f, 0.04891163f, -0.03839958f, -0.04140530f, -0.00490180f, -0.00208379f, -0.03311047f, -0.03116701f, 
    0.03683739f, -0.04109673f, -0.04793838f, 0.02595979f, 0.00992105f, -0.05376685f, -0.00213346f, -0.02157057f, 
    0.01301911f, 0.00304061f, 0.04709038f, -0.05344462f, -0.05264025f, 0.00696079f, 0.00829141f, -0.04156347f, 
    0.03647866f, 0.03309929f, -0.00492725f, -0.00914743f, 0.03707772f, -0.00568467f, -0.04007626f, -0.00885136f, 
    0.03509858f, -0.05431252f, 0.00410138f, 0.03761208f, -0.01853772f, -0.04538455f, -0.03278596f, -0.01845829f, 
    0.00689672f, 0.03221014f, -0.04919182f, -0.04724541f, 0.04056396f, 0.00536889f, 0.00841674f, -0.02323353f, 
    -0.04558637f, -0.00250273f, 0.00964792f, -0.02853890f, -0.06310712f, 0.03366462f, -0.02359068f, -0.02779211f, 
    -0.05194706f, -0.05752081f, -0.02151654f, 0.01244768f, 0.01627035f, -0.03866463f, -0.05454491f, 0.02416359f, 
    -0.01407324f, -0.04609679f, -0.04298944f, 0.01098154f, 0.02331585f, -0.01594998f, -0.02595789f, 0.01846369f, 
    0.03780650f, -0.00481250f, 0.00697854f, 0.02634364f, -0.05918699f, -0.04705407f, -0.01496928f, 0.03969754f, 
    -0.02912614f, -0.00991699f, -0.01300310f, -0.04597953f, 0.03621995f, -0.01293077f, -0.02119159f, -0.02726229f, 
    -0.00076104f, -0.05940729f, -0.00646833f, -0.03879314f, 0.03764806f, -0.04689102f, -0.00352360f, 0.02365963f, 
    -0.03026854f, -0.02793814f, 0.03318084f, 0.01848223f, -0.00883269f, -0.01724074f, 0.00086055f, -0.03242320f, 
    -0.01259293f, -0.04100503f, 0.01552801f, -0.02793875f, -0.02926830f, -0.03251116f, 0.02334121f, -0.00879758f, 
    -0.00266225f, 0.00675886f, 0.03603483f, -0.01196304f, -0.04124595f, 0.00212998f, 0.03388586f, 0.04307846f, 
    0.03009952f, 0.02372605f, -0.02109434f, 0.02958177f, 0.01812917f, -0.00896479f, -0.02649613f, 0.00327215f, 
    -0.04243930f, -0.06620922f, -0.05260648f, 0.00399289f, -0.06207750f, -0.00362542f, -0.00858817f, 0.04691963f, 
    -0.02107327f, 0.01478623f, -0.03352518f, -0.03628274f, -0.00393963f, 0.00581063f, -0.03193676f, 0.01686710f, 
    -0.01033213f, -0.03957478f, 0.00546756f, 0.01182373f, 0.03477443f, -0.01794652f, -0.04442152f, 0.02459403f, 
    0.00163504f, 0.02868793f, 0.04407605f, -0.00814460f, -0.05531223f, -0.04277727f, -0.02733749f, -0.05853234f, 
    -0.00731882f, 0.01083396f, 0.03700448f, 0.04207745f, 0.00136673f, 0.04057581f, -0.03865327f, -0.03858330f, 
    0.01076224f, 0.03222534f, 0.01023821f, -0.01944298f, -0.05190223f, -0.02434635f, -0.06744928f, 0.01856501f, 
    -0.05673601f, -0.05993024f, -0.01892965f, 0.03566376f, -0.03059960f, 0.01228616f, -0.06029071f, -0.05418564f, 
    -0.04874374f, 0.00539071f, -0.01298550f, -0.03874687f, -0.04152180f, -0.02561562f, 0.04661191f, 0.00817809f, 
    -0.01395406f, -0.04213706f, -0.05800697f, -0.04933361f, -0.02030993f, -0.00957600f, -0.04137390f, -0.04476155f, 
    0.04233083f, 0.01457967f, -0.03045743f, 0.01589585f, 0.02350816f, -0.04320670f, -0.02893839f, -0.00506090f, 
    -0.05421447f, -0.05650059f, -0.01568926f, -0.02099558f, -0.01319155f, -0.02942406f, 0.04277294f, -0.00519631f, 
    0.04484267f, 0.01193275f, 0.03224913f, -0.05464592f, -0.03577245f, -0.05566973f, -0.01732879f, -0.04105393f, 
    -0.00779313f, -0.00550145f, 0.03563504f, 0.01895007f, 0.03109452f, 0.00754313f, -0.00648202f, -0.04686206f, 
    0.00699707f, -0.04160625f, 0.02556671f, 0.01167315f, 0.04879741f, -0.04482163f, -0.04670316f, -0.06038319f, 
    -0.04679488f, 0.01252238f, 0.00157010f, 0.04825064f, -0.00471304f, 0.02655515f, 0.03229420f, -0.03356741f, 
    0.04254736f, -0.04250345f, -0.02593593f, -0.01212894f, -0.04787412f, -0.04234591f, -0.00102261f, -0.02535279f, 
    0.04826320f, 0.03968989f, 0.01818574f, 0.03390082f, -0.04242522f, -0.05309223f, -0.02914687f, -0.02280039f, 
    0.02757738f, -0.00736353f, -0.02916398f, -0.05715306f, 0.02536099f, 0.00992707f, -0.01873973f, -0.04445857f, 
    0.03121835f, -0.05611277f, 0.03749976f, -0.04984948f, -0.04673579f, 0.03434367f, -0.03121065f, 0.04045877f, 
    0.00053557f, -0.00152624f, -0.01585503f, -0.03777203f, -0.02572267f, -0.02785323f, -0.04406878f, -0.03177676f, 
    0.04691357f, -0.05341778f, 0.00610796f, 0.01549257f, -0.05517616f, -0.01535788f, -0.05011570f, 0.03449074f, 
    -0.04009053f, 0.03794586f, -0.03111338f, 0.02315442f, 0.03166030f, -0.01059746f, -0.04661982f, 0.04594747f, 
    -0.05422065f, 0.01202836f, -0.01594090f, -0.01450375f, -0.05535056f, -0.00817018f, 0.01025264f, 0.04457588f, 
    -0.01993508f, -0.05145079f, -0.02237581f, -0.04007942f, -0.05245611f, -0.05318810f, 0.02125408f, -0.02571867f, 
    -0.04256004f, 0.01552129f, 0.02897496f, 0.01760955f, -0.05022901f, -0.00557652f, -0.00216899f, 0.03955201f, 
    0.03312722f, -0.01784951f, -0.04491944f, 0.03526628f, 0.03159932f, -0.00309842f, -0.00505682f, -0.03684541f, 
    -0.03891227f, 0.00250589f, -0.01623518f, -0.01484041f, -0.06019623f, -0.01835988f, -0.02909636f, 0.01402630f, 
    -0.01538612f, 0.03760959f, -0.04021007f, 0.04237299f, -0.05111185f, -0.00869213f, -0.00384781f, -0.00011866f, 
    0.00450494f, -0.05628608f, -0.01035608f, -0.01223897f, -0.03761518f, -0.02729910f, -0.05219277f, -0.05284639f, 
    -0.01613633f, -0.04566872f, 0.04493401f, -0.00439676f, -0.02593335f, -0.01069064f, -0.00580465f, 0.04852838f, 
    -0.03056557f, 0.03280230f, -0.01704591f, -0.00530273f, -0.02282750f, -0.01139545f, 0.01851577f, 0.01933425f, 
    -0.01578094f, 0.01731524f, 0.03880021f, 0.02404401f, 0.03053883f, 0.02519512f, -0.01918181f, 0.01388977f, 
    -0.01016316f, 0.04610882f, -0.02934619f, -0.04487905f, -0.01169160f, -0.00904061f, -0.02949245f, 0.03477666f, 
    -0.01275501f, -0.05648136f, 0.03821150f, 0.01224164f, 0.04216068f, 0.02907113f, 0.04480410f, 0.01092490f, 
    0.02421631f, -0.00055247f, -0.02150905f, 0.03806181f, 0.03003512f, -0.04177871f, 0.03969254f, -0.01424977f, 
    -0.04779982f, -0.06046312f, 0.04731816f, -0.03519517f, 0.01121483f, -0.02896417f, 0.03775159f, -0.00886560f, 
    0.04136427f, -0.05310856f, 0.00901531f, -0.02639223f, -0.03239668f, 0.04774944f, -0.02133505f, 0.02404392f, 
    -0.00640558f, 0.03247540f, 0.02869843f, -0.05577916f, -0.00819586f, -0.00050820f, -0.00093544f, 0.02081708f, 
    -0.01714462f, -0.00979123f, 0.03167486f, 0.03437233f, -0.02244372f, 0.01395085f, -0.02237498f, -0.04635686f, 
    -0.01898687f, -0.04295281f, 0.02995941f, -0.05121579f, 0.04078122f, 0.00665778f, 0.02128259f, -0.01418897f, 
    -0.00338197f, -0.03543608f, 0.02723772f, -0.05318047f, 0.01759944f, -0.03213567f, -0.02450891f, -0.05489410f, 
    -0.02859860f, -0.06031231f, -0.03010842f, 0.02253048f, 0.03780712f, -0.01660901f, -0.03652718f, -0.04734667f, 
    -0.01549532f, -0.01060693f, -0.03356097f, -0.01599754f, -0.00058695f, 0.01161378f, 0.01208373f, -0.01833368f, 
    0.02165063f, -0.05891568f, -0.03672802f, -0.05640451f, -0.01453935f, 0.00179723f, 0.01079132f, -0.00289470f, 
    0.04966471f, 0.04825361f, 0.03243708f, -0.02838678f, -0.00039757f, -0.05395359f, 0.00311996f, -0.01509120f, 
    -0.03733882f, -0.06123047f, -0.02127397f, -0.01255167f, -0.03014953f, 0.03697216f, -0.03273449f, 0.00857616f, 
    -0.00247792f, 0.02208390f, -0.04652345f, 0.01442973f, 0.01254648f, -0.02735543f, 0.04929804f, 0.02449423f, 
    -0.02346043f, -0.02973803f, 0.02396153f, -0.00173141f, -0.05027336f, 0.00987197f, -0.00134315f, -0.06137313f, 
    0.02047796f, -0.04107086f, -0.04709200f, 0.02609873f, -0.00092733f, -0.06070636f, 0.01512787f, -0.05135649f, 
    -0.07948672f, 0.49700648f, 0.18441887f, 0.30000821f, -0.08576611f, -0.05728601f, -0.02682455f, 0.06531113f, 
    -0.01267143f, 0.06619763f, -0.04206491f, -0.12594967f, -0.08466607f, 0.05197356f, -0.03059132f, -0.06174259f, 
    -0.06956339f, -0.10703024f, 0.08317592f, 0.07335669f, -0.28212151f, -0.36000764f, 0.31492057f, 0.03803246f, 
    0.01584204f, -0.11933350f, 0.16681029f, -0.03117055f, -0.15895155f, 0.03022750f, -0.00048838f, -0.05079605f, 
    0.06182316f, 0.06410672f, 0.11629476f, -0.01508530f, -0.06651784f, 0.07667693f, -0.09071622f, -0.00311264f, 
    -0.00315698f, -0.18708535f, -0.36933467f, 0.04845849f, -0.32790101f, -0.03285360f, -0.09363018f, -0.05562048f, 
    0.07164715f, -0.01321948f, 0.02575026f, -0.01141824f, -0.02765564f, -0.03167902f, 0.08937495f, 0.05894188f, 
    -0.07230664f, -0.01664552f, 0.09928133f, -0.07607415f, -0.06467884f, -0.04929417f, 0.25635549f, 0.19565234f, 
    -0.18032500f, 0.10292743f, -0.09208476f, 0.05589554f, 0.19917114f, -0.05267219f, 0.00156624f, 0.01432674f, 
    0.00443878f, -0.13963552f, -0.00658908f, -0.06540164f, -0.13204457f, -0.08060504f, -0.18569322f, 0.04764288f, 
    0.00184217f, 0.18630114f, -0.20475504f, 0.16818607f, 0.00322768f, -0.18222763f, 0.07123966f, -0.08353566f, 
    0.14527944f, -0.06096435f, -0.08388076f, -0.00265923f, -0.11532316f, -0.05416732f, 0.05214091f, 0.07517315f, 
    0.05131372f, -0.05778878f, 0.13878900f, 0.00136575f, -0.06774161f, -0.21206957f, 0.23727259f, 0.29880437f, 
    0.14698935f, -0.11866893f, -0.02237354f, 0.06412012f, 0.04893460f, -0.09683797f, -0.00270042f, -0.02507728f, 
    -0.05548217f, -0.10515393f, -0.11899798f, 0.17247419f, -0.05170695f, 0.05744948f, -0.10967518f, 0.00965063f, 
    0.28848559f, 0.05910906f, 0.08693415f, 0.24933857f, 0.14210945f, 0.01385851f, 0.14393105f, 0.15378895f, 
    0.09516636f, -0.22385222f, -0.04393137f, -0.00933629f, -0.04210071f, -0.06771021f, 0.00572278f, -0.02035474f, 
    -0.03432944f, -0.05176455f, -0.04136465f, -0.01220418f, -0.06224784f, -0.38430506f, -0.15438934f, -0.02431159f, 
    -0.14181209f, -0.00096290f, 0.01532587f, -0.01789770f, -0.03203077f, 0.01349643f, 0.11388854f, 0.18299998f, 
    -0.09065145f, -0.07888203f, -0.02409529f, 0.01455381f, -0.04331204f, -0.03321798f, -0.01113348f, -0.10868372f, 
    0.14950730f, -0.40697265f, -0.03661498f, -0.02109859f, -0.11233078f, 0.07650461f, -0.03849803f, -0.10733107f, 
    -0.05609585f, 0.09731693f, 0.02836373f, 0.05517082f, -0.01880993f, -0.04661795f, 0.05020441f, 0.01595430f, 
    0.06751722f, 0.10286400f, -0.02302301f, 0.07188682f, 0.06160327f, 0.15043446f, 0.00694319f, 0.14300664f, 
    -0.12317652f, 0.02469191f, -0.21629524f, -0.24565497f, -0.08935811f, 0.07644027f, -0.05660324f, 0.05287747f, 
    -0.10475966f, -0.03556069f, -0.09286027f, -0.09405924f, 0.01789256f, -0.02525968f, 0.11743715f, 0.13167913f, 
    0.23681517f, -0.14327212f, 0.13297325f, -0.03354907f, -0.01425390f, -0.05225931f, 0.07592420f, -0.06435236f, 
    0.08556841f, 0.01001132f, 0.09348116f, -0.12230514f, 0.11216364f, -0.05670337f, 0.05158544f, 0.15089904f, 
    0.13143411f, -0.08931252f, -0.01025976f, 0.00162442f, -0.03358182f, -0.30032706f, -0.08759475f, -0.03717547f, 
    -0.29014245f, 0.04659914f, 0.04822644f, 0.00881108f, -0.08089698f, 0.10191494f, -0.05931681f, 0.07701334f, 
    0.02481478f, 0.04383441f, 0.00084762f, -0.06685049f, 0.06416551f, 0.04878126f, 0.05678455f, -0.02582661f, 
    0.21030518f, 0.21799332f, -0.26323652f, 0.08926044f, -0.15300602f, -0.00064339f, 0.14287177f, -0.04442404f, 
    0.07916109f, -0.09229965f, 0.04637900f, -0.09338532f, -0.12709157f, -0.04870242f, -0.09176740f, -0.06031867f, 
    -0.09713001f, -0.06608112f, 0.05877871f, 0.07457504f, -0.00949887f, -0.21962036f, -0.12333793f, -0.14309698f, 
    0.02025541f, 0.06184933f, -0.09901656f, 0.02941070f, -0.03491135f, -0.02497274f, 0.03278364f, 0.03703258f, 
    0.08890884f, -0.03777422f, 0.04701318f, -0.00858680f, -0.03468844f, 0.04891378f, -0.00499793f, -0.01661982f, 
    0.03342433f, -0.08808120f, -0.19500464f, -0.03858890f, -0.02958330f, -0.02416400f, 0.03241744f, -0.02300607f, 
    0.12604058f, 0.00108267f, -0.04181088f, -0.04594842f, -0.05330903f, 0.00295641f, -0.09185588f, -0.06894021f, 
    -0.01702045f, -0.01095387f, -0.00996369f, 0.06799369f, 0.01506719f, 0.13113932f, 0.47067243f, 0.11307831f, 
    -0.12300157f, 0.06263686f, 0.03362554f, 0.05355157f, -0.05033236f, -0.01015681f, -0.07327465f, -0.04678153f, 
    -0.01737145f, -0.05027249f, 0.01838521f, -0.00598984f, 0.04727799f, -0.14800353f, -0.00597464f, -0.02326907f, 
    0.18114401f, -0.39055583f, 0.15160882f, 0.11978341f, -0.12693527f, 0.07763854f, 0.08801755f, 0.02033068f, 
    -0.10655755f, 0.04516130f, 0.00574132f, 0.04414047f, -0.07674134f, -0.05908419f, -0.00642130f, -0.00083368f, 
    -0.04207338f, 0.01706720f, 0.00428243f, -0.28117204f, -0.04859373f, -0.10939089f, -0.21103647f, 0.18950781f, 
    -0.19722733f, 0.08234049f, -0.15401585f, 0.03298112f, -0.07879512f, -0.11756926f, 0.01731918f, -0.12933597f, 
    -0.02555650f, -0.16116849f, 0.01447264f, -0.06986230f, 0.00903022f, 0.01057620f, -0.05349059f, -0.12448388f, 
    -0.29191786f, -0.25622845f, -0.08090432f, -0.03364002f, -0.18025886f, -0.15515150f, -0.03093275f, -0.20974249f, 
    0.01036437f, -0.03062767f, 0.08338787f, -0.02244265f, -0.02104498f, -0.07528295f, -0.08800333f, 0.03092730f, 
    0.14404005f, -0.07482977f, -0.03534812f, -0.06622981f, -0.06067197f, -0.18587692f, 0.18320574f, 0.07891862f, 
    0.10815051f, 0.08801764f, -0.15701449f, 0.05644347f, -0.10387384f, 0.09479193f, -0.05498660f, 0.07521862f, 
    -0.04144706f, -0.03473432f, -0.00374241f, 0.19551915f, 0.02049604f, 0.05340804f, 0.23245609f, 0.15276769f, 
    -0.27322015f, -0.03903198f, 0.02848757f, 0.10291086f, -0.18814290f, -0.09063894f, 0.06562655f, -0.10094928f, 
    -0.03194109f, -0.19835159f, 0.07545433f, 0.04696244f, 0.00770131f, -0.02291914f, -0.10675748f, 0.18478261f, 
    -0.09474035f, 0.11634519f, -0.09231354f, -0.05431239f, 0.06023734f, 0.02872400f, -0.09530538f, 0.31764266f, 
    0.00220076f, 0.14434855f, -0.06091671f, 0.01898791f, 0.08846930f, 0.15351683f, -0.00433405f, -0.02922697f, 
    -0.04635094f, 0.02929080f, 0.08043621f, -0.01446819f, 0.10884007f, 0.07221796f, 0.03860974f, 0.28690284f, 
    0.03254814f, -0.11263879f, 0.22875665f, 0.29709119f, 0.23005673f, -0.06725232f, -0.12345889f, -0.07927237f, 
    -0.01810578f, -0.03141313f, 0.00968822f, -0.01695139f, 0.07447582f, 0.03032591f, -0.05602250f, -0.02872747f, 
    -0.08262429f, 0.09003150f, -0.08708818f, -0.00175925f, -0.54733139f, -0.02725155f, -0.02851775f, -0.12651218f, 
    -0.08216239f, 0.01019683f, -0.13177189f, -0.00487012f, -0.07125287f, -0.05562207f, -0.00028362f, -0.11597415f, 
    0.04177737f, -0.05490729f, 0.10552228f, -0.03808466f, 0.08740752f, 0.12403110f, -0.00055489f, 0.11132904f, 
    0.03801632f, -0.02356345f, 0.05224396f, 0.11105165f, 0.10112126f, 0.07730879f, -0.06959250f, -0.15499029f, 
    -0.01993068f, -0.02999802f, 0.05215142f, -0.06163763f, -0.02613615f, -0.06402528f, -0.03383477f, 0.08705413f, 
    -0.02197385f, 0.04405925f, -0.07414158f, -0.10733325f, 0.36649764f, 0.02157652f, 0.16525193f, 0.18858768f, 
    0.20261350f, 0.14656416f, -0.01547198f, -0.09896887f, 0.12330556f, 0.16026896f, 0.02667765f, 0.05152613f, 
    0.04186139f, -0.11074815f, 0.00701413f, 0.06011510f, 0.10841039f, 0.18863212f, 0.01900649f, 0.07612911f, 
    -0.20195411f, 0.07515202f, -0.08787391f, -0.14802413f, -0.00520543f, 0.03183080f, 0.00797244f, -0.04776024f, 
    -0.09294145f, 0.10906554f, 0.00197191f, 0.10993106f, 0.04137544f, -0.00620397f, 0.02159652f, -0.12326515f, 
    -0.15959518f, 0.12947671f, 0.00418663f, 0.01281967f, 0.15364735f, 0.09106269f, 0.08613700f, -0.03457109f, 
    0.28543139f, -0.07628281f, 0.15923180f, -0.12939689f, 0.01402403f, 0.00785426f, -0.07460107f, -0.06490737f, 
    0.07007378f, -0.04782216f, -0.02759366f, 0.09519025f, 0.03431221f, -0.09987468f, -0.05411722f, 0.04129893f, 
    -0.43157873f, -0.09403570f, 0.48246643f, -0.15804455f, 0.02959097f, -0.03293749f, 0.10633472f, -0.07742488f, 
    0.07485602f, -0.15567601f, -0.06865186f, 0.03913204f, 0.07952487f, 0.04013782f, 0.10059518f, -0.01976000f, 
    -0.03637377f, -0.01290209f, 0.02443004f, -0.11162595f, -0.26473501f, -0.20864303f, -0.06696965f, -0.18367121f, 
    0.02111531f, -0.00971517f, -0.01810198f, -0.17667061f, -0.09455028f, -0.08838955f, 0.09218753f, -0.03590290f, 
    0.04065417f, 0.04662619f, 0.01203482f, 0.16916068f, -0.05332646f, 0.02530604f, 0.07238582f, -0.11132420f, 
    -0.28531495f, 0.00378170f, -0.01330371f, -0.15991472f, 0.01781225f, 0.02240760f, -0.02959800f, -0.08877777f, 
    -0.03987315f, -0.06549206f, 0.09990607f, 0.10366636f, 0.02845849f, 0.14080000f, 0.08166074f, -0.04671788f, 
    0.03838442f, -0.01931024f, 0.05293611f, -0.08717286f, -0.13656002f, 0.00007369f, 0.04191935f, 0.11729771f, 
    0.10627621f, -0.09741502f, 0.07286121f, -0.03801750f, 0.02838168f, 0.08607092f, -0.09266402f, -0.08307503f, 
    -0.01685803f, 0.05370803f, 0.14438276f, 0.04467039f, 0.07097289f, 0.08669139f, 0.07078882f, 0.11110336f, 
    0.02522124f, -0.04348399f, 0.02230943f, -0.00036512f, 0.02885284f, -0.04705282f, 0.03222568f, 0.02108975f, 
    -0.01468837f, 0.02978067f, 0.04618191f, -0.03655505f, 0.02056634f, -0.04829399f, -0.01609636f, -0.01340853f, 
    0.01233545f, -0.01665530f, -0.05306329f, 0.00164668f, -0.04183050f, -0.03690320f, -0.00363947f, 0.04552782f, 
    0.03634516f, 0.00371685f, 0.00281915f, 0.00573397f, 0.00267285f, 0.00614661f, 0.01889993f, 0.03895759f, 
    -0.05755766f, -0.01568870f, -0.01870182f, -0.01970410f, 0.00333413f, -0.04231327f, -0.03339496f, 0.01348085f, 
    0.01732513f, -0.02125861f, 0.01207954f, -0.05865949f, -0.04623995f, -0.05873680f, -0.06134520f, 0.03413003f, 
    -0.05459230f, -0.04191351f, -0.04493762f, 0.01636541f, -0.00790263f, -0.04116585f, -0.01190638f, -0.00308277f, 
    -0.01581789f, 0.02896968f, -0.05706140f, 0.04637566f, -0.03104465f, -0.00979737f, -0.02408228f, -0.05948400f, 
    -0.01213216f, -0.05533531f, -0.04481830f, -0.03054512f, -0.05010556f, -0.04560023f, 0.02836548f, -0.00566067f, 
    -0.01366016f, 0.05243265f, -0.00498762f, -0.04809549f, -0.04318467f, 0.01122398f, 0.03632866f, -0.03907387f, 
    -0.03882841f, 0.01460197f, -0.03880942f, -0.03286081f, -0.03576680f, -0.00687254f, -0.03945088f, -0.01564307f, 
    0.00732372f, -0.05863924f, 0.00360232f, 0.00029362f, -0.04298788f, -0.05318470f, 0.00723083f, -0.01679313f, 
    -0.00989061f, 0.01967919f, 0.04442858f, 0.00288400f, -0.04516850f, 0.04985201f, 0.02779545f, 0.00749330f, 
    -0.01424331f, -0.03432658f, -0.00385485f, -0.01681972f, 0.01270718f, -0.03523849f, 0.00006939f, -0.04338508f, 
    0.05015878f, -0.03622866f, -0.05869286f, 0.03408095f, -0.02414699f, 0.04700458f, 0.00450728f, -0.02010835f, 
    -0.01817554f, -0.03790511f, -0.05600153f, -0.00289828f, 0.04047908f, -0.05604068f, -0.05538148f, 0.04692813f, 
    0.02881197f, 0.03259826f, -0.05984578f, 0.04215028f, -0.03454703f, -0.03768049f, -0.04872113f, -0.04020817f, 
    0.02310131f, 0.01775267f, 0.00046917f, -0.01284307f, -0.05463304f, -0.03373498f, -0.02748180f, -0.04799835f, 
    -0.02605650f, 0.04591544f, 0.02356807f, 0.03937683f, -0.04251837f, -0.04153458f, -0.06131568f, 0.01090343f, 
    -0.02207231f, -0.05003439f, -0.04899280f, 0.03374403f, 0.01126284f, 0.02313405f, -0.00200029f, 0.01191060f, 
    0.03465363f, -0.05890121f, -0.04877638f, -0.04882470f, -0.00324553f, 0.04227486f, -0.02865137f, 0.00441227f, 
    0.03387240f, 0.03092273f, -0.05066289f, -0.01259177f, -0.00090929f, 0.03567233f, -0.04663862f, -0.06002351f, 
    -0.02802510f, -0.03082202f, 0.01612061f, -0.03910432f, -0.03786641f, -0.02078733f, 0.00597727f, -0.02423727f, 
    -0.03234093f, 0.00576789f, -0.06075949f, 0.04859216f, 0.00440170f, 0.02944136f, -0.00477748f, -0.05433818f, 
    -0.00663917f, -0.01335951f, 0.00972391f, -0.01539614f, -0.00809318f, -0.03368051f, 0.02941940f, -0.02351861f, 
    -0.00676258f, -0.03622277f, -0.02206956f, 0.02841462f, -0.05592791f, 0.04025933f, 0.04201464f, -0.00913992f, 
    0.04340430f, -0.02809645f, 0.02925213f, 0.03733197f, -0.02991161f, -0.01402299f, -0.01449336f, 0.03197190f, 
    0.00424820f, 0.00774605f, -0.06105547f, 0.00190635f, 0.00013394f, 0.00667896f, -0.03559736f, -0.00435823f, 
    0.00625532f, -0.00789994f, 0.00306031f, -0.01737888f, 0.03205081f, -0.02597456f, -0.01459521f, 0.04784912f, 
    -0.05565109f, 0.01895032f, -0.04128629f, 0.02239883f, -0.01428689f, -0.04016538f, 0.00861160f, -0.02506897f, 
    0.01307602f, -0.01168025f, 0.02536171f, 0.02014366f, -0.05973201f, -0.03362843f, 0.02605240f, -0.00950478f, 
    -0.01477429f, 0.04208478f, 0.00610378f, -0.02074892f, 0.01844202f, 0.02775129f, 0.02105779f, 0.01757017f, 
    -0.03462696f, -0.04646518f, -0.05373279f, -0.02055708f, -0.03199852f, 0.00027712f, -0.05220878f, -0.04671370f, 
    0.01875705f, 0.03021085f, 0.03754048f, -0.05458767f, 0.04492292f, -0.03565009f, 0.04543788f, 0.04111437f, 
    0.00785525f, -0.00591588f, -0.00786796f, -0.02371287f, -0.00036022f, 0.01092907f, -0.02937034f, -0.03285241f, 
    0.03904439f, -0.02798773f, -0.02675696f, -0.05712301f, -0.00223116f, 0.04016210f, -0.01645438f, 0.03076286f, 
    0.01814863f, 0.00845371f, -0.03585883f, 0.04984733f, -0.02877699f, 0.00850955f, -0.04867138f, -0.01272941f, 
    0.03050135f, 0.01562718f, 0.02972544f, -0.06037356f, -0.01288750f, 0.04510261f, -0.02610874f, -0.05046709f, 
    0.00160415f, 0.03365013f, -0.03579630f, -0.00484272f, -0.02462169f, 0.01073192f, 0.02311757f, -0.05337583f, 
    0.01760437f, -0.01038473f, -0.00068553f, -0.03223103f, 0.01733845f, 0.00251808f, -0.01863682f, -0.02863916f, 
    -0.03190985f, -0.59751838f, 0.15546599f, 0.18428104f, -0.17957145f, -0.07703329f, -0.02851357f, -0.03587635f, 
    -0.00419549f, 0.01538555f, 0.05877344f, 0.07666105f, -0.09778146f, -0.08740768f, 0.06735456f, -0.00575980f, 
    0.21217087f, 0.12580527f, 0.21262075f, -0.03064241f, 0.23975225f, 0.05967839f, -0.19663711f, 0.16790101f, 
    -0.05218316f, 0.09773467f, -0.09620220f, -0.00835273f, 0.07714032f, -0.11505181f, 0.13536899f, -0.04918781f, 
    -0.03743341f, -0.12210844f, 0.07821961f, 0.04094475f, 0.06469516f, -0.03890584f, 0.05812659f, -0.00167443f, 
    0.18851139f, -0.02549523f, 0.08707938f, 0.07244428f, 0.04902517f, -0.03300630f, 0.06847037f, -0.12706029f, 
    -0.12009718f, -0.05486843f, -0.01180454f, -0.10338789f, -0.05320796f, -0.01615875f, 0.04040594f, 0.04312942f, 
    -0.01382733f, -0.01767390f, -0.12369432f, -0.00332465f, -0.25944927f, -0.32998458f, 0.22021040f, -0.14490730f, 
    -0.07804435f, -0.13422960f, -0.03189196f, -0.00997212f, 0.00665850f, -0.12156021f, 0.04486508f, -0.00907372f, 
    -0.00486046f, 0.09050847f, 0.02671445f, 0.11375960f, -0.04732282f, 0.04548986f, 0.09357945f, -0.18065466f, 
    0.00997033f, -0.04228660f, -0.18208741f, -0.01008432f, -0.01494783f, 0.06404079f, 0.03464276f, 0.04693202f, 
    0.09862673f, 0.00502220f, 0.10607931f, 0.01978213f, 0.06533661f, 0.03788554f, 0.09730277f, 0.10260168f, 
    -0.03954461f, -0.01062879f, 0.00003882f, -0.06664193f, -0.06465136f, -0.02903521f, -0.09787410f, 0.20407379f, 
    -0.08281620f, 0.11521405f, 0.02060609f, 0.05125665f, 0.19982621f, 0.09481860f, 0.02157617f, -0.02794378f, 
    -0.07247444f, 0.10557398f, 0.13633423f, 0.02038787f, 0.00815821f, 0.08961593f, -0.01531422f, 0.02133262f, 
    -0.14307906f, -0.10170044f, 0.10151021f, -0.04383785f, -0.16057578f, -0.12807676f, -0.05706509f, -0.06361802f, 
    0.16969329f, 0.06398093f, 0.00342949f, -0.06857727f, -0.09103961f, -0.11196554f, -0.08770510f, -0.06133049f, 
    -0.02715486f, 0.03874590f, -0.01252373f, 0.00138767f, -0.47887722f, -0.10212822f, -0.13203911f, -0.10939620f, 
    0.25666153f, -0.07745225f, -0.15207756f, -0.12231228f, -0.16073556f, -0.30206719f, -0.05220028f, 0.10514829f, 
    0.06276768f, 0.16609959f, 0.16762872f, 0.01319566f, 0.03522128f, 0.13284267f, -0.05458947f, -0.03561104f, 
    0.14581846f, 0.13276829f, -0.08527701f, 0.08132791f, 0.10199556f, 0.10900819f, 0.11910859f, 0.10308605f, 
    0.02036687f, 0.06839693f, -0.06311553f, -0.01931322f, 0.00838577f, 0.02201998f, -0.10875283f, 0.11315179f, 
    -0.09946217f, 0.05368508f, -0.00620461f, -0.03636284f, 0.13876323f, -0.19365840f, 0.09925085f, 0.02231239f, 
    0.12998098f, 0.22904590f, 0.11912061f, 0.05213070f, 0.05589567f, 0.00931248f, -0.13040009f, 0.05464661f, 
    0.05448274f, -0.04666669f, -0.03059506f, 0.08418794f, -0.06979153f, 0.01125470f, -0.08314643f, -0.05513702f, 
    -0.04945642f, 0.06766579f, -0.15058051f, 0.04996170f, 0.19467342f, -0.02059233f, -0.12045162f, 0.05107819f, 
    0.06230749f, 0.14233309f, -0.03873326f, 0.19117111f, -0.03936270f, 0.10491538f, 0.19160794f, 0.05648202f, 
    -0.15463629f, 0.12936649f, 0.09136564f, 0.09826263f, 0.43801546f, 0.16681416f, -0.08185213f, -0.01973763f, 
    0.19951190f, 0.07820638f, 0.12099891f, 0.08644693f, 0.02113775f, -0.12704785f, 0.04817644f, 0.00253914f, 
    -0.00669759f, -0.01755859f, -0.00027819f, 0.19150843f, -0.03200447f, -0.03378227f, 0.03178954f, 0.02491027f, 
    -0.26981282f, -0.00938466f, 0.26206112f, -0.36021456f, 0.12735167f, -0.08262005f, 0.03992092f, 0.09375497f, 
    -0.01206864f, -0.06469946f, -0.00449050f, 0.23738512f, 0.16450582f, 0.00581084f, 0.07192625f, -0.07725401f, 
    0.03769246f, 0.09047823f, -0.01534851f, -0.02785997f, 0.01391544f, 0.01110422f, 0.06366501f, -0.02510501f, 
    -0.06816339f, 0.04053868f, -0.03216831f, -0.05117359f, 0.02429632f, -0.04232398f, -0.00513158f, -0.12785150f, 
    -0.02863297f, 0.04196703f, -0.08569919f, 0.01924380f, -0.01379801f, 0.07997245f, -0.05442848f, -0.03038926f, 
    -0.03964360f, 0.08000062f, 0.11675595f, -0.05671312f, 0.03312156f, 0.00979850f, -0.02927163f, -0.04513262f, 
    -0.08099947f, 0.05027805f, 0.19129767f, 0.21285093f, 0.22895490f, 0.15400937f, 0.16430630f, -0.10249434f, 
    -0.07464721f, -0.02690161f, 0.07402613f, -0.08296826f, -0.18865170f, -0.09151904f, -0.10676037f, -0.03292581f, 
    0.06710199f, -0.02331316f, -0.00817932f, 0.08654993f, 0.18799148f, 0.12085092f, -0.02116361f, 0.06331858f, 
    -0.02113974f, 0.03869768f, -0.07030975f, 0.13588734f, -0.00022748f, 0.11456042f, -0.01273892f, -0.06177077f, 
    -0.18604945f, -0.51374245f, -0.16175754f, -0.08628798f, -0.29701191f, -0.12632696f, 0.10660332f, 0.02959248f, 
    0.03753996f, -0.15224819f, 0.04355684f, 0.02193706f, 0.07595108f, 0.04716413f, 0.07835665f, 0.10299812f, 
    -0.04081889f, -0.01285369f, -0.13250558f, -0.12586546f, -0.04709555f, 0.09451909f, -0.26271269f, 0.03017225f, 
    0.07913154f, -0.04683176f, 0.02677253f, -0.04287726f, 0.05570280f, 0.03714257f, -0.10111608f, 0.00890149f, 
    -0.01204366f, -0.13169451f, -0.07957859f, 0.02536618f, -0.02506225f, -0.18974870f, -0.05401197f, 0.02519509f, 
    0.29924878f, 0.01180294f, -0.06014897f, -0.12967139f, 0.30904368f, -0.01201256f, 0.08935452f, 0.07690229f, 
    -0.03553807f, -0.01537342f, 0.01377099f, 0.01688213f, -0.01059836f, -0.12350971f, -0.04604532f, 0.06623928f, 
    0.00375883f, -0.17585936f, 0.01506410f, 0.11468672f, -0.18773785f, -0.38202435f, -0.15161736f, -0.04628460f, 
    -0.02643502f, 0.07087728f, 0.03210698f, -0.05913238f, -0.03533915f, -0.02756481f, 0.02216935f, -0.08538423f, 
    0.05303703f, 0.10816008f, 0.02661640f, 0.02670499f, 0.02185425f, 0.11496423f, 0.16003929f, 0.17660682f, 
    0.21782263f, -0.02959894f, 0.11234324f, -0.17014994f, -0.02798773f, 0.08016309f, -0.11594158f, 0.01532352f, 
    -0.04969723f, -0.04493088f, 0.02612798f, 0.02055816f, 0.02193136f, 0.09608824f, 0.05755102f, -0.00179954f, 
    -0.13128541f, -0.01043626f, -0.15670455f, -0.20981222f, -0.44857758f, -0.06639753f, -0.19993119f, 0.24723779f, 
    -0.17212483f, 0.03926244f, 0.07049844f, 0.02980097f, 0.06082315f, 0.16687354f, 0.04641332f, -0.01772419f, 
    0.07143401f, 0.05713567f, -0.00094794f, -0.05866229f, 0.03938390f, -0.03586036f, 0.08014438f, 0.08134065f, 
    -0.28107843f, 0.00107558f, 0.27479467f, -0.09631658f, -0.23547693f, -0.03169579f, -0.10023435f, -0.25256082f, 
    -0.06121659f, -0.09506195f, -0.02643099f, 0.12468757f, 0.12591794f, 0.19674049f, 0.06086849f, 0.06091251f, 
    -0.14951932f, 0.01964504f, -0.04778156f, 0.03910904f, -0.06586985f, 0.02047157f, -0.03402048f, 0.01484745f, 
    0.34300128f, -0.00261816f, -0.01367022f, -0.04701784f, 0.00460205f, -0.01728471f, -0.00644420f, -0.07014374f, 
    0.12130312f, 0.01411333f, 0.04731824f, 0.02964654f, 0.00451501f, -0.02562263f, -0.02508268f, 0.17879593f, 
    0.09692287f, 0.21434234f, -0.36489356f, -0.11215156f, 0.21300197f, 0.02902698f, -0.10072237f, 0.14670816f, 
    0.00922216f, 0.06135106f, 0.16098794f, 0.02565606f, -0.04132582f, -0.01697110f, -0.08519866f, 0.01008628f, 
    -0.06869899f, 0.00068308f, 0.02231529f, 0.10305299f, 0.01405062f, 0.09441711f, -0.50989944f, 0.10897858f, 
    0.04015823f, 0.06033797f, 0.16101249f, 0.28250962f, 0.04429451f, 0.09067042f, 0.13803771f, 0.07433511f, 
    0.06455339f, 0.12117079f, -0.00626435f, 0.12939142f, 0.08235601f, 0.02420889f, 0.09053383f, -0.04312529f, 
    -0.03466303f, 0.19834793f, -0.14137264f, -0.09746114f, 0.04231824f, 0.01782908f, -0.13467088f, 0.06406890f, 
    -0.05792541f, 0.00217553f, 0.08484576f, 0.09788293f, -0.05499539f, 0.05110432f, -0.08310297f, -0.14076105f, 
    -0.13289376f, -0.07529947f, -0.17518947f, 0.12414070f, 0.44232801f, 0.24436188f, -0.14148983f, -0.12327209f, 
    0.10772476f, 0.00904217f, -0.17236164f, 0.04795520f, 0.06281500f, -0.00514171f, 0.12395447f, 0.06051638f, 
    -0.04940816f, -0.00121468f, 0.04482499f, 0.01446536f, -0.00350927f, -0.07941499f, -0.12454085f, 0.02324091f, 
    0.11209503f, -0.05154179f, 0.39529651f, -0.30566207f, -0.11100781f, -0.06625577f, -0.07999805f, -0.08181448f, 
    0.04372703f, 0.01847363f, 0.04462552f, 0.09758084f, 0.10283229f, 0.09450614f, 0.10820988f, 0.06004189f, 
    0.01336622f, 0.05633579f, -0.02074295f, -0.03422552f, 0.17571406f, -0.04413068f, -0.05464860f, -0.02815407f, 
    0.12671675f, -0.05234520f, 0.06038656f, -0.07730138f, 0.02909165f, 0.03078010f, 0.05119913f, -0.04025743f, 
    -0.08972530f, -0.13939370f, -0.13953616f, -0.05953104f, -0.15635903f, -0.06538745f, 0.01390707f, -0.04141651f, 
    0.04816195f, 0.10791882f, 0.24498735f, -0.07614067f, 0.06332170f, 0.08253048f, -0.00399917f, -0.06141637f, 
    -0.12230407f, -0.01632991f, -0.07330375f, -0.08161615f, 0.08465354f, -0.05426073f, 0.00176003f, 0.07337998f, 
    -0.06456957f, -0.01270736f, -0.06408961f, -0.04791754f, -0.06383674f, -0.20500411f, -0.09227905f, -0.07422307f, 
    -0.03076259f, -0.02934758f, -0.09213116f, -0.04877209f, 0.06889746f, -0.06816015f, 0.08160176f, 0.06953487f, 
    0.11161946f, 0.06794874f, -0.06472024f, -0.11449707f, 0.09446523f, 0.11285209f, -0.01363192f, 0.09577716f, 
    0.30765525f, 0.39957851f, -0.27219296f, -0.14994635f, 0.04533278f, 0.03656335f, -0.11622431f, -0.02208273f, 
    -0.09002768f, -0.08534052f, 0.04796907f, -0.01736842f, 0.08699558f, -0.08497968f, -0.05790292f, -0.11256617f, 
    -0.11067423f, 0.09326018f, -0.03245570f, -0.08806504f, 0.08289865f, 0.08745680f, 0.11810066f, 0.04579651f, 
    0.10708948f, 0.00300747f, 0.16555467f, 0.02889173f, -0.00883462f, 0.03940957f, 0.21395773f, 0.11813653f, 
    0.00256433f, 0.06631406f, 0.05973774f, -0.01914092f, 0.02404005f, 0.02794300f, -0.14825261f, -0.18252283f, 
    -0.50937068f, -0.17897886f, -0.14819835f, -0.05559378f, -0.27648744f, -0.03617467f, 0.01061561f, 0.16745567f, 
    0.04231288f, 0.09408008f, -0.05875102f, 0.03962204f, 0.04054613f, 0.14268267f, -0.07858112f, 0.00780747f, 
    -0.13601498f, 0.09798278f, 0.22163352f, -0.06839472f, 0.13379580f, 0.35749868f, -0.26494077f, -0.15092221f, 
    -0.12602618f, 0.13104317f, -0.04791293f, -0.11114785f, 0.07271744f, 0.04444763f, -0.04197510f, 0.01896865f, 
    -0.16732593f, -0.17415547f, -0.06978903f, -0.19524318f, 0.03460810f, 0.18718202f, 0.03969145f, 0.23896228f, 
    -0.08255528f, 0.12742591f, -0.14686014f, 0.07416968f, 0.13050012f, -0.01120486f, -0.01166319f, 0.06988455f, 
    -0.00428715f, 0.11894228f, -0.02242903f, 0.03956266f, -0.02420203f, -0.06807616f, 0.00628108f, 0.00454765f, 
    0.06407025f, 0.12811536f, 0.07265645f, -0.10424555f, 0.33143228f, 0.10216460f, 0.14436208f, -0.17283845f, 
    0.30345738f, -0.05577790f, 0.12536807f, -0.11493619f, -0.16410843f, -0.06839829f, 0.08377197f, -0.06381220f, 
    0.00026458f, -0.04590185f, -0.05197105f, -0.00162689f, 0.01869517f, 0.07258882f, -0.10545622f, 0.06934832f, 
    0.26737031f, 0.23981044f, -0.18655120f, 0.20955023f, 0.27460983f, 0.07776966f, 0.05917485f, 0.18914101f, 
    -0.05069357f, -0.04612361f, -0.00465921f, -0.04875741f, 0.03065782f, -0.08405320f, 0.01249126f, -0.00109296f, 
    -0.03291494f, -0.19425456f, -0.02027819f, -0.04247113f, 0.06006498f, -0.24295850f, -0.06587199f, -0.00534237f, 
    -0.05542048f, 0.05895600f, 0.01505764f, 0.16147298f, 0.10672994f, 0.16072302f, -0.00235954f, 0.06139579f, 
    0.04091729f, 0.01403453f, -0.06262904f, 0.16783780f, 0.11671326f, 0.12541293f, 0.03853096f, 0.11568382f, 
    -0.12702726f, -0.30208081f, 0.41240069f, -0.18445672f, -0.02951948f, -0.00670470f, 0.01911833f, -0.08038917f, 
    0.07626294f, 0.05239071f, -0.06888185f, 0.03335549f, -0.00521775f, 0.16916068f, 0.04644178f, -0.06715887f, 
    0.11357236f, -0.02858403f, 0.05857072f, 0.03196968f, -0.23708251f, -0.11189472f, 0.36140421f, -0.30857792f, 
    -0.03687290f, -0.03107342f, -0.27174827f, -0.23525110f, 0.01865967f, 0.00739834f, 0.01840631f, 0.02994742f, 
    -0.02148792f, 0.04673417f, 0.04229966f, -0.03885854f, 0.23536228f, 0.06578582f, 0.02247231f, 0.13225877f, 
    -0.06465641f, -0.07807762f, 0.02187028f, 0.01284700f, -0.05414433f, 0.21627544f, 0.05124925f, 0.05618643f, 
    0.02228908f, -0.07113271f, -0.06060918f, 0.10477804f, 0.05493484f, -0.10659447f, 0.05218875f, 0.05391167f, 
    0.18695857f, -0.09506435f, -0.02087129f, -0.07643141f, -0.49225056f, -0.14930215f, 0.29933909f, 0.04517238f, 
    -0.04194866f, 0.09598979f, -0.05306204f, -0.13150002f, 0.04085177f, -0.01819890f, -0.17042318f, 0.12549627f, 
    -0.02273063f, 0.07167769f, 0.03880041f, 0.05316960f, -0.00580169f, -0.08623580f, 0.04074736f, -0.06418342f, 
    -0.03915667f, 0.14609224f, -0.23881119f, 0.29616350f, 0.11685283f, 0.00063310f, 0.04294858f, 0.04711061f, 
    -0.09311789f, 0.15020634f, -0.03140080f, -0.01791626f, -0.05174809f, -0.06093196f, 0.00706598f, 0.02181200f, 
    0.05856658f, 0.00239918f, 0.05013716f, 0.00567133f, -0.11693930f, 0.00539775f, 0.01150645f, -0.09001409f, 
    0.02540325f, -0.10910383f, 0.07985293f, 0.02509608f, 0.14477508f, 0.06098909f, -0.06323931f, -0.01171964f, 
    0.02262035f, 0.11076926f, 0.01374056f, -0.00125634f, 0.03299623f, -0.01786707f, 0.03328761f, 0.09733967f, 
    -0.14006923f, 0.06687339f, -0.04021458f, 0.04215773f, 0.13395099f, -0.02328118f, 0.05982549f, 0.05528378f, 
    0.14573304f, 0.09145868f, -0.07027961f, -0.07963111f, -0.09904847f, -0.01942241f, -0.01145621f, 0.03531568f, 
    0.02957853f, 0.09908827f, -0.02904725f, 0.09095766f, 0.21941374f, 0.01047547f, 0.11835264f, 0.05320461f, 
    -0.11297210f, 0.12140266f, 0.00004880f, 0.14737341f, -0.17382944f, 0.00828839f, -0.04750791f, -0.05099176f, 
    -0.04335012f, -0.08825210f, 0.14191610f, 0.00536477f, -0.09361449f, -0.04873793f, 0.05119956f, -0.04310935f, 
    0.20327346f, 0.28815585f, 0.18462482f, -0.01610938f, 0.15680115f, -0.03739791f, 0.02692300f, 0.12826961f, 
    0.08130643f, 0.21483426f, 0.03278538f, 0.06354991f, 0.02118796f, 0.08337531f, -0.02878703f, -0.20785403f, 
    -0.17539033f, -0.10759658f, -0.08694276f, -0.15755843f, -0.10064495f, -0.09394444f, 0.02490235f, 0.10149592f, 
    -0.08353753f, 0.01353226f, -0.05961301f, 0.00994639f, -0.06203878f, -0.17628461f, 0.02032340f, 0.02794810f, 
    -0.03064331f, -0.09050498f, 0.03470515f, -0.16456929f, -0.10969640f, -0.11281125f, -0.23888403f, -0.35701892f, 
    -0.06128956f, -0.18388100f, 0.06030243f, 0.00332882f, -0.10617317f, -0.14270854f, -0.04527812f, 0.02299996f, 
    0.09851325f, -0.26291797f, 0.04765072f, 0.08205391f, 0.04700165f, 0.09286853f, 0.05103810f, -0.04615145f, 
    0.22716004f, 0.00105984f, 0.11729979f, 0.07677811f, 0.27718240f, 0.15439476f, -0.23700671f, 0.22972681f, 
    0.20387298f, 0.08421557f, 0.06445387f, 0.11519575f, -0.12749109f, 0.27575198f, -0.08912688f, 0.00012071f, 
    0.00035365f, 0.07108326f, -0.10225294f, 0.28184286f, 0.15741350f, 0.11759210f, 0.24732068f, 0.36085457f, 
    -0.36546937f, -0.33027810f, 0.28950897f, 0.01620182f, -0.09575050f, -0.04157801f, 0.03378450f, 0.13925214f, 
    -0.04896531f, -0.27144906f, 0.02630466f, -0.06294056f, -0.09461276f, 0.04866867f, -0.17314340f, 0.06410889f, 
    -0.11278297f, -0.04575770f, -0.24124944f, -0.11111593f, 0.17067990f, 0.05807748f, -0.03822608f, -0.06108821f, 
    0.14772311f, 0.02138051f, 0.08346099f, -0.04988787f, -0.11029790f, -0.02678507f, 0.00880784f, -0.04179445f, 
    0.10447799f, 0.03554263f, -0.05078446f, -0.04476072f, 0.10888399f, 0.02071848f, 0.09822858f, 0.27463564f, 
    0.67817622f, 0.13808590f, -0.01717101f, 0.22488971f, 0.21909933f, -0.04290588f, -0.23170012f, 0.04880968f, 
    -0.07180034f, -0.07341471f, 0.05356302f, 0.01801432f, 0.00865213f, 0.05454437f, 0.02407764f, -0.00608763f, 
    -0.09867086f, -0.06652963f, -0.21703425f, -0.17815107f, 0.05453147f, 0.16501553f, 0.09092840f, 0.07383788f, 
    -0.19194274f, -0.05244302f, -0.05631680f, 0.18828493f, 0.07367998f, 0.10560808f, 0.12790787f, 0.11415231f, 
    0.12345109f, -0.01581155f, 0.05357571f, 0.09125147f, 0.15584111f, 0.07291961f, -0.00920793f, 0.19531316f, 
    -0.04568182f, 0.04163413f, 0.08977454f, 0.02042230f, -0.05669371f, 0.08093610f, -0.04635195f, -0.04862475f, 
    -0.12685923f, -0.14802074f, 0.07745399f, -0.03535308f, -0.12075391f, -0.05659186f, 0.00659505f, 0.02354962f, 
    0.05181964f, 0.04465237f, -0.16005294f, -0.19503604f, 0.28389856f, 0.29241586f, 0.05172257f, 0.16692300f, 
    0.14645989f, 0.04310592f, -0.00431844f, 0.09322916f, 0.08776179f, -0.03274255f, 0.09409031f, -0.19930710f, 
    0.05554884f, -0.14144884f, 0.07925483f, 0.20288703f, 0.25240195f, 0.14012779f, 0.16132627f, 0.17164592f, 
    -0.15724218f, 0.14772984f, 0.02934522f, -0.06619263f, -0.32801139f, -0.02103850f, 0.02275554f, 0.02651494f, 
    -0.09954761f, -0.10499393f, 0.01618803f, 0.05525766f, 0.02898507f, 0.10387034f, 0.04978726f, -0.03550392f, 
    -0.06860201f, 0.10279068f, -0.08857932f, -0.36513838f, -0.28118131f, -0.03029481f, 0.10943256f, 0.14641441f, 
    0.05500352f, 0.09591922f, 0.01018882f, -0.03653527f, 0.00134272f, 0.04641468f, -0.13174029f, -0.07335864f, 
    0.06972399f, -0.19443838f, -0.10128723f, 0.01215200f, -0.09712234f, -0.06821396f, -0.10047125f, -0.02176554f, 
    -0.14301403f, -0.12962079f, 0.06338850f, 0.24133967f, -0.00103308f, -0.03235407f, -0.04061402f, 0.12431736f, 
    0.03363809f, -0.17301250f, -0.03937579f, -0.05596149f, -0.03519056f, 0.07807308f, 0.05494437f, -0.06558169f, 
    -0.13948146f, -0.02658391f, 0.02384321f, -0.07313070f, 0.05401284f, -0.01760392f, 0.01888238f, -0.03773563f, 
    -0.06486452f, 0.16716410f, 0.00983502f, 0.00862021f, -0.08426033f, -0.18780653f, -0.09202101f, -0.13072482f, 
    0.12984587f, -0.01646755f, 0.10742392f, 0.10763310f, 0.02367169f, -0.02078491f, -0.15359373f, -0.00875311f, 
    -0.03536688f, 0.04555175f, -0.02593340f, -0.06427877f, -0.04144216f, -0.08920343f, -0.16572823f, 0.00128247f, 
    0.00861476f, -0.31808069f, -0.04356958f, 0.03892158f, -0.01519811f, 0.07367771f, 0.08963807f, -0.04265113f, 
    -0.16836442f, -0.15120260f, -0.09393596f, -0.26068410f, 0.02544348f, -0.02131052f, 0.07599434f, -0.04096961f, 
    0.12337753f, -0.11753225f, 0.04230432f, 0.00102630f, -0.03109849f, -0.05202824f, 0.04277081f, 0.04903041f, 
    0.00892499f, 0.11253749f, 0.13528611f, 0.06396045f, 0.16497131f, 0.09924604f, 0.08477795f, 0.23996188f, 
    0.14194311f, 0.03864778f, -0.04500855f, 0.00679352f, -0.26533565f, -0.01417702f, -0.28242177f, 0.03479904f, 
    -0.13595839f, 0.11510029f, -0.05006913f, -0.07611573f, 0.14687927f, 0.04908733f, 0.08090698f, 0.04172337f, 
    0.09849421f, -0.02237785f, 0.08956021f, 0.10766037f, 0.24347700f, 0.07957347f, 0.22558355f, 0.01855395f, 
    -0.11458865f, 0.05085300f, 0.08348341f, -0.15088788f, 0.01711317f, -0.10755333f, 0.06639908f, -0.07491811f, 
    0.13175879f, 0.04546555f, 0.01169323f, 0.02418334f, 0.11429431f, 0.10468172f, -0.03913760f, 0.00341041f, 
    0.08786599f, 0.10559966f, 0.23159355f, 0.25709620f, 0.02851835f, -0.03215304f, 0.00448220f, -0.02913127f, 
    0.01085361f, 0.03421498f, -0.11948138f, -0.18500029f, 0.05176570f, 0.04114034f, 0.01693612f, 0.10175464f, 
    -0.07242511f, 0.21990873f, -0.12421630f, -0.18451655f, -0.10410156f, -0.00595317f, 0.18546593f, -0.25227481f, 
    -0.19722392f, -0.16399512f, -0.16927609f, 0.01057017f, 0.03123299f, -0.16603392f, 0.06336570f, 0.16022086f, 
    0.06950060f, 0.12184765f, 0.12307592f, 0.10966445f, -0.00474395f, -0.01684627f, -0.17868789f, -0.25204578f, 
    0.30676904f, -0.05364092f, -0.20610166f, 0.13013770f, -0.03416049f, 0.04903834f, -0.03558637f, -0.00410249f, 
    0.01796045f, 0.03849420f, 0.07795544f, 0.09612938f, -0.12524857f, -0.07726302f, 0.12311017f, -0.10272033f, 
    0.09639540f, 0.00990213f, 0.14889218f, 0.02154693f, 0.06151343f, -0.03640293f, 0.18531057f, -0.20158310f, 
    -0.02279805f, 0.14884402f, 0.04019734f, 0.16472363f, 0.11308958f, -0.09536949f, 0.11778432f, -0.00900909f, 
    0.04359008f, -0.00550080f, 0.13883120f, 0.11515962f, 0.03310638f, -0.01075534f, -0.02750479f, -0.05978805f, 
    -0.29895231f, -0.35431045f, -0.38970280f, -0.10697009f, -0.18346603f, -0.04116399f, 0.18528698f, 0.10769734f, 
    0.08010153f, 0.15398145f, 0.09352184f, -0.09190621f, -0.03259793f, -0.12357494f, -0.12619255f, -0.06341206f, 
    0.10826159f, -0.09465160f, 0.07335323f, 0.03578774f, -0.11349054f, -0.16620362f, -0.03729916f, -0.05275720f, 
    -0.02573399f, -0.10136698f, -0.01525207f, 0.01104031f, -0.07565751f, -0.18727081f, -0.04901033f, -0.08689633f, 
    -0.02464660f, 0.09574968f, 0.05670926f, 0.04993056f, -0.06246639f, -0.06018775f, -0.07943762f, -0.29746112f, 
    0.16895677f, 0.16614249f, 0.26070204f, 0.14197089f, 0.04789914f, 0.05301515f, 0.13189758f, -0.08822728f, 
    0.08855813f, -0.01018450f, -0.12210924f, -0.01901776f, 0.02882365f, 0.00207557f, 0.01509630f, -0.01895243f, 
    0.12666073f, -0.08613688f, -0.02258218f, 0.05313380f, 0.22056876f, -0.02205515f, 0.45303217f, -0.06071447f, 
    -0.11491945f, 0.17380366f, -0.10497071f, -0.15336412f, 0.04594293f, -0.01259568f, -0.18110186f, 0.07028753f, 
    -0.06401991f, 0.03568354f, 0.00469323f, -0.02096621f, 0.00508782f, -0.03050725f, -0.01742035f, 0.04881671f, 
    0.04856189f, -0.10067442f, 0.09413001f, 0.06049935f, 0.01499538f, -0.04450654f, -0.00807795f, -0.03047878f, 
    0.11298935f, 0.04615545f, -0.00029860f, -0.04581808f, 0.04301420f, -0.16078244f, 0.17128615f, 0.12860420f, 
    0.00117159f, 0.05203465f, 0.02211866f, 0.00676824f, 0.04461306f, -0.01546370f, 0.14664917f, 0.08270326f, 
    0.06269941f, 0.06129317f, 0.00288151f, -0.07068144f, 0.03139536f, -0.03626646f, -0.15993731f, -0.01120286f, 
    -0.05280883f, 0.10274542f, 0.00313854f, -0.06769633f, 0.15536894f, -0.01591239f, 0.14594235f, -0.00610892f, 
    -0.04416656f, -0.27063042f, -0.40560037f, 0.01886270f, -0.09434281f, -0.01122815f, 0.09779281f, -0.00022871f, 
    0.09845757f, 0.16280103f, 0.05300231f, 0.05776671f, 0.01843253f, -0.08993525f, -0.03722406f, -0.01653084f, 
    0.00155953f, 0.06219688f, 0.01669678f, 0.05300305f, 0.00912231f, 0.14581627f, 0.00936922f, 0.15241939f, 
    -0.03476601f, -0.08869214f, -0.03688616f, 0.00684052f, -0.05141066f, -0.09791543f, -0.11122613f, -0.09862848f, 
    -0.12647039f, 0.01723927f, -0.06011586f, -0.10520744f, 0.08915364f, 0.09412616f, -0.07949784f, 0.03572514f, 
    -0.09409571f, -0.09076272f, -0.15178150f, 0.07514487f, -0.12033841f, -0.02894337f, 0.12114558f, 0.10006783f, 
    0.03174959f, -0.05427266f, 0.11698924f, 0.09245005f, 0.04130714f, 0.04430497f, 0.02026552f, -0.15068778f, 
    0.06998441f, 0.07272734f, 0.02398823f, 0.03412022f, 0.02926413f, 0.05348824f, -0.13011448f, -0.03845550f, 
    -0.07230639f, 0.13147543f, -0.00584345f, 0.06749228f, 0.02452136f, 0.15247490f, 0.01983413f, 0.02421864f, 
    0.01634813f, 0.05574388f, 0.02781549f, 0.21709290f, -0.04247333f, -0.01675358f, 0.06212124f, 0.08701581f, 
    0.39301190f, 0.10277739f, 0.26129964f, -0.47904298f, -0.19274087f, 0.02571073f, 0.10559684f, 0.00771487f, 
    -0.00054588f, 0.10055938f, 0.19522026f, -0.11989585f, 0.15596761f, -0.10021242f, 0.08654229f, 0.07480253f, 
    0.08945879f, -0.12378072f, 0.00143527f, 0.16025351f, 0.16334325f, -0.03547470f, -0.06050840f, 0.09269204f, 
    -0.23347099f, 0.21664296f, -0.08181670f, 0.06317895f, -0.14238745f, -0.01987005f, 0.00394297f, -0.05074742f, 
    0.07512749f, 0.01467855f, -0.21429132f, -0.00073541f, 0.03593772f, 0.06999081f, 0.07473955f, 0.15480219f, 
    0.20954497f, 0.30019185f, 0.31545758f, -0.02247141f, 0.22802714f, -0.07106854f, 0.09365869f, -0.05276137f, 
    0.01551668f, -0.11480267f, 0.02652558f, -0.04465595f, 0.11026947f, -0.05035915f, 0.09930176f, -0.01919666f, 
    -0.03827038f, 0.07824242f, -0.06010465f, -0.04577658f, 0.19893697f, 0.30157626f, 0.22951028f, -0.09398942f, 
    -0.29013714f, 0.05397663f, -0.09294727f, -0.19785298f, 0.02443223f, -0.02304526f, 0.11727446f, 0.04597403f, 
    0.03128144f, 0.08042736f, -0.02328110f, 0.08530140f, 0.06334686f, -0.03547169f, -0.01584745f, -0.25568724f, 
    0.50405043f, -0.30922431f, 0.24210279f, -0.17967348f, 0.01216432f, -0.08173990f, -0.01048336f, -0.05579566f, 
    -0.18498975f, 0.08392901f, 0.17169333f, -0.07835747f, 0.12600994f, -0.03939491f, -0.05765807f, -0.11481840f, 
    0.21707493f, -0.18116646f, 0.07553615f, 0.02362692f, -0.12752999f, -0.00103370f, 0.01060761f, -0.21369155f, 
    -0.41706896f, 0.17981572f, -0.20696400f, 0.06088604f, 0.11881958f, -0.00874890f, 0.12582166f, 0.05630560f, 
    -0.04776876f, -0.08594549f, 0.13459812f, 0.07068852f, -0.01528383f, -0.00033283f, -0.03117757f, -0.05520979f, 
    0.12849379f, -0.27871138f, -0.41410983f, -0.35026875f, -0.30239850f, -0.07766881f, 0.11449959f, 0.13971286f, 
    0.05223416f, 0.10825390f, 0.12606882f, -0.16416743f, -0.11692916f, 0.05417211f, -0.03207838f, -0.05911911f, 
    0.21284010f, 0.11750996f, 0.01047981f, 0.13316222f, 0.18441337f, 0.20510729f, -0.04321357f, 0.06679780f, 
    -0.04441025f, -0.15911344f, -0.02567532f, 0.08920139f, 0.01657766f, -0.08099444f, 0.00503350f, -0.03292397f, 
    -0.05123160f, 0.07468938f, -0.06401166f, -0.04081344f, -0.15435152f, -0.18402152f, 0.03114237f, -0.10710920f, 
    0.08286298f, 0.33971992f, -0.18265858f, 0.25942293f, -0.07464670f, -0.08013243f, -0.01186711f, -0.08491389f, 
    -0.04804533f, -0.01875550f, -0.02272541f, 0.06412794f, 0.07132872f, 0.06011394f, -0.00422050f, 0.08008184f, 
    -0.04158126f, 0.05113756f, -0.04182643f, 0.05644357f, -0.08053003f, 0.68101889f, 0.09447753f, 0.23259960f, 
    -0.03835319f, 0.15911050f, -0.13299797f, -0.13072781f, -0.10567388f, -0.10009225f, -0.03780763f, 0.07233111f, 
    0.05883642f, 0.01507790f, 0.05857719f, 0.07535239f, 0.00230698f, 0.06187940f, 0.02325116f, -0.15367581f, 
    0.12483025f, -0.05806310f, 0.08357356f, 0.19065787f, 0.14686503f, -0.09760572f, 0.08923569f, 0.01940490f, 
    -0.13457294f, 0.03631185f, -0.03951739f, -0.13378668f, -0.08155854f, 0.01834609f, 0.00909274f, 0.01760482f, 
    -0.12819721f, 0.00781387f, -0.11627336f, 0.11201455f, -0.01525978f, 0.22252277f, -0.23280150f, 0.03781536f, 
    0.04831422f, -0.07258233f, 0.03873806f, -0.03863875f, 0.07652957f, -0.00432134f, 0.02067851f, -0.00957875f, 
    0.03179498f, 0.03248370f, -0.06424877f, 0.04812834f, 0.08748071f, -0.10671544f, 0.00896077f, 0.03262361f, 
    0.23445584f, -0.53171527f, -0.20066491f, -0.20504111f, -0.19254884f, 0.04323051f, -0.11010987f, 0.13946396f, 
    0.03440797f, 0.03403540f, 0.03462280f, 0.06104165f, -0.05800646f, 0.09803534f, -0.13153273f, 0.00536378f, 
    0.00362871f, 0.02316296f, -0.00184125f, 0.01591975f, 0.06588805f, 0.32836738f, 0.04919354f, 0.27357158f, 
    0.00144123f, 0.00316899f, 0.08608007f, 0.00142799f, 0.03670647f, -0.21659687f, 0.02459799f, 0.09109583f, 
    -0.04576128f, 0.05843658f, 0.04916233f, -0.06921241f, 0.05069101f, -0.04109194f, 0.07913427f, -0.11388022f, 
    0.14375728f, -0.09985486f, -0.09653089f, -0.01167147f, -0.12320437f, 0.01801401f, -0.00104644f, 0.05929542f, 
    -0.13555488f, -0.01965449f, 0.08542234f, -0.04245276f, -0.03322605f, 0.01360738f, -0.06294210f, -0.01328376f, 
    0.04768987f, 0.04044043f, 0.05218467f, 0.01159670f, 0.24768904f, -0.15542999f, -0.18504882f, -0.40055659f, 
    0.00034978f, 0.07376706f, -0.00232117f, 0.03664443f, -0.02043605f, 0.13390072f, 0.06430905f, 0.03384813f, 
    -0.03185842f, -0.08261494f, 0.00083276f, 0.16959128f, 0.01928657f, 0.01095285f, 0.09433725f, 0.14583611f, 
    -0.69398260f, 0.25915843f, -0.16741472f, 0.12923391f, 0.10673121f, 0.07005175f, -0.13430099f, 0.02747007f, 
    0.08676939f, -0.13060282f, -0.16778685f, -0.06446865f, -0.01677074f, 0.09733307f, 0.04471329f, -0.07304026f, 
    -0.08813318f, 0.09611671f, -0.24227421f, 0.16457860f, -0.16566518f, -0.13577369f, 0.22860068f, -0.09038395f, 
    0.08673373f, -0.09434094f, 0.20629409f, 0.04067561f, -0.09424298f, 0.21596204f, 0.02766571f, -0.05648180f, 
    0.10074767f, 0.10126275f, -0.04364767f, -0.07878293f, -0.02614743f, 0.03751756f, -0.01118171f, 0.02606523f, 
    0.33132404f, 0.18052356f, 0.01053387f, 0.25068551f, 0.05061340f, 0.02496283f, -0.12224212f, 0.07454741f, 
    0.00260514f, 0.01471932f, 0.02160706f, 0.11831872f, 0.01482962f, 0.01307904f, 0.00786210f, 0.00955540f, 
    -0.03353985f, 0.02111218f, 0.18364088f, -0.06463641f, -0.11797125f, -0.23819749f, -0.13473050f, 0.17519733f, 
    0.05193850f, 0.04684933f, 0.02940689f, 0.03564695f, 0.15664932f, -0.03432787f, -0.02477645f, 0.07764308f, 
    0.03795077f, -0.07623027f, 0.03887936f, -0.19169536f, 0.07271490f, -0.16539478f, -0.15654202f, -0.07499055f, 
    0.35490027f, 0.19096106f, -0.08746702f, -0.03281510f, -0.02437235f, 0.00447579f, -0.00352807f, 0.10091643f, 
    0.12573905f, -0.02089003f, -0.12074082f, 0.10200750f, -0.01497522f, -0.01217723f, -0.06334496f, -0.07981993f, 
    -0.02752408f, 0.13486111f, 0.06592428f, 0.09509267f, -0.21072379f, -0.20567621f, 0.13639148f, 0.01963978f, 
    0.24151003f, -0.08385867f, 0.07749622f, 0.06765432f, -0.17595962f, -0.01801074f, 0.09520052f, -0.02501525f, 
    -0.07260780f, -0.14124134f, -0.03250602f, 0.19075717f, -0.01439671f, -0.00039755f, 0.02967272f, -0.21755129f, 
    -0.33842698f, -0.13394292f, -0.04375483f, 0.01460489f, -0.02234971f, -0.01761436f, 0.07281376f, 0.07313718f, 
    0.05834486f, -0.13946234f, -0.17044066f, 0.04525629f, -0.01012365f, 0.09386320f, -0.10457643f, -0.01739099f, 
    -0.07252492f, -0.02845841f, -0.01391400f, 0.05029059f, 0.20596364f, -0.10789075f, 0.22793595f, 0.06100882f, 
    -0.01709744f, -0.03528166f, -0.00639708f, 0.03958029f, -0.01009470f, 0.08846382f, 0.16463350f, 0.07475708f, 
    0.01324804f, -0.13568784f, 0.02798303f, -0.00155881f, -0.11497376f, -0.31950757f, 0.00412330f, -0.18566447f, 
    0.14251238f, -0.03728610f, 0.21761404f, -0.02641248f, 0.05625083f, -0.09155545f, -0.08907955f, -0.01332823f, 
    -0.05077195f, -0.01973226f, 0.03758335f, 0.02775297f, 0.04048529f, 0.07842737f, 0.06912929f, -0.02279729f, 
    0.16875803f, -0.08091472f, 0.05421077f, 0.09922498f, 0.15562367f, -0.11578076f, -0.06855828f, -0.17788056f, 
    -0.01075103f, -0.26016882f, -0.24200945f, -0.01579894f, -0.21214202f, -0.02746124f, -0.06910811f, -0.08517151f, 
    -0.00316882f, 0.10358772f, 0.02784874f, -0.01384105f, 0.07764613f, -0.13393778f, 0.13258684f, 0.02751702f, 
    0.30842355f, 0.06797834f, 0.28596619f, 0.07680309f, -0.00560969f, 0.06144059f, -0.08697372f, -0.00130183f, 
    0.18978171f, -0.15807505f, 0.08797199f, -0.03714287f, 0.17876476f, -0.01806075f, -0.12220535f, 0.05707832f, 
    0.25312242f, -0.11469059f, 0.05176711f, -0.05826162f, -0.04570141f, -0.07864858f, 0.17354620f, 0.00350149f, 
    -0.16569413f, 0.08452745f, -0.17119907f, 0.11865812f, -0.00115357f, -0.00797177f, 0.00217207f, 0.07157855f, 
    -0.01497889f, 0.12472032f, 0.01958046f, -0.01162497f, 0.09184165f, 0.17727695f, 0.14937481f, 0.09835627f, 
    0.56049657f, 0.21413809f, -0.25633886f, 0.19065699f, -0.21023248f, -0.10179286f, 0.06651542f, 0.03898866f, 
    -0.00825458f, 0.02926142f, 0.12196341f, -0.07336814f, 0.00286690f, -0.12222958f, -0.04289900f, 0.00168140f, 
    -0.10807315f, -0.05009760f, -0.01571608f, 0.02491683f, 0.10326375f, -0.01033780f, 0.08508340f, 0.01780492f, 
    0.10402231f, -0.03154719f, -0.08419945f, -0.04007538f, -0.03405260f, -0.03090389f, 0.13867596f, 0.05717636f, 
    0.01964897f, -0.09291990f, 0.07408439f, -0.06381822f, 0.05041600f, -0.04668206f, 0.00231266f, -0.04894425f, 
    0.15641950f, -0.11975192f, -0.06267849f, 0.09584441f, -0.07366130f, -0.05626846f, -0.03062437f, 0.08801141f, 
    0.03685563f, 0.05784287f, -0.04762136f, 0.05366778f, 0.00415706f, -0.13518594f, -0.05743261f, -0.09170744f, 
    -0.04749078f, -0.04284047f, -0.04581003f, -0.03633844f, 0.00778176f, 0.07608247f, 0.20279261f, 0.22337760f, 
    -0.05694719f, 0.12705494f, 0.00209044f, -0.03701203f, 0.05179364f, -0.04650065f, -0.02424946f, -0.12012503f, 
    0.03830462f, -0.07419178f, -0.07592219f, -0.02698792f, 0.17476761f, -0.10819728f, 0.05860018f, 0.05584829f, 
    -0.03424264f, -0.36245075f, 0.23579088f, 0.15657137f, -0.04477997f, -0.00313954f, -0.04591930f, 0.06464896f, 
    -0.06120920f, 0.03183142f, 0.03912406f, -0.03292403f, -0.07431728f, -0.04120537f, 0.03002314f, 0.03073576f, 
    0.08709467f, 0.12515172f, -0.11387220f, -0.20523657f, 0.38116863f, 0.03288902f, -0.03473593f, 0.03135764f, 
    -0.07398693f, 0.09767094f, 0.06169631f, -0.15373980f, 0.03465301f, -0.06759006f, 0.03951970f, -0.00084003f, 
    0.00111349f, -0.08865319f, 0.05292694f, 0.00976194f, -0.05103124f, 0.02303299f, -0.14756578f, -0.02565544f, 
    -0.08159903f, 0.02106142f, 0.23102355f, 0.05774380f, -0.20755498f, -0.05427318f, 0.03748450f, -0.07220824f, 
    -0.11256124f, -0.03203561f, -0.03092479f, -0.12535918f, 0.04262502f, -0.02070661f, -0.09258581f, -0.04949297f, 
    0.07256749f, -0.00853080f, 0.02892970f, -0.13141106f, 0.05247853f, 0.00287972f, 0.11200175f, 0.13500106f, 
    0.23535998f, 0.00040314f, -0.12059085f, 0.04006911f, -0.05548903f, 0.01867021f, -0.04910859f, 0.04506066f, 
    -0.15343174f, 0.01744608f, 0.01456062f, -0.04431114f, 0.09088130f, 0.24195170f, 0.08715243f, 0.09290778f, 
    -0.12550825f, -0.12341574f, -0.25926200f, 0.11252045f, -0.14304087f, 0.03311026f, -0.02142418f, 0.14559707f, 
    -0.17860316f, -0.06769366f, -0.03782432f, 0.02988533f, -0.15550521f, -0.09228241f, -0.03291486f, 0.14247301f, 
    -0.05743611f, 0.19397959f, -0.09249188f, -0.06029137f, 0.15022732f, -0.01357157f, 0.02135388f, -0.08235446f, 
    0.16868591f, 0.12381630f, 0.12300024f, -0.04509037f, -0.13702464f, 0.04510915f, -0.08497388f, -0.05824423f, 
    0.02891307f, 0.13987333f, 0.11584428f, -0.00912526f, 0.09260774f, 0.08026069f, 0.04443703f, 0.01495591f, 
    -0.37916872f, -0.24087079f, -0.30447829f, 0.19050273f, 0.21564181f, 0.01478217f, -0.16671236f, 0.11438438f, 
    -0.10383576f, 0.19918458f, -0.06238719f, -0.06537028f, 0.04912263f, -0.04962168f, -0.01140863f, -0.00007943f, 
    0.02736641f, -0.01138842f, -0.04627314f, 0.01118412f, -0.27457210f, 0.07769713f, -0.16110161f, -0.05097830f, 
    -0.08945963f, -0.05336449f, 0.06604996f, 0.02704182f, 0.00300872f, 0.04231108f, -0.11164855f, -0.15727185f, 
    0.05222693f, 0.05987450f, 0.17724848f, 0.01898797f, 0.08590019f, 0.02099733f, 0.01547749f, 0.04442926f, 
    0.30146801f, -0.02113089f, 0.26907411f, 0.02334964f, 0.00019823f, 0.06182951f, 0.09814119f, -0.24534282f, 
    0.07284176f, 0.03698172f, -0.12109666f, -0.00805948f, 0.03623968f, 0.06392200f, 0.04117323f, 0.02955412f, 
    -0.06252786f, -0.11166580f, -0.08667958f, 0.05496883f, 0.46506780f, -0.29892278f, 0.56340909f, -0.10356572f, 
    0.12060216f, 0.15811029f, 0.00909619f, -0.29290360f, 0.27641338f, 0.07013565f, -0.02231002f, 0.04505807f, 
    -0.01001161f, -0.05666275f, -0.04395439f, -0.13367622f, 0.04290320f, 0.08644959f, -0.00245308f, 0.07654077f, 
    0.01527948f, 0.08214511f, -0.14519864f, -0.03556389f, 0.06942500f, -0.07842131f, 0.00859430f, -0.07085423f, 
    0.00667005f, 0.10144367f, -0.05379350f, 0.05562972f, 0.04730761f, -0.18408780f, 0.11113570f, 0.04282146f, 
    -0.17262127f, -0.03614490f, -0.07223101f, 0.08602975f, 0.16730848f, -0.09045237f, 0.34917891f, 0.13956580f, 
    0.40743747f, 0.04441340f, 0.08506174f, -0.20682436f, 0.06198039f, -0.05419630f, -0.10949833f, -0.05104078f, 
    -0.02423750f, -0.00959980f, 0.02039897f, 0.05104697f, 0.12322035f, 0.01026356f, 0.01454247f, 0.02877844f, 
    -0.49807620f, -0.04910352f, -0.04626229f, -0.05110313f, 0.17558810f, -0.11998646f, 0.20638725f, 0.02737319f, 
    -0.07473073f, -0.08432563f, -0.13777862f, 0.03858989f, 0.07070401f, 0.05986781f, 0.13278796f, 0.02512389f, 
    -0.00999021f, 0.04887357f, -0.09849183f, 0.06853345f, -0.07695175f, 0.10960865f, 0.00972530f, 0.04071536f, 
    -0.01234048f, 0.04287411f, 0.05336256f, -0.11734507f, -0.09471421f, 0.03469458f, -0.16863440f, -0.08167412f, 
    -0.08461587f, 0.08558195f, -0.06744458f, 0.07225554f, 0.10655823f, 0.03203709f, -0.20763405f, 0.02630346f, 
    -0.26675642f, 0.06199943f, -0.28434256f, -0.00103511f, -0.05754157f, 0.01713545f, 0.08558436f, 0.13612452f, 
    -0.09566701f, -0.02950158f, -0.05109869f, 0.06297660f, -0.00490925f, 0.00595881f, -0.02941702f, -0.05741163f, 
    -0.03722184f, -0.00026574f, -0.14608569f, -0.00824706f, -0.10078110f, 0.05132906f, -0.15758952f, 0.10745496f, 
    0.13274443f, -0.07598754f, -0.02280678f, 0.01903007f, -0.06452129f, -0.02569922f, -0.04852149f, -0.00162394f, 
    0.05096412f, 0.06560560f, 0.09028285f, 0.07727544f, -0.05289340f, 0.07967123f, -0.05330252f, 0.06598048f, 
    0.32906392f, -0.53027362f, -0.52278370f, 0.03457157f, 0.08500761f, 0.03473008f, 0.09165532f, -0.14794590f, 
    0.15282425f, -0.08223013f, 0.04906654f, 0.09135535f, -0.06005779f, -0.04588265f, 0.00103561f, 0.05546244f, 
    0.05846298f, 0.16597940f, 0.11792743f, 0.10833376f, -0.04510749f, 0.17238151f, -0.35579243f, -0.04220076f, 
    -0.06536706f, -0.10605307f, -0.07941987f, 0.06021959f, 0.20105368f, -0.07043286f, -0.02283079f, -0.02983849f, 
    -0.06792239f, -0.01638852f, -0.00515501f, -0.00230887f, 0.05892688f, 0.02003411f, 0.19069515f, 0.06426964f, 
    -0.34226871f, 0.03023192f, -0.17256914f, -0.26135233f, 0.03966008f, -0.04468218f, -0.04750588f, -0.10264546f, 
    -0.06082037f, -0.02390129f, 0.01080242f, 0.10656223f, -0.04432720f, 0.04331509f, 0.07126146f, -0.05147688f, 
    0.05905165f, -0.03015444f, -0.24156487f, 0.07512112f, -0.02388366f, -0.16607149f, -0.14827225f, -0.22315231f, 
    0.08604220f, -0.07490020f, 0.10176682f, 0.05675246f, -0.15359871f, -0.08925748f, -0.02066157f, -0.03683804f, 
    0.03429489f, 0.03384060f, 0.01154659f, 0.21634783f, 0.08467618f, 0.06367977f, 0.10455544f, -0.01935692f, 
    -0.28555125f, 0.06538698f, 0.11006185f, -0.08493777f, -0.00655450f, 0.00829579f, 0.04318792f, -0.06622928f, 
    0.09850009f, 0.10211987f, 0.16591614f, -0.04247605f, 0.07626208f, 0.12276454f, 0.14720036f, 0.06002525f, 
    -0.05613423f, 0.00436553f, -0.06098391f, 0.11478803f, 0.24717651f, 0.40873009f, -0.30006680f, 0.23252182f, 
    -0.02402729f, -0.03054191f, -0.07929213f, -0.10444625f, 0.12994097f, 0.12345910f, 0.01402076f, 0.04333415f, 
    0.09063670f, -0.00522694f, -0.01606056f, 0.02638294f, 0.04204352f, 0.06439099f, 0.06936144f, 0.01479447f, 
    -0.17496543f, 0.17131849f, 0.45151433f, -0.21045804f, 0.04828054f, -0.06123475f, -0.09271372f, -0.12516727f, 
    0.16019173f, 0.19261725f, -0.09473220f, 0.06307684f, -0.09014636f, -0.02269405f, 0.05580989f, -0.02447261f, 
    0.00515309f, 0.03672115f, 0.14032942f, -0.00484260f, -0.00090483f, 0.26617798f, 0.28283626f, -0.09123573f, 
    0.11296922f, -0.01803113f, -0.05121345f, -0.11153860f, 0.08255781f, 0.02116005f, 0.12855043f, 0.19216038f, 
    0.14339653f, 0.04548056f, 0.08923874f, -0.03779545f, 0.02512405f, 0.06560408f, -0.11749572f, -0.02184263f, 
    -0.35926753f, 0.17651749f, -0.06741684f, -0.13494880f, 0.06246407f, 0.04693782f, 0.09617474f, 0.20569806f, 
    0.00025427f, -0.01013264f, -0.03991761f, -0.05713626f, -0.02254591f, -0.01709829f, 0.00416924f, 0.00867082f, 
    -0.01507932f, -0.00792919f, 0.08318699f, -0.07589804f, -0.20642115f, -0.13704099f, -0.26095533f, 0.04005013f, 
    0.24098299f, -0.05643091f, 0.17113653f, 0.26460868f, -0.12695684f, -0.05369493f, -0.01570131f, -0.02214052f, 
    -0.00496967f, 0.05239941f, 0.01875217f, 0.13052233f, -0.11707412f, -0.12365108f, -0.02254134f, 0.02873979f, 
    -0.29588187f, 0.09053125f, -0.14633425f, -0.05871459f, -0.04825406f, 0.04155556f, -0.17196210f, 0.02996819f, 
    -0.09331581f, -0.02712000f, 0.00365696f, 0.15072402f, -0.06423379f, 0.20643912f, 0.08227038f, -0.10061003f, 
    -0.06003742f, 0.01985291f, 0.09236412f, 0.11919536f, -0.20234570f, 0.14837447f, -0.14509454f, -0.06832977f, 
    0.05574536f, 0.06372540f, 0.06099961f, 0.10215513f, -0.05972942f, -0.11625084f, 0.06662384f, -0.05754301f, 
    0.08929557f, -0.06333285f, 0.08742254f, -0.00133348f, -0.10302698f, 0.03703031f, -0.14684683f, 0.00879372f, 
    -0.15038365f, 0.37523478f, 0.61888456f, -0.06789457f, 0.40712225f, 0.03238584f, -0.09921043f, -0.09477783f, 
    0.04771770f, 0.02112927f, 0.11251991f, 0.04784108f, 0.13618843f, 0.08983772f, 0.09548625f, -0.01655855f, 
    0.01105560f, -0.07690094f, 0.05267388f, -0.00192957f, -0.27232689f, -0.26952246f, -0.10117152f, -0.24860254f, 
    -0.16348800f, -0.04453688f, -0.07290442f, -0.05824707f, -0.06843437f, 0.00721128f, -0.05637551f, -0.03167640f, 
    -0.01885375f, -0.05565856f, -0.03201883f, 0.01170746f, -0.03581175f, -0.06711069f, 0.04122731f, -0.03244224f, 
    -0.12449825f, 0.08145308f, 0.25421634f, -0.06739242f, 0.11560290f, -0.03614923f, -0.03780908f, -0.13207830f, 
    -0.05447139f, 0.12600851f, 0.07893234f, 0.03114649f, 0.05498588f, 0.09128156f, 0.11029114f, -0.03196299f, 
    -0.09634107f, -0.09053203f, 0.19305773f, -0.02862087f, 0.01190422f, -0.00461012f, -0.21298535f, 0.11093397f, 
    0.32234630f, -0.10833104f, 0.01758253f, -0.13498770f, 0.12745798f, 0.08624005f, 0.10506820f, -0.00598570f, 
    -0.02342616f, 0.01729518f, -0.01365504f, 0.02215947f, 0.08882935f, 0.04714216f, -0.03680565f, -0.06382491f, 
    -0.19585276f, 0.33580026f, 0.11062793f, 0.16312264f, 0.10272148f, -0.15162827f, -0.06468261f, 0.15478021f, 
    0.16451651f, -0.04460339f, -0.08735842f, -0.11223780f, 0.06848428f, 0.14465143f, 0.04065455f, -0.01034957f, 
    0.13716358f, -0.00610370f, 0.11517717f, 0.16117570f, -0.36319309f, -0.18567950f, 0.11882760f, -0.10294106f, 
    0.12882283f, -0.07054987f, 0.11399380f, 0.01614912f, -0.09075829f, 0.05760084f, 0.00108885f, 0.01792692f, 
    0.04248168f, 0.10531156f, -0.03395286f, -0.05659533f, 0.01458050f, -0.00807770f, 0.05883130f, 0.13045536f, 
    0.20460105f, -0.04377853f, -0.10371220f, -0.16330554f, -0.19883655f, -0.05832483f, -0.03934148f, 0.09485124f, 
    -0.06716560f, -0.05059605f, -0.16189456f, 0.03821201f, 0.07746451f, -0.08401328f, -0.00648486f, 0.09598812f, 
    -0.06903605f, 0.01569300f, 0.06289605f, 0.05903628f, 0.00662441f, 0.08990021f, 0.05774117f, 0.29454905f, 
    -0.11233824f, 0.05819806f, 0.06621397f, -0.08254239f, 0.15273145f, -0.04819752f, 0.17122333f, 0.03629464f, 
    0.04072201f, -0.05573498f, 0.04484795f, -0.07932873f, 0.01835035f, -0.10528047f, -0.21595928f, -0.03524285f, 
    0.42593411f, 0.00836564f, -0.09153390f, -0.01065853f, -0.01406084f, 0.01355896f, -0.02486308f, -0.13728771f, 
    0.08511242f, 0.14080012f, -0.17969035f, 0.00515609f, -0.10997553f, 0.05928794f, 0.08906931f, 0.00503772f, 
    0.08251818f, -0.10689186f, 0.13164806f, 0.08763520f, -0.02500132f, -0.15123081f, 0.15602113f, 0.15289110f, 
    0.15317202f, -0.00006312f, 0.09144568f, 0.17636484f, 0.15211450f, 0.01766935f, 0.04876124f, 0.04780914f, 
    0.02221890f, -0.06362992f, -0.10372290f, 0.14407060f, -0.04558813f, 0.07451023f, -0.10099766f, -0.12364864f, 
    0.13186727f, 0.06346644f, 0.14169274f, 0.05137673f, -0.17101903f, -0.07095917f, 0.16869964f, 0.01959201f, 
    0.02903694f, -0.09705362f, 0.05028305f, 0.06032272f, 0.04710411f, -0.01473089f, 0.07937571f, 0.05104975f, 
    0.08066719f, -0.07214905f, 0.08733889f, -0.06812126f, 0.36380240f, -0.31412080f, 0.10606898f, 0.26911390f, 
    0.07993109f, -0.18113153f, 0.02182544f, -0.11556797f, -0.16500093f, -0.15429579f, 0.01655712f, 0.16081306f, 
    0.01961676f, -0.00685234f, -0.06116680f, 0.08659303f, -0.09997442f, -0.11773575f, 0.04810632f, 0.01349640f, 
    -0.15439388f, -0.35236344f, -0.22862841f, -0.34528244f, -0.45556706f, 0.02265941f, -0.05280736f, -0.01786345f, 
    -0.00510492f, 0.06359320f, -0.05861113f, 0.06813400f, 0.04666479f, 0.01218918f, -0.10512973f, -0.00622131f, 
    0.05508038f, 0.01150448f, 0.06351936f, 0.04505395f, -0.34736344f, 0.08018764f, -0.40741527f, -0.09147857f, 
    -0.53974158f, -0.04459624f, -0.16470860f, 0.06218546f, -0.12586777f, -0.02805145f, -0.06064814f, 0.07251874f, 
    0.04504029f, 0.07513631f, -0.14419538f, -0.03893697f, 0.10111290f, -0.07442113f, 0.00258652f, 0.03052454f, 
    0.25328377f, -0.23712446f, 0.07616093f, 0.19595565f, -0.09153111f, 0.00106328f, 0.03560904f, -0.07541507f, 
    0.07660370f, -0.19182867f, -0.05303011f, -0.14064616f, 0.06499469f, 0.07604958f, -0.00744679f, 0.16242772f, 
    0.17179899f, -0.06257480f, -0.05390214f, -0.00366377f, -0.34121832f, -0.44674653f, -0.10721914f, -0.28638989f, 
    -0.86924475f, 0.03283015f, -0.19482838f, 0.10855059f, 0.04795861f, 0.03942307f, 0.04975704f, -0.05966835f, 
    0.02273753f, 0.03709386f, 0.13802479f, -0.03662486f, -0.06450579f, -0.02587491f, 0.08983421f, 0.05900472f, 
    0.47256371f, 0.00839684f, -0.30713817f, 0.08635679f, -0.38542557f, -0.08414236f, -0.06410017f, 0.00797575f, 
    0.06469888f, 0.12701324f, 0.05067258f, -0.09183128f, -0.13940054f, -0.05528680f, -0.05872646f, 0.04018617f, 
    -0.03184454f, -0.09226281f, 0.02728320f, 0.15416507f, 0.21348508f, -0.34672114f, -0.07191202f, -0.43601471f, 
    -0.48899886f, -0.09876555f, 0.03237820f, 0.15492563f, -0.10753796f, -0.06754541f, -0.01774805f, -0.00061537f, 
    -0.03376619f, -0.20577008f, -0.01897264f, -0.07558578f, 0.05511639f, 0.01031926f, 0.02069786f, 0.02193074f, 
    0.03333250f, -0.31839004f, -0.07945696f, -0.05723121f, -0.24502578f, -0.26031289f, 0.02130863f, -0.04427551f, 
    0.11571231f, -0.04439919f, 0.05244949f, -0.01510594f, -0.00918450f, -0.08051697f, 0.00811261f, 0.16655473f, 
    -0.00709297f, -0.08242007f, -0.08580855f, 0.13398647f, 0.20864831f, 0.12980306f, 0.37668702f, 0.18486506f, 
    -0.06478208f, 0.16190061f, 0.03873879f, 0.11940608f, 0.05634063f, -0.03762480f, 0.18741129f, -0.02770019f, 
    -0.06602900f, -0.07510318f, -0.02763496f, 0.02872303f, 0.02372059f, -0.02284745f, -0.02302332f, -0.00157685f, 
    0.01345833f, 0.04165032f, 0.00207967f, 0.05922633f, 0.02058212f, 0.04211783f, -0.02779886f, -0.05738880f, 
    0.01381783f, -0.03649962f, 0.01473118f, -0.01443303f, -0.02400694f, 0.04262847f, -0.04883075f, -0.00365274f, 
    -0.06460658f, -0.04647536f, 0.05850843f, 0.03038394f, -0.00225502f, 0.00178030f, 0.00378770f, -0.01018343f, 
    -0.05319146f, 0.02849908f, -0.06021705f, -0.02652373f, -0.01456894f, -0.02515894f, 0.03200639f, -0.05077339f, 
    0.04258107f, 0.04199322f, -0.04483853f, -0.03152691f, 0.03189798f, -0.06336733f, 0.02670883f, 0.04731949f, 
    0.01007910f, -0.05690682f, -0.03428235f, -0.04034815f, -0.06162984f, 0.01880455f, -0.05990534f, -0.02174031f, 
    -0.06345516f, -0.06177471f, -0.01905815f, 0.00222833f, 0.01842806f, -0.01165566f, -0.02415585f, -0.05310179f, 
    -0.04738884f, -0.05963466f, -0.03088555f, 0.03722940f, 0.03425664f, 0.03697034f, -0.01966693f, -0.01225520f, 
    0.01764295f, 0.03418823f, 0.02972725f, -0.02740802f, 0.04662581f, -0.01278194f, -0.00555458f, 0.01752737f, 
    -0.02844075f, 0.01798216f, -0.05892003f, 0.00844618f, -0.03810299f, -0.03682017f, 0.02030467f, 0.05701261f, 
    -0.05538550f, 0.05091307f, 0.03261855f, 0.03510224f, -0.04863992f, 0.03876199f, -0.03807310f, 0.00118044f, 
    -0.01495676f, 0.00140419f, -0.05252877f, 0.03778305f, -0.05651804f, 0.00826957f, -0.05451781f, -0.01117002f, 
    0.02352342f, -0.05383554f, -0.05029316f, -0.05364373f, 0.04824718f, -0.00595792f, -0.01118049f, -0.03191804f, 
    0.02539631f, 0.00407207f, -0.02008167f, -0.02539798f, 0.04785392f, 0.01022832f, -0.01564733f, 0.00348195f, 
    -0.04751532f, -0.02142108f, -0.02177003f, -0.05650385f, 0.02378432f, 0.03831269f, -0.00154424f, -0.02493177f, 
    0.00674177f, 0.00485990f, -0.01008412f, -0.01178527f, -0.01514089f, 0.03620142f, 0.01152505f, 0.02151552f, 
    -0.01753075f, 0.05012823f, -0.05878645f, 0.01933925f, 0.00256511f, 0.00609400f, 0.01113343f, -0.03127652f, 
    -0.06015988f, -0.03067295f, -0.00064779f, -0.01095083f, 0.01227015f, 0.04401370f, 0.02073709f, -0.01945591f, 
    0.04522695f, -0.00041619f, -0.03303726f, 0.04160092f, -0.04817223f, 0.03699579f, -0.01640961f, 0.01256613f, 
    0.01463343f, -0.01527207f, 0.01364626f, -0.03848321f, 0.02190417f, -0.04059642f, -0.01668623f, 0.03652874f, 
    -0.01048824f, 0.04596012f, 0.03989628f, 0.00956409f, -0.01091804f, 0.02220780f, -0.02543644f, 0.00667141f, 
    0.02061599f, -0.00080185f, 0.01770988f, 0.00940877f, -0.05495905f, 0.04989872f, -0.01486279f, 0.01926641f, 
    -0.05403021f, 0.02931510f, -0.00444001f, -0.03530757f, -0.06564886f, -0.02617139f, -0.03084808f, 0.03709856f, 
    0.00884203f, -0.01605624f, -0.06009100f, 0.01043553f, 0.00997452f, 0.04333030f, 0.01602432f, -0.00967890f, 
    0.00980833f, -0.03480326f, -0.03559629f, 0.04713771f, 0.00589507f, -0.04101179f, -0.02660180f, 0.00170881f, 
    0.01414083f, -0.04767654f, 0.02824897f, -0.01326600f, 0.01681780f, 0.04667292f, -0.02126338f, 0.02851489f, 
    -0.00043929f, -0.03420518f, -0.01195717f, -0.02250304f, 0.01974144f, 0.04057574f, 0.04823804f, -0.03419897f, 
    -0.06287473f, -0.05955986f, 0.04203972f, 0.03400825f, -0.04156273f, 0.02046631f, -0.04543636f, 0.01339322f, 
    0.00414083f, 0.03996456f, 0.00075417f, 0.03283354f, 0.04328198f, -0.05164688f, 0.00401916f, -0.05752753f, 
    0.03479664f, -0.00071901f, -0.03288567f, 0.00152817f, 0.02470393f, -0.02179809f, -0.00301959f, 0.04474098f, 
    0.01473636f, -0.03440512f, 0.04847728f, 0.02710947f, -0.03431432f, -0.05396227f, -0.03368504f, -0.01265072f, 
    -0.01329996f, -0.01908690f, -0.01393320f, -0.02250582f, 0.00745019f, 0.04278611f, 0.02204361f, -0.00046937f, 
    0.04215716f, -0.00643211f, 0.02973838f, 0.02080470f, 0.03786770f, -0.02451219f, 0.05103622f, -0.02972864f, 
    0.01148221f, 0.03852005f, 0.03263899f, 0.02781032f, 0.03958398f, 0.03395987f, -0.00927226f, -0.03282605f, 
    -0.01894119f, -0.01019414f, 0.03315046f, 0.02718916f, 0.04107743f, 0.01805776f, -0.03475940f, 0.03815522f, 
    -0.01342058f, 0.01246980f, -0.02589771f, -0.02437734f, -0.04961360f, -0.06232692f, -0.00315761f, 0.00867638f, 
    0.00836722f, -0.05474652f, -0.00352627f, -0.05235429f, -0.04611309f, -0.05652754f, -0.03526864f, 0.02569904f, 
    -0.03095254f, -0.00746362f, 0.01442281f, 0.00149265f, -0.04001519f, -0.03624226f, -0.03425334f, 0.03897618f, 
    0.02210933f, -0.02191426f, -0.05336667f, 0.02013295f, -0.00010668f, -0.05853664f, -0.01982898f, 0.01588659f, 
    0.04974296f, 0.01147782f, 0.03253870f, -0.00758550f, -0.03578085f, -0.03265313f, 0.01447625f, -0.00788545f, 
    -0.37635240f, -0.65041018f, -0.04741596f, -0.17932628f, 0.04439249f, 0.01237875f, 0.34596989f, -0.31808934f, 
    0.04578641f, -0.20216081f, 0.00046691f, 0.08994405f, 0.10158736f, -0.06996377f, -0.02234570f, 0.00153214f, 
    0.06393646f, 0.12777992f, 0.02828390f, 0.02741604f, 0.03038549f, -0.05280392f, -0.52969301f, 0.04423581f, 
    0.01300998f, -0.03134125f, -0.05366502f, 0.05626557f, -0.05822346f, 0.08534070f, 0.09780162f, 0.16376950f, 
    -0.04582959f, 0.15039402f, -0.03220804f, -0.05596250f, 0.04612610f, 0.08522795f, -0.00853064f, 0.14216304f, 
    0.10585742f, 0.09241672f, 0.08720348f, -0.11802443f, -0.03036389f, -0.04329158f, -0.03885868f, -0.02035949f, 
    -0.08736444f, -0.10098551f, 0.12212034f, -0.01460752f, -0.00763787f, -0.01110383f, 0.01020061f, 0.01375030f, 
    0.02994597f, 0.14480785f, 0.10225710f, 0.10225903f, -0.25886315f, -0.17817141f, 0.18277904f, -0.14136258f, 
    -0.24109522f, 0.06166747f, 0.05158572f, -0.24088660f, 0.18495980f, 0.01897860f, -0.00407839f, -0.06800106f, 
    -0.11169959f, -0.00105827f, -0.04551104f, -0.04555821f, 0.11019349f, -0.00476110f, 0.12383476f, 0.03971338f, 
    0.10036828f, 0.15844472f, 0.02174007f, -0.29442906f, 0.01586941f, -0.02983565f, 0.02507659f, 0.04622974f, 
    -0.09361086f, 0.11816867f, 0.08250517f, 0.02323494f, 0.15382256f, 0.12513840f, 0.12685221f, 0.03938423f, 
    -0.07199129f, 0.14367718f, 0.06705777f, -0.07493568f, 0.14833504f, 0.16771883f, -0.15088758f, 0.11574101f, 
    -0.03226235f, 0.09761365f, 0.01715378f, -0.15207711f, 0.05831198f, 0.17877899f, -0.04065404f, 0.09108281f, 
    -0.09995069f, 0.06945465f, -0.00419608f, 0.08042134f, -0.01337984f, 0.01669232f, 0.05316747f, 0.00050903f, 
    0.08004783f, -0.19564891f, 0.14333050f, -0.22539653f, -0.16328005f, -0.07328659f, -0.06082493f, -0.03292223f, 
    0.01336146f, 0.02472181f, 0.01329803f, 0.09947191f, 0.07749404f, 0.05894025f, 0.07422800f, 0.03891703f, 
    0.00517143f, -0.01276106f, 0.03751777f, -0.04060066f, -0.04355760f, -0.03528176f, -0.00944512f, 0.07917315f, 
    0.06272335f, -0.05863865f, -0.07709064f, -0.00528165f, -0.06472237f, -0.11216711f, -0.09488869f, 0.05624090f, 
    0.02896831f, 0.07677018f, 0.08481760f, -0.06234958f, 0.00148385f, 0.07590939f, 0.17926104f, 0.17043304f, 
    -0.13984786f, -0.08383154f, -0.15511702f, -0.04921464f, -0.05220820f, -0.16925932f, -0.04336150f, -0.01044136f, 
    -0.03916033f, -0.02425872f, 0.07792763f, 0.03450918f, 0.03448139f, 0.06475773f, -0.06686281f, 0.04743906f, 
    -0.21756898f, 0.18943171f, 0.02923737f, 0.08267420f, -0.53397566f, -0.12591563f, 0.01542869f, -0.24047489f, 
    -0.08595823f, -0.16614835f, 0.11688533f, -0.00302230f, -0.04858649f, -0.00439095f, -0.04467631f, -0.01364478f, 
    0.07857545f, -0.00553376f, -0.00507157f, 0.06668410f, -0.08687247f, 0.06139396f, -0.06184295f, -0.10113239f, 
    0.06171897f, 0.04991693f, -0.12502235f, 0.04091003f, 0.09717224f, 0.01718279f, -0.03795218f, 0.05045860f, 
    -0.04645993f, -0.10598039f, -0.02374840f, 0.13064972f, -0.01590318f, 0.07723413f, -0.04634315f, -0.04019101f, 
    -0.09106510f, 0.14162189f, -0.01587954f, 0.23322472f, 0.05222572f, 0.08799703f, -0.05650407f, -0.10349873f, 
    0.05884985f, 0.09084043f, -0.09296529f, -0.04937769f, -0.05433498f, -0.09019910f, 0.12023484f, 0.01984631f, 
    0.10602095f, 0.02304815f, -0.07908751f, 0.20272221f, -0.17499785f, -0.04705635f, -0.03974287f, 0.14990875f, 
    0.02972501f, 0.23696405f, 0.28367198f, -0.40014011f, 0.20173727f, -0.00657354f, -0.09496330f, 0.10320241f, 
    -0.08617944f, 0.09282450f, 0.04570339f, 0.07541156f, 0.10125297f, 0.06939530f, 0.13067438f, 0.02632068f, 
    0.02794040f, 0.07587546f, -0.02480614f, -0.03972929f, 0.00131357f, -0.05307145f, 0.06464791f, -0.02498969f, 
    -0.06906524f, -0.03886783f, -0.20236512f, -0.13481726f, -0.02335470f, -0.08106980f, 0.09352663f, -0.06338827f, 
    -0.00480046f, -0.07885224f, -0.09155447f, -0.08041609f, -0.01555472f, 0.13124311f, 0.18289988f, 0.00109462f, 
    -0.02817413f, 0.08892532f, 0.09295483f, -0.13538614f, -0.04835822f, -0.01319937f, -0.12309904f, 0.00757771f, 
    -0.04835073f, -0.04404873f, 0.12728202f, 0.01682122f, 0.04950923f, 0.02164572f, 0.11904255f, 0.07346726f, 
    0.05054578f, -0.01917637f, 0.13063477f, 0.03587372f, 0.05201666f, -0.20403260f, 0.08655839f, -0.07202610f, 
    0.10986796f, -0.00076940f, 0.04906546f, 0.14598578f, 0.08237947f, 0.00039362f, 0.09391095f, 0.03616075f, 
    -0.01836499f, -0.06381520f, -0.11517631f, 0.01052777f, -0.03130142f, 0.10878411f, 0.01032289f, 0.02073551f, 
    0.03149083f, -0.01905131f, 0.02584176f, -0.02048626f, -0.04429730f, 0.02489999f, -0.04576461f, 0.00580890f, 
    -0.00732196f, -0.01574800f, 0.01793270f, 0.00001820f, 0.03913601f, 0.04396975f, -0.05609858f, -0.05109496f, 
    -0.01219130f, -0.00144622f, -0.05297632f, -0.02564865f, -0.03256020f, -0.01457723f, 0.02863190f, -0.02468019f, 
    0.05011126f, -0.04429596f, -0.03653574f, 0.02782648f, -0.03710961f, 0.01596139f, -0.00604771f, -0.02703086f, 
    -0.00613357f, -0.00524878f, -0.02713357f, 0.02065442f, 0.02294695f, -0.03565386f, -0.03931512f, 0.03326622f, 
    -0.05351009f, 0.01098160f, -0.03015690f, 0.01518702f, -0.02130443f, 0.01477265f, -0.05603329f, 0.02189138f, 
    0.04965731f, -0.03316336f, 0.03496272f, 0.03975203f, -0.04905244f, -0.05247513f, -0.01544641f, -0.05264768f, 
    -0.00774220f, 0.00242667f, 0.05149743f, -0.02846479f, 0.00524057f, -0.04096457f, 0.04763190f, 0.04598771f, 
    -0.02817097f, 0.04457531f, 0.04511413f, -0.03205022f, 0.03601111f, -0.04577548f, -0.04087709f, -0.02734398f, 
    0.03937546f, 0.03033338f, -0.05893742f, 0.04860297f, -0.02450573f, 0.01797234f, 0.01333167f, -0.01081149f, 
    -0.00097427f, -0.06114057f, 0.00206191f, -0.02046295f, 0.03854295f, -0.02199269f, -0.00385082f, 0.02312332f, 
    -0.04957846f, 0.01347791f, -0.00773914f, -0.05490521f, 0.03403600f, -0.04094545f, -0.05254795f, 0.03142693f, 
    0.03281588f, 0.00483093f, -0.01334100f, -0.01860529f, 0.05009705f, 0.00440316f, -0.05292843f, -0.03847755f, 
    0.03503489f, -0.00152252f, 0.03210672f, -0.05012992f, -0.02360193f, 0.03757624f, 0.01367430f, 0.02589759f, 
    -0.02800319f, 0.00565533f, -0.00624705f, 0.00614000f, 0.01795834f, 0.00619796f, -0.02532253f, -0.04579984f, 
    -0.01327490f, 0.04587601f, -0.00028815f, -0.01695394f, 0.01769792f, -0.01617734f, -0.02770476f, 0.04274949f, 
    -0.01013394f, -0.04243408f, 0.03594364f, -0.00491599f, -0.00924336f, -0.05110008f, 0.02490121f, 0.00401211f, 
    -0.05982333f, 0.03463646f, -0.04198555f, 0.01012251f, -0.02667563f, 0.04231561f, 0.03079705f, 0.02717758f, 
    -0.01214571f, -0.03060670f, -0.02095509f, 0.05102105f, -0.01270877f, -0.02268721f, 0.00977991f, -0.01223837f, 
    0.03283343f, 0.04640556f, 0.04320655f, 0.00538641f, 0.02618918f, -0.00340326f, -0.03586559f, 0.03080973f, 
    -0.01296193f, -0.04998175f, 0.01019559f, 0.01319559f, -0.04385570f, 0.00036803f, -0.05789735f, -0.02586643f, 
    0.00351215f, -0.04150354f, -0.00657526f, 0.02174787f, -0.04331295f, -0.03938377f, -0.04251719f, -0.04994623f, 
    0.03398775f, -0.01090345f, 0.03035862f, 0.00061189f, -0.05572072f, 0.03800028f, -0.01317895f, 0.00044496f, 
    0.03001727f, 0.00852465f, -0.01368961f, 0.01105427f, -0.00628116f, 0.01384499f, -0.01058315f, -0.04603424f, 
    0.04834973f, 0.00316433f, -0.02288684f, 0.00798886f, 0.05114568f, 0.02925477f, 0.01515203f, -0.01303464f, 
    -0.04134194f, -0.02136612f, 0.00826125f, -0.00223413f, -0.02481486f, -0.03220051f, 0.02322234f, 0.01738195f, 
    -0.04967373f, -0.04137290f, -0.05762421f, -0.03127099f, 0.04650247f, 0.02275751f, 0.03368294f, 0.02633594f, 
    -0.01720859f, 0.00061197f, -0.01916457f, -0.00848738f, 0.02820502f, -0.02260115f, -0.02484262f, -0.01500433f, 
    0.00384114f, 0.01422635f, 0.03013120f, 0.01602241f, -0.04023780f, -0.06170260f, 0.03527195f, 0.02478897f, 
    -0.04709779f, -0.03903925f, 0.02433370f, 0.00849623f, 0.05177512f, 0.01400320f, -0.05050751f, 0.03986713f, 
    0.00730107f, -0.05223058f, -0.03583054f, 0.00642109f, 0.02934969f, -0.04947867f, -0.01196736f, -0.02904243f, 
    -0.00729166f, -0.02553002f, 0.01017360f, 0.02627164f, 0.04394044f, -0.00060977f, -0.00883807f, -0.05336344f, 
    0.01290182f, -0.05243590f, -0.05470879f, -0.01045608f, 0.02367439f, 0.03914673f, 0.04290816f, -0.01965374f, 
    -0.05814510f, -0.04480615f, -0.05612442f, 0.02596778f, -0.03675848f, -0.01907228f, -0.02503382f, -0.00300502f, 
    0.03800761f, 0.00338597f, 0.02108147f, -0.00782963f, -0.05410865f, 0.02884384f, -0.01534204f, 0.01537237f, 
    -0.01733374f, 0.01972326f, -0.05033052f, -0.03772764f, -0.06030828f, -0.02568600f, 0.04122986f, -0.01402216f, 
    0.00994772f, -0.04063750f, -0.04413667f, -0.02588821f, 0.04668035f, 0.02446657f, -0.02919918f, -0.01425824f, 
    -0.01638374f, -0.05516511f, -0.02138507f, -0.02358624f, -0.04619726f, -0.04645189f, 0.04969644f, 0.00843343f, 
    -0.01837445f, 0.02850899f, 0.01679363f, 0.03936274f, -0.02602662f, 0.02246878f, -0.05294950f, -0.03193111f, 
    -0.00524385f, 0.01752735f, -0.05747333f, -0.01303880f, 0.04053390f, -0.03659147f, -0.02309665f, -0.05808628f, 
    -0.43600947f, -0.16067265f, -0.01074338f, 0.26459777f, -0.01241858f, -0.10023931f, -0.06439561f, -0.00223452f, 
    -0.07596325f, -0.26641560f, 0.00594658f, 0.01248453f, -0.03147032f, 0.04871970f, -0.01278521f, 0.04502413f, 
    0.07089696f, 0.20483442f, -0.12883122f, -0.09645530f, 0.01489624f, 0.05249662f, -0.01341969f, -0.10811260f, 
    0.16909896f, -0.15266703f, 0.12795547f, -0.05852764f, 0.11471517f, 0.01611920f, 0.00722100f, -0.00843980f, 
    -0.04102392f, 0.06568018f, 0.08378500f, -0.03890086f, 0.03350120f, -0.06849335f, -0.05233259f, -0.16509475f, 
    0.29954460f, -0.08993300f, -0.11148284f, 0.07179693f, -0.09068222f, 0.06009676f, -0.09138179f, 0.04024377f, 
    -0.00498534f, 0.03900934f, -0.05641284f, -0.00975118f, -0.04913113f, -0.06452635f, -0.00735614f, 0.20683411f, 
    0.17294276f, 0.03751424f, 0.13263504f, 0.09109803f, -0.22440477f, -0.43608469f, -0.22433281f, 0.10659465f, 
    0.00754262f, 0.12124626f, 0.02961375f, 0.00720866f, -0.01312223f, -0.09246394f, 0.14967515f, -0.02073448f, 
    0.12446536f, 0.06794724f, 0.18058588f, -0.04748432f, 0.02978869f, 0.07878353f, 0.05917355f, 0.22547680f, 
    0.15414304f, 0.22985539f, -0.14777400f, -0.05512303f, -0.18830578f, 0.02220876f, -0.14820537f, 0.11867157f, 
    0.08564622f, -0.05820708f, -0.08431631f, 0.03501794f, -0.16943637f, 0.15722598f, 0.05242052f, -0.00257294f, 
    -0.22100893f, 0.12697457f, -0.08859144f, -0.13023120f, -0.30784535f, -0.23889197f, -0.09456115f, 0.16859737f, 
    0.08859314f, -0.01350642f, 0.16791734f, 0.07335369f, -0.08836454f, 0.02487624f, 0.06090593f, 0.01671515f, 
    0.06481833f, 0.07900388f, -0.04870315f, 0.09291388f, 0.16556670f, 0.01549488f, 0.13849600f, -0.01502718f, 
    -0.24058510f, 0.06725909f, 0.34464416f, 0.26266879f, -0.04407676f, -0.08000598f, -0.07769231f, -0.12071330f, 
    0.08264935f, -0.17159741f, -0.04171300f, 0.18208484f, -0.02022929f, 0.02467517f, -0.00149322f, 0.08248024f, 
    -0.14091507f, -0.02449679f, -0.04578826f, -0.05961511f, -0.10808336f, -0.06974209f, -0.00954611f, -0.09628908f, 
    0.25279328f, -0.04274265f, -0.01292652f, -0.14109392f, -0.02712645f, -0.03577099f, 0.03761574f, 0.08200775f, 
    0.18862905f, 0.02429158f, 0.05129803f, 0.08147296f, 0.13529426f, 0.02081220f, 0.06767461f, 0.07849289f, 
    0.24575727f, -0.10012486f, -0.06381033f, -0.18606816f, 0.04283272f, 0.05499258f, 0.02285001f, 0.12783439f, 
    0.04405524f, 0.10089412f, 0.01683339f, -0.06830881f, -0.08558995f, -0.05274009f, -0.02270796f, -0.00028069f, 
    0.10638766f, -0.09411410f, 0.13244680f, 0.08228697f, 0.05533608f, -0.16957885f, -0.28713602f, -0.18895233f, 
    -0.03240819f, 0.02146359f, 0.16472585f, 0.12030156f, 0.08378304f, 0.01570998f, 0.04529149f, 0.00813898f, 
    -0.00225433f, 0.00482134f, 0.02493688f, 0.02328201f, 0.21163404f, -0.05565046f, 0.13702616f, 0.09584981f, 
    0.19854529f, 0.24802221f, 0.02889550f, -0.13134962f, -0.00119316f, 0.00432690f, -0.10355003f, -0.04214228f, 
    0.17137721f, -0.16731228f, 0.01596931f, 0.14146872f, -0.00064926f, -0.00297515f, -0.07005238f, -0.06015908f, 
    0.17601286f, -0.03664450f, -0.04460801f, -0.07697991f, 0.32604569f, -0.00342787f, 0.12926497f, -0.18576153f, 
    -0.13723026f, 0.16260923f, -0.09422117f, 0.09746160f, 0.07794107f, -0.08348939f, 0.07051828f, 0.03584610f, 
    -0.02892645f, -0.02345248f, 0.01419222f, 0.06534407f, -0.00827204f, 0.07908370f, -0.01102267f, 0.05714181f, 
    0.23428036f, 0.21853888f, 0.06940624f, -0.03479538f, -0.11636367f, -0.09527555f, 0.06818806f, -0.01703837f, 
    0.11417767f, -0.05140176f, 0.19642153f, -0.08296040f, 0.06193443f, -0.08206928f, 0.09652163f, 0.00031045f, 
    -0.01241861f, 0.03485432f, 0.00754116f, 0.04873699f, 0.22887208f, -0.23230289f, 0.00809237f, -0.02633162f, 
    0.07979710f, -0.08011024f, -0.04201201f, -0.07333897f, -0.03291109f, 0.11354008f, 0.05231567f, -0.06050483f, 
    -0.09634685f, -0.07310623f, -0.07234100f, -0.07110574f, -0.07923636f, -0.03015993f, 0.06033218f, 0.06414729f, 
    0.03161220f, 0.03534421f, 0.06368753f, -0.01274932f, 0.02479440f, -0.09249803f, -0.07824292f, 0.00419478f, 
    -0.05328304f, -0.03825256f, 0.08089189f, 0.02941052f, 0.14628178f, -0.11270452f, -0.04149225f, 0.08256382f, 
    -0.00682248f, -0.00767795f, -0.02087526f, -0.00364012f, -0.13345927f, -0.15675925f, 0.06351806f, 0.15290082f, 
    -0.05551364f, 0.02139494f, -0.00535253f, -0.02355368f, 0.01666402f, -0.20642105f, 0.16481999f, 0.00303825f, 
    0.19664578f, 0.12218592f, -0.01692270f, -0.05926708f, 0.13641371f, 0.00289753f, -0.00409295f, 0.07895005f, 
    0.03682818f, -0.23373620f, 0.49086845f, -0.13005178f, 0.06440178f, 0.22453290f, 0.35552841f, -0.02441847f, 
    -0.09513106f, 0.11293816f, 0.18948875f, 0.07602768f, -0.08004329f, 0.02396473f, 0.06883821f, 0.05936111f, 
    -0.01574147f, -0.04613737f, 0.06297757f, 0.06095013f, -0.13166787f, -0.31616852f, -0.20732106f, 0.10279128f, 
    -0.15876783f, 0.05388344f, -0.20871289f, -0.06649049f, 0.04905590f, -0.09426831f, -0.08890175f, -0.04011239f, 
    -0.06621888f, -0.14078806f, 0.01995121f, 0.04506775f, 0.02693589f, 0.09291839f, -0.04898478f, 0.02026752f, 
    0.05150880f, -0.05819469f, 0.04551543f, -0.06319383f, 0.10321715f, 0.13261110f, -0.11118384f, -0.19886076f, 
    -0.04008139f, 0.04731711f, 0.04319993f, -0.01145596f, -0.17025511f, -0.06051267f, 0.03950080f, -0.14879592f, 
    -0.11075912f, -0.08483130f, 0.07862605f, -0.04370963f, 0.06804997f, 0.12145059f, 0.50967211f, 0.01121782f, 
    0.05586255f, 0.03250421f, 0.14172029f, 0.10574204f, 0.08941595f, 0.00149928f, -0.07024311f, -0.06292221f, 
    -0.00831231f, 0.06616815f, 0.01934921f, 0.14508016f, -0.00169285f, -0.00793736f, 0.05495720f, -0.02743685f, 
    -0.29840621f, -0.18087855f, 0.33341506f, -0.02687120f, 0.28776547f, -0.10778306f, -0.02038875f, 0.18884188f, 
    0.01516681f, -0.08269058f, 0.14290674f, -0.12192882f, 0.12951781f, -0.09663262f, -0.05930408f, 0.11118273f, 
    -0.12428288f, -0.13022016f, 0.11495146f, 0.05129563f, 0.13542140f, 0.17249432f, 0.08378425f, 0.16835305f, 
    -0.27831972f, 0.02651539f, 0.03064737f, -0.04344111f, 0.19551903f, 0.13569789f, -0.17127955f, -0.01447642f, 
    -0.23602346f, 0.03235708f, 0.08493552f, -0.03105957f, -0.04534689f, 0.12239665f, -0.08607583f, 0.11781242f, 
    -0.01600112f, 0.09339252f, 0.08483385f, -0.26023671f, 0.01641718f, 0.15989649f, -0.08115219f, 0.09300489f, 
    0.15571217f, 0.11776028f, 0.04980801f, 0.01288885f, 0.05263440f, -0.00103398f, -0.11854962f, -0.19024575f, 
    -0.05574115f, 0.09051298f, 0.01210555f, 0.17777964f, -0.16308187f, 0.20223331f, -0.16212548f, -0.02159424f, 
    -0.07360432f, 0.03299410f, -0.19438502f, -0.19545501f, -0.07854655f, -0.03718949f, -0.15162978f, -0.03931701f, 
    0.00417921f, -0.02104529f, -0.08275284f, -0.22456880f, -0.05535217f, 0.19791321f, 0.05403332f, 0.10344978f, 
    -0.22311693f, -0.03687361f, -0.34279296f, 0.38281187f, 0.03829092f, -0.03621100f, -0.11713419f, 0.08611766f, 
    -0.08961101f, -0.00474223f, 0.01508405f, -0.05746983f, 0.01244467f, -0.10504483f, -0.02635119f, 0.04342195f, 
    -0.19484699f, 0.25958380f, -0.01274700f, -0.04728428f, -0.02095358f, 0.15846758f, 0.22379914f, 0.31525493f, 
    0.26727992f, 0.01182224f, 0.22756296f, 0.11921779f, 0.02462601f, 0.19727150f, 0.04577046f, 0.09992963f, 
    0.03988793f, -0.11568722f, 0.07992627f, 0.07829066f, -0.25771701f, 0.19719660f, -0.16079304f, -0.07782055f, 
    -0.13578363f, 0.10385300f, -0.07068348f, 0.01511403f, 0.19306287f, -0.01881491f, -0.13294522f, -0.06484258f, 
    -0.03275893f, 0.19404168f, 0.08911400f, 0.09172823f, 0.02316766f, -0.04658002f, 0.16080706f, -0.05413907f, 
    -0.33061770f, 0.16689321f, 0.19572720f, 0.17586677f, 0.46946234f, 0.02575567f, -0.45394862f, -0.10826310f, 
    0.37760857f, -0.06678906f, 0.13483134f, 0.09909140f, -0.14597510f, 0.01693076f, 0.14349885f, -0.01697814f, 
    -0.03619165f, -0.10877965f, -0.02726196f, 0.12809488f, -0.02049792f, -0.00361210f, -0.02750536f, -0.08911274f, 
    -0.36315989f, -0.10680778f, -0.05804384f, -0.33755338f, 0.29548442f, 0.10726646f, -0.04370784f, 0.14533994f, 
    -0.06085408f, -0.00764863f, -0.00665590f, 0.03627330f, 0.07507209f, 0.00833807f, -0.01936318f, -0.13792445f, 
    -0.09887228f, 0.02266500f, 0.06750809f, -0.01946264f, -0.18449613f, -0.07307386f, -0.03258000f, 0.04824767f, 
    -0.07801221f, 0.13557239f, -0.11535176f, -0.02771543f, -0.04106599f, -0.04390781f, 0.00025268f, -0.07281916f, 
    0.00798288f, 0.11203959f, -0.07802562f, 0.01403234f, -0.21072234f, 0.10749271f, 0.04416915f, -0.10982962f, 
    0.01325846f, -0.04137833f, -0.25250119f, -0.07767535f, 0.10992783f, 0.19667400f, -0.15075800f, -0.03360659f, 
    -0.25919849f, 0.07196960f, 0.05056378f, -0.03410214f, -0.00505727f, 0.11078361f, 0.05365936f, -0.20067115f, 
    -0.15003429f, 0.08471002f, 0.13900483f, 0.04492758f, -0.09534792f, 0.10575323f, -0.08444746f, -0.13865761f, 
    0.19177495f, -0.01003756f, 0.11849143f, 0.07311270f, 0.06464313f, 0.16210572f, -0.06969161f, 0.00864542f, 
    -0.04958805f, 0.07846667f, 0.02849928f, 0.06321628f, 0.09039069f, 0.05607008f, 0.02543523f, -0.04993337f, 
    -0.37608868f, -0.23964581f, 0.04113624f, 0.40903309f, 0.05261229f, 0.02309406f, -0.11925254f, -0.04166718f, 
    -0.02536945f, -0.04749993f, -0.06506182f, 0.06114339f, -0.10719750f, 0.01983652f, -0.01245140f, 0.00812865f, 
    0.06610746f, 0.12349489f, 0.04546786f, 0.14324377f, 0.06733147f, -0.07464477f, 0.20157886f, -0.05005507f, 
    0.10390764f, -0.06379035f, -0.00605677f, -0.07697061f, 0.07903293f, 0.11516482f, 0.15236445f, 0.02131154f, 
    0.11907528f, 0.04223382f, 0.14541934f, -0.02791357f, -0.07386669f, 0.09957630f, 0.05415089f, 0.05690560f, 
    0.22772337f, 0.14623034f, -0.01375795f, 0.17860292f, -0.17240648f, 0.17821962f, -0.13495231f, -0.11115419f, 
    -0.11621235f, 0.07288647f, 0.02948097f, -0.04809536f, -0.02870567f, -0.04748878f, 0.01631321f, 0.09345544f, 
    -0.09774305f, 0.04206779f, -0.13851558f, -0.07851326f, -0.20181428f, -0.30281061f, 0.29127613f, 0.09074467f, 
    0.01537326f, 0.06503627f, -0.04595600f, 0.22622688f, 0.10039435f, -0.19091612f, 0.04753073f, -0.01978544f, 
    0.09299481f, 0.06276125f, 0.11841249f, 0.01497897f, -0.05761971f, -0.01237645f, -0.14927076f, -0.11092160f, 
    0.13651782f, 0.16093585f, -0.28450477f, 0.16415277f, -0.01175331f, 0.06422020f, 0.01965642f, 0.05981762f, 
    0.07502420f, 0.12457518f, 0.03587047f, 0.07556681f, -0.14341085f, 0.05771063f, -0.00127860f, -0.03996885f, 
    -0.03547116f, 0.02426087f, -0.00516892f, 0.06271759f, 0.08058668f, -0.09622762f, 0.09385945f, 0.11745095f, 
    0.05793657f, 0.00756756f, -0.00142358f, 0.16813953f, -0.04199769f, 0.05984802f, -0.00740551f, 0.05868232f, 
    -0.02090696f, 0.07322428f, -0.03445368f, 0.07575326f, 0.07230646f, 0.07407963f, 0.02910750f, -0.06420668f, 
    -0.26111174f, -0.15639865f, 0.16732925f, 0.07772611f, 0.08695341f, -0.06694081f, 0.07963786f, 0.07702320f, 
    0.09173762f, 0.02619959f, 0.07824180f, 0.08640087f, -0.13181780f, -0.19838937f, -0.14700766f, -0.10599657f, 
    -0.08760381f, 0.01374223f, 0.06188357f, -0.03521872f, -0.14581369f, -0.08278819f, 0.04555731f, -0.04150025f, 
    0.07216626f, -0.04824675f, -0.01303384f, -0.15075378f, -0.13706368f, -0.08900210f, 0.07033535f, 0.14350305f, 
    -0.00992892f, 0.00522109f, 0.12936766f, -0.15382132f, -0.17930298f, -0.06458180f, -0.11942079f, -0.24201693f, 
    0.18302555f, -0.13498241f, 0.14885098f, -0.05118755f, 0.07439604f, 0.03435598f, 0.02722829f, 0.08992729f, 
    0.03887343f, 0.06925175f, -0.09686307f, -0.04874824f, 0.02630765f, -0.09734095f, 0.00521991f, 0.02146091f, 
    -0.01107483f, 0.04551563f, 0.07929929f, 0.07929368f, 0.24055287f, -0.35137984f, 0.17453642f, -0.05070002f, 
    -0.00484171f, 0.13599190f, 0.00204448f, -0.03788576f, -0.00694731f, -0.02302093f, -0.18050122f, 0.00807962f, 
    -0.05806286f, -0.02461805f, -0.06347919f, -0.04625578f, -0.14650013f, -0.02359367f, -0.04159742f, 0.04272909f, 
    0.09326163f, 0.03799227f, 0.13736361f, -0.01672368f, 0.17431998f, -0.04102440f, -0.05358678f, -0.06050821f, 
    0.15536916f, 0.07096466f, -0.01914374f, 0.00023082f, 0.07730611f, 0.13036849f, 0.11238568f, 0.09488045f, 
    -0.02908309f, 0.06410722f, 0.04276471f, 0.05431806f, 0.23529302f, -0.14414760f, 0.11171873f, 0.02523921f, 
    0.04063955f, 0.11401566f, 0.00202088f, 0.12132107f, 0.08662018f, -0.11707216f, 0.07035813f, 0.02646068f, 
    0.01685211f, -0.00854448f, 0.00726234f, 0.07696220f, 0.03744723f, 0.15820114f, 0.11520004f, 0.12485276f, 
    0.04545991f, 0.24094327f, -0.07263176f, -0.00019319f, 0.11342600f, -0.08602065f, 0.13550103f, -0.03682214f, 
    -0.01032023f, -0.04936259f, 0.14685218f, 0.05500928f, 0.06849605f, -0.09435770f, -0.02395177f, -0.08319943f, 
    -0.03022616f, -0.04788185f, -0.02225732f, -0.05350060f, 0.12672488f, -0.11941234f, 0.06519216f, -0.02993220f, 
    -0.07464541f, 0.06074600f, -0.08164652f, -0.06584751f, -0.06802375f, 0.03860824f, 0.02453602f, 0.04686922f, 
    0.03595839f, -0.00672166f, 0.05464792f, -0.00749773f, 0.04355625f, -0.05029602f, -0.03047022f, -0.00336402f, 
    -0.03963194f, 0.01391543f, -0.08645745f, 0.01207485f, -0.01254623f, -0.03218433f, 0.08938064f, 0.04015969f, 
    0.00593648f, 0.16219229f, 0.23274368f, 0.08247180f, 0.14853191f, 0.04512027f, 0.04387175f, -0.12344498f, 
    -0.08236120f, -0.02783970f, 0.04995158f, 0.01160208f, -0.17842171f, 0.01407631f, 0.10903846f, 0.19450597f, 
    0.13987347f, 0.00418895f, 0.06892683f, 0.02699400f, 0.04600859f, -0.02419420f, -0.03329921f, -0.02530327f, 
    -0.02896355f, 0.03216294f, -0.12374898f, 0.02175619f, 0.06923830f, -0.04594020f, -0.03340660f, -0.03722730f, 
    -0.11367320f, -0.08576344f, 0.08886918f, -0.05952222f, 0.13811702f, -0.02970400f, 0.28427583f, -0.03419590f, 
    0.02723949f, -0.02873904f, 0.03303011f, 0.02695662f, -0.00671145f, -0.05542667f, -0.12147103f, -0.16157453f, 
    -0.15977009f, 0.10642427f, 0.07861724f, 0.11523037f, -0.34297076f, 0.00154376f, -0.49060258f, 0.19869140f, 
    0.07624906f, -0.03100297f, -0.12582764f, 0.22189574f, -0.16087943f, 0.08601563f, 0.02173342f, 0.14139064f, 
    -0.10205173f, -0.03395701f, -0.12178260f, -0.16757479f, -0.15366024f, -0.19319348f, -0.07530045f, -0.22981907f, 
    0.06803862f, -0.09393908f, -0.04552690f, -0.20436516f, -0.03716226f, -0.13109928f, -0.00096739f, -0.03052061f, 
    0.06356164f, 0.01843453f, 0.05092365f, 0.12129900f, 0.00136462f, -0.02657159f, 0.13529769f, 0.03780547f, 
    0.13883172f, -0.06657407f, 0.07659718f, 0.10277343f, -0.00834923f, -0.05073450f, -0.14139028f, 0.02743046f, 
    0.12147302f, 0.14133832f, 0.10728909f, -0.11448525f, 0.02336604f, 0.07170615f, 0.02034719f, -0.13492829f, 
    0.01405543f, 0.05163058f, -0.08472223f, 0.04883204f, 0.16729471f, 0.03052289f, 0.14906023f, 0.20513727f, 
    -0.19424620f, 0.10732164f, 0.27041987f, -0.24469538f, -0.01162993f, -0.08159003f, 0.04857774f, 0.00347412f, 
    -0.14590371f, -0.08205241f, -0.03046381f, 0.03467553f, 0.23087351f, 0.14803928f, -0.09062260f, 0.07276435f, 
    -0.20104633f, 0.08342825f, -0.12915716f, 0.02966735f, -0.12913935f, 0.01982674f, -0.07947853f, 0.36129582f, 
    0.01595845f, -0.05662962f, -0.01488973f, -0.07210390f, 0.06800498f, 0.06463118f, 0.05288321f, 0.13389404f, 
    0.00841642f, 0.05809759f, -0.00847050f, 0.02988591f, 0.16919963f, 0.09343242f, 0.12461463f, 0.18128394f, 
    0.32975513f, 0.35597315f, 0.59684891f, 0.10558946f, 0.02286976f, -0.05034598f, -0.24776018f, -0.16833544f, 
    0.04118690f, -0.09190465f, -0.01907794f, 0.08142187f, -0.01155199f, 0.02181824f, -0.06607421f, -0.06721938f, 
    -0.22338594f, -0.01232954f, -0.06112125f, -0.06104821f, 0.16705093f, 0.18670996f, 0.09050439f, 0.02240133f, 
    0.06389704f, 0.02309693f, -0.11540494f, -0.16073421f, -0.06484013f, 0.11282135f, 0.10903279f, 0.19659795f, 
    0.10918777f, 0.01563282f, 0.09494767f, 0.02660860f, 0.10722227f, 0.04883043f, 0.20152594f, 0.24651043f, 
    -0.22071916f, -0.05126559f, -0.17234345f, 0.04573799f, 0.03340144f, -0.03638394f, -0.09570178f, 0.19504471f, 
    -0.06411625f, 0.00326500f, 0.15891977f, 0.04049051f, -0.01849899f, -0.06084226f, -0.04473124f, 0.04760870f, 
    -0.07109186f, -0.01907885f, -0.05024577f, -0.16074423f, -0.34949499f, 0.26491737f, -0.29871777f, 0.12837394f, 
    0.15946878f, -0.02776831f, 0.19965930f, 0.14879830f, -0.07102081f, 0.12937699f, 0.02799384f, -0.13630849f, 
    -0.04945635f, -0.00588071f, 0.10415298f, 0.03006276f, 0.08305089f, 0.15228504f, 0.02112362f, 0.04509002f, 
    0.10515364f, 0.17628762f, -0.08996992f, -0.00685217f, -0.01016427f, 0.03434243f, 0.01943944f, 0.08611570f, 
    -0.07405826f, -0.22220472f, 0.02211604f, 0.11446117f, 0.03395797f, 0.13446233f, -0.04849728f, -0.06894267f, 
    -0.02093675f, 0.03552932f, 0.04313282f, -0.05277845f, 0.07818586f, 0.18231098f, -0.14820212f, -0.10243627f, 
    0.00420489f, 0.01299441f, 0.00996591f, 0.00003037f, -0.03402880f, -0.03759681f, 0.10957022f, -0.05553517f, 
    0.05300899f, -0.01727522f, -0.01048391f, 0.08478836f, -0.06910215f, -0.07140164f, -0.13901249f, -0.02537111f, 
    0.11860502f, 0.24989256f, 0.39812300f, -0.16351458f, 0.04064684f, -0.01049281f, -0.12924880f, -0.00035046f, 
    -0.05876855f, -0.09663510f, 0.00575528f, -0.01226820f, 0.10411117f, 0.02857783f, -0.00535647f, -0.05780664f, 
    -0.00124600f, -0.05883133f, 0.00179697f, -0.00245848f, 0.00746170f, -0.21050321f, 0.06660178f, -0.03773290f, 
    0.01629536f, -0.01441654f, -0.01418507f, 0.02596406f, 0.01494524f, 0.01129126f, 0.15641670f, -0.00453818f, 
    0.01597635f, 0.00690623f, 0.07550447f, 0.06388422f, -0.09593526f, -0.10600019f, 0.03658900f, -0.22557937f, 
    0.18964170f, 0.16008204f, 0.21275561f, -0.11195768f, 0.18585257f, -0.11707695f, -0.29319176f, -0.15694597f, 
    -0.06350864f, -0.13117117f, 0.01560645f, 0.07743162f, 0.00723676f, -0.01106517f, -0.02995943f, 0.05051861f, 
    -0.13077345f, -0.15139289f, 0.06042675f, -0.14990133f, -0.03476929f, -0.08322315f, 0.18082026f, -0.01795291f, 
    0.03175598f, -0.04036592f, -0.04038457f, -0.01886991f, 0.03427378f, 0.06743743f, 0.09544379f, -0.00899038f, 
    0.08363753f, 0.02558738f, 0.12456397f, 0.02217792f, 0.28545466f, 0.04526734f, 0.06671309f, 0.20510973f, 
    -0.30870855f, -0.24750666f, 0.00101040f, 0.32315728f, 0.01396593f, -0.11190052f, -0.10387900f, 0.09295040f, 
    0.06244795f, -0.10219076f, -0.02935787f, 0.02403843f, -0.09609784f, -0.00070211f, 0.04443400f, 0.10812047f, 
    0.07499574f, 0.16714700f, -0.01151000f, -0.00768751f, 0.20062760f, 0.15846786f, 0.00189811f, -0.21908151f, 
    0.03959422f, -0.07821847f, -0.01951572f, -0.04980985f, 0.12267884f, -0.01295241f, 0.05970161f, -0.00054562f, 
    0.10589735f, -0.05074491f, 0.03230637f, -0.08284274f, -0.07587075f, -0.03330762f, -0.01821967f, -0.05484440f, 
    0.26349157f, 0.06345001f, -0.02082090f, 0.14514840f, -0.14077052f, 0.07313322f, -0.04798385f, 0.02478596f, 
    0.03585574f, -0.07806802f, -0.04379817f, -0.05875201f, 0.08710674f, -0.08167764f, -0.05364971f, 0.06943493f, 
    0.11616313f, -0.03827669f, -0.15186754f, 0.00690333f, -0.13530219f, -0.34352857f, -0.17023340f, 0.13604881f, 
    0.18935613f, -0.01894652f, 0.05026786f, 0.07880753f, -0.10905126f, 0.07207886f, 0.14185917f, 0.06119196f, 
    0.01803183f, 0.14805241f, 0.09488525f, -0.01738636f, 0.09282607f, 0.13056763f, 0.05834346f, 0.05900845f, 
    0.18886589f, 0.02808548f, -0.18378790f, 0.03285057f, -0.15025023f, 0.12045076f, -0.12835242f, 0.14005770f, 
    0.04228125f, -0.03096066f, -0.07573781f, 0.02408815f, -0.09099405f, 0.06674267f, -0.08221937f, -0.01463178f, 
    -0.12559944f, 0.11351060f, -0.15449311f, 0.01932241f, -0.18135250f, -0.12408613f, -0.14815848f, 0.01383670f, 
    0.01413167f, 0.08435288f, 0.11914887f, 0.12891282f, -0.25193599f, 0.14369734f, 0.00063094f, 0.06063813f, 
    0.17208777f, 0.10051784f, 0.13785045f, 0.05728318f, 0.14188769f, 0.00331319f, 0.21396352f, 0.05924203f, 
    -0.38050076f, -0.11683951f, 0.13161705f, 0.05889190f, -0.10638013f, -0.08971052f, -0.09930022f, -0.11447921f, 
    0.00167083f, 0.09787106f, -0.03740019f, 0.11070854f, -0.10080016f, -0.00526467f, -0.06592572f, 0.02273499f, 
    -0.12127575f, -0.02635945f, 0.00071986f, -0.03583241f, -0.10381637f, 0.05525820f, 0.05136664f, -0.07674174f, 
    0.20654459f, -0.07112535f, -0.02204918f, -0.11064525f, -0.02595317f, -0.09685092f, -0.05714753f, 0.02370588f, 
    0.13567393f, 0.10462774f, 0.04364245f, 0.10032181f, 0.06538032f, -0.19353507f, -0.08005574f, 0.02834978f, 
    0.30912197f, 0.18828516f, 0.17053539f, -0.15726630f, 0.04883408f, 0.08832946f, 0.09190595f, 0.09112843f, 
    0.01677070f, -0.04111512f, -0.00192769f, 0.03230276f, -0.05574473f, 0.05297824f, -0.04867970f, -0.06388648f, 
    0.02201315f, -0.11906724f, -0.01155091f, -0.00148025f, 0.42442325f, -0.29212499f, -0.08519236f, -0.07392325f, 
    0.02899929f, 0.00771750f, 0.07987831f, 0.13077316f, 0.14287679f, 0.01518384f, -0.04123954f, -0.00619948f, 
    0.04469363f, 0.08236695f, 0.04471557f, 0.05385625f, 0.05952094f, 0.00636010f, 0.10452211f, 0.08867564f, 
    0.11743958f, 0.17761599f, 0.05807330f, -0.24220045f, 0.02526515f, 0.01042574f, 0.02857429f, 0.05676121f, 
    0.07659963f, -0.08229446f, -0.06977718f, 0.08067746f, -0.03825826f, -0.00456138f, -0.03492151f, -0.00200016f, 
    0.02502249f, -0.08997679f, -0.11840689f, -0.04200808f, 0.32027140f, 0.04592847f, 0.21605976f, 0.01208540f, 
    0.00899509f, 0.10287856f, 0.04246275f, 0.05074236f, 0.13381782f, -0.12517206f, 0.02595358f, -0.03848126f, 
    -0.02091961f, 0.03454678f, 0.04551012f, 0.02101448f, 0.05418918f, 0.13960932f, -0.05164926f, -0.02379399f, 
    0.06793103f, 0.04040860f, 0.06522205f, 0.04841900f, -0.01088839f, -0.11355648f, 0.09538799f, -0.12241428f, 
    -0.00772092f, 0.01002229f, 0.06161639f, 0.02066536f, 0.14291073f, 0.05266889f, 0.12205103f, 0.01899586f, 
    -0.00968980f, -0.03711502f, -0.11753509f, -0.02935014f, 0.12993161f, 0.00161245f, 0.01316470f, 0.03071296f, 
    0.00118988f, -0.02669945f, 0.08320215f, -0.09095421f, -0.13129103f, -0.02139129f, -0.01743803f, -0.06381191f, 
    -0.07306470f, -0.03480569f, -0.05375845f, -0.00554045f, 0.07633973f, -0.07176067f, -0.06853540f, -0.00460691f, 
    -0.05583194f, 0.08675708f, 0.08350292f, -0.01113851f, -0.00157493f, -0.04517475f, -0.01050898f, -0.03472429f, 
    -0.07510848f, -0.01039329f, 0.00655480f, 0.08583902f, 0.13168570f, -0.00480774f, 0.00116958f, -0.04620977f, 
    -0.05810603f, -0.08777509f, -0.15774305f, -0.08411283f, -0.16124655f, -0.13057174f, -0.25050589f, 0.11053661f, 
    0.17447275f, -0.04976967f, -0.05080135f, -0.10504425f, 0.17571554f, -0.00763354f, 0.11725397f, 0.04392992f, 
    0.07759082f, 0.17577761f, 0.08403679f, 0.12008410f, 0.12999818f, 0.10237697f, 0.07039575f, 0.18506931f, 
    -0.27582824f, -0.37204412f, -0.18006377f, 0.37036303f, 0.05917258f, 0.12353071f, -0.07456696f, 0.04423467f, 
    0.02105840f, 0.00686813f, -0.18055487f, 0.02135156f, -0.07208056f, -0.07486164f, -0.02836799f, -0.04294059f, 
    -0.06095353f, 0.06177650f, -0.15062474f, -0.00192770f, 0.26778537f, 0.12229922f, -0.10877971f, -0.17430234f, 
    0.04800883f, 0.00668094f, 0.06986530f, -0.07858577f, -0.00814500f, -0.00669304f, 0.17940642f, 0.12938055f, 
    0.20024112f, -0.06568813f, -0.06113496f, 0.06752038f, -0.08196179f, 0.11635590f, -0.07044717f, -0.03984090f, 
    -0.12145801f, 0.29422253f, 0.33560315f, 0.15929396f, -0.09708373f, 0.02972045f, -0.00710146f, 0.01202636f, 
    -0.02175460f, -0.05309307f, 0.13549064f, -0.02476067f, 0.04888339f, 0.04387249f, -0.06370825f, 0.01149576f, 
    0.01170510f, 0.09298384f, -0.05823811f, -0.11566595f, -0.07847638f, -0.18402489f, -0.07164214f, 0.17010131f, 
    0.20378397f, 0.10518947f, 0.02823458f, 0.09414442f, -0.08491836f, 0.21665104f, -0.13184124f, 0.05161975f, 
    -0.06664091f, -0.01652086f, -0.06326636f, -0.04492658f, 0.17466339f, 0.03878379f, -0.06115619f, 0.01342949f, 
    -0.08144106f, 0.06199016f, -0.19066495f, 0.01110648f, -0.11875674f, 0.02091631f, 0.00530996f, 0.08409582f, 
    0.05493354f, 0.07983919f, 0.10302587f, 0.01942371f, 0.07388058f, 0.07722915f, -0.08288793f, -0.05997490f, 
    0.04036526f, 0.09290510f, 0.01117815f, -0.09639965f, 0.27293232f, 0.01908288f, -0.18213880f, -0.01156815f, 
    0.23747642f, 0.10144741f, -0.00742524f, -0.03015028f, -0.23768777f, 0.10813137f, -0.09569753f, -0.02497126f, 
    0.01183479f, -0.00079070f, 0.11856252f, 0.03394538f, 0.07128840f, 0.04885306f, 0.05242787f, -0.07091039f, 
    -0.03784433f, -0.22642839f, -0.03359282f, 0.13594656f, 0.16653670f, -0.03866419f, -0.05886193f, -0.06017756f, 
    -0.01586626f, 0.22460939f, 0.09985096f, 0.01135420f, 0.02698008f, -0.02157134f, -0.15102048f, 0.01158991f, 
    -0.13298677f, -0.09279364f, -0.00632409f, -0.18762767f, -0.08481777f, 0.00933096f, 0.13027108f, -0.04017540f, 
    -0.10705156f, 0.10635584f, 0.07787664f, 0.08943929f, 0.02671186f, 0.01425230f, -0.03325095f, -0.22661541f, 
    -0.07126100f, -0.03949815f, 0.05418048f, 0.02842647f, -0.12488347f, -0.21667251f, -0.07076570f, -0.00881275f, 
    0.24750112f, 0.11409432f, 0.40276963f, -0.16409087f, 0.11052786f, -0.03152921f, 0.03211053f, -0.05402052f, 
    0.07516500f, -0.10083949f, 0.10196921f, 0.02460101f, 0.09903498f, 0.10248756f, -0.00810492f, -0.06942231f, 
    -0.03909470f, 0.05196560f, -0.05928982f, -0.04577404f, 0.47218692f, -0.28569758f, 0.31255698f, -0.15857738f, 
    0.20384917f, -0.19899258f, -0.08733564f, -0.12192393f, 0.12902404f, -0.06631383f, 0.00870297f, 0.03164966f, 
    -0.03239235f, -0.00134893f, -0.00704540f, -0.09052539f, -0.00018746f, -0.01669348f, -0.05190063f, -0.00436911f, 
    -0.05830541f, 0.08130536f, -0.00038641f, -0.18936186f, -0.03062772f, 0.03787482f, 0.05746266f, 0.09216107f, 
    0.00216417f, 0.03935311f, 0.03251497f, -0.13758868f, 0.09084898f, -0.11533917f, 0.03415440f, -0.18643208f, 
    0.00004356f, -0.08747206f, 0.02831578f, -0.09147651f, -0.15378998f, 0.06822464f, 0.55413085f, 0.24577390f, 
    0.31590560f, 0.07184173f, 0.04223724f, -0.10758020f, 0.08819746f, -0.12790532f, 0.13939537f, 0.02345476f, 
    0.10612077f, 0.06863380f, 0.01641106f, -0.00805066f, 0.08430956f, 0.16417481f, -0.00591063f, 0.04376609f, 
    -0.17096964f, 0.19928043f, 0.39051059f, 0.10288983f, 0.13119197f, -0.00166354f, 0.10211870f, 0.00561495f, 
    0.04675000f, 0.09378106f, 0.05585804f, -0.00654742f, 0.12322665f, 0.20849581f, 0.11174695f, 0.00301298f, 
    0.01734695f, -0.10329609f, 0.03965443f, -0.09791701f, 0.13652313f, 0.21174964f, 0.23558708f, 0.06188212f, 
    -0.11774151f, 0.04121533f, 0.02834843f, -0.05939665f, -0.02782489f, 0.00393537f, 0.09600268f, 0.10899521f, 
    0.02567591f, 0.04630996f, 0.05289760f, 0.13644247f, 0.17229567f, 0.02133667f, -0.03750757f, -0.09864448f, 
    -0.01936993f, 0.12991707f, 0.06667647f, -0.02260821f, -0.05941619f, 0.05742380f, -0.00552539f, 0.08340412f, 
    0.04972979f, 0.05533003f, 0.10439656f, 0.02024215f, 0.09515292f, 0.00578898f, 0.05418500f, 0.06343088f, 
    -0.02193543f, -0.10386630f, -0.05711037f, -0.10889371f, -0.10194764f, 0.03803078f, -0.07690762f, 0.21536407f, 
    0.26967353f, -0.09569849f, 0.07688216f, 0.00344240f, 0.15571737f, 0.05501865f, -0.11438822f, -0.03434379f, 
    -0.01178909f, 0.01404705f, 0.01010581f, 0.08921347f, 0.04146283f, 0.08620566f, 0.07634867f, 0.09470155f, 
    -0.37581056f, 0.06533249f, -0.31782585f, 0.18775654f, 0.28992900f, 0.20010713f, -0.05334935f, -0.10607988f, 
    0.11584290f, 0.00457693f, -0.01958697f, 0.02771687f, 0.05138259f, 0.07616782f, -0.00256836f, 0.01295848f, 
    0.04341794f, 0.18032563f, 0.12385588f, 0.22259076f, 0.13525854f, 0.00038492f, -0.01465007f, -0.14656813f, 
    0.06807458f, -0.07852276f, 0.10858403f, -0.06053608f, -0.02595590f, 0.03087699f, 0.12327389f, 0.13822286f, 
    0.02951782f, 0.05046264f, 0.07831030f, 0.00331297f, -0.02599787f, 0.13250786f, -0.05086453f, 0.00088833f, 
    -0.09958707f, 0.36589530f, 0.23518646f, 0.26577750f, -0.32907945f, 0.02434985f, -0.12403401f, -0.14242831f, 
    -0.14273077f, -0.04628242f, -0.04995750f, 0.04920603f, 0.01306156f, 0.08040874f, -0.06142023f, -0.00163383f, 
    -0.03863548f, 0.08152699f, 0.01738418f, -0.15009043f, 0.05194775f, 0.21805856f, -0.02586576f, -0.13994944f, 
    0.08751160f, 0.05074154f, 0.02810900f, -0.05328371f, 0.08633242f, -0.06383502f, -0.10643849f, 0.03605630f, 
    -0.01003593f, 0.05416326f, 0.07850592f, -0.13682249f, 0.02156580f, 0.01581997f, -0.18790472f, -0.01835368f, 
    -0.19178061f, 0.48583144f, -0.37837097f, 0.19716167f, 0.09096257f, -0.08821965f, 0.18701355f, 0.08542221f, 
    0.04784225f, 0.21259892f, -0.02341571f, 0.15276521f, -0.01019918f, 0.06890642f, -0.01537052f, -0.07657843f, 
    0.06493194f, 0.11209129f, 0.15748700f, 0.05919071f, 0.58230746f, 0.36863077f, 0.16739638f, -0.25812659f, 
    0.40080553f, 0.02705611f, 0.11461975f, -0.01830065f, -0.04881893f, -0.00533762f, -0.03603141f, 0.04571383f, 
    -0.02549158f, 0.06424426f, -0.03802360f, 0.09459879f, 0.01368303f, 0.03963020f, 0.10801757f, -0.08869953f, 
    -0.13588840f, -0.12175894f, -0.10028380f, -0.17394391f, 0.23649663f, 0.08518215f, 0.05846453f, 0.18400653f, 
    0.03353668f, 0.12662002f, -0.03927655f, 0.07537837f, -0.01462661f, -0.07187308f, 0.01124052f, 0.06972729f, 
    0.04929624f, -0.06815442f, 0.08982813f, -0.10297289f, 0.23032059f, -0.09230030f, 0.20244184f, 0.09730899f, 
    -0.22597697f, 0.09030531f, 0.12370324f, 0.07118943f, -0.01659381f, 0.10338928f, 0.10985428f, 0.14107196f, 
    0.01822092f, 0.02868197f, -0.00450095f, 0.08631390f, -0.09098440f, -0.12845378f, 0.06808481f, -0.10650732f, 
    0.09286939f, -0.32024810f, 0.55028218f, -0.13435087f, -0.02286800f, -0.19451183f, 0.03751172f, -0.06028653f, 
    -0.06083106f, 0.02099314f, -0.15641190f, 0.05479670f, 0.05263557f, 0.02456792f, 0.03409393f, -0.10576101f, 
    0.00287722f, -0.09902579f, 0.10474302f, 0.06590535f, -0.08471920f, -0.35735261f, 0.54773903f, -0.38159519f, 
    0.09857128f, -0.09533058f, -0.04862531f, -0.10377845f, 0.01635767f, -0.06393524f, -0.03023477f, -0.01449948f, 
    -0.06366580f, -0.02183658f, -0.00004339f, -0.09349813f, -0.02167643f, -0.04517851f, -0.02639117f, 0.03683454f, 
    0.05201515f, -0.06229639f, -0.05221523f, 0.14600565f, -0.00452790f, -0.01044689f, 0.05856344f, -0.01716498f, 
    -0.03144517f, -0.09031568f, -0.01254817f, -0.00233664f, 0.01525620f, 0.01775665f, 0.02851209f, 0.07517501f, 
    0.20137338f, -0.09383090f, 0.11611626f, -0.04127327f, -0.37329355f, -0.17884393f, 0.31765553f, 0.24724934f, 
    0.05600664f, 0.10730664f, -0.04620156f, 0.01215790f, 0.01834098f, -0.16134842f, 0.05156279f, 0.04125045f, 
    0.01793485f, 0.11569112f, -0.03621014f, -0.01554658f, -0.00783716f, 0.21067195f, 0.11669645f, 0.07831007f, 
    -0.02946278f, 0.58614504f, -0.24436361f, 0.25084427f, 0.35487363f, -0.00664668f, 0.04954425f, -0.02356760f, 
    -0.06251503f, 0.11877732f, 0.07309120f, -0.00574982f, 0.07004086f, 0.06913134f, -0.00922885f, 0.09302969f, 
    0.07807893f, -0.04578610f, 0.04124973f, 0.02775858f, -0.07385193f, -0.18685383f, 0.19430764f, -0.22774751f, 
    -0.16933064f, -0.06027900f, -0.23278512f, -0.16781698f, -0.08686006f, -0.06994449f, -0.08217314f, -0.10782456f, 
    -0.07499812f, -0.19703811f, -0.07478027f, 0.03047234f, 0.10258012f, -0.08196186f, -0.14552441f, -0.07224561f, 
    -0.04898733f, 0.10164546f, -0.09954727f, -0.13700250f, -0.02990915f, -0.16281784f, -0.03512483f, 0.01965356f, 
    0.05680076f, 0.04973233f, 0.07111051f, 0.05979578f, 0.00391776f, -0.12204152f, -0.02541505f, -0.07538085f, 
    -0.00947255f, -0.14546505f, -0.02509314f, 0.02214266f, 0.08358847f, 0.23535386f, 0.03388171f, 0.27530974f, 
    0.17192182f, 0.09655014f, 0.01580086f, 0.16543752f, 0.06071055f, 0.09537419f, 0.01348266f, 0.07078634f, 
    -0.05880035f, -0.03113004f, 0.05626601f, 0.14261526f, -0.04358438f, 0.11666931f, -0.02633596f, -0.03158835f, 
    -0.04925828f, 0.22515211f, 0.29518336f, 0.34209383f, 0.09050434f, 0.02291330f, -0.17898782f, 0.31556320f, 
    -0.13838531f, 0.15729624f, 0.04424874f, -0.05197144f, -0.09163097f, 0.08435068f, 0.02858171f, 0.12063871f, 
    -0.01030074f, -0.02617140f, 0.00965054f, 0.16208528f, 0.15355943f, -0.10936298f, 0.32652831f, -0.04975123f, 
    -0.12968929f, 0.08853476f, 0.07120997f, -0.11865998f, 0.17318238f, -0.12170818f, 0.00520126f, -0.08890916f, 
    0.05819187f, -0.06681684f, 0.05862240f, 0.11820139f, 0.04996782f, 0.01217970f, 0.04001290f, 0.06550239f, 
    0.04620317f, -0.13117336f, -0.12910351f, 0.26929298f, -0.12658367f, -0.02051005f, -0.00753914f, -0.02036267f, 
    -0.00033050f, 0.03228896f, -0.08228540f, -0.12915620f, 0.04753029f, 0.03656094f, -0.06905744f, -0.00039070f, 
    -0.05129004f, 0.02101986f, -0.08705438f, 0.05223957f, -0.10666759f, -0.15224954f, 0.29934114f, 0.15003060f, 
    0.19811225f, -0.12524159f, -0.04813139f, 0.25943753f, -0.08527469f, 0.01322512f, 0.07454346f, 0.02203107f, 
    -0.00200415f, 0.07650552f, 0.09235456f, 0.14257060f, -0.07152209f, -0.05927317f, -0.13832007f, -0.07732544f, 
    -0.22884890f, -0.12809606f, -0.11946371f, 0.38319907f, -0.07094949f, -0.04423256f, 0.10046623f, -0.04051965f, 
    0.20989563f, -0.03494205f, -0.02962419f, 0.01407633f, -0.00337878f, -0.01210180f, 0.02788541f, 0.02435572f, 
    0.01027816f, -0.15661983f, 0.02584681f, 0.09849959f, 0.09402525f, -0.01917223f, 0.09113286f, -0.08016142f, 
    -0.06017115f, 0.09135413f, 0.09874742f, 0.22857687f, -0.02319841f, 0.09006345f, -0.02242884f, 0.00565905f, 
    0.00394516f, -0.00064314f, 0.09920066f, 0.08141615f, 0.00374659f, -0.01353817f, 0.09026059f, -0.03828053f, 
    -0.18481335f, 0.02954982f, -0.03037356f, 0.11800228f, 0.00269342f, 0.05690070f, 0.05394836f, -0.02291013f, 
    0.03124673f, 0.18699808f, 0.04336182f, -0.03629354f, -0.02770011f, -0.14671683f, -0.14042456f, 0.04790445f, 
    0.11935735f, 0.00241876f, -0.05340634f, 0.01800341f, -0.19061860f, 0.03069992f, -0.09055051f, -0.05852830f, 
    -0.05463935f, 0.06313369f, 0.08045018f, -0.02572712f, -0.05206133f, -0.12865995f, -0.12845705f, 0.00449767f, 
    0.00243404f, 0.06478143f, 0.04203906f, -0.14664251f, -0.12213581f, 0.06745315f, -0.01789266f, -0.17430103f, 
    0.22780201f, -0.04269930f, 0.10861583f, 0.05968397f, -0.09629440f, 0.09129870f, 0.17417616f, -0.04233959f, 
    0.01679835f, -0.04950387f, -0.03151875f, 0.01775204f, -0.01082158f, -0.04776667f, -0.12694976f, 0.11344363f, 
    0.08496232f, 0.14702971f, 0.03254913f, 0.05328004f, 0.47984341f, -0.24186538f, 0.06574981f, 0.21162029f, 
    -0.02792610f, 0.10919736f, -0.01965576f, -0.04635755f, 0.03392637f, 0.00773420f, 0.00431695f, 0.03199202f, 
    -0.08753392f, -0.02961473f, -0.07485033f, -0.02435670f, -0.14425442f, 0.05843278f, 0.00380256f, 0.15384978f, 
    0.02099821f, -0.08839523f, -0.00398699f, -0.09534074f, 0.04563200f, -0.10603084f, 0.04219926f, -0.01187381f, 
    0.11580467f, 0.13320880f, -0.02215716f, -0.03435655f, -0.00596887f, 0.04932793f, 0.10576237f, 0.05772407f, 
    -0.07518999f, 0.04785684f, -0.03481447f, -0.13494627f, 0.21521762f, -0.17352644f, -0.09920499f, 0.08624233f, 
    0.07279624f, 0.00590306f, 0.21094665f, 0.12277956f, 0.10254175f, -0.00523077f, -0.05446694f, -0.06859379f, 
    0.01898945f, 0.02133343f, -0.01825185f, -0.05295757f, 0.02465967f, 0.17838424f, 0.13485095f, -0.02972820f, 
    -0.25817806f, -0.09135647f, -0.36286855f, 0.18136083f, -0.02433312f, 0.00290606f, 0.17657422f, -0.02335379f, 
    0.18455429f, 0.02919227f, -0.01434123f, -0.02159583f, 0.09292803f, -0.00564332f, 0.01843193f, -0.03852683f, 
    -0.12484883f, -0.03047843f, 0.03137195f, -0.02332458f, -0.04117623f, -0.00444772f, -0.06626400f, 0.01501322f, 
    -0.13008207f, 0.03517402f, 0.08588095f, 0.13915443f, -0.06798118f, -0.03226857f, -0.07353655f, -0.00697558f, 
    0.04975005f, -0.00868882f, -0.02974826f, 0.04535576f, 0.06111680f, 0.06460456f, -0.01631196f, -0.00157515f, 
    -0.15387434f, -0.06292129f, -0.19788976f, 0.05250817f, -0.11395483f, 0.02526668f, 0.09469541f, 0.04722255f, 
    0.05267243f, 0.01574422f, 0.08690210f, 0.05048409f, 0.17289145f, 0.05314263f, 0.04281623f, -0.07731601f, 
    -0.06747134f, 0.00412178f, 0.04189497f, -0.01349170f, -0.14607701f, 0.28272942f, -0.14359409f, 0.10653433f, 
    0.00457706f, -0.02550549f, 0.06730141f, -0.01567328f, 0.09061538f, 0.08729543f, -0.04208502f, 0.04130656f, 
    0.06388780f, 0.13018107f, -0.01470818f, 0.08439887f, -0.08576346f, 0.01219383f, -0.00429818f, -0.03525578f, 
    -0.03560039f, 0.02110763f, 0.00062680f, -0.05609483f, -0.00193963f, 0.02705313f, 0.00265197f, -0.04192961f, 
    -0.03043937f, -0.01242926f, -0.01064702f, -0.02119374f, 0.00271599f, 0.02874468f, 0.04394681f, -0.00167438f, 
    0.02021512f, 0.03601106f, -0.00746659f, -0.05210056f, 0.00345153f, -0.05461387f, -0.05046206f, -0.01271810f, 
    0.04128275f, -0.04834687f, 0.03024016f, 0.00895467f, 0.02738908f, -0.05720032f, -0.03594888f, 0.02501973f, 
    -0.03227124f, -0.00764755f, 0.00585642f, 0.00287764f, 0.00754949f, -0.01193185f, -0.05556896f, -0.05746609f, 
    0.02356348f, -0.05219943f, -0.00241951f, 0.04684092f, 0.03456568f, -0.02295245f, 0.05237694f, 0.02548871f, 
    0.03208342f, -0.00302607f, 0.00628613f, 0.03760334f, 0.02430768f, 0.01511995f, -0.03130454f, -0.02534366f, 
    0.00403269f, -0.01669441f, -0.04698903f, 0.04702997f, 0.02727946f, 0.03316242f, 0.02080155f, -0.00762406f, 
    0.02610643f, -0.04689020f, -0.00189594f, -0.02718505f, 0.00086441f, -0.05111452f, -0.04924435f, -0.01267213f, 
    -0.01968108f, -0.02656387f, -0.01272876f, 0.03344309f, 0.04207704f, -0.00251533f, -0.02362850f, 0.01737936f, 
    -0.02204450f, 0.04047096f, -0.05872060f, -0.00384199f, -0.00450262f, 0.05219905f, -0.00945166f, -0.04493641f, 
    0.03686936f, -0.01099242f, 0.00274595f, 0.04474219f, -0.03199012f, -0.02007799f, -0.02533439f, 0.00137058f, 
    -0.04320573f, -0.04768166f, 0.04775347f, -0.03935087f, -0.02160342f, -0.00104867f, -0.02119651f, -0.03223786f, 
    0.00646140f, -0.02476256f, -0.04884811f, 0.04222050f, -0.02921561f, -0.04078892f, -0.03267887f, -0.02966378f, 
    -0.02347944f, -0.05213544f, 0.03963879f, -0.02330915f, 0.03621573f, -0.01421711f, -0.01242199f, 0.02809468f, 
    -0.05868638f, -0.03689696f, 0.01898510f, -0.00167990f, -0.00522468f, -0.06132229f, -0.00088775f, -0.04826704f, 
    0.01425119f, -0.04680805f, -0.03986830f, -0.03363615f, 0.02815925f, -0.01615936f, -0.04406942f, 0.02516307f, 
    0.03708983f, -0.01898588f, -0.02070460f, 0.03258545f, -0.03709212f, -0.03834859f, 0.01729588f, -0.00090356f, 
    0.02510995f, -0.03855874f, -0.03221956f, -0.04151519f, -0.05181780f, -0.05227762f, 0.03468869f, 0.01102914f, 
    -0.05922795f, 0.05211759f, -0.02156087f, 0.04099021f, -0.03036848f, 0.02039806f, -0.05109001f, -0.01596457f, 
    -0.03915606f, -0.03929635f, -0.05134967f, 0.04236113f, 0.00904571f, 0.01290313f, -0.02590441f, -0.03673281f, 
    0.02697613f, -0.05412795f, -0.00057708f, -0.05312850f, 0.04325971f, -0.04108721f, -0.04429479f, 0.00230506f, 
    -0.00512205f, 0.01010696f, 0.03207426f, 0.00581556f, -0.00499326f, -0.00897692f, -0.06049152f, 0.00139427f, 
    -0.02718308f, -0.04174447f, -0.03599361f, 0.04211311f, -0.03610203f, -0.01403505f, -0.01520926f, 0.03016931f, 
    -0.01469451f, 0.00733175f, -0.03666705f, -0.04912088f, 0.04107998f, 0.04082517f, -0.02038466f, -0.00799086f, 
    -0.01702981f, 0.00206776f, -0.05941645f, -0.00165265f, -0.02638848f, -0.03892879f, -0.04070077f, 0.00724119f, 
    -0.03529856f, -0.03854514f, 0.04180306f, -0.03840039f, -0.02905859f, -0.02414979f, -0.02490182f, 0.04187669f, 
    -0.01362882f, -0.04133029f, -0.00949843f, -0.01574881f, 0.03591143f, -0.05060470f, -0.03564338f, 0.01578044f, 
    -0.05040205f, -0.04068112f, -0.01079606f, 0.01998605f, 0.01645207f, -0.02936332f, -0.02552537f, -0.02442583f, 
    0.01131359f, -0.01341803f, 0.01139443f, -0.00752991f, -0.02332495f, 0.01759402f, -0.06002134f, -0.03209594f, 
    -0.00421449f, -0.00164462f, 0.02317949f, -0.05873173f, 0.03244783f, -0.03223156f, 0.00232648f, -0.05721161f, 
    0.00568111f, 0.01624701f, 0.00084925f, -0.00541136f, 0.02723029f, -0.04901957f, -0.02487281f, -0.05439637f, 
    -0.03246845f, -0.06032153f, 0.03982840f, -0.03580865f, -0.01483618f, 0.01586674f, -0.02645881f, 0.01226578f, 
    -0.02553328f, -0.01034266f, 0.00062932f, -0.03773188f, 0.05535490f, -0.03529968f, -0.04736299f, 0.02242321f, 
    0.01343843f, -0.00515070f, 0.02011408f, -0.03746056f, 0.04688888f, -0.01344422f, 0.04783604f, -0.05593672f, 
    0.02990470f, -0.04194719f, 0.00656028f, 0.01533972f, 0.01724692f, -0.00164989f, -0.04990028f, -0.02208518f, 
    -0.03287159f, 0.04784643f, 0.04900346f, 0.04354443f, -0.00125442f, 0.01184616f, -0.03127228f, -0.02765768f, 
    0.01439690f, 0.04220087f, 0.01615644f, -0.05749734f, -0.05302840f, -0.03737751f, 0.04166686f, 0.04199365f, 
    -0.03638735f, -0.02678017f, 0.04031294f, -0.04758490f, -0.02107876f, -0.01228540f, 0.04898079f, -0.03377845f, 
    -0.03254221f, 0.04955056f, 0.03459687f, -0.04637185f, 0.01104666f, -0.02399345f, -0.02183407f, -0.05969748f, 
    -0.08011907f, 0.52718067f, 0.07197983f, -0.16700397f, 0.04895801f, 0.02131904f, 0.09605653f, 0.02332029f, 
    0.16186522f, 0.04029193f, 0.00189883f, -0.05628021f, 0.07281870f, 0.08576269f, 0.03251404f, 0.04575166f, 
    0.00714090f, -0.14998792f, 0.05304968f, 0.19444460f, -0.50634623f, -0.20461993f, 0.23760499f, -0.13431643f, 
    -0.01171564f, -0.00829071f, 0.05230405f, -0.03395648f, -0.04615843f, 0.02049136f, -0.10173251f, 0.01957470f, 
    0.03373622f, 0.10442817f, 0.08330126f, 0.15775599f, 0.19646139f, -0.06730234f, 0.12103047f, 0.03304337f, 
    0.02521268f, -0.09963127f, -0.19009227f, 0.04708090f, 0.23396529f, -0.22104695f, -0.01096875f, -0.01516919f, 
    0.01538450f, 0.01599897f, -0.06844547f, 0.07662181f, -0.18408984f, -0.07722288f, 0.01053290f, -0.04068858f, 
    0.07072414f, 0.06681842f, 0.07172869f, 0.04889016f, 0.05701350f, 0.16190431f, 0.08965570f, 0.02890371f, 
    -0.08762997f, -0.06284656f, 0.10824139f, -0.01989064f, 0.17111172f, 0.01290783f, 0.11822233f, 0.04561773f, 
    0.14473234f, -0.03988338f, 0.04255312f, 0.00868472f, -0.10641623f, -0.16167592f, -0.09827875f, -0.17282030f, 
    0.06917296f, 0.08735055f, 0.16253792f, 0.02254865f, 0.18876329f, -0.19910406f, -0.08183707f, -0.20431411f, 
    0.10240851f, 0.05730272f, -0.07721737f, 0.06163860f, 0.04147755f, -0.11339779f, 0.09571152f, -0.10391698f, 
    0.09478826f, 0.03811402f, 0.10526457f, 0.17262837f, -0.14267305f, -0.00323408f, 0.24326681f, 0.01196260f, 
    -0.09159093f, 0.03175640f, 0.09141195f, 0.08194952f, 0.17685799f, -0.02642242f, 0.06089654f, 0.00778805f, 
    -0.12615745f, -0.01052118f, 0.02647337f, 0.14251515f, 0.04264125f, -0.01498999f, -0.05563752f, -0.00071057f, 
    -0.04894124f, 0.08156084f, -0.01106539f, -0.23033984f, -0.20279883f, -0.04130667f, 0.10904412f, -0.09327570f, 
    0.01001567f, -0.03229491f, -0.06256457f, 0.09800536f, -0.05435266f, -0.04481494f, 0.00387133f, -0.03709985f, 
    0.10609648f, 0.04272134f, 0.11257624f, 0.08492095f, 0.31847259f, -0.06653374f, -0.04524764f, 0.15373403f, 
    -0.02736165f, 0.00540328f, 0.01278166f, -0.12226751f, -0.09962248f, -0.14299075f, 0.08456219f, 0.06776301f, 
    -0.06510506f, 0.17284951f, 0.00099946f, 0.16986619f, 0.03573846f, 0.07702104f, 0.07076237f, -0.06289606f, 
    -0.14270388f, -0.11922979f, -0.25252971f, 0.06726158f, -0.08064677f, -0.07210151f, -0.03301018f, 0.19519687f, 
    -0.08262381f, 0.03466255f, -0.04919749f, 0.08123331f, -0.08125179f, 0.02491647f, -0.06402255f, 0.08721939f, 
    0.18962741f, 0.04294237f, 0.05402730f, 0.05953037f, -0.36953187f, 0.18181916f, -0.40195420f, 0.19649929f, 
    -0.15630662f, -0.05937212f, 0.08778936f, 0.16872001f, -0.14510262f, -0.02337094f, 0.00781188f, 0.02846808f, 
    -0.04697157f, -0.08433752f, -0.05209741f, -0.06578719f, -0.06647307f, -0.13290356f, -0.00184046f, 0.01396934f, 
    0.26582670f, -0.11758213f, -0.00980858f, 0.04355572f, -0.10498289f, -0.06555282f, -0.09877206f, 0.02274868f, 
    0.00933713f, -0.06235566f, 0.18166733f, -0.06444516f, 0.02934497f, 0.12357477f, 0.09029942f, 0.08957466f, 
    0.18953080f, 0.01055557f, 0.08460083f, 0.03547151f, 0.00403339f, -0.10194670f, -0.49780685f, -0.10946895f, 
    -0.35434288f, -0.08435951f, 0.00984420f, 0.15188028f, -0.07006408f, 0.08170918f, 0.01091356f, 0.05397522f, 
    -0.13261189f, 0.01129245f, 0.10833550f, -0.00350366f, 0.16252117f, 0.04657678f, 0.02607764f, 0.05114142f, 
    0.36001116f, 0.00281650f, -0.41203624f, 0.03537227f, -0.38581288f, 0.02960199f, -0.22244902f, -0.13547482f, 
    0.06531280f, 0.07654843f, -0.08036695f, 0.04310206f, -0.02276216f, -0.02631329f, -0.07348240f, -0.00332467f, 
    -0.13418896f, 0.08999109f, 0.03401601f, 0.14239506f, 0.01142786f, -0.18199857f, -0.05040522f, 0.02263791f, 
    0.06821271f, 0.01162645f, -0.04131380f, 0.23586991f, 0.06201411f, -0.03752823f, 0.00818831f, 0.16968621f, 
    0.04040777f, 0.02908082f, 0.06616830f, 0.06366820f, 0.12873584f, 0.04830957f, 0.07686992f, -0.00268770f, 
    0.26432493f, -0.13625658f, -0.12188146f, 0.05873573f, -0.13408971f, -0.03129093f, -0.08330750f, -0.09146576f, 
    -0.03941961f, -0.18195976f, -0.08550809f, -0.02673439f, 0.01586569f, 0.10042447f, -0.00023324f, 0.02471928f, 
    -0.06761540f, 0.06079377f, -0.00265889f, 0.20421457f, 0.11139528f, 0.13560642f, 0.19987579f, -0.05697669f, 
    -0.21975422f, 0.14217748f, 0.03305919f, 0.07314451f, 0.02550252f, -0.02011074f, 0.02237228f, 0.08405714f, 
    -0.04888603f, -0.03940947f, 0.04042235f, -0.04058440f, 0.03658754f, -0.01030714f, 0.00901582f, 0.01821071f, 
    -0.03680693f, 0.44384626f, -0.01684751f, -0.16128890f, 0.24819554f, 0.16760395f, 0.08423183f, 0.03882793f, 
    0.07234595f, 0.15365779f, 0.04498730f, -0.06906533f, -0.09082165f, 0.10745268f, -0.01444819f, 0.09136238f, 
    -0.10619172f, -0.03421581f, 0.10518730f, 0.14629161f, -0.23438957f, -0.22028705f, 0.33987877f, -0.19781330f, 
    -0.03001973f, -0.11534900f, 0.05331051f, 0.01115189f, -0.01549292f, -0.04682662f, -0.07072163f, 0.15150043f, 
    -0.02246072f, -0.03449647f, 0.06605157f, 0.17215918f, -0.01206554f, -0.03970835f, 0.00057587f, 0.06209666f, 
    -0.18358596f, -0.16018319f, -0.18774402f, 0.20611556f, -0.10276507f, -0.08230448f, -0.12309415f, -0.01499734f, 
    -0.07860813f, -0.10521151f, -0.06843273f, 0.09603496f, 0.03935940f, 0.09004375f, -0.07474472f, -0.08067383f, 
    -0.05356497f, 0.00166100f, 0.04068465f, -0.01963245f, 0.15524563f, 0.42111987f, -0.06362069f, -0.08265353f, 
    -0.01667538f, -0.08014420f, 0.10610814f, -0.11896791f, 0.02499876f, 0.07041812f, 0.03901559f, 0.03295376f, 
    0.05394229f, -0.10637848f, -0.03268180f, -0.10973556f, -0.03936704f, -0.03656080f, -0.08833183f, -0.06116235f, 
    -0.39684656f, 0.00503072f, -0.01098815f, 0.12009152f, 0.06833605f, -0.09381554f, 0.00860477f, 0.16347933f, 
    0.10881680f, 0.04759272f, -0.14083710f, 0.18848647f, 0.11341881f, -0.08981605f, 0.05950065f, -0.05298185f, 
    -0.02559040f, 0.04517468f, 0.05846294f, 0.09689760f, 0.18818827f, 0.24848109f, 0.31337151f, -0.29848945f, 
    0.11377321f, -0.03885704f, 0.15663262f, 0.00098613f, -0.04253607f, -0.04401404f, -0.02716896f, -0.02415460f, 
    0.01610655f, -0.00160679f, -0.03830411f, -0.02226926f, -0.07739845f, -0.03122468f, 0.10647114f, -0.07269353f, 
    0.11806112f, 0.23998512f, -0.10493577f, -0.15182456f, -0.03352847f, 0.20741829f, 0.09966028f, 0.06906807f, 
    -0.14263640f, 0.10939547f, -0.06021934f, 0.02346113f, -0.01788943f, -0.06586780f, -0.08499475f, 0.03343720f, 
    0.11224418f, -0.04966749f, 0.00987732f, 0.08594134f, 0.33141375f, 0.12501130f, 0.02778442f, 0.01763498f, 
    -0.31193221f, 0.01650745f, 0.06512807f, 0.03698233f, -0.04592609f, 0.08377814f, 0.12422459f, 0.21511136f, 
    0.07867306f, 0.10580571f, 0.01626354f, -0.02186820f, -0.08719914f, -0.06014134f, 0.02756169f, -0.06565449f, 
    -0.10481638f, -0.28152508f, 0.18625616f, -0.07427108f, -0.23341905f, -0.09190333f, 0.02391937f, 0.09083327f, 
    -0.04154759f, 0.01940500f, -0.05791757f, 0.08040974f, 0.01992062f, 0.01745491f, 0.03854783f, -0.05799975f, 
    0.09458604f, 0.04029788f, -0.00599007f, -0.05118763f, -0.18302429f, -0.00694481f, 0.00604138f, -0.12888159f, 
    -0.01631426f, -0.24740830f, 0.02564188f, 0.01703668f, -0.15717188f, 0.02154400f, 0.09223054f, 0.01015807f, 
    0.00932774f, -0.01719889f, 0.01292590f, -0.11544408f, -0.02976820f, 0.03848081f, 0.02190783f, 0.01002131f, 
    -0.02781841f, -0.03355047f, -0.14095914f, 0.08884466f, -0.18790999f, 0.11200204f, 0.02356968f, -0.06061544f, 
    -0.00648724f, -0.04247666f, 0.00601683f, 0.00395071f, -0.02049753f, 0.06791344f, -0.05013934f, 0.01258288f, 
    0.07333143f, -0.08821376f, 0.03810706f, -0.01950958f, -0.16316709f, -0.21115373f, -0.25970426f, 0.15492983f, 
    -0.25258577f, 0.08961307f, -0.08658169f, 0.18576486f, -0.06334907f, -0.01546502f, 0.02250450f, 0.07906355f, 
    -0.12239207f, 0.01284561f, 0.02612447f, -0.15795465f, -0.05408124f, 0.14737712f, 0.01484622f, -0.06338255f, 
    0.05252156f, 0.32329088f, -0.58855051f, 0.35703287f, -0.06887829f, 0.13257597f, -0.07512920f, 0.02216712f, 
    -0.04473612f, 0.12408485f, 0.01892348f, 0.02450294f, -0.00463176f, -0.03985251f, -0.02847904f, 0.00512468f, 
    -0.00983924f, 0.08857924f, 0.03540275f, -0.04155790f, -0.02619549f, -0.25903237f, -0.02662206f, -0.13905235f, 
    -0.21461719f, -0.03562264f, -0.06943214f, 0.23046596f, -0.07578127f, -0.05271563f, -0.09250306f, 0.04860584f, 
    0.06283583f, -0.12325069f, 0.06147121f, 0.04281063f, 0.00778101f, -0.02620920f, -0.16557552f, -0.06481490f, 
    0.04346762f, -0.03015641f, -0.28178766f, 0.03577387f, -0.10367674f, -0.00341638f, -0.02073840f, -0.00363545f, 
    0.07048580f, 0.07556768f, -0.02773209f, -0.00626890f, 0.03342819f, 0.01653620f, -0.03519221f, -0.01045448f, 
    -0.00113291f, -0.06948525f, -0.11447088f, 0.04034480f, 0.13238171f, 0.22163889f, -0.04988221f, 0.00949160f, 
    -0.02253395f, 0.08693085f, -0.05533284f, 0.12894854f, -0.05104795f, -0.00331774f, -0.00040174f, 0.05160810f, 
    -0.10836051f, 0.02365076f, 0.07877697f, 0.02980969f, -0.12514375f, 0.04975145f, -0.02135578f, -0.04412702f, 
    0.37163764f, 0.23925410f, 0.68402976f, 0.03087397f, 0.15141243f, 0.16056290f, 0.22947203f, 0.12318951f, 
    -0.01783118f, 0.28065687f, 0.17233238f, 0.12737168f, -0.18833490f, 0.00639474f, -0.02308322f, -0.04318408f, 
    0.00733499f, -0.03645916f, -0.00276722f, -0.13604265f, -0.11049038f, -0.18259156f, -0.01158502f, 0.16737664f, 
    -0.21660376f, 0.08572181f, -0.18136029f, -0.05374680f, 0.05992756f, -0.17412359f, -0.15331997f, 0.03395133f, 
    -0.03238205f, 0.01571967f, -0.06601181f, -0.02946615f, -0.01228511f, -0.01211886f, -0.12535456f, -0.10264970f, 
    0.00778456f, -0.23627791f, 0.08350997f, -0.10163552f, -0.03498546f, -0.02279234f, 0.03041795f, -0.01208032f, 
    0.00909058f, -0.10326254f, 0.02459161f, -0.06355760f, 0.05567321f, -0.08351295f, 0.01878701f, -0.05885681f, 
    0.01760773f, -0.13639644f, 0.07298107f, 0.03061825f, 0.31728786f, 0.30011383f, 0.29502794f, 0.17045492f, 
    0.19581901f, -0.02865163f, -0.02192165f, 0.07795689f, -0.06710540f, 0.15114684f, -0.07395919f, -0.01398376f, 
    0.00732008f, -0.01054654f, -0.16463463f, 0.09324711f, -0.03074368f, 0.10252650f, 0.25625357f, 0.15478849f, 
    -0.31668115f, -0.56487584f, 0.42498279f, -0.09990080f, 0.18654183f, 0.05448688f, -0.04347385f, 0.11681672f, 
    -0.05332679f, -0.33077854f, 0.19606254f, -0.03078829f, 0.06446858f, -0.00871577f, -0.06843217f, 0.10831748f, 
    -0.05396417f, -0.03317738f, -0.21571623f, -0.10770132f, 0.03381979f, -0.01849743f, 0.03441408f, 0.07639991f, 
    -0.12147245f, -0.03026226f, 0.04368955f, 0.06058005f, 0.15138951f, 0.00230378f, -0.09589139f, -0.03924845f, 
    -0.07159176f, 0.14723326f, 0.06071786f, -0.08331505f, 0.02486255f, 0.01013769f, 0.15202901f, 0.13717982f, 
    0.45473155f, 0.13498323f, -0.12141407f, 0.09501666f, 0.12970440f, 0.04763267f, -0.07197320f, 0.07982115f, 
    -0.04431536f, 0.14928770f, 0.03967124f, -0.08996203f, -0.03064139f, -0.07429373f, 0.00663749f, -0.10797823f, 
    -0.05498583f, 0.15066867f, -0.12692806f, 0.12713911f, -0.17240205f, 0.20180647f, -0.27697080f, -0.04960649f, 
    -0.21434675f, -0.09695932f, -0.07412647f, 0.00188888f, -0.00569297f, 0.11936652f, -0.08993402f, -0.02708287f, 
    0.07236873f, 0.07910353f, 0.10396214f, -0.15058425f, 0.13774508f, -0.01340004f, 0.06910110f, 0.19552593f, 
    -0.11136061f, 0.09270095f, -0.33184761f, 0.27389547f, -0.09571172f, 0.08429269f, -0.13282989f, -0.03696892f, 
    -0.06943332f, -0.02748157f, 0.04470815f, -0.01000714f, -0.06841248f, -0.02198490f, 0.06682022f, 0.13017359f, 
    -0.05639039f, 0.13897610f, -0.17568843f, -0.17416757f, 0.31869709f, 0.31989080f, 0.07531058f, 0.41098782f, 
    0.20294712f, -0.02924581f, 0.05821496f, 0.04426925f, 0.14765571f, 0.13145438f, 0.08207509f, 0.00086987f, 
    -0.00710593f, -0.12259840f, 0.03856102f, 0.06267361f, 0.00348078f, 0.09125631f, 0.05785484f, 0.04951632f, 
    -0.26667917f, 0.06181151f, 0.01963948f, -0.00648571f, -0.09735839f, -0.02932537f, -0.01699971f, -0.00374477f, 
    -0.03183747f, 0.10678440f, 0.11117355f, 0.09801166f, -0.03602378f, 0.08736324f, 0.15359683f, -0.09512436f, 
    -0.16300842f, 0.12207509f, -0.08354688f, -0.04674450f, 0.17606771f, 0.06125233f, -0.35768640f, 0.04400016f, 
    0.13560736f, -0.11642364f, 0.13496146f, -0.03404924f, -0.05592560f, 0.12595581f, 0.00788535f, -0.03815565f, 
    -0.01340708f, -0.10605033f, 0.05244322f, 0.10784233f, 0.02264747f, -0.11817297f, -0.11408082f, -0.15261982f, 
    -0.44020209f, -0.48433685f, -0.07591467f, -0.13264945f, 0.07352798f, 0.08866629f, -0.05692156f, 0.13462971f, 
    0.06118808f, -0.17587642f, -0.00975602f, 0.03730008f, 0.03351649f, 0.01146964f, 0.09154381f, -0.04384622f, 
    -0.13275462f, 0.08360389f, -0.01137533f, -0.11481190f, -0.11240553f, 0.13072510f, -0.06167679f, 0.07268119f, 
    -0.13001847f, 0.15310358f, 0.12410286f, 0.01857754f, -0.12989233f, -0.02434799f, -0.12417662f, -0.04909421f, 
    0.09653999f, 0.13245496f, 0.12179922f, 0.02777080f, -0.01325643f, -0.04274257f, -0.12478690f, -0.09290806f, 
    -0.10638564f, -0.10556789f, -0.23833053f, -0.11093254f, -0.12745474f, 0.08302066f, -0.09008908f, 0.06536832f, 
    -0.18392460f, -0.01509177f, -0.04829192f, 0.00107165f, -0.02901976f, -0.02090617f, 0.04986055f, -0.08316015f, 
    -0.00163532f, 0.06242712f, -0.16382918f, -0.02434936f, -0.07915881f, 0.11471742f, -0.05821053f, -0.20186919f, 
    0.16369225f, -0.16794951f, 0.03862932f, 0.03693599f, 0.08841313f, 0.02497966f, -0.10255730f, 0.03002541f, 
    -0.10423125f, 0.24194874f, 0.13998093f, 0.03319044f, 0.17560872f, 0.08292099f, 0.12922427f, 0.09205021f, 
    0.16849333f, 0.25308436f, 0.02892648f, 0.00726032f, -0.01209745f, -0.00612993f, 0.11030143f, 0.06496179f, 
    0.14920878f, 0.01535977f, -0.02310956f, 0.00785137f, 0.11021185f, -0.06300879f, -0.01569462f, -0.02366091f, 
    -0.16146192f, -0.03759814f, -0.00693420f, -0.01639182f, -0.39036170f, -0.06501925f, -0.23368900f, 0.13057570f, 
    0.11516789f, -0.04798215f, 0.00448571f, 0.10488518f, -0.23004603f, 0.05015000f, -0.00410828f, 0.00681134f, 
    0.05339749f, 0.11608583f, -0.08932927f, -0.05493475f, -0.12531987f, -0.11146721f, -0.14720307f, -0.16927595f, 
    -0.36523950f, -0.49553910f, -0.36694509f, -0.45210698f, -0.03525262f, -0.15804848f, 0.04728098f, 0.16085687f, 
    0.06248565f, -0.08665018f, -0.06105327f, 0.01062400f, -0.04229580f, -0.06550714f, -0.01421901f, 0.06096810f, 
    0.12677833f, 0.02614502f, 0.08685250f, -0.10195992f, 0.09370083f, -0.02503795f, -0.09346519f, 0.30349475f, 
    0.04969110f, 0.13316141f, 0.01443031f, -0.05070639f, 0.08895625f, 0.06708338f, 0.07320024f, 0.06317106f, 
    0.07787877f, 0.03275095f, 0.03590692f, 0.05058217f, 0.22236165f, -0.04983889f, -0.03221305f, 0.17858952f, 
    0.25088197f, -0.08055666f, 0.15493695f, -0.27534005f, -0.15144159f, -0.02858088f, 0.08124575f, -0.17127641f, 
    -0.16931079f, -0.06107724f, 0.00832354f, -0.03380295f, -0.08513070f, 0.03331383f, -0.06034147f, 0.08426948f, 
    0.03065185f, -0.12117372f, -0.06895276f, -0.09488602f, -0.24005884f, -0.13087718f, 0.04183387f, 0.34276199f, 
    0.12517005f, -0.01357439f, 0.02194839f, -0.04994391f, 0.09192588f, 0.04470438f, 0.10083117f, 0.07057207f, 
    0.13929000f, 0.03489079f, 0.05421505f, 0.16286004f, 0.08497564f, 0.07972798f, -0.06775798f, 0.21000005f, 
    0.29499137f, 0.04934974f, 0.14874643f, 0.36883450f, -0.03601485f, -0.10955838f, -0.08683095f, 0.00945114f, 
    0.01488097f, -0.09033898f, -0.06033235f, -0.03759214f, 0.11301354f, 0.07617458f, 0.10048869f, 0.10261174f, 
    -0.09094963f, 0.03093737f, -0.03551972f, -0.20506091f, 0.24956915f, 0.00383457f, -0.05788045f, 0.05827398f, 
    0.04625370f, -0.04468551f, -0.18877229f, 0.01543824f, -0.04418078f, -0.06381899f, 0.09808013f, 0.09577779f, 
    0.10583384f, -0.06241088f, 0.02840662f, 0.00225489f, 0.06781849f, 0.00097133f, 0.01693108f, 0.09801619f, 
    -0.19519481f, -0.20681770f, -0.26245359f, -0.10145214f, -0.06140527f, 0.20535529f, -0.05910228f, -0.06418560f, 
    0.10240847f, -0.02018781f, 0.06278452f, -0.03413585f, 0.01489184f, -0.03835298f, 0.06483591f, 0.00178815f, 
    0.07242752f, 0.00848385f, -0.03297392f, 0.00504686f, -0.16701840f, 0.16907391f, -0.21270552f, 0.24429780f, 
    -0.09606836f, 0.14092349f, 0.07842160f, 0.01381577f, 0.01667234f, 0.01333632f, 0.12708615f, -0.08632604f, 
    0.10171784f, -0.04029033f, 0.07104321f, -0.06455757f, 0.23979166f, 0.08439856f, 0.14984360f, 0.09471389f, 
    0.17303582f, -0.02404187f, -0.12056711f, -0.11982969f, -0.14948449f, 0.00104768f, -0.00352481f, 0.14160118f, 
    -0.11198341f, -0.08792401f, 0.06319425f, 0.03555337f, -0.04234826f, -0.08246084f, -0.07756432f, 0.14374599f, 
    0.06251144f, 0.05713294f, -0.09394371f, -0.12039021f, -0.40763366f, -0.09203353f, -0.01652195f, -0.15787183f, 
    -0.29707813f, 0.05434811f, 0.02430351f, -0.19411959f, -0.06008245f, 0.09237374f, -0.03924398f, -0.02022089f, 
    0.09530167f, 0.02973679f, 0.12699160f, 0.04893821f, 0.01193875f, -0.11027187f, -0.11494670f, -0.06052798f, 
    0.30066040f, -0.12064828f, 0.30695379f, 0.02742817f, -0.28517401f, -0.05075118f, -0.12438452f, -0.01478183f, 
    0.04379131f, -0.05939065f, 0.03843306f, -0.03382825f, -0.00115329f, 0.15001784f, 0.06655309f, 0.01918690f, 
    -0.02577098f, -0.08062922f, -0.00913370f, 0.08209023f, -0.27466351f, -0.36479774f, -0.30585775f, -0.13043560f, 
    0.13266021f, -0.00286701f, 0.02616424f, -0.09553836f, 0.08136886f, -0.03110287f, 0.09865198f, 0.02585533f, 
    0.00549484f, -0.07783436f, 0.10693462f, -0.01925292f, 0.10074787f, -0.13014714f, 0.02186597f, -0.06183318f, 
    -0.04353394f, -0.20568925f, 0.04083916f, -0.05531654f, 0.07983729f, -0.08712795f, -0.07122669f, -0.10757640f, 
    0.06282805f, -0.20001338f, -0.01484060f, 0.01240251f, -0.02319148f, -0.02844039f, 0.02036466f, 0.15129830f, 
    -0.04978695f, -0.08076897f, -0.10132193f, -0.01488173f, 0.18083632f, -0.00085497f, 0.37159094f, 0.12949581f, 
    -0.06883365f, -0.01311524f, -0.02032842f, 0.02867269f, 0.02432569f, 0.02433177f, 0.10924598f, 0.01483533f, 
    0.06837680f, 0.08961768f, 0.11463084f, -0.04803945f, 0.20600484f, 0.00783714f, 0.07409279f, 0.10607544f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01164726f, 0.11267900f, 0.00173302f, -0.01412746f, 0.00868127f, -0.03282290f, -0.04230946f, -0.00088807f, 
    0.01479856f, -0.04383028f, -0.03434189f, 0.11253574f, -0.11627843f, 0.22019330f, 0.00546774f, 0.07181346f, 
    -0.04783658f, 0.00283335f, 0.05996101f, 0.20728929f, 0.09339288f, 0.11335720f, -0.04689358f, 0.01890525f, 
    0.06701770f, 0.17272025f, -0.05237406f, -0.03386565f, -0.04109387f, -0.02417803f, 0.01157144f, 0.02584905f, 
    -0.00036755f, -0.02279436f, -0.01044911f, 0.00436048f, 0.10224364f, 0.02872045f, 0.07710934f, 0.08162154f, 
    -0.11927504f, -0.03415142f, 0.05028033f, 0.05077756f, 0.12609640f, 0.03570257f, 0.06596505f, 0.00095608f, 
    0.01500939f, 0.12116233f, -0.04328145f, 0.15115719f, 0.00067161f, 0.11572394f, 0.06126443f, 0.14055903f, 
    0.07363452f, 0.06750624f, 0.04985654f, 0.04190926f, -0.03781997f, -0.12802096f, 0.00432360f, 0.01081131f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07255997f, 0.20066535f, -0.06343304f, 0.10392473f, -0.08526310f, -0.04759737f, -0.08218899f, 0.23851475f, 
    -0.37260267f, 0.07070216f, 0.16688895f, -0.34180427f, 0.05727746f, -0.10972743f, 0.16619973f, -0.10361069f, 
    -0.06248268f, -0.12757848f, -0.18681677f, 0.07550374f, -0.13694575f, 0.01537397f, 0.12023183f, 0.12304217f, 
    -0.00948904f, -0.05776608f, 0.11912304f, 0.18258487f, 0.11804891f, -0.05352619f, -0.04919294f, 0.05401062f, 
    -0.33746529f, 0.05897693f, 0.06639901f, -0.27736485f, -0.08442146f, 0.06179640f, 0.21430986f, 0.17144650f, 
    -0.07841596f, -0.01409117f, 0.18542647f, 0.24811457f, 0.17238776f, 0.12315012f, -0.13554053f, -0.18808049f, 
    -0.02473853f, 0.07647231f, -0.00677527f, 0.12544723f, 0.01559768f, 0.08202179f, 0.11493669f, 0.17316365f, 
    0.16407992f, -0.01975207f, -0.01723260f, -0.10033439f, -0.09733032f, -0.09463629f, 0.07996755f, -0.36299944f, 
    0.00910223f, -0.03732581f, -0.03087558f, -0.09315465f, 0.08506457f, 0.08233726f, -0.08164208f, -0.49086776f, 
    -0.02188040f, -0.12411965f, 0.11626496f, -0.03472606f, -0.36182225f, 0.23146932f, 0.17946592f, 0.21705699f, 
    0.11954168f, -0.04178699f, 0.31136045f, 0.10259885f, 0.29275239f, 0.11681557f, -0.06303146f, -0.10201526f, 
    0.14081077f, 0.10613898f, -0.03586553f, -0.27627423f, -0.07545725f, 0.01792403f, -0.02770537f, -0.09466628f, 
    -0.09531572f, 0.12134603f, -0.05890315f, -0.02055488f, -0.03391354f, -0.07645772f, 0.05824474f, 0.18652736f, 
    -0.10690655f, -0.28536513f, -0.16846733f, 0.07448548f, -0.11062087f, -0.03301980f, 0.17205186f, 0.33427665f, 
    0.11533903f, 0.27272469f, -0.00382180f, 0.24433295f, -0.10210095f, 0.06094841f, 0.35692745f, 0.08587545f, 
    -0.02831751f, -0.18878415f, -0.25681499f, -0.02845387f, 0.16164358f, -0.16163155f, -0.27834982f, 0.41806570f, 
    0.05837962f, -0.13690674f, -0.00963447f, -0.01044981f, -0.06363846f, -0.06121875f, -0.01148488f, 0.05321758f, 
    -0.02402961f, -0.05358008f, -0.13095158f, 0.02981286f, -0.01626141f, -0.09384090f, -0.04510850f, 0.10890089f, 
    -0.12495096f, -0.02830164f, -0.09090728f, -0.04290247f, -0.11380804f, 0.01370777f, 0.01596095f, 0.08243997f, 
    0.00297482f, 0.09645095f, -0.04581816f, -0.10592078f, 0.00122160f, -0.03459018f, -0.08254200f, 0.01921727f, 
    -0.11590531f, -0.11845417f, 0.06470910f, -0.12558652f, -0.15515071f, 0.11984943f, -0.12514013f, -0.06418569f, 
    -0.05465753f, -0.10244824f, 0.01178978f, 0.05175673f, -0.12779999f, 0.05411523f, -0.12671843f, -0.07350837f, 
    0.11090033f, -0.15420027f, 0.03720877f, -0.13451999f, 0.07659316f, 0.09842906f, 0.04562495f, -0.05925862f, 
    -0.12258025f, 0.02061309f, 0.06297479f, 0.06123157f, 0.01416628f, 0.06749485f, 0.02614651f, 0.05389055f, 
    0.08599287f, 0.07209303f, -0.21639299f, -0.03405118f, -0.10801779f, 0.08985828f, -0.03564130f, 0.00823342f, 
    0.00540105f, 0.07626131f, -0.05183236f, -0.03573538f, 0.03369280f, -0.05039909f, -0.19810228f, 0.28271639f, 
    -0.09127011f, 0.01701431f, -0.21267115f, -0.09795440f, 0.02531958f, 0.21303874f, -0.02197496f, -0.08201446f, 
    0.33698922f, 0.17619698f, -0.05877110f, -0.05890991f, 0.09304278f, 0.09327574f, 0.01675631f, -0.07188933f, 
    0.01400132f, 0.06721870f, -0.01059690f, 0.15596220f, -0.22758241f, 0.12123324f, 0.09959357f, -0.12638713f, 
    0.01527748f, -0.22492236f, 0.07756343f, -0.19125333f, 0.21527639f, -0.16723600f, -0.03823438f, 0.20375524f, 
    0.08867896f, -0.12571888f, 0.02681778f, -0.07612222f, -0.26253387f, 0.12916546f, -0.05456384f, 0.13820395f, 
    0.10471106f, 0.40408018f, 0.09137984f, 0.03217055f, 0.16656795f, 0.03669005f, -0.44547653f, -0.08964676f, 
    0.11953235f, -0.01031758f, -0.23684117f, 0.00955025f, -0.00032070f, -0.08445047f, 0.05350536f, -0.01784755f, 
    -0.24284397f, 0.07475429f, 0.17812076f, -0.34201527f, 0.08947811f, -0.02148423f, -0.06734386f, -0.11479185f, 
    -0.12242737f, -0.00652479f, -0.10114814f, 0.30355781f, -0.18950824f, 0.20876908f, 0.00934868f, -0.21183918f, 
    0.11248954f, 0.01774795f, -0.08424450f, 0.04567224f, 0.12284738f, -0.05516590f, 0.05537309f, -0.07113294f, 
    -0.28150707f, 0.03744728f, -0.00854024f, -0.16379784f, -0.16290958f, 0.07476057f, 0.16435827f, 0.18160982f, 
    -0.11536283f, -0.19891183f, -0.03970886f, 0.05069512f, 0.21650285f, -0.12401518f, 0.03898128f, -0.19443303f, 
    -0.03101195f, 0.26982605f, 0.11517846f, 0.07160196f, -0.06616576f, 0.14791228f, 0.07668357f, 0.19695061f, 
    0.02871167f, 0.08370610f, -0.27475089f, -0.12485190f, 0.03251603f, -0.08877471f, -0.03198719f, -0.39749864f, 
    -0.04164867f, 0.32354188f, -0.12450331f, 0.07313329f, 0.05630441f, -0.01246053f, -0.06242917f, 0.23829083f, 
    -0.05418605f, -0.02870815f, 0.29092959f, -0.12916003f, 0.11984496f, 0.01261730f, 0.29314053f, 0.34600255f, 
    0.10689526f, 0.06431329f, 0.00882921f, -0.03557443f, 0.28625107f, -0.01264587f, -0.32414243f, -0.16645721f, 
    0.21312431f, 0.27279305f, -0.09135570f, -0.43104288f, 0.11066017f, 0.08044799f, -0.11035844f, -0.09415047f, 
    0.11712524f, -0.06344429f, 0.08366987f, -0.01627474f, -0.17251532f, -0.04020551f, 0.04184454f, -0.07719117f, 
    -0.28841832f, -0.37916690f, 0.19544631f, 0.30947691f, -0.07503135f, -0.09656253f, 0.18734549f, 0.20231923f, 
    -0.06351031f, -0.04649013f, 0.10922980f, -0.07384387f, 0.02605738f, 0.12290761f, -0.20108539f, -0.00982461f, 
    0.05285184f, 0.02062576f, 0.03327589f, 0.01892732f, 0.06778896f, 0.10731944f, -0.14118572f, -0.14272729f, 
    0.01023960f, -0.06932864f, 0.09764735f, 0.05422442f, -0.00832457f, -0.08356018f, -0.06993119f, 0.05674545f, 
    0.03488529f, 0.12151624f, 0.13744476f, 0.04256389f, 0.04987390f, -0.31327689f, -0.13464189f, -0.11224343f, 
    0.12582816f, 0.16974276f, 0.05901162f, -0.35901394f, 0.12101123f, 0.10173679f, 0.30513486f, 0.13136616f, 
    -0.15440096f, 0.00849905f, 0.01613098f, 0.37891507f, -0.07682177f, -0.08195820f, 0.00267391f, 0.02458014f, 
    -0.02976758f, -0.01098149f, -0.01549897f, 0.15139671f, 0.17047882f, -0.05687751f, -0.02186880f, -0.08775679f, 
    0.02444776f, 0.46544182f, -0.34210753f, 0.02926370f, -0.16847980f, -0.03437951f, 0.09120483f, -0.21679920f, 
    -0.01894276f, 0.15426296f, -0.03194245f, 0.02942650f, -0.01720403f, 0.03151879f, 0.25975472f, 0.06989828f, 
    0.11267361f, -0.00469527f, -0.23043326f, -0.06180216f, -0.20559120f, -0.08388422f, 0.14702863f, 0.16411409f, 
    -0.09626311f, -0.06107940f, 0.04737366f, -0.11097091f, -0.01809266f, 0.07418615f, 0.11021482f, -0.25486049f, 
    -0.17108692f, 0.02312146f, 0.02747161f, -0.02585745f, 0.17191941f, -0.27179405f, 0.07249916f, -0.26920417f, 
    -0.10656352f, -0.12845802f, 0.02777927f, -0.06754953f, 0.05742761f, 0.03998456f, 0.05441437f, -0.26338637f, 
    0.09128537f, 0.03618005f, -0.08887953f, 0.24966320f, -0.03314705f, 0.09295136f, -0.08415417f, -0.06022533f, 
    0.01591297f, -0.03430947f, -0.06050284f, -0.19963321f, -0.14626755f, 0.00483526f, 0.00371190f, 0.03877208f, 
    0.15103322f, 0.13019720f, 0.10112853f, 0.21388942f, 0.17133062f, -0.20410684f, -0.16777435f, 0.11180829f, 
    0.03339188f, 0.02037581f, -0.02029222f, -0.11775950f, 0.17768247f, 0.01753452f, 0.05756358f, -0.07990113f, 
    0.05415773f, -0.08231445f, 0.00596514f, -0.00557843f, 0.10614677f, -0.09018110f, 0.33235410f, -0.00026561f, 
    -0.00647448f, 0.14573492f, -0.14069320f, 0.00413300f, 0.00194135f, -0.09793673f, -0.06226809f, 0.14650880f, 
    0.10272884f, -0.05721465f, 0.12689939f, -0.32556516f, -0.07380938f, -0.15380453f, 0.11433104f, 0.21933824f, 
    0.00922880f, 0.15678190f, -0.00865632f, -0.24403836f, 0.14582486f, -0.09770839f, -0.14939125f, -0.47539955f, 
    0.17362238f, 0.01077605f, -0.03456590f, -0.24184570f, 0.13035184f, -0.03448958f, 0.05239763f, -0.01316057f, 
    -0.03233321f, 0.05836155f, -0.03582759f, -0.05788856f, -0.33251593f, 0.11633113f, -0.14623322f, 0.12827139f, 
    -0.03068240f, -0.26830298f, 0.11461655f, 0.14414580f, 0.10980923f, 0.01586366f, -0.05342159f, 0.25088492f, 
    -0.08409619f, 0.06101141f, -0.08524271f, -0.18901630f, -0.36643425f, 0.01756639f, -0.17046532f, -0.04364146f, 
    0.22150365f, 0.14438823f, 0.03367854f, 0.02470520f, -0.02035392f, 0.13848180f, -0.21197355f, 0.31874502f, 
    0.06638646f, -0.23096707f, -0.14790052f, -0.10588336f, 0.03301508f, 0.06702301f, -0.11182170f, -0.17220809f, 
    0.49703935f, -0.09728439f, 0.06658548f, 0.27492279f, -0.18756373f, 0.20259888f, -0.09746258f, 0.33400264f, 
    -0.05266109f, 0.08652153f, 0.09139787f, 0.10156172f, 0.42740986f, 0.04921427f, -0.06837168f, 0.03572521f, 
    -0.02452679f, 0.15390770f, 0.11106977f, 0.04807909f, 0.07027104f, 0.05430299f, 0.08679907f, 0.04994059f, 
    0.11809279f, 0.11493386f, 0.09191893f, 0.06936797f, 0.18326060f, 0.10981235f, -0.05857152f, -0.22284065f, 
    -0.05229343f, -0.00879695f, 0.02807498f, -0.23685400f, -0.01649573f, -0.02337783f, 0.06432312f, -0.37128136f, 
    0.07705852f, -0.02717896f, 0.09954888f, -0.21186386f, 0.06379639f, 0.11116915f, 0.20406863f, -0.23994951f, 
    -0.04157710f, 0.22791782f, -0.11826079f, 0.10674971f, 0.08072963f, -0.04503535f, -0.21163951f, 0.12116344f, 
    -0.03397305f, -0.07739555f, 0.13015665f, -0.10845163f, 0.00245399f, 0.00917700f, -0.00380013f, 0.06788224f, 
    0.05966928f, -0.09031624f, -0.10838903f, -0.17271808f, 0.07933427f, -0.00166620f, 0.04132326f, -0.07728590f, 
    0.05224149f, -0.32716379f, 0.02898126f, 0.13072723f, -0.15132800f, -0.25626317f, -0.00670052f, -0.05259153f, 
    0.06819736f, -0.18288408f, 0.06594586f, -0.07741107f, 0.01970574f, 0.09935840f, 0.10458268f, -0.09158164f, 
    0.18272413f, 0.07875918f, -0.11822842f, -0.09338723f, -0.09211107f, -0.02367634f, -0.11912122f, 0.03307917f, 
    -0.03289399f, -0.01525417f, 0.03868162f, 0.08660107f, -0.16312911f, 0.00544921f, 0.00414721f, -0.08686514f, 
    0.09732816f, 0.02053304f, -0.06261650f, -0.11031801f, -0.10102019f, 0.11421842f, -0.14218897f, -0.09591374f, 
    -0.11552015f, -0.05735916f, 0.07009389f, -0.07172444f, -0.28237835f, -0.08210810f, 0.10992087f, -0.15303536f, 
    -0.11814044f, 0.03179467f, 0.08047658f, -0.00017855f, 0.07024604f, -0.06066667f, -0.07497828f, -0.33105928f, 
    0.07694288f, -0.01843626f, -0.29877585f, -0.05766127f, -0.27966839f, 0.32363921f, -0.26607230f, -0.02630821f, 
    0.11868469f, 0.09463526f, 0.25423259f, 0.18098240f, -0.01457141f, 0.21361533f, 0.06655870f, 0.09598812f, 
    -0.09378934f, 0.00234524f, -0.02267513f, -0.26177388f, -0.06380190f, 0.05717399f, -0.06536601f, 0.09191658f, 
    -0.13042413f, 0.02847082f, 0.00698052f, 0.11764473f, 0.12090035f, 0.07399663f, 0.14726476f, 0.10268068f, 
    -0.15753272f, 0.06558128f, 0.11834153f, -0.25443822f, 0.17748831f, 0.22874475f, -0.11986165f, 0.22842892f, 
    0.04722593f, -0.11701233f, 0.06613360f, 0.30270001f, -0.18573797f, 0.01592830f, 0.07858475f, 0.22847190f, 
    0.03784130f, 0.12154236f, 0.14326210f, 0.08615337f, -0.03631164f, -0.22211313f, -0.25421461f, 0.18145287f, 
    -0.03558083f, -0.14093885f, -0.23675592f, 0.09650494f, -0.06127682f, -0.06131539f, -0.07836430f, -0.10319877f, 
    0.26786727f, 0.09186442f, 0.31453758f, -0.02843863f, -0.12944141f, -0.11831813f, 0.08778900f, 0.00469292f, 
    -0.05078534f, 0.07462623f, -0.27358064f, -0.13048634f, 0.10012766f, 0.16081031f, 0.08249646f, -0.09657511f, 
    0.14353685f, 0.32256198f, 0.06607360f, 0.15695864f, -0.09929435f, -0.05081045f, 0.08556286f, -0.11504883f, 
    -0.23850574f, 0.05879734f, -0.08580366f, -0.07807264f, 0.00423421f, 0.09697057f, 0.13920246f, 0.14692965f, 
    0.08705570f, -0.13598144f, -0.09306964f, -0.06400654f, 0.10123567f, -0.17132452f, 0.20208669f, 0.03279044f, 
    -0.08247669f, 0.07991845f, -0.04514526f, -0.01231691f, -0.10858013f, -0.07286427f, 0.21554635f, -0.05226661f, 
    0.14305826f, 0.04248482f, -0.26808816f, -0.10415669f, -0.13864307f, -0.46590444f, -0.12099950f, 0.24458188f, 
    -0.02222267f, 0.11114468f, 0.31564263f, 0.02673775f, -0.04438037f, 0.06307077f, -0.09475565f, 0.08407938f, 
    -0.20209336f, 0.03081108f, 0.02038102f, 0.27457315f, 0.15134744f, 0.13380876f, 0.40927458f, -0.28336924f, 
    0.03167953f, 0.12603898f, 0.06604081f, 0.17284402f, -0.19464123f, -0.15752310f, 0.12618656f, -0.08035457f, 
    -0.36336893f, 0.05673674f, -0.09093966f, 0.05766196f, 0.06366381f, 0.10383064f, 0.06213595f, -0.00272123f, 
    -0.23414464f, 0.07046639f, -0.08883515f, 0.03351438f, -0.15114665f, 0.11842602f, 0.15813762f, 0.14451012f, 
    -0.30071884f, 0.04398582f, -0.09687729f, 0.04281554f, -0.05727832f, -0.37161908f, 0.24464656f, 0.20488277f, 
    -0.02566484f, -0.10112806f, -0.08220340f, 0.03993569f, 0.11406903f, 0.05993878f, 0.13262317f, 0.12387876f, 
    -0.17638333f, -0.29487932f, 0.14250430f, -0.06924181f, 0.23361905f, 0.17305689f, 0.18659045f, -0.06452554f, 
    -0.12470353f, 0.05675751f, -0.13244516f, 0.01998506f, 0.00740705f, 0.03488214f, -0.06626622f, 0.07565453f, 
    0.16683002f, 0.09974877f, 0.01248460f, -0.06876875f, 0.03014175f, 0.06102861f, -0.13719778f, 0.38167012f, 
    0.01086796f, 0.03749852f, -0.05022710f, 0.21195425f, 0.01012006f, 0.14818445f, -0.36101204f, 0.01013848f, 
    0.30937797f, 0.25249293f, -0.00300394f, -0.35712609f, 0.10121831f, 0.00852271f, -0.06011828f, 0.09237683f, 
    0.11195485f, -0.01284731f, 0.07882710f, 0.07519884f, -0.14963454f, 0.11919277f, 0.05713108f, -0.15312976f, 
    -0.15333998f, -0.41673902f, 0.17191279f, -0.00296782f, 0.04088982f, -0.04622447f, -0.14849111f, 0.32820952f, 
    0.00579370f, -0.09490402f, 0.03790131f, 0.01493492f, 0.04306373f, 0.12950318f, -0.26849777f, 0.07334428f, 
    0.07451744f, 0.23679452f, 0.08995269f, 0.10384025f, 0.27902877f, 0.16944747f, -0.16380665f, -0.24172500f, 
    -0.03719680f, -0.05616670f, -0.12469015f, 0.08852592f, 0.00108346f, -0.06425332f, -0.09332202f, 0.06569514f, 
    -0.04621577f, -0.10930746f, 0.03301406f, 0.01669644f, 0.07682227f, -0.16636783f, -0.07838979f, -0.05054145f, 
    -0.07372911f, -0.12792885f, -0.08073377f, -0.00114982f, -0.08875037f, -0.02995717f, 0.06688095f, -0.02282430f, 
    0.00455454f, -0.04539368f, 0.00306938f, -0.08563351f, 0.02270581f, -0.05764861f, 0.06690647f, -0.00165811f, 
    -0.14096637f, -0.00601360f, 0.08936603f, -0.13151348f, -0.11870056f, -0.05489676f, -0.10226997f, -0.08275110f, 
    -0.04100965f, 0.08013403f, -0.00385903f, -0.06050294f, -0.14973162f, -0.04380943f, 0.00116545f, 0.01901819f, 
    0.09470627f, -0.00896749f, -0.12616733f, 0.05639530f, -0.10418621f, -0.01181765f, 0.01572525f, -0.07508892f, 
    -0.11161766f, 0.05410570f, -0.08941330f, -0.10447221f, -0.06815839f, -0.04888262f, 0.02341654f, 0.04695025f, 
    0.02587210f, 0.01372905f, -0.12750551f, -0.09039275f, 0.09748545f, -0.01659928f, 0.02635683f, 0.00820423f, 
    0.06978504f, 0.00538542f, -0.08420180f, 0.00366787f, 0.15914354f, -0.00428735f, 0.01152832f, 0.13684244f, 
    0.11979407f, 0.00690318f, -0.12567490f, -0.08583481f, 0.01909897f, -0.03934730f, 0.12898979f, -0.04246029f, 
    -0.21168146f, -0.18243349f, -0.06974621f, -0.04580306f, 0.10308100f, 0.11873251f, -0.04775506f, 0.01895054f, 
    -0.14432871f, -0.11795019f, 0.11262819f, 0.20504344f, 0.10733424f, -0.01403573f, -0.06906188f, 0.10058854f, 
    -0.09170692f, 0.15474540f, -0.11015011f, 0.03754791f, 0.02366158f, -0.01215209f, 0.00799516f, 0.17673640f, 
    -0.09490993f, 0.11624642f, -0.10107850f, 0.11563923f, -0.07849527f, -0.00874908f, 0.13614331f, -0.00035448f, 
    -0.07591156f, 0.03509697f, 0.11075687f, -0.10080241f, 0.02285103f, -0.05956775f, 0.10668882f, -0.09103458f, 
    -0.11225818f, 0.13963380f, 0.12589265f, 0.06150510f, -0.03633544f, 0.00452061f, -0.12289251f, -0.06399960f, 
    -0.05706723f, -0.00267119f, 0.31464732f, 0.05552077f, 0.10946292f, 0.13902645f, -0.01823450f, 0.26766708f, 
    0.05636470f, -0.17898785f, 0.14682339f, 0.00511058f, 0.22209391f, 0.05624949f, -0.19055361f, 0.40971890f, 
    0.19681586f, 0.11602248f, -0.08307619f, -0.12849802f, -0.00556052f, 0.06669162f, 0.03220565f, 0.11676871f, 
    -0.06821845f, -0.00146086f, -0.01952469f, -0.11464369f, 0.02011173f, 0.02729899f, 0.07505498f, 0.13977395f, 
    -0.24372263f, -0.17073868f, 0.15849175f, 0.08848207f, 0.15733238f, -0.17250557f, -0.07140996f, -0.06180189f, 
    -0.03908918f, -0.24978152f, 0.04482226f, -0.01940734f, -0.05236144f, -0.07422228f, 0.07604360f, 0.16954681f, 
    -0.06247562f, -0.33054021f, 0.00654870f, 0.02375361f, 0.18155991f, -0.12064859f, 0.02477686f, 0.06377999f, 
    -0.01342902f, 0.01004307f, 0.07733245f, 0.08951586f, 0.03099814f, -0.10762212f, -0.06764427f, 0.13361236f, 
    0.12390924f, -0.04449420f, 0.12718947f, -0.00621066f, 0.02030808f, -0.11786770f, 0.04563186f, 0.17492083f, 
    0.03957932f, -0.20927711f, -0.00535261f, 0.04164412f, 0.24441059f, 0.11169993f, -0.07643597f, -0.12508020f, 
    0.21342041f, 0.06310883f, 0.03605527f, -0.04931920f, -0.00323130f, -0.12211564f, -0.01832364f, 0.02727707f, 
    0.10944972f, 0.12401587f, 0.08302853f, 0.12906410f, -0.15001568f, -0.03573167f, 0.13136312f, 0.00580704f, 
    0.04552832f, -0.11515553f, 0.07983122f, 0.17022282f, -0.32649806f, -0.15077390f, -0.11268952f, 0.06743512f, 
    -0.00253513f, 0.05169631f, 0.06986107f, -0.12358720f, 0.21162060f, -0.07073205f, -0.03847738f, -0.16032107f, 
    -0.12570208f, 0.03437257f, -0.08150163f, -0.11019723f, -0.02609928f, -0.02571349f, 0.07540163f, -0.09410507f, 
    0.00748572f, 0.17298992f, 0.15948135f, 0.07246224f, 0.00541756f, -0.05423573f, 0.09092728f, 0.42555621f, 
    -0.28415197f, -0.00534377f, 0.38215619f, -0.01735560f, 0.41114432f, -0.21123996f, 0.06719668f, -0.13211375f, 
    -0.07034735f, 0.08051439f, 0.08513479f, -0.32103804f, -0.07221992f, 0.17966403f, 0.21851736f, 0.32001710f, 
    0.17743634f, 0.22547749f, 0.09496520f, 0.25892699f, 0.00193945f, 0.03047489f, 0.01892335f, 0.09058348f, 
    -0.08248028f, 0.07759926f, 0.04175715f, -0.03647293f, -0.05160208f, -0.01228583f, 0.01925513f, 0.00040427f, 
    -0.17855158f, 0.30063739f, 0.05471119f, 0.14757483f, -0.22225863f, 0.02293726f, 0.05723014f, -0.15990826f, 
    -0.02147621f, 0.04183843f, 0.02574400f, -0.14011484f, 0.07770258f, -0.06629553f, 0.00653978f, -0.04516707f, 
    -0.11277278f, -0.25018486f, 0.04222643f, 0.04523296f, 0.22594479f, 0.07672261f, 0.37356487f, 0.13339408f, 
    -0.09500743f, 0.26006928f, 0.36294553f, 0.06792954f, -0.11925960f, -0.03710628f, -0.11173218f, -0.16115947f, 
    0.13196582f, -0.04119274f, -0.03149721f, -0.01886512f, -0.17267756f, 0.23170741f, -0.11466603f, 0.11458863f, 
    0.03440014f, -0.06202467f, 0.28930411f, 0.09293468f, 0.17927606f, 0.03062966f, -0.03876208f, -0.08266573f, 
    0.18172106f, 0.00926693f, 0.04555138f, 0.01397349f, 0.11912313f, 0.03097640f, -0.01933115f, -0.04546371f, 
    0.01393540f, -0.11211371f, 0.06509469f, 0.00706106f, 0.07765916f, -0.05988900f, -0.03478905f, -0.00276621f, 
    -0.08574681f, -0.05250839f, 0.07383490f, 0.16558798f, -0.00755694f, -0.01961416f, -0.01337693f, 0.47973087f, 
    0.03367459f, -0.10759910f, -0.05429134f, 0.05654584f, 0.04873225f, -0.04695938f, -0.02464448f, 0.04418979f, 
    -0.26099706f, -0.17009611f, -0.04120135f, 0.04933031f, 0.02364779f, -0.05875586f, -0.06769162f, 0.31209010f, 
    -0.06233083f, 0.03466109f, 0.08844478f, -0.00260055f, -0.04587051f, -0.00100203f, -0.09620243f, -0.19468313f, 
    0.12312261f, -0.06126186f, -0.00131001f, 0.19004829f, -0.23757844f, 0.15508991f, 0.08840030f, -0.03257110f, 
    0.04394877f, -0.09917844f, 0.01299941f, 0.25382000f, 0.12645149f, 0.08536075f, -0.24119888f, -0.36074746f, 
    -0.23472695f, 0.03664919f, -0.09144874f, 0.00754693f, -0.11473504f, -0.05281290f, 0.11539304f, 0.05260719f, 
    -0.10360236f, -0.09102682f, 0.13086244f, 0.10704236f, -0.03665470f, 0.10291681f, 0.14907467f, 0.17575398f, 
    -0.32193583f, -0.40421110f, -0.06836861f, -0.05447267f, 0.06329339f, -0.06539550f, -0.03500740f, 0.33738625f, 
    -0.07050444f, 0.34923542f, -0.00995936f, 0.17812873f, 0.43242431f, 0.20255172f, 0.21458982f, -0.08557288f, 
    -0.02898725f, 0.16998962f, 0.04760060f, 0.06556380f, 0.22933103f, 0.06402313f, -0.11269971f, -0.13828196f, 
    -0.10726123f, 0.00889965f, -0.01133839f, -0.08592761f, -0.01989546f, 0.03117477f, -0.08033664f, -0.15164834f, 
    -0.11125264f, 0.03155389f, 0.08486871f, -0.06063404f, -0.18365404f, 0.13983905f, 0.27319840f, 0.02084743f, 
    -0.00159483f, 0.21017323f, 0.15938793f, 0.06573348f, 0.00993208f, -0.03311357f, 0.26298979f, -0.10774393f, 
    -0.24265803f, -0.08734548f, -0.00818865f, 0.08929639f, 0.04702892f, -0.10421984f, 0.03456984f, 0.00255610f, 
    -0.02505786f, 0.00312594f, 0.03793294f, -0.25052425f, 0.24839260f, 0.04812115f, 0.02837310f, 0.19875638f, 
    0.09492380f, 0.10013884f, -0.31119281f, 0.06235989f, -0.20753478f, -0.03504236f, 0.27005821f, -0.42133039f, 
    -0.03505523f, 0.10105484f, 0.12401119f, -0.11375684f, 0.30887589f, -0.11086150f, 0.29774481f, 0.06615831f, 
    0.02028421f, -0.04539891f, -0.21999042f, 0.09508838f, -0.05899919f, -0.09897670f, 0.23942767f, 0.26462185f, 
    0.02642497f, 0.00410592f, 0.07498450f, -0.11858095f, 0.08074574f, -0.07480466f, -0.03641425f, -0.05476979f, 
    0.24290182f, 0.10687069f, -0.04551149f, -0.03241680f, -0.00140484f, -0.14054632f, -0.33382457f, -0.07675850f, 
    -0.06912518f, -0.00119927f, 0.19228661f, 0.02882088f, -0.11162136f, 0.04060407f, 0.08296403f, -0.03224314f, 
    0.31042132f, -0.01714643f, -0.05343491f, -0.08877857f, -0.12280843f, -0.00753482f, 0.08052281f, -0.04301529f, 
    0.24409424f, -0.03199465f, -0.01074472f, 0.31894159f, -0.14022058f, -0.00755387f, -0.06809141f, -0.14410105f, 
    0.07749297f, 0.04393687f, -0.02815448f, -0.13816926f, 0.25476468f, 0.15772034f, -0.24880977f, 0.47028369f, 
    0.00204101f, -0.10044318f, 0.00374151f, 0.16417482f, -0.10143240f, 0.18587422f, 0.03137521f, -0.00118577f, 
    0.11395422f, 0.23514931f, 0.01124705f, -0.01994435f, 0.12840270f, 0.20287438f, -0.08247708f, 0.22525632f, 
    0.00281794f, 0.14565891f, -0.05299800f, 0.06163426f, 0.05144371f, 0.12363189f, 0.06036796f, -0.14764312f, 
    -0.01795539f, 0.05151441f, 0.14204109f, -0.15149894f, 0.09589235f, -0.26104179f, -0.20823395f, 0.19626497f, 
    -0.07682303f, -0.01086289f, 0.17136368f, -0.14447051f, 0.18950775f, -0.15877523f, -0.00576444f, -0.01722287f, 
    0.20736140f, -0.17833081f, -0.09301629f, 0.06373782f, 0.09089912f, -0.03787846f, -0.02173153f, 0.04382912f, 
    0.15841812f, -0.06130009f, -0.08596064f, 0.10644393f, -0.25006381f, 0.10073474f, -0.22393370f, -0.06696127f, 
    0.15847330f, 0.03389607f, -0.04465760f, -0.04168993f, 0.10564405f, 0.07414965f, -0.04107097f, 0.37828112f, 
    0.04662723f, 0.02348552f, 0.00768621f, -0.02744017f, -0.17069314f, -0.09007126f, 0.12222047f, -0.05540894f, 
    -0.16800451f, 0.21549462f, 0.01407657f, -0.06308259f, 0.04620444f, 0.34034029f, -0.04494489f, 0.21079056f, 
    -0.07914755f, -0.15606473f, -0.18764488f, -0.01302283f, 0.03329723f, -0.04703239f, 0.11837750f, 0.17207159f, 
    0.23353295f, 0.11607525f, -0.06297662f, 0.00526190f, -0.17771493f, 0.08647328f, -0.08942685f, 0.36217135f, 
    0.04934882f, 0.13921387f, -0.25249481f, 0.06839926f, 0.07768531f, 0.05059333f, -0.24868116f, -0.11031841f, 
    0.06327783f, -0.01277566f, 0.12188375f, -0.08712105f, -0.09152246f, 0.05944701f, -0.03349985f, 0.10546811f, 
    0.02480799f, -0.10405335f, -0.00975972f, 0.04788033f, -0.00073295f, -0.01399340f, 0.14861475f, -0.13100503f, 
    -0.07227442f, -0.12895712f, 0.17016780f, -0.24467322f, -0.12546788f, 0.25950927f, 0.21718942f, -0.18665507f, 
    -0.09847347f, 0.02322942f, -0.08668970f, -0.01065828f, 0.07325853f, 0.19106434f, -0.11441747f, 0.14774220f, 
    0.10334335f, 0.40872270f, 0.06050144f, -0.04992764f, -0.23975410f, -0.01865506f, -0.11574807f, -0.08346101f, 
    0.10756159f, 0.18753946f, 0.10349531f, -0.10595887f, 0.07782809f, 0.08232962f, 0.08054190f, 0.16384177f, 
    -0.07754577f, 0.04166241f, -0.14380907f, 0.17169712f, -0.32243291f, 0.38505363f, 0.30114368f, 0.04559435f, 
    0.01111057f, -0.02810003f, -0.11100983f, 0.46521065f, 0.11619989f, -0.07941405f, 0.03801216f, 0.01263828f, 
    -0.04703613f, -0.02983388f, 0.11369178f, -0.27885553f, -0.04091338f, 0.07757635f, 0.12566528f, 0.03375360f, 
    0.07273232f, 0.05604141f, -0.11684798f, 0.04891220f, 0.11941433f, 0.04860733f, 0.20820872f, 0.11402405f, 
    0.00562534f, -0.15797666f, 0.13981919f, -0.08490665f, -0.00063953f, -0.09518550f, 0.27035806f, -0.10857478f, 
    0.10854395f, 0.00354556f, -0.11923584f, 0.22940612f, -0.11501191f, 0.12811266f, 0.00144250f, 0.06808482f, 
    -0.10799226f, -0.08909580f, 0.04623562f, 0.06174873f, -0.13759598f, -0.26493523f, -0.16059171f, -0.09053259f, 
    0.07607758f, -0.08946465f, 0.08214700f, -0.02470522f, 0.10595974f, 0.09756283f, 0.06678412f, -0.12842734f, 
    -0.05261647f, 0.08418278f, 0.20399061f, 0.27462465f, 0.24852198f, 0.18226051f, 0.13144927f, -0.13732618f, 
    0.11417808f, 0.06040708f, 0.11665685f, 0.23552987f, 0.17499353f, 0.00069315f, 0.23503982f, 0.49242586f, 
    -0.38205609f, -0.10599022f, 0.00061616f, 0.18823832f, -0.04687427f, 0.11205210f, -0.03068435f, 0.10552302f, 
    0.03460504f, -0.11349016f, -0.04350888f, 0.06659889f, 0.18418823f, 0.05540520f, -0.00870938f, 0.10177414f, 
    -0.09342784f, 0.32856125f, -0.16527851f, -0.21947160f, -0.21239318f, 0.02643595f, 0.05814855f, -0.41584960f, 
    0.01359155f, -0.08880806f, -0.00220064f, 0.06511757f, 0.37889919f, -0.11937506f, 0.23222299f, 0.02303595f, 
    0.03525374f, -0.10665862f, 0.03506760f, -0.06916548f, 0.08210734f, 0.15699565f, 0.37395450f, -0.04355379f, 
    -0.07912615f, -0.11704412f, -0.14327347f, -0.11470924f, 0.02728408f, -0.10031308f, -0.00638469f, 0.13463992f, 
    -0.08626775f, 0.09655577f, 0.14523473f, 0.06512009f, 0.04956743f, -0.16855814f, -0.11071683f, 0.00234426f, 
    0.00271214f, -0.12628359f, -0.04411955f, 0.22388010f, 0.01714194f, 0.03901770f, -0.14946264f, 0.08605302f, 
    0.18037979f, -0.03936515f, -0.04899987f, -0.13879608f, -0.00403135f, 0.01674775f, -0.06452711f, -0.04606118f, 
    0.00668176f, 0.08471549f, 0.11367419f, -0.11048580f, -0.03892573f, 0.02779727f, -0.01861869f, -0.09552919f, 
    -0.10055547f, -0.09040979f, 0.07540137f, -0.05384065f, 0.08574641f, -0.03366064f, -0.17625788f, -0.08023302f, 
    0.02965449f, 0.02301935f, 0.03678102f, -0.16084172f, -0.09291792f, -0.02319830f, 0.03411931f, 0.08722659f, 
    0.05422616f, -0.10015732f, -0.29233614f, -0.05561712f, -0.10233077f, -0.03666046f, 0.00830768f, -0.09626898f, 
    -0.10939603f, 0.02329112f, 0.03439571f, -0.06772184f, 0.01462178f, -0.11753777f, 0.07239187f, -0.15088895f, 
    0.12530327f, 0.11316427f, 0.01782729f, -0.09316450f, -0.29472569f, 0.25401354f, 0.20348570f, 0.14216103f, 
    0.03681261f, 0.22449201f, -0.07058728f, -0.07029683f, -0.05875006f, 0.05353507f, 0.13351116f, 0.04669200f, 
    -0.38669971f, 0.21775785f, 0.05823832f, 0.01071091f, -0.04657780f, 0.08371112f, 0.08013152f, 0.08988427f, 
    -0.02397376f, 0.01263348f, 0.06247264f, -0.15472727f, 0.31622475f, 0.09342125f, 0.21829253f, 0.20099084f, 
    -0.00836957f, 0.07189624f, -0.11604317f, 0.05072428f, 0.10221742f, 0.24789363f, 0.31106398f, -0.25272396f, 
    -0.01330960f, 0.06573859f, 0.07747988f, 0.22530346f, -0.06995084f, 0.11566057f, 0.04578436f, 0.11592434f, 
    0.14526854f, -0.05291344f, -0.02698777f, 0.08827376f, -0.27674472f, -0.36314133f, 0.10728530f, 0.19116686f, 
    -0.09090249f, 0.17354068f, 0.04589336f, -0.08237851f, -0.12775171f, -0.07580267f, -0.12213503f, -0.07024729f, 
    -0.38387445f, 0.11232903f, 0.00187443f, -0.33166358f, 0.27316028f, 0.08367573f, -0.18628092f, -0.17369148f, 
    -0.03672078f, -0.00586958f, -0.03112774f, -0.07684166f, -0.19558333f, 0.08052944f, -0.02117221f, 0.29476127f, 
    0.12227789f, -0.05208031f, 0.06113227f, 0.14038147f, -0.00144771f, -0.09298822f, -0.00147587f, 0.11582734f, 
    -0.09498072f, 0.06260311f, 0.05037118f, -0.11686962f, 0.05416681f, -0.03831613f, 0.02630543f, 0.12474786f, 
    -0.06813271f, 0.10654371f, 0.19275109f, 0.24306840f, 0.19621651f, 0.13405661f, -0.19762358f, 0.03950696f, 
    -0.10158217f, 0.04297907f, -0.04867667f, -0.05269966f, 0.10879463f, 0.07610059f, 0.00714930f, 0.10747397f, 
    0.17422308f, -0.08089054f, 0.06462059f, -0.02105646f, -0.04242888f, 0.01753232f, 0.49653021f, -0.24692334f, 
    -0.07809055f, -0.04599000f, 0.08805750f, 0.07635505f, 0.12358847f, -0.01615890f, 0.11624718f, -0.06282783f, 
    0.16377178f, -0.01817075f, 0.11475083f, 0.01643931f, -0.01726643f, 0.26299259f, 0.10345928f, 0.07672116f, 
    -0.08717155f, 0.10790920f, 0.02892885f, -0.19403696f, 0.09424955f, 0.04772007f, -0.00386281f, 0.21963556f, 
    -0.15870544f, -0.09124572f, 0.03726961f, 0.00445487f, -0.00163874f, 0.06837798f, 0.07198486f, -0.01075036f, 
    0.30092645f, -0.03052284f, -0.07590405f, 0.06924532f, 0.18141210f, -0.02276665f, 0.07622587f, -0.00190877f, 
    0.00046534f, 0.06170836f, -0.01410434f, -0.00385400f, -0.07359304f, 0.15361314f, -0.12405975f, -0.26238269f, 
    0.07817375f, -0.11229880f, -0.03409987f, -0.01314574f, 0.23033911f, 0.02661017f, -0.05894323f, 0.05131901f, 
    0.14957340f, -0.30286476f, -0.09520362f, 0.02100395f, -0.06363864f, -0.16652389f, 0.22270346f, 0.07613673f, 
    0.04456167f, -0.20519693f, -0.19890787f, -0.06598027f, 0.01057663f, 0.07470296f, 0.02924534f, 0.17487824f, 
    0.30423239f, 0.07703045f, -0.10303399f, 0.19989274f, -0.06142601f, 0.13726233f, 0.02005169f, 0.08897285f, 
    0.06323246f, 0.06132780f, -0.14290449f, 0.18553871f, -0.05351545f, 0.18367435f, -0.16620907f, -0.19626693f, 
    -0.06191169f, 0.08698145f, 0.04564467f, 0.03870320f, -0.08520497f, 0.05836790f, -0.04950667f, 0.02007219f, 
    -0.07323083f, 0.07554436f, -0.06056627f, 0.06159002f, 0.05317909f, -0.06740849f, 0.08382930f, 0.02635100f, 
    -0.15034702f, -0.09452233f, -0.03991039f, -0.33290157f, -0.04040939f, -0.09282286f, 0.30855036f, -0.18765606f, 
    -0.11493210f, 0.04653644f, -0.00441043f, -0.14975172f, 0.20297116f, 0.18206395f, 0.16793483f, -0.09109651f, 
    0.06843943f, 0.37243700f, 0.07781192f, 0.12162723f, -0.05426615f, 0.08075419f, -0.36119673f, -0.09875324f, 
    -0.12286271f, -0.20267591f, -0.15438068f, -0.03411185f, 0.01645896f, -0.04234155f, -0.00346006f, 0.27358124f, 
    -0.07679641f, 0.11791774f, 0.37382811f, 0.18196198f, 0.32652754f, -0.34139872f, 0.09683593f, -0.06070135f, 
    -0.09623881f, 0.10982156f, -0.04409134f, -0.08954628f, -0.01295371f, 0.08339904f, -0.03152203f, 0.16591421f, 
    -0.10837344f, -0.01063910f, -0.05559634f, 0.44563833f, 0.11455399f, 0.05676974f, 0.08689311f, 0.08682186f, 
    0.02600410f, -0.10842795f, -0.11200915f, -0.14720659f, 0.02892928f, -0.11437964f, 0.13639393f, -0.04497065f, 
    0.04203343f, 0.21068127f, -0.13589349f, 0.05585428f, -0.24464536f, 0.04488709f, 0.29215866f, -0.45966959f, 
    -0.04109809f, 0.09009890f, -0.02520695f, -0.05167839f, 0.29630518f, -0.12165726f, 0.13806742f, -0.14784434f, 
    0.00783349f, 0.22513592f, -0.01671266f, 0.06535065f, 0.09883940f, 0.16981113f, 0.33562648f, -0.10406325f, 
    -0.08186638f, -0.11828316f, -0.04762500f, -0.12614831f, -0.10833031f, 0.10065085f, -0.01174573f, -0.03637780f, 
    0.05454748f, 0.09632061f, 0.08554500f, 0.09591918f, -0.01144830f, -0.13267697f, 0.04992963f, -0.07433934f, 
    -0.04431493f, 0.00169451f, -0.00742301f, 0.06071496f, -0.07925642f, -0.07346946f, 0.06838953f, 0.02195230f, 
    -0.08500084f, -0.08159597f, -0.10926000f, -0.02983585f, 0.03811188f, 0.06711894f, 0.09229567f, -0.01056246f, 
    -0.13069801f, -0.07541919f, 0.07311478f, 0.00481208f, -0.09989693f, -0.04420818f, 0.08990862f, -0.08380154f, 
    -0.08772776f, 0.06972962f, -0.09374512f, -0.01963548f, -0.08812471f, -0.12715937f, -0.09133434f, -0.05428530f, 
    -0.10892858f, 0.02266570f, 0.03996452f, -0.12487925f, -0.11044018f, -0.13238126f, -0.13713008f, 0.01320776f, 
    -0.09074774f, 0.10299402f, -0.02476110f, -0.04487853f, 0.10656985f, -0.04327599f, 0.07566907f, -0.10231335f, 
    -0.07805088f, -0.08673704f, -0.01252695f, -0.12291478f, 0.01587969f, -0.08400610f, 0.10536323f, 0.13066968f, 
    -0.02069492f, 0.11288272f, -0.12886225f, -0.10510489f, -0.00460251f, -0.00756942f, 0.01465145f, 0.10433254f, 
    -0.00998512f, -0.19618064f, 0.12511815f, 0.17982700f, 0.00871428f, -0.18535054f, -0.14206378f, 0.00055056f, 
    -0.03695824f, -0.17939758f, 0.11856775f, 0.01805707f, 0.12200212f, -0.00113897f, -0.06692663f, 0.10777763f, 
    -0.06431850f, -0.11768708f, 0.00046994f, -0.05802702f, 0.03331654f, -0.09135838f, -0.00602204f, 0.01362261f, 
    0.21285532f, 0.06534594f, -0.03399503f, -0.16961403f, -0.07911210f, -0.11119638f, -0.04319870f, -0.01742433f, 
    -0.05583782f, -0.07145754f, -0.02084638f, 0.03588108f, 0.02112578f, 0.04029997f, -0.00127904f, -0.01367030f, 
    -0.02954273f, -0.14338249f, -0.14106712f, 0.00920802f, -0.09073697f, 0.04215328f, 0.12183252f, -0.05094814f, 
    -0.01436527f, 0.13560770f, 0.22216892f, 0.04322388f, -0.11513411f, 0.09693833f, -0.04529710f, 0.06381208f, 
    -0.20210843f, -0.12322090f, -0.24862473f, -0.09197368f, -0.05828262f, 0.06732351f, 0.03246789f, -0.22996821f, 
    -0.06547990f, 0.18755768f, 0.04021146f, -0.03362874f, -0.20574681f, 0.14874530f, 0.11966874f, 0.24848647f, 
    -0.23104900f, -0.02838024f, 0.02064579f, -0.06142873f, 0.03307458f, 0.11746149f, -0.08966295f, 0.04058330f, 
    0.18917739f, 0.02125923f, 0.09741753f, 0.00556231f, 0.12582324f, 0.11905392f, 0.13293158f, -0.15097564f, 
    -0.13972121f, 0.18363859f, -0.04748089f, -0.16629767f, -0.02175194f, 0.44586697f, -0.24119397f, -0.30748612f, 
    0.12149342f, -0.06160361f, -0.02778272f, 0.03623505f, 0.16453685f, 0.24981217f, 0.02940303f, 0.14300360f, 
    0.16799572f, -0.06495068f, 0.27997023f, -0.00063956f, -0.26906011f, 0.03658868f, 0.42203873f, -0.19827397f, 
    0.02036086f, 0.05414709f, 0.16758654f, 0.09172761f, 0.05661811f, -0.04884061f, -0.07357336f, -0.11763219f, 
    -0.05455448f, -0.05978701f, -0.21774484f, 0.04856301f, -0.19379660f, 0.16265680f, -0.05763096f, 0.08033549f, 
    -0.09249903f, 0.07240474f, -0.03319925f, 0.00751685f, -0.13750000f, 0.26592752f, 0.04525446f, 0.26604649f, 
    0.19694473f, 0.14707425f, 0.08116917f, -0.12866466f, 0.05175127f, 0.08685645f, -0.10686833f, -0.10187183f, 
    -0.15969224f, -0.00795757f, 0.04374619f, 0.03055297f, 0.12654892f, 0.07339107f, 0.13151634f, 0.13491017f, 
    0.05253318f, -0.17226450f, 0.01543551f, -0.05817107f, 0.19611570f, 0.06272801f, -0.01650389f, 0.29643443f, 
    -0.03998639f, -0.00179811f, 0.11073857f, 0.31693086f, -0.29818663f, 0.09288490f, 0.13024206f, 0.20054804f, 
    0.11020529f, -0.01832664f, 0.13269094f, -0.01590113f, -0.06856313f, -0.19884942f, -0.33510989f, 0.14243639f, 
    0.07057557f, 0.12298103f, 0.23457807f, 0.04788886f, 0.05949014f, -0.05850620f, 0.03660485f, -0.04876674f, 
    0.15128775f, 0.12218416f, 0.24308226f, 0.19060013f, 0.07217409f, 0.05576889f, -0.09645157f, 0.24438649f, 
    -0.00658401f, -0.06675657f, 0.09863924f, -0.18289393f, 0.33276972f, 0.22216102f, -0.05024232f, -0.10698155f, 
    0.24865261f, 0.34692362f, 0.09482765f, -0.04684169f, -0.06381598f, -0.10759316f, -0.03855889f, 0.02262649f, 
    0.11164729f, 0.11366748f, -0.08748971f, 0.28128275f, 0.08022400f, -0.03983286f, 0.14715396f, -0.18518926f, 
    -0.16335157f, -0.16862874f, 0.16671708f, 0.28385013f, 0.00409434f, -0.17989336f, -0.16875714f, 0.25039953f, 
    0.08933088f, 0.22710761f, -0.06287856f, -0.21965124f, 0.37826869f, 0.24929228f, -0.02449148f, -0.11697243f, 
    -0.10519642f, -0.00181009f, 0.08178020f, 0.05656582f, 0.26447791f, 0.05582225f, 0.23600517f, -0.11175387f, 
    -0.01172328f, 0.09000093f, -0.13524242f, 0.06250370f, 0.01076347f, 0.04883075f, 0.06331796f, 0.21569777f, 
    0.22882701f, 0.09845567f, 0.04813486f, -0.03071436f, 0.20119646f, -0.05183500f, -0.01526159f, 0.25415206f, 
    0.11438495f, -0.10996510f, -0.16146123f, 0.40295190f, 0.27793422f, -0.01507634f, -0.09734570f, 0.04312357f, 
    0.07231615f, 0.04542107f, 0.07830528f, -0.01799413f, 0.08024472f, 0.09624240f, 0.09936087f, -0.05235260f, 
    0.13506871f, 0.07462685f, -0.09626993f, -0.06234083f, -0.07820106f, 0.04104735f, 0.19136743f, -0.16781312f, 
    0.23335540f, -0.09350645f, 0.16573761f, -0.01782553f, -0.22828609f, 0.18265055f, -0.04239557f, -0.04520864f, 
    -0.01925837f, 0.13279712f, 0.10544409f, 0.03076657f, 0.03490011f, 0.05885731f, 0.05436047f, 0.00956675f, 
    -0.10376775f, 0.18350069f, 0.04497865f, -0.10171185f, 0.05189989f, 0.18877743f, -0.03398022f, -0.18253629f, 
    -0.05124906f, 0.08796401f, 0.24252853f, -0.07415622f, 0.05136481f, -0.11156555f, 0.09647093f, -0.13528101f, 
    -0.14109330f, -0.00034384f, 0.03047448f, -0.07705349f, -0.07008011f, 0.11547590f, -0.21956907f, -0.20212860f, 
    0.05844796f, 0.01168164f, 0.11250143f, 0.02242437f, -0.01604482f, 0.15384348f, -0.07994523f, 0.18633950f, 
    -0.02893644f, 0.34505934f, -0.00918637f, -0.14300179f, -0.06752179f, 0.11836383f, -0.01528531f, -0.08165020f, 
    -0.00238593f, -0.08562890f, 0.06108484f, 0.13535087f, 0.14958060f, 0.10976554f, 0.14518899f, 0.04565506f, 
    -0.17902772f, 0.03455339f, 0.10364349f, -0.02077288f, 0.01675848f, 0.08209293f, -0.08910026f, 0.02630889f, 
    0.10559401f, 0.10907489f, -0.00719050f, 0.06136126f, 0.12357601f, 0.09050885f, -0.09721993f, 0.16946191f, 
    0.02176064f, -0.23755731f, 0.00936218f, 0.06895623f, -0.13550557f, -0.10336792f, 0.21221058f, 0.10271327f, 
    0.11953785f, 0.03507762f, 0.06262229f, 0.12529534f, -0.05800008f, 0.01883694f, -0.06314665f, 0.06619403f, 
    0.23214540f, -0.02443024f, 0.10299913f, 0.16731451f, -0.10666106f, 0.22431470f, 0.28484440f, 0.07264923f, 
    0.07011069f, 0.11624772f, 0.31447062f, -0.01544391f, 0.23182636f, -0.11080565f, -0.15488350f, -0.17108023f, 
    -0.24364182f, 0.16996619f, 0.03028258f, -0.14569746f, 0.01220557f, 0.00951772f, -0.07672521f, -0.03789686f, 
    0.32533687f, -0.11303484f, -0.03475759f, 0.04333038f, 0.22572349f, 0.12463664f, -0.05428438f, -0.11314806f, 
    -0.21488410f, 0.04388030f, -0.13676576f, 0.12613258f, -0.21464454f, 0.05033464f, 0.16619653f, -0.15462019f, 
    -0.12056504f, -0.00004249f, -0.03992185f, -0.22052357f, 0.35323367f, -0.04162579f, 0.01655801f, -0.21138099f, 
    -0.06511239f, -0.05654908f, 0.17527018f, -0.10784034f, 0.04081183f, 0.06704334f, 0.25459254f, 0.07528118f, 
    0.09789208f, -0.17927755f, -0.03762208f, -0.00589423f, 0.10745987f, -0.01101492f, 0.02340629f, 0.05547256f, 
    -0.17985965f, 0.07876951f, -0.05189670f, -0.00288983f, -0.04834712f, -0.04358563f, 0.02555463f, 0.02820449f, 
    -0.03895470f, 0.10202558f, 0.08803546f, 0.10555661f, -0.25381988f, -0.07813595f, 0.08455633f, -0.10866394f, 
    -0.09252463f, -0.13651186f, -0.00907763f, 0.00312904f, 0.08993985f, 0.00001346f, -0.08212888f, -0.12263751f, 
    0.07481530f, 0.02411230f, 0.11989459f, 0.04316514f, -0.07824136f, -0.04206501f, -0.20718226f, -0.02876782f, 
    -0.09777565f, -0.02933041f, -0.01046105f, 0.05233884f, -0.17164418f, -0.02003413f, -0.15004252f, -0.05212424f, 
    0.02521845f, -0.10347913f, -0.06915382f, 0.03559002f, -0.14503609f, 0.01525424f, 0.00404575f, -0.21070372f, 
    -0.06970339f, -0.21570171f, 0.05806534f, -0.03284954f, -0.13985863f, -0.15000135f, -0.08335092f, 0.04443863f, 
    0.01057105f, 0.10847901f, -0.12951495f, 0.01898252f, -0.03054958f, -0.11958671f, -0.00725135f, 0.08604736f, 
    -0.02199903f, 0.01992934f, -0.13608600f, -0.11887641f, -0.05205367f, 0.00547297f, -0.13718173f, 0.07178567f, 
    -0.09448019f, -0.13003621f, -0.01538397f, 0.00761838f, -0.04719389f, 0.04899925f, -0.10023871f, 0.09311920f, 
    -0.05854943f, -0.08779208f, -0.04337788f, 0.01703026f, -0.10790761f, -0.04956528f, 0.02749095f, -0.01199859f, 
    -0.01952421f, -0.06022642f, 0.04761711f, -0.09460443f, -0.12880141f, 0.01817553f, -0.10358138f, 0.01228418f, 
    -0.10394182f, 0.06967464f, 0.02884991f, -0.20550066f, 0.00347651f, 0.03764850f, 0.01207229f, 0.10792965f, 
    0.10428657f, -0.09291749f, -0.06784932f, 0.00670941f, -0.08730972f, -0.12361168f, 0.04240085f, 0.01285900f, 
    -0.14137261f, 0.08506473f, -0.07541104f, 0.07122013f, 0.04349564f, -0.00024729f, -0.09968429f, 0.00660465f, 
    -0.03659163f, 0.16243623f, 0.36029589f, -0.12537827f, -0.12131933f, 0.05022854f, -0.04886556f, -0.25701421f, 
    -0.04035524f, 0.06223270f, 0.27187023f, 0.28977153f, -0.07927562f, 0.15555497f, 0.00999864f, 0.16743299f, 
    0.03470881f, 0.23229353f, 0.34425271f, -0.12243580f, 0.12431181f, -0.09930763f, 0.09106885f, 0.21781950f, 
    -0.01219334f, 0.12001599f, -0.11416174f, 0.05669774f, 0.06994982f, 0.04438497f, 0.03061227f, -0.04942005f, 
    -0.03496157f, -0.04564374f, 0.05054226f, 0.25851664f, 0.19276966f, 0.03286166f, 0.03665043f, -0.03193911f, 
    0.02462700f, 0.12310405f, -0.01315896f, -0.10398148f, -0.02370047f, -0.12637949f, -0.08765139f, 0.14233728f, 
    -0.01405666f, 0.07016802f, -0.08588410f, -0.13507316f, -0.24254763f, -0.17660210f, 0.15139253f, -0.22213851f, 
    -0.14227059f, -0.29043269f, 0.00725995f, 0.03662943f, 0.25831956f, -0.21398507f, 0.14719434f, 0.45022571f, 
    -0.03868330f, -0.04435838f, -0.08543713f, -0.11093892f, 0.04569829f, -0.09524982f, 0.07579429f, 0.07918407f, 
    0.05454921f, -0.07010578f, -0.10538015f, -0.09272540f, -0.02592240f, -0.20057635f, 0.00015227f, 0.20059681f, 
    0.00841153f, -0.15307353f, -0.01014121f, -0.16379699f, -0.15739614f, -0.10647871f, -0.08913463f, -0.08133973f, 
    -0.07960014f, -0.08626236f, -0.10453698f, 0.08987173f, -0.08745997f, -0.08963166f, 0.01390145f, 0.10315014f, 
    0.06503622f, 0.06104181f, -0.09062752f, 0.00097052f, 0.10356300f, -0.11413606f, -0.06086640f, -0.03130814f, 
    0.03757959f, 0.02668556f, 0.06871247f, 0.00858698f, -0.28375787f, -0.08809895f, 0.02448300f, -0.01211341f, 
    0.10937255f, -0.00664444f, -0.04482289f, -0.03266684f, -0.03846643f, -0.10469449f, 0.02029902f, -0.14792714f, 
    0.08764596f, -0.14844739f, 0.05583440f, 0.01237471f, -0.01776359f, -0.27406281f, -0.00994289f, -0.13279015f, 
    -0.05154626f, -0.15237260f, -0.36863431f, 0.02749611f, 0.08686883f, 0.07076429f, 0.08086355f, 0.18582705f, 
    -0.10083823f, 0.05333466f, 0.11390062f, -0.07500057f, 0.17901620f, -0.07881583f, 0.25247127f, 0.08166939f, 
    -0.06952319f, 0.23297516f, -0.24202031f, -0.14828336f, -0.10926188f, 0.24340804f, -0.12492133f, 0.02805880f, 
    -0.21968070f, 0.08656823f, -0.05743944f, 0.01260371f, 0.02636746f, 0.09634058f, 0.01920506f, -0.09843323f, 
    0.06359642f, -0.02867148f, -0.12289757f, -0.13211037f, 0.21637851f, 0.06924610f, 0.03618620f, -0.18251525f, 
    -0.09665713f, 0.12975784f, -0.14125140f, -0.31832072f, 0.02429543f, 0.08898957f, 0.28795269f, -0.22329248f, 
    0.04901963f, 0.16247290f, -0.06921060f, -0.10016858f, 0.03052546f, 0.10088801f, 0.09177884f, 0.12061610f, 
    0.24383657f, 0.33803090f, 0.14497605f, 0.01459411f, -0.23524591f, 0.04658636f, -0.06915246f, -0.17496789f, 
    0.01320903f, -0.01200693f, 0.08153630f, -0.05395640f, -0.00919546f, 0.09991324f, 0.04101740f, -0.00802521f, 
    -0.06552294f, 0.02956708f, 0.14046139f, -0.16082899f, 0.20448934f, -0.16809370f, -0.12739238f, 0.09711674f, 
    0.09421463f, -0.11606266f, -0.05119296f, 0.00254349f, 0.03698756f, -0.05318415f, -0.04381835f, -0.06962401f, 
    0.08692265f, -0.06502153f, -0.01344598f, 0.12575465f, -0.07064363f, -0.09255956f, -0.07365321f, 0.04592630f, 
    0.13105609f, -0.08705345f, 0.06648003f, 0.01103723f, 0.02804581f, 0.07525566f, -0.06005934f, -0.20677975f, 
    -0.05248862f, 0.03600695f, -0.04952938f, 0.02675082f, -0.02446128f, -0.14242706f, -0.09294651f, -0.03855755f, 
    -0.07141377f, -0.07614845f, 0.09620937f, 0.05588875f, -0.08436285f, -0.06211738f, 0.07608327f, -0.21087569f, 
    -0.10122131f, 0.05411785f, -0.01493399f, -0.11256281f, 0.00318820f, 0.16737895f, 0.10499708f, 0.10476746f, 
    -0.02720152f, 0.13196635f, -0.11474530f, 0.07027647f, 0.01345475f, 0.04483433f, -0.01910527f, -0.12107695f, 
    0.03973722f, -0.12132074f, -0.06757307f, -0.02637351f, -0.02322628f, 0.06412490f, -0.06313466f, 0.11863915f, 
    -0.12441461f, 0.12591887f, 0.11493018f, -0.11470713f, -0.00845756f, -0.00618173f, -0.23312096f, -0.34835199f, 
    -0.01951946f, -0.01794890f, 0.01086320f, -0.19403785f, 0.00657964f, 0.10710169f, 0.01708338f, 0.06579157f, 
    -0.05542920f, -0.03273742f, 0.10911734f, -0.06503072f, -0.19538292f, 0.08486815f, -0.13071792f, -0.04944878f, 
    0.10393168f, -0.35398257f, 0.12649953f, 0.11574347f, 0.27681887f, 0.07575649f, 0.05182849f, 0.21969560f, 
    0.09327307f, 0.01849279f, 0.02950826f, -0.07425503f, -0.17192921f, 0.08078063f, 0.00887800f, -0.03235738f, 
    0.18134987f, 0.01687228f, 0.00014083f, 0.10485773f, -0.04270894f, -0.02573531f, -0.43841988f, 0.26869071f, 
    0.03873810f, -0.12305871f, 0.07183677f, -0.02341134f, -0.03549574f, -0.01820719f, 0.09921958f, 0.08017197f, 
    0.11398087f, -0.02046489f, 0.02355941f, 0.19943818f, 0.17793429f, -0.13988185f, 0.02562291f, 0.01970767f, 
    0.10124545f, 0.18354133f, 0.00196871f, -0.06916744f, -0.09161576f, 0.19701873f, 0.27351156f, -0.10525212f, 
    0.11456697f, 0.08470181f, -0.00540397f, 0.03595139f, 0.05472709f, 0.02057009f, 0.10026853f, -0.01794372f, 
    -0.01578852f, -0.02929820f, -0.01322017f, 0.06988196f, -0.01118954f, -0.07211602f, -0.11386833f, -0.21625160f, 
    0.35319224f, 0.19039330f, -0.10810326f, -0.39024577f, 0.33479661f, -0.31751487f, 0.13071156f, 0.17683396f, 
    0.10757663f, -0.15930825f, 0.11596037f, 0.00514825f, -0.13406518f, 0.04510275f, -0.02123603f, -0.15592358f, 
    -0.01754356f, 0.18768255f, 0.02546230f, 0.06745174f, 0.22010446f, 0.30920619f, -0.05719233f, 0.07545806f, 
    -0.10845380f, -0.00583654f, 0.16401459f, -0.03415791f, 0.02326360f, 0.04146105f, 0.07595401f, 0.13139229f, 
    -0.15397069f, -0.12932877f, -0.08832607f, -0.14097901f, -0.09791420f, -0.14144464f, 0.02260370f, 0.04845272f, 
    -0.07390664f, -0.19735371f, -0.07455956f, -0.07264393f, -0.21487609f, 0.07044099f, -0.22159155f, 0.17963468f, 
    -0.05585901f, -0.15862896f, -0.09230102f, -0.10628346f, -0.00943574f, -0.00430167f, -0.12248040f, -0.00668785f, 
    0.24847195f, -0.06769895f, 0.06390752f, -0.07669002f, -0.06222640f, -0.11963211f, -0.08465533f, 0.20408952f, 
    -0.04214121f, -0.01410512f, 0.01698579f, 0.08616149f, -0.03796903f, 0.01599517f, -0.10645962f, 0.14963263f, 
    0.11573045f, -0.08677445f, -0.07354307f, 0.05696569f, 0.09231267f, 0.14404623f, -0.12498670f, 0.03851910f, 
    -0.22006626f, -0.05168038f, -0.01715284f, 0.04108694f, 0.06325316f, 0.03172612f, -0.07948645f, -0.18521903f, 
    0.03201072f, 0.09931128f, -0.00424033f, 0.00989996f, -0.05132815f, 0.06224455f, 0.03245773f, -0.19138926f, 
    -0.13693516f, -0.10998493f, -0.26363915f, 0.06053877f, -0.14391634f, 0.28207546f, 0.17604280f, -0.25511548f, 
    -0.03876838f, 0.07051881f, 0.06838519f, 0.09136941f, -0.24881524f, 0.19285887f, 0.07478558f, -0.11834658f, 
    -0.19397713f, 0.21417572f, 0.04367201f, 0.04216557f, 0.07251353f, -0.03115512f, -0.02983863f, 0.03239729f, 
    -0.20643879f, -0.00545846f, -0.02026397f, 0.22970785f, 0.02432182f, -0.01257202f, 0.17529240f, 0.14068411f, 
    -0.12998611f, -0.08228776f, -0.22723524f, -0.37048677f, 0.20766127f, -0.35359550f, 0.22191373f, 0.40299678f, 
    0.08362033f, 0.21408929f, -0.08381628f, 0.33533645f, 0.01705181f, 0.15178949f, 0.28171611f, 0.03341572f, 
    -0.11286240f, 0.07643804f, -0.07116538f, -0.05240472f, 0.17832784f, -0.10802490f, -0.26097977f, 0.10518698f, 
    -0.04109348f, 0.19597436f, -0.11663979f, -0.10816906f, -0.07932499f, 0.05844253f, 0.06950618f, 0.16580375f, 
    -0.12190408f, 0.05004977f, 0.16850242f, -0.04126735f, 0.20683129f, 0.00131379f, 0.17769869f, 0.34638983f, 
    0.00038121f, 0.10626194f, -0.07628838f, -0.01259048f, 0.14179672f, -0.02168954f, -0.10411030f, 0.19091798f, 
    0.40420201f, 0.08064560f, 0.08873420f, -0.22407614f, 0.04574067f, 0.03177337f, 0.03247835f, 0.01798290f, 
    -0.09408330f, 0.05463038f, 0.02302031f, -0.11078928f, -0.22879544f, -0.03798147f, -0.00065081f, -0.15322171f, 
    -0.09038185f, -0.09229524f, 0.04867437f, 0.10232410f, 0.09367672f, -0.12600729f, 0.06941506f, 0.12147049f, 
    -0.02478819f, -0.01097416f, 0.05747768f, -0.09155119f, -0.21384980f, 0.03618120f, -0.04819300f, 0.08745632f, 
    0.02202596f, 0.10756005f, -0.06534064f, 0.00323257f, 0.20120703f, 0.24486102f, -0.30590913f, 0.09967503f, 
    0.07488155f, 0.05137390f, 0.14217651f, -0.03673005f, -0.03739303f, 0.06003699f, -0.06976575f, -0.14699118f, 
    -0.07367262f, 0.02628765f, -0.21009992f, 0.15101728f, -0.12576087f, 0.15744346f, 0.18660061f, -0.01853317f, 
    -0.12353096f, 0.08411517f, 0.09712951f, 0.10648778f, -0.16750871f, 0.00647065f, 0.16861200f, -0.23840064f, 
    0.14541949f, 0.02100727f, -0.06158511f, -0.21113938f, -0.06041305f, 0.02338880f, 0.01403006f, -0.05866820f, 
    -0.06551430f, -0.07925338f, -0.00788404f, 0.03922639f, -0.12995102f, 0.04292924f, -0.07302811f, 0.07839084f, 
    -0.20143521f, 0.04197645f, -0.25091234f, -0.18784812f, 0.18976760f, -0.30572549f, 0.23464550f, 0.45941728f, 
    -0.09065886f, -0.06492259f, 0.00089846f, 0.09705397f, -0.01178977f, 0.12656727f, 0.15376438f, 0.12039562f, 
    0.09088704f, -0.10674591f, 0.05642574f, 0.03840983f, 0.18865611f, -0.06332478f, -0.19207154f, 0.06938782f, 
    0.06612471f, 0.03312196f, 0.19821215f, -0.02229162f, 0.09890530f, 0.11302388f, -0.09404179f, 0.02387192f, 
    -0.25055262f, -0.02887213f, -0.14096001f, 0.11098965f, -0.12507081f, 0.27142087f, 0.31123826f, -0.30644110f, 
    0.11864851f, 0.00881698f, 0.11271937f, -0.01570682f, -0.20720865f, 0.05437762f, 0.02511724f, 0.24576090f, 
    -0.37868860f, 0.17983772f, 0.09736878f, -0.18501113f, -0.08487560f, -0.09146383f, -0.11531983f, 0.08128237f, 
    -0.03323909f, 0.04533673f, 0.07321145f, 0.07613132f, 0.12819637f, -0.10556600f, 0.15646207f, 0.03527116f, 
    -0.37812406f, -0.00169672f, -0.08093208f, -0.14380215f, -0.13293353f, 0.12099208f, 0.12695038f, -0.06813403f, 
    0.06967169f, -0.24387068f, -0.09119857f, -0.08261442f, 0.06021685f, 0.15130541f, -0.06061118f, 0.09011611f, 
    0.07775311f, -0.09948628f, 0.20114526f, -0.09349059f, -0.03470200f, -0.11212796f, 0.27560344f, 0.10587472f, 
    0.07008250f, 0.11511527f, 0.02641214f, 0.00556539f, -0.09363532f, 0.09592484f, 0.09890932f, 0.10957670f, 
    -0.00060399f, -0.04433031f, -0.04780573f, -0.01090492f, -0.02022683f, 0.07763535f, 0.13070995f, 0.06062535f, 
    0.11932176f, 0.05104188f, -0.04974749f, -0.06319991f, -0.04518249f, -0.09001203f, -0.03240854f, -0.24345888f, 
    -0.09113773f, 0.03690969f, 0.10639340f, 0.10442279f, -0.02117503f, -0.02828385f, 0.08751461f, 0.07057241f, 
    -0.20251256f, -0.11283043f, 0.07393512f, 0.05992359f, -0.04602594f, -0.05864732f, -0.10717092f, -0.17214625f, 
    -0.03809576f, -0.05476443f, 0.11835551f, 0.14450806f, 0.05397889f, -0.16839485f, -0.03053302f, 0.13115707f, 
    -0.06841496f, 0.11311296f, 0.04093184f, -0.02380671f, -0.25626159f, -0.01118858f, -0.20592764f, -0.13153249f, 
    0.08043971f, 0.04778304f, 0.13574967f, -0.00139436f, -0.30930781f, -0.10960776f, -0.02420666f, 0.05119586f, 
    0.06167834f, 0.10245867f, -0.13142541f, -0.06021178f, -0.02127539f, 0.02466894f, 0.07689262f, 0.40063816f, 
    0.09217869f, 0.08064201f, -0.15872821f, -0.21117726f, 0.26604310f, -0.15648273f, 0.06447029f, -0.04367365f, 
    0.06735707f, 0.10502155f, -0.35221851f, 0.16722535f, -0.25746924f, 0.24844261f, -0.15445942f, 0.07467666f, 
    0.15336551f, 0.06706019f, -0.08299077f, 0.11127225f, -0.02975838f, -0.13904107f, 0.08815739f, 0.00224646f, 
    0.05036620f, 0.06834205f, 0.08375683f, 0.17146768f, 0.04476638f, 0.06448439f, 0.18509491f, -0.17545988f, 
    0.02751455f, 0.05895951f, 0.26908034f, -0.22024472f, -0.01478022f, 0.36985314f, 0.07504735f, -0.00340437f, 
    -0.09093645f, -0.11871798f, 0.03759319f, 0.05727855f, -0.09317963f, 0.14075083f, -0.31662062f, 0.16297615f, 
    0.17551057f, 0.55930614f, 0.14446881f, 0.07504666f, -0.21867841f, 0.19637620f, 0.10102697f, -0.35130674f, 
    0.03399575f, 0.20149638f, 0.04187901f, 0.01102132f, -0.10235739f, 0.03456113f, -0.02140152f, 0.17477106f, 
    -0.07827929f, 0.00353329f, -0.04123875f, 0.11391292f, -0.04265627f, 0.24082987f, 0.27977732f, -0.00468051f, 
    0.08753463f, -0.01711985f, -0.08568730f, 0.23015957f, -0.07599768f, 0.01972509f, -0.24404562f, 0.21391755f, 
    -0.24919124f, 0.33566189f, -0.08600155f, -0.11397818f, -0.02204852f, -0.02636087f, 0.03501328f, -0.08943573f, 
    -0.03088293f, -0.11696207f, 0.01799002f, 0.03562468f, 0.18006076f, -0.05974359f, 0.27212349f, 0.13938911f, 
    -0.13420855f, -0.11523426f, 0.09655209f, -0.12883860f, -0.27461836f, 0.06016444f, 0.09658767f, -0.20443311f, 
    0.10775002f, 0.09961995f, -0.02665576f, -0.10335031f, 0.15707345f, 0.09826303f, -0.09957752f, 0.03418728f, 
    -0.02344066f, -0.09517710f, 0.17389990f, 0.07236304f, 0.01419303f, -0.23871569f, 0.08550271f, -0.17877467f, 
    -0.02122386f, 0.35300878f, 0.38669083f, 0.07104421f, 0.04755628f, 0.03618436f, 0.05930808f, 0.05909413f, 
    -0.01627696f, 0.10315399f, 0.06713963f, 0.27053097f, 0.11546791f, 0.01650182f, -0.05004153f, 0.12792653f, 
    0.04335685f, 0.14260539f, 0.48024753f, -0.04865150f, 0.07126132f, -0.11890437f, 0.20102152f, -0.20978230f, 
    0.08547185f, -0.11903924f, -0.05582360f, -0.07986650f, 0.05653384f, -0.09130444f, -0.09346022f, 0.06720527f, 
    0.16428316f, -0.09431455f, 0.09243339f, 0.06669342f, -0.14194526f, 0.11666273f, -0.12147302f, -0.15064852f, 
    -0.20133360f, -0.01620384f, -0.10905960f, -0.20571397f, 0.22596861f, -0.04546431f, -0.20334736f, 0.80881208f, 
    -0.03782358f, -0.15591829f, 0.03572269f, -0.15079977f, 0.20362663f, -0.02151316f, 0.00764215f, -0.00323666f, 
    -0.09371322f, 0.11038806f, 0.35209852f, -0.03832930f, 0.31097859f, 0.51997513f, 0.30501139f, 0.13333976f, 
    -0.08896747f, -0.10468174f, -0.06789976f, -0.08767805f, 0.01863909f, 0.05055808f, -0.08538973f, 0.05687634f, 
    -0.13828109f, -0.10055238f, 0.01477212f, 0.07244994f, -0.09578073f, 0.02227799f, -0.05013312f, -0.12266750f, 
    -0.09893155f, 0.11899672f, -0.04289813f, -0.03511866f, -0.12454691f, 0.12088212f, -0.10272274f, 0.03055846f, 
    -0.13597235f, -0.08330262f, 0.07765725f, 0.11052351f, 0.11680602f, -0.02968159f, 0.08251608f, 0.07597557f, 
    0.07629604f, -0.11174479f, 0.06771645f, -0.02984320f, 0.00540027f, -0.00038503f, -0.02201933f, 0.04376505f, 
    -0.10087833f, 0.08335235f, 0.05240319f, -0.13730703f, -0.07823587f, 0.07658941f, -0.09644075f, -0.04509227f, 
    -0.06000982f, -0.10231017f, -0.07178304f, -0.06414845f, -0.07436422f, -0.03078047f, 0.03239547f, 0.07924674f, 
    0.15949143f, 0.07498179f, -0.05966877f, -0.12418875f, -0.10519234f, -0.14022130f, -0.07649844f, -0.06428082f, 
    0.00839065f, 0.34833607f, 0.07557271f, 0.05407766f, -0.05973151f, -0.06306306f, -0.04115185f, 0.25280163f, 
    0.03644944f, 0.02256058f, 0.22920413f, -0.11956330f, 0.14929429f, 0.02457896f, 0.11700734f, 0.17021620f, 
    0.00976751f, -0.08390324f, 0.02185226f, 0.26047277f, 0.37462097f, -0.16060026f, -0.26966763f, -0.20155382f, 
    0.27505153f, -0.07394765f, 0.10399633f, -0.24035844f, -0.04366866f, -0.00726926f, 0.01877262f, 0.12198643f, 
    0.19685680f, 0.09073811f, 0.09949103f, 0.02277846f, 0.01334157f, -0.09756345f, 0.13599998f, -0.18515137f, 
    0.07879473f, -0.17302099f, 0.17238167f, 0.29082993f, -0.13231689f, 0.07745730f, 0.07835239f, 0.20490651f, 
    0.05152790f, -0.10931711f, -0.08279163f, -0.14087455f, 0.03750929f, 0.13174255f, -0.19253707f, -0.10517441f, 
    -0.14602245f, -0.05408738f, 0.07394186f, -0.04469186f, 0.18075943f, -0.01318287f, 0.12998666f, -0.09770970f, 
    -0.01911788f, -0.07354982f, 0.05064081f, -0.09408108f, 0.05191517f, 0.00522443f, 0.06339892f, -0.01776636f, 
    0.14236118f, -0.03551690f, 0.16602831f, 0.19239204f, 0.16271079f, -0.21156569f, -0.12173168f, -0.20338909f, 
    0.08480845f, 0.00561125f, -0.00983516f, -0.39485693f, 0.02988249f, 0.24795958f, 0.28744245f, 0.31536877f, 
    -0.07573787f, 0.12237273f, -0.09327653f, 0.35631931f, 0.07656606f, 0.08421034f, -0.04344662f, -0.02397689f, 
    0.05933938f, 0.06855138f, 0.02170659f, 0.13947932f, 0.11222087f, 0.09451421f, -0.15945756f, -0.15295906f, 
    0.18777224f, 0.42147577f, -0.22764036f, -0.33520618f, -0.17146289f, 0.10466038f, -0.01866800f, -0.24279654f, 
    -0.05901464f, -0.13058457f, -0.06381079f, -0.09242901f, -0.04879882f, 0.06741311f, 0.28607845f, -0.07958523f, 
    0.10456479f, 0.29078141f, 0.03780049f, -0.11146243f, -0.10179650f, 0.09134034f, 0.25075895f, 0.26627037f, 
    0.11557238f, 0.20585540f, 0.32092765f, 0.10509781f, -0.02054360f, -0.10724516f, 0.03794228f, 0.17581567f, 
    0.21319102f, 0.02058071f, -0.07452960f, 0.20008779f, 0.17107394f, -0.04947640f, -0.11302527f, 0.00365515f, 
    0.06829806f, 0.04731358f, 0.14120336f, 0.06052759f, 0.03485654f, -0.11552609f, 0.23523331f, -0.28692231f, 
    0.06494215f, 0.01469311f, -0.09543224f, -0.03513523f, 0.08674109f, 0.00434678f, 0.00859116f, 0.02232644f, 
    -0.10503199f, -0.04962938f, 0.01644914f, 0.18381791f, -0.11496853f, 0.01244281f, -0.13363564f, -0.37561387f, 
    0.00371502f, 0.00656807f, 0.01471232f, -0.00974263f, -0.01984215f, -0.23279543f, -0.11214422f, 0.46487322f, 
    -0.11920436f, -0.26650819f, 0.03792184f, -0.07860144f, -0.08519220f, 0.08425539f, 0.04320377f, -0.07199505f, 
    -0.25141299f, 0.11706551f, 0.20006555f, -0.03104514f, 0.23571663f, 0.15718290f, -0.01374742f, 0.06692319f, 
    0.12331079f, 0.08243922f, 0.16220708f, -0.05108079f, -0.04111708f, -0.08187711f, -0.05694672f, -0.04144042f, 
    -0.14431943f, -0.03180332f, -0.18579991f, -0.20214069f, -0.08119610f, 0.11125673f, 0.11791401f, 0.10887792f, 
    0.10345502f, 0.19236186f, 0.05261277f, 0.15416825f, 0.01869926f, -0.13752493f, 0.09480503f, 0.36097571f, 
    0.05890013f, -0.13944817f, -0.08015437f, -0.02835937f, 0.04073686f, -0.11251030f, -0.13018359f, 0.09771330f, 
    0.32103738f, -0.10699373f, -0.06800532f, -0.06467707f, 0.05341553f, -0.01836187f, -0.02264242f, 0.01311804f, 
    0.06871280f, 0.12468451f, 0.02323964f, -0.03349566f, 0.06894423f, 0.17309210f, 0.07642111f, -0.36101031f, 
    -0.00434802f, -0.32375267f, -0.00648653f, -0.08472054f, -0.33289650f, 0.06098632f, -0.18428805f, 0.12078717f, 
    0.05138905f, -0.13819690f, 0.13894297f, 0.03964730f, -0.19970536f, -0.11907323f, 0.17499281f, 0.23353048f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.17617857f, 0.19313154f, -0.16511008f, 0.00697281f, 0.13501182f, 0.07550397f, -0.00136466f, 0.19884698f, 
    0.01942964f, -0.07200522f, -0.06834511f, 0.18451214f, 0.22675304f, 0.15835610f, -0.08089370f, -0.07655691f, 
    -0.09722893f, 0.03416748f, -0.05729208f, -0.07078023f, 0.15659960f, 0.07525060f, 0.06106743f, 0.09361234f, 
    -0.21533306f, -0.06088795f, 0.15431704f, 0.17782725f, -0.14522904f, 0.12945619f, -0.03398456f, -0.07044009f, 
    0.04441936f, -0.08990936f, -0.07315762f, 0.03572040f, 0.11298212f, 0.21888793f, 0.17090039f, 0.04475286f, 
    0.16359766f, 0.15008393f, -0.04045683f, -0.00803355f, 0.13865894f, 0.09773867f, -0.09381649f, -0.03530937f, 
    0.00421673f, -0.10766082f, 0.13280247f, 0.22401460f, -0.05035505f, 0.22661965f, 0.13816428f, -0.06363688f, 
    0.03727691f, 0.19592626f, 0.05215526f, -0.05851091f, -0.02366148f, -0.08966144f, 0.05646405f, 0.11363031f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.33449504f, -0.30887598f, -0.08268391f, -0.24186411f, -0.24905975f, -0.21824133f, 0.09794949f, -0.03089694f, 
    -0.08906518f, 0.04360370f, -0.01074932f, -0.20273328f, -0.15676266f, 0.06961172f, -0.18614960f, -0.10396865f, 
    -0.01756946f, 0.14796405f, 0.05201773f, 0.16809174f, 0.06258436f, -0.28281102f, -0.06116325f, 0.12504587f, 
    0.21648328f, -0.32616082f, -0.20113455f, 0.11065888f, 0.02415192f, -0.44327027f, -0.06223812f, -0.02217140f, 
    -0.36775687f, 0.14532121f, 0.09636331f, 0.01214831f, -0.28011033f, -0.30546418f, 0.09062030f, 0.07743096f, 
    -0.32298905f, 0.02334556f, -0.18625094f, 0.07822003f, 0.17855930f, -0.02032358f, -0.62555128f, 0.05059668f, 
    -0.08946368f, 0.22854424f, -0.18172783f, -0.36302462f, -0.01022774f, -0.17164440f, -0.31338143f, -0.18330044f, 
    -0.18268888f, -0.46437952f, 0.16072676f, -0.02818289f, 0.15906982f, 0.12449939f, 0.25097263f, 0.04868597f, 
    0.07408904f, 0.26422295f, -0.06462013f, 0.17586182f, 0.21613289f, 0.09173600f, -0.15864834f, 0.07865606f, 
    -0.01639864f, -0.01099210f, -0.02021659f, 0.12836695f, 0.00809957f, -0.38236672f, 0.13394964f, 0.06583748f, 
    -0.11109751f, 0.17039298f, -0.02441098f, -0.20942850f, 0.20854224f, 0.09482810f, -0.17006534f, 0.19019732f, 
    0.26197252f, -0.03502422f, -0.06852500f, -0.43509093f, 0.07781301f, -0.05036745f, 0.03844224f, -0.08560468f, 
    -0.12528735f, -0.50543779f, 0.06376019f, -0.00303160f, -0.30513155f, 0.15186158f, 0.08232611f, -0.01796101f, 
    0.02786529f, -0.03936521f, -0.03568791f, -0.00037785f, 0.07728791f, -0.07085849f, -0.21140255f, -0.08486872f, 
    0.02993978f, 0.06709243f, -0.09888005f, 0.02200535f, 0.16189706f, 0.15203969f, -0.41179857f, -0.03511523f, 
    -0.13362624f, -0.19147673f, 0.20349143f, 0.05204710f, 0.08209806f, -0.20803322f, 0.13276154f, -0.08875626f, 
    -0.39474332f, 0.14955615f, -0.10514006f, -0.01496210f, -0.27574816f, -0.31402346f, 0.09675591f, -0.03497552f, 
    0.03005761f, 0.30677161f, 0.00610829f, 0.17582718f, 0.24890125f, -0.33683953f, -0.16964430f, -0.16762213f, 
    -0.32311767f, -0.14920060f, -0.02638446f, -0.38023922f, -0.04787321f, 0.09751713f, -0.01483416f, -0.03659170f, 
    -0.18034397f, 0.14480087f, 0.14589378f, 0.04039749f, -0.14098091f, 0.14491178f, -0.49721038f, 0.06915218f, 
    0.25738218f, -0.04056438f, 0.08165997f, 0.06972713f, -0.19392644f, 0.12610033f, -0.01995710f, 0.08698490f, 
    0.03157566f, -0.00663978f, 0.05222546f, 0.07901786f, 0.09055663f, -0.04006228f, 0.12896870f, -0.15442114f, 
    -0.02157016f, 0.07785631f, -0.08167771f, 0.13570645f, -0.19462740f, -0.09583507f, -0.09636357f, -0.24553959f, 
    -0.14205879f, 0.09433611f, -0.73890328f, 0.03046133f, -0.21528602f, 0.23877817f, -0.39439139f, -0.04313844f, 
    -0.31117705f, -0.22614945f, -0.00421386f, 0.09967017f, -0.44421083f, 0.03250900f, 0.10252495f, -0.39309102f, 
    0.04034535f, 0.11191413f, -0.23880614f, -0.12915027f, -0.25381851f, -0.30017114f, -0.06368764f, 0.00045023f, 
    -0.06117778f, -0.34581470f, -0.21801150f, 0.01769118f, -0.45967612f, -0.37399679f, 0.08342278f, 0.02988140f, 
    0.09239140f, 0.13072927f, -0.37321693f, 0.18579075f, -0.06271829f, -0.02931738f, -0.03166212f, 0.09985242f, 
    0.08278978f, 0.29633680f, -0.02623650f, -0.56657654f, 0.04964416f, -0.19760995f, -0.08907565f, -0.06563211f, 
    -0.20583089f, 0.11737064f, -0.28127944f, -0.09039295f, -0.01791733f, -0.15800864f, 0.39326751f, -0.12575436f, 
    -0.11590611f, 0.06749254f, -0.25048983f, -0.30289274f, 0.13302436f, -0.38882732f, 0.01168133f, -0.50616074f, 
    0.06935348f, -0.22510709f, 0.02973865f, -0.03494111f, -0.20544240f, 0.20743151f, -0.18529163f, 0.07894031f, 
    0.01579318f, -0.13889517f, -0.18449411f, -0.34879670f, 0.01772346f, -0.37364078f, 0.14758931f, 0.07520547f, 
    0.20126043f, -0.02485530f, -0.11414421f, 0.05773145f, -0.24140832f, 0.11853801f, -0.38625017f, 0.01824833f, 
    -0.14022763f, -0.25880593f, -0.20758249f, 0.10632741f, 0.02863835f, -0.31660932f, 0.08574302f, 0.09542432f, 
    -0.14434814f, -0.23710845f, -0.01435266f, 0.07224946f, -0.21971594f, 0.04525499f, 0.20923954f, 0.11952657f, 
    -0.23610801f, -0.07249837f, -0.00297895f, -0.39814401f, 0.15034492f, -0.07964084f, -0.03837368f, -0.47076032f, 
    0.05351504f, 0.20909683f, 0.05924102f, -0.00124384f, 0.14928615f, -0.18959266f, -0.25388288f, -0.21078868f, 
    0.20561729f, -0.09720235f, 0.12181190f, -0.00505847f, -0.21383558f, 0.18519080f, 0.24491204f, 0.11185170f, 
    -0.18234120f, -0.14672855f, 0.14774384f, 0.01277268f, -0.10529623f, 0.15704368f, 0.04340555f, 0.13205354f, 
    -0.09160316f, 0.11122525f, -0.09541503f, -0.26194596f, -0.31727657f, 0.15680796f, -0.20671955f, -0.00671825f, 
    -0.32361290f, 0.06994019f, 0.11975894f, -0.01292312f, -0.29012343f, 0.14045809f, 0.00978511f, -0.09478881f, 
    -0.18938079f, 0.23243736f, 0.08338115f, -0.11762295f, 0.10471465f, 0.26302680f, -0.01791899f, -0.06055425f, 
    -0.07035766f, 0.01533594f, 0.05171072f, 0.10112265f, -0.10131314f, -0.04147075f, -0.00856406f, 0.13588117f, 
    -0.05518047f, -0.16086279f, 0.01634299f, -0.07553995f, 0.02523959f, -0.13402088f, 0.23585953f, 0.12311510f, 
    0.09970912f, 0.24008317f, 0.01479908f, 0.11948885f, 0.08413246f, 0.08987904f, -0.23269095f, -0.01417321f, 
    -0.21598482f, -0.30878857f, 0.15307622f, -0.10863522f, -0.07898954f, -0.10017657f, 0.11201657f, -0.13203862f, 
    -0.25130972f, 0.16366422f, 0.14556906f, -0.16502838f, 0.22894178f, -0.27059430f, -0.00729942f, -0.02220871f, 
    0.13456136f, 0.14389879f, -0.06268478f, -0.27578095f, 0.20486149f, -0.32821280f, -0.08297538f, -0.04081419f, 
    -0.11597040f, -0.25543985f, -0.03570883f, 0.20309189f, -0.09811053f, 0.24905063f, -0.26886421f, -0.04407480f, 
    0.22426179f, -0.40666780f, -0.10778675f, -0.63456494f, -0.12065286f, 0.32928529f, 0.17444286f, -0.48432818f, 
    0.00977971f, 0.09473246f, 0.17831238f, 0.06548955f, 0.07393827f, 0.12378351f, -0.09774438f, -0.16368359f, 
    0.16405597f, -0.04381147f, -0.10930120f, 0.03264573f, 0.02168443f, 0.04827544f, -0.68527478f, 0.05038417f, 
    -0.04695845f, -0.37536615f, -0.08192945f, 0.07647129f, -0.65837735f, -0.34757629f, 0.15875903f, -0.06722040f, 
    -0.21313304f, -0.64196855f, 0.07653991f, 0.29044154f, -0.40898395f, 0.27741662f, -0.00458931f, -0.06837442f, 
    -0.02568557f, 0.00420246f, -0.47906834f, -0.21099584f, -0.13023561f, -0.26986566f, -0.17448847f, -0.13252646f, 
    0.16889459f, -0.15566026f, 0.03344937f, -0.27524641f, 0.08623060f, -0.03773779f, 0.22913516f, 0.15463065f, 
    0.18606642f, -0.50351542f, -0.12686677f, -0.21743713f, 0.12607893f, 0.02670204f, -0.17090464f, -0.00392482f, 
    0.04692635f, -0.13982575f, -0.02339202f, 0.47100970f, -0.14341003f, 0.12797447f, 0.02514623f, -0.27368513f, 
    -0.28692922f, -0.38763022f, -0.40597448f, -0.02399139f, -0.22219938f, -0.02078771f, 0.17977473f, -0.02345991f, 
    -0.39144966f, 0.37084645f, 0.11216545f, 0.04282102f, 0.12942438f, -0.00679001f, 0.25218764f, -0.08940705f, 
    0.15680274f, -0.21791962f, -0.14911138f, 0.05186580f, -0.11079286f, 0.03787304f, 0.05106955f, -0.09577733f, 
    0.14775017f, -0.32175204f, -0.43711156f, -0.11809173f, -0.08732440f, -0.24906382f, -0.05382289f, 0.16515280f, 
    -0.05247157f, 0.04615535f, -0.36684561f, 0.06823194f, -0.09212279f, 0.21993107f, -0.34782869f, -0.35576651f, 
    0.00805997f, -0.15892056f, 0.03737881f, 0.03723757f, -0.10833671f, 0.33973902f, -0.12243569f, -0.28340900f, 
    0.07754145f, -0.04804029f, -0.30822611f, -0.37117085f, -0.05114507f, -0.31013218f, 0.14442466f, -0.01958936f, 
    -0.16480835f, -0.10407142f, 0.03830552f, 0.14011694f, -0.20252930f, -0.28871188f, -0.05612857f, -0.22132915f, 
    -0.20734812f, 0.20037031f, 0.11293680f, -0.51688826f, -0.08095793f, 0.01533669f, -0.14215526f, -0.05791358f, 
    0.09004474f, 0.09508961f, 0.09132577f, -0.46044490f, -0.16115187f, -0.13291867f, -0.00243348f, 0.18590355f, 
    -0.05391366f, 0.12611890f, -0.12539276f, 0.07797110f, -0.34334904f, -0.21094336f, 0.27229953f, -0.08647892f, 
    -0.08078564f, -0.28582749f, 0.00573851f, -0.31771320f, 0.24383099f, -0.13466871f, -0.29329818f, 0.03212679f, 
    0.19338034f, 0.12103239f, -0.61235034f, -0.04864441f, 0.31405634f, -0.33860272f, -0.11083198f, 0.02548043f, 
    -0.01018082f, 0.23035793f, 0.04232265f, -0.41157836f, -0.10069615f, -0.04983714f, 0.01942259f, -0.40568894f, 
    -0.29171804f, -0.16606978f, -0.22089718f, 0.03490042f, 0.04297984f, 0.36658984f, -0.40376365f, -0.05854860f, 
    -0.16016819f, 0.16060203f, -0.46203360f, 0.14816405f, 0.26740631f, -0.13590632f, 0.19917625f, -0.49053192f, 
    -0.37079746f, -0.40449986f, 0.13375261f, 0.19879407f, -0.02558968f, 0.13610250f, -0.02857187f, 0.09968180f, 
    -0.26704714f, -0.01566871f, -0.06282157f, -0.15878235f, -0.17623477f, 0.13575220f, -0.34573933f, -0.32124805f, 
    0.08120987f, -0.06632378f, -0.11476255f, 0.01233788f, 0.33106798f, -0.18230771f, -0.10698050f, 0.02543346f, 
    0.00023529f, -0.42612371f, -0.25911257f, 0.17998119f, 0.14505377f, 0.17767546f, 0.19067472f, -0.17720623f, 
    -0.47470838f, 0.15540205f, -0.14765856f, -0.06286205f, -0.31177041f, -0.09379490f, -0.53734010f, 0.12612288f, 
    -0.31030163f, -0.28788266f, -0.09557668f, 0.23755164f, -0.12283926f, 0.03882456f, -0.38600633f, -0.34210449f, 
    -0.39130124f, -0.06398109f, -0.16219963f, -0.06333882f, -0.33048102f, 0.38253152f, 0.14823684f, 0.11711010f, 
    0.25990030f, -0.45896155f, -0.09688744f, -0.12425662f, -0.50284368f, 0.19724587f, -0.41229126f, 0.05701480f, 
    -0.26956594f, 0.00033732f, 0.05977504f, -0.12539858f, -0.00972332f, -0.33474201f, -0.36651185f, -0.26519135f, 
    0.32293019f, -0.04737864f, -0.08619695f, -0.93490142f, -0.18891613f, 0.01933204f, 0.04705054f, -0.06669305f, 
    -0.10125998f, -0.08973899f, -0.08927556f, 0.11864229f, -0.21882589f, -0.14487542f, 0.09504294f, -0.00783294f, 
    -0.10974798f, 0.27168909f, 0.01750975f, 0.35032481f, 0.03332339f, 0.27778357f, 0.14387311f, -0.09297465f, 
    0.13633682f, 0.09430037f, 0.09877851f, -0.09438913f, -0.11235315f, -0.16256781f, 0.22544159f, -0.20526578f, 
    0.04770049f, -0.35587952f, 0.03333374f, -0.01298607f, -0.14347793f, -0.17791152f, -0.22628935f, -0.58278406f, 
    -0.31608734f, -0.16746819f, -0.19589651f, 0.33155972f, -0.36629891f, -0.27955177f, 0.09372014f, 0.05517276f, 
    -0.30504113f, -0.09610801f, -0.29120860f, -0.10640547f, -0.25594667f, -0.29477403f, -0.23181580f, 0.12507410f, 
    -0.35430971f, 0.09994653f, 0.06572964f, 0.01019952f, -0.08049515f, 0.02954465f, 0.23096325f, 0.04489732f, 
    -0.21831454f, -0.30168545f, -0.08489336f, -0.24323852f, 0.38051274f, 0.23745559f, -0.22647324f, 0.14655498f, 
    0.22818555f, -0.37286851f, -0.22903121f, -0.09823304f, -0.00909704f, -0.27063766f, -0.01591557f, -0.10462995f, 
    -0.23030518f, -0.07907048f, -0.02242550f, -0.12073373f, -0.11388902f, -0.20528407f, 0.09311668f, -0.18899858f, 
    0.39824724f, 0.14050984f, -0.05878487f, 0.15734389f, -0.04488580f, 0.01349323f, -0.02835864f, 0.21768558f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09613111f, 0.02328245f, -0.04269248f, 0.00236880f, -0.05580391f, 0.03059835f, 0.00866143f, -0.14539735f, 
    -0.11548340f, -0.04994712f, 0.06498618f, -0.04079484f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
