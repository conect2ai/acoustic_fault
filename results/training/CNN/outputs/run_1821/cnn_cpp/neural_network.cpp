#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.03211450f, 0.16298741f, 0.33080798f, 0.19550033f, 0.15428112f, 0.23875111f, -0.12468027f, 0.08943697f, 
    -0.07846369f, 0.23196739f, 0.33026761f, -0.28965619f, -0.04910810f, 0.07644681f, -0.10550981f, -0.31152812f, 
    -0.25750792f, -0.19306900f, 0.19834431f, 0.14810574f, 0.21664687f, 0.05626202f, -0.26389477f, -0.04526970f, 
    0.09221526f, -0.01159258f, -0.00640237f, 0.14280041f, 0.02753480f, -0.13177355f, -0.71435440f, -0.42871892f, 
    -0.29505703f, -0.22985537f, 0.49690485f, -0.21068469f, 0.08313865f, -0.36412153f, -0.13736762f, -0.17588699f, 
    0.34929383f, -0.13444999f, 0.25443816f, 0.04705950f, -0.54261059f, 0.02592409f, -0.24651794f, 0.08021391f, 
    -0.26928034f, -0.19631077f, -0.32804549f, -0.34718996f, 0.15824513f, 0.75126094f, -0.22436200f, 0.40774903f, 
    -0.18349808f, -0.67004693f, -0.52467203f, 0.06625005f, 0.45204940f, 0.08115114f, -0.03645073f, 0.13306010f, 
    0.11875109f, -0.03837672f, -0.30068949f, 0.55524784f, -0.05678493f, -0.27310413f, -0.37339363f, 0.03389475f, 
    -0.07785223f, 0.24461678f, 0.14635773f, 0.03523622f, -0.57385039f, -0.00796994f, 0.60765988f, 0.27010801f, 
    0.04213408f, 0.30639622f, -0.24830110f, -0.29841912f, -0.39206818f, -0.13153994f, 0.20807517f, 0.24505383f, 
    0.32926339f, -0.14340502f, -0.33464342f, 0.19088596f, -0.14573695f, -0.07525900f, 0.03625497f, -0.01456451f, 
    -0.32898375f, -0.11390625f, 0.16214366f, 0.25118765f, -0.52334917f, -0.31083581f, 0.19627276f, 0.51592004f, 
    0.09719320f, -0.70425296f, -0.04511912f, -0.12106123f, 0.18078497f, 0.15092035f, 0.04193331f, -0.27151519f, 
    0.29424509f, -0.03671474f, 0.07976209f, -0.08907308f, -0.26920095f, -0.19543381f, 0.20734471f, -0.39624980f, 
    0.08466332f, -0.03575548f, 0.01786283f, 0.10312898f, 0.21119420f, 0.34038883f, -0.01227075f, 0.08651391f, 
    0.10602529f, -0.03560937f, -0.25315982f, 0.12373559f, -0.04065062f, -0.24117208f, -0.00360113f, 0.02384806f, 
    0.32039773f, -0.16559215f, -0.06807261f, -0.09403365f, 0.22825797f, 0.26753065f, 0.02705737f, -0.18038473f, 
    -0.22715151f, -0.10489240f, 0.07790986f, 0.15009013f, 0.03229065f, 0.07230705f, 0.23559590f, -0.13636011f, 
    -0.56932271f, -0.32185587f, -0.54425007f, -0.26233277f, -0.34116217f, 0.19866496f, 0.20556796f, 0.37722871f, 
    0.47611278f, 0.34038845f, 0.28437614f, 0.00814280f, -0.12355864f, 0.03591318f, 0.09633233f, 0.03589156f, 
    -0.27467397f, -0.07218860f, -0.18850976f, 0.20296104f, -0.19851500f, -0.33122322f, 0.26849788f, -0.10117444f, 
    -0.09905852f, -0.32527879f, 0.13701667f, 0.50846124f, -0.02531588f, -0.10963532f, -0.57077563f, -0.44183594f, 
    -0.22511506f, 0.33050328f, 0.57595527f, -0.40403485f, -0.00053272f, 0.06037505f, 0.03976568f, 0.37294069f, 
    -0.11619669f, 0.18524052f, -0.28118849f, -0.20056115f, -0.12000945f, 0.15238740f, 0.10001742f, -0.27226323f, 
    -0.83064550f, -0.40145266f, 0.12632789f, 0.47451729f, -0.35911241f, -0.46518216f, -0.33091179f, -0.77441132f, 
    -0.78603226f, -0.04021383f, 0.45217723f, -0.08252741f, 0.64867926f, -0.28516158f, 0.05990328f, -0.13292655f, 
    -0.06926963f, 0.06684801f, -0.16388622f, 0.29455572f, 0.39424589f, -0.26530120f, -0.18105884f, -0.02991105f, 
    -0.09926955f, -0.48721603f, -0.80787623f, 0.03541697f, 0.37279469f, 0.35960504f, 0.56885153f, 0.24857217f, 
    -0.12319602f, -0.46474880f, -0.13475505f, 0.12124407f, -0.17531052f, -0.20728588f, -0.38744625f, 0.40285438f, 
    -0.38668296f, -0.30670920f, 0.18807301f, 0.13807675f, 0.23676237f, 0.18975948f, -0.49418852f, -0.02532759f, 
    0.22923051f, -0.13801067f, -0.67668879f, 0.64280844f, 0.61494005f, -0.75418872f, -0.94973969f, -0.45550194f, 
    0.25789803f, 0.38091344f, 0.42803138f, 0.19017692f, 0.21529759f, -0.19447070f, 0.18303874f, -0.42636636f, 
    -0.18961018f, -0.10839676f, -0.21447860f, -0.12268043f, 0.05343760f, 0.14365965f, -0.07929201f, 0.09809829f, 
    0.06063595f, -0.08149110f, 0.49063730f, 0.92090601f, 0.18504651f, -0.08261123f, -0.45889777f, -0.57579547f, 
    0.12125791f, 0.33964521f, 0.55422866f, -0.45429337f, -0.44390896f, -0.02481293f, -0.14628875f, -0.03834644f, 
    -0.22369175f, 0.07152271f, 0.07734201f, -0.09130839f, 0.28698114f, -0.11209257f, 0.10053252f, -0.00623027f, 
    -0.26241508f, -0.20488104f, 0.30264875f, -0.02487424f, 0.03113845f, 0.77772260f, 0.05031024f, -0.48911908f, 
    -0.37183243f, -0.34811783f, -0.20037080f, -0.32696423f, 0.04882912f, 0.41563046f, 0.03332941f, -0.15564877f, 
    -0.12587512f, -0.12031142f, 0.09731165f, -0.15758905f, 0.19404273f, -0.01846780f, -0.13934833f, -0.35478371f, 
    -0.27693588f, -0.38106829f, -0.48936230f, -0.54070020f, -0.60996187f, -0.74194366f, 0.38094205f, 0.52364987f, 
    0.31635410f, 0.18586875f, -0.44766662f, -0.53305918f, 0.22746107f, -0.37111560f, -0.31314462f, 0.05561314f, 
    -0.00015344f, 0.08936283f, 0.07273107f, 0.09515179f, -0.21824042f, -0.08079930f, -0.07085726f, -0.19930197f, 
    -0.14374687f, -0.22687960f, -0.11854805f, -0.13299118f, -0.00400602f, -0.10127408f, -0.01887886f, 0.19804424f, 
    0.40960634f, -0.69939303f, -0.88485402f, 0.18262979f, 0.47534955f, -0.39092931f, -0.26768038f, 0.21094081f, 
    0.11001714f, 0.03962384f, 0.18968262f, -0.14069280f, 0.33553568f, 0.15681528f, -0.10766126f, 0.10113285f, 
    -0.00282076f, 0.04756020f, 0.17140742f, 0.04292435f, 0.10990296f, -0.35558388f, 0.11379958f, 0.49463886f, 
    1.01092827f, 0.58543485f, -0.52210134f, 0.16402596f, -0.30297086f, -0.39748976f, -0.12581931f, -0.17751297f, 
    -0.44136524f, -0.01327597f, 0.09474007f, -0.09018522f, 0.03303752f, -0.07581878f, 0.06202842f, -0.12166957f, 
    0.19849101f, 0.31154776f, -0.12147202f, -0.17372890f, 0.24557246f, -0.05356616f, -0.01782640f, 0.02178440f, 
    -0.82561630f, -0.34229112f, -0.02901085f, -0.29555914f, -0.56921762f, 0.41682011f, 0.04088276f, -0.20614499f, 
    0.08977363f, 0.49052924f, 0.20761536f, -0.12615293f, 0.05041914f, -0.26936606f, -0.21763599f, -0.15580986f, 
    0.09013326f, -0.22652984f, -0.12062274f, 0.05860072f, -0.10773372f, -0.32247701f, -0.33383465f, -0.47357318f, 
    -0.36842752f, 0.07131974f, 0.02066372f, 0.15714405f, 0.02097390f, 0.03750744f, -0.02754432f, 0.20678408f, 
    0.39010268f, -0.27802551f, -0.02683649f, 0.12649626f, 0.24017659f, -0.16703747f, -0.05998481f, 0.07993622f, 
    0.07392101f, 0.37603292f, -0.00767595f, 0.13746262f, -0.35403737f, 0.12638937f, -0.06711046f, -0.27593803f, 
    -0.09524630f, 0.26626110f, -0.14031282f, -0.01777468f, 0.17698862f, 0.02635176f, 0.18679260f, -0.05304763f, 
    -0.06380013f, 0.13008216f, 0.17509644f, -0.29115471f, -0.13460934f, 0.11265200f, -0.11116412f, 0.34577334f, 
    -0.38415557f, 0.15130246f, 0.16330384f, 0.01328846f, 0.03524348f, -0.13720177f, -0.06423981f, -0.10116457f, 
    -0.32138175f, -0.06543725f, 0.33807996f, 0.26286334f, -0.31542706f, -0.13409036f, 0.31672007f, -0.30535936f, 
    -0.47727972f, -0.70199901f, -0.06099265f, 0.27543449f, -0.26639575f, 0.45347700f, -0.04234337f, 0.36212739f, 
    0.50860178f, -0.00291090f, -0.02121869f, -0.10623419f, 0.14518727f, -0.37558520f, -0.27874520f, -0.06932050f, 
    0.10019642f, 0.08483478f, -0.09842479f, -0.18136494f, 0.31824800f, -0.34592369f, -0.36831799f, 0.08124760f, 
    0.56271201f, 0.08755243f, 0.08985619f, -0.31511778f, -0.32928136f, 0.04469384f, -0.11434667f, 0.06510753f, 
    -0.11623985f, -0.32741946f, -0.18806329f, 0.12951428f, 0.52251256f, 0.23940140f, -0.14786084f, -0.13538183f, 
    0.20925893f, -0.08187604f, -0.23421220f, -0.17517476f, -0.45394316f, 0.50283176f, 0.17912425f, 0.08540234f, 
    -0.29484463f, 0.11224923f, -0.13984670f, 0.18085313f, 0.28819364f, -0.15739605f, -0.38030145f, -0.25999108f, 
    -0.20341213f, 0.02345797f, -0.06321499f, -0.08606904f, 0.00075195f, -0.01837663f, -0.05642393f, -0.05057639f, 
    -0.08623405f, 0.19200768f, -0.29259634f, -0.49436277f, -0.38709474f, -0.33013710f, -0.57377100f, -0.09515174f, 
    -0.00931091f, 0.23951794f, 0.26669741f, 0.04963425f, 0.16581245f, -0.20112899f, 0.26763824f, -0.17544150f, 
    -0.24455734f, 0.18420283f, -0.30619252f, 0.40319821f, -0.27296054f, 0.13472933f, -0.02546736f, -0.24824023f, 
    0.08193908f, -0.04025939f, 0.21311601f, -0.04311031f, -0.13441858f, 0.01570698f, 0.11025713f, -0.37938771f, 
    -0.00166559f, 0.33625001f, -0.11937009f, 0.23310083f, 0.23741983f, 0.38061714f, -0.33344820f, -0.04498305f, 
    -0.01034742f, 0.14342466f, 0.38616928f, 0.03946015f, -0.48409116f, 0.08263142f, -0.31442514f, 0.12709056f, 
    -0.04485068f, -0.21984635f, 0.03063067f, 0.00286620f, 0.31774467f, -0.22745624f, -0.08991706f, 0.20959981f, 
    0.16927336f, -0.76545835f, -0.88632441f, -0.22730307f, -0.02575980f, -0.34291953f, -0.41969502f, -0.20880856f, 
    -0.60882455f, -0.49224758f, -0.33835480f, -0.57645869f, -0.02778200f, 0.18651360f, -0.01072432f, -0.12379075f, 
    -0.30644330f, -0.07965396f, -0.11538807f, -0.11131879f, -0.11207029f, -0.15481248f, 0.04085161f, -0.15814659f, 
    -0.33878601f, -0.76936275f, -0.14367953f, -0.33675650f, -0.24208191f, 0.05164015f, 0.35041955f, 0.26303536f, 
    0.25382611f, 0.26117456f, 0.42550033f, 0.08118903f, -0.09307182f, 0.04825650f, -0.08435480f, -0.10528234f, 
    -0.18627508f, 0.05181189f, 0.09349016f, -0.33289388f, 0.21827051f, -0.07493877f, -0.08583055f, 0.24020416f, 
    0.08897869f, -0.16413087f, 0.43862185f, 0.00012004f, -0.24624230f, -0.34141722f, -0.67999983f, -0.70169163f, 
    -0.32033291f, -0.27382827f, -0.61994326f, -1.03881979f, 0.08762597f, 0.15646520f, 0.26723602f, -0.07321788f, 
    0.18257314f, 0.15148821f, 0.09080431f, 0.09601296f, -0.05343724f, -0.04385031f, -0.13534763f, -0.19061384f, 
    -0.03068126f, -0.22815673f, 0.48018411f, -0.68402308f, -0.25604898f, 0.27018923f, 0.17000702f, -0.41116089f, 
    0.21847808f, -0.01917375f, 0.14963956f, 0.05215069f, 0.31297550f, -0.20538704f, 0.05839435f, 0.23243216f, 
    -0.05859582f, -0.14908451f, 0.17015788f, -0.22765990f, -0.38613018f, -0.19489090f, -0.01557315f, -0.03829531f, 
    0.11510956f, 0.20958197f, 0.26670051f, 0.26731321f, -0.85375917f, -0.22056527f, -0.61015761f, -1.02311397f, 
    -0.84489977f, 0.51187581f, 0.17828619f, -0.10319940f, 0.18030058f, 0.19903328f, 0.09341920f, 0.39055371f, 
    -0.00369609f, -0.11205570f, -0.10408645f, -0.47304264f, -0.22106384f, -0.11581004f, -0.42335424f, 0.01239301f, 
    -0.13401866f, 0.16834243f, -0.22213544f, 0.03267783f, 0.29455721f, -0.59172970f, -0.09299410f, -0.43808511f, 
    -0.33864075f, 0.38314760f, 0.27815399f, 0.15389077f, 0.14083654f, 0.31939837f, 0.18002543f, -0.23712526f, 
    -0.05562337f, -0.06449897f, 0.30084687f, -0.44385245f, -0.10976248f, 0.09129089f, -0.28984940f, 0.47445089f, 
    -0.11179785f, -0.07148942f, 0.14267033f, 0.04409762f, 0.06765749f, -0.17736304f, 0.97920853f, -0.83898580f, 
    -0.81956798f, -0.07857293f, -0.09784054f, 0.41917613f, 0.55450165f, 0.33628836f, -0.04582800f, 0.18044266f, 
    -0.22419278f, -0.13443732f, -0.33406815f, -0.13604863f, 0.02729039f, 0.18060192f, 0.15682773f, 0.26027599f, 
    -0.04126423f, -0.23704596f, 0.18332984f, -0.06661474f, -0.06990425f, -0.17424759f, 0.22291441f, -0.25254193f, 
    0.53170437f, -0.16032284f, 0.33922371f, -0.31570902f, -0.74598432f, -0.27192837f, 0.05919181f, 0.24140273f, 
    0.34801573f, -0.10196480f, 0.01908229f, -0.39399150f, 0.27686784f, -0.02806105f, -0.08464674f, -0.10278631f, 
    0.00902652f, -0.11954942f, 0.18659545f, 0.04282967f, -0.18149999f, -0.16364369f, -0.11234692f, 0.08686826f, 
    0.38143125f, 0.29386994f, 0.19369943f, 0.08868876f, -0.51866329f, 0.11369448f, 0.05174704f, 0.19814779f, 
    0.14568801f, 0.16567628f, -0.29907498f, 0.20398164f, -0.29312816f, -0.22205372f, -0.25351286f, 0.42362729f, 
    -0.18879573f, -0.20938779f, -0.21692972f, 0.03954026f, -0.45018718f, 0.14617060f, 0.21784908f, 0.05786315f, 
    -0.12611927f, -0.66158301f, -0.69817901f, 0.15536653f, 0.04259022f, -0.11236373f, -0.44552776f, -0.34510776f, 
    -0.48408857f, -0.57364476f, -0.19863179f, 0.00946143f, -0.34295690f, -0.11107148f, -0.38007274f, -0.47660983f, 
    -0.30211350f, -0.24837549f, -0.28061336f, -0.15083702f, -0.32980189f, 0.05866753f, -0.18056357f, -0.18071860f, 
    0.11749703f, 0.14238343f, 0.47513822f, 0.00239738f, 0.01279030f, 0.39296579f, -0.37508765f, 0.21273173f, 
    0.36965793f, -0.24835894f, -0.49300212f, -0.29137003f, -0.06644639f, -0.05151336f, -0.06619476f, -0.09762295f, 
    0.30057406f, -0.10524657f, 0.03633370f, 0.00627792f, -0.10244891f, 0.02898355f, -0.26917213f, -0.01191832f, 
    0.11836038f, 0.06080968f, -0.10849383f, -0.36490756f, -0.58500379f, -0.47727677f, -0.30278888f, -0.16660164f, 
    -0.43573865f, -0.45559159f, -0.46432984f, -0.42416289f, -0.75364733f, 0.59138101f, -0.01524895f, -0.03777513f, 
    0.07285345f, -0.14825553f, -0.16470471f, -0.25040483f, -0.14484616f, -0.25385752f, -0.05903793f, -0.46981207f, 
    -0.23960119f, 0.24669316f, 0.19240986f, -0.02608005f, -1.08194351f, -0.73299491f, -0.36516333f, -0.58421338f, 
    -0.65132731f, 0.81220925f, 0.23469628f, -0.60594231f, -0.37199345f, 0.58645988f, -0.20730998f, -0.24417108f, 
    -0.15872553f, 0.00079206f, -0.16878000f, 0.07375902f, 0.04926626f, -0.01594764f, 0.00124392f, -0.18896723f, 
    -0.14049052f, -0.19189739f, -0.01281469f, -0.18621306f, 0.11525055f, 0.10953652f, -0.77179414f, -0.30831346f, 
    -0.26610351f, 0.22398555f, -0.37365577f, -0.12232122f, -0.01570616f, 0.27726761f, -0.08196212f, 0.20481302f, 
    -0.16336805f, -0.45594069f, -0.39112958f, -0.02029206f, -0.28517950f, -0.26316816f, -0.33134475f, -0.10435823f, 
    -0.33376172f, 0.15356012f, 0.21766780f, 0.17248020f, -0.45303524f, 0.05487440f, -0.24439386f, 0.03005598f, 
    0.00925624f, 0.42753348f, -0.23584312f, -0.21305488f, -0.34078476f, -0.17515498f, 0.10611835f, 0.37778512f, 
    0.28574792f, -0.08278228f, 0.37561744f, -0.44905663f, 0.17620121f, -0.24884035f, -0.04578751f, 0.37859264f, 
    -0.33398169f, -0.42254657f, -0.09671261f, 0.04024659f, 0.22356449f, 0.19740991f, 0.30165222f, -0.46918222f, 
    -0.03667543f, -0.50988054f, -0.30662391f, -0.06582016f, -0.10601924f, -0.29710272f, -0.17633741f, -0.44409677f, 
    -0.23208132f, -0.16008243f, -0.14116892f, -0.14288875f, 0.01788980f, 0.07840250f, 0.14167096f, -0.11573342f, 
    -0.19560221f, 0.02273364f, -0.37275746f, 0.11889909f, 0.41544417f, 0.35722196f, 0.26291355f, 0.33769646f, 
    0.43135872f, 0.62014222f, -0.04743364f, -0.34414825f, -0.44918498f, -0.16067211f, -0.24772188f, -0.24868083f, 
    -0.13263254f, 0.03102986f, 0.34909636f, 0.09170691f, 0.16798617f, 0.03658863f, 0.29578570f, -0.37602457f, 
    -0.20143020f, 0.26102141f, -0.19339465f, -0.07237180f, 0.23989548f, -0.01029189f, -0.20250931f, -0.25815561f, 
    0.08420021f, -0.20071416f, -0.62141567f, 0.21667741f, 0.26224047f, 0.50011963f, -0.40308949f, -0.22779773f, 
    -0.26683623f, -0.18752918f, 0.59056330f, -0.24429074f, 0.37683609f, 0.01805630f, 0.15143079f, -0.12939526f, 
    0.19492619f, 0.16747460f, -0.14218892f, -0.10270822f, -0.16523832f, 0.22546788f, 0.01676977f, 0.04502612f, 
    -0.16816488f, -0.02152800f, -1.15004575f, 0.33027929f, 0.55193037f, 0.17641965f, 0.05361400f, -0.47608644f, 
    0.07819372f, 0.02679753f, 0.29170391f, -0.04298821f, 0.15396756f, -0.08710290f, 0.11435369f, 0.27188250f, 
    -0.28724125f, -0.11505949f, 0.28446805f, -0.13158534f, -0.18743798f, -0.10092205f, -0.09595939f, -0.15423699f, 
    0.10311374f, 0.12073804f, -0.25338793f, -0.21365505f, -0.03150238f, -0.06525202f, 0.01905095f, 0.01083093f, 
    0.17209210f, 0.49537876f, 0.13312368f, 0.23561341f, -0.11213148f, -0.15761063f, -0.02783299f, 0.27345958f, 
    -0.36732849f, -0.11782741f, -0.28972641f, -0.02657896f, -0.02279521f, 0.18326096f, 0.06062141f, -0.16689093f, 
    0.02166437f, 0.05602409f, 0.08157935f, 0.24124767f, 0.38846242f, 0.15874365f, 0.06880298f, 0.14848824f, 
    -0.39963481f, 0.30917072f, 0.43565306f, 0.07811245f, -0.38793716f, -0.24194787f, 0.03429631f, -0.12380362f, 
    0.53514427f, -0.25775665f, -0.37965405f, -0.07209104f, -0.09343245f, 0.12892392f, -0.22379065f, -0.26358226f, 
    0.28500977f, 0.13404845f, 0.12260538f, -0.21445464f, -0.04411634f, 0.23100060f, 0.22167008f, 0.36404938f, 
    0.36459762f, 0.02249892f, 0.07564592f, 0.01941762f, 0.00441099f, 0.06315039f, -0.12897462f, -0.00237993f, 
    0.02752012f, -0.03455484f, 0.16078152f, -0.23480435f, -0.15662406f, 0.01489053f, -0.16721292f, -0.14331037f, 
    -0.00416841f, -0.00179749f, -0.28754011f, -0.41493693f, -0.17767526f, -0.15658790f, -0.68229556f, 0.26211372f, 
    -0.27434602f, 0.07634285f, -0.40096468f, -0.03100345f, -0.14711143f, -0.11297984f, 0.42397180f, 0.05643821f, 
    0.19309786f, 0.08940984f, 0.18288492f, 0.38399610f, -0.32559377f, -0.24892774f, 0.03375095f, -0.20946538f, 
    -0.25169715f, 0.35532057f, 0.13334510f, 0.23655766f, 0.09330169f, 0.19182532f, -0.09286679f, 0.75424325f, 
    0.56486785f, 0.32921413f, -0.15590361f, 0.31881040f, -0.52687520f, -0.51317894f, -0.09519303f, -0.17007175f, 
    -0.24551032f, -0.08765011f, 0.06355392f, 0.00455170f, -0.20034130f, 0.01554997f, -0.24057057f, 0.03172666f, 
    0.05919452f, 0.09902484f, 0.14650984f, -0.23306514f, 0.16906747f, -0.01601988f, 0.07606620f, -0.11295352f, 
    -0.10979134f, -0.56430054f, -0.58848852f, 0.16654138f, 0.05244582f, -0.11314027f, 0.10404740f, 0.21094885f, 
    0.48205584f, 0.20342073f, -0.04941251f, 0.01834657f, -0.39000821f, -0.25981140f, -0.06561732f, -0.16705951f, 
    0.29639897f, -0.12649657f, 0.15347143f, -0.10695651f, 0.00755948f, -0.35438830f, -0.25745979f, -0.23054343f, 
    -0.23106390f, -0.70062554f, -0.12880450f, -0.07786453f, 0.68336183f, -0.23287532f, 0.69602978f, -1.05831456f, 
    -0.14744124f, 0.55803382f, 0.13877152f, 0.06269244f, -0.16898453f, -0.32079884f, -0.10981752f, -0.15168363f, 
    -0.02554392f, -0.07757835f, -0.09905412f, -0.04257519f, 0.02170084f, 0.18102387f, -0.20190176f, 0.10975929f, 
    -0.32712707f, 0.38528854f, -0.37291035f, -0.17529126f, -0.24118207f, 0.43610922f, 0.24759564f, -0.04010547f, 
    -0.34044826f, 0.00374266f, -0.17938615f, 0.30837768f, 0.01531829f, 0.42127198f, 0.00276581f, 0.04277318f, 
    -0.20361598f, -0.26901978f, 0.17183222f, 0.18634559f, -0.13381156f, -0.35930032f, 0.14322290f, 0.34818557f, 
    0.09746717f, 0.04412847f, -0.13384120f, 0.59783900f, -0.37787697f, -0.30614933f, -0.22332810f, -0.69796503f, 
    0.15436423f, -0.04103069f, -0.53856820f, -0.51805234f, -0.54101348f, -0.17745440f, -0.01845413f, -0.16163960f, 
    0.38234335f, 0.08110045f, 0.22649428f, -0.18955427f, -0.18185917f, -0.05186702f, -0.14047258f, -0.36677316f, 
    -0.27092493f, -0.29182133f, -0.08646271f, -0.28903735f, -0.98050010f, -0.14341228f, 0.45718035f, 0.30656880f, 
    0.30708322f, -0.23691803f, -0.01794495f, -0.61700815f, 0.39838368f, 0.40275174f, -0.44210026f, 0.04257825f, 
    -0.42201164f, 0.03262293f, 0.01646979f, 0.16933478f, 0.09924403f, 0.18257114f, -0.05746057f, -0.28500193f, 
    0.17520268f, -0.09749442f, 0.06247643f, 0.05835016f, -0.06432004f, 0.29108083f, 0.08590003f, 0.00160795f, 
    0.26899776f, 0.09020515f, -0.28578818f, -0.08515204f, 0.03704749f, -0.01404617f, -0.19706616f, -0.30538559f, 
    -0.10039758f, -0.21213643f, 0.30414146f, 0.18750954f, -0.13616161f, 0.17742291f, 0.29549679f, -0.02286181f, 
    -0.30465862f, -0.11890453f, 0.14825825f, -0.04943452f, -0.30863389f, -0.21456224f, -1.20812416f, -0.57290232f, 
    -0.34814224f, 0.28770965f, -0.11420547f, 0.53926462f, 0.56003702f, 0.15800346f, -0.02859108f, -0.04299790f, 
    -0.12870352f, 0.20710094f, -0.23849414f, 0.39081240f, 0.11195297f, 0.15288936f, 0.09360287f, -0.27242333f, 
    -0.18053037f, -0.00618640f, 0.10827050f, -0.18360256f, 0.17067641f, 0.14422303f, -0.01932810f, -1.16415393f, 
    -0.38760710f, -0.40290967f, -0.02058579f, -0.09802700f, 0.26280010f, 0.06550564f, 0.48876938f, 0.43889198f, 
    -0.06545112f, 0.20815583f, 0.19044016f, -0.15741080f, 0.12784621f, -0.10255817f, -0.19186348f, -0.03660277f, 
    -0.11907035f, -0.29389367f, -0.17330600f, -0.01057219f, 0.37969214f, 0.49389726f, -0.04311292f, -0.20680864f, 
    -0.11773386f, 0.17458376f, -0.14255033f, -0.02424445f, 0.29338279f, -0.30234790f, -0.34947360f, 0.19796938f, 
    0.40505481f, -0.02185829f, 0.11208034f, -0.24522546f, 0.12026970f, 0.12192432f, 0.00660804f, 0.03965395f, 
    -0.09504738f, -0.16546278f, -0.05153235f, 0.09216124f, -0.34288135f, 0.25395331f, 0.02474783f, 0.16976117f, 
    -0.21536887f, -0.14125766f, 0.40954417f, 0.30306321f, -0.39050880f, -0.18632966f, 0.32384837f, 0.21911299f, 
    0.03196652f, 0.04185186f, -0.43801123f, 0.08097562f, 0.04556850f, -0.07610100f, -0.21349765f, 0.15110604f, 
    0.05190626f, -0.05206925f, -0.00217674f, 0.08863088f, -0.14512160f, -0.01192209f, 0.18332668f, 0.44605663f, 
    -0.42560789f, -0.31955972f, 0.45682430f, 0.11989768f, -0.30926824f, -0.47536111f, -0.14884543f, -0.35920557f, 
    -0.02547721f, 0.02069944f, 0.48128361f, 0.34426361f, -0.11476269f, 0.38769737f, -0.38847420f, -0.01354241f, 
    -0.23088841f, 0.19688073f, -0.18417440f, 0.01545147f, 0.00038464f, 0.08881530f, -0.19053246f, 0.07733693f, 
    0.10065917f, -0.03931689f, 0.22908078f, -0.33685374f, -0.23622911f, -0.48202062f, 0.10471965f, 0.02328929f, 
    -0.45631137f, -0.64590073f, 0.01815108f, 0.57858390f, -0.17996533f, 0.03205046f, 0.11132769f, 0.09928127f, 
    0.16512412f, 0.35892537f, 0.30553937f, -0.12260284f, -0.29765308f, -0.08507252f, -0.37360492f, -0.25961357f, 
    0.27533740f, -0.18369906f, -0.01880822f, 0.13198805f, 0.26274887f, -0.44277430f, -0.62696093f, 0.53479844f, 
    0.41998658f, 0.26472974f, 1.07400501f, -0.90719652f, -0.80815202f, -0.22616026f, -0.12456497f, -0.18935522f, 
    -0.18900779f, -0.19265231f, 0.18002716f, -0.05587608f, -0.51340914f, 0.06544565f, 0.31980506f, -0.16934194f, 
    -0.04278816f, 0.01709475f, 0.01336981f, -0.10823294f, -0.13406859f, -0.57141888f, -0.03129882f, -0.48523957f, 
    -0.61063665f, -0.11537472f, 0.31108087f, 0.36115941f, 0.29220596f, 0.06775839f, -0.10943405f, -0.22520021f, 
    -0.21499017f, -0.31668681f, 0.16755646f, -0.01710287f, 0.10474428f, -0.08440789f, -0.20961706f, 0.05991938f, 
    -0.32334375f, -0.37181121f, 0.09087466f, -0.17583290f, -0.42325899f, -0.53446317f, 1.01406443f, -0.66301179f, 
    -0.91855103f, 0.13292018f, 0.25075826f, 0.34336805f, 0.46973318f, 0.16941753f, 0.02946593f, -0.32760775f, 
    -0.23508814f, -0.12779757f, -0.22135220f, -0.06795613f, 0.06100136f, -0.11675823f, 0.09886260f, 0.06251906f, 
    0.14581876f, -0.11337864f, 0.26259634f, -0.03934002f, -0.12851542f, -0.16928518f, 0.14872423f, -0.66748470f, 
    -0.03939211f, 0.50053537f, 0.31964898f, -0.13510375f, 0.51432258f, -0.52389222f, 0.10221089f, -0.04826749f, 
    -0.22066377f, 0.31681553f, -0.16600488f, -0.07731468f, 0.26205179f, -0.23534457f, -0.22326030f, -0.39979222f, 
    0.01312566f, 0.19039333f, 0.38680342f, 0.06504433f, -0.08435845f, 0.19590762f, -0.05087152f, -0.35183504f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.15089308f, 0.05158950f, 0.22542880f, 0.10868142f, 0.05519762f, -0.13341570f, 0.29439855f, 0.04279655f, 
    0.06869586f, 0.09452090f, 0.14256267f, 0.22873692f, -0.18775602f, -0.12640755f, 0.13367330f, 0.26690868f, 
    -0.06793677f, -0.07404809f, 0.29018474f, 0.13422100f, 0.23852554f, -0.10328379f, 0.28690973f, 0.17952617f, 
    -0.46098360f, 0.05725919f, -0.20174664f, -0.02955822f, 0.30310899f, 0.18785912f, 0.03681674f, 0.32409307f, 
    0.39265782f, 0.04635829f, 0.13544683f, -0.27189469f, -0.12194765f, 0.21095468f, 0.15001370f, -0.03941024f, 
    -0.07522448f, 0.13227674f, 0.07712727f, -0.09183301f, 0.32065961f, -0.13742831f, 0.17907776f, 0.20007612f, 
    -0.05739937f, 0.08633608f, 0.03422571f, -0.24631688f, -0.00697687f, -0.00470031f, -0.00802605f, 0.18630354f, 
    0.33572415f, 0.30172199f, 0.01738569f, 0.07853675f, 0.20553561f, -0.14847958f, 0.18138537f, 0.13089821f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.35744575f, -0.36078876f, -0.10133719f, 0.00573877f, 0.04487555f, 0.05817924f, 0.07162154f, 0.08330131f, 
    0.02645265f, -0.00734222f, 0.02253208f, 0.08497791f, 0.02843075f, 0.28274873f, 0.06145162f, -0.20103477f, 
    -0.06619174f, 0.10429123f, 0.02838129f, -0.03573396f, -0.02545029f, 0.02199976f, -0.02821060f, -0.01813650f, 
    0.20534261f, 0.02624559f, -0.04094335f, -0.28001413f, -0.02826311f, 0.05666170f, -0.09301412f, -0.19098526f, 
    -0.08563704f, -0.22613981f, 0.00689861f, 0.06998175f, 0.08710935f, -0.08725268f, -0.00140645f, -0.01870627f, 
    0.10190021f, -0.08138723f, 0.00461967f, -0.01468674f, 0.04519221f, 0.01330954f, -0.03404986f, -0.11473992f, 
    -0.02173822f, 0.26827893f, 0.29267865f, -0.26376978f, 0.12944390f, -0.00018021f, 0.00804955f, -0.11966629f, 
    0.01860559f, -0.06169970f, -0.10832162f, -0.07019254f, 0.01180820f, 0.05290210f, -0.05841139f, 0.01639163f, 
    -0.12734172f, -0.06703715f, 0.02409567f, 0.06726116f, -0.03443678f, 0.05375959f, -0.00289375f, -0.01690024f, 
    0.19338544f, 0.02488749f, 0.05352298f, -0.02971020f, 0.04474372f, -0.01650277f, 0.07366002f, -0.22073932f, 
    -0.18387020f, 0.07588989f, 0.05436967f, 0.01544413f, 0.13592258f, 0.11479941f, -0.19982766f, 0.05958943f, 
    0.08720458f, -0.15591820f, -0.24662800f, -0.07091800f, 0.01879445f, 0.01877541f, -0.07800353f, -0.06421626f, 
    0.32359904f, 0.25165874f, -0.13349873f, -0.35180140f, 0.04891154f, -0.10350952f, 0.04091672f, 0.15638347f, 
    0.05152998f, 0.03022704f, 0.00572836f, -0.04674806f, 0.42801523f, 0.04873108f, -0.16732830f, -0.35967094f, 
    -0.09662098f, -0.11869130f, 0.03313622f, -0.17066668f, -0.15285680f, -0.01839861f, 0.00203672f, 0.09119013f, 
    -0.15030253f, -0.26378125f, 0.33515504f, -0.03285367f, -0.04171764f, -0.10214833f, -0.00099235f, 0.01909124f, 
    0.06016893f, -0.10490903f, -0.01526769f, -0.36692989f, -0.17782825f, -0.66314721f, -0.23689869f, 0.03893004f, 
    0.01317813f, 0.02675109f, -0.17692477f, -0.23767516f, 0.02270673f, 0.01468294f, 0.01628970f, -0.09367657f, 
    -0.25085470f, 0.08804973f, 0.02002857f, 0.04735522f, -0.00444940f, 0.04172677f, -0.02940804f, 0.02352956f, 
    -0.11085802f, -0.05057586f, 0.11869229f, 0.05533804f, -0.06995051f, 0.04773800f, 0.24829610f, -0.02676152f, 
    -0.16705632f, -0.16615066f, 0.00326174f, 0.01793938f, 0.03111098f, 0.03304963f, -0.00358632f, 0.02885935f, 
    0.23515619f, -0.07040284f, -0.13566597f, 0.01323398f, -0.01012879f, 0.02625072f, -0.16753845f, -0.21458894f, 
    -0.08336280f, -0.05560031f, 0.05936768f, 0.00854768f, -0.17518629f, 0.08521043f, -0.26407257f, 0.07319451f, 
    0.01793635f, -0.03965828f, -0.12180309f, -0.02462523f, 0.02278447f, 0.08206125f, 0.01454808f, 0.05382767f, 
    0.17610548f, 0.18295026f, -0.09714383f, -0.13028954f, 0.06578813f, 0.10095026f, 0.00508795f, -0.04376234f, 
    0.10246426f, 0.07515033f, 0.05924716f, 0.05202229f, -0.02304824f, 0.01534334f, -0.00090498f, 0.06507220f, 
    -0.02926128f, 0.01930832f, -0.04336659f, -0.00425031f, -0.30656388f, -0.18010741f, -0.11017676f, -0.00742320f, 
    -0.07480243f, -0.03897290f, -0.03685102f, 0.02880660f, -0.17188050f, -0.04617407f, 0.03379254f, 0.03170642f, 
    -0.07143456f, -0.11113677f, -0.10104552f, -0.04209191f, 0.25717270f, 0.15695186f, 0.10244902f, -0.33640966f, 
    -0.08695673f, -0.06608853f, -0.01209028f, -0.01444398f, 0.07342707f, -0.00194968f, -0.12057488f, -0.02794912f, 
    0.04397331f, -0.03216315f, -0.20288885f, 0.15534900f, -0.03010580f, -0.06837057f, -0.01359777f, -0.06345253f, 
    -0.04296188f, 0.07511536f, 0.01585808f, -0.05111822f, -0.37959096f, -0.50352687f, -0.11420307f, 0.31163150f, 
    -0.00285255f, 0.01988250f, 0.01079283f, -0.02206806f, 0.06156135f, 0.00844648f, -0.01017754f, -0.04659093f, 
    -0.00588043f, 0.00670253f, -0.02598736f, -0.14774890f, -0.02553242f, 0.00048861f, 0.05846822f, 0.04224767f, 
    -0.03737615f, -0.01457830f, -0.06219853f, -0.12246983f, -0.15151690f, 0.01129761f, 0.09545074f, -0.07949072f, 
    -0.01746368f, -0.00619673f, 0.01996285f, -0.02283125f, -0.12818311f, 0.00062949f, -0.08000588f, -0.25693575f, 
    0.36190164f, 0.10685632f, 0.02183192f, -0.12490292f, 0.17037843f, 0.08907554f, 0.06897999f, 0.05888593f, 
    -0.06667273f, -0.00305089f, 0.00482237f, -0.03145882f, 0.10030044f, -0.12824957f, 0.00018034f, 0.01172586f, 
    0.06377330f, 0.12148320f, 0.08617964f, 0.04073296f, 0.05927790f, 0.06438934f, -0.01805039f, -0.21935022f, 
    0.34914154f, 0.00706279f, -0.10711998f, -0.12809944f, 0.03947409f, -0.04929949f, 0.07045944f, 0.12126675f, 
    0.02281817f, 0.08701678f, 0.01110623f, 0.03514680f, -0.02255604f, -0.07235511f, 0.18090056f, -0.10456601f, 
    -0.02426007f, -0.12127183f, 0.07418212f, 0.06035192f, -0.06203829f, -0.11180831f, -0.06819747f, -0.05206961f, 
    0.21945645f, 0.00298093f, -0.03783975f, -0.09863006f, 0.07526991f, 0.14353676f, -0.06791289f, -0.14213336f, 
    -0.08037243f, -0.10881793f, -0.06006090f, -0.07723558f, 0.08591861f, -0.08722057f, -0.13246070f, 0.08704777f, 
    0.02910585f, 0.11282384f, 0.07104619f, -0.04257992f, 0.06986786f, 0.03784541f, -0.15658611f, -0.08756164f, 
    0.14044707f, -0.19048586f, -0.46119586f, 0.02418793f, 0.07412846f, 0.06663564f, 0.08804967f, -0.00657248f, 
    -0.06924035f, 0.09174412f, -0.13834018f, 0.04047038f, -0.33412883f, 0.14453712f, 0.18574095f, -0.24103983f, 
    -0.02328635f, 0.00892009f, -0.11307838f, -0.10971893f, 0.05534188f, -0.10229221f, -0.03850792f, 0.00151957f, 
    -0.55874842f, -0.49958456f, -0.25778338f, -0.23516946f, 0.02072621f, -0.00016455f, 0.04276995f, 0.02625224f, 
    -0.03895491f, -0.04571847f, -0.00959429f, -0.05238680f, 0.35163555f, 0.22156207f, -0.03860511f, -0.25733110f, 
    0.02742761f, -0.01112819f, 0.08672068f, 0.00381435f, -0.03809058f, -0.12476132f, -0.16321997f, -0.14196135f, 
    -0.01019484f, -0.32176811f, -0.04675519f, -0.00292378f, -0.04294994f, 0.03505975f, 0.02481747f, 0.01809465f, 
    -0.04239436f, -0.00124129f, 0.07106903f, 0.06603578f, 0.31218186f, 0.19657497f, -0.04274541f, -0.26382038f, 
    0.15672992f, 0.03693348f, 0.04548557f, 0.08151791f, -0.01737688f, -0.00003951f, -0.02868914f, -0.02403337f, 
    0.37282446f, 0.21044303f, -0.03751827f, -0.16309287f, 0.12089848f, 0.13532732f, 0.10739223f, 0.02751033f, 
    0.01598241f, 0.03562595f, 0.07344574f, 0.03298077f, 0.20806482f, -0.00637778f, -0.03165382f, -0.15863279f, 
    0.01849259f, 0.04179304f, 0.06612863f, -0.16397572f, -0.13026085f, -0.10213508f, -0.01435053f, 0.05557165f, 
    0.10052320f, 0.03702889f, 0.10122921f, -0.16390984f, 0.00403943f, 0.07880798f, -0.00003600f, -0.06930324f, 
    -0.07841954f, -0.18633457f, -0.08122960f, 0.00704309f, 0.18122402f, 0.17858958f, -0.07088613f, -0.18433830f, 
    0.01457693f, 0.10561462f, 0.02920244f, -0.12976240f, -0.06823279f, -0.03331644f, -0.02206151f, -0.00373052f, 
    0.17007664f, -0.07923559f, -0.29938060f, 0.02753890f, 0.01077581f, -0.01414195f, 0.06404492f, 0.04463652f, 
    -0.07178453f, 0.07360914f, 0.11154033f, -0.05242684f, -0.02952018f, 0.24949203f, 0.12885223f, -0.16220862f, 
    -0.02227540f, -0.03120753f, 0.02783220f, -0.25431007f, -0.04012371f, -0.03422259f, -0.04515642f, -0.06775422f, 
    -0.20088266f, -0.14496614f, 0.21241395f, -0.11788653f, -0.00306874f, -0.00917853f, 0.07891497f, 0.13425422f, 
    -0.00005135f, 0.00481970f, -0.18104589f, 0.01031510f, 0.03351048f, -0.00363057f, -0.01029195f, -0.02170471f, 
    0.03922445f, -0.04162230f, 0.04518915f, 0.03717123f, 0.07626230f, -0.00899474f, -0.03262461f, -0.09249652f, 
    -0.31333199f, -0.37386319f, -0.34607664f, 0.09169269f, 0.02360707f, 0.01009690f, 0.02427446f, 0.07089675f, 
    0.03812112f, -0.00485179f, -0.08933386f, 0.08399916f, -0.26099190f, -0.25548708f, -0.05134551f, 0.07841925f, 
    0.04730378f, 0.02473990f, 0.03218960f, 0.05281043f, 0.03153438f, 0.06557295f, 0.01563514f, 0.15432288f, 
    -0.00376102f, -0.00404190f, 0.08201243f, -0.05009305f, 0.01499959f, 0.01531763f, -0.09383813f, -0.04144048f, 
    -0.07750118f, -0.15938874f, 0.03602666f, -0.10725027f, -0.34351560f, 0.10085538f, -0.21758977f, -0.08694255f, 
    0.00228631f, -0.08752637f, -0.03419212f, 0.07255132f, 0.01395582f, 0.05756940f, 0.01982484f, 0.02981182f, 
    0.15759389f, 0.04389852f, 0.05310229f, 0.01444184f, 0.10508132f, 0.04254705f, 0.06735219f, -0.04797607f, 
    0.06032166f, 0.10823169f, 0.13285635f, 0.17764968f, 0.21686074f, 0.35623372f, 0.41752899f, -0.40508863f, 
    -0.15828174f, -0.05311862f, 0.01019458f, 0.02951997f, -0.04988451f, 0.11263134f, -0.09425817f, -0.12926395f, 
    -0.08654382f, 0.26798853f, 0.21430962f, -0.11556635f, -0.10605061f, 0.17906159f, -0.02037344f, -0.11060806f, 
    -0.03993320f, -0.12407209f, -0.03452227f, 0.02545929f, 0.17969614f, -0.05171434f, -0.10308012f, -0.15393057f, 
    -0.01898655f, -0.04480137f, 0.03347636f, -0.02747938f, -0.11190571f, -0.02533701f, -0.00319465f, 0.05709979f, 
    0.32455179f, 0.32188860f, 0.16074255f, -0.42504326f, -0.15534474f, -0.15114988f, 0.02937668f, 0.15053731f, 
    0.04424912f, 0.03576027f, -0.06847909f, 0.02805555f, -0.25804657f, -0.06604040f, 0.18880443f, -0.24190409f, 
    0.03241048f, -0.03640054f, 0.05328036f, -0.00969674f, 0.04297084f, -0.01895756f, 0.04496207f, -0.02125396f, 
    0.26088372f, -0.21323799f, -0.12904653f, -0.00806591f, 0.01085963f, 0.08628427f, 0.02679965f, 0.04575745f, 
    -0.14056210f, -0.08053312f, -0.06200586f, 0.08807730f, 0.04291423f, -0.22743736f, 0.02816150f, -0.15853988f, 
    0.08631308f, 0.13525978f, 0.00761917f, 0.00094699f, -0.23836963f, -0.16216362f, -0.22464824f, -0.01515412f, 
    -0.37214252f, 0.01365706f, 0.08468575f, -0.08128186f, -0.06370047f, -0.01690166f, -0.01196454f, 0.01730712f, 
    0.00372999f, -0.05776114f, -0.07691983f, -0.11067969f, -0.10590561f, -0.55724281f, -0.51302898f, -0.11786713f, 
    0.04216059f, -0.01087141f, -0.00055228f, 0.09825745f, -0.20015013f, -0.02851686f, -0.04942604f, 0.07489218f, 
    -0.04239881f, -0.04487725f, -0.09203663f, -0.07610760f, -0.12460188f, -0.00097432f, 0.00453452f, 0.00084961f, 
    -0.04913801f, -0.10095694f, -0.00106340f, -0.03534895f, 0.31935793f, 0.15757941f, 0.20862803f, -0.19750234f, 
    -0.15103357f, 0.04201214f, 0.02518580f, -0.31587619f, -0.01149437f, -0.04076172f, -0.09647848f, -0.01628860f, 
    0.30884019f, 0.04762015f, -0.15554285f, 0.06238990f, -0.15202364f, -0.23089555f, 0.17964427f, -0.14560787f, 
    -0.09243086f, -0.04940073f, 0.06948140f, 0.10597358f, 0.10766554f, -0.17829251f, -0.16124400f, -0.06287192f, 
    0.03458366f, 0.11036845f, -0.00974889f, -0.01639462f, -0.00780481f, 0.03121627f, 0.03303596f, 0.20060299f, 
    0.08017810f, -0.63338250f, -0.41616505f, -0.08020449f, -0.07325720f, -0.02390853f, 0.12933351f, 0.05258021f, 
    -0.05097169f, -0.01679721f, -0.14212169f, -0.04248779f, 0.14139616f, 0.01614572f, 0.08465745f, -0.38779372f, 
    -0.08731183f, -0.16357759f, -0.06784499f, 0.07175458f, -0.08297024f, 0.00506430f, -0.04565073f, -0.03976385f, 
    0.23029287f, 0.28639075f, 0.09647249f, 0.19051768f, 0.01289952f, -0.01364761f, -0.03550507f, 0.05531375f, 
    -0.00618265f, 0.00835319f, 0.05386065f, -0.04673790f, -0.21733794f, -0.06680132f, 0.05502952f, -0.34349203f, 
    0.09511705f, 0.04658874f, -0.14528093f, -0.08127508f, -0.04288745f, 0.02954075f, 0.01986475f, -0.04539525f, 
    -0.10311009f, 0.03858872f, -0.19998695f, 0.01549023f, -0.10867560f, 0.03068721f, -0.03000231f, 0.20488173f, 
    -0.03050287f, -0.00053280f, 0.07841508f, 0.05779092f, -0.06028664f, 0.01617447f, 0.02636877f, 0.02555721f, 
    0.12349395f, 0.10386880f, 0.08823423f, -0.18877394f, 0.05225573f, -0.06821238f, 0.03386803f, 0.11237074f, 
    -0.43340316f, 0.10557960f, 0.02097820f, -0.11269299f, -0.15069103f, 0.15103012f, 0.08971889f, 0.08485632f, 
    0.00843822f, -0.02404903f, 0.05671354f, 0.00678816f, 0.07926046f, -0.02065786f, 0.04062825f, 0.00983150f, 
    0.01408431f, 0.00500058f, 0.00189971f, -0.02690833f, -0.04355114f, 0.04562081f, -0.05471313f, 0.05435677f, 
    -0.17765990f, -0.31846970f, 0.02969007f, -0.16141596f, 0.04455591f, 0.10441987f, -0.05558563f, -0.10236454f, 
    0.33010715f, -0.01570472f, -0.04345738f, 0.05581627f, -0.06991759f, -0.04614278f, -0.16329060f, 0.11977310f, 
    -0.19826508f, 0.04564247f, 0.08076767f, 0.20631644f, 0.05485193f, 0.15477511f, -0.18856646f, 0.09727766f, 
    -0.17454487f, 0.16102394f, -0.11914816f, 0.00239422f, -0.09153552f, -0.16426501f, -0.06202645f, -0.15449685f, 
    -0.02847600f, -0.04997560f, 0.05879364f, 0.08577789f, 0.12822954f, -0.14379476f, 0.01873439f, -0.04030720f, 
    -0.06715654f, 0.01990664f, 0.07637521f, -0.00256909f, 0.31734496f, -0.03565432f, 0.06497840f, -0.04333570f, 
    0.02101460f, 0.10580511f, -0.05327983f, -0.52909219f, 0.04981570f, 0.24616845f, -0.00974399f, -0.11974722f, 
    0.01596111f, 0.20337109f, -0.15186702f, -0.01637516f, 0.79332638f, -0.16247493f, 0.11755091f, -0.07625026f, 
    -0.04589634f, -0.09125824f, 0.17948012f, -0.09847791f, 0.12313823f, 0.05896685f, -0.21507157f, 0.10210346f, 
    -0.13593763f, -0.03899918f, 0.15454325f, -0.19344240f, 0.07394599f, 0.06149587f, -0.08834169f, 0.01833039f, 
    -0.17409478f, -0.22421727f, -0.32990608f, -0.12458419f, -0.40405318f, -0.26312530f, -0.53417951f, -0.42121634f, 
    0.00954166f, -0.07504003f, -0.00033139f, 0.00369821f, -0.02147179f, 0.04263811f, -0.01958715f, -0.02271255f, 
    -0.01909833f, -0.09237730f, 0.00542759f, -0.16629836f, 0.01768687f, 0.15665472f, -0.20712797f, 0.11894099f, 
    -0.11528464f, 0.05440619f, 0.04891256f, -0.03277550f, 0.27270070f, -0.07555858f, 0.08029483f, -0.10572667f, 
    -0.08108359f, -0.17079027f, 0.00069368f, 0.03657952f, -0.02693069f, -0.06770322f, 0.04034471f, 0.02488160f, 
    0.18044209f, 0.09693068f, -0.07925193f, -0.05113784f, 0.01555769f, 0.01880251f, -0.05971823f, -0.06029246f, 
    -0.20172563f, -0.19404489f, -0.18548076f, -0.36492950f, 0.12931435f, 0.02073288f, 0.07994358f, 0.03083714f, 
    0.04201918f, 0.02960248f, 0.03227402f, -0.04471963f, 0.21481596f, 0.03049562f, -0.12035841f, -0.01703215f, 
    -0.04020809f, 0.02321309f, 0.08819044f, 0.03391658f, 0.05134604f, 0.06350104f, -0.00689392f, -0.07433031f, 
    0.20145597f, -0.11329397f, 0.00453516f, 0.01708111f, -0.38496864f, 0.03731081f, -0.09050868f, -0.27600780f, 
    -0.01385501f, 0.03105213f, 0.11930844f, 0.08860152f, 0.04688971f, 0.08894142f, 0.07975392f, 0.11858196f, 
    0.05551353f, -0.05840696f, -0.10447928f, 0.08821200f, 0.02073934f, -0.06987944f, 0.04847055f, 0.09970199f, 
    0.11943975f, -0.21244626f, -0.24989456f, 0.12555785f, 0.37393874f, 0.08188181f, 0.22654343f, 0.14879836f, 
    -0.01524984f, -0.04313367f, -0.04877230f, 0.03454732f, 0.00556517f, -0.01313025f, 0.10038726f, 0.06964149f, 
    -0.08539086f, -0.02017584f, 0.04236822f, 0.13513669f, -0.10501920f, 0.03726014f, 0.06750569f, 0.01555890f, 
    0.15640405f, -0.03321273f, -0.05976669f, 0.02967251f, 0.21060959f, 0.01526253f, -0.03345962f, 0.18405731f, 
    0.03188478f, -0.04781915f, 0.00321185f, -0.02337201f, 0.04625788f, 0.07232305f, -0.23376362f, 0.09916929f, 
    0.15477213f, 0.13000835f, 0.24797319f, 0.15571414f, -0.00458377f, -0.18904656f, 0.18569987f, -0.33711204f, 
    0.00378401f, -0.03341125f, 0.06754152f, -0.03082385f, 0.07572926f, 0.06566262f, 0.00369220f, -0.09569511f, 
    -0.02194593f, -0.02402404f, 0.04444356f, 0.01405794f, 0.02755862f, 0.02245474f, -0.06275147f, 0.06235043f, 
    0.13401793f, 0.02167550f, -0.00426031f, -0.38090587f, -0.17108729f, -0.10756855f, 0.03476644f, -0.27147275f, 
    -0.01553273f, -0.05110865f, -0.01590589f, 0.02780970f, -0.06245190f, 0.16100879f, -0.03174062f, 0.06633345f, 
    0.00162123f, 0.05580455f, 0.06058916f, -0.01633439f, 0.00838394f, 0.10184481f, 0.05316744f, 0.01443117f, 
    0.03431940f, 0.01814140f, -0.15777031f, -0.00530158f, 0.08131778f, 0.18130571f, 0.02293517f, 0.17063195f, 
    0.01290660f, 0.09584048f, -0.05833961f, -0.08031985f, -0.01431359f, 0.09534593f, -0.13298446f, 0.13454144f, 
    -0.02031805f, 0.03625325f, -0.01936659f, -0.01452202f, -0.02638523f, -0.17495197f, -0.02845634f, 0.05872161f, 
    0.83429235f, -0.05919730f, -0.08053810f, -0.02621235f, 0.00246788f, -0.01098804f, -0.14230515f, -0.12860589f, 
    0.01200566f, -0.19437090f, -0.24675237f, -0.03293367f, -0.36062273f, 0.05363239f, 0.07390986f, -0.14787105f, 
    0.12379594f, 0.01521255f, -0.12750804f, 0.00483794f, 0.21034360f, -0.09678915f, -0.02776277f, -0.11878566f, 
    0.32973766f, 0.25670651f, 0.47460330f, 0.10416907f, -0.02433421f, -0.01664020f, 0.00869730f, 0.02337995f, 
    -0.04186102f, 0.07361861f, -0.00040176f, -0.02977536f, 0.09610239f, -0.01707719f, 0.02223244f, 0.00888155f, 
    0.02849215f, -0.00692888f, -0.05214071f, 0.01297209f, 0.06563000f, -0.02050716f, -0.05042621f, -0.03558605f, 
    0.23898050f, -0.02652628f, 0.09076278f, 0.06988897f, -0.08734737f, -0.07218880f, 0.03006962f, -0.02000090f, 
    -0.04385148f, 0.02699191f, 0.03257763f, 0.05024238f, 0.02621039f, 0.15704496f, 0.11348017f, 0.10289932f, 
    -0.05457953f, 0.03482068f, 0.11412305f, -0.09008327f, -0.02433770f, 0.02003106f, -0.00062868f, 0.03636565f, 
    0.45643276f, 0.18270198f, 0.22156650f, 0.01658511f, 0.01625178f, -0.00314797f, -0.14082561f, -0.08888546f, 
    0.04349020f, -0.01033214f, -0.02825967f, -0.18271750f, -0.23221704f, 0.25359643f, -0.19018558f, -0.03895774f, 
    0.03647707f, -0.04815287f, -0.11311942f, 0.17367874f, 0.00478968f, -0.00905555f, -0.27966234f, -0.11844826f, 
    -0.28461325f, 0.19898446f, -0.01620699f, -0.14171855f, 0.14020041f, 0.14588240f, -0.07405790f, 0.00584957f, 
    -0.05550082f, -0.06276549f, 0.08159523f, 0.00938667f, 0.06740343f, 0.09202685f, 0.24578510f, 0.17807324f, 
    -0.09426283f, -0.10061740f, 0.05955424f, 0.00076246f, -0.10199163f, 0.03528044f, -0.03592398f, -0.06388343f, 
    0.04574767f, -0.24158637f, 0.13150170f, -0.28928003f, 0.03289167f, 0.06057217f, -0.03188814f, 0.08184864f, 
    0.09450937f, -0.14924935f, 0.05164894f, 0.16038740f, -0.25159955f, 0.11776201f, -0.01674006f, 0.00660537f, 
    -0.04631271f, -0.01290298f, 0.12150015f, 0.08689527f, -0.04873538f, 0.00621338f, -0.02225363f, 0.08898456f, 
    -0.29834804f, -0.04750236f, -0.01771674f, -0.09642138f, 0.05730623f, -0.03721069f, 0.02412611f, 0.04060755f, 
    -0.01472444f, -0.09543404f, -0.11914614f, 0.00811922f, 0.01975414f, 0.02210763f, 0.00245586f, 0.10277158f, 
    -0.03483924f, 0.01842415f, 0.04351877f, -0.00090743f, 0.18387519f, 0.05682351f, -0.05881929f, -0.00846192f, 
    0.33936241f, 0.07238241f, 0.18107072f, 0.02856980f, -0.09598078f, -0.01998874f, 0.00278102f, 0.06108222f, 
    -0.06859642f, -0.04501315f, -0.00706337f, 0.11551458f, 0.18082677f, 0.15845391f, 0.15905127f, 0.15152998f, 
    -0.03624166f, -0.03729697f, -0.03656104f, -0.03189575f, 0.13862424f, -0.02555122f, -0.02488367f, 0.04759252f, 
    -0.36137915f, 0.06448676f, -0.14541146f, -0.03613390f, 0.06549157f, -0.08294161f, 0.13649984f, -0.05022249f, 
    -0.13737285f, -0.11357055f, 0.04163275f, 0.02795281f, 0.36424109f, 0.09079202f, 0.02310640f, -0.05747847f, 
    0.04769464f, -0.12257227f, -0.05705411f, -0.05678445f, -0.03998889f, 0.03157226f, 0.01311872f, 0.04609717f, 
    -0.12452058f, -0.03979106f, -0.05152488f, 0.04089878f, -0.09655362f, 0.00484427f, -0.10268898f, -0.15737832f, 
    -0.22506592f, -0.31253716f, -0.25068593f, -0.10388159f, -0.72402763f, 0.36094600f, -0.48844489f, -0.55615193f, 
    -0.03045505f, -0.02631870f, -0.14090699f, 0.16891363f, 0.07402667f, -0.05269193f, 0.04027670f, -0.04740144f, 
    -0.17280257f, -0.02720727f, -0.12258275f, 0.03239312f, -0.08613357f, 0.02750730f, 0.04619929f, 0.11910545f, 
    -0.09287953f, -0.02426702f, -0.14628777f, 0.06743200f, 0.24997047f, -0.07687468f, 0.14134771f, -0.00681336f, 
    0.20564008f, -0.04502834f, -0.07777043f, 0.02642218f, 0.14550519f, -0.06704348f, 0.00533256f, -0.07774838f, 
    -0.30304822f, -0.00292717f, 0.06644322f, -0.24083669f, 0.12282923f, 0.11696286f, -0.04526320f, 0.11457115f, 
    0.08336293f, -0.00353262f, -0.03773477f, -0.04195909f, 0.04838565f, 0.15730990f, -0.06767684f, -0.11245480f, 
    0.01657307f, 0.00416418f, -0.06576496f, 0.08611207f, -0.04659090f, 0.09815792f, -0.03426719f, -0.00452006f, 
    0.09859188f, -0.40486977f, 0.12530802f, -0.01882511f, -0.03522323f, -0.01612471f, 0.04853584f, -0.03579836f, 
    0.07960138f, -0.09069861f, 0.08009502f, -0.14868958f, -0.34255362f, -0.09745172f, -0.18404163f, -0.24221717f, 
    -0.12173890f, -0.00137080f, 0.10374195f, 0.12116123f, -0.17744394f, 0.08592754f, 0.08487057f, 0.01181572f, 
    -0.03285120f, 0.03254515f, 0.13458171f, 0.08184575f, 0.00644543f, -0.01823052f, 0.01234369f, 0.08144310f, 
    0.03290190f, 0.10856158f, -0.03978406f, 0.12535289f, 0.13332473f, -0.01957055f, 0.14159411f, 0.02626924f, 
    -0.00911793f, -0.00651094f, -0.05219869f, 0.07225917f, 0.00912217f, 0.08575362f, 0.06767363f, -0.21775678f, 
    0.01875942f, 0.04084941f, 0.15174982f, -0.07773796f, 0.09764852f, 0.08856622f, -0.02852837f, -0.13575442f, 
    0.02202353f, 0.03584437f, -0.15920763f, -0.02168028f, -0.48658609f, 0.10477821f, -0.30437580f, -0.14729533f, 
    0.14577436f, 0.08104916f, -0.04243537f, -0.18971969f, -0.12201689f, 0.10127826f, 0.05590853f, 0.01510702f, 
    0.18095329f, -0.41510737f, 0.09530570f, -0.21289425f, -0.10133832f, 0.03320149f, 0.00827062f, 0.05351190f, 
    0.00338926f, 0.01354972f, 0.11136347f, -0.14808474f, -0.16511460f, -0.08777000f, 0.01575603f, 0.14032781f, 
    -0.00560118f, -0.01749267f, -0.02613632f, -0.01955051f, -0.25744012f, -0.06345331f, -0.16755119f, -0.17811280f, 
    0.87508786f, 0.17862016f, -0.11864036f, 0.22755504f, -0.01739259f, -0.00616076f, -0.07474944f, -0.01811703f, 
    0.03293318f, -0.10503712f, -0.07409316f, -0.13027160f, 0.09332245f, 0.10649423f, -0.25140682f, -0.34580138f, 
    -0.11326625f, -0.10092316f, 0.17051218f, 0.08237876f, -0.09277854f, 0.07181524f, 0.12884752f, -0.10913721f, 
    -0.06209819f, 0.04385984f, -0.20894331f, -0.26498565f, -0.00024571f, 0.03059102f, -0.03108466f, 0.06791579f, 
    -0.04864982f, -0.01542142f, 0.03588372f, 0.04501409f, -0.17254549f, -0.51071161f, 0.14309716f, 0.00375976f, 
    -0.04754847f, -0.04744712f, -0.08548246f, 0.10576329f, -0.04432040f, -0.07243479f, 0.05633391f, -0.00908857f, 
    -0.07420098f, 0.04409208f, 0.09270851f, -0.10999027f, 0.05327055f, -0.16788527f, -0.18937139f, 0.12051491f, 
    -0.08005765f, -0.08328447f, 0.08419517f, 0.00206719f, -0.03260888f, 0.12753895f, -0.14114043f, -0.00515825f, 
    -0.17245752f, -0.14382203f, -0.01934776f, 0.16901430f, -0.03605030f, 0.03944099f, -0.01576044f, -0.10033628f, 
    -0.02816526f, 0.10962190f, -0.28079575f, 0.14101009f, 0.08200853f, 0.14803451f, -0.07528178f, 0.05101918f, 
    -0.05956592f, -0.01659856f, 0.08235815f, -0.09623763f, -0.03837681f, -0.10216977f, 0.00768251f, -0.00855550f, 
    -0.02765190f, -0.02851909f, 0.03836842f, 0.02033430f, 0.02473301f, -0.05686105f, 0.03240749f, -0.00528220f, 
    0.01517599f, 0.25694284f, -0.09899122f, 0.13833894f, 0.01100760f, 0.08167097f, -0.07318053f, -0.14401020f, 
    0.06025583f, -0.00435676f, -0.03583609f, 0.15731047f, 0.01613606f, -0.06633649f, -0.05958654f, -0.11472812f, 
    0.04331601f, -0.15975270f, -0.01514065f, -0.00141061f, 0.01993424f, -0.11155957f, -0.12037812f, 0.08988679f, 
    0.03579193f, -0.47861850f, -0.19575331f, -0.15865083f, 0.22892812f, 0.02782328f, -0.05409560f, 0.11345235f, 
    0.01845655f, 0.04250458f, 0.02385984f, -0.04206592f, 0.06797285f, 0.00834805f, 0.02313042f, 0.02535639f, 
    -0.02457482f, -0.05354616f, 0.09341731f, 0.22660711f, 0.05563954f, 0.12859343f, -0.07707934f, -0.08341616f, 
    0.25598130f, 0.41437912f, -0.18443911f, -0.17553252f, 0.14356697f, 0.03670455f, -0.28102335f, 0.08781611f, 
    -0.11235458f, -0.06489331f, -0.13451222f, 0.07581104f, -0.30913562f, 0.13592318f, 0.09520676f, -0.41955000f, 
    0.04129942f, -0.04832513f, 0.03932144f, -0.17401250f, 0.00989290f, 0.03779327f, -0.05351047f, 0.04287177f, 
    0.07687860f, -0.11318818f, 0.12037682f, -0.08839428f, 0.02597773f, -0.07855939f, -0.09590848f, -0.14527157f, 
    0.07626013f, 0.16130376f, 0.00965828f, 0.24395941f, -0.09931709f, 0.13886739f, -0.17166056f, -0.11057083f, 
    -0.05246525f, -0.02845473f, -0.15364540f, -0.00003621f, -0.03461780f, -0.04314374f, -0.01026056f, -0.07580560f, 
    0.18055278f, -0.01331093f, 0.14033039f, -0.02100282f, 0.02128323f, -0.10644924f, -0.08508667f, -0.03991687f, 
    0.14233352f, 0.17362739f, -0.00675431f, -0.00022075f, -0.24249054f, -0.20910627f, 0.32877392f, -0.21467674f, 
    -0.02559995f, 0.05358400f, -0.01709548f, 0.09087136f, -0.00100923f, -0.03885367f, 0.05519884f, 0.01931892f, 
    0.21989433f, 0.01373209f, 0.10917962f, 0.30720145f, -0.00951950f, -0.04356411f, -0.03745804f, -0.02888763f, 
    0.02758986f, -0.12773246f, 0.00610027f, 0.17443858f, -0.06206996f, -0.13517191f, -0.02550080f, -0.00376344f, 
    -0.00794102f, 0.02711336f, -0.01143601f, 0.06267365f, 0.04512287f, -0.09961463f, -0.01662890f, 0.00717177f, 
    -0.00902823f, -0.05889505f, -0.05068794f, 0.01565641f, -0.00479371f, 0.04178087f, -0.03010887f, 0.15857708f, 
    0.07504386f, 0.03588729f, 0.04315372f, 0.01991271f, -0.37467700f, 0.02892867f, -0.04425317f, 0.21094246f, 
    -0.07780075f, -0.10838165f, -0.06678268f, -0.20752440f, -0.01454722f, -0.14039360f, 0.06515665f, 0.03350452f, 
    -0.04385031f, -0.05444286f, -0.00695690f, -0.02580657f, 0.12091710f, -0.06267972f, 0.05679901f, 0.06078119f, 
    0.08616421f, 0.00298232f, -0.11569686f, 0.05414626f, -0.02129821f, -0.11692680f, -0.15454002f, -0.05340591f, 
    0.00827366f, 0.01468595f, -0.00261286f, -0.00881425f, -0.06652089f, -0.03526906f, -0.01573666f, -0.05143215f, 
    -0.01829357f, -0.07867172f, -0.23096028f, 0.12399981f, 0.07319865f, -0.00558091f, 0.03993466f, 0.05115363f, 
    0.04575686f, -0.02614933f, 0.05932858f, 0.01808902f, 0.09781661f, -0.20846169f, -0.12680125f, -0.07648855f, 
    0.06803424f, -0.03973735f, -0.04338356f, 0.10550097f, -0.10739816f, 0.07069986f, -0.00174988f, -0.03196742f, 
    -0.77782267f, -0.59941304f, -0.09074731f, -0.22421360f, -0.07285333f, -0.14659558f, 0.08023840f, -0.13374172f, 
    -0.00428863f, -0.04375333f, 0.02222620f, -0.06421761f, -0.24953341f, 0.02548898f, 0.22235031f, 0.23507631f, 
    0.06431887f, 0.01229675f, 0.09927153f, -0.02742879f, -0.02222450f, -0.00875964f, -0.06344987f, -0.09459556f, 
    -0.60479569f, -0.30689728f, -0.46770296f, -0.48965615f, -0.05430989f, 0.05822873f, -0.05980687f, -0.43750003f, 
    0.04415279f, 0.00690102f, -0.00257123f, 0.02103884f, 0.11786286f, 0.01131007f, -0.03658063f, 0.12012057f, 
    0.08790892f, -0.04499330f, -0.05812418f, -0.00306146f, -0.07875212f, -0.12436014f, -0.01762097f, 0.07134716f, 
    0.18593782f, 0.39157468f, 0.21918501f, 0.48984793f, 0.03106538f, 0.02901271f, -0.03803679f, 0.00888958f, 
    0.02525561f, -0.06821449f, -0.08211978f, 0.02265504f, -0.23803757f, -0.10158851f, 0.14470819f, 0.20062575f, 
    -0.02227356f, 0.02617414f, 0.07535324f, 0.01388927f, 0.06295466f, -0.15635243f, 0.19626038f, -0.00199119f, 
    -0.27718624f, 0.21560284f, 0.54731834f, 0.04590368f, -0.02785178f, 0.01601272f, -0.16892467f, -0.02538622f, 
    0.06459220f, 0.08536224f, 0.01060759f, 0.02205310f, 0.09189438f, -0.00728022f, -0.01045789f, 0.05604420f, 
    -0.07918575f, 0.05062271f, -0.04939249f, 0.00316938f, 0.00066188f, 0.04237619f, 0.04939185f, 0.00840490f, 
    -0.07177611f, -0.00901480f, -0.07693611f, -0.14765866f, 0.02765046f, 0.04524054f, -0.03538759f, 0.07830118f, 
    0.06205846f, -0.04943474f, -0.12798208f, 0.20265730f, -0.15397301f, 0.01162093f, -0.14398232f, -0.22716890f, 
    0.08371905f, -0.07223353f, -0.07543920f, 0.07006213f, -0.09907750f, -0.06833561f, 0.07918177f, -0.06417958f, 
    -0.31347305f, 0.12702484f, -0.06555161f, -0.08819275f, 0.04856995f, -0.08116995f, 0.04806643f, -0.00056536f, 
    -0.01476880f, 0.05653906f, -0.02630960f, -0.00866140f, -0.74471116f, -0.07345107f, -0.16155250f, -0.31921130f, 
    -0.06342828f, -0.03395412f, 0.09431752f, -0.05304240f, -0.01224191f, -0.01611234f, -0.02842833f, -0.00898106f, 
    0.04129140f, -0.03714536f, 0.62455481f, 0.48458341f, -0.03486572f, 0.04074634f, -0.07427571f, 0.10944001f, 
    0.00830852f, 0.00973959f, 0.02077883f, -0.00682206f, -0.13422631f, 0.09292260f, 0.07413656f, 0.17909038f, 
    0.05562398f, 0.05715996f, -0.09401307f, 0.07005471f, 0.03243598f, 0.01099185f, -0.05514305f, -0.06453615f, 
    -0.21513137f, -0.18472253f, -0.03282635f, 0.04684054f, 0.14033312f, 0.04976416f, -0.07069489f, -0.04742602f, 
    0.02350035f, -0.05384263f, 0.08082244f, -0.01088244f, -0.17336825f, -0.28963554f, -0.08953141f, 0.05752045f, 
    0.06394342f, 0.02384599f, 0.05372244f, -0.05203428f, -0.04468948f, -0.07355931f, -0.04496622f, -0.03579419f, 
    -0.07568021f, 0.04363855f, 0.16600992f, -0.22169144f, 0.07079975f, -0.01924045f, -0.28208387f, -0.08150365f, 
    0.11812814f, 0.10807864f, -0.13605450f, 0.10293282f, 0.18216351f, -0.08452446f, -0.09821661f, 0.14290020f, 
    -0.15797783f, -0.00012028f, -0.02550241f, 0.01536128f, 0.00130489f, -0.04854472f, -0.01537106f, 0.01783213f, 
    0.29861733f, -0.09472584f, -0.23837829f, 0.00139844f, 0.02577937f, -0.01258031f, 0.03597971f, 0.00409661f, 
    -0.10652058f, -0.03313185f, 0.04182916f, 0.07904974f, -0.13076216f, -0.02575076f, -0.02863045f, 0.01548566f, 
    0.01397292f, -0.05096337f, -0.04958972f, 0.01533581f, -0.06194631f, -0.08768228f, 0.07007048f, -0.25785792f, 
    -0.00603371f, -0.02152949f, -0.11031622f, -0.43142560f, 0.10461843f, -0.02506147f, -0.02244481f, 0.01814454f, 
    -0.02870097f, -0.04229648f, 0.08807251f, -0.04927419f, -0.15181383f, 0.03316844f, -0.14651279f, -0.17552134f, 
    0.00713705f, -0.00004422f, 0.00200225f, 0.07537731f, -0.03668597f, -0.12735456f, 0.01560222f, 0.10726608f, 
    0.13752121f, -0.15139996f, -0.16084693f, 0.25119799f, 0.10375182f, -0.05333492f, 0.05213658f, 0.10739858f, 
    0.07915136f, -0.09100556f, -0.03947619f, 0.01596164f, -0.48212850f, -0.19763841f, 0.42231280f, -0.07374235f, 
    -0.07425353f, 0.10462444f, 0.00194340f, 0.04406020f, 0.01854914f, -0.01545140f, -0.00849524f, 0.03067230f, 
    -0.04348942f, 0.04017600f, 0.09375528f, 0.12208085f, -0.06890412f, -0.02001079f, 0.02953229f, 0.09248597f, 
    -0.02583596f, 0.06056500f, -0.08002606f, 0.18758486f, -0.36473781f, 0.12153476f, -0.28119755f, -0.03121108f, 
    0.01468133f, -0.00090581f, -0.04546455f, 0.05702846f, 0.00836863f, 0.06955140f, -0.06000094f, -0.02074146f, 
    -0.12369075f, -0.15996401f, -0.16850878f, 0.06020740f, 0.10136238f, -0.17842282f, -0.01830068f, 0.04370823f, 
    0.05051359f, -0.11364841f, 0.08078908f, 0.03064704f, -0.35256600f, -0.02118808f, 0.06254152f, -0.36662239f, 
    0.05630389f, 0.12374977f, -0.01958188f, -0.24210496f, -0.00035846f, 0.04876550f, 0.04481772f, 0.00257469f, 
    0.06453752f, -0.28370899f, -0.00342364f, 0.12782244f, 0.02850670f, -0.04363804f, -0.09640445f, 0.06976643f, 
    -0.03474436f, -0.07961029f, -0.03504278f, -0.01204086f, -0.10566091f, 0.02819497f, -0.11916401f, 0.02501383f, 
    -0.00212151f, -0.05820426f, 0.06863309f, 0.05185746f, 0.04855738f, -0.09074309f, 0.01427988f, 0.05490497f, 
    0.11007737f, -0.28123495f, 0.46074533f, 0.20014238f, -0.01376573f, 0.00655883f, 0.05550300f, 0.03587945f, 
    -0.04343040f, 0.00695809f, -0.03167821f, 0.13916796f, -0.13761228f, 0.07782973f, 0.18577349f, 0.15875959f, 
    0.07792563f, -0.00010082f, 0.09600578f, -0.04198843f, -0.02573036f, -0.09654839f, -0.10452202f, 0.03411689f, 
    0.00157446f, 0.03354735f, -0.01644979f, 0.15215205f, -0.00363596f, 0.04137213f, 0.03435103f, -0.03671221f, 
    0.04839818f, 0.02330098f, 0.02308132f, 0.12502553f, 0.15433314f, -0.00239117f, 0.00413441f, -0.15947923f, 
    0.01852653f, -0.10652827f, 0.13006260f, -0.00881136f, 0.07398180f, 0.01872020f, -0.07193887f, 0.04960603f, 
    -0.04874741f, 0.18331598f, -0.05815582f, 0.12625840f, -0.10424258f, -0.06379546f, -0.03312775f, 0.07652292f, 
    -0.01315452f, 0.05851997f, -0.30872974f, 0.05183832f, -0.36298200f, 0.01278117f, -0.32798672f, 0.28134796f, 
    -0.05876322f, 0.05306824f, -0.04604941f, -0.11883824f, -0.01497179f, 0.08624896f, -0.08238060f, 0.10375608f, 
    0.09855216f, 0.00429003f, -0.03904932f, -0.11548194f, 0.06131818f, 0.04878756f, -0.03280542f, 0.11922415f, 
    0.02664903f, 0.02595251f, 0.00373010f, -0.04988298f, 0.04420068f, 0.02566818f, 0.27057147f, 0.09590513f, 
    0.03458039f, -0.00874695f, 0.08216037f, -0.03892232f, 0.05205037f, 0.02021386f, 0.07968291f, 0.03691030f, 
    -0.24120416f, 0.18072063f, 0.25983801f, 0.17801356f, 0.04230341f, -0.03213026f, -0.12207311f, 0.03117868f, 
    0.10928689f, 0.06551243f, -0.01362528f, -0.13967362f, 0.19256970f, 0.29768929f, -0.39032522f, -0.11644621f, 
    0.00485875f, -0.20511162f, 0.07014217f, 0.10853291f, 0.00612555f, 0.09168383f, 0.02224340f, -0.03181016f, 
    -0.19704606f, -0.25706574f, -0.22223006f, -0.11218483f, -0.04335139f, -0.04226282f, -0.02398643f, 0.04805380f, 
    0.00075134f, -0.10400114f, 0.08247644f, -0.15864904f, 0.05953270f, -0.02462452f, -0.03735023f, 0.12512431f, 
    -0.10966092f, -0.01850254f, 0.10529702f, -0.01733510f, -0.06461799f, 0.00055624f, -0.00534718f, 0.02943470f, 
    -0.02930536f, 0.16303119f, -0.05745963f, 0.35532171f, 0.02866830f, -0.02258533f, 0.01020322f, 0.03264187f, 
    -0.13997586f, -0.00328835f, -0.04501961f, -0.06251381f, -0.08535291f, 0.33197665f, -0.45363569f, 0.31906328f, 
    0.11777273f, -0.20517439f, 0.11521114f, -0.03355006f, -0.15242116f, -0.15227678f, -0.08746194f, 0.09065868f, 
    0.21575576f, 0.15594819f, -0.07046125f, -0.16435471f, -0.10097141f, -0.09214842f, -0.03491114f, -0.03364941f, 
    -0.01351304f, -0.03218224f, 0.12133787f, -0.21598193f, -0.00328251f, -0.17694202f, 0.11547522f, -0.15949932f, 
    -0.10104749f, -0.16005276f, -0.08332645f, -0.19753578f, -0.10802554f, 0.04275265f, 0.09993714f, -0.19569899f, 
    -0.31934747f, -0.17334123f, -0.04395908f, 0.19235739f, -0.03757058f, 0.08161194f, -0.07645851f, -0.02791860f, 
    -0.07078249f, 0.04850270f, -0.14021647f, -0.01747760f, 0.14645076f, 0.07536294f, -0.17425188f, 0.20140581f, 
    -0.00697970f, 0.06474687f, 0.06956752f, -0.05719126f, 0.09217516f, -0.09523708f, 0.10819623f, 0.18843871f, 
    -0.00936113f, -0.08835591f, -0.14747794f, 0.19908981f, 0.10580698f, 0.03405831f, -0.03913153f, -0.08245734f, 
    -0.10053024f, 0.08788911f, 0.02419182f, 0.03527343f, -0.79533154f, 0.38846800f, -0.22567467f, -0.31917468f, 
    0.10408779f, 0.03953253f, -0.11597408f, -0.16916163f, -0.08562535f, -0.05670309f, 0.15128714f, 0.00046429f, 
    0.69636387f, 0.10115106f, 0.06955826f, 0.32790238f, 0.00170590f, -0.00034824f, -0.23699246f, -0.11324961f, 
    -0.11408215f, 0.00568204f, 0.18194953f, -0.17404942f, -0.24612385f, 0.17844427f, -0.03032534f, 0.47604787f, 
    -0.01075241f, -0.10878880f, 0.23786433f, 0.09987841f, 0.01757463f, 0.05287317f, 0.06390882f, -0.10924173f, 
    0.08790541f, -0.16002819f, 0.18975557f, 0.04681363f, -0.20228569f, 0.02837729f, -0.05156390f, 0.06683558f, 
    -0.00968890f, 0.07932460f, -0.00766795f, 0.01663042f, 0.24877706f, 0.25289115f, 0.17085281f, -0.09263211f, 
    -0.05148841f, 0.04762442f, 0.10683341f, 0.10219335f, -0.08718907f, 0.03837329f, -0.06775546f, 0.18938299f, 
    0.00964097f, -0.07725647f, 0.27996525f, 0.31540972f, 0.02935871f, -0.07138053f, -0.05969176f, -0.07444267f, 
    -0.09109929f, -0.11547451f, 0.00790032f, -0.08087000f, -0.15341942f, -0.27065894f, 0.60567164f, 0.04414115f, 
    -0.25561002f, 0.11857523f, -0.21403810f, 0.06977226f, 0.08069441f, 0.03928693f, 0.11618016f, -0.00705500f, 
    0.06243515f, -0.13571259f, 0.07267983f, 0.13376570f, 0.18109934f, 0.05219940f, 0.00683012f, -0.07470036f, 
    0.01005291f, 0.09394849f, 0.05534502f, 0.00647214f, -0.14775547f, -0.16472949f, -0.08769611f, -0.02177696f, 
    -0.18864840f, -0.23681588f, -0.11719959f, -0.10075632f, -0.03426692f, 0.01427803f, -0.25413302f, -0.00629258f, 
    0.21742396f, -0.09719245f, -0.07462131f, -0.08060340f, -0.18269207f, -0.06974237f, -0.07214281f, -0.16174217f, 
    -0.03617712f, 0.06410395f, -0.00920779f, -0.18128224f, -0.01812821f, -0.14287332f, -0.06798109f, -0.02441344f, 
    0.11319324f, 0.06213273f, -0.10370231f, 0.17186259f, -0.09293208f, 0.03526802f, -0.02097199f, -0.08848845f, 
    -0.04778465f, 0.25602520f, -0.05791590f, 0.21863884f, -0.02853195f, -0.06353868f, -0.03744043f, -0.09058984f, 
    -0.14488061f, 0.09744720f, -0.03183179f, 0.02725273f, 0.24374165f, 0.20548324f, 0.28327638f, 0.04815736f, 
    0.02080646f, 0.04500445f, -0.02525355f, 0.07126523f, 0.05746368f, 0.09507842f, 0.04303013f, -0.09288409f, 
    0.08911736f, 0.24071573f, -0.40480375f, -0.41295269f, 0.02000526f, -0.03999223f, -0.06601030f, -0.00708465f, 
    -0.26437658f, -0.04760706f, 0.00515725f, -0.02501751f, -0.24341913f, -0.02335349f, -0.07869730f, -0.51504028f, 
    -0.01948133f, -0.13266918f, -0.14665978f, 0.00724076f, -0.09633839f, -0.05932060f, -0.06413070f, 0.01386507f, 
    -0.09267180f, -0.06881146f, -0.20975143f, 0.24785654f, 0.01484823f, -0.00292272f, -0.05043463f, -0.02303940f, 
    -0.01549433f, 0.03499752f, -0.08595647f, -0.06029114f, 0.44897091f, -0.13829497f, -0.14933431f, -0.26153374f, 
    0.30225939f, 0.10773328f, 0.09247725f, -0.06054209f, -0.03949578f, 0.06041108f, -0.08547217f, -0.02029491f, 
    -0.09523457f, -0.29258856f, 0.14090869f, 0.25380319f, 0.00051121f, 0.26341122f, -0.06429114f, 0.10780530f, 
    0.02995910f, -0.03548051f, -0.01134419f, -0.09758230f, 0.01987373f, 0.13593213f, 0.12122186f, -0.04994883f, 
    -0.05703116f, 0.03735889f, -0.24962936f, 0.11138305f, -0.09440461f, 0.05239666f, -0.09561742f, 0.10663269f, 
    0.03367888f, -0.12957779f, 0.05096580f, 0.22956739f, 0.09502232f, -0.14477734f, -0.07218355f, 0.02892287f, 
    0.00296093f, 0.09831232f, -0.05829178f, 0.02916151f, 0.50651503f, -0.33299822f, -0.24549469f, -0.19585007f, 
    0.12139336f, 0.10174262f, -0.00280751f, 0.06989562f, -0.04732933f, -0.00256005f, 0.03567825f, -0.03791755f, 
    -0.14131722f, 0.58301294f, -0.01881575f, 0.02463978f, 0.14645346f, 0.00774307f, 0.08683147f, 0.06905259f, 
    -0.17779101f, 0.02206559f, 0.09274162f, -0.10517619f, 0.09166471f, 0.00597125f, -0.08384709f, -0.25980195f, 
    -0.06616344f, -0.04461242f, 0.00484695f, -0.12536921f, -0.05579522f, -0.11396757f, 0.01303386f, -0.10520402f, 
    -0.37767801f, 0.09283002f, 0.11320731f, -0.21276966f, -0.21081854f, 0.17051660f, -0.08883837f, 0.05097381f, 
    -0.16596520f, -0.14550473f, 0.08170209f, 0.09635255f, -0.17400366f, -0.00410541f, -0.04373760f, 0.11039789f, 
    -0.01161823f, 0.01006098f, -0.06538706f, 0.02449435f, -0.06346871f, -0.02084102f, -0.09814405f, -0.03159326f, 
    -0.44474575f, 0.12613101f, -0.21500607f, 0.52496010f, -0.04140121f, -0.18790555f, 0.03922597f, -0.05630413f, 
    -0.02878399f, -0.06969436f, -0.08457355f, -0.04344772f, -0.07136386f, -0.12802418f, -0.10781723f, 0.15475808f, 
    0.05915020f, 0.11325317f, 0.01613377f, 0.04127671f, 0.00713171f, -0.08848921f, 0.01645312f, -0.06436793f, 
    -0.09618580f, -0.09396277f, -0.04755230f, 0.08934496f, 0.10682055f, -0.03002324f, -0.05360034f, -0.08318981f, 
    -0.04747564f, 0.05224048f, 0.05733077f, 0.04471103f, -0.05450245f, 0.12390570f, -0.00081445f, 0.08365832f, 
    -0.01147492f, -0.06300750f, -0.01624952f, 0.00242687f, -0.11637840f, 0.09468251f, -0.00380227f, -0.01913348f, 
    0.21180771f, -0.01107691f, 0.00708959f, -0.04827027f, -0.03103059f, -0.11928821f, -0.00901370f, -0.17667972f, 
    -0.06587368f, 0.19669010f, -0.11476092f, -0.17983592f, 0.12425923f, -0.06609657f, -0.03625195f, 0.19191042f, 
    -0.04295411f, -0.03104907f, -0.05638076f, -0.09317366f, 0.09260965f, 0.03466455f, 0.02433602f, -0.00591718f, 
    -0.22526155f, 0.03521807f, 0.14477855f, 0.05901846f, -0.00202607f, 0.13193861f, -0.04578440f, 0.08781883f, 
    -0.05474957f, -0.24324568f, -0.11873528f, 0.04309999f, 0.03349966f, -0.02495810f, -0.30301744f, -0.26211795f, 
    -0.03517764f, -0.04763844f, -0.01409601f, 0.05512571f, 0.09008545f, -0.06530356f, -0.21677870f, 0.04416194f, 
    0.38281372f, 0.40704980f, 0.06620280f, -0.48811942f, 0.04475531f, -0.01318926f, -0.10359895f, -0.09659206f, 
    -0.06487989f, 0.04028722f, 0.00817179f, -0.09786356f, 0.02778182f, 0.05005514f, -0.16552813f, -0.17714272f, 
    0.25259939f, 0.15527929f, 0.01887942f, 0.21844144f, -0.15584414f, -0.01737751f, 0.06070867f, -0.03325322f, 
    -0.32899743f, 0.04283135f, -0.06961948f, 0.11801223f, 0.02098220f, 0.09560890f, -0.01838744f, 0.17562427f, 
    0.02048729f, -0.01319871f, 0.13164803f, 0.00198756f, -0.06366262f, -0.07718857f, -0.04404439f, -0.18261881f, 
    -0.14536312f, 0.18844344f, 0.00934127f, 0.06815388f, 0.01111229f, 0.09787813f, -0.00404004f, 0.14054935f, 
    0.06252750f, -0.16815892f, 0.02926897f, 0.06752517f, -0.02616246f, 0.02180132f, -0.04965315f, -0.02488565f, 
    -0.12154136f, 0.17727688f, -0.02572832f, -0.01745442f, -0.28229269f, -0.37977353f, 0.48935276f, 0.22527789f, 
    -0.08155413f, -0.13348556f, -0.10335644f, 0.05812045f, 0.07379691f, 0.05995384f, -0.05187258f, -0.01488370f, 
    0.05529778f, 0.07912196f, -0.11949269f, -0.03834489f, 0.07941581f, 0.09787221f, 0.05052045f, -0.05777996f, 
    -0.10022782f, 0.14885120f, -0.02506548f, 0.03955651f, -0.01145179f, 0.01345915f, 0.11796277f, -0.37404478f, 
    0.05752717f, -0.04170499f, -0.06286351f, 0.03496250f, -0.03973374f, 0.10394508f, -0.01414145f, -0.06558582f, 
    0.29915506f, -0.14454386f, -0.23624414f, -0.21725024f, 0.11379359f, -0.04891294f, 0.06333436f, 0.08727792f, 
    -0.01077724f, 0.04519245f, -0.25943211f, -0.08514882f, -0.19390772f, -0.08711937f, 0.00024834f, 0.25747675f, 
    -0.16310702f, 0.04539416f, 0.10946067f, 0.15073669f, 0.03654717f, 0.09871909f, 0.11204173f, 0.02131816f, 
    0.28123420f, 0.44781375f, -0.20596117f, -0.44993308f, -0.09596922f, 0.04059429f, -0.04708569f, -0.27009287f, 
    -0.30147046f, 0.08484728f, -0.20055036f, 0.21627675f, 0.01584843f, -0.10130069f, 0.00121613f, 0.23083249f, 
    -0.26323283f, 0.06041943f, -0.21783604f, 0.08120716f, 0.00262806f, 0.12147400f, 0.11233824f, 0.14494660f, 
    -0.34488675f, 0.43691856f, -0.23528703f, -0.06575878f, 0.14374922f, 0.09773539f, 0.06501161f, -0.03623234f, 
    -0.33935753f, 0.05411686f, -0.04330721f, 0.01144741f, 0.28584635f, -0.13102727f, 0.03111739f, -0.08442774f, 
    0.22153188f, 0.08537701f, 0.08210123f, 0.05581872f, -0.09915917f, 0.00679257f, -0.07381522f, 0.08510626f, 
    0.07705639f, -0.27768144f, -0.17358272f, -0.43996215f, -0.23324943f, -0.13302086f, -0.11414667f, 0.03687141f, 
    -0.09948911f, -0.05264395f, 0.06458996f, -0.24018666f, 0.07871738f, -0.27159083f, 0.14253534f, 0.04697723f, 
    -0.08355140f, 0.19025962f, -0.18344897f, -0.02024217f, -0.05004907f, -0.06083133f, 0.08509772f, -0.02935995f, 
    0.10101066f, 0.10902189f, -0.31294185f, 0.15247744f, -0.07297003f, -0.00623988f, -0.09533194f, -0.09472539f, 
    -0.10388999f, -0.06127048f, 0.08728550f, 0.08287553f, 0.16173311f, 0.00316245f, -0.21085711f, -0.03046008f, 
    -0.03951051f, -0.11766946f, 0.02979335f, 0.20436585f, 0.05386793f, -0.07409091f, 0.04761828f, -0.03729021f, 
    -0.08301274f, 0.39513460f, -0.56072986f, 0.28940406f, -0.02218798f, -0.09111201f, -0.03307987f, -0.04329941f, 
    0.06392870f, -0.10732652f, 0.02136047f, -0.06431252f, 0.23323947f, -0.03970103f, -0.05536249f, 0.15535589f, 
    0.11459172f, 0.08199473f, 0.05250129f, -0.01637628f, -0.10393284f, 0.04033543f, 0.02869458f, 0.06141878f, 
    0.07088949f, 0.88068545f, -0.30713955f, 0.27331120f, 0.17426731f, -0.06701683f, -0.02430614f, -0.15175356f, 
    -0.06403513f, -0.03088555f, 0.07230700f, -0.09334044f, -0.26594949f, 0.36423591f, 0.08680427f, -0.20431142f, 
    -0.18782550f, 0.08588295f, -0.05814680f, 0.02619054f, 0.00892958f, -0.15751885f, -0.00930514f, -0.10575861f, 
    0.00857157f, -0.06723777f, -0.04635111f, 0.09822997f, 0.06926750f, 0.05331246f, 0.04579750f, 0.02437163f, 
    0.04449764f, 0.06342646f, -0.03969783f, 0.09867697f, 0.06468842f, -0.01388287f, -0.03483412f, 0.13590592f, 
    -0.00289745f, 0.06651213f, -0.07914254f, -0.22731055f, 0.05364674f, 0.01153714f, -0.05416961f, -0.06458472f, 
    0.00240437f, 0.07357859f, -0.01814570f, 0.01276407f, -0.01838020f, -0.17433926f, -0.02381071f, -0.10034011f, 
    -0.21753684f, 0.07793591f, -0.19289130f, -0.21425052f, 0.17105818f, -0.24388994f, 0.13837360f, -0.00993078f, 
    0.08182144f, 0.04160100f, -0.13521618f, 0.16912811f, -0.10132980f, 0.07150600f, 0.00120311f, -0.09776410f, 
    -0.03932833f, -0.16005693f, 0.04323101f, 0.11426514f, -0.12018161f, 0.05860772f, 0.01286178f, 0.05877802f, 
    0.01269078f, 0.02654042f, -0.11605918f, -0.01120452f, 0.08260662f, 0.03738331f, 0.04113121f, 0.05707211f, 
    0.01206934f, 0.05256180f, 0.04175209f, 0.08788605f, 0.07251590f, 0.07737237f, -0.02695482f, -0.01129652f, 
    0.15744306f, -0.01322999f, 0.14064126f, 0.01332149f, 0.00940271f, -0.01270979f, -0.03400202f, -0.01870731f, 
    0.11886414f, -0.08425961f, -0.03836307f, -0.06812456f, 0.04977777f, 0.04601396f, 0.16194086f, 0.13766940f, 
    -0.13623190f, -0.26899230f, 0.01691955f, 0.02848082f, -0.22076616f, -0.00180543f, 0.02542090f, -0.05449522f, 
    -0.00247929f, 0.20015055f, 0.19153425f, 0.13824809f, -0.06255873f, -0.07594468f, -0.05886831f, -0.08752548f, 
    0.07185942f, 0.03112689f, -0.10321463f, 0.03637270f, -0.05536379f, -0.25875312f, -0.03672180f, 0.28715998f, 
    -0.02798596f, -0.04400141f, -0.01915850f, -0.23213950f, -0.29098016f, -0.11981829f, -0.13820370f, -0.07379375f, 
    -0.09530549f, 0.05960456f, -0.11523405f, -0.04907178f, -0.07820980f, -0.10884286f, 0.00605635f, 0.09985662f, 
    0.04710422f, -0.14735530f, -0.01020557f, -0.08721783f, -0.07939441f, 0.40436387f, -0.09233223f, -0.25169888f, 
    0.18955353f, -0.02589416f, -0.13006443f, -0.07203145f, -0.12112040f, 0.00399844f, -0.06552561f, -0.11129323f, 
    0.16170549f, 0.09604059f, -0.30742484f, 0.19334966f, 0.04143272f, -0.07764718f, 0.03389760f, -0.08590838f, 
    0.13452034f, -0.02226402f, 0.21416758f, 0.41758716f, 0.01429624f, 0.04560945f, 0.03470775f, 0.34407291f, 
    -0.09216197f, -0.09741250f, -0.12479271f, -0.05982100f, 0.07240278f, -0.02104655f, 0.08137657f, 0.11877025f, 
    -0.00339451f, 0.19054364f, 0.00456734f, 0.14772788f, -0.03591064f, -0.12225416f, -0.18227892f, -0.10677306f, 
    0.00422791f, 0.03888311f, 0.01609011f, 0.00497395f, 0.21456991f, 0.15815017f, -0.11192633f, 0.32692152f, 
    0.03134641f, 0.00348998f, 0.17483485f, -0.24528131f, 0.09647771f, -0.02386313f, -0.03024415f, -0.03931398f, 
    -0.00615185f, 0.00699016f, 0.01022798f, 0.17261122f, -0.09902164f, -0.07457142f, 0.04383000f, 0.05738274f, 
    0.02628725f, 0.04597671f, -0.03412366f, 0.14482476f, 0.08313224f, 0.06811981f, 0.05058476f, 0.03577237f, 
    0.11272386f, 0.07014064f, 0.08564937f, 0.06584127f, -0.06354132f, -0.08656695f, 0.02521258f, -0.10390238f, 
    -0.01110217f, -0.02586530f, 0.02924718f, 0.01510455f, 0.00575094f, 0.05498107f, -0.05866264f, 0.00037497f, 
    -0.06155645f, -0.04964450f, -0.09246654f, -0.08053123f, 0.00820235f, -0.04527844f, 0.26213449f, 0.12512949f, 
    -0.09686712f, 0.00482448f, 0.01440739f, 0.00429161f, -0.05468871f, 0.01686388f, 0.00077252f, 0.01103489f, 
    0.07678701f, -0.16075787f, 0.06576890f, -0.18689360f, -0.02762820f, -0.00244498f, -0.12139715f, -0.12865998f, 
    0.11488789f, -0.16800496f, 0.02094859f, -0.00536470f, -0.01824080f, -0.04730039f, -0.43087530f, -0.30855554f, 
    0.01696743f, -0.00238289f, 0.00041421f, -0.01285130f, 0.09554707f, -0.02919548f, -0.00542049f, 0.10469952f, 
    0.02605370f, -0.13152404f, 0.08676618f, -0.06179291f, 0.02655020f, 0.05823547f, -0.02532082f, 0.01347059f, 
    -0.02765670f, 0.05394167f, -0.15209858f, -0.04130151f, 0.08151854f, 0.00772368f, -0.15212971f, -0.00490170f, 
    0.13681872f, -0.05256519f, 0.05498723f, -0.12116616f, -0.12003018f, -0.10745123f, 0.02683153f, -0.09557600f, 
    -0.07855427f, 0.06986504f, 0.13708143f, -0.04439887f, -0.17258126f, 0.10279529f, 0.08924885f, 0.09964999f, 
    -0.00904830f, -0.01576283f, -0.02000875f, 0.13166153f, 0.03409639f, 0.17074957f, -0.04162104f, -0.03473479f, 
    -0.09370287f, -0.07554620f, 0.02518486f, 0.10874999f, -0.01887065f, -0.22287096f, -0.16483037f, -0.01923794f, 
    0.09579880f, 0.35254928f, 0.25827929f, 0.17870307f, -0.07995830f, -0.03548810f, 0.01760621f, 0.19183548f, 
    -0.00497862f, -0.02073499f, 0.06346440f, -0.03894803f, 0.20625287f, -0.05328686f, -0.23723586f, 0.03216840f, 
    -0.11005805f, 0.04647156f, 0.12488624f, -0.01139583f, -0.07090919f, -0.23651607f, 0.11248814f, -0.16539642f, 
    0.08572051f, 0.14126725f, 0.08144350f, 0.12127638f, -0.10949275f, -0.18120520f, -0.03694719f, -0.16378628f, 
    -0.04082615f, -0.14539875f, 0.00224614f, 0.06744299f, -0.26804745f, 0.09506889f, 0.17670411f, -0.02759714f, 
    -0.06640947f, 0.01082687f, -0.11887489f, 0.08462901f, -0.08595464f, -0.01575555f, -0.21480009f, -0.07905089f, 
    -0.32452190f, -0.18421412f, -0.05135642f, -0.12842937f, 0.03445664f, 0.18382542f, -0.05194793f, 0.12518339f, 
    0.16751251f, 0.05350311f, -0.03410880f, 0.13685562f, -0.07558744f, -0.13891850f, -0.19443621f, 0.10698095f, 
    -0.06806063f, -0.02838573f, -0.10259818f, 0.00579930f, -0.02225897f, -0.01927662f, -0.05890195f, 0.09720238f, 
    -0.14211409f, -0.64467812f, -0.51065183f, -0.07240639f, 0.12064941f, -0.00659090f, 0.02230448f, 0.00210273f, 
    -0.00690386f, 0.08707716f, 0.00719836f, -0.19431961f, -0.06222083f, 0.01036800f, 0.06376397f, 0.15493478f, 
    0.01617147f, 0.01254862f, 0.00263958f, -0.13712102f, -0.07613729f, -0.02338689f, -0.00345090f, 0.12889729f, 
    0.12359659f, 0.01808966f, 0.00042441f, 0.05754189f, 0.10368941f, 0.05593743f, 0.01776398f, -0.00191082f, 
    0.02379405f, -0.00956686f, 0.00358167f, -0.03547603f, 0.01691807f, 0.09905791f, 0.16412121f, 0.19464818f, 
    -0.09529502f, -0.08672535f, 0.02345354f, 0.11360772f, 0.03065669f, 0.01015340f, -0.00412495f, -0.00589728f, 
    -0.12535931f, -0.05691571f, 0.02049671f, 0.14105639f, -0.16735338f, -0.08574928f, -0.03647465f, -0.12064361f, 
    -0.02490548f, 0.06225338f, 0.00691727f, 0.01730051f, -0.09397265f, -0.06516153f, 0.10180504f, -0.00320720f, 
    0.03617849f, -0.02269062f, -0.08455115f, -0.03782329f, 0.01755570f, -0.07482661f, -0.08629916f, 0.03217592f, 
    -0.14351989f, 0.12777610f, -0.00207455f, 0.06234277f, -0.00459430f, -0.13332087f, 0.10656672f, 0.00629046f, 
    -0.15455541f, -0.12454994f, -0.22422032f, -0.15351078f, 0.02370561f, 0.03974956f, 0.05319015f, 0.10767669f, 
    0.07085061f, 0.06640586f, -0.03085599f, 0.14997025f, 0.05993196f, -0.02331393f, 0.04391761f, 0.04385700f, 
    -0.12956515f, 0.08231140f, 0.12570754f, 0.20626602f, 0.08416288f, -0.01836045f, 0.14576821f, -0.04685837f, 
    0.05592531f, 0.23625942f, 0.01243931f, -0.13764605f, -0.05983853f, -0.03469780f, 0.03806525f, 0.03456489f, 
    -0.10103114f, 0.00253627f, -0.06896628f, -0.11933684f, -0.01968821f, 0.00842362f, 0.02759137f, -0.07720656f, 
    -0.25641036f, -0.15673703f, -0.20297879f, 0.19767293f, -0.01898832f, 0.03599311f, 0.01137572f, -0.12132349f, 
    -0.03909450f, -0.09109082f, 0.06597405f, 0.18999398f, 0.21766531f, 0.11702560f, 0.09525798f, 0.05498351f, 
    0.01936118f, 0.05375982f, 0.05547433f, 0.11632021f, -0.16759090f, -0.10055802f, -0.17667267f, -0.42950690f, 
    0.16283765f, -0.18546331f, -0.22713520f, -0.00530364f, 0.03972608f, 0.05052137f, 0.04849931f, -0.06256673f, 
    0.01001359f, -0.02882804f, -0.03380775f, -0.19652390f, -0.02148957f, -0.14772071f, -0.09991152f, 0.03566266f, 
    0.08174263f, 0.01410109f, 0.02980854f, 0.01334257f, 0.01877245f, 0.11361579f, 0.05439054f, 0.17226662f, 
    0.01700469f, 0.02532070f, -0.10907200f, -0.07584126f, -0.12375712f, 0.12476690f, -0.06800506f, 0.01906376f, 
    0.23287903f, -0.06722485f, -0.21833909f, 0.07322565f, 0.16064388f, 0.28587934f, 0.03305049f, 0.13674796f, 
    -0.09495089f, 0.02758198f, 0.14492190f, -0.09480746f, 0.05472162f, -0.04614234f, 0.04695287f, -0.00817748f, 
    -0.15648377f, -0.04564796f, -0.10193267f, -0.04914310f, -0.02817910f, 0.05084093f, -0.04112689f, 0.13632160f, 
    0.04288534f, 0.05582896f, -0.03050942f, 0.09906698f, 0.20882663f, -0.28755394f, -0.40526429f, 0.16245779f, 
    -0.08875196f, -0.02471712f, 0.20400955f, -0.02797936f, -0.06539344f, -0.15509884f, -0.08421095f, -0.02209720f, 
    0.00337227f, 0.00732907f, 0.14838570f, -0.02082388f, -0.02180296f, -0.12248244f, 0.05101341f, -0.21715041f, 
    -0.01011647f, -0.06007477f, 0.06495235f, -0.06233330f, 0.11874519f, 0.17575185f, 0.14899126f, 0.02811615f, 
    0.16954376f, 0.06724881f, -0.05986066f, 0.11663901f, 0.04377637f, 0.04022538f, -0.10870249f, 0.03206051f, 
    -0.25836870f, -0.38107711f, -0.20835440f, 0.23122878f, -0.07197114f, 0.11502576f, 0.14167513f, -0.26727256f, 
    -0.03233635f, 0.04858236f, 0.06308558f, -0.00373683f, -0.01541672f, 0.05404973f, -0.08256396f, 0.14457113f, 
    -0.00372793f, 0.00979702f, 0.00056773f, -0.09663289f, 0.07661417f, -0.03249694f, -0.04752855f, 0.02839243f, 
    0.26468676f, -0.43531832f, 0.02134370f, 0.00732047f, -0.06580289f, -0.06441215f, 0.05025972f, 0.04315149f, 
    0.11615156f, 0.01070683f, -0.01360636f, 0.02015418f, 0.25151336f, 0.00490105f, 0.11005709f, 0.05677170f, 
    -0.04188888f, -0.03660104f, 0.00755068f, -0.05498517f, 0.24473640f, -0.16932933f, -0.22118303f, -0.08451317f, 
    -0.13549541f, -0.09187698f, 0.00569200f, -0.16246125f, -0.00344766f, 0.08061615f, -0.00775596f, -0.03639034f, 
    -0.00536051f, -0.08529228f, -0.00878229f, -0.04623602f, 0.04101969f, -0.18846889f, -0.24678159f, 0.00993816f, 
    0.16766940f, -0.09157696f, 0.01971315f, -0.14141971f, 0.01084024f, -0.25092381f, -0.11816694f, 0.00670279f, 
    -0.19590318f, -0.07245524f, -0.16263901f, -0.03776797f, 0.14426379f, -0.02039887f, 0.06885681f, 0.20024738f, 
    0.11042866f, 0.00727838f, 0.06814390f, -0.22421297f, 0.11189507f, 0.07064649f, 0.20093451f, 0.21545205f, 
    -0.14302410f, -0.04215270f, -0.15664370f, 0.08074912f, -0.02855748f, -0.05601230f, -0.04992336f, -0.00137355f, 
    -0.16003978f, -0.12293953f, 0.13652320f, -0.07404674f, 0.07827812f, 0.05404592f, -0.10456015f, -0.08055273f, 
    -0.10213162f, 0.03832430f, -0.07362327f, 0.00707213f, -0.12259851f, 0.00162615f, 0.08763273f, 0.05931281f, 
    -0.11480848f, -0.07525508f, 0.04453716f, 0.00917288f, 0.14005321f, 0.04194362f, 0.12428058f, 0.08705812f, 
    -0.32032460f, -0.30663714f, 0.07253550f, -0.48920771f, 0.11787166f, 0.18160912f, -0.17315973f, 0.03718922f, 
    0.04923485f, -0.01047238f, 0.01562722f, 0.03457571f, 0.07078687f, -0.43199936f, 0.09665068f, 0.19098061f, 
    0.05437195f, 0.05253184f, 0.00066865f, -0.15894696f, -0.13941796f, 0.01450196f, -0.08065822f, 0.17453636f, 
    -0.22547558f, -0.12329186f, 0.05187941f, 0.06281302f, 0.01735628f, -0.06858467f, -0.04182043f, -0.03095264f, 
    -0.05776807f, -0.00731742f, -0.00578083f, 0.10351177f, 0.10327341f, 0.16293180f, 0.16166295f, 0.08176133f, 
    -0.01353662f, -0.13992180f, 0.12302464f, 0.23323862f, -0.00040988f, -0.07372902f, 0.04255646f, 0.07630965f, 
    0.11712808f, 0.06529452f, 0.22921936f, -0.26577312f, 0.11081777f, 0.13415338f, 0.07377495f, -0.15216027f, 
    0.29227662f, -0.11620305f, -0.00219465f, 0.01380021f, 0.23615597f, 0.07856560f, -0.01987242f, -0.00057870f, 
    -0.25014687f, -0.17587925f, 0.09521604f, 0.10839461f, 0.05900370f, 0.04973420f, -0.02817031f, 0.04814817f, 
    0.04205573f, -0.10901809f, 0.15175197f, 0.07807338f, 0.00724585f, -0.09178339f, -0.00451521f, -0.01101381f, 
    0.00966885f, 0.07832000f, -0.06944703f, 0.17105095f, -0.03862291f, 0.00856221f, -0.10024258f, 0.08640558f, 
    0.29221570f, 0.04419443f, -0.12939312f, -0.08793645f, 0.11395144f, -0.04024338f, 0.05790043f, 0.00085661f, 
    0.14824623f, -0.01125567f, -0.20641977f, 0.04666312f, -0.01636383f, -0.04028867f, 0.15893517f, 0.25215480f, 
    -0.19770858f, -0.03165029f, 0.02502676f, -0.04101533f, -0.05050090f, 0.17023724f, 0.26675236f, -0.55669630f, 
    0.20514379f, -0.12972127f, 0.13495082f, -0.18519001f, 0.00828009f, -0.04703823f, 0.20644294f, 0.02149490f, 
    0.15651461f, -0.04583399f, 0.25509372f, -0.10140640f, 0.07423823f, 0.12773970f, -0.06127347f, 0.15213872f, 
    0.02147301f, 0.00018863f, 0.10644630f, -0.01425521f, 0.21354309f, 0.12072579f, 0.11106439f, 0.01837636f, 
    -0.02785507f, -0.04339018f, -0.06270267f, 0.21081664f, 0.08771103f, 0.15313222f, -0.11657283f, -0.01858462f, 
    -0.45696440f, -0.19574869f, -0.34406951f, 0.31859958f, 0.06691743f, -0.18748295f, 0.10559078f, 0.03646104f, 
    0.03198862f, 0.05765080f, -0.03494360f, 0.25243318f, -0.09599085f, -0.04921451f, -0.66633582f, -0.06897023f, 
    -0.00697679f, 0.14710397f, -0.22336350f, 0.12090494f, 0.08730675f, -0.23108989f, 0.13825019f, 0.00508016f, 
    -0.08121888f, -0.03679030f, -0.05418555f, 0.07086152f, 0.03440457f, 0.01499084f, 0.07574249f, 0.03634541f, 
    0.01239856f, -0.20453805f, -0.32596320f, -0.59689397f, -0.07909594f, -0.15265438f, 0.33897644f, 0.28152856f, 
    0.08959655f, 0.03433765f, 0.01640589f, -0.07016894f, 0.05701431f, -0.02228128f, 0.04957046f, -0.23646185f, 
    -0.15255007f, 0.05184617f, -0.27081552f, -0.17263120f, 0.11928952f, -0.01502525f, 0.11165041f, 0.22359791f, 
    0.10034218f, -0.03272512f, 0.00874262f, 0.08486243f, -0.25109860f, 0.10885365f, -0.31121254f, 0.01104361f, 
    0.16795729f, -0.04014800f, -0.10923733f, 0.12599352f, 0.03802271f, 0.08935167f, -0.03020464f, 0.03321957f, 
    -0.36076945f, -0.05805770f, -0.00591283f, -0.22094211f, 0.00374757f, 0.01556187f, -0.00680889f, 0.10743016f, 
    0.02018186f, -0.17169243f, 0.00023835f, 0.03148040f, -0.08724465f, -0.05540828f, -0.16286206f, 0.04118869f, 
    0.11081626f, -0.11104719f, -0.15344679f, -0.02313801f, -0.11286707f, -0.04018264f, 0.14977284f, 0.25876257f, 
    -0.01128319f, -0.11457726f, -0.01279398f, 0.01527453f, 0.10631178f, -0.07423805f, -0.03619841f, -0.05733877f, 
    -0.14420508f, 0.08977389f, 0.15811436f, 0.15597452f, 0.27644134f, -0.08716998f, -0.11538282f, 0.04888545f, 
    0.04534326f, 0.09296586f, 0.01169801f, -0.23107204f, -0.09186362f, -0.04328072f, -0.05009558f, -0.15509555f, 
    -0.03328282f, 0.03715136f, 0.23942727f, -0.27159360f, -0.05770973f, -0.00934786f, -0.10303715f, 0.08791488f, 
    -0.22211215f, -0.01936173f, 0.23581523f, -0.19466604f, -0.21370193f, -0.21235833f, -0.12632790f, -0.03393039f, 
    0.04695080f, 0.03225408f, 0.02937946f, -0.03616881f, -0.01289184f, 0.01356234f, -0.06876335f, -0.31492823f, 
    -0.04167657f, -0.00130149f, 0.20040590f, 0.07339273f, 0.09012721f, -0.06883466f, 0.03855976f, -0.10720593f, 
    -0.05718712f, 0.03844406f, 0.15765849f, 0.09941687f, -0.18697637f, 0.00331210f, -0.07684916f, 0.03321387f, 
    0.01507821f, 0.01907741f, -0.05368321f, 0.06034463f, 0.23570319f, -0.19396690f, 0.33543611f, 0.18065241f, 
    0.11797709f, 0.14251395f, 0.04615742f, -0.05145759f, 0.18236144f, -0.01376482f, -0.23454316f, 0.04986519f, 
    0.04257577f, 0.00648611f, -0.02147872f, 0.05744520f, -0.41313070f, -0.20468719f, -0.28800839f, 0.02437929f, 
    -0.07420240f, 0.01595495f, -0.07079266f, -0.01827831f, 0.03852773f, -0.02210902f, 0.14569452f, 0.10047016f, 
    -0.04417923f, 0.11100516f, -0.06834764f, 0.15223171f, 0.27816287f, 0.05648664f, -0.16715007f, -0.05058345f, 
    -0.04450404f, -0.04439660f, 0.04773358f, 0.11995099f, -0.21592313f, -0.25373739f, -0.08745496f, -0.00194586f, 
    0.13007696f, -0.20258732f, -0.08472791f, 0.00036462f, 0.13708736f, 0.14147207f, -0.13469723f, 0.12816805f, 
    -0.25409251f, -0.06295698f, -0.08070773f, -0.28046504f, -0.03661820f, 0.08359041f, 0.08251026f, -0.03308154f, 
    0.14211856f, -0.00649190f, 0.02634582f, 0.00876823f, -0.43053135f, -0.17066503f, -0.02524374f, -0.21043439f, 
    0.03553092f, -0.04633542f, 0.06699411f, -0.07221090f, 0.02281888f, 0.10584988f, 0.10135748f, -0.01739389f, 
    -0.04014051f, -0.11478633f, 0.06541486f, -0.23536250f, -0.07448235f, -0.08717941f, 0.00136583f, 0.08909541f, 
    -0.01908608f, -0.17756753f, 0.05973721f, -0.07114023f, 0.17198224f, -0.14610524f, 0.07090236f, 0.36920008f, 
    -0.02956752f, -0.07577953f, 0.05406774f, -0.01325851f, -0.23337218f, 0.12629104f, -0.05961915f, 0.02095100f, 
    0.31192720f, -0.18372855f, -0.49762073f, 0.11819614f, 0.01384072f, -0.00665270f, -0.03800932f, 0.00429183f, 
    0.15825526f, -0.09090466f, -0.04256501f, 0.05912600f, 0.11269542f, 0.16955210f, 0.23377460f, 0.02789953f, 
    0.08520260f, 0.06588645f, 0.08567803f, 0.14678350f, 0.12532793f, -0.01844591f, -0.01640804f, 0.00194219f, 
    -0.11097438f, -0.19541360f, -0.18077196f, -0.00176929f, 0.11472094f, -0.00787524f, -0.02479868f, 0.06697571f, 
    0.10816219f, -0.08149315f, -0.05737721f, -0.03861699f, 0.04345135f, 0.10170569f, 0.09684686f, -0.01285377f, 
    0.03149554f, 0.21519279f, 0.09190238f, -0.23704934f, 0.05727455f, 0.00157311f, 0.00720684f, 0.02800608f, 
    -0.36011460f, 0.00461822f, -0.09444791f, -0.38066408f, 0.06292141f, 0.00443832f, 0.05361865f, 0.08689385f, 
    -0.03864031f, -0.03711655f, -0.03215822f, 0.02340877f, 0.26805899f, 0.01220417f, 0.14862888f, -0.00235325f, 
    -0.21697016f, -0.08808912f, -0.02730623f, -0.00390151f, 0.00913133f, -0.02873199f, 0.07790185f, 0.00489114f, 
    0.17626518f, -0.07822197f, -0.11811608f, 0.05839571f, -0.19002970f, 0.03381226f, -0.02147433f, 0.03655907f, 
    0.17116140f, 0.12807816f, 0.11741935f, 0.10615797f, -0.04113238f, 0.14220482f, 0.08787949f, -0.21110061f, 
    0.13655651f, 0.13336889f, 0.17233993f, 0.08120075f, 0.11652127f, 0.03296217f, 0.04025834f, 0.08055803f, 
    0.14122529f, 0.05800653f, -0.29517075f, 0.07236098f, -0.11276493f, 0.01465822f, -0.00548301f, -0.04649657f, 
    -0.22261877f, -0.01878653f, -0.04804904f, -0.20703733f, 0.17660612f, -0.26530066f, 0.20160031f, 0.02396035f, 
    0.11762901f, -0.04978145f, 0.00574071f, 0.25834724f, 0.02143060f, -0.01433014f, 0.04891742f, -0.00180578f, 
    -0.32763341f, -0.12999454f, 0.22690453f, 0.31549472f, 0.04956979f, 0.01166042f, -0.05404069f, 0.09763207f, 
    0.05462991f, 0.01041681f, -0.09829970f, -0.18956235f, 0.02996041f, -0.18973601f, -0.04533402f, 0.07156099f, 
    -0.03235881f, -0.03453097f, -0.01667559f, -0.07701538f, -0.07517930f, -0.02344377f, 0.00033687f, 0.30556926f, 
    0.08355875f, -0.10154390f, -0.39185461f, -0.01234530f, 0.03929315f, -0.03969053f, -0.04585413f, 0.00466133f, 
    0.08799902f, 0.09208988f, 0.00585531f, -0.06944235f, 0.13083372f, -0.06890216f, 0.00714393f, 0.11559740f, 
    0.03847079f, 0.06912968f, 0.04041206f, 0.02812678f, -0.02823268f, 0.04684237f, 0.03225664f, -0.48769817f, 
    0.04748958f, -0.13214342f, 0.11048069f, -0.03260029f, -0.04096454f, 0.06151443f, -0.01853981f, 0.01130211f, 
    -0.05134220f, 0.23066455f, 0.11952400f, -0.02080321f, -0.06532075f, -0.13790746f, -0.28156063f, -0.02075451f, 
    0.07076440f, 0.13075919f, -0.08373104f, 0.06433834f, 0.03375420f, -0.05141653f, -0.02747676f, -0.00620325f, 
    -0.00572329f, -0.23646127f, -0.02196564f, -0.06772780f, -0.00585235f, -0.09566810f, 0.07888819f, 0.10629431f, 
    -0.11209423f, -0.29389399f, 0.03135702f, -0.18354684f, 0.02900592f, -0.38853198f, 0.27006719f, 0.27579892f, 
    0.05668682f, 0.11985978f, -0.03917400f, -0.07476456f, 0.05839843f, -0.04742374f, 0.06719038f, 0.13723175f, 
    0.21057019f, -0.02126048f, 0.14301218f, -0.01666173f, -0.11179581f, -0.06951242f, 0.12258133f, 0.00206568f, 
    0.11648368f, 0.04413421f, 0.16939655f, -0.02183047f, 0.06944539f, 0.12514342f, -0.13574269f, -0.09016233f, 
    -0.16332053f, -0.04361087f, -0.12681520f, -0.17180409f, -0.19054297f, -0.08823591f, 0.01558499f, -0.02604194f, 
    -0.28554133f, -0.15328972f, 0.41123712f, 0.15846473f, -0.01905805f, -0.15944572f, -0.08804704f, 0.06540003f, 
    -0.06371595f, -0.06992247f, 0.07873698f, 0.00968130f, -0.04322691f, -0.38707152f, 0.18802407f, 0.09839083f, 
    -0.02670927f, 0.01397132f, 0.04668659f, 0.03753506f, 0.00967857f, 0.10214167f, 0.03776044f, -0.11131724f, 
    -0.42681822f, 0.15900478f, -0.36096206f, -0.07602087f, 0.05505049f, -0.05465684f, -0.10601450f, 0.01401499f, 
    0.08268228f, 0.11127261f, -0.09618487f, -0.09486058f, -0.27016944f, -0.11123604f, -0.13300748f, 0.05588070f, 
    -0.03776247f, -0.08050072f, -0.05234035f, -0.13923548f, 0.25579718f, 0.05067061f, 0.13047653f, -0.11290308f, 
    -0.22873166f, -0.09981973f, -0.01950750f, 0.07759731f, -0.00128301f, -0.00858241f, 0.03487790f, -0.04443775f, 
    0.04869059f, -0.00195241f, 0.10590352f, 0.02060996f, -0.31965554f, 0.32106578f, -0.38746902f, -0.13075402f, 
    0.02811811f, 0.04566213f, -0.02112611f, 0.08796581f, 0.19076574f, 0.04008171f, -0.05572597f, 0.05048276f, 
    0.22448075f, -0.08978259f, -0.07526488f, 0.00972109f, -0.13866986f, 0.02738426f, -0.10915750f, 0.03127136f, 
    0.08315220f, -0.07835480f, 0.01581349f, 0.18622975f, -0.01559267f, -0.26889485f, 0.21285979f, 0.12355265f, 
    0.01744499f, 0.09725111f, 0.20921041f, 0.11420402f, -0.03081456f, -0.09516636f, -0.10870647f, -0.03992994f, 
    0.00414013f, 0.30350631f, -0.08681492f, -0.46236858f, -0.00230369f, -0.12235954f, -0.01557339f, 0.17332667f, 
    0.11584014f, 0.06251484f, -0.14791378f, -0.05190098f, -0.18200244f, 0.09868208f, -0.20120631f, -0.34812027f, 
    0.03062815f, 0.00167372f, 0.06194997f, -0.02536102f, 0.05365759f, -0.11894875f, -0.25134096f, -0.36715344f, 
    -0.19960071f, -0.06771763f, 0.19632326f, -0.42586881f, -0.14507845f, -0.04201945f, 0.02277377f, 0.03559687f, 
    -0.04801081f, 0.03523163f, -0.00178256f, -0.04324765f, -0.07714236f, -0.14890057f, 0.11375349f, 0.32468623f, 
    0.14944221f, -0.00873135f, -0.13298671f, -0.00013708f, 0.29595992f, -0.17806639f, -0.05983244f, -0.15851973f, 
    0.09391423f, 0.07514883f, -0.02129296f, 0.05474662f, 0.04161809f, 0.02511514f, -0.02146802f, -0.07769200f, 
    -0.06184730f, -0.07604904f, 0.03569305f, 0.00423506f, -0.25436020f, -0.74123335f, -0.85391611f, -0.09517944f, 
    -0.00451678f, 0.06245893f, 0.08783609f, -0.00501174f, -0.00667514f, -0.04004978f, -0.02077238f, 0.00287421f, 
    -0.29783869f, -0.50612950f, 0.07035927f, 0.26541084f, -0.03928960f, -0.06025396f, 0.18934800f, 0.07731044f, 
    0.03957683f, 0.14891960f, -0.09703112f, -0.02595485f, -0.31630284f, -0.18276358f, 0.04986526f, 0.10389137f, 
    -0.01258551f, -0.02019205f, -0.04483279f, -0.00719374f, -0.00897521f, 0.00325200f, -0.17101294f, 0.01994164f, 
    -0.11272956f, -0.29411146f, -0.21490015f, -0.08461186f, -0.06894568f, -0.20113507f, 0.01247387f, 0.02466186f, 
    -0.04881976f, 0.02776233f, -0.05758923f, 0.04639018f, -0.03540252f, -0.12678835f, -0.11696156f, -0.10662421f, 
    -0.04550159f, 0.01975855f, -0.02123159f, -0.02996518f, -0.04177079f, -0.04105205f, -0.17069589f, -0.04245783f, 
    0.13462175f, 0.27208111f, 0.06925833f, 0.06700685f, -0.04806201f, -0.08003659f, 0.03989366f, -0.04664366f, 
    0.12130193f, 0.10114788f, -0.06600132f, -0.07090992f, -0.19790998f, -0.17834334f, 0.05705184f, 0.04436973f, 
    0.07312638f, 0.05548263f, -0.01820903f, -0.06461355f, 0.00485013f, -0.05054205f, 0.13711943f, -0.09811770f, 
    -0.83357310f, -0.70358896f, 0.15977094f, 0.08968116f, -0.03932782f, 0.04562476f, -0.13558172f, -0.35317239f, 
    -0.05820305f, -0.02425166f, -0.05841394f, 0.03357793f, -0.06505079f, -0.16842608f, 0.07020462f, 0.35421050f, 
    0.17482764f, 0.04704605f, 0.00498988f, -0.05404646f, -0.14445172f, -0.01567019f, -0.05197460f, 0.07209526f, 
    0.02538223f, -0.24450471f, 0.17566749f, 0.81808054f, -0.11366776f, -0.08663009f, 0.12710053f, -0.03922737f, 
    -0.00597096f, -0.03733457f, 0.02082026f, -0.20385650f, 0.36661750f, 0.16307743f, 0.19737412f, -0.15135717f, 
    0.04333246f, -0.08854692f, 0.17423229f, -0.02068714f, 0.15884356f, 0.04427559f, -0.02088450f, 0.04736109f, 
    0.29478350f, -0.09995452f, -0.13147961f, -0.00803047f, -0.03720471f, -0.00565972f, 0.05785397f, 0.07827231f, 
    0.07298280f, 0.24128713f, 0.18265854f, 0.10569369f, -0.42284897f, -0.26911274f, -0.35291550f, 0.01858024f, 
    0.04293994f, 0.14682178f, 0.11809471f, 0.06460524f, -0.01203702f, 0.00889274f, 0.00108667f, 0.08751217f, 
    0.34734356f, -0.17684668f, -0.01472461f, 0.05286353f, 0.08845651f, -0.13425040f, 0.13589182f, -0.06281961f, 
    0.01758605f, -0.07284417f, -0.05598103f, 0.04687821f, 0.14583263f, -0.35878846f, -0.20692879f, -0.14820948f, 
    0.07014100f, 0.19289327f, 0.19352658f, -0.07792138f, -0.03310924f, -0.02293899f, -0.05798956f, 0.01323259f, 
    -0.19125256f, -0.06528118f, 0.22002709f, 0.06753473f, -0.04245245f, -0.00024696f, 0.08731083f, -0.04771943f, 
    0.06874835f, 0.09810940f, 0.03649746f, 0.07959504f, 0.10795441f, 0.05078780f, -0.06024389f, -0.04504369f, 
    -0.02913204f, -0.05875163f, 0.05715385f, -0.10384948f, -0.11138918f, -0.00439049f, -0.04077052f, -0.00890840f, 
    -0.01276998f, 0.06802711f, 0.03379957f, -0.06486903f, 0.03557738f, -0.01665524f, 0.08039534f, 0.03347293f, 
    -0.06432638f, 0.12709104f, -0.02930418f, -0.01269157f, 0.20535699f, 0.23807375f, -0.37360892f, -0.27804932f, 
    -0.02334259f, 0.03845144f, -0.09308458f, -0.04940943f, 0.10805474f, -0.08372474f, -0.05303594f, 0.05253518f, 
    -0.00088566f, -0.11662748f, 0.04836616f, 0.14237200f, 0.06375516f, 0.04227847f, 0.01092440f, -0.08974403f, 
    -0.03190246f, 0.16401659f, 0.05255460f, 0.01482770f, -0.13009425f, 0.10533859f, -0.03944699f, -0.16437225f, 
    -0.00246816f, 0.00710114f, 0.06020307f, -0.02163652f, 0.00358451f, -0.04215732f, -0.05245336f, 0.05433454f, 
    0.06711087f, 0.04261491f, 0.09471253f, 0.05072865f, 0.01224379f, -0.01550873f, 0.01026990f, -0.00281053f, 
    -0.04628486f, 0.05151748f, 0.00333567f, -0.07384527f, -0.08211151f, -0.08960235f, 0.18840450f, 0.02953690f, 
    0.06430946f, 0.10076692f, 0.00531581f, 0.03078482f, 0.03946015f, -0.09801120f, 0.08559807f, 0.05308928f, 
    -0.43508038f, -0.45188612f, -0.46390021f, -0.13205017f, -0.22787145f, -0.02519887f, -0.19351596f, -0.05225449f, 
    0.04074964f, -0.00950752f, 0.01441546f, 0.06488797f, -0.10871650f, 0.09725253f, 0.26361308f, 0.19448884f, 
    -0.04239852f, -0.04902584f, -0.08387243f, 0.08726975f, -0.06007883f, 0.01639681f, 0.04270565f, 0.02833644f, 
    -0.24042878f, -0.35417548f, -0.45737645f, -0.36348155f, -0.12330910f, -0.18923897f, 0.06864016f, -0.38243315f, 
    0.06306100f, 0.01220467f, -0.01442045f, -0.04193913f, 0.00431762f, -0.14842105f, 0.17058206f, 0.13892660f, 
    -0.00849039f, -0.10605939f, -0.02737854f, 0.02755881f, -0.13887644f, 0.01899095f, 0.04687501f, 0.04699465f, 
    -0.66786468f, 0.25312454f, 0.49565041f, 0.32297659f, -0.03049764f, -0.19666559f, 0.01029617f, -0.09243485f, 
    -0.06024382f, 0.01832397f, -0.03557711f, 0.09601410f, 0.08694519f, 0.08056336f, 0.24857281f, -0.07231163f, 
    -0.00729215f, 0.03573778f, -0.05156953f, 0.11158274f, -0.01306562f, 0.20800932f, -0.04557903f, 0.06458415f, 
    -0.18875447f, 0.11091686f, -0.12079095f, 0.11542872f, 0.00633579f, 0.00814677f, 0.12641828f, 0.04325603f, 
    0.12330176f, 0.09188435f, 0.19839004f, -0.05337631f, 0.09497972f, 0.00973370f, -0.23392533f, 0.14614618f, 
    -0.09075505f, 0.02293189f, 0.14134882f, 0.16294648f, -0.01505694f, -0.00618765f, 0.06969961f, 0.01312897f, 
    0.15606974f, 0.16803436f, -0.00343060f, -0.03898398f, 0.03067757f, 0.01435820f, -0.04445599f, 0.00276957f, 
    -0.06733263f, 0.02632141f, 0.05755472f, -0.20241539f, -0.33368692f, -0.52404654f, -0.44181338f, -0.37201813f, 
    -0.11541101f, -0.05230990f, -0.00030250f, -0.07385287f, -0.01057387f, 0.01779568f, 0.03877444f, -0.02086579f, 
    -0.02772183f, -0.11744844f, 0.05646008f, -0.01734336f, 0.08716822f, 0.11824222f, 0.05280175f, -0.00838719f, 
    0.02663500f, -0.09488440f, -0.00190209f, -0.01982048f, -0.39529115f, -0.60555142f, -0.30981037f, -0.11546730f, 
    -0.14357671f, -0.15583044f, -0.31217000f, -0.15818793f, -0.00973337f, -0.04097192f, -0.00979149f, -0.04624485f, 
    -0.66373956f, -0.60186422f, 0.08987556f, -0.11554036f, -0.14029795f, -0.15168153f, 0.05531759f, -0.02042384f, 
    -0.05636460f, 0.07359318f, 0.00841216f, 0.03487968f, -0.31902182f, -0.18932916f, -0.16786294f, -0.11482751f, 
    -0.05747110f, 0.04077300f, 0.01952429f, -0.05990282f, -0.01749376f, -0.00386027f, 0.16919671f, 0.02361047f, 
    0.00540830f, -0.13131095f, 0.08415936f, 0.11209171f, -0.16839397f, 0.00361154f, 0.18404961f, 0.22922339f, 
    -0.01281628f, 0.12232494f, -0.20753823f, -0.14932057f, -0.38265413f, -0.56512910f, -0.34518778f, -0.23572165f, 
    -0.11744749f, -0.42202550f, -0.31968033f, -0.09657294f, -0.06205508f, -0.02503112f, -0.02937821f, -0.05429846f, 
    0.35428157f, -0.09030761f, -0.03508296f, -0.06902556f, -0.02159877f, -0.03935412f, 0.11518020f, 0.00311734f, 
    0.07013025f, -0.08235759f, 0.00438292f, 0.05624099f, -0.13420215f, -0.38450512f, -0.11528148f, 0.11890344f, 
    -0.04884796f, -0.08412863f, 0.02965448f, 0.03550869f, 0.02028801f, -0.02902852f, 0.03121976f, -0.05962892f, 
    -0.03037594f, -0.07190088f, 0.15558454f, -0.14649566f, -0.03384599f, 0.11774220f, -0.06912374f, 0.08127304f, 
    0.06442523f, 0.11936138f, 0.08333584f, 0.02858628f, -0.15101264f, 0.01180809f, 0.08605886f, 0.09841363f, 
    -0.01418413f, -0.06931250f, -0.03425341f, 0.01629706f, -0.14708818f, -0.09139837f, -0.18069631f, 0.07225123f, 
    -0.05489688f, 0.05454270f, -0.08551528f, -0.22289988f, 0.04879160f, -0.00435742f, 0.08008598f, -0.02762989f, 
    0.06254095f, 0.05773506f, -0.14397565f, 0.01485980f, 0.00804362f, 0.01388857f, -0.02352040f, -0.07953180f, 
    0.00957650f, 0.03280420f, 0.02769161f, -0.01030317f, -0.09197401f, -0.04973923f, -0.12694354f, -0.04603237f, 
    -0.14135537f, 0.18144405f, 0.25277334f, 0.05110699f, -0.08315343f, -0.00030547f, -0.05203341f, -0.06776072f, 
    -0.03496255f, -0.09376056f, 0.06146366f, 0.02546876f, 0.07085252f, -0.33124435f, -0.17323819f, -0.05581455f, 
    0.04516602f, 0.14283769f, 0.17489690f, -0.05305875f, 0.01686286f, -0.00225590f, -0.00851162f, 0.03892470f, 
    -0.10770875f, 0.16496606f, 0.03523304f, 0.07312381f, -0.00838164f, 0.06395362f, 0.04398234f, -0.05124401f, 
    0.01306398f, 0.09518820f, 0.21263619f, 0.06110556f, 0.15498829f, 0.08787505f, -0.25758827f, 0.13134052f, 
    0.05459065f, -0.02867611f, 0.03794628f, -0.04676807f, 0.02449131f, 0.04622828f, 0.11669254f, -0.09013011f, 
    -0.12126548f, -0.10667701f, -0.04002967f, 0.15383126f, -0.04582668f, 0.04887754f, -0.08272511f, 0.01059135f, 
    0.02763740f, 0.08985274f, -0.13367817f, -0.10920222f, -0.20897336f, -0.16623546f, -0.12855124f, 0.11502659f, 
    -0.02055000f, 0.03981024f, 0.05679734f, -0.28735051f, 0.01130894f, 0.00586786f, 0.08087344f, 0.08850205f, 
    -0.05227261f, -0.37380722f, -0.22728194f, 0.26166263f, -0.16268861f, 0.10118195f, -0.08523532f, 0.01337417f, 
    0.00660973f, 0.05609174f, 0.01123156f, -0.07586402f, -0.01144440f, -0.06198601f, 0.00516845f, -0.02728494f, 
    0.02266308f, 0.09721954f, 0.04378722f, -0.05020371f, -0.03528361f, -0.07877783f, -0.02283099f, 0.11963289f, 
    -0.42753342f, 0.05336320f, 0.40243241f, 0.09921638f, -0.02154575f, -0.01162332f, 0.00611375f, -0.00413875f, 
    -0.07506548f, 0.13677382f, 0.13029674f, 0.06656802f, -0.35575178f, 0.15456955f, 0.31553859f, -0.11793990f, 
    -0.11432264f, 0.02715035f, -0.16156486f, 0.07338152f, -0.10058057f, 0.12285051f, 0.08240804f, -0.05832890f, 
    0.00671467f, 0.12916729f, -0.11282785f, 0.07785427f, 0.01589622f, 0.03386466f, -0.04687408f, 0.08891272f, 
    -0.17920740f, 0.02863253f, 0.13628908f, -0.08791644f, 0.09609696f, 0.01010739f, 0.21362799f, -0.08328678f, 
    -0.00538869f, 0.01153277f, 0.06471658f, -0.08046422f, 0.04812444f, 0.00320302f, 0.01680409f, -0.00533681f, 
    0.22411203f, 0.12541157f, -0.20156798f, 0.33689517f, -0.00690261f, -0.06096242f, 0.05428968f, 0.17877638f, 
    0.06654867f, 0.01908493f, -0.02934598f, -0.35541534f, -0.07897519f, 0.14252169f, -0.62173140f, -0.42269030f, 
    -0.01945412f, -0.16568127f, -0.12127646f, 0.11131896f, -0.04037891f, -0.08515631f, 0.16662180f, -0.07465424f, 
    -0.68262750f, -0.65445530f, -0.08728845f, 0.44550982f, 0.19193481f, 0.10514974f, 0.05411142f, -0.00674250f, 
    0.05458802f, 0.07375215f, 0.06292672f, 0.05640895f, -0.14149410f, -0.01283506f, 0.13462022f, -0.07759356f, 
    -0.04468958f, 0.03321362f, 0.05616765f, -0.01648436f, 0.12211797f, 0.04206990f, 0.12996063f, 0.06206020f, 
    -0.29443601f, 0.28168187f, -0.00437624f, 0.00755294f, 0.13612127f, 0.06394107f, -0.07122735f, -0.09303171f, 
    0.13533169f, 0.08903910f, 0.01515213f, 0.05156975f, -0.32900822f, -0.12124234f, 0.14037198f, 0.25821793f, 
    0.04399320f, 0.25037029f, -0.10960615f, -0.10374334f, 0.17950512f, -0.02808436f, 0.05435864f, 0.05191738f, 
    0.02064456f, -0.00129370f, 0.05534743f, -0.13855386f, 0.01304279f, 0.01171109f, -0.02224834f, -0.01755694f, 
    0.03065795f, 0.08048889f, 0.02611702f, -0.02580952f, -0.26541945f, -0.33770424f, -0.10812373f, 0.28577819f, 
    0.08969780f, 0.05153780f, -0.08785491f, -0.10291535f, 0.03157216f, -0.07343701f, -0.03589321f, 0.03468059f, 
    -0.09699572f, -0.58614606f, 0.18183163f, -0.12403930f, -0.05964591f, 0.08226404f, -0.09350959f, 0.09792720f, 
    -0.03393979f, 0.00740309f, 0.07829001f, -0.01103463f, -0.05396614f, 0.00853649f, 0.12937772f, -0.12771936f, 
    0.01957791f, 0.11327766f, 0.00334222f, 0.05016788f, -0.04284305f, 0.01302336f, -0.03229322f, -0.06533386f, 
    0.27035141f, -0.25163937f, -0.06115207f, 0.28947130f, 0.05571188f, -0.05945468f, 0.06825543f, -0.10991050f, 
    0.02539756f, 0.03354340f, -0.02888350f, -0.05039142f, -0.01988005f, 0.00321770f, 0.03458146f, -0.04611065f, 
    0.02459051f, -0.06305185f, 0.02815044f, -0.00216931f, -0.01336488f, -0.02264553f, 0.02969782f, 0.05125780f, 
    -0.15475376f, -0.27266294f, -0.25049484f, -0.05444195f, -0.00760536f, -0.01220474f, -0.01473228f, -0.06712383f, 
    -0.11350214f, -0.01994460f, 0.18116699f, -0.00452647f, -0.05055201f, -0.09782727f, 0.06956059f, -0.04899897f, 
    0.11230775f, 0.17764972f, 0.00242450f, 0.03072909f, -0.06979693f, -0.08552267f, 0.15338528f, -0.03987953f, 
    -0.26172334f, -0.77036124f, 0.23442751f, 0.31942242f, 0.08361017f, -0.03269713f, 0.04155056f, 0.08894830f, 
    0.06717788f, 0.01771735f, -0.05500212f, -0.00980394f, 0.16165230f, -0.29021895f, 0.05585281f, -0.44913149f, 
    -0.04117563f, 0.09108578f, -0.05683564f, 0.05775892f, -0.14880328f, 0.04899395f, 0.05973240f, -0.23027559f, 
    -0.28669164f, -0.01427583f, -0.29203242f, 0.23771532f, -0.02659143f, 0.27740303f, -0.02759590f, -0.03362868f, 
    0.03576182f, -0.04142459f, 0.11666347f, 0.06977729f, -0.16933826f, 0.38990623f, -0.12009080f, 0.31204820f, 
    -0.07772125f, 0.09822165f, 0.11707448f, 0.01129062f, -0.11938182f, 0.04798160f, 0.14165536f, 0.02427566f, 
    0.00630745f, -0.23764671f, 0.14597601f, 0.00168717f, -0.03409903f, 0.04737605f, 0.02901079f, 0.02650239f, 
    0.10809414f, 0.03165526f, 0.03966508f, 0.05389111f, 0.03847941f, 0.05241450f, -0.17255150f, 0.07485837f, 
    -0.04497422f, -0.12842825f, 0.12011341f, 0.05688825f, -0.01740475f, 0.01069757f, -0.01996544f, -0.07969693f, 
    -0.07926796f, -0.00180887f, 0.04811023f, 0.02334349f, -0.14197415f, 0.02583401f, 0.09118699f, -0.11361930f, 
    0.06397764f, 0.00488094f, 0.02014859f, 0.06334084f, -0.25164807f, 0.19565372f, -0.08262505f, -0.02108821f, 
    -0.05290093f, -0.08728018f, -0.12148291f, 0.03899715f, 0.07320625f, 0.04206321f, 0.04092446f, 0.00137355f, 
    0.19274616f, -0.41534588f, -0.03592918f, -0.03937492f, -0.05499816f, -0.11899867f, -0.05775490f, 0.03750657f, 
    0.20972644f, 0.05050455f, 0.11472929f, 0.06691411f, 0.03137250f, 0.09711638f, -0.00216805f, 0.00710371f, 
    -0.02010758f, -0.01920172f, -0.00178267f, -0.07692005f, -0.16591464f, -0.15529764f, -0.00777927f, -0.00863550f, 
    0.07586356f, 0.01123906f, -0.03023656f, -0.05266707f, -0.03268252f, 0.00648805f, -0.02530758f, -0.14801639f, 
    -0.13830391f, -0.02962867f, -0.02668247f, 0.01817529f, -0.01426740f, -0.34241915f, -0.12637965f, 0.28587154f, 
    0.13190363f, 0.07065027f, 0.07117343f, 0.04580617f, -0.10015535f, -0.04584074f, 0.03564311f, 0.02528353f, 
    -0.03052816f, -0.13501306f, 0.16597307f, -0.09546067f, -0.01373496f, -0.08908582f, -0.00777254f, -0.10851920f, 
    -0.08277816f, -0.09937893f, 0.12143843f, 0.01899604f, -0.07174062f, 0.08883153f, 0.06019525f, 0.14954302f, 
    0.04177681f, 0.01073778f, -0.01244542f, -0.09246643f, -0.01688032f, 0.07145958f, 0.03957504f, 0.03027273f, 
    0.19327071f, 0.02192090f, -0.10011695f, -0.11424421f, 0.02413264f, -0.03043132f, -0.02307589f, 0.04896162f, 
    -0.02924381f, 0.01622248f, -0.13045384f, -0.04774516f, 0.10466041f, 0.09543569f, 0.06865439f, -0.14246969f, 
    0.02598323f, 0.00956437f, 0.03015346f, -0.00398120f, -0.05891956f, -0.00523453f, -0.11928782f, -0.43223804f, 
    -0.39915642f, -0.11426584f, -0.06735773f, -0.12211061f, 0.06938740f, -0.01092887f, 0.20602621f, 0.17336509f, 
    -0.01329227f, -0.02121080f, -0.07983615f, -0.09609651f, 0.32781422f, 0.02558557f, -0.15721925f, -0.15794103f, 
    -0.02151453f, -0.05658839f, -0.03212682f, -0.04650620f, -0.04431216f, -0.06786752f, -0.13407503f, -0.19493957f, 
    -0.48158813f, -0.00434845f, -0.24739043f, 0.29026347f, 0.08744203f, -0.10250897f, 0.06502473f, 0.09526630f, 
    0.02853213f, 0.10128313f, -0.03503140f, 0.01485548f, 0.20350228f, 0.02686453f, 0.02170022f, -0.05296876f, 
    -0.10669097f, 0.14520444f, 0.01964922f, 0.05291322f, -0.02975607f, 0.09937011f, 0.05000956f, 0.05714390f, 
    -0.03119835f, -0.65301102f, -0.58772767f, -0.56932294f, -0.04906067f, -0.12282547f, -0.10381228f, 0.04848256f, 
    0.05943360f, -0.01589449f, 0.06373080f, 0.09792579f, 0.24638470f, 0.02805509f, -0.15426227f, -0.15358873f, 
    0.03803423f, -0.01795360f, 0.00087853f, 0.02014726f, 0.03738464f, -0.10944372f, -0.20319003f, -0.18410344f, 
    -0.30782777f, -0.45018366f, 0.05960906f, 0.09052464f, 0.07287990f, 0.05090753f, 0.19347909f, -0.05224641f, 
    0.00123077f, 0.08176118f, 0.08467454f, -0.00773550f, 0.17562179f, -0.14947575f, -0.02682099f, -0.15229353f, 
    -0.13772136f, 0.04205009f, -0.11144375f, -0.06530257f, -0.11011877f, 0.08320587f, 0.00007807f, -0.02866643f, 
    -0.03628334f, 0.06789012f, 0.10465548f, 0.07292771f, 0.05314709f, 0.07109736f, -0.02505103f, -0.06143398f, 
    0.04186809f, -0.01610139f, -0.01884053f, -0.05953307f, -0.33287475f, -0.32304853f, 0.21656831f, 0.43349287f, 
    -0.05268375f, -0.08416767f, -0.10087063f, 0.13379313f, -0.06699654f, -0.05815921f, -0.14600077f, -0.00651343f, 
    0.02486257f, 0.10845208f, 0.03176625f, -0.05305349f, -0.03413430f, 0.01540237f, 0.01016278f, -0.03190137f, 
    0.00823274f, -0.01973966f, 0.02055709f, -0.02549222f, -0.35890371f, -0.26310346f, -0.19898766f, 0.24943218f, 
    -0.04373905f, -0.06135637f, -0.01115612f, 0.13266066f, -0.00704289f, 0.01195082f, -0.03207521f, 0.00116128f, 
    0.18047509f, -0.48923364f, -0.26074660f, -0.48789436f, -0.08710333f, 0.02110982f, -0.06909426f, 0.30292416f, 
    0.06506918f, 0.00260065f, -0.01526758f, -0.02271540f, -0.33891651f, -0.36421487f, -0.16788386f, 0.03036980f, 
    0.02332103f, 0.09381721f, 0.08481652f, -0.03752992f, -0.06373552f, -0.02663016f, 0.05266738f, 0.02605943f, 
    0.11502031f, -0.14262095f, 0.04252531f, 0.07563403f, -0.16662258f, -0.03407509f, -0.04179979f, -0.00972170f, 
    -0.01007171f, -0.08380149f, -0.01435230f, -0.07158429f, -0.36631015f, -0.32784492f, -0.11449050f, 0.15069871f, 
    -0.00425069f, -0.13265406f, 0.00662795f, -0.02999114f, 0.03884902f, 0.01902258f, -0.00368025f, 0.03445589f, 
    -0.11118224f, 0.01550937f, -0.02296373f, 0.03833506f, -0.00726155f, 0.02701916f, -0.01915794f, 0.08130231f, 
    -0.00859904f, -0.10868501f, 0.05626293f, 0.02803172f, 0.20137554f, -0.12957023f, 0.03536341f, -0.03945072f, 
    -0.09689081f, -0.06454077f, -0.03686239f, -0.17735681f, 0.01553209f, 0.03237123f, 0.06268083f, -0.04052656f, 
    0.28372943f, 0.11334009f, 0.00837168f, -0.02188867f, -0.00240506f, 0.01336785f, 0.03930970f, 0.00344210f, 
    -0.13979994f, -0.07070672f, -0.17560539f, -0.16453809f, 0.06817486f, 0.12219901f, -0.11232983f, -0.07394434f, 
    0.01673637f, 0.07396515f, 0.04777037f, -0.00365985f, -0.12580727f, -0.04138008f, -0.00760931f, -0.16262245f, 
    -0.04902417f, 0.10337762f, -0.03582709f, 0.05702051f, 0.03397425f, -0.01886541f, -0.00670807f, 0.03607404f, 
    0.05295444f, 0.00417350f, -0.02282335f, -0.06708317f, 0.06265732f, 0.04798233f, 0.06855536f, -0.04380869f, 
    -0.01329974f, -0.03716072f, -0.03294927f, 0.00324779f, 0.00878318f, 0.00202928f, -0.01376159f, -0.01161648f, 
    0.29128891f, -0.12757632f, -0.07924502f, 0.11128879f, -0.00685015f, -0.19493410f, -0.04399635f, -0.03014857f, 
    -0.02733589f, 0.10848492f, 0.01031352f, 0.02589409f, -0.20882162f, 0.08462691f, -0.13323365f, -0.03854323f, 
    -0.00285700f, -0.09935319f, -0.13518828f, -0.03444408f, 0.07400957f, 0.06609747f, 0.06745590f, 0.01250366f, 
    0.11410289f, -0.24934795f, 0.06690916f, -0.19811389f, -0.04277549f, -0.07252113f, -0.04949986f, -0.02493022f, 
    0.04525522f, 0.06502546f, 0.05353944f, -0.05204974f, 0.55930358f, -0.35966414f, 0.59108365f, -0.39085224f, 
    0.00051066f, 0.05672465f, -0.10694197f, 0.11999132f, -0.06900233f, 0.04395082f, -0.08802781f, -0.01432546f, 
    0.21835785f, -0.06804501f, 0.16046508f, -0.08716340f, -0.06984065f, 0.17560567f, -0.07657900f, -0.04743060f, 
    0.01670731f, -0.03859074f, 0.05933330f, -0.04684381f, -0.20523830f, 0.22010213f, 0.18585062f, -0.20762490f, 
    -0.07672076f, 0.02514891f, 0.25385323f, 0.12555614f, -0.16452652f, 0.03454113f, -0.11344587f, -0.09793388f, 
    0.55158734f, -0.43329525f, 0.04344603f, -0.10944206f, 0.04877255f, -0.04886665f, -0.29919279f, 0.14110042f, 
    0.02426894f, 0.03756968f, -0.05461714f, 0.00238310f, 0.05477470f, -0.00499117f, -0.00739280f, -0.02135967f, 
    -0.04858286f, -0.03870572f, -0.04625052f, -0.10248367f, 0.05506519f, -0.05139269f, 0.05567466f, 0.01182372f, 
    0.37405986f, 0.11920645f, -0.31910431f, -0.18196559f, -0.02362672f, -0.04083408f, -0.04400028f, -0.02591951f, 
    -0.01393256f, 0.17497538f, 0.04762821f, 0.01844995f, 0.51651323f, 0.08448789f, -0.39038914f, -0.57823879f, 
    0.02141145f, -0.09961814f, -0.01864791f, 0.02947186f, -0.08020137f, 0.01816155f, 0.01077787f, -0.05682995f, 
    0.08971781f, -0.04130596f, -0.01973283f, -0.03486879f, 0.05153025f, -0.02681190f, -0.01371944f, -0.07040367f, 
    0.00197892f, -0.01069319f, -0.09685030f, -0.21079035f, -0.01664455f, 0.16827194f, -0.05150538f, 0.07497491f, 
    -0.02997727f, -0.03477523f, 0.11487356f, -0.01576521f, 0.03359902f, -0.16264516f, -0.09603466f, -0.26894391f, 
    -0.19986419f, -0.12155059f, 0.02783412f, -0.08489226f, -0.07106809f, 0.06400342f, 0.08925841f, -0.06728055f, 
    -0.00881353f, 0.10831936f, 0.05383449f, 0.01989684f, 0.06400350f, -0.10510261f, -0.11747857f, 0.39384952f, 
    -0.10747319f, 0.14702472f, 0.03972699f, -0.19723679f, 0.02849402f, 0.05368425f, 0.04729645f, -0.02974169f, 
    0.11994384f, 0.00351413f, 0.31176281f, -0.12247153f, 0.05928618f, -0.18912579f, 0.05576587f, 0.02028719f, 
    0.05328789f, 0.01467941f, 0.03262796f, 0.01929766f, 0.16798542f, -0.12160198f, -0.39871371f, 0.16926633f, 
    -0.00521050f, -0.11636308f, 0.00281161f, -0.07891062f, 0.19616252f, -0.07818595f, -0.01546692f, 0.07303742f, 
    -0.18787181f, -0.23130459f, 0.19709310f, -0.00470602f, 0.04473869f, 0.00175192f, 0.20023626f, -0.01478166f, 
    -0.09155130f, 0.06863808f, -0.00529629f, 0.09426533f, 0.06842177f, 0.07736804f, -0.03980983f, -0.12807389f, 
    -0.00697073f, 0.00591092f, -0.16971232f, 0.04790663f, -0.14574136f, 0.06929274f, 0.03879149f, 0.01363182f, 
    0.05574701f, 0.02491343f, 0.10080713f, -0.10304428f, -0.06671527f, -0.04443093f, 0.01299381f, -0.01364157f, 
    -0.05091403f, -0.00119636f, 0.09771838f, -0.06050561f, 0.33574247f, -0.05725624f, 0.21439053f, 0.06328250f, 
    0.01153717f, 0.04171414f, -0.00418642f, -0.05490077f, 0.01845183f, 0.12707342f, -0.02469886f, -0.02652742f, 
    0.22390498f, -0.08339607f, 0.05741297f, -0.07629706f, -0.07108239f, -0.26863086f, 0.08531610f, 0.05867675f, 
    0.11530431f, 0.13419747f, 0.11284009f, 0.03534551f, 0.16820803f, 0.05615525f, -0.01462742f, -0.04856884f, 
    -0.09026892f, 0.04262037f, 0.04337386f, -0.14573115f, 0.07373445f, 0.04050099f, 0.04791495f, 0.04758701f, 
    0.50167966f, -0.08381471f, -0.30998057f, -0.21085158f, 0.02913676f, -0.07235622f, -0.02310993f, -0.05135503f, 
    0.12965398f, 0.09011503f, 0.15437928f, 0.08651546f, -0.20363887f, 0.04244041f, 0.08232213f, 0.06119423f, 
    0.02559754f, 0.00705797f, -0.00839959f, -0.02298466f, 0.08416186f, 0.05426640f, 0.00182196f, 0.04200643f, 
    -0.19358829f, -0.14191906f, -0.26428467f, -0.02928494f, 0.04721662f, 0.00984510f, 0.05724151f, 0.12419427f, 
    -0.12316330f, -0.10016409f, -0.11431431f, -0.04797908f, -0.04084222f, 0.07007503f, 0.02618863f, -0.13460702f, 
    -0.14674084f, 0.03897179f, 0.06803006f, -0.06267121f, 0.00770419f, 0.01195353f, -0.14198689f, -0.03105635f, 
    0.20919748f, -0.09914201f, -0.42753130f, -0.08660601f, -0.07614193f, 0.03617965f, 0.16693601f, -0.10124505f, 
    0.01000408f, -0.03127451f, -0.01043129f, 0.02063507f, 0.25120482f, 0.01569505f, 0.02591148f, -0.16517688f, 
    -0.06314756f, -0.25489280f, -0.04078028f, -0.03253502f, 0.00460138f, -0.16825160f, 0.13265038f, 0.17679937f, 
    -0.06165275f, 0.27947569f, -0.12183890f, 0.32179722f, -0.04520829f, -0.02448295f, 0.00810274f, 0.11307324f, 
    -0.04151287f, -0.06234936f, 0.09611926f, 0.09399603f, -0.59639478f, -0.23853627f, 0.36867610f, 0.22963281f, 
    -0.12558997f, 0.06565642f, -0.10212722f, -0.01167257f, 0.03190223f, -0.16070086f, -0.00074653f, 0.06815523f, 
    -0.28786105f, -0.06436513f, 0.03212634f, -0.09601163f, 0.07721619f, -0.02064170f, -0.00557088f, 0.00762802f, 
    -0.37154928f, -0.10500275f, -0.15454166f, -0.40363017f, 0.61302918f, 0.11170176f, -0.10693333f, -0.10558501f, 
    0.07538682f, -0.06052658f, 0.07027192f, 0.02077293f, 0.07860588f, 0.05132572f, 0.00491485f, 0.08074933f, 
    -0.20446037f, -0.28993827f, 0.02459531f, 0.14471555f, -0.08511819f, 0.08724215f, 0.04141493f, 0.11678509f, 
    -0.10118840f, -0.05610926f, -0.04444980f, -0.08964626f, -0.26882073f, 0.10856308f, 0.23771618f, 0.08821093f, 
    0.08805086f, -0.03804447f, 0.03844787f, 0.00828060f, -0.07485601f, -0.02436788f, 0.05942179f, 0.07223400f, 
    -0.12408265f, -0.09127568f, -0.07941387f, -0.04057704f, 0.07853230f, 0.11122221f, 0.12662451f, 0.05456250f, 
    -0.34415269f, -0.05624887f, -0.29208484f, -0.55522496f, -0.10425162f, 0.01226523f, 0.00522210f, -0.02607214f, 
    -0.11209279f, -0.03231682f, 0.03156545f, -0.00901044f, 0.04471307f, 0.01647726f, -0.00100828f, 0.01002657f, 
    -0.01408498f, 0.06835243f, -0.02930385f, -0.01525358f, -0.01959407f, -0.04124393f, 0.04323773f, -0.02658889f, 
    0.11354338f, 0.01134474f, -0.01724873f, 0.07783668f, 0.07220384f, -0.06604754f, -0.08035706f, -0.07778703f, 
    0.07100867f, 0.02078464f, 0.00099728f, 0.03806725f, -0.03241359f, -0.05088555f, -0.03794238f, -0.01576726f, 
    0.06621024f, 0.14667039f, 0.01219780f, 0.04979632f, -0.06840887f, 0.05804959f, 0.09039155f, -0.19308567f, 
    0.03557948f, 0.04531404f, -0.07577711f, -0.04814898f, -0.35796157f, -0.03934568f, 0.18852219f, 0.05611669f, 
    -0.04522251f, -0.04038120f, -0.08615725f, -0.04563903f, -0.03272988f, 0.01436579f, -0.14708704f, -0.18040496f, 
    0.14816135f, -0.00844367f, 0.00995074f, -0.13595939f, -0.04458614f, -0.05098631f, -0.00252165f, -0.06907909f, 
    -0.02085888f, 0.04260949f, 0.11982536f, 0.08516601f, -0.08024202f, 0.07230915f, 0.04622198f, -0.10060345f, 
    -0.08145836f, -0.02588170f, 0.02395999f, -0.00191250f, -0.00130147f, 0.03380397f, 0.13216121f, 0.09096384f, 
    0.05438179f, -0.26368457f, -0.34419945f, -0.23419426f, -0.23240790f, -0.08660098f, -0.05434058f, -0.27705264f, 
    0.06442428f, -0.05319922f, 0.01654853f, 0.04122175f, -0.10986639f, -0.21942891f, -0.09993654f, -0.09439995f, 
    -0.06107863f, 0.02425455f, 0.03244575f, 0.02823257f, 0.21493590f, 0.09884398f, 0.07928331f, 0.04394454f, 
    -0.39047870f, -0.28121740f, 0.05422246f, 0.16985178f, 0.02483786f, 0.03063069f, -0.01753320f, 0.01286156f, 
    -0.01381486f, -0.02593870f, 0.00480737f, 0.02117191f, 0.00590580f, -0.09649429f, -0.11073930f, -0.04289550f, 
    -0.03167808f, 0.10230400f, 0.01056134f, 0.03126552f, 0.10548764f, 0.09842013f, 0.14261167f, 0.00947582f, 
    -0.49163646f, -0.67979813f, -0.43040520f, 0.28099194f, 0.13590145f, 0.25457919f, 0.16464841f, 0.12253260f, 
    -0.07334132f, 0.10626692f, 0.14199540f, -0.02011405f, 0.03148266f, -0.09648014f, -0.05751001f, -0.06234519f, 
    -0.03211217f, -0.02110904f, 0.07782054f, 0.04185706f, -0.04161136f, 0.07964034f, 0.00574022f, -0.02094851f, 
    -0.18278353f, -0.32542381f, 0.27460226f, 0.08782300f, -0.06994651f, -0.03810954f, 0.02762283f, -0.13299295f, 
    0.04092916f, 0.10381851f, -0.07122035f, 0.03862493f, 0.33421332f, 0.13938101f, 0.05136161f, -0.04070517f, 
    0.17640936f, 0.07371548f, -0.01684144f, -0.00725530f, -0.01919993f, -0.06194611f, 0.03254334f, 0.01717857f, 
    -0.35574982f, 0.20124075f, 0.08313258f, 0.06948722f, -0.04411514f, -0.02464719f, -0.02063491f, -0.00572078f, 
    0.00257731f, 0.10298209f, 0.02272497f, -0.00698664f, 0.20684232f, -0.13252893f, -0.32508221f, -0.50913608f, 
    -0.15725373f, -0.10797185f, -0.02707504f, -0.04983018f, 0.12620287f, 0.08280929f, 0.07585663f, 0.04789775f, 
    -0.28016394f, 0.03740253f, 0.15192522f, 0.04089914f, -0.10719090f, -0.03834657f, -0.02707112f, 0.01062127f, 
    0.03293973f, 0.00787949f, -0.01154629f, 0.06956998f, -0.19821160f, -0.40674374f, -0.26748738f, -0.14416115f, 
    -0.05758492f, -0.12300574f, -0.02212840f, -0.06493598f, 0.00312895f, 0.01790655f, 0.05958708f, 0.09346496f, 
    -0.23361228f, -0.16534707f, -0.56406742f, 0.00565633f, 0.12299011f, 0.03911971f, 0.14598159f, 0.02636142f, 
    -0.08123071f, -0.03889957f, -0.10207738f, -0.00430006f, 0.21069951f, -0.22665069f, -0.20253296f, -0.09455436f, 
    0.06764530f, -0.00515525f, 0.06850864f, 0.00058007f, 0.02988427f, 0.03251115f, 0.06658807f, -0.01094025f, 
    0.26280782f, -0.06019813f, -0.04873993f, 0.01210143f, 0.20332724f, -0.18264730f, -0.02295465f, 0.14721465f, 
    0.10654082f, 0.10126808f, 0.11100575f, 0.24549277f, -0.20650205f, -0.35092524f, -0.25191551f, -0.11096583f, 
    0.06490470f, 0.06296347f, -0.12780085f, 0.10566713f, -0.01002699f, 0.08909167f, 0.03922230f, 0.12563913f, 
    -0.26216111f, -0.17349274f, 0.01033367f, 0.08547376f, 0.06154820f, -0.03058048f, -0.06495912f, 0.04463726f, 
    -0.19708067f, 0.01929956f, -0.01152003f, -0.14063463f, 0.33951953f, -0.04582319f, 0.04370806f, -0.05649113f, 
    0.06979728f, -0.02160512f, -0.05728546f, -0.05539322f, -0.01243323f, 0.13562579f, 0.04114828f, -0.03796224f, 
    0.43046850f, 0.12696101f, -0.28444123f, -0.20455745f, -0.01345121f, 0.02969643f, -0.02663449f, -0.01823691f, 
    0.20028257f, -0.02422037f, 0.08216920f, 0.05340569f, 0.00795984f, -0.00429748f, 0.01051882f, 0.10175809f, 
    -0.08305412f, -0.08987290f, -0.01209228f, -0.01684251f, 0.09994375f, 0.15327206f, 0.17445450f, 0.12316255f, 
    -0.30417174f, 0.18037534f, 0.06936744f, 0.13117070f, -0.09891434f, -0.02135901f, -0.10735271f, -0.06106457f, 
    -0.00062348f, 0.08676533f, -0.04429718f, 0.13386929f, -0.30666998f, 0.03500045f, -0.02794467f, -0.20521538f, 
    -0.04847157f, -0.02536290f, -0.00056569f, -0.05908047f, -0.20906956f, -0.14562926f, -0.15613098f, -0.22195700f, 
    0.04259259f, -0.11466800f, -0.14977702f, -0.05335622f, 0.08709063f, 0.09598306f, 0.12673740f, 0.05051347f, 
    -0.03725089f, -0.06918001f, 0.04876317f, 0.04752699f, -0.19530648f, 0.12711702f, 0.13361710f, 0.14046483f, 
    0.04555050f, -0.05777463f, -0.03017724f, -0.09123101f, -0.04490665f, -0.02961473f, 0.02417110f, 0.00979580f, 
    0.06036198f, -0.12731725f, -0.05324760f, -0.03907844f, 0.01985988f, 0.02701757f, 0.11336014f, -0.01986071f, 
    0.04389166f, -0.08929467f, -0.10993606f, -0.37570882f, 0.37507227f, 0.15656172f, -0.03663929f, -0.22462986f, 
    0.13367319f, -0.13291496f, 0.01724610f, -0.01575852f, 0.01692693f, 0.04179664f, 0.06997640f, 0.03739748f, 
    0.09738879f, 0.05916514f, -0.09036950f, -0.10014477f, 0.00968907f, -0.19300319f, -0.03229640f, -0.03479329f, 
    0.00518185f, 0.17720309f, 0.01751992f, 0.20792654f, -0.19520098f, -0.16019659f, -0.07518928f, 0.01404263f, 
    0.03981300f, 0.05630722f, 0.02966397f, -0.27841106f, -0.03381062f, -0.10569990f, -0.02873450f, -0.07455135f, 
    0.39717564f, 0.30147272f, -0.06860901f, -0.15205024f, 0.07941875f, -0.05108800f, -0.05256421f, -0.01292866f, 
    0.03549321f, 0.09167339f, 0.03224580f, 0.06422953f, -0.22102135f, 0.17625397f, 0.16487315f, -0.08966070f, 
    0.01281819f, -0.03393397f, 0.03115766f, -0.04376874f, -0.08046059f, -0.09092700f, -0.07930533f, -0.00351638f, 
    -0.13218881f, -0.42344218f, -0.28551629f, -0.29394120f, -0.07694466f, 0.06255116f, 0.06518669f, 0.11685318f, 
    0.14923759f, -0.16861324f, -0.05680186f, -0.17171249f, -0.20809813f, -0.42460111f, -0.39960909f, -0.07321854f, 
    -0.05090024f, 0.05605366f, 0.11456736f, 0.06543604f, 0.07847835f, 0.12986057f, -0.04053770f, 0.18126450f, 
    0.14092605f, 0.07411154f, -0.12401678f, -0.12671132f, 0.04492460f, -0.03076460f, 0.04057026f, -0.04395077f, 
    0.03607162f, 0.07442917f, -0.01445844f, 0.15989260f, -0.15047596f, -0.09071381f, 0.08632736f, 0.03163786f, 
    -0.07335269f, -0.00598315f, -0.03973110f, 0.05275570f, -0.06851219f, 0.20586137f, -0.00825871f, 0.25734219f, 
    -0.06176613f, -0.02774009f, 0.00219523f, -0.00474063f, 0.11933116f, -0.04245302f, 0.02029319f, -0.05340216f, 
    -0.03856212f, 0.04001775f, 0.00354837f, 0.09254955f, 0.05081140f, -0.47341835f, -0.16913688f, -0.33272305f, 
    0.24792500f, 0.14407760f, -0.01180150f, 0.16377878f, 0.06841743f, -0.02283091f, 0.02426135f, -0.01905640f, 
    0.20409620f, -0.18626733f, 0.14713551f, 0.05368565f, -0.09289513f, 0.07519236f, -0.01912371f, -0.12872189f, 
    -0.04140274f, 0.00511163f, 0.07944562f, 0.10526913f, -0.10206722f, -0.10010383f, 0.02375612f, -0.04037047f, 
    0.05957117f, 0.07078828f, 0.02223304f, 0.08203579f, -0.39365613f, -0.08757753f, -0.23392473f, -0.46294188f, 
    -0.23618655f, -0.34948474f, 0.07481251f, -0.03929058f, -0.04020178f, 0.02233001f, 0.00136977f, -0.18879695f, 
    0.00540772f, -0.05305283f, 0.07082025f, 0.08697016f, 0.26393852f, 0.02262617f, -0.01456932f, -0.13209547f, 
    0.04479743f, 0.00221818f, 0.12695026f, 0.07516898f, -0.09915744f, 0.04011560f, -0.03895278f, 0.04456435f, 
    -0.13195579f, -0.40374270f, 0.00461866f, 0.00573470f, -0.01717427f, 0.15731877f, 0.07787899f, -0.08594055f, 
    0.03613661f, 0.08350138f, -0.01975736f, -0.05921901f, 0.17347844f, -0.01099935f, -0.16855556f, -0.01255597f, 
    0.00140972f, -0.09845768f, -0.04281295f, -0.00934474f, 0.05673208f, 0.08349635f, 0.00843899f, -0.02372519f, 
    0.36937097f, -0.57240421f, 0.07542987f, -0.17620115f, -0.08982121f, -0.02036721f, -0.17222527f, 0.06054876f, 
    -0.16141540f, 0.15276776f, 0.02563711f, -0.11490963f, 0.03314989f, -0.43185788f, 0.13738951f, -0.00172175f, 
    0.15985464f, 0.08945775f, -0.12891962f, -0.04384927f, -0.06517367f, -0.12855558f, -0.02071231f, -0.06174496f, 
    -0.12974501f, -0.23366641f, -0.30741626f, 0.05841802f, 0.13663431f, 0.00134008f, -0.00810984f, 0.12209776f, 
    0.01555203f, -0.09951827f, -0.10183510f, 0.04670455f, -0.10828778f, -0.13112614f, -0.10006702f, 0.04938249f, 
    0.22156933f, 0.10300045f, 0.14838032f, 0.09979843f, 0.14869723f, -0.09639008f, -0.04710258f, -0.03996749f, 
    0.06985140f, 0.27127448f, 0.39662933f, -0.25993729f, 0.06819145f, -0.27936557f, -0.16460893f, -0.00970177f, 
    -0.10991612f, 0.08633126f, 0.09392446f, 0.02398738f, 0.17578726f, -0.49039876f, -0.02125291f, -0.10078012f, 
    0.04520448f, 0.10615726f, -0.04034810f, 0.21965800f, -0.03558430f, 0.15368497f, -0.09881809f, -0.09257284f, 
    -0.22867604f, -0.13210294f, -0.16583961f, -0.16386509f, -0.26912242f, -0.05392063f, 0.07282776f, 0.18791108f, 
    0.03216913f, -0.01233059f, -0.00875465f, -0.03024455f, -0.23909687f, -0.55346733f, 0.26315713f, -0.07420278f, 
    0.11181302f, 0.05273605f, -0.30286899f, 0.06004191f, -0.07262189f, -0.17100395f, 0.09532785f, 0.07923324f, 
    -0.54384851f, 0.22084439f, -0.47672096f, -0.60128349f, -0.23081486f, -0.20294602f, 0.08817741f, 0.01833937f, 
    0.08868338f, -0.02964413f, 0.00432451f, 0.04019847f, -0.39709735f, -0.22684863f, -0.18988310f, -0.28995034f, 
    0.12441618f, 0.03993445f, 0.22257560f, 0.05243507f, -0.10262009f, -0.04241206f, 0.00214970f, -0.02289432f, 
    -0.01510567f, 0.14760059f, -0.06686098f, -0.04848256f, 0.02161411f, 0.05157730f, 0.07678931f, -0.10805766f, 
    -0.03854269f, -0.00109225f, 0.14655685f, 0.11214329f, -0.12701434f, -0.23609987f, -0.35066664f, 0.04065419f, 
    -0.02566932f, 0.18976505f, 0.06972502f, 0.02111369f, 0.00614843f, 0.01316404f, 0.07078207f, -0.04386971f, 
    -0.16953352f, 0.41508335f, -0.19410250f, -0.52029920f, -0.18837216f, -0.02318902f, -0.08563690f, -0.05386321f, 
    0.23361255f, 0.02326996f, 0.02326486f, 0.09312023f, -0.08201341f, 0.27857161f, -0.55073857f, 0.11336967f, 
    0.06976695f, 0.02809280f, 0.22100526f, 0.08472365f, 0.02355734f, -0.01666369f, -0.07626863f, -0.09545488f, 
    -0.15301558f, 0.07309253f, 0.03732682f, -0.13388759f, -0.02567970f, 0.02040798f, -0.13191438f, -0.12820558f, 
    0.02855699f, 0.08600357f, 0.08428708f, 0.14500774f, -0.03938032f, -0.17786887f, -0.00010334f, -0.03177725f, 
    0.02844665f, 0.10663982f, 0.13426077f, 0.04482447f, 0.20429575f, 0.15932383f, -0.10177553f, -0.06938428f, 
    -0.10360017f, -0.06538292f, -0.18709312f, 0.14272447f, 0.11285231f, 0.02853770f, 0.12940319f, -0.01007904f, 
    0.08556771f, -0.03014344f, -0.12003104f, -0.01132145f, 0.13873620f, 0.15146255f, -0.03522285f, -0.02084600f, 
    0.07811227f, -0.17231993f, -0.03955229f, -0.03405233f, 0.13152982f, 0.05080251f, 0.03050370f, -0.07624509f, 
    0.04712183f, -0.19326980f, 0.04625575f, -0.16558427f, 0.08593404f, 0.04167987f, 0.16073798f, 0.03585567f, 
    0.18011206f, 0.11895677f, -0.01894674f, 0.09636132f, -0.09962974f, 0.02768234f, -0.07689544f, 0.02925749f, 
    0.05447758f, 0.04881218f, 0.15909030f, 0.03035023f, 0.14020148f, 0.04900285f, 0.08651052f, 0.21986911f, 
    -0.11254723f, 0.00678980f, -0.01885272f, 0.15263332f, 0.04283994f, 0.09038149f, -0.04162882f, 0.04565044f, 
    -0.07717969f, -0.06212655f, -0.06509317f, 0.01338608f, -0.09826726f, -0.09205308f, 0.09379273f, 0.17680410f, 
    -0.00950799f, 0.00592885f, -0.18704216f, -0.03226070f, 0.01151689f, 0.22009924f, 0.01379522f, -0.08194924f, 
    -0.21483915f, -0.18571417f, 0.13594168f, 0.03926000f, -0.07935566f, 0.00376878f, 0.06849646f, 0.05581371f, 
    0.01481719f, 0.14665878f, 0.00889727f, 0.00267908f, 0.11674837f, 0.29748580f, 0.24902776f, 0.15697977f, 
    0.09718708f, -0.09112546f, -0.22277325f, -0.30251405f, -0.10816821f, -0.08861773f, 0.03726545f, 0.07508109f, 
    -0.12744735f, 0.33591223f, -0.08148146f, -0.34037292f, -0.05208984f, -0.23771064f, 0.13755946f, 0.33888555f, 
    -0.09808659f, 0.04448301f, 0.04463263f, -0.09807278f, -0.23854175f, 0.17559145f, -0.09915027f, 0.03590905f, 
    -0.30591032f, 0.07069265f, -0.12630422f, -0.00462186f, 0.09849454f, -0.18282469f, -0.10423903f, -0.13075960f, 
    0.12210157f, 0.13981108f, 0.06091658f, -0.74870980f, -0.01741519f, -0.18964161f, -0.08644292f, 0.00846056f, 
    -0.03520773f, 0.03382410f, 0.07549012f, 0.07438554f, 0.06387410f, 0.00797231f, 0.12340015f, 0.29827270f, 
    0.06865498f, -0.19784573f, -0.13127773f, -0.10714205f, 0.07050394f, -0.14596464f, 0.02430431f, 0.19452384f, 
    0.25587976f, -0.23336315f, 0.21171755f, -0.12776127f, 0.05654243f, -0.18351971f, -0.04352871f, -0.01957857f, 
    0.05129565f, 0.10630114f, -0.01599478f, -0.09631920f, -0.19370575f, 0.10115572f, -0.28639513f, -0.01349055f, 
    0.05224861f, 0.08128283f, -0.02160845f, -0.09754848f, 0.08331859f, 0.09023252f, 0.00053887f, 0.13445149f, 
    -0.18634620f, -0.04086713f, -0.19217916f, -0.02046370f, 0.07014129f, 0.00470078f, 0.12195942f, -0.01576057f, 
    0.05460755f, 0.05126292f, 0.11867776f, -0.04042996f, -0.48338372f, -0.08540303f, -0.08496726f, 0.10229538f, 
    -0.03987973f, 0.05828104f, 0.07029939f, -0.01975160f, 0.00016152f, 0.08324520f, 0.10608656f, -0.01524839f, 
    0.26745701f, -0.35768861f, 0.15110815f, -0.10162511f, 0.05493613f, 0.07465101f, -0.14774995f, 0.02990773f, 
    -0.03203629f, -0.10031371f, -0.00930645f, -0.04399119f, -0.18870807f, -0.13028951f, 0.18267262f, -0.30533695f, 
    0.05205581f, -0.09240728f, 0.01032849f, 0.26600963f, -0.00988999f, 0.02477422f, 0.04172427f, -0.06666862f, 
    -0.10854053f, -0.36632672f, -0.26800275f, -0.25330883f, -0.20949474f, 0.08832877f, 0.01274023f, 0.06374422f, 
    0.18050601f, -0.04231204f, 0.03406623f, 0.07594103f, 0.14779383f, -0.04498946f, 0.34764135f, 0.09960488f, 
    0.06556117f, -0.18251131f, 0.01887578f, -0.03419433f, 0.05803736f, 0.10314821f, 0.01501762f, -0.02859725f, 
    0.12228580f, -0.10791392f, -0.15641201f, 0.05328900f, -0.01577034f, 0.02066541f, -0.12673691f, -0.02860999f, 
    0.08189934f, 0.01360472f, -0.11181270f, 0.10958395f, -0.11356556f, -0.16865082f, -0.05471839f, -0.20874014f, 
    -0.23300864f, 0.05305402f, 0.00585765f, 0.08246362f, 0.06377801f, -0.05619822f, 0.00628234f, -0.04041637f, 
    -0.02783118f, 0.40675467f, 0.00310951f, -0.13413292f, -0.07675213f, -0.10914563f, 0.07725225f, -0.05661789f, 
    0.19733098f, 0.15326811f, -0.16182952f, 0.01126039f, 0.04101534f, -0.15725206f, 0.04621993f, 0.06969712f, 
    0.14211416f, 0.16119525f, -0.08233388f, -0.13379732f, 0.09138605f, -0.04977853f, -0.06094444f, -0.08965239f, 
    -0.30922434f, 0.00394843f, -0.37240136f, 0.44405392f, -0.04115274f, -0.04051099f, -0.12910691f, 0.00381147f, 
    -0.01986928f, -0.04667640f, 0.01925009f, 0.01105792f, 0.08151440f, 0.04052240f, 0.00729575f, 0.06369418f, 
    0.09463603f, -0.05104836f, -0.04549969f, 0.05041325f, -0.05652520f, -0.01536544f, 0.09876912f, 0.09594800f, 
    -0.11036842f, -0.17641483f, 0.18707299f, 0.11056725f, -0.01506929f, 0.05302627f, -0.06132299f, 0.05859303f, 
    0.10480023f, 0.09937687f, -0.05348632f, -0.03840403f, -0.02504527f, -0.06853280f, -0.07039640f, 0.14484429f, 
    0.07068935f, 0.11373988f, 0.14892198f, 0.00730914f, 0.07409739f, 0.13921690f, 0.06029398f, 0.08680043f, 
    0.08283303f, 0.38129225f, -0.03283447f, -0.09725468f, -0.11818054f, -0.06794301f, -0.12560496f, -0.03154817f, 
    0.10768888f, -0.17867966f, 0.00865274f, 0.06229196f, 0.06606271f, -0.12160474f, -0.60879427f, -0.10268035f, 
    0.14041650f, 0.10852773f, 0.19615324f, 0.06003089f, -0.01716645f, -0.03216211f, -0.02478166f, -0.08129147f, 
    0.17990017f, -0.04045391f, 0.32536370f, 0.10145184f, -0.01655927f, -0.04522791f, -0.16691057f, -0.05666042f, 
    0.14402100f, 0.08620542f, -0.01229334f, 0.03223306f, -0.22308555f, -0.50902331f, 0.09641080f, 0.08461647f, 
    -0.05494691f, 0.02663439f, 0.02919339f, -0.10688152f, 0.04821339f, -0.05891084f, 0.02303406f, 0.05206350f, 
    0.08016061f, -0.39871332f, 0.11307999f, 0.13230531f, 0.23938936f, -0.01631928f, -0.10202260f, 0.03880795f, 
    0.06148769f, 0.09712497f, -0.15965655f, -0.02543723f, 0.11945906f, -0.05680411f, 0.06669755f, -0.16720876f, 
    -0.10344931f, -0.06624050f, 0.08555007f, 0.19067548f, 0.03729324f, 0.14288610f, 0.01323734f, -0.04009210f, 
    -0.18177259f, 0.03776081f, -0.33546582f, 0.22149885f, 0.04703126f, 0.11345465f, -0.02116134f, 0.03332518f, 
    0.04553673f, -0.03250986f, -0.01326084f, -0.08023296f, -0.01996941f, -0.19833316f, -0.31136894f, 0.03768536f, 
    0.09495649f, 0.09999073f, 0.10416351f, 0.05365412f, -0.06377873f, -0.00297001f, 0.04910516f, -0.01718475f, 
    0.12026239f, 0.45076725f, -0.10702736f, 0.38327739f, -0.07747582f, -0.06303675f, -0.16228949f, -0.17321070f, 
    0.06166103f, -0.02266639f, 0.05793000f, 0.07313304f, 0.09237097f, 0.34903806f, 0.16440521f, 0.50559497f, 
    0.17182885f, -0.18974458f, -0.26084518f, -0.13023187f, 0.06628831f, -0.07718565f, 0.01377292f, 0.15797658f, 
    -0.05795403f, 0.03925355f, -0.09508051f, 0.08155121f, 0.18357340f, -0.06650866f, 0.04423098f, -0.14023302f, 
    0.19047602f, -0.08566236f, -0.07933145f, -0.00387678f, -0.15001592f, -0.01000237f, -0.02795324f, 0.12188785f, 
    -0.07589515f, 0.07663099f, -0.10878260f, -0.06219486f, 0.05646565f, -0.05556205f, 0.07783801f, 0.06140229f, 
    -0.07950772f, -0.29175726f, 0.37747395f, -0.57058287f, 0.23570688f, -0.16350600f, 0.14556125f, -0.18588966f, 
    -0.20401579f, 0.02816086f, -0.04598564f, -0.07230891f, 0.03913795f, 0.01970007f, 0.24521653f, 0.21354471f, 
    -0.00460123f, -0.31557968f, 0.04485262f, -0.04371994f, 0.07014307f, -0.02436761f, -0.03205660f, -0.07166218f, 
    0.17190035f, -0.87451810f, 0.28066733f, -0.50770974f, -0.05216037f, 0.09195565f, -0.19562210f, 0.08480154f, 
    -0.02332996f, -0.01946265f, -0.06753641f, 0.02090049f, 0.03520477f, 0.14552087f, 0.08175533f, 0.22601070f, 
    -0.02153940f, -0.00959432f, -0.04591230f, -0.14470573f, 0.06835210f, -0.01212558f, 0.12834255f, 0.12378622f, 
    0.20385721f, -0.65155947f, 0.10400069f, -0.36996067f, 0.05248212f, -0.23147833f, 0.08497673f, 0.12415795f, 
    -0.14180477f, -0.03444624f, -0.09233338f, 0.08550065f, -0.28901279f, -0.25024405f, -0.14967959f, -0.06560688f, 
    -0.11742195f, 0.07605709f, -0.06575840f, -0.02061563f, -0.08586392f, -0.04352192f, 0.05672330f, 0.16798770f, 
    -0.20897447f, -0.30931836f, -0.14027828f, -0.01413180f, -0.29031515f, -0.17529505f, -0.08456343f, -0.11242845f, 
    0.17864203f, 0.00297424f, -0.12787600f, -0.01085691f, -0.11933243f, 0.09379387f, -0.05272309f, -0.03234711f, 
    0.05866059f, 0.00889250f, 0.05389495f, 0.01603033f, -0.00574958f, 0.00589190f, 0.00029608f, -0.02226510f, 
    -0.13771078f, 0.12887472f, -0.21449234f, 0.08157866f, -0.02237441f, 0.19936751f, 0.01839225f, -0.03202366f, 
    0.00289206f, 0.04152787f, -0.13610303f, 0.10717115f, -0.22690460f, 0.06303424f, 0.01085912f, 0.06443636f, 
    -0.07925072f, 0.04691910f, -0.30472469f, -0.00789829f, 0.12413467f, 0.08554341f, 0.14635810f, -0.04920611f, 
    -0.31129986f, -0.05396548f, 0.30749965f, -0.04235606f, -0.14563143f, 0.09412692f, -0.15968788f, 0.02837988f, 
    0.08446139f, 0.10364211f, 0.22522268f, 0.19409382f, 0.00181462f, -0.14110686f, 0.00700434f, -0.26243320f, 
    -0.11463290f, -0.05499688f, -0.12479541f, 0.00423913f, -0.24349132f, 0.00657216f, 0.07888474f, 0.05668910f, 
    -0.29553339f, -0.00118021f, -0.00279781f, 0.06506062f, -0.10918374f, -0.05042080f, -0.04468396f, 0.00593929f, 
    -0.00094829f, -0.24342610f, 0.02099185f, -0.04166849f, -0.33061787f, -0.03330554f, 0.22236952f, 0.02288065f, 
    0.11154786f, 0.12442305f, 0.00158929f, -0.00225901f, -0.05202594f, 0.04535215f, 0.13848634f, -0.04762432f, 
    -0.28517455f, -0.36983547f, 0.24740855f, 0.29071900f, -0.12910739f, 0.24195002f, -0.24121918f, -0.03917170f, 
    -0.01892792f, -0.02479953f, 0.07306904f, 0.08481552f, -0.39664423f, 0.29645324f, -0.05669720f, 0.12087743f, 
    0.05823001f, 0.13167487f, -0.20517379f, 0.06640552f, -0.03419976f, 0.05349273f, 0.01935877f, -0.01567205f, 
    0.40544483f, -0.33293310f, 0.43945408f, -0.00303601f, -0.29390851f, 0.18177587f, 0.10479429f, -0.01592188f, 
    0.08120856f, -0.04053057f, 0.01203002f, 0.12398231f, -0.00885289f, -0.32867312f, 0.21921968f, 0.27182698f, 
    0.12498395f, 0.06396987f, -0.38901347f, 0.12205353f, 0.00253682f, -0.03957050f, 0.02527764f, -0.02824053f, 
    -0.13425463f, 0.17722759f, -0.19277291f, -0.03915238f, -0.05779488f, -0.08172137f, 0.13023068f, -0.05902831f, 
    -0.11353478f, -0.18918580f, -0.37369370f, -0.20373380f, -0.07609124f, -0.16609234f, 0.16253218f, -0.22322491f, 
    -0.21179414f, 0.05748113f, 0.10681794f, 0.02752809f, 0.06849962f, 0.01437701f, -0.16375549f, -0.13431440f, 
    0.18063647f, -0.18534043f, 0.37016439f, 0.11486993f, 0.01180011f, -0.09656595f, 0.10886174f, 0.02841992f, 
    -0.20897175f, -0.07106995f, 0.01041807f, 0.08078364f, -0.09363146f, -0.36672091f, -0.04005245f, -0.14500819f, 
    -0.07286835f, -0.07660916f, 0.12577540f, -0.04889311f, -0.03357004f, 0.15788335f, -0.01957857f, -0.06005041f, 
    0.10393047f, -0.07444951f, -0.07351652f, -0.11977901f, 0.14390047f, 0.02645288f, -0.03362664f, 0.01813744f, 
    -0.32075825f, -0.05480359f, -0.34506628f, -0.46799895f, 0.04372402f, -0.53785735f, 0.14530112f, -0.19635963f, 
    -0.08332482f, -0.04039381f, -0.10412688f, 0.05674061f, -0.02274831f, 0.01942582f, 0.19612883f, -0.04999125f, 
    0.05848064f, 0.26505679f, 0.11772136f, 0.07593348f, -0.04322400f, 0.05139655f, -0.02635182f, -0.03623921f, 
    -0.06796163f, 0.15886396f, 0.12254494f, -0.01912841f, -0.48606294f, 0.12142309f, -0.18347998f, 0.10388514f, 
    0.02384594f, 0.03948241f, 0.13137643f, 0.13645758f, -0.17189384f, 0.10321504f, -0.10014179f, 0.06219757f, 
    -0.18207078f, 0.11471243f, -0.09483520f, -0.01410264f, -0.03952605f, 0.09978358f, -0.25202838f, 0.00089104f, 
    0.00942243f, -0.20338705f, -0.15689777f, -0.14619438f, -0.00948208f, -0.10064742f, -0.08685833f, -0.16262023f, 
    -0.11169130f, -0.03341869f, -0.05368988f, 0.04904369f, -0.06861084f, -0.18812060f, -0.18241884f, -0.03987780f, 
    -0.01218485f, 0.28751966f, 0.17346220f, -0.00521636f, -0.08349834f, -0.01426036f, -0.07761902f, 0.01992564f, 
    0.15491310f, -0.01012198f, 0.15086122f, -0.00244479f, 0.16964184f, -0.16207241f, 0.21998537f, -0.16136442f, 
    -0.21849383f, -0.03430055f, 0.28044108f, -0.02334281f, 0.08383872f, 0.04028691f, -0.03641845f, -0.02196287f, 
    -0.17681986f, -0.18231212f, -0.70082670f, 0.12033409f, -0.02657674f, 0.00106265f, -0.14425036f, 0.12744594f, 
    0.08359912f, 0.09473427f, 0.00300026f, 0.05028861f, 0.04276528f, -0.08694082f, 0.13042776f, 0.01313014f, 
    0.03150102f, -0.01781203f, -0.01294270f, -0.06519624f, -0.06028051f, 0.07991574f, 0.07440837f, -0.11049528f, 
    -0.17594610f, -0.30977377f, 0.03324578f, 0.14929606f, -0.01837358f, 0.14049694f, -0.19438094f, 0.01998605f, 
    -0.04824654f, -0.00169464f, 0.06776889f, -0.01347842f, 0.04359111f, 0.04457173f, 0.26189470f, 0.03125886f, 
    -0.05431101f, 0.09355737f, -0.01332607f, -0.02625364f, 0.02176517f, -0.00902421f, 0.10206195f, 0.07159954f, 
    0.21026859f, -0.18098339f, 0.13999224f, -0.03171899f, -0.08038650f, -0.01730378f, 0.06545637f, 0.00099367f, 
    -0.03773496f, 0.02168937f, -0.00234550f, -0.16271576f, -0.02383430f, 0.23354268f, 0.06802282f, -0.13992350f, 
    -0.00991782f, -0.04149683f, 0.04515282f, -0.08332075f, -0.05093978f, 0.15032408f, -0.11040657f, -0.14034328f, 
    -0.54282236f, 0.22971749f, -0.08789692f, 0.09884027f, 0.01591312f, -0.11670641f, -0.12673315f, 0.02652221f, 
    -0.05804773f, -0.08177988f, -0.05715809f, -0.22176704f, -0.12908205f, 0.10287897f, 0.20338112f, -0.22046444f, 
    0.01285919f, 0.05820521f, 0.37122890f, 0.13249046f, 0.04948830f, -0.07559019f, -0.00378120f, -0.12549791f, 
    -0.01999856f, -0.08881669f, 0.10967313f, 0.00698201f, -0.08211632f, 0.05370684f, 0.01343226f, -0.10781861f, 
    0.01545221f, -0.00191115f, -0.04399290f, 0.08853060f, -0.15740630f, -0.15946950f, -0.12586209f, 0.07479932f, 
    -0.06743058f, 0.05077864f, 0.02804397f, -0.03723113f, 0.08208194f, 0.10768070f, 0.07251228f, 0.07646106f, 
    -0.01124628f, 0.13344485f, 0.20233729f, -0.08591776f, -0.04999959f, 0.20737520f, -0.14850451f, -0.04046423f, 
    -0.01354555f, 0.10493328f, -0.01073700f, 0.09850970f, -0.12231145f, -0.13205595f, -0.29145604f, 0.17739581f, 
    -0.08318185f, -0.16866939f, -0.16901441f, -0.06486309f, 0.03280896f, 0.11686411f, 0.02949916f, 0.07793524f, 
    -0.09257365f, -0.06902666f, -0.19449915f, 0.16052753f, 0.15127271f, -0.07116941f, 0.09005339f, -0.09886355f, 
    -0.08073312f, 0.04261209f, -0.01402402f, -0.05834230f, -0.19474442f, 0.07995174f, -0.22450005f, 0.15958451f, 
    -0.00868760f, 0.10181767f, 0.14576401f, 0.04449053f, -0.01897335f, 0.00371190f, -0.11898810f, -0.04666138f, 
    -0.14146751f, 0.06912939f, 0.20702924f, 0.14455464f, -0.04560002f, 0.15802486f, 0.08845855f, -0.14457197f, 
    -0.04484850f, -0.01445149f, 0.17731866f, 0.21015806f, 0.00588095f, 0.02856513f, -0.03973773f, 0.12867756f, 
    -0.10706627f, 0.00034953f, 0.08642770f, 0.21047774f, 0.03667242f, 0.14534739f, 0.07087790f, 0.20857261f, 
    -0.04703782f, -0.16874120f, 0.05977997f, 0.15390724f, -0.09861727f, 0.05449289f, 0.18281792f, 0.02118140f, 
    -0.11389929f, -0.13379362f, 0.14055252f, 0.07436886f, -0.47024909f, 0.10334323f, -0.07496373f, 0.15820709f, 
    0.03010703f, 0.01029152f, -0.05745178f, -0.08017776f, -0.05083176f, 0.06587135f, 0.08211529f, 0.12753358f, 
    0.03390048f, 0.37649047f, 0.13606994f, -0.08868964f, -0.14706859f, -0.01260908f, 0.02647828f, 0.06108974f, 
    0.02254278f, 0.03819526f, -0.20159145f, -0.00854298f, -0.07633030f, -0.05291921f, 0.31151587f, -0.11365119f, 
    -0.08721150f, -0.03922711f, -0.06872030f, -0.15770902f, 0.09818922f, 0.10263831f, -0.00722320f, 0.03972711f, 
    -0.09491757f, -0.11831137f, 0.21251799f, 0.20762548f, -0.12018994f, -0.07185014f, -0.07702473f, 0.08718536f, 
    0.05644706f, -0.18369564f, 0.05806453f, 0.17948675f, -0.09260698f, -0.08704507f, -0.07503330f, -0.25245184f, 
    -0.03322515f, -0.11597179f, -0.03429694f, -0.01928491f, -0.08197039f, -0.05994671f, -0.10538708f, -0.31482744f, 
    -0.01694011f, 0.23457682f, 0.18020810f, -0.10513059f, -0.02202676f, 0.09455177f, 0.14965999f, 0.01661024f, 
    -0.10617037f, 0.05968838f, 0.05475529f, -0.06264447f, -0.22893606f, -0.08822670f, -0.12912360f, -0.18468840f, 
    -0.11762039f, -0.07944599f, -0.07399638f, 0.05812255f, -0.07220241f, 0.14054614f, 0.03376049f, -0.04297168f, 
    -0.25884321f, 0.30863923f, -0.10385391f, -0.25008240f, 0.04234839f, 0.07448687f, -0.21884196f, 0.07978315f, 
    -0.14012435f, -0.23279791f, -0.14232551f, -0.59280288f, -0.19483817f, 0.03138040f, -0.61064148f, 0.23148498f, 
    0.06820412f, 0.27618122f, 0.03935025f, -0.06460711f, -0.15060782f, -0.02104809f, -0.11455663f, -0.02128032f, 
    -0.37321064f, 0.32421672f, 0.06131500f, 0.05452840f, 0.01045499f, 0.09277646f, -0.04121797f, -0.09498935f, 
    0.01435278f, 0.07541120f, 0.10225248f, 0.08716349f, -0.00078322f, -0.03518363f, -0.07827357f, 0.03238954f, 
    0.12580192f, -0.00887262f, -0.09341685f, 0.08134433f, -0.00556387f, -0.07139892f, -0.16755500f, -0.11142720f, 
    -0.21019030f, -0.00995784f, 0.03046572f, 0.14018515f, -0.13515051f, -0.04371286f, 0.15936150f, -0.02796440f, 
    -0.02470889f, -0.14730385f, 0.16066183f, -0.01564803f, -0.37579566f, 0.01122275f, -0.10281540f, -0.10980226f, 
    -0.08001604f, 0.02220249f, -0.02543406f, -0.09907218f, -0.19028185f, 0.00900618f, -0.02960968f, -0.04746064f, 
    0.11667003f, 0.30568644f, 0.01896632f, -0.16846615f, 0.16003358f, 0.04689034f, -0.20699029f, 0.13602301f, 
    -0.08361016f, 0.04159650f, 0.07288677f, -0.03422379f, 0.17863204f, 0.26329544f, 0.01748600f, -0.01590734f, 
    -0.11120898f, -0.12585482f, 0.02527647f, 0.03633345f, -0.06055972f, 0.01054178f, -0.08095103f, 0.08218634f, 
    -0.05632062f, 0.16877921f, -0.10562038f, -0.04107380f, -0.16293842f, 0.06406771f, 0.14086221f, -0.03337641f, 
    0.01033262f, 0.05036527f, -0.12968008f, -0.02006893f, 0.30444157f, -0.15441665f, 0.13544828f, 0.15338789f, 
    0.03913680f, -0.14092833f, 0.05308317f, 0.01249961f, -0.14101750f, -0.03198095f, -0.20702662f, 0.05913280f, 
    -0.08216695f, 0.12537690f, 0.27721798f, -0.06849628f, -0.12701099f, -0.00884474f, 0.13032630f, -0.07639778f, 
    0.02501678f, 0.00206099f, 0.20963427f, 0.13133262f, -0.44042134f, 0.20763808f, 0.00405877f, -0.11714278f, 
    0.00383103f, -0.08633749f, 0.07632341f, -0.10027162f, -0.04196811f, 0.05994634f, -0.11846212f, -0.06974024f, 
    -0.10563841f, 0.37732330f, 0.31407872f, 0.30792272f, 0.01735745f, 0.05087620f, -0.07397510f, -0.07887572f, 
    0.10769199f, -0.10437901f, -0.05297669f, 0.07110203f, 0.19505915f, -0.01354706f, 0.02542984f, -0.16489290f, 
    0.06488622f, -0.01947611f, -0.09207759f, 0.07644921f, -0.06437740f, -0.00926063f, -0.30887219f, -0.41598070f, 
    -0.32830983f, 0.43421805f, -0.05849698f, 0.08848912f, -0.00080261f, -0.06708084f, -0.10030063f, 0.05857812f, 
    -0.01558777f, 0.03588932f, 0.11549972f, -0.01665127f, -0.13147196f, 0.20587100f, 0.10382970f, 0.28264838f, 
    -0.03700690f, 0.01464945f, 0.03019230f, -0.11379611f, -0.06855158f, 0.04387727f, -0.21703838f, -0.08678738f, 
    0.05543524f, 0.04411187f, 0.07120562f, -0.02314730f, -0.04495887f, -0.00036191f, 0.09278981f, -0.00741423f, 
    0.08291323f, -0.03100997f, 0.01836716f, 0.05644174f, 0.00262512f, -0.14086238f, -0.03749638f, 0.00293464f, 
    -0.08788980f, -0.17373252f, -0.00251199f, -0.11416341f, 0.07455015f, 0.07621041f, -0.00214190f, 0.00287516f, 
    -0.49221212f, 0.16372329f, -0.12841769f, 0.33252278f, 0.15231556f, -0.17657672f, 0.05995812f, -0.13059610f, 
    -0.04083894f, 0.02353605f, 0.18932433f, 0.00103209f, -0.01513111f, 0.28001860f, -0.05609352f, 0.03672278f, 
    0.03457611f, 0.01905543f, -0.00187006f, -0.00851801f, -0.01713649f, 0.01633049f, -0.09554413f, -0.00563551f, 
    0.07642837f, -0.01831029f, -0.24364705f, 0.01001115f, 0.13538596f, -0.24889112f, 0.11602221f, -0.06890575f, 
    -0.00465676f, -0.02893623f, 0.01730364f, -0.07264660f, 0.15183362f, 0.14737995f, -0.04166941f, 0.09229450f, 
    -0.02872307f, 0.07990584f, 0.06662115f, 0.19707476f, -0.08009619f, -0.04659611f, 0.04653078f, -0.15648010f, 
    -0.03394092f, -0.16548276f, -0.03297503f, 0.03936097f, -0.03726932f, 0.06685261f, 0.00932836f, -0.01181439f, 
    -0.11555403f, -0.00310506f, 0.06362829f, -0.21518992f, -0.02438185f, 0.13546394f, -0.19830438f, 0.29746130f, 
    -0.27090096f, 0.12382761f, -0.12344514f, -0.07481841f, 0.02374362f, -0.00062469f, 0.00633452f, -0.01793692f, 
    -0.15715301f, -0.35953522f, -0.24515899f, 0.27316940f, -0.14257760f, -0.29583263f, 0.07506429f, -0.15603904f, 
    0.03997359f, -0.05602695f, 0.02782763f, -0.07695297f, -0.38459757f, 0.30641145f, -0.28488082f, 0.07905155f, 
    0.08919320f, 0.07831129f, 0.20683706f, -0.05239432f, -0.01796749f, 0.09984727f, 0.02983824f, 0.09305841f, 
    0.03356593f, -0.35826811f, 0.39487511f, -0.44352958f, 0.17301010f, 0.01771408f, 0.13945244f, 0.02893879f, 
    -0.09158058f, 0.06169333f, -0.12473199f, -0.09201609f, -0.07081410f, 0.04255927f, 0.17819840f, -0.07249754f, 
    -0.20732850f, 0.00976525f, -0.08224430f, 0.23970875f, -0.25703245f, 0.09356866f, -0.03322883f, 0.02129635f, 
    0.02755418f, 0.18294528f, -0.00776895f, -0.08440577f, 0.06058039f, 0.03646300f, -0.09811148f, 0.04967918f, 
    0.04623464f, 0.19424012f, 0.05374652f, -0.06185620f, 0.16402812f, 0.07292057f, 0.30701169f, -0.35588127f, 
    0.21022582f, 0.12676273f, -0.11342544f, 0.06241238f, 0.04838270f, 0.00842214f, 0.10388996f, 0.08671457f, 
    -0.41931984f, 0.23326847f, -0.08915017f, 0.08955760f, -0.05533090f, 0.07460316f, 0.16687095f, -0.19782522f, 
    -0.00303578f, -0.04513547f, -0.20444322f, 0.02619484f, 0.44986016f, 0.06880850f, 0.36356580f, -0.01864905f, 
    0.02809186f, 0.04139538f, -0.12358526f, 0.06098993f, -0.13811789f, -0.00390801f, 0.00591515f, -0.02631702f, 
    -0.20364344f, 0.04376090f, -0.32121259f, -0.20861827f, 0.00247609f, -0.06527113f, 0.00047072f, -0.00529099f, 
    0.07071861f, 0.06182071f, 0.07133871f, -0.02451816f, -0.13147615f, 0.11753029f, -0.00885851f, -0.09098621f, 
    -0.02654384f, 0.02482019f, 0.04167423f, 0.08053569f, -0.04205710f, 0.09803914f, 0.15249836f, -0.02503454f, 
    0.06819789f, -0.09725567f, 0.07965553f, -0.02283958f, -0.05201492f, 0.06312861f, -0.02236455f, 0.02260447f, 
    0.04605209f, 0.04710009f, 0.04187842f, 0.04533833f, 0.07323620f, -0.31205419f, 0.25661379f, 0.37107974f, 
    0.03770662f, -0.03022987f, -0.07300540f, 0.06567471f, 0.07928982f, 0.02141474f, 0.12761609f, 0.05006846f, 
    -0.22563563f, 0.17384991f, -0.24302168f, 0.18584986f, -0.08252756f, 0.13087434f, 0.01242666f, 0.05126441f, 
    0.00811775f, 0.10271756f, 0.07631074f, -0.01355700f, 0.21194789f, 0.09076662f, 0.07332238f, -0.20176077f, 
    -0.00829521f, 0.07893623f, -0.04980990f, 0.03787299f, -0.01420035f, 0.04240094f, 0.10816634f, -0.00250006f, 
    -0.10240543f, -0.08568274f, -0.11516540f, -0.01676808f, 0.10887773f, 0.04766179f, -0.03624805f, -0.02233833f, 
    0.09957077f, -0.07702555f, -0.07143723f, 0.01629960f, -0.15098609f, 0.22002272f, -0.20686565f, -0.06885120f, 
    -0.01574005f, 0.09737017f, 0.06221668f, 0.03260030f, -0.02112689f, 0.15286718f, 0.01098653f, -0.09122255f, 
    -0.20852849f, -0.26206651f, 0.00256327f, -0.13292997f, -0.27945480f, -0.16744091f, -0.01572621f, -0.01927439f, 
    -0.01329660f, 0.02913730f, 0.08883405f, -0.03517242f, -0.38770679f, -0.07794985f, -0.18939300f, -0.14007720f, 
    0.12092435f, 0.00574150f, -0.01721027f, 0.06276990f, -0.07730407f, -0.03258257f, 0.01647141f, -0.06409363f, 
    -0.04981791f, -0.24606439f, -0.01131072f, -0.14754246f, -0.04302054f, -0.17516954f, -0.16349736f, -0.10639267f, 
    -0.03468981f, -0.01920225f, -0.05071336f, -0.02543476f, -0.22052236f, -0.11351336f, -0.12081298f, -0.11661264f, 
    0.19744104f, -0.04446995f, -0.03156911f, -0.08934875f, -0.09614661f, -0.09660275f, -0.17528009f, -0.10672099f, 
    -0.29012871f, -0.17280865f, -0.13229449f, -0.37430450f, 0.01979182f, -0.15591599f, -0.02838497f, 0.01066296f, 
    0.02303529f, 0.00260279f, -0.03100231f, -0.05514781f, -0.09431445f, -0.15744945f, -0.29612792f, -0.07850646f, 
    0.19794540f, 0.06111205f, 0.00187529f, 0.03998627f, 0.04860627f, -0.01043841f, 0.08984084f, 0.01874072f, 
    -0.49251887f, 0.23304591f, -0.34694692f, 0.33415797f, 0.02185649f, 0.04082119f, 0.05233851f, 0.11570759f, 
    -0.35365751f, -0.06628853f, 0.17353737f, 0.06327806f, 0.27045313f, -0.27481753f, 0.20844349f, 0.07752088f, 
    0.10641430f, -0.14117721f, 0.09804415f, 0.08468635f, 0.02879181f, 0.12350747f, 0.09908774f, 0.02779329f, 
    0.07391015f, -0.07832634f, 0.06479924f, 0.06173326f, -0.06059612f, -0.01005506f, -0.03137901f, -0.08785249f, 
    0.01122978f, 0.10139032f, 0.12305719f, 0.06209759f, -0.05638510f, -0.50226581f, -0.15496685f, 0.11292204f, 
    -0.04544521f, -0.06697861f, -0.11508705f, -0.15733038f, 0.01977178f, 0.00344833f, 0.04244658f, -0.04680843f, 
    0.02992219f, 0.31240350f, -0.26596233f, -0.02675139f, 0.06376463f, -0.07132186f, 0.19169445f, 0.00930018f, 
    -0.04983196f, -0.04053394f, -0.04581422f, -0.04271230f, 0.10168753f, -0.24050654f, 0.07642109f, -0.00443965f, 
    -0.14673482f, -0.03028763f, -0.20623659f, -0.12638573f, -0.01451014f, 0.04468502f, -0.01646336f, -0.07487459f, 
    -0.12102377f, 0.41631752f, -0.33910981f, 0.09619296f, -0.08239724f, 0.03917170f, 0.17975557f, -0.09459901f, 
    -0.05766741f, 0.01052281f, 0.01429783f, 0.06568414f, -0.06343403f, -0.52475262f, -0.06131627f, 0.03747375f, 
    0.00567820f, 0.05096051f, -0.07322914f, -0.09080854f, 0.02896526f, 0.08405808f, 0.22104453f, 0.04331415f, 
    -0.13384886f, 0.19705072f, -0.02935240f, 0.11838762f, 0.03157875f, -0.09209450f, 0.08435751f, -0.10184975f, 
    -0.05304002f, -0.08631845f, 0.00226883f, -0.21221685f, 0.04849496f, 0.01696338f, 0.10512935f, -0.07608695f, 
    -0.18393391f, -0.11685863f, -0.22677058f, -0.18385488f, -0.00176138f, -0.07225624f, -0.10324652f, -0.11594497f, 
    -0.01294843f, 0.16371207f, 0.17167251f, 0.07081625f, -0.00828199f, -0.07775185f, -0.04521532f, -0.08621272f, 
    0.05504170f, 0.13340014f, 0.04294074f, 0.18024470f, -0.17080249f, 0.26451346f, -0.18626401f, 0.00135267f, 
    0.03182428f, 0.11692904f, 0.06643320f, 0.01247832f, -0.00810524f, -0.03375684f, 0.07470106f, -0.14011605f, 
    -0.10881693f, -0.19437703f, 0.08452846f, -0.08338379f, 0.11611148f, 0.01322070f, 0.05767679f, -0.03871465f, 
    -0.01799199f, 0.16291341f, 0.20348991f, 0.04227434f, -0.14277081f, -0.06724555f, 0.08638931f, -0.13280384f, 
    0.05453689f, 0.04443873f, -0.06420441f, -0.00675333f, -0.06345613f, 0.02512718f, -0.06623334f, -0.08149164f, 
    0.01967313f, 0.09124515f, 0.11904773f, -0.14385881f, -0.08698474f, 0.02891410f, 0.07057238f, -0.02438164f, 
    -0.05899344f, 0.02300115f, 0.07360015f, -0.09975059f, 0.16035986f, 0.05801558f, 0.09521960f, -0.06515752f, 
    -0.01104238f, -0.05911852f, -0.00086728f, 0.00426749f, 0.06581715f, 0.06610937f, 0.05440748f, 0.04321745f, 
    0.06177813f, -0.31154582f, 0.21580042f, 0.08072810f, 0.05327114f, 0.00634967f, -0.04246368f, 0.01965836f, 
    0.12258451f, 0.09923512f, -0.08655711f, -0.12639046f, 0.45039767f, 0.24645104f, 0.38608271f, 0.05801831f, 
    -0.08872166f, 0.15528226f, -0.13609223f, 0.08787588f, -0.11332873f, -0.03273398f, -0.06721529f, -0.02936850f, 
    0.00627145f, 0.04724957f, -0.16066314f, 0.12782128f, 0.14101113f, 0.02628286f, 0.08203962f, 0.06499670f, 
    0.05370113f, 0.08358321f, 0.05389345f, 0.12500492f, -0.13368823f, -0.48487079f, 0.09186015f, 0.64414996f, 
    0.11571002f, -0.06969742f, 0.10361697f, -0.12165386f, 0.04564828f, -0.03193680f, -0.00596660f, -0.06710944f, 
    0.01347555f, 0.17011647f, -0.14518675f, 0.01198280f, 0.01294604f, 0.10907965f, -0.02337827f, 0.12764770f, 
    0.04262647f, -0.10852256f, 0.11977532f, -0.25452065f, -0.24193248f, -0.11489970f, -0.03851517f, -0.04951579f, 
    -0.28240493f, -0.19062746f, -0.24830526f, 0.13984060f, 0.04330399f, 0.07795142f, 0.06407832f, 0.08170564f, 
    -0.36134705f, -0.15965642f, -0.25702354f, 0.09011649f, 0.05003560f, 0.09539144f, 0.24240279f, -0.23269102f, 
    0.03955757f, 0.11025854f, 0.12396254f, -0.03752207f, 0.32464850f, 0.14676930f, 0.07342038f, -0.03881568f, 
    0.12520190f, -0.06255503f, 0.01248328f, 0.08335026f, 0.06309170f, 0.04413743f, 0.09875957f, -0.12783819f, 
    -0.61902618f, -0.00841334f, -0.32134217f, 0.17134678f, 0.08516689f, -0.05761669f, -0.00824484f, -0.04361936f, 
    -0.04548457f, -0.11347994f, -0.06955402f, 0.08418496f, -0.30186325f, -0.32649842f, -0.02472650f, 0.18672121f, 
    0.03796871f, 0.00990719f, -0.04435215f, -0.05162741f, -0.14793408f, -0.12931547f, 0.08716606f, -0.13706484f, 
    0.24602385f, -0.07098263f, 0.12897187f, -0.00916314f, -0.10882051f, 0.13732274f, -0.08899044f, 0.08357822f, 
    -0.10119190f, -0.02371631f, -0.02544231f, 0.14179122f, -0.13856764f, -0.05699194f, 0.01225150f, -0.10673811f, 
    0.02073329f, 0.10018876f, 0.03676140f, -0.10956819f, -0.02629334f, -0.04360919f, 0.14260396f, -0.07611293f, 
    0.10537660f, -0.15557155f, 0.03271865f, 0.29080078f, 0.01244516f, 0.17838910f, -0.11242987f, 0.09565857f, 
    -0.24349874f, -0.03721434f, 0.13834003f, -0.03582214f, 0.25259289f, -0.24631298f, 0.29979256f, -0.20096560f, 
    0.00025303f, -0.07124150f, -0.29583541f, 0.24483639f, 0.06826148f, 0.03659309f, 0.16652116f, 0.12025681f, 
    -0.66406429f, 0.43020710f, -0.52447647f, 0.38165593f, -0.05022184f, 0.06125682f, 0.19901253f, 0.02252748f, 
    -0.02176979f, 0.09841607f, 0.06891533f, -0.01138562f, -0.01542309f, -0.02229646f, -0.18442644f, -0.17124437f, 
    0.08916313f, -0.08632831f, -0.05630475f, 0.02746053f, 0.00202970f, 0.01895205f, 0.07981308f, 0.10350581f, 
    -0.57114702f, -0.06178131f, -0.31418222f, 0.41649115f, -0.00445904f, 0.14227942f, 0.06219706f, 0.17316812f, 
    -0.25670373f, -0.01047982f, 0.03723144f, 0.10861995f, -0.11596183f, -0.07415713f, 0.27750444f, 0.29404360f, 
    0.15927458f, -0.06165220f, 0.09425920f, -0.05594760f, 0.03075125f, -0.09234402f, 0.05342097f, 0.12805682f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15702808f, 0.11766081f, 0.06483503f, -0.11844960f, -0.09708857f, 0.02299901f, 0.02176632f, -0.09081147f, 
    0.05325907f, 0.05102485f, -0.02036510f, -0.04084606f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
