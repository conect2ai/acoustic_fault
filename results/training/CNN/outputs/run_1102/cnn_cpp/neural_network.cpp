#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.34676817f, -0.14453317f, 0.15069364f, 0.57805616f, 0.61240822f, 0.56448710f, 0.61688381f, 0.72718960f, 
    0.74188489f, 0.46687573f, -0.09135421f, 0.04120007f, 0.18009622f, 0.08746794f, -0.06921250f, -0.15502787f, 
    0.13935938f, -0.06397653f, -0.13375787f, 0.16439433f, 0.27070484f, 0.01887099f, -0.21713850f, -0.28675327f, 
    0.21893315f, 0.91408390f, -0.55299747f, -1.25155962f, -1.60125875f, -1.34799361f, 0.61593664f, 0.49540111f, 
    0.74475408f, 0.43204957f, 0.00673467f, 0.07846472f, 0.26207086f, 0.17521758f, -0.25970891f, 0.11513314f, 
    0.12544119f, -0.17216153f, -0.07146257f, -0.30099472f, 0.31852475f, 0.42115104f, -0.04699560f, -0.34206465f, 
    0.10864289f, -0.01488889f, -0.56922907f, -0.98894376f, -0.14514577f, 0.09578773f, -0.35301447f, 0.75453722f, 
    0.37476394f, -0.65389037f, 0.20446467f, 1.19321287f, 0.12279719f, 0.12345175f, -0.16616829f, -0.14522333f, 
    0.09306066f, 0.03889236f, 0.12720072f, -0.28846717f, -0.25403520f, 0.03290337f, -0.10612108f, -0.34163561f, 
    -0.06671306f, 0.47572058f, -0.24453722f, 0.29801056f, -2.06564903f, -1.49673152f, 0.37502593f, 1.56948233f, 
    -0.08859062f, 0.50807798f, -1.31006563f, -1.47716129f, -0.80430537f, -0.43305141f, -0.82979983f, 0.05574668f, 
    -0.16320232f, -0.78053850f, -0.24825381f, -0.11076329f, -0.38515982f, -0.41428664f, 0.18916357f, -0.07809287f, 
    -0.00157890f, -0.02162300f, -0.20811613f, 0.17231204f, -0.35640106f, -0.91769749f, -0.65195793f, -0.18584476f, 
    -0.63104355f, -1.21207941f, -1.53376210f, -1.00202346f, -0.72893077f, -1.25439215f, 0.82168108f, 0.19691235f, 
    0.21933737f, -0.13496104f, 0.58509427f, 0.12596942f, 0.18798456f, 0.20570874f, -0.12739259f, 0.04634223f, 
    -0.07115696f, 0.23081625f, 0.18625841f, 0.00418913f, 0.06014061f, -0.58744413f, -0.97243273f, -0.60299033f, 
    -0.03639135f, -0.00064437f, -0.41313571f, 0.47579163f, -0.13110819f, -0.04519745f, 0.10564286f, 1.02734232f, 
    0.03317643f, 0.54676503f, 0.48223794f, 0.46031800f, 0.15483811f, -0.27012011f, 0.00853364f, -0.20137687f, 
    -0.17032902f, -0.04933726f, -0.03666048f, 0.25502965f, -0.35065958f, -0.21509543f, 0.64672607f, -0.83273977f, 
    -0.26918030f, 0.57535708f, -0.19076423f, 0.55972201f, 0.34441736f, 0.49060220f, -0.17595334f, 0.11674261f, 
    0.05547306f, 0.12742417f, -0.22839844f, 0.25202233f, 0.03671804f, 0.39209768f, -0.44721806f, -0.37868693f, 
    0.00968925f, 0.02093773f, 0.34320557f, -0.47571295f, -0.26454827f, 0.27967903f, 0.31439734f, 0.26881957f, 
    0.30877069f, 0.29764655f, 0.33584428f, 0.59268755f, -0.09038901f, -0.20614973f, -0.64276558f, -0.51227033f, 
    -0.34482589f, -0.82821888f, 1.06676698f, -0.68912733f, -0.42522278f, -0.28815120f, -0.12782927f, 0.29258448f, 
    -0.34152684f, -0.18025601f, 0.34905457f, 0.31053361f, -0.45277914f, -0.31190002f, -0.23478892f, -0.06377466f, 
    1.99523818f, 1.05403328f, -0.88968414f, -0.75635159f, -1.08759284f, -0.24559541f, 0.38671452f, -0.01218217f, 
    -0.49993220f, -0.30758238f, 0.25581262f, 0.44307050f, 0.38914111f, -0.21602088f, 0.01638512f, 0.04841299f, 
    -0.58806020f, 0.36934698f, -0.08806828f, 0.05973173f, 0.13687697f, -0.12034759f, 0.10079675f, 0.10567167f, 
    -0.24097966f, -0.56240779f, -1.01187181f, -0.31945354f, 0.26442769f, 0.70644426f, 0.50434881f, -0.39652914f, 
    -0.45200217f, 0.36607972f, 0.49039909f, -0.23949949f, -0.07394079f, -0.56992799f, -0.35946390f, 0.33208200f, 
    -0.12130659f, 0.54004586f, 0.41358349f, 0.13220724f, -0.33803183f, 0.09632105f, -0.06620453f, -0.17069690f, 
    -0.28400832f, 0.36445406f, -0.17655781f, -0.20938243f, -0.25978726f, 0.18922794f, -0.33523816f, -0.01207745f, 
    -0.05577356f, 0.03968239f, 0.37407145f, -0.30229899f, 0.81802684f, -0.18316048f, 0.19543657f, 0.28870225f, 
    -0.38076550f, -0.21507314f, -0.59279954f, 0.51565427f, 0.56840199f, 0.05210149f, 0.39278549f, 0.12069166f, 
    0.10197657f, -0.26796660f, 0.78776175f, -1.43163514f, -0.41519508f, -0.72471964f, -1.32632518f, -0.76144189f, 
    -0.05457880f, -0.24747919f, -0.52472281f, 0.16220064f, 0.72786945f, -0.17644966f, -0.43421334f, -0.42925245f, 
    -0.54485077f, -0.23320305f, 0.49485704f, 0.38930660f, 0.16235609f, 0.48154235f, 0.28227976f, -0.33172995f, 
    -0.34702668f, -0.19498679f, -0.38786593f, -0.49480367f, -0.87984800f, -0.84742743f, -0.85114491f, -0.14586531f, 
    -0.69577473f, 0.47887424f, 0.54596484f, -0.03054774f, -0.04399906f, 0.20681316f, 0.07293437f, -0.35055271f, 
    -0.17335053f, 0.27743518f, 0.20052959f, -0.45932764f, -0.16069917f, -0.49022371f, -0.74716187f, -1.01283956f, 
    -0.20563559f, 0.07187725f, 0.90779918f, 0.17618079f, -0.00554899f, 0.68619007f, -0.17185174f, -1.08951950f, 
    -0.70745629f, 0.57876414f, 0.00619954f, -0.37348375f, -0.59203494f, -0.58446330f, -0.07597867f, -0.63935095f, 
    0.71864051f, -0.59672004f, -0.22879477f, -0.00037439f, 0.21096164f, -0.03754165f, 0.21476504f, 0.12585257f, 
    -0.57807654f, 0.02664356f, 0.30128691f, 0.23569474f, 0.42957115f, 0.65735286f, -1.85771680f, -0.35554504f, 
    1.04861987f, -0.07060337f, -0.01459002f, 0.73732430f, 0.74032480f, -0.00676841f, -0.43062088f, -0.20888114f, 
    0.22424844f, 0.02703355f, -0.01988340f, -0.63236773f, -0.27356842f, 0.53046280f, 0.03690819f, -0.18688504f, 
    -0.08098365f, -0.03160285f, -0.01363523f, 0.10039120f, -0.13272712f, -0.03911909f, 0.33932176f, -0.82196516f, 
    -0.49255556f, -0.57055914f, 0.18856812f, -0.33351204f, -0.60866594f, -0.76461780f, -0.49779233f, -0.49864888f, 
    -0.18931618f, 0.11627608f, -0.80463016f, -0.17125699f, 0.18255094f, -0.29438704f, -0.34521985f, -0.31425855f, 
    -0.31126410f, -0.23076449f, -0.92694992f, -0.38417616f, -0.38821101f, -0.62182271f, -0.43024379f, -0.30846065f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01998210f, 0.47087431f, 0.49550399f, 0.47133088f, 0.00618630f, 0.34684959f, 0.74632943f, 0.29937920f, 
    0.72375584f, 0.52324826f, 0.28156185f, -0.11491132f, 0.37094960f, 0.39458445f, 0.73713601f, 0.35380295f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11824938f, -0.08928933f, -0.03622704f, 0.09164429f, 0.06142762f, 0.04742542f, 0.09821102f, 0.00605934f, 
    -0.17280170f, -0.07456657f, -0.05523120f, -0.25669932f, 0.13485239f, -0.36693001f, -0.36756557f, 0.03140033f, 
    0.23461603f, 0.16047604f, -0.36781901f, -0.10009107f, -0.24153557f, -0.02151911f, 0.12582652f, 0.09484256f, 
    0.25450236f, 0.15049225f, -0.09508297f, -0.08123406f, -0.10673534f, 0.05072800f, -0.08272804f, -0.10550333f, 
    -0.01978708f, 0.03800692f, -0.02049812f, -0.00595317f, 0.66883653f, -0.20440494f, -0.11926845f, -0.04752002f, 
    0.21372966f, -0.03317193f, 0.24677864f, -0.14495200f, -0.20364569f, -0.03050050f, -0.18357752f, -0.09108891f, 
    0.61705202f, 0.34042722f, -0.24847446f, -0.42583561f, 0.11132529f, 0.00222719f, -0.02924892f, 0.10676499f, 
    0.02304523f, 0.08038069f, 0.02629178f, -0.00576896f, 0.19567665f, 0.44600344f, -0.04781235f, -0.03045304f, 
    0.03116912f, 0.04400904f, -0.00503572f, -0.00196554f, 0.03654284f, 0.05480149f, -0.13954258f, 0.09623995f, 
    -0.67977506f, -0.27511871f, -0.09765597f, 0.03450205f, -0.02763199f, -0.05510524f, 0.03409354f, 0.01318917f, 
    -0.14159413f, -0.34175166f, -0.31584868f, -0.34848750f, -0.29012167f, 0.28483534f, -0.25585005f, -0.06280506f, 
    -0.13663934f, -0.06259142f, -0.03878783f, -0.03542339f, -0.14567663f, -0.05377997f, -0.00550727f, -0.08974868f, 
    -0.00178968f, -0.27286127f, -0.72618389f, 0.03113773f, -0.13888627f, -0.28029996f, -0.01351504f, -0.02267645f, 
    -0.16713640f, 0.02831917f, -0.07316257f, -0.06419869f, 0.28001529f, 0.26940197f, 0.00501799f, -0.24472941f, 
    -0.05165486f, -0.03111553f, -0.02966921f, -0.06346887f, 0.11823247f, 0.04053394f, 0.03806480f, -0.27160078f, 
    -0.02754608f, 0.08764915f, 0.15720908f, -0.10524228f, 0.08401676f, -0.12124417f, -0.12938227f, -0.20674713f, 
    -0.00936166f, -0.13871902f, -0.13226879f, -0.16900933f, 0.36281449f, 0.44071525f, 0.00435148f, -0.15350747f, 
    0.08009329f, 0.28853497f, 0.03382741f, 0.13707368f, -0.05118300f, 0.14130044f, 0.09311604f, 0.13487829f, 
    0.24807909f, -0.03566382f, -0.28685960f, -0.02330884f, 0.16068603f, 0.11396485f, -0.03790743f, -0.46589917f, 
    -0.04341470f, -0.38029605f, -0.36659846f, 0.00549074f, 0.13556042f, 0.42539248f, -0.49696285f, 0.00222627f, 
    0.02363609f, -0.10977774f, -0.14291118f, -0.11218988f, 0.00495019f, -0.04037473f, 0.02516442f, -0.09291198f, 
    0.60690886f, 0.24432604f, -0.20548387f, -0.65502751f, -0.41259155f, -0.20731799f, 0.17047518f, 0.05287117f, 
    -0.16685610f, -0.11592393f, -0.16027886f, -0.14337370f, 0.46641922f, 0.25115311f, 0.21125926f, -0.19909853f, 
    -0.02899786f, 0.12149411f, -0.08802222f, 0.13109754f, -0.22333209f, -0.31726262f, -0.15793611f, 0.08003988f, 
    0.31865054f, 0.23088658f, 0.26795501f, 0.19911911f, -0.08098277f, 0.05384224f, -0.07732753f, -0.02528841f, 
    0.04901246f, -0.09870774f, 0.03131388f, 0.06715372f, 0.51402086f, -0.44413507f, -0.14143749f, -0.24404722f, 
    0.00385024f, 0.21958172f, -0.00277147f, -0.22636625f, 0.07091651f, -0.09361137f, -0.12770927f, -0.09165592f, 
    0.77380562f, 0.17207921f, -0.20169152f, -0.19292279f, -0.01925939f, -0.07747190f, 0.06565025f, -0.20937413f, 
    -0.01201632f, -0.17059083f, 0.10432390f, -0.04672467f, -0.10170565f, -0.19562206f, 0.13648796f, 0.08999611f, 
    0.18238886f, -0.17585632f, 0.34497911f, -0.07107010f, 0.08963095f, 0.03561434f, -0.03806752f, -0.05051486f, 
    -0.42995381f, 0.28092727f, 0.03387389f, 0.25527465f, -0.13652305f, -0.09541973f, -0.05214661f, -0.11634758f, 
    -0.08676574f, 0.03219765f, -0.06118614f, 0.13961093f, -0.49554363f, -0.26696837f, -0.23912120f, -0.15956961f, 
    -0.06154750f, 0.15809619f, 0.17627037f, 0.04870376f, -0.07519075f, 0.05896915f, 0.09938245f, -0.02571465f, 
    0.62543267f, -0.03712550f, -0.00825233f, 0.22450702f, -0.09656515f, 0.00280997f, 0.13110039f, -0.25410131f, 
    0.14771153f, -0.05244720f, 0.10363226f, 0.01976780f, 0.32172066f, 0.20744544f, -0.52607423f, -0.29301023f, 
    0.00823127f, -0.13659504f, -0.31357419f, -0.08750354f, 0.05383190f, -0.03465688f, -0.15208364f, 0.08654778f, 
    0.51202661f, -0.57789814f, -0.11185261f, -0.27472916f, -0.03366824f, -0.16100258f, -0.19155778f, 0.20256987f, 
    0.00396660f, -0.02785234f, -0.10158466f, 0.23081218f, -0.20919058f, 0.17829195f, -0.31846067f, -0.18539824f, 
    0.11663420f, 0.06095837f, -0.26346132f, 0.09020098f, 0.11452547f, -0.11122163f, -0.21895599f, 0.03376668f, 
    -0.24663308f, 0.05906823f, -0.07087924f, -0.19113384f, 0.05067094f, 0.19511853f, -0.21636668f, 0.04693946f, 
    -0.16137931f, -0.02062834f, 0.09267221f, 0.07640964f, 0.12409986f, 0.38585639f, 0.17424698f, 0.15614727f, 
    0.02841064f, -0.16898921f, -0.44573513f, -0.31963286f, -0.03133139f, -0.10881981f, -0.15143730f, -0.11452787f, 
    -0.17452158f, -0.10339665f, 0.17919584f, -0.36383131f, 0.01468794f, 0.14911075f, 0.27737483f, 0.25773790f, 
    0.00540573f, -0.05810953f, 0.11324973f, -0.15564363f, 0.50720984f, 0.15724637f, -0.06484792f, 0.26859534f, 
    -0.27994195f, 0.15122737f, 0.16605544f, -0.08246329f, -0.01925070f, 0.01571474f, -0.10060625f, 0.02631077f, 
    0.01527395f, -0.33081672f, -0.00706239f, 0.31715068f, 0.16298604f, 0.14847928f, 0.08458234f, -0.05594761f, 
    0.08210273f, 0.06427844f, -0.19360974f, 0.36795920f, -0.01063367f, -0.03596431f, 0.03114063f, 0.06761922f, 
    -0.04601461f, -0.14188544f, 0.13192782f, 0.02964879f, -0.05228761f, 0.02397375f, -0.13287707f, -0.28585672f, 
    -0.24499607f, -0.25447798f, -0.14403379f, 0.12626280f, -0.08049331f, 0.03489488f, 0.12677012f, 0.09282240f, 
    -0.11321244f, -0.01082669f, -0.13341463f, -0.39354506f, -0.13828355f, 1.13130367f, 0.55807078f, 0.40518358f, 
    -0.17227899f, -0.08730014f, 0.34413427f, -0.17632326f, 0.03433654f, 0.12706943f, -0.28274885f, 0.03160058f, 
    0.11981399f, -0.05516768f, 0.34144282f, 0.17249291f, 0.07676703f, 0.02945244f, 0.06937636f, -0.10322114f, 
    0.01581846f, -0.00182369f, -0.17375889f, 0.19344440f, 0.02017709f, 0.07121378f, -0.06987507f, -0.11102443f, 
    -0.16702500f, -0.12939414f, -0.00860725f, -0.15875842f, 0.00330462f, -0.08024301f, 0.01125952f, -0.22942832f, 
    -1.60890698f, -0.98809940f, -0.52962977f, -0.42420992f, -0.22922735f, -0.07136381f, -0.16925453f, -0.24895659f, 
    -0.00563427f, -0.03369431f, -0.03314703f, -0.02945125f, 0.09784217f, -0.13510804f, 0.20251264f, -0.00928622f, 
    -0.11794668f, -0.11185385f, 0.15473227f, -0.08920367f, -0.09834659f, -0.03055601f, -0.01140344f, 0.13023850f, 
    -0.18657789f, 0.10584180f, 0.03356428f, 0.00777538f, -0.04042681f, -0.01456519f, -0.01717198f, 0.14980516f, 
    0.02508763f, -0.06372768f, 0.16170420f, 0.21882036f, 0.02507326f, 0.10035586f, 0.04450379f, -0.31184033f, 
    0.07692830f, -0.00101873f, -0.00481895f, 0.16549230f, -0.02647332f, -0.09399009f, -0.21053338f, 0.07713896f, 
    -0.45898059f, 0.04799170f, 0.15054052f, -0.49594724f, -0.05646191f, -0.24712296f, -0.42528042f, -0.26015034f, 
    0.15830155f, 0.01105464f, 0.09912110f, -0.02822554f, -0.18304014f, -0.00436436f, 0.20283216f, 0.49378690f, 
    0.05703401f, 0.04133961f, -0.33384427f, 0.14869322f, -0.02796448f, 0.01803114f, -0.11591806f, 0.00678335f, 
    -0.16094354f, 0.36845130f, -0.22961171f, -0.30265746f, -0.15367526f, 0.15296993f, -0.21837638f, 0.15519495f, 
    -0.08331359f, -0.09261539f, 0.00729779f, -0.20471482f, -0.04255013f, 0.31694269f, 0.15533862f, 0.50573963f, 
    0.09119682f, 0.07818674f, 0.04440621f, 0.17961720f, -0.01192402f, 0.09073489f, 0.02973902f, 0.15365504f, 
    -0.10825874f, 0.28840774f, 0.80069852f, 0.10694189f, -0.05328031f, -0.05050385f, 0.10888442f, -0.14617278f, 
    -0.09665157f, -0.33306015f, 0.06049486f, -0.22728568f, -0.19259484f, -0.24688941f, 0.27531818f, -0.05645803f, 
    0.02082565f, -0.04890840f, -0.13558950f, 0.06463149f, -0.02205010f, -0.18342763f, -0.03817561f, -0.02761946f, 
    0.29810074f, -0.17349893f, 0.07391372f, 0.17862712f, 0.13014702f, 0.00805678f, -0.37767756f, 0.31304452f, 
    0.01103249f, 0.03128592f, 0.04731461f, 0.00469967f, -0.42425504f, 0.12167621f, 0.30774817f, 0.05221602f, 
    0.10478900f, -0.07542189f, -0.30587709f, -0.05297761f, -0.10681491f, -0.02401112f, 0.05611075f, 0.01972222f, 
    -0.23131268f, 0.02438668f, -0.25323483f, -1.03163242f, 0.33415994f, 0.20175968f, 0.33447856f, 0.13449849f, 
    -0.19483705f, -0.12303769f, -0.13775806f, -0.14270182f, 0.04293335f, -0.06562713f, 0.09797565f, 0.79380608f, 
    0.00455276f, 0.04492245f, 0.16406813f, 0.08358538f, 0.03259858f, 0.14421269f, 0.10382551f, 0.20761077f, 
    -0.89511389f, -0.25192502f, 0.05624759f, -0.16743363f, 0.18533374f, 0.15499812f, -0.01932119f, -0.30507588f, 
    -0.14027800f, 0.00122419f, -0.12915632f, 0.20110483f, -0.15781653f, 0.55123639f, -0.57413203f, 0.50566781f, 
    0.14252174f, -0.04880634f, -0.19533692f, -0.01172255f, -0.07882222f, -0.03453130f, -0.12130936f, -0.09482417f, 
    0.06686817f, -0.42951146f, -0.19272067f, 0.09098332f, 0.20106681f, 0.16090445f, 0.01526281f, 0.16131839f, 
    0.07935394f, -0.12218115f, 0.05649874f, -0.06505293f, 0.00215770f, -0.18960790f, -0.35210833f, -0.12171918f, 
    0.05066541f, 0.10613477f, 0.02674517f, -0.12119346f, -0.12176627f, -0.07348653f, 0.13965926f, -0.21869110f, 
    -0.71006358f, 0.43038413f, -0.14351051f, -0.24827173f, 0.30935204f, -0.46021369f, 0.02160408f, -0.08472845f, 
    -0.38625878f, -0.08772672f, 0.03922829f, -0.09163740f, -0.00728968f, 0.27682918f, 0.23700209f, -0.03509564f, 
    -0.05555473f, 0.15205018f, 0.10148898f, -0.10894456f, 0.05891254f, 0.04171530f, -0.22707362f, 0.14365758f, 
    -0.79653448f, 0.24298863f, 0.09884416f, 0.68631780f, -0.14700006f, 0.11959200f, -0.12807727f, -0.09376281f, 
    -0.13271961f, -0.14669335f, 0.32448557f, -0.18360728f, 0.10433117f, 0.32404512f, -0.35086071f, -0.48190325f, 
    0.03008457f, -0.05732951f, 0.04266214f, 0.05709659f, -0.26961696f, -0.03341550f, -0.06085468f, -0.06371795f, 
    -0.21774748f, -0.18150699f, 0.03667061f, 0.04175247f, -0.13083276f, 0.02770449f, -0.49330845f, -0.10539906f, 
    0.17173809f, -0.00714033f, 0.40996447f, -0.20999809f, 0.53629297f, -0.36645856f, -0.08447712f, 0.14240855f, 
    0.10880215f, 0.08154635f, 0.10699840f, -0.20027851f, -0.00315860f, -0.03367636f, -0.02399726f, 0.33417621f, 
    0.11794158f, -0.03986223f, 0.12826249f, 0.30005944f, -0.03008714f, 0.08359767f, 0.07790314f, -0.09640282f, 
    -0.15000658f, 0.01223899f, -0.03095148f, 0.16873932f, 0.07589339f, -0.03159671f, 0.17947406f, 0.24722661f, 
    0.19056685f, -0.20131560f, 0.06315101f, -0.05188330f, -0.05090889f, -0.19161732f, 0.06308586f, -0.15599880f, 
    -0.11014327f, 0.57374644f, 0.03974190f, -0.38834512f, 0.12893993f, -0.14295198f, -0.33199474f, -0.13189313f, 
    -0.43894073f, -0.04198358f, -0.04254466f, -0.00740025f, -0.07238596f, -0.05369775f, -0.13973276f, 0.12501270f, 
    -0.01880579f, 0.03451556f, -0.12534125f, 0.09499221f, -0.14139579f, 0.17084971f, 0.16564676f, 0.06511870f, 
    0.20205688f, 0.07122971f, -0.03052268f, -0.07714882f, 0.03045814f, 0.04344761f, 0.09884363f, 0.18133295f, 
    -0.05285715f, 0.30489993f, -0.05171020f, -0.04538522f, -0.05480986f, 0.11452340f, 0.07469926f, -0.08860788f, 
    -0.02447916f, -0.14426070f, -0.16088592f, -0.11843764f, 0.09143443f, 0.11330023f, -0.06176228f, 0.20213214f, 
    0.15000987f, 0.08234732f, -0.38967672f, 0.03353460f, -0.08266693f, -0.01947750f, 0.03123334f, 0.16485354f, 
    -0.25463319f, -0.09037782f, -0.08254722f, 0.03029237f, -0.08869493f, -0.08721954f, 0.55410230f, -0.33901584f, 
    0.03627988f, 0.25740191f, -0.24661988f, -0.09084912f, -0.19402650f, -0.11458606f, 0.00636144f, 0.02246422f, 
    0.14662305f, 0.39670354f, 0.63759804f, 0.20347881f, -0.06313963f, -0.11039927f, 0.08105049f, 0.30756167f, 
    0.08770613f, -0.06784975f, 0.13796659f, 0.02957930f, 0.29441023f, 0.09549940f, 0.03547448f, 0.13784398f, 
    -0.03331788f, -0.13760412f, 0.02048811f, -0.01227509f, 0.18586691f, 0.00250753f, -0.18985502f, 0.06107186f, 
    0.14656375f, -0.25203964f, -0.13015558f, 0.01747850f, -0.08337999f, 0.12209269f, -0.09558809f, 0.06164302f, 
    -0.24265449f, -0.13939594f, -0.43438071f, 0.00863036f, 0.19717643f, -0.10994947f, 0.04904433f, 0.47696295f, 
    0.06273910f, -0.05062737f, 0.02250252f, 0.31453034f, -0.06270655f, 0.03833226f, 0.03531000f, -0.19711025f, 
    -0.21805882f, 0.05786461f, -0.21636577f, -0.10460458f, 0.28162202f, 0.07733207f, -0.02758696f, -0.35863155f, 
    0.20556153f, -0.05178490f, 0.07469323f, -0.05171153f, 0.05563021f, -0.26071987f, -0.05186984f, 0.04314828f, 
    -0.31541681f, 0.03769587f, -0.06546068f, -0.24204366f, -0.16679814f, 0.04701207f, -0.06065420f, -0.20713997f, 
    0.18602055f, 0.01851804f, 0.13778068f, -0.16456027f, -0.14258456f, 0.00021295f, 0.02284835f, 0.13897498f, 
    0.10732044f, 0.00881546f, -0.42259344f, -0.19976379f, -0.34304518f, -0.08796712f, 0.17432763f, 0.16696632f, 
    -0.08919764f, -0.13290444f, -0.01872277f, 0.02222875f, 0.08054191f, 0.12231033f, -0.01660725f, 0.11615133f, 
    0.16464420f, 0.25436273f, 0.02689936f, 0.27019456f, -0.15999117f, -0.26483339f, -0.00450968f, -0.26013762f, 
    0.09951765f, -0.26799494f, -0.01905883f, 0.03571727f, -0.06099790f, -0.30831212f, 0.03203363f, -0.04491246f, 
    -0.04323812f, -0.01137928f, -0.09907937f, -0.17143857f, -0.02393256f, 0.06173428f, -0.07466197f, -0.16659939f, 
    0.08298904f, -0.70765835f, -0.29146397f, 0.28507295f, 0.04088785f, 0.03642017f, 0.14457153f, -0.42807800f, 
    -0.21534733f, -0.16186841f, 0.07601719f, -0.36397973f, -0.02137496f, 0.00285448f, 0.05086408f, 0.11635655f, 
    0.03244105f, 0.03381144f, 0.00074643f, -0.07609487f, -0.03469543f, 0.21885937f, 0.05244897f, 0.25327179f, 
    -0.24196674f, -0.40369114f, -0.12814626f, 0.16720521f, 0.02327927f, -0.14630581f, -0.13776393f, -0.13858363f, 
    -0.10966566f, -0.06102655f, -0.01846305f, 0.16745494f, -0.23114245f, -0.41499913f, -0.51230681f, -0.46550745f, 
    0.09306939f, -0.00613801f, -0.16149014f, 0.29166391f, -0.02221861f, -0.15798643f, 0.02058758f, -0.03876823f, 
    -0.70899230f, -0.59319127f, 0.25802898f, -0.03244639f, -0.07466916f, -0.04111136f, 0.05523552f, 0.29883707f, 
    0.25261214f, 0.03413267f, 0.08028598f, -0.06892575f, 0.17457856f, 0.41605628f, 0.17474823f, -0.27880517f, 
    -0.14134301f, 0.01440575f, -0.10375518f, 0.06596906f, 0.09998655f, 0.02168059f, -0.07827371f, 0.03297042f, 
    0.23991179f, 0.15791222f, 0.14886552f, -0.00130401f, 0.27620584f, 0.29686552f, 0.23224884f, -0.36110261f, 
    0.11054195f, 0.04898917f, 0.01278511f, -0.00723100f, 0.22181222f, 0.03235921f, 0.09926938f, -0.05217536f, 
    0.05582051f, -0.11376312f, -0.17025773f, 0.04840522f, 0.00038157f, -0.12769751f, -0.10325975f, -0.13372387f, 
    -0.23220496f, -0.19056271f, 0.04493521f, -0.13130817f, 0.16083074f, -0.04560998f, -0.01456665f, 0.09812061f, 
    0.21496287f, 0.39827532f, 0.00075480f, 0.14353593f, -0.16660641f, -0.41728780f, 0.18256009f, 0.09482328f, 
    0.06689588f, -0.01830717f, -0.14573684f, 0.12006772f, -0.06513306f, -0.18698177f, 0.27187476f, -0.10944019f, 
    0.43708295f, -0.02117307f, -0.61962050f, -0.47920179f, -0.00975167f, 0.16037209f, 0.01570350f, 0.03094613f, 
    0.00005245f, -0.10249586f, -0.20368411f, -0.28375071f, -0.15393864f, -0.30168474f, 0.51229542f, -0.05762943f, 
    -0.09356587f, -0.11785565f, 0.03179098f, 0.04707903f, -0.06101470f, -0.08655398f, 0.35671869f, 0.14986208f, 
    0.09857297f, -0.20194611f, -0.15182397f, 0.13990766f, 0.08748550f, 0.07697440f, 0.27596459f, -0.23672862f, 
    0.13170931f, 0.16387771f, 0.04547103f, 0.22895168f, -0.31461141f, 0.07492574f, -0.02520817f, -0.24676771f, 
    -0.11767764f, -0.06470222f, -0.08166575f, 0.06235401f, -0.13636005f, -0.11872163f, -0.00052708f, 0.02756589f, 
    -0.30548552f, -0.02708036f, -0.25970674f, -0.32091862f, -0.00589789f, -0.06522898f, -0.15246823f, -0.03967974f, 
    0.13978305f, 0.24728712f, -0.14758557f, -0.10539105f, -0.24312092f, 0.27737665f, 0.10682285f, -0.54764754f, 
    0.24552292f, 0.17868641f, 0.00768316f, 0.07621783f, 0.19934106f, -0.01796500f, 0.13856052f, 0.41203868f, 
    -0.65974820f, 0.41182092f, 0.03389826f, 0.11908673f, 0.19976087f, -0.05178047f, 0.21811561f, 0.14448354f, 
    0.16137032f, -0.18227638f, -0.07622546f, 0.21908702f, -0.00677048f, 0.18385436f, 0.21893527f, -0.08895122f, 
    -0.03189075f, 0.09638552f, 0.14826229f, -0.10152957f, 0.33635855f, -0.35847771f, -0.22687370f, -0.08602952f, 
    -0.28940985f, -0.02449170f, 0.16586089f, -0.02346388f, -0.02387536f, -0.19102183f, -0.14000376f, -0.04987425f, 
    0.04669895f, 0.20877858f, 0.00801868f, 0.07369921f, 0.39459071f, 1.21577668f, -0.04691442f, 0.33149531f, 
    -0.07409525f, -0.00409736f, -0.22700137f, 0.04189546f, 0.17796481f, 0.06331709f, 0.10800296f, 0.01633755f, 
    -0.05562076f, 0.13844948f, 0.05287700f, 0.32392317f, -0.00865426f, -0.01586887f, 0.05444228f, 0.33731693f, 
    0.04891314f, 0.10028929f, 0.02930483f, -0.09177005f, -0.48273119f, -1.44147074f, 0.00539122f, 0.77885306f, 
    0.19330351f, 0.04292155f, -0.18243574f, 0.06276327f, -0.00313347f, 0.03396843f, 0.09128930f, 0.07344293f, 
    -1.43079424f, -1.04235697f, -0.52024108f, -0.31914505f, -0.34848621f, -0.01872110f, -0.28243530f, -0.52382195f, 
    -0.01377772f, -0.14459132f, -0.05105700f, -0.00076960f, -0.22794111f, 0.41292232f, 0.27696076f, -0.16425666f, 
    -0.12483902f, 0.05117135f, -0.24517466f, -0.11297915f, 0.02268331f, -0.20121256f, 0.17574950f, 0.02136653f, 
    -0.00467470f, 0.09974055f, 0.19829652f, 0.04824559f, 0.02917436f, -0.07214912f, 0.14030360f, -0.10065646f, 
    0.16703478f, 0.07786135f, 0.21066150f, -0.15715496f, -0.60389274f, -0.47556171f, -0.18270628f, -0.10213943f, 
    0.02274012f, 0.16044906f, 0.21393497f, -0.33237752f, 0.07973903f, 0.07977229f, 0.18442580f, 0.06673045f, 
    0.83171594f, 0.36355963f, -0.15468492f, -0.36406887f, 0.14707577f, -0.24533187f, 0.28734890f, -0.20855327f, 
    0.01670809f, 0.09349586f, -0.22431697f, 0.04919086f, -0.22288381f, -0.12536442f, -0.17354168f, 0.30105373f, 
    0.23956244f, -0.03222169f, 0.18717650f, 0.20748189f, 0.11218036f, 0.08345753f, 0.18983497f, 0.11808904f, 
    -0.25967386f, 0.07388168f, 0.37174058f, 0.08230884f, 0.14423551f, -0.21529457f, 0.00424273f, -0.42053205f, 
    -0.28349832f, -0.24716078f, -0.32499835f, -0.03208617f, -0.89405644f, -0.86251485f, -0.26266897f, 0.24087526f, 
    -0.41323650f, 0.16138276f, 0.24401146f, 0.08507291f, 0.02975247f, 0.12376445f, 0.11293842f, -0.07399506f, 
    -0.51243716f, 0.28362834f, 0.44714218f, -0.30648187f, -0.11504954f, -0.03628070f, -0.19845094f, 0.16085958f, 
    -0.05311405f, 0.11351769f, 0.20111065f, 0.11080831f, -0.30405679f, -0.74636263f, -0.17785145f, -0.25462121f, 
    -0.08572020f, -0.13036461f, -0.04735851f, -0.20698851f, -0.00567570f, -0.11701682f, -0.12172995f, -0.29050750f, 
    -0.06013245f, -0.37131739f, 0.70794088f, -0.22580890f, -0.04842059f, -0.23989074f, -0.05649187f, -0.25857800f, 
    -0.10580116f, 0.15007296f, 0.16488560f, -0.22460151f, -0.37450248f, -0.62670141f, -0.55475873f, -0.31617898f, 
    -0.42771170f, -0.05092778f, 0.26197779f, -0.14638804f, -0.05411181f, 0.10448147f, 0.08059402f, -0.06940458f, 
    0.29955134f, 0.20661409f, -0.09443411f, -0.22879335f, 0.02385941f, 0.06441119f, -0.03559120f, -0.07355579f, 
    -0.17571737f, -0.13856505f, -0.18390028f, -0.19471349f, -1.08773971f, -0.83067572f, -0.63212705f, -0.03169565f, 
    -0.30290180f, -0.20583132f, 0.34116319f, -0.30294949f, 0.08844846f, -0.06607550f, 0.02211474f, 0.05170691f, 
    0.43239945f, -0.27547470f, 0.12456344f, -0.46617028f, -0.11926468f, 0.01728973f, -0.23627765f, -0.12695634f, 
    0.21340238f, 0.11172903f, -0.18821999f, -0.15980734f, -0.69502562f, -0.20890860f, 1.21956098f, -0.55367666f, 
    -0.11312167f, -0.10423657f, 0.19310346f, 0.02021617f, -0.04347075f, -0.11405846f, -0.02427757f, -0.20160334f, 
    -0.95048451f, -0.74654150f, 0.01472823f, 0.80460751f, 0.25091067f, 0.01342099f, 0.07781091f, 0.14295341f, 
    0.03986212f, 0.09680165f, 0.00214335f, -0.02469894f, 0.33880797f, -0.43767807f, -0.15975583f, -0.12177153f, 
    0.22671343f, 0.05191293f, 0.04135114f, -0.09766603f, 0.05214272f, 0.17285259f, 0.20146865f, 0.08247253f, 
    0.01660422f, 0.03495392f, -0.09135331f, -0.18563507f, -0.04306530f, 0.11919042f, -0.04018778f, -0.03514089f, 
    -0.01418703f, -0.09606403f, -0.38127401f, 0.09992170f, 0.08383475f, -0.19062819f, -0.17295168f, -0.36886245f, 
    0.07147371f, -0.29417765f, -0.16163798f, -0.13926145f, -0.07733922f, 0.06947988f, -0.02394411f, -0.01733555f, 
    -0.78040016f, 0.54139173f, 0.09417073f, 0.35579896f, -0.09175585f, -0.22114748f, 0.11236227f, 0.15730494f, 
    0.02273759f, -0.02297074f, 0.25977695f, 0.06247151f, 0.47930548f, -0.84189242f, 0.16622075f, -0.79332668f, 
    0.06045266f, 0.26329839f, -0.31982249f, -0.03147731f, 0.16463280f, 0.02305233f, 0.01347498f, -0.07414283f, 
    0.12138259f, -0.03546221f, -0.12607045f, -0.13714907f, -0.06526489f, -0.19583395f, -0.08582126f, 0.23461843f, 
    -0.00110274f, 0.12429257f, 0.04894359f, 0.08299118f, 0.40065175f, -0.43969929f, -0.37785918f, -0.12752792f, 
    -0.09778706f, 0.05667187f, -0.00733588f, 0.33765432f, -0.00326889f, -0.10280477f, -0.18807036f, 0.08941042f, 
    1.06599188f, -0.61040282f, -0.52152681f, -0.76320052f, -0.09464481f, -0.24919286f, 0.03302644f, 0.12903579f, 
    -0.02698902f, 0.30327132f, 0.20354623f, 0.00665786f, -0.65310550f, 0.12820290f, 0.18997203f, -0.19119899f, 
    -0.15210411f, -0.48296899f, -0.01201121f, 0.12267715f, 0.09717058f, 0.13030267f, 0.03938805f, -0.06732710f, 
    0.29545185f, 0.38179928f, -0.05849671f, 0.13750549f, -0.07457873f, -0.02355178f, -0.12937030f, 0.09300850f, 
    -0.02941388f, -0.03484261f, 0.04100381f, -0.06904461f, -0.25496092f, -0.42718035f, 0.01457203f, 0.30526602f, 
    0.01383306f, -0.05071693f, -0.00433027f, 0.06550688f, 0.12395889f, 0.09775332f, -0.05757879f, 0.03289414f, 
    -0.18574606f, -0.20863378f, -0.02860326f, -0.42675203f, -0.08031666f, -0.03707945f, 0.03899432f, 0.05336881f, 
    0.13470587f, 0.00689777f, 0.14817956f, 0.08348554f, -0.57067007f, -0.64941853f, 0.03955107f, 0.73697895f, 
    -0.10249387f, 0.38280591f, 0.29683214f, 0.04288977f, -0.19435528f, 0.10077574f, 0.24597342f, -0.07271758f, 
    -0.09894494f, -0.49362540f, 0.09124687f, 0.19994000f, 0.04174944f, 0.12366515f, 0.17992133f, 0.12716943f, 
    0.12811001f, -0.26139027f, 0.13064900f, -0.03683401f, 0.83248484f, -0.41856724f, -0.27381977f, -0.21751191f, 
    -0.44397566f, 0.16981211f, 0.02151857f, -0.19849530f, 0.15958358f, 0.04148288f, 0.11523553f, 0.11749817f, 
    -0.09365836f, -0.61929840f, -0.38501903f, -0.05400687f, 0.09961365f, -0.12521255f, -0.14660700f, 0.05509061f, 
    -0.06221385f, 0.00257586f, -0.05151706f, 0.17382528f, 0.16549397f, -0.35318136f, -0.18043019f, -0.39489079f, 
    -0.12782694f, 0.09873748f, -0.03641058f, 0.19417953f, 0.07197469f, -0.31772879f, -0.25708356f, -0.50090903f, 
    -0.09669705f, -0.17627336f, 0.11455397f, -0.30027997f, -0.17602235f, 0.06867595f, 0.09781376f, -0.11317223f, 
    0.12627631f, 0.06518367f, 0.23857601f, -0.09601206f, 0.10247277f, 0.68767935f, 0.42182067f, 0.05059953f, 
    -0.20812865f, 0.11717327f, -0.05894816f, -0.48771894f, -0.14048801f, 0.01473908f, -0.22031568f, -0.11251517f, 
    -1.25812161f, -0.17189156f, 0.33838430f, 0.27207687f, -0.02797613f, 0.31560084f, -0.08853047f, 0.06590658f, 
    -0.11634172f, -0.06371125f, 0.03232019f, 0.20758204f, 0.06557450f, 0.21741179f, -0.12913409f, -0.26448402f, 
    0.07236233f, -0.31991735f, 0.04839221f, -0.00626057f, -0.06777453f, 0.07660295f, -0.01161122f, 0.22105914f, 
    0.19925591f, -0.12520996f, -0.15598707f, 0.00488522f, 0.08124843f, -0.01598896f, 0.24682283f, 0.14713410f, 
    -0.02492996f, 0.01917137f, 0.25587374f, 0.10165034f, -0.01175899f, -0.45428479f, -0.53905219f, 0.10336669f, 
    0.05320025f, 0.05536291f, -0.04084004f, -0.08835483f, -0.17965218f, -0.19583169f, -0.15271057f, -0.30983326f, 
    -0.65004188f, -1.08101857f, -0.13107643f, -0.07469627f, 0.08321761f, 0.47533309f, 0.15255280f, 0.23857637f, 
    0.14096798f, 0.25744691f, 0.05525091f, 0.19608043f, -0.24189265f, -0.59052819f, -0.14434136f, 0.09066238f, 
    0.12953177f, 0.18423869f, 0.09354810f, 0.10157590f, 0.00173693f, 0.20861524f, 0.12085526f, 0.19519748f, 
    0.29623163f, 0.23540898f, -0.28529185f, -0.01804327f, -0.21887754f, -0.08045074f, -0.10658015f, 0.23476440f, 
    0.12827359f, 0.28639397f, -0.09759451f, -0.04357113f, 0.35811099f, -0.01862229f, -0.41125423f, -0.41554174f, 
    0.20025793f, -0.04019712f, 0.10952459f, -0.03774492f, 0.07546812f, -0.09167241f, -0.17809458f, -0.41230175f, 
    -0.17735714f, 0.00550257f, 0.18286224f, 0.36863604f, 0.05033409f, -0.02540813f, -0.01492089f, 0.00607485f, 
    0.15569989f, 0.09491792f, 0.12820317f, 0.17642143f, -0.12231985f, 0.11435204f, 0.60206532f, -1.50084686f, 
    0.18880050f, -0.32528439f, -0.01322801f, 0.06179323f, -0.22787444f, -0.03239209f, 0.19899182f, 0.05053165f, 
    0.21332945f, 0.08805133f, 0.31968930f, 0.06459229f, -0.21406896f, 0.18423976f, -0.42311072f, -0.45530814f, 
    -0.20623596f, 0.09926815f, 0.19657347f, -0.02945070f, -0.48477826f, -0.90902412f, 0.29917660f, -0.64500469f, 
    -0.06150911f, -0.01090653f, -0.05216587f, 0.12188492f, -0.01186701f, 0.07136413f, 0.15584314f, -0.01635720f, 
    0.28332588f, -0.30759692f, -0.08405580f, -0.22819963f, 0.12812017f, -0.20152479f, 0.22730017f, 0.47900844f, 
    -0.06827816f, 0.00255991f, 0.03184010f, -0.06645092f, 0.20513627f, 0.05674711f, 0.60807055f, 0.19502464f, 
    0.08385625f, -0.29286364f, -0.20071761f, -0.01923728f, 0.13595851f, 0.00269267f, 0.20502494f, -0.02213503f, 
    -0.02806205f, -0.12666970f, 0.12279128f, 0.02947015f, -0.03999351f, -0.07281370f, -0.42165664f, -0.02839629f, 
    -0.23392782f, -0.00636120f, 0.00848939f, -0.24310386f, -0.34605870f, -0.87763065f, -0.19730881f, -0.36305925f, 
    0.17051476f, 0.15685157f, 0.01172410f, 0.16190252f, -0.10454402f, -0.11570174f, 0.11349641f, -0.06485569f, 
    0.03176809f, 0.78640991f, 0.39477444f, -0.94712025f, 0.03659614f, -0.05484845f, 0.11528328f, 0.18876700f, 
    0.15459616f, 0.05920036f, -0.19152081f, 0.08973981f, 0.65135550f, -0.42585650f, 0.41341984f, 0.02146377f, 
    -0.04408468f, 0.08421338f, 0.02693778f, -0.22627378f, 0.10500464f, -0.14443898f, -0.15033042f, 0.13273452f, 
    0.12200458f, -0.13845132f, 0.13902424f, -0.37802312f, 0.11170134f, -0.14037508f, 0.10635797f, -0.18428352f, 
    0.19063485f, 0.05244065f, -0.21422620f, 0.03307157f, -0.21434709f, -0.03154602f, 0.34289965f, -0.31777284f, 
    -0.15386871f, -0.11088774f, 0.11933300f, -0.09788905f, 0.26066372f, -0.00428092f, 0.15228097f, 0.10358682f, 
    0.23618177f, 0.32818875f, -0.01434062f, 0.16511977f, -0.13679424f, -0.19236465f, -0.41678542f, 0.05694678f, 
    -0.26113394f, -0.11996095f, 0.19245623f, -0.09656473f, 0.27611235f, -0.34301490f, 0.12073822f, -0.34610221f, 
    -0.13382758f, -0.26113495f, 0.10395890f, 0.15462261f, -0.12136480f, 0.05017486f, -0.38535523f, -0.05229898f, 
    -1.13829482f, 0.06180942f, -0.39619726f, 0.58162957f, -0.30390576f, 0.45279962f, -0.47673622f, 0.05941658f, 
    0.10037950f, -0.18572119f, -0.12084934f, -0.36388156f, -0.01588755f, 0.03232507f, 0.15853719f, 0.39818022f, 
    0.06822617f, 0.00095536f, 0.07200654f, 0.15466915f, -0.00081837f, 0.18982150f, 0.16060244f, 0.11086588f, 
    -0.19959025f, -0.18530804f, -0.14062934f, -0.54621929f, -0.10861416f, -0.46071750f, -0.19782634f, -0.04752811f, 
    0.17916161f, -0.11219554f, 0.00367490f, -0.12858744f, 0.17906162f, 0.17523232f, 0.27341771f, 0.06889939f, 
    -0.09423247f, -0.18065268f, -0.17429473f, 0.11127986f, 0.15287873f, 0.07821251f, -0.21510217f, -0.38948774f, 
    -0.83622330f, 0.59779030f, 0.13488989f, 0.01645399f, 0.33120391f, 0.20167302f, -0.15619747f, -0.04547826f, 
    -0.42727438f, -0.06188425f, 0.11031853f, -0.05230636f, -0.56683141f, -0.16738772f, -0.95502251f, 0.37946326f, 
    -0.06466293f, 0.12193954f, -0.01972055f, 0.22733092f, 0.07733826f, -0.00610823f, 0.09614262f, 0.14661810f, 
    -0.54227489f, 0.04507614f, -0.30895764f, 0.19827183f, -0.08641652f, -0.04816804f, -0.21826819f, 0.02489709f, 
    -0.02284783f, 0.15648904f, -0.09868206f, 0.17925210f, -0.42120051f, 0.37275317f, 0.05504913f, 0.65216929f, 
    -0.06521205f, 0.02614820f, 0.03668469f, 0.06403776f, -0.29243472f, -0.03197701f, -0.02577661f, 0.11963233f, 
    -0.31424651f, 0.24149160f, 0.13053273f, -0.13717751f, 0.17608251f, 0.01302589f, -0.73983055f, 0.14108621f, 
    0.19593033f, -0.29363996f, -0.02496348f, -0.28437775f, -0.28810027f, -0.46603310f, 0.72467786f, 0.24018568f, 
    -0.10157626f, -0.29632720f, -0.12552199f, -0.21176645f, -0.19674979f, -0.27490005f, 0.04599353f, -0.17383552f, 
    -0.06671106f, -0.81978399f, 0.10479513f, 0.35873011f, -0.12818679f, -0.00081917f, 0.06822169f, 0.13686302f, 
    -0.04036677f, -0.12415656f, -0.02930862f, -0.10561976f, -0.69773692f, 0.25400385f, -0.37632707f, 0.29849690f, 
    0.13475847f, 0.08672653f, 0.04524882f, 0.10993829f, -0.18358168f, -0.01789254f, 0.20886447f, -0.22389786f, 
    -0.17049505f, 0.33391574f, 0.03904623f, 0.25552526f, -0.20133314f, -0.19701666f, 0.20961294f, 0.10089553f, 
    0.09508378f, 0.11860281f, 0.10184573f, 0.34587076f, -0.05506992f, -0.16642855f, -0.10002398f, -0.02958841f, 
    -0.00232865f, -0.28928864f, -0.33939326f, -0.14299698f, -0.26344755f, 0.11697067f, -0.17992269f, -0.47634178f, 
    0.27181497f, 0.52815932f, -0.34357643f, 0.04078276f, 0.13407396f, 0.15555066f, -0.03676587f, 0.24446909f, 
    0.00593342f, 0.43076491f, -0.18081786f, 0.12520969f, -0.07251552f, 0.20258224f, 0.53135252f, 0.38967302f, 
    0.05370583f, 0.13179064f, 0.29070389f, 0.13261627f, 0.17037447f, 0.14663386f, 0.42683864f, 0.34042063f, 
    0.93916774f, -0.58231777f, 0.47789398f, -0.16303480f, -0.21248472f, 0.02746480f, 0.24929869f, 0.15548535f, 
    -0.21438390f, -0.31684494f, 0.00353943f, 0.01030265f, -0.16001154f, 0.28952011f, -0.57617122f, -0.00166378f, 
    0.01168736f, 0.28161073f, 0.11910196f, -0.10761110f, -0.08525754f, 0.18405257f, -0.27952343f, -0.44287902f, 
    -0.31123126f, -0.16115762f, -0.43252724f, 0.00176024f, 0.11364672f, -0.03449083f, -0.01508942f, -0.16016272f, 
    0.13245887f, -0.00125159f, -0.07189172f, -0.08698674f, -0.66667676f, -0.41394630f, 0.29698396f, -0.51645845f, 
    -0.01161376f, -0.12121336f, 0.13129166f, -0.02896175f, -0.17591794f, 0.00351674f, -0.12249715f, -0.34776542f, 
    -0.39541635f, 0.55307430f, -0.23511977f, 0.42243546f, 0.41169417f, -0.34275767f, 0.02427495f, 0.15985022f, 
    0.13676399f, 0.02321173f, -0.14005210f, 0.18987639f, -0.71855944f, -0.01795814f, -0.28881162f, 0.63639671f, 
    -0.11726084f, 0.03819694f, -0.10351882f, 0.08226577f, -0.08415287f, 0.08256227f, 0.13929994f, 0.01632638f, 
    -0.06247015f, -0.24818023f, 0.04903537f, -0.14425999f, -0.07301302f, -0.26938558f, -0.17700525f, -0.39740109f, 
    -0.07982756f, -0.03550353f, -0.05418995f, -0.13313410f, -0.32912549f, -0.51790756f, -0.63171321f, 0.60654974f, 
    -0.20183086f, 0.22071600f, 0.22437462f, -0.18184263f, 0.06965797f, 0.20424809f, 0.01937396f, -0.04529810f, 
    -0.38171312f, 0.17525995f, -0.15572667f, 0.26440960f, 0.16408661f, -0.31856903f, 0.28278172f, 0.25355807f, 
    -0.03024793f, 0.14717956f, -0.23486055f, 0.25327978f, 0.57704413f, 0.41519594f, -0.17320667f, 0.49646702f, 
    0.03088994f, 0.25975880f, 0.02878265f, 0.05904199f, 0.37839934f, 0.26723695f, -0.28748327f, 0.46997151f, 
    0.36364976f, -0.19434392f, 0.72752094f, 0.65993726f, -0.08962481f, 0.29188123f, 0.14292468f, 0.09856693f, 
    -0.27363101f, 0.30819356f, 0.09630352f, 0.26000178f, -0.19340490f, 0.21834566f, -0.13100046f, 0.66627151f, 
    -0.02966417f, -0.10569291f, 0.50149566f, -0.30866170f, -0.01922848f, 0.03975340f, 0.19755244f, 0.18472660f, 
    0.28779596f, -0.39202523f, 0.25065926f, 0.54527515f, -0.01525651f, -0.11674330f, 0.04312995f, 0.08982031f, 
    0.05965663f, -0.24657696f, -0.10923838f, -0.10779787f, 0.39368957f, 0.21436581f, -0.35797319f, -0.70152545f, 
    -0.05584169f, -0.10667753f, 0.35124707f, -0.18833496f, -0.04978614f, 0.12137469f, 0.15574560f, 0.06851729f, 
    -0.57066363f, -0.14621276f, -0.39279768f, 0.00020172f, 0.04513105f, -0.19064297f, 0.03477663f, 0.18476360f, 
    -0.21966046f, -0.10534102f, -0.03696658f, -0.02285202f, -0.51148808f, 0.31168753f, -0.19237366f, 0.30688843f, 
    -0.30216393f, 0.07583807f, -0.45986798f, 0.24473642f, -0.26221234f, -0.17046674f, -0.25858617f, -0.50888318f, 
    -1.09939075f, 0.06741145f, -0.00951899f, -0.26743352f, 0.05397749f, 0.11236905f, 0.26617146f, -0.40705130f, 
    -0.05120007f, 0.03171864f, 0.33170220f, 0.02650183f, 0.13949248f, -0.55991530f, -0.04472130f, -0.19892128f, 
    0.18365173f, -0.22527415f, -0.35554057f, -0.14190860f, -0.01898320f, 0.13843614f, 0.20607577f, 0.23685266f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.32950631f, 0.14188336f, 0.04938997f, -0.15338948f, -0.12290859f, 0.09840047f, 0.02953779f, -0.14652722f, 
    0.14114586f, -0.04297771f, 0.11012827f, 0.07926732f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
