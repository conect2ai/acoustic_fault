#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.15455735f, 0.13158871f, 0.25203019f, 0.52650368f, 0.69631660f, -0.07928175f, 0.22682399f, -0.74362123f, 
    -0.21213688f, 0.33456120f, 0.17291252f, 0.23970731f, -0.22452590f, 0.30550048f, -0.22089614f, -0.16106066f, 
    0.12414101f, 0.00652793f, -0.14399271f, -0.12621985f, 0.15641911f, 0.10422214f, 0.05763699f, -0.02967508f, 
    -0.23472102f, -0.49081865f, -0.95782155f, -0.39114189f, 0.09255200f, 0.76162958f, -0.45739165f, -0.48827246f, 
    -0.65824640f, -0.51574898f, -0.06636848f, -0.40711215f, -0.35954538f, 0.25351870f, -0.19327906f, -0.38610348f, 
    -0.18070018f, -0.15798667f, -0.31775215f, 0.00474879f, -0.20147148f, 0.20555912f, -0.41365486f, -0.09211594f, 
    -0.06971972f, 0.10612283f, 0.35461438f, 0.18310772f, 0.07588517f, -0.47118875f, -0.27985504f, -0.41492471f, 
    -0.11881295f, 0.09989494f, 0.29144850f, 0.15530594f, -0.01275052f, 0.06126831f, 0.33600286f, 0.00008959f, 
    -0.23597695f, 0.16802858f, 0.02300076f, 0.00099666f, -0.06368722f, -0.28668746f, -0.09359098f, -0.17585339f, 
    -0.11747519f, -0.27293193f, -0.43859491f, -0.72531146f, -0.14126216f, -0.24697961f, 0.13918874f, 0.02615589f, 
    -0.55801779f, -0.39228818f, 0.69836247f, 0.63040262f, 0.33654836f, -0.27585965f, 0.05589879f, 0.05517870f, 
    0.15616564f, -0.11565305f, -0.04751880f, -0.02543011f, 0.14767574f, -0.45325533f, -0.11340185f, 0.05097321f, 
    0.11453330f, -0.04182095f, -0.12253419f, 0.37472004f, -0.08169687f, -0.10332952f, -0.48602065f, -0.29037574f, 
    -0.33958402f, -0.16281185f, -0.27619690f, -0.27929732f, 0.03888874f, -0.33987212f, -0.19200790f, -0.29636571f, 
    -0.14311475f, -0.33282545f, -0.08586429f, -0.03051471f, 0.06391885f, -0.02710952f, 0.14352480f, -0.12348728f, 
    0.16663252f, 0.21382152f, -0.09605876f, 0.26210153f, 0.41878536f, -0.22929211f, 0.00593213f, -0.10392101f, 
    0.18171307f, 0.21241251f, -0.43543336f, -0.36300209f, 0.21324368f, 0.37017596f, 0.18496704f, -0.04337464f, 
    0.02991726f, 0.03700871f, -0.53672272f, 0.34733328f, -0.04369672f, 0.15236439f, -0.09447405f, -0.40953809f, 
    0.13100593f, -0.03456657f, 0.47955808f, 0.02069012f, -0.18097457f, 0.14719808f, -0.26149026f, -0.54518157f, 
    -0.18438992f, 0.37529239f, 0.17988837f, 0.18998554f, 0.01495305f, -0.12858944f, -0.04416095f, 0.37886009f, 
    0.25807247f, 0.22280943f, -0.37691936f, -0.14298333f, -0.05087791f, -0.18123408f, 0.06474641f, 0.29766297f, 
    0.06953497f, -0.07028325f, 0.00772627f, 0.02376381f, 0.02093840f, 0.01301723f, -0.00417238f, 1.18929458f, 
    -0.16273227f, -0.70173979f, -0.70473856f, -1.08964956f, 0.19470194f, -0.07079159f, 0.30602881f, 0.35917494f, 
    0.08744082f, 0.16478212f, 0.08217392f, 0.04439696f, 0.11174037f, 0.01562767f, -0.18152358f, -0.39301744f, 
    -0.14189920f, -0.17221372f, -0.49979228f, -0.25633115f, -0.09646216f, 0.11949166f, -0.30603424f, -0.21691357f, 
    0.70655763f, 0.21584605f, -0.37979290f, -0.66899544f, -0.48161247f, 0.21840957f, 0.39370185f, 0.23452759f, 
    -0.11134899f, -0.05712963f, -0.41658843f, -0.15747245f, 0.24467136f, 0.15551512f, -0.26109865f, -0.09447149f, 
    -0.01597014f, 0.39870882f, -0.36574745f, 0.14358731f, 0.08626926f, -0.29997540f, -0.54960912f, 0.39122838f, 
    0.07825590f, 0.20629580f, 0.09182548f, 0.18956356f, -0.28106579f, -0.28532031f, 0.21040876f, -0.10839040f, 
    -0.05026526f, -0.02723992f, 0.02860764f, 0.52604479f, -0.56244761f, 0.05093125f, 0.21705930f, -0.35214567f, 
    -0.08305065f, 0.02938945f, -0.23202781f, 0.02646859f, 0.28499681f, -0.09981354f, 0.06886134f, -0.13384971f, 
    -0.12992607f, 0.28123367f, 0.41842300f, 0.38009349f, 0.10194215f, 0.10287318f, 0.22717454f, -0.00952080f, 
    -0.01198451f, 0.12866607f, -0.24570960f, -0.22448617f, -0.00238258f, -0.05978924f, -0.20887996f, 0.26396236f, 
    0.17639782f, -0.01904739f, -0.01863167f, 0.18534756f, 0.19769602f, -0.21080858f, 0.35829991f, 0.09504138f, 
    -0.04457710f, -0.13392633f, -0.26646504f, -0.02053961f, 0.58837873f, 0.39053845f, -0.27307764f, -0.00346071f, 
    -0.55674613f, -0.08864539f, 0.10370108f, -0.07802629f, -0.18388161f, -0.05863307f, 0.12481329f, 0.16271657f, 
    0.19615109f, 0.06453086f, 0.17018141f, -0.13423297f, -0.17546564f, 0.35307610f, -0.34213018f, -0.11734877f, 
    0.03324025f, 0.18645163f, 0.04288488f, 0.24393438f, -1.02152610f, -0.77575952f, 0.38592005f, 0.54981971f, 
    0.11591482f, 0.16033374f, 0.30232167f, 0.55053854f, -0.16863933f, -0.07138908f, -0.30252680f, -0.02700586f, 
    -0.10795451f, 0.62853682f, -0.36107397f, -0.23876272f, -0.04005409f, -0.18194902f, -0.12968515f, 0.40475386f, 
    0.14372431f, -0.18649542f, 0.11393324f, 0.17063335f, -0.03356001f, -0.22048768f, -0.46679869f, -0.05542739f, 
    0.16473304f, 0.46166715f, -0.37299553f, -0.30441722f, 0.11103680f, 0.41104016f, 0.36892402f, 0.03923772f, 
    -0.06860172f, -0.07452200f, 0.07045132f, 0.01266670f, -0.06053204f, -0.21636456f, 0.07126070f, -0.27850977f, 
    0.30489919f, -0.45347515f, 0.16780989f, 0.32265195f, 0.08443237f, -0.16888341f, -0.00391348f, 0.16986139f, 
    0.21599522f, 0.10701022f, -0.05430887f, 0.02104357f, -0.50098711f, 0.06423501f, 0.31923881f, 0.32606551f, 
    -0.33086187f, -0.13740809f, 0.10684555f, -0.00818819f, -0.31802171f, -0.01696470f, -0.07736641f, -0.12130307f, 
    -0.13353625f, -0.10308650f, -0.27780288f, -0.40676650f, -0.35775349f, -0.51754498f, -0.67870623f, -0.14870435f, 
    0.04298298f, -0.33727583f, 0.19397420f, -0.41366875f, -0.01688073f, 0.38711858f, -0.41204551f, -0.28665155f, 
    0.52545190f, -0.45932767f, 0.80331558f, -0.25038946f, -0.07679207f, -0.21039203f, -0.31130487f, -0.15797782f, 
    -0.04672190f, -0.21155453f, 0.57433045f, -0.18350706f, -0.15451182f, 0.05368439f, 0.24707051f, -0.23853421f, 
    0.04989104f, -0.04672757f, 0.03354069f, -0.27117097f, 0.48284367f, 0.21805558f, 0.57019758f, -0.60319632f, 
    -0.77462018f, -0.84117556f, -0.02651345f, -0.21651000f, -0.13615754f, 0.52067655f, -0.20638731f, 0.03139287f, 
    -0.09946077f, 0.18939865f, 0.20501518f, 0.17727493f, -0.10505141f, -0.03033330f, -0.12861162f, -0.15194961f, 
    -0.06421968f, 0.26246870f, 0.22693053f, -0.48038578f, -0.61091560f, -0.43921784f, 0.64569145f, 0.25143379f, 
    0.15531601f, -0.17530906f, -0.19417894f, 0.09787243f, 0.36485437f, -0.38354778f, 0.31756610f, -0.03746924f, 
    -0.23251316f, -0.37689772f, -0.10289042f, -0.02671963f, -0.32242429f, 0.26510227f, -0.11237818f, -0.25991115f, 
    0.41598877f, 0.47318804f, 0.40849546f, 0.18825646f, 0.09139689f, 0.12505735f, -0.29477575f, -0.34927371f, 
    -0.24596502f, 0.30023280f, 0.19978595f, -0.27035245f, 0.29106760f, -0.16423291f, -0.20134154f, -0.22054082f, 
    0.23200063f, 0.10397972f, -0.10536128f, 0.07504136f, -0.20618880f, 0.04038944f, 0.15728463f, -0.24520567f, 
    -0.31088454f, 0.36277139f, 0.01560995f, -0.50563246f, 0.34909150f, 0.14485271f, -0.24741367f, -0.35057631f, 
    -0.57899165f, 0.10526134f, 0.75142032f, 0.29811284f, -0.20229572f, -0.43517247f, -0.14228871f, -0.09134112f, 
    0.46851555f, -0.25460577f, 0.03742289f, -0.43855056f, -0.31370661f, 0.07424442f, -0.63956720f, -0.19316365f, 
    0.25757653f, 0.25491613f, -0.24435046f, -0.24507061f, -0.66980010f, -0.78855139f, -0.67627609f, -0.23775014f, 
    -0.38324556f, -0.32189754f, -0.16750836f, 0.20573947f, 0.18059944f, 0.09596814f, 0.14170590f, -0.27444080f, 
    -0.34494796f, -0.05174522f, -0.03370041f, -0.12593462f, 0.04520541f, -0.03072658f, -0.04995771f, -0.31414619f, 
    -0.26953262f, -0.18634941f, 0.00330525f, 0.11554559f, -0.14543054f, -0.18306336f, -0.83605665f, -0.31403261f, 
    -0.19604962f, -0.00360006f, 0.13376601f, -0.36315343f, 0.26936513f, -0.51707900f, -0.07675494f, 0.60858446f, 
    0.29076609f, 0.41234273f, 0.04441144f, -0.00402053f, -0.07416590f, -0.16769013f, -0.21744467f, -0.07147314f, 
    -0.10582322f, -0.09875719f, 0.08657367f, -0.04455025f, 0.23135701f, -0.14501503f, 0.39517266f, 0.37164134f, 
    0.06387401f, 0.24068685f, -0.38432443f, 0.48098612f, -0.40401113f, -0.17100534f, 0.13668713f, 0.10195560f, 
    -0.07376918f, -0.13713469f, -0.01955707f, -0.03748201f, -0.33559215f, -0.10471676f, -0.06447796f, 0.14903870f, 
    0.15442413f, -0.29287761f, -0.36844510f, 0.37326092f, 0.12133466f, -0.12406157f, -0.24115470f, 0.03001192f, 
    -0.03818807f, 0.04056401f, -0.04416004f, 0.03584312f, 0.02829780f, 0.05103416f, -0.16892423f, 0.00135141f, 
    0.33369452f, 0.13696715f, -0.04476549f, -0.43612206f, 0.05729786f, -0.06952904f, 0.30937383f, 0.19895457f, 
    -0.20778263f, -0.10022261f, -0.00181174f, -0.29408902f, -0.30269277f, -0.06875713f, 0.23696251f, -0.01027111f, 
    0.42073241f, 0.60591376f, 0.41071120f, 0.31602192f, -0.15015212f, -0.19774421f, -0.23055983f, -0.20570560f, 
    -0.15951526f, -0.26158807f, -0.08763327f, -0.03725412f, 0.44666645f, -0.16431370f, -0.19755216f, 0.06379687f, 
    -0.02451046f, 0.06827834f, 0.03165818f, 0.04599456f, 0.01303631f, 0.04110861f, -0.06845542f, -0.11164314f, 
    0.02732112f, -0.34567595f, -0.53537631f, -0.46553013f, -0.46853399f, -0.65024447f, 0.68185031f, 0.51458102f, 
    0.28482306f, 0.29756120f, 0.37369728f, -0.04988727f, 0.05012341f, 0.04434351f, 0.19465467f, -0.32274571f, 
    -0.12966236f, -0.23106195f, -0.13655585f, 0.14647390f, -0.06844711f, 0.05557350f, 0.06308166f, 0.33421347f, 
    0.03414132f, -0.15969975f, 0.14786741f, -0.00913000f, -0.03405460f, -0.06441923f, -0.01718296f, 0.47733065f, 
    -0.18399642f, -0.37548885f, 0.12630562f, -0.05107076f, 0.23767918f, 0.13546593f, -0.12528919f, 0.13128297f, 
    -0.33644810f, 0.05837104f, 0.06688526f, 0.10341224f, 0.42156515f, 0.16740425f, 0.40406150f, 0.32120746f, 
    -0.22075254f, 0.07836036f, -0.36785990f, 0.29705244f, 0.61878580f, 0.14625150f, -0.51235807f, 0.19570214f, 
    -0.01315781f, -0.46760052f, -0.27509233f, -0.26014501f, -0.39906958f, 0.21092950f, 0.16010638f, 0.14953719f, 
    -0.30269966f, 0.49269775f, -0.35944235f, 0.16316462f, 0.04255731f, -0.07477867f, 0.22318195f, -0.16487354f, 
    0.10140051f, 0.05024806f, 0.04101380f, -0.19996358f, -0.99211919f, -0.12349945f, -0.80306238f, -0.71721137f, 
    -0.21047296f, 0.25024194f, 0.75606269f, 0.69082701f, -0.35424164f, -0.51732129f, -0.20197564f, -0.29179519f, 
    -0.40437728f, -0.30283600f, 0.02298828f, -0.06194167f, 0.14766598f, 0.04916764f, -0.32950494f, -0.20103543f, 
    0.20139848f, -0.01058132f, -0.06536341f, 0.03745186f, -0.08986876f, 0.02172824f, 0.93984962f, 0.91981292f, 
    -0.59431076f, -0.16486491f, -0.53232938f, -0.24765845f, 0.00049081f, 0.14319356f, -0.27764243f, 0.25134906f, 
    -0.28619105f, -0.03152101f, 0.37825114f, -0.37850425f, 0.05082979f, -0.17562397f, 0.08640230f, 0.13514215f, 
    0.02408071f, -0.06649696f, 0.12166993f, -0.05716533f, -0.02038602f, 0.04622698f, 0.25131273f, -0.24526279f, 
    0.28917417f, -0.04435471f, -0.22796048f, 0.26901674f, 0.17914240f, -0.39054191f, 0.20045587f, 0.10708597f, 
    0.14844771f, 0.23364083f, -0.01462536f, -0.01075119f, -0.44570202f, -0.07862565f, -0.10245700f, -0.23679109f, 
    -0.00413915f, 0.25885567f, -0.32972780f, 0.43598819f, 0.11823203f, 0.06732102f, -0.15349296f, -0.08432599f, 
    0.53551143f, 0.46284050f, -0.03688740f, -0.46329263f, -0.01309091f, -0.37801930f, -0.45677710f, -0.30831897f, 
    -0.40773621f, 0.43134734f, 0.03990398f, 0.08316647f, 0.14100525f, 0.03959218f, 0.15412353f, -0.30993807f, 
    0.06718495f, -0.17278452f, -0.24830066f, -0.11065280f, 0.14354663f, -0.28710389f, -0.19877072f, -0.38992906f, 
    0.96128720f, 0.48734349f, 0.05845704f, -0.10686304f, -0.43810624f, -0.02697938f, -0.05122291f, -0.03738507f, 
    -0.36438778f, -0.32042217f, 0.07975294f, 0.07897874f, 0.01706819f, -0.26805672f, 0.06013559f, -0.18933971f, 
    -0.14905609f, 0.00764729f, 0.26361874f, -0.13508978f, 0.00254569f, 0.18293576f, -0.16466326f, -0.11719477f, 
    -0.26718661f, -0.54336137f, -0.47891185f, -0.46540582f, -0.32453996f, -0.18714620f, -0.13889891f, -0.39186200f, 
    -0.07816748f, -0.35929981f, -0.45896983f, 0.19792065f, 0.40512124f, 0.11074483f, -0.20275706f, -0.02651040f, 
    -0.06001216f, -0.15093547f, 0.09976614f, -0.06449474f, -0.01909503f, 0.21056490f, 0.42714971f, -0.04884878f, 
    0.04277797f, 0.27315402f, -0.29716989f, -0.89960539f, -0.78742909f, -0.08388888f, 0.77441525f, -0.16740952f, 
    0.44798592f, -0.40348238f, -0.37649485f, 0.17626233f, 0.26937225f, 0.18670970f, 0.22397485f, -0.55701053f, 
    -0.33092859f, 0.21076122f, 0.07932041f, 0.00004340f, 0.01861548f, 0.43096671f, 0.29747927f, -0.26224411f, 
    -0.15122668f, -0.09009000f, -0.13101432f, -0.81757277f, 0.28982595f, -0.10114205f, -0.92929399f, -0.54562002f, 
    0.09709386f, 0.24946727f, 0.09239528f, -0.23869787f, 0.50286531f, -0.23969658f, -0.39231890f, -0.33607692f, 
    -0.24526931f, 0.36882791f, 0.26737520f, 0.09375961f, -0.16424674f, -0.02417308f, 0.00881186f, -0.13210942f, 
    -0.29262754f, -0.25242212f, -0.31959724f, -0.37126389f, -0.71082592f, -0.45370790f, 0.25650600f, 0.25798467f, 
    0.09647761f, 0.72204864f, 0.36438918f, -0.30846563f, -0.28152886f, -0.04716066f, 0.12943713f, -0.02465902f, 
    0.03889210f, 0.03168408f, -0.37276873f, 0.29882669f, 0.19098715f, 0.05368476f, -0.11250921f, -0.34360805f, 
    0.00894628f, -0.05812799f, -0.00106504f, 0.15922895f, 0.12681852f, -0.34130204f, -0.57667333f, -0.49910000f, 
    -0.06050298f, 0.33161104f, -0.08612923f, 0.31833044f, 0.33980685f, 0.03590935f, 0.11985583f, 0.25130004f, 
    0.11917699f, -0.07673558f, -0.30216610f, -0.03911785f, -0.41344479f, -0.04773117f, -0.20984074f, -0.14367139f, 
    -0.07877880f, 0.34850442f, 0.19540960f, 0.26677111f, 0.17335574f, 0.25248560f, -0.89241672f, -0.34477651f, 
    0.11515994f, 0.57553995f, 0.45708942f, 0.28128946f, 0.01768745f, -0.07229862f, 0.08191839f, 0.19731498f, 
    -0.05895619f, -0.07889461f, -0.26524675f, 0.04576927f, -0.00810440f, 0.02669314f, -0.09399747f, 0.05856190f, 
    -0.12185996f, -0.18591855f, -0.30225119f, -0.01987589f, -0.28857130f, -0.31546411f, -0.50441790f, -0.42154026f, 
    -0.34663984f, -0.53102183f, -0.30472431f, 0.05702307f, -0.30886146f, -0.01697378f, -0.08745833f, -0.18390125f, 
    -0.07646961f, -0.43959448f, -0.42931384f, -0.37272698f, 0.02892422f, 0.17740966f, 0.06333563f, 0.00766988f, 
    -0.28694496f, -0.09662543f, 0.19122525f, 0.00064728f, -0.28671178f, -0.27183664f, -0.23220631f, -0.67576319f, 
    -0.64201474f, -0.49430552f, 0.44427043f, 0.37628159f, 0.54249567f, -0.32730970f, -0.42358944f, -0.35955101f, 
    -0.14133061f, 0.23195769f, -0.11511341f, -0.19852814f, 0.13971661f, 0.24904971f, 0.16706067f, 0.13299040f, 
    0.00244721f, 0.09988046f, -0.04014900f, -0.17394574f, -0.29595619f, 0.18106584f, 0.09588487f, 0.06259096f, 
    -0.33941555f, 0.52273601f, -0.16251653f, -0.70479894f, -0.87096757f, -0.66981751f, -0.26087180f, 0.25011802f, 
    0.11450204f, 0.15114278f, 0.32411644f, 0.08037291f, 0.27727103f, 0.20932022f, 0.01241820f, 0.09117642f, 
    0.03369260f, 0.10011538f, -0.02645839f, -0.27370432f, -0.12846610f, -0.11428935f, -0.15628102f, -0.06590714f, 
    -0.12246197f, -0.14859280f, -0.26625922f, -0.27723500f, -0.52256352f, -0.49422649f, -0.08354715f, -0.13249505f, 
    -0.05510231f, -0.76942295f, -0.64117259f, -0.79315048f, 0.62353969f, 0.09357645f, 0.49843004f, 0.34832418f, 
    0.21011078f, -0.21570286f, -0.30476671f, -0.07478590f, -0.23566473f, 0.02090886f, -0.10006222f, -0.21618699f, 
    0.06522185f, 0.09802514f, 0.07702335f, -0.00488751f, -0.06980657f, -0.48836312f, -0.16328037f, -0.72288334f, 
    -0.44353551f, -0.12138986f, -0.36047068f, -0.64620554f, -0.25556248f, 0.17026199f, 0.00562650f, 0.18136832f, 
    -0.08877651f, 0.06095324f, -0.05926946f, 0.06397398f, 0.29415250f, -0.12758636f, -0.12711577f, 0.15210937f, 
    -0.07716151f, 0.08186862f, 0.39660811f, 0.14905727f, -0.55088341f, -0.23293793f, -0.23758505f, -0.27014259f, 
    -0.01322992f, -0.61876535f, -0.48236290f, -0.17137536f, -0.30605784f, -0.47209668f, 0.10320675f, -0.04162716f, 
    -0.25856912f, -0.41837201f, -0.19801432f, -0.02881828f, -0.24900967f, -0.06278620f, -0.13280259f, -0.15392451f, 
    -0.14672546f, 0.02745945f, 0.23498744f, -0.33253813f, 0.22994031f, 0.34966439f, 0.53304029f, -0.54445297f, 
    -0.48363599f, -0.37676337f, -0.27770454f, 0.50824887f, 0.26132551f, -0.23676158f, -0.40579170f, -0.30341962f, 
    0.05177619f, 0.01967856f, 0.07552591f, -0.29965329f, 0.27652267f, -0.49699467f, -0.06600384f, 0.02693610f, 
    -0.07771006f, 0.42411157f, 0.12543084f, 0.19656436f, 0.12967771f, 0.09953313f, 0.37605715f, 0.92253023f, 
    -0.33685860f, -0.54357857f, 0.27969748f, 0.17898248f, -0.45744732f, -0.19847474f, -0.60833687f, -0.78678143f, 
    0.00480537f, 0.20227921f, 0.08161508f, -0.06069493f, 0.10061675f, 0.09277482f, 0.26956528f, -0.02379310f, 
    0.14761963f, -0.01929059f, 0.04097986f, -0.10717399f, 0.09540503f, 0.07494772f, 0.00162930f, 0.03175445f, 
    -0.01274794f, -0.02753014f, 0.36552975f, -0.02280547f, 0.24066162f, 0.32009670f, 0.30513144f, -0.07917942f, 
    0.25933605f, 0.21622011f, 0.19193952f, 0.12967765f, -0.23132992f, 0.03133649f, 0.24479561f, -0.09148398f, 
    0.14531380f, -0.09608465f, 0.00424075f, 0.15286401f, -0.11257243f, -0.22699846f, -0.00711432f, 0.23772435f, 
    1.11956227f, -0.13472517f, -0.24349357f, -0.13288464f, -0.29603663f, 0.39216802f, -0.29324481f, -0.56040400f, 
    0.16338424f, -0.80760235f, -0.06144632f, 0.26252323f, -0.13937218f, 0.07718383f, -0.18827787f, -0.02524403f, 
    0.31886533f, 0.01793649f, -0.31030872f, 0.01668743f, -0.27394155f, 0.17879367f, -0.09114166f, -0.08030923f, 
    -0.00487483f, 0.05905167f, 0.06029692f, 0.56931651f, -0.08547167f, -0.58595169f, 0.22812331f, -0.34496927f, 
    -0.74672717f, -0.37037075f, 0.53768390f, 0.04342241f, -0.31629536f, -0.40588328f, -0.30885103f, 0.33485821f, 
    0.07813431f, 0.02865710f, 0.22013772f, 0.00216512f, -0.28512937f, 0.02787866f, 0.25438187f, 0.18030806f, 
    -0.04035735f, -0.23596923f, -1.21798682f, 0.25161204f, -0.46829814f, -0.28518429f, -0.26755702f, -0.07260220f, 
    0.21223551f, 0.18964951f, 0.32484660f, 0.38555476f, 0.17919432f, 0.02293691f, -0.19030246f, 0.12648147f, 
    0.14142193f, -0.18736438f, -0.22924273f, -0.23821680f, -0.20622373f, -0.20555496f, -0.17157824f, -0.11572791f, 
    -0.00611220f, -0.16112170f, -0.47924095f, -0.03738763f, 0.20862336f, 0.34564352f, -0.22648878f, -0.06141598f, 
    -0.11418678f, 0.01417614f, -0.14634159f, 0.34222662f, -0.29898822f, 0.18525155f, 0.01845508f, 0.04553085f, 
    -0.11845694f, -0.06651227f, -0.18821001f, -0.03055693f, 0.14253153f, -0.27578616f, -0.28514040f, 0.35518238f, 
    0.09313742f, -0.34118113f, -0.00428467f, 0.17052370f, 0.13932645f, -0.86216784f, -0.05895712f, 0.12011923f, 
    0.01824072f, 0.59912777f, 0.67954916f, 0.37632176f, -0.45794341f, -0.06342709f, -0.25688803f, -0.38843188f, 
    -0.13623387f, -0.22761947f, -0.10377998f, 0.32180265f, 0.15123732f, -0.14173801f, 0.23116852f, -0.18378514f, 
    -0.09923375f, -0.02933836f, -0.16574696f, -0.18894719f, -0.11814315f, -0.78419977f, -0.44634759f, -0.27765611f, 
    -0.49412969f, -0.19814020f, -0.21127731f, -0.35511690f, -0.26578757f, 0.18401034f, 0.32727873f, -0.17138930f, 
    -0.39763099f, -0.40293375f, -0.30494714f, -0.34824494f, 0.13396825f, 0.16964279f, 0.19969696f, 0.16281369f, 
    0.02250931f, -0.25140467f, -0.17154047f, -0.21030894f, -0.17925128f, -0.36283526f, 0.22081101f, -0.20449317f, 
    -0.58476156f, -0.66821659f, -0.60616809f, 0.22715349f, -0.23767470f, -0.18343027f, 0.57906270f, 0.25705442f, 
    0.09991997f, -0.01147531f, 0.16589269f, 0.15700506f, 0.11131322f, 0.15894622f, 0.01118264f, 0.09275225f, 
    0.23390770f, 0.00964445f, 0.07335107f, -0.16670072f, -0.30599698f, -0.12610888f, 0.03332553f, -0.89580524f, 
    -0.06933441f, 0.66104382f, -0.22690350f, -0.02198001f, -0.09346879f, -0.12209254f, -0.19063875f, 0.17168170f, 
    0.35054582f, -0.40639588f, 0.14141285f, -0.43031919f, 0.52685082f, 0.13824034f, -0.06948116f, -0.01465923f, 
    -0.41393250f, 0.34784743f, -0.12321593f, 0.01190817f, 0.17990519f, 0.02848125f, 0.18424672f, -0.14320469f, 
    -0.13281526f, -0.38385260f, -0.50992626f, 0.16202144f, -0.12630071f, -0.71190423f, -0.51241714f, -0.23029776f, 
    0.19141227f, 0.21663715f, 0.05162485f, -0.35143584f, -0.48312262f, 0.06900743f, 0.24702477f, 0.25447392f, 
    -0.40544859f, 0.30070156f, 0.04140699f, -0.16713530f, -0.13449517f, 0.12717374f, -0.35305175f, -0.12701292f, 
    0.35289785f, 1.00606036f, -0.52072817f, -0.16942433f, 0.12322600f, -0.09577102f, 0.26760724f, -0.26075789f, 
    -0.02765104f, 0.03194074f, 0.26632395f, 0.03547502f, -0.09805115f, 0.05052879f, -0.35716823f, -0.24714620f, 
    0.10478076f, 0.03633922f, 0.16502056f, -0.16851607f, -0.06711899f, 0.08694113f, -0.19446167f, -0.04245559f, 
    0.19682096f, -0.08541827f, -0.06155124f, 0.06663184f, -0.12839404f, -0.37698340f, 0.02696452f, -0.04922824f, 
    0.01911645f, -0.42418477f, -0.70422071f, -0.07052598f, -0.25728494f, -0.19902849f, -0.23735352f, 0.20177296f, 
    0.36530727f, -0.29008555f, -0.34822911f, -0.38915944f, -0.06249215f, -0.75268185f, -0.15734826f, 0.00677672f, 
    0.29231414f, 0.29551879f, 0.05236963f, -0.39096376f, -0.53424942f, -0.92832834f, -0.51484895f, -0.08984345f, 
    0.53760523f, 0.38949475f, 0.15222700f, 0.42246822f, -0.03601252f, -0.31247768f, 0.06185208f, -0.29542366f, 
    0.08593868f, -0.25123799f, 0.29407352f, 0.18664825f, -0.08730190f, 0.26599777f, -0.08177972f, 0.02977509f, 
    0.13476110f, 0.18945222f, -0.09966675f, -0.23982380f, 0.75296181f, 0.22315608f, -0.27304590f, -0.41680622f, 
    0.27990606f, 0.21655263f, 0.37686333f, 0.31990719f, -0.13796549f, -0.30297339f, -0.32067841f, 0.40647721f, 
    -0.16459014f, -0.25511506f, 0.01572752f, 0.10229188f, -0.31002057f, 0.20657347f, -0.23989828f, -0.28172746f, 
    -0.11578351f, 0.13190591f, -0.07824620f, -0.07796989f, 0.15072685f, -0.41930380f, -0.39084139f, 0.23628709f, 
    0.55100173f, 0.46064982f, 0.15832539f, 0.45466694f, 0.30195281f, 0.34855136f, 0.18407600f, 0.19258273f, 
    0.16829319f, -0.11874276f, -0.29154423f, 0.03881184f, -0.00506755f, -0.12504202f, -0.12044953f, -0.10879067f, 
    -0.15277815f, -0.15576734f, -0.28787497f, -0.08776179f, -0.12481371f, -0.17007814f, 0.17062183f, 0.48911521f, 
    0.30983984f, -0.00814394f, -0.77452707f, -0.35304564f, 0.27756736f, -0.12837958f, -0.20625231f, 0.55672026f, 
    0.13799882f, 0.31753600f, -0.18982561f, -0.19400652f, -0.07820341f, 0.01043431f, -0.07739741f, 0.16126408f, 
    -0.06635357f, -0.07743250f, -0.16879167f, 0.24902780f, -0.25082290f, -0.28618631f, 0.23990364f, -0.14441852f, 
    -0.67978442f, -0.50795949f, 0.04973788f, -0.27398112f, -0.33238626f, -0.31119058f, -0.14387089f, 0.31706282f, 
    -0.17909652f, 0.35957634f, 0.31474820f, 0.21582544f, 0.07039893f, -0.40887350f, -0.28404516f, -0.12966411f, 
    0.18753192f, 0.18853427f, 0.12087538f, -0.37644565f, -0.08988554f, 0.10025796f, -0.21556535f, -0.43941760f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16273245f, 0.16055977f, 0.06270216f, 0.34805337f, -0.09192352f, 0.13438612f, 0.11542543f, 0.19267830f, 
    0.18862420f, 0.18956511f, -0.08470940f, 0.19273078f, 0.35216907f, 0.36292630f, -0.04125715f, 0.18151727f, 
    -0.00302037f, 0.19506760f, 0.28220347f, 0.05663283f, -0.29433343f, 0.44821739f, 0.44193393f, 0.11128872f, 
    0.15181890f, 0.07818379f, 0.18707275f, 0.06363433f, -0.06156253f, 0.30046937f, 0.19125454f, -0.12585431f, 
    0.25461039f, -0.05036015f, 0.23131640f, -0.04354995f, 0.27056968f, 0.08909562f, 0.00756389f, -0.02638040f, 
    0.21832339f, 0.29291856f, 0.16929100f, -0.07033448f, -0.03121327f, 0.28038031f, 0.05653957f, 0.15324531f, 
    0.11092829f, 0.01496211f, -0.02699709f, 0.21884112f, -0.06049533f, -0.42916507f, 0.14450091f, 0.34386155f, 
    0.32056037f, 0.29631785f, -0.00354092f, -0.07410998f, 0.26852265f, -0.02036328f, 0.28778523f, 0.08623535f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18279840f, 0.22879539f, 0.23728742f, -0.08121902f, -0.13823842f, 0.05154179f, 0.05308020f, 0.04646461f, 
    -0.00505799f, 0.02557727f, -0.00081103f, -0.03642615f, 0.35206002f, 0.18096544f, -0.00379287f, -0.08845104f, 
    0.14121446f, 0.06668738f, 0.15812226f, -0.05956305f, -0.02965026f, -0.08464323f, -0.09042818f, -0.13461633f, 
    -0.09847248f, -0.08599134f, 0.07945914f, 0.07052879f, -0.04009813f, -0.01276077f, 0.02344672f, 0.07562228f, 
    -0.15353361f, -0.09721614f, 0.03102894f, 0.25970083f, -0.22040859f, 0.11836069f, 0.27339628f, -0.13655283f, 
    -0.01563971f, -0.02378825f, 0.01359363f, -0.12076347f, -0.15759823f, -0.11531746f, -0.04061656f, -0.34859863f, 
    0.19208436f, 0.11017454f, -0.12775554f, -0.20081589f, 0.12314624f, 0.03092450f, -0.01323265f, 0.02573685f, 
    -0.02799864f, -0.00542415f, -0.02166759f, 0.01227573f, -0.08626005f, 0.13483863f, 0.09113976f, -0.09017891f, 
    -0.18579124f, -0.00657607f, 0.00778325f, -0.12123846f, -0.00149866f, -0.09913293f, -0.06445668f, -0.08641344f, 
    0.17517269f, 0.06822737f, 0.08658981f, -0.04503930f, 0.01099082f, -0.02683698f, -0.04738858f, -0.14247341f, 
    0.05797483f, 0.06060599f, -0.13317598f, -0.01864673f, 0.09737654f, -0.22384211f, -0.32200542f, 0.01487049f, 
    0.01917099f, -0.00972886f, -0.05355590f, 0.07001554f, -0.07054034f, -0.01117876f, -0.15132807f, 0.08440567f, 
    -0.04828097f, -0.32541946f, -0.24799587f, 0.21666166f, -0.01281666f, 0.11763462f, -0.18160312f, -0.02605010f, 
    -0.03277044f, -0.16611002f, 0.01053296f, -0.06958730f, -0.10178088f, -0.21597968f, -0.03348930f, -0.05995487f, 
    -0.06332044f, -0.00578813f, -0.03951280f, 0.00778996f, -0.05719310f, -0.08242836f, -0.03390158f, -0.09711546f, 
    -0.03410218f, -0.06579987f, -0.03373716f, 0.00817033f, 0.03061868f, 0.00780145f, 0.08305123f, -0.04095978f, 
    0.00660590f, -0.00685125f, 0.01275862f, 0.04483913f, -0.05838274f, -0.01021348f, 0.03685733f, 0.03037838f, 
    -0.01371108f, -0.13712534f, -0.07963274f, -0.16781484f, -0.01257931f, 0.04122736f, -0.06002507f, -0.05196242f, 
    0.31807327f, -0.31797594f, 0.16429918f, -0.08639096f, -0.04201825f, -0.08201554f, 0.09336026f, 0.04019618f, 
    -0.14256850f, -0.18405844f, -0.13569783f, -0.04369402f, -0.04801702f, 0.28012320f, 0.02862377f, -0.23261289f, 
    -0.04410782f, -0.04374233f, 0.02321752f, 0.02745808f, -0.06568508f, -0.09061858f, -0.05642647f, -0.16433087f, 
    -0.47507867f, -0.13072610f, 0.13957317f, 0.02273948f, 0.00149039f, -0.01226838f, -0.01741281f, 0.00030082f, 
    -0.17661880f, 0.02614775f, 0.07662922f, 0.11840972f, 0.05235712f, -0.17629445f, 0.10952826f, -0.07033997f, 
    -0.05923380f, -0.11415785f, 0.05288784f, 0.09441550f, -0.12406615f, -0.03365222f, -0.08152388f, -0.20115216f, 
    0.39789522f, -0.22625782f, -0.36294556f, -0.02919354f, 0.07842366f, 0.00826940f, 0.10147654f, -0.01076987f, 
    -0.03697410f, 0.01144106f, -0.00111575f, 0.02146129f, 0.10256719f, -0.26617903f, -0.40465736f, -0.00981831f, 
    0.04810051f, 0.03530415f, -0.21748216f, -0.13821588f, -0.16373137f, -0.08787134f, -0.17366795f, -0.10065215f, 
    -0.24535340f, -0.33810678f, -0.05078797f, -0.10136184f, -0.02604456f, 0.08041124f, -0.15748307f, -0.08418854f, 
    -0.02460544f, -0.03307789f, 0.02956351f, -0.02602427f, -0.26200262f, -0.24395710f, 0.11714041f, 0.13749728f, 
    0.05493890f, -0.06579226f, -0.09495494f, -0.02530545f, 0.09207458f, -0.15749991f, -0.21732427f, 0.08930183f, 
    0.37789470f, 0.13382895f, 0.08837223f, -0.05003014f, 0.21940109f, 0.17773822f, 0.08411301f, 0.06594391f, 
    -0.08221520f, -0.05652413f, -0.03191639f, -0.00180360f, 0.25912485f, 0.20837697f, -0.14503615f, -0.19043677f, 
    0.02339567f, 0.02587696f, -0.02871229f, -0.08516720f, -0.07375143f, 0.11874568f, -0.12764917f, -0.03988110f, 
    -0.37342313f, -0.21928857f, -0.21206446f, -0.05066141f, 0.01581064f, -0.04411764f, -0.01215063f, 0.02273964f, 
    -0.06760259f, -0.09089460f, -0.00889758f, 0.04549454f, -0.11835982f, 0.10574900f, -0.02588747f, 0.00227042f, 
    0.00909050f, -0.03286187f, 0.02976538f, 0.04509884f, -0.06335355f, 0.01731301f, 0.04833163f, -0.10064032f, 
    -0.19922724f, -0.13172536f, -0.03605824f, -0.07186536f, 0.05136666f, -0.05369060f, -0.11336572f, 0.01617421f, 
    -0.00214927f, 0.03093052f, -0.01880009f, 0.06468940f, 0.06254327f, -0.33983180f, -0.21637571f, 0.06943822f, 
    0.11384639f, 0.07018758f, -0.04777755f, -0.14459103f, -0.05083835f, -0.00740617f, -0.07876075f, 0.01591920f, 
    -0.06374957f, -0.02590109f, -0.05155084f, 0.02460106f, -0.31796321f, -0.14291708f, 0.04262187f, -0.01432539f, 
    -0.02020680f, -0.07036743f, 0.02137699f, -0.00303137f, 0.09010909f, -0.02185498f, -0.38924190f, 0.06181716f, 
    -0.10215063f, -0.11960057f, -0.03869196f, 0.00250947f, -0.00107926f, 0.01283638f, 0.01260987f, -0.09829675f, 
    0.21349181f, -0.00435772f, -0.16178240f, -0.06611492f, 0.03140579f, 0.20842473f, 0.04440616f, 0.01693229f, 
    -0.02546701f, -0.00170993f, 0.02591912f, 0.12912467f, -0.26386011f, 0.07040612f, -0.06644899f, 0.08031885f, 
    -0.04865643f, -0.03736046f, -0.04912933f, 0.01461728f, -0.01357350f, -0.02168733f, 0.00442974f, 0.01922714f, 
    -0.12063600f, -0.35614735f, -0.20079665f, -0.16492048f, -0.02660929f, -0.09648332f, 0.04207079f, -0.03668149f, 
    -0.05424280f, -0.06273209f, 0.06872829f, -0.01221530f, 0.03848279f, -0.05633377f, -0.24993964f, -0.11049087f, 
    -0.23343997f, -0.06020994f, -0.15350419f, -0.07297923f, -0.02005577f, -0.05459287f, 0.11305904f, -0.06258457f, 
    -0.28519756f, -0.37009838f, -0.42895016f, 0.14443804f, 0.01537737f, 0.02292076f, 0.01872689f, -0.00833484f, 
    -0.09237537f, 0.03666670f, 0.04192444f, 0.03595760f, 0.23408210f, 0.18144061f, -0.13143872f, -0.12491407f, 
    0.04191376f, 0.08397765f, 0.04202535f, -0.06689832f, 0.00386768f, -0.04989143f, 0.03191846f, 0.00144096f, 
    0.44567335f, 0.24254455f, -0.23791742f, -0.07514092f, 0.14673279f, -0.12792134f, 0.20117082f, -0.22671092f, 
    -0.04056739f, 0.00704837f, 0.05776494f, -0.06052539f, -0.15375398f, 0.13468245f, 0.07055987f, -0.07129271f, 
    0.05255130f, 0.20666152f, -0.10463979f, 0.09398038f, -0.15400483f, 0.01843871f, 0.04726093f, -0.08234911f, 
    0.18953456f, 0.05171871f, -0.07773733f, -0.09566934f, -0.25942260f, -0.15711051f, 0.02171879f, 0.05319122f, 
    -0.06950375f, -0.14369902f, -0.05774318f, -0.04250801f, 0.06640565f, 0.12075932f, -0.04204563f, 0.04877916f, 
    0.06754021f, -0.02486655f, 0.04397875f, -0.08704649f, -0.04639629f, -0.06157218f, -0.18389931f, -0.12063675f, 
    0.15699244f, -0.03890413f, -0.00274254f, -0.00363157f, -0.03552001f, -0.04343974f, 0.05998405f, 0.01305374f, 
    0.00160832f, 0.07692969f, 0.01876673f, 0.10523074f, 0.24553075f, 0.09408152f, 0.09037687f, 0.04093894f, 
    0.08628146f, 0.16033089f, 0.01230469f, -0.03485791f, -0.10768562f, -0.05605291f, -0.02794629f, -0.04466261f, 
    0.14805363f, 0.12483563f, 0.11289999f, -0.43346971f, 0.00820607f, -0.09768496f, 0.00445220f, -0.15965419f, 
    -0.10772187f, -0.03584107f, -0.08756501f, -0.10590416f, 0.12999040f, -0.00471108f, -0.02086436f, 0.07828669f, 
    0.08369130f, 0.05560406f, -0.03557065f, -0.10906669f, -0.15226506f, 0.00739596f, -0.00117222f, 0.03363932f, 
    0.26271644f, 0.16398323f, -0.31135669f, -0.19854236f, -0.03761126f, -0.09635152f, -0.02485961f, -0.00819208f, 
    0.06900853f, -0.05476091f, 0.00996574f, -0.01407259f, 0.29258597f, 0.07107385f, -0.18645345f, -0.07352279f, 
    0.10225494f, 0.02959839f, -0.05295696f, -0.03773110f, 0.01228134f, -0.04421633f, 0.02000740f, 0.05545841f, 
    0.26200026f, 0.18669313f, 0.00556108f, -0.17988336f, 0.16278394f, 0.15251492f, 0.04176040f, -0.00700881f, 
    -0.03808285f, 0.00322328f, -0.01733613f, -0.03962667f, 0.09555823f, 0.03517845f, -0.09498229f, 0.03887964f, 
    0.04206547f, 0.02633129f, 0.13820378f, -0.17778929f, 0.00843925f, -0.04265912f, -0.04492191f, -0.03875454f, 
    0.17910187f, 0.00358978f, -0.41254786f, 0.15775402f, -0.06334553f, -0.09165134f, 0.09810717f, 0.08677578f, 
    0.00538852f, 0.08512656f, -0.03423144f, 0.02318637f, 0.01756945f, -0.02360264f, -0.02102043f, 0.03540678f, 
    -0.02086062f, -0.00145103f, 0.00288802f, 0.05390164f, -0.26161233f, -0.21398547f, -0.13850708f, -0.15440418f, 
    0.07698101f, -0.20144828f, -0.23278864f, -0.04049374f, -0.09650695f, 0.03964105f, -0.05503361f, 0.04291122f, 
    -0.05251450f, 0.05088643f, -0.04845591f, -0.02476550f, 0.10150158f, 0.15752172f, -0.24026820f, -0.28540838f, 
    -0.07321727f, -0.03903122f, -0.14940366f, -0.07987327f, -0.00968663f, -0.07259059f, 0.07503790f, 0.00499445f, 
    -0.03122030f, -0.11390207f, 0.06347144f, 0.02622824f, 0.05321480f, 0.02993764f, -0.00734546f, 0.03442791f, 
    0.07737508f, 0.09900472f, 0.04498793f, 0.06384826f, -0.00041547f, -0.15244538f, -0.05406043f, -0.04272617f, 
    -0.05963443f, 0.11053918f, -0.13772848f, 0.02530798f, -0.01628614f, -0.01586204f, 0.02390781f, -0.09991134f, 
    0.37303817f, -0.16342066f, -0.35288608f, -0.05982729f, 0.03488600f, 0.04246723f, 0.11560876f, 0.07729646f, 
    0.08490467f, 0.15380032f, 0.00040038f, 0.08380368f, 0.27448416f, 0.28021637f, 0.16299860f, -0.02514500f, 
    0.14008999f, 0.26592276f, 0.11966657f, 0.14471641f, -0.02461825f, -0.03209130f, -0.05319609f, 0.03047828f, 
    0.13958077f, 0.03161161f, 0.01009226f, 0.01188246f, 0.12425437f, 0.08536153f, -0.00562788f, -0.07606188f, 
    -0.01619797f, -0.00143547f, 0.04872428f, 0.07459021f, 0.12565155f, 0.00359839f, 0.09871318f, -0.20019172f, 
    0.03113805f, -0.04421838f, 0.02673993f, -0.08013398f, -0.05718001f, 0.02746110f, -0.13957782f, -0.11279035f, 
    0.17973886f, 0.19450584f, 0.11223719f, -0.24192531f, 0.03924454f, 0.07185350f, 0.05310028f, -0.07729426f, 
    0.01991605f, -0.03024275f, 0.00260297f, -0.05683390f, -0.18066886f, -0.01260434f, -0.42675313f, -0.04338236f, 
    -0.00023190f, 0.06455113f, 0.02321711f, -0.02506286f, -0.05686925f, -0.00353304f, 0.07510894f, 0.04663434f, 
    0.09696253f, 0.15544549f, -0.10397261f, 0.02036935f, 0.03777621f, -0.01885328f, -0.19293691f, -0.28849664f, 
    -0.09213790f, -0.11368180f, -0.06992925f, -0.10082804f, 0.31714010f, -0.10597888f, -0.23773432f, -0.02870070f, 
    0.05647388f, 0.10390332f, 0.19147551f, 0.03214389f, -0.01523471f, 0.07702517f, -0.00222641f, 0.01236484f, 
    -0.51781839f, -0.36899617f, -0.52974063f, 0.28803802f, -0.01814226f, 0.02869342f, 0.02201239f, -0.01821134f, 
    0.02452596f, -0.02660400f, -0.09519452f, -0.25676218f, -0.32420388f, -0.10953610f, -0.01459461f, 0.04849320f, 
    0.02877297f, 0.01721882f, 0.04439649f, 0.02889466f, -0.02884728f, -0.08324421f, 0.17473924f, 0.14518715f, 
    -0.09144152f, -0.13945240f, 0.06216119f, -0.01358299f, 0.04034396f, 0.09967443f, -0.03238075f, -0.05101404f, 
    -0.25530222f, -0.16930106f, 0.02681668f, 0.01555379f, 0.30464956f, 0.11746860f, 0.02412451f, -0.16575307f, 
    0.05715568f, -0.15265787f, -0.00983644f, 0.09652055f, -0.10259251f, 0.07852907f, -0.02529364f, 0.08193180f, 
    0.04965716f, -0.03454594f, -0.21656074f, 0.03357078f, -0.13401847f, 0.03688487f, 0.06610817f, 0.15772136f, 
    -0.05032393f, -0.04738730f, -0.03384431f, 0.10415115f, -0.04151254f, -0.06728697f, -0.09869591f, 0.22538596f, 
    0.07913127f, -0.03723570f, 0.14876966f, -0.19528975f, 0.05584730f, -0.00859114f, -0.02253970f, 0.02594326f, 
    -0.12296119f, -0.16739404f, 0.05062399f, -0.02386435f, -0.00987605f, 0.04633262f, 0.01138369f, 0.04307236f, 
    0.06442753f, 0.12664489f, -0.14177316f, -0.07762782f, -1.08066690f, 0.10606557f, -0.03922347f, -0.16873308f, 
    -0.07511604f, 0.09919582f, 0.00276558f, 0.00122181f, 0.04634587f, 0.11596277f, 0.01509153f, 0.15060420f, 
    0.13805649f, 0.24439496f, 0.02921639f, -0.09896027f, 0.01862965f, 0.13149954f, 0.07324074f, 0.00284235f, 
    -0.04822724f, -0.03204281f, -0.05486105f, -0.06997316f, -0.15372531f, 0.06153999f, 0.00601333f, 0.02985797f, 
    0.27634192f, 0.10281537f, -0.21257396f, -0.00609299f, -0.02210711f, 0.08706884f, -0.11914562f, 0.14501938f, 
    0.00609082f, 0.09869519f, -0.05084534f, -0.00232523f, -0.04460478f, 0.01611358f, -0.06167716f, 0.06274373f, 
    -0.05886300f, -0.12641460f, -0.11464757f, 0.04753693f, 0.21458992f, -0.06393511f, -0.08089656f, -0.38802645f, 
    0.00568383f, 0.02269504f, -0.00538123f, 0.02329053f, 0.05762703f, -0.11453659f, -0.19654895f, -0.07014259f, 
    0.69353455f, -0.45583335f, 0.26943839f, -0.22369823f, -0.01328958f, -0.12680005f, 0.13291147f, 0.09535731f, 
    0.03970989f, 0.06645934f, -0.00413970f, -0.00187779f, 0.09142783f, -0.01761938f, 0.00164037f, -0.05903965f, 
    0.00206587f, -0.00229659f, 0.05294101f, 0.01791645f, -0.03812394f, 0.07672659f, -0.00918129f, -0.13089418f, 
    0.15409413f, 0.15907171f, 0.04704219f, 0.07778875f, 0.00819919f, -0.05732609f, -0.12544821f, 0.00282477f, 
    -0.00786152f, -0.02876418f, 0.04599913f, -0.02408891f, 0.13250111f, -0.10717896f, 0.01619390f, -0.06833424f, 
    -0.09497284f, 0.07885070f, 0.01337217f, -0.02209174f, -0.00423155f, -0.01239461f, 0.03863025f, 0.02052636f, 
    0.01475148f, -0.13996267f, 0.13570356f, -0.06671759f, 0.04269998f, 0.04026113f, 0.05134983f, -0.09767347f, 
    0.11739866f, -0.03507887f, 0.15130758f, 0.06771415f, -0.21509647f, 0.18170570f, -0.00089094f, 0.08266715f, 
    0.00320396f, 0.02294369f, 0.08220923f, 0.06390135f, 0.01272962f, 0.24388911f, -0.01881561f, 0.15102972f, 
    0.04702111f, 0.14621818f, 0.03066475f, -0.06795733f, 0.00968615f, 0.01679080f, -0.05345618f, -0.02597608f, 
    -0.42524326f, -0.08232098f, -0.11639152f, -0.43451655f, 0.15504394f, 0.16432478f, -0.33319673f, -0.54952610f, 
    -0.02550146f, -0.00956871f, -0.08887833f, 0.01339543f, 0.21860208f, -0.13856751f, -0.33072069f, -0.03310573f, 
    0.15161808f, -0.16103117f, 0.01205715f, -0.00902101f, 0.02053748f, -0.17314446f, -0.07864675f, -0.07689834f, 
    -0.02085370f, -0.00597506f, 0.02423374f, -0.05928311f, 0.28670618f, -0.38797873f, -0.05517201f, -0.06990137f, 
    -0.06973577f, 0.07182564f, 0.09643696f, 0.05789268f, 0.22794306f, 0.03928072f, -0.02786132f, 0.03913498f, 
    0.10843198f, 0.13585852f, 0.20723125f, 0.02817553f, -0.01961377f, 0.04469938f, 0.12044654f, -0.13598867f, 
    0.06153885f, -0.01259923f, -0.03278815f, 0.08526341f, -0.56566548f, -0.24290991f, -0.03226831f, -0.07852370f, 
    -0.02684977f, -0.01333409f, 0.04875446f, -0.04527336f, 0.06896572f, -0.05483315f, -0.05464222f, -0.03330460f, 
    0.26074964f, 0.24682562f, 0.16464980f, 0.00621557f, -0.01661269f, -0.04305931f, 0.07488164f, -0.13451053f, 
    0.03530228f, -0.01928703f, -0.03500882f, -0.11709376f, -0.23347607f, -0.24844803f, -0.39523500f, -0.11198454f, 
    -0.00049890f, 0.05319698f, 0.09639182f, 0.07660689f, -0.05504670f, -0.00693961f, 0.06501710f, 0.03223660f, 
    0.16282211f, 0.30951741f, 0.13153024f, 0.08774497f, -0.00754687f, 0.00580427f, 0.01880656f, -0.00295056f, 
    -0.06512929f, 0.05024852f, 0.04175141f, 0.04504864f, 0.15807565f, -0.02455639f, -0.01962339f, -0.01889367f, 
    0.04717744f, -0.04364403f, 0.05540762f, -0.04459617f, 0.20114197f, -0.07379562f, -0.31074640f, 0.09569608f, 
    0.16386771f, 0.05203712f, -0.09452710f, -0.05625864f, 0.01617183f, -0.05056722f, -0.09414817f, -0.07214976f, 
    -0.03566747f, 0.01858275f, 0.01783772f, 0.04821131f, 0.31319076f, 0.15739922f, -0.32419953f, -0.22909977f, 
    -0.09785812f, -0.01946563f, 0.02603694f, 0.02016908f, -0.11099874f, 0.01896405f, -0.04882305f, -0.06705401f, 
    0.01472550f, -0.03943327f, -0.00110019f, 0.03781490f, 0.14556809f, 0.02417769f, 0.08445813f, 0.00599033f, 
    -0.14042529f, -0.14543670f, -0.00393481f, 0.07821254f, 0.10887477f, -0.14928070f, -0.06695746f, -0.00565319f, 
    0.14109664f, -0.01818125f, 0.05435667f, 0.06542215f, -0.11047459f, 0.06356777f, -0.06895363f, 0.09873661f, 
    0.07563878f, 0.02138098f, 0.37225458f, 0.00701545f, 0.11929674f, -0.02888710f, -0.00494637f, -0.15899156f, 
    -0.01316455f, 0.06702568f, -0.08524160f, -0.06623382f, 0.31267866f, -0.18206114f, 0.13065571f, -0.16400959f, 
    0.07342817f, -0.10791418f, -0.05088940f, 0.09155716f, 0.01039246f, -0.06949192f, 0.02088258f, -0.04041308f, 
    0.31166583f, 0.11605223f, -0.09627748f, 0.06530242f, 0.00132237f, -0.03085046f, -0.04346595f, 0.08106098f, 
    -0.07777601f, 0.08415415f, -0.08313822f, -0.05897506f, -0.12555210f, -0.15430896f, -0.08390801f, -0.38945159f, 
    -0.05637448f, -0.03895867f, 0.06364366f, 0.06761273f, -0.07057009f, -0.06389090f, 0.03820547f, 0.08827510f, 
    0.31498331f, -0.03665784f, 0.13113520f, -0.12250321f, -0.03458327f, -0.09652010f, -0.02767869f, -0.03102492f, 
    -0.07240590f, 0.00867482f, 0.03187334f, 0.05157604f, -0.07518342f, 0.18335228f, 0.09062169f, 0.17368595f, 
    -0.01117928f, 0.06556696f, -0.15647708f, 0.07349467f, -0.10991602f, -0.00763703f, -0.04132117f, 0.00716203f, 
    -0.01880947f, -0.15982267f, -0.21918711f, 0.17985576f, -0.25500971f, -0.04388649f, 0.03338027f, -0.23662865f, 
    0.05718505f, -0.12041775f, -0.06940594f, 0.09878802f, 0.08978816f, -0.09636484f, 0.20114227f, 0.02617177f, 
    0.26613852f, 0.05732250f, -0.39775154f, -0.25814810f, -0.05437128f, 0.07276177f, -0.17521915f, -0.21154797f, 
    0.13461913f, -0.04953216f, 0.02306535f, 0.05364771f, 0.13396345f, -0.06086639f, 0.09209859f, 0.06646092f, 
    0.01461693f, -0.17679372f, 0.01616017f, 0.06545903f, -0.11856732f, 0.05962096f, -0.01914414f, -0.00571861f, 
    0.06036465f, 0.05260168f, 0.03914718f, 0.07733691f, -0.02644795f, 0.01055769f, -0.05701579f, 0.01679218f, 
    0.07846524f, 0.03255919f, -0.07760167f, 0.07789418f, -0.00997041f, 0.02500294f, -0.05822807f, 0.04648725f, 
    -0.23728412f, -0.36686790f, -0.16468719f, -0.21065357f, 0.08780673f, -0.06487203f, 0.15713856f, -0.00367648f, 
    0.01147222f, -0.08065058f, -0.01873394f, -0.03434807f, -0.01524246f, -0.02058381f, 0.00572043f, 0.04499590f, 
    -0.33349451f, 0.05718479f, -0.15713750f, -0.01128339f, 0.13250306f, -0.04673606f, 0.06743525f, 0.13347821f, 
    -0.02716051f, 0.10581484f, 0.05948614f, -0.14376891f, 0.06755954f, -0.28325680f, -0.07022820f, -0.08945750f, 
    -0.00485428f, 0.07844886f, -0.01176498f, 0.03957734f, 0.31512359f, 0.03680296f, -0.01152659f, -0.03171469f, 
    -0.10038519f, -0.09394984f, 0.09581906f, -0.00342299f, 0.11503504f, 0.10121384f, 0.21310985f, -0.03707286f, 
    0.04489234f, 0.01224918f, 0.03566459f, 0.05368067f, 0.02054144f, 0.04318850f, 0.17961426f, -0.10965627f, 
    -0.05272667f, -0.12268018f, -0.15339574f, 0.00535551f, -0.00312136f, -0.03533297f, -0.03211108f, 0.03405819f, 
    -0.06671370f, 0.14082003f, -0.00724833f, -0.00498919f, 0.03510411f, 0.06518053f, 0.01960478f, 0.02486333f, 
    -0.02746489f, 0.01879596f, -0.03233753f, 0.02826549f, 0.23112333f, -0.01231224f, 0.15034460f, -0.08161610f, 
    -0.28276709f, 0.06014453f, -0.01556565f, 0.05169742f, -0.07801632f, -0.02708491f, 0.01892756f, 0.07103784f, 
    0.06687144f, -0.11471409f, -0.28644753f, -0.05450333f, -0.24167003f, -0.19493617f, 0.19458888f, -0.03036401f, 
    -0.08800252f, 0.04436891f, 0.02118779f, 0.12147386f, 0.12409318f, 0.06148255f, 0.05587029f, 0.11455130f, 
    -0.04924750f, 0.02115047f, -0.04613616f, -0.07382260f, 0.16436827f, 0.03178100f, 0.08523469f, 0.01122109f, 
    0.38616949f, -0.08717200f, -0.60455632f, -0.10820986f, -0.11381228f, -0.23572509f, 0.01259033f, -0.03771471f, 
    -0.07980181f, 0.07760253f, -0.10790093f, 0.07612143f, 0.02433817f, -0.09572798f, 0.10246790f, -0.27791974f, 
    -0.01436902f, 0.07468873f, -0.03026327f, 0.27645141f, -0.01602322f, 0.00321659f, 0.04109422f, -0.11208974f, 
    -0.30282429f, -0.10121708f, -0.05370459f, -0.15504424f, 0.02041858f, -0.01450713f, -0.01188091f, 0.01392485f, 
    -0.17885125f, -0.13355857f, -0.16219674f, -0.12623510f, -0.01002376f, 0.03485625f, 0.12279064f, 0.03701121f, 
    -0.06422031f, 0.04904090f, 0.06906559f, 0.07857141f, 0.08156004f, -0.02039291f, -0.07141566f, 0.01483086f, 
    0.43769020f, -0.33428797f, 0.10306523f, 0.16523607f, 0.04496803f, -0.03221270f, -0.02659846f, -0.10959888f, 
    0.24931903f, -0.18501011f, -0.06255095f, -0.05855996f, 0.18432298f, 0.22198135f, 0.06936187f, 0.05961462f, 
    -0.02176239f, -0.05371213f, -0.29943150f, -0.10720045f, -0.02662304f, 0.00825722f, -0.03601206f, -0.03019436f, 
    -0.04565050f, -0.10302894f, -0.01238147f, -0.06790100f, 0.03129430f, 0.17698996f, -0.18766765f, -0.28840044f, 
    -0.05619470f, -0.00028479f, -0.01511501f, -0.07996649f, -0.45682934f, -0.16051491f, -0.01654368f, -0.00327908f, 
    0.08158444f, -0.12398735f, -0.06960756f, 0.27004978f, 0.11124026f, -0.11368855f, 0.10131927f, 0.10320156f, 
    -0.18362053f, 0.16968738f, -0.08606578f, -0.06877519f, 0.03279572f, 0.08348805f, -0.07451962f, -0.07468061f, 
    -0.01029437f, 0.06228224f, -0.03900548f, 0.01821205f, 0.54227000f, 0.15635745f, 0.10655665f, 0.04140801f, 
    -0.04553460f, -0.07860807f, -0.04275137f, -0.08680794f, 0.00197305f, -0.07114816f, 0.02673128f, 0.13404232f, 
    0.08897698f, -0.30083239f, 0.18557911f, -0.02478343f, 0.07073375f, -0.09905358f, 0.10231636f, 0.11000303f, 
    -0.03903167f, -0.04119224f, 0.09299561f, -0.08479265f, 0.08446240f, 0.20547800f, -0.21881439f, 0.09070457f, 
    -0.06946310f, -0.07623775f, -0.09430654f, -0.03622631f, -0.05506606f, -0.08014460f, -0.01821949f, -0.12737373f, 
    0.66630346f, 0.11099930f, 0.33176365f, 0.19580784f, -0.04855966f, 0.01568580f, -0.01152867f, -0.03197504f, 
    -0.01946832f, 0.16546638f, -0.21434492f, 0.11172189f, 0.19639115f, 0.11215609f, 0.12738448f, 0.10773869f, 
    -0.04262860f, 0.01094391f, -0.02721499f, -0.02572551f, -0.12542942f, -0.05970832f, -0.00260923f, -0.10446729f, 
    0.08548322f, -0.03944433f, 0.19124660f, -0.06971962f, -0.00746088f, 0.12736662f, -0.11494207f, -0.03546578f, 
    0.24304943f, -0.08054567f, 0.10945942f, -0.21235646f, -0.13142090f, 0.00245533f, -0.05914045f, -0.02130516f, 
    -0.09506498f, 0.12452373f, 0.13075210f, -0.10023197f, 0.16994072f, -0.23849699f, 0.06042805f, 0.05846737f, 
    0.12491019f, 0.03229611f, -0.21653701f, 0.06572121f, 0.17723235f, -0.27383095f, 0.04228158f, 0.05794815f, 
    0.00761883f, -0.11151135f, 0.06481040f, -0.03638357f, -0.00833471f, -0.26192644f, -0.14594173f, 0.02430547f, 
    -0.07762259f, 0.07484156f, -0.01787868f, 0.08318386f, -0.03936574f, -0.05114040f, 0.04853807f, -0.08967488f, 
    -0.01707410f, 0.08810181f, -0.08210611f, 0.05687362f, -0.00585441f, -0.01201912f, 0.00318486f, -0.14225642f, 
    0.09174579f, 0.11972649f, 0.09612202f, 0.11823766f, -0.03542079f, 0.16637859f, -0.28784052f, 0.11828982f, 
    -0.02449940f, 0.17220743f, 0.00210927f, -0.12242147f, -0.03991784f, -0.05540697f, -0.07831284f, 0.02321021f, 
    -0.38062641f, -0.21025327f, 0.01489311f, -0.07037627f, -0.04427696f, 0.06603596f, 0.04260349f, 0.01119212f, 
    -0.05066604f, -0.05815429f, -0.03459258f, -0.05521274f, -0.06347422f, -0.14725724f, -0.07013981f, 0.14342709f, 
    -0.10852828f, 0.09423629f, 0.03650125f, -0.04976310f, 0.11403058f, -0.01939264f, -0.06063434f, 0.14227070f, 
    -0.04739659f, 0.01499763f, 0.04344336f, 0.01648531f, 0.00141242f, -0.00716684f, -0.02827403f, 0.06026192f, 
    -0.00989026f, -0.01423248f, -0.09460713f, 0.07703108f, -0.36333627f, 0.52627122f, 0.06080773f, 0.04313721f, 
    -0.02735476f, 0.07206931f, 0.08634596f, -0.11573528f, 0.06277097f, 0.06701667f, 0.02801643f, 0.08050284f, 
    -0.02085261f, 0.18098587f, 0.16685739f, -0.10447060f, 0.01888199f, -0.06840063f, 0.00279432f, -0.01017753f, 
    0.08561429f, 0.08786448f, 0.11107937f, -0.26520637f, -0.09398919f, 0.07855125f, 0.03213844f, -0.08472098f, 
    0.08483028f, -0.00417790f, -0.17375970f, 0.20936428f, 0.08463227f, 0.04986626f, -0.10490347f, 0.12697138f, 
    -0.10065239f, -0.04892675f, -0.11295225f, -0.03183821f, -0.01447963f, -0.06265661f, -0.11520844f, 0.07997531f, 
    0.03636388f, -0.07385461f, -0.01580943f, 0.02239861f, -0.04869813f, -0.08874144f, 0.05838804f, 0.05839740f, 
    -0.05941366f, -0.06131058f, 0.06539949f, -0.06843867f, -0.01334816f, -0.07760211f, 0.03713992f, -0.05343667f, 
    0.20405915f, -0.08220017f, -0.03801043f, 0.08475102f, -0.06244816f, 0.00681162f, 0.02016552f, 0.06983335f, 
    -0.10411263f, 0.10558720f, 0.02865471f, -0.22404462f, -0.22468644f, 0.13812055f, -0.14200002f, 0.19344540f, 
    0.09597506f, 0.01015413f, 0.05039627f, -0.06084741f, 0.13584998f, 0.01402683f, -0.06452870f, -0.05213242f, 
    -0.06606659f, 0.04276343f, -0.09270708f, 0.11389114f, -0.04663400f, -0.02420159f, 0.00032731f, -0.03687052f, 
    0.14089918f, 0.09922349f, 0.16383244f, 0.07177584f, 0.33396250f, -0.13195612f, -0.07358387f, -0.06846932f, 
    0.05837494f, -0.09034986f, -0.04379460f, 0.00747670f, 0.03245649f, 0.15456092f, -0.05513599f, 0.13955753f, 
    -0.18262303f, -0.10020281f, -0.21070105f, -0.39145294f, -0.07845517f, -0.20234293f, 0.05559618f, -0.01950113f, 
    0.03960629f, -0.03282361f, 0.05784977f, -0.11563111f, -0.07248554f, 0.03187687f, 0.15296747f, -0.29266921f, 
    0.07391046f, 0.01340726f, -0.11557694f, 0.03460331f, -0.15378417f, -0.14633702f, -0.19063164f, 0.03827411f, 
    -0.26550692f, 0.03852574f, -0.01712867f, 0.00056091f, -0.04460977f, -0.01192264f, 0.10937726f, 0.02755212f, 
    0.01383141f, 0.07353817f, -0.07226884f, 0.14493053f, 0.18914883f, 0.03657941f, -0.06522518f, 0.00307999f, 
    -0.08691124f, 0.04715592f, 0.00693998f, -0.03292263f, -0.00561188f, -0.13969876f, -0.00657218f, 0.03014703f, 
    -0.40546441f, 0.44601730f, 0.22632207f, -0.07798807f, -0.12143060f, -0.07234776f, 0.14521061f, 0.01743130f, 
    -0.06250056f, -0.02515433f, 0.04242910f, -0.03837113f, 0.09179211f, -0.11061671f, -0.00819021f, 0.00693322f, 
    -0.00075010f, -0.14091457f, 0.03189230f, -0.04874286f, 0.02283319f, 0.08245897f, 0.02442912f, -0.04637192f, 
    -0.32187405f, 0.06425735f, 0.18824373f, -0.28371543f, 0.05480875f, -0.04062606f, 0.01126975f, 0.03529132f, 
    -0.00670087f, -0.02751461f, 0.08721685f, -0.01832301f, 0.02688937f, -0.05599511f, 0.00837166f, 0.00593313f, 
    0.04357440f, -0.02292331f, 0.04127059f, -0.06591140f, 0.15153725f, 0.06535613f, -0.01998266f, 0.23232831f, 
    -0.36942679f, 0.06366134f, 0.23653822f, -0.35926533f, -0.01068712f, -0.01124122f, -0.03538746f, 0.03405032f, 
    -0.02186590f, -0.02357392f, 0.02517069f, -0.06287017f, -0.26487434f, 0.34210682f, 0.45072627f, 0.29072315f, 
    -0.01166323f, -0.02313742f, 0.12393490f, -0.00251274f, 0.05446116f, -0.25613466f, 0.10474484f, -0.10218255f, 
    -0.05957120f, 0.07235941f, -0.06867382f, -0.02954623f, 0.01258324f, -0.21806248f, -0.07412974f, 0.16829640f, 
    0.05362988f, 0.03149428f, 0.10508139f, 0.01917427f, -0.19153561f, -0.10313140f, 0.11979821f, -0.15948509f, 
    -0.02852493f, -0.03745173f, -0.15666950f, -0.10514381f, 0.04210287f, 0.05720545f, -0.02311290f, 0.06647317f, 
    -0.09756564f, 0.15699206f, 0.61884141f, 0.17238487f, -0.00037835f, -0.10248373f, 0.10694076f, -0.02223524f, 
    0.06820457f, -0.02271708f, -0.04467650f, -0.09905799f, -0.13051163f, -0.23435029f, 0.25617111f, -0.37627926f, 
    0.03898848f, -0.06012253f, -0.05919977f, 0.12578027f, -0.00714173f, -0.05129080f, -0.01163132f, -0.01632874f, 
    -0.17009945f, 0.11374389f, -0.21491478f, 0.06342880f, 0.08941555f, -0.09812469f, -0.07357197f, 0.13464490f, 
    0.13513909f, -0.04998367f, 0.02021824f, 0.00814453f, 0.01325889f, -0.06850887f, 0.07753401f, -0.42477283f, 
    0.08332805f, -0.15544985f, -0.23016787f, -0.06269228f, -0.00040161f, -0.03624708f, 0.07125297f, 0.05183581f, 
    -0.35885242f, -0.05885993f, 0.19324087f, -0.34367198f, 0.05120280f, -0.07216977f, -0.22091384f, -0.00403302f, 
    0.08617131f, 0.00117784f, 0.03185075f, 0.05114983f, -0.18601617f, 0.00035399f, -0.01745745f, -0.04782895f, 
    -0.03706785f, -0.06050619f, -0.07291733f, 0.07494243f, 0.02830105f, -0.03805179f, -0.03195832f, -0.02226730f, 
    0.11197391f, -0.26768997f, 0.07338900f, 0.10614218f, 0.03006133f, -0.07383203f, 0.07754307f, 0.20808581f, 
    0.03772831f, 0.09442613f, 0.04151589f, -0.03429121f, 0.33505780f, -0.09160866f, 0.23312332f, 0.13300762f, 
    -0.01613116f, -0.02106327f, 0.00739101f, -0.02911478f, 0.01227926f, 0.06429230f, -0.12363060f, 0.04340285f, 
    0.00690153f, -0.15917195f, 0.06372803f, 0.06990577f, 0.02950738f, -0.00082492f, -0.06984621f, 0.08062214f, 
    0.03365208f, -0.03922181f, 0.04135665f, 0.01717312f, 0.04438398f, -0.02169516f, 0.01335599f, 0.07022279f, 
    0.08204653f, 0.10415992f, -0.03933565f, -0.02196681f, -0.02115499f, -0.10960402f, -0.18002047f, -0.09140867f, 
    0.07304903f, -0.04109416f, -0.06793178f, 0.01137951f, 0.01321190f, -0.00913250f, -0.01800052f, 0.07710790f, 
    0.05416845f, 0.04381815f, -0.03398884f, 0.07332662f, -0.22615404f, -0.16287869f, 0.13880394f, 0.12078457f, 
    0.08293333f, -0.09737311f, 0.07462610f, -0.00403159f, 0.01702377f, 0.02769536f, 0.01814819f, -0.09797558f, 
    0.13773397f, 0.05748405f, -0.08182665f, 0.20757720f, -0.11064430f, -0.05824674f, -0.10099244f, -0.02424254f, 
    -0.00309941f, -0.07211459f, 0.01171216f, -0.05628800f, 0.06015885f, 0.25987285f, 0.16314845f, 0.05010589f, 
    -0.07254290f, 0.01478905f, 0.08031769f, -0.05834711f, -0.00197506f, 0.06014125f, -0.09758162f, 0.12055574f, 
    -0.31233642f, -0.33274671f, -0.10040051f, -0.43669549f, -0.02618829f, -0.05195795f, 0.00914908f, 0.00412118f, 
    -0.09778669f, 0.00958378f, 0.00030938f, -0.04984464f, -0.34835118f, -0.31275830f, -0.02015307f, -0.29664049f, 
    -0.02591792f, -0.05567460f, -0.07268599f, -0.26523122f, -0.00749042f, -0.00664767f, 0.05631797f, -0.02658314f, 
    -0.54299796f, -0.10817801f, -0.14269377f, -0.18802188f, 0.03663982f, -0.02147057f, 0.08421504f, -0.04547248f, 
    -0.01407168f, -0.03918824f, -0.03279913f, 0.01395924f, 0.11460278f, 0.02479650f, 0.05110285f, -0.15764746f, 
    -0.04876339f, -0.00474560f, -0.12626970f, -0.06829829f, -0.00081745f, -0.05784975f, 0.01071716f, -0.05784090f, 
    -0.21122243f, -0.33790773f, 0.17118113f, -0.14025113f, -0.01472350f, -0.30364311f, -0.21239771f, -0.23037784f, 
    0.01002296f, -0.05296408f, -0.00353769f, -0.02209021f, 0.02959928f, -0.04609900f, -0.01540336f, 0.00634807f, 
    0.03746583f, 0.07190168f, -0.03224347f, 0.08480756f, -0.18338329f, -0.02944816f, 0.07311051f, 0.07655093f, 
    -0.74435228f, 0.14935043f, 0.04995062f, -0.18711761f, -0.06261846f, 0.04985086f, -0.22442099f, -0.18950090f, 
    0.03608682f, -0.00279983f, -0.07897132f, 0.09843220f, -0.24075806f, -0.20304418f, 0.24690963f, -0.23388340f, 
    0.17289935f, -0.08582214f, -0.34332615f, 0.23908566f, 0.01953296f, 0.04057902f, -0.05149443f, -0.01934473f, 
    0.23534909f, 0.19975691f, 0.13280791f, 0.11177483f, -0.01711033f, 0.01411590f, 0.06629614f, -0.09296770f, 
    -0.01344868f, 0.06126363f, 0.07160152f, 0.01934261f, -0.02712714f, -0.06131291f, 0.10006733f, -0.23750201f, 
    0.09776056f, 0.00556550f, 0.02640704f, 0.09655356f, 0.00916164f, 0.02187703f, 0.07562649f, 0.06543425f, 
    -0.05034704f, -0.17350706f, 0.27654633f, -0.00923052f, -0.02765400f, 0.01118807f, -0.17620996f, 0.01653014f, 
    0.11175345f, -0.08222680f, 0.14706294f, -0.08940555f, -0.35988194f, 0.10796446f, -0.03964844f, 0.07174426f, 
    0.02862060f, -0.01007782f, -0.03170766f, 0.04794593f, 0.01707832f, -0.04456118f, -0.00551178f, -0.01890504f, 
    0.00758120f, 0.25578150f, 0.03458001f, 0.15753517f, -0.01398517f, 0.06377895f, 0.06310573f, 0.06667215f, 
    0.01019304f, 0.09752142f, 0.09318282f, 0.05663630f, 0.50014901f, -0.15426980f, -0.09077992f, 0.32641646f, 
    0.11147950f, 0.07302674f, 0.04759615f, -0.04660368f, -0.02083460f, -0.01118022f, 0.02625776f, 0.08567102f, 
    -0.25295499f, -0.11244967f, -0.12281304f, 0.05678268f, 0.06359948f, 0.11239573f, 0.00179022f, 0.00439634f, 
    -0.03621777f, -0.02792744f, 0.02981902f, 0.07737529f, -0.44764599f, 0.28240892f, 0.01625245f, -0.02090625f, 
    0.02324894f, -0.01846112f, 0.03994733f, -0.04294075f, -0.00279910f, 0.05684697f, 0.08866010f, -0.00826472f, 
    -0.05306203f, -0.33476391f, 0.05354574f, -0.22883295f, 0.06997845f, 0.09014114f, 0.02734700f, -0.05651376f, 
    -0.00449409f, -0.04239761f, -0.04258643f, -0.18809684f, -0.11309908f, 0.15774472f, 0.54187942f, 0.17756364f, 
    0.05055572f, -0.00698517f, 0.18914214f, 0.03871492f, 0.05134365f, -0.04573718f, 0.03730586f, 0.06595935f, 
    0.14477263f, -0.11862281f, 0.06861794f, -0.18741676f, 0.00024762f, -0.04145222f, -0.02311640f, 0.01771420f, 
    0.02277274f, 0.09318848f, -0.04340348f, 0.00751985f, -0.01727686f, -0.08060125f, -0.08644974f, 0.04142359f, 
    -0.01576519f, -0.00803281f, 0.04892614f, 0.06588029f, -0.07408409f, 0.08125485f, -0.06082805f, 0.05176874f, 
    0.07139605f, -0.07876379f, 0.08539591f, -0.08531999f, 0.06524787f, -0.05302089f, -0.13028891f, 0.06393225f, 
    0.09085456f, 0.01069627f, 0.01454556f, 0.05769800f, -0.09316111f, 0.15064456f, -0.08766033f, 0.16028576f, 
    -0.05547878f, -0.10739824f, 0.00505592f, -0.02591029f, 0.01948276f, -0.07527255f, 0.08141510f, -0.06664086f, 
    0.21516311f, 0.53931230f, -0.61732340f, -0.33615398f, 0.02622178f, 0.13900720f, -0.06998648f, 0.01037709f, 
    -0.08140979f, -0.04639671f, -0.03312882f, 0.15944070f, -0.23342955f, 0.12425932f, -0.24212961f, 0.14644304f, 
    0.03756479f, -0.01307721f, -0.02180938f, -0.04872438f, -0.05889032f, -0.02979602f, -0.01064332f, -0.02286438f, 
    0.10275592f, 0.06992931f, -0.02409912f, -0.03381050f, -0.16327046f, 0.05890772f, -0.01341259f, 0.15755269f, 
    -0.03736412f, -0.07254464f, 0.01226193f, 0.04466735f, 0.37128958f, -0.10703050f, -0.11619031f, -0.03033924f, 
    0.03181377f, -0.04247351f, -0.04263523f, 0.07667794f, 0.01652995f, 0.09336820f, -0.11975007f, 0.00262246f, 
    0.05391815f, -0.07370505f, 0.07322612f, 0.16716783f, -0.06292146f, -0.04847407f, -0.05271138f, -0.00309133f, 
    0.05467362f, -0.04105040f, -0.07906939f, -0.03811213f, 0.23924828f, -0.19896360f, -0.08937359f, -0.38911062f, 
    0.09366157f, -0.12710699f, -0.00946436f, 0.07338592f, 0.14257498f, 0.11721063f, -0.23198852f, -0.15956549f, 
    -0.28904176f, 0.03846086f, -0.15659736f, -0.31526661f, 0.09259731f, -0.03942214f, 0.04228109f, -0.10116905f, 
    -0.11128514f, 0.14623320f, 0.07210027f, -0.07516978f, -0.28928718f, 0.10065142f, 0.05442389f, 0.22146724f, 
    -0.12636331f, 0.12288792f, -0.07000021f, 0.00640240f, -0.06696367f, 0.08324357f, 0.09454937f, 0.09637512f, 
    0.07918476f, -0.04366767f, 0.01332887f, 0.33044362f, -0.01002736f, -0.02811853f, 0.04681221f, -0.02748297f, 
    -0.04049205f, 0.16288680f, 0.08848305f, -0.01585335f, -0.26327157f, -0.03317120f, 0.02513823f, -0.04695958f, 
    0.05504024f, 0.15249625f, -0.03885073f, -0.23257083f, 0.00398723f, 0.05473479f, 0.04880641f, -0.14284523f, 
    -0.23483564f, -0.44883832f, -0.12722774f, 0.17450470f, 0.02772221f, 0.12809253f, -0.11686963f, 0.17603578f, 
    0.12078417f, -0.09898479f, 0.03132372f, 0.22564545f, 0.26285815f, 0.09288457f, 0.29346645f, -0.20548421f, 
    -0.12862401f, 0.12535356f, -0.19720930f, 0.01566162f, 0.04819791f, -0.14810744f, 0.14318617f, -0.12627208f, 
    -0.77876353f, 0.62468159f, -0.13999432f, -0.50022626f, 0.08926594f, 0.02494160f, -0.07240710f, 0.06000202f, 
    -0.28071049f, -0.09617818f, -0.07599024f, -0.11001426f, -0.16818571f, -0.13884071f, -0.08639848f, -0.61164308f, 
    0.12139320f, 0.01755773f, 0.00692480f, -0.00255356f, -0.03607260f, 0.05814665f, 0.03145119f, -0.16902578f, 
    0.03899360f, -0.05094566f, -0.00137740f, -0.19315124f, -0.13065967f, 0.09890471f, -0.04440391f, 0.01245250f, 
    0.01812519f, 0.06980276f, 0.03731196f, -0.08003572f, -0.39136451f, -0.07951256f, -0.17050070f, -0.19216089f, 
    -0.08720134f, 0.00280212f, 0.00802297f, -0.13645342f, -0.15091623f, 0.03633757f, -0.10421916f, 0.09087721f, 
    0.06341641f, -0.04001660f, -0.09208743f, 0.36162210f, 0.00982764f, -0.03673224f, -0.10999689f, -0.11201297f, 
    -0.00882619f, -0.13550235f, 0.08309850f, 0.00509985f, -0.13893594f, 0.10299710f, 0.03861666f, 0.37800854f, 
    0.27556100f, -0.20474334f, 0.13996485f, -0.04187916f, -0.00822231f, -0.10166422f, 0.16989297f, -0.03014596f, 
    -0.09210560f, -0.33495870f, 0.10532130f, -0.11953779f, -0.20943825f, -0.30242360f, -0.01695158f, 0.13204789f, 
    0.04690428f, 0.01628180f, -0.15437497f, -0.11324616f, 0.57867634f, 0.03791583f, 0.09955824f, 0.17117347f, 
    -0.04918433f, 0.00615413f, -0.09478622f, 0.02606470f, -0.06058308f, -0.09805782f, 0.21470453f, -0.01739459f, 
    -0.03568293f, -0.08765006f, -0.08134819f, 0.06875929f, 0.04079664f, 0.05340328f, -0.06691933f, -0.10365830f, 
    -0.00998309f, 0.03573228f, 0.13006106f, 0.04495076f, -0.22235171f, -0.13285226f, -0.09173426f, 0.01675737f, 
    0.01354248f, -0.02612570f, 0.06527007f, 0.10869996f, -0.05085811f, -0.01355063f, -0.00122700f, -0.00286482f, 
    -0.40609497f, -0.04976987f, 0.16552530f, -0.08613762f, -0.21994112f, -0.00881567f, -0.07716129f, 0.10276431f, 
    -0.03799606f, 0.02442357f, -0.00230234f, -0.08952697f, -0.06556048f, 0.01365809f, -0.08779471f, -0.16889805f, 
    -0.15500093f, 0.00441772f, -0.07504793f, -0.08342648f, -0.16168974f, 0.00814323f, 0.00094698f, 0.02510807f, 
    -0.10625938f, -0.04102954f, 0.09346311f, 0.15656307f, -0.06023406f, -0.05620049f, -0.13880309f, -0.03590084f, 
    0.08080629f, 0.03102747f, 0.04249142f, 0.08250967f, -0.03938502f, -0.21440998f, 0.05560400f, 0.17402422f, 
    0.19245595f, 0.18581466f, 0.06227717f, 0.06187351f, 0.02453060f, -0.03158456f, 0.03233804f, 0.08063574f, 
    -0.14704525f, 0.06553864f, -0.23102921f, -0.07025604f, -0.10068779f, 0.15107161f, -0.19827594f, -0.10747838f, 
    -0.11222088f, -0.02784937f, 0.02697601f, -0.01507429f, -0.16306303f, -0.29570574f, 0.30965468f, -0.05730645f, 
    0.05394389f, -0.04721512f, -0.02145931f, 0.03215267f, -0.01160690f, 0.00145215f, -0.21379706f, 0.05649874f, 
    0.26763636f, 0.03372503f, -0.07090556f, 0.16530085f, 0.11587325f, -0.01280494f, -0.01825064f, 0.03693488f, 
    -0.11237173f, -0.05020412f, 0.01356287f, 0.09789889f, 0.16349405f, -0.14072722f, 0.24900255f, -0.34422415f, 
    -0.29072282f, 0.08128295f, -0.08813590f, -0.03644560f, 0.03472844f, 0.07524397f, 0.13789369f, -0.12955984f, 
    -0.62628376f, -0.13293292f, -0.30549160f, -0.02214086f, -0.01367992f, -0.08642829f, -0.06696928f, 0.05688116f, 
    -0.06340423f, -0.04195403f, -0.00221495f, -0.09025913f, 0.11369119f, 0.11626994f, 0.35052639f, 0.19748636f, 
    0.17467843f, 0.04967668f, 0.09957221f, 0.10650627f, 0.09912184f, -0.05262173f, 0.07671589f, 0.12706415f, 
    -0.41830924f, 0.02815536f, 0.14055282f, 0.20705186f, -0.00451443f, 0.01441686f, -0.13719451f, 0.08499052f, 
    0.05643723f, 0.09378321f, -0.11330677f, -0.00283407f, -0.01852813f, -0.13323109f, -0.08327723f, 0.09406027f, 
    0.06310450f, 0.00911263f, -0.07395213f, 0.04783313f, 0.09614866f, 0.05503776f, 0.07174134f, -0.01240229f, 
    -0.14577703f, 0.17745513f, -0.16260213f, -0.08696418f, 0.12355539f, -0.03973454f, -0.03803677f, -0.13359678f, 
    0.04633442f, 0.07634945f, -0.14794399f, -0.00141858f, 0.57145190f, -0.27515677f, 0.01141836f, 0.19324724f, 
    0.05322250f, -0.09766728f, 0.03789495f, -0.13934423f, -0.04519785f, 0.05687242f, -0.00531534f, 0.11880633f, 
    -0.27936217f, 0.61681181f, -0.10857370f, -0.32444334f, 0.16870871f, 0.18424483f, -0.09013147f, -0.13085026f, 
    -0.44141760f, 0.07110630f, -0.08571657f, 0.00427008f, -0.00442998f, 0.22380202f, -0.00157237f, 0.08151402f, 
    0.10189259f, 0.06117018f, 0.08768289f, -0.17177069f, -0.02264562f, 0.12305450f, 0.13811488f, 0.05859706f, 
    -0.11368596f, 0.37986609f, -0.19098321f, -0.11832780f, 0.07933803f, 0.13836525f, 0.09281018f, -0.00123550f, 
    -0.16830610f, 0.02293066f, -0.05425626f, -0.06957858f, 0.02959366f, 0.00696066f, -0.11489882f, 0.05346514f, 
    -0.00884067f, -0.00033227f, -0.00826775f, 0.01339361f, 0.01943843f, 0.05338372f, 0.05384155f, 0.06861728f, 
    -0.03559237f, 0.23632829f, -0.06693193f, 0.15724343f, -0.15182903f, 0.00721255f, -0.10668080f, 0.02267970f, 
    -0.00726679f, -0.05754664f, -0.15257828f, 0.11192692f, -0.16261417f, -0.05824496f, -0.02122630f, 0.22769240f, 
    -0.03395180f, 0.03276308f, -0.07310685f, 0.00029489f, -0.02407548f, 0.04680011f, -0.04645694f, 0.16122635f, 
    -0.00876750f, -0.07345369f, -0.08061214f, 0.06913052f, 0.08576021f, 0.02755693f, 0.12682481f, 0.12502918f, 
    -0.08611496f, -0.00106889f, -0.00890657f, -0.13266365f, -0.04627144f, -0.06503483f, 0.06017396f, 0.28879666f, 
    -0.01370290f, 0.00183666f, 0.05766209f, 0.00454078f, -0.01499338f, 0.14959513f, 0.00758699f, -0.07865980f, 
    0.05007131f, -0.10585603f, -0.07423367f, -0.00318620f, 0.01763251f, 0.06533039f, -0.02427335f, 0.06279198f, 
    -0.06587315f, -0.12685663f, -0.06771977f, -0.05407742f, 0.07324618f, 0.03642268f, 0.08754650f, 0.23543176f, 
    -0.10242832f, 0.00667823f, -0.03632993f, 0.00723174f, 0.01244630f, 0.13945429f, 0.23379314f, -0.03962097f, 
    -0.20352367f, -0.20993097f, 0.45198694f, 0.25796044f, 0.01228525f, 0.13226159f, -0.02991900f, -0.00202883f, 
    0.15815125f, -0.01315954f, -0.18124440f, 0.10128453f, 0.00806099f, -0.10687394f, -0.18085098f, -0.12665117f, 
    0.11684847f, -0.12295843f, 0.03453689f, -0.07618456f, -0.10594884f, 0.04961633f, -0.08822729f, -0.22117728f, 
    -0.23007537f, -0.12473210f, 0.17557436f, 0.19883253f, -0.03290224f, -0.08780989f, 0.09594327f, -0.01862577f, 
    -0.09288798f, 0.13169412f, -0.04070755f, -0.06665729f, -0.01163079f, -0.11712661f, 0.28172216f, 0.21101625f, 
    0.00560257f, -0.10406695f, 0.03381567f, -0.07961591f, -0.02198462f, -0.03370793f, -0.17689857f, 0.11913285f, 
    0.41525468f, -0.06403241f, 0.00880463f, 0.05942718f, 0.20294660f, 0.06631579f, 0.03919453f, -0.19459677f, 
    -0.22605190f, 0.00104544f, -0.00016539f, -0.00678611f, 0.09594242f, -0.10092011f, -0.00304088f, -0.02474950f, 
    -0.06628054f, -0.01257783f, -0.10438950f, 0.00843413f, -0.08785556f, 0.04969618f, -0.19255961f, 0.12100804f, 
    -0.25999126f, 0.78172523f, -0.16908625f, -0.06108463f, 0.29875311f, 0.07488991f, 0.08252332f, -0.01822344f, 
    -0.10549194f, -0.11897738f, -0.06257575f, 0.02409198f, 0.17573667f, -0.18230985f, -0.03539731f, 0.03425873f, 
    0.04576544f, -0.02680634f, 0.02120971f, -0.00600419f, -0.00366132f, 0.06375773f, 0.06724600f, 0.17325066f, 
    -0.09011153f, -0.03691290f, -0.12932438f, 0.26868582f, -0.05563413f, 0.04721153f, -0.12724727f, 0.01052390f, 
    -0.02637759f, -0.13867001f, -0.00851989f, 0.01180008f, 0.22827147f, 0.18474306f, -0.14361626f, -0.04185165f, 
    -0.20988570f, 0.10201448f, -0.21684244f, -0.12024096f, -0.02783179f, -0.23397443f, 0.03953651f, 0.07503923f, 
    0.04635402f, -0.14152491f, -0.05014417f, -0.02496733f, -0.04385246f, -0.00670013f, -0.07135575f, 0.06034750f, 
    0.00995367f, -0.05261433f, 0.17550239f, -0.18608384f, -0.74471837f, 0.26745266f, -0.07226587f, -0.37354439f, 
    -0.06230481f, 0.08460210f, 0.07807788f, -0.14891142f, -0.05779818f, 0.09154158f, 0.07909137f, -0.08798555f, 
    0.08140271f, -0.07492576f, -0.01007241f, 0.25250614f, 0.00520698f, -0.01395269f, 0.07743383f, -0.09386577f, 
    -0.09614911f, -0.10798655f, -0.01953989f, 0.08465407f, 0.20401484f, 0.04335033f, -0.19199017f, 0.12422572f, 
    0.11770632f, 0.09707160f, -0.02154784f, 0.01730141f, -0.11230082f, -0.00743390f, 0.06800818f, 0.12320478f, 
    0.18643451f, 0.24478947f, 0.20981297f, 0.04867325f, 0.25036705f, -0.08723000f, -0.18462247f, -0.13054210f, 
    -0.14655815f, 0.01075231f, 0.15704951f, 0.01840285f, -0.11566114f, 0.27871773f, -0.17113215f, -0.29772052f, 
    0.06778782f, 0.10993946f, 0.06003625f, -0.01957838f, -0.06646017f, 0.07951776f, -0.11051442f, -0.02346004f, 
    -0.16509432f, 0.07336018f, -0.26417235f, 0.18311122f, -0.15523143f, -0.21492718f, -0.19965619f, -0.09627716f, 
    -0.03619134f, -0.00551869f, 0.08127334f, -0.17690402f, -0.17258142f, -0.16296367f, -0.14199562f, 0.03261634f, 
    0.06934896f, 0.08169406f, -0.04572651f, 0.07628135f, -0.08206121f, -0.08874143f, -0.07287059f, 0.04487841f, 
    -0.06950042f, -0.31316799f, 0.06879120f, 0.36937708f, -0.00148229f, -0.27987698f, -0.08686817f, -0.09821092f, 
    -0.00661708f, 0.00205691f, -0.03581779f, 0.09632496f, 0.03017179f, -0.01260085f, 0.18057169f, -0.02805415f, 
    -0.10438576f, 0.10789293f, -0.22411881f, 0.00991924f, -0.06343452f, -0.01738752f, 0.03587334f, 0.05521056f, 
    -0.02701864f, -0.04136807f, -0.09153114f, 0.06005519f, 0.03335094f, 0.02545739f, 0.00118242f, -0.21424662f, 
    0.06178408f, -0.00338124f, 0.12322592f, 0.18635485f, 0.03433930f, 0.05016560f, 0.13155641f, 0.00207618f, 
    -0.15626229f, -0.10447442f, -0.03368496f, 0.05305691f, -0.08959253f, -0.15319830f, -0.04717655f, -0.11843236f, 
    -0.05791244f, -0.00058605f, 0.11431995f, 0.11732674f, 0.03940351f, 0.02482975f, 0.01230624f, 0.10306165f, 
    0.01774454f, 0.06021958f, -0.02124199f, -0.02639483f, 0.03422770f, -0.00392346f, 0.03526194f, -0.08207152f, 
    -0.11204269f, -0.11134584f, 0.10732768f, 0.02604886f, -0.00344156f, -0.06463093f, 0.04376267f, -0.14007647f, 
    0.02356956f, 0.02204606f, -0.03812713f, 0.04488508f, -0.15994595f, -0.02746027f, -0.10044401f, -0.12559444f, 
    -0.01955983f, -0.01133594f, -0.16285668f, -0.10152392f, -0.14745381f, 0.00725700f, 0.17421050f, 0.18437374f, 
    0.00896542f, -0.04096042f, 0.00097036f, -0.08283561f, 0.08656641f, -0.10441937f, -0.02838591f, 0.05259595f, 
    -0.26597464f, 0.06479150f, 0.02913494f, -0.18838874f, 0.01940807f, -0.09635337f, -0.32714033f, -0.10191157f, 
    -0.03005373f, 0.05628398f, -0.06011041f, 0.09264709f, -0.01835978f, 0.05318181f, -0.16213866f, -0.03307125f, 
    0.01138044f, 0.00960238f, -0.21524116f, 0.04328458f, -0.00320333f, -0.12136516f, -0.19641840f, -0.09834174f, 
    0.04429263f, 0.08892619f, 0.00628938f, 0.14100745f, 0.13303719f, 0.02732345f, 0.12864242f, 0.01311830f, 
    0.16052741f, 0.08646687f, 0.00787918f, 0.04925185f, -0.04492133f, 0.09293690f, -0.03713980f, 0.08375087f, 
    -0.02957768f, -0.00952776f, -0.03449681f, 0.09284323f, 0.06565072f, -0.03965788f, -0.07443069f, -0.11217868f, 
    0.24165361f, -0.68311089f, 0.11702340f, -0.14482743f, -0.09290165f, -0.01051417f, -0.01792732f, 0.00769398f, 
    -0.14771797f, 0.12688197f, -0.08351278f, 0.01334510f, 0.05812766f, -0.25642854f, 0.02168428f, -0.20669395f, 
    -0.05510756f, -0.03747542f, -0.07844844f, 0.04376994f, -0.19174151f, -0.20764661f, -0.09032293f, -0.09776186f, 
    0.03766678f, -0.08186107f, -0.07611788f, 0.02722776f, -0.02744004f, -0.07018496f, 0.05140815f, 0.00668813f, 
    0.19091317f, 0.13761261f, 0.10016707f, 0.38860488f, 0.04985909f, 0.21686363f, -0.09808481f, 0.05062342f, 
    0.16482075f, -0.06001882f, -0.02473438f, -0.08177794f, -0.07270473f, -0.07943589f, 0.13275690f, -0.14017820f, 
    -0.23332371f, 0.26474899f, 0.29018259f, 0.12114080f, 0.11839741f, 0.13341512f, -0.03449124f, 0.24021323f, 
    -0.07015657f, 0.03197218f, -0.10699876f, -0.00293520f, 0.06524060f, 0.11204160f, -0.08394394f, 0.17692047f, 
    0.01162230f, -0.05787117f, -0.07939108f, 0.01538440f, -0.34606209f, -0.06871045f, 0.03415038f, -0.03397181f, 
    -0.17485286f, 0.18575896f, 0.00132708f, -0.15569571f, -0.06790616f, -0.06657736f, -0.13540800f, 0.02422819f, 
    -0.03262838f, 0.03347423f, -0.00567029f, -0.06373047f, -0.13927008f, -0.03231008f, 0.05662475f, -0.07655286f, 
    0.01865988f, -0.00939522f, -0.00499264f, -0.01638171f, -0.12799704f, -0.19148402f, 0.00256133f, 0.00197415f, 
    -0.06454784f, 0.03006087f, 0.09716872f, 0.17531073f, -0.06444173f, -0.01911571f, 0.04491534f, 0.09877542f, 
    0.02072726f, 0.09588607f, -0.03930682f, 0.13871703f, 0.23802087f, 0.15298875f, 0.22019103f, 0.13907343f, 
    -0.01783023f, -0.06609915f, -0.03213217f, -0.09708675f, 0.10674887f, 0.03405464f, 0.02841840f, 0.03750849f, 
    0.12355437f, -0.52857983f, -0.23247093f, -0.02386299f, 0.05063385f, 0.03355369f, 0.05483708f, -0.07066003f, 
    0.06964280f, -0.04692881f, -0.00151427f, 0.03214823f, -0.04108073f, -0.13762593f, -0.14883929f, 0.01195226f, 
    -0.00252980f, 0.02433925f, 0.03251352f, 0.11250011f, -0.24051465f, -0.00787384f, -0.15409112f, -0.08485254f, 
    0.13725029f, 0.01119733f, 0.06929356f, 0.20933378f, -0.03463978f, 0.05180569f, 0.15490310f, 0.04404012f, 
    0.05389732f, -0.01360387f, -0.01064882f, -0.03883793f, 0.08359963f, 0.35734364f, 0.16082455f, 0.04420465f, 
    -0.01260228f, -0.09273343f, -0.05209330f, -0.03143365f, 0.06906931f, -0.20857987f, -0.13424677f, 0.04710235f, 
    0.11978389f, 0.02490991f, 0.07402460f, 0.08206467f, 0.07909732f, -0.17016146f, -0.07276017f, -0.04519484f, 
    0.05829334f, -0.07062651f, -0.25769675f, 0.02697021f, 0.03168702f, 0.18312953f, 0.03721278f, 0.18900180f, 
    0.05596390f, 0.08935903f, 0.05043123f, -0.10189644f, -0.06109432f, -0.07911885f, 0.09096340f, -0.04340690f, 
    -0.11959651f, -0.20088390f, 0.06825268f, 0.02167145f, -0.05578890f, -0.08375379f, -0.04687262f, -0.10713159f, 
    0.00456879f, 0.04158894f, -0.01295359f, -0.10984163f, 0.13923803f, -0.01784402f, -0.25705099f, 0.37541080f, 
    -0.04817434f, 0.06265221f, -0.08686002f, -0.10362896f, 0.08940838f, -0.01605670f, -0.05293298f, -0.03464269f, 
    0.28202823f, 0.00931598f, -0.08355541f, -0.15300016f, 0.01585678f, 0.15449449f, 0.08099865f, -0.14864403f, 
    -0.14201659f, -0.15171011f, -0.04388956f, -0.11009069f, 0.03597451f, 0.09081452f, -0.15596814f, 0.38668644f, 
    0.24190341f, -0.00254924f, -0.05356796f, -0.12874708f, -0.01189858f, 0.14328246f, 0.05851891f, -0.01641071f, 
    0.04384405f, 0.15012096f, -0.23116721f, -0.04347194f, 0.08091934f, -0.07846057f, 0.16305463f, -0.24719337f, 
    0.04009843f, 0.05476002f, 0.01063612f, 0.00747976f, 0.14324555f, 0.15720867f, 0.17017393f, 0.04972877f, 
    -0.06959914f, -0.08941646f, -0.02554804f, -0.02750999f, 0.04593014f, -0.01680947f, 0.04523812f, 0.04722240f, 
    -0.07151935f, -0.15663546f, 0.06430019f, 0.10732829f, -0.12545229f, 0.04012930f, -0.27131251f, -0.03280414f, 
    -0.11877198f, 0.04086093f, 0.03301496f, 0.05014217f, -0.10293767f, 0.04651543f, -0.15206209f, 0.05026300f, 
    -0.11534559f, -0.09669507f, 0.09618985f, -0.06527030f, 0.05027680f, 0.03580321f, -0.01547770f, 0.25383061f, 
    0.17707402f, -0.06478631f, -0.01097357f, 0.07342505f, 0.03670098f, 0.03661862f, 0.08629858f, -0.16076517f, 
    -0.11806804f, 0.05910679f, -0.00888847f, -0.21685447f, 0.18739806f, -0.07747730f, 0.04556134f, -0.05384130f, 
    -0.07508460f, -0.00037556f, -0.13200887f, 0.01904283f, 0.06586704f, -0.07985724f, -0.19560595f, -0.06143467f, 
    -0.08811056f, -0.24953260f, 0.09435375f, 0.00328679f, -0.02289425f, -0.03388716f, -0.01390722f, 0.00167884f, 
    0.07285029f, 0.21439317f, 0.09281783f, 0.24659610f, -0.14699984f, 0.07296094f, 0.03093669f, -0.00460429f, 
    -0.10667101f, 0.06826133f, -0.01805438f, 0.03911871f, 0.04083288f, -0.00432030f, -0.07254443f, 0.18375385f, 
    -0.08012870f, -0.06638473f, 0.07869568f, 0.02707087f, -0.13526584f, -0.02418324f, -0.07242881f, -0.03984616f, 
    -0.09948473f, -0.00990667f, -0.03527378f, 0.01280634f, -0.12819928f, -0.08236791f, 0.04919278f, 0.07235806f, 
    -0.00052858f, -0.09910025f, -0.00498617f, -0.06916961f, 0.04464693f, -0.13307735f, 0.02564495f, -0.08452987f, 
    0.12523328f, 0.19869410f, 0.29348984f, 0.24302195f, -0.03150547f, -0.10579485f, -0.08051834f, 0.06264150f, 
    0.07710676f, 0.07518534f, -0.05076763f, -0.00590140f, -0.00814208f, 0.19631132f, 0.10756471f, 0.11221344f, 
    -0.11120863f, -0.10953940f, 0.14794399f, 0.15620795f, 0.05409920f, 0.03965280f, -0.02438089f, -0.00893345f, 
    -0.00472135f, 0.07179592f, 0.10669088f, 0.15141577f, -0.03340601f, -0.03179529f, -0.05833421f, 0.09806324f, 
    0.00201349f, -0.04375797f, -0.02771417f, 0.01047639f, -0.10008826f, 0.03929921f, -0.09239818f, 0.08483054f, 
    0.07690845f, -0.01022052f, -0.18938427f, -0.08092088f, 0.00907084f, -0.06643314f, 0.00459865f, -0.00917977f, 
    0.16105326f, 0.35597393f, -0.06121122f, 0.02018661f, 0.14642391f, 0.13983692f, 0.03237528f, 0.04416859f, 
    -0.00318422f, 0.00176200f, 0.05479029f, -0.14004679f, 0.07139203f, 0.06007033f, 0.05330924f, -0.00091288f, 
    0.07173347f, 0.10707517f, 0.02043118f, 0.03996477f, -0.18364051f, -0.08431718f, -0.09165911f, -0.06204601f, 
    0.19996940f, 0.20987812f, 0.22315492f, -0.07323710f, 0.09746428f, 0.01198127f, 0.00351685f, -0.01510212f, 
    0.06547835f, -0.08402245f, 0.08747820f, -0.16207801f, 0.02701895f, 0.06306595f, -0.43240273f, 0.08904236f, 
    0.11850419f, 0.02714481f, -0.04758331f, -0.29865709f, -0.04138723f, -0.00169421f, -0.01848886f, 0.01702971f, 
    0.06569988f, 0.15123360f, -0.03629826f, 0.00481933f, -0.01733546f, -0.07462328f, 0.03087180f, 0.01574471f, 
    0.17908517f, 0.03169542f, -0.00166415f, 0.20281896f, -0.22863683f, -0.03173820f, 0.10255699f, 0.00109674f, 
    0.03018572f, -0.08431021f, 0.07908356f, -0.14961059f, -0.00946533f, -0.07843879f, -0.00666887f, -0.15455487f, 
    -0.33142135f, -0.33413193f, 0.01096500f, -0.18872403f, 0.05273074f, 0.03478714f, -0.02373983f, -0.03350078f, 
    -0.12615329f, -0.03660358f, 0.01287393f, 0.08366810f, -0.14357357f, -0.01996783f, 0.01747557f, 0.07222240f, 
    0.00125127f, 0.04015692f, 0.00167087f, 0.01124691f, 0.02123628f, -0.00445410f, 0.06244752f, 0.08579986f, 
    -0.00482353f, 0.03584500f, 0.13089015f, 0.11518688f, -0.07079183f, -0.07251709f, -0.19630735f, -0.07818554f, 
    -0.00363203f, 0.04761229f, -0.06157536f, 0.01356352f, -0.14761664f, 0.06621604f, -0.23442686f, 0.02880309f, 
    -0.22328104f, -0.13766988f, -0.08793513f, -0.18118559f, -0.03760935f, -0.04871341f, -0.07044711f, -0.18827976f, 
    -0.11341983f, 0.10701865f, 0.05106618f, 0.04407435f, -0.09617636f, 0.00014085f, -0.08093442f, -0.06439482f, 
    -0.01348616f, 0.02268351f, -0.12817928f, 0.02724527f, 0.20039509f, -0.45507783f, -0.17405498f, -0.36838529f, 
    0.05624561f, 0.01807596f, 0.06467984f, 0.13226493f, 0.04257435f, 0.06108118f, -0.15874878f, -0.02908004f, 
    0.01525425f, 0.16597533f, 0.03664612f, 0.18791430f, 0.04002909f, 0.10396367f, -0.00303340f, 0.01580858f, 
    0.00412203f, -0.15446493f, -0.10055732f, -0.15666261f, -0.38744682f, 0.04187114f, 0.24122974f, 0.02717094f, 
    -0.14435254f, -0.04262874f, -0.11709813f, 0.05191160f, 0.06996000f, 0.02667031f, -0.02983897f, 0.00751673f, 
    -0.37742364f, -0.26501137f, -0.70106423f, -0.34411058f, 0.04852878f, 0.00656779f, 0.07787216f, 0.01459085f, 
    -0.00196569f, -0.04271381f, 0.08330913f, -0.17912397f, -0.03859049f, -0.15007263f, -0.04023012f, 0.00098941f, 
    0.07610520f, -0.00798140f, 0.00769563f, 0.05373118f, -0.08434402f, 0.03939686f, -0.01824891f, 0.02506180f, 
    0.04495954f, -0.05453822f, -0.07932449f, 0.05956426f, 0.09828538f, -0.07776113f, 0.04927614f, -0.07133649f, 
    -0.01289941f, 0.04134695f, -0.03253618f, -0.05203237f, -0.00696552f, -0.05382039f, 0.11553947f, 0.14114985f, 
    0.00720086f, -0.05910928f, -0.02457531f, -0.03911394f, 0.02743718f, 0.19790107f, 0.03052535f, 0.00903524f, 
    -0.03314475f, -0.16246109f, 0.59426922f, -0.18137974f, 0.14689735f, -0.13571207f, -0.09792430f, 0.08647369f, 
    0.16738334f, -0.02630919f, 0.04978347f, -0.00205152f, 0.10946371f, 0.19166054f, 0.30088109f, -0.10756000f, 
    0.13620767f, -0.03876342f, -0.01504199f, 0.13883297f, 0.07785913f, -0.03883539f, 0.00620907f, 0.14387272f, 
    0.10440192f, -0.03079131f, -0.03429051f, 0.00174743f, 0.00490862f, 0.00395893f, -0.05047865f, 0.03324841f, 
    0.06818490f, -0.19016527f, -0.03269612f, -0.15372278f, 0.10080083f, -0.38307443f, 0.02252896f, 0.19292517f, 
    0.11249128f, 0.00235254f, 0.04246821f, 0.03097186f, 0.02709588f, -0.04473805f, -0.04559303f, 0.10906176f, 
    0.03822776f, -0.00153022f, 0.12289340f, -0.00741770f, 0.05362375f, 0.07013244f, 0.07125930f, 0.06803977f, 
    0.03508712f, 0.02726188f, 0.10453703f, 0.16571073f, 0.00801071f, -0.02153612f, 0.03514798f, 0.15471482f, 
    -0.21277153f, 0.02115717f, 0.08201008f, 0.05351634f, -0.01135479f, -0.04463854f, 0.23099723f, -0.00609469f, 
    -0.06090334f, -0.15391690f, 0.04132807f, -0.12452810f, 0.16749628f, 0.09554464f, 0.11457642f, -0.07116355f, 
    0.04749266f, 0.02158289f, 0.09120156f, -0.04145152f, 0.18049265f, -0.25387001f, -0.12387183f, -0.17197265f, 
    0.03556443f, 0.06133904f, 0.04872810f, 0.04956545f, 0.05535752f, 0.07708883f, 0.04097657f, -0.22836003f, 
    -0.12815088f, 0.22509314f, -0.41319522f, -0.23067212f, -0.00581409f, 0.11775217f, -0.14200071f, -0.08503388f, 
    0.00244275f, -0.42484650f, -0.08658171f, 0.01608514f, 0.05200563f, 0.03671172f, -0.07757893f, 0.23103555f, 
    0.13725229f, -0.06611585f, 0.01570089f, -0.15197209f, 0.12676305f, 0.01075979f, 0.19283226f, 0.31260774f, 
    -0.12972549f, -0.21322879f, -0.04188098f, 0.01807215f, -0.09622366f, -0.06092067f, 0.07208771f, -0.02296665f, 
    -0.09998985f, 0.11921070f, -0.04287508f, -0.13848433f, -0.33591720f, 0.00238480f, -0.11928142f, 0.13992360f, 
    0.20028134f, 0.08755855f, 0.11474281f, 0.10213186f, 0.01564381f, 0.07184764f, 0.02406367f, 0.05006599f, 
    -0.03366603f, -0.14436100f, -0.20070419f, 0.44905141f, 0.07962437f, -0.11740007f, -0.03606379f, -0.00463206f, 
    0.11376096f, 0.14415658f, -0.13308468f, -0.07763272f, 0.23688751f, -0.32618344f, 0.12764123f, 0.26087451f, 
    -0.09637465f, -0.07625800f, -0.01874979f, -0.06991736f, 0.03105917f, -0.06941915f, 0.09445298f, 0.06406300f, 
    -0.01618816f, -0.24934828f, 0.04193873f, 0.08838791f, 0.02055528f, 0.04132939f, 0.06930504f, 0.01541414f, 
    0.09297235f, -0.37436670f, -0.25551453f, -0.41744828f, -0.18030532f, -0.29074511f, -0.08208195f, 0.45350793f, 
    -0.07400190f, 0.00679570f, 0.07793327f, -0.02058505f, -0.03551577f, 0.00844969f, 0.25916266f, -0.09339850f, 
    -0.03475458f, 0.37582520f, -0.29974613f, -0.34044683f, -0.08250988f, -0.12343939f, 0.07811504f, 0.07257742f, 
    0.06253287f, 0.04020645f, -0.02205788f, 0.04138054f, -0.39016327f, 0.23761871f, -0.20157273f, -0.36475715f, 
    -0.02912187f, 0.02775039f, -0.11188804f, -0.09121436f, 0.26962420f, -0.00367212f, -0.04470285f, 0.03957345f, 
    0.17617993f, -0.22960339f, -0.33774853f, 0.11352380f, 0.14167412f, 0.01193775f, 0.02121719f, 0.14787908f, 
    -0.03130918f, 0.02354399f, 0.08296506f, 0.01145008f, 0.10199894f, 0.03275026f, -0.11188075f, -0.06613462f, 
    0.06237999f, -0.03308627f, -0.00713080f, 0.08376838f, 0.01941183f, 0.24793872f, -0.08633161f, -0.19743055f, 
    -0.11793520f, -0.10086350f, -0.11685736f, -0.05765327f, -0.02693510f, 0.00958003f, -0.04167062f, -0.12421069f, 
    0.05971369f, -0.15837249f, -0.09434945f, -0.10910548f, 0.09732263f, 0.12844574f, 0.23291136f, -0.00364267f, 
    0.07533459f, 0.07197019f, -0.01002524f, -0.03293950f, 0.04457705f, -0.05419677f, -0.04082357f, -0.09077566f, 
    0.33839506f, -0.05246299f, -0.18066154f, -0.10837145f, -0.00515049f, 0.02556221f, -0.02734709f, 0.08407982f, 
    0.09947012f, -0.07690448f, -0.08322877f, -0.06086710f, -0.15187638f, -0.08216099f, 0.00621295f, 0.00477973f, 
    0.04127675f, -0.01718031f, -0.08209325f, -0.00440965f, 0.15865034f, -0.09741777f, 0.11969690f, 0.05240372f, 
    0.03803911f, -0.18994769f, -0.29378176f, 0.22761625f, 0.04838627f, 0.00434929f, -0.01896066f, 0.08850279f, 
    0.01246085f, -0.00395883f, -0.01500066f, -0.00584284f, -0.36876160f, -0.51105654f, -0.35384259f, -0.32520577f, 
    0.03146698f, -0.02757111f, -0.13416067f, -0.00657475f, 0.05173513f, 0.15606591f, 0.08883306f, -0.06250911f, 
    -0.02727080f, -0.06179925f, -0.08535530f, -0.19096234f, 0.07158891f, 0.00523056f, -0.08014797f, 0.07402461f, 
    0.13299224f, 0.31289530f, 0.09600832f, -0.15244006f, -0.17600647f, 0.08554950f, -0.08304528f, -0.14286031f, 
    -0.08128340f, 0.02840602f, -0.15024652f, -0.01485788f, 0.05428585f, -0.02419873f, 0.05769683f, -0.15475914f, 
    -0.18642576f, 0.36591953f, -0.29698542f, -0.12333637f, -0.07778251f, -0.06954113f, -0.04402613f, 0.16735767f, 
    0.05203775f, -0.07489190f, 0.07793408f, 0.11838000f, -0.46033543f, 0.17350094f, -0.24063316f, 0.32294720f, 
    0.23688157f, -0.07443996f, 0.02987365f, -0.07805285f, -0.03338997f, 0.03928494f, -0.00059924f, 0.09093562f, 
    -0.21232793f, -0.38604686f, -0.07199217f, 0.07947318f, -0.11955708f, -0.04401559f, -0.03254898f, -0.09909289f, 
    0.22118753f, -0.05484863f, 0.03873723f, 0.22001339f, -0.02861301f, 0.10804666f, 0.07379367f, 0.05816559f, 
    -0.03190444f, -0.00470685f, 0.01712225f, -0.01680519f, -0.00981024f, -0.13120452f, -0.25209853f, -0.09761282f, 
    0.16828023f, -0.12569608f, -0.31481770f, 0.19525042f, 0.00613184f, 0.10736172f, 0.03267675f, 0.06774571f, 
    0.03918517f, -0.05814858f, -0.05722127f, -0.18967603f, 0.02535548f, -0.04703086f, 0.02058057f, -0.03087816f, 
    0.11049683f, 0.21638018f, 0.24849913f, -0.00468229f, 0.04725237f, -0.01003528f, -0.01971890f, 0.00230823f, 
    -0.11232031f, 0.11339257f, 0.21969071f, -0.32993171f, 0.19553012f, 0.10807285f, 0.03501580f, 0.28162181f, 
    -0.05550721f, 0.00126155f, -0.01225211f, 0.04503049f, -0.45683506f, 0.21381003f, -0.08483855f, -0.29613632f, 
    -0.07060181f, -0.13115677f, -0.05347613f, 0.14932953f, 0.08857223f, -0.26962945f, -0.08345049f, -0.12196179f, 
    -0.22608654f, 0.04911817f, -0.05057286f, -0.03550983f, -0.07640083f, -0.12025481f, -0.19955644f, -0.02462294f, 
    0.19478983f, -0.09095274f, -0.04387293f, 0.15446690f, -0.10589860f, -0.12557772f, -0.09508055f, 0.01157002f, 
    -0.18639162f, 0.00425535f, 0.00079976f, -0.05008957f, 0.12252034f, 0.03388852f, 0.11246069f, 0.05156933f, 
    -0.15652245f, -0.08368591f, 0.18287463f, -0.09955020f, 0.03164035f, 0.04161813f, 0.02986291f, -0.02627574f, 
    0.07088008f, -0.15652864f, -0.22216763f, -0.18008126f, -0.05541980f, 0.14754155f, 0.03786615f, 0.04371952f, 
    0.06954550f, -0.19935146f, -0.13428076f, 0.03818913f, 0.05913013f, 0.02009469f, -0.06780240f, -0.22170563f, 
    0.01246915f, -0.19709550f, 0.39207861f, -0.02169825f, 0.02013748f, -0.03998810f, 0.05072487f, -0.06628251f, 
    0.14607216f, -0.03071412f, -0.11122698f, 0.03209126f, 0.13295776f, -0.08586760f, -0.22715610f, -0.10294047f, 
    0.01252183f, -0.03145457f, 0.02508831f, 0.03821536f, -0.15305360f, -0.03513059f, -0.04121964f, -0.10923848f, 
    0.11279520f, 0.16330221f, 0.00943228f, -0.10537846f, 0.07597630f, 0.11863354f, -0.07376949f, -0.12207220f, 
    -0.03209298f, -0.02935139f, -0.09676920f, 0.02139448f, 0.11205654f, 0.07475730f, -0.01504114f, -0.01056902f, 
    0.21313082f, 0.33340693f, 0.01171208f, 0.01842919f, -0.01935635f, 0.01423584f, 0.04405727f, 0.02497457f, 
    0.03695723f, 0.14798567f, 0.17396533f, 0.14338742f, 0.04668432f, 0.07243410f, 0.15167737f, -0.00703569f, 
    0.04156561f, 0.05234753f, 0.07908586f, 0.04366358f, 0.03422270f, 0.13923086f, -0.13059144f, -0.12797220f, 
    0.28053254f, -0.03965273f, -0.00757049f, -0.17275764f, 0.06982975f, 0.13997313f, -0.09732039f, 0.00497299f, 
    0.01374259f, 0.20567410f, -0.16659884f, -0.35946587f, 0.16753939f, 0.16646780f, -0.11005887f, 0.01270325f, 
    -0.00463690f, -0.04654052f, 0.07126664f, -0.02900853f, -0.04876108f, -0.13262926f, -0.17686525f, -0.05184173f, 
    0.03897407f, -0.10495406f, 0.01153621f, -0.01366488f, 0.08166448f, -0.03658796f, 0.04496360f, 0.14482114f, 
    0.09160761f, 0.07044367f, -0.15698688f, -0.10817344f, 0.02453426f, 0.25175112f, 0.11900949f, -0.08504400f, 
    0.04713576f, -0.15850121f, 0.10721769f, -0.11146684f, 0.03885399f, 0.17981534f, 0.09287253f, -0.07498718f, 
    -0.07497904f, -0.12833615f, 0.18632109f, 0.15297958f, 0.02237709f, 0.06358084f, 0.03830948f, -0.06480743f, 
    -0.66110778f, 0.01206679f, -0.07962149f, 0.00654318f, 0.02425850f, 0.01772813f, 0.00548884f, 0.00418206f, 
    0.06978834f, 0.00722717f, 0.01970701f, -0.25972211f, 0.15310679f, -0.06654841f, -0.18344788f, 0.07273322f, 
    0.02934968f, -0.05592494f, -0.01608691f, 0.04043569f, -0.09097018f, -0.04938478f, 0.07938655f, 0.19367647f, 
    0.09330460f, 0.11229330f, -0.17808561f, -0.38717782f, -0.10636977f, -0.08746321f, -0.00424766f, -0.01611973f, 
    -0.24103720f, 0.01092536f, -0.33231658f, -0.15510203f, -0.19301647f, -0.08883595f, 0.11079904f, -0.01390254f, 
    -0.12435340f, -0.14815992f, 0.06944177f, -0.07466593f, -0.05292187f, -0.06533451f, 0.00529579f, -0.17419092f, 
    0.01036329f, -0.09568201f, -0.04234752f, -0.17282045f, 0.10419979f, -0.09780079f, 0.10635649f, 0.34167150f, 
    -0.06010321f, -0.04516037f, 0.14182530f, 0.07853295f, -0.28922737f, -0.19958036f, 0.30701795f, -0.06521438f, 
    0.10624629f, 0.05610821f, 0.04737592f, 0.05308644f, 0.00413888f, 0.18566488f, -0.04864439f, 0.03739506f, 
    0.21520923f, -0.03473388f, 0.22820006f, 0.21935847f, 0.10024110f, 0.08640966f, 0.09169404f, 0.15512858f, 
    0.01771815f, -0.09083223f, 0.00431418f, 0.13973132f, 0.05527993f, 0.01115053f, -0.02308338f, 0.03379246f, 
    0.04198039f, 0.03999402f, -0.06998034f, -0.02882670f, 0.10066028f, -0.05303521f, 0.00516233f, -0.10175378f, 
    0.00768561f, 0.23374094f, -0.01048263f, -0.20372178f, 0.06572502f, 0.00472213f, -0.02031223f, 0.06642672f, 
    0.04642734f, 0.12332769f, -0.05475456f, 0.14484884f, -0.23727541f, -0.09110227f, -0.08860552f, -0.43827575f, 
    0.19037683f, -0.06300300f, 0.02270769f, -0.19204226f, 0.02954265f, -0.03238722f, 0.01844219f, 0.02366543f, 
    -0.33857477f, -0.12381983f, -0.53785163f, -0.14658344f, 0.03226978f, 0.03898416f, 0.01120081f, -0.02452744f, 
    0.13954771f, -0.16447325f, 0.07980784f, 0.03211397f, -0.00767502f, -0.04236509f, -0.00134009f, 0.07072581f, 
    0.01913196f, -0.02616013f, -0.00892331f, -0.03259904f, 0.01162839f, -0.15655097f, -0.13623604f, 0.01120280f, 
    -0.04291369f, 0.06445199f, -0.34499970f, 0.13629049f, 0.08717789f, -0.16239879f, 0.11334980f, 0.17977580f, 
    -0.05225261f, 0.00277526f, -0.12785098f, 0.36574322f, 0.17884195f, 0.02811833f, 0.02123629f, -0.10128082f, 
    0.00018100f, -0.01420861f, -0.10437735f, 0.01809718f, -0.08270191f, -0.01317305f, 0.02111474f, -0.09252676f, 
    -0.23994415f, -0.51695615f, -0.07557552f, 0.09236658f, -0.06362912f, 0.15575550f, -0.00349686f, 0.08017675f, 
    0.07774965f, 0.04698824f, 0.02313446f, 0.00460782f, -0.20693380f, -0.54856843f, -0.49084762f, 0.07985851f, 
    -0.08891626f, -0.15104012f, 0.12207708f, 0.02178381f, -0.03623511f, 0.05230997f, 0.02693074f, 0.02444527f, 
    0.22703460f, 0.05404431f, -0.11192739f, -0.09320318f, -0.01206332f, 0.03770416f, -0.02453322f, 0.13649525f, 
    -0.02808309f, 0.14807585f, -0.01811617f, -0.07448576f, -0.16957223f, 0.06069363f, -0.11537631f, 0.08364382f, 
    -0.06101119f, -0.13884717f, 0.08315572f, 0.11149721f, -0.01287730f, 0.06799286f, 0.06761786f, 0.07182002f, 
    -0.34064606f, -0.38061854f, -0.28446412f, -0.08705247f, -0.02933474f, -0.37786588f, -0.08900727f, -0.20436817f, 
    -0.03369632f, -0.03131515f, -0.03374717f, -0.06115386f, 0.16512108f, -0.05051143f, -0.07933722f, 0.08462955f, 
    -0.15514667f, -0.10801604f, -0.02899586f, 0.14963129f, -0.04715380f, 0.01941069f, 0.03905990f, -0.15506886f, 
    -0.16555861f, -0.02503862f, 0.11007901f, 0.22477949f, -0.01002993f, -0.16385813f, -0.04739849f, -0.08848618f, 
    -0.06041126f, 0.00222181f, -0.03904305f, -0.13324673f, 0.44532698f, 0.45322329f, -0.10628258f, 0.13208793f, 
    0.02407540f, -0.03524259f, -0.00863771f, 0.05946525f, 0.12497442f, 0.11169106f, 0.12719986f, 0.02612854f, 
    0.13922958f, 0.17177263f, 0.13151038f, -0.19096011f, -0.01129368f, -0.15372284f, 0.16442338f, 0.00761288f, 
    0.02955881f, 0.11869656f, -0.20205253f, 0.12570752f, 0.20640017f, 0.02043421f, 0.13673785f, 0.04533600f, 
    0.14453040f, 0.03338924f, 0.09837727f, -0.15238255f, -0.04358352f, -0.06395908f, 0.11212771f, -0.06296246f, 
    0.07280720f, -0.17997420f, -0.05615780f, -0.02326918f, 0.01854951f, 0.07661480f, 0.06216148f, -0.02694024f, 
    -0.07943030f, -0.06359630f, -0.03745527f, 0.00126932f, 0.07915232f, -0.13137333f, -0.15145680f, -0.09211348f, 
    -0.01339820f, -0.08770571f, 0.12058094f, -0.02928176f, -0.05583377f, -0.05332125f, -0.07551007f, -0.07978342f, 
    -0.21327773f, -0.14517984f, 0.20730320f, -0.06783299f, -0.05516226f, 0.06008247f, -0.09287564f, -0.05939293f, 
    -0.20156632f, -0.03738739f, -0.04445254f, 0.11124427f, 0.01422577f, 0.00899070f, -0.11849432f, 0.17124981f, 
    0.00390155f, -0.00808345f, -0.16923426f, 0.14313161f, -0.03602978f, 0.01883655f, 0.16543911f, 0.07476102f, 
    0.11104515f, 0.05174043f, -0.05459105f, -0.11361112f, -0.05566991f, 0.02809062f, 0.04269533f, 0.09316837f, 
    0.02656494f, 0.15091953f, 0.12181571f, 0.19752994f, -0.27317107f, -0.05051460f, 0.22372627f, 0.60789353f, 
    0.07643794f, 0.12121392f, -0.07870319f, 0.00392021f, 0.00463378f, 0.03218999f, 0.10550501f, 0.11272632f, 
    -0.27381030f, -0.55864233f, -0.09180381f, 0.47233963f, 0.27281606f, 0.00215807f, -0.09554379f, -0.32292575f, 
    -0.07100024f, -0.02720831f, -0.02682742f, 0.09041911f, 0.00215612f, 0.20676997f, 0.42400044f, 0.15696359f, 
    -0.02976044f, -0.20301957f, 0.06693176f, 0.02283195f, 0.04628655f, 0.04474644f, -0.03727146f, -0.04597840f, 
    0.24386598f, -0.05129787f, -0.07264559f, -0.10847631f, 0.01394960f, -0.01805499f, 0.10226729f, -0.09323599f, 
    0.06598093f, 0.07701183f, 0.03696480f, -0.09818507f, 0.10681316f, 0.17886969f, 0.03552285f, -0.66831434f, 
    -0.00720466f, 0.00771810f, 0.02459247f, -0.00649064f, -0.01550913f, 0.10495477f, 0.28405634f, 0.12323973f, 
    -0.72721976f, -0.62785751f, -0.41485620f, -0.06168033f, -0.28839186f, -0.01663774f, -0.09508695f, -0.02806829f, 
    0.01937247f, -0.02511388f, 0.06396233f, -0.06782314f, -0.55832458f, 0.48690858f, 0.26822501f, -0.20242119f, 
    -0.09991373f, 0.01761759f, -0.14129606f, -0.00907731f, -0.04076166f, -0.00081264f, 0.01862174f, 0.04764375f, 
    0.04665491f, 0.02897916f, -0.06840924f, -0.11654834f, 0.00902778f, 0.02007638f, 0.00067798f, -0.03137862f, 
    0.04335165f, 0.03345543f, -0.03668500f, -0.02534712f, 0.08258860f, 0.04537506f, 0.00745209f, 0.04245093f, 
    0.00960452f, 0.05552473f, 0.00014501f, 0.12480395f, -0.00736776f, -0.01135972f, 0.04739617f, -0.06562002f, 
    -0.02273322f, -0.28282225f, -0.34436181f, -0.08879232f, -0.03437665f, 0.10977111f, 0.21947652f, -0.04025311f, 
    -0.04758402f, -0.01354892f, -0.08448831f, 0.06149586f, -0.18260469f, 0.25447738f, 0.38343397f, 0.11962184f, 
    -0.03960110f, -0.03963681f, -0.13477105f, 0.05408739f, -0.02123864f, 0.02237253f, -0.08304226f, 0.19498888f, 
    0.05556044f, -0.01856942f, 0.03724900f, -0.00068129f, 0.15521698f, 0.09532055f, -0.00533961f, -0.14285009f, 
    0.06335200f, 0.02440851f, 0.06288929f, -0.10385942f, 0.08240632f, -0.23404700f, 0.03254531f, 0.02788817f, 
    0.15362951f, 0.16485135f, 0.23060320f, -0.10384008f, 0.04213038f, -0.08069940f, 0.06400427f, 0.05191888f, 
    -0.53077650f, -0.41529018f, -0.09144582f, -0.26108649f, -0.05567755f, -0.00875727f, -0.04195296f, -0.14649497f, 
    0.01448457f, -0.00663513f, 0.03979873f, -0.06933768f, 0.04372264f, -0.13081840f, -0.17863017f, -0.40262288f, 
    0.03704149f, 0.13541204f, 0.07642002f, -0.13008176f, -0.08749095f, 0.04068853f, -0.02562601f, -0.03356578f, 
    0.18502675f, -0.01623686f, 0.08014169f, 0.10426512f, 0.03518894f, 0.04863432f, -0.05180965f, -0.10754456f, 
    -0.04884707f, -0.04829354f, 0.11804840f, 0.04324618f, 0.03719627f, -0.24938241f, -0.09438012f, -0.23155017f, 
    -0.04991519f, 0.04663978f, 0.18581654f, -0.02642320f, 0.14015433f, 0.04605476f, -0.01520932f, -0.00391533f, 
    0.37511754f, -0.15204154f, -0.03023669f, -0.18186487f, 0.03301763f, -0.02401410f, 0.13232377f, -0.03573570f, 
    -0.00189577f, -0.04938811f, -0.00344891f, 0.08789098f, -0.56337643f, -0.31681401f, 0.06238377f, -0.25784853f, 
    -0.22471645f, -0.27009103f, -0.18181321f, -0.37871119f, -0.04527431f, -0.01247014f, -0.03771631f, 0.00101071f, 
    -0.29739827f, 0.08685590f, 0.34566373f, 0.05928383f, -0.15754895f, -0.06763498f, -0.04563922f, 0.07906662f, 
    0.09303430f, 0.05204341f, 0.05781858f, -0.12743595f, 0.13225557f, -0.24175267f, -0.22282021f, 0.20712006f, 
    -0.17401236f, 0.03796865f, 0.19373567f, 0.17000352f, -0.02324639f, -0.07455012f, 0.15015191f, 0.00967472f, 
    -0.09067226f, -0.14849903f, 0.26635107f, -0.17494430f, 0.04897434f, -0.13898581f, -0.03105780f, -0.13265304f, 
    -0.17380331f, 0.22039881f, -0.12635483f, -0.09990289f, -0.15576501f, -0.01426227f, 0.03911575f, 0.01937636f, 
    -0.17824307f, -0.08104927f, -0.10168270f, 0.12032084f, -0.00852297f, -0.04422896f, 0.00899787f, -0.08417429f, 
    -0.01038854f, -0.04131957f, -0.02812770f, 0.00526774f, -0.01057660f, 0.01428754f, 0.01216079f, 0.05506819f, 
    0.18938960f, 0.17420323f, 0.16328701f, 0.06668269f, -0.13590215f, -0.46581370f, -0.27038851f, -0.02587512f, 
    -0.11613802f, 0.06680080f, 0.03630638f, -0.06279598f, 0.05946096f, 0.00830777f, 0.07134149f, 0.06334068f, 
    -0.05292195f, -0.20395479f, -0.15957132f, 0.10745431f, 0.04729733f, 0.11232071f, 0.03655381f, 0.09546318f, 
    0.06924257f, 0.06265117f, 0.07389432f, 0.12306950f, 0.35792631f, 0.31374741f, 0.03012757f, 0.01883335f, 
    -0.06535669f, 0.00518512f, -0.02434881f, 0.05826527f, -0.01098455f, 0.06282129f, 0.11271159f, 0.03085940f, 
    -0.71856838f, -0.19965138f, 0.17004618f, -0.03358731f, -0.08098793f, -0.25436255f, -0.37603536f, -0.21631576f, 
    -0.15375577f, -0.05880379f, -0.01603956f, 0.03826106f, -0.26744619f, -0.43478081f, -0.40179047f, -0.31986168f, 
    -0.15282869f, -0.14868233f, 0.01664980f, -0.18355757f, -0.01217127f, -0.00507134f, -0.05624210f, -0.07650393f, 
    -0.28962529f, -0.55004966f, -0.23196590f, -0.24870731f, -0.24637616f, -0.12196527f, -0.15360957f, -0.15930900f, 
    -0.01333260f, -0.02247081f, -0.01017835f, -0.05006889f, -0.07128538f, 0.04403793f, 0.20461701f, -0.18320334f, 
    0.04196046f, -0.17063452f, -0.01789446f, 0.08124620f, 0.03114340f, 0.00391302f, -0.03758102f, -0.08718983f, 
    -0.08719782f, -0.37387899f, 0.15122411f, -0.10986537f, 0.04069136f, -0.00088389f, -0.00440812f, -0.24855952f, 
    0.03628579f, -0.07056738f, -0.01908969f, 0.07156547f, 0.01011597f, 0.01372664f, 0.10120366f, 0.03406887f, 
    -0.02358032f, -0.06519885f, 0.03770850f, -0.05935710f, -0.08322181f, -0.11473257f, -0.17286247f, -0.17695726f, 
    0.06096421f, 0.09935695f, 0.09140008f, -0.31035870f, 0.09082875f, 0.14770229f, 0.15732113f, -0.35190129f, 
    0.13294055f, 0.00495774f, 0.03491347f, 0.05932340f, -0.11252721f, -0.22277878f, -0.39314899f, 0.05262736f, 
    0.01392333f, 0.08669519f, 0.08077782f, -0.08839296f, -0.01381098f, -0.01911513f, 0.06356822f, -0.01791645f, 
    -0.31212062f, 0.06511817f, 0.10478980f, 0.00278522f, -0.02112044f, 0.04316035f, -0.04343099f, 0.03082760f, 
    0.07119618f, 0.03895213f, 0.13839377f, 0.11850031f, -0.06433371f, -0.09352145f, 0.08375625f, -0.37026492f, 
    0.02115341f, -0.04080396f, 0.04417152f, -0.11271809f, 0.00658287f, 0.06727023f, -0.01702409f, 0.02569588f, 
    -0.08005682f, 0.13780132f, 0.07593457f, -0.09282518f, 0.01324252f, 0.01123504f, 0.03078613f, -0.09547225f, 
    0.03251933f, 0.13156128f, 0.16617723f, 0.02564271f, -0.19063663f, -0.60240620f, -0.44271517f, -0.07468506f, 
    -0.20094958f, 0.07199760f, -0.03031854f, 0.00994614f, -0.03372208f, 0.03852336f, 0.03524894f, -0.05549063f, 
    0.19180721f, 0.20198841f, -0.12989289f, -0.03580114f, -0.07353512f, -0.02938606f, 0.10382041f, 0.29719204f, 
    0.10697222f, 0.00695367f, -0.04590255f, 0.01505238f, -0.04670121f, -0.20884016f, -0.05797985f, 0.25864643f, 
    -0.00561975f, 0.13399026f, -0.06472132f, 0.07667188f, 0.02089201f, 0.01043212f, 0.06027762f, 0.04327943f, 
    -0.21662131f, -0.58126473f, -0.56194407f, 0.11671769f, -0.20951703f, -0.06845922f, 0.13248821f, -0.04148012f, 
    0.04692622f, -0.00998814f, 0.03282398f, -0.02391671f, -0.08283509f, -0.13499011f, -0.18079875f, -0.03656789f, 
    -0.00013816f, -0.03226035f, 0.05311307f, 0.08093987f, 0.03729609f, 0.13729163f, -0.05411954f, -0.11169095f, 
    -0.07422835f, -0.44614577f, -0.42807356f, -0.39138064f, 0.00604636f, -0.08070963f, 0.07497522f, 0.06343460f, 
    -0.01668870f, 0.07117123f, 0.03978528f, -0.00552734f, -0.30669841f, -0.00991593f, 0.37100509f, 0.05279520f, 
    -0.01920716f, -0.02894551f, -0.13564311f, 0.20672148f, 0.04514508f, 0.05960166f, 0.01641809f, -0.04033383f, 
    -0.11295121f, -0.02945339f, 0.14573961f, -0.27726349f, 0.09557610f, -0.01794255f, 0.02255070f, 0.02024893f, 
    -0.03237404f, -0.01170731f, 0.02119323f, 0.00269651f, -0.09067149f, 0.03337883f, 0.01222848f, -0.02785605f, 
    0.02381427f, -0.00270873f, 0.02404186f, 0.03112616f, 0.05462082f, 0.02700162f, 0.15740909f, -0.02987599f, 
    0.29971194f, -0.09538256f, -0.10084356f, 0.00092532f, 0.01733145f, -0.04343100f, 0.23755357f, 0.02713571f, 
    -0.01503284f, 0.22210982f, -0.04068333f, -0.05099557f, -0.30430970f, 0.14025891f, 0.23897509f, -0.04501066f, 
    -0.20617752f, 0.06139321f, -0.08419719f, -0.26375443f, -0.02074853f, 0.10465769f, -0.20633237f, 0.07968573f, 
    0.35937873f, 0.01854454f, -0.13989691f, -0.20020643f, 0.05595483f, 0.12972756f, 0.00147705f, -0.06334521f, 
    0.02640140f, 0.01315589f, -0.03177590f, -0.14238553f, 0.09410768f, -0.40991196f, 0.36106047f, -0.02365762f, 
    -0.03504026f, 0.04067036f, -0.01441425f, 0.13478944f, -0.06584195f, -0.11862373f, -0.00558917f, -0.06236029f, 
    -0.05222060f, 0.01567986f, -0.05888317f, 0.09011252f, -0.04373942f, 0.04360478f, -0.02940181f, -0.02124075f, 
    0.07817196f, -0.01524052f, -0.03213779f, -0.08628425f, 0.39096954f, -0.10991600f, -0.28227121f, -0.11822395f, 
    -0.07812336f, 0.06403291f, 0.01161534f, -0.03727960f, -0.04871986f, 0.00356893f, 0.03493986f, -0.14525414f, 
    -0.36022988f, -0.21922520f, -0.22471347f, -0.00889088f, -0.00980931f, -0.02652497f, 0.04264806f, 0.06926040f, 
    0.03490521f, 0.00492222f, -0.02335361f, -0.00059024f, 0.19141711f, -0.08173600f, 0.01304597f, -0.04609176f, 
    -0.03070833f, -0.01265382f, 0.04019641f, -0.08420437f, 0.00854258f, 0.05821263f, -0.01470391f, -0.09688014f, 
    0.15455496f, -0.04786409f, 0.06245982f, -0.21189469f, -0.17200989f, 0.02513377f, -0.04557241f, 0.07092919f, 
    0.04385757f, 0.00014475f, 0.02264439f, -0.08351576f, -0.16136236f, -0.43612817f, -0.27422404f, 0.10363982f, 
    -0.00005431f, -0.00916085f, 0.02328635f, -0.03249989f, -0.05839526f, 0.02272213f, 0.07244402f, 0.02074617f, 
    -0.31556568f, 0.20615062f, 0.05856656f, 0.34950089f, -0.10991448f, 0.14446981f, 0.08766791f, 0.08859485f, 
    -0.14109799f, 0.06740130f, 0.07948754f, 0.00934519f, -0.05202008f, -0.01728369f, 0.06297290f, -0.11576835f, 
    -0.10597496f, 0.02327901f, -0.02033173f, -0.09696931f, -0.11957712f, 0.00129974f, -0.01631734f, -0.01403697f, 
    -0.00319967f, 0.12215237f, 0.07295455f, -0.01493106f, -0.08067781f, 0.04884780f, -0.01844581f, 0.01028826f, 
    0.05064677f, 0.06250240f, 0.04413025f, -0.01107524f, -0.12302116f, 0.12610403f, -0.02883826f, 0.06042606f, 
    -0.13845313f, -0.08380121f, -0.21237902f, 0.00356020f, -0.01178683f, 0.05335569f, 0.00611296f, -0.01796327f, 
    0.15840189f, 0.28474626f, -0.35138640f, -0.10495105f, 0.00525065f, 0.04032551f, -0.04361840f, -0.01298348f, 
    -0.18944372f, 0.14585607f, -0.09617949f, -0.07776618f, 0.25472802f, -0.32070908f, 0.02868373f, -0.17664279f, 
    0.02170799f, -0.06114220f, -0.00389610f, -0.07908414f, -0.00778864f, -0.03121626f, -0.03256292f, -0.33265257f, 
    0.06236656f, 0.02161682f, 0.09214070f, 0.00630707f, -0.03219277f, 0.01090298f, -0.05038316f, -0.07530427f, 
    0.12634477f, 0.03877629f, 0.06217277f, 0.08710805f, 0.20812845f, 0.04228746f, 0.17399152f, -0.08083683f, 
    -0.02815810f, -0.09457773f, -0.08959972f, 0.06381169f, -0.15021567f, 0.13402927f, 0.05401744f, -0.05767683f, 
    -0.18654971f, 0.11318751f, 0.29887399f, 0.02959381f, -0.14510582f, 0.04377804f, -0.06913321f, -0.00972353f, 
    -0.06569567f, 0.03677477f, 0.00570420f, 0.04547537f, 0.02061343f, 0.17339379f, -0.23014152f, -0.06295088f, 
    0.01121846f, 0.05491690f, 0.06432828f, -0.04393043f, -0.13542269f, 0.10880338f, 0.03123147f, 0.03632952f, 
    -0.00163707f, 0.03930910f, 0.00701859f, -0.05015916f, -0.06091008f, 0.05296239f, -0.14017212f, -0.03315899f, 
    -0.02666793f, -0.04716337f, -0.01083449f, 0.01935888f, -0.15555169f, 0.23436038f, -0.29766431f, 0.32949612f, 
    -0.02555795f, 0.04689780f, -0.02058268f, -0.09172810f, -0.12947896f, -0.10633207f, -0.11046426f, -0.00038781f, 
    0.39696831f, -0.47885558f, -0.30614522f, -0.08545540f, -0.06946544f, -0.07758369f, 0.08022411f, 0.10864393f, 
    0.01340559f, 0.02556157f, -0.01000580f, 0.07663552f, 0.02197430f, -0.24282619f, -0.10514760f, -0.14500660f, 
    0.01532395f, -0.01786593f, 0.02095616f, 0.06315002f, 0.08972698f, 0.04138188f, 0.10182516f, 0.00626455f, 
    -0.00618183f, 0.04694751f, 0.07042605f, -0.11664989f, 0.00717208f, -0.03216085f, -0.03352939f, -0.04324809f, 
    0.00441115f, -0.02520869f, 0.03584974f, 0.00699264f, 0.01862371f, 0.01816474f, 0.11327232f, 0.01571451f, 
    0.00607272f, 0.03321758f, -0.03342950f, 0.01655076f, -0.18353337f, 0.00163451f, -0.01805908f, -0.13740531f, 
    -0.05571341f, 0.10896474f, -0.07035135f, 0.00721137f, -0.01142699f, -0.04596623f, -0.07689361f, -0.00596511f, 
    0.01518476f, 0.02857360f, 0.03045935f, -0.00284848f, 0.18158276f, -0.23947889f, -0.51190519f, -0.18447404f, 
    -0.04404505f, -0.00015100f, 0.03625606f, 0.04510551f, 0.05358590f, 0.01047953f, 0.06027215f, 0.01724528f, 
    0.00248568f, -0.01368739f, 0.03465723f, -0.06000355f, -0.16672750f, -0.07480404f, -0.11523730f, -0.08906233f, 
    -0.00666792f, 0.02164402f, 0.05243104f, 0.06436867f, -0.12358941f, 0.14967601f, -0.08670578f, 0.06503962f, 
    0.01936118f, -0.07627030f, 0.04539121f, 0.11176083f, 0.05480135f, -0.06113952f, 0.04354149f, -0.08284006f, 
    -0.16938229f, -0.07772762f, -0.43195540f, -0.21140280f, 0.05219001f, -0.09497595f, 0.05797189f, 0.04119567f, 
    0.07677887f, 0.03496894f, -0.07698842f, 0.00348604f, -0.18747702f, 0.13995437f, -0.02344770f, 0.07998621f, 
    -0.17633465f, 0.07360610f, -0.07195787f, -0.03505594f, -0.01999644f, 0.06048663f, 0.01609422f, 0.02144361f, 
    -0.16830333f, -0.05244914f, 0.15890591f, -0.07482959f, -0.00299106f, 0.00477194f, 0.03157130f, -0.03823776f, 
    0.10680618f, 0.02891526f, -0.03453923f, -0.20891349f, 0.01407838f, 0.04197355f, -0.00242355f, 0.13668469f, 
    -0.01924328f, -0.04810339f, 0.03188780f, 0.04832562f, 0.20961905f, -0.01126884f, 0.05494788f, -0.04815263f, 
    -0.20538455f, 0.24517673f, -0.00542395f, -0.14504208f, -0.07546764f, -0.03846940f, -0.00752941f, 0.06925976f, 
    0.07360972f, 0.06388115f, 0.03232425f, 0.00311548f, -0.27484736f, -0.28332922f, -0.24276707f, -0.11661065f, 
    0.06111926f, -0.11979683f, -0.08281449f, 0.01995700f, 0.05051782f, 0.01597361f, 0.03840987f, 0.01660662f, 
    0.14047348f, -0.11982988f, 0.23475924f, -0.12008218f, -0.01400112f, -0.14055544f, 0.11894193f, 0.02151493f, 
    0.03827434f, -0.05986538f, -0.02330117f, -0.01147911f, -0.23142746f, -0.22843570f, -0.36945087f, 0.09697886f, 
    0.05019927f, 0.03554439f, 0.11194925f, -0.04435725f, 0.01947730f, 0.00757554f, -0.03535916f, 0.08024880f, 
    0.07782637f, 0.09811500f, 0.02652374f, -0.05244333f, -0.06930335f, 0.11396087f, -0.05486047f, 0.08779987f, 
    0.01035587f, 0.05822190f, -0.02672013f, 0.05089017f, 0.22504206f, -0.04604538f, -0.10687622f, -0.00134589f, 
    -0.08994869f, -0.07073775f, 0.16067769f, 0.04936891f, 0.00471337f, 0.06962215f, 0.04296442f, -0.06617391f, 
    0.20531376f, -0.07126546f, 0.01174119f, -0.10254609f, -0.01535003f, -0.06307140f, -0.00153743f, -0.04574610f, 
    0.09441379f, 0.11980894f, 0.07826968f, -0.01769953f, -0.29903829f, -0.29029408f, -0.32080826f, -0.18560494f, 
    0.08451549f, 0.03033700f, 0.09999418f, 0.02045230f, -0.03202672f, -0.02687898f, -0.07364839f, 0.04708048f, 
    0.29724804f, -0.44940686f, -0.10114660f, 0.02094871f, -0.02484409f, 0.03214573f, -0.03040339f, -0.12045359f, 
    -0.03961975f, 0.02084343f, 0.02485028f, -0.11975323f, -0.34120965f, -0.27796981f, -0.17600074f, -0.04273607f, 
    -0.06732019f, 0.04721589f, -0.01295209f, -0.01993290f, -0.01800936f, 0.01775752f, 0.08041730f, -0.03276573f, 
    -0.24430047f, -0.21712643f, 0.22963114f, 0.07862762f, 0.13452162f, -0.07117545f, -0.07140504f, 0.00459394f, 
    0.00904552f, 0.01485579f, 0.01198602f, 0.02584049f, -0.17318620f, -0.17817871f, -0.21220909f, 0.14693458f, 
    0.05918036f, -0.08229873f, -0.04373633f, 0.01202511f, 0.04437761f, -0.01177828f, -0.03994774f, 0.02898751f, 
    -0.21827599f, -0.15086325f, -0.25242567f, 0.35622245f, 0.07117503f, -0.12961647f, -0.07653973f, 0.05222024f, 
    -0.01640941f, -0.01568140f, -0.04373322f, -0.06526156f, -0.54616958f, 0.44456509f, -0.30538911f, 0.39346728f, 
    0.09982993f, -0.18482289f, 0.14851087f, -0.04796576f, 0.00060826f, -0.01796722f, -0.05589548f, 0.04752305f, 
    -0.34864840f, 0.28949395f, 0.07577967f, 0.03741334f, -0.00458993f, -0.18538815f, 0.04511330f, 0.07532274f, 
    -0.00285062f, 0.02550099f, 0.05970089f, -0.03209115f, 0.03261409f, 0.03752048f, -0.00638210f, -0.05968353f, 
    0.03341503f, 0.01566077f, -0.03904591f, -0.04950137f, -0.20243134f, -0.24551685f, -0.26870421f, -0.10459086f, 
    -0.02537663f, 0.11583143f, 0.14404602f, -0.25229937f, -0.10688246f, -0.13585724f, 0.00195795f, -0.02220616f, 
    0.00362408f, -0.02616817f, 0.05462670f, -0.07844151f, 0.21028034f, -0.24698056f, 0.17989931f, 0.10646851f, 
    -0.06869589f, 0.19281341f, -0.08347990f, -0.00678141f, 0.01444200f, -0.06382126f, 0.01345918f, 0.06089061f, 
    0.68286580f, -0.39112362f, -0.30410019f, -0.23179436f, -0.00715320f, -0.02704640f, -0.01580159f, -0.07302914f, 
    0.22439058f, -0.02362586f, -0.03032958f, 0.07572884f, -0.02762937f, 0.15156378f, -0.05305129f, 0.14257832f, 
    0.00438670f, 0.06728104f, -0.01862328f, -0.02253950f, -0.00926540f, -0.00652763f, -0.12728025f, -0.02898948f, 
    -0.13243434f, -0.06148298f, -0.17029546f, 0.30758488f, 0.00297313f, -0.04934717f, 0.09474058f, 0.02152872f, 
    -0.00093335f, 0.08673247f, 0.11178619f, -0.05695457f, -0.04554417f, -0.34619847f, -0.25297272f, -0.13699271f, 
    0.00960160f, 0.07865410f, 0.01470480f, 0.16890495f, 0.05958604f, -0.05375820f, -0.13131709f, 0.12167487f, 
    -0.13099991f, 0.02744202f, -0.00737442f, -0.04575792f, -0.18102586f, -0.07170676f, 0.13120472f, -0.11318435f, 
    0.07500714f, 0.07072575f, -0.04888428f, 0.03786799f, 0.34494847f, -0.18489638f, -0.20240325f, -0.13436300f, 
    -0.07578981f, -0.01115191f, -0.10344263f, -0.05973602f, -0.07094794f, 0.06206875f, -0.01704951f, -0.02268709f, 
    -0.33903140f, -0.30265611f, -0.19900729f, 0.15381086f, 0.02210350f, -0.06544188f, -0.04989716f, -0.03785261f, 
    -0.00253439f, -0.01655631f, -0.02728808f, -0.08320404f, -0.00962407f, -0.05329518f, 0.17232749f, -0.15734059f, 
    0.06810499f, 0.05717981f, 0.05272632f, -0.05406202f, -0.01789846f, -0.13105033f, 0.01829996f, -0.02290313f, 
    -0.34687757f, 0.43179876f, 0.33752647f, 0.37505576f, -0.07819097f, -0.06814814f, -0.07207566f, -0.09088232f, 
    -0.02790610f, -0.11177381f, -0.08227415f, -0.09710208f, 0.08673815f, -0.52448249f, -0.25339818f, -0.12747170f, 
    -0.04661502f, -0.14714979f, 0.06706198f, 0.11466221f, 0.10429839f, 0.03683999f, -0.01429597f, -0.03574646f, 
    -0.07776129f, 0.13363102f, 0.00681764f, 0.11933343f, 0.02279610f, -0.02216036f, 0.01315808f, 0.00555968f, 
    0.04856052f, -0.17632514f, 0.01257960f, -0.15295036f, 0.14905642f, 0.00889431f, 0.06263886f, -0.16106923f, 
    0.03938089f, 0.00690274f, 0.03627569f, -0.01186874f, 0.07010470f, -0.00449945f, -0.06975796f, -0.18398708f, 
    -0.00340678f, 0.03229618f, 0.11078899f, -0.00486085f, -0.05010778f, 0.03333034f, -0.02821493f, 0.01579807f, 
    -0.10786092f, -0.21099328f, -0.08673673f, 0.05934132f, 0.09664986f, -0.31136402f, -0.11325597f, -0.05874570f, 
    0.15691005f, 0.12206028f, 0.04517221f, 0.00679407f, -0.03522724f, 0.02661014f, 0.07295754f, 0.05427015f, 
    0.26794454f, 0.01934736f, 0.01581462f, -0.39117822f, -0.17672986f, -0.23442583f, -0.02306170f, -0.27775192f, 
    -0.14677601f, 0.17223583f, 0.01527622f, 0.14491232f, 0.34960803f, -0.06130701f, -0.39851633f, -0.44187051f, 
    -0.03298085f, -0.11060409f, -0.11431426f, -0.17955953f, 0.05150871f, -0.00816989f, -0.01969613f, 0.02328731f, 
    -0.07677534f, 0.08512978f, -0.11334658f, 0.08399413f, 0.07290883f, 0.00626509f, -0.01269621f, 0.07878049f, 
    -0.17502399f, -0.12313252f, -0.19313402f, -0.23214048f, 0.16847639f, -0.05747969f, -0.53026384f, -0.06381558f, 
    0.31713143f, 0.00825891f, 0.03115789f, 0.06124475f, 0.14056695f, 0.01090048f, 0.04319511f, 0.16621466f, 
    -0.08535454f, -0.19534904f, -0.10330173f, 0.09779274f, 0.06727051f, -0.06833606f, -0.00115233f, 0.03011367f, 
    0.00244531f, -0.00057483f, 0.04956524f, 0.07933929f, 0.06719120f, 0.05367120f, -0.13303988f, -0.10715646f, 
    0.18155719f, -0.01143165f, -0.03565376f, -0.08269222f, -0.02093590f, 0.07891618f, 0.00730481f, 0.24148101f, 
    -0.03525467f, 0.04577582f, -0.11412260f, -0.03921907f, -0.04587631f, -0.13469009f, 0.11974145f, 0.08808251f, 
    0.08444060f, 0.01283080f, 0.08987152f, 0.08689905f, -0.51447940f, -0.01537837f, -0.05335166f, 0.17373356f, 
    0.07858408f, 0.08963741f, -0.02926250f, 0.01014895f, -0.01987114f, 0.08115987f, -0.18538126f, -0.02288372f, 
    -0.66236705f, -0.30873486f, 0.18195938f, 0.46754956f, 0.00768440f, 0.05868294f, -0.00722400f, 0.01107343f, 
    0.07354711f, 0.04050530f, 0.04917432f, 0.25082681f, -0.22977403f, 0.06252560f, -0.06729351f, 0.03402217f, 
    0.17720485f, 0.08353762f, 0.06386750f, 0.14967024f, -0.03839727f, 0.02387485f, 0.02939121f, -0.13592607f, 
    -0.28784814f, -0.01614132f, 0.05799127f, -0.07911780f, -0.02250364f, -0.02879962f, -0.00097715f, -0.08380285f, 
    -0.12865512f, -0.05168747f, -0.02507094f, -0.00553426f, 0.02124120f, 0.04313283f, 0.00569889f, 0.03311655f, 
    0.08463576f, -0.05879011f, -0.03569588f, 0.07314802f, 0.13699687f, 0.05266117f, 0.14533751f, 0.11998796f, 
    0.07766535f, -0.11632604f, -0.25477937f, -0.18276945f, -0.10599571f, -0.04973485f, 0.03844756f, 0.06669331f, 
    0.15248962f, -0.03603853f, 0.17108466f, 0.12545951f, 0.23322846f, 0.18234660f, -0.14494051f, -0.18250553f, 
    0.06835985f, -0.04716554f, 0.08181777f, -0.06000867f, 0.12610115f, -0.04867321f, 0.01853995f, 0.15306562f, 
    -0.05986569f, -0.03462150f, -0.05385489f, -0.04968526f, -0.00216815f, -0.03057513f, 0.00600762f, 0.04271875f, 
    -0.08486862f, -0.02850645f, -0.21249369f, -0.30101833f, 0.07278850f, 0.14347915f, 0.14136383f, 0.31121624f, 
    0.07128333f, 0.15147308f, 0.18732369f, -0.02047448f, 0.02962516f, -0.15491974f, 0.09103408f, -0.12185603f, 
    0.08171032f, 0.07926562f, 0.13649496f, -0.15750402f, 0.09712097f, -0.09536896f, -0.03438381f, 0.02113160f, 
    -0.02384063f, -0.01491899f, -0.03631987f, 0.07216644f, -0.37936327f, -0.16397449f, 0.08849316f, 0.03467768f, 
    0.00422125f, 0.05870677f, 0.10683599f, 0.00090653f, 0.12745735f, -0.04392726f, 0.11675291f, 0.04240050f, 
    -0.15629475f, 0.08012656f, 0.24316144f, 0.16220920f, 0.09190641f, -0.11701429f, -0.09807123f, -0.11987783f, 
    0.05113068f, -0.05956967f, 0.04554964f, -0.05852383f, -0.02561574f, 0.27885661f, -0.25664303f, 0.01744109f, 
    0.08910649f, 0.13450894f, 0.00126199f, 0.15634729f, 0.03533963f, 0.24912232f, 0.11135446f, 0.02874145f, 
    -0.46916845f, -0.40503049f, -0.52784538f, -0.42990920f, 0.02551703f, -0.00524779f, 0.02230974f, -0.06080963f, 
    0.04998631f, -0.06733252f, -0.03940376f, -0.03214126f, 0.22228611f, -0.27720410f, -0.45790467f, -0.16003534f, 
    -0.07662801f, 0.03547708f, -0.01455579f, 0.04739253f, 0.06973904f, -0.07018860f, -0.08866093f, -0.05989168f, 
    -0.25355422f, 0.19954078f, 0.08286335f, 0.05300856f, -0.06018328f, -0.09510864f, -0.08851287f, -0.08522747f, 
    -0.07055984f, 0.01888195f, -0.18668863f, -0.00662903f, -0.00889338f, -0.03577748f, -0.02301763f, -0.11758982f, 
    0.00627686f, -0.03450701f, -0.02305280f, 0.01944035f, -0.03478620f, -0.09206660f, -0.05715448f, -0.14390849f, 
    -0.20902239f, 0.12708415f, 0.08566841f, 0.14179839f, -0.06058224f, -0.02791703f, -0.05054908f, -0.09265453f, 
    -0.02531353f, 0.00202539f, -0.04927761f, 0.02190343f, -0.33565053f, -0.24056649f, 0.13216026f, 0.18555760f, 
    -0.08624224f, 0.18332066f, 0.08777834f, 0.05228469f, 0.05609239f, 0.08368549f, 0.05520940f, 0.03041120f, 
    -0.03206992f, 0.01706144f, 0.00791574f, 0.00257640f, 0.02101330f, 0.01851011f, 0.07571581f, 0.00635446f, 
    0.01456892f, -0.03997705f, 0.03775864f, -0.07921129f, -0.11807965f, -0.05008401f, 0.04579562f, 0.02639303f, 
    0.07465631f, -0.02496267f, -0.09844256f, 0.02751867f, 0.04678503f, -0.00909309f, -0.03957392f, -0.04258958f, 
    -0.03809712f, -0.25327870f, -0.36839694f, -0.09275950f, -0.04924804f, 0.17745310f, -0.00844516f, -0.00278946f, 
    -0.04913093f, 0.00890105f, 0.04528630f, 0.09368055f, -0.07080109f, 0.14496981f, 0.02164111f, 0.08932649f, 
    0.17579636f, -0.06049871f, -0.03119312f, 0.06837829f, 0.00620338f, 0.01020458f, 0.06414741f, -0.01534014f, 
    -0.02658067f, 0.09746817f, 0.01533373f, 0.17060784f, -0.11125946f, 0.05520413f, 0.01482929f, -0.05485076f, 
    -0.00742209f, 0.14001259f, -0.03723716f, -0.04217169f, -0.05501983f, -0.04461172f, -0.03347391f, -0.08199648f, 
    0.06336864f, -0.03955930f, -0.09793733f, 0.04566256f, -0.27736929f, 0.20373182f, -0.11817835f, -0.32839411f, 
    -0.40904352f, 0.00629990f, 0.09707840f, 0.15681992f, -0.06355949f, 0.00561443f, -0.17349021f, -0.01390115f, 
    -0.14254957f, -0.01572092f, -0.06511635f, -0.08743574f, -0.03965876f, -0.45240065f, -0.41067249f, 0.08002356f, 
    0.04495068f, 0.05055602f, 0.01037386f, -0.00144403f, -0.09331658f, 0.06147853f, 0.04277720f, 0.00422134f, 
    0.25248826f, -0.11971287f, -0.25265625f, 0.06586614f, 0.07618244f, 0.18859449f, 0.20997809f, -0.02167062f, 
    -0.03832903f, -0.07587539f, 0.06762750f, -0.07813889f, -0.26259735f, -0.41330820f, 0.05265209f, 0.19490443f, 
    0.07959799f, 0.10794852f, -0.04115750f, 0.06730384f, -0.18427852f, -0.04614016f, 0.08035792f, -0.54668695f, 
    -0.04846825f, -0.02626805f, -0.08497958f, -0.09823976f, -0.11424860f, -0.04301377f, 0.03927157f, 0.14203469f, 
    0.17449071f, 0.11082900f, 0.02996552f, 0.07726941f, -0.09341976f, -0.14198862f, -0.15606290f, -0.12461301f, 
    -0.03710934f, 0.06971485f, 0.10188784f, 0.00977779f, 0.09677515f, 0.06491888f, 0.16102295f, 0.17553405f, 
    -0.00695001f, 0.04580315f, -0.06449571f, -0.12516697f, -0.05414435f, -0.07310590f, -0.03247531f, 0.01128135f, 
    -0.08454756f, 0.05054254f, -0.08902891f, -0.14430925f, 0.26612413f, -0.02716797f, -0.12874007f, 0.02695150f, 
    0.06572515f, -0.06499333f, 0.04309503f, -0.12533672f, 0.07246456f, -0.11356437f, 0.01553261f, -0.16051912f, 
    0.38952467f, 0.12934044f, 0.00465624f, -0.19047357f, 0.14621314f, 0.03384512f, 0.01229563f, -0.00535256f, 
    -0.00962629f, 0.02760097f, 0.00441753f, 0.05258797f, -0.25125352f, -0.16393782f, -0.01688070f, 0.05849093f, 
    0.07417661f, 0.08507902f, -0.03814477f, 0.05810779f, -0.06804281f, -0.04912790f, -0.03348313f, -0.02319909f, 
    -0.10055159f, -0.31041208f, -0.09638128f, -0.17139708f, -0.09736849f, 0.03771272f, 0.08118559f, 0.09147756f, 
    0.04921283f, 0.08311643f, -0.00256742f, 0.03629518f, -0.38469017f, -0.33882791f, -0.02568387f, 0.20544194f, 
    0.06386981f, -0.06507581f, 0.10199287f, -0.04815064f, 0.02961641f, 0.02106863f, 0.03312904f, 0.10479967f, 
    0.12020099f, -0.19816321f, -0.41257712f, -0.31451169f, -0.06834928f, -0.16780259f, -0.07179611f, -0.07274023f, 
    0.03509483f, 0.06973241f, -0.01684889f, 0.05477018f, -0.36244854f, -0.32668224f, 0.05735049f, 0.14393654f, 
    -0.16230692f, 0.15056135f, -0.05983437f, 0.10541285f, -0.12666509f, -0.01462493f, 0.08020217f, 0.09666752f, 
    -0.36912182f, 0.00867533f, 0.10319337f, 0.07506710f, 0.02608129f, 0.03510585f, 0.03797720f, 0.00674418f, 
    0.08689776f, -0.00607221f, -0.01008980f, -0.03135527f, -0.07553073f, -0.12789524f, -0.06503599f, -0.08330201f, 
    -0.08839469f, -0.00682697f, 0.03979037f, -0.01686134f, 0.06801414f, 0.06235648f, 0.06042426f, 0.04047175f, 
    -0.46911713f, -0.08919355f, 0.00843851f, 0.08377682f, 0.08977300f, 0.15547760f, -0.23273824f, -0.01519888f, 
    0.05694563f, 0.06042959f, 0.02428259f, 0.03335322f, -0.14110453f, -0.14003675f, 0.30097339f, 0.32015246f, 
    0.08407118f, -0.05354975f, -0.23394793f, 0.08145622f, -0.08348302f, 0.13964894f, -0.02454567f, 0.00122898f, 
    -0.23727523f, -0.15362993f, -0.03018132f, -0.07390864f, 0.06284104f, 0.13381231f, 0.02398850f, 0.07556671f, 
    -0.05470446f, -0.03536015f, -0.18543164f, -0.29623768f, 0.03644210f, 0.15490998f, -0.00135476f, 0.14344434f, 
    0.07809965f, -0.03670686f, -0.07960442f, 0.02915535f, -0.01835282f, 0.09219139f, 0.20013601f, -0.13944918f, 
    0.11765587f, -0.11958378f, 0.03219741f, 0.02251675f, -0.08553967f, 0.02283188f, -0.03895501f, 0.06151349f, 
    -0.09284806f, -0.09874210f, -0.12507422f, -0.27271795f, -0.04147368f, -0.08810273f, -0.26127195f, -0.08360375f, 
    0.11506919f, -0.02658264f, 0.04221775f, -0.04372617f, -0.06377854f, -0.00296457f, -0.09960996f, -0.16593388f, 
    -0.16007875f, -0.21474837f, -0.19977129f, -0.01604516f, 0.12481989f, 0.07523994f, 0.07947377f, 0.00842594f, 
    -0.13854668f, -0.09584995f, -0.06635395f, -0.08023892f, 0.24915540f, -0.06865991f, 0.05771073f, -0.20579022f, 
    0.19908617f, 0.20997296f, -0.02372435f, 0.20130196f, 0.11655425f, 0.02016320f, 0.07367769f, -0.07916296f, 
    0.23897675f, -0.03023155f, 0.05693796f, -0.11728587f, 0.06263648f, 0.03469897f, 0.09936091f, 0.03743422f, 
    0.01908487f, 0.04328591f, 0.04270456f, 0.05813092f, 0.05276070f, 0.01418730f, 0.01215657f, 0.13689810f, 
    -0.01049452f, -0.03488322f, -0.06742375f, -0.12292223f, 0.11326988f, 0.01418601f, 0.03974220f, 0.01689184f, 
    -0.25406170f, -0.30367547f, -0.19287519f, -0.24442437f, 0.12102868f, 0.11023036f, 0.07374657f, 0.13976990f, 
    0.15913142f, 0.12132777f, 0.11698811f, 0.19307247f, 0.16741459f, -0.27895740f, -0.23470941f, 0.02689755f, 
    -0.05096454f, 0.06108148f, 0.10071756f, 0.03058887f, -0.15538275f, 0.01578339f, -0.08248778f, 0.06357568f, 
    -0.55781436f, -0.07860713f, 0.09935102f, -0.16319084f, -0.07817069f, 0.04713391f, -0.01974897f, 0.00199084f, 
    0.07262544f, 0.04008306f, -0.01299646f, 0.17367959f, -0.05762421f, -0.15162455f, -0.18933894f, -0.34099725f, 
    -0.05157354f, -0.07262448f, -0.04812799f, -0.07351280f, 0.05830020f, -0.01840206f, 0.01300885f, -0.09928686f, 
    -0.30365196f, 0.07232059f, 0.03393973f, 0.08431463f, -0.02234734f, 0.02553569f, -0.11843918f, 0.00601741f, 
    -0.11591369f, 0.09194108f, 0.04980571f, 0.10322537f, 0.07970119f, -0.11301514f, -0.15439855f, 0.05446077f, 
    0.16114642f, 0.03145288f, 0.10157362f, 0.13128483f, -0.16454406f, -0.23669864f, -0.06634331f, -0.11068171f, 
    -0.36013627f, -0.72160983f, -0.04222987f, 0.09348764f, 0.04493308f, 0.22539808f, -0.18022369f, -0.22729880f, 
    -0.19093581f, 0.08523567f, -0.01802868f, -0.12439787f, -0.43266922f, -0.33675072f, 0.02556759f, 0.01048450f, 
    -0.06303515f, -0.04727906f, 0.01946437f, 0.10584071f, 0.03930441f, 0.08532354f, 0.01801077f, 0.04563202f, 
    -0.13078134f, 0.28139061f, 0.23071270f, -0.00323156f, -0.03046797f, -0.09334943f, 0.10399508f, -0.07027785f, 
    0.07557303f, 0.10800339f, 0.00366924f, 0.05539948f, 0.33024025f, 0.31667367f, 0.04760984f, 0.26615617f, 
    0.00218563f, -0.43737495f, -0.05490384f, -0.15914093f, 0.06171535f, -0.04717107f, -0.12353832f, -0.03443855f, 
    0.12277981f, -0.13946521f, -0.20091531f, -0.16498649f, -0.17843762f, -0.11176309f, -0.03938919f, -0.03454753f, 
    0.02556345f, 0.03838238f, -0.00453656f, -0.00268584f, -0.20813677f, 0.14015496f, -0.12776552f, 0.04375161f, 
    0.07132279f, -0.15621632f, 0.10118851f, -0.00674782f, 0.15271917f, -0.11008380f, -0.19618027f, -0.08671160f, 
    0.20668742f, -0.35360560f, 0.31203291f, 0.06404249f, 0.00298782f, 0.00590295f, -0.20358686f, 0.04413773f, 
    0.10923036f, 0.02277694f, 0.01890556f, 0.02659578f, 0.13516341f, 0.11828534f, 0.47785571f, -0.57301939f, 
    0.00413770f, -0.20623024f, 0.00060045f, -0.02292974f, -0.12154891f, 0.07438178f, 0.01920417f, -0.01673375f, 
    -0.04132976f, 0.17032079f, -0.03535467f, -0.48005798f, -0.02100023f, -0.10453597f, 0.01535119f, -0.13690972f, 
    -0.10566461f, -0.00837934f, -0.06985582f, 0.07323094f, -0.02476031f, -0.09376000f, -0.47179550f, -0.41390234f, 
    -0.14684887f, -0.10825124f, 0.10701745f, 0.12266798f, -0.08458352f, -0.00044173f, -0.13946900f, -0.12617251f, 
    -0.09199509f, -0.03816478f, -0.18545040f, -0.23555785f, 0.09476534f, 0.19729127f, 0.23109050f, -0.03443141f, 
    0.02760030f, -0.02210557f, -0.04568603f, 0.03616783f, -0.12799752f, 0.39836562f, -0.09560803f, -0.06667105f, 
    0.05439103f, -0.07310037f, 0.04377212f, 0.15838538f, -0.00638086f, -0.10635991f, -0.05860245f, -0.08568917f, 
    -0.30732322f, 0.12883084f, -0.08338519f, 0.40254259f, 0.01776714f, 0.03342325f, -0.14038929f, 0.05370271f, 
    0.11248466f, -0.20114745f, 0.03689978f, 0.00632853f, -0.03441266f, 0.05486873f, 0.32208359f, 0.15505753f, 
    0.16707475f, -0.12201448f, 0.07280634f, -0.17059098f, 0.14384106f, -0.14193107f, 0.02086959f, 0.08183060f, 
    0.07383460f, 0.01561537f, -0.05049751f, 0.08555188f, 0.08495162f, -0.00624566f, 0.10984035f, -0.05303047f, 
    0.09886462f, 0.13623050f, 0.10574678f, 0.16897696f, 0.00088802f, -0.43427378f, 0.13158894f, -0.84302223f, 
    -0.17500681f, -0.05958179f, -0.09965359f, -0.01459452f, 0.01422047f, -0.15740582f, -0.04497721f, 0.03714873f, 
    -0.34340301f, -0.40324163f, 0.04477268f, -0.42107069f, -0.17552729f, 0.17022912f, -0.05597115f, 0.22895253f, 
    0.07485444f, -0.06895867f, -0.09949370f, -0.00647682f, 0.27629572f, 0.03178109f, 0.09442879f, -0.43990064f, 
    -0.05563021f, 0.00224567f, -0.03354396f, -0.05139347f, -0.17778736f, 0.00058620f, 0.08193395f, -0.05209081f, 
    -0.24441697f, -0.07591427f, -0.45889175f, -0.04894622f, 0.02683976f, 0.01003655f, 0.02896057f, -0.02051685f, 
    0.06706293f, -0.09328542f, -0.04305232f, -0.13702920f, -0.47021958f, 0.16912924f, -0.30221385f, 0.39337534f, 
    0.05335249f, -0.13239826f, -0.01719149f, -0.11804152f, 0.10661894f, 0.02488522f, -0.00316378f, -0.02329577f, 
    -0.02163321f, -0.11855309f, 0.26541069f, 0.32103515f, 0.15725739f, -0.14868636f, -0.02116497f, 0.03776691f, 
    0.00613080f, 0.07896431f, 0.04464632f, 0.01317404f, 0.17119442f, -0.09975372f, 0.17912753f, 0.07815971f, 
    -0.01257266f, -0.11614902f, -0.11158717f, 0.02780536f, -0.06349468f, -0.04552460f, 0.05185952f, 0.03145322f, 
    0.01846094f, -0.31522518f, -0.12868452f, 0.06308398f, 0.02755249f, 0.15780862f, 0.04884829f, -0.00969837f, 
    0.05311625f, -0.00933146f, -0.03499415f, 0.00402866f, 0.01864030f, -0.08813465f, -0.00007637f, 0.07398578f, 
    0.03818485f, 0.02296620f, -0.04594088f, -0.03079333f, 0.02241291f, 0.15008806f, 0.20060179f, -0.06429999f, 
    -0.17396577f, -0.06241639f, -0.36480829f, 0.09619208f, 0.20565538f, 0.07748745f, 0.12788132f, 0.05842576f, 
    0.00978696f, -0.05956531f, -0.09772838f, -0.02433008f, 0.35664386f, 0.14340162f, 0.03626483f, -0.15567474f, 
    0.00751597f, -0.11586110f, -0.10285279f, -0.19775842f, 0.03396189f, -0.09093904f, -0.06388690f, 0.04105011f, 
    0.06269623f, -0.03523173f, 0.03274862f, 0.03209911f, -0.11717179f, 0.16544197f, 0.05949144f, 0.04815613f, 
    0.22501808f, 0.00295205f, -0.13079268f, 0.09391405f, 0.23111480f, 0.02531940f, -0.38192254f, -0.19120929f, 
    0.05636103f, -0.00138213f, 0.05681012f, 0.09061410f, -0.03322193f, -0.08156676f, -0.12744507f, 0.00568324f, 
    0.00285436f, -0.06594904f, -0.20401004f, 0.16330244f, 0.06007567f, -0.01055829f, -0.04144007f, 0.03755843f, 
    0.06824435f, -0.03472083f, -0.01234499f, -0.01105904f, -0.29800382f, 0.28048220f, -0.64661825f, 0.20618236f, 
    -0.04986750f, -0.02363073f, 0.20590971f, 0.05049108f, 0.02557097f, -0.05480102f, -0.08526924f, -0.06618353f, 
    -0.02628449f, -0.25995710f, 0.04666212f, -0.10808551f, 0.02997469f, 0.14873545f, -0.06384914f, 0.04633566f, 
    0.12483670f, -0.06772567f, -0.11060105f, 0.05595639f, 0.14169420f, 0.38889918f, -0.13509417f, -0.02972177f, 
    -0.09018003f, 0.18493380f, 0.16720340f, -0.00401821f, 0.09746744f, 0.06955991f, -0.10935202f, -0.04461683f, 
    0.00351556f, -0.00541274f, -0.05636704f, -0.13474478f, -0.06518450f, 0.11274399f, 0.11254341f, 0.10179781f, 
    0.04264199f, 0.03227921f, -0.01708981f, 0.07705912f, -0.20996489f, -0.04835617f, 0.04162182f, -0.17943791f, 
    0.03276557f, -0.13094583f, 0.04371193f, 0.08739629f, 0.01980030f, -0.02843059f, -0.02023856f, -0.03511447f, 
    -0.26819468f, -0.14090453f, 0.28448468f, -0.29483205f, 0.00399448f, -0.15156494f, -0.12665138f, 0.01146308f, 
    0.02730432f, -0.01148233f, -0.02305901f, 0.09605196f, -0.24846606f, -0.08665457f, -0.05953720f, -0.37786186f, 
    -0.13075370f, -0.09035523f, -0.03874191f, -0.06296364f, 0.11506021f, 0.04505344f, 0.16555813f, 0.14625630f, 
    -0.15455881f, -0.23823571f, -0.10158559f, 0.27424657f, -0.06670004f, 0.31796384f, -0.13531716f, 0.19411013f, 
    0.11011934f, -0.05224916f, -0.03063378f, -0.12035775f, 0.18876198f, 0.07569054f, 0.37092891f, 0.06427299f, 
    0.21358497f, -0.23831424f, -0.03491533f, 0.02982240f, -0.14390939f, -0.07790917f, 0.02936654f, -0.08911868f, 
    0.02689864f, 0.02357635f, 0.17627525f, 0.32511336f, -0.04261005f, 0.09834087f, -0.03284225f, -0.02984514f, 
    0.07292268f, 0.09184892f, 0.10833586f, 0.11663070f, -0.12936696f, 0.06357992f, -0.10473561f, 0.02019655f, 
    0.05949804f, 0.08434166f, -0.00442862f, 0.04620145f, 0.09286412f, 0.02884572f, 0.09178133f, 0.09595102f, 
    0.06414009f, -0.08902065f, -0.10811258f, 0.07469617f, 0.05660560f, 0.12657511f, -0.01038853f, 0.04754065f, 
    -0.00009558f, 0.03796354f, -0.03015835f, -0.00959425f, -0.03854455f, 0.24612427f, 0.45803842f, -0.30551347f, 
    -0.04471536f, -0.16971242f, -0.04398824f, -0.08342486f, 0.01728499f, -0.01382891f, 0.09258022f, 0.05813427f, 
    0.14077379f, 0.07567464f, 0.10801025f, -0.23880985f, -0.12120827f, -0.10050907f, 0.04548674f, 0.14202484f, 
    0.00408058f, -0.02604659f, 0.05022327f, -0.06159214f, -0.08160977f, 0.24348274f, -0.07009857f, -0.37707716f, 
    -0.09622218f, -0.02792667f, 0.08997940f, 0.19889449f, -0.07675564f, -0.02876827f, -0.06435160f, 0.05219907f, 
    -0.41059610f, -0.20282756f, 0.11570624f, -0.05982896f, 0.07828258f, -0.21283744f, -0.02635253f, 0.04109132f, 
    0.02754000f, 0.04129808f, 0.03714841f, -0.00198207f, -0.27154803f, 0.07629053f, -0.04998831f, -0.60030371f, 
    -0.02693643f, -0.20443702f, 0.08391693f, -0.07515729f, -0.01137923f, 0.00977202f, -0.01327828f, 0.03177742f, 
    0.17412463f, 0.19793969f, -0.25014070f, -0.21396467f, 0.00346975f, 0.06046889f, 0.08821250f, 0.10698261f, 
    -0.04890801f, 0.02789856f, -0.13942324f, -0.09600601f, -0.00488260f, -0.02125320f, 0.06676066f, 0.05537560f, 
    -0.02125112f, 0.05476139f, -0.05044720f, 0.02351265f, 0.14643583f, 0.17410703f, 0.08424944f, -0.01840244f, 
    0.15074845f, -0.32984483f, -0.31895494f, -0.01174423f, -0.03379181f, -0.10967290f, 0.08627177f, 0.32180563f, 
    -0.02435508f, -0.03743985f, 0.06396407f, -0.07965568f, 0.36470163f, -0.68742454f, -0.11434661f, -0.02155288f, 
    -0.28971618f, 0.11643425f, -0.05630981f, -0.10658679f, 0.15190278f, -0.00467843f, -0.09770806f, 0.11196302f, 
    -0.02246872f, 0.15072018f, 0.20365320f, 0.30171806f, -0.00630891f, -0.09894325f, -0.03740333f, -0.15311125f, 
    0.02540180f, -0.09147461f, 0.08313665f, 0.05493055f, -0.07139020f, 0.02023323f, -0.25323075f, 0.28362888f, 
    -0.03457993f, -0.00306397f, 0.05308975f, -0.13198200f, 0.12941341f, 0.07091098f, -0.18672453f, -0.23169829f, 
    -0.04119798f, -0.12054583f, -0.00512520f, 0.23799203f, 0.02652616f, 0.05599963f, -0.18008225f, 0.22247572f, 
    0.17646973f, 0.07740184f, 0.04400693f, 0.15940638f, 0.02659629f, -0.08148828f, 0.15261661f, 0.09098236f, 
    -0.04393940f, -0.05222540f, 0.00843144f, -0.11463492f, 0.12370241f, 0.08489928f, 0.13775852f, 0.16259140f, 
    0.04201528f, 0.08968013f, 0.30485469f, -0.33009017f, -0.19742271f, -0.23510745f, -0.04018853f, -0.19381055f, 
    -0.04019348f, 0.05602783f, 0.00013645f, -0.01137820f, -0.23215587f, 0.25131419f, -0.21918970f, -0.04402898f, 
    -0.25903696f, -0.07185439f, -0.11201097f, -0.05556497f, -0.06079040f, -0.18307665f, -0.00045414f, -0.12618525f, 
    0.04097756f, -0.09329342f, 0.23567851f, 0.05096464f, -0.01252559f, -0.27840799f, -0.03195689f, -0.04407747f, 
    0.06472757f, 0.05295116f, -0.00287439f, 0.03504273f, 0.13507338f, -0.32346725f, 0.13134341f, -0.03868099f, 
    0.07713142f, -0.04779182f, 0.05495172f, -0.02397628f, -0.02333183f, 0.03342254f, 0.02551102f, -0.00961361f, 
    -0.03772705f, -0.20161214f, 0.12118617f, -0.09308270f, -0.17440854f, 0.09666905f, 0.01282866f, -0.01177555f, 
    0.04162126f, -0.00886334f, -0.03706999f, -0.03389476f, 0.10905385f, 0.06201374f, -0.14416277f, -0.03055006f, 
    -0.23336570f, 0.03547439f, -0.06930715f, 0.06111244f, 0.06588581f, -0.02295009f, 0.06487879f, 0.03417022f, 
    -0.08070959f, -0.08312804f, 0.10914969f, -0.25121510f, 0.11427774f, -0.16188005f, 0.02055063f, -0.08650809f, 
    0.05504274f, 0.00463728f, -0.04859286f, -0.11671506f, -0.02965758f, 0.10114875f, 0.24753343f, 0.30985910f, 
    -0.00225236f, 0.08327655f, -0.12035521f, -0.06291150f, 0.05927443f, 0.15689082f, 0.06444906f, 0.01198424f, 
    -0.15616331f, 0.21239343f, -0.22292355f, -0.17265840f, -0.27276006f, 0.10492545f, 0.06549930f, 0.03181217f, 
    0.02759355f, 0.10071802f, -0.06865695f, -0.07276870f, 0.03744125f, -0.08363965f, 0.27961066f, -0.17326987f, 
    0.04224589f, -0.11602979f, -0.03534752f, 0.17400849f, 0.05733153f, 0.00383932f, 0.01896681f, 0.10950021f, 
    -0.35141942f, 0.32224536f, 0.22085512f, 0.03528563f, -0.14705783f, 0.04312577f, 0.05737447f, 0.00198280f, 
    0.05601693f, 0.17817746f, 0.08726983f, 0.08369997f, -0.37699267f, 0.04849405f, -0.27800617f, 0.05405335f, 
    -0.07677577f, 0.11258540f, -0.06213355f, -0.07358643f, 0.01641441f, 0.02933698f, 0.03549172f, 0.01082439f, 
    -0.04456022f, 0.07220031f, 0.05708454f, 0.03160821f, 0.00879312f, -0.17945351f, -0.00667119f, 0.06943694f, 
    -0.14032075f, -0.00150868f, -0.38437679f, -0.01837166f, -0.02382317f, 0.19700053f, 0.15146974f, -0.10101423f, 
    -0.24135591f, 0.09043632f, -0.06058903f, 0.05251700f, 0.07799958f, -0.11080143f, 0.06015799f, -0.07841194f, 
    0.03064335f, -0.04066168f, -0.07988741f, 0.11746223f, -0.03696137f, 0.09500206f, 0.21041276f, 0.03001306f, 
    0.11402621f, 0.04351418f, 0.01898460f, 0.03191366f, -0.22804242f, -0.01611195f, 0.30202636f, -0.07934049f, 
    -0.13678555f, -0.10423907f, 0.01619554f, -0.00960228f, -0.08956486f, -0.03801284f, 0.28826511f, 0.06129208f, 
    -0.44391301f, 0.01223054f, 0.08731923f, 0.12867777f, 0.09309908f, 0.07555453f, 0.04428629f, 0.03720859f, 
    -0.13792825f, -0.05403135f, 0.10319993f, 0.04920720f, -0.10999296f, -0.13044347f, -0.21625514f, 0.06404898f, 
    0.03400807f, -0.12961634f, -0.06874526f, -0.00508782f, -0.10826833f, -0.27332026f, -0.14231558f, -0.25189796f, 
    0.15712793f, -0.11662509f, -0.09190652f, 0.33607215f, 0.09764047f, 0.01084785f, -0.03593330f, -0.02527274f, 
    0.10894724f, -0.07657252f, 0.07090637f, -0.06842620f, 0.16228352f, -0.02719531f, -0.11382524f, 0.20865734f, 
    -0.30230927f, -0.05836744f, 0.12417074f, -0.07701726f, 0.03867584f, 0.17468305f, -0.20350628f, 0.07271174f, 
    -0.28365090f, -0.27432001f, -0.21860728f, -0.26874590f, -0.06940740f, -0.06768534f, -0.09330842f, -0.05301418f, 
    -0.10760050f, -0.01257701f, -0.13712502f, -0.10938267f, -0.06910607f, -0.26817504f, 0.03213019f, -0.12474417f, 
    -0.10712215f, 0.06211914f, 0.11223695f, -0.03434893f, -0.07364240f, 0.21985178f, 0.05389110f, 0.06002790f, 
    -0.21107198f, 0.54668581f, 0.33784887f, 0.01761320f, 0.04408588f, -0.01760006f, -0.19895877f, 0.16144872f, 
    0.13035025f, 0.04179591f, 0.16663618f, 0.10436139f, -0.49503577f, 0.12862951f, -0.01416695f, -0.24306822f, 
    -0.16110039f, 0.02079306f, 0.08987731f, 0.12730025f, -0.17510395f, 0.07134762f, -0.01418023f, 0.07739425f, 
    -0.07845806f, 0.17658825f, 0.03860842f, -0.00734496f, -0.08504328f, -0.04156533f, -0.04596461f, -0.04021682f, 
    -0.10978696f, -0.10717418f, -0.30374417f, -0.22003718f, -0.18730453f, 0.26520035f, 0.40204698f, 0.03424059f, 
    0.01003162f, 0.24975090f, 0.01851257f, 0.10452537f, 0.00030426f, -0.05884155f, 0.13871357f, 0.07736640f, 
    -0.00564110f, 0.12750660f, 0.09925124f, 0.07613872f, -0.16345738f, 0.18548438f, -0.09385011f, -0.11519609f, 
    0.12427101f, 0.00318264f, 0.04466659f, -0.04773489f, 0.40951541f, -0.07198980f, 0.32404321f, 0.16230471f, 
    -0.05868338f, 0.03343410f, -0.04454800f, -0.01897897f, 0.12569028f, 0.12504783f, 0.23207413f, 0.00896730f, 
    -0.03631181f, 0.02003957f, -0.18010589f, -0.00883148f, -0.01916093f, -0.00521331f, -0.27493018f, 0.00972209f, 
    -0.00713076f, -0.02893895f, 0.11546585f, -0.02971536f, 0.33416960f, 0.11814756f, 0.09583129f, -0.19782360f, 
    -0.06108575f, -0.05034950f, 0.04370864f, 0.01727508f, -0.00083290f, -0.05793157f, -0.33146524f, -0.11639732f, 
    -0.42039800f, -0.13103783f, -0.28286245f, -0.03953744f, -0.13497818f, -0.03550840f, -0.19355026f, 0.10750085f, 
    0.00891585f, 0.03483694f, -0.11790550f, -0.16141015f, -0.25175375f, -0.00399356f, 0.01890295f, 0.19171649f, 
    0.01548937f, 0.15613306f, -0.10320968f, -0.03194094f, 0.02492667f, -0.09658261f, -0.10490983f, 0.00873018f, 
    -0.04175415f, 0.07292064f, -0.31640542f, 0.30547088f, -0.16447435f, -0.00766063f, -0.02931404f, -0.12003536f, 
    -0.00528788f, 0.12784021f, -0.06768647f, 0.07812162f, -0.07393374f, 0.06242350f, 0.08619809f, -0.10355680f, 
    -0.01820344f, -0.01341866f, -0.09808004f, -0.00994078f, -0.07430762f, 0.05151729f, 0.03793620f, -0.16518623f, 
    -0.13082086f, -0.32259604f, 0.13071372f, -0.14092684f, -0.17426875f, 0.00327078f, -0.01520974f, -0.05449225f, 
    -0.02394234f, -0.01014525f, 0.07565554f, 0.04232633f, 0.01939983f, 0.17494053f, 0.14804348f, -0.09833936f, 
    0.04967562f, -0.13460338f, 0.00411505f, -0.04380332f, -0.01917137f, 0.15330806f, -0.15483099f, -0.09352191f, 
    -0.02120870f, 0.09988015f, -0.12009953f, 0.01386306f, 0.02674580f, -0.14045241f, 0.20442787f, -0.03067644f, 
    -0.22107418f, 0.09233485f, -0.09366336f, -0.09604596f, -0.23491447f, -0.02649794f, 0.11770298f, 0.19917051f, 
    -0.05555084f, -0.05268234f, 0.07952397f, 0.00603076f, -0.07806781f, 0.11228904f, 0.12500718f, 0.00971885f, 
    0.26340109f, -0.24766667f, -0.05025591f, 0.10886449f, 0.00836401f, -0.00845575f, 0.01124271f, 0.24005768f, 
    0.03086700f, 0.02281489f, 0.06466793f, 0.00524692f, 0.07321823f, 0.08103986f, -0.20333351f, -0.11335605f, 
    -0.38670269f, -0.00080042f, 0.08638621f, -0.15372142f, 0.00868904f, 0.19181518f, -0.10544728f, 0.07522605f, 
    0.07509861f, 0.27503529f, 0.22510409f, -0.26137987f, 0.04353158f, -0.02406620f, 0.11131308f, 0.16814566f, 
    -0.25862592f, 0.11623735f, 0.09927312f, 0.08875467f, 0.07251288f, -0.27602291f, -0.06139579f, -0.00324042f, 
    -0.17583762f, -0.03900256f, 0.05850676f, -0.12157992f, -0.10238519f, -0.13251840f, -0.29470927f, 0.04405669f, 
    -0.02334899f, -0.01909013f, -0.00055983f, 0.11715010f, 0.00361075f, -0.02806071f, 0.00257848f, 0.07459034f, 
    -0.13826567f, -0.05298216f, -0.13622332f, -0.18820082f, -0.12369089f, -0.16640353f, 0.06814616f, 0.02116994f, 
    -0.12796140f, -0.04637661f, 0.04507526f, 0.08172838f, 0.03486557f, 0.03402502f, 0.14401616f, 0.01477076f, 
    -0.30193949f, -0.05773193f, -0.02896929f, 0.16008872f, 0.08970393f, 0.14635429f, -0.11628734f, -0.03323803f, 
    -0.17200714f, -0.21612328f, 0.03453849f, -0.08594696f, 0.23181733f, 0.01108518f, 0.23560105f, -0.13422009f, 
    0.01083498f, -0.07688819f, 0.11916091f, 0.09787709f, -0.07579640f, 0.05307153f, -0.09796674f, -0.42771479f, 
    0.03063998f, 0.24964719f, -0.02349734f, 0.02137388f, 0.10331635f, 0.06261746f, 0.03001217f, 0.04213228f, 
    -0.16648875f, 0.07100802f, 0.14233272f, 0.15622024f, -0.10678648f, 0.05968058f, 0.06109729f, 0.07395368f, 
    -0.22029240f, 0.03450543f, -0.06350710f, 0.00866635f, 0.10001462f, -0.02417397f, 0.20319726f, 0.15790159f, 
    -0.15159193f, 0.01873698f, -0.00780690f, -0.10181192f, -0.07014120f, 0.05805065f, 0.01494799f, -0.00837427f, 
    -0.14963606f, -0.17949337f, -0.13433702f, -0.30097836f, -0.03304066f, -0.02554398f, -0.11744375f, -0.03332268f, 
    -0.02245083f, 0.10109612f, -0.11658543f, -0.04514420f, -0.07522988f, -0.00018723f, -0.03978415f, -0.15214835f, 
    -0.41517049f, 0.05457343f, -0.02761141f, -0.05863014f, -0.09003925f, 0.11759742f, 0.10023616f, 0.03196093f, 
    -0.10168448f, -0.06530198f, -0.08765216f, 0.19570029f, -0.18595086f, -0.00341212f, 0.05042939f, 0.13942544f, 
    0.04032706f, -0.14620602f, 0.00659058f, 0.03067483f, -0.02605167f, -0.08453076f, -0.10798276f, -0.08087344f, 
    -0.08225781f, -0.01861665f, -0.08292558f, 0.22601432f, -0.09116430f, 0.04011149f, -0.11113263f, -0.06850450f, 
    0.11267786f, 0.06660025f, 0.05751798f, -0.00160600f, -0.09230818f, -0.25650418f, 0.03078198f, 0.21392092f, 
    -0.07350881f, 0.08467200f, 0.06670773f, 0.03333191f, 0.12047902f, 0.02719589f, 0.05342668f, 0.11206087f, 
    -0.09623569f, -0.32977378f, -0.21886763f, -0.03780541f, -0.02626365f, 0.05619290f, -0.02357621f, 0.18397401f, 
    -0.04110461f, 0.10286626f, 0.05908304f, 0.01864161f, 0.10233757f, -0.13347208f, 0.25801629f, 0.10776808f, 
    -0.13767989f, 0.06681251f, 0.21419236f, 0.22297576f, 0.02424531f, 0.06196716f, -0.00401690f, 0.08495680f, 
    -0.06451573f, -0.40689638f, 0.09607977f, 0.04894125f, -0.05205048f, -0.19060284f, 0.08854783f, -0.11668215f, 
    -0.01218656f, -0.04375248f, 0.04714629f, -0.10629638f, -0.12031797f, -0.12241928f, 0.06463441f, -0.07471504f, 
    -0.01523085f, 0.09088333f, -0.24107540f, 0.01746827f, 0.09143124f, -0.00577574f, 0.08606963f, 0.05346023f, 
    -0.13352986f, 0.32121909f, 0.11656821f, 0.21113341f, 0.09737924f, -0.24931090f, -0.07786851f, 0.26166528f, 
    -0.16169833f, 0.00204494f, -0.07635103f, -0.09956017f, 0.04776043f, 0.17334241f, -0.03506024f, 0.17764704f, 
    0.10269824f, -0.26721084f, 0.09388756f, -0.07138035f, 0.13010710f, -0.07765338f, 0.02088849f, 0.14572059f, 
    0.18533053f, -0.04274494f, 0.00387335f, -0.27154741f, -0.05032369f, 0.01609171f, 0.03578703f, 0.09585848f, 
    -0.07788680f, -0.09524069f, -0.20126721f, -0.36696172f, 0.18449730f, 0.29608607f, 0.04713243f, -0.05250621f, 
    0.03699213f, -0.04413183f, 0.14930011f, -0.05296407f, 0.09096352f, -0.10840615f, 0.11875788f, 0.16871828f, 
    -0.08912185f, -0.14962895f, 0.10376253f, 0.02231516f, -0.07683875f, -0.11619712f, -0.06475034f, -0.04503826f, 
    -0.16035369f, -0.01903954f, -0.12787803f, -0.11192124f, -0.15451290f, -0.07196232f, -0.28555238f, -0.18144278f, 
    0.10868007f, -0.07607453f, -0.02980239f, -0.05216207f, -0.04564149f, 0.10095584f, -0.11313654f, -0.26782694f, 
    -0.01596270f, 0.08288384f, -0.11630467f, 0.10549697f, -0.00397197f, -0.30858275f, 0.03184639f, -0.03854982f, 
    0.08157960f, -0.02300888f, -0.11178816f, -0.17490306f, 0.09317362f, 0.41031277f, 0.24956098f, 0.07436246f, 
    -0.02255952f, -0.03664401f, 0.27460840f, -0.04543773f, 0.00742185f, 0.14378330f, 0.25323045f, 0.02814656f, 
    -0.29426047f, 0.09533280f, -0.32905540f, -0.01756523f, -0.11602026f, 0.13472219f, 0.08616223f, 0.01644619f, 
    -0.00892533f, -0.02676677f, -0.09761308f, 0.01125116f, -0.42422041f, 0.14011326f, -0.27265546f, 0.28366122f, 
    -0.05941361f, 0.03271231f, -0.20451275f, 0.12731604f, -0.02219312f, -0.15607654f, -0.00274889f, -0.05080117f, 
    -0.07566751f, 0.19690520f, -0.11394753f, 0.06324542f, -0.02020622f, 0.14385067f, -0.06714604f, -0.04380091f, 
    0.11735339f, 0.13686907f, 0.07772976f, 0.08126463f, -0.09941142f, 0.08031048f, 0.06864399f, -0.04160967f, 
    -0.02963359f, -0.14562152f, 0.00981813f, -0.13359939f, -0.12131257f, 0.16615146f, -0.00418990f, -0.12902415f, 
    -0.12150339f, 0.09786864f, 0.25066298f, 0.02862602f, 0.02366619f, -0.08260689f, -0.01817546f, 0.04394601f, 
    -0.01752443f, -0.06718896f, 0.14043517f, 0.18836884f, -0.36893690f, 0.02335209f, -0.06979220f, -0.25644109f, 
    0.00655460f, -0.02519680f, -0.07043828f, -0.03950786f, 0.10034249f, -0.24053483f, -0.21952607f, -0.16468330f, 
    0.15836598f, 0.07141451f, 0.14919047f, -0.11085667f, -0.10198394f, -0.08499137f, 0.08946399f, -0.00229322f, 
    0.02741366f, -0.17659253f, 0.02116748f, 0.10106521f, -0.34039867f, 0.19261612f, -0.14692055f, 0.01827264f, 
    -0.00203620f, 0.07038613f, 0.03092746f, 0.12615769f, -0.09668633f, -0.06528563f, -0.17965110f, -0.04390617f, 
    -0.67416573f, 0.15218076f, -0.40930450f, 0.15469214f, 0.02579834f, 0.15210383f, 0.07460942f, -0.06079015f, 
    0.03926265f, -0.12223145f, 0.05676105f, -0.24485819f, -0.29385841f, -0.30984503f, 0.01192303f, 0.10815503f, 
    -0.15119496f, -0.05067371f, -0.02468575f, -0.19264835f, -0.05175909f, 0.00035523f, 0.04224049f, -0.02711774f, 
    0.12854829f, -0.02325639f, 0.13199331f, -0.16355418f, 0.08510675f, 0.07890869f, -0.01335635f, 0.02582723f, 
    -0.06679004f, 0.09459376f, 0.21849144f, -0.05911729f, 0.14616501f, -0.55390519f, 0.16371667f, -0.23671319f, 
    0.13235247f, -0.05176821f, -0.17269874f, 0.06428935f, -0.03735400f, 0.03971174f, 0.21532163f, -0.12699527f, 
    0.02929054f, -0.12903938f, 0.03210278f, -0.20889570f, -0.05567585f, -0.16577506f, -0.17947438f, -0.02053915f, 
    -0.03902683f, -0.04482193f, -0.07684416f, -0.13382547f, 0.16529128f, 0.05878072f, 0.09384567f, -0.00502602f, 
    -0.06143417f, 0.19670725f, 0.02073092f, 0.19567391f, -0.07913814f, -0.10485562f, 0.02640470f, -0.21529953f, 
    -0.19569106f, 0.18546630f, -0.33764192f, 0.14722063f, 0.07189432f, 0.02625865f, 0.06792771f, 0.00864575f, 
    -0.03509694f, 0.05317841f, 0.10430375f, -0.02525280f, -0.42663637f, -0.47813579f, 0.05981173f, -0.04428775f, 
    -0.01052026f, 0.05648041f, 0.03645448f, 0.13810790f, -0.14201152f, 0.00734831f, 0.05085092f, 0.09275594f, 
    -0.26947051f, 0.25775740f, 0.26546434f, -0.07915535f, 0.02873664f, 0.07006019f, -0.01495930f, 0.08138429f, 
    -0.21950790f, 0.17897524f, 0.03245686f, -0.07551503f, 0.11690806f, -0.05902584f, 0.30698749f, 0.22005835f, 
    -0.06311709f, -0.05978346f, -0.04403077f, 0.06687231f, 0.07217874f, -0.06267511f, 0.06646224f, 0.13277631f, 
    0.21083771f, 0.17383535f, 0.14863017f, -0.08552535f, 0.06563022f, 0.10647946f, -0.15049396f, 0.06237239f, 
    0.00816617f, -0.03748835f, 0.10964398f, -0.01199106f, 0.39340398f, -0.00956932f, 0.19935407f, -0.09920200f, 
    0.09475243f, 0.09927376f, -0.13023780f, 0.05172082f, -0.04430465f, -0.01659632f, -0.08016358f, -0.04137187f, 
    -0.25496799f, -0.26009637f, -0.02918827f, 0.04180761f, 0.28120211f, 0.09555304f, 0.01021120f, 0.00941222f, 
    -0.07022422f, -0.08323395f, -0.07787613f, 0.14005536f, 0.08685081f, -0.00108365f, -0.08452349f, 0.07842336f, 
    0.02984476f, 0.25132012f, -0.07175951f, -0.00651045f, 0.01954595f, 0.02430460f, 0.00714194f, 0.01188815f, 
    0.10459319f, -0.08732770f, 0.04985630f, 0.01642698f, 0.02592867f, -0.00971624f, -0.03054007f, 0.02399883f, 
    0.04936943f, 0.10359192f, 0.10621905f, 0.05550237f, 0.15014958f, 0.13377771f, -0.56718445f, 0.29475102f, 
    -0.02176402f, -0.05006669f, 0.11929030f, 0.02966514f, 0.06950748f, 0.27271712f, -0.03043071f, 0.23392887f, 
    -0.14961265f, 0.09593186f, 0.22387244f, 0.06500046f, -0.16290718f, 0.11754461f, 0.11106259f, -0.27915469f, 
    0.03528864f, -0.00326198f, 0.10247847f, 0.08068025f, -0.29084060f, -0.02277617f, -0.09513444f, -0.00173640f, 
    0.05500726f, -0.06063504f, -0.00690235f, 0.10931440f, -0.29822165f, -0.04854836f, -0.13929455f, 0.12720910f, 
    0.32697591f, 0.17596091f, 0.06956550f, 0.07849095f, 0.02105204f, -0.13415870f, 0.05942265f, 0.12598599f, 
    -0.08047443f, -0.05973785f, -0.12524115f, -0.04765001f, 0.21067385f, -0.67750823f, 0.24524921f, -0.21257965f, 
    0.07646865f, 0.05687150f, -0.08725425f, 0.07844711f, -0.07111771f, 0.00598023f, 0.06208094f, 0.07902735f, 
    0.08903543f, -0.23656736f, 0.08192129f, -0.25298280f, 0.01282451f, -0.06287208f, -0.12313131f, 0.17501377f, 
    -0.01507552f, 0.11544356f, 0.07843017f, 0.01534236f, -0.20338146f, -0.39310127f, 0.10914441f, 0.17967896f, 
    -0.05074594f, -0.12499624f, -0.00467810f, -0.02299451f, -0.07939433f, 0.09477268f, 0.07177631f, 0.06009590f, 
    0.07832919f, 0.07342798f, 0.13632499f, 0.11106080f, 0.06118667f, 0.00979710f, 0.04835141f, -0.02028245f, 
    -0.06870267f, -0.03703590f, 0.06005171f, -0.07014640f, -0.04459398f, 0.12502503f, -0.01116673f, 0.02825529f, 
    -0.08532491f, -0.00722600f, 0.00320082f, -0.00287538f, 0.03044310f, 0.08789559f, 0.09402113f, 0.12394660f, 
    0.38356125f, 0.19696650f, 0.45544752f, -0.22865187f, -0.00725909f, -0.09905655f, -0.09221517f, -0.01660855f, 
    -0.06644887f, -0.02429845f, -0.06368957f, -0.05152291f, -0.35021695f, -0.13790315f, -0.18774836f, -0.01908275f, 
    0.03236782f, -0.03626532f, 0.03318438f, 0.07010435f, -0.08590958f, -0.01251186f, -0.03736855f, -0.15225722f, 
    -0.16225784f, 0.01743694f, 0.05719290f, 0.16465670f, -0.13312858f, 0.10280879f, 0.09177908f, 0.00724784f, 
    -0.05679904f, -0.08800416f, -0.10834106f, -0.03966470f, 0.20937091f, 0.22864544f, 0.30398172f, -0.15209660f, 
    -0.17264409f, 0.07884207f, -0.08376454f, 0.01227901f, -0.03523181f, 0.06461284f, -0.07051395f, 0.04886464f, 
    -0.23435871f, 0.07172886f, 0.28602159f, 0.03798813f, -0.12533200f, 0.15734583f, 0.01909342f, -0.05918271f, 
    -0.07193388f, -0.03712636f, 0.07187448f, -0.06763936f, 0.39956614f, -0.20303632f, 0.55151200f, 0.03059312f, 
    0.07110555f, -0.10314044f, 0.08462358f, 0.03082412f, -0.03847597f, -0.08869546f, -0.06472676f, -0.07278239f, 
    -0.07516080f, 0.16180682f, 0.19110078f, 0.05226194f, 0.08150043f, 0.01682350f, 0.04528430f, -0.02015556f, 
    -0.11731020f, -0.01141743f, 0.00979409f, 0.09271590f, -0.06837805f, 0.06517844f, 0.20068733f, -0.00068117f, 
    0.03292930f, 0.07258335f, -0.09518694f, -0.04956694f, -0.01983525f, 0.03991585f, 0.16694148f, 0.15727301f, 
    0.12440780f, 0.17373043f, 0.25106996f, 0.02872413f, -0.10822293f, 0.00731744f, 0.02818958f, 0.03458488f, 
    -0.03700676f, 0.06265671f, 0.12772773f, 0.02542533f, 0.12408340f, -0.00369076f, 0.06617256f, -0.11762626f, 
    -0.07502553f, -0.19054501f, -0.12394813f, 0.03875014f, -0.00758110f, -0.03481400f, -0.02766456f, -0.18942459f, 
    -0.37218243f, 0.20332888f, -0.32920250f, 0.36894819f, 0.01437679f, 0.11014797f, 0.03178242f, -0.10844240f, 
    0.03939930f, 0.10845987f, 0.02272379f, -0.09983986f, -0.11762170f, 0.36790994f, -0.17584316f, -0.42230701f, 
    -0.07686787f, -0.01523387f, 0.09990840f, 0.15186848f, 0.01373781f, 0.06535423f, 0.06556971f, 0.11159735f, 
    -0.50134152f, 0.08320350f, -0.08113459f, 0.19289096f, 0.01790554f, -0.04624947f, 0.13582391f, -0.10085733f, 
    -0.11606125f, 0.10705649f, 0.10624746f, -0.12197449f, -0.27349338f, -0.11826615f, -0.18225172f, -0.00438156f, 
    0.12562791f, 0.05063113f, -0.14227228f, 0.08084708f, -0.12393444f, -0.04101581f, -0.03838029f, -0.18212664f, 
    -0.24694856f, -0.02220708f, -0.21219535f, 0.03776850f, 0.07109874f, 0.03675373f, -0.00118369f, 0.00557874f, 
    0.10212044f, 0.00412946f, 0.19279498f, 0.17619745f, -0.09732824f, -0.06573333f, 0.04828043f, -0.14307757f, 
    -0.09117479f, -0.00175029f, 0.10470327f, -0.01247362f, 0.03106454f, 0.05400977f, 0.05139166f, 0.02100320f, 
    -0.09774710f, 0.03201019f, -0.16858564f, 0.02276823f, 0.10030014f, -0.02732771f, 0.01304182f, -0.02050077f, 
    0.06400682f, 0.06032047f, 0.11812035f, 0.00344041f, -0.22872822f, -0.07466160f, -0.12568916f, -0.05608115f, 
    -0.11172356f, -0.02251519f, -0.07410488f, -0.00958032f, -0.06697859f, 0.08864988f, -0.00740815f, 0.00778870f, 
    -0.29591855f, -0.21398641f, -0.20730339f, 0.08314534f, -0.10270645f, 0.03903384f, -0.14546676f, -0.18283281f, 
    0.00891419f, 0.03052735f, -0.11109150f, -0.04466931f, -0.01931143f, 0.10944576f, -0.13116553f, -0.06974492f, 
    -0.07757490f, -0.20861201f, -0.11768907f, -0.13699746f, -0.07489221f, 0.01639120f, -0.11797075f, -0.15242472f, 
    -0.04156363f, -0.28809032f, 0.10763749f, -0.15698129f, -0.16839013f, -0.03260839f, -0.21434480f, -0.18328853f, 
    -0.02544689f, -0.00705558f, 0.03425301f, -0.02533815f, 0.10533395f, -0.20360367f, 0.00468214f, -0.09658905f, 
    -0.12458082f, 0.11001077f, -0.18967886f, 0.13771285f, 0.01344539f, -0.02037533f, -0.10977732f, -0.03477522f, 
    0.26156026f, -0.09425461f, 0.35484064f, -0.13227525f, -0.14269151f, 0.21728171f, -0.39124253f, 0.16698521f, 
    -0.08980904f, 0.04361465f, 0.03485809f, 0.04628339f, -0.31287944f, -0.00114932f, -0.17250259f, -0.08734310f, 
    0.00480777f, -0.08166830f, 0.12155544f, 0.05329386f, -0.05492390f, 0.06545779f, 0.04412943f, -0.09917772f, 
    0.01123795f, -0.16097115f, 0.36597446f, 0.29456407f, -0.03171544f, 0.07168456f, -0.12103949f, 0.05837202f, 
    -0.02059793f, 0.07834443f, 0.05167785f, 0.11072000f, -0.47505239f, 0.39718089f, -0.06268181f, -0.04071113f, 
    0.03152298f, -0.00021980f, 0.21836188f, -0.37148297f, 0.04747321f, 0.08302043f, 0.04738132f, -0.09304988f, 
    -0.28305066f, -0.24829477f, -0.18599036f, -0.16066061f, -0.08108860f, -0.06023606f, -0.09963944f, 0.02856993f, 
    -0.08383467f, 0.10252441f, 0.02470663f, 0.06249096f, 0.00940540f, -0.08265308f, 0.08631940f, -0.14803286f, 
    -0.01093188f, 0.02610737f, 0.05231489f, -0.03356018f, 0.02049813f, -0.11513214f, 0.00121722f, -0.07845464f, 
    -0.34156328f, 0.30546340f, -0.09107278f, 0.04061631f, 0.07863121f, 0.04161964f, 0.09180257f, -0.00031182f, 
    -0.10265335f, -0.01859192f, 0.17853905f, 0.14111969f, 0.13653639f, 0.03942833f, 0.02037235f, -0.27702019f, 
    0.03956280f, -0.03328358f, 0.10397769f, -0.01362520f, 0.02325118f, 0.15090573f, 0.13610956f, -0.01129776f, 
    0.00145684f, -0.10179850f, 0.15868749f, -0.04454553f, 0.00926881f, -0.07487173f, -0.02667055f, -0.06374358f, 
    0.05007624f, -0.00822566f, -0.02770749f, -0.12032365f, -0.10717051f, -0.13125502f, -0.13191852f, 0.06130454f, 
    0.13638179f, -0.08745715f, 0.25398201f, -0.18691143f, 0.06016098f, 0.17022648f, -0.17789519f, 0.03615082f, 
    0.23729284f, -0.16057450f, 0.00623111f, -0.09935935f, 0.01950609f, -0.38766491f, -0.08479973f, 0.04901752f, 
    0.00135424f, -0.02601529f, 0.08024492f, -0.04889707f, -0.15975195f, 0.00591836f, 0.12311547f, 0.25481451f, 
    -0.04838313f, -0.14959630f, 0.07261154f, 0.13947135f, -0.18698356f, 0.09934145f, 0.00783531f, -0.12598799f, 
    -0.12461367f, -0.06751075f, -0.01609927f, -0.10119736f, -0.15331627f, -0.12760702f, -0.06058681f, -0.06238353f, 
    0.04379423f, 0.09669305f, 0.07737171f, 0.05984954f, -0.05527496f, 0.07160696f, 0.11369000f, -0.02759351f, 
    0.09871802f, 0.15170059f, -0.10749775f, -0.03881622f, 0.01487474f, -0.07304042f, 0.04527647f, -0.00113416f, 
    0.11087188f, 0.09233463f, -0.27412438f, 0.26142216f, -0.08465442f, 0.15062413f, -0.19108404f, 0.14693497f, 
    -0.15436584f, 0.01140196f, 0.15304680f, 0.05093186f, -0.25085345f, -0.02193720f, -0.28941101f, -0.06526790f, 
    0.06178416f, -0.00826615f, 0.01491150f, -0.09578937f, 0.03685708f, 0.21873875f, 0.06722581f, 0.11412854f, 
    -0.20113772f, 0.14987250f, 0.17009209f, 0.01757056f, -0.09033368f, -0.01186578f, 0.04793103f, -0.18057364f, 
    -0.04771531f, -0.12190741f, 0.06809458f, -0.13878386f, 0.20528066f, -0.28717262f, -0.13777272f, -0.01861922f, 
    0.07162776f, -0.01306062f, 0.00681373f, -0.03242464f, 0.02796130f, 0.18691649f, -0.04210519f, 0.05182679f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15635860f, 0.08587034f, 0.06919296f, -0.05635952f, -0.06602898f, 0.07289413f, 0.05049346f, -0.11898293f, 
    0.09557852f, 0.04565033f, 0.01279783f, -0.05178361f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
