#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.80773276f, 1.05245841f, -0.59819204f, 0.82419664f, -0.02724010f, -0.77804840f, 0.81879586f, -0.23425086f, 
    -0.79214382f, 1.05356753f, -0.33542526f, 0.68704522f, 0.67589980f, 0.16651946f, 0.40105039f, 0.57374972f, 
    0.07829113f, -1.17988360f, -0.93840325f, 0.98162299f, 1.00586760f, 0.24908121f, 0.15592436f, 0.88347471f, 
    -0.85636604f, -0.43216524f, 0.16258746f, 0.41197658f, -1.26425183f, -0.79798418f, -1.27325583f, -0.03488452f, 
    -0.23845944f, -0.53979540f, 0.09630288f, 0.59094369f, 1.25923479f, 0.97171926f, -0.25950104f, 0.10629902f, 
    -0.61648178f, -0.80998993f, 1.04619336f, 0.78137773f, -0.08592913f, 0.79556179f, -0.20069295f, 1.04540324f, 
    0.98627263f, 0.62410939f, -0.63801074f, 0.32712808f, 0.50429273f, 0.69761616f, 1.30066347f, 0.73141873f, 
    1.21030617f, -1.27441466f, 0.21914966f, -0.78662813f, -0.09047664f, -0.02041946f, 0.24516156f, 0.05292647f, 
    1.68367970f, -1.09459341f, 0.78763819f, -0.00141426f, -0.80077964f, -0.16456409f, -0.15557157f, 0.48826146f, 
    0.47723562f, -1.69656229f, 0.33942944f, -0.78990310f, 0.65006453f, -0.54536241f, 0.42966530f, 0.66129982f, 
    -0.38078129f, -1.19806302f, -0.66534662f, -0.00497979f, -0.44543484f, 0.82790613f, -0.55696970f, 0.18684123f, 
    0.66609859f, -0.65337086f, -0.95083040f, -0.23650628f, -0.96187007f, -0.06652839f, 1.26805484f, 0.10471892f, 
    0.07547688f, -0.28168017f, 0.26954308f, 0.87920827f, 0.94415385f, 1.34227562f, 0.24714659f, -0.82249475f, 
    0.47545031f, 0.47165912f, -0.58522111f, 0.08399295f, 0.58758968f, -1.25688720f, -0.84218574f, -0.02936811f, 
    -1.46881473f, -0.56702733f, -0.14316665f, 0.04989041f, 0.30074775f, -1.07428777f, 0.76756942f, -0.11116750f, 
    -0.67503393f, -0.78891587f, -1.17617869f, -0.21665421f, 0.22122234f, 0.78903621f, 1.28978288f, 0.30223119f, 
    0.19073942f, 0.32057646f, 0.77528769f, 0.77076238f, -0.76769716f, 0.36478424f, 0.57497561f, 0.04377180f, 
    -0.95730013f, -0.35100526f, 0.80913222f, -1.27276397f, -0.78324455f, -0.25118998f, 0.35659561f, 0.88034546f, 
    -0.21457389f, 0.45287549f, 0.60034847f, -1.26224649f, -0.29913396f, -1.50875640f, 0.16900416f, 0.42824796f, 
    -0.56348801f, -0.86672193f, -0.85739219f, -0.13721526f, -0.13728043f, 0.42198899f, -0.04539311f, -0.54941255f, 
    -0.29696068f, -0.90159869f, -1.23914123f, -0.46977779f, -0.73480409f, 1.04778993f, 0.54373735f, 0.21108548f, 
    0.04884360f, 0.65750533f, 0.49130979f, 0.98756832f, -0.19639790f, 0.86234868f, 1.02231371f, -0.65936553f, 
    0.81909150f, -0.23370741f, -0.60024148f, -0.67146450f, -1.68250155f, 0.24193154f, 0.07906114f, 0.61048186f, 
    0.66339201f, 0.46598405f, -0.01494137f, -0.11677617f, -0.76051724f, 1.19371164f, -0.15898943f, -1.14065123f, 
    0.65053707f, 0.77127331f, -0.72734177f, 0.03700172f, 0.11203084f, -0.34261391f, 0.80523556f, 1.16537476f, 
    0.83587146f, -0.62558931f, -0.83772194f, 0.06432889f, -0.31604639f, 0.59978467f, -0.06430034f, -0.69735271f, 
    -0.86764443f, -0.76617920f, 0.67866528f, 0.97440070f, -0.18052833f, -0.09568418f, -0.29684922f, -0.54912674f, 
    -1.01364315f, -0.51354009f, -1.13707983f, -0.03154412f, -0.60780311f, -0.65626746f, 0.09711082f, 0.04453693f, 
    -0.02504506f, 0.64094758f, -0.54102278f, -0.79546189f, -0.33674639f, 0.79934627f, -0.94442070f, -0.09123545f, 
    -0.31871638f, -0.53249407f, -1.06908453f, -0.95404249f, -1.20392656f, 0.17924705f, -0.28278270f, 0.60182524f, 
    0.70856082f, -0.30003566f, -0.60213542f, 0.46669263f, 1.03384519f, 0.47135839f, -1.05567718f, 1.30037725f, 
    0.16060838f, 0.59777206f, -0.21118297f, -0.57961905f, -0.75460988f, -0.81067109f, 0.59585053f, 0.63946658f, 
    1.09984982f, 1.46074951f, -0.14958315f, -0.23947969f, -0.28740832f, -0.98113501f, -0.38512817f, -0.04895142f, 
    -0.97731513f, 1.24575603f, -0.47209936f, 0.17173487f, -0.49824205f, 0.51648831f, 0.47907689f, -0.61807466f, 
    1.10038280f, 1.00751102f, 0.83587080f, -0.46703428f, -0.49330875f, -0.37395078f, -0.24707435f, -0.49914220f, 
    -1.27311981f, 0.76140833f, 0.79778075f, -0.17704585f, 0.79245073f, 0.39577994f, 0.22315475f, 0.72552299f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31834465f, -0.24680762f, -0.28290522f, 0.15808351f, -0.25208712f, 0.05409364f, -0.24581137f, 0.03439806f, 
    -0.02619725f, -0.04848597f, -0.01532223f, 0.33081555f, 0.42865384f, 0.44957674f, 0.21600024f, -0.20500308f, 
    0.42416388f, -0.22084382f, 0.05850439f, 0.09321023f, 0.28022128f, 0.13079281f, 0.27283436f, -0.08293062f, 
    0.15158708f, -0.02062793f, 0.36753908f, -0.32188720f, -0.21047799f, -0.21077260f, 0.18363984f, 0.42969117f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.16465510f, 0.06909978f, -0.17357136f, 0.25636908f, -0.15488146f, -0.05014817f, 0.07556959f, 0.21985802f, 
    -0.12964518f, -0.14365724f, 0.00145750f, 0.01937559f, -0.09097657f, 0.06185493f, -0.11370578f, 0.27742994f, 
    0.05848902f, 0.15868534f, 0.00896761f, -0.26568460f, 0.05146578f, 0.04697245f, -0.26328593f, -0.00130503f, 
    -0.00870952f, -0.07755140f, -0.01805376f, 0.06108350f, 0.12535244f, 0.03766594f, -0.14118282f, -0.07258043f, 
    -0.00412655f, -0.12980339f, 0.00261453f, -0.19436955f, 0.11351149f, -0.33356854f, -0.11686548f, -0.05404761f, 
    -0.11310668f, 0.27114800f, 0.17513208f, -0.15002654f, -0.05852324f, -0.09821843f, 0.04244273f, 0.19641495f, 
    -0.26599795f, -0.03096493f, -0.21615714f, 0.04739619f, -0.01564983f, 0.28758049f, -0.60089862f, -0.44738573f, 
    0.13860412f, 0.07573441f, 0.16363397f, 0.24247007f, -0.00535116f, -0.23158650f, 0.07552543f, 0.15830091f, 
    -0.19446887f, 0.05548931f, -0.26980516f, -0.02915731f, -0.19083545f, 0.03008333f, -0.06096629f, -0.01339506f, 
    -0.07512431f, 0.18510161f, 0.27724004f, 0.15507250f, -0.11468020f, -0.17776237f, 0.04829561f, -0.02046066f, 
    0.01283772f, -0.00971209f, 0.28734416f, 0.15197554f, -0.04634535f, -0.00273495f, -0.00280235f, 0.01965232f, 
    -0.21943860f, 0.00662138f, 0.28387463f, 0.17577490f, 0.29745215f, 0.17483442f, 0.03574923f, -0.07596542f, 
    0.00317762f, 0.05703752f, -0.31437311f, -0.30599520f, 0.02074559f, 0.04599071f, 0.05935284f, -0.12732038f, 
    0.28040990f, 0.00838210f, 0.04913579f, 0.11104133f, 0.14370020f, 0.15942954f, -0.27969119f, -0.03078884f, 
    -0.03292466f, 0.24349917f, -0.14281759f, 0.04499463f, -0.27043262f, 0.03500047f, -0.22530204f, -0.11364374f, 
    -0.00014329f, 0.04513083f, 0.20156421f, -0.17699872f, -0.14210780f, 0.08974661f, -0.00216250f, -0.00339565f, 
    0.01174043f, 0.00507725f, -0.09706237f, -0.25858167f, 0.13923877f, 0.17101967f, 0.18435313f, 0.05165726f, 
    0.27421877f, -0.27291545f, 0.03160663f, 0.19159907f, 0.28181979f, 0.21143103f, 0.03462161f, 0.02667637f, 
    0.07648147f, 0.03231400f, 0.04214661f, -0.09138796f, -0.07891973f, 0.25586146f, -0.28788683f, 0.15314998f, 
    0.00626206f, 0.20145887f, 0.28610018f, -0.01231125f, 0.00709257f, 0.09740625f, 0.14195940f, -0.02014132f, 
    -0.00620402f, -0.03342214f, -0.03468456f, 0.19840772f, 0.30507243f, -0.11733273f, 0.14747681f, 0.02434050f, 
    0.12566009f, 0.10092226f, 0.24888840f, -0.19370055f, -0.16279292f, 0.03904139f, 0.07919782f, -0.03881457f, 
    -0.07168090f, 0.11351984f, -0.22829676f, 0.24712096f, -0.04147429f, 0.03255790f, 0.21082212f, 0.18250251f, 
    0.05736281f, -0.16826892f, 0.03191504f, 0.05857161f, 0.08015493f, 0.12835269f, 0.05886256f, 0.08028980f, 
    0.00785378f, -0.08890810f, -0.11867354f, -0.10231102f, -0.11033566f, -0.11834155f, -0.26696271f, -0.32329497f, 
    0.05897585f, -0.08381734f, -0.19655655f, -0.01035277f, -0.01494263f, -0.13392089f, 0.12776025f, 0.24084137f, 
    0.34436309f, 0.07536411f, 0.01644187f, 0.03663763f, -0.13904707f, 0.20024487f, 0.09252522f, -0.09676529f, 
    -0.08496271f, 0.25440136f, 0.01412410f, -0.27374890f, 0.10633027f, 0.19717169f, -0.00651711f, 0.27536660f, 
    0.00080934f, 0.06584626f, 0.16798905f, 0.12306038f, 0.00442419f, 0.04455558f, -0.17735523f, -0.10597213f, 
    -0.07054224f, -0.30281332f, 0.06752718f, 0.29006770f, -0.03105527f, 0.04802266f, 0.02734543f, -0.19753940f, 
    0.18296514f, 0.17490549f, 0.09102938f, -0.18721583f, -0.00011567f, -0.33729404f, 0.22985768f, -0.00475955f, 
    -0.01263684f, -0.03399762f, 0.14506182f, -0.07608969f, 0.33532771f, -0.14400809f, -0.08385685f, -0.01521521f, 
    0.13915867f, -0.31411132f, 0.12975508f, 0.17277019f, 0.01830494f, -0.19975087f, -0.05424435f, -0.13634217f, 
    0.30780727f, -0.01816646f, 0.16428043f, -0.07129519f, -0.22636814f, -0.38353655f, -0.03533050f, -0.14193413f, 
    -0.18765236f, -0.05741714f, 0.11011215f, 0.02211915f, 0.14348070f, -0.00394724f, 0.03381718f, 0.03448593f, 
    0.04496864f, 0.05585476f, -0.04380729f, 0.00528904f, 0.00273774f, 0.14449795f, 0.21006525f, 0.09912065f, 
    -0.01109944f, -0.27418169f, 0.19903985f, -0.06672940f, -0.02416652f, -0.00417721f, 0.06708702f, 0.17366180f, 
    0.00240331f, -0.19339584f, 0.08418424f, -0.23862210f, 0.11129118f, 0.06691621f, 0.04996170f, 0.05588229f, 
    0.27238688f, -0.06466744f, -0.65543312f, -0.19646819f, -0.07228475f, 0.03038038f, 0.21999480f, -0.00971427f, 
    -0.08168956f, -0.03101077f, -0.13409296f, -0.30637461f, 0.08803847f, -0.12560675f, 0.03523709f, -0.20774277f, 
    -0.08477554f, 0.24793468f, 0.16455697f, -0.06955417f, 0.43761712f, -0.07007363f, -0.02828122f, 0.36470005f, 
    -0.22539835f, -0.03449517f, 0.10272468f, -0.02879414f, -0.05110043f, 0.24300820f, -0.21574429f, 0.03874400f, 
    0.01314294f, 0.17424376f, 0.12285440f, 0.03937962f, 0.19465074f, -0.12927718f, 0.61819780f, 0.45233676f, 
    -0.04202747f, -0.06393834f, -0.05113167f, 0.10548394f, 0.09021437f, 0.05679457f, 0.19639660f, 0.31405145f, 
    -0.20252606f, 0.05164796f, 0.28237629f, 0.08542036f, -0.07853956f, 0.23961888f, -0.27169386f, -0.06375147f, 
    -0.28618175f, 0.26040909f, -0.20783167f, -0.04377790f, 0.00991601f, -0.03573512f, -0.08404993f, -0.08794435f, 
    -0.31034541f, -0.15367740f, 0.07721529f, -0.06051151f, -0.18352506f, -0.15098192f, 0.08433454f, 0.05281458f, 
    0.03701493f, 0.31040996f, -0.28249082f, 0.13675331f, 0.07769360f, 0.10307954f, 0.21313205f, -0.07845800f, 
    -0.26903915f, -0.03905728f, -0.07004702f, 0.71392339f, -0.31436762f, -0.11463592f, 0.09704751f, -0.27353975f, 
    -0.00185797f, 0.10376381f, 0.18264560f, -0.03389418f, 0.12366608f, 0.07783945f, -0.10352626f, 0.14182223f, 
    -0.08872151f, -0.14615141f, 0.03517229f, 0.19713636f, -0.07431671f, -0.15802740f, -0.05491031f, -0.13357329f, 
    -0.25677344f, 0.02343420f, 0.00853345f, 0.16486728f, -0.19003774f, -0.16506875f, -0.34287861f, 0.05484832f, 
    0.07068597f, 0.03394715f, 0.13215162f, 0.03182970f, -0.02667535f, 0.12032236f, -0.16837476f, 0.07197186f, 
    -0.15921274f, -0.20575204f, 0.14137939f, -0.04111929f, -0.00467806f, 0.17308687f, 0.06854695f, -0.17540973f, 
    0.41558027f, -0.15430290f, -0.28458202f, -0.02878699f, -0.02567134f, 0.07409223f, 0.04270080f, -0.00474942f, 
    -0.08003451f, -0.19831342f, 0.21670851f, -0.10842364f, -0.16375825f, -0.13139866f, 0.18869880f, -0.24147943f, 
    0.04059248f, -0.05178665f, 0.02181398f, 0.01610687f, -0.03411982f, 0.12114820f, 0.22388889f, -0.00761981f, 
    0.12440964f, -0.10762212f, -0.01302640f, -0.27044696f, -0.35683724f, -0.12271098f, 0.19057402f, -0.07918813f, 
    0.11157124f, -0.28136995f, 0.02727139f, -0.29605097f, -0.57311368f, 0.14559643f, 0.05569144f, 0.14454946f, 
    0.00069353f, 0.04096673f, -0.25640762f, 0.12807803f, 0.14206098f, 0.11210531f, 0.01966989f, -0.12363452f, 
    -0.07347515f, 0.07364737f, -0.09013131f, -0.11757131f, 0.01157117f, 0.11504399f, 0.78110480f, 0.03368308f, 
    0.00590260f, 0.21606939f, -0.06679018f, 0.00251846f, 0.20795068f, 0.04774969f, 0.33071363f, -0.14368887f, 
    0.08636602f, 0.02878462f, -0.11154187f, -0.10094736f, 0.05724918f, -0.13659298f, 0.13629261f, 0.00141255f, 
    0.09102450f, 0.03657116f, -0.07836279f, -0.29413792f, -0.01942838f, -0.18893006f, 0.04480658f, 0.13667844f, 
    -0.06247328f, 0.16412720f, 0.15684609f, -0.15051009f, -0.01243448f, 0.08628664f, -0.00781157f, -0.14355922f, 
    -0.07709078f, 0.03169673f, -0.03092709f, 0.13641873f, -0.09969942f, -0.06888106f, 0.18917970f, 0.02678882f, 
    0.14676303f, 0.08486225f, -0.05169751f, 0.61057144f, -0.35947996f, -0.09978783f, 0.12646510f, 0.17379637f, 
    0.08887017f, -0.01404635f, 0.20433028f, 0.22076842f, -0.61841297f, 0.09722367f, -0.08959638f, -0.02660066f, 
    0.05751846f, 0.04858735f, -0.08000906f, 0.16447303f, 0.13526392f, -0.58930588f, 0.43665463f, -0.09377147f, 
    0.08985668f, 0.15676154f, 0.13176721f, -0.40328187f, 0.17381465f, 0.01045439f, -0.48748732f, -0.37656295f, 
    -0.14134026f, 0.05676918f, 0.19887941f, -0.03903986f, -0.08447000f, -0.05835836f, 0.01209091f, -0.55497336f, 
    -0.07836143f, 0.07974075f, 0.03435646f, 0.00954954f, 0.19925313f, 0.05506494f, -0.04821356f, -0.01866654f, 
    -0.02615599f, -0.00848422f, -0.04719134f, 0.00058459f, -0.01509061f, 0.00477768f, -0.02013735f, -0.03477742f, 
    -0.02373956f, -0.01475741f, -0.05857786f, 0.01814196f, 0.00537241f, -0.06020040f, -0.03843952f, 0.04180473f, 
    -0.03075069f, 0.02848969f, -0.04762166f, 0.04661063f, 0.01699991f, -0.03501252f, -0.02952806f, 0.02379727f, 
    -0.05363394f, -0.00296360f, 0.00275816f, 0.04481605f, -0.00719940f, 0.01328001f, -0.04822894f, -0.05101122f, 
    -0.05169649f, 0.03274187f, -0.02815402f, 0.02057406f, -0.02732999f, 0.03132771f, -0.01593058f, -0.03690683f, 
    -0.03137747f, -0.00810457f, -0.06227518f, 0.00143372f, -0.03511330f, -0.02191519f, 0.00319813f, 0.00970737f, 
    0.04723196f, -0.06127890f, 0.04040428f, 0.03785338f, -0.02702054f, -0.04081172f, -0.02080234f, 0.04368905f, 
    -0.01448253f, -0.04838920f, 0.02319329f, -0.05936841f, -0.04183580f, -0.04923189f, 0.01899903f, -0.03376944f, 
    -0.00164985f, 0.02277540f, 0.04820602f, -0.06211022f, -0.01620301f, 0.00154293f, -0.04248598f, 0.04118010f, 
    -0.05930434f, -0.05500892f, 0.00541834f, -0.06350709f, -0.00010012f, -0.02943923f, -0.04425677f, -0.06224066f, 
    0.01155546f, -0.04545718f, 0.01127737f, 0.02731851f, 0.03042324f, -0.05528983f, -0.06139320f, -0.05470615f, 
    -0.03104076f, -0.00399238f, -0.00754763f, 0.00265563f, -0.01181850f, -0.01594358f, -0.03032125f, 0.02713415f, 
    0.00364905f, -0.06430697f, 0.01727237f, 0.01171790f, -0.06284608f, -0.04998366f, 0.04783669f, 0.04701192f, 
    0.04666522f, 0.00333034f, 0.03504455f, -0.04418402f, 0.03504337f, -0.04381618f, -0.03293283f, -0.01923711f, 
    -0.00867890f, -0.07071219f, -0.06466879f, -0.06080955f, -0.03394115f, -0.01357722f, 0.00748668f, -0.00975959f, 
    0.04559696f, -0.06072853f, -0.04335584f, 0.02627769f, -0.02438929f, -0.00495320f, -0.05318801f, -0.02391266f, 
    0.01882912f, 0.00152230f, 0.01955945f, 0.02161428f, -0.02746011f, 0.04168234f, -0.02196640f, 0.04312272f, 
    0.01444386f, -0.02177702f, 0.02703716f, -0.06303979f, -0.01971950f, 0.03624152f, -0.02105556f, 0.04440379f, 
    -0.04357216f, -0.06035006f, 0.02593233f, 0.00683872f, -0.00312580f, 0.00839593f, 0.02075519f, -0.04296242f, 
    0.03666001f, 0.04000339f, -0.00788451f, 0.01810614f, -0.05198050f, 0.04502045f, 0.03287347f, -0.02235964f, 
    -0.03281891f, -0.04425397f, -0.02030878f, -0.00737886f, 0.02475590f, -0.00803007f, 0.04143151f, -0.01123192f, 
    0.05591409f, -0.04197698f, 0.02820396f, 0.00191297f, -0.03897134f, -0.05672012f, 0.00828095f, 0.03749752f, 
    -0.02039680f, -0.01515701f, -0.00089612f, -0.01375096f, -0.06471281f, 0.04569765f, -0.04967038f, -0.01393411f, 
    -0.01401991f, -0.02184818f, 0.03638049f, 0.03221226f, -0.04682018f, -0.02378173f, -0.05482859f, -0.02127742f, 
    0.01370487f, -0.04110912f, 0.02891861f, -0.00363519f, -0.05520420f, -0.02786280f, -0.05213626f, -0.01901628f, 
    -0.01878808f, 0.00770771f, -0.01271588f, 0.02958657f, -0.00911576f, -0.02633611f, 0.02733119f, -0.02494116f, 
    -0.00377252f, -0.05016803f, -0.00491464f, 0.05012997f, 0.04223855f, -0.05328913f, 0.03487131f, 0.02826727f, 
    0.00929672f, -0.04491310f, 0.00492630f, -0.04421662f, 0.04771475f, -0.01451712f, 0.00588750f, 0.00664822f, 
    -0.02152477f, 0.02298380f, 0.00766041f, 0.01179722f, 0.00267241f, -0.06368729f, 0.03805391f, 0.04971224f, 
    -0.06231328f, 0.02975494f, -0.00748117f, 0.02871434f, -0.02784651f, 0.01275915f, -0.03925346f, 0.01540276f, 
    -0.03482393f, 0.01348518f, -0.04005522f, -0.03871441f, 0.03936196f, 0.03618210f, -0.02206070f, 0.02434785f, 
    -0.03733263f, -0.03765994f, -0.05590325f, -0.03225265f, 0.03674760f, -0.04662770f, -0.04567696f, 0.03034845f, 
    0.03177812f, 0.01063009f, -0.03706379f, -0.05052909f, 0.04036244f, -0.04719526f, 0.03253453f, -0.00930075f, 
    -0.04249529f, -0.06290822f, 0.03924554f, 0.04513864f, 0.03899187f, 0.02620625f, 0.02535317f, 0.00123441f, 
    -0.02651120f, 0.03795584f, 0.02859943f, -0.03667521f, -0.00362087f, -0.01665096f, 0.02895945f, -0.04499567f, 
    0.03202243f, -0.02081626f, 0.01067506f, 0.03860122f, -0.03913328f, 0.01908438f, 0.03908997f, -0.05014617f, 
    0.05153093f, 0.02945320f, -0.01384985f, -0.00003611f, -0.01406263f, -0.02742627f, -0.04368238f, -0.05291810f, 
    -0.04994424f, -0.05089537f, -0.03472329f, 0.03789032f, -0.05520588f, -0.02485926f, -0.03133456f, -0.04757148f, 
    0.04919367f, -0.00053972f, 0.05280577f, -0.03221354f, -0.01954743f, -0.06047158f, 0.03646278f, 0.01405825f, 
    0.01298376f, -0.04920814f, -0.06214804f, -0.05458125f, -0.01535240f, -0.06002449f, 0.02755692f, -0.05810629f, 
    -0.00576508f, -0.05560219f, -0.03273750f, 0.02593437f, -0.04864614f, 0.00991878f, 0.04714275f, -0.00985230f, 
    -0.05333711f, 0.00324336f, 0.02945656f, -0.05948242f, -0.03082130f, -0.01289110f, 0.00491599f, -0.01264461f, 
    -0.05717947f, 0.01255249f, 0.03038133f, -0.02221143f, -0.00373514f, -0.04649579f, 0.01716803f, -0.06047669f, 
    0.01433051f, 0.00831939f, -0.05533483f, -0.00686360f, 0.03394532f, -0.03058787f, 0.01627848f, -0.04418616f, 
    0.00989642f, -0.03237620f, -0.05311086f, -0.04663830f, 0.02704534f, 0.01220824f, -0.00777827f, -0.00803290f, 
    -0.02173650f, -0.05922063f, -0.01316146f, -0.03713961f, -0.05322596f, 0.04401817f, -0.01355460f, -0.01070876f, 
    0.00837746f, -0.03123166f, 0.03551697f, -0.04753587f, 0.03935594f, -0.06190419f, -0.00548746f, -0.01525297f, 
    0.00238905f, 0.02682320f, 0.01566697f, -0.03072064f, -0.05091986f, -0.04076399f, -0.05365264f, -0.01283615f, 
    -0.05472740f, -0.00321964f, -0.05574561f, -0.00111410f, -0.02666998f, -0.05292793f, -0.04253195f, -0.00494233f, 
    0.00319371f, -0.03844706f, -0.00559279f, -0.05149775f, -0.01743529f, -0.04212079f, 0.04616345f, -0.02867032f, 
    0.00825090f, -0.05722465f, -0.06142798f, 0.02784832f, 0.04972227f, 0.04277488f, 0.00756940f, -0.04154550f, 
    0.01143945f, 0.04790817f, 0.02527720f, -0.02530792f, -0.02174862f, 0.05130794f, 0.00003179f, -0.05187323f, 
    -0.00017096f, -0.03486526f, 0.04422002f, 0.05572528f, 0.02527025f, -0.00890043f, -0.00946969f, -0.03594097f, 
    0.01959510f, -0.00271535f, -0.04829712f, 0.03132526f, 0.01001254f, -0.04359969f, -0.02270181f, 0.04959321f, 
    -0.05122124f, 0.01581616f, -0.03066551f, -0.05945694f, -0.01314358f, 0.00786524f, 0.02920045f, 0.01751814f, 
    -0.02412053f, -0.02096093f, 0.00310725f, 0.00694686f, -0.05267498f, 0.02479805f, 0.04342040f, 0.03231616f, 
    -0.01891165f, 0.01740861f, 0.04439879f, 0.02045011f, -0.04179901f, 0.01455236f, -0.02108282f, -0.05524521f, 
    0.04871888f, 0.02803381f, -0.02522494f, -0.00466982f, -0.05078568f, 0.02842444f, -0.04301670f, 0.02799647f, 
    -0.03737612f, 0.02727753f, 0.02717381f, 0.00243437f, 0.01571830f, 0.02390753f, -0.02866125f, 0.01584575f, 
    -0.02546268f, -0.00525679f, 0.04713736f, 0.00588262f, -0.01462962f, 0.00557905f, -0.01031310f, -0.00098989f, 
    -0.02940793f, 0.02087611f, 0.00972912f, 0.02193594f, 0.03198903f, -0.01323932f, -0.06180625f, 0.02380270f, 
    0.00538836f, 0.01036113f, -0.06300876f, -0.02332042f, -0.03169571f, -0.03484518f, -0.01521245f, 0.00875419f, 
    -0.02205027f, 0.04637099f, 0.00290867f, 0.04724621f, 0.01226454f, 0.00576374f, -0.05100961f, 0.00941897f, 
    0.04382210f, 0.03531051f, 0.02068992f, -0.01752418f, 0.05307298f, 0.03248971f, 0.00825665f, 0.00237715f, 
    -0.05034391f, -0.02199490f, 0.01984304f, 0.03079600f, 0.00053787f, 0.02806907f, -0.01079506f, -0.05336040f, 
    -0.05469190f, -0.04890909f, -0.02395888f, -0.05961562f, 0.03606766f, 0.04594501f, -0.03318178f, -0.01124000f, 
    -0.03700300f, -0.04491785f, -0.04250796f, -0.00099448f, -0.05553742f, 0.03185485f, -0.01915631f, -0.04003920f, 
    0.04979856f, -0.06242897f, -0.04278757f, 0.02903112f, 0.00744309f, -0.01932564f, -0.02116034f, 0.02637771f, 
    0.02411138f, -0.00615133f, 0.00327761f, -0.00013956f, 0.04476429f, 0.02086851f, -0.05046839f, 0.03388445f, 
    0.02029455f, 0.01981468f, 0.04590812f, 0.01840856f, -0.00263840f, -0.05593281f, -0.00803048f, 0.01581330f, 
    -0.02673095f, 0.03638950f, -0.00046350f, 0.03292012f, 0.05054147f, 0.04207043f, -0.06095781f, -0.04132696f, 
    0.02825687f, -0.06391530f, -0.05541584f, -0.05273191f, -0.01436837f, -0.00149377f, 0.03237451f, -0.04300253f, 
    -0.05948132f, 0.01553063f, -0.00190381f, -0.03753303f, 0.01200257f, 0.01071974f, -0.00204398f, -0.02324839f, 
    -0.00289607f, 0.03806328f, -0.04756516f, -0.02286162f, -0.00852853f, -0.01770913f, -0.04566779f, 0.01784129f, 
    -0.00712076f, -0.04413417f, -0.02448492f, 0.05050844f, -0.00305158f, -0.00687125f, 0.01122727f, -0.00826693f, 
    -0.02131184f, -0.06253842f, 0.03777104f, -0.05608503f, -0.03849645f, -0.03809948f, -0.01821102f, -0.03050917f, 
    0.00487538f, -0.01290418f, -0.02986927f, -0.01085762f, -0.06148761f, 0.00270547f, -0.04153265f, 0.03661893f, 
    0.01535025f, -0.04217318f, -0.02336721f, -0.00385915f, 0.00525724f, -0.04466136f, -0.01588318f, -0.00098726f, 
    0.01461255f, 0.01879449f, 0.04392599f, 0.01976706f, 0.01226364f, 0.01030322f, -0.02977209f, 0.03463450f, 
    0.02377640f, -0.05617800f, 0.03905589f, 0.02178231f, 0.02429607f, -0.02850216f, -0.00314051f, 0.01036642f, 
    -0.03360595f, 0.03229421f, -0.00216702f, 0.00828983f, 0.02030389f, -0.00440481f, -0.04659227f, -0.06983503f, 
    -0.04343709f, -0.02156671f, -0.00475552f, -0.03474325f, -0.04499086f, -0.03732013f, -0.03814619f, -0.04946358f, 
    0.01230984f, -0.00055250f, 0.03188902f, -0.00787986f, 0.00769893f, -0.04848043f, 0.00412245f, -0.03963684f, 
    -0.06307292f, 0.00317682f, 0.03917174f, 0.01893591f, -0.02339688f, 0.04416689f, -0.03295761f, -0.05540576f, 
    -0.04125967f, 0.05005331f, -0.03611868f, 0.03812448f, -0.03115605f, 0.04192854f, -0.04539949f, -0.01872487f, 
    -0.03392897f, -0.01298578f, 0.00892481f, -0.00992630f, -0.05980123f, 0.02835259f, -0.00544592f, 0.00450762f, 
    0.03409563f, -0.05287075f, -0.00773903f, 0.04088785f, 0.01873000f, -0.04110788f, 0.00907387f, 0.02135867f, 
    -0.05483337f, -0.01538300f, 0.00020059f, -0.05976887f, -0.01462942f, -0.06882172f, -0.02424688f, -0.00566878f, 
    0.04176600f, -0.04024951f, 0.01258012f, -0.03221182f, -0.01580826f, -0.01582571f, -0.01880309f, -0.01129214f, 
    -0.03953574f, -0.00835008f, -0.06574626f, 0.02213449f, -0.05618067f, 0.02625787f, -0.03347345f, -0.03325029f, 
    -0.05319702f, 0.03900002f, -0.02383044f, -0.02762273f, 0.04765017f, 0.00923423f, -0.03021636f, 0.01745203f, 
    -0.00261260f, -0.00464288f, -0.03585633f, -0.02130737f, 0.01685270f, -0.01871620f, 0.00825393f, -0.02199058f, 
    -0.00385811f, -0.00488974f, 0.02663865f, 0.03641447f, 0.03764790f, -0.01301766f, -0.01449711f, 0.03643569f, 
    -0.02823142f, -0.01036655f, 0.03622730f, -0.05106353f, -0.03564226f, -0.06019127f, 0.01650790f, -0.04755444f, 
    -0.04504894f, -0.04765318f, -0.03261593f, -0.03578642f, -0.05750693f, -0.00760958f, 0.00809990f, 0.01037897f, 
    -0.04559713f, 0.01009810f, 0.02398207f, -0.03254531f, -0.00011966f, -0.01845413f, -0.04934321f, 0.00182827f, 
    -0.01298977f, 0.01324422f, 0.01392637f, -0.01080419f, -0.01357370f, -0.01664101f, 0.04095730f, -0.02279152f, 
    0.04142245f, -0.01271691f, -0.06863632f, -0.03128582f, 0.03708005f, -0.03186640f, 0.04750642f, 0.01730936f, 
    0.04110041f, 0.03177944f, 0.01803144f, 0.03142828f, -0.03574797f, -0.02269050f, 0.01194511f, 0.03637991f, 
    0.00832249f, -0.03054550f, 0.03317487f, 0.02270588f, 0.04336747f, 0.03715600f, -0.02093501f, -0.01706116f, 
    -0.01070264f, -0.03531394f, 0.01526844f, -0.04834503f, 0.00455294f, 0.00307554f, -0.05721539f, -0.02413905f, 
    -0.01110414f, 0.02966547f, -0.02891980f, -0.00922655f, -0.00387019f, 0.03943163f, 0.03280435f, -0.06766605f, 
    -0.04385809f, 0.03024805f, 0.01724452f, -0.00269101f, -0.05935029f, -0.04441679f, -0.06459935f, -0.01096924f, 
    -0.04568352f, -0.02972937f, -0.02928146f, 0.00102000f, 0.04046192f, -0.06132143f, 0.02840203f, -0.03547620f, 
    0.04195096f, 0.00441965f, 0.00824338f, 0.01345939f, 0.03527938f, 0.00780998f, -0.02715431f, -0.01083401f, 
    0.03120053f, 0.03150165f, -0.03459378f, 0.00688551f, -0.01597664f, 0.04235156f, -0.06810586f, 0.00480929f, 
    -0.01334300f, 0.02606968f, -0.05011019f, 0.01327849f, -0.04141437f, -0.04500352f, -0.00698864f, -0.00808095f, 
    -0.02239101f, -0.02081341f, 0.03157049f, -0.05270017f, 0.00943397f, 0.04334734f, -0.05062067f, 0.01663265f, 
    0.38474298f, 0.15611972f, 0.02129842f, -0.02448569f, -0.07592088f, -0.08164336f, 0.13340491f, 0.09636236f, 
    0.10149127f, -0.33538172f, 0.03783276f, 0.03951298f, 0.12863791f, -0.17044733f, 0.07828926f, -0.07658295f, 
    -0.27352434f, -0.16139112f, 0.23105137f, 0.11984012f, 0.23382330f, 0.12116788f, -0.22330263f, 0.04436706f, 
    0.20924826f, -0.06508506f, -0.18740563f, 0.24452774f, -0.08653171f, 0.24888684f, -0.08526147f, 0.07851077f, 
    -0.20644516f, 0.16863547f, 0.10300484f, 0.00629015f, -0.08910655f, 0.07481140f, 0.07442083f, -0.11271901f, 
    0.10977977f, -0.04124447f, -0.10118541f, 0.07342951f, -0.10080191f, -0.16227981f, -0.07055514f, -0.23468962f, 
    0.10391062f, -0.10459444f, 0.01865719f, -0.07825020f, -0.04459406f, -0.04764859f, -0.04995729f, -0.28054202f, 
    0.12281535f, -0.08994766f, -0.02757219f, 0.09274226f, -0.13632482f, 0.03765806f, 0.05186709f, 0.54839581f, 
    -0.00408576f, 0.22077370f, 0.13869964f, -0.06361188f, -0.25423372f, -0.22740154f, 0.03876226f, -0.16103816f, 
    -0.04719295f, -0.05502578f, -0.02392140f, -0.11612185f, 0.08816414f, -0.13359839f, -0.03709939f, -0.03315695f, 
    -0.11759636f, -0.18694620f, 0.27860677f, 0.22200525f, 0.20547365f, -0.07307062f, -0.13071282f, -0.13322599f, 
    0.02954283f, -0.03602741f, -0.16726330f, 0.18156110f, 0.28370836f, 0.06103922f, -0.12905957f, 0.15863165f, 
    0.09069756f, 0.09554835f, 0.14198652f, -0.05106953f, -0.22698921f, 0.08158658f, -0.02263450f, 0.00396642f, 
    -0.09674533f, 0.16082592f, 0.00723650f, -0.10193621f, 0.29530433f, 0.08846267f, 0.08640018f, -0.15376061f, 
    -0.28482530f, -0.14916225f, 0.00103941f, 0.14719889f, 0.12741835f, 0.13615614f, 0.03890757f, 0.16489172f, 
    0.15979423f, -0.00470316f, -0.26522630f, 0.16787365f, 0.03256211f, -0.11635730f, -0.06268915f, -0.14672974f, 
    -0.11167997f, -0.10181013f, 0.20420724f, 0.16845118f, -0.11005430f, -0.15215789f, -0.59594369f, 0.24315344f, 
    0.18774688f, 0.05889926f, 0.00880680f, -0.12399442f, 0.09971034f, 0.16757852f, 0.08586990f, -0.00625918f, 
    -0.01031226f, 0.11907496f, -0.00557392f, 0.18650927f, 0.01698724f, -0.15747750f, 0.08871835f, -0.01076346f, 
    -0.04318576f, -0.17107770f, -0.06621452f, 0.44271454f, -0.02908628f, 0.00099746f, 0.23219894f, 0.17454848f, 
    0.00934125f, 0.20063412f, -0.25698105f, -0.06644700f, 0.24764931f, 0.23165216f, -0.00233886f, 0.12433404f, 
    0.04234866f, -0.03171852f, -0.19427454f, 0.05116960f, 0.12631828f, -0.45077375f, 0.00095070f, 0.03359494f, 
    0.02741354f, -0.05603092f, -0.09029399f, -0.19692680f, 0.00557345f, 0.12522888f, 0.09335505f, 0.00558254f, 
    -0.21196684f, 0.13366076f, 0.10327829f, -0.19354069f, -0.02309149f, -0.06443265f, 0.29697543f, 0.03135873f, 
    -0.31834954f, -0.02638349f, -0.02334972f, -0.08377902f, 0.09189983f, 0.09476728f, -0.26253882f, -0.39393696f, 
    -0.04439790f, 0.03216280f, 0.34341249f, 0.03552134f, 0.02130135f, -0.05112283f, -0.20041926f, -0.41831604f, 
    0.14368077f, 0.29408804f, 0.16468863f, -0.02548206f, 0.32152122f, -0.08388518f, 0.10064221f, 0.38227448f, 
    0.00246784f, -0.04038043f, -0.16387589f, 0.09736314f, -0.17094442f, -0.16026227f, 0.18844348f, 0.10369359f, 
    0.18868731f, 0.16901004f, 0.29524627f, -0.08956941f, -0.26065308f, -0.06388041f, -0.21755366f, 0.13594544f, 
    -0.05124149f, 0.16955814f, -0.14757657f, -0.01219970f, 0.12358546f, 0.09210099f, -0.04002809f, -0.05677176f, 
    -0.11441097f, 0.02415235f, 0.27419278f, -0.49454221f, 0.03343749f, 0.24163041f, 0.04931309f, -0.28576943f, 
    0.33855200f, 0.02654557f, -0.01862754f, -0.09996317f, -0.02114025f, 0.01600703f, 0.21496908f, 0.07925463f, 
    0.07517377f, 0.37179989f, -0.06210774f, -0.08863229f, -0.22122067f, -0.24141599f, 0.17931773f, 0.23188186f, 
    0.04299281f, 0.01966242f, -0.07207952f, 0.17447639f, -0.13402110f, 0.20006476f, -0.18379171f, -0.00269627f, 
    -0.40715477f, 0.04797618f, -0.17129739f, 0.08215044f, -0.03044869f, 0.10715201f, -0.03255051f, 0.35350364f, 
    -0.40611327f, -0.24332105f, -0.15200342f, 0.29008618f, 0.06936160f, -0.13773829f, -0.23186812f, -0.38576227f, 
    0.16458641f, -0.02124813f, -0.36628664f, -0.08338303f, 0.19005452f, 0.22940211f, -0.16553885f, 0.37042254f, 
    -0.17887188f, 0.06210960f, -0.09716754f, -0.03609923f, -0.29654080f, 0.03679241f, -0.02637259f, -0.29829466f, 
    -0.04337583f, 0.16389692f, 0.08630391f, 0.09218420f, -0.22417101f, 0.08622604f, 0.33329722f, 0.05844676f, 
    0.09549549f, -0.29488584f, -0.22222823f, -0.36436456f, -0.11541523f, 0.18308094f, 0.10148331f, 0.17997013f, 
    0.02991174f, 0.00690472f, -0.09720295f, -0.00840945f, -0.63458687f, -0.20790932f, -0.17371006f, 0.08311771f, 
    -0.06282502f, -0.10301390f, -0.30966365f, 0.12340339f, 0.08227880f, -0.33732808f, -0.19491461f, -0.21849632f, 
    -0.08474471f, -0.23780558f, -0.05030082f, 0.12021483f, 0.04422159f, -0.19918257f, -0.47497061f, 0.11107213f, 
    -0.03979668f, -0.15602799f, 0.00479523f, -0.06783335f, 0.15055583f, -0.16458707f, 0.14075881f, -0.06040251f, 
    -0.31896690f, 0.05462796f, -0.13428262f, -0.03555187f, 0.13477071f, 0.00169371f, 0.48577178f, -0.13855310f, 
    0.06483290f, -0.01144761f, 0.15769023f, 0.00242027f, 0.04559368f, -0.14661814f, -0.04713827f, 0.02320602f, 
    0.11046714f, 0.10642996f, -0.14846817f, -0.16189981f, -0.05999862f, -0.16715895f, 0.01762551f, -0.07643853f, 
    0.13961489f, 0.06405018f, 0.33333904f, -0.12753534f, 0.12383147f, -0.07701724f, 0.03436957f, 0.07106048f, 
    -0.04174823f, 0.29050237f, 0.28131860f, -0.07822092f, -0.09534550f, -0.10212319f, -0.32778862f, -0.04245554f, 
    0.12653247f, -0.14873546f, 0.01793069f, 0.27900335f, 0.13518932f, 0.14439929f, 0.19085047f, -0.08262338f, 
    -0.01874475f, 0.05800472f, 0.02676909f, -0.00445506f, 0.11465178f, 0.31557420f, 0.14707077f, -0.09755987f, 
    -0.10472495f, -0.07186576f, -0.07068174f, 0.17119327f, 0.09586056f, 0.19612169f, -0.23481573f, 0.06845761f, 
    0.11063337f, 0.01936199f, 0.11924799f, -0.03763754f, 0.17978044f, 0.00190518f, 0.04731863f, 0.30731797f, 
    -0.01612078f, 0.01412927f, -0.20671052f, -0.01041136f, -0.21511853f, -0.03952739f, -0.04685115f, -0.00672939f, 
    -0.04076795f, 0.43672779f, -0.15634471f, 0.15501443f, 0.17437282f, -0.00206933f, -0.11115111f, -0.00583188f, 
    0.22727785f, 0.08490812f, -0.23024604f, 0.00680768f, -0.10598201f, -0.03786734f, -0.00221968f, -0.02821318f, 
    -0.24735190f, -0.19090328f, 0.32096314f, 0.12080971f, 0.05157211f, -0.05752385f, -0.03223732f, 0.17748700f, 
    0.06236547f, 0.16537464f, 0.22709215f, 0.11654550f, 0.08050793f, 0.25156415f, -0.27658170f, 0.10469990f, 
    0.29334077f, -0.03210031f, -0.00681382f, -0.02654866f, 0.38480681f, 0.15443493f, -0.32321614f, 0.03040379f, 
    0.12667321f, 0.12671527f, 0.26770145f, -0.00713138f, -0.10437092f, 0.31416082f, -0.02637183f, 0.06770524f, 
    0.06744827f, 0.00949173f, 0.07606638f, 0.12514637f, 0.07527065f, -0.18230492f, -0.52026808f, 0.02293534f, 
    -0.17916079f, 0.06809723f, -0.03832535f, 0.14559978f, -0.02747841f, 0.04195195f, -0.04649201f, 0.20862530f, 
    -0.23460634f, -0.05287322f, 0.35336199f, -0.00463569f, 0.13262357f, -0.06581631f, 0.37669215f, -0.16267215f, 
    0.38597259f, -0.19456762f, 0.16078174f, -0.11982991f, 0.13882218f, 0.56256258f, -0.08793979f, -0.00429558f, 
    -0.14508255f, -0.00641202f, -0.18818784f, 0.08109462f, -0.02663220f, -0.11819693f, 0.31964293f, 0.22103295f, 
    0.13052183f, -0.07859509f, 0.29753673f, -0.20947357f, 0.06648184f, -0.01562785f, 0.20210087f, 0.18484646f, 
    -0.29215643f, -0.21938542f, 0.10408775f, -0.41028067f, 0.29838154f, 0.06702057f, 0.06729139f, 0.06496017f, 
    -0.05514773f, 0.07030734f, -0.01906228f, -0.04131109f, 0.30358246f, -0.02534958f, 0.11359824f, -0.00667201f, 
    0.15554625f, 0.18307479f, 0.01747727f, -0.01162665f, -0.17679390f, -0.22078834f, -0.09845128f, 0.17374314f, 
    -0.09566163f, -0.16336210f, 0.12735200f, -0.19658947f, 0.05995849f, 0.10855544f, 0.26156542f, 0.11963847f, 
    -0.10262926f, -0.00441361f, 0.02353038f, 0.14225608f, 0.26673901f, 0.17392564f, -0.16416280f, 0.15505211f, 
    -0.01745309f, 0.07925244f, -0.18801381f, -0.14044857f, 0.05232994f, 0.12753095f, 0.01557173f, -0.18666542f, 
    -0.04225908f, -0.00909289f, 0.04019598f, 0.04101879f, -0.03152085f, 0.02072063f, 0.00503721f, -0.03118378f, 
    -0.01411967f, -0.03512276f, -0.06628253f, -0.03675086f, -0.03366515f, 0.02753101f, -0.05642487f, 0.04029123f, 
    -0.02736568f, -0.05434787f, -0.04704483f, 0.02669911f, 0.00765673f, -0.01176152f, 0.05054165f, -0.03442828f, 
    -0.01586471f, -0.01313311f, -0.06733510f, 0.03225432f, -0.05417722f, 0.00505670f, 0.02095583f, -0.01206399f, 
    0.02144735f, 0.02472167f, 0.04847663f, 0.03793692f, 0.00745244f, -0.04088337f, 0.02911062f, 0.04647126f, 
    0.04267781f, -0.05055356f, -0.00225493f, -0.01624875f, 0.03112483f, 0.04469036f, 0.01178063f, -0.05133040f, 
    -0.06157123f, -0.04906574f, -0.04692458f, 0.03417047f, -0.01760865f, 0.03130731f, -0.01053198f, -0.05281503f, 
    -0.03263819f, 0.03366750f, -0.04042968f, -0.00439251f, 0.02590861f, -0.04061603f, -0.05616206f, -0.05743230f, 
    -0.01754669f, 0.01643214f, -0.02762101f, -0.05346215f, 0.02334481f, -0.05384018f, 0.00175824f, -0.00155614f, 
    0.02399606f, -0.05053144f, -0.01057572f, 0.03047847f, 0.02004668f, -0.00185390f, -0.00237682f, -0.06637876f, 
    -0.01219332f, -0.04558247f, -0.05498385f, -0.06595233f, -0.00872541f, 0.01954428f, 0.03567384f, 0.00186385f, 
    -0.01539095f, 0.01509976f, 0.03943333f, 0.01141226f, 0.01130355f, -0.05021025f, 0.01471463f, 0.03531432f, 
    0.00089735f, -0.00585549f, -0.01501202f, 0.00997309f, -0.01538490f, -0.04619164f, -0.06348684f, -0.05264070f, 
    -0.01220950f, 0.02391100f, -0.01071112f, -0.01933067f, 0.04192019f, -0.03902030f, 0.00005092f, -0.01187587f, 
    0.01326095f, 0.00095361f, -0.04246152f, 0.03323536f, 0.03062420f, 0.00227427f, 0.00846834f, -0.05313870f, 
    0.02703081f, -0.05528518f, 0.04008172f, -0.06820665f, -0.03027301f, -0.01067599f, 0.02221806f, -0.01005051f, 
    0.01510637f, -0.02793391f, 0.01833147f, -0.00523115f, -0.05412083f, -0.05082137f, 0.04900827f, -0.00643840f, 
    -0.04346197f, -0.05306743f, -0.04864222f, -0.02466871f, 0.02408544f, -0.02648169f, -0.01306396f, -0.01465383f, 
    0.01860257f, -0.06708014f, -0.05230518f, 0.00701067f, 0.02406036f, -0.03322339f, -0.07078876f, -0.00846089f, 
    -0.03279932f, -0.05154857f, -0.00252518f, 0.03199122f, -0.03168321f, 0.01798142f, -0.02893009f, 0.02211935f, 
    0.03610668f, 0.04701497f, 0.00728622f, -0.03984720f, 0.04198641f, 0.02136004f, -0.01096209f, 0.04614730f, 
    -0.03753327f, -0.04678393f, 0.04742135f, 0.02802392f, 0.00865025f, -0.00856154f, 0.04405019f, 0.02694700f, 
    0.00673051f, -0.05269337f, -0.06198648f, -0.00670859f, -0.06441019f, -0.05098493f, 0.00054468f, -0.04368016f, 
    -0.04304742f, 0.00873302f, 0.02822060f, -0.05822940f, 0.03060449f, -0.02867065f, -0.02046840f, -0.01725977f, 
    -0.05843820f, 0.03906162f, 0.02052047f, 0.00457265f, -0.00999134f, -0.02640556f, -0.05337743f, 0.02847810f, 
    0.04529633f, -0.01348615f, 0.00279669f, -0.01804248f, 0.00161918f, -0.02648548f, 0.03516251f, -0.02494622f, 
    -0.05191069f, -0.05377952f, 0.03921649f, -0.02432906f, -0.00529798f, -0.02123907f, 0.03869906f, 0.04566490f, 
    -0.05437216f, 0.03285319f, 0.02127479f, -0.00907935f, 0.02855943f, 0.02687810f, -0.04147418f, -0.02751541f, 
    -0.02972786f, 0.02228920f, 0.03517712f, -0.03438106f, -0.06233582f, -0.04476656f, 0.05102296f, 0.00509634f, 
    0.03673290f, -0.03972837f, 0.01072585f, -0.06387671f, 0.03241705f, -0.01559031f, 0.00923349f, 0.00311802f, 
    -0.06060858f, -0.04773602f, -0.06421907f, -0.04574553f, -0.02469230f, -0.01786669f, -0.04675399f, 0.03122533f, 
    -0.03660061f, -0.01400003f, 0.04662061f, -0.05037031f, 0.01510915f, 0.01003079f, -0.01083838f, -0.00579307f, 
    -0.00185717f, 0.04603632f, 0.02674709f, -0.05441326f, -0.04170876f, -0.00650239f, -0.05493539f, -0.02789168f, 
    0.03296540f, -0.02880095f, -0.06018262f, 0.02610244f, -0.01761358f, 0.04769109f, -0.02336354f, 0.00568327f, 
    0.04269237f, -0.04759300f, 0.01365850f, -0.01648922f, -0.03477772f, -0.01056263f, -0.06435722f, -0.06457438f, 
    -0.02279204f, -0.03050008f, 0.02977767f, 0.00561357f, -0.06321131f, -0.03508094f, -0.01532076f, -0.00628128f, 
    0.30958238f, 0.02290547f, 0.07937303f, -0.03905755f, 0.10216966f, 0.00014796f, -0.08756682f, -0.13826789f, 
    -0.07868809f, -0.38618633f, 0.12731482f, -0.14645706f, -0.01001712f, 0.12921683f, 0.08565384f, 0.24448091f, 
    -0.08201294f, 0.10246064f, 0.52324873f, 0.03215863f, 0.00517050f, -0.21237995f, -0.02199027f, 0.10232156f, 
    -0.04636737f, 0.07230876f, 0.00454314f, 0.77687699f, -0.03759762f, -0.17588322f, 0.05006037f, -0.01331250f, 
    0.00548547f, 0.03066440f, -0.01742851f, 0.07941151f, 0.17286056f, 0.05357224f, 0.05514028f, 0.03061555f, 
    -0.08427817f, -0.02498502f, -0.01869692f, 0.14332134f, -0.22687009f, -0.02042063f, -0.15020527f, -0.05375879f, 
    -0.03306266f, 0.18243876f, -0.10484174f, -0.00809727f, 0.04533039f, -0.26154301f, -0.28823799f, 0.65273488f, 
    0.03787322f, 0.20849049f, 0.19599441f, 0.05842660f, 0.05191334f, 0.01404715f, -0.17829981f, 0.20806806f, 
    0.24348527f, -0.13485415f, -0.00196567f, 0.25224575f, -0.04940144f, -0.25528157f, -0.09054634f, -0.04289669f, 
    0.51332533f, 0.14004263f, -0.19819444f, 0.01629478f, -0.02434195f, -0.01536410f, 0.00861143f, 0.03197021f, 
    -0.08536875f, 0.50249720f, -0.09327688f, -0.22466628f, -0.29649988f, 0.30307513f, 0.02175364f, -0.20978719f, 
    0.06176180f, -0.09898669f, -0.12703705f, 0.01618441f, -0.06417363f, 0.04187712f, -0.17958653f, 0.00674787f, 
    0.12717447f, -0.14724626f, 0.19477525f, -0.09624802f, 0.18932961f, -0.02990139f, 0.03567009f, 0.23158550f, 
    0.14566788f, -0.02903624f, 0.13201766f, 0.05100494f, -0.40414712f, -0.52388692f, 0.11562140f, 0.02291350f, 
    0.09801728f, -0.16711269f, 0.02628603f, 0.11340807f, 0.06307629f, 0.24748097f, 0.16978236f, -0.09919876f, 
    -0.01810003f, -0.07905808f, -0.08866408f, 0.01403174f, 0.10957588f, 0.02077803f, -0.21921070f, -0.06194356f, 
    -0.07732800f, -0.02513399f, -0.15955709f, 0.29989478f, -0.02442310f, -0.03399885f, -0.12999584f, -0.45654553f, 
    -0.35532761f, 0.16183881f, -0.18815145f, 0.02624077f, -0.01764316f, 0.01414189f, 0.10073064f, 0.11283382f, 
    0.33876202f, -0.02676169f, -0.06589416f, 0.08599168f, -0.13161309f, -0.12894492f, -0.14574020f, -0.12109208f, 
    0.11656879f, -0.09100425f, -0.10420422f, -0.20039424f, -0.22768654f, -0.04461229f, 0.03814270f, -0.19041727f, 
    0.03960341f, -0.08085070f, 0.43510795f, 0.18475236f, 0.14808321f, -0.10988086f, -0.06200665f, -0.14289348f, 
    -0.12076160f, -0.18326837f, -0.11923055f, -0.57264078f, 0.05529470f, 0.04114993f, 0.24476953f, -0.02827380f, 
    -0.08512271f, -0.12166017f, 0.01712625f, 0.10489152f, 0.55847651f, 0.03068795f, -0.33943525f, -0.40554178f, 
    -0.02188804f, 0.04214665f, -0.19084468f, -0.11211678f, -0.13865378f, 0.31098145f, -0.50549871f, 0.02162445f, 
    -0.07446269f, -0.11598781f, 0.15132937f, -0.00097322f, -0.13435403f, -0.06407420f, -0.28641835f, 0.18471020f, 
    0.05591448f, 0.10091433f, 0.14273843f, 0.21741828f, -0.02129857f, 0.14657174f, -0.06342049f, 0.11303544f, 
    -0.26623172f, 0.11285163f, -0.02982970f, -0.12203797f, -0.04266581f, 0.10148127f, 0.00879492f, 0.21014035f, 
    -0.45485589f, -0.05587487f, 0.06719103f, 0.11306049f, -0.15575790f, 0.03462728f, 0.17493336f, -0.00460658f, 
    -0.02257118f, -0.08924884f, -0.37550274f, 0.33816952f, 0.22502990f, -0.05745401f, 0.14481376f, -0.28298390f, 
    0.00853712f, 0.03852982f, -0.03736698f, -0.08805756f, 0.30128688f, -0.21671946f, 0.12278254f, -0.01974720f, 
    -0.01745586f, -0.01241124f, -0.09903184f, 0.02252224f, 0.19986372f, -0.04240806f, 0.17560868f, -0.21022110f, 
    0.11550985f, -0.22997288f, 0.25105432f, 0.23049070f, 0.23298870f, -0.10701970f, -0.07006916f, -0.21062736f, 
    -0.31365824f, 0.10884139f, 0.08573965f, -0.02253247f, 0.08618370f, 0.20667171f, -0.02155337f, -0.31483236f, 
    -0.33295691f, -0.00984586f, 0.17245510f, -0.12887067f, -0.01987336f, -0.10212066f, -0.03043652f, -0.22124374f, 
    0.18064569f, 0.23463136f, 0.07269572f, -0.08786748f, -0.00168159f, 0.10582232f, -0.09523007f, 0.00732773f, 
    -0.15874520f, 0.02939404f, -0.06486581f, -0.07089861f, -0.05842675f, -0.04454281f, -0.02775898f, -0.02559790f, 
    -0.15733930f, -0.39631718f, -0.39448327f, -0.12041595f, 0.22874379f, -0.13872497f, 0.00924587f, -0.04071734f, 
    0.15535989f, 0.13691126f, 0.01476126f, -0.05648874f, -0.23212139f, -0.03582143f, -0.03983507f, -0.01698097f, 
    0.23026283f, 0.01314282f, 0.39353377f, 0.03675280f, -0.13546818f, 0.13522348f, 0.12292381f, 0.04309207f, 
    -0.00210540f, 0.07134838f, -0.04442422f, -0.21830523f, -0.14519057f, 0.09608340f, -0.03577191f, 0.23657747f, 
    0.29373947f, -0.01610767f, 0.22573321f, -0.19230494f, 0.16215315f, 0.12998262f, 0.32548708f, 0.14676754f, 
    -0.01182763f, -0.01410728f, -0.02590290f, -0.03559791f, 0.27128339f, -0.35734090f, -0.14781648f, 0.25131825f, 
    -0.29131424f, -0.00212523f, -0.05843387f, 0.34180689f, 0.01161154f, -0.09214693f, 0.31930828f, 0.24919179f, 
    -0.26372114f, -0.17065364f, -0.08283664f, 0.09090888f, -0.08517645f, -0.04887432f, -0.08170327f, 0.11068442f, 
    -0.07799660f, -0.16997379f, -0.02274669f, 0.01221932f, -0.23869872f, -0.26840317f, 0.05189036f, 0.20835374f, 
    0.50861120f, -0.42796895f, -0.00770412f, -0.28142101f, -0.01534978f, 0.12325481f, -0.11259090f, 0.09434954f, 
    0.09234197f, -0.06556621f, -0.20120662f, 0.07628786f, 0.00106003f, 0.10468277f, 0.00626246f, 0.23464394f, 
    0.02262616f, -0.22101791f, 0.45612848f, -0.03951850f, -0.32575256f, 0.02788693f, 0.24524523f, 0.00443192f, 
    -0.01426479f, -0.18957175f, -0.30562761f, -0.01495938f, 0.26627031f, 0.24075361f, -0.21956505f, 0.10279462f, 
    0.17788303f, -0.01559739f, 0.26734129f, 0.03436239f, -0.48933402f, 0.00763774f, -0.19759540f, 0.04204324f, 
    0.18265934f, 0.11815023f, -0.09785351f, 0.11276968f, -0.12929411f, -0.17830396f, 0.30645967f, -0.48203701f, 
    0.07216734f, 0.07109003f, 0.11662058f, 0.04257860f, 0.11085632f, 0.22589950f, -0.16736980f, 0.07210808f, 
    0.03701159f, -0.01764298f, 0.14560403f, 0.15813287f, -0.08479806f, 0.07452803f, 0.08598106f, -0.57745433f, 
    0.03716285f, -0.33162636f, -0.04476601f, 0.19450168f, 0.06438918f, -0.11523818f, 0.22073911f, -0.14446823f, 
    -0.21876666f, 0.09944303f, -0.30258620f, 0.18804799f, 0.08662856f, 0.04682869f, 0.33387494f, -0.02052138f, 
    -0.06472436f, -0.00400357f, -0.32337901f, -0.01506350f, 0.06202645f, -0.03996260f, -0.02152652f, 0.35132802f, 
    0.15022323f, -0.09592397f, 0.25713745f, 0.13442443f, -0.06334489f, -0.09565365f, -0.08804859f, -0.10748399f, 
    0.01898125f, -0.07795424f, 0.02555244f, -0.16372876f, 0.11093090f, 0.26180184f, 0.00086607f, 0.16907454f, 
    0.07609197f, -0.07353868f, 0.04038113f, -0.21036170f, 0.09478588f, -0.03639733f, -0.24850991f, 0.04802065f, 
    -0.18086813f, 0.01056831f, 0.14922743f, 0.13640429f, -0.13388631f, 0.13853617f, -0.78114671f, -0.27215436f, 
    -0.03466070f, -0.10847949f, 0.05790971f, 0.23646601f, 0.00529379f, -0.07957939f, 0.24549682f, 0.24596068f, 
    -0.11761965f, -0.07519881f, -0.04055182f, 0.03653549f, 0.09306612f, 0.10745204f, 0.09398128f, 0.22279836f, 
    -0.19111902f, -0.33337346f, 0.08465150f, -0.05781715f, -0.07163472f, 0.19043154f, -0.07833279f, -0.12931751f, 
    -0.07096905f, 0.02389796f, 0.09673607f, -0.10723837f, 0.13446617f, -0.05012072f, -0.00447886f, -0.18490428f, 
    -0.10167333f, -0.10206278f, -0.24053665f, -0.52318722f, -0.09190618f, 0.05166261f, 0.10862626f, 0.24859223f, 
    0.03056212f, -0.24290389f, 0.26326358f, 0.34369588f, -0.09322578f, -0.09271522f, -0.03881595f, 0.23224206f, 
    -0.08495001f, 0.02640125f, 0.03662299f, 0.15923727f, 0.47978249f, -0.37772721f, -0.29897657f, -0.01575882f, 
    -0.14100777f, 0.17490795f, 0.04312969f, 0.25071561f, 0.14710203f, 0.22513358f, -0.04319947f, 0.13833214f, 
    -0.04925478f, -0.01496562f, -0.21813466f, -0.24038172f, 0.10038552f, 0.19593588f, -0.04554437f, -0.02694940f, 
    -0.31929621f, 0.21605630f, -0.02383224f, -0.09435045f, -0.00816424f, -0.16975036f, 0.04241826f, -0.33985528f, 
    0.24416575f, -0.06756644f, 0.21446195f, 0.13979784f, 0.16216293f, 0.07235258f, 0.05788556f, -0.10180086f, 
    0.02544791f, 0.29886231f, 0.05973748f, 0.08198706f, 0.07293482f, -0.05282630f, -0.02556868f, -0.01649245f, 
    -0.01342311f, 0.02373786f, -0.02533854f, 0.02050128f, -0.01109284f, 0.04119992f, -0.01866140f, 0.02576072f, 
    -0.01213861f, 0.02872605f, 0.00416642f, 0.00879788f, 0.03515549f, 0.01268890f, -0.01291996f, 0.00689060f, 
    0.04447045f, -0.04902474f, -0.00499310f, -0.04889261f, -0.01980047f, -0.00277139f, -0.01911295f, -0.04666372f, 
    -0.01626970f, -0.02741895f, 0.03947317f, -0.01592972f, -0.01255699f, -0.01600198f, -0.06212448f, -0.03388612f, 
    0.00220188f, -0.07074329f, 0.04644882f, 0.03454190f, -0.02454718f, 0.04945998f, -0.05834914f, -0.05249920f, 
    0.01781473f, -0.03620202f, -0.03849176f, -0.00139255f, 0.01830588f, -0.05280621f, 0.02667507f, 0.03385639f, 
    0.04720496f, 0.02647104f, -0.03054828f, 0.02666765f, 0.01721018f, -0.04879387f, 0.03151289f, -0.02925787f, 
    0.02838118f, -0.03749978f, 0.02510935f, 0.03952621f, -0.04489212f, 0.04229003f, 0.00906004f, -0.03189435f, 
    -0.06335016f, 0.02406376f, -0.04053818f, -0.01697344f, 0.02911638f, 0.00648423f, -0.03377958f, 0.01571107f, 
    -0.03828973f, 0.01165518f, 0.02253675f, 0.03403722f, -0.06556430f, 0.00316287f, -0.01530409f, -0.00104637f, 
    -0.00560031f, -0.00013187f, -0.02137532f, -0.01523678f, 0.04568266f, 0.03063629f, -0.06323774f, 0.03509385f, 
    -0.04607766f, 0.00102775f, 0.02899943f, -0.01038722f, 0.01830402f, -0.01113786f, 0.02038224f, 0.00598603f, 
    0.01436977f, 0.00889481f, 0.03763252f, 0.00402845f, -0.03464879f, -0.00456044f, 0.01402077f, 0.02850475f, 
    0.04471201f, 0.05281753f, -0.05486894f, -0.05984320f, 0.00741426f, 0.02868542f, -0.05240688f, 0.00731979f, 
    -0.05872820f, -0.05334766f, -0.03586999f, -0.02176888f, 0.03337703f, -0.00786560f, 0.03143311f, -0.00675871f, 
    0.00380846f, 0.04240777f, -0.00371438f, 0.02874373f, 0.04858352f, -0.00248245f, -0.01083257f, 0.00994055f, 
    -0.01921974f, -0.04511327f, -0.06450349f, 0.03695992f, -0.01996023f, 0.05146716f, 0.03532456f, 0.01677699f, 
    -0.05268509f, -0.03557359f, -0.03883340f, 0.00495341f, 0.00836015f, 0.00592523f, 0.04445175f, -0.05466729f, 
    -0.04670283f, -0.05756010f, 0.01223362f, -0.01373994f, -0.05694596f, 0.01035173f, 0.00398008f, 0.00184031f, 
    -0.03053205f, 0.02743708f, -0.01614076f, 0.03726842f, -0.01489740f, 0.02744660f, -0.05714888f, -0.01724026f, 
    0.01408580f, 0.00110226f, -0.05226834f, -0.02056330f, 0.00792940f, 0.01539164f, -0.02181317f, 0.03396420f, 
    -0.01721555f, -0.04666549f, -0.02344791f, -0.01903858f, -0.01586088f, 0.00659879f, -0.02636751f, -0.05678851f, 
    -0.03708012f, -0.01422455f, 0.04547526f, 0.02341000f, -0.02181215f, -0.02065959f, 0.00717858f, -0.02559673f, 
    0.03939929f, 0.00331272f, 0.02538326f, 0.03357925f, -0.06169961f, 0.00978962f, -0.04736079f, -0.04174721f, 
    0.02818321f, -0.05351528f, -0.00828304f, -0.02687109f, -0.01180806f, 0.02314100f, -0.02919304f, -0.04673973f, 
    -0.00466518f, 0.02260490f, 0.01989440f, -0.05655235f, -0.03293198f, -0.02164488f, -0.01652018f, 0.02270755f, 
    0.02458942f, 0.02154901f, -0.02466044f, 0.01791440f, -0.06447280f, -0.06508924f, 0.00682343f, -0.02342273f, 
    -0.05324447f, -0.03877521f, 0.03454914f, 0.03072640f, -0.00478535f, -0.00409896f, 0.01205110f, -0.07018243f, 
    -0.03622843f, -0.05662206f, -0.00274985f, -0.06497948f, 0.02302139f, 0.00087226f, -0.04419312f, -0.04237327f, 
    0.04808264f, -0.01810796f, -0.06609710f, 0.04686965f, 0.00795522f, 0.00725614f, 0.01121255f, -0.04955620f, 
    0.03146984f, -0.05475465f, 0.04505888f, -0.05335812f, 0.00976070f, -0.01346300f, 0.02838698f, 0.03624604f, 
    -0.01453879f, 0.05293788f, 0.03047651f, -0.03420147f, 0.04514010f, 0.02736829f, -0.04893458f, -0.03571550f, 
    -0.05685311f, 0.01901520f, 0.05169992f, -0.02202283f, 0.04094389f, 0.02488617f, 0.04824901f, -0.04773946f, 
    -0.03573092f, 0.03253578f, 0.02140074f, 0.03709126f, 0.01830691f, 0.00708897f, 0.03990315f, -0.06278603f, 
    -0.06191642f, -0.01089947f, -0.04245597f, -0.00390934f, 0.04594574f, -0.04219107f, -0.01715016f, -0.06146637f, 
    0.02397844f, 0.04267745f, -0.05222262f, 0.03352438f, -0.04269150f, -0.04608055f, -0.02208504f, 0.01603684f, 
    0.02510638f, -0.04586584f, 0.04134961f, 0.03777164f, 0.01861900f, -0.02218433f, -0.01824068f, -0.02740480f, 
    0.00910482f, -0.00610487f, -0.00894431f, -0.02449791f, 0.00720874f, 0.03637257f, -0.01373550f, -0.02564242f, 
    0.05239619f, -0.06342208f, 0.04848202f, 0.00088800f, 0.01531987f, 0.03683420f, 0.05314462f, -0.06004498f, 
    0.01485850f, 0.02851489f, 0.03495416f, 0.04089141f, -0.04544755f, -0.01380880f, 0.01720841f, -0.01844123f, 
    -0.00424800f, 0.02277443f, 0.02310361f, -0.00876668f, -0.00401697f, -0.02197522f, -0.05068794f, 0.03236007f, 
    0.02769822f, -0.04466508f, 0.02778194f, -0.05401231f, -0.00257054f, 0.01556716f, 0.03976553f, -0.04933783f, 
    -0.02837018f, -0.01501721f, -0.05755256f, -0.02951400f, -0.00975632f, -0.03011829f, -0.01563918f, -0.06015656f, 
    -0.02641520f, -0.01006613f, -0.04013480f, -0.02727356f, 0.05113165f, -0.04715289f, -0.03494698f, -0.03226601f, 
    -0.05594873f, -0.02345479f, -0.04865396f, -0.03390966f, -0.04228350f, -0.04863968f, 0.02166181f, -0.06204805f, 
    -0.00991849f, -0.05183563f, -0.03692898f, 0.02689425f, -0.00220039f, 0.01436136f, -0.04155592f, 0.01443066f, 
    0.00408273f, -0.02279225f, 0.01850718f, 0.03767733f, 0.03381882f, -0.00173743f, 0.04153987f, 0.00748869f, 
    0.03439656f, 0.04581651f, 0.02177793f, -0.01584734f, 0.01840153f, -0.01541642f, -0.02288918f, -0.02946791f, 
    -0.02817488f, 0.01526661f, -0.04756892f, -0.04205682f, 0.04440347f, 0.03233620f, 0.03241295f, -0.04604743f, 
    -0.04088731f, -0.00014950f, -0.01811931f, -0.03396820f, 0.01891860f, -0.00660192f, 0.00287615f, 0.02137944f, 
    0.02908755f, 0.02860732f, 0.02248348f, 0.03033084f, 0.04255661f, 0.01798988f, -0.03952660f, 0.04908260f, 
    0.01497346f, -0.03575237f, -0.05946109f, 0.03838010f, 0.01820925f, -0.06463300f, 0.02175938f, 0.00670463f, 
    -0.03881716f, -0.06246604f, 0.00845564f, 0.00454095f, 0.04381456f, 0.04388519f, 0.02896581f, -0.04961338f, 
    0.03675120f, 0.02351562f, 0.04004989f, -0.00001243f, 0.01850533f, -0.01138127f, 0.01876538f, 0.03740666f, 
    -0.04840913f, -0.03697150f, 0.00882367f, -0.05302162f, -0.06035914f, 0.01265271f, -0.03425487f, -0.03989797f, 
    -0.05982367f, 0.03103304f, 0.00611489f, -0.04424138f, 0.01202351f, 0.00568993f, 0.01286935f, 0.00580744f, 
    -0.02263718f, -0.04064400f, 0.01025894f, -0.00555954f, 0.04591455f, 0.01041683f, -0.03960303f, -0.02769855f, 
    0.03155608f, -0.03346542f, 0.00720678f, 0.03361142f, 0.04572911f, 0.03560169f, 0.01522901f, -0.03519231f, 
    0.03264117f, -0.06340799f, -0.03405262f, -0.01420179f, -0.02398308f, -0.04862313f, -0.05979493f, -0.04240283f, 
    -0.04306499f, -0.05826400f, -0.04796538f, -0.01496127f, -0.05955989f, 0.00490202f, -0.06204209f, 0.02662781f, 
    0.03584535f, -0.05304665f, 0.05037230f, 0.03722666f, 0.01115395f, -0.02501305f, 0.03742449f, 0.00698623f, 
    -0.04507659f, -0.02755137f, 0.03280811f, -0.05645655f, 0.00196010f, 0.02663747f, -0.01295184f, -0.04851717f, 
    -0.00258179f, 0.04620788f, -0.00727140f, 0.01416502f, -0.01144248f, 0.00090880f, 0.00080361f, 0.00301154f, 
    0.01831919f, 0.04635228f, -0.01849603f, 0.00944842f, 0.01650438f, 0.03115442f, 0.02053667f, 0.01558077f, 
    -0.05220110f, 0.02442449f, -0.00045853f, -0.02520216f, 0.04781738f, -0.02215986f, 0.04357767f, -0.00592567f, 
    0.00434876f, 0.01328231f, 0.01858082f, -0.03717109f, -0.06059757f, -0.02097949f, -0.02176297f, -0.04817964f, 
    -0.03932833f, 0.04426759f, -0.06034925f, -0.04169330f, 0.01935989f, -0.06502437f, 0.05022322f, -0.02986691f, 
    -0.03075697f, 0.03376239f, -0.05475384f, 0.01127172f, -0.04767145f, 0.00274093f, -0.02678791f, -0.01492005f, 
    0.02362553f, -0.05464816f, -0.01257846f, 0.01199919f, -0.06393465f, -0.05425214f, 0.02267141f, -0.00850152f, 
    0.00230707f, -0.02118860f, 0.03475992f, -0.00838192f, -0.03264396f, -0.03826125f, 0.04318934f, -0.00826907f, 
    -0.03650871f, -0.00462474f, -0.06332842f, 0.02238043f, -0.04676502f, -0.06492345f, 0.04883718f, -0.05395399f, 
    0.02074130f, -0.05785863f, 0.05022468f, -0.03188189f, -0.04271742f, -0.04613441f, -0.04549320f, 0.00754320f, 
    -0.03722330f, -0.02935248f, -0.00786004f, -0.03087492f, -0.03918591f, 0.00215424f, 0.03930198f, -0.04502100f, 
    0.01451684f, -0.04729674f, -0.04529914f, -0.02719267f, -0.05553550f, -0.03689601f, -0.00565578f, 0.00019024f, 
    0.00860860f, -0.00042195f, 0.03188158f, -0.02069929f, 0.03131746f, 0.03241640f, 0.03095167f, -0.02017941f, 
    -0.05852217f, 0.02434879f, 0.03833622f, -0.00707681f, -0.05004985f, -0.00247789f, 0.01059936f, -0.04298392f, 
    -0.05892337f, 0.04608626f, 0.05355606f, -0.00549508f, 0.02976958f, 0.00570777f, -0.04416724f, -0.05594093f, 
    -0.01896326f, -0.04404406f, -0.02734642f, -0.01108329f, -0.04163398f, -0.01506632f, 0.03986806f, -0.04710467f, 
    0.01942552f, -0.00914046f, -0.05435718f, 0.02327681f, 0.03276330f, -0.04873484f, 0.05206091f, 0.02618155f, 
    -0.01892251f, 0.00577348f, -0.04836021f, 0.02665716f, 0.04993897f, 0.03538586f, -0.05107638f, 0.01587389f, 
    -0.00682326f, 0.05173965f, 0.05425523f, -0.00220860f, 0.03976601f, -0.05810605f, 0.02914037f, 0.00472456f, 
    -0.03246778f, -0.03084455f, -0.03046196f, -0.02027821f, -0.05375550f, -0.03043373f, -0.02051076f, 0.02063190f, 
    0.02411004f, -0.01994849f, -0.05888657f, -0.05457604f, -0.02355884f, 0.02090963f, 0.03105177f, -0.04856537f, 
    -0.02281329f, 0.04707712f, -0.02483469f, -0.04090789f, 0.00653649f, -0.03584131f, 0.00923737f, 0.05320047f, 
    -0.00258626f, -0.04355957f, -0.03768097f, -0.03706156f, -0.03527246f, -0.05157223f, 0.02170880f, 0.02091828f, 
    -0.00096738f, -0.04326480f, -0.05025094f, 0.03997265f, -0.04467763f, 0.00949347f, -0.01153179f, 0.03188413f, 
    -0.03208320f, -0.03449810f, -0.04600287f, 0.01373143f, -0.00269335f, -0.01895375f, 0.05156899f, -0.05012967f, 
    -0.01311157f, -0.05288928f, -0.04928815f, -0.00347107f, -0.04552593f, -0.02319216f, -0.01759595f, -0.04084488f, 
    -0.05082308f, -0.00349122f, -0.03763888f, 0.05452384f, 0.01230894f, -0.01192761f, 0.02301833f, -0.05743849f, 
    0.05818852f, 0.00725636f, 0.01425861f, -0.03510925f, -0.05236460f, -0.04556791f, -0.03697602f, -0.02829418f, 
    -0.05460389f, -0.03898244f, -0.05765611f, 0.00268159f, -0.05169111f, 0.04299294f, 0.04822872f, 0.05781900f, 
    -0.05078975f, -0.02914773f, -0.04573952f, -0.02176984f, -0.04657397f, 0.02059932f, 0.03602498f, -0.03082738f, 
    0.02302465f, -0.03771428f, 0.04642914f, 0.04405978f, -0.00117467f, -0.00250139f, 0.00346918f, 0.03191718f, 
    -0.03197617f, 0.02992313f, -0.03751968f, 0.03763892f, -0.02786279f, 0.00699769f, -0.03490560f, 0.02050979f, 
    -0.01574502f, 0.03708583f, -0.00339932f, 0.04339914f, 0.04267058f, -0.01256521f, 0.02345846f, -0.02509200f, 
    -0.04566781f, -0.02716268f, -0.05179241f, -0.00771311f, 0.04823703f, -0.02020965f, -0.00197190f, -0.00803816f, 
    0.05112991f, -0.05193156f, 0.00459016f, -0.05883309f, -0.01677690f, -0.01280487f, -0.03805194f, -0.01905656f, 
    -0.00781879f, -0.03887887f, 0.05087170f, -0.05598894f, 0.02037444f, 0.01699773f, -0.04580022f, 0.01337725f, 
    -0.04660412f, -0.04251591f, -0.01989302f, -0.01657773f, -0.05839265f, -0.04293515f, 0.03489975f, -0.01858189f, 
    -0.00150786f, -0.03176061f, -0.03163125f, 0.01688798f, 0.03201718f, 0.03049904f, -0.05657646f, -0.01133461f, 
    0.01417602f, -0.03849403f, -0.04743189f, -0.04703575f, -0.05850819f, -0.05212645f, -0.03126387f, 0.04445318f, 
    0.03191342f, 0.04763910f, 0.01512829f, -0.04622244f, -0.00415087f, -0.03160908f, -0.04068130f, 0.05266313f, 
    0.04519268f, -0.04090715f, 0.01034910f, 0.00495451f, -0.01443451f, 0.01478461f, -0.02494789f, 0.04164293f, 
    -0.02470763f, 0.01591440f, -0.01395880f, 0.03791325f, 0.04483737f, 0.04071516f, -0.00469330f, -0.01482491f, 
    0.04091025f, -0.05609135f, 0.01864987f, 0.02947224f, -0.01183868f, 0.05062525f, 0.04928013f, -0.00091768f, 
    -0.03787655f, 0.00421986f, -0.03897403f, -0.04218836f, -0.05772324f, -0.01477060f, -0.04413382f, -0.03998611f, 
    -0.03845412f, 0.04696504f, 0.04379939f, -0.00065992f, -0.00628893f, -0.02115916f, 0.00593778f, -0.04380455f, 
    0.03084530f, 0.02253756f, 0.05554134f, -0.04946842f, -0.02751329f, -0.03012906f, 0.05745267f, -0.05754789f, 
    0.29842645f, 0.25631946f, 0.02272049f, 0.17786565f, -0.05331545f, -0.11125004f, 0.18819915f, 0.23287264f, 
    0.26558158f, -0.52994007f, -0.11807968f, 0.03501673f, 0.19800889f, 0.15710182f, -0.02202138f, 0.07525739f, 
    0.04715981f, -0.01101022f, 0.55954152f, -0.09303525f, -0.02613626f, -0.21424428f, 0.01957853f, 0.02236624f, 
    0.04437012f, 0.05599316f, -0.01533275f, -0.12495017f, -0.05051134f, -0.19776094f, 0.20257680f, -0.10174266f, 
    0.01279771f, -0.02681734f, 0.10261447f, 0.10203722f, -0.43524188f, -0.11693681f, -0.12771392f, -0.06798117f, 
    -0.11199353f, -0.18435736f, -0.14312014f, -0.07696490f, -0.10810339f, -0.22909035f, -0.00999058f, 0.31508914f, 
    0.01375512f, 0.14967999f, 0.02171445f, -0.13776751f, -0.19570911f, 0.10673363f, -0.21921772f, 0.43948871f, 
    0.51173186f, -0.19514455f, 0.12701023f, -0.18653783f, -0.09808185f, 0.28872541f, -0.12968466f, -0.21254928f, 
    -0.12113689f, -0.21138062f, 0.17802854f, 0.26559955f, -0.08105013f, 0.00204395f, -0.13057947f, -0.11315151f, 
    -0.13097548f, 0.40335500f, -0.22219639f, 0.03412520f, -0.12372099f, 0.02226977f, -0.14470321f, 0.16735281f, 
    -0.14600652f, -0.28248593f, 0.15213890f, -0.08157314f, 0.10349753f, 0.03774002f, 0.25714651f, 0.05362405f, 
    0.00359650f, -0.03355142f, -1.04200053f, -0.12693600f, -0.13120562f, -0.05432017f, 0.08983570f, 0.21219125f, 
    0.04921197f, -0.38170910f, 0.03069722f, 0.05043578f, -0.03470302f, 0.52266639f, 0.29251641f, 0.24399708f, 
    -0.14707883f, -0.01174245f, 0.04732995f, 0.03857816f, -0.13821915f, -0.17443462f, -0.34744737f, -0.10340559f, 
    0.05601302f, 0.03381560f, 0.10905942f, 0.00351838f, 0.16218209f, 0.13554144f, -0.01750967f, 0.15948687f, 
    0.20229726f, 0.01538392f, -0.01142872f, 0.10530889f, 0.15028726f, 0.11174849f, 0.49355212f, -0.06407931f, 
    -0.10106780f, 0.17274544f, -0.06938900f, 0.05324963f, 0.10229083f, -0.18977165f, 0.17034668f, -0.25561491f, 
    -0.41853434f, -0.22661164f, 0.11704019f, -0.00899883f, 0.03819758f, -0.06360929f, -0.01346867f, 0.30025545f, 
    0.09073964f, 0.06653162f, 0.11931961f, 0.06018838f, 0.13083558f, -0.03180020f, -0.02080927f, 0.08784737f, 
    0.00127762f, -0.04401420f, 0.26539838f, -0.48012319f, -0.11896739f, -0.11892040f, -0.06278712f, 0.18030164f, 
    -0.12541865f, -0.13584898f, -0.26111490f, -0.03349027f, -0.41069871f, 0.06700101f, 0.10825491f, 0.08116616f, 
    0.04662333f, 0.10190648f, -0.12456868f, -0.37276769f, 0.21407481f, 0.09067982f, 0.11318321f, 0.13022934f, 
    0.27273253f, 0.19404060f, -0.04171378f, -0.11234653f, 0.67363161f, 0.13100585f, -0.19740446f, 0.00122471f, 
    -0.01713623f, 0.13352652f, -0.01371852f, -0.07140056f, 0.10796990f, -0.02588550f, -0.63256711f, -0.25388011f, 
    -0.06117786f, 0.09162516f, 0.10846805f, 0.03227070f, 0.10637147f, -0.17042634f, -0.00815103f, 0.05464084f, 
    0.37567499f, -0.17311385f, 0.14197464f, 0.06803602f, 0.33196586f, 0.01101298f, 0.12238289f, -0.27379450f, 
    0.03943983f, -0.36001754f, 0.07261130f, -0.00973484f, 0.24383228f, 0.10241523f, -0.15164909f, -0.01130441f, 
    -0.04297293f, 0.11310570f, 0.13888499f, 0.15265639f, 0.22677153f, -0.30225176f, 0.22379130f, -0.14936811f, 
    0.26124924f, -0.16472922f, -0.39072388f, 0.06052873f, 0.16031976f, -0.20012067f, 0.15212786f, -0.12531744f, 
    0.08538925f, -0.20650290f, -0.49789482f, 0.13964051f, -0.48867938f, 0.16449702f, 0.01237447f, 0.09462458f, 
    0.26783526f, 0.08701552f, 0.00004733f, -0.52537727f, 0.43314442f, 0.04341782f, 0.05576362f, 0.05741714f, 
    0.41057304f, 0.16689451f, 0.09924080f, -0.09374978f, -0.23429963f, -0.06720691f, -0.03062401f, 0.02021351f, 
    0.12037283f, 0.03317928f, -0.08602171f, -0.03321944f, 0.07988911f, -0.76523817f, 0.16947034f, -0.21896084f, 
    -0.13312767f, 0.08126061f, 0.14458323f, -0.03342423f, -0.20582399f, -0.25500643f, -0.39376444f, 0.20174192f, 
    0.03333582f, -0.14216910f, 0.07561369f, -0.13753788f, -0.07877263f, 0.12120757f, 0.05932162f, -0.61049515f, 
    -0.16310290f, 0.13214725f, 0.19549955f, 0.01984652f, -0.02202079f, -0.24072616f, -0.05352463f, 0.02113227f, 
    -0.41503048f, 0.11353514f, 0.01997612f, -0.16142043f, -0.02261683f, 0.04846586f, 0.11910328f, 0.07188550f, 
    0.04292744f, -0.17207187f, -0.17893411f, -0.12263998f, -0.00501277f, 0.07779632f, 0.02854204f, 0.29490927f, 
    0.09800486f, 0.07023963f, -0.36174968f, 0.13687922f, 0.33474067f, 0.05154704f, 0.27061850f, -0.10027587f, 
    -0.09313662f, 0.01020836f, 0.07305014f, 0.11938096f, 0.03222335f, -0.02138283f, -0.10285950f, -0.02598885f, 
    -0.00767973f, -0.10456531f, -0.07761921f, -0.02094316f, -0.09311525f, 0.22175001f, -0.04681508f, -0.07766139f, 
    -0.20740920f, 0.13178469f, -0.03775308f, -0.08913328f, -0.06132588f, 0.07662863f, 0.35582539f, 0.25843945f, 
    -0.02531673f, 0.06855690f, 0.05392392f, 0.13508521f, -0.09216172f, -0.25829092f, 0.16143143f, -0.32248947f, 
    0.19557557f, -0.67265773f, -0.26199055f, 0.09106637f, 0.03319721f, -0.05815134f, -0.20927006f, -0.12660417f, 
    0.41797686f, 0.11068065f, -0.08032516f, -0.13378336f, -0.11462542f, -0.12547743f, -0.27871791f, 0.06504939f, 
    0.13047761f, -0.17577977f, 0.30226567f, -0.02306077f, 0.02956682f, 0.03345591f, -0.06006603f, -0.02386854f, 
    -0.01262194f, -0.17904474f, 0.27179101f, 0.39231086f, 0.21691079f, -0.16942301f, 0.07367925f, -0.11157051f, 
    0.13482104f, -0.02938484f, 0.19059087f, 0.17448850f, 0.01249019f, 0.16601907f, -0.02266353f, -0.05308682f, 
    0.04934214f, 0.06585597f, -0.16990076f, -0.28929883f, -0.12519625f, -0.11191535f, -0.11795924f, -0.20578216f, 
    -0.04762436f, 0.16701007f, -0.03500232f, -0.08588017f, 0.04642574f, -0.05685448f, 0.09172770f, -0.18796991f, 
    0.00104831f, -0.11721925f, -0.00797676f, 0.11093672f, 0.14551103f, -0.22845010f, -0.38250169f, 0.25386673f, 
    -0.09778662f, -0.11804703f, 0.08832122f, -0.03483190f, -0.16009004f, 0.01189872f, -0.15019783f, 0.12529947f, 
    -0.22921364f, 0.37279427f, 0.02700211f, 0.05802374f, 0.24442388f, 0.06234341f, -0.13083741f, -0.09213857f, 
    -0.17588055f, -0.01176381f, -0.16576993f, -0.00475502f, -0.13355155f, 0.16495866f, 0.18936197f, 0.20592473f, 
    -0.17473671f, -0.49812666f, -0.01688969f, -0.29079962f, -0.29086688f, 0.09387210f, 0.10444338f, 0.11320701f, 
    -0.07234341f, 0.23511951f, 0.37201440f, 0.14137731f, 0.17321651f, 0.19878554f, 0.04206970f, 0.04740918f, 
    -0.23309436f, 0.27268887f, 0.16356413f, 0.06064858f, -0.21985686f, 0.34786525f, 0.07182339f, 0.38263106f, 
    0.11579294f, 0.18392095f, -0.14762582f, -0.05831561f, 0.03032603f, -0.12331449f, 0.04435165f, 0.08818973f, 
    0.00509794f, 0.19822015f, 0.13675015f, -0.01531616f, 0.02403456f, 0.33671907f, 0.09492617f, -0.12867825f, 
    0.10944930f, 0.00043116f, -0.25550076f, 0.19693932f, -0.01087402f, -0.33917588f, 0.08957824f, -0.26222402f, 
    0.08035930f, 0.03347043f, -0.00867785f, 0.12900668f, 0.03480975f, 0.11650297f, -0.02065441f, -0.06812011f, 
    0.07006993f, -0.44940460f, -0.28290868f, -0.19974062f, -0.00642641f, 0.02653601f, -0.06699894f, 0.31126934f, 
    0.39943004f, -0.07507073f, 0.10744070f, 0.26331943f, 0.07839012f, -0.01848640f, 0.04632159f, 0.13326074f, 
    -0.28542545f, -0.18426560f, 0.11105627f, 0.22888911f, 0.13075188f, -0.05988347f, 0.09844222f, 0.10784665f, 
    -0.10487715f, 0.12762681f, 0.06810434f, -0.26139879f, -0.03986442f, -0.06102545f, -0.05860098f, -0.07176534f, 
    -0.02061516f, 0.04734067f, 0.08830934f, -0.07255367f, -0.00989542f, 0.18812703f, 0.14017072f, -0.27161419f, 
    0.10048941f, 0.18158777f, -0.12960322f, 0.33209869f, -0.20630075f, -0.18628232f, 0.01275579f, -0.22827746f, 
    -0.05488075f, 0.00785980f, 0.22367978f, 0.02486395f, 0.21499708f, 0.12760326f, -0.14444420f, 0.10319714f, 
    0.32892406f, 0.13587372f, -0.13174103f, -0.20841347f, 0.25885603f, 0.19341843f, 0.08947517f, 0.15990981f, 
    -0.00534761f, 0.07870115f, -0.19620092f, -0.20931470f, 0.15333579f, -0.06054306f, 0.00382080f, 0.21337239f, 
    0.09324872f, -0.14534830f, -0.02234698f, 0.12777075f, -0.03386255f, -0.07614605f, 0.08697144f, 0.08009126f, 
    -0.20616500f, 0.07111523f, 0.26470819f, 0.17083226f, -0.16043875f, -0.03381866f, -0.13228938f, -0.13352960f, 
    -0.06103601f, 0.03959214f, -0.05894247f, -0.00845899f, 0.04865135f, -0.03035883f, 0.02820741f, -0.00656055f, 
    0.03250036f, 0.00713352f, -0.04742587f, -0.01672139f, -0.06366495f, -0.05601882f, 0.04792539f, -0.06566022f, 
    0.00626950f, -0.02952772f, 0.01206686f, 0.04463734f, 0.01389886f, -0.00915046f, 0.03611799f, -0.00430546f, 
    0.03745941f, 0.00718818f, -0.04572131f, 0.00755644f, -0.02743254f, 0.02463517f, -0.03087391f, 0.01141942f, 
    0.00448874f, 0.03500373f, -0.04236167f, 0.04109265f, -0.00696083f, -0.04153090f, 0.02267884f, 0.01471246f, 
    -0.06375361f, -0.03697070f, -0.05073017f, -0.02371866f, 0.04436796f, -0.04429852f, -0.01749181f, -0.01200473f, 
    -0.05047505f, 0.03470814f, 0.00769868f, 0.01078315f, -0.01452314f, -0.00079468f, 0.04532501f, -0.04069772f, 
    0.03523314f, 0.02132512f, -0.02042017f, 0.04022317f, -0.06159298f, -0.05108149f, -0.05895358f, 0.00083223f, 
    0.01137403f, 0.00416574f, -0.03349344f, -0.01371739f, -0.06323562f, -0.02520053f, -0.00069777f, -0.02632718f, 
    0.03190732f, 0.00156146f, 0.01699385f, -0.01326365f, -0.03148928f, 0.00035521f, 0.04637215f, -0.03535369f, 
    -0.05932090f, 0.00371559f, 0.01655841f, 0.04984387f, -0.03096622f, 0.03351174f, -0.04926027f, -0.01524082f, 
    0.01306601f, 0.02255570f, -0.06285482f, -0.03914584f, 0.04732415f, 0.01939399f, -0.03962152f, 0.03214904f, 
    0.04439528f, -0.04472882f, 0.00018729f, 0.04896226f, -0.00501621f, -0.03528576f, -0.05521223f, -0.03398441f, 
    -0.02113820f, -0.02862037f, -0.02326765f, -0.05266942f, 0.04761075f, -0.00736036f, -0.03948647f, 0.04935828f, 
    -0.06525090f, -0.05158544f, 0.04801871f, 0.04607923f, 0.03348063f, -0.05239729f, -0.03400112f, 0.00185648f, 
    0.02637616f, 0.03202666f, -0.04680645f, -0.05546390f, -0.01059987f, 0.02825812f, -0.02716017f, -0.01556086f, 
    0.03890023f, -0.00917259f, -0.05999310f, 0.04696633f, -0.04442231f, 0.00107313f, 0.03746676f, -0.01228653f, 
    -0.04842703f, -0.03299994f, 0.01505378f, 0.01730531f, 0.00172575f, -0.05261413f, 0.02416080f, -0.03022339f, 
    -0.03797884f, -0.05450001f, -0.06508063f, -0.05225592f, 0.03989183f, -0.02365029f, -0.01738721f, 0.01975131f, 
    -0.01088566f, -0.01597784f, 0.01875380f, -0.03341031f, 0.04158118f, -0.01117193f, -0.04654071f, 0.00538854f, 
    -0.06147330f, -0.01938313f, -0.02458416f, -0.03567709f, -0.06045648f, -0.00860718f, 0.01991050f, -0.03925498f, 
    -0.06313225f, -0.05190076f, 0.01007285f, 0.03024826f, -0.01751253f, 0.04434486f, 0.02079910f, 0.01696518f, 
    0.03852326f, -0.01621318f, -0.06055710f, -0.02556255f, -0.04363975f, -0.05467357f, 0.00225003f, 0.00328216f, 
    -0.05547082f, -0.00291457f, -0.03859772f, 0.03318315f, -0.06276949f, 0.01652667f, -0.00617686f, 0.02617526f, 
    -0.02212804f, 0.00713554f, -0.04359700f, -0.01833527f, -0.03648014f, 0.03613676f, 0.04981010f, -0.05101600f, 
    -0.01873097f, -0.00388232f, 0.02628367f, 0.01495651f, -0.02778775f, -0.05085978f, -0.00729076f, 0.04794374f, 
    0.01417077f, 0.01492009f, 0.05143499f, -0.04851022f, -0.01710571f, -0.03703537f, -0.02323802f, 0.02558463f, 
    -0.01270372f, -0.05448216f, -0.02957689f, 0.02710066f, -0.02365832f, 0.01243727f, 0.03313662f, -0.00253281f, 
    -0.04603647f, 0.01307936f, -0.01770795f, -0.00729685f, -0.04113406f, 0.04215283f, -0.03061365f, -0.05425566f, 
    -0.02585613f, 0.02981210f, 0.00096316f, 0.02384357f, 0.01489814f, -0.02383376f, 0.03450922f, -0.03295952f, 
    -0.02594779f, 0.00068049f, 0.04607413f, 0.00167799f, -0.03566698f, -0.02759638f, 0.02885497f, -0.01241622f, 
    0.04463624f, 0.04538004f, 0.04783952f, -0.01874000f, -0.00417685f, 0.00912858f, 0.02398479f, -0.05449165f, 
    -0.00228807f, 0.01048685f, -0.01439448f, -0.04348029f, -0.02932921f, -0.05908833f, -0.03612027f, -0.03293541f, 
    -0.05479167f, 0.00138532f, -0.03619060f, 0.02670947f, -0.01576237f, 0.04056534f, -0.02819251f, -0.04755122f, 
    -0.01516856f, 0.00675774f, 0.03880085f, -0.03818825f, 0.01589987f, 0.03706643f, 0.02619842f, -0.02325946f, 
    0.02684594f, -0.06117867f, 0.00197256f, -0.03973959f, -0.04517122f, -0.06294457f, -0.04734799f, 0.04949195f, 
    0.50333905f, -0.27768022f, -0.05921975f, 0.05571018f, -0.04529126f, 0.14011648f, 0.22076891f, -0.14736050f, 
    0.00687675f, -0.65748382f, -0.70925099f, -0.25344172f, 0.13702087f, 0.20587106f, 0.01319960f, 0.10034306f, 
    0.16389453f, -0.04849877f, -0.47692311f, -0.02039559f, -0.23157535f, 0.26463327f, 0.01810088f, 0.08996207f, 
    0.04049733f, -0.35502467f, 0.03944151f, 0.14437513f, 0.18206275f, -0.08041428f, 0.18829805f, -0.11464883f, 
    0.23669004f, 0.31670195f, -0.15348943f, -0.12364397f, 0.10521836f, -0.14438410f, -0.08292212f, 0.12589967f, 
    0.15473180f, 0.18012144f, 0.02065715f, 0.21676628f, 0.02064180f, -0.78496736f, -0.34464550f, -0.02887072f, 
    -0.10787980f, 0.00615237f, 0.04403461f, 0.17684034f, 0.03505771f, 0.22053854f, -0.10032051f, 0.23917450f, 
    0.04650300f, 0.29992464f, 0.18184793f, 0.18533225f, 0.00225690f, -0.19832908f, 0.04444573f, 0.46990290f, 
    -0.62946296f, -0.11045758f, -0.03775498f, -0.04106261f, 0.05619544f, -0.07451142f, 0.08505561f, 0.10599829f, 
    -0.01532493f, 0.11398701f, 0.07693514f, 0.02133067f, -0.00028289f, 0.05222051f, -0.15455057f, 0.16889392f, 
    -0.01432144f, -0.20261401f, 0.10322621f, -0.04243013f, -0.28073955f, -0.02626249f, 0.00209161f, 0.04128279f, 
    -0.09341383f, -0.03229813f, 0.40364861f, 0.08494283f, -0.10540322f, -0.24427877f, 0.06826011f, -0.16550747f, 
    -0.02252844f, 0.20463517f, -0.09438281f, -0.63697797f, -0.56416154f, 0.05787373f, 0.35760358f, 0.32492322f, 
    0.15108863f, 0.03446482f, -0.15423286f, -0.12305934f, 0.41051519f, 0.15162368f, -0.20676124f, 0.09036032f, 
    -0.09723539f, 0.11805592f, -0.09069739f, 0.05067319f, 0.23733890f, 0.45915934f, 0.05109783f, 0.13247497f, 
    -0.01663463f, -0.14958018f, -0.07276861f, -0.03214430f, 0.02073551f, 0.09770562f, -0.53933471f, -0.34081203f, 
    -0.12313985f, -0.18873025f, 0.05187848f, -0.04473562f, 0.20786914f, 0.02465791f, 0.11617889f, 0.40390128f, 
    0.08349056f, -0.12119980f, 0.06887035f, -0.11153544f, -0.06881264f, 0.08102635f, 0.03717970f, 0.28282550f, 
    0.81219095f, 0.25970215f, 0.41827148f, 0.17783992f, -0.05610187f, 0.17315303f, -0.21259245f, -0.01417348f, 
    0.12432842f, 0.02025756f, 0.11429206f, -0.19566278f, -0.13454817f, 0.09433962f, 0.04972950f, -0.06446180f, 
    -0.06625059f, -0.26987398f, 0.23307520f, 0.09533217f, -0.17950584f, -0.42654693f, -0.26919234f, -0.00752090f, 
    0.10283600f, 0.08040498f, 0.03873151f, -0.67779052f, -0.43692681f, 0.15746130f, 0.24412130f, 0.32480249f, 
    0.12009545f, -0.19879967f, -0.19685540f, -0.00756829f, 0.09688413f, 0.16441339f, -0.12400278f, -0.14398547f, 
    0.07352767f, -0.10603148f, 0.08164099f, -0.02619920f, -0.04763897f, 0.28379828f, 0.12214994f, -0.30939096f, 
    -0.24125588f, -0.04121798f, -0.15590566f, 0.04254820f, -0.00994082f, 0.07319400f, 0.00742395f, -0.29732683f, 
    0.06132612f, 0.07090886f, 0.12524620f, 0.01560789f, 0.01723202f, 0.12664829f, -0.12857501f, 0.19518012f, 
    0.17497015f, -0.24415387f, -0.09722453f, 0.12812085f, -0.08970243f, 0.02703045f, 0.07402440f, -0.03246143f, 
    -0.02270051f, -0.02975149f, -0.12256268f, -0.07333960f, -0.30020803f, 0.22325669f, -0.12627549f, 0.14721730f, 
    0.06378071f, 0.20739974f, 0.26565731f, -0.04964411f, 0.10565126f, -0.13667361f, -0.08286501f, -0.01067252f, 
    -0.07452572f, -0.03432003f, 0.17978415f, 0.11841916f, -0.39296165f, -0.07692213f, -0.00061687f, -0.05452751f, 
    -0.16137606f, 0.21896230f, 0.12802577f, -0.19066270f, -0.53622150f, -0.04077500f, 0.02810193f, -0.12913650f, 
    -0.02835735f, -0.03219589f, -0.27455208f, 0.08823744f, 0.47155929f, 0.30826133f, -0.07699859f, -0.06871947f, 
    0.15064394f, -0.05391129f, -0.07667619f, 0.32409760f, -0.20706306f, -0.32179382f, -0.22584248f, 0.18292108f, 
    -0.31654498f, -0.09240282f, 0.03604443f, 0.25109068f, 0.03752171f, -0.09183828f, -0.47724840f, -0.21459809f, 
    -0.18221243f, -0.05544037f, 0.04729657f, 0.16397060f, -0.20642303f, 0.06625962f, 0.25216600f, 0.35956541f, 
    0.10871772f, -0.01839852f, 0.09005009f, -0.09486683f, -0.00725879f, -0.12304419f, 0.26199427f, 0.06988207f, 
    -0.33470991f, 0.19974114f, 0.06097273f, -0.00588415f, 0.08558497f, -0.15423611f, 0.15318677f, 0.15402250f, 
    0.00265184f, -0.07010970f, -0.38683084f, -0.41602296f, 0.18322557f, 0.07759672f, 0.15676229f, -0.06575134f, 
    0.03130587f, -0.17714347f, -0.23153353f, -0.02009549f, 0.08801854f, 0.24197659f, -0.13090061f, 0.20530897f, 
    -0.13301051f, -0.02073523f, -0.38690051f, 0.11512583f, 0.00263730f, 0.20289937f, 0.00291405f, 0.01465153f, 
    0.00335949f, 0.16811298f, 0.34151861f, -0.02412261f, -0.45660615f, -0.04166242f, 0.05648275f, -0.28529483f, 
    -0.22931564f, -0.38363528f, -0.06546345f, 0.17916100f, 0.08573128f, -0.37062779f, -0.58260238f, -0.30162260f, 
    0.22368504f, 0.12689060f, 0.05449762f, 0.08069565f, 0.02124118f, -0.13307704f, -0.03127102f, -0.21050078f, 
    -0.00752787f, -0.16281722f, -0.10626700f, -0.01947501f, -0.03623854f, 0.22640184f, 0.02316185f, 0.09882653f, 
    0.04105886f, 0.20896935f, 0.28138074f, -0.15595751f, 0.05089848f, -0.18273924f, 0.04624054f, -0.03348056f, 
    0.14712226f, -0.29934764f, -0.01748448f, 0.28297502f, -0.01242017f, -0.06419594f, -0.15839359f, -0.17040144f, 
    -0.17994022f, -0.06887752f, -0.06379201f, 0.02275655f, 0.05305982f, -0.08026534f, -0.19419631f, -0.10924920f, 
    0.11607759f, 0.01727832f, -0.00462240f, 0.08124439f, 0.13126123f, 0.09228541f, -0.02370414f, -0.03007431f, 
    -0.01963499f, 0.29061967f, 0.16914602f, -0.69202000f, -0.26887912f, -0.42631274f, 0.08625059f, -0.02388118f, 
    0.14423788f, 0.01569992f, -0.05230312f, -0.31050259f, 0.44886595f, -0.10996560f, 0.07265456f, -0.02432185f, 
    0.01536777f, 0.09598915f, -0.04205536f, 0.12920083f, -0.06386527f, 0.20018816f, 0.08653057f, 0.28500351f, 
    0.04592241f, -0.16219684f, 0.00887361f, 0.25320947f, 0.01162984f, 0.00003140f, -0.39537972f, -0.24601653f, 
    0.01474821f, -0.01122348f, 0.20013212f, -0.07143913f, 0.11235041f, -0.08906595f, -0.04671083f, 0.27248421f, 
    -0.11255220f, 0.01651428f, -0.22204344f, 0.09580825f, 0.05972451f, 0.10068370f, -0.07387128f, 0.06763085f, 
    0.19833708f, 0.15214898f, 0.24898812f, 0.19338036f, -0.05808142f, -0.14877720f, 0.07314361f, 0.01003256f, 
    0.10058789f, -0.15849090f, -0.18458994f, 0.06979716f, 0.10661329f, -0.04474753f, -0.09366845f, -0.18375415f, 
    -0.32713804f, 0.23756692f, 0.03511011f, 0.04382191f, 0.02866121f, 0.07745641f, 0.28417471f, 0.03179465f, 
    -0.05737459f, 0.09859536f, 0.15080124f, -0.30327657f, -0.04085306f, -0.24953002f, 0.00476092f, 0.00707766f, 
    0.26667437f, -0.27287802f, 0.16825373f, -0.23889574f, 0.14257994f, -0.04862302f, 0.00837603f, 0.03841685f, 
    -0.03154816f, -0.06416941f, -0.00023606f, 0.12963083f, 0.10122670f, -0.18243343f, -0.07992736f, 0.28987765f, 
    0.17986193f, 0.16608550f, -0.30994928f, 0.00532928f, 0.37172335f, -0.01091755f, -0.18841717f, -0.29978359f, 
    -0.03526823f, -0.01186782f, -0.07291954f, -0.11274135f, -0.02189668f, 0.11854618f, -0.01699293f, -0.11567911f, 
    0.01113864f, 0.04567670f, -0.17174561f, 0.01747552f, -0.11190867f, -0.02153728f, 0.21913297f, 0.13538386f, 
    0.08900444f, -0.21863718f, -0.02399866f, -0.01876619f, 0.12932535f, 0.07314841f, 0.23769061f, -0.10012019f, 
    0.03970708f, 0.12030068f, 0.02079022f, 0.18537700f, 0.05425363f, 0.11680125f, -0.09570736f, 0.26939088f, 
    0.26282096f, 0.07925573f, 0.04727527f, -0.17040892f, 0.14816645f, 0.07293522f, 0.25573933f, 0.16981202f, 
    0.13119464f, 0.08347943f, 0.15132174f, 0.03321102f, -0.04254306f, -0.01406465f, -0.36563063f, 0.19620597f, 
    0.14811726f, 0.31043613f, -0.10904542f, -0.12295426f, 0.10993785f, -0.19586289f, -0.14308259f, 0.10069901f, 
    -0.11444932f, 0.10610324f, 0.00065755f, 0.21629511f, -0.17134267f, -0.17657889f, 0.22070138f, 0.18769194f, 
    0.18433230f, -0.26240706f, 0.06685713f, 0.15051104f, 0.13818966f, 0.05452297f, -0.26511723f, -0.06816931f, 
    0.00593408f, 0.06850089f, 0.04194964f, 0.12925354f, -0.04054548f, 0.31625551f, -0.09662589f, 0.21084422f, 
    0.05070473f, -0.35758725f, 0.13248675f, 0.16003872f, 0.07094494f, 0.09148284f, -0.10749263f, -0.01427701f, 
    0.05033511f, -0.07819651f, 0.09586824f, -0.00753830f, 0.09169643f, 0.18581045f, -0.01213716f, 0.00809802f, 
    0.03028290f, 0.06394541f, -0.43568343f, -0.07044601f, -0.17002319f, 0.14736819f, 0.22654536f, -0.04462016f, 
    -0.16420996f, -0.14192361f, -0.29518989f, -0.12454622f, 0.37768927f, -0.16571704f, 0.06142949f, 0.08803830f, 
    0.16133501f, -0.02560110f, -0.29667276f, 0.24228804f, -0.02351464f, 0.03079169f, -0.07584289f, 0.19330110f, 
    -0.21210763f, 0.17534460f, 0.15518738f, -0.16226448f, 0.29262286f, 0.21838005f, -0.04639240f, 0.04918214f, 
    -0.09149363f, 0.18251631f, 0.07533321f, 0.04045908f, -0.07693467f, -0.12888977f, -0.09361588f, -0.56540525f, 
    0.01058748f, 0.13615590f, 0.20498107f, -0.19654049f, -0.00661391f, -0.31027931f, 0.37852418f, 0.20111524f, 
    -0.09995256f, -0.08179682f, 0.05116815f, 0.14908506f, 0.21195407f, -0.13811076f, 0.16940494f, -0.00247708f, 
    0.12126150f, -0.13321047f, 0.02604427f, 0.12985726f, 0.10152372f, 0.17543617f, -0.19228770f, 0.04621778f, 
    -0.05132548f, -0.17004845f, -0.32029444f, 0.21459900f, 0.24088213f, 0.26255015f, -0.24424396f, 0.00767820f, 
    -0.11395913f, -0.11481344f, 0.04242917f, 0.09771926f, -0.23029754f, -0.21493521f, -0.09553886f, 0.11299810f, 
    0.01502128f, 0.26466885f, 0.30945972f, 0.08997782f, 0.12986490f, -0.28219131f, -0.11184007f, -0.19244356f, 
    0.02549463f, 0.10262010f, 0.27786049f, 0.07945402f, 0.00510486f, -0.16575576f, -0.11356894f, 0.10922024f, 
    0.03856852f, 0.12682070f, -0.14810279f, -0.12700553f, 0.15281717f, -0.12779979f, -0.22092463f, -0.01649645f, 
    0.08573399f, -0.16492918f, 0.26431733f, -0.00143453f, 0.00783921f, -0.15772474f, -0.09427688f, 0.03527750f, 
    -0.04212859f, 0.03420876f, 0.06780093f, -0.01396412f, 0.12336140f, -0.00188598f, -0.09369399f, -0.07280845f, 
    -0.20222551f, 0.00185070f, 0.07194337f, 0.10553961f, 0.14650092f, 0.06607857f, 0.04384482f, 0.04569291f, 
    0.22613664f, -0.33526063f, 0.16028307f, -0.03867288f, -0.20270015f, -0.10862480f, -0.08576094f, -0.17526934f, 
    0.27495623f, -0.22685759f, -0.00292459f, 0.31154883f, -0.11230923f, 0.18025988f, 0.40888825f, -0.03317586f, 
    -0.00560935f, -0.41309100f, 0.05081560f, -0.09045450f, -0.16818839f, -0.14222907f, -0.00050981f, 0.21039777f, 
    0.17080505f, 0.23054813f, 0.49957806f, -0.09110782f, 0.03512741f, -0.21394105f, -0.43228075f, -0.19267909f, 
    -0.12677597f, -0.03445176f, -0.17337276f, 0.25445732f, -0.06674078f, -0.07839500f, -0.17330486f, 0.06367126f, 
    0.15856513f, 0.07777972f, -0.14427544f, -0.01568513f, 0.09694595f, 0.07571961f, 0.03155726f, -0.30326229f, 
    -0.10160596f, 0.02946405f, 0.07750042f, -0.01394714f, 0.20156452f, -0.08914121f, -0.12633531f, 0.17779592f, 
    -0.04772354f, 0.00828782f, 0.09873523f, 0.07625213f, 0.22997415f, -0.12321565f, 0.43517676f, 0.17382655f, 
    -0.06570800f, 0.05077597f, -0.06424294f, 0.05317802f, 0.03391900f, -0.02213207f, -0.09945018f, -0.01629951f, 
    0.18946573f, 0.03650245f, -0.37547404f, -0.30318728f, -0.02927648f, 0.09638640f, 0.15771842f, 0.27276653f, 
    -0.17022614f, -0.30701944f, -0.06093134f, -0.17785789f, -0.46593243f, -0.35304055f, -0.05806394f, -0.07309028f, 
    -0.01999944f, -0.16271362f, 0.08792435f, 0.09028091f, 0.04812600f, 0.25702110f, -0.08726164f, -0.14513007f, 
    0.16953741f, -0.26398620f, 0.09231581f, -0.03624316f, -0.05378240f, -0.29563475f, 0.27455074f, -0.08110443f, 
    0.03165837f, 0.05568714f, 0.06046816f, -0.12623118f, 0.07813993f, -0.18850437f, -0.16818403f, 0.14462028f, 
    -0.20046034f, 0.12863691f, -0.19612078f, 0.20130414f, 0.17994785f, 0.17441718f, 0.08293258f, -0.20473817f, 
    -0.15851760f, 0.05086945f, -0.02223947f, 0.23992656f, -0.06797086f, -0.01806281f, 0.39389461f, 0.26801303f, 
    0.08236604f, -0.01324265f, -0.06106269f, -0.29704493f, -0.03990773f, 0.14029916f, -0.15541047f, 0.01320233f, 
    -0.04184092f, -0.00721580f, 0.09833494f, 0.12771471f, 0.07066803f, 0.19045924f, 0.09522517f, 0.11296496f, 
    0.05138152f, 0.04530469f, 0.02389954f, 0.07194472f, -0.13559142f, 0.02792566f, -0.00597844f, -0.23255746f, 
    0.39924261f, -0.54679036f, -0.13490874f, 0.08552579f, 0.08235370f, 0.05765977f, 0.15425266f, 0.17549567f, 
    0.00278364f, 0.06515931f, -0.05639625f, -0.22162764f, 0.13556387f, 0.12014671f, 0.00906811f, -0.01038128f, 
    0.01048604f, -0.11045733f, 0.03509197f, 0.30563414f, 0.12608375f, 0.16440247f, 0.05216276f, -0.16162100f, 
    0.00693956f, 0.07243827f, 0.07612500f, -0.34930325f, -0.42663845f, 0.43011403f, 0.04055673f, -0.00236896f, 
    0.08838096f, 0.01764674f, -0.13097997f, 0.13064720f, -0.25554842f, -0.33785552f, 0.22980018f, -0.08943436f, 
    -0.09852993f, 0.06888103f, -0.13888060f, -0.04542464f, 0.09662663f, 0.03573208f, -0.00904391f, 0.27281612f, 
    0.08038344f, 0.21128708f, -0.03473943f, -0.04874508f, -0.05345178f, 0.17627534f, 0.29554221f, -0.07649294f, 
    -0.19593512f, 0.07581488f, -0.27350995f, 0.18575390f, -0.03021757f, -0.03814325f, -0.01481848f, 0.14784525f, 
    -0.49467951f, -0.14838195f, -0.23725078f, 0.00598586f, -0.15697780f, 0.16425262f, -0.07705754f, 0.01687287f, 
    -0.19241819f, -0.52869511f, -0.01360303f, 0.01813377f, 0.05412015f, -0.12978499f, -0.04803942f, -0.01272274f, 
    -0.07326654f, -0.01179997f, -0.21591739f, -0.03279370f, -0.02237540f, 0.10671627f, 0.05873317f, 0.03498448f, 
    -0.21008472f, -0.08383392f, 0.65957785f, 0.24380502f, -0.27519688f, 0.14549874f, -0.01244255f, -0.14976567f, 
    0.06025363f, 0.02950647f, -0.09422772f, -0.19682159f, 0.05530002f, 0.17094854f, 0.16738267f, 0.08002525f, 
    0.03751833f, 0.10107175f, -0.06741642f, 0.04282019f, -0.05991550f, -0.30230424f, 0.28136250f, 0.03945200f, 
    0.17168754f, 0.09875778f, -0.04120107f, 0.00472138f, 0.10234364f, -0.57102567f, 0.03686760f, -0.34707406f, 
    0.11633115f, -0.02008228f, 0.19155866f, 0.10097999f, -0.01410117f, 0.13862038f, 0.31521890f, 0.20459527f, 
    -0.11347491f, 0.01323699f, -0.15965419f, -0.07443179f, 0.03111038f, -0.02840232f, 0.33509201f, -0.51771772f, 
    -0.26081178f, -0.00908926f, -0.09584281f, 0.04602527f, 0.12519574f, 0.03669821f, 0.04603675f, 0.15631957f, 
    -0.12629047f, -0.10075030f, -0.22128877f, -0.03728671f, -0.06566257f, -0.07490619f, -0.14869079f, 0.19030426f, 
    0.16807857f, -0.05849775f, 0.03021193f, -0.15637985f, -0.03588467f, 0.09927604f, 0.05459073f, 0.27518791f, 
    0.24615100f, -0.09842830f, 0.24834217f, 0.20049228f, -0.27261937f, 0.15375239f, -0.06944817f, -0.13302892f, 
    0.24804838f, -0.05627483f, 0.09986977f, 0.27472785f, -0.05270555f, 0.05223905f, 0.15952608f, 0.22409293f, 
    0.04912911f, 0.14178610f, 0.27871054f, -0.06762230f, 0.35757220f, 0.31645986f, -0.00393403f, -0.04900965f, 
    0.08985295f, -0.03181392f, 0.09268337f, -0.01881140f, -0.05006440f, 0.00558721f, -1.27109158f, -0.11435276f, 
    -0.20189045f, -0.13634977f, -0.09262736f, -0.31795010f, -0.06711117f, 0.04237348f, 0.10250696f, 0.20557781f, 
    -0.03298710f, -0.03444123f, -0.22879870f, 0.05270403f, -0.10067330f, -0.13489000f, 0.10538685f, 0.12445746f, 
    0.14565063f, -0.02134755f, -0.11457001f, 0.07213427f, -0.05607382f, 0.02066401f, 0.03506236f, -0.14169392f, 
    -0.00052181f, -0.18454602f, -0.15583760f, 0.06633129f, 0.09124739f, 0.04988914f, 0.18303201f, 0.02894126f, 
    -0.18035419f, -0.28894195f, -0.38064069f, -0.01449850f, 0.03665581f, -0.06199374f, 0.09182767f, -0.28290430f, 
    0.09807190f, -0.24447063f, 0.27393621f, 0.17989776f, -0.25319985f, 0.22784615f, 0.01008717f, 0.12517503f, 
    -0.07370646f, 0.20029959f, 0.10818109f, -0.11352707f, 0.41474515f, -0.40614951f, 0.17142864f, 0.03312005f, 
    0.11725695f, -0.13780066f, 0.04177506f, -0.12809962f, -0.41428772f, 0.53719372f, -0.04635244f, -0.06443722f, 
    0.03641388f, -0.18288471f, 0.13786836f, 0.02609562f, -0.00788054f, -0.12279606f, 0.04323561f, -0.13218245f, 
    -0.08627306f, -0.02426350f, 0.23031978f, -0.04212028f, -0.12475199f, -0.22654839f, -0.09128285f, 0.04486889f, 
    0.23081574f, 0.04075627f, 0.19318207f, -0.29131684f, 0.02274006f, 0.00928400f, 0.11652197f, -0.59658068f, 
    0.21963865f, 0.20616955f, -0.01800197f, 0.11759213f, -0.10449439f, 0.06487322f, 0.03060596f, -0.10046202f, 
    -0.71665829f, -0.16775031f, -0.33037603f, -0.11705642f, -0.16793175f, -0.02498608f, 0.15508838f, -0.06960515f, 
    0.12318126f, -0.13067435f, 0.37551790f, 0.24586180f, 0.00805643f, 0.07288212f, 0.09090059f, 0.29176950f, 
    0.11967916f, 0.18879160f, 0.25458592f, -0.41621292f, -0.17699656f, -0.00861529f, 0.08485718f, 0.08644667f, 
    0.09941092f, 0.19493063f, 0.00664206f, 0.38252726f, 0.18510592f, 0.09584469f, 0.12943614f, -0.08863378f, 
    0.05912855f, -0.27756783f, -0.15456101f, 0.01145239f, 0.18925932f, 0.43332964f, -0.06978960f, 0.07298676f, 
    -0.20378831f, -0.02709243f, 0.08204265f, -0.01332199f, -0.04193463f, 0.18011795f, -0.12244843f, -0.29429746f, 
    -0.18850321f, 0.00742187f, -0.01379907f, 0.12437700f, -0.02880859f, -0.04268970f, 0.08430678f, -0.61053872f, 
    0.13999698f, 0.18416862f, -0.02506306f, -0.07378374f, 0.00021940f, 0.14678922f, 0.10546199f, -0.42520005f, 
    0.06533357f, -0.19390823f, 0.10334468f, -0.18785158f, -0.17346665f, 0.13037325f, -0.03400868f, -0.05886506f, 
    0.47283638f, 0.02236734f, -0.13281490f, 0.05163786f, 0.07970406f, 0.06355044f, 0.01020492f, 0.03651486f, 
    -0.21366990f, 0.05774311f, 0.08098565f, 0.31017652f, -0.06568638f, 0.37707809f, -0.16376500f, 0.06710221f, 
    0.00487131f, 0.13412866f, -0.15039931f, 0.05359489f, 0.26082179f, 0.05159848f, 0.08426289f, -0.13403122f, 
    -0.16087452f, 0.00412620f, 0.03576503f, 0.03613619f, 0.31964397f, 0.01850446f, 0.13355310f, -0.01223589f, 
    0.11443131f, -0.30661026f, -0.00158425f, 0.05372129f, 0.35501757f, 0.17205197f, 0.05992986f, -0.23479219f, 
    -0.00704914f, -0.12768546f, -0.07246523f, 0.00631918f, -0.15700780f, -0.29444799f, -0.41794556f, -0.45278135f, 
    0.11347301f, -0.04894190f, -0.15276521f, -0.07282212f, 0.02618945f, 0.10741640f, 0.20477474f, 0.02018249f, 
    0.15985323f, -0.13784777f, -0.08308128f, -0.16138485f, 0.00739087f, 0.30534700f, -0.00853017f, 0.06186913f, 
    -0.05735499f, -0.32267898f, -0.28891671f, -0.13247466f, 0.16648230f, -0.02704999f, -0.09339300f, 0.17230752f, 
    -0.25141194f, -0.59823155f, -0.34521821f, -0.05837594f, 0.10217962f, -0.05758053f, -0.06786475f, 0.04618179f, 
    -0.15934734f, -0.25319135f, 0.38942650f, 0.29433629f, 0.38878536f, 0.21333465f, 0.30694902f, 0.13879366f, 
    0.11587217f, 0.23239723f, -0.08674314f, 0.04471651f, 0.23723832f, 0.09488283f, -0.17626595f, 0.20889142f, 
    0.10928091f, 0.13803947f, -0.00396227f, 0.45231178f, 0.25499132f, -0.19341521f, 0.18942758f, 0.13068868f, 
    -0.00339454f, 0.00633672f, -0.01361466f, 0.12993588f, 0.10460142f, -0.18122610f, -0.07510659f, 0.02045313f, 
    -0.03017161f, -0.06805584f, -0.16506481f, -0.05169866f, -0.00581718f, 0.23878722f, -0.09530889f, -0.43476045f, 
    -0.26304331f, -0.06029924f, -0.08143409f, -0.19188075f, -0.23071335f, 0.12835437f, -0.00494343f, 0.03575036f, 
    0.02488424f, -0.08282533f, 0.05682740f, 0.00507525f, -0.22446997f, -0.05436635f, -0.05700887f, -0.17276086f, 
    0.41812447f, 0.36485034f, 0.01902624f, 0.09753392f, -0.05102572f, 0.09642753f, -0.21089734f, 0.06426461f, 
    -0.24222596f, 0.32138371f, 0.58697325f, 0.20668980f, -0.00357628f, 0.08826581f, -0.02160086f, 0.00029770f, 
    -0.01375084f, 0.19477247f, 0.03771666f, -0.11536575f, 0.17841005f, -0.00003924f, 0.00046740f, -0.14847191f, 
    -0.02080901f, 0.03425806f, 0.07123633f, 0.08070499f, 0.34804779f, -0.10250947f, 0.07163267f, -0.02709727f, 
    0.09935778f, 0.03173424f, 0.02266300f, 0.22576801f, -0.06142975f, 0.13020493f, 0.18528600f, 0.07312759f, 
    0.05317730f, 0.10720299f, -0.11027960f, 0.14283791f, -0.09036329f, -0.05786955f, 0.20876031f, -0.25025827f, 
    -0.00630992f, -0.12219507f, -0.10247708f, -0.02287830f, -0.05694513f, -0.19104213f, -0.19065988f, 0.27720848f, 
    0.13036111f, 0.11481833f, -0.02953416f, -0.01832965f, -0.01162841f, 0.13311361f, -0.06669211f, 0.17378746f, 
    -0.01509616f, -0.15884486f, 0.03354353f, -0.02427764f, 0.08114403f, 0.07503704f, -0.06430244f, 0.02264236f, 
    -0.25066516f, -0.10281966f, -0.18791087f, -0.44848588f, 0.01235786f, -0.12075816f, 0.14207974f, 0.03288472f, 
    -0.19124804f, -0.00494234f, 0.04403073f, 0.09409884f, 0.10064893f, -0.05104032f, 0.19923507f, -0.02726182f, 
    0.17376053f, 0.01193848f, 0.28904086f, -0.18002044f, 0.03972206f, 0.10645872f, 0.13113125f, 0.46643037f, 
    0.13657714f, -0.14045468f, 0.11139940f, 0.01494926f, -0.17290869f, -0.22574778f, -0.00879933f, 0.00203216f, 
    0.15428422f, 0.24630728f, 0.11416109f, 0.17293444f, -0.28528139f, 0.02410841f, 0.01869747f, 0.00436317f, 
    -0.15203364f, -0.19241787f, -0.16575924f, -0.06206272f, -0.24569871f, 0.03786198f, 0.40370506f, -0.09996025f, 
    -0.18105885f, 0.21732002f, 0.17334081f, -0.05579582f, 0.13231502f, 0.11095905f, -0.16395031f, -0.06587563f, 
    0.09665235f, -0.08170627f, 0.17044312f, 0.02180430f, -0.05165588f, 0.10704165f, -0.05771019f, 0.12064186f, 
    -0.09346996f, 0.16510473f, 0.16373043f, 0.13696232f, -0.14927827f, -0.22242662f, 0.01185514f, -0.10997150f, 
    0.09043628f, -0.01914007f, 0.09238157f, -0.17574294f, 0.04402491f, 0.07490647f, 0.15796760f, -0.00013092f, 
    -0.08018436f, 0.05450593f, -0.04358155f, -0.15108350f, 0.02892220f, -0.08896217f, 0.07927128f, -0.06743117f, 
    -0.20213336f, 0.00523589f, 0.18564542f, 0.07620813f, -0.07150315f, 0.21844327f, 0.17168316f, -0.05636652f, 
    -0.00037564f, -0.39849773f, 0.12134453f, 0.35574108f, 0.48096356f, -0.00153722f, -0.23427582f, 0.21029042f, 
    -0.00205071f, -0.08296578f, 0.12970968f, -0.04567248f, 0.01582370f, -0.48011047f, 0.19428095f, -0.03699140f, 
    -0.01470651f, -0.15000397f, 0.05772991f, -0.12529410f, -0.05711352f, -0.09791774f, -0.01275976f, -0.03192955f, 
    0.07912853f, -0.30978224f, -0.11556181f, 0.17565195f, -0.12074107f, 0.07464820f, -0.25109571f, -0.13856065f, 
    -0.01715397f, -0.36519340f, -0.34130052f, -0.06249316f, 0.08616553f, -0.15457171f, 0.08102427f, 0.08369368f, 
    0.05142600f, 0.06901751f, 0.08813767f, -0.13660319f, -0.22440998f, -0.08905631f, 0.15705876f, 0.09754268f, 
    0.09674113f, -0.18688506f, -0.08444455f, 0.12061950f, -0.39140195f, 0.13061270f, 0.12635623f, -0.16663888f, 
    0.04407697f, -0.02655258f, 0.02735226f, 0.05408188f, -0.06731069f, -0.11731348f, -0.43405771f, -0.00215263f, 
    -0.31722915f, -0.04390660f, 0.15851943f, 0.20031357f, -0.03823050f, 0.04876130f, -0.18224552f, -0.33509693f, 
    0.19220440f, -0.08535083f, 0.22316322f, 0.43881455f, 0.04573561f, 0.00404194f, 0.02174048f, 0.08158584f, 
    0.29503921f, 0.19367680f, 0.11897739f, 0.11130549f, -0.23371567f, -0.13248324f, 0.15409382f, -0.03594479f, 
    0.19073585f, -0.10031699f, 0.11106116f, 0.03543206f, 0.40327460f, 0.24199839f, 0.02067429f, 0.03131415f, 
    -0.11456456f, -0.06898362f, -0.19896668f, -0.03410446f, 0.16772485f, -0.20409688f, 0.12581109f, 0.22814637f, 
    -0.07209017f, 0.10728711f, -0.02929224f, 0.13444988f, -0.02687569f, -0.16678688f, -0.41950846f, 0.05841358f, 
    -0.02764944f, 0.03564785f, 0.01512733f, 0.07379477f, 0.17305417f, 0.00649982f, 0.15953799f, -0.11459144f, 
    0.39773655f, 0.50601882f, -0.10324805f, -0.07027776f, 0.05988612f, 0.01403007f, 0.09556730f, -0.00558445f, 
    -0.03427239f, -0.01130144f, -0.12627684f, 0.12295200f, -0.09432053f, -0.09235902f, -0.04550705f, 0.16434245f, 
    -0.07951738f, -0.26321092f, -0.09259619f, 0.21973184f, -0.02473524f, -0.12167862f, 0.05922286f, 0.07650304f, 
    -0.01829731f, -0.36095300f, 0.08536556f, 0.10484657f, 0.18429911f, 0.10972123f, -0.17773455f, 0.11065102f, 
    0.06835499f, -0.13526034f, 0.01198301f, -0.05831458f, 0.13760874f, -0.35424703f, 0.16232824f, 0.20247847f, 
    0.04088006f, 0.05408287f, 0.01498383f, -0.15194385f, 0.46473259f, 0.33097959f, 0.09091526f, -0.33087811f, 
    -0.06763958f, -0.00035844f, -0.01068823f, 0.14224528f, -0.01693794f, 0.01317692f, -0.06157423f, -0.06349006f, 
    -0.27779904f, 0.01260451f, -0.01622977f, 0.01610319f, -0.02681824f, -0.14305471f, -0.09340909f, -0.04598961f, 
    -0.14331637f, 0.09754690f, -0.10371052f, -0.05678106f, 0.14699680f, 0.40503189f, -0.06584207f, 0.07054793f, 
    0.07254630f, -0.21767139f, -0.07847375f, 0.06802009f, -0.13357978f, -0.03357555f, -0.00955862f, 0.02057266f, 
    -0.16758063f, -0.04915728f, 0.25743523f, -0.06286669f, -0.07113194f, 0.02369957f, 0.14605755f, -0.10574595f, 
    -0.09966929f, 0.35768184f, -0.01255398f, 0.15055269f, -0.00034081f, -0.14856461f, 0.11215754f, 0.00454479f, 
    0.25368348f, -0.03522069f, 0.23825651f, -0.23193698f, -0.11698230f, 0.16078487f, 0.10722236f, -0.06412126f, 
    0.15629317f, -0.22673193f, -0.12456549f, -0.07186129f, 0.25357655f, -0.37284535f, -0.03770330f, 0.04544274f, 
    -0.03179031f, 0.06587715f, 0.00903761f, -0.15847731f, 0.33194524f, 0.20202497f, -0.13116206f, -0.00980358f, 
    -0.01234860f, -0.05369874f, 0.05391731f, -0.02649877f, -0.28565136f, -0.04790384f, -0.03700781f, -0.14343886f, 
    -0.03304321f, -0.00481389f, 0.13873282f, 0.14654945f, 0.07191904f, -0.11527583f, 0.43592900f, 0.33798254f, 
    0.22629081f, 0.06908374f, -0.01294726f, 0.06910557f, -0.13122161f, 0.01162939f, 0.02220128f, 0.22411992f, 
    -0.07764467f, 0.47094637f, 0.06889853f, -0.07798406f, -0.02217408f, -0.02614581f, -0.06333662f, 0.04641408f, 
    0.63898993f, 0.29892191f, -0.23380709f, -0.01860689f, -0.07293141f, -0.13551283f, -0.05092891f, -0.04289556f, 
    -0.04797756f, -0.24545734f, -0.13952430f, -0.09690031f, -0.09371892f, 0.27139598f, -0.04946898f, 0.16047743f, 
    0.15133423f, 0.01753916f, -0.17962104f, -0.30976695f, -0.01669511f, -0.09014223f, -0.08003522f, -0.01860697f, 
    -0.07797983f, 0.04696428f, 0.01389821f, 0.28572845f, 0.26748681f, 0.38043845f, -0.10068208f, 0.18967587f, 
    0.02958726f, 0.24828793f, 0.14599073f, 0.04942250f, 0.04375476f, -0.15953262f, -0.54142356f, -0.07455865f, 
    0.11956386f, -0.13268818f, -0.09464920f, 0.07559823f, 0.10266041f, 0.24345914f, 0.04249079f, -0.09725546f, 
    -0.07139198f, -0.04223591f, 0.03378350f, -0.06665143f, -0.10551698f, 0.06664083f, -0.74211508f, 0.01558479f, 
    0.20390975f, -0.00291169f, 0.10948942f, -0.13553132f, -0.03339146f, 0.04943503f, -0.08489932f, 0.01620060f, 
    -0.15515295f, -0.35295931f, 0.23175134f, 0.05821444f, -0.00582142f, 0.10641939f, -0.19514121f, 0.02881271f, 
    0.10278004f, 0.13988684f, -0.08051836f, 0.11258691f, 0.03191023f, 0.16372268f, -0.15271975f, 0.04195586f, 
    -0.03717131f, -0.10702588f, -0.12861557f, -0.17772390f, -0.36146554f, 0.10644098f, -0.05824584f, -0.12111522f, 
    0.26049885f, 0.14372401f, -0.09488092f, -0.51961440f, -0.07168519f, -0.02190744f, 0.03413527f, 0.19687168f, 
    0.11085660f, -0.02423119f, -0.24196087f, 0.10098164f, 0.16958995f, 0.14727500f, 0.16916078f, -0.09441151f, 
    0.26747230f, 0.05291243f, -0.06308243f, -0.15146528f, -0.16883208f, -0.24911538f, -0.22898860f, 0.01989998f, 
    0.02325047f, -0.06085908f, -0.08309720f, 0.15477905f, -0.00278301f, -0.37208745f, -0.25369877f, 0.23044686f, 
    0.02783411f, 0.13280310f, -0.14374842f, -0.01747971f, -0.01502463f, 0.08300633f, 0.35530719f, 0.12733930f, 
    0.27651861f, -0.06553145f, 0.01306226f, -0.00162356f, 0.27517694f, -0.04719028f, 0.12759389f, -0.00009424f, 
    -0.21168053f, -0.25255993f, -0.15690289f, 0.04271743f, 0.13626611f, -0.06424384f, 0.05236147f, 0.03163668f, 
    0.11584944f, 0.01645374f, -0.49001822f, -0.09277426f, -0.16867748f, -0.04521791f, 0.04833796f, -0.03969755f, 
    0.06740861f, -0.11121877f, -0.18862033f, -0.14400031f, -0.01657693f, 0.11371802f, 0.21397597f, -0.09158672f, 
    0.00183954f, 0.13434881f, -0.15239552f, 0.05306318f, -0.39152619f, -0.08741397f, 0.00983841f, 0.07640381f, 
    0.04079319f, 0.09815287f, -0.01238907f, -0.01546991f, 0.16042091f, 0.45139873f, 0.04541386f, 0.03408620f, 
    -0.04475180f, -0.05763379f, 0.11105835f, 0.01818709f, -0.24005988f, -0.51819402f, -0.29596522f, 0.23997410f, 
    -0.07014980f, 0.14826056f, -0.14681034f, -0.06875980f, 0.07913163f, 0.09054726f, -0.10236973f, 0.03870974f, 
    -0.06773146f, 0.13524136f, 0.14696547f, -0.02363165f, -0.03001782f, 0.07690308f, -0.05295861f, -0.24708295f, 
    -0.26431900f, 0.19731326f, 0.06077113f, 0.03903724f, -0.06003665f, 0.06784680f, -0.01862869f, -0.17016976f, 
    -0.37555835f, 0.07876188f, -0.02760947f, -0.03284019f, 0.16523229f, 0.09835932f, 0.06823471f, -0.09993427f, 
    0.31191453f, 0.12586035f, -0.21716309f, 0.31125104f, -0.11460420f, 0.12459084f, -0.05678426f, -0.04487593f, 
    -0.05481810f, -0.08255045f, -0.17723076f, 0.05901120f, -0.11692755f, 0.44721743f, 0.06823052f, 0.18219402f, 
    0.13387676f, -0.01851606f, -0.24096118f, -0.18211591f, -0.22506398f, -0.23771845f, 0.02236055f, -0.14062694f, 
    -0.22325377f, 0.20268735f, 0.15798460f, -0.08754193f, -0.04856944f, 0.07663465f, -0.17298801f, -0.12876083f, 
    -0.02952610f, 0.10550291f, -0.05945988f, 0.04546055f, 0.47885448f, -0.09616060f, -0.37287304f, -0.04779044f, 
    -0.11974586f, -0.19241065f, -0.11446681f, -0.01085384f, -0.23800872f, 0.00571949f, -0.13497260f, 0.14060909f, 
    -0.05098425f, -0.03007139f, 0.09640554f, -0.12626892f, 0.05918400f, 0.02943845f, -0.36123213f, 0.28100657f, 
    -0.36039606f, 0.00241209f, 0.17278589f, -0.02548320f, -0.04733213f, -0.09785639f, -0.00699669f, 0.40825570f, 
    0.38482741f, 0.16883443f, 0.05178350f, -0.13249193f, -0.15935928f, 0.05654090f, -0.03245761f, 0.03716844f, 
    -0.34253892f, -0.00559019f, -0.08488873f, 0.04407991f, -0.18166940f, 0.02962594f, 0.25191608f, 0.05488984f, 
    -0.19346467f, -0.33248907f, 0.20103179f, 0.19636531f, 0.02162440f, -0.19762534f, -0.06890049f, 0.04135409f, 
    -0.03982690f, -0.15022580f, -0.25700113f, 0.21068723f, 0.18864574f, 0.01049699f, 0.05124462f, 0.09298942f, 
    -0.08610478f, 0.10065283f, 0.15005930f, 0.04887811f, -0.26406100f, -0.29592445f, 0.14925997f, -0.00928963f, 
    0.10689297f, 0.20581928f, 0.03740694f, 0.05303595f, 0.21790951f, 0.06726845f, -0.01066209f, -0.03199849f, 
    -0.07140522f, -0.06711178f, 0.03863511f, 0.00182023f, 0.01052147f, -0.08891413f, 0.16507384f, -0.15169364f, 
    0.06968233f, 0.01881154f, -0.17486712f, -0.04478216f, 0.04514241f, -0.04765185f, 0.33222607f, -0.34786597f, 
    0.01758428f, -0.03089743f, 0.15237994f, 0.17574508f, 0.10675821f, -0.00541511f, 0.02585853f, 0.09256507f, 
    -0.06783377f, -0.10723179f, -0.15699242f, 0.11351214f, 0.17129453f, -0.00671854f, 0.02823709f, 0.02564857f, 
    -0.19739628f, 0.16861865f, -0.37455741f, 0.22027838f, -0.09410854f, -0.15646222f, -0.09642439f, -0.13507894f, 
    0.00866101f, 0.23766580f, 0.00305362f, 0.33284295f, -0.35086441f, 0.13212448f, 0.03999114f, -0.04563116f, 
    0.08604463f, 0.29445061f, -0.07067768f, 0.14296353f, 0.25475833f, -0.03308196f, -0.08022988f, 0.05772585f, 
    -0.18066956f, -0.09850250f, 0.20341159f, -0.01153483f, -0.08069825f, -0.16493255f, -0.12654752f, 0.12430172f, 
    -0.07663398f, 0.14965822f, -0.01760594f, 0.05244042f, -0.24412908f, 0.07104934f, 0.18411335f, -0.06317969f, 
    0.06433583f, -0.08126095f, -0.19551806f, -0.04332917f, 0.25465962f, 0.23991950f, 0.09632852f, 0.26893008f, 
    0.02452185f, -0.19764413f, -0.00944317f, 0.03894787f, -0.18758173f, 0.14470159f, 0.03931718f, 0.09583884f, 
    -0.21136773f, 0.01206385f, 0.06165191f, 0.04358819f, 0.05024153f, 0.04134900f, -0.14918140f, -0.02822015f, 
    0.06517272f, 0.05292478f, 0.13060704f, -0.05032194f, -0.01345447f, -0.11535228f, -0.03538157f, 0.25202245f, 
    -0.18430075f, -0.03710558f, 0.25779745f, -0.22723277f, 0.05277316f, 0.01016830f, 0.00783927f, 0.04867775f, 
    -0.04431914f, 0.11277138f, -0.15439582f, 0.24092089f, 0.03498936f, -0.11442900f, -0.06765963f, -0.05168356f, 
    0.12081864f, 0.01805821f, 0.14917827f, -0.01471730f, -0.10277240f, 0.02333696f, -0.05762189f, 0.12168203f, 
    0.02951176f, 0.14563872f, 0.01821199f, -0.35445383f, 0.17788231f, -0.01064428f, -0.10036247f, 0.05128465f, 
    -0.15582775f, -0.05191071f, 0.09333690f, 0.16391376f, 0.29728213f, -0.16587618f, 0.21946107f, 0.14699046f, 
    0.02350633f, -0.28802890f, 0.08851273f, 0.12348337f, 0.14627922f, -0.55102968f, -0.08471032f, 0.00312166f, 
    0.13377787f, -0.10655496f, 0.13440101f, -0.13679618f, -0.16736205f, -0.23899588f, -0.26074401f, -0.15653650f, 
    -0.24139482f, 0.00709834f, -0.13820608f, -0.08791476f, 0.14060189f, 0.03599780f, 0.13052569f, 0.41709074f, 
    -0.18956238f, -0.22806710f, 0.17877845f, 0.11714970f, 0.19296633f, -0.15772158f, -0.18766716f, 0.08534078f, 
    -0.08397248f, -0.03507494f, 0.06380908f, 0.11604656f, 0.04146589f, 0.02673092f, -0.04154944f, 0.06711562f, 
    -0.20800377f, -0.04512937f, 0.05444933f, -0.29528400f, -0.04010070f, 0.09240072f, 0.06873230f, 0.22513220f, 
    0.01046753f, 0.03262677f, 0.22905882f, -0.03111929f, -0.26473895f, 0.07057585f, -0.18592310f, -0.18245336f, 
    -0.02563387f, 0.01564431f, 0.23508717f, -0.06908787f, -0.00205845f, 0.18263116f, 0.03534394f, -0.02514895f, 
    0.04596185f, -0.03291593f, -0.19831032f, 0.07083122f, 0.03273669f, 0.15959315f, 0.06992768f, -0.49196282f, 
    -0.01045759f, -0.17842951f, -0.12053922f, 0.08219192f, -0.18914373f, -0.01621221f, -0.06964013f, -0.28364316f, 
    0.05992847f, 0.09598994f, 0.28077629f, -0.06938574f, 0.11357274f, 0.03711335f, -0.26311409f, 0.36044750f, 
    0.07755367f, 0.24164066f, 0.04335209f, 0.34126475f, -0.22683483f, 0.09005900f, 0.19876775f, -0.08137780f, 
    -0.02184328f, 0.23517233f, 0.08067958f, 0.22063245f, 0.00237174f, 0.09915803f, -0.15594885f, -0.07166615f, 
    -0.74791300f, -0.17213462f, 0.13637117f, -0.19470513f, 0.25637561f, 0.02975457f, 0.06948963f, -0.04530449f, 
    -0.18888037f, -0.91822898f, -0.32040855f, 0.45316574f, 0.10559056f, 0.24838185f, -0.22510765f, 0.09736784f, 
    -0.06631827f, -0.18649635f, -0.52901328f, -0.21632756f, -0.07116414f, -0.00609032f, 0.22880249f, 0.12956895f, 
    -0.21392225f, -0.00696878f, -0.21369803f, -0.09572134f, -0.00682481f, 0.02867091f, 0.06481697f, 0.30355120f, 
    -0.11058418f, -0.10117223f, 0.14454253f, -0.02259353f, -0.05565783f, -0.26473320f, 0.33207449f, 0.33396786f, 
    -0.05761123f, 0.07532085f, -0.04035215f, 0.08572922f, 0.16740885f, 0.20735720f, 0.03568420f, -0.02065265f, 
    -0.09493028f, -0.02225151f, 0.11995132f, 0.23439854f, 0.06866621f, 0.36458135f, 0.11282275f, -0.04847331f, 
    -0.17826228f, -0.05141193f, -0.06111961f, 0.03827500f, -0.02264945f, 0.17359397f, 0.12377039f, -0.16803648f, 
    -0.34563032f, -0.27237284f, 0.15683581f, 0.04187620f, -0.11080601f, -0.05244143f, 0.07588101f, -0.00105404f, 
    0.23759636f, 0.10020007f, 0.01806043f, -0.02311943f, -0.00705079f, 0.04334154f, 0.04630644f, 0.31027147f, 
    0.23497681f, 0.25170246f, 0.26979989f, 0.14103930f, 0.04421479f, 0.09348398f, -0.01393132f, -0.13868897f, 
    0.17098379f, 0.10616324f, -0.51796281f, -0.03718369f, 0.08212834f, 0.25527096f, 0.25351754f, 0.17914402f, 
    -0.10075939f, 0.12284420f, 0.27821505f, 0.22862172f, 0.16058159f, 0.02090390f, 0.07817052f, -0.00052486f, 
    0.15222713f, -0.13005993f, -0.05812854f, -0.12795021f, 0.17538077f, 0.06524592f, 0.03505481f, 0.01941005f, 
    0.06621522f, 0.03611910f, -0.06823922f, 0.17266878f, 0.23408596f, -0.07178951f, 0.15584433f, 0.12437627f, 
    -0.07446619f, -0.27227578f, 0.07836344f, 0.02418368f, 0.17431004f, 0.03359324f, 0.03554651f, 0.00714337f, 
    0.29190153f, 0.07855383f, 0.13906927f, -0.01078011f, -0.22890098f, 0.25662994f, 0.09096476f, -0.39603767f, 
    -0.14841722f, 0.10624334f, 0.21986572f, 0.13648988f, 0.01041444f, -0.06861766f, 0.14674273f, -0.08764903f, 
    -0.24547115f, 0.19252321f, 0.59616846f, 0.27034506f, 0.16016307f, 0.15876694f, 0.14718650f, 0.07364007f, 
    -0.06655253f, -0.36342797f, -0.02339623f, -0.00471203f, 0.01277169f, -0.27059180f, -0.06397787f, -0.05914396f, 
    0.15961643f, -0.30315670f, -0.51711738f, -0.05843552f, 0.24757086f, 0.27861583f, 0.19959255f, 0.01869453f, 
    0.12684321f, 0.12326998f, 0.06878982f, -0.17574674f, 0.01481415f, -0.07895777f, -0.21717751f, -0.26713270f, 
    -0.42195451f, 0.19658588f, -0.02564437f, -0.00302929f, 0.42440122f, 0.28288135f, -0.51111925f, 0.09153494f, 
    0.01977456f, -0.09094454f, 0.17532928f, -0.13468061f, 0.09148149f, -0.40830499f, -0.29714024f, -0.03053243f, 
    -0.13676937f, -0.17474373f, 0.03854138f, 0.27761853f, -0.24446736f, -0.30351764f, 0.04554490f, 0.12354351f, 
    -0.10358442f, -0.20997761f, -0.12123487f, -0.16779861f, 0.09238687f, 0.17685807f, -0.04853856f, 0.28129691f, 
    0.02987355f, -0.14423881f, 0.08843953f, -0.08044036f, 0.01795155f, 0.09144449f, -0.06098882f, 0.04943021f, 
    -0.26190877f, -0.51801336f, 0.00941786f, 0.03888597f, 0.17722590f, -0.14972988f, 0.12598564f, -0.03612584f, 
    0.02960408f, 0.40862691f, 0.08192886f, -0.11721083f, -0.06920876f, -0.12296676f, 0.00683037f, 0.42839903f, 
    -0.05798190f, 0.18952870f, 0.17547710f, -0.12373169f, 0.02923760f, 0.08030444f, 0.02311001f, -0.19481669f, 
    -0.20730951f, 0.13458534f, 0.04202051f, -0.51543158f, 0.09430966f, -0.33207795f, 0.06490028f, -0.01114665f, 
    0.11439890f, -0.21482271f, -0.04999498f, -0.09493268f, 0.21521918f, 0.14816242f, -0.04067572f, 0.02081149f, 
    -0.19335426f, -0.04375793f, 0.10314915f, -0.19748877f, 0.04468228f, 0.12567373f, 0.12522288f, 0.07199161f, 
    0.25213313f, 0.04745170f, -0.05646937f, 0.02239455f, -0.10400540f, 0.07998252f, -0.16799022f, -0.09629216f, 
    0.06286996f, 0.25273076f, -0.12130281f, 0.08301079f, -0.08040071f, 0.08509340f, 0.05102743f, -0.33098808f, 
    -0.24097583f, 0.15189436f, 0.08137888f, 0.15094747f, 0.09808147f, -0.04240276f, -0.02563164f, -0.20974354f, 
    -0.14397258f, -0.25848156f, -0.09728025f, -0.01914619f, 0.28689924f, 0.04867931f, -0.09836398f, -0.32899931f, 
    0.25454718f, -0.50254726f, -0.08375148f, -0.24552600f, 0.00790857f, 0.14667760f, 0.07750532f, -0.19357173f, 
    -0.14958604f, 0.04535468f, 0.18560354f, -0.43130308f, -0.45973617f, 0.08758837f, 0.10593908f, 0.01466342f, 
    -0.23776066f, -0.04052252f, -0.36238685f, -0.01199838f, 0.12689614f, 0.01850929f, -0.01085840f, -0.23732038f, 
    0.07538036f, 0.12604879f, 0.07213336f, -0.12265228f, 0.04423433f, -0.12052707f, -0.20168723f, 0.26441747f, 
    0.07700688f, 0.06618855f, -0.00291510f, -0.02442767f, -0.04162920f, -0.00209804f, -0.31116807f, 0.03984740f, 
    -0.01681502f, 0.11855619f, 0.21868390f, -0.00229416f, 0.02112185f, -0.03248341f, -0.02410875f, 0.23342209f, 
    0.01331745f, 0.13733219f, -0.22792827f, 0.07989380f, 0.11617217f, 0.16357766f, 0.13903657f, -0.24051584f, 
    -0.22604999f, -0.28318676f, 0.34968805f, -0.03814190f, 0.00116818f, 0.07596416f, 0.01837236f, -0.02685982f, 
    -0.06881784f, -0.02880459f, 0.17739983f, -0.00275545f, 0.30238813f, 0.22775400f, 0.02055105f, 0.04126908f, 
    0.28287578f, 0.15316427f, 0.26900643f, -0.29646963f, 0.06270909f, 0.09414561f, 0.01867155f, 0.23409069f, 
    0.04564409f, 0.14879225f, -0.30587944f, -0.19409291f, -0.09319685f, 0.32635936f, 0.16574700f, -0.08696084f, 
    -0.00956095f, 0.17828727f, -0.03027829f, 0.35150224f, 0.20459473f, 0.00179099f, -0.12069810f, -0.06909421f, 
    -0.05735895f, 0.08355983f, -0.10339722f, 0.08531145f, -0.13018857f, -0.14887285f, -0.23619936f, 0.03424810f, 
    -0.03164664f, -0.00557818f, 0.12534301f, 0.04978096f, 0.18780391f, -0.21902576f, 0.18381685f, -0.03147836f, 
    0.21041101f, -0.15032373f, 0.10010582f, 0.28910279f, -0.15565804f, 0.18087803f, 0.22549842f, 0.08992476f, 
    0.19919449f, 0.10393386f, 0.01505078f, -0.06189742f, 0.10707048f, 0.06981111f, 0.02946998f, -0.01406968f, 
    -0.21867208f, -0.53114635f, 0.01138227f, 0.04476484f, -0.15493859f, 0.22590579f, -0.16167927f, -0.25185156f, 
    -0.10375504f, 0.13351837f, 0.01836854f, 0.08669467f, 0.20066079f, 0.20370224f, -0.08154044f, 0.09156236f, 
    -0.12728859f, -0.13066505f, -0.03798681f, -0.45065260f, 0.03701235f, 0.02492589f, 0.18960848f, 0.17857076f, 
    -0.10471045f, -0.04002246f, -0.01566220f, 0.11057141f, -0.15071942f, -0.11995366f, 0.10144028f, 0.09684721f, 
    0.25682890f, -0.05438984f, 0.03090151f, 0.36524597f, -0.10071197f, 0.06937375f, 0.19201511f, -0.20509417f, 
    -0.29722038f, -0.05410350f, -0.06777184f, 0.23691261f, 0.16692390f, 0.11907680f, -0.22672886f, 0.03796549f, 
    -0.06922530f, -0.02646321f, 0.04831662f, -0.14304130f, -0.18038629f, 0.00311067f, -0.34852964f, -0.11527646f, 
    0.07204132f, 0.00204270f, -0.20699863f, -0.28586540f, 0.05494153f, -0.35125333f, 0.22194926f, -0.13351631f, 
    0.13589364f, 0.12456011f, 0.07259832f, -0.36370450f, 0.20635287f, -0.01251588f, 0.17163849f, 0.43829823f, 
    0.15423550f, -0.16572167f, -0.01590030f, 0.05218769f, 0.08096018f, 0.10729193f, 0.13286796f, -0.05342020f, 
    -0.02795792f, 0.02058417f, -0.05552424f, 0.02871874f, -0.00521347f, 0.04238258f, -0.03601155f, 0.00006712f, 
    -0.05207133f, -0.01974848f, 0.01313056f, 0.00202133f, -0.03719081f, -0.06613985f, 0.03511890f, 0.00621264f, 
    -0.03144918f, 0.00412019f, -0.00857816f, 0.03078773f, 0.00389295f, 0.02073261f, 0.00141241f, 0.03523545f, 
    -0.01217619f, -0.01904476f, -0.01896221f, 0.02144617f, -0.04330653f, -0.01866725f, -0.05840722f, -0.01452306f, 
    0.03337975f, 0.03989943f, -0.01698626f, -0.06204830f, -0.04478144f, -0.01676480f, 0.00495102f, 0.05301254f, 
    0.02776944f, -0.01436237f, -0.05279398f, -0.03567003f, -0.01314779f, -0.04008979f, -0.02794704f, -0.00638244f, 
    -0.03453211f, -0.00010052f, 0.03549607f, 0.01604223f, -0.06623960f, -0.06161948f, -0.00047033f, 0.02352394f, 
    -0.06190853f, -0.06565064f, -0.02099252f, -0.05202361f, -0.04933297f, -0.03579224f, -0.05637347f, 0.02077593f, 
    -0.02262115f, -0.02080592f, -0.06279331f, 0.00805141f, -0.05599013f, -0.01057469f, -0.04159283f, -0.06489774f, 
    0.04157190f, 0.00149285f, 0.03552786f, -0.04002000f, -0.04022066f, -0.02691198f, 0.00974357f, 0.01984231f, 
    0.02655901f, 0.02174012f, 0.03257314f, -0.02819838f, 0.03991194f, 0.03116976f, 0.03583162f, -0.03749424f, 
    0.04107912f, 0.04296881f, -0.06363823f, -0.00537961f, -0.03458179f, 0.00391181f, -0.02311112f, -0.03674323f, 
    -0.06344937f, 0.03746532f, -0.00859468f, 0.01512618f, -0.03082737f, -0.06319122f, 0.00121300f, -0.02965282f, 
    0.02246330f, -0.02863913f, 0.04064496f, -0.03018443f, -0.06105173f, -0.05218063f, -0.02487610f, -0.04277169f, 
    0.01782718f, -0.03945009f, 0.02236934f, -0.03539544f, -0.05307718f, -0.05366538f, 0.00937527f, 0.05060193f, 
    -0.00740715f, -0.03222744f, -0.06101640f, -0.01990231f, -0.03262187f, 0.03580896f, 0.04107519f, -0.06189380f, 
    -0.03621328f, -0.05411223f, -0.05186740f, -0.00942566f, -0.03508678f, 0.03526082f, -0.05831338f, -0.00780425f, 
    0.04407059f, -0.04762131f, -0.02750758f, -0.05355395f, -0.04030464f, 0.03246612f, 0.04759412f, 0.02164285f, 
    0.00776620f, 0.01279237f, -0.04919964f, 0.00565554f, -0.04294299f, -0.01864660f, 0.01223782f, 0.00815234f, 
    -0.02525296f, 0.04859741f, -0.03985510f, 0.01695249f, -0.03518496f, -0.04597077f, -0.00665773f, 0.03086918f, 
    0.02056099f, -0.00885933f, -0.02351043f, -0.04842085f, -0.00222162f, -0.04966215f, 0.04452801f, -0.04076559f, 
    -0.00605599f, -0.04577610f, 0.02785427f, 0.04370924f, 0.03259375f, 0.04979750f, -0.01614454f, 0.04760794f, 
    0.00896119f, -0.01487678f, 0.03111214f, -0.03004685f, -0.06096697f, -0.06539933f, -0.00522953f, 0.00796285f, 
    0.04622263f, -0.00576844f, -0.01136381f, -0.02028873f, 0.04672349f, 0.02384407f, 0.03094722f, -0.05508466f, 
    0.00112822f, -0.00225612f, -0.02661021f, -0.02199561f, 0.02699548f, -0.00187651f, 0.00162044f, 0.02559164f, 
    0.04187098f, -0.05215318f, 0.03614223f, 0.02994342f, -0.00149013f, 0.04520573f, 0.04159975f, -0.01766473f, 
    0.03293784f, -0.03950150f, -0.01899985f, 0.01340200f, 0.00264496f, 0.04959094f, -0.02346949f, 0.04440613f, 
    0.02757769f, 0.01466955f, -0.01926379f, -0.01517432f, -0.05226863f, 0.00219530f, 0.03892721f, 0.02776203f, 
    0.03632998f, 0.01355333f, -0.02432914f, -0.05499293f, -0.02828659f, -0.03156836f, -0.00957916f, 0.03498371f, 
    -0.00421823f, 0.01544872f, 0.00541955f, 0.02349210f, 0.02675388f, -0.02975895f, -0.00874571f, -0.01616550f, 
    -0.05986898f, 0.04043840f, -0.00566207f, 0.00751175f, 0.04584260f, -0.02991222f, 0.00932062f, -0.01699864f, 
    0.00299436f, 0.01766767f, -0.04257262f, -0.01260272f, -0.03664334f, 0.02520514f, -0.06372885f, 0.01588700f, 
    0.02488817f, 0.04021596f, -0.03079610f, 0.04689959f, 0.01588892f, -0.06236079f, -0.03659619f, 0.02570127f, 
    -0.02473223f, 0.02602036f, 0.01885490f, 0.02316700f, 0.01807433f, -0.06438209f, -0.02387423f, -0.04756117f, 
    0.03447139f, -0.05046836f, 0.05022802f, 0.02287112f, -0.06048997f, -0.02625169f, -0.02193512f, 0.01346683f, 
    0.00493002f, -0.03148458f, 0.04205811f, 0.01799698f, 0.02259418f, 0.00926676f, -0.02096962f, 0.01959422f, 
    -0.00155103f, 0.03196152f, -0.03665610f, -0.06056980f, 0.00843685f, 0.02311281f, -0.01529102f, -0.02456202f, 
    -0.00873076f, 0.03929009f, 0.04521006f, -0.00757675f, 0.04551172f, -0.05660320f, -0.05306219f, 0.03456231f, 
    -0.01871379f, -0.00677369f, 0.02921449f, -0.00412829f, -0.02540074f, 0.02574220f, -0.01222513f, 0.02180598f, 
    -0.04629609f, -0.03136250f, 0.02206208f, -0.04064323f, 0.04445824f, 0.00678952f, -0.00964590f, 0.02310139f, 
    -0.00835979f, 0.04669171f, -0.01862263f, -0.02826661f, -0.04952589f, -0.02715516f, -0.03635240f, -0.03161019f, 
    -0.05917096f, 0.04277751f, -0.05515935f, 0.01191469f, -0.01702115f, 0.05152811f, -0.01713880f, 0.01333262f, 
    -0.00612772f, -0.05349929f, -0.01716338f, 0.02129186f, 0.03698191f, -0.05380696f, -0.01933152f, 0.03019363f, 
    -0.05909656f, -0.01823533f, 0.01467462f, -0.02197052f, 0.03589368f, -0.04709929f, 0.00728945f, 0.00204182f, 
    -0.05241447f, 0.02809036f, -0.03112025f, 0.01004745f, 0.00151905f, 0.04235777f, 0.01372065f, -0.02940358f, 
    0.00383594f, 0.04049257f, -0.04766462f, 0.02951461f, -0.00798410f, 0.03727411f, -0.05845143f, 0.00148232f, 
    -0.00200251f, -0.04085116f, 0.01818662f, -0.03779444f, 0.01520453f, -0.01999057f, 0.03178056f, 0.03729407f, 
    -0.03825136f, -0.03386155f, 0.00178255f, -0.03960285f, -0.03727725f, -0.05456293f, -0.01178383f, -0.04360342f, 
    0.00897147f, -0.05722832f, -0.02618542f, -0.01476974f, 0.03516531f, 0.03100595f, -0.04552045f, -0.00625931f, 
    0.01538943f, -0.00847762f, -0.02503537f, -0.02937957f, 0.00237013f, 0.03930716f, -0.04814978f, -0.06203606f, 
    -0.05048950f, -0.01999323f, 0.04105750f, -0.04189011f, -0.05823253f, -0.04682044f, -0.04301930f, -0.01813637f, 
    -0.04681623f, 0.00136692f, 0.00123222f, -0.04775043f, 0.00573168f, 0.03784340f, 0.01693917f, 0.01709551f, 
    -0.03294806f, -0.01371822f, 0.01839465f, 0.02811021f, -0.01178185f, 0.01968273f, 0.04267459f, 0.03608237f, 
    -0.03218218f, -0.06139627f, 0.03773881f, -0.00195654f, -0.06443474f, 0.04740878f, -0.01918304f, -0.01101672f, 
    -0.04980524f, 0.03775564f, -0.03702964f, -0.06408217f, -0.02760637f, -0.05579346f, -0.03491951f, -0.03375342f, 
    -0.00467277f, 0.03032226f, 0.03883781f, -0.04108806f, 0.00458511f, -0.04361699f, 0.05243638f, 0.01559408f, 
    -0.06429201f, 0.00436758f, 0.03274210f, -0.01470586f, -0.05198171f, -0.05541705f, -0.01959397f, -0.00999704f, 
    -0.04917298f, 0.05731343f, -0.02952297f, -0.04457145f, -0.03361898f, -0.02922484f, -0.01929277f, -0.04526204f, 
    -0.04214999f, 0.03784930f, 0.02500384f, -0.05013333f, -0.04850829f, 0.02082139f, -0.00954414f, 0.01620175f, 
    -0.05764529f, 0.00753893f, -0.01786336f, 0.03034590f, 0.04326450f, 0.04432281f, 0.05023301f, -0.04531050f, 
    -0.00967660f, -0.01104947f, -0.04017533f, 0.02019075f, 0.04722977f, 0.02447807f, 0.00225091f, -0.05967711f, 
    -0.05546381f, 0.03542038f, -0.02403306f, 0.02763844f, 0.03815740f, 0.03431078f, 0.02699014f, -0.01136108f, 
    0.01259740f, 0.02748663f, 0.01769733f, -0.06116885f, 0.02469190f, -0.05677767f, 0.05093148f, -0.00343156f, 
    -0.04655407f, 0.05170901f, 0.03714252f, -0.02077060f, -0.04042880f, 0.03155987f, 0.03051655f, 0.04460451f, 
    -0.02406871f, 0.00533248f, 0.02540052f, 0.00584797f, 0.01497211f, -0.02294506f, -0.04771314f, -0.04849138f, 
    0.01056686f, 0.03401935f, 0.01620240f, -0.03998090f, -0.01037357f, -0.03606361f, -0.05957290f, 0.01029263f, 
    -0.06102363f, 0.01781069f, -0.03929847f, -0.03869003f, -0.02830497f, 0.00445627f, 0.03320276f, -0.02808607f, 
    -0.00989950f, -0.03028509f, -0.01337216f, -0.00982025f, -0.04740511f, -0.03779750f, -0.02674492f, -0.06157776f, 
    0.04420073f, 0.04623955f, 0.04518159f, -0.03628232f, -0.03292326f, 0.02230337f, 0.04181091f, -0.04964161f, 
    0.02308508f, -0.01747921f, -0.04466328f, -0.06472960f, -0.04634871f, -0.02968388f, -0.05152722f, -0.04540617f, 
    0.04453048f, -0.04932864f, -0.02798903f, 0.00481751f, -0.00084762f, 0.03128031f, 0.01102655f, -0.04063999f, 
    0.03319523f, -0.00254608f, -0.01713298f, -0.01450881f, -0.05138772f, -0.04314877f, -0.03960592f, -0.00074527f, 
    0.03105468f, -0.00983628f, -0.02902815f, 0.03780961f, -0.01488084f, -0.05606869f, -0.00800702f, 0.04287077f, 
    0.00876948f, -0.04354068f, -0.04521435f, -0.05164770f, 0.00642759f, -0.00607050f, 0.02201806f, -0.00168081f, 
    -0.01671273f, 0.03989638f, -0.03082802f, -0.05990974f, -0.01915224f, -0.04697718f, 0.02518134f, 0.04228426f, 
    -0.05670233f, -0.04865072f, 0.00112265f, -0.06047808f, -0.01212733f, -0.03770404f, 0.03976326f, -0.03339827f, 
    -0.01453715f, -0.01678589f, 0.01698926f, 0.02838688f, 0.02783216f, 0.01308825f, -0.01879480f, 0.01138060f, 
    0.00433696f, 0.01777038f, -0.05447556f, -0.04903866f, -0.03870480f, -0.01350191f, -0.04359203f, 0.01731146f, 
    -0.03275940f, -0.05649882f, 0.02430703f, -0.01553325f, 0.05104840f, 0.01269496f, -0.01245823f, -0.01217322f, 
    -0.04227819f, 0.05357337f, -0.00495529f, -0.05315756f, 0.03005724f, 0.01605881f, -0.00614443f, -0.04177038f, 
    -0.06149988f, 0.04645814f, 0.04528647f, 0.01663155f, 0.03625251f, -0.04135859f, -0.05495096f, 0.02988727f, 
    0.00332006f, -0.03703225f, -0.05392551f, -0.02838212f, -0.01560497f, -0.02834778f, 0.00524906f, 0.00079393f, 
    -0.02647681f, 0.01913639f, -0.07455991f, -0.01906073f, 0.03995185f, -0.05630230f, -0.02052667f, -0.04482532f, 
    -0.01925743f, 0.00437197f, 0.03485848f, -0.07415003f, -0.06963813f, -0.04951153f, -0.02771078f, -0.01783648f, 
    0.00645078f, -0.00618288f, -0.01461694f, -0.03141544f, 0.00109332f, -0.04043115f, -0.03367990f, 0.02651256f, 
    0.04316976f, 0.00649565f, -0.02159841f, -0.01417794f, -0.04611471f, -0.04275398f, -0.00131908f, -0.00498461f, 
    0.02566191f, -0.01354437f, 0.00727137f, 0.00762533f, -0.05733693f, 0.04188082f, 0.02719998f, 0.01773047f, 
    -0.06229999f, 0.00633097f, -0.02795603f, -0.05102142f, 0.01697960f, 0.02860622f, -0.01309502f, -0.04347114f, 
    0.00249562f, 0.01268370f, 0.00479308f, -0.01887923f, 0.01626212f, -0.02110352f, 0.00482158f, 0.00049541f, 
    -0.04302321f, -0.03170218f, -0.03627768f, -0.04690211f, -0.03709866f, 0.01933778f, -0.03861810f, 0.01819416f, 
    0.04289201f, -0.06285185f, 0.00306531f, 0.03432802f, 0.03885287f, 0.02241287f, -0.00337374f, -0.01665043f, 
    -0.04905407f, -0.07640376f, 0.01533017f, 0.02940265f, -0.00180993f, -0.03220986f, 0.02912113f, -0.01223486f, 
    -0.03050865f, -0.03861445f, -0.03720338f, 0.00469657f, 0.03705827f, 0.01920158f, 0.05418227f, 0.05118846f, 
    -0.01545545f, -0.03110936f, -0.03682178f, 0.01754447f, -0.03415830f, 0.04210829f, 0.02910363f, -0.06272058f, 
    -0.06367788f, 0.02466921f, 0.03307985f, -0.03379500f, -0.05509410f, 0.03637660f, -0.02015355f, 0.04838325f, 
    -0.05372201f, 0.00148702f, 0.04391456f, -0.06688533f, -0.06071200f, 0.02415062f, 0.01932863f, -0.06065459f, 
    -0.03377705f, 0.00532282f, -0.03882556f, 0.02169863f, 0.03561094f, 0.02891088f, 0.04924392f, -0.03969202f, 
    0.04516702f, -0.04611594f, 0.05457722f, -0.05155962f, 0.03115302f, 0.02337713f, -0.03630930f, 0.00184131f, 
    0.02572306f, 0.00568217f, 0.03940704f, 0.02971882f, 0.02550821f, 0.02967072f, -0.06797552f, -0.04971690f, 
    0.02127977f, 0.00369424f, -0.01746555f, 0.00901198f, -0.04404413f, -0.05098383f, 0.05018854f, -0.04222571f, 
    0.03398259f, 0.02098114f, 0.01287649f, -0.05060532f, -0.05286792f, -0.05989016f, 0.01086613f, -0.05368900f, 
    0.02404898f, 0.00668216f, 0.01165120f, -0.04434792f, -0.01210921f, -0.05416739f, 0.02469879f, -0.02905646f, 
    -0.00215511f, -0.00036628f, -0.01216893f, 0.00110739f, -0.02239520f, 0.04116565f, 0.03295010f, 0.00348276f, 
    0.03702031f, 0.03691309f, 0.00175410f, 0.03694244f, 0.02424694f, -0.03577377f, -0.04690406f, -0.00889619f, 
    -0.00403076f, -0.06490371f, -0.01997647f, -0.04742178f, 0.01524245f, 0.02838548f, 0.00567684f, 0.01234391f, 
    0.04222642f, -0.00881534f, 0.05278035f, 0.03180069f, 0.02771876f, -0.06466562f, -0.03699258f, 0.02425450f, 
    -0.04017133f, -0.00662598f, -0.01553637f, -0.01808755f, 0.03007198f, -0.01076598f, 0.00233267f, -0.02915728f, 
    -0.01087922f, -0.00874255f, -0.03505084f, 0.03531636f, 0.02517002f, -0.01022476f, 0.05588915f, 0.01123592f, 
    -0.01912110f, -0.03358191f, 0.02828296f, 0.01855388f, -0.03520807f, -0.03959139f, 0.04487931f, 0.00858035f, 
    0.02686909f, 0.03901281f, 0.03679037f, -0.06502182f, -0.01546084f, 0.02583840f, 0.04021289f, -0.06202163f, 
    -0.06586108f, -0.06346307f, 0.04772146f, 0.03937791f, 0.00589826f, 0.03831755f, -0.03560222f, 0.02690393f, 
    0.03564219f, -0.02600499f, 0.00628487f, 0.00199827f, -0.02408590f, 0.00231779f, 0.01382801f, -0.02889697f, 
    -0.00603618f, -0.02143256f, -0.05952767f, 0.04356200f, 0.01493303f, 0.03209832f, -0.00563431f, 0.01927351f, 
    0.00341656f, 0.02385709f, 0.00549313f, 0.03572971f, -0.03957976f, -0.04096765f, -0.03816592f, -0.02192170f, 
    0.02249062f, 0.01465850f, 0.04746609f, -0.00370849f, -0.02139234f, 0.02920429f, -0.06189872f, 0.04181500f, 
    -0.04859903f, -0.02662972f, -0.01996715f, 0.00530047f, 0.05066777f, -0.05142172f, 0.01421944f, -0.02911492f, 
    0.02636723f, 0.04009977f, -0.02671491f, -0.02309410f, -0.04988110f, -0.04741271f, 0.02508387f, -0.05618646f, 
    0.02522116f, -0.02599430f, -0.05470878f, -0.05668026f, 0.01061569f, -0.04812052f, -0.01147773f, -0.02142048f, 
    0.00626170f, 0.03709712f, 0.01357259f, 0.00088864f, 0.02237672f, -0.00506046f, 0.01344756f, 0.02251531f, 
    0.01408814f, 0.03646429f, -0.05425209f, -0.05098118f, 0.03239547f, -0.01133892f, -0.05846580f, 0.00880883f, 
    0.04369916f, 0.03817487f, -0.06166613f, 0.02049432f, 0.03905225f, -0.01508479f, -0.05592567f, 0.03285040f, 
    -0.01987216f, -0.06092876f, -0.03399831f, 0.02812921f, -0.06244443f, 0.01222357f, 0.03175014f, -0.04592410f, 
    0.01908170f, 0.01592130f, -0.02236517f, 0.02532579f, 0.02901976f, 0.03411420f, 0.01697202f, -0.01232666f, 
    0.00849542f, 0.03064651f, -0.01517283f, 0.01753243f, -0.03077925f, -0.05236086f, -0.04752384f, -0.04108936f, 
    -0.04125401f, 0.01036064f, -0.03147398f, 0.01928557f, -0.01561848f, -0.03304596f, 0.03123111f, -0.01101062f, 
    0.00426497f, -0.01854217f, -0.03557928f, 0.01039006f, -0.05717119f, -0.05088532f, -0.05200161f, -0.00753125f, 
    0.01407147f, -0.04812155f, -0.02828107f, 0.00913177f, -0.01867599f, 0.02052851f, 0.04167859f, 0.03552685f, 
    -0.03343968f, 0.02839611f, 0.02567866f, 0.01276308f, -0.05302614f, 0.03959864f, 0.04905533f, 0.04893328f, 
    -0.00309357f, -0.05140170f, -0.03578035f, 0.00334941f, -0.06466200f, -0.00625748f, -0.01759780f, 0.03605511f, 
    0.04117029f, 0.00108774f, -0.01946165f, -0.06826715f, 0.01890889f, -0.01035949f, -0.00131981f, -0.04666342f, 
    0.01797947f, 0.02779069f, 0.04716222f, 0.01779164f, -0.02020105f, -0.00353811f, -0.01620998f, 0.03356473f, 
    -0.06017884f, 0.01343417f, -0.03254141f, -0.04760428f, 0.03036276f, -0.03442643f, 0.03354392f, 0.05133815f, 
    -0.00108400f, -0.06018910f, -0.00688917f, 0.04439317f, -0.05561977f, -0.05762616f, -0.04808933f, 0.03862538f, 
    0.03765178f, 0.00009682f, 0.03426036f, -0.06117961f, 0.01937950f, -0.00540289f, 0.03873897f, 0.04279631f, 
    -0.02588185f, 0.04455023f, -0.05711638f, 0.04037227f, 0.00548368f, 0.04549898f, -0.02935482f, -0.02320441f, 
    -0.04742792f, -0.04128329f, -0.05334529f, -0.06431527f, -0.05045804f, 0.05314691f, 0.03735828f, 0.04384274f, 
    -0.05866463f, 0.03600397f, 0.01687868f, -0.01830614f, 0.02540884f, -0.00859128f, -0.03374085f, 0.00792148f, 
    0.04752095f, 0.01486883f, 0.00590022f, -0.00362724f, 0.00462163f, -0.06422178f, 0.01545554f, -0.03345824f, 
    -0.01573580f, -0.06292717f, 0.00897699f, 0.03309007f, -0.05567896f, -0.06571241f, 0.01133031f, -0.02431756f, 
    -0.02567626f, -0.01332255f, -0.00278956f, 0.00744636f, 0.01928746f, 0.01109696f, 0.02547118f, -0.05096723f, 
    0.01745706f, -0.03266518f, 0.03318707f, 0.03281422f, 0.01325226f, -0.02695623f, 0.03764990f, -0.06116504f, 
    -0.05930242f, 0.01958940f, 0.04380553f, -0.04118589f, -0.06215444f, -0.04308695f, -0.06671733f, -0.05569500f, 
    -0.06936098f, 0.03079057f, 0.00683638f, 0.00602351f, -0.01160189f, -0.02516323f, -0.05745856f, 0.00903778f, 
    0.00621605f, -0.00660881f, 0.00580947f, -0.03671164f, -0.00797943f, 0.03705696f, -0.05491503f, 0.00512718f, 
    0.02796994f, 0.01002584f, -0.04537769f, 0.02051115f, -0.03591171f, -0.03539032f, -0.06594051f, -0.04856435f, 
    0.02316364f, -0.00387717f, 0.01944613f, -0.00713486f, 0.04031491f, -0.02261676f, 0.04540054f, -0.06306532f, 
    0.03235567f, -0.01367379f, -0.06695731f, -0.02721204f, 0.04134224f, -0.01081992f, -0.04499507f, -0.03067618f, 
    -0.02804242f, 0.02345087f, -0.02025040f, 0.04607683f, 0.04756277f, -0.04670037f, -0.03165451f, 0.03372113f, 
    -0.06075408f, 0.01607396f, -0.03000649f, -0.03845472f, -0.05021150f, 0.02269231f, -0.06162371f, -0.06865742f, 
    0.01266435f, -0.03268651f, -0.05033468f, -0.03317786f, 0.02463490f, 0.05448851f, 0.00275676f, -0.03084336f, 
    -0.01703301f, 0.00667041f, -0.04960870f, -0.05575867f, -0.05003555f, 0.05733922f, -0.01329258f, 0.03437622f, 
    0.01913114f, -0.03609069f, 0.00044446f, -0.00878716f, -0.03923649f, 0.03031837f, -0.04587931f, 0.03662886f, 
    0.01882376f, 0.02725044f, 0.03114456f, -0.02177940f, -0.03429502f, 0.03201346f, 0.02085845f, -0.02347191f, 
    -0.02482315f, -0.03958928f, -0.03977330f, 0.01203763f, 0.00907048f, -0.02125916f, -0.00081053f, -0.05597481f, 
    -0.03812285f, -0.06103357f, 0.03169570f, -0.02276533f, 0.04516466f, -0.04978588f, -0.05779899f, -0.00866792f, 
    -0.02709467f, 0.02623449f, -0.00886526f, -0.06648860f, -0.05994639f, -0.00996001f, -0.02724385f, -0.00801235f, 
    0.05841366f, 0.04641417f, -0.02470996f, -0.04745955f, 0.00782982f, -0.00209987f, 0.04658687f, 0.02924809f, 
    -0.02912535f, 0.02470045f, -0.02173461f, 0.00262125f, 0.00532647f, -0.02665476f, 0.00338351f, -0.04979041f, 
    -0.01105378f, 0.01046392f, 0.04936948f, 0.01128614f, -0.06629211f, 0.02725651f, 0.03688703f, -0.04027615f, 
    -0.00923484f, 0.00811827f, -0.02093879f, -0.05639133f, -0.03042063f, -0.03464107f, 0.04647851f, -0.04091654f, 
    -0.04871526f, -0.00596997f, 0.03542093f, -0.00852900f, 0.00860062f, -0.00784665f, -0.03094996f, 0.05477700f, 
    -0.05679689f, 0.01469620f, 0.01718216f, -0.03972759f, 0.03602444f, 0.02446014f, -0.05761021f, -0.04673040f, 
    -0.00411284f, -0.04746829f, 0.04326880f, 0.00519361f, 0.01272888f, 0.02570376f, -0.02042243f, -0.04075070f, 
    -0.03698216f, 0.04499128f, 0.03477382f, -0.00052512f, -0.04622391f, -0.07410312f, 0.00854219f, -0.02558315f, 
    -0.04755821f, 0.03438314f, -0.06117348f, 0.04343256f, -0.00036354f, 0.04852428f, 0.03043289f, 0.03624555f, 
    -0.01564123f, 0.02593495f, 0.00571366f, -0.05911798f, -0.05597717f, -0.05514952f, 0.00405273f, 0.00114620f, 
    -0.02696987f, 0.02183748f, 0.03625830f, -0.01056439f, -0.04420408f, -0.01927698f, -0.02840103f, 0.02994079f, 
    -0.02187092f, 0.02049288f, 0.00650804f, -0.05523476f, 0.01868642f, -0.04011555f, -0.03459883f, -0.04669938f, 
    0.03992307f, 0.04927361f, -0.01745141f, -0.04248226f, -0.05345958f, -0.03670451f, 0.04128433f, -0.00596820f, 
    0.01810080f, 0.04632242f, -0.04973939f, -0.01056273f, 0.01226560f, 0.01670904f, 0.02109582f, -0.02909695f, 
    0.04595657f, -0.06083616f, 0.03342407f, -0.06594850f, 0.04495906f, 0.02452682f, -0.01508173f, 0.03775480f, 
    -0.03111057f, -0.00407087f, 0.04398475f, -0.00926958f, -0.05834993f, -0.04962007f, -0.05597794f, -0.03829866f, 
    -0.03647610f, -0.05938723f, 0.02753634f, 0.03100202f, -0.06965446f, 0.04836214f, -0.00442643f, -0.00964047f, 
    0.02837011f, -0.04828399f, -0.02173465f, -0.01476141f, -0.05219037f, -0.01835747f, 0.03081766f, -0.02061389f, 
    0.03490822f, -0.06086164f, -0.05322834f, 0.03324905f, -0.01901113f, 0.01934756f, -0.04327754f, -0.02327490f, 
    -0.03394829f, 0.04084663f, 0.03131369f, -0.04400428f, 0.03213090f, 0.02376255f, -0.02279210f, 0.00815180f, 
    0.01180184f, -0.02870426f, -0.04728756f, -0.00915775f, 0.02850170f, 0.00524605f, -0.04378644f, -0.03320369f, 
    -0.05978753f, 0.03757631f, 0.03055438f, -0.01704455f, 0.00625901f, -0.03145784f, 0.04017947f, 0.00357512f, 
    -0.04979085f, -0.00396390f, 0.00220962f, -0.04388958f, 0.00742292f, -0.06161660f, -0.06112853f, 0.01563423f, 
    0.00983065f, 0.00631524f, 0.04458523f, -0.00040018f, -0.04302191f, 0.05103216f, 0.03466246f, -0.01958864f, 
    -0.02244973f, -0.22528547f, -0.23117471f, 0.32273397f, 0.03716371f, 0.09490383f, -0.10166478f, 0.13200438f, 
    -0.22935791f, 0.17006047f, 0.24352710f, 0.03649855f, 0.22285548f, 0.01028538f, -0.13695469f, 0.24193186f, 
    0.05470395f, -0.04041382f, -0.13465972f, 0.20754290f, 0.26487747f, 0.06511869f, 0.11086123f, -0.01862587f, 
    -0.02281221f, 0.23107979f, 0.21107933f, -0.02179961f, 0.37628007f, -0.14160629f, -0.16778761f, -0.17288306f, 
    0.01652849f, 0.03362542f, 0.00264953f, 0.11228877f, 0.38951427f, -0.05533912f, -0.21203305f, 0.07161961f, 
    -0.03366403f, 0.00098254f, -0.17751224f, 0.08834176f, -0.01719740f, 0.25728080f, -0.30183324f, -0.33267134f, 
    -0.03456102f, -0.07893085f, 0.04264404f, 0.17182471f, -0.21874677f, 0.31601533f, -0.44370630f, -0.37070322f, 
    -0.26902673f, 0.53757745f, 0.32883283f, -0.01908807f, 0.17483811f, -0.14355923f, 0.11650909f, 0.07051307f, 
    0.06079681f, -0.58264571f, 0.20782684f, -0.12741354f, -0.07046131f, -0.10823034f, -0.14293508f, 0.41036019f, 
    0.19717062f, -0.01948891f, -0.26392648f, 0.04827248f, 0.15952726f, 0.10615613f, -0.05071134f, -0.13875034f, 
    0.08057353f, -0.26318973f, -0.39714670f, -0.21055426f, 0.13908255f, -0.00174307f, -0.10811637f, 0.06280230f, 
    0.04059714f, 0.16036174f, -0.25617382f, -0.03912268f, 0.41296074f, -0.24757835f, 0.06457909f, -0.09463521f, 
    0.03226750f, -0.08729842f, 0.22230935f, -0.21973544f, 0.15081434f, 0.26051193f, 0.37487236f, 0.06128586f, 
    -0.15065111f, 0.03213969f, -0.02055049f, -0.00673540f, -0.13647208f, 0.10710196f, 0.16677892f, -0.02695484f, 
    -0.03703652f, -0.02580175f, 0.15101171f, 0.21323659f, 0.12808158f, -0.00588046f, -0.05755564f, -0.48554522f, 
    0.16826871f, 0.00481867f, -0.08178855f, 0.09771667f, -0.10197651f, 0.03328878f, 0.08448103f, -0.05146765f, 
    0.29068181f, 0.11982818f, 0.11580185f, 0.04793987f, 0.14027263f, 0.11564060f, 0.15652241f, -0.19746324f, 
    -0.24270892f, 0.08502491f, -0.28879687f, -0.12414479f, -0.18099043f, 0.04623076f, -0.01328992f, 0.28420696f, 
    -0.14937770f, 0.05482767f, -0.39298114f, 0.05085091f, 0.11054181f, -0.11361295f, 0.02689147f, -0.03609580f, 
    -0.08522835f, -0.08402390f, -0.15921253f, 0.02465080f, 0.07922755f, -0.05480130f, -0.05142098f, 0.18116632f, 
    -0.03241657f, 0.07674051f, 0.07606538f, -0.08463240f, 0.37359014f, -0.02689322f, -0.04632022f, -0.16851361f, 
    0.02038566f, -0.16113679f, 0.12128997f, 0.24980372f, 0.24179818f, -0.15023604f, 0.02242416f, 0.19573928f, 
    -0.07298362f, 0.18345515f, 0.14871672f, -0.18865587f, 0.25795534f, -0.14680739f, 0.00046785f, -0.00991715f, 
    -0.11611990f, -0.03625292f, 0.15202059f, 0.01855501f, 0.10635665f, 0.38469312f, 0.36851352f, 0.01857606f, 
    -0.03440692f, -0.06678274f, -0.27116391f, -0.12079348f, 0.06003933f, 0.01795867f, -0.31236640f, -0.16587825f, 
    0.10043027f, 0.31633797f, 0.03728472f, -0.03578324f, -0.04969449f, 0.04359552f, -0.15760498f, -0.22556967f, 
    -0.20193024f, 0.45041263f, -0.02672478f, -0.10339128f, 0.05242147f, -0.12744424f, -0.13933295f, -0.14992359f, 
    0.03132578f, -0.28040633f, 0.23527008f, 0.27543160f, 0.09929382f, -0.13016571f, 0.10911037f, 0.21838057f, 
    -0.05598046f, 0.16011491f, 0.26428813f, -0.44248804f, -0.26061788f, 0.00848654f, 0.08873527f, -0.10917349f, 
    0.04805687f, -0.16799368f, -0.31499815f, -0.07136539f, 0.61044645f, 0.07038729f, -0.02847171f, -0.05551466f, 
    -0.17385058f, 0.11449839f, -0.04703796f, -0.11239024f, -0.30689251f, -0.29381037f, 0.16360019f, 0.08500914f, 
    0.18904020f, 0.08902630f, -0.06478705f, -0.11241003f, 0.48394912f, 0.21104445f, 0.51215208f, -0.06926063f, 
    -0.09604299f, -0.14090635f, -0.07575529f, 0.14932539f, -0.06470067f, -0.33025399f, -0.42528751f, -0.27326974f, 
    -0.10863230f, -0.06153200f, 0.27905151f, -0.02081113f, 0.04999378f, -0.02639937f, 0.32843810f, -0.23074940f, 
    -0.12361470f, -0.11951726f, -0.06282187f, -0.00271175f, 0.03685300f, 0.01572199f, 0.14403547f, 0.36800116f, 
    0.07827722f, 0.30552480f, -0.05869390f, -0.06563438f, 0.12666065f, -0.10853682f, 0.07626149f, 0.08484500f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.06987721f, 0.03383244f, 0.03638029f, 0.03186325f, -0.01269305f, -0.10165713f, 0.15409818f, -0.00829111f, 
    -0.11979880f, 0.08232919f, -0.05889855f, -0.06426443f, 0.02407989f, 0.22733296f, 0.03545456f, -0.02778164f, 
    0.09673125f, 0.17094809f, -0.03859493f, 0.10629775f, -0.11931880f, -0.06981862f, 0.03009659f, 0.01462870f, 
    0.24357368f, 0.26940742f, 0.01662598f, 0.05208073f, 0.03945861f, 0.04310997f, 0.01658280f, 0.09252957f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.27972877f, -0.46859643f, 0.17885858f, 0.14763223f, -0.01393651f, 0.13760565f, 0.19075043f, 0.00826270f, 
    -0.46900728f, 0.15450722f, -0.02883856f, 0.11216918f, 0.03470789f, -0.31311718f, 0.54875004f, 0.10547154f, 
    -0.29005578f, 0.18909551f, 0.53903961f, 0.84750861f, -0.56644535f, 0.27653083f, -0.77932459f, -0.60507309f, 
    0.08403854f, -0.02305782f, -0.14392860f, -0.17220537f, -0.01842251f, -0.06950130f, -0.07243957f, -0.32729372f, 
    0.16718003f, -0.38557133f, -0.08650024f, -0.07244089f, -0.00181410f, -0.50695306f, 0.29228738f, -0.05269240f, 
    -0.42699575f, 0.59746945f, -0.13672590f, 0.14206360f, 0.14465360f, -0.27085018f, -0.20473349f, 0.04005257f, 
    -0.18717818f, -0.35824141f, -0.26477367f, 0.61613125f, 0.60545152f, -0.36772051f, -0.04959299f, -0.12584665f, 
    -0.07772497f, 0.40722743f, -0.15822105f, 0.11158717f, -0.15252079f, -0.13997063f, 0.07265946f, -0.14619142f, 
    -0.51362801f, -0.04027870f, 0.03222005f, -0.09274261f, 0.12267998f, -0.07850140f, -0.09639498f, 0.03229547f, 
    1.13123190f, 0.18073648f, 0.10066273f, 0.02448372f, -0.04648247f, -0.28696364f, -0.36177409f, 0.08548011f, 
    -0.31624857f, -0.12319598f, 0.39573944f, -0.10986339f, 0.08570614f, 0.29862237f, -0.17541814f, -0.82325608f, 
    -0.09556849f, -0.04286849f, -0.03992170f, 0.11522066f, -0.01901138f, 0.06246868f, -0.05433141f, 0.05594631f, 
    0.28018433f, -0.07012092f, 0.01156905f, -0.16021363f, -0.01992026f, 0.50704581f, -0.01347306f, -0.03183559f, 
    0.25918463f, -0.48887300f, 0.12127279f, -0.07832899f, -0.05351632f, -0.12865584f, -0.33420959f, -0.15841454f, 
    0.39839587f, 0.10215143f, -0.07089338f, 0.11387702f, -0.76894790f, -0.14249130f, 0.20539646f, 0.78035945f, 
    -0.34275579f, -0.75346076f, 0.11630517f, -0.07612674f, -0.14034821f, 0.14429681f, 0.07610568f, -0.24357389f, 
    -0.46978870f, -0.18232284f, -0.00179870f, -0.16754313f, -0.09179305f, 0.39183587f, 0.34676385f, 0.13800840f, 
    0.00456088f, -0.69667935f, 0.10105436f, -0.00526037f, -0.08845934f, 0.62580746f, -0.24172814f, -0.05117070f, 
    -0.29725638f, 0.15777476f, -0.26351699f, -0.20138180f, -0.18739942f, 0.19507602f, -0.30977729f, 0.06068129f, 
    0.27132046f, -0.25004318f, 0.13192439f, 0.04142841f, 0.07163300f, 0.07782609f, -0.03099296f, 0.25292602f, 
    0.44039038f, 0.03382394f, -0.02435578f, -0.05514178f, -0.03795349f, -0.25441876f, -0.37908900f, -0.09665349f, 
    -0.17145543f, -0.12457904f, -0.03685685f, 0.10770258f, -0.08679056f, 0.61238438f, 0.48932168f, 0.14203458f, 
    -0.35997319f, -0.29896298f, -0.48927361f, 0.26737794f, -0.64453381f, 0.01255474f, -0.03121611f, -0.17297956f, 
    0.42775348f, 0.22671215f, -0.01828621f, 0.07547137f, -0.06080516f, 0.01741175f, 0.13130137f, -0.42194918f, 
    -0.32072341f, 0.31018615f, 0.15996289f, -0.05592714f, 0.13472188f, 0.20823197f, -0.02693972f, 0.03233998f, 
    0.07774596f, 0.41507021f, 0.06048464f, 0.03504567f, 0.06327829f, 0.35968435f, 0.13430913f, 0.13889015f, 
    -0.13279945f, -0.10641157f, -0.04839860f, -0.67594683f, -0.13236272f, -0.75260806f, 0.85270834f, -0.42700207f, 
    -0.03409425f, -0.07932076f, 0.14585470f, -0.04564428f, -0.09860846f, -0.11852579f, 0.12278826f, -0.26148233f, 
    0.20021969f, -0.54807907f, -0.03987900f, 0.04714936f, 0.01429704f, 0.33763862f, -0.09907619f, 0.11182550f, 
    -0.36862957f, -0.21620257f, -0.13861190f, -0.05701245f, -0.14839183f, -0.34836754f, 0.32822379f, -0.14175045f, 
    -0.09581814f, 0.18921873f, -0.19472980f, -0.11908694f, 0.66199523f, 0.63310850f, -0.15514317f, 0.21544854f, 
    -0.33214250f, -0.28167084f, 0.01607811f, -0.16208716f, -0.11248337f, -0.06424802f, -0.03555101f, -0.38516757f, 
    0.34218049f, 0.05406956f, 0.05320106f, -0.06683631f, -0.05680829f, -0.13012989f, -0.66287571f, 0.12392318f, 
    -0.70200557f, -0.09326565f, 0.01659755f, -0.07402965f, -0.16099244f, -0.27976599f, -0.35382482f, -0.06122878f, 
    0.01393225f, -0.77629530f, -0.29899561f, -0.03897295f, 0.70406300f, -0.21650656f, -0.14117302f, -0.20202886f, 
    0.20379804f, 0.25482363f, -0.01462636f, 0.16546051f, 0.14312418f, 0.00531863f, 0.01523910f, 0.84147519f, 
    -0.54441392f, -0.52076924f, 0.15933123f, 0.13216281f, -0.10990700f, -0.06628978f, 0.20683402f, 0.16264862f, 
    -0.52097553f, -0.00315981f, -0.02998081f, -0.18290059f, -0.13363697f, -0.53384310f, 0.15560262f, -0.11299036f, 
    -0.56719154f, -0.00179416f, 0.32399946f, -0.90389669f, -0.06275089f, -0.42777634f, 0.41223571f, 0.85028404f, 
    0.48726389f, 0.46782914f, 0.08037414f, -0.11166974f, -0.15241519f, 0.15816629f, -0.09207214f, 0.17947739f, 
    0.24052151f, 0.02305183f, 0.08667808f, -0.02248385f, 0.03579794f, -0.62597466f, 0.32021686f, 0.07558593f, 
    -0.03916645f, -0.12201665f, 0.06904797f, 0.08049513f, -0.08418325f, -0.63193971f, -0.91843778f, 0.11295113f, 
    0.47193852f, 0.32498726f, -0.08817687f, -0.19453965f, -0.48181945f, 0.38492468f, -0.49858776f, -0.33572823f, 
    -0.12540236f, -0.18604228f, 0.15360847f, -0.03888739f, 0.00425328f, 0.10152769f, 0.14803532f, 0.30205449f, 
    -0.30699196f, 1.20311439f, 0.16556776f, 0.07943629f, 0.08521169f, 0.06379447f, -0.17788202f, 0.04744870f, 
    0.02250393f, -0.08326547f, -0.09228977f, 0.14961007f, 0.00452573f, -0.31339797f, 0.13230407f, 0.14857469f, 
    -0.10002570f, 0.50977868f, 0.35732320f, 0.06180906f, -0.09179531f, -0.15752949f, 0.17971326f, -0.09461877f, 
    -0.54567277f, -0.22933599f, 0.13817118f, -0.02598570f, -0.09384713f, -0.07314261f, -0.11194979f, -0.17184564f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08887166f, -0.00773032f, -0.13586259f, -0.22130106f, 0.04506394f, 0.00312186f, 0.00277261f, -0.52548593f, 
    -0.27993765f, -0.10345867f, 0.23425446f, -0.03378713f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
