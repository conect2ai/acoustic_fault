#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.54532230f, -0.93597251f, 0.11301158f, -0.03518259f, -0.22149779f, -0.15732303f, -0.54044056f, 0.47408044f, 
    0.17952764f, 0.02685858f, 0.37239057f, -0.27226529f, -0.18003218f, 0.31414679f, -0.03981831f, 0.58000267f, 
    0.14880340f, -0.04161599f, 0.09689391f, 0.15397575f, 0.05190104f, -0.34955689f, 0.39802861f, 0.08820827f, 
    0.48178378f, -0.07023935f, -0.07577040f, -0.57336646f, -0.29320621f, -0.42091089f, 0.17763475f, 0.20433879f, 
    -0.50215596f, -0.53653914f, -0.44703078f, -0.10402109f, -0.25403020f, -0.49982148f, -0.47455159f, -0.23060308f, 
    0.10110071f, 0.48560145f, 0.05875603f, 0.16195609f, -0.26516700f, 0.22212853f, -0.01119340f, 0.22979967f, 
    -0.08996273f, -0.17419608f, -0.48199970f, -0.06034262f, 0.22395562f, -0.03461417f, 0.46877897f, -0.08762467f, 
    -0.55487669f, -0.62228620f, -0.35608822f, -0.60879439f, -0.15897897f, 0.37152433f, 0.08343761f, -0.07960822f, 
    -0.30860612f, 0.24833156f, 0.09344254f, -0.03448464f, -0.54026657f, 0.27513632f, -0.27489707f, -0.03177951f, 
    0.31608993f, 0.29821703f, 0.16439803f, -1.09637165f, 0.14355035f, -0.39737707f, -0.33178449f, -0.86157584f, 
    0.68966144f, 0.67777467f, -0.38391584f, 0.38850594f, 0.28544641f, -0.25180849f, -0.02125809f, 0.07033982f, 
    -0.04405011f, 0.44938499f, 0.24962169f, 0.06344897f, -0.26636773f, 0.21687400f, 0.12067614f, -0.07314756f, 
    -0.15361701f, -0.06079234f, -0.04649785f, -0.04075976f, -0.11799780f, -0.02585495f, 0.89645606f, 0.28967395f, 
    -0.92761213f, -0.27918488f, -0.58181244f, 0.23658320f, 0.11276602f, 0.03957003f, 0.04679719f, 0.22923289f, 
    -0.10829098f, 0.04650333f, 0.32908157f, -0.17717335f, 0.01114730f, -0.14188920f, -0.18321280f, -0.20351730f, 
    0.23643495f, 0.04715695f, -0.10374166f, -0.23235820f, 0.05654160f, -0.78016514f, -0.51199085f, 0.57811189f, 
    -0.23605856f, -0.66056913f, 0.29403520f, -0.56450593f, 0.26938182f, -0.71285385f, -0.54852641f, -0.22316177f, 
    0.05317966f, 0.16988635f, 0.38025934f, 0.37197536f, -0.16307257f, 0.00890957f, -0.01797619f, 0.13249618f, 
    -0.16323002f, 0.38278854f, 0.25946200f, -0.10643286f, 0.41377524f, 0.08189714f, 0.12676144f, 0.00284700f, 
    0.74043649f, 0.39659497f, -0.05221877f, -0.96092147f, -0.18569358f, -0.55142874f, -0.28561789f, -0.33347005f, 
    0.26368344f, 0.15679319f, 0.06216415f, 0.31016508f, -0.15272956f, -0.28888825f, 0.29865310f, -0.20264243f, 
    0.15239714f, 0.29812393f, 0.13629831f, -0.11851648f, 0.10475476f, -0.24754187f, 0.26900348f, -0.64578384f, 
    0.02458938f, 0.57328779f, 0.26810995f, -0.68200457f, -0.67098069f, 0.33036804f, -0.07013237f, -0.33594844f, 
    0.19194569f, 0.44910225f, 0.61810625f, -0.51103431f, -0.01599980f, -0.02395551f, 0.36649764f, 0.26646781f, 
    0.57511568f, 0.17940828f, -0.26960894f, -0.22926351f, -0.00403268f, 0.01617829f, 0.01074033f, 0.14697388f, 
    -0.79768097f, -0.34347561f, -0.58185250f, -0.61932021f, -0.35497701f, 0.27038717f, -0.42125392f, -0.05198701f, 
    -0.14930511f, -0.42778248f, 0.29576916f, 0.47279274f, 0.16023208f, 0.12655106f, -0.22449066f, -0.08556835f, 
    -0.09165862f, -0.18721126f, -0.36126491f, 0.19595119f, 0.20066246f, 0.29176438f, 0.15740418f, -0.00955871f, 
    0.21285045f, -0.78054172f, -0.87487543f, 0.79308522f, -0.00174181f, -0.37162116f, 0.64304364f, 0.62917274f, 
    0.47545138f, -0.21356215f, 0.21133111f, -0.39540285f, -0.04800277f, -0.07339745f, 0.00677348f, -0.16507341f, 
    -0.01043643f, -0.04397907f, -0.08283193f, -0.10480765f, -0.29327458f, -0.08500769f, -0.05024894f, 0.38693830f, 
    -0.00185469f, -0.00028639f, -0.38340375f, -0.44016051f, -1.11251938f, 0.37133557f, 0.49303922f, -0.72589344f, 
    0.60302210f, 0.48937616f, 0.15481813f, -0.22512019f, 0.51923651f, -0.34372029f, 0.28679046f, -0.26084706f, 
    0.36119848f, -0.09235355f, 0.31001538f, -0.15958677f, -0.28524852f, -0.02657992f, 0.16171709f, 0.13915627f, 
    -0.06511574f, 0.27001986f, 0.27313828f, 0.52147073f, 0.03181529f, 0.37726474f, 0.63452590f, 0.64184260f, 
    -0.71062237f, 0.46982092f, 0.44487751f, -0.35959285f, -0.36258194f, 0.25838593f, 0.21028417f, -0.34103844f, 
    0.00595656f, 0.11571301f, 0.46440721f, -0.31323332f, -0.04453593f, -0.03481422f, 0.18683800f, 0.00333787f, 
    0.05132056f, 0.21722399f, 0.15454167f, -0.23375092f, 0.61920565f, 0.68231010f, 0.65357584f, 0.42449799f, 
    0.81734520f, 0.15488122f, -0.52203715f, -0.61617553f, -0.03406071f, -0.25024918f, -0.09005785f, 0.22637586f, 
    0.36407161f, 0.01472688f, 0.05417071f, 0.08121166f, 0.38007540f, 0.33969128f, 0.01497617f, 0.23001058f, 
    0.20154536f, 0.15738858f, 0.26101106f, 0.00872425f, -0.03763057f, 0.39156157f, -0.04024271f, 0.45364985f, 
    0.21998055f, 0.18210526f, -0.51830178f, -0.36920539f, -0.49517360f, -0.40254128f, -0.31382284f, -0.15509512f, 
    -0.23648307f, -0.12592934f, 0.21214673f, 0.23460914f, 0.03764784f, -0.26517960f, 0.31785455f, 0.34232309f, 
    0.20878845f, -0.28226146f, -0.23032284f, -0.24801719f, -0.18790655f, -0.00377240f, -0.61622155f, -0.66250825f, 
    -0.33181557f, -0.34152281f, -0.32592243f, -0.50511020f, 0.87529063f, 0.34500659f, -0.49881002f, 0.45233050f, 
    -0.26122490f, -0.12955594f, 0.24136853f, -0.33671325f, -0.06892920f, -0.03275927f, -0.18742669f, -0.20763493f, 
    0.16437116f, 0.08915330f, 0.27667907f, 0.32399991f, -0.13988997f, 0.16504455f, 0.19666632f, 0.93597186f, 
    0.60973853f, 0.20887074f, 0.74895877f, -0.42651910f, -0.22200258f, -0.87011385f, -0.20073143f, 0.15841630f, 
    -0.15210463f, 0.08959587f, 0.18846782f, 0.26325861f, 0.03502926f, -0.19042978f, 0.17716412f, -0.41789237f, 
    0.16731076f, 0.02656249f, 0.22341032f, -0.40741006f, 0.19943595f, 0.25385556f, -0.03411911f, 0.21334979f, 
    0.86225176f, 0.63806510f, -0.20838095f, 0.43465221f, 0.57408440f, -0.36493903f, -0.12042305f, 0.79362422f, 
    0.75147855f, 0.14601055f, -0.51744920f, 0.10503899f, 0.06828734f, -0.52346569f, -0.31164125f, 0.19600558f, 
    0.08227120f, 0.07176047f, 0.12953633f, -0.04806542f, 0.16401954f, -0.15762947f, 0.17615488f, 0.19164094f, 
    -0.08127826f, 0.46424645f, 0.85174680f, -0.28195146f, -0.36186936f, -0.69983894f, 0.34545708f, -0.29862186f, 
    -0.54177862f, -0.24434818f, -0.03013220f, 0.40239543f, 0.15017535f, 0.33662549f, 0.15710208f, -0.27290872f, 
    0.03664305f, -0.22609910f, -0.09114909f, 0.14950272f, -0.17247543f, 0.26826197f, 0.25464603f, 0.26747113f, 
    0.37266612f, -0.18148378f, -0.17303643f, 0.35344115f, -0.68854421f, -0.90716207f, -0.25878072f, 0.48964810f, 
    -0.51334524f, 0.13822010f, 0.11720213f, -0.18967274f, -0.40697935f, -0.56082481f, -0.20294519f, 0.06950112f, 
    -0.49973869f, -0.24293073f, 0.45523608f, -0.15374736f, 0.12161618f, 0.25251397f, -0.20962137f, 0.08413980f, 
    -0.17031844f, 0.12965660f, -0.05237173f, -0.62170792f, -0.87577635f, -0.67868382f, -0.48705822f, -0.41861495f, 
    0.07635528f, 0.69604176f, 0.09175036f, 0.40081802f, 0.50299364f, 0.18696271f, -0.18549925f, 0.15641028f, 
    -0.17810018f, -0.21787880f, 0.11787717f, 0.28525633f, 0.24747549f, 0.01432128f, 0.13083099f, 0.08164602f, 
    -0.22814755f, -0.19220355f, -0.05318199f, 0.23403013f, -0.16421404f, -0.47488925f, -0.35399097f, 0.65124875f, 
    0.03954002f, -0.07709198f, -0.36892682f, 0.20746382f, -0.30811387f, -0.44894093f, -0.22906390f, 0.30527833f, 
    0.42089671f, -0.32459527f, -0.39733106f, 0.24624600f, 0.12159002f, 0.16462821f, 0.11215959f, -0.36566487f, 
    -0.20782773f, -0.28786358f, -0.45944208f, 0.03837539f, -0.39252684f, 0.74198157f, 0.29408017f, -0.74660826f, 
    -0.64366013f, -0.70161325f, -0.09314238f, 0.07638677f, -0.25869486f, -0.44348782f, 0.11560512f, -0.10956853f, 
    0.23866278f, 0.50007820f, 0.12324066f, -0.08328805f, 0.12132977f, 0.22132687f, -0.13159212f, 0.13357131f, 
    0.27166450f, 0.29302895f, -0.10335719f, -0.00702968f, 0.05858479f, -0.09037735f, 0.19788542f, -0.01546706f, 
    0.40463081f, 0.60496616f, -0.19841379f, 0.41379771f, 0.50435317f, 0.46382558f, 0.55028921f, 0.63085246f, 
    -0.34285921f, 0.41480651f, 0.50371623f, 0.05529344f, -0.16507588f, -0.50061560f, -0.33951050f, -0.21270047f, 
    -0.03348890f, 0.09395443f, -0.00034846f, -0.19384016f, -0.22189832f, 0.27529356f, -0.01388507f, 0.89179999f, 
    0.78625661f, 0.05355911f, -0.65312636f, -0.43584415f, -0.58549690f, 0.29706648f, -0.23093343f, 0.59365380f, 
    0.46552336f, -0.18160868f, -0.09815736f, -0.11675291f, -0.42615408f, 0.11128639f, -0.06242944f, 0.07129734f, 
    -0.41831467f, 0.09601191f, 0.10100939f, -0.49858218f, -0.04706604f, -0.08194328f, 0.01066823f, 0.16643772f, 
    0.38288322f, 0.37551859f, 0.30154359f, 0.81248468f, 0.02101574f, -0.04555624f, 0.49872613f, 0.54566485f, 
    -0.31899792f, 0.25412127f, 0.09898654f, -0.17362532f, -0.44755408f, -0.12431064f, -0.22136316f, -0.43677089f, 
    -0.01333353f, 0.05885525f, 0.37214980f, -0.28694323f, 0.10590048f, -0.25969371f, -0.37770310f, 0.37814277f, 
    0.18070719f, 0.81005520f, -0.28783035f, -0.87849182f, -0.38425449f, -0.03345380f, -0.03961994f, -0.12316482f, 
    0.06935599f, 0.05179698f, -0.17577232f, -0.05054133f, -0.06996003f, 0.04381789f, -0.38426089f, -0.11525387f, 
    -0.09071736f, -0.08843776f, 0.07085852f, 0.01656436f, -0.09070238f, 0.34403685f, 0.54410785f, 0.07702616f, 
    0.10672980f, 0.31631884f, -0.23841411f, -0.38916355f, 0.38189512f, 0.90319628f, -0.33796933f, -0.45553488f, 
    -0.14162061f, 0.39529940f, -0.47071621f, -0.22412857f, 0.09468687f, -0.11367427f, 0.08092587f, 0.27866986f, 
    0.31734446f, -0.03397750f, 0.43672961f, 0.36365828f, -0.47137231f, 0.19784193f, 0.14347413f, -0.25399286f, 
    -0.25419962f, -0.36399296f, -0.11766487f, -0.40884638f, -0.16893342f, 0.34775463f, 0.36737192f, 0.33041361f, 
    -0.69160450f, -0.30171394f, -0.39395809f, -0.45150384f, -0.42872870f, 0.62751198f, 0.55536711f, -0.08218059f, 
    -0.10122325f, 0.30682835f, -0.28749284f, 0.04680972f, 0.10913955f, 0.19432534f, 0.03710176f, 0.23188463f, 
    -0.10353931f, 0.22929735f, 0.16273129f, -0.39480597f, -0.94684780f, 0.66903222f, -0.26067096f, -0.79408878f, 
    -0.62487131f, 0.55997699f, 0.22167590f, -0.58237368f, 0.36278626f, 0.65689766f, -0.06171366f, 0.18405375f, 
    -0.19766194f, 0.24656460f, 0.09490417f, -0.08606619f, 0.20384757f, 0.09072165f, 0.07885638f, -0.31600896f, 
    -0.28927407f, -0.18132755f, -0.25693932f, -0.04464571f, 0.06488962f, 0.08684973f, 0.07505552f, -0.25520641f, 
    -0.74184930f, -0.42070568f, 0.02303658f, -0.56815153f, -0.02451210f, -0.08441827f, -0.36180043f, 0.01136729f, 
    -0.30742496f, -0.02081071f, 0.21949089f, -0.45093143f, -0.27111879f, 0.04522033f, 0.23556598f, 0.11144245f, 
    0.53031534f, 0.15400603f, -0.03694486f, -0.28870010f, 0.14595634f, -0.29508552f, 0.77523404f, 0.70806444f, 
    0.73486304f, 0.29412645f, 0.40554559f, -0.31286636f, 0.28061268f, -0.15400876f, 0.29850286f, 0.07264043f, 
    -0.21382453f, -0.21118024f, -0.13172068f, -0.03912913f, 0.16291158f, -0.02424168f, -0.35153210f, -0.28388575f, 
    0.37506247f, -0.24213128f, 0.28421000f, -0.10365869f, 0.20108461f, 0.17971992f, 0.23228917f, -0.43084842f, 
    -0.11350943f, -0.18877588f, -0.14191279f, -0.56716532f, 0.13839552f, -0.26709411f, 0.03335066f, -0.37843108f, 
    -0.32682163f, 0.36939910f, -0.02351182f, -0.28263834f, -0.22769071f, -0.08570825f, 0.24658568f, 0.27023190f, 
    0.08318230f, -0.50752807f, 0.33072305f, -0.48591864f, -0.27054313f, 0.26241302f, 0.35849506f, -0.16217750f, 
    -0.51978767f, 0.59636045f, -0.43529785f, -0.90740508f, -0.02754486f, -0.64247268f, 0.53052539f, 0.41991875f, 
    -0.33076206f, -0.26498058f, -0.25261500f, -0.12950061f, 0.16971740f, -0.15868339f, 0.13363485f, 0.46748859f, 
    0.28587341f, 0.16187738f, 0.36800569f, -0.10643648f, 0.11652418f, 0.01155881f, 0.14731210f, -0.14071856f, 
    0.07905932f, 0.71765608f, 0.71445221f, 0.26892415f, -0.85473597f, -0.59836721f, -0.17445120f, -0.45013788f, 
    -0.29926223f, -0.52320910f, -0.12467185f, 0.27718040f, -0.01783283f, -0.09869133f, -0.18853734f, -0.13059819f, 
    -0.24530199f, -0.08238867f, -0.16892688f, 0.00693058f, -0.11916954f, 0.31606233f, 0.18332128f, -0.45692706f, 
    0.33082670f, 0.39967945f, -0.66643727f, 1.05361104f, 0.66901690f, -0.76915270f, -0.05371819f, 0.44899097f, 
    -0.08751671f, -0.59937733f, 0.16525351f, -0.56081337f, -0.28619942f, 0.21629965f, -0.31652251f, 0.29823148f, 
    0.05326040f, -0.16430438f, 0.05639405f, -0.13014603f, -0.07990329f, -0.02261097f, -0.35201296f, -0.28539351f, 
    -0.08438432f, -0.22215611f, 0.18371175f, 0.92979771f, 0.59943014f, 0.23059841f, 0.25064728f, -0.55961454f, 
    0.15123639f, 0.06024280f, -0.16409448f, 0.09112719f, 0.60689610f, 0.39667684f, -0.06312174f, -0.26319066f, 
    -0.12630197f, -0.35916907f, 0.26602551f, -0.15588804f, 0.17228843f, -0.40310168f, -0.02091272f, -0.10217036f, 
    0.01340887f, 0.14847125f, -0.12575677f, -0.41287878f, -0.36166015f, -0.37558031f, 0.48184758f, -0.38819489f, 
    0.25348416f, 0.35524598f, -0.52804244f, -0.83481061f, 0.04834828f, -0.42461255f, 0.37302873f, 0.59622312f, 
    0.02598260f, 0.15004383f, 0.15693128f, 0.18243615f, 0.12274805f, -0.02114734f, 0.31048766f, 0.06318953f, 
    0.29996172f, 0.11099128f, -0.24000679f, -0.12856537f, 0.36896613f, -0.35999727f, 0.28014171f, 0.12998304f, 
    0.43565303f, -0.75011969f, 0.25807056f, -0.11668789f, 0.38325971f, 0.59164220f, 0.30967462f, -0.39236727f, 
    -0.28589767f, 0.05676252f, -0.02126778f, -0.44404417f, 0.21697047f, 0.19222036f, 0.29318535f, 0.05414563f, 
    -0.26991579f, 0.18404268f, -0.05006059f, -0.25299990f, -0.15156932f, -0.09029087f, 0.34678042f, -0.46183246f, 
    -0.69031417f, -0.45951605f, -0.47319743f, -0.09896025f, 0.76221842f, 0.44145241f, 0.58835024f, 0.25883859f, 
    -0.23390114f, -0.01158495f, -0.42482901f, -0.20427203f, -0.11843036f, -0.08248454f, -0.28070343f, -0.16112134f, 
    -0.04635296f, -0.15246679f, -0.20738399f, 0.01847527f, 0.19565094f, -0.20254865f, -0.21143687f, -0.22479047f, 
    -0.44330674f, 0.14532316f, -0.14421555f, 0.24294674f, -0.21871006f, -0.51641780f, 0.41900104f, 0.54900736f, 
    -0.66619021f, 0.10930389f, -0.14633556f, 0.15439020f, -0.26321679f, -0.23832832f, 0.28061038f, 0.01924894f, 
    0.43217456f, 0.24344128f, -0.06508022f, 0.05219943f, 0.38136238f, -0.00841982f, -0.07854193f, -0.22375327f, 
    0.94820613f, -0.36770537f, 0.14936779f, 0.75213140f, 0.42559567f, 0.15940629f, 0.48725340f, -0.13000830f, 
    0.34762511f, 0.44731221f, -0.50428116f, 0.05208302f, -0.04282890f, 0.14789665f, 0.02907474f, 0.08870549f, 
    0.07976643f, -0.15929800f, 0.10622402f, 0.26203540f, 0.20944156f, 0.04473145f, 0.09830520f, -0.21143728f, 
    -0.06661050f, 0.75346386f, -0.61050540f, 0.27428654f, -0.06610861f, -0.08415288f, 0.56055146f, -0.31593648f, 
    0.39745209f, 0.33220392f, 0.52744007f, 0.10245244f, -0.32569644f, -0.10813560f, -0.00328821f, -0.29738194f, 
    -0.15455873f, 0.08035602f, -0.16803207f, 0.12092791f, -0.07206218f, 0.13844283f, 0.15286569f, 0.10321637f, 
    0.09593309f, -0.08571304f, 0.70140225f, -0.56778181f, -0.15216608f, -0.12763117f, 0.51304674f, 0.35287842f, 
    -0.12242046f, 0.37444702f, -0.30753091f, 0.56120914f, -0.29101351f, 0.41024789f, 0.08570426f, 0.04566744f, 
    -0.24715297f, 0.24518481f, -0.40238938f, -0.29047763f, 0.06272274f, -0.24852501f, 0.07860021f, 0.12622155f, 
    0.23603575f, 0.34797135f, 0.07231349f, -0.53374732f, 0.68933153f, -0.28384161f, -0.13315447f, 0.33254489f, 
    -0.84665620f, -0.49152035f, -0.34759057f, -0.37438831f, 0.17864475f, -0.13831106f, -0.22160752f, -0.07753865f, 
    0.24409555f, 0.01993331f, -0.30335805f, -0.40631002f, 0.35568610f, -0.44695380f, -0.30860162f, 0.07046157f, 
    0.24509984f, 0.12425091f, -0.29061294f, 0.12718421f, -0.44922382f, -0.67410731f, -0.69995290f, -0.61317474f, 
    -0.07421161f, -0.17996064f, 0.09714919f, 0.56033397f, 0.20889908f, 0.42654184f, -0.51471394f, -0.02910599f, 
    -0.18744777f, -0.31372818f, -0.18693143f, -0.12777063f, -0.01399518f, 0.02237656f, -0.19692132f, 0.00559723f, 
    0.07914735f, 0.00176439f, -0.17876194f, -0.09173170f, -0.11092707f, -1.12413704f, 0.53271824f, 0.94368970f, 
    0.07480116f, 0.38303658f, 0.30731553f, -0.10418338f, -0.06226542f, 0.74671394f, -0.37197679f, -0.19500940f, 
    -0.02854731f, -0.38567728f, 0.08180898f, -0.00101961f, -0.09680220f, -0.00631047f, 0.31499115f, -0.05348043f, 
    0.01230886f, 0.05041113f, -0.07590392f, -0.38768259f, 0.20143247f, 0.12352692f, -0.82721734f, -0.93927217f, 
    -0.00360538f, 0.71343082f, 0.49635175f, 0.55433035f, 0.47881880f, 0.08516803f, 0.02236137f, -0.11278625f, 
    0.26357207f, -0.00600493f, 0.18941334f, 0.19927588f, -0.15032643f, -0.38661873f, 0.10378090f, 0.09319269f, 
    -0.09718639f, -0.03988634f, -0.20840907f, 0.33278808f, -0.09395257f, -0.13072897f, -0.16862483f, 0.98065716f, 
    0.03163830f, 0.92327261f, -0.56395525f, -0.67704278f, 0.38246021f, -0.44835171f, 0.35056916f, 0.04480729f, 
    0.03832288f, 0.37407750f, 0.18761180f, -0.23745330f, 0.17836690f, -0.00889923f, 0.01925110f, 0.03586554f, 
    -0.10685597f, -0.18969482f, 0.30743048f, -0.06334091f, 0.15465464f, 0.39829075f, -0.11817024f, 0.03486368f, 
    -0.47756031f, 0.23149070f, 0.23538785f, 0.54278141f, -0.12067020f, 0.43938050f, -0.41796675f, -0.13246597f, 
    0.03181960f, 0.11942535f, -0.28751615f, -0.30026925f, -0.18831961f, 0.25363019f, 0.26787257f, -0.14184853f, 
    -0.08248031f, -0.15381183f, -0.26788318f, -0.16259354f, -0.00747514f, -0.17937130f, -0.32305571f, -0.30758944f, 
    -0.56344408f, -0.03605919f, -0.40001997f, 0.68086112f, 0.23610817f, 0.04833600f, -1.08724368f, 0.38461721f, 
    -0.45023346f, -0.50170827f, 0.18230836f, -0.27970892f, 0.43771932f, -0.53050202f, 0.10728246f, -0.08774988f, 
    -0.30340117f, 0.08134864f, -0.17594777f, -0.12126858f, -0.28971043f, 0.13603529f, -0.02655698f, -0.10686056f, 
    -0.10507616f, -0.20574492f, 0.40593138f, -1.57189012f, 0.63397771f, 0.30891591f, -0.08286230f, 0.44918296f, 
    0.55629086f, 0.35540873f, -0.38560680f, -0.30247664f, 0.04604529f, 0.25446507f, -0.27203438f, 0.15723176f, 
    0.28299835f, -0.23503815f, -0.22609851f, -0.24213135f, -0.10105758f, -0.07726478f, 0.05387336f, 0.29555133f, 
    0.08060044f, 0.01080776f, 0.11957316f, 0.10960520f, -0.29356739f, 0.53575051f, -0.70286095f, 0.55869913f, 
    0.10377849f, 0.53457457f, -0.35199910f, -0.56805813f, -0.21503659f, 0.10286716f, -0.19256490f, 0.38167548f, 
    0.01867602f, 0.09548268f, -0.38720408f, -0.12381822f, 0.14619374f, -0.07772469f, -0.40331110f, -0.10213242f, 
    -0.27193725f, 0.10300665f, 0.36861405f, 0.20875035f, 0.39452168f, 0.45918027f, 0.82337540f, 0.64232999f, 
    0.37701803f, 0.43022946f, -0.12955508f, -0.56158406f, -0.60089546f, 0.10534964f, 0.29489860f, 0.13983868f, 
    -0.22375154f, -0.14366882f, -0.08561528f, -0.09322014f, 0.04850515f, 0.14378259f, -0.07538238f, -0.07190713f, 
    0.00533924f, 0.24522606f, 0.00955356f, 0.24808176f, 0.42523426f, 0.62830561f, -0.91781640f, -0.23126970f, 
    -0.34861246f, 0.26946732f, -0.27992785f, 0.66262650f, 0.15240441f, 0.06633671f, 0.27117306f, -0.21617901f, 
    -0.20344123f, -0.52361780f, 0.27157909f, 0.02764114f, -0.00174080f, 0.20848009f, -0.39288357f, 0.22730505f, 
    0.14188765f, 0.05182239f, 0.06501265f, -0.08718590f, -0.00326149f, -0.19838533f, 0.84564620f, 0.10534631f, 
    0.73642141f, 0.17656019f, -0.31167713f, 0.04010693f, -0.75322217f, 0.32402164f, 0.05905472f, 0.17140824f, 
    0.11672489f, -0.27704328f, -0.19379587f, -0.19937110f, -0.10731345f, -0.17574184f, -0.04637131f, 0.15002751f, 
    -0.09793823f, -0.17133705f, 0.32395709f, 0.18447761f, 0.08463299f, -0.04293069f, -0.09919053f, -0.12795231f, 
    0.72490191f, 0.59969366f, 0.63982314f, -0.37010425f, -0.68097311f, -0.23244345f, -0.57414693f, -0.04918604f, 
    0.01083763f, 0.28854379f, -0.11659987f, -0.03597077f, -0.11694108f, 0.02305016f, -0.09062336f, -0.33169496f, 
    0.26042619f, -0.39370272f, -0.03766077f, -0.00534735f, 0.07682681f, -0.08863139f, -0.20807433f, -0.25195572f, 
    -0.32999405f, -0.96140599f, 0.20693983f, 0.84040314f, 0.23123367f, -0.44330096f, 0.73358983f, 0.85621476f, 
    -0.52201104f, -0.07152063f, 0.11827352f, 0.04644983f, -0.21972260f, -0.13442223f, -0.15213895f, -0.21973419f, 
    0.15048009f, -0.31675437f, -0.02162006f, -0.19483238f, -0.11893492f, -0.21018274f, -0.22773233f, 0.25560445f, 
    -0.14726266f, 0.29831845f, 0.22262937f, 0.10852350f, -0.72981894f, 0.05748726f, 0.18107527f, 0.42541236f, 
    0.62199992f, 0.31112397f, 0.57624936f, -0.19555576f, -0.27757889f, 0.03811625f, 0.00847231f, -0.55806130f, 
    -0.15107459f, 0.02599334f, 0.22217269f, 0.20373258f, 0.01340944f, 0.48425457f, -0.17796071f, 0.04286963f, 
    -0.38146627f, -0.31013542f, -0.37308642f, -0.35304174f, -0.21128318f, 0.01331794f, 0.48495165f, 0.31764197f, 
    0.48380870f, -0.30891952f, 0.01130771f, -0.04899235f, -0.02232850f, -0.27227294f, 0.03089441f, -0.13846233f, 
    0.44010702f, -0.44682720f, -0.51468468f, 0.19226786f, -0.30268627f, -0.40130764f, 0.15715051f, 0.13451146f, 
    -0.20496312f, 0.48553607f, -0.08759744f, 0.64077353f, -0.19728808f, -0.86049372f, 0.02152625f, 0.63397461f, 
    0.40622005f, 0.02488697f, -0.65699238f, 0.07174853f, 0.35820809f, -0.07611527f, -0.06581165f, 0.14891334f, 
    0.38570479f, 0.15336552f, 0.11329570f, 0.16364084f, 0.08890581f, -0.25640821f, -0.07671364f, 0.27827251f, 
    0.07368964f, 0.19203463f, 0.19764760f, 0.00460041f, -0.55363905f, -0.58715850f, -0.53363538f, -0.10106642f, 
    0.18057144f, -0.07452781f, 1.08325255f, -0.05536653f, -0.49188069f, 0.49147880f, 0.01035888f, -0.18151806f, 
    0.08143588f, -0.31683689f, 0.02733316f, -0.12595023f, 0.06002048f, -0.06512747f, -0.11148828f, -0.50048655f, 
    0.11635147f, -0.19391070f, 0.07003612f, -0.00962012f, -0.01233219f, 0.22372098f, 0.05993259f, -0.11952724f, 
    0.58804846f, -0.61392385f, -0.74102598f, 0.20947662f, 0.70576370f, -0.14234516f, 0.23386452f, -0.23388003f, 
    0.09538089f, 0.63968605f, -0.42459109f, 0.26499298f, 0.16441461f, -0.11824122f, 0.11328902f, 0.00615594f, 
    -0.07079817f, 0.05673852f, -0.23942243f, 0.28261897f, -0.19460411f, 0.16654578f, 0.68780547f, 0.09339437f, 
    0.13281135f, 0.81145954f, 0.62911034f, 0.64121974f, 0.22236188f, -0.33349887f, -0.06873542f, 0.23054756f, 
    -0.07917073f, 0.35732841f, -0.27021798f, 0.11827055f, 0.23635080f, -0.24596447f, -0.08270184f, 0.12770389f, 
    -0.08639971f, -0.18544795f, -0.16559312f, -0.34580317f, -0.03197806f, -0.18629338f, -0.13394526f, 1.04024601f, 
    0.68424213f, 0.25606558f, 0.79420453f, 0.81414908f, 0.43748996f, 0.13153113f, -0.31705979f, 0.32615989f, 
    -0.38423297f, 0.04667545f, 0.23233497f, -0.09597707f, 0.33462116f, 0.07364809f, 0.30428776f, 0.08994351f, 
    0.36729091f, 0.11185800f, -0.04191667f, -0.00907036f, 0.07300723f, -0.04037412f, 0.15909368f, 0.41253302f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04271456f, -0.07336593f, 0.31001556f, 0.06668588f, 0.18572891f, 0.22784410f, 0.10823177f, 0.29477587f, 
    0.20148791f, -0.02482721f, 0.17746040f, 0.13959995f, 0.05167479f, 0.19669878f, 0.04973907f, -0.01363572f, 
    0.17871909f, 0.17057331f, 0.00900360f, 0.10617181f, 0.00682866f, 0.10739899f, -0.08454621f, 0.01221089f, 
    0.06276993f, 0.08523925f, -0.09062626f, -0.09384533f, 0.13193397f, 0.03479633f, 0.14625648f, 0.15732189f, 
    0.24387860f, 0.07501152f, 0.17120485f, 0.22986439f, 0.10589191f, 0.07778789f, 0.03324703f, 0.13066921f, 
    0.14556974f, 0.10016921f, 0.01503123f, -0.01373710f, 0.16018106f, 0.20672615f, 0.14785157f, 0.12837470f, 
    0.08722457f, 0.03784183f, 0.15676571f, -0.02389978f, 0.18291607f, 0.13274769f, 0.27480975f, 0.03361919f, 
    0.19129926f, 0.04164745f, 0.04988020f, 0.17558374f, 0.16014487f, 0.15369323f, 0.29433662f, 0.16522138f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11012640f, -0.09095641f, -0.22861765f, 0.05251601f, 0.09346364f, 0.05419653f, -0.12108094f, 0.10521621f, 
    0.10965914f, 0.08197323f, -0.08919573f, 0.02626623f, -0.24799019f, -0.04131815f, 0.20019346f, -0.08328141f, 
    -0.05491769f, -0.02752288f, -0.02644989f, 0.05335131f, -0.00934353f, 0.01630516f, 0.10462034f, 0.10895778f, 
    -0.18292525f, -0.07127436f, 0.10187138f, 0.03459061f, 0.11124709f, -0.02850777f, -0.03500572f, -0.02212660f, 
    0.03228859f, -0.06974214f, -0.05451810f, -0.11510331f, 0.54636896f, 0.10039563f, 0.01713991f, -0.16569549f, 
    -0.03000085f, 0.08053456f, -0.07619383f, 0.05376582f, 0.12488857f, -0.05516813f, -0.01923919f, 0.01721451f, 
    -0.13684008f, 0.01089020f, -0.19701271f, 0.27874875f, 0.00690409f, -0.02972899f, 0.01869796f, -0.14230897f, 
    0.03000931f, 0.05429264f, 0.08157753f, 0.00471826f, -0.50291860f, 0.03491789f, 0.01006842f, 0.16288048f, 
    0.04344510f, 0.12626570f, 0.00646484f, 0.01128234f, 0.01833839f, 0.08942717f, -0.01043053f, -0.07941227f, 
    0.14328635f, 0.02807570f, -0.03124344f, 0.11059642f, -0.15718038f, 0.01140574f, -0.00364858f, -0.09090492f, 
    0.05157229f, -0.01220493f, -0.19666223f, -0.03126477f, -0.23802716f, -0.09392639f, 0.01777690f, 0.11234134f, 
    -0.05882735f, 0.03518316f, 0.00943808f, 0.03225708f, 0.04099237f, 0.08467294f, -0.02353378f, 0.05284984f, 
    -0.16794057f, -0.37188259f, 0.01490344f, -0.06284238f, -0.07119896f, 0.08299788f, 0.10591727f, 0.02253254f, 
    -0.07407400f, -0.06115142f, 0.02542597f, -0.06462421f, -0.10478385f, 0.18575995f, 0.25770944f, 0.03975268f, 
    0.03390153f, 0.05846523f, -0.01597444f, 0.02031215f, -0.00670518f, 0.04718076f, -0.07502632f, -0.08459774f, 
    -0.40210608f, 0.31838009f, -0.05275740f, 0.03612375f, 0.02642454f, -0.02223467f, 0.03480358f, -0.05837008f, 
    0.00344850f, 0.00426264f, -0.04735556f, 0.01782379f, 0.18543167f, 0.10610770f, -0.07756058f, 0.10385438f, 
    -0.07533075f, 0.04707939f, -0.10264401f, -0.00679162f, 0.08071519f, -0.09899113f, 0.09491698f, -0.11967526f, 
    0.18405263f, 0.00491225f, 0.00901201f, -0.08425811f, -0.09532666f, -0.00511083f, 0.03077462f, -0.00756291f, 
    0.00848579f, -0.00463067f, -0.14518845f, 0.01026631f, 0.12464249f, 0.09137832f, 0.02461725f, 0.02996901f, 
    -0.13619101f, -0.00839729f, 0.05394663f, 0.13761944f, 0.07504286f, -0.00452248f, -0.13978060f, -0.04872783f, 
    -0.16274807f, 0.08359554f, 0.07125160f, -0.30449253f, 0.05044614f, 0.02648311f, -0.02503698f, 0.09474319f, 
    -0.01681948f, -0.05908514f, -0.01681870f, 0.07962447f, 0.22217599f, -0.00857374f, -0.10921030f, 0.11842526f, 
    -0.02586184f, -0.03761028f, -0.24125411f, 0.14128754f, -0.06392705f, -0.07408722f, -0.09442456f, 0.11497648f, 
    0.07778199f, 0.05217422f, 0.04200266f, 0.09476787f, -0.15549517f, 0.10490865f, -0.04658682f, 0.00850043f, 
    -0.01845078f, 0.07650155f, 0.05046875f, 0.00560781f, -0.16006990f, 0.08308455f, -0.02363775f, -0.13394581f, 
    -0.09117822f, 0.13465220f, 0.04595509f, -0.08951903f, 0.00980130f, -0.02335601f, -0.02745947f, 0.01795963f, 
    0.10153014f, -0.04229742f, 0.01721938f, -0.27723908f, 0.00359979f, -0.04037457f, 0.01896097f, -0.03227991f, 
    -0.02139573f, 0.10226956f, 0.10304612f, -0.08734576f, 0.16092338f, 0.20360397f, -0.01750208f, -0.38762909f, 
    0.07297372f, 0.02335867f, 0.01166240f, 0.09877458f, -0.03475818f, -0.03949968f, -0.05612835f, 0.11142643f, 
    -0.20217565f, -0.07708849f, -0.10415582f, 0.14648750f, 0.04740368f, 0.09605200f, 0.03143661f, -0.05472805f, 
    0.20853804f, 0.08980277f, -0.11156207f, 0.00435624f, -0.49826968f, -0.01971401f, 0.17045832f, -0.25666991f, 
    -0.01273751f, -0.03207727f, 0.01691673f, -0.03398881f, -0.11378768f, -0.04024455f, 0.01739648f, 0.04573764f, 
    0.06819508f, 0.01377012f, -0.20152670f, 0.17149878f, 0.09302096f, 0.04356911f, -0.05445249f, -0.02896994f, 
    0.03313597f, 0.06244518f, 0.04929880f, 0.06077139f, -0.09566880f, 0.05525323f, -0.02563880f, -0.27056345f, 
    -0.08609360f, -0.05431412f, -0.07777026f, 0.11446767f, 0.06949029f, -0.01321068f, 0.10205247f, -0.07978056f, 
    0.01630113f, 0.03631248f, 0.00392765f, 0.00653631f, -0.05747411f, -0.03513663f, 0.01546538f, -0.07919624f, 
    -0.00975905f, -0.03757017f, 0.02382086f, 0.00378760f, -0.04050995f, -0.15942065f, -0.06182745f, -0.02205545f, 
    0.13963892f, -0.04136885f, 0.16170166f, 0.03466346f, -0.05605293f, -0.04805202f, 0.12507233f, -0.06312796f, 
    -0.00751115f, 0.10621475f, -0.26488203f, 0.27478614f, 0.00763228f, 0.12170669f, 0.10799597f, -0.15760669f, 
    -0.03844878f, -0.04734041f, -0.04082710f, -0.01269995f, -0.09608541f, -0.07118322f, -0.03842473f, 0.13580512f, 
    0.01253736f, -0.01761974f, 0.02596398f, -0.03348467f, 0.02158784f, -0.00804389f, 0.02122264f, 0.00711575f, 
    0.41657573f, -0.09731545f, -0.09900966f, -0.20828576f, -0.02129579f, 0.07106952f, 0.05976797f, -0.00647843f, 
    -0.00036647f, 0.03318683f, -0.12865096f, 0.01507069f, -0.13460428f, -0.02004376f, 0.02264372f, -0.12755452f, 
    -0.01387136f, 0.09221402f, -0.06178657f, -0.05794116f, 0.01160266f, 0.00086663f, -0.01577944f, 0.13977844f, 
    0.05623110f, 0.01353606f, -0.05435232f, -0.00079118f, -0.04420056f, -0.13202876f, -0.02451128f, -0.02245205f, 
    -0.04133870f, 0.00747611f, -0.03640016f, -0.06978348f, -0.03678469f, -0.07881413f, -0.08513610f, 0.02891215f, 
    0.01726996f, 0.12125736f, -0.02570309f, 0.07709657f, -0.05043979f, 0.00222799f, 0.02195024f, -0.13576102f, 
    -0.09935872f, 0.09306807f, 0.09950880f, -0.21571615f, -0.00062389f, -0.10674886f, 0.02436800f, 0.07346313f, 
    -0.09989580f, 0.01296494f, -0.02286189f, 0.09082174f, -0.24412635f, 0.18479021f, 0.14920354f, -0.23665486f, 
    -0.00257584f, -0.01073487f, 0.08124903f, -0.09768425f, -0.05011264f, -0.06061523f, -0.03859967f, -0.02409911f, 
    -0.33332565f, 0.19114077f, 0.08723115f, -0.08845872f, -0.00919767f, 0.01625419f, 0.01327223f, 0.02860854f, 
    0.04796490f, -0.06062887f, -0.08472793f, 0.04249954f, 0.00845532f, 0.00398994f, -0.12313951f, 0.00300282f, 
    -0.17623262f, -0.05934052f, -0.09560230f, 0.02884073f, -0.01859021f, 0.05836583f, -0.04137613f, -0.16045035f, 
    -0.39895204f, -0.09787065f, 0.15770163f, 0.02572904f, -0.13807283f, 0.05977743f, 0.00886720f, -0.12536693f, 
    0.07148128f, 0.09468866f, 0.08924673f, 0.00512455f, 0.23166361f, 0.15064299f, -0.07598822f, 0.16289854f, 
    0.01089833f, 0.08110702f, 0.02569701f, -0.07517185f, 0.01506689f, -0.03638021f, -0.05837920f, 0.01461785f, 
    -0.00610257f, 0.12161492f, -0.07104971f, -0.25501058f, 0.00182829f, 0.00318252f, 0.07132319f, -0.10011427f, 
    -0.05885916f, 0.06364904f, 0.08197159f, -0.02701528f, 0.04260646f, 0.10224074f, -0.02063599f, -0.02994771f, 
    0.04534950f, 0.05013048f, 0.02146784f, 0.02393465f, 0.03989485f, -0.00546325f, 0.03128978f, -0.01544018f, 
    0.19887689f, -0.12835820f, -0.10181490f, 0.31413087f, -0.05445035f, -0.04889933f, -0.10455404f, -0.03072507f, 
    -0.02897422f, 0.02438427f, -0.02332647f, 0.10694186f, 0.16357256f, -0.15734462f, 0.04364470f, 0.06686310f, 
    0.16104548f, 0.05844418f, -0.04842054f, -0.08945840f, -0.18853498f, 0.12389268f, 0.05378611f, -0.04974301f, 
    0.28231248f, -0.07429346f, 0.02823483f, -0.10232861f, 0.09391926f, -0.09707286f, -0.07492600f, 0.01766534f, 
    -0.20379809f, 0.06452979f, 0.08933699f, -0.16017762f, -0.02405408f, -0.05721924f, 0.05052180f, -0.05235574f, 
    0.07185633f, -0.12384262f, 0.06925157f, -0.03557830f, -0.06946727f, 0.02376120f, -0.04706145f, -0.05589777f, 
    -0.05467195f, 0.04534762f, -0.09255284f, -0.31893635f, 0.03696071f, 0.01792828f, 0.05505899f, 0.08256706f, 
    -0.00645132f, -0.00617771f, -0.01070398f, 0.10798669f, -0.27961719f, 0.09009072f, 0.11162075f, 0.25105509f, 
    -0.09648215f, -0.08976452f, 0.08246131f, -0.11146181f, 0.00810041f, 0.04598482f, -0.03488787f, 0.00752713f, 
    -0.28450498f, 0.05797192f, -0.04463855f, 0.03190263f, 0.09630486f, 0.07660020f, 0.07444867f, 0.01510731f, 
    -0.06515573f, -0.04571802f, -0.06321569f, 0.03376161f, 0.11182488f, -0.03297141f, -0.02188168f, -0.10919645f, 
    0.00459723f, -0.05360295f, -0.00826353f, -0.01352832f, -0.08544280f, -0.09238532f, -0.07887099f, 0.04864118f, 
    -0.03142802f, -0.03440370f, -0.13723747f, 0.20383771f, -0.00398492f, 0.03018635f, 0.08392079f, -0.00599433f, 
    -0.01317741f, -0.07918881f, 0.04060506f, 0.01677207f, 0.15958555f, -0.14415884f, -0.15439278f, 0.24143380f, 
    -0.05663833f, -0.00872358f, 0.08118782f, -0.14857671f, -0.10666069f, 0.01633918f, -0.06546327f, 0.09547990f, 
    -0.13816708f, 0.06212563f, 0.04230478f, 0.03954160f, -0.01616251f, -0.04010939f, -0.01642626f, -0.08480807f, 
    0.03066087f, 0.04414970f, 0.10896872f, 0.06846043f, -0.09598358f, -0.18832035f, 0.16274735f, -0.32460558f, 
    -0.01955525f, -0.27973935f, 0.06125014f, -0.09561754f, -0.03166813f, 0.00840721f, -0.03743668f, 0.02706988f, 
    -0.01718352f, 0.03145690f, 0.01017510f, 0.06257294f, -0.16194375f, -0.20821194f, 0.04716990f, 0.00166679f, 
    -0.01665414f, 0.05992328f, -0.10625716f, 0.01742358f, -0.05554276f, -0.01611638f, 0.05716439f, -0.24689189f, 
    -0.14145057f, 0.00791467f, -0.01172778f, -0.03424634f, -0.10231720f, -0.03297340f, 0.03233838f, -0.12344743f, 
    0.16970912f, -0.14499803f, 0.03090735f, 0.11286403f, -0.12550732f, -0.06683402f, -0.08842158f, -0.04542796f, 
    -0.14919463f, -0.02940860f, -0.06338084f, -0.01726581f, -0.01374196f, 0.09918834f, -0.22220574f, 0.10777354f, 
    -0.14941056f, 0.06532783f, 0.03971447f, -0.09895048f, -0.01838774f, 0.10624271f, 0.06022587f, -0.02962432f, 
    -0.20516892f, 0.11015806f, -0.09219423f, 0.17771080f, -0.07492368f, 0.02095756f, 0.02016844f, -0.05268063f, 
    0.02702533f, -0.06899905f, 0.02052438f, -0.01878183f, -0.00614415f, 0.00280702f, -0.00396039f, -0.26912600f, 
    0.10010266f, 0.04835677f, -0.05329235f, -0.10078981f, -0.01271006f, 0.07643931f, -0.00687262f, -0.05203149f, 
    -0.11807636f, 0.08085112f, 0.12290724f, 0.03001007f, 0.04370543f, -0.08372110f, 0.00746892f, -0.02580634f, 
    0.02873002f, -0.10344402f, -0.07312693f, -0.02939467f, 0.06093460f, -0.04843185f, 0.19820766f, 0.10828441f, 
    -0.01231349f, -0.01601718f, 0.05081037f, 0.00085554f, -0.07087331f, 0.03589742f, 0.09075727f, -0.03090994f, 
    -0.01476358f, 0.13972074f, 0.19559860f, -0.17885169f, 0.02928704f, -0.07322347f, -0.06655549f, -0.02372049f, 
    -0.01060431f, 0.10805530f, -0.04917759f, 0.07249296f, -0.30446374f, 0.06686502f, -0.16186862f, 0.06537366f, 
    0.01934665f, 0.03096440f, -0.09557556f, -0.11545455f, 0.07721863f, 0.09059672f, 0.10118551f, -0.00639799f, 
    0.06667901f, -0.11851727f, -0.04052309f, 0.21998516f, -0.18188438f, 0.04109492f, 0.02728600f, 0.07851769f, 
    0.01963539f, 0.04958850f, -0.00986646f, -0.04640799f, 0.12061110f, 0.01844647f, -0.04991095f, 0.10290106f, 
    -0.12112702f, -0.08366783f, 0.02283657f, 0.10095179f, 0.08213719f, 0.01362838f, -0.01956622f, -0.00823358f, 
    0.00681900f, 0.11482480f, 0.00458378f, 0.00659232f, -0.00105720f, -0.00547876f, 0.00240010f, 0.11342489f, 
    -0.05348481f, 0.02445604f, 0.00769090f, 0.10778077f, 0.04635274f, 0.08223896f, -0.30540386f, -0.06729541f, 
    0.07491377f, -0.07375868f, -0.02020016f, -0.00276925f, 0.10179196f, -0.05879462f, -0.15323751f, -0.14239825f, 
    -0.02799160f, -0.08158576f, 0.02629871f, -0.31003037f, 0.02682943f, 0.06225397f, 0.10955429f, 0.02129677f, 
    0.06912134f, 0.04682866f, 0.02073251f, 0.00970316f, -0.35054523f, -0.11205248f, -0.03833506f, -0.05122218f, 
    0.09730233f, -0.06524386f, 0.07724518f, -0.08092184f, -0.05302215f, 0.10637277f, -0.12539165f, 0.00020679f, 
    -0.37498599f, 0.10269022f, -0.04407006f, -0.11734657f, -0.01551478f, -0.00588980f, -0.05045107f, 0.01822819f, 
    -0.01365943f, -0.08434343f, -0.05594980f, -0.01000601f, -0.08029773f, 0.08587024f, -0.02523135f, 0.16060901f, 
    -0.19361527f, -0.10694201f, -0.02447731f, -0.03061379f, -0.01074204f, 0.04084633f, -0.02562474f, 0.06520693f, 
    -0.19417627f, -0.14198525f, -0.15524752f, 0.00901991f, 0.10022335f, -0.05164381f, -0.08918566f, 0.04912363f, 
    0.08695526f, 0.06353737f, 0.17798477f, 0.09016424f, -0.30297184f, 0.02394899f, -0.26819789f, 0.05182758f, 
    -0.10609790f, -0.04043075f, -0.02226461f, -0.02054680f, 0.01286421f, 0.01173434f, 0.03331592f, 0.03301999f, 
    -0.05430423f, -0.00083153f, -0.08648325f, -0.06593886f, 0.00067074f, -0.04821904f, 0.00576034f, 0.10914645f, 
    0.18689768f, 0.02169827f, -0.02457229f, -0.12307065f, -0.22684874f, 0.01867362f, -0.23804899f, 0.03838480f, 
    -0.01191806f, -0.02592052f, 0.05485073f, -0.09886953f, -0.01337136f, 0.00977173f, 0.00665500f, 0.07947550f, 
    0.34257430f, -0.04510558f, -0.12554236f, -0.00956104f, 0.10796957f, 0.10782692f, -0.10992637f, 0.02523106f, 
    0.04055397f, -0.00489986f, 0.03691075f, 0.01892874f, -0.13684571f, 0.05647440f, 0.12813021f, 0.09871230f, 
    -0.11814327f, -0.04636966f, 0.06444754f, -0.00167977f, 0.00528532f, 0.06970015f, -0.15707651f, 0.18833584f, 
    0.07369658f, -0.00301769f, 0.17853808f, 0.20359075f, -0.11323115f, -0.02225581f, 0.07256529f, -0.02070531f, 
    0.04218483f, -0.01020933f, 0.03362942f, -0.05375315f, -0.03281940f, -0.10694187f, -0.12378120f, -0.02927135f, 
    0.05171065f, 0.01944461f, -0.00658650f, -0.02525404f, -0.03943436f, -0.00009336f, -0.01316209f, 0.06800950f, 
    0.18251124f, 0.01736118f, -0.12362075f, -0.01772603f, 0.08267085f, -0.16968182f, 0.08065288f, -0.02544784f, 
    0.04460668f, 0.09424525f, -0.12306321f, -0.04540258f, 0.02265332f, -0.06499258f, -0.01337944f, 0.13855548f, 
    0.05704908f, -0.05752349f, 0.08386366f, -0.00907981f, 0.02701920f, 0.11419829f, 0.01356564f, 0.02261307f, 
    0.17113584f, -0.00273444f, 0.00714131f, 0.17346181f, -0.01754857f, -0.06771013f, -0.04384116f, -0.02061949f, 
    0.05945098f, -0.18067785f, -0.12831020f, 0.00900434f, 0.05631695f, -0.03679006f, 0.00445364f, -0.15371224f, 
    0.08220857f, 0.01122997f, 0.08201731f, 0.11501567f, -0.02492147f, 0.12778081f, -0.01015184f, -0.06613830f, 
    -0.18023625f, -0.17607194f, 0.10235990f, -0.34491056f, -0.00118400f, -0.05429965f, 0.11103392f, 0.04497037f, 
    -0.00075314f, 0.00957927f, -0.03783544f, 0.01891565f, 0.17833447f, -0.03834186f, -0.04908483f, -0.06272006f, 
    0.07347237f, -0.00681871f, 0.09500475f, 0.07547490f, 0.06883401f, 0.06179751f, 0.00841267f, 0.02955551f, 
    -0.14962423f, -0.06458856f, -0.18816818f, 0.00250871f, -0.01608861f, -0.02219461f, -0.20711669f, -0.02477350f, 
    -0.07491124f, -0.24627420f, 0.05198704f, -0.01252254f, 0.31452131f, -0.08061792f, 0.10248595f, -0.24694274f, 
    0.06600191f, -0.00141429f, 0.06891964f, 0.06357663f, -0.09756791f, 0.07327510f, 0.06928018f, -0.06003323f, 
    0.07435112f, 0.09233522f, 0.03630736f, 0.03611593f, -0.03320877f, 0.06746180f, -0.01906880f, -0.10690221f, 
    -0.02672826f, -0.08553963f, -0.03344481f, -0.09964501f, 0.28104398f, 0.13534226f, -0.16323940f, -0.08785454f, 
    0.07502177f, -0.17159545f, 0.08186252f, -0.09342138f, -0.19166552f, -0.05932430f, -0.09311753f, 0.11866372f, 
    0.05051492f, 0.12994391f, 0.00522110f, 0.32505029f, -0.04980093f, 0.12194163f, 0.03837957f, -0.00152946f, 
    -0.06852212f, 0.02553679f, 0.01020768f, 0.08783115f, 0.15764853f, -0.34386578f, 0.07816677f, -0.23990373f, 
    -0.06231009f, 0.04283835f, -0.10578063f, -0.05689495f, 0.08535109f, 0.01904801f, -0.01307264f, 0.14775984f, 
    -0.37675312f, 0.10477761f, -0.12109689f, 0.12628002f, 0.02160545f, -0.06475519f, -0.10256591f, 0.02853136f, 
    -0.00512007f, -0.03594214f, 0.17881019f, 0.06056347f, -0.20983338f, -0.11548791f, -0.19020344f, -0.01137225f, 
    0.03174951f, -0.09040703f, -0.06982714f, -0.04755111f, -0.10317379f, 0.02601218f, 0.05659964f, -0.06267276f, 
    -0.50094706f, -0.00288420f, -0.04215354f, -0.12274324f, 0.02324156f, 0.03659928f, 0.00525621f, -0.02116810f, 
    0.08594160f, 0.04468719f, 0.02585716f, -0.11126249f, -0.07049038f, -0.18093108f, 0.04261963f, -0.17720748f, 
    -0.08436801f, -0.01185975f, 0.05483440f, 0.09663612f, -0.01607986f, -0.02355685f, 0.05675083f, 0.07986909f, 
    0.17642441f, 0.13043050f, 0.00708056f, 0.26949030f, -0.01753035f, -0.02242776f, 0.06108298f, 0.08507845f, 
    0.02097844f, -0.03896163f, -0.12102892f, 0.08750989f, -0.12276361f, 0.04911439f, -0.03969326f, 0.01613586f, 
    0.03107467f, 0.06652910f, 0.11294690f, -0.13313267f, 0.02566873f, -0.02957699f, 0.01043515f, 0.12033689f, 
    0.00932354f, 0.12875532f, -0.02615081f, -0.41574785f, 0.03153926f, 0.16929398f, -0.10744081f, 0.08333203f, 
    0.08242019f, -0.04524665f, 0.12208847f, 0.03093409f, 0.07259306f, 0.12537690f, -0.18188913f, -0.21430553f, 
    -0.15776692f, 0.01467219f, 0.06817587f, 0.10643932f, -0.02582519f, 0.12868077f, 0.02223537f, 0.08583214f, 
    -0.17726977f, 0.02374914f, -0.22648461f, -0.08395713f, -0.04514244f, 0.01908937f, 0.04492931f, -0.08240014f, 
    0.03760910f, 0.08361025f, 0.01119428f, -0.01953049f, 0.19542240f, 0.04207630f, 0.09989920f, 0.12409937f, 
    -0.08305623f, -0.16385542f, 0.05456939f, -0.03045607f, -0.01646076f, -0.10353755f, -0.10265473f, 0.03186229f, 
    -0.18509087f, -0.00441961f, -0.01891770f, -0.01112288f, -0.03498326f, 0.08697694f, -0.09922185f, 0.11700784f, 
    -0.02969961f, 0.12563974f, -0.06013089f, -0.00954369f, -0.30760750f, -0.01988945f, -0.04786963f, 0.02445015f, 
    0.09993713f, -0.14801626f, -0.10082987f, 0.06680328f, 0.13802940f, 0.05965894f, 0.06089033f, -0.04966177f, 
    0.20826361f, -0.29115710f, 0.03579368f, -0.11824838f, 0.04513365f, -0.14726943f, -0.05481992f, 0.00909659f, 
    -0.03392691f, -0.02882365f, -0.09119834f, -0.04808708f, -0.21819997f, 0.00447742f, -0.09657344f, -0.01741090f, 
    0.01169694f, 0.02829680f, -0.00147604f, -0.01437259f, 0.03690289f, 0.07110196f, -0.05364921f, 0.18098478f, 
    0.42439541f, -0.06835041f, 0.03575070f, 0.12211969f, -0.09310669f, 0.02282088f, -0.01073018f, -0.07663587f, 
    0.03274234f, 0.12085471f, 0.08776035f, 0.06081364f, 0.08192769f, 0.01697014f, 0.11698571f, 0.00038225f, 
    -0.05535264f, -0.02370902f, -0.01054252f, 0.04047867f, 0.18998224f, -0.01815730f, -0.07213107f, 0.05489634f, 
    0.06059908f, 0.00704471f, 0.13281816f, -0.01299439f, 0.02478179f, 0.12605268f, 0.05829110f, 0.06049044f, 
    0.12527834f, -0.17186198f, -0.15122274f, 0.11168033f, 0.03290456f, -0.05571366f, -0.13763155f, -0.42349428f, 
    -0.04823672f, 0.03257116f, -0.00852388f, -0.04562751f, -0.02193018f, -0.08091424f, -0.04835266f, 0.09072894f, 
    0.06167784f, -0.02388969f, 0.05732227f, -0.22467795f, 0.14507098f, -0.11962746f, -0.01601676f, 0.05157984f, 
    0.09477517f, -0.03912379f, -0.02791390f, -0.09292841f, -0.06590145f, 0.12502383f, -0.24123584f, -0.05267317f, 
    0.05953905f, 0.02397282f, -0.05293356f, 0.02816310f, -0.09083103f, -0.00648851f, 0.04206027f, -0.01763302f, 
    0.15177184f, 0.16865470f, -0.17695990f, 0.08666077f, -0.03907153f, 0.03544585f, -0.12411875f, -0.00088564f, 
    -0.05753996f, -0.04512944f, 0.11875843f, -0.08551449f, -0.00028284f, 0.13498865f, -0.01716542f, -0.15849894f, 
    -0.03032701f, -0.08289143f, 0.04082795f, -0.07667378f, -0.06354985f, 0.05962452f, 0.09928673f, -0.05307190f, 
    0.03541745f, 0.13828798f, -0.02180763f, 0.05893145f, -0.00119096f, -0.03697278f, -0.10375769f, -0.13908158f, 
    -0.06499173f, -0.05161159f, 0.01413151f, -0.10584861f, -0.39109308f, 0.02502175f, -0.06922504f, 0.00058157f, 
    -0.01096976f, 0.00047152f, -0.05390336f, -0.02100101f, 0.04327573f, -0.08186562f, -0.04941278f, -0.15955019f, 
    0.09823192f, -0.12890857f, -0.03489742f, 0.12798187f, -0.04845909f, 0.07615227f, 0.02396699f, -0.00559231f, 
    -0.07714485f, -0.05366324f, -0.01821543f, -0.06974951f, 0.03580169f, -0.03314808f, -0.20224148f, -0.17882140f, 
    -0.00500862f, 0.08798695f, 0.04453505f, 0.14449145f, 0.13017054f, -0.04766057f, 0.01190154f, -0.04751105f, 
    0.13778546f, 0.00622559f, 0.16592173f, 0.09136495f, -0.13094108f, 0.12095498f, 0.00721610f, 0.00531989f, 
    -0.03621689f, -0.07004805f, 0.16017637f, -0.09060342f, 0.38395610f, -0.25257853f, 0.02004235f, -0.06000908f, 
    0.05331999f, -0.06146461f, 0.01064156f, -0.02108147f, 0.10348209f, 0.16183622f, -0.16214202f, 0.01032369f, 
    0.01489356f, 0.20495959f, 0.04771164f, 0.08091314f, -0.01388246f, -0.03736934f, 0.09198741f, 0.00745740f, 
    0.09250760f, -0.05313141f, -0.01819409f, -0.01365328f, 0.02374193f, -0.07499220f, -0.19031398f, 0.04410771f, 
    0.00663201f, -0.07560717f, 0.05545740f, -0.03435566f, -0.18560037f, -0.15202990f, 0.04855473f, 0.07471138f, 
    -0.18350875f, -0.07433341f, 0.00114713f, 0.21420690f, -0.05405655f, 0.03039865f, -0.04051056f, -0.01831098f, 
    -0.05017042f, -0.04116656f, 0.03358368f, -0.02250561f, -0.08017891f, 0.07146093f, 0.06365076f, -0.05985854f, 
    0.12530132f, -0.08312424f, -0.02457329f, 0.14073934f, 0.07690708f, -0.03453245f, -0.03378752f, -0.10922252f, 
    0.08423073f, -0.02140406f, -0.14324166f, 0.00355591f, 0.01600104f, 0.01558798f, -0.01379865f, 0.04788683f, 
    -0.06379128f, -0.04887873f, 0.03978959f, 0.07028476f, 0.18511701f, -0.17242631f, -0.14348052f, -0.18824969f, 
    -0.13626672f, 0.02221983f, -0.03143090f, -0.03944185f, -0.00696741f, 0.02745725f, -0.02047025f, 0.01513412f, 
    0.26853466f, -0.03108266f, -0.19847985f, -0.12252294f, -0.01244922f, 0.02668424f, -0.04638438f, 0.08974048f, 
    0.07028338f, -0.07363600f, 0.03537709f, -0.06641215f, 0.09214864f, -0.04610298f, -0.08764898f, -0.03515012f, 
    0.01154562f, -0.01553938f, -0.09187447f, 0.06727850f, -0.06738280f, -0.09801847f, -0.03177810f, 0.01362325f, 
    0.15923595f, 0.04570625f, 0.02656485f, 0.07287107f, -0.01914266f, -0.04346167f, -0.04573878f, -0.02444475f, 
    -0.05767965f, -0.04582958f, -0.00384215f, 0.00209212f, 0.23622246f, -0.02924963f, 0.14237818f, 0.21916646f, 
    -0.03846180f, 0.00637898f, -0.10670836f, 0.01113376f, -0.07045653f, 0.04498015f, -0.05440766f, -0.03515011f, 
    -0.03676465f, -0.07095458f, -0.09432170f, 0.04765299f, -0.08562978f, -0.01996695f, -0.15384760f, -0.04236707f, 
    -0.09194121f, -0.13219346f, 0.03623150f, -0.09237214f, -0.22164257f, -0.17733425f, -0.14952901f, -0.25736254f, 
    0.01270677f, -0.02480628f, 0.00703288f, -0.09494352f, 0.05969357f, 0.04145344f, 0.04835065f, 0.01912289f, 
    0.04891603f, -0.01416052f, -0.14971149f, 0.03012866f, 0.01028245f, -0.04523070f, -0.07922873f, -0.09615415f, 
    -0.08544534f, 0.05331613f, 0.03461385f, -0.11809688f, 0.36001086f, 0.15986729f, 0.04270056f, 0.01180578f, 
    0.04978865f, -0.01337747f, 0.01485077f, 0.07143542f, -0.12584704f, -0.03756658f, 0.02388651f, -0.04916097f, 
    -0.15918240f, -0.07086301f, -0.03276564f, -0.22683217f, -0.13255922f, 0.06494787f, 0.03893138f, -0.09943553f, 
    0.11336157f, 0.00525475f, -0.06047134f, -0.06018048f, -0.07419202f, 0.09496088f, -0.24986662f, -0.48398009f, 
    -0.16831334f, -0.08349112f, -0.03924836f, 0.02932672f, 0.07637478f, -0.02453219f, -0.12159552f, -0.00925264f, 
    -0.00867959f, 0.16030718f, -0.27972105f, 0.02423633f, 0.02440411f, 0.05056240f, -0.04279337f, -0.04065414f, 
    -0.09532993f, 0.05456684f, -0.15911250f, 0.02688817f, 0.24455905f, -0.07267048f, 0.00620379f, -0.00854933f, 
    -0.03167373f, -0.02537991f, 0.06445235f, 0.04907011f, -0.08265430f, -0.10333683f, -0.05544583f, -0.09335588f, 
    -0.12097333f, 0.02994550f, 0.09505693f, -0.13796332f, -0.03200109f, -0.12896156f, -0.05904752f, -0.12267245f, 
    -0.07998498f, -0.02831422f, -0.10369026f, -0.14584488f, 0.23428068f, -0.05509579f, 0.08463260f, 0.02924770f, 
    -0.13144201f, -0.17192592f, 0.00249806f, 0.12138253f, 0.06165065f, 0.03449833f, -0.00086014f, -0.09005886f, 
    0.32118320f, -0.10504181f, -0.10799653f, -0.03624582f, -0.01565436f, -0.00835085f, -0.08368952f, -0.02409136f, 
    0.01846104f, -0.04490681f, 0.08567062f, 0.02847230f, 0.12781771f, -0.01957449f, -0.11061989f, -0.02562379f, 
    0.14347987f, 0.09681023f, -0.06211568f, -0.03505945f, 0.02670070f, -0.02052680f, 0.06355453f, -0.10965150f, 
    -0.04713168f, 0.03770922f, -0.01242034f, 0.09407312f, 0.12695782f, 0.05394708f, -0.04121780f, -0.12120709f, 
    0.00175368f, 0.00377120f, -0.05547800f, -0.00846083f, -0.23124357f, -0.02642103f, -0.18471816f, -0.03575314f, 
    0.08806749f, 0.01927058f, -0.03130622f, 0.00581781f, -0.07396676f, 0.00310024f, -0.14279053f, -0.10485855f, 
    0.34422231f, 0.01840304f, -0.04164226f, 0.22840333f, -0.11201219f, -0.10864762f, -0.03736307f, 0.00639027f, 
    0.07533733f, 0.09051173f, 0.01489333f, 0.03994877f, -0.08785001f, 0.11046425f, -0.07585261f, -0.08232851f, 
    0.09438797f, 0.05173800f, -0.04627220f, 0.02369142f, -0.16301163f, 0.08550873f, 0.02345986f, -0.09096748f, 
    0.07820286f, 0.09298234f, -0.08544283f, 0.04442963f, 0.07325079f, 0.00909037f, 0.03402786f, 0.09111566f, 
    -0.02798339f, -0.04871208f, 0.00016509f, -0.06222183f, -0.03423426f, 0.07519766f, 0.03080417f, -0.11585911f, 
    -0.01121973f, 0.03160909f, 0.03291775f, -0.04029155f, 0.00551670f, 0.02047023f, -0.01481703f, -0.02421232f, 
    -0.21066566f, 0.02899317f, -0.03201088f, 0.00790328f, 0.01536944f, 0.09808142f, -0.04526373f, 0.00415423f, 
    -0.09877901f, -0.00839874f, 0.09860780f, 0.00610478f, 0.22693546f, -0.05790551f, 0.19305250f, 0.21854863f, 
    -0.14108020f, -0.12098183f, 0.03844335f, 0.10481820f, -0.02517249f, -0.00982341f, -0.01578786f, -0.11383225f, 
    0.14136094f, -0.20329493f, 0.01627874f, 0.04161740f, -0.04175594f, 0.01594026f, -0.03454975f, 0.04686977f, 
    -0.03603048f, -0.04485109f, -0.07448950f, -0.11780605f, -0.17286298f, 0.08476408f, 0.00995130f, -0.28063512f, 
    -0.12085776f, -0.05156798f, 0.05247164f, -0.12485528f, 0.01502016f, -0.02729793f, -0.11675595f, 0.03308022f, 
    0.12631376f, 0.05822563f, -0.04723020f, -0.02919565f, -0.18152446f, -0.00946011f, 0.03119018f, 0.04989657f, 
    -0.04787817f, 0.08633427f, 0.07883602f, 0.03628051f, -0.02475908f, 0.03681500f, 0.03947210f, -0.04765477f, 
    -0.02214963f, 0.10388587f, 0.09189068f, 0.08446297f, -0.14754409f, 0.00325033f, 0.07817211f, -0.13763312f, 
    -0.03524703f, 0.08018529f, -0.09198250f, -0.07919160f, 0.07737181f, 0.02430401f, 0.03857042f, 0.00975815f, 
    -0.09165813f, -0.02849279f, -0.01686580f, -0.01558670f, -0.04230435f, -0.01807668f, 0.00559825f, 0.04613997f, 
    0.06255208f, -0.05708809f, 0.07915912f, -0.09233625f, 0.00115372f, -0.01110294f, -0.00469867f, 0.12926807f, 
    0.26731977f, -0.03789987f, -0.28596437f, 0.02822147f, -0.08806237f, 0.12261585f, 0.03957782f, 0.02626305f, 
    0.07554347f, 0.01256518f, -0.13095026f, -0.05253172f, 0.23633705f, -0.08850776f, -0.05879970f, 0.00811917f, 
    -0.02199948f, 0.10972325f, -0.01380696f, 0.03482070f, -0.09861352f, -0.08766836f, 0.12596747f, -0.08450466f, 
    0.25449544f, 0.08714844f, 0.05393963f, -0.16195828f, -0.00258833f, -0.04498968f, 0.06978464f, 0.02275258f, 
    -0.08894772f, 0.11494302f, -0.03244815f, -0.13281056f, -0.41602650f, -0.03226415f, -0.00409698f, -0.09710506f, 
    -0.08806807f, 0.04947400f, 0.02890952f, 0.01742522f, -0.02353531f, 0.00947159f, -0.01117536f, 0.01817386f, 
    0.02108273f, 0.09747402f, -0.08477286f, -0.07661882f, -0.01390924f, 0.00337012f, 0.01913795f, -0.02965273f, 
    0.02220817f, 0.04901002f, 0.10447691f, -0.04916702f, -0.13877238f, -0.04184735f, 0.02973342f, -0.21212739f, 
    -0.08318017f, 0.01643005f, -0.06693923f, -0.00643423f, -0.07596178f, -0.08483385f, 0.09901200f, -0.14536321f, 
    -0.07903914f, 0.15417269f, -0.30208737f, 0.06897442f, 0.01391099f, -0.01729022f, -0.01354961f, -0.07341354f, 
    -0.04828120f, -0.02348200f, -0.01987104f, 0.00212833f, -0.39388135f, -0.09194695f, 0.04769936f, -0.26139164f, 
    0.00285088f, -0.09520446f, 0.08784967f, -0.08663048f, 0.06840552f, -0.01508311f, -0.00439792f, 0.00895791f, 
    0.03294979f, -0.01756538f, -0.25388399f, -0.08275555f, 0.03807335f, 0.09384101f, 0.05810248f, -0.00946087f, 
    -0.08424694f, 0.10743205f, -0.06755349f, -0.02513107f, 0.11039183f, -0.06470067f, 0.12091032f, -0.06937287f, 
    -0.00742347f, -0.02776476f, 0.03154593f, 0.07687988f, 0.01425348f, 0.07306727f, 0.03503213f, -0.08625988f, 
    0.19928695f, -0.13235931f, -0.07014602f, 0.02484136f, -0.05770672f, -0.00899534f, 0.10921375f, 0.07497921f, 
    0.01994129f, -0.11901145f, 0.02075152f, -0.07406199f, -0.04704234f, 0.07861321f, -0.07350212f, 0.07010219f, 
    0.01019557f, 0.06826989f, 0.01359501f, -0.04715760f, -0.02082478f, 0.02021537f, -0.02374904f, -0.02897838f, 
    0.17673607f, 0.16902114f, 0.09039046f, 0.29747587f, -0.10964897f, -0.04389663f, 0.11255751f, 0.10859513f, 
    -0.01403597f, 0.03235285f, -0.03024798f, -0.04175305f, -0.25639787f, -0.09452294f, -0.22670828f, 0.00981909f, 
    -0.06626797f, 0.04825720f, -0.00995731f, -0.00157897f, -0.02450179f, 0.00211042f, -0.03451749f, -0.06281563f, 
    -0.12602109f, 0.01917438f, 0.03581383f, -0.13429898f, 0.04785206f, 0.00304148f, 0.03741404f, 0.00201170f, 
    -0.08354395f, -0.01083048f, 0.00955277f, -0.02518793f, -0.14513084f, 0.09695631f, -0.03245082f, 0.05861554f, 
    0.06832960f, -0.05815668f, 0.07030504f, 0.07794590f, -0.11288655f, -0.01447447f, 0.01564129f, -0.01630900f, 
    -0.12764850f, 0.02314159f, 0.00935953f, -0.09221282f, -0.03324658f, -0.03081000f, -0.06933594f, 0.02110475f, 
    -0.08914945f, 0.03164107f, 0.04770406f, 0.05117059f, -0.12781574f, -0.12083526f, -0.08479434f, -0.24670252f, 
    0.07853335f, 0.02888367f, 0.01586755f, -0.17645618f, 0.02835377f, 0.02653768f, -0.05134468f, -0.00067150f, 
    0.29698744f, 0.07338878f, -0.01373651f, 0.27465564f, -0.15809858f, -0.07254352f, 0.02877319f, 0.07680930f, 
    0.00971029f, 0.06732711f, -0.02886602f, 0.03396015f, 0.30414143f, -0.08476501f, -0.25095797f, 0.12762578f, 
    -0.16219075f, -0.00351009f, 0.10600963f, -0.02828644f, -0.04721509f, 0.02156099f, 0.00269851f, 0.01024053f, 
    0.18820412f, -0.25925687f, 0.15938643f, 0.03584468f, -0.13347545f, 0.06388165f, -0.10674529f, 0.01355902f, 
    0.07166413f, -0.03673205f, -0.15566640f, 0.02203821f, -0.48120740f, 0.03556727f, 0.11202612f, -0.21508077f, 
    0.02859514f, 0.06816391f, 0.07791597f, 0.04106034f, -0.10113834f, -0.12015017f, -0.10671098f, -0.06762582f, 
    -0.04295867f, -0.05150995f, 0.00826090f, -0.09427512f, -0.02268147f, 0.09755911f, -0.10877351f, 0.02747332f, 
    0.00141677f, 0.09386792f, -0.07843097f, -0.00380456f, 0.33837703f, 0.06119706f, -0.20623966f, -0.10426070f, 
    -0.13657412f, 0.00445216f, 0.12536380f, -0.00963573f, -0.04375998f, 0.06897857f, 0.01951634f, -0.00476679f, 
    0.13708140f, 0.00425284f, 0.02829468f, -0.24184978f, -0.05128109f, 0.01598825f, -0.03045424f, -0.00959262f, 
    0.12196226f, -0.03974913f, 0.04603184f, -0.14942534f, -0.00600367f, -0.12796354f, -0.01540680f, -0.16679806f, 
    0.10119631f, -0.01415470f, 0.06170945f, -0.01171524f, -0.03607108f, 0.02044885f, -0.04626065f, 0.06034106f, 
    0.03808052f, -0.01941611f, 0.04665068f, 0.04377667f, 0.04649710f, 0.04783134f, -0.02090362f, -0.03258857f, 
    0.10390983f, 0.06669561f, -0.04400640f, -0.01928302f, 0.05050416f, 0.03004788f, 0.00471699f, 0.05784697f, 
    -0.04644331f, -0.09980306f, 0.09301450f, 0.08602030f, -0.00103985f, -0.05230021f, -0.00896713f, 0.03971462f, 
    -0.35442033f, 0.03631677f, 0.04944363f, -0.10318296f, -0.02898158f, -0.01185299f, -0.01645465f, -0.04648933f, 
    -0.03440994f, 0.04342009f, 0.03258323f, 0.03111606f, -0.12704419f, 0.08084665f, -0.12197813f, -0.01233511f, 
    0.02613626f, 0.09377810f, -0.02238257f, -0.09159154f, 0.06796390f, -0.00122938f, -0.10720646f, 0.04493949f, 
    0.32537168f, -0.05269801f, -0.06766053f, 0.00793152f, 0.01257440f, 0.04440876f, 0.03117690f, 0.02021584f, 
    0.07755682f, -0.00246630f, 0.02547381f, -0.01040766f, 0.02705323f, 0.10721466f, -0.00323020f, 0.07592011f, 
    -0.02968564f, 0.02480008f, 0.09667854f, -0.05621789f, -0.11718594f, -0.03764332f, -0.07487441f, 0.02565695f, 
    0.12799090f, -0.08169672f, 0.11249028f, 0.01690242f, 0.04042168f, -0.02040254f, -0.02910087f, 0.01610300f, 
    0.10288977f, 0.04478030f, 0.01537633f, 0.02962421f, -0.03159901f, -0.24166714f, 0.03214491f, -0.13386524f, 
    0.02387435f, -0.01093001f, -0.04496644f, -0.03013916f, -0.05091114f, -0.01803362f, -0.04590901f, -0.08562897f, 
    0.29621166f, -0.14277054f, 0.18501624f, 0.13395235f, -0.04172051f, -0.00272030f, -0.06066650f, 0.00673444f, 
    0.03446938f, 0.02739777f, -0.01796101f, -0.00522724f, 0.30341795f, -0.00965306f, -0.10359455f, 0.09781205f, 
    -0.05171905f, 0.05049362f, 0.09564567f, 0.01210703f, -0.00509286f, -0.02656380f, 0.01460930f, -0.02195558f, 
    0.06509922f, -0.10329846f, 0.09654133f, 0.00471749f, 0.08369785f, 0.06929228f, -0.00423697f, 0.07522892f, 
    0.03625404f, 0.00729391f, 0.00125630f, -0.02173436f, 0.14149345f, -0.04624012f, -0.01553783f, -0.01168501f, 
    0.13821387f, 0.01019840f, 0.02516128f, -0.01401674f, 0.00248572f, 0.01245913f, 0.04566114f, -0.02678096f, 
    0.22034930f, -0.06247596f, 0.05372287f, -0.06709056f, -0.01250977f, -0.01396191f, -0.08554161f, -0.06649630f, 
    -0.06724385f, 0.05364629f, -0.01336095f, -0.12906905f, 0.12302870f, -0.04598093f, 0.08779142f, -0.01359475f, 
    -0.13043335f, -0.00355084f, 0.02223437f, 0.00883816f, -0.02889102f, 0.04187260f, 0.03362406f, 0.12328535f, 
    0.13924773f, 0.00623039f, 0.03589952f, 0.19511235f, 0.08360614f, -0.04738558f, -0.11298147f, 0.02391724f, 
    -0.01922774f, -0.01125889f, -0.08639732f, -0.07008548f, -0.19288215f, 0.10398289f, -0.04599005f, -0.16655879f, 
    0.04298040f, 0.00920411f, -0.07303256f, 0.03384744f, -0.05624131f, -0.09879989f, 0.05871997f, 0.04466425f, 
    -0.08846005f, 0.02434278f, 0.01890573f, 0.00605710f, -0.05085287f, -0.02141506f, 0.03685679f, 0.00101529f, 
    0.00439250f, 0.04635783f, -0.03163977f, 0.05533627f, 0.35748011f, 0.10135195f, 0.09459067f, -0.13231237f, 
    0.05430259f, -0.03140243f, 0.01181906f, -0.01849393f, -0.08866695f, -0.03896312f, -0.10499883f, -0.00296557f, 
    -0.30178946f, 0.24645904f, 0.01749022f, 0.18225549f, -0.00825366f, 0.04903606f, 0.07669930f, -0.03892550f, 
    -0.01236990f, 0.00933071f, -0.08540781f, -0.11378741f, -0.33000249f, 0.19897230f, 0.08029477f, 0.01918501f, 
    0.07522294f, -0.06764167f, 0.03946717f, 0.01871663f, -0.02803865f, -0.06565510f, -0.04473139f, -0.00004591f, 
    0.08923878f, 0.12760179f, -0.08919628f, -0.07512281f, -0.20297451f, -0.07742208f, 0.02775700f, -0.04108481f, 
    0.02541772f, -0.04265344f, 0.02189186f, -0.03037848f, 0.12198858f, -0.07875104f, 0.11364971f, -0.17360537f, 
    0.05864074f, -0.02199515f, -0.00217647f, 0.07231074f, -0.08336991f, -0.11371758f, 0.04332474f, -0.06176651f, 
    0.08096633f, 0.11231492f, -0.05295752f, 0.09975822f, -0.13538286f, -0.08839102f, 0.12853855f, -0.11323742f, 
    -0.12182625f, 0.09600526f, -0.17713042f, 0.00246637f, -0.42221773f, -0.11736456f, 0.25325292f, 0.06509411f, 
    0.01883051f, 0.01128365f, -0.01432394f, 0.00981332f, -0.04102031f, -0.00353253f, 0.05331432f, -0.11943033f, 
    0.05791285f, -0.35130963f, -0.07003304f, 0.16316271f, 0.05198817f, -0.04694321f, -0.04183321f, -0.08501915f, 
    -0.00403796f, -0.02484509f, -0.16048157f, 0.03339974f, 0.00535928f, 0.16561289f, 0.05601677f, 0.09527387f, 
    0.11226630f, 0.06454299f, 0.06133930f, -0.05694290f, -0.00652214f, -0.06119680f, 0.06270273f, -0.02930426f, 
    0.06771720f, 0.10005775f, 0.07935664f, -0.06547179f, -0.02268501f, -0.15778475f, -0.07429161f, 0.05917422f, 
    -0.09504543f, -0.02625529f, -0.00319152f, 0.00706861f, 0.38916856f, -0.42770129f, -0.24331944f, 0.08458104f, 
    0.00460753f, 0.04608899f, 0.02579100f, 0.06527878f, 0.08052466f, -0.11489446f, -0.13947266f, -0.09213141f, 
    -0.04030803f, -0.06556050f, -0.01763546f, -0.07049840f, -0.07850637f, -0.13639536f, 0.02941394f, -0.02532390f, 
    -0.09293718f, -0.03950431f, -0.13011482f, 0.01871567f, 0.12774277f, -0.18108419f, -0.07005536f, 0.10907321f, 
    0.01106434f, 0.03197534f, -0.06869511f, 0.03346972f, 0.05672500f, -0.06265881f, -0.04244116f, 0.04758623f, 
    0.07129855f, -0.02336313f, -0.01005018f, -0.02221226f, -0.11804611f, -0.04642826f, 0.10931383f, 0.02835199f, 
    0.03609523f, 0.00532488f, -0.01362401f, 0.14569679f, -0.09821168f, -0.03371534f, -0.12377452f, -0.08105046f, 
    -0.12619752f, -0.18781331f, 0.00306146f, 0.01040031f, 0.06115339f, -0.07336801f, -0.00631272f, 0.00837968f, 
    0.24265778f, -0.07001503f, 0.08925682f, 0.12608847f, 0.09684303f, -0.06244790f, 0.14505778f, -0.02026585f, 
    -0.01504682f, 0.06100480f, -0.17372139f, 0.03483821f, 0.06278238f, -0.08744117f, -0.03439233f, 0.09949455f, 
    -0.06056927f, 0.08127285f, 0.00515639f, -0.02373231f, -0.01229326f, 0.03431435f, -0.02641728f, 0.08335321f, 
    -0.19662470f, -0.18840522f, -0.22110347f, -0.22339769f, -0.07180753f, -0.06278291f, 0.04974075f, -0.07694649f, 
    -0.04627173f, 0.02976126f, 0.02748762f, 0.05722721f, -0.13376597f, -0.02509269f, -0.11198287f, -0.12061433f, 
    -0.07623246f, 0.10883086f, 0.07015943f, 0.10807741f, 0.05911984f, -0.02709128f, 0.07901633f, 0.08442890f, 
    -0.35486841f, -0.36014280f, 0.03233279f, -0.01856062f, -0.10954187f, 0.02932593f, 0.01340768f, 0.03275806f, 
    -0.00791744f, -0.01677121f, 0.17959145f, -0.06521966f, 0.19378397f, -0.04919747f, 0.07725763f, 0.09189915f, 
    -0.09781747f, 0.02403960f, 0.05313027f, 0.00653120f, -0.09101747f, 0.04307488f, -0.14478485f, 0.01092936f, 
    0.05052649f, -0.13646454f, 0.18258366f, 0.05160961f, 0.08241060f, 0.05471407f, 0.11159549f, 0.08696023f, 
    0.00453106f, -0.03765950f, 0.05835330f, -0.04041801f, -0.12796146f, 0.18468556f, 0.09077292f, 0.13669299f, 
    0.06795043f, 0.07528024f, -0.08927357f, 0.07487578f, -0.07375698f, 0.03292561f, -0.11914585f, -0.13824774f, 
    0.02128095f, 0.13039616f, 0.03853794f, -0.19739912f, -0.06635100f, -0.02015000f, -0.05632287f, 0.00740334f, 
    -0.01412187f, -0.05012791f, -0.03469601f, 0.09360120f, 0.04376065f, 0.09085088f, -0.09082324f, -0.06257094f, 
    0.09332363f, 0.14592440f, 0.02995282f, 0.05410744f, -0.01430193f, -0.01431506f, 0.08061276f, 0.07087656f, 
    -0.34952483f, -0.28549832f, -0.21870089f, -0.10892033f, -0.08161594f, -0.08543720f, 0.09605043f, -0.10763475f, 
    -0.07473244f, -0.05101210f, 0.12871851f, 0.03282437f, 0.12105168f, 0.03563899f, -0.03281658f, -0.06857718f, 
    -0.01387579f, -0.04630352f, -0.03567149f, 0.01148690f, -0.01893009f, -0.04146771f, 0.03667212f, -0.14405930f, 
    -0.24998333f, 0.08501658f, 0.00732350f, -0.07899756f, -0.01329413f, -0.04407385f, 0.11376919f, -0.01006111f, 
    0.09194173f, 0.05743793f, -0.05367737f, 0.05236597f, 0.07467844f, -0.13333900f, 0.03030990f, 0.02577391f, 
    0.02781476f, -0.01590154f, 0.01963029f, 0.04539232f, -0.05989904f, 0.12103588f, -0.01583701f, -0.03696939f, 
    0.41152993f, 0.10225187f, -0.05175327f, 0.05844510f, 0.06431083f, -0.01320565f, -0.03519924f, 0.11724145f, 
    -0.00293735f, 0.01603343f, -0.06140549f, 0.01715727f, -0.30429858f, -0.11210947f, -0.24957471f, 0.05055123f, 
    -0.16133022f, 0.03898885f, -0.07413887f, 0.00637162f, -0.01125944f, 0.07786036f, -0.05090384f, -0.04323710f, 
    0.07969975f, -0.02356684f, 0.12607250f, 0.15351745f, 0.10096537f, 0.00128617f, 0.10003518f, -0.08316232f, 
    0.00030253f, 0.00619632f, -0.08807263f, -0.07764434f, -0.19509082f, 0.11974092f, -0.06192568f, -0.02511716f, 
    -0.11599897f, 0.08224734f, 0.06082332f, 0.05975488f, -0.02517715f, 0.10147250f, -0.01710387f, 0.06153630f, 
    0.06246397f, -0.09477676f, -0.09589849f, 0.00777137f, -0.06266216f, 0.07306863f, 0.00000658f, -0.02137920f, 
    -0.03667499f, 0.02625348f, 0.01369685f, 0.00537403f, -0.01846166f, 0.04453185f, 0.14866690f, 0.17647943f, 
    -0.02959730f, 0.04517527f, 0.02108416f, -0.06250019f, 0.03157527f, 0.01394729f, -0.05837091f, 0.02153347f, 
    -0.33589801f, -0.24148817f, -0.19299331f, -0.12029967f, -0.04583323f, -0.05653004f, -0.01110507f, -0.04999655f, 
    -0.01344263f, -0.06812167f, -0.03789109f, 0.03612347f, -0.10684809f, 0.06436606f, -0.13156727f, -0.08374899f, 
    0.01718877f, 0.04891026f, -0.00978827f, -0.00232168f, -0.05048716f, -0.03193584f, -0.01082095f, -0.05417050f, 
    0.07316352f, 0.09632988f, -0.15545425f, 0.19236365f, 0.05797784f, 0.09446358f, 0.04210531f, -0.07919364f, 
    -0.05008974f, 0.04485535f, 0.01670854f, -0.00242069f, 0.12178938f, 0.15045877f, 0.04876677f, 0.04634901f, 
    -0.01140350f, -0.06059651f, -0.03855437f, -0.10008580f, 0.00843117f, -0.03693941f, 0.09694508f, -0.07187994f, 
    0.10172986f, 0.01211656f, -0.01870455f, -0.02969312f, -0.13657387f, -0.06355266f, -0.01947791f, 0.01864750f, 
    -0.10916398f, 0.08312915f, -0.02997293f, -0.00049704f, 0.12943296f, 0.09592680f, 0.01514419f, -0.02594364f, 
    0.06219786f, -0.13060194f, 0.08082937f, 0.02756379f, -0.05670752f, 0.00376941f, -0.00146153f, -0.08308563f, 
    0.04014307f, -0.01198931f, -0.03674921f, 0.05778137f, -0.03640105f, 0.02436564f, 0.00179879f, 0.11328032f, 
    0.02217955f, -0.04178889f, 0.02130400f, 0.04976101f, -0.08635187f, -0.26404512f, -0.12655635f, -0.11383476f, 
    -0.04753035f, -0.02614905f, -0.02653200f, 0.19370918f, 0.03823255f, 0.06604213f, -0.04088781f, -0.04883795f, 
    0.12360458f, 0.11261088f, -0.05424127f, 0.14215337f, -0.07675160f, 0.03532018f, 0.10175394f, 0.07578655f, 
    0.05163392f, 0.06534624f, 0.07439117f, 0.05454741f, -0.30522954f, 0.45174578f, 0.10402939f, 0.15501399f, 
    0.00422328f, 0.11794545f, -0.01644592f, -0.07661786f, -0.08962856f, 0.02783976f, 0.07862937f, 0.10863987f, 
    0.28107697f, -0.03069293f, -0.04984206f, 0.04758769f, -0.07834700f, 0.05842669f, -0.03399283f, -0.00681364f, 
    -0.02415780f, -0.05202350f, -0.00778248f, 0.00537465f, -0.09064512f, 0.03174910f, 0.23604962f, 0.09584280f, 
    0.03192339f, 0.00869157f, 0.02363432f, 0.01786060f, -0.01128129f, 0.08426578f, -0.05392756f, -0.00549424f, 
    -0.27661243f, -0.41262111f, -0.10702888f, 0.23427488f, -0.01459831f, -0.04994804f, -0.05909016f, -0.00090291f, 
    -0.07333786f, -0.03799967f, -0.03941638f, -0.05705343f, -0.04980671f, -0.07369924f, 0.02642794f, 0.05339612f, 
    -0.00454607f, 0.03195379f, 0.04769954f, 0.01477468f, -0.12152611f, -0.05823714f, 0.01407584f, 0.02830523f, 
    0.03885817f, -0.35300723f, -0.22985207f, 0.19911812f, -0.07802913f, 0.06860219f, -0.00565576f, 0.01894289f, 
    -0.01572033f, 0.10239115f, -0.03500415f, 0.05332180f, -0.14610091f, 0.11485601f, -0.16103362f, 0.09280272f, 
    0.01950738f, 0.04667256f, 0.06024570f, 0.02942883f, -0.03037538f, 0.06939635f, 0.00631728f, -0.00577126f, 
    -0.10718535f, 0.04653395f, 0.20739748f, -0.01360613f, 0.00797613f, 0.02255788f, 0.03521610f, -0.02240357f, 
    -0.03455158f, 0.05643671f, -0.04756499f, -0.00647318f, -0.39085042f, -0.06312696f, -0.06714037f, -0.19775546f, 
    0.00159214f, -0.08303796f, -0.14936313f, 0.01219279f, -0.02728904f, 0.10376155f, -0.01878965f, 0.01856687f, 
    0.04978313f, 0.05919940f, 0.07250901f, 0.11603070f, -0.01665031f, -0.08019153f, 0.06553654f, 0.01624980f, 
    -0.00009953f, 0.05752148f, 0.08251446f, 0.00986786f, 0.17917317f, 0.06431890f, 0.07299124f, -0.05327666f, 
    0.02898350f, 0.07169135f, 0.00288287f, -0.08971514f, -0.02712383f, 0.01299018f, 0.02775037f, -0.01614606f, 
    -0.05489979f, 0.02283352f, -0.03964464f, 0.12303350f, 0.03495769f, -0.08783595f, 0.05501731f, 0.01060256f, 
    -0.02718355f, 0.20941943f, -0.05041880f, -0.04592166f, 0.08665885f, -0.13476580f, 0.00510817f, -0.10830399f, 
    0.07702504f, 0.05584588f, 0.04499209f, -0.07435149f, -0.03578811f, -0.03385591f, -0.02072974f, 0.00176030f, 
    -0.16306402f, -0.28812647f, -0.02687701f, 0.13164876f, -0.07002022f, 0.10551376f, 0.01771228f, -0.03079762f, 
    0.09711163f, -0.10416897f, -0.01270354f, 0.04695253f, -0.17038491f, -0.24109603f, -0.13955252f, 0.00535047f, 
    -0.05615633f, -0.04063314f, -0.00861751f, -0.01404193f, -0.00403518f, -0.18149276f, 0.05307643f, -0.01996561f, 
    0.10063964f, -0.04319228f, -0.03834781f, 0.11819287f, 0.10089567f, -0.09040286f, -0.00757721f, 0.09348831f, 
    0.03619026f, -0.09792771f, 0.07524799f, -0.04000181f, 0.06167543f, -0.01967225f, 0.20072070f, -0.02777963f, 
    0.05699936f, -0.07226988f, 0.11909062f, 0.05903754f, -0.05481921f, 0.15495522f, 0.18215455f, 0.18080218f, 
    -0.02674722f, 0.12349293f, 0.18181038f, -0.07408040f, -0.05914715f, 0.02739979f, -0.03253927f, 0.04876408f, 
    0.00910999f, 0.01820432f, 0.02683186f, 0.05409619f, -0.08204156f, -0.00878677f, 0.04428576f, 0.14291805f, 
    0.04408023f, 0.02710389f, -0.01884439f, 0.02438376f, 0.00065976f, 0.00215253f, -0.02905381f, 0.03703639f, 
    0.08048020f, -0.27578464f, 0.01579957f, -0.19814879f, -0.03893719f, 0.02912408f, -0.07343100f, -0.04171296f, 
    -0.03395384f, -0.00292042f, -0.07888866f, 0.07719756f, 0.10743953f, -0.08908242f, 0.19432782f, -0.33837980f, 
    0.11739122f, 0.05504877f, -0.02562765f, 0.08225419f, -0.13276500f, -0.11653411f, 0.01509173f, 0.10783245f, 
    -0.26906148f, -0.15174913f, 0.09624974f, 0.12139497f, -0.04676858f, -0.05463944f, -0.01662607f, -0.13787881f, 
    0.03125513f, -0.07016806f, -0.03947300f, -0.11675867f, 0.03160070f, -0.08109679f, 0.01572339f, -0.12452693f, 
    0.05015148f, 0.11893372f, 0.07964173f, 0.03005358f, -0.01137961f, 0.09284934f, -0.06925222f, 0.00339040f, 
    0.10078292f, 0.06521194f, -0.06728832f, -0.17833371f, 0.22452095f, 0.00853142f, 0.05606798f, 0.14864635f, 
    0.02531127f, 0.04574331f, 0.03357924f, 0.03112710f, -0.15066816f, 0.02703855f, -0.19605181f, -0.17304179f, 
    -0.00185882f, 0.01861515f, -0.19445394f, 0.10735583f, 0.03807931f, -0.04851665f, -0.15827481f, 0.06853290f, 
    0.12094168f, -0.05945251f, -0.10621841f, -0.08664729f, 0.02546968f, 0.03617540f, -0.02546476f, 0.02687647f, 
    -0.02071051f, -0.06506249f, -0.03625986f, -0.01822771f, 0.04188297f, -0.02046718f, 0.04144615f, -0.03508344f, 
    -0.06024103f, -0.09389959f, 0.07383793f, -0.04707633f, -0.04501458f, 0.06003501f, 0.05164928f, -0.16047868f, 
    -0.15390176f, -0.05902540f, 0.13616659f, 0.10609224f, -0.13765231f, 0.04620351f, -0.03670011f, 0.06811333f, 
    0.00500932f, -0.02960628f, -0.10014130f, 0.02275627f, -0.11100644f, 0.07159304f, 0.17124806f, -0.00952526f, 
    0.08018066f, 0.03884120f, -0.06005092f, -0.01283954f, 0.15215571f, -0.00421156f, 0.03898787f, -0.04094856f, 
    -0.52792859f, -0.05416202f, 0.13160254f, 0.07438175f, -0.05148927f, 0.04751505f, -0.08564912f, -0.00708171f, 
    -0.11172847f, -0.18782233f, 0.07557187f, 0.00652532f, -0.24482277f, 0.01190364f, 0.09345095f, 0.15014549f, 
    -0.23660797f, 0.02639563f, -0.02086486f, -0.07236183f, 0.09688537f, -0.03464239f, 0.08632258f, -0.12256166f, 
    0.24765348f, -0.20979047f, 0.02312911f, 0.04008164f, -0.12971674f, -0.01774768f, 0.01436631f, -0.00559687f, 
    0.04789141f, 0.04354880f, -0.01918967f, 0.02679249f, -0.16345035f, -0.12861551f, -0.07385710f, -0.08328132f, 
    -0.04370178f, 0.01422921f, 0.01509351f, -0.05519837f, -0.10667600f, -0.02351823f, -0.11218959f, -0.01491202f, 
    0.16169640f, -0.11468074f, -0.10056382f, 0.17511067f, 0.01782779f, -0.00613225f, 0.04137482f, 0.03566565f, 
    -0.06329620f, -0.02170066f, 0.04693609f, 0.12477394f, -0.39020652f, -0.05799994f, 0.08618454f, 0.29843855f, 
    0.04119698f, -0.02567089f, -0.04318831f, 0.04150560f, -0.03073232f, 0.04660368f, 0.16318849f, -0.01573152f, 
    -0.05214367f, -0.03307693f, 0.00715166f, 0.02551222f, 0.05334535f, -0.06770324f, -0.06092289f, 0.03115430f, 
    -0.07845669f, 0.09531307f, -0.02599022f, 0.04687741f, 0.05771287f, -0.13146907f, 0.02471080f, 0.15626107f, 
    -0.02213558f, 0.12289071f, 0.05722607f, -0.07619854f, 0.10307637f, 0.06200284f, -0.07398699f, -0.10365778f, 
    -0.26687601f, 0.16098149f, 0.06855636f, 0.09297428f, 0.06559267f, -0.03098814f, -0.09789981f, 0.11648770f, 
    -0.05336137f, 0.03826738f, 0.06032440f, 0.03308737f, -0.18390945f, -0.18987642f, 0.04648779f, 0.03933996f, 
    -0.13448566f, -0.14449106f, 0.02898599f, -0.03733153f, -0.00131092f, 0.02872706f, 0.16539790f, 0.02443426f, 
    -0.07640576f, 0.02107224f, 0.08917064f, 0.03907786f, -0.00086566f, -0.07840599f, 0.12441505f, 0.08613591f, 
    -0.06008556f, 0.02150065f, 0.03324052f, -0.04506291f, 0.11094176f, 0.03578823f, -0.16266911f, -0.07929084f, 
    -0.02078690f, -0.01753308f, 0.07802199f, 0.02154698f, -0.18374096f, 0.14934860f, -0.00783561f, -0.08754867f, 
    -0.11767163f, -0.10949282f, -0.04375262f, -0.15869522f, -0.02430296f, 0.08645668f, 0.00475394f, -0.04313875f, 
    -0.05747161f, 0.01209895f, -0.19254044f, 0.07838918f, -0.29725608f, -0.22306111f, 0.13621415f, 0.10733537f, 
    -0.01394787f, -0.04260299f, -0.08632249f, -0.03457926f, 0.02413357f, -0.05485917f, -0.09636994f, 0.05332784f, 
    0.25852555f, 0.04405277f, 0.18543899f, 0.10512473f, 0.04136939f, -0.03368890f, 0.05801763f, 0.06801052f, 
    0.05526290f, -0.04219598f, 0.01319789f, 0.07129062f, 0.15261330f, 0.10289054f, 0.07991092f, 0.10693480f, 
    -0.02557577f, 0.00673371f, 0.20431878f, 0.04300673f, -0.10489070f, 0.02383080f, 0.10679627f, -0.00227128f, 
    0.05704827f, 0.18222353f, 0.05588817f, 0.04079738f, -0.11602776f, -0.06256668f, -0.00171982f, 0.01518764f, 
    0.06823310f, 0.00883512f, 0.07873907f, -0.09997877f, 0.08749440f, 0.01355397f, 0.06283072f, 0.02696634f, 
    -0.03394465f, 0.04494917f, -0.01525042f, -0.01831983f, -0.08629587f, 0.10482878f, -0.05850763f, 0.08061621f, 
    0.12178162f, 0.00555004f, 0.23886301f, 0.08602597f, -0.03092466f, -0.10668720f, 0.09458059f, -0.00150879f, 
    0.04752675f, -0.03222825f, -0.08514880f, 0.00823925f, -0.10460947f, -0.25828004f, 0.11001708f, -0.01492695f, 
    -0.03901739f, 0.04803741f, 0.05927815f, 0.00343613f, 0.06282298f, -0.06544665f, -0.06529658f, -0.16928218f, 
    0.28559050f, 0.21052502f, 0.02192902f, -0.32241961f, -0.04178109f, 0.02144515f, 0.07903630f, -0.02482548f, 
    -0.01782169f, 0.02325636f, 0.02906552f, -0.03918269f, -0.15976994f, -0.09960761f, 0.07961422f, -0.09315643f, 
    -0.08125532f, 0.09788199f, -0.00099257f, 0.04677707f, -0.00139827f, -0.05025074f, -0.00186234f, 0.05439959f, 
    -0.00107009f, 0.07135060f, 0.04178646f, 0.00756344f, 0.01976197f, -0.00488659f, -0.06557208f, -0.02500526f, 
    0.04397709f, -0.12227044f, -0.10558927f, -0.08123229f, -0.00268904f, -0.16408995f, 0.07002027f, -0.02230098f, 
    0.00560102f, 0.00934195f, 0.10048854f, 0.02054358f, -0.00783205f, 0.00932110f, 0.00163070f, 0.10771269f, 
    -0.38132378f, 0.13233671f, 0.17187028f, 0.14672762f, -0.04748360f, 0.11843885f, 0.01137618f, 0.02302213f, 
    0.05066384f, 0.06398924f, 0.11064681f, 0.06186698f, 0.11196642f, 0.06177220f, -0.29789680f, 0.02207943f, 
    -0.04887900f, 0.01810576f, 0.05070648f, -0.03714856f, 0.00542228f, -0.04497162f, 0.04609853f, -0.04703274f, 
    -0.00750373f, 0.24764699f, -0.10797931f, 0.05580147f, -0.03051591f, 0.02484443f, 0.10784276f, 0.04489839f, 
    -0.04115643f, -0.05004218f, -0.01290566f, -0.07685418f, -0.30789840f, 0.08336873f, 0.07081480f, -0.05659694f, 
    0.04501802f, -0.05041271f, -0.05178775f, -0.02480245f, 0.09785135f, 0.02778782f, -0.05425083f, 0.03505044f, 
    -0.18021649f, -0.01535975f, -0.08735842f, 0.03475391f, 0.07777075f, -0.00018984f, -0.08809716f, 0.00866431f, 
    -0.11476614f, 0.08271451f, -0.07078686f, 0.01202516f, 0.04004141f, -0.13078992f, 0.10408404f, 0.30970269f, 
    0.06580526f, 0.01000913f, 0.04020719f, -0.07843725f, 0.01486795f, 0.00938631f, 0.09421273f, 0.01226547f, 
    -0.19752270f, -0.12588088f, 0.06551611f, 0.20659676f, 0.04793861f, 0.05640227f, 0.04470172f, 0.11861721f, 
    0.04730958f, 0.00845504f, 0.11924001f, 0.00492687f, 0.36415973f, 0.34985670f, -0.26083514f, -0.30772316f, 
    -0.00678503f, 0.05414253f, -0.00840546f, -0.03584544f, 0.07647716f, -0.09098448f, -0.03625562f, 0.09271038f, 
    -0.34532148f, 0.23923922f, -0.17774399f, -0.18771450f, -0.01499490f, 0.04979300f, 0.13723963f, -0.01719250f, 
    0.09942451f, 0.05077717f, -0.00297027f, 0.05956693f, -0.10763168f, -0.05511712f, 0.10792893f, -0.32807645f, 
    -0.05109336f, 0.12556188f, -0.19728862f, -0.04170458f, -0.00625089f, 0.06275698f, 0.01482125f, -0.06476378f, 
    0.07414084f, -0.05179516f, -0.14085567f, -0.10298055f, 0.01387606f, 0.12315074f, 0.10279077f, 0.07258567f, 
    -0.01801499f, 0.00415620f, -0.01613770f, 0.08761182f, -0.24105214f, 0.02112184f, 0.18499008f, 0.00094620f, 
    0.10001922f, 0.04773424f, -0.13906975f, -0.02668575f, 0.03085751f, 0.10752576f, 0.09468999f, -0.00089720f, 
    -0.70923376f, 0.31623223f, -0.01152962f, -0.43395725f, 0.08445504f, -0.08535980f, 0.02241335f, 0.04744376f, 
    -0.06987303f, -0.02726360f, 0.05258025f, -0.04911708f, -0.09146869f, 0.10052543f, -0.05672276f, -0.34225613f, 
    0.07698825f, 0.12694234f, -0.12348106f, 0.02073677f, -0.01211669f, -0.19318560f, -0.07807191f, 0.00052063f, 
    -0.11197918f, 0.08730683f, 0.10900506f, 0.01755416f, -0.00248051f, -0.01399594f, -0.08568054f, 0.00482504f, 
    0.12354776f, -0.08381461f, -0.07607711f, 0.04731916f, -0.29373482f, 0.19560301f, 0.12816198f, 0.07159635f, 
    0.06001266f, -0.03152898f, -0.05102356f, -0.04734391f, 0.08819802f, 0.00512422f, 0.06122337f, -0.03167732f, 
    -0.00902173f, 0.00756168f, 0.15337825f, -0.05890609f, -0.00650843f, -0.02603601f, -0.01902990f, -0.04783661f, 
    0.05048576f, -0.00377304f, -0.06908231f, 0.11708761f, -0.25150329f, -0.24880812f, 0.14443335f, 0.04741583f, 
    -0.08858587f, 0.08619817f, 0.00774097f, 0.03012581f, 0.13149621f, -0.04664163f, -0.14448336f, 0.04037595f, 
    -0.32222086f, 0.08288113f, -0.05052084f, 0.03044489f, -0.00823875f, -0.03462087f, -0.00196696f, 0.05311356f, 
    -0.09238826f, 0.00246572f, 0.04418365f, 0.05779612f, -0.01304284f, -0.10250390f, 0.07826888f, 0.12183971f, 
    -0.17444372f, 0.08482362f, 0.08320977f, -0.07841633f, -0.00255788f, -0.15048000f, 0.03415581f, -0.00188263f, 
    -0.01341378f, 0.02893097f, -0.19166125f, -0.15490182f, -0.04214643f, -0.01564420f, 0.09503778f, -0.04505986f, 
    -0.16335852f, -0.07509026f, -0.04179626f, -0.03680833f, 0.06073280f, -0.09863169f, 0.01125923f, 0.07726018f, 
    0.00209947f, 0.00508742f, 0.03003546f, -0.01394447f, -0.03789954f, -0.05553143f, -0.10234717f, -0.08998000f, 
    -0.68848318f, 0.07763707f, 0.04301029f, -0.00574486f, -0.01390264f, -0.10817739f, 0.06639621f, 0.02100945f, 
    -0.03355090f, 0.03601852f, 0.04613044f, 0.02724897f, -0.10178966f, -0.13388172f, 0.09992605f, -0.00891149f, 
    -0.01849428f, -0.05740150f, -0.12718220f, -0.05180544f, -0.07505293f, 0.08839277f, -0.10945554f, -0.06849074f, 
    0.02942065f, 0.05514709f, -0.06216554f, -0.09389864f, -0.04396647f, -0.00331307f, 0.02417250f, 0.09694922f, 
    -0.04448756f, -0.04364717f, -0.00536067f, 0.12105833f, 0.16125552f, 0.05319438f, 0.04548096f, -0.00775527f, 
    -0.14229462f, -0.02562245f, 0.06564230f, 0.08000901f, 0.00926889f, 0.04681024f, -0.02049790f, -0.00282848f, 
    -0.26256308f, -0.10987774f, -0.12101141f, 0.07038299f, 0.15425588f, 0.08166060f, 0.09737226f, -0.09643757f, 
    0.18377636f, 0.04515141f, -0.05288520f, 0.10551183f, -0.04611746f, 0.08099082f, -0.02339875f, -0.02836066f, 
    0.07632343f, 0.19194905f, -0.00135980f, 0.09256770f, 0.04780671f, -0.00751308f, -0.06175777f, -0.08512482f, 
    -0.04645576f, -0.02899040f, 0.00650202f, 0.15808478f, -0.06532905f, -0.05025678f, 0.04885584f, -0.04445386f, 
    -0.09172064f, -0.07036010f, -0.04720195f, 0.20986432f, -0.40026399f, 0.00670947f, -0.05352295f, -0.16393466f, 
    -0.03023555f, 0.02971782f, -0.06047948f, -0.17658055f, 0.06004266f, 0.08160734f, 0.21392414f, 0.06108155f, 
    0.20701489f, 0.02874183f, -0.01840753f, 0.10130642f, -0.03822261f, -0.00828766f, -0.07687178f, 0.23512709f, 
    -0.05367497f, -0.00409772f, -0.03858978f, -0.00179253f, -0.28843138f, -0.23565121f, -0.08314799f, 0.16533814f, 
    0.03572465f, 0.08687293f, -0.02962776f, 0.19344927f, 0.04152352f, 0.08906677f, 0.11150222f, -0.05273419f, 
    0.13290220f, 0.00260852f, 0.14522916f, 0.08502957f, -0.01971759f, -0.00197462f, 0.13462698f, 0.06107439f, 
    -0.14516574f, -0.03192175f, 0.07216257f, 0.12187926f, 0.05871340f, 0.02661886f, -0.11631924f, -0.15179153f, 
    -0.02993533f, 0.05260018f, -0.02541534f, 0.05717843f, 0.10664178f, -0.08034126f, 0.06557658f, 0.11071707f, 
    -0.29070473f, -0.27588347f, -0.11204001f, 0.21449904f, -0.08917937f, 0.01729715f, 0.02605644f, -0.03347246f, 
    -0.14164206f, 0.08046808f, 0.02405120f, 0.22025956f, -0.31749213f, 0.23595174f, 0.04090323f, 0.09691817f, 
    -0.10682612f, -0.07846176f, 0.05479777f, -0.10398091f, 0.04706363f, -0.07523289f, -0.05760355f, -0.11839107f, 
    -0.42986554f, 0.11532432f, 0.01512260f, -0.17453621f, -0.00535209f, 0.05030355f, -0.06678025f, 0.05607533f, 
    0.10903355f, 0.00827804f, -0.03322904f, 0.10566390f, 0.00968457f, 0.05466611f, 0.10254785f, 0.02100773f, 
    0.07586432f, 0.07662075f, -0.05034462f, -0.05857539f, 0.02217072f, -0.03356731f, -0.09984686f, 0.05891234f, 
    0.09692118f, -0.01624088f, 0.03912902f, 0.01971680f, -0.04546884f, -0.03771274f, 0.07730154f, 0.05821595f, 
    -0.05005661f, 0.13263726f, 0.16388324f, 0.20135836f, 0.11573014f, -0.01708953f, -0.03897297f, 0.01520918f, 
    -0.11469850f, 0.03351386f, -0.05948576f, -0.05090655f, -0.15001990f, 0.12856418f, 0.25280184f, 0.10702092f, 
    -0.39511636f, -0.18204014f, -0.35228500f, -0.01308915f, 0.06206609f, 0.09665906f, 0.01789053f, 0.13594544f, 
    -0.02274278f, 0.08408490f, 0.08849392f, -0.15537228f, 0.05933609f, 0.16807759f, -0.04917630f, -0.04130329f, 
    -0.13299789f, 0.04214337f, 0.13473508f, -0.01930031f, -0.05719661f, -0.11748832f, 0.10888156f, 0.06432271f, 
    0.12786786f, 0.01042311f, 0.10922725f, -0.21674101f, 0.11300507f, -0.01838706f, -0.03426198f, -0.11407216f, 
    -0.01567695f, 0.03330612f, 0.07700387f, -0.00358828f, -0.14358608f, 0.06316310f, 0.08106198f, 0.12835878f, 
    -0.02721955f, -0.14306124f, 0.04965809f, 0.09314548f, 0.04302659f, -0.14999804f, 0.04601646f, -0.01505270f, 
    0.21313660f, -0.01588832f, 0.10333877f, 0.05151110f, 0.20345092f, -0.09890588f, -0.11033842f, 0.03440790f, 
    -0.05318814f, -0.12327179f, -0.08411471f, -0.17000297f, -0.26956433f, -0.06667560f, -0.27415767f, -0.06078658f, 
    0.09404898f, 0.15092440f, -0.14761958f, -0.13248257f, 0.07834978f, -0.11911017f, -0.01881277f, 0.00530850f, 
    -0.02713891f, -0.16133083f, 0.03184435f, -0.19970468f, 0.00910676f, 0.08568855f, -0.01293839f, -0.01296316f, 
    -0.06980781f, 0.01813164f, 0.16581877f, 0.06099260f, -0.00013593f, -0.00872105f, -0.01721417f, 0.05576852f, 
    -0.07419479f, -0.18274046f, -0.02199943f, 0.09662440f, 0.01844377f, -0.01000880f, 0.08573675f, 0.03567595f, 
    0.06446735f, 0.04887022f, 0.03591646f, -0.10978494f, -0.08166087f, -0.06652392f, -0.02522340f, 0.04450509f, 
    -0.12091901f, -0.00600040f, 0.07897856f, -0.12572153f, 0.14997822f, -0.18011664f, -0.00156582f, -0.11536755f, 
    -0.02641460f, 0.03660133f, -0.04689861f, -0.15121198f, -0.05842660f, 0.05738258f, -0.05311896f, -0.03993787f, 
    0.09474911f, 0.14887215f, 0.10537576f, -0.19027726f, -0.08616083f, 0.04672623f, -0.15527859f, 0.10968541f, 
    0.00004070f, -0.09768909f, 0.05068540f, -0.15786235f, 0.05175189f, -0.19952941f, 0.02150929f, -0.00336565f, 
    -0.00926151f, 0.04527574f, -0.04829487f, 0.17181645f, 0.07446960f, -0.01946983f, -0.07827818f, -0.17090964f, 
    0.06761029f, -0.03079970f, 0.07536998f, -0.17785691f, 0.09154797f, -0.03092850f, -0.11534465f, 0.06967105f, 
    -0.01985629f, 0.05570285f, 0.05719459f, 0.02791410f, 0.09862132f, 0.11677466f, 0.09667201f, -0.11617062f, 
    -0.14539364f, -0.09207113f, 0.06092146f, 0.08326635f, 0.02368825f, 0.11030907f, 0.05132780f, 0.15473352f, 
    -0.24179375f, -0.19930077f, -0.13884045f, -0.00446254f, 0.10105707f, 0.03972806f, -0.05428614f, -0.13619453f, 
    -0.06527550f, -0.11554591f, 0.13820750f, -0.04079021f, 0.06972998f, -0.20514016f, -0.07049190f, 0.14552699f, 
    0.08185146f, -0.17460449f, -0.06135777f, 0.13354297f, 0.04661499f, 0.02517155f, 0.03405276f, -0.05224558f, 
    -0.04270927f, 0.01462895f, 0.13845734f, -0.03118222f, -0.05968510f, 0.07325637f, 0.06139865f, 0.02180161f, 
    0.05938629f, 0.00786641f, 0.05085243f, -0.09386205f, -0.26217422f, -0.13417979f, 0.09546735f, 0.06161546f, 
    0.06852850f, -0.19722615f, 0.12690106f, 0.06839664f, 0.23211426f, 0.02669537f, -0.03886716f, 0.01151547f, 
    -0.14890629f, -0.31303388f, -0.06551597f, 0.13007107f, 0.09773656f, 0.11978571f, -0.09799004f, -0.00315646f, 
    0.10179876f, 0.12770130f, 0.01061347f, 0.13045542f, -0.04599489f, -0.04811701f, 0.01775085f, 0.19798316f, 
    0.08423293f, 0.03873098f, -0.05550062f, 0.07188777f, -0.00541086f, -0.00319293f, 0.04762124f, 0.00718568f, 
    -0.13757445f, -0.14619751f, 0.22731629f, 0.14216246f, 0.05249747f, -0.11737289f, -0.10591811f, -0.05414993f, 
    -0.18833721f, 0.02334238f, 0.00663085f, -0.04959759f, 0.10351387f, 0.01877332f, -0.05149286f, 0.00668005f, 
    0.15184575f, -0.15358670f, 0.02322421f, -0.02720569f, -0.02285407f, -0.03822234f, 0.05082653f, -0.05576947f, 
    -0.03219829f, -0.03514054f, -0.08204138f, 0.04603169f, 0.10843372f, -0.02701470f, -0.06576441f, -0.00599380f, 
    -0.07860694f, 0.06137729f, 0.03893414f, 0.25178573f, 0.20633422f, 0.02764324f, 0.02531501f, -0.06779093f, 
    0.08591609f, -0.01988381f, -0.13329946f, 0.02540706f, 0.09794728f, -0.10651083f, -0.02480755f, 0.08830966f, 
    0.04099573f, -0.10631111f, -0.22971509f, -0.10790898f, 0.04068365f, -0.00984620f, -0.01963217f, -0.13587213f, 
    -0.01516091f, -0.11515026f, -0.22459479f, -0.01014602f, 0.00169530f, -0.11784044f, -0.08227292f, -0.02332243f, 
    0.05060734f, -0.00994792f, 0.03033726f, 0.03905794f, 0.04364269f, -0.14188017f, 0.03166222f, -0.05228031f, 
    -0.08962350f, 0.06708685f, 0.14441988f, -0.16349052f, 0.02819644f, -0.16077821f, -0.07772514f, 0.10055923f, 
    0.02979407f, 0.00366834f, -0.09629953f, 0.02031936f, 0.09613271f, -0.00852869f, -0.05909697f, 0.01611364f, 
    -0.08378153f, -0.02454581f, -0.04542486f, -0.01281643f, 0.08516216f, -0.06859891f, 0.03245394f, 0.03701189f, 
    -0.17257269f, 0.05246712f, 0.13298923f, -0.16209117f, -0.14521065f, -0.00756790f, -0.02278845f, 0.02647816f, 
    0.04654225f, -0.03151478f, 0.01287524f, -0.10514696f, 0.00132987f, 0.21312578f, 0.03754422f, 0.31299800f, 
    -0.13305855f, -0.10380276f, -0.05604995f, 0.10166851f, -0.00079738f, -0.04572254f, 0.05378373f, -0.12281134f, 
    -0.05483581f, 0.04688739f, -0.36462453f, -0.02963615f, 0.11546692f, 0.20234233f, -0.01974792f, -0.11726325f, 
    -0.13018876f, -0.12889010f, -0.09788201f, -0.10458721f, -0.18333636f, -0.19050814f, 0.35823050f, 0.19536565f, 
    0.01245888f, -0.00912682f, -0.12327759f, -0.04303628f, 0.10161985f, 0.05223503f, -0.01742444f, -0.05945874f, 
    -0.44622231f, -0.09722252f, 0.06870235f, -0.21523520f, 0.14601246f, -0.03649846f, 0.07777186f, -0.21575086f, 
    -0.10862941f, 0.02259790f, 0.13267048f, -0.04167680f, -0.06915206f, 0.05536946f, -0.02631580f, 0.26794332f, 
    -0.15883006f, -0.18021773f, 0.13818379f, 0.00920606f, 0.15423121f, 0.01512568f, 0.01056880f, 0.01461451f, 
    -0.09921426f, 0.00579452f, 0.25202817f, -0.16089188f, 0.08871170f, 0.08741354f, -0.03817363f, 0.01144279f, 
    -0.03474756f, 0.00912751f, -0.14660574f, -0.09837201f, 0.12437267f, -0.00722001f, -0.04365292f, -0.01761223f, 
    0.01519512f, -0.07677608f, -0.02082649f, 0.08135202f, -0.06846307f, -0.03542859f, -0.07973338f, -0.13319017f, 
    -0.53538114f, 0.20614387f, 0.08677901f, 0.13645048f, -0.07897645f, 0.04034257f, -0.03858336f, 0.05960321f, 
    -0.02111712f, 0.03075371f, -0.06900100f, -0.13176017f, 0.01737710f, 0.19119258f, 0.20169671f, 0.11836655f, 
    -0.13918124f, 0.08448735f, 0.10757539f, 0.05037649f, -0.11227216f, 0.02448557f, 0.02034844f, -0.18182243f, 
    0.09674650f, -0.01918672f, 0.00971187f, 0.16649964f, -0.08596136f, 0.09447848f, 0.09388422f, 0.00305912f, 
    0.02551761f, 0.05464679f, -0.01145622f, 0.04481074f, -0.11139888f, 0.05896361f, -0.05634719f, -0.07264296f, 
    0.00312994f, 0.09170687f, -0.09778556f, -0.06796263f, -0.06101796f, -0.01724237f, -0.06869345f, -0.03257557f, 
    0.12940243f, -0.11832731f, -0.04132866f, 0.08189627f, 0.00258820f, 0.04131283f, -0.07345536f, 0.14036146f, 
    0.05686336f, -0.00162510f, 0.09773838f, 0.00104230f, 0.08476894f, 0.11911698f, 0.10089622f, 0.14527105f, 
    0.01333059f, -0.08239753f, -0.11990771f, 0.13125269f, 0.03434643f, 0.08477364f, -0.02242202f, -0.02321311f, 
    -0.10779816f, 0.21240236f, 0.00725773f, -0.31591707f, 0.09325580f, -0.00047978f, 0.01667053f, 0.01266294f, 
    0.02633072f, -0.02388823f, -0.07167517f, -0.03439632f, 0.34366077f, 0.02584319f, 0.05316084f, -0.16487430f, 
    0.06590816f, -0.14492376f, -0.12196259f, -0.04617486f, 0.07077431f, 0.01089142f, 0.03903487f, 0.00452588f, 
    -0.14904650f, 0.03329887f, -0.07492978f, -0.20892052f, 0.01325972f, -0.02306735f, 0.08192270f, 0.16014078f, 
    -0.02515374f, 0.05810351f, -0.03875516f, -0.33460712f, -0.05656792f, 0.04550961f, 0.02553258f, -0.14447317f, 
    -0.05502047f, -0.11006328f, 0.08575090f, 0.05039889f, 0.20545012f, 0.04709632f, 0.04311052f, 0.07979894f, 
    -0.38073432f, -0.00081308f, -0.06543798f, -0.22624348f, -0.02224540f, 0.14609344f, 0.03045746f, 0.02254356f, 
    -0.01587850f, -0.26637489f, 0.00422014f, -0.20759857f, 0.14109041f, 0.06099113f, -0.00215722f, -0.00457564f, 
    -0.11341335f, -0.18220784f, 0.11189331f, -0.00511781f, 0.04355878f, -0.09164496f, -0.00238879f, -0.00163005f, 
    -0.05358829f, 0.03030030f, 0.15978542f, -0.07296827f, 0.04896147f, -0.00412812f, 0.07856422f, -0.04586291f, 
    -0.02559706f, 0.03355036f, 0.00681621f, -0.06978773f, -0.03139326f, 0.02634869f, 0.09427585f, -0.11580846f, 
    0.03419349f, 0.09322957f, 0.12192754f, -0.08987807f, 0.02127886f, 0.01141180f, 0.10875355f, 0.16547827f, 
    -0.22377224f, 0.02118409f, -0.02386606f, -0.38385510f, -0.05241035f, -0.06716747f, 0.06293809f, -0.11329125f, 
    0.02348027f, -0.10277473f, -0.07615379f, -0.13209425f, 0.02902982f, -0.06214541f, -0.12065262f, 0.16723597f, 
    -0.07317559f, 0.00117599f, -0.13958152f, 0.07074349f, -0.01209981f, 0.03671956f, -0.08596581f, 0.08510409f, 
    0.05579707f, 0.00661301f, -0.09540688f, -0.05869579f, -0.07957043f, 0.12011150f, 0.04993177f, -0.05727720f, 
    0.00973552f, 0.01822128f, -0.05719973f, -0.08569833f, 0.18812835f, -0.07995215f, -0.08833867f, 0.08689582f, 
    -0.09094699f, 0.14041139f, 0.08289530f, 0.03991865f, -0.13429169f, 0.00979894f, -0.09632584f, -0.03834389f, 
    -0.11589693f, 0.01455581f, 0.16330555f, 0.02626358f, 0.14430474f, -0.01130841f, 0.01273258f, 0.06381924f, 
    -0.02465245f, 0.04540826f, 0.08123620f, -0.11660749f, -0.20578246f, -0.15830624f, 0.02299331f, -0.11212953f, 
    0.04808131f, -0.04896008f, -0.00929877f, -0.11187010f, -0.10543802f, 0.02713421f, -0.00166070f, 0.00535473f, 
    0.16644970f, 0.07776641f, 0.01049382f, -0.29111814f, -0.01399447f, 0.00017035f, -0.04547158f, -0.05789278f, 
    -0.03502097f, -0.07694115f, -0.09243777f, -0.12855539f, 0.02438442f, -0.05966169f, 0.08718856f, -0.03048450f, 
    0.06196130f, -0.09204158f, 0.08529245f, -0.09547678f, -0.04420619f, 0.01928912f, -0.06698164f, -0.15209429f, 
    0.17816460f, 0.13389583f, -0.17052238f, -0.09909064f, -0.01251999f, -0.00733762f, -0.10755793f, -0.14552201f, 
    -0.11431041f, -0.10958423f, -0.02151846f, -0.06107003f, 0.18725771f, -0.58061421f, -0.13652024f, 0.14690915f, 
    0.06455170f, 0.12384924f, 0.03875585f, -0.00995436f, -0.04153410f, 0.06673677f, 0.04059896f, 0.21813875f, 
    -0.13511595f, -0.02407447f, 0.06117739f, 0.12523820f, 0.03764826f, -0.04261337f, 0.14773706f, -0.13253237f, 
    0.05886066f, -0.06978061f, 0.03102603f, -0.13618214f, 0.23575704f, 0.09543732f, 0.07297400f, -0.21361248f, 
    0.02201485f, 0.04903060f, 0.00725429f, 0.07955255f, -0.15228775f, 0.04007504f, 0.14856687f, -0.07033801f, 
    -0.06969169f, 0.18022059f, 0.07222457f, -0.27345625f, 0.00465706f, 0.03651568f, -0.04346802f, -0.05624079f, 
    0.05662636f, -0.03011261f, 0.00156464f, -0.07466464f, 0.03992447f, 0.22344778f, 0.07196248f, -0.10402308f, 
    -0.06055699f, 0.03329131f, 0.02748715f, 0.05014273f, 0.01359927f, -0.12286387f, -0.14363743f, -0.05586175f, 
    -0.05337385f, -0.18016227f, -0.00322825f, -0.16389164f, -0.01287753f, 0.07636770f, 0.08574422f, -0.25415969f, 
    -0.03793692f, -0.14632921f, 0.04720783f, 0.13480352f, -0.16015464f, 0.08572198f, 0.16230042f, -0.07055014f, 
    -0.01690247f, 0.01096869f, 0.01720979f, -0.01258257f, 0.09696145f, 0.01945844f, -0.10291937f, -0.02896679f, 
    -0.35715860f, 0.11350626f, 0.15744376f, -0.20878422f, -0.01294484f, -0.00303407f, 0.11664213f, 0.11995344f, 
    -0.06058545f, 0.08537238f, 0.02488885f, -0.03409720f, 0.07950238f, -0.01441319f, -0.12763861f, 0.24564616f, 
    -0.00451272f, 0.11633006f, -0.13021098f, 0.07535394f, -0.04381466f, 0.14484434f, -0.03157360f, 0.01013695f, 
    -0.10209311f, 0.06459004f, -0.05399137f, 0.09384644f, -0.17706342f, 0.00437728f, 0.10299329f, -0.09260028f, 
    0.10805981f, -0.00246003f, 0.05033768f, 0.09716558f, -0.09897533f, -0.23239526f, -0.21274230f, -0.36286014f, 
    -0.04813658f, -0.04176506f, 0.03041484f, -0.12633307f, 0.03701282f, 0.03966945f, 0.02178573f, 0.02375503f, 
    0.05332808f, 0.13106902f, 0.06531393f, -0.11868726f, 0.00092681f, -0.05387910f, -0.00434157f, 0.11397658f, 
    0.14928079f, -0.00453705f, -0.09482012f, 0.02434621f, 0.05667173f, -0.14882223f, -0.12226699f, 0.19026284f, 
    0.02391408f, 0.04795032f, -0.07624449f, -0.01132328f, -0.06085790f, -0.02830533f, 0.02576344f, -0.10439363f, 
    -0.02961250f, -0.27910191f, 0.20894152f, 0.06920414f, -0.07915816f, -0.01181074f, -0.00389431f, -0.07424077f, 
    -0.03012979f, 0.08244631f, -0.01434243f, 0.15712443f, -0.50221443f, 0.19295621f, 0.03005458f, 0.31536794f, 
    0.08112430f, 0.11139785f, 0.05319785f, 0.06764297f, 0.06617054f, -0.02808360f, 0.02273867f, -0.08868863f, 
    0.13915701f, 0.03562787f, 0.05330166f, -0.16099581f, 0.07622486f, -0.07949403f, 0.01753872f, 0.10307506f, 
    0.13868238f, 0.20928718f, -0.06132934f, 0.14840272f, -0.07934055f, -0.04869522f, -0.13091514f, 0.01416730f, 
    0.02282118f, -0.07166848f, 0.14474323f, -0.09281387f, 0.02318572f, -0.08662367f, -0.03449067f, -0.01641631f, 
    0.16145344f, -0.09084194f, 0.19069350f, -0.21821727f, 0.00411778f, 0.02692866f, 0.02462925f, 0.01003444f, 
    0.02668282f, -0.07236779f, 0.01248550f, -0.08569698f, 0.18871152f, -0.12059674f, -0.10025442f, -0.02635046f, 
    0.05870402f, 0.19525331f, 0.09004607f, 0.00892524f, 0.03435415f, -0.02646738f, -0.17156433f, 0.05040641f, 
    -0.07828384f, 0.03575664f, -0.13838588f, 0.19799373f, -0.12542990f, 0.02026771f, -0.03383971f, -0.03276752f, 
    -0.10250784f, 0.15830958f, -0.07682224f, 0.02314298f, -0.14454427f, -0.13046017f, -0.10737705f, 0.12150063f, 
    -0.01873009f, 0.00449327f, -0.01305514f, -0.11723249f, 0.02110195f, -0.10642681f, -0.06580031f, -0.08302539f, 
    -0.18319602f, 0.18441802f, 0.12380990f, -0.11347194f, 0.00370324f, -0.03871115f, -0.04774372f, 0.08306839f, 
    -0.07397655f, 0.03768158f, 0.04508828f, 0.12199239f, 0.14958549f, 0.10496722f, -0.19375978f, -0.06379092f, 
    -0.10862152f, 0.06620793f, -0.11286546f, 0.00975661f, 0.01748289f, 0.00900637f, 0.01101408f, -0.01891948f, 
    -0.19849516f, -0.10703412f, -0.17753376f, 0.12707403f, -0.04999579f, -0.07368843f, 0.05230287f, -0.02777145f, 
    -0.03333627f, -0.08030915f, -0.10998933f, -0.13110147f, -0.25371867f, -0.14151087f, -0.38679296f, 0.17439151f, 
    0.08554284f, -0.04771729f, -0.08295170f, 0.13766956f, -0.13242282f, -0.06502446f, -0.03808498f, -0.02327634f, 
    0.18468936f, -0.02081389f, -0.01895970f, 0.12173127f, -0.10688443f, -0.02412735f, 0.05948823f, -0.01330545f, 
    0.06714933f, -0.03662402f, -0.04679778f, -0.01190030f, -0.25258455f, 0.08846256f, -0.02750255f, 0.19075476f, 
    -0.08176799f, 0.16796912f, 0.01654508f, 0.10098353f, -0.02907441f, 0.07715738f, 0.02952369f, 0.06951406f, 
    0.06038611f, -0.07884505f, 0.03498506f, -0.00036095f, 0.04188398f, 0.03982428f, -0.01045660f, -0.12050215f, 
    -0.02475526f, -0.03192802f, -0.00024712f, -0.06492337f, -0.02705409f, 0.04982990f, 0.16269174f, 0.00998443f, 
    -0.08574989f, -0.03706291f, 0.14131434f, -0.04556126f, 0.02965708f, 0.00075463f, -0.08923227f, -0.00564199f, 
    -0.13747095f, -0.15490273f, -0.03908237f, -0.12128444f, 0.06920715f, -0.02457642f, -0.03167446f, -0.11002671f, 
    -0.01564433f, -0.03801252f, 0.18638399f, 0.11015796f, -0.02795551f, -0.08201300f, 0.13326342f, -0.19056050f, 
    0.04636401f, 0.07845623f, -0.00931920f, -0.05560862f, -0.17044023f, -0.05909077f, 0.05080181f, 0.06162957f, 
    0.03668962f, -0.06490352f, 0.18564048f, -0.08211086f, -0.14149512f, 0.02057759f, -0.04108813f, 0.03587874f, 
    -0.06910510f, -0.03517718f, 0.01442525f, -0.04567980f, -0.07262839f, -0.06628802f, 0.05892452f, -0.05743015f, 
    -0.06147237f, 0.01391343f, 0.08676866f, -0.01499884f, -0.09525830f, 0.00117712f, 0.05912226f, 0.07301071f, 
    0.05391725f, -0.00563811f, 0.16873173f, 0.04544222f, -0.06353666f, -0.05471232f, -0.12624358f, -0.00495253f, 
    0.02383757f, 0.02668543f, 0.06542794f, 0.06409162f, -0.15384078f, 0.02852099f, -0.01381722f, -0.16189520f, 
    -0.03620367f, 0.06471201f, -0.03675109f, 0.04815631f, -0.10464038f, 0.09189767f, -0.12763207f, 0.12546101f, 
    -0.28113350f, -0.13127524f, -0.06180758f, -0.20668888f, -0.04201773f, -0.02408237f, -0.05115052f, -0.06875598f, 
    -0.03090801f, 0.07265146f, 0.06598609f, 0.17051107f, 0.22440331f, -0.16154638f, 0.04172437f, -0.05138041f, 
    0.00939466f, 0.02629133f, 0.05661845f, -0.02059095f, 0.01493832f, 0.05983103f, -0.06017831f, -0.05807449f, 
    0.32520545f, -0.47932020f, 0.02657681f, 0.01791455f, -0.09406386f, -0.07481359f, 0.06812453f, 0.07271246f, 
    0.07269936f, 0.04646883f, -0.01613775f, 0.00168362f, -0.35871011f, 0.07107213f, -0.06149413f, 0.38846180f, 
    0.02464937f, 0.18202318f, 0.04096397f, -0.04304196f, -0.06254415f, -0.03104933f, -0.10308319f, -0.08578636f, 
    0.19572100f, 0.03355111f, -0.00945520f, -0.03326763f, -0.03044973f, -0.02786458f, -0.04019338f, 0.08538551f, 
    0.00671383f, 0.03772247f, 0.16569301f, -0.00091444f, 0.21909240f, -0.07947531f, -0.02154633f, -0.13641740f, 
    0.06135666f, 0.12350380f, 0.06520497f, -0.04734544f, -0.05183831f, -0.03558239f, 0.11806076f, 0.13040330f, 
    0.47406426f, -0.34538275f, 0.12717980f, 0.01688133f, 0.17400950f, -0.07467050f, 0.04328314f, -0.04637221f, 
    -0.06477778f, 0.02467708f, 0.07845913f, -0.04399056f, 0.15985525f, -0.06659149f, 0.06593312f, 0.18651687f, 
    -0.03553350f, -0.07894665f, -0.07521684f, -0.05040265f, 0.09628992f, -0.01176599f, 0.00681882f, 0.16101712f, 
    0.08467799f, 0.04585429f, -0.03460101f, -0.30011889f, -0.00847707f, -0.13485964f, 0.04264235f, 0.08493693f, 
    -0.00757887f, 0.02922872f, -0.04835336f, -0.02081471f, 0.15233286f, 0.00394135f, 0.10146910f, -0.03748801f, 
    -0.02813041f, 0.03116357f, -0.00085257f, 0.03445373f, -0.02651957f, -0.01875949f, 0.08989031f, 0.12568802f, 
    -0.19607839f, 0.11575247f, 0.02525192f, 0.08954199f, 0.05375313f, 0.05870285f, 0.01257076f, 0.04210612f, 
    -0.07738793f, -0.05134655f, -0.02767124f, 0.01399453f, 0.06345665f, 0.07944085f, 0.07652792f, -0.29263127f, 
    0.02760803f, -0.02554974f, 0.06067150f, 0.02099879f, -0.01333388f, -0.04770224f, 0.04091030f, -0.01261743f, 
    0.31430027f, -0.31087127f, 0.11684752f, -0.03429408f, -0.06349767f, 0.07136337f, 0.09978008f, 0.06165488f, 
    0.09716315f, 0.06269545f, 0.02558873f, 0.02406397f, -0.18810737f, -0.00885458f, -0.03705341f, 0.22647388f, 
    0.00051236f, -0.01925260f, 0.08132420f, 0.04382697f, 0.03963835f, -0.04015611f, 0.03504348f, 0.11942278f, 
    0.19723518f, -0.07362209f, 0.04087236f, -0.06329031f, 0.05563971f, 0.06458305f, -0.09905668f, -0.06708843f, 
    -0.07765726f, 0.02924180f, 0.01552053f, 0.15278867f, -0.15186264f, -0.05064293f, 0.03151972f, -0.15376817f, 
    0.03604404f, 0.07888580f, -0.10268698f, -0.07539891f, -0.08522856f, 0.00668951f, -0.02872244f, -0.09841724f, 
    -0.09166832f, -0.27365589f, -0.03664712f, -0.14348017f, 0.04166417f, 0.05569465f, 0.04452010f, -0.00662931f, 
    0.05927440f, 0.01561773f, 0.08019029f, 0.26885745f, -0.16256602f, -0.05666259f, 0.27383453f, -0.04707944f, 
    0.03623120f, -0.01969972f, -0.08000402f, 0.03483697f, -0.02114203f, 0.04792766f, 0.05833471f, -0.01631015f, 
    0.10945582f, -0.01669448f, 0.08525380f, -0.17058191f, -0.15493779f, 0.06365117f, 0.07729936f, 0.12060060f, 
    0.08791220f, -0.00628016f, -0.03221354f, 0.02749561f, -0.23555392f, 0.12654953f, 0.05565772f, -0.18720485f, 
    -0.04062650f, -0.05831096f, -0.00826656f, 0.06171297f, 0.13025047f, 0.01092805f, -0.13745193f, -0.18438260f, 
    0.02614543f, 0.11346079f, 0.09256975f, 0.17784980f, -0.00058520f, 0.11402131f, 0.02508850f, -0.02436382f, 
    0.00179839f, 0.01021219f, 0.00623150f, -0.03442565f, 0.09314653f, 0.13112180f, 0.06929204f, 0.20896007f, 
    0.06492102f, 0.05390421f, -0.03203768f, 0.05738968f, -0.05446636f, 0.01655824f, 0.04240219f, -0.06738672f, 
    -0.07349033f, -0.04153960f, 0.01180790f, 0.02969018f, -0.03996466f, -0.06737924f, -0.03427678f, -0.00978509f, 
    -0.04679921f, 0.04659108f, 0.02856357f, -0.03279203f, 0.00426092f, 0.08480393f, 0.01359099f, 0.09251340f, 
    0.10856099f, -0.02006086f, 0.02518210f, -0.01988431f, 0.02778913f, -0.03508825f, 0.04414729f, -0.02385826f, 
    0.22668432f, -0.00714214f, -0.03022152f, 0.04869684f, 0.10132800f, -0.02906641f, -0.00720443f, -0.04669707f, 
    -0.05781016f, -0.00373393f, -0.02701337f, -0.06733514f, 0.20597000f, 0.01592264f, 0.05539468f, 0.21746901f, 
    0.07685269f, -0.04800942f, 0.03250930f, -0.04270131f, 0.04016299f, -0.01185403f, -0.03087058f, -0.08083040f, 
    0.17380756f, -0.38738233f, -0.02452241f, 0.03506706f, -0.08774301f, -0.01763639f, -0.01923771f, 0.00220104f, 
    -0.00352479f, 0.00061276f, -0.07352483f, 0.02519725f, 0.19285780f, -0.01274992f, 0.16772297f, -0.06684352f, 
    0.07110736f, -0.01311334f, -0.00125240f, -0.05009104f, -0.07426491f, -0.09480402f, -0.02247563f, -0.05342188f, 
    0.11490896f, 0.11948983f, 0.15172110f, 0.22090770f, 0.07530270f, -0.02981812f, 0.04637927f, 0.04311326f, 
    -0.04490482f, -0.02767942f, -0.08846010f, -0.04225383f, 0.08038825f, 0.02025805f, 0.06212138f, 0.10564402f, 
    0.13998228f, 0.02411607f, 0.03322181f, 0.07609954f, -0.00820211f, 0.04508311f, 0.04407435f, 0.01948808f, 
    0.04735593f, -0.17033954f, 0.11778872f, -0.15268618f, 0.01498824f, 0.03500758f, -0.02472321f, 0.04961287f, 
    -0.03219328f, 0.04977656f, 0.07450864f, -0.03043305f, 0.23874076f, -0.17120653f, -0.09374822f, 0.00665191f, 
    -0.15349470f, 0.00955148f, 0.05489659f, -0.04386023f, -0.01431666f, -0.04227519f, -0.00916983f, -0.01198586f, 
    -0.33832544f, 0.05977138f, -0.13582118f, -0.10691329f, 0.03340739f, 0.01285600f, -0.01253672f, -0.04745417f, 
    -0.06516720f, -0.00326772f, 0.01541710f, -0.02599741f, 0.07233080f, -0.13478591f, -0.03367549f, 0.15603405f, 
    -0.06792899f, -0.05258996f, 0.00827770f, 0.00843747f, -0.05200418f, 0.02748562f, -0.06512677f, -0.01935726f, 
    0.17252035f, 0.14590967f, 0.23873302f, 0.09977573f, 0.11118343f, 0.05660497f, 0.08014128f, 0.00610360f, 
    0.00292460f, 0.02035150f, 0.00092236f, -0.04485000f, -0.15092172f, 0.19222943f, -0.10465962f, 0.03117059f, 
    -0.08847884f, 0.00709321f, -0.07732647f, -0.00653918f, -0.09001161f, 0.03746315f, 0.07602867f, -0.04609431f, 
    0.09553766f, 0.08919367f, 0.02022507f, -0.06672546f, -0.02249090f, 0.02239580f, -0.04194121f, -0.02718355f, 
    -0.06897065f, 0.05553934f, 0.04684492f, -0.04643441f, -0.17253998f, 0.02191923f, -0.02521580f, 0.07351673f, 
    -0.11445627f, -0.05349652f, -0.01028910f, -0.02544352f, -0.06134286f, 0.03850533f, -0.01160623f, 0.04114335f, 
    0.21323377f, 0.19170409f, -0.07145109f, 0.27286223f, 0.06477732f, 0.00378390f, -0.08038558f, 0.12232110f, 
    -0.05634920f, 0.00034175f, -0.02495819f, -0.00436268f, 0.01681968f, 0.16526322f, 0.13103274f, 0.14279769f, 
    0.06506617f, 0.06419476f, 0.06473584f, -0.02010180f, -0.07258990f, 0.05408743f, -0.02421613f, -0.05154343f, 
    0.11667845f, 0.05128610f, 0.16386458f, 0.00725454f, 0.04204626f, 0.01963116f, 0.04741560f, 0.06672766f, 
    -0.03004405f, -0.05022441f, -0.06850082f, -0.08408852f, -0.06538882f, 0.08434492f, 0.01850351f, 0.05117550f, 
    -0.06940911f, -0.05941729f, -0.12947974f, -0.02815182f, 0.09478985f, 0.03177878f, -0.02127612f, -0.08744166f, 
    -0.01157091f, 0.08209189f, -0.05002193f, -0.07933756f, 0.00807641f, -0.02135718f, -0.02355569f, -0.03470279f, 
    0.03710779f, -0.00986929f, -0.02240715f, -0.08419234f, -0.04344177f, -0.09013832f, -0.17783867f, -0.10330757f, 
    0.05026074f, -0.01534213f, -0.13612251f, 0.00532905f, 0.05174036f, 0.00022794f, -0.05786305f, -0.08669070f, 
    0.06966591f, -0.03090221f, -0.00610757f, -0.13179445f, -0.02938603f, -0.04512258f, 0.01755895f, -0.09422053f, 
    0.05441595f, 0.02183692f, -0.02464437f, -0.05632254f, -0.00073267f, 0.13953272f, -0.00856034f, 0.16796760f, 
    0.02463377f, 0.01067204f, 0.02331805f, -0.00980447f, -0.00603585f, 0.07938557f, 0.00747295f, -0.06040869f, 
    0.28064141f, -0.02977568f, -0.02579743f, 0.02914028f, -0.12687752f, -0.02817030f, 0.02348693f, -0.06762297f, 
    0.00403435f, -0.01654853f, -0.03506819f, -0.08722249f, 0.07788183f, -0.16453882f, -0.02921833f, 0.01030134f, 
    -0.06236787f, -0.10428809f, -0.00257988f, -0.07026669f, 0.02797407f, -0.06832141f, 0.00451470f, -0.03361557f, 
    0.04343147f, 0.18362232f, -0.01512850f, 0.16996041f, 0.09945725f, -0.03254404f, 0.01294326f, 0.03282031f, 
    -0.03392284f, -0.01986679f, -0.00193556f, -0.03332287f, 0.07943031f, 0.18786299f, -0.02304345f, 0.14319231f, 
    0.03555600f, -0.05133050f, -0.09998433f, 0.03169971f, -0.03491194f, 0.00243062f, -0.02816881f, -0.13685752f, 
    -0.12638511f, -0.06030751f, -0.11613929f, -0.11224151f, 0.03372173f, -0.01133840f, 0.01994073f, -0.04278677f, 
    -0.01185483f, -0.07654446f, -0.02042858f, 0.01548944f, 0.04049098f, 0.05938638f, 0.01047949f, 0.17669827f, 
    0.05441639f, -0.04090332f, -0.02397566f, 0.01881528f, -0.10907681f, 0.01220576f, -0.01250119f, -0.10828462f, 
    0.16183631f, 0.01716068f, 0.16087410f, 0.22473010f, 0.11397797f, -0.03653997f, -0.07406400f, -0.05831275f, 
    -0.07222960f, -0.00521484f, -0.06362814f, -0.04124232f, -0.11201435f, -0.08802323f, -0.14790696f, 0.11509222f, 
    0.04098779f, -0.05620302f, -0.01224103f, -0.05898859f, -0.04733177f, -0.00728117f, 0.01989018f, -0.07559822f, 
    -0.04223135f, 0.03110973f, 0.03721652f, 0.18565424f, 0.05510394f, -0.06355140f, 0.04078126f, 0.01977001f, 
    -0.08240225f, -0.02883203f, -0.08259721f, -0.03758215f, -0.27048495f, -0.06849063f, -0.04247866f, -0.09755217f, 
    -0.06513901f, -0.00878046f, -0.05588697f, -0.06658781f, 0.00667352f, -0.01380294f, -0.04627763f, -0.06996971f, 
    -0.07091103f, 0.03976764f, -0.06887484f, 0.02478204f, -0.00322648f, 0.04240675f, 0.01418956f, -0.03338405f, 
    0.01108841f, -0.12132666f, 0.00337716f, -0.04540724f, 0.14796098f, 0.01322346f, -0.05295757f, -0.00132764f, 
    0.01468306f, -0.05482163f, -0.00461950f, -0.11483350f, -0.07773109f, 0.02204021f, 0.02354403f, 0.00055887f, 
    0.06310765f, 0.09333194f, 0.07404386f, 0.06981435f, -0.04587859f, 0.03825168f, 0.01695992f, -0.07615293f, 
    0.05514869f, 0.05033740f, -0.01802966f, -0.01057218f, 0.13048461f, 0.00576822f, 0.05109502f, -0.00556182f, 
    0.04054525f, 0.01850742f, -0.01736485f, -0.08492544f, -0.04391743f, -0.00449811f, 0.04240585f, -0.05484726f, 
    -0.15048195f, 0.11792694f, -0.07768072f, -0.06293277f, -0.07443317f, 0.03093636f, -0.00853125f, -0.02770418f, 
    -0.07128588f, -0.04343700f, -0.09258491f, -0.08819702f, -0.09400871f, -0.03933894f, -0.12494504f, -0.09273463f, 
    -0.13932565f, -0.03210746f, -0.04218512f, -0.04971278f, -0.09471609f, 0.01923880f, -0.09198102f, -0.06828983f, 
    -0.12596267f, -0.11096114f, -0.06763065f, -0.05564667f, -0.03441238f, 0.01265908f, -0.06891923f, -0.07983987f, 
    -0.08750686f, 0.02017950f, -0.04717645f, -0.05809266f, 0.02835987f, -0.13577698f, 0.03119889f, 0.04716177f, 
    0.04997854f, -0.11407195f, -0.03887872f, -0.00465343f, -0.07992808f, 0.02040253f, 0.03097464f, -0.03001286f, 
    0.12531281f, 0.08374319f, 0.17330666f, 0.16153798f, 0.05986800f, 0.00251681f, 0.03788264f, -0.06445326f, 
    -0.03948376f, 0.02391048f, -0.00871558f, 0.00682246f, -0.19658899f, -0.08685796f, 0.07671202f, -0.18538757f, 
    0.09088412f, -0.01283348f, 0.01166270f, -0.06840917f, -0.05535300f, -0.04103177f, -0.06103295f, -0.02486528f, 
    -0.10171663f, -0.05474519f, 0.10894243f, -0.10437533f, -0.01832881f, -0.00242278f, -0.02695908f, -0.01014476f, 
    0.01440067f, -0.01793413f, 0.03345102f, -0.05701616f, -0.10769969f, -0.14992823f, -0.10692883f, -0.04627160f, 
    -0.01602133f, -0.10693179f, -0.12885685f, -0.02330470f, 0.03323678f, 0.04039448f, -0.04817476f, -0.05160677f, 
    0.00943983f, 0.02831756f, -0.09770705f, -0.00046021f, 0.09737471f, 0.02172881f, 0.02974616f, -0.12432607f, 
    -0.02935532f, 0.02682958f, 0.00944034f, -0.04366166f, 0.18625535f, -0.25886294f, 0.07002948f, -0.01898928f, 
    -0.02055062f, -0.03893266f, 0.01806404f, 0.05865338f, -0.04529517f, -0.07199150f, -0.08901216f, 0.05086567f, 
    0.15373854f, -0.10963260f, 0.02398080f, -0.02301805f, -0.02307171f, -0.01335847f, -0.01321689f, 0.09557704f, 
    0.06093684f, -0.01406587f, -0.12810396f, 0.00218713f, 0.08675665f, -0.08686112f, 0.04858975f, 0.09643225f, 
    -0.13190253f, -0.04402957f, 0.01108706f, -0.00491600f, -0.02412724f, 0.05621716f, 0.00970681f, -0.05397158f, 
    -0.23018795f, -0.06950333f, -0.18433446f, -0.15120351f, -0.00683702f, -0.07152417f, -0.02889766f, -0.05019845f, 
    -0.01862254f, 0.09576377f, -0.04356085f, 0.00561170f, -0.06279027f, -0.07674713f, -0.03885591f, -0.09652636f, 
    -0.09237977f, -0.00447206f, 0.03137474f, -0.02823560f, -0.03130517f, 0.00713065f, 0.00653965f, -0.05173542f, 
    -0.05604073f, 0.02728728f, -0.24577510f, -0.15544531f, -0.02803458f, -0.06207559f, -0.06019510f, -0.06786752f, 
    -0.08000372f, 0.01040107f, -0.00377916f, -0.02532582f, 0.02065269f, -0.33007506f, -0.07334043f, 0.05451077f, 
    -0.01938009f, 0.03801452f, -0.00253945f, -0.01983352f, -0.03665122f, 0.00546326f, 0.04157605f, -0.00102633f, 
    0.26972371f, -0.09973589f, -0.00491469f, -0.11899912f, -0.03559858f, 0.01666637f, -0.03207845f, -0.01357524f, 
    0.04810067f, 0.04388288f, 0.02832190f, -0.12964059f, 0.10078610f, -0.03047156f, -0.05926402f, -0.03759080f, 
    -0.05188071f, -0.09550980f, 0.02597024f, -0.17433219f, 0.01660368f, -0.04175718f, -0.01462965f, 0.04987920f, 
    -0.13032384f, -0.02394313f, 0.14592148f, -0.07760523f, -0.08017359f, 0.00544971f, -0.02921859f, -0.04175669f, 
    -0.03923276f, -0.00143156f, -0.05635852f, -0.04102043f, -0.23948972f, 0.09075140f, -0.14556874f, -0.09875136f, 
    -0.08616892f, 0.00656622f, -0.06746601f, -0.04838981f, -0.07228296f, 0.01532410f, -0.04510761f, -0.12732489f, 
    0.10461288f, 0.10997080f, 0.20324452f, 0.04879021f, 0.00252964f, -0.02377856f, -0.00218038f, 0.02088501f, 
    -0.09286943f, 0.03904670f, -0.06522398f, -0.07518779f, 0.16858126f, 0.03057205f, -0.01662196f, -0.20868678f, 
    -0.08940729f, 0.03740450f, 0.00928891f, -0.08400182f, -0.07893546f, -0.07355517f, 0.01126489f, 0.01764229f, 
    -0.22582127f, 0.12184691f, -0.08489577f, -0.06466123f, -0.02781601f, -0.04582115f, 0.00606991f, -0.09675973f, 
    -0.07808570f, -0.03482019f, -0.08283602f, -0.12219200f, -0.37652305f, 0.15797700f, -0.03035934f, -0.03840397f, 
    0.00128906f, 0.02137278f, 0.01388295f, -0.07188327f, 0.00736367f, 0.07275694f, -0.01706078f, -0.01653809f, 
    -0.18985224f, -0.09163067f, 0.20820160f, -0.00592395f, 0.00902979f, 0.07112458f, 0.02882519f, -0.16601817f, 
    -0.09467451f, -0.01641950f, -0.01095639f, 0.11938662f, -0.11598984f, -0.06954410f, -0.22809534f, -0.25766578f, 
    -0.00311271f, -0.21639653f, -0.04009385f, -0.10432789f, 0.04304117f, -0.00758520f, 0.00988448f, -0.01477381f, 
    -0.14373896f, -0.14168596f, -0.11502618f, -0.21539159f, -0.05093465f, 0.09218089f, 0.02317963f, -0.06310534f, 
    0.04832315f, 0.04538361f, -0.00874593f, -0.01210214f, 0.04237695f, -0.02966726f, 0.06750783f, 0.05788071f, 
    -0.02212109f, -0.18562967f, -0.01783557f, 0.12942295f, 0.05052384f, -0.01268532f, -0.01181228f, -0.02767673f, 
    0.07362155f, -0.16184953f, -0.04418036f, -0.09952305f, 0.05109045f, -0.12997594f, -0.04615227f, 0.08812538f, 
    0.11043994f, -0.02138186f, -0.03255285f, 0.02619592f, -0.06896973f, -0.05654589f, 0.03086750f, -0.25875658f, 
    0.03751691f, -0.06230064f, 0.07087360f, 0.06772618f, 0.07495605f, 0.06075950f, 0.09639386f, -0.01207205f, 
    -0.07584756f, -0.23491286f, -0.14005947f, -0.10675675f, -0.01949268f, -0.03184887f, 0.02544085f, -0.03819968f, 
    0.05177166f, 0.08897488f, 0.02379891f, 0.06778168f, 0.05542906f, -0.13839188f, 0.00357699f, -0.00105815f, 
    0.04203892f, -0.02813791f, -0.05914329f, -0.10635149f, 0.03130731f, -0.05799218f, 0.01628106f, 0.14317301f, 
    -0.08508635f, 0.10495566f, 0.09857149f, -0.16205296f, 0.03253961f, -0.02364708f, 0.04119211f, 0.03746739f, 
    -0.00626709f, -0.00335793f, 0.06944353f, 0.11680102f, 0.04988229f, -0.12267129f, 0.14375344f, -0.05322212f, 
    -0.06938665f, -0.01673068f, 0.02705656f, -0.11706595f, -0.02449278f, -0.16346839f, 0.04541078f, -0.07827669f, 
    -0.19369544f, -0.01485552f, 0.04183561f, -0.07831718f, -0.05049497f, -0.00629684f, 0.02366899f, -0.02222695f, 
    0.03068557f, 0.03675885f, -0.06955624f, 0.10463065f, 0.05422718f, -0.10155500f, -0.01327532f, 0.17268299f, 
    0.07910259f, -0.03055201f, 0.01647230f, -0.01257153f, 0.07286975f, 0.09298011f, -0.07913649f, 0.09811317f, 
    0.02070434f, -0.22428927f, 0.06005032f, 0.09986569f, 0.12371689f, 0.07245424f, 0.00742596f, -0.01913735f, 
    0.08151454f, 0.10214581f, 0.06156484f, -0.07562484f, -0.09512314f, -0.21229935f, -0.16546625f, -0.09374991f, 
    0.00052183f, -0.02423551f, 0.00340370f, -0.08657514f, -0.06046105f, 0.08817127f, 0.18438230f, -0.04563362f, 
    -0.01745446f, -0.06229298f, 0.12856495f, -0.03837708f, 0.04102063f, 0.03723431f, 0.01687223f, -0.01178472f, 
    0.02917997f, -0.06925241f, 0.03440577f, -0.05331621f, 0.00929360f, -0.27472508f, 0.00362087f, 0.05674137f, 
    0.11049202f, 0.00378897f, -0.05883456f, -0.06071935f, 0.01834517f, 0.09781897f, 0.11275733f, -0.05296777f, 
    0.09159163f, -0.06861607f, 0.03482001f, 0.04910790f, 0.00683171f, -0.04598773f, -0.09289547f, -0.06146287f, 
    -0.03147369f, 0.04840253f, 0.05537502f, 0.09290195f, 0.18200520f, 0.14890255f, -0.14294587f, -0.04937910f, 
    -0.00562945f, -0.11134188f, 0.05159328f, -0.00084025f, 0.05558906f, -0.09226581f, 0.02928096f, 0.03617460f, 
    -0.17959309f, 0.20264794f, -0.13627535f, -0.35395518f, -0.02855163f, -0.03174968f, -0.01291753f, 0.06177634f, 
    0.00340075f, -0.07858074f, 0.08475125f, -0.21321441f, -0.16979556f, 0.01684611f, 0.20960654f, 0.04884183f, 
    -0.13523290f, 0.14157115f, -0.03476438f, -0.03827740f, 0.02176780f, -0.01035423f, -0.04706264f, -0.01157494f, 
    -0.20974763f, -0.24345657f, -0.03825181f, -0.16970238f, 0.04390050f, -0.08385471f, 0.10990981f, -0.00375461f, 
    -0.00753932f, -0.07417973f, 0.05181152f, 0.08638760f, -0.03767672f, 0.20333600f, -0.13978346f, -0.10140509f, 
    -0.04261088f, -0.00485320f, -0.12926707f, -0.00945470f, 0.07944980f, 0.07445607f, 0.06000562f, 0.10410482f, 
    0.23653562f, -0.11578706f, 0.06219807f, 0.08699048f, 0.06310459f, 0.02869932f, -0.04391271f, -0.06342191f, 
    -0.04029680f, -0.02399717f, 0.04969713f, -0.06104692f, 0.06521272f, 0.07988586f, -0.21409455f, -0.00938203f, 
    0.03111841f, 0.03052796f, -0.15651347f, -0.08645201f, -0.04200820f, -0.03367703f, -0.18241632f, 0.07242064f, 
    0.24287713f, 0.00378562f, -0.08916266f, 0.08393005f, 0.09113651f, -0.10766234f, -0.07215304f, -0.06520627f, 
    -0.04849749f, -0.09526756f, 0.00833597f, -0.03936533f, -0.19468808f, 0.25235516f, -0.00164351f, -0.09490451f, 
    -0.09975940f, 0.09803025f, -0.04351856f, 0.12909415f, 0.13329181f, -0.03176066f, -0.00484768f, 0.01602134f, 
    0.03766631f, -0.25006250f, 0.08691812f, -0.10043167f, 0.02628395f, -0.18474264f, -0.03681736f, -0.02695045f, 
    0.05025497f, 0.08063706f, 0.00365802f, -0.06267950f, -0.04352761f, -0.07046045f, -0.08730066f, -0.19752736f, 
    0.00848658f, 0.01772094f, 0.04873553f, -0.02320961f, -0.00580825f, 0.06130425f, -0.02252012f, 0.02593996f, 
    0.10206987f, 0.13063920f, -0.14392750f, 0.02357337f, -0.04663322f, -0.01178846f, 0.01114349f, -0.00070336f, 
    -0.06983203f, -0.00450204f, 0.01079412f, 0.08644825f, -0.08158861f, 0.15919843f, -0.08226472f, -0.38079891f, 
    0.11555542f, -0.04683156f, 0.02074705f, 0.12589282f, 0.04195269f, 0.06950976f, 0.06899703f, -0.10833571f, 
    0.07178532f, -0.14554141f, -0.03995839f, 0.15202314f, 0.11045207f, 0.04447976f, -0.01221046f, -0.08191493f, 
    -0.08803735f, 0.02713956f, -0.00180872f, -0.03472756f, -0.14220577f, -0.03109870f, -0.19188727f, -0.27940717f, 
    -0.03064068f, -0.11072499f, 0.08102318f, -0.08866493f, -0.12222517f, 0.06083458f, -0.06165355f, 0.08097186f, 
    -0.05820074f, 0.11446338f, -0.11254466f, -0.13072950f, -0.06928975f, -0.07119977f, -0.05781212f, -0.12767604f, 
    0.02260684f, 0.03294615f, 0.04091202f, -0.03399862f, 0.08082955f, 0.18909484f, -0.25614247f, -0.22804523f, 
    0.07933261f, -0.12565862f, 0.00688866f, 0.03482501f, 0.06256296f, -0.02728204f, -0.07379493f, 0.10651743f, 
    0.15335967f, -0.10941841f, -0.23962407f, -0.13016273f, 0.10731485f, 0.02852521f, -0.11227615f, 0.00373400f, 
    0.05434311f, 0.02240198f, -0.03012486f, -0.02030591f, 0.12851374f, 0.01107945f, -0.10160372f, 0.02653341f, 
    0.13271290f, 0.06779128f, -0.02145782f, -0.04578872f, 0.00504238f, 0.01046179f, -0.08986045f, 0.03779221f, 
    0.00235173f, -0.14941847f, 0.03089713f, -0.14427914f, -0.20394816f, -0.09015348f, -0.03028606f, -0.02326321f, 
    0.08155883f, -0.00223451f, 0.02653447f, 0.11809140f, 0.13384494f, -0.08696812f, 0.06244723f, -0.02478548f, 
    -0.01221550f, -0.12292989f, -0.10096409f, 0.07885478f, -0.06043465f, -0.05654794f, 0.07725416f, -0.06643389f, 
    0.01169760f, 0.21791066f, -0.04578699f, 0.03778483f, -0.04409412f, -0.03482586f, 0.09336899f, 0.03731820f, 
    0.04236309f, 0.00250326f, -0.13605742f, 0.01638630f, -0.27638105f, -0.03815215f, 0.14563367f, -0.07201733f, 
    -0.04394666f, -0.11633831f, -0.04057499f, 0.10615359f, -0.11171013f, 0.10222668f, -0.00369201f, 0.02524368f, 
    0.16873306f, 0.05948580f, 0.08918528f, 0.15651464f, -0.02443712f, -0.07837385f, -0.01475748f, -0.03906098f, 
    -0.01759174f, -0.00998706f, 0.03734775f, -0.04432543f, 0.06515516f, 0.04769415f, 0.06103376f, 0.08882110f, 
    -0.07150871f, -0.03361939f, -0.04188393f, -0.00001132f, 0.06744715f, -0.02842361f, 0.00667001f, -0.03160732f, 
    0.02344627f, -0.05918941f, -0.03875063f, -0.00262952f, 0.03072429f, -0.01552698f, 0.02741855f, -0.04814994f, 
    0.06736632f, -0.01909643f, 0.02890590f, 0.09743589f, -0.20075542f, 0.01955791f, -0.07490152f, -0.14376409f, 
    0.06338312f, 0.04713317f, -0.04484243f, 0.11389489f, 0.11956344f, -0.02793988f, 0.13454545f, -0.13339402f, 
    -0.25779617f, 0.00720985f, 0.16340154f, 0.04826243f, -0.12113608f, 0.03811902f, -0.11685516f, -0.00018066f, 
    0.00516820f, -0.00399240f, -0.12595873f, -0.14663070f, 0.05215215f, -0.17569502f, 0.03259197f, 0.03344737f, 
    -0.02951698f, -0.03044492f, -0.09076554f, -0.05267315f, 0.03395747f, 0.01753982f, 0.01053428f, -0.01336796f, 
    -0.07744536f, -0.13617927f, 0.20818375f, 0.13511017f, -0.14535150f, -0.14562526f, -0.04561961f, 0.13962454f, 
    0.00719953f, -0.02424167f, -0.05435805f, -0.04591302f, 0.27222466f, 0.27303472f, -0.22906122f, -0.14605410f, 
    -0.00163098f, 0.07711608f, -0.02660681f, -0.10453794f, 0.06487383f, 0.04364061f, -0.06058142f, 0.04033697f, 
    -0.09377136f, -0.23754844f, 0.09847812f, -0.03818490f, 0.02770534f, -0.13182305f, -0.05429440f, 0.09287121f, 
    0.03588550f, 0.05879411f, -0.00392461f, -0.12919536f, -0.03578065f, -0.06534000f, -0.33585045f, -0.23612189f, 
    0.02404048f, 0.01996646f, -0.01039950f, 0.08358823f, 0.08921818f, -0.04123586f, 0.06783675f, -0.00201198f, 
    0.02051722f, 0.00680976f, -0.00989676f, -0.08413672f, 0.01417524f, -0.01129706f, -0.00974516f, 0.04269652f, 
    0.14441131f, 0.00270483f, -0.04247665f, 0.05652022f, -0.06321859f, 0.03020154f, -0.17722079f, 0.06914921f, 
    0.05869146f, -0.05041640f, -0.04046630f, -0.19605646f, -0.02930839f, 0.00169701f, 0.04952227f, -0.09695012f, 
    -0.09782247f, 0.02733668f, -0.01483606f, 0.22605163f, 0.10272313f, 0.02498201f, -0.01501847f, -0.05758886f, 
    0.03917406f, -0.05473672f, -0.01335967f, 0.05502861f, -0.14173082f, 0.17404644f, -0.08511215f, -0.08069979f, 
    -0.01478790f, -0.01108901f, -0.02162135f, 0.03142045f, 0.04112023f, -0.01883915f, 0.00898975f, -0.12008486f, 
    -0.06297211f, 0.12997566f, -0.08078355f, 0.00252274f, 0.11140610f, 0.07237980f, -0.04289124f, 0.00217737f, 
    0.05167082f, 0.03535499f, 0.00175922f, -0.03136437f, -0.04130896f, -0.14051776f, -0.06885537f, 0.01878891f, 
    0.09106086f, -0.12059312f, -0.06015388f, 0.05658682f, 0.08490670f, 0.04248956f, 0.05096835f, -0.10123595f, 
    -0.05061237f, -0.08770449f, 0.12524852f, 0.00563722f, 0.00044198f, -0.13493682f, 0.04229147f, -0.10052471f, 
    0.02533384f, -0.04671110f, -0.08946753f, 0.01560213f, 0.20973635f, 0.11224554f, -0.00792032f, 0.07619643f, 
    -0.02825811f, 0.00556655f, -0.10849478f, -0.01523697f, -0.06983484f, 0.03892666f, 0.09749285f, -0.24999033f, 
    -0.09388313f, 0.03190568f, -0.00738389f, 0.11862696f, -0.05402280f, 0.04528160f, -0.05153121f, -0.04777562f, 
    0.01101165f, 0.03633849f, -0.08873906f, -0.05155386f, -0.08910812f, 0.06978171f, 0.10134432f, 0.03386300f, 
    -0.04256451f, -0.00871271f, -0.00593653f, -0.00265136f, 0.00860601f, -0.04286700f, 0.05142934f, 0.08591600f, 
    0.00838626f, 0.01377236f, -0.06059111f, 0.08033112f, -0.05191169f, 0.03273663f, -0.03743334f, -0.12118448f, 
    -0.00414331f, -0.02698761f, -0.10018407f, -0.06549559f, 0.18785207f, -0.02588179f, -0.01456835f, -0.01124988f, 
    -0.02196352f, -0.12012890f, -0.01017628f, 0.00673620f, -0.04176037f, 0.01358068f, 0.09403423f, 0.04635559f, 
    0.07831783f, 0.01702084f, 0.02318347f, 0.15321817f, 0.02915046f, -0.03196787f, -0.02576334f, -0.11317761f, 
    0.02344648f, 0.00903589f, 0.02998972f, -0.00782887f, 0.04898108f, -0.14971915f, 0.11019800f, 0.16656242f, 
    0.10665045f, 0.04534787f, -0.04880013f, -0.06249949f, -0.00831474f, -0.06664361f, 0.09983122f, 0.09616572f, 
    0.42322576f, -0.14190499f, -0.10105425f, 0.01732030f, -0.11658198f, -0.08299623f, 0.04212177f, 0.01700786f, 
    -0.02174550f, 0.05313098f, 0.06795200f, -0.07070912f, -0.22103068f, -0.04659258f, -0.09082084f, 0.04628778f, 
    0.05634688f, 0.09788039f, 0.00706371f, -0.16865857f, -0.04017708f, -0.08339636f, 0.02611373f, 0.05611509f, 
    0.02233470f, -0.00618862f, -0.09762653f, -0.01843395f, 0.00412196f, -0.04964008f, -0.04498413f, 0.08113088f, 
    0.03606944f, -0.02062217f, 0.03130375f, -0.03319580f, -0.27412599f, -0.23228876f, 0.07699161f, 0.02486768f, 
    0.02911871f, -0.06416208f, 0.08014021f, 0.00473174f, 0.06287553f, -0.06967898f, -0.00374362f, 0.01732893f, 
    0.27717257f, 0.20367430f, 0.03853020f, -0.07231901f, -0.03280681f, 0.05106087f, 0.09818710f, -0.16996710f, 
    0.00239036f, -0.01000986f, 0.05928320f, -0.00927822f, 0.23350486f, 0.04373109f, -0.29406172f, 0.06029198f, 
    0.11055145f, -0.12906234f, 0.02312821f, -0.12344205f, -0.12496339f, -0.11797170f, -0.05307408f, 0.10047989f, 
    -0.12648474f, -0.00655228f, 0.05851481f, -0.24210893f, 0.03744342f, 0.00893845f, -0.03595612f, 0.05878684f, 
    0.09031628f, -0.02194414f, -0.00507258f, -0.03499285f, 0.05150001f, -0.10270661f, 0.11549246f, 0.18683387f, 
    0.03967362f, 0.04580638f, -0.09999951f, -0.09107090f, 0.00317643f, 0.03035944f, 0.09480490f, -0.10104953f, 
    -0.29889190f, -0.23468594f, 0.04984816f, 0.27910334f, 0.00135306f, -0.04373572f, -0.14569324f, 0.05916091f, 
    0.04536332f, 0.04389021f, 0.01876889f, 0.06045345f, 0.35743302f, -0.04019396f, 0.10850453f, -0.03338920f, 
    0.15151803f, -0.08053113f, -0.02742871f, -0.07971243f, -0.01049125f, 0.09594338f, 0.10179417f, 0.02064744f, 
    0.00576136f, -0.22173014f, -0.07792410f, 0.13252561f, -0.04561878f, -0.00767710f, 0.01987698f, 0.07878441f, 
    -0.07082640f, -0.05138757f, -0.03233070f, 0.00892077f, -0.10373873f, 0.04099011f, -0.09728564f, -0.14891541f, 
    -0.02093492f, -0.03014869f, -0.03549838f, 0.02082022f, 0.00835171f, -0.04081889f, 0.01320105f, 0.06550627f, 
    -0.10429131f, 0.15780766f, -0.09109173f, -0.45146769f, -0.03154540f, 0.03244118f, -0.02838570f, 0.01837028f, 
    -0.04404044f, -0.16310744f, -0.15581666f, -0.18625456f, -0.02909034f, -0.07796507f, -0.07580449f, -0.15379322f, 
    -0.07674035f, -0.13942483f, 0.09957381f, 0.01306323f, 0.01478351f, -0.00259173f, 0.00709536f, 0.04844542f, 
    0.15875730f, -0.34675562f, -0.06770171f, -0.05570908f, 0.00553727f, -0.02910997f, -0.06326967f, -0.01424283f, 
    -0.14741428f, 0.09811970f, -0.09393000f, -0.03200448f, -0.14569689f, 0.10408180f, 0.09056777f, -0.27081379f, 
    -0.05160805f, -0.01447295f, -0.03121527f, -0.04929667f, -0.05100598f, -0.14864123f, -0.10671325f, -0.12928635f, 
    -0.10449307f, -0.02307908f, -0.11144741f, 0.14516445f, 0.03121564f, 0.05544919f, -0.06626608f, 0.01477596f, 
    0.00068479f, -0.03823478f, 0.06299298f, -0.02425884f, -0.10322989f, 0.07997221f, 0.24565302f, -0.12014409f, 
    0.05047645f, -0.02459221f, 0.00404452f, -0.17536724f, -0.01544248f, -0.09383339f, 0.08667802f, -0.04169651f, 
    -0.33515358f, 0.00422672f, 0.09604108f, -0.07053166f, 0.01536680f, 0.02433166f, -0.06134500f, 0.08668188f, 
    0.02360271f, 0.10505395f, -0.08096566f, 0.14133418f, -0.15894186f, -0.38270584f, -0.03772318f, -0.04408037f, 
    0.07036267f, -0.00954071f, 0.03930856f, 0.08258700f, -0.05181092f, 0.03119220f, -0.09198942f, 0.02390240f, 
    -0.15486772f, 0.09405632f, -0.11581979f, 0.18689822f, 0.02318238f, 0.04377304f, 0.10319063f, 0.02136039f, 
    -0.02056871f, 0.13370939f, -0.08524691f, 0.03235791f, -0.32700649f, 0.09053757f, 0.10455257f, 0.02610865f, 
    0.11299272f, 0.03908458f, -0.02072382f, -0.02586586f, -0.03025065f, -0.05816152f, -0.12336233f, -0.00267105f, 
    0.04029518f, 0.08473463f, -0.09345897f, -0.10054944f, 0.03969342f, 0.03715827f, 0.13032107f, -0.15436944f, 
    0.03504341f, 0.04279592f, -0.08181451f, 0.17317571f, 0.23424734f, 0.04346535f, 0.22941457f, 0.13504773f, 
    -0.03092158f, 0.02570819f, -0.08119550f, 0.06908976f, 0.13145822f, 0.03760456f, -0.00069731f, 0.04954507f, 
    -0.14444746f, -0.09871151f, -0.07594924f, 0.13707194f, 0.01724636f, -0.04224415f, 0.03368661f, -0.08492540f, 
    0.00685792f, -0.04344488f, -0.00615383f, 0.05086854f, -0.22718477f, 0.25566059f, 0.11070160f, 0.11304009f, 
    -0.02594480f, 0.03489346f, -0.10221117f, -0.06446770f, -0.09310518f, -0.00954584f, 0.03543633f, 0.04140004f, 
    0.19362023f, 0.16868602f, -0.11350206f, -0.02473100f, -0.01354840f, -0.04913646f, 0.11603960f, 0.00108552f, 
    0.09731462f, -0.07741253f, -0.07536115f, -0.12430166f, -0.12172485f, 0.15135852f, -0.03653024f, -0.02210453f, 
    -0.00463040f, 0.00876498f, 0.02309994f, -0.05638205f, 0.10812422f, -0.07461558f, 0.08741012f, -0.17863449f, 
    -0.34405935f, -0.26828042f, 0.24057922f, -0.10965099f, 0.00679637f, 0.05309622f, -0.01096808f, 0.07293817f, 
    0.03427103f, -0.08524395f, -0.04726708f, 0.02429390f, 0.03329502f, -0.00783843f, 0.14994901f, -0.10478521f, 
    0.04136365f, 0.04933355f, -0.11691296f, -0.02302779f, -0.06112239f, -0.04923466f, -0.15213124f, 0.00168354f, 
    -0.08721728f, -0.18231466f, 0.15440567f, -0.01987515f, 0.02517866f, 0.07030606f, -0.02660215f, -0.12090762f, 
    -0.01235274f, -0.00782233f, -0.12487628f, 0.00802209f, 0.02264035f, 0.04238830f, 0.07366060f, 0.09860691f, 
    0.04622521f, 0.05266571f, -0.03698168f, 0.08770066f, 0.08215559f, -0.10852528f, 0.04391281f, 0.02554178f, 
    0.28762475f, -0.48791042f, -0.07023745f, 0.05723278f, -0.05017097f, 0.03996249f, 0.03753546f, 0.05116842f, 
    -0.01241891f, -0.01227739f, -0.02328596f, -0.05894267f, 0.22828731f, 0.09708758f, 0.20887981f, 0.03060157f, 
    -0.05923184f, -0.03673307f, 0.01500286f, -0.13302673f, -0.14806625f, -0.02691485f, 0.04109873f, 0.03265854f, 
    -0.27196735f, -0.21073607f, 0.19420929f, -0.13690676f, -0.06330097f, 0.00742548f, -0.07352003f, 0.04015234f, 
    -0.02813693f, -0.03939321f, 0.06757563f, 0.09563893f, -0.00510487f, 0.18512382f, 0.15740141f, -0.05200541f, 
    0.02875804f, -0.02288450f, 0.07897390f, -0.02223357f, 0.07489549f, 0.00061743f, 0.00060235f, -0.01285645f, 
    0.05083046f, 0.18845174f, -0.22696280f, -0.18406948f, 0.11687940f, -0.11813565f, 0.21128456f, -0.08174824f, 
    -0.01663230f, -0.02644245f, 0.03171184f, -0.03339296f, 0.07592840f, 0.04362501f, 0.02706201f, 0.05927992f, 
    0.03008186f, 0.04687190f, 0.06573724f, 0.05582807f, -0.09215011f, 0.09591672f, 0.06825546f, 0.05677893f, 
    -0.24760011f, 0.15486176f, 0.02345256f, 0.11213137f, 0.01472716f, 0.06405979f, -0.04854910f, 0.12718914f, 
    -0.00805175f, -0.01882668f, 0.01941762f, 0.05180814f, 0.28194946f, -0.08088626f, -0.09307417f, 0.23975241f, 
    -0.08566381f, -0.09427237f, 0.01624659f, 0.03636559f, 0.03294379f, 0.06539248f, -0.01328011f, -0.07913978f, 
    -0.28899422f, 0.16087164f, -0.16097897f, -0.16249265f, 0.05418271f, 0.13356668f, 0.08532835f, -0.02078096f, 
    -0.01364969f, -0.08519584f, 0.03063446f, 0.00933006f, 0.37125525f, 0.14246449f, -0.05474326f, 0.04389118f, 
    0.05831994f, 0.02448703f, 0.05608580f, -0.05417905f, -0.06871002f, -0.05676981f, 0.01938664f, 0.03531145f, 
    0.07725187f, 0.21104181f, -0.34006181f, 0.05840622f, -0.03310645f, 0.06296856f, 0.08466610f, -0.15246154f, 
    -0.00146184f, -0.01541652f, 0.11559436f, -0.08921514f, -0.04377849f, -0.39348784f, 0.03659528f, -0.16299038f, 
    -0.10781644f, 0.03356883f, -0.02149980f, -0.01749925f, 0.01098005f, 0.05753792f, 0.01163915f, 0.02624693f, 
    -0.06850322f, -0.06172324f, -0.07052990f, -0.01947390f, -0.01666226f, -0.03304473f, -0.01152545f, -0.00207150f, 
    -0.03608479f, -0.03616443f, 0.05517142f, -0.04092471f, -0.15110260f, -0.12603576f, -0.01141629f, 0.08128254f, 
    -0.03539710f, -0.03410780f, 0.09519596f, -0.01933506f, -0.11260048f, -0.12087408f, 0.09619559f, -0.04239944f, 
    0.08995351f, 0.09406337f, -0.12267341f, 0.12865302f, 0.06673191f, -0.05710908f, -0.13231865f, 0.04328844f, 
    -0.01876611f, 0.06876626f, -0.06761087f, 0.15781462f, 0.53718793f, -0.01880150f, 0.18536115f, -0.08748864f, 
    -0.00088602f, 0.01406788f, 0.05152983f, 0.07697723f, 0.02594546f, 0.02223002f, -0.03517847f, 0.07817756f, 
    -0.12041130f, 0.03477614f, 0.04468585f, -0.08002712f, 0.00934246f, -0.02073652f, 0.04764529f, 0.04284185f, 
    0.05320676f, -0.01801699f, -0.02998764f, 0.11511363f, -0.16178454f, -0.24436876f, 0.16848251f, -0.13226604f, 
    -0.13248351f, -0.02913286f, 0.06094995f, -0.01876895f, 0.05963917f, -0.05623408f, 0.05738250f, 0.03437859f, 
    0.44510153f, 0.00109093f, -0.27761292f, -0.11748195f, 0.00658507f, -0.06507725f, 0.03293305f, 0.01574579f, 
    -0.06957269f, -0.01646595f, -0.02791695f, 0.20297851f, -0.04849688f, -0.08166201f, -0.16178951f, -0.00139900f, 
    0.04908461f, 0.01923532f, -0.06225059f, 0.05966133f, -0.02869108f, 0.07088000f, 0.09668987f, 0.05740667f, 
    -0.16632359f, 0.12690622f, -0.08555049f, -0.37616888f, 0.10886852f, -0.02061689f, -0.14313552f, -0.01438779f, 
    -0.11195249f, -0.02019445f, -0.05472520f, -0.05506185f, 0.02043877f, 0.08019057f, -0.16104452f, 0.18905205f, 
    0.04213950f, 0.07647905f, -0.06629060f, -0.02779801f, -0.09391767f, -0.11921217f, 0.05126827f, 0.06428681f, 
    0.24732208f, 0.01341692f, -0.00620644f, -0.06481613f, -0.10447865f, 0.06829843f, 0.08215148f, -0.02431761f, 
    -0.03323444f, -0.00315437f, -0.09522885f, -0.03164374f, -0.02658210f, 0.13144043f, 0.13335910f, -0.09178559f, 
    -0.09852833f, 0.00707947f, -0.00812751f, 0.02099477f, -0.06089863f, -0.03888964f, -0.01576436f, -0.05151422f, 
    0.15598004f, 0.00891571f, -0.14845432f, -0.04183837f, 0.01712416f, 0.03659081f, -0.04853089f, -0.00842396f, 
    -0.02465662f, -0.02764146f, 0.05888143f, 0.01691315f, 0.00659630f, -0.06071354f, 0.04021250f, 0.05666138f, 
    -0.02338675f, 0.16594727f, 0.05320277f, -0.00236071f, -0.03578425f, 0.10334902f, 0.00423530f, 0.07632226f, 
    -0.18907444f, -0.02103404f, 0.05378135f, 0.09907541f, 0.10612623f, 0.07864895f, -0.00631039f, 0.05557079f, 
    0.15445009f, -0.00569020f, 0.07459091f, 0.05583442f, -0.41871703f, 0.42181155f, -0.00616643f, 0.03724585f, 
    0.11710121f, -0.00127788f, -0.03730219f, 0.08289343f, -0.05206598f, -0.06882533f, -0.02214991f, 0.06889640f, 
    0.16111447f, -0.34153163f, -0.10771219f, 0.07401551f, 0.03357400f, -0.01272115f, -0.10083789f, -0.08218417f, 
    0.01895246f, 0.13977662f, -0.01904283f, -0.05129014f, -0.09483609f, 0.06948996f, -0.12192136f, 0.09459117f, 
    0.09185807f, 0.14029276f, 0.19841227f, 0.04560968f, 0.08144453f, -0.01580546f, -0.04435915f, 0.03426773f, 
    -0.33861801f, 0.28461450f, -0.21902210f, -0.17672536f, 0.11753152f, 0.00945972f, -0.00603859f, -0.03319470f, 
    0.00234041f, 0.06973054f, 0.07467190f, -0.01122250f, -0.19076647f, 0.27072898f, -0.17181151f, -0.20373900f, 
    0.10376118f, -0.09281428f, -0.02594142f, -0.05202201f, -0.10916801f, -0.02999399f, -0.03773842f, -0.12747547f, 
    -0.01933878f, 0.04754151f, 0.11590301f, -0.10966743f, -0.01713998f, 0.05475072f, 0.02389919f, -0.01759237f, 
    -0.00118579f, -0.01803831f, 0.01968568f, 0.12309359f, -0.10632899f, -0.00809423f, 0.06962337f, -0.09203059f, 
    -0.09464415f, -0.09072238f, -0.00882980f, -0.06946600f, 0.02078961f, -0.16167219f, -0.08303864f, -0.14928019f, 
    0.30391359f, 0.15430516f, 0.03307128f, -0.10166343f, 0.02931946f, 0.06076225f, 0.14304453f, 0.04724647f, 
    0.07687065f, -0.00469546f, 0.06635229f, 0.06169758f, 0.14982049f, 0.07063928f, -0.05995721f, 0.07629140f, 
    -0.11021065f, -0.11849879f, 0.04989013f, -0.02324015f, -0.00774590f, -0.00121312f, -0.00435089f, -0.02725761f, 
    -0.16373242f, 0.14127219f, -0.00943852f, 0.22917540f, 0.09229266f, 0.07786668f, 0.01756539f, 0.02890300f, 
    -0.10296007f, 0.03817813f, 0.00875182f, -0.01102806f, 0.07985769f, -0.00261420f, -0.18966666f, 0.03968037f, 
    0.03903485f, 0.11881885f, -0.00167872f, -0.03496405f, -0.02604310f, 0.10417900f, 0.14077167f, -0.08228201f, 
    0.17199756f, 0.11497154f, 0.17713496f, -0.08865761f, -0.01896411f, 0.04436922f, 0.02034611f, 0.14625323f, 
    0.03065521f, 0.20743451f, 0.11868168f, 0.03375464f, -0.13372760f, 0.02761144f, -0.03926153f, 0.00210352f, 
    0.01629692f, 0.08228513f, 0.03986318f, -0.03657525f, -0.04697485f, 0.03850525f, 0.06075849f, 0.12161542f, 
    0.16434273f, 0.03869461f, -0.01951523f, -0.09600536f, 0.02239080f, 0.03435133f, 0.05583289f, 0.02080958f, 
    0.03982433f, 0.05888225f, 0.08620289f, 0.05695815f, 0.12512362f, 0.16005582f, -0.02775555f, 0.09461096f, 
    -0.22588383f, -0.05717836f, -0.03006538f, -0.02146636f, 0.12584946f, -0.03462107f, 0.00877378f, -0.08001138f, 
    0.10558073f, -0.11012193f, -0.01115531f, 0.14178613f, 0.01811374f, 0.10453201f, -0.05793434f, 0.12287919f, 
    -0.02491795f, 0.08800367f, 0.05751227f, 0.08034719f, -0.30748272f, -0.09071124f, -0.26191169f, -0.10182363f, 
    -0.00230096f, -0.03589794f, -0.01971927f, 0.03063370f, -0.02987128f, -0.01276045f, -0.10013986f, 0.11582818f, 
    -0.30819473f, -0.26985344f, -0.09027612f, -0.38770330f, 0.09220931f, -0.03692523f, -0.02164061f, 0.09658580f, 
    -0.01755202f, 0.12056056f, 0.14369848f, 0.00671611f, -0.02531945f, -0.00212607f, 0.11578928f, -0.09934108f, 
    0.00986527f, 0.02214024f, -0.05732163f, 0.00308774f, -0.05052651f, 0.13683705f, 0.04221980f, -0.02010561f, 
    0.21096435f, 0.03022660f, -0.09661261f, -0.00218508f, -0.08370225f, 0.01669852f, -0.02165615f, -0.05524191f, 
    0.09282356f, 0.11772491f, -0.08612461f, 0.04489965f, -0.29137298f, -0.22024484f, 0.17611171f, -0.15630211f, 
    0.16406296f, -0.05325408f, 0.01413078f, -0.10925082f, 0.03522078f, 0.12825252f, 0.04716491f, 0.08197142f, 
    -0.33116326f, -0.37985095f, -0.12686428f, -0.08851600f, 0.00240083f, 0.03843101f, -0.02804512f, -0.02723555f, 
    0.04530377f, -0.01646984f, 0.08593824f, 0.10666284f, -0.22079408f, -0.01528039f, 0.05317032f, 0.00643277f, 
    0.09448961f, -0.02217291f, 0.01514510f, 0.02451452f, 0.05974495f, 0.05560002f, 0.08856416f, 0.00300988f, 
    -0.15483585f, -0.07199301f, -0.03078296f, 0.03414996f, 0.03486923f, 0.03028557f, -0.01415548f, -0.10921980f, 
    0.07171541f, 0.02139154f, -0.08831798f, -0.15184300f, 0.16752143f, 0.07856013f, 0.01837733f, -0.02631561f, 
    -0.12594545f, -0.00819331f, -0.09018305f, -0.01967051f, -0.00848801f, -0.07733073f, -0.00573844f, -0.03339110f, 
    0.03694881f, 0.09261619f, 0.04113800f, -0.01085935f, -0.02696020f, -0.11574310f, -0.03830289f, -0.06757566f, 
    -0.00825888f, -0.19418688f, 0.01746311f, 0.02579566f, 0.01641972f, 0.01160636f, -0.04542289f, -0.04821404f, 
    0.07413120f, 0.02310009f, -0.00315422f, -0.02857168f, 0.02288332f, -0.01045294f, 0.01654518f, 0.04201085f, 
    -0.00343211f, -0.05320235f, -0.08161977f, -0.06949605f, -0.10231436f, -0.01456790f, -0.00616902f, 0.04323608f, 
    0.09221311f, -0.11333957f, -0.06301697f, -0.07530479f, -0.50933331f, -0.20908545f, 0.09019606f, 0.13390628f, 
    0.03389076f, 0.02930500f, 0.04837360f, -0.15818532f, 0.03165497f, -0.05828005f, -0.22681980f, 0.06458296f, 
    -0.25766715f, -0.12649582f, -0.14321356f, -0.18193573f, 0.00317494f, 0.03248069f, -0.10908625f, -0.04145054f, 
    0.03060034f, -0.04098634f, -0.14660798f, -0.04652273f, -0.20862503f, -0.17269011f, 0.12548013f, 0.04905893f, 
    -0.00314349f, 0.01773646f, -0.12917382f, -0.00645235f, 0.14868926f, 0.00001095f, 0.13510804f, -0.01530330f, 
    -0.26998171f, 0.05774344f, -0.04165841f, 0.05682958f, -0.03094918f, -0.08353627f, -0.10627858f, -0.11488632f, 
    -0.11530585f, 0.05346970f, 0.05571812f, 0.09798162f, 0.25581509f, 0.24060877f, -0.03340335f, -0.02957068f, 
    -0.03740909f, 0.04676986f, 0.09628643f, 0.02712120f, 0.03303135f, -0.04413311f, 0.09451938f, 0.09969817f, 
    -0.10107744f, 0.05996195f, -0.21222444f, 0.06799693f, -0.11147789f, 0.02958423f, 0.02517046f, -0.03928629f, 
    -0.05068929f, -0.05870908f, 0.01923194f, -0.05908826f, 0.00068523f, -0.12438082f, 0.03934574f, -0.01726334f, 
    0.00282525f, -0.00138933f, -0.02417597f, -0.01618891f, 0.06159953f, 0.07169469f, -0.07520051f, -0.08461342f, 
    -0.38848695f, -0.19345744f, -0.17235024f, -0.11056496f, 0.02338264f, 0.03574657f, -0.04702449f, -0.04916338f, 
    0.14307730f, 0.08643644f, -0.15804584f, 0.08825580f, 0.11356530f, 0.02527379f, 0.09369960f, 0.07009856f, 
    0.08858474f, 0.01641772f, 0.04129605f, -0.10314643f, 0.05388577f, 0.06237647f, -0.01857023f, 0.17339286f, 
    0.06486037f, -0.02268968f, 0.16324440f, -0.17756943f, -0.12024405f, 0.10514941f, -0.09895472f, -0.05855913f, 
    -0.12278131f, 0.01737585f, 0.07502324f, -0.00323715f, -0.31411797f, 0.16334164f, 0.09920930f, 0.03246808f, 
    0.08863369f, 0.06106443f, -0.07784490f, 0.06742679f, 0.06311417f, 0.02955358f, -0.06641167f, 0.06019654f, 
    -0.36053881f, -0.06762055f, -0.10625289f, 0.00993583f, 0.15396334f, -0.00686880f, -0.00267318f, -0.06998757f, 
    0.03846054f, 0.02503676f, -0.06269598f, -0.16165906f, -0.37233487f, -0.35999662f, -0.04065253f, 0.07046272f, 
    0.16443874f, -0.06607014f, 0.03448189f, -0.17944191f, 0.02342558f, -0.06017580f, -0.01800459f, 0.11224905f, 
    0.09512147f, 0.20629272f, -0.09407952f, -0.07105014f, 0.10311153f, 0.04028890f, -0.00790503f, 0.05199179f, 
    0.05059597f, 0.06464165f, 0.11860297f, 0.05454348f, -0.03333749f, -0.05344919f, -0.00778627f, -0.03090408f, 
    -0.02977835f, -0.00611841f, -0.08178637f, -0.09564313f, -0.03569456f, -0.12730756f, 0.05592758f, -0.04671453f, 
    0.16777377f, -0.13405347f, -0.00794072f, -0.17769830f, -0.09239531f, 0.00495625f, 0.12750225f, -0.08054966f, 
    0.04326617f, -0.14342347f, -0.15929820f, -0.13370799f, 0.00906628f, 0.02191037f, 0.08934705f, -0.13328372f, 
    0.03088473f, -0.07093840f, 0.06058900f, 0.06272384f, -0.05827353f, 0.08922379f, 0.10782632f, 0.01882265f, 
    -0.37128657f, -0.35687667f, -0.13612513f, -0.01460405f, 0.03024200f, 0.00843058f, 0.00019993f, -0.01259468f, 
    0.07185459f, 0.03223866f, 0.09235795f, -0.00200518f, -0.15179588f, -0.24523376f, -0.02711643f, 0.11563158f, 
    -0.02559468f, 0.00073277f, 0.05686139f, -0.02133056f, 0.07200982f, 0.02547948f, -0.03178740f, 0.02678229f, 
    -0.06409488f, -0.17861934f, 0.09319280f, 0.06257983f, -0.00644173f, -0.04067422f, 0.04448308f, 0.03113427f, 
    0.05988422f, 0.05396540f, -0.02490202f, 0.02075073f, 0.17281926f, 0.22169064f, -0.06594711f, 0.12570857f, 
    0.12324986f, 0.06336625f, 0.01549103f, 0.07818387f, 0.02338264f, 0.04525476f, -0.01190835f, 0.02836172f, 
    0.17047036f, 0.06710451f, 0.02284034f, -0.09833104f, -0.08564205f, -0.00067303f, -0.03627918f, 0.02166132f, 
    0.01023210f, -0.07920711f, -0.05535914f, -0.07434043f, -0.25020257f, 0.15384318f, -0.11845888f, -0.06059656f, 
    0.05601572f, 0.08141422f, -0.08869451f, 0.09278297f, 0.07965190f, 0.12671050f, -0.06662261f, 0.04577012f, 
    0.32323748f, 0.19689819f, -0.00738655f, 0.02210763f, 0.02533176f, -0.15922475f, -0.05447944f, 0.02736718f, 
    -0.03109744f, -0.09608974f, -0.06928102f, -0.09738915f, -0.46390158f, -0.15061769f, 0.12713431f, 0.18210413f, 
    0.16697758f, -0.09198945f, 0.06110044f, -0.06958194f, 0.02028660f, 0.12465361f, -0.01868066f, 0.11552694f, 
    -0.19315204f, -0.08092758f, 0.01466788f, 0.12157588f, 0.09400709f, -0.22944853f, -0.07165412f, -0.05925329f, 
    -0.11716142f, -0.10553640f, -0.12772675f, -0.09658282f, 0.12615772f, -0.04040493f, 0.02261597f, 0.04741674f, 
    -0.01400355f, 0.02006957f, -0.05090090f, 0.08364286f, 0.01371674f, 0.00989238f, -0.10965469f, -0.24683894f, 
    0.07677444f, -0.03164741f, 0.08357391f, 0.14473861f, -0.02334938f, -0.01036685f, -0.00464548f, -0.03542173f, 
    0.00990069f, 0.09731831f, -0.03243872f, -0.08209887f, -0.01552046f, 0.14325055f, -0.08144324f, -0.04405625f, 
    -0.05930395f, 0.02793471f, -0.02674857f, 0.01546518f, 0.06577417f, 0.06402340f, 0.06734622f, -0.03121176f, 
    -0.26147926f, 0.01072157f, -0.12240894f, -0.14940661f, 0.02880257f, 0.07390717f, 0.01801550f, 0.01431682f, 
    0.00922370f, -0.02537204f, 0.09119396f, 0.14928441f, 0.08976719f, -0.12414119f, -0.03193050f, 0.00134427f, 
    0.00411470f, 0.01980507f, 0.05480098f, 0.07803837f, -0.00238369f, 0.02132160f, -0.02423990f, -0.06807678f, 
    -0.46367589f, -0.13083224f, 0.11670563f, 0.00928358f, 0.08742552f, -0.01540761f, 0.01490222f, -0.06606320f, 
    -0.00644640f, 0.02169998f, 0.05386125f, 0.09346540f, -0.16654241f, 0.14659749f, 0.10399693f, -0.10794798f, 
    0.10617173f, -0.08540354f, -0.03037435f, 0.00272915f, -0.07414800f, 0.00971945f, 0.08896819f, 0.03400569f, 
    0.04135817f, 0.02720929f, -0.17080857f, 0.03801650f, 0.04401972f, -0.09249277f, -0.08354987f, -0.02147421f, 
    -0.00352029f, -0.12015649f, -0.04482637f, -0.04210027f, 0.01552210f, -0.07743469f, -0.07009534f, -0.04489898f, 
    -0.03116002f, -0.04052667f, 0.04748968f, 0.01295178f, -0.04076079f, -0.09079939f, -0.10896602f, 0.03280885f, 
    0.27292344f, 0.05108460f, -0.10398062f, 0.12427279f, -0.00829951f, -0.06804129f, 0.03012408f, 0.02091582f, 
    0.08361319f, 0.04768266f, -0.09398517f, -0.03725123f, 0.04806344f, -0.17576252f, -0.12691937f, 0.15973747f, 
    -0.01642251f, 0.03565498f, 0.10343101f, 0.04275798f, 0.09591025f, 0.05827241f, 0.08617523f, 0.04032379f, 
    0.30076444f, 0.04063574f, -0.11560401f, 0.06499401f, -0.14352590f, -0.01549926f, 0.03074957f, 0.04417903f, 
    -0.00507576f, -0.10341968f, -0.03534611f, -0.09730768f, -0.15784970f, 0.00555203f, 0.06364170f, 0.04382359f, 
    0.07536490f, 0.07192604f, -0.00119347f, 0.08596940f, 0.09902681f, 0.03287099f, 0.08991887f, 0.13668372f, 
    -0.26290104f, -0.17072664f, -0.07074852f, -0.00424588f, 0.01067890f, -0.03121597f, 0.00455376f, -0.04498325f, 
    -0.02020252f, -0.00054280f, 0.00028568f, 0.03593367f, -0.59529829f, -0.41155210f, -0.15524618f, -0.14636695f, 
    0.00560326f, 0.04135578f, -0.00694210f, 0.03510328f, 0.04168507f, 0.13106887f, 0.10116433f, 0.09927817f, 
    -0.17134818f, 0.23353359f, -0.02955772f, -0.14320061f, -0.16459948f, -0.01830804f, -0.00754907f, -0.05997750f, 
    -0.05148332f, -0.03603088f, 0.05514025f, -0.09877297f, 0.13038838f, -0.21757571f, -0.14749479f, -0.02680954f, 
    -0.09752417f, 0.00980530f, 0.09696846f, -0.18895128f, -0.15270440f, -0.02645702f, 0.05111597f, -0.09621755f, 
    -0.07460673f, -0.03214825f, -0.08798514f, 0.19130385f, 0.06798485f, -0.07634382f, 0.03108929f, 0.04897776f, 
    -0.09540468f, 0.05018870f, -0.04123850f, -0.05103770f, 0.02483909f, 0.00960964f, -0.04354757f, 0.04732672f, 
    -0.02270748f, 0.10642509f, -0.05967236f, 0.01898216f, -0.06138987f, -0.05268412f, -0.06680206f, -0.02654613f, 
    0.08020195f, 0.04529183f, 0.11135021f, -0.03854222f, 0.00170188f, -0.00691203f, 0.00896943f, -0.00771419f, 
    0.05765590f, -0.00119173f, 0.04526661f, 0.02546716f, -0.22849506f, 0.02445620f, 0.00089570f, 0.02011971f, 
    -0.27369633f, 0.03833088f, 0.06354727f, -0.00183352f, 0.13685183f, -0.03388822f, 0.05529720f, 0.00976793f, 
    0.19800815f, -0.02023612f, -0.07801662f, -0.01977176f, 0.07240964f, -0.05456199f, -0.04617558f, 0.11178865f, 
    -0.01249021f, -0.04943940f, -0.03648291f, -0.01230179f, 0.20471342f, 0.18706578f, 0.06201427f, -0.03636353f, 
    -0.10623822f, 0.03836440f, 0.01132333f, 0.01488332f, -0.10093547f, 0.07431930f, -0.06620760f, -0.00469948f, 
    0.11434631f, -0.03816791f, 0.02242437f, 0.00902335f, -0.06862260f, 0.08429539f, -0.05044066f, -0.18818192f, 
    -0.02393877f, -0.02113731f, -0.03062874f, -0.02101151f, -0.50340223f, -0.11060015f, -0.06117820f, -0.02528405f, 
    -0.06075066f, 0.12323232f, 0.01455703f, 0.13429897f, -0.01500277f, 0.01488149f, 0.07796441f, -0.05920956f, 
    -0.13716483f, 0.05833719f, 0.10708243f, -0.05913781f, 0.01489967f, -0.09176716f, 0.04368316f, -0.11017329f, 
    -0.07007213f, -0.02371591f, 0.04641879f, -0.13287054f, 0.00595167f, -0.08089764f, -0.16778846f, -0.10206874f, 
    0.01812426f, 0.05461009f, 0.01251714f, 0.06020430f, 0.04305353f, -0.02744757f, -0.10189189f, -0.09952217f, 
    0.21142001f, 0.06090032f, -0.23316425f, 0.16580525f, 0.02852430f, -0.00396747f, -0.04077655f, -0.00432036f, 
    -0.02424658f, -0.02174272f, -0.02780043f, -0.08642426f, 0.03290117f, -0.00071026f, -0.09490397f, 0.06739113f, 
    0.13358019f, -0.01956190f, -0.00494710f, -0.06072534f, 0.05681901f, -0.08246139f, -0.07903569f, 0.02826402f, 
    -0.22234999f, 0.16518940f, -0.10536100f, 0.15722078f, -0.12155493f, 0.02815755f, 0.01884593f, 0.00339869f, 
    0.01181331f, -0.06901991f, 0.05363187f, -0.03641782f, 0.20254274f, 0.10289453f, -0.09500572f, -0.12876730f, 
    0.10149184f, -0.04762380f, -0.08989983f, 0.13345833f, 0.00261780f, -0.02437730f, -0.05848879f, 0.05969624f, 
    -0.31156763f, 0.28982925f, -0.17501923f, -0.03937426f, 0.06306005f, 0.10374637f, 0.04460097f, 0.10792421f, 
    0.07429942f, -0.03747976f, 0.02749338f, -0.05836962f, 0.32038113f, -0.16176614f, -0.14502460f, 0.09560372f, 
    0.03138912f, -0.04128517f, -0.11412667f, -0.05235367f, 0.00294058f, 0.04525974f, -0.04050769f, 0.05719146f, 
    0.13767968f, -0.14364506f, -0.23035333f, 0.19028325f, -0.08020833f, 0.03514378f, -0.14096422f, -0.22673626f, 
    -0.03021653f, 0.00469982f, -0.00469006f, 0.02816079f, 0.17303802f, 0.07406894f, -0.00305248f, -0.00226503f, 
    -0.17826548f, -0.06254564f, 0.09829666f, -0.04033875f, -0.10646664f, -0.03339440f, -0.04220891f, -0.18723406f, 
    0.01762221f, 0.08828138f, -0.14765592f, -0.13131024f, 0.02955181f, -0.04756358f, 0.06017961f, -0.10670362f, 
    0.01166344f, 0.04714453f, 0.12122785f, -0.04587089f, 0.17970046f, 0.07978484f, -0.15596139f, 0.04887311f, 
    0.07569711f, -0.00461305f, -0.04130016f, 0.00032153f, -0.03132382f, -0.03921594f, -0.04271847f, 0.00943498f, 
    -0.50727117f, -0.18600951f, -0.07546871f, -0.21956681f, 0.15927494f, 0.03286393f, -0.07916211f, 0.11712623f, 
    0.12141260f, -0.09272664f, -0.18973987f, -0.06315199f, 0.19003128f, 0.24064852f, 0.06741669f, 0.07736515f, 
    -0.01569268f, 0.04220026f, 0.02543779f, 0.00014918f, 0.06070577f, 0.03150683f, -0.01340603f, 0.02570962f, 
    0.02914373f, -0.07817844f, -0.18530059f, -0.18799831f, 0.04010070f, -0.06403366f, -0.00389960f, 0.01330328f, 
    0.01236669f, -0.02989189f, -0.10277186f, 0.06619542f, -0.15029520f, 0.18718134f, -0.07909108f, 0.09594399f, 
    0.12303655f, -0.07480903f, -0.09655403f, -0.17155947f, 0.00082663f, 0.03064324f, -0.02299966f, 0.11090090f, 
    -0.37162581f, 0.16780107f, 0.07019716f, -0.09190157f, -0.03961743f, 0.02627168f, 0.03727923f, -0.03314465f, 
    0.05487865f, -0.09386173f, -0.00177630f, -0.03007908f, 0.07632612f, 0.07667279f, -0.09364622f, 0.10791511f, 
    0.01297451f, 0.05502979f, 0.04181411f, -0.02296905f, -0.04319033f, 0.05448677f, -0.04862754f, -0.12295499f, 
    0.04544807f, -0.12173003f, -0.05361609f, 0.16633625f, -0.06095485f, 0.09920081f, -0.04050872f, 0.04801149f, 
    -0.00923802f, 0.01662003f, -0.03225356f, -0.02093328f, 0.12447314f, 0.05332763f, -0.13123126f, 0.12951067f, 
    -0.08407393f, -0.05112886f, -0.03893559f, -0.19843331f, 0.00783144f, 0.00245897f, -0.12896909f, -0.01455827f, 
    0.28337702f, 0.09524122f, -0.18703495f, -0.04661241f, 0.01432544f, -0.03714406f, -0.00194985f, -0.00015622f, 
    0.03620592f, -0.03234970f, -0.02058425f, 0.00551602f, 0.01825037f, -0.07357632f, 0.04780980f, -0.01849994f, 
    -0.11977632f, -0.06176980f, -0.06696507f, 0.05078352f, -0.05521308f, 0.00204193f, 0.04584205f, -0.16750252f, 
    -0.00412769f, 0.14267725f, -0.03788437f, 0.10562623f, -0.03554726f, -0.07597372f, -0.02408406f, -0.07765489f, 
    -0.11984756f, -0.02140980f, 0.00300590f, -0.13031241f, 0.41066134f, 0.07479201f, -0.06428526f, -0.00734687f, 
    -0.06792212f, 0.00220566f, -0.07184999f, -0.12743655f, 0.13097620f, 0.11882035f, 0.05328909f, 0.02503115f, 
    -0.02487046f, -0.01497324f, -0.03083882f, 0.27425885f, -0.01946538f, 0.05171966f, -0.02984018f, 0.03986692f, 
    0.06614149f, -0.05752164f, 0.10648923f, 0.13104375f, 0.30903131f, -0.04753997f, 0.02489605f, -0.20563079f, 
    0.05414557f, -0.01481673f, -0.06956809f, 0.02063779f, 0.03173749f, 0.09000021f, 0.07363437f, 0.04982358f, 
    0.04454600f, -0.05719691f, 0.02142504f, 0.20750396f, -0.02105050f, 0.04128863f, 0.02268567f, 0.09475833f, 
    0.00528701f, -0.13105282f, -0.19675456f, -0.14007944f, -0.13945727f, -0.09330901f, -0.00645181f, -0.16051118f, 
    -0.07504653f, 0.11617775f, -0.01723625f, 0.01878387f, -0.09402481f, -0.01869197f, -0.04360943f, -0.16096626f, 
    -0.26469079f, 0.13537467f, -0.04843577f, 0.01871281f, 0.06828839f, -0.12451091f, -0.04555645f, 0.03533537f, 
    -0.04324377f, 0.06154751f, 0.04303119f, -0.02166143f, 0.03387615f, 0.15775016f, 0.09323850f, -0.10869222f, 
    0.04409297f, 0.03004712f, -0.08616094f, 0.02706781f, 0.01883275f, -0.07177974f, -0.06115833f, -0.12048485f, 
    -0.17862833f, -0.12368699f, -0.05979194f, -0.08919290f, 0.08493873f, 0.01613933f, 0.06047446f, -0.02811252f, 
    -0.03471245f, 0.01423544f, -0.06678216f, 0.01852179f, -0.14269315f, -0.18494390f, -0.04923751f, -0.09643099f, 
    0.04169641f, -0.06712534f, -0.01586092f, 0.17291896f, -0.13938053f, -0.01009486f, 0.08336999f, -0.05087683f, 
    -0.12011272f, 0.03422518f, -0.18300356f, 0.01843661f, 0.06904747f, -0.14086528f, 0.05903521f, 0.10207378f, 
    0.00467253f, 0.00275638f, -0.08553113f, -0.02990714f, 0.10352163f, 0.01756223f, -0.17597219f, -0.07230970f, 
    0.01321365f, 0.00142337f, 0.01373587f, 0.05712159f, 0.14640795f, -0.05534286f, -0.02849565f, 0.00443159f, 
    -0.00820546f, 0.13799463f, -0.14399822f, -0.01888250f, -0.10351939f, -0.11082927f, -0.02349032f, -0.12969331f, 
    0.09826448f, 0.11765857f, 0.10411698f, 0.02020700f, -0.15142950f, 0.01090895f, 0.09577917f, -0.06887534f, 
    -0.02967019f, 0.04737935f, -0.01876456f, 0.17790934f, -0.04932028f, 0.03315885f, -0.04242910f, 0.12821157f, 
    0.02099824f, -0.03138242f, 0.10933352f, -0.01773757f, 0.03074785f, 0.02774642f, 0.05716647f, -0.08855359f, 
    -0.02196308f, 0.02488987f, 0.00473729f, 0.12159924f, 0.19908848f, -0.23762533f, -0.05544060f, -0.03582431f, 
    0.04790721f, -0.14798363f, -0.09817714f, 0.02605236f, -0.01128392f, -0.08308735f, 0.04174652f, 0.04876446f, 
    0.08796503f, -0.18837953f, 0.09681523f, -0.14553466f, -0.08694354f, -0.04828954f, 0.07525983f, -0.05106824f, 
    0.11763737f, -0.03902446f, 0.02330933f, 0.11159612f, 0.13351290f, 0.10892832f, -0.15048884f, -0.09387291f, 
    0.00920375f, -0.11917508f, -0.03834776f, 0.05644428f, -0.02505914f, 0.03748948f, -0.05288320f, 0.07818449f, 
    -0.41070521f, -0.20446937f, -0.01264869f, 0.06238934f, 0.07030702f, -0.05126576f, -0.04621613f, 0.06343307f, 
    0.04679840f, 0.02922168f, 0.05249473f, 0.06263852f, 0.07853346f, -0.04873990f, -0.10896571f, 0.26340592f, 
    -0.04859278f, -0.05237765f, 0.08627371f, 0.00648569f, -0.09786101f, 0.12389235f, 0.09490492f, 0.14177236f, 
    0.34618345f, -0.23045626f, -0.13597074f, -0.05205839f, -0.00308167f, -0.04205818f, 0.03916208f, -0.10015409f, 
    -0.03827323f, -0.00944969f, -0.05340729f, -0.04254266f, -0.12528744f, 0.03176929f, -0.14363287f, 0.03791357f, 
    0.05354374f, -0.03220433f, 0.09887212f, 0.03127127f, 0.01231202f, 0.02680166f, 0.01241820f, 0.02528018f, 
    0.26851580f, 0.11199877f, -0.07881797f, -0.37368414f, 0.04250592f, 0.00205335f, -0.03553157f, 0.02274418f, 
    0.01147737f, -0.03871846f, 0.07971101f, -0.02039546f, 0.38789359f, -0.05847898f, -0.07467512f, -0.05533795f, 
    -0.01865047f, 0.02121472f, -0.02834576f, -0.01993577f, 0.10224615f, 0.00044164f, 0.09524906f, 0.04976471f, 
    -0.24433550f, 0.07846983f, -0.08811586f, -0.08647437f, 0.06406318f, -0.02329968f, 0.00013104f, -0.00202812f, 
    0.01379920f, 0.06331705f, -0.02015150f, 0.04340542f, -0.19991194f, -0.05720929f, -0.10980371f, 0.04448989f, 
    0.01996795f, 0.03861338f, 0.07609394f, -0.03821630f, -0.06280491f, -0.06521116f, 0.03444448f, 0.05773691f, 
    0.10318551f, -0.09730900f, 0.09200519f, 0.15734240f, -0.11176220f, 0.08477966f, -0.02413488f, -0.06701504f, 
    0.06088952f, -0.00609436f, 0.09733997f, 0.07571425f, 0.24042897f, -0.05817820f, -0.08380156f, 0.11572178f, 
    0.10076211f, -0.05376531f, 0.04632013f, 0.07886957f, 0.03996865f, -0.06367034f, -0.01353259f, -0.03299145f, 
    0.10201126f, 0.00639370f, -0.12856373f, 0.19445357f, 0.08111631f, -0.00015973f, 0.10378321f, -0.03239188f, 
    -0.03610518f, -0.13223219f, 0.14239551f, 0.05830295f, -0.36982909f, 0.16845423f, 0.04915518f, 0.03299146f, 
    0.05820564f, 0.00222290f, 0.02333488f, 0.08720744f, 0.06650409f, 0.00826526f, -0.08398620f, -0.09769461f, 
    0.17695892f, -0.13948752f, -0.04977214f, -0.06009312f, 0.01880451f, -0.03972764f, 0.02177978f, -0.03556197f, 
    0.01279019f, 0.04482860f, 0.02638259f, 0.02607329f, 0.12414382f, -0.21201091f, -0.03555407f, 0.03027252f, 
    0.08889827f, 0.00004775f, -0.07782108f, 0.00768279f, 0.02485716f, -0.02384657f, -0.08234961f, -0.07877377f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03612566f, 0.02745530f, -0.03807033f, -0.01489551f, 0.01071204f, 0.04301094f, -0.00891482f, -0.03433390f, 
    0.01108291f, -0.01628182f, 0.07755254f, 0.03554656f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
