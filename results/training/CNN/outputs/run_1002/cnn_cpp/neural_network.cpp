#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.42580929f, -0.65723640f, 0.53224486f, 0.97030491f, 0.68451494f, 0.03904038f, -0.30777746f, -0.23430337f, 
    -0.29862055f, 0.00240551f, -0.07879278f, -0.43072331f, -0.07158304f, 0.24840635f, 0.09621413f, -0.32343131f, 
    -0.18427579f, 0.21522488f, -0.17720552f, 0.01664052f, -0.09660706f, -0.05986442f, 0.10634200f, 0.12388039f, 
    0.25490788f, 0.31591922f, -0.34661406f, -0.42863911f, 0.11408605f, -0.22098264f, 0.71692771f, 0.72352380f, 
    0.49086457f, 0.36057815f, 0.02524099f, 0.13515174f, 0.17405726f, 0.16655442f, -0.22537749f, -0.08517300f, 
    0.11659784f, -0.47684160f, 0.18068828f, 0.06313088f, -0.19936647f, -0.14055450f, 0.08464198f, -0.18234541f, 
    0.10804686f, 0.17156544f, 0.54648256f, 0.56514686f, 0.23046900f, -0.12724853f, 0.33688965f, -0.40292728f, 
    -0.17463434f, -0.28271085f, -0.28806508f, 0.29388323f, 0.17979187f, -0.68657100f, 0.47391015f, -0.05169063f, 
    -0.00514322f, 0.01091768f, -0.01568181f, -0.04424701f, 0.02287260f, 0.05120666f, 0.14004450f, 0.31671101f, 
    -0.33066374f, 0.36875036f, -0.19798790f, 0.11804406f, 0.56225717f, 0.15531781f, -0.38274217f, 0.17408521f, 
    -0.11272217f, 0.08896542f, 0.20296140f, -0.46697277f, -0.48747736f, 0.06428467f, 0.16505553f, -0.26498133f, 
    0.16314529f, 0.02927261f, 0.14389606f, -0.15015805f, -0.17264651f, 0.21916415f, -0.40024644f, 0.04518289f, 
    -0.03709159f, -0.02647913f, 0.38658914f, 0.49757320f, -0.22694384f, 0.76780254f, 0.45078701f, -0.86882585f, 
    -0.66774088f, -0.74379057f, 0.62316042f, -0.13778764f, 0.35823944f, 0.27050892f, -0.13435833f, 0.26112840f, 
    -0.09297656f, 0.12427063f, 0.00098217f, -0.01021819f, 0.03132950f, -0.15392417f, 0.29549262f, 0.01029602f, 
    -0.04512945f, 0.17128626f, 0.09104657f, -0.24728063f, -0.39997828f, -1.23126507f, -0.49203467f, -0.85407370f, 
    -0.93471205f, 0.25886998f, 0.37069833f, -0.07024847f, 0.48574987f, 0.41239911f, 0.40512159f, -0.13270299f, 
    -0.16634680f, -0.07669042f, -0.01847149f, 0.17525214f, 0.08751667f, 0.07471141f, -0.13543890f, 0.06000762f, 
    -0.20287198f, 0.12664397f, -0.18140139f, 0.16845956f, -0.15288654f, -0.29050556f, -0.05273144f, -0.41741511f, 
    0.28893089f, -0.69206023f, -0.67726856f, 0.60640907f, 0.51176608f, -0.16570333f, -0.27348396f, 0.65278733f, 
    0.29353756f, -0.24082951f, 0.03306361f, -0.03358797f, 0.19143541f, -0.13299902f, 0.02339144f, -0.00369683f, 
    -0.02955352f, -0.38680524f, 0.07046914f, 0.16118452f, 0.33743510f, 0.04050343f, 0.15478234f, -0.18499112f, 
    0.79143250f, -0.04532462f, -0.29499760f, -0.09249338f, 0.43692589f, 0.31349978f, -0.09793155f, 0.02022270f, 
    -0.21167165f, -0.45815727f, -0.07225641f, 0.24478863f, -0.21750550f, -0.07785194f, 0.17704506f, 0.11930487f, 
    -0.05484791f, -0.27818725f, -0.15752612f, 0.16697815f, -0.30194584f, -0.19965945f, -0.22172153f, -0.61982685f, 
    -0.62706751f, 0.05821653f, 0.36987561f, 0.57299721f, 0.32074118f, -0.71414095f, -0.24746169f, 0.40232986f, 
    0.44585046f, -0.07043708f, -0.17900535f, -0.48938617f, -0.00379723f, 0.29841286f, 0.32133165f, -0.07032719f, 
    0.08360233f, -0.04754345f, -0.08129497f, -0.23651814f, -0.37209472f, 0.28458819f, -0.17582415f, -0.09551512f, 
    -0.23527735f, 0.40610927f, 0.57303172f, 0.53058302f, 0.28565633f, 0.08252765f, -0.34808165f, 0.35568535f, 
    -0.25743899f, -0.05213972f, 0.38900253f, 0.40295285f, 0.27780977f, 0.08339522f, -0.46782091f, -0.08368049f, 
    0.25250512f, 0.13136110f, 0.06323270f, 0.04994664f, -0.11293156f, 0.01986894f, 0.30297583f, -0.21277677f, 
    -0.20575424f, 0.38961110f, -0.40367573f, -0.31696543f, -0.07393616f, -0.58579421f, -0.20618719f, 0.02601682f, 
    -0.23528945f, -0.53600872f, -0.07663864f, 0.32306603f, -0.32259235f, -0.16595255f, -0.16128491f, -0.01758469f, 
    0.22826545f, 0.17966911f, 0.28452262f, -0.05554563f, 0.17588252f, 0.22966671f, -0.30048192f, -0.42148924f, 
    -0.25532705f, -0.24101032f, -0.49507180f, -0.14835796f, -0.63119531f, -0.42822015f, -0.18688832f, 0.10117432f, 
    -0.55488420f, -0.27702186f, 0.01095873f, -0.28650251f, -0.63487613f, 0.06059506f, -0.04959613f, -0.28370965f, 
    0.44344646f, -0.41662025f, -0.02472289f, -0.06176415f, 0.02544620f, -0.10989680f, 0.11419393f, -0.02478370f, 
    0.31101209f, 0.07488804f, 0.09091333f, 0.55150199f, 0.36107543f, 0.32799637f, 0.29742125f, 0.26550752f, 
    0.28588295f, 0.02423384f, 0.18199430f, 0.02855846f, 0.03155405f, -0.02988096f, 0.46603692f, -0.25804833f, 
    -0.06289631f, -0.23269384f, 0.15656854f, -0.30350119f, 0.20013641f, 0.14430644f, 0.10154073f, -0.20365550f, 
    -0.19859934f, -0.25994423f, -0.15547240f, -0.37645811f, -0.55441934f, -0.16830595f, 0.10426454f, 0.03983534f, 
    -0.22684453f, 0.55503595f, 0.05619390f, -0.15181825f, 0.26412845f, 0.32620147f, 0.15370002f, -0.26894203f, 
    0.30770612f, -0.35624149f, 0.04017108f, 0.38626429f, -0.19969170f, -0.50774908f, -0.26210764f, -0.02388840f, 
    -0.07532796f, 0.29422581f, 0.19854878f, -0.12826589f, 0.16817547f, 0.47572610f, 1.24949372f, -1.18970692f, 
    -0.97275180f, -0.02458317f, -0.46601507f, 0.68112576f, 0.75452185f, 0.36316457f, -0.26150668f, -0.17383158f, 
    -0.19529389f, 0.19228677f, -0.03857738f, -0.37615100f, 0.27550173f, -0.08153151f, 0.06968150f, 0.19224903f, 
    -0.20919634f, 0.01219487f, 0.10001695f, -0.24712281f, -0.17619906f, 0.15465210f, 0.23837812f, -0.28787574f, 
    -0.91474330f, -0.74715638f, 0.43273959f, 0.73773903f, 0.09459992f, 0.48838678f, -0.29835406f, -1.10117102f, 
    -0.85691291f, 0.08053949f, -0.49228811f, 0.14891466f, -0.45456526f, -0.42061946f, 0.19998702f, -0.34766689f, 
    -0.10803602f, -0.06962389f, -0.03167452f, -0.03683529f, 0.00740550f, 0.01476209f, -0.12631735f, -0.21652314f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.37381724f, 0.00966752f, 0.40964571f, 0.11855757f, 0.39375892f, 0.16913019f, 0.34463811f, 0.25220457f, 
    0.35965174f, 0.54143369f, 0.12590793f, 0.32307717f, 0.11133958f, 0.20597807f, 0.22445148f, 0.36961299f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09562620f, 0.19765194f, -0.15139352f, -0.29479626f, -0.25613385f, -0.29563802f, 0.08976349f, -0.02999948f, 
    -0.04593173f, 0.14560719f, 0.04370320f, -0.16187271f, -0.18071035f, -0.24847056f, -0.43860531f, -0.30491287f, 
    -0.36654845f, -0.25140336f, 0.06681885f, -0.12520976f, -0.03047318f, 0.01222538f, 0.05720689f, 0.10041501f, 
    -0.44647667f, -0.02515765f, 0.11413631f, -0.25503263f, -0.10605861f, -0.26503867f, -0.20496993f, 0.22339746f, 
    0.16023189f, -0.16328962f, 0.17452988f, 0.11720596f, -0.14071503f, 0.04782163f, -0.07973951f, 0.18788527f, 
    -0.00120360f, -0.12115277f, 0.08555009f, 0.19454376f, -0.06911705f, -0.04935380f, 0.00844362f, -0.00166033f, 
    0.16426234f, -0.12475793f, -0.10219799f, 0.06339723f, 0.17428519f, 0.11051430f, -0.08045141f, 0.08309458f, 
    0.26614371f, 0.07531383f, -0.05318054f, 0.23059562f, -0.16290617f, 0.38028541f, 0.42040235f, 0.42804593f, 
    0.00171010f, -0.01243181f, 0.07753535f, -0.06134311f, 0.18793690f, -0.05672104f, 0.00794194f, 0.09202636f, 
    0.07074219f, -0.14632750f, 0.21353206f, -0.19758300f, -0.01257172f, 0.19302793f, -0.02644334f, 0.06190327f, 
    0.11340207f, -0.03457038f, 0.08976845f, -0.07776584f, -0.05201903f, 0.04123496f, -0.29392210f, -0.05542596f, 
    0.23489447f, -0.15545304f, -0.23414491f, 0.00363802f, 0.06491575f, 0.08493343f, 0.09826606f, -0.14044806f, 
    -0.04978406f, -0.25267011f, -0.14524589f, 0.26477250f, -0.03545796f, -0.16504778f, -0.13006692f, 0.07813766f, 
    0.08991437f, 0.03285535f, -0.10184284f, -0.04770575f, -0.38901868f, -0.13747355f, 0.31542581f, -0.15246885f, 
    0.02452031f, -0.28074723f, -0.45082060f, 0.18225637f, 0.20272107f, -0.08329793f, 0.01084418f, 0.28878304f, 
    0.08688045f, 0.12753028f, 0.35092479f, 0.38368234f, 0.18228465f, -0.01871460f, -0.03210761f, 0.06517247f, 
    -0.02940453f, 0.11612947f, 0.04858975f, -0.02284188f, 0.08831907f, 0.22187839f, 0.25086564f, 0.18695432f, 
    0.06818276f, 0.43223029f, 0.26828080f, 0.08284561f, 0.01336599f, 0.02720500f, 0.01842188f, 0.01438020f, 
    -0.22408661f, -0.02726807f, -0.13016646f, -0.21996790f, 0.06964983f, -0.24132466f, -0.18997845f, -0.19414364f, 
    0.17286672f, -0.14189683f, 0.06073539f, 0.15646391f, 0.01359826f, -0.21213886f, -0.40132454f, 0.04618394f, 
    -0.08078790f, 0.08182774f, -0.10586681f, 0.37639073f, -0.08938003f, 0.21644080f, -0.43961972f, 0.01138627f, 
    0.43100393f, 0.14984597f, 0.48361230f, -0.21512072f, -0.00407014f, 0.01085923f, 0.17489541f, -0.32035261f, 
    0.09913261f, 0.00235864f, -0.06950697f, -0.05792538f, 0.14107332f, 0.36030903f, 0.21007989f, -0.20271273f, 
    0.03986944f, -0.09979774f, 0.36294219f, 0.13422614f, 0.17446490f, 0.12877846f, -0.08152208f, 0.00555834f, 
    0.28202188f, 0.14041701f, 0.11564983f, -0.31670335f, 0.08331048f, -0.18212965f, -0.05596198f, -0.20600386f, 
    0.14241770f, -0.09977192f, -0.05225708f, 0.00466928f, -0.22899838f, -0.17637236f, -0.24327923f, 0.07294869f, 
    -0.04680359f, -0.00500529f, -0.00607208f, 0.01933044f, 0.18301249f, 0.04090030f, 0.16720027f, 0.05631232f, 
    0.00968337f, 0.04033448f, 0.28680789f, -0.13927548f, 0.21621628f, -0.01737536f, -0.04428272f, 0.04288498f, 
    0.02905992f, 0.02249206f, 0.08541143f, 0.00294538f, -0.13417730f, 0.20693925f, -0.01360968f, 0.01270379f, 
    0.17462370f, 0.24487734f, -0.00309850f, 0.10685530f, 0.03004307f, 0.00026072f, -0.10479664f, 0.02746268f, 
    -0.52288413f, -0.02504252f, -0.13013297f, 0.10274617f, 0.03721967f, 0.11933055f, 0.15059237f, 0.09618204f, 
    -0.10651790f, 0.08640553f, 0.11269584f, 0.03046160f, 0.34510589f, -0.23385680f, -0.01417642f, -0.17111935f, 
    0.29483503f, -0.09197598f, 0.28673437f, -0.06259390f, -0.03243167f, -0.07836000f, 0.00279989f, 0.16645087f, 
    -0.30980393f, 0.01949195f, -0.32121715f, 0.05505789f, 0.08177135f, 0.20357820f, -0.03887097f, -0.20382228f, 
    0.26130548f, -0.08437594f, -0.12842207f, -0.01166373f, -0.20580374f, 0.14166228f, 0.01012501f, 0.24737832f, 
    -0.15086755f, 0.12778607f, -0.06061119f, 0.08432457f, 0.06023072f, -0.00272508f, -0.00783109f, -0.08238943f, 
    0.48918599f, -0.06821950f, 0.25847018f, 0.06802404f, 0.10301606f, -0.03333943f, 0.08962039f, -0.04437229f, 
    0.04365999f, 0.12238055f, 0.17143865f, 0.00408844f, -0.06511348f, 0.29375470f, -0.02109483f, 0.08360952f, 
    0.01156419f, -0.03840906f, -0.00010218f, 0.07745732f, -0.09399975f, 0.08079464f, -0.00838432f, -0.02870216f, 
    0.14747837f, -0.06346000f, 0.12707289f, -0.13007641f, 0.03361142f, -0.11371112f, 0.02718986f, 0.17774779f, 
    0.00141659f, -0.06643042f, 0.01420795f, -0.14365517f, 0.32073289f, -0.08074331f, 0.10625670f, 0.05927467f, 
    0.16974141f, -0.00926153f, 0.12444256f, 0.06736246f, -0.01554420f, 0.02001477f, -0.09734576f, -0.05172741f, 
    -0.08787839f, 0.11773047f, -0.06167981f, -0.07779580f, -0.05713927f, 0.18713558f, -0.02142789f, -0.10072576f, 
    0.03604826f, 0.04098829f, -0.06256202f, -0.01279029f, 0.08820872f, 0.01071996f, -0.07298004f, -0.24830112f, 
    0.06157556f, 0.05057735f, -0.10898168f, -0.06149045f, 0.01340760f, 0.03432429f, 0.09704566f, 0.14401698f, 
    -0.50107586f, -0.16790615f, -0.17758062f, 0.13120003f, 0.03251447f, -0.03644397f, 0.18240079f, 0.10366318f, 
    -0.14802437f, -0.06450436f, -0.07363867f, -0.03558492f, 0.24451835f, 0.61246103f, 0.06769787f, -0.04285270f, 
    -0.08953945f, -0.03228379f, 0.17546828f, 0.12367567f, 0.05874779f, 0.15598366f, -0.06338516f, -0.05016964f, 
    0.38764292f, -0.17706026f, 0.18982215f, -0.13302070f, -0.31650582f, 0.01613162f, 0.01103667f, -0.01129836f, 
    0.01794331f, 0.02066583f, 0.05108181f, -0.12684532f, 0.40036634f, 0.00203286f, -0.01727358f, 0.08155556f, 
    -0.00731172f, -0.05537224f, 0.01133161f, -0.01907513f, 0.04514245f, -0.00065011f, -0.02704799f, -0.08778293f, 
    -0.06803920f, 0.16119021f, -0.04693807f, 0.03206151f, -0.16214325f, -0.24517152f, -0.14573090f, -0.15691684f, 
    0.05773070f, -0.01085310f, 0.09274510f, 0.05426109f, 0.08152680f, 0.16268881f, 0.11396213f, 0.22203520f, 
    -0.22938012f, -0.15008575f, 0.17191981f, -0.21880998f, -0.04236279f, 0.07346635f, 0.02102794f, 0.03130790f, 
    -0.20068434f, 0.02844838f, 0.07114175f, -0.08557567f, -0.07366101f, 0.02006239f, -0.12742315f, 0.10594850f, 
    0.06795163f, -0.19355558f, -0.11297771f, 0.01318540f, 0.66459322f, -0.46130651f, -0.59383488f, -0.12380954f, 
    -0.05287392f, 0.21072206f, -0.15583524f, 0.15095080f, -0.06375282f, -0.03499394f, -0.00514180f, 0.05272825f, 
    0.21879783f, -0.44688556f, -0.06021073f, -0.21860947f, -0.04081927f, 0.13369602f, 0.02957931f, 0.17843626f, 
    -0.01396036f, 0.04624055f, 0.01192362f, -0.15939018f, 0.04819091f, 0.18039674f, -0.01440076f, 0.33002043f, 
    0.01425910f, -0.07004544f, -0.01044206f, 0.02765369f, -0.09091560f, -0.05107795f, -0.13481666f, -0.05240608f, 
    0.01222012f, 0.09096418f, 0.33059177f, -0.01747856f, -0.12452394f, -0.00399295f, 0.01646012f, -0.20874654f, 
    0.02879575f, 0.01609617f, -0.09045725f, -0.01002865f, 0.24363934f, 0.19956374f, 0.20700310f, 0.13370095f, 
    -0.04128608f, 0.05759503f, -0.15807191f, -0.13928707f, 0.04737764f, 0.04989757f, 0.04617615f, 0.13978951f, 
    0.10147344f, 0.10892235f, -0.07451941f, 0.10631145f, 0.23796098f, 0.19007856f, -0.06625218f, 0.04912938f, 
    -0.08317417f, -0.16130656f, -0.13120693f, -0.06387670f, -0.00582124f, 0.05612586f, -0.35051188f, 0.05887264f, 
    0.19685495f, 0.18768936f, 0.25090754f, 0.05186445f, -0.19306690f, 0.06832589f, -0.09344736f, 0.06587240f, 
    0.14555936f, 0.06213202f, 0.20080855f, -0.00023153f, -0.01772893f, 0.01278781f, 0.04646106f, -0.11111181f, 
    0.11355852f, 0.02794803f, -0.02540887f, 0.11399051f, 0.23757862f, 0.25558797f, 0.18205352f, 0.01008429f, 
    -0.18471293f, -0.00499055f, -0.01535047f, -0.08149871f, -0.09433467f, -0.00133673f, 0.13760515f, -0.20634691f, 
    0.58625627f, -0.49202970f, 0.03898584f, -0.04161802f, -0.03770898f, -0.11228675f, 0.12843373f, 0.01891986f, 
    0.14989050f, 0.01207087f, -0.02105665f, 0.12348678f, 0.34210250f, -0.01566063f, -0.09054273f, -0.08528121f, 
    0.25139695f, -0.00131996f, 0.21610558f, 0.18338843f, -0.11969711f, 0.01322290f, -0.08167587f, 0.17699082f, 
    -0.10273065f, 0.21960972f, -0.07181745f, 0.24712054f, -0.04487793f, -0.03295906f, 0.00606067f, -0.11839107f, 
    -0.01847751f, -0.04187704f, 0.11914926f, 0.01812760f, -0.01584086f, 0.10057962f, -0.13773827f, -0.10687346f, 
    -0.03037309f, -0.14057687f, -0.01390807f, -0.06858253f, -0.09540433f, 0.03358856f, 0.14502157f, 0.01969089f, 
    0.28368750f, 0.05335278f, 0.04896102f, -0.21506950f, -0.12967783f, -0.11111359f, -0.03355065f, -0.10084444f, 
    -0.02573022f, 0.01304908f, 0.03921428f, -0.08594635f, 0.11211117f, -0.07702202f, 0.00623110f, -0.14757419f, 
    0.08882110f, 0.02675282f, 0.04174375f, -0.02436340f, 0.04837481f, -0.13708399f, -0.11068519f, -0.01168949f, 
    0.26947132f, -0.04670956f, 0.00430307f, 0.12091839f, -0.22068448f, 0.17390387f, 0.12064225f, 0.02584258f, 
    -0.02023277f, 0.09903876f, 0.06143717f, 0.14996697f, 0.29395100f, -0.09247547f, -0.11911546f, -0.16382177f, 
    0.21660276f, -0.13018110f, 0.04427680f, -0.12136050f, -0.04912616f, -0.05965293f, 0.07006459f, 0.13945693f, 
    -0.05589624f, -0.18843687f, 0.03295550f, -0.12296487f, -0.03009444f, -0.05909114f, 0.21466780f, 0.11252912f, 
    0.12361424f, 0.07644668f, 0.02935929f, 0.10817543f, 0.31882635f, 0.11409923f, 0.23997907f, 0.00179930f, 
    -0.08490814f, 0.14716683f, 0.04890335f, 0.06670061f, -0.01772201f, 0.10989706f, 0.19122063f, 0.08109476f, 
    0.16764635f, 0.25113857f, 0.06994337f, 0.08815470f, -0.10716159f, -0.08297032f, 0.09574223f, 0.03866880f, 
    -0.02965518f, 0.18295726f, 0.37739310f, -0.10307460f, 0.36029124f, 0.15243569f, -0.06185002f, 0.01594287f, 
    -0.06868391f, -0.08002680f, 0.11055918f, -0.00203038f, 0.04122291f, -0.05486037f, -0.12503248f, -0.05302021f, 
    0.10739372f, -0.17460069f, -0.04171536f, -0.00082275f, 0.13411239f, 0.06694148f, 0.10358455f, 0.11978318f, 
    0.06797260f, -0.00568968f, 0.19974484f, 0.16685788f, -0.22208519f, -0.23079091f, -0.15727702f, -0.11483496f, 
    0.01388834f, -0.01493343f, 0.06595211f, -0.01279267f, -0.04136669f, -0.09203938f, -0.19403642f, -0.08153592f, 
    0.06059209f, 0.05963312f, 0.12036967f, -0.09455982f, -0.11014828f, 0.10928067f, -0.02648716f, 0.10730847f, 
    0.27005607f, 0.16619910f, 0.03507260f, -0.00219585f, 0.07897022f, 0.19889943f, -0.03260639f, -0.05742174f, 
    0.08758020f, -0.14200853f, 0.05781264f, -0.13650459f, 0.08390214f, -0.04870344f, -0.00615097f, -0.07418401f, 
    -0.27763471f, 0.32527140f, -0.14010237f, 0.09640151f, 0.01071911f, -0.09228461f, 0.24515983f, 0.02083038f, 
    -0.12684175f, 0.03669610f, 0.14142568f, 0.00452681f, -0.17671375f, 0.30510917f, -0.18878013f, 0.11025351f, 
    0.13860404f, -0.04096553f, 0.28272051f, 0.12347165f, 0.08984372f, 0.19646631f, 0.06731318f, -0.05657227f, 
    0.02178156f, -0.02010306f, -0.01706951f, -0.04007857f, -0.03042119f, 0.02026919f, 0.00295580f, -0.05322325f, 
    0.00521268f, -0.05658675f, -0.03054363f, -0.05570003f, -0.00910028f, -0.00821337f, -0.01001685f, -0.06085566f, 
    -0.00606497f, -0.01293075f, 0.02498959f, 0.02252847f, -0.04148674f, -0.06527801f, -0.02687640f, 0.03401772f, 
    -0.04210737f, -0.04165098f, 0.01551339f, -0.05970059f, 0.02296713f, -0.04546582f, 0.01596823f, -0.05084120f, 
    0.05935636f, 0.06284847f, 0.03431015f, 0.05226702f, 0.00140211f, 0.02684775f, 0.01401069f, -0.02236635f, 
    -0.06895363f, 0.04702913f, 0.02606453f, 0.06135756f, 0.03552773f, -0.01844864f, 0.00889237f, -0.03264511f, 
    0.03265254f, 0.02896065f, 0.00075603f, -0.03600263f, -0.02705329f, -0.04653675f, 0.00818929f, 0.01011937f, 
    0.04943635f, -0.02941080f, -0.01627072f, -0.07615795f, 0.04748975f, -0.07131620f, 0.04941246f, 0.06276813f, 
    -0.03371861f, 0.04213745f, 0.00368130f, -0.02712924f, -0.02078932f, -0.01585455f, -0.00162532f, 0.02213318f, 
    -0.03824676f, -0.01204527f, -0.05081142f, -0.03794279f, 0.04733951f, -0.06623203f, -0.07178865f, -0.04719796f, 
    -0.05015919f, 0.05883824f, 0.01101092f, -0.00421705f, 0.01888558f, 0.02750209f, -0.03832139f, -0.00701305f, 
    -0.06337686f, -0.07402026f, -0.04294405f, 0.03585760f, -0.05369451f, -0.07191350f, -0.04418899f, -0.05070665f, 
    0.02388115f, 0.04084855f, 0.00242910f, 0.03158984f, -0.03534885f, -0.00791729f, -0.02920934f, -0.00299356f, 
    0.00584555f, 0.05266017f, 0.00657754f, -0.02743009f, -0.03749596f, 0.06292597f, 0.03481420f, -0.07621873f, 
    -0.05072929f, 0.01072782f, 0.02390912f, -0.06463105f, -0.01283841f, 0.02640384f, 0.02758968f, -0.05106174f, 
    0.05165594f, -0.06056535f, 0.04980430f, -0.03172903f, 0.03865048f, 0.01392642f, -0.03444067f, 0.05395655f, 
    -0.01766970f, 0.05323447f, -0.05919175f, -0.07309321f, 0.06357282f, 0.05738739f, 0.04452949f, -0.05220955f, 
    -0.02462072f, -0.07424300f, -0.01599842f, 0.05233474f, -0.06704080f, -0.01850011f, 0.04482423f, -0.04003883f, 
    0.02096267f, 0.00770893f, 0.00421788f, -0.05184852f, 0.03028522f, -0.00050893f, 0.03396406f, -0.02127492f, 
    -0.02216102f, -0.04054308f, 0.04317008f, -0.02683639f, -0.03368448f, -0.04741017f, 0.03311856f, -0.02161672f, 
    -0.03239362f, -0.02858630f, 0.03692912f, -0.07486690f, -0.04196130f, -0.01379737f, -0.00822293f, 0.01631165f, 
    -0.05302165f, 0.03071221f, -0.04473859f, 0.05834639f, 0.04187022f, 0.04087457f, -0.07473736f, 0.00190642f, 
    -0.06112443f, 0.06047278f, -0.03356745f, -0.08057526f, -0.03315406f, -0.03384334f, -0.02333464f, -0.01024860f, 
    0.05802049f, 0.02424369f, -0.01316881f, 0.06387344f, -0.00961678f, -0.04065643f, 0.01053620f, -0.03683474f, 
    0.15863498f, -0.08758520f, 0.36315757f, 0.22201706f, -0.12623245f, 0.02142652f, 0.04487541f, 0.08804089f, 
    -0.09311302f, -0.00682610f, 0.05980966f, 0.03847023f, 0.25372329f, 0.00029214f, 0.13015778f, 0.18640244f, 
    0.12132645f, -0.08026610f, -0.10837851f, 0.07838517f, -0.05096839f, -0.00660544f, -0.03363278f, -0.02467085f, 
    0.27757218f, 0.27764770f, 0.10161951f, 0.05609005f, -0.04952864f, 0.02715068f, 0.03268344f, 0.03699604f, 
    0.12784272f, -0.04735084f, -0.08945942f, 0.02282747f, 0.19874761f, -0.05965088f, 0.10587362f, 0.04402228f, 
    -0.06505748f, 0.30870169f, 0.01479414f, 0.07413333f, -0.09434972f, -0.01916803f, -0.15012449f, 0.05033283f, 
    -0.09947199f, 0.03655251f, 0.08516834f, -0.10593058f, 0.01946201f, -0.19671978f, -0.01226725f, -0.03145659f, 
    0.00289924f, 0.07014514f, -0.07378995f, -0.10686354f, -0.44219103f, 0.18737018f, 0.45042160f, -0.10863392f, 
    -0.13938102f, -0.07655387f, -0.20101039f, 0.15737416f, -0.08562981f, -0.04489880f, 0.15112288f, -0.13765010f, 
    0.34801799f, 0.01098007f, -0.09742044f, -0.53556299f, 0.00836373f, -0.19007556f, 0.08465859f, -0.07094134f, 
    0.02130909f, 0.16223767f, -0.01114278f, 0.00531648f, 0.02707168f, 0.12138272f, 0.00478880f, 0.02833026f, 
    0.14410073f, 0.01360787f, 0.05772563f, 0.07752653f, -0.14973713f, -0.18056133f, 0.09425095f, -0.03943827f, 
    -0.23517635f, -0.05957866f, 0.17589164f, 0.31769830f, 0.02547228f, -0.00623585f, -0.00942509f, 0.11886400f, 
    0.02302105f, -0.22430627f, -0.05975173f, -0.21822327f, 0.15202303f, -0.01878722f, -0.05524593f, 0.10426352f, 
    -0.04482937f, 0.06298378f, -0.03121011f, -0.02289247f, 0.11657205f, 0.02114478f, -0.01776225f, 0.07889853f, 
    0.03452301f, 0.12048850f, 0.06699933f, -0.12388770f, 0.06898151f, 0.05872142f, -0.18663041f, -0.22296931f, 
    -0.14399268f, 0.17509909f, 0.16346258f, 0.08058209f, -0.05943198f, 0.34494820f, 0.11210420f, -0.05621895f, 
    -0.07738890f, 0.01131308f, 0.00107094f, -0.03508471f, -0.06306504f, 0.00721301f, 0.08578900f, -0.08160705f, 
    0.14656362f, 0.00038229f, 0.10279291f, 0.20919740f, 0.06216589f, 0.11408390f, 0.02860862f, 0.08788632f, 
    0.11176519f, -0.01217362f, 0.00126536f, 0.21948493f, 0.01581919f, 0.10611567f, 0.05515775f, 0.34418342f, 
    0.08333398f, 0.05528509f, 0.01514222f, 0.08100612f, -0.02812365f, -0.03686888f, -0.10439332f, 0.04384173f, 
    0.28017431f, 0.00540290f, -0.03921423f, -0.12096512f, 0.05388458f, -0.12772004f, -0.34144342f, -0.01359321f, 
    -0.06931323f, 0.14909853f, 0.16982137f, 0.00539866f, -0.23211272f, -0.08816049f, 0.08150412f, -0.07130508f, 
    0.09650671f, 0.03281114f, -0.13237645f, 0.00954728f, -0.01426902f, -0.22289237f, -0.09347206f, -0.13300374f, 
    -0.07278284f, 0.48798537f, -0.07590470f, 0.40008235f, 0.12614258f, -0.02598419f, 0.03778820f, 0.00274812f, 
    0.10946907f, 0.10590710f, -0.02962293f, 0.04453944f, -0.32196584f, 0.07395446f, -0.03247878f, -0.09385169f, 
    -0.18128799f, 0.01190247f, 0.00529121f, -0.17222458f, 0.11964767f, -0.03682847f, 0.02946733f, 0.24483512f, 
    -0.13182038f, 0.07462111f, 0.18119673f, 0.13478446f, 0.12323458f, 0.18080898f, 0.34229121f, 0.09834159f, 
    -0.04344640f, 0.15324993f, 0.17050599f, -0.03721189f, -0.17730653f, -0.13714935f, -0.02577321f, -0.17564143f, 
    0.08177672f, -0.02362112f, 0.11918973f, 0.06412929f, 0.07753528f, 0.02623274f, 0.14938958f, -0.01427886f, 
    0.29044983f, 0.11421702f, 0.03216657f, 0.08374561f, 0.08541135f, 0.00405159f, -0.04213925f, 0.20948286f, 
    0.11887799f, 0.18525702f, 0.04546949f, 0.24131954f, -0.43588296f, 0.03702378f, 0.09908544f, 0.14527315f, 
    0.07316728f, -0.13734789f, 0.22831093f, 0.19040555f, 0.01564127f, 0.07330805f, 0.04743087f, 0.01835800f, 
    -0.23729372f, 0.15325519f, 0.36531964f, 0.30077758f, 0.08242147f, 0.22486030f, 0.15617760f, 0.26885086f, 
    0.18480934f, 0.27718922f, 0.07307878f, 0.03934367f, 0.40756479f, 0.06293126f, 0.33956653f, -0.09570540f, 
    -0.02328593f, -0.06883910f, -0.00544023f, -0.05803907f, 0.15989736f, -0.02386346f, 0.12457905f, -0.04556499f, 
    0.40480673f, 0.24998899f, -0.25135037f, 0.00465053f, -0.02095621f, 0.03993205f, -0.08042602f, 0.03577907f, 
    -0.12193933f, 0.17676625f, 0.01450282f, -0.05340079f, 0.10583621f, 0.10807729f, 0.28227401f, 0.10395794f, 
    0.07470046f, 0.01528025f, -0.05890452f, 0.06277782f, 0.00900246f, -0.03371466f, 0.01861731f, 0.04012966f, 
    -0.06309619f, -0.14222097f, 0.06990632f, 0.13704562f, -0.00934329f, -0.17488119f, 0.17851134f, 0.12981652f, 
    0.10203752f, -0.07110821f, -0.01910859f, -0.05451356f, -0.34435755f, -0.11589049f, -0.06144557f, 0.25585961f, 
    -0.05183041f, 0.29475436f, 0.13530259f, 0.06340010f, 0.06646712f, 0.06903114f, 0.08379502f, 0.14230770f, 
    -0.02064812f, 0.08477775f, -0.03680392f, -0.18442819f, 0.02293103f, -0.03554574f, -0.12591276f, -0.11811941f, 
    -0.10051525f, -0.01919833f, -0.08564528f, -0.18660443f, 0.07668252f, -0.14166756f, -0.14061084f, -0.05346073f, 
    -0.13736340f, 0.01032909f, 0.06799924f, 0.08162761f, 0.03798768f, 0.14532666f, 0.07958104f, 0.19108263f, 
    -0.19072574f, 0.56231064f, 0.34911922f, 0.08858114f, -0.04896818f, 0.25878561f, 0.15130286f, 0.16173413f, 
    0.21268393f, 0.09156151f, 0.10328297f, 0.04175592f, -0.22773960f, 0.14750418f, -0.01772798f, 0.12730941f, 
    -0.01702124f, 0.11066562f, 0.24768709f, 0.10314187f, 0.15192422f, 0.01988032f, 0.19888823f, 0.19505227f, 
    -0.10833304f, 0.16237910f, 0.07171386f, -0.00727338f, 0.10872697f, 0.06897509f, -0.15091592f, -0.00767343f, 
    -0.16157894f, -0.03338256f, 0.03401309f, -0.15205815f, 0.11754570f, 0.21278441f, 0.40150717f, -0.07549737f, 
    0.32870063f, 0.05987312f, 0.03876922f, 0.22213937f, -0.12879805f, 0.04010329f, 0.11125141f, -0.14907880f, 
    -0.09348224f, -0.16187614f, -0.27846959f, -0.10478251f, 0.07523628f, 0.08629337f, 0.01589824f, -0.16639337f, 
    0.25076142f, 0.05089081f, -0.06622863f, -0.14832176f, -0.06296524f, 0.05121529f, -0.06438230f, 0.04551264f, 
    -0.04250826f, 0.15629613f, 0.07340971f, 0.12966162f, 0.08464907f, -0.02935773f, -0.13792197f, -0.28606695f, 
    0.31965277f, 0.40318966f, -0.02261748f, -0.09285729f, -0.08323988f, -0.00135828f, -0.08556449f, -0.19184799f, 
    -0.01873433f, -0.17419012f, -0.02309723f, -0.07789564f, 0.71126485f, -0.03448979f, 0.01200711f, 0.37776583f, 
    0.26073891f, -0.00884160f, -0.02014493f, 0.04741895f, -0.10497291f, 0.10619993f, 0.18265179f, 0.24945189f, 
    0.21222384f, -0.12809110f, 0.09309733f, 0.20376776f, 0.03723684f, 0.01943733f, -0.17640215f, 0.11516236f, 
    0.00625433f, 0.00747179f, 0.20886636f, 0.32733828f, -0.01524302f, 0.09290698f, 0.05233918f, -0.00480552f, 
    -0.04979545f, 0.03293568f, 0.03870636f, -0.08510593f, 0.03982130f, 0.28955102f, 0.00177954f, 0.14865160f, 
    0.02414655f, 0.26872855f, -0.14915609f, -0.11742072f, -0.12097438f, 0.00359279f, 0.01304536f, 0.05151592f, 
    -0.14194505f, -0.14190748f, 0.04713095f, 0.13322769f, -0.14833046f, -0.24311616f, -0.17233428f, -0.12048184f, 
    -0.00430261f, 0.15730397f, 0.19437602f, 0.07695483f, 0.19183046f, 0.27559415f, -0.07217715f, -0.06445321f, 
    0.14182860f, -0.09039438f, -0.05158101f, 0.10852879f, -0.04026625f, 0.20912471f, 0.15024593f, 0.06748120f, 
    0.06049923f, 0.11221337f, -0.09616850f, 0.34788617f, -0.06124021f, -0.14301755f, -0.11754184f, 0.03554216f, 
    -0.14159568f, -0.28497183f, -0.17615239f, -0.03947470f, -0.01815727f, -0.01930795f, 0.01428605f, -0.09714314f, 
    -0.02446416f, -0.06433558f, 0.03161738f, 0.00240715f, -0.08259577f, 0.08645233f, 0.20531762f, -0.01079308f, 
    0.19154006f, 0.24337658f, 0.18714216f, 0.18656997f, 0.18515909f, 0.09293106f, 0.01106944f, -0.04006192f, 
    0.22798294f, -0.19022983f, -0.00853304f, -0.12295404f, 0.02427843f, -0.11132452f, -0.05075668f, -0.13325495f, 
    -0.61775845f, 0.33661586f, 0.30313689f, 0.19363186f, 0.09082136f, -0.04646055f, 0.02883291f, -0.13081025f, 
    -0.16700429f, 0.11389881f, 0.18952824f, 0.21800151f, -0.01624271f, 0.12970853f, -0.26339877f, 0.20119904f, 
    0.09266255f, -0.02948376f, -0.10694534f, -0.06753344f, -0.08854848f, -0.00503991f, -0.03296272f, 0.00283474f, 
    -0.03224052f, 0.02842089f, 0.06986257f, 0.02295908f, -0.03466831f, 0.04887108f, -0.04440451f, 0.03312854f, 
    0.05508966f, -0.02768094f, -0.02830585f, -0.00792900f, 0.00893057f, -0.05926507f, -0.00496947f, -0.05653071f, 
    -0.02828209f, -0.07214037f, -0.05223672f, 0.05950804f, -0.02080033f, 0.00965571f, -0.07547548f, 0.05726571f, 
    -0.06817117f, 0.04132992f, -0.04076536f, -0.00631978f, -0.04838036f, -0.07374695f, -0.00985051f, -0.05325723f, 
    -0.06948724f, -0.01427856f, -0.05967437f, -0.04969321f, -0.04164242f, -0.02274948f, -0.02053090f, 0.01882527f, 
    -0.00887923f, 0.02830439f, -0.07259787f, -0.01048637f, -0.01105375f, -0.00208412f, -0.00603757f, -0.02934108f, 
    -0.00232010f, -0.01007129f, -0.04455473f, 0.01134873f, 0.02424865f, -0.05451787f, 0.04363202f, 0.03674687f, 
    0.04282695f, -0.04556263f, 0.01847694f, 0.04524306f, 0.00547429f, -0.03532376f, 0.04043719f, -0.03362667f, 
    -0.01521929f, -0.03093219f, -0.03773364f, 0.05426108f, 0.02205923f, -0.03970598f, -0.02400730f, -0.02978610f, 
    0.02201205f, 0.04529732f, 0.00289918f, -0.08037175f, -0.05931049f, 0.04001063f, -0.00703536f, 0.06366584f, 
    0.00746871f, 0.00978853f, -0.06341071f, -0.03499112f, -0.02283832f, -0.06052908f, 0.05975507f, 0.01911735f, 
    -0.00748683f, 0.05208328f, -0.06137447f, 0.01579016f, -0.06963729f, -0.03322740f, -0.05128536f, 0.03825822f, 
    -0.00609652f, -0.01789415f, 0.01668565f, -0.00645863f, 0.01884785f, 0.05481039f, -0.05446342f, -0.01296352f, 
    0.00074495f, -0.05475169f, -0.07304079f, -0.06744569f, 0.02109729f, -0.01782533f, -0.03000261f, -0.04981150f, 
    0.02603658f, 0.03639194f, 0.03131429f, -0.05730087f, -0.06908010f, -0.04806720f, -0.05137715f, -0.02288566f, 
    0.02378604f, -0.01968944f, -0.03864183f, -0.03073124f, -0.07692635f, -0.00256347f, 0.02657576f, 0.03742229f, 
    0.01193198f, 0.02279757f, -0.00853615f, -0.02020404f, -0.08065232f, -0.01105433f, 0.02729041f, -0.06927821f, 
    -0.03474797f, 0.01088561f, 0.05653755f, -0.03894982f, -0.06679907f, 0.06354748f, 0.02073275f, -0.03454426f, 
    -0.02930568f, -0.06716997f, -0.01001084f, 0.03658039f, -0.03949871f, 0.04648400f, 0.05114973f, 0.01720638f, 
    0.01296997f, 0.02351113f, 0.05425615f, 0.02560782f, 0.05732475f, -0.06122271f, -0.07423781f, -0.03583010f, 
    -0.05892969f, -0.00820507f, -0.07466776f, 0.01127818f, 0.04940858f, 0.04925584f, -0.06629579f, 0.06293887f, 
    -0.06586194f, 0.00024231f, -0.00657659f, -0.04664753f, -0.01156857f, -0.00470995f, 0.05269079f, -0.01227886f, 
    -0.02367851f, -0.04261829f, 0.00098736f, -0.05741436f, 0.01577690f, -0.03161564f, 0.01572938f, 0.05422070f, 
    0.04094458f, 0.04383083f, -0.02173821f, -0.05588168f, 0.02326502f, 0.03611108f, 0.03749022f, -0.02850127f, 
    0.10343930f, 0.09164993f, 0.03386596f, 0.30858371f, 0.11780048f, -0.01971284f, -0.01552246f, 0.07949262f, 
    -0.05026145f, -0.03235320f, -0.03074106f, 0.06371652f, -0.11704061f, 0.14497970f, 0.12939784f, 0.06075202f, 
    -0.13845186f, -0.08402541f, 0.00842291f, -0.02241760f, 0.06454574f, 0.15359032f, -0.08264212f, 0.26818982f, 
    0.45217195f, 0.01859321f, 0.22248888f, 0.03830798f, 0.15511484f, 0.01926585f, 0.25180620f, 0.24947974f, 
    -0.14032178f, -0.01932695f, -0.20895475f, -0.05923032f, 0.06031786f, -0.07055225f, -0.19734795f, -0.16162491f, 
    0.33760974f, -0.17052054f, -0.11470352f, -0.04718358f, -0.14337896f, -0.09010300f, -0.03498979f, 0.03373082f, 
    -0.04387864f, -0.18675131f, -0.08111496f, 0.06240766f, 0.13414386f, 0.10639016f, -0.07160479f, 0.07482763f, 
    0.09216502f, 0.13776875f, 0.24808730f, -0.11232022f, -0.62466848f, 0.09849739f, 0.06004283f, -0.14691640f, 
    -0.04720882f, 0.13495620f, 0.11144753f, -0.01803961f, 0.10989856f, -0.14191240f, 0.10379985f, -0.02238376f, 
    -0.22174461f, 0.27526981f, -0.00252204f, 0.14428537f, 0.08186904f, 0.01740073f, 0.18713538f, 0.07384917f, 
    -0.03604043f, -0.00874691f, 0.17594676f, -0.00158006f, 0.21734841f, -0.02991729f, 0.33061191f, -0.11951578f, 
    -0.21295142f, 0.03479731f, 0.00392516f, 0.03727663f, 0.16999593f, 0.05387231f, 0.16425538f, -0.06281638f, 
    0.28410551f, 0.22755575f, -0.06180067f, 0.01863734f, -0.05098089f, 0.03296305f, -0.03903735f, 0.07168250f, 
    0.18647787f, 0.13419862f, 0.26902547f, 0.22170456f, 0.22133507f, 0.24248682f, 0.05722588f, 0.09813184f, 
    0.00474083f, -0.02708785f, 0.08423670f, 0.19030315f, -0.03118369f, 0.05115654f, -0.15071584f, -0.04523320f, 
    -0.11652291f, -0.01294441f, -0.05438847f, 0.00856001f, -0.01652066f, 0.08410966f, 0.11233504f, -0.02933912f, 
    0.02470181f, -0.21771419f, 0.01017833f, -0.08407436f, -0.08075630f, -0.24214992f, 0.17553955f, -0.00973366f, 
    0.03059253f, -0.02481718f, -0.07625180f, -0.19097069f, -0.02125977f, -0.23399414f, -0.14912741f, -0.04627622f, 
    0.01552883f, -0.00330664f, -0.06821638f, -0.10498440f, -0.00967857f, -0.08962875f, -0.00385140f, -0.06096898f, 
    0.06770327f, 0.03442350f, 0.13472483f, -0.03629051f, -0.07524663f, 0.02462460f, 0.05138989f, -0.00155030f, 
    -0.03422456f, -0.06161506f, 0.05539424f, -0.06263842f, 0.08035340f, -0.05382549f, -0.00966929f, 0.18940990f, 
    0.09088468f, -0.28607300f, -0.11385414f, 0.14615123f, -0.04826897f, 0.03403190f, 0.03522645f, 0.05428074f, 
    0.10215560f, -0.23662873f, -0.06956073f, 0.12612517f, -0.13312365f, -0.15972999f, 0.18862340f, 0.00370781f, 
    -0.00777083f, 0.15108545f, 0.10013825f, -0.02104202f, 0.08314613f, 0.15035641f, 0.01249832f, 0.08262107f, 
    0.01986850f, -0.01132929f, -0.08343779f, -0.06935284f, 0.00012142f, -0.07318802f, 0.00987918f, -0.05675685f, 
    0.02924290f, -0.01853002f, -0.02393554f, -0.08934748f, -0.05389848f, -0.01217318f, 0.01712295f, -0.01946328f, 
    0.02231789f, 0.02632425f, 0.01793618f, -0.00998460f, -0.00366053f, -0.06651855f, -0.10355803f, 0.00466962f, 
    -0.06786656f, 0.01404434f, 0.01189315f, 0.02564247f, -0.07741481f, -0.01820239f, -0.09562206f, -0.09688951f, 
    -0.08565525f, -0.04047386f, -0.03357886f, -0.01833361f, 0.02338660f, 0.00264890f, -0.08009384f, 0.02004365f, 
    0.01389553f, -0.06565495f, -0.05879786f, -0.01195508f, -0.04046353f, -0.07923800f, -0.01284410f, -0.10371105f, 
    -0.00513735f, -0.08134022f, 0.03904632f, -0.04155562f, -0.08490109f, 0.02371233f, 0.02199499f, -0.07963549f, 
    -0.00481780f, -0.06739298f, -0.05818104f, -0.09507445f, -0.05312494f, -0.04239209f, 0.03873651f, 0.00201964f, 
    -0.02766938f, -0.05807611f, -0.07960933f, -0.03520567f, -0.05021694f, 0.03399207f, 0.02768438f, -0.07529874f, 
    -0.06997180f, -0.03875824f, -0.04640220f, -0.00088892f, -0.04962836f, -0.10107346f, -0.00219170f, -0.01914676f, 
    -0.09201052f, -0.00704357f, 0.00353772f, -0.05376934f, -0.03485735f, 0.03866980f, 0.05104359f, 0.02098547f, 
    -0.02959947f, 0.04829475f, 0.02442035f, 0.00351349f, 0.00133346f, -0.03899292f, -0.05488339f, -0.06745993f, 
    -0.06306876f, -0.08974595f, 0.00677691f, -0.04584461f, -0.07618506f, -0.00520194f, -0.01588040f, -0.06727785f, 
    -0.05893125f, -0.06660599f, -0.04440017f, -0.05473039f, -0.05531787f, -0.07681876f, 0.00825329f, -0.00611430f, 
    -0.03972921f, -0.08295016f, 0.02439363f, 0.02655048f, -0.04283800f, -0.03413344f, 0.01040798f, -0.00950345f, 
    0.00403363f, 0.00827372f, -0.03244228f, 0.00601808f, 0.01264190f, -0.00182567f, 0.05257541f, -0.02098450f, 
    0.04805404f, -0.02479631f, 0.01297917f, -0.05791335f, 0.01425442f, 0.03694699f, -0.07958318f, 0.04675864f, 
    0.02242856f, -0.04904318f, -0.04143040f, -0.03066859f, 0.02798627f, 0.03246902f, -0.05456460f, 0.01356433f, 
    -0.04708416f, -0.08684158f, -0.03988604f, -0.03888026f, 0.02316370f, -0.01689968f, -0.08931921f, -0.01114098f, 
    -0.05608343f, 0.02932335f, -0.05575354f, -0.08681118f, -0.03681783f, -0.10757349f, -0.05257151f, -0.10156217f, 
    -0.10065482f, 0.02032360f, -0.02955159f, -0.08586683f, -0.05114997f, -0.00361474f, -0.09129520f, -0.00923071f, 
    0.03045646f, -0.03125892f, 0.01915641f, -0.06806342f, -0.10685176f, -0.04097788f, -0.03863615f, -0.00365034f, 
    -0.02700456f, -0.00171588f, -0.05695164f, -0.00111105f, 0.04590163f, -0.05196224f, -0.06395733f, -0.06598094f, 
    -0.07657523f, -0.04673171f, -0.05669460f, -0.06358501f, -0.04564881f, 0.03126605f, -0.05427441f, 0.00549040f, 
    -0.03603628f, 0.42342874f, 0.10314733f, -0.05831891f, 0.26447985f, -0.06086824f, -0.08557008f, -0.25009543f, 
    -0.34193802f, -0.19863343f, -0.16837871f, -0.20915107f, -0.05819782f, 0.11045362f, -0.74052548f, 0.30724120f, 
    0.43646079f, 0.00998403f, 0.04163217f, -0.12607440f, -0.17685112f, 0.07422922f, 0.30108312f, -0.09950953f, 
    -0.35696301f, -0.02245190f, 0.24908726f, 0.14999332f, -0.07269858f, 0.24753198f, -0.16212985f, -0.08677385f, 
    -0.01682054f, -0.10338347f, -0.04521591f, -0.47457385f, -0.02526063f, -0.00894336f, -0.04487431f, 0.29459044f, 
    -0.00179731f, -0.05812635f, -0.03182172f, -0.18478607f, 0.00160985f, -0.16406801f, -0.35272741f, -0.50136483f, 
    0.02433557f, -0.42266273f, 0.24881315f, 0.18828738f, -0.13400204f, -0.01647944f, -0.12675765f, -0.13560180f, 
    0.01410090f, 0.01078317f, 0.11323179f, 0.26464164f, 0.58918136f, -0.03517244f, -0.04149084f, 0.03394309f, 
    0.17781404f, 0.27210733f, -0.03017059f, -0.24949344f, -0.04035446f, 0.20206000f, 0.06078658f, 0.22010255f, 
    -0.24722552f, -0.34246337f, -0.02918024f, 0.32611504f, 0.08834789f, 0.06181902f, -0.16411939f, -0.33651710f, 
    0.01568540f, -0.02743515f, -0.17517594f, 0.01465181f, -0.22348803f, -0.12468256f, -0.04230761f, 0.42574921f, 
    -0.14370728f, -0.06940427f, -0.02045628f, 0.05647055f, -0.06081202f, 0.26163200f, 0.06234660f, 0.38408276f, 
    0.13102821f, 0.19239376f, 0.53205341f, -0.23034611f, -0.07204369f, -0.21665800f, -0.18028654f, -0.09916005f, 
    -0.16719390f, -0.13138017f, 0.03144499f, 0.18597557f, -0.05952090f, -0.14351265f, 0.13823104f, 0.08851634f, 
    -0.21127829f, -0.22112741f, -0.17503503f, -0.10204818f, -0.19435400f, 0.08645950f, -0.12360065f, -0.26708654f, 
    0.27309480f, 0.17563225f, -0.09968716f, 0.07704356f, 0.00386772f, 0.14030261f, 0.10558628f, -0.01374660f, 
    0.21195950f, 0.19741514f, 0.12149806f, 0.45732042f, 0.32792026f, 0.00051975f, 0.02605998f, -0.11269569f, 
    0.22082303f, 0.06508335f, 0.14437284f, 0.03839316f, -0.09887413f, -0.14323463f, -0.02994038f, -0.29590955f, 
    -0.34424683f, -0.13255325f, 0.13585125f, 0.31331995f, -0.38465670f, -0.05146152f, -0.05870435f, 0.04461148f, 
    0.16095537f, 0.39169267f, 0.00969982f, 0.18661006f, -0.16124219f, -0.03084388f, 0.03414640f, -0.24768001f, 
    0.08226030f, -0.19775905f, -0.00188206f, -0.02391763f, -0.29344013f, -0.34378371f, -0.19820791f, -0.55178571f, 
    -0.41203102f, 0.02209331f, -0.70678949f, 0.24825737f, 0.18722652f, -0.05949790f, 0.04545796f, -0.26837924f, 
    -0.01669619f, 0.00632575f, 0.00482877f, 0.07925905f, 0.51708668f, 0.20943688f, -0.21851447f, 0.23074573f, 
    0.16583504f, 0.15869427f, 0.15194693f, 0.02013289f, -0.07507375f, 0.09837402f, 0.11804550f, 0.09974151f, 
    0.04662782f, -0.06739543f, -0.00009921f, -0.05611584f, -0.04347509f, 0.04442429f, -0.00559524f, 0.04749212f, 
    -0.07245344f, -0.00000961f, -0.02351919f, 0.01344412f, 0.06181871f, 0.03859243f, -0.07698501f, 0.01609936f, 
    -0.02250663f, 0.05736875f, -0.05309887f, -0.05703486f, -0.03134624f, 0.00125792f, 0.00794239f, 0.07242401f, 
    0.03150343f, 0.01586862f, -0.01927017f, -0.01490374f, 0.04699563f, -0.01465989f, -0.06463771f, -0.03983042f, 
    -0.06188905f, -0.06884978f, -0.01091397f, 0.02453284f, -0.07107776f, -0.02648806f, 0.04831374f, -0.00558440f, 
    0.03237931f, -0.05957372f, 0.03342658f, 0.00617018f, -0.03006627f, -0.05356622f, 0.05861926f, -0.07835460f, 
    0.00110463f, 0.05442332f, -0.03552454f, 0.05961987f, -0.07640238f, -0.05961571f, -0.00745490f, -0.00237769f, 
    0.01764174f, -0.06690452f, 0.03471734f, -0.04791412f, -0.07441397f, -0.02194484f, -0.06872321f, 0.03674739f, 
    -0.07678991f, 0.01202802f, 0.04379011f, 0.05846005f, 0.02634658f, -0.05048501f, 0.03647313f, -0.04270240f, 
    0.02496540f, 0.04215071f, -0.01962825f, -0.01650834f, -0.02712782f, 0.01585903f, 0.04776978f, 0.00899150f, 
    -0.02301252f, -0.01946381f, -0.06797770f, -0.02947414f, 0.01002675f, 0.06547020f, 0.02913534f, 0.04621936f, 
    0.05124811f, -0.01760121f, 0.04427813f, -0.07958023f, -0.06141471f, -0.06686582f, -0.02957059f, 0.01868087f, 
    -0.08306085f, 0.05479473f, -0.02810904f, 0.02067365f, 0.00518566f, 0.00252923f, -0.05418894f, 0.00261706f, 
    0.00008913f, -0.06236119f, -0.06658328f, 0.03435209f, -0.00803984f, 0.04235461f, -0.05069548f, 0.04160755f, 
    -0.01453377f, -0.05499299f, -0.03642792f, 0.05819493f, -0.05052337f, 0.03766462f, -0.05597069f, -0.05581026f, 
    0.03858141f, 0.03095847f, 0.01913496f, 0.02841721f, 0.01412920f, -0.00823515f, -0.05538135f, 0.03244706f, 
    -0.02977948f, 0.02476879f, 0.04911241f, -0.04909369f, -0.06620254f, -0.00735855f, -0.02509470f, 0.00131496f, 
    0.01287694f, 0.01667742f, 0.05461474f, 0.00588363f, 0.00385811f, -0.08239265f, 0.01086830f, -0.04880637f, 
    0.02539997f, -0.03456556f, -0.07826252f, -0.04752005f, 0.02596654f, -0.05827463f, -0.06598186f, -0.04578456f, 
    -0.03253944f, 0.02082856f, -0.06055814f, 0.00933327f, -0.01037495f, 0.00249468f, -0.03386628f, -0.02420030f, 
    -0.04110654f, 0.04243994f, -0.00437652f, 0.00416191f, -0.06645922f, 0.05971233f, -0.06896325f, -0.03441761f, 
    -0.00234167f, -0.03885785f, 0.04942507f, -0.03720247f, 0.02545963f, -0.05266300f, 0.01931996f, 0.02695272f, 
    0.05145342f, 0.02020969f, -0.01921489f, -0.03528271f, -0.03594428f, 0.05668437f, -0.00830662f, -0.06970473f, 
    -0.05033960f, 0.03781997f, 0.05470747f, 0.03739325f, -0.01268617f, -0.04911060f, -0.02039594f, -0.07986701f, 
    0.13581479f, 0.02437484f, 0.03346182f, 0.12926620f, -0.12658833f, -0.06473364f, 0.02175133f, 0.00871232f, 
    0.21352933f, -0.10253997f, -0.05876392f, 0.15701580f, -0.16856374f, -0.13361935f, -0.16298029f, 0.18794942f, 
    -0.14858796f, -0.00793482f, -0.07049412f, -0.04648590f, 0.16518332f, -0.04296488f, -0.03540127f, 0.21603833f, 
    0.14270647f, 0.16238476f, 0.21028678f, 0.21106347f, 0.16423161f, 0.11686144f, 0.06395022f, -0.03538234f, 
    -0.04153176f, 0.04743807f, 0.06419889f, 0.01451924f, 0.04785325f, -0.13513695f, 0.10373684f, -0.10402549f, 
    0.13359430f, -0.09482282f, -0.13657723f, -0.06549601f, -0.02429754f, 0.08944812f, 0.03409981f, 0.20210455f, 
    -0.27105668f, -0.36651468f, 0.20777774f, 0.10629597f, 0.01223023f, -0.11649483f, 0.16166703f, 0.05173407f, 
    0.09141959f, 0.16434401f, -0.01572007f, -0.00871656f, -0.40073022f, 0.11907712f, -0.07796637f, -0.31956023f, 
    0.02405401f, 0.13118085f, 0.13209724f, 0.13939403f, 0.09971394f, 0.05865124f, -0.08263233f, -0.17258961f, 
    -0.11733212f, 0.21506947f, -0.18503621f, -0.10079671f, 0.04524111f, 0.02033378f, -0.00055389f, -0.25385395f, 
    0.10071132f, 0.01709975f, -0.00843377f, 0.04145009f, -0.08638778f, 0.02391011f, -0.06187803f, 0.14396548f, 
    -0.13472429f, 0.08535041f, -0.01978987f, -0.05530446f, 0.05345830f, -0.18569219f, -0.02741657f, -0.03060454f, 
    -0.20195712f, -0.19237596f, 0.34882569f, 0.12801301f, -0.01035448f, -0.05676054f, -0.03743756f, 0.05937207f, 
    0.20251535f, -0.06028095f, -0.09731868f, -0.01073120f, -0.06292424f, 0.13107376f, 0.06761814f, 0.20966224f, 
    0.11317174f, -0.05524995f, 0.06680708f, -0.03705269f, -0.08677306f, -0.10428474f, 0.13260968f, -0.04940773f, 
    0.03075419f, 0.27384529f, 0.05067177f, -0.15309398f, -0.01681423f, -0.17791846f, -0.06402497f, 0.06302845f, 
    -0.05889312f, 0.00015552f, 0.03757156f, -0.19354184f, 0.39445126f, 0.32191896f, 0.16079445f, 0.00619534f, 
    0.14707312f, 0.25078845f, 0.11261518f, 0.02923063f, 0.13259740f, 0.13877529f, 0.00525741f, 0.18050772f, 
    -0.12781695f, -0.04033488f, -0.11569774f, 0.10669201f, 0.01329097f, -0.00589056f, -0.10802989f, -0.04713794f, 
    -0.17941839f, -0.16449615f, -0.18774273f, -0.15800731f, -0.18787627f, -0.02658549f, 0.22302878f, 0.13952935f, 
    -0.10098274f, 0.06556913f, -0.05430306f, -0.06800133f, 0.01261188f, 0.05083036f, 0.11903977f, 0.23276630f, 
    -0.02751983f, -0.25396112f, -0.46652144f, -0.12104957f, 0.12094986f, 0.00420668f, -0.33884886f, 0.18947454f, 
    -0.06520963f, 0.03815454f, 0.00079500f, 0.02006152f, 0.31021225f, 0.02867007f, 0.10932356f, -0.13571568f, 
    0.00757807f, 0.23038313f, -0.09362102f, 0.07789204f, -0.07006827f, 0.08255448f, -0.07661837f, 0.04137333f, 
    -0.31837678f, 0.27877900f, -0.10520210f, 0.47054723f, 0.07873115f, -0.06522840f, 0.02028022f, 0.16793807f, 
    -0.04972045f, -0.01941973f, -0.01987509f, -0.07394065f, -0.16454555f, 0.09173349f, 0.23692605f, -0.12272710f, 
    0.03921925f, -0.10368685f, -0.02661289f, 0.04762258f, -0.02020058f, 0.11985925f, 0.14703019f, 0.13264079f, 
    0.46921304f, 0.00706865f, -0.13520050f, 0.08601573f, -0.01443542f, 0.13360670f, 0.12542450f, 0.09014904f, 
    0.03657249f, 0.04835720f, -0.19903192f, -0.09806921f, 0.13726158f, -0.23582120f, 0.01975529f, -0.29522485f, 
    0.01946365f, -0.09624806f, 0.07787291f, 0.00198435f, -0.00262676f, -0.10055242f, -0.03132132f, -0.18754812f, 
    0.48761877f, 0.14659308f, 0.02472490f, -0.06884773f, 0.09306917f, 0.05708375f, -0.02154445f, 0.01507148f, 
    0.00678042f, 0.04984381f, 0.06948712f, 0.07382901f, -0.12747277f, 0.16280036f, 0.19284098f, 0.37332025f, 
    0.05978969f, -0.02782982f, -0.03534865f, 0.11006971f, -0.06709161f, 0.08912209f, 0.20234914f, 0.01215962f, 
    -0.09545428f, 0.20424840f, 0.28208798f, 0.25998774f, -0.00339059f, -0.08470984f, 0.13812830f, 0.13069998f, 
    -0.10757437f, 0.13903503f, 0.14990483f, 0.02834959f, 0.20816594f, -0.23704778f, 0.28629336f, -0.33090019f, 
    -0.08317015f, 0.05081111f, -0.01381171f, -0.02321393f, 0.15885119f, 0.22165266f, 0.20885453f, 0.15490064f, 
    -0.08622969f, 0.26581833f, -0.40830684f, -0.18869147f, -0.11183537f, -0.01949630f, -0.09917628f, 0.16301304f, 
    0.08537632f, 0.00674843f, 0.20156476f, 0.19025077f, 0.15196653f, -0.06862350f, 0.01559747f, -0.18616107f, 
    -0.05033034f, 0.02285935f, 0.13445972f, 0.08080218f, 0.08646743f, 0.21523878f, -0.07324821f, -0.11511856f, 
    -0.05672023f, -0.02700708f, -0.03319761f, 0.21276151f, -0.07198416f, 0.02507487f, 0.13404579f, 0.01262980f, 
    -0.03846392f, -0.05335908f, 0.01676624f, 0.30934665f, -0.34014529f, -0.13467397f, -0.02440107f, 0.10439350f, 
    -0.09074982f, -0.04260358f, -0.11646762f, 0.01113435f, 0.00321734f, -0.02920666f, -0.00390501f, -0.06898052f, 
    -0.14447369f, -0.07924756f, -0.13593318f, -0.14070286f, -0.10050463f, -0.09115995f, 0.01338407f, -0.03016948f, 
    0.14427446f, 0.08227308f, 0.09884405f, -0.03906539f, -0.04154785f, -0.08477726f, -0.19604552f, 0.06976764f, 
    0.02991492f, -0.12608021f, 0.06011666f, 0.02915124f, 0.10229383f, -0.00978226f, -0.07027428f, 0.04490341f, 
    -0.04396420f, 0.47609103f, 0.16694669f, 0.25282401f, 0.10024282f, 0.10664225f, -0.04188364f, -0.04140975f, 
    0.00628592f, -0.09372458f, 0.00292715f, 0.04672652f, -0.37711447f, -0.21739735f, -0.00922635f, 0.34485173f, 
    0.01718514f, 0.08431617f, 0.02933086f, -0.09481166f, -0.00023558f, 0.07748988f, 0.08491365f, 0.02885919f, 
    0.20333433f, -0.16259749f, 0.35553321f, 0.23950963f, 0.15152654f, 0.01766669f, -0.07819621f, -0.00424809f, 
    -0.29326478f, -0.04799058f, -0.14495930f, -0.17089354f, 0.16976528f, 0.17133160f, 0.18901601f, -0.20106481f, 
    -0.10597491f, -0.15906471f, -0.08116010f, 0.12614267f, 0.11260685f, 0.03017854f, 0.14248012f, 0.05506194f, 
    -0.14721328f, -0.19767492f, -0.12268800f, -0.10789344f, 0.26806533f, 0.17855757f, 0.11992082f, 0.06150159f, 
    0.02310455f, -0.17160851f, -0.20727932f, -0.03114149f, -0.15908805f, 0.16292934f, -0.22874634f, 0.01105867f, 
    0.23584169f, -0.06730595f, 0.05909686f, -0.05762735f, -0.35555330f, -0.24100742f, -0.22224076f, -0.36232001f, 
    0.14876950f, 0.37748706f, -0.48036829f, -0.00926587f, -0.00123406f, 0.17436992f, 0.13056369f, -0.01607182f, 
    0.10260896f, 0.06938947f, 0.11979160f, 0.30497196f, 0.16124769f, 0.12842464f, 0.32555339f, 0.39872682f, 
    0.05703401f, -0.09155601f, 0.13537583f, 0.12174552f, 0.08616814f, -0.02643846f, 0.05148531f, 0.29438141f, 
    0.26155704f, -0.11544148f, 0.14711136f, -0.11053156f, 0.08185706f, -0.00680298f, -0.17562510f, -0.07278182f, 
    0.05631398f, -0.09229188f, -0.05255051f, -0.00968771f, 0.04998076f, 0.06304429f, -0.19402355f, 0.00235245f, 
    0.10607493f, -0.00697115f, 0.03298208f, 0.01279155f, 0.38745052f, 0.25928217f, 0.15706436f, 0.18105200f, 
    -0.08568843f, 0.00593653f, -0.06866503f, 0.37124619f, 0.01504071f, 0.01993612f, 0.03574646f, 0.00553683f, 
    0.13775098f, 0.11183360f, 0.24671137f, 0.23330320f, -0.16199157f, -0.27233380f, -0.15696430f, -0.04828252f, 
    0.22771436f, -0.04004633f, 0.07345542f, 0.22682272f, 0.05710999f, 0.13220793f, -0.12131269f, 0.06855741f, 
    -0.13639033f, -0.22291134f, 0.04977385f, -0.01782477f, -0.03083024f, 0.25349697f, -0.04646626f, 0.02338130f, 
    0.08409030f, 0.07738142f, 0.00713367f, 0.41997290f, -0.19264036f, -0.01658883f, -0.01802794f, -0.12732825f, 
    0.06717972f, -0.01457632f, -0.03887657f, -0.03229990f, -0.05321466f, -0.09356503f, -0.07093792f, -0.12032606f, 
    -0.01888586f, -0.16652247f, 0.05479055f, -0.08670535f, 0.07365446f, 0.13377605f, 0.13996495f, 0.09920862f, 
    0.30945534f, 0.20699835f, 0.07857043f, 0.36019766f, -0.02114702f, -0.03203336f, -0.00294960f, 0.11067160f, 
    0.16454108f, -0.18716091f, -0.14703462f, -0.17713252f, -0.16930161f, -0.15002781f, -0.19091289f, -0.04488335f, 
    -0.38364878f, -0.03622647f, 0.32868063f, -0.41435808f, 0.01066485f, -0.06736398f, 0.12038381f, -0.00827765f, 
    -0.06791315f, -0.00331905f, 0.02701496f, -0.05477213f, -0.12900905f, 0.14776497f, 0.10259265f, 0.11408931f, 
    0.18695596f, 0.03513499f, 0.03635945f, 0.13350794f, 0.12827264f, 0.09504302f, 0.08974513f, 0.06154435f, 
    -0.06823494f, 0.04217440f, 0.03476753f, -0.01136385f, 0.01842082f, -0.05852302f, 0.01679487f, -0.09463862f, 
    -0.02187374f, -0.02539616f, 0.01139349f, -0.01983359f, -0.06800520f, 0.01897081f, -0.02029961f, 0.02522846f, 
    -0.00981625f, -0.06207230f, 0.03403946f, -0.01507578f, 0.00901224f, -0.02578083f, -0.03936850f, 0.04525816f, 
    -0.03386594f, 0.02002089f, -0.02370930f, -0.03006967f, 0.00781968f, 0.03082975f, -0.04378008f, 0.04447696f, 
    0.05436124f, 0.05752816f, -0.04155168f, 0.02339636f, -0.08497636f, 0.02558556f, -0.05058998f, -0.04420155f, 
    -0.00975152f, 0.00103427f, 0.01434454f, -0.00682192f, -0.01776284f, 0.02360048f, -0.01586087f, 0.01086066f, 
    -0.05973143f, 0.02897574f, 0.04648921f, -0.06687004f, 0.02121382f, -0.00661973f, -0.06131440f, 0.03704193f, 
    0.02819406f, 0.02767951f, -0.01987962f, -0.04822608f, -0.02866037f, 0.01271667f, 0.03020880f, -0.03820148f, 
    -0.06364705f, -0.03986174f, 0.03887065f, -0.06968927f, 0.06106862f, -0.04898752f, 0.00389339f, 0.04617047f, 
    0.04779604f, -0.04020488f, 0.02113525f, 0.05138239f, -0.08723949f, -0.03486532f, 0.01413477f, 0.03432859f, 
    -0.06317709f, -0.05408977f, -0.04925864f, -0.07226311f, -0.03215484f, 0.02789865f, -0.01425574f, 0.00217456f, 
    -0.02358446f, 0.03214411f, 0.02619664f, -0.08047898f, -0.04653860f, -0.07318921f, 0.05721935f, -0.06235548f, 
    0.00260112f, -0.00592938f, 0.00861747f, 0.05255410f, -0.03271354f, -0.00564694f, 0.04911009f, 0.02036222f, 
    0.03005798f, 0.06030309f, 0.02441706f, -0.06752025f, -0.01436158f, 0.04235546f, 0.04301657f, 0.00468852f, 
    -0.01127915f, -0.08511049f, 0.01529324f, -0.03491911f, 0.02463465f, -0.04381521f, 0.01620634f, 0.00279528f, 
    -0.00372473f, 0.01129035f, 0.04700614f, -0.03821363f, -0.05940081f, -0.06096783f, 0.03054979f, 0.00590418f, 
    -0.00161640f, 0.01958509f, -0.03952077f, -0.07214568f, 0.05168782f, -0.05373020f, 0.00964703f, -0.01112544f, 
    0.02003294f, -0.03121951f, -0.01693400f, 0.00085727f, -0.06602127f, 0.03870098f, 0.00735715f, -0.01949961f, 
    0.00373597f, 0.03370944f, -0.05361621f, 0.02923775f, -0.08747312f, -0.02132003f, -0.00250538f, -0.00315729f, 
    -0.06279770f, 0.00978508f, 0.06030925f, 0.00274540f, 0.05189846f, -0.05889276f, -0.05809374f, 0.00731086f, 
    0.02671830f, -0.07390230f, 0.04097189f, -0.01046069f, 0.02634094f, 0.01606045f, -0.00441755f, -0.09071521f, 
    -0.02421989f, 0.06912348f, -0.03057043f, -0.08115759f, -0.00664295f, -0.08748770f, 0.02539507f, -0.07489334f, 
    -0.05680335f, -0.04663718f, -0.04077544f, -0.06678652f, 0.03599210f, -0.03434601f, -0.02916437f, 0.01328594f, 
    -0.00251943f, -0.04937005f, 0.04348493f, -0.08087309f, -0.07783721f, 0.00120579f, -0.06723981f, -0.01579275f, 
    0.30279070f, -0.12587669f, 0.26482448f, -0.12655051f, 0.04653060f, -0.16585615f, -0.11773455f, -0.19161361f, 
    -0.08751465f, 0.13801081f, -0.21309797f, -0.13795045f, -0.15215579f, -0.06452836f, 0.02382583f, -0.15546879f, 
    -0.15251094f, -0.19307500f, -0.23529214f, -0.19650856f, 0.08220466f, 0.03588737f, 0.16858931f, -0.01793376f, 
    -0.11476646f, -0.13908111f, 0.06065807f, -0.16666624f, 0.21654911f, -0.03180615f, 0.04130383f, 0.13961530f, 
    0.05378537f, -0.16323026f, -0.09104650f, -0.04933477f, -0.21862657f, 0.20299779f, -0.17051139f, 0.16915046f, 
    0.16525112f, -0.01066387f, 0.02403357f, 0.11277408f, -0.16479008f, -0.10241749f, -0.31627390f, -0.39342025f, 
    -0.32109141f, 0.47095907f, -0.54507041f, -0.01150878f, 0.23799086f, -0.04915276f, 0.03599312f, -0.22605377f, 
    0.00116571f, 0.03866606f, 0.07964116f, 0.14560209f, 0.22674400f, -0.10789743f, 0.22064590f, 0.44831988f, 
    0.19135949f, -0.16748048f, 0.01828302f, 0.06313431f, 0.22344331f, -0.02119053f, -0.01961989f, 0.17701888f, 
    0.01517409f, -0.03707150f, -0.05660894f, -0.24690597f, 0.09010929f, 0.29285893f, -0.03673327f, -0.21432251f, 
    0.09986154f, -0.10943178f, -0.01665114f, -0.05934542f, 0.08948243f, 0.11970323f, -0.11268017f, 0.01079802f, 
    0.18584467f, -0.01795172f, -0.02718643f, 0.01820876f, 0.23695360f, 0.09991647f, 0.14225537f, -0.10009795f, 
    0.15846911f, 0.10577040f, -0.13652286f, 0.35177520f, -0.00714607f, 0.04861439f, 0.24394786f, -0.06199940f, 
    0.12736236f, 0.09123015f, 0.00749270f, 0.17153840f, -0.04685174f, 0.13358057f, 0.05389370f, -0.12696478f, 
    0.09980302f, 0.05698865f, -0.04245334f, 0.33211491f, 0.12237494f, -0.01381159f, 0.02177989f, -0.10171908f, 
    -0.16876698f, -0.14952782f, 0.17756125f, -0.15949790f, -0.12323533f, 0.11386152f, 0.06958269f, 0.10718859f, 
    0.09479733f, 0.15913178f, -0.02773585f, 0.20877300f, -0.16398945f, -0.04739441f, -0.00684923f, 0.05246716f, 
    0.10575563f, 0.05577002f, -0.01090820f, 0.25861487f, -0.05445634f, 0.02365412f, 0.08000802f, -0.10484966f, 
    0.13474819f, -0.01897285f, 0.15724209f, -0.11215807f, -0.07990109f, -0.01526998f, 0.24061355f, -0.02444643f, 
    0.19944729f, 0.12604983f, 0.00612882f, 0.10056137f, 0.05763756f, -0.03873905f, -0.15551086f, -0.16534179f, 
    0.18720794f, -0.09293376f, -0.20760423f, -0.37739605f, -0.05059551f, -0.01449788f, -0.26288265f, 0.06677645f, 
    -0.35487428f, -0.51941365f, 0.48558682f, -0.25612110f, -0.01605385f, 0.10412252f, 0.16612497f, -0.04105344f, 
    -0.13972841f, -0.10826953f, -0.00498815f, -0.03578882f, -0.06468571f, 0.16943635f, 0.30643469f, 0.00303129f, 
    0.00896167f, 0.03812222f, 0.01538981f, 0.16025588f, 0.10280281f, -0.01154170f, 0.00828199f, -0.09302289f, 
    0.08648950f, -0.00663063f, 0.19279890f, 0.14436427f, 0.14828156f, -0.04011872f, -0.13604452f, -0.03007535f, 
    0.06828289f, -0.01115719f, -0.11398552f, 0.13304774f, -0.03265709f, 0.23520073f, -0.02572549f, -0.05361915f, 
    -0.00706581f, -0.05743976f, -0.08494720f, -0.00585089f, 0.05224842f, 0.03195032f, 0.07437333f, 0.05166020f, 
    0.39813092f, -0.03313051f, 0.22395153f, -0.10651276f, 0.14800563f, 0.12764728f, 0.01218122f, 0.03069114f, 
    0.04934329f, -0.07328361f, -0.16658731f, -0.03781049f, 0.11641727f, 0.20470342f, -0.10698744f, -0.19116867f, 
    0.27711922f, 0.17564182f, -0.01041677f, 0.10211977f, -0.14664739f, 0.00142178f, -0.21088146f, -0.03026113f, 
    -0.01078275f, 0.01487610f, -0.23604107f, 0.00870711f, -0.06904636f, 0.11859018f, 0.34525046f, -0.08040775f, 
    -0.11477040f, 0.10001182f, 0.33334786f, 0.02067128f, -0.02363442f, -0.16117001f, 0.10754865f, -0.21296886f, 
    -0.01496593f, -0.26392150f, 0.04968800f, -0.02016693f, 0.21022089f, -0.03863461f, 0.05812167f, 0.30152470f, 
    -0.27239612f, 0.25938588f, -0.19136143f, -0.02684944f, 0.03445780f, -0.05646265f, 0.10830361f, -0.13897809f, 
    0.15312086f, -0.18471918f, 0.06774263f, -0.04015341f, 0.29962999f, 0.16853409f, 0.14407749f, 0.03743954f, 
    -0.05365955f, 0.01817341f, 0.15102835f, -0.00656392f, 0.26184785f, 0.08498830f, 0.15706451f, 0.04755140f, 
    0.40077174f, -0.05433341f, 0.11868016f, 0.20122969f, 0.01865456f, 0.02754319f, -0.00083416f, -0.03057459f, 
    0.09824687f, 0.05645933f, 0.32393628f, 0.15295178f, 0.22113128f, 0.16146459f, -0.04845256f, 0.07766959f, 
    0.02785664f, -0.07668928f, 0.09103276f, 0.03389670f, 0.01814069f, 0.05229624f, -0.08871474f, -0.10145654f, 
    -0.08177924f, -0.08324847f, 0.06496302f, -0.15306033f, -0.13339502f, 0.00537593f, 0.14734460f, 0.09721424f, 
    0.06986585f, -0.07691295f, 0.12021810f, 0.26902393f, -0.12763326f, -0.30297124f, 0.17521921f, -0.00071410f, 
    0.05265048f, -0.13820040f, -0.19430304f, -0.05106829f, 0.08957066f, 0.00965647f, -0.03737794f, -0.01630319f, 
    0.20632228f, 0.16127801f, -0.02054635f, -0.03237817f, 0.04922808f, 0.04621961f, 0.08067561f, 0.05098109f, 
    0.21040359f, 0.12139399f, 0.15265606f, 0.04386275f, 0.14206052f, 0.09900963f, -0.03416944f, 0.01542151f, 
    0.17904910f, -0.07190912f, -0.01032641f, -0.12138942f, 0.05527454f, -0.19570094f, -0.05678943f, 0.05958769f, 
    -0.64595693f, -0.29355210f, -0.30965212f, 0.04534807f, -0.06779756f, -0.14853691f, 0.08149997f, 0.17296726f, 
    -0.13193181f, -0.01348868f, -0.10716961f, 0.04407917f, -0.21046057f, 0.15496321f, 0.27326810f, 0.12923571f, 
    0.00467736f, 0.22746749f, 0.03674659f, 0.03926087f, 0.01895614f, 0.19644713f, 0.13754267f, -0.03060887f, 
    0.36189827f, 0.08672795f, 0.06421692f, -0.10574534f, -0.10824214f, -0.12560003f, -0.02502302f, -0.05972126f, 
    0.12932958f, 0.03682198f, -0.04330802f, 0.08951668f, -0.09838691f, -0.12807605f, -0.20271803f, -0.09153592f, 
    -0.01035701f, 0.02861963f, 0.05948240f, -0.05098477f, 0.11611681f, -0.09008458f, 0.09631643f, 0.03103079f, 
    -0.38194314f, 0.07745793f, -0.12190431f, 0.02992590f, 0.02745256f, -0.08029570f, -0.00459452f, -0.02333213f, 
    0.04065331f, 0.07320870f, 0.14869355f, 0.04938406f, -0.17761579f, 0.06133284f, -0.03469842f, 0.11722387f, 
    -0.04383036f, 0.06406543f, -0.11212385f, 0.01721382f, 0.14102525f, 0.03351623f, 0.05921781f, 0.15357691f, 
    -0.18813755f, 0.07113422f, -0.13429819f, 0.08851912f, -0.09060194f, 0.09868696f, -0.03995360f, 0.36144394f, 
    0.00394400f, -0.01594626f, -0.07426856f, 0.00344312f, 0.20289212f, -0.25847632f, -0.36694247f, -0.12208429f, 
    0.28507644f, -0.03168461f, 0.23343192f, 0.05957701f, -0.06419028f, -0.02840780f, -0.07886960f, 0.03418827f, 
    -0.04140931f, -0.25040138f, 0.05010119f, 0.10029943f, -0.00173722f, 0.25872990f, -0.01260034f, 0.11818285f, 
    0.36628160f, 0.06722632f, -0.00997471f, 0.11583024f, -0.09563068f, 0.22278252f, 0.01675915f, 0.14038149f, 
    -0.03010898f, 0.00888684f, -0.02418931f, -0.01191737f, 0.00393380f, -0.13302042f, -0.17209204f, -0.28645295f, 
    0.38814864f, -0.02817050f, 0.10772556f, -0.00398461f, -0.05089368f, -0.10704881f, 0.04141864f, -0.11341035f, 
    -0.02570388f, 0.20188829f, -0.05865814f, -0.18472293f, -0.08731347f, 0.12993948f, 0.11370946f, -0.05825323f, 
    0.01809105f, -0.08898477f, -0.14192580f, -0.13016488f, -0.02284012f, 0.09129310f, 0.02747048f, 0.12498014f, 
    0.02657494f, -0.16052653f, 0.08010536f, 0.03431945f, 0.13979156f, -0.00772426f, 0.05303580f, 0.19005258f, 
    -0.14222167f, -0.18878461f, -0.10835077f, -0.32618347f, 0.12052135f, -0.08908995f, -0.17260708f, 0.16027281f, 
    0.14864711f, 0.12493167f, 0.23695713f, 0.02639201f, -0.00250833f, 0.11192138f, -0.03124538f, 0.14273842f, 
    -0.03827178f, 0.18779947f, 0.11446424f, -0.10640774f, -0.09107817f, -0.02604180f, -0.14925678f, -0.16768457f, 
    -0.11641820f, -0.12096002f, -0.00790549f, -0.23133975f, 0.13495186f, 0.04596711f, 0.10122155f, -0.21739866f, 
    -0.05701657f, -0.08864744f, -0.11186502f, -0.00878485f, -0.06546302f, 0.13925248f, 0.08115781f, 0.29242942f, 
    -0.02697810f, -0.08454469f, 0.09806511f, 0.00884687f, -0.02788747f, 0.16200189f, 0.27666542f, -0.18524499f, 
    0.08339155f, 0.11347651f, 0.04168968f, 0.13743733f, 0.22337265f, 0.53642565f, -0.11966034f, -0.08526981f, 
    0.09578896f, -0.12401865f, 0.19018582f, 0.03890934f, -0.01216002f, 0.03812870f, -0.10204464f, -0.00719334f, 
    -0.01790477f, -0.13095994f, 0.15891367f, 0.31941622f, 0.18828015f, 0.07143034f, 0.00061454f, 0.17376862f, 
    -0.07466994f, -0.00988875f, -0.21206422f, -0.11537281f, 0.26013315f, 0.49079832f, 0.06159759f, -0.08166884f, 
    -0.12277088f, 0.03047585f, -0.14113085f, -0.03183882f, 0.16385591f, -0.19163261f, -0.05825343f, -0.02568188f, 
    -0.25339910f, -0.28099510f, -0.09015261f, 0.29344037f, -0.01439278f, 0.38592103f, 0.06192780f, -0.05571983f, 
    0.09673457f, -0.01843022f, -0.14385563f, -0.00686547f, -0.21509770f, -0.07206878f, -0.11068165f, 0.15016070f, 
    0.22616819f, -0.04790231f, -0.01881361f, 0.03551544f, -0.07638562f, 0.05046725f, -0.00641309f, -0.19706348f, 
    0.15924935f, -0.04520168f, -0.08505213f, 0.16966332f, 0.01633779f, -0.14466675f, 0.02046366f, 0.06518441f, 
    0.05214508f, 0.00562735f, 0.11223657f, 0.05567715f, -0.12133309f, 0.16064093f, 0.02857618f, 0.03874569f, 
    -0.01876138f, 0.14999913f, 0.11227709f, 0.35942918f, 0.18051343f, 0.08196922f, -0.08671778f, -0.01942512f, 
    0.25399926f, 0.41100866f, 0.02997699f, 0.16138624f, 0.12397836f, -0.29281753f, 0.07704268f, 0.08678566f, 
    -0.02289542f, -0.01063218f, -0.11523239f, 0.00147903f, 0.16824947f, -0.12796268f, -0.06125806f, -0.10330109f, 
    0.02906075f, -0.03942010f, 0.04334140f, -0.11914992f, 0.32796177f, 0.02893789f, 0.09608369f, 0.06422074f, 
    -0.18499087f, -0.30654413f, 0.01388561f, -0.12059622f, -0.14779341f, 0.00149692f, -0.17881745f, -0.00084273f, 
    -0.03064230f, -0.00320987f, -0.15275535f, 0.23927101f, -0.37552884f, -0.60307986f, -0.15290175f, 0.10697135f, 
    0.19621155f, -0.09834480f, 0.25506476f, 0.02160803f, 0.12308994f, -0.03059611f, 0.03625866f, 0.02060294f, 
    -0.08377193f, 0.01142786f, -0.01479786f, 0.17737497f, 0.02052380f, 0.20432930f, 0.25548884f, 0.05579012f, 
    -0.01846372f, 0.08132131f, -0.12457590f, 0.27775896f, 0.20608050f, 0.29219604f, 0.23281826f, 0.08883572f, 
    -0.09112708f, 0.08685762f, -0.06525795f, -0.04244985f, 0.09953384f, -0.01338469f, 0.13775836f, -0.02653396f, 
    -0.17415056f, -0.22855948f, -0.35657150f, 0.11156984f, 0.28716090f, -0.18509418f, 0.08999051f, 0.05532303f, 
    0.08266737f, 0.07046814f, -0.01199307f, 0.24569474f, -0.18548228f, -0.25251746f, 0.17415227f, 0.07265361f, 
    0.08199021f, 0.08040852f, 0.01088256f, -0.03384473f, -0.22540180f, -0.07429355f, 0.11313367f, -0.09351768f, 
    -0.41913882f, 0.28378808f, -0.18501814f, -0.10901386f, -0.04634987f, 0.12959786f, -0.18808980f, 0.04415617f, 
    0.10134327f, -0.00536038f, 0.00767974f, -0.02818094f, 0.17688502f, -0.02390480f, 0.09231439f, 0.08053819f, 
    0.12107245f, 0.13231403f, -0.26615518f, 0.00558711f, 0.09991672f, -0.03797603f, 0.05878377f, 0.08983225f, 
    0.19764648f, -0.52538550f, 0.10800059f, -0.38005081f, -0.13153340f, 0.16986124f, 0.10920288f, -0.03568694f, 
    0.01667853f, -0.01976236f, 0.00748232f, -0.09332278f, 0.52006751f, -0.12113944f, 0.34034571f, 0.09434710f, 
    -0.25208849f, -0.20647414f, -0.17736448f, -0.29043800f, 0.11998367f, 0.10588130f, -0.05002442f, 0.11178539f, 
    -0.12419283f, 0.03561657f, -0.26546997f, -0.01456455f, 0.22576429f, -0.03180449f, 0.00008929f, 0.13726208f, 
    -0.08663780f, -0.10488790f, -0.06955438f, 0.07751471f, -0.22404668f, -0.18915576f, -0.03828266f, -0.05922187f, 
    -0.02077666f, -0.02646740f, 0.17710754f, -0.00070509f, -0.07134242f, -0.00186774f, -0.05599141f, -0.19677554f, 
    -0.32170501f, 0.15410535f, 0.00971988f, -0.31601551f, -0.00954409f, 0.03920878f, 0.04347647f, 0.00052733f, 
    0.21130402f, 0.29565945f, 0.14169024f, 0.17737246f, -0.05750405f, 0.28435051f, 0.34527010f, 0.16982783f, 
    -0.18185328f, 0.14235479f, -0.31422192f, 0.04465121f, 0.18428370f, 0.09000733f, 0.08313859f, 0.01781569f, 
    0.38750833f, -0.07520613f, 0.13439451f, -0.22161825f, -0.14348628f, 0.07030516f, -0.10960911f, 0.15699881f, 
    0.02773200f, 0.06347021f, 0.09898981f, -0.00296462f, -0.33021232f, 0.09540302f, -0.19086556f, 0.27742168f, 
    0.14163816f, -0.08707986f, 0.06727614f, -0.02456500f, -0.04262654f, 0.06979399f, 0.13193052f, 0.20930402f, 
    -0.31046852f, -0.02018201f, 0.17679638f, 0.42880747f, 0.10269600f, 0.07178440f, 0.01549612f, -0.12480213f, 
    0.14739570f, -0.02062776f, 0.05038405f, 0.07848286f, -0.23949894f, -0.26412648f, 0.10415100f, 0.24777508f, 
    0.12769593f, 0.33919004f, 0.01698933f, 0.07515051f, 0.12814359f, -0.03351139f, 0.01434236f, 0.16094559f, 
    0.01752332f, 0.20271400f, 0.05882618f, -0.16729300f, 0.10961607f, 0.17596775f, -0.08019377f, -0.02965960f, 
    0.19119389f, 0.09062956f, 0.12056331f, -0.08014644f, 0.06675339f, 0.28132480f, -0.00382611f, -0.23814581f, 
    0.14283486f, 0.06014837f, 0.26013309f, 0.28402311f, -0.04600551f, -0.08553654f, 0.04588890f, -0.05064475f, 
    -0.05330507f, -0.15274698f, 0.10699918f, 0.16465926f, 0.07772963f, -0.02253314f, -0.02534425f, -0.18520601f, 
    -0.00020194f, -0.15307237f, 0.03241831f, 0.22154409f, -0.11298227f, 0.10963164f, 0.15840374f, 0.21123479f, 
    -0.00071159f, 0.22596736f, -0.03030654f, -0.11188422f, -0.05060099f, 0.19731905f, 0.01168239f, -0.01755056f, 
    1.16299057f, -0.69077826f, 0.16310029f, -0.47320589f, -0.04321004f, 0.10110946f, -0.06969255f, 0.08274566f, 
    0.21824662f, -0.07910750f, 0.05596866f, 0.20259956f, 0.16015460f, -0.37330836f, 0.17582552f, -0.20278692f, 
    0.15080896f, 0.11431485f, 0.17657411f, 0.19140512f, 0.11559721f, -0.01181845f, 0.07690870f, 0.06240800f, 
    -0.06373808f, -0.60755122f, 0.18436293f, -0.41602194f, 0.10514176f, 0.18313825f, 0.03679170f, -0.14440604f, 
    -0.15919824f, 0.02262197f, -0.08669280f, -0.11473412f, 0.27971414f, -0.14579584f, -0.00781592f, -0.04002105f, 
    0.21242265f, 0.20022647f, 0.01435127f, -0.00190885f, -0.01381841f, 0.00681760f, 0.05809999f, -0.00931431f, 
    -0.07090181f, -0.22569805f, -0.39874396f, -0.06520233f, 0.02661935f, 0.09968199f, 0.04521870f, -0.10019418f, 
    0.19017035f, 0.02131843f, -0.07803669f, -0.06586517f, -0.09135201f, -0.01520533f, 0.07588525f, 0.06104961f, 
    -0.01050136f, 0.05099327f, 0.24899176f, 0.15954462f, -0.02022460f, -0.06024904f, -0.17880541f, -0.31935731f, 
    -0.21657112f, 0.15285879f, 0.06718788f, -0.20318711f, -0.01016895f, -0.06882678f, 0.01934286f, -0.22163516f, 
    0.14875260f, -0.11858597f, 0.02157891f, 0.05849154f, 0.26910517f, 0.01515877f, 0.14937827f, 0.24596058f, 
    0.19466698f, 0.04175723f, -0.12882367f, 0.28064904f, -0.03345616f, 0.02090496f, 0.16216846f, 0.15345591f, 
    0.21505433f, 0.18213053f, -0.03465394f, 0.04271763f, 0.05556831f, 0.02086354f, -0.02393732f, -0.10894659f, 
    -0.11598056f, -0.11475618f, 0.12717883f, 0.00304128f, -0.33584806f, -0.00556969f, -0.16886531f, 0.02360836f, 
    0.07328317f, 0.06293163f, -0.04461788f, -0.08560108f, -0.04540144f, -0.05652581f, -0.02122083f, 0.21271493f, 
    -0.20645162f, -0.15763156f, -0.16649264f, -0.13284746f, -0.00543671f, -0.00122804f, -0.19652340f, -0.11021044f, 
    -0.06087708f, -0.21663149f, 0.02928511f, 0.14793204f, -0.41215536f, -0.45650944f, -0.12824310f, -0.27351767f, 
    -0.00038622f, 0.28781411f, 0.09902858f, -0.13121092f, 0.17787245f, 0.16196369f, 0.05805985f, 0.02177719f, 
    0.14956595f, 0.21712868f, 0.13433674f, 0.09479406f, -0.13071395f, -0.01711428f, 0.00481649f, 0.05491286f, 
    0.00715794f, 0.15793733f, 0.05694676f, 0.14431697f, 0.21047391f, 0.41631719f, 0.37106109f, 0.40690207f, 
    -0.05115671f, -0.07048927f, -0.02027536f, 0.35919726f, -0.00333627f, 0.12565976f, 0.09171636f, -0.07509427f, 
    -0.04925703f, -0.18727656f, -0.20294888f, -0.00601352f, 0.04611766f, 0.11805144f, 0.00772170f, -0.09678198f, 
    -0.09963663f, 0.08233151f, 0.04421241f, 0.15946165f, -0.03297654f, -0.07605247f, 0.09008744f, 0.14358191f, 
    0.02409719f, 0.04491000f, -0.08734996f, -0.12940317f, -0.04569997f, -0.04803111f, -0.08404804f, -0.02105966f, 
    0.46007538f, -0.26733741f, -0.02535167f, 0.02283098f, -0.03657515f, 0.20199141f, 0.04987352f, 0.35275647f, 
    -0.04549523f, 0.01908761f, 0.00093832f, 0.01981549f, -0.05934844f, -0.18541601f, 0.33293340f, 0.24921411f, 
    0.04339639f, 0.14219137f, -0.11377953f, 0.18218274f, 0.02765749f, -0.04979859f, 0.02674423f, 0.12661175f, 
    -0.02024523f, 0.00519178f, -0.05096336f, 0.01199659f, -0.05636636f, 0.00903166f, -0.07519326f, -0.03791281f, 
    0.05689931f, 0.05835092f, 0.03169828f, -0.06904542f, 0.05057405f, 0.04908466f, 0.03813032f, -0.04167077f, 
    -0.00991297f, -0.01045537f, -0.00644884f, 0.02474113f, 0.01042061f, -0.01939649f, -0.00749073f, 0.03655381f, 
    0.02370868f, -0.05944977f, 0.00167347f, 0.05085231f, -0.00891044f, 0.02309842f, -0.06594074f, -0.06315573f, 
    0.03749194f, 0.06275586f, 0.02789239f, 0.01466902f, 0.04345631f, 0.01060526f, -0.05284300f, -0.05736381f, 
    0.02458229f, -0.01847888f, 0.01724147f, -0.06355575f, 0.05455121f, -0.07694781f, 0.02814519f, -0.02329886f, 
    -0.05602985f, 0.00805753f, 0.04698320f, -0.04184511f, 0.00976534f, 0.05880835f, -0.03246333f, -0.06204258f, 
    -0.00794044f, -0.07505518f, 0.05257130f, -0.03422212f, 0.03693217f, -0.06297193f, -0.01751617f, 0.06291372f, 
    -0.04640099f, 0.01404919f, 0.02431510f, 0.00449012f, 0.00286930f, -0.07588436f, -0.05623084f, 0.03037027f, 
    -0.06836683f, -0.05673308f, -0.04604280f, 0.02807488f, 0.04506103f, -0.01697575f, -0.05962706f, 0.02077291f, 
    0.01656497f, -0.05274954f, -0.03095234f, -0.04507633f, 0.04123759f, -0.00244910f, 0.06848416f, -0.02251429f, 
    -0.03884470f, -0.03498481f, -0.03088683f, 0.02344562f, -0.00667902f, -0.06384703f, 0.06828730f, 0.03701033f, 
    -0.06903085f, 0.05682379f, 0.02206665f, -0.03468542f, -0.02568134f, 0.03038468f, -0.02196389f, -0.04007661f, 
    -0.00172181f, -0.02819869f, 0.00635371f, 0.04502099f, -0.05590172f, -0.06962883f, -0.03822028f, 0.01026521f, 
    -0.05259960f, -0.01977181f, -0.04029580f, 0.00244942f, 0.02532359f, 0.05552040f, 0.06275818f, 0.02533847f, 
    0.04888837f, 0.06101410f, 0.04089251f, -0.06360836f, -0.04140839f, -0.01003443f, -0.01677033f, 0.01055243f, 
    -0.00659397f, -0.00601120f, 0.03317425f, 0.00167360f, -0.01585071f, -0.04810360f, 0.04889755f, 0.00536780f, 
    -0.00823395f, -0.02020183f, -0.06616023f, -0.05061164f, 0.04166046f, 0.00708808f, 0.00986114f, -0.02915801f, 
    -0.05847378f, 0.03810606f, 0.03745688f, -0.05937791f, 0.00378911f, -0.06829864f, -0.01541881f, 0.02440820f, 
    0.02632105f, -0.04453447f, 0.03586999f, -0.01364424f, 0.03377674f, 0.04346797f, -0.00381111f, -0.01537567f, 
    -0.06329428f, 0.06501801f, 0.02548490f, -0.04523330f, -0.04995263f, -0.07504706f, -0.03894648f, -0.07215272f, 
    0.02767850f, 0.06469338f, -0.06296088f, -0.04356837f, -0.05194144f, 0.01935086f, -0.01836952f, 0.01236703f, 
    -0.03950192f, 0.05117173f, -0.03701133f, -0.06890731f, 0.00915517f, -0.07492901f, -0.04874236f, -0.00091408f, 
    0.00056244f, -0.03885934f, -0.06033995f, 0.01105473f, 0.04186851f, 0.01928337f, 0.04062080f, -0.05383030f, 
    -0.28334343f, -0.49792057f, -0.09571074f, -0.48777810f, 0.12385478f, -0.01599358f, 0.17184679f, 0.06566963f, 
    0.10447622f, 0.07613742f, 0.00933607f, -0.02945786f, 0.16985266f, -0.09745307f, -0.38018677f, 0.09063379f, 
    -0.03019754f, -0.00459875f, 0.16143715f, 0.07468076f, -0.14913532f, 0.09267499f, -0.18558827f, -0.17503552f, 
    -0.05849906f, -0.07312558f, -0.10183730f, -0.04261706f, 0.03863047f, -0.15423608f, -0.23946665f, 0.17887925f, 
    0.00678341f, -0.11686816f, 0.09992354f, 0.11787120f, 0.04640615f, 0.08310551f, -0.09183972f, 0.20321320f, 
    0.01760850f, -0.07818497f, -0.02206221f, -0.08488216f, -0.15955873f, -0.00706705f, -0.08827267f, 0.02187488f, 
    -0.13345253f, -0.30519769f, 0.14512357f, -0.00433261f, 0.05137662f, 0.21266784f, -0.03674980f, 0.08863479f, 
    0.22377272f, 0.16683589f, 0.12750949f, 0.03958254f, -0.14431691f, 0.20862447f, 0.27870488f, -0.05223171f, 
    -0.02908479f, 0.40213072f, -0.03867793f, 0.02120689f, 0.14435747f, -0.09141362f, 0.02646657f, -0.22074138f, 
    0.19547464f, -0.03392987f, -0.09358684f, -0.14538784f, 0.09133063f, 0.05920279f, 0.18415926f, -0.01117630f, 
    -0.22491536f, -0.10210206f, 0.07276750f, -0.04617563f, -0.46727061f, -0.24825519f, -0.36673903f, 0.05430304f, 
    0.10975087f, -0.14247419f, -0.08941004f, 0.06024254f, -0.26760343f, 0.13701610f, -0.01468390f, 0.16177709f, 
    -0.53783166f, -0.43025541f, 0.07489223f, 0.09405089f, 0.08866995f, -0.04931374f, -0.05688697f, 0.15414223f, 
    0.17165262f, 0.07391381f, -0.10904287f, 0.02189496f, -0.06253478f, -0.19153734f, -0.04869833f, -0.07631683f, 
    0.10585842f, 0.07743747f, -0.12025377f, 0.10834891f, 0.04212479f, -0.03187646f, 0.15086727f, 0.11719383f, 
    0.06394930f, 0.25724170f, 0.15464211f, 0.01955635f, 0.20741296f, 0.26212227f, 0.04941207f, 0.09136699f, 
    0.05490933f, -0.03548822f, 0.00652804f, -0.04123000f, 0.16522926f, 0.24064724f, 0.24395169f, -0.13702479f, 
    0.11229479f, 0.07058235f, 0.33309832f, 0.02190119f, -0.09791137f, -0.11282101f, -0.02296196f, -0.04085723f, 
    -0.00485853f, -0.10494489f, -0.12387586f, 0.02800559f, 0.13573225f, -0.08734669f, -0.01930315f, 0.01508568f, 
    -0.17077164f, -0.15020607f, 0.08639968f, 0.11488679f, -0.19967231f, -0.00116461f, -0.18520926f, 0.02362950f, 
    -0.03397078f, 0.17506880f, 0.06102186f, 0.20386149f, -0.07603562f, -0.00741112f, 0.00019511f, -0.09676479f, 
    0.86170149f, -0.26353806f, -0.29568273f, -0.23512533f, 0.00193692f, 0.08789454f, 0.19200742f, -0.12069193f, 
    0.09596990f, -0.04485960f, -0.08740539f, -0.01515773f, 0.30841240f, -0.19484681f, 0.28817379f, -0.16402225f, 
    0.03855801f, -0.01007802f, 0.28672954f, 0.09185632f, -0.01257529f, -0.12327527f, -0.11573894f, 0.00105607f, 
    0.07893934f, -0.01289676f, 0.04628664f, -0.04536226f, 0.06027079f, 0.06092589f, -0.00173661f, -0.07964174f, 
    -0.04687981f, -0.09176712f, 0.01671457f, -0.06608805f, 0.04197822f, -0.05058538f, -0.06752930f, 0.05954093f, 
    0.05225226f, 0.01606053f, 0.01561647f, -0.03910725f, -0.08429206f, -0.01373251f, 0.03512350f, -0.05826303f, 
    -0.05273585f, 0.01127175f, 0.04714444f, 0.04860226f, -0.07918710f, -0.03792261f, -0.09233349f, -0.07883856f, 
    -0.00945490f, 0.04281858f, 0.00073624f, -0.01397527f, 0.02432680f, 0.07399716f, -0.06364121f, -0.04765306f, 
    0.02949646f, -0.00787445f, 0.00858910f, -0.06084564f, -0.03190366f, 0.01479868f, 0.01378443f, -0.02867947f, 
    -0.02016842f, -0.04610804f, -0.07978822f, -0.04252967f, 0.06288141f, 0.00823266f, 0.05056621f, -0.06539771f, 
    -0.02024774f, 0.00292887f, -0.08552289f, -0.00330928f, 0.06254044f, -0.01623326f, -0.04421173f, 0.06179196f, 
    0.02749961f, -0.03732255f, 0.04898101f, -0.07026114f, -0.05615402f, 0.02758676f, -0.00332175f, -0.00551521f, 
    -0.03969158f, -0.00823723f, -0.07928649f, -0.07002047f, -0.00766380f, -0.01692084f, -0.10535870f, -0.03688831f, 
    0.04758447f, 0.01804950f, 0.04037247f, -0.01250295f, -0.01616284f, -0.01045149f, -0.05558583f, -0.00312898f, 
    0.03679926f, -0.00295349f, 0.05708226f, 0.04116273f, 0.01497072f, -0.01233674f, -0.05185489f, -0.05358962f, 
    0.05880228f, -0.00580429f, 0.07141121f, -0.06102211f, -0.03317621f, 0.05459392f, -0.05300985f, 0.00562829f, 
    0.01143247f, -0.06894622f, -0.01755465f, -0.00641280f, 0.00253331f, -0.03542068f, 0.08030859f, 0.03338671f, 
    -0.06943570f, 0.00525586f, -0.05151081f, 0.00537297f, -0.00333764f, -0.06518745f, -0.05970362f, -0.05149822f, 
    0.05812968f, 0.05385039f, -0.01394135f, -0.07476592f, -0.03152499f, -0.00566791f, 0.04249187f, 0.05054964f, 
    0.03959182f, -0.01807782f, 0.02003715f, 0.05478147f, 0.04819852f, -0.03704163f, -0.07635343f, 0.05325254f, 
    0.05319246f, -0.08305097f, 0.03370945f, -0.07791310f, -0.03110927f, -0.00975327f, -0.03901055f, -0.04856551f, 
    -0.04084302f, -0.06836400f, 0.07011488f, 0.03063140f, -0.05042372f, -0.04337389f, -0.02764706f, 0.03628178f, 
    0.06205889f, -0.06924320f, 0.04759809f, -0.02817691f, -0.06332232f, 0.01400455f, -0.08803459f, -0.07867334f, 
    -0.08510158f, -0.02679332f, -0.02079755f, -0.08919738f, 0.00171836f, -0.03738100f, -0.05782137f, 0.00358630f, 
    -0.03859590f, -0.00207940f, 0.01198015f, -0.06321774f, -0.00684921f, 0.01840151f, -0.06903650f, -0.08858426f, 
    -0.01745955f, 0.04892098f, -0.00472869f, -0.02907438f, -0.06871766f, 0.05178655f, 0.01958667f, 0.05368641f, 
    -0.05542128f, 0.04383921f, -0.03349997f, 0.03555083f, -0.04881963f, -0.05961190f, -0.05316821f, -0.01660506f, 
    0.05021248f, -0.07274472f, 0.06149165f, 0.06243039f, -0.00719534f, -0.05998540f, 0.05896447f, 0.03424259f, 
    0.05544336f, -0.00808074f, -0.05148919f, -0.02994820f, -0.06866231f, 0.01250450f, -0.06072915f, 0.04758545f, 
    0.03757705f, 0.00436704f, -0.04284533f, -0.04382566f, 0.03667669f, -0.00383408f, 0.03914973f, -0.03972227f, 
    -0.06154761f, 0.05021933f, 0.05839727f, 0.01919536f, -0.06308070f, 0.02944565f, 0.00815770f, -0.00866157f, 
    0.00956592f, -0.07231538f, 0.03519586f, -0.06534609f, -0.06278632f, -0.06478105f, 0.00035818f, -0.07151940f, 
    0.04543439f, 0.04423947f, -0.01813402f, -0.04275393f, 0.05562503f, 0.06629013f, -0.01820246f, -0.04822535f, 
    0.03308508f, -0.03791684f, 0.05825460f, 0.04440846f, 0.02247104f, -0.05073411f, -0.03567679f, -0.05180136f, 
    -0.04677938f, -0.00943458f, -0.05815983f, -0.04444593f, 0.02344389f, 0.01049726f, 0.03902110f, -0.04782564f, 
    -0.07116263f, -0.02342016f, -0.05193540f, 0.05276355f, -0.03010749f, 0.04044301f, -0.05425150f, 0.05337014f, 
    0.03560054f, 0.03894284f, -0.05779668f, 0.04626976f, 0.05810108f, 0.02634046f, -0.05351640f, -0.07249354f, 
    -0.00727106f, -0.02994028f, 0.02138286f, -0.06568910f, 0.05567316f, -0.06331194f, 0.00957810f, 0.04749186f, 
    0.00891848f, -0.02202338f, -0.03540926f, -0.02936548f, -0.00231326f, -0.07382656f, -0.00065658f, 0.02763226f, 
    -0.02285685f, -0.05058076f, -0.01882848f, -0.07498658f, -0.05299883f, 0.01103365f, -0.06210762f, 0.03238705f, 
    -0.00930532f, 0.04982790f, -0.01820235f, -0.01443237f, -0.06366121f, 0.01725985f, 0.01399784f, 0.02053468f, 
    -0.05139524f, -0.06031087f, -0.05921900f, 0.02637125f, -0.03156558f, 0.00679552f, -0.07742339f, -0.06527645f, 
    -0.03372663f, 0.00145026f, -0.05745738f, 0.00723970f, 0.01502418f, -0.00166221f, 0.00047287f, -0.02474772f, 
    -0.03658061f, 0.01361091f, -0.04610667f, -0.00638258f, -0.06176167f, 0.01222599f, -0.03583270f, -0.07130721f, 
    -0.06540820f, -0.01675581f, 0.03426695f, -0.01654105f, 0.05699835f, 0.00942854f, -0.07457858f, -0.02233039f, 
    -0.04467416f, -0.06002129f, 0.02258106f, -0.03007044f, -0.04699026f, -0.07368653f, 0.03303164f, 0.03181997f, 
    -0.06794488f, -0.06300563f, -0.07381576f, 0.03011652f, 0.02563306f, -0.06477593f, -0.05994676f, 0.02939246f, 
    0.04006445f, 0.01004395f, -0.03521487f, -0.06657140f, -0.00915532f, 0.02497752f, -0.03151280f, 0.06905331f, 
    0.02180133f, -0.06154294f, -0.02822662f, 0.01845490f, -0.02306383f, 0.00061303f, 0.04362446f, 0.01319942f, 
    0.05401975f, -0.06158252f, 0.05832401f, -0.07937966f, -0.06209537f, -0.00390187f, 0.05049632f, -0.07930046f, 
    -0.02097620f, 0.03295738f, 0.05595424f, 0.03828154f, 0.00239868f, -0.01845886f, -0.03609546f, -0.02885119f, 
    0.56475765f, -0.47833824f, 0.31143400f, -0.00731966f, 0.08289684f, 0.05803339f, -0.05673619f, 0.08024668f, 
    0.06196076f, -0.10256741f, -0.18012051f, -0.02291916f, 0.09579068f, -0.26022592f, -0.31929150f, 0.04411070f, 
    0.16821378f, 0.01885048f, -0.22041488f, -0.22387309f, 0.08070538f, -0.11153626f, 0.03941959f, 0.13898493f, 
    -0.15026446f, 0.18318078f, -0.00828056f, -0.04829669f, 0.18304592f, 0.08500399f, 0.13776280f, -0.12274690f, 
    0.07971948f, -0.12271888f, 0.01628774f, 0.07252294f, -0.18849243f, 0.10738657f, -0.42425096f, 0.08065952f, 
    0.38015866f, 0.09278375f, 0.11401144f, -0.01456291f, -0.10054011f, -0.04272925f, -0.19276258f, 0.02048585f, 
    -0.69022602f, -0.02768574f, -0.44694909f, 0.06197189f, -0.03901301f, -0.07987340f, 0.22861050f, 0.08439737f, 
    0.10527575f, 0.13457774f, 0.30326068f, -0.05187451f, -0.17190012f, 0.15434155f, 0.07323044f, -0.03696859f, 
    0.16684543f, -0.05591005f, 0.05137959f, 0.14027233f, 0.00999316f, -0.10476777f, 0.10837307f, 0.05787982f, 
    0.00133478f, 0.04952944f, -0.30457965f, -0.24225035f, 0.09222656f, -0.04196667f, -0.07314703f, -0.19936207f, 
    0.26257786f, 0.02882511f, -0.15289228f, -0.17782876f, -0.36866695f, 0.22107606f, -0.16070275f, 0.12899677f, 
    0.07555801f, 0.23984034f, -0.00408814f, -0.11217450f, 0.29427519f, -0.02981659f, 0.06302359f, -0.21355046f, 
    -0.14316963f, -0.41319752f, 0.22529182f, 0.25682288f, 0.05060763f, 0.17474230f, -0.06871345f, -0.14540586f, 
    0.17789754f, -0.01142504f, 0.03680351f, 0.07768983f, -0.22821537f, -0.35576606f, -0.44426060f, 0.38787085f, 
    0.29240918f, -0.19007929f, 0.20285252f, 0.03798044f, 0.05341449f, -0.05919761f, 0.02596202f, 0.21249729f, 
    0.07276738f, 0.07255214f, 0.06839591f, 0.01119219f, -0.03715333f, -0.04851172f, -0.06736888f, 0.08104867f, 
    -0.06282236f, -0.06345625f, 0.15764676f, 0.02596209f, 0.27497691f, 0.19178656f, 0.23848686f, -0.04335550f, 
    0.03113430f, 0.04555041f, 0.03319332f, -0.06905891f, 0.15121493f, 0.00410542f, 0.02590531f, -0.07002804f, 
    -0.13633753f, -0.29728121f, -0.18435037f, -0.07805800f, 0.20628336f, 0.18195187f, 0.07495909f, 0.08882374f, 
    0.13684835f, 0.06207229f, 0.01673150f, -0.09529262f, -0.39896649f, -0.30540377f, 0.10528131f, 0.24186550f, 
    0.10957322f, -0.05473765f, -0.13100411f, -0.13770624f, 0.02430034f, -0.10488153f, -0.02845836f, 0.09940492f, 
    -0.35819244f, -0.45230314f, -0.38248336f, -0.39659879f, 0.05674608f, -0.09934904f, -0.04439628f, 0.05448519f, 
    -0.13151540f, 0.15073264f, 0.10000826f, -0.14388597f, 0.25367290f, 0.46611404f, 0.27585110f, 0.01350460f, 
    0.18541975f, 0.13091923f, 0.03131360f, 0.25621170f, -0.10766986f, 0.00350261f, 0.00674064f, 0.12028234f, 
    -0.20741569f, 0.54810047f, -0.12982640f, 0.23287216f, 0.11768540f, -0.01416204f, -0.07246283f, 0.08239137f, 
    0.09929161f, -0.03180661f, 0.04917438f, 0.18370992f, -0.17507139f, 0.00149387f, -0.13334911f, -0.06686576f, 
    -0.01595639f, 0.02546682f, -0.14296231f, -0.19622231f, 0.08936562f, -0.12324013f, -0.06341350f, -0.00116584f, 
    -0.17805940f, 0.01336433f, 0.05230916f, 0.12816167f, -0.01120717f, 0.15108576f, 0.06228044f, -0.14908366f, 
    -0.00569747f, 0.13714707f, 0.04981998f, 0.02578528f, -0.19258721f, -0.28799847f, 0.06669878f, -0.13622808f, 
    0.06387187f, -0.07250255f, -0.03900728f, 0.00604079f, 0.13180614f, 0.15656005f, 0.09196228f, 0.16179855f, 
    0.09911107f, -0.17947833f, 0.30025721f, 0.26161653f, 0.06181559f, 0.05372698f, 0.01512366f, 0.25267121f, 
    0.00399219f, 0.01827341f, -0.02102456f, 0.02089426f, 0.16589220f, 0.09525211f, -0.27976227f, -0.14717485f, 
    0.14937189f, 0.03287901f, 0.23022775f, 0.13656305f, -0.10512389f, 0.06924717f, -0.00678072f, -0.05357850f, 
    -0.06367515f, 0.18115470f, 0.10979816f, 0.54415941f, -0.04202974f, -0.07937154f, 0.02934341f, -0.06500362f, 
    0.05308313f, 0.14696141f, 0.13667437f, 0.23243026f, 0.05654283f, -0.17854300f, 0.17427467f, 0.05988539f, 
    -0.11545188f, 0.02712009f, -0.01777557f, -0.01971455f, 0.00923830f, 0.02787643f, -0.04974173f, 0.03975397f, 
    0.07752026f, 0.11632777f, 0.10232211f, -0.34286696f, -0.00863406f, -0.07330142f, -0.02374239f, 0.09236186f, 
    0.03641041f, 0.08091629f, -0.12331263f, 0.14010175f, -0.27006522f, -0.11956405f, 0.11612069f, 0.01274714f, 
    -0.12218766f, -0.13900816f, 0.03471681f, -0.18860821f, -0.15194042f, -0.01848500f, -0.06173625f, -0.18112841f, 
    0.17216668f, -0.04508326f, -0.00070672f, 0.09061421f, 0.21913581f, -0.07117847f, 0.20223828f, 0.14210679f, 
    -0.11304918f, -0.10594312f, -0.03960792f, -0.25364202f, 0.22539914f, 0.16013861f, -0.00109513f, 0.11121399f, 
    0.00004448f, 0.16622818f, 0.06466817f, 0.01051158f, 0.03503259f, 0.06435652f, 0.06907461f, 0.07588016f, 
    -0.16784661f, 0.04420722f, -0.11705228f, 0.09386533f, 0.02838181f, -0.02866946f, -0.17030495f, -0.04847735f, 
    -0.03319542f, 0.10390275f, -0.06867286f, -0.15507807f, -0.03855081f, 0.06974702f, 0.13831745f, -0.15385264f, 
    -0.12693764f, -0.11654104f, 0.05452363f, -0.13793808f, 0.07322551f, 0.08078104f, 0.29521048f, 0.11947160f, 
    -0.23642616f, 0.53958488f, -0.13629636f, 0.37371624f, 0.14802735f, 0.22312003f, -0.13042399f, 0.21483123f, 
    0.09229660f, 0.16872932f, 0.18746690f, 0.13161869f, 0.27858654f, 0.35712358f, -0.24639788f, 0.34008792f, 
    0.00573745f, 0.05686564f, -0.07463336f, -0.08595524f, 0.02272357f, -0.05999363f, 0.04272690f, -0.02066465f, 
    -0.14193830f, 0.46160865f, -0.23034742f, 0.08858454f, -0.12720515f, -0.10759220f, -0.04693469f, -0.16872649f, 
    0.00054010f, 0.07343505f, 0.04254526f, 0.06160199f, 0.17163481f, -0.05539325f, -0.19745557f, -0.00732139f, 
    -0.08869874f, -0.02641345f, -0.03073358f, -0.01513536f, 0.03521391f, 0.15420283f, 0.07269863f, -0.09649359f, 
    0.31899947f, 0.19272986f, 0.23940788f, -0.05938973f, -0.18361047f, -0.15679209f, -0.09220684f, -0.15605365f, 
    -0.09009428f, -0.08552232f, 0.10228302f, -0.11850458f, 0.19761507f, -0.13849998f, 0.21260461f, 0.00083353f, 
    -0.11042388f, -0.15541950f, 0.01222476f, -0.16670579f, 0.00588927f, -0.05346777f, 0.07159793f, -0.01152537f, 
    0.23676303f, -0.42476496f, 0.24644272f, 0.01847687f, 0.08720348f, 0.05913481f, -0.01712079f, -0.03780280f, 
    0.04705460f, -0.00480860f, -0.13462350f, 0.13987492f, 0.29281119f, -0.06238342f, -0.05996506f, -0.02632337f, 
    0.05036665f, 0.05037163f, -0.00723665f, 0.05688043f, -0.16537091f, 0.12541005f, 0.03832997f, -0.04016157f, 
    -0.07019400f, -0.07249279f, -0.00039263f, 0.17979671f, -0.01814841f, 0.02035323f, -0.00759417f, 0.03492077f, 
    -0.12755397f, 0.12381988f, -0.02527129f, -0.01061516f, 0.17954743f, 0.02882978f, 0.25800058f, -0.03226469f, 
    -0.08671908f, -0.04154367f, -0.03589512f, 0.06254369f, -0.07327096f, 0.08913745f, -0.06741322f, 0.08789030f, 
    0.04119560f, 0.29011589f, 0.11639067f, -0.21884190f, -0.13439603f, -0.04362099f, 0.00653356f, -0.00040383f, 
    0.05851743f, 0.06078697f, 0.12019769f, 0.04389063f, 0.20678002f, 0.19561948f, 0.26420364f, 0.08727848f, 
    -0.17492206f, 0.04829818f, -0.08797029f, -0.01756740f, 0.00626992f, 0.09723569f, 0.09551279f, 0.01240252f, 
    0.22725895f, 0.20761387f, 0.03687377f, 0.12605153f, 0.43010733f, -0.09707931f, 0.00560767f, -0.06645619f, 
    0.02051792f, 0.10620951f, -0.04729052f, -0.09419284f, 0.00469358f, 0.09646992f, -0.05047163f, 0.35436234f, 
    0.01898160f, 0.27640331f, 0.07508767f, 0.26131797f, -0.17483281f, -0.10493661f, -0.08103663f, -0.12303580f, 
    -0.04439747f, 0.01327261f, 0.02208770f, -0.00105851f, -0.22743359f, -0.03004405f, -0.17792994f, -0.12139775f, 
    0.20313893f, 0.31852809f, 0.06733958f, 0.24918973f, 0.06141534f, 0.10174099f, -0.02953347f, 0.08484197f, 
    -0.10966377f, 0.12121406f, -0.03228744f, -0.01385011f, 0.10193470f, -0.07723159f, -0.08364604f, 0.05033047f, 
    0.44858825f, 0.51443082f, -0.08236100f, 0.38564140f, 0.19084750f, -0.00002479f, 0.13637593f, 0.14815812f, 
    -0.04168165f, 0.04805736f, 0.00228642f, -0.11828256f, 0.02313150f, 0.20278463f, -0.09343604f, 0.43687022f, 
    0.06533736f, 0.14329337f, 0.11894807f, 0.14958385f, 0.05137120f, 0.06813215f, 0.10776642f, 0.11744878f, 
    -0.24624480f, 0.59286690f, -0.33432287f, 0.17277525f, -0.05540842f, -0.08662903f, 0.14231864f, -0.07210477f, 
    0.01016502f, 0.03594081f, 0.01937044f, -0.14234215f, -0.32202363f, -0.11292264f, -0.09023221f, -0.11116064f, 
    -0.30235302f, -0.01119749f, -0.07190616f, -0.02280127f, -0.00308474f, 0.06713304f, -0.06161469f, 0.05256867f, 
    0.54858249f, 0.18367009f, 0.45544496f, 0.01495005f, -0.01094505f, 0.07446752f, -0.05547457f, 0.25355029f, 
    0.01754441f, -0.01109127f, -0.10475788f, -0.13380942f, 0.32087451f, -0.21714556f, 0.01863887f, -0.29177031f, 
    -0.03396467f, 0.15198925f, -0.02989601f, 0.15361355f, -0.09794509f, -0.13336669f, 0.10802219f, -0.18768959f, 
    0.40481243f, -0.10736361f, 0.12826377f, -0.01180790f, 0.13783883f, -0.11575384f, 0.02348157f, 0.05200264f, 
    -0.00751368f, 0.01301983f, 0.07183174f, 0.15807047f, -0.36513856f, 0.28166074f, 0.36204061f, 0.06689154f, 
    -0.01238864f, -0.22090188f, -0.05141544f, 0.18466309f, 0.04623044f, 0.01407680f, 0.04588643f, 0.03609473f, 
    -0.39043587f, 0.59547693f, -0.11176284f, 0.11060400f, 0.06261822f, -0.11951298f, 0.17822358f, -0.02754783f, 
    -0.16053662f, 0.06527531f, -0.04924204f, 0.06920081f, 0.28093898f, -0.19617267f, 0.14752823f, -0.32652724f, 
    0.08476697f, -0.09283660f, -0.22662723f, 0.05863832f, 0.11932820f, 0.04762205f, 0.09899847f, -0.06114202f, 
    -0.01782538f, 0.09811340f, -0.28827980f, 0.11534395f, -0.07385283f, 0.07267284f, -0.12132096f, -0.03235635f, 
    0.11391296f, 0.08324536f, 0.05009852f, 0.08604153f, 0.13405314f, 0.24542126f, 0.21642943f, 0.06048649f, 
    -0.06224973f, -0.06060869f, -0.13373011f, 0.24761185f, -0.06611333f, -0.03213930f, -0.01943936f, -0.08583845f, 
    -0.07505073f, 0.16811533f, 0.14213060f, 0.08860703f, 0.02784215f, -0.29837739f, 0.04852860f, -0.09861392f, 
    -0.05906433f, 0.17324078f, 0.01502017f, 0.01430133f, -0.11328843f, 0.06061446f, 0.23393320f, 0.33519456f, 
    -0.03469522f, 0.27060494f, -0.05549187f, 0.14714397f, 0.03237189f, 0.01606038f, 0.09169611f, -0.08963878f, 
    -0.07370707f, 0.14539739f, -0.18162529f, 0.00388800f, -0.09899946f, -0.23863630f, -0.18972054f, -0.05117277f, 
    0.19029263f, 0.00795415f, 0.00674559f, -0.02473076f, 0.09217706f, -0.13840498f, -0.26421198f, 0.06772383f, 
    -0.09256721f, 0.20893782f, -0.13224401f, 0.01617969f, 0.07277505f, 0.02686244f, -0.50602740f, -0.05950731f, 
    -0.18609358f, 0.44144565f, 0.12042709f, 0.28968817f, 0.04790452f, 0.13807228f, -0.20377381f, 0.21408048f, 
    -0.15918824f, 0.04013783f, -0.17808056f, -0.01044679f, -0.28975695f, -0.00981557f, 0.25287840f, 0.24126515f, 
    -0.03715997f, 0.10074843f, 0.00752719f, 0.00269557f, 0.09306724f, -0.09475069f, 0.09207641f, 0.00408062f, 
    -0.05619154f, -0.04660222f, -0.04930356f, -0.02307854f, 0.01736311f, 0.00017497f, -0.04877802f, -0.03588632f, 
    0.06500230f, 0.05233647f, 0.04909446f, -0.08149553f, -0.01551514f, -0.02455886f, 0.04818625f, 0.03141717f, 
    -0.03051107f, 0.00510744f, 0.02204824f, 0.03875856f, 0.03739828f, -0.08632366f, -0.01186991f, 0.04178352f, 
    -0.00086840f, -0.01524993f, -0.03612750f, -0.07035311f, -0.01146686f, 0.03855289f, -0.02792005f, 0.04132842f, 
    -0.01837740f, -0.08179521f, 0.02892739f, -0.00087810f, -0.07898184f, -0.02547756f, -0.06705100f, -0.05143486f, 
    -0.01161771f, 0.04732826f, -0.07583900f, -0.02223902f, 0.04949842f, 0.01081253f, -0.08767836f, 0.03355626f, 
    0.01897870f, 0.05759038f, -0.05625336f, 0.05570273f, 0.00619419f, -0.06926022f, 0.05096527f, 0.01197604f, 
    -0.01990059f, -0.03500181f, -0.06441527f, 0.04692633f, 0.03922139f, -0.07530091f, -0.03573669f, -0.01974891f, 
    0.05523831f, -0.02920959f, 0.04080722f, -0.04342182f, -0.07472619f, -0.03238779f, -0.07120696f, -0.01734209f, 
    -0.04209760f, -0.08262031f, 0.06192991f, 0.01762071f, -0.06450679f, -0.06682330f, -0.05536122f, -0.03531905f, 
    -0.03944469f, -0.02977696f, -0.04805109f, -0.00944978f, -0.03591603f, -0.03009908f, -0.04473504f, 0.04425544f, 
    0.00765624f, -0.05963554f, 0.03157446f, 0.00179610f, 0.05743077f, 0.04556124f, -0.05190220f, -0.03095733f, 
    0.06497745f, 0.06500756f, -0.07009929f, -0.07658756f, -0.00024300f, -0.04720976f, -0.07149152f, 0.02703098f, 
    -0.00479992f, -0.00754213f, 0.01548057f, -0.06042638f, -0.01847845f, 0.01930352f, 0.02145958f, -0.01045035f, 
    -0.08208860f, 0.00698535f, -0.04039599f, 0.03737012f, -0.05599014f, 0.02418160f, -0.08412766f, 0.01579961f, 
    -0.07392339f, -0.00225006f, -0.06203496f, -0.02221226f, -0.01085597f, -0.01498245f, -0.05403619f, -0.07566463f, 
    -0.05350330f, -0.05246120f, 0.05752225f, 0.02214798f, 0.04090653f, -0.05396817f, 0.00902823f, 0.01081207f, 
    0.03678780f, -0.07271243f, 0.02669947f, 0.00922824f, -0.01125625f, 0.02647991f, -0.02981337f, 0.02219091f, 
    -0.00085863f, 0.01413790f, -0.04797815f, 0.03824931f, -0.05127080f, -0.06487367f, -0.00577390f, -0.07836638f, 
    -0.00431070f, -0.00273993f, -0.03130742f, -0.02854432f, 0.02132987f, 0.01023636f, 0.04388195f, -0.04170777f, 
    0.00013367f, 0.04811260f, -0.07131298f, -0.04676937f, -0.04794697f, 0.01644880f, 0.05890017f, -0.01118930f, 
    -0.05413450f, 0.04227189f, 0.03569791f, -0.07210235f, -0.02827296f, 0.00846003f, 0.03477457f, 0.00458515f, 
    0.00385282f, -0.00984905f, -0.03043732f, -0.00305532f, 0.03375931f, 0.03356681f, -0.07440131f, 0.00906957f, 
    0.03367468f, 0.05145159f, -0.04667925f, -0.07117537f, -0.01960397f, 0.06621013f, 0.01036105f, -0.06132303f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19610359f, 0.06001014f, -0.07809582f, 0.02897936f, -0.03571564f, 0.04068637f, 0.36136577f, -0.16011979f, 
    0.04600203f, 0.20019545f, -0.03927591f, -0.22404306f, 0.02013650f, 0.07674398f, 0.21823262f, 0.07660633f, 
    -0.04732312f, 0.09150222f, 0.08759528f, 0.06255475f, 0.04433734f, 0.17275089f, -0.01814175f, 0.01577886f, 
    -0.03682514f, 0.05683807f, -0.06752227f, 0.12359002f, 0.12138809f, 0.11057940f, 0.21011314f, 0.01380188f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00280023f, -0.10653831f, -0.57094073f, 0.11185544f, -0.14732629f, -0.30450368f, 0.24509461f, 0.08760502f, 
    0.16309869f, 0.22559954f, -0.09278442f, -0.08508977f, -0.02501874f, -0.17301357f, 0.43260685f, 0.01414657f, 
    -0.07592899f, -0.20045634f, 0.12157445f, -0.35847014f, 0.27809060f, -0.27332714f, -0.06644311f, -0.12933105f, 
    -0.33815402f, -0.11693475f, 0.08279197f, -0.21268769f, 0.30806500f, 0.21900193f, 0.42912358f, -0.09338856f, 
    -0.45405713f, 0.28090948f, -0.43455264f, -0.22668412f, 0.08265230f, 0.13300906f, 0.02383393f, 0.38895583f, 
    0.10730247f, 0.02305832f, 0.16119063f, -0.13015349f, 0.05984646f, 0.00455796f, -0.18060811f, 0.18196826f, 
    0.14190049f, 0.16986340f, -0.26435009f, 0.08284458f, -0.21404815f, -0.28903142f, -0.51851028f, 0.09505049f, 
    0.09637883f, -0.06460414f, 0.15636235f, -0.19073263f, -0.23878063f, -0.06316358f, -0.21895717f, 0.17137629f, 
    -0.00236544f, 0.40852615f, -0.02673540f, -0.11624261f, 0.02504201f, -0.03274335f, 0.16550165f, -0.14385509f, 
    0.05123828f, 0.12038347f, -0.14512651f, -0.39713201f, -0.02049579f, 0.12614363f, -0.23407203f, 0.08072451f, 
    -0.08745570f, 0.32360852f, 0.09892932f, 0.14376256f, 0.14033295f, 0.06847186f, -0.42360228f, -0.15429944f, 
    0.03349907f, -0.12536305f, -0.13867141f, 0.55570704f, 0.04269478f, -0.23907335f, -0.17185524f, 0.01713645f, 
    -0.25519314f, 0.23639299f, -0.05998877f, 0.50268865f, 0.05717019f, 0.00692463f, -0.09333503f, 0.30147135f, 
    -0.04695294f, -0.08223487f, 0.02390216f, 0.19042480f, 0.13575973f, -0.42536578f, 0.27731124f, 0.25732467f, 
    0.10129973f, 0.10108309f, 0.26007730f, -0.23854436f, -0.20759170f, -0.07497817f, -0.01136882f, -0.11517071f, 
    -0.29965112f, 0.13277704f, 0.12172307f, -0.05085893f, -0.02906998f, 0.06540367f, -0.10718889f, -0.15085776f, 
    -0.12148468f, 0.35898465f, 0.24560466f, -0.07411419f, 0.00027000f, 0.00529216f, -0.40534285f, 0.20498726f, 
    -0.13558021f, -0.34031877f, 0.14336045f, 0.74600315f, -0.06775597f, 0.15273304f, -0.13688987f, 0.29359284f, 
    0.02163111f, 0.19807169f, 0.14636643f, -0.13091756f, 0.37518269f, 0.24068420f, 0.41854104f, -0.02833035f, 
    0.18016346f, -0.03935149f, -0.12785546f, 0.38450518f, 0.12829803f, 0.06658656f, -0.34773719f, -0.14543723f, 
    0.30677545f, 0.38115937f, 0.00085150f, 0.01214507f, -0.10681691f, -0.27324924f, 0.25895938f, -0.42063031f, 
    0.06789388f, 0.12455942f, 0.05022842f, -0.80997866f, -0.14428110f, 0.34729397f, -0.02774309f, -0.26322412f, 
    0.05922282f, 0.00666329f, 0.19047248f, 0.06871681f, -0.35871968f, 0.16596907f, -0.21265708f, -0.06387130f, 
    0.03162888f, 0.03003593f, 0.13701870f, -0.05295293f, 0.05381967f, 0.31948352f, 0.55030483f, -0.03478790f, 
    0.03325877f, -0.35534793f, 0.38730407f, -0.15678552f, 0.01542524f, 0.15526052f, 0.23633875f, 0.27988154f, 
    -0.16592063f, 0.15908577f, -0.06877787f, 0.07685179f, -0.11015633f, -0.12969486f, 0.34258032f, -0.08051495f, 
    0.04678844f, 0.29592115f, -0.24131806f, 0.00484295f, 0.02117882f, -0.19010188f, 0.27826560f, 0.06275037f, 
    -0.20524228f, 0.07814190f, 0.06373721f, -0.41950119f, -0.09804294f, 0.15403451f, 0.18720360f, -0.15521596f, 
    -0.11749075f, 0.03324115f, -0.06138577f, -0.16264987f, -0.13967994f, -0.15768349f, -0.00180718f, -0.07361593f, 
    0.16726495f, 0.01063687f, 0.16851705f, 0.06982073f, -0.08778571f, 0.10525049f, 0.09307774f, -0.13193874f, 
    -0.09151294f, 0.06751024f, 0.06435752f, -0.17921941f, 0.09491091f, -0.09780529f, -0.04862164f, 0.11354590f, 
    -0.14660396f, 0.14542180f, 0.13714057f, -0.17271122f, -0.17690347f, -0.13481030f, 0.03816909f, -0.00850877f, 
    0.12274110f, 0.09800483f, 0.19848554f, -0.12570670f, 0.13847671f, -0.29352689f, 0.00175404f, 0.23889914f, 
    0.04680939f, -0.24874461f, -0.00458094f, 0.22693767f, 0.14310820f, 0.07740684f, 0.14965557f, -0.25241533f, 
    -0.09656599f, -0.24514034f, -0.24571407f, 0.38181409f, 0.08541117f, 0.00364110f, 0.31543329f, 0.10179365f, 
    -0.31818628f, -0.01002358f, -0.13553536f, -0.02259803f, 0.49081874f, 0.34349149f, 0.05084033f, 0.11997383f, 
    -0.10351571f, -0.09335208f, 0.39893702f, 0.03945670f, -0.07056044f, -0.20679685f, 0.19222775f, 0.09039807f, 
    0.09050318f, -0.05662805f, 0.00980116f, 0.07214845f, -0.01422883f, -0.14011987f, -0.20187338f, 0.05078179f, 
    0.10107438f, -0.19232515f, -0.10836214f, 0.49203718f, 0.14982161f, 0.36370930f, -0.02885039f, -0.10765586f, 
    0.16031988f, 0.06489907f, -0.02641130f, 0.11875210f, 0.10348229f, 0.15674871f, -0.47725222f, 0.01643245f, 
    0.30166531f, 0.62489688f, 0.08322079f, 0.14348955f, -0.05352013f, -0.14406542f, 0.06287089f, 0.38996205f, 
    -0.04207069f, 0.18589577f, 0.11278744f, -0.05707758f, -0.02244672f, -0.27328652f, -0.17813212f, -0.09139381f, 
    0.07331582f, 0.34561270f, -0.01435824f, 0.20277734f, -0.53690451f, 0.04555826f, -0.22350143f, -0.06986542f, 
    0.14285758f, -0.07265534f, -0.00874087f, -0.10995953f, -0.12458618f, 0.22994041f, -0.03540161f, 0.13084719f, 
    -0.41400424f, -0.23119669f, -0.60278636f, -0.02333460f, -0.09970722f, -0.07812398f, 0.09257931f, 0.22217333f, 
    -0.15421993f, 0.13297170f, -0.16383132f, 0.05417131f, -0.09896656f, -0.07774253f, 0.34237915f, 0.15907635f, 
    -0.12731381f, 0.06165083f, 0.10780613f, -0.37572125f, 0.14945927f, 0.08436138f, 0.23584421f, 0.10408905f, 
    -0.24874973f, -0.08739883f, -0.11833172f, -0.25970834f, 0.16804124f, 0.13388170f, 0.27144963f, -0.02177970f, 
    0.33895472f, -0.21403746f, 0.10409191f, -0.03803711f, 0.06224685f, 0.14717063f, 0.17623812f, -0.00870744f, 
    -0.02646528f, -0.12520298f, -0.06141480f, -0.45048317f, -0.03559071f, -0.27551842f, -0.04301058f, 0.24390270f, 
    -0.04018698f, 0.25506279f, -0.22271740f, 0.16505735f, -0.03767304f, 0.15095688f, -0.17935474f, 0.12143434f, 
    0.10335661f, 0.10003106f, 0.15893354f, -0.59553915f, -0.19940589f, 0.10965579f, 0.10751972f, -0.11786010f, 
    -0.08296119f, -0.22698940f, -0.06483187f, -0.06311636f, 0.01020373f, 0.15366207f, 0.03996287f, 0.03079759f, 
    -0.02444172f, -0.00420883f, 0.04485833f, 0.18879674f, -0.02702258f, 0.27182040f, 0.04303508f, 0.26749438f, 
    0.02580987f, 0.05935783f, -0.22186929f, -0.19515702f, 0.34943029f, 0.46563768f, 0.17206071f, 0.12949154f, 
    0.05464446f, -0.12338322f, 0.18474437f, 0.40536070f, -0.00212552f, -0.15144965f, -0.07077031f, 0.03277583f, 
    0.13798122f, -0.64880472f, 0.02860435f, 0.24891429f, -0.16826932f, 0.05583139f, 0.03006810f, -0.05602820f, 
    0.14281720f, 0.01593652f, -0.08075238f, -0.43071023f, -0.05928569f, 0.04050676f, 0.36428204f, 0.23305508f, 
    0.01683608f, -0.26833966f, -0.17427273f, -0.04731245f, 0.01841036f, 0.36419910f, -0.05774154f, -0.13529962f, 
    0.29479420f, -0.10907722f, 0.15426305f, -0.43030843f, -0.07773624f, 0.07542444f, 0.01546896f, 0.14763968f, 
    0.04772710f, -0.08593923f, 0.26208025f, 0.01752646f, 0.00002012f, -0.05767471f, 0.16110894f, 0.27336496f, 
    0.09270896f, 0.13898827f, -0.00884390f, -0.44676912f, -0.08112509f, -0.03531942f, 0.25682995f, 0.20272247f, 
    -0.11347943f, -0.30145574f, -0.11386790f, 0.26785654f, 0.15709636f, -0.18455543f, -0.35119274f, 0.16728392f, 
    -0.03432366f, -0.02801787f, 0.10024263f, 0.05124144f, 0.19747804f, -0.32726154f, -0.35398245f, 0.08109724f, 
    0.20743151f, 0.26409620f, 0.16830534f, -0.08801204f, -0.07744127f, 0.16021174f, -0.18249178f, -0.23710985f, 
    0.07760836f, 0.35121739f, -0.15361431f, 0.01137442f, -0.16920635f, 0.20980394f, 0.06859747f, -0.26815125f, 
    -0.16168378f, -0.23152424f, -0.03907522f, -0.00811407f, -0.00170316f, 0.48062381f, 0.15331830f, 0.07610854f, 
    0.55279100f, 0.19049168f, -0.17465745f, 0.10353908f, -0.17062137f, 0.06611729f, -0.16769333f, -0.00191996f, 
    0.62466323f, -0.36099201f, -0.10926421f, 0.05880775f, 0.00329300f, 0.12688591f, 0.04469216f, 0.30438009f, 
    0.04717340f, -0.10270782f, -0.04842974f, 0.67211765f, 0.07126462f, 0.00515259f, 0.20262533f, 0.27702981f, 
    0.13934793f, -0.35487884f, -0.19489449f, -0.07424848f, 0.52475899f, -0.33885956f, 0.05465729f, -0.07971732f, 
    0.07022569f, 0.17050226f, -0.05480665f, -0.23211008f, 0.09961469f, 0.35700193f, 0.44240856f, 0.13433285f, 
    -0.05392322f, 0.29923934f, -0.02557403f, 0.02482322f, -0.09654419f, -0.44684556f, -0.06650809f, 0.39524990f, 
    0.14485380f, -0.11495499f, 0.05365321f, 0.23030955f, 0.01966031f, -0.43492877f, 0.16351832f, 0.50161904f, 
    0.04151264f, 0.68262118f, 0.31080052f, -0.25867131f, 0.15569726f, -0.12747177f, -0.01730718f, 0.02287975f, 
    -0.20467465f, 0.16380972f, 0.00042271f, 0.09899965f, -0.23456401f, -0.03089756f, 0.19121373f, 0.16975889f, 
    -0.04454634f, -0.12367842f, -0.47150069f, -0.07012040f, 0.12460206f, 0.21462551f, 0.00890489f, 0.18709111f, 
    -0.02410997f, 0.09673873f, -0.03424292f, 0.15241997f, -0.10947258f, 0.22919534f, 0.16557249f, 0.25560912f, 
    0.14301458f, -0.21345331f, 0.26233745f, -0.27532774f, 0.28988707f, 0.27107698f, 0.38668194f, -0.11502960f, 
    -0.04162443f, -0.15882143f, 0.04651581f, 0.63860250f, -0.08203327f, -0.14990902f, 0.14808951f, 0.02656598f, 
    0.06945772f, -0.11480307f, -0.07145628f, 0.14873546f, -0.04584795f, -0.17954819f, -0.09088521f, -0.06042276f, 
    0.10730349f, -0.18460728f, 0.05493087f, 0.06661679f, -0.14761166f, 0.11232932f, -0.14192690f, -0.14719014f, 
    -0.02960934f, 0.04328771f, 0.12079072f, 0.06799376f, 0.14741287f, -0.00788010f, -0.00302037f, -0.03602270f, 
    0.06727342f, -0.05594463f, 0.07750839f, -0.10655992f, -0.13614975f, -0.17976062f, -0.10245237f, -0.15485047f, 
    -0.00528487f, 0.04837737f, 0.13212156f, 0.08863891f, -0.01231873f, 0.07760368f, 0.00925216f, 0.07172764f, 
    -0.06366336f, -0.19569834f, -0.03879477f, -0.09541517f, 0.12930711f, -0.18883593f, 0.13511591f, 0.05495571f, 
    -0.09984919f, -0.09429215f, 0.01342437f, 0.07465897f, 0.02313323f, -0.08623827f, 0.11982671f, 0.11041139f, 
    -0.25475371f, -0.11452813f, 0.09326722f, 0.03466164f, 0.06605148f, -0.18383712f, -0.08676440f, 0.16772409f, 
    0.08450484f, 0.46225485f, -0.02399843f, 0.04384293f, -0.15547340f, -0.06993646f, 0.06971864f, 0.08817837f, 
    0.12899493f, 0.10388318f, -0.04147393f, 0.23343897f, -0.16388927f, 0.19402228f, 0.03852827f, 0.09363694f, 
    -0.16589603f, -0.06447447f, 0.18429461f, 0.18668060f, 0.34610191f, -0.38466960f, -0.36393237f, -0.01666345f, 
    -0.22298358f, -0.15483792f, -0.15455441f, 0.05695750f, 0.32525489f, -0.04770569f, -0.07556106f, -0.08612736f, 
    0.04802401f, -0.42065689f, -0.02103743f, 0.01667895f, 0.08378232f, -0.07823538f, 0.19565427f, -0.35479087f, 
    0.01741023f, 0.38321725f, -0.12779577f, -0.47732246f, 0.09448379f, 0.27890992f, 0.17590666f, -0.21221307f, 
    -0.02159585f, -0.43946996f, 0.12248933f, -0.14682443f, 0.14657037f, 0.22194614f, 0.08539119f, -0.14540845f, 
    0.06919614f, 0.09182987f, 0.03302269f, -0.03686128f, 0.13040359f, 0.13258544f, 0.18274872f, 0.11981095f, 
    0.33111873f, -0.18793003f, 0.10784398f, -0.22297877f, 0.13225752f, -0.19605459f, -0.01876495f, -0.01501942f, 
    -0.14857832f, -0.01775148f, 0.05256181f, -0.17100793f, 0.07547659f, -0.21216711f, 0.08248787f, 0.01504455f, 
    -0.07730626f, -0.06508624f, -0.24220061f, -0.15279962f, -0.15366457f, 0.21514820f, 0.35870129f, 0.06266070f, 
    0.46241021f, 0.03427398f, -0.11250093f, -0.32569835f, -0.02824300f, -0.04609727f, 0.00918973f, -0.04445622f, 
    -0.06917296f, 0.28295615f, 0.00993371f, 0.31834495f, -0.02020533f, -0.23641099f, 0.22831519f, -0.03620205f, 
    -0.10457536f, -0.12597330f, -0.08471972f, -0.01627753f, 0.09313118f, 0.13182852f, 0.07466230f, -0.16042037f, 
    0.15076023f, -0.38343596f, -0.13940126f, 0.33579791f, -0.26778382f, -0.06301219f, -0.06110423f, 0.13633761f, 
    -0.17389385f, -0.00390919f, -0.13923877f, -0.21516088f, 0.39785776f, 0.31482986f, 0.13262232f, 0.03493562f, 
    -1.05121839f, -0.01863788f, 0.07490310f, 0.34627834f, 0.01218059f, 0.22796702f, 0.09105772f, -0.10463715f, 
    -0.14664088f, 0.27796400f, 0.08408154f, -0.08356337f, -0.06308208f, -0.09283733f, 0.22973849f, -0.00427333f, 
    -0.16766599f, 0.08262286f, 0.45366493f, -0.15046498f, -0.48215693f, -0.04524119f, -0.08764347f, -0.12192399f, 
    -0.16806389f, -0.05683513f, -0.11030869f, 0.37986761f, -0.40967762f, 0.22212867f, 0.21859960f, -0.05194209f, 
    0.16686144f, -0.28599390f, -0.07194359f, 0.19790612f, -0.06135399f, -0.34799263f, -0.16457900f, 0.35174251f, 
    -0.15692306f, 0.10297324f, 0.04962919f, 0.45331869f, 0.13341767f, -0.58556974f, 0.03560905f, 0.55169851f, 
    -0.11255758f, 0.45650339f, 0.17813589f, -0.23308526f, 0.25963202f, 0.21099941f, 0.01321935f, -0.01421969f, 
    -0.09402341f, -0.03753933f, 0.04591585f, -0.12044321f, -0.25747454f, -0.03339835f, -0.20115343f, 0.04516865f, 
    0.16881791f, 0.11197889f, 0.18370175f, 0.17366722f, -0.01484247f, 0.23748910f, -0.13392448f, -0.25123656f, 
    0.13912365f, 0.03445730f, 0.16996846f, 0.41699746f, 0.09061755f, 0.31412661f, -0.18655320f, -0.05114575f, 
    -0.06581348f, -0.11771420f, 0.22154875f, 0.04288417f, 0.32148099f, -0.03042150f, 0.60228658f, 0.11449029f, 
    0.43616498f, 0.02719595f, 0.10719720f, 1.11607695f, -0.25265792f, 0.16276637f, 0.18817468f, 0.16256835f, 
    0.11240645f, 0.38975567f, -0.37002891f, 0.18560162f, -0.11930452f, 0.02524851f, 0.04977896f, 0.12728207f, 
    -0.15112714f, 0.05078848f, -0.00637968f, -0.37037864f, 0.12601888f, -0.07801303f, -0.01341847f, 0.33144245f, 
    0.06771063f, 0.39500213f, 0.21445502f, 0.25570315f, 0.08497032f, -0.28286964f, 0.12392169f, -0.09524708f, 
    -0.36988336f, 0.07746622f, 0.08103137f, 0.48167026f, 0.02973814f, -0.13199854f, -0.08670963f, 0.05659068f, 
    0.19844903f, -0.00369739f, -0.04595993f, 0.04687915f, -0.15890889f, -0.20679566f, 0.22480701f, 0.10827100f, 
    -0.01398844f, 0.07909557f, -0.09592435f, -0.63097161f, -0.13978340f, -0.15145960f, 0.22302166f, 0.37132755f, 
    -0.14638788f, 0.76811475f, 0.27479148f, 0.12954243f, -0.15752728f, 0.15034543f, 0.06052252f, -0.17586413f, 
    -0.25171989f, -0.06170804f, 0.07222861f, 0.38873717f, -0.21981175f, -0.23163751f, 0.09238346f, 0.13340035f, 
    0.63256317f, 0.11547467f, -0.16311738f, -0.28601447f, -0.02442675f, 0.12743220f, 0.02579887f, -0.09918782f, 
    0.11900902f, -0.21270791f, -0.11490002f, -0.17333093f, 0.02466077f, 0.00770822f, -0.05277725f, 0.31306088f, 
    -0.17381847f, 0.29902562f, -0.26371402f, -0.08153882f, -0.07836842f, 0.57056773f, 0.32487887f, -0.15264732f, 
    0.47978026f, 0.06982557f, 0.00738067f, 0.42287609f, -0.18631038f, -0.04164553f, 0.19886261f, 0.03221040f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.14007916f, -0.23507380f, -0.03783541f, 0.19138946f, -0.13976204f, 0.23846856f, 0.22153442f, -0.20580474f, 
    -0.03156843f, -0.04561049f, 0.06039926f, 0.28243306f, 0.05525218f, 0.05493907f, 0.05410960f, -0.15888663f, 
    0.05411246f, 0.02254292f, -0.13106780f, -0.05016436f, -0.22910224f, 0.02443969f, 0.08357869f, 0.32277375f, 
    -0.09487616f, 0.04454507f, 0.09820866f, 0.12307801f, -0.11080585f, 0.18620221f, 0.36814857f, 0.10057497f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.48008403f, 0.11318761f, 0.15080644f, -0.31845835f, 0.40909246f, -0.39013225f, -0.37157959f, -0.07974367f, 
    0.09663644f, 0.18523885f, -0.02026076f, -0.24643417f, -0.06791840f, 0.27651629f, 0.03190230f, 0.03717070f, 
    0.30111006f, 0.09673037f, -0.19152535f, 0.18240358f, 0.10409683f, -0.13349165f, 0.07418391f, -0.17253193f, 
    0.01808612f, -0.19106826f, -0.34264970f, 0.02746601f, 0.19187903f, -0.34311521f, -0.94483405f, 0.14913690f, 
    -0.13525175f, -0.03929731f, -0.34013262f, 0.21914481f, -0.25078869f, 0.15973540f, 0.08332153f, 0.12467235f, 
    -0.08455668f, 0.07862154f, 0.07456825f, -0.50682676f, 0.06610630f, -0.09170247f, 0.37959599f, -0.32911292f, 
    0.36925206f, -0.04799018f, -0.68455654f, -0.13484991f, -0.09232599f, -0.23183890f, -0.28345251f, 0.23010884f, 
    0.68382639f, 0.17736170f, 0.27027693f, -0.42499736f, 0.10059407f, -0.42608032f, -0.13914843f, 0.23389842f, 
    0.08289710f, -0.01223394f, 0.03275329f, -0.16995233f, -0.69893050f, 0.21596329f, 0.15888897f, -0.05460484f, 
    -0.22606790f, -0.38285002f, 0.15481508f, -0.05663383f, 0.24403614f, 0.10758501f, 0.26177585f, -0.01178010f, 
    -0.33395571f, 0.30781931f, 0.03522847f, -0.11927778f, 0.11944624f, -0.04338900f, -0.03967654f, -0.07436347f, 
    -0.59784335f, -0.22603966f, -0.51688552f, 0.26255989f, -0.43975797f, -0.05201109f, 0.24194352f, 0.27550474f, 
    0.12302746f, -0.65149635f, -0.65584189f, 0.24228340f, 0.05010849f, -0.32650444f, 0.28874359f, 0.13489787f, 
    0.34298176f, -0.02675164f, 0.09661620f, -0.09962101f, -0.41678539f, -0.20953165f, -0.84183878f, -0.14694238f, 
    -0.30926010f, 0.24497491f, 0.12333573f, -0.03207585f, -0.10224521f, 0.03990347f, 0.18786685f, -0.46502629f, 
    -0.17858428f, 0.29650280f, -0.40100977f, 0.05379727f, 0.05144005f, 0.17129056f, -0.28362727f, -0.14333206f, 
    0.16778444f, -0.56033033f, -0.02407411f, -0.75871783f, 0.22058426f, -0.20542865f, 0.25402629f, 0.01408386f, 
    -0.11950231f, -0.27312446f, -0.27802217f, 0.19111973f, -0.16676778f, 0.04041814f, -0.37030315f, 0.30284423f, 
    0.07436065f, 0.07222046f, 0.15648666f, 0.19097768f, -0.02179787f, -0.07097322f, 0.06872005f, -0.02353425f, 
    0.12458026f, -0.54693872f, -0.06454777f, 0.14871530f, 0.20372851f, -0.08405977f, -0.01557145f, 0.12763143f, 
    -0.21167579f, -0.20923679f, 0.31177706f, -0.26015186f, -0.13743070f, 0.18262585f, -0.36728090f, -0.12712583f, 
    -0.05134996f, 0.03359616f, -0.09729646f, -0.51188868f, -0.21942821f, 0.12282855f, -0.16884089f, 0.01084277f, 
    0.03733154f, -0.06301264f, -0.47419947f, 0.12049939f, -0.09767313f, 0.02163148f, 0.05192645f, 0.10128754f, 
    -0.24265727f, -0.08295926f, -0.20494041f, -0.49099633f, 0.22705762f, 0.33526120f, 0.30921155f, 0.24301578f, 
    0.26862088f, 0.11029036f, 0.02576356f, 0.26791683f, -0.69772601f, -0.32213017f, 0.03030735f, 0.07169380f, 
    -1.06302452f, -0.12657937f, -0.39444983f, 0.35235363f, -0.07786103f, 0.11123515f, 0.33886698f, 0.23883875f, 
    -0.43450859f, -0.09032805f, 0.08487765f, 0.19189975f, -0.23952506f, 0.03024551f, 0.17680158f, 0.27376157f, 
    -0.18064040f, -0.29773432f, 0.06951686f, 0.30899519f, -0.47326961f, -0.08187098f, 0.05074624f, -0.87959796f, 
    -1.00019181f, -0.17683728f, 0.15735878f, 0.16255933f, 0.14897484f, 0.03176718f, 0.06065034f, -0.02957738f, 
    -0.18447760f, 0.15826868f, 0.35648331f, -0.68432832f, 0.27457163f, -0.14154132f, -0.02926559f, -0.00672115f, 
    -0.02729343f, -0.42319998f, 0.33640057f, -0.38847449f, -0.05061401f, 0.09118436f, 0.06642043f, -0.58272529f, 
    0.02416853f, -0.17225678f, 0.17912206f, 0.30138773f, -0.08804299f, 0.05321942f, 0.24281397f, -0.16190743f, 
    -0.18597609f, 0.08982581f, 0.19141336f, -0.19393133f, -0.44244763f, 0.27411318f, 0.03140123f, -0.05321602f, 
    0.17516583f, 0.21620703f, 0.34816018f, -0.04516610f, -0.33983836f, -0.43348968f, -0.31922406f, 0.05875485f, 
    0.24237297f, -0.74164307f, -0.23232506f, -0.54429871f, 0.09933721f, -0.77267212f, 0.24203071f, 0.15527685f, 
    -0.26617277f, 0.34305581f, -0.24305153f, -0.05850035f, -0.53967428f, 0.03557676f, 0.18806417f, -0.66605860f, 
    -0.44355774f, -0.43571383f, -0.10267357f, 0.29581535f, 0.04461912f, -0.36181578f, 0.19649099f, -0.01153841f, 
    -0.24020122f, -0.17686783f, -0.00253008f, 0.24863791f, -0.09963813f, 0.29744169f, 0.05565006f, -0.10500117f, 
    -0.02776089f, -0.28810081f, 0.19533642f, 0.27418980f, -0.00061074f, -0.02852325f, -0.56051016f, -0.15926209f, 
    -0.20788512f, -0.81149787f, 0.04775266f, 0.27834883f, -0.07033967f, 0.07653016f, 0.27870321f, 0.25615004f, 
    0.29636428f, -0.22799404f, -0.52163374f, -0.34616107f, -0.18994489f, 0.20680365f, 0.23213746f, -0.21240106f, 
    0.34899876f, -0.04076236f, -0.68204302f, 0.48119989f, -0.09889612f, 0.15498976f, 0.11137648f, -0.39353630f, 
    -0.23220475f, 0.04760366f, -0.48709986f, -0.14097895f, -0.07516770f, -0.03448869f, -0.01789104f, 0.35149863f, 
    -0.38979965f, 0.35008484f, -0.42770082f, -0.58925474f, -0.18102749f, -0.39478871f, -0.40958193f, -0.35707128f, 
    0.35420936f, -0.03753552f, -0.08984374f, 0.24315792f, -0.17484838f, 0.41315234f, -0.15085851f, 0.00590745f, 
    -0.38607597f, -1.06614530f, 0.22984739f, 0.26663810f, -0.62146515f, -0.39015347f, -0.38753217f, -0.62142777f, 
    0.06601258f, -0.13377580f, 0.03709380f, 0.12077767f, 0.07329661f, -0.05094805f, 0.02514099f, 0.06902990f, 
    -0.25469777f, 0.17511997f, 0.22941193f, -0.51129293f, 0.04584157f, 0.19412369f, -0.06670557f, -0.15616348f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.15562551f, 0.10486468f, 0.01838842f, -0.10986517f, -0.20643124f, 0.26741242f, -0.08332590f, -0.14890318f, 
    0.17085931f, 0.01112796f, 0.13998798f, -0.04522004f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
