#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.48629332f, 0.65608567f, 0.61895239f, 0.46547708f, 0.54065186f, -0.42272758f, -0.31259683f, -0.31164441f, 
    0.21900471f, -0.10317945f, -0.02574058f, 0.01868765f, 0.19954185f, 0.25080717f, 0.18158014f, 0.16044722f, 
    0.08996499f, -0.26131201f, 0.17382705f, 0.10432561f, -0.27219671f, -0.22405061f, -0.27607554f, -0.38189676f, 
    0.20242575f, -0.34584102f, -0.44895348f, -0.24112035f, 0.50252324f, 0.37234697f, 0.13907391f, -0.51961648f, 
    -0.55409956f, -0.18069087f, -0.34262827f, -0.17431164f, 0.22130357f, 0.25866929f, 0.17509104f, -0.00951106f, 
    -0.15131485f, -0.30963543f, 0.05948328f, -0.09220535f, 0.24147485f, 0.08884282f, 0.43070507f, 0.08459054f, 
    0.05195978f, -0.24975924f, -0.49099997f, -0.52101433f, 0.39920756f, 0.71511334f, 0.07244588f, -0.41504014f, 
    -0.09415372f, -0.00475764f, -0.27652428f, -0.33463398f, 0.27657992f, 0.29095733f, 0.13922435f, 0.06679747f, 
    -0.13044021f, 0.29795277f, 0.41158766f, 0.45388582f, -0.02292970f, -0.02985403f, -0.31738746f, -0.35566378f, 
    0.34282774f, 0.34312332f, -0.11785982f, 0.09799375f, 0.70909047f, -0.12219742f, 0.44328734f, 0.27024066f, 
    0.22262008f, -0.69714814f, -0.76673365f, -0.38345656f, 0.01136389f, 0.24367617f, -0.06584328f, 0.08698789f, 
    0.14849907f, -0.07103630f, -0.04871470f, -0.01231405f, -0.09890763f, -0.31449193f, -0.15453392f, -0.35803214f, 
    0.30574128f, 0.43780926f, 0.05603431f, 0.33859548f, -0.21971264f, 0.38566080f, -0.31391793f, -0.45708427f, 
    -0.09556247f, 0.07901200f, -0.27848431f, -0.53504866f, -0.10867310f, -0.13197187f, 0.41227546f, 0.02996267f, 
    0.22419809f, 0.40459764f, -0.22158819f, -0.55416054f, -0.02088587f, 0.26993701f, -0.10300702f, 0.11791681f, 
    0.17757592f, -0.19661485f, 0.00717936f, 0.14269634f, -0.02312188f, -0.14534163f, -0.31654149f, -0.52141482f, 
    0.05237607f, -0.29828268f, 0.56171596f, 0.02942168f, 0.09263460f, 0.48516381f, -0.08854900f, -0.56336045f, 
    -0.29664686f, 0.33960903f, -0.28972682f, -0.20753935f, -0.48243338f, -0.21856706f, 0.01826579f, -0.05708642f, 
    -0.21383639f, 0.04746124f, 0.01071239f, -0.14063714f, 0.07719491f, 0.07802369f, -0.68561804f, -0.03915806f, 
    -0.43724930f, 0.23818129f, -0.54729837f, 0.45281702f, 0.64175183f, -0.04454398f, 0.12959245f, -0.48589554f, 
    -0.09249552f, 0.22871125f, 0.17979820f, 0.23765145f, 0.45401987f, -0.04636081f, -0.44012466f, 0.23630023f, 
    -0.33584350f, -0.26884499f, -0.01678934f, 0.46397263f, 0.26912683f, 0.03984804f, -0.12115672f, 0.15395600f, 
    -0.52872574f, 0.93972731f, 0.16555886f, -0.66957974f, 0.31654987f, -0.42391267f, -0.07040527f, 0.11949438f, 
    -0.11671589f, 0.22501978f, 0.23932952f, 0.21244486f, 0.40645865f, 0.37431598f, -0.23655500f, 0.16539395f, 
    -0.03036034f, -0.03863385f, 0.23266762f, 0.15260839f, 0.14537314f, -0.09683278f, 0.05490955f, 0.28828743f, 
    -0.81337589f, 0.06431505f, 0.01782034f, -0.01780426f, 0.62463838f, -0.95114022f, 0.23172255f, 0.09916119f, 
    -0.62004483f, -0.40650421f, 0.32191896f, 0.21951689f, 0.04968006f, -0.05893402f, 0.24666776f, -0.21461548f, 
    0.00363069f, 0.19250865f, -0.14545362f, 0.01764012f, 0.11785565f, 0.02137296f, -0.21279800f, 0.11896741f, 
    0.16293366f, 0.59553033f, -0.14334910f, -0.52863038f, -0.68262422f, -0.25839019f, 0.59242088f, 0.53496283f, 
    0.49087715f, 0.20244236f, 0.22842501f, -0.34168488f, -0.18846105f, -0.38980213f, -0.05558863f, -0.21713369f, 
    -0.05781962f, -0.05434215f, 0.14280057f, -0.03383829f, -0.16189931f, -0.18231213f, -0.08648217f, -0.37692526f, 
    0.10509329f, -0.22596122f, 0.01140610f, -0.51579291f, -0.88883215f, -0.69296199f, -0.03698450f, -0.57614952f, 
    0.47439569f, 0.43122888f, -0.27631551f, 0.00889695f, 0.02136029f, -0.13005340f, 0.10606003f, -0.28813770f, 
    0.39236400f, 0.03488505f, 0.06472833f, 0.10353862f, 0.24568905f, 0.24859008f, 0.00173139f, -0.15056019f, 
    0.08296220f, -0.15926857f, 0.09194410f, -0.93237180f, 0.95462602f, 0.40245044f, -0.79059583f, 0.43489727f, 
    -0.38147756f, 0.51367766f, 0.44748795f, 0.01639617f, 0.13887887f, -0.37310725f, 0.27343169f, -0.17377862f, 
    0.00374196f, -0.18629982f, -0.06146662f, -0.17956589f, -0.12644598f, -0.22047959f, -0.15100427f, -0.04839336f, 
    0.02770730f, 0.03293915f, 0.06610061f, 0.06361977f, 0.04021553f, 0.64094245f, 0.75255644f, -0.17500301f, 
    -0.94649708f, -0.39901763f, -0.14291207f, -0.07534280f, -0.34931684f, -0.12283987f, 0.33123386f, 0.47424912f, 
    0.06997976f, 0.01754036f, -0.08331128f, 0.09404860f, 0.02714195f, 0.22178328f, 0.35252753f, 0.00238892f, 
    -0.07452362f, 0.17580666f, -0.12263082f, -0.12667470f, -0.10664909f, 1.00649488f, 0.13217372f, 0.43128198f, 
    0.53914237f, 0.66004032f, -0.28421372f, 0.02012112f, -0.08508942f, 0.43430036f, -0.09941796f, -0.25313178f, 
    -0.14508818f, 0.00784259f, 0.13409330f, 0.03294758f, -0.18153366f, -0.05985016f, 0.11147264f, 0.15595166f, 
    0.04349382f, 0.14412293f, 0.07413911f, -0.16870174f, -0.19592537f, -0.13261405f, -0.61690223f, -0.40294829f, 
    -0.73534811f, -0.13847403f, 0.32858893f, -0.07602929f, 0.58919156f, 0.63149208f, 0.21514645f, 0.32937482f, 
    0.01904188f, 0.27786380f, -0.08513368f, -0.32994291f, -0.41216657f, -0.30357882f, 0.25382185f, 0.03223867f, 
    0.14689250f, -0.19684584f, -0.17893335f, -0.08697881f, 0.10857618f, -0.08447079f, -0.08086108f, 0.15171218f, 
    -0.71013612f, -0.60129446f, -0.08616476f, -0.44917175f, -0.07419092f, 0.82132661f, 0.10619079f, 0.06515181f, 
    0.40064609f, 0.27148938f, -0.12610579f, -0.01335248f, 0.15739675f, 0.11657105f, 0.10726012f, 0.12063009f, 
    0.04310031f, 0.17018987f, -0.03513041f, 0.36973351f, 0.22062774f, -0.20137778f, 0.21974647f, 0.04376133f, 
    0.84108043f, 0.90198076f, -0.50750732f, 0.06197806f, 0.24566329f, 0.02456566f, 0.31789511f, -0.00056221f, 
    0.51278394f, 0.59805673f, 0.10282448f, -0.02534537f, 0.10404620f, -0.37713948f, -0.12122300f, 0.08119660f, 
    -0.03746685f, 0.02917533f, -0.22303672f, 0.09997334f, -0.00434397f, -0.13301514f, 0.25601172f, -0.03048288f, 
    0.22224765f, 0.19902343f, -0.35923278f, -0.09800474f, 0.01249096f, 0.10917408f, 0.25221550f, -0.60235786f, 
    0.03935618f, -0.02437925f, -0.07991830f, 0.04632453f, -0.09955948f, 0.30936834f, -0.36774889f, 0.43244609f, 
    -0.39089411f, -0.34189984f, -0.16723828f, -0.48252845f, -0.29381043f, -0.28657460f, -0.19853577f, 0.45555907f, 
    0.29543728f, -0.08799433f, -0.26231852f, -0.43118197f, -0.39007935f, -0.31915429f, -0.09844936f, -0.12717848f, 
    -0.30220559f, -0.58898520f, -0.59116942f, -0.19926636f, 0.05704922f, 0.32230300f, -0.16533947f, 0.23046024f, 
    0.01111979f, 0.37173685f, 0.10380648f, -0.48956987f, 0.00600298f, 0.07114735f, 0.15752850f, -0.07063374f, 
    0.26843596f, 0.18741906f, -0.12115349f, 0.55713224f, -0.20178658f, -0.43811437f, 0.65824264f, 0.77099067f, 
    0.75475711f, -0.18069437f, -0.48899433f, 0.22563156f, 0.00441982f, 0.00408565f, 0.20354939f, -0.27295503f, 
    -0.06686395f, 0.19125509f, 0.32070163f, -0.07864720f, 0.07071907f, 0.03730910f, 0.15274233f, 0.00648732f, 
    0.15548486f, -0.12563804f, 0.07167707f, 0.27655843f, -0.35491267f, -0.45509920f, 0.21745992f, -0.49010330f, 
    -0.20998490f, 0.11017257f, -0.28969911f, -0.23347472f, 0.48895925f, -0.43183795f, 0.28117973f, 0.26052693f, 
    -0.16353105f, 0.01805376f, -0.34537899f, -0.05268670f, 0.00439974f, -0.32163981f, 0.04411000f, -0.43707490f, 
    0.21566439f, 0.20955619f, 0.11859209f, 0.10102227f, 0.28395125f, -0.78802055f, 0.00822414f, 0.37918743f, 
    -0.50670838f, -0.40398484f, 0.35494578f, -0.13444148f, 0.01272998f, -0.40802738f, -0.23705360f, 0.04779330f, 
    0.35531998f, 0.29932478f, 0.23277490f, 0.05826875f, -0.14395800f, -0.11049666f, -0.52920187f, -0.45458734f, 
    -0.04757955f, -0.09111264f, 0.10081392f, 0.03226570f, 0.03980503f, 0.22313860f, 0.27028206f, -0.39199167f, 
    0.66056573f, 0.84637159f, 0.45877054f, 0.50033176f, 0.09235735f, 0.51963288f, 0.27082926f, 0.16802698f, 
    -0.48037416f, -0.19411963f, -0.03685909f, 0.34726611f, 0.01278326f, 0.22896595f, -0.06572417f, 0.09312516f, 
    0.24248043f, -0.00216584f, -0.05931039f, -0.08093450f, -0.12872951f, -0.08088108f, -0.05604490f, -0.40432191f, 
    -0.96258438f, -0.53437465f, -0.14946109f, 0.30093467f, 0.49168542f, 0.56946403f, -0.49097088f, 0.20210983f, 
    0.24040996f, 0.21402618f, -0.03901314f, -0.06794683f, -0.02018138f, -0.01181392f, -0.10264619f, 0.04841950f, 
    -0.08842421f, -0.19338712f, -0.09842159f, -0.20548135f, -0.14969270f, -0.32949370f, -0.13053709f, -0.04336039f, 
    0.80206025f, 0.30261746f, 0.81535405f, 0.77567607f, 0.56567937f, 0.22903435f, 0.29705879f, -0.34709349f, 
    -0.73923820f, -0.01383894f, 0.18224636f, 0.07775021f, -0.03119464f, -0.00374087f, -0.27616277f, -0.13793905f, 
    -0.06269325f, 0.05720529f, 0.26181147f, -0.15576339f, 0.30271351f, 0.20675309f, 0.34692019f, 0.06061000f, 
    0.20456290f, -0.06196222f, -0.51250237f, -0.63687980f, -0.20883934f, 0.27258363f, -0.33268949f, -0.16162403f, 
    0.44942281f, 0.59730190f, -0.34319952f, -0.12609191f, -0.23924488f, 0.37446234f, -0.04087651f, -0.38013655f, 
    0.30281487f, 0.30220345f, -0.20541011f, -0.45394894f, 0.10956547f, 0.11341826f, 0.10392739f, 0.05728275f, 
    0.27115217f, 0.25475258f, -0.42996597f, 0.68179345f, -0.09308517f, -0.13419440f, -0.28506166f, -0.16366316f, 
    -0.29887784f, -0.51196158f, -0.24421033f, -0.22304739f, -0.27135310f, 0.11308400f, -0.31681716f, 0.43818873f, 
    -0.23058686f, -0.37208071f, -0.07783810f, -0.17495365f, -0.22229099f, -0.04954040f, -0.29200071f, 0.10110620f, 
    -0.10203982f, 0.23524892f, -0.14745130f, -0.14189923f, -0.23344804f, -0.21175312f, -0.23040858f, -0.34278283f, 
    0.45818645f, -0.13051282f, 0.29187253f, 0.46836361f, 0.36773470f, 0.58735746f, -0.38317722f, -0.37310633f, 
    0.25226447f, 0.32001927f, 0.02863555f, 0.46581671f, 0.05135288f, 0.26026475f, 0.12101346f, -0.32389650f, 
    0.09063290f, 0.18138202f, 0.07918487f, -0.09040453f, 0.05359552f, -0.26057267f, -0.34172302f, -0.10331340f, 
    0.26049516f, -0.43276098f, -0.77138269f, -0.49821487f, -0.22364061f, -0.15545033f, -0.03430473f, 0.35502321f, 
    0.35789657f, -0.04368240f, -0.13919045f, -0.00464996f, 0.01903508f, 0.27131543f, 0.29185680f, -0.00811499f, 
    0.23599401f, -0.17800733f, -0.04482336f, 0.41191709f, -0.04236623f, 0.41197538f, -0.23639260f, -0.71873915f, 
    -0.77441204f, 0.57758957f, 0.26510474f, -0.57603860f, 0.36117843f, 0.04101471f, 0.10497458f, -0.50578612f, 
    0.10871796f, -0.16814293f, 0.06786162f, -0.14900838f, 0.00411740f, -0.31959403f, -0.16753690f, 0.26087418f, 
    0.07246191f, 0.04872585f, -0.17726442f, -0.04912969f, -0.30932021f, -0.08708401f, -0.71580720f, -0.08531586f, 
    -0.40392286f, -0.36498386f, -0.55478466f, 0.50667679f, 0.32936823f, 0.17072436f, -0.16984832f, 0.34933788f, 
    -0.13938957f, -0.27633581f, 0.04219484f, -0.33521789f, -0.01022773f, -0.02680179f, 0.13573085f, 0.07703447f, 
    0.02855933f, 0.22951061f, -0.06273157f, -0.32186070f, 0.21704929f, 0.15564172f, 0.29781565f, -0.80114388f, 
    0.21842271f, -0.61060578f, -0.72823936f, -0.50736803f, -0.17470717f, -0.14194742f, -0.29688188f, 0.15693444f, 
    0.30616817f, -0.27503037f, -0.25382885f, -0.03709343f, -0.27704543f, -0.29000089f, 0.14998311f, 0.23961355f, 
    0.34847698f, -0.00412458f, 0.15396208f, 0.18598853f, 0.25461772f, 0.06302668f, -0.12646472f, 0.01455198f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15822133f, -0.04800356f, 0.24533422f, 0.07681728f, 0.01083824f, 0.01897568f, 0.13056313f, 0.15678017f, 
    0.15108192f, -0.11049496f, 0.30618864f, 0.18727216f, 0.13516180f, 0.16818470f, 0.12109095f, 0.11312927f, 
    0.25264105f, 0.12183665f, 0.08884594f, 0.13775440f, 0.19598891f, 0.09824813f, 0.02466292f, 0.14943852f, 
    0.07959832f, -0.02936968f, 0.05975574f, -0.03338182f, 0.20092809f, 0.06582048f, -0.11977964f, 0.20189600f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05435636f, 0.03428129f, 0.01364899f, 0.00658976f, -0.03389968f, -0.00537462f, -0.00163964f, -0.00401204f, 
    -0.04268720f, 0.02871909f, -0.05429881f, 0.01417776f, -0.05326522f, 0.03430629f, -0.03055732f, 0.03321481f, 
    -0.03050384f, 0.02917594f, 0.02955797f, -0.05517386f, -0.04740174f, 0.01278596f, -0.02131725f, -0.04099288f, 
    0.02964509f, -0.01039466f, -0.01079648f, 0.02170228f, 0.03671746f, -0.05032302f, -0.04513049f, 0.01971722f, 
    0.00586199f, -0.00740424f, 0.00294370f, 0.00438487f, -0.00677963f, 0.02093770f, -0.01676065f, 0.01630146f, 
    -0.04910504f, -0.04506697f, -0.03742315f, -0.03525775f, 0.01969347f, 0.03272335f, 0.01458722f, 0.04171972f, 
    0.03977435f, -0.02881184f, -0.03582773f, 0.01406846f, -0.05310208f, 0.03558599f, 0.02967622f, -0.01438248f, 
    0.01669638f, -0.01239955f, -0.04323106f, -0.03360946f, -0.01760725f, -0.04861981f, 0.01990356f, -0.05601325f, 
    -0.04502894f, 0.02063588f, -0.00637638f, -0.04214652f, 0.03882162f, -0.00250753f, 0.04431375f, -0.04356661f, 
    -0.01269775f, -0.03039846f, -0.05463202f, -0.01179490f, 0.04494241f, -0.00882587f, 0.01674726f, -0.01674020f, 
    -0.04995015f, 0.00444025f, -0.01607241f, -0.02817794f, -0.04778586f, -0.03479898f, -0.02132090f, -0.02328788f, 
    0.01199984f, -0.05524268f, 0.02377477f, 0.02552575f, 0.03675733f, -0.01042832f, 0.02106442f, -0.00701097f, 
    0.00172525f, 0.01081321f, -0.05394159f, -0.02183307f, -0.03007646f, -0.03263263f, -0.01424784f, -0.02275391f, 
    0.01405928f, 0.01141332f, -0.03130057f, 0.01763990f, 0.00959611f, -0.03137828f, -0.01385895f, -0.05218752f, 
    -0.01837619f, -0.01733559f, -0.03862982f, -0.02732503f, -0.04609331f, -0.00551399f, -0.02794346f, 0.02422598f, 
    -0.04396809f, -0.03491022f, 0.03184539f, -0.02562554f, -0.05517071f, -0.00122103f, 0.03693086f, 0.00293547f, 
    0.02941918f, -0.02694066f, 0.01865783f, 0.01129633f, -0.02029474f, 0.01828445f, -0.00307160f, -0.00482179f, 
    -0.02486641f, -0.00135623f, 0.00034150f, -0.02259780f, -0.00326211f, 0.00960346f, 0.01803091f, 0.03074414f, 
    -0.01949740f, 0.03148161f, -0.00893451f, -0.03439780f, 0.00707609f, 0.03470093f, -0.01098848f, 0.00616514f, 
    0.01587388f, -0.04908624f, 0.04552308f, 0.03984923f, 0.02899981f, 0.03670622f, 0.02450323f, -0.03916562f, 
    -0.05066406f, -0.04878993f, 0.03564338f, -0.05531189f, 0.03300797f, -0.02349747f, 0.02108504f, -0.04122451f, 
    0.03279782f, 0.02150296f, 0.03764359f, -0.00763268f, -0.01955752f, -0.02898059f, -0.02181279f, 0.01680465f, 
    -0.00002273f, 0.04434294f, 0.04310406f, -0.01639812f, 0.02324609f, 0.02274294f, -0.00753229f, 0.00939187f, 
    0.01483412f, -0.02259699f, 0.00805201f, -0.00009758f, -0.04417745f, -0.03390673f, -0.01255291f, 0.01461699f, 
    -0.03716312f, 0.00590754f, -0.03986574f, -0.04665106f, 0.00207245f, 0.03973401f, -0.04532671f, 0.03742282f, 
    -0.03226321f, 0.02055614f, -0.04840992f, -0.04097756f, -0.00152149f, -0.02212631f, -0.02827560f, -0.01914180f, 
    -0.00136328f, -0.02761917f, -0.03107962f, 0.04311052f, 0.00874053f, 0.02003719f, 0.00514345f, 0.03175627f, 
    -0.04494311f, -0.05292011f, -0.03474280f, 0.00927429f, -0.00777785f, -0.04572922f, 0.03840013f, -0.04953856f, 
    -0.04449404f, 0.03525829f, -0.00956801f, -0.03751470f, -0.01623981f, 0.02779827f, -0.00031374f, -0.03305484f, 
    -0.00736716f, -0.00731558f, -0.04484248f, 0.04477705f, 0.03862859f, -0.00571723f, 0.00574514f, 0.01358420f, 
    0.04328643f, 0.02971385f, -0.04536267f, -0.01852028f, 0.03425501f, -0.00995224f, -0.00037932f, -0.05135207f, 
    -0.04627111f, 0.00856399f, -0.03867758f, -0.00357402f, 0.01468111f, -0.03705385f, 0.00905887f, -0.05420241f, 
    0.02511526f, 0.03933524f, -0.05615693f, 0.01453751f, -0.00122751f, -0.04222120f, 0.03349052f, -0.01425698f, 
    0.02263498f, -0.02939808f, -0.02746202f, 0.00773569f, -0.03568422f, 0.02064433f, -0.00742546f, 0.03223855f, 
    -0.03657791f, 0.00805865f, -0.03571039f, 0.00434244f, -0.03211701f, 0.02275896f, -0.01668851f, -0.03037029f, 
    0.02973711f, -0.02863990f, 0.03810856f, -0.03312631f, 0.00284698f, -0.05157690f, 0.01273634f, 0.02157620f, 
    -0.05477534f, -0.03378388f, -0.03577575f, -0.04052874f, 0.03107560f, 0.02422813f, -0.04019958f, -0.03755597f, 
    0.04444797f, 0.00125752f, -0.00273195f, -0.03194902f, -0.01966107f, -0.04450576f, -0.00938166f, 0.03015102f, 
    -0.01476753f, 0.03965066f, -0.02099247f, 0.00975885f, -0.02191372f, 0.03927860f, -0.03072676f, -0.00549877f, 
    0.01601780f, -0.01392428f, -0.00470064f, 0.01595827f, -0.00421973f, 0.02727119f, -0.00444415f, 0.00557040f, 
    0.01975456f, 0.03148088f, -0.03750302f, -0.00105297f, -0.03722683f, 0.02982130f, -0.01066741f, 0.03634526f, 
    0.00886722f, -0.02716701f, -0.02775074f, 0.03844040f, -0.04395602f, -0.03626406f, -0.00321109f, 0.02085573f, 
    0.02602259f, -0.03033897f, -0.04688489f, 0.00599395f, 0.00077393f, -0.00882116f, -0.00854291f, -0.03317480f, 
    0.03891522f, 0.03381645f, 0.02110837f, 0.02217252f, -0.01050374f, -0.05505605f, -0.01117371f, 0.03734576f, 
    -0.02404818f, -0.03533614f, -0.05191697f, 0.00871498f, -0.03042807f, -0.00426015f, -0.02799757f, -0.02175573f, 
    -0.04716294f, 0.01700629f, 0.02257186f, 0.03171491f, 0.00893842f, 0.00135205f, 0.00727008f, -0.04525146f, 
    -0.04983053f, -0.01327346f, -0.04524034f, 0.02828878f, -0.00129736f, -0.00589960f, 0.00652873f, 0.00602585f, 
    -0.00055198f, 0.03737959f, -0.04910451f, -0.04681771f, -0.03698055f, -0.05059337f, -0.03566308f, -0.02075045f, 
    -0.03697297f, -0.04672089f, -0.04923981f, 0.04220730f, -0.03275120f, 0.01625402f, -0.02186041f, -0.04772872f, 
    0.02206518f, -0.01892931f, -0.03779432f, 0.00065644f, -0.03603032f, -0.02091691f, 0.04408146f, -0.04503046f, 
    -0.00556891f, 0.03103643f, 0.02280864f, -0.00185694f, -0.05031966f, -0.00940944f, -0.05600698f, 0.00602580f, 
    0.04501733f, -0.04960316f, 0.04382852f, -0.05097130f, -0.03991216f, 0.00345411f, -0.05329217f, 0.00003787f, 
    -0.02306969f, 0.03411729f, 0.04537361f, 0.00321372f, -0.04024852f, -0.03205317f, -0.00008032f, 0.04235825f, 
    0.03675766f, 0.03280977f, -0.03538314f, 0.02578720f, 0.01079934f, -0.02902952f, -0.03462124f, -0.02764757f, 
    -0.00104511f, 0.00886410f, -0.00769731f, 0.00557533f, 0.02399845f, -0.01059235f, 0.03046817f, -0.03587620f, 
    -0.00121235f, -0.03989261f, -0.04635604f, -0.05211176f, 0.00698112f, -0.04557206f, -0.05243791f, -0.00181961f, 
    -0.02282309f, -0.04653389f, 0.00161562f, 0.04581155f, 0.01718471f, -0.03263813f, -0.00053796f, -0.01908075f, 
    0.02386164f, -0.00258171f, 0.02740007f, -0.03178388f, 0.01128874f, 0.02921451f, 0.03651476f, 0.04143227f, 
    -0.04889017f, -0.04779584f, 0.02345320f, 0.03731495f, 0.00056060f, 0.03530573f, -0.01944064f, 0.03853903f, 
    0.01103282f, 0.01702170f, -0.01023278f, -0.05236114f, 0.01229020f, -0.01443021f, 0.00215818f, 0.03161141f, 
    0.02577302f, 0.03841410f, 0.00535953f, -0.04327301f, -0.03777341f, 0.03619619f, 0.01689802f, -0.02176441f, 
    -0.05152423f, -0.03458975f, 0.04698315f, -0.03157349f, 0.01675345f, 0.02053454f, -0.05135767f, -0.01848856f, 
    0.00455095f, -0.01342993f, -0.04998817f, -0.04359740f, 0.02863145f, -0.03449244f, 0.03401396f, 0.02077465f, 
    -0.04636954f, 0.02556781f, 0.02180165f, 0.03639672f, -0.05205636f, 0.00850995f, 0.02157114f, -0.03388566f, 
    -0.01364344f, -0.04347368f, 0.04171534f, -0.00903710f, 0.02404718f, 0.03664790f, 0.04559501f, -0.05453559f, 
    0.02975556f, -0.03370104f, -0.04805977f, -0.02775509f, -0.03477318f, -0.04859253f, 0.03314540f, 0.01097331f, 
    -0.05360619f, 0.02853180f, -0.00797522f, -0.03469491f, 0.00259323f, -0.01413201f, 0.00328146f, -0.02126992f, 
    -0.03417335f, -0.02783870f, 0.01393153f, 0.00341039f, 0.01005538f, 0.00204863f, -0.01479099f, -0.01454282f, 
    0.01835792f, -0.02441787f, -0.03018263f, 0.02815807f, 0.02873015f, 0.03459255f, -0.04262388f, -0.05211288f, 
    -0.04356521f, 0.04509895f, -0.04028527f, 0.00524474f, 0.00943572f, -0.05285690f, 0.02514844f, -0.03680807f, 
    -0.01194886f, 0.00709190f, 0.01344192f, -0.00027338f, -0.05289328f, -0.00872108f, -0.04288205f, -0.02359972f, 
    0.01514861f, -0.05099047f, -0.04426407f, -0.02249690f, -0.00451433f, 0.01996690f, -0.05281102f, 0.01084588f, 
    0.02697492f, -0.01456758f, 0.00631652f, 0.04311462f, -0.05659347f, 0.00786259f, -0.04923831f, 0.02902015f, 
    0.04220231f, 0.02400487f, -0.04270162f, -0.00112685f, -0.04366091f, 0.00703875f, -0.01094128f, -0.03018189f, 
    0.02821358f, 0.01721100f, -0.05490329f, -0.00223678f, -0.04139145f, 0.02108582f, -0.01751403f, 0.03697804f, 
    -0.05188724f, -0.01966836f, -0.00214135f, -0.01695465f, -0.03877131f, -0.03106269f, 0.05061645f, -0.02417728f, 
    -0.04037505f, -0.02267322f, 0.02671118f, -0.01626506f, -0.00625566f, -0.04725400f, -0.02237452f, -0.01239544f, 
    0.03573447f, -0.01369637f, -0.01275771f, 0.02092091f, -0.03411182f, -0.01765372f, -0.04970971f, -0.01082622f, 
    -0.04988955f, -0.03192646f, 0.03124716f, 0.04073613f, 0.02396723f, -0.03561796f, -0.04436515f, 0.04286042f, 
    -0.04689429f, 0.04325369f, 0.01948138f, 0.02857729f, -0.01350818f, -0.00363549f, -0.04691932f, 0.01278770f, 
    0.00359913f, -0.02032768f, -0.01833728f, -0.01801927f, 0.04588965f, 0.04101360f, 0.02375526f, 0.01207217f, 
    0.03666388f, 0.02669530f, -0.01919145f, -0.00544993f, -0.04180819f, 0.04129487f, 0.03209709f, -0.03420215f, 
    -0.02258953f, 0.04511273f, -0.02783922f, 0.03161243f, 0.04218085f, -0.04594577f, -0.04625912f, -0.04990967f, 
    -0.03069013f, -0.00609069f, -0.04275664f, -0.01081976f, -0.03819041f, 0.01412940f, -0.02447672f, 0.00718707f, 
    -0.03434074f, 0.02807846f, -0.05396085f, 0.03124920f, -0.03595215f, 0.02538172f, 0.00810482f, -0.00667114f, 
    0.00672319f, 0.04161803f, -0.04943603f, 0.04498514f, -0.04310969f, -0.05169573f, -0.05271962f, 0.03933838f, 
    0.00591451f, -0.03299693f, -0.05326616f, -0.00510083f, 0.02029516f, -0.03065436f, -0.03445905f, -0.03806633f, 
    0.04547616f, 0.02352837f, 0.01928686f, 0.02537251f, -0.02411293f, -0.01470104f, 0.01862209f, -0.02479229f, 
    0.04171610f, -0.02883901f, -0.01574515f, -0.00489705f, 0.02850757f, -0.02756960f, -0.02663475f, 0.02051180f, 
    -0.05751086f, -0.02896544f, 0.01413795f, -0.03634296f, 0.04848456f, -0.02570975f, -0.02248853f, 0.00300313f, 
    0.04460594f, -0.03986039f, -0.03760282f, 0.03104810f, -0.01416279f, -0.00526581f, -0.00465661f, -0.01633944f, 
    0.02179196f, -0.01814112f, 0.03493940f, 0.04090057f, 0.01966862f, 0.02373466f, -0.02888159f, -0.02419537f, 
    0.03131908f, -0.02013049f, 0.03503285f, 0.02820102f, -0.04644609f, 0.00533490f, 0.00810768f, -0.03425491f, 
    0.00091690f, 0.02911195f, 0.02631346f, 0.03011707f, -0.04459704f, -0.01297646f, -0.02105789f, -0.05309796f, 
    0.02497399f, -0.00314726f, 0.02501776f, 0.03984763f, 0.02328965f, 0.01470723f, -0.05363177f, 0.03740841f, 
    -0.03557052f, -0.05067187f, 0.02798578f, -0.02469107f, -0.02001078f, 0.01099856f, -0.02150158f, 0.02846045f, 
    -0.03809714f, 0.01784440f, -0.05262233f, 0.02231859f, -0.04544987f, -0.00716922f, -0.05550676f, -0.05362701f, 
    -0.01451085f, -0.02502897f, 0.02068515f, -0.05090521f, -0.00109810f, -0.00677635f, -0.03502747f, -0.02811996f, 
    0.02149181f, -0.02754699f, -0.04097798f, -0.03913096f, -0.01706712f, 0.01521157f, -0.01600705f, 0.02047862f, 
    0.01162355f, 0.02634646f, -0.01121138f, 0.00173456f, -0.00351782f, -0.02150875f, -0.05593009f, 0.02123970f, 
    0.00293088f, -0.01481219f, 0.02558953f, 0.00188836f, 0.03591828f, -0.01576627f, -0.05055756f, -0.00064288f, 
    -0.02887202f, 0.01446921f, 0.04094434f, 0.01413123f, -0.05201351f, -0.00253502f, 0.02216555f, 0.02582374f, 
    -0.00050707f, 0.03974546f, -0.02901375f, -0.03235070f, -0.00632373f, -0.02229617f, -0.05265832f, -0.03633866f, 
    0.03337187f, 0.04210933f, 0.04681095f, 0.01046233f, 0.04748665f, 0.02565882f, 0.04562918f, 0.04655867f, 
    -0.02113360f, -0.03798700f, -0.05528689f, -0.03788603f, 0.02110709f, -0.04830638f, -0.00259976f, 0.02765885f, 
    0.03943151f, -0.03003243f, -0.02709851f, 0.03182501f, -0.03783263f, -0.05586036f, -0.04357447f, -0.01083924f, 
    -0.02682457f, 0.00157635f, 0.00962966f, -0.05272086f, -0.00738806f, 0.05394849f, -0.02129263f, -0.02881318f, 
    -0.01411506f, -0.03190783f, 0.02921338f, -0.02506942f, -0.02933002f, -0.01180385f, -0.01888934f, 0.01417580f, 
    0.00604860f, 0.02165905f, -0.02899707f, 0.04608183f, -0.03322051f, 0.04278971f, -0.03480592f, -0.03658465f, 
    -0.04082185f, -0.04947090f, -0.04763054f, 0.03129280f, 0.04366792f, -0.03285479f, 0.03741203f, 0.00076155f, 
    0.02878304f, -0.01257012f, 0.01753380f, 0.00808961f, 0.04156249f, 0.00292852f, 0.03045370f, 0.01921855f, 
    -0.05355013f, -0.03785483f, 0.02726727f, -0.03073670f, 0.01318205f, 0.03852041f, -0.02736065f, -0.01501569f, 
    -0.05247665f, 0.00781351f, 0.03606768f, 0.02140568f, -0.02744760f, 0.00156754f, -0.00666618f, 0.00859667f, 
    -0.02630922f, -0.01171979f, -0.03794089f, -0.02410121f, 0.02387002f, -0.03121474f, 0.04354197f, -0.05549315f, 
    -0.00304231f, -0.02475556f, -0.04376426f, 0.02466986f, 0.02267677f, -0.01525961f, 0.01519409f, -0.00011682f, 
    -0.04136281f, -0.00402672f, -0.05317014f, 0.03201365f, 0.03596414f, -0.00480819f, -0.00649876f, 0.04245584f, 
    -0.02424382f, -0.05109788f, -0.05650277f, 0.00022584f, 0.00423792f, -0.05629951f, -0.05135158f, -0.00902128f, 
    -0.03788148f, -0.03107638f, 0.02030783f, -0.01448137f, -0.01546241f, -0.00002215f, -0.03529082f, 0.02636830f, 
    0.00194489f, -0.00599351f, -0.05571131f, 0.05075869f, -0.03021693f, 0.01880319f, -0.00030197f, 0.01236324f, 
    0.03352666f, 0.00225275f, -0.03803516f, 0.02721173f, -0.01286409f, 0.00848678f, 0.04719095f, -0.04349174f, 
    -0.02764161f, -0.03936255f, 0.02509514f, 0.01567518f, 0.02559893f, -0.01214001f, -0.01005065f, 0.02399589f, 
    -0.04383572f, 0.02753793f, -0.01685496f, 0.03044272f, -0.04831234f, -0.02732361f, -0.05121560f, -0.03364000f, 
    0.04106023f, -0.03114346f, 0.03242223f, 0.04667617f, -0.02249897f, -0.00311413f, -0.00492459f, 0.01315155f, 
    0.03668573f, 0.00935436f, -0.01316894f, -0.00503941f, 0.03270150f, -0.05410225f, 0.02349631f, -0.03448969f, 
    -0.02146153f, -0.05584801f, -0.03947398f, -0.02973865f, -0.00412842f, 0.03054829f, -0.02973226f, 0.04066077f, 
    -0.05184563f, -0.04070462f, -0.01856460f, 0.04072332f, -0.02047610f, -0.00226832f, 0.02039218f, 0.02029567f, 
    0.01580807f, -0.00208941f, -0.05187392f, 0.04579450f, -0.04070334f, 0.03421697f, -0.04252479f, -0.00565356f, 
    -0.04397333f, -0.04447952f, -0.05303463f, -0.04742375f, -0.01600055f, -0.04103012f, -0.03846270f, 0.01145483f, 
    0.00149903f, -0.05571701f, -0.01662145f, 0.00020075f, 0.03187642f, -0.02369934f, -0.03146752f, 0.02289508f, 
    0.03478472f, -0.03489159f, -0.00126126f, -0.00978813f, -0.03149397f, 0.02111495f, -0.00595417f, -0.03630371f, 
    -0.05007356f, -0.03992666f, -0.01903794f, -0.00519642f, 0.04563653f, 0.02034426f, 0.01830732f, -0.04778221f, 
    0.00599374f, 0.01823866f, 0.02022246f, -0.00045236f, -0.00793759f, 0.00355598f, -0.04493449f, -0.05873128f, 
    -0.03021378f, -0.05427193f, -0.00557086f, 0.02425512f, 0.02712728f, -0.02463371f, 0.01515333f, -0.01885436f, 
    0.02658810f, -0.05134408f, 0.04549239f, 0.03109597f, 0.05123489f, 0.03808481f, 0.00257363f, -0.02881461f, 
    0.03377680f, -0.01458337f, 0.03900503f, -0.04234883f, -0.04174809f, 0.02616875f, 0.00181239f, -0.04989899f, 
    0.00378283f, 0.03072285f, 0.01504441f, -0.02437018f, -0.05554326f, -0.04585467f, -0.03758699f, -0.03222716f, 
    0.00406292f, 0.02376889f, -0.02297256f, -0.03645321f, 0.01109059f, -0.01486996f, -0.00300500f, -0.03229143f, 
    -0.03414262f, 0.04837946f, -0.03324611f, -0.03454393f, -0.01240856f, 0.03250720f, -0.02259979f, -0.03605836f, 
    -0.04048109f, -0.03549027f, 0.02224413f, 0.02656278f, -0.03473202f, -0.01063961f, 0.00084056f, 0.01779830f, 
    0.02815438f, 0.01423111f, -0.02825028f, 0.04313333f, 0.04487536f, 0.01345858f, 0.03496257f, 0.02881625f, 
    0.02062894f, -0.00520367f, -0.01142737f, -0.03322828f, 0.03217375f, -0.00514344f, -0.04058485f, 0.01315979f, 
    0.00095426f, -0.03758656f, -0.03892954f, 0.00641145f, 0.02019125f, -0.00351492f, -0.03574550f, -0.00493344f, 
    0.00280465f, -0.00962486f, 0.01085740f, -0.04398238f, -0.03872990f, 0.00945525f, -0.00344974f, -0.03597428f, 
    0.02941495f, 0.01270553f, -0.04834441f, -0.02825012f, -0.02238875f, 0.00548621f, -0.05440966f, -0.00084644f, 
    -0.07136745f, -0.16301449f, -0.20914206f, 0.04073234f, -0.05918541f, -0.13922578f, -0.04419922f, 0.07024477f, 
    0.13078813f, 0.08112368f, -0.00172105f, 0.01623819f, 0.19718888f, 0.09034214f, 0.07235385f, 0.06131917f, 
    0.14342061f, -0.04076601f, 0.07575677f, 0.06285410f, 0.11908767f, -0.07684191f, 0.01147788f, 0.04132973f, 
    -0.16028351f, 0.01641618f, -0.16249157f, -0.01418148f, 0.01749780f, -0.03300384f, 0.07754862f, -0.13140044f, 
    -0.07648538f, 0.07549264f, 0.13549562f, -0.03688168f, 0.15779750f, -0.06948636f, -0.04248036f, 0.04841912f, 
    0.11365408f, -0.05266455f, -0.04197016f, 0.11246549f, 0.09170546f, 0.13372028f, 0.09089753f, 0.03514475f, 
    0.18919384f, 0.04935617f, -0.08942709f, -0.02975960f, -0.10290842f, 0.08550883f, 0.12307493f, -0.08166081f, 
    0.22281636f, 0.08541290f, 0.06655052f, -0.00873918f, 0.28510314f, -0.01048601f, -0.01022228f, -0.02452516f, 
    0.03214451f, -0.06227542f, 0.12868150f, 0.04650463f, 0.10530294f, 0.01016650f, 0.10328527f, -0.10286512f, 
    0.14093229f, -0.13893159f, -0.02946532f, -0.06006701f, -0.02055403f, 0.02267052f, 0.05336145f, 0.00735387f, 
    -0.04939539f, 0.12780266f, 0.07697520f, 0.08969547f, -0.24575199f, -0.12483352f, -0.01493954f, 0.24106923f, 
    0.05047133f, -0.04137266f, 0.05253669f, -0.06500737f, 0.12342731f, 0.15331259f, -0.08309882f, 0.15778303f, 
    -0.29381043f, 0.26061976f, 0.12777309f, 0.06363682f, 0.01543689f, -0.04998125f, -0.07942066f, -0.05365724f, 
    -0.03353583f, -0.01544017f, 0.10884281f, 0.02949160f, -0.08802857f, -0.13290097f, -0.09340178f, -0.22209165f, 
    -0.00106466f, -0.03117483f, 0.07250582f, -0.08973055f, -0.06358989f, -0.01774248f, 0.02033362f, -0.04089808f, 
    -0.02090591f, 0.01689047f, 0.27716264f, -0.08827374f, -0.00408893f, 0.00788065f, 0.08583262f, -0.10010252f, 
    0.00868524f, -0.01372805f, -0.01970803f, -0.01323996f, -0.51579630f, 0.27119392f, 0.06681614f, -0.13181926f, 
    0.12438431f, 0.01654420f, -0.03314337f, 0.02938597f, 0.01880963f, 0.03606805f, 0.01011263f, -0.05113675f, 
    0.04675851f, 0.03290719f, 0.01960008f, 0.11588694f, 0.00598860f, -0.00576498f, 0.00789165f, 0.01771589f, 
    0.05505582f, 0.04356700f, 0.04854506f, 0.10611727f, -0.00012688f, -0.22505195f, -0.18317240f, -0.01725554f, 
    -0.11474529f, -0.06917877f, -0.00708777f, 0.02671890f, 0.11471371f, 0.02507857f, -0.06443302f, -0.03936782f, 
    -0.03350287f, 0.21225083f, 0.04336972f, -0.06665163f, 0.00044429f, -0.04633638f, 0.08050676f, 0.09122767f, 
    -0.07375517f, -0.00129836f, 0.01975724f, 0.00397817f, 0.04142962f, 0.07181833f, 0.07370269f, 0.02315178f, 
    -0.10101824f, 0.05297069f, -0.06887650f, 0.04500185f, 0.00503596f, -0.10381224f, -0.05172107f, 0.00783304f, 
    -0.34594679f, -0.15465979f, -0.14063683f, 0.00450544f, 0.09761005f, 0.10546368f, 0.00714723f, 0.04784001f, 
    0.04083018f, 0.11642261f, 0.01862533f, 0.01887613f, 0.05042853f, -0.06913002f, -0.01599493f, 0.24609736f, 
    0.07117643f, 0.08178556f, -0.07443146f, -0.05597366f, -0.04445528f, 0.08113142f, -0.07084280f, 0.08491285f, 
    0.19949856f, -0.03743888f, 0.03411480f, 0.04364800f, 0.09567705f, -0.01689151f, 0.08098231f, 0.02369895f, 
    -0.04965377f, -0.05585934f, -0.11168937f, 0.07143056f, 0.18058152f, -0.22100215f, 0.05674940f, 0.36192092f, 
    -0.03703292f, -0.06084057f, 0.07633436f, 0.04918163f, -0.05995823f, -0.03750841f, 0.10861473f, 0.05032239f, 
    -0.08864226f, 0.07436515f, 0.09459019f, 0.02419828f, -0.02771227f, 0.09071989f, -0.03116537f, 0.03256358f, 
    0.16246495f, 0.02638648f, -0.09418228f, -0.14917566f, 0.01535799f, -0.04538891f, 0.10532342f, 0.10550693f, 
    0.07532680f, 0.09296046f, 0.05714002f, -0.05246694f, 0.09702101f, -0.07270431f, 0.06258550f, -0.03344417f, 
    -0.08710143f, -0.21522401f, -0.26403049f, -0.07695775f, -0.08386976f, 0.01507220f, -0.01680402f, -0.01133937f, 
    0.04718461f, 0.04775448f, 0.06717247f, -0.05697891f, 0.03889351f, 0.22222972f, 0.07020577f, 0.09310194f, 
    0.05803524f, -0.07359746f, 0.09309454f, 0.04462301f, -0.00600596f, -0.10215651f, 0.03622799f, 0.00914825f, 
    0.21823913f, -0.23627834f, -0.29221720f, 0.00173860f, -0.08440951f, -0.07925025f, 0.04479098f, -0.07301286f, 
    -0.01747595f, 0.03796444f, 0.06696713f, 0.01316488f, 0.16546687f, 0.10690247f, 0.10333470f, -0.07564379f, 
    0.04573929f, -0.00462531f, 0.08276527f, 0.06363637f, 0.07423796f, 0.06650713f, 0.09542823f, 0.05604385f, 
    0.03186585f, 0.11445820f, 0.04269552f, 0.14519420f, -0.03530847f, -0.04258614f, 0.08992876f, 0.05346204f, 
    0.10792525f, -0.07588954f, -0.16927554f, -0.05416212f, 0.09266876f, -0.06666100f, 0.06497332f, -0.01456530f, 
    -0.03504382f, 0.00274136f, -0.12617233f, -0.04599574f, -0.08684353f, 0.18316609f, -0.02580618f, 0.00823830f, 
    0.19684467f, 0.09132685f, 0.00442183f, 0.19449539f, 0.01426808f, 0.08387560f, -0.07212300f, 0.04716957f, 
    0.03152755f, 0.06484732f, -0.00264980f, 0.01029082f, 0.15240398f, -0.00442273f, 0.07799755f, 0.15896247f, 
    0.03640325f, -0.05636507f, 0.04339943f, -0.05599063f, -0.01774885f, -0.04708657f, -0.06108681f, -0.03586652f, 
    -0.03187635f, -0.11373007f, 0.09620645f, 0.07352322f, -0.03582150f, -0.06487843f, 0.13608529f, 0.01808079f, 
    -0.00150196f, 0.04144558f, -0.10590822f, -0.03911759f, 0.16347207f, 0.24971317f, -0.05472063f, 0.06815449f, 
    0.06422459f, -0.07791574f, -0.04312139f, -0.03126537f, 0.09691669f, 0.05010331f, 0.01183703f, -0.08521402f, 
    0.02458880f, 0.16267896f, 0.02685386f, 0.00095613f, 0.04840274f, 0.05346867f, -0.06339780f, 0.03508144f, 
    -0.05268540f, 0.04504476f, 0.01991446f, 0.11825281f, -0.02132572f, -0.03422773f, 0.04781494f, -0.15363288f, 
    0.06583344f, 0.11128242f, -0.03291347f, 0.02131176f, 0.06169246f, 0.03617436f, 0.14926295f, 0.12774436f, 
    -0.13880087f, 0.01576813f, -0.00502204f, -0.20851369f, 0.06481676f, -0.01693154f, 0.05222930f, -0.03677253f, 
    0.04110628f, -0.01546372f, 0.02609301f, 0.03911955f, 0.00112136f, -0.05054772f, 0.06237405f, 0.22722088f, 
    -0.09168077f, -0.04655753f, 0.07623811f, 0.01352341f, -0.06890521f, -0.02104680f, 0.05464653f, 0.07804505f, 
    0.04573496f, -0.08621087f, -0.05946907f, 0.25928542f, -0.00369875f, 0.10365386f, 0.06085386f, 0.01126994f, 
    -0.01615595f, -0.00655173f, -0.05005918f, 0.05622296f, 0.21443734f, 0.01471870f, -0.15659598f, 0.01203150f, 
    0.00852885f, 0.09006356f, -0.01342570f, 0.00331449f, 0.00138223f, 0.00780829f, 0.08881210f, -0.13801707f, 
    -0.26499721f, -0.01068834f, 0.00078895f, -0.01655369f, 0.02005141f, 0.00114175f, -0.00133811f, 0.00426251f, 
    -0.00547030f, 0.10311128f, 0.05019461f, 0.02412236f, -0.23144273f, 0.00825546f, 0.07701262f, 0.29159373f, 
    0.03299087f, 0.00647148f, -0.07149995f, 0.03035384f, 0.02670846f, -0.05838295f, -0.01849039f, -0.04680965f, 
    -0.08639705f, -0.06662912f, -0.00148735f, 0.05515723f, 0.01362597f, -0.05405782f, -0.04348378f, 0.01685742f, 
    -0.02724448f, 0.07474823f, 0.07889747f, 0.05426306f, 0.23539415f, -0.20986989f, -0.11984363f, -0.13733676f, 
    0.12357597f, -0.02389450f, -0.08177081f, -0.10880200f, 0.00134064f, 0.06444930f, -0.04642949f, 0.03552235f, 
    -0.00325506f, 0.13923898f, 0.11089410f, -0.02657845f, 0.13341413f, 0.07845061f, 0.01911568f, -0.12040561f, 
    -0.04875084f, 0.08605587f, 0.02995088f, -0.06552155f, -0.32429206f, 0.16038752f, 0.08035690f, 0.12958394f, 
    -0.08783218f, 0.07640908f, 0.04976376f, -0.04890882f, 0.06363066f, -0.05302633f, -0.02339073f, -0.06917185f, 
    0.15858699f, -0.26616752f, -0.00189110f, 0.08210580f, -0.09972166f, -0.11143345f, 0.05310433f, 0.01100725f, 
    0.19062941f, -0.11572926f, 0.02016161f, -0.07053963f, 0.23341109f, -0.00180440f, 0.05074134f, -0.05503888f, 
    -0.07726926f, 0.00617672f, -0.00284027f, 0.01766477f, 0.13893592f, -0.01523115f, 0.05660900f, -0.01447977f, 
    -0.07473554f, 0.19722179f, 0.01307566f, -0.12799674f, 0.18237999f, 0.04289370f, 0.01411391f, -0.12009473f, 
    0.10065500f, -0.05189725f, 0.08910692f, 0.05871851f, -0.11628842f, 0.22561195f, -0.06734558f, 0.05143245f, 
    0.08810356f, 0.01630807f, -0.07001448f, 0.04631628f, 0.06047648f, -0.05894592f, -0.00410680f, 0.03085229f, 
    0.00946629f, 0.00049358f, -0.08032723f, 0.04811353f, 0.13390516f, 0.04472043f, 0.03059466f, -0.04595511f, 
    -0.03744379f, -0.08515018f, -0.03027587f, 0.02605823f, -0.13068914f, -0.17723922f, -0.03442246f, 0.04483417f, 
    -0.13193747f, -0.01300683f, 0.09616078f, 0.08967923f, 0.03082610f, -0.09963644f, -0.08917986f, 0.03168499f, 
    0.05618773f, 0.04496762f, -0.01224753f, 0.03493415f, 0.08090573f, -0.06315961f, 0.04836682f, 0.10139307f, 
    -0.05884394f, 0.17631105f, -0.04903987f, 0.05555390f, 0.15344076f, -0.22271793f, 0.11634173f, -0.19734313f, 
    -0.03929638f, 0.06609464f, -0.14654620f, 0.07742345f, -0.02269104f, 0.06002935f, 0.01833532f, 0.00013563f, 
    -0.15988892f, 0.01698760f, -0.09658424f, 0.11141364f, -0.00046803f, 0.18027198f, -0.00514864f, -0.01706864f, 
    -0.00860006f, -0.06582467f, -0.22752112f, -0.05447256f, -0.16245332f, -0.24228549f, 0.07327916f, 0.27479962f, 
    -0.12813868f, 0.06414977f, 0.06746566f, -0.01116805f, -0.08414321f, 0.00804975f, -0.10148659f, 0.01263060f, 
    -0.05075023f, 0.09011114f, 0.08812876f, -0.09471306f, -0.05870712f, 0.06071251f, -0.04274805f, 0.05891955f, 
    -0.02345820f, -0.01993662f, -0.00208052f, -0.00257623f, -0.09064773f, 0.24595709f, -0.00866642f, -0.11816903f, 
    0.04902203f, 0.02605174f, -0.01014564f, -0.02045111f, -0.07353388f, -0.05984522f, -0.08271084f, -0.03061066f, 
    0.41596615f, -0.09119495f, 0.22797082f, 0.08887546f, -0.10243098f, -0.02631930f, 0.05192142f, -0.03965738f, 
    0.02211993f, 0.03570599f, 0.08734461f, -0.01034272f, -0.05122273f, 0.09146953f, 0.02789555f, -0.16219006f, 
    0.19655266f, 0.12545159f, 0.09275689f, -0.05044311f, 0.10615218f, -0.04238298f, -0.07919540f, -0.00725162f, 
    -0.00977405f, 0.02056934f, 0.15989392f, 0.25966972f, -0.08428568f, -0.05218362f, 0.05346303f, 0.04749127f, 
    0.01099119f, 0.08127217f, -0.04154335f, -0.02676746f, -0.05409702f, 0.05642632f, -0.17840771f, 0.15311694f, 
    0.04712379f, -0.00864885f, -0.04155931f, -0.12994365f, -0.06412798f, 0.14878674f, -0.00201194f, -0.06603151f, 
    0.00585708f, -0.00485713f, -0.14535244f, 0.19676466f, 0.03283288f, -0.10357608f, -0.03483415f, 0.02965023f, 
    -0.05137272f, -0.01831320f, 0.05372770f, 0.00450092f, 0.25004971f, -0.15284769f, 0.12138420f, -0.09865788f, 
    0.17645696f, -0.08665534f, -0.09080492f, -0.02159548f, -0.05339916f, 0.02845563f, -0.08715562f, -0.07987817f, 
    -0.02371514f, 0.04600254f, -0.08601513f, 0.25166494f, 0.11255442f, -0.00042308f, 0.02510120f, 0.02922948f, 
    0.05540100f, 0.10819273f, 0.01277615f, -0.09535576f, 0.12902056f, 0.17710398f, 0.04664565f, 0.29926395f, 
    0.14008936f, 0.04965327f, 0.00701457f, -0.15620141f, 0.16793697f, 0.07163578f, 0.04351156f, -0.09962744f, 
    0.05875554f, 0.03753311f, 0.17779100f, -0.04892845f, 0.03329358f, 0.16168727f, 0.01734467f, -0.10155513f, 
    -0.03382355f, 0.04651706f, 0.02123516f, 0.07112446f, 0.00833789f, 0.09549199f, -0.06323683f, 0.01412878f, 
    -0.09953183f, 0.00012147f, -0.05420865f, 0.07525213f, -0.14177386f, 0.28779581f, 0.05416514f, -0.00678221f, 
    0.17279907f, 0.08445933f, 0.07390978f, -0.07724010f, 0.08254320f, 0.05299640f, 0.03338795f, 0.00848916f, 
    0.12734593f, 0.00592576f, 0.10135993f, 0.15093000f, -0.16735466f, 0.06473505f, 0.05815817f, 0.05289610f, 
    -0.10076537f, 0.07475996f, 0.12203938f, 0.02360260f, -0.00425075f, -0.09780019f, -0.13463478f, -0.02621749f, 
    -0.12573747f, -0.04635192f, 0.01928735f, 0.09461639f, 0.02989906f, -0.11160494f, -0.01982658f, 0.05295871f, 
    -0.13523531f, -0.11000536f, 0.00622309f, 0.00955307f, -0.15131435f, 0.03697155f, 0.20244206f, -0.12476384f, 
    -0.08882593f, 0.06670716f, -0.15618725f, -0.05418853f, 0.02965695f, -0.05968824f, 0.03946026f, -0.00051368f, 
    -0.29834026f, -0.00741917f, -0.03925025f, 0.24572605f, -0.05768215f, 0.01708948f, 0.03580726f, 0.06804718f, 
    -0.00386092f, 0.12946613f, 0.01252278f, 0.01095370f, 0.26265228f, 0.13234659f, 0.03223887f, 0.03431648f, 
    0.00199905f, 0.02294149f, 0.10271395f, 0.08754190f, -0.06309443f, -0.01245133f, 0.09078903f, 0.03076234f, 
    0.33420908f, -0.25103354f, 0.02446217f, 0.02773081f, 0.07106170f, 0.15309000f, -0.01933134f, 0.09628437f, 
    0.05100697f, 0.08838796f, 0.00397479f, 0.08481360f, 0.05856497f, 0.13361202f, -0.00432427f, 0.08455417f, 
    -0.02169780f, 0.04479381f, -0.10662460f, -0.01749861f, 0.14305986f, -0.03455297f, -0.09105548f, -0.08349648f, 
    -0.13197015f, -0.34912887f, -0.22624996f, -0.05819340f, 0.09911430f, 0.06239287f, 0.00648029f, 0.07015450f, 
    -0.03493204f, 0.13023132f, -0.02111153f, -0.04492133f, 0.16936980f, -0.32500654f, 0.11544327f, 0.11148702f, 
    0.03269426f, -0.01266101f, -0.08946111f, 0.10509270f, -0.01768036f, 0.02879149f, 0.09328979f, 0.07303957f, 
    0.09373001f, 0.13090068f, 0.04192181f, -0.02467089f, 0.07907813f, 0.01652844f, 0.04030384f, 0.07726945f, 
    0.05866683f, 0.11682940f, -0.02881579f, 0.08711973f, -0.12137833f, 0.09600373f, 0.28008732f, 0.08133101f, 
    0.02079058f, 0.00996357f, -0.02105544f, -0.00228908f, -0.03810810f, -0.02275775f, 0.11064166f, 0.15138601f, 
    -0.06636485f, -0.27738726f, -0.08743656f, -0.05659637f, 0.03218773f, -0.00399252f, -0.13353309f, -0.01907960f, 
    -0.00174957f, -0.04109990f, -0.02039278f, -0.07053376f, -0.03042788f, -0.26245227f, -0.33620539f, -0.09500936f, 
    0.06428699f, -0.03158807f, 0.00961836f, 0.01213949f, 0.09283130f, 0.12912196f, 0.11628247f, -0.00307068f, 
    -0.05541026f, 0.31884035f, 0.12329006f, -0.11978251f, 0.02167823f, -0.01433350f, -0.04445496f, -0.10982522f, 
    0.04757537f, -0.05192665f, 0.00411336f, 0.04991335f, 0.02982903f, 0.09610576f, 0.05877571f, -0.07149722f, 
    -0.02393725f, -0.02821945f, 0.09487622f, 0.11086609f, 0.19330111f, -0.04425479f, -0.00684617f, -0.16130118f, 
    -0.02765207f, 0.04853094f, -0.04485591f, 0.08766552f, 0.02046683f, 0.13001066f, 0.01392110f, -0.12152077f, 
    0.07832275f, 0.03047746f, 0.05868469f, -0.00682484f, -0.22669512f, 0.52753687f, -0.13069046f, -0.24724658f, 
    -0.00837112f, 0.07159133f, -0.00358435f, 0.02231291f, -0.05692263f, 0.15936379f, -0.12527679f, 0.04997019f, 
    -0.15551731f, -0.14597768f, -0.11122178f, 0.11112727f, 0.13293304f, -0.07997580f, 0.04915493f, 0.04932383f, 
    -0.07184178f, -0.00758401f, 0.01888079f, 0.16808397f, -0.26250145f, -0.16937470f, -0.08455855f, 0.13283639f, 
    -0.03888094f, -0.06427170f, 0.07569790f, -0.00910978f, -0.02885242f, -0.02672583f, -0.02036028f, -0.02790422f, 
    0.26449165f, 0.25811452f, 0.25931665f, 0.04836906f, 0.11008449f, -0.01198314f, -0.05001214f, -0.11044689f, 
    -0.02116195f, 0.02335651f, -0.03036856f, 0.07059940f, -0.14423728f, -0.09957352f, -0.25908408f, -0.02028679f, 
    0.11526934f, 0.03350114f, -0.11918908f, -0.13513021f, -0.07183456f, 0.03837613f, -0.03408685f, 0.03191775f, 
    -0.14809315f, 0.10214245f, 0.21665007f, -0.03216292f, 0.01983263f, 0.04100930f, -0.05110394f, 0.00556644f, 
    0.02977805f, -0.03870455f, 0.02566459f, 0.06015420f, -0.11270064f, -0.24565269f, -0.02195372f, -0.07797138f, 
    -0.11337669f, 0.08745228f, -0.11024252f, 0.11356774f, -0.06004872f, -0.11240950f, -0.11293536f, 0.05883827f, 
    0.05076831f, -0.25509250f, -0.00424253f, 0.07290181f, 0.09184664f, 0.04235112f, -0.06786640f, 0.01565558f, 
    -0.10004344f, 0.03516545f, 0.07247784f, -0.06592969f, -0.17930283f, -0.09736039f, -0.12110264f, -0.08930246f, 
    0.04794106f, -0.09874391f, -0.04538610f, 0.08618136f, 0.00742906f, -0.03145630f, -0.01007411f, 0.01080531f, 
    -0.07671127f, 0.09972180f, 0.04641140f, -0.22133304f, 0.00607630f, -0.11753826f, 0.08955877f, -0.09506585f, 
    -0.05309885f, -0.04752681f, 0.13404670f, 0.11397076f, -0.08520000f, 0.29298276f, 0.20863512f, -0.08247559f, 
    0.02512532f, 0.08777452f, -0.13502795f, 0.03771043f, 0.03720034f, -0.01469662f, 0.10769597f, 0.05167999f, 
    -0.21628293f, -0.01748441f, -0.20720069f, -0.23953265f, 0.10364560f, 0.01395234f, 0.16005498f, -0.05408210f, 
    0.09037069f, -0.05150606f, 0.02639933f, 0.06029797f, -0.29082066f, -0.19617115f, -0.02545317f, -0.09664028f, 
    0.02741963f, 0.01149991f, -0.04704600f, 0.11681192f, -0.00692331f, 0.02494381f, 0.02011093f, 0.05834020f, 
    -0.06142702f, 0.14228198f, -0.07219095f, -0.14390224f, -0.01310226f, -0.04195116f, 0.00810959f, 0.03175339f, 
    0.08027380f, -0.03972962f, -0.00707219f, -0.06816368f, 0.05951991f, 0.06072722f, 0.14278193f, 0.11562751f, 
    0.01383118f, 0.02312413f, 0.06016607f, -0.00136869f, 0.08806162f, -0.08719635f, -0.14625584f, 0.05570436f, 
    0.29369372f, 0.02739602f, 0.11511220f, -0.05979743f, -0.10601062f, -0.00252258f, -0.05283369f, 0.01821642f, 
    -0.15369126f, 0.13562895f, -0.06218505f, -0.25088289f, 0.19197175f, 0.02041591f, -0.25764507f, -0.02324651f, 
    0.12238753f, 0.04432462f, -0.08002832f, 0.03935223f, -0.06691194f, 0.09496317f, 0.05560335f, 0.00487246f, 
    0.25557014f, 0.10334080f, -0.01471380f, 0.03185350f, -0.00112305f, -0.05161963f, -0.16885476f, -0.03229516f, 
    0.03523554f, 0.08868349f, -0.09846874f, -0.02662039f, 0.03721230f, 0.10140076f, 0.16769482f, 0.05877632f, 
    -0.04633353f, -0.05642571f, 0.11012134f, -0.01647732f, 0.10926232f, 0.06007494f, -0.04583682f, 0.16153942f, 
    0.30508813f, -0.06476492f, 0.11625300f, 0.14640278f, -0.05799191f, 0.04571760f, 0.01213258f, -0.08646194f, 
    0.01018544f, -0.01013512f, 0.09375767f, -0.05740661f, 0.15994246f, -0.03996686f, -0.08265713f, -0.06647099f, 
    0.14659241f, -0.02111566f, -0.01714342f, 0.10986300f, 0.06179893f, -0.07199716f, -0.06190887f, -0.01812075f, 
    0.30451941f, -0.04656558f, 0.13974513f, 0.04940334f, 0.03011512f, 0.13037011f, 0.02384621f, -0.01172511f, 
    0.01674741f, 0.04694584f, -0.02021318f, -0.08205279f, -0.19294319f, 0.10951488f, -0.14139874f, 0.09976900f, 
    -0.08281931f, 0.00729619f, 0.22745505f, 0.16377197f, -0.04688558f, 0.07689582f, 0.02546342f, -0.01295875f, 
    0.09691791f, 0.05684332f, 0.01970642f, 0.11701562f, 0.04928102f, -0.04898826f, 0.02461401f, -0.04631408f, 
    -0.00789782f, 0.00482652f, -0.00184530f, 0.01995009f, 0.13443431f, -0.19283324f, -0.01574357f, 0.19809854f, 
    0.08458767f, -0.00483030f, -0.00491741f, 0.01970421f, -0.01925009f, 0.04254137f, 0.04041528f, 0.09741437f, 
    0.30857491f, -0.04164688f, 0.13296300f, 0.17073461f, 0.14148848f, 0.12141095f, -0.04101251f, 0.04910078f, 
    -0.03825241f, -0.01195547f, -0.04858234f, -0.01211131f, -0.26293477f, 0.16279019f, -0.06465457f, -0.28567097f, 
    0.05289347f, 0.06274481f, 0.06558557f, -0.07749575f, -0.01297854f, -0.11244141f, -0.05294379f, 0.06390795f, 
    0.01564979f, -0.13498449f, 0.03622502f, 0.09691236f, -0.08969175f, -0.04125556f, 0.06237361f, 0.08608189f, 
    -0.05330168f, 0.11128952f, 0.07059086f, 0.05512239f, 0.10017341f, 0.02665503f, 0.19470119f, -0.02956795f, 
    0.01146149f, 0.06651115f, 0.08825789f, -0.11504164f, -0.05494862f, -0.00654187f, 0.00003936f, -0.07552448f, 
    -0.35682914f, 0.12880917f, 0.02044029f, -0.02890616f, 0.12101027f, 0.06638670f, 0.06077896f, 0.07262614f, 
    -0.01282703f, 0.09302470f, 0.11519141f, -0.01249713f, -0.01484670f, 0.11401645f, -0.09189825f, -0.07067087f, 
    0.11954462f, -0.03703959f, 0.04980439f, -0.01300544f, 0.01689932f, 0.15044121f, 0.17359865f, 0.08710746f, 
    0.16044678f, 0.07316361f, -0.17520598f, -0.05228054f, -0.11247399f, 0.13115914f, -0.08000328f, -0.01358823f, 
    0.10525830f, -0.07532506f, 0.03593102f, -0.09477319f, -0.09905907f, 0.09142557f, 0.01468557f, 0.00026459f, 
    -0.01669043f, 0.00276857f, 0.01622992f, -0.05485355f, 0.09739944f, -0.01703658f, 0.08702352f, 0.01718136f, 
    0.13210577f, 0.10750944f, 0.05775745f, 0.02787839f, 0.04760894f, -0.07228433f, -0.00201098f, -0.09295933f, 
    -0.08138368f, 0.07810006f, 0.14010741f, 0.00007219f, 0.26846349f, 0.07395130f, -0.03846889f, 0.12027674f, 
    0.02648441f, 0.07746026f, -0.08789556f, -0.08850184f, 0.07847890f, 0.04089509f, 0.08390754f, -0.01203685f, 
    -0.03372667f, -0.22141851f, 0.07911471f, -0.35503355f, -0.03254503f, -0.04696213f, -0.00631707f, 0.04380494f, 
    -0.13593362f, -0.14009076f, -0.08538820f, 0.04620140f, 0.22298788f, -0.04935227f, -0.00258578f, -0.00569122f, 
    0.01597306f, 0.03994226f, 0.10330862f, 0.07068287f, 0.08324747f, 0.02270860f, 0.07483001f, 0.11542027f, 
    0.00199027f, -0.10794090f, -0.36122596f, -0.33125922f, 0.23076588f, -0.01813068f, -0.08083037f, -0.11146659f, 
    -0.00435857f, 0.03129823f, -0.03115804f, 0.00627856f, 0.13745171f, 0.14545920f, 0.19109146f, 0.05648500f, 
    -0.07997526f, -0.13297230f, 0.02554503f, 0.04776349f, 0.06862153f, 0.15623988f, 0.13973181f, -0.00200049f, 
    0.18828584f, -0.03909595f, -0.05860854f, 0.07113258f, 0.01413534f, 0.01429857f, -0.03732139f, -0.12432387f, 
    0.04839763f, -0.00860067f, 0.10149567f, 0.09423543f, -0.00240994f, 0.03872945f, 0.06405994f, 0.03875015f, 
    -0.04090198f, 0.03375233f, -0.02683669f, 0.13494278f, 0.00686166f, -0.02690063f, 0.05716537f, -0.10407117f, 
    0.02979334f, 0.26080012f, -0.11206000f, -0.05193699f, 0.06735910f, 0.05453903f, -0.22687812f, 0.00772076f, 
    -0.07654849f, -0.03684631f, -0.11009380f, -0.13093877f, -0.13639735f, 0.21434854f, -0.13930152f, 0.36657134f, 
    -0.00837825f, -0.07014733f, 0.14605874f, -0.01640597f, 0.05437709f, 0.02045351f, 0.09013432f, 0.11444902f, 
    0.06708706f, -0.08156598f, -0.05833141f, 0.12318683f, -0.16058128f, 0.00317260f, 0.01249809f, -0.08714824f, 
    -0.08603046f, -0.00886031f, 0.03631524f, -0.04477392f, -0.08226444f, 0.05789367f, -0.13769822f, 0.06230737f, 
    -0.02875159f, 0.05129103f, -0.13879900f, -0.12372678f, -0.15428123f, 0.01874956f, -0.09377544f, -0.01097418f, 
    -0.02730022f, 0.02814715f, -0.00666792f, -0.00048067f, -0.04050009f, -0.02688438f, -0.04041384f, 0.03824686f, 
    -0.00685592f, 0.01526338f, -0.00175807f, 0.00170363f, -0.02961875f, 0.04350919f, -0.02976015f, -0.05216316f, 
    -0.00121973f, 0.03869309f, -0.04464710f, 0.01531107f, -0.01641543f, 0.03720653f, -0.02716880f, 0.01890139f, 
    0.01076160f, -0.02642354f, 0.04081898f, 0.02595460f, -0.01725560f, -0.04806147f, -0.00094759f, 0.02566089f, 
    -0.03504148f, -0.03566344f, 0.04526864f, 0.00722517f, -0.01949291f, -0.01539303f, 0.00327249f, -0.02379108f, 
    -0.03344739f, -0.05525920f, 0.03652086f, 0.03679458f, 0.00605461f, -0.04890119f, -0.00436595f, -0.01927843f, 
    0.02344161f, -0.06152250f, -0.01578817f, -0.05635910f, -0.01726539f, 0.00706439f, -0.05435682f, -0.01723166f, 
    0.03663491f, 0.01992154f, 0.01880644f, 0.00744663f, 0.02827316f, 0.02265155f, -0.02968295f, -0.04907459f, 
    -0.05411994f, -0.01387387f, -0.01337351f, -0.01136300f, 0.00983852f, 0.01724402f, 0.00188307f, 0.01457371f, 
    -0.02848411f, -0.04205767f, 0.01696754f, -0.02732817f, 0.03243285f, 0.00798310f, -0.02548985f, 0.03118613f, 
    -0.02030329f, -0.05287316f, 0.03501187f, -0.04247424f, 0.01668027f, 0.02934624f, -0.05500893f, -0.01478714f, 
    -0.03475612f, 0.00579709f, 0.01619748f, -0.05082289f, -0.02767623f, 0.01629903f, 0.00929828f, 0.04489761f, 
    0.03088328f, 0.03464634f, -0.03161517f, -0.03274099f, 0.01170968f, -0.04174431f, -0.02431015f, -0.04410902f, 
    0.00641950f, -0.02732353f, 0.00646281f, 0.03408727f, 0.00204787f, -0.04468596f, 0.04662307f, -0.00695951f, 
    -0.03127376f, -0.03830621f, -0.05023396f, -0.01563914f, -0.04479866f, 0.03160540f, 0.02028969f, -0.01918818f, 
    -0.01806472f, 0.00912586f, -0.01165392f, -0.02720633f, 0.02650513f, -0.05602770f, 0.02693070f, -0.03521792f, 
    -0.04593679f, 0.03992942f, -0.01159585f, 0.01309728f, 0.01330013f, 0.01710303f, -0.02768043f, 0.02053339f, 
    -0.02402292f, 0.03774705f, 0.03206047f, 0.03738749f, 0.03057207f, -0.00679632f, -0.05684724f, -0.04548045f, 
    0.00613809f, -0.03193592f, 0.04497909f, -0.00603441f, -0.05367511f, -0.03468867f, 0.01497031f, -0.00346554f, 
    0.00744297f, -0.00998205f, -0.00220558f, -0.00073082f, -0.00858166f, 0.03430042f, -0.00216126f, -0.02989807f, 
    0.02924658f, 0.00732633f, -0.00968789f, 0.00553479f, 0.03500078f, -0.01649194f, -0.05997431f, 0.01028767f, 
    -0.01975339f, 0.03217347f, -0.05392747f, -0.05707587f, -0.02445041f, -0.04236978f, -0.01031032f, 0.04133618f, 
    -0.01049253f, 0.01083111f, -0.04006231f, 0.04397568f, -0.03207839f, 0.02996384f, -0.05845026f, 0.03043287f, 
    -0.00537123f, 0.03101789f, -0.04427268f, 0.03513971f, 0.00855784f, 0.04871144f, -0.03896970f, 0.03294777f, 
    -0.02004222f, -0.02676795f, -0.03328856f, 0.03642611f, -0.00442246f, -0.02941203f, 0.03235760f, 0.02463964f, 
    0.02882955f, -0.02901573f, -0.05287585f, -0.04805712f, -0.02223358f, -0.03844772f, 0.00352353f, 0.00918816f, 
    0.00881637f, 0.04293055f, 0.01467800f, 0.03843126f, -0.03452362f, -0.01907253f, 0.01137360f, -0.00800623f, 
    0.00477381f, -0.00776052f, -0.04535267f, -0.05552058f, 0.05010498f, 0.03643386f, 0.01404897f, 0.01332843f, 
    -0.00808387f, 0.00516925f, 0.00239157f, 0.01498864f, -0.00540480f, -0.05923377f, 0.04039632f, 0.03880031f, 
    -0.03271795f, 0.00088623f, -0.00170280f, -0.03869650f, -0.02252198f, 0.01415389f, -0.01492255f, -0.00086368f, 
    -0.04651933f, 0.02119951f, 0.01857816f, 0.00578048f, -0.02075407f, -0.02772445f, 0.00151392f, -0.02989176f, 
    -0.01116560f, -0.03372570f, -0.03362150f, 0.00348399f, 0.04307700f, 0.02195359f, -0.05523204f, 0.03854025f, 
    -0.00967133f, 0.01803883f, -0.03140820f, -0.03626282f, 0.02100542f, 0.00341301f, -0.04985360f, 0.03627417f, 
    -0.05258423f, 0.03910410f, -0.00341540f, 0.01354943f, 0.01991146f, 0.00900325f, 0.02669582f, 0.01743793f, 
    0.01359261f, -0.01665952f, -0.02635048f, -0.01541899f, -0.00587707f, 0.02964091f, 0.03847393f, 0.01756673f, 
    -0.03419904f, -0.04875762f, -0.02247744f, -0.03245273f, -0.02142758f, -0.02210234f, 0.00777412f, 0.00337644f, 
    0.01151223f, -0.04948281f, -0.03926460f, 0.02363276f, 0.02558604f, 0.02653663f, 0.00954181f, -0.01728482f, 
    -0.03278283f, -0.04078431f, 0.04234660f, 0.02944577f, 0.01591609f, -0.01979084f, 0.00605538f, -0.01978141f, 
    0.01712438f, -0.03139769f, 0.03267729f, -0.04020670f, 0.00874914f, 0.04025920f, -0.02915870f, 0.02226426f, 
    -0.04949914f, 0.02675243f, -0.01056825f, -0.00942481f, -0.04992615f, -0.02621185f, -0.02234982f, -0.00461601f, 
    0.02616983f, 0.03961879f, -0.02302253f, 0.00767143f, 0.02330380f, -0.05318410f, 0.00510267f, -0.04686950f, 
    0.03494149f, 0.02410678f, -0.04236967f, 0.01919828f, 0.02535301f, -0.01781947f, -0.03048878f, -0.00064608f, 
    -0.04561435f, 0.01982361f, -0.01531321f, -0.00414208f, -0.00450843f, -0.05354986f, -0.05620519f, -0.01390542f, 
    0.02003396f, 0.02226346f, 0.04841138f, 0.04034713f, -0.03995431f, 0.04298555f, -0.01437559f, 0.02314851f, 
    0.02794460f, -0.01109724f, -0.03346044f, -0.03213541f, 0.00213744f, 0.03172177f, -0.00147202f, 0.02610018f, 
    -0.03111559f, -0.00669080f, 0.00139513f, 0.01861953f, -0.02440519f, -0.05764971f, 0.01338675f, 0.00135960f, 
    -0.03749936f, -0.01545808f, 0.04080055f, -0.02758976f, -0.03297555f, 0.03644672f, 0.01707043f, -0.03771232f, 
    -0.01419109f, -0.04097753f, 0.02563318f, 0.00196166f, -0.05612196f, -0.00535971f, -0.03833330f, 0.01046947f, 
    0.06045450f, 0.10866745f, 0.06546500f, -0.15841712f, -0.12793572f, -0.07838774f, -0.06476822f, 0.09603240f, 
    0.17322910f, -0.06708128f, 0.09344522f, 0.01645423f, -0.16089700f, 0.15915105f, 0.02091844f, 0.21325722f, 
    0.08200621f, -0.01232580f, 0.05443408f, -0.03811684f, 0.12864397f, -0.21321893f, -0.12952575f, 0.06582315f, 
    -0.09234566f, 0.17988934f, -0.09438558f, 0.12146141f, 0.10147269f, 0.02840343f, 0.04176275f, 0.08684830f, 
    0.00868700f, 0.07835373f, -0.04571848f, -0.07386423f, 0.15988645f, -0.04931756f, 0.05598307f, -0.15484521f, 
    -0.03416691f, 0.01445583f, -0.09068869f, 0.03603479f, -0.05055531f, 0.08136565f, -0.00584439f, 0.01046274f, 
    0.09651835f, 0.00607850f, 0.03241910f, -0.13081510f, -0.07216497f, -0.01120421f, 0.10195932f, 0.04578440f, 
    0.12200157f, 0.03606825f, -0.04748594f, 0.05728329f, -0.13739003f, -0.10230375f, 0.08531007f, -0.03955308f, 
    0.08219147f, -0.06535934f, 0.02332735f, -0.00579193f, 0.07146953f, 0.00048966f, 0.02955818f, 0.20790763f, 
    0.00515700f, -0.03088717f, 0.07399965f, 0.12887225f, 0.14977801f, 0.13058829f, 0.06136544f, -0.00991146f, 
    0.04708468f, 0.03348103f, -0.00989917f, -0.04681386f, 0.29110005f, -0.06792638f, 0.02936182f, -0.10558790f, 
    0.00240268f, -0.01367712f, 0.08316576f, -0.03598997f, -0.03541853f, 0.00661941f, 0.03144999f, -0.00317614f, 
    -0.34395769f, 0.07606629f, -0.04502376f, 0.07434571f, -0.08868789f, 0.06128442f, 0.11468410f, 0.00793506f, 
    0.03575510f, -0.14012161f, -0.02040755f, 0.01863840f, -0.18673113f, 0.10559260f, -0.00111294f, 0.00655987f, 
    0.04302908f, 0.05486251f, 0.15417756f, 0.04226338f, -0.08154634f, 0.02336471f, 0.07699165f, 0.07319007f, 
    -0.44784233f, 0.12928337f, -0.13233534f, -0.01860000f, 0.09622350f, -0.06809382f, 0.06755637f, 0.00544930f, 
    0.05705848f, -0.08582401f, 0.03333641f, -0.01743963f, -0.03142341f, -0.20160452f, 0.20089234f, 0.07524638f, 
    0.04931630f, -0.10394409f, 0.00064511f, 0.04054475f, -0.00814189f, -0.02474025f, 0.05807500f, 0.00725855f, 
    0.18024109f, 0.21719924f, 0.15225363f, -0.06074437f, 0.16540608f, 0.17088567f, -0.03711375f, -0.03441389f, 
    -0.09163874f, 0.02602248f, -0.02885148f, 0.06226845f, 0.24276778f, 0.13322394f, -0.10391304f, 0.04183387f, 
    -0.08840274f, -0.05909688f, 0.07979234f, -0.04258092f, 0.06668164f, 0.01529143f, -0.04791665f, 0.13971786f, 
    -0.19758350f, -0.09111083f, -0.15395062f, 0.03376054f, 0.00514427f, 0.06091461f, 0.01029395f, 0.14768486f, 
    -0.03697535f, 0.08917037f, 0.06702282f, -0.12973061f, -0.36647019f, -0.01937333f, 0.07972423f, -0.20707875f, 
    0.15207519f, 0.04984423f, -0.01300249f, -0.13149481f, -0.02050790f, -0.02161997f, 0.02219521f, 0.00756989f, 
    -0.24690194f, 0.12849084f, 0.03125684f, 0.13951749f, -0.04282255f, -0.03387760f, 0.02584386f, 0.06202570f, 
    -0.00131255f, 0.15411915f, 0.13276935f, -0.03612153f, -0.01931344f, 0.05342718f, -0.03580247f, 0.01152256f, 
    0.04004440f, -0.07786552f, -0.00404314f, -0.02963533f, -0.00240880f, 0.10298821f, 0.04369123f, 0.17627625f, 
    -0.33681843f, -0.03678272f, -0.08532424f, 0.07926473f, 0.05765026f, 0.15377899f, 0.05043023f, -0.01752397f, 
    -0.02298583f, -0.08500934f, -0.02713752f, -0.07330471f, 0.11083402f, 0.16856290f, -0.06045877f, 0.18828323f, 
    -0.00522356f, -0.05057321f, 0.11934052f, 0.06149560f, 0.01150805f, -0.01466955f, 0.08478902f, -0.06532267f, 
    0.18619992f, 0.05618948f, 0.03204778f, -0.19548462f, -0.02469943f, -0.13634105f, 0.01411452f, -0.14762776f, 
    -0.02498913f, 0.12741098f, 0.15058199f, 0.01747823f, -0.09258154f, 0.02258324f, -0.00643339f, -0.09380614f, 
    0.03468134f, 0.10608727f, 0.05483493f, -0.00308548f, 0.00811521f, -0.01490056f, 0.11627648f, 0.09254707f, 
    0.17821981f, -0.21397653f, -0.08211903f, 0.08049580f, 0.07623760f, -0.01348429f, 0.06781550f, 0.00531573f, 
    -0.02428727f, -0.07197172f, -0.02763320f, 0.04892124f, -0.10164061f, -0.15242194f, -0.02311072f, 0.03696635f, 
    0.04016716f, 0.02264777f, 0.11985727f, 0.03377474f, 0.05740021f, 0.15319203f, 0.14292693f, 0.00451871f, 
    0.21470748f, 0.24205224f, -0.25335419f, -0.15455185f, 0.05619882f, -0.03002879f, 0.02691986f, 0.01064703f, 
    -0.09645472f, 0.03014063f, -0.08063195f, -0.00496865f, -0.14543888f, 0.15065512f, 0.02892199f, -0.04908188f, 
    -0.05907843f, 0.05228925f, -0.03826496f, 0.00358930f, 0.04567414f, 0.13537997f, 0.10747089f, -0.08950993f, 
    -0.06256932f, 0.03704379f, 0.11877696f, -0.17023030f, -0.07581386f, -0.00042169f, -0.04965572f, -0.02901893f, 
    0.07985911f, -0.04065563f, 0.03231352f, 0.13075483f, 0.10266519f, -0.14330046f, 0.00613454f, -0.13159211f, 
    -0.00884927f, 0.07335174f, 0.11542545f, 0.08302252f, 0.05104250f, -0.05707550f, 0.04016062f, -0.05038176f, 
    -0.17638390f, -0.02011520f, 0.11129445f, 0.02523312f, 0.07161374f, 0.00647656f, 0.03899759f, 0.00857176f, 
    -0.01530390f, 0.03969203f, -0.10332295f, -0.01010329f, 0.01289977f, 0.01559447f, -0.16223203f, 0.03604858f, 
    -0.04346726f, -0.04103610f, 0.07922820f, -0.04882989f, 0.08737355f, -0.02572520f, 0.16343258f, 0.08470934f, 
    0.09289667f, -0.18030302f, -0.11939077f, -0.23512153f, -0.04976670f, -0.00977159f, -0.15868784f, 0.00791907f, 
    -0.10313601f, 0.04578800f, -0.13148066f, 0.12762801f, 0.25162786f, -0.11494530f, -0.05657102f, -0.14922033f, 
    -0.12363588f, -0.01522770f, 0.03821727f, 0.08526843f, -0.15335880f, -0.05701267f, -0.03886534f, 0.00379912f, 
    -0.05793119f, -0.03970210f, 0.04000475f, 0.04075116f, 0.00322823f, -0.03072748f, -0.02467126f, 0.02903655f, 
    0.01359628f, -0.02692809f, -0.05272169f, -0.04905953f, 0.02644860f, 0.03436172f, -0.00308299f, -0.02448964f, 
    -0.04998412f, 0.00840994f, 0.00508570f, 0.02272052f, 0.02126844f, -0.03373480f, -0.00490865f, 0.02501042f, 
    0.01354624f, 0.03816821f, -0.03946010f, -0.05606584f, -0.03038982f, 0.03507693f, 0.00613314f, 0.01839092f, 
    0.01728820f, -0.00449183f, 0.00169013f, -0.01244069f, -0.04492355f, -0.00476850f, 0.03527774f, -0.05147895f, 
    0.00100740f, -0.03801368f, -0.03631444f, 0.02013559f, -0.03663472f, -0.00735116f, -0.02748024f, -0.00498157f, 
    0.03179904f, -0.03287615f, 0.02335395f, 0.00478362f, -0.00167023f, 0.01790683f, -0.04697086f, -0.04014712f, 
    -0.02461752f, 0.03238444f, 0.02523261f, 0.00308891f, -0.05034232f, 0.02944897f, -0.02194480f, -0.05607542f, 
    -0.01919082f, -0.03618519f, 0.03224968f, -0.03276272f, -0.02134865f, -0.00608443f, -0.04085790f, -0.01146669f, 
    0.04153070f, -0.01350028f, -0.00501668f, 0.02753889f, 0.01988324f, -0.04198059f, 0.02958301f, 0.03731982f, 
    -0.02456497f, -0.05228342f, 0.03458804f, 0.02122465f, -0.02461318f, -0.00191316f, -0.05180293f, 0.01797094f, 
    -0.01887589f, -0.00273041f, -0.00595107f, -0.04950041f, -0.04229590f, 0.02295802f, -0.05813261f, 0.03494133f, 
    -0.02180093f, -0.02884365f, -0.04075453f, 0.02466689f, 0.00712166f, -0.02755259f, -0.02015805f, -0.03712672f, 
    -0.02968631f, 0.01957267f, 0.00421085f, -0.05715563f, -0.05553408f, -0.02431986f, -0.02735745f, 0.04175797f, 
    -0.01585579f, -0.02990044f, -0.03203342f, -0.04853179f, 0.04034865f, -0.01026195f, -0.04579860f, -0.02451250f, 
    0.03613293f, -0.01326263f, 0.02543914f, -0.01673688f, 0.02521505f, -0.01501784f, 0.00692688f, -0.02358671f, 
    -0.01975014f, 0.02015435f, -0.01208798f, 0.03486244f, -0.01528391f, -0.02232496f, 0.00249279f, -0.02553894f, 
    -0.05364180f, 0.02996523f, -0.01750439f, 0.02760846f, 0.03018860f, 0.03650833f, -0.05542659f, -0.00308115f, 
    -0.01057251f, -0.01503758f, 0.02508980f, 0.02011719f, -0.00086226f, -0.04719557f, -0.04224761f, 0.02184265f, 
    -0.03508117f, -0.02615467f, 0.01787011f, 0.03329510f, -0.02849441f, 0.02333700f, 0.01453652f, -0.00103312f, 
    -0.05279265f, -0.04739198f, -0.03167209f, -0.02489375f, 0.03541512f, 0.02088591f, 0.01345757f, 0.02158870f, 
    0.01136422f, -0.04597017f, 0.03315492f, -0.02429922f, -0.02257712f, -0.03259939f, -0.01529068f, -0.04770780f, 
    -0.00004399f, 0.02491288f, 0.03541462f, 0.02758276f, 0.02015276f, 0.02662319f, 0.02278994f, -0.01788395f, 
    0.01844639f, 0.04325739f, 0.00322098f, 0.03323684f, -0.00594333f, 0.00804447f, -0.03343689f, 0.03380759f, 
    -0.01535703f, 0.00673044f, -0.00837287f, -0.01882335f, -0.03053998f, -0.03867574f, -0.00268278f, -0.00964398f, 
    0.01109301f, -0.02415497f, -0.00184159f, -0.03187657f, -0.04301314f, -0.04971975f, 0.03431696f, 0.03733625f, 
    0.03182511f, -0.03956971f, 0.03580476f, -0.01791195f, 0.02857735f, -0.03491852f, -0.02656022f, -0.05619454f, 
    -0.01731398f, 0.00589650f, 0.02128877f, -0.05675640f, 0.02530398f, 0.03115732f, -0.05134887f, -0.05390089f, 
    -0.05160250f, -0.04919686f, -0.05511825f, -0.05691078f, -0.02397331f, 0.01886575f, -0.01686947f, -0.04481264f, 
    -0.04670424f, -0.04888263f, -0.00376166f, -0.00648688f, 0.00642694f, 0.03996364f, 0.00363543f, 0.03811638f, 
    0.00671431f, 0.00155504f, 0.04111532f, 0.02094232f, 0.02363125f, -0.03691711f, -0.02147179f, -0.04661626f, 
    -0.03164517f, 0.00164816f, -0.02984360f, 0.02143217f, -0.01371982f, -0.05125185f, -0.04817669f, -0.02060312f, 
    0.00043142f, -0.02039679f, -0.05389744f, 0.02197989f, -0.01931761f, -0.04467081f, 0.03994676f, -0.01001041f, 
    -0.05455365f, -0.03967959f, -0.00345308f, 0.00017878f, 0.03027894f, -0.01387950f, 0.01834150f, -0.02384869f, 
    0.01651776f, -0.00634798f, 0.03522349f, 0.03834214f, -0.04857129f, -0.04703338f, 0.03393839f, 0.03444426f, 
    -0.03186791f, -0.00545829f, -0.04606586f, 0.02931630f, -0.05349767f, 0.03287635f, 0.02543251f, -0.01355873f, 
    -0.02015501f, -0.00633145f, -0.04908112f, -0.02444741f, 0.02623549f, 0.00243790f, 0.01808007f, -0.00587841f, 
    -0.02036176f, -0.02703276f, 0.02956543f, -0.00804449f, 0.00447767f, -0.03233341f, -0.01114804f, -0.00089654f, 
    0.02452554f, 0.00076567f, -0.04791185f, 0.02063622f, -0.05073309f, 0.01086256f, 0.00175975f, 0.02859453f, 
    -0.01931480f, 0.00009968f, -0.04144529f, 0.04240838f, 0.02893541f, 0.03789455f, -0.05826094f, 0.02496761f, 
    -0.00082078f, -0.04282803f, -0.05035701f, -0.04872849f, 0.03810072f, -0.05403568f, -0.00560167f, -0.05854917f, 
    -0.04587558f, 0.02451150f, 0.03700758f, -0.04551416f, 0.02835428f, 0.01854949f, -0.05362780f, -0.05490845f, 
    -0.01250458f, -0.00473418f, -0.04076692f, -0.02994402f, -0.03281506f, -0.03052435f, -0.00138194f, 0.03386002f, 
    -0.05193176f, 0.00844124f, -0.00910054f, 0.02850604f, -0.02653299f, -0.02825687f, -0.01816785f, 0.00712535f, 
    0.03214736f, 0.02445005f, 0.00094801f, 0.01812622f, -0.05778326f, -0.01090552f, -0.05735916f, 0.02491540f, 
    -0.03857172f, -0.04936284f, -0.03547230f, 0.03338986f, -0.01906882f, 0.02022499f, -0.05249201f, 0.00299603f, 
    -0.02106130f, -0.05486557f, 0.03616060f, 0.00261442f, -0.01346216f, 0.03371927f, 0.02661986f, 0.03380039f, 
    -0.04232872f, 0.01062102f, 0.01950251f, 0.00906480f, 0.03843463f, -0.03383355f, 0.00872577f, 0.01336447f, 
    0.03656402f, -0.05274199f, 0.00000881f, 0.03094369f, -0.03195130f, -0.02203127f, 0.03763158f, -0.03636054f, 
    0.02929467f, -0.05095219f, -0.03745616f, 0.04403787f, -0.04396733f, -0.02711882f, 0.00278290f, 0.02864907f, 
    -0.04201412f, 0.02881026f, -0.01497416f, -0.01996616f, 0.01342680f, -0.04431755f, -0.04254531f, -0.04242108f, 
    0.01655384f, -0.03292007f, -0.02981951f, 0.00555287f, -0.01629744f, 0.02257733f, 0.02991734f, -0.05520448f, 
    -0.05671390f, -0.02351779f, -0.01232935f, 0.04645723f, -0.03208127f, -0.00138057f, -0.04413424f, -0.05416767f, 
    -0.02972460f, 0.04230491f, -0.02126466f, -0.01834308f, -0.04423317f, -0.04301924f, -0.01340411f, -0.01899750f, 
    -0.03739422f, 0.01392991f, -0.05672668f, 0.01696528f, -0.02834782f, 0.00952969f, 0.00135458f, 0.03035238f, 
    -0.01220231f, -0.00289764f, -0.03421228f, 0.02733621f, -0.02916257f, 0.03723524f, 0.02933634f, 0.04324179f, 
    -0.02661487f, -0.01957827f, -0.00599878f, -0.04731029f, -0.00119071f, -0.02356824f, 0.01105531f, 0.04008399f, 
    -0.01584650f, -0.01811122f, 0.02034107f, 0.01303505f, -0.05293521f, -0.00330053f, 0.00391846f, -0.03972777f, 
    0.00108820f, 0.01231175f, -0.05404469f, -0.04583557f, -0.02204474f, -0.04862219f, 0.00913457f, 0.04231045f, 
    0.03361260f, -0.04221659f, -0.05290730f, -0.02538059f, 0.03590272f, -0.04544147f, -0.04336646f, -0.00317459f, 
    0.03988038f, 0.03465127f, -0.00463081f, -0.03989992f, -0.05130230f, -0.00937459f, 0.00351096f, 0.02686002f, 
    0.00683704f, 0.03746840f, -0.04839496f, 0.01126249f, 0.00867618f, -0.03972749f, -0.02000577f, 0.02762066f, 
    -0.03742381f, 0.03147396f, 0.03019979f, -0.00128223f, 0.03611838f, 0.03762589f, -0.01001889f, -0.00212914f, 
    -0.02499337f, 0.02942007f, -0.05532238f, -0.02309920f, 0.02184765f, -0.01549521f, 0.02146484f, 0.01946109f, 
    0.00502188f, -0.02380993f, -0.00127277f, -0.04419513f, 0.03802004f, -0.03063625f, 0.00706359f, -0.01704300f, 
    0.00469625f, -0.05648638f, -0.05480401f, 0.03569382f, -0.04405695f, -0.03240278f, 0.00886293f, -0.05381628f, 
    0.00659492f, -0.04167372f, 0.00864925f, 0.01137246f, -0.02175106f, 0.03231619f, 0.01382096f, 0.00243835f, 
    0.00934126f, 0.00759479f, -0.03280757f, -0.00783721f, -0.01093194f, -0.04727370f, 0.00074782f, -0.02115008f, 
    0.02435661f, 0.00354822f, -0.05444286f, 0.03457250f, -0.04835377f, 0.01494392f, -0.05625584f, 0.02797532f, 
    -0.02405645f, 0.00609345f, -0.04054191f, -0.04595890f, 0.01387766f, 0.00106695f, 0.03444482f, -0.01059565f, 
    0.01991308f, 0.01504425f, -0.03476914f, 0.02071445f, -0.02646418f, -0.01517453f, -0.04253924f, 0.00916754f, 
    -0.05086202f, -0.03139443f, 0.01477603f, -0.04477327f, 0.01533347f, -0.02662537f, -0.02974131f, -0.02856279f, 
    -0.04312105f, -0.00360100f, -0.05005991f, 0.04102305f, -0.03106262f, 0.04022570f, -0.02762682f, -0.04087209f, 
    -0.05001083f, -0.05328933f, -0.04753933f, -0.02307417f, 0.02349176f, -0.02543422f, 0.00734927f, 0.02958464f, 
    0.04034126f, -0.05485236f, -0.00237508f, -0.00838744f, -0.01905371f, 0.03351138f, -0.01204915f, -0.02004055f, 
    -0.05041836f, -0.04179116f, -0.03791035f, -0.00626445f, -0.03757854f, 0.01586788f, -0.01850864f, -0.00087772f, 
    -0.04685952f, 0.03353531f, 0.01397388f, 0.00435155f, -0.04684267f, -0.04648278f, 0.04010996f, -0.04421433f, 
    -0.00658869f, -0.03937179f, -0.00685916f, -0.02019596f, -0.02474836f, -0.02268402f, -0.00906863f, 0.04455602f, 
    -0.02446134f, -0.02136694f, -0.00784969f, -0.03263232f, 0.01403645f, -0.05495077f, -0.02399205f, -0.05504302f, 
    0.03619830f, 0.00229892f, -0.01191863f, 0.02478353f, 0.01807566f, 0.01760081f, 0.03813554f, -0.01507645f, 
    0.02420016f, 0.02521613f, 0.03239924f, -0.03657712f, -0.05617343f, -0.04675467f, -0.03887041f, 0.01839654f, 
    -0.05617559f, -0.01631327f, -0.02721400f, -0.01568091f, 0.03034218f, 0.02651970f, -0.01783103f, -0.04618251f, 
    0.03297064f, -0.01734738f, -0.00370651f, 0.00677832f, 0.04233286f, -0.05292495f, -0.02431463f, -0.01724261f, 
    -0.02250218f, -0.00917909f, -0.05454304f, 0.03436137f, -0.03280641f, -0.00485127f, -0.04770827f, 0.02599011f, 
    0.00661410f, -0.03076824f, 0.03628296f, 0.03571454f, 0.03747273f, -0.05444582f, 0.01546611f, -0.02423936f, 
    -0.00743408f, 0.02174490f, -0.05456000f, -0.00365629f, 0.04039458f, 0.04242530f, -0.04544574f, -0.03870332f, 
    -0.03277982f, -0.05408102f, 0.03121556f, -0.03759030f, 0.04041074f, -0.00549913f, -0.02300478f, 0.01783863f, 
    0.03827819f, -0.01773036f, 0.00802327f, 0.03739881f, -0.00639227f, 0.01760628f, 0.02770207f, -0.01950150f, 
    -0.02353077f, 0.01058372f, -0.00258634f, -0.02089173f, 0.00217967f, 0.00531935f, -0.04280134f, -0.01020131f, 
    0.01872370f, -0.05634370f, -0.04630113f, 0.02491617f, -0.04963324f, -0.03704537f, 0.00075987f, -0.02812012f, 
    -0.03387140f, 0.03295171f, 0.01071087f, -0.03769718f, -0.03439356f, -0.02662049f, -0.02176960f, -0.02010577f, 
    -0.03173834f, 0.01078681f, -0.00456485f, -0.00369292f, -0.04899059f, -0.02746245f, -0.02944287f, -0.03537799f, 
    0.02002779f, -0.02792599f, -0.02315968f, 0.03074425f, 0.03269847f, 0.01984993f, 0.03694292f, 0.04419441f, 
    -0.01181294f, -0.02136065f, -0.02730342f, 0.01801950f, -0.03912830f, -0.03304683f, -0.00204068f, -0.03302506f, 
    -0.04765033f, 0.02596306f, 0.00478356f, 0.04094474f, 0.01439451f, 0.03665774f, -0.01177136f, 0.02487722f, 
    0.03630749f, -0.04076108f, -0.04036288f, 0.01155477f, -0.04199268f, -0.03376146f, -0.05394072f, -0.01448549f, 
    0.02837474f, -0.04914966f, -0.00733443f, 0.00350120f, 0.04077001f, 0.02754767f, -0.00687169f, -0.03459393f, 
    -0.00704045f, 0.03518514f, -0.03009088f, 0.03426729f, 0.03072441f, -0.01900083f, 0.02723445f, -0.01597009f, 
    -0.00865260f, -0.00155732f, -0.04837617f, 0.00343928f, -0.00290299f, 0.01401741f, 0.01645747f, -0.01013137f, 
    -0.01900107f, 0.03995712f, -0.02710772f, 0.04116147f, -0.04756862f, -0.03345628f, -0.05912944f, -0.05413376f, 
    0.03846452f, 0.03345938f, 0.03196014f, -0.05105368f, -0.00314897f, -0.00306377f, 0.02675533f, 0.01698682f, 
    0.02042170f, -0.04124881f, -0.04337724f, 0.04079064f, 0.02350093f, -0.04785968f, -0.00621541f, 0.01805039f, 
    0.02060608f, -0.04425805f, -0.02608523f, 0.02097218f, -0.00498599f, 0.03825749f, 0.03845959f, 0.00030303f, 
    -0.03948743f, 0.03548232f, 0.02395595f, -0.04124363f, -0.02422918f, -0.00368441f, 0.02711006f, -0.01574249f, 
    -0.02731837f, -0.04044718f, -0.05361433f, 0.03377227f, -0.02445716f, -0.04606907f, 0.02177557f, -0.03624579f, 
    0.03443072f, -0.00943027f, -0.00331607f, 0.01855799f, 0.01099516f, 0.02037354f, -0.02565799f, -0.04088270f, 
    0.01212304f, -0.00237536f, 0.00457266f, -0.02791523f, -0.00982608f, -0.04288441f, 0.03227126f, -0.05602440f, 
    0.02506678f, 0.02339312f, -0.00358420f, -0.04245050f, -0.01000077f, -0.01570588f, -0.05751217f, -0.02123666f, 
    -0.02749129f, -0.04499511f, -0.00199160f, 0.01083651f, 0.00082685f, -0.03319308f, 0.00833615f, 0.03805934f, 
    0.02420627f, 0.03529422f, -0.04020196f, -0.00847302f, -0.03659606f, -0.03549099f, -0.03578936f, 0.03655656f, 
    0.02240336f, 0.00153302f, 0.01813632f, 0.02301664f, -0.03701664f, -0.01317623f, -0.02363891f, -0.01829768f, 
    -0.02470675f, -0.04573552f, -0.01102618f, -0.05370496f, 0.02189509f, -0.01920753f, -0.00901232f, -0.00192897f, 
    0.02395741f, 0.03846186f, 0.03567031f, -0.02388886f, 0.03178642f, 0.02323383f, -0.04465200f, -0.03162234f, 
    -0.00987170f, -0.05738360f, -0.01199451f, -0.01020336f, -0.03996808f, 0.01742107f, 0.02429556f, 0.03424877f, 
    -0.03159923f, -0.00872710f, 0.00240697f, 0.01887341f, -0.05002873f, -0.02474645f, 0.01725551f, -0.02761075f, 
    -0.04214939f, 0.00518416f, -0.05156365f, 0.00619890f, 0.02241402f, -0.00176328f, -0.01941091f, 0.01951731f, 
    -0.04314721f, -0.03168692f, -0.03912814f, -0.00353443f, -0.03890898f, -0.03085858f, 0.01266704f, -0.01789442f, 
    -0.05175470f, 0.02045855f, -0.00624932f, -0.02489945f, -0.03307097f, 0.02260502f, -0.02003896f, 0.02618605f, 
    0.01367927f, 0.01510134f, 0.00780489f, -0.03130805f, 0.03431279f, 0.02337897f, 0.01712584f, -0.04644762f, 
    0.04139935f, -0.04802127f, -0.05071957f, 0.02713742f, -0.04403581f, -0.01482861f, -0.04305522f, -0.04198170f, 
    0.01571783f, -0.03732481f, 0.02164799f, -0.00610582f, -0.01998271f, -0.00846261f, 0.01974372f, -0.03134861f, 
    -0.01609795f, -0.00204638f, 0.03014903f, -0.02864268f, -0.00367142f, -0.03370761f, 0.04430348f, -0.04477766f, 
    0.02391017f, 0.04253094f, -0.03467085f, 0.04611932f, 0.01261539f, 0.00524213f, -0.02254335f, 0.04107602f, 
    -0.01689086f, -0.05281411f, -0.04838121f, 0.02986898f, -0.04481737f, 0.01203369f, 0.01475378f, 0.01639388f, 
    -0.04877722f, 0.03329157f, 0.02033493f, 0.00960668f, -0.00071859f, -0.05477826f, 0.03519832f, 0.01450095f, 
    -0.00554722f, -0.00327926f, -0.01908094f, 0.03276310f, -0.03635752f, 0.02569191f, 0.02171979f, -0.03678120f, 
    -0.01301202f, -0.01726496f, 0.02251965f, -0.01429860f, -0.02015900f, 0.00502403f, 0.03121067f, -0.04123984f, 
    -0.00480206f, 0.00855779f, -0.04067840f, 0.01993865f, 0.01201850f, -0.02408014f, 0.03769540f, -0.05845407f, 
    0.00648491f, -0.01668125f, 0.00019521f, 0.03523054f, 0.03436466f, -0.03438578f, -0.02253897f, 0.00817755f, 
    -0.01973805f, -0.01684996f, 0.00469116f, -0.02718272f, -0.00365632f, 0.00225807f, -0.03669759f, -0.02036614f, 
    -0.04861744f, 0.00469644f, -0.05190747f, -0.02228769f, 0.03258812f, -0.02713964f, -0.04076784f, -0.00925703f, 
    -0.04736522f, -0.02856164f, -0.01910763f, 0.02333030f, -0.01861263f, -0.05059576f, 0.02024313f, -0.04068823f, 
    0.00758791f, 0.03944790f, -0.02425983f, 0.03195953f, 0.01871120f, -0.01993053f, -0.02570434f, -0.00604042f, 
    -0.03778079f, 0.02098715f, -0.03198601f, -0.00249182f, 0.00294291f, -0.00445217f, -0.02545116f, 0.02025908f, 
    -0.02051017f, 0.00932583f, 0.00533037f, 0.04599047f, 0.00400156f, 0.03692584f, 0.00654250f, -0.02107297f, 
    -0.02923686f, -0.03713258f, 0.02034126f, 0.00808060f, 0.04457667f, 0.00351397f, 0.00758066f, 0.03519089f, 
    -0.01960271f, -0.01024261f, -0.05108895f, -0.02400415f, 0.00647755f, -0.05087259f, 0.04378604f, 0.03029925f, 
    -0.04966180f, -0.00151442f, -0.00034923f, 0.00840819f, 0.03385663f, -0.03030990f, -0.00839632f, 0.03907485f, 
    0.00049292f, 0.03669519f, -0.01100629f, -0.02289051f, -0.02774329f, 0.04257706f, 0.01366276f, 0.02432585f, 
    0.02796207f, 0.03470882f, -0.03217874f, -0.03635683f, 0.03020654f, -0.00902670f, -0.04215814f, -0.01766299f, 
    -0.04722550f, 0.00792189f, -0.04401463f, -0.03493381f, 0.03030576f, -0.02181343f, -0.04210796f, 0.01640601f, 
    0.02472590f, 0.04503517f, -0.05498252f, -0.04465297f, 0.04506362f, -0.03532458f, 0.01686361f, 0.03396608f, 
    0.02507799f, -0.02828237f, -0.02388521f, -0.02445937f, 0.03922614f, 0.02991841f, 0.04455412f, -0.01645612f, 
    -0.03502386f, 0.01981057f, 0.00020120f, 0.00738979f, -0.05110528f, -0.01992066f, -0.05667133f, -0.05603328f, 
    -0.00584654f, -0.02622845f, 0.03578063f, 0.01921500f, -0.03675600f, -0.02031767f, -0.02790739f, -0.00969197f, 
    -0.05039739f, -0.03045187f, -0.02211993f, 0.01485256f, 0.02837326f, 0.02189996f, -0.01246518f, -0.04578655f, 
    -0.01690025f, -0.01112803f, 0.04014013f, -0.03595366f, -0.01093174f, -0.00075970f, 0.01797649f, 0.01023837f, 
    0.01926845f, -0.04072374f, -0.04694537f, 0.02710902f, -0.04063595f, -0.02482789f, 0.03887106f, 0.00598182f, 
    0.01971383f, 0.00348047f, 0.03869715f, -0.01364779f, 0.01541533f, -0.03839457f, -0.02167184f, -0.05368138f, 
    -0.05062886f, -0.05073364f, -0.02246783f, 0.00025403f, -0.03870424f, 0.04546853f, 0.02002748f, -0.00926716f, 
    -0.04682285f, 0.02649541f, -0.00449711f, 0.00653412f, -0.03275043f, -0.00437896f, -0.02151266f, -0.04110149f, 
    -0.04520111f, -0.02833771f, -0.01209538f, -0.03216077f, -0.00027819f, -0.01261376f, -0.01546869f, 0.00270948f, 
    -0.03671683f, 0.03585731f, 0.00910024f, 0.04536698f, 0.00255721f, -0.00855173f, -0.04536288f, -0.00075825f, 
    -0.04771174f, 0.02869193f, -0.05592283f, -0.02081502f, -0.04505185f, -0.03936004f, 0.02037389f, -0.00637867f, 
    -0.00304209f, 0.00434275f, -0.00966924f, 0.03534970f, -0.04790971f, 0.04269483f, -0.04648853f, -0.05471854f, 
    0.02748086f, 0.02388978f, -0.04587767f, -0.01558355f, -0.05231004f, 0.02862512f, -0.04785250f, -0.04549332f, 
    -0.03202040f, 0.02029694f, 0.01782070f, 0.03973584f, 0.02290243f, 0.02871520f, -0.00771873f, -0.01350271f, 
    0.02198455f, 0.01050841f, -0.00136093f, 0.03772228f, -0.04262778f, 0.02488488f, -0.01980145f, -0.01710422f, 
    -0.05156615f, -0.05215023f, -0.04024253f, -0.01186374f, -0.04708341f, -0.05544520f, 0.00431990f, -0.00305328f, 
    0.03199749f, -0.00416833f, 0.02864867f, 0.00034537f, -0.04318726f, 0.03880354f, 0.01967777f, 0.04216862f, 
    -0.04145838f, 0.01262474f, -0.04990327f, 0.03566581f, -0.04240920f, -0.04264348f, -0.05230933f, 0.04374297f, 
    -0.04592257f, 0.02180498f, 0.01319700f, -0.02729440f, -0.00242529f, -0.05508303f, -0.03932271f, 0.02225331f, 
    -0.02741514f, -0.04181203f, 0.02680103f, 0.01445568f, -0.00855202f, -0.01893756f, -0.05510902f, -0.01748104f, 
    -0.05591743f, 0.04381043f, 0.00390159f, -0.00571831f, 0.01875692f, 0.03778221f, -0.02061277f, 0.03415733f, 
    -0.02719817f, 0.04421780f, 0.00763869f, 0.02880928f, 0.01949418f, 0.03339609f, 0.02243649f, -0.03632200f, 
    0.01698144f, -0.01963427f, -0.02549104f, -0.00164990f, 0.00900865f, 0.04168782f, -0.02650800f, -0.00673253f, 
    0.03177966f, -0.03787085f, 0.01076657f, 0.01322115f, -0.03977004f, 0.00557946f, -0.00972707f, -0.01465437f, 
    0.03454115f, 0.04310423f, -0.02654088f, 0.01448100f, -0.04338066f, -0.04472624f, -0.04679447f, 0.02858600f, 
    0.02721201f, -0.00202402f, -0.01204027f, -0.03213240f, -0.05441315f, 0.04309285f, -0.02841156f, 0.02564244f, 
    -0.05215640f, 0.01203740f, -0.05567339f, 0.00620599f, 0.02347586f, 0.01291971f, -0.03865705f, -0.00772372f, 
    0.02862714f, 0.00944756f, 0.01778987f, -0.04717754f, -0.03820087f, -0.04730184f, 0.02330778f, -0.02138596f, 
    0.01361998f, -0.02310463f, 0.03019550f, -0.03184232f, -0.00248099f, 0.02860636f, -0.00156380f, 0.00103590f, 
    0.02430321f, -0.01199346f, 0.00578495f, -0.05398213f, 0.03333748f, -0.03334377f, 0.02688147f, -0.04777996f, 
    -0.02623972f, -0.05030084f, 0.00577540f, -0.04681826f, 0.01032758f, 0.03600139f, 0.00191218f, -0.00268282f, 
    0.03474086f, 0.04499169f, -0.03497370f, -0.00004707f, -0.04830584f, -0.04337867f, 0.04295081f, -0.02684025f, 
    -0.00684845f, 0.01597124f, -0.00193221f, -0.04538504f, 0.00075334f, -0.04968315f, -0.00969522f, 0.01987404f, 
    0.04094370f, -0.02030883f, -0.02485383f, -0.02597532f, -0.00406039f, -0.03069127f, -0.01444446f, 0.00018623f, 
    0.01419587f, 0.02292977f, -0.05210524f, 0.03134396f, -0.01190078f, -0.02697302f, -0.05412591f, -0.02920792f, 
    0.00904964f, 0.02345932f, 0.02597572f, 0.03806032f, -0.00182022f, 0.02474837f, 0.03372922f, -0.02048601f, 
    -0.04574295f, -0.04324266f, 0.01628148f, 0.02035335f, -0.04525943f, -0.04124564f, 0.01129808f, -0.04643937f, 
    -0.05049444f, 0.02333797f, 0.00634667f, -0.04011532f, 0.03990872f, 0.01129372f, -0.00814121f, -0.02430803f, 
    -0.04978314f, -0.04996436f, -0.01638617f, -0.04979461f, -0.02497583f, -0.04051090f, -0.04902641f, 0.04005943f, 
    0.04573626f, 0.04387062f, -0.00470882f, -0.04670195f, 0.01590752f, -0.04861148f, -0.03284445f, -0.03306765f, 
    -0.03843758f, 0.01552195f, 0.02730203f, -0.02433803f, -0.04310225f, 0.02331647f, 0.02006572f, -0.05025101f, 
    -0.02211952f, -0.04160281f, -0.05521713f, 0.01099348f, -0.01162422f, -0.01024454f, -0.02264353f, -0.04051936f, 
    -0.02860703f, 0.02382090f, -0.00345999f, -0.03020991f, -0.00920097f, -0.03208664f, -0.02829998f, -0.02066804f, 
    -0.00498579f, 0.00801899f, 0.02585362f, 0.02015799f, 0.01574699f, -0.03953996f, 0.01763583f, 0.00597916f, 
    0.02191249f, -0.00219339f, -0.01630798f, 0.03693829f, 0.02314127f, 0.00464662f, 0.00552340f, -0.03947068f, 
    0.04422536f, -0.03043782f, 0.01914071f, -0.00432643f, 0.02350433f, 0.00364583f, 0.01553176f, -0.05207306f, 
    0.02400086f, 0.00696386f, 0.01448706f, 0.00991542f, 0.00320726f, 0.04158212f, -0.05034713f, -0.03156164f, 
    -0.02191218f, 0.04148180f, -0.04254174f, 0.02060978f, 0.00473692f, 0.00969394f, 0.01153674f, -0.01963697f, 
    -0.02872225f, -0.02455555f, -0.03579570f, 0.02883337f, -0.05358815f, 0.02587276f, -0.02391605f, -0.01782443f, 
    -0.04562975f, -0.26215088f, -0.10602459f, 0.24403921f, 0.03396965f, 0.05093523f, -0.01052583f, 0.10167569f, 
    -0.04031932f, 0.01341122f, 0.05916752f, 0.13453853f, -0.14627004f, -0.05814255f, -0.03234597f, 0.02673887f, 
    0.11952521f, -0.04289978f, 0.07562225f, 0.15126389f, 0.12262584f, 0.05658116f, 0.09350803f, 0.10280556f, 
    -0.33265239f, 0.14659649f, -0.09604008f, 0.01442166f, 0.06982923f, -0.02975920f, 0.03456277f, -0.13251315f, 
    0.01046746f, -0.05455866f, 0.08777725f, 0.24781099f, 0.05433303f, -0.18802859f, 0.16959447f, 0.06347018f, 
    0.01456881f, 0.07521079f, 0.01493127f, -0.00006260f, 0.14492631f, -0.08077040f, 0.03129827f, 0.02461216f, 
    0.10950387f, -0.14693052f, -0.03158106f, -0.11044019f, -0.02622787f, 0.08436339f, 0.20524055f, -0.05412275f, 
    0.00844611f, 0.02501336f, 0.24220090f, 0.07786826f, -0.01112049f, -0.16748701f, -0.05224593f, 0.02112949f, 
    0.19606611f, 0.03378560f, -0.07533622f, 0.11272064f, 0.05256437f, -0.05916749f, 0.13627653f, -0.23773013f, 
    -0.18019900f, -0.13497339f, -0.14210781f, -0.12856832f, 0.06766897f, 0.01738813f, 0.04312049f, 0.11502190f, 
    0.06244803f, 0.07235236f, 0.07340425f, 0.02108234f, 0.00840938f, -0.06413542f, 0.03976309f, 0.10545973f, 
    -0.06536698f, 0.04806229f, -0.04644647f, -0.05544480f, 0.01756100f, 0.06070006f, 0.02401005f, 0.16731015f, 
    -0.37903786f, 0.21249418f, -0.08289640f, -0.07272518f, -0.02449237f, -0.07713391f, -0.05144467f, -0.01962626f, 
    -0.05059113f, 0.07304902f, 0.00933516f, 0.10835724f, 0.18776573f, -0.04276602f, -0.00414555f, -0.15640555f, 
    0.10445599f, -0.09915436f, 0.00868749f, -0.12811917f, 0.08708803f, -0.00079994f, -0.04403847f, -0.13424549f, 
    -0.15338232f, 0.18958858f, 0.05305510f, -0.03918211f, -0.11605158f, -0.00701931f, -0.03141037f, -0.03106511f, 
    0.00074648f, 0.00779460f, 0.00798941f, 0.03253106f, -0.17948306f, 0.30901411f, -0.02508815f, -0.10010906f, 
    -0.05658899f, 0.06150816f, -0.03384280f, 0.07612434f, 0.11156739f, -0.02311693f, -0.01015427f, -0.02936922f, 
    0.29464808f, 0.04530892f, -0.01677138f, -0.19447133f, -0.05839508f, -0.00115094f, -0.07237267f, 0.01814113f, 
    0.09418415f, 0.06367040f, 0.11025951f, 0.09569009f, 0.21623477f, -0.17849487f, -0.12938651f, 0.15145694f, 
    0.09887026f, -0.08481676f, -0.09257139f, 0.06209773f, 0.21987680f, 0.00910906f, 0.03704933f, -0.08106853f, 
    -0.02723791f, 0.30558291f, -0.06625780f, 0.05358459f, -0.02311218f, 0.11081922f, 0.09677795f, -0.14147919f, 
    0.08310394f, -0.12780197f, 0.03519282f, -0.06199196f, -0.10616423f, 0.20481753f, -0.07947867f, 0.08767926f, 
    0.11139347f, -0.06246349f, -0.21279268f, 0.10097203f, 0.08765099f, -0.00793225f, -0.09159162f, 0.04535605f, 
    0.36347923f, -0.28871611f, -0.16804250f, 0.11412229f, 0.09579983f, 0.05488831f, 0.02961205f, -0.05137644f, 
    0.02607972f, 0.02116659f, -0.07005902f, -0.00847464f, -0.09840166f, -0.12665804f, 0.07110628f, 0.12752476f, 
    -0.06808566f, 0.00002854f, -0.06064469f, -0.03929561f, 0.10148082f, -0.11322613f, -0.14209448f, -0.03029170f, 
    -0.10411932f, -0.01535879f, 0.06697608f, -0.06883539f, 0.17463003f, -0.15581314f, 0.20664985f, 0.03955545f, 
    -0.01825252f, 0.07727549f, -0.05464080f, 0.16449744f, 0.14633375f, -0.17428324f, 0.16532971f, 0.19637674f, 
    0.12891111f, -0.06833012f, -0.02172009f, -0.00773480f, -0.02408206f, 0.10705682f, 0.01595015f, 0.16912901f, 
    0.03258017f, -0.01639028f, -0.00785404f, -0.13208534f, 0.01785956f, 0.15814987f, 0.03329590f, 0.11097889f, 
    0.12643248f, -0.09251481f, -0.18171257f, 0.10022071f, -0.28291377f, -0.04030844f, 0.04540639f, -0.10716560f, 
    -0.03771600f, 0.07511294f, 0.10475274f, -0.03772222f, 0.03801430f, -0.02609274f, 0.00694652f, 0.12933321f, 
    -0.00817164f, 0.08919639f, -0.14672145f, 0.11775316f, 0.09736570f, -0.05607906f, -0.04042327f, 0.05152719f, 
    0.07098437f, 0.04455814f, 0.09950791f, 0.01903997f, -0.06002915f, 0.08620398f, 0.14184269f, 0.10732560f, 
    0.11300096f, -0.03264124f, 0.04784958f, -0.03527056f, -0.02678839f, -0.05927051f, -0.04230539f, -0.02943488f, 
    0.37258360f, -0.01641481f, -0.07313092f, 0.37793985f, 0.03531737f, -0.02688086f, -0.00225685f, -0.00269911f, 
    0.05443415f, -0.04231738f, 0.03572562f, 0.03896036f, -0.10743566f, 0.09086099f, -0.06728733f, -0.11360034f, 
    0.08413823f, 0.15085045f, 0.02070211f, 0.06665779f, 0.05699191f, -0.09073056f, 0.00039613f, 0.13059121f, 
    -0.20430525f, -0.00787003f, 0.00240009f, -0.13224998f, -0.11270243f, -0.10129383f, 0.01063480f, 0.03848672f, 
    0.13502257f, -0.09151679f, -0.05184639f, -0.08660739f, 0.22008604f, -0.05238266f, 0.08365233f, 0.11166794f, 
    0.15385585f, -0.02317528f, 0.00848373f, 0.01475283f, -0.05125307f, 0.08792119f, -0.03040044f, 0.11124921f, 
    -0.06796157f, -0.02593603f, 0.01628660f, 0.20481314f, -0.01581977f, -0.03354225f, 0.15422224f, 0.19800192f, 
    0.14788106f, 0.05784793f, 0.21157163f, 0.12345910f, -0.01425411f, -0.02633747f, 0.00394136f, -0.00605043f, 
    0.04038345f, -0.05528706f, -0.18732692f, -0.05570322f, -0.02338658f, 0.03279145f, -0.00971420f, -0.13286318f, 
    -0.15516256f, -0.12707682f, 0.16641702f, 0.04664251f, -0.01926707f, -0.03829384f, 0.04820434f, 0.02808920f, 
    0.03760927f, 0.03475113f, -0.00450177f, -0.07129107f, 0.12665574f, -0.00709441f, 0.05677643f, 0.03800435f, 
    0.05618621f, -0.03863138f, -0.02023485f, 0.06397929f, 0.23823264f, 0.05367345f, 0.07022556f, -0.05968489f, 
    -0.33448666f, -0.04805298f, -0.05436996f, 0.04149941f, 0.09297959f, -0.03285610f, 0.06225318f, 0.04316461f, 
    -0.06779002f, -0.03588866f, -0.08324446f, -0.04209987f, 0.33146611f, 0.02033372f, -0.10990683f, -0.02190519f, 
    0.02074164f, -0.04143284f, 0.06206685f, -0.00440408f, -0.00069970f, 0.12010044f, 0.06048836f, -0.28135580f, 
    0.05909946f, -0.30650380f, 0.04740830f, 0.04869089f, 0.04380115f, -0.07616264f, 0.01293853f, 0.02056876f, 
    -0.01654081f, 0.14573669f, 0.01682162f, -0.03872469f, -0.19773325f, 0.10232569f, -0.01524414f, -0.01451338f, 
    0.12920561f, 0.09145660f, 0.03557476f, 0.10274153f, 0.07207952f, 0.01705350f, 0.07568289f, -0.01644617f, 
    -0.05988179f, 0.28546628f, 0.10677896f, -0.01318837f, -0.01234558f, -0.01159488f, 0.01094592f, 0.11354815f, 
    0.11170274f, 0.11256877f, 0.09088145f, -0.04622076f, 0.19321705f, 0.06626634f, 0.02631191f, 0.00801816f, 
    -0.12086082f, 0.00511666f, 0.09795542f, 0.07632054f, -0.02943981f, 0.04682523f, 0.06496522f, 0.03075920f, 
    0.34368515f, 0.23784462f, 0.00805879f, -0.04158482f, -0.11197706f, -0.19503781f, -0.14655110f, -0.13623500f, 
    -0.08647331f, 0.01222239f, -0.10239072f, 0.04895626f, 0.04890180f, 0.04532380f, 0.06532684f, 0.11917845f, 
    0.09175280f, -0.07476988f, -0.06577524f, -0.02246589f, 0.15609048f, 0.18548031f, -0.04807340f, -0.04364394f, 
    0.08521736f, 0.05628195f, 0.17585523f, -0.04782883f, 0.13398732f, -0.00893703f, -0.01128748f, -0.03018536f, 
    -0.07213748f, 0.05367293f, -0.00265324f, 0.07941978f, 0.06063608f, -0.13193327f, 0.01119400f, -0.02234874f, 
    -0.03998951f, -0.00100576f, -0.15669775f, -0.06524322f, 0.04972879f, 0.04081069f, 0.03879283f, 0.03756554f, 
    0.21541859f, -0.13299425f, 0.14852545f, -0.20832287f, -0.11534769f, 0.01541163f, 0.10434527f, 0.03922245f, 
    0.03877833f, -0.05925002f, 0.05984396f, -0.00656125f, -0.04454541f, 0.16247949f, 0.07532835f, -0.10052773f, 
    0.03166835f, -0.08256733f, -0.00240372f, -0.06646950f, -0.10818549f, 0.03399415f, -0.07246521f, 0.08490424f, 
    -0.57227123f, -0.22965884f, -0.03083983f, 0.17272031f, 0.13878149f, -0.01322282f, -0.00730757f, 0.01478522f, 
    -0.03664170f, 0.08543471f, -0.01153859f, 0.00162328f, -0.12928528f, -0.17167689f, 0.12221731f, 0.10917037f, 
    -0.01456684f, 0.03114368f, 0.06890696f, -0.02322410f, -0.18877675f, -0.01652454f, 0.06812485f, -0.03257922f, 
    0.07824091f, 0.05768284f, 0.17837015f, 0.03443133f, -0.11281461f, -0.14081357f, -0.12347626f, 0.06962464f, 
    0.02544212f, -0.00944232f, 0.03936247f, 0.19977444f, 0.23553124f, -0.02687231f, 0.06043492f, -0.09848557f, 
    -0.30177295f, -0.00914969f, 0.04851431f, -0.10904595f, -0.01665723f, 0.11992626f, 0.11318002f, 0.11140609f, 
    -0.37306437f, 0.16410382f, -0.12031787f, 0.01345887f, -0.06481042f, -0.06619423f, -0.00424724f, -0.01977434f, 
    -0.02356602f, 0.03525277f, 0.00800135f, 0.00183425f, 0.19826254f, 0.10384753f, 0.02736230f, 0.05472169f, 
    0.05396403f, 0.09898239f, -0.04364818f, 0.01575967f, -0.03014694f, 0.10786030f, -0.08182948f, -0.00885487f, 
    0.23426683f, 0.13410650f, 0.16319147f, 0.03857668f, -0.03273990f, -0.01583352f, 0.07122506f, -0.04258589f, 
    0.03173560f, 0.07396437f, 0.03280465f, -0.01780662f, 0.00566894f, 0.06472255f, -0.29086736f, -0.16363701f, 
    -0.11806935f, 0.12374553f, 0.03021129f, -0.04619995f, -0.05388669f, -0.08441711f, 0.09408872f, -0.09687218f, 
    0.19250967f, 0.16578868f, 0.12882037f, 0.16161351f, -0.03696511f, -0.10918975f, -0.06497428f, 0.04421947f, 
    -0.03097429f, 0.18536057f, 0.15087251f, -0.09824428f, 0.39809415f, 0.18317923f, 0.17815790f, -0.03369323f, 
    0.00016019f, -0.08800688f, -0.07147428f, -0.06533314f, 0.03793376f, -0.08922409f, -0.07863392f, -0.07549687f, 
    -0.06798474f, -0.07902249f, -0.07458618f, 0.21014865f, -0.10332236f, -0.01080462f, 0.05213074f, 0.00994330f, 
    0.01215500f, 0.01288625f, 0.05081736f, -0.02213486f, -0.01339778f, 0.23586057f, 0.08763143f, 0.09373943f, 
    -0.09502416f, -0.03511183f, -0.23311169f, -0.07969622f, 0.00257077f, 0.07268750f, 0.14200489f, 0.11503428f, 
    -0.43723825f, -0.19958675f, 0.09209494f, -0.08109248f, 0.08524502f, 0.03158595f, 0.02611084f, 0.10314122f, 
    -0.07996774f, -0.05119167f, 0.10942513f, 0.07708032f, 0.17574987f, -0.12316261f, 0.16039538f, 0.08436701f, 
    -0.02823120f, -0.12904879f, -0.02497334f, -0.01638320f, 0.02368382f, -0.08610920f, -0.03414578f, 0.09933499f, 
    -0.05982115f, 0.01600081f, 0.16546312f, -0.01052093f, 0.08934786f, 0.10789253f, 0.04314464f, 0.08421727f, 
    -0.11311540f, -0.02053728f, 0.03944508f, -0.02170811f, -0.06666798f, 0.08368725f, -0.02332237f, 0.01078235f, 
    -0.13827887f, -0.02113241f, 0.03460570f, -0.06604773f, 0.18318978f, 0.00643615f, -0.08036121f, 0.07660186f, 
    0.14884874f, -0.07822243f, 0.04913745f, 0.03402431f, -0.03202083f, 0.11551515f, 0.04373002f, -0.10203700f, 
    -0.04950994f, -0.11184628f, 0.03546120f, -0.01498363f, 0.10487058f, -0.06408440f, 0.20254476f, -0.09599251f, 
    0.00195165f, 0.09446181f, 0.07543174f, 0.01807972f, -0.07593126f, -0.08876357f, -0.04239079f, -0.06195437f, 
    0.04597035f, 0.08515309f, 0.03696189f, -0.07254454f, 0.02828507f, -0.18998618f, -0.04334450f, -0.04500410f, 
    0.04497258f, 0.06507782f, -0.09435868f, 0.08176561f, -0.09270038f, 0.33677167f, 0.09245838f, -0.07796825f, 
    0.00886448f, -0.10404310f, -0.02504302f, 0.06338626f, 0.01559765f, -0.02264944f, 0.08340529f, -0.01254369f, 
    -0.03151223f, -0.00808915f, -0.03244326f, 0.03591394f, -0.00831023f, -0.02366957f, -0.00028030f, -0.00320951f, 
    0.03917589f, -0.00123323f, -0.00250651f, 0.04045584f, -0.01661292f, -0.01372901f, -0.04962047f, -0.05251264f, 
    0.04286328f, -0.03879055f, 0.00640705f, 0.02383559f, 0.01548404f, -0.01176577f, -0.03876249f, 0.00511243f, 
    0.03502540f, 0.04292666f, 0.02761901f, 0.04050397f, -0.01770579f, 0.00983584f, -0.05478378f, 0.00900850f, 
    -0.02826300f, -0.03687775f, 0.02916776f, -0.02621566f, 0.02039833f, -0.03157287f, -0.01811913f, 0.00013491f, 
    -0.05579546f, 0.01783087f, -0.03147659f, -0.04188249f, -0.01633454f, -0.03079414f, 0.00784708f, -0.03741923f, 
    -0.04913263f, 0.00575294f, -0.03956359f, -0.04154224f, -0.00108722f, 0.02080097f, -0.02421883f, 0.01842753f, 
    -0.05558426f, -0.01018779f, 0.02648469f, -0.00003794f, -0.00550614f, 0.04561977f, 0.00491617f, 0.02116913f, 
    0.02089518f, 0.00381040f, 0.04443009f, -0.04290142f, 0.01571421f, 0.04391595f, -0.02273801f, -0.01165682f, 
    0.03148085f, -0.02701737f, -0.01262310f, 0.03127679f, -0.05298637f, 0.02020969f, -0.00652685f, 0.02571167f, 
    0.02475657f, -0.04487089f, 0.00915623f, -0.01151201f, -0.01625538f, -0.01416815f, 0.03113231f, -0.04941463f, 
    0.02485079f, 0.02858101f, -0.03624970f, -0.04765219f, -0.02091397f, 0.01964997f, -0.00090474f, -0.03894717f, 
    -0.01679419f, -0.00179576f, 0.04336298f, -0.04864258f, -0.03672433f, 0.03485706f, -0.00289146f, -0.00714839f, 
    0.02695496f, 0.00004819f, -0.03253494f, -0.03664901f, -0.05521392f, -0.03143281f, -0.02509683f, -0.03666573f, 
    0.01801881f, 0.02136250f, -0.05144515f, 0.02806270f, -0.05092952f, -0.01858855f, -0.00629024f, 0.03937583f, 
    -0.04900312f, 0.03356468f, -0.04282654f, 0.00692703f, -0.02911040f, 0.02686956f, -0.02564175f, 0.02062363f, 
    0.02235348f, -0.05080310f, 0.02745427f, -0.00677415f, 0.03967753f, -0.01489010f, -0.01184645f, -0.02599312f, 
    -0.04009017f, -0.02986868f, 0.03959545f, -0.02778420f, -0.03251538f, 0.00786521f, 0.01713636f, 0.02770210f, 
    -0.02549768f, 0.03728351f, -0.04182287f, 0.01357522f, -0.00553658f, -0.02980863f, -0.04373946f, -0.05347972f, 
    0.04398938f, 0.03819836f, -0.05252946f, -0.03237329f, -0.02311924f, 0.00385550f, -0.01736535f, 0.00168780f, 
    0.01728884f, -0.01604860f, -0.04734224f, 0.00660902f, -0.02661624f, 0.00998441f, -0.01431285f, -0.03575171f, 
    -0.01137528f, -0.05543474f, 0.04412501f, -0.02948468f, -0.04467095f, -0.00870832f, 0.00038342f, -0.04146554f, 
    0.02863411f, -0.02013337f, 0.02479010f, 0.04158536f, -0.03218633f, 0.03109257f, -0.03077628f, -0.03604228f, 
    0.02572200f, 0.01006171f, -0.04528493f, -0.03858139f, 0.00584142f, -0.00900585f, -0.02337942f, -0.00663080f, 
    -0.01082800f, -0.04524693f, -0.03701119f, -0.04829848f, -0.04930839f, -0.03722353f, -0.01102849f, 0.00322256f, 
    0.02478230f, -0.01621785f, -0.04739425f, -0.00697816f, 0.03156823f, -0.03885255f, -0.04238547f, -0.01231526f, 
    0.00053244f, 0.01930046f, -0.01616720f, -0.03723836f, 0.04180773f, -0.00526481f, 0.01205020f, -0.02835909f, 
    -0.05516022f, -0.03983764f, 0.00517425f, -0.03714125f, 0.00229014f, 0.02807399f, -0.00254831f, -0.03859457f, 
    0.03377159f, 0.02642204f, -0.04941089f, -0.05354669f, -0.01421998f, 0.02864386f, -0.00318285f, -0.03332543f, 
    -0.02595009f, -0.03347230f, -0.00928360f, -0.05384240f, -0.01736353f, -0.01828081f, 0.02506966f, 0.00938035f, 
    -0.05212833f, 0.01435913f, -0.04484048f, 0.01358812f, 0.03480028f, 0.03124616f, 0.00466865f, -0.02242432f, 
    0.02216199f, -0.03017751f, -0.05338838f, 0.02655829f, -0.02107741f, 0.03372559f, -0.04976396f, 0.00033795f, 
    0.00664981f, -0.00824400f, -0.02975829f, -0.04081989f, -0.05560611f, -0.03382296f, 0.01546247f, -0.00861957f, 
    0.04480129f, 0.00232257f, 0.01980250f, -0.01411684f, -0.04787536f, 0.03782100f, -0.02656369f, 0.01505092f, 
    0.00301198f, 0.04387801f, 0.04204985f, 0.04255345f, -0.03658929f, -0.02946427f, -0.03154134f, -0.02291435f, 
    -0.00082009f, -0.03492257f, -0.00113716f, -0.00568589f, 0.00655525f, -0.03528198f, -0.02848427f, -0.04472068f, 
    0.02202773f, -0.02198678f, -0.03973595f, 0.03794083f, 0.02908059f, 0.04376067f, 0.03913058f, -0.01982638f, 
    -0.05283600f, 0.02535512f, 0.00506013f, 0.01244399f, 0.00189866f, 0.01780077f, -0.04240598f, -0.05379265f, 
    0.03651734f, -0.04146346f, -0.01199723f, -0.00047665f, -0.04142018f, 0.00163951f, -0.05460374f, 0.03618463f, 
    -0.00789342f, -0.00257143f, 0.00736729f, -0.01701697f, 0.03951409f, -0.01156604f, -0.04736698f, 0.00446842f, 
    0.02501633f, -0.01081125f, -0.01610645f, -0.04774875f, -0.01531337f, 0.02275310f, -0.05560605f, -0.03219754f, 
    -0.04569162f, -0.02872739f, -0.05404659f, 0.01234523f, -0.00746519f, 0.02908041f, 0.00917223f, -0.03821820f, 
    -0.04921922f, 0.03474769f, 0.01971021f, 0.02421419f, -0.00958093f, -0.00801344f, -0.02209526f, 0.02057315f, 
    0.02579138f, 0.00445102f, 0.00694931f, -0.04575263f, 0.01619172f, 0.02510723f, -0.00734988f, 0.03365279f, 
    -0.03131097f, -0.03064005f, -0.04322932f, 0.02258431f, -0.00098828f, 0.01631538f, -0.03946785f, -0.03921941f, 
    0.02028992f, -0.03040929f, 0.01106868f, -0.00544022f, -0.04957231f, -0.01358880f, 0.01516908f, -0.00681131f, 
    0.01813312f, -0.01068333f, -0.05251965f, -0.02099446f, -0.02611458f, -0.00433730f, 0.04181842f, -0.01446267f, 
    -0.02355280f, 0.03408409f, -0.01512463f, 0.02024864f, -0.05337998f, 0.00831858f, 0.03175166f, 0.00849330f, 
    -0.00092994f, -0.24162257f, -0.15757202f, 0.17560324f, 0.08477727f, -0.00709640f, -0.01166375f, -0.04232430f, 
    -0.02978621f, 0.05137457f, -0.02700585f, -0.01629958f, 0.01586490f, -0.13294999f, 0.14884672f, -0.00197043f, 
    -0.03175821f, -0.06526686f, 0.05705047f, -0.02858475f, 0.06099397f, 0.06246090f, -0.01522309f, -0.00789933f, 
    0.02598356f, -0.19395727f, -0.14432064f, 0.09017928f, -0.09578962f, 0.00088567f, 0.15815230f, -0.15396775f, 
    -0.02447376f, 0.01635968f, 0.09580075f, 0.01276125f, 0.13826355f, -0.02468145f, -0.08021833f, 0.09973516f, 
    0.23525345f, -0.01242409f, -0.01712559f, 0.03637605f, 0.01758622f, 0.13430546f, -0.02611526f, 0.05306510f, 
    -0.03335072f, 0.14728373f, 0.02772605f, -0.10785525f, -0.04774762f, 0.00201506f, 0.13260891f, -0.03984782f, 
    0.01292423f, 0.12676077f, 0.19742589f, 0.03569889f, 0.31340456f, 0.13992727f, -0.09003425f, 0.08446226f, 
    -0.00729950f, 0.00700216f, 0.03884977f, 0.10319070f, 0.03472605f, -0.01902680f, 0.04284967f, -0.12127273f, 
    0.32904860f, 0.00749887f, -0.00523066f, -0.10465733f, -0.15554610f, -0.05138288f, -0.04004566f, 0.01486726f, 
    0.06032552f, 0.09621296f, 0.16134487f, -0.04955272f, 0.01193816f, -0.03661440f, -0.00769755f, 0.13333181f, 
    -0.01557925f, -0.02669015f, 0.06542229f, 0.04667534f, 0.10055152f, 0.09088947f, -0.05775146f, 0.09556564f, 
    0.24064408f, 0.06119679f, -0.00456141f, -0.02181467f, 0.04384988f, -0.08564583f, -0.03027796f, -0.00253025f, 
    -0.11542063f, 0.19067679f, -0.10194959f, 0.11899620f, 0.21617535f, 0.18107820f, -0.02112074f, -0.07575226f, 
    -0.10890878f, 0.00224574f, 0.03486490f, 0.00418020f, -0.02633188f, -0.03724360f, -0.05284574f, -0.11334433f, 
    0.02583713f, 0.23246819f, 0.08920450f, -0.00772603f, -0.10156885f, -0.03589415f, -0.00765283f, -0.14427750f, 
    -0.05976074f, 0.02638953f, -0.03077288f, 0.02018470f, 0.02653987f, 0.09816384f, -0.05279317f, -0.01915385f, 
    0.07471520f, 0.11299868f, -0.10166735f, -0.05661552f, 0.03470909f, -0.01429950f, 0.02352812f, -0.05685381f, 
    0.09134397f, 0.17279442f, -0.04578011f, 0.08748726f, -0.09469550f, 0.01613392f, 0.06124789f, 0.06690440f, 
    -0.01031578f, 0.02763707f, 0.10211815f, 0.06875367f, -0.17086001f, -0.10557689f, -0.17175001f, 0.06629225f, 
    0.11385709f, -0.02332268f, -0.06792504f, -0.04261332f, 0.11244650f, 0.02417266f, -0.00554494f, -0.09701555f, 
    0.06630822f, 0.26148519f, 0.08864351f, 0.04200132f, -0.10522170f, -0.00521220f, 0.05022556f, 0.05883351f, 
    -0.05575621f, -0.06551377f, -0.06753317f, 0.03102357f, 0.26840416f, 0.18721296f, 0.16054286f, 0.06344385f, 
    -0.10636435f, -0.06226819f, -0.02753369f, 0.05948967f, -0.01745575f, -0.14810318f, -0.03283650f, 0.06163301f, 
    0.18960348f, -0.05775364f, -0.07269084f, 0.02542523f, 0.15261076f, 0.05548718f, -0.04981175f, 0.01450508f, 
    -0.05836121f, 0.06113419f, 0.08683942f, -0.01261520f, 0.01401106f, -0.11382513f, 0.04776436f, 0.02434182f, 
    -0.00780606f, 0.02063736f, -0.01221025f, -0.11651537f, -0.03108657f, 0.04367988f, -0.03066157f, -0.05614080f, 
    0.02429099f, -0.01078766f, 0.00361070f, -0.15351345f, -0.11004984f, -0.10933506f, -0.01844145f, 0.07917694f, 
    0.05269397f, -0.18626899f, 0.02662618f, 0.04384861f, -0.11281408f, -0.30045351f, 0.28341329f, 0.35316682f, 
    0.07596041f, -0.04366551f, 0.04457578f, -0.06731978f, 0.00799009f, 0.11670389f, 0.06532057f, 0.17686775f, 
    -0.26651192f, 0.01580130f, 0.22989084f, -0.01844550f, -0.04413386f, 0.12756273f, -0.04464667f, 0.00803552f, 
    0.10486047f, -0.03817498f, -0.07558109f, -0.03763188f, 0.01632433f, 0.00959566f, 0.19523166f, 0.04910615f, 
    0.02823557f, 0.11388488f, 0.04299471f, -0.07850076f, 0.10207535f, 0.00119049f, 0.07176566f, 0.00466418f, 
    -0.10801762f, -0.13661453f, -0.02393680f, 0.08830819f, -0.00016936f, 0.08675495f, -0.08046582f, -0.05719184f, 
    0.03088962f, -0.08664377f, 0.06039886f, -0.13871267f, 0.10257952f, 0.02568710f, 0.25473416f, -0.01743519f, 
    0.01394769f, -0.02262104f, 0.03636818f, 0.00602009f, -0.06576608f, -0.00693882f, -0.00493495f, -0.00257127f, 
    0.21976824f, -0.23192278f, -0.21201883f, 0.28070831f, -0.05689048f, -0.00045966f, -0.00349110f, -0.06728233f, 
    -0.00624347f, 0.10423136f, 0.00702335f, 0.10602204f, -0.01559019f, 0.20694166f, 0.19205564f, 0.00658100f, 
    0.10820836f, 0.08543453f, 0.09856725f, -0.05375753f, 0.02661841f, 0.09161380f, 0.06266171f, 0.04264535f, 
    -0.09635859f, 0.16666307f, -0.21310548f, 0.04916240f, 0.07428393f, -0.04767979f, -0.05121157f, 0.02859691f, 
    -0.00918411f, -0.03216357f, -0.13957056f, -0.08815550f, 0.09707934f, 0.08076033f, 0.15644936f, 0.08396560f, 
    -0.03367522f, 0.02370266f, -0.13483290f, -0.10420544f, -0.17256822f, 0.17738092f, -0.00127911f, 0.03611704f, 
    0.03102933f, 0.07679234f, 0.02187374f, -0.09292440f, -0.04785556f, 0.00320228f, -0.14806278f, 0.04788302f, 
    0.01825140f, -0.03557330f, 0.07147206f, 0.00962966f, -0.07576674f, 0.09894706f, 0.16618828f, 0.08452395f, 
    0.03132010f, 0.02082202f, -0.08783831f, 0.02882881f, -0.01655654f, -0.06300423f, -0.20627722f, -0.02957413f, 
    0.32424176f, 0.23330215f, 0.16741312f, 0.04974417f, 0.10880314f, 0.02817194f, 0.08414284f, 0.11326182f, 
    -0.00893757f, 0.03589829f, 0.03108014f, -0.06594067f, 0.02578744f, 0.15164268f, -0.00894683f, 0.11875838f, 
    0.15453166f, 0.01135761f, -0.13660981f, -0.09142657f, 0.13009225f, -0.06552620f, 0.04330917f, -0.09935338f, 
    0.07457544f, -0.00741498f, -0.11913314f, 0.08760571f, 0.12113764f, 0.03114713f, 0.01721528f, -0.05396141f, 
    0.01304055f, 0.02269544f, -0.06408771f, 0.11516102f, 0.35394269f, -0.00113320f, -0.06378367f, 0.03248288f, 
    -0.04360214f, 0.03664613f, 0.06399155f, -0.04634591f, 0.02817555f, 0.13765524f, 0.14703108f, -0.03646703f, 
    -0.22013238f, 0.09923053f, -0.04453026f, -0.03478311f, 0.00708671f, 0.03214040f, -0.03199315f, -0.05160474f, 
    0.00149193f, -0.02624170f, 0.05927235f, 0.04354879f, 0.25054634f, -0.00440662f, -0.26781267f, 0.20854898f, 
    0.21826567f, 0.01230858f, 0.18536122f, 0.07808999f, 0.04420385f, 0.03581088f, 0.06847091f, 0.01739408f, 
    0.31261447f, -0.06756169f, -0.10803248f, 0.12014154f, -0.01917712f, -0.03743059f, -0.06812713f, 0.09809532f, 
    0.02387842f, -0.00288401f, 0.02796831f, -0.00738943f, -0.02738382f, -0.09442800f, -0.09388702f, -0.11802701f, 
    -0.09838722f, -0.00528445f, 0.05349877f, 0.11601797f, 0.04399909f, -0.02802817f, 0.05008313f, -0.11696408f, 
    0.04019427f, -0.05358450f, -0.02297607f, 0.04664126f, -0.04790537f, -0.00540753f, -0.04449219f, 0.04051838f, 
    -0.09848326f, -0.01159847f, 0.03921881f, 0.15653811f, -0.29167944f, 0.06019466f, 0.08039328f, 0.16588588f, 
    0.00985777f, 0.01514899f, 0.03787674f, 0.18252511f, 0.16991356f, 0.08375495f, 0.06476778f, 0.02645995f, 
    0.00765991f, 0.20617683f, 0.06987070f, -0.02738189f, 0.03144311f, 0.09207734f, -0.13679156f, 0.06197872f, 
    -0.07317188f, 0.14692859f, 0.09427422f, -0.03722376f, 0.19756272f, -0.36445281f, -0.11369322f, -0.12639280f, 
    0.10600901f, 0.04254358f, -0.04032602f, -0.02947105f, 0.05820464f, 0.05622587f, -0.11318404f, -0.06436014f, 
    0.26927945f, -0.07633186f, 0.11401348f, -0.06609064f, 0.05823719f, 0.16260509f, 0.07812598f, -0.02967226f, 
    -0.06822229f, 0.09753163f, 0.04792284f, -0.05996143f, -0.57436311f, 0.21603407f, 0.02349401f, -0.14435935f, 
    0.06832441f, 0.08778463f, -0.02369516f, 0.15771547f, 0.07884659f, 0.00755728f, 0.07225679f, 0.02593374f, 
    0.06450538f, -0.01131906f, -0.16401978f, 0.19128242f, -0.01331948f, -0.02459005f, -0.01902859f, 0.05441408f, 
    0.16708320f, 0.03296040f, 0.00194994f, 0.10886632f, -0.06901776f, -0.16538596f, 0.02293230f, -0.03829725f, 
    -0.00881852f, 0.04084375f, -0.05333543f, 0.06777688f, 0.06385010f, -0.05788788f, 0.01811448f, 0.04583272f, 
    0.06292828f, 0.09530648f, -0.02279841f, -0.04419915f, -0.01611920f, -0.10067053f, -0.01294826f, 0.01566580f, 
    0.02892262f, -0.08887196f, -0.05063038f, 0.07084746f, 0.37262407f, -0.25796455f, -0.31205913f, 0.00355314f, 
    0.01498220f, 0.01060662f, 0.07335474f, -0.01607316f, 0.12068781f, 0.01024555f, -0.08913280f, 0.03763073f, 
    0.10721835f, -0.01588157f, -0.09757272f, -0.03495771f, 0.11146519f, -0.02900956f, -0.03650932f, 0.01870577f, 
    0.04334006f, -0.00871665f, -0.09328718f, 0.17138052f, 0.05262350f, -0.00823701f, 0.07195508f, 0.00361199f, 
    -0.00201200f, 0.04425550f, -0.02401586f, 0.15512811f, 0.14478461f, 0.00994737f, -0.00971983f, 0.03375940f, 
    0.33146140f, 0.10729467f, -0.03193159f, 0.07312527f, -0.11100524f, -0.02049638f, -0.06270532f, 0.02918930f, 
    -0.02475311f, 0.03673842f, 0.00798134f, 0.04775535f, 0.13516282f, -0.09943804f, -0.04762668f, -0.07001190f, 
    0.01157069f, 0.09001239f, -0.11269762f, 0.02449634f, -0.12810200f, 0.03481965f, -0.04280236f, 0.05759247f, 
    -0.09750549f, -0.06513862f, 0.02701131f, 0.15454563f, 0.05643933f, 0.15821171f, -0.01016303f, 0.12857553f, 
    0.08995001f, -0.01277913f, -0.04372723f, -0.00609307f, -0.16031298f, -0.04972000f, 0.04703307f, 0.22357827f, 
    -0.08296502f, 0.03182751f, 0.06656120f, -0.07922693f, 0.13832550f, 0.07577018f, -0.06854557f, -0.07068581f, 
    0.03711097f, -0.03418641f, 0.07495283f, -0.11725800f, -0.15756592f, 0.07283733f, -0.10992330f, -0.01282899f, 
    0.04178125f, 0.02938698f, 0.08465738f, 0.04052179f, 0.32270032f, 0.10580448f, -0.16063359f, -0.01260946f, 
    0.03947622f, 0.02907274f, -0.08628353f, -0.02748526f, -0.08663560f, -0.05261314f, -0.01225427f, 0.02215884f, 
    0.21048450f, -0.32587621f, 0.07537085f, 0.13530844f, -0.03725167f, 0.01184810f, -0.03279831f, -0.03886304f, 
    0.08041696f, 0.02135225f, 0.12452269f, 0.02896293f, 0.13709138f, -0.01205102f, 0.12466183f, -0.11741760f, 
    -0.07750731f, -0.08931354f, 0.05483248f, -0.03191734f, 0.06638137f, -0.09569032f, -0.09434970f, 0.10325170f, 
    0.20508327f, 0.04555988f, -0.00247560f, 0.23280767f, -0.00390946f, -0.04080393f, 0.01907232f, 0.12742108f, 
    0.02319567f, 0.02485125f, 0.01745255f, -0.07772819f, -0.04972166f, 0.00642705f, -0.08307786f, -0.06116554f, 
    0.04124707f, -0.01794996f, -0.13087639f, 0.00478433f, 0.01823169f, 0.08873830f, -0.10914866f, 0.01306780f, 
    0.15804654f, 0.19799811f, -0.13376892f, 0.13471811f, 0.01579772f, -0.05802473f, 0.13558784f, -0.09263525f, 
    -0.05231559f, 0.01392567f, -0.00430169f, 0.00348866f, 0.00565091f, 0.17857748f, 0.22203000f, -0.05105584f, 
    0.05715200f, -0.02712240f, -0.15195033f, 0.05351507f, -0.06295053f, 0.01523081f, -0.02210918f, -0.01635707f, 
    -0.19611534f, -0.09445475f, -0.03224934f, -0.01263639f, -0.08926293f, 0.05314755f, -0.02652197f, -0.12454749f, 
    0.05808689f, 0.01764498f, -0.05592456f, -0.05687991f, -0.24168822f, 0.30736744f, 0.01608064f, -0.04114042f, 
    -0.06930480f, 0.07455889f, -0.11811092f, 0.01132581f, 0.14223303f, 0.04225942f, -0.02229736f, -0.01891496f, 
    0.24159878f, 0.13894290f, 0.00377442f, 0.12629336f, 0.07559425f, 0.00566542f, 0.06824949f, 0.04349982f, 
    0.07797138f, 0.08728362f, -0.02225062f, -0.01676781f, 0.28162035f, -0.15308659f, -0.09464303f, 0.02369195f, 
    0.04250325f, 0.08581988f, -0.01434661f, -0.02595746f, 0.02224512f, 0.06139543f, -0.00074049f, -0.11570279f, 
    0.08958857f, 0.03478623f, -0.23721740f, 0.18914072f, -0.06104274f, 0.09439611f, -0.03586888f, 0.02539183f, 
    0.04388304f, 0.00666793f, 0.06650690f, -0.02477081f, 0.20657401f, 0.15636259f, -0.04540765f, -0.14438646f, 
    0.16199717f, 0.05114185f, 0.12737395f, -0.01244167f, -0.02256997f, 0.02286655f, 0.04146219f, -0.04616038f, 
    -0.12834971f, -0.11624015f, -0.02323199f, -0.13748997f, -0.00351613f, 0.00927632f, -0.08459804f, 0.09592680f, 
    -0.01820264f, 0.08755345f, 0.06990742f, -0.02524872f, -0.07750883f, -0.02318978f, -0.02990340f, 0.00999648f, 
    -0.03984249f, 0.01058928f, -0.04637957f, 0.09807163f, 0.04193482f, 0.10304514f, -0.03046740f, 0.19459562f, 
    0.25237533f, 0.09225178f, 0.00111151f, 0.01744254f, -0.03585440f, -0.09451950f, -0.02557639f, -0.07452507f, 
    0.02874961f, -0.07843509f, -0.07147529f, 0.11082347f, -0.26807511f, 0.13840553f, -0.01933489f, -0.04896040f, 
    -0.04168134f, 0.13339172f, 0.06144547f, 0.13833256f, 0.09660184f, 0.04063197f, 0.03057049f, -0.08524637f, 
    0.20553391f, 0.15973492f, -0.16586044f, 0.00460327f, 0.10149212f, 0.08073545f, 0.04593754f, 0.06775514f, 
    0.06868332f, 0.02131283f, 0.08809310f, 0.02760307f, 0.14608046f, -0.08621015f, 0.11476545f, 0.00635364f, 
    0.09261563f, 0.00736566f, 0.05174475f, 0.04869112f, 0.03952124f, 0.00232465f, -0.00915420f, 0.11599781f, 
    0.13850284f, -0.08428622f, -0.01001245f, -0.13543271f, -0.01760894f, 0.05945193f, 0.08868247f, 0.06601266f, 
    0.07543667f, -0.00494394f, 0.04819574f, 0.04969641f, -0.07174227f, 0.24795781f, -0.18851234f, -0.16540235f, 
    0.14780667f, 0.08763270f, 0.07986500f, 0.06767981f, 0.06504034f, 0.05320452f, 0.09229369f, 0.00037794f, 
    -0.36369577f, 0.23843066f, -0.04201528f, -0.00643680f, -0.01699919f, 0.00527087f, 0.05439251f, -0.07854008f, 
    0.00014194f, -0.00167677f, 0.02191054f, 0.02947038f, 0.02191309f, 0.00611202f, 0.17906857f, 0.17892465f, 
    0.05788544f, 0.04371757f, -0.01008761f, 0.09482111f, 0.02329469f, 0.02906526f, -0.03181398f, 0.04504078f, 
    0.22681731f, -0.07448136f, -0.03995425f, 0.03005827f, -0.05104554f, -0.05114572f, -0.07852464f, 0.29460433f, 
    0.06544805f, -0.11582091f, -0.01839265f, 0.11492627f, 0.31022772f, -0.21591900f, -0.13973601f, -0.12023212f, 
    -0.08299554f, 0.03883782f, 0.21918406f, -0.01166243f, 0.10479235f, 0.06616344f, 0.06626064f, 0.03651193f, 
    0.22119576f, -0.02477791f, 0.07357727f, 0.10259377f, -0.06241974f, -0.04545292f, 0.09287862f, 0.04040847f, 
    -0.03500630f, 0.07888556f, 0.09553634f, 0.16471195f, 0.13543837f, -0.01028796f, 0.15496804f, -0.13822833f, 
    0.06147054f, 0.08877391f, -0.08301205f, 0.05096088f, 0.01772841f, 0.02492921f, 0.07740846f, 0.05689815f, 
    0.02597803f, -0.08548221f, -0.08561379f, -0.16780844f, -0.09095241f, 0.03955959f, -0.01472916f, -0.00682780f, 
    -0.01918862f, -0.04471879f, 0.05372704f, -0.00232955f, 0.09132072f, -0.26258609f, 0.09922594f, 0.13910586f, 
    0.09640443f, 0.05864259f, -0.06294149f, 0.05385051f, 0.01157885f, -0.03264961f, 0.04918965f, 0.03895422f, 
    -0.12863214f, -0.09730326f, 0.04402540f, -0.02065014f, -0.02520976f, 0.02427363f, -0.01116045f, 0.17938752f, 
    0.07641248f, 0.03199713f, 0.03432814f, 0.00199770f, -0.00983871f, 0.11505850f, 0.01186825f, -0.19169690f, 
    -0.02112861f, 0.00880614f, -0.09311056f, 0.05309589f, 0.07200826f, 0.04060937f, 0.01532006f, -0.09395381f, 
    0.05566555f, 0.01797046f, -0.03317648f, 0.26760426f, -0.07213732f, 0.07462879f, -0.05410425f, 0.02090366f, 
    0.12631941f, 0.05979547f, 0.08139493f, -0.00983458f, 0.34819800f, -0.14710009f, 0.09209806f, -0.04212535f, 
    -0.02111198f, -0.01365413f, -0.06489547f, 0.15793236f, -0.01551399f, 0.02677104f, 0.03439274f, 0.03323636f, 
    0.12584767f, 0.00617246f, 0.16024318f, 0.13285458f, 0.01458246f, 0.10597334f, -0.02464879f, 0.01988071f, 
    0.00663023f, 0.20961203f, 0.10267462f, 0.05029298f, -0.13131124f, -0.16802302f, 0.01412767f, -0.00627720f, 
    -0.04785230f, -0.10776886f, 0.01751941f, 0.03905194f, 0.04254553f, -0.03543435f, -0.01393592f, 0.02710414f, 
    -0.10164309f, 0.02416489f, -0.25965118f, -0.13028154f, 0.16471423f, 0.08854482f, 0.08108547f, 0.07291422f, 
    -0.05704626f, 0.11207861f, 0.07487451f, 0.04838340f, 0.01919699f, 0.08575177f, 0.12042974f, -0.11596752f, 
    -0.04209531f, 0.08666871f, 0.02156263f, 0.04248701f, 0.06972399f, -0.01320436f, -0.08014792f, 0.00971142f, 
    0.08000883f, -0.02611384f, 0.16396667f, -0.18435055f, -0.01863627f, 0.10261340f, 0.13457018f, 0.06234639f, 
    -0.00845384f, -0.04067201f, 0.08204395f, 0.05664336f, -0.05444281f, -0.06078374f, 0.26743284f, -0.35599175f, 
    -0.02600650f, 0.02353226f, 0.08245569f, 0.17059179f, 0.04042229f, 0.02491463f, -0.06247920f, 0.03095021f, 
    0.15366182f, -0.04159198f, 0.00589842f, -0.18949898f, -0.07796409f, -0.01155936f, -0.06357308f, 0.00311076f, 
    0.08064937f, 0.01321683f, -0.06443594f, 0.07016686f, -0.15194559f, 0.00945209f, 0.08729091f, -0.24574138f, 
    -0.07039696f, 0.01634893f, 0.02122301f, 0.03478548f, 0.05418228f, -0.00625459f, 0.09053147f, 0.01366839f, 
    0.02591853f, 0.00605215f, 0.01119231f, -0.00650958f, 0.00884744f, 0.00400484f, -0.03803041f, 0.00752887f, 
    -0.03833076f, -0.03167858f, 0.00168382f, -0.00943034f, 0.00770022f, -0.01615468f, -0.04461832f, 0.01137671f, 
    0.02302098f, 0.04158395f, -0.02526786f, 0.02028282f, -0.01527759f, -0.01104892f, -0.00895087f, 0.03679446f, 
    0.01612168f, -0.04240276f, -0.04156456f, -0.05495451f, 0.02837099f, 0.00336964f, -0.02032208f, 0.04131631f, 
    0.00205997f, -0.03981826f, -0.03700582f, -0.01658868f, -0.01126038f, 0.02414947f, 0.01350057f, -0.03106380f, 
    -0.05732365f, -0.00168337f, -0.02591157f, 0.02449485f, 0.02999107f, 0.03266019f, 0.02324634f, 0.01909810f, 
    -0.05969500f, -0.03656632f, -0.05438222f, 0.00827349f, -0.04429116f, -0.02769284f, 0.02867245f, -0.02021072f, 
    -0.02351577f, 0.01298547f, -0.01409725f, 0.03828863f, 0.03534622f, 0.01967654f, 0.03738828f, 0.03052166f, 
    0.00825460f, -0.00718490f, -0.05112534f, 0.02272748f, 0.03998556f, 0.03937518f, 0.02656586f, -0.00671995f, 
    0.03533772f, 0.02093953f, -0.04538076f, 0.02325704f, -0.05675250f, -0.05258337f, 0.03868829f, -0.01675853f, 
    0.02926598f, -0.02285324f, 0.03815336f, 0.02266105f, -0.03794380f, 0.00633320f, 0.00346126f, -0.02087290f, 
    0.03770498f, -0.05093022f, 0.00761040f, 0.01570238f, 0.00050851f, 0.01868641f, -0.05625235f, 0.00819030f, 
    -0.01934198f, 0.01279376f, 0.01265383f, -0.05242637f, 0.02021386f, -0.01258739f, 0.03118115f, -0.00784521f, 
    -0.03222287f, -0.01113301f, 0.01363684f, 0.04760391f, -0.00937081f, 0.00620674f, 0.00608197f, 0.00074190f, 
    0.00262367f, -0.02022525f, 0.02342947f, -0.00227986f, 0.02222207f, -0.04171896f, -0.03808862f, -0.02808161f, 
    0.00261224f, 0.00503995f, -0.01293034f, -0.02898047f, 0.02800208f, -0.03627195f, 0.03138942f, -0.01015431f, 
    0.02773765f, 0.02879171f, -0.02965296f, -0.00850703f, -0.03621069f, -0.04241253f, 0.04088247f, 0.04129326f, 
    -0.04085222f, -0.03193172f, 0.01805528f, 0.02190361f, 0.02950170f, 0.02652690f, 0.04070486f, 0.01349243f, 
    -0.03070756f, -0.04931960f, -0.05625195f, 0.00629932f, -0.01371528f, 0.03539734f, 0.01582146f, -0.02151738f, 
    -0.05121380f, -0.06003659f, 0.00082688f, -0.00982976f, 0.03478086f, -0.00409475f, -0.03140411f, -0.01872437f, 
    -0.05457171f, -0.05315569f, -0.02372425f, 0.03485244f, 0.03020031f, -0.05072172f, -0.05104427f, -0.03699173f, 
    -0.03107879f, 0.02107439f, -0.00026888f, -0.03838941f, -0.05687463f, -0.05099314f, 0.02303580f, 0.00690389f, 
    -0.04611383f, 0.00354529f, -0.06044957f, 0.02348090f, -0.00157755f, -0.05971319f, 0.00652615f, -0.03655792f, 
    -0.00140744f, -0.00031943f, 0.00737554f, -0.04007558f, 0.01755810f, -0.00465688f, -0.02826956f, -0.02809100f, 
    -0.00144854f, -0.04859117f, -0.04290012f, -0.02486673f, 0.01582509f, 0.00192412f, 0.02985761f, -0.05609318f, 
    -0.00780420f, -0.03201190f, -0.04854286f, 0.02368676f, 0.04376683f, 0.02065224f, 0.01569109f, 0.00562195f, 
    0.01864650f, -0.05304348f, -0.03781307f, 0.03634670f, -0.01646533f, -0.01402541f, 0.04140517f, -0.03009066f, 
    -0.03740964f, 0.01946065f, 0.00547362f, -0.00023459f, 0.02441593f, -0.03036817f, 0.03725866f, -0.05983174f, 
    -0.00758617f, 0.03062677f, -0.03802695f, 0.04148659f, 0.02454029f, -0.03631411f, -0.03170817f, -0.02461900f, 
    -0.01303321f, 0.01940885f, -0.05868950f, -0.00761292f, 0.02739721f, 0.03076302f, 0.02245498f, 0.03263558f, 
    0.02447592f, -0.00661780f, 0.01005510f, -0.04251038f, -0.00482987f, 0.03900708f, -0.05076472f, 0.01076257f, 
    -0.03785354f, -0.02027881f, 0.00325653f, 0.01772655f, -0.00328461f, 0.02640001f, -0.01846568f, 0.03832612f, 
    0.02246153f, -0.02748548f, 0.03515900f, -0.02773309f, -0.04827663f, 0.03001868f, 0.00515271f, -0.04962653f, 
    0.01730741f, -0.03213023f, -0.03114482f, 0.03080999f, -0.02644539f, 0.02189421f, 0.04104741f, -0.02681813f, 
    -0.01615518f, -0.00441531f, -0.01987186f, -0.00108102f, -0.03268152f, 0.00688378f, 0.03486084f, -0.00706478f, 
    -0.03494934f, -0.03636358f, 0.01947299f, -0.04348188f, -0.01635225f, 0.01793275f, -0.03966660f, 0.00890455f, 
    0.03406028f, 0.02447188f, 0.02691440f, 0.03299443f, 0.00794574f, 0.02421609f, 0.00585254f, 0.02227059f, 
    -0.02836304f, -0.00162595f, -0.01021032f, -0.04120444f, -0.04955561f, -0.01379517f, -0.03663640f, -0.05640520f, 
    -0.01700430f, -0.04714944f, -0.03201775f, 0.04727864f, -0.05423316f, -0.00943090f, -0.05850700f, 0.01240261f, 
    -0.04138015f, -0.04572879f, -0.01329755f, -0.03521032f, 0.02796009f, 0.03230929f, 0.03370120f, 0.03941096f, 
    -0.02560437f, -0.04716309f, -0.01094137f, -0.05049348f, -0.01908791f, 0.00968386f, 0.03164212f, -0.02922821f, 
    0.00088509f, 0.00441330f, -0.01956853f, -0.02872920f, -0.04544666f, -0.05747679f, -0.04105738f, -0.02832020f, 
    -0.00913586f, -0.00350651f, -0.05908625f, 0.00571597f, 0.00367507f, -0.03133767f, -0.01438822f, -0.02369529f, 
    0.01649888f, -0.05424854f, -0.04014193f, -0.05655713f, 0.03162326f, 0.02907802f, 0.01009746f, 0.01449642f, 
    -0.02824826f, 0.02260719f, 0.01746681f, -0.05464261f, -0.00157077f, 0.02542555f, -0.00150698f, -0.02865994f, 
    0.01261857f, -0.04122360f, -0.05196220f, -0.02577895f, 0.02929440f, -0.02247601f, -0.00707004f, 0.02661539f, 
    0.00488723f, -0.02626035f, -0.05059496f, 0.02532662f, 0.00384352f, -0.04817838f, 0.00220718f, -0.02358057f, 
    -0.03949498f, 0.03187162f, -0.05026948f, -0.00262051f, -0.02514336f, -0.02335794f, 0.02085072f, -0.01430523f, 
    -0.07263510f, -0.12455373f, 0.05541451f, -0.02684290f, -0.11616556f, -0.20307672f, -0.12569669f, -0.01869610f, 
    -0.06487604f, -0.07421055f, 0.07963304f, -0.00982883f, -0.04558252f, 0.02087911f, 0.22118610f, 0.07476579f, 
    0.04853394f, -0.09515607f, -0.04825226f, 0.01860276f, -0.02083665f, -0.06598318f, -0.03121162f, 0.03711835f, 
    0.08210931f, -0.10317019f, -0.09937000f, 0.11280461f, 0.00727873f, -0.02548346f, -0.02243784f, 0.09111256f, 
    0.04841323f, 0.02445222f, -0.07320859f, -0.00158780f, -0.19099431f, -0.02798319f, 0.32767767f, -0.07600305f, 
    -0.11824206f, -0.15487260f, -0.19885553f, -0.04056902f, -0.08732051f, 0.13810295f, -0.02274087f, -0.00544818f, 
    -0.30440712f, 0.02691681f, 0.07821320f, -0.09735324f, -0.12958828f, -0.03283050f, 0.20824882f, -0.12103640f, 
    0.09620579f, 0.00209589f, 0.01204775f, -0.10252716f, 0.27232802f, 0.16486935f, -0.21195628f, -0.00139954f, 
    0.15924399f, 0.07267559f, 0.09523553f, 0.01638102f, -0.04096270f, 0.10341568f, 0.09495710f, 0.01974131f, 
    -0.14076398f, 0.01577410f, 0.00833940f, -0.10124940f, 0.09091842f, 0.08025066f, 0.12733255f, -0.03083454f, 
    0.14486004f, 0.07745137f, 0.05678082f, 0.08981020f, 0.05620792f, -0.10333639f, -0.19128774f, 0.18832380f, 
    -0.09233060f, -0.11310576f, -0.00021653f, -0.16960466f, 0.03233839f, 0.02481603f, -0.20892189f, 0.15097742f, 
    -0.14122695f, -0.10681147f, -0.06172126f, -0.01574566f, -0.05524547f, -0.10136868f, 0.03694019f, -0.15265481f, 
    -0.07895719f, 0.04040501f, 0.05818288f, 0.02549015f, 0.07344147f, 0.21497631f, -0.04676042f, -0.23137459f, 
    -0.00046836f, 0.10352837f, 0.06194128f, -0.04256637f, -0.16669400f, 0.02209884f, 0.11865688f, 0.01852782f, 
    -0.12121298f, 0.13497899f, 0.05891427f, 0.00738632f, -0.07251187f, 0.03786751f, 0.10758879f, 0.04291070f, 
    -0.01755961f, -0.17952482f, -0.11081146f, 0.03305422f, 0.14462465f, -0.16880633f, 0.01578121f, -0.16914015f, 
    -0.02471833f, -0.05814681f, -0.08532022f, -0.12137784f, -0.01282410f, -0.05086302f, -0.02599231f, 0.01238134f, 
    -0.21350583f, 0.08995144f, 0.14179780f, 0.02341624f, 0.07399589f, -0.02873888f, 0.02758765f, -0.11080486f, 
    -0.04734526f, 0.05271997f, 0.05138708f, -0.05201797f, 0.19456567f, -0.07301456f, -0.15942042f, 0.09494823f, 
    -0.10083544f, -0.02161280f, -0.10560936f, -0.25333250f, -0.07613228f, 0.01299332f, -0.06397964f, 0.03363847f, 
    -0.00764769f, 0.14574941f, 0.00148251f, -0.10261718f, 0.11576663f, 0.13404252f, 0.18504944f, 0.09017784f, 
    -0.06238387f, 0.05877995f, -0.06780789f, -0.02574241f, -0.18938142f, 0.25350589f, 0.12953548f, -0.15599363f, 
    0.06001402f, 0.10859468f, -0.02045676f, -0.07758560f, -0.00395889f, -0.10452058f, 0.01421193f, 0.04252790f, 
    -0.10984450f, -0.33809599f, -0.02830660f, -0.14360681f, -0.06412710f, -0.01687728f, -0.08415090f, -0.07396595f, 
    0.02563456f, 0.07324527f, 0.08317937f, -0.04954274f, -0.00966155f, -0.06565151f, -0.05428065f, 0.23441958f, 
    0.07363414f, 0.04909093f, 0.01118247f, -0.05534915f, -0.15769318f, -0.05145048f, 0.04362492f, 0.05082820f, 
    -0.14151181f, -0.04871175f, 0.20824294f, 0.28243271f, 0.13415802f, 0.08721438f, 0.04465206f, -0.04027787f, 
    0.09138253f, 0.08008063f, 0.01756320f, 0.00987673f, -0.00185389f, 0.04286191f, 0.15106693f, 0.16261645f, 
    0.07177052f, -0.20154071f, 0.06150244f, -0.00327275f, 0.09863325f, 0.01348159f, 0.10478988f, 0.02563107f, 
    -0.06363920f, 0.15001325f, 0.09100233f, 0.06903242f, 0.07168432f, -0.04028317f, -0.00851412f, 0.02538931f, 
    0.05193552f, 0.10529240f, 0.02090994f, -0.05243715f, 0.06814236f, 0.03400659f, 0.15236475f, 0.06220902f, 
    0.02131673f, 0.04340820f, -0.00004284f, -0.00572859f, 0.08709518f, 0.05902991f, -0.02817489f, 0.14068457f, 
    0.05703659f, 0.12064964f, -0.40400195f, 0.15522003f, 0.05830504f, -0.11004253f, -0.06373117f, -0.11786346f, 
    -0.01053431f, -0.00019968f, 0.02248949f, -0.01630524f, -0.38433704f, 0.12811218f, 0.22850746f, -0.05133243f, 
    0.16833404f, 0.01852851f, 0.12269764f, -0.02735805f, 0.04352882f, 0.06569991f, 0.07002927f, -0.03781898f, 
    -0.05616153f, 0.20378314f, -0.08433246f, -0.10978109f, -0.19329387f, -0.22589433f, -0.09735214f, -0.08415327f, 
    -0.07423368f, 0.06362134f, -0.01341094f, 0.00496612f, 0.21741825f, 0.11642534f, -0.15631185f, 0.09227831f, 
    0.19091752f, 0.25325626f, -0.04590942f, 0.06464951f, 0.08595939f, 0.11834922f, 0.10335787f, -0.08822422f, 
    -0.20403506f, 0.10921262f, 0.14014275f, 0.14353767f, -0.03033474f, -0.07914516f, -0.02701075f, -0.04076151f, 
    -0.13308415f, -0.01319294f, -0.12283006f, 0.07490577f, 0.04041089f, -0.03040032f, -0.04913347f, -0.04739596f, 
    -0.00847909f, 0.08851978f, 0.12355879f, -0.07398356f, -0.02927317f, 0.03075540f, -0.01868046f, 0.00565966f, 
    0.13242973f, -0.20224665f, 0.18397610f, 0.09853178f, -0.00302320f, 0.02959671f, -0.08281921f, -0.02327521f, 
    0.12542765f, 0.06858478f, 0.04970762f, 0.09346970f, 0.27871957f, -0.12111479f, 0.02095174f, 0.08489472f, 
    0.01269151f, 0.04348945f, 0.07795527f, -0.03502931f, 0.03539310f, -0.03856561f, -0.12304056f, 0.07339337f, 
    0.26755816f, 0.15283015f, 0.04793347f, -0.12341379f, 0.19900414f, 0.05381620f, 0.11168440f, 0.21324438f, 
    -0.07245158f, 0.05884208f, -0.05213375f, 0.10483658f, 0.41267267f, -0.10390142f, 0.09265020f, 0.11686148f, 
    0.20415320f, 0.04435331f, 0.01437533f, 0.04325919f, 0.04574694f, -0.03885337f, -0.03532148f, -0.07118361f, 
    0.09091612f, -0.16499668f, -0.08138570f, 0.20866108f, -0.08789065f, 0.02060674f, 0.12761521f, 0.06828978f, 
    0.01024752f, -0.04337761f, 0.04037836f, -0.01456240f, -0.30701429f, 0.03314496f, 0.06853113f, 0.16064177f, 
    -0.01495602f, 0.07362322f, -0.04401286f, 0.09675469f, 0.00674219f, -0.10291072f, -0.15223910f, -0.11121653f, 
    -0.16870371f, -0.10871659f, -0.03179082f, 0.25037596f, 0.03570844f, -0.06073415f, -0.05667454f, -0.00975029f, 
    0.01438437f, -0.00830241f, -0.05962945f, -0.09960080f, 0.16593516f, -0.06790803f, 0.03853782f, -0.03148339f, 
    0.01161124f, -0.05135957f, -0.10324734f, 0.06290203f, 0.05917605f, 0.02547380f, 0.02205088f, 0.00044723f, 
    0.06127954f, 0.04910187f, 0.03510105f, -0.15473558f, -0.06954046f, -0.02414386f, 0.00581339f, -0.05083172f, 
    0.03848042f, 0.04906364f, 0.03218643f, 0.04516976f, -0.22957048f, -0.06760950f, -0.00103354f, -0.01355940f, 
    0.15347727f, -0.06337751f, 0.02464177f, 0.08704821f, -0.03547734f, 0.03447026f, 0.03420489f, 0.04932836f, 
    0.05119970f, -0.04360716f, 0.02688370f, -0.06182997f, 0.13511062f, 0.07951661f, -0.03569487f, -0.00041321f, 
    0.07787419f, -0.08732284f, -0.05351268f, 0.00782564f, 0.33312842f, -0.05087278f, -0.01104522f, -0.28106210f, 
    -0.01289604f, -0.02948582f, -0.02741283f, -0.01118664f, -0.05199781f, -0.12927483f, 0.00607139f, 0.09316967f, 
    -0.33847111f, 0.10476997f, 0.18274061f, 0.06905949f, -0.00881111f, -0.05421428f, 0.01493245f, -0.10871518f, 
    -0.07913913f, -0.04883522f, -0.05872916f, 0.01593666f, -0.13849428f, 0.04998855f, 0.08984809f, 0.08352885f, 
    0.07733637f, -0.05840205f, 0.14024127f, 0.08418986f, -0.03779003f, 0.06589023f, 0.07566166f, -0.01981033f, 
    -0.15669696f, 0.17150310f, -0.08949677f, 0.02184697f, -0.11302855f, -0.07717799f, 0.00932951f, 0.00611109f, 
    0.03412570f, -0.11876593f, 0.10537949f, 0.04959392f, 0.14673789f, 0.03422859f, 0.04454606f, -0.11712891f, 
    0.07270358f, -0.01210115f, 0.07080610f, 0.03820986f, 0.04727162f, 0.02634180f, 0.14407896f, 0.07999571f, 
    0.20369284f, 0.10238313f, -0.04082891f, -0.03774377f, 0.06020122f, 0.15958893f, -0.06629813f, 0.01440081f, 
    0.01922606f, 0.08603961f, 0.06749473f, 0.02823633f, 0.31769255f, 0.05590949f, -0.22056654f, 0.14716539f, 
    0.02342389f, -0.00490368f, -0.00902046f, 0.05659587f, 0.10098469f, -0.03673498f, -0.07859160f, 0.01644186f, 
    -0.21144168f, 0.13708588f, -0.03479612f, 0.13686024f, -0.08998206f, -0.00026899f, 0.01790504f, 0.01617456f, 
    -0.03583368f, 0.09306939f, -0.04093917f, -0.00762339f, -0.06308885f, 0.03492873f, 0.10047731f, 0.03118157f, 
    0.03288320f, -0.09166066f, -0.05421512f, -0.03840961f, 0.02120090f, 0.02553436f, -0.07679871f, 0.05266970f, 
    0.42814654f, 0.00984372f, 0.06199770f, 0.05467139f, -0.08669414f, -0.03812994f, -0.02522726f, 0.13808906f, 
    -0.08364506f, 0.14680687f, -0.07805824f, -0.04357366f, 0.05366280f, 0.22846021f, -0.08284622f, 0.05494464f, 
    0.05126612f, -0.05158470f, -0.12348524f, -0.05550200f, -0.02386230f, 0.14835724f, 0.10634825f, 0.06230854f, 
    -0.19318980f, 0.06694957f, -0.02106617f, -0.00789275f, -0.02214186f, 0.00281490f, -0.02195638f, 0.12879056f, 
    0.04298811f, -0.03039676f, 0.10216103f, 0.01118108f, 0.05190603f, 0.14252687f, 0.14846025f, 0.37577635f, 
    -0.02904376f, 0.00978531f, -0.01411378f, -0.05565700f, 0.01565157f, -0.05591665f, -0.02973767f, 0.02305058f, 
    0.10300555f, -0.03339984f, 0.14889677f, -0.10106775f, -0.13292395f, 0.00407666f, 0.01364903f, -0.07782154f, 
    0.10767282f, 0.04242394f, 0.08695165f, 0.05884761f, 0.02980228f, 0.14686364f, 0.10172797f, -0.22005920f, 
    0.05804010f, -0.01878186f, -0.06682716f, 0.12551013f, 0.12237802f, 0.09962180f, -0.00632303f, 0.11613018f, 
    0.03590153f, -0.20421000f, -0.04403686f, 0.12480480f, 0.01405238f, -0.02144659f, 0.05189610f, -0.00724052f, 
    0.00944713f, -0.04634926f, 0.03053101f, 0.01429731f, -0.05146763f, -0.12678581f, 0.14542042f, 0.10733971f, 
    0.05418478f, 0.01997442f, 0.08884126f, -0.01099462f, 0.07743458f, 0.06892144f, 0.10048472f, 0.01374557f, 
    0.15559897f, -0.03724555f, -0.12085429f, 0.41213134f, 0.05271733f, 0.00399834f, 0.06905821f, 0.01566479f, 
    -0.00512079f, -0.00527058f, -0.15291156f, -0.01816230f, -0.02579846f, 0.15987687f, 0.04961760f, 0.12744384f, 
    -0.05327096f, -0.08352183f, -0.01922885f, -0.06409181f, -0.03603524f, 0.07149569f, 0.18045530f, -0.02898967f, 
    0.02693972f, 0.04477929f, -0.13544740f, -0.21470718f, -0.05934199f, -0.05591436f, -0.00622883f, -0.00211743f, 
    0.06407918f, 0.00538813f, 0.17126988f, 0.07880773f, 0.18702798f, -0.04081535f, 0.09843349f, -0.14486465f, 
    0.02895421f, 0.14803712f, -0.14899336f, 0.15237035f, 0.07103044f, -0.15413591f, 0.04918252f, 0.00376197f, 
    -0.25985402f, 0.01827840f, 0.14069571f, 0.09406908f, -0.04947728f, -0.01027768f, 0.04446077f, 0.09575161f, 
    0.13063370f, 0.07727420f, -0.08135814f, -0.07377649f, -0.04505815f, 0.10480952f, -0.24595597f, 0.16396861f, 
    -0.11200535f, 0.10369299f, 0.04993883f, -0.11571454f, 0.05187106f, 0.09357467f, 0.04214108f, -0.00589891f, 
    0.03238312f, -0.10157792f, 0.14690980f, -0.14991240f, -0.06312407f, 0.04207456f, -0.09735515f, 0.00030284f, 
    -0.08084898f, -0.01186713f, -0.04488104f, 0.02690558f, 0.09211965f, 0.05839766f, -0.00544754f, -0.24239689f, 
    -0.07783213f, -0.02344731f, 0.01593621f, 0.21999982f, 0.08598429f, -0.06277350f, -0.04925101f, 0.12386425f, 
    0.00373514f, -0.04731874f, -0.02341570f, -0.05502821f, 0.01045341f, -0.02686311f, -0.05451444f, 0.04324726f, 
    0.03004961f, 0.00048856f, -0.04298984f, -0.05427380f, 0.00990717f, -0.04244677f, -0.04515935f, -0.05247045f, 
    0.02954230f, -0.02997966f, -0.02710653f, -0.00521926f, 0.03434052f, 0.03618785f, -0.00810830f, -0.04037277f, 
    -0.04327041f, 0.01291965f, -0.04039311f, -0.05048790f, -0.01615210f, -0.04187033f, 0.00715074f, -0.03271060f, 
    -0.04771867f, -0.04761817f, -0.03946255f, 0.03276330f, 0.01899204f, 0.03119349f, 0.02378554f, 0.03134328f, 
    -0.01973031f, -0.00287478f, -0.00254641f, -0.04632116f, -0.01670280f, -0.04918928f, -0.00816005f, -0.00835160f, 
    0.04414541f, 0.03824042f, -0.03081126f, -0.05137656f, 0.00721073f, 0.02027440f, -0.00729493f, -0.03792427f, 
    -0.00120249f, 0.01727529f, -0.05424946f, 0.04190793f, -0.01151066f, -0.05160879f, -0.04755484f, 0.03066264f, 
    0.03394929f, 0.01148935f, -0.01574029f, 0.03707425f, -0.01895707f, -0.03860649f, -0.02526473f, -0.02652932f, 
    -0.04588595f, 0.01742701f, -0.01936920f, 0.00166452f, 0.03411380f, -0.05612924f, 0.03363863f, -0.01868512f, 
    -0.00449935f, -0.00334936f, -0.02030408f, -0.03644376f, 0.02238484f, -0.03921211f, 0.02849893f, -0.04972650f, 
    -0.05494238f, 0.03456024f, -0.02571156f, -0.03703672f, -0.04205184f, 0.02585258f, 0.03096041f, -0.04599443f, 
    -0.05679418f, 0.02383721f, 0.02171700f, -0.05441777f, -0.01660127f, 0.01568940f, 0.03121748f, -0.03328345f, 
    0.01808205f, -0.03109949f, 0.00023945f, -0.05407192f, 0.02036607f, 0.00317306f, 0.01684851f, 0.01421593f, 
    -0.03751507f, 0.00107520f, -0.04004574f, 0.01289466f, -0.00672518f, -0.04831645f, -0.03220839f, 0.04157249f, 
    -0.00878870f, -0.00455588f, 0.00282568f, -0.00673810f, -0.03562881f, -0.02443044f, -0.01617165f, -0.05155085f, 
    0.00947614f, 0.01880011f, -0.02971336f, -0.03922289f, -0.00625639f, 0.02464914f, -0.04058797f, 0.00635549f, 
    0.03830738f, -0.03212286f, -0.00500956f, 0.00475656f, 0.03433694f, -0.00299742f, 0.04378021f, 0.04147460f, 
    0.02668874f, 0.02098729f, -0.01595133f, -0.02301631f, 0.03522541f, 0.02729500f, 0.02154293f, -0.01058399f, 
    0.03640349f, 0.04049974f, -0.02607329f, -0.05278937f, -0.02045371f, -0.00441756f, -0.05055242f, 0.04362233f, 
    -0.00311817f, 0.03908800f, -0.00738607f, -0.01951884f, -0.04553059f, 0.03349057f, 0.01053790f, 0.03872646f, 
    0.00734996f, 0.01994676f, -0.05640618f, -0.03968783f, 0.01786417f, 0.00111045f, 0.02644682f, 0.01290521f, 
    0.00592765f, 0.04351982f, 0.01995180f, 0.03689302f, -0.05396956f, -0.00362729f, -0.00714519f, -0.00038673f, 
    -0.00625996f, -0.03079876f, 0.03770371f, 0.03485560f, 0.01514713f, -0.02436515f, -0.00375537f, 0.00862242f, 
    0.03046146f, -0.00917818f, -0.03712578f, -0.05566968f, -0.04313954f, -0.00508811f, -0.02372554f, 0.03907571f, 
    -0.04654455f, -0.00373333f, -0.03149218f, -0.04728721f, -0.05362405f, 0.00874231f, -0.02084758f, -0.02174379f, 
    -0.02039863f, -0.03180763f, -0.00856389f, 0.00565783f, -0.02385834f, 0.03827558f, 0.02527672f, -0.02513439f, 
    0.03275323f, -0.03368432f, -0.02068366f, -0.02435369f, 0.00045192f, -0.04090930f, 0.00886304f, 0.03522088f, 
    -0.01334422f, -0.05578935f, -0.02845947f, -0.01790642f, 0.00461570f, -0.03113859f, 0.03357654f, -0.05181601f, 
    -0.02036844f, 0.01334108f, -0.03157648f, -0.05671078f, -0.04531557f, -0.00578209f, -0.04964178f, -0.01333971f, 
    0.01617515f, -0.01723002f, 0.01442720f, -0.04821194f, 0.01432674f, 0.00932924f, 0.01953011f, -0.00812158f, 
    -0.05063691f, -0.00388061f, 0.00297136f, 0.00988023f, 0.00672948f, -0.02304210f, 0.00207556f, 0.00560071f, 
    -0.01496456f, 0.04381078f, 0.03157228f, 0.02816687f, 0.02447618f, 0.02806409f, -0.01652249f, 0.02070368f, 
    -0.04551942f, -0.02593260f, -0.00413905f, -0.03304695f, -0.04311571f, 0.04433764f, -0.01175013f, 0.01764777f, 
    -0.03349469f, -0.02354525f, 0.03118634f, 0.00950129f, 0.00029414f, 0.03084678f, 0.02265009f, -0.05515925f, 
    0.04466090f, -0.03630191f, -0.02244390f, -0.02388483f, 0.02194206f, -0.04375885f, 0.01060663f, 0.02575613f, 
    -0.02306863f, -0.01894749f, -0.04799579f, 0.03481570f, 0.00694855f, -0.02550135f, 0.00049656f, -0.03818357f, 
    -0.02695541f, -0.03983932f, 0.03003819f, -0.00115411f, -0.01462031f, 0.00261158f, 0.03810617f, -0.04522868f, 
    -0.03883762f, -0.03446332f, -0.01865123f, 0.03720971f, 0.00228861f, 0.00265966f, -0.03196145f, 0.02206848f, 
    0.04024370f, -0.04105900f, -0.00043326f, -0.03962899f, 0.00443836f, 0.03662108f, -0.03623791f, 0.01306317f, 
    0.03584593f, 0.00082598f, 0.01545634f, -0.03071753f, 0.02059033f, 0.02189653f, -0.02350119f, -0.04481017f, 
    -0.04906106f, -0.02881065f, -0.04203947f, -0.03030458f, -0.03940208f, 0.01409786f, -0.01123301f, -0.04252007f, 
    -0.03137466f, -0.03784075f, 0.03404041f, -0.04621981f, 0.00526439f, 0.04392255f, -0.03013187f, 0.00834190f, 
    -0.02617262f, -0.05462572f, 0.03370575f, -0.01219864f, 0.02163148f, 0.04425657f, 0.00834749f, 0.00696244f, 
    -0.01711472f, -0.04283284f, 0.04297954f, 0.00968235f, -0.03753085f, -0.02014278f, 0.03636914f, 0.00038512f, 
    -0.03659165f, -0.01720959f, 0.03221381f, 0.01350415f, 0.01253067f, -0.01330274f, -0.03952577f, 0.04003086f, 
    -0.04972872f, -0.02538482f, -0.05610750f, -0.03664742f, 0.03052963f, 0.00069329f, -0.01315059f, 0.03551966f, 
    -0.02277818f, -0.00245034f, 0.02251902f, -0.00746304f, 0.02646845f, -0.04807243f, -0.01595896f, 0.00415642f, 
    -0.03810998f, 0.12958640f, -0.00003684f, 0.11260869f, 0.03014290f, -0.00590495f, 0.00180386f, 0.05597210f, 
    0.00940161f, -0.05909098f, 0.02144383f, -0.01078509f, 0.18532205f, 0.22859435f, 0.11709885f, -0.03999406f, 
    0.08645387f, 0.01583545f, 0.01114580f, -0.01128979f, 0.14670545f, -0.04943403f, 0.08173417f, 0.09094924f, 
    -0.10256702f, -0.01490046f, 0.33300287f, -0.12533496f, -0.03440059f, -0.09242222f, 0.05571652f, 0.00390130f, 
    -0.07459720f, 0.05864716f, -0.03051737f, 0.00159730f, 0.15453370f, 0.06736384f, -0.10421186f, 0.30489561f, 
    -0.01023373f, -0.01809491f, -0.04528691f, 0.05479986f, 0.11064295f, -0.05373589f, 0.07743785f, 0.10854131f, 
    0.33765715f, 0.18202399f, -0.13065685f, 0.13115165f, 0.05245414f, 0.01831510f, -0.10848421f, 0.02718124f, 
    0.05395675f, 0.15878187f, -0.04448833f, 0.08163364f, 0.07746772f, -0.10448229f, -0.01447397f, 0.02412849f, 
    -0.07523008f, 0.04888264f, 0.16439413f, -0.00662699f, -0.03071226f, -0.03990433f, 0.06010274f, 0.03920203f, 
    -0.03509369f, -0.10050218f, 0.05621908f, -0.09957383f, 0.00782219f, -0.03539553f, 0.10099220f, 0.00139422f, 
    -0.05391074f, 0.05356567f, 0.10550328f, -0.05750199f, -0.16827226f, -0.23007508f, 0.14429322f, 0.13210204f, 
    0.11311333f, -0.03137198f, -0.07781760f, -0.02011087f, 0.02992000f, -0.06549695f, 0.04610877f, 0.07704881f, 
    -0.15792069f, 0.23154360f, 0.20300829f, 0.05872539f, 0.02324287f, 0.03670159f, 0.03140537f, 0.02539941f, 
    0.02219433f, 0.09173971f, 0.01348785f, 0.00759202f, -0.19876663f, -0.15924507f, -0.04440960f, 0.02172901f, 
    -0.10801162f, -0.07922265f, 0.09369163f, 0.03864037f, -0.03461812f, 0.00060185f, 0.02465791f, 0.00036786f, 
    -0.02816516f, -0.03928410f, 0.15510204f, 0.06234641f, -0.03760315f, -0.02717753f, 0.04393878f, -0.06661312f, 
    0.11425808f, 0.01555283f, -0.00623018f, 0.00275137f, -0.13978817f, 0.33877805f, -0.06384753f, 0.19166012f, 
    -0.10578373f, 0.05129005f, -0.01871173f, -0.02204580f, 0.02556109f, 0.06038004f, -0.05644985f, 0.01128189f, 
    0.13339353f, -0.24585074f, 0.03109626f, 0.11489279f, -0.01228876f, -0.02832050f, -0.01513180f, 0.11414791f, 
    0.07310922f, -0.04665784f, -0.03235548f, 0.08600567f, -0.04283940f, -0.00390162f, 0.10257713f, -0.13708127f, 
    -0.03804721f, 0.09397769f, 0.00903469f, -0.02856349f, 0.03962540f, 0.06956942f, 0.15850011f, -0.09196892f, 
    -0.15604003f, 0.15035239f, 0.06210155f, 0.01793433f, -0.02186647f, -0.00706555f, 0.16640894f, -0.12521340f, 
    -0.02367093f, 0.02254435f, 0.10894845f, 0.04137142f, -0.17263019f, 0.09345660f, 0.05290249f, 0.02936667f, 
    -0.04441101f, 0.08532240f, -0.04986891f, 0.04818141f, -0.00738378f, -0.03928151f, 0.04795738f, -0.05672153f, 
    -0.32605603f, -0.09867273f, -0.19289888f, 0.02064782f, 0.19815084f, 0.16521843f, -0.00846968f, 0.02518016f, 
    0.01051983f, 0.03537958f, -0.07996612f, -0.02105077f, -0.00654437f, -0.05806624f, 0.00231864f, 0.02123833f, 
    0.01134097f, -0.05674818f, 0.03971938f, -0.00393387f, 0.02547737f, 0.10981617f, -0.05304701f, 0.00205934f, 
    0.24389713f, 0.12788948f, -0.03240376f, -0.04644033f, 0.04784903f, -0.10127658f, -0.04619058f, 0.06333638f, 
    0.02374625f, 0.06304464f, 0.02720207f, 0.07253964f, 0.10310216f, -0.03689440f, 0.07286313f, -0.02485277f, 
    -0.02049044f, 0.00319350f, 0.04435012f, 0.09587306f, 0.01249761f, -0.10041111f, 0.02973148f, 0.04833495f, 
    0.25740209f, 0.18306740f, 0.01867628f, -0.12496223f, -0.04216620f, 0.06382663f, 0.01344747f, -0.04694541f, 
    0.01329498f, 0.01212525f, -0.03897686f, 0.03729662f, 0.36853647f, -0.06595836f, -0.06458723f, -0.05554277f, 
    0.04706004f, 0.06343129f, 0.03728994f, -0.07851438f, -0.05919943f, -0.04336099f, -0.00240175f, 0.01786475f, 
    -0.28822246f, -0.03896157f, 0.06005024f, -0.23418839f, -0.01010700f, -0.03231536f, 0.04801984f, 0.13941953f, 
    -0.07447760f, 0.00164133f, 0.02320224f, -0.02507110f, -0.01985090f, 0.23143990f, -0.12880352f, 0.00419218f, 
    -0.04447754f, -0.03272926f, 0.10047679f, 0.02259060f, -0.00563429f, -0.09276299f, -0.01447716f, 0.05461593f, 
    -0.05847373f, -0.15011576f, 0.01127217f, -0.09516257f, 0.14923288f, -0.00448752f, -0.00851032f, -0.02617219f, 
    0.09069985f, -0.10256263f, 0.09859641f, 0.07236272f, 0.05332168f, 0.02405548f, 0.05584707f, -0.04481263f, 
    -0.00947306f, -0.16298346f, 0.08224127f, -0.03516601f, 0.04218003f, 0.06319363f, -0.00477431f, -0.00098747f, 
    0.26019129f, 0.12986580f, 0.21511790f, 0.13662916f, -0.09078667f, 0.00452301f, -0.01217319f, -0.03679141f, 
    0.10136992f, -0.00845442f, 0.07450885f, -0.03298110f, 0.02609228f, -0.05506891f, 0.01476363f, 0.12250971f, 
    0.04796842f, -0.02371792f, 0.06002378f, 0.04640348f, -0.02417266f, 0.07174635f, -0.03248881f, 0.03020522f, 
    0.20042278f, 0.11451939f, -0.13698550f, 0.22439249f, 0.12505049f, -0.03843673f, -0.06108124f, -0.02647364f, 
    0.03876466f, -0.03596111f, -0.08263812f, -0.00091096f, -0.14479801f, -0.08600771f, -0.21200974f, 0.27917650f, 
    0.02817480f, -0.10237836f, 0.16001078f, -0.01555378f, -0.01638650f, -0.05470423f, 0.01242920f, -0.06198629f, 
    -0.24407086f, -0.04726092f, -0.01026838f, 0.23545890f, -0.11596763f, -0.08895335f, 0.07229060f, 0.00971407f, 
    -0.06459896f, -0.05580807f, 0.03979295f, -0.08519601f, -0.03927177f, 0.20108218f, -0.11486109f, 0.15696262f, 
    -0.06641612f, -0.00880670f, -0.01347354f, -0.11365305f, -0.08091726f, 0.00356772f, -0.07142977f, 0.00822710f, 
    -0.03433983f, -0.16400518f, 0.02173051f, -0.00650581f, 0.07488397f, 0.11066022f, 0.10893439f, -0.05921556f, 
    -0.15394430f, 0.06834280f, 0.04151472f, -0.05383569f, 0.01279364f, -0.05744270f, 0.05061828f, 0.07339779f, 
    -0.02687502f, -0.04551533f, -0.09789550f, 0.08902165f, -0.17169578f, 0.09351443f, -0.04092757f, -0.01711112f, 
    0.28944331f, -0.08280753f, 0.00985204f, 0.18169864f, 0.01093227f, 0.03757907f, 0.06071915f, 0.06224388f, 
    0.06672056f, 0.05302024f, -0.01545747f, -0.03167268f, -0.08263391f, 0.08799185f, 0.19913831f, -0.04598843f, 
    -0.11972338f, 0.04133616f, -0.11208645f, -0.00600459f, -0.03913328f, -0.05215619f, -0.06520982f, 0.03265261f, 
    -0.19466755f, 0.18408690f, 0.20381595f, -0.08218059f, 0.02142492f, -0.07104567f, 0.19251177f, -0.07172751f, 
    -0.01141496f, -0.13346918f, 0.05778128f, 0.03508221f, 0.08113544f, 0.26277044f, 0.05389383f, 0.09901019f, 
    0.05731498f, 0.02716770f, -0.00922719f, -0.04584838f, -0.06685990f, 0.01238230f, 0.00517493f, -0.00430175f, 
    -0.07187082f, 0.20965032f, 0.03071526f, -0.00449546f, -0.13701500f, -0.00037342f, 0.08552364f, 0.11586759f, 
    0.10983565f, 0.05471284f, -0.00771215f, -0.01871040f, 0.31801474f, 0.07401019f, -0.07707921f, -0.03416251f, 
    -0.12036182f, 0.12682624f, 0.02934129f, -0.11618452f, -0.04862192f, 0.00389926f, -0.01167344f, 0.09097867f, 
    0.24075668f, -0.14387806f, 0.00141692f, 0.01331289f, 0.02299671f, -0.14702542f, 0.08808903f, -0.02179570f, 
    0.01039299f, 0.01001144f, -0.09975888f, -0.01182135f, 0.06435619f, 0.34609449f, 0.09247553f, 0.13129574f, 
    -0.11783090f, 0.00253573f, 0.04692700f, 0.09869241f, -0.01838592f, 0.03582889f, 0.01104133f, -0.04022835f, 
    -0.01750644f, -0.12588955f, -0.06263955f, 0.04693382f, -0.03971196f, -0.08056533f, 0.00536735f, 0.11945339f, 
    -0.04364797f, 0.04915851f, -0.08367448f, 0.08537655f, 0.48707587f, -0.13978235f, -0.00969479f, -0.12385007f, 
    0.06679511f, -0.03169610f, 0.00749457f, -0.08256951f, 0.02587633f, 0.01900067f, -0.06442906f, 0.08399120f, 
    -0.25757566f, 0.19708933f, -0.00577600f, -0.08849613f, 0.00607633f, 0.07681398f, 0.04948873f, 0.05536628f, 
    -0.07849787f, 0.04927572f, 0.06009525f, -0.03230186f, -0.18936643f, -0.12410396f, -0.05560089f, -0.01773312f, 
    0.10909438f, 0.01724588f, 0.07800315f, -0.09520237f, -0.02297122f, 0.03424836f, -0.03807854f, 0.00161435f, 
    0.16054988f, 0.03435878f, 0.14321975f, 0.04585400f, 0.00101220f, 0.01532770f, 0.01661395f, -0.01988066f, 
    -0.08923154f, 0.13416110f, -0.05704143f, -0.01486148f, -0.06710391f, 0.06423758f, 0.20175397f, 0.06917899f, 
    -0.06671087f, -0.16054133f, -0.01922413f, 0.06660696f, -0.04623453f, 0.02707065f, 0.00683237f, -0.00885311f, 
    0.15813094f, -0.10886633f, 0.02634738f, -0.28915527f, -0.18352340f, -0.02747389f, -0.06690603f, 0.04922754f, 
    -0.02447467f, -0.00313548f, 0.04508150f, -0.07584385f, 0.19844793f, 0.10220765f, 0.06817142f, 0.13060074f, 
    -0.04730507f, 0.10151678f, -0.04921888f, -0.04969927f, -0.04345374f, 0.02840549f, 0.07928934f, -0.16957121f, 
    -0.02782114f, -0.07091791f, 0.26910308f, 0.15139671f, 0.08304200f, 0.04175552f, 0.00777568f, 0.05783555f, 
    0.05390959f, -0.03377872f, 0.06964265f, 0.03859933f, -0.10965507f, 0.26116258f, -0.13249366f, 0.05908442f, 
    0.05559983f, -0.08549577f, 0.07185547f, 0.04346429f, -0.01900597f, 0.09022217f, 0.11744792f, 0.11286672f, 
    0.06720191f, 0.04606472f, 0.04601646f, 0.12048203f, 0.06107743f, -0.01160342f, 0.00413184f, 0.02150142f, 
    0.08708891f, 0.10647018f, 0.04556897f, 0.06264433f, 0.11443291f, 0.06165764f, 0.08547346f, -0.08109348f, 
    0.08494540f, -0.01827037f, -0.05709495f, 0.13276318f, -0.04526103f, 0.08522534f, 0.08306085f, -0.02030164f, 
    -0.12129587f, 0.10685878f, -0.08691311f, 0.13237385f, 0.13906917f, 0.04125125f, 0.09109664f, -0.07529987f, 
    0.01181426f, -0.01487532f, 0.00389770f, -0.01006842f, -0.20690487f, -0.00849590f, 0.05650900f, 0.07396154f, 
    -0.00498902f, 0.06518413f, -0.01104809f, -0.06739818f, 0.08071055f, 0.03606018f, 0.03730017f, 0.00456569f, 
    -0.53287953f, -0.01960161f, 0.04459369f, -0.00906566f, 0.02734739f, 0.04186103f, 0.02117675f, -0.04474852f, 
    -0.04135126f, -0.01237108f, -0.04382986f, 0.03009204f, 0.22162955f, 0.03899735f, -0.16337246f, 0.23542488f, 
    0.06322339f, 0.04914459f, -0.04979511f, -0.02252273f, -0.05020859f, 0.01497554f, -0.01312770f, -0.05442939f, 
    -0.05966482f, 0.06537141f, 0.05913927f, 0.04246003f, 0.05048452f, 0.03865439f, -0.06222629f, -0.03661484f, 
    -0.09824869f, -0.02065526f, -0.06328128f, 0.05017729f, 0.08469902f, 0.05504708f, 0.06197318f, -0.04525709f, 
    -0.04534287f, 0.03666621f, 0.10553428f, -0.01135729f, -0.01385580f, -0.00476463f, 0.02078546f, 0.04994576f, 
    0.12044435f, -0.16719238f, 0.19418082f, -0.08253372f, 0.00604708f, 0.12388238f, -0.06637754f, -0.04113512f, 
    0.00177359f, 0.01950573f, 0.01016985f, 0.05238872f, 0.02669974f, 0.08143045f, -0.03850843f, 0.21770395f, 
    -0.11301844f, 0.13698500f, 0.01101303f, 0.03719628f, 0.05592655f, 0.06649924f, -0.13272391f, -0.04832824f, 
    0.12451013f, 0.25239381f, 0.21786976f, -0.06638637f, 0.21285869f, 0.00911490f, 0.08929500f, 0.19660436f, 
    -0.09570278f, -0.04006092f, 0.12412398f, 0.07192788f, 0.11119340f, -0.20810872f, 0.07264459f, 0.05831422f, 
    0.11502537f, -0.00439138f, 0.02196194f, 0.07436809f, -0.04475037f, -0.06414841f, 0.05707993f, 0.09037863f, 
    -0.07671859f, -0.02037284f, -0.01733142f, 0.02056687f, 0.14656651f, -0.02039223f, -0.01960610f, -0.06068693f, 
    -0.06252624f, 0.00624725f, -0.05666992f, -0.09094220f, -0.17681438f, -0.06774260f, -0.09916112f, -0.20036542f, 
    -0.13002954f, -0.10912006f, -0.04097454f, -0.00699722f, -0.01276990f, 0.05958597f, -0.01980022f, -0.04459414f, 
    0.30848196f, -0.10692179f, -0.11945074f, 0.09565258f, -0.10333639f, 0.07339754f, -0.07240751f, -0.05651215f, 
    -0.09441017f, -0.03067948f, 0.04773773f, -0.00976552f, -0.27368948f, -0.03409884f, -0.04624001f, -0.24784641f, 
    0.17029293f, -0.01993740f, -0.08405674f, -0.09214159f, -0.01468515f, 0.08342087f, 0.13148168f, -0.00306453f, 
    -0.14484662f, -0.11362898f, 0.05984058f, -0.28070927f, 0.10190432f, 0.04129469f, -0.06005633f, 0.05284498f, 
    -0.04781414f, 0.00083441f, 0.10098632f, -0.11493123f, 0.01067821f, 0.03448041f, 0.11141951f, 0.07811692f, 
    -0.03811782f, -0.11794537f, 0.02208378f, 0.08818012f, 0.03741581f, 0.03765763f, -0.00456355f, 0.05775600f, 
    0.16619749f, -0.14234772f, 0.03656138f, 0.07556113f, -0.04099282f, -0.09016092f, 0.06853528f, 0.00253328f, 
    0.01944625f, -0.05979205f, -0.17440386f, 0.06709660f, 0.08025777f, 0.12452755f, -0.09417798f, -0.14286469f, 
    0.04505387f, 0.01854960f, -0.05186867f, 0.07287849f, 0.03406664f, 0.06475791f, -0.03813072f, -0.01729555f, 
    0.42761028f, -0.21956125f, -0.10823295f, -0.19087680f, 0.00627319f, 0.07424173f, -0.07388368f, 0.01212102f, 
    0.10644747f, 0.07617966f, 0.16880396f, -0.06532026f, 0.02275171f, 0.08206865f, 0.04187639f, 0.12670375f, 
    -0.06204264f, 0.11884880f, 0.06937297f, 0.13471177f, 0.08022954f, 0.01086253f, 0.00707931f, -0.01017013f, 
    0.47082204f, 0.12911806f, 0.06976015f, 0.08175189f, -0.01396072f, 0.05166538f, -0.06732111f, 0.05103682f, 
    0.02375884f, 0.09634642f, 0.00887227f, -0.05712696f, 0.31816110f, -0.01156581f, -0.28868896f, 0.03163533f, 
    0.08886360f, 0.09523628f, -0.06039028f, -0.04979871f, -0.01784874f, 0.00952783f, -0.00000800f, -0.04758373f, 
    0.16363272f, -0.15854070f, 0.00940238f, -0.13589209f, 0.02066331f, -0.00843484f, -0.03447362f, -0.15625392f, 
    -0.03693069f, 0.11407194f, -0.08250490f, 0.02923732f, -0.14645107f, -0.03750384f, -0.01051757f, 0.23575871f, 
    0.08076841f, -0.04630667f, -0.00971847f, 0.00973433f, -0.02945316f, -0.03875785f, -0.07304136f, -0.07025729f, 
    0.33955812f, -0.29223049f, 0.02571869f, 0.25562859f, -0.02367011f, 0.00564741f, -0.15105650f, 0.03559226f, 
    0.05493750f, -0.01861312f, 0.04403274f, -0.03390449f, 0.35424432f, 0.06577594f, 0.10133773f, 0.03068808f, 
    -0.03697543f, 0.14248024f, 0.11192343f, 0.03646236f, -0.01045102f, 0.11121962f, 0.05963541f, 0.02462469f, 
    0.19078577f, -0.02302931f, 0.12175349f, 0.21972089f, 0.11753710f, -0.06022467f, 0.08412354f, -0.06072190f, 
    0.07339189f, 0.11165504f, 0.04217692f, 0.06970824f, -0.25116646f, 0.09016985f, 0.00880034f, -0.05854982f, 
    0.08923763f, 0.10080265f, -0.08541609f, -0.08048467f, -0.06903382f, -0.01128335f, -0.04243388f, 0.00069520f, 
    0.00621775f, 0.06303711f, -0.08717742f, -0.11139265f, -0.08459619f, 0.07191333f, 0.04730691f, -0.08010547f, 
    0.02613550f, 0.00627729f, -0.03967642f, 0.02484934f, -0.11517616f, -0.07882351f, 0.10457147f, 0.03117489f, 
    0.09677009f, -0.06858764f, -0.08255128f, -0.02575055f, 0.05429206f, -0.00884314f, 0.03053698f, -0.01026256f, 
    -0.04067727f, -0.05824002f, 0.07308000f, -0.00244698f, 0.10002106f, 0.05662875f, -0.02761883f, 0.17677359f, 
    -0.05775832f, -0.08678722f, 0.10361008f, 0.11659323f, 0.06307460f, 0.14453086f, -0.10453456f, -0.06611132f, 
    0.10417872f, -0.04362258f, -0.06316067f, -0.02739362f, 0.11058582f, -0.03653412f, -0.01395286f, -0.12249706f, 
    0.35103256f, 0.15664953f, -0.08079999f, -0.02657732f, -0.00887477f, 0.04164594f, -0.04851037f, 0.01130287f, 
    0.06571752f, 0.08199993f, 0.03083019f, -0.01151023f, 0.21367352f, 0.00273116f, 0.28042486f, -0.04565343f, 
    0.10771858f, -0.05400520f, -0.05305302f, 0.08169889f, -0.00216385f, -0.05070922f, -0.03970812f, 0.00165101f, 
    0.06815168f, 0.35628694f, -0.14099848f, -0.09923524f, 0.12660137f, -0.00883534f, 0.00689138f, -0.05001642f, 
    0.10025087f, 0.04927417f, 0.05201309f, -0.07384832f, 0.03030283f, -0.15153134f, 0.11375302f, -0.00125488f, 
    0.03856724f, -0.03455549f, -0.13981637f, 0.12534091f, 0.05814953f, 0.01965311f, 0.10297988f, 0.21517371f, 
    -0.23798949f, -0.24030803f, -0.24198647f, -0.18550234f, 0.00834343f, 0.02962041f, -0.06336657f, -0.17453766f, 
    -0.01189940f, 0.02528729f, -0.02318927f, 0.07136701f, -0.06915049f, 0.19225155f, 0.26738212f, 0.08634759f, 
    -0.10700557f, -0.03120261f, 0.05302928f, 0.08726894f, -0.03994614f, -0.00582450f, 0.03402808f, 0.00787291f, 
    -0.16028818f, 0.12907672f, -0.03879460f, -0.22684407f, 0.03262879f, -0.00639151f, -0.01355232f, 0.04763752f, 
    0.01326101f, 0.06607793f, 0.12828813f, -0.08291010f, -0.14266464f, 0.02296320f, 0.00954183f, 0.00724607f, 
    -0.04025986f, -0.01234778f, 0.01927130f, 0.11529636f, -0.03298769f, 0.00631476f, 0.05119877f, 0.03427235f, 
    0.02857979f, -0.03944448f, 0.15931711f, 0.17371458f, 0.01528835f, 0.01514910f, 0.01319837f, 0.01827897f, 
    0.01701589f, 0.09868935f, -0.01570757f, 0.04331775f, -0.18413344f, -0.07732002f, 0.11974909f, 0.09878124f, 
    0.09382620f, 0.07321614f, 0.07667475f, -0.02759313f, 0.08104802f, 0.04833804f, 0.03070177f, -0.06003161f, 
    -0.05274824f, 0.02825489f, -0.01303954f, -0.00075722f, -0.04269674f, 0.04199912f, 0.03398157f, -0.02861664f, 
    -0.00275615f, -0.04225714f, -0.00947378f, 0.03936721f, -0.01536676f, -0.01527848f, 0.04071370f, 0.02418382f, 
    0.00672915f, -0.04153518f, 0.00059118f, 0.01804148f, -0.00208880f, -0.03653101f, -0.03454420f, 0.00718478f, 
    -0.04215268f, 0.02976969f, -0.04691423f, 0.04004082f, -0.00628222f, -0.02656722f, 0.03966634f, -0.02914011f, 
    -0.01682694f, 0.02346873f, -0.01625812f, -0.02389763f, -0.05531646f, -0.02379426f, 0.03799005f, 0.05056552f, 
    -0.01445447f, 0.03764812f, 0.02007102f, -0.01294551f, -0.02280685f, 0.02287916f, 0.01185919f, -0.04077756f, 
    0.00018851f, -0.02382595f, -0.01225849f, 0.02128649f, -0.01684926f, -0.00556564f, 0.00512807f, -0.03813624f, 
    -0.02916004f, 0.04274806f, 0.00501077f, -0.01391295f, 0.04530219f, -0.02729293f, -0.01775428f, -0.00847841f, 
    -0.03234944f, 0.03204983f, 0.01819902f, -0.03938289f, -0.04620159f, -0.02071087f, -0.05183200f, -0.03556481f, 
    -0.02951703f, 0.01271942f, 0.00360663f, 0.00085929f, 0.02216256f, 0.03902507f, 0.02311781f, 0.03317601f, 
    -0.04992763f, -0.03790665f, -0.00264200f, -0.02973807f, 0.03650745f, 0.00039614f, 0.00180971f, -0.01129179f, 
    0.04127960f, 0.01872369f, 0.00237795f, 0.04084351f, -0.03177429f, -0.03163705f, -0.03685698f, -0.05322175f, 
    -0.00135088f, -0.03934241f, -0.01696644f, -0.04001576f, -0.00495727f, -0.02878672f, -0.01202630f, 0.01114503f, 
    -0.00074278f, -0.05529812f, 0.01870126f, -0.05323192f, -0.02570514f, -0.02029840f, -0.00853548f, -0.04855609f, 
    0.01471283f, 0.03719312f, -0.02440052f, 0.00106045f, 0.02845911f, -0.04223740f, 0.01024317f, -0.04781318f, 
    -0.02489199f, -0.04494755f, -0.04348013f, 0.01706572f, -0.03789105f, -0.05509518f, -0.01931748f, 0.02821943f, 
    0.02464283f, 0.04111674f, -0.03806653f, 0.01303606f, -0.01691984f, -0.00848485f, -0.00608319f, 0.04010479f, 
    -0.02078293f, -0.01395625f, 0.03978270f, 0.02369236f, -0.05508038f, -0.00898749f, -0.00295936f, -0.01572886f, 
    -0.04971769f, -0.01259181f, -0.03204258f, 0.03953253f, -0.05862185f, -0.00089071f, -0.03845503f, -0.00125110f, 
    -0.00351018f, 0.04204111f, -0.04209112f, -0.05711551f, 0.02525006f, 0.01984842f, 0.01149523f, -0.02834570f, 
    0.02122524f, 0.00365321f, 0.03688894f, -0.00596139f, 0.03143884f, -0.03606422f, -0.05309889f, -0.02480312f, 
    -0.02736228f, -0.02288540f, 0.00430634f, -0.02001600f, -0.00472058f, -0.05914401f, 0.00464750f, -0.00952338f, 
    0.01700531f, -0.02682582f, -0.04279742f, 0.01790587f, -0.02612894f, 0.01054923f, -0.04889433f, 0.00607475f, 
    0.03674711f, -0.05359811f, 0.01511242f, 0.01697374f, -0.01394675f, 0.01702990f, -0.02197639f, 0.03055773f, 
    0.00744014f, 0.01761247f, 0.03670274f, -0.04364637f, 0.01485116f, -0.00347783f, -0.00453011f, -0.03395456f, 
    0.04906878f, -0.03832062f, 0.01351858f, -0.04777058f, 0.01081430f, -0.00648393f, -0.06049487f, 0.00220965f, 
    -0.04698117f, 0.03211194f, 0.03482520f, 0.01807716f, -0.04883366f, -0.05645159f, -0.05746400f, -0.02953155f, 
    -0.02566634f, -0.04159775f, -0.03842650f, -0.02091393f, -0.00889764f, 0.04013902f, -0.00777015f, 0.00834108f, 
    -0.03640150f, -0.00279640f, 0.04522470f, -0.00149381f, 0.01286679f, -0.05346422f, -0.03351340f, -0.03417141f, 
    0.00783153f, 0.02871227f, 0.03374486f, -0.01553826f, 0.04816501f, 0.01054521f, 0.01084828f, -0.01469666f, 
    -0.04796714f, 0.02068765f, 0.02156705f, 0.02285633f, 0.03614904f, 0.04535270f, 0.03762920f, 0.02181244f, 
    0.00471221f, 0.01440691f, 0.00714805f, -0.00813697f, -0.01120678f, 0.00078591f, 0.00191839f, 0.02412081f, 
    -0.01378153f, -0.02713326f, 0.01301663f, 0.03810165f, 0.00301097f, -0.05144248f, -0.02853816f, 0.03446281f, 
    -0.02781803f, -0.03942947f, 0.04131447f, 0.02809795f, 0.04000108f, 0.00065664f, -0.04506180f, -0.02337326f, 
    -0.05989235f, 0.02545287f, 0.00059185f, -0.02062910f, -0.05379051f, 0.01234086f, -0.02162430f, 0.02342406f, 
    -0.04396743f, -0.03953584f, 0.02443926f, -0.01435039f, -0.04681176f, 0.02035036f, 0.05206120f, -0.05187446f, 
    -0.03685885f, -0.03015939f, -0.00627783f, 0.01080679f, 0.02173439f, -0.02595203f, -0.03437978f, -0.03572049f, 
    -0.00690346f, 0.01775709f, -0.03391960f, -0.01906002f, 0.02108959f, -0.02598360f, 0.04428716f, -0.01754048f, 
    -0.02021044f, 0.01279429f, 0.02898728f, -0.02752312f, -0.02951920f, 0.03357057f, 0.01772716f, -0.04514334f, 
    -0.02979062f, -0.04452566f, -0.01135614f, -0.03924868f, 0.02202792f, 0.01913134f, -0.00911935f, -0.02100312f, 
    -0.04906382f, -0.04818513f, 0.03725305f, 0.03504904f, -0.01130300f, -0.02540761f, 0.00724257f, -0.03331557f, 
    0.01021657f, -0.00238547f, -0.01091559f, -0.00134287f, 0.02080114f, 0.02662258f, 0.00803950f, -0.04791324f, 
    0.03832304f, -0.00100918f, 0.04138335f, 0.02787255f, 0.00152738f, 0.04520366f, 0.04412261f, -0.01762431f, 
    0.02684958f, -0.01896915f, -0.02864639f, -0.02569347f, -0.02552402f, 0.00284838f, -0.00786241f, 0.03756895f, 
    0.00285386f, -0.04782125f, -0.02816903f, -0.00602319f, -0.05610914f, -0.00854804f, 0.00617420f, 0.01730124f, 
    0.03693291f, 0.02817357f, -0.02777398f, 0.03141491f, -0.01056533f, 0.03440078f, 0.01225238f, -0.04987954f, 
    -0.00171764f, -0.04770306f, 0.03182856f, 0.02215324f, 0.03950622f, 0.03954846f, 0.02404208f, 0.03599078f, 
    0.03341536f, -0.01085813f, 0.00209096f, 0.02768994f, 0.00826283f, 0.01308399f, 0.03925721f, 0.01745969f, 
    0.02490339f, 0.06476124f, -0.02610521f, 0.06998242f, 0.17218488f, 0.15869574f, 0.02442236f, -0.13581035f, 
    -0.11620314f, -0.00373469f, -0.00460401f, 0.11895341f, 0.17736678f, 0.06537281f, 0.05700634f, -0.17728844f, 
    -0.08368522f, -0.05738015f, -0.02606775f, 0.06673955f, 0.02599983f, 0.12526646f, 0.15363243f, 0.09886687f, 
    0.12514246f, 0.06078141f, 0.18470937f, -0.13008936f, -0.06344643f, -0.08005621f, -0.04865306f, 0.04337188f, 
    -0.00910212f, -0.06083600f, 0.05249562f, 0.18987513f, -0.02895094f, 0.15185884f, 0.09108490f, 0.12197301f, 
    -0.00779535f, 0.11003631f, 0.04514449f, -0.11758540f, 0.01833473f, -0.05653520f, 0.05644831f, 0.10244346f, 
    0.09879074f, 0.12836705f, -0.06109050f, 0.08983346f, 0.07595934f, 0.06364743f, -0.06131331f, 0.00822248f, 
    -0.04348981f, 0.06819201f, 0.03588827f, 0.05789785f, -0.03363631f, 0.03618295f, -0.09796721f, 0.02690995f, 
    -0.09394915f, 0.01350483f, 0.05570682f, 0.04558902f, -0.01040944f, -0.01849092f, -0.00605589f, -0.13238934f, 
    -0.03166562f, 0.01297297f, -0.03754893f, -0.10371065f, -0.12321324f, -0.06518362f, 0.11085910f, 0.07890096f, 
    -0.01151538f, 0.08091848f, 0.01947734f, -0.05289362f, -0.14705078f, -0.07144737f, 0.11457761f, 0.06420701f, 
    0.09075822f, 0.15901034f, -0.05796380f, 0.02594653f, 0.03688402f, -0.00916916f, 0.02217074f, 0.05636814f, 
    0.27981582f, 0.10694466f, -0.06369901f, -0.02561232f, 0.01332451f, 0.00785806f, 0.01893246f, 0.04133260f, 
    0.05909374f, 0.14669216f, 0.03575566f, 0.05581795f, -0.02759195f, 0.04856706f, 0.08568074f, 0.13178511f, 
    -0.08613136f, -0.06937174f, 0.13449100f, 0.02829643f, 0.13582578f, -0.03332844f, -0.00199501f, -0.07638741f, 
    0.11296509f, -0.06069406f, 0.03651318f, 0.17815706f, -0.08665982f, -0.02298567f, -0.07292130f, 0.05739119f, 
    0.07551637f, 0.06924998f, 0.00555970f, -0.04000363f, 0.26071471f, 0.28676397f, -0.32447705f, 0.14974745f, 
    -0.08264120f, 0.08624941f, 0.00204147f, -0.00749780f, 0.01508594f, 0.08790254f, -0.05062197f, 0.06832210f, 
    0.03308091f, -0.07253130f, -0.05165447f, -0.16598268f, -0.12628119f, 0.00616449f, 0.11431955f, 0.08553637f, 
    0.09948320f, 0.01043045f, 0.06209880f, 0.01400889f, -0.31378481f, -0.06373520f, 0.10582615f, -0.06649484f, 
    0.20016137f, 0.05586027f, -0.02749119f, 0.00526141f, 0.15062729f, 0.10086309f, 0.12238710f, -0.06995600f, 
    0.10375929f, 0.12054291f, 0.07978956f, 0.09975523f, -0.03877932f, -0.06693581f, 0.05035953f, -0.08350010f, 
    0.09334794f, -0.06241682f, 0.07486132f, 0.07804637f, -0.07933550f, 0.08613340f, 0.10896534f, 0.14734179f, 
    -0.06858511f, -0.03993407f, 0.02917406f, 0.10538197f, 0.10025988f, -0.06718890f, 0.05296232f, -0.01025302f, 
    0.09229000f, -0.30716345f, -0.18222998f, -0.12330800f, 0.08035224f, 0.14060774f, 0.01052850f, -0.06710797f, 
    0.00881145f, -0.01748398f, -0.01076622f, 0.02200412f, 0.03971883f, -0.06894433f, 0.10758214f, 0.01391429f, 
    -0.10080519f, 0.05881186f, 0.08094964f, 0.01251707f, 0.02794286f, -0.05926434f, -0.00060646f, -0.10888074f, 
    0.24426667f, -0.02643134f, 0.08213405f, -0.10663620f, 0.09373216f, -0.09019390f, -0.04836264f, -0.03721180f, 
    0.01709289f, 0.08475731f, -0.03397996f, 0.07751629f, -0.03538481f, -0.10844988f, 0.03193833f, -0.22677691f, 
    0.09610382f, -0.07282918f, 0.04658195f, 0.05970677f, 0.11186849f, 0.03351710f, 0.05668464f, 0.16873775f, 
    0.09342832f, 0.00246977f, -0.00614168f, -0.08862154f, 0.09936319f, 0.09845934f, -0.05473334f, 0.07783320f, 
    0.01150258f, -0.01059479f, -0.07212894f, 0.09593362f, 0.05825545f, 0.06163496f, -0.12585004f, -0.17175572f, 
    -0.02724208f, -0.01821568f, 0.02424788f, 0.00171922f, -0.06701905f, -0.00123150f, -0.02181411f, -0.00018339f, 
    -0.36269841f, 0.15565971f, 0.07494159f, -0.18889548f, 0.05816548f, -0.04875109f, -0.12738411f, 0.12534171f, 
    -0.00107881f, -0.01918133f, -0.06431860f, -0.01731393f, 0.03333308f, 0.11516877f, 0.08184216f, -0.01338167f, 
    0.04829490f, -0.07793453f, 0.03606167f, -0.04038000f, -0.03480141f, -0.14298202f, -0.01938019f, -0.06107710f, 
    -0.19651480f, -0.03601391f, 0.21767540f, -0.04839779f, 0.18982506f, 0.13230199f, -0.08988816f, -0.00819726f, 
    0.20033506f, -0.03906430f, 0.07722687f, 0.08209775f, 0.00591209f, -0.11978459f, -0.25645769f, 0.09103768f, 
    0.06789945f, -0.05269077f, -0.02648996f, 0.07196722f, 0.07529352f, -0.06087850f, -0.03176293f, 0.12365875f, 
    0.08231197f, 0.03209018f, 0.10270128f, 0.02977940f, -0.02846330f, 0.17551255f, -0.01773482f, -0.05282772f, 
    0.08420137f, -0.08236032f, -0.11348210f, -0.00161163f, 0.09265977f, -0.03570801f, 0.13739161f, 0.25217831f, 
    0.00514816f, -0.03718778f, 0.15057161f, 0.05833613f, -0.11274203f, -0.00268675f, -0.02100291f, 0.11437059f, 
    0.23778294f, 0.05054821f, -0.17780995f, 0.16344398f, 0.05457884f, 0.01130110f, -0.00925492f, -0.00694032f, 
    0.04141668f, 0.02770403f, 0.08877621f, 0.05569602f, -0.33941686f, -0.04491653f, -0.15389065f, 0.15139815f, 
    0.13425621f, 0.01709446f, 0.01192005f, 0.02309975f, -0.06437447f, 0.06150350f, -0.08114354f, -0.06806567f, 
    -0.18308647f, 0.03986631f, 0.09930297f, 0.28222892f, -0.14198376f, -0.08364180f, 0.05021084f, 0.05838269f, 
    -0.00440524f, -0.01709804f, 0.03716169f, -0.11381596f, -0.13433596f, -0.08087671f, -0.00843385f, 0.30219343f, 
    0.00703186f, 0.08433957f, 0.05972394f, -0.19788539f, 0.03015070f, 0.01992226f, -0.01197195f, -0.03661789f, 
    0.06751359f, 0.24824820f, 0.13643561f, -0.11672133f, -0.08505479f, 0.10001344f, 0.09865605f, 0.01641021f, 
    -0.08388598f, -0.07215269f, 0.07376136f, 0.00156105f, -0.11250743f, 0.08990874f, 0.09304881f, -0.16268241f, 
    0.11822487f, 0.09781449f, -0.01210557f, -0.04452047f, -0.02667269f, -0.10745562f, 0.02082334f, 0.08304627f, 
    0.07695046f, -0.00720370f, 0.27949247f, -0.20910221f, 0.09814816f, 0.02118450f, 0.02252529f, 0.06717356f, 
    0.15242954f, 0.02799531f, -0.04272630f, 0.00815695f, -0.08632047f, 0.14133358f, 0.17264080f, 0.18097350f, 
    -0.28405523f, -0.00721711f, 0.02896657f, 0.00266043f, -0.08533519f, -0.09610424f, -0.02731032f, 0.05826034f, 
    -0.00864101f, 0.01765030f, 0.05211274f, 0.28203678f, -0.00351174f, 0.03892910f, 0.05286522f, -0.01499881f, 
    -0.00403475f, 0.00377786f, -0.18906948f, 0.02690036f, 0.12784013f, 0.05508702f, -0.07793125f, -0.00307146f, 
    -0.00853452f, 0.14782605f, 0.04907355f, -0.05907862f, -0.11375106f, -0.00490917f, -0.00460870f, 0.07713589f, 
    -0.34102792f, 0.07097177f, 0.08974618f, -0.08639737f, 0.10819984f, 0.04404358f, 0.03734502f, -0.00094254f, 
    0.00804854f, -0.01554167f, 0.05464175f, -0.08901069f, -0.08579363f, -0.07025202f, 0.16324022f, 0.02972575f, 
    0.06609482f, -0.03254521f, -0.08378001f, -0.12707032f, -0.03963390f, -0.12369310f, 0.00595629f, -0.06877639f, 
    -0.08629861f, -0.14247128f, 0.08424716f, 0.19208719f, -0.04680432f, -0.08615253f, 0.08608099f, 0.01505744f, 
    -0.01157339f, -0.00926305f, -0.07477756f, 0.07569065f, -0.08024368f, -0.10834774f, 0.00375254f, 0.13414447f, 
    0.01997226f, -0.09396474f, -0.04589791f, 0.03640323f, -0.02524108f, 0.09865389f, 0.09399254f, 0.13462865f, 
    -0.23181863f, 0.00606474f, -0.04238245f, 0.15816809f, 0.17348562f, -0.02048929f, -0.01149920f, -0.03243656f, 
    0.10273181f, -0.04056150f, 0.06705720f, 0.07515065f, 0.21522586f, -0.03378113f, 0.06354003f, 0.24934995f, 
    -0.13385715f, -0.05945247f, 0.12268435f, -0.14059764f, -0.00563944f, 0.00210154f, -0.07187279f, 0.02499005f, 
    0.00565107f, -0.16912073f, 0.13803546f, 0.04956697f, -0.03762576f, -0.03891542f, 0.17367935f, 0.10226796f, 
    0.07412851f, -0.15471509f, -0.05317057f, -0.04194266f, 0.23407771f, 0.25777090f, 0.17112716f, -0.10891338f, 
    -0.06389540f, 0.07966874f, 0.13116746f, 0.04145661f, -0.00737084f, 0.04895125f, 0.08990620f, -0.00055081f, 
    -0.17838798f, 0.07496792f, 0.04901758f, -0.15265508f, 0.15978669f, 0.16884637f, 0.06547363f, -0.12213291f, 
    -0.03098191f, 0.07948784f, 0.04466495f, -0.00594185f, -0.41481230f, 0.12821551f, 0.10966483f, 0.06910431f, 
    0.06182808f, -0.04240060f, -0.00604620f, -0.02447995f, -0.07368677f, -0.03103369f, 0.11281133f, 0.04100861f, 
    -0.22599159f, 0.03957661f, 0.09622729f, -0.00601680f, -0.07328253f, 0.04416037f, 0.08193802f, -0.02107688f, 
    -0.06124162f, -0.10518459f, -0.03655706f, -0.12046701f, -0.01186672f, -0.06926383f, -0.07384600f, -0.09279253f, 
    -0.11748484f, -0.04093100f, 0.14953178f, 0.03426774f, -0.16731060f, 0.00553635f, 0.02455442f, -0.05051078f, 
    -0.12822254f, 0.03999726f, 0.03071471f, 0.14447553f, 0.11682830f, 0.02689176f, 0.03955089f, 0.05835235f, 
    -0.01692363f, 0.07881451f, 0.04100658f, -0.02470891f, 0.08204904f, 0.08365941f, -0.05188927f, -0.26701692f, 
    -0.02015118f, 0.09293675f, 0.06401911f, 0.02978710f, 0.06999665f, -0.06627944f, 0.01493869f, -0.11093275f, 
    0.09274143f, 0.10879534f, -0.23895839f, 0.07312676f, -0.03003875f, -0.10150117f, 0.03542988f, -0.07348660f, 
    -0.13841289f, 0.06285278f, -0.06955601f, -0.04902382f, 0.08446525f, -0.17661315f, -0.08860316f, 0.13895161f, 
    0.02596933f, 0.06157424f, -0.00510016f, -0.00188322f, -0.19506143f, -0.03915383f, -0.00564064f, 0.10193392f, 
    -0.16556011f, 0.21162276f, 0.18148115f, -0.10175800f, 0.00581331f, 0.02431425f, 0.13560428f, 0.06560118f, 
    -0.07482260f, 0.04576318f, -0.05028371f, 0.05369454f, -0.28005844f, 0.05350251f, -0.20941472f, -0.05520115f, 
    -0.06416216f, 0.10305677f, 0.01819333f, -0.02811613f, 0.02913133f, 0.01254641f, 0.05245473f, -0.02261114f, 
    0.01126825f, 0.17765382f, 0.40688512f, -0.10786577f, -0.03385403f, 0.01606201f, -0.00994817f, 0.08501250f, 
    0.06091323f, -0.05624436f, 0.04131179f, -0.01906778f, -0.07109890f, 0.03418743f, -0.16918430f, -0.03260661f, 
    0.14399047f, 0.02708584f, 0.05566124f, -0.04941362f, 0.02057234f, 0.05469095f, -0.11139599f, -0.10850688f, 
    0.07232102f, 0.15638204f, 0.36104721f, 0.16694054f, -0.04368352f, 0.00971958f, 0.16417634f, 0.04255351f, 
    -0.00673345f, 0.01586945f, 0.00015325f, 0.03920441f, -0.08276843f, 0.03695095f, -0.19844061f, 0.19811656f, 
    0.09339236f, 0.07827283f, 0.06006663f, -0.01605662f, 0.00898361f, -0.04691712f, 0.04711344f, -0.01542240f, 
    0.04844631f, -0.17661646f, -0.03548944f, 0.13286388f, 0.05376165f, 0.05252942f, -0.05488894f, -0.05203931f, 
    -0.05785755f, 0.00162668f, -0.07059542f, 0.06404566f, 0.13655211f, -0.23099884f, -0.24679102f, -0.01651352f, 
    0.05169830f, 0.05052564f, 0.08306731f, -0.05026258f, 0.01922784f, -0.02219395f, 0.08713013f, -0.04528650f, 
    -0.08764943f, 0.02543341f, -0.14762132f, 0.17652462f, 0.11231749f, 0.00780101f, -0.03518002f, 0.10824720f, 
    -0.01576612f, 0.05292907f, 0.08320845f, 0.00048287f, 0.25930661f, -0.14553830f, -0.04156520f, 0.25626758f, 
    0.10735226f, -0.00604460f, 0.03443928f, -0.00605306f, -0.09000426f, -0.01597910f, 0.04627514f, -0.04680368f, 
    -0.02387489f, 0.04462776f, 0.22171675f, 0.06490216f, 0.09057847f, -0.06646668f, -0.03486058f, 0.00156091f, 
    0.05590457f, -0.00127322f, -0.08862429f, -0.05578892f, 0.14565796f, 0.01213521f, -0.24641572f, -0.20852193f, 
    -0.01937737f, -0.07623602f, -0.00094538f, 0.05239514f, -0.03645362f, 0.16009477f, 0.13525945f, -0.01630649f, 
    -0.11867071f, 0.06628990f, 0.03225028f, -0.01379232f, 0.08935585f, 0.02282644f, 0.02175672f, -0.01079052f, 
    0.09394291f, 0.01598798f, 0.02571883f, 0.22975156f, -0.29865113f, 0.08063568f, 0.12550171f, -0.11360664f, 
    0.00694177f, 0.10668530f, 0.15349770f, -0.01300634f, 0.20688070f, -0.06053542f, 0.07904952f, -0.05777385f, 
    -0.06739826f, -0.07144066f, -0.06346339f, -0.17819676f, 0.15307273f, 0.01826178f, 0.01915182f, 0.13734932f, 
    0.02431747f, -0.05882074f, 0.19759080f, 0.01621274f, -0.20372111f, -0.15967178f, 0.04772574f, -0.03158963f, 
    -0.00897286f, -0.07853187f, -0.02043963f, 0.02447882f, -0.03532188f, 0.05599454f, 0.01983778f, -0.05552570f, 
    -0.04996657f, -0.04157409f, 0.00640832f, 0.03183918f, 0.04372532f, -0.05027565f, 0.06452610f, 0.01809715f, 
    -0.03523805f, -0.01115572f, -0.16723181f, 0.12396514f, -0.09654656f, 0.13986352f, 0.14922251f, 0.01269650f, 
    0.09373349f, -0.04989936f, 0.00165637f, -0.01787453f, -0.00541947f, 0.15268402f, 0.10486574f, 0.00007624f, 
    -0.10209110f, 0.06331442f, -0.09790520f, -0.20142761f, 0.01846607f, 0.15967658f, -0.05028999f, 0.12471564f, 
    0.13655405f, 0.02786295f, 0.06838705f, 0.09787804f, 0.06544070f, -0.11000745f, 0.06356295f, -0.02926514f, 
    0.05061918f, 0.11424828f, -0.12694444f, -0.05823856f, 0.14081430f, -0.09236924f, -0.05363908f, 0.01839138f, 
    0.02931272f, -0.16864799f, -0.06803019f, -0.22157602f, -0.00327169f, 0.19571136f, -0.01527084f, 0.09896513f, 
    0.13437432f, 0.08845054f, 0.00513992f, -0.05669246f, -0.13672626f, 0.21808989f, 0.02131041f, -0.00840132f, 
    -0.04743631f, 0.05745896f, 0.07746241f, 0.11103090f, 0.05010910f, 0.05491083f, -0.12164984f, -0.00326823f, 
    -0.20262648f, -0.05953382f, -0.03869934f, -0.19758385f, 0.11121985f, -0.02182039f, 0.01504168f, 0.02052260f, 
    -0.02158464f, 0.09575561f, 0.06687213f, 0.14279591f, 0.05214023f, -0.19544502f, 0.28184411f, 0.34647653f, 
    -0.01451005f, -0.00917522f, 0.00143797f, 0.10200142f, -0.02611592f, 0.15484579f, 0.10829233f, 0.03576204f, 
    0.10441019f, -0.26029697f, -0.04092526f, 0.08600315f, 0.03157491f, 0.01292259f, -0.07857740f, 0.06811007f, 
    0.19717078f, -0.12931706f, 0.03505395f, 0.07264675f, 0.08208176f, -0.13631195f, -0.21821353f, -0.05006806f, 
    -0.02223725f, 0.13458705f, 0.13277903f, 0.01307173f, 0.13312231f, 0.14492871f, 0.10631695f, 0.05689989f, 
    -0.06987339f, -0.03652997f, 0.00567658f, 0.18593316f, -0.02183277f, -0.00672591f, 0.00704635f, -0.10633676f, 
    0.08906468f, -0.02749892f, -0.06282248f, 0.09370624f, -0.09259362f, 0.06668495f, 0.13779277f, -0.05029602f, 
    0.06705603f, 0.07301484f, 0.05809034f, -0.00711553f, 0.14163998f, -0.09711020f, -0.08503370f, -0.01429650f, 
    0.05464800f, 0.08499118f, 0.02865808f, -0.01138564f, 0.11266825f, -0.04540555f, 0.17222451f, -0.08974280f, 
    -0.08813956f, 0.13691378f, -0.05690034f, 0.04565615f, 0.04472705f, 0.07342970f, -0.09702095f, -0.16448487f, 
    -0.04319505f, 0.03752710f, 0.02742491f, 0.05192149f, 0.00011397f, 0.03299139f, 0.00365363f, 0.02489280f, 
    0.14028721f, -0.01859982f, 0.01612547f, -0.04427496f, 0.06994414f, 0.02276453f, 0.05678306f, 0.23089515f, 
    -0.04062804f, 0.02916211f, 0.12194995f, 0.10685806f, -0.00307532f, 0.08104566f, -0.10444205f, -0.11115571f, 
    -0.02936279f, -0.06520999f, 0.18372191f, 0.03349789f, -0.06331528f, -0.08286341f, -0.04113818f, -0.04777516f, 
    0.42367771f, 0.26961169f, 0.04546668f, 0.22500636f, 0.01326546f, -0.02741331f, 0.00915108f, 0.04561375f, 
    0.12944098f, 0.21469364f, 0.14750578f, 0.02789383f, -0.08958101f, 0.14603138f, -0.10985623f, 0.02749711f, 
    0.02865249f, -0.05405835f, -0.13493598f, 0.04506649f, -0.02261463f, -0.02159379f, -0.08562265f, 0.00442770f, 
    -0.08731648f, 0.33770528f, 0.21338655f, 0.03604637f, -0.08564656f, 0.02508657f, 0.06617144f, 0.11024401f, 
    0.07509784f, 0.05898876f, 0.20049763f, -0.00022873f, -0.15366185f, -0.33185759f, 0.00511291f, -0.09595926f, 
    -0.00500278f, 0.03813265f, 0.00129948f, 0.12706023f, 0.04918726f, -0.21622123f, -0.06693130f, 0.14597599f, 
    -0.23716024f, -0.25709030f, 0.01693437f, -0.13899897f, -0.00494610f, 0.02885810f, 0.04328749f, 0.05689672f, 
    0.03517855f, 0.01208915f, 0.01130421f, -0.03864177f, -0.19000927f, -0.01438569f, 0.05681681f, -0.00229968f, 
    0.01526893f, -0.07242041f, 0.08334136f, -0.06686166f, 0.02583542f, -0.01704671f, 0.02293567f, 0.14133643f, 
    0.04092873f, 0.04483620f, 0.10523903f, -0.12047698f, -0.03455783f, 0.02650000f, 0.20793918f, 0.02242368f, 
    0.08083377f, -0.01745821f, 0.21378207f, 0.13095328f, -0.10723247f, -0.15036048f, 0.21801743f, -0.39571363f, 
    0.07839870f, 0.05739942f, 0.02220419f, 0.25296322f, -0.05126090f, -0.02841072f, 0.09728190f, 0.02819004f, 
    -0.22450183f, -0.06031571f, 0.00239032f, -0.06406064f, -0.02866236f, 0.00313608f, 0.07193036f, -0.05886706f, 
    0.15745370f, 0.00304389f, -0.12015402f, 0.16967434f, -0.21159241f, -0.02671125f, 0.17121668f, -0.13292174f, 
    0.03234106f, -0.05177949f, 0.17874080f, 0.16222526f, 0.10644785f, 0.06936641f, 0.08624736f, 0.05319498f, 
    -0.14314944f, -0.13737951f, 0.08345582f, 0.02693278f, 0.18663298f, 0.06052113f, 0.01611360f, -0.07878270f, 
    -0.08057427f, 0.03617108f, 0.00291493f, 0.02444203f, -0.14320621f, 0.01054895f, -0.05183672f, -0.17364693f, 
    -0.10028259f, -0.05869558f, -0.04120292f, 0.09263290f, -0.04312971f, 0.20551759f, 0.08498771f, 0.06340913f, 
    0.02578942f, -0.09143543f, 0.11359591f, -0.09964371f, -0.01433097f, 0.07182954f, 0.09188677f, -0.12940510f, 
    0.08445498f, 0.06226683f, 0.10123694f, 0.24653473f, -0.36231777f, 0.01232581f, 0.11695024f, 0.04118187f, 
    -0.03253659f, 0.02862968f, 0.10577734f, -0.10670998f, 0.08009890f, -0.00499116f, 0.01023682f, 0.05646571f, 
    -0.10874118f, 0.08336334f, 0.05201227f, -0.05055743f, 0.12650888f, -0.11807567f, 0.16386163f, -0.01491831f, 
    -0.04476077f, -0.03918968f, 0.17218931f, 0.09852230f, 0.16668117f, 0.08300435f, 0.19458529f, -0.02562224f, 
    0.07963117f, 0.12005368f, -0.05320262f, 0.01250701f, -0.04615976f, -0.01904026f, 0.04975152f, -0.24190144f, 
    -0.09527476f, -0.01996756f, 0.06383813f, 0.04111947f, -0.07079651f, 0.02482546f, 0.06263487f, 0.09193161f, 
    -0.03460672f, 0.09530085f, 0.09363085f, 0.00132101f, 0.26286539f, 0.06071505f, 0.01642662f, 0.11591209f, 
    -0.00460891f, -0.04772801f, 0.04801940f, 0.02713461f, -0.02512611f, 0.17198122f, 0.05341617f, 0.06195845f, 
    0.11264303f, -0.28705680f, -0.03431613f, -0.14857213f, -0.00349463f, 0.04789893f, -0.03983695f, 0.03522889f, 
    0.09726547f, 0.18615018f, -0.08929612f, 0.14655112f, 0.29621547f, 0.26347148f, -0.07149711f, -0.10290418f, 
    -0.05207444f, 0.05979263f, -0.17661552f, -0.06896878f, 0.11737915f, 0.06409189f, -0.05285056f, -0.09273460f, 
    -0.07792140f, 0.04617964f, -0.01780614f, -0.11553327f, 0.04498500f, 0.06070122f, -0.16899474f, 0.00511543f, 
    -0.00698809f, 0.14146669f, -0.09898002f, 0.01099418f, 0.08922421f, -0.20986922f, 0.10522065f, 0.24046829f, 
    0.02219565f, -0.04294120f, -0.09226937f, 0.03049197f, 0.03392543f, 0.00000846f, -0.16372129f, -0.05745623f, 
    0.14814603f, -0.04547339f, -0.08532798f, -0.11258280f, 0.02247403f, -0.11654904f, -0.00480026f, 0.07027933f, 
    -0.00370956f, 0.07172783f, 0.11571350f, 0.13842282f, -0.02455550f, -0.13629943f, 0.17581254f, 0.14696671f, 
    -0.03073374f, -0.00666778f, -0.07008116f, -0.04161375f, -0.06550977f, 0.04254633f, 0.24642843f, -0.04060600f, 
    0.01934534f, -0.08284772f, 0.09593469f, 0.09519239f, 0.11402135f, 0.07320522f, -0.06146456f, -0.18356632f, 
    0.08237433f, -0.14270586f, -0.05487924f, -0.01873249f, -0.00275163f, 0.23195043f, -0.02363290f, 0.06843159f, 
    0.02250324f, 0.03975135f, -0.05272218f, 0.07615421f, 0.05028171f, 0.08032737f, 0.04949294f, 0.04888766f, 
    0.05554869f, 0.07778887f, -0.01009745f, 0.00559112f, 0.09141403f, 0.02164449f, -0.14912182f, -0.16600095f, 
    0.08262193f, -0.08126149f, 0.00229888f, 0.04023558f, -0.17082505f, 0.04174625f, -0.03954340f, 0.00123436f, 
    -0.03880184f, 0.05685385f, 0.10113604f, -0.00833817f, 0.10713553f, -0.01585125f, -0.09257638f, -0.21902886f, 
    -0.04381112f, 0.04218403f, 0.04749974f, 0.02727378f, 0.11350097f, -0.06279390f, 0.08245379f, -0.06948796f, 
    -0.00648908f, 0.12641317f, -0.02948577f, 0.13574199f, -0.17919275f, 0.24246368f, -0.05781305f, -0.12891160f, 
    0.01304126f, 0.02175891f, 0.02526537f, 0.01291925f, 0.05418579f, 0.17213346f, -0.07177269f, 0.10973989f, 
    -0.05246458f, -0.10074987f, 0.10172016f, 0.16665854f, 0.01720218f, -0.00448116f, 0.12298363f, 0.16197649f, 
    -0.05089364f, -0.14307901f, 0.00414525f, 0.17419460f, -0.07252340f, -0.01880083f, 0.11922491f, 0.10486414f, 
    0.05134598f, -0.04587990f, 0.12255125f, -0.02557375f, 0.01968628f, 0.09080154f, 0.04889585f, 0.01131569f, 
    0.31991786f, 0.24051736f, 0.22074223f, 0.16823539f, 0.09521560f, -0.04971838f, -0.10246014f, -0.13041183f, 
    0.07164721f, 0.15145892f, 0.13405406f, -0.01096380f, -0.27275953f, 0.15924624f, 0.02260180f, 0.03261743f, 
    0.04433421f, 0.05327401f, -0.14353612f, -0.11816639f, -0.04283462f, 0.05726424f, -0.12528139f, -0.01060092f, 
    -0.07313447f, 0.12283882f, 0.08410998f, 0.14945494f, -0.07050338f, -0.01125762f, -0.00587346f, 0.04847677f, 
    0.08095346f, -0.00361936f, 0.05556587f, -0.03865186f, -0.07334974f, -0.01816976f, 0.18310624f, -0.02728195f, 
    0.09755848f, 0.24674153f, 0.06586079f, 0.04094499f, -0.04261846f, -0.14604546f, -0.14123823f, 0.22970948f, 
    -0.21408743f, -0.23768800f, -0.06924002f, 0.08899055f, 0.07189433f, -0.13122463f, -0.12494034f, -0.02967291f, 
    -0.05391017f, -0.03912826f, -0.05786229f, -0.17723101f, -0.14467128f, 0.04098692f, 0.06668176f, 0.02772162f, 
    0.04813733f, -0.09010009f, 0.04202946f, -0.15145376f, -0.02705045f, 0.05010065f, 0.02436910f, 0.01978227f, 
    -0.06763272f, 0.06706800f, 0.00481924f, -0.19658166f, -0.10607617f, -0.10080153f, -0.00423247f, -0.10465381f, 
    0.08723804f, -0.01350310f, 0.17929848f, 0.12697788f, -0.00511603f, 0.16567892f, 0.19222061f, -0.15594259f, 
    0.01856535f, 0.05344100f, -0.22720574f, 0.06352387f, -0.08732592f, 0.05117358f, -0.03250166f, -0.05205980f, 
    0.02773333f, 0.15796007f, 0.07133118f, 0.08217388f, 0.09299023f, 0.09299221f, 0.15122509f, -0.04989628f, 
    0.09696434f, -0.04186492f, 0.15201527f, 0.00464057f, -0.13198635f, -0.02622246f, 0.06414334f, 0.07801422f, 
    0.24249484f, 0.05942675f, 0.01765348f, 0.08077600f, 0.13535844f, -0.01028690f, 0.04823788f, -0.07716223f, 
    0.09829409f, 0.38617104f, 0.24274576f, -0.37846056f, -0.05899527f, 0.00887192f, 0.00972418f, 0.11772988f, 
    0.08625752f, 0.04859168f, -0.00669061f, -0.05440229f, -0.12253128f, 0.03334205f, -0.03385191f, 0.09707399f, 
    -0.00464601f, 0.08799832f, -0.04528233f, -0.14104599f, 0.02526105f, -0.16607845f, -0.10226615f, 0.14700386f, 
    0.33629715f, 0.17222016f, -0.10697994f, 0.03953229f, 0.04491463f, 0.11205400f, -0.10643698f, 0.18734269f, 
    0.07275379f, 0.12504132f, -0.03068890f, -0.13234091f, 0.03312445f, 0.01772394f, 0.13373354f, -0.23563643f, 
    -0.09194633f, 0.03857665f, -0.08982917f, -0.03967485f, -0.17222770f, 0.00282176f, -0.06754625f, 0.02054636f, 
    -0.19610032f, -0.20617659f, 0.12759016f, 0.02951922f, 0.02977440f, -0.05702804f, -0.04150231f, 0.04167369f, 
    0.00701033f, -0.04426530f, -0.21728002f, -0.00783938f, -0.11525717f, 0.04616554f, 0.04611715f, 0.06736866f, 
    0.08263563f, 0.07860100f, -0.03602047f, -0.03158505f, 0.04039344f, 0.12752321f, -0.02425360f, 0.23440368f, 
    0.01169072f, -0.01891333f, 0.19598356f, 0.22664589f, 0.03466270f, 0.05566039f, 0.00664837f, -0.06081946f, 
    0.08492669f, -0.02309604f, 0.01466519f, -0.12020170f, 0.20231202f, 0.05067949f, 0.01695199f, -0.13189051f, 
    0.08343814f, 0.00030277f, -0.00883294f, -0.03051103f, -0.12650631f, -0.12604651f, -0.03720202f, -0.08387513f, 
    0.16122055f, -0.21023311f, -0.19546175f, 0.03093436f, -0.08096860f, 0.04208650f, 0.15264858f, 0.01072984f, 
    0.08869762f, -0.13110468f, 0.11143838f, -0.05371553f, -0.18638748f, 0.11222489f, -0.01444299f, 0.10780782f, 
    0.08262992f, 0.00734936f, 0.14360997f, 0.12278990f, -0.00655014f, 0.01136258f, 0.05942111f, 0.14030360f, 
    -0.25392836f, 0.09772438f, -0.12704670f, 0.18454206f, 0.14948234f, -0.09265453f, 0.05878428f, 0.10118806f, 
    0.00322047f, -0.11117986f, -0.01527600f, 0.04136634f, 0.23867868f, -0.51492864f, 0.06321375f, 0.08452195f, 
    -0.02790416f, -0.01698005f, 0.08847325f, -0.05629242f, -0.08824312f, 0.02208534f, 0.11486270f, 0.00997106f, 
    0.03827177f, 0.12010209f, 0.28871119f, 0.01131592f, 0.12010819f, 0.10943575f, 0.02499502f, -0.00388251f, 
    -0.03845719f, -0.01747096f, -0.04001090f, -0.16844192f, 0.03395818f, 0.39582273f, -0.04487022f, -0.16184913f, 
    0.05507126f, -0.00850138f, 0.11870500f, 0.00763868f, -0.06709287f, 0.02329400f, -0.07991958f, 0.14912722f, 
    0.00100465f, -0.21632133f, -0.09010223f, 0.00876507f, 0.04958334f, 0.11920333f, 0.00653511f, 0.15354030f, 
    -0.05972314f, 0.10861688f, 0.04866451f, -0.05928523f, -0.25110081f, 0.10392525f, 0.17669725f, -0.09395631f, 
    0.11251426f, 0.03468387f, 0.05554637f, -0.02107582f, -0.09462724f, -0.04290292f, 0.07918705f, -0.01900624f, 
    -0.18242101f, 0.19555111f, 0.24317913f, -0.04387656f, 0.03869881f, 0.07227105f, 0.15610032f, 0.09533381f, 
    0.06013677f, 0.08204596f, 0.21225128f, -0.08252081f, -0.10932785f, 0.00083300f, -0.04538381f, 0.03851773f, 
    0.03857779f, -0.05224053f, 0.14421441f, 0.03534470f, -0.03256369f, 0.01665725f, 0.04108758f, 0.11814994f, 
    -0.27130562f, -0.08157101f, -0.07574347f, 0.01693468f, -0.07269691f, 0.21286707f, 0.00804729f, -0.02897775f, 
    0.00562302f, -0.02387759f, 0.13689168f, -0.09097098f, -0.10712839f, 0.11916961f, -0.09649819f, -0.05249602f, 
    0.05933766f, -0.03053877f, 0.02095850f, 0.06272323f, 0.03758366f, -0.02584174f, 0.08219358f, -0.08919706f, 
    -0.00872386f, 0.05514780f, -0.21170682f, -0.01119682f, 0.03281652f, -0.17370147f, 0.03234977f, -0.07146202f, 
    -0.07074249f, 0.16859768f, 0.17494616f, -0.02881853f, -0.11232896f, -0.01167517f, -0.10872737f, 0.08749205f, 
    -0.03064784f, -0.01452620f, -0.17696650f, 0.09653418f, -0.05979881f, -0.06147725f, 0.08316329f, 0.12290437f, 
    0.17204645f, 0.01353378f, 0.01268841f, -0.05262741f, 0.19407651f, -0.01438287f, 0.06505601f, 0.10683911f, 
    -0.05689177f, -0.09308621f, -0.14670891f, 0.06795799f, 0.05037540f, -0.18539405f, -0.03983501f, -0.04788014f, 
    0.00746351f, 0.05170967f, 0.05434523f, 0.10867122f, 0.11727770f, 0.14848398f, 0.11572431f, 0.04433095f, 
    0.19845103f, 0.40901801f, -0.05933205f, -0.38778520f, 0.15095651f, 0.00834623f, 0.07057443f, 0.04386122f, 
    -0.02716291f, 0.06206293f, -0.09219201f, -0.00057546f, -0.09385532f, 0.05744409f, -0.17460336f, 0.04460455f, 
    0.06364623f, 0.03660981f, 0.00457555f, 0.06892337f, 0.03387115f, 0.13942847f, 0.09577283f, -0.09692767f, 
    -0.12417523f, -0.05281632f, 0.11486436f, -0.12679397f, -0.03892558f, 0.08665536f, 0.05285630f, -0.10210612f, 
    -0.01006150f, 0.09222087f, 0.07753795f, 0.26816344f, 0.08202739f, -0.01013581f, 0.00777121f, 0.08625638f, 
    -0.05198229f, 0.03058243f, 0.17060390f, 0.16454595f, -0.03151131f, -0.01361430f, 0.01501311f, -0.09496388f, 
    -0.15022932f, -0.02537419f, 0.03496523f, -0.00786662f, -0.03095028f, 0.02389619f, -0.03513126f, -0.01156231f, 
    -0.02289068f, 0.06367149f, -0.01194394f, -0.00328836f, 0.06731986f, -0.03839377f, -0.11293533f, 0.00149174f, 
    0.02856281f, -0.00678415f, 0.21114251f, 0.01647776f, 0.10463925f, -0.02534860f, 0.08939798f, 0.16116931f, 
    0.26293847f, -0.02925058f, -0.11009289f, 0.00016759f, 0.08133452f, 0.05476734f, -0.10749116f, 0.04639452f, 
    -0.07249537f, 0.05896938f, -0.00887772f, 0.13394178f, 0.28940469f, -0.39516854f, -0.09632069f, 0.06941934f, 
    -0.10226491f, 0.00899606f, 0.05232213f, -0.08528341f, -0.18293501f, 0.06163030f, 0.00971444f, -0.05984798f, 
    0.02279056f, 0.00835132f, 0.01559657f, -0.00439782f, -0.05758861f, -0.04486439f, -0.03075739f, 0.01621474f, 
    -0.03690372f, 0.02194249f, 0.01570619f, -0.01410084f, 0.00519853f, -0.02763178f, 0.03741715f, -0.04625006f, 
    -0.02898119f, -0.05250666f, -0.00770578f, 0.01358944f, -0.04687228f, -0.03729247f, -0.04788283f, -0.00726123f, 
    -0.00068838f, 0.02230884f, -0.03778904f, 0.00609330f, 0.03593901f, -0.00643378f, 0.03081561f, 0.00244244f, 
    -0.01744798f, 0.00440185f, -0.03118048f, -0.04667606f, -0.00336818f, 0.02928472f, -0.02974196f, -0.00995042f, 
    -0.03455028f, 0.01940465f, 0.04192369f, 0.00599531f, 0.02372787f, 0.02615550f, -0.05156284f, -0.04584752f, 
    -0.05462752f, -0.01692612f, 0.03941840f, 0.03979948f, 0.00781227f, 0.04142017f, 0.03625914f, 0.01107512f, 
    -0.03043292f, -0.05019233f, -0.05249660f, 0.01072434f, -0.04390864f, 0.03163719f, -0.01905226f, 0.01528699f, 
    0.03496627f, -0.00221714f, -0.03393443f, -0.04864781f, -0.00828893f, 0.00366316f, -0.02919551f, 0.01025159f, 
    -0.00030723f, 0.03610712f, 0.00031760f, -0.05463232f, -0.04029952f, -0.00614212f, -0.04309027f, -0.03154102f, 
    -0.02693765f, -0.05884897f, -0.03256120f, 0.02974510f, 0.01353283f, -0.03365436f, -0.01399242f, 0.01811372f, 
    -0.03528407f, 0.04070078f, 0.00415726f, 0.01058277f, -0.02233709f, 0.00918003f, 0.03410984f, -0.05138901f, 
    -0.02939443f, 0.01978221f, -0.01861749f, -0.02990738f, -0.01192087f, 0.00712045f, -0.04455241f, -0.02078609f, 
    -0.03388201f, 0.04141374f, 0.03069132f, 0.01583346f, -0.01142664f, 0.00874734f, -0.05631444f, 0.00446359f, 
    -0.04554198f, -0.04808505f, 0.03703680f, 0.02850508f, -0.03946966f, 0.01465320f, 0.02025331f, 0.01492631f, 
    -0.01050797f, 0.01587087f, -0.01281083f, -0.02420882f, 0.03267223f, 0.02271402f, -0.02088572f, 0.04386103f, 
    0.00946331f, -0.00960463f, 0.00638088f, 0.02601197f, -0.05008850f, 0.03222789f, 0.04018849f, -0.05458571f, 
    0.01382927f, 0.03131771f, 0.00779748f, -0.05301243f, 0.01955789f, 0.03324731f, 0.02774184f, 0.03603743f, 
    -0.03010085f, 0.01518608f, -0.00804185f, 0.01665591f, 0.01871238f, 0.00897200f, -0.03584514f, 0.04239374f, 
    0.02020048f, 0.01784021f, -0.03722186f, -0.02664692f, -0.04824808f, 0.02301573f, -0.00749190f, 0.01680789f, 
    -0.02114071f, -0.04899121f, 0.02836882f, -0.05313600f, 0.03692904f, -0.02117332f, -0.03350714f, -0.03800129f, 
    -0.03508819f, -0.05294670f, -0.05308728f, -0.01347285f, -0.00242668f, 0.00844979f, 0.00273879f, -0.03079369f, 
    0.04050567f, -0.04781881f, -0.04593169f, 0.04089827f, 0.02535260f, -0.03579971f, -0.01000774f, -0.04671358f, 
    -0.00032952f, -0.03939825f, -0.03948570f, -0.05675871f, -0.02167930f, -0.00760585f, -0.01701666f, -0.03766565f, 
    0.01228617f, 0.02658308f, 0.02850965f, -0.03780537f, -0.04063893f, 0.01017434f, 0.00975950f, 0.01552657f, 
    -0.05692599f, -0.02017134f, -0.04142155f, -0.02867177f, 0.00967474f, 0.00388643f, 0.00462068f, -0.03822460f, 
    -0.01775925f, -0.03786108f, 0.02669048f, 0.03184418f, -0.03030589f, 0.02366171f, 0.02666038f, -0.00240001f, 
    0.01091393f, 0.02176567f, -0.04635155f, -0.03265329f, -0.01898835f, -0.04758912f, -0.01381715f, -0.02671344f, 
    0.04498847f, 0.01151556f, 0.01475331f, 0.02905279f, -0.04109162f, -0.04162390f, 0.01939303f, 0.00821667f, 
    0.00650198f, -0.04923924f, 0.03609788f, -0.00931727f, -0.05401205f, 0.02547337f, -0.00569682f, 0.02028111f, 
    0.02400364f, 0.00636769f, 0.01996796f, 0.02396223f, -0.02579312f, 0.00873458f, 0.00375973f, -0.04741726f, 
    0.00443197f, -0.05199242f, 0.04037473f, 0.01911673f, -0.03258231f, 0.03369470f, -0.03014078f, 0.02829145f, 
    -0.03289310f, 0.01471278f, 0.04022098f, 0.04268457f, -0.02547042f, 0.01628072f, -0.01982801f, -0.04265480f, 
    0.02786267f, -0.02283927f, -0.01526092f, 0.03697687f, 0.01020061f, -0.04806111f, -0.02500069f, 0.02621402f, 
    0.01435014f, 0.03635926f, -0.05558754f, -0.04632312f, 0.03502119f, 0.01672039f, -0.03753972f, -0.04671928f, 
    0.00675035f, -0.03984507f, 0.03512618f, -0.03901702f, -0.02534570f, -0.04296206f, -0.01584439f, -0.04445571f, 
    -0.04007700f, 0.01310229f, -0.03099119f, 0.00574771f, -0.03362000f, 0.01040180f, 0.03942489f, -0.01438571f, 
    0.03405190f, 0.02265490f, -0.01039556f, -0.04833813f, 0.01502562f, -0.04918919f, -0.05049072f, -0.04035766f, 
    -0.05538973f, -0.03260553f, 0.04899762f, -0.03249907f, 0.04396838f, 0.03005436f, 0.03413622f, 0.01047484f, 
    0.02455759f, 0.03302198f, 0.01925641f, -0.04229904f, 0.00444551f, 0.01877068f, 0.02788861f, -0.02777993f, 
    0.04102230f, 0.01127984f, -0.03259001f, -0.01886493f, 0.02005167f, -0.03322584f, 0.02054569f, 0.02659911f, 
    -0.03094162f, 0.00393630f, -0.03756560f, -0.01614136f, 0.01257204f, 0.00585363f, -0.03596962f, -0.00959971f, 
    0.04633740f, -0.04074312f, 0.00116957f, -0.00418313f, 0.02321186f, -0.01168500f, 0.01631279f, 0.00893600f, 
    -0.05409207f, -0.00578545f, -0.03668030f, -0.05300754f, 0.02208223f, -0.00167199f, 0.04562371f, 0.03965205f, 
    0.00727208f, -0.01369787f, -0.02108936f, 0.02811894f, 0.00634397f, -0.03195285f, 0.03389989f, -0.02675814f, 
    -0.04710696f, -0.01931081f, 0.00579935f, -0.03945773f, 0.03569350f, -0.00613924f, -0.03032203f, 0.00281280f, 
    0.01596667f, 0.01111440f, -0.00954926f, -0.01432799f, 0.03659399f, 0.04498035f, -0.01627856f, -0.03665772f, 
    0.01388535f, -0.00076901f, -0.00162488f, -0.01971626f, 0.00918833f, -0.01201818f, 0.01828139f, 0.00277099f, 
    0.01310923f, -0.02400181f, 0.04465063f, -0.01438707f, -0.03045870f, 0.01218265f, -0.04390938f, -0.01806629f, 
    -0.03357138f, -0.04532720f, 0.00504954f, -0.00506639f, -0.00451633f, -0.00419534f, -0.03080551f, 0.00580076f, 
    -0.04638880f, -0.01728595f, 0.00919525f, 0.02580534f, -0.05159977f, 0.03518657f, 0.02292358f, 0.02439164f, 
    0.04342664f, 0.04331520f, -0.02282221f, 0.03577951f, 0.02335239f, -0.03336142f, 0.02389758f, -0.04216386f, 
    -0.02038900f, 0.00991612f, 0.03678181f, -0.02694351f, -0.05473349f, -0.03718565f, -0.04972884f, 0.01001513f, 
    0.00847889f, 0.03770543f, 0.00003426f, 0.01847447f, -0.03690839f, -0.01431785f, 0.02603646f, -0.05842147f, 
    -0.00527288f, -0.02617905f, -0.02453720f, -0.03695283f, 0.04479990f, -0.05057600f, 0.02730262f, -0.03006193f, 
    -0.04727883f, -0.01250255f, 0.00256048f, -0.00824947f, 0.01937712f, -0.05554537f, -0.04561025f, -0.03037942f, 
    0.00300089f, 0.04153039f, -0.00675602f, -0.00897878f, -0.02420829f, 0.02032226f, 0.01464928f, -0.00149125f, 
    0.03138484f, 0.00768101f, 0.02872919f, -0.00899619f, -0.04892229f, 0.02410199f, -0.02504562f, 0.02294676f, 
    0.01799097f, -0.02523858f, -0.02203337f, -0.03722528f, -0.03673020f, -0.02664628f, 0.01790823f, 0.03054232f, 
    0.03072933f, 0.01200869f, -0.00932461f, 0.03814627f, -0.00837239f, -0.04784169f, 0.02611310f, -0.01315421f, 
    0.02223556f, -0.02490826f, 0.04561268f, -0.04592469f, -0.04285010f, 0.02292866f, 0.00708348f, -0.05461730f, 
    0.01981517f, -0.00929155f, -0.03351341f, -0.00826574f, 0.03415268f, -0.00216806f, -0.04134549f, -0.00881736f, 
    -0.02554685f, 0.04189939f, 0.00712905f, 0.00534092f, 0.04174083f, -0.03620031f, 0.02082166f, 0.01874486f, 
    0.04228360f, 0.01156634f, -0.02184660f, 0.04441475f, 0.03327804f, 0.03286163f, -0.01999974f, 0.00995141f, 
    -0.03186814f, -0.04702992f, -0.03740629f, 0.02630299f, 0.03121960f, 0.00266431f, 0.05005510f, 0.03557174f, 
    -0.01441199f, 0.03853767f, -0.03338517f, -0.03006967f, 0.01472377f, 0.00635118f, 0.01825312f, 0.02173767f, 
    -0.04669822f, 0.01912042f, 0.03640959f, -0.04006495f, 0.01994212f, -0.04596628f, 0.00266113f, -0.02270765f, 
    -0.00787057f, 0.00029694f, 0.01772822f, 0.02964996f, 0.02567787f, 0.01675863f, 0.02641580f, -0.02272458f, 
    -0.02830568f, -0.03669591f, 0.02445137f, 0.02408258f, 0.02610452f, -0.04298366f, -0.03424075f, 0.03634032f, 
    0.00794255f, -0.00818152f, -0.01859022f, 0.01356016f, -0.04946281f, -0.04396887f, 0.04413362f, -0.04211272f, 
    0.03057849f, 0.01396887f, -0.00384650f, 0.02666198f, -0.06088439f, 0.01717922f, 0.00177482f, 0.02924910f, 
    0.03875126f, 0.00907534f, -0.00416310f, -0.00818576f, -0.02396105f, -0.04767420f, -0.01924801f, 0.04382232f, 
    0.00083059f, 0.03817407f, -0.00785752f, 0.02204069f, -0.00991561f, -0.00520185f, -0.01069858f, -0.03683706f, 
    -0.05911943f, -0.03567906f, -0.04852004f, 0.01084587f, -0.00659611f, 0.04776657f, -0.04047649f, 0.03774894f, 
    -0.04818984f, -0.00525512f, -0.02263183f, -0.03450800f, 0.01947070f, -0.01672724f, 0.00471340f, -0.03705987f, 
    -0.03422642f, 0.02045991f, -0.01294319f, -0.04124119f, 0.01749864f, 0.00445353f, 0.04427007f, -0.00209933f, 
    -0.04041445f, -0.00962191f, -0.04987611f, -0.02025662f, 0.02849277f, -0.03134705f, -0.03120803f, -0.00592996f, 
    -0.05444946f, -0.03470324f, 0.00410917f, -0.05781424f, -0.04867099f, 0.00787142f, 0.02308610f, -0.03671874f, 
    0.04213560f, 0.04533179f, -0.03584933f, 0.02859149f, -0.01895806f, 0.02232695f, -0.05022262f, -0.00959504f, 
    0.00154836f, 0.02901628f, 0.01778694f, 0.00802137f, 0.04196429f, 0.00437871f, -0.03360985f, -0.04291184f, 
    -0.03682207f, 0.03251080f, -0.01017374f, -0.03927740f, 0.02858522f, 0.04071907f, -0.02066287f, -0.05403716f, 
    -0.04165922f, 0.02874038f, 0.00030893f, -0.05113804f, 0.00767063f, 0.03969780f, 0.02593569f, 0.01677281f, 
    0.03961095f, -0.04250528f, 0.02885820f, 0.02290436f, 0.02863134f, -0.00962459f, 0.00901039f, 0.01588335f, 
    -0.02258701f, 0.04421909f, 0.01032507f, -0.05455574f, -0.02047753f, -0.03399435f, -0.05681825f, -0.03177815f, 
    -0.04505375f, -0.01856845f, -0.04304688f, -0.02689007f, 0.03467974f, -0.01917906f, 0.01858062f, 0.01654836f, 
    0.03058548f, -0.00251836f, -0.03891067f, -0.01697771f, 0.01583621f, -0.04814307f, 0.02132592f, 0.01458467f, 
    -0.02715919f, 0.01024524f, -0.00526536f, -0.05954484f, 0.01043780f, -0.02643723f, -0.04494221f, 0.01500588f, 
    0.02279828f, -0.04628689f, -0.00189084f, 0.02272361f, 0.05010004f, 0.04528785f, 0.01827037f, 0.00250028f, 
    -0.04445680f, 0.03047589f, 0.00094223f, 0.00969304f, -0.03100493f, -0.04049468f, -0.01147025f, 0.03487039f, 
    -0.03863055f, -0.00446463f, -0.04600693f, -0.00356332f, -0.00271041f, 0.04635577f, -0.03973537f, 0.00184038f, 
    0.03853937f, -0.04726711f, -0.02168731f, -0.00021441f, 0.02280370f, -0.03936115f, -0.01220170f, -0.02290889f, 
    -0.01522451f, 0.00381459f, -0.00913868f, -0.05414288f, -0.03313729f, 0.02441180f, 0.00360851f, -0.01767457f, 
    -0.00979902f, -0.04172619f, 0.00016952f, -0.02476060f, -0.02269213f, -0.02651271f, -0.04806711f, -0.01102082f, 
    0.01508728f, -0.00489189f, -0.01394016f, 0.01754642f, -0.00065993f, 0.03066365f, 0.02487097f, 0.03684219f, 
    -0.02200683f, 0.02017375f, -0.04079289f, 0.02799030f, -0.04368193f, -0.03079717f, 0.04684829f, 0.00296329f, 
    -0.02543894f, 0.00954708f, 0.00235516f, 0.00619353f, 0.00852015f, -0.00049382f, 0.04665062f, -0.03189777f, 
    -0.04232920f, -0.05611456f, 0.00785832f, -0.00804889f, 0.03967392f, -0.02688262f, 0.02050604f, -0.01633741f, 
    0.02166015f, -0.01931117f, 0.00285501f, -0.03698691f, 0.02604626f, -0.00096511f, -0.03581342f, -0.03935962f, 
    0.00762441f, -0.01909228f, 0.04510391f, 0.00641499f, 0.04262653f, -0.00448940f, -0.03321479f, 0.03199373f, 
    0.02374347f, -0.03198184f, -0.04853871f, 0.01492983f, -0.01716463f, 0.00954655f, -0.03232990f, -0.03735378f, 
    -0.02636611f, 0.02417225f, -0.02928681f, 0.01258188f, 0.01698485f, 0.03690061f, -0.01797259f, 0.00920886f, 
    -0.01303416f, -0.03120185f, 0.00037459f, -0.00749591f, 0.04259684f, -0.01492697f, -0.01006922f, -0.05106339f, 
    0.00598208f, -0.03886848f, -0.00732451f, 0.03507636f, -0.01045043f, -0.01414425f, -0.04799661f, -0.00848460f, 
    -0.02892615f, 0.02374282f, -0.00913443f, -0.01959334f, -0.01357995f, -0.05083724f, -0.04776472f, -0.02057364f, 
    0.02983637f, 0.02342079f, -0.04194226f, -0.01189714f, 0.01200601f, -0.01930133f, 0.02126749f, 0.02571179f, 
    0.01915355f, -0.01828436f, 0.00797613f, -0.05081692f, 0.01658432f, 0.01822584f, -0.04153158f, -0.04303805f, 
    0.01752819f, 0.02345280f, 0.03255877f, 0.01122562f, 0.03964258f, 0.02215615f, 0.03692264f, 0.01941023f, 
    0.00580103f, 0.00132454f, 0.00288753f, 0.01018663f, -0.01400106f, 0.01786019f, -0.04068185f, 0.03819499f, 
    -0.03202285f, -0.03308875f, -0.00895401f, 0.01764591f, 0.00272708f, -0.01487444f, -0.02103258f, 0.00513751f, 
    -0.05140807f, -0.02604728f, -0.04199455f, 0.02114621f, 0.02394497f, -0.01597414f, -0.05185620f, 0.02153061f, 
    0.00544710f, -0.00773345f, -0.02829900f, -0.03601038f, 0.00437878f, -0.04401255f, -0.05502988f, 0.04021060f, 
    0.02783322f, 0.00187536f, -0.00861604f, -0.03772864f, -0.03474260f, 0.00417690f, 0.00873150f, 0.04006255f, 
    0.04286430f, -0.05391901f, -0.04332545f, 0.02686213f, 0.00300955f, 0.00458775f, 0.00003684f, 0.02786960f, 
    0.00744987f, 0.00256654f, 0.01331913f, -0.04441660f, -0.01974371f, -0.00430248f, -0.03415918f, 0.03887846f, 
    0.01420915f, -0.02352605f, 0.01063601f, -0.05473277f, 0.01652495f, -0.03617440f, 0.03784676f, -0.04587001f, 
    -0.05179894f, -0.02133552f, 0.01469292f, -0.00572317f, 0.01436250f, -0.05585556f, -0.02642513f, -0.00526063f, 
    -0.00918799f, -0.04807927f, -0.00573639f, -0.03505617f, -0.00613158f, 0.01000360f, -0.03422198f, 0.00996923f, 
    0.00929350f, 0.04263084f, -0.01135071f, 0.01520704f, -0.05535118f, -0.03715488f, -0.01285436f, 0.03245424f, 
    -0.00177331f, 0.03909091f, -0.03806041f, -0.02222332f, 0.03745344f, 0.00144950f, 0.01123796f, -0.05178469f, 
    -0.03066164f, 0.01393861f, 0.03701673f, -0.00667527f, 0.04113008f, 0.02202966f, -0.01150699f, -0.04889829f, 
    -0.03429767f, -0.05364867f, 0.03618059f, -0.01969965f, -0.01219596f, 0.03250958f, -0.04400834f, -0.00496718f, 
    -0.03950766f, -0.00112538f, 0.00109987f, 0.04199002f, 0.04478194f, 0.00011026f, 0.02687790f, 0.01944182f, 
    -0.02451736f, -0.04506805f, 0.02802787f, -0.03972026f, -0.03647130f, -0.00639866f, 0.04381811f, 0.01623388f, 
    -0.00434569f, -0.04792268f, 0.04525911f, -0.00355179f, -0.00168341f, -0.02050596f, -0.03054180f, 0.03178550f, 
    -0.04057638f, -0.04941452f, -0.00261263f, 0.00863188f, -0.01398452f, -0.05291113f, -0.00114512f, 0.03592821f, 
    -0.00754043f, -0.01250605f, -0.00755588f, -0.02137843f, 0.00849845f, -0.03466871f, -0.05165793f, 0.03758351f, 
    -0.04273784f, -0.02277225f, 0.04007865f, -0.02032163f, 0.01645751f, -0.03287359f, -0.03028526f, -0.01203602f, 
    -0.03276742f, -0.04390040f, -0.01412230f, -0.01537790f, -0.02774213f, 0.04320043f, 0.03882525f, 0.04261700f, 
    -0.03551451f, 0.03123047f, 0.00962941f, -0.02061705f, -0.01042055f, 0.02482031f, 0.01042768f, 0.01591317f, 
    -0.01390967f, 0.00915451f, -0.03914151f, 0.01973227f, 0.03676942f, -0.03486054f, 0.00343802f, 0.03059859f, 
    -0.02678878f, 0.02051171f, 0.00262184f, -0.02415513f, 0.00589939f, -0.05416661f, -0.04050069f, -0.02010412f, 
    0.04089325f, 0.02778460f, -0.02945251f, -0.01967233f, 0.04347945f, 0.03416967f, -0.05298156f, -0.05178183f, 
    0.00730234f, -0.01792747f, -0.02422543f, 0.00929026f, 0.04097226f, -0.02888147f, 0.03804442f, 0.00827951f, 
    -0.00970032f, 0.00808113f, -0.02192879f, -0.02456847f, 0.01098936f, -0.02390460f, -0.00965157f, -0.05209249f, 
    -0.05058884f, 0.04141692f, -0.05539697f, 0.04506849f, 0.01130034f, 0.02046845f, -0.01950105f, -0.00138295f, 
    -0.03604669f, -0.04865250f, -0.01548502f, -0.04008270f, 0.03836089f, 0.01581599f, -0.04763805f, -0.01524748f, 
    -0.04887148f, -0.00425045f, 0.03226479f, 0.00879021f, 0.03891729f, -0.05282851f, 0.00122949f, -0.05649858f, 
    0.00231522f, 0.02229160f, 0.04107055f, -0.05578763f, 0.03218454f, -0.05248312f, 0.03277082f, -0.01678733f, 
    -0.02650474f, -0.02576920f, -0.02810699f, -0.04144706f, -0.04452304f, -0.03486412f, -0.02645770f, -0.04549127f, 
    0.01373036f, -0.03123837f, -0.04050053f, -0.01385001f, 0.01896241f, 0.01360539f, -0.04490883f, 0.01414134f, 
    -0.00693933f, 0.01789704f, -0.03980532f, 0.02306187f, -0.01485409f, -0.05258042f, -0.04439902f, 0.00841649f, 
    0.00677478f, 0.03175430f, -0.03200034f, -0.03338844f, 0.03886178f, 0.00996579f, -0.02706032f, 0.01420269f, 
    -0.02029494f, 0.01730109f, -0.04645159f, -0.04843806f, -0.00471247f, 0.02519552f, -0.03076392f, -0.03638975f, 
    -0.00058762f, -0.04067283f, -0.01682735f, -0.02076959f, 0.02281843f, -0.01530801f, -0.05367502f, 0.00740549f, 
    -0.09372856f, -0.23123175f, -0.03766589f, 0.16181836f, -0.01749953f, 0.09575531f, 0.09813476f, -0.00838758f, 
    -0.01244069f, -0.01984723f, 0.08825133f, 0.03031027f, -0.14071596f, -0.04063214f, -0.01133243f, 0.06273965f, 
    -0.02460204f, 0.02052256f, -0.03641015f, -0.00726868f, -0.15684216f, 0.01328538f, -0.01206836f, 0.01943908f, 
    -0.20999689f, 0.06913775f, 0.04813274f, 0.18428008f, 0.09790320f, 0.03789905f, -0.08124990f, -0.02416431f, 
    0.07764079f, -0.11214328f, 0.00003369f, -0.01512475f, -0.15260617f, -0.03543978f, 0.25609580f, -0.05418780f, 
    -0.15329494f, -0.06449809f, -0.05281484f, -0.06179964f, -0.02522123f, -0.02231323f, 0.09190738f, 0.04327008f, 
    -0.05403543f, 0.00154498f, 0.15889892f, 0.06030284f, -0.00509431f, 0.04953197f, 0.06052979f, 0.00970881f, 
    -0.02690272f, -0.19323856f, 0.01469790f, -0.04845117f, -0.19241409f, -0.06240427f, -0.04373289f, 0.03215194f, 
    0.18781428f, -0.03409867f, -0.07237428f, -0.10156522f, 0.00092394f, 0.02910986f, 0.01476548f, -0.13817248f, 
    -0.38809651f, 0.17717838f, -0.13822719f, 0.02088023f, 0.05996063f, 0.20524359f, 0.01102501f, 0.09721726f, 
    0.10458835f, 0.01564983f, -0.10979819f, 0.13707437f, 0.14194301f, 0.18864313f, -0.08737235f, -0.07605144f, 
    -0.13559589f, 0.07547035f, 0.07151494f, -0.14823155f, -0.06697519f, 0.02261584f, 0.02310904f, 0.00855491f, 
    -0.32961741f, 0.04566794f, 0.13022979f, -0.01575670f, 0.07339851f, -0.09681966f, -0.04173373f, -0.06940208f, 
    -0.03741563f, -0.02583996f, -0.00300207f, -0.07599615f, 0.01599886f, -0.24969946f, 0.12815611f, 0.09632716f, 
    0.13785951f, -0.01165187f, -0.10835135f, -0.03412664f, 0.03540543f, 0.07792794f, 0.05121956f, 0.05023319f, 
    0.29016200f, -0.15576416f, 0.03212619f, 0.09562837f, 0.01849787f, 0.03507017f, -0.02502554f, 0.06768215f, 
    -0.04070342f, -0.10369058f, 0.01858102f, -0.02861269f, 0.03615956f, 0.11377091f, 0.11624190f, -0.19144104f, 
    0.01930631f, -0.01740097f, 0.15516627f, 0.10955571f, 0.11853232f, 0.03651096f, 0.03815253f, 0.02319452f, 
    -0.00765511f, -0.12721927f, -0.05469623f, -0.02663347f, -0.06840200f, 0.06155659f, 0.02433534f, -0.07256899f, 
    0.01029221f, 0.07714162f, 0.00395528f, -0.02701930f, 0.30535397f, -0.18444219f, -0.07764342f, 0.21851790f, 
    -0.07286650f, -0.06950431f, 0.12511146f, -0.03702654f, 0.09422314f, -0.03761407f, -0.07758894f, 0.01468348f, 
    0.05115296f, 0.08279843f, -0.01072552f, -0.00213191f, 0.04568945f, 0.09338371f, -0.01389191f, -0.09911172f, 
    0.02790517f, 0.07409153f, 0.09845815f, -0.08484686f, -0.08590920f, -0.00792024f, -0.02802489f, 0.05771859f, 
    0.03982099f, -0.04892467f, -0.17234944f, -0.03321713f, 0.04364709f, 0.08113391f, -0.05784670f, 0.02434649f, 
    0.31966409f, -0.10800048f, 0.04772211f, -0.07917466f, -0.19438104f, -0.04454042f, 0.00037665f, 0.00611281f, 
    0.02200784f, -0.03608141f, -0.14403905f, -0.05729381f, 0.09922030f, 0.11805684f, -0.06982978f, 0.12028508f, 
    -0.07751312f, 0.03599499f, -0.12377506f, 0.06642397f, -0.06271268f, -0.15377831f, 0.03306866f, 0.05374264f, 
    -0.09080508f, 0.05635056f, 0.18513632f, 0.35648960f, 0.00942311f, -0.04574706f, 0.13024065f, 0.06773285f, 
    0.03719179f, 0.11428531f, -0.00054803f, 0.06154095f, 0.11675444f, 0.27461359f, -0.18642733f, 0.05075255f, 
    -0.02157759f, 0.00037602f, -0.01809837f, -0.08643100f, -0.14447562f, -0.07705856f, -0.01523152f, -0.06998319f, 
    0.13485743f, 0.01242089f, -0.02951812f, 0.15335324f, 0.05140172f, 0.06317068f, 0.07031602f, -0.03852960f, 
    0.05408772f, 0.01283395f, -0.05702809f, -0.00762059f, -0.04305902f, -0.00196060f, 0.09331458f, -0.00297890f, 
    0.01828960f, -0.01246007f, 0.04029597f, 0.20738301f, 0.02314922f, 0.11484770f, -0.08696175f, 0.06248686f, 
    0.14985652f, 0.19780740f, -0.21430473f, 0.02550888f, 0.01783966f, -0.00200385f, 0.11324082f, -0.03109029f, 
    0.15921037f, 0.06894416f, 0.02963315f, 0.14795059f, -0.32471126f, 0.23173948f, -0.16487211f, 0.08716139f, 
    0.11036207f, 0.06546126f, 0.06811053f, -0.04594215f, -0.07779206f, -0.02970655f, 0.03782603f, -0.09889222f, 
    -0.23728874f, 0.07221203f, 0.12724178f, 0.13653579f, -0.09595862f, 0.06574998f, 0.05888790f, 0.04672529f, 
    -0.05318987f, -0.11198921f, -0.06193377f, -0.02038942f, 0.40568399f, 0.07842763f, -0.21053195f, 0.29645303f, 
    0.03368685f, 0.05395147f, -0.09233934f, -0.02156406f, -0.13155845f, -0.09241629f, 0.01315892f, 0.01775118f, 
    0.07017349f, -0.04307181f, 0.17926697f, 0.00324035f, -0.08340315f, -0.12791879f, 0.02601167f, 0.07026293f, 
    -0.00913545f, -0.04042838f, -0.02187413f, -0.03070637f, 0.03178729f, -0.00645095f, -0.15763512f, -0.13878506f, 
    0.02973668f, 0.09377839f, -0.07098391f, 0.03905423f, 0.19207723f, -0.08302459f, 0.04830693f, 0.06170176f, 
    0.06685100f, -0.09474407f, 0.13716368f, 0.29929131f, -0.02511148f, -0.09743613f, 0.06762359f, -0.01763226f, 
    0.07097533f, 0.09803986f, -0.03417720f, 0.02522226f, 0.35924691f, -0.07426560f, -0.13619597f, 0.06254194f, 
    -0.05600641f, 0.10819165f, -0.05002505f, 0.00732479f, -0.03975313f, 0.12651467f, 0.01358121f, 0.00098374f, 
    -0.25044659f, -0.13871711f, 0.06685475f, 0.00901324f, 0.14935593f, -0.04403596f, -0.00775277f, 0.08152184f, 
    -0.02944888f, 0.02008268f, 0.15594453f, 0.03364043f, 0.09675611f, -0.05466417f, 0.16354442f, -0.02048488f, 
    -0.01515721f, -0.04620851f, 0.05063154f, 0.26219776f, 0.03689111f, -0.00234120f, 0.02683406f, 0.20617455f, 
    -0.05353727f, -0.03515909f, -0.05567727f, 0.00461750f, -0.06064757f, 0.00219065f, 0.01422960f, 0.00184376f, 
    -0.00682876f, -0.00859259f, 0.01908484f, 0.02036580f, -0.02155580f, 0.00007421f, -0.04832123f, -0.05033556f, 
    0.03615896f, -0.01613481f, -0.02485546f, 0.03552576f, 0.02615697f, -0.04466520f, -0.00253892f, -0.01780614f, 
    0.00341184f, -0.04213763f, -0.03720247f, -0.01696231f, 0.02400562f, -0.04313301f, 0.02957367f, -0.04727264f, 
    0.04194153f, 0.01930518f, -0.02523251f, 0.03963744f, -0.02840930f, 0.01895833f, 0.01760221f, 0.03614601f, 
    0.04856821f, -0.00079666f, -0.00739157f, 0.00092768f, -0.01693869f, 0.03658687f, -0.02502775f, -0.01262361f, 
    0.01932376f, -0.01057962f, 0.01885745f, -0.03811391f, 0.04028533f, 0.03198843f, -0.01529390f, -0.05523948f, 
    0.01567003f, 0.01247745f, -0.00570502f, -0.01947083f, -0.04338935f, -0.05096887f, 0.01401842f, -0.01700518f, 
    0.03427074f, -0.04397799f, 0.00400926f, 0.03678568f, 0.02103421f, 0.01898552f, -0.01585461f, -0.00719430f, 
    -0.00598197f, -0.03883843f, -0.05587180f, -0.04819283f, 0.01422592f, -0.04678634f, -0.02262365f, -0.02024913f, 
    -0.01390193f, -0.02519930f, 0.04142946f, 0.03828590f, 0.01174804f, 0.00421370f, 0.03454605f, -0.01641419f, 
    0.02009367f, -0.02298976f, -0.02949773f, 0.02802464f, -0.03436910f, -0.02890673f, -0.00512287f, -0.01453792f, 
    0.02090043f, -0.03153374f, 0.00412523f, 0.02744903f, -0.01745727f, 0.01084546f, -0.01681746f, -0.04287766f, 
    0.00597209f, -0.03502548f, -0.03839350f, -0.00071028f, 0.03440571f, 0.03436112f, -0.03370541f, 0.03018709f, 
    -0.02318120f, -0.02909626f, 0.02555501f, -0.00300641f, -0.03620180f, 0.00620560f, 0.02826653f, -0.03696313f, 
    0.00039116f, 0.01025700f, 0.03914472f, -0.05757251f, -0.03933864f, -0.02400063f, 0.03663373f, -0.04093312f, 
    0.02973906f, -0.05253766f, 0.00811731f, 0.00102643f, -0.04604270f, -0.01529205f, -0.01951940f, -0.00567933f, 
    -0.00899698f, -0.03997223f, -0.02914272f, -0.04258495f, -0.05161515f, 0.01557928f, -0.03024914f, 0.02980054f, 
    -0.01769269f, -0.01653012f, 0.01559191f, -0.04743993f, 0.03430231f, 0.02534543f, 0.01684483f, 0.02283312f, 
    -0.01039926f, -0.00685804f, -0.03839749f, -0.00083604f, -0.02134065f, -0.04172305f, 0.01894666f, 0.03280814f, 
    -0.03454266f, 0.03609783f, -0.02960074f, 0.02305251f, -0.05350274f, 0.03317321f, 0.00050098f, -0.03437657f, 
    0.02533014f, 0.04222319f, -0.00026510f, 0.01781086f, -0.00866521f, 0.02550384f, -0.04298644f, -0.03819492f, 
    0.03046833f, 0.01389715f, -0.04939096f, -0.02669097f, -0.04796185f, 0.04257417f, 0.00449424f, -0.03829279f, 
    0.04038357f, 0.02330497f, -0.00763321f, 0.05243427f, -0.02132356f, 0.04047653f, 0.00703047f, -0.03501102f, 
    -0.04865148f, 0.03837729f, 0.02482735f, -0.05081750f, -0.00020633f, 0.00166989f, -0.00051933f, 0.00882270f, 
    0.01641298f, 0.01179173f, -0.02335593f, -0.00090416f, 0.00783445f, -0.04299554f, 0.00394336f, 0.02450095f, 
    0.00811082f, -0.02987062f, -0.00209897f, 0.00797987f, -0.00122405f, 0.03203292f, -0.01258294f, -0.04753616f, 
    -0.03889136f, 0.01712033f, 0.02072240f, -0.04583490f, 0.01070437f, -0.05012875f, -0.04463707f, -0.04548849f, 
    -0.04805917f, -0.05041740f, -0.01552986f, -0.02280842f, 0.04541705f, -0.04912796f, 0.01712624f, 0.00854427f, 
    -0.03806273f, -0.01737232f, -0.00382926f, -0.03554931f, -0.03789259f, 0.03297390f, 0.04290045f, 0.02563793f, 
    0.02920813f, -0.02637148f, 0.03002113f, -0.02869044f, 0.04548037f, 0.04303398f, -0.02266633f, -0.00977850f, 
    -0.01228486f, 0.02867039f, -0.03493809f, -0.04578637f, 0.03771714f, -0.02716308f, -0.03481589f, -0.05526603f, 
    -0.04260407f, 0.02115200f, -0.02509221f, 0.00294894f, 0.02931601f, 0.00682463f, 0.03757093f, 0.01228725f, 
    0.02348589f, -0.04480341f, 0.01525329f, -0.00237295f, -0.03191565f, -0.03758631f, -0.00923080f, -0.00207043f, 
    -0.01128077f, -0.02273860f, -0.01470405f, 0.01656698f, 0.04632843f, -0.03481115f, -0.00424942f, 0.03935757f, 
    -0.02733613f, 0.01919444f, -0.03465724f, -0.01289471f, 0.03041286f, -0.03906427f, 0.02084632f, -0.01416940f, 
    0.03980104f, 0.01327143f, 0.03426642f, 0.04306838f, 0.01167333f, -0.04950707f, 0.03547115f, -0.01472449f, 
    0.03385250f, -0.04544940f, -0.02704473f, -0.02035267f, -0.03024915f, -0.02490713f, -0.02591684f, -0.05182274f, 
    -0.06294430f, -0.03433602f, -0.03258801f, 0.02512599f, 0.05476896f, 0.02341523f, 0.00678866f, 0.02467505f, 
    -0.04171191f, 0.00169527f, -0.04495281f, 0.01516025f, -0.02492125f, 0.03491530f, 0.02538916f, -0.00553207f, 
    -0.00076119f, 0.01652810f, -0.01161653f, 0.01056534f, -0.04669007f, -0.05108177f, -0.01772034f, -0.05626991f, 
    0.02034590f, 0.02730328f, 0.03652716f, -0.00210335f, -0.04731376f, -0.01866788f, 0.02437331f, -0.02921360f, 
    -0.05570663f, 0.00478081f, 0.02673178f, -0.02527551f, 0.03305013f, 0.03884047f, 0.03149003f, -0.02558458f, 
    0.03054570f, 0.00518882f, 0.02201622f, -0.04629631f, 0.00156260f, -0.00255748f, 0.02873610f, -0.01279559f, 
    0.00011014f, 0.01691765f, -0.00773941f, 0.01177010f, 0.00948597f, 0.04073459f, 0.02151171f, 0.02548933f, 
    -0.05061455f, 0.04417555f, -0.01459109f, 0.02101863f, 0.00682724f, -0.01032099f, -0.02265938f, 0.02217532f, 
    0.01615144f, -0.03851950f, -0.03965642f, -0.02715525f, -0.02944967f, -0.00428194f, -0.04704789f, -0.05436844f, 
    0.01428132f, -0.03526907f, 0.02548594f, 0.04381392f, 0.04167839f, -0.06108185f, -0.02755737f, 0.02166937f, 
    0.23880185f, -0.01293400f, -0.01853222f, -0.07402275f, -0.02753921f, -0.02594636f, -0.02614522f, 0.00855083f, 
    0.09218995f, 0.10800071f, -0.03834997f, 0.14582869f, 0.25161922f, 0.00450750f, -0.03337217f, 0.03458392f, 
    0.09945900f, 0.09045961f, 0.03491073f, 0.03108022f, 0.10595235f, 0.05276375f, 0.14625652f, 0.00078698f, 
    -0.16494322f, 0.11589002f, -0.19332795f, -0.01199878f, 0.03070715f, 0.01399381f, 0.09686527f, 0.02145606f, 
    0.10609128f, 0.03244339f, 0.16277887f, 0.10654489f, 0.35351849f, 0.07298853f, -0.05720386f, 0.20757419f, 
    0.08713930f, 0.00178891f, 0.16200253f, 0.08334526f, -0.01643734f, 0.04600779f, -0.09071125f, -0.00051233f, 
    -0.03929550f, -0.14380197f, -0.02524280f, 0.11580264f, -0.07206930f, -0.01487252f, 0.08766797f, 0.08010162f, 
    0.00912915f, 0.09315192f, 0.04077584f, 0.16377704f, 0.16616230f, 0.03877246f, -0.13297717f, -0.12327508f, 
    -0.05553723f, 0.16466787f, -0.01228227f, 0.03114352f, 0.05619040f, -0.08392072f, 0.01532845f, -0.01927607f, 
    0.06439310f, 0.06741422f, -0.02706859f, 0.02866823f, -0.03693059f, -0.08463832f, -0.04997104f, 0.02516915f, 
    0.00015338f, 0.02282869f, 0.06402761f, 0.04089067f, -0.28175971f, -0.03478195f, 0.11631674f, 0.29701066f, 
    -0.02768422f, -0.08381770f, 0.05967055f, 0.13288394f, 0.09540472f, 0.09572447f, 0.08443256f, 0.06766146f, 
    -0.05937342f, 0.23545195f, -0.06182081f, 0.07194733f, 0.07490094f, 0.01706416f, -0.02092652f, 0.03698894f, 
    -0.01171560f, 0.02240297f, 0.03841587f, 0.20952347f, 0.31867468f, -0.07464653f, -0.14232136f, -0.26618391f, 
    0.08536237f, 0.04693425f, -0.09381240f, -0.07956001f, 0.01207843f, -0.03171220f, -0.06619715f, -0.04815396f, 
    -0.17561853f, 0.00557338f, -0.12655836f, -0.20546828f, 0.01650914f, 0.02234587f, 0.02359510f, -0.00204736f, 
    -0.06040327f, 0.00822577f, -0.06716675f, 0.06497095f, -0.47148004f, 0.12423426f, 0.02986057f, -0.12496879f, 
    0.02823496f, 0.03756391f, -0.00434484f, 0.11764978f, 0.05125981f, 0.02816281f, -0.01384340f, -0.00932318f, 
    -0.22225583f, 0.38069591f, -0.12366369f, 0.16988496f, -0.07643559f, -0.07714257f, 0.02637107f, 0.09958465f, 
    0.04360636f, 0.05918163f, 0.04689827f, 0.04562547f, 0.07512254f, -0.04255866f, 0.11337169f, -0.02322533f, 
    -0.00634015f, -0.00162227f, -0.15597244f, 0.03127047f, 0.07265510f, -0.00791646f, 0.04561047f, 0.03371257f, 
    0.02334927f, 0.23383786f, -0.13070941f, -0.22677177f, 0.05233971f, -0.02467687f, -0.06329483f, 0.11106183f, 
    0.03684392f, -0.11131275f, -0.15215319f, 0.07500501f, 0.25225613f, -0.15242279f, -0.29065999f, -0.09365708f, 
    0.01176334f, -0.00426004f, 0.08683153f, -0.00260597f, 0.13755773f, 0.01059959f, 0.03494384f, 0.05304896f, 
    0.07498983f, 0.03693063f, -0.02607604f, 0.00797273f, 0.03953201f, -0.03061367f, 0.03461998f, 0.01604177f, 
    0.04148990f, 0.02044391f, 0.13931829f, 0.06973062f, 0.15409158f, -0.18859814f, 0.16289432f, 0.05329272f, 
    -0.02110208f, 0.02061749f, 0.11588398f, -0.02988614f, 0.16071597f, -0.03365501f, -0.04852745f, -0.07814490f, 
    0.02954546f, -0.01294845f, -0.05328793f, -0.00948615f, -0.05036106f, -0.03365138f, 0.04027544f, 0.00894207f, 
    -0.06079246f, -0.00269612f, 0.08783007f, 0.03260204f, 0.13329343f, -0.24940869f, 0.11360364f, 0.05874449f, 
    0.00523063f, 0.11858727f, -0.00886961f, 0.02869971f, -0.01388184f, 0.11517891f, 0.01820847f, 0.09067307f, 
    -0.20620424f, -0.11247989f, 0.02169192f, 0.03211766f, 0.02236005f, 0.04540070f, -0.00942658f, 0.07900000f, 
    0.15543444f, -0.00592366f, -0.06428850f, -0.02838122f, -0.36993429f, -0.10743664f, 0.06370439f, 0.05544133f, 
    -0.12969553f, 0.04553937f, 0.05104234f, -0.04219931f, 0.11965413f, -0.00391010f, 0.00511557f, 0.02543392f, 
    -0.14558960f, -0.08489203f, 0.07844134f, 0.21484935f, -0.03956532f, 0.08083627f, -0.03772330f, 0.00743446f, 
    0.02979796f, 0.02730730f, 0.02926599f, -0.01845736f, 0.27188095f, -0.07216389f, -0.05965963f, -0.07414876f, 
    0.01015762f, -0.02484813f, -0.03575658f, 0.00054649f, -0.04825164f, 0.04941150f, -0.02276359f, 0.08973518f, 
    0.26707476f, -0.22695328f, 0.14382450f, 0.25645092f, -0.14869989f, 0.03345258f, 0.05275079f, 0.06263632f, 
    0.01431997f, 0.14353192f, 0.09507935f, 0.12090150f, -0.19734761f, 0.02474986f, 0.04156268f, -0.21605395f, 
    -0.00351395f, 0.12311549f, 0.14095928f, -0.02133907f, 0.04375116f, -0.02946159f, -0.08356059f, -0.03892227f, 
    0.02064525f, 0.19396730f, -0.01479711f, 0.11756714f, 0.02680547f, 0.00618092f, 0.02492946f, 0.17990704f, 
    -0.09210914f, 0.01119634f, 0.02085569f, -0.05933110f, 0.10806662f, -0.09777074f, -0.15736076f, -0.15114681f, 
    0.03908179f, 0.00866407f, -0.04311396f, -0.14163071f, 0.00765586f, 0.19233049f, -0.11438185f, 0.07565664f, 
    0.13954836f, -0.00203710f, 0.06903783f, -0.00584488f, 0.00629494f, 0.05894290f, 0.17185903f, -0.00081218f, 
    0.01316120f, -0.02222805f, 0.10271648f, 0.09216626f, 0.10803521f, 0.07351507f, 0.38138285f, -0.35720047f, 
    0.03427914f, -0.04664863f, -0.14814383f, 0.06467395f, 0.00899298f, -0.06465675f, -0.09695757f, 0.00043205f, 
    0.16271932f, 0.13907358f, -0.09595272f, -0.30781657f, -0.01333445f, 0.14522453f, -0.00880256f, 0.02081921f, 
    0.13309260f, -0.04183873f, -0.00067729f, -0.00615806f, 0.00586887f, 0.03450797f, 0.01158976f, -0.15543267f, 
    -0.02084698f, -0.02599953f, -0.03305084f, 0.02375099f, 0.03346936f, -0.00217293f, 0.04878436f, -0.05810405f, 
    0.08530559f, 0.15478539f, 0.05323787f, -0.32159379f, 0.05010828f, 0.03632783f, -0.09837464f, 0.00529035f, 
    0.13367034f, 0.04904471f, -0.01419340f, 0.11577228f, 0.32115662f, 0.10295502f, -0.01101145f, 0.28309748f, 
    0.05587435f, 0.00979753f, 0.11101700f, -0.08081910f, 0.06267383f, 0.08490402f, -0.00821538f, 0.09604865f, 
    0.10812645f, 0.35776418f, -0.08701301f, -0.08216844f, 0.11846117f, 0.04436845f, -0.03364651f, 0.09237278f, 
    0.06523953f, 0.10176069f, 0.09744794f, -0.01395722f, 0.33777609f, -0.04193306f, -0.15204065f, 0.03761051f, 
    0.08350436f, 0.11022615f, 0.13110693f, 0.08924692f, -0.06729096f, 0.02930204f, -0.05533991f, 0.02804143f, 
    0.23874509f, -0.08085682f, -0.05692178f, 0.23748924f, -0.04757576f, -0.12991770f, -0.08958786f, 0.06493776f, 
    0.06382132f, 0.00834366f, -0.19077396f, 0.00239284f, 0.01447329f, 0.04443248f, 0.07690446f, -0.11659933f, 
    -0.06350075f, 0.01368279f, 0.04849879f, -0.03780745f, 0.20295204f, 0.04684051f, 0.07516801f, 0.06778964f, 
    0.13013944f, -0.00246269f, 0.12356947f, 0.30345684f, -0.00378226f, 0.00575600f, -0.06564023f, 0.02682748f, 
    -0.00510248f, 0.09156039f, 0.14153032f, -0.00774829f, 0.06183025f, -0.02272918f, 0.00411305f, 0.18836910f, 
    -0.00244652f, -0.07924694f, 0.07733092f, 0.19911911f, -0.04813835f, -0.01073982f, 0.01570239f, 0.02399010f, 
    0.11209664f, 0.13282135f, -0.05989937f, 0.19293454f, -0.03373051f, 0.17106235f, 0.10152791f, 0.14946061f, 
    0.03533067f, 0.03504065f, 0.05337930f, 0.03346451f, 0.03460659f, 0.10036022f, -0.19338061f, -0.06288663f, 
    0.02590212f, -0.00092425f, -0.00350339f, 0.01861689f, 0.08206796f, -0.01657798f, -0.02544574f, -0.01655931f, 
    -0.11853040f, -0.07991994f, -0.06451935f, 0.08717490f, 0.14928226f, -0.03350666f, 0.10502836f, -0.07588194f, 
    -0.03112808f, 0.07841501f, -0.02738309f, 0.03453224f, -0.34925571f, -0.35406980f, 0.19645557f, 0.03771324f, 
    0.05513978f, -0.01525004f, -0.03797562f, 0.16519400f, -0.06816226f, 0.06319969f, 0.17159869f, 0.08018941f, 
    0.06215842f, 0.20930476f, 0.05520044f, 0.21029735f, 0.11185826f, 0.01989242f, -0.03825497f, 0.07729520f, 
    0.05543318f, 0.02186403f, 0.04790616f, 0.00747339f, -0.37174797f, 0.16337745f, 0.03130160f, -0.33561096f, 
    -0.01636915f, 0.03983381f, -0.05484278f, 0.01105737f, 0.01708139f, -0.01309726f, -0.04385418f, 0.08891618f, 
    0.00551709f, -0.07148512f, -0.15244117f, -0.16192359f, 0.01174359f, -0.16469163f, -0.04488129f, 0.16543549f, 
    -0.09347045f, 0.07275275f, -0.05057651f, -0.05751805f, 0.20296033f, -0.16698104f, -0.16862433f, -0.02576149f, 
    0.13791023f, -0.00085033f, 0.03566305f, -0.06241933f, -0.01423971f, -0.02847000f, 0.03086408f, -0.05515091f, 
    -0.42423341f, 0.11853097f, -0.09084028f, -0.13075511f, 0.12371165f, 0.02892504f, 0.03343404f, -0.03087730f, 
    0.11418197f, -0.04172399f, 0.15182577f, 0.04980881f, 0.16719644f, -0.02988195f, 0.09695894f, 0.04058655f, 
    -0.04802898f, 0.00070854f, 0.18024781f, 0.13441047f, 0.16451232f, 0.04511467f, 0.12946679f, 0.00102773f, 
    0.17149381f, -0.07905833f, -0.10040533f, 0.19039521f, -0.12439077f, 0.11536854f, -0.10476944f, -0.07543882f, 
    0.04998138f, -0.04174669f, 0.00427601f, -0.04345281f, -0.14673632f, 0.10890548f, -0.16054319f, -0.07481214f, 
    0.13511850f, -0.02046017f, 0.04358271f, 0.00849394f, -0.01038383f, 0.14086016f, 0.11232366f, 0.04277756f, 
    -0.03708099f, 0.04584404f, -0.06030047f, 0.05317744f, 0.03975390f, -0.10475322f, 0.01587167f, 0.01957331f, 
    0.08660741f, 0.14205495f, 0.11582313f, 0.01750768f, -0.26853594f, -0.02717991f, 0.01119580f, 0.31130964f, 
    -0.17817290f, 0.04412806f, -0.04195085f, -0.07151791f, 0.08615009f, -0.09545663f, 0.14788175f, -0.00474340f, 
    -0.12138988f, -0.18048203f, 0.09006591f, -0.26444635f, 0.09382644f, 0.01717501f, -0.10328112f, -0.07815164f, 
    -0.06170259f, -0.06317811f, -0.02081854f, 0.06709883f, 0.39634892f, -0.06483158f, -0.18698606f, -0.02173259f, 
    0.00557156f, -0.00466169f, 0.04292471f, -0.02264996f, 0.00009198f, 0.07744344f, 0.04289450f, 0.06970502f, 
    0.00268667f, -0.20201077f, -0.19944093f, -0.33965454f, 0.10721651f, -0.06144932f, 0.02966150f, -0.12383190f, 
    -0.02971378f, 0.09460356f, 0.07885028f, 0.11447009f, 0.12520358f, 0.08066092f, -0.03927833f, -0.11035369f, 
    -0.17731990f, -0.04945089f, 0.03582396f, 0.10727791f, 0.04223372f, 0.06419184f, 0.00571964f, -0.01218734f, 
    0.10560044f, 0.11046164f, 0.16548191f, 0.29695284f, 0.04048015f, 0.09221505f, 0.02937603f, 0.05170064f, 
    -0.08517794f, -0.01576312f, -0.01128100f, 0.07632315f, 0.13374756f, -0.24376583f, -0.09606871f, -0.13867177f, 
    -0.01903882f, -0.02460215f, 0.15189728f, 0.09055195f, -0.02975139f, 0.07801924f, -0.03415591f, -0.07125735f, 
    0.18482427f, 0.13075474f, -0.11320093f, 0.06747907f, 0.10379082f, 0.01336045f, 0.09512809f, -0.06833612f, 
    -0.09541027f, 0.02652414f, -0.03249913f, -0.00796096f, -0.00923127f, 0.25116408f, 0.14175797f, 0.21495299f, 
    0.11010278f, -0.08926232f, -0.00777478f, -0.06975049f, 0.12519801f, 0.02755975f, 0.03745950f, 0.11487621f, 
    0.02675607f, 0.03807468f, -0.16100718f, -0.12987587f, -0.06574017f, 0.13280170f, -0.04268679f, -0.13296403f, 
    0.04096441f, -0.02808059f, -0.05879754f, -0.01976476f, 0.03768119f, -0.09210361f, -0.20651034f, 0.04139367f, 
    -0.18059818f, 0.07112827f, -0.13294537f, -0.20673837f, -0.19747192f, -0.00271085f, -0.07151489f, -0.05871191f, 
    -0.02266828f, -0.14012198f, -0.14991546f, 0.13778348f, 0.07389148f, 0.06848096f, 0.09182327f, 0.05277871f, 
    -0.00008263f, -0.02592541f, -0.04613755f, 0.04149337f, 0.10566571f, 0.02680193f, -0.09388547f, 0.04917286f, 
    -0.01369751f, 0.03345826f, -0.00445434f, 0.06980804f, -0.07518601f, 0.02601503f, 0.07464439f, 0.04970470f, 
    -0.06649420f, 0.11130371f, 0.02951271f, 0.12500757f, -0.04417003f, -0.04332062f, -0.15567786f, 0.03837345f, 
    -0.11177303f, -0.09469701f, -0.01083631f, -0.02456843f, 0.02387165f, -0.07676304f, -0.05391793f, -0.08358550f, 
    0.18548319f, -0.03627252f, 0.01136591f, 0.00459660f, 0.03522806f, -0.04931690f, 0.18332039f, -0.05982810f, 
    0.11863063f, 0.04098559f, -0.01599667f, -0.11991130f, 0.07329085f, 0.07407284f, -0.03347544f, -0.04160500f, 
    0.00555724f, -0.04681220f, -0.00382535f, -0.11841169f, -0.34155148f, -0.08058712f, -0.06713766f, 0.12135791f, 
    0.03544442f, -0.12248473f, -0.02889955f, 0.06717492f, 0.00782518f, 0.08406989f, 0.05371016f, -0.08709471f, 
    -0.04369632f, 0.08436665f, -0.14652498f, 0.07278332f, -0.01782326f, 0.04856534f, -0.01794429f, 0.07700077f, 
    -0.07178297f, -0.10575436f, -0.06972491f, 0.13619614f, -0.09715998f, 0.15475488f, -0.08183298f, -0.18238266f, 
    -0.08291413f, 0.15070154f, -0.01433704f, -0.01656539f, 0.05660393f, -0.00274874f, -0.01225800f, 0.03466018f, 
    0.03740827f, 0.14212285f, -0.02380835f, -0.11953577f, 0.05173330f, 0.06930036f, -0.05560649f, -0.01963209f, 
    -0.05322013f, 0.06188635f, 0.12758946f, -0.14688258f, -0.16810694f, -0.23090668f, 0.14584775f, 0.22396079f, 
    0.11258112f, -0.03218503f, 0.11470211f, -0.01726148f, 0.01446996f, 0.05712919f, 0.09889572f, -0.02963853f, 
    0.71893042f, -0.17152560f, 0.15166852f, 0.16389167f, -0.10181357f, -0.00622345f, 0.03594078f, 0.13703844f, 
    -0.00655884f, 0.00500646f, 0.06594951f, -0.02998630f, 0.01131000f, 0.25812033f, -0.11720565f, -0.26690432f, 
    -0.00276261f, 0.07804421f, 0.08822629f, 0.07890705f, 0.09207875f, 0.11072245f, 0.09830860f, 0.07460935f, 
    -0.07715536f, -0.11640154f, -0.15263426f, -0.12032762f, -0.05186622f, 0.08798356f, -0.02209768f, -0.04717306f, 
    0.00417393f, 0.03696612f, -0.04825077f, -0.01211213f, -0.11292639f, -0.25169051f, -0.05882233f, 0.04997639f, 
    0.11119016f, -0.01053456f, -0.00635904f, 0.00252029f, 0.10418300f, -0.03495782f, -0.12809625f, 0.04438347f, 
    0.24583229f, -0.10776221f, -0.03911104f, 0.18861885f, -0.07581254f, -0.05979107f, 0.03808610f, 0.05462379f, 
    0.05429823f, 0.12418298f, 0.09038681f, -0.08456776f, 0.33846885f, -0.24026468f, 0.04165703f, 0.14918321f, 
    0.00967207f, -0.05526323f, -0.03780420f, 0.03808589f, 0.06153787f, 0.10534123f, -0.01514549f, -0.04027876f, 
    0.22495991f, -0.29401633f, -0.08123706f, -0.13988803f, -0.01259258f, -0.06101643f, 0.02417691f, 0.02098736f, 
    0.01037345f, -0.02518016f, -0.07268227f, 0.04646472f, 0.03337729f, 0.20247769f, 0.05862792f, 0.07020790f, 
    0.09183651f, 0.10546278f, -0.17698312f, 0.14290895f, -0.01299148f, -0.09584584f, 0.05307848f, 0.03334726f, 
    0.42207068f, 0.03907875f, 0.03274205f, 0.14171521f, 0.01953490f, 0.05899414f, 0.02025225f, 0.00174323f, 
    0.06073500f, 0.05480442f, -0.07910459f, -0.02266981f, 0.11913796f, 0.01577548f, -0.07945541f, 0.02686521f, 
    0.06976347f, -0.06621353f, -0.01064160f, -0.08326325f, -0.14022824f, -0.05507464f, 0.02103237f, -0.02694035f, 
    0.21462898f, 0.05093367f, -0.04115655f, 0.00024947f, 0.15428190f, 0.06181535f, 0.02208011f, 0.08150993f, 
    0.14057115f, 0.02653853f, -0.04619430f, 0.05764265f, 0.06711642f, 0.11949468f, -0.16227092f, -0.08589167f, 
    -0.00770173f, 0.01758981f, -0.06254988f, 0.12328092f, 0.04021231f, 0.00112290f, -0.06720039f, -0.03803567f, 
    -0.09157135f, 0.05996126f, -0.18710867f, -0.18539378f, -0.15073685f, 0.01365890f, 0.02563416f, 0.07044947f, 
    0.07539183f, 0.04579608f, 0.11548050f, 0.05864334f, 0.32711309f, 0.11150189f, -0.05274976f, 0.08200082f, 
    0.05189984f, -0.10603832f, 0.04208504f, 0.00193364f, -0.05706814f, -0.06628790f, 0.05593156f, -0.04111421f, 
    -0.29182631f, -0.12126546f, -0.06394509f, -0.03960522f, 0.09018148f, 0.07804774f, -0.00391646f, -0.02509796f, 
    0.06686641f, -0.05367798f, 0.07032893f, -0.05568102f, 0.47511724f, -0.10781927f, -0.17626613f, 0.22499885f, 
    -0.10254439f, -0.23164684f, -0.06737034f, 0.07518703f, -0.00281881f, -0.02694818f, 0.03424769f, 0.12351709f, 
    0.19409008f, -0.09385839f, -0.08455173f, -0.04703909f, -0.00844123f, 0.03781462f, -0.00264144f, 0.04065884f, 
    0.11453478f, -0.00257799f, -0.00929123f, 0.00847658f, 0.04221405f, -0.01840602f, 0.08767302f, -0.13731627f, 
    -0.05158212f, -0.00387853f, -0.05812316f, 0.18383703f, 0.07529779f, -0.11487968f, 0.05770978f, 0.05431679f, 
    0.20945056f, 0.12599361f, 0.03998857f, 0.22878231f, 0.13095462f, -0.03225485f, 0.09780721f, 0.02548302f, 
    0.07359386f, 0.10022154f, 0.00972698f, -0.02039641f, -0.10525674f, -0.02257048f, -0.07636523f, 0.20936264f, 
    -0.06382446f, -0.04384540f, 0.02379894f, 0.02865977f, -0.00065891f, 0.09885176f, 0.11941171f, -0.01649642f, 
    -0.29180959f, -0.17936270f, 0.19464327f, 0.10912658f, -0.08821742f, -0.09921573f, -0.04435785f, 0.03359139f, 
    -0.06789149f, 0.01265386f, -0.00072526f, -0.01770468f, -0.11989541f, 0.10963507f, 0.06257891f, -0.00413257f, 
    -0.08332847f, 0.05897978f, 0.05741758f, 0.03855589f, -0.00272357f, 0.12336908f, 0.00852698f, 0.20578043f, 
    -0.03441160f, 0.26054481f, 0.05382073f, -0.10926894f, 0.06416188f, -0.08925581f, -0.06373814f, 0.00937793f, 
    0.04250389f, -0.06359769f, -0.02381735f, -0.03172766f, -0.24960741f, 0.04824761f, 0.03640257f, -0.07870869f, 
    0.03568805f, -0.01254056f, 0.05388587f, -0.02663920f, 0.08655234f, -0.09589114f, -0.09091661f, 0.04296992f, 
    0.07700926f, 0.00806305f, 0.23005386f, -0.18523926f, -0.01386394f, 0.01239419f, -0.01943031f, 0.04292475f, 
    -0.03802466f, 0.08880260f, -0.12323913f, -0.17796637f, -0.12782352f, -0.08601977f, -0.16150844f, 0.03955382f, 
    0.04110453f, -0.02079317f, -0.05051901f, 0.00574587f, 0.03866195f, 0.01767415f, 0.03510996f, 0.04736879f, 
    0.19775335f, 0.00474200f, -0.08836847f, 0.05221172f, 0.04860023f, -0.04867770f, -0.20102638f, 0.04775045f, 
    0.06118041f, 0.04220928f, -0.03128927f, 0.06071049f, 0.07204785f, -0.02868980f, 0.21297410f, -0.00700140f, 
    -0.03055673f, 0.02478084f, 0.07249992f, -0.04798526f, 0.03965118f, 0.04813812f, 0.01871808f, 0.20153993f, 
    0.04711441f, -0.21062462f, 0.13836236f, 0.06639066f, 0.06364188f, 0.01886415f, 0.03517216f, -0.07870205f, 
    -0.02464928f, -0.05621564f, 0.01825628f, -0.02604445f, 0.17447466f, -0.09827337f, 0.07616207f, -0.10799116f, 
    0.12908359f, -0.06402349f, -0.09357993f, 0.07698396f, 0.03738789f, -0.11498056f, 0.04444944f, -0.10059448f, 
    0.12040070f, -0.25890398f, 0.15253030f, 0.00983978f, -0.05888537f, 0.18410286f, 0.08867498f, 0.05321503f, 
    0.02871706f, -0.00265087f, -0.02617455f, -0.02886758f, -0.13691664f, 0.00949889f, -0.10997429f, 0.13236029f, 
    -0.02442782f, 0.03019022f, 0.06425229f, 0.08452869f, 0.05231101f, 0.06665964f, 0.06084061f, 0.12459320f, 
    0.01613118f, 0.12617877f, 0.04167084f, 0.05249513f, 0.07259887f, 0.04525609f, -0.00172149f, -0.07565713f, 
    0.07150817f, 0.02266931f, 0.06252091f, -0.05379026f, 0.05216763f, -0.27739805f, -0.02593900f, 0.34398773f, 
    0.01729462f, -0.04578511f, -0.05258291f, -0.07692589f, -0.08472519f, 0.02390003f, 0.00584668f, 0.04521635f, 
    0.44636115f, -0.23573706f, 0.16684994f, 0.07355427f, 0.12737063f, 0.01562760f, -0.00497582f, -0.04467141f, 
    -0.07403305f, -0.00600734f, -0.09699450f, -0.07169252f, -0.04842564f, 0.26009655f, 0.07086593f, -0.13746141f, 
    -0.02877576f, 0.07901891f, -0.00355345f, -0.04935697f, -0.08749543f, -0.02264728f, 0.11044890f, -0.03986592f, 
    -0.17415735f, -0.21554479f, -0.01584589f, 0.13710026f, 0.02950826f, -0.03415693f, 0.03999766f, -0.05658783f, 
    -0.01717220f, 0.04018412f, 0.07523775f, 0.05240890f, -0.06559523f, 0.14109205f, 0.10270277f, -0.01146279f, 
    0.03083265f, 0.13890086f, 0.03423871f, -0.03954919f, -0.09727672f, 0.01456045f, -0.01814709f, -0.08574930f, 
    -0.39484662f, 0.27332270f, 0.10273430f, 0.23399697f, 0.20521967f, 0.06730374f, -0.01951939f, 0.02008492f, 
    0.00803536f, 0.06400297f, 0.03859962f, 0.02056276f, -0.19467653f, 0.03110586f, -0.18139413f, -0.14973432f, 
    0.03616047f, -0.00676085f, 0.17509641f, 0.03128185f, 0.02976328f, 0.11793315f, 0.05616130f, 0.08097583f, 
    -0.03084358f, 0.09631096f, -0.16748394f, 0.01336564f, -0.03297165f, 0.11967723f, 0.02088966f, -0.06916267f, 
    0.03348475f, 0.03371164f, 0.01230624f, -0.04164604f, -0.07975820f, 0.09275594f, 0.05664571f, -0.21087168f, 
    -0.06175157f, 0.00379061f, 0.04149394f, -0.06364747f, 0.12385343f, -0.05631623f, -0.06590082f, -0.14780700f, 
    0.06189643f, 0.08532245f, 0.01257376f, 0.04159194f, 0.00018391f, -0.08224669f, 0.00466894f, -0.04329790f, 
    -0.15575512f, -0.08354183f, 0.20339125f, 0.08637860f, 0.19181268f, -0.00591759f, -0.06352571f, 0.16913383f, 
    0.08219954f, 0.04483606f, 0.02106779f, -0.05498708f, -0.00990592f, 0.00030943f, 0.01558481f, 0.03946130f, 
    0.26601496f, -0.05766975f, 0.21687229f, -0.25960720f, 0.00601760f, -0.08308931f, 0.01084382f, 0.06914331f, 
    -0.08372770f, -0.09686097f, 0.00002304f, -0.01881318f, 0.01832920f, 0.00950329f, 0.05556128f, 0.00880857f, 
    0.03364476f, 0.03864274f, -0.01649988f, 0.12025575f, 0.09670351f, 0.08679745f, 0.04706063f, 0.11080487f, 
    0.30207089f, 0.11737829f, -0.14660706f, -0.25031254f, 0.15836252f, -0.03425483f, -0.01650869f, -0.06658955f, 
    -0.00955236f, -0.03496064f, 0.02513609f, -0.03907707f, -0.02557630f, 0.03170535f, 0.20468107f, -0.10955170f, 
    -0.01426062f, -0.01265603f, 0.04510289f, -0.00581951f, 0.09134236f, 0.14123778f, 0.13204019f, 0.09145693f, 
    0.08253013f, -0.18867637f, 0.02293090f, 0.03898657f, 0.01497966f, 0.00290855f, 0.01351278f, -0.12418813f, 
    0.18747327f, 0.12136956f, 0.16974220f, 0.10159377f, -0.12669225f, 0.10335353f, 0.03698652f, 0.11662259f, 
    -0.04543186f, 0.00625927f, -0.02313562f, 0.08983776f, -0.00828165f, -0.00381977f, 0.02654514f, -0.10020509f, 
    -0.27941695f, 0.19182357f, -0.21640454f, -0.11913154f, 0.05173295f, -0.10258868f, -0.14618410f, 0.04062455f, 
    -0.04269332f, -0.00176535f, -0.05202562f, -0.12402896f, 0.01945344f, 0.01700973f, -0.13689914f, 0.22730431f, 
    0.05157845f, -0.06523872f, 0.10824170f, -0.00681857f, 0.04594564f, -0.01188675f, 0.08556980f, 0.09017818f, 
    -0.00987411f, -0.12611313f, -0.14974396f, 0.21333000f, -0.05621342f, 0.01802034f, 0.05718682f, -0.00554291f, 
    0.03677756f, -0.02716493f, -0.06059492f, 0.04791099f, -0.06550510f, 0.14052936f, -0.05859647f, 0.11933382f, 
    -0.01323418f, 0.04902234f, -0.01708353f, -0.03680075f, -0.09923247f, 0.01920563f, -0.01235262f, -0.07821550f, 
    -0.06493481f, -0.01275170f, 0.04241179f, -0.10901967f, 0.00216270f, 0.11654595f, 0.06806814f, -0.00840492f, 
    0.01696803f, -0.05039594f, 0.04186892f, -0.02933256f, -0.03102883f, 0.12291025f, 0.15096819f, 0.18725024f, 
    -0.00726892f, 0.00713073f, 0.05013098f, 0.00027753f, -0.12915836f, -0.03870641f, -0.01867025f, 0.14932516f, 
    0.22398719f, 0.04949117f, 0.22843713f, 0.05643062f, 0.01159570f, -0.05773224f, -0.05193193f, 0.11724399f, 
    0.04590455f, 0.07419024f, -0.03299867f, -0.13040274f, 0.04511618f, 0.02061170f, -0.08023582f, -0.05986286f, 
    -0.05791942f, 0.03816267f, -0.11708373f, 0.04232137f, -0.09960320f, -0.03740281f, 0.06261914f, 0.08807117f, 
    0.14431326f, 0.14729439f, 0.10457935f, 0.16693687f, 0.06368421f, -0.00843675f, -0.10031046f, -0.10628463f, 
    0.05348771f, -0.09601768f, -0.16193202f, 0.05414487f, -0.02932299f, 0.08167553f, 0.10015550f, 0.08364864f, 
    0.00036805f, -0.01561096f, 0.09282431f, -0.04571678f, 0.03677669f, 0.06327910f, 0.06813066f, -0.00420916f, 
    -0.10878646f, 0.07384628f, 0.05083316f, 0.13486023f, -0.03329495f, 0.09220132f, 0.09233047f, 0.09214762f, 
    0.03075444f, 0.08056881f, 0.04619887f, -0.07669783f, 0.36706173f, -0.02111839f, -0.04683750f, -0.13948710f, 
    0.02268179f, 0.06471845f, 0.02864353f, -0.02739924f, -0.09579704f, -0.04869927f, -0.02362155f, -0.02227991f, 
    0.14692600f, -0.15111794f, 0.07099446f, 0.13674755f, -0.01479724f, -0.01210055f, 0.10495042f, -0.02662232f, 
    0.00960173f, -0.04311680f, -0.10005233f, -0.14924286f, -0.24833505f, 0.07758038f, -0.01997822f, 0.15093708f, 
    -0.04059068f, 0.01956990f, 0.08035325f, 0.17130005f, -0.02693681f, 0.09952940f, 0.07307225f, 0.02183802f, 
    0.04977974f, -0.10838212f, -0.06848550f, 0.23286372f, 0.10131945f, -0.03579100f, -0.02266422f, -0.01997386f, 
    0.02487054f, 0.00498224f, -0.01486455f, 0.01371154f, 0.31667554f, -0.32363370f, 0.08976671f, 0.16123340f, 
    0.04243162f, -0.03835493f, -0.02558720f, -0.01374766f, -0.00776684f, 0.04032832f, 0.04899598f, 0.09353381f, 
    0.19703583f, -0.03698483f, 0.13941817f, 0.05586428f, 0.06244098f, 0.13859808f, -0.04436973f, 0.08801012f, 
    0.02620141f, -0.02843393f, -0.05557778f, -0.00906283f, -0.15417877f, 0.16070399f, -0.04376142f, -0.26383507f, 
    0.05306955f, 0.08788007f, 0.15832448f, -0.15451749f, 0.03315069f, -0.07252482f, 0.00774527f, 0.08590566f, 
    -0.00028585f, -0.14164773f, 0.06340916f, 0.09025912f, -0.03681985f, -0.06215057f, 0.07119277f, -0.03428416f, 
    -0.09245787f, 0.22093482f, 0.05432442f, -0.08423477f, -0.08222739f, -0.00758338f, 0.16431552f, 0.04088136f, 
    0.04155643f, -0.10519493f, -0.02590819f, -0.01304630f, -0.01560570f, 0.03269263f, -0.01557289f, -0.04945709f, 
    -0.21108937f, 0.09136358f, 0.00885435f, -0.22073051f, -0.02511379f, 0.05065354f, -0.03869897f, 0.02435743f, 
    0.01027786f, -0.00002499f, -0.00386239f, -0.07691769f, 0.05812259f, 0.09760570f, -0.11761624f, 0.07675469f, 
    -0.03351041f, 0.02389429f, 0.06169484f, 0.09146143f, 0.00637799f, 0.09185116f, 0.20053728f, 0.00487394f, 
    0.01415939f, -0.01164690f, -0.02404229f, 0.14155860f, -0.01341877f, 0.09139936f, -0.13352309f, 0.01206694f, 
    0.07315055f, -0.01095386f, 0.04913630f, 0.00817609f, -0.11353016f, 0.40453723f, -0.12496556f, -0.08866951f, 
    0.04439221f, -0.07130420f, 0.09709756f, -0.04251927f, 0.02367607f, 0.03337811f, 0.04793825f, 0.04175595f, 
    0.18712479f, 0.11884551f, -0.07457046f, 0.04736829f, 0.00869102f, -0.06379104f, 0.07882579f, -0.16162270f, 
    -0.04933028f, 0.04707718f, 0.09505752f, 0.04462585f, 0.17257704f, 0.00356112f, -0.01909927f, 0.14943717f, 
    0.09889673f, 0.00629595f, -0.04739321f, 0.08930434f, -0.02728027f, 0.01735623f, 0.06730089f, 0.06019753f, 
    -0.03422536f, 0.00020327f, 0.07553197f, -0.26574177f, 0.13088478f, 0.00940196f, 0.04999028f, -0.00060156f, 
    -0.08293425f, -0.08956902f, -0.06395339f, 0.12683009f, -0.14180854f, -0.06534486f, -0.19395021f, 0.03696281f, 
    0.03791463f, 0.07391609f, 0.06117743f, -0.05412901f, 0.09088999f, 0.02247756f, 0.08387431f, -0.00928718f, 
    -0.41201234f, 0.01406939f, -0.10385600f, -0.27558687f, 0.12600796f, -0.02088565f, -0.01391609f, -0.06004452f, 
    -0.02226732f, -0.13540018f, -0.04548206f, 0.02147255f, 0.30028367f, 0.07233164f, -0.07164047f, 0.22021927f, 
    0.01511940f, -0.03407243f, -0.01880000f, 0.02076442f, -0.03583817f, 0.05887612f, 0.04808920f, -0.03056938f, 
    0.15957700f, -0.01217592f, 0.19037262f, 0.09308373f, -0.03281019f, 0.03560089f, -0.05400879f, -0.07316228f, 
    0.04454833f, -0.04431535f, 0.06860745f, 0.07548656f, 0.12251021f, -0.05375764f, -0.08182995f, -0.07927419f, 
    -0.02623440f, 0.00291042f, 0.10454487f, 0.19130707f, 0.08588871f, -0.13138819f, 0.08909447f, -0.02783647f, 
    0.03981168f, 0.07277139f, -0.06059575f, 0.14954174f, 0.06189631f, 0.00416887f, -0.11936627f, -0.12099522f, 
    -0.02937617f, 0.03212106f, -0.06474754f, -0.01029436f, 0.04175392f, 0.20544231f, -0.29695997f, 0.45126012f, 
    -0.05239544f, -0.03477382f, 0.04428006f, -0.07155168f, 0.07403404f, 0.14556666f, 0.11382075f, 0.13872802f, 
    -0.03446100f, -0.03296394f, -0.02251530f, 0.00905161f, 0.02006951f, -0.01205866f, 0.00882801f, -0.00787095f, 
    -0.08804603f, -0.03807212f, 0.12983170f, 0.01201282f, 0.03998692f, -0.09282976f, -0.13384330f, 0.08837430f, 
    -0.04751375f, 0.06895509f, -0.01706788f, 0.00242675f, -0.15322769f, -0.00371674f, -0.01214781f, 0.07510637f, 
    0.00332637f, 0.00807766f, 0.09779627f, 0.09790760f, -0.13922372f, 0.07576239f, 0.01533756f, -0.20385621f, 
    -0.00638230f, -0.08412625f, -0.01176637f, -0.07307143f, 0.06692556f, 0.04075130f, 0.14456567f, 0.01183856f, 
    -0.02348712f, 0.15576726f, -0.05119117f, -0.09104891f, -0.00877713f, 0.02253102f, 0.02819531f, 0.01869265f, 
    -0.02537172f, -0.18995722f, 0.19639897f, -0.03841389f, 0.19652659f, -0.06901684f, -0.04964365f, 0.10824096f, 
    0.06645390f, 0.06314912f, -0.07298771f, -0.07346264f, 0.04728707f, 0.13152602f, 0.20734784f, 0.29059520f, 
    -0.20590787f, -0.01350064f, -0.11487890f, -0.03768361f, -0.11775332f, -0.03307888f, -0.13631590f, 0.01309751f, 
    -0.02544255f, 0.22149482f, 0.08776976f, 0.10613237f, -0.10822414f, -0.05109819f, 0.06712856f, -0.00151818f, 
    -0.05050503f, 0.05272716f, -0.05663752f, 0.06477202f, 0.18866411f, 0.12864861f, -0.14701569f, -0.10016700f, 
    0.05034351f, 0.19521700f, 0.07289358f, 0.05770466f, -0.08343858f, 0.07036448f, -0.01673169f, 0.02267659f, 
    -0.18702577f, 0.13009363f, -0.08530291f, -0.20955065f, 0.02357969f, -0.01495264f, -0.09063344f, 0.01018538f, 
    0.12835620f, 0.01578637f, 0.06860503f, -0.00948647f, 0.00933577f, -0.20080905f, 0.07026013f, 0.04900204f, 
    -0.05385541f, 0.00210882f, -0.06166381f, -0.13602132f, 0.09482048f, -0.10882738f, -0.08877864f, 0.00909477f, 
    -0.22394139f, -0.02571339f, 0.22314890f, 0.23666070f, 0.06483468f, -0.21986581f, 0.10257576f, -0.00606536f, 
    0.00951931f, 0.03769191f, -0.11578088f, 0.10800077f, 0.05049847f, 0.12094454f, 0.01105501f, -0.20234106f, 
    -0.01527570f, 0.00113811f, -0.03197055f, 0.08773712f, 0.03746952f, 0.12386008f, 0.06045302f, 0.05213298f, 
    -0.29402760f, -0.16046403f, -0.10928302f, 0.00381707f, -0.07508389f, -0.11758408f, 0.16734028f, 0.09530864f, 
    0.01021968f, -0.08440495f, 0.04826713f, 0.08661996f, 0.19554399f, 0.04133280f, 0.27188000f, 0.13365278f, 
    -0.05643789f, -0.01145719f, 0.04858327f, -0.04991742f, -0.04893811f, 0.09317450f, -0.08010101f, 0.12062424f, 
    -0.26008543f, 0.03662543f, 0.10248032f, 0.18587433f, -0.04680155f, 0.11411896f, 0.03264495f, 0.07517423f, 
    0.10561907f, -0.05909058f, -0.05649954f, -0.01631912f, 0.27188590f, 0.05938283f, 0.12332700f, -0.01861471f, 
    0.01806072f, 0.04417335f, 0.09890851f, -0.28669259f, 0.05755274f, -0.09462012f, 0.00781127f, 0.00107586f, 
    -0.24239644f, 0.32855919f, 0.04337494f, -0.35590768f, 0.06268501f, 0.02643237f, 0.19316295f, 0.04059382f, 
    -0.07566212f, 0.14901631f, 0.04703107f, 0.08365297f, -0.32389948f, -0.02678105f, -0.00798603f, -0.12235721f, 
    -0.08165643f, -0.01385133f, -0.03058659f, 0.01336078f, 0.02545712f, 0.00505076f, 0.00460966f, -0.02520538f, 
    -0.14740093f, 0.01346341f, -0.12774496f, -0.27183372f, -0.10326134f, 0.11833167f, -0.09596409f, -0.12557165f, 
    -0.08602060f, -0.02666571f, -0.13196760f, -0.02723594f, 0.27401081f, -0.04236565f, -0.04125332f, 0.10257221f, 
    0.01109186f, -0.05353414f, 0.08005780f, 0.02548428f, 0.05100802f, 0.05312048f, 0.08197030f, -0.01891426f, 
    0.01545842f, -0.04736839f, 0.20485669f, 0.14803632f, 0.08888312f, -0.00131674f, -0.03554586f, 0.05488204f, 
    0.11599866f, 0.11166774f, 0.14115883f, 0.04220205f, 0.13473818f, 0.21400876f, -0.01206166f, -0.05416415f, 
    -0.00903148f, -0.08018712f, 0.01375297f, -0.12597179f, 0.00334533f, -0.05435473f, -0.00495898f, -0.02351806f, 
    0.00810220f, 0.09420938f, 0.01175200f, 0.18728392f, -0.03800543f, -0.08043976f, 0.02431796f, -0.12561919f, 
    0.02205230f, 0.14917313f, 0.05734611f, -0.04025998f, 0.21283120f, -0.04503084f, 0.22396353f, 0.03489004f, 
    0.08154532f, 0.01284369f, -0.01266959f, 0.06841744f, -0.04947500f, 0.12543704f, 0.07705029f, 0.17449337f, 
    -0.26624471f, 0.16840422f, 0.08147830f, 0.13093153f, 0.03690973f, -0.07005268f, 0.04148367f, -0.06080794f, 
    -0.00120587f, -0.15957305f, -0.12669992f, -0.02653888f, -0.40119117f, 0.08966987f, -0.06358013f, -0.11927814f, 
    -0.02461790f, 0.02648799f, -0.02262921f, -0.04155650f, -0.03920000f, 0.11947308f, 0.14470713f, 0.10375170f, 
    -0.19601531f, -0.14128727f, 0.35705820f, 0.21793430f, -0.07340135f, -0.02158659f, -0.15383041f, -0.17971423f, 
    -0.07429430f, -0.06381062f, -0.03730769f, -0.00927362f, 0.00759967f, 0.10369128f, -0.15025139f, 0.07546867f, 
    0.10167886f, 0.10290008f, -0.02486233f, -0.24040978f, -0.07529099f, 0.05612728f, 0.01521788f, -0.20138560f, 
    0.15185845f, 0.13685864f, 0.25918037f, 0.20045719f, -0.05213735f, 0.00786391f, -0.00534718f, 0.19568634f, 
    0.02059416f, 0.06940251f, 0.03250331f, 0.02726103f, 0.07202157f, -0.16496293f, -0.27433118f, -0.15692045f, 
    0.13437076f, 0.03932887f, -0.03915596f, -0.15509290f, 0.16287246f, -0.03027586f, -0.08781438f, 0.08342270f, 
    0.13615714f, -0.08230175f, 0.11690773f, 0.10243361f, -0.03383355f, -0.00954386f, -0.00345212f, -0.03534179f, 
    0.10810134f, -0.04995858f, -0.07511513f, -0.02890315f, 0.21910781f, 0.03573124f, -0.07099006f, 0.00688697f, 
    -0.07928202f, 0.05891152f, 0.00686176f, 0.01939455f, 0.10071658f, 0.02359785f, 0.08600505f, -0.02185622f, 
    0.18626945f, 0.21068390f, -0.15004438f, -0.22972126f, 0.08949465f, 0.04429784f, 0.02880785f, 0.12445346f, 
    -0.04185266f, -0.02567254f, 0.10965804f, 0.05801110f, 0.22829045f, 0.04449913f, 0.02213918f, 0.13230313f, 
    0.03061431f, 0.08072889f, 0.04929364f, 0.04979602f, 0.03268151f, 0.02418764f, -0.00250315f, 0.06328614f, 
    0.12605883f, 0.16188742f, 0.13701229f, -0.19536915f, 0.10862648f, 0.06620496f, -0.07294227f, -0.03681800f, 
    -0.03175215f, 0.09857620f, 0.00714200f, 0.17445372f, 0.07337143f, 0.02651498f, 0.03981029f, -0.01051844f, 
    -0.01333120f, -0.02111317f, 0.06647198f, 0.02736361f, 0.12348004f, 0.12717736f, 0.16411699f, 0.17831722f, 
    0.21083291f, 0.15614806f, -0.07548297f, -0.14711180f, -0.04405806f, 0.09421138f, 0.03859686f, 0.17473258f, 
    0.10848905f, 0.04056934f, 0.10703568f, 0.22416383f, 0.03243509f, 0.09666654f, 0.11426933f, 0.06096174f, 
    -0.10179233f, 0.18779728f, 0.05089458f, -0.05269043f, -0.01709962f, -0.09443074f, -0.07842811f, 0.02396999f, 
    -0.03467777f, -0.14172886f, -0.05737060f, 0.05416925f, 0.06078037f, 0.01641502f, 0.08932538f, -0.05536974f, 
    -0.03703887f, 0.05867109f, 0.07312772f, 0.09231220f, 0.02117715f, 0.09260888f, -0.08924286f, 0.06357238f, 
    -0.01012441f, 0.06059860f, 0.00640927f, 0.02933683f, 0.07282773f, 0.00548355f, -0.00304676f, 0.00327381f, 
    0.00017412f, -0.06219124f, 0.01922940f, -0.03667486f, -0.01196744f, -0.05796434f, 0.12496304f, 0.09717511f, 
    0.06765935f, 0.08480367f, 0.15273194f, -0.11697873f, -0.09944143f, -0.11254403f, 0.14233704f, 0.21223028f, 
    0.09340352f, 0.08327608f, -0.02057585f, 0.03149659f, -0.02814665f, 0.00221584f, 0.06018046f, 0.00629569f, 
    0.17608422f, 0.06681488f, -0.26939765f, -0.05759218f, 0.00224158f, -0.01614615f, 0.09523440f, 0.07733962f, 
    0.06854425f, 0.00786215f, 0.06225628f, 0.14597306f, 0.11197313f, 0.15729786f, -0.09810647f, 0.02201032f, 
    -0.00903951f, -0.01917053f, 0.02179489f, -0.05271475f, 0.06311384f, -0.08603723f, -0.11600931f, 0.00934071f, 
    -0.30458897f, 0.07556332f, -0.16500276f, 0.04784447f, -0.03686867f, -0.00387730f, -0.04805008f, 0.00799867f, 
    0.06005351f, 0.09855953f, 0.01189542f, -0.00681182f, 0.26269168f, 0.05428833f, -0.14062271f, 0.12002596f, 
    -0.13291432f, 0.05748357f, -0.03917893f, -0.09588567f, 0.00510584f, 0.11095289f, -0.04778981f, 0.09166118f, 
    0.01709060f, 0.10492343f, 0.13509409f, -0.19803761f, -0.11321282f, -0.02718889f, 0.11506464f, 0.08745606f, 
    0.09252679f, -0.04519627f, 0.00515493f, 0.03617668f, -0.17588389f, 0.17744647f, 0.14011019f, -0.08695392f, 
    0.10873189f, 0.02186036f, -0.08001000f, 0.08425183f, 0.09532175f, 0.09413635f, 0.10156917f, 0.02078940f, 
    0.03244207f, 0.12670629f, -0.07815365f, -0.07077776f, -0.01475584f, 0.04070796f, -0.00818649f, -0.00863882f, 
    0.08016561f, -0.10317498f, 0.01328100f, 0.09791265f, -0.23167372f, 0.10910362f, 0.08461852f, 0.10391433f, 
    0.12072819f, -0.02107595f, 0.05972747f, 0.14910671f, 0.08141055f, -0.02929209f, 0.13012721f, 0.03296941f, 
    -0.00187431f, -0.11748371f, -0.15116389f, -0.00825719f, 0.10861902f, 0.13912946f, 0.08391730f, -0.08876773f, 
    0.10093438f, -0.01046351f, 0.14208685f, -0.00172066f, -0.03056147f, -0.22823223f, 0.07450129f, -0.05526266f, 
    -0.07436547f, 0.00991005f, 0.18035296f, -0.01991064f, 0.08008209f, -0.09335881f, -0.11222123f, -0.13872834f, 
    -0.06929483f, -0.09666954f, 0.01894160f, -0.14853422f, 0.08727859f, -0.03741442f, 0.02283454f, 0.00902201f, 
    -0.02090409f, 0.04184040f, -0.01390102f, 0.08013228f, -0.04267607f, -0.09632656f, 0.08447383f, -0.17531042f, 
    0.20903003f, -0.07395117f, 0.09041309f, 0.15128972f, 0.14367746f, 0.10814720f, 0.08324074f, 0.17931399f, 
    -0.01831410f, 0.02092176f, -0.09594340f, -0.10181367f, 0.05113736f, -0.06447616f, -0.06111868f, -0.00590360f, 
    0.04799281f, 0.04032300f, -0.05239146f, 0.13403983f, -0.25712776f, -0.07984634f, -0.07284454f, -0.02598204f, 
    -0.05918358f, 0.03711093f, -0.04367644f, -0.01924501f, -0.08848681f, -0.13142605f, 0.17337328f, 0.05061809f, 
    -0.24011873f, 0.09503698f, 0.15595706f, -0.04551225f, 0.12018587f, -0.03596152f, -0.04572652f, 0.04681868f, 
    -0.03238371f, -0.00523115f, -0.08394612f, 0.08009485f, 0.02353343f, -0.02863509f, 0.03766350f, -0.00507859f, 
    0.06864356f, -0.02733782f, 0.01435120f, -0.04155416f, -0.01378269f, -0.00452246f, 0.01915358f, -0.04807366f, 
    0.17296641f, 0.23033957f, 0.10848287f, -0.09802476f, 0.11326492f, 0.01359530f, -0.02463239f, 0.06984702f, 
    0.11684144f, 0.04988664f, 0.08641113f, 0.08486889f, -0.27924070f, -0.08083243f, -0.18880293f, -0.06951838f, 
    0.08907020f, 0.09477130f, 0.00853715f, 0.11288060f, 0.15378386f, -0.03224536f, -0.01937883f, 0.07594934f, 
    -0.12556405f, 0.05885287f, 0.07882857f, -0.00451512f, 0.00437416f, 0.12599628f, -0.00741842f, -0.08840884f, 
    0.04677416f, -0.03631264f, -0.14111672f, 0.01357139f, 0.11322739f, -0.09107696f, 0.08811665f, 0.19877835f, 
    0.08751272f, -0.01863327f, 0.18464190f, -0.05042548f, -0.19649158f, 0.09980292f, 0.03148692f, 0.05115971f, 
    0.11504620f, -0.03257132f, -0.08156083f, -0.01257069f, 0.06000276f, 0.02111677f, 0.01731660f, 0.02468015f, 
    -0.03757344f, 0.04869647f, 0.22088990f, 0.11515322f, -0.22073869f, -0.01549221f, 0.02078432f, -0.04017640f, 
    0.14821020f, -0.03797616f, -0.03145919f, 0.05229335f, 0.05124361f, 0.04469782f, -0.04661567f, -0.08795845f, 
    0.00571416f, 0.02648099f, 0.00839943f, 0.10391043f, -0.00864996f, 0.05142581f, -0.00479373f, 0.04057341f, 
    0.08161630f, -0.01657279f, 0.04459613f, -0.03315747f, 0.06624690f, -0.30301160f, -0.00329178f, 0.24380788f, 
    0.02711403f, 0.10548753f, 0.02432371f, -0.16496804f, 0.03080375f, 0.00562095f, 0.05027355f, -0.12641476f, 
    0.03888245f, -0.02533517f, 0.02899515f, 0.02044996f, -0.03220407f, 0.04860859f, -0.00574853f, 0.04750502f, 
    -0.04123892f, 0.00246583f, 0.03742930f, 0.01133744f, 0.01587817f, 0.01593000f, -0.05369276f, 0.00573418f, 
    0.00674626f, -0.00986709f, -0.04940284f, 0.05059721f, -0.02069099f, 0.02892004f, -0.04465302f, 0.00328724f, 
    -0.01057997f, 0.01833126f, -0.04791710f, 0.00508830f, 0.03291986f, -0.00158195f, -0.03818688f, -0.04300684f, 
    -0.04362935f, 0.01689270f, 0.00428654f, -0.04525828f, 0.03980973f, -0.04214283f, 0.00895049f, -0.03882147f, 
    -0.05895542f, 0.00533525f, 0.05030042f, -0.00198741f, -0.02327880f, -0.04069420f, -0.00488702f, 0.00954314f, 
    -0.04732799f, -0.03028892f, 0.02095826f, -0.00637420f, -0.03759697f, -0.05108325f, -0.02443136f, -0.03081225f, 
    0.03865852f, -0.01684498f, 0.01509386f, -0.03594564f, 0.03184292f, 0.00684502f, 0.03281622f, 0.02201110f, 
    -0.05564014f, 0.00960976f, 0.01812620f, -0.01743286f, 0.00670327f, 0.03623474f, 0.02033057f, 0.01695117f, 
    0.04446986f, 0.04770491f, 0.01315498f, 0.04124169f, -0.03492969f, 0.03986838f, 0.01882734f, -0.03485114f, 
    -0.00319206f, 0.03269109f, -0.03160534f, -0.02371167f, -0.04176180f, -0.03849766f, -0.04303908f, -0.00736360f, 
    0.02537864f, -0.03232478f, -0.00392651f, 0.00541947f, 0.02181379f, -0.04690227f, -0.02616991f, -0.00165169f, 
    -0.05637227f, 0.03804328f, 0.02414215f, 0.01785834f, 0.00535777f, 0.02625892f, -0.03874321f, -0.02715149f, 
    0.04606783f, -0.04139777f, -0.01086195f, 0.02933671f, -0.04785461f, -0.02291961f, 0.03359842f, -0.00194005f, 
    -0.05140070f, -0.01852033f, -0.03756995f, -0.04316719f, -0.04309614f, 0.03394287f, 0.03301472f, -0.03756781f, 
    0.00744098f, -0.04413947f, 0.04333176f, -0.03162742f, -0.05545901f, -0.02168266f, -0.00246295f, -0.00113925f, 
    0.05205771f, -0.01942931f, 0.04509196f, -0.03479687f, -0.03168729f, -0.05158032f, -0.01748771f, -0.02402472f, 
    -0.05546414f, -0.01354100f, -0.00795066f, -0.04686429f, 0.00803249f, -0.01362473f, -0.02391133f, -0.03488097f, 
    0.00168581f, 0.00057928f, 0.02783940f, 0.02818874f, -0.00350808f, -0.03930238f, 0.00151322f, -0.00575413f, 
    0.01924070f, -0.01699835f, 0.00678691f, 0.02936724f, 0.02897664f, -0.05189376f, 0.00225823f, -0.02610992f, 
    0.00532848f, 0.02830664f, -0.02902848f, 0.03701219f, 0.02354909f, 0.04608838f, 0.01813715f, 0.04348424f, 
    -0.01658079f, 0.01572496f, -0.05513696f, -0.00208843f, -0.03634380f, 0.01599659f, -0.03939541f, 0.03601297f, 
    -0.03060347f, -0.03944770f, 0.01218545f, -0.02561945f, -0.04508409f, -0.05538578f, 0.01263240f, -0.00099698f, 
    -0.02116887f, 0.02755923f, -0.03737747f, 0.02990189f, 0.04218833f, -0.03963936f, -0.05358652f, -0.03534745f, 
    0.02117775f, 0.00211392f, 0.04962710f, 0.01226997f, 0.02105979f, -0.02882964f, 0.00050489f, -0.04804306f, 
    0.02675047f, 0.01578652f, -0.05014266f, 0.04293345f, 0.04310861f, -0.01253123f, 0.02677524f, -0.00502056f, 
    0.04810194f, 0.00110596f, 0.02734758f, -0.01643141f, -0.03111910f, -0.01123575f, 0.01206125f, 0.04435002f, 
    0.03079888f, 0.02114392f, 0.04004434f, -0.01167358f, -0.02775330f, 0.04165614f, -0.01933776f, 0.02553798f, 
    0.02868464f, 0.02753327f, -0.04734652f, -0.00862052f, -0.00157194f, 0.03193087f, -0.01092843f, -0.04067026f, 
    0.01299130f, 0.02139199f, 0.04114033f, -0.00040279f, -0.00247677f, 0.04807975f, -0.05084805f, -0.04943351f, 
    -0.04966551f, -0.02655567f, -0.02753343f, -0.03955022f, -0.01100060f, -0.01871094f, 0.03414476f, -0.04642265f, 
    0.00815327f, -0.01655216f, 0.00284014f, -0.03655761f, -0.03538608f, -0.01888706f, -0.04096350f, -0.02972687f, 
    0.03009280f, -0.02435104f, 0.04280179f, -0.02490420f, 0.01357821f, -0.02499302f, -0.04549024f, -0.04179903f, 
    -0.01639665f, 0.02574109f, -0.02361263f, -0.02968944f, -0.00508356f, 0.00680733f, 0.04428683f, 0.00315865f, 
    0.00782676f, -0.04006919f, -0.01716983f, -0.04362238f, 0.05300555f, 0.03767213f, -0.01226604f, 0.01938548f, 
    0.02630999f, 0.03070172f, 0.01942578f, -0.04778260f, -0.03843446f, 0.03324927f, -0.05088294f, -0.00639107f, 
    -0.04924739f, -0.05482084f, -0.04827255f, -0.03876241f, -0.00687730f, 0.01249324f, -0.00952164f, 0.03072521f, 
    -0.04235430f, 0.04075702f, 0.02523090f, 0.03655240f, -0.03048715f, 0.03973306f, -0.01554003f, 0.00354866f, 
    -0.03435007f, -0.05234538f, 0.01988472f, 0.00678520f, -0.01957001f, 0.01735527f, -0.02468558f, -0.04929963f, 
    0.04126163f, -0.04839584f, -0.02748239f, 0.02240825f, 0.04799288f, 0.04725201f, -0.01443828f, 0.04919189f, 
    -0.03436133f, -0.04270753f, -0.05101276f, -0.01824240f, 0.01394793f, 0.02779856f, -0.02458823f, 0.03915637f, 
    0.04570933f, -0.02207099f, -0.00098589f, 0.02734702f, -0.02944785f, 0.04457762f, 0.00079517f, -0.01151056f, 
    -0.00197278f, -0.04149755f, -0.01789253f, 0.00085065f, -0.04686707f, 0.03585319f, 0.04052248f, 0.02134541f, 
    -0.01634270f, 0.02270495f, -0.01255345f, 0.02119966f, 0.02933845f, -0.04279073f, -0.04479308f, -0.04280338f, 
    -0.04417088f, 0.03118175f, -0.05339685f, 0.00420379f, -0.01255640f, 0.01173673f, -0.03506065f, -0.03995853f, 
    0.01085237f, -0.04010764f, -0.03005185f, -0.00185838f, 0.04560721f, 0.00397868f, 0.03023047f, -0.03013934f, 
    -0.01086516f, -0.04546522f, 0.02300017f, -0.02065897f, -0.01905860f, 0.03412478f, 0.02435794f, -0.03369292f, 
    -0.01158472f, -0.01287961f, -0.02341708f, -0.01066811f, 0.03790126f, -0.02491214f, -0.01020253f, 0.01237777f, 
    -0.05678247f, -0.02468071f, 0.01331844f, -0.04598938f, -0.02160035f, -0.01231353f, 0.04277376f, 0.04289192f, 
    -0.01192307f, -0.02004703f, -0.02506525f, -0.00778494f, -0.03003965f, -0.05409934f, 0.01575516f, 0.02782583f, 
    0.01102966f, -0.03938512f, -0.04313383f, -0.01239438f, -0.02483956f, -0.04070227f, -0.04738173f, -0.01077439f, 
    0.02718444f, -0.01162217f, -0.05194759f, 0.02192927f, -0.02236877f, -0.00636963f, 0.03225051f, -0.01309969f, 
    -0.03534352f, 0.01009274f, 0.04071539f, -0.04996842f, 0.02987781f, -0.01493369f, -0.03327250f, 0.01351312f, 
    -0.03334815f, 0.03882545f, 0.00808924f, 0.03484512f, 0.00586225f, 0.02136465f, -0.05393142f, 0.04132883f, 
    -0.05071352f, -0.04353013f, 0.02663392f, 0.04318569f, 0.02028971f, 0.01122363f, 0.01182741f, -0.00461493f, 
    -0.02251574f, 0.00108205f, -0.01173475f, -0.05614182f, -0.04146470f, -0.00301543f, -0.01129174f, 0.04173925f, 
    0.02884086f, -0.04222633f, 0.01962904f, -0.05097901f, -0.03624263f, -0.00795589f, -0.04704506f, -0.01394267f, 
    0.03725646f, 0.01660773f, -0.03692641f, 0.00432051f, -0.00951846f, 0.02943001f, -0.04128946f, -0.04570167f, 
    0.02680824f, 0.02655682f, -0.01700927f, -0.04585697f, 0.02687491f, -0.05125772f, 0.02261664f, -0.01034661f, 
    0.02189017f, -0.04957853f, 0.01994052f, 0.00160013f, 0.03581231f, -0.01485095f, -0.04054308f, 0.01019577f, 
    -0.05281945f, -0.00718464f, -0.05821114f, 0.01778674f, -0.03116542f, -0.01459320f, -0.04803294f, 0.01228879f, 
    0.00938000f, 0.02608429f, -0.01813681f, 0.02354413f, -0.00599294f, -0.01819663f, 0.02146150f, -0.03296417f, 
    -0.02699870f, 0.02308436f, -0.05220003f, -0.03192888f, -0.03508466f, -0.02776009f, 0.02924735f, 0.00182453f, 
    -0.01938681f, -0.03659923f, 0.01103428f, 0.01442080f, -0.04286069f, 0.01142311f, 0.00144238f, 0.03838213f, 
    -0.03563109f, -0.00867332f, -0.02588308f, -0.04646488f, -0.02301510f, 0.03032908f, 0.02047376f, 0.01615768f, 
    0.04094273f, -0.00915267f, -0.00450276f, -0.04528847f, -0.04088058f, 0.02467958f, -0.03551211f, 0.00315509f, 
    0.03321331f, -0.01524975f, -0.01026129f, 0.02834721f, 0.01058151f, -0.01675335f, -0.04735687f, 0.00025056f, 
    0.02694154f, -0.01045461f, -0.01027498f, 0.04173359f, 0.01898535f, 0.00389831f, 0.03152555f, -0.00068415f, 
    0.02152834f, -0.01063850f, 0.02744630f, 0.00333320f, -0.01783546f, -0.00348480f, -0.02681647f, -0.01965894f, 
    0.01351160f, -0.01903696f, 0.01969448f, -0.03677847f, 0.03230083f, 0.03213984f, -0.05535467f, -0.02613084f, 
    -0.03535905f, 0.02993289f, -0.02716757f, -0.03216750f, 0.00267729f, 0.04416749f, -0.01859241f, 0.04023835f, 
    0.03317282f, -0.03630887f, -0.01677171f, -0.03221131f, 0.01990093f, -0.03377172f, -0.03254511f, -0.02413432f, 
    -0.00308479f, -0.03979363f, -0.03571262f, 0.01633333f, 0.01387630f, -0.03748346f, 0.02743992f, -0.04441503f, 
    -0.03286051f, -0.01380410f, 0.00890947f, 0.04085648f, 0.04142558f, 0.04001276f, -0.04329633f, 0.01345216f, 
    0.01078711f, 0.02421468f, -0.04205952f, 0.01174281f, -0.04878071f, -0.00208665f, 0.04452574f, 0.03782305f, 
    -0.04549955f, 0.02186126f, 0.03198213f, -0.01375399f, -0.02665331f, 0.01167945f, 0.01721786f, -0.01779347f, 
    -0.02509985f, -0.02944648f, -0.02923624f, 0.03528728f, 0.02793747f, 0.00019255f, 0.00411919f, 0.00705341f, 
    0.02466955f, 0.02038009f, -0.05930719f, 0.02639604f, 0.01712212f, -0.03442907f, -0.02251442f, 0.02454143f, 
    -0.02664567f, -0.04406248f, 0.03854351f, -0.02014151f, -0.00966222f, -0.02133483f, 0.02040937f, -0.04898496f, 
    -0.04216540f, 0.03959952f, 0.02180723f, -0.03096257f, -0.04760557f, -0.04669512f, -0.02334066f, -0.02747058f, 
    0.02335816f, -0.04323423f, -0.05115757f, -0.04205734f, 0.03969679f, -0.00080601f, -0.05336896f, 0.01861988f, 
    -0.03681125f, 0.00510079f, -0.00957205f, 0.02736239f, 0.03357759f, 0.03424064f, 0.02286047f, -0.01899251f, 
    0.00420131f, -0.05343811f, -0.00276498f, -0.05479030f, -0.01850226f, -0.05950151f, 0.00126939f, -0.01010088f, 
    -0.05416979f, -0.04562220f, 0.01910563f, 0.03014305f, -0.02553157f, -0.02519001f, -0.03403442f, -0.04053923f, 
    -0.03112275f, -0.00876859f, 0.01901118f, 0.01240163f, -0.02696489f, -0.03530981f, 0.03403469f, 0.04029485f, 
    -0.02438118f, -0.05829407f, -0.01725461f, -0.04789835f, 0.01104855f, 0.01441875f, 0.02019898f, 0.00777398f, 
    0.02371609f, -0.04777646f, -0.01121518f, 0.01409415f, 0.02430862f, -0.01331328f, 0.00424343f, -0.02527339f, 
    -0.01345001f, 0.02565876f, -0.03069461f, -0.01586275f, -0.01979186f, -0.00495756f, 0.02268204f, -0.01777874f, 
    -0.00031613f, 0.02938348f, -0.04668425f, -0.02657068f, -0.00221616f, -0.02462224f, 0.04223717f, -0.01305189f, 
    0.01827000f, -0.03573505f, 0.02601344f, -0.04488260f, 0.00919092f, 0.03360885f, 0.01739380f, 0.04267721f, 
    0.01892998f, -0.03480261f, -0.03410995f, 0.01382432f, 0.03940599f, 0.03336761f, -0.02057185f, 0.03196239f, 
    -0.04358557f, 0.03925098f, 0.00403753f, -0.02516697f, 0.03183796f, -0.00743079f, -0.05290046f, -0.04999641f, 
    0.03151462f, 0.03224907f, -0.05512162f, 0.03673724f, 0.01801653f, 0.03591587f, -0.04352924f, -0.03711762f, 
    -0.00516971f, -0.03459391f, -0.03282608f, -0.04936285f, 0.01381555f, -0.02038823f, -0.03382140f, 0.01816253f, 
    -0.02982207f, -0.01399562f, 0.03775558f, -0.01379507f, 0.03634103f, 0.03824228f, 0.01346210f, -0.02784776f, 
    -0.03888236f, -0.04919595f, -0.02350751f, -0.01806163f, -0.00541975f, -0.05749640f, -0.05125839f, 0.03806115f, 
    0.00678246f, -0.02540843f, -0.10279272f, 0.01706282f, -0.09608401f, -0.02457322f, -0.02144040f, 0.10155895f, 
    0.00070978f, -0.01013735f, 0.09157456f, 0.04107516f, -0.21363588f, -0.16498512f, 0.01223120f, 0.06075608f, 
    0.00947372f, 0.08831396f, 0.00211713f, -0.07451390f, -0.07399058f, -0.11037459f, -0.04289121f, 0.03149396f, 
    0.05326649f, 0.10254747f, -0.27317587f, 0.24628720f, -0.01241066f, 0.02622603f, -0.08375542f, -0.04731638f, 
    -0.05233025f, -0.11155288f, -0.00588916f, -0.11627913f, 0.03376613f, -0.13740425f, 0.03616121f, -0.19861481f, 
    0.08062156f, -0.11005071f, -0.11756324f, -0.01626860f, -0.08951913f, 0.04788848f, -0.01132959f, 0.03044399f, 
    -0.28136727f, -0.18791680f, 0.08789720f, -0.08405266f, -0.07674155f, 0.05236453f, 0.06652020f, -0.00283591f, 
    0.08971579f, -0.04790460f, 0.00480185f, -0.16875938f, -0.02622526f, 0.05161801f, -0.11913306f, 0.12350856f, 
    0.14928901f, -0.12152577f, -0.12110519f, -0.00567433f, 0.13933790f, 0.09714644f, -0.03070487f, 0.09771479f, 
    0.11420356f, -0.00494267f, -0.02376898f, 0.08598968f, 0.06250645f, 0.03410034f, -0.02822221f, -0.02471206f, 
    0.07939418f, -0.12388207f, -0.08342324f, 0.08772599f, -0.01603775f, 0.10128479f, -0.10472344f, -0.13833129f, 
    -0.03780610f, 0.11024331f, 0.05138439f, -0.04510171f, 0.06158683f, -0.03447274f, -0.11167461f, -0.03052061f, 
    0.12186483f, -0.00180449f, -0.07629877f, -0.11667822f, -0.07373870f, 0.02453688f, -0.06408180f, -0.01658045f, 
    -0.04922066f, -0.05427543f, 0.16351902f, -0.08568515f, 0.00793118f, -0.04355708f, 0.12439337f, 0.01418332f, 
    0.19780369f, 0.07682869f, 0.18267471f, 0.02140110f, -0.01450364f, -0.03700712f, 0.07005067f, 0.05081030f, 
    0.29227322f, 0.08617352f, 0.12366135f, 0.12934501f, 0.01694318f, 0.03236004f, 0.00259553f, 0.06939389f, 
    -0.04534746f, -0.03382378f, 0.07421942f, 0.00665391f, 0.00153844f, -0.03448357f, 0.00818130f, -0.31976885f, 
    0.05747230f, 0.08703361f, 0.07304574f, 0.03952553f, 0.01477299f, -0.05143289f, 0.11700236f, -0.08150329f, 
    -0.01107975f, 0.02082304f, 0.06058326f, -0.05251880f, -0.05766067f, 0.07929884f, 0.02137978f, -0.13595909f, 
    -0.07696943f, 0.07198271f, -0.00539943f, -0.08791657f, 0.15927130f, -0.00298045f, -0.21787554f, 0.13748772f, 
    0.09826142f, -0.03878256f, 0.04508084f, 0.03077432f, 0.06467900f, -0.06878676f, -0.25975767f, 0.05260189f, 
    0.27581185f, 0.04401923f, -0.01021453f, 0.10613874f, -0.01521155f, 0.00262367f, -0.05938790f, 0.15740085f, 
    0.05639666f, 0.07341290f, 0.05454371f, -0.02100778f, 0.18561655f, 0.10239497f, 0.16157268f, 0.02795860f, 
    -0.04426119f, 0.05147766f, -0.06205344f, 0.03513387f, -0.05144472f, -0.02186955f, 0.02507835f, 0.05399781f, 
    0.23974112f, -0.15063028f, 0.20403297f, -0.01963374f, -0.13005015f, -0.11159980f, 0.10978089f, 0.07650672f, 
    0.03399387f, 0.05059978f, 0.05533178f, 0.00064738f, -0.07961648f, 0.03090552f, 0.04444344f, 0.13105787f, 
    0.01575862f, -0.00509059f, -0.17962429f, 0.05130596f, -0.05792783f, -0.15784858f, -0.00309089f, 0.13544640f, 
    -0.12144723f, -0.05076329f, -0.01987955f, 0.08679667f, 0.03254718f, 0.13626727f, 0.07347823f, 0.06905816f, 
    -0.03133688f, 0.04604357f, -0.05531088f, 0.00156200f, 0.05090199f, -0.17169912f, 0.05310296f, 0.27850726f, 
    0.07910085f, -0.04743940f, -0.09288386f, -0.05351138f, -0.02187209f, -0.03584034f, 0.07643965f, -0.03393709f, 
    -0.17074127f, -0.01624171f, 0.02911245f, 0.01794011f, 0.04886422f, 0.04238220f, -0.08127140f, 0.01552214f, 
    0.03595297f, 0.00234090f, 0.00508461f, -0.10456133f, -0.10811116f, 0.11740590f, 0.04065967f, -0.00873331f, 
    -0.01674747f, 0.01890604f, -0.09741554f, 0.05152233f, 0.11633576f, -0.00082938f, -0.07090973f, -0.00790359f, 
    0.17149633f, -0.05839070f, -0.26391560f, 0.04088670f, -0.05420627f, 0.08204649f, 0.02121781f, 0.02373207f, 
    0.05661793f, 0.01723490f, -0.06481896f, 0.04983244f, 0.16984804f, -0.10923412f, 0.18842886f, -0.01804198f, 
    0.14114085f, -0.03296332f, 0.09590995f, 0.06167275f, -0.05339848f, -0.05026390f, 0.00991481f, -0.04294135f, 
    0.22800297f, 0.21495499f, -0.12733912f, -0.02783290f, -0.09740321f, -0.02677359f, 0.06959736f, 0.04270862f, 
    -0.14342922f, 0.05610610f, -0.08629189f, -0.05504702f, 0.19527346f, 0.12388900f, -0.08659857f, 0.08755800f, 
    0.09911469f, 0.06713961f, -0.06408266f, 0.08497492f, 0.04333817f, 0.05581234f, 0.11844590f, -0.03142367f, 
    -0.20161219f, -0.02886949f, -0.20797312f, -0.16917214f, 0.01706854f, -0.00050517f, -0.00217892f, -0.06170207f, 
    0.00137206f, 0.01702701f, -0.05538521f, 0.09378175f, 0.12362000f, 0.15142606f, 0.02750930f, -0.04977113f, 
    -0.00096005f, 0.07193238f, -0.02793496f, 0.16938250f, -0.04748927f, -0.02423681f, -0.01118618f, -0.11507794f, 
    -0.05199748f, -0.08369826f, 0.11175390f, -0.02239243f, 0.03610676f, 0.06508332f, 0.07221984f, 0.18172820f, 
    0.06736959f, 0.13082497f, -0.07792713f, -0.03761908f, 0.22253855f, -0.12632467f, 0.07214908f, 0.02615810f, 
    0.00840906f, -0.02853047f, 0.03293154f, 0.05005881f, 0.08189696f, 0.02351868f, -0.05920528f, 0.10108475f, 
    0.19879051f, -0.09902062f, 0.14352013f, 0.07843284f, 0.10715532f, 0.00703219f, -0.09036461f, 0.04884319f, 
    -0.05575826f, 0.08586016f, -0.02247505f, 0.03190317f, 0.31341583f, -0.11243507f, 0.05418513f, 0.00431998f, 
    0.08038516f, -0.02288395f, 0.10480893f, 0.05322574f, 0.04503988f, 0.04934410f, 0.02382837f, 0.00647996f, 
    -0.03522396f, 0.04286931f, -0.00752712f, -0.02551466f, 0.01264618f, -0.03996426f, 0.01771188f, -0.00697986f, 
    -0.02651622f, -0.05399543f, -0.01994251f, 0.03733059f, -0.02726975f, -0.05415206f, -0.00807289f, -0.01024007f, 
    -0.04155288f, 0.02626071f, 0.04168326f, -0.01740116f, 0.02687993f, -0.02110518f, -0.05120712f, -0.00243852f, 
    -0.03266570f, 0.00228708f, -0.03925972f, -0.02163749f, 0.01496958f, 0.02164160f, -0.00733583f, 0.03319386f, 
    0.00172367f, 0.03529527f, 0.04187422f, 0.02503241f, -0.03555237f, -0.04976249f, -0.03497500f, 0.02605506f, 
    -0.05487264f, 0.00529503f, -0.02378095f, 0.01273627f, -0.01333146f, 0.01938497f, -0.03926465f, -0.00261297f, 
    0.03092739f, -0.02778399f, -0.00422124f, -0.03422698f, 0.03311278f, -0.02720983f, -0.03525343f, 0.00037658f, 
    -0.03590261f, -0.03636175f, -0.02324730f, -0.03622802f, -0.01653504f, -0.03540070f, -0.00006249f, -0.01734963f, 
    -0.00562186f, -0.01393678f, 0.01938979f, 0.01895409f, 0.03873169f, -0.04153298f, -0.00847734f, -0.03188037f, 
    -0.00494946f, -0.00517328f, -0.00185870f, -0.05559179f, -0.01521905f, -0.03564728f, 0.02138039f, 0.02300121f, 
    -0.00365469f, 0.00979668f, -0.04515417f, 0.04139295f, 0.03576485f, -0.01449757f, 0.00089415f, -0.02676587f, 
    0.02737686f, -0.04579227f, 0.02357664f, 0.05303356f, -0.02336431f, -0.02392616f, 0.00024170f, -0.03458028f, 
    0.04272745f, -0.05690961f, 0.03322100f, 0.00161125f, 0.02991876f, 0.00969416f, -0.04305732f, -0.04255951f, 
    0.04459820f, 0.03898995f, 0.00933265f, 0.02572934f, 0.00738696f, 0.00043860f, -0.02135661f, -0.01988243f, 
    0.04568847f, -0.02059964f, 0.00573677f, -0.03635321f, 0.02952738f, 0.00853876f, 0.02770469f, -0.03274550f, 
    0.01198313f, -0.04695238f, -0.04879965f, 0.00712587f, -0.02945318f, -0.03366415f, -0.02207185f, 0.03495675f, 
    0.04463809f, 0.03021551f, -0.04430684f, -0.03762836f, -0.00357042f, -0.05263247f, -0.02823860f, -0.03864002f, 
    0.00382852f, 0.03495873f, 0.02098215f, 0.00302324f, -0.03010579f, 0.00656897f, 0.03556481f, 0.04044480f, 
    0.02283522f, -0.00755050f, 0.03349636f, -0.02415074f, 0.01713420f, -0.01590101f, -0.04283731f, -0.03228081f, 
    0.02399665f, 0.02815687f, 0.01497072f, -0.04170508f, 0.00719725f, -0.00219980f, 0.03273532f, -0.05154892f, 
    -0.04046448f, -0.02710412f, 0.03909025f, 0.02342903f, -0.03127154f, -0.00595187f, 0.01729506f, -0.04433182f, 
    -0.01466803f, -0.01439300f, -0.01519416f, 0.04544140f, -0.00154023f, -0.01155635f, -0.00439682f, -0.00393723f, 
    -0.04126276f, -0.00006437f, 0.03551693f, 0.05187114f, 0.03586403f, -0.01186334f, -0.00247823f, 0.00969156f, 
    -0.04936285f, 0.03356646f, -0.00386183f, 0.01367569f, -0.00129221f, -0.01797088f, -0.02238319f, 0.01682654f, 
    -0.04727743f, -0.01884298f, 0.03213533f, -0.03962067f, 0.00808966f, -0.04150059f, 0.04313469f, -0.04374053f, 
    0.03218767f, -0.04167691f, -0.02957947f, -0.04022817f, -0.04498721f, 0.00712006f, -0.04591081f, -0.00348460f, 
    -0.01744755f, 0.02684995f, 0.01826769f, -0.02544646f, 0.02925487f, -0.02872704f, -0.03733324f, 0.00933751f, 
    -0.03136379f, 0.03966561f, -0.00474588f, 0.04106604f, -0.03247637f, -0.02832363f, -0.00452439f, 0.01694451f, 
    0.01722065f, -0.04748754f, -0.04465711f, -0.01012350f, -0.04878042f, -0.04295208f, -0.01919021f, -0.00960442f, 
    0.02357143f, 0.00337348f, -0.02602766f, 0.03859964f, 0.02938103f, -0.03917792f, -0.01452967f, 0.00037914f, 
    0.01091827f, 0.02279655f, 0.02593923f, 0.03526812f, 0.03606269f, 0.00807147f, 0.01619332f, 0.02143330f, 
    0.00426422f, 0.03475772f, -0.01850616f, 0.00187701f, -0.00023650f, -0.00665900f, 0.03831868f, -0.02529749f, 
    -0.03279654f, -0.04734281f, 0.00788019f, 0.00325741f, 0.02491536f, -0.02896201f, -0.05165449f, -0.02402077f, 
    -0.03995230f, -0.03515178f, -0.04228822f, 0.04720159f, -0.02580886f, 0.03456171f, -0.05168156f, -0.04073961f, 
    -0.02817569f, 0.04252842f, -0.02074634f, 0.01515542f, 0.00654116f, 0.00756131f, -0.00112977f, -0.02028888f, 
    -0.02629546f, -0.05325510f, -0.03609518f, -0.05329765f, -0.03984575f, -0.01649123f, 0.04399289f, -0.03139138f, 
    -0.03443862f, 0.02397702f, -0.00332455f, -0.02110379f, 0.02272600f, 0.03966892f, 0.00585111f, 0.02563632f, 
    -0.01209364f, 0.00469289f, 0.00495946f, 0.01491977f, -0.04987732f, -0.00514081f, 0.04597704f, -0.02817734f, 
    0.01083408f, 0.02656964f, 0.02053828f, -0.01108020f, -0.03135919f, 0.03391796f, -0.03477722f, -0.03274976f, 
    -0.05738091f, 0.02872157f, -0.04008054f, -0.04856572f, -0.04469444f, 0.03008351f, 0.01247127f, -0.03501245f, 
    -0.00747047f, 0.03371944f, 0.00716653f, -0.05119865f, -0.03119032f, -0.04138168f, -0.04108963f, 0.01813318f, 
    0.02874842f, 0.04803764f, 0.00146178f, -0.03509402f, -0.04488583f, 0.01170220f, -0.00117718f, -0.04210738f, 
    -0.03544075f, -0.02932910f, -0.05390748f, -0.03166119f, 0.03695241f, 0.04819370f, -0.01079410f, 0.03698843f, 
    -0.03903176f, -0.02405777f, 0.01308814f, -0.01233634f, 0.01659247f, 0.03249406f, 0.01817115f, 0.03029599f, 
    -0.01917168f, -0.02717243f, -0.05186212f, 0.04374803f, 0.00928378f, -0.02468430f, 0.02335137f, -0.01900618f, 
    0.03499099f, -0.01660313f, -0.00910878f, -0.00130805f, 0.00039490f, -0.04271694f, -0.04245677f, -0.03321034f, 
    0.00242894f, 0.00319462f, -0.01894282f, 0.02531726f, -0.02752888f, -0.04288249f, -0.02287531f, 0.02391812f, 
    -0.03596214f, 0.03353301f, 0.01280350f, 0.00677483f, 0.04582683f, 0.03915844f, 0.00270430f, 0.04196712f, 
    0.16011734f, 0.15311745f, -0.04671895f, 0.21155573f, -0.19221415f, -0.03747738f, 0.04143164f, 0.11201510f, 
    0.14587367f, -0.06519888f, -0.04970293f, -0.03361133f, -0.09472207f, -0.02660403f, 0.06534855f, -0.00254074f, 
    0.16444656f, 0.16874477f, -0.05579297f, -0.07212549f, 0.07238214f, -0.19912924f, -0.03710680f, -0.10410980f, 
    -0.30701721f, -0.13122739f, -0.07751882f, 0.15923680f, 0.06174144f, 0.00441580f, -0.04420070f, 0.02863984f, 
    -0.06998820f, -0.09538677f, -0.12584972f, -0.17596123f, 0.28082675f, 0.01258623f, -0.03693922f, 0.03261036f, 
    0.01044606f, -0.09779339f, -0.05528298f, 0.06702336f, 0.01725264f, 0.12702538f, 0.04285477f, -0.05868804f, 
    0.05833337f, -0.04005088f, -0.07198685f, -0.05698958f, -0.06652813f, 0.20535955f, -0.07259367f, 0.07518461f, 
    0.05770534f, 0.14569411f, -0.08554548f, -0.03340221f, -0.06631592f, -0.18567750f, -0.14458095f, 0.05292691f, 
    0.05756696f, -0.02029563f, 0.00512214f, 0.06266255f, -0.03939560f, 0.02027352f, -0.03108229f, 0.22897750f, 
    0.07104362f, 0.00092109f, -0.01667868f, -0.17708406f, 0.08778909f, 0.01436950f, -0.13891940f, -0.07129758f, 
    0.01427097f, -0.15759765f, -0.09031495f, 0.11647858f, -0.40400720f, 0.03159760f, 0.07593267f, -0.05722293f, 
    0.06529060f, 0.08209990f, -0.02475222f, -0.03548049f, 0.12523463f, -0.13908814f, -0.00500312f, -0.02934864f, 
    -0.26489541f, 0.29665735f, 0.14315602f, 0.04480465f, 0.05513493f, -0.05607498f, -0.01480998f, -0.02748356f, 
    -0.09832655f, -0.13563506f, 0.03389341f, 0.00633557f, -0.15442584f, -0.43224198f, 0.11443497f, 0.03278572f, 
    0.14050949f, -0.02766779f, 0.07338846f, 0.02598606f, -0.09907382f, 0.12545839f, 0.13698618f, 0.16677769f, 
    0.15475832f, 0.12448958f, 0.13386162f, -0.00309148f, 0.03583985f, 0.04311562f, 0.11578112f, -0.04183596f, 
    0.12953080f, -0.13688688f, 0.12475780f, 0.09805986f, -0.18971430f, 0.43537369f, -0.05874310f, -0.15390572f, 
    0.00256291f, 0.08815101f, 0.19080187f, 0.02071687f, 0.04089641f, -0.01733756f, 0.08476974f, 0.02440726f, 
    -0.00703575f, -0.09561719f, -0.03971947f, 0.08043211f, -0.05479138f, -0.00512485f, 0.06616443f, -0.09736492f, 
    0.00547327f, -0.07049850f, -0.02313785f, -0.02971305f, 0.45914862f, 0.11987820f, -0.01607257f, 0.18549503f, 
    -0.01443266f, -0.02534312f, 0.03643661f, 0.12995802f, 0.08665890f, 0.03241945f, -0.09962743f, 0.05583867f, 
    -0.04598368f, 0.11461116f, -0.02392512f, -0.01452704f, 0.00669448f, 0.04606087f, 0.09461255f, 0.04332384f, 
    0.09037627f, 0.00994300f, 0.05652368f, 0.04893658f, 0.01377858f, -0.17122921f, -0.00426376f, -0.00844670f, 
    -0.05502559f, 0.09762476f, 0.10598122f, 0.00896074f, -0.00005258f, -0.09506255f, 0.03941876f, -0.01133525f, 
    0.19516383f, -0.01012232f, 0.09925255f, 0.22060166f, -0.03938373f, 0.01128940f, 0.10753493f, 0.10893967f, 
    -0.13013805f, 0.05947233f, -0.06557599f, -0.00069991f, -0.00789487f, 0.04721693f, -0.02790523f, -0.04599564f, 
    0.00100321f, -0.01980089f, -0.06589495f, -0.00941393f, -0.10547753f, 0.06214955f, 0.04061688f, 0.19008391f, 
    -0.12292753f, 0.07900345f, -0.03594334f, -0.14361940f, -0.07638810f, -0.00690810f, 0.00547834f, 0.12662594f, 
    0.02211296f, -0.04302570f, 0.06516083f, -0.00357509f, 0.36937517f, -0.29931948f, 0.16747189f, 0.22515614f, 
    -0.07996359f, 0.05718382f, -0.10088471f, 0.02708804f, -0.01564432f, -0.16951479f, -0.03989533f, -0.09045436f, 
    -0.04750741f, 0.05299929f, -0.00120401f, -0.11218083f, -0.09129236f, 0.09990533f, -0.03304171f, -0.08347110f, 
    -0.04329130f, 0.03347529f, -0.02825769f, -0.14960374f, 0.14209512f, 0.03321078f, 0.01220483f, -0.15326859f, 
    0.07810469f, 0.07104730f, -0.03727870f, 0.06046160f, 0.04189054f, 0.07186208f, -0.11484237f, 0.02850692f, 
    -0.03220766f, -0.08866603f, -0.08375598f, 0.14486186f, -0.21749243f, 0.06348071f, 0.11385711f, 0.11720095f, 
    0.01521603f, -0.04572872f, 0.01151314f, -0.03224571f, 0.21505071f, -0.06807805f, 0.11650430f, -0.06133409f, 
    -0.03179218f, 0.04229855f, 0.03445645f, 0.13197769f, -0.04101558f, 0.06478747f, 0.09824446f, 0.00015720f, 
    0.40843442f, -0.07208020f, 0.13309646f, 0.29086491f, -0.07933129f, 0.06403358f, -0.02975924f, 0.07389135f, 
    -0.00061732f, 0.01002532f, -0.02303992f, -0.03851631f, -0.12930265f, 0.09866586f, -0.00395791f, -0.07428615f, 
    0.08869875f, -0.16032971f, 0.04271511f, -0.16607973f, 0.02067890f, 0.10128638f, 0.05642968f, -0.09570794f, 
    0.07335476f, 0.10882793f, -0.08583634f, -0.16189367f, -0.02731750f, 0.00836159f, 0.17796752f, 0.08666707f, 
    0.09669279f, 0.06419185f, 0.18198381f, 0.10438314f, 0.08726178f, 0.05484783f, 0.00286410f, -0.03121820f, 
    0.02181752f, 0.13452481f, -0.12420657f, 0.07463771f, 0.09266370f, -0.04294013f, -0.02690936f, -0.02076829f, 
    -0.01967905f, -0.10054699f, 0.08307930f, 0.18099815f, 0.06791211f, 0.10322886f, 0.04477716f, 0.16168478f, 
    0.05891146f, -0.03099180f, -0.20935145f, -0.11685693f, 0.07801187f, -0.28917426f, -0.10549584f, -0.10714355f, 
    0.00171917f, -0.00913674f, 0.24152686f, -0.01284389f, 0.04621263f, -0.05556456f, 0.04359963f, 0.02419441f, 
    0.06995702f, -0.21499352f, -0.00660047f, -0.00477525f, -0.00026120f, -0.05247320f, -0.08080622f, 0.07663317f, 
    -0.07021630f, 0.07520735f, -0.15425824f, -0.00367604f, 0.08792564f, 0.18003884f, -0.01073689f, -0.10666648f, 
    -0.08222626f, -0.04436892f, 0.07096449f, 0.12618692f, 0.06579126f, 0.02631469f, -0.05349541f, 0.02294525f, 
    -0.24958618f, -0.01736073f, 0.03373034f, -0.12655570f, 0.01409671f, -0.12099089f, -0.05123491f, 0.03507357f, 
    0.17638774f, -0.05685290f, -0.05174628f, -0.08900341f, 0.04465808f, 0.11768902f, 0.03176899f, 0.02835913f, 
    0.04003769f, -0.06870016f, 0.09998816f, 0.05423315f, 0.07980523f, -0.13777898f, -0.11827394f, -0.14043233f, 
    -0.03101108f, -0.06624310f, 0.13281082f, -0.02438919f, 0.02444062f, -0.09528631f, -0.02530945f, 0.05827918f, 
    -0.12445815f, 0.07520979f, -0.08473109f, -0.12427420f, -0.10905880f, 0.00766453f, -0.02354865f, -0.15321989f, 
    0.03924888f, 0.00122830f, -0.12711762f, 0.10406994f, 0.13606502f, 0.08198523f, 0.10398098f, -0.00498928f, 
    0.23077030f, 0.15577319f, -0.01688916f, -0.13458273f, 0.12108157f, 0.12503660f, -0.08587816f, 0.04501132f, 
    0.22011764f, 0.03012299f, -0.05126099f, -0.01222894f, -0.11934867f, -0.09304518f, 0.09312238f, 0.01470259f, 
    0.04953561f, -0.13656461f, 0.09721292f, 0.04461219f, 0.03159655f, 0.06517376f, 0.00964114f, 0.21188065f, 
    0.15173188f, -0.11762224f, 0.02685582f, -0.03746068f, 0.09593671f, 0.01292957f, 0.16206887f, -0.06062052f, 
    -0.06515341f, -0.00748592f, -0.09386974f, -0.07028293f, 0.03044795f, -0.17046753f, -0.08636045f, -0.09737131f, 
    0.10726138f, 0.06195799f, -0.00231920f, -0.00773009f, -0.05347888f, -0.01656663f, 0.03375051f, -0.03658145f, 
    -0.32520688f, 0.06881429f, 0.19539270f, 0.07781361f, 0.00762052f, 0.07171888f, 0.03415004f, 0.04799393f, 
    0.09447318f, -0.05310491f, 0.03024489f, -0.05964466f, -0.34279686f, -0.04024976f, 0.06652381f, 0.14094794f, 
    -0.11071883f, 0.07564754f, 0.09258489f, 0.05191240f, -0.04759710f, 0.00083664f, 0.07129632f, 0.05212687f, 
    0.04296293f, -0.05576035f, 0.18694028f, -0.05885228f, -0.01730495f, -0.02494393f, 0.06806103f, 0.03642429f, 
    0.10738811f, -0.07254998f, -0.00226776f, -0.05972181f, -0.00060623f, 0.03604108f, 0.04056257f, 0.07516503f, 
    0.03053500f, -0.05802385f, 0.04590868f, -0.05260592f, -0.02007830f, 0.07443853f, 0.00753969f, 0.03614621f, 
    -0.07662570f, -0.13223656f, 0.13079506f, -0.01921751f, 0.19762518f, 0.02672622f, 0.00607398f, -0.03124098f, 
    -0.11911554f, 0.08996187f, -0.09328468f, -0.03783792f, -0.11191583f, -0.02264015f, -0.00502897f, -0.07320683f, 
    -0.04419687f, -0.03070606f, 0.03174397f, -0.03949074f, -0.04756293f, 0.08308813f, 0.03081338f, 0.10680322f, 
    -0.24399020f, -0.13485879f, 0.09785741f, 0.11145454f, -0.06236737f, -0.00934254f, 0.05631994f, 0.08931176f, 
    -0.00852308f, 0.16461353f, 0.15502933f, 0.03676648f, -0.14859644f, 0.01690449f, 0.23711762f, -0.04556480f, 
    -0.05870737f, 0.11288463f, 0.05428678f, -0.03696307f, -0.04015273f, 0.01229856f, 0.04663569f, 0.01628453f, 
    -0.39192984f, -0.04182293f, -0.08605356f, 0.07837019f, -0.07624268f, -0.01952332f, 0.04508869f, 0.08296137f, 
    0.08795016f, 0.08452971f, -0.02282450f, 0.06181021f, -0.00095740f, 0.11628649f, -0.07518911f, 0.02328829f, 
    0.13529795f, 0.05033064f, -0.02439551f, -0.11125513f, -0.03014076f, 0.11361625f, 0.15868375f, 0.12637973f, 
    0.09669852f, 0.06637132f, 0.01980222f, 0.12623568f, 0.10625507f, 0.14058706f, 0.04517815f, 0.00233299f, 
    0.00872274f, -0.00502502f, 0.04523908f, -0.10665406f, 0.12917195f, 0.17888243f, -0.16404007f, 0.06071106f, 
    -0.09881512f, 0.01449443f, 0.18226096f, 0.05729223f, 0.07685278f, -0.10286982f, -0.00607309f, -0.05360576f, 
    0.33700383f, 0.16503872f, 0.10239273f, -0.10860712f, -0.00676765f, -0.05271862f, 0.02327188f, -0.06878393f, 
    -0.00540511f, 0.07970583f, 0.24964483f, -0.03499954f, 0.37798014f, 0.14922215f, -0.07922635f, -0.18417090f, 
    0.17913464f, 0.01888884f, 0.04818483f, 0.00907321f, 0.02793196f, -0.03492210f, 0.06200064f, -0.03559434f, 
    0.11296752f, -0.20568401f, -0.11849330f, -0.10988057f, 0.02324653f, -0.10586601f, 0.09194162f, 0.00549147f, 
    0.04815982f, -0.00375291f, 0.07393823f, 0.02600237f, -0.14336236f, 0.11852806f, -0.02615860f, 0.10484032f, 
    -0.04624762f, 0.00375187f, 0.10471149f, 0.05775096f, 0.15424159f, -0.07053260f, 0.07710450f, 0.03402107f, 
    -0.24770011f, 0.13509971f, -0.16759169f, -0.20173594f, 0.01082998f, -0.01578562f, -0.09655508f, 0.01103739f, 
    0.02774289f, -0.05999818f, -0.00560991f, -0.00245371f, 0.20964861f, -0.08390383f, 0.04358269f, 0.01439065f, 
    -0.04487482f, -0.17413996f, 0.01239978f, 0.08016612f, 0.02490921f, 0.06151071f, 0.16136518f, 0.03107242f, 
    0.04256315f, -0.06170511f, 0.13719189f, -0.11669146f, -0.01759552f, 0.05258165f, 0.01780787f, -0.00936703f, 
    0.23841803f, 0.04409484f, 0.06027178f, 0.09240624f, 0.04341854f, -0.02814181f, 0.05940076f, -0.06685061f, 
    -0.11399667f, 0.05580699f, 0.04968912f, 0.14037307f, 0.03314313f, -0.03781124f, 0.07218264f, -0.00018958f, 
    0.09194838f, 0.09035606f, 0.04380528f, 0.01955744f, 0.07376938f, 0.05168530f, -0.05450171f, 0.05720634f, 
    -0.01328969f, 0.00810555f, -0.08375659f, -0.15176703f, -0.13642845f, -0.13474797f, -0.31638572f, 0.18733139f, 
    -0.04751691f, 0.02327332f, 0.27145836f, 0.00770533f, 0.06337111f, -0.00579271f, 0.04518298f, 0.11133488f, 
    -0.15506229f, -0.24852994f, 0.03112005f, 0.15599069f, -0.13669781f, -0.07030501f, 0.05602553f, -0.01957050f, 
    -0.07635338f, -0.01894457f, -0.10608307f, 0.09283891f, -0.07632612f, 0.16800131f, 0.00493736f, -0.03771763f, 
    -0.13982998f, -0.09720959f, 0.16936885f, 0.10732500f, -0.05972410f, 0.05911637f, -0.00259695f, 0.00375073f, 
    -0.09091845f, -0.22904845f, 0.01231120f, 0.10950676f, 0.02448563f, 0.16066571f, 0.09631249f, 0.06194409f, 
    -0.02065144f, -0.04085303f, 0.10428307f, -0.01376939f, -0.35442790f, 0.13204835f, 0.20326188f, 0.23639660f, 
    0.03077994f, -0.05882432f, -0.04926279f, 0.04982364f, -0.00334542f, -0.05051253f, -0.01414333f, 0.13543049f, 
    -0.24581838f, 0.10589623f, 0.31034654f, -0.00852839f, 0.11368545f, -0.04379189f, 0.00532617f, -0.03342258f, 
    0.00661863f, 0.07098488f, -0.01947316f, -0.00605992f, 0.05868889f, -0.12592624f, 0.06139063f, 0.09682970f, 
    -0.13300109f, 0.08672947f, -0.09862713f, 0.02701765f, 0.10154084f, -0.11394670f, -0.00643295f, 0.05369125f, 
    0.20453501f, 0.07924564f, 0.08541378f, 0.12268428f, -0.04487986f, -0.00421830f, 0.07962569f, -0.08060090f, 
    0.01610084f, -0.04771950f, -0.00871996f, 0.08447285f, -0.23122063f, -0.07400295f, 0.06426087f, 0.02527678f, 
    0.13026664f, 0.01488454f, 0.05346458f, 0.01796046f, -0.03051972f, -0.03584928f, 0.11778264f, -0.10863934f, 
    -0.29883385f, -0.07240969f, 0.03012571f, 0.02210781f, 0.12312215f, 0.18405886f, 0.06359008f, 0.12431123f, 
    0.02179997f, 0.02086671f, 0.08918522f, -0.03384689f, 0.41972926f, -0.11491665f, -0.03082985f, -0.13635334f, 
    -0.03637764f, -0.00979679f, 0.01907450f, -0.04226223f, -0.04333862f, -0.03194294f, 0.05956928f, 0.13138293f, 
    -0.41977629f, 0.07613974f, 0.18592006f, 0.04069114f, -0.04944694f, -0.05610828f, 0.07047663f, -0.03314601f, 
    -0.02022362f, -0.00796667f, -0.07783113f, -0.01984430f, -0.23243786f, 0.03215718f, 0.00876048f, 0.17404220f, 
    -0.01540994f, -0.03469570f, 0.03945498f, -0.02853324f, -0.02159829f, 0.07346396f, 0.10387919f, 0.00574894f, 
    -0.26012608f, 0.03459510f, -0.03407752f, 0.19689153f, -0.06273616f, -0.06684320f, 0.04992086f, -0.01970014f, 
    0.07574175f, -0.00166152f, -0.01221512f, -0.04566235f, 0.12143532f, -0.00768893f, 0.11591732f, 0.16709773f, 
    -0.04881232f, -0.06893563f, -0.03153156f, -0.00490267f, 0.02331087f, 0.05890753f, 0.01687710f, 0.08628601f, 
    0.44251698f, -0.10033635f, 0.09466677f, -0.11929093f, -0.00695602f, 0.12396304f, -0.03170894f, 0.12486523f, 
    0.13433395f, -0.01131295f, 0.06371342f, 0.03003221f, 0.17851380f, 0.02279616f, -0.10120109f, 0.04142819f, 
    0.04123116f, 0.03413326f, 0.12681319f, -0.10855862f, 0.12613478f, -0.05222678f, 0.05654019f, -0.02900577f, 
    -0.31640893f, 0.14901373f, 0.03124925f, 0.10515095f, -0.04587276f, -0.00531249f, 0.08028261f, -0.22344729f, 
    -0.04920638f, 0.14803338f, 0.06343351f, -0.15808146f, -0.37574878f, 0.14844637f, 0.11420141f, 0.15426980f, 
    0.07967585f, -0.01474555f, -0.20433575f, 0.04382693f, -0.02962704f, -0.02070934f, -0.04262049f, -0.02924058f, 
    0.11143995f, -0.03521601f, -0.07685132f, -0.04278340f, 0.02598406f, 0.16633824f, -0.08805332f, 0.00581716f, 
    -0.08495187f, -0.03663409f, -0.13859822f, -0.07155129f, -0.01359417f, 0.08515361f, -0.08721401f, 0.07280949f, 
    -0.06566607f, -0.09207174f, 0.07430627f, -0.01446219f, 0.05088127f, 0.03542732f, 0.06011947f, -0.03341768f, 
    -0.12626597f, 0.10966906f, 0.10934385f, 0.14235090f, 0.10140071f, -0.02803348f, 0.01852965f, 0.05942448f, 
    0.05509139f, 0.07025927f, 0.05148015f, 0.08954760f, 0.01542059f, 0.34470916f, 0.01474906f, 0.06360433f, 
    0.02214583f, -0.01162045f, 0.11392958f, -0.08283963f, 0.01105638f, 0.01806168f, -0.06292906f, -0.02940791f, 
    0.27406007f, 0.10766588f, 0.04426284f, -0.04221649f, -0.03951350f, -0.04309906f, 0.09494828f, -0.13926543f, 
    0.05301505f, 0.00659327f, 0.03384657f, 0.17251730f, -0.01280915f, -0.01999971f, 0.02932379f, -0.10168830f, 
    0.08027668f, -0.05726485f, 0.06754656f, 0.06602812f, -0.08319981f, 0.13138288f, 0.06782579f, 0.15943073f, 
    -0.00134418f, -0.05431938f, 0.04929353f, -0.17552362f, 0.17966568f, -0.14476153f, 0.10949263f, 0.04147461f, 
    -0.00311721f, -0.04479941f, 0.05217797f, 0.09026506f, -0.30556908f, 0.08924380f, -0.08519202f, 0.12717946f, 
    0.07068846f, 0.05312686f, 0.06688251f, -0.06277212f, 0.03200943f, 0.05608198f, 0.06052004f, 0.00913051f, 
    -0.05577119f, -0.05511991f, -0.02805175f, 0.21462375f, 0.15651864f, -0.00722296f, -0.00065946f, -0.04460558f, 
    0.05680089f, -0.16498338f, -0.10141478f, 0.05566148f, 0.08910543f, 0.08595642f, -0.01792935f, 0.21298097f, 
    -0.00356859f, -0.03313100f, -0.02514228f, 0.02739406f, -0.09753487f, 0.01066528f, 0.05080800f, -0.03420670f, 
    0.14773537f, -0.00083254f, 0.20676132f, -0.01587456f, -0.12866566f, -0.02434258f, -0.03911888f, -0.05259391f, 
    0.09872588f, -0.12065894f, 0.10656969f, 0.00591135f, 0.21478641f, -0.13491009f, 0.01464552f, 0.04860459f, 
    0.01772973f, 0.03796443f, -0.01573221f, 0.08317953f, 0.10195437f, -0.11742573f, 0.06804895f, 0.03919303f, 
    -0.20897633f, 0.07901870f, -0.01158896f, 0.27453867f, 0.06308235f, -0.09013769f, -0.04528632f, 0.00600457f, 
    0.08068056f, 0.03606810f, -0.07628840f, 0.00262273f, -0.00754033f, 0.13242474f, -0.43602249f, 0.34294859f, 
    -0.06019031f, -0.03342908f, -0.08936050f, -0.14827922f, 0.00650349f, 0.08601416f, 0.08096403f, -0.03729840f, 
    -0.21252809f, -0.10486940f, 0.09639508f, -0.03639058f, -0.07275151f, 0.00859711f, 0.01494386f, -0.03875633f, 
    -0.10172485f, -0.07417370f, 0.09017792f, 0.01112933f, 0.17608696f, -0.03894430f, 0.06094159f, 0.07333963f, 
    -0.12415005f, 0.03665838f, 0.02214763f, 0.15818806f, 0.00942843f, -0.02636341f, -0.06209233f, 0.13522536f, 
    0.00258497f, 0.03276996f, -0.03856590f, 0.01206766f, -0.04472584f, -0.01644012f, -0.03233831f, 0.03969778f, 
    -0.03349204f, -0.02502787f, -0.02612215f, 0.03881670f, 0.02238378f, -0.04972647f, 0.03921787f, 0.04082351f, 
    0.04967214f, -0.04046794f, 0.03012287f, 0.02096262f, -0.01358729f, 0.00739374f, -0.04788017f, -0.03394132f, 
    -0.05551369f, -0.00575931f, -0.00631464f, -0.01115576f, -0.02889195f, 0.03737220f, 0.03232405f, -0.00003159f, 
    -0.04901443f, 0.02383622f, 0.01602194f, 0.03272031f, -0.04795963f, -0.04699195f, 0.02454315f, -0.04540346f, 
    -0.00017102f, 0.03755055f, 0.00085029f, 0.03628526f, 0.00221127f, -0.04141808f, -0.02982341f, 0.00528541f, 
    -0.03985146f, -0.03632277f, 0.02212131f, 0.04410572f, -0.02187546f, -0.05333541f, -0.04236038f, -0.03960916f, 
    0.01863252f, 0.01412783f, -0.00994153f, 0.02165470f, 0.03596988f, -0.04258285f, -0.04275305f, -0.04789691f, 
    0.02739091f, -0.04653847f, -0.04076621f, -0.03628989f, -0.04314366f, 0.03476643f, -0.01267716f, 0.03094069f, 
    0.02773835f, -0.02809754f, -0.05681433f, 0.00662497f, 0.01773534f, -0.02774371f, -0.03523928f, 0.02280888f, 
    -0.05415532f, 0.00903012f, 0.02737488f, -0.05595874f, -0.04788625f, -0.05276689f, 0.02240615f, 0.00927711f, 
    -0.05126880f, 0.03074573f, -0.05681087f, -0.05126593f, 0.03187142f, -0.00164135f, 0.03911867f, -0.03518930f, 
    -0.03744683f, 0.04393653f, -0.04458756f, 0.02565129f, -0.01796853f, 0.03887991f, -0.03791975f, -0.01105001f, 
    0.00162263f, -0.02014446f, -0.04585683f, 0.02609518f, -0.02739260f, 0.00103627f, -0.01071593f, 0.01220390f, 
    0.04129880f, 0.01797432f, -0.01079840f, 0.01518051f, -0.03634043f, 0.01975153f, 0.00770193f, 0.01174282f, 
    0.01993932f, 0.01481486f, -0.05167246f, -0.00104865f, 0.02617760f, -0.00445442f, 0.01678353f, -0.04370357f, 
    0.01908940f, -0.04540649f, 0.02062556f, 0.02243339f, -0.01964385f, 0.01233682f, -0.04877717f, 0.00443539f, 
    -0.03230176f, 0.01664904f, -0.00251916f, 0.03268743f, -0.00255427f, -0.04485313f, 0.00350903f, -0.04100786f, 
    0.00861627f, 0.02875057f, 0.02568258f, -0.01075355f, -0.00364302f, 0.02740471f, -0.01775946f, 0.02980525f, 
    -0.01971050f, 0.02422949f, 0.03198023f, 0.00065322f, 0.04364653f, 0.02509860f, 0.03300618f, -0.02878621f, 
    0.04249512f, -0.01301853f, -0.05376147f, -0.01166128f, -0.04870825f, -0.00692060f, -0.00487657f, -0.02495040f, 
    0.02210600f, -0.04793843f, -0.01608283f, -0.03982905f, -0.03396108f, 0.01462130f, -0.02053018f, 0.02208161f, 
    0.03682931f, -0.01029894f, 0.04286383f, -0.00199518f, -0.03330762f, 0.05321448f, 0.02900274f, 0.03905230f, 
    -0.03075397f, -0.02989074f, 0.04573866f, -0.03077354f, -0.04246605f, -0.04688627f, -0.02776229f, -0.04292576f, 
    -0.04450972f, 0.01251240f, -0.01680163f, -0.00220070f, 0.00130276f, -0.04304758f, 0.01675442f, -0.04665771f, 
    -0.02285078f, -0.00226158f, -0.00099353f, -0.03096103f, 0.01208211f, -0.03421938f, 0.03115959f, 0.02141603f, 
    0.03117719f, -0.02847234f, -0.05020226f, 0.02554771f, -0.03851589f, -0.00355778f, 0.02384547f, -0.04396725f, 
    -0.03833141f, 0.01707783f, 0.00023399f, -0.01835688f, -0.00961902f, 0.02936001f, -0.03286722f, -0.04422636f, 
    0.03351824f, 0.01398020f, 0.01611349f, 0.03154711f, 0.01029954f, -0.02624183f, -0.01432692f, -0.01417709f, 
    0.01629050f, -0.03242675f, -0.03098878f, -0.05023428f, -0.01714587f, -0.02645574f, 0.04231676f, -0.01002426f, 
    -0.02144197f, -0.03899531f, -0.00217344f, -0.04015708f, -0.01696794f, 0.04830807f, -0.01690764f, -0.00283430f, 
    -0.03591030f, -0.01278194f, -0.02480648f, 0.02941060f, 0.01396548f, -0.04794457f, 0.01197000f, -0.00311984f, 
    0.03539110f, -0.03010841f, 0.01565920f, -0.04384865f, -0.03923187f, -0.04721349f, 0.00803982f, 0.02836490f, 
    -0.04932548f, -0.05022502f, 0.02431150f, -0.03113418f, -0.01324188f, -0.03929982f, 0.00559013f, 0.03767893f, 
    -0.01727219f, 0.02270997f, -0.03791373f, 0.03661769f, -0.00544290f, -0.01618902f, -0.02521732f, 0.01984677f, 
    -0.03330863f, -0.03769305f, 0.02657597f, -0.02671687f, 0.01161884f, 0.01691797f, 0.02805560f, 0.02801398f, 
    0.02115456f, -0.02295632f, 0.01216980f, 0.01049074f, 0.00636877f, 0.01242332f, -0.02765921f, 0.04027434f, 
    -0.03883380f, 0.00798587f, -0.05260717f, -0.02823216f, 0.02228338f, 0.01917923f, 0.02718528f, -0.02171838f, 
    -0.03133443f, -0.02808216f, 0.01869607f, -0.01126263f, 0.01214679f, -0.04763443f, 0.01155438f, 0.00938968f, 
    -0.03643167f, 0.03078589f, -0.04242407f, -0.03521087f, 0.01497692f, -0.05722683f, 0.03605742f, 0.04214944f, 
    -0.02583284f, -0.04060687f, -0.00146316f, 0.03071633f, 0.03038068f, 0.00950057f, 0.00867659f, -0.05542742f, 
    -0.00552152f, -0.04874681f, -0.01047045f, 0.01235720f, -0.00510367f, 0.01239072f, -0.00185660f, 0.00309322f, 
    0.00396788f, -0.04206847f, -0.02445219f, 0.04117915f, -0.02772730f, -0.02294075f, 0.04262275f, -0.01938377f, 
    -0.02943299f, -0.03834587f, -0.04477635f, 0.01452823f, 0.02201721f, 0.02769930f, 0.02776995f, -0.04327268f, 
    -0.03172889f, -0.02925055f, 0.04974173f, -0.02667271f, 0.03242170f, -0.02149031f, 0.02547728f, -0.00290202f, 
    -0.04240411f, -0.02342069f, -0.04743699f, -0.02420770f, 0.04137858f, 0.00885453f, 0.00681482f, 0.02410632f, 
    0.04941627f, -0.02076341f, 0.01233311f, -0.02483854f, 0.03171309f, 0.03409318f, -0.04672685f, 0.00592832f, 
    -0.02855148f, 0.00363342f, -0.00918004f, -0.04577224f, 0.00884778f, -0.03100297f, -0.02759306f, 0.01074109f, 
    -0.01341999f, 0.00998170f, 0.03354501f, 0.00330250f, 0.03621054f, 0.00149270f, 0.01701722f, 0.00658152f, 
    0.02815201f, 0.03120389f, -0.00151553f, -0.02268544f, 0.00203680f, 0.02067607f, 0.00206392f, -0.04348193f, 
    0.03486341f, -0.00499140f, 0.03922721f, -0.03979855f, -0.01272844f, -0.03990133f, 0.00306002f, -0.05684953f, 
    0.00170564f, -0.00464233f, -0.00551712f, 0.02296348f, -0.01930027f, 0.02646319f, -0.00608908f, 0.02386183f, 
    0.02236385f, 0.04515077f, -0.03887943f, -0.03950355f, -0.05228032f, 0.01828362f, 0.03314094f, -0.03501962f, 
    0.01652490f, -0.03917311f, -0.04075659f, 0.03650546f, -0.04687464f, -0.03026937f, -0.05876732f, -0.01081068f, 
    0.01945451f, -0.02390139f, 0.00713716f, -0.05180133f, -0.04643049f, -0.01708543f, -0.03946359f, 0.02095618f, 
    0.03546320f, 0.00708842f, -0.03678305f, 0.00170017f, 0.02258581f, 0.01656087f, 0.00046339f, -0.00383248f, 
    -0.02264485f, -0.03762372f, -0.01324391f, 0.01213507f, 0.03171628f, -0.01233787f, 0.01926571f, -0.05468930f, 
    0.02927027f, 0.01833080f, 0.04560883f, -0.01985776f, -0.00522453f, -0.04892194f, -0.04894209f, -0.00547355f, 
    -0.00760925f, 0.01764397f, -0.04010862f, -0.00714272f, 0.01046886f, 0.03154183f, 0.01152043f, -0.03505750f, 
    -0.05582370f, -0.03764262f, 0.03685689f, -0.03451287f, 0.00183143f, 0.00402199f, -0.05682498f, 0.03210574f, 
    -0.00419813f, -0.00883171f, -0.00229924f, -0.04656741f, -0.00522233f, 0.02680869f, -0.00224013f, 0.01593592f, 
    -0.04514199f, -0.01810837f, 0.01159405f, 0.02357322f, -0.04739955f, 0.03424153f, 0.00334648f, -0.00316959f, 
    -0.00573095f, 0.03408893f, -0.05565819f, -0.01846540f, 0.04218815f, 0.03614474f, 0.03078196f, -0.03283458f, 
    -0.03903295f, 0.02604774f, 0.01911971f, -0.00993403f, -0.02542961f, -0.04753602f, -0.01848586f, 0.01929892f, 
    0.04212482f, -0.04473861f, -0.00857789f, 0.03005727f, -0.01442854f, -0.02684490f, 0.01020242f, -0.05322526f, 
    -0.03008796f, -0.03852508f, -0.02461561f, -0.03722000f, 0.01623722f, -0.03561785f, 0.03255057f, 0.00865888f, 
    -0.04406265f, -0.05106583f, 0.01927865f, 0.00971462f, 0.03180006f, 0.01732400f, -0.03094195f, 0.02584429f, 
    -0.00421387f, 0.00529644f, -0.01683139f, 0.03874166f, 0.03596049f, 0.01144978f, 0.01624904f, 0.00330532f, 
    -0.03805490f, 0.02917379f, -0.03887618f, 0.03684322f, -0.01804437f, 0.03169473f, -0.00714595f, 0.00181838f, 
    0.02258293f, 0.02194369f, 0.04518996f, -0.03805959f, 0.00226467f, -0.05546982f, -0.04424103f, 0.01467134f, 
    -0.01886072f, -0.00488647f, 0.01067413f, -0.03130540f, 0.02966776f, -0.04244363f, -0.01984270f, 0.01093442f, 
    -0.04022829f, -0.04352510f, 0.02587195f, -0.02720784f, -0.00354525f, 0.03636470f, -0.05484877f, 0.01510988f, 
    -0.01084871f, -0.01578680f, -0.05515818f, -0.01761899f, 0.03343984f, -0.04998713f, -0.04211169f, 0.01376591f, 
    0.01847497f, -0.00735521f, -0.00235439f, -0.03150635f, 0.04329171f, -0.01004304f, -0.03784426f, -0.01377988f, 
    -0.04908664f, -0.00662160f, -0.00183671f, 0.00304523f, -0.01198062f, -0.00308232f, -0.04859918f, 0.02859573f, 
    0.02451681f, 0.00306718f, 0.00686260f, 0.01955275f, -0.02368096f, 0.03518480f, -0.04709540f, -0.01433698f, 
    -0.03276625f, -0.03341876f, -0.00471575f, 0.02893891f, 0.02214480f, -0.01730852f, -0.02658218f, 0.03133830f, 
    0.01337487f, -0.00442828f, -0.05318480f, -0.05564544f, -0.02216698f, 0.04315083f, -0.02473642f, -0.01915584f, 
    -0.02680838f, 0.03646066f, 0.01482391f, -0.03654974f, 0.02064270f, 0.00916160f, 0.03234799f, -0.01158165f, 
    -0.01866675f, 0.04188048f, -0.05290265f, 0.02997142f, -0.03282381f, -0.04090232f, -0.02980746f, 0.03118698f, 
    0.01370638f, -0.04164691f, -0.03113333f, -0.00186777f, 0.01550141f, -0.03309923f, -0.03417982f, 0.02909142f, 
    -0.05819072f, -0.05309477f, 0.00080598f, 0.01958857f, -0.03638835f, -0.00979457f, -0.02508537f, 0.01995420f, 
    -0.04510378f, -0.04760728f, 0.01520251f, -0.00423992f, -0.00564022f, 0.04009658f, -0.01937384f, -0.03452841f, 
    0.00001659f, -0.00728670f, -0.04788429f, 0.03737492f, 0.03557071f, -0.03681853f, 0.00544136f, -0.02478704f, 
    -0.04339285f, 0.02008523f, -0.04360972f, 0.00830421f, -0.00897688f, -0.03588907f, -0.00006404f, -0.03587078f, 
    -0.00834042f, -0.01992984f, -0.03848679f, 0.02113063f, -0.01246455f, 0.03856648f, -0.02809469f, 0.03400395f, 
    -0.02402972f, -0.06097934f, 0.00424889f, -0.05149592f, -0.01254925f, -0.05587959f, 0.03865952f, 0.03320110f, 
    -0.04648079f, 0.02744541f, 0.03353463f, -0.01478823f, -0.01709450f, -0.00979055f, -0.01367019f, 0.02340052f, 
    -0.02390208f, 0.00542268f, -0.01146240f, -0.00258770f, -0.02874335f, -0.01168024f, -0.02968653f, -0.00873849f, 
    -0.03955647f, 0.00429290f, -0.01807919f, -0.01534861f, 0.03251534f, -0.02471734f, -0.02818730f, -0.02633421f, 
    -0.03909668f, -0.04175660f, -0.01809650f, -0.01815286f, 0.03712067f, 0.03928857f, -0.02348059f, -0.02076547f, 
    -0.02481002f, 0.02371539f, -0.05072374f, -0.05479855f, 0.01167846f, -0.04235147f, 0.00317642f, 0.02167413f, 
    0.04456124f, -0.02522023f, -0.01626239f, 0.04095078f, 0.02032132f, 0.02706699f, -0.01345115f, 0.03472140f, 
    0.02436670f, 0.03197106f, 0.02507218f, -0.01497449f, -0.04843616f, 0.00914633f, -0.03665591f, -0.05091476f, 
    0.00420264f, 0.02565843f, 0.02085136f, -0.05075097f, 0.03756245f, -0.04704168f, -0.02627027f, 0.03618586f, 
    0.01155411f, -0.00848907f, -0.04689760f, 0.04344779f, -0.05380973f, -0.02528447f, -0.03111054f, 0.02723251f, 
    0.22376297f, 0.34388819f, 0.17738947f, 0.07658551f, -0.00390082f, 0.02770670f, 0.04510254f, -0.00885368f, 
    0.05350997f, -0.04339992f, 0.03896215f, 0.03128693f, -0.28326058f, -0.11087990f, -0.10624237f, -0.25836456f, 
    0.11461206f, 0.11372697f, -0.08205660f, -0.04360694f, 0.05682741f, -0.06181253f, 0.12158516f, -0.01651239f, 
    -0.07713117f, -0.04303425f, -0.02667607f, -0.06347927f, 0.06065533f, 0.06652381f, -0.06224940f, -0.00488300f, 
    0.10210307f, -0.02114476f, -0.04269566f, 0.03167653f, -0.06549110f, 0.02648535f, 0.12128789f, 0.05002369f, 
    -0.04748936f, 0.02061076f, 0.10600105f, -0.05303017f, -0.09575193f, -0.02591816f, -0.01129257f, 0.05804866f, 
    -0.17165495f, -0.18164833f, -0.01018178f, 0.09651631f, 0.08791766f, 0.03038603f, -0.10150243f, 0.07742650f, 
    -0.02213962f, 0.01657189f, -0.00287382f, -0.00895365f, -0.09146438f, -0.07226294f, -0.08009199f, 0.01575566f, 
    0.03659344f, 0.04362348f, -0.01982070f, -0.02451856f, -0.01571985f, 0.01362798f, -0.06562046f, 0.09863847f, 
    -0.11024594f, 0.00848794f, 0.04521100f, 0.00204860f, 0.17534436f, 0.03718530f, 0.02450103f, -0.02670150f, 
    -0.04852054f, -0.07521646f, -0.10335282f, 0.05180662f, -0.24132785f, 0.16591521f, 0.05802355f, -0.05445577f, 
    -0.02371281f, 0.02868380f, -0.07462261f, 0.03059237f, 0.04663359f, -0.08117083f, -0.00579702f, -0.13222340f, 
    0.01890051f, -0.15820816f, -0.09539366f, 0.00318875f, 0.02030665f, 0.02243315f, 0.05550097f, -0.03003348f, 
    0.06812768f, -0.00845711f, 0.10238347f, 0.02000770f, 0.02283499f, -0.24680166f, 0.06863722f, 0.07203920f, 
    0.12217540f, -0.06564644f, -0.03306400f, -0.04451321f, 0.03147798f, 0.12521492f, 0.04724582f, 0.22460498f, 
    -0.01397433f, 0.05460967f, -0.03152684f, -0.01255327f, 0.08264490f, 0.05631772f, 0.04020767f, 0.00704776f, 
    0.06663061f, -0.09084734f, 0.09452059f, 0.04280917f, 0.02093038f, 0.03342753f, -0.14772554f, 0.05805982f, 
    -0.04774803f, 0.06985428f, 0.11199842f, -0.02284782f, -0.00930966f, -0.00971075f, 0.05705540f, -0.00506422f, 
    0.13581955f, -0.17501530f, 0.07055811f, -0.08710200f, -0.07892252f, -0.03322817f, 0.10048034f, -0.06368154f, 
    0.03172763f, -0.07566005f, 0.00047976f, -0.06142578f, 0.43398929f, 0.26693112f, 0.18549068f, 0.21718623f, 
    -0.00628549f, 0.00134858f, 0.02663591f, 0.12903228f, 0.02648362f, 0.04567835f, 0.08768779f, 0.11118388f, 
    0.00074141f, -0.13676843f, -0.02999032f, -0.01971930f, 0.14836372f, 0.10511477f, -0.08041144f, -0.03606208f, 
    0.06323896f, -0.03292055f, 0.11497034f, 0.06416341f, -0.07290109f, -0.00304620f, -0.10285886f, 0.04679818f, 
    0.07134371f, 0.15171783f, 0.16036904f, 0.07467964f, 0.02958096f, 0.02028712f, 0.02798406f, -0.01274680f, 
    0.17542146f, 0.12824610f, 0.17245504f, 0.20790254f, 0.07279360f, -0.03511585f, 0.09975140f, 0.03787941f, 
    0.01413095f, 0.02196564f, -0.04140798f, 0.00586949f, -0.20670615f, -0.02568527f, 0.01601246f, -0.19661129f, 
    -0.01535242f, -0.06524749f, 0.07746471f, 0.10484803f, -0.05538423f, -0.05752414f, -0.01725191f, 0.10087543f, 
    -0.20862904f, 0.11537828f, -0.04953769f, -0.11331166f, 0.03197692f, -0.01085292f, -0.02519576f, 0.02684085f, 
    -0.03775294f, 0.13399260f, -0.03164658f, 0.01650986f, 0.15257820f, -0.13585328f, 0.11701573f, -0.25053898f, 
    -0.01277075f, 0.10209316f, -0.13752469f, -0.00974939f, 0.02315696f, -0.05081600f, -0.03610572f, -0.16296636f, 
    -0.06180361f, -0.03728519f, -0.18672203f, 0.04137558f, 0.01538880f, 0.00267933f, -0.01653059f, 0.00542563f, 
    -0.10652377f, -0.07996995f, -0.01170950f, -0.01806338f, -0.09608701f, -0.07734992f, -0.15467833f, 0.01702729f, 
    -0.06619095f, 0.01202504f, -0.05447906f, 0.04591654f, -0.03875276f, 0.00407802f, -0.03432547f, 0.02296600f, 
    0.23479268f, 0.20354462f, 0.14409737f, 0.08814634f, -0.01160715f, 0.02008522f, 0.02452537f, 0.16580085f, 
    0.08298122f, 0.09534007f, -0.04072099f, -0.06285282f, 0.06875855f, -0.06693164f, 0.03631485f, -0.14455691f, 
    0.08532678f, 0.11031720f, -0.08196614f, 0.08297218f, -0.07371377f, 0.11142953f, -0.05988687f, -0.03318670f, 
    0.46376017f, 0.30941468f, 0.36724684f, 0.08698446f, -0.00397188f, 0.03773070f, 0.02245923f, 0.07298438f, 
    0.03797155f, 0.04962346f, 0.07825477f, -0.07023918f, -0.21723861f, -0.06923699f, -0.06381319f, -0.09695384f, 
    0.14254703f, 0.03361573f, 0.01877381f, -0.03947524f, 0.07088394f, 0.01698867f, -0.02215295f, -0.00826372f, 
    -0.08289060f, -0.05604712f, -0.06210045f, -0.15116595f, -0.08603632f, 0.03601225f, 0.08485344f, -0.01743091f, 
    0.03329980f, 0.12336232f, 0.14073893f, 0.08757956f, -0.10813327f, 0.06930361f, -0.05190912f, 0.17842163f, 
    0.04512981f, -0.00927002f, 0.01065801f, 0.07950033f, 0.05680800f, -0.03961279f, -0.04907618f, -0.10153183f, 
    -0.14309892f, -0.06545472f, -0.03569715f, -0.01661608f, 0.00460721f, -0.09757020f, 0.13876781f, 0.09342761f, 
    0.06616440f, -0.05735142f, -0.03668557f, 0.05268977f, 0.07034490f, -0.21821377f, -0.04698215f, -0.31334722f, 
    0.12257954f, -0.04860949f, 0.06916119f, 0.06548280f, 0.00831966f, 0.02908053f, 0.05134488f, 0.04181708f, 
    -0.04638579f, -0.12172091f, -0.14968240f, 0.21706727f, 0.05128458f, 0.04111949f, -0.03601895f, 0.02057028f, 
    0.07268488f, 0.05258589f, -0.05302831f, 0.00697463f, 0.03764137f, -0.11083793f, 0.08507048f, 0.12117682f, 
    0.06227941f, 0.03714692f, 0.09817110f, 0.04925361f, 0.04451152f, 0.08549377f, 0.02220697f, -0.01376201f, 
    -0.04474773f, -0.12306574f, 0.07157181f, -0.00298978f, 0.13298796f, 0.08826698f, -0.00914827f, -0.05763812f, 
    -0.09906697f, 0.07166035f, 0.02258022f, 0.16388737f, 0.23507325f, 0.02234128f, -0.10643849f, -0.13069457f, 
    -0.01256394f, -0.08649721f, -0.03272163f, -0.00296843f, -0.12661090f, 0.14663319f, 0.10939091f, 0.16183461f, 
    -0.04780678f, 0.16129555f, 0.02999685f, -0.06078048f, 0.03908322f, 0.08474796f, -0.00751932f, -0.02832229f, 
    0.07271645f, -0.01602312f, 0.10380770f, 0.12790239f, -0.25225627f, -0.00937308f, 0.17717998f, -0.01725794f, 
    -0.11413886f, 0.02789167f, 0.17067820f, -0.08363732f, 0.03435758f, -0.10170391f, 0.10602590f, 0.03268331f, 
    -0.08917852f, -0.03569052f, 0.03627695f, 0.07845014f, 0.03203657f, 0.02349350f, 0.08699449f, 0.06034439f, 
    -0.03990436f, -0.11240577f, 0.00023721f, -0.06820612f, -0.07884243f, 0.00339516f, -0.05099876f, 0.00746672f, 
    0.10040975f, -0.02274396f, -0.08802417f, -0.04997279f, -0.00060387f, -0.03070482f, 0.12574069f, -0.23700532f, 
    -0.29182881f, 0.04506912f, -0.06428832f, 0.09190375f, -0.04619242f, 0.05527566f, 0.07594279f, 0.13649245f, 
    -0.01183274f, 0.02488128f, -0.04533792f, 0.05167304f, -0.09807420f, 0.14572060f, 0.02055132f, 0.13512848f, 
    -0.04697260f, 0.03964430f, -0.03601972f, -0.04802292f, -0.03660201f, 0.02088899f, 0.00396497f, 0.00951362f, 
    0.01565065f, 0.01449108f, -0.10543285f, -0.08854643f, 0.05839811f, -0.05745562f, -0.04741515f, 0.07891399f, 
    -0.04078105f, 0.03027556f, 0.08964987f, -0.05614137f, 0.19589277f, -0.12998183f, 0.07820442f, -0.05981030f, 
    0.06274965f, 0.08092225f, -0.09357917f, -0.12428145f, 0.05178573f, -0.01539496f, -0.05685678f, -0.08091971f, 
    0.32792151f, -0.17307340f, 0.12469928f, 0.02848267f, -0.00503883f, 0.12575182f, 0.00084692f, 0.10313979f, 
    -0.01472513f, 0.09456356f, -0.05282791f, -0.05329204f, -0.07208806f, 0.02559335f, 0.06645577f, -0.18112150f, 
    0.01176334f, -0.04060156f, 0.04758762f, 0.00343847f, 0.00520510f, 0.02763312f, -0.04262724f, -0.00653041f, 
    -0.18316597f, -0.11039657f, -0.04586136f, -0.14027604f, -0.05113308f, -0.11153174f, 0.01557562f, -0.08819810f, 
    0.07863329f, 0.08254454f, 0.06632573f, 0.00590836f, 0.00947071f, -0.25172931f, 0.12811975f, 0.10971045f, 
    -0.04823475f, 0.02283950f, -0.01293963f, -0.08112023f, 0.04111043f, 0.09650540f, 0.01434473f, 0.07932536f, 
    0.15272233f, -0.04592924f, -0.00416018f, -0.11350960f, 0.09773541f, 0.07709136f, -0.01391563f, 0.00451720f, 
    0.05796808f, -0.08105127f, -0.01254297f, -0.07347948f, 0.03443174f, -0.04742505f, -0.21023341f, 0.01216050f, 
    0.04032163f, 0.06230398f, -0.10210197f, 0.00633916f, 0.05067073f, 0.08804296f, 0.03451977f, 0.07276989f, 
    -0.01850364f, -0.24657226f, -0.03624212f, -0.18181458f, -0.03322703f, 0.02113181f, 0.03611534f, -0.11244068f, 
    0.06476277f, -0.03941033f, -0.04961060f, 0.05538009f, 0.06601495f, -0.02148921f, 0.10475397f, 0.11477410f, 
    -0.03116416f, 0.04185038f, 0.00293505f, 0.13270880f, 0.02236682f, -0.26554468f, -0.06144318f, -0.02950309f, 
    0.23654695f, 0.05602105f, 0.14793065f, 0.32653961f, 0.12554404f, 0.04005338f, 0.10251610f, -0.10010188f, 
    0.03880152f, 0.12224253f, -0.06590720f, 0.04165620f, -0.01063597f, 0.13725317f, -0.11412933f, -0.29288325f, 
    0.05181076f, 0.04323522f, -0.06824286f, 0.03367594f, -0.07175086f, 0.11056258f, 0.04938823f, 0.01028049f, 
    0.05144837f, -0.02982627f, -0.07610328f, 0.07051918f, 0.18677151f, 0.06833485f, 0.06243875f, 0.14064884f, 
    0.04082881f, -0.06906477f, -0.09669520f, 0.07766686f, -0.21676703f, -0.00723189f, -0.02921262f, 0.14490773f, 
    -0.05732267f, -0.04148207f, 0.04970252f, 0.08617520f, -0.05387415f, -0.06875766f, -0.04566505f, -0.03612882f, 
    0.03892833f, 0.31735474f, -0.12097854f, -0.02473913f, 0.01101645f, -0.04922997f, 0.02264314f, -0.00914142f, 
    0.05522092f, 0.10727214f, 0.03199868f, 0.08929090f, -0.07885610f, 0.21561603f, -0.16690263f, 0.04338852f, 
    0.09293880f, -0.03861010f, -0.02683878f, -0.12243093f, -0.10160062f, -0.12868774f, -0.03861530f, -0.10034853f, 
    -0.26167884f, 0.07122075f, 0.19405672f, -0.06476391f, -0.06162637f, 0.01753954f, 0.01003617f, -0.02834318f, 
    0.11443400f, -0.03021437f, 0.09488457f, -0.00539713f, 0.29077902f, -0.19288979f, -0.15325995f, 0.01739671f, 
    0.02229648f, 0.10462013f, -0.03034043f, 0.14422603f, -0.05515502f, -0.14663814f, -0.13440380f, 0.00407500f, 
    -0.00710490f, -0.08258107f, 0.29809183f, 0.25429913f, -0.00306799f, -0.02552428f, 0.07220057f, 0.01406807f, 
    -0.03514330f, 0.00348223f, -0.07402848f, -0.08597498f, -0.10440700f, 0.02764799f, -0.17582245f, -0.06024132f, 
    0.00706819f, -0.05651516f, 0.05525115f, -0.03222406f, 0.01167061f, 0.06777401f, 0.03405055f, 0.05492848f, 
    0.24462080f, -0.01303457f, 0.06597715f, 0.11985606f, -0.03471288f, -0.10374900f, 0.13338977f, -0.08233257f, 
    -0.00317424f, 0.03110489f, 0.15924683f, 0.11694608f, 0.17438334f, -0.04011526f, 0.15595339f, -0.09647607f, 
    0.08845551f, 0.00252968f, -0.07069761f, 0.07997785f, -0.01593279f, 0.03632241f, -0.03749406f, -0.04614933f, 
    -0.25522456f, 0.03386878f, 0.07830604f, 0.06878576f, 0.05843208f, -0.02446409f, 0.09949350f, 0.01277138f, 
    0.05347754f, 0.05786270f, 0.09513973f, 0.02676829f, -0.03274471f, -0.02855503f, 0.15936354f, 0.15808730f, 
    0.09619474f, 0.03354467f, 0.08305953f, -0.00418439f, 0.06283569f, 0.04727143f, 0.07335833f, -0.00747875f, 
    -0.03018812f, -0.01075018f, -0.00973291f, 0.02168196f, 0.04325339f, 0.04191320f, -0.04431108f, -0.02084305f, 
    -0.03613736f, 0.02213706f, -0.04649974f, -0.00686394f, -0.01238532f, 0.01680666f, 0.01113142f, -0.02874678f, 
    -0.05497699f, 0.03271049f, -0.03731158f, 0.00683808f, -0.04774010f, 0.04590842f, 0.03227616f, -0.00122465f, 
    0.01340924f, 0.04119726f, 0.01794025f, -0.03619109f, -0.02351048f, -0.01528139f, -0.01445522f, -0.02851585f, 
    -0.01513291f, -0.01436159f, 0.04076306f, -0.01598221f, -0.02153733f, -0.03072898f, 0.04615134f, -0.00538991f, 
    0.04341202f, 0.04246081f, 0.02356325f, 0.03909224f, 0.04218900f, -0.01220681f, -0.01867119f, 0.02232409f, 
    0.01254534f, 0.02922119f, -0.00321909f, 0.03013210f, -0.05398807f, -0.04771958f, -0.02872334f, -0.00623336f, 
    -0.01524804f, -0.04778095f, 0.04785608f, -0.02979343f, -0.01917492f, -0.01684484f, 0.00989673f, -0.01203274f, 
    -0.03973899f, -0.03745950f, -0.04484477f, -0.02770454f, -0.01435834f, -0.01707591f, -0.03517841f, -0.02768980f, 
    0.04662532f, 0.01078299f, 0.03034193f, -0.04088002f, 0.03509340f, -0.05761617f, -0.04353964f, -0.01646970f, 
    0.00166704f, 0.04486696f, -0.04786530f, -0.00504842f, -0.02971360f, 0.00856487f, -0.03470685f, -0.04141849f, 
    0.04131960f, 0.02121835f, 0.00776424f, -0.01641812f, -0.03939028f, -0.01644685f, 0.03612611f, 0.00308794f, 
    0.02141812f, 0.04037364f, 0.01086726f, 0.01169036f, 0.01392628f, 0.00304956f, -0.01192288f, -0.02151707f, 
    -0.03205876f, -0.03221237f, 0.02817227f, 0.03546258f, -0.05056103f, -0.01798791f, -0.02541185f, -0.00884793f, 
    0.03159345f, 0.01403243f, 0.00666545f, -0.00916364f, -0.00896228f, 0.04871822f, -0.01593084f, -0.01013303f, 
    0.00176813f, -0.02592651f, 0.01552320f, -0.04127551f, -0.03466814f, 0.03726766f, -0.03956219f, 0.02861487f, 
    0.01234689f, 0.01672122f, -0.01074694f, -0.00901728f, -0.02415487f, -0.05144864f, 0.01142518f, -0.00432874f, 
    0.01774338f, 0.00103375f, -0.03009131f, 0.02286728f, 0.00968158f, -0.04964563f, 0.00318482f, -0.04180656f, 
    -0.02692177f, 0.00826083f, 0.04146029f, -0.04407273f, -0.01967944f, -0.02552306f, 0.02436481f, 0.02944183f, 
    -0.03455357f, -0.01624256f, 0.04730965f, -0.03498873f, -0.02757410f, 0.01464139f, -0.01031688f, 0.00302426f, 
    -0.04354275f, -0.04205538f, -0.00233527f, 0.02720692f, 0.00350044f, 0.00116177f, 0.04226520f, -0.01237733f, 
    -0.00572323f, 0.04009927f, 0.00319648f, 0.02752021f, 0.04334057f, -0.00804272f, -0.01802722f, -0.03559453f, 
    0.04284142f, -0.05076049f, 0.02381815f, -0.03801877f, -0.04813408f, -0.02055193f, 0.03704789f, 0.02129724f, 
    0.00140899f, 0.00959243f, -0.04666505f, -0.04423574f, 0.00608110f, -0.01164130f, -0.01090414f, 0.01949383f, 
    -0.00774200f, 0.02044803f, 0.01967275f, 0.03510528f, -0.01360998f, -0.04949070f, -0.03638579f, 0.00348169f, 
    -0.00967575f, -0.02813097f, 0.03262299f, -0.05325588f, -0.01661400f, 0.00549617f, 0.01785164f, 0.03580856f, 
    0.02731284f, -0.04821892f, -0.05189899f, -0.04178363f, -0.00289846f, -0.02401751f, -0.01652320f, 0.02886982f, 
    -0.04301467f, 0.04499469f, -0.03914481f, 0.02409560f, 0.01436346f, -0.04630313f, 0.00246351f, -0.04958034f, 
    0.01260543f, -0.04383224f, -0.03233569f, -0.02271522f, -0.01160461f, -0.00517583f, 0.00736000f, -0.04615455f, 
    0.00445157f, 0.00240866f, -0.00140828f, -0.02888635f, -0.00222827f, 0.00564760f, -0.00338717f, 0.02787542f, 
    -0.03758563f, 0.01924498f, -0.00688541f, 0.00763570f, -0.00710087f, -0.02811981f, 0.02018412f, -0.02500178f, 
    -0.04993679f, -0.03071182f, 0.01191207f, 0.04271980f, 0.03548076f, -0.01703225f, 0.02982873f, 0.02033343f, 
    -0.04925504f, 0.00541272f, 0.01902054f, 0.01070094f, 0.00402688f, -0.04042793f, 0.01258560f, 0.03910765f, 
    0.00118287f, 0.04468498f, 0.04429541f, -0.05631430f, -0.01213105f, -0.01366552f, 0.01704629f, -0.03861019f, 
    0.00465360f, -0.02350639f, -0.02093316f, 0.03013315f, 0.04440900f, 0.02591021f, 0.01218111f, -0.02283721f, 
    -0.02981390f, -0.05286036f, -0.03963240f, 0.00393872f, -0.03544589f, -0.03792490f, -0.03668561f, -0.02358136f, 
    -0.01211857f, -0.02647946f, 0.01434538f, -0.02635898f, 0.04405961f, -0.04870084f, 0.02916324f, -0.00220622f, 
    0.00347720f, -0.00692269f, 0.02433140f, 0.03085425f, 0.02293547f, 0.02923086f, -0.02408403f, -0.04146196f, 
    0.01774796f, 0.04053898f, -0.03978356f, 0.02209986f, 0.00151342f, 0.04271122f, -0.03940373f, -0.03346376f, 
    0.01031724f, -0.04287721f, -0.01386182f, -0.00687425f, 0.01207574f, -0.05566204f, -0.03949617f, 0.03996943f, 
    0.00952330f, 0.03713378f, -0.03960706f, -0.02668416f, -0.01907041f, -0.05261353f, -0.01738237f, -0.00501300f, 
    -0.04295171f, 0.02374383f, 0.00116734f, -0.01478065f, 0.00560318f, 0.04901779f, -0.03187744f, -0.02605413f, 
    -0.02046077f, 0.02698593f, 0.03423556f, -0.02347036f, -0.01733213f, -0.02322642f, -0.01829372f, -0.04543943f, 
    -0.04936660f, 0.00360398f, -0.01256018f, -0.02874846f, 0.02915890f, 0.03472413f, 0.01283042f, 0.01859613f, 
    0.04266140f, 0.01393565f, -0.02721472f, 0.01942184f, -0.03741110f, 0.00656842f, 0.03285215f, -0.03871471f, 
    0.02807947f, -0.02637767f, 0.04024186f, -0.03439207f, -0.02301432f, -0.04145291f, -0.04492966f, -0.04337014f, 
    0.00284023f, -0.00108753f, 0.00706649f, 0.03947999f, -0.00043871f, -0.04077814f, 0.00546821f, -0.04734513f, 
    -0.01905228f, -0.02062961f, 0.04768986f, -0.03029436f, -0.04000538f, 0.03276889f, 0.01699897f, 0.05033223f, 
    0.04474370f, -0.04965694f, 0.03397841f, -0.02424763f, -0.01403371f, -0.05186266f, -0.02526801f, -0.01122153f, 
    -0.03282377f, -0.01616733f, -0.04800414f, 0.03464657f, 0.03273665f, 0.01289750f, -0.04675860f, 0.01736693f, 
    -0.04715369f, -0.04135841f, -0.02435355f, -0.03563302f, -0.04598139f, 0.02119599f, -0.01321967f, 0.01614694f, 
    0.00109494f, 0.02525782f, 0.01322961f, -0.03189282f, -0.05145572f, 0.00511342f, 0.03981669f, -0.04016735f, 
    0.01142856f, 0.01852526f, -0.01944997f, 0.01968835f, -0.03920929f, 0.03508110f, -0.02396432f, 0.04448485f, 
    -0.02231114f, 0.04168722f, -0.01649120f, 0.00157298f, -0.02079833f, 0.01255291f, -0.01200218f, -0.02756904f, 
    0.01864488f, 0.03408566f, -0.01311920f, -0.03931655f, 0.01700903f, 0.00065538f, 0.04473232f, -0.05017943f, 
    -0.00810132f, 0.02846746f, -0.04935846f, 0.01383422f, -0.05076725f, -0.03453482f, -0.04689042f, 0.00071447f, 
    -0.00775017f, -0.03063933f, 0.04289703f, 0.00683391f, -0.03171962f, 0.01892003f, -0.00292070f, -0.02782187f, 
    0.01391017f, 0.03078190f, 0.02283384f, 0.01945331f, 0.03627452f, 0.03824666f, -0.02965919f, -0.01809912f, 
    -0.03374344f, 0.02266396f, -0.04950862f, -0.04631034f, 0.04408557f, 0.02303191f, -0.01677767f, -0.02313942f, 
    0.03110665f, 0.04409043f, -0.03787430f, -0.03876947f, -0.02176227f, 0.03187016f, 0.01046480f, -0.01467175f, 
    0.02360366f, 0.03250499f, -0.02110578f, -0.01985586f, 0.01457465f, -0.02291379f, -0.04206488f, -0.03184136f, 
    0.01225651f, 0.01340225f, -0.04857264f, -0.03486008f, -0.00025876f, 0.02510907f, 0.03800857f, 0.00902278f, 
    -0.01632069f, 0.01848110f, 0.02389121f, 0.04421994f, -0.04785009f, -0.04551678f, 0.03567559f, -0.04404802f, 
    -0.05264524f, 0.03626433f, -0.01922467f, 0.03574485f, -0.01133220f, 0.01478211f, -0.01824198f, -0.05039750f, 
    -0.04940601f, 0.01094911f, -0.03675169f, -0.05436389f, -0.03827748f, 0.03437600f, 0.01948268f, 0.00402027f, 
    -0.02265012f, -0.03369359f, -0.03522294f, -0.05392716f, -0.01637647f, 0.02231422f, 0.04222040f, -0.03278529f, 
    -0.02578840f, -0.03853267f, -0.04307664f, -0.00749402f, -0.03258770f, -0.05619647f, 0.00707740f, -0.05058530f, 
    -0.02702851f, 0.00444943f, 0.01016063f, 0.01463778f, 0.04423632f, -0.03863283f, 0.01865819f, -0.02143848f, 
    -0.03925278f, -0.02476222f, 0.01554001f, -0.00339380f, -0.03386418f, -0.00466304f, 0.01153818f, 0.00353303f, 
    0.00039985f, 0.00712389f, -0.02194645f, 0.01339024f, -0.01815920f, -0.01886629f, -0.00100009f, 0.04307756f, 
    0.01182966f, -0.02004607f, 0.02029676f, -0.00840789f, -0.00562742f, -0.01023737f, -0.04010453f, 0.02218024f, 
    0.02037963f, 0.03492534f, -0.00184303f, -0.04122776f, 0.01984029f, -0.03576547f, -0.03272150f, -0.04153949f, 
    0.03768418f, -0.01275173f, -0.00193349f, 0.02209514f, -0.02225852f, -0.05026450f, 0.02842050f, 0.02630769f, 
    0.04558275f, 0.03518629f, -0.00062575f, -0.05301211f, 0.04140980f, 0.01168006f, 0.02758463f, 0.02655393f, 
    0.02963512f, 0.02858069f, -0.05000964f, 0.01319162f, 0.03055144f, -0.02601428f, -0.03899309f, -0.00194399f, 
    -0.01363383f, 0.02768953f, 0.01466279f, 0.04243346f, 0.01604283f, -0.00492457f, -0.01799388f, 0.01546539f, 
    0.04663407f, 0.02832915f, -0.00098746f, -0.03397469f, -0.01959128f, -0.04545866f, -0.01737024f, -0.01535403f, 
    0.02763180f, -0.02344443f, -0.01233595f, -0.05277774f, 0.00813370f, -0.02767476f, -0.02700583f, -0.03710239f, 
    0.02198645f, -0.00172107f, -0.02969094f, 0.04428040f, 0.02012098f, -0.03881402f, -0.03285807f, -0.03863958f, 
    -0.00008411f, 0.00270359f, -0.01891454f, -0.02540043f, -0.03892623f, 0.03667491f, 0.00536725f, 0.00490148f, 
    0.02993903f, 0.00506810f, -0.00659361f, 0.01986854f, 0.03887163f, -0.04315349f, 0.03914363f, 0.00887972f, 
    0.03468277f, 0.03637808f, -0.05283477f, 0.03375107f, -0.04153351f, -0.05026944f, -0.04826166f, -0.01404453f, 
    0.03689631f, -0.04643871f, -0.04667584f, -0.03887920f, -0.01651899f, 0.00361876f, -0.04731326f, 0.02058870f, 
    -0.04515291f, -0.04278103f, -0.00926624f, -0.01288325f, -0.03216861f, -0.00200784f, -0.02984877f, -0.02188715f, 
    0.02449128f, -0.05282525f, -0.04911608f, -0.04492936f, -0.02712161f, -0.02737166f, -0.01335387f, -0.04010996f, 
    -0.00940822f, -0.04807987f, 0.00862021f, 0.04415969f, 0.03896392f, 0.02828596f, -0.00915642f, -0.01707782f, 
    -0.01996839f, -0.05213507f, -0.00889689f, -0.01930477f, -0.01389540f, 0.00535034f, -0.02769485f, 0.00698949f, 
    -0.02666122f, -0.00071761f, -0.02171227f, -0.02947604f, 0.01965002f, 0.03414504f, -0.03369347f, 0.02349539f, 
    0.01104540f, 0.04045689f, -0.03037677f, 0.03818038f, 0.03822381f, 0.03527163f, 0.00385344f, 0.02073716f, 
    -0.02611571f, -0.02919206f, 0.01508741f, 0.01942418f, -0.03367829f, -0.02726789f, -0.03847807f, 0.02185008f, 
    0.02210625f, -0.01248175f, -0.03737240f, 0.03715658f, -0.01571933f, -0.04595971f, -0.02348929f, 0.00393894f, 
    -0.03993808f, 0.01671554f, 0.00862596f, 0.03135836f, -0.04519350f, -0.04086018f, -0.00455727f, -0.03241342f, 
    -0.00239765f, -0.00732087f, -0.03219374f, -0.04301563f, 0.00130972f, -0.03170606f, -0.00327271f, -0.03324419f, 
    -0.05469701f, -0.03349185f, 0.03605390f, 0.00507409f, 0.00859053f, 0.00305431f, -0.05411185f, 0.03442773f, 
    0.01937650f, 0.01436264f, -0.02458059f, -0.04345374f, 0.02676937f, -0.02836929f, -0.05155813f, -0.00615411f, 
    0.01535161f, -0.04445506f, -0.05023104f, 0.00639163f, 0.02382211f, 0.00761575f, -0.00944308f, -0.01780277f, 
    -0.02171425f, 0.01295572f, 0.03811551f, -0.14227955f, 0.08948313f, -0.03631127f, 0.01104611f, -0.01674191f, 
    0.01560587f, 0.02623639f, 0.06463236f, 0.05506095f, -0.18850392f, -0.15622535f, -0.06959943f, -0.01481527f, 
    -0.01949612f, -0.02148738f, -0.04792773f, -0.03366482f, -0.13387762f, 0.08727496f, -0.00665650f, 0.01331506f, 
    0.09729543f, 0.09226527f, -0.18203263f, 0.06892375f, -0.05337716f, 0.12729111f, -0.09613708f, -0.10094103f, 
    -0.00233831f, -0.04766829f, 0.08866201f, -0.03113637f, -0.13765998f, -0.17547831f, -0.02971109f, -0.16412409f, 
    0.08109058f, 0.02644405f, 0.07054586f, -0.04794892f, -0.05508455f, 0.10086846f, -0.05468756f, -0.02115661f, 
    -0.19106880f, -0.21513791f, 0.05721595f, -0.00673779f, -0.03597276f, -0.12430297f, 0.01724839f, 0.06476688f, 
    -0.04079344f, -0.06883527f, 0.01697072f, -0.07895392f, 0.06330033f, 0.08141527f, 0.14847700f, 0.04316202f, 
    0.09809280f, -0.02993881f, -0.13464144f, 0.03190113f, 0.17508779f, 0.04141328f, 0.09430485f, -0.01093737f, 
    -0.00091701f, -0.02663030f, 0.02737573f, 0.30331212f, -0.03669843f, 0.04276549f, -0.04793998f, 0.04552425f, 
    0.02683479f, -0.00509122f, -0.04733045f, 0.03097908f, 0.21319674f, 0.23697110f, -0.07010392f, -0.05490794f, 
    -0.08742980f, -0.01825486f, 0.03376971f, 0.09460236f, -0.06533035f, -0.03762689f, 0.01639422f, -0.03812073f, 
    0.32591128f, -0.25678244f, -0.13843331f, -0.15971313f, 0.00286245f, 0.06006595f, -0.02701795f, -0.02544783f, 
    -0.06334237f, 0.00718617f, 0.11547281f, -0.08750093f, 0.31855732f, 0.09996346f, -0.00959511f, 0.03995012f, 
    0.14967355f, 0.13383631f, -0.08599599f, -0.01321738f, 0.04704307f, 0.00682202f, -0.04289677f, -0.00431789f, 
    0.24158303f, 0.08074486f, -0.00081222f, 0.13963401f, 0.12343583f, 0.11124784f, -0.06392319f, -0.01706289f, 
    -0.15225457f, 0.02277401f, -0.08115414f, -0.06835586f, -0.01338394f, -0.39537573f, 0.03270220f, -0.09974585f, 
    0.08545396f, -0.01063110f, 0.00361578f, 0.09270564f, -0.04336137f, -0.05720120f, 0.12374061f, -0.09871249f, 
    0.23860911f, -0.00645482f, -0.05910866f, -0.00941016f, 0.02146613f, -0.00986323f, -0.12068418f, -0.07519896f, 
    0.00505394f, 0.05881071f, -0.04479338f, -0.08662716f, -0.02646834f, 0.08177238f, -0.16401142f, 0.10056771f, 
    0.01653625f, -0.05037820f, -0.00453989f, -0.04351543f, 0.02523702f, -0.08963599f, -0.08875658f, 0.11572409f, 
    0.29827282f, -0.14683460f, -0.00032272f, 0.04116884f, 0.09150109f, -0.05021336f, -0.16842107f, 0.07596901f, 
    0.02908457f, -0.05668408f, -0.02115961f, -0.08594687f, 0.36560687f, -0.01965776f, -0.15494779f, 0.00204687f, 
    0.12597495f, 0.03151443f, -0.03532232f, -0.04241583f, 0.06197606f, 0.05153414f, -0.10027610f, -0.00478074f, 
    0.29113808f, 0.13552096f, 0.19070390f, 0.01392013f, 0.07399122f, -0.08606572f, 0.00997073f, 0.02989582f, 
    0.06895047f, -0.02379684f, 0.05457838f, -0.03791532f, -0.14027323f, 0.10586150f, 0.01968032f, 0.05907040f, 
    0.03949365f, 0.01041949f, 0.00122712f, 0.10857889f, 0.09569643f, -0.11888306f, 0.01300894f, 0.10350830f, 
    -0.09672195f, 0.01883147f, -0.04374587f, 0.13107370f, -0.12148069f, 0.12443425f, -0.00038212f, -0.09644654f, 
    0.04799169f, 0.02813572f, -0.01365251f, -0.00174313f, -0.19208400f, 0.11366846f, -0.07600477f, -0.01120150f, 
    0.02135818f, 0.03121843f, -0.16587575f, -0.10216767f, -0.10654005f, 0.10056106f, 0.01792423f, -0.09412430f, 
    -0.15696739f, -0.07760146f, 0.06071204f, 0.14595631f, 0.02901135f, 0.04176510f, -0.01874482f, 0.03376729f, 
    0.03775670f, -0.03889458f, 0.04610949f, 0.04555659f, -0.30060679f, 0.03395648f, 0.10895223f, 0.23286977f, 
    -0.08305966f, 0.05884676f, 0.02232886f, 0.09407765f, 0.05077817f, 0.05946709f, -0.03206959f, -0.03648036f, 
    0.44760641f, -0.00303079f, -0.02287572f, -0.03133461f, 0.06773820f, 0.09782184f, -0.03929183f, -0.11765522f, 
    -0.00341556f, 0.01174514f, 0.01189414f, 0.08748799f, 0.20843841f, -0.10078681f, 0.09073327f, -0.07067005f, 
    0.10717937f, 0.10679479f, -0.09095604f, -0.04141079f, -0.05325004f, 0.05689226f, -0.00432315f, -0.04569468f, 
    0.27897123f, 0.13567060f, -0.22043435f, -0.01025076f, -0.02132512f, 0.00533098f, 0.06174716f, -0.06328081f, 
    -0.10454493f, 0.05909954f, -0.04720888f, 0.00470030f, 0.15222308f, 0.08909487f, 0.07417502f, 0.03655156f, 
    -0.01203564f, 0.13313968f, -0.01041740f, 0.07911455f, -0.03459664f, -0.00990589f, 0.00018782f, 0.05676700f, 
    -0.08998644f, -0.18323530f, -0.19120613f, 0.07164424f, 0.00299063f, -0.09909500f, -0.09766485f, -0.02221195f, 
    -0.04846011f, 0.06837754f, 0.02971863f, 0.02174004f, -0.07538892f, 0.08754692f, 0.01855191f, -0.00845139f, 
    0.02800932f, -0.03048169f, -0.02885294f, 0.06757617f, -0.01688301f, 0.02521987f, 0.04682176f, -0.12547243f, 
    -0.18848506f, 0.10855063f, 0.03571630f, -0.15792061f, -0.03687827f, -0.06494171f, -0.02176759f, -0.06364756f, 
    0.05228525f, 0.05261225f, 0.07028761f, 0.01515852f, 0.24124116f, 0.22053856f, 0.25537506f, -0.02441721f, 
    0.03235234f, -0.02912725f, -0.15113212f, 0.04494343f, -0.00697170f, 0.02564170f, 0.05836450f, 0.07096381f, 
    0.15656951f, 0.02680647f, 0.02521849f, -0.05991047f, 0.17327917f, 0.11216298f, -0.04784035f, 0.02060886f, 
    0.04573891f, 0.06138004f, 0.05622698f, 0.00373239f, 0.07460295f, -0.10060576f, 0.11249469f, 0.01652337f, 
    0.11734384f, 0.09415507f, -0.09914210f, 0.05206830f, 0.04492347f, 0.05747936f, 0.04117940f, -0.03235442f, 
    -0.01470131f, -0.03475212f, 0.00095796f, 0.01209825f, 0.02884359f, -0.01657457f, 0.01533346f, -0.01978252f, 
    0.00741020f, -0.04489912f, -0.03842732f, 0.04587789f, 0.00982280f, -0.00826061f, 0.03564291f, 0.02242208f, 
    -0.00828479f, -0.04936332f, -0.00924130f, 0.01714174f, -0.03580028f, 0.03613215f, -0.03913877f, 0.00677918f, 
    0.05063118f, -0.03670145f, 0.03936478f, -0.00453493f, -0.04808927f, 0.03055744f, 0.00184287f, 0.00535279f, 
    -0.03827567f, -0.04236806f, -0.02128759f, -0.04896761f, -0.02947651f, -0.01276388f, -0.04438485f, -0.02651372f, 
    -0.03961258f, -0.01311430f, 0.00740063f, -0.04368885f, 0.05025703f, 0.04925840f, -0.04750603f, -0.03337131f, 
    0.04328820f, 0.00420602f, -0.03688879f, 0.04225097f, -0.00736190f, 0.02519246f, -0.00417377f, 0.01733736f, 
    -0.04256982f, 0.02410937f, 0.03967454f, -0.03789560f, 0.04877250f, 0.02594689f, 0.04278308f, -0.04500258f, 
    -0.03337765f, -0.01203590f, 0.02464952f, 0.02551800f, 0.02509944f, 0.01821620f, -0.01902742f, -0.03072733f, 
    -0.04808934f, -0.04188068f, -0.03494163f, 0.02097940f, 0.02821750f, -0.03445273f, 0.00220016f, 0.04962746f, 
    -0.02644053f, -0.00501390f, -0.02510306f, -0.00017063f, -0.03529384f, 0.03528801f, 0.01404029f, 0.03441710f, 
    -0.00213790f, 0.04748843f, 0.02741874f, -0.00128392f, 0.03788280f, 0.01025462f, -0.03410133f, -0.02164122f, 
    0.00895375f, -0.01604019f, 0.02596870f, -0.03292356f, 0.05096995f, 0.04353973f, 0.02676650f, 0.03303260f, 
    -0.01746671f, -0.01189808f, -0.01079658f, 0.03328552f, -0.01453946f, 0.01806665f, -0.04954414f, 0.04280711f, 
    0.03338837f, -0.01088057f, 0.02296300f, 0.01382800f, -0.03810165f, -0.04818613f, -0.04301789f, 0.03119958f, 
    0.03249636f, 0.02418598f, -0.04747628f, -0.02090783f, 0.00050954f, -0.04097940f, -0.02330795f, -0.03935936f, 
    0.03668623f, 0.04361401f, 0.05080250f, 0.02611933f, -0.04372586f, -0.03759476f, -0.00473476f, 0.00259253f, 
    0.02904055f, -0.01961928f, 0.04806842f, -0.02622648f, 0.03470154f, 0.00159233f, -0.04100643f, 0.01358862f, 
    -0.01217813f, 0.02915543f, 0.04410432f, -0.02509836f, -0.05025476f, 0.00636718f, -0.03959185f, -0.05064420f, 
    0.03423939f, 0.03581984f, -0.01292137f, -0.00496465f, -0.01066429f, -0.00934695f, -0.02359562f, -0.03719576f, 
    -0.03389571f, -0.03216161f, 0.01580573f, 0.01492850f, -0.00749523f, -0.03710489f, -0.02930692f, 0.01316421f, 
    -0.04315089f, 0.00405909f, -0.03543964f, 0.04979313f, 0.01485990f, 0.00027740f, 0.02250019f, 0.01768694f, 
    0.02435253f, -0.01784439f, 0.00076601f, -0.00915905f, -0.00100609f, -0.02261549f, 0.00861098f, -0.01967969f, 
    -0.04634959f, -0.01929394f, -0.04771766f, -0.01177520f, 0.02917111f, 0.02689377f, -0.03333539f, -0.04722010f, 
    -0.00506662f, 0.03077290f, 0.00367149f, 0.04880570f, -0.02460718f, -0.01408898f, -0.03531463f, -0.04268954f, 
    -0.02943752f, 0.00039904f, 0.01788458f, -0.00078502f, -0.00734523f, 0.01158393f, 0.00614008f, -0.05049767f, 
    -0.04508361f, -0.02529826f, -0.01734948f, -0.04613949f, -0.04204107f, 0.02223591f, -0.04021425f, 0.02819520f, 
    0.04021908f, -0.01742270f, -0.04352015f, -0.02262516f, -0.03558440f, -0.04558646f, 0.00306154f, -0.04612142f, 
    0.02390387f, -0.02862497f, -0.00214876f, -0.04778085f, 0.03978955f, 0.02158739f, -0.05089261f, -0.02528802f, 
    -0.01624312f, 0.03811908f, 0.04010735f, -0.03913160f, -0.04534846f, -0.04904521f, 0.00565386f, -0.04184172f, 
    -0.01966174f, -0.00903678f, -0.01366454f, 0.00633130f, 0.04349208f, -0.00497413f, 0.00274224f, 0.02859296f, 
    -0.03115883f, 0.03731852f, -0.05032600f, 0.00317907f, 0.02792439f, 0.03383333f, -0.01316068f, 0.00085421f, 
    -0.01576779f, -0.03691345f, -0.04128545f, -0.04027554f, 0.04153401f, -0.04058449f, -0.03622837f, -0.02459225f, 
    -0.02172844f, -0.02443186f, 0.03900274f, -0.02321006f, -0.01337708f, 0.04539928f, -0.03580683f, -0.04395857f, 
    0.01189568f, -0.04137860f, 0.03562204f, -0.03585899f, -0.02926616f, 0.04042801f, 0.02043144f, -0.00058046f, 
    -0.04709504f, 0.03816404f, -0.00225186f, 0.03236433f, -0.03780833f, -0.02958049f, 0.01688822f, 0.03123865f, 
    0.01664321f, 0.01765351f, 0.01533660f, 0.00673905f, 0.00775572f, -0.01989198f, -0.00261562f, 0.03106827f, 
    -0.03498396f, -0.03533219f, 0.00613572f, 0.00437583f, -0.03568870f, 0.04112442f, 0.00291057f, 0.01578924f, 
    -0.04918338f, -0.02596381f, 0.04395196f, -0.03502574f, 0.01099817f, 0.01544519f, -0.03761211f, 0.04951564f, 
    0.00600299f, 0.04309939f, -0.00237342f, -0.02540688f, -0.04022153f, 0.04078965f, -0.04531903f, 0.00979123f, 
    0.02017821f, -0.03515606f, 0.02760466f, -0.04361126f, 0.01911648f, -0.00384992f, -0.01902455f, 0.01004252f, 
    -0.03301555f, -0.00070777f, -0.00454035f, -0.04684059f, -0.03579425f, -0.04348886f, 0.03861883f, -0.03885100f, 
    0.02173030f, 0.01675792f, -0.03229128f, -0.01019470f, 0.03094643f, -0.02040627f, 0.02282113f, 0.03267908f, 
    0.00983282f, 0.03013684f, -0.01375029f, -0.00623706f, 0.01487308f, -0.00546502f, 0.04067283f, 0.02388325f, 
    -0.00052762f, -0.02540781f, -0.01495433f, -0.01989685f, -0.00050636f, 0.04996985f, -0.00535681f, 0.03235402f, 
    -0.03535819f, 0.02627741f, -0.01922721f, -0.02997161f, 0.03122542f, -0.02559538f, -0.03903041f, 0.02186419f, 
    0.02314692f, 0.04603405f, -0.01696854f, -0.03252258f, -0.03369468f, -0.04326300f, -0.01426283f, -0.02833339f, 
    0.03523879f, 0.03722925f, 0.04832954f, 0.02762716f, 0.04280005f, -0.01483358f, 0.03295840f, 0.01441286f, 
    -0.03493357f, -0.00318501f, -0.02689946f, -0.00618197f, 0.00787093f, -0.01240301f, 0.00162657f, -0.04392167f, 
    -0.00823491f, -0.04056799f, 0.02196526f, -0.01275903f, 0.03493448f, 0.03051780f, -0.04989422f, -0.03808355f, 
    -0.01126453f, 0.01020480f, -0.03205075f, 0.00261488f, 0.00915207f, -0.03724182f, -0.00071642f, -0.04558340f, 
    -0.02515127f, 0.00793520f, 0.01481079f, -0.00782052f, -0.02699593f, -0.05402308f, -0.04489892f, 0.01865557f, 
    -0.00423956f, -0.01388685f, -0.05575930f, -0.05298395f, 0.05331282f, -0.02951326f, 0.00012464f, 0.00058688f, 
    -0.02788114f, 0.01393567f, -0.02403410f, -0.00055609f, 0.00129545f, -0.01570874f, -0.04372299f, -0.01534539f, 
    0.01801476f, 0.00436494f, -0.04552154f, 0.01939107f, -0.00357738f, 0.02286426f, 0.02442366f, 0.03329843f, 
    0.04086168f, 0.03450147f, -0.01333915f, 0.00702222f, -0.01152112f, 0.01454648f, -0.05861576f, 0.01543464f, 
    -0.03788462f, 0.02811732f, 0.03972737f, -0.01226225f, 0.02036902f, -0.00396214f, -0.05023786f, 0.02029685f, 
    -0.04585286f, -0.01357590f, -0.00093498f, 0.04162326f, -0.03203427f, 0.00591916f, 0.04013099f, 0.01669346f, 
    -0.04391951f, -0.01373346f, 0.00935401f, -0.05190817f, 0.02480799f, 0.00443858f, -0.03665245f, 0.01773377f, 
    0.03291516f, -0.03405693f, 0.02744475f, 0.03046262f, 0.01830737f, 0.00835657f, -0.01629148f, -0.03110573f, 
    0.02702648f, 0.03604378f, 0.00673773f, -0.03975816f, -0.01821803f, 0.01540930f, 0.00037542f, 0.02563780f, 
    -0.03872622f, -0.02117059f, 0.00340679f, -0.02429829f, 0.01863335f, -0.05326231f, -0.04956172f, -0.02814361f, 
    -0.01317759f, -0.03812947f, 0.03549061f, -0.02363050f, -0.00732125f, 0.00419979f, -0.00407802f, 0.01447625f, 
    -0.01580935f, -0.00994945f, 0.02974141f, 0.00820783f, 0.02570535f, 0.01257197f, -0.03303324f, 0.01597399f, 
    0.00053188f, 0.03603229f, 0.02662250f, 0.01895443f, -0.00807867f, -0.00153606f, -0.00953055f, -0.05576269f, 
    -0.00116449f, 0.01996906f, 0.04949211f, -0.04838795f, 0.00360457f, 0.01569189f, 0.03934887f, 0.03425035f, 
    -0.01205520f, 0.01182716f, -0.03839474f, -0.03035590f, -0.00198527f, -0.02809320f, 0.00703068f, -0.05724328f, 
    0.04074524f, -0.01935498f, -0.04847784f, 0.02213557f, -0.01794987f, 0.03254026f, 0.03650503f, -0.04453214f, 
    0.00204312f, 0.00957280f, 0.03364103f, 0.03511523f, 0.04830607f, -0.02889301f, -0.03323797f, 0.05013687f, 
    -0.02067570f, -0.03726969f, -0.03179715f, -0.01998946f, -0.03086246f, -0.01986619f, 0.01905836f, 0.03292324f, 
    0.02535482f, 0.02243992f, -0.02434292f, -0.04334531f, -0.01826975f, -0.00525271f, 0.00224366f, 0.01797344f, 
    0.02946633f, 0.00421971f, -0.05646855f, -0.02005675f, 0.03877505f, -0.03743824f, -0.05270519f, 0.00201628f, 
    -0.01904313f, -0.00675256f, -0.00311355f, -0.03700421f, 0.00377442f, -0.00965777f, 0.00813811f, -0.00114268f, 
    -0.01325109f, -0.02451574f, -0.04121315f, 0.03079673f, 0.03075307f, 0.00182695f, 0.02480748f, -0.01486161f, 
    -0.04717400f, 0.01892671f, 0.00382562f, 0.00405880f, -0.03599373f, -0.01153166f, 0.01201910f, 0.00187307f, 
    -0.02075787f, -0.03018093f, -0.01834897f, 0.04195145f, 0.04680572f, 0.02511720f, 0.04404245f, 0.01956044f, 
    -0.04050473f, -0.00081018f, 0.01747437f, -0.04594378f, 0.03335197f, -0.04623512f, -0.00235926f, -0.04574276f, 
    0.00648374f, -0.04628039f, 0.01521809f, -0.01126739f, 0.04002277f, 0.00202940f, -0.00722536f, 0.03863100f, 
    0.01004942f, -0.01456563f, -0.05144988f, -0.03031961f, 0.04036711f, 0.03173886f, 0.03260397f, 0.00826603f, 
    -0.05321078f, 0.00426471f, -0.01752715f, 0.03581533f, -0.02093291f, 0.02134551f, -0.05244323f, -0.01762257f, 
    -0.04464620f, -0.02755809f, 0.00679008f, -0.01390810f, 0.02619892f, -0.01985683f, 0.01534421f, -0.04372098f, 
    -0.01582156f, -0.01845935f, -0.05504717f, 0.03968234f, -0.00647705f, 0.04234748f, -0.06007014f, -0.04024911f, 
    -0.03272772f, -0.02907280f, 0.01348218f, 0.00878335f, -0.04597956f, 0.00308383f, 0.03558848f, -0.01410963f, 
    0.00691436f, 0.03448155f, 0.00101381f, -0.03648007f, 0.01997008f, 0.03285944f, 0.04411846f, -0.01313300f, 
    -0.03782444f, -0.00744927f, -0.02616811f, 0.02648215f, -0.04727504f, 0.01568900f, 0.00101919f, -0.04378093f, 
    0.03901770f, -0.03878155f, 0.03861533f, -0.00012828f, -0.03796815f, -0.03879417f, -0.00790900f, 0.02144483f, 
    0.02551957f, -0.01077521f, 0.02638227f, 0.00248494f, 0.02799307f, -0.05139724f, -0.04860791f, -0.03977590f, 
    -0.02958129f, -0.02872359f, -0.00003291f, -0.02610298f, 0.01200047f, -0.02801822f, -0.02060510f, 0.01252662f, 
    0.00014963f, 0.03346508f, -0.03848717f, 0.00444501f, 0.02384445f, -0.01080775f, 0.01463361f, 0.03808590f, 
    -0.05389581f, 0.02648463f, -0.02405370f, -0.03965348f, -0.04457844f, -0.02810488f, 0.01682284f, -0.05616971f, 
    -0.01945754f, 0.00517539f, 0.02751679f, -0.03597144f, -0.02508892f, 0.02008262f, -0.00545691f, -0.03160933f, 
    -0.05667784f, 0.03641916f, -0.01966120f, 0.00635301f, 0.00001146f, -0.04975772f, -0.03338296f, 0.03829920f, 
    -0.02830365f, 0.02693582f, 0.04263699f, 0.00930155f, 0.02555021f, 0.03219282f, -0.02826150f, -0.03082920f, 
    -0.04298646f, -0.01839058f, 0.01607499f, 0.02686422f, -0.03382155f, -0.03965998f, 0.00393726f, -0.02994777f, 
    0.02649951f, -0.01637103f, 0.00196356f, -0.01215171f, 0.00430340f, -0.00316586f, -0.01329503f, -0.01811260f, 
    -0.04060910f, 0.00713479f, 0.00417359f, -0.03005620f, 0.01803232f, -0.02364317f, -0.00128625f, 0.02560418f, 
    -0.09768052f, 0.16373605f, 0.05254319f, -0.06297702f, -0.13225526f, -0.09572620f, -0.03915820f, 0.05482678f, 
    0.10208391f, -0.06833738f, 0.02395779f, -0.10943004f, 0.02767381f, 0.17042813f, 0.18119101f, 0.13306971f, 
    0.17173971f, 0.10741567f, 0.01861506f, -0.06767364f, 0.01524964f, -0.22986963f, -0.10997033f, -0.03295217f, 
    0.00603231f, 0.00119292f, 0.15355828f, -0.00215809f, 0.02131722f, -0.04334230f, 0.00372309f, 0.06826796f, 
    -0.08096264f, 0.13331446f, -0.06804535f, -0.24890167f, 0.12168111f, 0.07813136f, -0.06695185f, 0.04469298f, 
    0.03627979f, -0.08241695f, -0.06449173f, 0.13969432f, -0.01457446f, 0.05270969f, 0.00656730f, 0.05312586f, 
    0.24275465f, 0.19708379f, -0.00457202f, 0.10012986f, 0.01316365f, -0.00816845f, -0.08901959f, -0.03786598f, 
    0.13516437f, 0.06902080f, -0.13804701f, 0.03028947f, 0.01890532f, 0.01061295f, 0.08159178f, -0.07322345f, 
    -0.01022694f, -0.06752845f, 0.12407066f, -0.07577331f, -0.03329568f, 0.10665151f, -0.06209477f, 0.25860733f, 
    0.08742838f, -0.03066505f, 0.06020697f, -0.00481803f, 0.05757987f, 0.05868768f, 0.02698593f, -0.10176311f, 
    0.03629037f, 0.00379089f, 0.01444328f, 0.01475822f, 0.02038287f, -0.06458476f, 0.06155137f, -0.11760984f, 
    0.12390430f, -0.05637826f, -0.02593560f, 0.04489928f, -0.02936543f, -0.04930069f, -0.05232694f, 0.00243124f, 
    -0.15798578f, 0.03685017f, 0.16386950f, 0.23483066f, 0.02877104f, 0.06169134f, 0.08121578f, -0.09619335f, 
    -0.01007090f, -0.12279915f, -0.02660744f, -0.02443544f, -0.31970763f, -0.07421131f, -0.03157776f, 0.08328702f, 
    -0.03715883f, 0.05206086f, 0.12019126f, 0.13208015f, -0.04647894f, 0.02718799f, 0.08702478f, 0.09696184f, 
    0.02624706f, -0.01754041f, 0.13757724f, 0.05393181f, 0.10361730f, -0.06699419f, 0.12623608f, -0.01191513f, 
    0.09892981f, -0.07305375f, 0.03433248f, -0.03965350f, -0.02419610f, -0.03115530f, 0.11336434f, 0.17675929f, 
    0.01528067f, 0.00341491f, 0.09804115f, -0.00403012f, -0.07514711f, -0.04673890f, 0.01701368f, 0.07606667f, 
    -0.02436839f, -0.08582657f, 0.12201282f, 0.25723022f, 0.06268162f, 0.09269557f, 0.03002640f, 0.04684766f, 
    -0.06640765f, -0.07829480f, -0.09001094f, -0.05851441f, 0.04343107f, 0.21171845f, 0.05313513f, -0.14776407f, 
    -0.06921271f, 0.09949592f, 0.09102511f, -0.02032610f, -0.04912281f, -0.03991295f, -0.02484800f, 0.02545202f, 
    -0.22934711f, -0.06837859f, -0.03350623f, -0.05198715f, 0.04664306f, -0.01751493f, 0.13631298f, 0.07959779f, 
    -0.05242928f, 0.16041024f, 0.10641678f, -0.00255372f, -0.13221973f, 0.00518842f, 0.19190766f, -0.12879905f, 
    0.04471176f, 0.06403429f, 0.06630246f, -0.15492932f, -0.14384609f, 0.02172798f, 0.01332009f, 0.00068478f, 
    -0.52392060f, 0.14661765f, 0.02977407f, 0.01754535f, -0.00478204f, 0.07304976f, 0.04537483f, 0.15287328f, 
    0.00611232f, 0.10284775f, 0.06814849f, -0.06171473f, 0.11128606f, 0.07030679f, -0.12014107f, -0.00264538f, 
    0.04661962f, -0.08622012f, 0.04840353f, -0.00167515f, -0.15644866f, 0.20837706f, 0.11410996f, 0.12931728f, 
    -0.01186990f, 0.00238999f, -0.08541495f, 0.04549213f, -0.07415313f, 0.08875256f, -0.03903762f, 0.04827931f, 
    0.04254055f, -0.09047863f, 0.13278045f, -0.10170958f, 0.17258509f, 0.16408691f, -0.07147897f, 0.05179957f, 
    -0.06684224f, -0.00004508f, 0.08382344f, 0.05081690f, 0.07688029f, -0.18616191f, 0.07912570f, -0.09358408f, 
    0.13365039f, 0.18760757f, -0.03545763f, 0.03018131f, -0.09707765f, -0.04211304f, -0.01532792f, -0.18595453f, 
    -0.04419678f, 0.13412264f, 0.19163625f, -0.08990715f, 0.41093650f, -0.01345634f, -0.07488141f, 0.11239794f, 
    0.05412897f, 0.02062135f, -0.01635777f, -0.03025919f, -0.02588692f, -0.05072391f, 0.01344843f, 0.01227772f, 
    -0.07146580f, -0.21673809f, -0.01341415f, -0.11632751f, 0.00148816f, -0.02372738f, 0.11255691f, 0.06274131f, 
    -0.10391682f, -0.07419486f, 0.01545804f, 0.04239870f, -0.02875177f, 0.05493159f, -0.05901529f, -0.00313052f, 
    -0.08194803f, 0.01056825f, 0.09859944f, 0.13335571f, 0.04609612f, 0.06205143f, 0.12160000f, 0.09385700f, 
    -0.06172620f, 0.01613588f, -0.06772383f, -0.22651446f, 0.05104230f, -0.09573882f, -0.00083569f, 0.00237092f, 
    -0.05742119f, -0.00493644f, -0.00862612f, 0.04700371f, 0.15488723f, 0.06181070f, 0.12145448f, 0.08537097f, 
    0.01055111f, -0.15158577f, 0.03591722f, -0.07007605f, -0.01444600f, 0.20856977f, 0.17369333f, -0.14075460f, 
    0.17952241f, 0.13818935f, 0.11489883f, 0.01144688f, -0.01365300f, 0.00957029f, 0.08304578f, 0.02315351f, 
    0.09149536f, 0.08300450f, 0.14344290f, 0.08777973f, 0.00538414f, -0.01072940f, -0.07246113f, -0.05366880f, 
    -0.03656361f, 0.08377863f, -0.00014480f, 0.07971981f, 0.09310358f, -0.08105364f, 0.06271634f, -0.07355525f, 
    0.03490869f, 0.06193066f, -0.03764924f, 0.07726614f, 0.07604975f, 0.01962283f, -0.13462345f, -0.05725273f, 
    -0.08059039f, 0.02993537f, -0.23435751f, -0.07849366f, 0.03213737f, -0.03342464f, -0.20303376f, 0.20792830f, 
    -0.01138624f, -0.06035911f, 0.22494332f, -0.08951069f, 0.09064623f, -0.02768787f, 0.08015734f, 0.13160881f, 
    0.08626543f, -0.08274780f, -0.13997459f, 0.08301602f, -0.08147673f, 0.04350588f, -0.02532787f, -0.03803502f, 
    -0.15184887f, 0.00334825f, -0.11282019f, 0.01540316f, 0.08866754f, 0.17676617f, -0.08014787f, 0.01476697f, 
    -0.09124590f, -0.04750308f, 0.00778444f, -0.01668365f, -0.21188477f, -0.01520143f, -0.02652515f, 0.00538146f, 
    0.16138437f, 0.03228860f, -0.00322864f, -0.05275872f, -0.14671652f, 0.08555280f, 0.07717619f, 0.03585782f, 
    0.12129339f, -0.04431305f, 0.01710929f, 0.00417865f, -0.12143700f, -0.03119762f, 0.00864210f, 0.14977898f, 
    0.01506689f, 0.03384702f, -0.06778750f, 0.01757577f, 0.06793904f, -0.08464611f, -0.02073007f, -0.01199745f, 
    -0.18304557f, 0.12029469f, -0.00001826f, 0.12543549f, 0.13386124f, 0.01547353f, 0.03998379f, -0.02758171f, 
    0.11447513f, 0.02812728f, -0.03195704f, -0.02083305f, 0.14909229f, -0.08847275f, -0.02008215f, 0.04033761f, 
    -0.05851455f, -0.00464191f, 0.07482833f, 0.04119269f, -0.07153920f, 0.00377879f, -0.10574537f, -0.05934900f, 
    0.04122438f, -0.08349673f, 0.10275595f, 0.11443473f, -0.09421739f, -0.03336800f, -0.02965928f, 0.03921590f, 
    0.01202910f, -0.02091948f, -0.00388347f, 0.06936672f, -0.12624706f, -0.05614302f, -0.01953897f, -0.08453342f, 
    0.02583187f, 0.10299478f, -0.03658579f, 0.01595252f, 0.02208579f, -0.01203647f, -0.01319944f, 0.01499610f, 
    -0.07203686f, 0.02594570f, 0.03866553f, 0.09709255f, 0.13915950f, 0.07432203f, -0.14545518f, -0.02554449f, 
    0.10043549f, -0.00339945f, 0.00803488f, 0.12150541f, 0.09909987f, 0.14900112f, -0.02422464f, -0.02498200f, 
    -0.05793644f, -0.01142586f, 0.07649352f, 0.01188745f, -0.00228232f, -0.02031293f, -0.00592788f, -0.02509154f, 
    -0.28311235f, 0.02838349f, 0.13442408f, 0.15028271f, 0.01174756f, -0.02510365f, -0.06781048f, 0.00915397f, 
    -0.04675906f, -0.04328559f, -0.10351832f, 0.02373627f, 0.19294010f, -0.12198146f, -0.09102812f, -0.16205907f, 
    0.14702390f, -0.01105196f, -0.17200932f, -0.02216061f, 0.01119419f, 0.10764804f, -0.02634492f, 0.06355640f, 
    -0.16041045f, -0.01215716f, -0.05591684f, -0.04517041f, 0.02056007f, 0.08197340f, 0.06586020f, -0.00251028f, 
    0.03243807f, -0.09084635f, 0.05926307f, -0.00412893f, -0.43489775f, -0.07767508f, 0.15738867f, -0.11537752f, 
    0.04527568f, -0.09009258f, 0.08276738f, 0.14678647f, 0.01442212f, -0.01210802f, 0.12834541f, -0.04607380f, 
    -0.00573513f, 0.23476288f, -0.06338786f, 0.09540190f, 0.00951615f, 0.06363443f, -0.02176413f, 0.01861680f, 
    0.09180044f, 0.04263709f, 0.00364702f, 0.00067065f, 0.47051638f, 0.10293484f, -0.09508422f, 0.13789529f, 
    -0.02383073f, 0.03366625f, -0.01668475f, 0.09299943f, 0.02421596f, -0.01190202f, 0.01541625f, 0.08754178f, 
    -0.15345480f, 0.06542104f, -0.11248154f, -0.15518224f, 0.08293736f, 0.01221036f, -0.05248021f, 0.10741495f, 
    0.00315338f, -0.01816515f, -0.07644369f, 0.00571253f, -0.00919911f, -0.13277529f, -0.22503689f, -0.10054629f, 
    0.09195672f, -0.00776560f, 0.05376427f, -0.07884354f, -0.00752608f, -0.02585159f, -0.07638741f, 0.04651208f, 
    0.17031902f, 0.23151232f, 0.15101171f, 0.01481917f, -0.01828700f, -0.05210251f, 0.01305571f, 0.04735862f, 
    -0.07537729f, 0.05298369f, -0.01421780f, 0.04544392f, 0.08025668f, 0.02656173f, 0.00985441f, -0.00513447f, 
    -0.07864188f, -0.08619575f, 0.01710645f, 0.03978274f, 0.11293481f, 0.04963472f, 0.04720909f, 0.12732084f, 
    -0.14444919f, 0.09001056f, -0.01979680f, 0.12293537f, -0.04000547f, -0.05163382f, -0.07622708f, 0.07051503f, 
    0.06771887f, 0.00178294f, 0.12183701f, -0.00526933f, 0.16009535f, 0.11765136f, -0.02214524f, 0.12103532f, 
    -0.09431517f, 0.10261872f, -0.10934888f, -0.10279766f, -0.00979635f, 0.02561604f, -0.09347039f, -0.09928961f, 
    -0.05405675f, -0.00011080f, -0.01167655f, 0.11892954f, -0.06942082f, 0.00415195f, 0.01594555f, -0.02132953f, 
    -0.00709448f, 0.11581380f, -0.01217571f, -0.00316613f, -0.12107812f, -0.04254309f, 0.07934546f, 0.08662144f, 
    -0.03844100f, -0.03575936f, -0.03144871f, 0.12429721f, 0.01252679f, 0.10194556f, -0.03809074f, 0.13175595f, 
    0.25105369f, -0.11044850f, -0.01242131f, 0.11386402f, -0.00831336f, 0.03214620f, 0.11633756f, -0.02495584f, 
    -0.04533647f, 0.00315306f, 0.03971747f, 0.05018551f, 0.04257040f, -0.09714820f, -0.16143338f, -0.08003626f, 
    -0.01835802f, 0.11920289f, -0.05406087f, -0.05260754f, 0.03449664f, 0.15432170f, 0.04994708f, 0.02199910f, 
    0.33011124f, -0.07471615f, 0.13981622f, 0.30272967f, -0.08176053f, -0.00329115f, 0.10517929f, 0.06623557f, 
    -0.13578328f, 0.00888186f, -0.01042900f, 0.03688785f, -0.00965447f, 0.12493267f, 0.03099584f, -0.06518663f, 
    -0.05100193f, 0.04483495f, 0.03302939f, -0.07086201f, -0.03704017f, 0.00726423f, 0.05080803f, -0.15716857f, 
    0.09748422f, 0.07955392f, -0.00455853f, 0.07197772f, -0.02409990f, -0.11421605f, 0.02669519f, 0.20476894f, 
    -0.06858336f, 0.06573108f, 0.17410704f, 0.07762530f, -0.02860661f, 0.00584711f, -0.16118219f, -0.19652550f, 
    0.08674532f, 0.07300912f, -0.13475381f, 0.00231201f, 0.19457528f, -0.04558361f, 0.00088213f, -0.03124334f, 
    -0.18549801f, -0.03152639f, 0.15221016f, 0.01775099f, -0.04733606f, -0.01356424f, 0.09851617f, 0.02009520f, 
    0.07435848f, 0.00073764f, -0.10675479f, 0.08728325f, 0.23762663f, 0.02466648f, 0.12844937f, -0.26406431f, 
    -0.05878741f, 0.00113574f, -0.07748422f, 0.00398205f, 0.01899817f, -0.00102687f, 0.11806156f, 0.00652120f, 
    0.03267969f, -0.03144225f, -0.07314195f, -0.28563583f, 0.04929786f, 0.13697706f, -0.12875399f, 0.02864556f, 
    0.03106349f, 0.01090081f, -0.05616893f, 0.06333079f, 0.13851772f, 0.03850280f, 0.00738529f, -0.26349247f, 
    -0.11430671f, -0.06643272f, -0.04881711f, 0.19931985f, 0.06102059f, 0.01004853f, 0.00891891f, 0.06160557f, 
    -0.01265507f, 0.00887122f, -0.04063584f, 0.01761292f, -0.01942085f, -0.04222747f, 0.03687349f, -0.04141777f, 
    0.00143409f, -0.05220507f, -0.02085411f, -0.02500063f, -0.01280302f, -0.05038225f, 0.02838098f, -0.00148074f, 
    -0.05574042f, -0.01463766f, -0.03686735f, 0.01596968f, 0.00054235f, -0.02957533f, 0.01388636f, -0.00211650f, 
    0.04179617f, 0.02091100f, 0.03635412f, -0.01457527f, -0.01225145f, -0.03383950f, 0.02205504f, 0.00543952f, 
    -0.03017688f, -0.03288231f, -0.01784267f, -0.02788191f, -0.02362346f, 0.03087753f, -0.01257623f, -0.05414839f, 
    0.00246627f, -0.03034225f, 0.00459947f, -0.05341005f, 0.04270820f, 0.02596269f, 0.00002805f, 0.00160020f, 
    -0.04562541f, -0.05607697f, -0.00593163f, -0.04920651f, 0.02380031f, 0.03472029f, 0.04348721f, -0.05253236f, 
    0.04367163f, 0.01156881f, 0.04498511f, 0.02981158f, -0.02710078f, -0.05212708f, -0.00018174f, -0.03660254f, 
    0.00390389f, -0.02651850f, 0.00230969f, 0.00373298f, -0.02852822f, -0.02566426f, 0.00797625f, 0.00278082f, 
    -0.00760560f, 0.02225820f, 0.01142593f, -0.01578473f, -0.02824867f, -0.00405930f, -0.01677696f, -0.04533501f, 
    -0.03393387f, 0.01699990f, 0.01397137f, 0.03531966f, -0.03254164f, -0.05501162f, -0.00225585f, -0.01080866f, 
    -0.00938505f, 0.03477976f, -0.04738242f, -0.00425392f, -0.03279884f, 0.04111935f, -0.01452226f, -0.03067069f, 
    0.03459081f, -0.04545341f, -0.05309622f, 0.03048999f, 0.01021028f, -0.04328680f, -0.01269368f, -0.04995112f, 
    -0.00368167f, 0.02315285f, -0.02302372f, 0.01374640f, 0.01673059f, -0.05043818f, -0.05065963f, 0.02491264f, 
    -0.02370352f, -0.02817308f, -0.01548640f, 0.00707215f, 0.02187023f, 0.03280831f, -0.04287413f, -0.03959737f, 
    0.00357201f, -0.01908688f, -0.04037825f, 0.01275957f, 0.01478566f, 0.00428306f, 0.00683926f, -0.02418819f, 
    0.03397873f, -0.04758835f, 0.03997546f, 0.03768994f, -0.02328661f, 0.03347188f, 0.00444852f, 0.02163594f, 
    -0.00895941f, 0.03523436f, -0.01518045f, -0.05610228f, -0.05331104f, 0.01238191f, 0.00047736f, 0.02163122f, 
    -0.00892729f, -0.00130040f, 0.00584120f, 0.02859536f, 0.03938075f, 0.02568317f, -0.05634693f, -0.04634928f, 
    -0.04831588f, -0.04783924f, -0.02626597f, 0.00200312f, -0.02460769f, -0.03321169f, -0.04623852f, 0.01529726f, 
    -0.02642765f, -0.05023270f, -0.02646095f, -0.03958157f, 0.00458521f, -0.04354554f, 0.02024084f, -0.03698143f, 
    0.02793391f, -0.03530831f, -0.00289725f, 0.03982087f, -0.05255872f, -0.00633604f, 0.03835762f, -0.02175254f, 
    0.02209087f, 0.01355350f, -0.04189251f, -0.00004405f, 0.01133974f, -0.03246354f, -0.00004336f, -0.03239616f, 
    -0.03694598f, -0.03622186f, 0.02830531f, -0.03710174f, 0.01436935f, -0.04779014f, -0.04489478f, -0.05175808f, 
    0.02719233f, 0.03877870f, 0.00830759f, -0.01032222f, -0.03546674f, 0.02370482f, -0.01538336f, -0.04559479f, 
    -0.01507748f, -0.03352417f, -0.02251889f, 0.04359247f, 0.01843606f, -0.02767811f, 0.01749585f, -0.00502663f, 
    -0.01520401f, -0.03909583f, 0.03795136f, -0.02411576f, -0.05179533f, 0.00398421f, -0.04768065f, 0.03379932f, 
    -0.01447089f, -0.02895983f, -0.02642210f, -0.04495446f, 0.04086622f, 0.03601282f, -0.01316411f, 0.02882798f, 
    0.03865682f, -0.04495485f, -0.00225877f, 0.01829450f, 0.00257600f, 0.00997117f, 0.00283078f, -0.04145989f, 
    0.00264674f, -0.00167169f, 0.02895682f, -0.02387999f, -0.01491593f, -0.00729196f, 0.02251588f, 0.00489892f, 
    -0.04101571f, 0.02788039f, 0.04275455f, -0.02941148f, 0.03894215f, -0.01258697f, 0.02506191f, -0.03405601f, 
    0.01085655f, -0.02288147f, -0.01486211f, 0.03407209f, 0.02675010f, -0.05696698f, -0.04598813f, 0.02498879f, 
    0.04463976f, 0.02895856f, -0.00644602f, -0.00681304f, -0.03051126f, -0.02853135f, -0.00938592f, -0.03588801f, 
    -0.05703592f, 0.00122592f, -0.03446306f, 0.00621898f, -0.02589311f, 0.01531562f, 0.03788561f, 0.01834101f, 
    0.04394835f, 0.01318795f, 0.04038874f, -0.03389215f, -0.01604594f, 0.02568319f, 0.01228370f, -0.01595566f, 
    0.01364247f, 0.02243826f, -0.00647673f, -0.02860765f, -0.04592123f, 0.02680848f, -0.02105740f, -0.04926620f, 
    -0.03659019f, -0.01491229f, 0.03267933f, 0.00622022f, -0.02014301f, -0.01402240f, 0.01141606f, 0.03120207f, 
    0.01228468f, -0.04981517f, -0.03466699f, -0.02530990f, 0.01520418f, -0.02255513f, -0.00392505f, -0.03348305f, 
    0.02120372f, -0.03660620f, -0.04589174f, 0.03640685f, -0.01982326f, 0.04435407f, -0.02902347f, -0.03021666f, 
    -0.01484212f, 0.02020549f, 0.03336755f, -0.00317962f, 0.02435945f, -0.05421542f, -0.00319897f, 0.02622902f, 
    -0.05185058f, -0.05625949f, 0.02707748f, -0.01776780f, -0.02489401f, -0.02150354f, -0.03063198f, 0.02415633f, 
    -0.05071030f, -0.04479237f, 0.04127432f, 0.04234726f, -0.04882415f, -0.02597044f, -0.03558445f, -0.03353245f, 
    0.03877107f, -0.02785455f, 0.00107066f, 0.01819437f, -0.03114307f, -0.03941227f, -0.01888647f, -0.02900588f, 
    -0.03849037f, -0.02716566f, -0.00758392f, -0.00146821f, 0.03782201f, 0.00825583f, 0.01389728f, -0.02713002f, 
    0.01412480f, -0.04523340f, -0.02806027f, 0.03330229f, 0.00609998f, 0.02118499f, -0.05075227f, -0.01211989f, 
    0.01285215f, -0.00218374f, -0.00157129f, -0.01309031f, -0.04434419f, 0.03516169f, 0.03299160f, -0.01433620f, 
    -0.02815777f, 0.04488996f, 0.03652179f, -0.04734192f, 0.02760754f, -0.04974629f, -0.02203184f, -0.01669078f, 
    0.04054996f, -0.04374937f, 0.02040716f, 0.01519882f, 0.04059377f, -0.05059084f, -0.00635683f, 0.02599458f, 
    -0.03972507f, -0.00219914f, -0.03702656f, -0.03943312f, 0.01497437f, -0.01509015f, -0.05788871f, 0.04170060f, 
    0.03717929f, -0.00175477f, -0.00765402f, -0.01775522f, -0.00470339f, -0.02128373f, -0.04179221f, -0.03731450f, 
    -0.01793686f, -0.03049847f, 0.03116974f, -0.02456720f, 0.03586879f, 0.03494687f, 0.02420671f, -0.04660424f, 
    -0.04855413f, -0.04323610f, -0.05378601f, 0.04250664f, -0.01779943f, -0.03599627f, 0.02485838f, -0.02217761f, 
    -0.00021665f, -0.02434922f, -0.05625995f, -0.01976790f, 0.02211083f, -0.01916667f, 0.01931169f, -0.03714765f, 
    -0.03392399f, -0.01733887f, -0.01411843f, -0.02222557f, 0.02205131f, -0.03613508f, -0.03604581f, -0.01246093f, 
    -0.02194113f, -0.05492066f, 0.00919442f, -0.02235284f, -0.05241183f, -0.02208757f, -0.01430125f, -0.03396428f, 
    -0.01189656f, -0.02466733f, -0.01667508f, -0.02756768f, -0.03752248f, -0.00503937f, -0.02887199f, -0.03582911f, 
    -0.04552153f, 0.03624083f, 0.03207402f, -0.02097971f, 0.01308168f, 0.03125227f, -0.02623252f, -0.03916771f, 
    -0.04056793f, -0.03068669f, -0.03272379f, -0.01180003f, -0.05693760f, -0.04848105f, 0.04226359f, -0.01959369f, 
    0.04135082f, -0.05777152f, -0.03844064f, 0.03812940f, -0.02405231f, 0.00587392f, 0.00623245f, -0.04609146f, 
    0.03915318f, -0.03099837f, -0.02039888f, -0.02908242f, -0.02912693f, 0.02819768f, 0.01066337f, -0.02619139f, 
    0.00543145f, -0.04872198f, -0.03631730f, 0.03140269f, 0.03538034f, -0.01418105f, -0.03666076f, 0.03548754f, 
    0.01938654f, -0.02390347f, -0.02162583f, 0.02340605f, -0.02797518f, -0.02690282f, -0.00438592f, -0.03974197f, 
    -0.05584938f, 0.00314772f, -0.00131800f, -0.03323504f, 0.00653723f, -0.04904216f, -0.01098493f, 0.04165755f, 
    0.03330513f, 0.03260901f, -0.02694947f, 0.03768044f, -0.05221844f, -0.00375742f, -0.04677776f, 0.02061531f, 
    -0.00202229f, 0.01063763f, 0.00142290f, -0.04646307f, 0.02035211f, -0.02333295f, 0.00597251f, 0.01875592f, 
    -0.03920243f, -0.02332252f, -0.01462014f, 0.01133579f, -0.04469891f, -0.02672263f, 0.04053799f, -0.05406570f, 
    -0.01121668f, -0.04355494f, -0.04225559f, -0.01035096f, 0.03758785f, -0.04659560f, 0.04030753f, -0.00459880f, 
    0.00954136f, -0.01384226f, 0.01617387f, 0.03653314f, -0.05532635f, 0.01583976f, -0.01477442f, 0.01444480f, 
    0.00672639f, 0.03921061f, 0.02585250f, -0.04770003f, -0.01515398f, -0.04276614f, -0.04698088f, -0.04780643f, 
    0.03526811f, 0.02643424f, 0.02125840f, -0.05344990f, -0.01324395f, -0.01538311f, -0.00087741f, -0.02478402f, 
    0.03144212f, -0.02840568f, -0.02133228f, 0.03925896f, -0.01266726f, -0.01138989f, 0.03611352f, 0.04110650f, 
    -0.00945055f, 0.03191898f, -0.01932133f, -0.03929784f, -0.05681501f, 0.03347513f, 0.02729318f, -0.00809114f, 
    0.03037561f, -0.03792382f, 0.03500452f, -0.03108733f, 0.03801095f, 0.03052031f, 0.02003475f, -0.01163476f, 
    -0.01155178f, -0.03505073f, 0.01106123f, 0.02844523f, -0.03716540f, -0.05676106f, 0.02409109f, -0.01360138f, 
    0.01594254f, -0.03914043f, -0.02691858f, 0.03310565f, 0.02092365f, -0.03506859f, -0.02499828f, -0.03954851f, 
    0.01567032f, 0.03307859f, -0.02145263f, -0.05267595f, 0.04055594f, 0.01478123f, -0.04092153f, 0.03273850f, 
    -0.00746592f, 0.00340625f, 0.02256751f, 0.00717398f, -0.05535017f, -0.02094422f, 0.00790306f, -0.04203092f, 
    -0.05861285f, -0.04535300f, -0.03925768f, 0.02942246f, 0.00211858f, -0.05671228f, 0.04070396f, -0.03698238f, 
    -0.04065396f, -0.03023530f, -0.02678181f, 0.02160834f, 0.01793530f, 0.02970213f, 0.03458883f, -0.02693472f, 
    0.01313960f, -0.02852233f, -0.00261061f, 0.03418371f, -0.00306325f, -0.05708360f, 0.01130029f, -0.03225295f, 
    -0.03536495f, -0.00411181f, -0.00612408f, -0.04227841f, -0.04080896f, 0.01294254f, 0.04032076f, 0.04347759f, 
    -0.01071686f, -0.04612175f, 0.00419415f, -0.01930271f, -0.05251130f, -0.04062095f, -0.01635489f, 0.02865174f, 
    -0.04885348f, 0.02678952f, -0.01922880f, 0.03517048f, 0.01051188f, -0.04015190f, 0.00514749f, 0.02661205f, 
    0.02243277f, 0.01386466f, 0.00340878f, -0.05004487f, -0.03736241f, -0.03409275f, -0.00043610f, 0.02966782f, 
    -0.03559973f, 0.03667886f, 0.04034544f, -0.04381191f, 0.02461609f, -0.00851408f, -0.00384178f, 0.00527270f, 
    0.03942154f, 0.02751873f, -0.00672893f, 0.02260904f, 0.03276706f, 0.02273608f, -0.00789553f, 0.00044109f, 
    0.01610362f, 0.03351587f, -0.05679866f, -0.04384935f, 0.00018197f, -0.03169503f, 0.01504464f, -0.03587188f, 
    0.00021818f, 0.03589952f, 0.02974392f, -0.01623898f, -0.05629036f, -0.02494107f, -0.00508705f, 0.01359921f, 
    -0.03947975f, 0.04137748f, 0.01816088f, -0.01433379f, 0.00681437f, -0.01586147f, -0.01651320f, 0.01681189f, 
    -0.02402627f, 0.02075676f, 0.04402513f, 0.01759658f, -0.00660853f, -0.00028409f, 0.00334431f, 0.00662620f, 
    -0.05535720f, 0.03934406f, -0.03175038f, 0.01536417f, -0.03404471f, 0.02676082f, -0.02851231f, -0.00152381f, 
    0.00799369f, 0.03546035f, -0.04549471f, 0.02754646f, -0.00355485f, -0.01676095f, -0.00601842f, 0.01887204f, 
    -0.02716920f, 0.02681930f, -0.03776264f, -0.04733670f, 0.03613156f, 0.02900676f, -0.04291035f, -0.04968355f, 
    0.00509771f, -0.02887396f, 0.03064595f, -0.04889347f, -0.03789938f, -0.00663234f, -0.03768379f, -0.03689046f, 
    -0.02952817f, -0.04695428f, 0.03637339f, 0.02662317f, -0.00749527f, -0.00942564f, 0.04127809f, 0.03909035f, 
    -0.01740077f, -0.04464374f, 0.02774231f, -0.04992048f, -0.04215903f, 0.01327583f, 0.01468189f, -0.00366032f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02664255f, -0.03257027f, -0.04638241f, 0.01699894f, 0.06036368f, 0.07478946f, -0.02783719f, -0.05471457f, 
    0.01248550f, 0.00926135f, 0.04455397f, -0.01730518f, -0.03157283f, 0.02883563f, 0.00094164f, -0.04228155f, 
    -0.04200508f, 0.08558334f, 0.08594087f, -0.04052164f, -0.01654684f, -0.05295127f, -0.01976581f, 0.07809673f, 
    -0.00595288f, -0.03512974f, -0.06055769f, 0.09698392f, 0.03804127f, 0.13130371f, -0.00986795f, -0.04267212f, 
    0.03889993f, 0.00009430f, -0.03208141f, -0.04413453f, 0.02036782f, -0.01133798f, 0.12680961f, 0.03265455f, 
    0.01510468f, 0.01802233f, -0.06203707f, 0.12078167f, -0.02038348f, 0.02330232f, -0.02406563f, -0.02950253f, 
    -0.05308753f, 0.01606307f, -0.04273670f, 0.03341707f, 0.03924687f, 0.04391785f, 0.07640275f, -0.00484508f, 
    -0.04523988f, -0.04391602f, -0.03543868f, 0.04461158f, -0.02792565f, 0.00642974f, -0.03904614f, -0.02172490f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02203351f, 0.00147480f, -0.03635121f, 0.14192846f, 0.03948557f, -0.42130375f, -0.39755738f, 0.04050767f, 
    0.29003981f, 0.04655961f, -0.10362618f, 0.00908009f, -0.01426687f, 0.10184348f, -0.00370700f, 0.08462317f, 
    0.15933320f, -0.27146569f, 0.09250169f, 0.10082904f, 0.50831133f, 0.15391314f, -0.12216286f, -0.35048562f, 
    0.12060543f, -0.24672952f, 0.05211668f, -0.37250817f, 0.00553687f, -0.11104965f, -0.08146168f, 0.10608917f, 
    0.01213992f, 0.08372158f, 0.00607690f, 0.01648098f, 0.02875631f, 0.27734905f, -0.08257764f, -0.55341077f, 
    -0.51977450f, -0.34357950f, 0.24475868f, 0.00255018f, 0.10135233f, -0.09129770f, 0.22252327f, 0.07806838f, 
    0.22393440f, -0.16762462f, -0.13858002f, 0.03467947f, -0.03292679f, -0.01423374f, -0.19336034f, 0.07755484f, 
    0.06313258f, -0.03458904f, -0.11312303f, 0.05086683f, -0.04772254f, 0.28921598f, -0.03297478f, 0.02919341f, 
    -0.10545064f, 0.05168048f, -0.02882094f, -0.06270488f, 0.12809536f, 0.16691135f, -0.40163222f, 0.03543266f, 
    -0.21757416f, 0.08077199f, 0.11511593f, -0.09263819f, -0.07292168f, 0.05212078f, 0.15656875f, 0.07275742f, 
    -0.09644636f, 0.25732568f, 0.22951254f, 0.12567618f, -0.31723580f, -0.07848965f, -0.01998581f, -0.29217160f, 
    -0.18157557f, 0.13919246f, 0.02570461f, -0.15529433f, -0.22305126f, 0.21859016f, 0.02891382f, -0.22952867f, 
    -0.06874276f, -0.03396022f, -0.06061520f, 0.19336118f, 0.11999895f, 0.15484226f, -0.20339057f, 0.22532961f, 
    -0.25390992f, -0.46516281f, -0.41341865f, -0.13238052f, 0.10091296f, 0.02113249f, 0.15504335f, -0.02600770f, 
    0.22828659f, -0.21930732f, -0.34232545f, -0.09480434f, 0.10617048f, 0.21903352f, 0.23378961f, 0.01141869f, 
    0.01153906f, 0.23963761f, -0.08276220f, 0.06625749f, -0.36518726f, 0.21074077f, 0.06053101f, -0.09029377f, 
    -0.11839204f, -0.10731343f, -0.02623458f, -0.40885675f, -0.32356474f, -0.19033352f, 0.20476064f, 0.04125174f, 
    -0.36642495f, 0.04703365f, -0.04689214f, 0.05210461f, 0.05178662f, -0.17071809f, -0.16614155f, 0.07845902f, 
    0.24888733f, -0.27587953f, 0.29104003f, 0.03704594f, -0.24005742f, 0.05099172f, -0.01172557f, -0.28289878f, 
    0.31486779f, 0.37249321f, 0.02767568f, 0.25245386f, -0.20642836f, -0.22690421f, -0.19262330f, 0.14681384f, 
    -0.05654086f, 0.01077406f, -0.11334502f, -0.30878595f, -0.02435607f, -0.13745534f, -0.18573904f, 0.24649924f, 
    -0.14768413f, 0.01818938f, -0.28397566f, 0.13903560f, 0.09037702f, 0.08873801f, 0.32825515f, 0.03370199f, 
    0.10540053f, -0.25422499f, -0.40636033f, -0.11570419f, -0.01976728f, 0.06255937f, -0.32509497f, -0.04684966f, 
    -0.08525349f, 0.11465941f, -0.03799151f, -0.00893832f, -0.21847585f, -0.36904600f, 0.08380526f, 0.10275782f, 
    -0.11529427f, -0.12035814f, -0.03728272f, 0.07121176f, -0.26824132f, 0.01967449f, 0.06755159f, 0.02057638f, 
    -0.10215519f, -0.12437775f, -0.10790566f, -0.12993009f, -0.03847518f, -0.19661367f, 0.24100985f, -0.02914643f, 
    -0.01729153f, 0.17600910f, 0.03784629f, 0.06693672f, -0.23243041f, 0.21649733f, 0.09485348f, 0.19394854f, 
    0.15900357f, -0.42165098f, 0.08514744f, -0.07000575f, -0.18054229f, -0.14095503f, -0.22958069f, -0.67119497f, 
    0.07565575f, 0.11483173f, -0.01803923f, 0.16795054f, -0.00554713f, 0.05520843f, 0.07212730f, 0.25046030f, 
    -0.34480450f, 0.15675527f, 0.33004382f, -0.31725398f, -0.01887793f, 0.06400590f, -0.33178493f, -0.08269118f, 
    0.17591861f, 0.19175507f, 0.20995472f, -0.07381832f, 0.08797722f, -0.59424871f, -0.08640763f, 0.03903501f, 
    0.03010043f, -0.57078344f, 0.08071657f, -0.04138109f, 0.22218195f, 0.18083499f, -0.07832025f, 0.09729321f, 
    -0.07637847f, 0.09755224f, -0.09341741f, -0.06278470f, 0.04325382f, -0.35302800f, -0.19749014f, 0.11198415f, 
    0.09236421f, -0.09390198f, 0.07317074f, -0.01406539f, -0.02325093f, 0.10944241f, -0.15279239f, 0.09670329f, 
    -0.29796624f, -0.37072343f, -0.16925706f, 0.06259933f, 0.13337164f, 0.09432910f, -0.02355266f, 0.21203776f, 
    0.02620020f, -0.03382465f, -0.07891461f, 0.12120177f, 0.30100235f, 0.04215433f, -0.13802743f, 0.01451361f, 
    0.02932396f, -0.01037726f, 0.09009726f, 0.27792662f, 0.02498408f, -0.37863818f, -0.38407716f, 0.14777376f, 
    -0.05299205f, 0.02127361f, 0.09716945f, 0.02867941f, -0.11949332f, -0.07956448f, 0.03794794f, -0.03480847f, 
    0.23588903f, 0.27646631f, 0.33317435f, 0.04186209f, 0.09753374f, 0.13931094f, 0.08199601f, -0.08017693f, 
    0.06343117f, -0.42620543f, -0.09332536f, 0.09658328f, 0.08201343f, -0.10674845f, -0.03255627f, 0.11106770f, 
    0.09150264f, -0.08321153f, -0.11027677f, -0.20520732f, 0.28658512f, 0.36059523f, -0.33103096f, 0.01510850f, 
    -0.17467445f, -0.07115977f, 0.08206429f, -0.07375076f, -0.12371138f, 0.05065671f, -0.23681960f, 0.05368891f, 
    -0.07779235f, 0.02691744f, -0.12396679f, 0.05552855f, -0.11633356f, -0.27258822f, -0.00101079f, -0.01926866f, 
    0.11209422f, -0.27611116f, -0.12453406f, 0.14084047f, 0.28288081f, -0.01636314f, 0.18640402f, -0.02272125f, 
    -0.06205075f, 0.08725564f, -0.12844719f, 0.04743141f, 0.07651448f, 0.19768643f, 0.15143290f, -0.31445923f, 
    -0.21158071f, -0.00145692f, 0.31316030f, 0.21532008f, 0.01174994f, -0.10635022f, -0.32812542f, -0.07700920f, 
    -0.36675495f, -0.58427763f, 0.10737865f, 0.03834099f, 0.08969769f, 0.07330670f, 0.25217280f, -0.04325087f, 
    -0.11903775f, 0.00678379f, 0.07608978f, -0.07400662f, -0.34009594f, 0.10919141f, -0.10781435f, 0.08363118f, 
    0.11338682f, -0.08711122f, 0.00472989f, -0.22731356f, 0.01542415f, 0.10553131f, 0.21408947f, 0.01109906f, 
    0.18718271f, 0.09834811f, 0.04669299f, 0.08198726f, 0.00635962f, -0.40681100f, 0.32638812f, 0.11781675f, 
    -0.32313818f, -0.10290921f, 0.08238904f, 0.08795808f, -0.48993295f, -0.21561806f, 0.10406598f, 0.09386177f, 
    -0.33182052f, -0.05235843f, 0.01177784f, -0.17171526f, 0.22855002f, 0.05898278f, -0.14309564f, 0.29075134f, 
    0.07522455f, -0.05555935f, 0.08123178f, -0.46502930f, -0.09952407f, 0.04894836f, 0.19625935f, -0.46958983f, 
    0.44396955f, -0.03619874f, -0.03701589f, 0.04163460f, 0.05060667f, 0.00322355f, -0.27277690f, 0.00885842f, 
    0.16365394f, 0.19275472f, -0.28581437f, 0.03015485f, 0.02699047f, 0.24880689f, -0.29716250f, -0.11960005f, 
    0.05804785f, -0.14507803f, -0.01123330f, -0.01744576f, 0.33235124f, 0.14015847f, 0.05385670f, -0.01506198f, 
    -0.02218204f, -0.12661576f, 0.05518335f, 0.10366457f, 0.19977200f, -0.12418019f, 0.19734006f, -0.08578385f, 
    -0.44326511f, -0.08145083f, -0.10658223f, 0.08883690f, 0.05095707f, -0.27550751f, 0.18058090f, -0.01124757f, 
    0.12690674f, -0.07908831f, -0.34027845f, -0.10823024f, 0.30265388f, -0.23125593f, -0.10735069f, 0.04653087f, 
    0.11445571f, 0.15567201f, 0.08004037f, -0.17398655f, 0.07576533f, -0.24735938f, 0.14250629f, -0.14800970f, 
    -0.04737281f, 0.08304920f, -0.05576176f, 0.09366129f, 0.01684378f, -0.37241513f, -0.15384664f, -0.07961042f, 
    0.31665778f, 0.17772405f, 0.11917146f, -0.29655740f, -0.08818857f, 0.09492238f, 0.05413925f, 0.10934743f, 
    -0.26171890f, 0.06795694f, -0.09848122f, 0.11016964f, 0.04869308f, -0.10896876f, 0.08241598f, 0.11037777f, 
    -0.00966578f, 0.20287342f, 0.00983968f, -0.08305465f, 0.14826390f, -0.18087523f, -0.03960553f, 0.03871623f, 
    -0.08246818f, 0.03407921f, 0.06109034f, -0.03880596f, -0.12769239f, 0.05526772f, -0.05993882f, 0.05062776f, 
    0.05767053f, -0.10347894f, 0.00721608f, 0.10749615f, -0.05554271f, 0.26800904f, 0.00750251f, -0.10924809f, 
    0.24097382f, -0.11613823f, 0.00804327f, 0.05793969f, -0.27893764f, 0.22084148f, -0.06807242f, 0.02460936f, 
    -0.04761602f, 0.28379741f, -0.10838754f, 0.03945618f, -0.41485414f, 0.20317557f, 0.35540929f, -0.36805964f, 
    -0.12468624f, -0.06892215f, -0.09651224f, -0.35558054f, -0.03226228f, -0.02918649f, -0.46180573f, -0.32577816f, 
    0.23131961f, -0.31537876f, -0.34332126f, 0.09094623f, 0.05288608f, 0.00757991f, -0.32130978f, 0.00168690f, 
    -0.16618775f, 0.12379369f, 0.25051215f, 0.02404963f, 0.04251008f, -0.03033120f, -0.34498882f, 0.11557341f, 
    -0.13187996f, -0.02248285f, 0.09994280f, -0.13698737f, -0.40672636f, -0.11468742f, -0.07256891f, 0.03662774f, 
    -0.10410653f, -0.03718544f, -0.10440165f, -0.30085969f, -0.50531054f, 0.38879874f, 0.14832230f, -0.11299086f, 
    0.33178911f, 0.10029227f, -0.06684963f, 0.02867061f, 0.09516280f, -0.19328122f, -0.36702794f, -0.07550598f, 
    -0.38410407f, -0.35445383f, -0.11031722f, 0.02751960f, -0.00193685f, 0.10448733f, -0.06498640f, -0.43236333f, 
    0.20646167f, 0.12525748f, -0.11567868f, -0.26893869f, -0.17368238f, -0.01118981f, 0.00430818f, 0.34711641f, 
    0.00601073f, -0.06027949f, -0.08776027f, 0.19327556f, -0.05563620f, -0.32054952f, 0.25242129f, 0.15647073f, 
    0.07585328f, 0.34038407f, -0.30671710f, -0.08642228f, -0.11933932f, 0.11944015f, 0.15937120f, 0.02399234f, 
    -0.53753787f, 0.13604839f, 0.23424935f, 0.09072701f, 0.01239806f, -0.15135881f, 0.08542354f, 0.09002402f, 
    -0.00347711f, 0.38180831f, 0.06467609f, -0.01307519f, 0.01848193f, 0.09525719f, -0.03662293f, 0.08945692f, 
    -0.05979860f, 0.09469701f, 0.11143342f, 0.27093464f, 0.01033107f, -0.17357068f, 0.02046141f, 0.02645092f, 
    -0.33668476f, -0.09390996f, -0.02886569f, -0.05026213f, 0.10617118f, 0.01694490f, 0.20504947f, 0.05803448f, 
    0.06466845f, 0.17427543f, 0.09655920f, -0.03996908f, 0.08603525f, -0.51205289f, 0.00943763f, 0.22134472f, 
    -0.02375947f, 0.05509760f, -0.01586156f, 0.22708350f, -0.29250696f, 0.16769637f, -0.07983590f, -0.28768733f, 
    0.06161591f, 0.12407543f, 0.08274784f, -0.31303927f, 0.12281976f, 0.16615957f, 0.28515580f, 0.18191490f, 
    -0.29338858f, -0.15863046f, -0.35375917f, 0.16301191f, 0.09125511f, -0.09219762f, -0.10078921f, 0.08307483f, 
    -0.30686262f, 0.15904279f, -0.44504008f, -0.06435135f, 0.04295494f, -0.41871119f, 0.24716350f, 0.03548506f, 
    -0.06366450f, -0.30683908f, 0.11166812f, -0.04129447f, -0.08340602f, -0.52100956f, 0.02667819f, 0.06813186f, 
    -0.12372708f, 0.06923681f, -0.06056423f, 0.22618152f, 0.24770579f, -0.62600392f, 0.21463409f, -0.01556132f, 
    0.16511247f, -0.07145401f, -0.04717197f, -0.04812598f, 0.04792103f, 0.17560987f, -0.55489582f, 0.02881676f, 
    0.06985830f, 0.23725651f, -0.14570363f, 0.03807471f, -0.37154412f, 0.14000678f, 0.02717583f, 0.21957350f, 
    -0.45590436f, -0.16849475f, 0.10333360f, -0.08539573f, -0.14811182f, -0.41058743f, -0.34118891f, -0.09290335f, 
    -0.04888866f, -0.06048925f, 0.08959819f, -0.17236170f, -0.11323752f, 0.07455926f, 0.27372548f, 0.04966531f, 
    0.19231792f, -0.01621074f, -0.33247963f, -0.03516729f, -0.03916741f, 0.00217627f, 0.09375994f, -0.04884352f, 
    0.28532174f, -0.07708461f, 0.22932516f, 0.08540343f, 0.04726811f, -0.05065281f, -0.30427861f, -0.05707397f, 
    0.02492486f, 0.03493715f, 0.07117809f, -0.00191306f, 0.11375015f, 0.13774674f, -0.01674931f, -0.02380599f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04887550f, -0.09034189f, -0.04627056f, 0.04715866f, 0.00362571f, -0.06153455f, 0.09799042f, -0.20142676f, 
    -0.00807354f, -0.14183657f, 0.03303516f, -0.08491601f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
