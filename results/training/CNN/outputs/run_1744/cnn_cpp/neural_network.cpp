#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.34486571f, 0.03261809f, 0.64833075f, 0.27470919f, -0.43787029f, 0.11865254f, -0.43586630f, -0.07695895f, 
    -0.06842398f, -0.36175773f, 0.77326095f, -0.44241002f, 0.31141892f, 0.44594371f, -0.26586148f, -0.04292689f, 
    0.11484434f, -0.00252696f, 0.00445047f, -0.11753152f, -0.08238310f, -0.32077503f, -0.32567644f, 0.11171152f, 
    0.23289792f, -0.02439736f, 0.60329670f, -0.69080549f, 0.06036282f, -0.63231921f, 0.20707484f, 0.33185533f, 
    -0.12702604f, 0.36698323f, 0.03120330f, 0.51804733f, 0.03982056f, -0.67883122f, -0.35095522f, -0.03457914f, 
    0.67377216f, -0.51410276f, -0.12056226f, -0.10280351f, -0.28060800f, -0.40711439f, 0.51045185f, -0.03639153f, 
    0.03696705f, 0.56530583f, -0.00135721f, -0.12422477f, -0.27641919f, -0.32867646f, -0.53233087f, 0.61037570f, 
    0.38568228f, -0.52393645f, 0.00996001f, -0.16188425f, -0.09447842f, -0.23710041f, 0.33306557f, 0.22884203f, 
    -0.56459969f, -0.27496928f, -0.47130513f, -0.30383077f, -0.21845904f, -0.25029314f, -0.38365707f, 0.00029302f, 
    0.75970501f, -0.21945065f, 0.65200114f, -0.07399026f, 0.03367784f, 0.40635368f, 0.05507177f, 0.22755204f, 
    0.14823045f, 0.19432573f, -0.23654301f, 0.21634099f, -0.07278169f, 0.03985900f, 0.05947818f, -0.40280536f, 
    -0.19103187f, 0.65428448f, 0.77920228f, -0.53407049f, -0.30986431f, 0.14962339f, -0.37797165f, -0.32478482f, 
    0.11779380f, 0.20877112f, 0.11326434f, 0.35512081f, 0.27512401f, 0.05092606f, -0.36544234f, -0.56766427f, 
    -0.35455188f, -0.29041019f, -0.26935974f, -0.34751865f, -0.38363236f, 0.40960062f, -0.13040332f, -0.51928282f, 
    -0.47475734f, -0.02350686f, 0.36594087f, 0.34196225f, -0.08543740f, 0.40209407f, 0.19516374f, 0.09044459f, 
    0.49670073f, 0.39282849f, 0.48903763f, -0.14830577f, -0.17762955f, -0.01718076f, 0.46343571f, 0.15348053f, 
    0.38013858f, -0.77325583f, 0.15984520f, -0.27858356f, 0.31392291f, 0.04579734f, 0.16440390f, -0.26319820f, 
    0.41950130f, -0.38439062f, -0.22658606f, 0.25416818f, 0.14751226f, -0.04452094f, 0.30540979f, 0.00669453f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.18639514f, -0.14896218f, 0.20108633f, -0.14003424f, 0.09037630f, 0.18517242f, -0.14808506f, -0.05367547f, 
    0.27989632f, -0.05108780f, 0.28054705f, -0.04405927f, -0.07216597f, -0.02122325f, -0.15148607f, 0.25842109f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.22827937f, -0.40249917f, 0.08662844f, -0.07250253f, 0.05474520f, -0.03948824f, 0.08043143f, -0.15425850f, 
    -0.14415690f, 0.29755273f, 0.21284704f, 0.24937116f, 0.00275797f, 0.16849765f, 0.08798795f, -0.11894929f, 
    0.19324231f, 0.18341550f, -0.03773324f, 0.03991954f, 0.13643412f, -0.07631077f, 0.06783407f, -0.06171231f, 
    0.08629538f, -0.15127599f, 0.06340091f, 0.21364775f, 0.09087559f, -0.11832881f, -0.00186150f, -0.04516525f, 
    0.03734656f, 0.10824876f, 0.01606284f, 0.05765313f, 0.16433828f, 0.06477061f, -0.05259728f, 0.05867775f, 
    -0.00696820f, -0.08635151f, -0.11684170f, 0.01458494f, -0.02075435f, 0.03916084f, -0.00330902f, 0.09651107f, 
    0.05590895f, -0.06411593f, 0.07145732f, -0.17699534f, -0.10926654f, -0.11884478f, 0.02662989f, -0.19093670f, 
    0.25190121f, 0.11873816f, 0.12127208f, 0.06583806f, 0.09039060f, 0.04788426f, -0.14376074f, 0.20621775f, 
    -0.02189697f, 0.21669582f, -0.00677494f, 0.10645194f, 0.01551273f, 0.00993331f, 0.02313747f, -0.29172027f, 
    -0.06018833f, 0.03734898f, -0.04730375f, 0.03289424f, -0.01048724f, 0.15523727f, -0.05886737f, -0.01601818f, 
    0.10949089f, -0.05881829f, 0.04932549f, 0.18883528f, -0.21556942f, 0.09516845f, -0.28520167f, 0.14172280f, 
    -0.06784533f, 0.35671765f, -0.04311552f, -0.00525021f, -0.04296106f, -0.02005677f, -0.05618900f, -0.08132163f, 
    0.07775809f, 0.01842519f, 0.04072739f, -0.03977471f, 0.14924148f, -0.11338507f, -0.00246062f, -0.06152331f, 
    -0.03076022f, -0.06489677f, -0.04699006f, -0.08801086f, -0.05830136f, 0.11884201f, 0.11119957f, -0.03498439f, 
    0.14434372f, -0.00489855f, -0.05278375f, 0.24918622f, 0.14186104f, -0.05165124f, -0.13687000f, -0.24149504f, 
    0.04927507f, -0.18792550f, -0.12899752f, 0.00302323f, -0.13399567f, -0.06894630f, -0.24093440f, 0.05922190f, 
    -0.03110933f, 0.02062186f, -0.01337832f, 0.07211042f, -0.15531614f, 0.21260753f, 0.07616942f, 0.02291985f, 
    0.15160368f, 0.10233890f, -0.03603503f, 0.00198909f, 0.01135372f, 0.06303049f, 0.05054109f, 0.02569669f, 
    0.14051741f, 0.05567659f, 0.09448724f, -0.06577106f, -0.14703955f, -0.10685869f, 0.12195256f, -0.03212476f, 
    -0.00576588f, 0.01800370f, -0.22152881f, -0.44701126f, -0.09007231f, 0.09613509f, 0.03997866f, 0.04993975f, 
    0.16664565f, -0.06687763f, 0.23087543f, 0.02623662f, 0.17490138f, 0.05877428f, 0.05224235f, -0.13372551f, 
    0.06339210f, 0.06838676f, -0.32612592f, 0.06837896f, -0.43617520f, -0.10849332f, 0.15593474f, -0.17150934f, 
    -0.13170841f, 0.02238223f, 0.11546802f, -0.01134155f, -0.26973310f, 0.18050356f, -0.01501742f, -0.04455208f, 
    0.11549645f, 0.07633562f, -0.03487693f, 0.10749187f, 0.13345060f, 0.24068880f, -0.01057431f, -0.17718543f, 
    -0.12000427f, 0.04406479f, 0.01112575f, 0.14582060f, -0.05704472f, 0.13491975f, 0.11884662f, 0.08727845f, 
    0.26542705f, -0.23434198f, 0.00224102f, -0.15124989f, 0.05992730f, 0.06573261f, 0.12370486f, 0.25109318f, 
    0.12796353f, 0.07551538f, -0.01772664f, -0.00799913f, -0.05891212f, -0.04340933f, 0.08953416f, 0.04459275f, 
    0.30920994f, 0.21321018f, -0.21342331f, -0.15870802f, -0.01370215f, 0.00597437f, 0.06064297f, 0.00252984f, 
    -0.07190741f, 0.10702763f, -0.03751510f, -0.01601276f, -0.07447794f, 0.01704539f, -0.25605324f, -0.09347858f, 
    0.04729798f, -0.08982082f, -0.51771581f, 0.27702835f, 0.22182013f, -0.15244000f, 0.05923587f, -0.09599318f, 
    0.02313005f, -0.01932852f, -0.09053329f, 0.28308180f, 0.07450999f, 0.47557142f, -0.16381161f, 0.03801009f, 
    -0.09877133f, -0.03248913f, 0.06648814f, 0.11144430f, 0.17022571f, -0.19877295f, -0.12732132f, -0.16863416f, 
    0.10065769f, -0.13922644f, 0.08273396f, -0.04133936f, 0.11789891f, -0.17710088f, 0.33226457f, 0.19597244f, 
    -0.06877035f, -0.02716066f, 0.13488123f, 0.03085149f, -0.03173301f, 0.18482517f, 0.00905057f, 0.06623728f, 
    -0.41285232f, 0.08680496f, -0.03568231f, -0.03872853f, -0.18383770f, 0.13640125f, -0.07570808f, 0.15020318f, 
    -0.25006226f, -0.07201934f, -0.01819232f, -0.03317303f, 0.04207439f, -0.05323424f, 0.03296477f, 0.01549279f, 
    0.28349248f, 0.20271285f, -0.05706427f, 0.05623941f, 0.11005264f, 0.01513365f, -0.01782565f, 0.17814463f, 
    -0.11021303f, 0.05236417f, 0.11261036f, 0.02736115f, 0.03128187f, -0.00280299f, 0.08271060f, 0.17379542f, 
    0.11433643f, 0.05284404f, 0.07409538f, 0.01144129f, -0.04550772f, 0.03988592f, 0.13362679f, -0.09746536f, 
    -0.18110871f, -0.25369370f, -0.49503338f, -0.08068243f, 0.32864791f, -0.01960548f, -0.04228056f, -0.05804405f, 
    0.01175527f, -0.18412517f, 0.00962218f, -0.07180062f, -0.01968806f, 0.09662966f, -0.08529301f, 0.05806250f, 
    -0.07176419f, 0.06344807f, 0.18910983f, 0.15284714f, 0.22172928f, -0.06004353f, -0.06381371f, 0.10393961f, 
    0.04533117f, 0.08747008f, -0.07111452f, 0.11314536f, -0.03373311f, 0.16975841f, -0.18755616f, 0.13415806f, 
    -0.22858940f, -0.21324027f, 0.07241690f, 0.09662949f, 0.11784838f, -0.09118026f, 0.02115680f, -0.15955506f, 
    0.00395245f, 0.15820411f, 0.03734629f, 0.10737983f, 0.08118720f, 0.00916956f, -0.02706964f, -0.01530381f, 
    0.13891678f, 0.07577976f, 0.10296040f, 0.03751668f, -0.02739989f, 0.02169710f, -0.03310348f, -0.03464248f, 
    -0.01107968f, -0.00811531f, 0.16443904f, 0.16600855f, -0.03312968f, 0.12883301f, 0.05355654f, 0.05356760f, 
    -0.16277076f, -0.06984876f, -0.03265991f, -0.05162853f, 0.13587397f, -0.14746511f, 0.13777937f, 0.04429711f, 
    -0.18321581f, 0.05342526f, -0.17688088f, 0.06178332f, 0.14458314f, 0.08237232f, 0.09683057f, 0.08133546f, 
    0.09517553f, 0.22725929f, 0.12350582f, -0.03862334f, 0.02881112f, 0.01568236f, -0.08148287f, 0.03281802f, 
    0.12299198f, -0.11102141f, -0.16436271f, -0.11778720f, -0.09494096f, -0.20548023f, -0.19607699f, -0.10370418f, 
    0.19676633f, 0.16167495f, -0.05886287f, -0.02614328f, 0.09228698f, -0.24350555f, -0.03112801f, 0.08377080f, 
    0.17836115f, 0.00980066f, -0.12849741f, 0.00133785f, -0.06440462f, 0.09477769f, -0.09611021f, -0.25177106f, 
    0.09424520f, -0.03120753f, 0.08537880f, 0.09257774f, 0.06022117f, 0.01121470f, -0.13140854f, 0.12202415f, 
    -0.24197443f, -0.17017396f, -0.20612507f, -0.03105277f, 0.09958373f, -0.12429380f, 0.04627432f, -0.14506014f, 
    -0.14115839f, -0.25972885f, -0.11755629f, 0.00894543f, -0.01955529f, -0.20664902f, 0.08869134f, 0.12141608f, 
    0.12413877f, 0.09592637f, 0.05096864f, -0.06268483f, -0.10685464f, -0.04040850f, 0.00125218f, 0.07910557f, 
    0.07392651f, 0.08000207f, 0.08033572f, -0.46261185f, 0.40810868f, 0.29745427f, 0.06803561f, 0.06909525f, 
    -0.11497289f, 0.05837473f, 0.00839254f, 0.01498271f, -0.30453429f, -0.13676471f, -0.02515281f, -0.17438211f, 
    0.10789081f, -0.04709850f, 0.05066904f, 0.01865324f, 0.09436231f, 0.10075205f, 0.07856360f, 0.07825267f, 
    -0.14393380f, -0.05510040f, 0.12804280f, 0.03419360f, 0.01929052f, 0.15796921f, -0.21754840f, -0.33235568f, 
    -0.43553376f, -0.02915149f, 0.00822296f, -0.09434041f, 0.01677403f, -0.01550065f, 0.07180962f, -0.15940185f, 
    -0.22842181f, -0.03403532f, -0.02276450f, -0.04197555f, -0.15450957f, 0.15675931f, -0.05453430f, 0.07306273f, 
    0.12330227f, 0.06387883f, -0.12321784f, 0.15077718f, 0.01021230f, 0.06960303f, 0.02513640f, -0.04094620f, 
    0.12570809f, -0.00774233f, -0.17874107f, -0.07156088f, 0.13764699f, -0.05502594f, 0.09949074f, -0.02165825f, 
    0.06552216f, 0.07027896f, 0.25819799f, 0.30988330f, -0.18652648f, 0.09594607f, -0.04261239f, -0.09568644f, 
    0.08431424f, -0.00629157f, -0.00518016f, -0.21707195f, -0.15612495f, -0.12800102f, 0.02611278f, 0.12543310f, 
    0.02577996f, -0.03080722f, -0.01473540f, -0.01045278f, -0.41480607f, -0.21957591f, -0.50473928f, 0.05588765f, 
    0.07461932f, -0.02639676f, 0.09675302f, 0.03725119f, 0.04562183f, -0.15494996f, 0.11085299f, -0.14076661f, 
    -0.13848852f, -0.06040135f, -0.02673909f, -0.03538281f, -0.10066912f, 0.17012551f, 0.19552287f, -0.44639888f, 
    -0.42708409f, 0.04051619f, -0.04888090f, 0.01366852f, 0.04274140f, 0.22575280f, -0.07569762f, 0.05467676f, 
    0.25897941f, 0.10178477f, 0.12010927f, 0.08163052f, 0.04746128f, 0.09149575f, 0.19599061f, 0.10509802f, 
    0.05728072f, -0.07805155f, 0.02766392f, 0.02245463f, -0.07045554f, -0.02923685f, -0.01072435f, 0.03069009f, 
    0.00307839f, 0.03580206f, -0.03645247f, -0.08330569f, 0.00511194f, 0.02331419f, 0.07351692f, 0.06932801f, 
    0.01683125f, -0.04393934f, 0.02635190f, -0.08138692f, -0.05936457f, 0.03123706f, -0.06624479f, -0.02630672f, 
    -0.04717383f, -0.06155320f, -0.03054282f, -0.04224780f, 0.07468765f, 0.03297256f, 0.01043376f, -0.01209279f, 
    0.04200535f, -0.03097268f, 0.02017672f, 0.06878442f, -0.07244593f, 0.02803311f, -0.07042018f, 0.03457725f, 
    0.04748666f, -0.04999207f, 0.05382066f, 0.06191225f, 0.00936187f, 0.02430413f, 0.01384091f, -0.00177174f, 
    -0.00415148f, 0.02736573f, -0.08603493f, -0.04741576f, 0.05744099f, 0.05431768f, -0.00481534f, 0.01341100f, 
    -0.07258065f, -0.01559463f, 0.03599258f, -0.01184002f, -0.01035008f, -0.01071867f, 0.04230607f, 0.03392842f, 
    0.02077880f, -0.00353003f, -0.04184514f, -0.04775633f, -0.07618854f, -0.07916101f, 0.01068999f, 0.04829803f, 
    -0.04251123f, 0.00543375f, -0.05993409f, -0.05757926f, 0.06524816f, -0.00554112f, 0.01955767f, -0.05849956f, 
    -0.05912139f, -0.02797644f, -0.05167761f, 0.05559625f, -0.02046884f, 0.02606885f, 0.05372470f, -0.00579674f, 
    0.06525752f, -0.00452908f, -0.07789095f, -0.04331847f, 0.04587182f, -0.05161725f, -0.02690929f, 0.02083386f, 
    -0.02325589f, -0.06074769f, -0.03550233f, -0.04480056f, -0.04289570f, -0.07001652f, -0.07464308f, 0.04362396f, 
    -0.05779469f, -0.07699591f, 0.05600204f, 0.02981543f, 0.06802516f, 0.04599983f, 0.03881196f, 0.00589023f, 
    -0.06966045f, -0.06617986f, 0.00315785f, 0.01729413f, -0.04139914f, 0.06498051f, 0.00894275f, 0.03793516f, 
    -0.06415527f, 0.00000707f, -0.06295214f, -0.07188474f, 0.01652665f, -0.08738179f, 0.04197840f, -0.00249275f, 
    0.02981021f, -0.02806985f, 0.05745545f, -0.00063542f, 0.05562571f, -0.08356155f, -0.05853338f, -0.05221992f, 
    -0.08287273f, -0.02754814f, 0.02565962f, -0.05559171f, -0.06722418f, 0.01653371f, 0.04514507f, -0.05876636f, 
    -0.00502935f, -0.20848404f, -0.20554993f, 0.07057358f, 0.04887279f, -0.07318874f, -0.07358561f, -0.13008411f, 
    -0.07018546f, -0.10908780f, 0.19878493f, 0.01654991f, 0.28762528f, 0.07972876f, 0.10360173f, -0.15145038f, 
    0.23457585f, -0.14503777f, 0.03509900f, 0.08442397f, -0.03912540f, 0.11050148f, 0.03521329f, 0.00482167f, 
    0.09386788f, 0.01282581f, 0.09112740f, -0.03084514f, 0.21899514f, 0.15435663f, 0.10372330f, 0.11300623f, 
    -0.01019746f, 0.05157831f, 0.12612846f, 0.05032876f, 0.14867410f, 0.01937594f, -0.08511616f, 0.08761202f, 
    -0.01609677f, -0.00962351f, -0.06570803f, -0.05075783f, -0.20663120f, -0.13638759f, 0.00781288f, -0.03399081f, 
    0.10556452f, -0.04079203f, -0.07515489f, -0.05085301f, -0.20748635f, -0.27620286f, -0.04093815f, 0.01432951f, 
    0.03993426f, 0.11167325f, 0.01488762f, 0.12709504f, -0.07125363f, 0.15951079f, 0.01347740f, 0.24548198f, 
    -0.14540432f, 0.09813678f, 0.16598907f, 0.06828475f, 0.22329910f, 0.14964359f, 0.11624200f, -0.08627196f, 
    -0.15127590f, 0.10852630f, -0.06695238f, 0.15743452f, 0.10870571f, 0.04087063f, 0.02064059f, -0.00356143f, 
    0.08491994f, 0.06940823f, 0.10329794f, 0.03174300f, 0.06053852f, -0.07881574f, -0.09320064f, 0.11391148f, 
    0.09659611f, 0.05721329f, -0.11960455f, -0.29668596f, 0.00687728f, 0.04212914f, 0.04302179f, 0.10195190f, 
    -0.05980315f, 0.03380753f, -0.00397836f, -0.24021894f, -0.23370282f, -0.07491790f, 0.06402864f, 0.05573449f, 
    0.13915953f, -0.13113008f, 0.04469392f, 0.00519249f, 0.16188541f, 0.02633698f, -0.11773118f, 0.10873532f, 
    -0.05635639f, 0.15230738f, 0.00155338f, 0.16417015f, 0.22456038f, -0.19826318f, -0.13041709f, -0.02162653f, 
    -0.00051960f, -0.03090729f, 0.14221372f, 0.11991196f, -0.05709938f, -0.14160252f, -0.05349659f, -0.03511814f, 
    -0.08844572f, -0.10977065f, 0.03806145f, 0.13021219f, 0.09442914f, -0.02746258f, 0.05518637f, 0.09297250f, 
    0.03833847f, -0.02164291f, 0.04850573f, -0.01268693f, 0.16125196f, -0.00720323f, -0.05272420f, 0.12507199f, 
    -0.02640334f, -0.03853355f, -0.22754644f, 0.01230754f, 0.00578572f, -0.07220698f, 0.17943084f, -0.07306122f, 
    -0.02036401f, 0.36371771f, -0.22262913f, -0.31944144f, -0.12547491f, -0.32971871f, -0.18124144f, 0.00371779f, 
    -0.05213406f, -0.07005957f, 0.06141862f, -0.06221884f, 0.06814831f, 0.09583993f, 0.14073472f, 0.14519818f, 
    0.13898915f, 0.06475158f, 0.21645349f, -0.04455845f, 0.04607190f, 0.15229648f, 0.04197185f, 0.14050724f, 
    0.01905589f, -0.03306691f, -0.08910909f, 0.15817191f, 0.01085886f, -0.08224158f, 0.33696520f, 0.01260593f, 
    0.08165960f, -0.10640915f, 0.08248536f, -0.03145528f, -0.08373427f, 0.01006211f, 0.06348266f, -0.12965521f, 
    -0.07713467f, -0.13947533f, -0.16558041f, 0.06697864f, -0.01082203f, 0.01922734f, -0.25184435f, 0.09509756f, 
    -0.02325741f, 0.17061655f, -0.07201873f, -0.00815825f, -0.09220316f, -0.02106078f, 0.01979212f, -0.15903029f, 
    -0.28267792f, -0.07737166f, 0.13975811f, 0.03436153f, -0.09474626f, -0.06294819f, 0.05012192f, 0.05208892f, 
    0.05843772f, 0.36974949f, -0.06665156f, 0.03035655f, 0.18645057f, -0.00731568f, 0.00571303f, 0.10635734f, 
    0.09437837f, 0.06906816f, 0.28049502f, 0.06540943f, -0.07482160f, 0.04862759f, -0.02033662f, 0.04438666f, 
    -0.10560460f, 0.11070026f, -0.23968050f, 0.07696768f, 0.08853184f, -0.08783612f, -0.04393902f, -0.01539393f, 
    0.06382305f, 0.20081294f, 0.17648919f, -0.18057744f, -0.38356948f, 0.24527991f, -0.04287900f, 0.01820126f, 
    -0.00454352f, 0.11021697f, -0.00984990f, -0.06220375f, -0.04804188f, -0.35540169f, -0.16905253f, -0.01359725f, 
    -0.00779279f, 0.02402495f, -0.10316914f, 0.01254123f, 0.02359990f, -0.31699979f, -0.10287991f, -0.10105150f, 
    -0.05214047f, 0.08806846f, -0.25644487f, -0.00006128f, -0.01790914f, -0.13723668f, -0.33274314f, -0.24807492f, 
    0.00219495f, -0.07432854f, -0.04395556f, 0.03561709f, -0.00538660f, 0.01559010f, 0.15255317f, 0.22407416f, 
    0.00831786f, 0.21838896f, 0.06473862f, 0.05107599f, 0.10530993f, -0.05328213f, 0.09346084f, 0.13628465f, 
    0.12754023f, -0.06671824f, 0.28128487f, -0.05255036f, 0.04775827f, 0.02720547f, 0.01893174f, -0.07936181f, 
    -0.17157373f, -0.20446354f, -0.31822643f, -0.26018253f, -0.21183524f, -0.01122420f, 0.01179421f, 0.01970730f, 
    -0.14287318f, -0.08320184f, 0.02872938f, 0.05105279f, 0.06234213f, 0.12452549f, 0.08885320f, -0.01788689f, 
    0.19836825f, -0.01133157f, 0.05407603f, -0.28459477f, 0.17988785f, -0.12253118f, -0.14853032f, 0.06704430f, 
    0.00775279f, 0.06536151f, -0.04740511f, -0.04531308f, -0.15177856f, -0.03428616f, -0.04458595f, 0.12856370f, 
    -0.19001551f, -0.02576555f, -0.00105352f, -0.09920408f, 0.05741336f, -0.03545684f, -0.24905528f, -0.23530887f, 
    -0.07121680f, 0.12658018f, -0.04483627f, -0.04307112f, -0.10351317f, 0.00541715f, 0.07101236f, -0.08514436f, 
    0.49382117f, 0.19056770f, -0.11711748f, 0.09531499f, 0.04330749f, 0.04547968f, 0.00256280f, 0.11641870f, 
    0.25796235f, -0.10504156f, -0.07504804f, -0.29701805f, 0.12494472f, -0.02121408f, -0.12696527f, 0.04997886f, 
    0.33166614f, 0.24021125f, 0.10397830f, -0.03222705f, 0.03426110f, 0.18557386f, 0.02994785f, 0.03273014f, 
    0.14490359f, -0.10421851f, 0.22577584f, 0.36720046f, 0.08098767f, -0.04248656f, 0.09518659f, 0.21352829f, 
    0.09065989f, -0.11927823f, -0.10911387f, -0.16955446f, -0.30079913f, -0.06088472f, -0.02783541f, -0.07332540f, 
    -0.01507590f, 0.00166332f, 0.03880144f, 0.38590622f, 0.00306778f, -0.05265901f, -0.19996791f, -0.16983958f, 
    0.02150453f, 0.04446362f, 0.00824453f, 0.01382246f, -0.30121237f, -0.25484228f, -0.24420309f, -0.08964866f, 
    -0.13719104f, -0.09603652f, 0.02300836f, -0.01597020f, -0.02341960f, 0.06158109f, 0.04364843f, 0.01185263f, 
    -0.02395399f, 0.06493860f, -0.07551980f, -0.21834008f, -0.09450950f, 0.13711011f, 0.50565344f, 0.18984459f, 
    0.11440159f, -0.02766989f, 0.17710263f, -0.15222727f, -0.14362258f, -0.03601955f, 0.05871224f, -0.01098531f, 
    -0.23169665f, -0.13601850f, 0.18767990f, 0.18833962f, 0.01207703f, -0.00004173f, 0.16026548f, -0.00549439f, 
    0.07973418f, -0.07604115f, -0.03574166f, 0.05282640f, 0.00039723f, 0.07842422f, -0.02224081f, 0.07808139f, 
    -0.04187968f, -0.06222364f, 0.00262964f, 0.00074804f, 0.05654269f, -0.06076523f, 0.07761781f, -0.05489701f, 
    0.00563471f, -0.02274907f, 0.00445387f, 0.08115860f, 0.03868556f, 0.03195363f, 0.05315741f, -0.02667170f, 
    -0.03208501f, 0.01723027f, 0.00459791f, -0.05806592f, -0.01369105f, 0.04723559f, -0.04716910f, 0.05006696f, 
    0.01142108f, -0.02885903f, -0.06295009f, 0.00478587f, -0.03322044f, 0.05193829f, 0.05659963f, -0.05579734f, 
    0.04068445f, 0.04940985f, -0.07291417f, -0.07403760f, -0.01521011f, 0.06200686f, -0.03607118f, 0.01131796f, 
    -0.01634069f, 0.01685268f, -0.04632879f, -0.06531494f, -0.02370375f, 0.04698668f, -0.01338510f, -0.07319026f, 
    -0.07629499f, -0.04407626f, -0.07889099f, -0.03019585f, -0.02043877f, -0.01866543f, -0.04448640f, 0.00450454f, 
    0.03430977f, 0.00629670f, -0.04331205f, 0.05670562f, 0.01206626f, -0.02161983f, -0.01859975f, 0.07490300f, 
    -0.08087300f, -0.06774260f, -0.06506671f, -0.02537509f, 0.01002350f, -0.07067030f, 0.00915020f, -0.08255358f, 
    0.06641879f, -0.06031058f, 0.03497734f, -0.06841134f, -0.00464114f, -0.03677772f, -0.07900336f, -0.06474724f, 
    -0.02335370f, -0.04168028f, 0.00274105f, 0.04457459f, -0.02101874f, -0.06549528f, -0.04101300f, -0.05133891f, 
    0.05452558f, -0.02321579f, -0.03601801f, -0.06147870f, -0.05283128f, 0.06313287f, -0.02035925f, -0.05073725f, 
    0.07294580f, -0.03682382f, -0.03722883f, 0.06039999f, -0.03963044f, -0.01491079f, -0.04376725f, -0.01353826f, 
    0.01900575f, -0.07694491f, -0.01262110f, -0.03175908f, -0.01881659f, -0.07439881f, -0.06989175f, -0.00157326f, 
    -0.05758515f, -0.00714447f, 0.01072761f, 0.06752782f, -0.02016654f, -0.02372825f, -0.07407307f, -0.04427788f, 
    -0.02815736f, -0.02464689f, -0.02196895f, -0.05570953f, -0.05430930f, -0.07001959f, 0.07078238f, 0.03866024f, 
    0.07215011f, -0.04216164f, -0.03688132f, -0.02987402f, -0.05156711f, -0.07181915f, -0.07151170f, -0.04638225f, 
    -0.06702476f, -0.05111100f, -0.05541415f, 0.01904542f, -0.03813534f, 0.02273180f, -0.08896928f, 0.03806039f, 
    0.03884370f, 0.01660674f, -0.00684006f, -0.03414633f, 0.05280054f, -0.04449622f, -0.08580867f, 0.02650625f, 
    -0.03815492f, 0.02730552f, -0.01563079f, -0.05145093f, 0.03951991f, 0.04340161f, 0.04140161f, -0.01036776f, 
    0.03957991f, -0.04628630f, 0.03777304f, 0.01455035f, -0.02357855f, -0.08176430f, -0.07630474f, -0.08584701f, 
    -0.03370982f, 0.00865096f, 0.00290895f, -0.07178521f, 0.06498133f, 0.00818926f, -0.05932156f, 0.00302820f, 
    -0.09178983f, 0.04832984f, -0.07319006f, -0.08319867f, -0.07858119f, -0.06132701f, -0.11703325f, 0.04456865f, 
    0.05446946f, 0.00709054f, -0.08394685f, 0.02080435f, -0.08005070f, -0.04405371f, -0.07626049f, 0.02883511f, 
    -0.03398686f, -0.08533436f, -0.08649810f, -0.03795366f, 0.02184997f, 0.00553981f, 0.04086722f, -0.05723603f, 
    -0.07603613f, 0.07010582f, 0.02904593f, 0.01116087f, 0.01951157f, -0.07506187f, -0.05305675f, 0.04465581f, 
    0.00813523f, -0.02438090f, -0.02585133f, 0.00852730f, 0.03021982f, -0.03997497f, -0.01886201f, -0.11986154f, 
    -0.01545865f, 0.00022543f, 0.03646986f, -0.06550223f, -0.07217912f, -0.07551844f, 0.04265736f, -0.09191832f, 
    -0.00629561f, -0.08819197f, -0.03627777f, -0.10110174f, -0.01725287f, -0.01434066f, -0.08382798f, -0.09611104f, 
    -0.06805274f, 0.03787445f, 0.05038887f, 0.03938949f, 0.02627263f, -0.07875470f, -0.00109655f, -0.03878875f, 
    -0.07307015f, -0.00773709f, -0.02372670f, 0.02117059f, 0.06978460f, 0.04276906f, 0.06190259f, -0.06032621f, 
    -0.04221739f, 0.04806432f, 0.01965746f, -0.08045954f, 0.03750976f, 0.00733791f, -0.10268397f, -0.01063313f, 
    0.00175648f, 0.01162063f, 0.05716176f, -0.01458973f, -0.07421009f, -0.09941281f, -0.09755551f, -0.10376749f, 
    0.03445857f, 0.03243949f, -0.08205785f, -0.03306732f, -0.00747284f, -0.01983720f, 0.00374402f, 0.02970748f, 
    -0.10162392f, -0.03375329f, -0.10786303f, -0.00963147f, -0.10882372f, 0.03372342f, -0.04613185f, -0.05391601f, 
    -1.05185676f, -0.55684865f, -0.25749135f, -0.14861560f, 0.02255407f, -0.15018360f, 0.10172422f, -0.04086629f, 
    0.07646925f, -0.31345052f, 0.15606719f, -0.08767980f, -0.36448711f, 0.17211807f, -0.01244367f, -0.04611276f, 
    0.10617300f, -0.13735034f, -0.12590984f, 0.32170659f, 0.22772746f, -0.06884463f, -0.06950243f, -0.03408947f, 
    0.06314053f, 0.02298961f, -0.07415026f, 0.04848646f, -0.09724075f, 0.30481312f, -0.15453792f, -0.00190921f, 
    -0.12835240f, -0.06389354f, 0.14461640f, 0.03739144f, -0.16775078f, 0.13496415f, 0.20041066f, 0.12097722f, 
    -0.17715301f, -0.11363558f, 0.06061362f, 0.00982499f, -0.01474703f, -0.27347988f, 0.01489359f, -0.14408915f, 
    -0.03182386f, -0.06982408f, 0.07859282f, -0.09613451f, -0.02416157f, -0.00324546f, -0.09696970f, 0.04245028f, 
    0.06494860f, 0.13057737f, -0.11697792f, -0.08041519f, -0.12000807f, -0.14278872f, -0.04842430f, 0.05409481f, 
    0.11709829f, 0.16421849f, 0.09326429f, -0.10399441f, 0.14124209f, 0.08832146f, 0.01645511f, 0.05123560f, 
    -0.19742906f, 0.00034083f, -0.21822909f, 0.04710573f, 0.10333643f, 0.02207442f, 0.14911729f, 0.11317213f, 
    0.09104512f, -0.13476051f, 0.01621045f, -0.33622140f, -0.01473703f, -0.18715270f, 0.06676700f, -0.19313304f, 
    0.15043312f, 0.04867541f, 0.01615963f, 0.17630711f, 0.17784834f, 0.07207293f, 0.08451732f, 0.17182025f, 
    0.01866881f, -0.02312939f, 0.17439060f, 0.10981355f, -0.11629608f, 0.10689734f, 0.17093749f, -0.09677368f, 
    0.05981294f, 0.05209243f, 0.02639967f, -0.04046553f, 0.20477502f, 0.09277137f, 0.06339244f, -0.04084391f, 
    0.08506387f, 0.02312875f, 0.05079225f, 0.17330135f, -0.00097005f, 0.00785925f, 0.05339429f, -0.00630688f, 
    -0.04640909f, -0.22377558f, 0.05904308f, 0.03239832f, 0.08213455f, 0.04323524f, -0.28264666f, -0.06498921f, 
    -0.18604845f, -0.03677820f, -0.01310071f, -0.20189440f, -0.00771179f, -0.05064066f, 0.05198825f, -0.09849166f, 
    0.10736123f, -0.06516557f, -0.00699063f, 0.11097658f, 0.20987310f, 0.09345403f, -0.02208012f, 0.02732714f, 
    0.02545728f, -0.12939362f, 0.13138106f, -0.06004772f, 0.16107677f, 0.02602066f, -0.05671347f, 0.16674735f, 
    0.17537516f, 0.22130066f, 0.25469071f, 0.29719925f, -0.30229634f, -0.00013773f, -0.05699331f, 0.06084230f, 
    -0.26020443f, 0.01130183f, 0.05586178f, 0.06282713f, 0.01509509f, 0.11128449f, 0.13667557f, 0.05382256f, 
    -0.00472032f, 0.03061948f, -0.13477407f, 0.63497210f, -0.04908960f, -0.32461071f, -0.03498238f, 0.04308108f, 
    -0.09932290f, 0.15590432f, -0.05505949f, 0.01520839f, -0.13545237f, -0.36355895f, -0.14353800f, -0.03180879f, 
    -0.11561238f, 0.01197108f, 0.01275292f, 0.04696161f, -0.00862195f, 0.11141504f, 0.08377637f, -0.02154707f, 
    -0.08041345f, 0.09052923f, -0.01764547f, -0.03395956f, 0.07626067f, 0.09424642f, -0.41282445f, -0.09482291f, 
    -0.23944207f, 0.04154179f, 0.12377578f, -0.02730325f, 0.03788831f, -0.06677096f, -0.05582504f, -0.04445734f, 
    -0.13693863f, -0.09878390f, -0.03268156f, -0.19428553f, 0.08494630f, 0.18588285f, -0.00116529f, -0.01404886f, 
    0.11713479f, -0.10635318f, 0.19192089f, 0.01993211f, 0.05644126f, 0.02259869f, 0.08402490f, 0.01750389f, 
    -0.03407824f, -0.25694191f, -0.19487375f, -0.00474966f, 0.05588752f, -0.04549389f, -0.09506216f, 0.06647221f, 
    0.01034671f, 0.00615660f, -0.00559128f, -0.28479707f, 0.26836464f, -0.10018887f, 0.01107056f, -0.06532091f, 
    0.19901338f, 0.10677479f, -0.03523512f, -0.02515908f, -0.33115801f, -0.27207476f, 0.04804959f, -0.06974705f, 
    0.05474053f, 0.17185159f, -0.05766962f, 0.13491695f, 0.28407216f, -0.03549389f, 0.13778381f, -0.05486456f, 
    -0.03703250f, 0.02565273f, -0.06246943f, -0.07455806f, 0.02276575f, 0.16279763f, 0.05358728f, 0.34431779f, 
    -0.16518581f, -0.20725764f, 0.00832293f, -0.05964016f, 0.01273398f, 0.02421754f, 0.10588264f, 0.04147028f, 
    -0.06963322f, 0.04477489f, 0.12689723f, 0.13018115f, 0.05616335f, 0.02105235f, -0.06762703f, -0.02169467f, 
    0.11176057f, -0.44943461f, 0.12384105f, -0.13262394f, -0.01408240f, 0.12466545f, 0.03813190f, -0.11517011f, 
    -0.49972209f, -0.15851150f, -0.28337350f, -0.05978530f, -0.19636653f, -0.00278093f, 0.11266146f, -0.06468408f, 
    -0.08400138f, -0.24096218f, -0.06050385f, -0.86172932f, -0.12547481f, -0.06348393f, -0.11279721f, 0.01991203f, 
    0.13043192f, -0.06191787f, 0.21610865f, 0.22939356f, 0.18996821f, -0.03498749f, 0.01578218f, -0.07647513f, 
    0.00533637f, -0.02705464f, -0.02806247f, -0.01183291f, 0.00280176f, -0.13535221f, 0.00746136f, -0.08650714f, 
    0.15185229f, 0.04737020f, -0.02368632f, 0.10811748f, 0.33991522f, -0.13517404f, -0.00710855f, 0.12728716f, 
    0.10429201f, 0.05463580f, 0.07072078f, 0.05681880f, 0.07146667f, -0.44599593f, -0.20609577f, 0.28859249f, 
    -0.11611874f, -0.09883410f, 0.04431497f, 0.09355710f, -0.06313492f, 0.12432136f, -0.20086543f, -0.21986906f, 
    -0.10022473f, 0.00026428f, 0.12975526f, 0.00029989f, 0.05867133f, 0.09526556f, 0.06916797f, 0.21206440f, 
    0.14977126f, 0.21697158f, 0.04141739f, 0.12964027f, -0.02503904f, -0.00567239f, 0.00112991f, 0.02661374f, 
    -0.06688854f, -0.15995143f, -0.12950024f, -0.09894618f, 0.04562208f, 0.03972242f, 0.01718311f, 0.04944848f, 
    0.12720484f, -0.23994252f, 0.00430189f, 0.11262528f, -0.01616870f, 0.10681953f, -0.02200640f, 0.10360269f, 
    0.03389991f, -0.02255917f, 0.28456166f, 0.22629710f, -0.24514183f, -0.07858753f, 0.05954000f, -0.13216920f, 
    0.07033907f, 0.09535353f, 0.12167044f, -0.15670389f, 0.26481384f, 0.07655319f, -0.05372931f, -0.01059953f, 
    -0.05002177f, 0.00241885f, 0.02619400f, 0.02224133f, 0.05343790f, 0.12474865f, 0.13488421f, -0.09619402f, 
    0.00486414f, -0.26072288f, 0.00418243f, 0.09607852f, -0.00022165f, 0.55223906f, -0.02169934f, 0.12301075f, 
    0.03833380f, -0.14268339f, -0.04069060f, 0.04673604f, 0.07208799f, 0.00659372f, 0.14784211f, -0.42861110f, 
    -0.05337276f, 0.02013219f, -0.18595487f, -0.00457963f, -0.07504386f, -0.08652277f, 0.01913363f, -0.31071571f, 
    -0.25258511f, -0.28612924f, 0.04115269f, -0.05049181f, 0.06681061f, -0.02979627f, 0.06477906f, -0.13959180f, 
    -0.00285072f, 0.08015770f, -0.04749601f, -0.06236924f, 0.27090555f, -0.17919822f, -0.01784892f, -0.05471875f, 
    0.10492126f, -0.09096059f, -0.31912699f, -0.24563481f, -0.07668977f, 0.15039082f, 0.14341420f, -0.00234058f, 
    -0.23171915f, -0.09220571f, -0.17622611f, 0.12690350f, -0.11898824f, 0.11017384f, 0.13446660f, 0.11057772f, 
    0.08181692f, 0.10339445f, 0.03615008f, -0.43481705f, 0.10228468f, -0.02378093f, 0.07535496f, 0.22011518f, 
    0.01121495f, 0.11690175f, -0.07968875f, -0.11719022f, -0.09022453f, -0.19368932f, 0.00304815f, -0.14225243f, 
    -0.03515039f, 0.05846955f, -0.02756464f, -0.05836058f, -0.04404455f, -0.05134881f, 0.10535976f, 0.04150390f, 
    0.13760746f, 0.08824750f, 0.04330624f, -0.02327265f, -0.09710058f, 0.25067297f, 0.01025715f, -0.03675716f, 
    -0.16783175f, 0.02959089f, -0.05743529f, 0.12901871f, -0.07873502f, 0.03577669f, -0.05768909f, -0.45789316f, 
    -0.51175207f, -0.27019054f, 0.01285145f, 0.08291530f, 0.03458775f, 0.11774858f, -0.03468345f, -0.02734536f, 
    0.52174443f, 0.13022393f, -0.03234807f, -0.19400062f, -0.05148061f, 0.23157738f, 0.04837491f, -0.05280729f, 
    0.09401733f, 0.23272863f, 0.20441124f, 0.18114612f, 0.10370915f, -0.00470626f, -0.04571376f, 0.06289488f, 
    -0.04325462f, -0.02678055f, -0.00311305f, -0.26234388f, -0.10201792f, 0.12708168f, 0.03512150f, 0.00915181f, 
    -0.08998368f, -0.00509955f, 0.04133943f, -0.11753423f, 0.16098525f, 0.05316481f, -0.25772986f, -0.03625013f, 
    -0.06554464f, 0.03943677f, 0.06538444f, 0.03377914f, -0.36727566f, -0.22810182f, -0.16897516f, -0.00287532f, 
    0.01052670f, -0.15198612f, 0.00927277f, -0.00492059f, 0.07180529f, 0.01586216f, 0.15280411f, 0.13794610f, 
    -0.10724509f, -0.04391498f, -0.19472569f, 0.00959445f, -0.03353898f, -0.09557200f, 0.23548658f, -0.37144777f, 
    -0.09981021f, -0.17940530f, -0.11880741f, -0.32828331f, -0.15547876f, 0.04431623f, -0.09484673f, -0.04729948f, 
    -0.18569934f, 0.04545113f, 0.22943848f, 0.15494645f, 0.10085855f, 0.11215169f, -0.06250641f, 0.06161853f, 
    -0.01023869f, -0.00578521f, 0.01305842f, 0.06870120f, -0.03359339f, -0.00369448f, 0.02871496f, -0.06312435f, 
    -0.03725464f, -0.08896349f, 0.07409871f, 0.01059855f, -0.06017410f, -0.02994189f, 0.04257111f, -0.01743731f, 
    -0.04940347f, -0.05964641f, -0.07848714f, -0.07804205f, 0.04763473f, 0.01052604f, -0.07953442f, -0.03530482f, 
    0.01581464f, 0.01841531f, 0.04583603f, -0.01952380f, -0.04776600f, 0.02729033f, -0.00203260f, -0.06993619f, 
    -0.02852359f, -0.01330536f, -0.03030866f, -0.05371401f, 0.05053400f, 0.07100324f, -0.06900136f, -0.04126070f, 
    -0.04389780f, 0.05957431f, -0.01165867f, 0.02190900f, -0.04613195f, -0.08206021f, -0.01097647f, -0.05831571f, 
    -0.04767308f, -0.03758894f, -0.05399913f, -0.01966034f, 0.05604004f, -0.04967680f, 0.01200524f, -0.06468718f, 
    0.06407992f, -0.08253617f, -0.07983601f, 0.02062409f, -0.02175324f, 0.03139615f, 0.05793369f, -0.02656071f, 
    -0.04343758f, -0.01524492f, 0.04196245f, 0.01166888f, 0.00461040f, 0.02681504f, -0.01569935f, -0.02708935f, 
    -0.01525655f, -0.00918708f, -0.00096356f, 0.06222279f, -0.07994989f, -0.00748587f, 0.04984825f, -0.01161547f, 
    0.06317019f, -0.04996268f, 0.00769571f, 0.05644229f, -0.01018827f, -0.02682457f, 0.03587419f, -0.05574596f, 
    0.02359665f, 0.05909969f, 0.03491087f, -0.02383956f, 0.03070094f, -0.00929781f, -0.09019358f, 0.06053830f, 
    -0.08572745f, 0.07306123f, 0.01770403f, -0.04764697f, -0.07536729f, -0.04187952f, 0.04275662f, -0.01611518f, 
    0.01116293f, -0.08695222f, -0.00918294f, -0.04386863f, 0.01709507f, 0.04717603f, -0.03016757f, -0.05916432f, 
    -0.06099865f, 0.01591615f, 0.03841504f, -0.09003309f, 0.06121448f, 0.00425118f, 0.02643805f, -0.08676302f, 
    0.01222854f, -0.07978748f, -0.03894985f, 0.02989608f, -0.02531889f, 0.00204471f, 0.04816212f, 0.00305368f, 
    -0.07582168f, -0.04442579f, 0.04199592f, 0.00283111f, 0.07290183f, -0.06739917f, 0.06114185f, 0.02029177f, 
    -0.02290224f, -0.04599789f, -0.05147610f, -0.07721854f, -0.08284890f, -0.06004217f, -0.02042090f, 0.03682768f, 
    -0.23812500f, -0.17042698f, 0.17687126f, 0.07391170f, -0.08271904f, 0.03014682f, -0.00426746f, 0.00104461f, 
    -0.02624975f, 0.00477527f, -0.09430686f, 0.14997834f, 0.16357309f, 0.04171324f, -0.08931842f, 0.17596592f, 
    0.04931024f, 0.08134460f, -0.14044110f, 0.16548274f, -0.14373825f, 0.06340924f, 0.04290931f, -0.15144607f, 
    -0.05779679f, -0.10173469f, 0.00442824f, -0.36560822f, 0.11987973f, 0.13736185f, -0.05697473f, -0.34597254f, 
    0.08811278f, -0.12057725f, 0.04768173f, -0.05632479f, -0.07093222f, -0.16013044f, 0.36744446f, -0.06433816f, 
    0.15384185f, 0.13567723f, 0.10195993f, -0.03873508f, 0.18085855f, -0.07806580f, -0.03768638f, 0.12107910f, 
    0.00981686f, 0.21041973f, -0.11012463f, 0.12649398f, 0.15667358f, -0.06668971f, 0.12405924f, -0.20741127f, 
    0.07644083f, -0.03805220f, -0.02924490f, -0.16123481f, -0.04082509f, 0.00127354f, 0.01259091f, -0.07478361f, 
    0.00378703f, 0.14216597f, -0.07280570f, 0.03918375f, 0.03163153f, 0.01577374f, 0.12647581f, 0.07905728f, 
    0.17287800f, 0.17963472f, 0.16243313f, -0.01465019f, 0.10965538f, 0.11333141f, -0.06595829f, -0.12760665f, 
    -0.20423248f, -0.03568519f, 0.34694847f, 0.34826899f, -0.05549603f, -0.21217524f, 0.13981918f, 0.12849806f, 
    -0.22223206f, 0.10166431f, -0.05515616f, -0.08148618f, 0.01059286f, -0.12282109f, -0.08779415f, 0.07326120f, 
    -0.09573881f, -0.05174976f, -0.14166801f, 0.25917518f, -0.02459250f, -0.17386156f, 0.05564761f, -0.07708925f, 
    -0.02567062f, -0.02598612f, 0.05073298f, -0.01745969f, -0.10109676f, -0.03412024f, -0.14627120f, -0.08696419f, 
    0.08368445f, -0.01837279f, -0.09185971f, 0.16473137f, -0.07264361f, -0.10971607f, -0.18899366f, -0.01092881f, 
    0.12764846f, 0.20884141f, -0.09818714f, 0.06978872f, -0.03168175f, -0.05450878f, 0.20952216f, 0.06798548f, 
    -0.27183810f, -0.00873253f, 0.04665638f, -0.06990633f, -0.06091713f, 0.03992239f, 0.00832611f, 0.22434685f, 
    -0.05411463f, -0.11722504f, 0.09405933f, -0.03537425f, -0.06274266f, -0.04171392f, 0.03418557f, -0.13598591f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.09272870f, 0.04909092f, 0.02120516f, 0.27118576f, -0.01145553f, -0.07022958f, 0.22352192f, 0.00575545f, 
    0.00587035f, -0.06486242f, 0.04260287f, -0.02552724f, 0.04187755f, 0.20857209f, -0.00734003f, 0.09541033f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00712249f, -0.12983358f, -0.27386200f, -0.06904019f, 0.17474623f, 0.27252969f, 0.16149865f, -0.09471744f, 
    0.17538378f, -0.13374832f, -0.07507132f, 0.15456904f, 0.43406799f, -0.10645813f, -0.07646063f, 0.16293690f, 
    0.25515833f, -0.04465085f, -0.18880324f, -0.26192757f, 0.01910803f, -0.09801443f, 0.04847578f, 0.34376457f, 
    -0.06800318f, 0.21104173f, 0.13800862f, 0.09835500f, -0.01937884f, 0.58881080f, -0.20192935f, 0.37951005f, 
    -0.23223802f, 0.01657471f, 0.18004735f, -0.26145059f, 0.20938490f, 0.12750521f, 0.06286999f, 0.22378613f, 
    0.17204863f, 0.01422000f, 0.20490289f, 0.01934019f, 0.31588703f, 0.15655385f, 0.02547397f, -0.20280698f, 
    -0.12497133f, -0.05214193f, -0.04897460f, -0.01874064f, 0.22796515f, -0.14690414f, -0.22097294f, -0.19217619f, 
    -0.00546327f, 0.15276694f, -0.18377794f, -0.03600126f, -0.06282820f, -0.06749514f, 0.07503143f, -0.02447148f, 
    -0.12614709f, 0.08118425f, 0.00255326f, 0.27105567f, 0.06436580f, -0.28326422f, -0.01575532f, 0.07801840f, 
    0.08060265f, -0.08180200f, -0.18353902f, 0.29803124f, 0.48127523f, -0.14281724f, 0.15149096f, -0.36161193f, 
    -0.03389382f, 0.31225026f, 0.29116410f, -0.22943689f, -0.01280847f, -0.17020388f, -0.09362733f, -0.28259164f, 
    0.19824675f, -0.21876261f, 0.30771959f, 0.28695738f, -0.21281309f, -0.37833911f, -0.05855628f, -0.06072562f, 
    0.33600444f, 0.02909912f, -0.35595030f, -0.13329126f, -0.00277166f, 0.30904025f, 0.12393473f, 0.14362308f, 
    0.14642492f, -0.00635504f, 0.27030441f, 0.01552914f, -0.14477639f, 0.17162669f, 0.04595853f, 0.20817237f, 
    0.09461730f, 0.23710351f, -0.13772967f, 0.36039352f, 0.08476651f, -0.13662869f, -0.30271706f, 0.08196443f, 
    -0.16768900f, -0.17711420f, 0.11990519f, 0.02327097f, 0.52490270f, -0.32547405f, 0.05952165f, 0.24946091f, 
    -0.00503884f, -0.03457099f, -0.18558235f, -0.18276501f, 0.15457259f, 0.17590307f, 0.40904847f, 0.32006606f, 
    -0.14933896f, -0.07349263f, -0.15167691f, -0.05091522f, 0.08495077f, -0.20181657f, 0.11944397f, 0.02334655f, 
    0.40574285f, -0.28932855f, -0.16616701f, 0.13645907f, -0.23289286f, 0.13164733f, -0.02633879f, -0.28309163f, 
    -0.22215587f, 0.19604900f, 0.22379218f, -0.21364695f, 0.26414278f, -0.00494657f, -0.12604110f, 0.38981923f, 
    -0.07723984f, 0.06088755f, -0.13447779f, -0.00613147f, 0.12140876f, -0.24527991f, -0.04740697f, -0.15556011f, 
    0.09623319f, -0.03298494f, -0.22596008f, -0.19191718f, 0.20357275f, 0.01675922f, 0.21014014f, 0.06691679f, 
    0.12866186f, -0.43799567f, 0.35437968f, -0.03139448f, 0.14304636f, -0.09884688f, 0.43919441f, -0.15426013f, 
    -0.07693747f, 0.10319842f, -0.14307404f, -0.25888181f, 0.09590885f, 0.08744955f, -0.19810939f, 0.35702744f, 
    0.17172013f, 0.33054286f, 0.19229342f, 0.22257078f, -0.17078237f, 0.11360150f, -0.26191470f, -0.01687166f, 
    0.20553043f, -0.08306829f, 0.08896492f, -0.27765253f, -0.50735795f, -0.08471026f, 0.22478327f, 0.05960482f, 
    0.19656256f, 0.10626259f, 0.04884773f, -0.22080643f, 0.13152546f, 0.26582041f, -0.01291254f, 0.28969875f, 
    -0.06833109f, -0.21336898f, 0.23430383f, -0.36621201f, -0.25256705f, 0.23159036f, -0.20025247f, -0.05327720f, 
    0.30994147f, 0.05790702f, -0.19897547f, 0.18643172f, 0.04124870f, 0.16859527f, -0.23781827f, 0.30457634f, 
    -0.09933665f, 0.09375052f, -0.23439716f, -0.23363401f, 0.29941788f, 0.63177299f, 0.16970097f, 0.31940356f, 
    -0.06646606f, 0.10279365f, 0.00511999f, 0.15900461f, -0.08455965f, 0.14384115f, 0.08328755f, -0.00080330f, 
    -0.15232638f, -0.23354790f, -0.30423599f, -0.27743328f, 0.37737688f, -0.13165578f, -0.12304886f, 0.17080541f, 
    -0.27158487f, 0.14173640f, 0.07595111f, -0.07950473f, -0.18471539f, 0.27426440f, -0.22837685f, 0.27630079f, 
    -0.19813174f, 0.06194943f, 0.20403098f, -0.24704976f, 0.28845897f, -0.30180272f, 0.15969260f, -0.04553761f, 
    0.15299702f, 0.01216943f, -0.25210524f, 0.08200435f, -0.03663361f, 0.38436362f, -0.06222848f, -0.33029538f, 
    -0.03638628f, -0.12264191f, 0.00523245f, 0.09281844f, 0.27290708f, 0.37518415f, 0.03138299f, -0.25495848f, 
    -0.04312573f, 0.51618707f, -0.06169660f, 0.07865291f, 0.09242865f, 0.31758845f, -0.02196430f, 0.00193582f, 
    0.15945902f, 0.01434666f, -0.06952693f, -0.06507460f, -0.46046123f, -0.09839801f, 0.10528386f, -0.05052330f, 
    -0.00498799f, -0.01121511f, 0.09924229f, -0.01594062f, -0.23552017f, 0.06300747f, -0.24115656f, -0.11236752f, 
    -0.16110733f, 0.15805584f, 0.01421194f, 0.33406758f, 0.32508236f, 0.42267954f, 0.22533892f, 0.08603563f, 
    -0.19001472f, 0.41577604f, 0.29930010f, -0.33987230f, 0.19103347f, -0.29318571f, -0.06158254f, 0.04351527f, 
    -0.02009535f, 0.04267842f, 0.14427021f, -0.11419614f, -0.16038962f, -0.19551198f, 0.12338103f, 0.19939920f, 
    0.20905660f, 0.25283518f, 0.01903288f, -0.16671538f, 0.17140944f, 0.04559241f, 0.15106438f, 0.21812329f, 
    -0.03928792f, -0.20856053f, -0.05716071f, -0.09299123f, -0.42679015f, 0.11635619f, -0.02543152f, 0.20039374f, 
    -0.07528234f, -0.24835896f, -0.15575303f, -0.01819002f, -0.11274666f, -0.05414277f, -0.27539483f, -0.22985485f, 
    -0.19957268f, -0.17688981f, -0.18604209f, 0.07731568f, -0.10561311f, -0.06872610f, -0.19275978f, -0.05529219f, 
    0.34583142f, 0.12881434f, 0.05013606f, 0.21743655f, -0.17324668f, 0.14840364f, -0.33022159f, -0.32407063f, 
    0.24865910f, -0.06895135f, 0.39860368f, -0.26695961f, 0.04963113f, -0.29279599f, -0.02838091f, -0.14392206f, 
    0.18404856f, -0.00626117f, -0.10665775f, 0.07981599f, -0.17024592f, -0.08939468f, 0.06952023f, 0.25909221f, 
    -0.12937865f, 0.08568838f, 0.45509210f, 0.05302924f, -0.24864203f, -0.73249906f, 0.16990572f, -0.13703065f, 
    0.07055385f, -0.12586138f, -0.39687094f, -0.03309206f, 0.18578717f, 0.30779737f, 0.33992946f, 0.01363493f, 
    -0.15422660f, 0.18090618f, 0.11784457f, 0.11730699f, -0.13982314f, -0.08730729f, 0.02149488f, -0.19150095f, 
    0.12496942f, -0.46152049f, -0.02113013f, -0.01317917f, 0.01593062f, 0.00424604f, 0.33833218f, -0.40782276f, 
    0.05104530f, 0.04423013f, -0.18218271f, 0.20555060f, 0.29454818f, -0.28920653f, -0.10710686f, 0.10389633f, 
    0.01880337f, 0.24033561f, 0.14065525f, -0.09120234f, -0.24524738f, -0.05477593f, -0.19124593f, -0.03405002f, 
    -0.07111710f, -0.19771653f, -0.13648076f, 0.13714184f, 0.32302338f, -0.33805570f, 0.00494794f, -0.33177072f, 
    -0.29925442f, 0.24056073f, 0.28209528f, -0.09410843f, 0.05887434f, -0.02637360f, 0.26886585f, -0.19538309f, 
    0.00126675f, -0.09484717f, 0.00241688f, 0.04920500f, 0.41756538f, -0.08599354f, -0.08512958f, -0.33387867f, 
    0.01702441f, 0.40157917f, -0.01131158f, 0.49606910f, 0.19694652f, -0.27333939f, 0.20663601f, -0.11658379f, 
    0.13919264f, 0.08013956f, -0.17602199f, -0.26836920f, -0.06209732f, 0.30320060f, -0.06964995f, -0.15023950f, 
    -0.12213126f, 0.07836242f, 0.22059974f, -0.31364551f, 0.20433418f, -0.05857814f, 0.33934769f, -0.02700813f, 
    -0.24459863f, -0.18125746f, 0.34051144f, -0.17510048f, -0.18684554f, -0.03305646f, 0.08052523f, 0.31421593f, 
    -0.02192882f, -0.03440617f, 0.13857260f, 0.18294276f, 0.17514166f, -0.20980556f, 0.30087328f, -0.29085538f, 
    0.06615028f, 0.21371509f, 0.28147367f, -0.39216593f, -0.01352655f, -0.29642630f, 0.02134674f, 0.22671142f, 
    -0.28381702f, 0.37257338f, 0.35199770f, 0.40809754f, -0.21156061f, -0.22597827f, -0.17068659f, 0.36761358f, 
    -0.09870887f, 0.05870553f, 0.10157058f, -0.17100166f, -0.00378918f, -0.05130684f, -0.10244182f, 0.23612867f, 
    0.36394772f, -0.09091675f, -0.04116661f, 0.08142739f, -0.16409665f, -0.27444541f, 0.17367712f, 0.20270422f, 
    -0.14107791f, -0.16854280f, 0.25280619f, 0.27810651f, 0.49251333f, -0.05313877f, 0.06441178f, -0.31996253f, 
    0.13163602f, -0.14680037f, 0.03806451f, -0.06885573f, -0.09331065f, 0.01414350f, -0.13794890f, -0.09822476f, 
    0.10279161f, 0.13011733f, -0.16453534f, -0.01606745f, -0.18314821f, -0.06303641f, 0.11789373f, -0.16726741f, 
    0.22952262f, 0.11803149f, -0.20072666f, -0.30689991f, 0.15747519f, 0.23649809f, -0.16041449f, 0.25212902f, 
    -0.16314888f, 0.04953700f, 0.37152550f, 0.06704745f, 0.15907943f, 0.00621422f, 0.01405002f, -0.04094799f, 
    -0.04335323f, 0.22692923f, 0.25414014f, -0.03842409f, -0.06117693f, 0.00270299f, 0.14861377f, 0.43257460f, 
    -0.14541239f, 0.17335069f, -0.08334663f, -0.37113690f, 0.45402911f, -0.33251777f, 0.13803665f, 0.09061914f, 
    0.04920554f, -0.00919663f, 0.05369056f, -0.20267983f, 0.09252196f, -0.21733104f, -0.15287845f, 0.45962662f, 
    -0.03411865f, 0.13522078f, -0.22852992f, -0.00066188f, 0.14499366f, 0.23730676f, -0.07431508f, 0.42421606f, 
    0.16422202f, -0.20720099f, 0.21454526f, -0.30188188f, 0.10451155f, 0.31069720f, -0.12120442f, -0.11302505f, 
    -0.13957071f, 0.12225701f, 0.26365632f, -0.25017717f, -0.46507353f, 0.25201619f, 0.04118333f, 0.32227713f, 
    0.20246105f, 0.11088458f, 0.04592437f, -0.33314678f, 0.25577477f, 0.08223984f, -0.07201260f, -0.56665319f, 
    -0.03820720f, -0.03801326f, 0.17914851f, 0.29558882f, -0.13473921f, 0.25539801f, -0.14011756f, -0.40884483f, 
    0.06038573f, -0.01985582f, -0.37661198f, 0.26248470f, 0.00070909f, 0.30907944f, 0.02364249f, -0.08517829f, 
    -0.13626006f, -0.08846167f, -0.14803684f, 0.27428570f, 0.25737271f, 0.20533501f, 0.04923956f, -0.38937271f, 
    0.26359671f, -0.22806855f, -0.36354393f, -0.17147687f, 0.17864054f, 0.25499004f, 0.12614447f, -0.10638396f, 
    0.01518434f, -0.22144522f, 0.18596806f, -0.00427094f, 0.01895631f, 0.61085749f, 0.02720327f, -0.06114212f, 
    -0.06142691f, 0.25314850f, 0.00951857f, 0.42489696f, -0.02022458f, 0.10605812f, 0.15620974f, -0.20453072f, 
    -0.02080408f, 0.13558435f, -0.07236864f, -0.38768673f, -0.01616872f, 0.07893825f, -0.07292350f, 0.08490466f, 
    0.22451314f, -0.05278970f, 0.14131793f, -0.12873411f, -0.08404776f, 0.14077292f, 0.38161558f, 0.18619666f, 
    -0.03069410f, -0.10921384f, 0.24915844f, -0.24699931f, -0.50317043f, 0.14126246f, -0.04972375f, -0.01326536f, 
    0.14446445f, -0.06064999f, -0.31663737f, 0.12735198f, -0.25538078f, 0.00886717f, -0.02739252f, 0.10295358f, 
    -0.04490042f, 0.10854447f, 0.00071141f, -0.25539246f, 0.16320200f, 0.51984119f, 0.00876237f, 0.30918944f, 
    -0.10251354f, -0.08469956f, 0.09686696f, -0.01873293f, -0.16565290f, 0.04124074f, -0.22296754f, 0.50373846f, 
    -0.09115881f, 0.12581934f, -0.22040196f, 0.20079263f, -0.33525503f, -0.34268481f, -0.08345166f, 0.22364481f, 
    -0.05534283f, -0.00862206f, -0.00609412f, 0.57476246f, 0.18868835f, 0.16248554f, 0.22209066f, -0.46122399f, 
    0.17268169f, -0.00518853f, 0.16098252f, -0.32899675f, 0.11466375f, 0.17228271f, -0.01705809f, -0.01831294f, 
    -0.10410086f, -0.03072701f, 0.18021829f, 0.04019899f, -0.01968905f, -0.09676357f, 0.01004299f, -0.27528977f, 
    0.16008005f, -0.08808688f, 0.36694798f, 0.21478340f, 0.05177332f, -0.45278963f, -0.16228950f, 0.07221432f, 
    0.17017132f, 0.29288521f, 0.24508303f, -0.74860239f, -0.11234464f, -0.12717083f, -0.22685876f, -0.45194373f, 
    -0.15997562f, -0.24652626f, 0.10345016f, -0.25459391f, 0.26803681f, -0.21825550f, -0.21317813f, -0.27123722f, 
    -0.00009151f, -0.18255974f, -0.20365308f, -0.16708530f, 0.02084696f, 0.01605164f, -0.02671228f, -0.02898189f, 
    -0.22602025f, 0.19585460f, 0.07753716f, -0.23640443f, -0.03711913f, -0.13927841f, -0.23164910f, -0.01437893f, 
    0.39642856f, 0.25472319f, -0.14981756f, 0.13862334f, 0.19730301f, 0.30377766f, 0.11863577f, -0.01917055f, 
    -0.12572417f, -0.06127976f, -0.21081276f, -0.16229838f, -0.31638944f, -0.11257188f, 0.05394705f, -0.18732409f, 
    0.10376102f, 0.15318057f, 0.29284489f, -0.15193117f, 0.13298479f, -0.23342268f, -0.19638009f, 0.28113264f, 
    -0.20157564f, -0.20047852f, -0.06874768f, 0.08504979f, -0.09043417f, 0.36209139f, 0.08131895f, -0.22248077f, 
    -0.17890136f, 0.35713074f, -0.12324528f, 0.00839355f, -0.21281910f, -0.21767890f, -0.05093904f, 0.13093485f, 
    0.13205808f, 0.00853974f, 0.19654246f, 0.13564639f, 0.23120536f, 0.24694943f, 0.18049288f, 0.05462383f, 
    0.26384878f, -0.31450972f, 0.10129163f, -0.45051146f, -0.11316734f, 0.06081763f, 0.23939933f, 0.15376590f, 
    0.01102480f, -0.18424915f, 0.02793274f, 0.18317743f, 0.41256320f, 0.44206694f, -0.22755262f, 0.14573151f, 
    -0.10143343f, -0.21361136f, -0.20815811f, -0.02205816f, -0.19529063f, -0.04272908f, 0.14723444f, -0.06472749f, 
    0.00320596f, 0.16119719f, -0.12292919f, -0.15983522f, -0.24643627f, 0.23321405f, 0.20440388f, -0.13067335f, 
    0.10127848f, 0.30996546f, 0.09315940f, 0.37276542f, 0.01761157f, -0.15669870f, -0.07184942f, -0.21207751f, 
    0.10701099f, -0.22560847f, -0.18653040f, 0.12174796f, -0.14929014f, 0.01443214f, -0.06893252f, 0.04396601f, 
    0.45688480f, 0.24962693f, -0.11625122f, 0.04426614f, 0.03452228f, -0.04483725f, -0.16097991f, -0.11431639f, 
    -0.02666321f, -0.05601821f, -0.11749565f, 0.35168383f, 0.01628359f, 0.42383859f, -0.14306355f, -0.40264118f, 
    0.29683468f, -0.09528318f, -0.28666103f, 0.20307316f, -0.08583765f, 0.36610031f, 0.01497837f, -0.59938747f, 
    -0.17999405f, -0.12942220f, 0.19745398f, -0.09816884f, -0.15686819f, 0.39042854f, -0.18379977f, -0.10500662f, 
    0.10213755f, -0.21656132f, -0.13275370f, -0.05408740f, -0.21261349f, 0.37711981f, -0.00575011f, -0.46823749f, 
    0.07356799f, -0.04837272f, -0.06535336f, 0.05670267f, 0.34823570f, 0.09971131f, -0.17821309f, 0.11472490f, 
    0.06019691f, -0.37025285f, 0.13876219f, 0.38266125f, 0.00681366f, 0.03471411f, -0.08625376f, -0.28085065f, 
    0.20367458f, 0.02697283f, 0.06205190f, 0.24272400f, -0.25686237f, 0.02262361f, 0.11599835f, 0.30265710f, 
    -0.19099861f, 0.49157476f, -0.12588523f, -0.23409164f, -0.17235813f, 0.13831612f, -0.13258766f, -0.23270237f, 
    0.14441082f, 0.08753428f, 0.19751908f, -0.00627762f, -0.26712602f, 0.25229669f, 0.13039845f, -0.08795039f, 
    -0.02278489f, -0.00287894f, 0.32001030f, 0.30994090f, 0.01774731f, -0.35927659f, 0.27712497f, -0.10476436f, 
    0.08274552f, 0.06613192f, -0.17419849f, -0.35785308f, 0.06776782f, 0.21720847f, 0.02771807f, -0.12232873f, 
    0.33673871f, 0.23580666f, -0.30591330f, -0.27409437f, 0.21835820f, 0.26155671f, 0.36457330f, 0.08537383f, 
    -0.17398599f, -0.05730447f, 0.12217843f, 0.21046010f, -0.27625507f, 0.14517006f, -0.09476344f, -0.13769901f, 
    -0.14799228f, 0.28461763f, 0.13011965f, -0.46494803f, 0.15636176f, -0.20673957f, 0.41621512f, 0.29034176f, 
    0.06909016f, 0.20808025f, 0.47309959f, -0.29498538f, 0.15620781f, -0.05101208f, 0.21134919f, 0.03489719f, 
    0.00046480f, -0.17450479f, -0.11831385f, -0.13986307f, 0.13625786f, -0.09372163f, -0.18663758f, -0.13622752f, 
    0.18279082f, -0.12249967f, -0.19348490f, -0.07674015f, 0.08716878f, -0.13265863f, 0.17619434f, -0.12148416f, 
    -0.06773228f, 0.47199625f, 0.40569609f, 0.41333407f, 0.03310174f, -0.11468375f, 0.14824739f, -0.03572647f, 
    -0.03814265f, 0.02303337f, -0.13219200f, -0.24932091f, -0.29919958f, -0.14978147f, -0.17129627f, -0.12701696f, 
    0.16428389f, -0.01785748f, -0.00521673f, 0.25273564f, -0.06536585f, -0.04248196f, -0.30233306f, -0.03259503f, 
    0.04619163f, -0.06941431f, -0.13202423f, 0.17107719f, 0.56777763f, 0.43699846f, -0.01688271f, -0.04291439f, 
    -0.05436668f, 0.16136917f, -0.11660839f, 0.00752185f, -0.07886297f, -0.07073615f, 0.13326366f, 0.19312350f, 
    -0.03939068f, -0.20897584f, 0.19105294f, -0.09526972f, 0.10620490f, 0.00545866f, 0.06090925f, 0.38060835f, 
    0.05247095f, 0.11919828f, -0.12508976f, -0.16322851f, 0.15239875f, -0.20768887f, -0.00163331f, -0.39463839f, 
    0.16074541f, -0.24362396f, 0.09764275f, 0.43905964f, 0.14882703f, 0.21167730f, 0.20561461f, -0.39680818f, 
    -0.19443780f, 0.10081588f, 0.34759614f, 0.03674038f, 0.05692344f, -0.10866710f, 0.04216840f, 0.10403803f, 
    -0.04061061f, -0.18520069f, -0.20421965f, -0.09624501f, -0.15941954f, 0.33717629f, 0.16102906f, 0.13398956f, 
    -0.25853902f, -0.09194043f, 0.08761823f, 0.35189840f, 0.19275124f, -0.10682238f, -0.33446628f, -0.39381242f, 
    0.04876959f, 0.06240258f, 0.36676401f, 0.39922991f, 0.00535380f, 0.13331559f, 0.23776808f, 0.15825972f, 
    -0.06103265f, 0.21434762f, -0.09398107f, -0.05087804f, -0.22970213f, 0.19409248f, 0.50193197f, -0.45026812f, 
    -0.08264941f, 0.13588461f, -0.30779150f, -0.07138976f, 0.50120485f, -0.23609705f, 0.21990563f, -0.39434025f, 
    0.05190854f, 0.18140236f, -0.15216495f, -0.11982589f, -0.02035030f, 0.29699540f, 0.14470193f, 0.36169523f, 
    -0.09033933f, 0.08150486f, -0.12342018f, -0.19604759f, -0.23657081f, 0.42479271f, -0.02049484f, 0.23761553f, 
    0.39615682f, 0.08965884f, 0.05800108f, -0.39992768f, 0.23532905f, 0.16150345f, -0.20747957f, -0.03479512f, 
    -0.11525878f, 0.11620739f, 0.40801796f, -0.07556570f, -0.13969350f, 0.40588456f, -0.22390783f, -0.06042259f, 
    0.09540051f, 0.24886754f, 0.01270276f, -0.44635823f, -0.23673460f, -0.08885337f, 0.40492091f, 0.19823594f, 
    -0.17263910f, -0.16278180f, 0.37377533f, 0.14528048f, -0.38015857f, -0.16154487f, -0.03168867f, -0.16854851f, 
    0.16615930f, 0.01289434f, 0.37466216f, -0.08057176f, -0.23543359f, 0.11560119f, -0.08979587f, 0.45914045f, 
    0.12519252f, -0.23037581f, -0.05262482f, -0.35380045f, 0.45840237f, -0.29861835f, 0.20236370f, -0.18087871f, 
    -0.17154717f, -0.31536999f, 0.13874008f, 0.55424410f, -0.03006982f, -0.02998937f, 0.33623999f, -0.45922956f, 
    0.09382194f, 0.10929042f, 0.46183121f, -0.30535004f, -0.23420124f, -0.25338101f, -0.01850334f, 0.34566379f, 
    -0.05475910f, -0.22136278f, -0.10319299f, 0.14187433f, 0.07977098f, 0.30694717f, 0.28606626f, -0.49165511f, 
    0.07328853f, -0.20505488f, 0.01613532f, 0.05785086f, 0.03692068f, 0.17310201f, -0.20456569f, -0.17450555f, 
    0.20369592f, -0.27914673f, 0.05291811f, -0.32024831f, 0.23186570f, 0.22708026f, 0.04946319f, 0.34429279f, 
    0.05493000f, 0.08643109f, -0.13409413f, 0.03040124f, 0.15156606f, 0.33688992f, 0.07235061f, 0.14694723f, 
    -0.23160753f, 0.20096605f, -0.21460716f, -0.08163992f, -0.19075170f, 0.38728389f, 0.27197409f, -0.12502435f, 
    -0.23757625f, 0.15999426f, -0.10475665f, -0.15950683f, 0.26288226f, 0.17072500f, -0.05381308f, -0.33423564f, 
    -0.29313612f, -0.00596364f, -0.04298756f, -0.13657838f, 0.23544851f, 0.12656888f, 0.00825084f, 0.21604887f, 
    0.23565423f, 0.13119677f, -0.11620502f, 0.19384767f, 0.31511694f, -0.08172857f, -0.11341050f, 0.35845798f, 
    0.30746296f, -0.03953199f, 0.11641668f, -0.22432102f, 0.10719837f, 0.22988671f, -0.13144325f, -0.14745490f, 
    -0.16314942f, -0.14860138f, -0.20357591f, 0.24828576f, 0.39980495f, -0.05450319f, 0.14994688f, -0.13545023f, 
    -0.28218791f, -0.31837183f, -0.05605714f, -0.25107583f, -0.21791415f, 0.14090686f, -0.05502753f, 0.40666050f, 
    0.15394706f, -0.19862546f, 0.13411111f, 0.01308333f, 0.36707780f, 0.34668005f, 0.16612421f, 0.30352277f, 
    0.19356087f, -0.23591638f, -0.27638897f, -0.04539995f, -0.15567690f, 0.18382886f, -0.23722515f, -0.12610418f, 
    0.05077627f, -0.20471638f, -0.14721361f, -0.07194116f, -0.06244490f, 0.09078597f, 0.22740918f, -0.13654193f, 
    0.15915319f, -0.05594021f, -0.01778074f, 0.03165800f, 0.02754855f, -0.03768773f, 0.00128258f, 0.04298273f, 
    0.21231124f, 0.18460667f, -0.10100958f, -0.20322864f, -0.15455115f, -0.17576791f, -0.09937346f, -0.09659723f, 
    0.03603855f, -0.09232920f, 0.20389390f, -0.24889253f, 0.21063203f, 0.24988915f, 0.35775301f, 0.05370995f, 
    0.01104578f, 0.12344019f, -0.28996155f, 0.00392570f, 0.14892218f, 0.28894249f, -0.21328495f, -0.44720519f, 
    0.20846604f, 0.06325616f, -0.08685008f, -0.24943936f, -0.20470011f, 0.19440924f, -0.26619929f, -0.22221138f, 
    0.00558180f, 0.09992216f, 0.19660401f, -0.45565131f, 0.27411184f, -0.12056417f, -0.20026626f, 0.06794752f, 
    -0.33283505f, 0.03807260f, 0.14390945f, 0.01547580f, -0.15045834f, -0.12690389f, -0.59081239f, 0.31293824f, 
    0.04375270f, -0.24357376f, -0.22444667f, 0.26188028f, 0.12264418f, -0.31273511f, 0.17353082f, 0.33619228f, 
    -0.19000530f, 0.07092580f, 0.02474501f, 0.00643174f, 0.01090237f, 0.05596603f, 0.20678903f, 0.02621220f, 
    0.15655464f, -0.15032655f, -0.55938959f, -0.17944643f, -0.24189457f, 0.34990844f, -0.07453239f, 0.37782297f, 
    -0.06385059f, -0.13497753f, 0.18963008f, 0.20625351f, 0.12980251f, -0.29641876f, 0.05377478f, 0.14644155f, 
    -0.13091788f, -0.22370397f, 0.18509139f, -0.12625585f, 0.45599040f, -0.05708316f, 0.05125837f, 0.24861494f, 
    0.26406434f, 0.24965674f, 0.27842951f, -0.56997174f, -0.12723769f, -0.12003353f, -0.05952299f, -0.52072531f, 
    -0.20481512f, 0.10841367f, 0.30071688f, -0.23709998f, -0.16056611f, -0.79646075f, -0.09037141f, -0.33102050f, 
    -0.29266986f, 0.37021631f, 0.12108301f, 0.03328612f, 0.24226716f, 0.01274774f, 0.01771163f, -0.18604922f, 
    -0.13892943f, -0.01068815f, 0.09312938f, 0.03026603f, -0.37607861f, -0.06625853f, -0.15119702f, -0.07582466f, 
    -0.28512365f, 0.41080698f, -0.25948825f, 0.36007389f, 0.04071966f, -0.12332543f, -0.02271098f, 0.05054541f, 
    0.05000457f, 0.14619318f, -0.00788815f, 0.14278892f, 0.07078430f, 0.53852493f, 0.01881129f, -0.24259534f, 
    0.00888092f, 0.17927478f, 0.22775108f, -0.24435957f, 0.10838632f, -0.19031365f, -0.10586438f, 0.15250079f, 
    0.12176126f, 0.12455761f, 0.03025540f, 0.15698524f, -0.04120680f, 0.02974551f, 0.18209490f, 0.25942314f, 
    -0.09239091f, -0.16778719f, 0.09660858f, -0.14821777f, 0.06277275f, -0.06815473f, 0.09943189f, 0.10803831f, 
    0.05308405f, 0.18271849f, -0.02529446f, -0.19883405f, -0.23997431f, -0.12212101f, -0.10319138f, 0.02270372f, 
    -0.19415975f, 0.04320282f, -0.07598537f, -0.06393781f, 0.05805984f, -0.18792665f, -0.21690202f, -0.00351810f, 
    0.08913812f, 0.12980905f, -0.03450668f, -0.05940127f, -0.13142964f, -0.20104364f, 0.18685788f, 0.19675449f, 
    -0.09009366f, 0.38764760f, 0.20549494f, -0.00596558f, 0.23301069f, 0.08672514f, 0.12678371f, 0.36434329f, 
    -0.07819727f, -0.02174306f, 0.03887471f, -0.16405946f, -0.40658355f, 0.31367752f, -0.18279666f, -0.02753225f, 
    -0.04003964f, -0.18317495f, 0.18425117f, 0.41175309f, 0.22919558f, -0.06979995f, -0.45756274f, 0.05612201f, 
    -0.02735576f, 0.15415332f, 0.24052612f, 0.04585381f, -0.01278270f, 0.53055227f, -0.13630719f, 0.41995978f, 
    0.19895664f, 0.24070048f, 0.22514839f, -0.10779982f, -0.03697088f, -0.32495403f, -0.16576871f, -0.51917827f, 
    0.16219145f, -0.17811348f, 0.28383753f, 0.08308905f, 0.29602692f, -0.02190294f, -0.17650066f, -0.32173166f, 
    0.07424928f, -0.15700914f, -0.05315856f, 0.02811660f, 0.03780562f, -0.01463779f, 0.02150651f, 0.05433828f, 
    0.21638286f, -0.11713639f, -0.16218765f, -0.22005068f, -0.05643191f, -0.16277084f, 0.12808360f, 0.04052410f, 
    0.39823860f, 0.02302597f, -0.22883411f, 0.06664762f, 0.20021045f, 0.05129802f, -0.15935403f, 0.28119874f, 
    0.06889513f, -0.11075788f, 0.20579845f, 0.04734194f, 0.23821795f, 0.49805295f, 0.11442053f, -0.34415066f, 
    -0.49092987f, -0.05656163f, -0.24471079f, -0.12177725f, -0.19616392f, -0.14307787f, -0.49476603f, 0.55452472f, 
    -0.21403706f, 0.01986572f, -0.44574913f, 0.08362105f, -0.33736491f, 0.29745567f, 0.03918579f, -0.10781718f, 
    -0.24287675f, -0.06526138f, 0.28530052f, 0.40034935f, 0.23619296f, -0.15218072f, -0.09620460f, -0.23545177f, 
    0.15004450f, 0.07365413f, -0.03031039f, 0.17898932f, -0.15238333f, 0.14993170f, 0.04482406f, 0.39806068f, 
    0.22168007f, 0.17396839f, -0.09360573f, -0.35368565f, -0.20094346f, 0.20704724f, 0.14648791f, -0.12565182f, 
    -0.03230008f, 0.15701286f, 0.21983567f, 0.21588856f, -0.39585280f, 0.12037135f, 0.01992660f, -0.38932180f, 
    -0.20342609f, 0.15153234f, 0.25990951f, -0.11105758f, -0.04921380f, -0.01884782f, 0.41712663f, -0.21957119f, 
    0.15855685f, 0.02635831f, 0.17655659f, -0.30916986f, -0.27335426f, -0.63425761f, 0.21740396f, -0.14064151f, 
    0.20091361f, -0.23603922f, -0.18834047f, -0.16088644f, 0.13743971f, -0.10815204f, -0.15422349f, -0.06313532f, 
    0.17026335f, -0.10094357f, -0.21467395f, 0.06675819f, -0.05862659f, -0.13580441f, 0.07995826f, 0.03136894f, 
    -0.27254876f, -0.23845394f, -0.18864408f, -0.02097207f, -0.22288561f, -0.08631687f, -0.16377452f, -0.11460475f, 
    0.08799279f, 0.13655034f, -0.18963149f, 0.09140554f, -0.00416264f, -0.20997292f, -0.04715303f, 0.12806165f, 
    -0.03830147f, 0.11501986f, 0.19030885f, 0.25932455f, -0.18217407f, 0.16990498f, -0.00292608f, 0.27441299f, 
    -0.06825274f, -0.13252886f, -0.16928181f, -0.16593553f, -0.33360088f, -0.08254009f, 0.17478213f, -0.13988270f, 
    -0.05979577f, -0.28157201f, 0.23718722f, 0.35674590f, -0.18962514f, 0.13356657f, 0.20730779f, -0.33147725f, 
    0.05246520f, -0.02962011f, -0.19139460f, -0.23067561f, 0.21347751f, 0.33690289f, -0.18165568f, 0.09358728f, 
    -0.20812574f, 0.48025349f, 0.18086481f, 0.02971368f, -0.15541784f, -0.26697710f, -0.04555408f, -0.11655186f, 
    -0.20740479f, -0.05619857f, 0.08026717f, -0.18314384f, -0.16709791f, 0.29430914f, 0.04110093f, 0.35693479f, 
    -0.01411435f, 0.06235382f, -0.05209681f, -0.03344321f, -0.21473047f, -0.19073620f, -0.14861128f, -0.12699786f, 
    0.20868647f, -0.12548593f, 0.01149279f, -0.22694743f, -0.12578651f, 0.03293273f, 0.23148096f, -0.13096717f, 
    0.45473680f, -0.02055742f, -0.29367980f, -0.13406004f, -0.24279842f, 0.40155044f, 0.14976814f, -0.47009894f, 
    -0.15865761f, -0.20650733f, 0.05629311f, -0.28548554f, -0.02862749f, 0.28925058f, -0.01241123f, -0.08272398f, 
    0.39301348f, -0.05785732f, -0.07541218f, -0.30186993f, -0.24043715f, 0.18285058f, -0.18028240f, -0.16503435f, 
    -0.09174049f, -0.22327439f, 0.37242845f, 0.17441282f, -0.38468811f, 0.27387488f, 0.06972004f, 0.31179667f, 
    0.03413417f, -0.03742673f, -0.20304397f, -0.05379367f, 0.11848807f, -0.18384421f, -0.04689224f, -0.17814852f, 
    0.19350645f, -0.12810567f, -0.24721652f, 0.12777740f, 0.07737374f, -0.16727656f, 0.23860139f, 0.15163524f, 
    -0.25599220f, 0.26927415f, 0.01609883f, -0.95508069f, 0.03854517f, -0.20546407f, 0.18764496f, -0.57771939f, 
    -0.09989378f, 0.24806775f, 0.32445809f, -0.21652441f, 0.17519459f, -0.43469849f, 0.12539902f, -0.08010259f, 
    0.02819730f, -0.30894977f, 0.07171088f, -0.10143778f, -0.21337569f, -0.10297548f, -0.14173864f, -0.23614191f, 
    0.04240701f, -0.23108688f, -0.21502437f, -0.02616567f, -0.07282927f, -0.26502502f, -0.01054084f, -0.00610585f, 
    0.14643852f, -0.07191404f, -0.06646784f, -0.16433558f, 0.00591578f, 0.24202672f, 0.39666933f, 0.20467460f, 
    -0.01882750f, 0.23005094f, 0.03513071f, -0.44724855f, -0.03397620f, 0.43713573f, 0.23779014f, -0.02449497f, 
    -0.31854224f, 0.42600426f, 0.27044204f, 0.00743696f, -0.05174103f, -0.18681031f, -0.12908655f, -0.44421822f, 
    0.15000361f, 0.13067135f, -0.08705138f, 0.32188600f, 0.02359447f, -0.33230335f, -0.25038740f, -0.27420056f, 
    0.20722389f, -0.04229545f, 0.38424250f, -0.02766479f, -0.19732104f, 0.13222170f, -0.01504977f, -0.11453628f, 
    0.21421745f, -0.08101292f, -0.19161996f, -0.00763386f, 0.45367375f, -0.49763477f, -0.12604611f, -0.35320681f, 
    0.16903596f, 0.18157822f, -0.17874318f, 0.38508290f, 0.08616644f, -0.20946729f, 0.35320637f, 0.11417067f, 
    0.02170935f, -0.22979289f, -0.16093376f, -0.47206119f, 0.00789617f, 0.50316709f, 0.18939197f, 0.23302434f, 
    0.27233699f, 0.23979820f, 0.17242922f, 0.21044126f, -0.09929088f, 0.34936485f, -0.23389983f, -0.14560407f, 
    0.19551191f, -0.06350701f, -0.32216766f, -0.15533531f, 0.43971109f, -0.20561089f, -0.10034224f, -0.20367390f, 
    0.23343155f, -0.24472818f, -0.31902817f, 0.12823793f, 0.15603551f, 0.17440461f, 0.48286989f, -0.36211994f, 
    -0.13343325f, 0.23849502f, 0.32245663f, -0.19273667f, -0.14672650f, 0.03697922f, -0.00287965f, 0.18805197f, 
    0.29273516f, 0.20974642f, 0.26721680f, 0.25212246f, -0.14868470f, 0.07787825f, -0.31066468f, -0.18612577f, 
    -0.07451147f, 0.25327379f, 0.12858643f, 0.11016823f, -0.16355388f, -0.36555058f, 0.12098393f, -0.43689945f, 
    -0.09166819f, 0.18169495f, -0.12487128f, -0.26616731f, 0.20425956f, 0.07379773f, 0.49682808f, 0.33463064f, 
    -0.20864701f, -0.23320603f, -0.01363045f, -0.45209152f, -0.06305734f, 0.30408770f, -0.15546224f, 0.12983243f, 
    -0.06654537f, 0.02667676f, -0.00312678f, 0.11718009f, 0.11263750f, 0.25181612f, 0.36572719f, -0.61997432f, 
    -0.24804801f, 0.07827152f, 0.19386618f, -0.33751497f, -0.18492576f, -0.53385741f, -0.07630078f, -0.26369363f, 
    -0.02678667f, 0.05021959f, 0.13043776f, 0.10520940f, -0.21071510f, -0.28543428f, 0.42433766f, 0.06897803f, 
    -0.16843507f, 0.05076049f, 0.35242191f, -0.01029413f, 0.16017187f, -0.37236905f, -0.19356303f, 0.01864675f, 
    0.01447006f, -0.27948859f, 0.30236945f, 0.45586962f, 0.15814301f, 0.04475918f, -0.43015870f, 0.38470170f, 
    0.18724203f, 0.21308120f, 0.17291631f, 0.12968244f, -0.05447632f, -0.32557398f, -0.03784916f, -0.08930615f, 
    0.31382775f, 0.30153409f, 0.23318046f, -0.04550696f, -0.06954554f, -0.12780857f, -0.15377368f, -0.45709142f, 
    0.23460892f, 0.04712658f, 0.28744459f, 0.00509114f, 0.17242782f, -0.13452184f, 0.07380491f, -0.35383099f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19984598f, -0.14004520f, 0.02398597f, 0.16887528f, 0.41487926f, -0.08060385f, -0.42438644f, -0.12960771f, 
    0.10878767f, -0.32983476f, -0.17967811f, 0.43369484f, 0.26234829f, -0.24859934f, -0.21086042f, 0.37387314f, 
    0.06426002f, -0.15567070f, -0.21908133f, -0.40628347f, 0.26494664f, 0.15818553f, 0.02225264f, -0.30545864f, 
    0.02484255f, 0.32128775f, -0.12402748f, 0.30157655f, -0.21387158f, 0.49029374f, -0.06872802f, 0.29673973f, 
    -0.15236475f, -0.23602134f, -0.23332262f, -0.39549878f, -0.09634396f, 0.23211870f, 0.37658426f, 0.41927117f, 
    -0.28545579f, 0.24121878f, 0.26011834f, 0.16645037f, 0.15029404f, -0.24469784f, 0.17194860f, -0.08416428f, 
    -0.19480519f, -0.08088882f, 0.32009825f, 0.18322733f, 0.07920051f, -0.28476411f, -0.18430310f, 0.44165638f, 
    -0.22237316f, 0.11583774f, 0.34771374f, 0.03409807f, 0.47355694f, -0.07635947f, -0.18570836f, 0.18115036f, 
    0.06049490f, 0.09442110f, -0.29743835f, 0.43517199f, 0.19125146f, 0.47046909f, -0.18268450f, 0.32741237f, 
    -0.09407640f, -0.12283701f, 0.08483233f, 0.17690083f, 0.42529637f, 0.46857795f, -0.01861851f, 0.43237251f, 
    -0.29843569f, -0.37175834f, 0.11633193f, -0.23710307f, -0.06790226f, 0.05216274f, -0.20073584f, -0.20126690f, 
    -0.15924954f, 0.01350467f, 0.11729293f, 0.48365346f, 0.51351321f, -0.14325194f, -0.02588343f, -0.00299287f, 
    -0.09167849f, -0.13009092f, -0.19402315f, 0.11260291f, 0.16946535f, 0.32715008f, 0.25237060f, 0.25263834f, 
    0.26105997f, 0.14486602f, 0.03560005f, 0.20688708f, 0.53553462f, 0.43391344f, -0.06909311f, 0.20656231f, 
    -0.01635317f, -0.26852757f, 0.06693854f, 0.05658965f, 0.47819814f, 0.39447924f, 0.31144089f, 0.33410546f, 
    -0.21623409f, 0.34364673f, -0.21355347f, 0.22659811f, 0.39117390f, 0.36368778f, -0.21001494f, -0.30559784f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.27163404f, 0.03669640f, 0.09939037f, 0.08683734f, 0.01628797f, 0.26592273f, -0.04944126f, 0.09381725f, 
    0.03203979f, 0.23327202f, -0.06829362f, 0.16959752f, 0.10071414f, -0.02917560f, -0.28874865f, 0.01071768f, 
    -0.00087388f, -0.22333981f, -0.43053174f, -0.13233754f, 0.14180398f, 0.07490858f, -0.00049609f, 0.11753863f, 
    0.49416748f, 0.02372960f, 0.07919600f, 0.03823275f, -0.09649346f, 0.17158322f, 0.13206001f, 0.22386047f, 
    0.18002132f, 0.07665782f, 0.00568147f, -0.10736535f, 0.03033245f, 0.05695029f, 0.13356939f, 0.01452300f, 
    -0.55166149f, 0.14435039f, 0.14746995f, 0.21388231f, 0.14915888f, -0.07299177f, 0.12070794f, 0.22680004f, 
    -0.13527463f, 0.04270153f, -0.15028995f, -0.02707399f, 0.09577057f, -0.14580420f, -0.01849024f, 0.11246219f, 
    -0.54999596f, 0.14981335f, -0.04930375f, -0.01949526f, 0.10964306f, 0.10737020f, -0.12842694f, 0.17276543f, 
    0.07731193f, 0.06272402f, -0.17432693f, 0.11331055f, -0.01493324f, 0.03457801f, 0.18281601f, -0.14961182f, 
    -0.17679024f, 0.02528249f, 0.05729321f, 0.00070949f, 0.65233374f, 0.10357521f, -0.24626902f, -0.12328114f, 
    -0.12509996f, -0.26254031f, 0.17689298f, 0.03150340f, 0.04808841f, -0.45531124f, 0.02475013f, -0.00091533f, 
    -0.05368843f, 0.24719660f, -0.03575095f, 0.06475089f, -0.02824231f, 0.00194365f, -0.03217806f, 0.06639436f, 
    -0.08755521f, 0.16035730f, -0.05364558f, -0.05253358f, 0.06411249f, 0.37611395f, 0.00230235f, -0.05896022f, 
    0.36794096f, 0.07134203f, 0.06055148f, 0.06763961f, 0.03576297f, 0.14126053f, 0.04051925f, -0.00240440f, 
    -0.00766240f, -0.00183569f, 0.11117701f, 0.05343688f, -0.03266168f, 0.07477397f, -0.03082973f, 0.16344112f, 
    -0.27730858f, 0.36334774f, -0.11791370f, -0.23594606f, 0.23803426f, 0.29577142f, 0.17232986f, 0.01095641f, 
    -0.13226241f, -0.00291262f, 0.10986459f, -0.09190015f, -0.09108575f, 0.18812364f, -0.03764012f, -0.08634029f, 
    0.06617533f, -0.21110864f, 0.01721095f, 0.32930514f, 0.02994145f, 0.10825746f, -0.28353906f, -0.00728959f, 
    0.11278553f, -0.31945816f, 0.00615487f, -0.12150633f, 0.27691060f, 0.04099960f, 0.04249990f, -0.00102367f, 
    -0.09193508f, -0.13065165f, 0.19002207f, -0.12587264f, 0.10292181f, 0.04784976f, 0.36314279f, 0.14975971f, 
    0.21629260f, -0.11846145f, -0.05265590f, -0.10139979f, 0.03247923f, -0.02846077f, 0.23410422f, -0.17786375f, 
    -0.29464865f, -0.11340243f, 0.05821405f, 0.17247774f, -0.14549354f, -0.09247326f, -0.13888983f, 0.15990482f, 
    0.33801344f, -0.01592832f, -0.16012235f, -0.05735277f, -0.06887379f, -0.01593811f, -0.01858499f, -0.03587055f, 
    -0.34656844f, -0.52122843f, -0.17959867f, 0.16079505f, 0.15921062f, 0.62479699f, 0.02549244f, 0.22336794f, 
    0.07916409f, 0.09273215f, -0.28682059f, 0.02785419f, -0.04139402f, 0.14348777f, -0.13045152f, -0.02308006f, 
    0.03694080f, -0.05585051f, 0.24171437f, 0.04183073f, 0.21553281f, -0.15206596f, 0.03998392f, 0.05345350f, 
    -0.01996617f, -0.13604365f, 0.12586187f, 0.04671119f, -0.05369114f, 0.07088049f, 0.12417140f, -0.05921967f, 
    0.23455043f, 0.00846173f, 0.31233558f, 0.05241422f, -0.08437706f, 0.00301253f, -0.06452852f, 0.02607212f, 
    0.05188604f, -0.03555530f, 0.08500323f, 0.07929388f, -0.20452122f, -0.31465343f, 0.12199293f, -0.08127638f, 
    0.50008607f, 0.06421103f, 0.04027468f, 0.07330900f, 0.04683185f, 0.07847943f, -0.03484709f, -0.16732310f, 
    -0.10312862f, -0.08478372f, 0.45737478f, -0.01842419f, 0.16166662f, 0.09874243f, -0.16646323f, 0.03344639f, 
    -0.28354451f, 0.03847389f, -0.18578327f, 0.28823912f, 0.15444392f, 0.11124649f, -0.07085173f, 0.00460657f, 
    -0.03477964f, 0.02321044f, 0.07033652f, -0.05172276f, -0.09115577f, -0.01349714f, 0.01410364f, -0.07228316f, 
    -0.02252105f, -0.12275111f, 0.05613850f, 0.04506985f, -0.09336349f, -0.12891655f, 0.03551120f, 0.03436900f, 
    -0.05337406f, -0.13139699f, -0.08079905f, -0.03312382f, -0.08002501f, -0.05067815f, 0.07867867f, 0.04776701f, 
    0.02289942f, -0.07597732f, 0.04251882f, -0.06141356f, -0.01369494f, 0.01706087f, 0.03327885f, -0.05896970f, 
    0.05759315f, -0.07771109f, 0.01524854f, -0.08534257f, -0.06476655f, 0.00689469f, 0.00001512f, 0.03706490f, 
    -0.08938754f, -0.15186293f, -0.06747725f, -0.02001214f, -0.01739662f, -0.01694248f, 0.01910526f, -0.10869460f, 
    0.09247065f, -0.00281327f, -0.01060991f, -0.04499518f, -0.01672465f, -0.07399081f, -0.01716228f, 0.01928316f, 
    -0.06158566f, -0.13814257f, -0.04499251f, -0.06011059f, 0.03851059f, 0.02328611f, -0.06987457f, -0.02339135f, 
    -0.03540338f, -0.05073929f, 0.04539037f, -0.08974162f, 0.01942571f, 0.04776576f, 0.01645083f, -0.08530920f, 
    -0.02899964f, -0.06548700f, -0.09719536f, 0.03319285f, -0.08534904f, 0.04106307f, -0.10344423f, 0.02399268f, 
    -0.05370693f, -0.12480045f, -0.09760794f, 0.06072971f, -0.01585625f, -0.05493422f, 0.01041724f, 0.02274101f, 
    0.01438204f, -0.04639518f, -0.06324027f, -0.03797202f, -0.03236485f, 0.06355070f, -0.02662991f, 0.04246151f, 
    -0.03358353f, 0.00160356f, -0.00404149f, -0.05393143f, 0.02637969f, -0.05501645f, -0.04376010f, -0.08609562f, 
    0.07400502f, 0.07592135f, 0.04034924f, -0.04390792f, 0.00802810f, 0.02489232f, 0.07069203f, -0.04609283f, 
    -0.07837442f, 0.00665344f, -0.04173999f, 0.05574076f, -0.04582183f, 0.03397424f, -0.12057845f, 0.02399131f, 
    -0.09409002f, 0.05040314f, -0.00285551f, -0.08278727f, -0.10417356f, -0.07376252f, 0.01161722f, -0.00375898f, 
    0.06341831f, -0.00908529f, -0.04890123f, 0.07895352f, -0.04624857f, 0.04282202f, -0.03590631f, -0.06239853f, 
    -0.01633949f, -0.07114816f, -0.00536597f, 0.01583063f, 0.02219271f, 0.01422194f, 0.00074402f, 0.06631996f, 
    0.05901443f, -0.01132059f, -0.05055348f, 0.05793010f, -0.04154888f, 0.05772291f, 0.02781099f, 0.04320038f, 
    0.05715610f, 0.03232198f, 0.04918899f, 0.00718592f, -0.08669211f, 0.05830856f, 0.04141319f, 0.05314272f, 
    -0.06845400f, -0.10289519f, 0.04774107f, 0.05290405f, 0.04447481f, -0.01764885f, 0.02469350f, -0.04354359f, 
    -0.03621661f, -0.08785029f, -0.01398554f, -0.10002158f, -0.10284727f, -0.07563107f, -0.07318097f, 0.01874741f, 
    0.05295631f, 0.08630746f, -0.09639966f, -0.02322312f, -0.10118359f, 0.01080262f, -0.03322509f, -0.05630788f, 
    -0.09704224f, -0.05784859f, -0.03548832f, -0.04171439f, 0.01935068f, -0.07552961f, 0.05645830f, -0.06871945f, 
    0.04421403f, 0.04677726f, 0.02198861f, -0.04322016f, 0.02438749f, -0.00229945f, 0.00749607f, -0.00461689f, 
    -0.01693394f, -0.06258930f, -0.08908217f, 0.05331879f, -0.04284328f, -0.07574584f, -0.06895524f, -0.00556617f, 
    -0.07777222f, -0.07605952f, -0.04032210f, -0.04891476f, -0.08212350f, -0.06199902f, -0.06828780f, 0.03568535f, 
    -0.04015055f, 0.02848284f, -0.05779507f, 0.04946665f, -0.03031346f, 0.04133511f, -0.08582923f, -0.08057025f, 
    -0.08090895f, -0.04641417f, 0.05114604f, -0.05003027f, -0.05056454f, 0.04617636f, -0.01977665f, 0.00215166f, 
    -0.08304886f, 0.08762913f, 0.07282190f, -0.07113129f, 0.00731084f, -0.02955770f, -0.04120250f, -0.03152829f, 
    -0.03030212f, 0.02451287f, -0.04668202f, -0.08199207f, 0.03967131f, -0.08722310f, -0.04571232f, -0.03906903f, 
    0.05972714f, -0.05533421f, -0.01423550f, 0.04016952f, -0.03318543f, 0.08838688f, 0.05562507f, -0.08475653f, 
    -0.48488119f, 0.07220472f, -0.00021669f, -0.06920514f, 0.16120322f, 0.07326576f, -0.14489459f, 0.04308213f, 
    -0.15212151f, -0.79464847f, 0.08674476f, -0.01619647f, 0.44089052f, -0.10178991f, 0.19243002f, 0.10134722f, 
    -0.24701123f, -0.05225501f, 0.13437386f, -0.08961491f, -0.03073833f, 0.06928742f, -0.03520999f, 0.05946078f, 
    -0.56848288f, 0.04083332f, -0.29310781f, -0.08679379f, -0.10873549f, 0.50538981f, -0.06998900f, -0.38384458f, 
    0.19160540f, -0.29475200f, -0.06870108f, -0.32657909f, -0.20512778f, -0.02498931f, -0.03035943f, 0.30754539f, 
    0.07957123f, 0.21902418f, 0.13663636f, 0.13404307f, 0.30370817f, -0.34494111f, 0.02875246f, -0.34412050f, 
    0.01102830f, 0.02537284f, 0.28262097f, 0.15090351f, 0.29726580f, -0.21380839f, 0.05331351f, 0.18514355f, 
    0.10442410f, -0.17233728f, -0.36250684f, -0.05169242f, 0.23744926f, -0.04540445f, 0.03195634f, -0.02461161f, 
    0.02633700f, 0.44880596f, 0.01884002f, 0.24733181f, 0.48490670f, 0.27755857f, 0.09318592f, -0.65626854f, 
    0.10434845f, -0.06774072f, -0.10072286f, -0.29886851f, -0.12760614f, 0.19984686f, -0.07496180f, 0.23090474f, 
    -0.06896569f, -0.26521423f, 0.00643236f, -0.06568030f, 0.04835472f, -0.08206001f, 0.18490748f, -0.35782918f, 
    -0.01145483f, 0.03308199f, 0.32320210f, 0.21855137f, 0.46499932f, 0.00536595f, 0.05828716f, 0.07058082f, 
    0.19618045f, 0.15129620f, 0.20169333f, -0.00203403f, 0.27020079f, 0.16364101f, 0.09609400f, 0.09864875f, 
    -0.48178494f, 0.00159445f, -0.00769170f, 0.11393897f, 0.22449382f, 0.24021935f, 0.06070274f, -0.64056122f, 
    0.03293067f, 0.02957276f, -0.09486334f, 0.01474349f, -0.05518936f, 0.19455488f, -0.35471183f, 0.19467005f, 
    -0.21864577f, -0.41082984f, -0.12342815f, -0.05679189f, -0.52145869f, 0.07889399f, -0.06418362f, 0.02019815f, 
    -0.13824356f, -0.26246649f, 0.36348096f, 0.05243228f, 0.16188791f, 0.02169164f, -0.17392701f, 0.24439061f, 
    0.06672076f, -0.00636570f, -0.06927015f, 0.28366932f, -0.02357258f, 0.09269561f, -0.22760287f, 0.26156816f, 
    0.25839832f, 0.06555056f, -0.20996337f, -0.15763457f, 0.04266419f, -0.13562247f, -0.00895453f, 0.18127307f, 
    0.30356717f, -0.11853497f, 0.19105053f, 0.19761761f, 0.22107792f, -0.01450977f, 0.00852992f, 0.10317624f, 
    -0.05677100f, 0.30226499f, -0.04529226f, 0.03382602f, 0.33074334f, -0.15792949f, -0.02684696f, 0.10421692f, 
    -0.03747106f, -0.01400861f, 0.04362683f, 0.12468649f, 0.05745447f, -0.16377144f, 0.17419620f, 0.04772601f, 
    0.26519519f, -0.07650930f, -0.06470398f, 0.04475113f, 0.01020581f, 0.07005504f, 0.08212022f, -0.15048234f, 
    -0.15538636f, -0.30567119f, 0.05962062f, -0.24475996f, 0.02758786f, -0.12292493f, -0.18628624f, 0.21027669f, 
    0.08350649f, -0.02722315f, -0.10091394f, 0.12757024f, -0.01632447f, -0.13415977f, -0.20400436f, 0.37679955f, 
    -0.19045663f, 0.08337930f, 0.04627556f, 0.48094589f, 0.02460158f, 0.05429642f, 0.10334601f, 0.20409882f, 
    -0.16366762f, 0.19052936f, -0.05097783f, 0.05505116f, 0.02940143f, 0.25662106f, 0.19229579f, -0.10169463f, 
    -0.34201592f, 0.24430078f, 0.17974600f, -0.11854055f, -0.09035181f, -0.02603686f, -0.04215933f, -0.00609585f, 
    -0.10784346f, -0.34847108f, 0.12566578f, 0.09608656f, 0.11578534f, -0.69393432f, -0.21510504f, -0.01294789f, 
    0.13534467f, 0.08882034f, -0.07484275f, 0.04525295f, 0.14965148f, -0.25422460f, -0.07431166f, -0.10463017f, 
    -0.20196347f, -0.06503887f, 0.16664048f, 0.00857056f, 0.23960906f, 0.04949902f, 0.52947104f, 0.03648246f, 
    0.31410268f, 0.02625911f, 0.20419326f, 0.02070947f, 0.14912835f, 0.16085449f, 0.22188212f, 0.28734642f, 
    0.00671928f, -0.00561679f, 0.02276815f, -0.03637399f, 0.02693412f, -0.20715815f, -0.11006672f, -0.06030669f, 
    0.03982642f, -0.10701493f, -0.07925098f, -0.02451360f, -0.00594412f, -0.14523727f, 0.21555217f, 0.13910721f, 
    -0.05697476f, 0.29198802f, 0.03266625f, 0.06408861f, -0.31672600f, 0.01623371f, -0.03504062f, -0.20978220f, 
    -0.55218589f, -0.02553234f, 0.12593023f, 0.13841429f, -0.04680151f, 0.16684082f, -0.20738222f, -0.01780243f, 
    0.00272791f, -0.06641708f, 0.02233330f, 0.02918087f, 0.08981767f, 0.06440885f, -0.19783410f, 0.12730901f, 
    -0.03207110f, 0.00801430f, 0.09194000f, 0.00604197f, -0.07379676f, 0.05108067f, 0.06007947f, -0.23977351f, 
    -0.15572686f, 0.08224114f, 0.09948353f, 0.08351823f, -0.04951109f, -0.01282194f, 0.04346707f, -0.05442512f, 
    0.10197292f, 0.21239886f, 0.15678076f, -0.04857671f, 0.06623130f, 0.27374631f, 0.04787727f, -0.08796070f, 
    0.05607761f, -0.04374309f, 0.01327634f, -0.04495057f, 0.00716400f, 0.00076422f, -0.24762571f, 0.35943699f, 
    0.01241786f, -0.02713641f, -0.17094332f, 0.13071029f, -0.05582321f, 0.33156493f, 0.11487742f, 0.16500425f, 
    -0.09021594f, 0.02890716f, 0.02707701f, 0.01149679f, 0.03847212f, 0.34317166f, -0.00286487f, 0.09735945f, 
    -0.21253571f, -0.12736712f, -0.28313172f, -0.10267066f, -0.01148658f, -0.05910975f, 0.03406626f, 0.07057646f, 
    -0.00725348f, -0.11390121f, 0.01591549f, 0.00655733f, 0.17445071f, 0.56966662f, -0.16824518f, -0.04821322f, 
    -0.21616080f, 0.07838106f, -0.01978111f, 0.10106458f, 0.23966044f, -0.19330268f, -0.07035575f, 0.24027354f, 
    -0.12722786f, 0.06260826f, -0.25475281f, 0.11887844f, 0.26570341f, -0.04613909f, 0.18669686f, 0.39461032f, 
    0.32725057f, 0.01736168f, -0.08470962f, 0.14982186f, 0.08433457f, -0.16431782f, -0.12565851f, -0.00376113f, 
    0.02771243f, -0.07097983f, -0.03504642f, 0.00863329f, 0.01398318f, 0.02462030f, -0.03252812f, -0.06998926f, 
    -0.09264644f, -0.04702219f, 0.06542746f, 0.02152960f, 0.03430948f, 0.05145983f, 0.01328858f, -0.05534468f, 
    -0.06566003f, 0.06644812f, -0.06495791f, 0.00957271f, 0.06602210f, -0.02862095f, 0.00181463f, 0.05241257f, 
    0.03550955f, 0.00674378f, -0.01272390f, -0.04914348f, -0.06231103f, -0.00613022f, 0.04844837f, -0.00519632f, 
    -0.01420642f, -0.00709159f, -0.07185157f, -0.09193949f, -0.01180732f, 0.05587503f, 0.00968044f, 0.06726313f, 
    0.05162205f, -0.01811854f, 0.00401486f, -0.06614360f, -0.02412520f, 0.07673486f, 0.08094904f, -0.04718982f, 
    -0.04003468f, 0.07416379f, 0.07033231f, 0.03427235f, -0.03872922f, 0.01132018f, -0.00086363f, -0.01822075f, 
    -0.04781551f, -0.04915311f, -0.07300326f, 0.03364278f, -0.02254522f, -0.06513208f, 0.03447009f, -0.00308858f, 
    -0.08721314f, -0.04588306f, 0.05987434f, 0.02060346f, -0.08051871f, 0.04018905f, -0.05294908f, -0.03728164f, 
    -0.05022761f, -0.08638962f, -0.02415515f, -0.06488227f, -0.08503699f, -0.04741491f, 0.01079719f, -0.03512869f, 
    -0.03971848f, -0.09835684f, 0.05844543f, -0.02999569f, 0.03725774f, -0.04435214f, 0.02966471f, -0.02836945f, 
    -0.04815385f, 0.06277073f, 0.02703088f, -0.05181624f, -0.04349083f, 0.04212921f, 0.03288914f, 0.04286968f, 
    -0.06205406f, -0.05823815f, 0.04477758f, 0.00570568f, 0.03242672f, -0.04428311f, -0.04424459f, 0.01949253f, 
    -0.05165429f, 0.05132030f, 0.05739927f, 0.04992278f, -0.01415594f, -0.01477302f, 0.02267920f, -0.07721125f, 
    -0.06038574f, 0.00336988f, 0.02209367f, -0.06954028f, 0.01509761f, 0.05661304f, -0.03336110f, 0.06439343f, 
    -0.04937464f, -0.07833207f, -0.01896311f, 0.01818772f, -0.04197590f, -0.01429800f, -0.08748759f, -0.06911170f, 
    0.12138548f, -0.01024169f, -0.13186987f, -0.08586357f, -0.36903858f, -0.40595126f, 0.18965045f, -0.21162143f, 
    -0.11243917f, 0.20230402f, 0.01741926f, 0.20365658f, 0.17483887f, 0.19306763f, 0.14571758f, 0.12030712f, 
    -0.05583411f, 0.38399068f, 0.20626706f, -0.16105096f, -0.42525160f, 0.00229533f, -0.06174671f, -0.01120942f, 
    -0.14945176f, 0.10146237f, -0.20125803f, -0.08048160f, -0.12747416f, 0.23013858f, 0.11742117f, 0.02457334f, 
    -0.27826220f, -0.20068605f, 0.02950504f, -0.04681250f, -0.07497818f, -0.28531036f, 0.19556518f, 0.09369719f, 
    -0.13576822f, 0.26843172f, 0.18703936f, 0.14645144f, 0.08201376f, -0.82248181f, 0.23284324f, -0.15979350f, 
    -0.26095515f, -0.08582266f, 0.19858028f, -0.41946378f, -0.14838587f, 0.00678896f, 0.03301143f, -0.03356461f, 
    -0.01566819f, 0.68325353f, 0.29659873f, -0.12224250f, 0.13128521f, 0.26051402f, 0.02756524f, 0.04381165f, 
    -0.06365154f, 0.14950858f, -0.15633781f, 0.06745061f, -0.19028534f, 0.00347970f, -0.24991114f, 0.13295467f, 
    0.08171251f, 0.01410673f, -0.02353665f, -0.13692212f, 0.08108942f, 0.34386012f, 0.06570327f, 0.20229985f, 
    -0.34664878f, -0.06519868f, -0.21652952f, -0.02468100f, -0.05040604f, 0.13427190f, -0.09936217f, -0.33071655f, 
    -0.15331751f, -0.14716037f, -0.26542288f, 0.01012382f, -0.02002341f, -0.22493136f, 0.05779726f, -0.01694405f, 
    -0.02345381f, -0.34593689f, -0.17358097f, 0.01886261f, 0.09062079f, -0.03173884f, -0.22078547f, 0.14958169f, 
    -0.11078427f, 0.05885471f, 0.06112999f, 0.08187289f, 0.22611414f, -0.08140504f, -0.01070504f, 0.42764813f, 
    0.11295199f, -0.04368981f, -0.44385585f, 0.06324685f, 0.20043568f, -0.34635550f, -0.11332215f, 0.44442883f, 
    0.13170581f, 0.32881352f, -0.13074431f, 0.06302692f, 0.17876443f, -0.04761153f, -0.91083592f, -0.09024417f, 
    0.00119503f, -0.01393670f, -0.02671431f, -0.03230701f, -0.02255923f, 0.02123179f, 0.13938518f, 0.30415833f, 
    0.06440786f, 0.05244957f, -0.02362180f, -0.05723007f, 0.15125920f, -0.01517158f, 0.14348225f, 0.13013577f, 
    0.19860558f, 0.00302480f, 0.29520896f, 0.04457620f, 0.10972986f, 0.07687842f, -0.08715654f, -0.11524387f, 
    0.23930365f, 0.05574115f, 0.03512967f, 0.01379781f, -0.05088021f, 0.32940793f, 0.13218164f, -0.00193467f, 
    0.23539460f, -0.04505663f, -0.02621360f, -0.01691534f, 0.18555720f, 0.07040904f, -0.10465171f, -0.44808963f, 
    -0.02610456f, -0.12559751f, 0.20880099f, 0.05724081f, 0.18397586f, 0.00860623f, 0.15171649f, -0.03086068f, 
    -0.35246989f, -0.05191987f, 0.08796253f, -0.06345098f, 0.13003393f, -0.00663526f, -0.05175503f, 0.02811513f, 
    -0.11721817f, 0.12072431f, -0.03079592f, 0.00135636f, 0.14132541f, 0.30899704f, 0.05202186f, 0.04687002f, 
    0.05601263f, 0.24299364f, 0.10262281f, 0.12995097f, -0.56187212f, -0.01309103f, 0.07838652f, 0.07381672f, 
    0.11923286f, -0.06013527f, 0.11474897f, -0.10139166f, 0.24189763f, -0.09255787f, -0.03732731f, 0.12707849f, 
    0.01640924f, 0.08384968f, -0.05166366f, -0.00364026f, 0.06184787f, -0.05239341f, -0.43911609f, -0.01013561f, 
    0.03854594f, 0.17304616f, -0.67140287f, 0.15704149f, 0.10971423f, 0.12998074f, 0.03923999f, -0.01522679f, 
    0.11493722f, 0.02592119f, -0.24485657f, -0.08115654f, -0.10663568f, -0.26798496f, 0.10073069f, -0.13668473f, 
    -0.15906112f, 0.13366476f, -0.00504484f, 0.13896471f, -0.01349733f, 0.15543270f, 0.03262885f, -0.02101823f, 
    -0.11824100f, -0.01297312f, -0.19705349f, -0.00134156f, 0.00705873f, -0.01376831f, -0.15266317f, 0.36963528f, 
    0.10249926f, 0.05665285f, -0.07169924f, 0.15081893f, -0.16567363f, -0.01018657f, 0.14693850f, -0.04958980f, 
    -0.14315036f, 0.02604243f, 0.02159014f, 0.03137869f, 0.11828891f, 0.13372870f, -0.00581176f, -0.08318445f, 
    -0.11104272f, -0.12106496f, 0.02649554f, -0.34664309f, 0.28578532f, 0.34737280f, 0.01014118f, 0.04391102f, 
    0.03741344f, 0.11306652f, 0.27800554f, -0.04824123f, -0.02443835f, 0.09982261f, -0.02846435f, 0.31681100f, 
    -0.00996889f, -0.03927621f, -0.20497119f, 0.09711932f, -0.13264766f, 0.04295605f, -0.06462830f, -0.15632616f, 
    -0.01000123f, 0.00185960f, -0.05209956f, 0.00389591f, -0.01371095f, -0.14341798f, 0.14865816f, 0.47808444f, 
    0.21836212f, 0.01820870f, -0.01180290f, 0.07938927f, -0.11911664f, -0.11559099f, -0.12437180f, 0.00834371f, 
    0.32617021f, -0.03283322f, 0.27624720f, 0.02080619f, 0.05344146f, -0.20907053f, 0.07422148f, 0.00088512f, 
    0.23408830f, 0.37938949f, -0.05044146f, -0.00961376f, 0.15520322f, -0.33974338f, 0.13609231f, -0.03973949f, 
    -0.01577271f, 0.09161390f, 0.07174931f, -0.00193668f, 0.33058065f, 0.00684082f, -0.07946607f, 0.12224960f, 
    0.08103553f, 0.31688380f, 0.03857486f, 0.07137923f, -0.18033931f, -0.11248288f, -0.09533073f, 0.03285755f, 
    -0.12817866f, 0.04583897f, -0.23432642f, 0.14012001f, 0.00652420f, 0.07881714f, 0.14999352f, -0.13198227f, 
    -0.07990322f, -0.10666525f, 0.54612648f, 0.06164708f, 0.08676597f, 0.00076564f, -0.06123487f, 0.02703196f, 
    0.04298630f, -0.16798204f, 0.24177864f, -0.02216474f, 0.27732149f, 0.09784080f, -0.03410066f, 0.32098335f, 
    -0.00681327f, -0.06750315f, -0.01693144f, -0.02362420f, -0.10494323f, -0.04614759f, -0.04670084f, 0.31110433f, 
    0.10055714f, 0.04323769f, 0.15985054f, 0.02287732f, -0.00318723f, 0.07729541f, 0.00227447f, -0.18603314f, 
    0.10413533f, 0.03102153f, 0.26513442f, 0.06529857f, 0.04930967f, 0.01682135f, -0.02926729f, 0.43712088f, 
    0.27571413f, -0.13367063f, 0.19751264f, -0.01285710f, 0.04323695f, -0.26099104f, -0.03938424f, 0.30797985f, 
    -0.03599775f, 0.40041611f, -0.07321486f, 0.04506171f, -0.16634950f, 0.10271297f, -0.03381140f, 0.18238637f, 
    0.29673102f, 0.02069211f, -0.53452855f, -0.07383191f, -0.02370661f, -0.27699989f, -0.02117475f, 0.28761959f, 
    0.00381662f, -0.06156463f, 0.10459498f, 0.07927623f, 0.16346180f, -0.36044523f, 0.08341821f, 0.23185359f, 
    -0.07036326f, 0.30387148f, 0.05233292f, 0.10092038f, 0.12524836f, -0.07705059f, 0.04348647f, -0.11618545f, 
    -0.22276446f, 0.10483157f, 0.04859339f, -0.02961321f, 0.08210662f, -0.00394777f, 0.26300657f, 0.18208985f, 
    0.11857794f, -0.05363578f, -0.28863585f, -0.11148389f, -0.04093447f, 0.11079651f, 0.08552375f, -0.34583765f, 
    -0.25634131f, -0.06587957f, 0.19322993f, -0.24044432f, -0.19521706f, -0.42075902f, -0.23353481f, 0.17166017f, 
    -0.06364178f, -0.31852967f, 0.01205382f, 0.05794032f, -0.07960810f, -0.32714760f, 0.15257098f, 0.03538057f, 
    -0.13321206f, 0.02008564f, -0.14047967f, 0.31577381f, 0.30379751f, 0.09404341f, -0.06083976f, 0.03284303f, 
    -0.09227327f, -0.01737346f, 0.34251285f, 0.01008082f, 0.06817334f, -0.09808540f, 0.28812963f, 0.14924018f, 
    -0.10224512f, 0.32991734f, 0.03942144f, -0.26916578f, -0.20556313f, -0.22496590f, 0.02200728f, 0.08143836f, 
    -0.39858496f, 0.10233644f, 0.06305046f, 0.06385066f, 0.12454202f, -0.03503967f, -0.26050824f, -0.18784004f, 
    -0.11790332f, 0.08840689f, -0.02560136f, -0.12483224f, 0.08864257f, -0.39422745f, 0.03136343f, 0.04517665f, 
    -0.07780939f, 0.06416572f, 0.02080329f, 0.02650175f, 0.15691733f, -0.36522263f, 0.24136144f, -0.04338918f, 
    0.17396727f, 0.15622850f, -0.08704462f, -0.11974637f, 0.12292481f, 0.23798029f, 0.08426765f, 0.08232578f, 
    -0.04480843f, -0.04612999f, -0.06422131f, 0.04472829f, -0.08646453f, -0.03172836f, -0.06020675f, -0.01668714f, 
    -0.05215700f, 0.06405080f, 0.04844155f, 0.04529105f, -0.06034246f, -0.07862315f, 0.03410056f, 0.04910580f, 
    -0.00829309f, -0.01130932f, -0.02369948f, -0.08662047f, 0.00896713f, 0.02589322f, 0.01215262f, -0.07709842f, 
    0.01084861f, -0.01495022f, -0.05936436f, 0.02091854f, -0.04433396f, 0.01378504f, -0.08823694f, -0.08578477f, 
    -0.09725909f, -0.05991949f, 0.06993393f, -0.01016624f, 0.04468245f, -0.07370673f, -0.08993038f, 0.02439676f, 
    -0.06042250f, -0.08283064f, -0.02616917f, -0.01953349f, -0.04035537f, -0.00039241f, 0.01974095f, -0.02444224f, 
    -0.05631544f, -0.02981674f, 0.05574532f, 0.01441669f, -0.06475311f, -0.03272730f, 0.08230058f, -0.06868683f, 
    0.04374833f, -0.01074731f, -0.02909606f, -0.03355108f, -0.09498035f, 0.06746206f, -0.01171358f, -0.01595739f, 
    0.01768554f, -0.01249397f, -0.04496773f, 0.02761321f, -0.00240766f, 0.06023297f, -0.02350890f, -0.03036814f, 
    0.00910736f, 0.05091352f, 0.04376332f, 0.03037081f, 0.00522473f, -0.09121530f, -0.00585470f, -0.00076416f, 
    0.07927699f, -0.09879234f, 0.03768624f, -0.08623897f, 0.08208733f, 0.05880022f, -0.01185114f, -0.01644769f, 
    -0.04300942f, -0.08233573f, 0.01867480f, 0.04421572f, -0.06604277f, 0.01675969f, 0.06940266f, -0.03059232f, 
    0.00210647f, -0.05875481f, 0.06355228f, -0.03372593f, -0.10081545f, -0.06247031f, -0.05960159f, 0.02742267f, 
    0.02244354f, -0.02549139f, 0.03805677f, -0.06846056f, -0.08193966f, 0.02965507f, 0.03047456f, 0.06572391f, 
    -0.05714455f, 0.05881130f, -0.04668251f, 0.06329358f, -0.01095147f, -0.05052809f, -0.04091141f, -0.09344535f, 
    0.06155485f, 0.07131244f, -0.00744782f, -0.10026017f, -0.03867540f, -0.08724876f, -0.07282437f, -0.01418925f, 
    -0.23086393f, 0.13683718f, 0.23402293f, -0.08596954f, 0.23792525f, -0.05365881f, -0.14783117f, -0.59115618f, 
    0.11971159f, -0.09303596f, -0.06777117f, -0.41470072f, -0.38176435f, -0.40656614f, 0.05274758f, -0.34915614f, 
    -0.53197062f, -0.15370016f, -0.29812109f, 0.06318995f, -0.51948357f, 0.12306957f, 0.04507972f, 0.06291576f, 
    0.13074902f, 0.00517470f, -0.26502675f, 0.10708776f, -0.31804585f, -0.09042541f, -0.52295506f, -0.12166125f, 
    0.02792541f, 0.30315301f, 0.01008262f, -0.12307961f, -0.53219050f, 0.13338426f, -0.37398794f, 0.38786229f, 
    0.08453886f, 0.04789955f, -0.48300135f, 0.08331092f, 0.08315455f, 0.11623152f, -0.22442220f, -0.21068665f, 
    -0.01113727f, -0.01306100f, -0.22573125f, 0.37434304f, 0.11661729f, 0.19725020f, -0.02951618f, 0.05000885f, 
    0.27031797f, -0.46646926f, -0.37226871f, -0.03652256f, -0.24835864f, -0.01749752f, 0.04169244f, -0.08453292f, 
    -0.04316203f, -0.22694373f, 0.16865888f, -0.14042680f, 0.60080224f, 0.16686401f, 0.05920935f, -0.05586358f, 
    -0.04975317f, -0.14902188f, 0.15802670f, -0.35523427f, -0.37383372f, -0.17380302f, 0.16072090f, -0.40790045f, 
    0.05074765f, -0.11439931f, 0.10950714f, -0.05579696f, 0.01703003f, 0.19537209f, -0.04470098f, 0.02912514f, 
    -0.03061774f, -0.08487976f, 0.24567455f, -0.03974971f, 0.41905189f, 0.09739947f, -0.06510661f, 0.08548965f, 
    0.11897793f, 0.12685193f, 0.14377625f, -0.05015197f, 0.44209051f, 0.63004899f, -0.02715143f, 0.19555289f, 
    -0.20100898f, -0.04918930f, 0.07381012f, 0.06685328f, -0.40316749f, -0.30685413f, -0.01198776f, -0.41625258f, 
    -0.11444299f, 0.05597206f, -0.11881584f, -0.07800017f, -0.07318806f, -0.05856555f, -0.30243209f, -0.02985074f, 
    -0.64348453f, -0.59274763f, -0.12043084f, -0.09491281f, -0.22233164f, 0.00075616f, 0.11744750f, -0.01507528f, 
    0.26304257f, 0.09101404f, 0.26975125f, -0.04706024f, -0.08155154f, -0.27976692f, 0.25607583f, 0.14004974f, 
    0.18006016f, 0.01609793f, 0.00012707f, 0.05542069f, -0.09142808f, 0.02426962f, 0.19761953f, 0.09227023f, 
    0.05989502f, 0.07701807f, 0.13767159f, 0.00464043f, -0.04908658f, -0.06458628f, 0.05993171f, -0.09854363f, 
    -0.07340366f, 0.00359082f, -0.34805739f, -0.24577801f, 0.21204458f, -0.08180532f, 0.13277219f, -0.06950045f, 
    0.11814035f, 0.02040759f, -0.02191524f, 0.14563155f, 0.09257808f, 0.10973038f, -0.06462346f, -0.17062274f, 
    0.20981173f, 0.01608573f, 0.03557215f, 0.09592096f, 0.04109119f, -0.09291902f, -0.19991539f, -0.05264306f, 
    -0.11001985f, -0.04291194f, -0.02816983f, -0.07842610f, 0.09076808f, 0.22849990f, -0.03853044f, -0.21668100f, 
    0.01239023f, -0.27212024f, -0.03365510f, -0.02923075f, 0.01618724f, -0.26709804f, 0.13551846f, 0.23633182f, 
    0.08733779f, -0.11800021f, 0.08552857f, 0.15150015f, -0.11512638f, 0.05761817f, -0.06795892f, 0.10736847f, 
    0.27081880f, 0.09619015f, 0.06066624f, 0.03848488f, -0.21592039f, -0.06307118f, 0.16552493f, 0.27706230f, 
    0.18620448f, -0.04319380f, 0.27115557f, 0.02117947f, 0.04775465f, 0.10934075f, 0.04928981f, -0.37515059f, 
    0.24009013f, 0.17601269f, -0.25795174f, -0.07724074f, -0.05685263f, -0.05102315f, -0.02712850f, -0.06536542f, 
    0.08850199f, 0.05389450f, -0.03118065f, 0.06082990f, 0.14146844f, -0.33570775f, -0.10821859f, -0.05701892f, 
    -0.00460422f, 0.00434781f, -0.03586371f, 0.11214154f, -0.04429359f, 0.01088630f, -0.02116108f, -0.24078356f, 
    -0.09388033f, 0.00125547f, -0.06656807f, -0.08844247f, 0.05527993f, -0.34691271f, -0.10513887f, -0.00884216f, 
    0.02883122f, -0.05664429f, -0.29341191f, 0.54215211f, -0.22576003f, 0.02832561f, 0.01681545f, -0.07549325f, 
    -0.11425758f, 0.19958505f, 0.01736948f, -0.01132216f, -0.21156406f, 0.29212174f, 0.28548163f, -0.05430751f, 
    -0.05180204f, 0.08411749f, -0.06009062f, -0.04499414f, 0.23256749f, 0.22469053f, -0.20554489f, 0.04139183f, 
    0.06291646f, 0.07699046f, 0.12385486f, 0.00689857f, 0.24332520f, 0.19883150f, 0.05415266f, 0.29654437f, 
    0.14963031f, 0.09400398f, 0.05908690f, -0.12047808f, 0.07689792f, -0.11978560f, 0.21930544f, 0.03319656f, 
    0.05589866f, 0.14339375f, 0.08169453f, 0.17442061f, -0.06650270f, -0.14635758f, 0.27015916f, 0.22745420f, 
    -0.07595488f, 0.10223774f, -0.04763397f, 0.23284268f, 0.10130516f, -0.18900797f, 0.03931369f, 0.19109935f, 
    -0.04340505f, -0.00072548f, 0.07683753f, -0.12681468f, 0.18591233f, -0.01069929f, -0.03134512f, 0.09966999f, 
    0.14470151f, 0.21969143f, -0.06529649f, -0.01209569f, 0.30431104f, -0.47359812f, 0.18606047f, 0.16581514f, 
    -0.07012048f, 0.07101921f, -0.13705942f, 0.08234191f, 0.27088705f, -0.08146752f, 0.20867847f, -0.32976156f, 
    0.15673749f, 0.28847280f, 0.16741391f, -0.15753759f, 0.15132970f, -0.07980740f, -0.15649171f, -0.05789646f, 
    -0.10518293f, -0.09455968f, -0.19845827f, 0.10675941f, -0.00586233f, -0.18829370f, 0.05049545f, -0.37010798f, 
    0.04564949f, -0.00494221f, 0.23127493f, 0.13631263f, 0.06456263f, -0.00881414f, -0.00197607f, 0.03744246f, 
    0.15042049f, -0.09370886f, 0.13013840f, -0.07556816f, 0.22443891f, -0.43911090f, -0.00594621f, 0.36570054f, 
    0.03451113f, -0.14431122f, -0.07534353f, 0.07186018f, -0.09135979f, 0.05733164f, 0.07942954f, 0.03489869f, 
    0.40830022f, 0.02108109f, 0.10499610f, 0.02182829f, 0.00375759f, 0.02224270f, -0.22160786f, -0.27753919f, 
    -0.17793909f, 0.05103153f, 0.12445498f, -0.06998439f, 0.06851786f, 0.08310261f, -0.12468034f, 0.23782915f, 
    0.04701870f, 0.18390164f, -0.08039137f, 0.05183358f, 0.02035376f, 0.15435760f, 0.10759373f, 0.21059778f, 
    -0.05965048f, -0.06231580f, 0.07424538f, -0.04403096f, 0.01389633f, 0.03449541f, 0.02322876f, 0.04959717f, 
    -0.03524614f, -0.23053797f, 0.04089162f, -0.02405069f, 0.31383061f, 0.09764387f, -0.01063051f, 0.06700550f, 
    0.34691298f, -0.16633669f, -0.00774500f, -0.01962028f, 0.00689501f, 0.13919380f, 0.24334508f, 0.25435361f, 
    0.16053955f, -0.00788394f, -0.04956570f, 0.17495708f, 0.02585260f, 0.08935434f, 0.01097490f, -0.16871285f, 
    -0.01069436f, 0.02024875f, -0.00028721f, 0.10065594f, 0.07156879f, -0.07801598f, -0.01847019f, 0.20191714f, 
    0.05662776f, -0.06923176f, -0.18702583f, 0.03233473f, 0.18526706f, 0.03098832f, -0.07665370f, -0.04307788f, 
    -0.04938608f, -0.14532018f, -0.27914444f, -0.00425149f, 0.06436533f, 0.20482203f, -0.10197362f, 0.08805763f, 
    -0.05881643f, 0.02409260f, 0.07522955f, 0.13374878f, 0.03598198f, -0.01778490f, 0.12536871f, -0.24579288f, 
    -0.03081605f, 0.12165038f, 0.14554153f, -0.16461590f, 0.30509406f, -0.44395941f, -0.05574538f, -0.05221804f, 
    0.02699154f, -0.12100274f, 0.07049740f, 0.00729652f, 0.01170547f, -0.40027383f, 0.09682033f, 0.02004047f, 
    0.01082193f, 0.20642264f, 0.17239310f, -0.11188513f, -0.05020156f, 0.14711629f, 0.05321480f, -0.08444557f, 
    0.08850435f, 0.16054380f, 0.10112282f, 0.03552480f, 0.02094626f, -0.80975544f, 0.03789497f, -0.16298537f, 
    0.08122010f, 0.09657811f, -0.05306779f, 0.03368854f, -0.04854032f, 0.28818384f, 0.05783437f, -0.12192371f, 
    0.15781614f, -0.04111031f, 0.16500421f, 0.00845466f, -0.01572436f, -0.03415453f, -0.11798396f, 0.05519384f, 
    -0.32008880f, 0.04409553f, 0.02558924f, 0.11542631f, -0.04578020f, 0.13182926f, 0.04308445f, 0.10377713f, 
    -0.00388109f, 0.07483449f, -0.07643101f, -0.00973036f, -0.05723311f, 0.01272877f, 0.02365241f, -0.01699813f, 
    -0.00913010f, -0.00424062f, 0.02128094f, 0.02838407f, 0.01059895f, 0.03310888f, -0.06283040f, -0.04456040f, 
    0.06129387f, 0.04963460f, -0.03450103f, -0.02849746f, 0.01904038f, -0.01080693f, 0.03928809f, -0.04285616f, 
    -0.07330631f, -0.01963330f, 0.04657415f, -0.00267721f, -0.03197755f, -0.08890267f, 0.02482080f, -0.00838509f, 
    -0.05032019f, 0.03253723f, -0.07064304f, -0.06340568f, -0.06855606f, 0.04170658f, 0.03625393f, -0.05595431f, 
    -0.02237107f, 0.02488565f, -0.01188131f, -0.04127479f, -0.06431818f, 0.06881912f, 0.04580250f, -0.00570405f, 
    0.04217568f, -0.00484819f, 0.04441273f, 0.01726374f, -0.01205887f, 0.02676462f, -0.01009723f, 0.01762317f, 
    -0.00836130f, -0.02738148f, 0.01646388f, -0.07736137f, 0.01062212f, 0.05622213f, -0.05456278f, -0.08079039f, 
    0.02117620f, 0.01048396f, -0.03456458f, -0.03116654f, -0.02171679f, 0.06227006f, -0.06968742f, -0.02076097f, 
    -0.06706886f, 0.06424924f, 0.04663294f, -0.06518016f, -0.06673835f, 0.08450941f, -0.07789510f, -0.05863599f, 
    0.08035978f, -0.08722926f, 0.00352379f, -0.04838589f, -0.08535615f, 0.07864311f, 0.02447179f, -0.07774039f, 
    -0.02186263f, -0.06118977f, 0.06352694f, 0.05186587f, -0.03544571f, -0.06708796f, -0.04440093f, -0.02038178f, 
    -0.00003235f, -0.07607574f, 0.05761033f, -0.06671187f, -0.00036400f, 0.08738051f, -0.01204784f, 0.05847446f, 
    -0.06033101f, 0.03655707f, 0.07765950f, -0.08111057f, -0.04447404f, -0.07623623f, 0.02362791f, -0.07896322f, 
    0.02464559f, 0.02816965f, 0.05743206f, -0.00294081f, -0.05086380f, 0.01491426f, -0.07269303f, -0.06310157f, 
    0.02810764f, 0.04544200f, 0.00909272f, 0.06614176f, -0.06606275f, 0.02594221f, 0.07434871f, 0.03688890f, 
    -0.41432688f, -0.00047881f, -0.19998640f, 0.00028608f, -0.01715715f, -0.11090013f, -0.32729703f, -0.00966745f, 
    0.04158145f, -0.14459538f, -0.00785462f, 0.35553050f, 0.24944174f, -0.23813432f, -0.12031280f, 0.07955003f, 
    0.04400994f, -0.74414903f, -0.06296422f, -0.16336371f, 0.41963798f, 0.14051212f, -0.00018430f, -0.42205361f, 
    -0.02700743f, -0.11615147f, 0.31900364f, 0.03825902f, 0.02401804f, 0.40258697f, 0.09472261f, 0.26784706f, 
    0.26534760f, -0.37888363f, -0.07261554f, -0.46207055f, 0.12049870f, 0.10546494f, 0.06035376f, -0.57249171f, 
    -0.41086024f, -0.25421143f, 0.12416722f, -0.03832472f, 0.11768357f, 0.13561735f, 0.19323519f, -0.11440822f, 
    -0.19453900f, 0.07006183f, 0.01520422f, 0.07349277f, 0.09170333f, -0.24980196f, 0.03285981f, 0.15956201f, 
    -0.48197624f, -0.26941028f, -0.32235309f, 0.03344589f, 0.00589249f, 0.60261601f, -0.30408996f, 0.07497013f, 
    -0.02405149f, 0.29718482f, -0.21026598f, 0.19084153f, -0.38857070f, 0.33698308f, -0.22451127f, -0.04821418f, 
    0.10554843f, -0.34823748f, -0.13451722f, -0.09712340f, 0.49780771f, -0.03599737f, -0.26663020f, 0.03056629f, 
    -0.00183212f, -0.44875702f, 0.07176754f, -0.04235584f, 0.03834670f, -0.18752863f, -0.53382713f, 0.16406180f, 
    0.48928127f, 0.03711740f, -0.07561088f, 0.07189728f, 0.13524863f, 0.09601392f, 0.03008379f, -0.07280511f, 
    0.20088308f, -0.00534226f, -0.25492284f, 0.07906154f, -0.23993728f, -0.14298131f, 0.19840506f, -0.47345898f, 
    0.25245345f, 0.04782680f, -0.06518489f, -0.00179859f, 0.26507646f, 0.45871115f, -0.03540017f, -0.33267316f, 
    -0.36567220f, 0.03944928f, -0.08962948f, 0.08697791f, -0.03542059f, 0.18940826f, -0.06445500f, 0.46143687f, 
    -0.40189275f, 0.18248387f, -0.28318921f, 0.18805473f, 0.17992605f, 0.16860105f, -0.08570319f, -0.40308625f, 
    0.12315743f, -0.18494534f, 0.12635159f, 0.04316947f, 0.17205821f, 0.23853561f, -0.07623024f, 0.22119021f, 
    -0.05123459f, -0.02639432f, -0.07770392f, -0.09719004f, 0.02424322f, -0.05247739f, -0.10300297f, 0.08976354f, 
    0.24074197f, 0.10670931f, 0.18238020f, 0.15076232f, 0.08600698f, -0.05450056f, 0.10190213f, 0.19514954f, 
    -0.05159113f, -0.09479691f, 0.03552891f, 0.30248296f, 0.15929234f, 0.03256600f, -0.01460218f, -0.03916013f, 
    0.03987776f, 0.12852693f, 0.05068899f, 0.03107448f, 0.21842960f, -0.08691921f, -0.30585489f, 0.17879288f, 
    0.08803911f, -0.10475569f, 0.10084689f, -0.17024267f, -0.05739036f, -0.18376191f, -0.05036713f, 0.08478661f, 
    0.19855186f, 0.02783303f, 0.03243222f, -0.00315384f, 0.18092075f, -0.03161214f, 0.06405257f, 0.03196745f, 
    0.25223055f, -0.15488297f, 0.07136695f, -0.13703775f, 0.18200365f, -0.24179855f, 0.04909167f, 0.04496921f, 
    0.00329183f, 0.05067075f, 0.13326105f, 0.11384436f, 0.42966214f, 0.01453887f, 0.05624317f, 0.30837950f, 
    -0.15210299f, 0.09302606f, 0.09676589f, 0.21267296f, -0.15255412f, -0.04833995f, -0.20450293f, 0.19836064f, 
    -0.05123679f, 0.07957610f, -0.15238124f, 0.11632111f, -0.05399592f, -0.02047919f, 0.08964031f, -0.09504157f, 
    -0.07847985f, 0.05350368f, 0.01294232f, 0.08284752f, 0.05151882f, 0.05291935f, -0.07705632f, -0.08564428f, 
    -0.02636850f, -0.23971689f, 0.06094512f, -0.00771361f, 0.16301504f, -0.20167562f, -0.07945920f, 0.10908756f, 
    0.02586371f, -0.05084644f, 0.02887916f, -0.01454205f, -0.00331400f, -0.04301860f, -0.00273540f, -0.06386086f, 
    -0.15210256f, -0.02136848f, -0.12143722f, 0.01498828f, -0.08708706f, 0.27499327f, 0.26887023f, -0.25768983f, 
    0.37387565f, -0.18111821f, 0.28303006f, -0.20016930f, 0.06276172f, 0.11315884f, -0.05799851f, 0.17377584f, 
    0.27304706f, 0.03485030f, -0.01773620f, -0.00614443f, 0.06122845f, -0.11298634f, 0.13279928f, -0.12837037f, 
    0.13474715f, 0.19197108f, -0.02745521f, -0.01907522f, -0.35509834f, 0.02732739f, -0.08695319f, -0.04513174f, 
    -0.08086941f, 0.25311017f, -0.32925877f, -0.01218395f, -0.25345117f, -0.14221606f, 0.04980996f, 0.01826061f, 
    0.22774182f, 0.29871896f, 0.19344258f, -0.11506131f, -0.26647657f, -0.45336360f, -0.05190274f, -0.14894995f, 
    -0.55608851f, 0.11344253f, -0.07483733f, 0.17124143f, -0.20433703f, -0.25564620f, 0.02303645f, 0.13678569f, 
    0.27821058f, 0.30024004f, -0.11030213f, 0.00547190f, 0.01856074f, -0.02726203f, -0.09772874f, 0.07567696f, 
    -0.15486294f, 0.01180735f, 0.10399472f, -0.30845258f, -0.27467349f, 0.14203966f, 0.01960571f, -0.18065229f, 
    0.25176844f, 0.15478617f, 0.23287585f, 0.08171446f, -0.27933395f, -0.18672451f, 0.16393584f, -0.18760750f, 
    -0.04060841f, -0.79977429f, 0.03157580f, -0.06482862f, 0.17371283f, -0.30937162f, 0.03976982f, -0.07344738f, 
    -0.23195028f, 0.13654107f, 0.09733318f, 0.04950773f, -0.08804221f, 0.39849907f, 0.10091678f, -0.03571825f, 
    0.05829420f, 0.18385746f, 0.09022491f, 0.02222111f, 0.04363222f, 0.20502003f, -0.04723471f, -0.15214479f, 
    -0.35443929f, -0.06688594f, -0.17036586f, -0.26038009f, -0.24762435f, -0.22891632f, 0.08005655f, -0.07760362f, 
    -0.41663754f, -0.08063389f, 0.01085628f, 0.02491031f, 0.11787417f, 0.11228077f, -0.11105528f, 0.34618390f, 
    -0.49509272f, 0.02246160f, -0.04497677f, -0.10675402f, -0.02797636f, -0.77681971f, 0.03894496f, 0.16520125f, 
    0.24657300f, -0.05234083f, -0.44369870f, 0.09689474f, 0.00795986f, -0.09647413f, 0.11674637f, -0.18612559f, 
    -0.07839431f, 0.09766415f, 0.01385923f, -0.21069364f, -0.00321226f, 0.03895102f, 0.09820909f, 0.03106696f, 
    0.14026381f, -0.04433119f, 0.07022321f, -0.08580827f, -0.39598960f, -0.29799294f, 0.21211998f, 0.26764899f, 
    0.03437599f, 0.51287532f, 0.08584471f, 0.06336779f, 0.07158606f, 0.22081394f, 0.16907059f, 0.14197734f, 
    0.12656376f, 0.19346406f, -0.38708085f, -0.23786111f, -0.28766012f, -0.12547594f, 0.08448892f, 0.28168154f, 
    0.27212420f, 0.02517723f, -0.13444546f, -0.07406759f, -0.10490041f, -0.17002028f, 0.12878208f, 0.14174537f, 
    -0.23228954f, 0.09150685f, 0.03944879f, 0.14762734f, 0.08049645f, -0.11420105f, 0.12253921f, 0.04772275f, 
    -0.61740816f, 0.21165730f, 0.05923892f, 0.06561496f, 0.23739086f, -0.36218408f, 0.15290910f, 0.02758298f, 
    -0.14215322f, -0.03225885f, -0.03442023f, -0.44092456f, -0.20751934f, 0.18246622f, -0.05590029f, -0.35663640f, 
    -0.53724307f, 0.24274407f, 0.19258448f, -0.36040390f, -0.15924683f, -0.56760794f, -0.05253796f, 0.09455452f, 
    0.06204371f, -0.36118627f, -0.31334680f, 0.00609520f, -0.27730465f, -0.45224494f, -0.23915084f, 0.08562595f, 
    -0.05370108f, 0.21251564f, 0.00067743f, 0.24159212f, 0.17183545f, 0.06018157f, 0.00473837f, -0.03753115f, 
    -0.24119689f, -0.02726302f, -0.03623451f, 0.05379739f, 0.05854355f, -0.33661655f, 0.39338318f, -0.48109773f, 
    -0.27368334f, 0.15218502f, -0.04121201f, -0.19212300f, -0.48617956f, -0.20019715f, -0.01682490f, -0.06955031f, 
    -0.38331142f, -0.19888166f, -0.06834336f, -0.07863908f, 0.07383595f, -0.05516543f, -0.64115196f, -0.06763200f, 
    -0.03702533f, 0.03009334f, 0.08160049f, -0.15412164f, 0.07000507f, -0.27203253f, 0.03322367f, 0.28635293f, 
    0.10702462f, 0.05570151f, -0.14396562f, -0.03833839f, 0.21488562f, -0.59753621f, 0.08820067f, -0.00077967f, 
    0.14985789f, 0.30907431f, 0.01368435f, -0.06611642f, 0.19648144f, 0.05594936f, -0.30157563f, 0.18061714f, 
    -0.01418886f, -0.03898954f, 0.01374000f, -0.00766577f, 0.18647896f, 0.32049990f, -0.08896139f, 0.06400096f, 
    -0.12518974f, 0.13410234f, -0.08496995f, -0.30766213f, -0.02354383f, -0.02197946f, -0.01811935f, 0.00856733f, 
    -0.03104376f, 0.18544914f, 0.10179514f, 0.22979778f, -0.05286859f, -0.00172853f, 0.01189406f, -0.00150789f, 
    -0.39822200f, -0.11141471f, -0.07022826f, 0.21678695f, 0.12830813f, -0.54301310f, 0.00209210f, -0.00073255f, 
    0.01796824f, 0.03191069f, 0.04836039f, 0.13091660f, 0.09437646f, 0.12280109f, -0.18685918f, 0.32487133f, 
    -0.02825121f, 0.02887769f, -0.21904272f, -0.25983608f, 0.01883777f, -0.05058251f, -0.05134963f, 0.15034057f, 
    0.33932626f, -0.09276568f, 0.00500758f, 0.25413033f, 0.03948396f, 0.12722279f, -0.00211750f, -0.01072442f, 
    0.23446892f, 0.13231188f, -0.10710873f, 0.06038009f, 0.06012864f, -0.15139093f, 0.02462915f, 0.03069407f, 
    0.03897487f, 0.01225449f, 0.11898741f, -0.14108394f, 0.43274036f, 0.00818486f, 0.15254217f, 0.26065037f, 
    -0.06274442f, 0.14773704f, 0.02053797f, 0.19664556f, -0.37668869f, -0.15140225f, 0.07442755f, -0.13739274f, 
    0.09842478f, 0.17996944f, -0.06738491f, -0.02858660f, 0.05883994f, 0.16801921f, 0.18476216f, 0.11711942f, 
    -0.17301445f, 0.06159823f, 0.09616136f, 0.05122963f, -0.21042778f, 0.06789815f, 0.01893093f, 0.07069515f, 
    -0.08660633f, 0.07492061f, 0.37108278f, -0.07511891f, 0.04218122f, -0.49160755f, 0.07753305f, 0.02016927f, 
    -0.22001511f, -0.00286069f, -0.00247972f, 0.02461464f, -0.18809859f, -0.08952293f, 0.03951985f, 0.04301958f, 
    0.07056686f, -0.06859445f, -0.02295431f, -0.02949170f, -0.15244034f, 0.16751494f, 0.17247492f, -0.57525730f, 
    0.17830320f, -0.35122430f, 0.16740778f, -0.28126004f, -0.21442907f, -0.16121422f, -0.10713393f, 0.29441190f, 
    -0.03301587f, -0.03011759f, 0.02739916f, -0.02005778f, -0.02224481f, -0.00261051f, -0.07343447f, -0.08374617f, 
    0.00250623f, -0.04029392f, 0.00069767f, -0.08477197f, -0.08735736f, -0.08655929f, 0.04490523f, 0.00584390f, 
    0.02176791f, -0.04566540f, -0.08408209f, 0.05768227f, 0.03012784f, 0.00340624f, -0.02905295f, -0.04401536f, 
    0.07391389f, -0.07526410f, 0.03290728f, 0.04203691f, -0.07178646f, -0.04507785f, -0.08219762f, 0.08220398f, 
    -0.08181845f, 0.02871408f, -0.04818810f, -0.06391925f, -0.01798548f, -0.04182726f, -0.04214616f, -0.00304297f, 
    -0.01374941f, -0.00905552f, 0.00752088f, 0.07305317f, -0.04695528f, 0.00858266f, 0.00224786f, 0.06292258f, 
    -0.01698964f, -0.00094905f, 0.06922523f, -0.04532067f, -0.02124698f, -0.06488452f, 0.05170475f, 0.00045023f, 
    -0.06817933f, -0.05421840f, 0.06795671f, 0.04228718f, 0.01669901f, 0.04316549f, -0.00508133f, -0.06979950f, 
    -0.04616411f, 0.00889800f, -0.07783369f, 0.03029945f, -0.09048211f, -0.00443788f, 0.03410717f, -0.01208086f, 
    0.07119839f, 0.03739713f, -0.03247353f, 0.04041115f, -0.08628781f, 0.01772625f, 0.04027476f, 0.05349306f, 
    -0.01123890f, -0.05238676f, -0.01718408f, -0.07782601f, 0.03929546f, -0.02108199f, 0.07935280f, 0.01266700f, 
    -0.00190665f, 0.08009458f, 0.05432308f, -0.04752826f, 0.05970206f, -0.05130391f, 0.00881461f, -0.00587498f, 
    -0.08350421f, -0.02562404f, -0.00267677f, 0.03657896f, -0.08744478f, -0.06490305f, -0.04315669f, -0.05818862f, 
    0.07292413f, 0.06762643f, 0.05204450f, 0.02679362f, -0.05434654f, 0.06612984f, -0.02195132f, 0.03378954f, 
    0.08053405f, 0.08482748f, -0.02594767f, -0.09036312f, -0.07338023f, -0.08634980f, 0.07054036f, -0.05513331f, 
    -0.03574381f, -0.01414812f, 0.07978582f, -0.00114431f, 0.03135713f, 0.06542207f, -0.06571440f, -0.06669889f, 
    0.05283444f, -0.00999671f, 0.12188932f, 0.01777961f, -0.09426754f, 0.00986472f, 0.04915464f, 0.04897593f, 
    0.16833520f, -0.06577912f, -0.05889572f, -0.03008020f, 0.01977249f, 0.14781895f, -0.05177673f, -0.11256415f, 
    0.00982290f, 0.01295223f, 0.10557416f, -0.08967208f, -0.03442042f, 0.12284474f, -0.08352344f, -0.00279035f, 
    0.19978039f, 0.03246581f, -0.12387631f, -0.05591829f, -0.10223431f, 0.02458401f, 0.01176779f, -0.09699383f, 
    0.03753423f, -0.07538518f, -0.00223782f, 0.06186587f, -0.00170366f, -0.01704871f, 0.06266154f, -0.19025032f, 
    0.01690868f, -0.03192057f, -0.10055410f, 0.03527095f, 0.01066430f, 0.16187073f, -0.16881552f, 0.05257796f, 
    -0.10295167f, -0.05803294f, -0.04523120f, -0.05467103f, 0.00650706f, -0.06495533f, -0.02555935f, 0.00738815f, 
    0.04708659f, 0.04913867f, -0.03483117f, -0.03428199f, -0.11165395f, -0.13316478f, 0.13119557f, -0.06763843f, 
    0.05121532f, -0.09032398f, -0.10338038f, 0.09999036f, -0.05950917f, -0.01820474f, -0.01453584f, -0.15486434f, 
    0.03413927f, 0.01055008f, 0.02070767f, 0.05921149f, -0.13596840f, -0.08577493f, 0.00330298f, -0.11235018f, 
    0.06160775f, 0.04346271f, 0.15263410f, 0.06044133f, 0.01589410f, -0.09289456f, -0.10156585f, 0.12141356f, 
    -0.18866916f, 0.00183659f, -0.00704498f, -0.11006372f, -0.12988663f, -0.03827008f, -0.00277764f, 0.03503453f, 
    0.11499853f, -0.00637173f, -0.08184766f, -0.00665139f, -0.07178506f, -0.09175144f, -0.00251109f, 0.01659404f, 
    -0.07530156f, 0.05509891f, -0.07984810f, 0.07905363f, -0.23336847f, -0.05993621f, -0.04314346f, 0.01185998f, 
    -0.06089392f, -0.05952753f, 0.02933548f, -0.07905889f, 0.01296834f, -0.14845777f, -0.01842098f, 0.03049864f, 
    -0.11077625f, -0.10344171f, -0.08003735f, 0.10115518f, -0.07109759f, 0.00508361f, -0.00580319f, -0.13123201f, 
    -0.00166107f, -0.10586777f, -0.03029726f, 0.01833737f, -0.09103544f, 0.03989796f, -0.11021648f, -0.05577789f, 
    -0.12015624f, -0.10114672f, -0.04049903f, -0.06654736f, 0.02296459f, -0.10352995f, -0.00672294f, -0.01570375f, 
    -0.05485837f, -0.09754027f, -0.06293155f, -0.00352458f, -0.00887944f, -0.01532766f, 0.05224608f, -0.01157434f, 
    -0.01778124f, -0.03718327f, -0.06154718f, -0.11441817f, -0.06543286f, -0.03006689f, -0.00731117f, -0.08360291f, 
    -0.09916247f, 0.04236507f, 0.03460027f, -0.00812909f, 0.05343156f, -0.00148298f, 0.05166652f, 0.01337597f, 
    -0.06452686f, 0.02980109f, 0.05081483f, -0.12235434f, 0.04636949f, 0.02543009f, -0.11232268f, 0.03539585f, 
    0.02737381f, -0.05597572f, -0.06062888f, -0.03345264f, 0.04025997f, -0.08326756f, 0.02963255f, 0.00851446f, 
    0.00159852f, 0.01879074f, -0.00148189f, 0.00939023f, -0.03232724f, 0.03105886f, -0.10261238f, -0.02542182f, 
    -0.04622028f, -0.04062955f, 0.02208418f, 0.02052017f, -0.11172797f, -0.04625081f, -0.04000949f, -0.10051034f, 
    -0.09690710f, -0.04619480f, 0.00242255f, -0.04259453f, -0.11031215f, 0.00411903f, 0.00341101f, 0.04227919f, 
    -0.05700957f, -0.07642659f, 0.00783969f, -0.05376279f, 0.00912341f, -0.09098706f, -0.06678808f, -0.02511383f, 
    0.01615120f, 0.02975889f, -0.05046263f, -0.06995220f, -0.01061401f, 0.06162059f, -0.05997899f, 0.05899873f, 
    -0.07295119f, -0.01114191f, 0.04939912f, -0.02652857f, 0.05790258f, 0.02448616f, 0.09243545f, -0.03885447f, 
    0.01147791f, -0.00194504f, -0.01597400f, 0.05465394f, -0.09360197f, 0.02061762f, 0.03431918f, 0.01761003f, 
    -0.00374959f, -0.02520650f, -0.02554678f, -0.01249043f, -0.06325454f, -0.04286661f, -0.06677557f, 0.02146640f, 
    -0.00390775f, -0.02125130f, -0.08903348f, -0.00517162f, -0.03640670f, -0.04947260f, -0.07646023f, 0.05829920f, 
    -0.15959020f, -0.04664301f, -0.05143371f, 0.08280072f, -0.08134879f, 0.15495172f, 0.03157518f, -0.00713177f, 
    0.00505684f, -0.11775704f, -0.01801749f, -0.15239193f, 0.52657205f, 0.13466512f, -0.10968348f, -0.05273191f, 
    0.01564628f, -0.01003034f, 0.30828607f, -0.15678339f, 0.25024906f, 0.10257000f, 0.03012964f, -0.03896545f, 
    0.40531608f, 0.10936265f, -0.08128691f, 0.03407913f, -0.14043735f, 0.22657347f, 0.13366328f, 0.02876273f, 
    0.06463525f, -0.03435290f, 0.07242720f, 0.14079516f, -0.01072940f, -0.10960943f, 0.29212061f, -0.01425513f, 
    0.04167246f, -0.06612849f, 0.10643228f, 0.25982517f, -0.03473359f, 0.01442070f, 0.13153134f, 0.04825779f, 
    0.02397255f, -0.00027355f, 0.20047487f, 0.01165158f, -0.04388750f, -0.20748758f, 0.08343577f, 0.11202966f, 
    -0.13232252f, 0.50294518f, -0.12743521f, 0.00115131f, 0.34646851f, 0.18015300f, 0.13692689f, 0.05350380f, 
    -0.04864803f, 0.38164657f, -0.06447833f, 0.03765867f, -0.03343619f, 0.00026464f, -0.00351946f, -0.17183608f, 
    0.10595099f, 0.13825876f, 0.23796298f, -0.13551304f, 0.36789945f, -0.09425395f, -0.01574462f, -0.02121713f, 
    -0.04440470f, -0.17723158f, -0.13007548f, 0.00658383f, -0.08266328f, -0.05568668f, -0.01098022f, -0.03056497f, 
    0.00105012f, -0.10371022f, 0.09894250f, 0.19346669f, 0.07787777f, -0.02604896f, 0.00484686f, 0.02530934f, 
    0.18306358f, -0.01044525f, -0.04049730f, -0.09991765f, 0.09995534f, -0.01097291f, -0.05967717f, 0.09675596f, 
    0.21988931f, 0.07690424f, -0.05833794f, 0.15539460f, 0.04586269f, 0.21916322f, -0.06316917f, 0.10989063f, 
    0.02383849f, -0.05861671f, 0.21635097f, -0.08695584f, -0.01740145f, -0.05452330f, -0.14603330f, 0.06641655f, 
    0.00250813f, 0.04347993f, 0.25682855f, 0.21591844f, 0.22073838f, 0.03770652f, 0.07262965f, -0.00588268f, 
    -0.23552451f, -0.10283314f, -0.04701860f, -0.04401569f, -0.11984590f, 0.08118057f, -0.05191220f, -0.13268410f, 
    0.11024071f, -0.24230126f, -0.02492805f, 0.02029577f, 0.25311828f, 0.16937159f, -0.14071770f, 0.07526280f, 
    -0.08049070f, -0.21790174f, 0.29916695f, -0.22876202f, 0.29329208f, 0.22071351f, 0.00077709f, -0.07875326f, 
    0.47074753f, 0.15372187f, 0.22099981f, -0.06374920f, -0.15768754f, 0.26843327f, -0.00005686f, 0.01356317f, 
    0.04540909f, -0.19775243f, -0.00572620f, -0.04977024f, 0.12725508f, 0.21588235f, 0.02412997f, -0.11170557f, 
    0.15097514f, -0.10494607f, 0.16772911f, 0.17397776f, -0.02018390f, 0.12432607f, 0.14139545f, -0.00187392f, 
    -0.12585779f, 0.04405703f, 0.25370952f, 0.08649964f, 0.00010176f, -0.30951670f, -0.01385839f, 0.00032077f, 
    -0.16120130f, 0.24925798f, -0.18335406f, -0.21880384f, 0.16768321f, 0.49888960f, -0.00694392f, 0.01490873f, 
    0.01561365f, 0.32420322f, -0.32047281f, -0.03476707f, -0.34443700f, 0.08297820f, -0.30718088f, -0.04276519f, 
    0.05361077f, -0.01187070f, 0.24884844f, -0.01712531f, 0.13854079f, -0.02078691f, -0.17302851f, 0.07823750f, 
    -0.05389333f, -0.17310935f, -0.25041413f, 0.03258586f, -0.02570450f, -0.09151954f, -0.31528035f, 0.36397502f, 
    0.21790645f, -0.05695688f, -0.02864970f, 0.19233097f, 0.01842958f, 0.05261372f, -0.00121376f, -0.07894153f, 
    0.13166986f, -0.31805995f, -0.17349698f, 0.04146219f, -0.22295658f, 0.17651103f, -0.11836040f, 0.07706797f, 
    0.41541615f, -0.04791375f, 0.08106713f, 0.15420689f, -0.02268476f, 0.22118197f, 0.01543524f, 0.03775148f, 
    -0.15249488f, -0.04903108f, -0.01625759f, -0.04908738f, 0.14116265f, 0.09530168f, -0.00880235f, 0.31740910f, 
    -0.09368273f, 0.04660546f, 0.02857826f, 0.26670441f, 0.29411343f, -0.08530131f, -0.20452328f, -0.05958311f, 
    0.12167497f, -0.00598381f, 0.05604619f, -0.03398545f, -0.00706403f, -0.27962232f, -0.03891821f, -0.24702957f, 
    0.04299487f, -0.03453969f, 0.00532661f, 0.07951952f, -0.06191482f, 0.01804198f, -0.07176410f, 0.03122092f, 
    0.01563585f, 0.13483973f, -0.11379620f, -0.11203229f, -0.08970211f, 0.07395191f, 0.01858525f, -0.16479415f, 
    -0.45083430f, 0.18364999f, 0.07236495f, 0.04321308f, 0.09231588f, 0.13266951f, 0.06223618f, -0.05419808f, 
    -0.20332326f, -0.11365256f, -0.08321950f, -0.06994866f, 0.07150494f, -0.00245247f, 0.10369422f, 0.17632407f, 
    -0.08313141f, 0.19765240f, 0.00958292f, 0.10993791f, 0.07216586f, -0.32926586f, 0.04791763f, -0.18877411f, 
    -0.32390675f, 0.09475836f, 0.13468130f, 0.04188497f, 0.01373148f, -0.06085468f, 0.08164700f, -0.09386496f, 
    -0.20062597f, 0.16505289f, 0.12615304f, -0.25580344f, 0.13868038f, 0.02309312f, 0.02719890f, 0.14671482f, 
    -0.05188665f, -0.05113154f, -0.14416252f, 0.02715842f, 0.13524087f, -0.08078633f, -0.35540694f, 0.44939557f, 
    0.14495194f, -0.11309505f, 0.05867044f, -0.09493945f, -0.04651700f, 0.38595584f, 0.08951365f, 0.26196441f, 
    -0.04622080f, -0.03429672f, 0.15479875f, 0.01922081f, -0.05241195f, 0.28968844f, 0.01133672f, -0.18294258f, 
    -0.23299709f, -0.05096164f, -0.31219420f, -0.06445628f, 0.09307794f, -0.18851043f, -0.03616039f, -0.02733985f, 
    0.06613986f, -0.38230246f, -0.19349650f, 0.00026817f, 0.05970576f, 0.52514583f, -0.18108375f, 0.20755160f, 
    0.18317430f, -0.00878963f, 0.07248905f, -0.10653002f, 0.06807246f, -0.01405014f, 0.07622413f, 0.30862972f, 
    -0.10771075f, -0.00133361f, 0.11317745f, 0.01526453f, 0.34547430f, -0.11215945f, -0.03933351f, 0.11072702f, 
    -0.03247312f, 0.04157453f, -0.35930347f, 0.49628559f, 0.18937875f, 0.05307361f, -0.34692290f, -0.11117773f, 
    -0.06899041f, 0.06568170f, -0.10924280f, -0.04493416f, 0.01561866f, -0.02613067f, -0.07001143f, 0.05531736f, 
    -0.07400000f, 0.04952100f, -0.03200844f, -0.07545535f, 0.05978264f, 0.06122405f, 0.00662266f, -0.05918351f, 
    0.06684652f, 0.01659985f, 0.04025607f, -0.03888933f, -0.08778819f, 0.02268197f, -0.03545334f, 0.00061935f, 
    0.02960130f, -0.10822898f, 0.02846848f, 0.02361116f, -0.02171942f, -0.05998476f, -0.05593780f, 0.02780750f, 
    0.00947709f, 0.04055901f, -0.03378360f, -0.05435462f, -0.08469455f, 0.03465666f, -0.04996921f, -0.04887594f, 
    0.05991685f, -0.04518125f, 0.01509855f, 0.02116003f, -0.04027947f, 0.00405447f, -0.02593044f, -0.05075154f, 
    0.03403847f, 0.04750575f, -0.05863925f, 0.02774998f, -0.12419298f, 0.01488392f, 0.01999621f, -0.11011661f, 
    0.02580288f, 0.03499687f, 0.03068725f, 0.02757311f, 0.02603625f, 0.05770845f, -0.08918991f, -0.05255968f, 
    -0.06014973f, -0.09992743f, 0.01891324f, 0.03613205f, -0.05956873f, -0.03225816f, -0.11093250f, 0.07552578f, 
    0.01284931f, -0.09694359f, -0.07345811f, -0.00742262f, -0.02489840f, 0.02197442f, -0.02557627f, 0.01254368f, 
    -0.10327751f, -0.08241968f, 0.05341732f, 0.02312927f, 0.07534637f, -0.11024374f, 0.00100649f, -0.02235779f, 
    -0.03950119f, -0.09531410f, 0.00289684f, -0.08208436f, -0.03803316f, 0.01563025f, 0.00628234f, -0.02700599f, 
    -0.04481952f, -0.08507563f, -0.07595138f, 0.01433826f, 0.02659486f, -0.06624315f, 0.00975499f, 0.03412130f, 
    0.03653084f, -0.06848178f, -0.04408502f, 0.04348335f, 0.04113418f, -0.02586720f, -0.07551946f, -0.05463302f, 
    -0.01150925f, 0.08658895f, -0.07642399f, 0.08324875f, 0.04846602f, 0.04284341f, 0.03855656f, -0.03323795f, 
    0.04176340f, -0.06714046f, -0.03079249f, 0.01169050f, 0.01252066f, -0.10201038f, -0.01143562f, 0.05061517f, 
    -0.04510326f, 0.04989172f, 0.01358127f, 0.05216288f, 0.04237424f, -0.09523953f, -0.03602670f, -0.00804246f, 
    -0.09023308f, 0.04607464f, -0.00531588f, -0.04042723f, 0.05016817f, 0.01743328f, -0.03277567f, 0.05390412f, 
    -0.04387231f, -0.05770902f, 0.00975323f, -0.05790275f, 0.04122678f, 0.03048477f, 0.02147374f, -0.04276287f, 
    0.08508499f, 0.02224153f, 0.00666465f, 0.03019690f, -0.00262879f, 0.01820862f, -0.03982231f, -0.05653113f, 
    0.02160811f, -0.11735150f, -0.04230668f, -0.08122990f, 0.02186140f, 0.00153451f, 0.08431377f, 0.02473246f, 
    -0.01255919f, 0.05524682f, 0.03842759f, -0.07260475f, -0.01158028f, -0.08173802f, -0.00763204f, 0.00414410f, 
    0.06530781f, 0.06213614f, 0.02744150f, -0.10769653f, 0.06388131f, 0.06691686f, 0.01605030f, -0.05713196f, 
    0.03782815f, -0.04038014f, -0.01266840f, -0.02725252f, -0.01261592f, -0.05256812f, 0.00609609f, -0.09894942f, 
    -0.04656952f, 0.04626693f, 0.02590654f, -0.10932429f, -0.00684919f, -0.01395442f, 0.05096749f, -0.00081864f, 
    -0.05893395f, -0.08091555f, -0.09652518f, -0.07227163f, -0.07397837f, 0.01825080f, -0.03925834f, -0.05888213f, 
    -0.07621521f, 0.01738254f, 0.00377496f, 0.07365569f, -0.00860818f, 0.04328764f, 0.04510948f, 0.09261762f, 
    -0.00126944f, -0.00369046f, 0.01632140f, -0.03257313f, -0.03703397f, -0.05167178f, -0.02525123f, -0.02955294f, 
    0.04803180f, 0.02956246f, 0.00453632f, -0.01606051f, -0.08921553f, -0.00842201f, 0.03577410f, 0.05722340f, 
    0.04018575f, -0.01895895f, 0.08267052f, -0.00902645f, -0.04107746f, -0.00890536f, -0.04043908f, -0.07822789f, 
    0.02656216f, -0.01381656f, -0.02626413f, -0.06189583f, 0.04547055f, -0.05879534f, -0.04065654f, 0.03415489f, 
    -0.09626061f, -0.07636175f, 0.04483839f, -0.07195296f, 0.02826340f, -0.10042472f, 0.03694358f, 0.03775978f, 
    -0.16081287f, 0.08091881f, 0.07230905f, -0.05435909f, -0.01328264f, 0.03615225f, -0.04714417f, 0.06395467f, 
    0.02256838f, -0.48590526f, -0.04373381f, 0.11868595f, 0.04650256f, -0.28235573f, -0.03405698f, 0.08275426f, 
    -0.15798956f, -0.21083398f, 0.05502605f, 0.09057612f, 0.16460939f, 0.15845761f, 0.06317616f, -0.42240867f, 
    -0.01915300f, 0.10538984f, 0.02601239f, -0.08983633f, 0.12317079f, 0.27774984f, -0.02240965f, 0.04030123f, 
    0.25004578f, -0.00384355f, -0.01857453f, -0.09768481f, 0.01387153f, 0.17537555f, -0.12138837f, -0.18560645f, 
    -0.00376783f, 0.02614169f, 0.04691336f, 0.18927579f, 0.13337374f, -0.11947347f, -0.08372463f, -0.02947251f, 
    -0.45549953f, 0.01810948f, -0.04531380f, -0.01476368f, 0.18202017f, 0.06399906f, -0.07360747f, 0.06674911f, 
    0.00259846f, -0.69488555f, -0.08760931f, 0.13417816f, 0.12760834f, 0.22256178f, -0.05258738f, 0.12795492f, 
    -0.04590188f, 0.36714458f, 0.07667521f, 0.05064704f, 0.06290730f, 0.15289493f, 0.11960869f, -0.33269429f, 
    0.05210807f, -0.28894931f, 0.02058237f, -0.31731254f, 0.14267293f, 0.12737390f, 0.07484180f, 0.17026041f, 
    0.01010778f, -0.11012571f, 0.19855967f, -0.06729072f, -0.03604496f, 0.05495097f, -0.36538321f, -0.10228775f, 
    0.03488519f, 0.06737101f, -0.60842562f, 0.26864061f, 0.24419953f, 0.11007044f, 0.05086303f, 0.07176907f, 
    0.21733581f, 0.17547049f, -0.23417263f, -0.03405784f, -0.08013298f, 0.09188820f, 0.14689609f, -0.06941386f, 
    0.08629701f, -0.10855796f, -0.06204331f, 0.16002847f, 0.26315802f, 0.29937735f, 0.03655438f, -0.76717323f, 
    0.00283874f, -0.01225046f, -0.17209055f, 0.06220402f, -0.04019660f, 0.20379530f, -0.21985377f, 0.17865303f, 
    -0.27434608f, -0.20727663f, -0.20202154f, 0.05656865f, -0.19460519f, 0.11485640f, -0.00559102f, -0.27639630f, 
    0.14580114f, 0.06499498f, 0.01585621f, 0.01235870f, 0.09029879f, -0.41834819f, -0.08856330f, 0.14533703f, 
    -0.01604836f, 0.24927768f, -0.05451422f, 0.26543823f, -0.02418916f, -0.25489020f, 0.42686713f, 0.18198384f, 
    -0.12955044f, 0.10410884f, -0.14020398f, -0.10848615f, -0.06829791f, -0.13487428f, -0.00938937f, 0.00401940f, 
    -0.20153910f, -0.03526123f, 0.16874811f, -0.05752897f, 0.08247347f, 0.42303601f, -0.01111787f, 0.08645655f, 
    0.01047617f, 0.06757461f, -0.05468095f, -0.11969448f, 0.18342733f, 0.11238026f, -0.08751486f, -0.23196360f, 
    -0.09436598f, 0.10737166f, 0.12761691f, -0.04475366f, 0.32622027f, -0.35509586f, 0.13136010f, -0.26398337f, 
    -0.13951737f, -0.03818505f, -0.00849010f, 0.10304032f, 0.13183516f, 0.08333182f, -0.04863170f, -0.00229110f, 
    -0.04062164f, 0.23294728f, -0.00169624f, -0.20843074f, -0.02443978f, 0.17348334f, -0.22887413f, -0.05248444f, 
    -0.02751028f, 0.07776193f, 0.16940464f, 0.16016930f, -0.04665444f, 0.15368462f, -0.23059103f, -0.00662079f, 
    0.05708228f, -0.08473253f, -0.16574375f, -0.01383871f, 0.19983792f, 0.21414180f, -0.08416402f, 0.12012659f, 
    -0.14445555f, -0.02351313f, 0.02086920f, -0.05503695f, -0.02438780f, -0.00246155f, -0.09529809f, -0.19754912f, 
    0.05229364f, 0.17626742f, -0.31047949f, 0.03855728f, 0.26997983f, -0.04352543f, 0.05058745f, -0.05218779f, 
    -0.06064007f, 0.05737177f, -0.07131736f, -0.04204120f, 0.20641483f, -0.20957458f, 0.05274609f, -0.27670002f, 
    -0.28519344f, -0.03191793f, 0.04440793f, -0.02097148f, 0.27714220f, 0.10449023f, -0.05173619f, 0.11658025f, 
    -0.36664721f, 0.00849503f, -0.15613262f, 0.02642831f, 0.21742760f, -0.16647466f, -0.05317150f, 0.66093105f, 
    -0.01650548f, 0.22589488f, -0.26666731f, 0.17991577f, -0.11240386f, 0.16684012f, -0.33755800f, -0.17727843f, 
    -0.05617428f, 0.04829675f, -0.09943852f, 0.04949292f, 0.02218876f, -0.06417583f, 0.02928077f, -0.07600226f, 
    -0.11939681f, -0.05735167f, 0.06455784f, 0.00915575f, -0.06154259f, -0.10344462f, -0.10725459f, -0.00721723f, 
    -0.09144656f, -0.05296623f, -0.04443460f, -0.00723552f, 0.00560339f, -0.10585498f, 0.07485992f, -0.08549982f, 
    -0.04736242f, 0.00949896f, -0.02575045f, -0.00304487f, 0.03683443f, -0.02505479f, -0.06071899f, -0.08924668f, 
    0.03084866f, -0.02952399f, -0.04598247f, 0.01772908f, 0.00246532f, -0.08474450f, 0.01303298f, 0.06254049f, 
    -0.01113973f, 0.05549837f, -0.03220072f, 0.02884399f, 0.01136937f, 0.00200885f, -0.03445255f, 0.00203353f, 
    -0.05464659f, -0.04960807f, 0.00521808f, -0.09922887f, 0.03158301f, -0.03359132f, 0.01320462f, -0.00813394f, 
    -0.01177748f, 0.03244614f, -0.03169278f, 0.03429111f, 0.02125403f, -0.01599221f, 0.10792648f, -0.07732043f, 
    -0.00788012f, -0.03918646f, 0.02567399f, -0.04830487f, 0.00511608f, -0.01760235f, -0.00006913f, 0.03760356f, 
    -0.02109789f, 0.03045187f, 0.01453260f, 0.02225750f, -0.10460668f, 0.02540843f, 0.00859442f, -0.05285851f, 
    -0.09698962f, -0.01692307f, -0.08232786f, 0.00240382f, 0.02517861f, -0.04148376f, -0.09905304f, 0.04791580f, 
    0.06837039f, -0.13022064f, -0.05399465f, -0.02831014f, -0.10066347f, -0.10361964f, 0.05714022f, -0.03115684f, 
    -0.00100765f, -0.05492716f, 0.02799859f, 0.02947324f, -0.07437977f, 0.03545227f, -0.04410570f, -0.01617282f, 
    -0.07922732f, 0.07263845f, -0.04383714f, -0.06467181f, -0.11203089f, 0.02475437f, 0.01066160f, 0.06900304f, 
    0.06513944f, 0.05473856f, 0.01052031f, -0.00512293f, -0.11533421f, -0.02172049f, -0.05380816f, 0.06018372f, 
    -0.04086741f, -0.00005347f, -0.03368975f, 0.06563193f, -0.02536729f, -0.04237751f, 0.01478717f, 0.02470540f, 
    -0.13110374f, -0.00527145f, -0.04804901f, 0.04288228f, 0.04342506f, 0.00834821f, 0.08496654f, 0.21615316f, 
    0.02501980f, 0.20161068f, 0.04195317f, -0.07423647f, 0.26737273f, -0.03132796f, 0.07981750f, -0.02590594f, 
    0.07076194f, 0.02620719f, 0.03878461f, -0.04026045f, 0.19228980f, 0.07557761f, -0.02859374f, 0.05003342f, 
    0.31063744f, 0.07765591f, 0.01849008f, 0.07545826f, -0.10787427f, 0.09425380f, -0.08523767f, 0.09276792f, 
    0.18449102f, 0.03629130f, -0.06260134f, 0.04192994f, 0.13114792f, 0.12064310f, 0.05366954f, -0.22536567f, 
    -0.14172746f, 0.03584388f, 0.07854633f, 0.00959131f, 0.22354864f, 0.02771381f, 0.12463319f, -0.01234547f, 
    -0.16625285f, -0.03776785f, -0.01693263f, 0.11151072f, 0.24723925f, -0.07325907f, -0.00580723f, 0.02360605f, 
    -0.16795970f, 0.35052457f, -0.01826390f, -0.10621957f, 0.13589720f, -0.20194066f, -0.05319658f, 0.09200031f, 
    -0.06189394f, -0.01520321f, -0.01408197f, 0.19185814f, -0.22867635f, -0.05128269f, 0.02954609f, -0.30897844f, 
    0.00855946f, 0.01777961f, -0.02583181f, -0.01320186f, 0.32874015f, -0.11986887f, -0.19645038f, 0.05299403f, 
    -0.02212598f, -0.26805592f, 0.01507439f, 0.01514234f, 0.06217163f, -0.40689602f, 0.02880030f, -0.06299791f, 
    -0.15849859f, 0.03058041f, -0.14570595f, -0.01603058f, 0.20771790f, -0.02740937f, -0.07766843f, 0.08187958f, 
    0.03169996f, -0.07289653f, -0.05074732f, 0.01994740f, 0.11519668f, 0.50168550f, 0.06627364f, -0.03102659f, 
    -0.29586014f, -0.05916324f, 0.11270024f, 0.14572205f, 0.04621908f, 0.13065736f, -0.00729021f, 0.01646264f, 
    -0.05339241f, -0.03497789f, -0.15898520f, 0.05760308f, -0.04026564f, 0.05726333f, -0.04267200f, 0.25533569f, 
    -0.08610699f, 0.27126765f, -0.03838880f, -0.13871716f, 0.01046252f, 0.15457030f, 0.10656360f, -0.09233762f, 
    0.04184113f, 0.17467357f, -0.09504184f, 0.00003404f, 0.07213394f, -0.16590877f, 0.09598403f, 0.39956781f, 
    -0.01492567f, 0.10345452f, 0.02284360f, -0.19077496f, 0.06820713f, 0.13843949f, 0.45278862f, 0.04769152f, 
    -0.02838647f, 0.09435125f, -0.03409188f, 0.00277283f, -0.13614051f, -0.01098930f, 0.00477297f, 0.17989042f, 
    -0.18891326f, 0.05330969f, -0.29065150f, -0.00061046f, 0.04694194f, 0.00590524f, 0.04513165f, 0.05803721f, 
    0.23695208f, 0.11323825f, -0.01732606f, 0.09614242f, -0.01515815f, 0.10681447f, -0.09985378f, -0.01906111f, 
    -0.04829730f, 0.06397826f, 0.15821920f, 0.01219850f, 0.26606110f, -0.05071938f, 0.19145384f, -0.13272129f, 
    -0.09389199f, -0.09505888f, 0.19227250f, 0.18833742f, 0.14760780f, -0.08914785f, -0.03212738f, 0.13983016f, 
    0.05133543f, 0.24251112f, -0.11559020f, -0.05429522f, 0.03107757f, -0.48552832f, 0.04866935f, 0.10914225f, 
    -0.02559300f, 0.02736614f, 0.15928425f, 0.21600547f, 0.00524402f, 0.06079083f, 0.09173445f, -0.19564238f, 
    0.18183805f, 0.04690798f, -0.03277108f, -0.03574523f, -0.03683405f, -0.22213444f, -0.05998292f, -0.04255420f, 
    -0.09172626f, -0.00643294f, 0.11559797f, -0.09761656f, 0.02388190f, -0.30485427f, 0.07692850f, -0.09770247f, 
    0.00302572f, 0.13777341f, -0.14332199f, -0.11078801f, 0.22062936f, -0.01521032f, -0.01344223f, -0.06932006f, 
    0.08067638f, 0.13754487f, 0.17646171f, -0.07517602f, 0.29411870f, 0.08515600f, 0.02440033f, -0.13402407f, 
    -0.36893600f, -0.01271349f, -0.02532012f, 0.15203610f, 0.00837436f, -0.12469677f, -0.01617046f, 0.05413746f, 
    -0.02515917f, 0.02934762f, -0.23077928f, -0.08682144f, 0.13385688f, -0.27110013f, -0.12785532f, 0.03946158f, 
    0.04437109f, -0.00421487f, -0.06179031f, -0.12141666f, -0.16463174f, 0.07085623f, -0.06955203f, 0.21290918f, 
    0.08120292f, 0.07647151f, 0.14529884f, -0.04314883f, -0.22168812f, -0.43458048f, 0.16021581f, -0.17141657f, 
    0.20236824f, 0.11129201f, -0.02495599f, 0.03948468f, -0.10298011f, 0.15087888f, 0.07957773f, 0.02034181f, 
    -0.00590554f, 0.01052746f, -0.20381165f, -0.11571762f, -0.08102213f, 0.07325536f, 0.08550786f, -0.07895749f, 
    -0.10878859f, 0.12712896f, -0.17060059f, -0.30089790f, 0.00539023f, -0.04543869f, 0.10081290f, -0.11682697f, 
    -0.07345037f, -0.07287068f, -0.04201991f, 0.12345857f, -0.01908300f, 0.05233416f, 0.15815373f, -0.10823326f, 
    -0.05032890f, 0.02052755f, 0.07276136f, 0.14081149f, 0.10368150f, -0.08430748f, -0.14786181f, -0.10356750f, 
    -0.25675827f, -0.01042669f, -0.09950422f, 0.04528672f, -0.00036218f, 0.17329177f, -0.03508303f, -0.16788997f, 
    -0.28687355f, -0.04289581f, 0.02440863f, -0.03702991f, 0.00965813f, -0.23465078f, 0.10997883f, 0.18523467f, 
    0.04386771f, -0.27896151f, -0.00294097f, 0.02376024f, -0.20927350f, 0.01568377f, -0.13505824f, -0.00376859f, 
    0.22913295f, 0.08476567f, -0.00817615f, -0.07606855f, -0.09847037f, -0.07280003f, 0.21591999f, 0.22212951f, 
    0.17035043f, -0.08858696f, 0.21029532f, -0.10191374f, 0.00024581f, 0.16847788f, 0.17361572f, -0.06034898f, 
    0.19749147f, -0.01640776f, -0.16943322f, -0.10497388f, 0.01476729f, -0.12670378f, 0.02449575f, 0.02177327f, 
    0.16232219f, 0.06567268f, -0.15045513f, -0.05904996f, 0.05820519f, 0.15940522f, -0.11015046f, -0.01636775f, 
    -0.05931222f, 0.03933457f, -0.08061336f, 0.00231959f, 0.01018066f, -0.00245769f, -0.07513472f, -0.07563369f, 
    0.06836506f, -0.05852730f, 0.12707274f, -0.00393926f, 0.23299767f, -0.30215219f, -0.10751657f, 0.06539204f, 
    -0.19329691f, -0.00124497f, -0.40182036f, 0.38269892f, -0.09850019f, 0.00808853f, -0.10296521f, -0.18208556f, 
    0.16149604f, 0.13542348f, 0.12417118f, -0.03915949f, -0.03815904f, -0.23108084f, -0.07566041f, -0.00186041f, 
    0.05615376f, 0.05935930f, 0.05321562f, 0.27506381f, -0.29895428f, 0.03516699f, 0.08078488f, 0.16582640f, 
    0.00177182f, -0.12113835f, -0.18169846f, 0.01013729f, -0.01238127f, 0.12383694f, -0.03110148f, -0.20315976f, 
    -0.19584376f, 0.07045612f, 0.16708732f, -0.06237751f, 0.13500638f, 0.16423783f, 0.21140857f, 0.05604738f, 
    -0.03788005f, 0.05867602f, 0.06488775f, -0.01872659f, 0.14478813f, 0.04493628f, 0.13087349f, -0.16246660f, 
    -0.21442573f, 0.13593388f, -0.04321197f, 0.20763132f, 0.14101563f, -0.42221925f, -0.08219962f, -0.17507589f, 
    -0.23822975f, -0.04522628f, -0.11543747f, 0.12432871f, 0.08823071f, 0.24478225f, -0.05359010f, -0.18851995f, 
    -0.08644059f, -0.31095859f, -0.03313353f, -0.09700580f, 0.00608787f, 0.18399371f, -0.06547479f, 0.24169311f, 
    0.02083013f, -0.16871256f, -0.01686881f, 0.09322836f, -0.09858402f, 0.09114815f, -0.13280892f, 0.11457501f, 
    0.17145769f, -0.01409497f, 0.12574151f, 0.03083822f, -0.02257593f, 0.09614548f, 0.07556017f, 0.07259313f, 
    0.09937117f, -0.16164386f, 0.26303622f, -0.07799292f, 0.01893334f, 0.11520186f, -0.03188394f, -0.46307394f, 
    -0.08767910f, 0.15126990f, -0.50982302f, 0.07525670f, -0.01291588f, -0.01885633f, -0.03405656f, 0.08511823f, 
    0.08288113f, -0.09138657f, -0.18213548f, 0.07858583f, 0.00986167f, -0.23192614f, -0.05607433f, -0.15839286f, 
    0.14542748f, -0.02814115f, -0.06693491f, -0.15374409f, 0.05078166f, 0.10415684f, -0.05227724f, 0.00795128f, 
    -0.18484762f, 0.08930571f, -0.07664580f, 0.02482026f, 0.34828201f, -0.24117143f, -0.12647276f, 0.34334269f, 
    -0.18975972f, 0.04854656f, -0.55477077f, 0.46617183f, 0.07843164f, 0.06105966f, -0.40275136f, -0.23149681f, 
    -0.09653696f, -0.00378305f, 0.14261717f, -0.02131122f, -0.05770852f, 0.38911921f, -0.04906722f, -0.07322536f, 
    -0.09675326f, 0.05949861f, 0.07312872f, 0.12352403f, 0.08279694f, 0.12094644f, -0.55431229f, -0.08719993f, 
    -0.04067769f, 0.17065930f, -0.16116296f, 0.08639330f, 0.25441253f, 0.06085453f, -0.02920689f, 0.15164657f, 
    -0.18447889f, -0.02776510f, -0.05625014f, 0.09175318f, 0.16813120f, 0.04714315f, 0.22131635f, -0.09419073f, 
    -0.10745694f, 0.00684039f, 0.06072952f, 0.00287304f, -0.13176228f, -0.19822536f, 0.24102974f, 0.56242967f, 
    -0.08010758f, 0.05205434f, 0.12359547f, 0.11310264f, -0.04384703f, -0.33512858f, 0.00741619f, 0.21980733f, 
    -0.05074834f, 0.06426228f, -0.07089350f, 0.04152478f, 0.12717699f, -0.06620954f, 0.00105716f, 0.04652824f, 
    0.18659028f, 0.18551809f, 0.03616798f, 0.10737532f, 0.24012518f, -0.27833438f, 0.04594404f, 0.05671645f, 
    -0.04513045f, -0.05520264f, -0.10033073f, 0.09482146f, 0.44068882f, 0.07405508f, 0.25794899f, -0.04161263f, 
    -0.11492535f, 0.25879240f, 0.22093590f, -0.17707318f, 0.00132695f, 0.13345794f, -0.16810820f, 0.05370560f, 
    -0.14925520f, -0.01278045f, -0.11201343f, -0.07305151f, 0.01834108f, -0.06069269f, 0.03756545f, -0.20148833f, 
    -0.11653032f, -0.01657305f, 0.18678024f, 0.07104683f, 0.18405199f, 0.02164713f, 0.04440387f, -0.01858507f, 
    -0.04504240f, 0.10706511f, 0.29941130f, -0.01633340f, 0.02933544f, -0.46884546f, 0.04640716f, 0.32392728f, 
    -0.00949182f, -0.00991734f, 0.00048025f, -0.11606444f, 0.05316523f, 0.16151662f, -0.03344664f, 0.06618204f, 
    0.23430717f, -0.08279173f, 0.23374750f, -0.05849065f, -0.00144854f, 0.19309348f, -0.01295825f, -0.23357145f, 
    -0.09900406f, 0.02395777f, 0.14009354f, -0.10798312f, 0.12506355f, 0.04586772f, -0.23173513f, 0.29614055f, 
    -0.00888726f, -0.07620640f, -0.04547621f, -0.06078900f, -0.05353544f, -0.00457049f, -0.05812116f, -0.06096356f, 
    0.02334048f, 0.05725290f, 0.08458356f, 0.04672048f, -0.09622026f, -0.04477576f, -0.03564688f, 0.06011339f, 
    -0.00626289f, 0.01077653f, 0.03248314f, -0.08938561f, 0.02534159f, 0.05403428f, -0.00819122f, 0.04324993f, 
    -0.03814494f, -0.04794321f, -0.02184126f, -0.04218585f, -0.05966204f, -0.09574383f, 0.02716201f, -0.03617996f, 
    -0.01576710f, -0.06897099f, -0.03183040f, 0.05027821f, -0.00689087f, -0.02203225f, -0.01706799f, 0.02011560f, 
    0.03820080f, -0.06800976f, 0.02403395f, -0.05505589f, -0.09163496f, 0.01518352f, -0.04412225f, 0.01488692f, 
    0.04720891f, -0.04569755f, 0.04458769f, 0.02276678f, -0.07097974f, 0.03020192f, 0.06757346f, 0.03970632f, 
    0.02304867f, -0.11283472f, 0.03730850f, -0.02749944f, -0.03155312f, -0.05675929f, -0.10136268f, -0.06557623f, 
    0.07706758f, 0.03678591f, -0.07228858f, -0.07861926f, 0.04481331f, 0.03813296f, -0.03494317f, -0.00423227f, 
    -0.09041182f, 0.01544628f, -0.10452372f, -0.00408498f, -0.05342068f, -0.05093469f, -0.03752904f, -0.10316561f, 
    0.02261981f, -0.01471524f, -0.03149157f, 0.02682847f, 0.06758747f, -0.07800032f, -0.04030633f, 0.07053883f, 
    0.01336415f, -0.02703380f, 0.06101754f, 0.00847195f, 0.04629290f, 0.06812228f, 0.07720818f, -0.00154311f, 
    -0.06864769f, 0.00081725f, -0.02390863f, -0.03354617f, 0.00684200f, 0.04646606f, 0.02243976f, -0.07223474f, 
    0.04161991f, -0.05973205f, -0.08329926f, 0.06090831f, 0.01141786f, 0.01590293f, -0.02035043f, -0.04101049f, 
    -0.07900578f, -0.05264391f, -0.11151151f, -0.05018292f, -0.07783018f, -0.03651189f, 0.01578972f, -0.01516088f, 
    -0.04102317f, -0.08918282f, 0.05092359f, -0.06160095f, -0.06771625f, -0.06500922f, 0.03016700f, -0.06928946f, 
    -0.03963466f, -0.19178745f, 0.26596045f, -0.00273346f, 0.09679284f, 0.22241089f, -0.10029647f, 0.28431353f, 
    -0.16280901f, -0.09988766f, 0.08070704f, -0.05669066f, 0.07361211f, 0.06066870f, -0.34054404f, 0.13828456f, 
    0.37063468f, 0.11987960f, 0.12416256f, -0.13926671f, 0.16033269f, -0.07400585f, 0.00023581f, 0.34153932f, 
    0.50070494f, 0.12732407f, 0.12283300f, 0.31930181f, 0.17884390f, -0.04672671f, 0.13161631f, 0.17310265f, 
    -0.06188709f, 0.25464037f, 0.01209570f, 0.30977979f, 0.26699319f, -0.26970679f, -0.06366958f, 0.27412507f, 
    0.25718492f, -0.09908789f, 0.00735714f, -0.16712362f, -0.13913631f, -0.07193415f, 0.02598006f, 0.14094588f, 
    0.20584464f, -0.04770699f, 0.05367457f, -0.24035716f, -0.01511562f, -0.14891022f, -0.08247104f, -0.11595076f, 
    -0.11390906f, -0.29971960f, 0.19736493f, -0.05548587f, 0.02251500f, -0.20499079f, -0.07579520f, 0.06621738f, 
    -0.02422949f, 0.08726794f, -0.06234806f, 0.12944986f, 0.09159641f, -0.18614414f, 0.02723302f, 0.23957951f, 
    -0.28869227f, 0.17661737f, 0.06838894f, 0.52833241f, -0.06094919f, 0.00298341f, -0.08889812f, 0.07052533f, 
    0.06047899f, 0.09079681f, -0.18396099f, 0.01467631f, 0.01700472f, -0.16224489f, 0.22642626f, -0.15355887f, 
    -0.02047649f, 0.13239297f, 0.44939125f, 0.10573530f, -0.16652854f, -0.05181160f, 0.07166033f, -0.01441154f, 
    -0.12307652f, -0.15903732f, 0.19473571f, 0.06423853f, 0.20877557f, -0.25511199f, -0.12497245f, 0.10642093f, 
    0.31283385f, 0.02953810f, -0.07348599f, -0.06704758f, -0.08629691f, -0.14414003f, -0.04405979f, -0.10136239f, 
    -0.11104979f, 0.03097148f, 0.02690661f, 0.02915101f, -0.04229697f, 0.08796983f, 0.31593657f, -0.25900841f, 
    0.30085945f, -0.07350383f, 0.32910591f, -0.25259897f, 0.14886546f, 0.21043365f, 0.06202017f, 0.37342319f, 
    0.03854844f, -0.00497744f, -0.09291220f, -0.03993679f, -0.02066922f, 0.03889299f, 0.01428365f, 0.03251770f, 
    0.03428093f, -0.10476305f, -0.07193175f, -0.08543551f, -0.01439384f, -0.09150787f, -0.03195134f, -0.09870145f, 
    -0.06283116f, -0.11653580f, 0.04947169f, 0.04477438f, 0.02806684f, -0.11265802f, 0.02859212f, -0.00828589f, 
    -0.03336228f, 0.05277327f, -0.06582510f, -0.09750105f, 0.05086048f, -0.01709877f, 0.06100602f, -0.01865676f, 
    -0.05446893f, -0.02788614f, -0.08621745f, 0.02622158f, 0.00968923f, 0.02482053f, 0.02701971f, 0.04292047f, 
    0.02574495f, -0.09252924f, -0.02597878f, 0.03150676f, -0.08069827f, -0.00845814f, -0.03130767f, -0.04521173f, 
    0.04865614f, 0.00338927f, -0.05873869f, -0.06548463f, -0.00866351f, -0.06015646f, 0.05295143f, 0.05504935f, 
    -0.06130789f, 0.01350549f, -0.05908223f, -0.03867156f, -0.05693379f, 0.05156005f, -0.01948416f, -0.05793573f, 
    -0.08234347f, -0.04804982f, -0.06820867f, -0.06972786f, 0.04488117f, -0.08714101f, -0.09687648f, 0.04105878f, 
    -0.04808534f, 0.00412285f, -0.06135793f, 0.07803266f, -0.00347835f, 0.05120829f, 0.04697568f, -0.05085327f, 
    0.00561815f, -0.02554890f, -0.06210772f, 0.05849208f, -0.01903984f, -0.02248458f, -0.00869070f, 0.00093975f, 
    -0.02694531f, -0.06808707f, -0.01741454f, -0.02513705f, -0.03175715f, -0.03388244f, 0.00561570f, -0.04057055f, 
    -0.08763371f, -0.10595489f, 0.03844622f, 0.01068113f, 0.02728513f, -0.02878439f, 0.01303639f, 0.04717974f, 
    0.06605891f, -0.03993391f, -0.07583799f, 0.01045625f, -0.05490293f, 0.04899070f, -0.00096124f, -0.02820802f, 
    -0.11298741f, 0.03972171f, -0.02291624f, 0.07982140f, -0.03062373f, -0.00669248f, -0.07769933f, -0.07558594f, 
    -0.02073199f, -0.06136232f, -0.00640530f, 0.03400153f, -0.02867895f, -0.08839321f, -0.09010709f, -0.04064765f, 
    -0.02567006f, -0.00403013f, 0.16786501f, 0.04044482f, -0.29011357f, 0.20097648f, 0.08595175f, 0.16441026f, 
    -0.08812445f, -0.04162162f, 0.02654185f, 0.03590727f, 0.13267042f, 0.26198736f, -0.04620297f, -0.08617794f, 
    0.28670132f, -0.39034617f, 0.04567633f, 0.11082870f, 0.42136389f, -0.01685794f, -0.03568508f, 0.29818225f, 
    0.26586702f, -0.13110203f, -0.37448063f, -0.04419431f, 0.23780327f, -0.12769450f, 0.24805872f, 0.17307492f, 
    0.25753453f, 0.04274331f, -0.08198569f, 0.17801315f, 0.20163144f, 0.07825416f, 0.25434944f, -0.20349842f, 
    -0.12343991f, -0.14503907f, -0.04324267f, 0.14669986f, -0.06901032f, -0.01670117f, -0.08355474f, 0.25771761f, 
    0.25715971f, -0.02752177f, -0.20968825f, 0.00020341f, 0.17185940f, 0.10594467f, 0.01777895f, -0.18741433f, 
    -0.33780122f, -0.46916381f, -0.29443192f, -0.00288623f, 0.04397033f, -0.18645148f, -0.01264235f, 0.26448435f, 
    -0.03824781f, 0.06436178f, -0.16806731f, 0.03918309f, -0.10672732f, 0.07132208f, 0.11382739f, -0.22795048f, 
    0.10192667f, 0.11024657f, 0.20819353f, 0.22322828f, 0.08029854f, -0.37515661f, 0.00927018f, -0.02824176f, 
    0.09227580f, -0.02779226f, 0.14138846f, 0.07252152f, 0.05513483f, -0.07860895f, 0.15776081f, -0.12435480f, 
    0.35230690f, 0.12080646f, 0.23578337f, 0.08588755f, -0.16147609f, 0.14890763f, -0.01920488f, 0.03311200f, 
    0.07316254f, 0.03889925f, 0.11278643f, -0.10538108f, -0.13475803f, -0.31507751f, -0.03979551f, 0.00826710f, 
    0.28658757f, -0.07013291f, 0.04376304f, -0.06936707f, -0.17032906f, 0.14412017f, -0.04631648f, -0.27204496f, 
    0.03452063f, 0.01195974f, 0.09865724f, 0.03606156f, -0.03722786f, -0.02772110f, 0.01375490f, -0.30722204f, 
    -0.09883998f, -0.11028013f, 0.01005331f, 0.04901695f, 0.05793475f, 0.17585823f, -0.04393727f, 0.26758811f, 
    0.14916639f, 0.01738547f, 0.00285000f, -0.05452553f, 0.14889812f, -0.20158482f, -0.06509686f, 0.20785163f, 
    0.05023527f, 0.15356448f, 0.01050919f, 0.18724583f, -0.03142111f, -0.07374834f, 0.28271452f, 0.24035220f, 
    -0.02212824f, 0.19585831f, -0.06337681f, -0.04938687f, -0.07946453f, -0.12220585f, -0.05948184f, -0.02704335f, 
    -0.46087384f, -0.04751590f, 0.30747348f, 0.09025870f, -0.06965724f, 0.12527296f, -0.10649520f, -0.00387723f, 
    0.05254091f, 0.07166281f, -0.06720578f, 0.02785890f, 0.13838288f, 0.08997315f, -0.09251101f, -0.14429462f, 
    0.01141948f, 0.05128928f, 0.06432565f, -0.17848484f, 0.12900274f, 0.02437732f, 0.25978723f, -0.08349881f, 
    -0.15646037f, 0.09408901f, -0.07154158f, 0.12845384f, 0.11836655f, 0.07625366f, -0.07229412f, 0.05548231f, 
    -0.07468093f, -0.02550190f, 0.17775673f, -0.07953511f, 0.08441609f, 0.09604927f, -0.19475259f, -0.07354306f, 
    -0.07216693f, 0.06544362f, 0.18718776f, 0.05919338f, -0.19445226f, 0.06750172f, 0.02388167f, 0.21375564f, 
    0.02848369f, -0.15313178f, -0.18016200f, 0.09661598f, 0.11548291f, 0.20357545f, 0.04975943f, 0.07372329f, 
    0.00812632f, 0.10906702f, 0.05692733f, -0.00231264f, 0.08083647f, -0.04516867f, -0.01019853f, 0.02191100f, 
    -0.29088852f, 0.02399858f, -0.43011448f, -0.00710612f, 0.16902663f, -0.00078254f, 0.07004458f, 0.04399559f, 
    -0.11805791f, -0.01378627f, -0.15069011f, 0.06707897f, 0.11873899f, 0.87815815f, 0.02718329f, -0.20993559f, 
    -0.47328320f, 0.05576842f, -0.01414204f, -0.02358506f, 0.14572032f, 0.09906300f, 0.07790016f, 0.11983982f, 
    -0.12042823f, 0.00959229f, -0.32402855f, 0.06130664f, 0.05381053f, 0.03929178f, 0.08607216f, 0.36568984f, 
    0.36150157f, 0.03975852f, -0.05017393f, -0.13792443f, -0.11581200f, 0.00739117f, -0.06406856f, -0.06870997f, 
    0.03451930f, 0.03941684f, -0.04934609f, -0.02665957f, -0.10472380f, -0.03806921f, -0.03426680f, -0.01020717f, 
    -0.06549061f, 0.04205540f, 0.08620135f, -0.00907191f, -0.04819044f, 0.01355228f, -0.09910494f, -0.00929473f, 
    -0.04934247f, 0.04780069f, 0.02021529f, 0.02870884f, -0.02494253f, -0.09789690f, 0.00538357f, -0.10671949f, 
    0.02742689f, -0.05296545f, 0.03102339f, 0.04032863f, 0.01076187f, -0.08448175f, 0.04759558f, -0.03489141f, 
    -0.09733070f, 0.00695687f, 0.06736969f, 0.02572130f, -0.05396746f, -0.05552740f, -0.10604907f, -0.05307259f, 
    0.02826765f, 0.04170518f, -0.07968121f, -0.06910527f, 0.01563907f, -0.01205222f, -0.02902217f, -0.10804351f, 
    0.00785107f, 0.02554437f, -0.11915563f, -0.08430968f, 0.06852935f, 0.02046556f, -0.05506209f, 0.01790193f, 
    0.07134315f, -0.02800940f, -0.00333475f, -0.11356222f, -0.04555057f, 0.01301031f, 0.02579844f, -0.01735189f, 
    0.04236866f, -0.05176402f, -0.11976639f, 0.00477886f, -0.02202588f, -0.05103033f, -0.02385678f, -0.11344084f, 
    0.00419846f, 0.03988526f, -0.04480891f, -0.07238013f, -0.06171820f, -0.11306007f, 0.05308048f, -0.09506129f, 
    -0.05817451f, -0.09101362f, 0.00271034f, 0.02898012f, 0.06565815f, -0.02537753f, 0.02646866f, 0.03251329f, 
    0.03389878f, 0.00307504f, 0.03008307f, -0.02273238f, 0.02785535f, -0.01118333f, 0.08373246f, -0.03028679f, 
    0.00268180f, 0.03606746f, 0.02656725f, 0.00386712f, -0.10293911f, -0.08487450f, -0.10378280f, 0.03439028f, 
    0.02095814f, -0.04097513f, 0.07077941f, -0.08323941f, 0.04080525f, 0.03587241f, 0.08578865f, 0.01038568f, 
    -0.04023115f, -0.02650129f, -0.07943558f, 0.01455923f, -0.02578932f, -0.06270093f, 0.02291800f, -0.08088865f, 
    0.02557882f, 0.00940343f, -0.06621518f, -0.10914523f, -0.01971585f, -0.03041111f, 0.06471442f, -0.01701881f, 
    0.07333684f, -0.00994629f, -0.02230071f, -0.06022605f, 0.01386137f, 0.01990796f, 0.03467483f, -0.04741341f, 
    -0.04527424f, -0.02988507f, -0.00902242f, -0.01055115f, 0.05943689f, -0.02664261f, -0.04174197f, 0.01379719f, 
    -0.00852510f, -0.04714881f, 0.02807249f, 0.04192081f, -0.09078573f, -0.02554719f, 0.00925629f, 0.02925241f, 
    -0.08068968f, -0.09453452f, 0.04227654f, -0.08656031f, 0.07149149f, 0.03457703f, -0.10080463f, -0.04388061f, 
    -0.04752290f, -0.04811314f, -0.07838790f, -0.01226343f, 0.04944197f, -0.00791024f, -0.07902227f, 0.07381310f, 
    0.00097815f, -0.07124455f, 0.04687009f, 0.02465371f, -0.06865059f, 0.01413635f, 0.03930012f, 0.06374504f, 
    -0.08009756f, 0.02353914f, 0.01119923f, -0.01326941f, 0.03462071f, 0.02073652f, -0.06609017f, -0.00507005f, 
    -0.02197418f, 0.00267134f, 0.02731789f, 0.00169043f, -0.09232058f, 0.07127741f, -0.02028613f, -0.09762416f, 
    -0.00960367f, -0.06380949f, 0.00156612f, 0.02984246f, 0.07363328f, -0.06700286f, -0.03146226f, -0.04414355f, 
    -0.00871701f, 0.01642597f, -0.03593653f, 0.02594599f, 0.06716578f, -0.07900769f, -0.02760916f, 0.06177457f, 
    -0.04979067f, -0.05133108f, -0.06963040f, 0.05690134f, -0.01940691f, 0.02608388f, -0.02662331f, -0.05799979f, 
    0.02834659f, -0.01971216f, -0.04831800f, -0.02204414f, 0.01474965f, 0.04404731f, -0.07073919f, -0.06306723f, 
    -0.07743971f, 0.05269741f, -0.01991966f, 0.02463348f, -0.07215023f, 0.05625152f, -0.03323932f, 0.05309002f, 
    0.00487758f, 0.01860535f, 0.01343979f, -0.01611194f, -0.02699401f, -0.10205812f, 0.07209330f, 0.03441275f, 
    0.03273060f, 0.01255210f, -0.07666068f, 0.05577160f, -0.05296371f, -0.09647409f, -0.05270359f, -0.08236330f, 
    0.04735056f, -0.04387596f, -0.01802999f, -0.10057139f, 0.00627927f, -0.07911171f, -0.02929866f, 0.00103464f, 
    0.03631466f, 0.13335630f, 0.10816319f, 0.07670699f, 0.02196656f, 0.15363140f, 0.20989932f, -0.41851962f, 
    0.24154511f, -0.17698614f, 0.02076906f, 0.11892254f, -0.09801131f, 0.06519414f, -0.38108861f, -0.06358202f, 
    -0.04245960f, -0.17989124f, -0.03995450f, -0.07815577f, 0.30759203f, 0.04644705f, -0.01815960f, 0.07034480f, 
    0.52246034f, 0.33052310f, 0.00968362f, -0.06155339f, 0.19671428f, 0.06355780f, 0.21291415f, 0.09307346f, 
    -0.06841301f, 0.14827976f, 0.06769335f, 0.10636130f, -0.07141229f, 0.00918424f, 0.12051090f, 0.12303030f, 
    0.25168604f, 0.09926499f, -0.10858172f, 0.28088421f, -0.14271657f, -0.11898247f, -0.20686458f, 0.00594437f, 
    0.20149776f, 0.00497704f, 0.00265885f, 0.05960159f, -0.03465046f, -0.00346510f, -0.02375271f, 0.04941445f, 
    0.00263731f, -0.27309248f, -0.22180752f, 0.09619827f, 0.07748952f, 0.15371285f, 0.33596241f, 0.03131569f, 
    -0.05292637f, 0.09461378f, -0.24854036f, 0.06307878f, 0.24992529f, 0.01057713f, -0.00980753f, -0.11495640f, 
    0.14538087f, 0.18284993f, 0.27148464f, 0.00207772f, -0.08055022f, -0.02972073f, 0.06966212f, -0.11130191f, 
    0.06083125f, -0.14593139f, -0.02624475f, 0.07841729f, -0.06077533f, 0.26355004f, 0.08781340f, -0.43305027f, 
    0.16598848f, 0.01489933f, 0.39595398f, 0.13914658f, 0.01390310f, 0.03524909f, -0.07220519f, -0.08696479f, 
    0.01848078f, -0.15982266f, 0.11166384f, 0.02136259f, 0.06573334f, -0.80174816f, -0.05250945f, 0.28598240f, 
    0.56762850f, -0.04023162f, -0.07540994f, 0.03090487f, -0.23335612f, 0.08386674f, 0.03085885f, -0.17554551f, 
    0.18258919f, -0.03752922f, 0.43614709f, 0.03839223f, -0.06075653f, 0.07403649f, -0.07768053f, -0.10341424f, 
    -0.59569329f, 0.09086222f, -0.07223038f, 0.12224907f, 0.23707634f, 0.19041842f, -0.01418717f, 0.05815331f, 
    -0.04624686f, -0.19140060f, -0.03125174f, -0.06799536f, 0.08933792f, -0.13864481f, -0.00970180f, 0.05328388f, 
    0.18834093f, -0.17283078f, -0.07932335f, -0.18734562f, 0.27420402f, 0.02088751f, 0.05997226f, 0.17296483f, 
    0.12229695f, -0.06437963f, 0.20694464f, -0.14499716f, 0.06247539f, 0.11183660f, 0.03040803f, -0.04800270f, 
    0.05099546f, 0.13055184f, -0.33457637f, 0.12838553f, -0.01274396f, 0.34085470f, -0.18868929f, 0.05223063f, 
    0.02892384f, -0.22768687f, -0.06292712f, -0.09488951f, 0.09298790f, 0.06644098f, -0.25582784f, -0.10571066f, 
    -0.07124493f, -0.06085945f, 0.15418880f, -0.07516712f, -0.10625637f, 0.11043364f, 0.17890160f, -0.03932643f, 
    -0.37557429f, -0.06280904f, 0.27665076f, 0.01491271f, 0.08307954f, -0.36506414f, 0.00046938f, 0.19136202f, 
    0.02252779f, 0.27351248f, -0.02225327f, -0.08318140f, 0.29833007f, 0.25728738f, 0.12193443f, -0.08503418f, 
    -0.01750070f, 0.35696915f, -0.09678636f, 0.00502471f, -0.37354010f, -0.04979261f, -0.12780526f, 0.15963350f, 
    0.15832186f, -0.24537951f, 0.08143937f, 0.04253785f, 0.11181668f, 0.16662328f, -0.08331594f, 0.14021805f, 
    0.01205769f, -0.11646371f, -0.21191481f, -0.08562028f, 0.03679142f, -0.01684650f, -0.40576279f, 0.11062799f, 
    -0.04853756f, -0.24013224f, -0.58141601f, 0.06650084f, 0.27749977f, -0.03936838f, -0.00918280f, -0.01734172f, 
    0.03379665f, -0.31582090f, -0.29490352f, 0.12462386f, 0.08328658f, 0.41277951f, -0.17687128f, 0.08958117f, 
    0.14000964f, 0.01303439f, -0.03542900f, 0.12622006f, -0.01261573f, 0.13784355f, 0.00218526f, 0.06513593f, 
    -0.22128564f, 0.03580110f, -0.52559942f, -0.02018549f, -0.04993013f, 0.09175020f, -0.03342270f, 0.29221469f, 
    0.13348550f, 0.02571346f, 0.04190729f, 0.01456153f, 0.25518313f, 0.04665526f, -0.13366647f, -0.12345036f, 
    -0.09650858f, -0.03908491f, -0.04353137f, -0.07043041f, -0.07449903f, -0.05345869f, -0.10208613f, -0.05664780f, 
    -0.05488907f, 0.01228674f, 0.07098884f, -0.09935742f, 0.05440991f, -0.05604854f, -0.01873561f, -0.10165483f, 
    -0.00294745f, -0.09522624f, -0.08753058f, -0.07347648f, 0.03443737f, -0.03511831f, -0.08435926f, 0.01782195f, 
    -0.03519836f, -0.06346831f, 0.07060178f, -0.08407476f, -0.07818744f, -0.10659489f, 0.02197509f, 0.00750400f, 
    -0.03809035f, -0.05182863f, 0.05475782f, -0.05897718f, 0.02657531f, -0.06311825f, -0.00222533f, 0.00785526f, 
    -0.07016658f, 0.00777954f, 0.04448169f, -0.01070170f, -0.03330426f, 0.00088494f, 0.03482652f, 0.03934591f, 
    -0.09685882f, 0.00540304f, -0.08089882f, 0.02306639f, -0.05313846f, -0.11022782f, 0.00662036f, -0.08317282f, 
    -0.08530609f, 0.00537921f, -0.02953334f, 0.02364537f, 0.00957214f, -0.03449021f, -0.08686595f, -0.03527128f, 
    0.07193688f, -0.02684606f, 0.02566364f, -0.01796790f, -0.04916967f, -0.04028436f, 0.03166983f, -0.08655030f, 
    0.06356169f, -0.04829094f, -0.10307893f, -0.07381097f, -0.07970115f, -0.04563232f, 0.01630866f, -0.03344649f, 
    -0.07030912f, 0.03196961f, -0.07260658f, -0.08702085f, 0.00539654f, 0.02304710f, 0.04563330f, 0.00046630f, 
    0.01427909f, -0.06356768f, -0.02099081f, -0.10238506f, 0.08297361f, -0.11323377f, 0.01203911f, -0.05318569f, 
    0.02504862f, -0.06299961f, 0.05216224f, 0.04603809f, -0.02266185f, 0.03169420f, -0.06707991f, -0.07375862f, 
    0.02409454f, 0.06939694f, -0.08189568f, -0.07282879f, -0.05071862f, -0.11865951f, 0.04560424f, -0.11768565f, 
    -0.02693002f, -0.01598454f, -0.02988058f, -0.08077993f, -0.01351007f, 0.00770326f, 0.02364594f, 0.04872907f, 
    -0.10391891f, -0.09055653f, -0.05193917f, -0.01817704f, -0.01336668f, -0.02173398f, -0.04357867f, -0.07715933f, 
    0.02160939f, -0.01368766f, 0.05489643f, 0.07296167f, 0.20324656f, -0.05162818f, 0.00241216f, 0.13616082f, 
    0.12845428f, -0.14558385f, 0.04327635f, -0.24352533f, -0.13169718f, -0.04982820f, -0.06273465f, 0.01873268f, 
    0.13498934f, 0.16979806f, -0.01714127f, -0.06059609f, 0.13879611f, -0.00733858f, -0.07577696f, -0.20029195f, 
    -0.09610260f, 0.08179041f, 0.07593266f, 0.12303091f, 0.03955518f, 0.12882693f, 0.06058327f, -0.07237784f, 
    0.11627170f, 0.04857364f, -0.00244857f, 0.00089486f, 0.01828753f, -0.04237172f, -0.20792100f, 0.16696675f, 
    0.03345839f, 0.00907415f, 0.15243679f, -0.13730109f, -0.07343160f, -0.15509538f, 0.18971090f, -0.02437531f, 
    -0.30828699f, -0.00560054f, -0.07435119f, 0.07317231f, 0.36309081f, -0.07992595f, 0.07500528f, 0.12382402f, 
    0.02784491f, 0.08908937f, 0.09914239f, -0.10379075f, 0.37981531f, 0.05419093f, -0.01639959f, 0.12517351f, 
    -0.08538625f, -0.02519627f, 0.01932452f, 0.08882634f, 0.51915026f, 0.05984136f, 0.12632799f, 0.09867425f, 
    0.14840353f, -0.03496447f, 0.09886236f, -0.18243100f, 0.02749625f, 0.20416254f, -0.04839833f, 0.22280845f, 
    0.07799897f, -0.15398674f, 0.11702208f, 0.01862641f, -0.00527529f, -0.05518031f, -0.08336513f, -0.15155347f, 
    -0.06029414f, -0.03144198f, -0.45074126f, 0.11248128f, 0.31195176f, 0.01934539f, 0.04489512f, -0.02093466f, 
    0.01831300f, -0.17111163f, -0.05580465f, -0.12006006f, 0.12066472f, 0.31522077f, 0.07048808f, -0.00278360f, 
    0.03432692f, 0.09156376f, 0.01581418f, 0.02763374f, 0.00841235f, 0.11955029f, -0.06927886f, 0.02733075f, 
    -0.09091275f, 0.05873630f, -0.07718130f, -0.06488787f, -0.12888837f, 0.30056179f, -0.13414605f, -0.21211620f, 
    -0.00321091f, -0.00055837f, -0.14504562f, -0.08101401f, 0.00262803f, 0.15297914f, -0.05543765f, 0.04234815f, 
    -0.14574711f, 0.11854278f, 0.19024409f, -0.01398483f, -0.05636965f, -0.16551737f, -0.06758501f, -0.01712585f, 
    0.03222657f, -0.25748444f, -0.01970076f, 0.17135781f, 0.07104477f, 0.31340560f, 0.24808338f, 0.07739526f, 
    0.03277004f, -0.12875657f, 0.16050509f, -0.13425188f, 0.06519596f, 0.16319458f, -0.01701973f, -0.15016973f, 
    -0.03797461f, -0.10722823f, -0.13799384f, -0.07606295f, 0.10068133f, 0.19632068f, 0.24276555f, -0.00969372f, 
    0.14159685f, -0.06711056f, 0.06210725f, 0.07508973f, 0.30860811f, 0.03383211f, 0.02164516f, -0.27823642f, 
    -0.08124403f, -0.11586758f, 0.10160239f, 0.21804945f, 0.03079722f, -0.30866912f, -0.13812003f, -0.31850219f, 
    0.03593528f, -0.08236419f, 0.00066988f, 0.15165120f, 0.08869442f, 0.02587848f, -0.04904119f, -0.05487622f, 
    -0.04111958f, -0.43024617f, -0.25940865f, -0.23252706f, -0.00252069f, 0.16525275f, 0.06102785f, 0.28365692f, 
    0.07551496f, 0.16378471f, -0.12974666f, 0.05832770f, -0.28998902f, 0.02135183f, -0.61292809f, 0.14259499f, 
    0.20178071f, 0.15780468f, 0.05333524f, 0.24493614f, -0.21887663f, -0.38804546f, 0.13545729f, 0.05124578f, 
    -0.07627162f, -0.10897807f, 0.05061531f, 0.01513473f, 0.04955610f, 0.30344367f, 0.10309720f, -0.58217329f, 
    0.08070984f, 0.01837472f, 0.07404206f, 0.01154291f, 0.04110052f, -0.04178898f, -0.00702135f, -0.03683770f, 
    0.21254359f, -0.16994791f, -0.13055860f, 0.08136293f, 0.13283032f, -0.40931472f, -0.23486076f, -0.01235681f, 
    0.17469351f, -0.05449572f, -0.04583908f, -0.01688838f, 0.00587009f, 0.07324038f, -0.06771053f, -0.08504213f, 
    -0.11109262f, -0.01143628f, 0.07344058f, -0.06948135f, 0.36144438f, -0.13815862f, 0.02096580f, 0.36555359f, 
    0.05406431f, -0.13451150f, -0.39638650f, 0.63831657f, -0.24363787f, 0.11176819f, -0.34684718f, -0.12135789f, 
    0.01246849f, -0.11346903f, 0.33530405f, -0.03068650f, 0.21909827f, -0.13924748f, -0.04070436f, 0.27335861f, 
    -0.03626270f, 0.01984654f, 0.05955912f, -0.23224254f, -0.14678752f, 0.03811898f, 0.17534299f, 0.31460330f, 
    0.40353402f, 0.08151529f, 0.01228439f, 0.05133159f, -0.00710036f, -0.17897947f, -0.00876682f, 0.02730774f, 
    -0.05734095f, -0.05732527f, -0.23172282f, 0.15382414f, 0.15619370f, -0.05435282f, -0.11144963f, 0.01169867f, 
    0.16309844f, 0.07494397f, -0.06273824f, 0.19388120f, 0.31262580f, -0.04733516f, -0.09019733f, -0.16993096f, 
    0.08340218f, 0.10978878f, 0.17732824f, -0.19669147f, 0.04539070f, -0.07145222f, 0.14698437f, 0.03952102f, 
    -0.15415323f, -0.10087046f, -0.20065814f, 0.08029202f, 0.25495335f, -0.03907888f, -0.07931830f, -0.02779610f, 
    -0.06386773f, 0.04260892f, 0.10449577f, -0.28167599f, 0.18603086f, -0.31000230f, -0.08212792f, 0.14093305f, 
    -0.02772382f, -0.09702136f, 0.14856282f, 0.10814318f, 0.00246632f, -0.12187502f, -0.03251797f, 0.41735056f, 
    0.04585132f, 0.08259129f, -0.00991821f, 0.33284146f, 0.07653669f, 0.01778938f, -0.03869093f, 0.33786267f, 
    0.14387684f, 0.04382030f, 0.30065301f, -0.03015644f, -0.04354291f, 0.09922311f, 0.11552338f, 0.10245976f, 
    -0.28447923f, 0.14831917f, -0.29468429f, 0.01522341f, 0.29301992f, -0.10144626f, 0.07059572f, 0.06011632f, 
    0.02545525f, -0.25394452f, -0.18493429f, -0.02725676f, 0.18485908f, 0.66050005f, -0.15313324f, -0.03154444f, 
    -0.03011052f, 0.06975199f, 0.01679572f, -0.11048783f, 0.09083847f, -0.12720191f, -0.05791269f, -0.02713509f, 
    -0.22497377f, 0.08568298f, -0.03430967f, -0.05372050f, 0.06278291f, -0.02964695f, 0.19169405f, -0.03839622f, 
    0.27589023f, -0.05392415f, -0.05551101f, 0.17127135f, 0.10488179f, 0.13375983f, -0.05611575f, -0.05359192f, 
    -0.18660025f, 0.08403533f, 0.08603973f, -0.01870066f, -0.02297577f, 0.15410344f, 0.21445276f, 0.03228405f, 
    0.08358069f, -0.11069062f, -0.01513051f, -0.06359538f, 0.06502721f, 0.21792881f, 0.15838273f, -0.01099391f, 
    0.05234773f, 0.10118529f, 0.22207640f, 0.07775292f, 0.14386718f, 0.02280872f, 0.09805162f, 0.04010132f, 
    -0.37592280f, -0.15698302f, -0.45386377f, 0.15298110f, 0.05872763f, -0.15035163f, 0.16730887f, -0.07704928f, 
    -0.12938417f, 0.17220955f, -0.06441312f, 0.23588157f, 0.01188295f, 0.03218687f, 0.07588963f, 0.24612843f, 
    0.06369799f, 0.00287502f, -0.04528694f, -0.00002049f, 0.03303643f, -0.37050080f, -0.11182801f, 0.05640100f, 
    0.46895751f, -0.11742257f, 0.09804829f, 0.09375010f, 0.16535093f, 0.23176619f, 0.04060908f, -0.01673334f, 
    0.34686190f, -0.06938571f, -0.07012589f, -0.30047533f, 0.18702273f, -0.33614689f, 0.18333916f, 0.20757872f, 
    0.07259987f, 0.04010985f, 0.04205270f, 0.16109714f, 0.39026907f, 0.01087786f, -0.22959176f, 0.13766290f, 
    0.10974215f, 0.34288621f, 0.14702807f, 0.17968939f, -0.40591037f, -0.53410167f, -0.00466929f, -0.02866421f, 
    -0.12983401f, 0.19965453f, -0.10146874f, -0.04171491f, 0.01140347f, 0.18792151f, 0.18180962f, -0.47615260f, 
    -0.12206960f, 0.07426099f, 0.47003520f, -0.10444286f, -0.05753470f, 0.04538067f, -0.00462925f, 0.01438587f, 
    0.13652036f, -0.36165732f, 0.52477509f, 0.05005319f, 0.16221732f, -0.15184915f, -0.21105009f, 0.29439381f, 
    -0.13236174f, 0.05202931f, 0.07779466f, -0.11204088f, -0.24183428f, -0.04215467f, 0.00977209f, 0.01130695f, 
    0.25812322f, -0.06423846f, 0.34399697f, 0.01944836f, 0.03790550f, -0.03997154f, 0.09777010f, -0.37156367f, 
    0.24684937f, -0.24401887f, 0.09545099f, -0.01389084f, -0.18365626f, 0.08942574f, -0.48317149f, 0.32165480f, 
    0.21316607f, -0.10875595f, 0.23293038f, 0.06093308f, 0.05965047f, 0.00092827f, -0.03930657f, 0.14265133f, 
    -0.00394968f, 0.13161919f, 0.08328073f, 0.01686987f, -0.35617688f, -0.00569343f, -0.13846146f, 0.05363517f, 
    0.21375249f, 0.20894364f, -0.49884656f, 0.26620090f, 0.26219940f, -0.22094432f, -0.03129765f, 0.08531193f, 
    -0.09392910f, -0.13031124f, 0.46559584f, 0.18145311f, 0.29931033f, -0.39871198f, 0.10594040f, 0.02384708f, 
    -0.20645680f, 0.19345541f, -0.01441756f, 0.08216520f, 0.21341197f, -0.29526231f, -0.08805765f, 0.11137603f, 
    0.25521249f, 0.11947707f, 0.00878734f, -0.18516403f, -0.05093280f, -0.05013225f, -0.02783885f, 0.24772546f, 
    0.17864418f, 0.07406610f, -0.29207274f, -0.03212449f, 0.11551388f, 0.23455910f, -0.05620967f, -0.37705126f, 
    0.03576990f, -0.10588651f, 0.15429085f, -0.12352115f, -0.06878696f, -0.17815824f, -0.10013010f, 0.04053825f, 
    -0.08313441f, -0.46344176f, 0.01042696f, 0.06372995f, 0.26560339f, -0.62147760f, 0.10881622f, 0.22065169f, 
    -0.18108580f, 0.00296697f, 0.01485196f, 0.13681018f, -0.02869512f, -0.02893480f, -0.00926801f, 0.13523921f, 
    0.27969390f, 0.26797625f, 0.18254679f, 0.09814214f, -0.03653538f, 0.11192188f, 0.15738328f, 0.02694865f, 
    -0.05495924f, 0.02728083f, 0.10639499f, -0.23499578f, -0.23393999f, -0.00488481f, 0.00273851f, -0.05196663f, 
    -0.45089325f, -0.23797101f, 0.04431435f, 0.06512032f, -0.00138576f, -0.03622789f, -0.40506703f, -0.05353463f, 
    0.15589054f, 0.03689665f, -0.06255759f, -0.40359485f, 0.01240610f, -0.27748600f, 0.05491117f, 0.02019631f, 
    -0.17348652f, 0.07249653f, 0.34057736f, -0.01290402f, -0.02111888f, 0.05066661f, 0.11554444f, -0.43189088f, 
    0.19729792f, 0.06387617f, -0.05029372f, 0.15367392f, 0.04024917f, 0.08170077f, 0.06385319f, 0.06244496f, 
    -0.03835978f, -0.01333007f, -0.00803021f, -0.06327892f, -0.01192574f, -0.01121516f, 0.07423290f, -0.07174888f, 
    -0.00942251f, 0.04338858f, 0.01342118f, 0.00173780f, 0.02126745f, -0.00415953f, -0.02719827f, -0.03323221f, 
    -0.01412483f, 0.08436946f, 0.03924334f, 0.04070554f, 0.01555799f, 0.02263888f, -0.07134227f, -0.04834099f, 
    -0.03226957f, -0.04750401f, -0.02164569f, 0.01667887f, -0.03961340f, 0.06755347f, -0.05652192f, -0.03696764f, 
    0.02971351f, -0.03140361f, -0.07957008f, 0.05013596f, -0.07792152f, -0.04223288f, 0.02167461f, 0.02219558f, 
    -0.01122799f, -0.09026443f, -0.02863158f, 0.03214020f, 0.03374688f, -0.08137241f, -0.07265512f, -0.00984793f, 
    0.04023172f, -0.06674433f, -0.08145434f, -0.06009555f, 0.06374430f, 0.00693758f, -0.03263536f, -0.03648772f, 
    -0.05640949f, -0.02017417f, -0.06376643f, -0.03043570f, 0.01157097f, -0.04111502f, -0.10186206f, -0.02476561f, 
    0.04872271f, 0.04533130f, 0.04844379f, 0.03760005f, -0.07156081f, -0.05026000f, 0.03030477f, -0.00331557f, 
    -0.02158354f, -0.02147937f, 0.06697224f, -0.09146994f, -0.03277048f, -0.07988507f, 0.02130373f, 0.00743457f, 
    -0.08134172f, -0.05336872f, -0.09370501f, -0.06867155f, 0.03777992f, -0.04759656f, -0.00246644f, -0.09246566f, 
    -0.05127047f, -0.08509499f, 0.01579144f, 0.04328382f, 0.01102792f, -0.03245570f, -0.03699734f, 0.08386826f, 
    -0.09312406f, -0.07074970f, 0.02288437f, 0.00354520f, -0.04614362f, -0.01152640f, -0.05329169f, 0.01370477f, 
    -0.05782244f, 0.06970742f, 0.02104255f, -0.04547497f, -0.00111919f, -0.01695052f, 0.03881676f, -0.04527181f, 
    -0.01093561f, 0.06672908f, -0.04329366f, -0.07976056f, -0.07629868f, 0.05015668f, -0.07888574f, 0.04428373f, 
    0.07378355f, -0.03461081f, 0.01693372f, 0.02002076f, -0.09203468f, 0.08109114f, -0.03495810f, 0.04836104f, 
    0.01477728f, -0.10208053f, 0.20908694f, -0.02451467f, 0.22020328f, 0.26166564f, -0.22549237f, 0.49370968f, 
    0.01247491f, 0.02904155f, -0.00043805f, -0.02934892f, -0.05007162f, -0.02919608f, -0.07533342f, 0.13019510f, 
    0.18831491f, -0.03757174f, -0.02477606f, -0.08297986f, 0.30394503f, -0.18309064f, -0.02081116f, 0.12723757f, 
    0.19965318f, -0.11241820f, -0.22374882f, 0.30363539f, 0.22992295f, 0.19213249f, 0.05611008f, 0.06324508f, 
    0.27395713f, 0.16674845f, -0.00931850f, 0.10689164f, 0.18104985f, 0.11136462f, -0.14526260f, 0.00609584f, 
    0.04904806f, -0.16109130f, 0.14567801f, -0.15113042f, 0.03795983f, -0.04019594f, 0.18877171f, 0.24044947f, 
    0.36286494f, -0.02667263f, -0.15051071f, 0.08089233f, 0.26813182f, -0.05991092f, -0.03716359f, 0.12618439f, 
    -0.16145930f, -0.19456448f, -0.04874326f, -0.21687371f, 0.11401898f, 0.05220322f, -0.25119063f, 0.16998802f, 
    -0.01009361f, 0.21118920f, 0.02296253f, 0.07995873f, 0.16107291f, 0.03545636f, 0.00012558f, 0.19139363f, 
    -0.22735670f, -0.03200255f, 0.06596837f, 0.24262792f, 0.14155106f, -0.17461421f, -0.30290830f, 0.01021752f, 
    0.02666874f, -0.01809719f, -0.15342331f, 0.02991240f, 0.01611091f, -0.21662426f, 0.06582069f, 0.09534004f, 
    0.06890146f, 0.25603646f, 0.22553807f, 0.07431206f, 0.05610720f, 0.02697120f, 0.01101958f, 0.08283455f, 
    -0.07143154f, -0.17419295f, 0.21855880f, -0.06073860f, 0.01921698f, -0.07253634f, -0.04086057f, -0.25688088f, 
    0.15148589f, -0.05221144f, 0.03913112f, 0.00401893f, 0.07654969f, 0.17979036f, -0.00069275f, -0.00620007f, 
    -0.31075814f, 0.05911803f, 0.03733668f, -0.09682383f, -0.14488739f, 0.33984989f, 0.17527324f, 0.11459126f, 
    0.18553455f, -0.11741655f, 0.12200115f, -0.22893696f, -0.00269206f, 0.12754890f, -0.03474475f, 0.33975115f, 
    -0.13309786f, 0.00304052f, -0.09420925f, -0.07374979f, -0.07427129f, 0.38087043f, 0.03963334f, 0.17517059f, 
    -0.17627245f, 0.13196138f, -0.01050245f, -0.00742588f, 0.06202308f, 0.03797203f, -0.23301613f, -0.00402810f, 
    0.05518838f, -0.23111695f, -0.08363325f, -0.01213159f, 0.19385847f, -0.07840462f, 0.08728915f, 0.12611797f, 
    0.26373479f, -0.10006391f, -0.12597819f, 0.03543237f, 0.00827439f, 0.16696674f, 0.18513392f, 0.27288476f, 
    0.21871178f, 0.05869624f, -0.07939530f, -0.02082723f, 0.10821199f, -0.03071983f, 0.03779360f, 0.06894377f, 
    -0.33197564f, 0.07321079f, 0.16709487f, 0.01039760f, 0.06357273f, -0.08997913f, 0.19261779f, 0.21042980f, 
    -0.01279220f, -0.11615331f, -0.03400563f, -0.17916641f, 0.16060697f, -0.11886532f, -0.02138751f, 0.06481947f, 
    -0.44781724f, 0.15461174f, -0.06167641f, 0.12416580f, 0.05295488f, 0.13425864f, -0.02619178f, 0.04427302f, 
    0.03532712f, 0.06951053f, -0.20426489f, 0.16022028f, -0.08058967f, -0.09506012f, 0.27667406f, -0.08054248f, 
    -0.15605678f, 0.00961659f, 0.10538319f, -0.04052954f, 0.39929342f, -0.02852839f, -0.31500876f, -0.08734006f, 
    -0.14229259f, -0.22832607f, 0.00556030f, -0.07430069f, 0.02887676f, -0.54780447f, -0.11487445f, 0.05012356f, 
    -0.09102916f, 0.11293326f, 0.04668480f, 0.13014840f, -0.00271500f, -0.04788672f, 0.05866619f, -0.01540130f, 
    -0.08248729f, 0.05844141f, 0.10680462f, -0.04872946f, -0.05945323f, -0.08620779f, 0.02295336f, -0.06790975f, 
    0.23251595f, -0.06730063f, 0.08317022f, -0.07384877f, 0.02975039f, 0.13682669f, 0.04700749f, -0.03915163f, 
    0.02688783f, -0.02344429f, 0.12344113f, 0.04301842f, -0.05979871f, 0.06744811f, -0.10869898f, 0.13802004f, 
    -0.14913578f, 0.19689488f, -0.02332581f, -0.13390063f, 0.17642522f, 0.18664101f, -0.14168559f, 0.16351542f, 
    0.07886198f, 0.09885688f, -0.01723344f, -0.07063898f, -0.21612121f, -0.21381146f, 0.06520404f, 0.21863243f, 
    -0.01979602f, 0.56922066f, -0.05560956f, 0.12283681f, -0.02815777f, 0.08462296f, 0.31720832f, 0.05567237f, 
    0.06446620f, 0.08217300f, -0.35460493f, -0.07294968f, -0.24550651f, -0.08991635f, -0.05049956f, 0.22123933f, 
    0.14439800f, -0.18882619f, -0.39199826f, -0.05041312f, -0.20184219f, 0.03788847f, 0.05515434f, 0.09999943f, 
    -0.05516273f, 0.19483373f, -0.05847694f, 0.08741795f, 0.01738430f, 0.10717905f, 0.11435065f, -0.09539560f, 
    -0.56015497f, 0.11522450f, 0.07959231f, 0.05432824f, 0.31876501f, -0.44055542f, 0.09618469f, -0.11364203f, 
    -0.27155408f, 0.07054330f, -0.05178298f, -0.15072504f, -0.18394668f, 0.08161320f, -0.07862982f, 0.02131090f, 
    -0.20292358f, 0.42302588f, 0.23571013f, -0.29776976f, -0.04159110f, -0.50348288f, -0.23799062f, 0.02364312f, 
    -0.04690069f, -0.25724673f, -0.05487848f, 0.07468698f, -0.25046071f, -0.14386232f, -0.20444663f, -0.07536034f, 
    -0.15493611f, 0.14033078f, -0.04485315f, 0.00590029f, 0.14152886f, 0.04672166f, 0.02812745f, 0.02163679f, 
    -0.45999184f, 0.02916170f, 0.02999327f, 0.01568350f, -0.03047624f, -0.32523558f, 0.16361368f, -0.29908460f, 
    -0.24990159f, 0.04291746f, -0.06976783f, -0.16715379f, -0.09971090f, -0.10632069f, 0.03847302f, -0.03313333f, 
    -0.27018440f, 0.23358275f, -0.10314228f, -0.05678435f, 0.16478680f, 0.03152302f, -0.26325011f, -0.15658098f, 
    -0.22895737f, 0.08149926f, -0.08251363f, 0.00177375f, 0.04063312f, -0.19074143f, -0.07998917f, 0.37939554f, 
    0.11671177f, 0.09468752f, -0.26306704f, -0.07941820f, 0.11362340f, -0.51378340f, 0.07281308f, 0.23838626f, 
    0.16403966f, 0.31967938f, -0.08757450f, -0.12304002f, 0.09270681f, 0.09961881f, -0.31524181f, 0.09375250f, 
    -0.00096535f, -0.07761850f, -0.02200313f, 0.06697147f, 0.00951783f, -0.06430530f, -0.04928317f, -0.00436529f, 
    0.04309592f, 0.00775369f, 0.01618028f, 0.01592883f, -0.07287269f, -0.04679367f, 0.03995281f, -0.02801536f, 
    -0.02210912f, 0.03406176f, -0.02882668f, 0.00050130f, -0.01672782f, -0.07028837f, 0.00898254f, -0.08396924f, 
    -0.07280347f, -0.07853358f, -0.02971403f, -0.09515385f, -0.02232544f, -0.05088444f, 0.06005082f, -0.01779843f, 
    0.01441518f, -0.02051872f, -0.07522219f, -0.04392954f, -0.01963194f, -0.03918692f, -0.08526661f, 0.03828881f, 
    0.03276154f, -0.01524183f, -0.07188636f, -0.01584360f, -0.01649800f, 0.04267241f, -0.06967130f, -0.02170488f, 
    0.06360494f, -0.05284904f, -0.02927221f, -0.00307022f, -0.07748470f, -0.08014686f, -0.00833368f, -0.04903889f, 
    -0.08743197f, -0.07028700f, 0.01063314f, 0.00007794f, 0.02043122f, -0.06579824f, -0.04360602f, -0.01635876f, 
    0.03195304f, 0.04283724f, 0.02467515f, -0.06122444f, -0.05883784f, 0.07236524f, -0.00904696f, -0.06341474f, 
    -0.06073451f, -0.08810809f, 0.01858464f, 0.04059570f, -0.06572083f, 0.04102247f, 0.00136223f, 0.01215352f, 
    -0.06388297f, 0.00332871f, -0.02429143f, 0.08057912f, -0.06254904f, -0.00268658f, 0.07440817f, -0.04565488f, 
    -0.04883176f, -0.09875586f, 0.01750293f, -0.09187811f, -0.01950013f, 0.04338176f, 0.08404803f, 0.03384182f, 
    0.07236476f, -0.05591778f, -0.04941431f, -0.02394527f, -0.00247864f, -0.00365979f, 0.06890834f, -0.07807216f, 
    0.07654617f, 0.05552449f, -0.07318993f, 0.04044665f, -0.00406173f, -0.06981606f, 0.01917838f, 0.08401580f, 
    0.05434678f, 0.06785161f, 0.01880442f, 0.04340066f, -0.03900523f, 0.03313608f, -0.00647611f, 0.01880398f, 
    0.06535295f, -0.00540297f, -0.00956423f, 0.03655625f, -0.08341262f, 0.03034975f, -0.05033175f, -0.04255627f, 
    -0.07011675f, -0.05006684f, 0.03994948f, -0.08692498f, -0.05932457f, 0.06506782f, -0.05611962f, 0.02600219f, 
    0.05553539f, 0.07124304f, 0.08580469f, 0.02163427f, 0.01896381f, 0.05922078f, -0.03498724f, -0.07989632f, 
    0.03612528f, 0.05974004f, -0.07844222f, -0.02532236f, -0.08356164f, -0.08162651f, -0.08063339f, 0.05627831f, 
    -0.06416377f, -0.01698053f, 0.05620445f, -0.08651625f, 0.02867330f, -0.08445926f, -0.09039672f, -0.04603489f, 
    -0.00050127f, 0.02524775f, 0.03362718f, 0.02523432f, 0.04849071f, -0.08673076f, -0.08465485f, 0.05219958f, 
    -0.00570197f, 0.00370097f, -0.08474480f, -0.02404154f, -0.04798548f, -0.07828205f, -0.07424212f, -0.05186298f, 
    0.03387691f, 0.00860058f, -0.07538608f, 0.05648891f, -0.01298173f, 0.02400778f, 0.05995183f, 0.01460691f, 
    0.06123826f, -0.06602654f, -0.05642894f, -0.00316615f, 0.00522142f, 0.03206015f, 0.06226229f, 0.07375190f, 
    -0.00762364f, -0.00912065f, 0.01856835f, 0.00996120f, 0.00179824f, -0.06740303f, -0.03647381f, -0.02527336f, 
    -0.09333794f, -0.03293895f, 0.01473975f, -0.08212579f, -0.06700753f, 0.06607647f, -0.07708281f, -0.07813239f, 
    0.03363272f, -0.06071204f, -0.03493364f, -0.01250823f, 0.01649288f, 0.05097870f, 0.01569631f, 0.07663738f, 
    -0.04894057f, -0.02905961f, -0.00634439f, 0.05473682f, 0.07560432f, -0.01502505f, -0.03349103f, 0.07636322f, 
    -0.08349442f, 0.05725505f, -0.08372531f, -0.04078320f, -0.03728315f, 0.06283254f, 0.00605891f, -0.07406610f, 
    0.06585827f, -0.08599388f, -0.00359906f, -0.06330184f, -0.09404151f, 0.06450718f, 0.00360993f, 0.07723869f, 
    0.00635396f, 0.06655766f, -0.06908957f, 0.04229706f, -0.05258923f, -0.06018094f, -0.02183817f, 0.07263521f, 
    0.06497578f, 0.01964410f, 0.07255961f, -0.03364354f, -0.01610628f, 0.00573898f, -0.01789838f, 0.04232020f, 
    -0.09159253f, -0.07925455f, 0.02379270f, 0.02774153f, 0.03986813f, 0.40107855f, 0.00457085f, 0.00245400f, 
    -0.06762056f, 0.06237477f, -0.00835169f, -0.07331086f, -0.10952442f, -0.07301193f, -0.35674754f, -0.10534863f, 
    -0.04520080f, -0.02022729f, 0.33414710f, 0.01810402f, 0.21389726f, 0.01523762f, -0.04534683f, 0.13399448f, 
    -0.23314315f, -0.15718056f, -0.13422056f, 0.16209136f, 0.29556328f, -0.02524926f, 0.00401865f, -0.02014116f, 
    0.01618359f, 0.13795596f, 0.06244776f, 0.09135785f, -0.00019984f, -0.03091367f, -0.12950535f, 0.31993535f, 
    0.40088922f, -0.06374034f, -0.09286621f, -0.06877639f, -0.29416385f, -0.28900668f, -0.11279241f, 0.00088582f, 
    0.57662439f, 0.01807394f, -0.08273724f, 0.12775585f, 0.20982864f, 0.06085168f, 0.04470517f, 0.02943640f, 
    0.31041342f, -0.16170040f, -0.07100745f, -0.20651516f, 0.24757011f, -0.00453208f, 0.07252330f, 0.10688622f, 
    -0.04095805f, 0.08085000f, 0.06354623f, 0.03776370f, 0.57886809f, 0.00544527f, 0.00909015f, 0.01917109f, 
    -0.17785792f, 0.07448471f, 0.08959865f, 0.08049553f, -0.20554367f, -0.17872751f, -0.12520884f, 0.11376145f, 
    -0.08919865f, 0.11338387f, -0.17687957f, 0.08867027f, 0.03344208f, -0.00902708f, 0.33708271f, -0.50280273f, 
    -0.19203548f, 0.02881762f, 0.39890635f, 0.05640892f, 0.14428492f, 0.12722497f, -0.08361476f, 0.06114835f, 
    0.11321002f, -0.30010539f, 0.43682390f, -0.00838361f, 0.12271864f, -0.04396171f, 0.05502502f, 0.26278958f, 
    -0.03239907f, -0.03629486f, -0.07253793f, -0.03069325f, -0.22152625f, -0.02136968f, -0.07574328f, -0.14473975f, 
    -0.05426023f, -0.06375968f, 0.08939596f, 0.03672861f, -0.29505232f, 0.30259556f, -0.02529179f, -0.44002807f, 
    0.14157504f, -0.26816005f, 0.02814030f, -0.25036418f, -0.11273847f, 0.04907950f, -0.37574318f, 0.27514005f, 
    -0.03497396f, -0.12126420f, -0.16215074f, 0.09172317f, -0.29443881f, -0.21846224f, 0.05547350f, -0.00602691f, 
    -0.05255773f, 0.14919400f, 0.08835446f, 0.14700548f, 0.26992697f, -0.00104050f, 0.02127540f, 0.10511891f, 
    0.02316338f, 0.11056294f, -0.21926422f, -0.25504923f, -0.23258917f, -0.00444544f, 0.03481282f, 0.27414140f, 
    -0.00277609f, -0.02514232f, -0.28622285f, -0.12317591f, -0.19171567f, 0.21218522f, 0.00548368f, 0.19784822f, 
    -0.12373753f, 0.04616134f, -0.08050538f, -0.04199794f, -0.08501084f, -0.08100348f, 0.22196716f, 0.17541374f, 
    -0.15558735f, 0.24905983f, 0.21998145f, 0.09291781f, 0.22286512f, -0.52663010f, 0.23453750f, -0.10421509f, 
    -0.18103831f, -0.09736618f, 0.18048231f, -0.28033054f, -0.23482710f, -0.00834044f, 0.04345438f, 0.17710711f, 
    -0.39971426f, 0.55310649f, 0.23908062f, 0.01139012f, 0.03046901f, -0.33969525f, -0.14273661f, 0.03157962f, 
    -0.02782125f, 0.08429561f, -0.13814323f, 0.01442907f, -0.24900132f, -0.03437367f, -0.05168049f, -0.02064905f, 
    0.04113280f, 0.13445267f, -0.11737958f, 0.01814044f, 0.25292054f, 0.28910932f, -0.07139474f, 0.01268258f, 
    -0.54745430f, -0.20975734f, -0.23048140f, -0.06416892f, -0.10145203f, -0.17982179f, 0.05573913f, -0.21793267f, 
    0.54306483f, -0.06274780f, -0.10792960f, -0.01960055f, -0.11710910f, -0.19105798f, 0.04752674f, -0.05107176f, 
    -0.18946442f, 0.07979663f, -0.05624519f, -0.02315263f, 0.09389310f, -0.10822014f, -0.13176048f, 0.03027706f, 
    -0.10415427f, 0.03590198f, -0.02933964f, 0.01228063f, 0.25773838f, -0.03064068f, -0.04906127f, 0.30676910f, 
    0.18370342f, 0.02503729f, -0.16840342f, -0.03634452f, 0.11897938f, -0.33454335f, 0.04393450f, 0.26365063f, 
    0.01011451f, 0.28085938f, 0.11650512f, -0.12692261f, 0.31503043f, 0.10350491f, -0.20459574f, 0.10521536f, 
    -0.10494147f, -0.02293995f, 0.02894359f, -0.02333482f, -0.10328895f, -0.10346891f, -0.11135640f, -0.04725041f, 
    0.03671478f, -0.01357932f, 0.00506761f, -0.10628538f, 0.00282516f, -0.05711480f, -0.03778741f, -0.04081372f, 
    -0.08497139f, 0.06065771f, 0.00709551f, -0.08549315f, -0.08879200f, -0.01771296f, -0.03483225f, -0.00938469f, 
    0.00078432f, 0.03289022f, -0.05355041f, -0.10039715f, 0.05527635f, -0.04504361f, -0.10973670f, 0.05901693f, 
    0.03212164f, -0.09396031f, 0.06119414f, -0.06714381f, 0.03948709f, 0.02603335f, 0.03630830f, 0.00673968f, 
    -0.06085109f, -0.10991627f, -0.07113537f, -0.00034283f, -0.08958405f, 0.02882461f, -0.03122524f, 0.02217225f, 
    0.04971572f, -0.04218908f, 0.03121859f, -0.03378091f, 0.01444202f, -0.10608751f, 0.04802020f, 0.02160867f, 
    0.03220370f, -0.04178471f, 0.01162682f, -0.01091779f, -0.03758275f, -0.03702648f, 0.02354847f, -0.08313768f, 
    -0.02489255f, 0.01774897f, -0.10689909f, -0.05723193f, -0.02390150f, 0.02288955f, -0.05541604f, -0.00061787f, 
    -0.09949062f, -0.10844826f, -0.08979432f, 0.00972305f, -0.06178684f, -0.02307770f, 0.03164699f, -0.11067870f, 
    0.01719385f, 0.04169858f, -0.08561294f, 0.08297262f, -0.08225392f, -0.09223092f, -0.03240082f, 0.02042815f, 
    0.02037841f, 0.02661140f, 0.00554876f, -0.03660274f, 0.02597492f, 0.02696717f, 0.05271347f, 0.03111532f, 
    0.03170411f, -0.04081330f, -0.07784541f, -0.00298347f, -0.11518409f, 0.02350985f, -0.09714096f, 0.01217218f, 
    -0.02840967f, 0.07489222f, -0.02614511f, -0.01532355f, -0.12412695f, -0.02689439f, -0.02443604f, 0.05174400f, 
    -0.00368696f, -0.07603066f, 0.07216732f, -0.01345962f, -0.01956392f, 0.02442855f, -0.09203093f, -0.10031633f, 
    -0.11777314f, -0.08109335f, 0.00348212f, -0.07582143f, -0.02282295f, 0.02810434f, -0.04941135f, -0.03516526f, 
    0.15562232f, -0.03574004f, 0.06159251f, -0.01472901f, 0.17013353f, 0.10424668f, 0.06310185f, 0.03058909f, 
    0.22095782f, -0.20820276f, 0.03731458f, -0.03962937f, -0.26351601f, -0.05753199f, -0.07076461f, -0.01267732f, 
    -0.01849416f, 0.14044480f, -0.05320372f, -0.03452399f, 0.02969307f, -0.05150323f, -0.00389480f, -0.06820521f, 
    0.07263939f, 0.17510054f, 0.05784227f, 0.03785470f, 0.17372869f, 0.05604560f, -0.09765085f, -0.02860438f, 
    -0.13640116f, 0.22770253f, -0.08736869f, -0.00356808f, 0.00132103f, 0.01132720f, -0.31363377f, 0.09313480f, 
    0.27022353f, 0.03669540f, -0.13380612f, -0.05467564f, -0.02199128f, -0.30398127f, -0.11971421f, 0.01961271f, 
    0.20611586f, 0.05882144f, 0.13973755f, 0.04323470f, -0.01012014f, 0.03233526f, 0.00650987f, -0.01925934f, 
    0.15381970f, -0.51262504f, -0.06763735f, -0.07780022f, -0.06884439f, 0.12312605f, 0.20478676f, -0.00930405f, 
    -0.06036171f, -0.06069849f, 0.05467636f, 0.05251294f, 0.42692253f, -0.03020744f, -0.03219651f, 0.18964396f, 
    -0.03828583f, -0.03256169f, 0.13700819f, -0.00653507f, -0.25176123f, 0.06646752f, 0.01647272f, 0.09109485f, 
    0.02083353f, 0.04891090f, -0.02092916f, -0.02069061f, 0.09268842f, 0.17535362f, -0.02487855f, -0.39743140f, 
    0.25515282f, -0.02503417f, 0.08025446f, 0.11985004f, 0.05471982f, 0.00694655f, 0.08389938f, 0.04278214f, 
    -0.00094965f, -0.11830593f, 0.20352678f, 0.05959144f, 0.09558438f, -0.23333994f, 0.03755911f, 0.03047933f, 
    0.09809451f, 0.04842474f, 0.03632385f, -0.07852556f, 0.00831000f, 0.07454665f, -0.04284300f, -0.20200610f, 
    -0.19078949f, -0.02642135f, 0.07590553f, 0.02470842f, -0.11693379f, 0.17107709f, 0.12711103f, -0.22127961f, 
    0.03084566f, -0.27372324f, -0.07819045f, -0.06405678f, -0.16668969f, 0.16409855f, -0.15071933f, 0.08411080f, 
    -0.17028992f, 0.03469358f, 0.29935294f, 0.06783441f, 0.09864463f, 0.18865855f, -0.09554470f, -0.33738682f, 
    0.00176615f, -0.02473969f, 0.01969465f, -0.40889758f, 0.06474631f, -0.21656531f, 0.00378877f, -0.08002377f, 
    -0.22692974f, -0.15828696f, -0.00765265f, 0.17294984f, -0.00030181f, 0.02466784f, 0.00984995f, -0.40575486f, 
    -0.42677584f, -0.01648590f, -0.00626677f, 0.19912514f, 0.20756505f, -0.19122583f, -0.19857757f, -0.36152887f, 
    0.00404677f, -0.03816850f, 0.08751395f, 0.05798057f, -0.08270881f, 0.12416475f, -0.01443101f, 0.38656422f, 
    0.01019092f, -0.29552370f, -0.34795153f, -0.04563525f, -0.12151643f, 0.05326954f, -0.30742621f, 0.04411625f, 
    -0.41425067f, -0.04804670f, 0.02316975f, 0.20244487f, 0.11313444f, 0.09115481f, -0.08384941f, 0.06442819f, 
    0.11721954f, -0.27167803f, -0.07469986f, 0.08359328f, 0.03251660f, -0.21045795f, -0.02418568f, 0.06890138f, 
    -0.01829260f, 0.11351822f, 0.08318630f, -0.12908089f, 0.24135059f, 0.06391046f, 0.08191152f, 0.11739073f, 
    0.04355589f, 0.11419323f, 0.09380029f, 0.10288258f, -0.10467061f, -0.11067005f, 0.01656445f, 0.00955521f, 
    0.14779167f, 0.11769081f, 0.11096102f, -0.06072823f, 0.04681697f, 0.25781071f, -0.08145797f, 0.17129196f, 
    -0.17191464f, -0.07202818f, -0.33937374f, 0.02756608f, 0.06609003f, 0.08051569f, 0.02247771f, 0.01704356f, 
    0.10605069f, -0.00323935f, 0.25862163f, -0.05196266f, 0.03869589f, 0.31019929f, 0.13779627f, 0.11197180f, 
    -0.25633380f, -0.07037076f, -0.03838132f, 0.09186705f, -0.13478751f, -0.05852823f, -0.06500040f, -0.64507461f, 
    0.00573128f, -0.06675223f, -0.10000882f, 0.05185866f, -0.11665618f, 0.27700034f, 0.08805356f, -0.74856120f, 
    0.09850867f, -0.80908793f, 0.13484016f, -0.22717799f, -0.57301521f, -0.21862151f, -0.00667091f, -0.06940776f, 
    0.05851584f, -0.06380285f, 0.07357586f, -0.06337310f, -0.00897276f, -0.12976249f, 0.03313679f, -0.19136494f, 
    0.17361426f, -0.04266824f, 0.01574042f, 0.41392526f, 0.22039098f, -0.04052762f, 0.13855866f, 0.08761730f, 
    -0.02794044f, -0.19200543f, 0.18551327f, -0.07324392f, 0.18612574f, 0.14961588f, 0.04748773f, -0.15176184f, 
    0.08705797f, -0.00171274f, 0.02659755f, 0.01477502f, -0.04664037f, 0.18897396f, 0.00009448f, 0.13872305f, 
    0.05657446f, -0.29586259f, 0.00687075f, -0.01243672f, 0.18186060f, 0.16801566f, 0.27563319f, -0.17218599f, 
    -0.08028842f, 0.00547556f, 0.15607667f, 0.10882587f, 0.10276203f, 0.19660094f, -0.01763894f, -0.17249008f, 
    -0.21206450f, 0.04624416f, 0.05679899f, -0.08682705f, -0.07195866f, -0.04311390f, 0.03865692f, -0.06672473f, 
    -0.35907555f, 0.07813533f, 0.09267264f, -0.12856896f, 0.01061551f, 0.36736193f, -0.04265129f, 0.11496010f, 
    0.01237084f, 0.11220293f, -0.08630978f, 0.05748399f, -0.34039426f, 0.16094168f, -0.24962193f, 0.07471952f, 
    0.21134861f, -0.01028804f, 0.03874550f, -0.02096929f, 0.17258753f, 0.09977022f, 0.11667521f, 0.00045723f, 
    -0.01975664f, 0.00911827f, 0.20577349f, -0.01742051f, -0.03857651f, 0.09765592f, -0.19499490f, 0.26196861f, 
    0.16829956f, 0.06347089f, -0.10968065f, 0.04408391f, -0.16876730f, 0.01993248f, 0.06050089f, 0.03043390f, 
    0.03853061f, -0.06310792f, -0.27148414f, -0.09410203f, -0.19238386f, 0.29115072f, -0.06673258f, 0.00889573f, 
    -0.00061127f, -0.01917071f, 0.04929950f, 0.16045780f, 0.17164512f, 0.32099071f, -0.06774394f, 0.14703780f, 
    -0.10255223f, -0.05247569f, -0.02511336f, 0.00229929f, 0.32842949f, -0.09389248f, -0.04550468f, 0.58366376f, 
    -0.03536670f, 0.10951100f, -0.27813700f, 0.47459015f, -0.10059144f, -0.01224011f, 0.06823413f, -0.36651063f, 
    0.01943481f, -0.08521948f, 0.07552537f, 0.01410600f, -0.00406206f, 0.04428724f, -0.10476042f, -0.04773804f, 
    -0.10243963f, -0.05996186f, 0.02140841f, 0.02207873f, 0.00180202f, 0.00936890f, 0.03575005f, 0.02643462f, 
    0.02728176f, -0.08932430f, -0.09719896f, 0.06018258f, -0.01552750f, -0.00959479f, -0.07183266f, 0.08624393f, 
    -0.08613058f, 0.05208350f, 0.06889156f, -0.04417524f, 0.06533492f, -0.08175636f, -0.06658478f, -0.04770453f, 
    0.01530567f, -0.03550587f, 0.01303752f, 0.01106051f, 0.00948804f, -0.08521896f, 0.03831192f, -0.05434176f, 
    -0.08740003f, -0.02187715f, 0.04990567f, 0.01669482f, 0.05371491f, -0.00377386f, -0.03111461f, 0.06166667f, 
    -0.04518028f, -0.04789725f, -0.08278947f, -0.07508433f, -0.00226963f, -0.00525003f, 0.07539303f, -0.03504588f, 
    0.03910208f, 0.06494003f, -0.00327175f, -0.09758425f, 0.03615112f, 0.02657582f, -0.08764131f, -0.02809663f, 
    -0.08380704f, 0.06991447f, -0.10061477f, -0.07481150f, 0.03362823f, 0.00632286f, 0.01638895f, -0.05855349f, 
    0.05947706f, -0.03886255f, -0.01605627f, -0.06784172f, -0.01477029f, 0.03620300f, 0.03831753f, -0.05844136f, 
    0.02853920f, -0.09093960f, -0.03210780f, -0.08737384f, 0.04112457f, -0.04409676f, -0.08794919f, 0.01460410f, 
    0.07373525f, -0.03850903f, -0.07587136f, 0.06189662f, -0.01033898f, 0.02639501f, 0.04116077f, -0.03027858f, 
    -0.05511191f, 0.02132041f, 0.06132250f, 0.07031585f, -0.10532939f, 0.04651656f, 0.03004011f, -0.07738227f, 
    -0.08534700f, 0.00048946f, 0.03195680f, 0.02268709f, -0.05697642f, 0.00638078f, 0.04562958f, -0.03181880f, 
    0.05723496f, 0.02994260f, -0.01416808f, 0.04618960f, -0.03126562f, 0.00951634f, -0.03075931f, 0.05329464f, 
    0.01906004f, 0.03163879f, -0.02075931f, 0.04121791f, 0.00972734f, -0.02775248f, -0.04981909f, -0.08160305f, 
    0.07272552f, -0.09284260f, -0.00295509f, -0.01728306f, 0.21944211f, 0.17719321f, -0.11394773f, -0.05289755f, 
    0.02063098f, -0.21607557f, -0.06282867f, -0.20342726f, 0.12387975f, -0.03364200f, -0.10790434f, 0.03653450f, 
    -0.15926349f, 0.26016837f, 0.20896219f, 0.04461874f, 0.08973014f, 0.10766815f, 0.10933947f, -0.08214781f, 
    -0.25943115f, 0.02566964f, 0.19718693f, 0.13910705f, 0.05683604f, 0.29258534f, -0.08894366f, -0.15527506f, 
    -0.08443093f, 0.01760912f, -0.01621575f, 0.00124591f, -0.09617253f, -0.15228288f, -0.14872161f, 0.32727352f, 
    0.10854471f, 0.06684925f, 0.09711818f, -0.05253085f, -0.02369627f, -0.41208300f, 0.00300085f, -0.07306228f, 
    -0.03171818f, 0.06699171f, 0.11371227f, -0.00582870f, 0.17778838f, -0.09013310f, -0.01569840f, 0.14319120f, 
    0.22910108f, 0.25035280f, 0.12581414f, -0.15999466f, 0.22264273f, 0.20278591f, 0.04865522f, -0.08130469f, 
    -0.06765030f, 0.25636399f, -0.02594436f, 0.08002240f, 0.34981525f, 0.13165824f, -0.05727764f, 0.26924446f, 
    -0.09953704f, -0.12370760f, 0.08722685f, -0.13669172f, -0.20446707f, 0.13857451f, -0.25878096f, 0.19588728f, 
    -0.19352500f, -0.04442655f, -0.33359635f, -0.00390388f, -0.00889589f, 0.06654336f, -0.23645474f, -0.08593379f, 
    -0.01596211f, -0.11860604f, -0.16095901f, 0.20624828f, 0.19827053f, -0.03528779f, 0.00672331f, -0.00960618f, 
    0.09535752f, -0.37033653f, 0.00213597f, -0.03787557f, 0.06662017f, 0.17280532f, 0.02224120f, 0.27252254f, 
    -0.03897915f, 0.02685456f, -0.05013742f, -0.06669647f, 0.04850987f, 0.07743293f, -0.05751118f, 0.00799392f, 
    -0.21098673f, -0.00519363f, -0.14079674f, 0.08352041f, 0.01070659f, 0.32821128f, 0.11326829f, 0.00406477f, 
    0.28295556f, -0.13749719f, 0.02583877f, 0.08475266f, 0.00558952f, 0.00270740f, -0.39331716f, 0.10195314f, 
    -0.10843857f, 0.22355670f, -0.22397265f, -0.05811664f, 0.09298591f, 0.06909777f, 0.03850744f, 0.26956457f, 
    0.07184940f, -0.41355971f, 0.04337282f, 0.04853175f, 0.20676014f, -0.25816056f, 0.32126430f, 0.02373813f, 
    -0.19265726f, -0.22809333f, -0.03483846f, -0.01878362f, 0.25931868f, 0.16357648f, -0.04066276f, 0.22149560f, 
    -0.08865049f, -0.03742103f, 0.08900259f, 0.02167274f, -0.00031078f, 0.30115491f, -0.07477026f, -0.01162643f, 
    0.18766375f, 0.08401953f, 0.07038815f, -0.03605894f, 0.07050396f, 0.17898735f, -0.04798317f, 0.12901880f, 
    -0.02615350f, 0.03464440f, 0.06681975f, 0.04991928f, 0.37129396f, -0.16928592f, -0.12260842f, 0.08203861f, 
    0.07294203f, 0.08661371f, 0.16230150f, 0.06973942f, 0.20645674f, -0.06340143f, 0.02558194f, 0.25947449f, 
    0.10870606f, -0.73792464f, -0.23534411f, 0.01973699f, 0.15023805f, -0.05805038f, 0.05442154f, 0.00901113f, 
    -0.05194439f, 0.15916814f, 0.07749691f, 0.18108535f, 0.17874290f, 0.13788196f, 0.04754641f, -0.62385148f, 
    0.07639412f, 0.02178866f, 0.03815211f, -0.19847344f, -0.08018874f, -0.14369136f, -0.04689159f, 0.02721273f, 
    0.10838271f, -0.09370887f, 0.07308336f, 0.01839947f, 0.01310789f, -0.22679073f, 0.14478125f, -0.26849359f, 
    0.01508195f, 0.14817683f, 0.06373162f, 0.10286372f, 0.18743764f, 0.10090044f, -0.05658198f, -0.02868716f, 
    0.02174062f, 0.15163603f, 0.40342197f, -0.09442163f, 0.12387817f, -0.31222811f, 0.07470345f, -0.06535744f, 
    -0.45063487f, 0.00780960f, 0.03028820f, 0.14324324f, 0.12959816f, 0.20648439f, 0.08299140f, -0.50312334f, 
    0.15095976f, 0.02225065f, -0.20853084f, 0.03255174f, -0.21920721f, 0.06676511f, -0.04396316f, 0.10936619f, 
    0.02964638f, -0.40377870f, 0.03412667f, -0.31024611f, -0.51697111f, 0.15283380f, -0.14766656f, 0.06991102f, 
    -0.05760578f, -0.01665397f, 0.05651272f, 0.04654271f, 0.01436035f, -0.08840615f, -0.08188771f, -0.07185438f, 
    -0.01923032f, 0.02864694f, -0.01743953f, -0.01904974f, -0.06781460f, -0.06859577f, -0.04187429f, 0.07300732f, 
    -0.06833529f, -0.05323160f, -0.06216260f, -0.01458278f, -0.03401806f, -0.03291515f, 0.00565709f, 0.05642774f, 
    -0.02563305f, -0.04236974f, -0.00349508f, 0.01721449f, 0.04804749f, -0.03594217f, -0.02584892f, 0.01077956f, 
    -0.00323638f, 0.00878832f, 0.06465926f, 0.05771967f, -0.09350161f, -0.08213171f, -0.07072125f, -0.07734136f, 
    -0.07402653f, -0.03458228f, -0.07474589f, 0.03047120f, 0.01488927f, -0.03974487f, -0.01344923f, 0.05214833f, 
    0.03587506f, -0.02173241f, -0.08847085f, -0.06690212f, -0.08830718f, -0.06687821f, 0.06839909f, 0.01952151f, 
    -0.01922852f, -0.00679623f, -0.07480133f, -0.03161147f, -0.05414796f, 0.04683740f, 0.03146558f, 0.05708458f, 
    -0.06531294f, 0.06223354f, -0.05397284f, -0.03014890f, 0.00629601f, -0.00854693f, 0.03916938f, -0.09117864f, 
    0.07293704f, 0.03639648f, -0.04836955f, -0.02997317f, -0.08186961f, 0.01192854f, -0.07130928f, -0.03206889f, 
    -0.03554070f, 0.01542250f, 0.02480272f, -0.04910132f, -0.06306799f, -0.09932058f, 0.06112290f, 0.06960215f, 
    -0.04954591f, -0.00244135f, 0.08173805f, -0.01352125f, 0.06992348f, 0.04987700f, 0.01052483f, 0.05754294f, 
    -0.02328787f, 0.05859384f, -0.09655760f, 0.06925256f, 0.02394700f, -0.03896223f, -0.06553311f, 0.07331569f, 
    -0.08266269f, -0.03177888f, 0.04436091f, -0.03371026f, -0.03079372f, -0.05267260f, -0.01399697f, -0.02742173f, 
    0.07656152f, 0.06798998f, 0.07540108f, -0.05667607f, 0.02821458f, 0.03383152f, 0.04349187f, 0.01359579f, 
    -0.01382585f, -0.08961274f, -0.08469520f, 0.04412733f, -0.00466916f, 0.01005680f, 0.01766625f, -0.04863961f, 
    -0.17106301f, -0.27142170f, 0.08411430f, -0.02617991f, 0.00827415f, -0.03907754f, -0.25534469f, -0.22349283f, 
    -0.18377595f, 0.00605346f, 0.08643884f, 0.37865889f, -0.06373615f, -0.11250347f, -0.59786528f, 0.08067301f, 
    0.17953780f, -0.09664478f, -0.33713114f, -0.32339042f, 0.01805970f, -0.12238346f, -0.00619839f, -0.13223568f, 
    0.07434379f, 0.00327695f, 0.24823816f, 0.11982531f, 0.19073959f, 0.07203244f, 0.18873306f, 0.27082595f, 
    -0.23283999f, 0.09224476f, -0.03883692f, -0.29291493f, 0.01162661f, -0.24991481f, 0.19388294f, 0.20656176f, 
    -0.43090716f, 0.02515193f, 0.03642837f, 0.08999158f, -0.16322024f, -0.10707636f, 0.05236883f, 0.22056206f, 
    -0.13159186f, -0.00106761f, -0.05799300f, -0.22167581f, -0.19358227f, -0.03511881f, -0.07799278f, -0.02296440f, 
    -0.45213532f, 0.04162556f, 0.26076922f, -0.02414971f, 0.06709603f, 0.13335529f, -0.21136732f, -0.06702812f, 
    -0.00919442f, 0.09096252f, -0.45719847f, -0.01684543f, 0.22891204f, -0.06148589f, 0.00199789f, 0.27058157f, 
    -0.23459607f, -0.10202580f, 0.12762412f, 0.08740102f, 0.33822727f, 0.38064426f, -0.16066727f, 0.14823382f, 
    -0.10151967f, -0.18889357f, -0.02821296f, -0.06555428f, 0.01913199f, 0.16402139f, -0.03377856f, -0.14828633f, 
    -0.02136358f, -0.03854393f, -0.04761757f, 0.06170540f, -0.10596658f, -0.10101595f, 0.01765196f, 0.07191640f, 
    -0.12509926f, -0.34688661f, -0.04309772f, -0.05707420f, -0.17715041f, 0.02291041f, -0.12753886f, 0.09894311f, 
    0.38559210f, 0.03411834f, 0.04863897f, -0.03452920f, 0.30486470f, -0.04696772f, 0.04080384f, 0.11309848f, 
    -0.03059828f, 0.02179890f, 0.17221972f, 0.03381140f, 0.13701601f, 0.06667086f, 0.30624095f, -0.08451214f, 
    -0.02906329f, 0.25424522f, -0.03475434f, -0.03984000f, 0.43468574f, 0.15847614f, -0.12118962f, 0.04855563f, 
    -0.00764524f, -0.04655655f, 0.05906403f, 0.08480044f, 0.14668593f, -0.10018770f, 0.03533579f, -0.12276577f, 
    0.19187211f, -0.15812913f, -0.01864910f, -0.18713829f, 0.10335030f, -0.07411143f, 0.11365858f, 0.19285205f, 
    0.00451292f, 0.17586976f, 0.21304117f, -0.08804321f, 0.11683182f, 0.10978980f, 0.01154734f, -0.19452034f, 
    -0.03964396f, 0.24063958f, -0.02008922f, 0.10192513f, 0.07388322f, 0.19305684f, 0.01638065f, -0.07813472f, 
    0.07767875f, -0.17314465f, -0.05981638f, 0.06780424f, -0.05038948f, -0.01509729f, 0.02725894f, 0.16969477f, 
    -0.01458898f, 0.04289633f, 0.05394102f, 0.09278046f, -0.07196690f, -0.08245742f, -0.00076254f, -0.08206668f, 
    -0.16754404f, 0.09809615f, 0.24569146f, 0.03028660f, 0.15330604f, -0.13681300f, 0.00090615f, 0.05003360f, 
    0.00388020f, 0.26203895f, 0.14766060f, 0.02223861f, 0.33676070f, -0.23342529f, 0.11741629f, -0.01286531f, 
    0.00725093f, 0.08137092f, -0.09519903f, 0.10856440f, 0.19051860f, -0.01007544f, -0.04861909f, 0.16448842f, 
    0.37182945f, -0.16467433f, -0.01242489f, -0.16879702f, -0.01599092f, 0.27725092f, -0.04498532f, 0.13942640f, 
    0.03552159f, -0.11752807f, 0.09882518f, 0.02855342f, 0.10245296f, 0.08866683f, -0.06093820f, -0.15186793f, 
    -0.07309373f, -0.06701148f, -0.20225027f, 0.20523711f, 0.38697815f, 0.04260117f, -0.01775196f, -0.01746656f, 
    0.23438300f, -0.11978264f, -0.10762325f, 0.00292827f, 0.03724618f, 0.22700351f, 0.05549214f, 0.25098962f, 
    0.06456379f, 0.00230050f, -0.00834746f, 0.17355514f, -0.02547610f, 0.14793783f, 0.02061016f, 0.04198591f, 
    -0.18109204f, 0.03331927f, -0.00156610f, -0.13464519f, 0.00778760f, 0.06445189f, 0.00455851f, -0.20199621f, 
    -0.00903396f, 0.11734154f, -0.11379056f, 0.19654649f, 0.06491782f, 0.04949746f, -0.06499087f, -0.12818766f, 
    -0.05997149f, 0.06377976f, 0.13793348f, -0.02620868f, 0.08349024f, -0.21012954f, 0.16479312f, -0.08499280f, 
    0.18927161f, 0.07175402f, 0.05300703f, -0.00080976f, -0.08646779f, 0.04534527f, 0.00614555f, -0.01145434f, 
    0.16274947f, 0.01996311f, -0.15491997f, -0.24423374f, -0.05763048f, 0.02878129f, -0.00002530f, -0.18267372f, 
    0.05034749f, 0.17617619f, -0.28999910f, -0.04270671f, -0.02030663f, 0.05411743f, 0.07914416f, 0.12499603f, 
    -0.13895163f, 0.11853737f, -0.05133788f, -0.04343550f, 0.03265370f, 0.02810057f, 0.04077953f, 0.07687817f, 
    -0.34184325f, 0.23231675f, -0.00568508f, 0.13041708f, 0.04588785f, -0.32756072f, 0.02697822f, 0.06779000f, 
    -0.20827091f, 0.08900698f, 0.04673813f, -0.16104200f, 0.05865143f, -0.02593917f, -0.06587676f, -0.12727238f, 
    -0.32323831f, 0.07776133f, 0.07854527f, -0.21134892f, 0.15524344f, 0.05836762f, 0.06990980f, 0.06962662f, 
    -0.05835290f, -0.12745708f, -0.13216686f, 0.19583638f, 0.02026477f, 0.00464735f, -0.10279688f, 0.20700108f, 
    0.19567470f, -0.04533806f, 0.08741502f, 0.07284457f, 0.11507363f, 0.22916681f, 0.00760146f, 0.27922165f, 
    0.03437608f, -0.26922491f, 0.34151012f, -0.04836576f, -0.02153708f, 0.16686334f, -0.15499848f, -0.20536855f, 
    -0.32310244f, 0.00231045f, -0.29250276f, 0.04888449f, 0.07678229f, -0.04433114f, -0.03560088f, 0.03352325f, 
    -0.00627880f, -0.29198065f, -0.07206240f, 0.05491979f, 0.19780509f, 0.39068344f, -0.26169732f, 0.12127544f, 
    0.22248545f, -0.04270567f, -0.00188835f, -0.02488480f, -0.03138034f, -0.00365016f, -0.00365443f, 0.13967630f, 
    -0.13331836f, -0.04853086f, 0.05688544f, 0.01252211f, 0.38027266f, -0.07062885f, -0.06970021f, 0.21345869f, 
    -0.33073354f, 0.16373943f, -0.36293432f, 0.32317135f, 0.29539993f, 0.15064923f, -0.47794327f, -0.16949779f, 
    -0.05639642f, -0.05158816f, -0.01752387f, 0.02979512f, -0.04287067f, -0.06735888f, -0.03819824f, -0.05966051f, 
    -0.08076551f, 0.01510456f, -0.02660154f, 0.04673531f, -0.02067370f, 0.02008291f, 0.00237308f, -0.09170236f, 
    0.00780418f, -0.06955367f, -0.03816426f, -0.06528196f, -0.09115574f, 0.03255448f, -0.05125798f, 0.02122340f, 
    -0.05280506f, 0.06489485f, 0.00962625f, -0.08679909f, 0.03930511f, -0.06380644f, 0.01873964f, 0.05505429f, 
    -0.02030587f, 0.01888915f, 0.04853009f, 0.01884338f, -0.07566071f, -0.01358930f, 0.07008356f, 0.02328294f, 
    0.04933764f, -0.08771842f, -0.03757643f, -0.06029859f, -0.09008466f, -0.02595086f, -0.06976660f, -0.00422854f, 
    0.01694630f, -0.07348628f, 0.06979007f, 0.01953675f, 0.02765039f, -0.08345260f, -0.04338419f, -0.08607384f, 
    0.05588032f, 0.03923317f, 0.02136547f, -0.07545589f, 0.02665088f, 0.08739444f, 0.04204827f, 0.02427907f, 
    -0.04067101f, 0.00950418f, -0.02633253f, 0.05205892f, 0.02831402f, 0.03763322f, -0.03041451f, 0.06515756f, 
    -0.08458303f, -0.08096812f, -0.01440152f, 0.05964115f, -0.02315833f, 0.02349552f, 0.05548591f, 0.01269946f, 
    -0.03362970f, 0.00543912f, -0.01934626f, -0.04398073f, -0.04459444f, 0.00872564f, 0.06806696f, -0.05531530f, 
    -0.08293015f, -0.05178931f, -0.07810017f, -0.01586686f, 0.03698357f, 0.00939987f, -0.00874032f, 0.04416331f, 
    -0.08189113f, -0.07769749f, -0.06633228f, 0.02133396f, -0.09921039f, 0.04742571f, 0.04237517f, -0.04235139f, 
    -0.03064390f, 0.07375570f, -0.01496080f, 0.06766132f, -0.06891406f, 0.01111878f, 0.08814312f, 0.08810215f, 
    0.02174267f, 0.06569830f, 0.03660553f, 0.01652261f, 0.01416764f, -0.03285959f, -0.01601069f, -0.05050587f, 
    -0.08046769f, 0.00839044f, -0.01453141f, -0.05961712f, -0.07129541f, -0.08069231f, 0.00099009f, -0.04192555f, 
    -0.17095649f, 0.06915055f, 0.15482429f, 0.07685973f, 0.13373466f, -0.11814396f, -0.15009153f, -0.11739209f, 
    -0.06854226f, -0.15083827f, -0.04964568f, 0.05241292f, -0.00858223f, 0.12847188f, 0.05380353f, 0.04467249f, 
    -0.08596690f, 0.25058877f, -0.12779774f, 0.02635262f, -0.28966916f, 0.02400042f, 0.04662829f, 0.09925005f, 
    -0.41735050f, -0.00089376f, -0.24300033f, 0.08778784f, -0.11246351f, -0.15077464f, 0.02552515f, -0.06440688f, 
    -0.00073146f, 0.09340005f, 0.04904197f, -0.07083824f, 0.00875311f, 0.02736261f, 0.10634653f, 0.36809093f, 
    -0.06634232f, 0.14294478f, 0.01471852f, 0.08180004f, 0.04736561f, 0.01938872f, 0.01843792f, -0.20062114f, 
    -0.00273920f, -0.03491016f, 0.01416966f, 0.08893915f, -0.03151898f, 0.01480177f, -0.00410729f, 0.03669709f, 
    0.22296107f, 0.10063980f, 0.15420586f, -0.11085476f, -0.05053088f, -0.26872393f, -0.06453444f, -0.10474947f, 
    0.06053856f, -0.08948238f, 0.10120940f, -0.05671078f, 0.13165674f, 0.08544520f, -0.10936500f, 0.24992940f, 
    -0.05592217f, 0.07657599f, -0.03125847f, 0.23399213f, -0.14641383f, 0.09324346f, 0.09509332f, 0.04206166f, 
    -0.13478890f, -0.06012938f, 0.02765627f, -0.04830560f, 0.04857660f, 0.11168577f, 0.13898756f, -0.05094285f, 
    -0.13151564f, -0.05882405f, 0.25502333f, -0.08664920f, 0.16442101f, -0.04520863f, -0.07071617f, -0.01584231f, 
    0.07537676f, 0.06728305f, 0.07995750f, -0.06618374f, 0.20820342f, 0.74576819f, 0.00763934f, 0.09201434f, 
    -0.11825028f, -0.02263661f, -0.04848938f, -0.03217732f, -0.02794983f, -0.18925190f, 0.01767267f, 0.29993978f, 
    -0.02904773f, 0.12354583f, 0.27245864f, 0.00919419f, 0.21257883f, 0.00880295f, 0.09716560f, -0.13291954f, 
    0.06107493f, -0.05678895f, -0.04578004f, 0.05228847f, 0.03956679f, -0.12744077f, -0.05173838f, 0.22020444f, 
    -0.03459444f, 0.04863074f, 0.06191581f, -0.05405909f, -0.17370431f, -0.09305359f, 0.21670072f, -0.06994197f, 
    0.07095583f, 0.06485333f, -0.04589238f, -0.08009139f, 0.03480021f, 0.19243208f, -0.08342180f, 0.02876465f, 
    0.02710193f, 0.04083249f, -0.14945699f, -0.15038949f, -0.01777128f, 0.05408622f, -0.04952064f, 0.06177522f, 
    0.17203450f, 0.14144145f, -0.13145667f, -0.15370230f, -0.04611329f, 0.00071836f, 0.19232962f, 0.05522457f, 
    -0.03894250f, -0.05461532f, 0.04888440f, 0.07856569f, -0.00283822f, 0.03236799f, 0.29316273f, 0.00206003f, 
    -0.38651568f, 0.20010448f, 0.03576756f, 0.21712169f, 0.18334387f, -0.13222343f, 0.03515244f, 0.04347878f, 
    -0.32326049f, -0.00561074f, 0.05362706f, 0.00970026f, -0.04035890f, -0.09248333f, -0.04500544f, -0.06849553f, 
    -0.42396343f, 0.20046295f, 0.11692557f, -0.23953398f, 0.18943791f, -0.10550888f, 0.14411795f, 0.15349291f, 
    -0.01620378f, 0.00028352f, -0.24635760f, 0.19503680f, -0.14946407f, -0.05345215f, -0.23378712f, 0.07500098f, 
    0.17966880f, 0.13825905f, 0.24973720f, 0.03104432f, -0.03443411f, 0.02174867f, 0.08452559f, 0.11870408f, 
    -0.14223249f, -0.23189622f, 0.14780496f, 0.02482739f, 0.04338476f, 0.06837396f, -0.10028968f, -0.05600045f, 
    -0.19229220f, -0.03645484f, -0.12920479f, -0.02737183f, -0.01756869f, 0.03413093f, 0.04862685f, -0.03120376f, 
    0.03760023f, -0.23315866f, -0.20241632f, -0.01485970f, 0.11678841f, 0.16954303f, -0.25549853f, 0.27667865f, 
    0.22263977f, -0.06311053f, -0.06086790f, 0.16055909f, 0.03239105f, 0.04765281f, -0.01778991f, 0.26113510f, 
    0.13559878f, 0.00010119f, -0.00000758f, 0.02130580f, 0.31169850f, -0.21941191f, -0.09541687f, 0.17124826f, 
    -0.28082088f, 0.15225253f, -0.07822933f, 0.48962891f, 0.13311635f, 0.16331528f, -0.19762242f, 0.00480494f, 
    0.04910620f, -0.00004933f, 0.02042244f, 0.00321429f, -0.09508406f, -0.08223660f, -0.01601142f, -0.00250096f, 
    0.03118243f, 0.04015099f, 0.08048744f, -0.08235949f, -0.02969806f, -0.04804964f, 0.05388761f, 0.00357528f, 
    0.06556933f, -0.04903701f, 0.03162903f, -0.05105945f, -0.02153032f, -0.00714323f, 0.03641114f, -0.03813807f, 
    0.04305147f, 0.01157612f, -0.08902452f, -0.04566243f, -0.08327446f, -0.04123975f, 0.07870717f, -0.02481850f, 
    -0.02716112f, -0.01227270f, 0.03079218f, -0.01686479f, -0.07519317f, 0.04003354f, -0.07501667f, 0.01852477f, 
    -0.04771505f, 0.06966784f, -0.08388089f, -0.01656805f, -0.02684628f, -0.01367319f, -0.03023987f, -0.03586243f, 
    0.02839641f, -0.01236400f, -0.01875860f, 0.04521541f, -0.08257269f, 0.01844126f, 0.05074428f, 0.06167695f, 
    -0.01969510f, -0.06506859f, 0.03067820f, 0.01363822f, 0.03704423f, -0.04280882f, 0.06391539f, 0.00533031f, 
    -0.04386761f, -0.05944166f, 0.00122148f, 0.05259186f, 0.00415894f, 0.04643758f, -0.07001371f, -0.01255509f, 
    -0.06731629f, 0.00434849f, -0.04181874f, -0.07613494f, -0.01055205f, 0.07169909f, -0.07246558f, -0.01469715f, 
    -0.01714127f, -0.01027613f, 0.02019118f, 0.05259458f, -0.07401464f, 0.06407668f, 0.07615273f, -0.06904469f, 
    0.04545150f, 0.00812905f, -0.00353794f, 0.04485186f, -0.08229163f, 0.07619154f, -0.04695668f, -0.01715386f, 
    0.03705296f, 0.00560416f, 0.03080538f, -0.02239494f, -0.09548284f, 0.01120284f, -0.06577347f, -0.05520559f, 
    0.08169577f, 0.08820505f, -0.07954622f, -0.07167157f, 0.03827400f, 0.07294176f, 0.03212149f, -0.03119992f, 
    0.05203625f, 0.02476772f, 0.00062993f, 0.01487425f, -0.00792970f, -0.09474450f, -0.07873932f, -0.08870617f, 
    0.07350811f, 0.04730257f, -0.00545129f, -0.01718049f, -0.01942130f, 0.04547725f, -0.02914244f, 0.08050904f, 
    -0.20577259f, 0.07192330f, 0.28382906f, -0.09326727f, -0.23850912f, 0.08888372f, -0.09680606f, -0.13692422f, 
    0.08481934f, -0.10482884f, -0.08037089f, 0.06889841f, 0.29523435f, 0.23864625f, 0.14870252f, 0.10971065f, 
    -0.02365994f, -0.48385000f, 0.24558228f, 0.08539778f, 0.13043454f, 0.19707608f, 0.01798017f, 0.03331154f, 
    0.09705938f, -0.05566486f, -0.30145893f, 0.15543601f, 0.08493048f, -0.22876640f, 0.15886098f, -0.11994362f, 
    0.16768968f, -0.24224873f, 0.06334285f, 0.10947680f, 0.07864018f, 0.17332776f, 0.26415730f, 0.14497663f, 
    -0.27001575f, -0.12130452f, -0.14759171f, 0.13951103f, -0.11374000f, -0.11174915f, -0.32581162f, -0.04045675f, 
    -0.12699315f, 0.08463337f, 0.14570817f, 0.24871786f, 0.08482884f, -0.02532330f, 0.03654452f, 0.04099812f, 
    -0.20002724f, -0.64069164f, -0.11735145f, -0.15244165f, 0.11300288f, -0.56798404f, 0.02393415f, 0.09029498f, 
    0.05285982f, 0.20452958f, -0.15525423f, 0.16774164f, -0.13061254f, 0.12565681f, -0.23730771f, -0.23772421f, 
    0.21939686f, 0.25244245f, 0.28188342f, 0.06487061f, -0.13384801f, -0.41080874f, 0.15616462f, 0.09357386f, 
    0.06318906f, 0.02356326f, 0.05346277f, -0.06007021f, -0.08805928f, 0.10674174f, 0.06714237f, -0.18980831f, 
    0.25084302f, -0.09020744f, -0.10391778f, 0.09388643f, -0.05122400f, 0.19399907f, 0.00860942f, -0.04481852f, 
    0.28473255f, -0.02759480f, -0.14772590f, 0.06563896f, 0.06612989f, -0.00785820f, -0.11449364f, 0.20762242f, 
    0.00483367f, -0.02770676f, 0.03680458f, 0.15336446f, -0.09553035f, 0.22313364f, 0.04557846f, -0.07801680f, 
    0.11875241f, 0.06585594f, -0.35919109f, -0.00974254f, 0.13500001f, 0.02049131f, 0.09637494f, -0.35951337f, 
    0.11811905f, -0.21720403f, -0.05779467f, 0.15279116f, -0.09643779f, -0.05109158f, -0.04521275f, -0.01080814f, 
    -0.10681946f, -0.06712317f, 0.03352648f, -0.06446992f, 0.04298259f, -0.11590909f, -0.13008443f, -0.06974033f, 
    0.05759134f, -0.01088526f, 0.04945748f, 0.03872357f, -0.05845348f, -0.13878520f, 0.05078074f, 0.06684379f, 
    -0.14251584f, -0.07381200f, -0.00658018f, 0.00159996f, -0.05799774f, -0.08435996f, 0.01635703f, -0.09074715f, 
    0.03011399f, -0.13087295f, -0.01528487f, 0.02778063f, -0.00951894f, 0.07680121f, -0.05042491f, -0.10806412f, 
    -0.00831331f, -0.06980304f, 0.06949589f, -0.10947099f, 0.03649032f, -0.01894495f, -0.10486177f, -0.08681959f, 
    -0.02820643f, -0.00833560f, 0.10397466f, -0.02431589f, -0.03264116f, 0.05343731f, 0.07472423f, -0.00045620f, 
    -0.04253553f, -0.03947856f, -0.09400215f, -0.00162688f, 0.01728242f, -0.08999764f, -0.03216541f, -0.10136866f, 
    -0.02909515f, -0.08577012f, 0.00783706f, -0.01184329f, -0.01051725f, 0.01489896f, -0.10320346f, -0.08293980f, 
    0.03170611f, -0.04292618f, 0.02167818f, -0.04019494f, -0.05670127f, -0.03781625f, -0.02318834f, 0.03148067f, 
    -0.13115607f, -0.07588086f, 0.04897749f, 0.03245013f, 0.01768520f, 0.03558318f, -0.04351409f, 0.02605896f, 
    0.05657329f, -0.07069729f, -0.12168522f, 0.05286142f, -0.07879058f, -0.05826503f, 0.00442259f, -0.05433977f, 
    0.11244749f, -0.07035482f, 0.06915747f, -0.03637337f, 0.06398489f, -0.10084157f, -0.06824720f, 0.06319954f, 
    -0.06315789f, 0.03955194f, -0.01943886f, -0.02369403f, -0.02014623f, -0.09763960f, -0.09118911f, 0.03440050f, 
    -0.05030232f, -0.06982926f, 0.06448697f, 0.05727508f, 0.02286464f, 0.01747569f, -0.03474973f, 0.00041080f, 
    -0.08772770f, -0.03370098f, 0.07228538f, 0.05301740f, 0.01339939f, -0.09571666f, -0.02156937f, 0.02284838f, 
    0.06237373f, -0.14099087f, -0.01658731f, 0.04370942f, -0.00680522f, -0.06118969f, 0.09382395f, 0.01495122f, 
    0.08452673f, 0.07727849f, 0.03699436f, -0.01089852f, -0.19607505f, 0.00528028f, 0.09564786f, 0.03056298f, 
    0.10578328f, 0.06182342f, 0.03155554f, -0.14941598f, 0.13035202f, 0.16119988f, 0.10460797f, 0.04857479f, 
    -0.00366112f, 0.10195448f, 0.09931185f, -0.24357289f, 0.18255112f, 0.13956062f, 0.04279183f, 0.05444024f, 
    0.05188424f, -0.00066562f, -0.14899072f, -0.08237378f, -0.06809109f, 0.18646991f, 0.18076479f, -0.04104802f, 
    0.01557772f, -0.05694935f, -0.01408515f, 0.18345641f, 0.03820201f, 0.05793740f, 0.05310251f, 0.00395585f, 
    -0.38775027f, 0.07895023f, 0.11065798f, 0.10469377f, 0.17425053f, -0.13455302f, 0.09533758f, -0.19440934f, 
    -0.15513968f, 0.03160637f, 0.09778237f, 0.00154696f, 0.18640283f, -0.00878499f, 0.02739947f, -0.07049714f, 
    -0.23413005f, 0.18380709f, -0.07434992f, -0.45683849f, 0.27532065f, -0.23550293f, -0.00201846f, 0.25571555f, 
    -0.02150898f, -0.02405718f, -0.23277107f, 0.15013513f, 0.02637986f, 0.00548078f, -0.32401177f, 0.10057104f, 
    0.30920833f, 0.07574233f, 0.12884809f, -0.04568949f, 0.00260330f, -0.08425865f, 0.01464163f, 0.14781018f, 
    -0.20708427f, -0.21878155f, 0.12415829f, 0.01213951f, 0.01526495f, -0.02449379f, -0.07568148f, -0.16926938f, 
    0.03192538f, -0.02524738f, -0.22371916f, 0.01335191f, 0.05619859f, 0.07767330f, -0.06566249f, 0.03059882f, 
    0.16476066f, -0.30520329f, -0.01173553f, -0.04895131f, 0.03744140f, -0.05607716f, -0.25093067f, 0.01890836f, 
    -0.04628947f, -0.04663287f, 0.02800901f, -0.03434595f, -0.13942714f, 0.11541786f, -0.07730862f, 0.08622006f, 
    0.06990337f, -0.06077005f, 0.01683157f, 0.00594243f, 0.20425138f, -0.20880219f, -0.22465912f, 0.26776981f, 
    -0.10565911f, 0.17395978f, -0.17015439f, 0.53384387f, 0.08718693f, 0.14239067f, -0.37188908f, -0.03500708f, 
    0.16906306f, 0.15185067f, 0.06594676f, -0.05860495f, -0.14407672f, -0.26925221f, 0.15439184f, 0.23077090f, 
    0.03183617f, 0.18752052f, -0.03725052f, -0.11629524f, -0.05412608f, 0.12785672f, 0.37929663f, 0.13797307f, 
    0.11116883f, 0.16000992f, -0.07978799f, 0.07163513f, -0.15475270f, -0.01373023f, 0.02504448f, 0.05609522f, 
    -0.41086861f, -0.12977348f, -0.33701816f, 0.00549778f, -0.01512262f, -0.05777785f, 0.03374479f, -0.09942478f, 
    -0.07812240f, 0.05361691f, -0.08268970f, 0.12452868f, 0.16611168f, 0.15278891f, -0.06540061f, -0.01259797f, 
    -0.06533904f, 0.05772655f, 0.02419304f, -0.00241057f, 0.25168234f, -0.19012339f, -0.02835743f, -0.18357520f, 
    -0.14042559f, -0.06388164f, 0.03356462f, 0.00159664f, 0.21467811f, 0.07726794f, -0.03679574f, -0.10537305f, 
    -0.01938871f, -0.00734810f, 0.02069707f, -0.33053172f, 0.07269837f, -0.32811460f, 0.06785958f, 0.16423175f, 
    -0.01521372f, -0.19439580f, 0.14102383f, 0.04266643f, -0.09508605f, -0.04395236f, -0.09623975f, -0.01138216f, 
    0.19529121f, 0.10343482f, 0.02176913f, -0.03760915f, -0.20506556f, -0.08174140f, -0.00008704f, 0.16469002f, 
    0.01782926f, 0.03197777f, 0.16645715f, 0.04671632f, 0.01052500f, -0.01718327f, 0.05124589f, -0.33473232f, 
    -0.11401709f, 0.04477575f, -0.39193422f, -0.03151025f, 0.03459668f, -0.10793660f, -0.01685207f, -0.06331027f, 
    0.01244049f, -0.03082499f, 0.08873694f, -0.04435589f, 0.15359415f, 0.28508046f, -0.18048866f, -0.14709044f, 
    -0.33589748f, -0.02391107f, 0.00977684f, -0.01269543f, 0.01623472f, -0.13536116f, 0.02060831f, 0.09268931f, 
    -0.08721404f, -0.03612307f, -0.19051003f, 0.05157801f, 0.18203771f, -0.24837931f, -0.08233617f, 0.10984891f, 
    0.15541159f, -0.00133755f, -0.26921204f, 0.43402669f, -0.09988268f, 0.07466494f, -0.39444920f, -0.06628190f, 
    -0.18141301f, 0.19443950f, 0.12815960f, -0.02635759f, -0.23257776f, -0.01250435f, 0.15736090f, -0.06486776f, 
    -0.07859758f, 0.31920388f, 0.03813323f, 0.17596985f, 0.05873707f, 0.08789627f, -0.04121390f, 0.06201649f, 
    0.08844550f, -0.05508962f, -0.29612890f, 0.06534635f, -0.16865295f, 0.06147647f, 0.02003560f, 0.21907201f, 
    0.17620644f, 0.07239089f, -0.35419315f, -0.15707479f, -0.06051087f, -0.13768947f, 0.15529972f, 0.04078247f, 
    0.09349664f, 0.07536406f, -0.00949237f, 0.14469159f, -0.03010488f, 0.10940956f, 0.34857386f, 0.06053244f, 
    -0.24444993f, 0.09151694f, 0.00805484f, 0.24484004f, 0.03433086f, 0.00154530f, -0.00102514f, -0.01223080f, 
    -0.18292667f, 0.01813414f, -0.08556803f, 0.06345400f, -0.04842952f, 0.03128662f, 0.06817478f, -0.13476579f, 
    -0.32649434f, 0.08580415f, -0.02668086f, -0.01908766f, -0.08657487f, -0.36211005f, 0.03230669f, 0.08656762f, 
    0.08629981f, -0.08935229f, -0.07613797f, 0.14967375f, -0.19480307f, 0.01023402f, 0.04967902f, -0.11046357f, 
    0.16156742f, 0.16382474f, 0.11828177f, 0.01254708f, 0.19610018f, -0.01815614f, 0.06530984f, -0.02936605f, 
    -0.09864540f, -0.13281809f, 0.26363918f, 0.02261201f, 0.00924837f, -0.02899840f, 0.02331943f, -0.11095680f, 
    0.13908888f, 0.12700647f, -0.08532277f, -0.06837683f, -0.04447169f, -0.10362792f, 0.08713159f, -0.05198769f, 
    -0.01049519f, 0.23953305f, 0.04350534f, 0.00252135f, 0.24533796f, 0.12011692f, -0.07505067f, 0.08799586f, 
    0.09045005f, -0.13471976f, -0.08263939f, -0.00922992f, 0.02836560f, -0.03208062f, -0.01548477f, 0.13020596f, 
    0.24677052f, 0.04352374f, 0.08964176f, 0.07833045f, 0.08447235f, -0.15070601f, -0.13917583f, -0.12756515f, 
    -0.39901152f, 0.20809846f, -0.17269701f, 0.04029965f, 0.14599411f, 0.04076516f, 0.03686839f, 0.00663088f, 
    0.02058971f, -0.00103584f, 0.04692083f, 0.01978680f, -0.07445946f, -0.06741574f, 0.01057094f, 0.05472194f, 
    0.01693270f, 0.02365258f, 0.04087693f, -0.07369667f, 0.05904734f, -0.04842683f, 0.05483111f, -0.00660853f, 
    -0.07983102f, -0.06520732f, 0.06172126f, -0.03374413f, 0.00099113f, -0.08121780f, 0.01534668f, -0.06855541f, 
    -0.00422261f, -0.11468577f, -0.08125100f, -0.04589461f, 0.03201569f, 0.01606251f, 0.01951639f, -0.08904129f, 
    -0.04468469f, -0.06838538f, 0.07352601f, -0.12217896f, 0.03596972f, -0.11390482f, -0.10307516f, 0.00715740f, 
    0.05186195f, -0.05950686f, 0.07432961f, -0.06395587f, -0.00436980f, -0.07724674f, 0.03086552f, 0.01173512f, 
    0.07600465f, 0.05920047f, 0.02026277f, -0.11185813f, -0.02460789f, -0.13524471f, -0.02178618f, -0.10466214f, 
    0.02084599f, -0.01505044f, -0.09259915f, 0.00509990f, -0.09330885f, -0.00095292f, -0.08143871f, -0.01332430f, 
    -0.07832833f, 0.01324137f, -0.00945957f, -0.07438853f, 0.01238549f, -0.07121175f, 0.02555009f, -0.03622766f, 
    0.02757080f, -0.07210309f, 0.05714814f, 0.06789850f, -0.06775223f, -0.09153301f, -0.01340498f, 0.01770483f, 
    -0.08002155f, 0.02479346f, -0.04389850f, 0.00456075f, -0.05569097f, -0.04925745f, -0.03892854f, 0.05454861f, 
    -0.05304170f, -0.02888049f, 0.00440407f, -0.08399181f, 0.00106432f, -0.10363640f, 0.01545439f, -0.05951097f, 
    -0.08919502f, -0.05606692f, 0.05175761f, 0.08342661f, 0.03993956f, -0.06518918f, -0.03009527f, 0.00528971f, 
    -0.01406431f, 0.08070661f, 0.05811125f, -0.08183167f, -0.07744627f, -0.01287846f, -0.00614448f, -0.00159648f, 
    -0.00830738f, -0.02509162f, 0.04039862f, 0.04503278f, -0.02314998f, 0.04606184f, 0.03304392f, 0.02326595f, 
    -0.00279565f, -0.01942140f, -0.02807065f, 0.04435831f, -0.08269360f, 0.00593851f, -0.02079191f, -0.03809882f, 
    -0.41380119f, -0.15090244f, 0.01262503f, -0.06244946f, 0.11574420f, 0.00332320f, -0.03473177f, -0.15730038f, 
    0.24256970f, -0.10367242f, -0.05864237f, 0.33093840f, 0.08910687f, 0.09007183f, -0.46657187f, -0.00684407f, 
    0.15870288f, -0.31414196f, -0.08434296f, -0.53401327f, 0.16068338f, 0.10770028f, -0.08634872f, 0.00629278f, 
    0.38789007f, 0.06552817f, -0.32947117f, -0.07917079f, -0.01919712f, 0.15356813f, 0.23307741f, 0.13636947f, 
    -0.05466688f, -0.03891604f, 0.05594938f, -0.12476833f, 0.12615535f, 0.01312228f, 0.17137398f, -0.08602344f, 
    -0.40228906f, -0.10625158f, -0.02602143f, 0.25241438f, -0.07646031f, 0.38553300f, 0.05756212f, -0.00380149f, 
    0.06825940f, -0.06544139f, 0.03676407f, -0.08840928f, -0.20787840f, -0.05749213f, -0.07436696f, -0.06716903f, 
    -0.58332312f, -0.22468975f, -0.07612129f, -0.07970217f, -0.06315527f, 0.15492454f, -0.01082174f, 0.17890763f, 
    0.05957810f, 0.11297690f, -0.52629244f, 0.15356581f, -0.08077572f, 0.08351844f, -0.42076784f, 0.33418527f, 
    -0.07880733f, 0.00061866f, 0.33924097f, 0.15264250f, 0.11837120f, 0.04162520f, -0.15070309f, 0.10423756f, 
    -0.27636161f, -0.34888780f, -0.13470957f, 0.01955782f, -0.00674580f, 0.32443312f, -0.04065337f, 0.07384598f, 
    -0.14735958f, 0.09713113f, 0.14857675f, 0.04887579f, -0.08508318f, -0.12793608f, -0.05601527f, -0.07875411f, 
    -0.00168052f, -0.57977307f, -0.04409277f, -0.03974871f, -0.09306753f, -0.01277929f, -0.07072729f, 0.11535574f, 
    0.52180040f, 0.02509445f, -0.07172868f, 0.07183421f, 0.08436982f, -0.02614948f, -0.05992689f, 0.08094975f, 
    -0.21674354f, 0.05045781f, 0.21897338f, -0.02664197f, 0.20362416f, -0.00390873f, 0.04756121f, 0.25152117f, 
    -0.18172440f, 0.18056603f, -0.05255508f, 0.41473037f, 0.36226451f, 0.13513979f, -0.37298170f, 0.01601680f, 
    0.03784784f, -0.05324214f, -0.06999853f, 0.06330713f, -0.03628703f, 0.04863195f, 0.02733182f, -0.06768544f, 
    -0.07105448f, -0.06865237f, 0.00704083f, -0.07128638f, -0.01200167f, 0.07685409f, -0.04102537f, -0.04688930f, 
    0.03014811f, -0.12693612f, 0.04555722f, 0.03831866f, -0.09623595f, -0.05806839f, -0.07939567f, -0.04750959f, 
    -0.08572479f, -0.05009985f, 0.04883438f, 0.04038944f, -0.05620930f, 0.03699647f, 0.07117074f, -0.00614627f, 
    0.01178241f, 0.03500530f, 0.04491658f, -0.00023755f, -0.01664942f, -0.04188438f, 0.02586894f, 0.05237802f, 
    0.00925986f, -0.02421236f, 0.00110910f, 0.06071623f, 0.06425196f, 0.01416470f, 0.07140978f, -0.07656985f, 
    0.07664322f, -0.02256533f, -0.09110767f, -0.12887040f, -0.02166934f, 0.00996392f, 0.04133523f, -0.08680680f, 
    0.02733084f, -0.01690484f, -0.02631119f, -0.10293534f, -0.09597663f, -0.02210882f, -0.02042644f, -0.06258754f, 
    0.06850552f, 0.03355261f, 0.04686536f, -0.06414865f, 0.03255052f, 0.07192913f, -0.07773662f, -0.06528471f, 
    0.03266540f, 0.04737718f, -0.07164668f, -0.03651524f, 0.03422050f, 0.01856107f, 0.00545089f, -0.00821765f, 
    0.04814034f, -0.08611583f, 0.02790034f, 0.07646021f, 0.00919855f, -0.01358046f, 0.01439494f, -0.05184865f, 
    -0.09029160f, -0.06101974f, 0.00824360f, -0.10256453f, -0.01615739f, -0.09619755f, -0.07711414f, -0.05382029f, 
    -0.03510049f, 0.03666308f, 0.04822824f, -0.07484650f, 0.02799087f, -0.02858595f, 0.06246432f, -0.10924593f, 
    -0.00194149f, -0.07441746f, 0.03385048f, -0.11465533f, -0.08784160f, -0.03117501f, 0.08780500f, -0.01763723f, 
    -0.04900109f, -0.05083419f, -0.06808554f, -0.05945256f, 0.00005177f, -0.07102137f, 0.07648558f, -0.04681894f, 
    -0.06658406f, -0.02308765f, -0.11814805f, -0.06371322f, 0.00580348f, 0.07325400f, -0.13815862f, -0.08777522f, 
    0.01450869f, 0.06582096f, 0.04403710f, -0.02390398f, 0.00052249f, -0.02822517f, 0.03079319f, -0.21304138f, 
    -0.02542087f, 0.14010958f, 0.02110471f, 0.09329055f, -0.16163179f, -0.09702314f, -0.02732432f, -0.06824335f, 
    -0.01070469f, 0.01906984f, -0.26923490f, 0.05709429f, -0.28810325f, 0.07415832f, -0.09322500f, -0.14855188f, 
    -0.48167276f, 0.05887461f, -0.14875713f, 0.05904531f, 0.07141463f, 0.01085133f, 0.11992015f, 0.03653078f, 
    -0.22549798f, -0.08276498f, 0.05731409f, -0.05110345f, -0.13263066f, 0.01704996f, 0.10503970f, 0.39329123f, 
    -0.09592775f, 0.25435194f, 0.02774645f, 0.09446428f, 0.14421842f, 0.03173648f, 0.00869850f, -0.03450439f, 
    -0.28898382f, 0.08390523f, -0.08926859f, 0.11622224f, 0.05765410f, 0.03295285f, -0.06024883f, 0.09794452f, 
    -0.02557381f, 0.07198945f, 0.07029779f, 0.02206420f, 0.07997345f, 0.02953359f, 0.02151196f, -0.05277777f, 
    -0.00786389f, -0.22408769f, 0.00597653f, -0.03639787f, 0.24197452f, -0.06300735f, 0.06753068f, 0.20718417f, 
    0.09732515f, 0.05001593f, 0.11972891f, -0.21615863f, 0.07199062f, 0.35215425f, 0.01864192f, 0.05909261f, 
    -0.07369152f, -0.11502174f, 0.09994438f, -0.13444075f, -0.05381697f, 0.19993307f, -0.01951974f, 0.02898867f, 
    -0.17297338f, 0.01347094f, -0.26679826f, 0.03929183f, 0.12087390f, 0.03902849f, 0.06875568f, -0.01539870f, 
    -0.08040848f, 0.00283125f, -0.02331983f, -0.01731821f, -0.00860965f, 0.61260802f, -0.01862234f, 0.14848271f, 
    0.02980483f, -0.00236372f, 0.08157445f, 0.00618364f, 0.15917486f, -0.18767482f, -0.02633439f, 0.11026071f, 
    0.05302160f, -0.02090976f, 0.01837616f, -0.07321888f, 0.25504470f, 0.12718292f, -0.07786627f, 0.09005105f, 
    -0.21895900f, 0.21590129f, -0.21697918f, 0.13203289f, 0.16878718f, -0.02696948f, -0.16649203f, -0.04956876f, 
    -0.07299188f, -0.08506519f, -0.03396403f, 0.08505408f, -0.08671903f, -0.04350285f, -0.05552314f, 0.06201569f, 
    -0.04015332f, 0.02685877f, 0.04205420f, -0.00985437f, 0.00314155f, -0.07269585f, -0.04650694f, -0.08440266f, 
    0.03988258f, 0.03906494f, 0.00165439f, 0.08104619f, 0.02785642f, 0.05502998f, 0.06964044f, -0.08381606f, 
    0.06567390f, -0.06167326f, -0.02934545f, 0.01597967f, -0.08765195f, -0.00603868f, 0.01695442f, 0.07068039f, 
    -0.04694101f, -0.01002169f, -0.07839990f, -0.04588466f, -0.04023474f, 0.04869923f, 0.05085618f, -0.02700930f, 
    0.06263461f, -0.02379005f, 0.02080524f, -0.08812948f, 0.02935498f, -0.03809987f, 0.00030183f, -0.08786620f, 
    -0.08422302f, -0.00130673f, -0.04622221f, -0.06161618f, 0.02615058f, 0.01020300f, 0.04500105f, 0.08588910f, 
    0.01440517f, -0.05630543f, 0.05179935f, 0.02248922f, 0.00646850f, -0.07708316f, -0.08810553f, 0.00031762f, 
    0.05848165f, -0.03527019f, 0.07087941f, -0.07039288f, -0.07577996f, -0.06281616f, -0.07824184f, -0.03202512f, 
    0.07127859f, -0.05565454f, 0.06173864f, -0.04168631f, 0.00998773f, -0.08317105f, 0.08572829f, -0.07246923f, 
    0.00037049f, 0.01990837f, -0.05078446f, -0.04941360f, -0.01530056f, -0.05883209f, -0.03621315f, -0.04815041f, 
    0.05343991f, -0.05616097f, 0.03403453f, 0.00133413f, -0.05702895f, -0.06519132f, -0.00841429f, 0.01945435f, 
    -0.04574730f, 0.04215487f, -0.05982753f, -0.02195379f, -0.07816125f, 0.01021087f, -0.08769339f, 0.06860048f, 
    0.06816314f, -0.04874618f, -0.03571397f, -0.01987668f, 0.02827550f, 0.08710050f, -0.03423086f, -0.03531184f, 
    -0.03541473f, 0.02884950f, -0.04230667f, -0.05288357f, -0.03012739f, 0.08489898f, 0.01125456f, -0.02879320f, 
    -0.08360458f, 0.03112229f, -0.05489054f, -0.05447399f, 0.04289030f, 0.01350209f, -0.01901448f, 0.00497053f, 
    0.05966267f, -0.00239498f, -0.09085471f, -0.04351609f, -0.10037017f, -0.13621490f, -0.00217193f, -0.03671230f, 
    -0.08723065f, 0.07649720f, 0.06286714f, -0.02121495f, 0.03736177f, -0.06336750f, 0.02409381f, -0.00151251f, 
    -0.02317607f, 0.02325636f, -0.07248683f, -0.04862250f, 0.02519082f, -0.06094337f, -0.04769995f, -0.09468802f, 
    -0.00713586f, -0.02995741f, 0.08433562f, -0.09499873f, 0.06852265f, -0.04696418f, -0.08038136f, -0.11786148f, 
    -0.02153163f, -0.04696240f, 0.02980844f, -0.05461231f, -0.02796194f, -0.02506544f, -0.00079050f, -0.11460427f, 
    -0.09062059f, 0.07867575f, -0.05166313f, -0.07787656f, 0.00330535f, 0.02584198f, 0.12161953f, -0.04206914f, 
    0.01887341f, 0.03954734f, 0.06033204f, -0.08807728f, -0.09421578f, -0.08222041f, -0.06861924f, 0.01476483f, 
    -0.09412675f, 0.03386197f, 0.06436916f, 0.05963130f, -0.05999208f, 0.01300879f, -0.06191358f, -0.00304236f, 
    -0.00073072f, -0.04098633f, -0.01784667f, -0.03254671f, 0.02939612f, -0.09084010f, -0.02409513f, -0.08133151f, 
    -0.06831382f, -0.08348302f, 0.00434260f, -0.05342549f, -0.03781951f, 0.09653256f, -0.00079664f, -0.01286307f, 
    -0.04869212f, 0.00773749f, -0.07471435f, -0.07003162f, -0.06192296f, -0.06760883f, 0.06189226f, 0.01529760f, 
    -0.01584926f, -0.11919948f, -0.05671668f, -0.08633378f, 0.00107469f, 0.04411759f, -0.00605995f, 0.00806362f, 
    -0.10609417f, 0.05582049f, -0.09007796f, 0.06500310f, 0.04003516f, -0.03525218f, -0.03148454f, -0.06735880f, 
    -0.01518421f, 0.01524507f, -0.06095225f, -0.08054351f, -0.00824648f, -0.05456667f, -0.06653632f, -0.10605689f, 
    -0.04570018f, -0.05091312f, -0.04686519f, 0.06937202f, 0.05541675f, -0.01029982f, 0.04639796f, -0.05020970f, 
    0.08890881f, 0.00100973f, 0.03786560f, -0.03072625f, -0.09171662f, -0.10585956f, 0.02349775f, -0.02368773f, 
    -0.05123342f, -0.00837828f, -0.08067914f, 0.00794996f, -0.08967867f, -0.00298739f, 0.05187117f, -0.05389701f, 
    -0.04563861f, 0.06966089f, -0.08280283f, -0.03369799f, 0.05384219f, 0.07430023f, 0.00119194f, -0.08801993f, 
    -0.08826338f, -0.06267937f, -0.02279389f, 0.04491634f, 0.02367711f, -0.04434153f, 0.01557641f, 0.04986758f, 
    -0.02279677f, -0.08683647f, -0.05883110f, 0.00193156f, -0.04486509f, 0.03370481f, -0.05653978f, -0.08700108f, 
    -0.11984907f, -0.00647293f, -0.07336415f, -0.02751217f, 0.02042565f, -0.01980124f, 0.03416699f, 0.01175359f, 
    -0.10447085f, 0.02795931f, -0.01946928f, -0.03911636f, 0.02046928f, -0.00579073f, -0.02464785f, 0.00580480f, 
    0.07756348f, -0.06103098f, 0.06570300f, 0.01436418f, 0.02710428f, -0.10782915f, -0.01870770f, 0.04337205f, 
    -0.09579229f, -0.06034196f, -0.05788945f, 0.04765015f, -0.01014354f, -0.08670077f, -0.06817286f, -0.06205742f, 
    0.01583721f, 0.04197865f, -0.11529361f, 0.04943787f, 0.04029889f, -0.00222448f, 0.03315569f, 0.07048049f, 
    -0.04266975f, -0.09335111f, -0.01633442f, 0.02816084f, -0.00731628f, 0.08790974f, -0.02394998f, 0.04307710f, 
    -0.04929038f, -0.10047374f, 0.00667915f, 0.07013953f, -0.06649804f, 0.01186538f, -0.01790802f, 0.01489421f, 
    -0.08793990f, -0.07984213f, 0.06967532f, -0.05804168f, -0.05578217f, -0.00782286f, -0.07912906f, 0.06665161f, 
    -0.05048703f, -0.08284990f, -0.03419903f, -0.00077170f, 0.03256817f, 0.03208980f, -0.01683286f, 0.00865009f, 
    -0.07176884f, -0.01968764f, 0.00114732f, -0.06399050f, -0.08245201f, -0.08678143f, -0.02172431f, 0.02153029f, 
    -0.05947906f, -0.06959324f, -0.04295475f, 0.02360429f, -0.04255815f, 0.02657705f, 0.03310053f, -0.09275215f, 
    -0.05058648f, -0.03313500f, -0.00362399f, -0.02090015f, 0.04804107f, -0.05131133f, 0.03462487f, -0.07190502f, 
    -0.40068588f, 0.11163176f, -0.13725471f, -0.06701776f, -0.05743861f, -0.01655046f, -0.01848295f, -0.02416443f, 
    0.04279742f, -0.23856878f, -0.01685199f, 0.10651705f, 0.30889052f, 0.09121770f, -0.08225295f, 0.02687812f, 
    -0.04160530f, -0.25583631f, 0.22222152f, -0.21511520f, 0.33200186f, 0.15117335f, 0.08577789f, -0.10391565f, 
    0.21540415f, -0.00565708f, 0.07722012f, 0.08077553f, -0.18616542f, 0.43216264f, -0.00005727f, 0.04592921f, 
    0.13025504f, -0.21807013f, 0.02171251f, -0.10775340f, 0.03745792f, 0.11043230f, 0.24412243f, -0.10451885f, 
    -0.29393998f, 0.04600930f, 0.06739671f, 0.22181964f, -0.03965200f, -0.02047314f, 0.13469481f, -0.07319584f, 
    -0.21723643f, -0.02439996f, 0.31514511f, 0.18824352f, -0.03092112f, -0.25537562f, 0.01907950f, 0.19629203f, 
    -0.06038838f, 0.20297128f, -0.05143946f, -0.03323359f, 0.28877848f, 0.27710834f, 0.07118861f, -0.02071714f, 
    0.08118656f, 0.36184067f, -0.27540857f, 0.08944217f, -0.14771537f, 0.17722715f, -0.22356305f, -0.05284784f, 
    0.07485466f, -0.09934518f, 0.04065669f, 0.05404406f, 0.22408009f, 0.11117602f, -0.13663176f, -0.01401897f, 
    -0.14958560f, -0.22606531f, -0.08271918f, 0.08303671f, -0.10303167f, -0.22971974f, -0.26803982f, 0.14855604f, 
    -0.00208321f, 0.01811270f, -0.08715554f, 0.24787639f, 0.10744850f, 0.10441490f, 0.05529410f, 0.07281706f, 
    0.19227944f, -0.15673754f, -0.22445562f, 0.04067293f, -0.04921608f, 0.34783095f, -0.05314010f, 0.16965069f, 
    0.29456085f, -0.03047929f, -0.00022869f, 0.17220584f, 0.08209469f, 0.29183868f, 0.07066702f, 0.08681237f, 
    -0.00079562f, -0.07091226f, 0.00238653f, -0.10938415f, 0.22738405f, 0.09042965f, -0.04792098f, 0.36359352f, 
    -0.01939764f, 0.19047929f, -0.00095574f, 0.27912191f, 0.09318199f, 0.10207415f, -0.22490142f, -0.22650892f, 
    -0.05376540f, 0.04313319f, -0.00583083f, 0.04130097f, -0.01692327f, 0.02707018f, -0.12462603f, -0.09081219f, 
    -0.06316074f, 0.01013052f, -0.05428686f, 0.05063674f, -0.08637239f, -0.06798334f, 0.01330919f, 0.04335283f, 
    0.05505748f, 0.02492981f, -0.03663386f, 0.04883287f, -0.03866633f, -0.11587238f, -0.00319338f, 0.03463572f, 
    0.00334030f, -0.02254180f, -0.10867569f, -0.00992129f, 0.00535908f, -0.00100846f, 0.07414155f, 0.00176783f, 
    -0.11177963f, -0.11491989f, -0.06983414f, 0.02404243f, 0.06305911f, -0.07696816f, -0.01773913f, 0.00718879f, 
    -0.01523599f, -0.02910660f, -0.02056490f, -0.05121254f, -0.02853158f, 0.05178607f, -0.05973586f, -0.05067993f, 
    -0.03551267f, 0.07050736f, -0.06468324f, -0.07044881f, -0.06884025f, -0.04925690f, 0.01231762f, -0.00710253f, 
    -0.09441791f, -0.06365630f, -0.07203269f, -0.01380908f, 0.08222872f, -0.04947150f, 0.04079437f, -0.01353146f, 
    0.07308144f, 0.01079662f, -0.05480128f, -0.00171875f, -0.01806580f, -0.05069501f, -0.03014469f, 0.06884336f, 
    -0.00995131f, -0.06471887f, -0.00900326f, -0.08433773f, -0.03410072f, 0.03273182f, -0.06634577f, 0.02974057f, 
    0.01198129f, -0.04578856f, -0.04886701f, 0.07078254f, -0.03238512f, -0.09640525f, -0.05154434f, -0.11026847f, 
    0.06835361f, -0.03291171f, 0.02656721f, 0.03259008f, -0.00047804f, -0.07952861f, 0.06319262f, 0.01554190f, 
    0.04651409f, -0.06117124f, 0.04187667f, 0.05350518f, -0.00459192f, -0.08103998f, -0.03113869f, -0.02645059f, 
    -0.05808276f, 0.01833007f, 0.01546122f, -0.07800204f, 0.05628550f, -0.04104502f, 0.00025071f, 0.03182204f, 
    0.00081761f, 0.06688576f, -0.07869122f, -0.00676419f, -0.00727418f, -0.11616781f, -0.11529462f, -0.05505387f, 
    0.04685774f, -0.06813143f, 0.05301342f, -0.07325693f, -0.07567467f, 0.07726528f, 0.01352325f, -0.04940248f, 
    -0.27155730f, -0.06890409f, 0.01838110f, 0.07955510f, 0.09031200f, 0.29154691f, -0.18639126f, 0.08160138f, 
    -0.20685431f, -0.04266253f, -0.06886040f, 0.10995729f, -0.01303044f, -0.06083515f, -0.51574057f, 0.00865914f, 
    0.08939972f, -0.13328861f, 0.04745062f, -0.06300549f, 0.33104998f, -0.16941682f, -0.00091637f, 0.25309020f, 
    -0.06856122f, -0.18472968f, -0.00225648f, 0.18128929f, 0.28782621f, -0.00512285f, 0.23882477f, 0.12837230f, 
    -0.05190914f, 0.04153180f, 0.08201956f, -0.10482828f, 0.06526995f, -0.02299119f, -0.10869298f, 0.20857821f, 
    -0.06586659f, -0.21602714f, 0.08494376f, -0.07121177f, -0.18776655f, -0.33279553f, -0.05771057f, 0.19335847f, 
    0.40592062f, -0.04929271f, -0.24219708f, -0.03870835f, 0.19711560f, -0.16212864f, -0.05386532f, 0.10807457f, 
    0.05579773f, -0.14220691f, -0.01483664f, -0.02725003f, 0.09367464f, -0.12365361f, -0.10302286f, 0.06152468f, 
    0.06834810f, 0.25534251f, -0.13300009f, 0.08943994f, 0.47989020f, 0.12020566f, 0.26450765f, 0.08780783f, 
    -0.32869336f, -0.02729462f, 0.18549919f, 0.02074248f, -0.11467646f, -0.26401025f, -0.36228734f, -0.11228562f, 
    0.01352575f, 0.01217952f, -0.26818880f, -0.08485743f, 0.00507810f, -0.23189597f, 0.23736604f, -0.31786022f, 
    0.23254013f, 0.05718440f, 0.30808967f, 0.07177277f, 0.10380410f, 0.10041727f, -0.03638275f, 0.08281054f, 
    -0.03564813f, -0.25921375f, 0.47512400f, 0.02703538f, -0.04189039f, 0.02785842f, 0.19221587f, -0.08616322f, 
    0.17806469f, 0.05783812f, 0.00058735f, -0.09137683f, 0.06918909f, 0.17420833f, -0.00235101f, -0.05090545f, 
    -0.02704011f, 0.05111877f, 0.07690342f, -0.00774329f, -0.16925205f, 0.40404972f, 0.18377894f, -0.15356122f, 
    0.02165175f, -0.22249979f, 0.07616828f, -0.43114993f, -0.08542007f, 0.14501703f, -0.45926568f, 0.38220403f, 
    0.10403126f, 0.13694350f, 0.09907178f, -0.07100405f, -0.15126835f, -0.28597757f, 0.09559695f, 0.05549007f, 
    -0.03569582f, 0.30286476f, -0.05743320f, 0.28149065f, -0.15866545f, -0.01393080f, 0.27463946f, 0.12263377f, 
    -0.01771264f, 0.10542876f, -0.23818895f, -0.06189007f, -0.11709475f, -0.04142008f, -0.04369606f, -0.05408818f, 
    -0.07590081f, -0.10719713f, -0.16840383f, 0.05553027f, 0.03824800f, 0.05253058f, 0.13471757f, -0.00532595f, 
    -0.01973651f, -0.02617047f, 0.00920754f, -0.00332721f, 0.10635090f, 0.18840072f, 0.21847710f, -0.05033598f, 
    -0.39543384f, 0.14125346f, 0.03312267f, -0.01206108f, 0.20638029f, 0.01591704f, 0.11356284f, -0.07772045f, 
    -0.20399989f, -0.02861402f, -0.10713653f, 0.02010954f, 0.04737271f, 0.22531740f, -0.06242990f, -0.14137129f, 
    -0.16344967f, 0.21850160f, 0.18237254f, -0.09688622f, -0.02120291f, -0.08715054f, -0.16424298f, 0.07151734f, 
    0.03578767f, -0.17297341f, 0.05715890f, 0.10314509f, -0.03419422f, 0.09033675f, -0.14306727f, 0.09676465f, 
    0.14412668f, 0.14061597f, -0.03284957f, -0.03134062f, 0.06268663f, -0.02826915f, 0.16651070f, 0.11038131f, 
    0.03893549f, -0.08325657f, 0.30472845f, 0.00674178f, 0.06701718f, -0.04535783f, 0.03583731f, 0.05557481f, 
    0.08156352f, 0.14052795f, -0.34196275f, -0.03031254f, -0.06493244f, 0.06370214f, -0.01445531f, -0.02420583f, 
    -0.12108595f, 0.07355566f, -0.00436875f, 0.04554695f, 0.03045133f, 0.69213086f, 0.00024272f, -0.19537480f, 
    -0.35187900f, -0.00885804f, 0.07922993f, -0.04321755f, 0.14824353f, 0.10746651f, -0.07457270f, 0.24344593f, 
    0.07586472f, -0.05616607f, -0.22975427f, 0.03418346f, 0.22753347f, -0.32526216f, 0.03433495f, 0.42145196f, 
    0.04666253f, 0.15734984f, -0.40929946f, 0.22896691f, -0.00633392f, 0.07180300f, -0.12961248f, -0.01950740f, 
    -0.06830762f, -0.00449737f, -0.08532698f, 0.03223116f, -0.08816039f, 0.05523473f, -0.00071036f, -0.01353992f, 
    -0.07923389f, -0.01684500f, -0.06800129f, -0.00208370f, -0.08773412f, -0.01695485f, 0.03248271f, -0.09526177f, 
    0.05000199f, -0.03332334f, -0.05972274f, -0.02488884f, -0.06909463f, 0.04362212f, 0.07436147f, -0.00940584f, 
    -0.03081212f, 0.04213612f, -0.05452998f, -0.09255672f, -0.10612131f, -0.05731038f, -0.04423654f, 0.03204973f, 
    -0.03537875f, -0.05857868f, 0.08017913f, -0.05625789f, -0.05259959f, -0.06129104f, -0.03427904f, -0.00010920f, 
    0.06546725f, -0.05945554f, 0.01957683f, -0.02086392f, -0.00251385f, -0.04049617f, 0.03517231f, -0.08882440f, 
    -0.07793119f, 0.07086167f, -0.00938099f, 0.04640533f, -0.09461648f, -0.09703454f, 0.06689843f, 0.00274460f, 
    -0.01224920f, 0.08147079f, -0.04947400f, 0.03797958f, -0.01305847f, 0.02775011f, 0.03850883f, -0.02341444f, 
    0.03132267f, -0.03767579f, -0.01880078f, -0.11048371f, 0.03393523f, -0.11399876f, 0.04851871f, 0.05597564f, 
    0.03021135f, -0.06462801f, -0.11849055f, -0.04258243f, 0.06348622f, 0.04007812f, -0.00137412f, 0.04756160f, 
    -0.02052905f, 0.03914474f, 0.02750795f, -0.03240920f, 0.03449306f, -0.07396724f, 0.03768708f, 0.04117840f, 
    0.01121855f, -0.10046308f, 0.02134988f, -0.11536115f, 0.04148274f, -0.10219481f, 0.03791482f, -0.00404387f, 
    -0.08327030f, -0.03555648f, 0.05109753f, -0.05769032f, -0.02287131f, 0.01235749f, 0.04419977f, -0.01270508f, 
    -0.01470310f, 0.05265399f, -0.04233394f, 0.04134207f, 0.05244372f, 0.03422439f, -0.04964560f, -0.04783827f, 
    0.02265362f, 0.07410664f, 0.04563046f, 0.08416785f, -0.06631681f, -0.00293262f, 0.06470638f, -0.04128560f, 
    -0.05466582f, -0.01457233f, 0.04971389f, -0.00352580f, 0.00825599f, 0.03831779f, -0.04898221f, 0.00128662f, 
    -0.37109604f, -0.23187089f, 0.02406414f, -0.01635338f, 0.15462676f, 0.24421425f, -0.34571400f, 0.08396646f, 
    -0.15091763f, -0.32123655f, 0.07038014f, -0.02195128f, 0.17164984f, -0.18905930f, -0.31200767f, 0.10274075f, 
    0.12430179f, -0.00793456f, 0.16822980f, 0.00392726f, 0.06441396f, -0.06196834f, -0.04449168f, 0.08352293f, 
    -0.21401541f, -0.05763787f, -0.14521344f, 0.16709426f, 0.18077391f, 0.28578004f, -0.09290596f, -0.03255351f, 
    0.10054959f, -0.13135594f, -0.00262988f, -0.08546024f, -0.00098126f, -0.06464499f, -0.11363196f, 0.26215115f, 
    -0.04609708f, -0.05438211f, 0.11788141f, -0.10795646f, -0.07817928f, -0.52073771f, 0.13413997f, -0.06250520f, 
    0.18611594f, 0.05858946f, 0.05188922f, 0.15258665f, 0.11359150f, -0.35475037f, -0.05073689f, 0.12773868f, 
    0.23717064f, -0.39010277f, 0.05783445f, 0.07720310f, 0.23066509f, -0.12137436f, -0.06605121f, 0.05953197f, 
    0.04614896f, 0.22604395f, -0.01434829f, 0.08148501f, 0.33174601f, 0.15254696f, 0.09510894f, 0.10204332f, 
    -0.16599026f, -0.01492138f, -0.03545704f, 0.02876918f, -0.10687997f, 0.06930757f, -0.41090837f, 0.21737628f, 
    -0.12740962f, -0.04544246f, -0.25534740f, 0.02116160f, -0.03084497f, -0.04856652f, 0.05086030f, -0.55518001f, 
    -0.12027024f, -0.06963137f, 0.08936618f, 0.26598969f, 0.36324954f, -0.01890731f, 0.00010194f, 0.03438813f, 
    0.07337487f, -0.08417021f, 0.06548428f, 0.02471455f, -0.01409753f, -0.16751702f, 0.06935640f, 0.20516711f, 
    0.07893204f, -0.04727604f, 0.08173586f, -0.01589053f, 0.01041372f, 0.27227983f, -0.03045386f, -0.18458550f, 
    -0.13641629f, -0.06681978f, 0.35493672f, -0.08451971f, -0.07067573f, 0.44744870f, 0.04700145f, -0.10376695f, 
    0.10709962f, -0.27821934f, 0.08202671f, -0.24697600f, -0.01430508f, 0.09859262f, -0.14956877f, 0.19104083f, 
    -0.33754143f, -0.25242707f, -0.03800298f, 0.06818512f, -0.06718805f, 0.28297070f, -0.02665957f, -0.04467711f, 
    -0.05445772f, -0.17990237f, -0.06404771f, 0.05359018f, 0.32781398f, 0.11151264f, -0.66174030f, 0.06401339f, 
    0.21227132f, -0.09657950f, 0.18949030f, -0.44180134f, 0.30962950f, 0.13312782f, -0.02406953f, 0.11616509f, 
    0.21339887f, 0.14678288f, -0.55815977f, 0.12950216f, 0.00088369f, 0.26240048f, 0.18542607f, 0.08254814f, 
    -0.04937005f, -0.17053084f, -0.01102276f, -0.12460551f, 0.00982109f, -0.20013681f, 0.24814747f, 0.04921152f, 
    -0.17806187f, -0.16447337f, 0.17833728f, 0.11770871f, -0.09258483f, 0.29545143f, 0.07319043f, 0.11059655f, 
    0.01480193f, 0.00647858f, 0.15222320f, -0.08932500f, -0.07395768f, -0.42826524f, 0.01908580f, 0.07052091f, 
    -0.49802166f, -0.07309043f, -0.08594084f, -0.01871297f, 0.19765887f, 0.04200023f, 0.08000313f, 0.15473184f, 
    -0.06185514f, 0.25302345f, -0.41683492f, -0.00679486f, -0.14812507f, 0.07327767f, -0.19204764f, 0.20044875f, 
    -0.09227908f, 0.07734963f, 0.22520700f, 0.01916783f, 0.04912656f, 0.18285170f, -0.38599962f, 0.01267664f, 
    -0.22482365f, -0.13894163f, -0.46895972f, 0.08697443f, 0.02992262f, -0.09747948f, 0.00012398f, 0.20990580f, 
    0.23821165f, -0.05144620f, 0.33074835f, 0.13724247f, -0.13857682f, -0.01966817f, -0.08115674f, 0.05991640f, 
    0.14625774f, -0.62639362f, -0.07847641f, 0.04162719f, -0.10460082f, 0.04362885f, 0.03742523f, 0.28537273f, 
    0.52262658f, 0.07729689f, -0.02559338f, 0.01609330f, 0.04171687f, 0.09247757f, 0.05233370f, 0.09972754f, 
    0.11852750f, 0.00125885f, 0.02035140f, -0.06783230f, 0.12090667f, 0.11902315f, 0.04811861f, 0.08114745f, 
    0.04924089f, 0.04109889f, 0.16769852f, 0.04597956f, 0.37043992f, 0.07718308f, -0.30114904f, 0.02082761f, 
    0.06993847f, 0.08509190f, -0.00309731f, 0.07245526f, -0.24231331f, 0.17770591f, 0.09117853f, -0.42581701f, 
    0.29066294f, -0.39117289f, 0.05200155f, 0.07584251f, 0.01386195f, 0.27023461f, -0.07571725f, -0.02773128f, 
    -0.09439591f, 0.04962637f, 0.12414631f, -0.15033247f, 0.24626844f, 0.29827097f, 0.08969440f, -0.14504200f, 
    -0.13781601f, 0.17172925f, 0.37965941f, -0.06934006f, 0.05613448f, 0.18813719f, 0.29826465f, 0.01652872f, 
    -0.14840165f, -0.20324011f, 0.06429368f, 0.00166450f, 0.07980594f, -0.09967811f, 0.17701671f, 0.27231821f, 
    0.12277728f, 0.07389566f, 0.05973288f, 0.34840253f, -0.03765266f, 0.00313846f, -0.12056870f, -0.18716356f, 
    0.12952344f, 0.08928263f, 0.18538716f, 0.01564517f, 0.02669130f, 0.13374692f, -0.04121573f, -0.05146623f, 
    0.07527249f, -0.01273947f, -0.10433906f, -0.04017272f, 0.22536847f, 0.34974355f, 0.39306793f, 0.09032733f, 
    -0.00034802f, 0.06874045f, -0.21159624f, 0.08351952f, 0.20967503f, 0.00893877f, -0.40496266f, 0.13393265f, 
    0.31377646f, 0.11414732f, 0.27316740f, -0.16626675f, -0.20278113f, 0.04309533f, 0.15058467f, 0.18046565f, 
    0.02756465f, -0.10317254f, -0.18889764f, 0.00054656f, 0.09503889f, 0.39960325f, -0.06268352f, -0.20692034f, 
    0.03290520f, -0.13658397f, 0.18220544f, 0.11402255f, -0.09871478f, -0.01120216f, -0.06614395f, 0.06454746f, 
    0.30291981f, -0.55551398f, 0.04437184f, 0.03148750f, -0.05207340f, -0.47821188f, -0.20763327f, 0.43080768f, 
    0.49755266f, 0.13939084f, 0.00379787f, 0.02505642f, -0.12879233f, 0.25769526f, 0.00699363f, 0.08702435f, 
    0.20915100f, 0.08701196f, 0.34673792f, 0.01671794f, 0.28542268f, -0.00887150f, -0.15291220f, 0.09037028f, 
    -0.21827736f, -0.03278742f, -0.25357363f, 0.60246301f, 0.20680010f, 0.08407992f, -0.16023891f, -0.01106259f, 
    -0.10527629f, 0.05405746f, -0.05662148f, -0.05010656f, -0.10996445f, -0.10042027f, -0.02270672f, 0.01885661f, 
    -0.00181993f, 0.06790099f, -0.07245157f, 0.06539483f, 0.03228976f, 0.01123890f, -0.01634757f, -0.08758227f, 
    -0.03240667f, -0.05038955f, -0.04001944f, -0.01404417f, 0.04391292f, 0.04160374f, -0.06317268f, -0.05672089f, 
    -0.04466083f, -0.04750693f, -0.11353818f, -0.11633390f, -0.00596542f, -0.03348396f, 0.00333213f, 0.08294601f, 
    -0.07703277f, -0.10945928f, 0.01005882f, -0.09335665f, 0.01084035f, -0.11024386f, -0.06969667f, -0.05280776f, 
    0.03082206f, 0.00880218f, -0.04775282f, -0.07829881f, 0.05226641f, 0.01230983f, -0.07405507f, 0.00473812f, 
    -0.02370911f, -0.08043698f, -0.00854620f, 0.00518229f, -0.00724672f, -0.01120674f, -0.08300287f, -0.08207264f, 
    0.00458838f, 0.01305418f, 0.00832628f, -0.05350054f, -0.02800614f, 0.03004417f, 0.01629392f, -0.07788622f, 
    -0.03228926f, -0.01860662f, -0.10401854f, 0.02028623f, 0.01457597f, 0.01761612f, -0.03415035f, 0.08710311f, 
    -0.11129899f, 0.02549290f, -0.06068959f, -0.05940924f, -0.05955211f, -0.04214678f, -0.07734916f, 0.09137855f, 
    -0.04978564f, -0.07150295f, -0.03139163f, -0.03521767f, -0.01295587f, -0.05154350f, 0.08581823f, 0.03322090f, 
    0.09555691f, -0.05663639f, 0.01606699f, -0.11163771f, 0.07803226f, -0.05872399f, 0.02080379f, 0.04237068f, 
    -0.10273689f, 0.01429280f, 0.04685118f, 0.08464061f, 0.01664086f, 0.09733646f, -0.02878344f, -0.08573151f, 
    -0.06407641f, -0.08264705f, -0.07409284f, 0.04257720f, -0.07442757f, -0.03247893f, 0.08311436f, -0.04499348f, 
    -0.00281496f, 0.07445142f, -0.07996604f, -0.03550941f, 0.00226979f, 0.02236602f, 0.04663033f, 0.05770283f, 
    0.02869527f, -0.02899333f, -0.00067644f, -0.04621468f, 0.01557266f, -0.05302323f, 0.06046551f, -0.00125908f, 
    -0.09879841f, -0.00834505f, 0.00491071f, 0.00560735f, 0.02561930f, 0.02152077f, 0.04251098f, 0.03110288f, 
    -0.01339575f, -0.02348062f, 0.04233610f, -0.07080477f, 0.00081705f, 0.05597267f, 0.04763074f, -0.09485725f, 
    0.07323562f, -0.08839879f, -0.02150076f, -0.06771396f, 0.01161446f, 0.00932152f, -0.04606556f, -0.07497557f, 
    0.01861093f, 0.02306551f, 0.05866644f, -0.05726040f, 0.02910702f, -0.01324946f, -0.02442262f, 0.00336160f, 
    -0.04833112f, -0.02095810f, 0.02103053f, -0.02147520f, -0.07946739f, -0.06846131f, -0.02197933f, -0.02807890f, 
    0.06544995f, -0.02259149f, 0.04331983f, 0.05400765f, 0.00104359f, -0.00388767f, 0.04898242f, 0.03853953f, 
    0.06484949f, 0.04857389f, 0.07504484f, 0.02096027f, -0.09956297f, 0.05518823f, -0.00765410f, 0.03701533f, 
    -0.08626629f, -0.07801258f, -0.02196274f, 0.04665389f, 0.01263567f, -0.01666195f, 0.03089987f, -0.09296056f, 
    0.04402174f, 0.00898331f, -0.01388884f, -0.01864662f, -0.05694307f, -0.07893749f, -0.07069280f, -0.03826857f, 
    0.00429785f, -0.06087595f, -0.08712915f, -0.00895950f, -0.05854391f, 0.01100906f, 0.06600054f, 0.05841812f, 
    0.02136595f, -0.08880208f, 0.04002053f, 0.05862214f, -0.04607511f, -0.09616943f, -0.01388036f, -0.06599403f, 
    0.05393450f, -0.01409340f, -0.03330825f, -0.08522408f, -0.00359246f, 0.02102191f, 0.02190649f, 0.02708933f, 
    -0.07189120f, -0.01159276f, -0.07828970f, 0.02870002f, -0.01999192f, -0.07644635f, -0.00047279f, 0.03258390f, 
    0.04935502f, 0.07278766f, 0.04091186f, -0.02754245f, -0.00137101f, -0.07388860f, -0.06827213f, -0.05827153f, 
    -0.07118968f, 0.07447328f, -0.04556256f, 0.00964548f, -0.01056476f, -0.07542501f, 0.05820487f, 0.02622704f, 
    0.04816206f, -0.03890897f, -0.07170766f, -0.00767181f, 0.04142795f, 0.00460054f, 0.01524410f, -0.00315077f, 
    0.28287831f, -0.10705511f, 0.20323810f, -0.07355428f, 0.07314704f, -0.27056670f, -0.02585626f, -0.00745253f, 
    0.13903363f, -0.00083821f, 0.00378051f, 0.07780769f, -0.51573175f, -0.00120122f, 0.02660101f, 0.04367938f, 
    0.07822466f, 0.08731234f, -0.87276304f, 0.02807268f, -0.13085483f, -0.10425786f, 0.02223115f, -0.07919164f, 
    -0.07282352f, 0.00079595f, 0.31905597f, 0.15561831f, 0.18464302f, -0.46462175f, -0.02068465f, 0.01579267f, 
    -0.29038009f, 0.06216617f, 0.03667474f, -0.02023441f, 0.09731262f, 0.04102656f, -0.07088505f, 0.09320790f, 
    -0.13578336f, 0.05598135f, -0.07134768f, -0.10184816f, -0.07761617f, -0.00986789f, -0.00277461f, 0.09383735f, 
    0.02779785f, -0.00747152f, -0.16137199f, 0.18237023f, -0.11776827f, 0.25360817f, 0.02445328f, -0.61930662f, 
    0.06755322f, -0.07984421f, 0.23831864f, -0.00568522f, -0.25948307f, 0.18747339f, -0.09871582f, -0.01080634f, 
    0.05171932f, -0.68805808f, 0.02612945f, 0.06116039f, 0.08199521f, -0.19336671f, -0.07033627f, 0.31583789f, 
    -0.15848984f, -0.00229534f, -0.00439614f, 0.23016651f, -0.11675420f, 0.13332757f, 0.19469097f, 0.12926240f, 
    0.28840908f, 0.24329576f, 0.30720216f, -0.07933945f, 0.07645370f, 0.37007943f, 0.14467108f, -0.11251115f, 
    -0.01763130f, 0.11036032f, -0.19844197f, -0.31090257f, -0.36723283f, -0.15325461f, -0.03118689f, 0.01451188f, 
    -0.34998897f, -0.13849285f, 0.01247886f, 0.00815077f, 0.03004218f, 0.02698750f, -0.18535843f, -0.11384460f, 
    0.00707788f, 0.00388207f, 0.04742991f, -0.37854537f, 0.11592919f, -0.36514869f, 0.08335615f, 0.02643750f, 
    -0.18027629f, -0.04092890f, 0.00535739f, 0.04480377f, -0.01639375f, 0.18808325f, 0.20026395f, -0.31576592f, 
    0.10606320f, 0.03411221f, -0.19494890f, 0.02373535f, 0.01474757f, 0.05709876f, -0.19269755f, -0.00554391f, 
    0.02650434f, 0.06233505f, 0.03118401f, 0.00639321f, -0.30912244f, 0.13891740f, 0.29088894f, 0.00068523f, 
    0.10450260f, 0.05988290f, -0.03900366f, -0.12026001f, 0.23083961f, 0.27993274f, 0.03670793f, -0.06754968f, 
    0.13770278f, -0.13617139f, 0.40553159f, -0.08150341f, 0.21061824f, 0.03545723f, 0.05190581f, 0.14914402f, 
    0.34071422f, 0.02070842f, -0.13362740f, -0.06029461f, 0.05717284f, 0.10845391f, 0.09012817f, 0.16260052f, 
    0.09349449f, -0.01054287f, 0.03838351f, 0.20270158f, 0.10902108f, -0.03163955f, 0.09573424f, 0.02247124f, 
    -0.11390822f, -0.10963339f, 0.00038969f, 0.22444355f, -0.01113164f, 0.12234800f, -0.04120379f, 0.07776509f, 
    0.02658455f, -0.02875148f, 0.02752943f, -0.15614314f, 0.10158896f, -0.06470244f, -0.08027446f, -0.17795084f, 
    -0.24725769f, 0.10318276f, -0.05990655f, -0.22066870f, 0.18152826f, 0.00785570f, 0.21532062f, 0.21626535f, 
    0.01876003f, 0.09635607f, -0.14354666f, 0.11978243f, -0.06357861f, -0.21143195f, -0.23037273f, -0.04928888f, 
    0.16648601f, 0.17421615f, 0.20063479f, -0.05466955f, 0.10919994f, -0.13984835f, -0.08980116f, -0.00012701f, 
    -0.15293050f, -0.07923438f, -0.11315751f, 0.05795670f, -0.00001058f, -0.11219568f, -0.09410616f, 0.10471240f, 
    0.04452909f, -0.05693529f, 0.07772437f, -0.04809457f, -0.21327640f, 0.01828987f, -0.08271938f, -0.04317500f, 
    0.20243512f, -0.21314557f, -0.01909837f, 0.05777560f, 0.03443952f, -0.15924820f, -0.32336360f, 0.05957456f, 
    0.25778961f, -0.02085648f, -0.06165992f, 0.12218821f, -0.25463220f, 0.19832475f, -0.04058649f, 0.06895965f, 
    0.18554705f, -0.05811229f, 0.05921189f, -0.01812774f, 0.06527320f, -0.38640279f, -0.07630060f, 0.13657711f, 
    -0.17570157f, 0.13701865f, 0.01313865f, 0.37955028f, 0.19759968f, 0.08908176f, -0.01397234f, 0.11858214f, 
    0.03074142f, -0.01174219f, -0.10244718f, 0.07248399f, -0.09576768f, -0.00775653f, 0.04417105f, 0.02317162f, 
    0.04598871f, 0.06946845f, -0.07616697f, -0.05654892f, -0.06458753f, -0.04382242f, -0.08654834f, 0.02016900f, 
    -0.05218871f, -0.03334042f, 0.00841497f, -0.06822958f, 0.06122736f, -0.05128246f, -0.02300027f, -0.09918256f, 
    -0.05304818f, -0.01293015f, -0.01556049f, -0.09066220f, -0.01631537f, -0.11175444f, 0.07030815f, -0.06409243f, 
    -0.01000181f, 0.01050865f, 0.01682915f, 0.02377289f, 0.05612229f, 0.02235654f, -0.07106602f, -0.07349626f, 
    0.03595214f, 0.05588247f, -0.07538747f, 0.00281576f, 0.06874289f, -0.04473301f, -0.01057655f, -0.01532003f, 
    0.02353704f, 0.08625668f, -0.12024543f, -0.07877956f, -0.09368677f, -0.01022378f, 0.05291916f, -0.02302345f, 
    -0.02148190f, -0.09018366f, -0.03394406f, 0.00249959f, -0.06174011f, 0.02130305f, -0.05597353f, 0.02700298f, 
    -0.05109856f, -0.09862926f, 0.01337950f, -0.08167803f, 0.07834543f, -0.04035768f, -0.06294679f, -0.08567196f, 
    0.04284145f, 0.02176970f, -0.04784955f, 0.04411837f, -0.10977342f, 0.02627981f, -0.00560108f, -0.09964311f, 
    0.01147168f, -0.08753306f, -0.04746104f, -0.06519322f, -0.03285122f, -0.05718144f, 0.02859494f, 0.03794124f, 
    0.03084920f, -0.05072271f, -0.04339092f, -0.01529591f, -0.09104896f, -0.07093345f, 0.06603960f, 0.04598005f, 
    0.02264915f, 0.01729331f, 0.04148393f, -0.07057001f, -0.08594368f, 0.05606597f, 0.04911858f, 0.00320188f, 
    -0.02029251f, 0.00305344f, -0.05055719f, 0.00927677f, -0.01531832f, 0.00382567f, 0.05496130f, -0.10705332f, 
    0.05580099f, 0.03053202f, -0.00342651f, -0.04230912f, 0.03483871f, -0.05535565f, 0.04391383f, -0.00245142f, 
    0.04160373f, 0.03745539f, -0.03131815f, -0.00073313f, 0.03586818f, -0.03938851f, 0.01810451f, -0.05296355f, 
    0.14857945f, 0.21829449f, 0.01882172f, 0.06511301f, 0.04477924f, 0.10880526f, 0.10938814f, 0.15053792f, 
    0.07368542f, 0.18888652f, 0.04947490f, 0.12095600f, -0.37947264f, -0.07404102f, 0.16221127f, 0.07848054f, 
    -0.07888379f, 0.07379376f, -0.28608140f, 0.10970626f, 0.14400303f, -0.03907577f, 0.00685980f, -0.05237128f, 
    -0.50494134f, -0.01416760f, -0.06821045f, -0.05132800f, 0.15331940f, -0.26780060f, 0.09608626f, 0.07884252f, 
    -0.17583553f, 0.13905817f, 0.08706305f, -0.04539585f, -0.10109394f, 0.16284661f, -0.15442339f, 0.11317442f, 
    0.04640173f, 0.30537018f, 0.01505263f, -0.11800758f, 0.27976346f, -0.20106816f, 0.02243769f, 0.07300264f, 
    0.17880677f, 0.08136439f, -0.08182802f, -0.04548084f, 0.19890375f, 0.18959521f, 0.07826842f, 0.01707407f, 
    0.14012860f, -0.05829024f, 0.04498759f, 0.09045357f, -0.07407352f, 0.11878458f, 0.03114119f, 0.02339581f, 
    0.07040395f, -0.40974805f, 0.13568988f, 0.09246539f, 0.24390185f, -0.05236940f, 0.20759520f, -0.03059109f, 
    -0.06509893f, 0.06484824f, -0.05098204f, -0.04113659f, -0.06967340f, -0.01437419f, 0.07997552f, 0.03770334f, 
    -0.02144337f, 0.12087435f, 0.09565126f, -0.08129591f, 0.06854708f, -0.05300728f, 0.01928372f, -0.14277364f, 
    0.03570437f, 0.09926928f, 0.06607943f, -0.15391068f, 0.05740010f, 0.04941633f, -0.06272026f, 0.07514106f, 
    -0.19634876f, 0.11234056f, 0.26575643f, -0.02309018f, 0.00448120f, -0.20592399f, 0.07172774f, -0.06744700f, 
    -0.02045840f, 0.01942788f, -0.04149039f, -0.10699418f, -0.06187889f, 0.09608503f, -0.08481928f, -0.14765307f, 
    0.19075067f, -0.05253206f, 0.17681888f, 0.04173870f, 0.02842742f, 0.00871996f, -0.02025266f, -0.23483957f, 
    -0.08832043f, -0.02898565f, -0.18297914f, -0.10716319f, -0.15011939f, 0.10345995f, -0.11434874f, 0.20811895f, 
    0.00163238f, 0.04434618f, -0.11210687f, 0.01286679f, 0.05655489f, 0.03513271f, 0.05551188f, 0.17881344f, 
    0.07857727f, -0.01233756f, -0.04701846f, -0.27589256f, 0.17943044f, 0.25401032f, 0.08134761f, 0.07694264f, 
    -0.04789408f, 0.09123279f, 0.14251503f, 0.07826968f, -0.00738149f, 0.07196489f, 0.06193590f, 0.35659832f, 
    -0.05257226f, -0.00248538f, -0.20681073f, 0.06903075f, -0.01166428f, -0.09936651f, 0.00977512f, -0.01741222f, 
    0.04190879f, 0.20790771f, -0.04155386f, 0.07936759f, -0.00266515f, 0.05902761f, -0.14651373f, 0.44085759f, 
    0.11057171f, 0.06202297f, -0.06864440f, 0.00111575f, 0.12837684f, -0.16816671f, -0.04895646f, 0.07078434f, 
    0.38636255f, 0.02720079f, 0.28742483f, -0.06781219f, 0.01458266f, -0.09821564f, -0.03381002f, 0.10760148f, 
    0.22780928f, 0.14540042f, 0.00289626f, -0.05689014f, 0.13406117f, -0.37558910f, 0.15411687f, -0.00636364f, 
    -0.03835026f, 0.12917912f, 0.09336729f, 0.03446741f, 0.29481554f, -0.01829416f, 0.06715479f, 0.00495680f, 
    0.05368327f, 0.26998141f, 0.00452548f, 0.10701051f, -0.27390996f, -0.17931533f, -0.09739611f, 0.07656443f, 
    -0.04829080f, 0.05383264f, -0.23032141f, 0.04849195f, -0.02642963f, -0.11919032f, 0.21356264f, -0.09265361f, 
    -0.13945004f, 0.13310762f, 0.35142434f, 0.02287683f, 0.07311955f, 0.04704864f, -0.02885531f, -0.02657631f, 
    0.15534796f, 0.01503060f, 0.45064244f, -0.01644051f, 0.19166987f, -0.43238467f, -0.07592809f, 0.13250394f, 
    0.01915751f, 0.01011560f, -0.00306693f, 0.05465380f, -0.17172699f, -0.15069085f, -0.07279126f, 0.23974708f, 
    0.01791429f, 0.08799174f, 0.00436551f, -0.00516060f, 0.03721140f, 0.07817572f, 0.01535461f, -0.21903023f, 
    0.17888863f, -0.07058134f, 0.19206646f, -0.14613041f, -0.09203767f, 0.06551319f, -0.15315939f, 0.40198994f, 
    -0.01262659f, 0.00573870f, 0.10407564f, 0.03699725f, -0.09865977f, 0.04426286f, -0.07034218f, 0.05122798f, 
    0.04617783f, 0.17513695f, 0.00887095f, 0.22864011f, 0.25156620f, -0.06498549f, -0.09311672f, 0.09177092f, 
    0.05699847f, -0.00338794f, -0.09304080f, 0.04280237f, 0.09683537f, -0.02759927f, 0.04323797f, -0.05459258f, 
    0.17970507f, -0.08672705f, 0.19630519f, -0.01736029f, -0.06536089f, 0.15119788f, 0.05299259f, 0.06755435f, 
    0.10324942f, -0.14663346f, 0.01737420f, 0.10547793f, 0.05090235f, 0.07199912f, 0.40149283f, -0.02713564f, 
    -0.27771723f, 0.13550982f, 0.10134053f, 0.08466418f, 0.08404351f, -0.00819077f, 0.30654681f, 0.03801826f, 
    -0.26176015f, 0.06801201f, -0.01246771f, 0.06603044f, 0.05710693f, -0.10617164f, 0.03086069f, -0.07636179f, 
    -0.30320144f, 0.30027822f, 0.18443085f, 0.01836753f, 0.06973137f, 0.03926530f, -0.01197598f, 0.06168801f, 
    -0.04062870f, 0.01376095f, -0.05979338f, 0.08294239f, -0.22402817f, 0.01578907f, -0.03277867f, -0.13451625f, 
    -0.02150047f, -0.00185023f, 0.10291869f, -0.12438262f, 0.58853722f, 0.17678678f, -0.03586682f, -0.05238037f, 
    -0.03689073f, -0.15609188f, 0.06528664f, 0.07268949f, 0.02906951f, -0.12538153f, -0.03736578f, 0.09732372f, 
    -0.02752264f, 0.03532951f, -0.11596095f, 0.11531810f, 0.09319076f, -0.03272098f, -0.07012593f, 0.00335149f, 
    -0.01523998f, 0.01040508f, -0.16980311f, 0.07077868f, 0.05817195f, 0.74190629f, 0.02959902f, -0.01453847f, 
    -0.08839419f, 0.02951939f, 0.09265178f, 0.06488840f, 0.23827675f, 0.16531669f, -0.02321259f, 0.08441462f, 
    -0.00000184f, 0.07811490f, 0.09002331f, -0.03134323f, 0.06141588f, 0.06330175f, -0.01316042f, 0.33483258f, 
    -0.13284227f, 0.15600456f, -0.13800922f, 0.05905389f, 0.13211307f, 0.04021633f, 0.11967100f, -0.19541322f, 
    -0.05631894f, -0.18262680f, 0.01365967f, -0.02405964f, -0.11976966f, 0.13119259f, -0.00111077f, 0.20987241f, 
    -0.14850545f, 0.31280693f, 0.02855427f, 0.05493225f, 0.37926957f, -0.16472088f, -0.08605450f, 0.15749003f, 
    0.23206343f, 0.28815269f, -0.01202660f, 0.00004922f, -0.10681005f, -0.02797447f, -0.09383228f, 0.07795856f, 
    -0.04905431f, -0.05571367f, 0.20326406f, 0.15779965f, -0.01428341f, 0.26033628f, -0.04451647f, 0.01257192f, 
    0.08375676f, -0.04491021f, 0.07900710f, -0.03631666f, 0.04212969f, -0.21335222f, 0.32305315f, 0.31508151f, 
    -0.19777849f, 0.07562374f, 0.20687771f, 0.00725695f, -0.04898708f, -0.07166426f, 0.42102584f, 0.30272123f, 
    -0.36105263f, 0.05995097f, 0.07675949f, -0.12635814f, -0.08489145f, -0.16448565f, -0.02208732f, 0.12038426f, 
    -0.09890572f, 0.70262170f, 0.31359014f, 0.01692106f, 0.22712058f, -0.21072918f, -0.13118462f, 0.02022553f, 
    -0.05195053f, 0.14791609f, 0.02335986f, 0.00735686f, -0.09573565f, -0.04133443f, 0.24718742f, -0.05368204f, 
    -0.23129606f, 0.21946129f, -0.03385676f, 0.11876471f, 0.48655638f, 0.49066558f, -0.04714708f, 0.05731644f, 
    -0.10869779f, 0.04338197f, -0.12664782f, 0.02282994f, 0.03070945f, -0.13950719f, -0.14088021f, 0.05339518f, 
    -0.11717160f, 0.10744114f, -0.36613691f, 0.11515219f, -0.12658611f, -0.07103896f, 0.01711107f, -0.05710600f, 
    -0.12228186f, 0.09751876f, -0.36811930f, 0.02789735f, 0.08244520f, -0.24108675f, 0.01774608f, 0.02874483f, 
    -0.32876736f, 0.08361946f, -0.02805649f, 0.06983528f, 0.37713608f, -0.08218300f, -0.01110399f, 0.23446520f, 
    0.08096308f, 0.00237515f, -0.40463188f, 0.04196912f, 0.00634788f, 0.18056712f, 0.34594122f, 0.18722488f, 
    0.22488195f, 0.37890813f, 0.29506961f, -0.20241836f, 0.12978062f, 0.06341876f, 0.05264336f, -0.11447172f, 
    -0.04155558f, 0.04266946f, 0.08042838f, 0.02483030f, -0.13231911f, -0.03720805f, 0.06727114f, -0.17562941f, 
    0.05766447f, -0.01745916f, -0.01913244f, 0.39873114f, 0.16886817f, 0.05573765f, -0.15116523f, 0.06715221f, 
    0.04335904f, -0.07205565f, 0.08446412f, -0.02559574f, 0.26471815f, 0.13433348f, 0.04710026f, 0.01054617f, 
    0.29373747f, 0.00794105f, 0.09986053f, -0.05949298f, -0.01171779f, 0.18827645f, 0.07212454f, 0.13629632f, 
    0.04075288f, -0.15262879f, 0.08223145f, 0.03665457f, 0.04530226f, -0.03740383f, 0.53354156f, -0.12904538f, 
    -0.26549530f, 0.00914436f, 0.06540952f, 0.27515057f, 0.11436294f, 0.10200461f, 0.08754107f, -0.02852768f, 
    -0.20899704f, 0.04721887f, 0.11856654f, -0.13477772f, 0.04253339f, 0.03655495f, -0.07362097f, -0.02026604f, 
    -0.38950175f, 0.13317713f, 0.07284135f, 0.06075808f, 0.14094192f, 0.46164975f, 0.02330469f, 0.16413088f, 
    -0.04157714f, 0.02234786f, -0.16673841f, 0.04416100f, -0.12324154f, 0.00559592f, -0.13637777f, -0.04199752f, 
    0.17141946f, 0.02919569f, 0.11455318f, -0.12066548f, 0.51300573f, 0.21263297f, 0.10664958f, 0.12721075f, 
    0.01190159f, -0.03377721f, 0.20053202f, -0.07544748f, -0.08522719f, -0.04503770f, -0.05728042f, -0.00135260f, 
    0.16892615f, -0.02452452f, -0.04777262f, 0.13523698f, -0.06975910f, -0.03632727f, 0.05560586f, -0.06325091f, 
    0.16668342f, 0.05125219f, -0.22572471f, 0.01651122f, -0.04547129f, -0.02967806f, 0.08594219f, 0.03065231f, 
    0.15582393f, -0.06036387f, 0.00762847f, 0.16257414f, 0.21696685f, 0.35223991f, -0.05394102f, -0.05528900f, 
    0.09981416f, 0.08679590f, 0.16428135f, 0.00298231f, 0.12479611f, -0.04761782f, 0.09024952f, 0.31215832f, 
    -0.06988169f, 0.15220359f, -0.11530165f, 0.35874233f, 0.15434586f, -0.00364159f, -0.00508027f, -0.15647948f, 
    0.25303835f, -0.10023980f, -0.12874258f, -0.03463314f, -0.18683143f, -0.63753700f, 0.10933678f, 0.05565297f, 
    0.09613766f, 0.32118577f, 0.06274554f, 0.11516677f, -0.07476945f, 0.02686500f, 0.43743736f, 0.15252616f, 
    0.13041438f, 0.48595333f, 0.14752135f, -0.13891643f, -0.62503999f, 0.02566454f, 0.02684409f, 0.11699107f, 
    -0.33316028f, 0.12002443f, -0.10240156f, -0.05041996f, -0.20023185f, 0.02446404f, -0.19228436f, -0.18470585f, 
    -0.33347875f, -0.02723111f, -0.07712928f, 0.09760182f, 0.07058264f, -0.03297816f, 0.08794609f, -0.01351828f, 
    0.10768165f, 0.26001698f, 0.06492496f, 0.06679492f, 0.25222817f, -0.46277714f, 0.19024698f, -0.21947986f, 
    -0.07195034f, -0.03648517f, 0.22175223f, -0.30471793f, -0.28433549f, 0.02554706f, 0.00203345f, -0.06311262f, 
    -0.08275781f, 0.40660951f, 0.28135633f, -0.20468989f, -0.10323732f, -0.55988282f, 0.06936039f, -0.15953954f, 
    0.07694123f, -0.18237114f, -0.00120347f, 0.05564902f, -0.15634540f, -0.16898355f, -0.49043438f, 0.34046698f, 
    0.18321450f, 0.05925964f, -0.18990961f, 0.05903641f, -0.09634881f, 0.30124331f, 0.06759064f, 0.20944467f, 
    -0.19767830f, 0.21836998f, -0.05732372f, -0.12442949f, 0.04503608f, 0.18962364f, 0.26919776f, -0.37458426f, 
    0.07953602f, -0.01240860f, -0.12070700f, -0.10503601f, 0.05964778f, -0.32201603f, -0.07688911f, -0.01098025f, 
    -0.15194240f, -0.14420661f, -0.12685995f, -0.04393496f, 0.02139278f, 0.03579885f, -0.23509118f, -0.12493622f, 
    -0.49440724f, 0.05442601f, -0.01642573f, -0.04786932f, 0.10470459f, -0.43806854f, 0.02295940f, 0.34153354f, 
    -0.12465385f, 0.00125560f, -0.33004409f, -0.00160473f, 0.28073129f, -0.38763392f, 0.05188558f, 0.24714361f, 
    0.37608486f, 0.12420090f, -0.05810189f, 0.09735711f, 0.02295784f, -0.02953377f, -0.48957109f, 0.05542642f, 
    -0.51345050f, -0.37482172f, -0.05195888f, -0.07116511f, 0.04567788f, 0.04135429f, -0.39924860f, -0.17675237f, 
    -0.15213956f, -0.29229584f, -0.01253133f, 0.37517107f, 0.33890417f, 0.01419088f, -0.37351534f, 0.17126374f, 
    0.06670245f, -0.36484274f, -0.11975263f, -0.38481218f, 0.19973481f, -0.06010639f, -0.02602738f, -0.03843244f, 
    -0.00757322f, -0.09780736f, -0.07362761f, 0.08557873f, 0.19983238f, 0.40806088f, 0.06202078f, 0.18045092f, 
    0.23366968f, -0.12964059f, -0.06148316f, -0.37477803f, 0.11640970f, -0.17693511f, 0.18351609f, 0.04036877f, 
    -0.43038210f, -0.21600257f, 0.14812066f, 0.15968972f, -0.14676626f, -0.29317555f, 0.26690066f, 0.06711474f, 
    0.29708031f, -0.08496421f, 0.04069968f, -0.07012860f, -0.17171009f, -0.32774177f, 0.06613193f, 0.12977095f, 
    -0.51485431f, -0.12865190f, -0.13855277f, 0.27029249f, 0.00097172f, 0.93393946f, -0.46087763f, 0.06078419f, 
    0.03701741f, 0.52086055f, -0.22707833f, 0.09111708f, -0.18606462f, 0.27947921f, -0.08865063f, 0.13585517f, 
    -0.18809672f, -0.17510988f, -0.11867124f, 0.12518032f, 0.38059348f, 0.10643149f, -0.38213724f, 0.00344169f, 
    -0.24132022f, -0.36552083f, -0.40362981f, -0.02972143f, 0.02534696f, -0.02744696f, -0.06479656f, 0.08587237f, 
    -0.05295766f, 0.03319880f, 0.27437276f, 0.08466349f, -0.00410084f, -0.18049297f, -0.02001526f, 0.05179046f, 
    0.08147421f, -0.03147219f, 0.02617285f, -0.04632924f, -0.12591076f, -0.34925070f, 0.19329050f, -0.13766052f, 
    0.61764777f, -0.03427299f, 0.06242079f, 0.13904642f, 0.36653355f, 0.17701574f, 0.07000561f, -0.02768043f, 
    -0.51135844f, 0.01754941f, 0.26413849f, -0.08198228f, 0.12300107f, 0.30673274f, 0.25674874f, 0.28658921f, 
    0.01936751f, 0.10964055f, 0.18191330f, -0.01013531f, 0.31677023f, 0.13766874f, 0.10018110f, 0.04581596f, 
    0.24652205f, -0.34047791f, -0.01062982f, -0.03905927f, 0.30578250f, -0.20095062f, -0.27326965f, 0.11561579f, 
    0.02273985f, 0.07277673f, -0.06038963f, 0.16496970f, -0.16601309f, -0.19684695f, -0.08028127f, 0.14980879f, 
    0.19866712f, -0.01337089f, -0.36627680f, -0.28407535f, 0.02410531f, -0.15782346f, 0.07115353f, 0.00652098f, 
    -0.07729001f, 0.01680385f, 0.45700517f, 0.12382691f, 0.14074384f, 0.15001598f, 0.03607622f, 0.24641810f, 
    -0.01933384f, 0.18194704f, -0.02706880f, -0.21791725f, 0.15462166f, -0.16762067f, -0.29654717f, -0.13154933f, 
    -0.11087348f, -0.03165993f, 0.08336932f, -0.08312075f, 0.05505192f, -0.35774410f, 0.26871353f, 0.05513453f, 
    0.06447486f, -0.06335381f, 0.02017980f, -0.30571130f, -0.03649887f, -0.12660813f, -0.07299852f, -0.08028242f, 
    -0.42351556f, -0.02094232f, 0.25331500f, -0.15342955f, -0.20755765f, 0.18072307f, -0.27078319f, 0.14996092f, 
    -0.04118067f, 0.20191608f, -0.12056749f, 0.13011849f, -0.12616567f, -0.13547155f, -0.19591683f, 0.57082552f, 
    -0.32159129f, -0.25381932f, -0.06962410f, 0.25847641f, 0.14298829f, 0.17679590f, -0.27847299f, 0.18050846f, 
    -0.14050588f, -0.09536016f, -0.21023406f, -0.08259506f, -0.03541523f, 0.09558882f, 0.00801561f, -0.52974778f, 
    -0.12447664f, 0.12148164f, -0.24240026f, -0.01570114f, -0.06578662f, -0.16551015f, 0.02717714f, 0.02483318f, 
    -0.31496722f, -0.41131905f, -0.16056389f, -0.03456573f, -0.00730253f, -0.13760914f, -0.19761303f, -0.38307628f, 
    0.33929372f, 0.08362281f, -0.01842688f, -0.06170911f, 0.16833320f, -0.18929808f, 0.01969457f, 0.09252188f, 
    -0.64580959f, 0.01183676f, -0.07089376f, 0.08041883f, 0.13602756f, -0.05715463f, 0.25249889f, 0.25338134f, 
    0.18073763f, 0.19849481f, -0.00936213f, 0.15265991f, 0.34768587f, 0.26370749f, -0.20212588f, 0.05373874f, 
    0.18360128f, 0.15073939f, 0.13437641f, -0.07270975f, 0.12037550f, -0.02022481f, -0.06410017f, 0.34908268f, 
    0.02180972f, 0.06429327f, -0.04607629f, 0.23615079f, -0.22097431f, -0.10064506f, 0.10897969f, 0.25547448f, 
    0.16485153f, -0.04622240f, -0.19449586f, 0.10234603f, 0.03717941f, -0.03025372f, 0.05991767f, -0.05248079f, 
    -0.21998264f, -0.08489188f, 0.23225757f, 0.00240905f, 0.28397635f, -0.00762527f, 0.24113148f, 0.03308356f, 
    0.10701413f, 0.16054681f, -0.07847712f, -0.03725618f, 0.21109807f, 0.14180835f, -0.11660054f, -0.11147256f, 
    -0.08682664f, -0.05621771f, 0.09488141f, -0.05899024f, 0.16787498f, -0.12924553f, 0.10159073f, 0.18916859f, 
    -0.05010942f, 0.00502459f, -0.24345013f, 0.04840472f, 0.32898438f, 0.10930485f, 0.08163714f, 0.04203739f, 
    -0.02225277f, -0.39188388f, 0.01658100f, 0.02842314f, -0.05865306f, -0.02985290f, 0.02349163f, 0.17914623f, 
    -0.03007680f, -0.02247400f, 0.18451975f, 0.24133952f, 0.12538713f, 0.04421847f, 0.06927010f, 0.18982908f, 
    0.04700733f, -0.13086586f, 0.07543887f, 0.10840467f, 0.01789601f, 0.09694026f, 0.05625768f, 0.06656059f, 
    0.21319100f, 0.09122765f, 0.27656865f, -0.06739277f, 0.09731487f, 0.02255656f, 0.11633335f, -0.16015835f, 
    -0.04151598f, 0.23324488f, -0.39827427f, 0.11736505f, 0.11979650f, 0.06664112f, -0.08101333f, -0.07213329f, 
    -0.12440729f, 0.14961836f, 0.01705621f, -0.08884715f, -0.02468788f, -0.20173401f, 0.08145837f, -0.16580732f, 
    -0.13256349f, 0.04933340f, -0.09432301f, -0.14525415f, 0.19709587f, 0.14012112f, -0.01556124f, -0.20981155f, 
    -0.13586704f, 0.01259342f, -0.07824267f, 0.03014812f, -0.06769543f, 0.11763552f, 0.11431644f, -0.00766814f, 
    0.08412252f, -0.10024387f, -0.27514881f, -0.06813437f, -0.13127527f, 0.21622865f, -0.23635890f, 0.11096781f, 
    0.13355193f, -0.19448346f, 0.00957629f, 0.06787183f, 0.03553837f, -0.27969411f, 0.05024808f, 0.05562833f, 
    0.08411590f, 0.12287962f, 0.06604802f, 0.14921893f, -0.03960014f, -0.05836938f, 0.36282837f, 0.14389347f, 
    -0.05363026f, 0.15259346f, 0.25515804f, -0.04912089f, -0.21916620f, -0.04031561f, -0.01349778f, -0.08004246f, 
    -0.53946030f, 0.01264096f, -0.11486536f, 0.01871171f, 0.07481995f, 0.25876817f, -0.01288213f, -0.07635165f, 
    -0.07771172f, 0.05835259f, -0.05080792f, -0.11823975f, 0.04575801f, 0.00439030f, -0.09252780f, 0.10990196f, 
    -0.00173670f, 0.13823973f, 0.11105179f, -0.05910724f, 0.11711632f, -0.63156050f, 0.11768161f, -0.21886386f, 
    0.09538943f, -0.12603621f, 0.13315737f, -0.03668723f, -0.06710446f, 0.02623901f, 0.04673121f, 0.14590913f, 
    0.23629272f, 0.19971834f, 0.06856339f, -0.28368643f, -0.05159627f, 0.28862908f, 0.00975710f, -0.07598336f, 
    -0.05838918f, 0.07011861f, 0.12443453f, 0.00808763f, 0.08093585f, -0.04156824f, -0.52434862f, 0.29948485f, 
    0.09960228f, -0.13858438f, -0.05166826f, 0.04076792f, -0.07841141f, 0.24566218f, -0.05811136f, 0.18877481f, 
    -0.11036706f, 0.19593759f, -0.36962694f, -0.02339179f, 0.08689526f, 0.25828791f, -0.06288227f, -0.21504356f, 
    -0.26473626f, -0.08727782f, -0.24625248f, -0.07972889f, 0.08623043f, -0.14818130f, -0.06776948f, -0.04341215f, 
    -0.08963386f, -0.50654835f, -0.04849499f, -0.06209641f, 0.03764699f, -0.15190402f, -0.17182687f, -0.13442060f, 
    -0.17318015f, 0.02625213f, 0.05502085f, 0.07017584f, 0.24448729f, -0.12508257f, -0.00755797f, 0.19400600f, 
    -0.19309404f, -0.03921111f, -0.11633535f, 0.07017472f, 0.22161706f, -0.14551270f, 0.14534214f, 0.40255117f, 
    0.28927216f, 0.15063395f, -0.13227554f, 0.08757088f, 0.11075050f, -0.02302633f, -0.58299595f, 0.10377579f, 
    0.06754737f, -0.09140821f, -0.00827494f, -0.03265274f, 0.18923172f, 0.06319085f, -0.10171990f, -0.28493112f, 
    0.01716370f, -0.16575913f, -0.05183164f, 0.03371615f, -0.07764815f, -0.02868769f, -0.29824233f, 0.05561060f, 
    -0.07617205f, 0.18161252f, -0.10197289f, -0.05942180f, 0.05590053f, 0.06754686f, -0.05433793f, -0.16834913f, 
    -0.40542793f, 0.14617927f, 0.31169829f, 0.11492670f, 0.15718257f, 0.19594015f, -0.00697823f, -0.03945985f, 
    -0.32769299f, -0.14152302f, -0.02665998f, -0.07665667f, -0.17550097f, -0.13335697f, 0.17764638f, 0.29474908f, 
    0.03625693f, 0.20784712f, -0.03972632f, 0.12147021f, -0.01897364f, -0.46397159f, 0.05344063f, -0.01771336f, 
    -0.11511704f, 0.05523112f, 0.24139947f, 0.09689998f, -0.06355787f, 0.10033977f, -0.05755796f, 0.02648895f, 
    0.01286862f, 0.17402774f, 0.09725049f, -0.08999110f, 0.23090166f, 0.32463038f, 0.10641471f, 0.08149737f, 
    -0.00297989f, 0.01981691f, -0.05011627f, -0.04995861f, 0.31284186f, 0.10425569f, -0.21184070f, 0.30075303f, 
    -0.06171581f, 0.04887164f, 0.06733741f, -0.10803615f, -0.02063343f, 0.56503171f, -0.03801568f, 0.26454970f, 
    -0.04816460f, -0.01189501f, -0.03453621f, 0.05583133f, 0.01417583f, 0.42858347f, -0.07045240f, -0.10786394f, 
    -0.25819916f, -0.04122352f, -0.18170844f, 0.20913653f, 0.04278804f, -0.02595547f, 0.03246581f, 0.05239144f, 
    -0.09172136f, -0.43154585f, -0.10251223f, 0.04414800f, -0.05015882f, -0.03956489f, -0.09660644f, 0.38446939f, 
    0.13399656f, 0.08598948f, 0.02023396f, -0.11709128f, 0.22073366f, 0.07495157f, -0.05019202f, 0.09918883f, 
    0.05224022f, -0.09461290f, 0.06825819f, -0.00991402f, 0.05843361f, 0.41520280f, 0.07186327f, 0.01685825f, 
    -0.13325454f, 0.09373607f, -0.03994769f, 0.27359664f, 0.16904837f, 0.02196794f, -0.44607702f, 0.02176890f, 
    0.00114347f, -0.12946790f, 0.09654760f, 0.09034596f, -0.13799372f, -0.15536413f, 0.12430641f, -0.28272852f, 
    -0.01277763f, 0.10007035f, -0.00740965f, -0.06976232f, 0.06452014f, 0.38510233f, -0.14925125f, 0.06612946f, 
    0.27966973f, 0.19625781f, -0.03637808f, -0.03987307f, -0.14543884f, -0.12053673f, 0.01096679f, 0.43564510f, 
    -0.04203166f, 0.06438773f, 0.00375788f, 0.09965249f, 0.00634104f, -0.31649151f, 0.03781858f, -0.02988516f, 
    -0.28287658f, -0.06345796f, -0.06228606f, 0.27968577f, 0.11158441f, -0.30724287f, 0.20557040f, 0.48439449f, 
    0.14125687f, 0.13447866f, 0.06761076f, 0.13641857f, -0.15726160f, -0.25021002f, 0.06268516f, -0.09293500f, 
    0.09342553f, -0.02057673f, 0.05172821f, -0.00694081f, -0.37547198f, 0.09827507f, -0.03883425f, -0.21371801f, 
    0.02072726f, 0.34323183f, 0.09675607f, -0.16719529f, 0.02660934f, -0.23575141f, 0.17281319f, -0.02687346f, 
    0.05406527f, -0.21441671f, -0.18551670f, -0.03227082f, 0.16133371f, -0.24938762f, -0.19445148f, 0.07172730f, 
    0.08850411f, 0.32241431f, 0.05039046f, 0.13532212f, -0.16645445f, 0.10026767f, -0.02628285f, 0.09431040f, 
    -0.12502235f, 0.14421189f, -0.04660337f, 0.03853517f, -0.01948355f, 0.22606947f, 0.34868690f, 0.04387645f, 
    0.34731784f, -0.20502493f, 0.41542917f, -0.01085788f, -0.26287046f, -0.15668784f, -0.00164577f, 0.07142144f, 
    -0.07486935f, -0.13977945f, 0.00318081f, -0.07028318f, 0.27093989f, 0.02101845f, -0.41438496f, 0.30147630f, 
    -0.00153108f, 0.05458496f, -0.03611241f, -0.16147222f, -0.04264962f, -0.31737384f, -0.06588104f, 0.40360451f, 
    0.19895266f, -0.01275073f, 0.08526216f, -0.02456147f, 0.20913786f, -0.30930194f, 0.21678460f, -0.13004653f, 
    0.15237120f, 0.10822970f, 0.06889195f, 0.22536626f, 0.23169152f, -0.11436260f, -0.00967936f, 0.18315555f, 
    -0.09987290f, 0.00035854f, 0.21345404f, -0.00596588f, -0.25392962f, -0.11627460f, -0.00754777f, 0.01138874f, 
    -0.03363416f, 0.04735867f, 0.00282873f, 0.37610972f, -0.06864453f, 0.07677684f, 0.03069907f, -0.01875209f, 
    0.14268860f, -0.29861429f, -0.10266942f, -0.01472464f, -0.22187392f, -0.07639325f, 0.04466198f, 0.05195607f, 
    0.19056897f, -0.18113364f, -0.36960590f, -0.12025490f, 0.00258178f, -0.09752940f, 0.09515332f, -0.03877025f, 
    0.12385704f, -0.08465200f, 0.00442881f, 0.08075910f, 0.17906357f, -0.04072627f, 0.18670651f, -0.26315555f, 
    -0.39445820f, -0.06192941f, -0.04660813f, 0.05297396f, 0.05864461f, 0.03507688f, -0.14243954f, 0.01204810f, 
    -0.04341574f, -0.10466626f, -0.28257453f, -0.05560938f, -0.09412538f, 0.16406628f, -0.08209179f, -0.13299119f, 
    -0.26773566f, -0.40335158f, -0.08046517f, -0.10229637f, -0.10232634f, -0.05145086f, -0.24697559f, 0.14887190f, 
    -0.01548293f, 0.06080275f, 0.04350361f, 0.12093630f, -0.23534293f, 0.13816303f, -0.03416389f, 0.11102507f, 
    0.10349098f, 0.15518439f, 0.07364562f, 0.24608174f, 0.04585271f, -0.13915548f, 0.13757482f, -0.11945955f, 
    0.04161831f, 0.06865939f, 0.12715401f, 0.04140069f, -0.07729743f, 0.02965813f, 0.03735977f, 0.09988540f, 
    0.06839280f, 0.15780184f, -0.29184210f, 0.05787382f, -0.24682505f, 0.05118774f, -0.08519790f, 0.03128530f, 
    0.10476620f, 0.11067365f, -0.10846569f, -0.01175302f, 0.02076240f, -0.49364114f, 0.07199199f, -0.21660058f, 
    -0.00090155f, -0.09481839f, -0.02998521f, 0.02291670f, 0.20671512f, 0.07559949f, -0.04159935f, -0.09948258f, 
    -0.01357161f, -0.02372070f, -0.19199724f, -0.06822720f, 0.15087716f, -0.20507331f, 0.12437015f, 0.06998957f, 
    0.01358586f, -0.03091982f, -0.11177230f, 0.14089413f, -0.08957166f, 0.03771813f, -0.10938180f, -0.07279142f, 
    0.06442844f, 0.04110479f, 0.00887787f, -0.00356668f, -0.08892441f, 0.00297222f, -0.01871916f, 0.05136959f, 
    0.04139386f, -0.03091861f, -0.05642273f, -0.08246300f, -0.06476481f, -0.10556110f, 0.04449511f, 0.02823818f, 
    -0.07223380f, -0.06749301f, 0.00730148f, 0.03976646f, -0.06871179f, -0.01271888f, -0.02882704f, 0.04578600f, 
    0.05161683f, -0.08145913f, 0.02242516f, 0.02636369f, 0.03354664f, 0.00949649f, -0.00480303f, 0.02883036f, 
    -0.07724617f, -0.10113805f, 0.05930859f, 0.05696505f, -0.10375118f, -0.07054499f, -0.05676313f, -0.00104688f, 
    -0.05491741f, -0.01256193f, 0.01906005f, 0.04452905f, -0.04771977f, -0.04183942f, 0.02307050f, -0.07655811f, 
    -0.05129725f, -0.05826828f, -0.08883636f, -0.02731277f, 0.03582654f, -0.09708793f, -0.00479954f, 0.02176188f, 
    -0.10025296f, -0.08324514f, -0.06656870f, -0.09384097f, -0.05946257f, 0.01696985f, 0.03659409f, -0.10326527f, 
    -0.02051029f, 0.03089035f, -0.01064620f, 0.04352633f, 0.03211548f, -0.10285681f, 0.04511998f, -0.07268734f, 
    -0.08445667f, -0.04866527f, -0.02408603f, -0.05448888f, 0.01341946f, 0.02704569f, 0.03532058f, -0.03106974f, 
    -0.07133551f, -0.11244425f, -0.05263723f, 0.01675148f, 0.08476493f, 0.01794542f, -0.06874359f, -0.04050970f, 
    0.00409485f, -0.05166841f, 0.04777462f, -0.10501154f, 0.04598648f, -0.04044154f, -0.00000219f, -0.04055021f, 
    0.00798656f, 0.04709636f, -0.07331330f, -0.02735105f, 0.04400659f, 0.00188667f, 0.05284670f, 0.03411073f, 
    0.02378269f, 0.08303291f, -0.04239850f, -0.09873719f, -0.04040668f, -0.03873616f, -0.00557571f, 0.01174472f, 
    0.03326383f, 0.00339025f, 0.01347721f, 0.07067639f, -0.02523630f, -0.05598023f, -0.07213558f, -0.05840808f, 
    -0.01883139f, -0.06576031f, -0.00288071f, -0.06651881f, -0.01585437f, -0.00446956f, 0.00773329f, -0.02879369f, 
    -0.04046439f, 0.04306567f, -0.04887431f, -0.04539250f, -0.04952118f, 0.04014835f, 0.01032234f, 0.00489423f, 
    0.05664220f, -0.08195091f, 0.02439106f, 0.03319129f, 0.00548290f, -0.01948547f, -0.04078465f, 0.06134330f, 
    -0.00792774f, 0.05327485f, -0.10812046f, -0.07095949f, -0.02929137f, -0.09206113f, -0.06099010f, -0.05334737f, 
    -0.01384511f, 0.06578563f, 0.06273597f, -0.06050198f, -0.04993572f, 0.02104991f, 0.01223447f, 0.01406561f, 
    -0.06700398f, -0.05713053f, 0.06705225f, -0.06432440f, -0.03476544f, -0.07722278f, 0.01571523f, 0.06530826f, 
    -0.06212881f, 0.02889080f, 0.01120822f, -0.02459602f, -0.09658693f, 0.01631977f, -0.04933067f, 0.04304625f, 
    -0.07993162f, 0.01386419f, -0.04335223f, 0.03011783f, 0.04751265f, 0.00739730f, -0.08710711f, -0.02455181f, 
    -0.07487049f, -0.06341414f, -0.03737407f, -0.05227145f, -0.03879109f, 0.04997424f, -0.11699020f, -0.01893291f, 
    0.08821875f, 0.00937675f, -0.08971550f, 0.05869609f, -0.09110935f, 0.06766562f, -0.00025884f, 0.04508449f, 
    -0.08830006f, -0.00349686f, 0.04357457f, 0.03626180f, -0.01339975f, 0.05809426f, 0.00895964f, -0.04244174f, 
    -0.09816226f, -0.11174505f, 0.03332901f, -0.06112477f, 0.01423245f, 0.05409053f, 0.04905438f, -0.06778762f, 
    0.00401221f, -0.08922297f, 0.02847003f, -0.05026723f, -0.00835654f, -0.00192981f, 0.07098351f, 0.06465773f, 
    -0.02884823f, -0.05886296f, 0.05316686f, -0.05866174f, 0.07760978f, -0.08101049f, 0.03488473f, 0.06240153f, 
    -0.03512568f, 0.01443652f, 0.02642438f, -0.02465796f, -0.01071355f, -0.00110536f, 0.00247875f, 0.01910540f, 
    0.02052175f, 0.00272513f, -0.00085328f, -0.09266189f, 0.02794511f, -0.01206789f, -0.05493801f, -0.04959214f, 
    0.03765384f, -0.04776785f, 0.00542880f, 0.07316537f, -0.07144586f, 0.06625380f, -0.06762049f, -0.11232401f, 
    -0.19943167f, -0.29795691f, -0.09679852f, -0.05564162f, 0.23683213f, -0.02973189f, -0.15943545f, -0.06790047f, 
    0.13348989f, 0.03934876f, 0.03398142f, 0.06046484f, -0.13440509f, -0.08404732f, -0.32839087f, 0.15869141f, 
    0.08238750f, -0.07922836f, 0.00761395f, -0.59267092f, 0.01364852f, -0.07572893f, -0.08720656f, -0.01760178f, 
    0.06733690f, 0.07230395f, -0.19744639f, 0.06597859f, 0.06724094f, 0.39069653f, -0.05718607f, 0.15599550f, 
    -0.02621835f, 0.14827020f, 0.05121808f, -0.25039625f, 0.17818259f, -0.24435550f, -0.23443753f, -0.00190333f, 
    -0.06546512f, -0.07357767f, -0.00456168f, 0.01661564f, -0.02009803f, -0.46241170f, 0.10450430f, -0.00437740f, 
    0.24185799f, -0.05180694f, 0.22950496f, -0.25646853f, -0.13572322f, -0.18114753f, 0.01307371f, 0.09567136f, 
    -0.04878409f, -0.09576938f, -0.03396847f, -0.27564201f, 0.01061087f, 0.28016579f, -0.07754157f, 0.12436829f, 
    0.00789655f, 0.28714684f, -0.09468856f, 0.02097780f, 0.12501900f, 0.03523999f, -0.57994604f, 0.36381942f, 
    -0.28463259f, -0.22779797f, 0.13267140f, 0.09313994f, 0.01964288f, 0.14712846f, -0.28467229f, 0.07877449f, 
    -0.59728432f, -0.25898570f, -0.42107329f, -0.05187941f, 0.00727680f, 0.12487216f, 0.04961488f, -0.20889807f, 
    -0.26397327f, 0.11036243f, 0.06349064f, -0.07292124f, 0.06483143f, -0.09755029f, 0.06437311f, -0.01880115f, 
    -0.04208648f, -0.95231640f, 0.02476699f, -0.04031781f, 0.12455070f, -0.03747824f, -0.20827240f, 0.02487510f, 
    0.17114460f, -0.05431872f, -0.06130799f, -0.01006612f, 0.12601633f, -0.01493504f, 0.04644952f, 0.12088928f, 
    -0.47888216f, -0.04473525f, 0.19863757f, 0.04020967f, 0.03346570f, 0.04057980f, 0.25580296f, 0.36587951f, 
    0.00776160f, 0.20134416f, 0.08967142f, 0.18216132f, 0.30892190f, 0.21608774f, -0.35881752f, 0.15325274f, 
    -0.17566521f, -0.20053151f, -0.13471574f, -0.07105592f, -0.15605508f, -0.03804469f, 0.03662593f, 0.08536136f, 
    -0.10595720f, 0.01671702f, 0.04836412f, 0.07631307f, 0.26527989f, 0.14262778f, -0.04299192f, 0.17741397f, 
    0.02200332f, -0.08091041f, 0.09466658f, -0.36111993f, 0.09615041f, 0.04955282f, -0.01226149f, -0.03623698f, 
    0.29050246f, -0.06120975f, -0.39973310f, 0.04156227f, 0.00421502f, 0.41289592f, 0.09701948f, 0.24853826f, 
    -0.07351378f, -0.18421006f, 0.06969688f, -0.06233441f, 0.12072846f, -0.20014450f, 0.14497133f, -0.06754304f, 
    -0.32408020f, 0.08685425f, 0.26463255f, 0.18921432f, 0.13680492f, -0.04265571f, 0.16830064f, 0.00989178f, 
    0.05138649f, 0.02876178f, 0.14469530f, -0.43794474f, 0.08458640f, -0.18271469f, 0.08357105f, 0.08649489f, 
    -0.67657053f, 0.18346182f, -0.05468869f, 0.02220794f, 0.29605463f, 0.66034722f, -0.05189804f, 0.10915320f, 
    -0.07525132f, 0.38443428f, -0.28133512f, 0.04300400f, -0.11739504f, -0.05392205f, -0.21841706f, 0.00043925f, 
    -0.07807906f, -0.13841620f, 0.05343423f, -0.09392066f, 0.23526284f, 0.05035669f, -0.24578068f, 0.14920196f, 
    -0.47441787f, -0.21183772f, -0.29572877f, 0.01399369f, 0.01240036f, -0.27246255f, -0.03971420f, -0.06096094f, 
    0.24164107f, 0.06218076f, 0.17470983f, 0.10214925f, -0.08895183f, -0.23548780f, -0.03412614f, -0.07257927f, 
    -0.08192194f, -0.31306094f, -0.09055270f, -0.01510646f, -0.07314452f, 0.00396767f, 0.01286202f, -0.16271670f, 
    0.37334785f, -0.07408470f, -0.08278916f, -0.00522669f, 0.08955692f, 0.15201932f, 0.01612895f, 0.09835800f, 
    -0.01271979f, -0.06787621f, 0.05900653f, -0.06989529f, 0.19722889f, -0.04238544f, 0.01244099f, 0.33680382f, 
    -0.10111846f, 0.22759409f, 0.12901552f, 0.18745981f, 0.13172865f, 0.10066804f, -0.12300994f, 0.03794550f, 
    -0.51687998f, -0.06007963f, -0.18157533f, 0.00178144f, 0.03357803f, -0.13517897f, -0.28334409f, -0.09167286f, 
    0.01055039f, -0.19456804f, -0.01569224f, 0.36193907f, 0.29251641f, -0.03360336f, 0.03775457f, 0.16003364f, 
    -0.08865083f, -0.50638974f, -0.01823961f, -0.21583645f, 0.21887591f, 0.12681523f, -0.05982782f, -0.15821700f, 
    0.12403663f, -0.15731321f, 0.37771779f, -0.08518462f, -0.05708831f, 0.37022007f, 0.07224716f, 0.16703615f, 
    0.16833802f, -0.26368177f, 0.04589378f, -0.28738672f, 0.09627482f, 0.21604578f, 0.20118734f, -0.12373968f, 
    -0.27097821f, 0.03596619f, 0.15461248f, 0.23679887f, 0.09107040f, -0.08167200f, 0.18415876f, -0.13170001f, 
    -0.20047903f, 0.01896623f, 0.11925198f, 0.11901185f, -0.05232964f, -0.23628695f, -0.00984013f, 0.06451478f, 
    -0.10095853f, -0.06747887f, -0.13246520f, -0.10537122f, 0.17475756f, 0.66021383f, -0.23752466f, 0.10958402f, 
    -0.04014289f, 0.37531081f, -0.10720827f, 0.19801123f, -0.33812666f, 0.33771041f, -0.23562041f, -0.11231848f, 
    0.04318018f, -0.08358868f, -0.03295039f, 0.08341236f, 0.50531560f, 0.12489505f, -0.02971506f, 0.02488050f, 
    -0.12714596f, -0.28367311f, -0.10305884f, -0.07848166f, -0.03075118f, 0.00358840f, -0.35947534f, 0.19994779f, 
    0.15129526f, 0.07468040f, -0.03872932f, 0.17257454f, 0.09734960f, 0.10440625f, -0.00342063f, 0.07272483f, 
    0.20874037f, -0.00422698f, -0.19276634f, 0.07306866f, -0.10043953f, 0.15039670f, 0.16444077f, -0.14416249f, 
    0.35974327f, -0.01563194f, -0.04212530f, 0.12159394f, 0.16489938f, 0.27216759f, 0.01090579f, -0.02496272f, 
    -0.11800604f, -0.06092765f, -0.09143492f, 0.01076863f, 0.30856544f, 0.09423750f, 0.11257393f, 0.52477980f, 
    -0.22695744f, 0.21491066f, -0.03783805f, 0.29039961f, 0.09962446f, 0.01110114f, -0.19321035f, -0.21457805f, 
    0.03687165f, -0.03171404f, -0.03872009f, 0.05421822f, -0.01053098f, -0.05621186f, 0.01960620f, -0.05344604f, 
    -0.00511115f, 0.03001445f, -0.00930717f, 0.00449788f, -0.04705351f, -0.02258482f, -0.08673889f, -0.03730707f, 
    0.06509980f, 0.05977632f, 0.04999220f, -0.02240520f, -0.01268795f, -0.09464892f, 0.03128660f, -0.06268171f, 
    -0.04396112f, 0.01360626f, 0.03729132f, -0.02895770f, 0.01388030f, -0.05557666f, -0.03070333f, -0.02585886f, 
    -0.06273134f, -0.08749409f, -0.01651191f, 0.01520980f, 0.05362554f, -0.03603204f, -0.05745553f, 0.07897239f, 
    -0.02969631f, -0.04359505f, -0.02616286f, 0.00541683f, -0.05915569f, -0.03565776f, -0.01369380f, -0.03702198f, 
    -0.01276341f, 0.06704716f, -0.04560699f, -0.06819720f, -0.02060655f, 0.05320478f, -0.02293584f, 0.03773784f, 
    0.05472986f, -0.00106004f, -0.01638511f, 0.03806604f, -0.05587351f, 0.04609329f, -0.06186870f, -0.00369650f, 
    0.08720060f, -0.09574626f, 0.01678730f, -0.02174707f, -0.01567448f, -0.05906411f, 0.00789784f, 0.00823730f, 
    0.07497843f, 0.07355160f, -0.06238818f, -0.01702480f, -0.06867855f, 0.01607809f, 0.06966704f, 0.01212094f, 
    0.05152487f, -0.05506483f, 0.01459032f, -0.06525427f, -0.01608493f, -0.02673835f, -0.02326715f, -0.01479016f, 
    -0.04091677f, 0.02967044f, 0.01367925f, 0.06852300f, -0.03881867f, 0.07457018f, 0.05985576f, 0.03217605f, 
    0.05220644f, -0.06968515f, 0.05920077f, -0.05880295f, -0.07805275f, -0.00642658f, 0.03336623f, -0.06617907f, 
    0.03967103f, -0.06324870f, -0.03019834f, 0.03493249f, 0.04406585f, -0.04094735f, -0.01821820f, -0.05663171f, 
    -0.06047665f, -0.03605316f, 0.05658865f, 0.07487849f, -0.07326943f, -0.08707441f, 0.01049759f, 0.04678663f, 
    0.02962277f, -0.00155482f, 0.03714380f, 0.01663706f, -0.06167769f, -0.00148639f, -0.05458693f, 0.06178524f, 
    0.04873157f, 0.06278823f, -0.03875979f, -0.07185795f, 0.07523470f, -0.06408484f, -0.00661392f, -0.01480330f, 
    -0.07108083f, -0.05475807f, 0.04782250f, -0.02034513f, -0.04137243f, -0.06666993f, 0.06098979f, 0.04600087f, 
    -0.01368186f, 0.05074991f, 0.05832899f, 0.02749898f, -0.06808348f, 0.04650788f, -0.05955593f, -0.07159466f, 
    0.02221414f, -0.06597557f, -0.05113987f, -0.08137000f, 0.00485163f, -0.00813577f, -0.08679972f, 0.05621184f, 
    -0.02914539f, -0.01902144f, 0.01303081f, -0.01016650f, -0.01187143f, 0.01212260f, 0.00445992f, 0.01166211f, 
    -0.10904641f, 0.06948404f, -0.08318702f, -0.04683932f, -0.01632843f, 0.05700660f, 0.05936449f, 0.02972569f, 
    0.06488286f, -0.08087505f, -0.05237844f, 0.05705537f, -0.01411021f, 0.04595399f, -0.04501470f, 0.03054612f, 
    -0.11120144f, 0.07975522f, -0.03458447f, 0.04832339f, -0.08170747f, -0.01873045f, -0.06986198f, -0.08342633f, 
    0.02125996f, -0.00277739f, 0.04914302f, 0.01470006f, -0.00595562f, -0.04706251f, -0.07383841f, -0.01423301f, 
    0.01783519f, -0.04718328f, 0.02417287f, 0.06462270f, 0.07057101f, -0.05619123f, 0.02310289f, -0.07362800f, 
    -0.02312788f, -0.06860830f, -0.09372960f, -0.00087989f, -0.01517753f, -0.06515787f, -0.03483254f, -0.08643645f, 
    -0.02537106f, -0.00701404f, 0.07635773f, 0.01456400f, 0.04543054f, -0.02253579f, 0.08014268f, 0.04603314f, 
    0.06513674f, -0.03143590f, -0.07493741f, 0.02695041f, -0.05580445f, -0.04834437f, -0.01028564f, -0.06225172f, 
    -0.01529401f, 0.00500694f, -0.06884407f, -0.07664922f, 0.03813010f, -0.09637767f, 0.02448187f, -0.05467684f, 
    -0.09659436f, 0.00299822f, -0.06643111f, -0.06336956f, 0.03415521f, -0.05488552f, 0.02511286f, -0.07408293f, 
    -0.01364177f, -0.06240769f, -0.04317882f, 0.06052199f, 0.00221031f, -0.00002863f, -0.04828715f, 0.00128413f, 
    0.02329026f, -0.05027103f, -0.01045399f, 0.01521207f, 0.03659604f, -0.00553990f, 0.02785872f, -0.06810737f, 
    -0.06988492f, -0.08676346f, -0.06799299f, -0.08640408f, 0.02500317f, -0.00165643f, 0.03224024f, 0.04683078f, 
    0.04666190f, 0.05709600f, -0.06241045f, -0.02278736f, 0.07053909f, -0.06699202f, -0.00805929f, 0.01419615f, 
    -0.02333415f, -0.04287505f, -0.01503664f, 0.04825207f, -0.06600007f, -0.03075141f, 0.01234423f, -0.04168049f, 
    0.01106387f, 0.03263474f, 0.02053447f, -0.00670970f, -0.06293035f, -0.02167144f, -0.00880270f, 0.04169137f, 
    0.01863173f, -0.06383950f, 0.05029566f, 0.00891618f, -0.04711579f, 0.08716562f, -0.05153476f, -0.00092320f, 
    0.02862138f, -0.07687908f, 0.00888862f, -0.10841804f, 0.05674741f, -0.01262833f, -0.06248730f, 0.05260620f, 
    0.01119201f, -0.01624416f, 0.03547452f, -0.01694522f, -0.02992551f, 0.04584245f, -0.02195074f, -0.06584011f, 
    0.05590379f, 0.04440581f, -0.02946039f, 0.02511794f, 0.01114265f, -0.06914296f, 0.01911995f, -0.07609040f, 
    0.02302705f, -0.04638942f, -0.05076255f, -0.00298690f, 0.05408408f, 0.02350634f, -0.08383042f, -0.08094390f, 
    -0.06467431f, -0.07055950f, -0.05175610f, 0.04989245f, -0.07332154f, -0.04439817f, -0.06066409f, 0.04602976f, 
    0.07508027f, 0.06159332f, -0.05138380f, -0.03858317f, -0.08367626f, -0.04572303f, -0.06093391f, 0.01827125f, 
    -0.02441065f, -0.02040072f, -0.06623704f, 0.06498923f, -0.04404297f, 0.03584675f, -0.02238847f, -0.01506934f, 
    -0.06309243f, 0.04515570f, 0.05598316f, -0.07283528f, -0.01577818f, -0.04848928f, -0.04809710f, -0.09255390f, 
    -0.04139819f, 0.05411446f, 0.05126748f, 0.01718475f, -0.03021100f, -0.11227816f, -0.04439075f, 0.02975723f, 
    0.03292507f, 0.02648066f, 0.06086718f, -0.00502723f, 0.02731285f, -0.10647048f, -0.07802771f, -0.03300001f, 
    -0.11060459f, 0.10879928f, 0.19752258f, 0.02232945f, -0.01624112f, 0.40108702f, 0.05927835f, 0.15003918f, 
    0.01758741f, 0.09661961f, -0.05935044f, -0.22985426f, 0.12606935f, 0.32977149f, -0.02809860f, -0.12184285f, 
    0.29650027f, -0.20825686f, 0.16122554f, 0.09910605f, 0.28486094f, 0.01713330f, 0.03431832f, 0.25063246f, 
    0.27563265f, -0.12816226f, -0.38301161f, 0.13631332f, 0.16400598f, -0.30734494f, 0.17947125f, 0.04710462f, 
    0.21542673f, 0.16915423f, -0.05434181f, 0.28045487f, 0.07212246f, -0.00432469f, 0.12152892f, -0.04453049f, 
    -0.06691553f, -0.18711628f, -0.00985464f, 0.05335151f, -0.06125771f, -0.24559633f, -0.04773530f, 0.06833479f, 
    0.15097354f, -0.01797473f, -0.22784790f, 0.02527869f, 0.21186076f, 0.01429034f, 0.07680447f, -0.15833974f, 
    -0.09035718f, -0.28758293f, -0.21155748f, -0.14665009f, 0.24072430f, -0.36073342f, 0.03198240f, 0.21351039f, 
    0.01666255f, -0.01182533f, 0.06088551f, 0.08650823f, 0.17071220f, 0.05770059f, -0.04623522f, -0.16761971f, 
    -0.03951368f, 0.24709229f, 0.13695453f, 0.25927728f, -0.01454508f, -0.41872272f, -0.09348243f, -0.01076246f, 
    0.03287651f, 0.02696428f, 0.06235257f, 0.06128946f, -0.04864179f, -0.07098233f, 0.18037352f, -0.35699663f, 
    0.16977203f, 0.03034279f, 0.35137889f, 0.08781346f, -0.05374077f, 0.19238885f, -0.02604471f, 0.01019107f, 
    0.14970610f, -0.10001904f, 0.34137076f, -0.06121861f, 0.05196197f, -0.05599719f, -0.10483608f, 0.12919171f, 
    0.16685618f, 0.00469832f, 0.00159736f, -0.02523508f, -0.15082066f, 0.04815517f, 0.03783864f, -0.12639225f, 
    -0.01610765f, 0.04761588f, 0.00121668f, -0.02478078f, -0.16790310f, 0.05213802f, 0.08181197f, -0.47314471f, 
    0.11342192f, -0.26935211f, 0.25643602f, -0.24176668f, -0.05301873f, 0.00850951f, -0.12971720f, 0.27080962f, 
    -0.06366047f, -0.08072693f, 0.03216866f, -0.01698520f, -0.09296625f, -0.05785672f, 0.05935196f, 0.03476632f, 
    0.05565447f, -0.02160747f, -0.03197878f, 0.00165031f, -0.03098148f, -0.08872525f, -0.06958813f, -0.03752571f, 
    -0.05036981f, -0.02458882f, 0.01562022f, -0.04892634f, -0.09407164f, 0.04694401f, -0.04897879f, -0.02298587f, 
    0.04945209f, -0.08704156f, 0.00538283f, -0.02016329f, -0.08969927f, -0.08439639f, 0.03915827f, -0.02070502f, 
    -0.08143824f, -0.05042252f, 0.06522609f, -0.03200046f, 0.03149484f, -0.09368012f, 0.02283732f, 0.02718530f, 
    -0.06559667f, -0.07266977f, -0.03429193f, -0.07718937f, 0.03022334f, -0.07158918f, -0.03076953f, 0.03325452f, 
    0.04389577f, 0.08617849f, -0.06682093f, -0.02774340f, 0.03120708f, -0.03323941f, -0.03168025f, 0.07391942f, 
    -0.08789467f, -0.00468902f, -0.02752843f, -0.02715729f, -0.02691436f, -0.01775236f, -0.07888266f, 0.03838515f, 
    0.03893155f, -0.07692558f, -0.01126250f, -0.00829509f, -0.01814255f, -0.06705418f, -0.03927323f, 0.04010919f, 
    0.05719414f, 0.01533213f, -0.06555988f, 0.05648861f, -0.05237617f, -0.09294586f, -0.02883762f, -0.02061929f, 
    -0.05498109f, -0.01413578f, 0.05059110f, 0.05449422f, -0.02695571f, -0.04542528f, -0.09166047f, 0.07234793f, 
    0.01350196f, 0.05398386f, -0.06832779f, -0.09353504f, -0.07671084f, -0.01537804f, 0.03311053f, -0.02728370f, 
    -0.09834251f, -0.03156121f, 0.04431774f, 0.02904468f, -0.01236266f, -0.05477382f, 0.00237803f, 0.05927403f, 
    -0.02769493f, 0.06017854f, 0.08504818f, -0.08848864f, 0.01337984f, -0.02767859f, 0.06632694f, -0.08385580f, 
    0.04115814f, 0.04653145f, -0.07235058f, 0.08189619f, -0.00798906f, -0.04800550f, 0.00953908f, -0.04689887f, 
    -0.04035352f, -0.05417366f, 0.02007194f, -0.05143500f, -0.09090605f, -0.00745363f, -0.02086840f, 0.04962283f, 
    -0.18169507f, 0.21099481f, 0.12565555f, -0.01372179f, -0.31392753f, 0.06776701f, 0.07974628f, -0.32846648f, 
    0.02427956f, -0.05960387f, -0.08763600f, -0.04126560f, 0.19677486f, 0.29796484f, -0.01201619f, -0.09682726f, 
    -0.16442020f, 0.09855554f, -0.01006712f, -0.06824997f, 0.12481572f, 0.20049016f, 0.00481055f, 0.09422740f, 
    -0.13704236f, -0.10807224f, -0.19724199f, -0.13665949f, -0.02632033f, -0.02769904f, 0.15920770f, -0.01003175f, 
    -0.16944632f, -0.07740109f, -0.04885817f, 0.10456370f, 0.07073261f, -0.09030522f, 0.20307763f, 0.32307717f, 
    -0.21705578f, 0.19866094f, -0.05308453f, 0.29560623f, 0.04960302f, -0.19765455f, -0.02418156f, -0.03120010f, 
    0.15454067f, -0.01400476f, 0.19802618f, 0.16253568f, -0.06294714f, 0.12002632f, -0.04227758f, -0.04729819f, 
    0.04852737f, 0.27608073f, -0.09728179f, -0.16161960f, 0.20450577f, 0.02824944f, 0.21785542f, 0.20166554f, 
    0.02931507f, 0.08046056f, -0.21433753f, 0.11329274f, 0.07724020f, -0.01459636f, -0.14337090f, -0.09628791f, 
    0.12966451f, 0.35647938f, 0.23148775f, -0.13008921f, -0.06683371f, -0.11341009f, 0.13669433f, 0.01623251f, 
    -0.20757522f, -0.08325174f, -0.11412158f, -0.01161407f, -0.09359938f, 0.17855932f, 0.11936197f, -0.10809826f, 
    -0.17124106f, -0.06726898f, 0.37683031f, 0.04343287f, -0.08273689f, 0.08679304f, 0.02868793f, -0.06799854f, 
    0.09493020f, -0.14356752f, 0.19856869f, 0.01447689f, 0.16913687f, -0.10985581f, -0.09378207f, 0.29842904f, 
    0.06053631f, -0.01275932f, 0.05659117f, -0.04063271f, -0.06816547f, 0.04345064f, -0.00209150f, 0.14534631f, 
    0.35360044f, -0.03139855f, 0.29080999f, 0.00613581f, 0.18506548f, -0.16345674f, -0.14784883f, 0.08115412f, 
    -0.34499741f, 0.00960359f, -0.02716132f, 0.26568386f, 0.03569693f, -0.01986255f, -0.24430175f, 0.17180209f, 
    0.02341929f, 0.05147459f, 0.01709384f, -0.02787306f, -0.04479906f, -0.04871413f, -0.03149378f, 0.03855064f, 
    0.08762839f, -0.08106904f, -0.03117078f, -0.04488976f, -0.04452705f, -0.03225550f, -0.06611982f, -0.07764313f, 
    -0.00244721f, -0.00593613f, 0.05660855f, -0.08582200f, 0.06869373f, 0.02971759f, 0.07552390f, 0.07310301f, 
    0.06814595f, -0.03775790f, 0.05379717f, 0.07353051f, -0.03655965f, 0.00748660f, 0.02313508f, -0.08510179f, 
    0.07087363f, -0.01339979f, -0.04282646f, -0.01887101f, 0.02935934f, 0.00425202f, -0.05746758f, 0.07046607f, 
    0.01210888f, -0.05932589f, -0.02169815f, 0.00689859f, 0.08323030f, -0.06691128f, 0.07287009f, -0.06688221f, 
    -0.02474329f, 0.05640007f, -0.07438295f, -0.05642851f, -0.00321484f, -0.01324162f, 0.07860622f, 0.03436819f, 
    0.01859777f, -0.02595359f, -0.05975380f, -0.05979966f, -0.07557806f, -0.06280823f, 0.03887922f, -0.06623942f, 
    -0.02636729f, -0.03863741f, 0.00635224f, 0.04445816f, 0.02826560f, -0.03227051f, -0.04190636f, -0.07218984f, 
    -0.03799183f, 0.06225459f, -0.06103589f, -0.01872776f, 0.06462727f, -0.02733766f, 0.01994504f, -0.06378008f, 
    0.05625511f, 0.00180069f, 0.01447264f, -0.01031685f, 0.08785237f, 0.06680647f, 0.04984390f, -0.05739751f, 
    0.06065305f, -0.05622484f, 0.07428497f, -0.04380125f, -0.06834076f, -0.00430602f, -0.06540333f, -0.04869851f, 
    -0.08317983f, -0.08090214f, 0.01768915f, 0.04845202f, -0.05323998f, -0.05973395f, -0.01703313f, 0.01829603f, 
    -0.07221258f, 0.05016797f, -0.03350661f, -0.08104422f, -0.06042318f, 0.01757014f, 0.00055412f, -0.03145821f, 
    0.03289768f, 0.00832251f, -0.06968660f, -0.07705906f, -0.07163102f, -0.05691081f, -0.02306743f, -0.00968996f, 
    -0.07194291f, -0.03666663f, -0.03929744f, 0.00902849f, 0.03420550f, 0.02973620f, 0.04228429f, -0.06748375f, 
    -0.12847310f, -0.21614397f, 0.22711152f, -0.02670327f, 0.25441799f, 0.04573654f, -0.23931202f, -0.03620204f, 
    0.03899414f, 0.15688781f, -0.08301906f, 0.42234525f, -0.09239390f, -0.14472601f, -0.22143352f, 0.19610573f, 
    0.10175923f, -0.15044442f, -0.17523856f, -0.25060830f, -0.03946435f, -0.07181157f, -0.04701166f, -0.12056125f, 
    0.05675049f, 0.10538790f, 0.37331051f, 0.29916441f, 0.30482322f, 0.08270051f, 0.10322827f, 0.06152795f, 
    -0.07980040f, 0.32411435f, -0.03937363f, -0.08074035f, 0.23992725f, -0.06673844f, 0.09089963f, 0.16341512f, 
    -0.32606485f, 0.11298947f, 0.11005411f, 0.13921489f, -0.13061473f, -0.16309851f, -0.02382268f, 0.19040655f, 
    0.01737327f, 0.00151857f, -0.01449891f, -0.02853960f, -0.10681260f, 0.13793795f, -0.08761498f, -0.11237580f, 
    -0.16245112f, -0.33615264f, 0.19792613f, -0.15349303f, -0.10426851f, 0.04569437f, -0.03042217f, 0.17369559f, 
    -0.06097993f, 0.03301891f, -0.06907284f, 0.11850899f, 0.13694897f, 0.08626444f, -0.21375184f, 0.60013670f, 
    -0.16172768f, 0.04682955f, 0.10191406f, 0.40535092f, 0.15052949f, 0.27564126f, 0.08495077f, 0.32126170f, 
    -0.08521195f, 0.16872267f, 0.06744586f, -0.05021353f, -0.06814788f, 0.54258490f, 0.16918954f, -0.51189750f, 
    -0.42217466f, 0.08547283f, -0.12371650f, 0.04213307f, 0.00224440f, -0.08970623f, 0.06910335f, 0.08733222f, 
    -0.13423865f, -0.60578895f, -0.09328601f, -0.04194860f, 0.07605150f, -0.67137474f, -0.12724683f, 0.17656110f, 
    0.21541971f, -0.01182304f, -0.02657329f, -0.03583266f, 0.11157064f, -0.05181652f, -0.03670182f, -0.07877894f, 
    -0.31684935f, -0.04277832f, -0.02960273f, -0.09643548f, 0.25472301f, 0.10523272f, 0.47579509f, 0.04605380f, 
    0.15680073f, 0.20027964f, -0.06508642f, 0.22050889f, 0.19975068f, 0.21001191f, -0.31113988f, 0.07642493f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.27163041f, 0.02935343f, -0.07522752f, -0.10095162f, 0.46593726f, 0.08808625f, 0.12482022f, -0.09073356f, 
    0.12142096f, -0.10282669f, 0.07702129f, -0.10073188f, -0.01054516f, 0.26456827f, -0.11435574f, 0.10620808f, 
    -0.01301515f, -0.09380861f, 0.18918137f, 0.11931497f, -0.00068573f, -0.02031176f, -0.20209163f, -0.00630140f, 
    -0.03396051f, -0.07985008f, 0.13547708f, 0.12009203f, 0.18872833f, -0.09365597f, -0.10862453f, 0.32247996f, 
    0.15570278f, 0.03468490f, 0.19686559f, 0.01900119f, 0.03995054f, 0.14312071f, 0.16140424f, 0.00548855f, 
    0.18393797f, -0.03287998f, -0.09001539f, 0.15706334f, -0.04924897f, -0.02924727f, 0.10218042f, 0.20763212f, 
    -0.06388007f, 0.18034604f, 0.02027769f, 0.10934103f, -0.08903777f, -0.05030329f, 0.01240773f, 0.15144682f, 
    0.12852135f, -0.03218937f, -0.00178233f, -0.05901963f, 0.05321131f, 0.13296027f, -0.05260175f, 0.07169954f, 
    0.06208839f, 0.16472729f, -0.04923571f, 0.19353539f, 0.21599707f, -0.02657158f, 0.17690125f, 0.30970275f, 
    0.15434846f, -0.02085281f, 0.06843544f, 0.20018621f, -0.03328238f, 0.16407834f, -0.08206695f, 0.13062896f, 
    0.00699789f, 0.02068301f, -0.07690645f, 0.10768330f, 0.04648253f, 0.11985508f, 0.07656469f, -0.01983749f, 
    -0.02228858f, 0.32503250f, 0.01040810f, 0.00077240f, 0.06541429f, -0.10551542f, 0.24191087f, 0.22831789f, 
    0.09254927f, -0.00089115f, -0.04534359f, 0.08160740f, -0.02838031f, -0.06731973f, -0.02057956f, -0.03390187f, 
    0.22944459f, 0.13440709f, 0.21038298f, -0.05652796f, 0.20405442f, 0.19489183f, 0.03339630f, -0.00402452f, 
    0.33554211f, 0.05790349f, -0.06720473f, -0.01277609f, -0.03227398f, 0.13302684f, 0.22388238f, 0.27668628f, 
    -0.08075282f, 0.00643087f, 0.06145837f, -0.02249550f, -0.02056218f, 0.10107566f, -0.00934170f, 0.26863721f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.36868760f, -0.02418767f, -0.08702377f, -0.10423243f, -0.74793452f, 0.19954768f, -0.02569312f, -0.01382131f, 
    -0.24738406f, 0.00056112f, 0.02604225f, 0.14448695f, 0.01486503f, -0.35963431f, -0.00685954f, -0.25879049f, 
    -0.37140012f, -0.07480235f, -0.06784837f, 0.15193529f, 0.09680819f, 0.00744293f, 0.14534983f, -0.06850705f, 
    -0.11787266f, -0.02447871f, -0.50638503f, -0.10839143f, -0.17933944f, -0.04742580f, 0.07119197f, -0.05618122f, 
    0.13165407f, -0.02585713f, -0.26613426f, 0.00695332f, -0.05683411f, 0.19780411f, -0.08532456f, -0.03330557f, 
    0.12947424f, -0.08180816f, -0.02753389f, 0.06854547f, -0.00254744f, -0.02784121f, -0.19974355f, -0.19018260f, 
    -0.09084252f, -0.14456354f, 0.02672573f, 0.13385914f, 0.17684080f, 0.19413415f, 0.03143781f, 0.12893866f, 
    -0.21696381f, 0.01861337f, -0.05588776f, 0.03251921f, 0.13077088f, -0.17928825f, 0.01686253f, 0.13796496f, 
    0.02538269f, 0.14872600f, -0.06348484f, -0.08940122f, -0.18326756f, 0.03544549f, -0.01651291f, -0.46077007f, 
    -0.15031885f, -0.09213223f, 0.10478096f, -0.28398252f, 0.06640127f, -0.50644118f, 0.05597727f, -0.43553302f, 
    0.11670405f, -0.10707110f, 0.00672478f, -0.22513418f, -0.01919898f, -0.16070636f, 0.07949529f, -0.04857232f, 
    0.02912804f, -0.18404466f, -0.01909712f, 0.16793588f, 0.09420031f, -0.03627738f, 0.05293371f, -0.55869395f, 
    -0.46323034f, -0.00181395f, 0.02088528f, 0.18167055f, -0.38411379f, -0.01009548f, 0.12905666f, 0.10959238f, 
    -0.26679900f, 0.00268484f, -0.43020853f, 0.14472005f, 0.01583466f, 0.04826888f, 0.14874664f, 0.09912509f, 
    -0.42858753f, 0.02406796f, 0.11440393f, 0.04430267f, -0.10063157f, -0.09619298f, -0.45649302f, 0.39814103f, 
    0.04059621f, -0.09210203f, -0.01777110f, 0.02501685f, -0.03833326f, -0.05720772f, -0.00786015f, 0.17308478f, 
    -0.04218097f, -0.05524134f, -0.00740716f, -0.06537553f, 0.48362595f, 0.01067632f, 0.15190609f, -0.06345183f, 
    -0.01275611f, -0.07917451f, -0.09457839f, 0.16113757f, -0.06843445f, -0.03394167f, 0.08995195f, -0.27598661f, 
    -0.20021382f, 0.01186327f, -0.44667369f, -0.04671967f, 0.18165085f, 0.24770759f, -0.12587328f, -0.04540302f, 
    -0.11134953f, 0.03581501f, -0.18270519f, -0.53816384f, 0.18553504f, -0.02481820f, 0.00444231f, 0.16048236f, 
    0.12607980f, -0.02289168f, -0.02637297f, 0.07896724f, 0.29609460f, 0.23506066f, 0.07205666f, -0.08271972f, 
    -0.07114352f, -0.05175919f, -0.45213899f, 0.12778859f, -0.04619951f, -0.04020116f, -0.16544151f, -0.15363245f, 
    0.04228196f, 0.07268023f, 0.14349538f, 0.07881357f, -0.27433383f, 0.26893929f, -0.05742831f, -0.26756352f, 
    -0.22668126f, 0.09284513f, 0.02663758f, 0.01886108f, -0.27601591f, 0.06770261f, -0.04460659f, 0.02650762f, 
    -0.01376622f, 0.02450477f, -0.00611322f, -0.02895532f, 0.11211184f, -0.02844034f, 0.10489287f, 0.07930776f, 
    0.11960194f, -0.07276946f, 0.09185725f, 0.06989900f, 0.03095384f, 0.03046655f, -0.01945969f, 0.03574658f, 
    0.17542702f, 0.02300276f, -0.02716185f, -0.07752947f, -0.07277653f, 0.19549607f, 0.03774552f, -0.02202328f, 
    0.04945966f, -0.19002818f, 0.04323366f, -0.40548176f, 0.17865168f, -0.06800771f, 0.46331662f, -0.61394989f, 
    -0.02054001f, 0.01109964f, -0.05452213f, 0.37080738f, -0.28245214f, -0.06992644f, 0.04411185f, -0.12542646f, 
    0.00941650f, 0.02161760f, -0.01625513f, 0.19702187f, -0.39752978f, 0.12517978f, 0.10818616f, 0.03661313f, 
    0.25139284f, 0.08747698f, 0.00369206f, -0.04888299f, -0.01871365f, -0.17507759f, -0.30234674f, -0.22840285f, 
    -0.01750482f, -0.05341352f, 0.06492050f, -0.52060163f, -0.05665774f, -0.03812092f, -0.03368006f, 0.12892999f, 
    0.09216502f, 0.18189146f, -0.04066063f, 0.02233003f, -0.78689611f, -0.13794336f, 0.10174529f, 0.04695446f, 
    0.14438789f, -0.02272296f, -0.22737160f, -0.36706606f, -0.07495061f, 0.27429667f, -0.06629603f, -0.21264134f, 
    -0.05120359f, 0.07998016f, 0.24651027f, -0.21162528f, 0.10673571f, -0.62841344f, 0.15417132f, -0.01966413f, 
    0.00014093f, -0.01255123f, -0.04140943f, 0.13376567f, 0.14601447f, -0.01150275f, -0.05950201f, 0.01087861f, 
    -0.00266371f, -0.00028136f, -0.10516576f, -0.51144737f, -0.23058443f, 0.18446591f, -0.23838326f, -0.04282441f, 
    -0.30145988f, 0.00028217f, -0.13319740f, -0.01448086f, -0.14078082f, -0.09591822f, 0.13718463f, 0.09780753f, 
    -0.07162116f, -0.01282503f, -0.06319748f, -0.04581504f, -0.28631899f, -0.02343781f, 0.03930767f, -0.03842501f, 
    0.08243515f, -0.31043640f, -0.07738160f, 0.03200755f, -0.11089260f, -0.14466213f, -0.03409134f, -0.01641362f, 
    0.10621673f, 0.06311915f, -0.04504130f, 0.06584760f, -0.53355718f, 0.05137255f, 0.24605618f, 0.04030158f, 
    0.23108746f, 0.00380144f, -0.16514455f, 0.06623737f, 0.00868913f, -0.45823395f, -0.12487417f, -0.01148966f, 
    -0.14023665f, -0.06046546f, -0.05727693f, 0.28395668f, 0.06238004f, 0.18258812f, -0.00525097f, -0.01241355f, 
    0.04460962f, 0.08901492f, 0.04958679f, -0.06023312f, 0.02291242f, -0.11263217f, -0.23080730f, 0.15019606f, 
    0.20960237f, -0.09871650f, 0.05198300f, 0.07695883f, 0.04573283f, -0.09865806f, 0.09475655f, -0.37172261f, 
    0.08665527f, 0.06401985f, 0.11706625f, -0.67214298f, 0.15922329f, 0.19720516f, 0.02551136f, 0.21048562f, 
    0.24816418f, -0.71129405f, 0.03243916f, 0.03880963f, 0.01740318f, 0.37905034f, 0.20830995f, 0.14514068f, 
    -0.06588746f, 0.02439493f, -0.01296562f, -0.42193046f, 0.07522593f, -0.09572434f, -0.08197166f, 0.10353853f, 
    -0.14920260f, 0.19406460f, -0.00075719f, 0.07055793f, -0.28646949f, 0.12421654f, 0.07477276f, 0.07521375f, 
    -0.33557412f, -0.54902738f, 0.14537218f, -0.06888008f, -0.01125296f, -1.02080810f, -0.22008412f, -0.04881367f, 
    -0.14011261f, 0.04131856f, -0.09758969f, 0.15882832f, 0.36056584f, -0.30072665f, 0.16406655f, 0.05148522f, 
    -0.12893762f, -0.03848441f, 0.05883191f, 0.26676577f, 0.01390479f, -0.01432229f, 0.02161694f, -0.84005487f, 
    -0.47569799f, 0.00410572f, -0.26936436f, -0.24920575f, -0.16217895f, -0.22969767f, 0.06664892f, 0.03706790f, 
    0.14242129f, -0.06103238f, 0.08049165f, -0.22819285f, 0.02076414f, 0.05231771f, 0.12289108f, -0.38907877f, 
    -0.03207706f, -0.01865586f, 0.16067094f, 0.03238523f, 0.06116292f, 0.07933129f, 0.07384318f, 0.06870931f, 
    -0.05521753f, -0.52717191f, -0.00332028f, -0.06635590f, 0.16209975f, -0.16659619f, -0.08948139f, 0.12651230f, 
    -1.11742496f, -0.16671708f, 0.00012842f, 0.25380713f, -0.37065187f, 0.00062474f, 0.15132304f, 0.04613385f, 
    -0.04099366f, 0.01151150f, 0.08047359f, -0.11466154f, -0.06942605f, -0.00455898f, -0.06120468f, -0.09855684f, 
    -0.24940635f, -0.25907981f, -0.10171027f, 0.18021917f, 0.05994569f, -0.08235803f, 0.07794251f, -0.07460186f, 
    0.04830031f, 0.00206149f, 0.01258028f, 0.09469537f, -0.51998216f, 0.05750782f, 0.19607335f, 0.33819550f, 
    0.20212868f, 0.05809137f, 0.01606519f, -0.02026631f, -0.02609318f, -0.01425181f, -0.06605453f, 0.08456600f, 
    -0.22305465f, -0.03609534f, -0.17996638f, -0.11976264f, 0.29829863f, 0.12313256f, -0.09246660f, -0.13169646f, 
    0.23680213f, 0.07194280f, -0.03793620f, -0.06478434f, 0.00876502f, 0.22886129f, 0.04491933f, -0.00985334f, 
    -0.02125038f, 0.03578976f, -0.00605272f, 0.02801017f, -0.04326111f, 0.04524662f, 0.02568793f, 0.06103055f, 
    0.21542452f, 0.12283491f, -0.02076626f, 0.06104436f, -0.57445705f, 0.11506660f, -0.27591527f, -0.04233670f, 
    -0.53017014f, 0.05525901f, 0.05329437f, 0.13992576f, 0.06582277f, 0.18425961f, 0.00205260f, 0.22379377f, 
    0.12801275f, -0.06382047f, -0.34849265f, 0.01066710f, -0.40528232f, 0.00635982f, 0.05033747f, -0.07132109f, 
    -0.07214150f, -0.04869244f, 0.05920456f, -0.52068615f, -0.09126062f, -0.07779673f, 0.01756978f, 0.00049175f, 
    -0.37271574f, -0.09846199f, -0.05308248f, 0.10190175f, -0.02155811f, -0.25174612f, 0.14869577f, -0.06238520f, 
    0.10756563f, -0.10725328f, 0.22077805f, -0.16106415f, 0.05892083f, 0.02582146f, 0.17791781f, -0.12162208f, 
    0.02598793f, -0.10009895f, -0.14525057f, 0.10559872f, 0.02021035f, 0.14292644f, 0.02420613f, 0.14567658f, 
    0.18134844f, -0.06803781f, -0.06561583f, -0.05107470f, 0.08864363f, -0.06783690f, -0.03407464f, 0.00523818f, 
    -0.04701442f, -0.61497420f, -0.09023168f, -0.30901614f, -0.02581732f, 0.05988514f, 0.04270536f, -0.14587192f, 
    0.05223151f, 0.06238395f, 0.06983835f, -0.01794075f, 0.01259956f, -0.15421727f, 0.02391249f, -0.02700769f, 
    0.01958307f, 0.09329271f, -0.07341152f, 0.02334210f, -0.08019777f, -0.03859495f, -0.01255029f, -0.03956725f, 
    -0.03416336f, -0.67554086f, -0.03610734f, 0.11296823f, -0.12077725f, 0.03511453f, -0.02895768f, 0.02824527f, 
    -0.08141068f, -0.06172221f, -0.00561951f, -0.07582460f, 0.12952973f, 0.01519531f, 0.13317920f, 0.03457620f, 
    -0.01310565f, 0.08223457f, -0.09854818f, -0.27697834f, -0.05044439f, -0.02940378f, 0.09679716f, -0.50758755f, 
    -0.35690564f, 0.01756643f, -0.05089728f, 0.07130419f, 0.03567479f, -0.05279895f, -0.10824303f, -0.77300727f, 
    0.07168188f, -0.02298773f, 0.05705602f, 0.13569960f, -0.00529583f, 0.11022691f, -0.03119732f, -0.05107080f, 
    0.03653361f, -0.21453348f, -0.04085729f, 0.04709085f, -0.28293779f, 0.07910073f, 0.12611145f, 0.02462321f, 
    0.18117860f, -0.04353101f, 0.06844172f, 0.02974952f, 0.03763080f, -0.42585900f, -0.00820123f, -0.07143642f, 
    -0.05079761f, -0.05579783f, -0.43953249f, 0.14159901f, -0.48101071f, 0.14557216f, 0.18756285f, 0.00742610f, 
    -0.09885812f, 0.02486124f, -0.04166071f, 0.12148590f, 0.04066604f, -0.00642923f, 0.02484589f, -0.14983860f, 
    0.10726865f, 0.02848393f, -0.01438383f, 0.10123996f, -0.12984616f, -0.06579795f, -0.02277886f, 0.01559820f, 
    0.05825672f, 0.01527039f, -0.02930636f, 0.07568483f, -0.04674989f, -0.07002319f, -0.18000448f, 0.21968581f, 
    0.03258104f, -0.13847351f, -0.00326425f, 0.06794754f, -0.00266309f, -0.15201610f, 0.05310843f, 0.06163727f, 
    0.00881255f, 0.15504502f, 0.06887709f, -0.04677030f, 0.06577219f, 0.18102144f, 0.02475016f, -0.04272899f, 
    0.21170621f, 0.00338174f, -0.01672346f, -0.00410513f, 0.08901481f, -0.02639589f, -0.02873372f, -0.06075469f, 
    0.06659154f, -0.04626571f, 0.06567070f, 0.04562955f, 0.03167851f, 0.44344610f, -0.11594842f, 0.06000142f, 
    0.09888231f, 0.04499469f, -0.01244498f, -0.00559692f, -0.02499710f, 0.02190965f, 0.00882778f, -0.05554584f, 
    -0.04542818f, 0.13690132f, 0.01331962f, -0.08999801f, 0.05854903f, -0.06844101f, -0.46719071f, -0.08808103f, 
    -0.17239109f, -0.07376745f, 0.04975661f, -0.24330878f, 0.13849294f, 0.04755363f, -0.07661087f, 0.09034657f, 
    -0.07866570f, 0.08837722f, -0.10529889f, 0.19697423f, -0.29110739f, 0.14761199f, 0.03094518f, 0.15929635f, 
    -0.01526082f, 0.04487332f, 0.07368378f, 0.00747236f, 0.09122261f, 0.16815375f, -0.02734165f, 0.00546300f, 
    -0.05662969f, 0.01593426f, 0.02354824f, 0.00531554f, -0.01694166f, 0.01647064f, -0.08336276f, 0.08739822f, 
    0.14997782f, 0.03058640f, -0.05706393f, -0.09869809f, 0.00255139f, -0.70407081f, 0.15131736f, 0.00436703f, 
    0.19078609f, 0.13617799f, -0.45190543f, -0.24767277f, -0.05505417f, -0.33994907f, -0.58393240f, -0.62954545f, 
    0.15524839f, 0.07170156f, 0.36647379f, -0.22794658f, -0.11658427f, -0.15095064f, -0.08872274f, 0.07742808f, 
    0.02454738f, 0.00532572f, 0.10139727f, 0.27870521f, -0.51582056f, -0.06286729f, -0.05196080f, 0.12145590f, 
    0.31850034f, 0.03589149f, 0.17463437f, -0.10298640f, -0.36754382f, -0.25660655f, -0.72536296f, -0.03594483f, 
    -0.95564622f, -0.00274469f, 0.01912502f, 0.26684284f, -0.02796778f, -0.05053379f, -0.69593060f, 0.20666765f, 
    0.06473922f, 0.10048128f, -0.23749183f, -0.31924388f, -0.52142608f, -0.21353278f, 0.05858540f, 0.13834630f, 
    0.08794054f, -0.01595846f, -0.01983590f, -0.05859116f, -0.68501252f, 0.16074276f, -0.07761647f, -0.19086233f, 
    -0.14035389f, 0.13216175f, -0.00974484f, 0.02025289f, 0.10412142f, -0.01630425f, -0.63285571f, -0.01002361f, 
    -0.71516716f, 0.07166561f, -0.27231732f, -0.55865645f, 0.00831168f, -0.20872764f, 0.08987273f, -0.15665390f, 
    -0.32438144f, -0.45467767f, 0.03235938f, -0.50283265f, 0.00826089f, -0.27726883f, 0.05816959f, -0.07716601f, 
    0.03831362f, 0.17108816f, 0.05295415f, -0.25218993f, -0.01124929f, -0.06681609f, -0.03182819f, -0.48071027f, 
    -0.45132947f, -0.04749440f, -0.00136527f, -0.08947695f, -0.31935310f, 0.00511493f, 0.07002461f, -0.50436193f, 
    0.16943522f, 0.09114248f, 0.11143623f, -0.41409466f, 0.33758917f, -0.86373150f, 0.11122496f, -0.01420698f, 
    -0.24294695f, -0.24443415f, -0.25321844f, -0.00882304f, 0.07802236f, -0.61178678f, 0.27568632f, 0.27912205f, 
    -0.07378535f, 0.05483817f, 0.07039353f, -0.05093846f, 0.01120931f, -0.60255146f, 0.00257264f, -1.12694192f, 
    0.06413054f, 0.22842617f, 0.05051582f, -0.09579144f, 0.20094699f, -0.58946389f, -0.11233184f, 0.02329658f, 
    -0.44670978f, 0.04345100f, 0.00690143f, -0.27224043f, 0.08507336f, 0.00902958f, 0.09571931f, 0.27030787f, 
    0.14858684f, -0.03931749f, -0.05469560f, -0.01261651f, -0.32124761f, -0.15035971f, 0.05705122f, 0.03959407f, 
    -0.01404584f, 0.09582409f, -0.02583880f, -0.17794245f, -0.41214007f, -0.01551641f, 0.01942290f, 0.05469694f, 
    -0.71917099f, -0.01704448f, -0.11101293f, 0.14552870f, 0.03568675f, -0.32837653f, 0.31935498f, -0.05125020f, 
    -0.44980574f, -0.05889443f, 0.10646803f, -0.21915726f, -0.02666766f, -0.06362312f, 0.34616214f, -0.36422309f, 
    0.02664345f, 0.04987372f, -0.25550234f, -0.71810830f, 0.41980460f, -0.10016265f, -0.00123101f, 0.13567287f, 
    0.31698406f, -0.17080291f, 0.03360613f, -0.06998177f, 0.41209888f, -0.24929856f, -0.10173699f, 0.15060562f, 
    -0.01483344f, -0.20027684f, 0.05023660f, 0.12382766f, 0.15050685f, -0.02119478f, -0.39444765f, 0.06013855f, 
    -0.58559889f, -0.09386410f, -0.13090432f, -0.24479017f, -0.01303554f, -0.09137355f, -0.01758248f, 0.05100353f, 
    0.07159464f, -0.13074835f, 0.05623675f, -0.40186477f, -0.02170180f, -0.01269075f, 0.03753203f, 0.03775252f, 
    -0.05162301f, -0.39389676f, 0.04605846f, 0.50685406f, -0.20621786f, 0.04179401f, 0.13240574f, -0.04813049f, 
    0.40415809f, -0.06004023f, 0.05428903f, -0.13246930f, -0.02355936f, 0.04394860f, 0.17069161f, 0.17541528f, 
    -0.31492227f, -0.95435286f, -0.14523959f, -0.19638085f, -0.07292724f, -0.28933138f, 0.12365021f, -0.17666534f, 
    0.12617901f, -0.84230006f, -0.29535213f, -0.05664739f, 0.02268879f, -0.39994055f, 0.05731593f, -0.74059898f, 
    0.05585337f, 0.03371740f, 0.04090839f, 0.08688561f, -0.07572853f, 0.11076633f, -0.04337973f, -0.52819043f, 
    -0.70136058f, -0.66973853f, -0.05222355f, 0.03772946f, 0.00273869f, -0.47605765f, 0.16805443f, 0.05887441f, 
    0.41132033f, 0.15981124f, 0.23587961f, -0.80496299f, -0.05233526f, 0.18615989f, -0.07199636f, 0.06938425f, 
    -0.09711800f, 0.00612859f, -0.24637569f, -0.19290729f, -0.34314597f, -0.10718179f, -0.17335021f, -0.01820061f, 
    0.07137099f, -0.03732399f, 0.24543537f, 0.04238419f, 0.21022837f, 0.02011465f, -0.03661641f, -0.15753262f, 
    -0.02605933f, 0.00954341f, 0.09985356f, 0.19970077f, -0.00401661f, -0.01791036f, 0.00116682f, -0.06273131f, 
    -0.30457777f, -0.08014555f, -0.48043421f, 0.06982286f, -0.06743056f, -0.02430950f, -0.41390133f, 0.21328096f, 
    -0.08508427f, 0.08996488f, 0.16111930f, 0.06238065f, 0.10197148f, -0.71986556f, -0.08447227f, -0.72168499f, 
    -0.39583984f, 0.01791464f, 0.06641711f, 0.05628965f, -0.57664025f, 0.08218063f, 0.04231920f, -0.64487535f, 
    -0.04360222f, 0.12194004f, -0.00749434f, 0.17475350f, -0.22449133f, -0.03753318f, -0.49087387f, 0.14984497f, 
    0.14228877f, -0.00973081f, 0.04797534f, 0.20063442f, -0.06906959f, -0.05930170f, -0.00149762f, 0.31326407f, 
    0.16470753f, -0.14177059f, -0.07352331f, -0.23703326f, -0.00663302f, -0.00507739f, 0.00171056f, 0.03809410f, 
    0.06170391f, 0.20274021f, -0.01682874f, -0.34384868f, 0.05537360f, 0.00123117f, -0.25994340f, -0.00558275f, 
    0.14691742f, 0.02175784f, -0.07253191f, -0.47384912f, 0.20176893f, -0.04334810f, -0.39623639f, 0.10305121f, 
    0.08272110f, 0.19783339f, -0.00949476f, 0.34955278f, -0.99171340f, -0.58469844f, -0.23406219f, 0.22657320f, 
    0.09410075f, 0.12220804f, -0.38012657f, 0.05998302f, 0.02872997f, -0.50555199f, -0.02878768f, -0.02568679f, 
    -0.02601761f, 0.05370362f, 0.05595730f, -0.58884323f, -0.01655324f, 0.14337809f, -0.01146987f, -0.34376022f, 
    0.26525173f, -0.03498139f, -0.05855739f, 0.06566739f, 0.00486137f, -0.02801432f, -0.45489001f, 0.02549190f, 
    -0.41546637f, -0.00079710f, -0.20772871f, 0.11273163f, -0.02091865f, 0.16054305f, -0.20409714f, 0.08000374f, 
    0.04250144f, 0.05570649f, 0.15570551f, 0.17926869f, -0.37177804f, 0.05316824f, -0.45443559f, -0.07943755f, 
    0.01532471f, 0.04218316f, 0.07102636f, 0.02715931f, -0.41028813f, -0.00663563f, -0.09266107f, 0.03673924f, 
    -0.11955590f, 0.00656957f, 0.16329454f, 0.01016627f, -0.28506958f, -0.40539077f, -0.12027740f, 0.04477026f, 
    0.01559033f, -0.04685138f, 0.11648598f, 0.00322601f, 0.03147823f, -0.02917150f, -0.11436492f, 0.13086680f, 
    -0.02617863f, 0.15978502f, -0.51598209f, 0.16156508f, -0.91108763f, -0.77148873f, 0.00519530f, 0.22572693f, 
    0.17592074f, 0.25572062f, -0.01636447f, 0.01791753f, -0.03235755f, 0.16462687f, 0.00577924f, -0.10877559f, 
    -0.23070522f, -0.13446341f, -0.01890707f, 0.07013318f, -0.00202646f, 0.05321711f, 0.14618810f, 0.13218901f, 
    -0.16835071f, -0.08145600f, -0.30080760f, -0.12988548f, -0.02516003f, 0.15529250f, -0.07245857f, -0.24272308f, 
    -0.11503213f, 0.02030964f, -0.07384930f, -0.14874329f, 0.05259004f, -0.01806184f, 0.07268817f, -0.22010212f, 
    0.00968412f, 0.05654036f, -0.04009142f, 0.16421808f, -0.14149624f, -0.09212462f, 0.19969583f, 0.12485883f, 
    -0.51626462f, -0.06387483f, 0.02521151f, -0.57050848f, -0.21215384f, -0.03551465f, -0.23707749f, -0.21635546f, 
    0.14497665f, 0.17247722f, 0.04345508f, -0.25248745f, 0.18646501f, 0.06436929f, 0.12182793f, -0.58630717f, 
    -0.11305945f, -0.35659605f, 0.04502840f, -0.05480484f, -0.01888533f, -0.17332248f, 0.16283807f, 0.01390162f, 
    0.00288734f, 0.03145783f, -0.04876809f, 0.13410644f, 0.07412307f, -0.41037157f, 0.07254037f, -0.04593746f, 
    0.31267241f, -0.33393371f, -0.01304147f, -0.04496977f, -0.19252709f, -0.16482468f, -0.00706375f, -0.06539783f, 
    0.25131705f, -0.31037176f, 0.14037775f, -0.05129862f, -0.00859964f, -0.44700801f, -0.51295525f, 0.28675589f, 
    -0.24778770f, -0.02334231f, -0.20276269f, -0.48298728f, 0.26389971f, 0.31150705f, -0.24901552f, -0.00670658f, 
    -0.07965509f, 0.03329675f, 0.11652967f, -0.19470076f, 0.06879848f, -0.06829780f, -0.05512498f, -0.52103525f, 
    0.01938904f, 0.02932690f, -0.00047583f, 0.00139374f, -0.09482092f, -0.23240194f, 0.19506297f, -0.02260789f, 
    -0.08864161f, -0.04582673f, -0.35756910f, -0.44012204f, -0.05438615f, -0.07872564f, 0.20819886f, -0.09783073f, 
    -0.07082711f, -0.50885224f, -0.52928752f, -0.53895181f, -0.36355072f, -0.18555674f, 0.03555733f, -0.47330973f, 
    0.02600782f, 0.21175973f, 0.00691150f, -0.08560559f, -0.33839482f, 0.36972776f, -0.00514051f, -0.49216315f, 
    -0.39421764f, 0.00560651f, 0.02453135f, -0.54652268f, -0.40223530f, -0.05387789f, 0.21976529f, -0.15233321f, 
    0.07361868f, 0.02393960f, 0.11898083f, 0.24702632f, -0.04247139f, -0.50896162f, -0.08863881f, 0.01203619f, 
    -0.31440124f, 0.26939440f, 0.05235684f, 0.08794339f, 0.07572227f, 0.12319244f, -0.06515023f, -0.03720844f, 
    0.05826452f, 0.06867159f, -0.05786020f, -0.42786396f, -0.01099249f, 0.04697232f, -0.13576251f, 0.27633995f, 
    0.12671697f, 0.00586431f, 0.02226915f, 0.01645111f, 0.10482186f, -0.08761617f, -0.07396860f, 0.00526962f, 
    0.05618377f, 0.11826996f, 0.04193051f, 0.12379882f, -0.08594215f, -0.16374142f, -0.76366413f, -0.11211811f, 
    0.13045031f, 0.25172821f, -0.29797441f, -0.08921184f, -0.02231499f, -0.10089318f, 0.05914322f, 0.04790226f, 
    0.01961034f, -0.00737216f, -0.00455189f, -0.14206423f, -0.09157044f, 0.27382326f, -0.07516615f, -0.05816114f, 
    -0.19926240f, 0.20903198f, -0.00622959f, -0.01784382f, -0.01196053f, -0.18025491f, -0.19661227f, -0.06816287f, 
    -0.48240992f, 0.14959955f, -0.11098947f, -0.58616889f, -0.03551561f, -0.66762710f, 0.27296323f, -0.04423597f, 
    0.20092966f, -0.04833723f, 0.25786555f, -0.22295263f, 0.56259602f, -0.21545365f, -0.20923631f, -0.01846932f, 
    0.08514251f, -0.03447454f, 0.10771665f, 0.07758305f, -0.05453327f, -0.06727211f, 0.00586719f, 0.12306487f, 
    0.20765193f, 0.02237620f, 0.02060256f, -0.07294725f, 0.20089002f, 0.28734726f, -0.56033176f, -0.06482586f, 
    0.13260481f, 0.04282564f, 0.24781959f, -0.21960101f, 0.04795051f, 0.02748464f, 0.20787919f, -0.07603131f, 
    -0.05006091f, -0.16406980f, 0.46636629f, -0.17219785f, -0.20816319f, -0.29448417f, 0.04233338f, -0.21178468f, 
    -0.22969331f, -0.19518337f, -0.01437579f, -0.02183304f, -0.31938189f, -0.59576565f, 0.05670371f, 0.15688448f, 
    -0.17426662f, 0.16722208f, 0.01954622f, -0.40639934f, 0.00506865f, 0.02785758f, -0.41421705f, 0.01402699f, 
    -0.08106787f, -0.10001811f, -0.25619069f, 0.07026340f, 0.08499502f, 0.18604146f, 0.05655038f, 0.22789630f, 
    0.09615351f, 0.04424502f, 0.06972894f, 0.16950463f, 0.02744048f, -0.23434784f, -0.05279667f, -0.12344942f, 
    -0.09258068f, 0.07957086f, 0.05991001f, -0.64294285f, 0.11738215f, -0.00121588f, -0.52206105f, -0.08028504f, 
    0.11581479f, 0.01127693f, 0.02138356f, -0.19126795f, 0.34360191f, -0.10033952f, -0.34716842f, -0.22297330f, 
    0.05678762f, -0.30786154f, 0.19735250f, -0.51713514f, -0.18500905f, -0.47790685f, 0.01611996f, -0.11102234f, 
    -0.27042639f, 0.20881847f, 0.36023459f, 0.01090818f, 0.02130588f, -0.12679112f, 0.02110014f, 0.11907490f, 
    -0.10479414f, 0.02394339f, 0.02683047f, 0.06359942f, 0.01277608f, -0.06927077f, -0.06426342f, -0.29000100f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.16868201f, 0.15204504f, 0.06732488f, 0.10887882f, -0.06213622f, -0.04431237f, -0.01098520f, -0.02716712f, 
    0.01872233f, 0.14305055f, -0.07178750f, -0.07922254f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
