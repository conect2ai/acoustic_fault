#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.36861551f, -0.93299848f, -0.72875375f, 0.87414181f, -0.27655971f, -0.67565233f, 0.77699316f, -0.09865316f, 
    0.92708081f, -0.04105549f, -0.47504202f, 0.27473313f, -0.44506267f, 0.08006614f, -0.15529366f, 0.49818635f, 
    0.01787731f, -0.43728864f, -0.08484106f, 0.48857421f, -0.27812576f, -0.13145383f, 0.08909470f, 0.23858292f, 
    -0.26551914f, -0.11048724f, 0.39501712f, -0.57653213f, -1.47123790f, 0.16003984f, 0.26845452f, -0.77163672f, 
    -1.03347385f, -0.13071680f, -1.09307158f, 0.12391867f, 0.41432592f, 0.67407489f, 0.56917852f, 0.11050386f, 
    0.38175800f, 0.02159301f, 0.54030991f, 0.17177108f, 0.51602417f, -0.21197343f, -0.43724677f, 0.25200483f, 
    0.02072548f, 0.26971817f, -0.93969464f, -0.92138511f, -1.07012475f, -0.84161377f, -0.06622188f, -0.93540365f, 
    -0.37801591f, -0.37121755f, -0.59319711f, -0.14946966f, 0.42804757f, 0.56312734f, 0.29744908f, -0.00050508f, 
    0.18327935f, -0.61602789f, 0.15597126f, -0.12350602f, -0.61120421f, 0.08869670f, 0.07140517f, -0.25826082f, 
    0.28763950f, 0.48133916f, -0.19445354f, 1.52119255f, 0.36815259f, -0.02979991f, 1.86294281f, 0.77436399f, 
    0.56764817f, 0.04099301f, -0.47068822f, -0.20490211f, 0.22758925f, -0.16262741f, 0.34726197f, 0.30502939f, 
    0.18402502f, -0.50507700f, -0.25146848f, -0.16483115f, 0.15368854f, -0.31051022f, -0.28363785f, -0.27515888f, 
    -0.28045017f, -0.13632514f, -0.25627181f, -0.16944008f, -1.86563170f, 0.56370777f, 0.92659003f, -1.03188491f, 
    -1.01399422f, 0.56030768f, 0.47886169f, -0.11778678f, 0.41620362f, 0.21198662f, 0.22757150f, -0.03158643f, 
    -0.47478124f, 0.07261091f, 0.17884725f, 0.03664264f, -0.01957008f, -0.15289578f, -0.10429537f, -0.27252200f, 
    0.04497111f, 0.25816458f, 0.42472249f, 0.41771987f, 0.37586644f, -1.50976706f, 0.86339903f, 1.52867651f, 
    -0.41386542f, 0.86568213f, 1.17844057f, -0.06833036f, -0.08346967f, -0.81154776f, -0.85232764f, -0.26404756f, 
    -0.02481253f, 0.56652260f, 0.53630811f, -0.35998932f, -0.32814321f, -0.08819232f, 0.04913977f, -0.44227609f, 
    0.02785822f, -0.19514252f, 0.10615354f, -0.17054166f, 0.01448283f, -0.17103046f, 1.56731188f, 0.79315156f, 
    0.31116962f, 1.03233743f, 1.47688401f, 0.46789253f, 0.73489529f, 0.25539616f, 0.38453999f, -0.37938869f, 
    -0.28136584f, 0.02176902f, 0.01437636f, -0.07468612f, 0.21876188f, 0.13422431f, 0.18395375f, 0.39093152f, 
    0.27130285f, 0.19848463f, 0.45229283f, 0.40600711f, 0.51240551f, 0.60825062f, 0.34403300f, 0.14292192f, 
    -1.11835992f, -0.48109451f, 1.22666550f, 0.82312757f, -1.00487149f, -0.72769701f, -0.16476597f, -0.83558881f, 
    0.05635970f, 0.55714095f, 0.39405388f, 0.29331037f, 0.11956499f, 0.20449074f, -0.09047975f, 0.31530362f, 
    0.26249629f, 0.40721154f, -0.06376143f, 0.05164273f, 0.04440254f, -0.08027564f, -0.17269981f, -0.35775587f, 
    0.35623088f, -0.68976980f, 0.43857706f, -0.25301877f, -1.40384018f, -0.90458870f, -0.19117269f, 0.34013095f, 
    -0.35976183f, -0.12510800f, 0.17488287f, 0.07551179f, -0.67415684f, -0.81451714f, -0.92612964f, 0.24585849f, 
    0.10767381f, -0.26112965f, -0.11187112f, -0.60291022f, -0.30185556f, -0.17813434f, 0.14314713f, -0.35462263f, 
    -0.30528545f, -0.07535461f, -1.04353726f, -0.37617704f, 0.92837143f, -0.15061685f, -1.25132155f, 0.01493508f, 
    0.52427858f, -0.85282797f, -0.64062297f, -0.21525142f, 0.22383094f, -0.35266250f, 0.36598995f, -0.16017842f, 
    0.40672052f, 0.22602114f, -0.02678414f, -0.45517084f, -0.12717110f, -0.14362517f, -0.02878652f, 0.23637743f, 
    0.51129490f, 0.54355580f, -0.60749853f, -0.27026191f, -0.55919129f, -0.05540496f, -0.93674922f, 1.17590153f, 
    1.03778517f, -0.96756220f, -0.19274266f, 0.82594085f, 0.19524637f, -0.17463279f, 0.71549082f, 0.11878318f, 
    0.01162953f, -0.39382479f, 0.30859941f, 0.44659558f, 0.17774403f, 0.08585196f, 0.11314589f, -0.33152509f, 
    -0.31973773f, -0.24357980f, -0.05841991f, 1.54215634f, 1.53741169f, 0.08440907f, -0.14471065f, 0.56250358f, 
    0.76505053f, -0.45883507f, -0.06636117f, 0.92020577f, 0.42855260f, -0.57975292f, -0.27995631f, -0.37212083f, 
    0.01517854f, 0.02108462f, 0.01746410f, 0.04942422f, -0.22536166f, -0.01844904f, 0.27839741f, -0.07837714f, 
    0.27193972f, -0.20056079f, -0.30562508f, 0.31997719f, -0.87088168f, -1.58680999f, -0.87569612f, -0.50884473f, 
    -0.52453279f, 0.04705254f, 1.24710453f, 1.16228950f, 0.09088582f, 0.83727390f, 0.02023413f, -0.47936755f, 
    -0.27833468f, -0.08855893f, -0.13981713f, 0.05927648f, 0.28799683f, -0.02440364f, -0.01503729f, -0.27457502f, 
    0.06689171f, 0.27140021f, -0.18559891f, 0.26750627f, 0.16920172f, -0.02995421f, 0.82861835f, 1.34452832f, 
    1.08885181f, 0.25787720f, -1.17141640f, 0.36087465f, -0.41889051f, -0.91940743f, 0.14218345f, 0.69469559f, 
    0.44028929f, 0.30688420f, 0.17916629f, 0.20240320f, -0.06290477f, 0.00664583f, 0.46410957f, 0.14088723f, 
    -0.13646528f, 0.05957028f, 0.17705749f, 0.38416806f, 0.26585394f, -0.18035837f, 0.46467096f, 0.45197380f, 
    0.28184354f, 0.19052170f, -0.00169200f, -1.17910123f, -1.24134874f, -0.59420067f, -0.52058268f, -0.37079901f, 
    -0.31039581f, -0.05123388f, 0.25566253f, 0.46077582f, -0.26879486f, -0.78681386f, -0.28054637f, 0.03825907f, 
    -0.58547050f, 0.41086209f, 0.82290763f, 0.16058150f, -0.08206262f, 0.06356307f, -0.22738312f, 1.43441498f, 
    0.37276512f, -1.37165105f, -1.56099081f, -1.00915146f, 0.17230910f, 0.49184012f, -0.21801916f, -0.07500149f, 
    0.21868406f, -0.04849651f, -0.04148236f, -0.07723951f, -0.11379223f, -0.33151752f, 0.16324994f, -0.02139773f, 
    0.03124140f, 0.03311710f, 0.07179352f, 0.16465260f, 0.00889180f, 0.04902353f, -0.17986640f, -0.03106053f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07735434f, 0.63640320f, 0.43364406f, 0.28614220f, -0.00093873f, 0.05636070f, 0.29775676f, 0.43863076f, 
    -0.08452352f, 0.38564360f, 0.05776608f, 0.36153281f, 0.22252204f, 0.45362896f, 0.42688930f, 0.39801875f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04898696f, 0.18649085f, -0.04976676f, 0.12897326f, 0.09368988f, 0.15175463f, -0.03239387f, -0.04267932f, 
    0.05654040f, -0.04866653f, 0.13967058f, -0.30239955f, -0.62177342f, -0.09155775f, 0.21107569f, -0.44659093f, 
    -0.27069604f, -0.08899538f, 0.22259893f, -0.08082574f, 0.19026640f, -0.14113574f, -0.26486492f, 0.09899073f, 
    -0.63170946f, -0.30369902f, 0.03462259f, 0.17754267f, 0.01910140f, 0.04188164f, 0.13781816f, 0.09110691f, 
    -0.14211048f, -0.05980735f, 0.12875250f, -0.18105792f, 0.31256089f, 0.02686662f, -0.21187535f, 0.71864307f, 
    -0.34211704f, 0.11637826f, -0.02380376f, 0.14158608f, -0.17671125f, 0.21980968f, -0.23947737f, -0.01277132f, 
    0.58301485f, -0.01737021f, 0.26294142f, -0.17515503f, 0.06342911f, 0.25588432f, -0.08700312f, 0.08532102f, 
    0.07039401f, -0.03339288f, -0.01660681f, -0.08719379f, -1.06193352f, -0.10035630f, 0.28013244f, -0.06621312f, 
    -0.07067627f, -0.07735555f, 0.06225690f, -0.20117679f, 0.03367294f, -0.12881963f, -0.11229144f, 0.18690170f, 
    0.40331346f, -0.08358712f, 0.03382390f, 0.09667394f, -0.21139853f, -0.05632986f, -0.01643480f, 0.15493286f, 
    -0.22438580f, -0.06167490f, 0.14291289f, -0.16194338f, 0.30572262f, -0.53618574f, 0.10642235f, 0.14407113f, 
    0.02005767f, 0.07113118f, -0.01592633f, 0.05543964f, -0.05539842f, -0.13392347f, -0.05028825f, 0.09244848f, 
    -0.29593906f, 0.05969118f, -0.05004737f, 0.19720018f, -0.16383576f, -0.07358690f, -0.00874546f, -0.15601957f, 
    0.07015254f, 0.17591894f, 0.19757000f, -0.16106339f, 0.01954538f, -0.06015929f, -0.01780305f, 0.48984835f, 
    -0.02790302f, 0.01919923f, -0.26470727f, 0.06523026f, -0.01661325f, -0.02986175f, 0.01940084f, -0.13641012f, 
    0.38893849f, 0.01683922f, -0.29302210f, -0.22336212f, -0.02506717f, -0.04105565f, -0.22205196f, 0.06146626f, 
    0.04605277f, 0.06552419f, 0.03081666f, 0.12951609f, 0.33767226f, -0.28273723f, 0.26349062f, -0.10116830f, 
    -0.03871802f, -0.13009521f, 0.08074106f, 0.26254645f, 0.04639250f, 0.01975763f, 0.13858779f, -0.07666581f, 
    -0.14288360f, 0.52104032f, 0.00403810f, -0.63351095f, 0.03771153f, 0.25180668f, -0.06097201f, 0.10145948f, 
    0.08219142f, 0.00312563f, -0.15554124f, 0.11688555f, -0.23412043f, 0.13020065f, -0.46338508f, 0.29098761f, 
    0.05607152f, -0.12284375f, -0.05330959f, -0.12881082f, -0.01668918f, 0.04728550f, -0.05279838f, -0.00977012f, 
    0.31028137f, 0.17074797f, -0.00823997f, 0.07051218f, -0.00385951f, 0.02474982f, 0.01996939f, 0.02161331f, 
    -0.08684646f, -0.32585716f, -0.15596019f, -0.04894770f, -0.19484806f, -0.05532337f, 0.06864551f, -0.98437911f, 
    0.07842311f, -0.13440394f, 0.06353281f, -0.09294476f, -0.13208155f, -0.04942747f, 0.09507909f, 0.07243858f, 
    0.69096124f, -0.46529126f, -0.31629759f, 0.03277290f, 0.05803552f, -0.08072713f, 0.03864934f, -0.10047347f, 
    -0.30240342f, 0.02554125f, -0.07310807f, 0.25941417f, -0.18210036f, -0.16201223f, 0.14107785f, -0.14598335f, 
    0.13895592f, 0.19813904f, 0.31377286f, 0.03115093f, -0.01535217f, 0.19737606f, -0.01732277f, 0.24827857f, 
    0.32651186f, -0.08243323f, 0.06261773f, -0.19734748f, 0.02625402f, 0.02230907f, -0.09400354f, 0.03907569f, 
    0.01672980f, -0.10277402f, 0.22683519f, -0.10409629f, 0.35584256f, -0.24284360f, 0.34667033f, 0.24523073f, 
    0.22993591f, 0.03443169f, -0.14657055f, 0.01182743f, 0.17190757f, -0.30614597f, -0.13463609f, -0.08055655f, 
    -1.14613450f, -0.20690916f, -0.42677069f, -0.25948167f, -0.12927628f, -0.11753856f, -0.12331341f, -0.09422542f, 
    0.15003827f, 0.08056974f, -0.13831472f, -0.01773661f, 0.16110756f, 0.00896385f, -0.31920207f, -0.16182132f, 
    -0.19325528f, 0.11255388f, 0.08663916f, -0.30669525f, -0.13264455f, 0.08279849f, 0.10656332f, -0.30692017f, 
    0.34022114f, 0.18275702f, 0.27049872f, 0.48595011f, -0.22171162f, -0.02282825f, -0.05089410f, 0.09513856f, 
    0.03874512f, 0.14174215f, -0.07574112f, 0.19966692f, -0.23602760f, -0.19601071f, -0.01454552f, 0.10596515f, 
    -0.04585334f, -0.03851186f, -0.06706122f, 0.19054931f, 0.03175966f, 0.14367323f, 0.17279942f, 0.10959833f, 
    -0.07204866f, -0.06137703f, -0.56413627f, 0.19978833f, -0.03790211f, -0.18711522f, 0.13429593f, 0.08503345f, 
    -0.10728132f, -0.24673779f, -0.28061903f, 0.00006745f, -0.56312859f, -0.14821413f, -0.31486633f, 0.23555538f, 
    -0.15130512f, 0.01715218f, -0.07395849f, 0.17638083f, 0.10325475f, -0.13572735f, 0.05948502f, 0.07303720f, 
    -0.26582938f, -0.02523914f, 0.03130968f, -0.01516868f, 0.11267988f, -0.08832456f, 0.12966242f, -0.23586009f, 
    -0.13390663f, -0.00142126f, -0.02552549f, 0.01125383f, 0.34802935f, -0.29814932f, 0.18216722f, 0.02511227f, 
    -0.27544191f, -0.21343012f, -0.02312669f, -0.02014951f, -0.16994736f, -0.08545981f, -0.07422756f, -0.05443140f, 
    0.36964822f, -0.20079908f, -0.29350051f, 0.08447473f, 0.05253173f, -0.00015283f, -0.08529891f, -0.02271807f, 
    0.35178435f, 0.08230375f, -0.14325991f, 0.01718054f, -0.21271400f, 0.08316903f, 0.05731705f, 0.16148530f, 
    -0.09389221f, 0.13792627f, 0.06256283f, -0.04481698f, 0.24471477f, -0.13216932f, 0.08481706f, -0.02753921f, 
    -0.14013295f, -0.26728091f, -0.16054873f, -0.22545701f, 0.00579336f, -0.09008552f, 0.03696564f, 0.18519372f, 
    0.02769789f, 0.04766632f, 0.07464395f, 0.01734174f, 0.67895943f, -0.15467797f, 0.29295313f, -0.75607693f, 
    -0.03215021f, 0.02159019f, 0.05248275f, 0.14877656f, -0.10007329f, 0.05283778f, 0.02820321f, -0.01276067f, 
    0.23661999f, -0.37032843f, 0.04435377f, -0.11889467f, -0.26655966f, 0.07518490f, -0.14145353f, 0.24797505f, 
    0.09183125f, 0.17441519f, -0.05079991f, 0.04764260f, -0.62819713f, 0.06890801f, -0.17319550f, -0.44710195f, 
    0.08326869f, -0.17384231f, 0.09720910f, -0.00083718f, -0.24684799f, -0.01829943f, -0.08650023f, -0.12459838f, 
    0.56940943f, -0.33934984f, -0.04580938f, -0.38381159f, -0.06251515f, 0.21487668f, -0.39928859f, -0.22842319f, 
    0.03684684f, -0.02351263f, 0.17403761f, -0.11379107f, -0.03090913f, -0.18180233f, -0.11969538f, -0.00118799f, 
    0.07420868f, 0.15552162f, -0.04585585f, 0.04863013f, -0.25936973f, 0.31095773f, -0.10199994f, 0.00143640f, 
    0.60751283f, -0.15368435f, -0.01565014f, -0.21486171f, -0.10898586f, -0.03890569f, -0.13437057f, 0.28477275f, 
    -0.16606024f, 0.06730641f, 0.17481121f, -0.05924197f, 0.49434489f, -0.03400207f, -0.26733470f, 0.07402246f, 
    -0.12736374f, -0.04386491f, 0.00832696f, -0.08527780f, -0.05790769f, -0.06297017f, -0.10443781f, 0.06740678f, 
    0.09160171f, 0.03332135f, -0.06914411f, -0.27130517f, 0.21734375f, -0.22808135f, 0.06589839f, 0.06565298f, 
    -0.16685714f, -0.08852483f, 0.10929529f, -0.01753030f, 0.63900787f, -0.48346147f, -0.06824055f, -0.03843134f, 
    -0.08238433f, 0.21724057f, 0.09804636f, -0.08451492f, -0.02102284f, -0.02517997f, -0.05612679f, -0.19816376f, 
    -0.46397948f, -0.10287363f, 0.17165470f, -0.11328897f, -0.04281548f, -0.00816689f, 0.18761910f, 0.01720057f, 
    0.08957960f, 0.12929450f, -0.12027755f, -0.12482358f, 0.72771132f, -0.21304473f, -0.73707294f, -0.26275232f, 
    -0.20268363f, 0.11133163f, -0.10896292f, -0.22645061f, -0.05179886f, 0.14158641f, 0.11570315f, -0.14186209f, 
    0.48567969f, 0.00799527f, 0.53035080f, -0.16148579f, -0.04589513f, -0.02955196f, -0.09001637f, 0.29705805f, 
    0.03111690f, 0.17364775f, -0.09836569f, -0.22619878f, 0.29549104f, -0.30093813f, -0.06125223f, -0.01702373f, 
    0.20564082f, -0.02418360f, 0.19763747f, -0.15871139f, -0.10702240f, 0.00124116f, -0.00090334f, -0.08880480f, 
    0.42912000f, 0.19666624f, 0.38381591f, 0.62504035f, -0.40957311f, -0.14963111f, 0.18160219f, 0.14582244f, 
    0.21733710f, -0.04188849f, -0.07853802f, -0.05241097f, 0.46798196f, 0.15167345f, -0.53643042f, 0.14252760f, 
    0.06016427f, 0.11478459f, -0.06144567f, -0.01046688f, -0.37169597f, -0.12057783f, -0.16986552f, -0.16849740f, 
    -0.82973206f, 0.05443768f, -0.25175804f, -0.16566707f, 0.10917127f, 0.19496393f, -0.07915360f, -0.14363021f, 
    0.11492372f, 0.13290471f, -0.03993847f, -0.22105330f, -0.36535048f, -0.16683565f, 0.08061504f, -0.14976600f, 
    -0.22657387f, -0.29186597f, 0.17138332f, -0.15651068f, 0.03824761f, -0.20261578f, 0.12260628f, -0.01193469f, 
    0.25801992f, -0.01576306f, 0.08844558f, 0.11223439f, -0.00307249f, -0.21233907f, 0.03145330f, -0.11692011f, 
    -0.04684284f, 0.01126960f, 0.12065540f, -0.02544449f, 0.41271907f, 0.13036697f, 0.09522302f, -0.21943505f, 
    0.02202570f, -0.07737832f, -0.11338395f, -0.00387633f, -0.00613532f, -0.01454365f, -0.07735945f, -0.09888162f, 
    0.04429025f, 0.24700250f, 0.01628159f, 0.09121266f, -0.28142971f, -0.19079693f, -0.16115715f, 0.02989738f, 
    -0.26446933f, 0.26915726f, -0.02152441f, 0.01422634f, 0.48554426f, -0.32471091f, -0.37513956f, 0.48640260f, 
    0.15294822f, 0.01425093f, 0.14289521f, 0.03840226f, 0.28418806f, -0.09396333f, 0.05246271f, 0.22385874f, 
    -0.11861582f, 0.40352476f, 0.15956232f, -0.44231102f, 0.07758848f, 0.00090934f, 0.06197127f, 0.08636854f, 
    0.24884164f, -0.23108810f, 0.05979102f, -0.16118057f, 0.37748459f, -0.15784825f, 0.17935917f, 0.14293918f, 
    0.19270255f, 0.03499990f, -0.01770574f, 0.19317327f, 0.12550174f, -0.03302946f, -0.15197958f, 0.06341763f, 
    -1.10400319f, -0.55912465f, -0.12232589f, -0.28064725f, 0.10659587f, -0.04447633f, -0.11402117f, -0.08871797f, 
    -0.00809535f, -0.19205089f, 0.01349693f, 0.07675732f, 0.23998673f, -0.05979595f, 0.41107088f, 0.13708146f, 
    0.01505320f, 0.34659314f, 0.11422860f, -0.17785782f, -0.26646012f, 0.07957570f, 0.02263608f, -0.10312091f, 
    -0.16663732f, 0.45879868f, 0.04694143f, 0.04555883f, 0.02980431f, 0.01906024f, -0.22354692f, 0.14482711f, 
    -0.19597881f, 0.21524386f, -0.11034356f, -0.09727043f, 0.23423365f, 0.03441038f, 0.62235510f, 0.01629799f, 
    0.03663813f, 0.02323177f, 0.10891241f, -0.05873809f, -0.03088841f, -0.07912664f, -0.19281362f, 0.07382075f, 
    -0.20627689f, -0.07927909f, -0.38017157f, -0.06129999f, 0.07411373f, -0.04089065f, -0.20226514f, 0.08489712f, 
    0.04767988f, -0.15432857f, 0.04749254f, 0.22748025f, -0.12635955f, -0.11213923f, -0.99754637f, 0.06783158f, 
    -0.32885274f, -0.20037661f, -0.04797668f, -0.02804833f, 0.00954572f, 0.03174369f, -0.03200118f, 0.09068816f, 
    0.13411686f, -0.28455931f, -0.02425877f, -0.42590189f, -0.16574109f, -0.21876459f, -0.00763852f, -0.03127101f, 
    -0.32419923f, -0.08048666f, 0.01951609f, -0.02557934f, -1.45803225f, -0.10626244f, 0.10366663f, 0.37256986f, 
    0.05015590f, 0.07384428f, -0.11031929f, -0.07770731f, -0.03300374f, -0.01648343f, -0.17017837f, -0.07906284f, 
    0.18241939f, 0.00689259f, -0.03313451f, 0.03967333f, 0.07473514f, 0.00192218f, 0.00376483f, -0.11523914f, 
    -0.00613642f, 0.14743382f, 0.04197238f, -0.14407949f, -0.08386818f, -0.33600727f, -0.08396601f, 0.11744332f, 
    -0.05567634f, 0.01668570f, 0.02066511f, -0.02417183f, -0.20632197f, 0.25378886f, -0.04786907f, 0.15449288f, 
    -0.31282640f, 0.44656649f, -0.12112213f, 0.25122193f, -0.02624645f, 0.00786029f, -0.21929589f, -0.03801112f, 
    0.00418523f, 0.05351058f, 0.04247435f, 0.13632573f, -0.10017336f, 0.07961912f, -0.13944778f, 0.08705470f, 
    -0.01685775f, 0.19371401f, 0.03782550f, 0.07603028f, 0.03895095f, -0.23929244f, 0.14252393f, -0.28326946f, 
    0.01519541f, 0.07307343f, 0.24742563f, -0.13809231f, 0.12469934f, -0.01191793f, 0.21032269f, 0.17849633f, 
    0.07348981f, 0.16763227f, 0.05971286f, 0.02152879f, 0.14582290f, 0.23002942f, -0.09273945f, 0.03016068f, 
    -0.13374199f, 0.19048336f, 0.11924411f, 0.10112049f, -0.14185603f, -0.13891949f, 0.03479473f, 0.12670989f, 
    0.84150791f, 0.19862849f, -0.20634183f, -0.40426451f, 0.04405506f, -0.08046796f, 0.10066763f, 0.01138008f, 
    -0.03897741f, -0.10882158f, -0.19415411f, -0.09425147f, 0.02204023f, 0.66911924f, -0.37414640f, -0.50698525f, 
    0.16557874f, -0.09414307f, -0.08866531f, 0.11513232f, -0.06934325f, 0.09709313f, -0.01543794f, 0.18061605f, 
    0.45900854f, -0.14931767f, 0.07940905f, 0.08313774f, -0.05013753f, 0.07881243f, -0.04314173f, -0.01640920f, 
    0.13470127f, 0.06502864f, -0.08820891f, -0.10285264f, -0.31975487f, -0.21183960f, 0.09720892f, 0.26538134f, 
    0.13580096f, -0.14756927f, -0.18178253f, -0.16304432f, 0.30833128f, 0.02575941f, 0.01773088f, -0.14187205f, 
    0.16085379f, -0.67787462f, 0.24036938f, -0.15510893f, -0.05034923f, 0.20633531f, 0.05227211f, 0.07841037f, 
    -0.02063665f, 0.29407775f, 0.16000810f, 0.07277203f, -0.17205709f, 0.00934084f, -0.01486316f, 0.04748763f, 
    0.12240165f, -0.12895575f, -0.02329277f, 0.12565582f, -0.31350824f, 0.19840869f, 0.02321526f, -0.04967618f, 
    -0.76585400f, -0.25247321f, 0.20013225f, 0.25616679f, 0.09085645f, 0.01598235f, 0.15234251f, -0.15928143f, 
    -0.04207230f, 0.16583061f, 0.05868659f, -0.00233786f, -0.10387603f, -0.24857900f, -0.11058232f, 0.10611204f, 
    -0.12549314f, -0.08586908f, -0.00173260f, 0.02892396f, -0.11121183f, 0.00106265f, -0.01897554f, -0.08399458f, 
    -1.04724061f, 0.06090961f, -0.03466957f, 0.31949669f, 0.13321716f, 0.10305452f, 0.06041713f, 0.14606626f, 
    -0.14084336f, -0.02280706f, 0.17267482f, 0.11301574f, -0.85780030f, -0.39402586f, 0.27380094f, 0.22825719f, 
    -0.28275332f, 0.01913751f, -0.17460237f, -0.00415324f, 0.11570678f, -0.00949165f, -0.16409445f, -0.05989615f, 
    -0.26056820f, -0.29414964f, 0.18470886f, 0.29223794f, -0.40078878f, 0.03652141f, -0.22880828f, -0.42526281f, 
    -0.04191219f, -0.07307928f, -0.14635797f, 0.04607974f, -0.20390925f, -0.46338880f, 0.05679002f, 0.26813930f, 
    -0.13514391f, 0.20550407f, 0.11101662f, -0.16162817f, -0.01369138f, 0.13751319f, -0.01313281f, -0.03175408f, 
    -0.46761739f, 0.11001862f, -0.25980210f, -0.18455815f, -0.02406377f, -0.11582936f, 0.03157995f, -0.18120867f, 
    -0.04166720f, 0.01770745f, -0.35282156f, -0.10622659f, -0.21249008f, -0.10589626f, 0.22110035f, 0.26147243f, 
    -0.16854924f, -0.09816577f, -0.12497063f, -0.30559474f, -0.10436777f, 0.04064149f, 0.19791730f, 0.25709099f, 
    -0.66241670f, -0.17317815f, 0.08273151f, 0.41969967f, 0.11818792f, -0.08282208f, 0.07894339f, 0.20633002f, 
    0.15391335f, 0.04099610f, -0.18766356f, 0.33221725f, -0.14408579f, -0.10440470f, 0.36382547f, -0.27544686f, 
    -0.11342411f, -0.07741487f, 0.02985816f, -0.13791530f, -0.12336235f, -0.08783346f, 0.13573612f, 0.00470479f, 
    -0.47368932f, -0.65366399f, 0.03230858f, 0.47184706f, -0.07645652f, -0.27395520f, 0.19225809f, -0.02121143f, 
    0.19662037f, 0.13507685f, -0.34655648f, 0.10788907f, -0.56624883f, -0.53534311f, 0.73509657f, 0.44786018f, 
    -0.03407022f, 0.13189109f, 0.13204928f, -0.07349393f, -0.17784210f, -0.05549508f, 0.01902038f, -0.17633082f, 
    0.07609329f, -0.15992908f, 0.25001499f, -0.23991066f, -0.04798289f, 0.10582054f, 0.10103267f, -0.11999184f, 
    0.32255888f, 0.02465983f, 0.12753560f, 0.33780387f, -0.16126838f, -0.03362054f, -0.02195669f, -0.39829129f, 
    -0.10402948f, -0.04877669f, -0.25246990f, -0.01508475f, 0.23767154f, 0.05037167f, 0.23401655f, 0.09700736f, 
    0.08359364f, 0.17296247f, -0.29664078f, 0.06790937f, 0.14166793f, -0.02616830f, 0.13582934f, 0.10465375f, 
    0.28906181f, -0.29462147f, -0.14112616f, -0.17794034f, 0.13480160f, 0.04032277f, -0.14287467f, -0.19476900f, 
    0.18807027f, 0.08865473f, 0.03960724f, 0.09352544f, 0.21934421f, -0.00327634f, -0.18617916f, 0.10244577f, 
    -0.78292209f, 0.18967432f, -0.14621237f, -0.01443822f, 0.02656456f, 0.00465611f, -0.09085113f, -0.11348455f, 
    0.03714153f, -0.29626247f, 0.34031051f, -0.27065960f, 0.37249067f, 0.05540822f, 0.24776638f, 0.10671244f, 
    0.08378772f, 0.01751825f, 0.01522401f, -0.16553976f, -0.22320949f, 0.16131091f, -0.03781617f, -0.00030591f, 
    -0.31822047f, 0.10996960f, -0.69472933f, -0.26112774f, 0.27489418f, 0.21495764f, 0.03141017f, -0.06013470f, 
    -0.06331712f, 0.00604387f, -0.07881781f, 0.02696495f, 0.30953792f, 0.27025148f, 0.07336011f, -0.11074836f, 
    -0.07805440f, -0.18509960f, 0.02792260f, 0.09223142f, -0.06844957f, 0.02898805f, 0.02616858f, 0.17609793f, 
    0.17751701f, 0.01203881f, 0.00142072f, 0.49444956f, 0.03252170f, -0.13477626f, 0.09598244f, 0.08573814f, 
    -0.18819362f, 0.04917898f, 0.06274458f, -0.02750723f, 0.05596650f, -0.26283982f, -0.43430829f, -0.00134536f, 
    0.04001486f, -0.01019648f, -0.10640118f, -0.00820430f, 0.16615923f, -0.01947280f, -0.16502063f, 0.00717707f, 
    0.10081317f, -0.23489590f, 0.37401220f, -0.11370900f, 0.03131482f, 0.30858111f, 0.04280127f, 0.00046657f, 
    0.03141459f, 0.01339589f, 0.34621394f, -0.10239655f, 0.28729030f, -0.28919119f, -0.05117068f, 0.20053977f, 
    -0.01521910f, -0.03587471f, -0.18618320f, -0.07032998f, 0.03713988f, -0.10502882f, -0.42565683f, 0.02170358f, 
    -0.34918553f, 0.02131645f, -0.33483693f, -0.18438599f, -0.01441171f, 0.04522625f, 0.02206637f, -0.12760885f, 
    -0.13103536f, -0.03575487f, -0.19585875f, 0.05048268f, 0.35928333f, 0.13319610f, 0.27391475f, -0.46037361f, 
    -0.37927458f, 0.05539457f, -0.09495341f, 0.04670930f, 0.06168664f, 0.19563933f, 0.06151119f, 0.11407158f, 
    0.38096723f, 0.06465107f, -0.42315897f, 0.32984614f, -0.09772786f, 0.10603097f, -0.18007563f, -0.15836346f, 
    -0.41978735f, 0.11526263f, 0.11122294f, -0.31884965f, 0.55545294f, -0.47707993f, -0.15146482f, 0.01843947f, 
    -0.10955518f, 0.00888842f, 0.12542365f, 0.29913026f, 0.28301233f, 0.01469136f, -0.27999431f, 0.29079702f, 
    -0.35875821f, 0.29386574f, 0.19845977f, -0.39283922f, 0.02541603f, -0.09146143f, 0.00534832f, 0.08646257f, 
    -0.17796524f, 0.00497917f, -0.05563400f, -0.20630187f, 0.50777328f, 0.15985677f, 0.06935102f, -0.23117143f, 
    -0.21994080f, 0.09623656f, 0.23501007f, 0.13191202f, -0.05821851f, 0.01251079f, -0.26073483f, 0.02842940f, 
    -0.37777793f, -0.03254873f, 0.10212019f, 0.07132204f, -0.15499356f, 0.11352942f, -0.29648599f, -0.13554215f, 
    -0.04190962f, -0.01578623f, 0.16504037f, 0.11684956f, 0.15356115f, 0.03539022f, -0.16241750f, -0.10633063f, 
    0.15332022f, -0.22687043f, 0.16656555f, -0.24333602f, 0.21426752f, 0.01794470f, 0.20547040f, -0.35546294f, 
    0.23507272f, -0.15188237f, -0.06454886f, -0.01456239f, -0.20642500f, -0.05666358f, 0.07685773f, -0.03678760f, 
    0.06956477f, 0.18973488f, -0.00256436f, 0.21229731f, -1.02250922f, 0.43519929f, -0.03244527f, 0.01153397f, 
    -0.38139972f, 0.04526497f, 0.17445824f, 0.10187607f, 0.26886618f, 0.06975194f, -0.06726665f, 0.01695578f, 
    -0.31830314f, -0.94046438f, 0.08060389f, -0.32617930f, -0.04471487f, -0.07383314f, 0.03872173f, -0.19602402f, 
    -0.06476257f, -0.05156601f, 0.17908065f, 0.11800652f, 0.11312581f, -0.02371749f, 0.16114068f, -0.29824549f, 
    0.20266542f, -0.08479904f, 0.10744365f, -0.00633671f, -0.01154280f, 0.09452818f, -0.29159024f, -0.03774545f, 
    -0.26221702f, 0.16000749f, -0.09084290f, -0.32139608f, 0.31798944f, 0.06330369f, 0.00819135f, 0.13908693f, 
    -0.06747701f, -0.10160279f, -0.00290911f, 0.23675397f, -0.00938820f, -0.11099822f, -0.66953343f, 0.59159333f, 
    0.19159374f, 0.08500654f, 0.08989105f, 0.19646250f, 0.13481037f, -0.22844820f, 0.07497376f, -0.20514844f, 
    0.18685770f, 0.14923741f, 0.03764823f, -0.46170512f, -0.06476785f, 0.11878427f, -0.06993268f, 0.11045836f, 
    0.02572164f, 0.03668967f, -0.01244558f, -0.22759598f, -0.17109652f, 0.34301737f, -0.11247193f, 0.28416693f, 
    0.13731349f, -0.23432004f, -0.21066476f, -0.07616001f, 0.02986687f, -0.08354091f, -0.03971465f, -0.10816038f, 
    0.26690894f, 0.09279615f, 0.30119851f, 0.26730290f, -0.11579980f, -0.11500196f, -0.11831183f, -0.08799615f, 
    -0.04133028f, 0.00712841f, -0.13190363f, 0.03542596f, -1.22291875f, 0.65813935f, -0.01624597f, -0.07687264f, 
    -0.19747682f, -0.02281482f, -0.18792209f, -0.25096416f, -0.20085537f, 0.01362374f, -0.13942479f, -0.20401782f, 
    0.49378303f, 0.40633652f, 0.04614983f, 0.52594703f, 0.25715405f, 0.10622583f, 0.12530150f, -0.10639518f, 
    -0.05607455f, -0.04852882f, -0.02503265f, -0.02122899f, 0.13032793f, -0.09751191f, 0.19081107f, 0.23950645f, 
    -0.03470362f, -0.22756462f, 0.03285384f, -0.17768726f, -0.02543405f, -0.01435586f, -0.19319934f, -0.13523623f, 
    -0.53815377f, 0.17294843f, -0.00847753f, -0.18944423f, -0.23585978f, -0.04582128f, 0.04963834f, -0.07492342f, 
    -0.02676506f, -0.05010028f, -0.08797361f, -0.23179711f, 0.22706480f, 0.07620872f, -0.13287808f, -0.15160146f, 
    -0.11070786f, -0.08561436f, -0.02126852f, -0.16931801f, -0.18282270f, -0.16134366f, -0.18858062f, -0.15150079f, 
    0.22291575f, -0.15833689f, 0.29335177f, 0.29514396f, -0.01069778f, -0.13723777f, -0.09322139f, -0.01001960f, 
    -0.21341988f, -0.06652065f, -0.16022973f, -0.11013675f, 0.44444445f, -0.06215802f, 0.15804483f, -0.01542861f, 
    -0.08005027f, 0.03510423f, -0.11842292f, -0.06409821f, -0.12417345f, -0.01507954f, -0.14550836f, -0.05194201f, 
    -0.12654029f, 0.21882278f, 0.00672690f, 0.08859626f, -0.14727233f, -0.01449395f, -0.12579979f, 0.28243154f, 
    -0.04333803f, 0.17236206f, -0.15771885f, -0.24005388f, 0.09158453f, 0.22977613f, -0.33934969f, -0.32738259f, 
    -0.06853896f, 0.07650617f, -0.10574979f, -0.06806637f, -0.14055148f, 0.09899400f, 0.07770602f, 0.16365181f, 
    0.01321858f, 0.29549247f, 0.36022362f, 0.28313842f, 0.14285713f, 0.18734732f, 0.20493583f, 0.08288860f, 
    -0.01335527f, 0.15096621f, 0.08390083f, 0.02908553f, 0.15204333f, -0.51229310f, -0.30472013f, -0.20501894f, 
    0.01315641f, -0.09594993f, -0.03180074f, -0.08901254f, -0.19826429f, 0.07856252f, -0.00549791f, -0.02479855f, 
    0.14104745f, -0.12779404f, -0.14864400f, 0.07720373f, -0.10678147f, 0.00439525f, -0.13626777f, -0.23011354f, 
    -0.33811480f, -0.02242862f, -0.05257054f, -0.05873007f, -0.23419519f, 0.24703513f, -0.16218612f, 0.13725869f, 
    -0.04454689f, 0.08222104f, -0.30360156f, 0.01301280f, 0.04854632f, 0.02287468f, -0.16603902f, -0.11793362f, 
    -0.16954097f, 0.04578213f, 0.17089945f, 0.23661838f, 0.04574870f, -0.38601750f, -0.07857827f, -0.12944011f, 
    0.09933537f, -0.12936909f, -0.22049716f, 0.21136399f, 0.07215717f, 0.32932591f, -0.34500185f, -0.49811101f, 
    -0.11696814f, -0.09219763f, -0.20986396f, -0.14900102f, 0.05625691f, 0.05183494f, 0.20746285f, -0.06276866f, 
    -0.22485346f, 0.44398081f, -0.07681965f, -0.29420185f, 0.30848193f, 0.01739063f, 0.06727792f, -0.06494030f, 
    0.13750790f, -0.08204734f, 0.00420604f, 0.20470835f, 0.04768988f, -0.25025308f, 0.17964990f, 0.31837571f, 
    0.11982642f, -0.11888252f, -0.11744318f, -0.26038510f, 0.05875192f, 0.03320760f, 0.22199155f, -0.36836517f, 
    0.21173149f, 0.00707607f, 0.10975630f, -0.18905985f, 0.12675953f, -0.02915175f, 0.43113443f, -0.07838278f, 
    0.11213139f, -0.01270071f, -0.33348843f, 0.33094811f, 0.10758650f, 0.04680708f, -0.07096869f, -0.12893134f, 
    0.15181120f, -0.09888032f, -0.08755680f, 0.04067446f, 0.08934895f, 0.11236907f, 0.23230143f, -0.30745423f, 
    0.47592834f, -0.10110330f, -0.04303587f, 0.32608685f, 0.06777073f, 0.12174791f, -0.04324057f, -0.18751773f, 
    -0.13665952f, -0.09778863f, 0.14587839f, 0.21487865f, -0.55527526f, 0.04315482f, -0.19155218f, -0.43694648f, 
    -0.32602048f, -0.20888844f, 0.03570643f, 0.06296670f, 0.09607556f, -0.00007068f, -0.06378066f, 0.15865155f, 
    0.01065432f, -0.25959817f, -0.34527335f, -0.42748570f, 0.13365871f, -0.12109958f, -0.06590712f, -0.12219048f, 
    0.12156822f, -0.23674861f, -0.37169665f, 0.25091973f, -0.47343451f, -0.44521114f, -0.24635552f, -0.60277444f, 
    0.10270434f, -0.10684153f, 0.17574050f, -0.07808993f, 0.21106027f, -0.13560081f, -0.11089119f, 0.33915755f, 
    0.11452778f, 0.03844227f, 0.12584996f, -0.18722658f, -0.13198332f, -0.20535332f, -0.00442091f, 0.14956202f, 
    -0.11388624f, -0.17090359f, 0.16745180f, 0.08931943f, 0.16280986f, 0.10415187f, -0.05498503f, 0.10818694f, 
    0.15393871f, 0.19743627f, -0.39413488f, 0.08673117f, -0.09084249f, -0.04556571f, 0.10715167f, -0.02010823f, 
    -0.26014215f, -0.29829434f, 0.53787440f, 0.17194107f, -0.08965990f, -0.11876570f, -0.14016384f, 0.07102783f, 
    0.03613808f, -0.07286310f, -0.34662032f, -0.10305950f, 0.14944597f, -0.36508381f, -0.23887433f, 0.03061490f, 
    0.18899325f, -0.01644651f, 0.07801121f, -0.12369423f, 0.10026532f, -0.02761023f, 0.25912693f, 0.05956704f, 
    -0.49684101f, -0.48057511f, -0.15347548f, -0.48335448f, 0.09297053f, -0.10182548f, 0.24055983f, 0.08048879f, 
    0.36176878f, 0.02279993f, 0.27226883f, -0.47435775f, -0.10854156f, 0.82391918f, -0.45081237f, -0.24706064f, 
    0.02451666f, -0.06441660f, -0.36439881f, -0.21125281f, 0.05849715f, 0.03951189f, 0.13125159f, 0.01822188f, 
    -0.73084748f, 0.13632306f, 0.09858242f, -0.01499259f, -0.00609204f, 0.20389624f, 0.03212797f, 0.01512189f, 
    0.08574118f, -0.08356310f, 0.11731024f, 0.25293979f, -0.28775972f, -0.09882947f, 0.14031647f, -0.19421291f, 
    0.08038604f, 0.06326935f, 0.00018381f, 0.24838464f, 0.01466032f, -0.07462332f, 0.01959035f, -0.20911424f, 
    -0.19202140f, -0.59421617f, -0.16223066f, 0.25242826f, -0.09124004f, -0.04654735f, -0.08104089f, -0.13418230f, 
    0.12401457f, -0.29252002f, -0.03868918f, -0.22225201f, -1.08900142f, 0.60133910f, -0.41451558f, -0.63574982f, 
    0.07610823f, -0.03364527f, 0.19156779f, 0.06813986f, -0.01486708f, -0.00023812f, 0.22049853f, 0.03922495f, 
    -0.39332724f, -0.34128743f, 0.24814370f, -0.10407183f, 0.24457042f, -0.07795850f, -0.13168959f, -0.00658774f, 
    0.04446811f, -0.14253621f, 0.30187577f, 0.09436685f, 0.31931874f, 0.14565979f, -0.55305338f, -0.17954510f, 
    0.14989121f, -0.12476347f, -0.33234021f, 0.14438620f, -0.04583287f, -0.04412653f, 0.05060532f, 0.11202508f, 
    -0.57304734f, 0.53325391f, -0.67937660f, -0.00338622f, 0.32439810f, 0.09921169f, 0.06108598f, 0.01420088f, 
    -0.22451031f, -0.08224900f, -0.19578016f, -0.28574538f, -0.45128754f, 0.22968262f, -0.09661181f, -0.06412803f, 
    0.01252408f, 0.09227949f, 0.21358716f, 0.04907893f, 0.03678164f, -0.00353822f, -0.02588741f, -0.07533444f, 
    0.49351707f, -0.01202956f, -0.30255508f, 0.01675696f, 0.08139164f, 0.17135000f, 0.04912546f, 0.07438381f, 
    -0.04142807f, 0.17255151f, 0.18039829f, 0.01939844f, -0.10199682f, 0.32291988f, -0.07970573f, 0.13969250f, 
    -0.23734024f, 0.01076083f, -0.07685906f, 0.07635665f, -0.15377276f, 0.03554892f, -0.05984843f, -0.01841192f, 
    -0.49037677f, 0.04756092f, 0.14894356f, -0.27279642f, 0.15021138f, 0.19084242f, 0.02967386f, -0.07412631f, 
    0.16539153f, 0.19638894f, -0.22777580f, 0.09102243f, -0.08495772f, 0.51727617f, 0.43599075f, -0.03329810f, 
    0.11625588f, 0.20323139f, 0.01568251f, 0.00053567f, 0.05184115f, -0.06196723f, 0.03992677f, -0.12250674f, 
    0.40648910f, -0.32495332f, -0.16925907f, -0.00958652f, 0.01226216f, -0.15299143f, -0.02551029f, -0.02234906f, 
    -0.11870158f, 0.15780228f, 0.06360000f, -0.04138092f, 0.13831745f, 0.10443810f, 0.19813995f, -0.29930058f, 
    0.02092740f, 0.16926053f, -0.31387413f, -0.06599992f, -0.03644681f, 0.00849111f, -0.03032620f, -0.20871980f, 
    -0.11368730f, -0.17247689f, -0.00596994f, -0.35318390f, 0.09352870f, -0.19247578f, 0.07268430f, -0.09316698f, 
    0.01160218f, 0.04481466f, 0.00498385f, -0.01112667f, -0.47121695f, 0.46586862f, 0.55823743f, 0.18375097f, 
    0.09814906f, 0.03107181f, 0.07819509f, 0.25303963f, -0.10165613f, -0.00477234f, 0.03170378f, 0.06522839f, 
    -0.04949661f, -0.35604370f, -0.05135151f, 0.12455375f, 0.10980196f, -0.11956748f, 0.10382605f, 0.11507391f, 
    0.03087156f, -0.31312597f, -0.21507959f, 0.01862978f, 0.40498567f, -0.15689427f, 0.03105210f, -0.30318487f, 
    0.12818336f, 0.05145876f, -0.13758972f, 0.07667471f, -0.02866444f, 0.25966978f, 0.03938793f, 0.21529856f, 
    0.59713036f, 0.18974403f, -0.20078067f, -0.17104818f, 0.07443886f, 0.32263586f, 0.02927869f, -0.10058503f, 
    0.09405135f, -0.11552343f, 0.01743413f, -0.15697673f, -0.56824315f, -0.84539455f, -0.24119686f, -0.47606185f, 
    0.19836092f, -0.39928806f, -0.16912688f, -0.06997298f, 0.18393421f, -0.19561304f, -0.07729677f, -0.12258478f, 
    -0.44332141f, 0.18522026f, -0.14330746f, 0.10562227f, -0.10902419f, 0.10558566f, -0.08437134f, -0.16560712f, 
    -0.08505163f, 0.20804985f, 0.06601322f, 0.10994142f, -0.61124426f, 0.39282358f, -0.25701672f, -0.18212120f, 
    0.11998994f, 0.15261884f, -0.02976389f, 0.08200543f, 0.26929241f, 0.03064730f, 0.01652962f, -0.07913879f, 
    -0.44511303f, -0.43602008f, -0.27276051f, -0.22672772f, -0.08563932f, 0.03889973f, 0.03149695f, 0.17969717f, 
    0.05374621f, 0.32447875f, 0.20649484f, 0.22226886f, 0.39652294f, 0.15631799f, -0.16466464f, -0.01586757f, 
    -0.08845223f, -0.20767686f, -0.00310365f, 0.03787886f, -0.09630007f, 0.01859893f, 0.02420574f, 0.10679677f, 
    -0.31969905f, 0.08516214f, 0.32667616f, -0.18288915f, 0.20904489f, -0.04262804f, 0.17231019f, -0.35208392f, 
    -0.13035622f, -0.43483740f, -0.15794149f, 0.18206307f, 0.18343714f, -0.24631840f, 0.06026603f, 0.15662795f, 
    0.19811942f, 0.18818451f, 0.05133090f, -0.05128618f, 0.06482812f, 0.08763443f, -0.04826562f, 0.05426341f, 
    0.32539651f, 0.18058258f, -0.29230839f, 0.36036125f, -0.24590902f, -0.10670831f, 0.10643735f, -0.13114257f, 
    0.02992593f, -0.08859354f, 0.14777716f, -0.16013987f, -1.36333740f, -0.66039753f, 0.06329210f, -0.12494899f, 
    0.23871493f, 0.10319035f, -0.15550630f, -0.07119061f, 0.20889053f, -0.13882013f, -0.24568382f, 0.00262040f, 
    0.47802183f, 0.04797021f, -0.16180323f, -0.04877007f, -0.37841117f, 0.02312440f, -0.11216742f, -0.07559526f, 
    0.06479451f, -0.02864970f, -0.10869467f, -0.13852939f, -0.26608312f, 0.13234749f, 0.02221524f, -0.31479612f, 
    0.04371596f, 0.18479477f, 0.12153695f, 0.09620171f, -0.06954511f, -0.05825738f, 0.27189279f, 0.19211215f, 
    0.12356210f, 0.27866054f, 0.35663578f, -0.07434864f, 0.10971674f, 0.09448469f, 0.03324453f, 0.04493277f, 
    -0.06108403f, 0.11412527f, 0.02492842f, -0.05951856f, -0.34270540f, -0.16060100f, 0.10634132f, 0.03995318f, 
    -0.07569505f, 0.12056515f, 0.04904463f, -0.09165777f, 0.21510096f, -0.22877188f, -0.06835844f, -0.15116099f, 
    0.04284175f, 0.20059162f, 0.02224842f, -0.03151584f, -0.05455514f, -0.13505037f, 0.06036114f, 0.10026386f, 
    0.04922400f, 0.25248367f, -0.12424196f, -0.31165579f, 0.21983410f, -0.44905427f, -0.25098211f, 0.67773157f, 
    -0.07408750f, 0.00816041f, -0.20783660f, -0.03458416f, 0.02636578f, -0.09252632f, -0.08213325f, -0.16718048f, 
    -0.12025505f, 0.08008622f, -0.17345554f, -0.19725321f, -0.05512803f, 0.07334190f, -0.11097269f, -0.33780709f, 
    -0.08927571f, 0.09886049f, -0.01225182f, -0.21052621f, 0.10858522f, -0.43722990f, -0.26695904f, -0.41721982f, 
    0.28328711f, -0.17623957f, 0.05201054f, -0.10481762f, 0.10798196f, 0.14874277f, 0.08218722f, 0.13269854f, 
    -0.43909711f, -0.01670888f, 0.06322432f, 0.07412670f, -0.42845908f, 0.21482986f, -0.18307860f, 0.13171768f, 
    -0.08178788f, 0.20721392f, 0.17309919f, 0.01819953f, -0.24284996f, -0.31440830f, 0.20585695f, 0.34698331f, 
    -0.08730933f, 0.01680303f, 0.09756479f, -0.11240002f, 0.09094340f, -0.05267674f, 0.18495665f, 0.10682264f, 
    -0.23594913f, -0.34544569f, -0.15172605f, -0.11687096f, 0.21704717f, 0.11148053f, 0.12398165f, -0.10036626f, 
    -0.09418079f, -0.14281984f, -0.16703188f, -0.19945656f, -0.46651149f, 0.24450397f, -0.14396897f, 0.02873877f, 
    0.40378270f, -0.14248875f, -0.01040560f, -0.11745546f, -0.19411208f, -0.10127075f, -0.04726768f, -0.03573665f, 
    -0.24581563f, 0.21080688f, 0.34424773f, -0.47343019f, -0.05453916f, -0.10436065f, -0.15246655f, -0.20710239f, 
    -0.18555082f, 0.15016048f, 0.23407392f, 0.01312616f, -0.33113411f, 0.33792856f, 0.02765284f, -0.18713643f, 
    -0.19699541f, -0.00515989f, -0.03539976f, -0.00433917f, -0.09961018f, -0.02642701f, 0.09663060f, 0.15246296f, 
    0.53634566f, -0.43490058f, -0.02296776f, 0.05318408f, 0.08478030f, 0.07497784f, -0.09069943f, 0.08791324f, 
    -0.12653485f, -0.21957637f, -0.52671820f, -0.04956036f, 0.38258070f, -0.01350857f, -0.36477396f, 0.08677867f, 
    0.22683573f, 0.03982180f, -0.12469768f, 0.13336280f, 0.18211199f, 0.10798042f, 0.15169130f, -0.00516323f, 
    -0.38305429f, 0.13420896f, -0.02996414f, 0.08067557f, -0.12635794f, 0.02023876f, 0.06562170f, -0.06749010f, 
    -0.01530454f, 0.00519946f, 0.14125216f, -0.30044505f, 0.64941889f, 0.08613785f, -0.27333635f, -0.02448881f, 
    -0.08373939f, -0.16755947f, -0.15855777f, 0.02276033f, 0.01081704f, 0.02132536f, -0.02390818f, -0.03430066f, 
    0.56691253f, 0.54249108f, -0.21457155f, 0.12734200f, -0.00192784f, -0.03045057f, -0.16777478f, 0.26090527f, 
    0.32206428f, 0.06923002f, -0.05795270f, 0.04298460f, 0.23682313f, 0.17262304f, -0.32217193f, 0.01726524f, 
    0.18242301f, -0.23481219f, -0.32020041f, -0.30445826f, 0.05837864f, 0.05529742f, 0.09563050f, 0.05649417f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17495795f, 0.08650728f, -0.17904678f, 0.00951230f, -0.04363409f, -0.10334829f, 0.03418989f, -0.27629185f, 
    -0.10072235f, 0.04361481f, 0.14632848f, 0.08657761f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
