#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.77036524f, -0.50469095f, 0.18267778f, 0.15737686f, 0.05451622f, 0.58749658f, -0.06685890f, -0.08239163f, 
    0.27452728f, 0.44767460f, 0.03116900f, 0.11129258f, -0.24388134f, -0.11839204f, 0.12392324f, -0.21704368f, 
    -0.09056618f, -0.45712405f, -0.35371915f, -0.40726936f, 0.49545395f, 0.29270902f, 0.30862591f, 0.43989408f, 
    0.36259666f, 0.52651978f, 0.18953972f, 0.29912242f, 0.34219539f, 0.18766154f, -0.02233606f, 0.16190487f, 
    -0.04254772f, 0.08318538f, 0.08678488f, 0.27642077f, 0.27091649f, -0.33170500f, -0.36364639f, 0.27483305f, 
    -0.40552506f, -0.12775439f, 0.13078086f, -0.19743535f, 0.06556392f, 0.42823380f, -0.24588653f, -0.21172275f, 
    -0.09070814f, -0.49802759f, 0.35688540f, 0.34376049f, -0.05862269f, -0.08397847f, -0.46957421f, -0.07651547f, 
    0.01745403f, -0.01187991f, 0.50976545f, 0.18047222f, 0.18767482f, -0.11938327f, -0.07679906f, 0.66760308f, 
    -0.37400764f, -0.07728554f, 0.06301212f, 0.00044327f, -0.39686334f, -0.15793714f, 0.35480851f, 0.31864530f, 
    0.09766446f, -0.08637979f, -0.37139946f, 0.49115428f, -0.59395361f, -0.73100734f, -0.06993666f, 0.61169589f, 
    0.21982038f, 0.05007999f, -0.38150936f, 0.90688199f, -0.34843245f, -0.41357353f, 0.50330406f, -0.07275867f, 
    0.00703495f, -0.13394639f, -0.25775707f, 0.12702908f, -0.04834503f, -0.00028138f, -0.05544179f, 0.06135168f, 
    -0.12227051f, -0.05319884f, -0.10208164f, 0.43985492f, 0.78006488f, 0.97776502f, -0.83885497f, -0.40720031f, 
    -0.58490616f, -0.41464087f, -0.42733863f, 0.26304352f, 0.38368177f, -0.06036088f, -0.19524732f, -0.24317512f, 
    0.42243344f, 0.32940599f, -0.21832208f, -0.19156186f, 0.27290827f, 0.24822618f, 0.11219907f, -0.34887344f, 
    -0.20694192f, -0.01869931f, -0.24874647f, -0.23742549f, -0.19124444f, -1.03904927f, -0.37038872f, -0.19607048f, 
    0.99049133f, 0.63236421f, -0.13754356f, -1.27685177f, -0.74913424f, 0.45794407f, 0.32383862f, -0.20069581f, 
    -0.11307626f, 0.12625574f, 0.71423304f, -0.03610788f, 0.22840327f, 0.04581987f, -0.20514272f, -0.21403730f, 
    -0.02887441f, 0.05050188f, 0.07779135f, 0.00973578f, -0.09949014f, -0.07809764f, 0.08985858f, 0.31959718f, 
    0.20941019f, 0.00524305f, 0.09589747f, -0.44787905f, -0.13421766f, 0.26409015f, 0.04247594f, 0.30287373f, 
    -0.09620914f, 0.32231578f, -0.17753111f, -0.29458678f, 0.41018263f, 0.06407052f, 0.10091051f, -0.08779713f, 
    -0.25336280f, 0.05150366f, -0.04803394f, 0.02998384f, 0.04477806f, 0.28578269f, -0.26975271f, 0.16061424f, 
    0.24241705f, 0.24852286f, 0.32212868f, 0.14043365f, 0.08703869f, -0.33352411f, -0.33028150f, -0.16667418f, 
    0.15111968f, 0.26380026f, -0.14395155f, 0.05552182f, 0.00776857f, 0.37317583f, -0.16933283f, -0.03493379f, 
    -0.12739737f, -0.05215902f, 0.38844195f, -0.11818830f, 0.01595943f, 0.18044557f, 0.15318751f, 0.11915129f, 
    -0.89715439f, -0.58513188f, 0.10723668f, 0.44674915f, 0.37403414f, -0.22618814f, -0.71008056f, -0.74525332f, 
    -0.09965906f, 0.65647751f, 0.16932826f, -0.00442035f, -0.46458581f, 0.17708503f, -0.51221645f, -0.11392580f, 
    -0.33281648f, -0.28475556f, -0.44677341f, -0.39260480f, -0.50360650f, 0.22997002f, 0.23232584f, 0.12040931f, 
    0.15590647f, 1.03676164f, 0.05248013f, -0.42908880f, -0.89241117f, -1.19800806f, 0.30318344f, -0.07466108f, 
    0.21399257f, 0.42825410f, 0.18230848f, 0.36187837f, 0.23093899f, 0.00859954f, 0.06219701f, 0.07886850f, 
    -0.05152993f, -0.21269499f, 0.02988151f, -0.33987752f, -0.06027950f, -0.08235962f, -0.19532201f, 0.17624059f, 
    0.04971070f, 0.30011919f, 0.53616035f, 0.33872664f, -0.15515859f, -0.00543204f, -0.13437921f, -0.55410099f, 
    0.14869936f, 0.57411128f, -0.51571637f, -0.72477984f, -0.32637554f, 0.08561619f, 0.10715877f, -0.24288499f, 
    -0.19548678f, 0.22593427f, 0.05658178f, -0.04202113f, -0.15167940f, -0.28345317f, 0.08548194f, -0.05290553f, 
    -0.13844787f, 0.10350467f, 0.41522348f, -0.08967607f, -0.40927085f, 0.01723843f, 0.37070361f, 0.00846231f, 
    -0.19633640f, 0.62784868f, -0.10073162f, -0.00787040f, -0.65098298f, 0.02708953f, 0.44341829f, 0.08467562f, 
    -0.32564038f, -0.20576864f, -0.39213496f, 0.16789463f, 0.17218617f, 0.35775334f, 0.15286100f, -0.27511442f, 
    -0.39620265f, -0.12022801f, 0.29435697f, -0.11190064f, -1.30906713f, -0.13383529f, -0.29441157f, -1.09739578f, 
    -0.52679849f, 0.18158300f, 0.16156332f, -0.69129026f, -0.40852842f, 0.17450717f, -0.39598829f, -0.52918595f, 
    -0.54033780f, -0.61667836f, -0.45337147f, 0.29489434f, -0.03135374f, -0.13515325f, 0.01207747f, -0.19415337f, 
    -0.02438352f, -0.19054425f, -0.22054692f, 0.12271962f, -0.17692289f, -0.21142407f, 0.26924849f, 0.22229923f, 
    0.34526342f, 0.32664484f, -0.13683717f, 0.30261436f, 0.58326125f, 0.30736607f, 0.13827965f, -0.09100817f, 
    -0.09989513f, 0.47472140f, -0.37841848f, -0.54797930f, 0.17597753f, 0.02528143f, -0.11846112f, -0.21994019f, 
    -0.32583064f, 0.13475166f, 0.01856979f, 0.21457453f, 0.08438163f, 0.12235039f, -1.40517211f, -0.33222193f, 
    -0.26359960f, -0.89403546f, -0.61488509f, 0.14445616f, -0.17743628f, 0.34617749f, 0.64914912f, 0.69908303f, 
    -0.25704861f, -0.13502111f, -0.16168831f, -0.57709885f, -0.29183093f, 0.00437675f, 0.18186238f, 0.27108651f, 
    0.29122970f, 0.25196230f, 0.11523197f, 0.29986137f, 0.16304016f, -0.09689659f, 0.10696114f, -0.83940351f, 
    -0.05895149f, -0.23748508f, 0.85391492f, 0.11977489f, 0.28444377f, -0.11181443f, -0.59504372f, -0.44330829f, 
    -0.32648328f, 0.27906674f, -0.00743972f, 0.15733367f, 0.26082426f, 0.12018457f, -0.29132983f, 0.12121958f, 
    -0.03133629f, 0.10453025f, 0.28705263f, 0.29297784f, -0.32497251f, 0.02913111f, 0.00655394f, 0.13618539f, 
    0.50025517f, -0.72595936f, -0.17114238f, -0.54735512f, -0.90956980f, 0.59310925f, 0.04154373f, -0.36035925f, 
    -0.13989192f, 0.47771519f, -0.15982634f, -0.50872064f, -0.07025830f, 0.60731882f, 0.21834555f, -0.08014135f, 
    -0.10939021f, -0.04043947f, -0.22291888f, -0.67740476f, 0.08164762f, -0.32522357f, -0.42839471f, 0.05908527f, 
    -0.06458211f, 0.14415990f, 0.15359491f, 0.15255760f, 0.33408335f, 0.44647694f, -0.35083631f, 0.04053123f, 
    -0.18980305f, -0.24388830f, -0.47304916f, 0.16865475f, -0.29277113f, -0.28986895f, 0.62184924f, -0.05463469f, 
    0.32861474f, 0.28228304f, -0.11060970f, -0.16692312f, 0.28042740f, -0.27699870f, -0.22170351f, -0.10571285f, 
    0.03753543f, 0.15193611f, -1.37428200f, -0.49486095f, -0.03746896f, -0.64517641f, -0.79279935f, 0.15923741f, 
    -0.06446312f, -0.15660514f, 0.44053534f, 0.84031254f, 0.13545026f, -0.02762587f, 0.28390065f, 0.25462925f, 
    0.29483864f, -0.32471949f, -0.16053906f, -0.20727430f, -0.24778168f, -0.41202545f, -0.19448948f, -0.02629602f, 
    0.31622830f, -0.19495223f, 0.30946988f, -0.76608020f, 0.16192926f, -0.03762249f, 0.35254598f, 0.57428646f, 
    0.27642921f, -0.13195163f, -0.12158874f, -0.36143410f, -0.05151878f, -0.26757744f, -0.57176483f, 0.06805217f, 
    -0.55146772f, 0.07943942f, -0.20407221f, -0.20925990f, -0.02199464f, -0.12210985f, 0.40140599f, 0.04924790f, 
    0.31908396f, -0.05341173f, -0.26471514f, -0.19222929f, 0.10242607f, -0.66755611f, -0.17398450f, -0.09004068f, 
    0.64481634f, -0.12095971f, 0.10916618f, -0.27064449f, 0.12675537f, 0.09040605f, -0.11800761f, -0.24835445f, 
    0.37865251f, -0.45298508f, 0.65072209f, -0.41157165f, -0.06410803f, 0.21743444f, -0.09278283f, 0.07085165f, 
    0.01594818f, -0.43385315f, -0.05067860f, 0.38610744f, 0.33265057f, -0.05167145f, -0.41941828f, -0.08414906f, 
    0.56401306f, -0.10832558f, -0.25410756f, -1.06964278f, -1.18155265f, -0.79705304f, -0.81498730f, 0.24164039f, 
    0.04348662f, -0.19539215f, -0.34706378f, -0.32222947f, -0.14170520f, 0.32097566f, 0.07858900f, 0.06127597f, 
    0.05869782f, 0.11010325f, -0.23654839f, -0.11793928f, -0.31155226f, -0.44568604f, 0.65135247f, 0.79995972f, 
    0.11698528f, -0.25828677f, -0.22876897f, -0.56682503f, -0.19600308f, 0.07877912f, 0.20409019f, 0.23784617f, 
    -0.08991381f, 0.19460528f, 0.03488217f, -0.27649990f, -0.38903034f, -0.04893566f, -0.10994516f, -0.27154455f, 
    0.06221517f, 0.12786706f, -0.22032370f, 0.39990541f, 0.03577294f, -0.48005784f, 0.16146545f, 0.92951071f, 
    0.48722851f, 0.18545964f, -0.44458517f, -0.86522907f, 0.28344566f, 0.46083054f, 0.24197960f, -0.40565440f, 
    -0.05103697f, 0.05215694f, -0.25447673f, 0.13581702f, -0.39433414f, -0.21655600f, 0.03780330f, -0.22209232f, 
    -0.19566464f, 0.14195900f, 0.17432870f, -0.26951122f, -0.23314470f, 0.19747984f, 0.15414001f, 0.17265998f, 
    -0.18597645f, -0.59144467f, -0.28109440f, -0.89082116f, -0.50392091f, -0.28920102f, 0.08759942f, 0.82577896f, 
    0.28971305f, 0.23544113f, -0.54714459f, -0.59026676f, -0.76354909f, 0.01769003f, -0.00031563f, -0.30905536f, 
    -0.62380421f, -0.12090976f, -0.30180380f, -0.59505069f, -0.20620143f, 0.04711836f, -0.16052623f, -0.13561414f, 
    -0.18581545f, -0.43593088f, -0.61812347f, -0.34148532f, -0.23373866f, -0.27591908f, -0.56392026f, -0.21031180f, 
    -0.29819572f, -0.52748632f, -0.72299773f, -0.17568405f, 0.33176306f, -0.10188363f, -0.27890387f, -0.06005960f, 
    0.08721823f, 0.03146634f, 0.24604021f, 0.03099768f, 0.19074941f, -0.05797670f, 0.39368451f, 0.10307347f, 
    -0.06355788f, 0.21656980f, 0.73923165f, 0.97845984f, 0.40245521f, -0.27830738f, 0.12577838f, -0.08146512f, 
    -0.51602894f, -0.30558616f, -0.02150456f, -0.91189766f, -0.10854714f, -0.03839775f, -0.20987250f, -0.20253879f, 
    0.01569982f, 0.15956564f, 0.11652209f, 0.19861071f, -0.01458700f, -0.03131866f, -0.08297077f, 0.05821015f, 
    -0.20440592f, 0.03295849f, -0.15791431f, -0.27723888f, -0.05828572f, -0.85836339f, -0.69852972f, -0.33518341f, 
    -0.24178196f, -0.26848719f, -0.23574382f, -0.23157673f, -0.05066263f, -0.08946101f, 0.15766981f, 0.23153846f, 
    -0.36410677f, -0.12995525f, 0.23590805f, -0.24335265f, -0.16245286f, 0.24137613f, 0.22977605f, -0.21251781f, 
    -0.33711994f, -0.20141424f, -0.19298130f, -0.70342535f, 1.28693819f, -1.00334024f, -0.97661895f, -0.54210067f, 
    -0.71586031f, 0.86322123f, 0.59558588f, 0.72217917f, -0.16827317f, -0.13949272f, -0.22715558f, -0.07011437f, 
    -0.13336580f, -0.07618180f, 0.28004384f, 0.07747726f, -0.16541806f, 0.34679437f, 0.05527966f, -0.22517546f, 
    -0.01356210f, -0.45370620f, 0.10666750f, 0.06609312f, -0.02492169f, -0.99376464f, -0.42868814f, 0.88159770f, 
    -0.11180812f, -0.20434715f, -0.45784822f, 0.75940740f, -0.81240898f, -0.23379999f, 0.05450419f, 0.35928544f, 
    -0.19945166f, 0.06923934f, -0.26995558f, -0.25710633f, -0.13929465f, 0.01350205f, 0.06032454f, -0.00771284f, 
    -0.13513602f, 0.19087295f, 0.13000022f, -0.13391793f, 0.11734425f, 0.42476484f, -0.61687189f, -0.26277933f, 
    -0.50325578f, -0.67358077f, -0.81091309f, -0.00745257f, -0.22051172f, -0.93763125f, -0.88545614f, -0.35206386f, 
    -0.06209581f, -0.24153961f, -0.23829111f, -0.48322606f, 0.38452318f, -0.24080023f, 0.17476700f, 0.01629999f, 
    -0.67473143f, -0.59748352f, -0.22541542f, 0.21797067f, 0.35297349f, 0.17675500f, -0.00179404f, 0.28507769f, 
    -0.71642876f, -0.01200416f, 0.54957777f, 0.49356523f, 0.63313550f, 0.67331737f, 0.03564132f, -0.60734445f, 
    -0.57567441f, -0.23453921f, -0.42489678f, 0.37914631f, -0.18209468f, 0.06606767f, -0.29822376f, -0.15054041f, 
    0.28781623f, 0.04969580f, -0.05662341f, 0.28259546f, -0.42018762f, -0.17920974f, 0.11491609f, -0.07975599f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31240892f, 0.23092698f, 0.51091504f, 0.45177057f, 0.49535877f, 0.29658011f, 0.47144762f, 0.07954518f, 
    0.30395007f, 0.31987002f, 0.40429151f, 0.32651478f, -0.48755583f, -0.02949926f, -0.07471803f, 0.28571177f, 
    0.35977244f, 0.03212236f, 0.20557459f, -0.04852253f, 0.32821533f, -0.25608993f, 0.54626852f, 0.43396705f, 
    -0.28025937f, 0.04040815f, 0.09359881f, 0.13321599f, 0.24273998f, 0.27441293f, -0.23972149f, 0.42199329f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00991860f, -0.04390137f, 0.18114464f, -0.15617308f, -0.04888099f, 0.08825123f, 0.05137007f, 0.04325472f, 
    -0.08892167f, -0.09044320f, -0.15942852f, -0.27058646f, -0.31515488f, -0.08679132f, -0.03092627f, 0.13685134f, 
    0.03805955f, 0.05918944f, 0.04888473f, 0.02137845f, -0.06444524f, -0.03194841f, 0.01518480f, 0.11269804f, 
    -0.44901365f, -0.80377471f, -0.19455013f, 0.11822789f, -0.01588720f, 0.01835536f, 0.00474967f, -0.02894725f, 
    -0.17718105f, -0.18108854f, -0.23906884f, -0.22522369f, -0.42150426f, 0.12562859f, -0.23688349f, 0.02581638f, 
    -0.16923232f, 0.00806794f, 0.10576829f, -0.15812480f, -0.29462007f, -0.14580509f, 0.03537774f, -0.33275574f, 
    -0.33968094f, -0.36749217f, 0.03422703f, 0.08188540f, -0.03712029f, 0.00403781f, 0.10790849f, -0.06582981f, 
    -0.04211809f, 0.00219636f, -0.11158045f, 0.10008462f, 0.29447573f, 0.33482412f, 0.25093672f, -0.82414126f, 
    0.03637585f, -0.02841154f, -0.02778590f, 0.02730484f, 0.11637753f, -0.18870378f, -0.09159477f, -0.08717143f, 
    -0.25870579f, -0.02199471f, 0.04715361f, -0.01778274f, 0.02367233f, -0.00944481f, 0.01454877f, 0.02274883f, 
    0.00436431f, -0.11501605f, -0.07790122f, -0.01595285f, -0.04146466f, 0.02746850f, 0.05427272f, -0.02214446f, 
    -0.11155488f, 0.05693566f, -0.03132832f, 0.02531444f, 0.01638115f, -0.05485705f, -0.03416788f, -0.05628633f, 
    0.25266466f, 0.13763809f, 0.28676572f, -0.53836787f, 0.14085382f, -0.15322790f, -0.00512270f, -0.25106713f, 
    -0.18238994f, -0.03162182f, -0.07293298f, -0.06131576f, 0.22901082f, -0.83037442f, -0.40768528f, 0.17123823f, 
    0.04458513f, -0.01714154f, -0.12004144f, -0.02386359f, -0.10702499f, -0.08646582f, -0.35815609f, -0.06127419f, 
    -0.04180219f, -0.31711745f, -0.15892440f, 0.06221552f, -0.02089259f, -0.08242133f, -0.03789284f, 0.01025331f, 
    0.06296252f, 0.10653453f, -0.02354954f, -0.09871904f, 0.05598676f, 0.00075446f, -0.06138081f, -0.03558458f, 
    0.21640971f, -0.23672135f, -0.00145421f, -0.22387207f, -0.04405019f, -0.02438010f, 0.03990631f, 0.04539642f, 
    0.25921306f, 0.48191011f, -0.05277375f, -0.09406240f, 0.14307860f, 0.44034648f, 0.07413156f, 0.18868697f, 
    -0.03910941f, -0.01308196f, -0.03488008f, -0.06141033f, 0.00814335f, -0.02423003f, -0.17074868f, -0.01172935f, 
    0.06829410f, 0.04201334f, 0.06774730f, 0.10512942f, -0.02780234f, 0.02641069f, -0.04326443f, 0.05731193f, 
    0.23660558f, 0.18468104f, 0.25919834f, -0.23131560f, -0.02890425f, 0.40545776f, -0.01671227f, 0.13069394f, 
    0.03216291f, 0.03105122f, 0.06971338f, -0.03237255f, 0.26241037f, 0.19127320f, -0.07350767f, -0.03641938f, 
    -0.06001998f, -0.22823994f, -0.06298656f, -0.07814021f, 0.00112361f, -0.13240020f, -0.04394958f, -0.05295744f, 
    0.00406836f, -0.05696521f, -0.25285232f, -0.14742312f, 0.01428920f, -0.03952297f, -0.20914683f, -0.07621519f, 
    -0.00526094f, -0.10968464f, 0.10057547f, 0.09375449f, -0.02500523f, -0.06089671f, 0.12170960f, -0.09108838f, 
    -0.00991621f, -0.15270101f, 0.10202596f, 0.00143798f, 0.05077699f, 0.00425213f, -0.06686526f, 0.06295867f, 
    0.15386273f, 0.04055091f, 0.22710523f, -0.23759085f, 0.09435852f, 0.14674476f, -0.01538877f, -0.06415162f, 
    0.06792900f, -0.22588560f, -0.03002945f, 0.04982427f, 0.37145925f, 0.40023220f, 0.18009469f, -0.12932877f, 
    -0.04304662f, -0.05768010f, 0.11321636f, 0.03711780f, -0.01591917f, 0.04913704f, -0.03504549f, 0.07189786f, 
    -0.05022511f, 0.08444066f, 0.02544788f, -0.01608803f, -0.00768877f, -0.17053549f, -0.01149345f, -0.20826989f, 
    0.06634805f, -0.18227389f, -0.04868250f, -0.06558515f, 0.43293366f, 0.23382463f, 0.00110729f, -0.17259578f, 
    0.02285006f, -0.01640867f, 0.04081067f, 0.09651235f, -0.01117714f, 0.01237215f, 0.06299749f, 0.00392334f, 
    -0.70498508f, -0.37819946f, -0.40417650f, -0.02296738f, 0.07491598f, 0.03802066f, 0.04898836f, -0.00213627f, 
    -0.06100518f, -0.09480375f, -0.00816902f, -0.00266543f, -0.31740138f, -0.55907571f, -0.29271859f, 0.16541368f, 
    0.00016051f, 0.04213564f, 0.01548490f, -0.05393706f, -0.02604242f, -0.05228781f, -0.12395405f, -0.15817253f, 
    0.11664437f, 0.01435807f, 0.12865004f, 0.04144709f, 0.02501677f, 0.06924942f, -0.20931280f, -0.08819406f, 
    0.06220555f, -0.21728398f, -0.12219773f, 0.15466402f, 0.45657149f, 0.12353078f, -0.12106741f, -0.35758001f, 
    0.02750392f, 0.01689583f, 0.01242362f, -0.01154370f, -0.06956459f, 0.03649298f, 0.00380888f, 0.00628080f, 
    -0.14972796f, 0.00814570f, -0.40063670f, 0.26029399f, -0.05104573f, 0.02897156f, -0.25541371f, 0.02194534f, 
    0.06245109f, 0.03071784f, 0.02354052f, 0.03724494f, 0.18635640f, 0.21827790f, -0.14267394f, -0.04485796f, 
    0.14944386f, 0.14600140f, 0.13477243f, 0.00672067f, -0.08392853f, 0.01795025f, 0.03665686f, 0.00912334f, 
    0.21187095f, -0.34982333f, -0.48969644f, 0.09813203f, 0.08429298f, 0.10681790f, -0.05652590f, -0.02664121f, 
    0.09056276f, -0.05755815f, -0.06468603f, 0.16837297f, 0.34883693f, 0.12656547f, 0.10570533f, -0.36823696f, 
    -0.22625397f, -0.10460992f, 0.12490915f, 0.10489275f, -0.02756329f, -0.11872979f, -0.05951894f, -0.12223337f, 
    0.31628335f, 0.15086754f, -0.22907761f, -0.25186116f, 0.02889771f, 0.22949518f, -0.06691662f, -0.16152632f, 
    -0.05237640f, -0.08213366f, 0.02929343f, 0.04276906f, 0.32860813f, -0.58056849f, -0.45655918f, -0.18550737f, 
    -0.02831725f, -0.08918995f, -0.02035487f, 0.00806820f, 0.01419608f, -0.04976872f, -0.03998702f, 0.22156627f, 
    -0.10397480f, 0.08253859f, 0.00760860f, 0.00092793f, -0.05202106f, 0.11161529f, 0.07956213f, 0.15437061f, 
    -0.00515829f, 0.01310538f, 0.10714043f, 0.11174227f, 0.23183289f, 0.12501539f, 0.15991521f, 0.14900266f, 
    0.00607612f, -0.04995516f, -0.08425403f, -0.00818904f, 0.02368521f, -0.08529510f, -0.04249714f, -0.01335233f, 
    0.07700005f, 0.00336608f, 0.10333517f, -0.04938513f, -0.10020925f, -0.02984373f, -0.01650921f, 0.18466969f, 
    -0.02957236f, -0.16137984f, 0.14991944f, 0.01723234f, 0.42907706f, 0.05103305f, -0.67198294f, 0.17162785f, 
    -0.06604985f, 0.05414293f, -0.03910121f, -0.01004152f, 0.12169595f, 0.26706526f, 0.07455198f, 0.00597891f, 
    -0.08556236f, -0.20236969f, 0.16802815f, -0.19745691f, 0.24521522f, -0.01172959f, 0.06640206f, 0.00649505f, 
    0.00466837f, -0.03803581f, -0.10693844f, 0.27299145f, -1.25968099f, -0.04397413f, -0.34738505f, -0.04329911f, 
    0.00958078f, -0.31056777f, 0.17334242f, 0.01085438f, -0.10568034f, -0.08440325f, 0.13434765f, -0.02107605f, 
    0.14568533f, -0.02311579f, 0.25447485f, 0.02892940f, 0.06537785f, -0.04445302f, -0.01480699f, 0.00272406f, 
    0.15666002f, 0.02130341f, -0.05830910f, 0.01216317f, 0.03844946f, 0.12224296f, -0.07999615f, 0.04298037f, 
    -0.03681885f, -0.03889760f, 0.01081020f, -0.05580421f, -0.03034939f, -0.04839833f, 0.02846087f, 0.03908553f, 
    -0.08811646f, -0.17040014f, -0.58176625f, 0.11086646f, 0.02478416f, -0.01501230f, 0.09386884f, 0.11661888f, 
    -0.04279507f, 0.01195587f, -0.27233937f, 0.04282380f, 0.41546282f, -0.57698119f, -0.07863031f, -0.59109974f, 
    0.00733678f, 0.03104761f, 0.03802835f, 0.04535211f, 0.25788659f, -0.02839125f, -0.10611159f, -0.07284266f, 
    0.47179031f, 0.03781002f, -0.00013899f, -0.09584364f, -0.33020914f, 0.06985547f, 0.18066104f, -0.15516104f, 
    -0.07713997f, 0.00642599f, -0.00310880f, 0.06052905f, 0.02175624f, -0.15503354f, -0.08998550f, 0.04490296f, 
    0.06793933f, -0.07172186f, 0.12483407f, -0.06660300f, 0.27411464f, -0.17630826f, 0.16267273f, 0.08890793f, 
    0.66687071f, 0.32335907f, 0.18341121f, 0.24501519f, 0.16761199f, 0.07321791f, -0.11103012f, -0.09045496f, 
    0.02644074f, 0.04357222f, -0.08281021f, 0.02008018f, 0.02784064f, 0.08596686f, 0.28724006f, 0.06727667f, 
    -0.08570800f, 0.00707009f, 0.07430141f, -0.02014450f, -0.03874480f, 0.02455042f, -0.03948292f, 0.13032857f, 
    -0.09575894f, 0.30665141f, -0.01789153f, -0.34438264f, -0.16480444f, 0.06207221f, -0.14046526f, -0.10191400f, 
    -0.12394272f, -0.04554377f, -0.12463911f, 0.01552084f, -0.26595277f, -0.06715558f, -0.09155913f, -0.05211064f, 
    0.01134137f, -0.27513245f, 0.04542875f, 0.06435544f, 0.06362148f, -0.06665429f, 0.15246217f, 0.05518559f, 
    0.26526117f, -0.37143329f, 0.02118220f, -0.02492542f, 0.18922597f, 0.02867327f, -0.09632129f, -0.19313511f, 
    -0.04001825f, -0.08827038f, 0.24067986f, -0.26694110f, -0.02435629f, 0.09111599f, -0.13540673f, 0.00104334f, 
    -0.10114145f, -0.12030993f, 0.11424086f, 0.00819046f, 0.00984274f, 0.09705362f, 0.00067715f, -0.05418257f, 
    -0.44479841f, -0.11527184f, -0.11400834f, -0.16439986f, 0.07216814f, 0.14075974f, 0.02215602f, -0.05030476f, 
    -0.14036046f, 0.11127033f, 0.09884501f, -0.20845272f, -0.65813339f, -0.35847202f, -0.63316435f, -0.10079036f, 
    0.01545022f, -0.08886502f, -0.05898985f, -0.06280308f, -0.06527410f, 0.05014493f, -0.00238757f, -0.09183376f, 
    -0.28527883f, 0.13501522f, -0.03257094f, 0.15821411f, -0.01576661f, 0.03741108f, 0.20568703f, -0.20958433f, 
    0.16241691f, 0.05558087f, -0.04847302f, -0.10010530f, -0.20124964f, -0.03838439f, -0.39479169f, -0.22056901f, 
    0.01690933f, -0.41131926f, -0.22406007f, 0.21224558f, -0.00468480f, 0.01529041f, -0.01902934f, 0.02265906f, 
    0.31869477f, 0.15801546f, 0.57336414f, -0.05201242f, -0.01714031f, -0.00177694f, -0.06545193f, 0.05734305f, 
    -0.05645630f, 0.02838545f, -0.12338503f, -0.05505201f, 0.68953532f, 0.07691129f, 0.36774883f, 0.04295528f, 
    -0.11545404f, -0.12430302f, 0.07374293f, 0.01499933f, -0.04829011f, 0.02845275f, 0.03835585f, -0.04356958f, 
    -0.22734258f, 0.33390322f, 0.00777710f, -0.19768237f, 0.02165938f, 0.03639599f, 0.05192150f, 0.06139463f, 
    -0.04445394f, 0.10468099f, -0.50406241f, -0.21283196f, 0.05455285f, 0.24392979f, 0.07064049f, 0.09937081f, 
    -0.17827003f, 0.09558700f, -0.18886913f, -0.06103836f, -0.04574005f, -0.05598568f, -0.06315140f, 0.02823515f, 
    0.23961568f, -0.17034797f, -0.07220212f, -0.06807989f, -0.02110591f, -0.39402086f, -0.05248226f, -0.12444618f, 
    -0.08798824f, 0.01638975f, 0.01482370f, 0.04875377f, 0.03258399f, 0.06822003f, -0.01158723f, 0.18684393f, 
    -0.19805028f, -0.10175620f, -0.20407218f, -0.25506240f, -0.06959664f, -0.02519800f, -0.01622746f, 0.00184105f, 
    1.00358510f, -0.27698556f, -0.13164805f, -0.08949483f, 0.01878736f, -0.02984052f, 0.00317764f, -0.34468666f, 
    0.08982900f, -0.12373612f, -0.12755713f, -0.14579801f, 0.05783218f, -0.02578329f, -0.19542755f, -0.44160217f, 
    -0.17992434f, 0.08488471f, 0.01624392f, 0.20152391f, 0.02029916f, 0.04562210f, -0.03843193f, -0.02476250f, 
    0.21067218f, 0.03732940f, 0.43135908f, -0.04605080f, 0.16602333f, 0.03492637f, -0.11486123f, 0.21176831f, 
    -0.03765520f, 0.06355634f, 0.01791450f, 0.00413965f, 0.21341516f, -0.05022239f, 0.27114069f, 0.20437708f, 
    -0.00013533f, -0.04237018f, -0.05436006f, -0.07342986f, 0.13522474f, -0.00616747f, 0.16697246f, 0.00790303f, 
    -0.10305962f, -0.24925104f, -0.11614206f, 0.09484317f, 0.16557813f, 0.01181171f, -0.03600855f, 0.02589964f, 
    -0.10044512f, -0.10953978f, -0.47989154f, -0.07587054f, 0.01745758f, -0.00968663f, -0.03657746f, 0.05933369f, 
    -0.00071244f, -0.11881550f, 0.00248381f, 0.05147466f, 0.05483918f, 0.05234334f, -0.12501743f, 0.18475507f, 
    -0.23252966f, 0.07328005f, -0.15532586f, 0.04618599f, 0.08494858f, 0.01452515f, 0.02585919f, 0.00832262f, 
    0.01345516f, -0.16424054f, 0.05751653f, 0.10671131f, -0.09181238f, 0.14400639f, -0.14903942f, 0.07707141f, 
    -0.05520557f, 0.04148601f, 0.06653950f, 0.08911107f, 0.08297600f, -0.02032526f, 0.09546429f, -0.07859075f, 
    -0.12925775f, 0.19025743f, 0.10872968f, 0.05733053f, 0.00526716f, 0.02544118f, -0.15751724f, -0.13375498f, 
    -0.01765802f, 0.10298556f, 0.17267287f, -0.04159787f, -0.18340807f, -0.17441903f, -0.47454432f, 0.30332837f, 
    -0.08757071f, -0.32139817f, -0.16313282f, 0.05803879f, 0.02838834f, 0.01232687f, -0.11817469f, -0.06207623f, 
    0.01888347f, -0.05294571f, 0.04727707f, 0.08095963f, -0.00354342f, -0.10279267f, 0.04869360f, 0.06001428f, 
    0.03829181f, 0.12950128f, -0.18159387f, 0.17847489f, -0.32897392f, -0.00015619f, -0.05800030f, -0.07317106f, 
    -0.06012688f, 0.05123156f, -0.04921360f, -0.03708761f, 0.00823173f, 0.04998593f, -0.03774667f, -0.01479172f, 
    0.02572440f, -0.08527592f, -0.19174132f, 0.00183974f, 0.07554660f, 0.10383791f, -0.03073291f, 0.14914478f, 
    -0.02872753f, -0.13197900f, 0.05748447f, -0.04620921f, -0.62058765f, 0.82000935f, -0.04005365f, -0.19357802f, 
    0.01666374f, 0.05469611f, -0.03493948f, -0.26850602f, -0.04413611f, 0.04603139f, -0.39183033f, 0.20243190f, 
    -0.10721412f, -0.23393834f, -0.09112269f, -0.01018174f, -0.18760350f, 0.08259099f, 0.05654593f, -0.08148655f, 
    0.02009151f, -0.01211330f, 0.00835896f, -0.00088500f, 0.00803486f, -0.03032077f, -0.09674353f, 0.04066114f, 
    -0.06791668f, -0.07473056f, 0.08081482f, 0.10186076f, -0.20157239f, -0.19478175f, 0.10181602f, 0.05998585f, 
    -0.37914050f, 0.00716694f, 0.19680391f, 0.26829746f, 0.06368127f, -0.08142276f, -0.07905758f, -0.02204046f, 
    -0.03705465f, 0.00417871f, -0.04817499f, -0.07108873f, -0.16376533f, -0.47095999f, -0.33256844f, -0.00724159f, 
    -0.01481285f, 0.06633978f, 0.10063744f, -0.03767054f, -0.03625066f, -0.06027275f, 0.10555463f, -0.11881880f, 
    -0.09182566f, 0.39071316f, 0.12382781f, 0.45550460f, -0.17286330f, 0.01636205f, -0.12556228f, 0.06686032f, 
    0.01634607f, 0.00191911f, -0.01045246f, 0.04727995f, -0.06504980f, 0.10698164f, -0.01328474f, -0.09938033f, 
    0.28298983f, -0.10087424f, -0.13841370f, 0.20340654f, 0.03374530f, 0.07157116f, 0.00216390f, 0.00380917f, 
    -0.09503553f, 0.51320785f, 0.43976021f, 0.07204566f, 0.03137159f, 0.09104019f, 0.01655623f, 0.02232493f, 
    0.16453469f, -0.10661697f, 0.13354284f, -0.01178608f, -0.11262179f, 0.00196080f, -0.11441464f, 0.04913788f, 
    -0.05417787f, -0.06122949f, 0.00652630f, 0.05941321f, -0.11146732f, 0.05724361f, -0.02474512f, 0.08978263f, 
    0.55794317f, 0.33384559f, 0.20433299f, 0.51039249f, -0.03343102f, 0.09144549f, 0.01025728f, -0.06157584f, 
    -0.01765403f, -0.06512956f, 0.00863421f, 0.10926674f, -0.14463465f, 0.19353439f, -0.63626927f, -0.10255596f, 
    0.05136719f, -0.02533308f, 0.06785192f, -0.04345802f, -0.01688568f, 0.06228897f, 0.03483310f, -0.11254679f, 
    -0.00801580f, -0.07689776f, -0.06577604f, 0.07446731f, -0.13396955f, 0.14174764f, 0.06493140f, -0.06440779f, 
    -0.05107161f, 0.08735589f, -0.04582255f, -0.13256003f, -1.15096200f, -0.28749934f, -0.25685033f, -0.20597865f, 
    -0.00095693f, -0.10568429f, -0.04574945f, -0.07405992f, 0.02170114f, -0.01263730f, -0.02274097f, -0.01526797f, 
    0.00230818f, -0.25421044f, 0.43568948f, -0.02379125f, 0.00047202f, 0.02275007f, -0.02242725f, 0.05165194f, 
    0.10272893f, -0.02639930f, -0.05574272f, 0.11406013f, -0.22823721f, 0.14651832f, 0.08279869f, -0.68099207f, 
    0.07186003f, -0.00780870f, -0.04813126f, -0.02256829f, -0.01053592f, -0.00883950f, 0.09801588f, -0.07481835f, 
    -0.30817318f, 0.47700655f, 0.40932366f, 0.04679210f, -0.16675064f, -0.05551690f, -0.01270264f, -0.10141132f, 
    -0.16833088f, -0.11857793f, 0.03590890f, -0.07943817f, -0.51298296f, -0.38993564f, -0.33847949f, -0.46794343f, 
    -0.01609084f, 0.05688940f, 0.09442133f, 0.01790284f, 0.05644097f, 0.03457714f, 0.02416036f, -0.03583957f, 
    -0.53279716f, -0.32965150f, 0.56882811f, -0.46227217f, -0.00798873f, -0.10649640f, -0.11387039f, 0.06795420f, 
    0.03688882f, -0.04440530f, 0.00694795f, 0.00218111f, -0.07840324f, -0.07790915f, 0.04459822f, 0.26607573f, 
    0.08860684f, 0.04192746f, 0.07559874f, -0.05969537f, 0.02843139f, 0.09899034f, 0.04494605f, -0.01610497f, 
    -0.30070269f, 0.49798203f, 0.65139663f, -0.10797560f, -0.09108790f, -0.01404416f, 0.17252256f, -0.24344665f, 
    0.11602789f, 0.04469894f, 0.09931338f, -0.08452086f, 0.20883965f, -0.19870609f, 0.06052897f, -0.20713060f, 
    0.51727551f, 0.15524532f, -0.30323708f, 0.39629224f, 0.02222005f, -0.03257119f, 0.06656865f, 0.01216946f, 
    -0.61331284f, -0.63363636f, 0.20192012f, -0.19752724f, -0.02029031f, 0.02871847f, -0.17015976f, -0.14976133f, 
    -0.00140505f, 0.01318402f, -0.09367733f, -0.04496665f, 0.15800844f, 0.19637792f, -0.38968146f, -0.20699066f, 
    -0.01845648f, -0.07821323f, 0.06540268f, 0.16723251f, -0.01816412f, 0.18706085f, 0.20255676f, -0.27132541f, 
    0.20132257f, 0.20181365f, 0.13157892f, -0.07140502f, 0.14515570f, -0.04513517f, -0.09474578f, -0.09166721f, 
    -0.18691885f, 0.10747858f, -0.09332506f, 0.19504331f, -0.30399725f, -0.27764493f, -0.21955504f, -0.11355894f, 
    -0.42269614f, 0.01389907f, -0.09480583f, -0.25843698f, 0.06809998f, 0.17738052f, -0.18348572f, 0.15659101f, 
    -0.07494571f, -0.18236186f, 0.11296788f, 0.11955775f, 0.07794404f, 0.08307724f, -0.17534521f, -0.11123571f, 
    0.00674799f, 0.09588992f, -0.28371871f, -0.04453974f, 0.19254158f, 0.12606099f, -0.23148538f, -0.17754146f, 
    0.11492188f, -0.19108272f, -0.04033310f, -0.16034569f, -0.15825444f, 0.02928304f, -0.35867527f, 0.12243126f, 
    -0.06199032f, -0.37244561f, 0.06387471f, 0.12056712f, -0.48286974f, 0.07201008f, -0.39026821f, -0.22080170f, 
    0.14173235f, -0.00638822f, -0.13716106f, -0.02514421f, -0.03243611f, 0.53346449f, -0.44070438f, -0.40827349f, 
    -0.30309251f, -0.02229330f, -0.06829489f, 0.00755326f, -0.07929805f, 0.01459925f, -0.01005692f, 0.02170054f, 
    -0.06169803f, -0.19470070f, -0.09623192f, -0.56228071f, -0.30325168f, -0.33068654f, -0.15103813f, -0.15079670f, 
    -0.19245401f, 0.13609146f, -0.12275623f, 0.15499477f, -0.06410099f, -0.34664509f, 0.03904266f, -0.40180430f, 
    -0.02334190f, -0.23202375f, -0.09252156f, -0.13112675f, 0.07042556f, -0.05857377f, -0.06286091f, -0.04121518f, 
    0.03176607f, 0.15041241f, -0.15076713f, 0.06864112f, 0.00287605f, 0.03407327f, -0.05157067f, -0.02937486f, 
    -0.18002664f, -0.04660240f, 0.11641245f, -0.01270876f, -0.51696807f, 0.01086820f, 0.06670719f, 0.48534960f, 
    -0.06860412f, 0.06242026f, -0.30623677f, 0.00995855f, -0.13456455f, 0.17399950f, 0.14003822f, 0.01492302f, 
    0.07645477f, 0.15073824f, 0.23045896f, 0.48437980f, -0.04790720f, -0.08393630f, -0.17456761f, -0.11326247f, 
    -0.12442306f, -0.09347495f, 0.00019233f, -0.07683039f, -0.57015145f, 0.30929765f, -0.21787935f, 0.13981071f, 
    -0.01041895f, -0.21900344f, 0.05291380f, 0.08715389f, -0.06863341f, -0.27334398f, -0.14782746f, -0.04146254f, 
    0.26305383f, -0.39457640f, -0.05066177f, 0.14459372f, -0.00791158f, -0.04302491f, 0.03507807f, -0.13287707f, 
    -0.06074977f, 0.08414359f, 0.01059783f, 0.05515228f, -0.11507667f, -0.22614904f, 0.13473125f, -0.01352997f, 
    0.07653974f, 0.04218841f, -0.03016414f, 0.24522518f, -0.05796662f, 0.06538497f, -0.02692406f, -0.14463708f, 
    0.79147261f, -0.32742253f, -0.12860937f, 0.10999557f, 0.16865432f, 0.01402622f, 0.06636681f, -0.08043520f, 
    0.01539598f, 0.04141863f, 0.07765587f, 0.19464506f, -0.07037335f, 0.49447784f, -0.24199164f, 0.08916539f, 
    0.18001366f, 0.24535421f, 0.00917429f, -0.11598258f, -0.16911411f, -0.25806257f, 0.08965765f, 0.25856450f, 
    -0.37563017f, -0.34227794f, 0.03540730f, 0.33221540f, 0.05280460f, 0.03229995f, 0.12419945f, 0.13595131f, 
    0.08475774f, -0.04192441f, 0.00244669f, 0.05687751f, 0.43701443f, -0.13350537f, -0.04763143f, 0.37963244f, 
    -0.04640213f, -0.23246856f, -0.17915791f, -0.12505352f, 0.19913645f, -0.00148837f, 0.18611072f, 0.03451845f, 
    0.39666250f, -0.17017406f, 0.04516625f, 0.14822166f, 0.12822492f, 0.05961142f, -0.00420256f, 0.00296341f, 
    -0.07469079f, -0.03739138f, -0.16593179f, 0.05920220f, -0.01951184f, 0.20077039f, -0.10496964f, -0.22187507f, 
    0.05970572f, 0.03646806f, -0.24593712f, 0.34821522f, -0.17967421f, 0.06425785f, 0.11898021f, -0.01843986f, 
    -0.38857764f, 0.48619443f, -0.29250625f, -0.30410698f, 0.07873518f, -0.17791645f, 0.16523744f, -0.30800566f, 
    -0.10433155f, 0.17398374f, -0.14588301f, -0.39588988f, -0.25214300f, -0.05194140f, 0.01562095f, 0.36136058f, 
    0.02184837f, 0.24813032f, 0.14653830f, -0.00046383f, 0.09562054f, 0.05200905f, -0.07049242f, 0.05941727f, 
    -0.32497573f, 0.16794840f, 0.12543161f, -0.17186978f, -0.32643297f, -0.11041968f, -0.68381578f, 0.01833436f, 
    -0.14832197f, -0.07460616f, -0.03334326f, -0.01574267f, -0.42531523f, 0.16457368f, -0.14370152f, 0.37397784f, 
    0.17662270f, 0.04569319f, -0.17540133f, -0.03839104f, 0.11237551f, -0.01754212f, 0.12192039f, -0.03851268f, 
    0.30577695f, -0.20169301f, -0.09679905f, 0.20222400f, 0.07034159f, 0.07941503f, 0.15262634f, -0.04578947f, 
    -0.07376534f, 0.20249270f, 0.08916174f, 0.08773590f, -0.16537286f, -0.16553693f, -0.12169147f, 0.04150979f, 
    -0.01011255f, 0.07247020f, -0.07472568f, 0.07462334f, 0.00691209f, -0.00908254f, -0.01023530f, -0.13183074f, 
    -0.00339674f, -0.37690467f, 0.79204309f, 0.15931736f, -0.37468868f, 0.05164845f, -0.18335348f, 0.08582225f, 
    0.07728126f, 0.28784013f, -0.05980916f, 0.08110149f, 0.00331601f, -0.19828117f, -0.07167870f, 0.10634655f, 
    0.07316072f, -0.04263365f, 0.24085261f, -0.11134876f, -0.11007499f, -0.03081189f, 0.14150719f, 0.09383912f, 
    -0.52758205f, 0.24392579f, 0.08401221f, 0.28279310f, 0.27159393f, 0.18286617f, 0.24543850f, -0.09963343f, 
    -0.01786980f, -0.12602817f, 0.14041011f, -0.12965967f, -0.03074034f, 0.02682057f, -0.03427077f, -0.01572272f, 
    0.09566993f, 0.00989191f, -0.17893183f, -0.00700638f, 0.05773916f, 0.11334811f, 0.15221800f, 0.01539264f, 
    0.05870102f, -0.23876603f, -0.00091000f, 0.34175742f, 0.06306320f, -0.03719169f, -0.10556916f, -0.00115339f, 
    -0.06394670f, 0.10700016f, -0.16266465f, -0.02490698f, -0.68302613f, 1.23040283f, -0.71197253f, 0.38225704f, 
    0.38347870f, -0.00939341f, 0.27841890f, -0.20156564f, -0.18532705f, -0.06670322f, 0.11694666f, -0.14787270f, 
    0.34776881f, 0.15569784f, -0.06467162f, 0.20376955f, -0.10810318f, 0.00131522f, 0.14963911f, -0.09232239f, 
    0.00506137f, -0.34254682f, -0.14697856f, -0.29036820f, -0.10227858f, -0.20860997f, -0.11652631f, -0.07696556f, 
    0.12659563f, -0.07214812f, 0.05441170f, -0.06395679f, 0.08467575f, -0.00061250f, 0.07927698f, 0.04143472f, 
    0.03936736f, 0.08604066f, -0.07894321f, -0.10725827f, -0.02079174f, 0.09321784f, -0.04457935f, -0.02223022f, 
    0.05800750f, -0.10921557f, -0.26535431f, -0.09703032f, 0.08192147f, -0.21043037f, 0.34617588f, -0.19506225f, 
    -0.14233519f, 0.15471745f, -0.41555053f, -0.03559755f, -0.20724656f, -0.18414888f, -0.25996113f, -0.22653724f, 
    -0.14947961f, -0.10587189f, -0.13461919f, -0.01546264f, 0.17086807f, 0.18073216f, -0.17269999f, -0.10088706f, 
    -0.00572859f, 0.08840913f, 0.08382940f, 0.09968498f, -0.00949367f, -0.30529100f, 0.29074720f, 0.02203666f, 
    -0.11264387f, 0.11486779f, -0.25171873f, -0.08102868f, -0.01383424f, 0.11813658f, -0.14059532f, 0.11040507f, 
    -0.06212352f, -0.09876279f, -0.22585860f, -0.00060521f, 0.02194882f, 0.04583428f, 0.03201712f, -0.05166018f, 
    0.01245484f, -0.10578226f, 0.01784430f, -0.07901853f, 0.07723980f, 0.06971072f, 0.07694952f, 0.19710062f, 
    0.11097870f, 0.07495300f, 0.00925527f, 0.15895838f, -0.09045818f, -0.00708675f, -0.06829377f, -0.02498075f, 
    -0.11686186f, 0.23558906f, 0.16053912f, 0.21769804f, -0.01639334f, 0.03484359f, -0.01339833f, -0.32766929f, 
    -0.11297557f, -0.07185315f, 0.02690417f, -0.11780767f, -0.27307278f, -0.06424066f, 0.10920427f, 0.14451204f, 
    0.11312969f, -0.02625473f, -0.03709738f, 0.00929602f, -0.09274188f, -0.16477731f, 0.08255856f, -0.00027391f, 
    -0.16382904f, 0.30526125f, -0.17218521f, -0.19332807f, -0.12987320f, -0.03491769f, -0.07725396f, 0.16716635f, 
    -0.04217857f, -0.09950335f, -0.08011301f, -0.09233745f, 0.04187519f, -0.03824012f, 0.00239750f, 0.10441779f, 
    -0.32188544f, -0.08912585f, -0.09554122f, 0.00172080f, -0.04965450f, 0.11499932f, -0.01710338f, -0.40038666f, 
    -0.25426686f, -0.20893279f, -0.10133063f, 0.10065483f, -0.00319693f, -0.13135445f, -0.01588062f, -0.00256598f, 
    -0.03459263f, -0.01616765f, 0.13111392f, 0.12736417f, 0.20246376f, 0.01794595f, 0.12338588f, 0.04085543f, 
    0.09445474f, 0.10786168f, 0.11183828f, 0.10145293f, 0.10051543f, -0.07624675f, -0.05283756f, -0.15436536f, 
    -0.19447967f, -0.07982846f, 0.02851286f, 0.22773585f, -0.11772358f, -0.12445877f, -0.01501645f, 0.13031521f, 
    0.09996201f, 0.05729019f, -0.03155368f, -0.09050860f, 0.06174435f, -0.18267453f, 0.13010447f, 0.17289667f, 
    -0.13239406f, -0.19995727f, -0.23317571f, 0.11283790f, -0.22282298f, 0.16653869f, -0.25048697f, 0.02015135f, 
    -0.00129366f, 0.16968341f, -0.07331152f, 0.08310081f, -0.21618849f, -0.16145028f, -0.10853174f, -0.14961718f, 
    -0.08859850f, 0.04321091f, -0.13169670f, 0.13779646f, -0.02626870f, 0.19001317f, 0.22687985f, 0.10036338f, 
    -0.22033210f, 0.17031749f, -0.21979411f, 0.16411851f, 0.01422191f, -0.09139148f, -0.04619001f, -0.00418393f, 
    0.19299597f, 0.47661027f, 0.02903396f, 0.30459005f, -0.12742187f, -0.17039758f, 0.05504862f, -0.06982108f, 
    0.06917690f, -0.13835992f, 0.00797179f, 0.03224877f, 0.15176359f, -0.37052974f, 0.20275407f, 0.18130778f, 
    0.04959631f, 0.04466763f, 0.06244503f, -0.18601736f, 0.05073304f, -0.08161807f, 0.03986623f, 0.12578286f, 
    0.03416097f, -0.15637459f, 0.03587111f, -0.01890520f, -0.03948889f, -0.11248924f, -0.09648873f, 0.05790965f, 
    -0.44926220f, -0.17266189f, -0.04804984f, -0.05662312f, 0.25898960f, 0.17741857f, 0.28404003f, 0.20863432f, 
    0.15689912f, 0.02334675f, -0.12284788f, 0.04245256f, -0.00664271f, -0.08335456f, 0.00955603f, -0.13435833f, 
    -0.07093222f, -0.68547183f, -0.45217812f, -0.22103713f, -0.01851946f, 0.08741900f, 0.10498148f, -0.13838835f, 
    0.13650727f, -0.05085672f, 0.06650832f, -0.05976247f, -0.26661471f, 0.15548185f, -0.46106523f, -0.24770443f, 
    0.14565639f, 0.04738689f, -0.03269710f, 0.02115775f, -0.16636960f, 0.00341632f, -0.06301090f, -0.13008553f, 
    -0.34555107f, 0.18287121f, 0.05720140f, 0.10647793f, -0.01218512f, 0.04800391f, 0.13924149f, 0.06113997f, 
    0.04139535f, 0.02189505f, 0.15098010f, 0.22523057f, -0.00811037f, 0.08155749f, 0.28306285f, 0.20650326f, 
    -0.09228084f, -0.07480218f, 0.07288019f, -0.07865943f, 0.01452373f, 0.01357575f, 0.00537527f, -0.05677127f, 
    0.43017495f, 0.68761122f, -0.32305712f, 0.14200187f, 0.17318520f, 0.09510677f, 0.19032350f, 0.01583614f, 
    0.10100872f, -0.08314167f, 0.02050309f, -0.01596731f, -0.03089280f, 0.10453135f, 0.11420905f, 0.14954442f, 
    0.03806883f, -0.04735642f, -0.15438354f, 0.04269011f, 0.15110984f, 0.03381303f, 0.06341171f, 0.09925653f, 
    -0.25205892f, 0.16167934f, 0.06285142f, -0.03063106f, -0.08819325f, -0.06843591f, -0.03892434f, -0.13259506f, 
    -0.01315663f, -0.04705521f, -0.17157467f, 0.29335043f, -0.12342729f, 0.19345489f, 0.06621774f, 0.38224801f, 
    -0.10198275f, 0.10375796f, 0.08947787f, -0.75310951f, -0.07333086f, -0.00197901f, -0.14066826f, -0.07620738f, 
    -0.03675973f, 0.18635359f, 0.08595522f, 0.16750272f, -0.03472919f, -0.04571583f, 0.16505294f, 0.04742359f, 
    0.01329562f, 0.02179911f, 0.08773059f, -0.09980563f, -0.21414366f, -0.48058575f, 0.21378574f, -0.23925368f, 
    0.13134749f, 0.05815301f, 0.02508228f, 0.01893677f, 0.04607001f, -0.05584950f, 0.01918886f, 0.01701538f, 
    -0.22009803f, -0.31571686f, 0.05575493f, -0.10323806f, -0.14494842f, -0.10183832f, -0.10137651f, -0.07725843f, 
    0.22402406f, 0.09854551f, 0.01563081f, 0.08851554f, -0.17346391f, -0.17741436f, -0.18327573f, 0.00417361f, 
    0.14967413f, -0.04951353f, -0.11184605f, 0.10254189f, 0.00630827f, 0.03989572f, 0.10781179f, -0.22622547f, 
    0.29416928f, 0.06532385f, -0.16081017f, 0.12923332f, 0.04699481f, -0.16985655f, 0.00950032f, -0.01485083f, 
    -0.15189090f, 0.26033649f, 0.15121149f, 0.01717704f, -0.17189170f, -0.17990647f, 0.36377284f, -0.11744921f, 
    -0.00603329f, 0.02604347f, 0.26476333f, -0.08658470f, 0.21458165f, -0.05671437f, 0.27293786f, 0.24562044f, 
    0.46752286f, 0.04731159f, -0.27080917f, 0.18094139f, -0.19868194f, 0.03373622f, -0.09038942f, -0.07128777f, 
    -0.00688489f, -0.17488804f, 0.00139330f, -0.33644858f, 0.16671345f, -0.45835385f, 0.66520536f, 0.07217841f, 
    0.07555833f, 0.09946913f, 0.04761897f, -0.01457207f, 0.17909686f, -0.04260973f, -0.06121515f, -0.04697334f, 
    -0.30629042f, 0.01813227f, -0.14992844f, 0.12695299f, 0.05779712f, 0.03121761f, -0.07098840f, 0.13741674f, 
    -0.10696988f, 0.12809077f, 0.27438670f, 0.00144856f, -0.25523338f, -0.10539576f, 0.01122225f, 0.03007719f, 
    -0.01935335f, -0.01304795f, -0.05159894f, 0.05237051f, 0.07725690f, -0.01315812f, -0.03157024f, 0.11168011f, 
    -0.04292618f, -0.07566859f, 0.41491458f, -0.11682643f, -0.27184922f, 0.02116224f, 0.02963100f, 0.12532739f, 
    0.13684088f, -0.15359829f, -0.03808499f, 0.05906478f, -0.04122036f, -0.10716093f, -0.55459923f, -0.05654035f, 
    -0.12677053f, 0.01119365f, 0.02202466f, 0.04162365f, 0.13721804f, -0.02772284f, 0.07841592f, -0.05798149f, 
    -0.00095712f, -0.14485645f, -0.20865785f, 0.06025806f, 0.44785038f, 0.02809636f, -0.13761486f, 0.05618001f, 
    0.07219718f, 0.00346340f, 0.02065583f, 0.08946094f, 0.19332914f, 0.01374093f, -0.11757565f, -0.05810666f, 
    0.14978313f, 0.17738864f, -0.06246871f, 0.11201648f, -0.18525761f, -0.02093903f, -0.17961410f, 0.12205427f, 
    -0.31192476f, 0.18699037f, 0.12853478f, -0.28502613f, -0.08650305f, -0.21911237f, -0.02183257f, 0.09153454f, 
    0.01271862f, -0.03055740f, 0.02014972f, 0.03785983f, -0.24762395f, -0.03185223f, -0.15291353f, 0.17443281f, 
    -0.02076365f, -0.09435815f, -0.11730721f, -0.07303139f, -0.02707141f, -0.04676657f, 0.21475980f, 0.12902629f, 
    -0.38043895f, -0.30736566f, -0.19222407f, 0.08794443f, 0.14554122f, -0.06727853f, 0.09905682f, 0.01028135f, 
    -0.09768801f, 0.00745252f, 0.10825515f, 0.03825700f, 0.33676946f, 0.13921939f, 0.04290821f, -0.09129804f, 
    -0.17814404f, 0.29351568f, 0.05103239f, 0.12920548f, 0.27453265f, 0.02684224f, 0.00961991f, -0.04834176f, 
    0.09677020f, 0.13363563f, 0.06784028f, -0.36960113f, 0.02925134f, 0.05267444f, -0.02127758f, 0.05644090f, 
    -0.01604658f, -0.04471188f, -0.28371730f, -0.18753104f, -0.10504854f, -0.19833918f, 0.00858500f, 0.02357970f, 
    0.09051287f, 0.01227634f, -0.20498210f, -0.26582238f, 0.05656167f, 0.00961484f, 0.07566613f, 0.18585908f, 
    -0.61138588f, -0.35616612f, -0.06870081f, -0.07884914f, -0.03705591f, -0.09719575f, 0.03487551f, 0.07072688f, 
    0.06044310f, 0.03625254f, -0.18148059f, -0.09309171f, -0.17956252f, 0.28896874f, 0.48863336f, 0.27429509f, 
    0.01376469f, -0.03988536f, 0.00453542f, 0.08246093f, 0.06401659f, 0.00168357f, -0.07828711f, -0.06181573f, 
    0.33265388f, -0.31509843f, 0.10939953f, -0.04866573f, -0.09584320f, 0.06229675f, -0.20420979f, 0.18095905f, 
    0.06036442f, 0.03855786f, 0.07480856f, 0.30460718f, 0.16679102f, 0.08196246f, 0.31379181f, -0.21560290f, 
    -0.06800845f, -0.09249570f, 0.03169273f, -0.07554989f, -0.06238142f, -0.04111424f, 0.10153484f, -0.03647787f, 
    0.19330104f, -0.03658973f, -0.38902265f, 0.43156388f, 0.03241902f, -0.06773081f, 0.15515986f, 0.04633782f, 
    0.08039659f, -0.06562683f, 0.08620659f, 0.02554243f, 0.11312068f, -0.40381959f, -0.84029347f, -0.08915795f, 
    0.10177744f, -0.01217883f, -0.09022961f, -0.04295207f, 0.29738629f, -0.03972573f, -0.14888170f, 0.18521588f, 
    0.36764640f, -0.17271870f, -0.03600387f, -0.37426722f, 0.05264807f, -0.06773924f, 0.02454933f, 0.05994773f, 
    0.05244642f, -0.08805969f, -0.06807653f, -0.38952547f, 0.15511544f, 0.07644124f, 0.06583796f, 0.10806857f, 
    0.32697010f, 0.02515643f, 0.25766730f, -0.08207678f, 0.07607453f, 0.07135545f, 0.06182789f, 0.10535270f, 
    -0.18133114f, -0.01903623f, -0.46100426f, -0.26162502f, 0.22783987f, 0.30892777f, -0.07744285f, 0.19407597f, 
    0.00228703f, -0.02064510f, 0.00120263f, -0.08203124f, 0.06271901f, 0.16312782f, 0.14643258f, -0.20099927f, 
    0.02029274f, 0.03133528f, -0.08223572f, 0.19245802f, -0.12624332f, -0.03524687f, -0.05229816f, -0.13631192f, 
    -0.22105205f, -0.28934446f, -0.52696466f, -0.46558037f, -0.01758575f, -0.01288622f, -0.11774778f, 0.14112468f, 
    -0.04272227f, 0.01861719f, -0.11682966f, -0.15600900f, -0.09146774f, 0.07054190f, 0.12090126f, -0.02522618f, 
    0.24487361f, -0.08026017f, 0.24713154f, 0.16397986f, 0.14401715f, -0.08908571f, -0.01065631f, 0.10507495f, 
    0.01350425f, 0.23162892f, -0.03796012f, -0.10919305f, 0.07814728f, 0.00242016f, 0.26863033f, 0.00062806f, 
    0.09712016f, -0.04091215f, 0.11280080f, 0.06929724f, 0.02028718f, -0.12326414f, -0.09799918f, -0.23110102f, 
    -0.23169310f, -0.05123871f, -0.13165151f, 0.15428782f, -0.08639427f, 0.01916143f, -0.20724325f, -0.18854962f, 
    -0.09114628f, -0.15017191f, 0.02923011f, 0.08658901f, -0.02031567f, -0.14328063f, -0.06703895f, 0.02847263f, 
    -0.00842588f, -0.02901641f, 0.07738912f, -0.25615248f, 0.08228306f, -0.00715904f, -0.05427570f, 0.02332212f, 
    0.06710778f, 0.08646878f, 0.12651786f, -0.01711991f, -0.03230871f, -0.06842683f, 0.02402378f, -0.03568640f, 
    0.25957620f, 0.19925654f, -0.04673883f, -0.11270724f, 0.05102738f, 0.00071424f, 0.00849595f, -0.00600142f, 
    0.03252332f, 0.04879865f, 0.04182732f, -0.11449808f, -0.50655812f, 0.25057834f, 0.05530021f, 0.15233205f, 
    0.12239591f, 0.04882888f, 0.04180117f, 0.19354713f, 0.01086229f, 0.08504416f, -0.09351006f, 0.16636613f, 
    0.49941924f, 0.38400874f, -0.26895127f, -0.27519211f, -0.11162417f, 0.00220489f, 0.14985606f, 0.22100513f, 
    0.21320415f, 0.22540329f, -0.14200301f, 0.15803413f, -0.30888897f, -0.37683791f, -0.74392128f, 0.41077068f, 
    -0.15149342f, 0.14362085f, -0.03796343f, 0.17731398f, 0.06653704f, 0.03406523f, 0.11463753f, 0.13743235f, 
    0.08067180f, -0.04153436f, -0.20272358f, 0.05062217f, -0.09157454f, 0.00774131f, 0.04314435f, 0.18428913f, 
    -0.14820988f, -0.01043347f, 0.10918018f, -0.20272541f, -0.11639830f, -0.30872652f, -0.03436316f, 0.25198570f, 
    0.09681431f, 0.11501689f, 0.15384279f, 0.00479381f, -0.02822846f, -0.16411838f, 0.01875451f, -0.09355903f, 
    0.22818966f, -0.94524151f, -0.37401453f, 0.00848935f, -0.03795421f, -0.17908217f, -0.11064599f, 0.04470383f, 
    -0.05115944f, 0.13387948f, 0.13571380f, -0.13305607f, 0.88675249f, 0.59978795f, -0.16289522f, 0.36998412f, 
    -0.00066390f, -0.15048753f, -0.00167428f, -0.00899635f, 0.16799971f, 0.07385863f, 0.11843426f, -0.02265886f, 
    -0.15037246f, -0.21958171f, 0.04814391f, -0.54424596f, 0.02137992f, 0.04442185f, 0.17722121f, -0.00591114f, 
    -0.01214093f, 0.10194523f, -0.02516356f, 0.00172871f, -0.39625317f, 0.01159929f, 0.19465545f, 0.12304898f, 
    0.18307437f, -0.05198181f, 0.09950250f, -0.39170608f, -0.20358959f, 0.08740668f, -0.09171507f, 0.04370424f, 
    -0.65101182f, -0.88377625f, -0.65304238f, -0.05135671f, -0.10734759f, 0.00695944f, -0.19772825f, -0.12754013f, 
    -0.03796810f, 0.01597597f, 0.03958721f, -0.07430231f, 0.09013842f, -0.11203466f, -0.32252148f, -0.39526594f, 
    -0.00048847f, -0.06744023f, -0.01765514f, 0.04479795f, -0.14885214f, 0.10300200f, -0.29458311f, -0.14929500f, 
    -0.42864260f, -0.13729794f, -0.04179053f, 0.62988842f, -0.03101495f, 0.07602219f, -0.03864472f, 0.01795409f, 
    0.00439243f, 0.04657042f, -0.03609017f, -0.15680447f, -0.61034352f, -0.45841515f, -0.04939807f, 0.34921920f, 
    0.00234624f, -0.04808079f, 0.11299863f, -0.20343930f, -0.15154290f, 0.05264802f, -0.09814642f, 0.03227049f, 
    0.37573963f, 0.32860416f, -0.16025767f, -0.22546490f, 0.08214086f, -0.05353022f, 0.13604514f, 0.00479425f, 
    0.07440836f, 0.05328769f, 0.09199276f, 0.03796264f, -0.19456342f, -0.17870599f, -0.10465133f, 0.04398289f, 
    0.18760879f, 0.07905487f, 0.06779248f, -0.17941563f, -0.04626218f, -0.07750407f, -0.03303849f, 0.01752531f, 
    -0.36822730f, -0.00686354f, 0.28076115f, 0.25071123f, -0.14013921f, -0.13122988f, -0.07799442f, 0.17477436f, 
    -0.06344663f, 0.16596435f, 0.06650966f, 0.09064642f, 0.12595439f, -0.19386439f, -0.08130211f, 0.33955190f, 
    0.09009463f, 0.04974590f, -0.06368261f, -0.02888239f, 0.00475397f, -0.04155089f, 0.14831786f, 0.09335919f, 
    -0.14020273f, -0.00072065f, -0.00090324f, 0.21084201f, -0.12747195f, -0.07762511f, -0.04831021f, 0.40265697f, 
    0.06072466f, -0.14277683f, 0.04735766f, 0.03733863f, -0.43260074f, -0.86306870f, -0.56648612f, 0.35612157f, 
    -0.16138040f, 0.31480050f, 0.18956864f, -0.36226389f, 0.00395620f, -0.02272113f, 0.06898319f, 0.04266040f, 
    0.21976817f, 0.00501574f, -0.35338902f, -0.18479574f, 0.00469842f, -0.05341863f, 0.10381722f, 0.05109619f, 
    -0.07453914f, 0.04754510f, 0.07846981f, -0.06660640f, 0.29757985f, 0.00525964f, 0.07404588f, -0.04943988f, 
    0.02925555f, -0.06024628f, 0.10333004f, 0.05659189f, -0.08529171f, -0.04912383f, -0.08595430f, 0.04290867f, 
    -0.42945379f, -0.53705019f, -0.25728583f, 0.06103989f, -0.15258521f, -0.09871025f, -0.04790639f, 0.03664659f, 
    0.03292079f, 0.09637751f, 0.25713706f, 0.30015251f, -0.55479270f, -0.78629488f, -0.47016773f, -0.04543646f, 
    -0.26354557f, -0.16342425f, -0.11674431f, -0.33279175f, 0.00840458f, -0.07025947f, -0.01016339f, -0.03081493f, 
    -0.21510731f, -0.61213511f, 0.12535182f, -0.48959678f, -0.00684448f, 0.16171099f, 0.27486506f, -0.25800630f, 
    0.00123812f, -0.01212262f, 0.00913342f, 0.08225168f, -0.42060208f, -0.22254424f, -0.36000791f, -0.07998315f, 
    -0.29505512f, 0.25219163f, 0.08431026f, -0.05688017f, 0.10968752f, 0.03308009f, -0.03827447f, 0.04936091f, 
    -0.19996271f, 0.61153984f, -0.12235302f, 0.15830679f, -0.02286716f, 0.09299809f, 0.00053791f, 0.03340729f, 
    0.11263847f, 0.04292261f, 0.15718992f, 0.05416833f, -0.54971230f, -0.44624996f, -0.10459267f, 0.01251800f, 
    -0.12469930f, -0.44744638f, 0.11386984f, -0.41464111f, -0.14061299f, -0.00050259f, -0.05521042f, -0.09535588f, 
    -0.79554725f, -0.55513227f, -0.28620496f, -0.44400436f, -0.10405691f, -0.15829705f, -0.12510538f, -0.33879191f, 
    0.00329092f, -0.03956496f, 0.08822019f, -0.02351919f, -0.22843359f, -0.03516097f, -0.04471590f, 0.27639145f, 
    0.11396275f, 0.08306325f, 0.06976551f, -0.07635633f, 0.01989856f, -0.15312487f, -0.11354775f, 0.15082495f, 
    0.39127728f, -0.00543978f, 0.00880807f, -0.15330699f, -0.03306086f, 0.14135779f, 0.03391731f, 0.10245986f, 
    -0.03173275f, 0.12513936f, 0.14468566f, 0.08205792f, 0.07459610f, 0.04073803f, 0.11570612f, -0.14960842f, 
    -0.05477569f, 0.02071727f, -0.02222018f, -0.09550610f, 0.05489703f, 0.05683407f, 0.02332185f, -0.17878304f, 
    0.02354724f, -0.06275264f, 0.12862416f, 0.00892076f, -0.04694284f, -0.06140715f, -0.01701317f, -0.07448998f, 
    -0.08230235f, -0.22201540f, -0.25149012f, -0.33602065f, 0.10493638f, -0.53589338f, 0.17263679f, -0.54012424f, 
    -0.09874958f, 0.06035816f, 0.03833264f, -0.04293602f, 0.03105654f, -0.08848956f, -0.10093786f, -0.30466467f, 
    -0.08687375f, 0.10364700f, -0.08398169f, 0.07737894f, -0.06966309f, -0.01601414f, 0.22380236f, -0.05402151f, 
    -0.09314025f, 0.02839991f, 0.10323111f, -0.06232745f, 0.70813739f, -0.75030410f, 0.43855938f, -0.28862518f, 
    -0.11991674f, 0.31312227f, -0.12968928f, -0.15141682f, -0.08745480f, 0.17526804f, -0.01617932f, -0.12382254f, 
    0.01262932f, -0.05025256f, -0.01098454f, -0.07515182f, -0.03322681f, -0.01948675f, -0.04988398f, -0.05965656f, 
    -0.03950464f, -0.09676866f, -0.02045550f, -0.08820541f, -0.01096317f, -0.09528716f, 0.08925314f, -0.08638157f, 
    -0.00901627f, -0.05552557f, -0.03380922f, 0.05901980f, 0.02323927f, 0.06544467f, 0.01013162f, -0.09170976f, 
    0.46224430f, -1.02983928f, 0.47707114f, 0.49187231f, -0.16119227f, 0.09824441f, -0.33056334f, 0.00016225f, 
    -0.01432216f, -0.06191166f, -0.17857419f, -0.12249893f, -0.12963711f, -0.31979436f, -0.14660189f, -0.01572675f, 
    -0.01598881f, 0.02034577f, 0.08535013f, 0.10929871f, 0.02326016f, -0.08255128f, 0.19248769f, 0.02578476f, 
    -0.08085311f, 0.48541716f, -0.12957837f, 0.17801678f, 0.10831848f, -0.20401096f, -0.02561418f, -0.09252040f, 
    0.00571265f, 0.03959841f, -0.03995172f, -0.06183730f, -0.06852360f, 0.22297767f, 0.05761797f, -0.11795825f, 
    -0.12927258f, -0.02563088f, -0.13528131f, -0.02948654f, -0.38542670f, 0.10394994f, 0.04904824f, -0.01552049f, 
    -0.39489797f, -0.36398563f, -0.10759843f, -0.33988675f, 0.11855575f, 0.17159648f, 0.02926678f, 0.29810500f, 
    0.00985158f, -0.10229621f, -0.15766758f, 0.03095706f, 0.13873938f, 0.18508673f, -0.09868245f, -0.02128989f, 
    0.02386661f, 0.00522228f, 0.06440276f, 0.01326493f, -0.01692822f, 0.00682300f, -0.05335576f, -0.04584322f, 
    0.54270589f, -0.51247984f, -0.34054139f, -0.44413263f, -0.18177928f, -0.02465844f, -0.30386597f, 0.13537183f, 
    0.12490332f, 0.04077554f, 0.00991835f, -0.06704975f, 0.24727014f, -0.12732302f, 0.21732561f, -0.24437624f, 
    -0.09102917f, 0.17829971f, -0.08321872f, 0.05335248f, -0.09914468f, -0.03538049f, 0.04431992f, 0.04777345f, 
    -0.47008806f, -0.88829118f, 0.20252077f, -0.32267031f, -0.25191963f, 0.06479692f, 0.01600105f, 0.10730933f, 
    -0.10380065f, 0.18378112f, -0.06759005f, -0.05683075f, 0.10385474f, -0.01475883f, 0.03944018f, -0.15214249f, 
    -0.07049546f, -0.13144822f, 0.07007448f, -0.10585114f, 0.01508774f, 0.07001317f, 0.01814181f, -0.05957196f, 
    0.90610790f, -1.27617681f, -0.71442026f, -0.72546494f, -0.15930945f, -0.00790903f, -0.16003940f, -0.00135022f, 
    0.27968767f, 0.04953902f, 0.03223870f, 0.03551211f, 0.48189649f, -0.16370319f, -0.08491051f, -0.03385937f, 
    0.17346168f, -0.14076333f, -0.08975503f, -0.02014489f, 0.02777893f, 0.09278806f, -0.01740237f, -0.13945197f, 
    0.21685986f, -0.25076336f, 0.02889129f, -0.26830232f, -0.19074251f, 0.10137630f, -0.07010462f, -0.10963295f, 
    0.01221950f, 0.12001015f, -0.00448824f, -0.09763906f, -0.55168438f, -0.40589428f, 0.34681594f, 0.03243091f, 
    0.14038593f, 0.22823738f, 0.17344545f, 0.12682728f, -0.04414240f, -0.14659989f, 0.09433317f, 0.01431368f, 
    -0.26676217f, -0.04118327f, -0.09675034f, -0.08615119f, 0.06236650f, 0.01881304f, 0.03750686f, -0.13195752f, 
    0.09469629f, 0.09373482f, 0.02752682f, -0.03206622f, -0.15884277f, 0.35834578f, -0.03359179f, 0.38572821f, 
    0.00331660f, 0.11942321f, 0.02024557f, 0.01831386f, -0.04482567f, 0.04277913f, 0.03706855f, -0.16352555f, 
    -0.62236601f, -0.22908343f, -0.84516311f, -0.04643671f, -0.05057700f, 0.00000182f, 0.05140132f, 0.02562095f, 
    0.17893213f, 0.07687507f, 0.07124958f, 0.15680493f, -0.58332694f, -0.35383546f, -0.52614671f, -0.16118583f, 
    0.30114487f, -0.28945118f, -0.00915919f, 0.04624359f, -0.00627104f, -0.02103478f, 0.00891530f, -0.04806454f, 
    -0.24115449f, 0.41533858f, -0.16812888f, -0.05157370f, 0.00483144f, -0.08604492f, 0.02514957f, 0.03764290f, 
    0.00121433f, 0.01425776f, 0.04669777f, 0.00963905f, -0.35021088f, -0.21287338f, -0.11042172f, -0.33363655f, 
    0.01708720f, 0.08383260f, 0.20689407f, 0.19218168f, -0.10981222f, -0.23867723f, 0.04668101f, 0.06561096f, 
    -0.26314366f, 0.14274462f, -0.46409672f, 0.06074979f, -0.17627618f, -0.02076410f, 0.19108620f, 0.12819031f, 
    -0.07096956f, -0.04980941f, 0.05470918f, 0.00817031f, -0.30491766f, -0.65497303f, 0.32199499f, 0.27710220f, 
    0.12680525f, -0.10883353f, -0.21560585f, 0.21173477f, 0.01908451f, 0.01414218f, -0.09772521f, -0.05564196f, 
    -0.42336953f, -0.50300407f, 0.10533792f, -0.06060850f, 0.06280492f, -0.01848980f, 0.01740374f, 0.02299310f, 
    0.03572109f, 0.03059052f, -0.02391071f, -0.01412941f, 0.19811186f, -0.00755366f, 0.11227275f, -0.00075419f, 
    -0.02007526f, -0.00775302f, -0.11059391f, -0.01171335f, -0.00504171f, 0.07709653f, -0.00385551f, -0.13230021f, 
    -0.07699218f, -0.15814205f, -0.13294344f, -0.13912752f, -0.09272633f, 0.05779118f, 0.00605174f, 0.00899683f, 
    0.13709146f, 0.19273674f, 0.28775969f, 0.20211422f, -0.15257022f, 0.07707006f, 0.13707475f, -0.18521331f, 
    -0.09165028f, -0.01198849f, -0.10800873f, -0.12957560f, -0.22448161f, -0.07144647f, -0.14496909f, -0.11706188f, 
    -0.44761714f, 0.24511540f, -0.02439020f, 0.00106935f, 0.11849688f, 0.08229984f, -0.14773166f, 0.06077299f, 
    -0.04920638f, 0.20522849f, 0.10272299f, 0.28172535f, 0.34907356f, -0.02549196f, -0.12753083f, -0.19782361f, 
    0.19769773f, -0.04920448f, 0.14625573f, -0.04767043f, 0.09684792f, 0.12431083f, -0.04719621f, 0.27327043f, 
    -0.59598869f, -0.01805149f, -0.02797825f, 0.08487738f, 0.07435592f, 0.04984253f, 0.09685948f, 0.08991464f, 
    -0.12782186f, -0.34129211f, 0.01348721f, -0.04521601f, 0.73719329f, -0.09085058f, -0.01737943f, -0.42737851f, 
    0.17418826f, -0.14781535f, 0.14192307f, -0.34655613f, -0.00183090f, 0.00231401f, -0.00206859f, 0.04202693f, 
    0.12432258f, 0.06458177f, 0.12243699f, -0.01364401f, 0.05633730f, -0.01975995f, 0.04271416f, -0.01575679f, 
    0.05715831f, 0.01547085f, 0.11068031f, -0.02563480f, 0.06151493f, -0.00548715f, 0.02306156f, -0.13637519f, 
    -0.02936627f, -0.07856824f, 0.03210488f, -0.03778408f, 0.00196219f, 0.04182690f, 0.20507859f, 0.06209451f, 
    0.37920216f, -0.10283473f, -0.11251438f, -0.13555865f, 0.21867283f, -0.01069509f, 0.19713019f, 0.15282759f, 
    0.11829136f, 0.21700241f, 0.15537174f, 0.09645346f, -0.86507386f, 0.14053211f, 0.14409685f, 0.21014044f, 
    0.11637349f, 0.03241257f, 0.03634301f, 0.00672569f, -0.11477985f, -0.01835492f, -0.19976352f, 0.05981004f, 
    -0.49082431f, 0.10556588f, 0.21752787f, 0.28888032f, 0.05760960f, 0.02890857f, -0.15329917f, -0.06819460f, 
    0.03794093f, 0.04658813f, 0.11968051f, 0.08767051f, 0.10183406f, 0.07923263f, -0.19287619f, 0.11592279f, 
    -0.10322367f, -0.01119598f, 0.12861302f, 0.10398843f, 0.19929761f, -0.05491555f, 0.05377979f, 0.04841942f, 
    -0.00800640f, -0.26903781f, -0.40435293f, -0.06474353f, -0.19142701f, -0.10436285f, -0.00880396f, -0.21548037f, 
    0.05642434f, 0.03625047f, 0.01321824f, 0.00145699f, 0.08197600f, 0.12899029f, -0.04435942f, -0.10094283f, 
    -0.04714280f, -0.04936903f, -0.05022258f, -0.07127737f, 0.07176252f, 0.06039665f, 0.05463703f, 0.14367679f, 
    -0.15076616f, -0.18826658f, -0.41994089f, 0.12760705f, 0.15017635f, -0.13982169f, 0.18693234f, 0.02264845f, 
    0.01326636f, -0.01131293f, -0.06785368f, -0.02056740f, 0.25879127f, 0.08881012f, -0.07801754f, -0.21780327f, 
    -0.10915866f, -0.17232870f, 0.06264995f, -0.25686207f, 0.20593344f, 0.08394112f, 0.06708678f, 0.05321845f, 
    0.13621731f, -0.70090783f, 0.12660207f, -0.04244242f, 0.06578551f, 0.13561863f, 0.14250413f, 0.09309097f, 
    -0.00612404f, -0.10158147f, 0.02704117f, -0.18389869f, -0.14714599f, 0.14520514f, 0.08520909f, -0.07429281f, 
    0.01591689f, -0.16295402f, 0.10453370f, -0.10572564f, 0.08518766f, -0.14586616f, -0.00813496f, -0.03406300f, 
    -0.62582600f, -0.63944376f, -0.84323412f, -0.20171703f, 0.15914004f, 0.16478826f, 0.15231133f, 0.03100963f, 
    -0.12536924f, -0.00708424f, -0.07976614f, -0.01505008f, 0.39237621f, 0.50730509f, 0.15397465f, -0.52168214f, 
    -0.15384209f, -0.13726145f, -0.01491143f, -0.02120604f, -0.00529294f, -0.00380638f, -0.04477723f, 0.09869764f, 
    0.16145720f, -0.10727081f, -0.07623240f, -0.02816985f, 0.14886853f, -0.02919415f, 0.02472000f, 0.10270453f, 
    0.18244034f, -0.03932235f, 0.15173206f, 0.13355921f, 0.01907440f, 0.15725037f, -0.14491208f, -0.21623681f, 
    -0.11851703f, 0.02449007f, -0.05497832f, -0.43782476f, -0.05670723f, -0.03137710f, -0.09665768f, -0.02583895f, 
    -0.30721533f, 0.31003284f, -0.06020692f, 0.00739323f, -0.15719526f, -0.05069540f, -0.14938384f, -0.01125723f, 
    -0.17835043f, 0.02652869f, -0.01730744f, 0.05258717f, -0.61077166f, -0.04496240f, 0.19801573f, 0.32617155f, 
    -0.25370443f, -0.01364435f, -0.13839327f, -0.01763081f, -0.05232302f, 0.04023306f, 0.13084903f, 0.09173422f, 
    -0.23613222f, -0.50631839f, 0.05233957f, 0.33892897f, -0.02726069f, -0.04769198f, -0.00985241f, 0.10930564f, 
    0.11841918f, 0.07511887f, -0.27772152f, -0.49284708f, 0.12024438f, -0.46576905f, -0.35653815f, 0.28082398f, 
    0.03990363f, 0.07534707f, -0.17147167f, -0.04004275f, -0.08376309f, -0.01745671f, -0.05401891f, 0.03676607f, 
    -0.91822177f, 0.09356468f, 0.30797583f, 0.19631954f, 0.08314629f, -0.10989396f, -0.20279658f, -0.13424359f, 
    -0.10949758f, -0.12446532f, -0.10711377f, -0.08929253f, 0.10074027f, -0.24441601f, -0.04737076f, 0.25069204f, 
    0.03252838f, 0.00707158f, 0.02009248f, -0.10554298f, -0.01061689f, -0.18336943f, -0.08815335f, -0.16850096f, 
    -0.13208467f, -0.98577273f, 0.41869017f, 0.22225228f, -0.10217070f, 0.09702105f, -0.01945398f, 0.14514300f, 
    -0.01651750f, 0.10028524f, 0.07056776f, 0.11568383f, 0.13309760f, 0.01716149f, -0.35103625f, 0.02202392f, 
    -0.10057204f, -0.07753687f, -0.13762984f, 0.23160735f, 0.02649269f, 0.16425979f, 0.14754902f, 0.10113671f, 
    -0.48800775f, -0.57452703f, -0.32622641f, -0.15877125f, 0.08766495f, 0.01053713f, 0.07348897f, -0.11127461f, 
    -0.02030821f, 0.02746863f, -0.05591450f, 0.14536123f, -0.00504439f, -0.06244779f, 0.11166296f, 0.04022371f, 
    -0.17766240f, -0.08132859f, 0.06427426f, -0.00793458f, -0.14346665f, -0.11016051f, -0.03111344f, 0.20498383f, 
    0.22891790f, 0.23089261f, 0.24413401f, 0.16311121f, 0.01370338f, 0.06990993f, -0.14819109f, -0.12680116f, 
    -0.10110668f, -0.08705027f, -0.14535524f, -0.24854779f, -0.07600845f, -0.29562593f, -0.07502282f, 0.00583877f, 
    -0.06913999f, 0.29067045f, 0.06228921f, -0.04199539f, 0.20688340f, 0.07372209f, 0.04686782f, 0.00527887f, 
    -0.03563827f, 0.36254025f, -0.39126334f, -0.01733770f, 0.02669715f, 0.03126997f, 0.09154692f, -0.18955235f, 
    0.31113672f, -0.08594030f, -0.02651471f, 0.01171338f, 0.24064429f, -0.37646848f, 0.26814148f, -0.13392985f, 
    0.02411140f, -0.54273480f, -0.10291780f, -0.02811437f, -0.17884810f, 0.05655079f, -0.25305846f, 0.05045352f, 
    -0.31259349f, 0.40107238f, 0.02099861f, -0.25377479f, 0.22384621f, -0.47388405f, 0.03317164f, -0.01164246f, 
    0.05623377f, 0.17694132f, 0.04520119f, -0.02778099f, -0.11999253f, -0.34467995f, -0.15633035f, 0.28604504f, 
    -0.11892454f, 0.13120760f, 0.13536507f, -0.12605101f, 0.04744745f, 0.00011778f, -0.13038000f, 0.04206982f, 
    -0.19572888f, -0.09527793f, -0.28574064f, -0.05929206f, 0.07689969f, 0.19560932f, 0.05343122f, -0.08939082f, 
    0.21925242f, -0.13390164f, -0.06634313f, -0.04343249f, 0.38320747f, -0.22849093f, 0.00152304f, -0.01035532f, 
    0.05932702f, 0.12098291f, 0.12699728f, 0.01064663f, 0.00181094f, -0.09711564f, -0.12946393f, -0.07812034f, 
    -0.58420026f, -0.48406735f, 0.06662165f, 0.24829940f, -0.02298692f, 0.10110362f, -0.04185023f, 0.06119745f, 
    0.08399259f, 0.11998832f, -0.07907680f, -0.17028116f, 0.13731337f, 0.45319355f, 0.80669385f, -1.03747690f, 
    0.00748430f, -0.34881473f, 0.06114797f, -0.01189476f, -0.15199243f, 0.10028831f, 0.20964903f, -0.10184560f, 
    -0.49258262f, -0.05342997f, -0.15206131f, -0.05597851f, 0.13360596f, -0.15484965f, 0.07852759f, 0.08342808f, 
    -0.04634833f, -0.09326746f, -0.05428764f, -0.17592409f, 0.01512947f, -0.72045475f, -0.09646197f, -0.26055744f, 
    0.12175590f, 0.02985104f, -0.10143404f, 0.48014444f, 0.17343418f, -0.00177607f, 0.02014511f, 0.14855938f, 
    -0.46368524f, 0.08770689f, 0.26471958f, -0.39796215f, -0.17230061f, -0.10301781f, 0.05187347f, -0.04556064f, 
    0.11316592f, 0.03607913f, 0.07296073f, -0.06570085f, -0.37649277f, 0.01860744f, -0.11212652f, 0.52601540f, 
    0.21328273f, 0.05523507f, 0.02704034f, -0.10849411f, 0.05373894f, 0.01054246f, -0.22232960f, -0.20306079f, 
    0.11067667f, -0.13532220f, 0.26449290f, -0.30137119f, -0.00187173f, -0.11748768f, -0.05594349f, -0.21776246f, 
    0.06645365f, -0.04449149f, 0.04640782f, 0.06411283f, 0.25855815f, -0.68802547f, 0.28542951f, -0.08186225f, 
    0.08263151f, 0.11315817f, -0.17585433f, 0.05301960f, -0.07999496f, -0.14794905f, -0.08081980f, -0.13196763f, 
    0.38277209f, -0.13781422f, 0.00277913f, -0.09846215f, -0.30999041f, -0.13012920f, -0.14659894f, 0.00674126f, 
    0.07349848f, 0.04593543f, 0.09941606f, 0.02875422f, -0.03839483f, -0.33589539f, -0.35151550f, -0.08756199f, 
    0.23680484f, 0.06082318f, 0.28637338f, 0.28421763f, -0.14448841f, -0.09721079f, -0.08178509f, -0.17244694f, 
    0.24027485f, 0.24935544f, 0.15898155f, -0.26809675f, -0.24066484f, -0.28668553f, -0.22637562f, -0.12329616f, 
    -0.02724139f, 0.05623780f, 0.00948518f, 0.10843569f, -0.39011705f, -0.40183273f, 0.34677702f, 0.15911427f, 
    0.05551705f, 0.21891776f, -0.00257403f, -0.04698216f, -0.04942719f, -0.04592298f, 0.08401798f, 0.20214170f, 
    0.24020338f, -0.08524517f, 0.11284520f, -0.06907427f, 0.30480799f, -0.07481764f, 0.14537027f, -0.14577834f, 
    -0.33671016f, -0.26620746f, -0.21929859f, 0.04111039f, 0.19718511f, -0.54974294f, -0.06237877f, -0.14289382f, 
    -0.07467254f, -0.03204174f, 0.04422399f, 0.26694936f, 0.07524518f, 0.15180805f, 0.05673788f, -0.00771719f, 
    -0.26459613f, 0.04064611f, -0.48383537f, -0.04423074f, 0.07683112f, 0.11307712f, 0.20275992f, -0.02131526f, 
    0.11194266f, 0.01778101f, 0.10533653f, 0.02393835f, -0.39385802f, -0.01155750f, -0.07967495f, -0.45825478f, 
    0.05498761f, 0.02722478f, 0.27307478f, 0.00258612f, 0.02601750f, -0.00493468f, 0.02527742f, -0.04200763f, 
    0.22651733f, -0.00290553f, -0.10506068f, 0.48193347f, 0.17039330f, 0.00599723f, 0.07855339f, -0.12243827f, 
    -0.03842377f, 0.04319228f, 0.15570383f, 0.02802245f, -0.46283185f, -0.00946211f, 0.20073515f, -0.34576774f, 
    -0.08705004f, -0.21082525f, 0.04494563f, 0.30931503f, -0.02605511f, -0.02076820f, 0.03351251f, -0.01100234f, 
    0.14068878f, -0.03304335f, -0.77935499f, 0.32360336f, 0.18235414f, 0.09147195f, 0.32908240f, 0.05860584f, 
    0.07381489f, -0.05228667f, -0.12870486f, 0.02598483f, -0.08503225f, 0.38966224f, 0.48820353f, -0.76066983f, 
    -0.22919750f, -0.10410421f, 0.03179707f, 0.01000851f, 0.09004289f, 0.17030299f, 0.17446859f, 0.03951310f, 
    0.33540398f, -0.43190819f, 0.48877621f, -0.30395129f, 0.06838828f, -0.19914681f, -0.20428436f, 0.03586098f, 
    -0.07655381f, 0.06834359f, 0.04781086f, 0.14149332f, -0.64866775f, -0.25673085f, -0.09319405f, -0.19542284f, 
    -0.10653152f, 0.16484843f, -0.51457506f, -0.01185300f, 0.01648974f, -0.00594745f, -0.06848409f, -0.05880355f, 
    -0.07121988f, 0.14953957f, -0.02853408f, -0.25173247f, -0.11871671f, -0.02294385f, 0.07545698f, 0.27324033f, 
    0.10736518f, 0.08493680f, 0.03829655f, -0.01673042f, -0.12526038f, -0.67162549f, 0.32079306f, -0.00984432f, 
    -0.02695026f, 0.25042707f, -0.06272477f, 0.10498099f, -0.08674393f, 0.07707788f, -0.07157809f, 0.14700241f, 
    -0.09661723f, 0.12467232f, -0.15656383f, -0.14897321f, -0.10400554f, -0.05099687f, -0.00694232f, -0.19864145f, 
    0.18555003f, 0.10872382f, 0.27541551f, 0.17325631f, -0.23551464f, 0.00563436f, -0.09368206f, -0.36518601f, 
    -0.07575891f, -0.03547649f, -0.09090231f, 0.01170515f, -0.26332140f, 0.00978203f, 0.08454000f, -0.20859577f, 
    0.05688280f, 0.15789028f, -0.12672953f, -0.25965378f, -0.30825692f, -0.08391684f, 0.24534754f, -0.09416040f, 
    -0.16047186f, 0.02833239f, 0.05804310f, 0.06963088f, -0.47021011f, 0.63513851f, 0.33680072f, 0.28881568f, 
    -0.12512034f, 0.13120645f, 0.02884915f, 0.20634584f, 0.03207797f, -0.03582865f, 0.25098231f, -0.01682048f, 
    -0.08525297f, 0.00873283f, -0.36778766f, 0.42369235f, -0.03362632f, -0.14394844f, 0.16167815f, -0.09157887f, 
    -0.07584485f, -0.02314411f, -0.24722923f, 0.03826770f, -1.08299947f, 0.77443254f, -1.01950157f, 0.14715482f, 
    -0.13055363f, 0.23735495f, 0.16016571f, 0.02216970f, -0.14293420f, -0.13834330f, -0.14168119f, 0.02557989f, 
    -0.15537174f, -0.07080046f, 0.22866325f, -0.26707947f, -0.12824529f, 0.02632332f, 0.09391953f, -0.03714141f, 
    -0.09286987f, 0.13218239f, 0.16288579f, 0.07170675f, -0.27075714f, -0.12749104f, -0.22630188f, -0.10390878f, 
    -0.15375750f, -0.07559253f, 0.04278105f, -0.33575666f, 0.09166759f, 0.35053214f, 0.23114632f, -0.04407875f, 
    -0.54902995f, 0.56857169f, -0.24630457f, -0.08348433f, 0.02171165f, 0.00192519f, 0.14891431f, 0.10216064f, 
    -0.13045917f, 0.11571793f, -0.11906657f, 0.17275015f, -0.06876595f, -0.13006814f, -0.20279276f, 0.09616262f, 
    -0.12037750f, 0.03756071f, 0.01610741f, -0.08242995f, -0.15322338f, -0.23787223f, 0.05063837f, -0.07986194f, 
    0.01509402f, -0.32939827f, -0.00901101f, -0.04019086f, -0.05310073f, 0.21382299f, 0.00702007f, 0.07723743f, 
    0.09190816f, -0.00049376f, 0.18640132f, 0.18832202f, -0.41073987f, 0.31648892f, 0.46220055f, 0.10393374f, 
    0.10778010f, 0.13153207f, -0.41432607f, -0.13675624f, 0.00377243f, -0.04940994f, -0.15491591f, -0.25862822f, 
    0.05784266f, -0.65025276f, -0.05648023f, -0.06895766f, 0.08891467f, 0.03005065f, -0.01522068f, 0.02847726f, 
    0.02559053f, 0.00024957f, -0.05610190f, -0.17018974f, -0.34464082f, -0.22588152f, 0.08813518f, -0.50114161f, 
    -0.51949394f, -0.07238660f, -0.04653493f, -0.04205702f, 0.12768115f, -0.16000088f, 0.03631882f, 0.21188012f, 
    0.02110677f, -0.22288102f, 0.14511883f, -0.01464050f, -0.12723789f, -0.04782323f, -0.03131132f, 0.04768218f, 
    -0.13008609f, 0.25562233f, 0.08543051f, -0.12458462f, -0.59669286f, 0.08598284f, -0.22744069f, -0.05670119f, 
    -0.01798832f, 0.34729239f, 0.25754765f, 0.20930567f, 0.02434814f, 0.13361768f, 0.10795755f, 0.01190185f, 
    -0.01694339f, 0.32316762f, -0.21223252f, 0.37199357f, 0.13670684f, -0.02346400f, 0.03795540f, 0.13025108f, 
    -0.14140195f, -0.08775913f, -0.43701926f, -0.29344559f, -0.12138081f, 0.11462533f, 0.09930002f, -0.17602937f, 
    -0.12563708f, 0.24373506f, -0.19496650f, -0.11547472f, -0.04492572f, 0.19336444f, 0.00408733f, -0.20360619f, 
    0.10844098f, 0.15441515f, 0.32086596f, -0.33940852f, 0.06599660f, -0.19162074f, 0.09637029f, 0.03426104f, 
    -0.19867358f, 0.03836950f, 0.02688053f, 0.03615332f, -0.16962621f, -0.57102942f, 0.06295429f, 0.10240239f, 
    -0.25723460f, 0.10350562f, 0.09931207f, 0.22550851f, 0.15339422f, -0.11213048f, -0.15155415f, -0.00070816f, 
    -0.41555545f, 0.62228894f, 0.16469480f, 0.10297555f, -0.01272952f, 0.12820958f, -0.10739522f, 0.22511907f, 
    0.22277389f, 0.14359581f, 0.33254352f, 0.32715189f, -0.31266829f, -0.39035282f, -0.55260783f, 0.11370367f, 
    0.02539722f, -0.07970323f, -0.21936202f, -0.20980491f, 0.03358208f, 0.02649843f, -0.15038182f, -0.10957130f, 
    -0.00499323f, 0.15817049f, -0.14646426f, 0.00111772f, -0.17612256f, -0.30026305f, 0.13646466f, 0.10935913f, 
    -0.22821032f, 0.10026078f, 0.11653429f, 0.10979869f, 0.17404336f, -0.30569425f, 0.11805911f, 0.21097139f, 
    -0.00726124f, 0.10386873f, -0.16008566f, 0.12034640f, -0.00932713f, 0.00282285f, -0.10241404f, 0.19642924f, 
    -0.15571229f, -0.30905920f, 0.12787920f, -0.04481658f, -0.13714784f, 0.07049467f, -0.01031809f, 0.06462017f, 
    0.19354345f, -0.12125665f, -0.46911395f, -0.53108674f, -0.38137117f, -0.12627281f, 0.05008209f, 0.32418981f, 
    -0.19746493f, 0.09786381f, -0.15699354f, 0.18003066f, -0.05503860f, 0.09062490f, 0.07136365f, 0.20115873f, 
    0.02478199f, 0.05539699f, -0.07346517f, -0.06179484f, -0.11963128f, -0.32765722f, -0.01196197f, -0.02132902f, 
    0.00148628f, 0.02258177f, -0.01615106f, -0.15309142f, 0.05131292f, -0.16035835f, 0.03440976f, 0.06484482f, 
    0.03650690f, 0.01957547f, -0.13687442f, -0.10768913f, -0.10129437f, -0.18086055f, -0.28662929f, -0.22893132f, 
    -0.12199743f, 0.29699287f, -0.13593350f, 0.42940834f, 0.12020686f, -0.08090205f, -0.13732797f, 0.06303445f, 
    -0.04418319f, 0.19281432f, -0.20425087f, -0.18771109f, 0.16775566f, -0.00157200f, 0.39555636f, 0.19002219f, 
    -0.29784694f, -0.04441375f, 0.34260401f, 0.04910053f, -0.01699332f, 0.15233678f, 0.01386973f, 0.19390354f, 
    -0.08256137f, 0.04422606f, -0.17896312f, 0.24322945f, -0.08246383f, -0.14607567f, -0.00477128f, 0.16325811f, 
    0.08376108f, 0.21905912f, 0.07616733f, 0.09046753f, -0.38584566f, 0.22282924f, -0.01610525f, 0.13808551f, 
    -0.14072128f, 0.13073161f, -0.33031026f, 0.26490054f, 0.05404786f, -0.13422139f, 0.06402683f, 0.09744156f, 
    -0.65957421f, 0.02798139f, -0.29792377f, 0.02656295f, 0.23942575f, -0.14891122f, 0.11794902f, -0.17662805f, 
    -0.33270252f, -0.27248809f, -0.24597277f, -0.25283438f, 0.02280538f, 0.29669020f, -0.17942256f, 0.16161971f, 
    -0.16848199f, -0.01596026f, 0.12824151f, 0.04881026f, 0.02732114f, -0.02704772f, -0.02416060f, 0.10063612f, 
    -0.05120746f, -0.45617488f, 0.41788536f, 0.08950032f, -0.02379466f, 0.01655263f, 0.06231698f, -0.08406993f, 
    0.07211452f, 0.08381438f, 0.17806891f, 0.02742638f, -0.42153057f, -0.33405426f, 0.11520153f, 0.68270582f, 
    0.21483779f, 0.05332304f, -0.19839942f, 0.13738248f, -0.00257403f, -0.05573374f, -0.07554995f, -0.09191455f, 
    0.40676823f, -0.57081348f, 0.40678361f, -0.13423470f, 0.11477793f, 0.12459827f, -0.19246671f, 0.24365874f, 
    -0.02983742f, 0.03038879f, 0.16213700f, -0.02498922f, 0.06079528f, -0.49281034f, -0.06608754f, 0.43375203f, 
    0.30811265f, -0.36572355f, -0.07024962f, 0.03961957f, 0.06431514f, 0.04806671f, 0.20777494f, 0.08070652f, 
    0.30360118f, 0.29026973f, 0.00739307f, 0.08015957f, 0.00184723f, 0.06067504f, 0.00665886f, 0.01427459f, 
    -0.11184306f, 0.04894573f, -0.00164517f, 0.08540156f, 0.38350973f, 0.37908417f, 0.01265527f, -0.12701686f, 
    -0.02594150f, -0.01402895f, -0.03889278f, -0.06635544f, 0.08166725f, -0.08245597f, -0.05176555f, 0.00552660f, 
    -0.25474122f, 0.15046978f, -0.34659255f, 0.14740625f, 0.22298124f, -0.13438356f, 0.18358293f, -0.09014626f, 
    -0.02992917f, 0.06335746f, 0.18171781f, 0.02974380f, -0.24334224f, -0.60992444f, 0.44398004f, 0.27040797f, 
    -0.05661282f, 0.11035169f, 0.15597133f, 0.02237681f, -0.22343916f, -0.09583099f, -0.12248383f, 0.17545369f, 
    0.44887790f, 0.02279617f, 0.19542849f, -0.27770367f, -0.14132783f, 0.05860055f, -0.20186290f, 0.25017273f, 
    -0.01334325f, -0.09207406f, -0.05906100f, -0.01771461f, 0.02412474f, 0.09213734f, -0.04788533f, 0.04481932f, 
    -0.02916908f, 0.23291107f, -0.08949146f, 0.01274331f, 0.12146001f, 0.36732504f, -0.11487652f, 0.05961636f, 
    -0.02437027f, -0.12253664f, -0.17970313f, -0.02284797f, -0.21197781f, 0.07670294f, 0.11440978f, -0.09428898f, 
    -0.04331883f, 0.12784116f, 0.09024303f, 0.04195487f, -0.01249374f, -0.07672451f, 0.12302837f, -0.28219020f, 
    0.02900241f, -0.03491682f, -0.24928850f, 0.10081687f, -0.19079155f, 0.18070795f, 0.11766440f, -0.26694766f, 
    0.21644263f, 0.19532716f, 0.20881450f, -0.54300892f, 0.10486113f, 0.03705217f, 0.00195185f, -0.11935272f, 
    -0.03767310f, -0.01771797f, 0.06962728f, -0.03631585f, -0.44499439f, 0.22458100f, -0.02230683f, 0.19034448f, 
    0.24817334f, -0.24841093f, 0.09872340f, -0.14070070f, -0.12690678f, -0.03999276f, -0.14417925f, -0.16420822f, 
    -0.61331165f, 0.38398299f, 0.00700310f, 0.08906434f, -0.00561496f, -0.17322257f, 0.18323873f, 0.15180114f, 
    -0.04702285f, 0.11686752f, 0.03481326f, 0.22738896f, 0.32260728f, 0.08062430f, 0.34462327f, -0.08612460f, 
    0.10195393f, 0.14049919f, -0.03724617f, 0.07766907f, 0.15642855f, -0.04656883f, 0.01014065f, -0.10819232f, 
    -0.60884154f, 0.01372140f, -0.28153923f, -0.31357157f, 0.03195278f, -0.10165875f, 0.14814520f, -0.01797728f, 
    0.00893930f, 0.24059997f, -0.06708287f, -0.05365168f, -0.35940585f, -0.07956701f, -0.23899128f, -0.45991254f, 
    -0.11815351f, 0.16581669f, 0.03573968f, -0.07414541f, 0.07090288f, 0.01304495f, 0.05683028f, 0.01034518f, 
    -0.19637577f, -0.00355854f, -0.08476022f, 0.04355672f, 0.14869981f, 0.07207637f, -0.15524857f, 0.11530404f, 
    -0.15812285f, -0.01139358f, -0.18968625f, -0.17948225f, -0.18051773f, -0.19298276f, 0.03173118f, 0.27392280f, 
    -0.22385707f, -0.26629195f, 0.14265439f, -0.06961519f, 0.00539700f, 0.04055310f, -0.07925937f, 0.03041930f, 
    0.38094270f, 0.00548315f, 0.52152801f, 0.02316854f, -0.03490221f, 0.14510818f, -0.19229475f, 0.05639123f, 
    -0.26244718f, 0.01807152f, 0.04645961f, -0.04291343f, 0.03476052f, -0.03231173f, 0.58883941f, -0.24942359f, 
    -0.06680086f, 0.01543327f, -0.02299844f, 0.06055021f, -0.04321809f, 0.12502293f, 0.08073182f, 0.05783364f, 
    0.22466704f, -0.17526126f, 0.34497580f, -0.62497467f, 0.03095875f, 0.01261772f, 0.02088028f, -0.04920232f, 
    -0.07398275f, 0.04796072f, 0.13564508f, 0.22900456f, 0.10416440f, 0.10580526f, 0.09339038f, -0.04212905f, 
    -0.04632368f, 0.11214259f, -0.21177030f, -0.07091948f, -0.07464857f, -0.04465139f, -0.18041246f, -0.22991681f, 
    0.76869017f, -0.03269776f, 0.33223829f, -0.09145757f, -0.09600365f, 0.15909193f, -0.22795172f, 0.07889005f, 
    -0.10635974f, 0.14082246f, -0.02878974f, -0.02678647f, -0.11481407f, -0.26684776f, -0.14671123f, -0.27631119f, 
    -0.12350869f, -0.28312239f, 0.12381846f, -0.03481133f, 0.10480212f, 0.17437117f, 0.04858336f, -0.00160488f, 
    -0.84955585f, 0.10705488f, 0.05165784f, 0.13293742f, -0.15346389f, -0.05074401f, 0.01379455f, 0.29286006f, 
    -0.34274384f, -0.00909593f, -0.03083730f, 0.00105206f, -0.19672917f, -0.07129859f, -0.41722116f, 0.49758554f, 
    -0.02565833f, 0.08742877f, 0.05402498f, -0.28486177f, -0.06126909f, -0.09224977f, -0.07111938f, -0.15068442f, 
    -0.44912785f, 0.05602269f, -0.04552412f, -0.05587063f, -0.64983678f, -0.16585818f, -0.11187668f, -0.32195964f, 
    0.02422683f, 0.05412291f, -0.02483737f, -0.09298903f, -0.40068510f, 0.22955821f, -0.24213390f, -0.15220951f, 
    0.03786801f, -0.02665146f, 0.13648257f, -0.00338940f, -0.03215814f, 0.03549623f, 0.11093412f, 0.05254847f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19755845f, 0.09236550f, 0.04878151f, -0.06834007f, -0.11286901f, 0.10632074f, 0.08224304f, -0.17291832f, 
    0.12128717f, 0.08550412f, 0.05302909f, -0.02203777f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
