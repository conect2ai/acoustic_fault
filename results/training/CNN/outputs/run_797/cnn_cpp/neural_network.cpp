#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.92651898f, -1.05935526f, -0.65818012f, 1.05815923f, 0.66038769f, 0.23324175f, -0.52876890f, -0.57899851f, 
    -0.55900967f, 0.88092726f, 0.94597316f, 0.95628893f, 0.08205223f, 0.38132703f, 0.71715838f, -0.27728659f, 
    -0.58670461f, -0.62782133f, 0.55428386f, 1.21489775f, 0.30206072f, 0.18610379f, -0.94361359f, -0.68600428f, 
    0.80336452f, -0.58937556f, 0.64874440f, -1.11853004f, 0.33962575f, 1.08474481f, 0.02786433f, -0.53068691f, 
    0.49213150f, 0.56425774f, -0.44503447f, 0.90242130f, 0.76173705f, 0.71310961f, 0.49125862f, -0.17774385f, 
    -1.11301827f, 0.90878642f, 0.49054629f, 0.35802507f, -0.05534668f, -0.80434042f, -1.25194323f, 0.37974387f, 
    0.04604846f, -0.51797748f, 0.53165644f, 0.27395752f, 0.13616322f, 0.79795438f, 1.05700016f, -1.25449526f, 
    -0.61876357f, -0.57500273f, -0.95261985f, -0.09175210f, -0.22353749f, 0.38477764f, 0.34555566f, -0.04824415f, 
    -1.35168827f, -0.54127908f, -1.22630215f, -0.24330868f, 1.03506768f, -0.10837217f, -0.12394540f, -0.27011830f, 
    0.43555674f, -0.30131769f, 0.12839402f, 0.33599979f, -0.15891576f, -0.82782125f, 0.04782038f, 0.95250773f, 
    0.83751565f, -1.13906693f, -0.68399143f, -0.21928538f, 0.47972724f, 0.06806584f, 1.02203619f, -0.07418158f, 
    -0.58215284f, -0.51758915f, -0.79013985f, -0.34479806f, -0.64718503f, -0.35095549f, 1.08600426f, -0.54978514f, 
    -0.27921727f, -0.00846059f, -0.93130440f, -1.45528996f, -1.09718394f, -1.04446626f, -0.17014836f, -0.61447757f, 
    0.40819103f, 0.23836415f, 0.08101795f, 0.10076955f, 1.02647996f, 0.68778312f, 0.76806688f, 0.72641397f, 
    0.55524772f, 0.00577040f, 0.53185356f, 0.92843360f, 0.35480806f, 0.80240101f, 0.19078791f, 0.95964003f, 
    -1.28233969f, -0.16428496f, -1.16651142f, 0.24380727f, -0.55265778f, -0.03923840f, -0.95235604f, 0.27418977f, 
    0.53731191f, 0.63286322f, -0.86854672f, -1.34793031f, 0.00728082f, 0.40697107f, -0.26896900f, 0.35173765f, 
    0.02735761f, 0.61036801f, -1.15006268f, -1.12972069f, -0.35147324f, -0.25554895f, 0.41044068f, 0.66196567f, 
    -0.91124171f, -1.09188831f, -0.57489759f, 1.09025908f, 0.81254631f, 0.00305626f, 0.18972717f, 0.24037425f, 
    0.00456695f, 0.98108667f, 0.90003765f, -1.16858077f, 1.13151813f, 0.11404711f, -0.68774414f, 0.37972730f, 
    0.13007277f, -0.17285599f, 0.31750104f, -1.24794614f, 1.09318447f, 0.82953364f, -1.01188493f, 0.45010862f, 
    -0.21019043f, -0.41510633f, -0.43369958f, 1.51606905f, 1.19438946f, -0.56035841f, -0.91021466f, 0.80658489f, 
    -0.16496573f, 0.04479253f, 0.27406672f, 0.44727039f, 1.19816089f, -0.36888763f, -1.09682274f, -0.78411782f, 
    0.36188993f, -0.38825503f, 0.22375382f, 0.13342956f, 0.55370700f, -1.97533238f, 0.96334326f, 0.05058357f, 
    -0.28803882f, 0.61651421f, 0.56432670f, -0.45560926f, 0.01092541f, 0.33446944f, -0.22543968f, 1.26525593f, 
    0.84707636f, -1.02801013f, 0.28645030f, -0.68322438f, -0.40342420f, 0.31387174f, -0.61101836f, 0.37540627f, 
    -1.04495442f, -0.37291676f, -0.81708741f, 1.10463488f, -0.69032764f, 0.24821003f, 0.46163371f, -0.27874619f, 
    0.24319075f, 0.05162386f, -1.19697726f, 0.74493331f, -0.85892725f, 0.21373567f, -0.56580091f, -0.53802544f, 
    0.75569838f, -0.67202258f, 0.53732413f, 0.61487377f, 1.17879736f, 1.33495760f, 0.71908605f, -0.31616390f, 
    -0.03596865f, -0.24784502f, 0.05473507f, -0.01591757f, -0.29730973f, 1.23314261f, 0.92348772f, 0.49826670f, 
    -0.08442400f, 0.94157469f, 0.24752367f, 1.21921837f, 0.57306004f, 0.88763428f, 0.45744035f, -0.80973005f, 
    0.53643233f, -0.31839311f, 0.59465009f, -0.39604923f, -1.28729868f, -0.69177663f, -1.01455879f, -0.30965039f, 
    1.23523450f, 0.58687061f, 0.52000469f, -0.58445263f, 0.28108907f, -0.70104778f, -0.68558282f, -0.62604910f, 
    0.63285905f, -0.32048404f, -0.79179603f, 0.18085864f, -0.30769902f, -0.47038358f, -0.86156744f, -0.93891174f, 
    -1.00795770f, -0.77562386f, -1.25392163f, -0.65888667f, 0.10048645f, 0.00828229f, 0.07739468f, 0.01267984f, 
    0.46694151f, 1.02190638f, 0.54610556f, 0.50342435f, 0.62350094f, -0.09644540f, -0.80247259f, 0.12611288f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07558980f, 0.33437976f, -0.03066178f, -0.47649390f, 0.48810107f, 0.14770511f, 0.14134647f, -0.17469291f, 
    0.41831544f, 0.21416399f, -0.09668462f, 0.08522826f, 0.17590819f, 0.04635699f, -0.30370483f, 0.32509029f, 
    0.31357494f, 0.12239323f, -0.16861488f, 0.11530579f, 0.23760982f, 0.27005920f, 0.11921696f, -0.05717034f, 
    -0.07627933f, -0.27258191f, -0.05615046f, 0.52209955f, 0.17660666f, 0.07275361f, 0.19850586f, 0.46776506f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03102030f, -0.13577858f, -0.00630165f, 0.06909914f, -0.03317543f, 0.01714336f, -0.08891999f, -0.17450289f, 
    -0.24301706f, -0.29237673f, 0.04034051f, 0.19693972f, 0.15155226f, -0.08715938f, 0.11040190f, -0.00142986f, 
    -0.08774957f, 0.02396319f, 0.24618690f, -0.24202004f, -0.01678468f, 0.13997857f, 0.18663287f, -0.12645452f, 
    -0.15086786f, -0.05330656f, 0.18703231f, 0.10927293f, -0.10623423f, 0.12847309f, -0.03593398f, 0.18494155f, 
    -0.08793648f, 0.01124352f, 0.01141872f, -0.04710391f, -0.16774771f, 0.07380894f, 0.08330932f, 0.23499179f, 
    0.13008711f, 0.04733228f, -0.01710896f, 0.07670964f, 0.18813027f, 0.17925803f, 0.21418566f, -0.04598838f, 
    0.07272568f, -0.07202373f, 0.04522072f, -0.07626417f, 0.17275685f, -0.14496204f, 0.41162643f, -0.05118703f, 
    0.08619680f, 0.03355505f, -0.02371559f, 0.30765513f, 0.19015604f, 0.12532434f, 0.09380357f, -0.25679594f, 
    -0.31701210f, -0.20551988f, -0.10986546f, -0.05886644f, -0.05554082f, 0.02763225f, 0.05208093f, 0.14179896f, 
    0.27868095f, -0.04478684f, -0.03862053f, 0.02109608f, -0.19211991f, -0.06833494f, -0.10447998f, 0.12965539f, 
    -0.06721432f, 0.11547387f, -0.25218672f, -0.12118563f, -0.43635386f, 0.18236844f, -0.07818550f, -0.08330399f, 
    -0.00990859f, 0.11355310f, -0.30218422f, -0.35756734f, -0.13573603f, -0.07338236f, -0.24405761f, 0.04864694f, 
    -0.03349154f, -0.02697312f, 0.10476501f, 0.17105284f, 0.14011295f, -0.16375281f, -0.30057836f, -0.00139133f, 
    -0.26571187f, 0.06663137f, -0.10820080f, 0.04968240f, -0.72704399f, -0.43670136f, -0.12730530f, -0.19406591f, 
    0.04356268f, 0.10497323f, 0.08337371f, -0.09925734f, 0.14810453f, 0.58174932f, 0.31566024f, 0.35396278f, 
    0.08428930f, -0.07242690f, 0.12429900f, 0.10507198f, -0.11277755f, 0.05054187f, 0.24782163f, 0.02232270f, 
    -0.03483667f, -0.13255247f, -0.40866581f, -0.14702365f, -0.11243127f, 0.00077581f, 0.07372814f, 0.19477727f, 
    0.33363253f, 0.22586474f, 0.11028574f, -0.00155977f, -0.06746965f, 0.15201208f, 0.02664859f, 0.01876924f, 
    0.36846033f, 0.00706745f, -0.07972091f, -0.16197975f, -0.05627445f, -0.35043040f, 0.01943737f, 0.12079441f, 
    -0.04002884f, 0.09897314f, -0.32183591f, 0.04329311f, -0.07103699f, 0.14813054f, 0.03670522f, -0.11378968f, 
    -0.08333421f, -0.22736132f, -0.39737165f, 0.04274986f, 0.29046956f, -0.17865971f, 0.14686625f, 0.00437500f, 
    0.07417148f, -0.14857279f, 0.02951983f, -0.33235502f, 0.00585768f, 0.24051800f, 0.17207789f, 0.00694481f, 
    -0.21096921f, 0.05636885f, -0.03228657f, 0.01442180f, -0.00994884f, -0.02741274f, 0.00864700f, 0.16848001f, 
    0.07317105f, -0.01739053f, 0.14520530f, 0.11052544f, 0.06528959f, 0.19633569f, -0.01913551f, -0.11927024f, 
    -0.10414482f, 0.06221159f, 0.11624805f, 0.13921399f, -0.03211074f, -0.06806704f, 0.64075661f, 0.23134924f, 
    0.40056294f, 0.16049980f, 0.05343065f, 0.08840761f, -0.10007167f, -0.18040651f, -0.07474211f, 0.23645750f, 
    -0.14500195f, 0.07920330f, 0.00972147f, 0.13174050f, -0.21854231f, -0.02744459f, 0.07742570f, 0.17575623f, 
    -0.00515956f, -0.01555600f, 0.26720363f, 0.19651671f, -0.01165138f, -0.11597652f, 0.03632469f, 0.14674434f, 
    0.10029220f, -0.09093309f, -0.15720391f, -0.14336024f, 0.10344899f, 0.01425087f, 0.15097150f, 0.06060381f, 
    -0.03560805f, -0.22848114f, 0.09042684f, -0.10986698f, -0.12943240f, 0.02479565f, -0.07609974f, 0.19126318f, 
    -0.07914659f, 0.07459012f, -0.12090373f, -0.32245466f, -0.04354091f, 0.07422522f, 0.18667774f, 0.07570451f, 
    0.12196767f, -0.13559426f, 0.00528009f, 0.09080690f, 0.12841567f, 0.04206607f, 0.03718359f, -0.19152007f, 
    -0.05548952f, -0.28041336f, -0.01450444f, 0.25866741f, -0.04191905f, 0.06145901f, -0.16016032f, -0.17742659f, 
    -0.18980701f, -0.11140913f, 0.06913258f, -0.14231545f, 0.00560379f, 0.01651831f, 0.18153363f, 0.29771096f, 
    0.08875468f, 0.11062372f, -0.17321807f, 0.15370958f, -0.05643766f, -0.14195348f, 0.12172610f, -0.11051949f, 
    -0.09464452f, 0.05876233f, 0.11220583f, -0.00116641f, 0.19931249f, -0.01790839f, -0.12143752f, -0.13090754f, 
    0.01871799f, -0.03999470f, -0.05731924f, -0.05185557f, -0.00045016f, 0.03410656f, -0.01226367f, 0.03192662f, 
    0.03616532f, -0.01418336f, 0.05081179f, -0.05307534f, -0.01370301f, -0.04359435f, -0.03685473f, 0.04402638f, 
    0.01094384f, 0.04536664f, -0.05715312f, -0.04335267f, 0.02842185f, -0.02784346f, 0.03379339f, -0.00130193f, 
    -0.00071542f, 0.04522017f, -0.00149186f, 0.04936195f, -0.04160653f, -0.01529408f, -0.01700613f, 0.01923150f, 
    -0.04505755f, -0.01774943f, 0.03815101f, -0.04173103f, 0.00723892f, -0.05411846f, -0.00275790f, 0.01345160f, 
    -0.00540392f, 0.04903318f, -0.05330857f, -0.02257924f, 0.00538199f, -0.04203505f, 0.04036717f, -0.01289017f, 
    -0.03197408f, -0.02607816f, 0.02355113f, 0.04351436f, 0.04545969f, -0.01925904f, -0.07152283f, -0.02891413f, 
    0.03954039f, -0.04160787f, -0.00672616f, -0.07080034f, -0.01962649f, -0.01879497f, -0.02640455f, -0.02902182f, 
    0.03813639f, -0.02745411f, -0.06597715f, 0.04268301f, 0.05344530f, -0.01451539f, -0.06155927f, -0.01362939f, 
    -0.06692921f, -0.03429778f, 0.03994370f, -0.05525509f, -0.05539142f, -0.06282448f, -0.02356902f, 0.03888407f, 
    -0.06850200f, -0.00413372f, -0.03680342f, 0.01646432f, -0.02656257f, -0.02316458f, -0.02350723f, 0.02609975f, 
    -0.05339031f, 0.02812899f, 0.05094661f, -0.04799115f, -0.03849381f, -0.05087447f, 0.02141498f, 0.01284917f, 
    0.04784184f, 0.00940907f, 0.02962330f, -0.04798064f, -0.01909983f, -0.04241770f, 0.00955077f, -0.03807814f, 
    0.05310928f, -0.05539418f, -0.05694083f, -0.04519980f, -0.04754638f, 0.01536603f, -0.00005833f, -0.01207432f, 
    0.01064476f, 0.02268033f, 0.04389162f, 0.01052678f, -0.07145710f, 0.01850923f, -0.00257795f, -0.01381286f, 
    -0.04731960f, -0.04323957f, 0.00453777f, -0.00369415f, -0.04297173f, 0.01179722f, -0.03425329f, 0.00555577f, 
    -0.06542972f, -0.00114489f, -0.06635001f, 0.03439631f, -0.00196057f, -0.04584490f, -0.01182418f, -0.00115241f, 
    -0.00756239f, -0.04969475f, -0.01693196f, 0.04645516f, 0.02165603f, -0.03473672f, -0.04450648f, -0.00021235f, 
    -0.05507710f, -0.05722136f, -0.04360596f, -0.04383182f, -0.03540552f, -0.00748030f, 0.04432892f, 0.01610604f, 
    -0.04668181f, 0.03856473f, -0.04249307f, 0.04628517f, -0.02687439f, -0.00039399f, -0.05422087f, -0.05262376f, 
    0.00937752f, 0.04869641f, 0.03888370f, 0.01542427f, -0.06766324f, 0.04021879f, 0.01176534f, 0.00286291f, 
    0.01195743f, 0.00101438f, -0.04258827f, -0.02185602f, 0.02497716f, -0.03921692f, 0.02626678f, -0.01432707f, 
    0.04553140f, -0.00908543f, 0.04055421f, -0.04028132f, 0.02053238f, -0.01075136f, 0.01662001f, 0.04231421f, 
    -0.03613495f, -0.02916044f, 0.02613255f, -0.04294670f, 0.02476035f, -0.03874965f, 0.01048621f, 0.04069462f, 
    0.00676935f, -0.01634961f, 0.04617025f, 0.02588257f, -0.01389970f, 0.04626158f, 0.00929040f, 0.01992662f, 
    0.04970047f, 0.02495462f, -0.01440942f, 0.04491820f, -0.00279492f, -0.04817028f, -0.02523366f, -0.04557751f, 
    0.00896042f, -0.01183712f, 0.02283041f, 0.04815569f, 0.03966148f, 0.03442345f, -0.01486197f, 0.02141126f, 
    0.00307239f, -0.02799634f, -0.00782908f, -0.01914371f, 0.00513871f, -0.02892720f, 0.01268375f, -0.04053752f, 
    0.00525573f, -0.03065133f, 0.03983002f, -0.05749700f, 0.03965046f, -0.02012198f, -0.02186420f, -0.01721550f, 
    -0.03869781f, -0.02416919f, 0.02053261f, 0.00860480f, 0.03070324f, 0.01280572f, 0.05220064f, 0.00039410f, 
    0.02559491f, -0.00233024f, -0.01384716f, -0.05521883f, -0.00658208f, 0.04073383f, 0.02740521f, -0.03201341f, 
    0.03571381f, -0.01555596f, 0.02997966f, 0.01601693f, 0.02876684f, 0.03963426f, 0.04410659f, 0.03494719f, 
    -0.02451102f, -0.03971309f, -0.06260916f, -0.01714404f, 0.02991770f, 0.00113837f, -0.00640108f, 0.03291376f, 
    -0.03246169f, 0.02455495f, 0.02783578f, -0.02311246f, 0.00194204f, 0.00496676f, 0.01239855f, -0.00749622f, 
    0.03691658f, 0.02050774f, 0.00901366f, -0.05650641f, 0.04253011f, 0.03433081f, -0.03240773f, -0.03054000f, 
    -0.03749575f, -0.02988846f, 0.00568212f, 0.03550248f, 0.02553314f, 0.02352058f, -0.05291234f, -0.00763639f, 
    0.03211033f, -0.03781691f, -0.05333002f, 0.02773855f, -0.02890502f, 0.01303133f, -0.02539934f, -0.02490980f, 
    -0.01711001f, 0.00973157f, -0.02335443f, -0.04622647f, -0.04112794f, 0.02549125f, 0.03989524f, -0.01899803f, 
    0.04553183f, -0.04260764f, -0.03458227f, -0.02467861f, 0.03880743f, -0.04029632f, 0.02077413f, -0.02978085f, 
    0.00322598f, 0.02977785f, 0.04188316f, 0.02500182f, 0.03425455f, -0.04597317f, -0.06382209f, 0.00525025f, 
    -0.01104736f, -0.03578199f, 0.03045883f, -0.00445152f, 0.00026250f, -0.00544973f, -0.04465647f, -0.03891614f, 
    0.03161029f, -0.02321885f, 0.00676180f, -0.05753187f, -0.04676825f, 0.04488487f, 0.03788086f, -0.02914386f, 
    -0.04955313f, -0.06161035f, -0.01414659f, 0.04224741f, -0.02901994f, -0.00483434f, -0.04867532f, 0.04057811f, 
    -0.05467233f, 0.05244340f, -0.03300745f, -0.03715888f, -0.03090539f, -0.01452135f, -0.03346562f, -0.02711811f, 
    -0.03647901f, -0.02343679f, 0.05101732f, -0.04155910f, -0.05021062f, -0.00632630f, -0.04532113f, 0.04914583f, 
    0.03276706f, 0.03032210f, -0.00843059f, 0.03669108f, 0.02098124f, -0.00504331f, -0.04655109f, -0.06356501f, 
    0.00174057f, -0.03444784f, -0.05320482f, -0.00574815f, 0.01700565f, -0.00207690f, -0.00687656f, -0.00820216f, 
    -0.00858549f, -0.02658410f, 0.04866553f, -0.02845550f, 0.03942197f, 0.03325812f, -0.05171944f, 0.01059134f, 
    0.02353646f, -0.03986370f, 0.02513202f, 0.02565368f, -0.03342298f, 0.02187328f, 0.04593292f, -0.03778271f, 
    -0.04257722f, -0.03548050f, -0.05496335f, -0.03043025f, -0.04325464f, 0.00663762f, -0.01903901f, 0.03896682f, 
    -0.05458890f, 0.01699775f, -0.00898885f, 0.00076561f, -0.05320821f, -0.00588840f, -0.03753600f, 0.00340225f, 
    -0.00287719f, 0.05661133f, 0.05055868f, -0.01729961f, -0.05491078f, 0.00775594f, -0.03870175f, 0.01440708f, 
    -0.01676908f, -0.04717563f, 0.03186251f, -0.01805952f, -0.02421291f, -0.01670146f, 0.03042987f, 0.01987605f, 
    -0.02695890f, 0.03479860f, -0.05349266f, 0.05195272f, -0.03824202f, -0.01647699f, -0.05773949f, -0.00600198f, 
    -0.01442748f, -0.03591572f, 0.03918989f, 0.03705524f, -0.02834741f, 0.01875415f, -0.03795817f, 0.03170131f, 
    0.00855053f, 0.04822709f, 0.04988454f, -0.00738665f, -0.03805003f, -0.03863666f, -0.02118039f, -0.02711761f, 
    -0.06179662f, -0.00331985f, 0.03084930f, -0.02515547f, 0.03320604f, 0.03949844f, -0.04924391f, 0.02390007f, 
    0.01873975f, -0.00996458f, 0.05515287f, -0.02311666f, -0.05668863f, -0.01047858f, -0.06244255f, -0.00712457f, 
    -0.01672968f, -0.00408494f, -0.01994265f, -0.04160098f, 0.03633088f, -0.01766008f, -0.03885603f, -0.01952482f, 
    0.00221190f, 0.01749836f, 0.00501782f, -0.05483885f, -0.03339740f, 0.03249252f, -0.04450706f, 0.04575991f, 
    -0.06766294f, -0.01458579f, -0.01876104f, -0.02110385f, 0.03143288f, 0.00343732f, 0.04701515f, -0.00413805f, 
    -0.01959091f, -0.01678488f, 0.04508433f, 0.04117464f, 0.04553802f, -0.00805893f, 0.04461408f, 0.02167738f, 
    0.04256265f, -0.02651515f, -0.05550848f, 0.01347772f, 0.03872268f, 0.02539001f, 0.03098761f, -0.01979052f, 
    -0.04205777f, 0.05298955f, -0.01625296f, 0.00533921f, 0.00251760f, -0.02995699f, 0.04960229f, -0.02556448f, 
    -0.03869747f, 0.04567659f, -0.03642682f, -0.02712498f, 0.03344901f, 0.00096276f, -0.07016045f, 0.00402292f, 
    0.01315226f, -0.03288072f, -0.05943976f, -0.06328784f, 0.00130584f, -0.04912337f, -0.00979277f, -0.03756693f, 
    -0.03718239f, -0.02017478f, 0.01291566f, -0.05013276f, 0.04722277f, 0.01577346f, -0.05974865f, 0.01916298f, 
    -0.00552878f, 0.03339301f, -0.02999282f, 0.00932711f, -0.00903096f, 0.02605917f, -0.01527589f, 0.05573226f, 
    -0.03474453f, 0.05390698f, -0.05470526f, -0.01131293f, 0.01807364f, 0.01828514f, -0.03960671f, -0.02545693f, 
    -0.06003911f, 0.04002030f, -0.00465354f, 0.05289868f, -0.03935985f, 0.01728875f, 0.01101747f, 0.00734349f, 
    0.05083533f, -0.00562261f, -0.01343700f, 0.05867227f, -0.00649090f, 0.01096329f, -0.04045290f, 0.04259444f, 
    -0.01723048f, -0.04941537f, -0.02017763f, 0.01726380f, -0.02232818f, 0.04612327f, 0.05255025f, -0.04136787f, 
    0.40974498f, -0.18712209f, -0.20827787f, 0.12272458f, 0.02693041f, 0.29005188f, -0.11823372f, 0.04289643f, 
    0.06019204f, -0.03800532f, 0.28331381f, 0.28857619f, 0.17137046f, 0.06802459f, 0.13707054f, 0.18908067f, 
    -0.05985487f, 0.00127889f, 0.03610617f, 0.04597122f, 0.05846828f, -0.38262945f, 0.01408105f, -0.10859069f, 
    -0.18598762f, -0.02715477f, -0.06059222f, -0.16724557f, -0.13852169f, 0.13642506f, -0.18273301f, -0.12183060f, 
    0.02825935f, -0.07760136f, 0.16086881f, -0.32376879f, -0.28239220f, 0.02438707f, 0.13356332f, -0.03126087f, 
    0.21789689f, 0.11475711f, -0.07697085f, 0.04190846f, -0.03055719f, -0.23651235f, -0.28726909f, -0.12876719f, 
    0.46905455f, -0.01016063f, -0.03290460f, 0.05059299f, -0.02304933f, -0.11305039f, 0.18106616f, -0.29274040f, 
    -0.39947578f, -0.05795896f, -0.29908261f, -0.10020006f, -0.10779610f, -0.01182075f, 0.09033985f, 0.18811093f, 
    0.08979476f, -0.31373516f, 0.08679236f, 0.05914829f, -0.12842886f, 0.09803742f, 0.25918567f, 0.34045294f, 
    0.04966056f, 0.22269090f, -0.27526987f, -0.23529071f, -0.09762901f, -0.15467471f, -0.01977790f, -0.01738649f, 
    0.04768083f, 0.10943355f, -0.06199754f, -0.48451045f, 0.03564378f, 0.23271476f, 0.21858715f, 0.16883613f, 
    0.06897160f, 0.30491862f, -0.06596338f, 0.10703247f, -0.27244073f, 0.35254580f, 0.29785869f, -0.08056989f, 
    -0.33186626f, -0.09315723f, 0.29030931f, -0.59626764f, -0.07238532f, -0.19914033f, 0.27220801f, 0.14160612f, 
    0.15140368f, -0.00091760f, 0.05018704f, -0.09928533f, -0.13491835f, 0.15499407f, 0.05075702f, 0.05181254f, 
    0.21483169f, -0.03020628f, -0.00237243f, 0.14149421f, -0.07247271f, 0.07613485f, 0.15308313f, 0.18664081f, 
    -0.47808936f, 0.08993675f, -0.14059575f, -0.22847119f, -0.03976769f, 0.15954797f, -0.04299586f, -0.05462020f, 
    -0.21020396f, -0.06849327f, 0.26234940f, -0.11109643f, 0.20354009f, -0.02144192f, 0.29296109f, 0.04933138f, 
    0.00810686f, -0.04469332f, -0.09635181f, 0.06010491f, 0.01199603f, -0.03792455f, 0.08752346f, 0.20204078f, 
    0.07950296f, -0.20735094f, -0.10472339f, 0.33408603f, 0.17838901f, 0.00735435f, 0.09260022f, -0.05940897f, 
    -0.27485561f, 0.00641565f, 0.14315473f, 0.57741010f, -0.03536604f, -0.04613022f, -0.16352090f, -0.00632724f, 
    0.26795158f, 0.06029432f, 0.45997718f, -0.25813365f, -0.22899619f, -0.25475869f, -0.04685177f, 0.13573192f, 
    0.29208967f, -0.01559295f, 0.34480581f, -0.29438564f, 0.01573621f, 0.41737309f, -0.10888465f, -0.15992406f, 
    -0.08489863f, -0.18832484f, -0.15083900f, -0.18137567f, -0.17665708f, -0.11821326f, -0.13405354f, -0.09100209f, 
    -0.04649511f, -0.09985913f, -0.15279771f, 0.01073895f, -0.12459705f, 0.47446930f, -0.31071314f, 0.30917484f, 
    -0.28117615f, -0.11609185f, 0.23453943f, 0.07553351f, -0.10055237f, 0.08567888f, 0.10918193f, 0.34420669f, 
    0.42389345f, -0.09460916f, 0.00338673f, -0.16148414f, -0.19538648f, 0.16593520f, 0.18657391f, -0.33760643f, 
    -0.05583049f, -0.15664980f, 0.10639168f, -0.04776290f, -0.04279304f, -0.21528776f, -0.01108894f, -0.07513637f, 
    -0.00551134f, -0.34245804f, 0.04888583f, 0.17786552f, 0.12954170f, -0.06874569f, -0.01345740f, 0.07734807f, 
    0.25583893f, 0.39212418f, -0.13500582f, 0.19265944f, 0.24446180f, 0.25810894f, 0.07173765f, 0.01441383f, 
    -0.32829544f, -0.22924185f, -0.12860455f, -0.45074517f, 0.14416419f, 0.32308668f, 0.24662477f, 0.21837294f, 
    0.00289343f, 0.00889876f, -0.61920017f, 0.15631288f, 0.20502497f, 0.22883090f, 0.04213619f, 0.11019935f, 
    -0.03899373f, 0.04466310f, 0.18846238f, -0.23305559f, -0.10143769f, 0.17564732f, -0.31022969f, 0.07751001f, 
    0.21318905f, 0.27730975f, 0.04801960f, -0.08308524f, -0.03707595f, 0.06598891f, -0.00414917f, -0.00693556f, 
    0.21850762f, 0.07950644f, -0.15121876f, 0.57485974f, 0.01823769f, 0.41152203f, -0.31024474f, 0.06780948f, 
    0.12506653f, 0.31361815f, 0.17915781f, 0.11704166f, 0.01578231f, -0.05478346f, 0.04811698f, 0.01247996f, 
    0.06753961f, 0.22221240f, 0.23195374f, -0.02126911f, 0.10901584f, 0.20096970f, 0.05490405f, -0.04362877f, 
    -0.14478344f, 0.25184396f, -0.20135683f, 0.07318727f, -0.14501587f, -0.03509312f, 0.20756726f, 0.16133466f, 
    0.13894616f, -0.15300404f, -0.31057206f, 0.23420565f, -0.10705502f, -0.06680173f, 0.12833738f, 0.42851084f, 
    0.08145207f, 0.05016360f, -0.76707155f, -0.02996790f, -0.00255129f, -0.00119905f, -0.06522730f, -0.16673554f, 
    -0.26554829f, -0.01446552f, 0.21830046f, 0.28487965f, -0.52991414f, -0.10283267f, -0.04025444f, -0.07199610f, 
    0.14938588f, 0.14921562f, 0.13212766f, -0.18623142f, -0.31128463f, -0.14570528f, -0.24123682f, -0.10748027f, 
    0.05695014f, -0.25120428f, -0.06756561f, -0.01666766f, 0.01225412f, 0.20458899f, -0.42347607f, -0.03442653f, 
    -0.05694877f, -0.16230282f, 0.19987620f, -0.06723140f, 0.10589124f, -0.02692831f, 0.39304897f, 0.13967755f, 
    0.04656375f, -0.16656327f, -0.13380766f, -0.02851925f, -0.03407054f, -0.16515613f, 0.08063418f, 0.48480177f, 
    -0.12063064f, 0.24261092f, -0.20121735f, 0.06124957f, -0.12452620f, 0.13497470f, -0.02333299f, 0.15775041f, 
    -0.04222534f, -0.06609895f, -0.01859968f, -0.17191190f, -0.03774459f, -0.10445240f, -0.18484262f, -0.13449873f, 
    -0.07547609f, 0.05594134f, 0.28175557f, 0.03102048f, 0.21533737f, 0.11746012f, -0.09483485f, -0.01067284f, 
    -0.06879490f, 0.10408287f, -0.10656459f, 0.44146612f, 0.54245716f, 0.17710555f, -0.04788449f, 0.25666606f, 
    -0.07398553f, -0.16627523f, 0.11136977f, -0.04228281f, -0.04638939f, 0.35327575f, 0.02678546f, 0.34565341f, 
    0.14474580f, -0.00221243f, 0.08693370f, -0.03192814f, -0.22239934f, 0.24109054f, 0.38033575f, 0.13527143f, 
    -0.14835912f, 0.13229163f, -0.10848808f, -0.14272258f, -0.06873928f, 0.05715735f, -0.24206725f, 0.12020358f, 
    -0.35011613f, 0.01031655f, -0.08179545f, 0.03443057f, -0.06020279f, 0.13098907f, 0.19739155f, -0.00840949f, 
    -0.15574853f, 0.13037351f, -0.00246309f, -0.24793935f, 0.00088591f, 0.25656912f, 0.05448595f, 0.12668629f, 
    -0.06190947f, 0.04068506f, -0.27418441f, 0.01831564f, -0.27310637f, -0.06482168f, -0.14987242f, 0.00904964f, 
    -0.06422236f, 0.25815785f, 0.04851056f, 0.00829836f, 0.02474932f, 0.06395617f, 0.01308384f, 0.20330201f, 
    0.01370351f, -0.14245729f, 0.24893039f, -0.39618376f, -0.03584373f, -0.18261489f, 0.04272100f, 0.09702528f, 
    0.07548761f, -0.06773073f, 0.14237285f, 0.10132918f, -0.49025089f, 0.12515081f, -0.01318796f, -0.05361695f, 
    0.13373594f, -0.20440461f, 0.09642515f, -0.73085135f, 0.12948127f, 0.08071390f, -0.20909864f, 0.04377901f, 
    -0.09392317f, -0.10818644f, 0.09281642f, -0.04097656f, -0.06822977f, 0.31473011f, 0.00654021f, -0.18937808f, 
    0.11660773f, 0.02509049f, -0.15676977f, 0.21017854f, -0.16111104f, 0.12764703f, -0.26710749f, -0.01431731f, 
    0.07100870f, -0.10787112f, -0.10145404f, -0.03348906f, 0.16464743f, -0.01645267f, -0.22651760f, -0.21723254f, 
    0.31097427f, 0.17501129f, -0.22106697f, -0.01547331f, 0.07211522f, 0.03215772f, 0.09356980f, 0.00873498f, 
    0.02984895f, 0.34277526f, -0.06435855f, -0.15542437f, 0.11049075f, 0.08287618f, -0.03404054f, -0.19589615f, 
    0.69867134f, 0.32200715f, 0.12446777f, -0.11729912f, -0.03472607f, 0.07154430f, -0.22120765f, -0.20645586f, 
    0.00809745f, -0.11628053f, 0.29525632f, 0.28910869f, 0.06694852f, -0.04384938f, 0.12476885f, 0.06353307f, 
    0.00941346f, 0.07445668f, -0.00679958f, 0.05634644f, -0.01539389f, 0.00848556f, -0.10736157f, 0.00990345f, 
    0.13943842f, 0.02064024f, -0.01434324f, 0.02318533f, -0.04963252f, 0.02254039f, -0.06513232f, 0.02188563f, 
    -0.05358147f, -0.07416792f, 0.11961967f, -0.11757086f, 0.00360948f, 0.08204334f, 0.09108362f, 0.19587907f, 
    0.20990196f, 0.13594782f, -0.21689479f, -0.07644336f, 0.11534891f, 0.02416942f, 0.29493999f, 0.26089141f, 
    0.20202808f, 0.02134401f, 0.17195514f, -0.13969176f, -0.12673700f, -0.01730754f, -0.22016451f, -0.12106643f, 
    0.19673531f, 0.17241147f, -0.04249914f, -0.15667750f, 0.19072266f, -0.16540977f, -0.04494413f, 0.02170114f, 
    -0.33119941f, 0.06545077f, 0.13019505f, -0.08266956f, 0.15435432f, 0.07747066f, 0.03071757f, 0.14201625f, 
    0.23196465f, 0.09942966f, 0.12637265f, -0.10114843f, 0.00644991f, 0.02647526f, 0.01638071f, 0.09857559f, 
    0.20461535f, 0.07542119f, -0.21609893f, -0.34884101f, 0.24983837f, 0.07070483f, 0.21502952f, -0.03227251f, 
    -0.19222060f, -0.20012079f, 0.08419698f, -0.00306237f, 0.14486539f, 0.15787807f, -0.03295427f, 0.07736153f, 
    -0.19188905f, 0.06111854f, -0.09658428f, -0.42086551f, 0.08983390f, -0.14027941f, 0.32300171f, -0.17699076f, 
    0.03077202f, -0.22405547f, 0.08550259f, -0.14702274f, 0.09876646f, 0.09754938f, -0.24731795f, 0.41790956f, 
    -0.24418072f, 0.11180095f, 0.16441934f, -0.00861170f, 0.09133971f, -0.02146424f, 0.09799681f, 0.06201149f, 
    0.09252818f, -0.00438827f, 0.12388624f, 0.09795371f, 0.01207549f, 0.12869477f, 0.19150975f, 0.02622067f, 
    -0.01545015f, -0.20430623f, -0.17057341f, -0.03605726f, 0.12585244f, 0.14376022f, -0.02493905f, 0.23117656f, 
    0.05389623f, -0.06318805f, -0.16365187f, 0.04078954f, -0.07604612f, 0.08681174f, -0.01557058f, 0.05595815f, 
    0.36203769f, -0.26259318f, -0.05106968f, 0.05941890f, -0.05949717f, 0.00277410f, 0.15152144f, 0.07281076f, 
    0.08673391f, 0.16398545f, 0.00441670f, 0.07663897f, -0.02720702f, 0.11999956f, -0.31473371f, -0.03696488f, 
    0.13977453f, -0.03442525f, 0.01386032f, -0.02180769f, 0.27931297f, 0.06208691f, -0.02792650f, -0.08149735f, 
    -0.26290998f, 0.03766889f, -0.14483434f, 0.17005946f, 0.15830640f, 0.32715452f, 0.09601735f, 0.03258948f, 
    -0.14310348f, -0.01258917f, 0.06098519f, -0.10890572f, 0.26840377f, -0.14380154f, 0.04072410f, 0.07863655f, 
    -0.02170619f, 0.10363524f, 0.16459821f, 0.16088709f, 0.37137756f, 0.15680560f, -0.03525851f, -0.12577614f, 
    -0.05279893f, 0.08885752f, 0.01573375f, -0.42677155f, 0.21882375f, -0.04207663f, -0.41764274f, -0.23830578f, 
    -0.20765056f, -0.11007664f, -0.08447784f, 0.11005013f, 0.13415153f, 0.12507592f, -0.08342272f, 0.05149653f, 
    0.07079597f, -0.27343872f, 0.03559833f, -0.12840584f, -0.18197131f, -0.16363105f, 0.01683006f, 0.17251872f, 
    0.19545615f, 0.04349264f, 0.28565535f, -0.08897447f, -0.00160192f, -0.10434620f, 0.00993312f, -0.22761934f, 
    0.22410399f, -0.35217500f, 0.32431903f, 0.01085918f, 0.13666791f, -0.09792567f, -0.13551065f, 0.19685712f, 
    0.09945450f, 0.07048867f, 0.00552876f, -0.28013369f, -0.17681092f, -0.00026942f, 0.01310310f, 0.01541873f, 
    0.30528632f, 0.03971101f, -0.09954954f, -0.30164501f, -0.07642861f, 0.27358678f, 0.28268808f, 0.24108340f, 
    -0.04699501f, 0.12005992f, -0.16923741f, 0.11346374f, -0.08672047f, -0.07692374f, 0.09410641f, 0.07620692f, 
    -0.12257552f, -0.04282253f, 0.06128372f, 0.09855311f, -0.20412982f, -0.31870297f, -0.02453921f, 0.22987869f, 
    0.08990294f, 0.01487339f, 0.01345499f, -0.13988578f, 0.13777594f, 0.13367817f, -0.31491533f, -0.09178682f, 
    -0.01129502f, 0.21602656f, -0.29218686f, 0.03616978f, 0.03357757f, 0.01338525f, 0.06254207f, -0.20483750f, 
    -0.23845524f, -0.08475459f, 0.07171399f, -0.03897353f, 0.05194905f, -0.31291091f, 0.04747598f, -0.12294894f, 
    0.13251956f, 0.14331637f, 0.11756679f, -0.09632320f, 0.03261992f, 0.15469304f, 0.19848602f, 0.08856861f, 
    -0.34119758f, -0.00097238f, 0.18700488f, -0.29061410f, 0.02368071f, -0.09020936f, -0.10911286f, -0.10168794f, 
    0.12484941f, 0.14846328f, 0.15518405f, 0.03685607f, 0.27745029f, 0.04322195f, 0.08635752f, 0.11637482f, 
    -0.11013971f, -0.04182198f, 0.14198966f, 0.05911079f, 0.09793451f, -0.21050955f, 0.17839059f, 0.09478086f, 
    0.11954702f, 0.07468322f, 0.06261518f, -0.03976398f, 0.06670221f, -0.12244178f, 0.16852593f, -0.12524945f, 
    0.11258492f, -0.21782297f, -0.15913379f, -0.00302300f, 0.15727171f, -0.15597019f, -0.07058128f, 0.09635139f, 
    0.02275755f, 0.09845472f, 0.06054467f, -0.11770024f, -0.05995886f, -0.10512792f, 0.50970328f, 0.35150313f, 
    0.31089881f, -0.05241477f, 0.03680007f, -0.10356516f, -0.12678249f, 0.01469377f, -0.26429722f, -0.18021068f, 
    -0.15957451f, -0.15872291f, 0.24434625f, -0.07835656f, -0.03215706f, -0.11381991f, -0.04996286f, 0.06299954f, 
    0.20348021f, 0.03973567f, 0.31044289f, -0.01091541f, 0.05789016f, -0.06149177f, 0.04415357f, 0.20311417f, 
    0.16205001f, 0.06182921f, 0.06676275f, 0.43994725f, 0.10808338f, 0.01477467f, -0.09915936f, 0.08214675f, 
    0.21041703f, 0.08873343f, -0.31832621f, 0.37937385f, -0.15047346f, 0.07404385f, -0.13566612f, -0.09987067f, 
    -0.00495043f, -0.11940412f, -0.04205000f, 0.11435778f, -0.00574445f, 0.32586554f, -0.05713208f, -0.12775709f, 
    -0.13917731f, -0.07425573f, -0.23477109f, 0.06343700f, -0.20141515f, -0.11160857f, 0.05310110f, 0.21228367f, 
    -0.04453606f, 0.03940697f, -0.00601379f, 0.09532360f, -0.29664147f, 0.22172286f, -0.19845045f, 0.19033396f, 
    -0.08630189f, -0.02505391f, -0.04972696f, -0.02327819f, -0.12456089f, 0.10668275f, 0.00320272f, 0.21917911f, 
    -0.05410599f, 0.09729949f, -0.01001035f, -0.06805971f, 0.12488240f, 0.18998981f, 0.09083340f, -0.09515803f, 
    -0.19319534f, 0.02872534f, -0.08349103f, 0.14437778f, 0.01208099f, -0.02398382f, 0.17895077f, 0.06612987f, 
    0.17264673f, -0.17162980f, -0.21726482f, -0.11694626f, 0.01827207f, -0.05015972f, 0.01440354f, -0.09247670f, 
    0.18948051f, 0.13968958f, 0.06311908f, 0.17192630f, 0.10356031f, -0.11917595f, -0.00661631f, -0.08728401f, 
    0.07949125f, -0.13344145f, -0.03606502f, -0.09375526f, -0.13473211f, 0.00950856f, 0.15172413f, 0.08738128f, 
    0.07734454f, 0.28271580f, 0.00089860f, -0.26873139f, 0.00494712f, 0.51723105f, 0.02322490f, -0.27485156f, 
    0.06298652f, 0.01269259f, 0.05696447f, 0.01445427f, 0.31489101f, 0.21006729f, -0.06085694f, 0.12431910f, 
    -0.26562840f, 0.19087094f, 0.14889666f, -0.00277710f, 0.10436672f, -0.48648247f, -0.32648370f, -0.21070045f, 
    -0.01632503f, 0.05837971f, -0.10761572f, 0.10345168f, 0.09923810f, 0.14723508f, -0.54119033f, -0.42897111f, 
    -0.25864246f, -0.06170460f, -0.11752066f, -0.06654765f, 0.00974448f, -0.27826878f, -0.07189685f, -0.20328675f, 
    -0.20831905f, -0.13369311f, 0.07566897f, 0.01574661f, -0.11938252f, 0.15352811f, -0.01436525f, 0.00365859f, 
    0.12521541f, -0.02123162f, 0.28206018f, -0.08206525f, -0.14190440f, 0.00005920f, 0.06626903f, -0.01400624f, 
    0.08046311f, 0.18042478f, -0.18715824f, -0.29424426f, -0.22087003f, 0.12671015f, -0.12260408f, 0.08066175f, 
    -0.12998663f, 0.26530826f, 0.00482950f, -0.06625371f, -0.24306925f, -0.08854020f, -0.18868980f, 0.01695593f, 
    -0.17375436f, 0.13727370f, 0.01170642f, -0.03249446f, -0.10245078f, -0.30196986f, 0.22803874f, -0.12012240f, 
    0.09403650f, -0.15445207f, -0.08297057f, -0.07733469f, -0.11442274f, 0.15416038f, -0.30249944f, 0.27808121f, 
    -0.00700887f, 0.06070668f, -0.10957776f, 0.04985274f, -0.05308883f, -0.12591371f, 0.18196832f, 0.11279405f, 
    -0.10817067f, -0.08498613f, -0.00720674f, 0.09700320f, -0.05431624f, -0.01702787f, -0.49265942f, 0.03343602f, 
    -0.13571747f, 0.18414009f, 0.09562980f, 0.00015077f, 0.22086674f, 0.05981492f, -0.10515977f, -0.06291930f, 
    0.08423500f, -0.46261758f, 0.04419927f, 0.21859667f, 0.04546070f, -0.01215435f, -0.11012793f, 0.05135542f, 
    -0.02677593f, -0.07826249f, -0.34440213f, -0.22605324f, 0.13148233f, -0.07303081f, 0.21116376f, 0.08932786f, 
    0.10334997f, 0.38559210f, 0.11979020f, 0.31900093f, -0.09227497f, -0.11053888f, 0.13009883f, 0.06197102f, 
    0.24073780f, 0.02497932f, 0.21199730f, -0.10942829f, -0.01656729f, 0.11436377f, -0.19840509f, -0.00274178f, 
    -0.04217682f, 0.05110462f, 0.05454367f, 0.03931608f, 0.01727776f, 0.09763496f, 0.22170638f, -0.16900431f, 
    0.10144877f, 0.13004485f, 0.27128309f, -0.19540486f, 0.02672974f, -0.11919879f, 0.31814185f, -0.12101877f, 
    -0.12137708f, -0.05298122f, -0.15704837f, 0.08817674f, 0.17223965f, -0.10592218f, -0.54877269f, 0.46838668f, 
    0.12605338f, -0.20486215f, -0.01518778f, -0.12068623f, -0.01132269f, -0.04954570f, -0.19962835f, -0.06058049f, 
    0.39164317f, 0.30941102f, -0.19580255f, -0.10961471f, 0.22257888f, 0.07631730f, 0.07807634f, 0.24944112f, 
    0.04381903f, 0.26563472f, -0.08599763f, -0.05461290f, -0.00444594f, 0.01660508f, 0.06331468f, -0.01205631f, 
    -0.03277510f, -0.04193288f, -0.01464826f, -0.05654570f, -0.05830230f, -0.04394607f, -0.02443480f, 0.04050553f, 
    -0.02178407f, -0.06656440f, 0.05036757f, -0.04350032f, -0.00474347f, -0.00844344f, 0.01497807f, -0.05982400f, 
    0.02334619f, -0.03197745f, -0.06229105f, 0.01652974f, -0.04150944f, -0.06502026f, -0.02910739f, -0.02868212f, 
    -0.02273536f, -0.05956306f, -0.05736247f, 0.00325164f, 0.03716452f, -0.02663411f, -0.00672947f, 0.01833788f, 
    -0.04742494f, -0.01370886f, -0.06939706f, 0.03917518f, -0.03459033f, -0.01093359f, 0.04170716f, 0.00024982f, 
    -0.02500525f, -0.04122552f, 0.01382195f, -0.00870256f, 0.01475141f, 0.02870169f, 0.04593830f, -0.01064246f, 
    -0.02051280f, -0.05457849f, -0.06082279f, 0.03544631f, -0.04039248f, 0.02134094f, -0.01326717f, -0.06450570f, 
    -0.01735524f, -0.00656083f, 0.00119892f, 0.03645501f, -0.04068189f, -0.06129526f, -0.06284013f, -0.03550739f, 
    0.00971056f, 0.05085048f, -0.00169577f, -0.05316679f, -0.02734003f, 0.04487205f, -0.04967873f, -0.01863091f, 
    0.04262109f, -0.02912398f, -0.00121447f, 0.02523303f, 0.01844960f, -0.06895196f, -0.01209767f, -0.02114537f, 
    0.02883462f, -0.04554208f, 0.03032463f, 0.04855959f, 0.00675159f, -0.06382262f, -0.00920792f, -0.00548096f, 
    0.01449819f, -0.04910893f, 0.01152097f, -0.05541740f, -0.01263347f, 0.01428431f, 0.02358827f, -0.04025827f, 
    -0.06518728f, -0.03216854f, -0.02204839f, -0.04291758f, -0.02037789f, -0.01286791f, -0.06796156f, 0.04279186f, 
    0.01438746f, -0.01223659f, -0.01159327f, -0.03604732f, -0.03472360f, -0.02089395f, 0.02989211f, -0.00818433f, 
    0.03709655f, -0.01100039f, 0.01251036f, 0.03704171f, -0.05869509f, -0.05025810f, -0.03681948f, -0.03382216f, 
    0.01354628f, 0.05132208f, -0.05905417f, -0.03310925f, 0.04735336f, 0.00138631f, -0.00499745f, 0.00535276f, 
    -0.01995386f, -0.06472536f, 0.00689566f, -0.02215880f, 0.03101705f, -0.05288617f, 0.00474975f, 0.03885406f, 
    0.00505933f, -0.04224128f, 0.04507400f, -0.01892227f, 0.03177704f, 0.02170938f, -0.02890157f, -0.00199633f, 
    0.00574138f, -0.00013268f, 0.02893516f, 0.00334105f, 0.00960419f, 0.02991443f, -0.03500853f, 0.00495797f, 
    0.03255652f, -0.00333937f, 0.04457241f, -0.04390217f, 0.00771962f, -0.05813725f, -0.05091149f, -0.02752378f, 
    -0.00663810f, 0.01372270f, 0.03650331f, -0.02050552f, 0.05341267f, 0.00061483f, 0.03709368f, -0.00672768f, 
    -0.05130430f, -0.01258479f, -0.02425902f, -0.00200989f, 0.04025030f, 0.04534294f, 0.02631715f, -0.00064679f, 
    0.04037729f, -0.03750659f, -0.00983404f, -0.04712193f, 0.02297539f, 0.02068273f, 0.04421693f, 0.01220665f, 
    -0.03138388f, -0.05986001f, -0.02419369f, 0.01069797f, -0.05336672f, 0.00875890f, -0.06751892f, 0.02370846f, 
    -0.03129287f, 0.00096469f, -0.05179911f, 0.02691795f, -0.05725607f, -0.05384618f, -0.01123307f, 0.00960072f, 
    -0.02797502f, -0.02558915f, 0.00141931f, 0.04501337f, 0.03865165f, -0.03749567f, -0.03640923f, 0.03562795f, 
    -0.01303309f, -0.06176642f, -0.03478159f, 0.00888289f, -0.03021941f, 0.01652203f, 0.00650548f, 0.02076255f, 
    0.01765756f, -0.00573030f, -0.02400210f, -0.00601893f, -0.02100474f, 0.03407897f, 0.02137875f, -0.00581226f, 
    0.02374842f, -0.04444205f, 0.01144669f, -0.00140928f, 0.01713951f, -0.02185246f, 0.00530278f, -0.06165880f, 
    -0.04145909f, 0.02770105f, -0.03787362f, -0.06392933f, -0.03433843f, 0.01893950f, 0.01219261f, -0.06503265f, 
    0.01697177f, 0.04957920f, 0.01505045f, 0.04659863f, -0.01133548f, 0.03620500f, -0.05377961f, -0.01997415f, 
    -0.02404083f, -0.04896442f, 0.01369453f, 0.02143525f, 0.04020134f, 0.02318014f, 0.02169221f, -0.00659965f, 
    0.01205523f, -0.02247441f, 0.04431249f, -0.02779410f, -0.04944173f, -0.05732913f, 0.04327049f, -0.03991177f, 
    -0.00830247f, 0.01020107f, -0.00383912f, -0.01314111f, 0.04773967f, -0.00332046f, 0.00237224f, -0.00271281f, 
    0.03973123f, -0.00555234f, -0.04437947f, 0.01976296f, 0.01887085f, -0.00889130f, -0.00075754f, 0.04381255f, 
    0.02978699f, -0.05476987f, -0.02137980f, -0.01808885f, -0.04957655f, -0.03084887f, 0.03117372f, 0.03570690f, 
    -0.00785914f, -0.02127081f, -0.04625424f, -0.04898649f, 0.02681795f, 0.04186492f, 0.00604033f, -0.04231033f, 
    -0.03671622f, -0.02402440f, -0.01145944f, 0.04625008f, 0.02640126f, -0.05586255f, -0.03907438f, 0.03810972f, 
    0.04133248f, -0.06879718f, -0.06702396f, -0.02982383f, -0.00379983f, 0.03491962f, -0.03877719f, 0.03512426f, 
    -0.01070218f, -0.04692854f, 0.01209113f, -0.05400555f, -0.05169104f, -0.05305376f, -0.00719309f, 0.01479346f, 
    -0.05236156f, -0.05977218f, -0.04589079f, -0.00014168f, 0.04228333f, 0.00334397f, -0.04168162f, 0.01883027f, 
    0.01458125f, -0.06110025f, -0.00929661f, 0.01742652f, -0.04320012f, 0.00035389f, 0.01429946f, -0.03288985f, 
    0.04292230f, -0.04556404f, 0.03036737f, -0.01592725f, -0.03278547f, 0.01124358f, 0.01316766f, -0.05932182f, 
    0.03569117f, -0.05683421f, 0.04681495f, -0.05603847f, 0.04503780f, 0.03101871f, -0.03000160f, -0.03514346f, 
    -0.02257033f, -0.04459210f, 0.04468241f, 0.04246282f, -0.04667059f, 0.02848965f, 0.00825950f, -0.02395202f, 
    0.02519944f, -0.02286909f, 0.03518350f, -0.04743730f, 0.02836991f, -0.01689532f, -0.04758975f, 0.03152235f, 
    0.04676861f, -0.05813844f, 0.00855707f, -0.06430277f, 0.04360772f, 0.03110180f, -0.00415031f, 0.01546268f, 
    -0.05361330f, -0.03678341f, 0.00110420f, -0.03354115f, -0.02434167f, 0.04349509f, -0.02675573f, 0.04414223f, 
    -0.06042919f, 0.04560465f, 0.01803247f, 0.03144957f, -0.04353524f, -0.00457145f, -0.04466966f, 0.04027655f, 
    0.02754765f, -0.02882833f, -0.01091872f, -0.05897387f, -0.02396446f, -0.05508685f, -0.01526072f, -0.05058551f, 
    -0.06195599f, 0.04666713f, -0.03381249f, 0.04205845f, 0.04527344f, -0.05283463f, 0.02750950f, -0.06506083f, 
    -0.03168259f, -0.04226175f, 0.03878272f, -0.06989554f, 0.01511312f, -0.01149587f, -0.03228519f, 0.00596887f, 
    0.00277278f, -0.03278740f, 0.02311281f, -0.06025380f, -0.04815916f, -0.02892154f, 0.03657934f, -0.04585990f, 
    0.03805675f, 0.04370300f, -0.03470594f, -0.01445406f, 0.03187311f, 0.00052394f, -0.05700279f, -0.03502649f, 
    -0.00905042f, 0.02522448f, 0.04291729f, -0.06453163f, -0.02820770f, -0.01140019f, -0.02300196f, -0.01683543f, 
    0.01507838f, -0.04606532f, -0.00842739f, 0.01193335f, -0.01381646f, 0.03253179f, 0.02308865f, -0.03306029f, 
    -0.00440741f, 0.01846500f, -0.04036435f, -0.05772729f, 0.04740718f, -0.04193293f, -0.03144571f, 0.03897130f, 
    0.00886795f, -0.04764748f, -0.00514990f, -0.01778690f, -0.01337156f, -0.01254068f, -0.06810427f, -0.00396405f, 
    -0.03721519f, 0.04390092f, -0.06132432f, 0.04400680f, -0.01053170f, 0.04758354f, 0.03827564f, 0.04801683f, 
    0.01302002f, -0.05787705f, -0.03873491f, 0.02307457f, -0.06640683f, -0.06450860f, -0.01056528f, -0.06873259f, 
    -0.01991334f, 0.02883073f, 0.01424861f, -0.04463167f, -0.00207360f, -0.06836464f, -0.02384545f, 0.05065327f, 
    0.03808432f, 0.03305925f, -0.06440833f, -0.02653243f, -0.05521651f, -0.05260218f, -0.05094451f, -0.00711346f, 
    -0.05031932f, 0.01321472f, 0.02479900f, 0.03031749f, -0.03784972f, 0.03037986f, 0.00908319f, 0.01439634f, 
    -0.04111664f, -0.04929651f, 0.01598947f, -0.02727395f, 0.01822157f, -0.02414251f, 0.04684981f, -0.06360137f, 
    -0.04791368f, -0.01561257f, -0.06372312f, -0.03761097f, 0.02583974f, 0.03830623f, 0.03121570f, 0.03842613f, 
    -0.03128118f, -0.06641736f, 0.03403493f, -0.06790235f, 0.04315029f, -0.01195055f, 0.02905498f, -0.03834042f, 
    0.01785486f, -0.04689994f, 0.02099823f, -0.00395579f, -0.02543559f, 0.02673832f, 0.04515413f, 0.00566806f, 
    -0.05565655f, -0.00947215f, -0.03440781f, -0.04448847f, 0.00598286f, 0.03681577f, -0.05536700f, 0.01863702f, 
    -0.06861347f, 0.00922727f, -0.00905941f, 0.03125435f, -0.05837619f, 0.03611206f, -0.00269292f, 0.01993569f, 
    0.04979328f, -0.06786043f, 0.01241993f, -0.00555313f, 0.00241989f, 0.00944000f, 0.05817774f, 0.00081099f, 
    -0.05731011f, -0.02142417f, -0.01168149f, -0.01262904f, -0.06530178f, -0.04992842f, -0.01725273f, -0.00492542f, 
    0.04276999f, 0.03102270f, -0.04508835f, 0.00376027f, -0.00498643f, -0.06599715f, 0.03216632f, -0.02142354f, 
    0.05033654f, -0.04649355f, -0.04928951f, -0.05052396f, -0.03770306f, 0.05473686f, -0.04950739f, 0.04307108f, 
    -0.06622136f, 0.04342341f, -0.02759119f, -0.00773442f, 0.00896368f, -0.05135702f, -0.06246073f, -0.04545314f, 
    -0.02970532f, -0.01234979f, 0.00472218f, -0.02639609f, -0.01068041f, 0.04787951f, 0.02122779f, -0.00580305f, 
    -0.05194283f, -0.03663134f, -0.04521807f, -0.01402795f, -0.01829278f, 0.03639558f, -0.06039567f, 0.05831129f, 
    -0.05609383f, -0.02600276f, -0.02713715f, -0.00257266f, 0.03460772f, 0.01364050f, -0.01314896f, -0.00611082f, 
    -0.04626503f, -0.00666209f, 0.02889863f, 0.03687545f, -0.01452095f, -0.04819912f, -0.06482518f, 0.00096657f, 
    -0.05426199f, 0.05695753f, 0.03227082f, -0.05458627f, 0.02137039f, 0.01678834f, -0.03633637f, 0.01242963f, 
    -0.01009092f, 0.00831014f, 0.02286039f, -0.00200351f, 0.03758889f, 0.01224092f, -0.03708036f, 0.05236711f, 
    0.04324321f, 0.03842360f, -0.03420401f, -0.06331529f, -0.05919908f, 0.02932828f, -0.01091484f, -0.03017474f, 
    -0.05751012f, 0.03105388f, -0.05922813f, 0.03392219f, -0.04675824f, -0.05660279f, 0.02556080f, -0.02247813f, 
    0.03621209f, -0.02957346f, 0.04351762f, 0.04598226f, -0.03899734f, -0.01722383f, 0.03147370f, -0.05821112f, 
    0.00576861f, -0.02057114f, -0.01448278f, -0.01706676f, -0.06813781f, 0.05285019f, 0.04342386f, -0.05925578f, 
    -0.04177812f, 0.01841583f, 0.04450450f, -0.06247675f, 0.02758306f, 0.01295300f, 0.04878887f, -0.02642753f, 
    -0.06410730f, 0.00422770f, -0.00355864f, -0.01784289f, -0.00340147f, 0.04207402f, 0.00575487f, -0.04150495f, 
    -0.04027533f, -0.02293222f, -0.04336504f, 0.04917004f, -0.00081459f, -0.05697745f, -0.00172853f, -0.05139867f, 
    0.03528226f, 0.02298412f, -0.03913803f, -0.06399935f, 0.01891369f, -0.04896475f, -0.00001283f, 0.03385535f, 
    0.03994595f, 0.02569913f, -0.01007829f, 0.04728103f, 0.02961408f, -0.04648915f, -0.00630410f, -0.01845408f, 
    0.00828538f, -0.02357585f, -0.02126763f, 0.01731566f, 0.01579493f, 0.01880049f, 0.03593922f, -0.03624620f, 
    -0.06321006f, -0.01431025f, -0.03850581f, -0.02692152f, -0.01537080f, -0.02697384f, -0.00931529f, 0.04762329f, 
    0.04768089f, -0.04612370f, -0.06459472f, 0.02332811f, 0.01973076f, 0.00800731f, -0.02333161f, 0.04267410f, 
    -0.05669559f, 0.03860070f, 0.04019698f, 0.03885794f, -0.05008615f, 0.02175042f, -0.02122933f, -0.06116778f, 
    0.03814355f, 0.03804110f, -0.05645101f, -0.03380821f, -0.00113826f, 0.02522245f, -0.04183797f, -0.03039100f, 
    0.03022693f, -0.00926647f, -0.02791863f, -0.01084805f, -0.03297408f, 0.00805757f, -0.02022392f, -0.01205135f, 
    -0.01582367f, 0.03266094f, -0.03859565f, 0.00379598f, -0.00765416f, -0.03671604f, -0.04708816f, -0.03306056f, 
    0.02283827f, -0.05980042f, -0.02835047f, -0.02095646f, -0.00967987f, 0.02084632f, -0.03121470f, 0.03180566f, 
    -0.03909653f, 0.05080203f, -0.03571970f, 0.01905091f, -0.02401849f, 0.01949065f, 0.02717960f, -0.03488640f, 
    -0.02921567f, 0.03745402f, 0.04101965f, -0.02930938f, 0.04096916f, -0.06835733f, -0.01326457f, -0.03131515f, 
    0.04038486f, -0.01853591f, 0.04573791f, 0.04000091f, -0.05450503f, 0.03450561f, 0.01317219f, -0.05991171f, 
    0.04250552f, 0.02132768f, 0.05731831f, 0.03279207f, -0.00479871f, 0.00050821f, 0.00946581f, -0.02341701f, 
    0.03641167f, 0.00844385f, 0.04287056f, -0.00434513f, 0.05369990f, -0.01055038f, -0.04163693f, -0.00477289f, 
    -0.05402435f, 0.04712830f, 0.01924087f, 0.02299036f, -0.05936154f, 0.01345428f, -0.01132783f, -0.02720992f, 
    -0.02862791f, 0.00790016f, 0.02852083f, -0.05418391f, 0.00468362f, -0.03594670f, -0.01425679f, 0.04722898f, 
    -0.00411754f, 0.00904519f, -0.03137657f, -0.00813132f, -0.02857135f, 0.01886456f, 0.01358198f, -0.06566240f, 
    0.04752554f, -0.01606663f, 0.01041269f, 0.01172357f, 0.04057895f, 0.04385608f, -0.06029879f, 0.02416738f, 
    -0.06655692f, -0.04083354f, -0.05716529f, 0.03333141f, 0.04026216f, -0.02096254f, 0.03566721f, -0.00660092f, 
    0.03590690f, 0.02127931f, -0.05259157f, -0.03447679f, 0.03357779f, -0.02731324f, -0.02886503f, -0.00526468f, 
    0.02401163f, 0.01471472f, -0.00720932f, 0.00988471f, -0.00517111f, -0.00869701f, 0.01768744f, 0.01325455f, 
    -0.00711003f, -0.02375948f, -0.02038356f, -0.02435246f, 0.03177030f, -0.05134808f, -0.04629104f, -0.03401352f, 
    0.02813198f, -0.02201333f, 0.00108186f, 0.00513233f, -0.01249080f, 0.01417525f, -0.03179580f, 0.02775212f, 
    0.02213485f, 0.02463935f, 0.02038730f, 0.02039550f, 0.04705939f, 0.04217045f, 0.04688763f, -0.05296057f, 
    -0.06745039f, 0.04899092f, 0.00537050f, -0.03957526f, -0.02892997f, -0.01367827f, 0.03808277f, -0.02746893f, 
    0.02848030f, -0.02627767f, -0.02156649f, -0.05682431f, -0.01656805f, -0.01014163f, 0.04862701f, 0.04683053f, 
    0.04086547f, -0.05575708f, -0.01721979f, -0.02393601f, -0.06008041f, -0.02843359f, 0.00489471f, 0.05118112f, 
    -0.01022326f, -0.03356932f, -0.02209956f, 0.01637022f, 0.03919303f, -0.00154837f, -0.00510005f, 0.01693929f, 
    -0.03294918f, -0.01778987f, 0.04511238f, 0.03695516f, -0.04494553f, 0.02616164f, 0.04495632f, -0.00341940f, 
    -0.04018477f, -0.04992334f, -0.06567170f, -0.02965535f, -0.04393836f, 0.02959472f, -0.04407611f, -0.03110544f, 
    -0.01469413f, 0.03435246f, 0.00387375f, -0.05021103f, 0.02635081f, -0.01052818f, 0.01916054f, -0.00976004f, 
    -0.01485320f, -0.00700284f, 0.02013713f, 0.02113635f, 0.01512235f, -0.00676128f, 0.02275123f, -0.05776785f, 
    0.03029121f, -0.01737098f, -0.00571216f, 0.03946524f, 0.04591387f, 0.02933069f, 0.00150695f, -0.01617781f, 
    -0.01468404f, -0.00490336f, -0.04204924f, 0.00208305f, -0.05276596f, 0.03401783f, -0.02986145f, -0.02055129f, 
    0.03521242f, -0.04383814f, 0.02619189f, -0.00804066f, -0.05505781f, -0.04775820f, -0.04617126f, -0.03339233f, 
    0.03171533f, -0.06172653f, 0.02525302f, 0.01150839f, 0.04089742f, -0.05780714f, 0.03015265f, 0.05119276f, 
    0.04248869f, 0.02671640f, 0.01799179f, -0.04213534f, 0.05739215f, -0.04912748f, 0.01489217f, -0.02500420f, 
    0.00511206f, -0.01026526f, -0.05273883f, 0.03470100f, -0.01089972f, 0.01573681f, 0.01909756f, 0.03635763f, 
    -0.03520977f, -0.04891097f, -0.04599041f, -0.04679498f, 0.00120116f, -0.03615898f, -0.06095700f, 0.04062472f, 
    0.01294306f, 0.03675329f, -0.02559911f, -0.01233627f, -0.01984381f, -0.02798134f, -0.04471580f, -0.03308643f, 
    0.01522480f, -0.05605763f, -0.01972957f, -0.03313315f, 0.04637555f, 0.00929091f, -0.02914666f, -0.05086830f, 
    0.00869448f, 0.00898839f, 0.04691234f, 0.00007225f, -0.02156867f, -0.02016812f, -0.01363660f, -0.01549829f, 
    0.01839545f, -0.01585367f, 0.02154762f, 0.01556243f, 0.00641750f, 0.01029751f, -0.02474312f, 0.04727462f, 
    0.01098463f, 0.00752627f, 0.02463872f, -0.04518482f, -0.03939127f, -0.02217774f, -0.04873573f, -0.02141010f, 
    -0.01123054f, 0.05113594f, -0.06166657f, -0.05195085f, -0.02925529f, 0.02153093f, 0.03582200f, 0.03524888f, 
    -0.00753530f, -0.01952312f, 0.04132776f, 0.03479971f, 0.00041841f, 0.01486924f, -0.06292824f, -0.00101454f, 
    -0.04967279f, 0.01596912f, 0.05033006f, -0.00008629f, -0.04946787f, 0.03611856f, -0.01613008f, -0.05027337f, 
    -0.02040744f, 0.01555755f, 0.00924962f, -0.03780809f, -0.04211221f, -0.02122321f, -0.03291588f, -0.03534644f, 
    -0.01240403f, 0.02626815f, -0.06200868f, -0.00895783f, -0.02318300f, 0.04085407f, -0.02179141f, -0.01186321f, 
    -0.05034602f, -0.01855154f, -0.03948362f, -0.03826077f, -0.06645592f, -0.04220601f, -0.03910778f, -0.01745128f, 
    0.00823546f, 0.02614342f, -0.02888577f, -0.05803740f, -0.04016595f, 0.01523553f, -0.04451962f, 0.01692738f, 
    -0.04750726f, -0.01786437f, -0.03423489f, 0.00888869f, -0.04249324f, 0.02876794f, 0.04010770f, -0.00754480f, 
    -0.02729838f, -0.02708881f, -0.00645137f, -0.00587861f, 0.04445098f, 0.01930587f, 0.04616691f, -0.00788204f, 
    -0.06395143f, -0.04861622f, 0.00187648f, 0.00319438f, 0.05185695f, -0.02431171f, -0.01409484f, -0.06377111f, 
    0.03914598f, 0.01062277f, 0.00229177f, -0.01224330f, -0.02379475f, -0.05861376f, -0.06073996f, -0.01387162f, 
    0.01238768f, 0.05151032f, 0.02762534f, 0.00270871f, -0.01057729f, -0.06175062f, 0.00762466f, 0.01404814f, 
    -0.01811504f, -0.10578892f, -0.20576088f, 0.08045156f, -0.10152107f, 0.16974042f, -0.11890005f, 0.05782957f, 
    0.01822845f, 0.05721301f, -0.07896332f, -0.10771792f, 0.19066791f, 0.29502255f, 0.00673317f, 0.19203854f, 
    0.09901431f, -0.01162179f, 0.43082038f, -0.11624817f, -0.02263977f, 0.25391403f, -0.07530689f, -0.12627111f, 
    0.09095606f, 0.01461677f, -0.08575488f, 0.04999291f, -0.20712085f, 0.02526737f, -0.15207033f, 0.02679194f, 
    -0.00166433f, 0.02371763f, -0.14912759f, -0.33378327f, 0.25903690f, -0.26866803f, -0.05232472f, 0.18420658f, 
    0.15649588f, -0.04307375f, -0.06837241f, -0.06115060f, -0.22220980f, -0.16925584f, -0.20162590f, -0.15165189f, 
    0.15098213f, 0.06175392f, 0.28476495f, 0.04528866f, 0.01012229f, -0.13876596f, -0.07476994f, 0.05717813f, 
    -0.28114912f, 0.02690442f, -0.39596230f, -0.00027736f, 0.25625429f, 0.25639626f, 0.24764119f, -0.36028233f, 
    0.14881562f, 0.05295540f, 0.15116033f, -0.05435922f, -0.13615783f, 0.24494445f, -0.02366181f, 0.31646496f, 
    -0.14395453f, -0.17321007f, -0.11914795f, -0.02812816f, 0.18588816f, 0.28434023f, 0.04949391f, -0.29713935f, 
    -0.37268192f, -0.15715292f, 0.13357937f, 0.19985443f, 0.01975657f, 0.16454190f, 0.15690818f, -0.03036333f, 
    0.19983193f, 0.15690847f, -0.25457847f, 0.30868834f, 0.04052249f, -0.10101996f, -0.13400944f, 0.03140002f, 
    -0.33835816f, 0.06212100f, 0.17797817f, 0.08661055f, 0.01540986f, -0.02147852f, 0.17511317f, 0.08661223f, 
    0.05184574f, 0.01678688f, -0.13928221f, 0.01369056f, 0.16170098f, -0.20833048f, 0.03954378f, 0.09531122f, 
    0.18262456f, 0.26227200f, 0.00027957f, -0.04076915f, 0.08069328f, 0.33645007f, 0.25660554f, -0.12657566f, 
    -0.03409415f, -0.15813574f, 0.11157446f, 0.11129764f, 0.13186446f, 0.18030971f, 0.16995190f, -0.16470586f, 
    0.05091734f, -0.04556852f, 0.19910742f, 0.19443397f, 0.21437043f, 0.05418276f, -0.00263866f, -0.10084662f, 
    0.06765107f, -0.29525796f, 0.13654818f, -0.08983173f, -0.00598285f, 0.34652415f, 0.11187819f, -0.16285536f, 
    -0.37468803f, 0.03814308f, 0.18330741f, 0.16675554f, 0.12835522f, 0.03430756f, -0.09028911f, -0.03552424f, 
    0.11248937f, 0.40955380f, 0.11806745f, 0.01460597f, 0.17114167f, -0.16286704f, -0.04529859f, -0.23311532f, 
    -0.01092119f, 0.02071849f, -0.35896963f, -0.49418086f, -0.35279390f, -0.24513936f, 0.12880687f, -0.28864878f, 
    0.09316585f, -0.11997211f, -0.31854314f, 0.28042263f, 0.26111251f, 0.11714095f, -0.16499065f, 0.26095951f, 
    0.02418303f, 0.08351974f, -0.20490049f, -0.06241363f, 0.06019908f, 0.20283732f, -0.05459097f, -0.04153736f, 
    -0.01615139f, -0.14485316f, 0.16694868f, 0.14721689f, -0.06178945f, -0.28470907f, 0.29256573f, 0.26684615f, 
    -0.22231179f, 0.08062152f, 0.04125325f, -0.27504712f, -0.04628368f, -0.04884748f, 0.57558078f, 0.19441064f, 
    -0.25472465f, -0.14065300f, 0.11410948f, -0.18782976f, 0.02605277f, 0.21232034f, 0.27334055f, -0.26035142f, 
    0.03665287f, 0.04869409f, 0.13548818f, 0.00650575f, -0.19221921f, -0.25694770f, 0.10800891f, 0.08691859f, 
    0.11553457f, -0.01622322f, 0.14439146f, -0.00531032f, 0.07039351f, 0.19298522f, -0.02494818f, 0.15331881f, 
    -0.07311329f, -0.35062256f, -0.45722282f, -0.13402438f, 0.12001572f, 0.18457165f, 0.12571867f, -0.15021944f, 
    -0.09631181f, 0.03755508f, -0.31171137f, -0.17977937f, -0.00538278f, 0.35900873f, 0.35083786f, 0.09786122f, 
    -0.03744164f, -0.00400985f, 0.00386988f, -0.06173282f, -0.08466670f, 0.02226203f, -0.00751334f, 0.14840564f, 
    0.03954256f, 0.10429454f, -0.03817444f, 0.10608789f, -0.49670908f, 0.11437946f, 0.40125445f, -0.01683174f, 
    0.14792237f, 0.04160395f, -0.12978169f, 0.16783346f, 0.06301218f, -0.12510850f, -0.07747404f, -0.32417491f, 
    0.05845912f, -0.12383032f, -0.14652297f, 0.04340725f, 0.13706642f, 0.08597443f, -0.12037752f, 0.19711995f, 
    -0.12190312f, 0.08579882f, -0.10698634f, -0.03820651f, -0.03489492f, 0.08436982f, 0.15454628f, -0.14006934f, 
    -0.12904046f, -0.23865445f, 0.08430481f, -0.04951521f, 0.05904228f, 0.11107390f, 0.12204988f, -0.15145719f, 
    -0.03772506f, -0.04309442f, -0.04714463f, -0.01326217f, -0.02035863f, -0.00181770f, -0.02653015f, 0.01589078f, 
    0.02483055f, 0.00981455f, -0.02134961f, -0.02957321f, -0.05223059f, -0.04449048f, 0.04202541f, -0.05850507f, 
    -0.05218581f, 0.04299100f, -0.04575197f, 0.05078503f, -0.02079094f, -0.01745076f, -0.05257791f, -0.04719616f, 
    0.02687473f, -0.02108824f, 0.00282953f, 0.04973395f, -0.02830470f, 0.03033211f, -0.05856404f, -0.01663276f, 
    0.00036974f, -0.00186370f, 0.03269516f, 0.04508223f, -0.04574361f, 0.00668704f, -0.01493032f, -0.02384926f, 
    -0.02230589f, -0.05253469f, 0.01872565f, -0.01693481f, -0.00276144f, -0.05665594f, -0.04703896f, -0.04321124f, 
    -0.03521424f, 0.00929915f, -0.02848835f, -0.01026743f, 0.01190223f, 0.00534846f, -0.05181905f, -0.02100764f, 
    0.00601289f, 0.02196513f, -0.03469708f, 0.03654408f, 0.02531499f, 0.04897190f, -0.06245039f, -0.00732062f, 
    -0.02117632f, 0.04067113f, 0.05209501f, 0.02160906f, -0.02507437f, 0.03493426f, 0.04618002f, 0.04785051f, 
    -0.02972155f, -0.00450749f, -0.01878376f, -0.01501458f, 0.03289604f, 0.03270505f, 0.04403403f, -0.00132240f, 
    -0.00577476f, -0.05528045f, -0.00925831f, -0.03928136f, -0.02130144f, -0.00872923f, -0.03970890f, 0.02625733f, 
    -0.05109548f, -0.02222866f, -0.00640751f, -0.03944395f, -0.02842861f, -0.05920678f, 0.01029750f, -0.06078415f, 
    -0.03157481f, 0.00842464f, -0.01109051f, 0.01457157f, 0.01147220f, -0.01780021f, -0.02024729f, -0.01622944f, 
    0.03961122f, 0.04632264f, -0.01624968f, -0.05908530f, -0.02866848f, 0.04265903f, -0.00322193f, -0.05068876f, 
    -0.03765715f, 0.05930069f, -0.00090211f, 0.02279755f, 0.03637617f, -0.00396349f, 0.03502625f, -0.04513018f, 
    0.00566497f, -0.03914600f, 0.04257396f, 0.04494299f, -0.04160939f, -0.03364528f, 0.02063136f, -0.03355948f, 
    0.04884008f, 0.03449539f, -0.02390105f, 0.00126768f, 0.00045982f, 0.03522575f, 0.02460524f, 0.03075255f, 
    -0.05660079f, 0.01030660f, 0.04714083f, -0.02813746f, 0.03320619f, -0.03245714f, -0.00461653f, 0.02612261f, 
    -0.00626248f, 0.00470459f, 0.03124645f, -0.03274173f, -0.00693473f, -0.01340564f, 0.01373979f, -0.06120002f, 
    -0.04850741f, 0.02166029f, 0.00949424f, -0.01830037f, 0.02625749f, -0.01789065f, -0.05520343f, -0.00771935f, 
    -0.03599544f, 0.04513820f, -0.03251893f, 0.04645600f, 0.03895760f, 0.05799428f, -0.00587858f, -0.05614799f, 
    0.00498046f, 0.04887211f, -0.03154184f, -0.01664011f, 0.03789545f, 0.02360416f, 0.03854349f, -0.02217391f, 
    -0.05772210f, -0.02728453f, -0.03233842f, -0.02715079f, -0.02497869f, -0.01434169f, 0.02163582f, -0.01623235f, 
    0.05010005f, 0.02887950f, -0.05562544f, 0.00785377f, -0.05586204f, -0.04748929f, -0.05643556f, 0.03570234f, 
    -0.02698011f, -0.03851174f, 0.00785895f, -0.03758263f, 0.03033555f, -0.06027126f, 0.01216545f, 0.03697013f, 
    -0.04840503f, 0.03766529f, -0.02777959f, -0.05173736f, -0.03966181f, 0.03241285f, -0.03700905f, -0.02583960f, 
    0.01801281f, -0.03597672f, -0.05512817f, 0.00355029f, -0.06108073f, 0.00953477f, -0.00863162f, 0.01932530f, 
    -0.00537892f, 0.04236496f, -0.00045597f, -0.00070268f, -0.04446907f, 0.02884671f, -0.06206609f, 0.01149385f, 
    0.00554082f, -0.00255891f, -0.02767300f, -0.05660591f, -0.02127401f, 0.00999708f, -0.05874173f, -0.05551210f, 
    0.04613771f, 0.04449103f, 0.03674184f, -0.00465537f, -0.01921240f, -0.00208324f, -0.02817481f, 0.04319162f, 
    -0.00555341f, 0.02226889f, 0.04473867f, -0.02485432f, 0.00820670f, 0.02339113f, -0.05602670f, 0.04303954f, 
    0.02376829f, -0.05855485f, 0.00667543f, 0.00019605f, 0.03305726f, -0.00163921f, -0.04332577f, 0.01722929f, 
    0.01321511f, 0.01389503f, 0.03128253f, 0.03271539f, 0.00449002f, -0.02099429f, -0.02230176f, 0.02876293f, 
    -0.04612801f, -0.03446217f, -0.04756957f, -0.04278491f, -0.02257804f, -0.06216916f, 0.03641589f, -0.03991955f, 
    0.00193198f, -0.00182112f, 0.03269596f, 0.01249115f, -0.02575888f, 0.02117754f, 0.04006230f, 0.01979067f, 
    -0.03051072f, 0.04305527f, 0.03291176f, -0.06483217f, 0.02000619f, -0.01841925f, -0.05215033f, -0.03607699f, 
    -0.33025098f, -0.05988273f, -0.24845584f, -0.11419041f, -0.07600568f, 0.09598619f, -0.02865487f, -0.08383024f, 
    -0.02128493f, 0.02967639f, 0.31039792f, 0.37123632f, 0.15107784f, 0.08506012f, -0.05580401f, 0.06476478f, 
    0.05795687f, 0.14882404f, 0.22492827f, -0.11538029f, 0.23174517f, 0.01533958f, 0.05730150f, 0.02654835f, 
    0.18751262f, 0.17230456f, 0.04877581f, 0.57904953f, -0.31419110f, 0.05006373f, -0.12976724f, 0.10520059f, 
    0.02909833f, 0.15388006f, 0.12707479f, -0.19142948f, -0.08323491f, 0.35133922f, 0.28226337f, -0.16748843f, 
    0.08888668f, 0.03454924f, 0.16216396f, -0.06529897f, 0.08501556f, -0.49174342f, -0.30720964f, 0.03570665f, 
    0.10250076f, 0.12264564f, 0.06495479f, 0.10775819f, 0.05663116f, 0.13593936f, -0.06660742f, 0.10279367f, 
    -0.26867530f, -0.24352361f, -0.05495716f, -0.10761698f, -0.01321999f, -0.06538789f, -0.02767146f, 0.06114912f, 
    -0.19768643f, -0.12138117f, 0.18191569f, -0.22096941f, 0.04163267f, 0.06546596f, 0.08484542f, 0.01206891f, 
    0.19349280f, 0.21238141f, -0.12902711f, 0.00270628f, 0.23023760f, 0.10195640f, -0.10106720f, 0.06529250f, 
    -0.08390454f, 0.08673387f, -0.16026869f, -0.07210363f, 0.08868375f, -0.24336068f, 0.00357838f, -0.07132436f, 
    -0.11087125f, 0.21324842f, -0.04484481f, -0.20425460f, -0.26496083f, 0.10191461f, 0.04160007f, 0.14152430f, 
    -0.15962178f, 0.11844169f, -0.31435588f, -0.55291229f, -0.01660662f, -0.04736366f, 0.00578420f, 0.04021977f, 
    -0.08319898f, 0.08383479f, -0.00689908f, -0.01272601f, -0.05608095f, 0.20711483f, 0.30891272f, -0.14140876f, 
    -0.00551611f, 0.20695552f, -0.04233459f, 0.16990332f, -0.12040179f, 0.10751554f, 0.23757228f, 0.39990035f, 
    -0.06708636f, 0.09564268f, 0.00540880f, -0.18573014f, -0.15195067f, -0.02183793f, 0.42879695f, -0.21927319f, 
    0.15109873f, -0.06147391f, 0.11341128f, -0.06605653f, 0.04357846f, 0.14676721f, -0.02318282f, 0.22137089f, 
    0.13023770f, -0.02598140f, -0.05115237f, 0.04264887f, 0.02246798f, 0.17852646f, -0.11123116f, 0.36876962f, 
    0.13386878f, -0.41630650f, -0.34552070f, -0.02235206f, -0.14140071f, 0.16587827f, 0.08725064f, -0.05610573f, 
    0.01969702f, 0.34476298f, -0.49835414f, 0.02441351f, -0.07945875f, 0.15466149f, -0.25903848f, 0.15441102f, 
    -0.08074985f, -0.02537610f, -0.80040276f, -0.13744721f, 0.00605178f, -0.08420692f, 0.15754087f, -0.06558952f, 
    -0.10233585f, -0.06936779f, -0.17873873f, -0.05961677f, 0.16361074f, 0.27971917f, 0.01329119f, 0.05251800f, 
    0.01404896f, -0.00329919f, -0.12667806f, 0.09460088f, -0.23210555f, -0.46763432f, -0.14833796f, -0.05040247f, 
    0.10557675f, -0.16859543f, 0.07694761f, -0.07883866f, -0.07229856f, -0.27140430f, -0.32688156f, -0.56859899f, 
    -0.13409685f, -0.02723976f, -0.01754378f, 0.16503190f, 0.00265588f, 0.11865917f, 0.12937061f, 0.30417183f, 
    0.16456340f, 0.04561139f, 0.25366178f, 0.10266545f, 0.10573184f, 0.07611796f, 0.09966464f, 0.42106852f, 
    0.05163679f, -0.19482176f, 0.03984462f, 0.12815572f, 0.21614982f, -0.19320606f, -0.09481864f, -0.06253914f, 
    0.16079274f, -0.21933219f, -0.23074889f, -0.23620179f, 0.06190746f, 0.12664557f, 0.10664465f, -0.20314096f, 
    -0.11468801f, 0.25374621f, -0.21433091f, -0.10064303f, 0.01313125f, -0.01391695f, 0.07334834f, 0.16005473f, 
    -0.24822284f, 0.06569425f, -0.30072024f, -0.59601438f, 0.13079251f, -0.07667406f, -0.08717805f, 0.05186864f, 
    0.12201333f, -0.01700122f, -0.03343130f, -0.34099159f, 0.32398781f, 0.35137919f, -0.08803736f, 0.15542480f, 
    -0.05303239f, 0.26705217f, 0.06228223f, 0.05144690f, -0.42960012f, -0.21516821f, -0.04053101f, -0.10317301f, 
    0.03407481f, 0.18206941f, -0.00379620f, -0.10380809f, -0.07582825f, 0.11607764f, 0.37840882f, -0.25739712f, 
    -0.18285225f, -0.17987451f, -0.16539305f, 0.12772340f, 0.16156945f, 0.00959135f, -0.29529914f, -0.10701641f, 
    -0.30623534f, -0.10651202f, 0.08053263f, 0.23778883f, 0.03981310f, 0.12501200f, -0.05790720f, 0.45902598f, 
    0.07838601f, -0.02834390f, 0.15437596f, 0.20536625f, 0.09621064f, 0.16506398f, 0.06877636f, 0.00354950f, 
    -0.09338103f, -0.02315206f, 0.06443913f, 0.09500588f, 0.03764787f, -0.16424482f, 0.00308498f, 0.19462356f, 
    -0.24424751f, 0.14893563f, 0.05263543f, -0.14500791f, -0.01436004f, 0.05944379f, -0.02532912f, 0.09494466f, 
    0.10938577f, 0.15009594f, -0.37284294f, 0.09491625f, -0.18098743f, -0.05553479f, -0.14620265f, 0.04808465f, 
    -0.03639658f, 0.06241849f, -0.20362554f, -0.27129430f, 0.16320260f, -0.31649786f, -0.06563258f, -0.02979762f, 
    -0.00981908f, 0.04360505f, -0.15157010f, -0.00771448f, -0.14475967f, 0.21935503f, -0.15187570f, 0.01967248f, 
    -0.02381843f, 0.05997161f, -0.02600192f, -0.00581051f, 0.12425454f, -0.23200731f, 0.00611701f, 0.29848859f, 
    -0.02724925f, 0.02891566f, 0.11333644f, 0.16448389f, -0.15337807f, -0.04031968f, -0.71891081f, -0.27773193f, 
    0.06963956f, 0.10737481f, 0.07774384f, 0.14816131f, -0.15574792f, -0.17905748f, -0.20615232f, -0.05761134f, 
    -0.22602765f, -0.07501309f, 0.24228446f, 0.02470860f, -0.20277357f, 0.03710292f, 0.21275760f, 0.04285561f, 
    -0.26312876f, -0.11698924f, -0.03296888f, -0.02626744f, 0.07243074f, -0.00854837f, 0.04746507f, -0.09856358f, 
    0.14510036f, 0.32757056f, 0.18742424f, 0.05300334f, 0.20745692f, 0.16583645f, -0.25825354f, 0.19295497f, 
    -0.04538508f, -0.08792605f, 0.20127359f, 0.04870016f, -0.10588191f, -0.04842241f, 0.04411934f, 0.11371883f, 
    0.09408391f, -0.03118682f, -0.26536554f, 0.42153397f, 0.48478663f, 0.12579025f, 0.13779943f, -0.06737105f, 
    0.13229769f, -0.02461509f, 0.06089391f, -0.10059503f, -0.19836438f, -0.00636248f, 0.30122837f, 0.20458627f, 
    -0.04938741f, -0.24058293f, 0.03817366f, -0.14302921f, 0.28584427f, -0.23144327f, -0.09035373f, -0.20253271f, 
    0.09719554f, 0.15892774f, 0.15301472f, -0.30845249f, -0.04830908f, -0.05503248f, -0.12754840f, -0.28691933f, 
    -0.40532419f, -0.06502704f, 0.05476525f, 0.06228187f, -0.22105896f, 0.01565422f, 0.07924088f, -0.24512590f, 
    -0.51172489f, -0.23011613f, -0.07120638f, 0.07167230f, 0.18579271f, -0.17646480f, -0.15022916f, 0.26493946f, 
    0.40001059f, 0.22696070f, 0.18093359f, -0.14362070f, -0.05020594f, -0.09643875f, 0.16555759f, 0.23965509f, 
    0.13087228f, -0.53147125f, -0.59142953f, -0.15946098f, -0.00157894f, 0.15292072f, 0.02714529f, 0.20287861f, 
    0.23598310f, -0.11225992f, -0.28032005f, -0.06082452f, 0.48615780f, -0.15176268f, 0.13057069f, -0.15764992f, 
    0.00771657f, -0.03290172f, 0.01667731f, -0.03350409f, -0.06047010f, 0.10279793f, 0.08949752f, -0.08276927f, 
    0.06570477f, -0.22324269f, 0.02530245f, 0.21378246f, -0.20564356f, -0.48775893f, 0.17294157f, -0.04616861f, 
    0.23703064f, 0.10946929f, 0.17551962f, -0.12433171f, -0.18018931f, 0.06271511f, 0.13934948f, -0.06007902f, 
    0.21816342f, -0.06646266f, 0.13130309f, 0.10486497f, -0.06821836f, 0.07761558f, -0.13907701f, 0.13155028f, 
    -0.54368979f, -0.11397594f, 0.05686561f, 0.16070801f, -0.16285115f, -0.12546282f, -0.26026586f, -0.30318415f, 
    -0.21400477f, 0.00881006f, -0.13394603f, 0.15593790f, 0.10931687f, 0.18284619f, -0.01649554f, -0.18618062f, 
    0.08138686f, -0.06890824f, -0.23623918f, -0.03642226f, 0.13259554f, -0.07316103f, 0.16740634f, -0.06840089f, 
    -0.20564222f, 0.17584138f, 0.09699898f, 0.20151567f, 0.16795096f, 0.17055772f, -0.40912220f, 0.14032993f, 
    0.00979558f, 0.16714184f, 0.20801125f, 0.08053043f, 0.04421857f, -0.07248957f, 0.03790263f, -0.04450823f, 
    -0.00736406f, 0.04797937f, 0.22195821f, -0.08854811f, 0.21404113f, -0.06720752f, 0.01152328f, 0.03357873f, 
    0.00624853f, -0.04140906f, 0.08213374f, 0.27590305f, 0.67056561f, 0.30754507f, -0.09058043f, 0.11860941f, 
    0.04538830f, 0.01667021f, 0.03484809f, -0.07129036f, -0.06935189f, 0.17652202f, 0.22456363f, 0.05717915f, 
    -0.02562646f, -0.21392351f, 0.30177686f, 0.08691179f, 0.23523287f, -0.13985468f, 0.22844572f, -0.15243348f, 
    -0.22716418f, -0.01998242f, 0.16920410f, 0.23430957f, -0.02717738f, -0.02450551f, 0.15955816f, 0.11548430f, 
    0.17878313f, -0.09711809f, 0.12448369f, 0.17604378f, -0.11449742f, 0.00114315f, -0.01064322f, 0.23446642f, 
    0.02851885f, 0.07758727f, 0.11975156f, -0.07215357f, -0.23940478f, -0.01865871f, 0.21771042f, 0.06734548f, 
    0.13391942f, -0.44119120f, 0.01561879f, -0.34742218f, 0.12924437f, -0.12752359f, 0.06285241f, 0.21108258f, 
    -0.02255058f, 0.34037855f, 0.22654022f, 0.11827032f, 0.00697279f, 0.05117596f, 0.32038909f, -0.02278103f, 
    0.11842545f, 0.12755866f, -0.18279903f, 0.32896650f, 0.45461282f, -0.37262309f, 0.08199882f, 0.15538709f, 
    0.08278281f, 0.24013495f, 0.15261915f, -0.26950106f, -0.55412680f, 0.17536977f, -0.24287383f, 0.02569239f, 
    -0.03881964f, 0.09528142f, -0.05415565f, 0.01250208f, 0.11400104f, 0.20578408f, -0.03830351f, -0.09290575f, 
    -0.08314968f, -0.08649483f, 0.10310085f, 0.00041236f, -0.02387683f, -0.03025883f, 0.28687879f, -0.33332357f, 
    -0.30650574f, 0.29739043f, 0.28298753f, 0.07239480f, -0.14407122f, -0.00990003f, 0.05621732f, 0.84809762f, 
    -0.09909254f, -0.42658004f, -0.03184320f, 0.08042843f, 0.00423452f, -0.07808947f, 0.07761510f, 0.32967380f, 
    -0.20036347f, 0.07772958f, 0.05293533f, 0.16373989f, 0.12117681f, -0.08268813f, 0.00158602f, 0.21528654f, 
    -0.17810504f, 0.04857194f, 0.18634999f, -0.06807838f, -0.28119192f, -0.36969301f, 0.02858302f, -0.13283540f, 
    -0.02910178f, 0.06728707f, -0.12819853f, -0.06907140f, -0.29911789f, -0.09458568f, -0.08222865f, 0.14654812f, 
    -0.05835635f, -0.21740532f, 0.20135795f, -0.08625861f, -0.12877081f, 0.08194938f, -0.36204028f, 0.00980290f, 
    0.09409452f, -0.11891533f, 0.10336698f, 0.05433177f, -0.28147346f, 0.00608273f, -0.00080215f, -0.04532591f, 
    0.13523464f, 0.03796057f, -0.35241169f, 0.09649750f, -0.18120764f, 0.16414656f, 0.54438764f, -0.16794395f, 
    0.02913932f, 0.19084969f, -0.00621224f, 0.11624473f, -0.00722687f, -0.27286702f, 0.34317678f, -0.14749818f, 
    -0.27980724f, -0.15614025f, 0.09348927f, 0.08071558f, 0.00359307f, 0.23499708f, -0.12595762f, 0.13185416f, 
    0.35125548f, -0.06706643f, 0.15321028f, -0.00397615f, 0.00755091f, -0.06209698f, 0.20705873f, -0.00208795f, 
    0.45647627f, 0.08962748f, 0.20916262f, -0.17361541f, -0.33132017f, 0.01657204f, 0.09133439f, 0.06618551f, 
    -0.13360450f, 0.54029632f, -0.75262916f, -0.11302974f, -0.07428002f, 0.05343314f, -0.12742130f, -0.19516400f, 
    0.05998069f, 0.06028069f, -0.96824104f, -0.02812638f, 0.06014692f, -0.17936359f, 0.10538950f, -0.26727599f, 
    0.06692897f, -0.12297849f, 0.14145786f, 0.20774186f, 0.18962604f, -0.15237246f, -0.08547108f, 0.13442518f, 
    0.25183478f, -0.21199685f, -0.02965221f, -0.03659122f, 0.30999571f, -0.06216450f, -0.23221166f, -0.25576192f, 
    0.19215271f, 0.25210828f, -0.14262876f, -0.10899809f, -0.28783822f, 0.58332682f, -0.01203445f, -0.14490190f, 
    -0.26237822f, -0.12698150f, -0.01785616f, -0.36604673f, 0.16662996f, 0.07933611f, 0.38315845f, -0.08824977f, 
    -0.27610466f, 0.18646756f, 0.15850960f, 0.10889311f, -0.26066941f, -0.17474502f, -0.02641105f, 0.39910772f, 
    -0.13856509f, -0.05249423f, 0.14772490f, 0.16028844f, 0.07670712f, -0.43254066f, -0.07383332f, 0.02012664f, 
    -0.58855516f, 0.17839357f, -0.00987570f, -0.14798149f, 0.06485631f, -0.40669972f, -0.10020034f, 0.23847841f, 
    -0.09101972f, 0.72218108f, 0.04345411f, 0.00151233f, -0.07329565f, -0.26453519f, 0.13732705f, -0.07427327f, 
    0.01867848f, 0.14706409f, 0.48321795f, 0.13541499f, 0.13044177f, -0.13804103f, -0.15449572f, 0.23576967f, 
    0.08155327f, 0.08997502f, -0.07926440f, -0.53219247f, -0.11464824f, 0.02384761f, 0.08452961f, 0.15692723f, 
    0.02041800f, -0.21155760f, 0.23126973f, -0.08711503f, 0.30661243f, 0.22198004f, 0.10097483f, -0.12560239f, 
    -0.02642505f, 0.01887277f, 0.17216434f, -0.01705807f, 0.08529624f, -0.04789307f, -0.69032466f, 0.10520795f, 
    -0.08638377f, -0.12594253f, -0.13996884f, 0.01756881f, 0.04640738f, 0.02517994f, -0.02136675f, -0.56112862f, 
    -0.00695273f, 0.04049340f, -0.08569973f, 0.02144477f, -0.06887300f, 0.30766734f, 0.05461833f, -0.15903051f, 
    -0.06827435f, -0.00734222f, 0.03839767f, 0.01745201f, 0.19773616f, 0.16244537f, 0.11624061f, 0.15126719f, 
    -0.05790170f, 0.02993796f, -0.02171519f, 0.02936383f, 0.00461940f, -0.01286164f, 0.01078173f, -0.06664638f, 
    -0.00905550f, 0.02090503f, 0.01759017f, 0.00135536f, 0.03461629f, 0.04929158f, -0.04617075f, 0.00282270f, 
    -0.01912822f, -0.05273904f, -0.01115821f, 0.03709390f, 0.04713197f, -0.03931280f, -0.00160280f, 0.04730268f, 
    -0.01637032f, -0.01163643f, 0.04184448f, 0.01748431f, -0.01662091f, 0.04531729f, -0.05498109f, -0.05720146f, 
    0.02135670f, -0.05151502f, -0.06423968f, -0.00465282f, -0.01819598f, -0.03818399f, 0.00732960f, 0.03771092f, 
    0.02330693f, 0.00220280f, -0.02291951f, 0.04079743f, -0.01346082f, -0.05123882f, 0.00356166f, -0.03617256f, 
    0.01097191f, -0.01292803f, -0.05846630f, -0.06533892f, -0.04171242f, -0.04552615f, 0.01194210f, 0.03966920f, 
    -0.02690414f, -0.01467941f, 0.02196734f, 0.00842913f, 0.03632408f, 0.04560823f, -0.05567066f, -0.04136922f, 
    -0.02878003f, 0.04291845f, 0.01416531f, 0.00862850f, -0.00262069f, -0.04863711f, -0.05483883f, 0.02024293f, 
    -0.04172018f, -0.05413804f, -0.02676068f, 0.02171758f, -0.00584334f, -0.01292928f, 0.04354674f, -0.02182934f, 
    -0.01411499f, 0.01368139f, 0.03536744f, 0.01521540f, 0.04795510f, 0.01265342f, -0.02642059f, 0.00005407f, 
    -0.04962544f, -0.01522580f, -0.04319439f, -0.02613972f, -0.01899424f, 0.02744904f, -0.06019755f, -0.04820768f, 
    0.04014204f, 0.02083853f, -0.04786896f, 0.01849270f, -0.05082936f, -0.05015708f, -0.01701826f, 0.02390636f, 
    0.02329391f, -0.04831196f, 0.01627774f, -0.05397757f, 0.04322690f, 0.00045263f, -0.00257457f, -0.03023418f, 
    0.03532081f, 0.02464945f, 0.02605950f, 0.00825417f, 0.04164232f, 0.01602991f, -0.01865607f, 0.05011698f, 
    -0.05267081f, -0.06528246f, 0.04180575f, -0.04608748f, -0.02106703f, -0.02458435f, -0.02600641f, 0.04808684f, 
    0.01066449f, 0.04434642f, 0.04457519f, -0.00099351f, -0.06102655f, 0.04809888f, 0.03181067f, 0.00976045f, 
    -0.02220098f, 0.01712216f, -0.02470408f, -0.01037608f, 0.02224288f, 0.00721342f, -0.05041124f, 0.05140556f, 
    0.02034425f, -0.07357762f, 0.01744107f, -0.03042064f, 0.03120664f, -0.02553204f, -0.06029963f, -0.02981772f, 
    -0.06226048f, 0.00130958f, -0.05389958f, -0.04675322f, -0.01156469f, -0.05773164f, -0.03731051f, -0.06242110f, 
    -0.04176248f, -0.00563670f, -0.06371275f, -0.01976619f, 0.00377636f, -0.00212848f, 0.01503385f, -0.00734353f, 
    0.02637588f, -0.01538900f, -0.05915506f, 0.02780188f, 0.00488104f, -0.03194930f, 0.00932136f, -0.05557172f, 
    -0.01256780f, -0.02319164f, -0.01770192f, 0.00622996f, 0.04105204f, -0.02045347f, -0.05672056f, 0.01433522f, 
    0.02255828f, 0.03983644f, -0.03504777f, 0.02644017f, -0.02217028f, -0.03909211f, 0.02191251f, -0.00137878f, 
    0.00781989f, -0.03690722f, 0.02468576f, -0.04521270f, 0.04851782f, -0.05232540f, 0.00788606f, -0.04823919f, 
    -0.03079356f, -0.05503171f, -0.02777441f, -0.02255199f, -0.04324247f, 0.05412433f, 0.03148973f, -0.01375889f, 
    -0.02769158f, 0.00607492f, -0.02244921f, 0.00936919f, -0.06130471f, 0.01023935f, 0.01059133f, 0.00090781f, 
    0.03214374f, 0.01722804f, -0.02029380f, -0.02180691f, 0.03517891f, -0.03981153f, 0.04338278f, -0.01829202f, 
    -0.00338082f, -0.01272203f, 0.01243559f, -0.01939446f, -0.04837390f, -0.06046890f, 0.05285353f, -0.02597862f, 
    -0.01960836f, -0.01034296f, -0.01626492f, 0.02812978f, 0.04549170f, -0.01800470f, 0.05153186f, -0.05410284f, 
    -0.06344521f, 0.02700302f, 0.00041789f, 0.04076589f, -0.05559700f, 0.04537411f, 0.03516652f, -0.01515903f, 
    -0.00278141f, 0.03899782f, 0.03990361f, -0.03347937f, 0.00388177f, -0.03824000f, 0.02833863f, 0.01107481f, 
    -0.05842081f, 0.03238271f, 0.04596034f, -0.00803839f, -0.04588280f, -0.01688542f, -0.04585248f, -0.06662024f, 
    -0.02398846f, 0.02112263f, 0.02948434f, 0.00027476f, -0.04922622f, -0.03805663f, 0.04683612f, 0.03487708f, 
    0.01176603f, 0.05539829f, 0.01429514f, -0.05085226f, 0.02625387f, 0.03258869f, -0.03513591f, 0.00664536f, 
    0.05132475f, -0.00962582f, 0.05031651f, -0.04532154f, -0.01259289f, 0.02094432f, -0.02092529f, -0.02488302f, 
    0.00207604f, 0.03470160f, -0.01584213f, -0.06565046f, 0.01545245f, -0.00204203f, -0.02959684f, -0.04075560f, 
    0.01073371f, -0.06685556f, 0.01556578f, 0.02401379f, 0.04756075f, 0.00024444f, -0.00437996f, -0.03162647f, 
    -0.01806185f, 0.02463878f, -0.01444066f, -0.00208903f, -0.04173431f, -0.04062582f, -0.00976621f, 0.01401310f, 
    -0.00221463f, -0.03013666f, 0.04483560f, 0.00865474f, -0.01537284f, -0.02375040f, 0.03401535f, -0.03099591f, 
    0.02616856f, -0.01891719f, -0.01828168f, -0.03004531f, 0.04397387f, -0.01894960f, 0.03084306f, -0.02855906f, 
    -0.00583327f, -0.04034412f, 0.02718216f, 0.01274834f, -0.06239367f, 0.01550627f, 0.03587470f, 0.01455816f, 
    -0.03073255f, -0.01983637f, 0.00726320f, -0.05653309f, -0.05662942f, -0.04788931f, -0.02564608f, -0.01327591f, 
    -0.02686433f, -0.03983939f, -0.02968797f, 0.04198157f, 0.01409535f, -0.05758158f, -0.04418255f, -0.00389080f, 
    -0.01920421f, -0.06295576f, 0.02937334f, -0.01974401f, 0.04157370f, 0.00709919f, 0.02821707f, -0.03715922f, 
    0.04792648f, -0.05338039f, 0.03771705f, 0.04668658f, 0.02017871f, -0.04245362f, -0.04496877f, -0.02136559f, 
    0.01278704f, -0.03926858f, -0.02016723f, 0.02989109f, 0.02291029f, 0.01752320f, -0.04493884f, 0.00797823f, 
    0.05250761f, 0.01068996f, -0.03667145f, -0.03269335f, -0.03888243f, 0.00848606f, 0.05108915f, 0.04711827f, 
    -0.01499149f, 0.03118752f, -0.05590126f, -0.01452928f, -0.02661661f, 0.01150026f, -0.02678469f, -0.06660149f, 
    0.01705563f, -0.04106773f, -0.06119228f, 0.04566457f, -0.05543109f, 0.04087542f, -0.06297495f, 0.02302941f, 
    0.04643627f, -0.06849563f, -0.00480850f, -0.05604349f, 0.02125824f, -0.02141006f, -0.03800429f, 0.00242577f, 
    -0.05776884f, -0.00305484f, -0.03987332f, 0.04788694f, 0.01384298f, -0.00712381f, -0.03548902f, 0.01949157f, 
    -0.03435000f, -0.00912732f, 0.00915084f, -0.02136373f, -0.05986108f, 0.02864253f, 0.04701646f, 0.01679930f, 
    -0.00056362f, 0.04097042f, -0.01943264f, 0.03819488f, 0.00555543f, -0.06546332f, 0.03967404f, -0.00082964f, 
    -0.04529980f, -0.03910980f, 0.00709056f, -0.04599985f, 0.00606863f, 0.04667356f, -0.05872959f, -0.02134984f, 
    0.01001474f, -0.05330938f, -0.00746335f, -0.03288427f, 0.00206299f, -0.03523760f, -0.05039841f, 0.01265207f, 
    0.01614890f, -0.05521892f, 0.01076798f, -0.03344098f, -0.01203989f, -0.01552746f, 0.02307877f, 0.01414176f, 
    0.03809730f, -0.01828209f, -0.03568197f, -0.04401734f, -0.02005314f, 0.04514048f, -0.00033023f, 0.02460631f, 
    -0.05003796f, -0.03904751f, -0.01270922f, 0.00463221f, 0.02002385f, -0.03855269f, 0.00407867f, -0.06895720f, 
    0.02287410f, -0.00454662f, 0.02979554f, -0.02959663f, 0.02778743f, 0.02759255f, -0.03440243f, 0.02146279f, 
    -0.04458826f, -0.00438308f, -0.01715861f, -0.03506513f, -0.01722351f, -0.04500138f, -0.01575785f, 0.01853707f, 
    -0.00122627f, -0.03357387f, -0.03198477f, 0.01122469f, 0.04838461f, -0.03071964f, 0.02611398f, 0.00688670f, 
    -0.01922708f, 0.03381522f, -0.03828946f, -0.04137587f, -0.04821248f, -0.01367126f, -0.02295164f, 0.01118650f, 
    -0.03369656f, 0.01993938f, 0.04761489f, 0.00253658f, -0.06465495f, 0.04469723f, -0.00173912f, 0.05005300f, 
    -0.05262810f, -0.02949032f, -0.05572226f, -0.06924116f, -0.02382919f, -0.04151204f, -0.02963190f, -0.01572034f, 
    -0.01082851f, -0.06766507f, 0.04256355f, -0.02512898f, 0.02784260f, 0.04848129f, 0.01205829f, 0.03952603f, 
    0.03057633f, -0.01410596f, 0.03165764f, 0.01874704f, 0.03922019f, -0.04021519f, 0.03469383f, -0.00924953f, 
    -0.02159267f, 0.03664124f, 0.04173227f, -0.06787595f, 0.05846075f, 0.05816692f, 0.05204398f, -0.04929074f, 
    0.00119747f, 0.03555214f, 0.01347383f, 0.00645667f, -0.04141814f, 0.00609000f, 0.03364164f, 0.05083429f, 
    -0.00841889f, 0.04681806f, -0.01094775f, 0.03175935f, -0.04172498f, -0.04807245f, -0.00901340f, 0.02794513f, 
    -0.04929936f, 0.00366835f, -0.01201639f, 0.03926174f, -0.04770493f, 0.03379530f, 0.01705978f, -0.01708175f, 
    0.02084612f, 0.03143845f, -0.02577788f, 0.00742421f, -0.02513754f, 0.01671621f, -0.05384591f, -0.05091684f, 
    0.31278405f, 0.17059825f, -0.50200504f, 0.18030067f, -0.18513055f, 0.00261967f, 0.10902063f, -0.07216965f, 
    -0.15147518f, -0.10144910f, -0.08679192f, 0.03858242f, 0.05635595f, 0.10592345f, 0.08166980f, 0.09745087f, 
    0.10759997f, -0.01213055f, 0.02948987f, 0.11410061f, 0.19511423f, -0.14504051f, 0.02659567f, -0.09557008f, 
    0.15173788f, -0.02204457f, -0.02360839f, -0.16599503f, -0.35201296f, -0.39078271f, -0.00479966f, -0.06531377f, 
    -0.15653080f, 0.02432912f, -0.10337847f, 0.02305089f, 0.24337614f, 0.18940422f, 0.17321792f, 0.01577616f, 
    0.15058608f, 0.31893826f, -0.15825395f, 0.23980784f, 0.08106583f, 0.13256399f, 0.06965152f, -0.17274465f, 
    -0.09681908f, -0.12801248f, 0.03063858f, -0.12946825f, 0.16844305f, 0.12163356f, 0.02762068f, -0.20824040f, 
    -0.34095833f, -0.02866865f, 0.11777627f, 0.02868448f, 0.01824131f, 0.00918378f, -0.24525815f, 0.02158410f, 
    0.34588039f, -0.45364496f, -0.17633460f, 0.11977843f, 0.01176459f, 0.19717979f, -0.16389018f, 0.01831278f, 
    0.29365966f, 0.20092623f, 0.05147837f, 0.27127343f, 0.14427669f, -0.02182325f, 0.02152597f, 0.30746838f, 
    0.18846345f, 0.33282697f, 0.14150536f, -0.32308477f, -0.09827843f, -0.09052145f, -0.06487194f, 0.11071858f, 
    -0.03675346f, -0.02633012f, -0.16147509f, -0.44705701f, -0.19628766f, 0.09690887f, 0.11374325f, 0.06073863f, 
    0.02303832f, -0.04343088f, -0.02332640f, -0.71755630f, -0.16395919f, -0.09662926f, -0.17478429f, 0.01903586f, 
    -0.05265876f, -0.02626581f, -0.05953250f, 0.09548099f, 0.18988581f, 0.28778449f, 0.14983390f, 0.01530610f, 
    0.19383222f, -0.20142561f, -0.01966387f, 0.06697758f, -0.00236084f, -0.03839415f, -0.02346165f, -0.22854526f, 
    -0.08052453f, 0.18128468f, 0.19462633f, -0.06634442f, 0.06416146f, 0.15925756f, 0.10882273f, 0.09784356f, 
    -0.14132570f, -0.06346816f, -0.10292142f, 0.03527889f, 0.26552808f, 0.27405617f, 0.12680957f, 0.16427040f, 
    0.18497813f, 0.03666659f, -0.16266178f, 0.20139904f, -0.02485191f, -0.13371518f, 0.23740193f, 0.02640094f, 
    -0.46698216f, -0.31832358f, -0.14275664f, 0.04480337f, -0.05241948f, -0.04048866f, 0.14672877f, -0.11503809f, 
    0.02238163f, -0.66536206f, 0.07484332f, 0.32678422f, 0.21602784f, -0.02441385f, -0.10653629f, -0.07948847f, 
    -0.01779039f, -0.01885239f, 0.98390043f, -0.01717575f, -0.31684038f, -0.01879305f, -0.16641971f, 0.00431478f, 
    -0.02041330f, -0.19962031f, 0.13852631f, -0.31966138f, 0.03911316f, 0.14391580f, 0.06267272f, 0.00391348f, 
    0.06430041f, -0.13403910f, -0.22825834f, 0.02964729f, -0.62983459f, 0.21407968f, 0.07573353f, 0.04871244f, 
    -0.11528122f, -0.01140188f, -0.14741080f, 0.01054992f, 0.01629234f, 0.21821570f, -0.77701545f, -0.11306013f, 
    -0.15200610f, 0.11825187f, 0.00540377f, 0.05399133f, 0.08174712f, 0.16168772f, 0.15172775f, -0.60404271f, 
    0.29573882f, 0.17849448f, 0.00910673f, 0.14698997f, -0.05119497f, 0.02410520f, 0.10668271f, -0.19209351f, 
    -0.04999471f, -0.08106722f, -0.04205761f, 0.15740053f, 0.09064954f, -0.13604604f, 0.08666041f, -0.07129164f, 
    -0.86499929f, -0.17240064f, 0.13846816f, 0.13704057f, -0.15126806f, -0.13037045f, 0.01955864f, -0.03751587f, 
    -0.00876715f, 0.04357535f, -0.10995187f, -0.34422693f, 0.13067010f, -0.14923814f, -0.10620733f, 0.11421470f, 
    -0.13064410f, -0.10071715f, -0.22040124f, 0.07870006f, -0.15710638f, 0.05268088f, -0.39994523f, -0.03667921f, 
    -0.01391799f, -0.28491181f, -0.06476746f, 0.07353819f, 0.07834036f, 0.16470230f, -0.10155069f, 0.25950050f, 
    -0.10606294f, -0.19543223f, 0.06431910f, 0.11170837f, -0.03916300f, -0.48286965f, -0.21612817f, -0.14440061f, 
    -0.10949523f, -0.26814631f, -0.08422109f, -0.04822088f, -0.00801424f, -0.25581408f, -0.37808990f, 0.09045322f, 
    -0.09710794f, 0.06800370f, 0.16511831f, 0.11219783f, 0.00484071f, 0.03436023f, -0.14941981f, 0.18451455f, 
    -0.01476958f, -0.02878842f, 0.10539652f, 0.16747212f, 0.06388851f, -0.14094988f, 0.07084135f, 0.10280072f, 
    -0.04198359f, 0.13462290f, 0.15025704f, 0.06719988f, -0.09302366f, 0.14431790f, 0.18975566f, 0.04533423f, 
    0.44087103f, 0.13215312f, 0.23726761f, -0.09977831f, -0.07267214f, -0.07378095f, -0.14560041f, 0.21177343f, 
    0.03824356f, 0.18859884f, 0.01542563f, 0.03831459f, -0.07658050f, -0.07596043f, 0.03695294f, -0.05450834f, 
    0.02105666f, 0.20884962f, -0.30176598f, 0.23186399f, 0.07305135f, -0.02027022f, 0.01418728f, 0.08370010f, 
    -0.16512555f, 0.04365455f, -0.11357189f, 0.24307023f, -0.06413782f, -0.27695620f, -0.09425342f, -0.31539744f, 
    -0.13802889f, -0.05043234f, -0.14444029f, -0.07287937f, -0.26803383f, -0.02435506f, 0.22036646f, -0.00037854f, 
    0.08958044f, 0.01085444f, 0.04223708f, -0.02479503f, 0.10303353f, -0.02339921f, 0.06973135f, -0.03399900f, 
    0.12833126f, 0.08909675f, -0.09719439f, 0.12543033f, -0.14573407f, 0.09908856f, -0.02203224f, 0.01571065f, 
    -0.04107054f, -0.21083641f, -0.18553428f, 0.11481498f, 0.05565515f, 0.20062941f, -0.36938399f, -0.18248092f, 
    -0.13782993f, -0.04761260f, 0.09436954f, 0.11822043f, 0.14353885f, -0.01557665f, -0.04001911f, -0.15988673f, 
    0.25073522f, -0.07560731f, -0.12705001f, 0.15709087f, -0.02807006f, 0.05930462f, 0.00574233f, 0.03287186f, 
    -0.06490873f, 0.03312086f, -0.24421193f, 0.08948341f, -0.10312532f, -0.10994812f, 0.08219591f, 0.00201565f, 
    -0.03022997f, 0.08931489f, -0.51705056f, -0.07715107f, 0.24291693f, 0.26935354f, 0.17481817f, -0.10376614f, 
    0.05265983f, -0.18206607f, -0.13677803f, -0.40882590f, -0.01544897f, 0.16772342f, 0.13503739f, 0.09044646f, 
    -0.00620005f, 0.09636164f, -0.03113265f, 0.08919666f, -0.36066383f, -0.23682061f, -0.02172784f, -0.01147008f, 
    -0.04752288f, -0.06179568f, 0.01476326f, 0.03690636f, -0.07264312f, -0.10185491f, 0.24198040f, 0.14629135f, 
    -0.22810408f, 0.09192353f, -0.04547691f, 0.15612230f, -0.03773798f, 0.09767886f, -0.02391681f, -0.32614464f, 
    -0.19448604f, -0.12436127f, 0.04914938f, 0.20123354f, 0.06704963f, -0.06612626f, 0.19798324f, -0.06847885f, 
    0.00330721f, 0.14923219f, -0.08387727f, 0.06189175f, -0.14817218f, 0.12274536f, 0.30489993f, 0.08993967f, 
    -0.56163830f, -0.16648565f, 0.22613746f, -0.05111049f, -0.00518885f, 0.07229768f, 0.00202767f, -0.02627451f, 
    0.06003046f, -0.07205349f, -0.10293470f, 0.10500716f, 0.08138697f, -0.03440268f, 0.02803267f, -0.02835339f, 
    0.05378240f, -0.09259435f, 0.04921826f, 0.01174812f, -0.41257033f, 0.15400946f, -0.02284017f, -0.04768109f, 
    -0.05639682f, -0.12118323f, 0.11212128f, -0.09120554f, -0.13612160f, -0.05390646f, 0.03060553f, -0.16557789f, 
    0.07421634f, 0.11440894f, -0.09402759f, -0.00772015f, 0.05150607f, -0.08712859f, -0.11707330f, -0.18415755f, 
    0.00575059f, -0.04059554f, 0.14465474f, -0.16959167f, 0.08165323f, 0.06044107f, -0.43061981f, 0.22159897f, 
    -0.09831978f, 0.12627237f, 0.05494343f, -0.21862711f, 0.18953356f, 0.13684684f, -0.07173397f, 0.33935800f, 
    0.26959312f, 0.10045960f, -0.10925413f, -0.00158823f, -0.00564790f, -0.12419992f, -0.09536583f, 0.14030622f, 
    0.17711458f, -0.05497281f, -0.07610159f, 0.32023564f, -0.04065906f, -0.11141992f, -0.18305968f, 0.12358572f, 
    -0.32943287f, 0.14650837f, 0.23718180f, 0.01547434f, 0.10192125f, -0.26493940f, 0.20990720f, -0.15913880f, 
    -0.09563632f, 0.07496507f, -0.28785977f, -0.15188330f, -0.19371697f, -0.00051850f, -0.09922551f, 0.19466349f, 
    0.01582188f, 0.07198422f, -0.21778679f, -0.02928540f, 0.27285880f, -0.15476236f, -0.05965868f, -0.15543602f, 
    0.10414456f, 0.02672575f, -0.02115637f, -0.18435393f, 0.19659378f, 0.30055192f, 0.19103074f, 0.26578593f, 
    0.01158275f, 0.09490351f, 0.27309749f, 0.12098713f, -0.76716411f, -0.20030117f, 0.08693631f, 0.11129562f, 
    0.21695831f, -0.03571225f, -0.04975920f, -0.07245761f, 0.05527907f, -0.15754573f, 0.15685916f, 0.17224434f, 
    0.15594505f, -0.14820774f, 0.26330644f, 0.02809910f, 0.06176725f, -0.15505432f, 0.14109826f, -0.01296692f, 
    0.30799675f, -0.00911296f, -0.01835904f, 0.04678378f, 0.12495898f, -0.15656358f, -0.10701478f, 0.39171952f, 
    -0.01227383f, -0.20335689f, -0.23298974f, -0.15502240f, -0.08775418f, 0.19227916f, 0.04078191f, 0.14648747f, 
    -0.02671257f, 0.04910935f, -0.05991696f, 0.02843500f, -0.05691211f, -0.01176496f, 0.03997278f, 0.02447387f, 
    -0.01825312f, -0.05991847f, 0.01758674f, -0.04059249f, -0.00692727f, -0.00561862f, -0.00853268f, 0.00873724f, 
    0.04446960f, 0.04676454f, -0.05537097f, 0.05250607f, 0.01486617f, 0.00866044f, 0.00254250f, -0.03506780f, 
    -0.00071337f, -0.02286748f, -0.03941516f, -0.04009094f, 0.01910135f, 0.04101944f, -0.03408391f, 0.01267293f, 
    0.01174502f, -0.01720935f, -0.06300358f, 0.02998273f, -0.02319102f, 0.02882040f, 0.04983090f, -0.01858877f, 
    0.01818902f, -0.04661022f, -0.03359592f, 0.00707841f, -0.02181304f, 0.04037651f, -0.03375576f, -0.00143267f, 
    0.04894852f, -0.01166291f, 0.03264586f, 0.00418980f, 0.01016829f, -0.02442694f, 0.00016298f, -0.01168788f, 
    -0.00197503f, -0.01452617f, -0.02040363f, -0.04575996f, -0.05982433f, -0.04589239f, -0.06185056f, 0.00133948f, 
    -0.06507947f, 0.03981622f, 0.00692405f, -0.04811852f, 0.01172376f, -0.01979150f, -0.01079356f, -0.03673889f, 
    0.03300228f, 0.03302630f, -0.02969893f, 0.03844960f, 0.00892194f, 0.02372516f, 0.04669359f, -0.06643936f, 
    -0.06465957f, -0.06471979f, 0.00257783f, -0.00055386f, 0.04208282f, 0.01350839f, -0.06283408f, 0.01417680f, 
    -0.05577284f, -0.04920387f, 0.02166400f, -0.03121696f, -0.01740914f, -0.05984926f, 0.00593501f, 0.01053721f, 
    -0.06007140f, 0.01169593f, -0.04739100f, 0.03953147f, -0.04565937f, -0.06288557f, 0.04359047f, -0.02704468f, 
    -0.05897859f, 0.02482805f, -0.00319227f, 0.04720253f, -0.00073831f, 0.02770872f, 0.00100420f, -0.03786548f, 
    0.01393176f, -0.00687067f, 0.04977844f, 0.00011159f, -0.00370754f, -0.05710141f, -0.00921655f, -0.00222470f, 
    0.01627162f, 0.03405176f, -0.02753150f, -0.00257145f, 0.02905396f, 0.03238793f, 0.03050484f, 0.04478258f, 
    0.01621403f, 0.00158974f, -0.02718867f, 0.01463568f, 0.00395580f, 0.03504343f, 0.02295033f, 0.01348293f, 
    -0.01208481f, -0.04786616f, 0.04417556f, -0.03596776f, -0.00103778f, -0.04589523f, 0.02897971f, -0.03066580f, 
    -0.01765447f, -0.05101296f, -0.02700609f, 0.04759714f, -0.00537194f, -0.04285512f, -0.01419197f, -0.01263369f, 
    -0.04970652f, 0.00277248f, -0.01634226f, -0.06626185f, 0.02063841f, -0.01244916f, -0.02593097f, -0.06304926f, 
    0.03782342f, -0.04511048f, -0.06459227f, -0.04963751f, 0.01758237f, -0.01041623f, -0.05312039f, -0.02389500f, 
    -0.03453024f, 0.05102172f, 0.03734567f, 0.00483488f, 0.04475134f, -0.06139257f, -0.00823843f, -0.04910487f, 
    -0.02742442f, -0.02792101f, -0.01375909f, -0.02649082f, 0.02030053f, 0.01755413f, -0.06267595f, 0.00476418f, 
    -0.06178521f, 0.04386603f, 0.03343282f, -0.06637205f, 0.00124785f, -0.04450349f, 0.00190578f, 0.00583390f, 
    -0.05362773f, 0.01633222f, -0.01880253f, -0.00744093f, 0.02387034f, -0.04039093f, -0.05454268f, -0.00958986f, 
    -0.02398389f, 0.02236722f, -0.04049783f, 0.01809870f, 0.03970046f, 0.03447644f, -0.05686963f, -0.06417321f, 
    -0.04416462f, -0.05503912f, 0.00038931f, -0.01775294f, 0.04193358f, -0.02584933f, -0.06381709f, -0.03407579f, 
    -0.01203463f, -0.02020946f, 0.04135888f, 0.02880074f, -0.01897518f, 0.04884733f, 0.00353117f, 0.01012045f, 
    -0.02388085f, -0.04690842f, 0.02126246f, 0.05021127f, -0.03487838f, -0.00245657f, -0.06670769f, -0.02533100f, 
    -0.05666432f, 0.04853398f, -0.01070170f, 0.00226489f, -0.06494813f, -0.03866603f, 0.04368183f, 0.01977503f, 
    0.04771025f, -0.02452274f, -0.01190612f, 0.00045617f, -0.04989361f, -0.02365474f, 0.04988261f, 0.02142158f, 
    -0.05324155f, 0.03380549f, -0.05376352f, 0.03168540f, -0.03189498f, 0.03745783f, -0.03889026f, 0.01323912f, 
    0.02013633f, 0.04676672f, -0.05842183f, -0.03039832f, -0.05428428f, -0.02611938f, -0.02862683f, -0.03203314f, 
    -0.05788007f, -0.05642173f, -0.04135985f, -0.06463777f, 0.01775082f, 0.04711988f, 0.05088510f, -0.03812011f, 
    -0.00886958f, -0.01545020f, -0.00168191f, 0.04985838f, -0.03374559f, -0.04348033f, -0.00910219f, -0.04033477f, 
    -0.04249079f, -0.03073497f, -0.00957608f, 0.05263665f, -0.04295141f, -0.00346876f, -0.00437023f, 0.02391580f, 
    0.22385633f, 0.25417230f, -0.30443922f, 0.17997023f, 0.31295690f, -0.03021550f, -0.14030248f, 0.07516924f, 
    0.12298372f, -0.50731719f, -0.82422048f, 0.15676840f, 0.11385204f, 0.23085414f, 0.16827223f, -0.10967768f, 
    -0.15359564f, 0.09594781f, -0.06999856f, -0.24539004f, -0.00464064f, 0.21617846f, 0.09045985f, 0.23158613f, 
    0.03167977f, 0.29387733f, 0.05696423f, -0.40227100f, -0.38860506f, 0.09722784f, -0.00006185f, 0.12124453f, 
    0.09244382f, -0.03056870f, -0.09323281f, 0.21524884f, -0.35716733f, -0.62609404f, -0.05163161f, 0.12118611f, 
    0.07363064f, -0.06947878f, -0.02263101f, 0.21107443f, 0.01523786f, 0.33636245f, 0.18079996f, -0.15201886f, 
    -0.13803847f, 0.19956654f, 0.07118602f, -0.03991612f, 0.40519622f, -0.02601003f, 0.12214989f, 0.21054387f, 
    -0.28840598f, -0.15550752f, -0.11443714f, -0.05685047f, -0.03471078f, 0.00538864f, -0.00746327f, -0.30431923f, 
    -0.13491687f, -0.29405367f, 0.01819643f, -0.27651474f, -0.14927340f, 0.21055736f, 0.12756084f, -0.04186480f, 
    0.11879555f, 0.09335788f, 0.09333625f, 0.08317943f, -0.05673845f, 0.00057636f, 0.19128674f, 0.14530210f, 
    0.29294103f, 0.32931840f, 0.10745261f, -0.12554595f, 0.00832321f, 0.07264282f, -0.03454763f, -0.16758890f, 
    0.30543751f, 0.09637994f, 0.22165477f, 0.01480916f, 0.16471823f, -0.00430929f, 0.05889422f, 0.17943200f, 
    -0.05457583f, 0.05157176f, -0.04858892f, -0.03294481f, 0.07898519f, -0.12835328f, -0.19544250f, 0.09337922f, 
    -0.06314694f, -0.03554179f, 0.24304846f, 0.10172480f, -0.91723692f, -0.32677078f, -0.32449979f, 0.10800038f, 
    -0.01739496f, -0.25360602f, 0.16316324f, -0.02350555f, -0.01862370f, 0.09532546f, 0.16489924f, 0.81107610f, 
    -0.04730871f, 0.06271246f, 0.27722049f, 0.16443005f, -0.12784709f, -0.04713985f, 0.58909684f, 0.16721775f, 
    0.00608356f, -0.13033132f, -0.00377740f, -0.15991360f, -0.08348119f, -0.14826111f, -0.16056548f, 0.30297938f, 
    -0.05488647f, 0.27122015f, 0.04430598f, 0.15401579f, 0.05466097f, -0.01276601f, 0.19041273f, 0.08204184f, 
    0.34304550f, 0.05968959f, -0.07618166f, -0.17320834f, -0.07753346f, 0.18486273f, 0.23197159f, 0.44816729f, 
    0.06262629f, -0.04343353f, 0.30743140f, -0.47671968f, -0.29274067f, 0.19660510f, 0.03394947f, 0.15925616f, 
    -0.02051619f, 0.03153492f, -0.35409686f, 0.11440362f, 0.10989574f, 0.40526617f, -0.06300000f, -0.01893518f, 
    -0.26115695f, 0.22691116f, 0.06465308f, -0.78475463f, -0.59057146f, -0.31184605f, 0.01187436f, 0.05226614f, 
    0.00172582f, -0.06742448f, 0.24214463f, 0.11580314f, -0.13338067f, 0.08428326f, -0.12282487f, 0.01967512f, 
    -0.00458022f, -0.01508109f, 0.07268766f, 0.02869405f, 0.07692587f, -0.07256714f, 0.08235004f, -0.14701533f, 
    -0.09054456f, -0.14909858f, -0.09878344f, 0.06933592f, -0.20787710f, 0.11454287f, 0.60568792f, -0.06911658f, 
    0.03955482f, 0.11936538f, -0.00980126f, 0.20583434f, -0.12564971f, 0.08765490f, 0.09849883f, 0.02414319f, 
    -0.03345063f, 0.26125050f, 0.18698968f, -0.32295662f, -0.22171195f, 0.01795973f, -0.10365408f, -0.20938872f, 
    0.10587490f, -0.00827602f, 0.08512317f, -0.01452947f, 0.41712004f, 0.03578842f, 0.22485311f, 0.12483045f, 
    -0.06636938f, -0.26514658f, 0.04516330f, -0.18678008f, 0.20846085f, 0.20433222f, 0.00254794f, -0.06947763f, 
    0.10287783f, -0.12027588f, 0.25841308f, 0.12279627f, -0.15623739f, -0.17425282f, 0.05745592f, -0.21643464f, 
    0.21315640f, 0.38816801f, 0.02915848f, -0.93063444f, -0.97325069f, 0.12911488f, 0.11809240f, -0.02322023f, 
    -0.06160070f, -0.02311379f, 0.11381278f, 0.03866204f, 0.49293062f, 0.15986153f, -0.09294492f, 0.07826985f, 
    0.04193996f, -0.06101272f, 0.28361800f, 0.01309145f, 0.14626540f, 0.10246464f, -0.21738666f, -0.00286569f, 
    0.01096584f, 0.07632829f, 0.31824532f, 0.18378896f, -0.10009538f, 0.11349177f, 0.25915843f, 0.26757392f, 
    -0.12027761f, 0.07474260f, 0.08568326f, 0.09204182f, -0.09977674f, -0.03937171f, -0.05138957f, -0.11109233f, 
    -0.51615226f, 0.09488959f, 0.02141892f, 0.03465204f, 0.18860273f, 0.01662092f, 0.18453366f, 0.03232592f, 
    -0.04500511f, 0.01668216f, 0.04041389f, 0.00924879f, -0.01988082f, -0.00198024f, -0.02511979f, 0.05175248f, 
    -0.02222396f, -0.00587374f, -0.06534260f, -0.02575778f, 0.04564243f, -0.02536196f, 0.01598749f, 0.04748823f, 
    -0.03983972f, 0.01023707f, -0.02130334f, 0.01570781f, -0.04717996f, 0.05198688f, 0.02705729f, 0.04081606f, 
    -0.04891232f, -0.05768912f, 0.00471798f, -0.03999612f, -0.05714078f, 0.00710088f, -0.01353370f, -0.04215878f, 
    -0.03672855f, -0.05863727f, -0.02718016f, -0.03447655f, -0.06321384f, -0.00833687f, -0.02159514f, -0.01292565f, 
    -0.00151296f, 0.00290282f, 0.01227609f, -0.05201641f, -0.05413995f, 0.02945493f, 0.03449190f, -0.04046268f, 
    0.00491307f, -0.00843735f, -0.01229382f, 0.00321757f, -0.04053652f, 0.01695746f, 0.00055278f, 0.00733914f, 
    -0.00637024f, -0.05652415f, 0.01029786f, 0.03669323f, -0.04707641f, 0.02762735f, 0.01829631f, 0.00909928f, 
    0.03898835f, -0.06543270f, 0.04574117f, -0.00956725f, -0.01548435f, 0.02331077f, -0.05942752f, -0.01708146f, 
    -0.02128885f, -0.01024065f, -0.05402501f, 0.04411079f, 0.01290806f, -0.05942920f, 0.03917029f, -0.02464372f, 
    -0.05653956f, 0.01473676f, -0.00339019f, 0.03101522f, 0.03270022f, 0.04044492f, 0.02611823f, -0.00862846f, 
    0.03520030f, -0.00316162f, -0.05061946f, -0.03482916f, -0.06373460f, 0.01455699f, 0.02746913f, 0.02490092f, 
    -0.04931509f, 0.04836592f, 0.01807746f, 0.02351409f, -0.02128201f, -0.03953651f, 0.02351039f, -0.05551149f, 
    0.00114713f, 0.01706761f, 0.03775640f, -0.02613841f, 0.06638557f, 0.04129886f, -0.05460440f, 0.04828670f, 
    -0.00705569f, 0.01839895f, 0.04687759f, -0.01811624f, 0.01064297f, 0.01246265f, -0.07327873f, -0.02901888f, 
    0.03133046f, 0.00055741f, 0.05506141f, -0.01022644f, 0.04480492f, 0.02068166f, 0.00122808f, -0.01419395f, 
    -0.03631067f, 0.05809900f, -0.02441832f, -0.05433097f, -0.02376220f, 0.04208529f, 0.05036794f, -0.01507169f, 
    -0.04194549f, -0.04567897f, 0.03974735f, -0.04483693f, -0.06139387f, -0.05291576f, 0.00057995f, -0.05717131f, 
    -0.01898885f, 0.04401846f, 0.03157774f, -0.05262196f, -0.02259228f, 0.04085654f, 0.02147053f, -0.02732140f, 
    -0.02993652f, -0.05032561f, 0.05377453f, -0.05758730f, 0.01118219f, -0.04050921f, 0.03466130f, -0.04133803f, 
    0.04541155f, -0.02530073f, -0.07015761f, -0.01551933f, 0.04102341f, -0.04576995f, 0.00685042f, -0.02405090f, 
    -0.01329756f, 0.03180778f, -0.04168683f, 0.04887368f, 0.01625014f, 0.00538278f, 0.00850827f, -0.05003388f, 
    0.03996105f, 0.04507646f, 0.00338548f, 0.03569373f, 0.00443078f, -0.04503593f, -0.04073311f, 0.04548807f, 
    -0.04127318f, 0.04501183f, 0.04567402f, -0.03052280f, 0.03459002f, -0.00525399f, 0.00721357f, -0.03390426f, 
    0.01195673f, -0.06199244f, 0.03712143f, -0.01705960f, 0.01726581f, 0.00767538f, -0.05202628f, -0.06061009f, 
    0.01969952f, -0.01954828f, -0.05155956f, -0.01509565f, -0.01103062f, -0.03220318f, -0.00751948f, -0.05146618f, 
    0.04806321f, 0.04209920f, 0.02547371f, -0.03964479f, 0.06010608f, 0.02785799f, 0.00497167f, 0.01255882f, 
    -0.02762797f, -0.02434195f, 0.02066891f, -0.04811237f, -0.01207602f, -0.03526358f, 0.02562882f, -0.03539555f, 
    -0.04482154f, 0.05894266f, 0.04440378f, -0.05699941f, 0.00051947f, -0.01455985f, -0.03440214f, -0.01801991f, 
    -0.01236097f, -0.05350138f, 0.00630236f, -0.02778543f, -0.04658518f, -0.05505771f, -0.00915255f, 0.02329127f, 
    -0.03530236f, 0.01995330f, -0.02768428f, -0.04820582f, -0.01961391f, 0.01866150f, 0.00663656f, -0.04252192f, 
    -0.02900136f, 0.04424785f, 0.01428642f, 0.03094307f, 0.00730632f, -0.06497483f, -0.02058944f, 0.02716378f, 
    -0.00821203f, -0.04107960f, 0.04972691f, 0.03602994f, 0.02315466f, 0.02790103f, 0.04367957f, -0.03605746f, 
    0.03986054f, -0.01549150f, 0.01610960f, -0.03981332f, -0.02776713f, -0.02948672f, 0.00971438f, -0.03055611f, 
    -0.04122426f, -0.06232445f, -0.00998326f, 0.00089985f, -0.02401222f, -0.05932354f, -0.01724691f, -0.05185389f, 
    -0.03817868f, -0.01444312f, -0.03094469f, -0.00904269f, 0.00342635f, -0.05314042f, -0.01956089f, 0.01513276f, 
    0.32852256f, 0.21539997f, -0.38241071f, 0.04521118f, 0.30291563f, -0.36730981f, -0.10917642f, 0.00456563f, 
    0.13776898f, -0.10615988f, -0.02381861f, 0.05173802f, 0.08005589f, 0.08539896f, -0.10121827f, 0.05924410f, 
    0.07511612f, 0.33538970f, 0.53828758f, -0.30830175f, 0.16169266f, 0.07222253f, -0.05944805f, 0.28095552f, 
    0.15969266f, 0.21712613f, 0.00857304f, -0.36966363f, 0.18560609f, 0.12132160f, -0.14407682f, 0.13244067f, 
    -0.14722674f, -0.21910964f, -0.10772961f, 0.00778942f, 0.10379232f, -0.66748112f, -0.18254519f, -0.02138382f, 
    -0.19326419f, -0.10224081f, -0.15017822f, -0.11883407f, 0.12918830f, -0.14381866f, 0.09509651f, -0.11758616f, 
    0.03725574f, 0.03060926f, 0.29514351f, -0.05340368f, 0.32349193f, 0.12720679f, 0.38783854f, 0.39340258f, 
    -0.31046498f, 0.09258847f, -0.22675529f, 0.03187175f, 0.14386927f, -0.18396091f, -0.05511489f, -0.00245684f, 
    0.09005646f, -0.00922110f, -0.03138279f, -0.02661329f, -0.03321520f, -0.09843490f, 0.03636880f, -0.26009771f, 
    0.03694969f, 0.00343967f, 0.08632426f, -0.17046086f, -0.01412388f, -0.09649102f, 0.03895476f, 0.10861958f, 
    -0.16319144f, 0.21427912f, 0.20234731f, 0.09721576f, 0.19604203f, 0.10508148f, -0.05319624f, 0.11556872f, 
    -0.00424568f, 0.06795886f, 0.19166778f, 0.46029761f, 0.32184687f, -0.02580192f, 0.07717774f, -0.05320061f, 
    -0.04829473f, -0.27432135f, -0.18853101f, -0.13380192f, 0.48329335f, -0.02818265f, 0.21117041f, 0.09286787f, 
    0.22246926f, -0.12439035f, 0.15567459f, 0.10335630f, -0.04223240f, -0.04137211f, 0.07764085f, -0.14775833f, 
    -0.08171204f, 0.03593761f, 0.08443351f, 0.23513839f, 0.12726675f, -0.30147809f, 0.03780386f, -0.10768325f, 
    -0.02244073f, 0.11460854f, 0.26679322f, -0.08087868f, -0.03966767f, 0.07581266f, 0.15354560f, -0.08972677f, 
    0.15687270f, 0.15481344f, 0.06761175f, -0.19232482f, -0.01289841f, -0.06036047f, 0.06169609f, 0.01088687f, 
    -0.20977385f, -0.20921528f, -0.06322487f, -0.09550057f, -0.04632769f, 0.07242221f, 0.08055959f, 0.04970840f, 
    0.04460172f, 0.20080674f, 0.01683118f, -0.01679826f, 0.13619010f, -0.16027451f, -0.03312422f, 0.12572947f, 
    0.08060464f, 0.46271798f, 0.11112387f, -0.08695647f, -0.27240035f, -0.11798991f, -0.30455789f, -0.11340821f, 
    -0.01079599f, 0.05497798f, 0.39389181f, -0.08495148f, -0.12767963f, 0.17683981f, 0.22808981f, 0.11586832f, 
    0.02689263f, -0.02752236f, 0.15283318f, 0.16266853f, -0.86807543f, -0.32876989f, 0.00053084f, -0.21880949f, 
    -0.07888953f, -0.11143901f, -0.28026387f, 0.00593814f, 0.32961923f, -0.02882650f, -0.26278675f, -0.00067639f, 
    -0.07587421f, -0.12965192f, -0.10530780f, -0.09034950f, 0.09916055f, -0.26302186f, 0.04737351f, 0.01658777f, 
    -0.07879503f, -0.05435385f, -0.49473852f, -0.17146067f, 0.21694475f, -0.07087795f, -0.12667823f, -0.29458532f, 
    0.07128998f, -0.08186930f, 0.06386881f, 0.13497631f, -0.35225326f, -0.38928211f, 0.09019653f, 0.23461848f, 
    0.20752172f, 0.05643087f, -0.02481834f, 0.04767111f, -0.10700931f, -0.09784494f, 0.02411832f, -0.08519623f, 
    0.13426833f, 0.34004265f, -0.36464798f, -0.17894086f, -0.09143392f, 0.14231198f, 0.02323822f, -0.19845717f, 
    -0.06443109f, -0.22588691f, -0.05722949f, 0.06306288f, 0.01634652f, 0.16838080f, -0.18540835f, 0.02813884f, 
    0.33526811f, -0.09469598f, 0.00209114f, 0.15530425f, 0.11061086f, -0.08854385f, 0.09924775f, -0.02108288f, 
    0.14070354f, 0.23934287f, -0.10481804f, -0.24395223f, -0.27945402f, 0.10204263f, -0.03385670f, -0.03497770f, 
    0.04874346f, -0.04283354f, -0.25683412f, 0.08276534f, 0.02911644f, 0.47501260f, 0.07848356f, 0.22565472f, 
    0.04569058f, -0.16416448f, 0.04377606f, 0.01262704f, -0.04507609f, -0.28812489f, 0.62106860f, -0.17429146f, 
    0.02847009f, -0.03988034f, -0.05855511f, 0.17678595f, 0.22054355f, -0.16482483f, -0.20366304f, 0.45250857f, 
    -0.30552843f, 0.11699085f, -0.18292429f, 0.18465436f, -0.26841047f, 0.13425963f, 0.00518724f, -0.41187125f, 
    -0.12361394f, 0.10031136f, 0.06805066f, -0.08554488f, -0.19174041f, 0.11026801f, -0.00061985f, 0.06750635f, 
    -0.01667555f, 0.00931956f, 0.01393894f, -0.06852330f, -0.05818181f, -0.03816628f, -0.01429096f, 0.01663414f, 
    0.03243082f, -0.02438755f, 0.00449694f, 0.01781167f, -0.03939722f, -0.04680965f, -0.03460921f, 0.02690841f, 
    -0.05339620f, 0.01439098f, 0.00054017f, -0.06038780f, 0.03300483f, -0.05600712f, 0.01089081f, -0.02125305f, 
    0.01994802f, 0.03114043f, 0.01518063f, 0.03295646f, -0.03471968f, -0.08059286f, 0.05318230f, 0.01992099f, 
    0.02186890f, -0.01437212f, -0.04207210f, 0.03168746f, 0.04643421f, 0.00525487f, -0.00300365f, -0.01310051f, 
    0.02517693f, -0.04013361f, -0.00587910f, -0.02178302f, 0.01323320f, 0.00824018f, -0.05060731f, -0.00751284f, 
    -0.00761887f, -0.05058474f, -0.06501071f, -0.01091535f, -0.02838374f, -0.02812156f, 0.02479322f, -0.05975423f, 
    -0.07442048f, -0.02351022f, -0.00412173f, -0.05111862f, 0.03425378f, 0.00256623f, 0.00422098f, 0.03851497f, 
    0.02160935f, -0.00183447f, -0.05999523f, -0.07572828f, -0.00079988f, -0.06632490f, 0.03913601f, -0.07194687f, 
    -0.06952851f, -0.05127687f, 0.03561279f, -0.01112656f, -0.06801848f, -0.07742676f, -0.04043961f, 0.04117185f, 
    -0.05971962f, -0.02266168f, -0.00586471f, -0.05775259f, -0.06467136f, 0.03191722f, -0.02452198f, -0.01049989f, 
    -0.03261878f, -0.07311741f, 0.01633804f, -0.03303919f, 0.05899217f, 0.01283091f, -0.01294120f, 0.00930235f, 
    -0.06991228f, -0.06736948f, -0.00383318f, -0.09243762f, 0.02322613f, 0.02222311f, -0.03407485f, -0.02038781f, 
    0.00299298f, -0.07156796f, 0.01448767f, 0.00897778f, 0.01366002f, 0.04461243f, -0.04390646f, -0.05066450f, 
    0.03341443f, -0.04671561f, 0.03654018f, 0.00943705f, 0.01005858f, -0.05846302f, -0.03666047f, -0.01664044f, 
    -0.04425956f, -0.00955595f, 0.00716623f, 0.00256478f, -0.06064587f, -0.03447920f, -0.03689869f, 0.02928714f, 
    0.03929306f, 0.00896841f, -0.04634699f, -0.01638496f, 0.00437721f, 0.01456152f, 0.00601549f, -0.05166373f, 
    0.03516670f, -0.08064882f, -0.02721418f, -0.02414211f, 0.00492968f, -0.07634026f, -0.01420928f, -0.05913294f, 
    -0.00533888f, -0.06800792f, 0.02715575f, -0.03303680f, -0.03454228f, -0.04959830f, -0.07177334f, -0.04603743f, 
    -0.05167764f, -0.00494656f, 0.02240636f, -0.04992674f, -0.03543634f, -0.07881032f, 0.00102358f, -0.04670668f, 
    -0.04754388f, -0.04219935f, -0.08228485f, 0.02529677f, -0.04160689f, 0.04075191f, -0.06716213f, -0.02715769f, 
    -0.10507485f, 0.02433938f, -0.00628825f, -0.05513306f, 0.05294441f, -0.01358786f, -0.01309128f, -0.03463380f, 
    0.02823380f, -0.05285177f, -0.01464548f, -0.03906488f, -0.01609254f, 0.01970821f, 0.03742364f, -0.06405663f, 
    -0.01980688f, 0.01008937f, -0.02569423f, -0.01484398f, -0.07991937f, -0.03365090f, 0.01758857f, -0.07047512f, 
    0.00835689f, 0.03290591f, -0.07868504f, -0.07459272f, 0.00945811f, 0.02119517f, 0.00256688f, -0.00320500f, 
    -0.00476411f, -0.06875250f, 0.02362186f, 0.03464036f, -0.06686149f, -0.02040503f, 0.02306139f, -0.02638897f, 
    -0.05451860f, -0.05836384f, -0.04249747f, -0.02968592f, -0.04087735f, 0.01755692f, -0.06261996f, 0.00676528f, 
    0.01764575f, -0.02289984f, 0.00015836f, -0.09295566f, -0.00536135f, -0.04721409f, -0.02362138f, 0.01200103f, 
    0.03095836f, -0.00426426f, 0.01951094f, 0.03024547f, -0.06684480f, -0.00546762f, -0.02960995f, -0.02602973f, 
    -0.05781221f, 0.01188686f, 0.03286804f, 0.02181394f, 0.05582345f, -0.05111510f, 0.00718633f, 0.03852516f, 
    -0.05235012f, -0.07047927f, 0.04753220f, 0.00187875f, 0.03478105f, -0.07355953f, -0.00073617f, -0.03885812f, 
    0.00215765f, -0.05326817f, 0.00733153f, -0.00994079f, -0.05148520f, -0.01073685f, -0.06028550f, -0.04400941f, 
    -0.00138516f, -0.00756113f, -0.05738145f, -0.00308160f, -0.04932912f, -0.09395180f, -0.02103300f, -0.05229753f, 
    -0.03573099f, -0.01592621f, 0.02197017f, -0.02961569f, -0.05839165f, -0.02427916f, -0.02809623f, -0.06596567f, 
    -0.05816457f, -0.03408341f, -0.07162289f, -0.00216696f, -0.04549095f, -0.06307081f, 0.01939115f, -0.00754930f, 
    0.03660166f, -0.06418083f, 0.02134415f, -0.06008195f, 0.01502484f, -0.00916036f, 0.00123055f, -0.06158591f, 
    -0.02767017f, 0.03296981f, 0.22673278f, -0.22295025f, 0.13090207f, 0.04544761f, 0.18664779f, 0.22479759f, 
    -0.11524096f, -0.02153474f, 0.16853523f, -0.21856010f, -0.20204477f, 0.21889709f, 0.20877154f, -0.02219657f, 
    0.00567836f, -0.21492849f, -0.34829584f, 0.11102623f, -0.07779604f, -0.09188528f, -0.08839086f, -0.08288330f, 
    -0.22410651f, 0.10196543f, -0.05463775f, -0.06110346f, 0.23202746f, -0.15953830f, -0.07487099f, -0.01410743f, 
    -0.03059992f, -0.07805578f, 0.05227095f, -0.08594591f, -0.43039134f, 0.06132649f, -0.20335607f, -0.08904485f, 
    0.01180600f, 0.06027390f, -0.14861177f, -0.16421351f, -0.23179637f, 0.25205070f, -0.05196024f, 0.01074391f, 
    -0.30309451f, -0.08724479f, -0.32309508f, -0.12871531f, -0.12425133f, -0.06717004f, 0.41733041f, 0.11759904f, 
    0.11525132f, -0.04961552f, 0.09412977f, -0.38993585f, 0.00481258f, 0.03689376f, 0.05029240f, -0.03465550f, 
    -0.18303849f, 0.38155904f, -0.13242532f, 0.31809744f, -0.03515911f, 0.01496300f, -0.23855515f, 0.00714454f, 
    -0.20133734f, 0.06159597f, -0.06210654f, -0.21530269f, -0.05664214f, -0.26452589f, -0.05869268f, 0.12665613f, 
    -0.03968615f, -0.06091014f, -0.06518657f, 0.22642723f, 0.03156093f, -0.01658703f, 0.00968620f, -0.05590829f, 
    0.18266360f, 0.05848985f, -0.16157621f, 0.17958607f, 0.28057083f, 0.22310776f, -0.14715238f, -0.01773511f, 
    -0.10646304f, 0.14484748f, 0.39376551f, 0.16359341f, -0.23956995f, 0.26037121f, -0.10696007f, 0.19498229f, 
    -0.00242910f, -0.02100110f, -0.00673994f, 0.23714966f, -0.19167952f, -0.07966921f, 0.00053489f, -0.14652841f, 
    0.15366766f, 0.12927714f, -0.20157143f, 0.13209094f, 0.04305211f, 0.12931834f, -0.02031786f, -0.27121064f, 
    0.19705805f, 0.16467200f, -0.02421473f, -0.12179197f, -0.07260752f, 0.04646061f, -0.02511204f, -0.03818612f, 
    0.06269178f, 0.08370677f, 0.01511662f, 0.17868970f, -0.10093640f, -0.01059128f, -0.26375571f, -0.08886969f, 
    0.06407834f, -0.04188054f, -0.01940054f, 0.23159152f, -0.23791943f, -0.04686572f, 0.06336699f, -0.22358082f, 
    0.09927603f, -0.15408766f, 0.35783595f, 0.08910763f, 0.09775244f, -0.06652963f, -0.03525957f, 0.14651795f, 
    0.07794072f, 0.23317806f, 0.08303003f, 0.08806244f, -0.08616503f, 0.15369855f, -0.09318563f, -0.10106663f, 
    0.08686580f, -0.19125134f, 0.19610883f, 0.11180304f, -0.31261650f, -0.26860058f, -0.08730961f, 0.11404778f, 
    -0.16109999f, 0.10619238f, -0.18964924f, 0.01438898f, 0.11867519f, -0.03784560f, -0.14656515f, -0.30511811f, 
    0.04534328f, 0.07729414f, 0.18753989f, -0.05015872f, 0.36733615f, 0.03603671f, 0.22676057f, 0.02850937f, 
    0.04499822f, -0.28099185f, 0.08283859f, 0.13892922f, 0.03418133f, 0.37872377f, -0.07636509f, -0.22231220f, 
    0.00609102f, -0.07902387f, 0.06648893f, 0.00337273f, 0.06986845f, -0.05066465f, 0.07885578f, 0.07961991f, 
    -0.04423668f, 0.03356948f, 0.11560237f, -0.01735508f, 0.12086703f, 0.01523663f, -0.16553500f, 0.04006603f, 
    -0.02031078f, 0.10126697f, 0.13952483f, 0.08124341f, -0.08626964f, -0.15407427f, -0.08527101f, -0.12835047f, 
    0.18858899f, 0.30670366f, 0.33252326f, -0.16146654f, 0.33865923f, -0.16529268f, -0.14570369f, 0.27024332f, 
    0.08131672f, -0.23742452f, 0.20415300f, 0.20246926f, 0.33207521f, 0.27290145f, 0.22669214f, 0.01957993f, 
    -0.01514480f, -0.24072061f, -0.19732092f, 0.03436025f, 0.13411416f, 0.20699447f, 0.16926210f, -0.04725031f, 
    0.18791975f, -0.09632837f, -0.18545279f, -0.12511212f, 0.06694882f, -0.34472308f, -0.13196559f, 0.12143892f, 
    0.08268738f, -0.33362934f, -0.08886691f, -0.21627079f, -0.06232015f, 0.09056857f, 0.22980021f, 0.02504338f, 
    -0.01637885f, 0.05706968f, -0.04444402f, 0.24350029f, 0.12236842f, 0.12402563f, -0.03423616f, 0.08715098f, 
    0.02261799f, -0.00096145f, 0.16787493f, -0.21911781f, 0.01571102f, 0.09197907f, -0.01498086f, 0.11691405f, 
    0.19880421f, -0.05194278f, 0.08890004f, 0.04095360f, 0.08012177f, -0.02329979f, 0.15049636f, 0.00032553f, 
    0.08058079f, -0.00153369f, 0.00360916f, -0.00882759f, 0.18030725f, 0.09759433f, -0.03384413f, -0.45314837f, 
    -0.01072061f, -0.52577841f, 0.13243793f, 0.23248363f, 0.15825731f, -0.22076839f, 0.07061688f, -0.07867368f, 
    0.06272545f, 0.25978875f, 0.21082672f, -0.13588440f, 0.08054377f, -0.02922301f, 0.09600657f, 0.07362945f, 
    0.06442907f, 0.00873952f, -0.30932605f, 0.23502046f, 0.23829618f, -0.11683480f, -0.03349430f, -0.01321211f, 
    -0.24671584f, -0.15626596f, 0.18015689f, -0.00727516f, 0.09653889f, -0.12774310f, -0.06184810f, -0.09971672f, 
    -0.20621984f, -0.04022780f, -0.06725429f, 0.27750194f, -0.15169068f, 0.22874053f, 0.07002309f, -0.09358030f, 
    0.02348089f, 0.07881170f, 0.10060818f, 0.04684494f, -0.04194787f, -0.03380542f, 0.22131151f, 0.03289033f, 
    0.08729806f, 0.04177732f, 0.02392675f, -0.11301090f, -0.09831293f, -0.08334670f, -0.42493024f, 0.00312567f, 
    -0.06287210f, 0.16459703f, 0.02224564f, -0.19448924f, -0.04161544f, 0.02028526f, 0.19647329f, 0.10723483f, 
    -0.36310732f, 0.17078851f, 0.00562324f, -0.01294129f, 0.15742159f, -0.03340811f, -0.37118140f, 0.31562820f, 
    -0.21200113f, 0.08259964f, -0.06698205f, 0.12870172f, 0.01834274f, 0.09512369f, 0.06679873f, -0.10308287f, 
    0.01645905f, 0.22375485f, 0.21958354f, -0.10701094f, 0.16129096f, -0.03192688f, -0.02055578f, 0.15650064f, 
    -0.06247360f, -0.08972266f, -0.13547671f, -0.38265598f, -0.34919044f, 0.18301058f, 0.17894593f, 0.23057413f, 
    0.04649141f, -0.06051390f, -0.07420710f, 0.49447513f, 0.31130585f, 0.26530918f, 0.11904196f, -0.09337097f, 
    -0.25034952f, 0.02028898f, -0.14657320f, 0.23427679f, 0.13394636f, 0.09427948f, 0.24475867f, -0.17023340f, 
    -0.12313338f, -0.17645238f, 0.06729020f, -0.02063697f, 0.10873313f, -0.10516894f, -0.21088021f, -0.16611820f, 
    0.14669934f, 0.05544218f, 0.02828251f, 0.11171852f, -0.07205874f, -0.03112409f, 0.02197528f, -0.20749764f, 
    -0.40161985f, -0.03687745f, 0.05222525f, 0.10102624f, 0.02486438f, -0.08764786f, 0.36500302f, -0.65148222f, 
    0.03090042f, 0.14920568f, -0.06674468f, -0.05805334f, 0.00195810f, -0.02996001f, 0.03118098f, 0.16909297f, 
    0.21148291f, -0.29213223f, -0.05710745f, 0.10668960f, 0.03264786f, -0.14754044f, -0.02296982f, 0.14266528f, 
    -0.19362581f, 0.08939014f, -0.75100309f, -0.17530148f, 0.05202687f, -0.01994383f, -0.18836713f, -0.11965939f, 
    -0.03666344f, -0.01013224f, -0.19745958f, -0.09135289f, -0.16558826f, -0.20843646f, -0.09664047f, 0.12237868f, 
    0.05883645f, -0.08154771f, -0.19365935f, 0.41716200f, 0.34561422f, -0.12202401f, 0.06433931f, -0.38678944f, 
    -0.00260968f, 0.15702586f, -0.02930078f, 0.00583645f, 0.35425493f, -0.44040582f, -0.17412153f, 0.05159171f, 
    0.00360461f, -0.07949395f, 0.12229791f, 0.03669078f, -0.03806796f, -0.20178428f, 0.05974491f, -0.37600282f, 
    0.06530453f, 0.17445229f, 0.02827825f, 0.02656550f, -0.21611732f, -0.01009915f, -0.06245353f, 0.17315099f, 
    -0.34308484f, 0.10475593f, 0.20826258f, 0.08153490f, -0.24461173f, 0.31160849f, 0.08516023f, 0.02187129f, 
    -0.21300124f, -0.13595881f, -0.07822387f, 0.19263196f, 0.45243239f, 0.05175351f, -0.06776844f, 0.08024526f, 
    -0.15935917f, -0.03863916f, -0.33881480f, -0.10826929f, 0.04195584f, -0.05653595f, 0.06942207f, -0.07654792f, 
    0.03422635f, -0.02282749f, 0.05557737f, -0.00129191f, -0.04219840f, 0.07769074f, -0.01276101f, 0.16121022f, 
    0.05883734f, -0.07917367f, -0.20278719f, -0.11183189f, -0.03034662f, 0.04834384f, 0.06895089f, -0.09600858f, 
    -0.13556796f, 0.01222633f, -0.11301194f, 0.21007755f, 0.18663216f, 0.07232860f, 0.06118809f, -0.10015105f, 
    0.04200494f, 0.03104083f, 0.14467531f, -0.09009444f, 0.37766621f, -0.29306424f, -0.01485639f, 0.10995374f, 
    -0.00113020f, 0.04882303f, -0.15703721f, 0.13105425f, -0.19069625f, 0.17069453f, 0.13533217f, -0.07664575f, 
    0.09511735f, 0.08211185f, -0.00136794f, -0.01132052f, -0.18136114f, -0.09921287f, -0.00903988f, 0.20044777f, 
    0.09874952f, 0.33624056f, 0.08031372f, -0.02809417f, -0.06869020f, 0.02130807f, 0.19277431f, 0.46075019f, 
    0.27036738f, -0.07674804f, -0.02479101f, -0.05804320f, -0.14201133f, 0.14016299f, -0.07550226f, 0.14406593f, 
    0.40162674f, -0.38510799f, -0.07212293f, 0.00613279f, 0.15399471f, -0.32766119f, 0.00447279f, -0.05117595f, 
    -0.05996490f, 0.17389442f, 0.09598536f, -0.00814101f, -0.12294484f, -0.05240699f, 0.06607839f, 0.00231841f, 
    0.17252918f, -0.29302335f, 0.43743110f, -0.13504525f, -0.03736559f, 0.11007226f, -0.08528403f, -0.07571649f, 
    -0.04604074f, 0.21129912f, -0.06481274f, -0.30444774f, 0.07278834f, -0.00493856f, -0.19681938f, 0.11579125f, 
    0.08158978f, 0.19652289f, -0.02707716f, 0.04819221f, 0.23497073f, 0.17727691f, 0.32793096f, 0.15308900f, 
    -0.01229901f, 0.23356739f, 0.11001321f, -0.10222460f, 0.32377854f, -0.21211782f, 0.33057225f, -0.00587907f, 
    -0.09554979f, -0.02910028f, 0.00588973f, -0.07497522f, 0.16565664f, -0.23305452f, -0.06104289f, -0.04835247f, 
    0.25237736f, 0.25483856f, 0.03065286f, 0.08065584f, 0.04207989f, -0.02541874f, -0.18030788f, 0.03942740f, 
    0.02520944f, 0.20172410f, -0.03170251f, -0.15882868f, -0.10623733f, 0.11900230f, -0.06915221f, 0.05625602f, 
    -0.10046135f, -0.24592867f, 0.03244551f, 0.06265594f, -0.05148689f, 0.18677136f, 0.09070715f, 0.00561513f, 
    0.05193825f, -0.30150408f, 0.34991410f, -0.14486602f, 0.19747107f, 0.03267905f, 0.06517950f, 0.09816703f, 
    0.00771796f, -0.02916336f, -0.12469947f, -0.18237402f, -0.47123945f, 0.15101990f, -0.01458459f, 0.16880660f, 
    0.01223162f, 0.04667647f, -0.38614345f, 0.10455295f, 0.59913784f, -0.14137271f, -0.06326498f, -0.02693597f, 
    0.11069164f, -0.07225446f, -0.08327582f, 0.15369099f, 0.35880056f, -0.07648966f, 0.11153453f, -0.22766547f, 
    -0.11579078f, -0.04687400f, 0.16429164f, 0.03675812f, -0.03446490f, 0.49331042f, -0.16248651f, -0.06412375f, 
    0.05901024f, -0.13860498f, 0.02032733f, 0.16149780f, -0.21378161f, 0.00641625f, -0.72776520f, -0.35782811f, 
    0.06047744f, -0.11739506f, -0.02930982f, 0.02863596f, -0.04972418f, 0.03318312f, 0.09835358f, 0.09376075f, 
    0.25986272f, -0.05089048f, 0.16587591f, -0.14165998f, 0.11696091f, -0.09475553f, -0.00043240f, 0.20630749f, 
    0.09504316f, 0.11735391f, -0.06861860f, 0.02683885f, 0.07909428f, 0.02135840f, -0.04049154f, -0.02332086f, 
    0.01914241f, 0.12413677f, -0.63413292f, 0.11471527f, -0.06382051f, -0.06342066f, 0.06406235f, -0.14200905f, 
    0.17853482f, -0.06351963f, -0.23917410f, -0.09267514f, 0.20338289f, -0.09120874f, 0.22809599f, 0.04829231f, 
    0.06158036f, 0.18017119f, -0.08569568f, 0.52536947f, 0.15001844f, -0.09729279f, -0.12841193f, -0.15284233f, 
    -0.01715296f, -0.06975596f, -0.01266310f, 0.15759476f, 0.21818636f, -0.27736202f, 0.04359467f, 0.07803803f, 
    0.17658032f, -0.12065619f, 0.01716943f, -0.00393191f, -0.09705517f, -0.48229119f, 0.13712870f, -0.16874078f, 
    -0.20098914f, 0.10042448f, -0.08060487f, 0.19967769f, -0.00254725f, -0.04495702f, 0.03506163f, 0.05170589f, 
    -0.31136703f, -0.02338592f, 0.03250436f, -0.03295746f, 0.04643467f, -0.08360986f, 0.17454004f, 0.12075257f, 
    -0.51194823f, -0.52210414f, 0.04019965f, 0.12891412f, 0.19944726f, -0.19288291f, 0.13319226f, -0.24540302f, 
    -0.44494292f, 0.05020905f, -0.18373080f, -0.25336695f, 0.21917887f, -0.10007007f, -0.04657940f, -0.02465778f, 
    0.02292333f, -0.26189336f, 0.08582386f, -0.07851817f, -0.08946571f, 0.05081381f, -0.27857524f, -0.17914516f, 
    0.12746312f, -0.09074552f, -0.19563988f, -0.07383969f, -0.14165804f, -0.06844947f, 0.02356922f, -0.10123638f, 
    0.04421200f, -0.20661657f, 0.12706597f, 0.17458171f, 0.12525745f, -0.07221796f, -0.04716707f, -0.00942129f, 
    0.09879712f, -0.03166690f, 0.02078849f, 0.05913454f, 0.36246136f, 0.29444849f, -0.22360852f, -0.08619922f, 
    0.30992746f, 0.07758486f, -0.09196230f, -0.04150843f, -0.19586809f, -0.23712365f, -0.17980807f, -0.12619989f, 
    -0.10246691f, -0.17488499f, 0.04234815f, 0.03230967f, -0.02894023f, -0.14004819f, -0.16115539f, 0.19315736f, 
    -0.38369426f, -0.03244684f, 0.13781615f, 0.23002018f, -0.09457830f, -0.01827669f, -0.01401723f, 0.12168762f, 
    0.10182091f, 0.08826998f, 0.01164621f, 0.13135621f, 0.07214994f, 0.05635639f, 0.18985285f, -0.14525032f, 
    -0.05621254f, -0.00244276f, -0.00849795f, 0.02604686f, 0.01628753f, 0.00186163f, -0.02528655f, -0.05418031f, 
    0.00393611f, -0.05858552f, 0.02592858f, -0.06052466f, 0.01662811f, -0.02762247f, 0.03155046f, -0.02194735f, 
    -0.06556299f, 0.00397822f, 0.01096275f, -0.00478019f, 0.02874401f, 0.01723106f, 0.01074804f, -0.05375358f, 
    -0.06865889f, -0.02238884f, 0.01827269f, -0.03982797f, 0.02872845f, 0.03689212f, -0.05908192f, -0.02595089f, 
    -0.00944740f, 0.01407175f, -0.04610721f, -0.05060532f, 0.01843170f, -0.04361730f, 0.04234464f, 0.04618207f, 
    -0.04787825f, -0.05045965f, 0.01039434f, 0.03805834f, 0.02376483f, -0.03495483f, 0.03683530f, 0.04305205f, 
    -0.02021324f, 0.04317972f, 0.02053526f, -0.05627040f, -0.04654511f, 0.02401946f, 0.02151984f, -0.06298107f, 
    -0.03501525f, 0.02530787f, -0.05955387f, 0.03890950f, -0.04175428f, 0.01669727f, 0.02652566f, -0.03479849f, 
    0.04067525f, -0.00387713f, -0.01291481f, 0.00447144f, 0.04628171f, 0.01004224f, -0.05786654f, 0.03506257f, 
    -0.05130618f, 0.03501174f, -0.06893659f, -0.01418945f, 0.01192153f, -0.03649043f, 0.04199768f, 0.04443519f, 
    -0.00434372f, -0.00629416f, -0.02743096f, -0.06393693f, 0.01212405f, 0.04495948f, 0.02576611f, -0.06468966f, 
    -0.01537506f, -0.02136729f, -0.06446701f, -0.05389877f, 0.00928140f, -0.03045965f, -0.06847281f, 0.01982968f, 
    0.01893636f, 0.00971206f, -0.01472775f, -0.05104772f, -0.00870432f, 0.01084112f, -0.01752136f, -0.05514723f, 
    -0.00077132f, 0.01283160f, -0.03117024f, -0.01206568f, 0.01245605f, 0.04609340f, 0.02829510f, -0.05627826f, 
    -0.06518380f, -0.03244210f, 0.04072920f, 0.01052946f, -0.03654071f, -0.03867425f, 0.02412274f, -0.04343255f, 
    0.02278584f, -0.04688670f, 0.01107416f, -0.03133288f, -0.01652370f, -0.00205542f, -0.04334005f, 0.04221505f, 
    -0.00322553f, -0.05830710f, 0.02171054f, 0.00191750f, -0.03290886f, -0.03020315f, 0.03438039f, -0.02115857f, 
    -0.01058132f, 0.00610057f, 0.00685896f, 0.00157945f, -0.00523692f, 0.03548392f, -0.03610925f, 0.03005277f, 
    -0.03532810f, -0.02914643f, 0.01740087f, -0.05370654f, -0.03040366f, -0.07149690f, -0.06500270f, 0.03011922f, 
    -0.02880313f, -0.02558497f, 0.02493303f, -0.00734681f, -0.06410113f, -0.05744418f, -0.03358413f, -0.01671432f, 
    -0.06811595f, 0.01287457f, 0.03386695f, 0.01211298f, -0.07050429f, -0.04819997f, 0.04765715f, -0.05236363f, 
    -0.03591774f, -0.02342419f, -0.03884023f, -0.03830098f, 0.01141658f, -0.07039689f, -0.00517729f, 0.00086354f, 
    -0.01375261f, -0.05903524f, -0.03692634f, -0.05567551f, 0.03918355f, -0.03501699f, -0.03257287f, 0.04099772f, 
    0.03795103f, 0.01067753f, -0.02521865f, 0.00145071f, -0.01796063f, -0.03645399f, -0.03211982f, -0.02819296f, 
    -0.04249482f, -0.05224261f, -0.04128925f, -0.02334223f, -0.02960697f, -0.01257641f, 0.03000627f, 0.00886470f, 
    -0.03641022f, 0.02026817f, 0.00419217f, 0.01648612f, 0.02267620f, -0.02961352f, 0.01905298f, -0.05175899f, 
    -0.05329441f, -0.01679467f, 0.01607218f, -0.01286548f, 0.02400361f, 0.04087209f, 0.02372262f, -0.01184557f, 
    0.03269920f, 0.00402412f, -0.00195968f, 0.02723698f, 0.01917106f, -0.03439893f, -0.01087627f, 0.01505341f, 
    0.03329447f, -0.04948094f, 0.03043118f, 0.02372598f, -0.00247571f, 0.00922346f, -0.05939075f, 0.02318049f, 
    -0.00560254f, -0.06159082f, -0.00267477f, -0.06769037f, 0.01548368f, -0.03717891f, -0.00615141f, 0.03545697f, 
    -0.01458874f, 0.01827030f, -0.01579542f, 0.02660231f, 0.04228217f, 0.02250605f, 0.04089710f, -0.05541887f, 
    -0.05430176f, -0.05179908f, -0.05015999f, 0.00015029f, -0.01712405f, 0.04258071f, -0.02890216f, 0.03896974f, 
    -0.03149441f, -0.03277003f, -0.07022747f, 0.00483538f, 0.02295465f, 0.00843341f, -0.04505538f, -0.06726449f, 
    0.04514043f, -0.05647935f, -0.02069505f, 0.03659200f, -0.03417588f, -0.00598227f, 0.03822076f, -0.00169638f, 
    -0.00132543f, 0.02825091f, -0.01382224f, -0.03523282f, 0.04555216f, -0.05485488f, -0.03803276f, -0.02572000f, 
    -0.01269009f, 0.02258721f, -0.03405825f, 0.02864282f, -0.04405540f, -0.06945191f, -0.02291408f, -0.04633512f, 
    -0.01139346f, -0.00893851f, -0.04244152f, 0.02303644f, 0.04302977f, 0.05099110f, -0.02580729f, 0.03367048f, 
    0.02239797f, -0.04038253f, 0.03947966f, -0.06123630f, 0.01639224f, -0.06473240f, 0.03877133f, 0.03128059f, 
    -0.03844760f, -0.03331643f, 0.00048929f, 0.01810080f, -0.04904416f, 0.04064228f, -0.03153982f, 0.01440277f, 
    -0.00465255f, 0.04490386f, -0.02249647f, -0.05584405f, -0.05153471f, 0.02829520f, -0.04259763f, -0.02738158f, 
    0.00052797f, -0.04518108f, 0.01642243f, -0.04126736f, 0.03482404f, -0.05683354f, -0.03120493f, -0.03076547f, 
    -0.05619182f, 0.04746055f, -0.00387534f, -0.02318342f, -0.02529644f, 0.00788100f, -0.05357472f, 0.04192594f, 
    -0.01322665f, -0.03416190f, -0.03716805f, -0.01911610f, 0.02970585f, 0.05021801f, -0.02984097f, 0.03433137f, 
    0.05587767f, 0.03271113f, 0.04947861f, 0.00375051f, 0.00831977f, -0.02382473f, 0.00517739f, -0.02628578f, 
    -0.01547707f, -0.03147474f, 0.03615440f, -0.02295810f, 0.04721845f, 0.05211633f, 0.05195298f, -0.03956349f, 
    -0.03000812f, 0.01865837f, 0.01005586f, 0.01220003f, 0.00499143f, -0.02714838f, -0.00763821f, -0.05521496f, 
    -0.06426141f, -0.02785011f, 0.04088549f, 0.01890566f, 0.03517722f, 0.05706752f, -0.01929329f, -0.00882803f, 
    -0.06162218f, 0.00568689f, -0.03858647f, 0.01411347f, 0.03926384f, 0.01971251f, 0.03589290f, -0.00688656f, 
    -0.05036464f, -0.02012265f, 0.00546013f, 0.02858214f, 0.03061221f, -0.00275763f, -0.04076018f, -0.00991254f, 
    -0.03844704f, -0.02963724f, 0.00246609f, 0.04878362f, -0.02395181f, 0.00045243f, 0.00740194f, -0.05377265f, 
    -0.05386463f, 0.03495270f, 0.02368144f, -0.01547826f, 0.02092365f, -0.06385411f, 0.02311517f, 0.02425381f, 
    -0.02702517f, 0.03669388f, -0.03488266f, -0.00815337f, 0.05246145f, -0.05805290f, 0.02755321f, -0.02344407f, 
    -0.05792629f, 0.01764753f, 0.02503708f, -0.03314263f, 0.01501835f, -0.01310811f, -0.05207374f, -0.04170929f, 
    0.02367601f, -0.01961379f, -0.03275748f, 0.04080908f, -0.04503748f, -0.01329096f, -0.05696237f, 0.04503024f, 
    -0.00971896f, 0.03157125f, -0.00126067f, -0.00574049f, 0.02329026f, 0.04194519f, 0.00527508f, -0.01130852f, 
    -0.06127421f, -0.03467701f, 0.00350290f, 0.01971014f, 0.03556561f, -0.04165760f, -0.03033469f, 0.00571875f, 
    -0.01580873f, -0.01662778f, -0.00228406f, -0.06387990f, 0.01998146f, 0.04209144f, -0.02405491f, 0.02936895f, 
    -0.05709766f, -0.01769957f, 0.03409201f, 0.01853766f, -0.01818690f, -0.01698205f, 0.00288392f, -0.05064174f, 
    0.02749864f, -0.02485098f, -0.03161184f, -0.03160402f, 0.01150569f, -0.05269946f, -0.01283091f, -0.03368334f, 
    0.02053774f, -0.02893967f, 0.01115251f, -0.01144931f, -0.00144824f, 0.00873993f, -0.03532120f, -0.03370623f, 
    0.00169833f, 0.02575482f, 0.04242701f, -0.01101221f, -0.03560102f, -0.06354117f, -0.05896146f, -0.02928216f, 
    -0.06469277f, -0.02418743f, 0.01102455f, -0.02331595f, -0.05306416f, 0.00139449f, -0.02737699f, -0.01535484f, 
    -0.03410326f, -0.00465647f, -0.00852472f, 0.01334379f, 0.04944213f, -0.04034699f, 0.03379197f, 0.03078020f, 
    0.06189147f, 0.03789115f, -0.04849017f, 0.01500052f, -0.02576346f, -0.01176648f, -0.03018958f, -0.00549553f, 
    -0.02701411f, -0.02316114f, 0.02299038f, -0.05099618f, 0.00405135f, -0.02513005f, 0.00852438f, 0.02884967f, 
    0.02484599f, -0.01989939f, 0.01334710f, -0.01491342f, -0.04865430f, 0.01164163f, 0.00841326f, 0.00137531f, 
    -0.02915251f, -0.06246405f, -0.04386711f, 0.02402997f, 0.02122120f, -0.04316617f, 0.05063349f, -0.03907483f, 
    -0.01352959f, -0.05002308f, -0.04314087f, -0.05795176f, -0.03326194f, -0.00008613f, 0.03665194f, 0.01858315f, 
    -0.05191628f, 0.01071560f, -0.01177771f, -0.03103280f, -0.04328718f, -0.05258779f, 0.01121403f, -0.01621329f, 
    -0.01104813f, 0.05756186f, 0.00796939f, 0.02594712f, 0.00237444f, -0.05997984f, 0.03206411f, -0.06321586f, 
    -0.01441655f, -0.03058753f, -0.00332522f, -0.01764867f, -0.05745764f, 0.02387097f, 0.04319155f, -0.06008078f, 
    -0.00151196f, 0.01366521f, -0.01939327f, -0.03044069f, 0.01791933f, 0.04765086f, -0.01655680f, -0.02610079f, 
    0.48196775f, -0.30473396f, -0.24492215f, -0.09052386f, -0.08255852f, -0.30957308f, 0.14331672f, 0.17559223f, 
    0.19520134f, 0.22983795f, 0.00905252f, -0.02703664f, -0.36464536f, -0.15181465f, -0.06559370f, 0.36602283f, 
    0.24907550f, 0.21544461f, -0.02617050f, -0.12539184f, 0.16390397f, -0.13227259f, 0.07198646f, 0.01564649f, 
    0.08739161f, -0.19061409f, -0.13662857f, -0.25873905f, -0.20906104f, -0.05038553f, 0.01861350f, -0.09679665f, 
    -0.00556440f, -0.27385864f, 0.07369928f, -0.17357869f, 0.19116284f, 0.12814035f, 0.03381183f, -0.10282664f, 
    0.07048771f, -0.05043073f, -0.14533339f, 0.09521719f, 0.04641025f, -0.67040449f, -0.02124685f, 0.21733873f, 
    0.29368472f, 0.02992200f, -0.14585747f, -0.09538615f, -0.02910680f, 0.08399270f, -0.58421898f, -0.26754645f, 
    0.31404388f, 0.01850251f, 0.19810674f, -0.01268257f, -0.08637826f, -0.03573968f, 0.02418443f, -0.07267740f, 
    -0.10490479f, -0.39478967f, 0.07900153f, 0.08355723f, -0.16882078f, 0.24157017f, 0.10935298f, -0.12715840f, 
    -0.03517099f, 0.07940525f, 0.09071632f, -0.15637699f, 0.24677758f, -0.00349486f, -0.21246363f, 0.21898419f, 
    0.02864714f, -0.01856489f, 0.13893145f, -0.20324321f, -0.23990697f, 0.04291899f, 0.00146168f, 0.18299174f, 
    -0.06348585f, -0.09976806f, 0.15563335f, 0.11125317f, -0.11573748f, 0.26892176f, 0.26414901f, 0.43734020f, 
    -0.10001688f, -0.25666955f, -0.30972356f, -0.55447131f, -0.07838760f, 0.28459373f, 0.06487420f, 0.09725160f, 
    -0.02613186f, 0.15199767f, 0.02797787f, 0.07940180f, 0.14192791f, 0.18056162f, -0.02780844f, 0.02747568f, 
    0.26388568f, 0.13708505f, -0.00022428f, -0.19305131f, 0.05116842f, 0.16946906f, 0.14096396f, 0.03235075f, 
    -0.10318323f, -0.05358407f, 0.10265923f, -0.02955910f, 0.11975256f, 0.37223732f, -0.56754941f, -0.18335813f, 
    0.15404826f, -0.20459956f, 0.03523062f, -0.07846921f, 0.17210451f, 0.04465938f, 0.14939129f, 0.04678541f, 
    -0.12961479f, 0.07351673f, -0.20823753f, -0.02419700f, -0.03330567f, -0.06195845f, 0.28671765f, 0.17059037f, 
    -0.09818271f, 0.12519291f, -0.05385769f, 0.14212908f, 0.10173772f, -0.05779422f, -0.00013148f, 0.11338771f, 
    -0.04657001f, -0.16682832f, -0.01032783f, 0.00375742f, -0.29603425f, -0.03083967f, 0.10324837f, 0.08337336f, 
    0.01157286f, 0.10137892f, -0.24930465f, 0.16942938f, 0.34177715f, 0.10749501f, 0.16666102f, 0.00566597f, 
    0.47522873f, 0.05694302f, -0.18478635f, -0.12849151f, -0.04944256f, -0.19316484f, -0.36402768f, 0.10362537f, 
    -0.06400958f, -0.03397911f, 0.00154788f, -0.03931175f, -0.60485780f, 0.11380249f, 0.27613434f, -0.30141795f, 
    0.09878445f, 0.08277827f, -0.06202944f, -0.19862454f, 0.10657623f, 0.46922126f, 0.05944468f, 0.08965029f, 
    0.04212848f, 0.00005649f, -0.23664452f, 0.20645668f, -0.11465573f, 0.09126683f, 0.06072888f, -0.06788167f, 
    0.00352484f, 0.13850240f, -0.27184924f, -0.02373922f, 0.05789656f, 0.00607374f, 0.07089883f, -0.78604811f, 
    -0.04105483f, 0.32264414f, 0.01624449f, 0.26747555f, 0.22246134f, 0.13372870f, -0.24865679f, -0.15167935f, 
    -0.29162082f, -0.20480901f, -0.03709188f, 0.17166388f, 0.19692080f, 0.03430537f, 0.13268863f, 0.04804676f, 
    -0.08325002f, 0.46159846f, 0.39277685f, 0.07031281f, -0.15342608f, -0.39814413f, -0.25084358f, 0.07732208f, 
    0.05763036f, 0.34491843f, 0.38477606f, 0.06644820f, -0.41471964f, 0.20333415f, -0.11180252f, 0.07506023f, 
    0.10574125f, -0.03939773f, 0.16778372f, 0.05404560f, 0.17274909f, 0.14474036f, -0.00422398f, -0.06717899f, 
    0.03356355f, -0.10871379f, 0.05699791f, 0.02936778f, 0.44499084f, 0.20437297f, -0.15733494f, 0.01522354f, 
    0.09648227f, 0.07271082f, 0.01456405f, -0.05949478f, -0.18896176f, -0.50782031f, -0.26894528f, 0.08961810f, 
    -0.01148463f, 0.23615582f, -0.07704417f, 0.01017939f, 0.18313204f, -0.08498359f, -0.62788981f, -0.26431760f, 
    0.32856962f, -0.00506558f, -0.06173054f, 0.05998965f, 0.14995320f, 0.25566298f, 0.10601205f, 0.08193878f, 
    0.25457543f, 0.17442842f, -0.28075084f, -0.12164369f, -0.13906290f, 0.25173593f, 0.25704932f, 0.08989785f, 
    0.02169752f, 0.02622610f, 0.02457398f, -0.02630898f, -0.01330511f, -0.06194707f, -0.00557391f, 0.00140670f, 
    -0.04441001f, -0.00713272f, 0.05170657f, 0.02848217f, -0.01829298f, -0.02041079f, 0.00375597f, 0.04403784f, 
    -0.00426717f, -0.01038154f, -0.05910808f, -0.01374867f, 0.02143836f, -0.01214667f, -0.04420322f, 0.04979002f, 
    -0.04943496f, -0.06423515f, -0.00714517f, 0.00061762f, 0.02512710f, -0.04636180f, -0.06204846f, -0.04065666f, 
    -0.03292904f, 0.00812721f, -0.03355114f, -0.02669908f, -0.04274119f, 0.02128588f, 0.05261343f, 0.02393998f, 
    0.00110400f, 0.00038384f, -0.03184171f, 0.01668423f, 0.05264861f, 0.05059202f, -0.01995604f, -0.03546415f, 
    -0.04512477f, -0.06346384f, 0.03984110f, -0.06325752f, 0.01080880f, -0.00306753f, 0.02904022f, 0.03748879f, 
    0.01835704f, -0.01808897f, -0.05858104f, -0.02082144f, 0.00676668f, -0.03428823f, -0.02764820f, 0.00793358f, 
    0.00752674f, -0.02169773f, 0.00004009f, -0.04978039f, -0.06239998f, 0.03681555f, 0.00013609f, 0.03537964f, 
    -0.02053201f, -0.01356437f, -0.03449544f, 0.02582475f, 0.04813228f, 0.00888884f, 0.00318328f, -0.05114935f, 
    -0.00298476f, -0.01277118f, -0.04565596f, -0.05743633f, -0.00938125f, -0.05604443f, -0.02265804f, 0.05077827f, 
    -0.02669957f, -0.01611309f, -0.04043526f, 0.01503621f, -0.05667548f, 0.02842423f, -0.02600855f, 0.01949418f, 
    -0.00389961f, -0.02344193f, 0.05217452f, -0.05719873f, -0.00049374f, 0.01274772f, 0.00789735f, 0.04205381f, 
    -0.02896135f, -0.05147774f, 0.00516100f, -0.01143381f, 0.04496797f, -0.05498486f, 0.01690370f, 0.03191350f, 
    -0.04104470f, 0.00909306f, 0.02096365f, 0.01744668f, 0.04764763f, 0.00968773f, 0.00664810f, -0.00584026f, 
    -0.02768823f, -0.00730215f, -0.06233994f, -0.02077977f, -0.00337381f, -0.05925753f, -0.02609567f, 0.00565766f, 
    -0.03710799f, 0.03625836f, -0.06167895f, -0.02898331f, -0.05724351f, -0.01887804f, -0.02973761f, 0.02552666f, 
    0.03892576f, 0.00667967f, -0.02997022f, -0.06056774f, -0.05197777f, 0.04833071f, -0.05914916f, -0.06345385f, 
    0.03195184f, -0.05020086f, -0.00466646f, -0.03358266f, 0.05096936f, -0.03463043f, -0.00557704f, -0.05606038f, 
    -0.04781960f, -0.06396593f, -0.04529402f, 0.01924403f, -0.00675626f, -0.02258342f, 0.03568266f, 0.00521176f, 
    -0.02746036f, -0.04344489f, -0.03297859f, 0.04801101f, 0.01078151f, 0.05833932f, -0.01486358f, 0.03876243f, 
    -0.04067158f, -0.03069225f, 0.04837446f, -0.03487077f, -0.04853944f, -0.05581873f, -0.00886138f, -0.02798973f, 
    -0.01758155f, -0.00278130f, -0.05914380f, 0.00385181f, -0.01022325f, -0.05665939f, -0.02839354f, 0.01911729f, 
    -0.03763491f, 0.02826802f, -0.02860263f, 0.03012815f, -0.05193790f, 0.02618930f, -0.00370472f, -0.03391058f, 
    0.03922893f, 0.01446251f, 0.00991781f, 0.01174719f, -0.03317750f, 0.01713224f, -0.04463711f, 0.01772516f, 
    -0.04230425f, -0.02016575f, 0.03086138f, -0.03019849f, 0.02006098f, 0.03627253f, 0.00187981f, 0.03429728f, 
    -0.03391813f, 0.04711879f, -0.00405880f, -0.03055276f, 0.00240083f, 0.03418841f, 0.00185429f, -0.02995086f, 
    0.00545122f, -0.02453997f, -0.01534381f, 0.01481320f, 0.04377056f, -0.00507345f, -0.04942008f, -0.04292458f, 
    -0.02740012f, -0.01869837f, -0.00123712f, 0.00380150f, 0.03926255f, 0.01890890f, 0.02208367f, -0.00660504f, 
    -0.02195504f, 0.04344763f, -0.02149880f, 0.03360096f, -0.03029766f, 0.00367311f, 0.01792202f, 0.03332588f, 
    0.01045730f, -0.04133796f, 0.01798263f, -0.04742863f, -0.01736652f, -0.02087458f, -0.04987152f, -0.03798452f, 
    -0.05427285f, -0.02387060f, -0.01088653f, 0.04044326f, 0.01787242f, -0.00690467f, 0.04838946f, -0.01118151f, 
    -0.00962384f, -0.03106055f, -0.06419867f, -0.01580508f, -0.00157965f, -0.05895969f, 0.03478762f, -0.03333734f, 
    0.01898254f, 0.04908074f, 0.01549662f, -0.04483030f, -0.01200419f, -0.05307607f, 0.00385280f, -0.05893324f, 
    0.04158575f, -0.03990851f, 0.05202901f, 0.01601031f, -0.04347055f, 0.04966627f, -0.02770659f, 0.03042074f, 
    -0.01779796f, -0.01843693f, -0.02614592f, 0.04927454f, 0.04138211f, 0.02007029f, -0.01021592f, 0.03530542f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07601012f, -0.04185550f, -0.03050996f, 0.16160771f, -0.08356281f, 0.11340608f, 0.00481398f, -0.01732338f, 
    0.02533818f, -0.03509666f, -0.03094752f, 0.07889532f, -0.02828925f, 0.01656174f, 0.16501822f, -0.06008015f, 
    0.03804302f, -0.01711833f, 0.23874825f, 0.12696360f, 0.00588322f, 0.20872438f, 0.00509200f, -0.29447198f, 
    0.01857467f, -0.03038228f, -0.00743923f, 0.03671788f, -0.00164150f, 0.04816633f, 0.09851739f, 0.03008422f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.46782795f, 0.10420862f, -0.02023377f, 0.29196119f, 0.36434719f, -0.32238445f, 0.08758754f, 0.05477408f, 
    0.12664662f, -0.12062924f, -0.05440885f, -0.28972661f, 0.06543876f, -0.60623866f, 0.18237214f, -0.02196712f, 
    -0.12779160f, 0.02971066f, -1.02637470f, -0.60235173f, 0.12527083f, 0.13750152f, 0.07383121f, -0.35205796f, 
    -0.03579157f, 0.12379623f, -0.19694285f, 0.25151038f, 0.00755702f, 0.04795773f, 0.68100065f, 0.03297509f, 
    -0.15457992f, 0.09161206f, -0.10643475f, -0.22654673f, -0.03385105f, -0.39854228f, 0.04509035f, 0.00404006f, 
    -0.10667238f, -0.05679767f, -0.07025822f, -0.49989191f, -0.15556018f, 0.02398451f, 0.55344743f, -0.19487518f, 
    0.07226784f, -0.15646401f, 0.47757396f, 0.11079202f, -0.05360767f, -0.07452294f, -0.08397855f, 0.01662480f, 
    0.03336068f, 0.02717602f, 0.82735646f, 0.81430674f, -0.16117795f, -0.05457332f, 0.01257285f, -0.12000419f, 
    0.09642300f, 0.13473035f, 0.09378850f, -0.06271625f, -0.31480724f, -0.34160939f, -0.11225736f, 0.03858226f, 
    -0.01340517f, 0.04151157f, -0.05910483f, 0.08181869f, 0.01784439f, -0.23732516f, -0.11822230f, 1.13744950f, 
    0.16479814f, -0.12085493f, -0.31597409f, -0.11049377f, 0.02074716f, -0.38414526f, 0.05010439f, -0.42802420f, 
    0.10072395f, 0.18266617f, 0.25248030f, -0.04047288f, -0.01898408f, -0.07434925f, -0.00482722f, -0.02583868f, 
    0.44889158f, 0.05489796f, -0.02004370f, -0.27414817f, -0.06422630f, -0.34004197f, -0.37984577f, -0.09353757f, 
    0.10057493f, 0.00721597f, 0.04877576f, 0.16580114f, -0.17001088f, 0.20459168f, -0.67190963f, 0.00032544f, 
    0.03348485f, 0.15364277f, -0.10750319f, -0.61997229f, -0.02745558f, 0.60880429f, -0.17108281f, 0.63608187f, 
    0.04631796f, 0.10697825f, -0.86709028f, -0.41013703f, -0.02241014f, 0.02757005f, -0.14820269f, 0.14452741f, 
    0.17914447f, 0.15007611f, 0.10983713f, 0.13132456f, 0.22522499f, 0.04178256f, 0.35569933f, -0.10167522f, 
    -0.11630598f, -0.12790574f, 0.16373654f, 0.18946135f, 0.10477851f, 0.06841445f, -0.20019250f, -0.29913059f, 
    0.02501377f, 0.00389348f, -1.11279750f, 0.74597943f, -0.16204190f, -0.09221853f, -0.12892610f, -0.51649737f, 
    -0.05774535f, 0.19039126f, 0.35133430f, -1.03375304f, -0.07599211f, -0.01176083f, -0.15899339f, 0.05510279f, 
    -0.52954614f, 0.03855462f, 0.01796641f, 0.30493450f, 0.20659128f, -0.05948698f, -0.63930351f, 0.03204697f, 
    -0.06563343f, 0.06341524f, -0.14382346f, 0.03207359f, 0.02068294f, 0.32073334f, 0.40439582f, -0.33144119f, 
    -0.00980832f, -0.00146978f, 0.26811442f, 0.02159994f, -0.10277043f, -0.04661177f, 0.03765223f, 0.33643231f, 
    0.03010356f, -0.80486530f, 0.01537188f, -0.45588303f, -0.01741914f, 0.12878659f, 0.45344600f, -0.15342957f, 
    0.46849659f, -0.16926335f, 0.05942809f, 0.42706484f, -0.01979006f, -0.51581842f, -0.52949941f, 0.08998857f, 
    0.16481686f, -0.18135543f, 0.09023188f, 0.31306812f, -0.03189281f, 0.91073823f, -0.67666781f, -0.25594506f, 
    -0.00727285f, 0.04206568f, -0.45379338f, 0.19501492f, 0.06828942f, -0.16877489f, -0.01413613f, -0.24023807f, 
    -0.09801939f, -0.21657625f, 0.04342880f, 0.23529203f, 0.13479392f, -0.02068247f, -0.25772610f, 0.11328626f, 
    -0.60565156f, -0.12529214f, -0.10354772f, -0.26659441f, 0.83893996f, 0.29466718f, 0.07511043f, -0.02515439f, 
    0.05712635f, -0.13853437f, -0.05615328f, -0.31705964f, 0.06659561f, -0.14920695f, 0.04598145f, -0.33599585f, 
    -0.07128262f, 0.14122526f, 0.01711064f, -0.07601503f, 0.10681975f, -0.02783903f, -0.06042827f, 0.41361788f, 
    0.13361135f, 0.42833847f, -0.38515681f, -0.39016581f, 0.07445187f, 0.04277161f, -0.34539577f, 0.13629512f, 
    -0.39017043f, -0.13642374f, -0.18138304f, -0.26657423f, -0.49514091f, 0.20021954f, 0.89009404f, -0.02060024f, 
    -0.13249053f, -0.13879402f, -0.08630653f, -0.23041731f, 0.08375476f, -0.04073970f, -0.33751377f, -0.06103853f, 
    -0.10368218f, -0.10328978f, -0.29556853f, 0.38171121f, -0.02690244f, -0.32154623f, 0.08262108f, 0.68403500f, 
    0.10186351f, -0.45871687f, 0.01944726f, 0.46366075f, -0.16154173f, -0.04864701f, 0.31455141f, -0.12978752f, 
    -0.26470011f, -0.00540472f, -0.11611612f, 0.47107318f, 0.08852778f, 0.46570358f, -0.02973927f, -0.11588517f, 
    -0.07416781f, 0.13200508f, -0.03959328f, 0.16801986f, 0.09680581f, -0.92959619f, -0.50756246f, -0.32403502f, 
    -0.03030908f, -0.13259722f, 1.10238683f, 0.29287571f, 0.14273055f, -0.35392544f, 0.09713201f, -0.20430981f, 
    -0.04615573f, 0.26087046f, -0.05074206f, -0.38517815f, -0.02243528f, -0.02669410f, 0.02282836f, 0.15498836f, 
    0.44129133f, -0.05424058f, -0.07800461f, -0.66799498f, -0.42898011f, 0.52078927f, -0.11472271f, -0.05712835f, 
    0.15081050f, -0.06261007f, -0.10219485f, -0.27764148f, -0.09977448f, -0.17022558f, 0.50816894f, 0.05448796f, 
    -0.02442925f, -0.15051620f, -0.12391394f, 0.24774019f, 0.03286962f, 0.62810397f, 0.15962778f, -0.32799020f, 
    0.01702437f, -0.23631580f, -0.45657769f, -0.31941351f, 0.08184657f, -0.05282735f, -0.30271763f, -0.01145662f, 
    0.33411083f, 0.10318843f, 0.15115945f, -0.08787267f, -0.30848324f, 0.18651329f, -0.20251405f, -0.13229990f, 
    -0.05811914f, 0.09506578f, 0.04890501f, 0.86181730f, 0.09229972f, -0.22246355f, -0.35111862f, -0.12667066f, 
    -0.14723670f, 0.03597440f, -0.39610353f, -0.70469159f, 0.01444799f, -0.04370781f, -0.00682916f, -0.20630209f, 
    -0.17412968f, 0.15563957f, -0.00759819f, 0.45980489f, -0.14792515f, -0.08234159f, -0.43942702f, 0.11223305f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08578005f, -0.10471118f, -0.21626464f, -0.14953421f, 0.07226843f, -0.02924408f, -0.13248137f, -0.18416589f, 
    -0.17234488f, 0.26119331f, 0.30621529f, -0.06824828f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
