#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.74968314f, -0.55747503f, 0.02276875f, 1.26431489f, 0.99313134f, -0.40731886f, 0.24444073f, 0.73115754f, 
    -0.03567563f, 0.92881417f, 0.75583750f, 0.83529121f, 0.62858123f, 0.46958244f, -0.11851484f, 0.46018192f, 
    -0.87202436f, 0.11049679f, -1.12910032f, -0.83095062f, -1.26261425f, -0.28464538f, 0.80446804f, -0.16850886f, 
    0.49069938f, -0.30560634f, 0.41515177f, -0.24518920f, -1.20820713f, -1.07975256f, -0.64830196f, -0.93937761f, 
    -0.86897767f, -0.20287532f, 0.42520407f, 0.27282849f, -0.95290667f, -0.59126997f, 0.27245608f, 0.49412808f, 
    1.18380260f, -0.34302971f, 0.15400632f, -0.21077852f, -0.60139865f, 0.94791228f, 0.59413254f, 0.81556010f, 
    -0.02824358f, -1.10736847f, 0.46822265f, 0.45967093f, 0.53678590f, 0.61563921f, -0.27810666f, -1.22989094f, 
    -0.88103104f, 0.03168441f, 0.69713908f, 0.95766336f, -0.53045088f, 0.13409196f, 0.29625669f, -0.66876596f, 
    -0.24846514f, -0.09543049f, -0.96711653f, -0.37200221f, 1.00517750f, 0.65455651f, -0.32121637f, 0.67149043f, 
    -1.03156149f, -1.28964233f, -1.24133086f, -0.28985912f, -0.30122176f, 0.72253543f, 0.30171627f, 0.00849335f, 
    -0.51699650f, -0.80595011f, -0.60949087f, -0.81983787f, -0.07484812f, -0.58450353f, -0.63055587f, -0.53954953f, 
    0.25263262f, 0.15198940f, 0.15173630f, 0.44534373f, 0.67702454f, 0.85822535f, 0.89228135f, 0.70974451f, 
    -0.17248586f, 0.52803290f, 0.32659605f, 0.03408365f, -0.93222284f, 0.33333048f, 0.89804226f, 0.69821578f, 
    0.02140630f, -0.95590472f, -0.77101970f, -0.70861536f, -0.91393209f, -0.89590073f, 0.73208064f, 0.45442316f, 
    -1.38775659f, 0.69182640f, 0.26124662f, -0.42219195f, 0.28091934f, 0.23055430f, 0.72146857f, -1.16603863f, 
    1.12671709f, -0.72066271f, -0.41404918f, -0.30070499f, -0.02092130f, 0.61896616f, -1.43101406f, 1.17711067f, 
    0.41159436f, 0.21615088f, 1.15101218f, 0.84779096f, -0.38694292f, 0.40629083f, -0.10394264f, 0.82773340f, 
    -0.45485878f, 0.55856436f, -1.57560503f, -0.82315141f, -1.12813520f, 0.19488224f, 0.78721297f, 0.23439105f, 
    1.30231130f, 0.74651241f, 0.47497103f, 0.00695612f, -0.40855727f, -0.16362809f, 0.19347504f, 0.72728199f, 
    -0.27300304f, -0.86979163f, -0.91316032f, -0.50909376f, 0.73118353f, 0.86632270f, 0.22831854f, 0.08848409f, 
    0.23117870f, -0.01441211f, 0.76224273f, 0.45414886f, -1.13251281f, 0.67645282f, 0.95222688f, 1.08178687f, 
    -0.04700044f, -0.72089392f, 0.23828156f, 1.70704544f, -0.07866790f, -1.02257860f, 0.62757188f, 0.17615499f, 
    -0.54294842f, 0.02560279f, -0.16635671f, -0.12617904f, -1.22069013f, -0.48994172f, 0.13269269f, 0.36587495f, 
    0.73133630f, 1.06532383f, 0.28329247f, -0.50446033f, 0.38033387f, -0.22289893f, -0.68090630f, 0.89483154f, 
    -0.98861849f, 0.57307154f, 0.18574731f, -0.62545496f, -0.90704286f, -0.84042025f, 0.83550143f, 0.84247619f, 
    1.00345564f, -0.28910822f, -0.17318437f, 0.88348871f, -0.19005932f, -0.29244813f, 0.14500877f, 1.02559471f, 
    0.92024726f, 1.25773191f, 0.86507374f, 0.48743743f, -0.70622975f, 0.23613809f, 0.49186736f, -0.29922855f, 
    -0.78987813f, 1.13386774f, -0.30556533f, -0.22398394f, -0.30205441f, -1.33956003f, 0.12294349f, -0.20353360f, 
    0.38322866f, -0.96274787f, -0.49798125f, -0.96647149f, 0.86012608f, 0.38796967f, -0.37740156f, -0.51136017f, 
    0.33145782f, -0.36934072f, 1.26659262f, 0.96311730f, 0.21988249f, 0.47671074f, -0.38088191f, 0.49157789f, 
    -0.81510311f, 0.44814622f, -0.44911706f, 0.52897990f, -0.76501924f, -0.60402256f, 0.26079378f, -1.40762424f, 
    -0.31109992f, 1.15709817f, -0.00521667f, 0.22768919f, 0.66465873f, 1.27022600f, -0.34626520f, -0.56475383f, 
    -0.68105608f, -1.10298824f, 0.02673067f, -0.17704001f, 0.19472687f, -1.09212303f, 0.58768517f, 1.14331698f, 
    1.03711343f, 0.21327366f, -1.14413965f, -0.26746815f, -0.24627031f, -0.16363928f, -0.39430860f, -0.69837034f, 
    1.16455710f, 0.98554248f, 0.31103972f, -0.27956939f, -0.24247868f, -0.53146237f, 0.34069592f, 0.78483570f, 
    1.13704872f, -0.52167839f, -1.21642113f, -0.29243132f, 0.03756190f, 0.58693403f, 0.04374712f, -0.44552797f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15654312f, 0.13706957f, 0.15102217f, 0.11599934f, -0.22120233f, -0.18148321f, 0.03364295f, 0.44372168f, 
    0.02152536f, 0.38461113f, 0.41730937f, -0.00928909f, -0.09601757f, 0.09391939f, -0.18432219f, -0.16626857f, 
    -0.02829433f, 0.17194939f, 0.01337114f, 0.22114237f, 0.14804731f, 0.02434165f, 0.47597909f, -0.07749028f, 
    0.22125337f, -0.17884584f, 0.27754709f, 0.29612535f, 0.32204252f, -0.06291901f, -0.20478301f, 0.16411036f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.11282098f, 0.16543272f, -0.08079876f, 0.04618577f, 0.01654840f, 0.02219966f, 0.17404194f, 0.14493887f, 
    -0.08895996f, 0.45023400f, -0.24706629f, -0.06596281f, 0.18857326f, -0.07141266f, -0.02568517f, -0.15314808f, 
    0.10203921f, -0.07203691f, 0.31240243f, 0.36976472f, -0.15907909f, 0.14536937f, 0.04895683f, -0.01602918f, 
    -0.01536800f, -0.04947164f, -0.09856516f, 0.18660291f, -0.03582158f, -0.19361863f, -0.09204792f, 0.03188295f, 
    -0.08999372f, 0.05290760f, -0.06716740f, -0.09854580f, 0.17277242f, 0.21885833f, -0.01433638f, 0.09967896f, 
    -0.13868837f, 0.00718033f, 0.32640749f, -0.03711171f, -0.06643307f, 0.21132600f, -0.26123518f, -0.13610092f, 
    0.09563020f, -0.04915023f, 0.06108767f, 0.13211747f, -0.11618989f, 0.10520519f, 0.10527989f, 0.26653853f, 
    -0.13205579f, -0.04007439f, -0.03805619f, -0.01216256f, -0.01065276f, 0.12680326f, -0.03749088f, -0.31948808f, 
    0.05054009f, -0.41273275f, 0.04517438f, 0.04593453f, 0.31148604f, 0.16601147f, -0.05552203f, 0.17556441f, 
    -0.14219238f, 0.62030768f, -0.06118269f, 0.30220520f, -0.16162293f, -0.01128803f, -0.00428842f, 0.06032916f, 
    0.02374647f, 0.27288580f, -0.03195239f, -0.20929673f, 0.00254251f, -0.00237328f, -0.05180354f, -0.11665432f, 
    -0.03325994f, -0.13408321f, 0.24489391f, 0.26084271f, -0.04591153f, -0.01790800f, 0.06445807f, -0.00008353f, 
    -0.18760379f, 0.03504817f, 0.12290729f, 0.17203207f, 0.32723677f, 0.02894637f, -0.09873606f, -0.10123295f, 
    -0.04771926f, -0.06067171f, 0.19882075f, 0.04416610f, -0.49535650f, 0.06608103f, -0.01029291f, 0.18218474f, 
    0.04395361f, 0.11040321f, 0.00086239f, 0.18492898f, -0.26202101f, -0.01295833f, -0.17200023f, -0.33110684f, 
    0.04808177f, 0.03114352f, 0.14825742f, -0.01116281f, 0.13950659f, -0.03953160f, 0.25614125f, 0.21223769f, 
    0.22967872f, -0.17985524f, -0.11271326f, -0.15909411f, -0.02149446f, 0.02204510f, 0.10336707f, -0.29674068f, 
    -0.27997136f, 0.07495341f, 0.02518825f, 0.02374933f, -0.07351757f, -0.06259830f, -0.02125252f, 0.21943229f, 
    0.09444289f, 0.05118851f, 0.27321973f, 0.28043523f, -0.02847297f, -0.14514279f, -0.11182316f, -0.12018830f, 
    0.02180983f, 0.02393025f, 0.23263092f, 0.17068431f, -0.05289032f, 0.08425906f, 0.13853142f, -0.13291197f, 
    0.12718023f, -0.11797160f, -0.22130542f, 0.08925837f, -0.05535540f, -0.05890655f, 0.17231180f, -0.09340137f, 
    -0.00512473f, 0.09510926f, 0.06521837f, -0.13616759f, -0.22670119f, 0.16351634f, 0.05410141f, 0.03831738f, 
    -0.07734606f, -0.02478642f, -0.18182658f, -0.02682538f, 0.13408671f, 0.35153297f, 0.31950238f, 0.07818853f, 
    0.16492029f, -0.14573251f, -0.08396088f, -0.17514512f, 0.09712499f, -0.24121231f, -0.04286717f, -0.37748224f, 
    0.14077194f, 0.10931045f, -0.13528393f, 0.11326636f, 0.04633411f, -0.06828519f, 0.04529503f, -0.00737894f, 
    -0.14447729f, -0.12095984f, -0.12983654f, -0.01956062f, -0.32729667f, 0.07325259f, -0.19977608f, 0.03484464f, 
    -0.12248273f, 0.14383096f, 0.10546792f, 0.00308685f, -0.09119399f, -0.25179154f, -0.09859897f, 0.06182071f, 
    -0.06294417f, -0.21543637f, -0.22926246f, 0.03332192f, 0.12561816f, -0.04965014f, 0.03874688f, -0.07496651f, 
    -0.11487575f, 0.37885630f, 0.09178468f, -0.04986687f, -0.23972349f, 0.02181857f, 0.06624478f, -0.10905565f, 
    0.07208158f, -0.24667063f, 0.03860310f, -0.00761970f, -0.17060199f, 0.07891419f, -0.08624894f, -0.06038170f, 
    -0.00361971f, 0.11052420f, -0.02221174f, 0.04808046f, -0.10665990f, 0.02467903f, -0.02575209f, 0.06284031f, 
    -0.01711798f, 0.16753438f, 0.03170015f, 0.12661140f, 0.10512596f, -0.09781753f, 0.17178671f, -0.00399013f, 
    0.05289638f, 0.06658156f, -0.03332033f, -0.04815966f, -0.02888525f, -0.45668018f, -0.08194680f, -0.03376695f, 
    -0.16437837f, 0.12657765f, -0.04987793f, 0.00566562f, 0.05465518f, 0.04285903f, 0.00675175f, -0.01923995f, 
    -0.04206738f, 0.17038728f, -0.10714789f, -0.02120889f, -0.02572340f, -0.08503065f, -0.07401260f, 0.05427143f, 
    -0.07801107f, 0.02553803f, 0.02268123f, -0.22802703f, 0.02488361f, -0.05205439f, -0.16220279f, 0.04602873f, 
    0.00033706f, -0.00838074f, -0.00495229f, -0.06214126f, 0.03117011f, 0.01450500f, -0.01217942f, -0.03354615f, 
    -0.03050688f, -0.06423862f, 0.00351010f, 0.02934976f, 0.01636294f, 0.04439167f, 0.03830912f, 0.04912153f, 
    0.02113830f, 0.00353138f, 0.02250734f, 0.02172617f, 0.03791175f, 0.03836337f, 0.01563652f, -0.06074946f, 
    0.02308162f, 0.04529703f, -0.04456542f, -0.02304809f, -0.01443138f, 0.01942181f, 0.02738355f, -0.00649861f, 
    0.01187223f, 0.03179888f, 0.00334718f, -0.03431681f, -0.04848674f, 0.00544728f, -0.03575861f, 0.03567280f, 
    -0.05044779f, -0.02884927f, -0.01180835f, 0.00831924f, -0.02451482f, -0.04074280f, -0.01975367f, -0.04560228f, 
    0.04651607f, 0.04544483f, -0.04613617f, -0.05222883f, 0.02242141f, 0.03664305f, -0.02168962f, -0.00554903f, 
    -0.03538366f, 0.01548270f, -0.06269717f, -0.03418963f, -0.00059682f, 0.00411506f, 0.00127269f, -0.04906357f, 
    -0.05849822f, -0.01010887f, 0.01494210f, -0.02801239f, -0.00189608f, -0.05695061f, -0.02640677f, -0.03286611f, 
    -0.01940524f, 0.03246683f, 0.01684976f, -0.01162800f, 0.02053009f, -0.06475838f, -0.05853563f, -0.02839357f, 
    -0.06442349f, 0.03994570f, -0.02999895f, 0.02457876f, -0.02873101f, -0.03174254f, -0.04297595f, -0.05423232f, 
    -0.04176093f, 0.02451906f, 0.01240292f, -0.01531356f, 0.01812440f, -0.02138572f, -0.05084846f, 0.01539007f, 
    0.00560880f, 0.03485121f, 0.01021199f, 0.02493049f, -0.04209839f, -0.03338884f, -0.06108472f, -0.02835366f, 
    0.04700593f, 0.01747655f, 0.04441314f, -0.00136542f, -0.06250785f, 0.01207942f, 0.03914654f, -0.03427261f, 
    -0.02961775f, 0.03199951f, -0.03053224f, 0.05447511f, 0.00096943f, -0.05768855f, -0.04489048f, -0.05020449f, 
    -0.02359115f, -0.03200876f, 0.01609508f, -0.02179860f, -0.00734870f, -0.04703864f, 0.04988684f, -0.04889875f, 
    -0.03844152f, 0.01134086f, -0.02602894f, 0.02917347f, 0.00177182f, -0.05895645f, 0.01187417f, 0.01687800f, 
    -0.00786318f, 0.02968038f, -0.00522125f, -0.01768727f, -0.00529714f, -0.03372780f, -0.01394142f, 0.03196989f, 
    -0.00079928f, -0.03742450f, -0.03033525f, 0.02987867f, 0.02399281f, -0.00582625f, -0.05505794f, 0.00309628f, 
    0.00598837f, -0.05739949f, -0.00326053f, -0.05538831f, -0.05222347f, -0.06475527f, 0.04642107f, -0.06384102f, 
    -0.00375249f, 0.03875140f, -0.00838147f, 0.01177605f, -0.03755135f, -0.05367120f, 0.05202129f, 0.00316287f, 
    0.02042075f, 0.00290480f, -0.05299534f, 0.05055398f, -0.01791015f, 0.03034464f, 0.01591241f, 0.03545253f, 
    0.02893710f, 0.02012656f, -0.00768598f, 0.02235548f, -0.01575668f, -0.00168388f, 0.02652448f, -0.03011782f, 
    -0.00522843f, -0.05337287f, -0.03973129f, 0.01988742f, -0.04232785f, 0.03091891f, -0.04085274f, -0.04532459f, 
    -0.03809928f, 0.00514318f, -0.04881697f, -0.04616681f, 0.00137252f, -0.01504340f, -0.02044473f, -0.02008910f, 
    -0.03368168f, -0.02741561f, -0.02282743f, 0.01054776f, 0.00943685f, 0.05095045f, 0.02806067f, 0.04357023f, 
    0.03783788f, -0.01109302f, -0.02408726f, -0.06347571f, 0.03063698f, -0.06360357f, -0.05323016f, 0.04218847f, 
    0.02318805f, -0.05542527f, 0.03812539f, -0.00746451f, -0.05614326f, -0.02855202f, 0.02467599f, -0.02565073f, 
    0.03384620f, 0.03575067f, -0.05824432f, 0.01494825f, -0.02061144f, -0.02828865f, 0.02097760f, -0.05548498f, 
    -0.00831268f, -0.05021533f, 0.00532595f, -0.04033615f, -0.06302833f, -0.02175653f, -0.01812186f, -0.02959834f, 
    -0.05035048f, 0.03352799f, -0.00962576f, -0.04096411f, -0.04339701f, 0.00404032f, -0.03234510f, 0.02549811f, 
    -0.03217112f, 0.01182037f, 0.04424540f, -0.01684781f, -0.02645746f, 0.03526632f, 0.03886506f, 0.01300847f, 
    0.00592994f, -0.02946814f, -0.05352528f, -0.05916299f, 0.01391181f, 0.02970886f, -0.00382306f, 0.04534854f, 
    0.04338036f, 0.00581456f, -0.04191421f, -0.00046315f, 0.02505141f, -0.04327631f, 0.03033072f, -0.00492721f, 
    0.05190263f, -0.00721216f, 0.00668191f, 0.04377740f, -0.04553219f, -0.05526162f, 0.04052252f, -0.02835252f, 
    0.02882112f, -0.03210168f, -0.06153027f, 0.03332188f, 0.00843542f, -0.06300288f, 0.02944023f, 0.02593189f, 
    -0.38052920f, 0.22471738f, 0.01421684f, 0.16059881f, -0.14247228f, -0.16845526f, 0.10236699f, 0.17119417f, 
    -0.46061864f, -0.31480652f, 0.08736858f, -0.06087453f, 0.11166266f, 0.03327309f, 0.11537072f, -0.15728155f, 
    -0.10420237f, 0.04613752f, -0.39405176f, 0.00997186f, 0.08265730f, 0.10440068f, 0.12064792f, 0.09590980f, 
    0.00003655f, -0.00809157f, -0.02169733f, 0.19458945f, -0.15427494f, 0.13737293f, 0.16737917f, 0.08558548f, 
    0.25637603f, 0.18421704f, 0.11040954f, 0.01649785f, -0.03393418f, 0.16591248f, 0.19015716f, 0.23856559f, 
    -0.07327211f, -0.11126377f, 0.11231904f, 0.01629797f, 0.01990743f, -0.29930249f, -0.07576130f, 0.07175484f, 
    -0.09884735f, -0.09267993f, -0.15766765f, -0.03059797f, -0.11318911f, -0.05090058f, -0.16280524f, 0.02249383f, 
    0.08358683f, -0.00458800f, 0.07030736f, -0.00493856f, -0.01683948f, -0.02337454f, 0.02144081f, 0.02125953f, 
    0.00676838f, -0.09939835f, 0.01686744f, 0.09220061f, 0.07942877f, 0.07411219f, -0.05198599f, -0.12176774f, 
    -0.08086684f, -0.11540741f, 0.16438806f, 0.19567408f, 0.24970686f, -0.09977068f, 0.08189070f, -0.05378549f, 
    0.28174582f, -0.05211405f, 0.01089138f, 0.21529876f, 0.20021206f, 0.06581296f, 0.22980233f, 0.05624953f, 
    -0.02069651f, 0.17586283f, -0.24551407f, -0.04088231f, -0.10413559f, -0.00325710f, -0.12880442f, 0.02944161f, 
    -0.02390989f, -0.10022119f, -0.00782874f, 0.19469884f, 0.34116280f, -0.01940041f, -0.07637046f, -0.13069679f, 
    0.12331961f, -0.05190163f, 0.06817473f, 0.23276402f, 0.16441035f, 0.11043211f, -0.21995220f, 0.23271754f, 
    0.09906983f, 0.02535986f, 0.22204763f, -0.21483389f, -0.12255216f, 0.12391114f, 0.09014540f, 0.01784445f, 
    -0.15949710f, -0.10665954f, -0.05268254f, 0.00204411f, -0.04382231f, 0.04878988f, 0.14840141f, 0.05295272f, 
    0.01079286f, 0.00883333f, 0.09128603f, 0.24867538f, 0.10726041f, -0.29401600f, -0.24154191f, 0.29955986f, 
    0.09065008f, -0.12280826f, -0.21930018f, -0.05633296f, -0.11181867f, -0.16884270f, 0.25655240f, -0.05502702f, 
    -0.25605896f, 0.13848990f, 0.10223782f, 0.00641502f, 0.18483628f, 0.07982450f, -0.00137514f, 0.07661556f, 
    -0.01746529f, -0.40285078f, -0.11329503f, 0.14053005f, 0.21723819f, 0.08168556f, 0.03401143f, 0.01745315f, 
    0.06620844f, -0.13551921f, -0.23297779f, 0.04612861f, -0.09183254f, 0.04376054f, -0.07102980f, -0.03297966f, 
    0.05353314f, -0.02018761f, -0.01759090f, 0.24305187f, 0.22409175f, -0.06013500f, -0.22806451f, -0.14388400f, 
    0.16394548f, 0.09385783f, 0.01973030f, 0.23068562f, -0.19935462f, 0.12736547f, -0.15870559f, 0.09592698f, 
    0.07544139f, -0.02601268f, 0.12782726f, -0.27041164f, -0.15147792f, 0.26972431f, -0.04916633f, 0.05461125f, 
    0.04697659f, -0.01318045f, 0.22952622f, 0.19312264f, 0.13247815f, 0.03889313f, -0.26083413f, 0.03885632f, 
    -0.21170028f, -0.05900293f, 0.06669161f, 0.19898929f, 0.03700767f, -0.01169241f, -0.16733967f, -0.28749934f, 
    0.09991751f, 0.02357054f, 0.16962555f, 0.20809190f, 0.16484362f, 0.02897411f, -0.04117572f, -0.05444681f, 
    -0.00344613f, 0.17082128f, 0.11763182f, -0.09602116f, 0.12542751f, -0.25792426f, 0.19761339f, -0.27584535f, 
    0.24125633f, -0.24147657f, 0.01108397f, 0.16168354f, 0.13729960f, 0.08870234f, 0.13027085f, -0.06559099f, 
    -0.00663325f, 0.20223208f, 0.01219307f, 0.17291935f, 0.08501512f, -0.08588119f, 0.14517176f, 0.07966308f, 
    -0.01139682f, 0.18907715f, -0.48257434f, 0.11103452f, -0.05468984f, 0.07510437f, -0.05970793f, 0.03287559f, 
    -0.09845335f, 0.16358556f, 0.10204574f, -0.18045382f, -0.10850553f, -0.01082869f, 0.16367996f, -0.22226414f, 
    0.22767004f, -0.23232399f, 0.07301737f, 0.04052294f, -0.00947433f, 0.14792161f, 0.09404262f, -0.09573312f, 
    0.03743869f, -0.00518082f, 0.11134127f, 0.23413143f, -0.13035496f, -0.29406774f, 0.40450388f, 0.03374970f, 
    -0.28617120f, 0.09377196f, -0.20644915f, 0.02157725f, 0.10857661f, 0.09436308f, 0.05985074f, -0.12924999f, 
    -0.06113630f, 0.11761525f, -0.42072985f, 0.15406339f, -0.10393622f, 0.17210622f, 0.14237022f, -0.07249064f, 
    -0.20200531f, -0.26066965f, -0.08238064f, 0.08026890f, 0.21429931f, -0.11097698f, 0.13722619f, 0.26860490f, 
    0.08709576f, -0.42261779f, -0.12048542f, -0.12934981f, 0.12303733f, 0.06548064f, 0.17111735f, -0.01786341f, 
    0.26260898f, 0.15789656f, -0.06510089f, 0.26045531f, 0.08478613f, 0.00823254f, 0.04077145f, -0.03761375f, 
    -0.01973253f, 0.14306813f, 0.10721168f, 0.11824878f, -0.01630891f, -0.03254982f, -0.00807719f, -0.13926990f, 
    -0.09608246f, 0.32413408f, 0.05450936f, 0.05823442f, 0.03015537f, 0.07346377f, 0.25707522f, 0.10795171f, 
    0.13408995f, 0.03757124f, -0.02732696f, 0.21150510f, 0.05535821f, -0.31999370f, -0.32109269f, 0.01206371f, 
    -0.02516774f, 0.15750130f, 0.15236856f, 0.22707608f, 0.35044718f, -0.20389742f, 0.21881877f, -0.00429831f, 
    -0.06226204f, 0.09261338f, 0.02831569f, 0.08000926f, 0.11710823f, 0.13983417f, -0.18549933f, -0.16108613f, 
    0.05746796f, -0.01309747f, -0.28036001f, 0.02703783f, -0.18919355f, 0.17621587f, 0.00127752f, -0.01858963f, 
    0.09858481f, -0.06515234f, -0.08690632f, -0.12740153f, 0.02971304f, -0.25456798f, 0.01106277f, 0.17443094f, 
    0.07669321f, 0.00250054f, -0.07418426f, 0.01087717f, -0.10107252f, 0.00705246f, -0.22368897f, 0.16273856f, 
    -0.09463901f, 0.06388345f, -0.51620710f, -0.18716206f, 0.02984475f, 0.15668623f, 0.10053007f, 0.13006043f, 
    0.03362466f, 0.21253534f, -0.24095304f, -0.34580478f, -0.19592208f, -0.18478319f, -0.08070662f, 0.10893793f, 
    0.18672957f, -0.10872872f, 0.17958663f, -0.04825803f, -0.02011436f, -0.18980388f, -0.26337966f, -0.12526114f, 
    0.11024822f, -0.03069690f, -0.00977777f, -0.03459668f, 0.01959841f, 0.47942886f, -0.05738155f, -0.09173842f, 
    0.01524860f, 0.01894506f, 0.01256018f, 0.15786742f, -0.22871311f, 0.08802661f, -0.10268018f, 0.12659545f, 
    0.07238026f, -0.05903947f, -0.11713737f, 0.08045960f, 0.03897227f, -0.24709731f, 0.00623271f, 0.40223426f, 
    0.01706520f, 0.25444716f, -0.08624981f, -0.03461489f, -0.06469977f, 0.36582127f, -0.15347680f, 0.06622578f, 
    -0.47011787f, -0.47146991f, -0.15494496f, -0.02272064f, 0.08412512f, 0.03485324f, 0.12291604f, 0.06024047f, 
    0.11189933f, 0.21448143f, 0.07364708f, 0.11363278f, 0.06063151f, 0.22774443f, 0.01548084f, -0.04848267f, 
    0.22133110f, 0.01906794f, -0.09324552f, 0.07222264f, -0.01289572f, 0.19999713f, -0.06295665f, 0.04256316f, 
    -0.13237894f, 0.17922822f, -0.10979075f, 0.00517143f, 0.08970938f, -0.09061235f, 0.11185869f, -0.14054628f, 
    -0.11772055f, -0.05413475f, 0.02517986f, 0.08367541f, 0.14563742f, 0.05560723f, 0.01042792f, -0.10049590f, 
    0.11818694f, -0.06958900f, -0.08274443f, 0.00911040f, 0.19683123f, -0.25216112f, -0.06099532f, 0.15583934f, 
    -0.11083363f, -0.08323016f, 0.28635669f, -0.19413657f, -0.30831039f, -0.00374854f, -0.40342247f, -0.44415334f, 
    0.00551109f, -0.07645454f, 0.22392854f, 0.16049899f, 0.09842719f, -0.07847353f, -0.02582981f, -0.27751321f, 
    -0.27033105f, -0.05661072f, -0.13504344f, 0.12316147f, 0.17685471f, 0.12167224f, 0.15530251f, 0.00587652f, 
    0.29788071f, -0.21171105f, 0.15225822f, -0.09930912f, -0.00405490f, 0.07411198f, -0.03994123f, -0.04443897f, 
    0.10771010f, 0.19517286f, 0.12879753f, 0.15103836f, -0.11996341f, 0.08615652f, -0.08144929f, -0.08851691f, 
    0.00902218f, 0.14652629f, -0.60378987f, -0.28579542f, 0.08283561f, 0.15927511f, 0.19340552f, 0.05478208f, 
    0.11277221f, -0.02204513f, 0.08775157f, 0.26832342f, -0.34260711f, -0.12018371f, 0.00941283f, -0.36968389f, 
    -0.08521236f, -0.08996483f, 0.03065887f, 0.00334292f, 0.47568917f, 0.01935727f, 0.06776550f, 0.04721507f, 
    0.14605971f, -0.05992124f, 0.02487355f, 0.09610186f, 0.24527304f, 0.25803718f, -0.17054974f, 0.26969275f, 
    0.08345244f, 0.07113968f, -0.00057440f, -0.14174236f, 0.06799325f, 0.07291029f, -0.04557585f, -0.15262498f, 
    0.15762399f, 0.05751015f, -0.03581693f, 0.21744345f, 0.03040175f, 0.13443901f, 0.00388684f, 0.26152444f, 
    0.21496299f, -0.17506853f, -0.02994765f, -0.01401630f, -0.22293214f, 0.04971474f, 0.07671462f, -0.07656365f, 
    -0.29670677f, -0.07125766f, -0.00681606f, -0.08358674f, 0.29951781f, -0.10717092f, -0.06822912f, 0.08773857f, 
    -0.02217038f, 0.13385993f, 0.07958689f, 0.21081088f, 0.12693869f, 0.07041223f, 0.07633682f, 0.12695995f, 
    0.07651853f, 0.19855459f, -0.43693158f, 0.23177184f, -0.00349328f, 0.08534368f, 0.10360970f, 0.11656298f, 
    -0.02611852f, -0.02571964f, 0.04324926f, -0.13387594f, -0.03466847f, 0.23161630f, 0.12260535f, -0.06899472f, 
    -0.19761379f, 0.04625015f, 0.18606399f, 0.20841116f, -0.03429882f, 0.36093330f, 0.13382550f, 0.05760048f, 
    0.09342640f, 0.25617912f, -0.13948493f, -0.06873528f, -0.07752128f, 0.07650774f, 0.04881825f, 0.07093842f, 
    -0.10381854f, 0.16281863f, 0.14099017f, 0.08375268f, -0.00785366f, -0.06332524f, -0.22459474f, 0.19556974f, 
    -0.45210090f, -0.03448105f, 0.06715339f, -0.00827421f, 0.04060617f, 0.28358796f, 0.16330299f, -0.23858750f, 
    -0.34524086f, -0.17919514f, 0.20965976f, -0.04021297f, -0.07415108f, 0.00626906f, -0.02949175f, -0.03915231f, 
    -0.49773782f, 0.21875507f, -0.11415657f, 0.14183475f, 0.14833449f, -0.03377010f, 0.15430525f, 0.18351729f, 
    0.10836910f, -0.12068766f, -0.14974414f, -0.26829526f, 0.04769569f, 0.15457089f, 0.02766910f, -0.05586488f, 
    0.32637581f, 0.02569699f, -0.09716244f, 0.27659115f, 0.33349398f, 0.10248690f, -0.11660768f, -0.00222548f, 
    -0.06872907f, -0.21512753f, 0.10404712f, 0.01094093f, 0.32333863f, -0.00568446f, -0.06565239f, -0.08521916f, 
    -0.03970609f, 0.28104869f, 0.03329932f, -0.08947475f, -1.04408944f, -0.42147908f, -0.15302329f, 0.14600725f, 
    0.15142231f, 0.08164035f, -0.09333473f, -0.02573149f, -0.00552269f, 0.11464211f, -0.29380554f, -0.24722198f, 
    -0.10076338f, 0.02404119f, -0.14945631f, 0.03659748f, 0.02893957f, -0.01023469f, -0.11819516f, -0.01186604f, 
    0.28543621f, 0.07132383f, -0.05650368f, -0.01369006f, 0.16992633f, -0.22093110f, 0.04872221f, 0.28445998f, 
    -0.17853081f, 0.04971503f, -0.15589724f, 0.04336941f, 0.01206095f, 0.01855383f, 0.02768448f, 0.15303808f, 
    0.04256677f, 0.05212684f, 0.13637380f, -0.10799614f, 0.27083480f, -0.14984162f, -0.03248851f, -0.07029779f, 
    0.11135425f, -0.36008951f, 0.21756491f, -0.34329095f, 0.02218269f, 0.08839095f, 0.27020457f, 0.07558282f, 
    0.05716597f, -0.00361004f, 0.09796061f, 0.19395080f, -0.41461784f, -0.18332806f, -0.08968109f, 0.02016728f, 
    0.22972000f, 0.08931345f, -0.19529872f, -0.08664411f, -0.35773122f, -0.20007578f, -0.32247514f, -0.00050616f, 
    -0.12493974f, 0.01223592f, -0.21977535f, 0.26286829f, -0.16553842f, -0.02114983f, 0.11233856f, 0.00572125f, 
    0.12845391f, 0.10994621f, -0.05299204f, -0.05401736f, 0.05677960f, -0.07364810f, 0.05119347f, -0.06840526f, 
    -0.07362782f, 0.07468041f, 0.02517491f, 0.19290499f, 0.02102977f, -0.03974887f, -0.00726948f, 0.09237504f, 
    0.06490667f, -0.16883942f, 0.02328384f, 0.08575055f, 0.04198946f, 0.18949938f, -0.00108832f, -0.30043033f, 
    -0.21325804f, 0.51447368f, 0.08220573f, 0.24032241f, -0.09083614f, -0.04662730f, -0.00692294f, 0.17114970f, 
    0.02391063f, 0.16544345f, 0.09228875f, 0.06410784f, -0.03774917f, -0.06832557f, -0.00495898f, -0.05138956f, 
    0.11575700f, 0.00400109f, 0.30021238f, -0.34621722f, 0.18574567f, 0.21228279f, 0.13066819f, -0.00825088f, 
    0.18644071f, -0.03143631f, 0.26091340f, 0.09121837f, -0.10936249f, -0.17689171f, 0.10631084f, 0.01287267f, 
    0.07995610f, -0.01408408f, 0.05642205f, -0.18641482f, -0.04316384f, 0.10644392f, -0.13342394f, 0.03623885f, 
    -0.27387771f, 0.29922459f, -0.27133769f, 0.35272381f, -0.25785327f, 0.02830554f, 0.00637359f, -0.08185219f, 
    0.02456292f, -0.03857362f, -0.13481472f, -0.04951398f, 0.26672703f, 0.23390546f, -0.13285328f, 0.41251603f, 
    0.03659448f, -0.07553673f, -0.22116676f, 0.21000919f, -0.05828340f, 0.14976144f, -0.41398281f, -0.00913393f, 
    0.14508273f, -0.04252905f, -0.10520770f, -0.20078538f, -0.05732268f, -0.08087681f, 0.01466519f, -0.08895353f, 
    0.04533909f, -0.06648751f, -0.13349716f, -0.08459437f, -0.07838217f, -0.20795871f, -0.03729508f, 0.06621194f, 
    0.00989881f, -0.06080643f, 0.04384955f, -0.06008689f, -0.04445674f, -0.04727673f, 0.00897968f, 0.00395535f, 
    -0.00810407f, 0.05070938f, -0.06242311f, 0.02650769f, 0.02019935f, 0.03434814f, 0.03409872f, -0.02051625f, 
    -0.00465273f, 0.04463712f, -0.05462432f, 0.04447771f, -0.03529973f, 0.02985174f, 0.02620697f, -0.05297562f, 
    -0.03466295f, 0.01158945f, -0.00153237f, 0.03453854f, -0.01191726f, 0.00374491f, 0.00498311f, -0.01351623f, 
    0.03970725f, -0.02086580f, -0.01515015f, -0.06249308f, 0.01330241f, -0.04442046f, 0.02611524f, 0.03370980f, 
    0.01199088f, 0.02380195f, -0.04293384f, -0.03157823f, 0.00648479f, -0.04793011f, -0.05861889f, 0.04595015f, 
    -0.00962124f, 0.03017090f, -0.05781886f, -0.02287115f, -0.00713177f, 0.02855157f, -0.00033692f, 0.02640533f, 
    -0.02076271f, 0.04140271f, -0.02883987f, -0.03221191f, -0.06434811f, -0.01071920f, -0.05257135f, 0.02095392f, 
    -0.05369410f, 0.03479047f, 0.04240543f, -0.05318490f, -0.02296698f, -0.04009821f, 0.02813450f, -0.00501738f, 
    -0.01402216f, 0.02065745f, -0.06915745f, -0.04291354f, 0.04048824f, -0.06117327f, -0.03128622f, -0.03733447f, 
    -0.00928912f, -0.00386724f, -0.02725133f, 0.00651221f, 0.01276300f, -0.03952435f, -0.02385925f, 0.03192711f, 
    -0.05661923f, 0.04510836f, -0.02058978f, 0.04580643f, -0.03791226f, -0.05621780f, 0.01969189f, 0.01535431f, 
    0.03802687f, -0.06432097f, -0.04944278f, -0.00346626f, 0.04566680f, -0.01689685f, 0.03665569f, -0.03768687f, 
    0.04386502f, 0.00334454f, -0.05935081f, -0.01507798f, 0.00018872f, -0.04831756f, 0.02364133f, -0.05859421f, 
    -0.05856203f, 0.02625086f, 0.01299849f, -0.02169171f, 0.01245075f, 0.04429444f, -0.04394979f, -0.02686078f, 
    -0.02702880f, -0.01402772f, -0.00457782f, 0.04426101f, 0.00504276f, 0.02498972f, -0.00113026f, 0.04204800f, 
    0.04074928f, -0.00054330f, -0.05680407f, -0.01173174f, -0.02927596f, -0.05293113f, 0.01776141f, 0.01152498f, 
    -0.06781866f, -0.02912524f, -0.05896343f, -0.04994389f, -0.00677479f, 0.02983178f, -0.05839686f, 0.03089057f, 
    -0.02078649f, 0.04680892f, -0.04216682f, -0.04689560f, 0.03220894f, 0.02843585f, 0.03285970f, -0.03976071f, 
    -0.01674722f, 0.04288789f, -0.07076179f, 0.02258153f, 0.01269966f, -0.04880649f, 0.00093940f, 0.01292080f, 
    0.02659970f, -0.06568384f, -0.03427888f, 0.00490151f, -0.01099729f, 0.03376607f, -0.04421923f, -0.05255516f, 
    -0.06165803f, 0.02575249f, 0.01759229f, -0.05876346f, -0.03871497f, -0.04480930f, 0.03584176f, -0.01667228f, 
    -0.01866538f, -0.06559509f, -0.02971345f, 0.04474501f, -0.01665201f, 0.02710250f, -0.01341513f, 0.03651063f, 
    -0.01904858f, 0.03366268f, 0.00722319f, 0.02867104f, -0.06977682f, 0.02055078f, -0.06538734f, -0.00967346f, 
    -0.03344783f, -0.02351687f, -0.02803390f, -0.06728726f, 0.00663865f, 0.02427059f, 0.00351117f, -0.02948416f, 
    -0.03901408f, -0.04160124f, 0.01045472f, -0.04674540f, 0.00890185f, -0.01095150f, -0.06679589f, 0.00121055f, 
    0.02011671f, 0.03915519f, -0.00166262f, 0.02156448f, 0.01460329f, -0.00666712f, -0.03499636f, 0.03798095f, 
    -0.06911884f, 0.04315495f, -0.00297071f, -0.03021808f, 0.03421401f, -0.00632224f, 0.00646767f, 0.00222870f, 
    0.04077382f, 0.02795234f, -0.04624031f, 0.03987091f, -0.01894246f, 0.01163904f, 0.04362113f, -0.05411655f, 
    -0.04849001f, 0.04321827f, -0.04453195f, 0.03485801f, -0.03652491f, 0.04527675f, 0.00737049f, 0.02641824f, 
    0.02790901f, -0.06045943f, -0.02459471f, 0.02961365f, 0.03072630f, -0.02200681f, 0.03300381f, -0.05588835f, 
    0.00013301f, -0.03884780f, -0.02080351f, 0.02525532f, 0.03967458f, -0.05273188f, 0.03342539f, 0.03659787f, 
    0.03580777f, -0.06118833f, -0.06043899f, -0.00914705f, -0.03395591f, -0.01454796f, 0.04442837f, 0.03866288f, 
    -0.04533569f, -0.01566496f, -0.02262538f, -0.05738935f, -0.04864697f, 0.03944545f, 0.04427518f, 0.04727046f, 
    -0.04646437f, -0.06357181f, 0.04929088f, -0.02425035f, -0.01536878f, 0.02016378f, 0.03485765f, -0.07059622f, 
    -0.04408972f, 0.00422065f, -0.04241803f, -0.05565057f, 0.01148049f, 0.02988254f, 0.03229116f, 0.00791446f, 
    0.02525185f, 0.04206354f, -0.04795733f, -0.05374021f, 0.02102756f, 0.01700419f, 0.01783326f, 0.04361117f, 
    -0.04306934f, -0.05689310f, 0.04315816f, -0.02594104f, 0.05028193f, 0.00261009f, -0.04572066f, 0.04930082f, 
    -0.03730808f, 0.02907970f, 0.04478671f, -0.01335619f, -0.06016686f, -0.05575638f, -0.04413169f, 0.01754274f, 
    0.04431346f, -0.03803568f, 0.00051494f, 0.01914723f, -0.02766180f, 0.02846541f, 0.02448041f, 0.01313079f, 
    -0.06448213f, -0.05707313f, -0.01994913f, 0.03050485f, -0.06165423f, -0.06374878f, -0.00085830f, 0.00288560f, 
    -0.04789935f, -0.02510160f, -0.00445770f, 0.02065584f, 0.01595772f, 0.00670383f, -0.02641120f, 0.00491553f, 
    0.03620422f, 0.00092423f, 0.00435906f, -0.03821602f, -0.03057276f, -0.05067994f, 0.01835303f, -0.01540297f, 
    0.04097898f, -0.03552395f, -0.05872135f, 0.01107308f, 0.02704777f, -0.01538457f, 0.00052600f, -0.04766035f, 
    -0.06507401f, -0.01366265f, 0.04952472f, -0.00296565f, 0.01600753f, -0.03724588f, 0.01752550f, -0.01878631f, 
    -0.03266158f, 0.00204532f, -0.04194932f, -0.06256238f, 0.04428037f, 0.00565236f, -0.00023984f, -0.05575181f, 
    -0.01485571f, 0.01937602f, -0.02366635f, -0.00629975f, 0.01372061f, 0.02091111f, 0.02832367f, -0.00215112f, 
    0.01561548f, -0.00450255f, 0.01155529f, -0.04410877f, -0.04539800f, 0.03236694f, -0.01016380f, -0.00407593f, 
    -0.06026861f, 0.04668519f, 0.04626366f, -0.03448712f, 0.04796914f, 0.02081217f, -0.05311184f, -0.05315654f, 
    -0.02865374f, 0.03665731f, 0.00469370f, -0.05149586f, 0.01794094f, 0.03587986f, 0.04906484f, -0.00307970f, 
    -0.01974733f, 0.04148225f, 0.02810675f, 0.05098824f, -0.05364304f, -0.03016319f, 0.00888694f, -0.06191460f, 
    -0.00579289f, -0.03178647f, -0.03100028f, -0.05283447f, -0.03378740f, 0.01169749f, 0.04355632f, 0.01816805f, 
    -0.00322762f, 0.03152617f, -0.04642391f, 0.04898740f, -0.00356746f, -0.05065667f, 0.01198943f, -0.02551385f, 
    -0.03482984f, 0.03774005f, 0.03237504f, -0.06130531f, -0.00068605f, 0.03942057f, 0.02513027f, 0.02922684f, 
    -0.04918756f, 0.00535351f, 0.01962028f, 0.04668282f, -0.02682314f, -0.03783059f, -0.04557128f, -0.05775431f, 
    -0.04069566f, -0.02267512f, 0.03876991f, 0.04568658f, 0.03615040f, -0.00242470f, -0.00028664f, 0.01459711f, 
    -0.00978504f, -0.01737863f, 0.02224133f, 0.03124767f, 0.01662182f, 0.03940155f, 0.03931103f, -0.06635834f, 
    -0.01627718f, 0.03232631f, -0.01588475f, 0.04049455f, 0.00846681f, -0.05241096f, -0.01911730f, 0.03709718f, 
    -0.05449018f, 0.01485374f, -0.02863417f, 0.02794712f, 0.03579073f, 0.01299942f, -0.01625087f, 0.04714040f, 
    0.04623028f, 0.02608410f, 0.01095138f, 0.04221867f, 0.04802358f, 0.02210926f, -0.02914799f, -0.01594264f, 
    -0.03656346f, 0.00360705f, 0.01371015f, -0.00304735f, -0.03422121f, -0.04606542f, -0.03355126f, -0.06582676f, 
    0.02216857f, -0.00077840f, 0.01704958f, -0.05514587f, -0.00171269f, 0.00218134f, -0.06130139f, -0.00443567f, 
    0.04494287f, -0.01019751f, 0.02011940f, -0.03442737f, -0.04916478f, -0.03955512f, 0.02870645f, -0.02091138f, 
    -0.01402801f, 0.00356454f, -0.06052256f, 0.01607650f, 0.01696482f, -0.05104642f, -0.02801142f, 0.03233028f, 
    -0.03461594f, 0.01683361f, -0.02632030f, -0.03631456f, -0.06017881f, 0.04085244f, 0.00060670f, 0.02539492f, 
    0.04635337f, -0.01095991f, -0.01226924f, -0.01900572f, -0.06164719f, -0.00803928f, 0.02418873f, -0.04991797f, 
    -0.03002841f, -0.05217678f, -0.02395836f, 0.01884331f, -0.05174010f, -0.02660517f, -0.06507476f, -0.04407649f, 
    -0.00107831f, 0.02328516f, 0.04813477f, -0.04657778f, 0.04765822f, 0.04964503f, 0.03255793f, -0.00601971f, 
    0.01910441f, -0.04348201f, -0.04474965f, -0.06041725f, 0.01902359f, 0.02732752f, -0.05803914f, -0.05682037f, 
    -0.05663573f, 0.00287841f, -0.05693859f, -0.04324945f, -0.01561349f, -0.00004613f, -0.05110732f, -0.05954039f, 
    -0.01304053f, -0.06355750f, -0.00885084f, -0.06077120f, 0.01174170f, -0.03104920f, -0.05366905f, 0.05100749f, 
    -0.03740373f, 0.04115462f, -0.04314970f, -0.06357685f, -0.06616009f, -0.05163031f, -0.03429669f, -0.00794044f, 
    -0.00353246f, -0.05149147f, 0.04677407f, 0.01379659f, 0.04169540f, 0.01451930f, -0.03482336f, 0.03399186f, 
    -0.04150961f, 0.01195705f, -0.06039957f, 0.00546370f, -0.05679834f, 0.04506518f, -0.03340592f, -0.06312919f, 
    -0.06089933f, -0.05392863f, -0.05564448f, 0.00247086f, -0.03509365f, -0.04197485f, -0.05941200f, 0.01016659f, 
    0.04327829f, 0.01630890f, -0.05032190f, -0.03729945f, 0.02507236f, -0.04002441f, -0.02768649f, -0.04072409f, 
    0.04676220f, 0.04825200f, 0.02986105f, 0.05268413f, 0.00834719f, 0.02215212f, 0.04642991f, 0.02280074f, 
    0.03111920f, 0.03353327f, -0.05008840f, 0.03326201f, 0.02833689f, -0.06369767f, -0.06581066f, 0.04022138f, 
    0.05038280f, 0.00626924f, 0.04241016f, -0.04422041f, 0.01875183f, 0.03664324f, -0.00555132f, -0.03433509f, 
    0.01696212f, 0.01400428f, 0.01996328f, 0.03122401f, -0.03198100f, 0.00060551f, 0.01013512f, -0.06411679f, 
    -0.02680854f, -0.04315708f, -0.03982336f, 0.03952317f, -0.03460642f, 0.00437886f, -0.01731787f, -0.06254600f, 
    -0.01938048f, -0.03154317f, -0.05088943f, -0.03676945f, 0.03121869f, 0.00769608f, 0.01107201f, -0.06193579f, 
    0.03642023f, -0.06647478f, 0.03023089f, 0.04161406f, -0.06048143f, 0.01289927f, 0.00249072f, -0.01901476f, 
    -0.05309613f, 0.03323729f, -0.03048574f, -0.03777376f, -0.03344755f, -0.03664852f, 0.03472474f, -0.06475852f, 
    0.04909190f, -0.06133695f, 0.03954364f, 0.02040302f, 0.01143725f, -0.03918773f, 0.00602561f, -0.04496283f, 
    0.04027316f, -0.00781709f, 0.03413518f, -0.04476896f, 0.02688491f, -0.04448962f, 0.05071165f, 0.01567975f, 
    0.00372943f, 0.03405609f, 0.01518952f, 0.00778582f, -0.06416114f, 0.03844598f, 0.04583009f, 0.00224650f, 
    -0.02192792f, 0.01758691f, 0.04156068f, -0.06140795f, 0.02062499f, 0.02296216f, 0.04800922f, -0.00666160f, 
    -0.01732029f, -0.01715005f, 0.02558827f, -0.03404674f, -0.06312352f, 0.00549895f, 0.02475208f, -0.00834733f, 
    0.00443807f, 0.01574323f, 0.02419965f, 0.03609494f, -0.00899355f, -0.02366423f, -0.00592356f, -0.06124181f, 
    -0.06687069f, -0.00282797f, -0.05883472f, 0.04073837f, 0.02115914f, 0.02778661f, 0.02820701f, 0.02575334f, 
    0.03366249f, -0.02614914f, 0.03516087f, 0.03697526f, -0.00156693f, -0.01899020f, 0.04344690f, -0.05243005f, 
    -0.06269626f, 0.02460233f, -0.04150721f, -0.02278436f, -0.05321483f, -0.01912772f, -0.03515862f, 0.00240335f, 
    -0.02775637f, -0.02270711f, -0.04429012f, -0.02929651f, -0.00128876f, 0.03893172f, 0.01802045f, 0.00821987f, 
    -0.00238528f, 0.03604762f, 0.01514760f, -0.05914447f, 0.02263698f, -0.02819553f, -0.05663764f, -0.01780225f, 
    -0.01262330f, 0.03674246f, -0.01374129f, -0.01977909f, 0.00892076f, -0.05015371f, -0.00166987f, -0.04061796f, 
    0.03959377f, -0.00156257f, -0.00702168f, -0.00756542f, -0.03889978f, -0.06615856f, 0.03709610f, -0.04304488f, 
    0.02212742f, -0.03191522f, -0.00586291f, -0.01894475f, 0.02574282f, -0.06144502f, -0.00579174f, 0.02970062f, 
    0.01574412f, -0.04929121f, 0.02575239f, -0.05879225f, -0.02353227f, -0.00819240f, 0.05094297f, -0.05007941f, 
    -0.04733441f, -0.05324323f, 0.04172428f, -0.05177260f, 0.02261116f, 0.00313671f, 0.02934799f, -0.01431267f, 
    -0.01958331f, -0.04433856f, 0.00061519f, -0.04564525f, -0.02474254f, 0.04952301f, -0.00820660f, 0.00942918f, 
    -0.06708534f, 0.00632556f, -0.05864948f, 0.02530697f, -0.04195169f, -0.01353067f, 0.04696463f, 0.00838266f, 
    -0.01978772f, -0.02336573f, -0.03207472f, 0.01913426f, -0.03065269f, 0.02219097f, 0.01842766f, 0.00696750f, 
    0.01198144f, -0.02185322f, -0.00740169f, 0.00210582f, -0.04828368f, 0.02925516f, 0.03357721f, 0.01581060f, 
    -0.02715597f, 0.02865524f, -0.03129471f, -0.00050093f, -0.06527063f, 0.00210373f, 0.00442037f, 0.01063322f, 
    -0.06120564f, -0.04898465f, 0.01806373f, -0.04449164f, -0.00753747f, -0.01238117f, -0.01434439f, 0.01825814f, 
    -0.03817796f, -0.04075572f, -0.02744906f, 0.04243834f, -0.01042882f, 0.02562374f, 0.02833625f, -0.00700221f, 
    -0.03463385f, -0.00209547f, -0.06128931f, -0.01860161f, -0.04658391f, -0.04582947f, -0.03765476f, -0.02300413f, 
    -0.11695178f, 0.07600264f, -0.28652242f, -0.10376301f, -0.11161698f, 0.07751782f, 0.21117932f, 0.20471829f, 
    0.20650440f, -0.50441033f, -0.05079806f, -0.03196831f, 0.09140189f, -0.05208842f, -0.11872748f, -0.01016708f, 
    -0.04038928f, 0.11221007f, 0.20214334f, 0.11757997f, 0.00860842f, 0.09024585f, 0.00383764f, 0.16907112f, 
    0.15786022f, -0.01664697f, 0.00799309f, 0.29397124f, 0.10082896f, 0.05282465f, 0.01878448f, -0.26425585f, 
    0.04121796f, -0.25535059f, 0.15979587f, 0.01053340f, 0.28909335f, 0.34776193f, -0.09719765f, 0.09989018f, 
    -0.14261980f, -0.03100974f, 0.18692775f, 0.13478579f, -0.03528983f, -0.75915605f, -0.07975420f, -0.00079435f, 
    0.01124652f, -0.11081190f, 0.08865522f, -0.07327693f, 0.12428543f, 0.17712723f, 0.13718863f, 0.29402396f, 
    0.10133528f, 0.11801856f, 0.00011197f, -0.17442951f, -0.03385022f, 0.13078317f, 0.09433448f, -0.14468192f, 
    0.02560663f, -0.18681699f, 0.06350673f, 0.09651812f, 0.32286996f, 0.01540785f, 0.19658911f, -0.08169912f, 
    0.05572550f, 0.20052794f, 0.19791663f, 0.32595530f, -0.04856459f, -0.23686728f, -0.14140122f, 0.02073095f, 
    0.01767995f, 0.18703990f, 0.12071432f, 0.04226169f, -0.00063918f, 0.17246372f, -0.02632721f, -0.21872018f, 
    0.12919074f, 0.13284437f, -0.17671669f, 0.02682524f, -0.14214434f, 0.03233019f, 0.20037888f, -0.07364815f, 
    0.00302754f, 0.11553945f, 0.18279259f, 0.25061888f, -0.04044579f, -0.08771553f, 0.03078661f, 0.10656004f, 
    -0.29397470f, -0.18771420f, -0.02258291f, -0.03182370f, -0.03750809f, 0.03951950f, -0.01260392f, -0.06840698f, 
    -0.16245826f, 0.12162738f, -0.25924903f, 0.18566020f, 0.00257647f, 0.25273395f, 0.06117994f, -0.01051259f, 
    0.02307186f, -0.11279403f, 0.20045954f, 0.23208807f, 0.23463283f, 0.08799022f, -0.33709905f, -0.13768801f, 
    -0.24747653f, 0.14220163f, 0.23625092f, -0.28872353f, 0.20466502f, 0.11129870f, 0.01024320f, 0.25813311f, 
    0.14528285f, 0.24922593f, 0.07099033f, 0.03585135f, 0.06128230f, -0.12395196f, -0.01733974f, 0.07878626f, 
    -0.75177056f, -0.38737911f, -0.13350774f, 0.01270260f, -0.13239226f, 0.06377338f, 0.08786543f, 0.10888027f, 
    0.02597378f, 0.43194470f, 0.26252687f, 0.10355347f, -0.25357226f, -0.19177349f, 0.13754523f, -0.11933763f, 
    -0.00411450f, 0.05594946f, 0.13434599f, -0.08495473f, -0.25224754f, -0.01439697f, 0.07917784f, -0.03060802f, 
    0.07778015f, -0.04094598f, 0.09555922f, -0.29404449f, 0.00085683f, 0.14300412f, -0.07064363f, -0.03766601f, 
    0.01488299f, -0.13497621f, -0.09678295f, -0.11393655f, 0.38963041f, 0.10904098f, -0.03456329f, 0.00534889f, 
    -0.02639342f, 0.08560127f, 0.10787816f, -0.09776079f, 0.00731774f, -0.03806835f, -0.08972199f, 0.19745275f, 
    -0.23529290f, 0.26164705f, -0.02484202f, -0.15339981f, -0.06279864f, -0.32857955f, -0.48985079f, -0.30831826f, 
    -0.00960170f, -0.00009596f, -0.02868343f, -0.07719893f, -0.23959638f, -0.05232153f, -0.06242209f, -0.85041624f, 
    -0.33060768f, -0.48346332f, 0.18449663f, 0.14891790f, -0.04674513f, 0.03934164f, -0.01645963f, 0.15032360f, 
    0.03312891f, 0.09729332f, -0.24117680f, 0.02378105f, 0.03133112f, 0.02377863f, -0.00565861f, -0.02449297f, 
    -0.11261501f, 0.34760162f, 0.09231678f, 0.22092400f, -0.25128484f, 0.24417454f, -0.04061524f, 0.03446265f, 
    0.27118632f, 0.02387461f, -0.67632455f, -0.01945425f, 0.04659628f, -0.01378250f, -0.00848960f, -0.01220295f, 
    -0.09006048f, -0.10887432f, -0.15605411f, 0.17258990f, -0.04816958f, -0.09996977f, 0.00430762f, -0.05360276f, 
    0.22563809f, -0.13984747f, 0.21019764f, -0.14504184f, 0.07908481f, 0.35101894f, 0.17838183f, 0.07928152f, 
    -0.12709139f, 0.09318227f, -0.05826957f, 0.03926051f, 0.03611522f, -0.49336362f, -0.15365000f, -0.28316486f, 
    -0.02619636f, 0.08772713f, 0.02828053f, -0.02231775f, 0.14269787f, 0.06395210f, -0.07261705f, 0.03680984f, 
    0.05465255f, -0.04969518f, -0.03575593f, -0.30157658f, 0.05332474f, -0.01956269f, -0.01528255f, -0.32682392f, 
    -0.10164507f, -0.16137379f, -0.13651791f, -0.08024212f, -0.03219550f, -0.10600580f, -0.02830684f, -0.08885559f, 
    -0.31375071f, -0.46229511f, 0.23412023f, 0.08239550f, -0.09858746f, 0.03784204f, 0.06082410f, 0.22070010f, 
    -0.11017287f, 0.31675145f, 0.00318422f, 0.06377082f, -0.04057063f, -0.05199251f, -0.08275130f, 0.00023920f, 
    0.11422345f, -0.06152051f, -0.27176842f, -0.22397718f, 0.27227446f, 0.13233046f, -0.04050906f, 0.05359110f, 
    -0.19026922f, 0.00579601f, -0.00996060f, 0.03206856f, 0.00269268f, -0.17470437f, 0.35145685f, -0.13349541f, 
    -0.03594263f, 0.25050837f, 0.07677525f, 0.04411452f, -0.68533546f, -0.24181452f, -0.33221266f, -0.08800530f, 
    0.05003283f, -0.12248423f, -0.13302884f, 0.17041157f, 0.12450092f, 0.29927096f, 0.08749941f, 0.17574883f, 
    0.04518708f, -0.03917336f, 0.08053327f, 0.10534947f, 0.09092520f, -0.01327658f, -0.08924806f, 0.01413618f, 
    -0.00579949f, -0.00189603f, 0.06113062f, -0.02504267f, 0.03814811f, -0.34165883f, -0.04157201f, -0.55405980f, 
    0.06015494f, 0.00943458f, 0.21341379f, 0.35475168f, 0.12340707f, 0.26748246f, -0.08596101f, 0.03613371f, 
    -0.05975676f, 0.09608106f, -0.19761710f, 0.03324832f, 0.29899672f, 0.00177778f, 0.01791904f, -0.21067986f, 
    -0.18063590f, 0.11564531f, 0.08403391f, 0.10055749f, 0.06424372f, -0.08324353f, 0.04783946f, 0.17403765f, 
    -0.09623289f, 0.05706759f, -0.00825900f, -0.55264068f, 0.07702517f, 0.14985086f, 0.30463421f, 0.13780265f, 
    0.06794761f, 0.11825822f, -0.02229048f, -0.25861239f, -0.13112257f, -0.11314306f, -0.10204899f, -0.07668709f, 
    0.19755895f, 0.03516717f, 0.00729075f, 0.18624334f, -0.47094253f, -0.56428885f, -0.42847380f, 0.03878841f, 
    0.14898807f, 0.15599220f, -0.00573064f, 0.01130380f, 0.26788798f, -0.17878640f, 0.13870049f, 0.16205132f, 
    -0.03758893f, 0.05268221f, -0.03658475f, 0.23055938f, -0.10284607f, 0.02889683f, -0.76732969f, -0.41271168f, 
    0.07537233f, 0.09754016f, 0.14421128f, -0.03528304f, -0.23869206f, 0.06346090f, -0.15666188f, 0.11310209f, 
    -0.07336187f, -0.15872560f, -0.13253622f, 0.16407630f, 0.11701331f, 0.06947480f, 0.08301724f, 0.03399421f, 
    0.44199491f, 0.26949582f, 0.14660054f, 0.14613278f, -0.09322359f, 0.11805265f, -0.00557431f, -0.06863042f, 
    -0.01587024f, -0.11397891f, -0.26859814f, 0.06982717f, 0.05239934f, 0.11788112f, 0.01411178f, 0.05942263f, 
    0.01451727f, -0.04673658f, 0.02695489f, -0.22661377f, 0.28793192f, 0.10962019f, -0.00320964f, 0.11095694f, 
    -0.16222391f, -0.15000655f, 0.22119233f, 0.23998521f, 0.15669797f, 0.18324178f, 0.11845786f, -0.15053992f, 
    0.00451738f, -0.00374753f, -0.05431408f, -0.03742257f, -0.71023548f, -0.28407082f, 0.06113331f, 0.20011720f, 
    0.26102045f, 0.09846150f, 0.10818401f, 0.02900635f, 0.04808089f, -0.23233593f, 0.25337887f, -0.15964238f, 
    -0.18404248f, 0.03639398f, -0.06905499f, -0.22556837f, 0.09731520f, 0.09298577f, 0.51425231f, 0.23755054f, 
    0.34653986f, 0.23424970f, 0.27973500f, 0.03577641f, 0.14058821f, -0.23093414f, -0.02007184f, 0.53564656f, 
    0.19120026f, -0.13751501f, 0.06839997f, 0.01498720f, 0.09087192f, 0.06691866f, -0.03520007f, -0.00446498f, 
    -0.20879848f, 0.30179182f, 0.18773443f, -0.14551857f, -0.01038392f, 0.04354376f, 0.16707504f, 0.03533293f, 
    0.04949968f, -0.29001254f, 0.09965599f, 0.37719449f, 0.14721346f, 0.12572567f, -0.00518380f, 0.04412893f, 
    -0.11100765f, -0.08160775f, 0.40239716f, 0.26462549f, 0.30852795f, 0.32446316f, 0.25911024f, 0.03386834f, 
    -0.01048236f, 0.06479581f, 0.03793449f, -0.16287743f, 0.01543103f, -0.21936823f, 0.06982037f, 0.08518913f, 
    -0.08489241f, 0.06735492f, -0.03186989f, 0.09198609f, 0.32841524f, 0.27083653f, 0.11206783f, 0.00079038f, 
    0.16544494f, 0.08411638f, 0.17365986f, -0.11714955f, -0.04805376f, -0.44544795f, 0.02192657f, -0.60649472f, 
    -0.18656829f, -0.08638974f, 0.06430271f, 0.05047262f, 0.10630632f, 0.08347296f, -0.29690135f, -0.16938053f, 
    -0.26241314f, -0.22439881f, -0.06915399f, 0.02862489f, 0.05169034f, 0.01609891f, 0.05835272f, 0.18206111f, 
    0.25112545f, 0.26423049f, -0.05122618f, -0.03330992f, 0.11664464f, -0.06143631f, 0.10818756f, -0.14197133f, 
    0.31537801f, -0.22038665f, 0.24599917f, -0.08398525f, -0.01942382f, 0.00112002f, 0.08912766f, 0.16925342f, 
    0.06938639f, 0.15840827f, -0.03250119f, 0.13498349f, 0.13433832f, 0.07907803f, 0.13660732f, 0.14260320f, 
    0.22247592f, -0.16960537f, 0.08174652f, 0.03505204f, -0.24467601f, -0.02604557f, 0.13583703f, 0.05457049f, 
    0.13938895f, -0.02662738f, -0.32375133f, -0.56992108f, -0.15034740f, 0.03404842f, -0.14747436f, 0.09280431f, 
    0.20459159f, -0.09507450f, -0.05547152f, -0.11329097f, 0.04454390f, 0.01362923f, -0.17819339f, -0.08523379f, 
    -0.01747181f, -0.04898036f, 0.06137296f, -0.02154546f, -0.13169990f, 0.17251529f, 0.43558303f, -0.08870247f, 
    0.03987984f, -0.16538501f, 0.23008132f, -0.09871073f, 0.07079768f, 0.14561568f, -0.03345834f, -0.22086018f, 
    -0.53153813f, 0.06338925f, -0.00189211f, -0.09197862f, -0.08341981f, -0.11915000f, -0.11914702f, -0.01921337f, 
    0.15428796f, 0.06549196f, 0.21244968f, 0.08387004f, 0.01067747f, 0.02797138f, 0.26015118f, 0.17456834f, 
    -0.04262254f, 0.17949215f, -0.17463890f, -0.04403479f, 0.00976162f, 0.21059909f, 0.10114228f, 0.01277033f, 
    -0.16961604f, -0.34680563f, -0.18234240f, -0.06339483f, -0.01273007f, 0.13943931f, 0.21153075f, 0.01125344f, 
    0.04480711f, -0.33593935f, 0.29111901f, 0.28743055f, 0.05863325f, -0.13653837f, 0.22598684f, -0.10720731f, 
    -0.22307658f, 0.12688285f, 0.10417378f, 0.38978061f, 0.00550895f, -0.06037200f, -0.00201362f, 0.05908909f, 
    -0.26247987f, -0.18823677f, 0.10903873f, -0.15241402f, -0.68759364f, 0.12024887f, 0.06897214f, 0.09355426f, 
    0.05589104f, 0.10839797f, 0.32991683f, -0.01332210f, 0.17211948f, -0.30918199f, -0.26727474f, 0.10647091f, 
    0.06868300f, 0.10981025f, 0.16715862f, 0.03725460f, 0.05189788f, 0.04256679f, 0.38191777f, 0.32325038f, 
    -0.46717000f, 0.04640184f, -0.26206967f, -0.26803958f, 0.07027915f, 0.02880576f, 0.22866556f, 0.16372393f, 
    -0.05979626f, -0.02547049f, -0.06217841f, -0.02485954f, 0.40530691f, 0.01272236f, 0.23524792f, 0.07185037f, 
    0.34706533f, 0.19060633f, -0.17192942f, 0.18309322f, -0.10094684f, 0.15526731f, -0.12325761f, 0.10826019f, 
    0.00988311f, 0.09342801f, -0.07141948f, -0.49909726f, -0.11781802f, 0.01393292f, 0.11696160f, -0.02539663f, 
    0.08315849f, -0.24313711f, 0.00596274f, 0.17359543f, -0.09602898f, 0.11077408f, -0.18374150f, -0.01983742f, 
    -0.03196985f, 0.06251583f, -0.08056848f, -0.04514916f, -0.36445203f, -0.00978523f, 0.00288268f, -0.09944941f, 
    -0.10883101f, 0.28129289f, -0.06294879f, -0.03062751f, 0.21451491f, 0.45819071f, -0.30611697f, -0.00484375f, 
    -0.06724823f, -0.15244716f, 0.05497880f, -0.04072800f, 0.03886278f, -0.19451225f, -0.07255050f, 0.12768240f, 
    0.35893294f, -0.11623409f, 0.00992316f, 0.29468992f, 0.02654819f, -0.33943331f, 0.15178546f, 0.05179718f, 
    -0.00203718f, 0.05429479f, -0.04642072f, 0.22036029f, -0.11380942f, -0.00327117f, -0.05284078f, 0.26022407f, 
    -0.12337054f, 0.09371188f, -0.05595198f, 0.10350253f, -0.06293854f, 0.07600352f, 0.05803801f, -0.04466475f, 
    0.13761316f, -0.45884383f, 0.10737428f, 0.18986291f, 0.04453871f, 0.22934918f, 0.13211046f, 0.03692639f, 
    -0.05722822f, 0.06073362f, -0.08173602f, -0.32347563f, 0.06989668f, 0.00567899f, -0.01267257f, 0.03380922f, 
    -0.14734967f, -0.51437104f, 0.25779307f, 0.22051676f, -0.15557785f, 0.11498486f, -0.03246498f, -0.04849949f, 
    -0.18753220f, 0.13050511f, 0.02330994f, -0.28690529f, 0.09949084f, 0.24418804f, 0.25313923f, 0.05732376f, 
    -0.03540727f, 0.11495978f, -0.03477942f, -0.06315894f, 0.29871741f, -0.05991169f, -0.03938712f, 0.08970614f, 
    0.03963380f, 0.23254751f, -0.09411614f, -0.13431180f, 0.02025287f, -0.19969220f, -0.19976236f, 0.33047378f, 
    -0.04169696f, 0.10350061f, -0.23334445f, -0.11963215f, 0.00696185f, 0.12340625f, -0.12599832f, 0.15039271f, 
    0.29371038f, -0.19638327f, 0.19967465f, 0.01966674f, 0.03667089f, 0.07483838f, 0.01696054f, 0.21606097f, 
    0.44154769f, -0.20193189f, 0.28177577f, -0.12521295f, 0.04542723f, -0.27040514f, 0.03553766f, 0.01873632f, 
    0.21049231f, -0.03825883f, 0.33727735f, -0.09415758f, -0.00496524f, -0.16261446f, -0.03456293f, 0.06647928f, 
    0.06805912f, 0.17315225f, -0.06339345f, -0.10381378f, 0.14433222f, 0.04253912f, 0.15021233f, -0.09956193f, 
    0.14913809f, -0.06794047f, -0.16594894f, -0.12260181f, 0.22995667f, -0.09392008f, -0.14328499f, -0.03296360f, 
    0.08197634f, -0.02611582f, 0.14259103f, 0.28293097f, -0.12435370f, -0.08006953f, 0.11988697f, -0.13191074f, 
    -0.21984033f, 0.05982802f, 0.09880667f, -0.21708301f, 0.10227851f, -0.12742385f, -0.18109015f, -0.02855092f, 
    0.00464379f, -0.18657379f, 0.16331077f, 0.02315118f, -0.22376099f, -0.30928907f, 0.26434985f, -0.15076080f, 
    0.02792926f, 0.09793274f, 0.01267382f, -0.18165731f, 0.06817443f, 0.16432515f, 0.23104990f, 0.16405100f, 
    0.46733111f, -0.16456930f, 0.07060894f, 0.09770990f, -0.12881793f, 0.05601137f, 0.08790691f, 0.10033278f, 
    -0.02114090f, 0.13388607f, 0.13289163f, 0.13691610f, -0.04843980f, -0.11647310f, -0.09735186f, 0.09247272f, 
    0.00350408f, -0.07654195f, 0.35647619f, -0.19800998f, 0.02676602f, 0.15556714f, -0.21049993f, 0.02699270f, 
    0.08981165f, -0.24780905f, -0.28695002f, 0.12273506f, -0.07294927f, -0.14947830f, -0.06754202f, 0.04632669f, 
    0.17661355f, -0.08438089f, 0.38311815f, 0.05912293f, 0.11681142f, -0.01480283f, 0.06423262f, 0.07762066f, 
    0.11526121f, 0.09581038f, 0.17791529f, -0.04523079f, 0.17933737f, 0.35237840f, 0.03256679f, -0.21082488f, 
    -0.03274719f, 0.11876250f, 0.10555606f, 0.00217600f, 0.00924358f, -0.06374133f, -0.17559054f, -0.14307912f, 
    -0.13674100f, -0.07447819f, 0.01567873f, 0.02605560f, -0.08339599f, -0.21747191f, 0.06961942f, 0.06891666f, 
    -0.12176450f, -0.05064989f, -0.00514519f, -0.06703258f, 0.24164541f, -0.05617505f, 0.45313728f, 0.15879400f, 
    -0.07231046f, -0.20096815f, -0.19470146f, 0.04720414f, -0.16586506f, 0.23623513f, -0.07537432f, -0.01310801f, 
    0.51841223f, -0.54225159f, 0.17371321f, 0.09232257f, -0.05468902f, -0.04622573f, -0.00139780f, -0.16797392f, 
    0.02339362f, 0.24786234f, 0.17946269f, 0.30236682f, 0.00014982f, 0.06113474f, 0.00034002f, 0.01746694f, 
    0.00199030f, 0.24450275f, 0.06039123f, 0.41316995f, -0.04749554f, -0.06270878f, 0.08314984f, 0.02908967f, 
    -0.12261721f, 0.00739505f, 0.10901103f, 0.16113518f, 0.05593121f, -0.09650027f, -0.06528866f, -0.06190948f, 
    0.02393278f, -0.02124031f, -0.04464789f, 0.14910099f, -0.08641937f, 0.13383298f, -0.19411995f, 0.03338126f, 
    0.00201263f, -0.22504252f, -0.07844621f, -0.09042212f, 0.26933596f, 0.23291643f, 0.11067189f, -0.00895727f, 
    -0.16642089f, 0.05802675f, -0.10196299f, 0.10467248f, -0.01493211f, -0.09054524f, 0.13282001f, -0.49864015f, 
    -0.08861145f, 0.00707024f, 0.07603982f, -0.23321842f, 0.09177338f, -0.00479373f, -0.46452329f, 0.06234731f, 
    -0.17027500f, 0.26613271f, 0.07801961f, 0.05689107f, 0.03121530f, -0.03592254f, 0.19929464f, 0.05017661f, 
    -0.20759685f, -0.20290211f, 0.25024247f, 0.11516327f, 0.00354826f, -0.03302876f, 0.07337037f, 0.12710366f, 
    0.22266243f, -0.10553838f, -0.43878037f, 0.13752009f, -0.04699448f, -0.00311754f, -0.05279013f, 0.20230785f, 
    0.01100233f, 0.05544285f, -0.21300136f, 0.32743266f, 0.14008801f, 0.17668207f, 0.12192427f, 0.10911766f, 
    0.15243006f, 0.06021642f, -0.03185294f, -0.06926597f, 0.09961518f, 0.10657124f, 0.19178092f, 0.04031415f, 
    0.07627535f, -0.04793695f, 0.04740984f, -0.29000086f, -0.16181822f, 0.02936236f, -0.25703785f, -0.09686464f, 
    0.11147685f, -0.08147100f, 0.00281652f, -0.04446766f, -0.30245656f, 0.10774840f, -0.33280399f, 0.07432961f, 
    0.03962206f, -0.16329886f, -0.02928712f, -0.01235726f, -0.07385282f, 0.32745522f, -0.26097637f, -0.63623405f, 
    -0.04003274f, 0.11697678f, 0.09974109f, -0.08538692f, -0.09412444f, 0.15315154f, 0.21543369f, -0.21331277f, 
    -0.05305991f, -0.24545349f, -0.04885950f, -0.02562309f, 0.13346061f, -0.03242095f, -0.01871927f, -0.04887138f, 
    -0.12340598f, -0.28697219f, 0.09737721f, 0.03067124f, 0.03188476f, -0.01604202f, 0.16399688f, -0.11409257f, 
    0.02496354f, -0.04104099f, 0.01447947f, 0.03077658f, -0.06585699f, 0.00151179f, -0.02154040f, 0.04685887f, 
    -0.03324214f, 0.00789671f, 0.00937339f, -0.04355855f, 0.02022585f, -0.03948872f, 0.04586891f, 0.02695841f, 
    -0.00814030f, 0.00916185f, 0.02246854f, 0.02219453f, -0.01846158f, -0.05285451f, 0.05001401f, -0.00268211f, 
    0.00482759f, 0.01844246f, 0.02115886f, -0.05094765f, 0.03628217f, -0.03266397f, -0.06137621f, 0.04535712f, 
    0.00051049f, -0.01601552f, -0.06426769f, -0.00202892f, -0.06006197f, -0.03854291f, 0.05161387f, 0.00947222f, 
    -0.03962931f, 0.03872684f, -0.05782449f, -0.04702105f, -0.02111700f, -0.04890437f, 0.01598951f, 0.01299484f, 
    0.00322641f, 0.02205843f, -0.04046326f, -0.04257063f, -0.03754755f, 0.04488707f, 0.00920947f, 0.02500716f, 
    0.02467704f, 0.03829960f, -0.04432244f, 0.02629671f, -0.01389878f, -0.01700622f, -0.03156505f, 0.01044877f, 
    -0.04895591f, -0.06188474f, -0.00292643f, -0.03463236f, 0.01203952f, 0.04261055f, 0.03691532f, -0.06158046f, 
    -0.06819137f, -0.00793948f, 0.00031523f, -0.02704330f, -0.01255674f, -0.01049822f, -0.03676911f, -0.00988257f, 
    -0.03022497f, 0.00129263f, -0.02076650f, 0.04715005f, 0.03780524f, -0.05550521f, 0.05897552f, 0.04475000f, 
    0.00298498f, -0.01151455f, 0.02455026f, -0.05732838f, 0.03947148f, -0.00338750f, -0.03850983f, -0.04416039f, 
    0.04847614f, 0.00949070f, -0.01065363f, 0.01817073f, -0.01713103f, -0.00761884f, 0.03105854f, 0.01084473f, 
    -0.03363082f, 0.01477195f, -0.03950883f, 0.03224808f, 0.01203976f, 0.00065497f, -0.03330723f, 0.00545743f, 
    0.00607660f, -0.05889078f, -0.04741006f, 0.01905033f, 0.02451502f, -0.04235129f, -0.03389255f, -0.04100655f, 
    -0.06127519f, -0.02969931f, -0.02031905f, 0.00530592f, -0.05487215f, 0.04985798f, 0.00479277f, 0.04772770f, 
    -0.04683979f, 0.00399189f, -0.01919685f, 0.03633447f, 0.05021626f, -0.02971237f, -0.00332290f, -0.03087570f, 
    -0.01407243f, 0.04317446f, -0.01390064f, 0.02728850f, -0.02926287f, -0.04252784f, 0.01466487f, 0.03510861f, 
    -0.02688528f, -0.04111160f, 0.03728755f, -0.03507156f, -0.01147660f, 0.00921356f, 0.00302632f, 0.00350458f, 
    0.01499280f, 0.00184290f, -0.06029405f, 0.01972444f, 0.05002283f, -0.05805663f, 0.00522855f, -0.02801277f, 
    0.01632637f, -0.03006586f, -0.04679634f, -0.06033071f, -0.05669292f, -0.05342694f, -0.00305005f, -0.03817759f, 
    0.02479251f, -0.05860981f, 0.04556319f, -0.03574909f, -0.02715754f, -0.02273510f, -0.03953679f, -0.00519361f, 
    0.03286114f, -0.06321534f, 0.04070280f, 0.04346055f, -0.05196929f, -0.03143948f, -0.04592652f, -0.02112751f, 
    0.03213001f, -0.00051900f, -0.05146144f, -0.03145553f, -0.05328218f, -0.06468779f, 0.03049552f, -0.00894955f, 
    0.02467145f, 0.01785885f, -0.06443271f, 0.02398387f, 0.01215170f, -0.00377145f, -0.01721467f, -0.01373060f, 
    -0.05272426f, 0.02152131f, 0.01436495f, -0.05166459f, -0.03305763f, -0.05255745f, 0.05521293f, 0.02240557f, 
    -0.02016700f, 0.02697595f, 0.00630087f, 0.00102451f, -0.04360933f, -0.04665770f, 0.05366003f, 0.02796867f, 
    0.02648948f, 0.01760452f, -0.03894624f, -0.05835528f, 0.02123774f, -0.02100214f, 0.01053152f, 0.00687361f, 
    0.03837629f, -0.02600233f, -0.05208872f, 0.03655412f, -0.02037477f, 0.02208874f, -0.02575861f, -0.01669703f, 
    0.03791818f, -0.06107469f, -0.01012936f, -0.03045778f, 0.01636446f, -0.06572061f, 0.04753814f, -0.00641710f, 
    0.04003594f, -0.02034993f, 0.03173988f, 0.04322900f, 0.04305446f, -0.02755559f, 0.03631087f, 0.03235666f, 
    0.05357575f, -0.03668755f, 0.03346509f, -0.04654039f, -0.04553010f, 0.00425296f, -0.01464029f, -0.00121965f, 
    -0.03947658f, 0.00730373f, 0.00649001f, 0.03278438f, 0.00445969f, -0.00010828f, -0.00262378f, 0.03790197f, 
    0.00936840f, 0.04267424f, 0.00060304f, 0.05543089f, -0.05707218f, -0.02092817f, -0.03704404f, 0.05381045f, 
    -0.03712786f, -0.02776676f, -0.00298869f, 0.01689460f, -0.01366479f, 0.03089158f, 0.02244702f, 0.02723288f, 
    -0.04110665f, -0.03807015f, -0.05155334f, 0.00768233f, 0.02900596f, -0.02454399f, 0.00191701f, -0.01710945f, 
    -0.01736957f, -0.04852483f, -0.03513821f, -0.04649104f, 0.02373623f, -0.02323341f, 0.03999657f, -0.03956586f, 
    -0.00380241f, 0.00722782f, -0.02390217f, 0.00968674f, 0.00617051f, -0.01733291f, 0.05148154f, 0.04580683f, 
    -0.00287605f, 0.04794890f, 0.03648965f, 0.02097718f, 0.04467321f, 0.04406549f, 0.01613432f, 0.01101410f, 
    -0.01850472f, 0.04070258f, -0.00515052f, -0.02451393f, -0.00781273f, 0.03656748f, 0.03568128f, -0.03072230f, 
    0.04388108f, -0.01441458f, 0.04428089f, 0.03237483f, -0.03273841f, 0.02580105f, 0.00012998f, 0.00170215f, 
    -0.00428549f, -0.00091975f, -0.03664866f, 0.03422896f, -0.06278259f, 0.05242532f, -0.04702209f, 0.01864914f, 
    0.02887712f, 0.03607916f, -0.03812277f, -0.05885365f, -0.05167332f, -0.02856315f, 0.01943174f, -0.04313425f, 
    0.00020099f, 0.02908351f, -0.04837002f, -0.01997200f, -0.05566894f, 0.00817483f, -0.00955989f, 0.01346090f, 
    -0.00356254f, -0.05514178f, 0.02705604f, -0.04205821f, 0.01485679f, 0.01942173f, -0.01677921f, 0.01662615f, 
    -0.02018009f, -0.06532951f, -0.05896544f, 0.02739701f, -0.05877286f, 0.02989388f, -0.04707741f, 0.01686515f, 
    0.04746019f, 0.02820866f, -0.04283895f, -0.01384625f, 0.04064742f, -0.03290427f, -0.01443431f, -0.01396316f, 
    -0.03382873f, 0.03414724f, 0.02739617f, 0.02480672f, -0.02027158f, 0.03563439f, -0.06369235f, -0.02907916f, 
    0.02563699f, 0.02272516f, -0.04308746f, -0.04105201f, -0.02068466f, 0.04533537f, 0.00649601f, 0.04801913f, 
    -0.05597162f, 0.02516736f, -0.00571754f, -0.06277132f, 0.02052616f, -0.02163944f, 0.01868590f, -0.02579557f, 
    -0.01864934f, 0.03303886f, 0.02653496f, -0.03795302f, -0.05069914f, -0.03840939f, -0.01231245f, 0.00408958f, 
    -0.05461136f, 0.04950237f, -0.01773291f, -0.01871692f, -0.05523882f, -0.01844374f, -0.04669477f, -0.04721256f, 
    -0.03302218f, 0.03727211f, -0.02961306f, 0.05032852f, -0.01902520f, 0.02987972f, -0.04409176f, 0.00548677f, 
    -0.05554959f, 0.02180388f, -0.00950525f, -0.01090395f, 0.04635466f, 0.01852141f, -0.00293468f, -0.05913444f, 
    0.03302557f, 0.02782306f, -0.05298466f, 0.03018091f, 0.05021033f, -0.01659017f, -0.03988982f, -0.01776600f, 
    -0.04928222f, -0.02153121f, -0.04235266f, -0.02882172f, 0.00610012f, 0.01082304f, -0.00368017f, -0.03336509f, 
    -0.01965787f, -0.01320034f, -0.04653095f, -0.05343395f, 0.04695493f, -0.04944633f, -0.04689601f, -0.03990522f, 
    -0.01511268f, -0.03044997f, 0.03564557f, -0.06547151f, -0.04586023f, -0.03879317f, -0.02016299f, -0.03264597f, 
    0.01888288f, 0.03914532f, -0.03560521f, -0.01327168f, 0.03297948f, -0.04694255f, 0.03799710f, -0.05936930f, 
    0.00587260f, -0.00845070f, -0.00138089f, 0.03389205f, -0.04421786f, -0.03118165f, -0.05591567f, -0.00840787f, 
    0.02200405f, -0.00771730f, 0.05217500f, -0.06559000f, 0.02877449f, -0.03208671f, 0.01038506f, 0.05646887f, 
    0.05193870f, 0.00940700f, -0.02447849f, -0.00413764f, 0.05388827f, -0.05100186f, 0.04932231f, -0.00931898f, 
    0.05581046f, -0.07518031f, 0.01831705f, -0.00805556f, -0.00209126f, 0.00362422f, 0.00930635f, -0.06375358f, 
    -0.06198496f, -0.03489186f, -0.02777547f, -0.06055431f, 0.01891831f, 0.03509982f, -0.00874763f, -0.02514357f, 
    -0.06276632f, -0.00145798f, -0.00275408f, -0.05239772f, -0.01544429f, 0.05186700f, -0.02876041f, 0.00884950f, 
    0.01080617f, -0.03368990f, 0.00977139f, -0.00731361f, -0.02891151f, 0.02291798f, -0.03279878f, 0.00746166f, 
    -0.06061756f, 0.00497773f, -0.04997910f, -0.03044347f, 0.05228698f, 0.02127237f, -0.00469529f, -0.03226818f, 
    -0.06039999f, -0.04386246f, 0.01620821f, 0.00347323f, -0.00383756f, -0.03142816f, 0.04910662f, 0.01038510f, 
    0.03567608f, 0.02266690f, 0.05220962f, 0.01504643f, -0.00460119f, 0.03719011f, 0.03250236f, 0.00624877f, 
    -0.05127319f, 0.01763921f, -0.02089039f, 0.00662890f, -0.02254849f, 0.01519646f, -0.05448372f, -0.02891625f, 
    0.00929109f, -0.05294402f, 0.04580305f, -0.03348531f, -0.04900868f, 0.04085346f, -0.00519176f, 0.02973509f, 
    0.04051542f, 0.00950259f, 0.05728878f, 0.02427123f, -0.05554423f, -0.05180329f, -0.05850245f, -0.01335294f, 
    0.01882403f, 0.03620134f, -0.03180308f, -0.03992777f, 0.01542021f, 0.01904467f, 0.04345649f, 0.03364263f, 
    -0.00963503f, -0.04701763f, -0.05579222f, -0.05537568f, -0.04579185f, -0.03733719f, 0.01133117f, -0.06532878f, 
    0.01215681f, -0.03290656f, -0.03402756f, 0.00076420f, -0.05335549f, -0.01400316f, -0.02037130f, -0.03511383f, 
    0.04551936f, 0.03908056f, -0.00741364f, 0.00539960f, 0.00863343f, 0.03081250f, 0.04187106f, -0.05575818f, 
    -0.01086112f, 0.04003353f, 0.02291447f, 0.01051492f, -0.04175369f, -0.00660412f, -0.00736371f, 0.02357384f, 
    0.05117290f, -0.01225063f, -0.03177373f, -0.01651181f, 0.04572330f, 0.04194462f, 0.03314538f, 0.02796358f, 
    0.01543199f, -0.05379843f, -0.03947861f, 0.03693167f, -0.02834338f, 0.00925894f, -0.03458830f, -0.05542223f, 
    0.02542331f, 0.00580716f, -0.05864722f, 0.02459398f, -0.00068701f, -0.02927703f, 0.04033788f, -0.00296735f, 
    -0.05201929f, 0.04896885f, 0.01619132f, 0.00482307f, -0.00697833f, 0.03183502f, -0.04102518f, -0.05593313f, 
    -0.05130883f, -0.02785321f, 0.00376857f, 0.02144432f, -0.01048227f, 0.01416131f, -0.02661888f, 0.04199613f, 
    -0.00318227f, 0.00462059f, 0.03789665f, -0.04297939f, -0.06554361f, -0.00207476f, 0.00614825f, 0.04816913f, 
    -0.06718732f, 0.01875890f, 0.04130466f, 0.04786981f, -0.02346792f, 0.03829061f, 0.02541729f, -0.05482687f, 
    -0.05248053f, 0.03850428f, 0.00816923f, -0.05976109f, 0.04726443f, -0.00125724f, -0.01774553f, 0.01400117f, 
    0.00544803f, -0.01950970f, 0.01428043f, -0.04081381f, -0.03737973f, -0.01964363f, -0.00955829f, -0.03127715f, 
    -0.04524587f, -0.02692655f, -0.06549109f, 0.02184220f, -0.04431117f, -0.03949547f, -0.02075708f, 0.03535705f, 
    -0.04341725f, -0.02695296f, -0.04949299f, 0.00213307f, -0.00477155f, -0.06134664f, -0.04124274f, -0.05282993f, 
    0.05316713f, 0.04617784f, 0.03942081f, -0.01805435f, -0.01777899f, -0.01286755f, 0.04302089f, -0.02711511f, 
    -0.04878880f, 0.03267098f, 0.03605777f, -0.05827762f, -0.01592405f, -0.05089435f, 0.01578505f, 0.02581174f, 
    -0.05187589f, -0.00495060f, 0.00340382f, 0.01251622f, -0.02286514f, -0.05421884f, 0.01370657f, -0.01487606f, 
    -0.01109023f, -0.03829604f, 0.03938136f, -0.00295015f, -0.03077848f, 0.00367207f, 0.00182467f, 0.03052094f, 
    -0.03022807f, -0.06318089f, 0.02787832f, -0.03724707f, -0.05808749f, -0.02001016f, 0.03951868f, -0.06353831f, 
    -0.05843771f, -0.01122206f, -0.01608819f, -0.01287366f, -0.02012587f, -0.00672579f, -0.06602944f, -0.02040969f, 
    -0.04866585f, -0.06727976f, -0.06644424f, 0.03148922f, -0.02463355f, 0.03090125f, 0.02170477f, 0.03992240f, 
    -0.00249992f, -0.05757429f, -0.03397607f, 0.04949142f, -0.02339548f, -0.03580026f, 0.04261257f, 0.02153690f, 
    -0.01471536f, -0.03768743f, 0.00162695f, 0.02347116f, -0.00061574f, 0.05224615f, -0.02294087f, 0.01581406f, 
    0.02502688f, -0.05210169f, 0.00269170f, 0.00349080f, 0.05040055f, -0.04868513f, -0.03814416f, 0.05257982f, 
    -0.00057302f, -0.03837235f, 0.02961276f, -0.03923443f, 0.01264234f, -0.04457624f, 0.00869915f, -0.02918248f, 
    0.03619932f, 0.04436644f, 0.00825707f, 0.04416940f, 0.02741280f, -0.03655931f, 0.02562196f, -0.00202590f, 
    0.04880993f, -0.03068871f, 0.04278536f, -0.01367611f, -0.04282500f, 0.01875184f, -0.00227747f, -0.01774650f, 
    -0.04187704f, 0.03121211f, -0.03440934f, 0.00191518f, -0.04451515f, 0.04624164f, 0.02548130f, 0.04021832f, 
    -0.06259235f, 0.01795468f, 0.02839375f, 0.03876988f, -0.05382476f, -0.06617576f, -0.06190011f, -0.01855953f, 
    -0.01851176f, -0.02202896f, -0.00043778f, -0.00914388f, -0.05969957f, -0.00717188f, 0.00156447f, -0.01365067f, 
    -0.00766190f, 0.03942339f, -0.06060973f, 0.03663757f, -0.05997195f, -0.04698764f, -0.00029900f, 0.02548771f, 
    -0.02869326f, -0.04167019f, -0.03963671f, -0.04063899f, 0.01307932f, 0.05045256f, 0.00803362f, -0.03722430f, 
    -0.00830051f, 0.04484347f, -0.03310782f, -0.02737954f, -0.04765526f, -0.02905918f, 0.01089965f, 0.00251218f, 
    -0.00466569f, -0.01053297f, 0.03041276f, -0.03610260f, -0.00682077f, 0.01963440f, -0.03432993f, -0.04220686f, 
    0.05689862f, -0.17676254f, -0.06686429f, 0.01785226f, -0.11882434f, 0.04827533f, 0.11635047f, -0.13084145f, 
    -0.03796680f, 0.25783679f, 0.07712954f, -0.20176044f, -0.10657462f, 0.13074641f, 0.05533756f, -0.08410256f, 
    0.13574043f, -0.01210247f, 0.00168974f, 0.22500966f, 0.20909543f, 0.19280031f, 0.18696466f, 0.00903683f, 
    0.17844798f, -0.13666232f, -0.09436891f, 0.23265676f, 0.21780948f, -0.16039109f, 0.06212358f, -0.14856647f, 
    0.03967557f, 0.07869763f, -0.00485182f, 0.08595484f, 0.32827988f, 0.38186920f, 0.03807052f, 0.02413857f, 
    -0.01010391f, 0.13314463f, -0.33008775f, 0.07162068f, 0.05606706f, 0.28307799f, -0.16797516f, -0.10252148f, 
    0.13299994f, -0.02705709f, 0.10418123f, 0.07194582f, -0.04889802f, 0.08615818f, 0.07640812f, 0.15792511f, 
    0.18656780f, 0.10721653f, -0.11110275f, -0.16181231f, 0.16626424f, 0.22247961f, -0.08391786f, -0.41643682f, 
    -0.14785510f, -0.04448713f, -0.13206977f, -0.07963024f, -0.19350411f, -0.16984932f, -0.20001441f, -0.09851082f, 
    0.19892424f, 0.46626824f, 0.24769531f, 0.00220663f, 0.21434881f, -0.16823216f, 0.03639195f, 0.19178392f, 
    0.00006360f, 0.24374719f, 0.18270545f, 0.04493007f, -0.18454647f, -0.19502680f, 0.09943091f, 0.05733187f, 
    -0.00422232f, 0.03179111f, -0.33955944f, -0.07432182f, -0.08562615f, -0.07223386f, 0.09495657f, -0.17656761f, 
    0.09142176f, 0.08616957f, 0.12431420f, -0.05089353f, -0.16245046f, -0.11127744f, 0.11049899f, 0.09975451f, 
    0.10913728f, -0.36384165f, 0.08403403f, -0.03379964f, -0.01318386f, -0.07589629f, 0.11738821f, 0.03446813f, 
    0.06631824f, 0.07821257f, -0.10634668f, -0.14720955f, 0.13567017f, 0.24569032f, 0.19019623f, 0.08361234f, 
    0.07007499f, -0.12692973f, -0.07140168f, 0.00216454f, 0.05791833f, 0.12641934f, -0.54175913f, 0.00157543f, 
    -0.03529380f, 0.25762099f, 0.09043320f, -0.04685799f, -0.07933255f, 0.17506716f, 0.19477816f, -0.00502276f, 
    -0.14704324f, -0.26830390f, 0.06159697f, -0.05066624f, 0.07640868f, -0.00890471f, -0.04583069f, -0.08780849f, 
    0.46718821f, 0.10708201f, 0.11200989f, -0.07183450f, -0.11311381f, 0.08154803f, 0.12283853f, -0.04339546f, 
    0.01679850f, 0.03959350f, 0.08535865f, 0.09627609f, 0.17195261f, 0.11067878f, -0.03696144f, 0.00172636f, 
    -0.09614310f, 0.01137083f, -0.09403718f, -0.11158253f, -0.01895307f, 0.09827039f, 0.13436435f, 0.01483424f, 
    0.03495310f, 0.03419227f, -0.06731003f, 0.32261556f, -0.12858072f, -0.20984329f, -0.03433256f, -0.07149548f, 
    -0.14930707f, -0.14763981f, 0.11925638f, 0.13194548f, -0.26635945f, -0.18573003f, 0.19389361f, 0.19864021f, 
    -0.06041441f, -0.15024348f, -0.13146596f, 0.16976994f, 0.14819394f, -0.26830110f, 0.44841614f, -0.08624128f, 
    0.09273600f, -0.10634461f, -0.03508754f, -0.45100340f, -0.25803113f, 0.19541116f, -0.12123165f, 0.03878273f, 
    -0.07348073f, 0.08660492f, -0.04947932f, -0.05334463f, 0.01977139f, 0.00312693f, 0.27654001f, 0.48198324f, 
    -0.47827375f, -0.25119612f, -0.17804915f, -0.02454391f, 0.04915060f, -0.01056953f, -0.03494116f, 0.02125490f, 
    -0.42842191f, -0.22684041f, 0.05550588f, -0.11056846f, 0.02484799f, -0.05739776f, 0.19773471f, -0.26770529f, 
    -0.06720142f, 0.34262395f, 0.32731965f, 0.06684722f, 0.03426653f, 0.03946328f, 0.02560571f, -0.08520418f, 
    -0.06154459f, 0.13418658f, 0.24861877f, 0.26721591f, 0.10075470f, 0.24337538f, -0.04491530f, 0.08585797f, 
    0.10145731f, -0.05079917f, 0.08151650f, 0.01841689f, -0.25782076f, -0.05579704f, 0.13673232f, -0.27139273f, 
    -0.02248014f, 0.02734148f, -0.12014062f, -0.24025954f, 0.09707151f, 0.04936773f, -0.14638677f, -0.08085966f, 
    -0.10816956f, -0.00361443f, -0.09354373f, -0.15272862f, -0.13963945f, -0.03138521f, -0.10045061f, -0.00193112f, 
    -0.27098492f, -0.07074443f, -0.10457896f, -0.01535121f, -0.03663850f, 0.19215126f, -0.45824584f, -0.12391128f, 
    -0.11965291f, -0.00241537f, 0.10604545f, 0.03377598f, 0.14732254f, -0.17761537f, 0.00212581f, 0.18741108f, 
    -0.14228731f, -0.31102148f, -0.06530116f, -0.02950767f, -0.03104744f, -0.15917388f, 0.16284442f, -0.03153783f, 
    -0.02856424f, -0.06845593f, -0.20293152f, 0.01073106f, -0.05863790f, -0.15731235f, 0.01945744f, 0.15765196f, 
    -0.06732448f, -0.46796167f, -0.16910511f, 0.24323019f, 0.02047313f, 0.31084546f, -0.15078492f, -0.14202563f, 
    0.05662071f, 0.18763016f, -0.28162089f, 0.16434856f, 0.21704715f, -0.15092380f, 0.00630681f, 0.20261602f, 
    -0.16649954f, 0.07832436f, -0.03171994f, 0.00394392f, 0.26808223f, -0.13795243f, -0.05198087f, -0.13334827f, 
    -0.04162038f, 0.07068120f, 0.25033745f, -0.06572778f, -0.52716643f, 0.09093824f, 0.09666526f, -0.23862225f, 
    -0.04705460f, -0.10250712f, -0.06025889f, -0.01062351f, -0.02212345f, 0.21205920f, -0.55202937f, 0.26706195f, 
    0.18685241f, 0.04822644f, 0.03895546f, -0.09713268f, -0.04806171f, 0.06144839f, 0.12642527f, 0.13802209f, 
    -0.26195884f, 0.13063300f, -0.13740353f, 0.11395156f, 0.09697250f, 0.13746656f, 0.19637834f, 0.02143229f, 
    -0.00555382f, -0.12523834f, -0.02485036f, -0.12572601f, -0.10939361f, -0.06113737f, -0.14363590f, -0.13048333f, 
    -0.04715151f, 0.00080968f, -0.01208087f, 0.08947008f, -0.01031935f, -0.19543728f, 0.09407605f, 0.07304643f, 
    0.25883940f, -0.13359243f, 0.08274180f, 0.02637582f, -0.10256788f, 0.07676724f, -0.08357100f, -0.06431630f, 
    0.09345337f, -0.03659454f, -0.39491981f, -0.18229954f, 0.12258266f, 0.06568672f, -0.15697727f, 0.09467108f, 
    -0.05688044f, 0.28201878f, -0.02337452f, -0.27552879f, 0.01762883f, -0.33614123f, -0.07226089f, -0.21329933f, 
    -0.11148220f, 0.00667432f, 0.09523812f, 0.08539305f, 0.13032009f, -0.00848867f, -0.25522229f, 0.11204970f, 
    0.17376465f, 0.01617187f, -0.05819173f, -0.08073916f, 0.02133293f, 0.36894718f, 0.17991994f, 0.06740616f, 
    0.02363332f, 0.27902195f, -0.08660688f, 0.20725465f, 0.11769230f, -0.06994410f, -0.16856399f, 0.20401087f, 
    0.20203412f, -0.09508455f, -0.10001415f, -0.07068029f, -0.06270777f, -0.07650426f, 0.01455318f, -0.05427978f, 
    0.18007080f, 0.05544050f, -0.01671805f, 0.01834537f, 0.11320858f, 0.32165176f, -0.02393179f, -0.01767624f, 
    0.00452675f, -0.50110281f, 0.20948422f, 0.11207146f, 0.03409762f, -0.16640146f, 0.15234706f, -0.30597746f, 
    0.11039975f, -0.10111988f, 0.28389353f, -0.08343290f, -0.01539714f, -0.13060950f, 0.00055274f, -0.15029353f, 
    0.02909921f, -0.04681665f, 0.29097903f, 0.04267472f, -0.28417310f, 0.03396177f, -0.09273648f, 0.00721772f, 
    -0.16733193f, 0.06243607f, 0.13378198f, 0.42999500f, 0.42907816f, -0.18176332f, -0.04197943f, 0.04139444f, 
    0.00807315f, 0.06748337f, 0.03010461f, 0.12276822f, -0.00330545f, 0.14006671f, 0.08250730f, 0.06235026f, 
    0.00675176f, -0.00396352f, -0.15494709f, 0.04543886f, 0.04981703f, 0.35649344f, 0.04862840f, 0.07706960f, 
    -0.17118767f, 0.16795447f, -0.02619541f, -0.15662968f, 0.18181387f, 0.07018252f, -0.20361251f, -0.38252449f, 
    0.10778948f, 0.05862449f, 0.17643984f, 0.01342525f, -0.06197003f, 0.05782155f, 0.11092873f, -0.06390912f, 
    -0.32558081f, 0.15197541f, -0.07709916f, 0.06740078f, -0.03344508f, 0.11179981f, -0.02771723f, 0.15545222f, 
    0.41704237f, 0.10627522f, 0.28780597f, 0.15685076f, 0.00963689f, -0.14282842f, -0.11412676f, -0.05365955f, 
    0.04242660f, -0.04819260f, 0.22527686f, -0.15330084f, -0.08213123f, 0.04122791f, -0.24284360f, -0.09536129f, 
    0.04485730f, -0.11155899f, -0.15051176f, -0.21852997f, 0.05830642f, -0.00511805f, 0.16380402f, 0.07281774f, 
    -0.03742703f, -0.01778511f, 0.03089844f, 0.33980724f, 0.27449372f, -0.31006667f, -0.08105184f, -0.12792772f, 
    0.15583977f, -0.04756594f, 0.01853387f, -0.06993244f, 0.21815404f, -0.14701961f, -0.18134823f, 0.21490768f, 
    0.16175106f, -0.02762290f, -0.18666467f, 0.02598451f, 0.11384510f, 0.50841200f, -0.28271440f, 0.16694885f, 
    0.10669572f, -0.05141482f, -0.05380087f, -0.01894605f, 0.03638083f, -0.00903060f, -0.39999187f, -0.07358874f, 
    -0.12821101f, 0.09841507f, -0.17135431f, -0.01264591f, 0.12200990f, 0.01541395f, -0.14100040f, 0.11344048f, 
    -0.50671583f, -0.40650433f, 0.11106052f, 0.16898154f, 0.05275608f, -0.07052973f, -0.14459644f, -0.11784842f, 
    -0.20105842f, -0.26805666f, 0.09932020f, 0.08651508f, 0.12040584f, 0.05190331f, 0.13119952f, -0.00251023f, 
    -0.10469787f, -0.11648432f, -0.05033888f, 0.20251186f, -0.00498697f, -0.24614041f, 0.05393105f, 0.10492258f, 
    0.09714793f, -0.03062237f, -0.42328417f, -0.26847777f, -0.43401730f, 0.05883351f, 0.06669074f, -0.04989710f, 
    0.07945523f, -0.01268454f, -0.16453142f, -0.23109716f, 0.06450741f, -0.44116864f, 0.22194193f, -0.00310923f, 
    -0.04978926f, -0.34353974f, -0.10709521f, 0.00105311f, -0.10549334f, -0.40632275f, -0.49965113f, 0.00029838f, 
    0.01180687f, 0.03837904f, 0.03468173f, -0.05986856f, -0.00789029f, 0.08605658f, 0.46682137f, 0.28484571f, 
    -0.25655740f, 0.09833047f, -0.08832526f, 0.24863625f, 0.07391012f, 0.03219292f, 0.13229911f, -0.29007050f, 
    -0.49229315f, 0.07664299f, 0.14726557f, -0.08937963f, -0.07996687f, -0.17129183f, -0.13033763f, -0.13415387f, 
    -0.09086916f, -0.21756305f, -0.02631973f, 0.13141018f, 0.02190719f, 0.14513874f, -0.23572718f, 0.13655977f, 
    -0.31945166f, 0.47837064f, -0.57401848f, 0.07765644f, 0.11379336f, 0.05546304f, 0.05165345f, 0.01103545f, 
    0.04655168f, -0.22467725f, -0.04010055f, -0.40796342f, -0.06890739f, -0.00102925f, 0.17125177f, -0.20211406f, 
    0.36212400f, -0.04763545f, 0.19291584f, -0.15167530f, 0.35001016f, 0.04225627f, 0.28104511f, 0.07891691f, 
    -0.03404699f, -0.09769928f, -0.06571580f, 0.38885516f, -0.12818848f, -0.32475632f, -0.10043333f, -0.08766802f, 
    0.14548370f, 0.04603516f, 0.04085553f, -0.13217026f, 0.08118211f, -0.10903339f, -0.47001815f, 0.02510474f, 
    -0.04175331f, 0.16307385f, -0.10031108f, 0.03010218f, 0.09910801f, -0.23317544f, -0.32850823f, 0.23376665f, 
    -0.03530190f, 0.10641685f, -0.05272754f, 0.12505995f, -0.14554605f, 0.12628399f, 0.26479417f, -0.31551591f, 
    -0.22804683f, -0.02031323f, 0.11173509f, 0.10421414f, -0.07638938f, -0.08393826f, -0.08342478f, 0.30609742f, 
    0.11533092f, -0.32546389f, -0.15625010f, 0.10480458f, 0.28741568f, 0.01590163f, -0.04822449f, -0.08151589f, 
    0.15010914f, 0.20929629f, 0.18828641f, -0.19503509f, -0.05337695f, -0.06494308f, -0.02927665f, 0.04478126f, 
    -0.00664580f, 0.07808220f, -0.33243081f, -0.59218359f, 0.07078196f, 0.06801045f, 0.08228152f, 0.05489181f, 
    -0.01561344f, -0.12468334f, -0.74444020f, 0.31395575f, 0.49237755f, 0.05532620f, 0.01219110f, -0.08486105f, 
    -0.03063006f, -0.14751503f, -0.08787024f, -0.49515080f, -0.11660528f, -0.02520629f, 0.24029261f, 0.12326791f, 
    -0.16711675f, 0.02604681f, 0.05774004f, 0.13347143f, 0.09610783f, -0.17783283f, -0.20598873f, 0.15760218f, 
    0.17679113f, -0.09866378f, -0.14233522f, -0.15676677f, -0.09726246f, 0.19606614f, -0.03317043f, 0.06736775f, 
    0.09823266f, 0.15002826f, 0.13191605f, -0.20154209f, 0.19961017f, 0.22617550f, -0.11559259f, 0.23057626f, 
    0.34177822f, 0.18494785f, 0.27903903f, 0.11020529f, 0.03428494f, -0.05667962f, 0.08941092f, 0.14444928f, 
    0.04802724f, 0.25640431f, -0.23994462f, -0.21509705f, 0.13469805f, -0.01010632f, -0.04888950f, -0.07110849f, 
    0.08504534f, -0.13771902f, 0.03395815f, 0.14129417f, 0.15969433f, 0.08199349f, -0.11774936f, 0.04949801f, 
    0.23245734f, -0.01624891f, 0.13765991f, -0.02775278f, -0.01021997f, -0.05333566f, -0.04511974f, 0.19173242f, 
    0.05716133f, -0.10265376f, -0.30149034f, 0.41274619f, 0.16146129f, 0.02057853f, 0.18245088f, -0.05055315f, 
    -0.05341817f, 0.04461925f, 0.17044741f, -0.07675561f, 0.06428512f, -0.49140900f, 0.05819108f, 0.27954829f, 
    0.10386360f, 0.17813301f, -0.05203248f, -0.15242258f, 0.09982412f, -0.00555009f, 0.08836079f, 0.14833274f, 
    -0.11760361f, 0.00558541f, -0.22819726f, 0.05802340f, 0.19595219f, -0.07158055f, -0.38076022f, 0.13950324f, 
    0.08579154f, 0.03857983f, 0.03202188f, 0.08053692f, -0.06496100f, 0.23955381f, 0.35872281f, -0.32627702f, 
    -0.20401995f, -0.09725258f, 0.16061299f, 0.00828620f, 0.01749204f, 0.02612641f, -0.03977072f, -0.13656975f, 
    0.24197719f, 0.09836285f, -0.17986608f, -0.00347069f, -0.17738314f, -0.09987106f, 0.00869096f, -0.02622448f, 
    0.40891108f, -0.26335680f, -0.28786135f, -0.17649040f, -0.10759467f, 0.00735958f, -0.22574049f, -0.03702661f, 
    0.12128162f, -0.37731066f, -0.03120272f, 0.13779011f, 0.13050933f, 0.17975655f, -0.13809425f, -0.04139127f, 
    -0.01995026f, -0.02766680f, -0.44323316f, -0.02563044f, 0.21010800f, 0.17362142f, -0.11677636f, 0.10441007f, 
    -0.05499050f, -0.05413905f, 0.11119086f, -0.15615931f, 0.41461122f, 0.09301642f, 0.01109736f, 0.02411840f, 
    -0.01203405f, -0.06634575f, -0.09465268f, 0.05441565f, -0.42096746f, -0.26034656f, 0.24693030f, 0.03103838f, 
    -0.25400776f, -0.00730935f, 0.09914198f, 0.01223163f, -0.09578302f, 0.00180529f, 0.33807367f, 0.06177844f, 
    0.21468419f, 0.18947503f, -0.01741688f, 0.22848405f, 0.04763953f, 0.02471830f, 0.17931443f, -0.04780046f, 
    0.24265127f, -0.09261122f, 0.10692311f, 0.06278297f, -0.02166283f, 0.05428496f, -0.07460121f, -0.10188790f, 
    -0.16926211f, 0.13243951f, -0.01116092f, 0.21082713f, 0.18713421f, -0.12981370f, -0.05581424f, 0.06910139f, 
    -0.15661177f, -0.07615241f, 0.32311675f, 0.03775003f, 0.14270449f, -0.12949917f, 0.03055809f, 0.16766907f, 
    0.05198858f, -0.31632063f, 0.01075351f, 0.19678780f, 0.03472418f, 0.05682399f, -0.21102770f, 0.08701157f, 
    -0.01009056f, -0.00362474f, -0.05837862f, 0.03515656f, 0.18827884f, 0.15972237f, -0.10563074f, -0.00003309f, 
    -0.03638047f, 0.02212904f, 0.00046733f, 0.14390507f, -0.12172981f, -0.12694512f, -0.04814236f, -0.05351277f, 
    0.11345145f, 0.01587912f, 0.04137642f, 0.27618951f, 0.10412242f, -0.28921413f, 0.01616092f, -0.10590833f, 
    0.06418267f, -0.02024376f, -0.11086217f, 0.17418687f, 0.00458033f, -0.01854653f, 0.41461667f, -0.42294794f, 
    -0.10122745f, -0.12880951f, -0.10227539f, 0.08751763f, -0.03145106f, 0.18027431f, -0.33899117f, 0.07388005f, 
    0.06966841f, -0.21653557f, -0.04045546f, -0.24756268f, -0.20781611f, 0.09304693f, 0.03363912f, 0.02507473f, 
    -0.01705337f, -0.58716220f, 0.29854172f, 0.11519741f, -0.07462337f, 0.23400809f, -0.20020308f, 0.11896244f, 
    0.08291496f, 0.26341054f, -0.08874013f, -0.05978950f, 0.13661726f, -0.12984191f, -0.06059613f, 0.06064416f, 
    -0.00878611f, -0.10415608f, -0.17281809f, 0.12795135f, -0.01739077f, -0.00633032f, 0.12836960f, -0.08358531f, 
    -0.00506727f, 0.00075950f, 0.23577371f, 0.16406408f, 0.04823237f, 0.07636176f, 0.00611504f, -0.11041256f, 
    0.12982900f, 0.01947554f, -0.01964779f, 0.45615071f, 0.37700328f, 0.30384338f, -0.41581136f, -0.16223332f, 
    -0.08259843f, -0.03138833f, -0.10092165f, -0.01308999f, 0.24598634f, -0.07693888f, 0.30289400f, 0.03096269f, 
    0.10155477f, 0.00915399f, -0.04705388f, -0.05079217f, 0.02199848f, -0.14658263f, 0.05558536f, 0.08248531f, 
    0.08786150f, -0.00468101f, -0.00596759f, 0.27495277f, 0.08646079f, 0.31945205f, -0.12271946f, 0.13023496f, 
    0.30192515f, 0.26239154f, 0.02454071f, 0.05490068f, -0.05401859f, 0.14455499f, -0.12038823f, 0.08491985f, 
    0.25294524f, -0.28302592f, 0.06677991f, -0.04544301f, 0.02387199f, 0.00344087f, 0.04230123f, 0.13107264f, 
    -0.05812470f, -0.09660419f, -0.56211686f, 0.05120408f, -0.06728809f, -0.01211276f, 0.08985494f, 0.00473390f, 
    -0.03115901f, -0.27313676f, -0.22364111f, 0.23969720f, 0.13713050f, 0.00394381f, -0.08902735f, 0.04384795f, 
    -0.06987956f, 0.00062367f, 0.00815769f, -0.04283708f, 0.38556033f, -0.08174392f, -0.01912240f, -0.11767314f, 
    -0.11014643f, 0.16600063f, -0.09432955f, -0.04041793f, 0.29826307f, -0.02902510f, -0.06074419f, 0.05821135f, 
    0.04124935f, -0.15514109f, 0.33899030f, -0.09131028f, 0.04144236f, 0.12994635f, -0.66770738f, 0.09529607f, 
    -0.07098550f, -0.16185406f, -0.15700515f, 0.08405038f, 0.02324060f, -0.30163094f, 0.11482122f, -0.42088416f, 
    -0.21742290f, -0.21947564f, 0.10869354f, 0.08623394f, 0.09332401f, 0.12640223f, -0.10704825f, 0.02569091f, 
    -0.18905552f, -0.09667190f, -0.15709953f, -0.08101919f, 0.07493079f, 0.16130045f, 0.23157306f, -0.32985386f, 
    0.18226007f, -0.41442657f, 0.22422019f, -0.23179008f, -0.13951051f, -0.05197205f, -0.02567332f, -0.16760550f, 
    -0.26520991f, 0.11932776f, 0.22120491f, -0.18307121f, 0.07261561f, -0.04851836f, 0.07382677f, 0.14318901f, 
    0.06259244f, 0.05785508f, 0.07032939f, 0.00152947f, 0.03042777f, 0.13824606f, -0.00588246f, -0.03135268f, 
    -0.03657138f, 0.15521285f, 0.05411129f, 0.09211080f, 0.10548901f, -0.20796695f, -0.03247473f, 0.00599081f, 
    0.04965710f, 0.08070363f, -0.19486536f, 0.25719443f, 0.23111925f, -0.42795023f, 0.21150383f, -0.01723889f, 
    0.08696290f, 0.07832976f, 0.23992740f, 0.06795742f, -0.27572477f, -0.01621205f, 0.10832470f, -0.38077825f, 
    -0.00069817f, 0.06846198f, -0.01829143f, -0.16123800f, 0.05286346f, 0.05134818f, 0.05040233f, -0.16343747f, 
    0.10734644f, 0.01867571f, 0.00287950f, 0.24449943f, -0.09513175f, -0.19061665f, 0.19479215f, 0.06789667f, 
    -0.02225341f, -0.21768810f, -0.04069837f, 0.14557466f, 0.19607674f, -0.02696822f, -0.11127757f, -0.05921236f, 
    0.35345215f, -0.28523549f, -0.15730563f, 0.14347264f, -0.00185921f, 0.01434845f, 0.15956132f, 0.06212934f, 
    -0.27298203f, 0.35947865f, -0.35121533f, -0.18773030f, 0.07094987f, 0.03788500f, 0.09309538f, -0.04438227f, 
    0.01103927f, -0.19884533f, -0.15486822f, -0.07619971f, -0.08167549f, -0.03863382f, 0.00707919f, 0.04939962f, 
    0.00786679f, -0.01731071f, -0.16113353f, -0.05554313f, -0.02475522f, 0.00240092f, -0.08832163f, 0.02236360f, 
    0.09741116f, 0.01874061f, -0.12706932f, -0.23839419f, -0.03748642f, 0.04187288f, -0.03679127f, -0.00903771f, 
    -0.14542207f, -0.19133042f, -0.06602310f, 0.03352519f, -0.80906922f, 0.14747250f, -0.36921895f, 0.10132450f, 
    -0.05172221f, -0.10627915f, -0.21174920f, 0.19340463f, 0.13501950f, 0.25424841f, 0.03068829f, -0.14937843f, 
    0.16196552f, 0.15640792f, -0.09547476f, -0.05935589f, -0.16065177f, 0.08755268f, 0.23263673f, 0.13440691f, 
    0.06135333f, -0.17890815f, -0.15818577f, -0.09572794f, -0.24933697f, 0.17325948f, -0.09869996f, 0.69525748f, 
    0.28818622f, -0.02565340f, 0.08546802f, 0.13520600f, -0.05204494f, 0.04787888f, -0.12624550f, -0.12871860f, 
    0.18421707f, -0.03096741f, 0.04329380f, 0.29998973f, 0.10539459f, 0.05018564f, 0.04351886f, -0.07636999f, 
    -0.23056923f, -0.14322370f, 0.05829224f, 0.12555903f, -0.23267350f, -0.12088221f, 0.11384350f, 0.01999688f, 
    -0.06173912f, -0.04596699f, 0.02004290f, -0.12713008f, -0.06361137f, -0.30164492f, -0.22181165f, 0.00244600f, 
    -0.12261860f, 0.04498393f, 0.06195024f, 0.05554278f, 0.29435632f, -0.16850233f, 0.07031278f, 0.16499217f, 
    0.16395888f, -0.08047485f, 0.04199739f, 0.11573207f, 0.10064097f, 0.13559745f, 0.21802491f, -0.27294019f, 
    -0.04033712f, -0.19009376f, 0.03354453f, 0.15933965f, 0.09049067f, -0.07698989f, 0.10807668f, -0.40079862f, 
    -0.10902601f, -0.02750699f, 0.19465999f, -0.16001008f, -0.05264107f, 0.00043204f, -0.26958871f, 0.06387471f, 
    0.00760735f, 0.19481595f, -0.09414271f, 0.03328646f, -0.07971519f, 0.04470539f, -0.10816852f, 0.18458769f, 
    -0.12844178f, 0.14436139f, 0.06846029f, 0.28668731f, -0.14698456f, -0.06098814f, 0.11878908f, -0.18724279f, 
    0.36299476f, -0.38022116f, -0.00361146f, 0.11243787f, -0.03029784f, -0.00546456f, 0.17502877f, 0.08883798f, 
    -0.07140753f, 0.07952223f, -0.03457301f, -0.12611362f, -0.12245175f, -0.10526910f, -0.09875559f, -0.17762260f, 
    -0.08897621f, -0.01878839f, -0.20240058f, -0.14243671f, -0.07183486f, 0.08502309f, 0.07105185f, 0.02711421f, 
    -0.25811940f, 0.08679615f, -0.07290852f, 0.21178360f, 0.19752613f, -0.05086383f, 0.07259165f, 0.00906151f, 
    -0.04351051f, 0.00450333f, -0.05814737f, 0.15826383f, 0.47203031f, 0.08630615f, -0.10040727f, 0.12098147f, 
    0.23950867f, 0.11710167f, 0.05478002f, -0.08151351f, 0.06025118f, 0.12664345f, 0.02555612f, 0.02500852f, 
    0.01320588f, -0.06500363f, -0.09984364f, -0.02654350f, -0.01191440f, -0.14600374f, -0.39013162f, -0.19818099f, 
    0.30664068f, -0.12990552f, -0.17234050f, -0.10813048f, 0.19495480f, -0.05082118f, -0.05142695f, 0.33952293f, 
    0.10860646f, 0.04551846f, 0.10907040f, 0.23019037f, -0.08566228f, 0.10669189f, -0.17181444f, -0.01205675f, 
    -0.11736228f, 0.06067325f, -0.19409044f, -0.13301069f, 0.10770509f, -0.20975530f, -0.10226449f, -0.11456624f, 
    0.10512981f, 0.13535811f, 0.10603260f, 0.22204661f, -0.03847127f, 0.08115409f, 0.03888425f, -0.04582382f, 
    -0.15028909f, 0.12237198f, -0.03126051f, 0.05785631f, 0.16779368f, 0.05001112f, -0.08116728f, 0.17761973f, 
    -0.14466839f, -0.04864981f, 0.12978117f, 0.29264253f, -0.03074549f, 0.08118507f, 0.18322906f, -0.07705819f, 
    0.12871452f, -0.12110975f, 0.29796076f, 0.08226751f, -0.08568325f, -0.13218740f, -0.02904580f, -0.01179285f, 
    0.12697901f, -0.05095591f, 0.04412577f, 0.19128959f, -0.23848152f, 0.17271659f, -0.03370171f, -0.09295305f, 
    0.11359043f, -0.20997168f, 0.02352326f, 0.09856584f, -0.00148200f, 0.08765786f, -0.24994965f, 0.34091726f, 
    0.04422783f, 0.27800810f, -0.05310253f, 0.08363178f, -0.05531505f, 0.21962593f, -0.10518885f, 0.15810600f, 
    0.02101167f, -0.12040985f, 0.14725256f, -0.23892491f, 0.05949224f, -0.09210151f, 0.04244597f, 0.08999201f, 
    0.07864477f, 0.11694738f, -0.13352039f, 0.16935335f, -0.03184993f, 0.11331546f, 0.08847836f, 0.09747745f, 
    0.01976501f, 0.05581884f, -0.10316398f, 0.14248382f, 0.14700410f, -0.06283731f, 0.03358449f, -0.05556975f, 
    0.19611630f, -0.06020159f, 0.41331545f, 0.09194802f, 0.26908556f, 0.02093079f, -0.18039609f, -0.07192102f, 
    0.26988629f, 0.21337797f, -0.11265823f, -0.00988110f, -0.03621855f, 0.07132793f, -0.03456920f, -0.14034845f, 
    -0.23877709f, 0.36313939f, 0.10547749f, -0.08470535f, 0.47743142f, -0.25617647f, -0.23545077f, 0.05171313f, 
    -0.14269455f, 0.08380378f, 0.03799966f, 0.03874572f, 0.04774839f, -0.15746348f, -0.05956754f, -0.49998915f, 
    0.03290136f, 0.13705732f, -0.02038837f, 0.08059093f, 0.07472852f, 0.04191107f, 0.04899028f, 0.01438511f, 
    0.00262367f, 0.00950932f, 0.13999602f, -0.07910708f, -0.15645652f, 0.12994182f, -0.06807435f, -0.66713077f, 
    -0.54442477f, 0.13829902f, 0.12851588f, 0.05789660f, -0.01985715f, 0.00376361f, 0.04315324f, -0.08334788f, 
    -0.07375321f, -0.04199135f, 0.16289525f, 0.07237175f, -0.07488588f, 0.06118333f, 0.15334548f, -0.09385376f, 
    -0.00695655f, -0.13408771f, -0.16133118f, 0.03000811f, 0.02657247f, 0.22064003f, -0.16380441f, 0.10596325f, 
    -0.11243622f, 0.08833428f, 0.26814741f, -0.05540586f, -0.03294756f, -0.14781237f, -0.12979269f, -0.12290958f, 
    -0.03041418f, -0.05521064f, -0.10280088f, -0.24660783f, 0.08560190f, -0.57779008f, -0.15019470f, 0.12704416f, 
    -0.09860651f, -0.26403913f, -0.15479515f, 0.03508329f, 0.20512886f, 0.07969901f, 0.15496880f, -0.06934224f, 
    0.09538627f, 0.13401891f, -0.04874011f, -0.01956016f, -0.05269042f, -0.17997105f, 0.31881440f, -0.17162943f, 
    0.32136682f, -0.03476168f, -0.10966691f, -0.28024533f, 0.03770409f, 0.12596273f, 0.28118056f, -0.03795877f, 
    0.18329675f, 0.03338488f, 0.08068696f, -0.08284200f, 0.05318840f, -0.03806624f, 0.19858888f, -0.15348084f, 
    0.08504723f, 0.19635093f, 0.13569193f, -0.18634219f, -0.01891150f, 0.13279870f, -0.18918452f, -0.01106836f, 
    -0.65036845f, -0.18638910f, -0.08918859f, 0.08640713f, 0.34388661f, 0.06626523f, 0.03501164f, 0.22370541f, 
    -0.02206866f, -0.33274287f, -0.28906578f, -0.29452586f, 0.16119123f, 0.14083427f, 0.00912362f, 0.20313387f, 
    0.01148559f, 0.00637800f, 0.11599281f, -0.00608620f, 0.22091448f, 0.08013126f, 0.02602972f, -0.09814027f, 
    0.12982440f, 0.15242393f, 0.10181290f, 0.20982805f, -0.09718204f, -0.14842479f, -0.19673419f, -0.09011966f, 
    0.09919971f, -0.03629460f, -0.20495772f, 0.38154361f, -0.43637803f, -0.20518476f, -0.14055717f, -0.10149363f, 
    0.22735269f, -0.00007147f, 0.21110651f, 0.01609119f, 0.05863916f, -0.07221542f, -0.06593464f, -0.06807994f, 
    0.15871045f, -0.05035616f, -0.06908389f, 0.10275508f, 0.06706636f, -0.02106931f, -0.02033487f, -0.16673531f, 
    -0.18420197f, 0.04260405f, 0.00446342f, -0.01570020f, -0.19167748f, -0.00859228f, 0.04455727f, -0.37231755f, 
    -0.17778675f, -0.30246091f, -0.06981049f, 0.17115125f, 0.10067140f, 0.08938732f, 0.00184633f, 0.14928921f, 
    -0.07827502f, -0.02149135f, -0.23638004f, -0.01839512f, -0.26191929f, -0.04122038f, 0.02733791f, 0.21822144f, 
    0.14726827f, -0.14813641f, 0.19188605f, 0.06871420f, 0.22573453f, -0.13533546f, -0.06610627f, -0.00716243f, 
    -0.04553162f, 0.02732353f, -0.06386610f, 0.22963667f, 0.25240895f, 0.03648619f, -0.13511650f, 0.09038788f, 
    -0.12387003f, 0.13337968f, 0.18088862f, 0.21173239f, 0.07828974f, 0.38218805f, 0.05304693f, -0.07544377f, 
    0.07793896f, 0.14963160f, -0.05372094f, -0.07380002f, 0.09528730f, 0.03348409f, 0.11788625f, -0.02260173f, 
    0.22978632f, -0.02499376f, 0.11668777f, -0.17269701f, -0.03104827f, -0.56273568f, 0.08109149f, 0.22298698f, 
    0.16070934f, 0.17114018f, -0.13639189f, -0.04080081f, 0.11624877f, -0.06526165f, 0.17852104f, -0.05245800f, 
    0.16252209f, -0.16777405f, 0.05816532f, -0.02879852f, 0.06391695f, -0.05546914f, -0.19860987f, 0.01891509f, 
    -0.16306180f, -0.17801555f, -0.17216124f, -0.12849766f, -0.05920061f, 0.08152966f, -0.08134863f, -0.11119074f, 
    0.01010848f, 0.05276053f, 0.24260625f, 0.01330777f, 0.09472253f, 0.03801923f, 0.09433205f, -0.06602094f, 
    -0.09398229f, 0.19855928f, 0.17040749f, 0.28631133f, 0.04162733f, -0.01827321f, 0.09075225f, 0.08633444f, 
    -0.04169158f, 0.04120134f, 0.02228628f, -0.16879565f, 0.03825824f, -0.00599787f, -0.05473883f, 0.05521074f, 
    0.11916430f, 0.09416946f, -0.11387790f, 0.32565519f, -0.08960888f, -0.02767095f, -0.03407538f, -0.04529513f, 
    0.19309083f, 0.09862421f, -0.19563134f, -0.03898901f, 0.12446541f, -0.17906207f, -0.03841231f, 0.14240752f, 
    0.07315937f, -0.06386504f, -0.14176320f, -0.25292709f, -0.32724449f, 0.13885365f, 0.00694375f, -0.00217377f, 
    -0.29452181f, 0.06501166f, -0.14669743f, -0.05717948f, 0.04769475f, -0.05611847f, 0.00545002f, -0.20764185f, 
    0.14956474f, 0.02275980f, -0.08100808f, 0.21187779f, 0.01521012f, -0.08382867f, -0.02785346f, 0.10796628f, 
    -0.16725655f, -0.10699853f, 0.00990552f, 0.03268631f, -0.37570307f, 0.08893681f, -0.01228060f, -0.12699480f, 
    -0.49958268f, 0.12575446f, 0.11971560f, 0.17592716f, 0.02737563f, -0.09346659f, -0.09723143f, 0.06790081f, 
    0.02708474f, -0.18627843f, 0.10091241f, 0.05423475f, 0.01867362f, 0.13679941f, 0.08575058f, -0.00641342f, 
    0.07603036f, -0.04504858f, 0.05577394f, -0.45768762f, 0.25008655f, 0.03905302f, -0.04777651f, -0.07231043f, 
    -0.34643742f, -0.10932826f, 0.01498737f, 0.11213992f, 0.01251735f, -0.21537264f, 0.01269524f, -0.17120013f, 
    -0.15430810f, -0.10721004f, 0.13920121f, 0.14348522f, 0.06206284f, -0.37481958f, -0.12668413f, 0.10433394f, 
    0.03925677f, 0.09229808f, -0.13369945f, -0.03297140f, -0.03382290f, 0.26994413f, -0.26286903f, 0.01771491f, 
    -0.15868130f, 0.07547840f, 0.04637385f, 0.12770307f, -0.04488951f, -0.01465155f, -0.13597086f, 0.27997497f, 
    0.07743966f, 0.16507438f, 0.00857395f, 0.13029815f, 0.13181268f, 0.02789180f, -0.13341710f, -0.25444311f, 
    0.25067124f, 0.21519370f, 0.07365508f, -0.11981761f, 0.12999186f, 0.02571180f, -0.09601417f, -0.14048544f, 
    0.05390483f, 0.31028402f, 0.07904134f, 0.03972220f, -0.03666735f, -0.01809626f, 0.14522259f, 0.01087510f, 
    -0.00637888f, -0.37196407f, 0.25152880f, 0.12983403f, -0.01080837f, 0.13254729f, 0.34281641f, -0.01178698f, 
    -0.08523922f, 0.08409343f, -0.05419939f, 0.39277440f, 0.18437344f, 0.04138315f, 0.08820898f, 0.07061640f, 
    -0.05817744f, -0.07953142f, -0.06954275f, -0.01430780f, 0.26882604f, -0.05848239f, -0.10227650f, -0.05121817f, 
    0.04747991f, -0.23129794f, 0.04715268f, 0.01524540f, -0.33210957f, 0.30214751f, 0.16690624f, 0.16539326f, 
    -0.17614861f, -0.30600160f, 0.00603935f, 0.12003557f, 0.11926326f, 0.64214456f, -0.02266719f, -0.35976210f, 
    0.00349465f, 0.00863782f, 0.12776294f, 0.12465907f, -0.01336535f, -0.05713285f, 0.19922982f, -0.26333287f, 
    -0.42413300f, 0.16469340f, -0.12721804f, 0.11000135f, -0.08561625f, -0.00759336f, 0.04785032f, -0.56144500f, 
    0.09495644f, -0.08437929f, -0.12744418f, -0.12015646f, -0.34407255f, -0.07482075f, 0.14655630f, 0.14756083f, 
    0.25015640f, -0.34939340f, 0.06519452f, 0.07569674f, -0.06987245f, -0.12935996f, -0.27457747f, 0.04916678f, 
    -0.18206109f, 0.02957961f, 0.07053488f, 0.21882118f, -0.05707182f, 0.01598409f, 0.14958543f, -0.04310359f, 
    0.09658116f, 0.16487299f, 0.68610251f, 0.11869308f, 0.13599135f, -0.00209724f, 0.29057172f, 0.01487299f, 
    -0.07503477f, -0.07454239f, -0.24595098f, -0.39081568f, -0.18969786f, 0.12815550f, 0.03147618f, 0.33938944f, 
    -0.13705875f, -0.12652093f, 0.16253056f, -0.01112335f, 0.53900737f, -0.10102136f, -0.00364769f, 0.02416238f, 
    0.02676434f, 0.04093079f, -0.07170274f, 0.01288061f, 0.08678234f, -0.53439355f, 0.14560795f, -0.02271904f, 
    -0.11139271f, -0.16562766f, -0.04904984f, -0.01514166f, -0.02262818f, -0.19295387f, 0.38829821f, 0.05079350f, 
    -0.07073013f, -0.19345702f, -0.16155353f, 0.07276014f, -0.05955601f, -0.08237811f, 0.21818420f, 0.19363229f, 
    -0.01465680f, -0.01327520f, -0.05158645f, 0.14588889f, -0.10119861f, -0.22223061f, -0.10266954f, -0.04773571f, 
    0.30986372f, -0.25896588f, 0.09451995f, -0.21642226f, 0.10431445f, 0.27232614f, -0.04214974f, 0.01201256f, 
    0.27296841f, -0.35768554f, -0.32983589f, -0.07252410f, -0.17877421f, 0.12891896f, 0.03194508f, 0.01845159f, 
    -0.09372768f, 0.07997341f, -0.07018124f, 0.11273246f, 0.14581272f, 0.02839040f, 0.03248800f, -0.11418892f, 
    -0.17494948f, -0.09229996f, -0.07484528f, 0.02916168f, -0.04892427f, 0.30539992f, 0.09017580f, -0.02945509f, 
    -0.05111277f, 0.27023211f, 0.16321187f, 0.32097566f, -0.10834152f, 0.20090912f, -0.13793837f, 0.08105322f, 
    0.13398077f, 0.00255698f, 0.02188419f, -0.22931187f, -0.22433878f, -0.25100237f, -0.31886068f, 0.11640316f, 
    -0.10637946f, 0.01312815f, -0.07097272f, -0.12865509f, -0.06305294f, -0.12129607f, 0.80764365f, 0.15912865f, 
    -0.35168731f, 0.05298842f, 0.31649619f, 0.12185968f, -0.25004143f, -0.05311558f, -0.02535174f, 0.04072310f, 
    0.32974654f, -0.04670871f, 0.04514148f, 0.15295169f, -0.19186561f, -0.10071109f, 0.10223865f, -0.10891606f, 
    -0.22794624f, 0.42026818f, -0.03154794f, -0.11629273f, -0.16126189f, 0.06356487f, -0.06198221f, 0.26000121f, 
    -0.16800265f, 0.51669908f, -0.05325951f, 0.09496222f, -0.08831985f, -0.19264030f, 0.05330093f, 0.13898610f, 
    0.08421224f, 0.00295395f, -0.02699732f, 0.03384432f, -0.14390980f, -0.18476239f, -0.16115300f, 0.13809001f, 
    0.09415635f, -0.19311908f, 0.09927775f, 0.31838456f, -0.87020206f, -0.22833712f, -0.26975664f, -0.17698722f, 
    -0.03213349f, -0.19346796f, -0.06964692f, -0.04534551f, 0.37504643f, 0.32608187f, -0.09222520f, 0.09457232f, 
    -0.05297418f, -0.06425267f, -0.05964277f, -0.07075971f, -0.03837648f, -0.34951478f, -0.04377170f, -0.39163578f, 
    0.10533047f, 0.04791085f, 0.12949614f, 0.13103345f, 0.02923484f, 0.09445169f, -0.31643263f, -0.01868940f, 
    -0.04790264f, -0.03453903f, 0.05339355f, 0.16734381f, -0.02419732f, -0.11945426f, 0.11038464f, -0.13899861f, 
    -0.05026544f, 0.28571686f, -0.08816925f, 0.12586947f, -0.05066951f, 0.08247907f, 0.00697198f, -0.03507711f, 
    0.01942088f, 0.16418642f, -0.59771991f, 0.06972229f, 0.17419288f, 0.04163687f, -0.02875084f, 0.16692959f, 
    0.19842842f, 0.39898422f, -0.39332166f, -0.10503151f, 0.04486676f, -0.03504840f, 0.11277332f, 0.25344425f, 
    -0.03462042f, 0.12149628f, 0.02283069f, 0.15838006f, -0.01942508f, -0.26979047f, 0.04588947f, 0.12652953f, 
    -0.17277032f, 0.03848261f, -0.07496385f, -0.58085120f, -0.42244786f, 0.27952126f, 0.01236041f, 0.22874267f, 
    0.06715223f, -0.02913070f, 0.14121458f, 0.00164767f, 0.05663218f, 0.00701272f, -0.12352896f, -0.15049557f, 
    0.02180606f, -0.02316281f, -0.07931729f, 0.05252511f, 0.18610248f, 0.16163127f, -0.24116555f, 0.17979559f, 
    -0.02346235f, 0.13200223f, 0.17206590f, -0.11998925f, 0.05280191f, -0.20330866f, -0.07806425f, -0.36050963f, 
    0.28282592f, 0.04306834f, 0.16245422f, 0.09962771f, 0.19856535f, 0.15288499f, -0.08281603f, -0.11132856f, 
    0.21912459f, -0.12732129f, -0.06532977f, -0.11361212f, -0.05799216f, 0.04380834f, 0.23600608f, 0.24604018f, 
    0.20994562f, -0.16491283f, -0.01146477f, 0.04367573f, 0.01516285f, -0.15447600f, -0.18800569f, -0.05464491f, 
    -0.09152216f, -0.05908499f, -0.19640025f, -0.02409709f, -0.11080297f, -0.01667223f, 0.09367365f, 0.02374974f, 
    -0.18893024f, -0.09023380f, -0.05870093f, 0.13189860f, 0.29968250f, -0.02189676f, -0.03123899f, -0.22209573f, 
    -0.03415329f, 0.10921212f, 0.21356794f, 0.31556225f, -0.02317812f, 0.12868130f, -0.16466379f, 0.09209770f, 
    -0.24850850f, -0.00707133f, 0.04170957f, 0.12260130f, -0.17683852f, 0.08087521f, 0.28808486f, 0.14599693f, 
    -0.12271897f, 0.01997411f, -0.01896277f, 0.03352471f, 0.23734088f, -0.05549737f, -0.03186392f, -0.10181125f, 
    0.03302004f, -0.11114393f, -0.04095526f, 0.13640988f, -0.02987763f, -0.21237276f, 0.21388756f, -0.02332455f, 
    0.22571312f, 0.09020320f, 0.03156203f, -0.30064601f, 0.07729933f, 0.06612188f, 0.06492179f, -0.07715193f, 
    -0.09417003f, 0.01957882f, -0.08396114f, 0.08342893f, -0.23983681f, -0.04397168f, 0.03987318f, -0.04805480f, 
    0.15262352f, -0.29254594f, 0.45546210f, 0.06718998f, 0.03843762f, -0.07694028f, -0.19000159f, 0.14659667f, 
    0.09607586f, 0.00862982f, 0.14296786f, 0.23719591f, 0.15085365f, 0.08795812f, -0.00332585f, 0.13668582f, 
    -0.02753471f, -0.03278564f, 0.07541145f, 0.01640324f, -0.08252899f, 0.09720767f, 0.02225437f, 0.18819393f, 
    0.05693576f, -0.06923224f, -0.28619573f, 0.11727728f, -0.24728844f, 0.16763404f, -0.03077031f, -0.13783382f, 
    0.13917442f, 0.07291029f, 0.04657969f, 0.25727063f, 0.09705386f, -0.08619336f, -0.20259115f, 0.04345194f, 
    -0.00423714f, -0.04211507f, -0.00373635f, -0.18693081f, 0.11242621f, 0.24532989f, 0.05052136f, -0.00182092f, 
    -0.00528908f, 0.17978393f, 0.08354700f, -0.07686821f, -0.15432084f, -0.23511297f, -0.27555835f, 0.07863192f, 
    0.20746148f, 0.06533469f, -0.09905361f, -0.00976438f, 0.12370551f, 0.07329095f, -0.04579782f, 0.20510514f, 
    -0.33088335f, -0.15428722f, 0.08120481f, -0.00161860f, -0.31781170f, 0.04941861f, -0.04357060f, -0.01302588f, 
    -0.12461251f, -0.05450077f, -0.08030480f, 0.10571609f, 0.10317980f, -0.01783759f, -0.01840133f, 0.02941663f, 
    -0.13122624f, 0.10019796f, 0.04602142f, 0.28609070f, -0.18519539f, -0.08691601f, -0.01539569f, -0.03290765f, 
    0.12912224f, 0.28135186f, -0.19828114f, 0.01921577f, 0.01527394f, 0.13410212f, 0.26405755f, -0.15970564f, 
    -0.04728591f, -0.02001464f, -0.16398911f, 0.26825756f, 0.08205914f, 0.41119027f, -0.16975319f, 0.01119085f, 
    -0.15701747f, -0.05111460f, 0.14189984f, -0.09910981f, 0.14732988f, -0.27247018f, 0.24262433f, -0.06192499f, 
    0.02599244f, -0.05301123f, 0.08259234f, 0.07720137f, 0.10314624f, 0.09694349f, -0.25940397f, -0.24424767f, 
    0.26635912f, 0.22548532f, 0.07536059f, -0.13464622f, 0.16892417f, 0.06575733f, 0.01737768f, 0.06582506f, 
    -0.34599280f, 0.07605781f, 0.04129485f, -0.01266099f, 0.03248424f, -0.05733421f, -0.20650709f, 0.22323647f, 
    0.03326501f, -0.23948739f, 0.13200748f, -0.05614723f, 0.20941503f, 0.10531505f, 0.15975924f, 0.09435657f, 
    -0.21962258f, 0.05831536f, -0.08256193f, 0.09209795f, -0.12976605f, 0.01575953f, -0.08809087f, 0.01714173f, 
    0.08941944f, -0.14065944f, -0.13723172f, 0.25258699f, 0.06777492f, -0.03465848f, 0.21776201f, -0.08669209f, 
    0.18759070f, 0.15802114f, 0.26623699f, -0.06210351f, 0.05095531f, 0.07406506f, 0.15055346f, 0.12590781f, 
    -0.00984314f, -0.23089087f, -0.09090365f, 0.13334939f, 0.02173253f, 0.14122880f, -0.18551755f, -0.04122414f, 
    0.19961245f, -0.01673656f, -0.09534969f, -0.14646661f, 0.09093178f, 0.08397713f, -0.14958958f, 0.22182706f, 
    -0.08593969f, -0.10611203f, -0.10619529f, 0.05211562f, 0.03970707f, -0.04727926f, -0.07833628f, -0.30538055f, 
    0.00414740f, -0.12232676f, 0.23818697f, 0.16008236f, 0.01608776f, -0.03537073f, 0.09903336f, -0.09406621f, 
    -0.35500759f, -0.04498368f, -0.12701644f, 0.11541953f, 0.05550329f, -0.20096482f, 0.10629926f, -0.18606377f, 
    0.25387755f, -0.36652055f, 0.08547510f, -0.17509063f, -0.00563884f, -0.13952357f, 0.11820777f, -0.10139859f, 
    0.38720584f, -0.37145996f, 0.03723595f, -0.07502531f, -0.06560601f, 0.08715158f, 0.01663002f, 0.00586078f, 
    -0.19515030f, -0.10943042f, 0.09543028f, 0.11753316f, -0.17433165f, -0.07240465f, -0.03403921f, -0.15113813f, 
    0.22963016f, -0.07801782f, 0.45250714f, 0.07579055f, 0.06452139f, -0.15233263f, 0.03461583f, -0.00574867f, 
    0.00517269f, 0.06204062f, -0.08338597f, 0.13903117f, 0.13179004f, 0.17269927f, 0.03126194f, 0.02564808f, 
    0.24077730f, 0.05199807f, 0.01381475f, 0.01667148f, -0.23342764f, -0.14864096f, -0.12443589f, -0.03029659f, 
    0.22846065f, 0.04057841f, -0.04869030f, -0.07945324f, -0.08257534f, -0.26608488f, -0.06012624f, -0.03224316f, 
    -0.03215213f, 0.21469054f, -0.14336354f, 0.07852017f, -0.07215732f, 0.19317929f, 0.04606656f, 0.01258474f, 
    0.14960358f, -0.04226364f, 0.00673613f, -0.12239330f, 0.02551247f, 0.13405889f, 0.04228160f, 0.26719949f, 
    -0.00831317f, -0.04105797f, 0.24983685f, 0.03584227f, -0.04287194f, 0.28165063f, -0.07238057f, 0.16468677f, 
    0.13789570f, -0.34338862f, 0.18946837f, -0.13779615f, -0.01794226f, 0.14984444f, -0.04332699f, 0.13774189f, 
    0.04836503f, -0.03544808f, -0.01371604f, -0.11259073f, -0.16814944f, 0.06444737f, 0.06493522f, 0.05412544f, 
    0.02737960f, 0.08243825f, 0.01313191f, 0.20946571f, 0.24411669f, -0.12012488f, 0.03287074f, 0.02681180f, 
    0.18457551f, 0.04658932f, 0.00415519f, 0.12727061f, -0.27689719f, 0.04748098f, 0.13591321f, 0.21140282f, 
    -0.23165677f, -0.01825828f, -0.03739322f, -0.12205805f, -0.10309266f, 0.28132966f, 0.03499860f, -0.07850736f, 
    -0.12794682f, 0.13756937f, 0.11181237f, 0.15629843f, 0.08577703f, -0.11813419f, -0.35073665f, -0.01444695f, 
    0.01263254f, 0.06227590f, -0.07236190f, 0.13423128f, 0.09933043f, 0.17741153f, -0.31205148f, 0.05485076f, 
    -0.02506321f, 0.10689493f, 0.25068551f, -0.18104123f, 0.42992151f, -0.12501870f, 0.02257346f, 0.10548135f, 
    0.05450155f, -0.00703885f, 0.16239053f, 0.03594773f, 0.16432142f, -0.00320191f, -0.12065666f, -0.09544257f, 
    -0.26610869f, -0.32119772f, 0.09617672f, 0.13820457f, 0.00086807f, -0.00921528f, -0.02108666f, -0.06323499f, 
    -0.17527591f, 0.21493974f, -0.03012852f, -0.08145930f, -0.07754716f, 0.03383199f, -0.05457377f, -0.03960897f, 
    0.08073091f, -0.02063588f, -0.00534497f, -0.18510507f, 0.28898075f, 0.02140270f, -0.01478821f, -0.04672187f, 
    0.16534242f, -0.13009313f, 0.31380165f, -0.23100938f, -0.32011953f, -0.12070482f, -0.01453385f, 0.17926770f, 
    -0.02019589f, -0.13881673f, -0.06934595f, 0.02107952f, 0.30804917f, 0.13375595f, -0.17228618f, -0.15236461f, 
    0.12937070f, 0.03025714f, -0.08978350f, 0.15924083f, -0.02656714f, 0.10893887f, 0.27854669f, -0.04621869f, 
    0.12952454f, -0.15301464f, -0.09024093f, -0.30123729f, 0.01618335f, -0.19696555f, -0.19608028f, -0.14294092f, 
    0.21971951f, 0.11539952f, -0.00117646f, 0.02264007f, -0.23182927f, -0.14180736f, 0.24625304f, -0.19643818f, 
    -0.14934894f, -0.08468165f, -0.16780931f, -0.18231280f, 0.08237454f, -0.19076823f, 0.10028557f, -0.10431004f, 
    0.10444202f, -0.09132738f, 0.06816750f, 0.21769983f, 0.13008641f, 0.07776027f, -0.00727075f, 0.14793777f, 
    0.20046388f, 0.24479765f, -0.24058467f, -0.25822559f, -0.13495870f, 0.14425091f, -0.12270087f, 0.13728334f, 
    0.08594371f, -0.00801743f, -0.15610376f, -0.30445769f, 0.15743408f, 0.05771124f, 0.01415454f, -0.02382916f, 
    -0.18180478f, -0.14648306f, -0.04666378f, 0.00144462f, -0.06003097f, -0.05034377f, -0.12325538f, 0.05395514f, 
    0.21395050f, 0.09170201f, 0.06193798f, 0.01374246f, 0.00851529f, -0.12608249f, 0.08629667f, 0.02119159f, 
    0.16797075f, 0.01136839f, -0.04444137f, -0.23628899f, -0.09747057f, -0.12941998f, -0.30337694f, 0.01280888f, 
    -0.10861967f, 0.01403996f, -0.05566440f, -0.16252354f, -0.12003158f, 0.03316817f, -0.16117777f, 0.13974361f, 
    0.09049707f, -0.06250408f, -0.00950681f, 0.00534962f, -0.03382565f, -0.10123923f, 0.05177110f, 0.05829568f, 
    0.08443380f, 0.01160968f, 0.10044070f, -0.06840436f, -0.01368807f, 0.15376887f, -0.04650502f, -0.02731008f, 
    -0.00282927f, 0.00659792f, 0.00496407f, -0.01678846f, -0.03612133f, 0.01843313f, -0.04203510f, 0.02835434f, 
    -0.04163656f, 0.01006020f, 0.00932078f, -0.02460125f, -0.00015867f, -0.01356569f, 0.02990763f, -0.03273011f, 
    -0.03583262f, -0.01493520f, -0.01824956f, -0.05841677f, -0.01190393f, 0.00769404f, -0.05131012f, 0.03056279f, 
    -0.04685551f, -0.05655985f, -0.03784795f, -0.01189848f, -0.01301355f, 0.00170230f, 0.04065107f, 0.03859256f, 
    0.00595246f, 0.03952843f, -0.03748123f, 0.02965928f, 0.03658835f, -0.04186455f, 0.03741913f, 0.01164238f, 
    -0.04210949f, -0.01217906f, -0.06402196f, -0.05108360f, 0.00284516f, 0.03873349f, 0.02206588f, 0.00032846f, 
    -0.01175904f, 0.03449722f, -0.01746863f, 0.00391820f, -0.04779066f, 0.00694480f, -0.04202083f, -0.02663589f, 
    0.00115525f, 0.02251255f, -0.05841533f, 0.02557695f, 0.01480291f, -0.06334674f, -0.00175118f, -0.05831475f, 
    -0.04305312f, -0.01650027f, 0.01045405f, -0.04481186f, -0.03827850f, -0.01742940f, 0.01760266f, -0.03598920f, 
    -0.00470757f, 0.03686269f, -0.02622663f, 0.04090718f, 0.02205892f, 0.00481591f, -0.05615295f, 0.05162599f, 
    0.03573583f, -0.02419444f, 0.05245916f, 0.01757553f, -0.00559690f, 0.03948507f, 0.01745800f, 0.00906149f, 
    -0.04677483f, -0.06141104f, -0.05682949f, 0.04405581f, -0.02142652f, 0.00446113f, -0.03911694f, -0.01529856f, 
    0.03085226f, -0.01366014f, 0.01323897f, -0.01315242f, -0.02216317f, -0.04040561f, -0.00741310f, -0.06172517f, 
    -0.03099114f, 0.01246033f, 0.00008761f, -0.03451261f, 0.04108806f, -0.02929494f, -0.01788202f, 0.02046677f, 
    0.00153956f, 0.02473859f, 0.01736760f, 0.01561282f, 0.01799537f, -0.01928224f, -0.03220646f, 0.01086297f, 
    0.03239518f, -0.01243661f, 0.05173014f, -0.06435127f, -0.03812840f, 0.05050823f, -0.02227169f, 0.00726055f, 
    0.05710053f, -0.05278328f, 0.05455022f, 0.01727858f, -0.01036829f, -0.00286391f, -0.01285711f, -0.00229563f, 
    -0.06178666f, 0.00642093f, -0.05333861f, -0.04382855f, -0.03865976f, -0.02012924f, -0.06119255f, 0.03176701f, 
    0.01644887f, -0.04141149f, -0.05844006f, 0.04180122f, -0.06487628f, -0.04334071f, 0.03126498f, 0.03223980f, 
    -0.02000578f, 0.02465725f, -0.03421750f, 0.02992821f, -0.02028084f, 0.00187580f, 0.02196432f, -0.04343457f, 
    -0.04769029f, -0.03379089f, -0.04482973f, -0.01977351f, -0.01786859f, 0.00119162f, 0.04199490f, 0.03887980f, 
    -0.01017212f, 0.00562006f, -0.06448163f, -0.06461590f, 0.00000878f, 0.00650000f, -0.05037507f, 0.00969765f, 
    -0.04958586f, 0.02379249f, 0.00784811f, 0.00064426f, 0.01955906f, 0.00482716f, -0.05900117f, 0.03438754f, 
    -0.00951025f, 0.00416097f, -0.01607345f, 0.01445047f, 0.04507189f, -0.00013830f, 0.00623042f, -0.01148987f, 
    0.05841245f, 0.05155092f, -0.02036877f, -0.05940428f, -0.01742631f, -0.02607688f, 0.00732919f, 0.01248416f, 
    -0.06276673f, -0.02382600f, -0.05090531f, -0.01205600f, -0.05763248f, -0.05868232f, -0.01375106f, -0.04621204f, 
    0.02280248f, -0.02945421f, -0.05008900f, 0.00053746f, -0.03112254f, 0.02196158f, 0.01245414f, 0.05271982f, 
    -0.04694685f, 0.00203942f, -0.01954502f, -0.03106433f, 0.01454541f, 0.03535367f, -0.03693452f, 0.00313729f, 
    0.03020981f, 0.05045873f, -0.04357482f, 0.00070428f, -0.05916003f, -0.03283136f, -0.01438198f, 0.00354023f, 
    -0.04306943f, -0.01729274f, -0.03925376f, 0.02976250f, -0.04186784f, -0.04579791f, -0.05794396f, -0.06053377f, 
    0.01341104f, -0.00095340f, 0.03337435f, -0.02685631f, -0.03437220f, -0.05195989f, -0.04961878f, 0.02265032f, 
    0.00711360f, -0.05251230f, -0.02391890f, 0.05260195f, -0.01607045f, -0.04266690f, 0.03938622f, 0.03211669f, 
    0.03153341f, 0.04571583f, -0.02572024f, 0.02773243f, 0.00778733f, -0.00671093f, -0.02109569f, -0.01030794f, 
    0.01908468f, -0.01614712f, -0.02617710f, 0.02302110f, -0.04481776f, 0.05251356f, -0.05673308f, 0.05099300f, 
    -0.05495662f, -0.03907561f, 0.03573112f, 0.00542614f, 0.01866786f, -0.05242145f, 0.05205023f, 0.02830654f, 
    -0.01386861f, -0.02705648f, 0.03358404f, 0.01733875f, -0.04285200f, -0.03031840f, 0.05165159f, -0.03981343f, 
    -0.03971055f, 0.01570593f, -0.04695950f, 0.02091681f, -0.03236464f, -0.04838009f, -0.06472813f, -0.04604265f, 
    0.02100716f, -0.06498396f, 0.03437502f, 0.01916545f, -0.01124146f, 0.04505207f, 0.04666393f, -0.00364950f, 
    0.01097650f, 0.00630575f, 0.03962966f, 0.01086189f, 0.02385095f, 0.01642718f, 0.02207744f, -0.03646505f, 
    -0.02240265f, -0.03067879f, 0.00586430f, -0.02240103f, -0.01400625f, -0.04776269f, -0.03777678f, 0.01911714f, 
    -0.02349370f, -0.05961294f, 0.04097498f, -0.05225972f, 0.01461958f, 0.03047200f, -0.03960784f, -0.02193453f, 
    0.03719005f, -0.04121982f, -0.03465303f, 0.01303190f, 0.01830125f, 0.02717837f, 0.03947189f, -0.04045435f, 
    0.02091089f, 0.00337593f, 0.05158238f, -0.01522013f, 0.03384089f, -0.03213800f, 0.01330351f, 0.04368426f, 
    0.04163950f, 0.02289913f, 0.02169303f, -0.04885557f, 0.04922709f, -0.01642118f, -0.04283462f, 0.01654387f, 
    0.00084282f, 0.03587770f, -0.02021647f, -0.04748018f, 0.02469930f, -0.04940462f, -0.03497095f, -0.00958510f, 
    -0.03204148f, -0.04340223f, -0.04770947f, -0.05148281f, -0.03653928f, -0.02539632f, 0.03800645f, 0.02048798f, 
    -0.06053001f, 0.00746120f, 0.02672313f, -0.06436983f, 0.05082040f, -0.03314009f, 0.01396105f, 0.03454120f, 
    -0.02941478f, 0.00449904f, 0.01394038f, -0.05631831f, 0.01793529f, -0.01468017f, -0.04794565f, 0.00674475f, 
    -0.03228172f, -0.04882303f, -0.00422655f, 0.01928946f, 0.02043468f, -0.04252585f, -0.00034048f, 0.01282827f, 
    0.02050778f, -0.06231869f, 0.03732433f, -0.02227313f, 0.02296665f, 0.04429029f, 0.01270249f, 0.02003475f, 
    -0.05211328f, -0.06576219f, -0.00171282f, -0.06577918f, -0.01305268f, -0.06182373f, 0.01506249f, -0.02827183f, 
    0.00359877f, 0.00821812f, 0.00888868f, 0.02920571f, 0.05203053f, -0.01049708f, 0.06116811f, -0.03816956f, 
    -0.06487265f, -0.01828254f, -0.04392434f, -0.05017744f, 0.01142072f, 0.02386850f, 0.00546669f, 0.02942564f, 
    0.01822052f, -0.03186690f, -0.04182399f, -0.03217598f, 0.00809483f, -0.00525714f, 0.02223319f, -0.04457813f, 
    0.02544733f, 0.00121465f, -0.01609691f, -0.02818255f, 0.02369051f, -0.04231384f, -0.02448746f, 0.03769271f, 
    -0.06127619f, 0.04577996f, 0.01548431f, 0.00221573f, -0.06217027f, -0.00121070f, -0.05319202f, 0.03949668f, 
    -0.05750524f, 0.02345929f, -0.03135675f, -0.05788353f, -0.06298295f, -0.04339097f, 0.04786479f, -0.01358841f, 
    -0.05058907f, -0.02676561f, -0.06695499f, 0.00489875f, -0.05374973f, -0.00498590f, -0.02742241f, -0.04840513f, 
    -0.02939440f, 0.04674637f, -0.02253254f, -0.04705621f, -0.05479547f, -0.01723410f, 0.00089393f, -0.02698204f, 
    -0.00202818f, 0.03653871f, 0.00658477f, 0.00284140f, -0.05178911f, 0.02981109f, -0.01786641f, 0.00282541f, 
    -0.00473656f, -0.00892261f, -0.03523110f, -0.06462710f, -0.01963751f, -0.01984326f, 0.04423542f, 0.01239894f, 
    0.04493052f, -0.00153061f, -0.04832448f, 0.03293552f, -0.03877573f, 0.02215813f, 0.02941306f, -0.06182660f, 
    -0.03511262f, -0.04140037f, -0.06703532f, -0.04343757f, -0.05349040f, -0.02161963f, -0.02621605f, -0.04579608f, 
    0.03951985f, -0.05846868f, 0.00487502f, -0.06002261f, 0.01383701f, -0.05994665f, 0.04408839f, 0.01668674f, 
    0.04116715f, 0.03533060f, -0.02640573f, 0.02051482f, -0.00129587f, -0.05719211f, 0.05049451f, -0.05083033f, 
    0.02587247f, 0.03300067f, -0.01452055f, -0.01486658f, -0.01344154f, 0.02813954f, -0.04406875f, -0.02502673f, 
    -0.02934906f, -0.06200789f, 0.01682575f, 0.04222957f, -0.01389940f, -0.02657921f, 0.03695071f, 0.04154975f, 
    -0.01058757f, 0.01709470f, -0.04318525f, 0.02501335f, 0.01203156f, 0.05116783f, -0.05422436f, 0.03333263f, 
    -0.02646610f, 0.04029107f, -0.05921495f, -0.05115651f, -0.03662378f, -0.02417388f, -0.03564566f, -0.05804701f, 
    0.01043551f, -0.04626532f, -0.05489469f, -0.02387649f, -0.02374391f, 0.03468314f, 0.04933621f, 0.02034559f, 
    0.04985113f, -0.06266011f, 0.01672494f, -0.06509423f, -0.06677683f, -0.02829519f, -0.04141021f, 0.04880145f, 
    -0.01110640f, 0.03861203f, -0.00000072f, -0.05238861f, 0.01719471f, 0.01568994f, -0.02909462f, -0.01640451f, 
    0.02663467f, -0.05042363f, 0.05210518f, -0.00442075f, -0.07623508f, 0.00042257f, -0.03405748f, -0.06580147f, 
    -0.00043535f, -0.06844226f, -0.05104713f, -0.06202266f, 0.02389356f, -0.01516135f, 0.01495664f, -0.02740440f, 
    0.02465841f, -0.01240779f, -0.07901393f, -0.00012785f, 0.00749730f, 0.04100851f, 0.02233665f, 0.00838217f, 
    0.02935483f, 0.00266856f, -0.01473112f, -0.01913495f, -0.04855834f, -0.06216428f, 0.01723194f, 0.01699005f, 
    -0.00739743f, 0.00527027f, -0.00083217f, 0.01610686f, -0.06191878f, -0.06287954f, -0.03763699f, -0.05255292f, 
    -0.00909221f, -0.03400582f, -0.00165158f, -0.03862193f, -0.08232622f, -0.04881853f, -0.01471565f, -0.04114354f, 
    -0.05976454f, -0.00427327f, 0.02358347f, -0.00933177f, -0.02369795f, -0.04054489f, -0.00936965f, -0.07320845f, 
    -0.03808485f, -0.05632287f, 0.02988945f, -0.01232577f, 0.00554034f, 0.00228416f, -0.00535809f, 0.02073054f, 
    0.03658694f, -0.07970481f, -0.03862771f, -0.06016739f, -0.04736391f, -0.01781848f, 0.03339629f, -0.05581871f, 
    -0.04427926f, 0.01868559f, -0.08200731f, -0.06229106f, 0.04112308f, 0.03164537f, 0.01404918f, -0.04427688f, 
    -0.05678005f, 0.01426112f, -0.02852243f, -0.01167217f, 0.03760275f, -0.02543462f, 0.00029922f, -0.02263897f, 
    -0.05123688f, 0.02912019f, -0.00764090f, 0.00226309f, 0.00077569f, -0.07920374f, -0.08516214f, -0.02542570f, 
    -0.01614753f, -0.04595532f, -0.02799579f, -0.01082085f, -0.05655026f, -0.04662779f, -0.00897112f, -0.06244849f, 
    -0.07646829f, -0.03475036f, 0.01652971f, 0.02214953f, 0.01212957f, -0.05567412f, -0.06625862f, -0.03355349f, 
    -0.00802950f, -0.05494411f, -0.04806353f, -0.03986415f, -0.00411614f, -0.02733338f, -0.00455258f, 0.02858554f, 
    0.02869253f, -0.01129274f, -0.05408402f, -0.03431070f, -0.01476055f, -0.02788448f, -0.06931943f, 0.01597240f, 
    -0.02263227f, -0.08653621f, 0.02374673f, -0.06882786f, -0.00564475f, -0.05921794f, 0.01071237f, -0.05278134f, 
    0.03259034f, 0.02276807f, -0.00469437f, -0.03771648f, -0.01311615f, 0.02324608f, -0.02618716f, 0.01638288f, 
    -0.02047547f, 0.03503656f, 0.01517253f, 0.00816994f, 0.00071791f, -0.06450724f, 0.02107682f, -0.02583973f, 
    0.00359183f, -0.00663602f, -0.05684916f, -0.01963932f, 0.03269336f, 0.01156972f, -0.01765206f, -0.03726142f, 
    -0.01340693f, -0.07286160f, -0.08332138f, -0.00637737f, -0.00352858f, -0.06905800f, 0.00886292f, 0.01100788f, 
    -0.05245914f, 0.02512508f, -0.06360815f, -0.03790642f, -0.05161270f, -0.01678711f, -0.04536768f, 0.02880823f, 
    0.02280821f, 0.02768344f, -0.05561679f, -0.08423018f, -0.05151303f, -0.01602077f, -0.02068157f, -0.06413744f, 
    -0.08046694f, -0.04710854f, 0.00976092f, -0.06040044f, 0.03076643f, -0.04023518f, -0.01896676f, -0.00171871f, 
    -0.03788663f, -0.04564308f, 0.00676116f, -0.00273619f, -0.03727522f, -0.06470800f, 0.01617570f, -0.04828191f, 
    -0.02571470f, 0.01753445f, -0.06091188f, -0.02566900f, -0.07513753f, -0.07797852f, -0.00743798f, 0.02253142f, 
    0.02824790f, -0.04744728f, -0.08671042f, -0.01610203f, -0.04896211f, -0.00195601f, -0.05919158f, -0.03867638f, 
    0.03370010f, -0.04357183f, -0.01182210f, -0.00362024f, -0.01424094f, 0.01951932f, 0.00609980f, -0.06940240f, 
    -0.06402828f, -0.02680740f, -0.04461264f, -0.04709863f, 0.01457735f, -0.06928495f, -0.02983383f, -0.05669039f, 
    -0.01424551f, -0.04847249f, 0.00727310f, 0.01827619f, 0.02710855f, 0.00475044f, -0.00970480f, -0.03049474f, 
    -0.04883782f, -0.03875204f, 0.00638505f, -0.07010482f, 0.02289378f, -0.00244081f, -0.03933981f, 0.03820447f, 
    -0.00113120f, -0.00673895f, -0.06207354f, -0.07347109f, -0.00603512f, -0.05637346f, 0.00833594f, -0.01778339f, 
    -0.07951886f, -0.00393409f, 0.00980906f, -0.00175714f, -0.07281774f, 0.03630384f, 0.02130485f, -0.03304373f, 
    -0.03143489f, -0.01847965f, -0.02855897f, 0.02018216f, 0.02070081f, -0.05542160f, -0.05340916f, -0.01916493f, 
    -0.04126144f, -0.06424507f, -0.05590199f, 0.00691964f, 0.00756676f, -0.04193047f, -0.01548046f, -0.03128062f, 
    0.01691904f, 0.00415718f, -0.05319720f, -0.06394766f, -0.01493304f, -0.02954397f, -0.00863550f, 0.00010017f, 
    0.01428743f, 0.04845029f, -0.03696331f, -0.04959806f, 0.00087510f, -0.00184127f, -0.00537810f, 0.02951734f, 
    0.02158301f, -0.05853983f, -0.05097499f, -0.01546765f, -0.03327456f, -0.02881332f, 0.01777473f, 0.02312602f, 
    -0.05201986f, 0.04463242f, -0.02892926f, -0.06367576f, -0.01589884f, 0.05121445f, 0.03714161f, -0.00461788f, 
    0.04943621f, -0.03743396f, -0.06322092f, -0.04104649f, 0.01597305f, 0.04098441f, -0.04373912f, -0.04739355f, 
    0.03461594f, -0.04035654f, 0.03805059f, 0.00795038f, 0.02583818f, -0.04352753f, 0.01703086f, -0.03055846f, 
    -0.02266869f, -0.02230812f, -0.04404764f, 0.03153790f, 0.02154298f, 0.00061628f, -0.00507175f, -0.03441595f, 
    -0.00650918f, 0.04798225f, 0.02851832f, 0.04076016f, 0.04962364f, -0.00895881f, -0.02840265f, -0.01022626f, 
    -0.02262415f, 0.01296130f, -0.03354052f, -0.00096141f, 0.05210041f, -0.00549403f, 0.04975297f, -0.04332018f, 
    -0.01491560f, 0.00151563f, -0.00939613f, 0.01802589f, 0.03239394f, 0.00408293f, -0.00160607f, -0.05372513f, 
    0.03944398f, -0.03030739f, 0.03845158f, 0.05802997f, -0.01862160f, -0.03080325f, -0.05767096f, -0.02685602f, 
    0.04854008f, -0.01244556f, -0.04094337f, 0.00708457f, 0.02339410f, -0.02033453f, -0.03853334f, 0.04839002f, 
    0.03512293f, -0.05167674f, -0.01104112f, -0.01748950f, 0.04139594f, 0.02017692f, -0.01340273f, -0.05629965f, 
    -0.05144398f, 0.04034589f, 0.00310006f, 0.00133198f, -0.01229255f, -0.06155668f, 0.00237891f, -0.02422922f, 
    -0.04425367f, 0.02893853f, 0.03976901f, -0.00054157f, -0.04031051f, -0.01531539f, 0.03531576f, -0.02299841f, 
    -0.06430837f, -0.02353631f, 0.04285750f, 0.02161263f, -0.00109340f, -0.02126949f, -0.00586617f, 0.02300759f, 
    0.00479392f, 0.02735903f, -0.05127271f, 0.03422882f, -0.03691058f, -0.05970724f, -0.00995210f, -0.02297383f, 
    -0.04188333f, 0.01764218f, -0.02783179f, -0.04118529f, 0.01463790f, 0.04285999f, -0.02119694f, -0.06220188f, 
    0.01385202f, 0.02177064f, -0.03864954f, 0.04581808f, 0.03623680f, 0.03873142f, -0.00854420f, -0.01281871f, 
    -0.02860087f, 0.04935383f, 0.00691959f, -0.04925513f, -0.03832790f, -0.05644935f, -0.03798488f, -0.02401609f, 
    -0.01272569f, -0.05216444f, -0.01705459f, 0.03690609f, -0.01914307f, -0.00352924f, -0.05144870f, -0.01697263f, 
    -0.06123002f, -0.01833062f, -0.01414247f, -0.03733212f, 0.01344171f, 0.01283369f, 0.01603185f, 0.00852591f, 
    -0.01693238f, -0.01045705f, -0.04856134f, -0.06403112f, -0.01138403f, -0.05140996f, -0.04902520f, -0.04292512f, 
    -0.03267418f, 0.04915534f, -0.01205328f, 0.02755117f, 0.03010679f, -0.05547240f, -0.04243675f, -0.05899501f, 
    0.04638432f, -0.04287845f, 0.03221879f, -0.04544082f, 0.00245770f, -0.04052515f, -0.01520702f, -0.03298440f, 
    0.00339693f, -0.02914624f, 0.02500262f, 0.00484512f, 0.04654454f, 0.04207029f, 0.03627136f, -0.05033096f, 
    -0.03371169f, 0.02914089f, 0.04555181f, 0.02305893f, -0.00120821f, -0.03095421f, 0.04896113f, 0.02067059f, 
    -0.03462685f, -0.03680560f, -0.04641211f, -0.01745659f, -0.04881456f, 0.01161847f, 0.01548995f, 0.03596886f, 
    -0.01863449f, -0.01166544f, -0.00102937f, 0.02727354f, -0.05968226f, -0.04638796f, 0.01116622f, 0.00964278f, 
    -0.03685337f, -0.02897133f, -0.03067867f, -0.00363247f, -0.00054286f, -0.04029701f, 0.00870545f, 0.01518160f, 
    -0.01205558f, -0.06313326f, -0.03696053f, -0.02433645f, 0.03605824f, -0.05270653f, -0.02742388f, -0.05534684f, 
    0.05026124f, -0.03335761f, -0.03457107f, -0.05682511f, 0.03803747f, -0.05192065f, 0.04803732f, 0.00770117f, 
    0.03670779f, -0.01155858f, -0.02914971f, 0.02068730f, -0.03117904f, -0.01176712f, -0.04001438f, -0.00424937f, 
    0.00781059f, -0.05665588f, -0.05395327f, 0.02990903f, -0.01642054f, -0.05708346f, -0.01135788f, 0.02886378f, 
    -0.04626792f, 0.00556390f, -0.00746727f, -0.05430845f, -0.05005480f, -0.01758270f, -0.03057306f, 0.01341824f, 
    -0.01212020f, 0.04486374f, 0.04111591f, 0.01224524f, 0.02881454f, -0.02632541f, 0.03440188f, 0.04685247f, 
    -0.06025776f, 0.01594823f, -0.00237940f, 0.02446836f, 0.00400902f, -0.04564885f, -0.01163269f, 0.05010061f, 
    0.04939607f, 0.01036298f, -0.00794036f, -0.06419424f, 0.00122371f, 0.03928899f, 0.02556182f, -0.00564559f, 
    0.04420921f, -0.02967825f, -0.06956302f, -0.04203762f, 0.01761000f, -0.05618934f, 0.01342166f, -0.01896633f, 
    0.00011564f, -0.01762987f, 0.04885932f, 0.02161860f, -0.05553257f, -0.05673699f, 0.03360042f, -0.02733016f, 
    -0.02562082f, -0.04715507f, 0.00961420f, -0.04845421f, 0.01009751f, 0.04647906f, -0.05168375f, -0.05116037f, 
    -0.04292720f, 0.04959096f, -0.03039171f, 0.00910350f, -0.04237548f, -0.00763213f, -0.05226456f, 0.04194516f, 
    -0.01981406f, -0.05182888f, -0.03571649f, 0.02257213f, 0.00558164f, -0.01774231f, -0.02694695f, 0.01731470f, 
    -0.00513151f, -0.01723967f, -0.01228574f, 0.03692965f, -0.01392333f, -0.03136016f, 0.03835813f, 0.02989282f, 
    -0.02238725f, -0.05266338f, -0.03037314f, -0.02737900f, -0.02422379f, 0.00367728f, -0.02465696f, 0.00515949f, 
    0.02189397f, 0.04755912f, -0.01523821f, -0.02559349f, -0.05001846f, 0.03267090f, -0.06666034f, -0.04141163f, 
    -0.05168138f, -0.04106088f, 0.05116967f, 0.01484168f, 0.04446625f, 0.01015283f, 0.03780482f, 0.00345804f, 
    0.00212286f, 0.01921109f, 0.01892196f, -0.05610301f, -0.04865248f, 0.01985272f, -0.02520862f, -0.03654321f, 
    -0.05831463f, 0.03359312f, -0.03370810f, -0.04416922f, -0.02269160f, -0.01411725f, 0.03144535f, 0.03610522f, 
    0.01014073f, 0.01557582f, -0.02356439f, -0.04627938f, -0.00635808f, -0.02348631f, -0.00477817f, -0.02583304f, 
    -0.04211587f, -0.04761420f, -0.03607572f, -0.00504052f, -0.04179924f, -0.03632205f, -0.03881957f, 0.04140340f, 
    0.02296475f, -0.04376755f, -0.05196667f, 0.03336536f, 0.03957345f, -0.06389569f, -0.05312423f, 0.02112080f, 
    -0.03968915f, -0.03839161f, -0.05752012f, 0.00058400f, -0.03310217f, 0.02632618f, -0.00821207f, 0.02373974f, 
    -0.01332000f, -0.01031225f, 0.05730845f, 0.01209131f, -0.03521324f, -0.04490181f, 0.01808504f, 0.02867228f, 
    -0.03485508f, -0.00538225f, -0.04377825f, 0.05076760f, 0.00692199f, 0.04014881f, 0.00446718f, -0.01668565f, 
    -0.00991081f, -0.02095064f, 0.00007281f, 0.02464461f, -0.04410924f, -0.05368229f, -0.04552559f, -0.05134792f, 
    -0.03831410f, -0.00838999f, 0.03604541f, -0.06600006f, -0.03344067f, -0.01204022f, -0.01432827f, 0.00721117f, 
    -0.06238794f, -0.01393594f, 0.05343564f, -0.01085509f, -0.03113964f, -0.01552801f, 0.04507225f, 0.00642073f, 
    -0.06132977f, 0.00516030f, 0.01629927f, -0.02280708f, -0.06538068f, -0.02100256f, 0.04208096f, -0.05135141f, 
    0.02862217f, -0.05285254f, 0.01889287f, 0.04591630f, 0.01274582f, -0.05369407f, -0.04655447f, 0.04404161f, 
    -0.03187477f, 0.00277949f, 0.05266235f, -0.02003687f, -0.06187771f, 0.04541847f, -0.02380801f, -0.05534483f, 
    -0.04807390f, -0.01012331f, -0.01260821f, 0.01625890f, 0.03654473f, -0.03298232f, 0.01813222f, -0.03164491f, 
    0.02712581f, -0.02037133f, 0.04039439f, -0.00395695f, 0.02235248f, 0.03696272f, -0.01632571f, -0.01628643f, 
    -0.00231488f, -0.03559066f, -0.00037225f, 0.05541035f, -0.02742974f, 0.00352624f, 0.04966142f, 0.02738883f, 
    -0.00453997f, -0.01731975f, -0.04482409f, 0.03966435f, -0.04306274f, -0.02853605f, 0.00277261f, -0.00366605f, 
    -0.01724331f, 0.05174479f, -0.02135826f, -0.06647535f, -0.05611714f, -0.01694041f, -0.06044035f, 0.01068091f, 
    0.03374799f, 0.03527456f, -0.04947139f, 0.03770078f, 0.00408866f, 0.05409484f, -0.00692127f, -0.01464380f, 
    -0.02007469f, 0.00090975f, -0.04699713f, 0.05721203f, 0.03071982f, -0.04083284f, -0.00316359f, -0.01326355f, 
    0.02999689f, 0.01711958f, -0.01255052f, 0.00195594f, 0.02551831f, 0.01896546f, -0.04334814f, 0.02619485f, 
    0.05199615f, 0.04567795f, -0.02111875f, 0.00740985f, 0.01307237f, 0.00566137f, -0.05805436f, 0.00009233f, 
    -0.02097881f, -0.05258282f, 0.05546025f, 0.04179408f, -0.03702198f, -0.00409752f, -0.05888847f, 0.00485734f, 
    -0.04325484f, -0.01702495f, -0.00433746f, -0.02023266f, 0.01521221f, -0.02826810f, 0.04346273f, -0.02157887f, 
    -0.03410176f, -0.05298229f, 0.02760866f, -0.01486578f, 0.01548204f, -0.06129768f, -0.00546658f, 0.04324178f, 
    0.22584729f, -0.22043112f, -0.00004777f, -0.10801202f, -0.13921462f, -0.02701236f, 0.14048193f, 0.12663729f, 
    0.09361263f, 0.06922790f, 0.04842200f, 0.21616881f, -0.08411191f, -0.13938098f, 0.01157132f, 0.09111669f, 
    0.11250582f, 0.04390177f, 0.39799485f, 0.43349856f, 0.00959077f, 0.08987717f, -0.06906400f, -0.08754526f, 
    0.15985690f, 0.08500453f, -0.07622035f, -0.12781470f, 0.12743057f, 0.24958086f, 0.03322999f, 0.03114059f, 
    0.16407122f, -0.15425725f, -0.11841523f, 0.06084840f, -0.32986486f, 0.12163995f, -0.16739260f, 0.03811432f, 
    0.11952058f, 0.01056471f, 0.32607532f, -0.20159297f, -0.04169997f, -0.17801583f, -0.25276887f, 0.10767634f, 
    0.08728579f, 0.01040913f, 0.00228309f, 0.09565661f, -0.10692151f, 0.31143120f, -0.18359570f, 0.17263815f, 
    0.03635783f, 0.07374328f, -0.10944997f, 0.02453070f, 0.09432299f, 0.19118178f, 0.14327613f, 0.22461067f, 
    0.15763672f, -0.22334096f, 0.09281026f, 0.09720459f, 0.08075940f, 0.01706810f, -0.08777861f, 0.19391905f, 
    -0.02794455f, 0.16268520f, 0.20565803f, -0.00042070f, -0.00680123f, -0.02748919f, 0.27213699f, 0.06701142f, 
    0.11288059f, -0.18011831f, 0.08585439f, -0.06316574f, 0.05998934f, 0.09943046f, 0.04291129f, 0.00277066f, 
    -0.00488094f, 0.12380243f, -0.02042165f, 0.36303121f, 0.09921770f, 0.08475073f, -0.15066889f, -0.06765197f, 
    0.03618643f, 0.07521104f, 0.27706549f, 0.42227563f, -0.00504541f, -0.05924306f, 0.13927352f, 0.11110363f, 
    -0.21106277f, 0.08568806f, 0.13946995f, -0.20395370f, -0.20424274f, 0.16205020f, 0.28284445f, -0.07051855f, 
    0.10741917f, -0.01130447f, -0.20940940f, 0.00785960f, 0.11623193f, -0.11345199f, -0.33609205f, -0.12587465f, 
    -0.00131654f, 0.02435346f, -0.02684748f, 0.21125880f, 0.04273171f, -0.27101490f, -0.33725926f, 0.14310464f, 
    -0.11719445f, 0.10928113f, -0.06289446f, -0.39884377f, 0.05813168f, -0.01140153f, 0.18545352f, -0.15818608f, 
    -0.12012081f, 0.00646768f, 0.10497432f, 0.03559315f, 0.23796670f, 0.05171214f, -0.10690679f, -0.15426116f, 
    -0.16410002f, -0.20442611f, 0.01433270f, -0.09449741f, -0.07355009f, -0.03541397f, 0.15841870f, -0.06767770f, 
    0.15271544f, 0.05127731f, 0.15803047f, 0.04432270f, -0.18550164f, -0.11649431f, -0.09017849f, 0.19291440f, 
    0.15034583f, 0.13013126f, 0.30027151f, -0.10807358f, 0.15357725f, -0.00977171f, 0.09416637f, -0.16525680f, 
    0.22757658f, -0.09608140f, 0.03543885f, -0.22765967f, -0.05449517f, -0.03021993f, 0.02060793f, 0.03994317f, 
    -0.16627561f, -0.17019904f, -0.03645669f, -0.12547511f, 0.10529895f, 0.27514893f, -0.09433619f, -0.07827422f, 
    -0.02988933f, -0.19834778f, 0.02597744f, 0.05040940f, 0.05880051f, 0.09427674f, 0.06839753f, -0.17474021f, 
    0.17223257f, -0.01121802f, -0.03778363f, -0.05215599f, -0.05611219f, -0.10920315f, 0.07997249f, -0.07835891f, 
    -0.00302497f, -0.01705647f, -0.03191657f, 0.08156083f, 0.03316685f, 0.03613895f, 0.24512513f, -0.33500555f, 
    -0.16741946f, 0.21795577f, -0.16805302f, 0.00198308f, -0.09376778f, -0.01775547f, 0.02200565f, 0.06411875f, 
    0.02391490f, -0.36566457f, -0.36196479f, -0.06138482f, -0.00426168f, 0.18243290f, -0.01872483f, -0.02244906f, 
    -0.09116060f, -0.03288998f, -0.11049263f, -0.08152348f, -0.04144247f, -0.15509324f, 0.00505412f, 0.08376203f, 
    0.33321938f, 0.02268995f, -0.06520176f, 0.02307809f, 0.03877227f, -0.21409430f, -0.24254273f, -0.03734130f, 
    0.05216487f, -0.05794265f, 0.04044215f, -0.28152210f, 0.15452398f, 0.03733244f, 0.02408077f, 0.02033565f, 
    0.10578531f, 0.07999596f, 0.04723936f, 0.05733663f, 0.03520390f, -0.38155836f, -0.08567255f, -0.22803701f, 
    0.05779655f, 0.18290411f, -0.11183182f, -0.05419689f, -0.06875791f, -0.58490247f, -0.07225718f, 0.02594070f, 
    -0.05806980f, 0.05139837f, 0.00422179f, -0.13290019f, 0.10735735f, -0.10699772f, -0.15382995f, 0.10095513f, 
    -0.02370172f, 0.12171961f, 0.02865215f, -0.15580665f, 0.07899906f, 0.00370103f, -0.02670102f, -0.09623674f, 
    -0.10420948f, -0.06187630f, -0.04577148f, -0.04489880f, 0.27288643f, -0.06761623f, 0.05691729f, -0.15918946f, 
    0.26649448f, -0.09543461f, -0.37087211f, 0.19753289f, -0.07821774f, 0.15454081f, 0.29885420f, -0.08489272f, 
    0.11966780f, 0.08903864f, 0.21999693f, -0.25428510f, -0.00422138f, -0.16456731f, -0.06154336f, 0.13930739f, 
    0.14359194f, -0.06155247f, 0.09435075f, -0.31285673f, -0.03445122f, 0.13791564f, 0.06818266f, -0.03722437f, 
    -0.15382409f, -0.20437568f, 0.11548959f, -0.55665499f, -0.08021547f, 0.26243892f, 0.17839409f, -0.11292486f, 
    -0.12238504f, 0.10563798f, -0.00751086f, -0.23004553f, -0.10100902f, 0.26845208f, -0.00675756f, 0.19787398f, 
    0.08416539f, 0.07851239f, -0.10751236f, -0.09561013f, -0.14365287f, -0.10594283f, -0.14801219f, -0.26245913f, 
    -0.29831100f, -0.13412736f, -0.07295988f, -0.30898017f, -0.03093571f, 0.03935033f, 0.29376090f, -0.45153043f, 
    -0.22094977f, 0.02277668f, 0.20356779f, -0.02486802f, -0.00160418f, 0.11544799f, 0.13653272f, -0.03048975f, 
    -0.24948898f, 0.11614557f, -0.03430166f, -0.01302038f, 0.00764888f, -0.22153035f, -0.03492151f, -0.00821031f, 
    0.01775827f, -0.22120851f, 0.04550105f, 0.21855383f, 0.04194807f, -0.06875075f, 0.06729630f, -0.17853920f, 
    -0.22820327f, 0.10741843f, 0.09315310f, 0.40833306f, -0.04694853f, -0.05002112f, -0.00446675f, 0.08159781f, 
    0.15494797f, 0.02624740f, 0.19815233f, 0.10763126f, -0.01391010f, 0.17899048f, 0.08764468f, -0.01541483f, 
    0.23017803f, 0.10468992f, 0.14811783f, 0.41101569f, 0.04032551f, 0.08903407f, -0.04229251f, -0.04839035f, 
    -0.00245194f, 0.18977894f, 0.15157010f, 0.23426464f, 0.24152464f, -0.25767764f, 0.02659145f, 0.25855863f, 
    0.16229084f, 0.00745244f, -0.04440392f, -0.09129641f, -0.10684691f, -0.64038610f, 0.03445512f, -0.10831057f, 
    -0.13166027f, 0.11578792f, -0.03233984f, -0.13019039f, -0.03772504f, 0.04314034f, 0.06673523f, 0.36920714f, 
    -0.29757038f, 0.10104056f, 0.18711701f, -0.30873400f, 0.02719548f, 0.04509351f, 0.27475351f, -0.44835618f, 
    -0.13651589f, 0.20687790f, -0.16929878f, 0.11831930f, -0.26235297f, -0.14902712f, -0.04097401f, 0.27498984f, 
    0.06879926f, 0.15418445f, -0.00305331f, -0.08858465f, -0.12413149f, -0.04312975f, -0.08713264f, -0.04356042f, 
    -0.01082139f, 0.25084603f, -0.17090283f, -0.13711572f, 0.16856508f, 0.19449443f, 0.05580507f, 0.06068587f, 
    -0.08800010f, 0.04420048f, 0.30619997f, -0.16918999f, -0.15958400f, 0.08493648f, 0.00518658f, -0.03445290f, 
    -0.08299729f, 0.31906942f, 0.06030697f, -0.18297757f, 0.08175984f, 0.07215194f, -0.11204559f, 0.00941883f, 
    0.12906457f, 0.02091827f, 0.09804612f, 0.11516839f, 0.33867612f, 0.22413108f, 0.07858885f, 0.06542242f, 
    0.06641141f, 0.00197907f, -0.08824120f, -0.07653773f, 0.16267377f, -0.16250135f, -0.19448864f, 0.19084226f, 
    0.23287754f, -0.06840265f, 0.01775706f, 0.13016379f, 0.10964419f, -0.07712413f, 0.00462596f, -0.12819329f, 
    0.10296948f, -0.18260159f, 0.05487571f, -0.05633990f, 0.06637286f, 0.05687883f, 0.15115187f, 0.03211281f, 
    0.16509011f, -0.17790286f, 0.07557397f, -0.17916180f, 0.05711775f, 0.23383622f, 0.02428158f, 0.14845489f, 
    -0.21208723f, 0.00911457f, 0.00701089f, -0.05323491f, 0.06587271f, 0.34722066f, 0.04476205f, 0.14877208f, 
    -0.11682016f, -0.09076726f, -0.31442699f, 0.11937099f, -0.00275381f, 0.15403482f, 0.03011709f, -0.15553962f, 
    -0.09853179f, 0.13662778f, 0.07505973f, 0.07521064f, 0.19376332f, -0.02268874f, -0.05601533f, -0.15801467f, 
    -0.07560421f, -0.15216908f, 0.17482331f, -0.27481934f, -0.04519657f, 0.16713096f, 0.24603322f, -0.00899125f, 
    -0.07627247f, -0.16257495f, 0.13078368f, 0.02919217f, -0.14676504f, 0.27665976f, 0.33185902f, -0.24745983f, 
    -0.10329287f, 0.04037207f, -0.11429180f, 0.05816145f, -0.04690606f, -0.63291633f, 0.26546526f, -0.03449728f, 
    -0.14291893f, -0.17815959f, -0.07864049f, 0.03136164f, 0.10429661f, 0.06668126f, 0.04724924f, -0.03204728f, 
    -0.13900264f, 0.05023478f, -0.09590438f, -0.04815880f, -0.03598584f, -0.02297921f, -0.12456281f, -0.17453656f, 
    0.12349521f, 0.08848885f, -0.37370813f, -0.10313737f, -0.22694422f, -0.04998897f, 0.08432101f, -0.03867612f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01617002f, -0.04051008f, 0.06477030f, -0.06206925f, 0.04592107f, -0.06985147f, -0.05921192f, -0.05951081f, 
    0.11679656f, 0.22804761f, 0.07234672f, 0.00130352f, 0.04940807f, -0.05805882f, 0.04813951f, -0.24448329f, 
    0.18074387f, 0.05541605f, -0.11748207f, -0.12868991f, 0.31648457f, 0.06004346f, -0.10096205f, -0.03586514f, 
    0.18410772f, 0.02571093f, -0.05617565f, 0.01637405f, 0.03005094f, -0.01222480f, 0.10407799f, 0.27175310f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.63896143f, -0.08480180f, 0.27297789f, -0.00022752f, 0.44711578f, 0.05885888f, 0.10352668f, 0.08555954f, 
    -0.01399170f, -0.57504582f, 0.28210148f, -0.52211684f, 0.16548836f, 0.01891894f, 0.09301637f, -0.44563121f, 
    -0.26965564f, -0.51382518f, -0.21362332f, -0.09240156f, -0.41004622f, -0.14105581f, 0.21215063f, -0.06605374f, 
    -0.51914084f, -0.06103662f, 0.00502832f, 0.14850736f, 0.12340992f, -0.15202205f, 0.14047033f, 0.66403210f, 
    0.03527890f, -0.12630008f, -0.48026368f, -0.44429898f, -0.28836942f, 0.16572759f, -0.08502655f, -0.16342455f, 
    -0.08426432f, -0.25346598f, 0.43298775f, -0.25408435f, 0.12481009f, -0.02206936f, 0.12986049f, 0.35220650f, 
    -0.41980833f, 0.20999944f, -0.12472542f, -0.28289694f, 0.34769467f, -0.21763523f, 0.40045607f, -0.27892604f, 
    0.54421943f, 0.01165756f, -0.08973209f, 0.01541559f, -0.02483269f, 0.05878232f, 0.51707476f, 0.13899146f, 
    -0.24125394f, 0.06412151f, 0.13602938f, -0.16183123f, -0.33490068f, -0.15561914f, -0.10701454f, 0.11253661f, 
    -0.22753483f, 0.05741687f, 0.07192541f, 0.67226619f, -0.13688996f, -0.12003723f, -0.03721701f, -0.25920868f, 
    -0.63672924f, -0.19853702f, 0.22484712f, 0.31854495f, -0.23693743f, -0.38502663f, 0.73978251f, -0.30595189f, 
    -0.31184208f, -0.17756432f, 0.17014532f, 0.01790961f, -0.17835577f, -0.04789381f, -0.38174760f, -0.33771396f, 
    -0.72341907f, 0.00252951f, -0.12115595f, 0.55569559f, -0.13954245f, -0.05997949f, -0.12361319f, 0.01088352f, 
    0.00991725f, -0.43385261f, -0.38486928f, -0.05707157f, 0.14924507f, -0.05827018f, 0.05415266f, -0.23491488f, 
    0.95111752f, -0.49929085f, 0.14192972f, 0.47792956f, -0.30539808f, -0.08438542f, 0.03447249f, 0.10852475f, 
    0.16627771f, -0.05180838f, 0.11470316f, -0.02463455f, 0.06154373f, 0.07176301f, 0.00824928f, -0.50921679f, 
    -0.29084578f, -0.09897745f, 0.33397666f, -0.06198285f, -0.01314818f, -0.09708896f, -0.06465409f, -0.08725831f, 
    -0.20365027f, 0.13882422f, -0.53395069f, 0.40332720f, 0.15033558f, -0.01648378f, -0.06801412f, -0.45362756f, 
    0.20299765f, -0.37631509f, -0.53114557f, -0.43425542f, 0.45837587f, 0.46518561f, -0.22014607f, 0.17812723f, 
    -0.10849234f, -0.07976191f, 0.03932777f, -0.07108922f, -0.00712737f, 0.01598178f, -0.25089797f, 0.28979588f, 
    -0.01972995f, -0.17235605f, 0.08410053f, -0.36815718f, 0.86560869f, 0.03864652f, -0.04038120f, 0.08935014f, 
    0.03336745f, 0.01685672f, 0.38485646f, -0.27969968f, 0.07246116f, -0.14904250f, 0.10143393f, 0.35013172f, 
    0.15078889f, 0.38030267f, -0.65680981f, -0.44667667f, -0.02226439f, -0.42822927f, -0.57472330f, -0.70384806f, 
    -0.28175876f, -0.10185458f, 0.04276627f, 0.00568649f, -0.10352443f, -0.10034019f, 0.02500545f, 0.14280309f, 
    -0.43189421f, 0.15600055f, -0.37980807f, 0.21377733f, 0.17480530f, 0.15612550f, -0.10094893f, 0.14657830f, 
    -0.55444115f, 0.65662515f, 0.12353227f, -0.72719997f, -0.12240262f, -0.01733369f, 0.07587164f, -0.52302003f, 
    -0.04826683f, 0.66543543f, -0.12415089f, 0.09096934f, -0.46002200f, 0.53314888f, 0.01974258f, -0.19793259f, 
    0.00196200f, -0.00591025f, 0.08648870f, 0.08656694f, 0.06521520f, 0.10796355f, -0.41680074f, -0.63243449f, 
    0.44091347f, -0.08921516f, 0.41534323f, 0.07239843f, 0.10679870f, -0.17001274f, 0.16283524f, -0.11628271f, 
    0.19448885f, -0.84655714f, -0.54920280f, 0.22888926f, -0.06029645f, -0.11872645f, -0.05182303f, 0.51650006f, 
    -0.06096865f, -0.39432475f, -0.04838801f, -0.56041175f, -0.20551240f, 0.44424585f, -0.16954821f, 0.40688130f, 
    -0.45404539f, 0.15636544f, -0.12899016f, -0.02652963f, -0.05492721f, 0.01021007f, -0.13711567f, -0.06796922f, 
    0.50478244f, 0.04734860f, -0.50969929f, -0.54715157f, 0.04350809f, 0.01940040f, -0.16327384f, -0.08291014f, 
    -0.29352540f, -0.15134059f, 0.07721052f, 0.20550671f, -0.00740622f, 0.07346199f, 0.13271452f, 0.13112608f, 
    0.15118851f, -0.00719275f, 0.93942559f, 0.30108982f, 0.09732035f, -0.57747233f, -0.85217655f, -0.06662335f, 
    -0.06711181f, -0.13410108f, -0.12346244f, -0.15037411f, 0.06914376f, -0.04132551f, 0.27331671f, -0.05737929f, 
    -0.38466188f, -0.04180248f, 0.34771827f, -0.34829447f, -0.67147136f, -0.06127879f, 0.02150466f, -0.10068890f, 
    0.02788606f, 0.25092188f, 0.08130420f, -0.19582750f, -0.02778761f, 0.16199510f, 0.01860651f, -0.14281717f, 
    -0.20597181f, 0.42961523f, 0.92067945f, -0.27685109f, -0.28654614f, -0.15701190f, -0.33853513f, 0.39471048f, 
    -0.48236111f, -0.05254607f, 0.09044998f, 0.10564478f, 0.00858499f, -0.09101627f, -0.51416242f, 0.36264566f, 
    0.13598832f, 0.14963979f, -0.42004970f, 0.08911515f, -0.77186906f, 0.03210475f, -0.13293780f, -0.10684490f, 
    0.89421606f, 0.05344627f, 0.21138121f, 0.32784215f, 0.16910325f, -0.01460797f, -0.10661308f, -0.60638696f, 
    -0.21926300f, -0.47099420f, -0.28630573f, 0.10862345f, -0.06460278f, -0.09775459f, -0.45891607f, -0.15821786f, 
    0.39337280f, 0.11555264f, -0.18509693f, -0.10119067f, -0.17055829f, 0.09356756f, 0.34484732f, -0.27280328f, 
    0.01174867f, 0.02593444f, -0.10089909f, 0.36639783f, -0.34456795f, -0.16668916f, 0.05381556f, 0.04810216f, 
    -0.62921107f, 0.19174789f, 0.14681204f, -0.28365481f, -0.03489279f, 0.05431499f, -0.09722947f, 0.71543688f, 
    -0.02069096f, -0.31263292f, -0.52621394f, 0.54790634f, 0.13444370f, -0.54772979f, -0.25598422f, 0.18762608f, 
    -0.05838756f, -0.10163192f, -0.17728421f, 0.06799989f, -0.12375935f, -0.16642748f, -0.21839681f, -0.70576888f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.22328721f, 0.11196328f, -0.12054104f, 0.02811973f, 0.14785847f, -0.00399179f, -0.02469991f, -0.61466831f, 
    -0.18127508f, 0.14826587f, 0.01231105f, 0.14766562f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
