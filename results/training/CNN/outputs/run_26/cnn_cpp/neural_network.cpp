#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.27382815f, -1.34774697f, -0.49927434f, -0.00018687f, -0.52131665f, 0.11947234f, 0.27424279f, -0.35139048f, 
    -0.04147284f, 0.40682235f, 0.36592180f, 0.39246213f, -0.25438935f, 0.27157453f, 0.18218358f, -0.00044328f, 
    0.15732083f, 0.09767754f, 0.38531891f, 0.22063862f, 0.10891066f, 0.10526637f, 0.13938533f, -0.15196958f, 
    -0.02025263f, 0.08486615f, 0.93426561f, 0.47378129f, -0.18977225f, -0.16499560f, 0.08011536f, 0.46369156f, 
    -0.13237941f, -0.28922272f, -0.21250133f, -0.03442852f, 0.26700941f, 0.31817734f, 0.18835993f, 0.13532655f, 
    0.08211990f, 0.30590358f, 0.29537639f, 0.17414431f, 0.30129325f, -0.24266775f, -0.10653601f, -0.33387491f, 
    -0.34957629f, 0.11605179f, 0.63344246f, 0.41907525f, 0.58535957f, 0.89621288f, 0.60320324f, -0.42190981f, 
    0.42050457f, -0.17442764f, 0.59564853f, 0.26985374f, -0.26237544f, -0.30901277f, 0.17888902f, 0.06241192f, 
    -0.08458529f, -0.02794940f, 0.01900569f, -0.16364244f, -0.14248355f, -0.14791484f, 0.05737172f, -0.29659462f, 
    -0.18410832f, -0.07616416f, -0.07840481f, -0.80704081f, -0.10907050f, -0.68037015f, -0.66721809f, 0.24217036f, 
    -0.22827148f, 0.35707924f, 0.17343569f, 0.28657675f, 0.18699466f, -0.15910934f, -0.09525881f, 0.24156260f, 
    -0.47548404f, -0.38429981f, 0.07891902f, -0.03917606f, 0.37244979f, 0.21084148f, -0.30357024f, -0.18831402f, 
    -0.38755643f, -0.40529388f, -0.35870957f, 0.00665290f, -1.18274939f, 0.35115996f, -0.17693676f, 0.39401191f, 
    0.15548663f, 0.57362860f, 1.31054616f, 0.11608908f, 0.36654699f, 0.39636141f, 0.09536308f, -0.22935005f, 
    0.05929323f, -0.30961975f, -0.00413761f, 0.03935531f, 0.02384631f, -0.11127774f, -0.01476393f, -0.12894823f, 
    -0.04223468f, -0.02363752f, -0.08402956f, -0.13100626f, -0.10660376f, -0.66691649f, 0.10012975f, 1.05880141f, 
    -1.07774067f, 0.36845830f, 0.12494516f, 0.20107876f, 0.86632884f, 0.17779329f, 0.11374312f, -0.10716710f, 
    -0.17257491f, -0.06178129f, 0.08886815f, -0.06144052f, 0.14012554f, -0.27220735f, 0.03085770f, -0.24148832f, 
    -0.02496353f, -0.08070461f, 0.19492416f, 0.02794145f, -0.06467392f, 0.21003611f, 0.15822850f, -0.04440724f, 
    0.35085016f, -0.66576487f, -0.59939629f, 0.14288230f, -0.82962286f, -0.16889586f, 0.18131459f, -0.10832677f, 
    -0.35621965f, 0.01356956f, -0.44948143f, -0.21762228f, -0.31018516f, 0.07780359f, 0.50140268f, -0.07799274f, 
    -0.33121017f, -0.58113211f, 0.21338840f, 0.18887430f, -0.22316049f, -0.02177846f, 0.15786579f, 1.11439049f, 
    0.20252788f, -0.16188301f, 0.01188986f, -0.13158987f, 0.31028682f, -0.26175252f, 0.40448645f, -0.18024907f, 
    0.10319900f, -0.45184526f, 0.03396971f, 0.12584952f, -0.35846776f, -0.04934660f, -0.52411836f, 0.03051917f, 
    0.06783068f, 0.29142118f, -0.20264143f, 0.57114542f, 0.08697747f, 0.21157333f, -0.11385383f, 0.04852942f, 
    0.35138071f, 0.08670323f, -0.58547318f, -0.71252322f, 0.01062065f, -0.20330076f, -0.93234611f, -0.55458128f, 
    -0.48137382f, -0.21273264f, 0.00951480f, -0.31692049f, 0.22532792f, 0.09097638f, -0.37815285f, -0.03230694f, 
    0.33014622f, -0.38795650f, 0.16864248f, 0.34780237f, 0.04675211f, 0.03390710f, 0.31794873f, -0.08718222f, 
    -0.18051811f, 0.20970367f, 0.94442147f, 0.57445437f, -0.25878227f, -0.09627182f, -0.71635830f, -0.19648576f, 
    -0.49774334f, -0.57525021f, 0.02588130f, -0.07220994f, 0.20811687f, 0.02681090f, 0.06579214f, 0.48682141f, 
    -0.10891366f, -0.29767382f, 0.03277861f, -0.20524399f, 0.17282310f, 0.42806554f, 0.28848007f, -0.08294754f, 
    0.05808632f, 0.27352625f, 0.48657954f, 0.56277561f, 0.78054959f, 0.96059221f, 0.13909797f, 0.11905605f, 
    -0.02163817f, -0.17419614f, 0.08088967f, 0.26178551f, 0.36243781f, 0.31810677f, 0.03221732f, -0.35898942f, 
    0.15218462f, -0.01688039f, -0.02337095f, 0.17462610f, -0.26163414f, -0.06732656f, -0.13495424f, 0.34237808f, 
    0.20344248f, -0.14741339f, 0.02473172f, -0.49156696f, -0.85331917f, -0.71218926f, -0.61575484f, -0.45905516f, 
    -0.40350249f, 0.91445929f, 0.72280055f, -0.13509576f, 0.27270314f, -0.31449315f, -0.02489337f, -0.12261713f, 
    -0.14328830f, -0.00738200f, -0.10851891f, 0.06164858f, -0.28911120f, 0.04713398f, -0.05640732f, 0.09814316f, 
    0.05372079f, 0.07120624f, 0.08135389f, 0.17663231f, -0.68940151f, -0.93392217f, -0.07775339f, 0.64303029f, 
    -0.29998672f, 0.12543461f, -0.26063210f, 0.69123054f, 0.22579981f, -0.59179229f, -0.20127696f, -0.35720810f, 
    -0.21574263f, 0.08054284f, -0.03409770f, 0.04864118f, 0.16521464f, -0.26075652f, -0.25745130f, 0.00658904f, 
    -0.02088526f, 0.11113289f, 0.42459965f, 0.09307195f, -0.14132905f, 0.60962635f, 0.33762118f, 0.61430687f, 
    0.73911351f, 0.15852192f, 0.18555914f, -0.80215901f, -0.50166154f, -0.12293340f, -0.38297749f, 0.37032190f, 
    0.29423225f, 0.10828675f, 0.46137667f, -0.19829297f, 0.25706714f, 0.29272062f, 0.30489534f, 0.08875418f, 
    0.30204788f, 0.07737540f, -0.10285911f, 0.15421854f, 0.31935915f, 0.23404385f, 1.29196429f, 0.75520152f, 
    -0.49245343f, -0.09686478f, -0.51619166f, -0.02505926f, 0.16423348f, -0.05069106f, 0.30316171f, 0.18201639f, 
    0.27215803f, 0.25844291f, -0.12929627f, 0.21007358f, 0.09732083f, 0.01351817f, -0.22809321f, -0.03631919f, 
    -0.11171512f, 0.09142819f, -0.19466470f, 0.30870083f, -0.10910159f, 0.02219640f, -0.04629853f, -0.22158165f, 
    0.78983331f, 0.19995275f, 0.29522967f, -0.25720769f, -1.07400930f, -0.42625356f, -0.15273647f, -0.36167020f, 
    0.00141768f, 0.06595634f, -0.00590541f, -0.44721127f, 0.53257507f, -0.44499063f, 0.12669967f, -0.15425295f, 
    0.10104403f, -0.02241666f, -0.14524303f, -0.49857947f, -0.09768807f, 0.05493641f, 0.01601447f, 0.11462702f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30038330f, 0.10555612f, 0.26058424f, 0.24768610f, 0.05520258f, 0.11567880f, 0.18521285f, 0.11339179f, 
    0.27004123f, 0.30036625f, 0.34225774f, -0.01771893f, 0.16474168f, 0.17057826f, 0.09476085f, 0.26889461f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.29043034f, -0.25533536f, -0.09909981f, 0.05897649f, 0.11213756f, -0.01114920f, -0.13686784f, 0.08164688f, 
    0.03789493f, -0.01125932f, 0.05408836f, -0.07752674f, -0.02522582f, 0.04335237f, 0.19275184f, -0.09272686f, 
    -0.04432936f, 0.05138363f, 0.17208412f, 0.07778952f, 0.06139421f, 0.08241474f, -0.03216831f, 0.02276963f, 
    -0.06514461f, -0.12263134f, 0.25409099f, -0.06234067f, -0.00387039f, 0.15635286f, 0.09468397f, -0.08307211f, 
    0.06436168f, 0.01088901f, 0.01804350f, 0.13670996f, 0.14769730f, -0.40205050f, 0.09270368f, 0.15261313f, 
    0.13215104f, 0.11938734f, 0.07355054f, 0.13001421f, -0.06641658f, 0.12128687f, 0.00851015f, -0.06480980f, 
    0.33630690f, -0.02847571f, 0.07462434f, -0.09542692f, 0.12062518f, -0.03245675f, 0.08032238f, -0.11440225f, 
    0.06325450f, -0.08628720f, -0.08274732f, -0.07101765f, 0.36554006f, -0.17627600f, 0.02764835f, -0.10162352f, 
    0.06093748f, 0.00960077f, -0.05368529f, 0.01380599f, 0.01132944f, 0.08414453f, -0.01126901f, 0.16147205f, 
    -0.07926199f, -0.07768850f, 0.30079734f, 0.10562082f, 0.28784332f, 0.01534422f, 0.02344326f, -0.15147541f, 
    0.07725565f, -0.03170075f, -0.01966638f, 0.09600841f, -0.02728297f, -0.09973537f, 0.23923829f, 0.16614851f, 
    0.06125068f, -0.03573361f, 0.02587585f, 0.02853454f, 0.00747711f, 0.15473349f, 0.07307307f, 0.06960648f, 
    -0.31784186f, -0.26602173f, 0.29446447f, 0.11697854f, 0.03970405f, 0.11022248f, 0.20184927f, -0.13532522f, 
    -0.04245816f, -0.06563534f, 0.02780190f, 0.13954571f, -0.29352340f, 0.01096752f, 0.10873383f, -0.15443602f, 
    0.04116365f, 0.18008800f, 0.06411807f, -0.07101734f, -0.30303141f, 0.07288329f, -0.00540063f, 0.01044490f, 
    -0.31105548f, 0.21923830f, 0.06766768f, -0.07471769f, -0.02696556f, 0.23980510f, 0.03532301f, 0.06779854f, 
    0.04862801f, -0.00762263f, 0.09130903f, -0.12482441f, -0.08664142f, -0.17525983f, -0.35456201f, 0.12096701f, 
    -0.14029366f, -0.11132902f, -0.04453697f, 0.25585452f, 0.04383492f, 0.08164056f, 0.03921935f, 0.05003342f, 
    0.12853691f, 0.07299151f, -0.39459330f, 0.40042165f, 0.04896608f, 0.28950751f, 0.05092884f, -0.05501030f, 
    0.05128488f, 0.05764878f, -0.02889065f, -0.03138863f, 0.05327696f, 0.28875741f, -0.04381340f, -0.23521768f, 
    -0.04226408f, 0.08812227f, 0.13517815f, 0.06992856f, -0.05703600f, -0.05483672f, 0.03365640f, 0.00792254f, 
    -0.09836013f, 0.04432598f, 0.35855168f, -0.13500857f, -0.10237574f, -0.13647772f, 0.32176143f, 0.17343067f, 
    -0.11200161f, -0.06940816f, 0.08353001f, 0.07020019f, -0.14199695f, 0.02884706f, 0.25313297f, 0.02907754f, 
    -0.22339231f, 0.01450985f, 0.06124150f, 0.06781674f, -0.13149823f, -0.01087225f, 0.07750248f, 0.06429277f, 
    0.34272456f, -0.30507386f, 0.47254437f, -0.29317397f, -0.23749936f, 0.04660046f, 0.16125698f, 0.00603503f, 
    -0.03530058f, -0.11523192f, 0.11910921f, -0.09290329f, 0.20932223f, -0.03688171f, -0.17957360f, 0.09485690f, 
    0.12411007f, -0.06070353f, 0.01655329f, -0.09497686f, -0.06595007f, -0.22792059f, -0.14825444f, -0.12631692f, 
    0.23487999f, 0.13345586f, 0.05065495f, 0.03613745f, 0.09643006f, 0.03134761f, -0.00549505f, -0.09744441f, 
    0.01979827f, 0.08009376f, 0.01577338f, -0.08780339f, -0.28754559f, -0.12352144f, 0.04859807f, 0.04846837f, 
    0.02874239f, 0.02481466f, 0.01547824f, 0.05546137f, 0.16477530f, -0.05704718f, 0.02769373f, 0.08261879f, 
    0.32000554f, -0.32898358f, -0.05363371f, 0.19122836f, -0.12281673f, -0.09075046f, -0.18848149f, 0.07208896f, 
    0.08724549f, -0.05995545f, 0.00605100f, 0.06528771f, 0.21705727f, -0.10051585f, -0.03387181f, 0.24693941f, 
    0.18075314f, -0.02508065f, 0.15080920f, -0.01757951f, -0.05392208f, 0.12905714f, 0.06208302f, 0.00907187f, 
    -0.12536605f, 0.02117995f, -0.16789505f, -0.15519826f, -0.20677471f, -0.04340920f, 0.03086275f, 0.03294293f, 
    0.14204597f, 0.04202629f, 0.17028229f, 0.09444243f, -0.00229396f, 0.22992752f, -0.10884442f, -0.03232399f, 
    0.04222279f, 0.01285508f, 0.16458853f, -0.00224870f, -0.06126827f, -0.02495747f, 0.05006370f, 0.05246279f, 
    -0.36989525f, 0.23482914f, -0.16243087f, -0.37387329f, 0.08301041f, 0.12599626f, -0.04803846f, -0.02738011f, 
    0.01440631f, -0.05615566f, 0.08037018f, -0.13962832f, 0.05087199f, 0.11096951f, -0.23112148f, -0.28178757f, 
    0.27210033f, 0.04563035f, 0.06367987f, -0.01042249f, 0.19676617f, 0.03429378f, 0.07215785f, -0.05003225f, 
    0.15832262f, 0.05025113f, 0.14416879f, 0.20332825f, -0.02373585f, 0.07918471f, 0.02126129f, -0.09010223f, 
    -0.09492075f, 0.05426127f, 0.06872903f, 0.00618868f, 0.37575978f, -0.04669898f, 0.13016064f, 0.21500431f, 
    -0.01163277f, -0.06983297f, 0.12503578f, -0.06992230f, -0.02919188f, -0.03525305f, 0.05113516f, 0.11848197f, 
    0.17404440f, -0.09043862f, 0.24197420f, -0.14852275f, -0.12503433f, -0.32616356f, -0.06042284f, -0.14000852f, 
    0.12922114f, 0.10201116f, 0.06848853f, 0.08252516f, -0.02886065f, 0.14916727f, 0.04403593f, 0.06025979f, 
    0.14692035f, 0.18982863f, -0.09789397f, -0.02726519f, -0.03756629f, 0.00036166f, -0.03945818f, -0.12977743f, 
    0.22092317f, 0.30819273f, -0.03533349f, 0.27141029f, 0.27421930f, 0.03761382f, 0.04836409f, 0.11411510f, 
    0.17662446f, 0.04484889f, 0.03373773f, -0.01525493f, -0.25962961f, 0.16279165f, -0.13137607f, -0.21129245f, 
    0.20484467f, 0.14611800f, 0.02726742f, -0.13595720f, -0.06261282f, 0.14346871f, 0.04855906f, 0.04308081f, 
    -0.08959246f, 0.09353944f, -0.11316004f, 0.06846642f, 0.01718479f, 0.02998821f, 0.00679257f, 0.08167029f, 
    -0.11506684f, 0.09387632f, -0.01788536f, -0.12435932f, -0.02504112f, 0.09069382f, 0.24095923f, 0.03579151f, 
    0.03363050f, 0.07778810f, 0.25049758f, 0.07038873f, 0.00034650f, 0.07157580f, -0.08255533f, 0.06986275f, 
    0.06953513f, 0.18767111f, 0.12467049f, 0.05897795f, -0.05745636f, 0.07497351f, 0.16739044f, -0.02598460f, 
    0.02438689f, 0.01288018f, 0.00446914f, 0.09947843f, -0.05843012f, 0.15953727f, 0.02500010f, 0.22846286f, 
    0.06473594f, -0.00674475f, 0.07730459f, -0.02025979f, 0.02030864f, 0.13327938f, 0.06320173f, 0.11744542f, 
    -0.63408661f, 0.35673195f, -0.06094997f, -0.11164162f, 0.06609903f, 0.01180173f, 0.12060562f, 0.00144758f, 
    0.04084506f, 0.11562911f, 0.09321053f, -0.04554500f, 0.30861318f, 0.08265083f, -0.25057048f, -0.02416886f, 
    -0.07874152f, -0.06135911f, 0.04153101f, -0.06221693f, -0.08251880f, -0.18121588f, -0.04925939f, 0.03424471f, 
    0.22117014f, -0.13236749f, 0.04668694f, 0.08731283f, 0.08216375f, 0.06297854f, -0.00388582f, 0.17209166f, 
    -0.08503380f, 0.05524371f, -0.05309578f, 0.18083332f, 0.20953020f, -0.07488796f, 0.29832524f, 0.11349203f, 
    -0.05224917f, 0.02547483f, -0.06940425f, -0.07490620f, -0.13068226f, -0.01505675f, 0.01490257f, -0.03019514f, 
    0.12805384f, 0.13031438f, -0.06881871f, 0.28931984f, 0.03679224f, -0.04153054f, 0.09318424f, 0.03782437f, 
    -0.02240691f, 0.01746601f, -0.00934343f, 0.08036730f, -0.18291567f, -0.25117409f, 0.09674402f, 0.22553425f, 
    -0.05474186f, -0.06110609f, -0.02854858f, -0.07280789f, -0.08611650f, -0.11759605f, -0.01840995f, -0.07261437f, 
    -0.10761818f, 0.01756889f, 0.11002516f, -0.03273235f, -0.03489155f, 0.03921670f, 0.13638413f, 0.07861932f, 
    0.13198204f, -0.05647486f, 0.03631794f, -0.03131456f, -0.16013150f, -0.10765047f, 0.02177310f, 0.26800877f, 
    0.07006729f, 0.02191898f, -0.03325067f, 0.06964222f, -0.05741561f, -0.05106982f, 0.00530447f, 0.02401409f, 
    0.01396041f, -0.02439314f, -0.22663538f, -0.06970073f, -0.02504903f, 0.21512888f, 0.00903903f, -0.01431992f, 
    -0.00520595f, -0.05718108f, -0.03946515f, 0.05254929f, -0.00867353f, -0.05794207f, 0.00073960f, 0.10369791f, 
    -0.08490656f, 0.02360634f, 0.06735597f, -0.08175451f, -0.07097998f, -0.13452686f, 0.00544975f, -0.11930319f, 
    0.28308508f, -0.15524866f, -0.11692858f, -0.05128584f, -0.27116734f, -0.01645100f, 0.07273959f, -0.03237822f, 
    -0.17891508f, -0.01096146f, 0.00324182f, 0.02998775f, 0.01673459f, -0.15539771f, 0.15792918f, 0.17149678f, 
    -0.01817866f, 0.11444072f, 0.05585377f, 0.04136864f, -0.03266877f, -0.12810685f, -0.04155904f, 0.13830121f, 
    -0.13546985f, -0.18539880f, -0.35700658f, 0.10042261f, 0.27509075f, 0.00478209f, 0.05520177f, 0.01583649f, 
    0.03295388f, 0.02073888f, -0.00185833f, -0.01233037f, 0.09832705f, 0.00879511f, -0.05267934f, -0.04151020f, 
    0.00263712f, -0.07832378f, -0.08223472f, -0.16334915f, 0.08381747f, 0.05131979f, 0.01918246f, -0.04132394f, 
    0.15473975f, -0.07603358f, 0.11522274f, -0.17697874f, 0.00653998f, 0.07950837f, -0.01032263f, -0.05426808f, 
    -0.00837351f, -0.14151368f, 0.05542706f, 0.02181947f, 0.31771418f, -0.31110483f, -0.03470379f, 0.06072877f, 
    0.19012666f, 0.09705140f, -0.15371980f, -0.02227667f, -0.08393344f, -0.05647722f, 0.04110076f, -0.17895301f, 
    0.00988394f, -0.11092601f, -0.01905822f, -0.14387788f, -0.00820934f, 0.13647735f, 0.00393897f, -0.14309692f, 
    -0.03305598f, 0.08913150f, -0.09677679f, 0.07035362f, -0.45293051f, 0.13371378f, 0.01098096f, -0.17507288f, 
    -0.02102005f, 0.18913147f, 0.08552673f, 0.07164649f, 0.08188033f, 0.08898168f, 0.03642167f, -0.00177942f, 
    0.01142755f, 0.23659831f, -0.08906460f, -0.09737062f, -0.00871171f, 0.02792920f, 0.01623490f, 0.02984875f, 
    0.22724460f, -0.20623995f, 0.04461182f, -0.04854002f, 0.07404009f, 0.21682881f, 0.01450518f, -0.05649916f, 
    0.04643396f, -0.04364052f, -0.06000701f, 0.14396571f, -0.01824754f, -0.17770594f, -0.01778663f, -0.16951653f, 
    -0.02109808f, -0.28775972f, 0.01079677f, -0.01132181f, 0.14258048f, 0.03490368f, 0.10679697f, 0.06226012f, 
    -0.06875893f, 0.16482809f, 0.00311059f, 0.11128607f, 0.29780242f, 0.13929677f, -0.11200971f, -0.05267715f, 
    -0.13224499f, 0.08562904f, 0.12016558f, 0.12275764f, -0.14883876f, 0.00865609f, 0.16596620f, 0.08689712f, 
    0.25776705f, 0.17829071f, 0.25649464f, -0.08195093f, 0.01382225f, 0.00665595f, 0.07519317f, -0.00068760f, 
    -0.01173459f, -0.16242255f, 0.00032030f, 0.07071467f, 0.04366587f, -0.10562599f, -0.21000624f, 0.00441084f, 
    0.05848682f, 0.00055459f, 0.00769169f, -0.00063076f, 0.05626081f, 0.04161660f, -0.06069792f, -0.19047333f, 
    -0.05547104f, 0.30454156f, -0.05819681f, 0.14276628f, 0.10330596f, -0.05940093f, 0.03715618f, 0.09313312f, 
    0.07856624f, 0.04553463f, -0.06433368f, 0.08187789f, 0.11595192f, 0.15279046f, -0.02334050f, -0.19076739f, 
    0.11313701f, 0.01044375f, -0.00915995f, 0.12407928f, -0.03092848f, 0.08092692f, 0.13323943f, 0.13476034f, 
    0.38916293f, 0.13558741f, 0.45114177f, -0.16102731f, 0.05592326f, -0.16447119f, 0.13020158f, -0.09310626f, 
    -0.11140411f, -0.07449763f, 0.01646034f, -0.05601290f, 0.15365323f, -0.10357806f, -0.21983133f, 0.00677540f, 
    -0.13906431f, -0.05164575f, -0.07887442f, 0.02201487f, 0.07259339f, -0.13435206f, 0.15476806f, 0.14187407f, 
    -0.03236915f, -0.05837864f, -0.06139993f, 0.06455115f, 0.05519423f, -0.03703865f, 0.00503263f, 0.01095034f, 
    0.05510330f, -0.07289667f, 0.05251656f, 0.01028789f, 0.03727776f, -0.01609682f, -0.02197887f, 0.02151985f, 
    -0.05555006f, -0.05347744f, 0.04285036f, 0.00932631f, -0.06363282f, -0.00626356f, -0.04354678f, -0.06583509f, 
    -0.05473310f, 0.04421382f, -0.05008372f, 0.05725307f, -0.02326598f, 0.00251864f, -0.00392042f, -0.03765966f, 
    -0.02956632f, 0.05629131f, -0.06139031f, 0.01957561f, -0.00581230f, -0.07434443f, -0.05565530f, 0.03320317f, 
    -0.01293002f, -0.05485183f, 0.05862986f, 0.01506828f, -0.05394572f, -0.07575953f, -0.05437202f, 0.00566850f, 
    -0.07643694f, -0.03261608f, -0.04519840f, -0.00468579f, -0.04254850f, -0.02370515f, -0.04129129f, -0.01446994f, 
    -0.01327515f, -0.04812115f, -0.04294375f, -0.03654499f, 0.00977818f, 0.00204825f, 0.04651135f, 0.04812182f, 
    0.02351848f, -0.07648598f, -0.07020624f, -0.05904982f, 0.06447835f, -0.02960520f, 0.03133341f, -0.01123206f, 
    -0.06136364f, -0.04433191f, 0.06358962f, 0.05796298f, -0.00394534f, -0.06263219f, 0.04180920f, -0.07157536f, 
    -0.01462939f, -0.04756739f, -0.00297247f, 0.06156509f, 0.00020922f, 0.01004432f, 0.00802288f, 0.04904578f, 
    -0.04478066f, 0.02245719f, -0.01015652f, 0.03244831f, -0.02213244f, 0.00306872f, -0.01946027f, 0.04967008f, 
    -0.01026377f, -0.00283058f, -0.04819568f, 0.04284625f, -0.05637784f, -0.04236313f, -0.05514823f, -0.07823478f, 
    0.01666004f, 0.00118811f, 0.04790829f, -0.06270216f, -0.06458637f, 0.01015380f, -0.02385299f, -0.01876725f, 
    -0.00861140f, 0.01997224f, -0.00197727f, 0.00049400f, -0.01529402f, 0.05844233f, -0.06637542f, 0.05298347f, 
    0.04335935f, -0.01548552f, -0.07186108f, 0.06219424f, -0.04488406f, 0.04269928f, -0.06492376f, -0.00404269f, 
    -0.04369140f, 0.04990991f, 0.04751516f, -0.05668790f, -0.02677388f, 0.05571826f, -0.04215273f, 0.02750884f, 
    -0.01526200f, -0.06629162f, 0.04533461f, -0.03350305f, 0.02525081f, -0.07187669f, 0.00361461f, -0.02959443f, 
    -0.01183718f, 0.01367159f, -0.07341023f, -0.04904437f, -0.05504413f, -0.02914882f, 0.01802411f, -0.07446374f, 
    0.01073323f, -0.04097542f, 0.06139420f, 0.03066597f, -0.03751811f, -0.02227644f, -0.06855638f, -0.05636607f, 
    -0.07820068f, -0.02541352f, -0.07710715f, -0.04963126f, -0.03738185f, 0.04263151f, 0.06163473f, 0.02913797f, 
    -0.04652712f, 0.02164289f, 0.04607333f, -0.06290268f, 0.00927086f, 0.05892542f, -0.03544225f, -0.01585902f, 
    -0.01764573f, 0.02349820f, -0.05199336f, -0.06702276f, -0.03035945f, -0.02557877f, 0.03563250f, -0.04412251f, 
    -0.02894115f, -0.00185358f, 0.05179783f, -0.03472222f, 0.05970326f, 0.02391879f, 0.04478247f, 0.02490720f, 
    0.01972359f, 0.05890105f, 0.12570596f, 0.21929108f, -0.07823790f, -0.06613905f, -0.05262367f, 0.10999873f, 
    0.11968026f, -0.09347145f, 0.09599333f, -0.03100529f, -0.04598949f, -0.01858842f, 0.08487315f, 0.19021754f, 
    0.13300271f, -0.00821589f, -0.03914012f, -0.17636533f, -0.04777510f, -0.11217593f, 0.02873404f, 0.05063666f, 
    0.07346902f, 0.21544790f, 0.05089302f, -0.13081674f, 0.16514090f, 0.10933679f, 0.03249491f, -0.12714683f, 
    0.04812341f, 0.02366302f, -0.05492458f, -0.11494884f, -0.18056078f, 0.01632606f, -0.19540545f, -0.05952613f, 
    0.11956640f, 0.10387538f, -0.07459761f, -0.16737856f, -0.16050416f, -0.02928226f, 0.05708865f, -0.04410664f, 
    -0.30786920f, 0.17073992f, 0.14144284f, -0.31325665f, -0.02296919f, -0.10362089f, 0.05584224f, 0.08489168f, 
    0.03357751f, -0.09167206f, -0.01395296f, -0.00145364f, 0.23256418f, 0.35181466f, -0.06370392f, 0.24197051f, 
    -0.09304755f, 0.03220112f, -0.06899843f, -0.04926008f, 0.00551876f, -0.15099034f, -0.07681788f, -0.00869413f, 
    -0.36700705f, -0.13006163f, -0.09636955f, 0.15494421f, 0.18468361f, 0.00180374f, -0.08359803f, 0.06544629f, 
    0.08764945f, -0.05300867f, -0.06361264f, 0.00293402f, 0.08270130f, -0.10801650f, 0.17960399f, -0.09888963f, 
    -0.12676403f, -0.02756989f, 0.06311130f, 0.12765689f, 0.14953110f, -0.06784210f, 0.17221747f, -0.24322587f, 
    -0.00472184f, 0.10990045f, -0.15099253f, 0.12591043f, 0.24711584f, -0.22016315f, 0.01119896f, -0.07958721f, 
    0.06157661f, 0.11077525f, -0.00262271f, -0.02799086f, 0.05223110f, 0.14992337f, -0.08771455f, 0.25222957f, 
    -0.13266239f, -0.06752899f, 0.03821503f, 0.10870319f, -0.05803289f, 0.15019536f, 0.06286812f, -0.12669866f, 
    0.01801244f, -0.00336209f, 0.17705503f, 0.13356471f, 0.15156777f, 0.17763157f, 0.09716298f, 0.08598567f, 
    0.08355872f, -0.05045289f, 0.05136104f, 0.14579332f, 0.52442259f, 0.09641463f, -0.02764400f, 0.30442792f, 
    0.06901366f, 0.13245484f, 0.08929741f, -0.07446586f, -0.06141825f, 0.05610361f, -0.12017833f, -0.06978641f, 
    -0.33342370f, -0.16587982f, -0.03813479f, -0.27961621f, -0.11410756f, 0.06553859f, 0.13686544f, -0.05575879f, 
    0.15760911f, -0.01276205f, -0.14718077f, -0.05673311f, -0.04040291f, -0.04016316f, -0.08858916f, 0.29062596f, 
    -0.04961524f, 0.21569185f, 0.08267149f, -0.09661008f, -0.03507936f, 0.02656369f, 0.11207180f, 0.23963742f, 
    0.26556322f, 0.01175910f, -0.16770007f, -0.11674593f, 0.04634627f, -0.17907482f, 0.08861846f, -0.13240996f, 
    -0.06880403f, -0.00504884f, 0.09644266f, -0.08563644f, 0.14260167f, 0.19350637f, -0.33141783f, 0.11940952f, 
    0.00420210f, 0.02577461f, 0.04817256f, -0.05424611f, 0.01594912f, -0.07121120f, -0.05451841f, 0.09594623f, 
    -0.49418050f, -0.15929683f, 0.03611663f, -0.18382934f, 0.17595197f, -0.01049646f, 0.12294624f, 0.07068728f, 
    0.17457619f, 0.09189992f, 0.06363462f, -0.08058654f, 0.28073788f, 0.12032220f, -0.03588653f, 0.05428808f, 
    0.17557360f, -0.06383353f, -0.11741451f, -0.08296452f, 0.11197075f, -0.07863274f, 0.07086720f, -0.05543756f, 
    0.33495167f, 0.31364205f, 0.52807820f, 0.08664226f, 0.12013215f, -0.05099839f, -0.12987690f, -0.14200501f, 
    -0.00467908f, -0.02243451f, 0.17032662f, -0.03047748f, -0.22084419f, -0.48831546f, -0.10241410f, -0.00932450f, 
    0.25042346f, 0.09866886f, -0.08335031f, 0.00560763f, -0.14563209f, 0.09237646f, -0.00984285f, -0.00135311f, 
    0.09015305f, -0.01788931f, -0.08605225f, 0.16005006f, -0.03811238f, -0.15797503f, -0.12872140f, 0.05507205f, 
    0.13943678f, -0.01222337f, -0.08012811f, 0.09363665f, 0.65338284f, 0.05236058f, 0.06931497f, 0.16229829f, 
    0.04282318f, -0.04516005f, -0.13041297f, 0.02962073f, -0.17385823f, -0.00080352f, -0.00522289f, 0.02135885f, 
    -0.18357682f, 0.05650448f, -0.11637712f, 0.29478019f, 0.23183058f, 0.00022685f, -0.10945981f, 0.03938852f, 
    0.24884540f, -0.15145621f, 0.00585659f, 0.07331838f, 0.03589999f, 0.16709530f, 0.11889113f, 0.18586111f, 
    -0.07684337f, 0.11537212f, 0.08969717f, 0.21467105f, 0.12331066f, 0.06080768f, 0.00120198f, -0.21471550f, 
    -0.38996527f, -0.09141944f, 0.06434944f, -0.05475007f, 0.04486492f, -0.04959891f, 0.12064081f, -0.07209515f, 
    -0.09288859f, -0.14094602f, -0.06482999f, -0.04814546f, -0.11396010f, 0.10677505f, 0.05872829f, 0.05785399f, 
    -0.01446601f, -0.04720086f, -0.04041213f, 0.08590651f, -0.10159625f, 0.10098493f, 0.14946902f, -0.08316472f, 
    0.15174730f, 0.37395182f, 0.32205611f, 0.16546737f, 0.05171287f, 0.01466337f, -0.10529049f, -0.08230084f, 
    -0.05916409f, -0.02409455f, 0.06691216f, 0.06476158f, -0.31124681f, -0.36178827f, -0.36169803f, -0.19089286f, 
    0.27252206f, 0.12868901f, 0.02460276f, 0.14265341f, -0.11862644f, -0.15326300f, -0.05320000f, 0.11881544f, 
    -0.26533687f, -0.01618342f, 0.02215258f, -0.27312216f, 0.16956122f, 0.06052125f, 0.11955952f, -0.05016845f, 
    0.00616361f, -0.00812460f, -0.21448927f, 0.05191346f, 0.04929976f, 0.35524791f, 0.28052634f, 0.04022864f, 
    -0.03737821f, 0.18874435f, -0.03631963f, -0.17961760f, -0.00377216f, -0.09804617f, 0.20071922f, 0.16246337f, 
    -0.25083664f, 0.47174218f, -0.10038864f, 0.12622412f, 0.07718778f, -0.12470499f, 0.10893751f, -0.14254841f, 
    0.08238354f, 0.05616321f, -0.00679490f, 0.02715561f, -0.08233571f, 0.07079396f, 0.09464797f, 0.13206677f, 
    -0.05205323f, -0.03010266f, -0.09396927f, -0.11152893f, -0.09843270f, -0.10439469f, 0.09699503f, 0.14436507f, 
    0.05267881f, -0.00808279f, -0.03641220f, -0.06784311f, -0.02808897f, -0.00064794f, 0.04868134f, -0.00371958f, 
    -0.05292909f, -0.00351000f, 0.04291711f, -0.04862778f, -0.03182460f, 0.05336637f, -0.07811728f, 0.04849434f, 
    0.01374383f, 0.04096990f, -0.04021856f, -0.07925291f, 0.01599811f, -0.02053416f, 0.02774598f, -0.02770617f, 
    -0.01699087f, 0.01712051f, -0.07944594f, 0.04865109f, 0.05407433f, -0.04903761f, -0.05868288f, -0.03946572f, 
    0.05045227f, -0.03270076f, -0.03265065f, -0.06407269f, -0.05955159f, 0.03458903f, 0.04543098f, -0.01006208f, 
    -0.00243148f, -0.07663044f, 0.03799039f, -0.05565360f, 0.04951077f, -0.03548338f, 0.04697272f, -0.02456586f, 
    -0.07419271f, -0.05545435f, -0.05690839f, -0.07426632f, 0.00877496f, -0.01023939f, 0.01688769f, -0.02721151f, 
    0.01029946f, -0.04613919f, 0.05442617f, 0.05764182f, -0.06402237f, -0.05356002f, -0.07873151f, 0.03004689f, 
    0.00065227f, 0.05759257f, -0.08218830f, -0.07895659f, -0.00329167f, -0.06849279f, -0.04108664f, 0.00592969f, 
    -0.06770369f, 0.03810887f, 0.05336947f, 0.00250933f, -0.01310291f, 0.00466978f, 0.05047037f, -0.03140676f, 
    -0.03471059f, -0.01768030f, -0.02118139f, 0.00269503f, -0.03294386f, 0.05072942f, -0.04212529f, -0.00005128f, 
    0.04908593f, 0.03813976f, 0.04012944f, 0.05230750f, 0.02383159f, -0.01051606f, -0.06160579f, -0.05564054f, 
    -0.01883301f, -0.05799553f, -0.03893390f, 0.03739522f, -0.05447762f, 0.02464134f, 0.03719763f, 0.01867362f, 
    -0.07917893f, 0.03203727f, -0.00064576f, -0.00994153f, -0.04668315f, 0.02667693f, -0.06763131f, 0.01064497f, 
    0.01768586f, -0.05693916f, -0.06399710f, -0.07518397f, 0.00961373f, 0.06033929f, 0.01478537f, 0.01775438f, 
    -0.04816748f, -0.06825183f, -0.03399134f, 0.04609135f, -0.04198836f, 0.05620727f, -0.01534177f, -0.04069403f, 
    0.02496327f, 0.04447613f, -0.00397243f, 0.03749450f, 0.02917700f, -0.03254933f, -0.06851704f, -0.02346583f, 
    0.02606026f, -0.05704490f, -0.01774228f, 0.04663807f, 0.01987378f, -0.04309347f, -0.03767119f, 0.05133802f, 
    0.02974923f, -0.02827623f, 0.04382284f, -0.03098433f, -0.05578493f, -0.03133211f, -0.00914040f, 0.01856072f, 
    -0.06725811f, 0.05162928f, -0.03336774f, 0.05704323f, -0.05188205f, -0.03588387f, 0.03808591f, -0.02542224f, 
    0.02261968f, -0.04032079f, 0.03082207f, -0.03062681f, -0.01067528f, -0.02644834f, -0.02134067f, -0.05389665f, 
    -0.05020496f, 0.00762983f, -0.00100172f, 0.05782553f, 0.04238566f, -0.02074993f, 0.05862867f, 0.00566233f, 
    -0.01880202f, -0.04963595f, -0.00381225f, 0.02315336f, -0.06462930f, 0.04690146f, 0.01942678f, -0.05212018f, 
    -0.04383481f, -0.06269275f, 0.05431231f, -0.06306428f, -0.05068688f, -0.04209223f, 0.01937344f, 0.03056493f, 
    -0.04903343f, 0.03140636f, -0.07536352f, 0.03735827f, 0.05856265f, 0.03226523f, 0.00617116f, -0.01841476f, 
    -0.07283061f, -0.07199568f, -0.01485877f, -0.02366658f, -0.06385901f, 0.03463562f, 0.02941672f, -0.03186843f, 
    0.03360120f, 0.04822362f, -0.01449564f, 0.01953262f, -0.04741437f, -0.00256774f, -0.04558032f, 0.00170801f, 
    0.06154787f, 0.04413357f, 0.06253803f, -0.02653822f, 0.01947277f, 0.04996630f, -0.00753074f, 0.02931958f, 
    -0.05770598f, -0.03579596f, -0.06301729f, -0.00184079f, 0.00412855f, 0.05743609f, -0.03250987f, -0.00542094f, 
    0.01108283f, 0.01960549f, 0.04502999f, -0.03273356f, 0.02456368f, 0.00968886f, -0.04393322f, 0.01727953f, 
    -0.03472834f, -0.02806689f, 0.02612805f, -0.01069872f, -0.00874699f, -0.06592898f, -0.03794029f, 0.02897665f, 
    -0.04679657f, 0.02764475f, -0.00125648f, 0.05485700f, 0.00801984f, -0.06633398f, 0.03451322f, 0.02964251f, 
    -0.07719653f, 0.03923666f, 0.05812299f, 0.00482388f, -0.02109626f, -0.04671499f, 0.05441796f, -0.00051839f, 
    -0.04432164f, 0.03746735f, 0.04601846f, 0.03728977f, -0.04078761f, 0.03127990f, -0.00055131f, -0.02287969f, 
    -0.03388042f, -0.02680955f, 0.02703117f, -0.04653751f, -0.07468817f, -0.04328205f, -0.07884701f, -0.00802502f, 
    0.03182232f, 0.00498589f, 0.04582501f, 0.03264337f, 0.05645988f, -0.03670510f, -0.01428509f, 0.02358474f, 
    -0.07634957f, -0.03320612f, 0.01420377f, -0.07357553f, -0.01821251f, -0.06769849f, 0.02692826f, 0.01918861f, 
    0.00397810f, -0.01555223f, 0.03265653f, 0.02730549f, -0.01935758f, -0.05657342f, -0.07581496f, -0.01673289f, 
    0.02792330f, -0.05933392f, 0.01042746f, 0.04256608f, 0.06333888f, -0.01139920f, -0.04690380f, 0.02417345f, 
    -0.02555299f, -0.05055104f, -0.00632331f, -0.03957096f, -0.04723183f, 0.01023207f, 0.03575403f, -0.00961308f, 
    0.04836157f, 0.05862736f, -0.06245652f, -0.07436642f, -0.01320479f, 0.02067860f, -0.06075734f, -0.01822611f, 
    0.02286156f, -0.03534130f, -0.06401476f, -0.06168770f, -0.03866277f, -0.04968206f, 0.05253553f, -0.00814688f, 
    -0.02125614f, 0.03047953f, -0.07387201f, -0.01642499f, -0.05487810f, 0.03250034f, -0.03281843f, -0.02477684f, 
    -0.05843551f, -0.05738729f, -0.07194931f, 0.02129554f, 0.02197468f, -0.03291216f, -0.03307460f, -0.00642789f, 
    -0.04592480f, 0.00204316f, -0.02556643f, 0.03305645f, -0.04032665f, -0.01790571f, -0.00658472f, -0.07572985f, 
    -0.00070360f, -0.03108384f, -0.00059656f, -0.03358594f, 0.06322092f, 0.05218882f, -0.04438802f, -0.00281421f, 
    0.03897852f, -0.07461516f, -0.02664316f, 0.01554232f, -0.01141344f, -0.06119833f, -0.06813238f, -0.04563659f, 
    -0.02055450f, 0.00406711f, -0.06128405f, 0.01942166f, 0.04077605f, -0.07255072f, -0.07138919f, -0.05957485f, 
    -0.09028882f, 0.30941150f, -0.06976905f, 0.27769604f, 0.03772224f, 0.07639405f, 0.10932086f, 0.17136717f, 
    -0.03236066f, 0.12727019f, -0.02831456f, 0.22248572f, -0.18251543f, 0.26398671f, -0.07214152f, -0.41276920f, 
    -0.06145924f, 0.10495415f, 0.08789641f, -0.13458148f, 0.10293787f, 0.12827392f, 0.21747710f, -0.00241235f, 
    0.41608536f, -0.00770994f, -0.09607106f, 0.47654527f, -0.18659717f, -0.04869840f, 0.02877002f, 0.13113493f, 
    0.11633141f, 0.01044412f, 0.00760783f, -0.13923423f, -0.01822520f, 0.31287768f, 0.20674399f, -0.39369315f, 
    0.07062174f, 0.06021978f, -0.01343728f, 0.06341449f, 0.01308304f, -0.16378099f, -0.04480092f, 0.12712200f, 
    0.02589370f, 0.35903996f, 0.18619892f, 0.14764152f, 0.08789545f, 0.11876557f, 0.02036463f, -0.01684956f, 
    0.01702789f, 0.08129012f, 0.12444112f, 0.00634965f, -0.05337888f, 0.31905845f, -0.07189558f, -0.04727865f, 
    0.07139176f, -0.06068671f, -0.14001437f, -0.06080531f, -0.08494575f, -0.09447090f, -0.11009369f, -0.05828144f, 
    -0.06524611f, 0.03639689f, 0.21490775f, 0.08279140f, -0.04682097f, 0.00773956f, 0.02935999f, 0.01150353f, 
    -0.02000979f, 0.02991378f, -0.03321033f, -0.04495717f, 0.38557908f, -0.21023449f, 0.22417514f, -0.07788209f, 
    -0.14078811f, -0.04572139f, -0.22051337f, -0.13982567f, 0.12950492f, -0.07849947f, -0.04230436f, -0.03021214f, 
    0.13770053f, -0.10857194f, 0.19006628f, -0.10928041f, -0.01474210f, -0.03321594f, 0.32534558f, 0.16118495f, 
    -0.06251983f, 0.02438283f, 0.03296893f, 0.04299287f, -0.39907691f, 0.15166540f, 0.15299603f, 0.09675600f, 
    -0.14674743f, -0.08463519f, 0.08049394f, 0.00043119f, 0.28810477f, 0.07675131f, 0.10975356f, 0.11695160f, 
    0.06244762f, 0.04407461f, 0.01474663f, 0.27245760f, -0.12962240f, -0.16611852f, 0.01437374f, 0.10145409f, 
    0.09168153f, 0.07770389f, -0.10200135f, 0.01779729f, -0.39901471f, -0.05319075f, 0.12985405f, -0.40435907f, 
    0.15333830f, 0.19336702f, 0.01544398f, 0.08126616f, 0.09967688f, -0.13194159f, -0.05560215f, 0.05170833f, 
    -0.56441456f, -0.05200681f, -0.18659869f, 0.06040164f, 0.12067784f, 0.15511081f, -0.02441210f, 0.10541891f, 
    0.08845890f, -0.01800204f, -0.13311842f, 0.04685081f, -0.03439671f, 0.01677352f, 0.14245385f, 0.27372432f, 
    -0.24791226f, -0.16800919f, 0.04284833f, 0.00454617f, 0.29617184f, 0.15396237f, 0.03091913f, 0.11901743f, 
    0.20310098f, -0.37217328f, -0.33971533f, -0.25504708f, -0.25075030f, -0.16290972f, -0.08918282f, -0.22408004f, 
    -0.01357657f, -0.03463962f, -0.15949717f, 0.09662894f, -0.13858938f, 0.08553778f, -0.27085936f, 0.07461113f, 
    0.06849236f, -0.06597655f, -0.03042952f, 0.03456160f, -0.02720143f, -0.07279193f, -0.07585661f, -0.10432855f, 
    -0.01538145f, 0.01156353f, -0.06860022f, 0.01920274f, -0.07000320f, -0.06527158f, 0.05463941f, -0.01046580f, 
    0.06285825f, -0.01330212f, 0.05068354f, -0.00131212f, -0.00841722f, 0.00029972f, -0.07628484f, -0.05007379f, 
    -0.00572753f, 0.02909278f, -0.00189632f, -0.00942813f, -0.01900957f, -0.02269682f, 0.02428148f, 0.03212610f, 
    0.05902871f, 0.02811490f, -0.04525114f, 0.04014440f, -0.06953838f, -0.05681144f, 0.06188990f, -0.00010269f, 
    0.05334800f, 0.06561247f, -0.02845887f, -0.06633591f, 0.06288554f, -0.00213013f, -0.03873371f, -0.02077581f, 
    0.00997746f, -0.05749442f, 0.06070672f, -0.02097471f, -0.02041741f, -0.03248179f, 0.00797642f, 0.02148934f, 
    -0.05733937f, 0.06580013f, 0.01372117f, -0.00006040f, -0.05937440f, -0.00242667f, -0.06829807f, 0.03469943f, 
    -0.06104686f, -0.04550747f, 0.03706120f, -0.02187736f, -0.05719908f, 0.00499314f, -0.04506050f, 0.03973630f, 
    -0.01857681f, 0.01420014f, -0.04511863f, -0.06384286f, 0.01001738f, 0.03744484f, -0.07680952f, 0.05063152f, 
    -0.07378037f, 0.05844390f, -0.05437380f, -0.05697714f, -0.07161484f, 0.01281791f, -0.04645093f, -0.00269067f, 
    -0.07482683f, -0.01829459f, -0.01136586f, -0.04455093f, 0.04484387f, -0.06095086f, -0.04608864f, -0.06080119f, 
    -0.03982591f, -0.05065506f, -0.07025209f, -0.00697304f, -0.05822458f, -0.05559434f, 0.01801095f, 0.02671969f, 
    -0.07153612f, 0.03069621f, 0.03856253f, 0.01874690f, -0.07786612f, 0.06010369f, 0.05539417f, -0.00431461f, 
    0.04630844f, -0.01507829f, 0.05755022f, 0.04193243f, -0.01128432f, 0.00592951f, 0.03543623f, 0.03008302f, 
    -0.00138194f, -0.07498214f, -0.01599843f, -0.00979809f, -0.02272214f, 0.04116879f, 0.03922389f, 0.06517083f, 
    0.02959018f, -0.01525193f, -0.06285430f, -0.07235701f, -0.04876876f, -0.07471547f, 0.00554824f, -0.01280537f, 
    -0.03361793f, -0.01761769f, 0.06042394f, 0.04160820f, -0.01883870f, -0.07681908f, -0.00822428f, -0.05473578f, 
    -0.03911878f, 0.00718446f, -0.06786545f, 0.06265540f, 0.05344716f, -0.06356909f, -0.04759119f, 0.04859378f, 
    0.00234271f, -0.04017552f, -0.01799774f, 0.03293419f, -0.00879172f, 0.04020097f, -0.06708287f, -0.02184190f, 
    -0.04747771f, 0.05482642f, -0.04484872f, 0.01907746f, 0.01541574f, -0.07213008f, -0.06853148f, 0.01657965f, 
    -0.04358670f, -0.05574905f, -0.00634957f, -0.06850225f, 0.04749756f, 0.04524257f, 0.05420554f, 0.06599037f, 
    0.01388381f, 0.06162507f, 0.02076973f, -0.04154399f, 0.04656678f, 0.04152223f, 0.02100829f, -0.00975732f, 
    -0.01923652f, -0.07705612f, -0.02140230f, 0.04054631f, -0.06731958f, -0.02860048f, 0.04203985f, -0.05508068f, 
    -0.02680675f, -0.03677760f, -0.04012435f, 0.00607643f, 0.04758676f, -0.01918260f, -0.02289778f, -0.07087170f, 
    0.09532582f, -0.04311146f, 0.03840500f, -0.03238966f, -0.05118649f, 0.04479922f, -0.00668635f, 0.10963788f, 
    -0.08526301f, 0.01851016f, -0.02752488f, -0.16721265f, 0.16563690f, 0.30540419f, 0.05838899f, 0.04237952f, 
    -0.11731399f, 0.04730071f, 0.08224848f, -0.04062372f, -0.05344531f, -0.13336512f, -0.01716646f, 0.05211474f, 
    0.61440498f, 0.35004613f, 0.02713989f, 0.18981169f, -0.08104003f, -0.16327716f, 0.03831477f, -0.09357014f, 
    0.02270107f, -0.05357310f, -0.04861978f, -0.15154766f, -0.04762667f, 0.20999977f, -0.18237299f, -0.21048890f, 
    0.06386910f, -0.02010150f, 0.08727599f, -0.00082444f, 0.09894641f, -0.00814225f, 0.05250623f, 0.13474412f, 
    -0.45522025f, 0.30933204f, 0.23368123f, -0.21309087f, -0.03091467f, 0.07086870f, 0.01659110f, -0.02499170f, 
    -0.01645309f, 0.12454600f, 0.15589157f, 0.03752019f, -0.11091043f, 0.14668542f, -0.16862844f, 0.15130758f, 
    -0.01459195f, -0.08218749f, 0.09309774f, -0.03390426f, -0.06227679f, -0.17454396f, -0.07836536f, -0.18687181f, 
    -0.04978321f, -0.05501913f, -0.19316700f, 0.09099130f, -0.11241715f, 0.01466325f, 0.03488827f, 0.20636384f, 
    0.12200270f, -0.00553159f, -0.03572056f, 0.03465609f, 0.41420570f, -0.09931467f, 0.07715140f, -0.04472245f, 
    -0.04523395f, -0.08332255f, -0.11852787f, 0.12892206f, 0.01736395f, 0.01719371f, -0.05001261f, -0.08821894f, 
    0.06790113f, 0.01022329f, -0.02419066f, 0.11464058f, 0.11510743f, -0.13635930f, 0.02499151f, 0.10487384f, 
    -0.03911656f, -0.03309021f, 0.12738508f, -0.10889897f, 0.24688150f, 0.06288540f, -0.19099191f, 0.25029841f, 
    -0.11309092f, 0.01289721f, 0.05160363f, 0.07825703f, 0.03114646f, -0.15265025f, 0.01811619f, -0.01140870f, 
    0.54194635f, 0.00217664f, 0.10214253f, 0.42412674f, -0.06759190f, 0.04246859f, 0.19200352f, 0.11649340f, 
    0.07106783f, -0.02453910f, 0.09799284f, -0.02580433f, -0.03293094f, -0.05450924f, 0.05744344f, -0.01116144f, 
    0.23165829f, 0.08853149f, 0.11476152f, 0.04794404f, 0.04743277f, -0.04997954f, 0.05071697f, 0.20496278f, 
    -0.24435528f, -0.04765302f, -0.04973495f, -0.08619915f, 0.00683315f, -0.00158827f, -0.05601317f, 0.00748006f, 
    0.03145637f, -0.14848232f, 0.06134119f, -0.04510047f, 0.14495106f, -0.11868490f, -0.08970783f, 0.41864297f, 
    -0.07761317f, -0.05901673f, -0.01865546f, -0.10552551f, -0.03838746f, -0.03970697f, 0.06195591f, 0.00433509f, 
    0.66582358f, 0.09394410f, -0.34035262f, -0.23613086f, -0.00948468f, -0.07204905f, -0.15050358f, 0.06522320f, 
    -0.10844908f, 0.03496219f, 0.04459143f, 0.10841860f, -0.04092086f, -0.01987851f, -0.30309597f, 0.31095967f, 
    -0.11889869f, 0.07617150f, -0.06012804f, 0.12887311f, -0.09548922f, 0.02943292f, 0.16457114f, 0.06688561f, 
    0.04040441f, 0.20377718f, -0.06644863f, -0.07468618f, 0.03604599f, -0.15289192f, -0.01070256f, 0.07201517f, 
    -0.05656355f, 0.05864498f, -0.19145480f, -0.30439296f, -0.16368039f, 0.12490604f, 0.15171650f, 0.08844828f, 
    -0.11464667f, 0.05124331f, 0.17805395f, 0.09141507f, 0.07815669f, -0.14146796f, -0.15056229f, -0.02162133f, 
    0.01009097f, 0.42829767f, -0.13310802f, -0.08749011f, -0.00985271f, -0.02013219f, 0.14465468f, 0.10654564f, 
    0.10262078f, 0.11299403f, 0.03990954f, 0.08256163f, -0.09225360f, 0.20535061f, -0.18636648f, -0.01571488f, 
    -0.17636368f, -0.18726347f, 0.24052334f, 0.11175068f, 0.11117965f, 0.17970115f, -0.02377458f, 0.27861759f, 
    -0.33718985f, -0.02719069f, -0.15261279f, -0.13030785f, 0.04610712f, 0.09489199f, 0.17504619f, 0.17365889f, 
    -0.11952102f, 0.12744945f, 0.18975174f, 0.02678408f, -0.21251945f, 0.04609914f, -0.17202869f, 0.17343476f, 
    -0.03441287f, 0.06032183f, 0.11233757f, 0.18011852f, -0.05036675f, -0.01863156f, 0.06963617f, 0.06555501f, 
    0.14144629f, -0.01361824f, -0.00241357f, -0.01687030f, -0.22821516f, -0.05559831f, 0.02830123f, -0.07116233f, 
    -0.09224983f, 0.22023091f, 0.15540232f, -0.09902725f, -0.00352285f, 0.05727151f, 0.17911424f, 0.01243775f, 
    0.04818469f, 0.07124024f, -0.01879966f, -0.19992886f, -0.00371087f, -0.05668517f, -0.01642784f, 0.11213657f, 
    0.35704783f, -0.01025883f, -0.16996224f, 0.21454492f, -0.20341891f, 0.00976704f, 0.01471962f, 0.08016005f, 
    0.06217700f, -0.03353043f, 0.08778922f, 0.09587140f, 0.05939362f, 0.10360093f, -0.03130374f, 0.38212609f, 
    -0.07966946f, 0.08206719f, -0.05907996f, 0.08454501f, 0.10204556f, -0.04535680f, -0.05935549f, -0.06937284f, 
    0.18256536f, 0.04273278f, -0.01265696f, -0.15644625f, -0.01006328f, 0.00334784f, 0.04209640f, 0.17453565f, 
    0.18528946f, 0.01543387f, -0.06796513f, 0.00942573f, -0.41496047f, 0.01567568f, -0.11798254f, -0.01382171f, 
    -0.00182257f, -0.14112104f, -0.03000397f, -0.03207282f, -0.09769732f, -0.04904879f, 0.17922798f, 0.04066571f, 
    0.00171119f, -0.04344203f, -0.16305745f, -0.32843706f, 0.13969909f, 0.05386947f, -0.18056983f, 0.05057337f, 
    0.05485868f, -0.09984826f, 0.10739408f, 0.11642408f, 0.15819626f, -0.10738207f, 0.05431879f, 0.10274074f, 
    0.01863281f, -0.12816399f, -0.00824556f, 0.02463552f, 0.08088088f, -0.14417972f, -0.14066175f, -0.17806190f, 
    0.07341772f, -0.36632037f, -0.00199213f, -0.01845505f, -0.02562248f, 0.07020427f, 0.04210961f, -0.00449370f, 
    -0.03125625f, 0.02377716f, -0.02476730f, 0.03266722f, 0.19489491f, 0.20406522f, 0.16568494f, 0.14175135f, 
    0.01023425f, 0.19845167f, 0.10986040f, 0.09506574f, 0.12768234f, 0.05141113f, -0.13060366f, 0.00509337f, 
    0.02319014f, 0.04091845f, -0.06052125f, 0.00339685f, -0.02640643f, -0.00625649f, 0.05026734f, 0.06510282f, 
    0.06069242f, -0.07337373f, -0.02635356f, -0.03780890f, -0.05145753f, -0.06204511f, -0.01166465f, 0.02517140f, 
    -0.00678057f, 0.05297419f, 0.05774112f, 0.02868101f, -0.00075020f, 0.00908471f, -0.04422225f, -0.00547308f, 
    0.00548321f, -0.02259373f, -0.02086083f, -0.02626424f, 0.01625161f, -0.05891914f, 0.05102633f, 0.03704251f, 
    -0.02299291f, -0.03098375f, 0.01945623f, 0.02882326f, 0.03243541f, 0.01589851f, -0.08229049f, -0.07933240f, 
    -0.00945485f, -0.00841456f, -0.03555439f, 0.01768716f, -0.06847432f, 0.05576668f, -0.08097421f, 0.00206708f, 
    0.07021748f, -0.01546740f, 0.01711467f, -0.03380610f, -0.06671479f, -0.07642537f, -0.07290844f, 0.03117253f, 
    0.04362831f, 0.05142023f, 0.04439510f, 0.01265268f, 0.03740079f, -0.04576591f, -0.06033799f, -0.07121410f, 
    0.03254080f, 0.03599437f, -0.07355984f, -0.02145761f, 0.01181895f, -0.02359714f, 0.01776896f, -0.05575754f, 
    0.02043252f, -0.03156817f, -0.04040348f, 0.01872907f, 0.01203247f, 0.05926294f, -0.06532986f, -0.04178046f, 
    -0.00043089f, -0.06292839f, -0.02929923f, 0.00627515f, 0.01723073f, 0.04121123f, 0.04682593f, -0.07256660f, 
    -0.04215591f, -0.00845185f, 0.02633204f, -0.03627676f, 0.03529075f, -0.08260451f, 0.01370801f, -0.03766266f, 
    0.04747090f, -0.06529691f, -0.00514327f, 0.04869188f, -0.00504912f, -0.08210965f, 0.03307972f, -0.02632187f, 
    0.04744553f, 0.00916198f, 0.03636960f, 0.02727368f, -0.06405913f, 0.00151142f, -0.03321120f, -0.05205121f, 
    0.02004049f, -0.03537117f, 0.05098563f, -0.07548220f, -0.05412998f, 0.01935698f, 0.01959354f, 0.03428959f, 
    0.02659549f, -0.06695271f, -0.05768489f, 0.01613227f, -0.00308301f, 0.01751600f, -0.05073757f, -0.05315076f, 
    -0.05231221f, 0.02544250f, -0.01079469f, -0.06928039f, 0.01680472f, -0.00241812f, -0.07729199f, 0.05411499f, 
    -0.00364685f, 0.00276539f, 0.00341869f, 0.02032569f, 0.05361528f, -0.08201893f, -0.07279436f, -0.02230991f, 
    0.00643620f, -0.01341438f, -0.05127076f, 0.05081807f, 0.04006108f, -0.01487441f, 0.00810719f, -0.07631589f, 
    -0.07821368f, 0.03556029f, -0.02494754f, 0.02533022f, -0.06326926f, 0.00707170f, 0.04210538f, -0.05494440f, 
    -0.03571148f, 0.06148860f, -0.03646505f, 0.06179269f, 0.00369840f, 0.03995770f, 0.00874236f, 0.02256661f, 
    -0.07334783f, 0.00755044f, -0.05524398f, 0.02250175f, -0.04507607f, -0.00879023f, -0.04278106f, -0.02934118f, 
    -0.07982027f, -0.08186009f, 0.06324934f, 0.02874970f, -0.06388213f, 0.02967791f, 0.04267589f, -0.07334640f, 
    0.05487593f, 0.04067105f, -0.02707464f, -0.01890479f, -0.00299749f, -0.00032262f, -0.08162122f, -0.07281239f, 
    0.42845038f, 0.04950581f, 0.02565305f, 0.07522871f, -0.01865679f, 0.09774561f, 0.14693320f, -0.09047157f, 
    -0.07791074f, -0.05074004f, 0.04461202f, 0.08272696f, -0.31169707f, -0.08614638f, -0.00735818f, -0.02003415f, 
    0.06894283f, -0.08163146f, -0.01826690f, -0.09742364f, 0.01553411f, -0.03195567f, -0.02312548f, -0.08922477f, 
    -0.06613617f, -0.07196480f, 0.03840009f, -0.19968341f, 0.15884414f, 0.12934864f, 0.02661404f, 0.00835007f, 
    -0.09167807f, -0.09601341f, -0.05908889f, 0.00006009f, 0.22891390f, -0.13539189f, 0.04795867f, 0.29343820f, 
    0.17371400f, -0.06009517f, -0.02986842f, 0.02495973f, -0.03667830f, 0.02903461f, 0.05415579f, 0.04128244f, 
    0.35634059f, -0.20017385f, -0.06225877f, 0.06493175f, 0.02598047f, -0.02586774f, -0.19483496f, 0.09392423f, 
    -0.01096561f, 0.03283210f, 0.06468286f, 0.01317713f, -0.08057082f, -0.05266695f, -0.25980613f, -0.05254327f, 
    -0.01187289f, 0.14213021f, 0.10259566f, 0.11005041f, -0.02098634f, 0.21201959f, -0.00974219f, 0.12984943f, 
    -0.01287427f, 0.06511641f, -0.01055570f, 0.02984526f, 0.05815793f, -0.02069426f, 0.09146330f, -0.08045955f, 
    -0.07934338f, -0.07642492f, 0.17197412f, -0.05263509f, -0.28417876f, 0.24261253f, -0.10167880f, 0.11203739f, 
    0.03141006f, 0.04721920f, 0.06824770f, -0.00560368f, 0.01099813f, -0.15503678f, -0.07900053f, 0.16084291f, 
    0.00957165f, 0.09638726f, 0.02565629f, 0.02990860f, 0.09484995f, 0.20509413f, -0.04850287f, -0.01338477f, 
    -0.22661358f, 0.04001419f, 0.01531530f, -0.10298706f, 0.02020563f, -0.17856109f, -0.12401952f, -0.30212286f, 
    0.22412539f, 0.09692246f, 0.17706120f, 0.02639043f, -0.05249340f, -0.03141091f, -0.05319814f, 0.02007177f, 
    -0.15496650f, 0.10405258f, -0.02620914f, -0.23620501f, -0.04573916f, 0.14210948f, -0.00918160f, -0.15970871f, 
    -0.19150111f, 0.00920873f, -0.06423049f, -0.00001795f, 0.69497162f, -0.03461302f, 0.32505652f, 0.36263514f, 
    -0.11118767f, -0.03955473f, -0.05868983f, 0.02791543f, 0.09699435f, 0.10550963f, 0.12001712f, -0.02778322f, 
    0.43195865f, 0.19066280f, 0.02902603f, 0.24733904f, -0.06370796f, -0.06114417f, -0.02362226f, -0.02949104f, 
    -0.01191368f, 0.00989268f, 0.04199617f, 0.15483671f, -0.35819390f, 0.16416308f, 0.02468717f, -0.28711754f, 
    0.10060322f, -0.07400166f, -0.02080765f, 0.01734445f, 0.00342120f, 0.21189655f, -0.09988800f, -0.16627020f, 
    -0.17259954f, 0.05320512f, 0.36090022f, 0.13867737f, 0.04116904f, 0.11649644f, 0.17206591f, 0.00943338f, 
    0.04952905f, 0.00636127f, 0.00725093f, -0.06531911f, -0.06654212f, -0.06960695f, -0.04368076f, -0.13240986f, 
    0.06346663f, 0.11430238f, 0.03566511f, -0.12114419f, -0.17957455f, 0.06659180f, -0.05093367f, -0.05807780f, 
    -0.16473243f, 0.28732577f, 0.09158430f, 0.00088707f, 0.09516600f, -0.03038239f, -0.00591960f, 0.03313713f, 
    0.01213456f, 0.13294089f, -0.07293766f, 0.05471900f, -0.15458044f, -0.12005495f, 0.01220172f, -0.06919080f, 
    -0.05496577f, 0.05291000f, 0.14822493f, 0.16202115f, 0.02475091f, 0.15144885f, -0.00128887f, 0.05932977f, 
    -0.32214144f, -0.16450237f, -0.16470551f, 0.08512709f, 0.05810596f, -0.02759522f, 0.00414090f, 0.16232079f, 
    0.08891997f, 0.12744878f, 0.10316969f, 0.11291288f, -0.00841478f, 0.18086043f, 0.13799736f, 0.26754189f, 
    -0.09179673f, -0.03024937f, 0.18059880f, 0.00958732f, 0.02911200f, 0.12109659f, 0.03282041f, 0.02404608f, 
    -0.12156453f, 0.23065338f, -0.04776092f, -0.02027331f, -0.04647087f, 0.06043440f, 0.11679760f, 0.07198282f, 
    0.05161064f, 0.04189684f, -0.00655960f, 0.01691757f, 0.25226605f, 0.05279221f, 0.00631267f, -0.10412969f, 
    -0.09404781f, 0.01272685f, -0.12545837f, 0.05852959f, -0.05094342f, -0.00587289f, 0.11867873f, 0.07730892f, 
    0.25592312f, -0.06111766f, 0.27203307f, 0.11060523f, -0.00634645f, 0.09520336f, 0.08739550f, 0.04243288f, 
    -0.19623949f, 0.21090080f, 0.04113515f, 0.04845732f, -0.22045985f, -0.09429096f, 0.03943039f, 0.07101845f, 
    -0.00043097f, 0.07659955f, -0.02913986f, -0.07861352f, -0.06547972f, 0.15795802f, 0.08067121f, 0.14073257f, 
    0.33203754f, 0.18242207f, 0.04033482f, 0.22379063f, -0.15702488f, 0.12769541f, -0.08063580f, 0.09700691f, 
    0.33315891f, 0.04862482f, -0.12004101f, 0.19646291f, -0.12212075f, -0.26942718f, 0.31353754f, 0.16617583f, 
    0.00440188f, -0.06874878f, -0.08385973f, -0.12874836f, 0.09818166f, 0.03471719f, -0.02030583f, 0.07423358f, 
    -0.41003087f, -0.16641450f, -0.14669433f, -0.18582548f, 0.15447791f, -0.04310127f, -0.07358128f, -0.00690120f, 
    0.08540159f, 0.13597690f, -0.04156071f, 0.06664909f, -0.28630644f, 0.12587787f, 0.23834564f, 0.09369110f, 
    -0.11445384f, 0.01810891f, 0.00027121f, 0.14872874f, 0.00483573f, -0.00554310f, 0.00387734f, -0.03575118f, 
    0.17512284f, -0.13033207f, -0.06024731f, -0.00651834f, 0.14532346f, 0.12295486f, -0.04865403f, 0.11715440f, 
    -0.07134736f, -0.02067456f, 0.01726122f, 0.08583834f, 0.00340872f, -0.10862569f, -0.04903890f, -0.06067799f, 
    0.00942653f, -0.01545132f, 0.00020077f, 0.00458691f, 0.06132177f, -0.03313616f, -0.00555898f, -0.05436442f, 
    -0.36406431f, -0.25501618f, -0.01925716f, 0.00578368f, -0.20999509f, 0.29001227f, -0.01677969f, 0.01391673f, 
    0.09904720f, 0.01075609f, -0.03198473f, 0.09533210f, 0.16357985f, -0.04282558f, 0.45994607f, -0.00386353f, 
    0.01825264f, 0.02792401f, 0.05391731f, 0.15776910f, 0.11007507f, 0.07363210f, 0.00132076f, -0.01273392f, 
    -0.28732732f, 0.18084867f, 0.09849797f, 0.00813766f, 0.17695463f, -0.05261874f, -0.11642740f, -0.01589005f, 
    0.13663524f, 0.10992356f, 0.06075344f, -0.08422927f, 0.30879295f, -0.22085722f, -0.07978311f, 0.19242857f, 
    0.09297004f, 0.01435765f, -0.14356537f, 0.02260049f, -0.03668666f, -0.00916806f, 0.15334158f, -0.00851777f, 
    -0.20424448f, 0.18418606f, 0.14505123f, -0.22758770f, 0.14574181f, 0.01083562f, 0.05222628f, 0.00904638f, 
    0.02150690f, 0.08804614f, 0.12431829f, 0.05350664f, -0.08762228f, -0.16905978f, 0.02446337f, 0.15336779f, 
    -0.13857684f, 0.13854158f, -0.05705212f, -0.16963162f, 0.12010290f, 0.04441585f, 0.04632216f, -0.08459190f, 
    -0.32309109f, -0.28645229f, -0.01167372f, 0.10338279f, -0.15551704f, -0.12650533f, 0.08433098f, 0.13691509f, 
    -0.02352856f, -0.12597959f, -0.01778505f, 0.03110124f, 0.14318277f, 0.12608334f, 0.20838599f, 0.29573518f, 
    -0.17289163f, 0.00521980f, -0.00404302f, 0.06969660f, 0.05012564f, -0.01152284f, 0.11740227f, 0.07669240f, 
    0.06956164f, 0.04836806f, 0.04458745f, 0.01170087f, 0.08248070f, 0.16726601f, -0.03083586f, 0.11787992f, 
    0.02477144f, -0.00248609f, 0.16355146f, -0.01072151f, -0.06800479f, 0.25778893f, -0.02424540f, 0.05468334f, 
    0.09069639f, 0.03501030f, 0.08109464f, 0.07014605f, 0.18536921f, -0.03855188f, 0.15861771f, -0.21269493f, 
    -0.01052765f, -0.07484117f, -0.15045224f, 0.12024928f, -0.10082702f, -0.02158367f, -0.19854529f, 0.06919003f, 
    0.17024896f, 0.06338131f, 0.00917333f, 0.16570285f, 0.07910584f, -0.00739321f, 0.16248342f, 0.11124924f, 
    -0.10223633f, -0.01466926f, -0.02904128f, 0.09704030f, -0.05807619f, 0.08142129f, 0.02013532f, -0.00554601f, 
    0.02732648f, 0.03309386f, 0.16604003f, -0.23733813f, 0.29385978f, -0.03630136f, -0.00265177f, 0.12904750f, 
    0.10566703f, 0.08138966f, 0.07623710f, -0.01354929f, -0.53994769f, 0.02165251f, -0.24068473f, 0.07839363f, 
    0.04234779f, 0.18521447f, -0.05283064f, -0.01208651f, 0.03333886f, 0.03326011f, -0.00492124f, -0.01335638f, 
    -0.23044154f, -0.08965675f, 0.15091321f, -0.51397663f, 0.14638495f, -0.04314687f, 0.19428585f, 0.05858770f, 
    0.00401501f, 0.23556589f, -0.08479748f, -0.03302974f, 0.10526750f, 0.07772750f, 0.06473081f, -0.20234066f, 
    0.15762912f, 0.11493716f, -0.05907458f, -0.04460278f, -0.02805052f, -0.12170745f, 0.05438588f, 0.12421568f, 
    -0.15081942f, 0.29391846f, 0.04799006f, 0.21325140f, 0.28057799f, 0.19228673f, 0.00856361f, -0.10503668f, 
    0.12201955f, 0.02881700f, -0.00039892f, 0.02802349f, 0.13453989f, -0.10887159f, 0.20021325f, -0.11993164f, 
    -0.02795170f, 0.01767444f, -0.05128776f, 0.11693482f, 0.09950728f, -0.02271922f, -0.03702346f, 0.07009282f, 
    -0.01676805f, 0.02792821f, 0.01722875f, -0.08732899f, 0.03539527f, 0.04789996f, -0.05447750f, 0.05138097f, 
    0.04449879f, 0.03237927f, -0.06831231f, -0.08721507f, -0.06639939f, -0.05430584f, 0.00978797f, 0.04603366f, 
    0.01698686f, -0.07655174f, -0.00536144f, -0.01607984f, 0.01225019f, -0.08414002f, 0.02324027f, 0.06657923f, 
    -0.08557053f, -0.06843342f, 0.00500091f, 0.00360479f, 0.01718229f, 0.04707275f, -0.02456061f, -0.07237014f, 
    -0.04952460f, -0.04252693f, 0.05738685f, -0.03615716f, -0.01539227f, -0.04696948f, 0.02117318f, -0.02304284f, 
    -0.06197133f, -0.00539162f, 0.00885368f, -0.01249824f, 0.03830883f, -0.01614930f, 0.02506168f, -0.02143307f, 
    -0.00924311f, 0.02083506f, -0.01088181f, -0.00042290f, -0.06139430f, -0.06171557f, 0.00365866f, 0.04754727f, 
    -0.03925861f, 0.01382394f, 0.01695140f, -0.02508446f, -0.06449834f, -0.00149904f, -0.00497510f, 0.03381783f, 
    -0.00060173f, 0.03563810f, 0.00964708f, -0.00938479f, -0.01405279f, -0.02016208f, -0.08709897f, -0.02601020f, 
    -0.00216363f, 0.05848491f, -0.04259343f, 0.01747712f, 0.01804666f, -0.07531965f, 0.01630171f, -0.03434408f, 
    0.00363147f, -0.07942704f, 0.00533650f, 0.00066464f, -0.02606233f, -0.04784938f, -0.04123891f, 0.02084957f, 
    -0.04998762f, -0.03821512f, 0.01355310f, -0.03511879f, -0.06157531f, -0.07948025f, 0.02884598f, -0.00969629f, 
    -0.04032620f, -0.08298012f, -0.05202056f, -0.06964476f, 0.03433177f, 0.02971421f, 0.03080020f, -0.01154289f, 
    -0.04876396f, -0.00623443f, -0.00869818f, -0.03040550f, 0.01970996f, 0.03004627f, 0.03538741f, 0.02098831f, 
    0.01279147f, -0.04222240f, -0.00930091f, -0.04453885f, 0.00010130f, 0.01674270f, -0.09237817f, 0.02945217f, 
    -0.03041684f, -0.07228090f, 0.05586317f, -0.07172174f, -0.01433680f, -0.06279323f, -0.02105971f, 0.01319894f, 
    0.04346232f, -0.07805631f, -0.03960047f, -0.04121045f, 0.05967704f, -0.06970565f, 0.02860105f, 0.01599911f, 
    0.02041167f, 0.03400016f, 0.04424496f, 0.05021577f, 0.03231097f, -0.01478000f, -0.04142589f, -0.05792243f, 
    -0.08131028f, -0.00636255f, -0.00964943f, 0.01235708f, 0.00533108f, -0.05103433f, -0.05535791f, -0.00336613f, 
    0.05686588f, 0.04435257f, -0.05582787f, -0.03559743f, 0.00102180f, 0.01771645f, -0.06206004f, -0.07395172f, 
    -0.06922322f, -0.04653540f, -0.02957837f, 0.01209356f, -0.07822019f, -0.04498370f, 0.01001665f, -0.07089267f, 
    -0.03499479f, 0.04862941f, 0.04492633f, 0.00201864f, -0.03063293f, -0.04838150f, -0.05485212f, 0.03780119f, 
    -0.04650246f, 0.01861764f, -0.00841236f, -0.07719500f, -0.03403658f, -0.01507310f, -0.04787405f, -0.00724134f, 
    -0.03704893f, -0.05034795f, 0.03547219f, 0.04246068f, -0.00675983f, -0.02110326f, 0.02507824f, 0.00490741f, 
    -0.00150306f, 0.01702037f, 0.01038116f, -0.07748802f, -0.03728499f, 0.00776407f, -0.03657463f, 0.03250350f, 
    0.00830464f, -0.04914105f, -0.02240032f, -0.00685483f, -0.02907972f, -0.01298256f, -0.06816755f, 0.01817043f, 
    0.05455886f, -0.03063125f, 0.01678886f, 0.05295816f, 0.02308331f, 0.03759615f, 0.02393369f, 0.00676499f, 
    -0.06716321f, 0.04308007f, 0.05845820f, -0.02850586f, 0.03724172f, -0.05862341f, 0.01586825f, 0.00789556f, 
    0.00321139f, -0.05786048f, -0.02382999f, 0.02488983f, -0.03018720f, 0.04122860f, -0.00745590f, -0.03594438f, 
    -0.06373771f, -0.04946161f, -0.00242997f, -0.04984671f, -0.05415174f, 0.05373269f, 0.00718939f, -0.01686752f, 
    -0.05421389f, 0.04648507f, 0.05834463f, 0.04418210f, -0.00857198f, 0.00788364f, 0.03763948f, 0.00055430f, 
    -0.02155216f, 0.00988648f, -0.06665611f, -0.03150492f, -0.00351315f, -0.03697553f, 0.05988159f, 0.01961008f, 
    0.00010182f, -0.00215475f, 0.02325713f, 0.02076836f, 0.03285510f, -0.00716827f, 0.03184143f, -0.06753623f, 
    -0.01326345f, -0.02538754f, 0.01307142f, -0.06549855f, -0.05798597f, -0.02577499f, 0.00173498f, 0.02898936f, 
    0.00007223f, -0.01293463f, 0.01847108f, -0.04554453f, 0.05451733f, -0.02568647f, -0.03954164f, 0.06355776f, 
    -0.02573766f, -0.05602938f, 0.02230509f, 0.01615056f, -0.00834323f, -0.05805402f, -0.07566636f, 0.02506476f, 
    -0.08262620f, -0.06152264f, -0.02567136f, -0.01925955f, -0.03945773f, 0.01612722f, -0.05706523f, 0.02146029f, 
    0.06093996f, -0.00902222f, -0.03978788f, 0.02061401f, 0.02155036f, 0.00564964f, -0.03244643f, -0.02498906f, 
    -0.01055826f, 0.02799517f, 0.00304294f, 0.02381183f, -0.04470098f, 0.02463837f, -0.05390027f, -0.04953093f, 
    -0.07120626f, -0.05290554f, -0.07576696f, -0.00737708f, -0.07901483f, -0.06476270f, 0.04676294f, 0.04824800f, 
    -0.00174856f, -0.04328889f, -0.00624787f, 0.04337672f, 0.00397385f, 0.00692556f, 0.02074375f, 0.02342408f, 
    -0.02732812f, 0.01787993f, 0.02464981f, 0.00287859f, -0.04340432f, 0.03958486f, 0.03134498f, -0.04137598f, 
    0.01540948f, -0.03671455f, -0.01777882f, 0.03315892f, -0.04057826f, 0.06457932f, 0.05073204f, -0.05808262f, 
    -0.06808367f, 0.02303531f, -0.05863886f, -0.02608270f, -0.03913172f, 0.01741334f, 0.01918681f, 0.00551158f, 
    0.02134886f, -0.03733977f, 0.01242166f, -0.06232093f, -0.00622334f, -0.00498238f, -0.00443600f, -0.04268309f, 
    -0.07361571f, -0.01694049f, 0.00852423f, -0.04219624f, 0.01141548f, -0.04675549f, 0.01697629f, 0.00179537f, 
    -0.07628367f, -0.07361443f, -0.07320023f, -0.04853418f, 0.05140370f, 0.05363405f, -0.00481090f, -0.04017837f, 
    -0.06979224f, 0.01895102f, -0.05765419f, -0.01117185f, -0.00803395f, -0.07139973f, 0.03369131f, -0.00199672f, 
    -0.01890300f, -0.16616267f, -0.00494886f, -0.13189985f, -0.00755337f, 0.13070290f, 0.07992650f, 0.09514016f, 
    -0.00151585f, -0.07733989f, 0.00419296f, 0.09810826f, 0.26321080f, 0.14524825f, 0.02958488f, -0.02533507f, 
    -0.07642885f, 0.08804215f, 0.03050224f, 0.03295313f, -0.02402910f, 0.07323505f, 0.06304195f, 0.15077604f, 
    0.34357873f, -0.16433741f, 0.13202858f, 0.50734395f, -0.09069081f, 0.04664597f, -0.06119192f, 0.03299325f, 
    0.04354531f, 0.04477761f, 0.09469686f, 0.06375904f, 0.00065374f, -0.20115934f, 0.24854194f, -0.01992094f, 
    0.02452682f, 0.09182386f, -0.16994497f, 0.09890237f, 0.07945996f, 0.04122056f, 0.02369821f, -0.06322999f, 
    -0.11294422f, 0.01691174f, -0.14792557f, 0.28156254f, -0.04796364f, 0.05954355f, -0.07217304f, 0.10095701f, 
    0.05091356f, 0.01369117f, -0.03724947f, -0.04417053f, 0.14718069f, -0.14997643f, -0.10466946f, -0.24345268f, 
    0.07070910f, -0.01068783f, -0.06884904f, 0.01203121f, -0.03405290f, 0.07668975f, 0.07537368f, 0.00048471f, 
    0.31981215f, 0.02796810f, -0.03547044f, -0.44152850f, -0.17433122f, 0.02671492f, 0.08531291f, 0.10640343f, 
    0.00262622f, 0.07217635f, 0.16983296f, 0.02351257f, 0.21200277f, 0.10845925f, 0.04069837f, 0.12306450f, 
    0.01245476f, 0.06751812f, -0.09933568f, 0.00833329f, 0.05518563f, -0.15437040f, -0.01308345f, 0.09410399f, 
    -0.03412948f, -0.03824329f, 0.03018400f, -0.23915562f, -0.00643740f, 0.16661558f, 0.13169995f, 0.09788831f, 
    0.01513909f, -0.00205327f, -0.05355348f, 0.14974655f, -0.18544018f, -0.32222149f, -0.05232438f, -0.22150029f, 
    0.05997942f, 0.02039542f, 0.12014378f, 0.00325463f, 0.15590787f, 0.06763624f, 0.12821092f, 0.00134968f, 
    0.06563243f, -0.01175394f, 0.28065050f, 0.20980079f, 0.03791277f, -0.08887161f, 0.00122886f, -0.09443633f, 
    0.04234296f, -0.05025579f, -0.02335788f, -0.01963874f, -0.28018534f, -0.23957379f, 0.05808200f, 0.00756882f, 
    0.16461712f, -0.13284796f, 0.04078851f, 0.15215036f, -0.11674386f, -0.00295434f, -0.02999498f, -0.02894639f, 
    0.10759071f, 0.20455588f, 0.00145644f, 0.08269281f, -0.00091244f, -0.15588954f, -0.15195535f, 0.04977285f, 
    -0.00696314f, -0.03808645f, -0.05878422f, 0.04895736f, 0.13779537f, 0.00372127f, 0.22738360f, 0.05374895f, 
    0.04443023f, 0.01225047f, 0.00997230f, 0.02660075f, 0.06117963f, 0.00538742f, 0.04056681f, -0.17554705f, 
    0.48662683f, 0.03451465f, 0.17735980f, -0.02158437f, -0.01176012f, -0.06298555f, -0.16596067f, 0.11136422f, 
    0.00392167f, -0.03239604f, -0.00596295f, 0.14953409f, -0.23890714f, -0.32428807f, 0.04744348f, -0.13613537f, 
    0.04856369f, 0.11171208f, -0.00189558f, 0.04099581f, 0.15058152f, -0.01864495f, 0.08461303f, 0.08524260f, 
    -0.24519530f, -0.12446181f, 0.15153292f, 0.00977310f, 0.13071935f, 0.03357747f, -0.15561898f, 0.00960700f, 
    0.11121771f, -0.01594054f, 0.10102469f, 0.18459885f, 0.00978609f, -0.03596137f, -0.04941803f, 0.05818265f, 
    0.00800154f, 0.03876954f, -0.01782898f, 0.01711375f, 0.03967426f, 0.05422999f, 0.14765738f, -0.00552408f, 
    -0.21054748f, -0.18123476f, -0.05347746f, 0.02784687f, 0.11594865f, -0.04903446f, -0.00195768f, -0.14791819f, 
    -0.05785492f, -0.11365815f, 0.03843691f, 0.00722643f, 0.20548615f, 0.18149815f, -0.11003581f, -0.03846012f, 
    0.02404941f, 0.04094448f, 0.02827771f, -0.00089496f, 0.01254678f, -0.07242835f, -0.05126117f, -0.09071000f, 
    0.35036880f, 0.34131315f, 0.43402568f, -0.18380500f, -0.05457786f, -0.03760349f, -0.03440290f, -0.24424207f, 
    0.11707075f, -0.08666153f, -0.13472895f, -0.00625496f, 0.09168030f, 0.04016738f, 0.42424819f, 0.05182182f, 
    -0.04245329f, 0.05529457f, -0.03546570f, -0.14826851f, 0.15532014f, -0.13986862f, -0.15937865f, 0.00432586f, 
    -0.13271010f, -0.02518887f, 0.09397029f, 0.28179175f, 0.26536644f, 0.03942342f, -0.09299407f, 0.02035246f, 
    0.14112301f, -0.04797100f, -0.21040758f, 0.13529895f, 0.06812719f, -0.25925189f, -0.23159395f, -0.11223903f, 
    -0.09458280f, -0.14319038f, 0.05606472f, 0.20454712f, 0.09734975f, 0.19948177f, -0.02830896f, -0.12315533f, 
    -0.19139650f, 0.05828207f, 0.33633119f, 0.03590546f, -0.08332161f, -0.10225465f, -0.06323084f, 0.02693999f, 
    0.13050050f, -0.03346960f, -0.03365653f, -0.02261070f, 0.11997028f, 0.17492902f, 0.13013978f, 0.14866430f, 
    -0.10648763f, -0.00485178f, 0.03614872f, -0.03147778f, -0.18753782f, 0.09246058f, 0.06317970f, 0.06645383f, 
    -0.14786597f, -0.10296881f, -0.16177911f, 0.02585593f, 0.02680937f, 0.03047227f, -0.06441418f, 0.04307423f, 
    -0.01358681f, 0.07894954f, 0.05281265f, -0.10716949f, 0.10750727f, 0.27994817f, -0.06390975f, -0.09483213f, 
    0.09344006f, 0.18033372f, 0.04708512f, 0.02684976f, 0.09954842f, 0.05219743f, -0.13056409f, 0.02815131f, 
    -0.09347049f, -0.03017532f, -0.01705509f, 0.21433046f, 0.08578926f, 0.21498604f, 0.13281552f, -0.07050654f, 
    -0.07242931f, -0.04188821f, 0.01025019f, -0.18194960f, 0.06335407f, -0.10679184f, -0.20902167f, 0.10580592f, 
    -0.14587620f, -0.09694262f, 0.14451459f, 0.10996262f, -0.04976748f, 0.10312316f, 0.02308979f, 0.18515481f, 
    -0.20942675f, 0.13601461f, -0.11260705f, -0.16624916f, -0.09870482f, -0.08109879f, 0.02683177f, -0.01675504f, 
    -0.05910271f, -0.01300830f, 0.11522976f, -0.12128878f, 0.16656847f, 0.11045109f, -0.02601757f, 0.29310390f, 
    -0.10833950f, -0.14140220f, -0.21332783f, 0.20877261f, 0.03210913f, -0.07968470f, 0.19874375f, 0.03992553f, 
    -0.45033732f, 0.16992277f, -0.16426466f, 0.07414281f, 0.21609776f, 0.02336042f, -0.10724705f, 0.04161269f, 
    0.13834789f, 0.13216172f, -0.02788252f, -0.10691468f, 0.38695976f, 0.05748898f, 0.08596591f, 0.07000152f, 
    0.02591647f, -0.03913610f, -0.00909231f, -0.01713481f, -0.01417939f, 0.07693914f, 0.15347451f, 0.05042630f, 
    0.17306353f, 0.00612055f, 0.12285983f, -0.01986162f, -0.03819922f, -0.04400781f, 0.03577834f, -0.00825278f, 
    0.14437748f, -0.05661911f, 0.04924732f, 0.03333462f, 0.21272807f, -0.12469164f, -0.04962629f, 0.00532064f, 
    0.05532412f, 0.13284568f, -0.20930929f, -0.11002692f, -0.03199104f, 0.06031195f, 0.11015746f, -0.17243491f, 
    -0.41774815f, 0.01285869f, 0.14836612f, 0.00197842f, -0.11940902f, 0.08541548f, 0.06025802f, 0.01401790f, 
    -0.08968345f, 0.02308339f, 0.03354315f, 0.07940039f, -0.09854868f, 0.09031133f, 0.20651177f, -0.01171505f, 
    -0.13796471f, 0.09439134f, -0.12924047f, -0.06256084f, 0.11689583f, -0.04070254f, 0.13224740f, -0.10469618f, 
    0.21048406f, 0.05891173f, -0.15254806f, -0.10903820f, -0.10824156f, 0.09470550f, 0.04844099f, 0.06076895f, 
    0.13917173f, -0.10653638f, 0.09681887f, -0.04697522f, 0.21036322f, 0.14219388f, -0.08809069f, -0.00228043f, 
    0.03091066f, 0.09778336f, -0.05338387f, 0.08768043f, 0.02669620f, -0.06043058f, 0.02615435f, -0.19905984f, 
    -0.01911840f, -0.18659475f, -0.17968920f, 0.08926853f, -0.06089214f, -0.08111312f, -0.09179320f, 0.19936079f, 
    0.07766219f, 0.13653876f, -0.03306435f, 0.06317300f, 0.36285248f, -0.05197236f, -0.00871701f, 0.16953517f, 
    -0.21501678f, -0.08372156f, -0.03966345f, 0.07974096f, -0.12220673f, -0.05549383f, 0.14639553f, 0.04474150f, 
    0.25023133f, 0.02516807f, 0.20148921f, -0.10546382f, 0.18161231f, 0.03477664f, 0.03245182f, 0.08692449f, 
    0.10004462f, -0.00789754f, -0.00601124f, 0.06433045f, -0.58814245f, 0.15935974f, -0.23601750f, -0.20092438f, 
    0.15795344f, 0.24287759f, 0.01736791f, 0.07188713f, -0.01450293f, 0.03179037f, -0.01847923f, -0.06060108f, 
    -0.35569319f, 0.15075089f, 0.11185738f, -0.16764919f, 0.23392875f, -0.03825583f, 0.19199999f, 0.07170185f, 
    0.01343235f, 0.01217863f, 0.07066958f, 0.00843352f, 0.23025581f, -0.01230517f, 0.05669925f, -0.17925203f, 
    0.00752712f, -0.09345911f, -0.00597627f, -0.04147020f, 0.03730222f, -0.02939751f, 0.10518096f, 0.08987867f, 
    0.28158107f, 0.43521777f, 0.16747904f, -0.09429281f, 0.08622514f, 0.05204545f, -0.09005151f, -0.16460291f, 
    -0.05359645f, -0.06025541f, 0.03857847f, 0.04788458f, 0.16531874f, -0.38809398f, -0.08698110f, -0.03445532f, 
    -0.12390561f, -0.05830355f, -0.11528190f, 0.14743060f, 0.14922807f, -0.15514240f, 0.12882853f, 0.05211850f, 
    0.10561559f, -0.08358849f, 0.04022171f, -0.03604344f, 0.04065586f, -0.18563077f, 0.13210385f, 0.08112077f, 
    -0.00926516f, -0.07267116f, 0.02254461f, -0.01320942f, -0.19221070f, 0.13985813f, -0.11570428f, -0.10244787f, 
    -0.13857402f, 0.07686798f, -0.09775172f, -0.08590604f, 0.03093943f, -0.15034373f, 0.08463518f, -0.00512881f, 
    0.16638766f, 0.17204608f, -0.11819402f, 0.26151440f, -0.00513898f, -0.02725670f, 0.02675427f, 0.12264480f, 
    0.12562050f, 0.13338146f, 0.04361035f, 0.00203712f, -0.00460081f, 0.24261038f, -0.10885261f, -0.23427339f, 
    -0.10446934f, -0.02619174f, 0.07129043f, -0.00314097f, 0.08355316f, -0.05282177f, 0.02429578f, 0.24556753f, 
    -0.00426334f, 0.03124020f, -0.08240774f, -0.04232615f, 0.03883826f, 0.16902164f, 0.07539470f, 0.01005008f, 
    -0.03619952f, -0.01349553f, 0.03687874f, -0.09721389f, -0.15294136f, 0.23215859f, -0.06576918f, 0.07043168f, 
    -0.02661678f, 0.10747951f, 0.03906965f, 0.02735785f, -0.01976289f, -0.01403382f, -0.12534840f, 0.00506386f, 
    -0.22395985f, 0.04643322f, 0.14869651f, 0.03258655f, -0.11673215f, 0.01809416f, -0.05656859f, -0.05544902f, 
    0.04990492f, -0.01464454f, 0.05323157f, -0.00370224f, 0.09022953f, -0.20990421f, 0.22103694f, -0.04427807f, 
    0.01078806f, -0.08433228f, -0.04212825f, -0.00671495f, 0.09879392f, -0.02168896f, -0.00538223f, 0.02801194f, 
    0.30236745f, -0.03802050f, 0.11660020f, -0.11298027f, 0.04500626f, 0.07138341f, 0.27160999f, -0.01044035f, 
    -0.00651841f, -0.04911152f, 0.19003133f, -0.01868704f, -0.25898534f, 0.48678899f, -0.04216417f, 0.13959703f, 
    -0.06832033f, 0.11570639f, -0.01582019f, 0.09616364f, 0.17527251f, 0.02218091f, 0.06429780f, 0.04153388f, 
    0.24602517f, -0.02514040f, 0.07809098f, 0.30013385f, -0.08928400f, -0.04103183f, 0.13469626f, 0.16274185f, 
    0.14119281f, 0.04918268f, 0.01716535f, 0.06476226f, -0.05127162f, -0.01225320f, -0.21680884f, -0.15280727f, 
    -0.03177172f, -0.10048851f, -0.08004434f, -0.05766476f, 0.01312784f, -0.12745629f, 0.20545627f, 0.08443227f, 
    -0.32470819f, -0.06167896f, -0.13180865f, -0.15921168f, -0.01808721f, 0.06428016f, -0.14146431f, -0.06351235f, 
    0.12781961f, -0.00453672f, -0.02290579f, 0.05563094f, 0.06287321f, -0.09834399f, 0.09859414f, 0.37250048f, 
    -0.00344583f, 0.00500007f, 0.03876443f, 0.12718916f, 0.10476862f, 0.01012178f, 0.00627989f, 0.01425738f, 
    0.31531724f, -0.52927649f, -0.21238436f, -0.02284710f, 0.06395342f, -0.18760657f, -0.05881328f, -0.07631011f, 
    -0.09013060f, 0.05247020f, -0.05335119f, -0.01542508f, 0.00928143f, 0.55552977f, -0.23097308f, 0.09606237f, 
    0.09161479f, 0.15589866f, 0.05511400f, 0.04932050f, 0.05402393f, 0.10282245f, 0.02034014f, -0.08549409f, 
    0.05527474f, -0.00663711f, 0.34215629f, 0.13561191f, -0.22298858f, -0.24025868f, -0.04914306f, -0.08415826f, 
    0.10645667f, 0.02930387f, 0.15143223f, 0.08394122f, 0.16188245f, -0.13727309f, -0.20383430f, -0.08360513f, 
    0.12092393f, 0.12763022f, -0.16644108f, -0.18561743f, -0.07996845f, 0.09643597f, 0.16086532f, 0.07123457f, 
    -0.10205298f, -0.23846014f, -0.25100058f, 0.05756219f, 0.31356820f, 0.11236101f, -0.14438708f, -0.01859822f, 
    -0.00028762f, -0.08664165f, -0.04695839f, 0.07138938f, -0.02572159f, 0.01010619f, 0.11793612f, 0.19533657f, 
    -0.15705541f, -0.05832993f, -0.18486141f, -0.14781936f, 0.02027727f, 0.05805027f, 0.28164223f, -0.31381658f, 
    0.34556323f, 0.07480671f, 0.00005147f, 0.05337255f, 0.11488318f, -0.03757856f, -0.06995696f, 0.03580410f, 
    -0.01206898f, -0.06660344f, -0.00805111f, 0.04462157f, 0.19124655f, 0.39029980f, -0.07753538f, 0.12589620f, 
    -0.14779076f, 0.11611275f, 0.01322337f, 0.01654834f, -0.03299812f, 0.04074109f, 0.18159033f, 0.07570934f, 
    -0.47329280f, -0.34459975f, 0.03396666f, -0.19798899f, 0.05565758f, 0.20094018f, 0.15792152f, 0.13560089f, 
    0.11698947f, -0.25323188f, -0.10958432f, 0.10962579f, -0.33985779f, 0.31898347f, 0.02048177f, -0.20011529f, 
    0.06107863f, 0.09384333f, 0.05246911f, 0.06803145f, 0.09818860f, -0.13725504f, 0.14115727f, -0.02469777f, 
    -0.27665037f, -0.00308020f, -0.17777272f, -0.06737372f, 0.12643014f, -0.04102735f, 0.06535186f, -0.03419568f, 
    0.17133306f, 0.30548054f, 0.00303382f, 0.06817783f, -0.00528769f, -0.10454541f, -0.20612970f, -0.23624951f, 
    0.00135711f, 0.14304973f, -0.04590027f, 0.05473312f, 0.15455998f, 0.15701476f, 0.00213891f, 0.08282685f, 
    -0.02855400f, -0.15495850f, -0.01122898f, -0.02994069f, 0.25368810f, 0.10239459f, -0.06897491f, -0.13004655f, 
    -0.00208653f, -0.14506401f, 0.05958392f, 0.04886829f, 0.28382871f, 0.29587892f, 0.11617665f, 0.54074931f, 
    -0.25314432f, -0.17963810f, -0.04338411f, 0.01648160f, -0.03126327f, 0.11207965f, -0.13393252f, -0.29796839f, 
    -0.14360523f, -0.15398850f, 0.10658015f, -0.17558220f, -0.17789780f, -0.16960114f, 0.15110952f, 0.00765479f, 
    0.11928757f, 0.13315274f, -0.11947349f, 0.13360666f, -0.18606313f, -0.02209672f, 0.05544614f, -0.10540704f, 
    0.27465004f, 0.09095048f, -0.03368270f, -0.02219090f, -0.08535152f, 0.05917005f, 0.12969562f, 0.12148790f, 
    0.10170670f, 0.13019361f, 0.11082699f, -0.07413524f, 0.21918792f, 0.08339096f, 0.11881425f, -0.27381450f, 
    0.17470914f, 0.03308442f, 0.05345897f, 0.06674025f, 0.03097605f, -0.15730865f, -0.32341596f, -0.14853816f, 
    0.12571388f, 0.09575381f, 0.09106795f, -0.26838312f, 0.01495673f, -0.02179481f, 0.01604760f, 0.13809921f, 
    0.01497634f, -0.00928227f, -0.05849205f, 0.06656674f, 0.00882370f, 0.05823347f, 0.02024112f, 0.00583426f, 
    -0.06069972f, 0.00165731f, -0.07428832f, 0.06394036f, 0.00688782f, -0.03343087f, -0.06013143f, 0.04166035f, 
    0.01475215f, -0.05481939f, 0.02052066f, -0.07209431f, 0.06427785f, 0.06673332f, 0.03173410f, 0.00958257f, 
    -0.00510156f, 0.05747617f, -0.01868021f, 0.00610994f, 0.05270716f, -0.00750281f, -0.03644887f, -0.05414857f, 
    -0.01284784f, -0.02587532f, -0.02161180f, 0.00952431f, -0.02254802f, -0.00320888f, -0.07108068f, -0.05859916f, 
    0.02015471f, -0.05627889f, 0.00567234f, -0.03120794f, -0.06375106f, 0.05085326f, -0.06276853f, -0.05271905f, 
    0.03499149f, 0.06087256f, -0.01662263f, 0.04360381f, 0.02755628f, 0.00557599f, 0.01685111f, -0.06057507f, 
    -0.07639870f, -0.04484146f, 0.02650053f, -0.03289006f, -0.07697689f, -0.00742366f, -0.00418656f, 0.00058940f, 
    -0.07273664f, -0.03491498f, 0.05911573f, -0.04080524f, -0.00342693f, -0.03198972f, 0.04397684f, -0.01213355f, 
    0.01013034f, -0.06465210f, -0.02974141f, 0.03575835f, 0.06453491f, -0.06485096f, 0.00296510f, 0.02794073f, 
    0.04805334f, 0.00259450f, -0.03719832f, 0.05503527f, -0.02871148f, -0.00705292f, -0.05476709f, 0.05099198f, 
    0.04655000f, 0.00591906f, -0.02999056f, 0.06659236f, -0.03004085f, -0.05343666f, -0.01809345f, -0.01081726f, 
    -0.02950744f, -0.06209605f, -0.01005132f, -0.00758745f, -0.03260501f, -0.05273918f, -0.03599246f, -0.07384786f, 
    0.01878985f, -0.06056359f, 0.00151429f, 0.05153912f, 0.04992879f, -0.04253739f, 0.05741272f, -0.05275690f, 
    0.05274598f, -0.07114550f, -0.06183512f, -0.05954256f, 0.01203606f, -0.07121044f, -0.04753261f, -0.06898049f, 
    -0.05661682f, -0.02770630f, -0.04045542f, 0.04866930f, -0.07123844f, 0.01378611f, -0.02460767f, -0.00411486f, 
    -0.02833046f, -0.03962672f, 0.06340504f, -0.02589878f, -0.00032261f, -0.03980545f, -0.00273151f, -0.00016528f, 
    -0.04194659f, 0.06006289f, 0.01297873f, -0.06217837f, -0.02640780f, 0.06676592f, -0.00379000f, 0.00041794f, 
    0.06684728f, -0.06213528f, -0.00243695f, 0.02235769f, -0.02173969f, 0.02477583f, -0.00544380f, 0.03260570f, 
    -0.01147415f, 0.00735575f, -0.00236562f, 0.04134674f, -0.04680040f, 0.01614371f, 0.01269982f, -0.06989631f, 
    -0.01537935f, -0.02896014f, -0.05534215f, -0.04387161f, 0.02955000f, 0.01871636f, 0.02554012f, 0.01320655f, 
    -0.01542021f, -0.03123530f, 0.05112776f, -0.01189510f, -0.03060466f, 0.01161246f, -0.02042288f, 0.04128218f, 
    -0.03464483f, 0.05617772f, 0.01235917f, -0.04758424f, -0.06839434f, -0.07502151f, -0.07059915f, 0.05876179f, 
    -0.07046019f, -0.03683501f, -0.00782699f, 0.04219820f, -0.06018260f, -0.05360725f, -0.04624243f, -0.03961372f, 
    0.21543074f, 0.10648977f, 0.41433617f, -0.07379817f, -0.13662568f, 0.03669045f, 0.11339664f, -0.02445902f, 
    -0.03627775f, -0.02979185f, -0.02719127f, -0.16406298f, -0.06633834f, -0.11030021f, -0.00841532f, 0.11098214f, 
    -0.00821834f, -0.06196145f, 0.19454458f, 0.11864371f, 0.11594681f, -0.06240870f, -0.17656599f, -0.13679841f, 
    -0.15885341f, 0.13694449f, -0.08800635f, -0.33964235f, 0.15592235f, 0.07328966f, 0.04744865f, -0.04705498f, 
    -0.00690168f, 0.21756540f, 0.12078872f, 0.04628892f, -0.07773306f, 0.28576878f, -0.05686695f, 0.22039415f, 
    -0.07168230f, -0.08791046f, 0.24933311f, 0.05637442f, 0.09680489f, 0.07254774f, -0.14258415f, 0.26978430f, 
    0.35576224f, -0.16609369f, 0.10972036f, -0.00924554f, 0.04838486f, -0.02990332f, 0.02816190f, 0.15614240f, 
    -0.09090103f, -0.06688365f, 0.16571394f, -0.02910060f, 0.09512670f, -0.07861153f, 0.07550855f, 0.33199954f, 
    -0.01234361f, -0.03934098f, 0.06959609f, 0.08523849f, 0.04248174f, 0.03931036f, 0.02449113f, 0.04657090f, 
    0.01698197f, 0.03860779f, -0.05204125f, 0.21493509f, -0.01076782f, -0.04437762f, -0.03214286f, -0.17754951f, 
    -0.09953344f, 0.24556713f, 0.03935832f, -0.01426456f, -0.22957577f, 0.13035379f, -0.19328432f, -0.14119567f, 
    0.04935022f, -0.01461409f, 0.22758257f, -0.11832622f, -0.18455353f, 0.15189119f, -0.08679302f, 0.24643730f, 
    -0.06322377f, 0.14150332f, 0.02403453f, 0.08608151f, -0.06411940f, 0.04470704f, -0.27566200f, -0.02075071f, 
    0.08649684f, -0.09747498f, 0.09527343f, -0.06538951f, 0.17280698f, 0.04845672f, 0.07000636f, 0.02205691f, 
    0.07166904f, 0.07376580f, -0.00304019f, -0.09276052f, 0.08363379f, -0.04050815f, -0.14488190f, -0.02213269f, 
    0.01318352f, -0.02478743f, -0.30773294f, -0.28031400f, -0.07708300f, 0.10005447f, -0.06400975f, 0.00267072f, 
    0.04990603f, 0.22862607f, 0.04914267f, -0.09318897f, 0.26299360f, 0.29020396f, 0.23289655f, 0.21855615f, 
    -0.10463952f, -0.06489937f, 0.05879968f, -0.05143032f, 0.16158339f, 0.05797410f, 0.21313092f, 0.15623049f, 
    0.22290610f, 0.04116559f, 0.24972463f, -0.04261344f, 0.01208626f, 0.09785545f, -0.05651788f, -0.02057248f, 
    0.06041473f, -0.03988189f, 0.22652274f, -0.01167869f, 0.09626938f, 0.00074423f, -0.12071540f, 0.00009337f, 
    0.08318521f, 0.01757097f, 0.02478348f, 0.10675400f, -0.08591530f, -0.01322673f, -0.18236887f, -0.14151447f, 
    -0.50397593f, 0.16623086f, -0.06897644f, 0.22144540f, 0.07669745f, 0.29738861f, 0.09375236f, 0.19358337f, 
    0.12957370f, 0.09678896f, 0.03339533f, -0.05052505f, 0.13691628f, 0.15576771f, 0.27826890f, -0.00899689f, 
    0.09185843f, 0.07999668f, -0.02220746f, 0.03027447f, -0.05340444f, 0.20146714f, -0.09607594f, -0.07652695f, 
    -0.04676460f, 0.05054496f, 0.10203692f, -0.12402719f, 0.12141591f, 0.03884088f, -0.14132379f, -0.11569377f, 
    0.06581575f, -0.08865472f, -0.11680640f, -0.00718580f, 0.04802189f, -0.01675291f, 0.08389340f, -0.00265656f, 
    0.03076491f, -0.03145276f, 0.03059801f, 0.21815483f, 0.04125645f, 0.04977735f, 0.10606185f, -0.01769609f, 
    -0.30467072f, -0.32932636f, -0.34750172f, -0.13530391f, 0.09036639f, -0.09515071f, -0.03292938f, -0.03604261f, 
    -0.00780178f, 0.06598556f, 0.08529784f, 0.09726867f, 0.15754998f, 0.06188279f, 0.10462572f, 0.33045641f, 
    -0.15759836f, -0.06953996f, 0.16162117f, 0.18617520f, -0.01436766f, 0.11875672f, 0.02760968f, -0.21605571f, 
    0.40249360f, 0.10568316f, 0.08606646f, -0.24702372f, 0.10526206f, 0.05506826f, 0.22156246f, 0.06554904f, 
    -0.03680492f, -0.14708874f, 0.03625171f, 0.10607903f, 0.17368382f, 0.02301306f, 0.09155706f, -0.27808520f, 
    -0.08768204f, 0.10363306f, -0.06210417f, 0.09084917f, 0.17188866f, 0.07721817f, 0.20728593f, 0.09302560f, 
    0.36796349f, 0.04001989f, 0.24665469f, -0.16298218f, -0.01214252f, -0.02118636f, 0.13904105f, -0.07903156f, 
    -0.12545131f, 0.18089947f, -0.05845479f, 0.14332545f, -0.22665013f, 0.09066791f, -0.15646951f, -0.04847295f, 
    0.04683696f, 0.01129550f, 0.11918183f, -0.16352481f, -0.08687963f, 0.14569847f, 0.12316657f, 0.10990525f, 
    0.14780490f, -0.03117658f, 0.15408786f, 0.34556299f, -0.22195080f, 0.11765508f, -0.18792488f, 0.07219287f, 
    0.13484584f, 0.06344533f, -0.10776471f, 0.17011993f, 0.25079250f, -0.27948028f, 0.19506161f, 0.03050711f, 
    0.02525972f, 0.06743004f, -0.11218067f, -0.16618805f, -0.00952796f, -0.12676609f, -0.00568768f, 0.13615376f, 
    -0.03244100f, -0.20146325f, -0.15292908f, -0.14092186f, 0.22412777f, 0.06487502f, -0.22972050f, -0.06380512f, 
    -0.06510814f, 0.04882360f, -0.07860398f, -0.06560230f, -0.19178824f, 0.27541727f, -0.01143812f, 0.19584697f, 
    -0.14222896f, 0.00205615f, -0.12143832f, 0.10456522f, -0.14338011f, 0.02007126f, 0.11817481f, -0.06316559f, 
    0.23781343f, 0.13515453f, -0.00653549f, 0.14844005f, 0.06142160f, 0.00265076f, 0.02485888f, -0.00813917f, 
    -0.10268220f, 0.04606969f, 0.17593426f, 0.02554196f, 0.19597103f, -0.15943915f, -0.00378028f, -0.22411059f, 
    0.28776729f, -0.00873237f, -0.02725864f, -0.02435737f, -0.07663863f, -0.05782137f, -0.07272746f, -0.13430370f, 
    -0.35630330f, 0.07078160f, 0.30091462f, -0.01972205f, 0.09876630f, 0.22720790f, 0.10757557f, -0.08152407f, 
    0.06510860f, -0.06618001f, 0.18175837f, -0.01653007f, 0.26800179f, -0.30074209f, 0.42500731f, 0.08410592f, 
    0.00644510f, 0.10478129f, -0.08694151f, 0.15157817f, 0.09373686f, 0.06939358f, 0.05806452f, 0.03418344f, 
    0.12539342f, 0.31981650f, -0.01988596f, 0.22549069f, 0.11030644f, 0.16711420f, 0.02498889f, 0.04295387f, 
    -0.04627005f, 0.15388803f, 0.02743650f, 0.04431392f, 0.15456262f, -0.01810029f, 0.02032848f, -0.04382983f, 
    0.19975412f, 0.09550618f, 0.06721136f, -0.00546426f, -0.07404689f, 0.09143733f, -0.23653804f, 0.11469741f, 
    0.11599378f, -0.05754778f, 0.18707874f, 0.08306088f, -0.03505486f, 0.03288656f, -0.08609092f, -0.07714791f, 
    0.01524121f, -0.11106542f, -0.01401192f, -0.00882444f, 0.17742983f, -0.05067858f, 0.32465452f, 0.22146729f, 
    0.33225778f, 0.22151645f, -0.01896462f, 0.02472972f, -0.11555880f, 0.06459448f, 0.08829455f, 0.01173236f, 
    -0.53961152f, 0.07881438f, 0.06124183f, -0.16562612f, 0.11397430f, 0.06202947f, -0.08976587f, -0.04340397f, 
    0.09568419f, 0.11180795f, 0.00499285f, -0.11615843f, 0.08589367f, -0.27149579f, -0.21781412f, -0.09726263f, 
    -0.00426855f, -0.14996819f, -0.11520937f, -0.01686643f, -0.07533880f, -0.19975333f, 0.00523077f, -0.08134560f, 
    0.34870967f, -0.00253203f, -0.11529414f, 0.26371568f, 0.12566517f, 0.05924566f, 0.05964021f, -0.00501258f, 
    -0.00403740f, -0.05191977f, 0.07058091f, 0.05865857f, 0.19240063f, 0.00221774f, 0.19204630f, 0.03018899f, 
    -0.15857337f, -0.05166039f, -0.12756689f, -0.04221724f, -0.10023306f, -0.03886141f, 0.02900033f, 0.03684735f, 
    0.06984328f, 0.21464300f, 0.00417728f, 0.14182082f, -0.09542233f, -0.16950285f, 0.00147623f, 0.02418453f, 
    -0.03962619f, 0.09947007f, -0.12822360f, -0.07378906f, 0.18339530f, -0.35445777f, -0.03311407f, -0.02019723f, 
    -0.13101755f, -0.16291688f, -0.05512243f, -0.13676582f, -0.15668674f, -0.11374962f, -0.03770058f, -0.02195200f, 
    -0.19633999f, 0.08827294f, 0.03198536f, -0.10763524f, -0.09915460f, 0.06422158f, -0.08393551f, -0.02594998f, 
    -0.07882648f, -0.19145580f, -0.06071171f, -0.03275076f, 0.23865880f, 0.05043246f, 0.23968782f, 0.27237788f, 
    0.27656177f, 0.22967233f, 0.07202744f, 0.17866920f, -0.05559768f, 0.18671207f, -0.09044775f, 0.08574340f, 
    0.25495148f, 0.16042419f, -0.19001338f, 0.17460755f, 0.03947661f, 0.22987591f, 0.20532265f, 0.04617081f, 
    -0.21114820f, 0.06274025f, 0.04536751f, -0.02941560f, -0.10492825f, 0.02064576f, -0.16650499f, -0.40085682f, 
    -0.22156858f, -0.02688571f, -0.03286102f, -0.06763156f, -0.05227819f, -0.07327312f, 0.00341387f, -0.04583453f, 
    0.07638934f, 0.29879341f, 0.00609494f, -0.11274105f, -0.23322044f, 0.05302586f, 0.10697459f, 0.01733121f, 
    -0.08872855f, 0.08218965f, -0.02797778f, 0.11765812f, 0.08651714f, -0.29227325f, 0.16349983f, -0.04150586f, 
    -0.10314276f, -0.00222390f, 0.03064359f, -0.00935676f, -0.08089820f, -0.06930469f, -0.16287735f, -0.12393891f, 
    -0.34523198f, -0.02462143f, 0.24203432f, -0.06995779f, 0.07827953f, 0.16505179f, 0.11593578f, 0.03212545f, 
    -0.18409137f, -0.00676559f, -0.08410151f, -0.10590690f, 0.17182653f, 0.29041487f, 0.25805867f, -0.18275738f, 
    -0.01684824f, 0.09336345f, 0.28831050f, 0.10664073f, -0.03740415f, 0.05445204f, -0.13743027f, 0.15006076f, 
    0.29609236f, 0.18135469f, 0.18171406f, 0.43205586f, -0.16878030f, -0.01666896f, 0.16508488f, 0.05704443f, 
    0.11062444f, 0.14223649f, 0.10829776f, -0.00909854f, 0.03871993f, 0.03838781f, 0.06399003f, 0.06339314f, 
    0.14165106f, 0.03407832f, 0.21745406f, 0.14090717f, 0.06375608f, 0.12707490f, -0.00654333f, 0.18249735f, 
    0.26721182f, 0.13370854f, 0.31771734f, 0.11218502f, 0.08348175f, 0.14184482f, 0.17339331f, -0.08350396f, 
    0.02566578f, 0.05751023f, 0.17133304f, 0.03632639f, 0.48804921f, -0.20726337f, -0.10580420f, 0.01497207f, 
    0.04154968f, -0.16967900f, -0.04317060f, -0.14136447f, -0.08789232f, -0.17186946f, -0.10251570f, 0.04534516f, 
    0.26886892f, -0.16327907f, 0.03389390f, -0.07060505f, -0.09322447f, -0.12917319f, 0.06022797f, 0.04912956f, 
    -0.05845566f, 0.14664263f, -0.10299082f, 0.07651923f, 0.39053577f, 0.04246073f, 0.16032040f, 0.01006736f, 
    0.00331392f, -0.07014848f, -0.00384088f, -0.18425915f, -0.20532532f, 0.12387791f, -0.03308993f, -0.02152459f, 
    -0.09015713f, -0.22207698f, 0.13677648f, 0.06264658f, -0.11898414f, -0.05136694f, 0.09933187f, 0.02718445f, 
    -0.01327820f, -0.18610190f, 0.13017584f, 0.05271000f, -0.15099627f, -0.35131004f, 0.18515432f, -0.03566774f, 
    -0.02373340f, -0.01609077f, -0.02683089f, -0.21602221f, -0.04288247f, -0.07398877f, -0.02086572f, 0.00257569f, 
    0.17641144f, 0.20063838f, 0.02064061f, 0.20009300f, -0.16956168f, -0.03481903f, -0.00326190f, 0.17825349f, 
    0.04820566f, 0.04123992f, -0.14313164f, -0.15840611f, -0.48232734f, 0.08319130f, 0.13227595f, 0.12379805f, 
    0.21132708f, 0.13101883f, 0.02824376f, 0.24566339f, -0.12065697f, -0.05863897f, 0.12099034f, 0.24584602f, 
    -0.09577262f, 0.07986026f, -0.07154759f, 0.07713838f, 0.10451103f, 0.25977641f, -0.21793833f, -0.02670062f, 
    0.00976766f, -0.07492486f, 0.04611949f, -0.09720698f, 0.15764295f, 0.19242656f, -0.01982804f, 0.09237581f, 
    -0.14497684f, 0.00461212f, 0.00350517f, 0.00105957f, 0.10568600f, -0.20371422f, 0.00017953f, -0.19866113f, 
    0.33945119f, 0.14749599f, 0.01138143f, -0.08066218f, -0.15962508f, -0.00791899f, -0.01340778f, 0.12403382f, 
    -0.23604794f, -0.02776534f, 0.12047856f, 0.11849549f, -0.19921392f, -0.24246992f, 0.13077386f, 0.01887190f, 
    -0.15024903f, 0.08482292f, -0.02251344f, 0.07473769f, 0.01356569f, 0.07903746f, 0.10774619f, 0.02307299f, 
    -0.07256199f, -0.04914648f, -0.02185940f, -0.05053340f, -0.07469143f, -0.00090358f, 0.02813811f, 0.02395893f, 
    0.05100190f, -0.02137592f, -0.01226646f, -0.00627907f, 0.00775828f, -0.00116321f, -0.02853552f, -0.01526797f, 
    -0.07062384f, -0.00634487f, -0.03715879f, -0.01498085f, 0.05549261f, -0.00395063f, -0.06258290f, 0.00089222f, 
    0.04704005f, -0.03213861f, -0.03787884f, -0.02025409f, -0.04168138f, -0.06470061f, -0.02293702f, -0.04717722f, 
    0.06210790f, 0.03783070f, -0.00128886f, 0.00648022f, -0.05855228f, -0.04981540f, 0.04168323f, -0.06659666f, 
    -0.00893627f, -0.00761106f, -0.01562976f, -0.03544166f, 0.01859458f, -0.01438244f, 0.02169561f, -0.06410959f, 
    -0.01303057f, 0.00004129f, 0.01547502f, -0.06868994f, 0.02477919f, -0.07004156f, -0.06560704f, -0.00019660f, 
    -0.05821228f, -0.05483471f, -0.03802676f, 0.02310914f, 0.00020616f, 0.01638222f, 0.01472016f, 0.00552517f, 
    -0.00763219f, -0.02002299f, -0.03697512f, -0.00564746f, 0.04585670f, 0.03176835f, -0.00731552f, -0.01062506f, 
    0.06345146f, 0.03827514f, 0.02998778f, 0.04012739f, -0.02256137f, -0.00927466f, -0.03967348f, -0.06236565f, 
    -0.03831484f, -0.00943292f, -0.04075808f, -0.07688178f, -0.05136579f, -0.01069206f, -0.01070074f, -0.00168337f, 
    0.06115554f, 0.06456594f, -0.05758862f, -0.01266159f, -0.05873847f, -0.02259151f, -0.01029329f, -0.03437865f, 
    -0.01093839f, 0.00671478f, -0.02445022f, 0.03405930f, -0.07092115f, -0.02127476f, -0.02750604f, -0.07278319f, 
    -0.01711372f, 0.03110021f, 0.01949583f, 0.00975090f, 0.04085960f, -0.01190277f, 0.05061047f, 0.00869924f, 
    0.06216346f, -0.03174119f, 0.04507023f, -0.02285015f, 0.04810531f, 0.01136793f, -0.07106123f, 0.00985357f, 
    0.03085431f, 0.01635982f, -0.01905627f, -0.01638881f, -0.05121575f, 0.03655216f, 0.01416574f, 0.04699646f, 
    -0.00571371f, -0.02258614f, -0.03036908f, -0.00861480f, -0.04004687f, 0.00330676f, -0.04015242f, -0.00788780f, 
    -0.05493702f, -0.00673321f, 0.01880861f, 0.05424283f, -0.03124881f, -0.06952939f, -0.02820864f, -0.03587747f, 
    0.03244996f, -0.04909125f, 0.02328023f, 0.05138296f, 0.04221105f, -0.01783554f, -0.06603514f, 0.00534867f, 
    -0.06965555f, -0.04271191f, -0.00152814f, 0.03638830f, 0.03174649f, -0.06871557f, -0.05602800f, -0.00488633f, 
    0.05992863f, 0.06541423f, 0.01303098f, -0.01216998f, 0.02421633f, -0.03995941f, 0.05480544f, -0.03747170f, 
    -0.03191933f, -0.06739002f, -0.05224352f, 0.04207698f, 0.03209025f, 0.00869482f, 0.03646343f, -0.00794151f, 
    0.04455703f, -0.01895320f, 0.06109444f, -0.01418210f, -0.05886848f, -0.02970465f, -0.02530026f, -0.01679369f, 
    -0.03593237f, 0.00667553f, -0.04020161f, -0.05054323f, -0.02577100f, -0.00803016f, -0.07085915f, -0.06944476f, 
    -0.02923249f, -0.19093847f, 0.26741418f, -0.15116550f, 0.03063054f, 0.02013660f, 0.19226892f, -0.01521915f, 
    -0.07144197f, -0.11717388f, -0.08796330f, -0.27458733f, 0.08579160f, -0.05563496f, -0.03252100f, -0.02215988f, 
    0.10584739f, 0.14672227f, -0.02176760f, -0.03032810f, -0.05353884f, -0.14788678f, -0.15313147f, 0.02317096f, 
    0.03895313f, 0.26803583f, 0.06467173f, -0.16149023f, 0.06329648f, 0.05524455f, 0.04338525f, 0.05160356f, 
    0.02965340f, 0.16026601f, 0.18716539f, 0.04055766f, -0.15520816f, -0.24412896f, -0.04559045f, 0.12216306f, 
    -0.02563125f, 0.04609672f, 0.11072329f, 0.10034209f, 0.05028343f, 0.08677121f, -0.05710685f, 0.13202301f, 
    0.27424106f, -0.35340747f, -0.25475609f, 0.12948595f, -0.03183058f, 0.07535478f, 0.00956376f, 0.15282805f, 
    0.01569993f, 0.01693265f, 0.10772417f, -0.06843153f, 0.13530363f, -0.06219659f, -0.31166384f, 0.11272815f, 
    -0.14344229f, 0.05176508f, 0.16262856f, 0.16050045f, -0.12937407f, 0.14814650f, 0.05161546f, 0.06294905f, 
    0.08802798f, -0.15170321f, -0.06420118f, -0.19663556f, -0.24661000f, -0.01932841f, 0.08390380f, -0.19135517f, 
    0.05751897f, 0.09308568f, 0.16829205f, -0.07886314f, -0.16206777f, 0.38226333f, 0.13519685f, 0.17751354f, 
    0.05793021f, -0.04075725f, 0.09963899f, -0.05026256f, -0.15550204f, -0.02297698f, 0.01655004f, 0.12768088f, 
    -0.11839372f, -0.03244388f, -0.16537246f, -0.06376015f, -0.07681294f, 0.06648153f, 0.03534085f, -0.11148748f, 
    0.05527490f, -0.08123031f, 0.10536014f, 0.04645192f, -0.02880303f, 0.05520968f, 0.11368103f, -0.10323556f, 
    0.08936901f, 0.08718816f, -0.00946613f, -0.06124150f, 0.13603982f, -0.08080383f, 0.04224855f, 0.01836482f, 
    0.11435081f, 0.17798331f, 0.16983329f, -0.08142241f, 0.00544867f, -0.01534224f, -0.03215284f, -0.06259116f, 
    0.09942855f, 0.02914433f, 0.07969087f, 0.04421588f, -0.13826114f, -0.05361794f, -0.11001024f, 0.32660371f, 
    -0.03577817f, -0.19154666f, -0.00972601f, 0.09452595f, -0.11403850f, -0.14646798f, 0.21444105f, 0.01747492f, 
    0.04137264f, 0.01702324f, 0.04950902f, -0.21467753f, 0.08527362f, -0.02972484f, -0.13127843f, -0.04632815f, 
    0.04682196f, 0.01275190f, -0.03054340f, 0.11607447f, 0.13450010f, 0.21637322f, 0.12441668f, -0.09639142f, 
    0.22372521f, 0.22010276f, -0.16486003f, 0.08993839f, -0.10228600f, -0.05818784f, -0.05417026f, -0.19242311f, 
    0.20258807f, 0.08599188f, 0.19991043f, 0.24500415f, 0.20081751f, 0.00125102f, 0.08424343f, 0.02425846f, 
    0.04360327f, 0.00657566f, 0.05381548f, 0.04789936f, 0.15906985f, 0.01114818f, 0.11734319f, -0.22914356f, 
    0.03928469f, 0.14796953f, 0.09761308f, -0.15505138f, -0.02862608f, 0.16384904f, -0.06952629f, 0.08493682f, 
    0.23878706f, -0.29551426f, -0.31159991f, -0.07197950f, -0.08009645f, -0.05773258f, 0.04730008f, 0.02014090f, 
    -0.10799262f, -0.03592128f, 0.00400385f, 0.02624347f, -0.07594535f, 0.08953281f, 0.13356805f, -0.03701309f, 
    -0.20284146f, -0.02922739f, 0.01522432f, 0.01148306f, 0.14296646f, -0.16397949f, -0.15091868f, -0.01865617f, 
    0.20210156f, 0.10695101f, 0.19709167f, -0.09976630f, -0.05538139f, 0.09091593f, 0.12377366f, 0.08383482f, 
    -0.01836178f, 0.01557351f, -0.05377323f, -0.00783337f, 0.10209052f, -0.14357516f, -0.12148471f, -0.12648240f, 
    0.08852130f, -0.04684152f, -0.01992078f, 0.18204778f, 0.12490211f, 0.08580574f, -0.03822423f, 0.22201534f, 
    0.26737052f, -0.22400497f, -0.14813213f, 0.09425702f, 0.12909979f, 0.11630467f, -0.02315144f, -0.00121772f, 
    -0.01171819f, 0.10300333f, 0.11551048f, 0.00847189f, -0.42542580f, -0.29247886f, -0.04675539f, 0.04265351f, 
    0.09680334f, 0.04629510f, 0.17806782f, 0.15115593f, 0.01959941f, 0.12264691f, 0.00556510f, 0.12019047f, 
    0.04597387f, 0.18455890f, 0.08076959f, -0.07774846f, -0.08027015f, -0.12580314f, 0.00926540f, -0.17810433f, 
    0.15715936f, 0.04542197f, 0.15079100f, 0.00574353f, 0.15998296f, -0.06628352f, 0.08894569f, 0.16933599f, 
    0.05268675f, -0.05404001f, 0.03126503f, -0.03184453f, -0.04379007f, 0.03007041f, -0.12148848f, 0.20363067f, 
    0.07762302f, -0.13974155f, 0.13219064f, -0.15432148f, 0.19094284f, 0.17303811f, 0.06321475f, -0.04733884f, 
    -0.19886340f, -0.16127127f, 0.11475568f, 0.05580664f, -0.13368122f, 0.15469888f, -0.11070807f, -0.11608676f, 
    0.12566468f, 0.09131024f, 0.11810503f, 0.00613889f, 0.02293781f, -0.11049285f, -0.03465263f, 0.03876578f, 
    0.04579121f, 0.12938485f, 0.15280990f, 0.04709321f, -0.23869285f, -0.03149583f, 0.13082469f, 0.03846065f, 
    -0.07665100f, 0.09709982f, 0.05468597f, 0.09170234f, 0.25042200f, -0.32128236f, -0.23123588f, -0.26308045f, 
    -0.08083703f, -0.08228661f, 0.05777107f, -0.05350587f, 0.06630541f, 0.13255492f, 0.06076774f, 0.01794207f, 
    0.30982080f, 0.25325403f, -0.12368874f, 0.40910587f, -0.03409801f, -0.04624930f, -0.16603777f, 0.04957662f, 
    0.12338631f, 0.07003795f, 0.15420565f, 0.05302424f, -0.07368839f, 0.18983035f, -0.03006133f, -0.13181195f, 
    0.05571187f, -0.04696821f, 0.00444843f, 0.07351546f, -0.03258731f, 0.04359857f, -0.12209618f, -0.17983143f, 
    0.11759942f, -0.13261010f, 0.25858337f, 0.10570121f, 0.02797060f, -0.06967481f, 0.12731774f, 0.13172506f, 
    0.01521595f, -0.02151882f, -0.04702171f, -0.02635329f, -0.20319632f, 0.21503045f, -0.01175469f, -0.11559848f, 
    0.01698164f, 0.05458939f, 0.15393429f, 0.01948400f, -0.09583884f, 0.15513201f, -0.01745552f, -0.01391752f, 
    -0.14392613f, 0.40984645f, -0.14296463f, 0.06271028f, 0.16280444f, 0.03253044f, -0.00126634f, -0.01281591f, 
    -0.00109393f, 0.13256118f, -0.15058941f, -0.28276414f, 0.03559006f, -0.00587619f, 0.25980419f, 0.06619488f, 
    0.10209484f, -0.00043837f, 0.13678031f, 0.21287417f, 0.07847177f, -0.01433518f, -0.03740547f, 0.01436761f, 
    -0.02942387f, 0.25717568f, 0.26156393f, -0.30449674f, -0.07016718f, 0.04271960f, 0.13400304f, 0.10303786f, 
    0.04936679f, 0.06101450f, 0.07207143f, -0.02530699f, 0.13205270f, -0.06442483f, -0.09593421f, 0.26924524f, 
    0.13644455f, 0.07742991f, 0.20134450f, 0.15916377f, -0.04110714f, 0.21929133f, -0.00658961f, 0.24194449f, 
    -0.18569753f, -0.13441111f, 0.02723144f, 0.00329556f, -0.01397362f, 0.07662563f, 0.10004365f, 0.03147808f, 
    -0.02610822f, 0.05778262f, 0.14057304f, 0.06070011f, 0.10376436f, -0.10638519f, 0.15220821f, 0.25676689f, 
    0.02400613f, -0.07006485f, -0.02912237f, -0.06383089f, -0.09221436f, -0.05710341f, -0.05834451f, 0.01898149f, 
    0.30641487f, 0.13285886f, -0.10209304f, 0.39021730f, 0.00046838f, -0.01956241f, 0.01843149f, -0.06498417f, 
    -0.04109035f, 0.15971437f, 0.15881206f, 0.01857523f, 0.03856176f, 0.15626134f, 0.02184644f, 0.05231632f, 
    0.00361388f, -0.00758818f, 0.06893232f, -0.10114474f, -0.08394241f, 0.20366725f, -0.07223783f, 0.08023464f, 
    0.01320576f, -0.14090940f, -0.11340835f, 0.28927583f, -0.13746485f, 0.04443159f, -0.20503320f, 0.10413528f, 
    -0.15072677f, -0.05612389f, 0.05258445f, 0.02600476f, 0.14103641f, -0.23741564f, 0.16484414f, 0.26287720f, 
    -0.01642284f, -0.05276924f, -0.04101749f, -0.11345388f, -0.24753052f, -0.12971328f, -0.03759983f, -0.04933406f, 
    0.09111959f, 0.19609666f, -0.12369619f, -0.36552912f, -0.03400294f, -0.03410815f, -0.02244261f, 0.09722739f, 
    0.00733437f, 0.08234317f, -0.04762007f, -0.18150292f, -0.15123361f, 0.06943648f, 0.05219772f, -0.01895693f, 
    0.16657414f, 0.33641714f, 0.03099812f, 0.02465395f, 0.08212674f, 0.03433922f, 0.03652975f, 0.19202702f, 
    0.17645262f, 0.01598812f, 0.00223383f, 0.04343285f, 0.14689486f, 0.21193661f, 0.15898946f, 0.03667715f, 
    -0.10216004f, 0.05993591f, 0.16464017f, -0.05507577f, -0.06356782f, 0.21717677f, -0.03568705f, -0.18972066f, 
    -0.14120582f, -0.08540391f, -0.01373301f, -0.01259253f, 0.02489795f, -0.19911906f, -0.07894719f, -0.08594754f, 
    -0.35891563f, 0.25834361f, 0.01535707f, 0.07443072f, -0.06966966f, 0.21033788f, -0.01608963f, 0.08152317f, 
    -0.06598425f, 0.01307008f, 0.13418481f, -0.02861611f, 0.09386972f, -0.18288729f, 0.32512110f, 0.08632910f, 
    -0.07240813f, 0.00080833f, -0.05904551f, 0.04353274f, 0.03299276f, 0.07001302f, -0.07173444f, -0.03742364f, 
    0.41365373f, -0.20488302f, -0.16393587f, -0.23965472f, -0.09867352f, 0.03293073f, 0.04574877f, 0.00323877f, 
    -0.06409591f, -0.11817048f, 0.05380001f, 0.25968105f, -0.01701080f, 0.18966362f, -0.04226110f, -0.14493670f, 
    -0.05845902f, 0.12674986f, 0.01309262f, 0.06590819f, 0.05563737f, -0.01180534f, -0.08404572f, 0.01533186f, 
    0.02192901f, -0.19720457f, -0.00174600f, 0.15051085f, 0.07560936f, 0.11065719f, 0.05389518f, -0.04240694f, 
    0.04383479f, -0.01014333f, -0.02785891f, -0.01906064f, 0.05793472f, 0.06310835f, -0.00656239f, -0.22535625f, 
    0.07370347f, -0.20396553f, -0.03855914f, 0.16755909f, 0.01878759f, -0.06242274f, -0.06507197f, 0.02856236f, 
    0.44936329f, 0.10849778f, -0.14108016f, 0.02027325f, 0.14075164f, 0.06842485f, -0.09577859f, -0.02882008f, 
    -0.03683768f, 0.10569019f, 0.03293057f, 0.03590792f, -0.10177238f, -0.21539587f, -0.06462464f, -0.21476600f, 
    0.26270926f, 0.04475605f, 0.06962457f, 0.08703257f, 0.09803850f, 0.08956197f, -0.05803673f, 0.13213727f, 
    -0.06394548f, 0.13655101f, 0.05257372f, -0.11199518f, 0.06778467f, -0.07405524f, 0.01399124f, -0.16289392f, 
    -0.00041491f, 0.10298233f, 0.03790387f, 0.00074910f, 0.01388106f, -0.29061067f, -0.03256929f, 0.17736180f, 
    -0.00036011f, 0.07510071f, -0.06932183f, 0.01303408f, 0.08560897f, 0.05507277f, -0.05833687f, 0.19527955f, 
    0.04932143f, 0.03636951f, 0.25764281f, -0.13905062f, 0.09272535f, 0.16844875f, 0.18835239f, -0.02658950f, 
    -0.10435165f, -0.01603669f, 0.06175979f, -0.09083114f, -0.34674802f, 0.08987180f, -0.08267795f, -0.21823575f, 
    0.17866524f, 0.18332730f, 0.06178271f, 0.09879047f, -0.02819187f, -0.01046152f, 0.01222391f, 0.12789012f, 
    -0.25234011f, 0.00967127f, 0.01486791f, 0.27278942f, -0.02828645f, 0.06802026f, 0.11662825f, -0.07518712f, 
    -0.08353073f, 0.05850026f, 0.08576259f, 0.02062557f, 0.63266855f, -0.29303589f, -0.00281168f, -0.38290873f, 
    -0.09569758f, -0.17279041f, 0.03456476f, -0.01833910f, 0.05285756f, -0.09152773f, 0.02655607f, -0.05662270f, 
    0.31255719f, 0.14077497f, -0.01630596f, 0.40389842f, -0.11827275f, -0.13366960f, -0.15613471f, -0.03336865f, 
    0.01028174f, -0.09434652f, 0.03175494f, -0.00048508f, -0.08344445f, 0.10262892f, 0.16086234f, 0.07039104f, 
    0.04444406f, -0.04301297f, 0.04866546f, 0.04947509f, 0.03481868f, 0.04445961f, 0.00762031f, -0.05878959f, 
    0.08207198f, -0.26342279f, 0.11464092f, 0.00557647f, -0.09518594f, -0.04811145f, 0.14835778f, 0.14085427f, 
    0.10884109f, 0.03699449f, -0.12338236f, 0.14818110f, -0.26818779f, 0.00735116f, 0.02097310f, 0.00556214f, 
    0.08832110f, -0.02234006f, 0.10240851f, -0.11198577f, -0.09924167f, -0.01636557f, -0.10426641f, 0.03556568f, 
    -0.10759047f, 0.14094014f, -0.08083288f, 0.11535945f, -0.05039483f, -0.10957368f, -0.12450518f, 0.02118335f, 
    0.00889356f, 0.05684405f, -0.07821291f, -0.17972553f, -0.11212251f, -0.11293360f, 0.10051966f, 0.22406431f, 
    -0.00160786f, -0.05005262f, 0.10212386f, 0.18810073f, 0.05595056f, 0.02471526f, -0.02418059f, 0.09140079f, 
    -0.32614344f, 0.13114738f, -0.20431840f, -0.22516529f, 0.04029272f, 0.01724230f, 0.13386737f, -0.08398953f, 
    0.09955171f, 0.07918072f, -0.08041993f, 0.15561403f, -0.07890224f, 0.31362644f, -0.08997338f, 0.13527711f, 
    -0.16485576f, 0.00052451f, 0.07062626f, -0.05335117f, 0.08988782f, 0.20976254f, 0.09638163f, 0.00686899f, 
    -0.66966075f, 0.26871037f, -0.03228384f, -0.37204674f, -0.09040795f, 0.03287069f, 0.17563479f, 0.04051847f, 
    0.01914177f, 0.06225257f, -0.03291432f, -0.08352118f, -0.02323267f, 0.18793851f, -0.00874807f, 0.15749091f, 
    -0.03705072f, 0.05466989f, 0.06680379f, -0.01070618f, 0.13689362f, -0.05489773f, -0.03256951f, 0.05257418f, 
    0.01727933f, -0.16637541f, 0.10552668f, 0.16940400f, 0.06021446f, 0.05515494f, -0.01514422f, 0.11026348f, 
    -0.06256788f, 0.05579919f, -0.11266201f, 0.03589723f, 0.01968492f, -0.11429159f, 0.03953031f, -0.05158439f, 
    0.06093023f, -0.01014641f, 0.05621962f, 0.07850053f, 0.02989745f, 0.01701577f, 0.10006451f, -0.07464302f, 
    0.34060234f, 0.11876902f, 0.03814651f, 0.29377928f, -0.07056323f, -0.13252378f, -0.12751888f, 0.08198737f, 
    0.12103609f, 0.04828708f, 0.01893363f, 0.05345822f, 0.19050814f, 0.05051584f, -0.00334916f, 0.37349597f, 
    -0.07217406f, -0.01325228f, -0.12249689f, 0.11636758f, -0.02168369f, -0.03131671f, 0.01600135f, -0.04755622f, 
    -0.05319426f, -0.28351563f, -0.09010742f, -0.15292323f, 0.23208812f, 0.06076578f, 0.01781551f, 0.08903515f, 
    0.14549527f, 0.05388230f, -0.00332876f, 0.00766614f, -0.14706808f, 0.17651828f, -0.18316810f, 0.16062726f, 
    -0.18469700f, -0.10583635f, 0.03278527f, 0.01184079f, -0.00520362f, 0.06744133f, 0.14462417f, -0.02534102f, 
    0.01862063f, -0.19137001f, -0.11585992f, -0.27812427f, 0.05967655f, 0.13930221f, 0.09246451f, -0.00132436f, 
    0.08145367f, 0.00909487f, 0.02690061f, 0.03056678f, 0.14485508f, -0.22513981f, -0.18656054f, 0.23649216f, 
    0.01443927f, 0.02239503f, 0.06722676f, -0.05951025f, 0.01122957f, -0.11190253f, 0.02714552f, 0.00467229f, 
    -0.11288635f, -0.33952811f, -0.13053383f, -0.09650283f, -0.03906218f, 0.11480179f, 0.01661407f, -0.07887661f, 
    -0.06042238f, 0.07070613f, 0.03707851f, -0.01026535f, 0.30495018f, 0.27785975f, 0.17200026f, 0.29895461f, 
    0.00538425f, 0.21603203f, 0.09175278f, 0.22374086f, 0.02601261f, 0.01091037f, 0.01155707f, 0.02724369f, 
    -0.05800580f, -0.09443991f, 0.02204503f, 0.25021622f, -0.16373712f, 0.01725458f, 0.11489023f, 0.01613735f, 
    0.09421689f, -0.10674778f, -0.00387672f, 0.23115478f, -0.16045311f, 0.23838109f, -0.12210272f, -0.34669393f, 
    0.01334408f, 0.15028393f, -0.01065345f, -0.20339561f, 0.01335164f, 0.14326952f, 0.09926175f, 0.06739174f, 
    0.24604768f, -0.11103034f, -0.05284227f, 0.53181672f, 0.11511640f, 0.06160628f, -0.01335189f, -0.00018347f, 
    0.04343793f, -0.03412907f, -0.03364471f, -0.08279896f, 0.20798886f, 0.16699298f, 0.00954342f, -0.17411299f, 
    -0.04234236f, -0.03593864f, 0.06858998f, -0.05503947f, -0.06217903f, -0.16556992f, 0.11593507f, -0.07052370f, 
    0.42275643f, 0.42814204f, 0.14357701f, 0.13531306f, 0.15783130f, 0.01481676f, -0.04731752f, -0.02374580f, 
    0.09483141f, -0.05037234f, -0.00931075f, 0.00385785f, 0.45648164f, 0.40819934f, -0.18696216f, -0.20382501f, 
    -0.04601245f, 0.07006817f, -0.07732830f, 0.10605362f, -0.01055241f, 0.00348946f, -0.14665742f, 0.04406007f, 
    -0.30891323f, -0.26457962f, 0.13169432f, -0.20770696f, 0.14677706f, 0.00115597f, 0.07072853f, -0.01828018f, 
    0.08439739f, -0.19385459f, -0.10800142f, 0.16290407f, -0.03221848f, 0.01357854f, 0.23547390f, -0.14079633f, 
    0.00602199f, -0.03732686f, -0.20430611f, 0.08331117f, 0.08381384f, 0.04769486f, 0.07193883f, 0.00608977f, 
    -0.29094791f, -0.28614131f, 0.10797671f, -0.19988218f, 0.22783303f, 0.07885591f, 0.34467459f, 0.00555529f, 
    -0.04798658f, 0.07166268f, -0.01857545f, 0.01581998f, -0.48154140f, 0.07387875f, -0.04491386f, -0.15271053f, 
    -0.08155053f, 0.14556985f, 0.18080454f, -0.03429630f, 0.10958058f, 0.00912171f, 0.11222530f, 0.13530713f, 
    0.04614233f, 0.08822005f, 0.12593238f, 0.46306247f, 0.05104020f, 0.04050408f, -0.02737795f, -0.03920771f, 
    -0.02592299f, 0.03657342f, -0.02230878f, -0.03640635f, 0.15990505f, 0.04302641f, 0.05222823f, 0.13260101f, 
    -0.09154264f, -0.08841398f, -0.05163779f, 0.19831547f, 0.06697752f, -0.04516023f, -0.15828030f, -0.08454721f, 
    -0.34871170f, -0.18831675f, -0.11913165f, -0.00105376f, -0.08714206f, 0.06867696f, -0.02366763f, -0.05193926f, 
    0.10410193f, 0.00893982f, -0.17619121f, -0.02955927f, -0.02043966f, 0.24407101f, 0.26354817f, 0.22594599f, 
    0.05768758f, 0.02212075f, -0.02135953f, 0.00684785f, 0.10562718f, 0.06861637f, 0.18996800f, 0.01961967f, 
    0.48810926f, -0.13275523f, -0.02895079f, -0.32158127f, -0.09369577f, -0.14260219f, 0.08215174f, -0.06384461f, 
    -0.12026090f, -0.07261546f, -0.02081400f, 0.09976214f, -0.23071879f, -0.07287136f, -0.38415965f, -0.04398215f, 
    0.01750014f, 0.06983199f, -0.04104518f, -0.11751625f, -0.13807908f, -0.18558516f, -0.08437858f, -0.02322617f, 
    -0.01463713f, -0.39350176f, 0.13697697f, -0.20808560f, -0.00221807f, -0.00199449f, -0.10470467f, 0.13558871f, 
    -0.01445383f, -0.15954764f, 0.11870605f, 0.06145463f, 0.09413416f, 0.16477004f, -0.04397178f, -0.00459298f, 
    -0.14932656f, 0.08979202f, -0.03094747f, -0.08153506f, 0.00624118f, 0.01023569f, 0.03248247f, -0.00869553f, 
    0.39454320f, -0.17945717f, -0.26590821f, 0.28783080f, -0.02018691f, -0.13445584f, -0.01245116f, -0.20335984f, 
    -0.00147205f, -0.03431728f, -0.02105043f, -0.04436571f, 0.07091866f, 0.19575699f, -0.04313571f, -0.24503027f, 
    -0.04236610f, 0.06173507f, -0.10191494f, 0.03033555f, 0.03872316f, -0.01235709f, 0.02802131f, -0.01183408f, 
    0.20852794f, 0.25544754f, 0.22916178f, -0.06023755f, -0.07057865f, -0.02695298f, -0.03887643f, -0.07384077f, 
    0.03152685f, 0.05341822f, -0.00381815f, -0.11311547f, -0.23811607f, -0.06992969f, 0.11641596f, -0.11699750f, 
    0.00432439f, -0.04990712f, -0.02788794f, -0.06514689f, 0.15782994f, 0.02603588f, -0.07268663f, -0.01788338f, 
    0.00798492f, -0.03747419f, -0.01130271f, -0.24383375f, -0.14461371f, 0.03883388f, 0.06375069f, 0.10368226f, 
    0.14013612f, -0.02258880f, -0.14856575f, 0.02988315f, 0.40969688f, 0.07331090f, -0.07977041f, -0.15823610f, 
    -0.01786493f, -0.02525201f, -0.01812490f, 0.13622436f, 0.01787675f, 0.03778240f, 0.03269642f, -0.03897753f, 
    -0.05095847f, 0.05837379f, 0.14614262f, -0.19490810f, 0.12010399f, -0.11948507f, 0.10018849f, -0.01108252f, 
    0.04807742f, 0.01096861f, 0.06296192f, -0.11097071f, 0.30736950f, 0.32960713f, -0.28513369f, 0.05362444f, 
    -0.17095421f, 0.16695349f, 0.03632342f, 0.03357884f, 0.03162319f, 0.00791006f, 0.02006316f, -0.02187146f, 
    0.34628382f, -0.27818137f, 0.01005839f, 0.53291470f, 0.01464403f, -0.01220766f, 0.03237581f, 0.01432548f, 
    -0.03109353f, 0.02093792f, -0.04192096f, -0.04108485f, -0.06534301f, 0.17756422f, -0.12573645f, -0.04141779f, 
    0.16007842f, -0.15312865f, 0.18469203f, 0.17964540f, 0.03819527f, -0.00734362f, -0.02429501f, 0.04038488f, 
    -0.17135794f, 0.17265087f, 0.07454784f, 0.12560654f, -0.07592976f, -0.01409049f, -0.02158246f, -0.03463071f, 
    0.13539031f, -0.11070758f, 0.10837188f, -0.01666633f, 0.41259643f, -0.27999285f, -0.12945548f, 0.43421575f, 
    0.01015963f, 0.00645067f, 0.06048081f, 0.02955259f, -0.03444076f, 0.02066388f, -0.00064830f, 0.03130599f, 
    0.62328744f, -0.11974449f, -0.12077516f, -0.20477811f, 0.04426660f, -0.12517233f, -0.06568100f, 0.10037548f, 
    -0.09756786f, -0.02638403f, 0.02737257f, 0.05530137f, 0.03880658f, 0.21462037f, -0.41004401f, 0.14985973f, 
    -0.00001469f, -0.05066475f, -0.05725228f, 0.14976290f, 0.05184471f, -0.11659402f, 0.21379475f, 0.06254325f, 
    -0.04400154f, -0.03732725f, -0.06252487f, 0.02238043f, -0.02076751f, -0.02737661f, 0.03481428f, -0.02822939f, 
    -0.03916375f, -0.00570094f, 0.01617276f, 0.02956405f, -0.00131142f, 0.06442036f, -0.00315263f, -0.03422578f, 
    0.02337098f, 0.04551434f, -0.00326452f, -0.05749577f, -0.00907122f, -0.05324705f, -0.00345049f, -0.06186985f, 
    0.05202891f, -0.00886011f, 0.00535399f, -0.01440616f, 0.06515625f, -0.03664496f, -0.00109623f, -0.00518906f, 
    0.02046941f, -0.07875406f, 0.03518577f, 0.05802359f, 0.04906364f, 0.03539899f, -0.01541683f, -0.05585692f, 
    0.00277447f, -0.04480805f, 0.04517832f, -0.02151433f, 0.03898959f, -0.00029770f, -0.01453373f, -0.04482732f, 
    -0.04268903f, -0.02963095f, 0.05330934f, -0.07078496f, -0.05982621f, -0.03463038f, 0.00101549f, 0.04549420f, 
    0.06309428f, 0.01998198f, -0.00913459f, -0.00195278f, -0.06531376f, -0.03175959f, 0.01046613f, 0.02297080f, 
    -0.00358031f, -0.07158910f, -0.07651525f, -0.03040833f, -0.03952515f, -0.00609629f, 0.02915176f, -0.00623078f, 
    0.01882515f, 0.05747610f, -0.02655649f, -0.02513168f, 0.03815686f, 0.03382059f, 0.04861518f, -0.04407563f, 
    -0.04268338f, -0.01394250f, -0.00057141f, -0.05612407f, 0.04964901f, -0.02588649f, 0.02258583f, -0.01782157f, 
    -0.06348162f, -0.02208592f, 0.01480462f, -0.01155812f, -0.04250096f, 0.03945391f, 0.00674197f, -0.05499040f, 
    -0.03878802f, -0.03285996f, -0.06796611f, 0.04404413f, 0.05325055f, 0.05204399f, -0.02484384f, 0.04103089f, 
    0.05888950f, -0.03684242f, -0.02987938f, 0.01184305f, -0.02705888f, -0.00890689f, 0.02007886f, 0.00924408f, 
    -0.00974781f, -0.04208593f, 0.03511755f, 0.00083314f, -0.06773123f, 0.06399973f, -0.05500879f, 0.03770700f, 
    -0.01078158f, 0.06059648f, 0.02877457f, -0.04592393f, 0.05054491f, -0.03206323f, -0.06864415f, -0.05851980f, 
    0.03884327f, 0.05451994f, -0.01004736f, 0.04846175f, -0.02794783f, 0.02113190f, -0.02906921f, -0.06064476f, 
    -0.06413587f, -0.00550015f, -0.06175275f, -0.06193045f, -0.04011094f, 0.02672883f, 0.06312381f, 0.06267459f, 
    -0.07639294f, -0.00829165f, 0.02899971f, 0.05014030f, -0.01594961f, -0.03159314f, -0.01221774f, -0.02816888f, 
    0.00132861f, -0.00138824f, 0.03849181f, -0.04576620f, -0.00537193f, -0.02174201f, -0.00858929f, -0.06339114f, 
    -0.06645896f, 0.01950829f, -0.02750224f, 0.01021906f, -0.04609096f, -0.07586277f, -0.04292597f, -0.02418346f, 
    -0.03850994f, -0.03820018f, 0.05885044f, -0.04581914f, -0.01597516f, 0.02174767f, -0.00216697f, -0.01774897f, 
    -0.06995203f, -0.06967383f, -0.01465238f, -0.06587465f, 0.02920155f, -0.07561554f, 0.00684425f, 0.06407018f, 
    0.02674667f, 0.06424316f, -0.07531752f, -0.06307267f, -0.04412384f, 0.05084772f, 0.00129455f, 0.00924220f, 
    0.46193221f, 0.20159306f, -0.22811781f, 0.09598958f, -0.10649937f, -0.04724612f, 0.21431413f, 0.06408151f, 
    -0.03200791f, 0.10692596f, -0.09906796f, 0.09296222f, -0.20529774f, 0.05425120f, -0.05097997f, -0.05088665f, 
    0.01879234f, -0.09133910f, -0.02847667f, -0.02311639f, 0.14227904f, -0.14795206f, 0.01303539f, -0.12923115f, 
    0.16699658f, 0.23942472f, 0.02608282f, -0.28595817f, -0.04304546f, -0.01841446f, -0.01997805f, 0.08898078f, 
    -0.03946796f, 0.01071889f, -0.03420397f, -0.11982518f, 0.10266729f, 0.06073526f, -0.08819409f, -0.20369036f, 
    0.09691259f, -0.10902351f, 0.03476213f, 0.02211737f, -0.00984735f, -0.06405394f, -0.03404173f, 0.13287760f, 
    0.14354624f, -0.24285775f, -0.14164153f, -0.00007049f, 0.05455298f, 0.07748959f, -0.01222595f, 0.07295155f, 
    -0.01725057f, 0.15376946f, 0.15517820f, 0.09807725f, -0.54779798f, 0.10083659f, -0.05296060f, 0.22536050f, 
    0.11274883f, 0.15271121f, 0.22116163f, 0.22298454f, -0.04862181f, 0.10569920f, -0.07388788f, 0.03440641f, 
    -0.31188187f, 0.20239519f, 0.01399064f, 0.23991883f, -0.06264594f, -0.01145655f, -0.00131863f, -0.10766371f, 
    -0.07285806f, -0.07687905f, 0.22353473f, -0.08633089f, -0.11846912f, -0.12410031f, -0.00970552f, -0.02788369f, 
    -0.02192836f, 0.05773473f, 0.01774833f, -0.06325067f, 0.08939803f, -0.00437665f, -0.06506814f, 0.17769988f, 
    0.20568506f, 0.06000945f, -0.03452044f, -0.04695893f, 0.20058200f, 0.00812653f, -0.00946578f, 0.03867490f, 
    -0.22737232f, -0.06306972f, 0.13098416f, -0.04681830f, -0.07383498f, 0.38039547f, -0.12796149f, 0.00112395f, 
    0.15689461f, 0.06582949f, 0.02203780f, 0.18136574f, 0.12043678f, 0.01462201f, -0.03518096f, 0.08135485f, 
    0.07414728f, 0.17925376f, -0.03446414f, 0.00606927f, -0.13326947f, -0.08568592f, 0.07412722f, -0.08928927f, 
    -0.02331592f, 0.10475026f, 0.09514212f, 0.04683372f, 0.64098006f, -0.02047491f, -0.05725596f, -0.38998166f, 
    -0.04725864f, 0.00281821f, 0.01819458f, -0.23362108f, 0.06753121f, -0.08353802f, 0.07481973f, 0.07775213f, 
    0.01007535f, 0.06544018f, 0.10623358f, 0.04036601f, -0.02929408f, -0.16811953f, -0.03734573f, 0.02818850f, 
    0.14877544f, -0.02511044f, 0.01354312f, 0.13201521f, -0.22002612f, 0.13263199f, 0.13422966f, 0.01615856f, 
    0.04147046f, -0.06875829f, 0.01824706f, 0.05770540f, -0.01004905f, 0.07389631f, -0.05726545f, 0.00445165f, 
    -0.17034566f, -0.28864232f, -0.10869502f, 0.14479116f, 0.14214273f, 0.01305854f, 0.02721683f, 0.03441134f, 
    0.04952886f, -0.01245456f, -0.20984262f, -0.01588690f, 0.03543710f, 0.34683400f, -0.20269415f, -0.07894756f, 
    0.08669979f, 0.08440630f, 0.04172085f, -0.05986014f, -0.04875324f, 0.16782096f, -0.14341739f, -0.06970785f, 
    0.30441535f, -0.07129985f, 0.12355842f, 0.07731717f, -0.05722702f, 0.00631437f, 0.17897305f, 0.05523078f, 
    -0.04197051f, -0.04032376f, 0.01302962f, 0.14638612f, -0.28891602f, 0.06255996f, -0.02788531f, -0.20918500f, 
    -0.10939609f, 0.12594213f, -0.05332607f, -0.11752325f, -0.03136801f, 0.08405113f, 0.01762547f, 0.00439143f, 
    -0.09652722f, -0.14929403f, -0.31498605f, 0.25018263f, -0.02122389f, -0.00536224f, -0.01679974f, 0.02652469f, 
    0.05366897f, -0.07767037f, -0.13918467f, -0.05745388f, 0.15470317f, 0.28501332f, 0.11946934f, -0.20980974f, 
    -0.15618606f, -0.03120225f, 0.02274569f, 0.03497606f, 0.04914165f, -0.06275041f, 0.01620034f, -0.11689114f, 
    0.37863147f, 0.19726789f, 0.03203262f, -0.08659760f, 0.08054083f, 0.19540606f, 0.08959207f, 0.13621500f, 
    -0.13063139f, 0.08053733f, -0.02585706f, -0.02543971f, -0.31533465f, 0.17842026f, -0.09648535f, -0.36040410f, 
    -0.11558619f, 0.12386955f, 0.04469794f, 0.23396327f, 0.05290339f, 0.13431248f, 0.00220342f, 0.03631960f, 
    -0.04084915f, -0.03582885f, 0.17612027f, -0.29548809f, -0.17382005f, 0.02359316f, 0.26478773f, -0.11523180f, 
    -0.00118235f, -0.01415331f, -0.00591117f, -0.08144131f, -0.17971058f, 0.05040178f, -0.01285155f, -0.11465020f, 
    0.03865656f, 0.00584838f, 0.00586628f, -0.04116229f, -0.06053877f, -0.05439052f, 0.01173210f, 0.25713345f, 
    0.22223556f, 0.15588312f, 0.02959779f, -0.06055253f, 0.04710583f, 0.14113362f, 0.24887095f, 0.05598114f, 
    0.09223864f, 0.10683814f, 0.06771803f, -0.01649533f, 0.09612092f, 0.00582014f, -0.05469730f, -0.10775188f, 
    -0.05504984f, 0.08162789f, 0.11107647f, -0.05972533f, 0.28700835f, 0.08562149f, -0.08089086f, 0.16743821f, 
    -0.01129998f, -0.14136679f, -0.07093564f, 0.17671092f, 0.07487912f, -0.02870466f, 0.03905733f, -0.00024656f, 
    0.00444579f, -0.01711493f, -0.04343175f, 0.11704945f, 0.11868316f, 0.08853567f, 0.17544124f, 0.15168101f, 
    -0.10449717f, -0.15689650f, -0.14615723f, 0.01865924f, 0.04177967f, 0.04086119f, 0.02914445f, -0.18635206f, 
    0.06611879f, 0.06130344f, -0.02256179f, 0.11935032f, -0.00732342f, 0.00735052f, -0.17507389f, 0.08956122f, 
    0.09296374f, -0.14739607f, 0.13722059f, 0.12429056f, -0.04777044f, -0.17414847f, 0.13700005f, 0.16005112f, 
    0.09015108f, -0.10904433f, -0.05393904f, 0.09015545f, 0.07879002f, 0.11496915f, 0.00103932f, -0.10074805f, 
    0.11483832f, -0.52132648f, 0.18875806f, -0.13167487f, -0.02545693f, -0.01616971f, -0.03038189f, -0.05457246f, 
    0.19113372f, 0.05335206f, -0.05572153f, 0.07025403f, 0.19202356f, 0.13273694f, -0.11227728f, -0.04371227f, 
    0.09553885f, 0.04126322f, 0.00760610f, -0.01304840f, 0.06146001f, 0.06371570f, 0.02511582f, -0.09082320f, 
    0.01560608f, -0.02740179f, 0.00138787f, 0.03628360f, -0.05141675f, -0.00802776f, 0.02177307f, 0.03126595f, 
    -0.07471415f, 0.00363881f, -0.05805927f, 0.04036180f, 0.05701918f, 0.00343895f, -0.02736758f, 0.02462032f, 
    -0.01900914f, 0.03254136f, -0.04245123f, 0.04492792f, -0.03129036f, 0.04368180f, -0.00872156f, -0.03047173f, 
    -0.01157815f, 0.03845515f, -0.05712321f, -0.04103817f, -0.04369915f, -0.00420641f, 0.01721481f, 0.04233893f, 
    -0.02420077f, 0.04562495f, -0.03885053f, -0.05624649f, 0.01283422f, -0.04733182f, -0.05060437f, 0.05602434f, 
    -0.01315816f, 0.02002739f, 0.00962217f, -0.03400053f, -0.02892691f, 0.00806888f, -0.02766084f, 0.04809096f, 
    0.00170715f, -0.05330145f, -0.05481568f, 0.01254711f, -0.02572303f, -0.03043651f, -0.00281318f, -0.02107838f, 
    -0.04922967f, -0.02763367f, 0.00227490f, 0.01448446f, -0.06400926f, -0.02345476f, -0.03669778f, -0.03916565f, 
    0.06033253f, -0.05292602f, -0.01659740f, -0.04952903f, -0.01967422f, 0.03971921f, 0.04180392f, 0.02998599f, 
    0.01930935f, -0.02719809f, -0.06269854f, -0.04826591f, -0.00480582f, -0.03145718f, -0.02120826f, 0.05499904f, 
    -0.06522828f, 0.06232342f, -0.07659657f, 0.05317156f, 0.05470308f, -0.01168369f, -0.00776310f, 0.02072978f, 
    -0.00567015f, 0.02510160f, 0.00123290f, -0.02236041f, 0.02274143f, 0.00591787f, -0.00865601f, -0.05412226f, 
    -0.05582961f, 0.04024599f, 0.03440952f, 0.02186143f, -0.00501999f, -0.01703126f, -0.05140029f, 0.03845143f, 
    -0.00228265f, 0.01891270f, 0.01414140f, -0.04901562f, -0.04711578f, 0.00306387f, 0.01930738f, 0.01215738f, 
    -0.03332993f, 0.06083208f, 0.01660606f, 0.04821729f, 0.02701735f, 0.00281503f, 0.02104834f, -0.01648184f, 
    -0.07726569f, 0.01390891f, -0.07050653f, -0.02264397f, -0.04423332f, -0.04986817f, -0.07844720f, -0.00164003f, 
    0.05183128f, 0.05251501f, -0.04781116f, -0.01273120f, -0.02646966f, -0.01342527f, 0.02355188f, 0.05598826f, 
    -0.00399632f, -0.05968387f, -0.00576557f, -0.04956546f, 0.04725466f, -0.01956444f, 0.05036123f, -0.06731948f, 
    -0.04725359f, -0.06738222f, -0.07189170f, -0.03580454f, 0.02590755f, 0.04106985f, 0.05678296f, 0.01992429f, 
    -0.03159642f, -0.05490058f, -0.07316158f, -0.00486356f, 0.04400788f, -0.00792765f, 0.04285913f, -0.05474180f, 
    -0.00131142f, -0.06053124f, 0.04743095f, 0.02447782f, -0.00475720f, -0.07141881f, -0.03327420f, 0.04441067f, 
    -0.01492082f, 0.04460225f, 0.00879447f, -0.01259523f, 0.00155703f, -0.07377099f, -0.05454777f, -0.06421751f, 
    -0.00266642f, 0.05745575f, 0.05349510f, 0.04973345f, -0.05132033f, -0.07074488f, -0.06061020f, -0.02397080f, 
    0.00580282f, -0.01402286f, 0.00029673f, 0.06365313f, 0.04570770f, 0.00077590f, -0.07046593f, 0.02034592f, 
    0.02951966f, 0.08818603f, -0.17784990f, 0.22299476f, 0.00158779f, 0.09566455f, 0.24517111f, 0.03246884f, 
    -0.06695905f, 0.06872167f, -0.12542900f, -0.03908958f, -0.04052709f, -0.37719402f, -0.28902963f, -0.03912164f, 
    0.07914907f, 0.03348644f, -0.02495999f, -0.20444748f, -0.22071391f, -0.20977950f, 0.16043562f, -0.00716759f, 
    -0.09939765f, -0.06399336f, 0.07275277f, 0.00439037f, -0.09206336f, -0.09751724f, -0.11614089f, -0.12433509f, 
    -0.13161118f, -0.04528873f, 0.00893420f, -0.17817684f, 0.20460112f, -0.04024283f, 0.02401495f, 0.07865275f, 
    0.16703790f, 0.15341730f, -0.01604834f, -0.12796862f, -0.01409322f, -0.16746570f, 0.26810756f, 0.06111907f, 
    -0.41333446f, -0.02930056f, -0.03230552f, 0.00084229f, 0.01469016f, -0.03358563f, -0.09935811f, -0.05273683f, 
    0.04719846f, 0.15741013f, 0.04985552f, 0.08432171f, -0.51037991f, 0.31503719f, 0.01348915f, -0.04708939f, 
    0.02527016f, 0.05114678f, -0.17875901f, 0.09984354f, 0.01442597f, -0.06708169f, 0.04986589f, 0.03620217f, 
    -0.05499553f, 0.18696818f, -0.06604680f, 0.12209793f, 0.10988401f, 0.00582305f, -0.16606979f, 0.03114353f, 
    0.07937111f, -0.17722370f, -0.00522689f, 0.02457434f, -0.01665455f, 0.29470065f, 0.05327727f, -0.08683469f, 
    0.00123989f, -0.06787145f, -0.12724641f, 0.14742354f, 0.00944011f, -0.14371809f, 0.09445775f, -0.01059597f, 
    -0.08239215f, 0.08064991f, -0.00005780f, 0.04532372f, 0.05520563f, -0.13666573f, -0.09592277f, -0.00166396f, 
    -0.07584135f, 0.15684609f, -0.12516259f, 0.00221113f, 0.44166371f, 0.09959327f, -0.04715193f, 0.11860125f, 
    -0.14523797f, -0.11974932f, -0.09174605f, 0.04166546f, 0.11131514f, 0.03740101f, 0.18026786f, -0.06066114f, 
    0.23223554f, -0.11452691f, 0.15484156f, 0.08299056f, 0.06856503f, -0.06024824f, -0.05178062f, -0.06282365f, 
    -0.12265698f, -0.13597254f, -0.02138981f, 0.08360271f, 0.18679777f, 0.04428939f, -0.08039477f, 0.34616256f, 
    0.10519182f, 0.16204126f, 0.12283014f, -0.00987941f, -0.01568659f, -0.07544983f, -0.12614636f, -0.06143771f, 
    0.00338289f, 0.02564781f, 0.16233563f, -0.12540025f, 0.06489066f, -0.00402585f, 0.10492942f, 0.00528576f, 
    -0.04487665f, 0.06076534f, 0.05193955f, -0.05802798f, 0.07682322f, 0.10601083f, -0.09928116f, 0.02523858f, 
    0.14581078f, -0.03010513f, -0.08312324f, -0.06918533f, -0.07903866f, 0.03524651f, 0.01943655f, 0.07035079f, 
    0.20622146f, 0.14438108f, 0.12358092f, -0.11843332f, 0.01450957f, -0.02409693f, 0.02644421f, -0.17288338f, 
    -0.01228357f, -0.18165593f, 0.17335497f, 0.03584265f, 0.31425086f, 0.10854219f, -0.15552454f, -0.06413199f, 
    0.01180158f, -0.13180813f, 0.03230376f, 0.00400749f, 0.04722210f, -0.03535180f, 0.06348346f, -0.03486279f, 
    0.25531480f, -0.02680572f, -0.02279690f, -0.19272262f, 0.00826293f, -0.06402283f, 0.10757751f, -0.05431394f, 
    -0.09582829f, 0.06528757f, 0.02592454f, -0.02148045f, 0.20367751f, 0.00200422f, -0.04792384f, -0.01082403f, 
    0.03205562f, -0.09976347f, -0.08480058f, -0.04086886f, 0.19940540f, -0.06796876f, 0.00629191f, -0.20587213f, 
    0.26765782f, -0.02561814f, 0.08291169f, -0.06358211f, 0.08339197f, 0.07100675f, -0.05783766f, 0.12180781f, 
    0.02741593f, -0.06823609f, 0.02408030f, -0.13184115f, 0.06701945f, -0.14133254f, 0.09864441f, -0.18040124f, 
    0.05913419f, -0.00876104f, -0.22128247f, 0.06101666f, 0.09266566f, -0.10485597f, 0.08118556f, 0.06609711f, 
    0.41145155f, -0.20985113f, 0.04345396f, 0.32766694f, 0.04182964f, 0.07704493f, -0.23762676f, -0.00862974f, 
    -0.01767524f, 0.03488020f, 0.13793422f, 0.00409287f, -0.29056707f, -0.11371366f, 0.16840000f, 0.16814239f, 
    0.07168411f, 0.08326142f, 0.00664911f, 0.08196795f, 0.01969999f, 0.18547770f, 0.03987449f, -0.00218808f, 
    -0.14862178f, 0.08371040f, -0.27124223f, -0.27332464f, -0.12644754f, -0.01712559f, 0.00948359f, -0.06194385f, 
    0.07965220f, -0.06590027f, 0.20230265f, -0.00683935f, -0.08807801f, 0.24001199f, -0.14424956f, -0.00317041f, 
    0.08965982f, 0.20707014f, 0.02110572f, -0.01318096f, 0.13074151f, 0.00314143f, 0.00346075f, 0.01453330f, 
    -0.15707199f, -0.06555554f, -0.24003257f, -0.21603222f, -0.04357234f, 0.04552274f, 0.05480450f, 0.01768364f, 
    -0.14342986f, -0.02478154f, 0.06016089f, -0.15650631f, 0.11805569f, 0.14156459f, -0.07900801f, -0.20013317f, 
    0.01333635f, 0.10186043f, 0.01335353f, 0.06966741f, 0.08448511f, 0.03633897f, -0.04480881f, 0.03414011f, 
    0.31568277f, 0.15977049f, 0.12804839f, 0.07348276f, -0.02663757f, -0.01956862f, 0.04298822f, -0.07004656f, 
    -0.07647964f, 0.05682107f, -0.02517106f, 0.00616633f, 0.04280914f, 0.10699842f, -0.04733960f, -0.40497148f, 
    -0.02775804f, 0.03842509f, 0.07506815f, -0.08977985f, 0.18526326f, 0.02681954f, 0.09063008f, 0.03260223f, 
    0.02054509f, 0.07683540f, 0.23693581f, 0.01914603f, 0.04025176f, -0.19957843f, 0.00107573f, -0.01501521f, 
    0.13452305f, 0.12278669f, 0.07247875f, 0.16362898f, 0.02701594f, 0.19677614f, 0.16091533f, -0.18267049f, 
    0.09343901f, -0.01935001f, -0.10200671f, 0.03395585f, -0.04340802f, 0.17795017f, -0.04853478f, 0.10284297f, 
    0.00813561f, 0.29568288f, 0.21559928f, 0.17557706f, 0.22203641f, 0.15102497f, -0.07735433f, 0.02934871f, 
    0.28850695f, -0.03440872f, -0.06418385f, -0.06989228f, -0.14693797f, -0.16247758f, -0.12567922f, -0.25746915f, 
    0.12845159f, -0.14158230f, 0.02702045f, -0.10288536f, -0.01060090f, 0.14422053f, -0.06835008f, 0.00684196f, 
    -0.21763104f, -0.37849903f, -0.23714063f, 0.05707100f, 0.27177146f, 0.15463582f, 0.01370444f, 0.02882895f, 
    -0.08000325f, 0.11150628f, -0.01964615f, -0.05946889f, 0.12465331f, 0.01621920f, 0.02339457f, 0.14850436f, 
    0.02563544f, -0.02487216f, -0.06253104f, -0.21859676f, -0.00366722f, 0.16284958f, 0.07703441f, 0.05423017f, 
    -0.00095692f, 0.01362729f, 0.04803035f, -0.17219536f, -0.03788030f, 0.15520716f, -0.06814316f, 0.08417761f, 
    0.06982818f, -0.04954730f, -0.01253666f, 0.09343272f, -0.00563636f, -0.38076448f, -0.02045907f, 0.11988802f, 
    0.27819890f, 0.02238343f, -0.11648730f, 0.00036260f, -0.08505081f, -0.04711229f, 0.06778162f, -0.18446949f, 
    -0.21042588f, -0.13443081f, -0.07474910f, -0.08286247f, -0.03088928f, 0.09945641f, 0.03691089f, 0.14008738f, 
    -0.02954624f, 0.02953553f, -0.05731660f, -0.01863379f, -0.56949556f, 0.16304666f, -0.08661749f, -0.36455834f, 
    0.02297354f, 0.20360801f, 0.08472212f, 0.28051257f, 0.03067788f, 0.04106883f, 0.18735057f, 0.08476145f, 
    -0.08456789f, 0.14485373f, 0.03027454f, -0.17586146f, -0.15297812f, 0.07615394f, 0.15891841f, -0.09416293f, 
    -0.04755272f, -0.06107428f, 0.15809840f, 0.04320903f, -0.16650987f, 0.25417176f, 0.11433481f, -0.02794309f, 
    0.12248593f, -0.07245883f, 0.09959161f, 0.05866871f, 0.00620743f, -0.17011936f, 0.00883007f, -0.01836910f, 
    -0.10603742f, -0.07553399f, -0.07733861f, 0.03301311f, 0.00891235f, -0.07631095f, 0.03246981f, 0.03989784f, 
    -0.14264254f, 0.18755189f, 0.00493937f, 0.09998058f, 0.41091371f, 0.14319457f, -0.00509932f, 0.04738243f, 
    -0.10290046f, -0.08326673f, 0.01208527f, 0.13684171f, 0.07676601f, 0.11131123f, 0.05880333f, 0.08750509f, 
    0.24576460f, 0.14372037f, 0.30889648f, -0.04406011f, -0.01193118f, 0.10827785f, 0.08880180f, -0.04701363f, 
    -0.02371042f, -0.05399912f, 0.06688557f, 0.07480895f, -0.21645185f, -0.21894957f, -0.23923467f, 0.04878325f, 
    0.05542375f, -0.09421588f, -0.06434602f, 0.10857108f, -0.20299506f, -0.03401007f, -0.18675464f, -0.16825593f, 
    -0.07229042f, 0.15761241f, -0.12912486f, 0.07070009f, 0.06139236f, -0.07456224f, -0.03026962f, 0.14796101f, 
    0.00918281f, -0.02917278f, 0.07149260f, 0.14531888f, 0.15782660f, 0.14325638f, 0.07009953f, -0.03632310f, 
    0.03587633f, -0.07748386f, 0.01054575f, 0.06005015f, 0.00671690f, 0.06496871f, 0.12212555f, 0.08682020f, 
    0.31671467f, 0.01989238f, 0.47047722f, -0.19633257f, 0.02566520f, -0.00025523f, 0.12697266f, -0.13892743f, 
    -0.01706805f, -0.00540431f, 0.11393300f, 0.00537650f, 0.31853363f, -0.17704661f, -0.08117452f, 0.04190026f, 
    -0.07118659f, -0.15119256f, -0.06796169f, 0.01587647f, 0.09749394f, -0.05380978f, 0.19984695f, 0.14923812f, 
    -0.07112469f, -0.02449979f, 0.00125338f, -0.01995634f, 0.04148835f, 0.05518562f, 0.05541359f, -0.06987348f, 
    -0.02715316f, -0.00848047f, -0.04379548f, 0.02282852f, -0.01870754f, -0.06969050f, -0.00291638f, 0.01233964f, 
    -0.05152882f, 0.01088055f, -0.07757642f, 0.00822381f, -0.07364011f, -0.03945545f, -0.04375552f, -0.08131988f, 
    -0.03828902f, -0.02645344f, 0.01023473f, 0.01380475f, -0.06723617f, 0.00351204f, 0.04913268f, -0.07571725f, 
    -0.05992265f, -0.03779236f, 0.00740951f, 0.00884370f, 0.01125726f, 0.06172537f, 0.03402590f, 0.02779059f, 
    0.04391596f, -0.03811717f, 0.01015376f, 0.04451099f, 0.05701649f, 0.00533081f, 0.06015503f, -0.06773866f, 
    0.06672826f, -0.04706369f, -0.05839517f, -0.00836389f, 0.00400074f, -0.01088365f, 0.04502112f, 0.05360143f, 
    -0.07285515f, -0.04405852f, 0.00705712f, -0.02671360f, -0.06835316f, -0.05608970f, -0.05942930f, 0.02323168f, 
    0.01481739f, -0.01558598f, -0.01529759f, 0.04208339f, 0.02635639f, -0.07495624f, 0.05776934f, 0.01156260f, 
    -0.01365509f, 0.05553950f, -0.07320198f, 0.04947476f, -0.03553307f, -0.06353660f, 0.01355624f, -0.06385961f, 
    -0.00357976f, 0.05050931f, -0.03983046f, -0.00173127f, -0.05381399f, -0.04009686f, 0.02940762f, -0.04493741f, 
    0.02906420f, 0.04130786f, -0.04399909f, -0.06052525f, -0.05752459f, 0.00769726f, 0.01196256f, 0.00104433f, 
    -0.02063199f, -0.01802491f, -0.04069785f, 0.03610134f, 0.04382955f, 0.00053034f, -0.02703532f, -0.06574161f, 
    0.00142335f, -0.07563566f, 0.02699941f, -0.01208303f, 0.01931069f, 0.05141986f, 0.04136165f, 0.00412341f, 
    0.04859867f, 0.02811852f, -0.06283896f, 0.03526487f, 0.03369125f, 0.02471254f, -0.00957561f, -0.05941525f, 
    0.05101348f, 0.03152026f, -0.04977022f, 0.02675368f, -0.01398071f, 0.01916309f, -0.00924168f, 0.05577847f, 
    -0.06420375f, -0.01392068f, -0.05980393f, 0.06046083f, -0.02126280f, -0.04053654f, -0.01813293f, -0.06324855f, 
    0.02365965f, -0.04430216f, -0.02679366f, 0.00058586f, -0.04041598f, 0.00600566f, 0.06178857f, -0.07188668f, 
    -0.05002843f, -0.07411235f, -0.02517167f, -0.00565332f, -0.04076906f, 0.02939571f, 0.02606176f, -0.02562456f, 
    -0.04970311f, -0.03709015f, -0.01790058f, -0.05456955f, -0.00957179f, 0.06593475f, 0.05123129f, -0.06606846f, 
    0.00705112f, 0.02174992f, -0.06133476f, -0.00692047f, 0.04151651f, 0.04383989f, -0.05406060f, 0.05322003f, 
    0.04140368f, 0.02798585f, -0.04928858f, -0.05235649f, 0.01646371f, 0.04921999f, 0.01677439f, -0.04075388f, 
    -0.04054284f, 0.03271329f, -0.07410127f, -0.06147048f, -0.04588703f, 0.06464917f, 0.00051553f, -0.00091236f, 
    0.00210429f, -0.03492671f, 0.04093495f, -0.02221304f, 0.04336469f, -0.07081145f, -0.04236829f, -0.06617438f, 
    -0.05544051f, -0.24951074f, -0.06790606f, -0.05920857f, 0.02277327f, -0.07792608f, -0.11187529f, 0.06762396f, 
    0.21717961f, 0.05775874f, 0.30238065f, 0.26761734f, -0.02014458f, -0.03399118f, -0.12496000f, 0.05320955f, 
    -0.05634031f, 0.03519328f, -0.29072016f, -0.10242612f, -0.02791603f, 0.12716538f, 0.27054441f, 0.17085823f, 
    -0.06074984f, -0.26959631f, -0.03320475f, 0.12186089f, 0.11902770f, 0.01386453f, -0.14131747f, -0.07284206f, 
    -0.03667986f, -0.05361955f, -0.07357265f, -0.04172029f, -0.01067387f, 0.16228262f, -0.06854342f, -0.27157110f, 
    -0.00934438f, 0.00939267f, -0.10388859f, -0.05656591f, -0.05410589f, -0.13852903f, -0.02761769f, -0.19943121f, 
    -0.13120162f, 0.35664344f, 0.05149692f, -0.07941598f, -0.09041107f, -0.10508247f, -0.15561172f, -0.12644938f, 
    0.13956153f, -0.03420569f, -0.17941932f, 0.01795621f, 0.08684873f, 0.05900269f, 0.24095777f, -0.14493303f, 
    0.18342589f, 0.10342315f, 0.00481183f, 0.05941465f, 0.18979928f, 0.03638994f, 0.07921369f, -0.05231276f, 
    -0.16363147f, 0.14131473f, 0.12202665f, 0.11048260f, 0.24397218f, 0.10917141f, -0.06815778f, 0.25303689f, 
    0.12948844f, -0.27338159f, -0.16335590f, 0.05616808f, 0.21007191f, -0.35142910f, -0.14514394f, -0.09103739f, 
    -0.03685080f, -0.03221168f, 0.03239920f, 0.26391283f, 0.16052435f, 0.09059232f, 0.09801136f, -0.19510886f, 
    0.12452547f, 0.06553683f, 0.16980681f, -0.03854515f, 0.18834408f, -0.07080693f, 0.15163603f, 0.05805230f, 
    0.09059347f, 0.05346275f, -0.12569775f, -0.02822719f, 0.01061590f, 0.21026775f, -0.10187364f, 0.08190671f, 
    -0.06188418f, -0.02007535f, -0.00279343f, 0.10902193f, -0.16299410f, 0.20590991f, 0.04397194f, 0.08425502f, 
    -0.14689633f, -0.22816411f, 0.08915963f, 0.28321034f, 0.12771475f, 0.01403439f, -0.00873550f, -0.04290238f, 
    0.04292979f, -0.10490195f, 0.13446318f, 0.14411283f, 0.29935846f, -0.09174965f, -0.32440463f, -0.36052546f, 
    -0.00861983f, 0.08603240f, 0.07257077f, 0.05659391f, 0.07472575f, 0.06297735f, -0.10193870f, -0.05286376f, 
    -0.05481539f, 0.04285273f, -0.03622057f, 0.16887352f, -0.00432788f, -0.12618779f, 0.25762632f, 0.06271262f, 
    0.09081373f, 0.08182333f, -0.10623660f, -0.06750781f, 0.07844836f, -0.27024814f, -0.06011482f, 0.30285946f, 
    -0.07886407f, -0.00625004f, 0.10775607f, -0.02368087f, 0.02357735f, 0.09260498f, 0.19574758f, 0.31407240f, 
    0.02617476f, -0.21117972f, -0.09481160f, -0.12545013f, -0.13829266f, -0.08818259f, -0.01798912f, -0.20562606f, 
    -0.07426953f, -0.05999596f, 0.07865601f, -0.09789545f, 0.00210857f, 0.17119355f, -0.05542776f, 0.16046162f, 
    -0.07817157f, -0.16525304f, -0.06116784f, 0.21654129f, -0.01439350f, -0.15202521f, 0.25616273f, 0.07950588f, 
    0.05128112f, -0.06037597f, -0.00281174f, 0.06821934f, -0.00226897f, -0.01383711f, 0.04350528f, -0.05973525f, 
    -0.00235146f, -0.05625512f, -0.05239909f, -0.05476888f, -0.06951832f, -0.06153002f, -0.01178162f, -0.06428189f, 
    -0.00725293f, -0.04143403f, -0.00151938f, -0.00224754f, -0.02511949f, 0.05067923f, -0.06068232f, 0.02182696f, 
    -0.04819246f, -0.06946869f, -0.04160880f, 0.01414063f, 0.04838000f, -0.05833923f, -0.06733568f, 0.04897694f, 
    -0.03593910f, -0.03606464f, 0.02880687f, -0.03087212f, 0.05624929f, -0.03134342f, -0.06168028f, 0.04322391f, 
    0.01578321f, 0.00798466f, -0.02210469f, -0.00027165f, -0.03390796f, -0.04335105f, -0.07216226f, 0.05419504f, 
    0.05776262f, 0.04001549f, 0.01494383f, -0.03454603f, 0.00153579f, -0.05214565f, -0.05475746f, -0.00408777f, 
    -0.05291741f, 0.01391652f, 0.00672692f, -0.07407172f, 0.00968101f, -0.04996886f, 0.04601325f, 0.04742023f, 
    -0.05453403f, -0.05511979f, -0.07307949f, 0.03572024f, -0.04997977f, 0.02756423f, -0.05082723f, 0.02376160f, 
    0.05198167f, -0.02835529f, 0.00285209f, 0.04875499f, -0.04136876f, 0.01119311f, -0.07701027f, -0.04110296f, 
    0.01188466f, -0.06272329f, 0.02860891f, -0.04212537f, 0.00440457f, -0.00605007f, -0.02819367f, -0.02098509f, 
    -0.05293359f, -0.05709395f, -0.03551459f, -0.01972591f, 0.06350486f, 0.01573277f, -0.03919607f, 0.02200370f, 
    -0.02688103f, -0.06631001f, 0.05621909f, 0.01948173f, 0.00233441f, -0.00557031f, -0.05634887f, 0.03535462f, 
    -0.02711588f, -0.03707445f, -0.05334443f, -0.06707779f, -0.03645204f, -0.03284525f, -0.04105676f, -0.02629369f, 
    -0.06132324f, 0.01058520f, -0.00080712f, -0.05463693f, 0.03731157f, -0.00408547f, 0.03129657f, -0.00187775f, 
    0.02097821f, -0.04597842f, -0.00039751f, -0.03732234f, 0.00174273f, 0.05923213f, 0.04201022f, -0.05516217f, 
    0.04710316f, -0.06114202f, 0.00853508f, 0.01881670f, -0.05209157f, -0.02143400f, -0.02935755f, -0.03295514f, 
    -0.01755868f, 0.04007317f, 0.00732000f, -0.06647119f, -0.00335536f, -0.03652139f, -0.01382936f, -0.03160596f, 
    0.02612984f, 0.03921923f, -0.07317773f, -0.06171554f, -0.06017905f, -0.04193491f, -0.00108698f, 0.05479922f, 
    0.06039333f, -0.03301176f, 0.05536345f, 0.05619510f, -0.07636469f, 0.03900358f, 0.04444943f, 0.01214937f, 
    0.04630644f, -0.03416743f, 0.04776049f, -0.00977460f, -0.04721558f, 0.02983909f, -0.07098190f, -0.02251678f, 
    -0.03636484f, -0.00203541f, -0.02366803f, -0.05260623f, -0.05823944f, 0.01823947f, 0.00275746f, -0.04194156f, 
    0.02440343f, -0.03757575f, 0.05898402f, -0.04665911f, -0.06114527f, -0.05292869f, 0.00802963f, 0.00951214f, 
    0.00965944f, -0.06448080f, -0.00803470f, 0.01379170f, -0.00619726f, 0.04665619f, -0.04172708f, -0.03678443f, 
    0.21928830f, -0.09587209f, 0.14392532f, -0.05884573f, -0.04171310f, -0.02828966f, 0.19500953f, 0.09223806f, 
    0.02246221f, -0.03581923f, 0.09442618f, 0.07909385f, -0.07122387f, 0.11621698f, -0.18805793f, 0.00464057f, 
    -0.04685337f, 0.06467186f, -0.15749693f, -0.10618316f, 0.07922300f, -0.06539477f, 0.09094119f, -0.00898701f, 
    0.22031850f, 0.15015200f, 0.09598798f, 0.22170332f, 0.02153008f, 0.07149025f, -0.04459043f, 0.03104738f, 
    -0.05477711f, 0.01236999f, 0.05380658f, -0.10791398f, -0.13313594f, 0.02008346f, 0.03150297f, -0.31852421f, 
    0.03077029f, -0.07503948f, -0.06024297f, -0.01291442f, 0.09002189f, -0.12178914f, 0.07000418f, 0.12062279f, 
    0.26616213f, -0.16226602f, -0.05320285f, 0.20764227f, -0.05148336f, 0.05560163f, -0.13979334f, 0.03535179f, 
    0.05185719f, 0.01122924f, 0.01470392f, -0.05326647f, -0.05359859f, 0.14461136f, -0.13666679f, 0.12413024f, 
    0.14046320f, 0.06476221f, 0.16948964f, 0.01974810f, -0.07978147f, 0.15136959f, 0.06936461f, -0.02029790f, 
    -0.29871124f, 0.00131025f, 0.12374080f, -0.06812976f, -0.01230804f, 0.02305157f, -0.02196788f, 0.04385557f, 
    0.05796865f, -0.09979334f, 0.01181067f, -0.08668701f, 0.06781081f, -0.10931528f, 0.06511740f, 0.03689518f, 
    -0.03055409f, 0.06436124f, -0.01669009f, 0.03344421f, 0.07011130f, -0.05877402f, -0.03705664f, 0.02529175f, 
    0.01846989f, 0.12071237f, 0.03972368f, -0.32167277f, 0.19527553f, 0.14041904f, 0.23183194f, -0.06310110f, 
    -0.15314907f, -0.06711519f, 0.18967412f, -0.07203206f, -0.27643499f, 0.42993692f, -0.13084267f, -0.05839323f, 
    0.12841098f, 0.02758226f, 0.04641668f, 0.14878576f, 0.16085102f, -0.01067529f, 0.11444329f, 0.09067664f, 
    0.13728535f, 0.08777791f, 0.06112206f, 0.33613822f, -0.00720966f, -0.03238860f, 0.00593039f, 0.04580438f, 
    -0.05240526f, -0.01064833f, 0.18139404f, 0.02000195f, 0.07004675f, -0.21039282f, -0.09368954f, -0.16099361f, 
    -0.03840344f, -0.09089966f, 0.07889877f, -0.15740275f, 0.01836186f, -0.10418665f, 0.07716057f, 0.12135834f, 
    -0.25876895f, -0.02109978f, 0.01277040f, -0.18948752f, -0.10476512f, -0.09088290f, -0.02142086f, -0.02475389f, 
    0.14752913f, 0.07756642f, 0.01687075f, 0.18238001f, -0.00287006f, 0.14282529f, 0.20235431f, 0.20937935f, 
    0.02409128f, 0.12334745f, -0.09288277f, 0.00403060f, 0.05932499f, 0.10372280f, -0.03461307f, 0.08971656f, 
    0.18777157f, -0.06593942f, -0.19692582f, 0.13722107f, 0.04654478f, -0.11782876f, -0.10914042f, 0.07393656f, 
    0.15861073f, -0.08543989f, -0.07785811f, -0.00335426f, -0.08883417f, 0.50197065f, -0.24284351f, -0.08272384f, 
    0.07256112f, 0.06747195f, 0.12522767f, -0.06715742f, -0.12175085f, 0.06356309f, -0.04521247f, 0.01962640f, 
    0.16724558f, 0.49459201f, -0.28698859f, 0.15982072f, 0.10698076f, 0.00493580f, 0.00845133f, 0.04963657f, 
    0.07020114f, 0.13147165f, -0.01083924f, 0.04620082f, 0.12729974f, -0.03596653f, 0.01342563f, 0.08960221f, 
    0.14994554f, -0.10710832f, -0.12485782f, 0.00198367f, -0.04873539f, 0.00597599f, 0.12201089f, 0.07729384f, 
    0.03313234f, 0.14104111f, 0.15714823f, -0.21163982f, 0.00256373f, 0.11101595f, -0.00393138f, 0.09780023f, 
    0.02072811f, -0.06032667f, 0.02317571f, 0.05442291f, -0.08682541f, -0.12258329f, 0.16047220f, 0.15948372f, 
    0.00222856f, 0.05363664f, -0.07389865f, -0.05816896f, -0.04917968f, 0.17031494f, 0.20939699f, -0.01012390f, 
    -0.59555262f, -0.11171127f, -0.29172868f, 0.04402024f, -0.07257862f, -0.12150717f, -0.08343759f, 0.13861664f, 
    0.04807275f, 0.04585884f, -0.05185502f, 0.01745983f, -0.15801385f, 0.18642220f, -0.10894239f, 0.08864796f, 
    -0.07206646f, 0.06847584f, -0.06376468f, 0.16490655f, -0.10293810f, 0.02943342f, 0.20850490f, -0.02179868f, 
    0.11053410f, 0.11921897f, -0.08881058f, 0.04811812f, -0.04133341f, 0.15840721f, 0.06503754f, 0.11788440f, 
    -0.03126902f, 0.00680065f, 0.26628458f, -0.01324235f, -0.14163062f, 0.06591384f, 0.19538528f, 0.10981271f, 
    -0.00675892f, 0.22501931f, -0.00726436f, -0.05388574f, 0.15364629f, -0.09703922f, 0.11895368f, -0.10834814f, 
    0.32987982f, 0.12971315f, -0.32744104f, 0.16934437f, 0.06542889f, -0.03505197f, -0.09704452f, 0.15408719f, 
    -0.02976691f, 0.10121778f, -0.13683523f, 0.08057557f, 0.15506715f, -0.14131737f, 0.05985662f, 0.15730710f, 
    0.01339408f, -0.13456394f, -0.08447066f, 0.14358941f, 0.02644033f, 0.05220383f, 0.11830304f, 0.00523149f, 
    0.02030117f, -0.01061190f, 0.20783740f, -0.29533479f, 0.13064732f, -0.08825007f, 0.03765680f, 0.04278713f, 
    -0.05670170f, -0.16570041f, 0.09773445f, 0.18300436f, 0.01007419f, -0.12205081f, -0.03544619f, 0.00326831f, 
    0.06560294f, 0.15216383f, 0.00115103f, -0.09754199f, -0.07590205f, 0.01890629f, 0.00561792f, -0.15682405f, 
    0.13692401f, -0.02107687f, 0.08590426f, -0.24460517f, 0.09415776f, -0.22291857f, 0.20894550f, 0.06646606f, 
    0.04650664f, 0.11854299f, -0.06126471f, 0.06820276f, -0.16446884f, -0.02843689f, 0.14022481f, -0.20337659f, 
    0.02007226f, -0.03892337f, 0.05657389f, -0.02447056f, 0.07718945f, 0.01206980f, 0.14692420f, 0.06957201f, 
    -0.12309603f, 0.04232580f, -0.01857248f, 0.09285164f, 0.19653027f, 0.17866282f, -0.04039312f, -0.10044832f, 
    0.13140817f, 0.04502479f, -0.11613715f, -0.05837506f, 0.09190356f, -0.09379011f, 0.17084455f, -0.04284769f, 
    0.12710792f, 0.09769375f, 0.06855395f, -0.07739645f, 0.13035327f, -0.12119880f, -0.05236265f, 0.00724687f, 
    0.07314336f, 0.29570508f, -0.11111113f, -0.03117548f, 0.09479050f, -0.12873147f, -0.04760414f, 0.03595481f, 
    0.02170007f, 0.09716763f, 0.00056419f, 0.07203537f, -0.13461529f, 0.01506829f, 0.03206189f, 0.07550996f, 
    0.03847607f, -0.12689634f, 0.09422266f, 0.16665310f, 0.07340799f, -0.06651746f, -0.02544897f, -0.00924473f, 
    -0.05953551f, 0.03840921f, 0.06953060f, -0.08976692f, -0.06971868f, -0.11556097f, -0.01561695f, -0.00668959f, 
    -0.01194893f, -0.02755596f, 0.02092935f, -0.03629618f, 0.15188183f, 0.11069927f, -0.13016933f, -0.19909374f, 
    0.16238309f, -0.07210966f, 0.13964376f, 0.05784883f, 0.02162896f, -0.05400060f, -0.16512308f, 0.09084591f, 
    0.26093021f, -0.00459968f, 0.28981772f, -0.00248759f, -0.06477299f, -0.09389391f, 0.04749146f, -0.12160471f, 
    -0.02982304f, 0.05121937f, 0.08007967f, 0.12539193f, -0.14892520f, -0.13535737f, 0.33947307f, 0.27221739f, 
    0.10698433f, 0.07501779f, -0.05518200f, -0.13089795f, 0.08946344f, 0.05063280f, -0.09535121f, 0.02695923f, 
    -0.08351371f, 0.32986617f, 0.10793537f, 0.37115622f, 0.14525230f, -0.06939911f, -0.09566965f, -0.06942881f, 
    -0.00068883f, 0.16462004f, -0.07857722f, -0.01809541f, 0.06666251f, -0.23842235f, -0.17363362f, -0.07200880f, 
    -0.07188089f, -0.01746536f, 0.00170703f, 0.04023810f, 0.00490417f, 0.20164470f, -0.10521740f, 0.01292945f, 
    -0.04291271f, -0.02487941f, 0.26161197f, 0.07538032f, -0.09430778f, -0.06336398f, -0.10920585f, 0.02724197f, 
    -0.13374133f, -0.16185692f, -0.01920901f, -0.09207969f, 0.04520224f, 0.22750644f, 0.07400811f, 0.19217074f, 
    0.01670043f, -0.02901164f, -0.06291755f, -0.00088788f, -0.15788367f, -0.05526806f, 0.05753900f, -0.07182460f, 
    -0.05728709f, 0.05742322f, -0.27245232f, -0.03866342f, -0.11344388f, -0.08371583f, -0.09297951f, 0.02832348f, 
    -0.09478796f, 0.28639489f, 0.03432222f, 0.03750515f, 0.12061285f, 0.14572868f, 0.04036986f, -0.59514713f, 
    0.16129787f, 0.34095055f, 0.07010489f, -0.07819758f, 0.13301376f, 0.00218444f, -0.02339206f, 0.21057235f, 
    -0.02414711f, -0.02131916f, 0.21268791f, 0.26811260f, 0.18897697f, 0.05093814f, 0.21569763f, 0.01439029f, 
    -0.06234089f, -0.03032142f, 0.09821000f, -0.06424924f, -0.00019304f, 0.06212849f, -0.11590384f, -0.02714633f, 
    -0.18648581f, -0.13120525f, -0.01167216f, 0.09323692f, 0.08650750f, 0.09805042f, -0.08503200f, 0.11540839f, 
    -0.55541319f, 0.10304815f, -0.23561417f, 0.13763781f, -0.09181543f, 0.13853973f, -0.05812227f, 0.07770614f, 
    0.00117690f, 0.05318321f, 0.04692591f, -0.00957687f, -0.05616158f, 0.21192335f, 0.06692302f, 0.14244562f, 
    -0.02613643f, -0.14418569f, -0.12551822f, 0.12131717f, -0.05799280f, 0.12475856f, 0.08027715f, -0.15387309f, 
    0.22617510f, 0.15061685f, 0.30617017f, 0.07433795f, -0.15862481f, 0.23157820f, 0.05485146f, 0.03835000f, 
    -0.08404073f, -0.07135879f, 0.01933567f, 0.06714182f, -0.17286135f, -0.04013658f, 0.11183295f, -0.23682240f, 
    -0.02571427f, 0.10310641f, 0.16432962f, 0.09496503f, -0.11205607f, 0.11429900f, -0.09670470f, 0.08057094f, 
    -0.04032043f, -0.18549104f, -0.19436607f, 0.36095971f, -0.04795099f, 0.02445377f, 0.00669331f, -0.04239647f, 
    -0.04903463f, 0.04447311f, -0.01889890f, 0.11653629f, -0.18696408f, 0.27540508f, 0.25374517f, 0.23536907f, 
    0.04529330f, 0.00569922f, 0.24006774f, 0.13353369f, 0.05620791f, 0.05693765f, 0.07116451f, 0.05570432f, 
    0.09183821f, 0.19953534f, -0.00455287f, 0.03422150f, 0.09767607f, 0.07010070f, 0.07774860f, 0.11994371f, 
    0.11330152f, 0.07884622f, 0.01012263f, -0.02604458f, 0.51213789f, -0.00106995f, -0.21657681f, -0.17261884f, 
    0.01602500f, -0.02575052f, -0.04376816f, -0.05581151f, -0.04995115f, 0.02079491f, 0.05455900f, 0.00698936f, 
    0.19125392f, -0.24182835f, 0.11708885f, 0.00309573f, -0.06020577f, -0.00742856f, 0.07873949f, 0.06679814f, 
    -0.10060801f, 0.21271430f, -0.05658368f, 0.07866210f, -0.05857245f, 0.01434253f, 0.03179442f, -0.03056832f, 
    -0.02537347f, 0.05006559f, -0.15153949f, -0.10016507f, -0.14080542f, 0.04794947f, -0.02272772f, 0.17567547f, 
    0.15841568f, 0.17255798f, 0.06479707f, 0.09758116f, 0.02719096f, 0.15545788f, 0.00508876f, -0.03019683f, 
    0.24311125f, 0.05040060f, -0.05807029f, 0.05506111f, -0.25528258f, -0.40175772f, 0.06722160f, -0.11612686f, 
    0.12058061f, -0.08368648f, -0.02621495f, -0.13109371f, 0.16291897f, -0.08761948f, -0.09201179f, 0.05588469f, 
    -0.35787144f, -0.23156768f, -0.20499279f, -0.00262173f, -0.09418216f, -0.00947439f, -0.14732835f, -0.02538555f, 
    0.06475997f, 0.00564273f, -0.09312937f, -0.01195392f, 0.02037610f, 0.07248554f, 0.46734887f, 0.36871979f, 
    -0.02037877f, -0.01542077f, -0.04917452f, 0.17363802f, -0.13121481f, -0.02781070f, -0.07025644f, -0.04406055f, 
    0.26483908f, -0.12547055f, 0.02134676f, -0.01923085f, 0.00343305f, 0.16112588f, -0.20325749f, 0.11160931f, 
    -0.02791035f, -0.03379955f, 0.03191018f, 0.08354813f, -0.23087576f, -0.07313362f, 0.00168669f, 0.23791875f, 
    0.01659268f, 0.11394143f, 0.00927276f, -0.03606120f, 0.05955490f, 0.08704218f, 0.05456182f, -0.22791028f, 
    0.02904385f, -0.21262366f, -0.10618071f, 0.00407145f, -0.14225517f, 0.11471450f, -0.05086270f, 0.08127268f, 
    0.08768079f, 0.02483835f, 0.03228712f, 0.13341293f, 0.02736756f, -0.21510488f, 0.21795772f, -0.03058342f, 
    0.21052259f, 0.00236518f, 0.04736266f, -0.11491762f, 0.00472317f, -0.01273267f, -0.09917124f, -0.00213916f, 
    0.04869666f, 0.03249764f, 0.00070318f, -0.06915100f, 0.02428197f, 0.00036882f, -0.07700544f, -0.05257670f, 
    0.01465649f, -0.05106268f, -0.01444867f, 0.05406270f, 0.01112280f, -0.00881963f, -0.07663130f, 0.00853963f, 
    0.04472122f, -0.01882565f, 0.01415761f, -0.01722481f, -0.07214959f, 0.05788210f, -0.06438225f, -0.03956750f, 
    0.02076281f, -0.06307179f, -0.00875674f, 0.02216874f, 0.03854496f, -0.00189076f, 0.06306439f, -0.06681123f, 
    -0.06611332f, -0.04381861f, 0.00313756f, -0.03605552f, -0.07629168f, -0.03212234f, -0.00534815f, 0.00261623f, 
    0.01577736f, 0.00871220f, 0.01675594f, -0.00494820f, -0.05751429f, -0.06429242f, -0.05826402f, 0.02093276f, 
    0.00976956f, -0.07599989f, 0.04096118f, -0.04619267f, -0.02169434f, 0.05245802f, 0.01292928f, 0.04738477f, 
    -0.06732519f, -0.01994968f, -0.02346843f, -0.05324478f, -0.04118195f, 0.01400441f, -0.05414589f, 0.00668945f, 
    -0.05911994f, -0.05390833f, -0.05894988f, 0.04671193f, -0.00127250f, 0.03833751f, 0.04111531f, 0.03912364f, 
    0.02663732f, 0.05968837f, 0.01666049f, -0.03007324f, -0.01091463f, 0.05250702f, -0.01438860f, 0.05047650f, 
    -0.02178006f, -0.00506703f, -0.00148768f, -0.03982610f, 0.03731124f, -0.02211799f, -0.03861068f, -0.04915075f, 
    0.04068774f, -0.04312538f, -0.02862480f, 0.04870783f, -0.07711672f, -0.01978084f, -0.00533137f, -0.03880785f, 
    -0.05000147f, 0.00805869f, -0.00364771f, -0.02324207f, 0.01645882f, -0.03011241f, 0.04139000f, -0.05395672f, 
    -0.04851740f, 0.00174740f, -0.05969222f, -0.06809058f, -0.04550132f, 0.05657917f, -0.00099617f, -0.00114946f, 
    -0.00360561f, -0.03868422f, 0.03727877f, 0.02900069f, 0.01028037f, -0.01634226f, 0.03033258f, -0.03058466f, 
    -0.07085871f, -0.00669104f, -0.03838331f, 0.03744370f, -0.00233396f, 0.01303142f, 0.05391463f, -0.01917952f, 
    -0.02545616f, -0.01527949f, 0.00139562f, -0.01129792f, -0.03602006f, 0.05239737f, -0.04503699f, -0.06583497f, 
    0.03469850f, 0.02073158f, 0.02838780f, 0.05801718f, 0.05480861f, 0.02711940f, 0.05455903f, -0.01438953f, 
    0.00826645f, -0.07697760f, -0.01091102f, -0.00668736f, -0.05385558f, 0.01705165f, -0.03152821f, 0.01591644f, 
    0.06292325f, -0.05472156f, -0.03836621f, -0.04981803f, 0.02560090f, -0.07935779f, 0.05297637f, -0.00449659f, 
    -0.03307869f, -0.01871227f, -0.00130696f, -0.01572313f, 0.02220522f, -0.06974470f, -0.03183575f, -0.02295930f, 
    -0.07034394f, -0.06689452f, -0.05278082f, -0.02428636f, -0.05339795f, -0.04900012f, -0.03199855f, 0.03802341f, 
    0.04712017f, 0.05654221f, 0.04126950f, 0.04136293f, 0.01097519f, 0.06169108f, 0.00437481f, -0.06016356f, 
    0.05997783f, 0.03174965f, -0.07162895f, -0.03788377f, 0.04135223f, -0.04129128f, 0.00833259f, 0.01056635f, 
    0.17728128f, -0.37384140f, 0.09639502f, -0.14900608f, -0.06923976f, -0.00858931f, 0.07388414f, -0.09986952f, 
    0.10945640f, -0.10617759f, -0.04946782f, -0.08018710f, 0.11984179f, 0.07811640f, 0.05922635f, 0.10069934f, 
    -0.12611049f, -0.16828288f, -0.05860717f, 0.18695399f, 0.13178590f, -0.13273051f, -0.15807706f, -0.00208250f, 
    -0.04825805f, 0.07893584f, -0.11267827f, -0.20124704f, -0.01927363f, -0.10443388f, 0.10983101f, -0.14468801f, 
    -0.09593394f, 0.12965642f, -0.08267950f, -0.00022575f, 0.02135890f, 0.04582009f, -0.09426242f, 0.06356478f, 
    -0.18846168f, -0.14363438f, 0.07332274f, 0.22815566f, 0.06448494f, 0.16024049f, -0.06966393f, 0.00905745f, 
    0.46225187f, -0.13585603f, 0.13180263f, 0.02992004f, -0.16199444f, -0.05294045f, 0.04641471f, 0.09740984f, 
    -0.14119074f, -0.03710927f, 0.08008818f, 0.04349668f, -0.09539460f, -0.21807812f, 0.20506391f, 0.24787000f, 
    0.05220960f, 0.11241265f, 0.11220689f, 0.00095865f, 0.01672359f, 0.05820996f, 0.10696115f, 0.02943867f, 
    0.22557481f, -0.00856472f, 0.02260437f, 0.02676568f, -0.10335153f, -0.01355060f, 0.08205004f, -0.00746804f, 
    -0.05469756f, 0.06479353f, -0.03794257f, 0.05708028f, 0.10988137f, 0.28193799f, -0.18740465f, -0.00593555f, 
    -0.15626204f, -0.02225007f, 0.14957172f, 0.00115430f, -0.12092812f, 0.01853098f, -0.01140201f, 0.04764486f, 
    0.04977329f, -0.10647969f, -0.01926969f, 0.07531372f, 0.04123678f, 0.09322235f, -0.35349858f, 0.07284864f, 
    0.02517835f, -0.22786219f, 0.06178300f, -0.00389406f, 0.08894286f, -0.05528267f, -0.07302207f, -0.02198429f, 
    0.07106154f, 0.10574657f, -0.06634905f, -0.08238332f, -0.01941956f, -0.02232049f, 0.00324459f, -0.02954348f, 
    0.15657663f, 0.04481398f, -0.03333527f, 0.04146824f, -0.01033858f, 0.00392406f, -0.09139415f, -0.24301378f, 
    0.00756543f, 0.12030815f, -0.00806207f, -0.07648216f, 0.08987159f, 0.08980848f, -0.03417121f, 0.00105536f, 
    0.03361961f, 0.10619786f, 0.04710405f, 0.12051407f, 0.05204176f, -0.03478682f, 0.08575906f, 0.11796916f, 
    0.38911375f, 0.08823632f, 0.11464507f, -0.01041515f, 0.06405283f, -0.20483992f, -0.02887354f, -0.08751994f, 
    -0.07070709f, 0.04078129f, 0.14854980f, 0.04301086f, 0.19928092f, -0.09841180f, -0.04920811f, -0.02973142f, 
    0.21142793f, 0.03741945f, -0.09799448f, 0.01518827f, -0.14510217f, -0.13764983f, -0.17173666f, -0.14943999f, 
    -0.13505073f, 0.13629623f, 0.01185737f, 0.27468809f, -0.01799267f, 0.06220011f, -0.11454336f, 0.14691208f, 
    0.19226106f, -0.08066820f, 0.03703257f, -0.18820530f, 0.01083713f, 0.13541642f, 0.12403306f, 0.08045068f, 
    -0.01075794f, 0.14638673f, -0.00339633f, 0.05290107f, -0.10085089f, 0.07873318f, -0.00715872f, -0.06880122f, 
    -0.00101379f, 0.01149444f, -0.07781766f, 0.04956420f, -0.03899045f, -0.01523418f, 0.00340017f, 0.06728146f, 
    -0.00850295f, -0.02674097f, 0.03836183f, -0.01548186f, -0.06923625f, 0.02571979f, -0.06251589f, 0.01403725f, 
    -0.05279256f, 0.02079549f, 0.02265602f, -0.04733301f, -0.02460874f, 0.02056055f, -0.05608453f, -0.03061845f, 
    -0.03375566f, 0.04147470f, -0.05329056f, -0.07838885f, -0.00536289f, -0.01893903f, 0.03009742f, -0.00969791f, 
    -0.06135479f, 0.01617464f, -0.05361388f, 0.03337506f, -0.05408615f, -0.07201883f, -0.06831324f, -0.04302783f, 
    0.01995728f, 0.02539121f, 0.04177735f, -0.06894168f, 0.03397978f, 0.01962509f, 0.02072371f, -0.04899125f, 
    -0.04115987f, 0.00310904f, -0.01173217f, -0.00301111f, -0.04498269f, -0.01648680f, -0.00812045f, 0.06260627f, 
    -0.04803437f, -0.00956106f, -0.03912807f, -0.04549477f, -0.00118590f, 0.04173334f, -0.00656282f, 0.03395090f, 
    0.05699207f, -0.03968915f, 0.02708729f, -0.02388194f, -0.04299850f, -0.03122341f, 0.02388246f, -0.00022539f, 
    0.00559689f, -0.02008445f, 0.06820996f, -0.01165166f, 0.02258940f, -0.02527046f, -0.01883795f, -0.05894044f, 
    0.02516295f, -0.03440623f, -0.06937839f, 0.00606191f, 0.04995582f, -0.04631137f, -0.01456169f, -0.04258772f, 
    -0.05857436f, 0.06108516f, 0.04300995f, -0.06692786f, 0.03822371f, 0.04838831f, -0.00878541f, -0.05223539f, 
    0.05106189f, -0.05794587f, -0.04419939f, -0.05306343f, -0.05770572f, -0.03437620f, -0.01120927f, 0.03517002f, 
    -0.00863329f, 0.03718464f, -0.01763372f, -0.07941135f, -0.02366033f, 0.06058510f, -0.02885683f, 0.02337589f, 
    -0.00436663f, 0.02687800f, -0.05487005f, -0.01519882f, 0.04592054f, 0.02021912f, -0.06467787f, 0.01099226f, 
    -0.04072075f, 0.05697173f, 0.00041356f, 0.01585367f, 0.03815858f, -0.05629522f, 0.00970663f, -0.01310548f, 
    -0.06875192f, 0.03588162f, -0.00516865f, -0.05694507f, -0.02797341f, -0.01146419f, -0.05058512f, -0.01695158f, 
    0.05022503f, -0.01125560f, -0.00127686f, 0.04235655f, -0.07315868f, -0.04235695f, -0.03886858f, -0.07009328f, 
    0.00156484f, -0.06014378f, -0.02146745f, -0.06355733f, 0.00543723f, 0.00483595f, -0.05221727f, -0.04453928f, 
    -0.04713426f, -0.07034832f, -0.01153567f, 0.01889694f, 0.03920100f, -0.00215906f, 0.03778834f, -0.00059424f, 
    0.01071253f, -0.03223646f, -0.01279246f, -0.01920686f, 0.03037877f, 0.04275469f, 0.06586666f, -0.03451731f, 
    -0.02642676f, -0.04607835f, -0.06307936f, -0.00335906f, -0.06046411f, 0.06813904f, -0.02921696f, 0.02817601f, 
    -0.07280815f, -0.03824674f, 0.04942172f, 0.03241494f, -0.07329055f, -0.03990424f, -0.03353194f, -0.03158047f, 
    0.01515302f, -0.01648731f, 0.01069044f, 0.03134092f, -0.04440688f, -0.05677713f, -0.05746420f, 0.06371241f, 
    0.02955325f, 0.00110716f, 0.04683594f, -0.06534054f, -0.01101233f, -0.05978399f, -0.00607429f, 0.03343433f, 
    0.00201991f, 0.05844197f, 0.05565561f, -0.05506993f, 0.05943022f, -0.01436198f, 0.01495400f, 0.01595111f, 
    -0.02870995f, -0.01277220f, 0.06306151f, -0.01501314f, 0.00696689f, 0.05091473f, -0.05278573f, 0.05860703f, 
    -0.06166418f, -0.04186223f, 0.03604549f, -0.03541499f, -0.01064191f, -0.05132646f, 0.05312919f, -0.07553604f, 
    0.02273137f, -0.06263461f, 0.03373360f, -0.02848110f, 0.00785189f, -0.00021446f, 0.00090606f, -0.00789684f, 
    0.00930237f, 0.05684020f, 0.02036625f, 0.02396270f, -0.04831351f, 0.03924202f, 0.03796528f, 0.04212328f, 
    -0.01005145f, 0.00882786f, 0.04522801f, -0.02302292f, 0.03447049f, -0.00813562f, 0.02132735f, 0.01357696f, 
    -0.04796411f, 0.02510953f, 0.04368501f, 0.01281173f, -0.02268005f, 0.01854961f, -0.03095449f, -0.05958579f, 
    0.02754830f, -0.02059559f, 0.03609940f, 0.01347218f, -0.02114091f, -0.01056181f, -0.02124139f, 0.01745596f, 
    0.03886499f, -0.00805682f, 0.06197564f, -0.04849713f, -0.01768234f, 0.00640148f, -0.07657395f, -0.04048640f, 
    0.03669160f, 0.01865461f, 0.04578841f, -0.07337209f, -0.03949717f, 0.00276066f, -0.02862263f, -0.03657606f, 
    -0.07176100f, 0.05297969f, 0.00577466f, 0.04249630f, -0.03121585f, -0.01649853f, -0.02536564f, -0.01980784f, 
    -0.08352841f, -0.03990936f, 0.01251948f, -0.02839764f, -0.03335889f, -0.02709300f, 0.02589185f, -0.07010584f, 
    -0.02135299f, -0.02299293f, 0.00287186f, -0.06757540f, -0.07345410f, -0.00256472f, -0.01158154f, 0.04142153f, 
    0.03110182f, 0.00924866f, 0.03659695f, -0.00353189f, -0.06973494f, 0.00417201f, -0.03996606f, -0.03961471f, 
    0.02076378f, -0.04942973f, -0.04647084f, 0.02775683f, -0.03873263f, 0.04714544f, -0.07461546f, -0.05969324f, 
    -0.06111895f, -0.00749607f, 0.05691901f, -0.06995154f, 0.04513153f, -0.07091405f, -0.05941365f, -0.00690849f, 
    -0.01004796f, 0.00481393f, 0.03892218f, -0.01875940f, 0.03942706f, -0.01494300f, -0.06156854f, -0.06854936f, 
    -0.00799860f, 0.02443997f, 0.05661494f, -0.01804010f, -0.05614562f, -0.04662614f, -0.04038906f, -0.02897440f, 
    0.03092692f, -0.07371511f, -0.06053234f, 0.01439738f, -0.05966620f, -0.03428664f, -0.01362629f, -0.02415749f, 
    0.04197199f, 0.01347230f, 0.01978285f, 0.04899998f, 0.00413380f, -0.03603106f, -0.04681651f, 0.06246463f, 
    0.02867229f, -0.02758523f, 0.04761854f, -0.04226822f, -0.04120817f, -0.04994535f, -0.00178481f, -0.01201491f, 
    0.04389989f, -0.06895569f, 0.04029081f, -0.03146860f, 0.03023990f, -0.03543082f, -0.00540979f, -0.07415414f, 
    0.02426194f, 0.02152619f, -0.04342851f, -0.06656655f, -0.00564493f, 0.00186644f, -0.05359211f, 0.03861224f, 
    0.04860923f, 0.01963758f, -0.06090152f, -0.02681099f, -0.01061829f, 0.02290066f, -0.01770204f, -0.00288369f, 
    -0.03138112f, -0.03594708f, 0.05398913f, -0.06474853f, 0.03055684f, -0.06908830f, -0.04242888f, -0.01786184f, 
    -0.03669478f, -0.02456516f, 0.04550194f, 0.03109681f, -0.04592105f, -0.06903042f, -0.07877205f, -0.01856490f, 
    0.05193471f, -0.05532177f, -0.06465144f, -0.01297223f, 0.02788581f, -0.07456140f, 0.04057195f, -0.05579278f, 
    -0.05337334f, -0.06311982f, 0.04510191f, 0.06332362f, -0.01787252f, -0.05381761f, 0.00110642f, 0.05032002f, 
    0.04232939f, -0.06503899f, 0.05056713f, 0.04537669f, 0.03285125f, -0.01016238f, 0.03139826f, -0.06507476f, 
    0.04713481f, -0.06767681f, -0.03849681f, -0.06882339f, -0.03082542f, -0.01826903f, -0.03787546f, 0.05045061f, 
    0.01392027f, -0.04592594f, -0.01224654f, -0.06939676f, -0.00973323f, 0.06203010f, -0.05286453f, 0.04420640f, 
    0.03042017f, 0.05141658f, 0.03234706f, -0.01944779f, -0.05459018f, -0.01324964f, -0.06502984f, 0.00906742f, 
    0.03499984f, -0.02515776f, 0.02546731f, -0.03245986f, -0.04713655f, -0.03793180f, -0.02080115f, -0.01790164f, 
    0.03609072f, -0.04543876f, -0.04628517f, 0.02894037f, -0.04237741f, 0.00091117f, 0.04431771f, -0.01986720f, 
    -0.00138548f, 0.06333219f, 0.04208641f, 0.01508069f, 0.05698592f, 0.00167183f, 0.02265627f, 0.03415972f, 
    0.01007733f, -0.00400429f, 0.00205845f, -0.03456062f, -0.02808950f, -0.06384811f, 0.05938491f, 0.03024053f, 
    0.03445745f, -0.01230314f, 0.00489306f, 0.00152635f, -0.00141642f, -0.03243408f, 0.00076755f, 0.03169733f, 
    -0.07846712f, -0.01427364f, -0.06316527f, -0.02869336f, 0.04822781f, 0.01389801f, 0.01180625f, -0.04477493f, 
    0.02841552f, -0.05302561f, -0.06354413f, -0.06934036f, -0.01228647f, -0.01073218f, 0.02233057f, -0.04653050f, 
    0.06251933f, -0.03888557f, -0.01270646f, 0.01305418f, -0.04352345f, -0.04469593f, -0.02183545f, 0.01866442f, 
    -0.00399203f, -0.07080957f, -0.02631629f, 0.03390988f, 0.02806323f, 0.02829337f, 0.02524906f, -0.04183489f, 
    -0.07224107f, -0.04401739f, -0.00866429f, -0.01757759f, 0.01467390f, 0.00920409f, -0.06964296f, 0.01494445f, 
    -0.05860070f, 0.04812342f, -0.05410402f, 0.06494416f, -0.05097512f, -0.03113844f, 0.02310965f, -0.07000787f, 
    -0.07422765f, -0.02474602f, -0.00567724f, -0.01637585f, -0.04743698f, -0.03662919f, -0.03873321f, -0.06313841f, 
    -0.03579844f, 0.04098409f, 0.02477393f, -0.00623621f, -0.02387859f, 0.01820668f, -0.04206748f, -0.01616869f, 
    -0.01842369f, -0.04371050f, -0.00236978f, -0.03230862f, -0.03787172f, 0.02786884f, -0.02560997f, -0.01515165f, 
    -0.05943814f, -0.03255445f, 0.05973690f, -0.06548362f, -0.04617621f, -0.06260090f, -0.04455376f, -0.05865252f, 
    -0.05667631f, -0.09707597f, -0.26606381f, -0.15728959f, -0.08773288f, -0.09506560f, -0.19355538f, -0.01745757f, 
    0.25290471f, 0.00269632f, 0.13342910f, 0.09854008f, 0.39551824f, -0.19940993f, 0.06887575f, 0.19493245f, 
    0.04102645f, 0.00412436f, -0.10594489f, 0.04935686f, 0.08665145f, 0.06273714f, 0.18535234f, 0.13938589f, 
    -0.01723965f, -0.17841642f, 0.33179402f, 0.01887798f, 0.12452424f, -0.01242084f, -0.01650166f, -0.10875922f, 
    0.06266111f, 0.04958657f, 0.07288168f, 0.19315553f, -0.24198471f, -0.19974956f, 0.02195858f, 0.03505617f, 
    -0.05227931f, 0.07276938f, -0.23976962f, -0.02406322f, 0.04857233f, 0.08896785f, 0.11877921f, -0.16952582f, 
    -0.49312425f, 0.03144103f, -0.27768120f, 0.07964318f, -0.08516369f, -0.18118487f, -0.02061057f, -0.05207683f, 
    0.10442495f, 0.03186871f, -0.05665886f, -0.03889735f, 0.17280240f, -0.24565080f, 0.28244621f, -0.05890669f, 
    0.12529477f, -0.05390859f, -0.07272647f, -0.11173882f, 0.11855426f, 0.10027066f, 0.20657098f, 0.05657297f, 
    0.05655865f, 0.02595593f, 0.15985180f, -0.03492206f, 0.12435021f, 0.15540919f, -0.15528516f, 0.22043771f, 
    0.08197394f, -0.01303256f, -0.12506147f, 0.11224137f, 0.20515749f, -0.14021482f, 0.02322652f, 0.21671174f, 
    0.06683221f, 0.18349522f, 0.09399129f, 0.17285728f, 0.19371314f, 0.02389044f, 0.08045620f, -0.10659655f, 
    0.04618017f, 0.12267748f, 0.08216697f, 0.09215821f, 0.09495006f, -0.02500552f, -0.02116758f, 0.17640708f, 
    0.16178538f, 0.04320318f, -0.25677273f, 0.14104268f, 0.09388602f, -0.10464881f, -0.05412834f, 0.05228227f, 
    0.16871703f, -0.03767437f, 0.00900235f, 0.07078606f, -0.06955360f, 0.07728910f, 0.06620701f, 0.02264966f, 
    -0.23856752f, -0.20103529f, 0.28526551f, 0.04489548f, 0.19746798f, 0.01205904f, 0.06437262f, -0.07444625f, 
    -0.08889908f, -0.09734517f, 0.18285014f, 0.10334735f, -0.01783588f, -0.39686075f, -0.27217543f, -0.28093430f, 
    -0.02385057f, -0.07072133f, 0.05539141f, -0.11739563f, -0.04651954f, 0.04047478f, -0.16215159f, -0.12908562f, 
    0.29217580f, -0.01129512f, 0.11384867f, 0.03862432f, -0.01601163f, -0.16298269f, 0.22611086f, -0.01866788f, 
    -0.12356156f, 0.18485671f, -0.03394406f, 0.02848511f, 0.07035397f, -0.14038037f, 0.05827243f, -0.09367926f, 
    0.10361426f, 0.16438426f, 0.12815197f, -0.04786917f, -0.04735791f, -0.01231965f, 0.18462513f, 0.10074499f, 
    -0.03275599f, 0.13344124f, -0.04534105f, 0.16530330f, 0.12947874f, 0.19451578f, 0.02472763f, -0.05567429f, 
    -0.13525778f, -0.01774750f, -0.05034616f, -0.03795982f, -0.12709831f, -0.03283101f, 0.26869407f, 0.12403219f, 
    -0.00017455f, 0.14188328f, -0.05255742f, 0.21062484f, 0.12284485f, -0.11909376f, 0.22997449f, 0.09341278f, 
    -0.03416910f, 0.05293998f, -0.01663419f, -0.00031997f, -0.03995900f, 0.06378817f, 0.02139452f, 0.03967578f, 
    -0.04000304f, -0.06092981f, -0.05581163f, 0.02517221f, -0.06852445f, -0.03409304f, 0.02609263f, -0.01522492f, 
    -0.07077480f, -0.00179820f, -0.05976279f, -0.06314107f, 0.05596251f, -0.07135215f, -0.03884687f, 0.00700273f, 
    -0.04002752f, -0.07010227f, -0.00130595f, 0.05608349f, -0.00903908f, -0.05459768f, 0.03847942f, 0.05275838f, 
    -0.07514986f, 0.03708767f, -0.06088570f, -0.00747763f, -0.03381628f, -0.05848556f, -0.08622095f, -0.05585983f, 
    -0.05083179f, -0.00192896f, 0.04396652f, 0.05253708f, -0.00121640f, 0.00897685f, -0.03505094f, -0.03527395f, 
    0.02163331f, -0.02106433f, -0.06800230f, 0.00666556f, 0.05862256f, 0.01576081f, -0.07520305f, 0.02595540f, 
    0.03383982f, 0.04507111f, -0.00695877f, -0.02673957f, -0.01169827f, -0.00586901f, 0.06591555f, -0.01485660f, 
    0.02227838f, 0.04305655f, -0.01836620f, 0.00134041f, -0.07388739f, 0.05705994f, 0.02589094f, 0.00138429f, 
    0.03719787f, -0.06865419f, 0.05385152f, -0.03488238f, -0.06656168f, 0.01426942f, 0.06170010f, 0.04321401f, 
    -0.01441478f, 0.02666806f, 0.05062238f, -0.06975117f, -0.05400999f, -0.00145653f, -0.05623105f, -0.06319065f, 
    0.00776077f, 0.02992544f, 0.01074810f, -0.05089002f, 0.00179816f, -0.04099773f, 0.05299697f, 0.05892847f, 
    -0.07514912f, 0.03165410f, 0.03533363f, 0.02141363f, 0.02132940f, -0.05918002f, -0.02425320f, -0.04378656f, 
    -0.02648082f, 0.04645138f, 0.05262223f, -0.05439469f, -0.02148188f, -0.00208106f, -0.05762276f, -0.07227090f, 
    -0.03836227f, 0.04957998f, 0.04160561f, 0.06580996f, -0.05656680f, 0.00803554f, -0.04128927f, 0.01826417f, 
    0.05886440f, -0.00051179f, 0.00985286f, -0.01835096f, 0.04685430f, -0.02705121f, 0.02714697f, 0.03055598f, 
    -0.05144719f, -0.06314091f, 0.02822850f, -0.05860736f, -0.03710185f, -0.06505954f, -0.02832675f, 0.05226252f, 
    -0.07461666f, -0.03096977f, 0.06138599f, 0.00080785f, 0.06304484f, 0.06482840f, 0.05891372f, -0.01831909f, 
    -0.00830130f, 0.01138606f, 0.03534684f, -0.02118269f, -0.04534791f, -0.00270273f, -0.03491317f, -0.05164256f, 
    0.04917791f, -0.04115296f, -0.02216016f, -0.05396281f, -0.07358153f, 0.03950255f, -0.06516186f, 0.02157359f, 
    -0.05574342f, -0.07238879f, 0.00044754f, -0.02998242f, -0.06667016f, 0.04258642f, 0.06599230f, -0.05587821f, 
    0.05911697f, -0.05408243f, 0.06846764f, 0.00624285f, -0.04880691f, -0.08139198f, 0.02006188f, -0.04930734f, 
    -0.04304568f, -0.02048762f, 0.00915503f, -0.01570554f, 0.05883072f, -0.01781587f, -0.07917322f, 0.05193007f, 
    0.02725641f, 0.01088067f, 0.01435539f, 0.02826321f, -0.01987816f, -0.01738583f, 0.03356254f, -0.05076634f, 
    -0.04206671f, -0.06594635f, 0.04074002f, -0.03045504f, -0.08135526f, -0.06982896f, 0.05736991f, -0.02690639f, 
    -0.06950057f, -0.07076759f, -0.03556279f, -0.00925363f, 0.05236179f, -0.07385045f, -0.00823160f, 0.04564832f, 
    -0.03403487f, -0.02633304f, -0.01206204f, -0.00401814f, 0.02238297f, 0.01330941f, -0.08332642f, -0.07672182f, 
    -0.03286009f, 0.00871298f, -0.01853762f, -0.04324740f, 0.04494075f, -0.02302921f, -0.06722616f, -0.04465302f, 
    -0.01069298f, -0.04294837f, -0.06878489f, 0.02513664f, -0.04028693f, -0.06988223f, -0.04323592f, -0.06818003f, 
    0.04169152f, 0.05398666f, 0.03087713f, -0.05312259f, 0.03978933f, -0.03684805f, 0.02143304f, -0.07526632f, 
    -0.08003042f, -0.02307270f, -0.01817608f, 0.00600186f, -0.08031066f, 0.01660543f, -0.02945676f, -0.07239927f, 
    0.02964033f, -0.05280019f, 0.02208883f, -0.00779805f, -0.07560750f, 0.01528260f, 0.02908749f, -0.00103052f, 
    0.04654890f, -0.04756847f, -0.02132900f, 0.00412174f, 0.03161599f, -0.02068753f, -0.07838271f, -0.03080615f, 
    -0.08720004f, 0.04519882f, 0.04513402f, -0.03120434f, -0.05197676f, 0.05135370f, -0.01745096f, -0.01704604f, 
    -0.02143708f, -0.07879934f, 0.06048843f, -0.07780431f, -0.03675751f, -0.07273477f, 0.05608710f, -0.02631167f, 
    -0.04431181f, -0.00121960f, -0.03893555f, -0.01346702f, -0.03528521f, 0.01455567f, 0.01693181f, -0.00407318f, 
    -0.08744743f, 0.01797816f, 0.00716777f, -0.00259117f, 0.01081009f, -0.06219198f, -0.03859416f, 0.05794705f, 
    0.03340887f, -0.03257355f, -0.03923664f, -0.02214341f, -0.08676497f, -0.05166506f, -0.07635459f, -0.03520605f, 
    -0.04956993f, 0.04554813f, 0.03896852f, 0.00054826f, -0.05629231f, -0.06359296f, -0.06740475f, -0.04577150f, 
    -0.07333681f, 0.01404238f, 0.01373655f, 0.00687197f, -0.05005788f, -0.00890696f, -0.03807071f, -0.03950495f, 
    0.03945465f, -0.02076898f, 0.01542131f, -0.04240855f, 0.03059012f, 0.04095475f, -0.02631223f, 0.01731766f, 
    -0.04249405f, 0.05006711f, -0.07950895f, -0.05222682f, -0.03565245f, 0.00865382f, -0.05445445f, -0.00149741f, 
    0.01616454f, -0.05118638f, 0.02919434f, 0.00147689f, -0.05387630f, -0.00475773f, -0.03852171f, -0.04087129f, 
    0.05948130f, 0.03411066f, -0.05940772f, -0.03188112f, -0.06353376f, -0.02302077f, 0.05693933f, -0.00949486f, 
    -0.06187513f, 0.05178292f, -0.01079943f, 0.03799098f, -0.02611640f, 0.02393185f, 0.05172727f, -0.06643182f, 
    -0.04253036f, 0.02457904f, -0.02231570f, -0.06206086f, 0.04654105f, 0.00340296f, -0.05400134f, 0.02604270f, 
    -0.03870305f, 0.02359170f, 0.02826556f, -0.00872479f, 0.04121520f, -0.08494551f, -0.04817025f, 0.04587094f, 
    0.02576863f, 0.04015987f, 0.00877448f, -0.05088674f, -0.07827079f, -0.05640476f, -0.07835590f, 0.01969212f, 
    -0.05496311f, -0.27621761f, -0.17218247f, -0.05803848f, 0.10569090f, 0.03355937f, -0.02061053f, 0.02303905f, 
    0.05282615f, -0.15475482f, 0.02189508f, 0.09189040f, -0.14356086f, 0.22431457f, -0.00822215f, -0.12956890f, 
    -0.08641587f, 0.03786924f, 0.05004909f, -0.11065114f, 0.17629491f, 0.03044504f, 0.03298265f, 0.01089193f, 
    -0.14545660f, -0.37738916f, -0.24221644f, 0.17578149f, 0.00814612f, -0.01089036f, 0.07028446f, -0.15407521f, 
    0.06372504f, -0.12250584f, -0.05275032f, 0.01086589f, 0.52561593f, 0.05970932f, -0.05297393f, -0.18952565f, 
    -0.01045981f, -0.06207006f, -0.03458772f, 0.07537342f, -0.01598500f, -0.12429993f, 0.00675912f, -0.13333826f, 
    0.47936690f, 0.36743701f, 0.22011860f, -0.15160544f, 0.26282197f, 0.03267055f, -0.03099621f, -0.09933989f, 
    0.01682599f, 0.04465967f, -0.00720453f, -0.00409959f, -0.27601460f, -0.05317602f, 0.10587677f, -0.22505505f, 
    0.03709047f, 0.11329322f, 0.04469256f, 0.09506843f, 0.13025466f, 0.16770583f, -0.05174335f, 0.08597438f, 
    -0.13491617f, 0.07142677f, 0.23057273f, 0.00445295f, 0.26127589f, -0.02648570f, -0.00170482f, -0.03899853f, 
    0.11178304f, -0.14230409f, -0.15180203f, -0.03274348f, -0.02832343f, -0.22242951f, 0.02185855f, 0.01640608f, 
    0.02396020f, 0.01451592f, -0.04116547f, 0.04064708f, -0.03229267f, 0.01081758f, -0.05857512f, 0.10433177f, 
    -0.12233730f, -0.19426066f, 0.36166766f, -0.03938179f, 0.02307656f, 0.00801577f, 0.14059450f, -0.02407245f, 
    -0.07335466f, 0.04039551f, -0.11161862f, 0.01999488f, 0.04915311f, 0.11218888f, 0.04317740f, -0.02631487f, 
    -0.04793646f, 0.20549130f, 0.07751514f, 0.02991540f, -0.09823194f, -0.01060281f, -0.01739220f, 0.09860898f, 
    -0.04529771f, 0.07911739f, -0.02329818f, 0.21924877f, 0.03684765f, 0.05637999f, 0.05383682f, -0.02261425f, 
    -0.08940592f, 0.04800501f, -0.01737222f, 0.08138312f, 0.32342142f, 0.15741928f, -0.16917758f, -0.26192495f, 
    -0.03886105f, -0.11914469f, -0.08545734f, 0.17260970f, 0.05702635f, 0.07796317f, -0.02930196f, -0.09939230f, 
    0.18634513f, 0.28461102f, -0.24129932f, 0.56631064f, -0.09720690f, 0.17256670f, -0.05721295f, 0.05661706f, 
    -0.08151642f, -0.05317386f, 0.10650504f, -0.12276345f, 0.07740682f, 0.10132042f, -0.16199824f, 0.00542175f, 
    -0.04249416f, -0.05849817f, 0.05294120f, 0.09918093f, 0.08219513f, 0.06046109f, 0.00788786f, 0.15931310f, 
    0.17854342f, -0.26931033f, 0.32223982f, -0.22148305f, -0.05454621f, -0.15660308f, 0.16066845f, 0.00599567f, 
    -0.06192188f, 0.03180306f, 0.12720552f, 0.14462511f, -0.02197780f, 0.09261456f, -0.08198475f, 0.15594269f, 
    -0.06525783f, -0.10905298f, -0.06626010f, -0.00359378f, -0.02956032f, -0.06828337f, 0.10852738f, -0.13136722f, 
    -0.03588009f, -0.04513723f, 0.00212323f, -0.05173874f, -0.07454909f, -0.06067492f, -0.02779247f, -0.04081997f, 
    0.02595687f, 0.02621931f, 0.05786564f, -0.06843998f, -0.07260951f, -0.03585077f, -0.03386083f, 0.00333904f, 
    0.04124783f, 0.02882496f, 0.00157747f, -0.01866576f, -0.04122750f, -0.06112868f, 0.03080063f, -0.06117677f, 
    0.04980463f, 0.04366987f, -0.02021383f, 0.05196745f, -0.07320057f, -0.06568955f, 0.00821796f, 0.00855868f, 
    0.04854920f, 0.02281908f, 0.05788920f, -0.00639001f, -0.00680161f, -0.02164452f, -0.04138848f, -0.05025473f, 
    0.00927721f, -0.06664339f, -0.04620345f, 0.00442228f, 0.01309329f, -0.03494667f, 0.03387134f, 0.00404578f, 
    -0.02557638f, 0.03779006f, 0.04496491f, -0.00251598f, 0.02677487f, -0.00605017f, -0.01304522f, -0.07129133f, 
    0.06099976f, 0.00356764f, 0.05168415f, 0.00399644f, 0.04163400f, -0.01607678f, -0.07512290f, -0.01240103f, 
    -0.04556282f, 0.04636983f, 0.02913169f, -0.01237964f, 0.04703500f, 0.00021797f, 0.04738460f, -0.01120587f, 
    0.05316674f, 0.00206244f, -0.00768879f, -0.05887605f, 0.04399435f, -0.00295434f, -0.03360291f, -0.02433258f, 
    0.04056906f, -0.07547551f, -0.01207191f, -0.07142840f, 0.04539166f, -0.04098674f, 0.01343857f, 0.06517741f, 
    0.00290852f, 0.00623501f, -0.00566912f, 0.01828372f, 0.00928698f, -0.06750610f, -0.07634186f, -0.02058790f, 
    -0.05712761f, 0.04389489f, 0.02711995f, -0.01280924f, -0.00403466f, -0.00734866f, -0.07177870f, -0.00340211f, 
    -0.07465822f, 0.00309508f, 0.04041542f, 0.06534770f, 0.01504565f, -0.05757087f, 0.03745219f, 0.04760420f, 
    -0.03595915f, -0.03877956f, 0.01031010f, -0.02911140f, -0.07104602f, -0.03882176f, -0.02520874f, -0.03017215f, 
    0.02979250f, -0.03915063f, -0.07676917f, -0.07157470f, -0.06634385f, -0.04736786f, 0.02228444f, 0.02018650f, 
    -0.00450135f, 0.05771970f, 0.02452532f, 0.00534156f, -0.02772728f, 0.06557614f, -0.02944438f, -0.01046973f, 
    -0.04436063f, -0.02628011f, -0.05814848f, -0.05616424f, 0.05366386f, -0.05041574f, 0.02232477f, 0.02211366f, 
    -0.06030958f, -0.02687363f, 0.04391601f, -0.05228716f, 0.00496512f, -0.00796005f, -0.07314762f, -0.03385659f, 
    0.03918803f, -0.02606395f, -0.03751804f, -0.01849250f, -0.04627321f, 0.00766424f, 0.02085691f, 0.00713667f, 
    0.02386443f, -0.02051985f, -0.02754968f, -0.02007090f, -0.01412262f, 0.03433144f, -0.03967435f, -0.00217901f, 
    0.04987083f, 0.04140387f, -0.02974600f, 0.06043410f, -0.03974430f, 0.03246757f, 0.02509508f, -0.03616069f, 
    0.02964264f, 0.00021166f, 0.05938470f, 0.01548613f, -0.02507145f, -0.06443742f, 0.01442187f, -0.00299278f, 
    -0.06052956f, -0.07589661f, -0.00374336f, 0.01195540f, -0.06200109f, -0.03353566f, -0.03457157f, -0.06929322f, 
    0.01267944f, -0.02383715f, -0.02653981f, -0.06172079f, 0.02032031f, 0.04285163f, -0.01132807f, 0.03075106f, 
    0.06008836f, -0.01496128f, 0.03673208f, 0.02039560f, 0.00370538f, 0.05100397f, -0.06071962f, 0.01623405f, 
    -0.07289816f, -0.06390206f, -0.04678635f, -0.06010816f, -0.05357084f, -0.04038784f, -0.01959401f, -0.03794192f, 
    0.06162897f, -0.05694728f, -0.03185851f, -0.03497047f, 0.02352281f, -0.04046509f, 0.05410477f, -0.05810126f, 
    0.04423168f, -0.01383133f, -0.02955344f, -0.02731253f, -0.01401504f, -0.06625900f, -0.03601591f, -0.05192234f, 
    -0.06729508f, -0.04754014f, -0.01363933f, -0.05387704f, -0.06880295f, 0.06136742f, -0.05145392f, 0.03738173f, 
    0.05002811f, -0.05883576f, 0.06577380f, 0.02731578f, -0.03890945f, 0.02605372f, -0.01003618f, -0.04970898f, 
    -0.02997630f, -0.02442512f, 0.00229065f, -0.06473496f, -0.03985863f, -0.01453380f, -0.02696011f, 0.03753889f, 
    0.03415101f, 0.01939768f, -0.00327851f, -0.03328369f, 0.00552832f, -0.03020769f, 0.01685464f, -0.01302233f, 
    0.03339078f, -0.06645479f, -0.07447974f, -0.01890759f, -0.07168981f, -0.00366991f, -0.03557462f, -0.00084036f, 
    -0.06855312f, -0.00977312f, 0.06397152f, 0.01004729f, 0.00922186f, -0.06162091f, -0.03545586f, -0.02491735f, 
    -0.07696506f, 0.05956180f, 0.04199482f, -0.04749472f, -0.02227116f, -0.02397083f, -0.03262226f, 0.03068702f, 
    -0.05880766f, 0.01514693f, 0.00833072f, -0.06116196f, -0.03586579f, -0.02578168f, -0.02669566f, -0.06698421f, 
    -0.07534179f, -0.03068362f, -0.06639143f, 0.02434922f, -0.07214538f, -0.04249603f, 0.00951290f, -0.01783402f, 
    -0.05060373f, -0.04713554f, -0.00105493f, -0.05672890f, 0.01401306f, -0.06088933f, 0.01740912f, 0.05179278f, 
    0.05125944f, 0.03759299f, -0.03239867f, -0.05027358f, 0.03754093f, -0.01289832f, -0.00472213f, -0.03257433f, 
    0.04000160f, -0.01970200f, 0.01994213f, 0.05144180f, -0.05440435f, -0.06171896f, -0.02092653f, 0.05568709f, 
    0.02621399f, 0.00926883f, -0.03322204f, -0.01887221f, 0.05484205f, -0.02047449f, 0.01124353f, 0.01841391f, 
    0.01267328f, -0.07443593f, 0.05355426f, -0.04864020f, -0.04681557f, -0.06358264f, -0.00909111f, 0.03854205f, 
    0.05072392f, -0.02762499f, 0.05231249f, -0.01512602f, -0.00024981f, 0.05756335f, -0.06613937f, 0.04632494f, 
    -0.02225899f, 0.04432341f, 0.05266880f, 0.05530541f, 0.01305872f, 0.05808441f, -0.01721469f, -0.04325595f, 
    0.03270701f, -0.01560080f, -0.02382920f, 0.02914091f, 0.03518795f, -0.04823334f, 0.02166961f, -0.04982997f, 
    -0.04706878f, -0.00521177f, -0.06932104f, -0.00707557f, 0.03973941f, -0.06375492f, 0.01950675f, 0.06341125f, 
    -0.03661411f, 0.00010868f, -0.06320727f, 0.06110761f, 0.00661002f, -0.05589959f, -0.04262716f, 0.03344084f, 
    0.53497845f, 0.21467212f, -0.12496412f, -0.03875850f, -0.00012882f, -0.13833094f, -0.16035572f, -0.11976103f, 
    0.05019460f, -0.02451260f, -0.09766664f, -0.05248591f, 0.23975131f, -0.15802664f, 0.04211551f, 0.13251022f, 
    -0.00257518f, 0.03195699f, 0.01162296f, 0.04446405f, -0.03614798f, -0.02883338f, 0.03672112f, -0.01016082f, 
    -0.00782536f, -0.20286010f, -0.31626585f, -0.20964307f, -0.08042861f, 0.01430756f, 0.05287258f, -0.01047944f, 
    0.04165063f, -0.01236669f, -0.06325067f, 0.00744433f, -0.09310861f, 0.35963663f, 0.18183033f, 0.14435118f, 
    -0.19650334f, -0.17116252f, 0.07236963f, 0.06945004f, 0.05716843f, -0.00771754f, -0.04361155f, -0.02877632f, 
    -0.58232772f, 0.34970379f, 0.02640313f, 0.00333025f, -0.02616980f, -0.04479089f, 0.07197159f, -0.04019738f, 
    -0.09303905f, 0.10255340f, 0.05883926f, -0.09781066f, -0.48967832f, -0.12948360f, 0.32294673f, -0.06950055f, 
    0.10727832f, 0.06099986f, -0.06193317f, -0.00857408f, 0.06179893f, 0.13694748f, 0.05844575f, -0.09152658f, 
    0.18458158f, -0.00273957f, -0.00043923f, -0.05185537f, -0.07919330f, 0.06081247f, 0.12373030f, 0.02738577f, 
    0.01758848f, 0.02900669f, -0.02207007f, 0.07908906f, 0.33783266f, 0.14420363f, -0.28315815f, -0.02609615f, 
    0.05124513f, 0.09462865f, -0.17183070f, 0.02167167f, 0.04364101f, -0.07903972f, 0.03158538f, 0.10058501f, 
    0.25722235f, 0.10376325f, 0.01896377f, 0.10010500f, -0.01176666f, -0.07145058f, -0.21156923f, 0.12097295f, 
    -0.01499297f, -0.04932973f, 0.02090934f, 0.03690005f, 0.30186331f, -0.17875189f, -0.10257395f, 0.03354350f, 
    0.02242171f, 0.03812677f, -0.05287147f, -0.01446060f, -0.08817318f, -0.04945458f, 0.09649025f, 0.03234415f, 
    0.15964028f, -0.35929206f, -0.16928194f, 0.04960409f, 0.13566436f, -0.04773349f, 0.10564516f, 0.00661153f, 
    -0.03896537f, -0.09434247f, 0.11329003f, 0.05338374f, 0.32559431f, 0.14675200f, 0.28578597f, -0.03936543f, 
    0.16389188f, -0.04073469f, 0.05251684f, -0.04526771f, -0.18634060f, 0.03203179f, -0.09627442f, 0.03058746f, 
    0.39144862f, 0.09500428f, 0.16130398f, 0.11892135f, -0.09525812f, -0.22134869f, 0.00341046f, 0.05340194f, 
    -0.06420910f, -0.00523246f, 0.09472357f, 0.06700388f, 0.16335818f, -0.44741243f, -0.15028244f, 0.20397502f, 
    0.11736132f, -0.11240105f, 0.07639132f, 0.07480690f, -0.17467199f, -0.09116659f, -0.03940504f, 0.04863114f, 
    0.51944357f, -0.07501208f, -0.14943507f, -0.06437512f, 0.09944090f, 0.13094403f, -0.15927283f, -0.03199732f, 
    0.02124883f, 0.02225163f, 0.00051899f, 0.08051471f, -0.10136347f, -0.15144490f, 0.04205159f, 0.06005332f, 
    0.02059530f, 0.00912479f, -0.02284198f, 0.12596843f, -0.01850276f, -0.27620313f, 0.11622178f, 0.24171446f, 
    -0.13831116f, 0.05925690f, -0.24410173f, 0.19072852f, 0.12326635f, -0.06883837f, -0.11520451f, -0.01140438f, 
    0.14440206f, 0.11965691f, 0.13343236f, 0.14152585f, -0.23891939f, 0.06939367f, 0.07938297f, -0.08082831f, 
    -0.01550701f, 0.01962249f, -0.02480839f, -0.07561804f, -0.03264416f, 0.18557192f, 0.14349410f, 0.20475914f, 
    -0.17473367f, -0.04539555f, -0.03588948f, 0.21020918f, -0.04575619f, -0.00677264f, 0.00391706f, 0.07676785f, 
    -0.01273170f, -0.01054763f, -0.03054035f, 0.14134231f, 0.04954007f, 0.18074529f, 0.09552475f, -0.11733510f, 
    -0.06509725f, 0.12576565f, -0.05368646f, -0.06724202f, -0.08503035f, -0.03046847f, 0.10290208f, -0.03995478f, 
    -0.45617846f, 0.41592705f, -0.09564047f, -0.14380209f, 0.05655941f, -0.01045804f, 0.09990879f, -0.00079111f, 
    0.02412850f, 0.07839058f, -0.04220990f, 0.01855570f, 0.20425382f, 0.41885522f, -0.04698373f, -0.25090259f, 
    0.00617835f, -0.06200334f, -0.10608467f, -0.00408432f, -0.04578256f, 0.03093457f, -0.06834984f, -0.06711236f, 
    -0.14896187f, -0.07748628f, 0.29593673f, 0.05478081f, 0.16298757f, 0.10161199f, -0.05371519f, 0.13511996f, 
    -0.03967476f, -0.11673655f, -0.06696632f, -0.02085293f, 0.03469490f, -0.38749677f, 0.27105013f, 0.13543537f, 
    0.00565851f, 0.00285490f, -0.10412498f, 0.01680666f, 0.16928414f, -0.03787568f, 0.02894732f, -0.16718780f, 
    0.30541995f, 0.06931242f, 0.12003650f, 0.09834600f, 0.12481359f, 0.01031320f, 0.17066279f, -0.01556010f, 
    0.10934299f, 0.18666585f, -0.10241931f, 0.18679608f, -0.28152981f, 0.18870312f, 0.27677026f, 0.20658144f, 
    0.00955460f, -0.08428719f, -0.01243972f, 0.11666653f, -0.06952603f, 0.13013819f, 0.11581952f, 0.04897272f, 
    -0.32423675f, 0.02712425f, 0.09981918f, 0.12890726f, 0.11569136f, 0.00339206f, 0.03406774f, 0.11551889f, 
    0.12967870f, -0.06122693f, 0.06725161f, -0.03449243f, 0.05458062f, -0.18354277f, -0.17324209f, -0.10433170f, 
    -0.09816829f, -0.04563177f, -0.06787144f, 0.00875525f, -0.11403968f, -0.02881231f, -0.12741773f, -0.17901583f, 
    -0.10882359f, -0.18837322f, -0.19468597f, -0.03999757f, -0.05719120f, 0.08040281f, 0.16213566f, 0.05937869f, 
    0.02813191f, 0.09987566f, -0.13930546f, 0.00680312f, -0.03261600f, -0.08243024f, 0.18401891f, 0.20315693f, 
    -0.08628508f, 0.05034656f, 0.18782832f, 0.01508897f, 0.15259892f, 0.09935837f, 0.09927942f, 0.09556396f, 
    -0.05096915f, -0.44374064f, -0.14558598f, -0.14116344f, -0.17854159f, -0.10515104f, -0.07174728f, -0.18376413f, 
    -0.13967057f, -0.02940356f, 0.00032142f, -0.01272150f, 0.06598128f, 0.20272312f, 0.06752960f, 0.11219647f, 
    -0.06486893f, 0.05908896f, 0.12202312f, 0.09975444f, -0.03931892f, -0.11014111f, 0.02319961f, 0.02300758f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00929137f, -0.03869569f, -0.02378737f, 0.08301179f, -0.03410650f, -0.00541170f, -0.05480085f, -0.05467723f, 
    0.01456797f, 0.03199267f, 0.00593874f, -0.02168073f, 0.16220567f, 0.02846614f, -0.00556068f, 0.06563772f, 
    0.01110865f, -0.05120814f, -0.06614791f, 0.05802402f, -0.03139044f, 0.03541258f, 0.11227927f, 0.11523411f, 
    0.01555412f, -0.05959573f, 0.02802829f, -0.06716749f, -0.08141307f, 0.01646271f, 0.02648134f, 0.07448754f, 
    0.06712593f, 0.08150520f, 0.02754271f, 0.02763281f, -0.00234483f, -0.06010699f, 0.12068007f, 0.10091492f, 
    -0.05215970f, 0.05666559f, -0.05475933f, 0.04671057f, -0.04309228f, -0.01372856f, 0.04705056f, 0.02569666f, 
    0.11798430f, -0.01298001f, 0.03393551f, -0.00076865f, 0.07166988f, 0.06361130f, -0.02160827f, 0.02841373f, 
    0.17601752f, -0.02638625f, -0.05265770f, -0.05602873f, 0.00328727f, 0.01676263f, 0.12563781f, 0.04119123f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03665494f, -0.22051202f, -0.23789473f, -0.04766988f, 0.02064232f, -0.24355498f, -0.16313024f, 0.06802879f, 
    0.11407944f, 0.47130319f, -0.05118421f, 0.12152129f, -0.05251531f, -0.02871154f, -0.31280127f, -0.11565207f, 
    -0.32188714f, 0.09923364f, 0.10999981f, -0.07446962f, 0.42161497f, -0.03939752f, 0.15499823f, -0.42331529f, 
    0.04516202f, 0.00339334f, 0.17741819f, -0.56932521f, 0.24908625f, 0.04387384f, -0.22866917f, 0.06295924f, 
    -0.02667375f, 0.18002310f, -0.27316672f, 0.23420258f, 0.32951114f, 0.04423473f, 0.01942405f, 0.19883065f, 
    -0.10052373f, -0.53742212f, 0.13283107f, -0.28618729f, -0.03399752f, 0.03397973f, 0.01377644f, 0.02682147f, 
    -0.52050936f, 0.31478521f, -0.10470154f, -0.04217251f, 0.12843820f, 0.09960052f, -0.02881825f, 0.03674450f, 
    -0.45818162f, 0.05317013f, -0.09932047f, 0.38736117f, 0.02719335f, 0.09870497f, -0.45170632f, -0.10795105f, 
    -0.09486836f, -0.02701242f, 0.00039371f, 0.25739634f, 0.10888566f, 0.10470588f, 0.10331199f, 0.03188138f, 
    -0.05744999f, 0.32290199f, 0.11476141f, 0.24261408f, -0.06856205f, 0.07038210f, 0.04303923f, -0.42844948f, 
    -0.27166173f, -0.07665706f, -0.01084056f, 0.19311602f, -0.34846815f, -0.02278876f, 0.14784542f, -0.09235458f, 
    -0.05383625f, -0.54240513f, -0.72366512f, 0.14663333f, -0.07248160f, -0.07787777f, -0.07302426f, 0.17802045f, 
    -0.24812268f, 0.33023372f, -0.34435499f, 0.27900821f, 0.16881035f, -0.00918979f, 0.21867983f, 0.08674123f, 
    0.00816394f, 0.36755142f, 0.11895614f, 0.28992453f, 0.06294587f, 0.11642908f, 0.07251174f, 0.16279358f, 
    0.08532780f, -0.28208888f, -0.14547223f, -0.06444955f, -0.47792634f, 0.08589894f, -0.09603854f, 0.04333659f, 
    -0.01534793f, 0.09316567f, 0.05248825f, 0.07074423f, 0.04204200f, 0.08515257f, 0.35379383f, 0.11172647f, 
    0.27200505f, 0.24439615f, -0.05591119f, -0.05514511f, -0.10077158f, 0.29275212f, -0.00545342f, 0.04580444f, 
    0.03075260f, -0.41662970f, -0.08508943f, -0.04115892f, -0.18623894f, 0.10394090f, 0.29938409f, -0.30974057f, 
    -0.22537267f, -0.04618520f, -0.01008061f, -0.16931047f, 0.07765820f, -0.56967026f, 0.10452255f, 0.32923326f, 
    -0.04003299f, 0.23885363f, -0.11119783f, -0.31463802f, 0.05029184f, 0.06163438f, 0.29281333f, 0.03861138f, 
    -0.24980661f, 0.16889651f, -0.09728404f, 0.36472765f, 0.13047652f, -0.00095837f, -0.03233876f, 0.16052207f, 
    0.04202058f, -0.04960964f, -0.09374756f, -0.18331510f, -0.00551761f, -0.19385989f, -0.05483432f, 0.13287242f, 
    -0.51478881f, -0.38569361f, 0.10486889f, -0.11097515f, 0.12088607f, -0.14486191f, -0.10947119f, -0.06247862f, 
    -0.53360367f, 0.09060010f, -0.04449484f, 0.10846098f, -0.02443299f, 0.02812672f, -0.84895563f, -0.26521090f, 
    -0.03412962f, -0.06190748f, 0.24377260f, -0.60993749f, 0.11635543f, -0.00020478f, -0.84949327f, -0.04680689f, 
    0.06738363f, -0.21560822f, -0.00494633f, 0.12983909f, 0.14155672f, -0.08066625f, -0.25778025f, 0.16848780f, 
    -0.31352836f, -0.04615055f, -0.07541423f, 0.05537133f, 0.03424038f, -0.48971385f, 0.05577725f, -0.36058828f, 
    0.10571074f, 0.02149595f, 0.10263444f, -0.12027395f, -0.04827443f, -0.09481789f, -0.25237843f, 0.10531989f, 
    -0.11761031f, 0.30540138f, 0.30273905f, -0.46507192f, 0.31304580f, -0.04720496f, -0.15748321f, 0.04398896f, 
    0.02576909f, -0.44051763f, -0.61936545f, -0.73780614f, 0.10377222f, 0.23653248f, -0.12387983f, -0.08337787f, 
    -0.08409820f, -0.07743803f, 0.22882712f, 0.04203616f, 0.38298365f, 0.04071284f, -0.09800170f, -0.11020610f, 
    0.37935507f, 0.08030632f, -0.00434064f, 0.02265985f, 0.08711357f, 0.02343648f, 0.35922948f, 0.20068841f, 
    0.02326321f, -0.23778813f, 0.36245993f, -0.29503632f, -0.06071439f, -0.02071519f, -0.02251350f, 0.08925960f, 
    -0.02081499f, 0.33324012f, -0.06711230f, 0.00283007f, 0.24963176f, -0.08219621f, -0.27542469f, 0.26470074f, 
    0.08622025f, 0.10166849f, -0.10149982f, 0.12283586f, -0.39536342f, 0.03901101f, 0.08030924f, -0.00350043f, 
    -0.07825164f, -0.13972849f, 0.08349150f, 0.36472911f, 0.29160964f, 0.06011729f, 0.09250541f, -0.20410088f, 
    0.13177669f, -0.32090166f, 0.11911536f, 0.27887097f, -0.41470867f, 0.06206455f, -0.28510019f, -0.00289942f, 
    -0.08054517f, -0.35990819f, -0.29313502f, -0.13701925f, -0.00694661f, -0.56240094f, 0.04193966f, -0.09411221f, 
    0.15483069f, -0.29253641f, 0.27873227f, -0.01643856f, -0.29283443f, -0.10034408f, -0.01225557f, -0.02972652f, 
    -0.15153399f, -0.07398504f, 0.04073632f, -0.42432249f, -0.00623504f, 0.02028034f, -0.48609722f, 0.26633146f, 
    0.20928802f, -0.27110049f, 0.12779184f, 0.27754843f, -0.12443756f, 0.33289400f, 0.29021171f, -0.03000736f, 
    -0.05443642f, -0.03473860f, -0.10658638f, 0.15817274f, -0.06202330f, -0.01822582f, -0.66810375f, -0.18833961f, 
    0.22353178f, -0.02393013f, 0.05395369f, -0.15069748f, 0.36872005f, 0.35515383f, -0.01388514f, 0.08509955f, 
    -0.03985425f, -0.35103628f, -0.17762706f, 0.20061985f, -0.02191757f, -0.04311866f, -0.18721947f, -0.15350878f, 
    0.06768599f, -0.41667989f, 0.19624299f, -0.06313809f, 0.07195389f, -0.08021452f, -0.26294589f, -0.50964940f, 
    0.00810310f, 0.13754165f, -0.16781089f, 0.15082955f, -0.08470028f, 0.32654417f, 0.11352381f, -0.10917287f, 
    0.07849891f, 0.03304271f, -0.60153127f, 0.11527987f, -0.18671836f, 0.05474456f, 0.04883167f, -0.06683128f, 
    0.31575045f, -0.10643513f, -0.09255777f, 0.02519437f, -0.11532928f, -0.03035612f, -0.00856671f, 0.24075596f, 
    -0.02790297f, 0.23340322f, -0.15802334f, -0.16065194f, -0.08986615f, -0.03885075f, 0.31186196f, 0.01856272f, 
    -0.01127204f, -0.12473503f, -0.06176209f, -0.01784507f, 0.16438648f, 0.08675934f, -0.04318832f, -0.17764194f, 
    0.19183438f, 0.02419776f, 0.10431101f, -0.10226369f, -0.35224524f, -0.08590449f, 0.09320200f, -0.55083865f, 
    -0.04720359f, 0.30436537f, -0.30872506f, -0.40365374f, 0.00256818f, -0.06700259f, 0.20072204f, 0.26347652f, 
    0.25141227f, 0.04052933f, -0.16535643f, -0.72213626f, -0.40298340f, -0.01790945f, 0.40664905f, -0.53117031f, 
    0.02850208f, -0.50433725f, 0.29480931f, -0.22536239f, -0.06826640f, -0.42592937f, 0.06852118f, 0.21794756f, 
    0.16552790f, 0.24809885f, -0.39305627f, -0.03462912f, 0.29743811f, 0.02789876f, 0.04073640f, -0.01604549f, 
    0.06770398f, -0.07159445f, -0.07277402f, -0.62147689f, 0.09058598f, -0.00916795f, -0.33014971f, -0.36664608f, 
    -0.32231915f, -0.09893163f, 0.11094564f, -0.27361253f, 0.01649218f, 0.17214926f, -0.08212402f, 0.00495183f, 
    0.00691992f, -0.24719808f, -0.00379863f, 0.06898412f, -0.16795368f, -0.02753748f, 0.31797409f, 0.04718042f, 
    -0.20267834f, -0.11142136f, -0.09746190f, -0.39686388f, 0.18908337f, -0.11971019f, -0.64620829f, 0.14129914f, 
    0.04229829f, 0.25435784f, 0.11166441f, 0.43611145f, -0.06995993f, -0.11764530f, -0.40322611f, -0.32537514f, 
    0.28986129f, -0.11576290f, -0.00687847f, -0.19501992f, -0.44803312f, 0.11503528f, 0.04348462f, -0.14564456f, 
    0.06577969f, 0.20169833f, 0.01099528f, -0.35311982f, -0.08425813f, -0.23564678f, -0.02783711f, -0.40267476f, 
    0.16147958f, 0.17099234f, 0.24901783f, -0.02466192f, -0.00270761f, 0.06737864f, -0.04794754f, 0.00078115f, 
    -0.21211599f, -0.06373692f, -0.00724229f, -0.12417930f, 0.11682454f, 0.11877488f, 0.11690005f, -0.23741084f, 
    -0.50584137f, 0.28359774f, -0.44449261f, -0.19105703f, -0.04303657f, 0.06955555f, 0.36645764f, 0.06813123f, 
    -0.09478772f, 0.09341143f, 0.03625651f, 0.01198912f, -0.59787869f, 0.10892959f, -0.24980652f, -0.12392835f, 
    0.21416122f, 0.09625141f, 0.01166187f, 0.30209360f, 0.10750800f, 0.19074205f, -0.12516360f, 0.37035096f, 
    -0.05286963f, -0.18302380f, -0.01903366f, -0.26235694f, -0.05158058f, -0.09842016f, 0.06840373f, -0.61605042f, 
    -0.37240896f, -0.18757874f, -0.38498452f, 0.16893651f, 0.30532876f, 0.01239174f, -0.45051470f, -0.00974997f, 
    -0.09518927f, 0.11616686f, 0.29831976f, -0.18433619f, -0.13280176f, 0.25382206f, 0.04819123f, 0.13437009f, 
    0.02382857f, -0.24703237f, 0.15018861f, -0.00992081f, 0.02774430f, 0.06587266f, -0.06656796f, 0.07951136f, 
    0.22864650f, -0.00640176f, -0.08506107f, -0.51501250f, 0.02330977f, -0.00030242f, -0.01742833f, -0.21300375f, 
    0.35136792f, -0.01768956f, -0.14424202f, 0.29345179f, -0.07518385f, -0.79134595f, 0.05178503f, -0.03559975f, 
    0.00010077f, -0.75889444f, 0.00759448f, -0.52982372f, -0.13481322f, 0.09859516f, 0.25602195f, 0.01169763f, 
    0.07057435f, -0.00895060f, -0.02695770f, 0.30227000f, -0.18040514f, 0.14378093f, -0.47276789f, -0.07163591f, 
    0.00426871f, -0.05542939f, 0.35064369f, 0.28032354f, 0.11627917f, -0.05569362f, 0.18191384f, 0.21930636f, 
    0.13152257f, 0.24190569f, -0.41833690f, -0.23051114f, -0.42196968f, 0.11284139f, -0.30416617f, -0.12135792f, 
    -0.00003147f, 0.07646314f, 0.18242611f, 0.28379038f, -0.07167234f, -0.34194529f, 0.02303731f, -0.24574482f, 
    0.04035592f, -0.21108976f, -0.07869860f, 0.04234985f, 0.16164441f, 0.11843941f, 0.08090228f, -0.10730840f, 
    0.18790895f, -0.03747275f, 0.01503426f, 0.20886333f, -0.11149538f, 0.00582959f, -0.16499110f, -0.43748438f, 
    0.00903754f, -0.25875017f, -0.34328029f, -0.08907636f, -0.01201486f, -0.01740806f, -0.34081563f, -0.04366896f, 
    0.05825094f, 0.09349517f, -0.06791217f, -1.03392673f, -0.10541460f, -0.06583355f, 0.20904541f, 0.24048349f, 
    0.00421430f, -0.00589344f, 0.10205234f, -0.41186655f, 0.16335374f, -0.47324002f, 0.09721629f, 0.32818994f, 
    0.02285704f, 0.02220445f, 0.24202219f, -0.46492204f, -0.85810030f, 0.02848821f, -0.26495034f, -0.02915147f, 
    -0.19578855f, 0.28825805f, 0.09176685f, 0.19570658f, -0.59515166f, -0.00934381f, 0.34895939f, 0.34605223f, 
    0.04421725f, 0.24177265f, 0.06421948f, -0.07934013f, 0.10800170f, 0.26539686f, -0.06667672f, 0.05800320f, 
    0.20064923f, 0.13398187f, 0.00257012f, 0.01869880f, -0.26438749f, -0.09123199f, 0.01009466f, -0.10494681f, 
    0.11057629f, 0.02630215f, 0.11471820f, 0.22192128f, -0.10712568f, -0.00225912f, -0.12680879f, 0.46701026f, 
    -0.60387105f, -0.09209131f, -0.13627256f, 0.26090452f, -0.02064021f, 0.04098558f, -0.67055935f, 0.10071163f, 
    -0.07761686f, -0.34010208f, -0.02861071f, 0.18021132f, 0.38154382f, -0.07284038f, -0.17283395f, -0.06593243f, 
    0.16246365f, -0.06383098f, 0.00472608f, -0.15779519f, -0.31638113f, 0.30410138f, 0.10769946f, 0.12971486f, 
    -0.08653153f, 0.12244319f, 0.25101241f, -0.40490505f, -0.27868447f, -0.00154016f, 0.12911743f, -0.09386860f, 
    -0.02268700f, -0.51795924f, 0.32029217f, -0.60704321f, 0.20580603f, 0.04221557f, 0.09413391f, 0.29738802f, 
    -0.08073956f, 0.41945016f, 0.14470768f, 0.36785567f, -0.06663994f, -0.31448460f, 0.03167994f, -0.13287491f, 
    0.19151147f, -0.25314993f, -0.31152514f, 0.11711004f, 0.22952497f, 0.05116769f, 0.03969174f, 0.05816747f, 
    -0.21876860f, 0.04599352f, -0.05475071f, -0.15954891f, 0.02336249f, -0.12186702f, 0.26339781f, -0.31855622f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01062152f, -0.04540071f, -0.08235244f, 0.08144005f, 0.05532211f, -0.03674585f, 0.10684372f, -0.13728914f, 
    0.03661254f, -0.06671080f, 0.08757170f, 0.02558390f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
