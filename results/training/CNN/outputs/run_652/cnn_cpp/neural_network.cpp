#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.14784217f, -1.42403626f, -1.00302219f, 0.05039840f, -0.72659850f, -0.94009155f, 0.16156356f, 0.65793341f, 
    -0.24072596f, -1.15460539f, 0.34440151f, 0.72501284f, -0.93545294f, 1.29397261f, -1.08800387f, 0.26809809f, 
    -0.30497184f, 0.47362244f, -0.77597988f, -0.83426863f, -0.66276753f, 0.84581715f, 1.58483946f, -1.12201822f, 
    0.30462685f, -0.49475116f, 0.11967269f, -1.15176523f, -1.47931600f, -0.72396988f, -1.15673542f, 0.56850451f, 
    0.99928838f, -0.35560253f, -0.49147099f, -0.61667955f, -0.71450943f, -1.23961401f, -0.98721373f, 0.67927277f, 
    1.06471276f, 0.74533033f, 0.21886149f, -0.12489405f, 0.22424814f, 1.54055238f, 1.56045651f, 0.88957477f, 
    0.13448286f, -1.08419263f, -0.99250412f, 0.21136656f, -0.17957738f, 0.10158186f, 1.48530102f, 0.87558681f, 
    1.11012352f, 0.33378696f, -0.29331604f, 0.26089439f, 0.32234150f, 1.06049514f, -0.30590591f, -0.69806838f, 
    -2.20164299f, 0.81906134f, 0.94121510f, 0.37675709f, 0.55419993f, -0.39644700f, 0.25492191f, -0.42396575f, 
    0.87604827f, -1.14008605f, -1.18544674f, 0.42717561f, -0.22318657f, -0.97951388f, -0.15403682f, 0.59230804f, 
    -0.60034043f, 0.51129836f, -1.26943719f, -1.00465238f, -1.02319944f, 0.02050865f, 0.04124413f, -0.49846157f, 
    -0.08283774f, 0.71140879f, 0.89132017f, -0.75950408f, -1.03478086f, 1.37592173f, 0.44844702f, 0.87990892f, 
    -0.61490345f, 0.38714328f, -0.81902099f, -0.38158008f, 0.52110684f, 1.26221001f, 0.76197690f, 0.95256066f, 
    1.18998671f, 0.46193689f, -0.42792359f, 0.46936241f, 0.92650110f, 1.90762281f, -0.99794942f, 0.86042738f, 
    0.99889737f, 0.57595748f, -0.22914870f, -0.22169651f, 0.01501504f, 0.14559427f, -0.90718812f, 1.50868118f, 
    -1.75802708f, -0.59453166f, -0.70817304f, 0.55925119f, 0.07800923f, -0.13748412f, 0.31367621f, 1.61066461f, 
    0.85891426f, -0.65744317f, -0.83697343f, 1.02032721f, 0.45314389f, -0.01965987f, -0.57987744f, 2.03311110f, 
    -0.09894481f, -1.06955254f, 0.15154472f, 0.10017127f, -0.48291793f, -0.29377714f, -0.46548569f, 0.42420149f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.33972299f, -0.08994766f, 0.18737249f, 0.19183160f, 0.24405302f, 0.01538622f, 0.24408288f, 0.23785371f, 
    0.64856058f, 0.26918700f, -0.21494223f, 0.48975450f, 0.33001962f, 0.12344822f, 0.26152301f, 0.17321226f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.34930280f, -0.90665942f, -0.00651046f, 0.13320799f, -0.21172260f, -0.04112428f, -0.19802834f, 0.02584369f, 
    0.11185584f, 0.11339343f, -0.18653776f, -0.11242513f, -0.08880546f, -0.10880111f, -0.04298483f, 0.12283037f, 
    -0.01117561f, 0.06468178f, 0.10281421f, 0.08436430f, -0.05153018f, -0.52751726f, 0.29792139f, 0.13540480f, 
    -0.17459869f, -0.00098431f, -0.00946327f, -0.03026213f, -0.02900455f, 0.16534917f, -0.19438292f, 0.29261085f, 
    0.13530967f, -0.06493139f, -0.12445793f, 0.05152049f, -0.29605347f, 0.05725738f, -0.17199641f, -0.14486879f, 
    0.47173536f, 0.09652103f, 0.26157743f, -0.18173774f, -0.32514152f, -0.20693611f, -0.00169660f, -0.01301096f, 
    0.03683163f, -0.09945426f, 0.12000976f, 0.06740886f, -0.07279635f, 0.14629306f, 0.01211556f, 0.05799159f, 
    -0.03306058f, 0.15405263f, -0.12573606f, -0.00630637f, -0.48522118f, 0.41046607f, -0.21098106f, -0.10579351f, 
    -0.37446728f, 0.05896439f, 0.18787235f, -0.17654747f, 0.19720183f, -0.10303393f, 0.08319782f, 0.03589445f, 
    -0.05183539f, 0.10202686f, 0.01874861f, 0.04245170f, -0.13148040f, -0.06405845f, 0.08532678f, 0.01483628f, 
    -0.07404970f, 0.31607682f, -0.02860951f, -0.30170274f, -0.36472368f, 0.20057569f, 0.13640356f, -0.09907763f, 
    0.10074986f, -0.10113768f, -0.03486398f, 0.01495983f, 0.00929728f, 0.08964755f, -0.02568470f, 0.10514927f, 
    0.16235238f, 0.02785004f, 0.08225306f, 0.00696014f, 0.12439416f, 0.11340507f, 0.03667925f, -0.41069308f, 
    0.29122540f, -0.31395218f, -0.23819576f, 0.05844267f, 0.07320686f, 0.03060879f, 0.00162416f, -0.02136859f, 
    -0.03138395f, -0.07400665f, -0.11624035f, 0.19437945f, 0.05175313f, 0.11769065f, 0.08508562f, -0.00310730f, 
    0.31141955f, 0.01539032f, 0.14499810f, -0.25941008f, 0.15977119f, -0.27277753f, -0.21019731f, -0.20750578f, 
    0.18947272f, 0.03738333f, -0.12496544f, -0.04764609f, -0.01313582f, 0.04405503f, -0.10118023f, -0.01161560f, 
    -0.15304622f, -0.05188742f, 0.03695973f, 0.06930161f, -0.25389665f, 0.19218403f, 0.07816996f, -0.12080250f, 
    -0.83755773f, 0.16265723f, 0.02771977f, 0.08212262f, 0.23478030f, -0.08715540f, -0.01183343f, -0.03249284f, 
    -0.06412297f, -0.10397841f, -0.12919085f, -0.01634624f, 0.00109235f, -0.08726579f, -0.00882509f, -0.12376153f, 
    0.05809005f, -0.64172494f, 0.07892282f, 0.02464390f, 0.13770121f, -0.03087835f, -0.04222950f, 0.26172751f, 
    -0.18498513f, 0.02102840f, -0.26328936f, 0.08114299f, 0.02601843f, -0.05713813f, 0.02003603f, -0.04278141f, 
    -0.02712084f, 0.07679427f, 0.08109210f, -0.02025848f, -0.07545139f, -0.42212009f, 0.20379104f, 0.38477644f, 
    -0.23668204f, 0.01677999f, 0.03593370f, 0.21568754f, 0.13058795f, 0.10173658f, 0.07478414f, 0.11054514f, 
    0.05303351f, -0.09538071f, 0.00280893f, -0.19467103f, 0.05237436f, -0.24111183f, -0.11682173f, -0.09360402f, 
    0.45575354f, 0.16774574f, -0.13097583f, -0.05215901f, -0.13186884f, 0.04188367f, 0.14916596f, -0.01705597f, 
    -0.11502936f, -0.26917827f, 0.00924409f, -0.07959168f, 0.15289111f, -0.06607554f, -0.10646705f, 0.16014095f, 
    0.21684533f, 0.05558922f, -0.02336066f, 0.07208344f, -0.14662403f, -0.01953408f, 0.21466164f, -0.02653049f, 
    0.09223922f, -0.02238314f, -0.12361311f, 0.06769635f, -0.16111043f, -0.11614835f, 0.07323487f, -0.14452070f, 
    0.03229237f, 0.02127675f, 0.14877051f, -0.20668547f, 0.04899495f, -0.16383964f, 0.02972966f, 0.08727673f, 
    0.19097373f, 0.06641532f, 0.10163563f, -0.25505215f, 0.67709941f, -0.34145215f, -0.03017133f, 0.12337992f, 
    0.18394487f, -0.06601236f, -0.02778207f, 0.14851919f, -0.13576069f, -0.13294098f, 0.02170734f, -0.11556365f, 
    0.03027959f, -0.01781341f, -0.15254916f, 0.05035068f, 0.42424622f, -0.48652247f, -0.41317496f, 0.33281204f, 
    -0.48480248f, -0.13966866f, -0.14508940f, 0.02878039f, -0.08903554f, 0.02635980f, -0.00100792f, 0.02747040f, 
    -0.09752548f, -0.07272655f, -0.09113074f, -0.00531637f, -0.03930986f, 0.03777681f, 0.03348326f, 0.05195528f, 
    -0.12622781f, 0.13712777f, 0.16312155f, -0.13879488f, 0.38720882f, -0.19288610f, -0.18972385f, -0.17119288f, 
    -0.03975705f, 0.08373258f, -0.01228598f, -0.12887855f, 0.20635557f, -0.07193474f, 0.10872750f, 0.01979729f, 
    0.06834858f, -0.17922404f, -0.15175101f, 0.04319177f, 0.18109550f, -0.37253430f, 0.31814295f, 0.41801807f, 
    0.48901954f, 0.03553966f, 0.00045154f, -0.15115272f, 0.13813788f, -0.02757883f, -0.25078860f, 0.07347212f, 
    0.17915699f, 0.04707838f, -0.12510198f, 0.13229202f, -0.11714175f, -0.07365786f, 0.05365712f, -0.08598142f, 
    0.27176630f, 0.21581131f, -0.05645824f, -0.04831859f, -0.06244535f, 0.31650457f, 0.00209903f, 0.09229293f, 
    -0.01557742f, 0.21293852f, -0.19931771f, -0.16860358f, 0.21056633f, 0.10629564f, -0.12006155f, -0.14188577f, 
    0.24815257f, -0.28753063f, -0.17243128f, 0.01391746f, -0.09657479f, -0.19790317f, -0.23860146f, -0.12813886f, 
    0.36013731f, -0.18545033f, 0.08972014f, -0.00451986f, -0.10025442f, 0.01325250f, 0.12924878f, -0.14259514f, 
    0.10874633f, -0.01935955f, -0.06498342f, 0.05792642f, 0.09797378f, -0.08389113f, -0.18779065f, 0.09917185f, 
    -0.09637325f, -0.24192587f, -0.31581199f, -0.02082404f, -0.04946251f, 0.14016858f, -0.07351185f, -0.00375936f, 
    0.09271877f, 0.06337728f, 0.04322279f, 0.15492895f, 0.00233494f, -0.06143065f, 0.05086819f, 0.03385430f, 
    -0.03119678f, -0.17977388f, 0.20490374f, -0.19929512f, 0.29531059f, -0.29864883f, 0.00219757f, 0.09350524f, 
    -0.22488815f, -0.27492660f, -0.17399991f, -0.12006612f, 0.02692388f, 0.02617638f, 0.03297958f, 0.01263343f, 
    -0.02799768f, -0.05493224f, -0.04547450f, 0.03024783f, -0.01101645f, 0.00326930f, -0.08770232f, -0.09950107f, 
    0.36727369f, 0.17168511f, -0.31309348f, 0.10634410f, -0.24680001f, -0.05073155f, 0.14465925f, 0.08645098f, 
    -0.10444561f, 0.18726145f, 0.07314205f, 0.01580028f, -0.19983326f, 0.00732512f, 0.01013663f, 0.12203472f, 
    0.03880747f, 0.08025889f, -0.05698299f, -0.03324810f, 0.20157643f, 0.01967710f, 0.07137851f, 0.16256920f, 
    0.09814867f, -0.11169771f, -0.10464276f, 0.08187193f, -0.00494204f, 0.01253553f, -0.07517702f, -0.05687729f, 
    0.14966759f, 0.01210254f, -0.03611514f, 0.01517894f, 0.07222769f, -0.13373652f, -0.07716366f, -0.01213798f, 
    0.25235540f, 0.25191423f, 0.12989646f, 0.23830108f, 0.09483537f, -0.04040604f, -0.19412732f, 0.02015789f, 
    0.00193886f, -0.06744897f, 0.01604886f, -0.10321132f, -0.04554591f, -0.07500278f, -0.11423466f, -0.05643522f, 
    0.21640754f, -0.13425571f, -0.03313026f, 0.19377360f, 0.31970954f, -0.12034186f, -0.20317398f, 0.14619076f, 
    -0.59740824f, 0.06023685f, 0.12420852f, 0.17860253f, -0.05358856f, 0.17526266f, 0.13790382f, 0.06997640f, 
    0.04414071f, 0.16928390f, 0.07098435f, -0.02309354f, 0.15844890f, 0.20436834f, -0.02637570f, 0.02134341f, 
    0.31535751f, -0.39583409f, -0.03507141f, -0.29228830f, 0.04461419f, -0.01655520f, 0.11812824f, -0.07236256f, 
    0.10976151f, 0.03434085f, -0.19533542f, -0.05562337f, 0.00881037f, -0.09205403f, -0.03682929f, 0.22485611f, 
    0.11313356f, -0.26117179f, -0.04166053f, -0.00078981f, -0.06069165f, -0.57963252f, -0.02407762f, -0.33162355f, 
    0.14151447f, 0.03054355f, 0.08586802f, 0.02607214f, -0.00541762f, 0.12275596f, -0.27753994f, -0.14319882f, 
    -0.05238650f, 0.07192940f, 0.00096782f, -0.01204601f, -0.16262090f, 0.07660386f, 0.00360868f, -0.11156566f, 
    0.38624969f, -0.50037259f, 0.15634422f, -0.15510079f, -0.06762651f, 0.04639124f, 0.09529112f, -0.19084072f, 
    -0.05648517f, 0.08826764f, 0.14940663f, 0.06764212f, 0.02094201f, 0.04340395f, -0.29559588f, 0.02727683f, 
    -0.06234088f, 0.00085061f, -0.00359452f, 0.09865830f, -0.04063141f, 0.36075273f, 0.22197415f, 0.10343134f, 
    0.13421325f, -0.11530913f, 0.25753742f, -0.10554242f, -0.02394703f, 0.09677164f, -0.17325215f, 0.05085463f, 
    -0.06879880f, -0.08919764f, -0.10956948f, 0.25027347f, -0.08966721f, 0.16207372f, -0.02100953f, 0.18821663f, 
    0.14076023f, 0.07189208f, 0.18273966f, 0.02074722f, 0.21839868f, -0.04276501f, -0.01241843f, -0.09319045f, 
    -0.06408416f, -0.01389206f, 0.02888167f, -0.03256644f, -0.05316363f, 0.17358793f, 0.03459988f, -0.06303270f, 
    0.02795127f, 0.17457406f, 0.15805645f, -0.00188867f, -0.83917797f, -0.23336621f, -0.16716698f, -0.10036263f, 
    -0.47982845f, 0.13426207f, 0.08704966f, -0.05335047f, 0.07490904f, -0.04047770f, 0.15019973f, 0.12509497f, 
    0.01586573f, -0.01766752f, -0.02708596f, -0.14121123f, -0.18821160f, -0.30478975f, -0.13812597f, -0.14222004f, 
    0.08616514f, 0.24630508f, 0.00221795f, 0.08870146f, 0.30772844f, -0.15845537f, -0.08010735f, 0.02707659f, 
    -0.00197831f, 0.09383156f, -0.07091404f, -0.00013346f, -0.16291927f, 0.23408897f, -0.09799466f, 0.00045961f, 
    0.04496547f, 0.11699060f, -0.01854732f, 0.04805900f, 0.36267462f, -1.09679985f, 0.09819686f, -0.64433831f, 
    -0.44252759f, 0.04373377f, -0.28009906f, -0.00383823f, -0.11432281f, -0.06915566f, -0.00388002f, -0.03807909f, 
    -0.17818643f, -0.02414970f, 0.01884726f, -0.34208128f, -0.10489284f, -0.40598670f, 0.07531143f, -0.18419389f, 
    0.03228181f, -0.77289748f, 0.27182212f, -0.24432667f, -0.15127437f, -0.11904988f, -0.11573814f, -0.19474278f, 
    0.05996580f, 0.00548511f, -0.00182210f, -0.07905090f, -0.02780889f, 0.00986820f, 0.05505846f, 0.00824823f, 
    -0.09706873f, 0.08619456f, 0.02640456f, -0.10574461f, 0.55606097f, -0.13570741f, -0.29663697f, -0.17539555f, 
    -0.48546267f, -0.03185957f, 0.08074582f, -0.15943843f, -0.02710874f, 0.05728408f, -0.00243931f, -0.15677930f, 
    0.10304426f, 0.05789622f, 0.05462088f, 0.11102298f, -0.15466240f, -0.04379553f, 0.16704717f, -0.08071010f, 
    0.59760791f, -0.41421503f, 0.32228604f, -0.14055313f, 0.11078116f, 0.08532438f, -0.15850072f, -0.06765337f, 
    0.13266793f, 0.10205202f, 0.09681527f, -0.01010596f, -0.02168427f, 0.07364649f, -0.01606174f, 0.16698442f, 
    -0.13059352f, 0.05982007f, 0.03961077f, -0.00140740f, 0.59038401f, -0.06441190f, -0.21807502f, 0.32954699f, 
    0.04790402f, -0.19467053f, 0.08739550f, -0.06883005f, -0.00721878f, 0.12289953f, 0.04192626f, 0.17651288f, 
    0.11441746f, 0.06530398f, -0.11474838f, 0.03454836f, -0.20907311f, 0.01087636f, -0.08235870f, -0.12395805f, 
    0.22214833f, 0.04742029f, 0.29577112f, 0.16787836f, 0.25878382f, -0.12901312f, -0.16586009f, -0.15393706f, 
    0.10626765f, 0.06884239f, 0.19884035f, -0.05411187f, -0.01666741f, -0.02518230f, -0.07186578f, 0.04696440f, 
    -0.09547931f, -0.03314412f, -0.06520963f, 0.12089497f, 0.01453609f, 0.15687305f, -0.06414239f, -0.17309001f, 
    0.14201185f, 0.22340958f, 0.07488980f, 0.13755612f, -0.03148630f, -0.17011301f, -0.10415062f, 0.12642573f, 
    -0.12116234f, -0.18157920f, -0.09774429f, -0.03545510f, 0.01484369f, 0.03083969f, -0.18877429f, -0.00689006f, 
    -0.20766614f, 0.24868287f, -0.00234348f, -0.19110924f, 0.10549287f, 0.11333942f, 0.10638600f, 0.13029529f, 
    -0.02461560f, -0.08612854f, -0.07509002f, 0.05060763f, 0.16857363f, -0.02271974f, -0.04275385f, 0.03241638f, 
    -0.10140917f, -0.02750644f, 0.00663738f, -0.03378702f, 0.07142885f, -0.18152823f, 0.18337157f, -0.02556076f, 
    0.21677321f, -0.48721865f, 0.03753586f, -0.09285703f, -0.07987872f, -0.06023652f, 0.10087292f, 0.00513289f, 
    -0.01770977f, -0.17368877f, 0.08345263f, -0.00560940f, -0.04188007f, -0.11761630f, 0.03260904f, 0.05378360f, 
    -0.43351388f, -0.79709977f, 0.02228947f, -0.23376665f, -0.31210917f, -0.07340310f, 0.05276059f, 0.04374382f, 
    -0.07955550f, 0.02540231f, 0.07607325f, -0.15546609f, -0.02681034f, 0.02369306f, -0.03202255f, 0.14009930f, 
    -0.16535875f, -0.07584582f, -0.01468967f, -0.11776467f, 0.77181053f, -0.34199786f, -0.11479673f, 0.04508438f, 
    -0.45406386f, -0.15292193f, 0.06513175f, 0.04177887f, 0.02790960f, 0.07269146f, 0.13221969f, 0.02444563f, 
    -0.07940881f, -0.01084379f, -0.16097136f, -0.14300804f, 0.05783131f, 0.02018846f, -0.01399677f, -0.07359288f, 
    -0.17411524f, 0.16094638f, 0.19556320f, 0.17625152f, 0.11867995f, 0.02467068f, -0.08184945f, -0.14132024f, 
    0.18025970f, 0.14840229f, -0.04685938f, -0.17070940f, 0.01526626f, 0.03990097f, 0.03106368f, 0.04182356f, 
    0.05524892f, -0.09664188f, -0.07433461f, 0.00503963f, 0.22207491f, 0.09944344f, 0.05222736f, 0.00477538f, 
    0.13081376f, -0.03169282f, -0.10531035f, 0.08235221f, 0.07803205f, -0.00139461f, 0.00495600f, 0.06424683f, 
    -0.01733867f, -0.01419004f, 0.00766194f, -0.07071438f, -0.20820624f, -0.20102336f, 0.00975128f, -0.05285548f, 
    0.53766704f, -0.20511615f, -0.03638731f, -0.25851476f, -0.06045044f, 0.10843987f, -0.05227552f, 0.20757052f, 
    -0.01581271f, 0.12380914f, -0.15088600f, 0.04481124f, 0.17101865f, 0.08312120f, -0.00934681f, -0.03379380f, 
    -0.04395093f, 0.09500985f, -0.17202069f, -0.14402187f, 0.32572603f, 0.09189203f, -0.27627546f, -0.07585839f, 
    -0.56596696f, -0.15738185f, 0.21027699f, -0.05904953f, -0.03487667f, -0.21736367f, -0.05282622f, -0.04498955f, 
    -0.09491588f, 0.00195197f, -0.14289972f, 0.16657376f, 0.12513325f, 0.02269498f, 0.16439916f, -0.17973606f, 
    -0.30910319f, 0.19501691f, -0.09420817f, -0.06795515f, 0.09039433f, -0.03355789f, 0.15694492f, 0.15848769f, 
    -0.05776918f, -0.15880708f, -0.07902284f, -0.00471102f, 0.04029264f, 0.01679541f, -0.01097201f, 0.00315590f, 
    -0.03355446f, -0.13133405f, -0.20257682f, -0.07944266f, -0.26300797f, -0.38918266f, -0.11142830f, -0.44510135f, 
    -0.39108545f, 0.00200561f, -0.12681516f, 0.07529211f, 0.02857477f, 0.00794784f, -0.13037317f, 0.05792795f, 
    0.02642029f, -0.03356216f, 0.00938280f, 0.05150111f, -0.14960468f, 0.11187986f, 0.14452608f, -0.03281185f, 
    0.08012947f, 0.13257854f, -0.14508593f, 0.08829421f, -0.08253360f, -0.15072545f, -0.13359040f, -0.13183732f, 
    0.01777291f, 0.15524234f, -0.12971117f, -0.05308719f, 0.03044260f, -0.07150733f, 0.00951468f, -0.13003704f, 
    -0.12247308f, 0.15652312f, -0.01820687f, -0.00208995f, -0.63993222f, 0.65560317f, 0.22126809f, 0.10462988f, 
    -0.08467580f, 0.11677142f, 0.07211754f, -0.01176155f, 0.21127363f, -0.00853166f, -0.01812274f, -0.19402191f, 
    -0.08370669f, 0.06262954f, -0.16754326f, -0.07960156f, 0.14974932f, -0.02539365f, 0.25777292f, 0.07777336f, 
    -0.15287167f, 0.10400494f, -0.21060644f, 0.17159969f, 0.07260942f, 0.08036253f, -0.29130179f, 0.08254145f, 
    -0.02430309f, -0.17150812f, 0.04163449f, -0.05737646f, 0.01548237f, -0.00052955f, -0.07650436f, -0.02848508f, 
    -0.05311979f, -0.03951675f, 0.09001143f, -0.08579937f, 0.00649225f, -0.13852578f, 0.09572789f, 0.17605025f, 
    -0.01726189f, -0.13719675f, -0.15370871f, 0.17570500f, 0.00416875f, -0.03524020f, -0.10743253f, 0.06481194f, 
    -0.05445136f, -0.08523031f, 0.06851235f, 0.07125559f, 0.11541711f, 0.22208273f, 0.25023180f, -0.06727520f, 
    0.11606448f, -0.22369939f, -0.22691721f, -0.08762866f, -0.26429507f, 0.01854231f, -0.13696699f, 0.04453675f, 
    -0.15119079f, 0.05231391f, -0.20101218f, 0.04873020f, 0.00199953f, -0.11823240f, 0.03473301f, -0.02420598f, 
    0.01462579f, 0.14122956f, -0.04500930f, 0.09667639f, -0.04377220f, -0.64725196f, -0.47761983f, 0.14484179f, 
    0.23943596f, -0.12627070f, 0.17993863f, -0.03518432f, 0.00790763f, 0.02624378f, 0.06411088f, -0.00186589f, 
    0.07053917f, -0.05292493f, -0.11439671f, -0.08027019f, 0.19322246f, 0.08953245f, -0.04151150f, -0.07717182f, 
    -0.67793131f, -0.99162644f, -0.53713673f, 0.27505237f, 0.02140474f, -0.06863416f, -0.03954639f, 0.11583699f, 
    0.05616756f, -0.14130063f, -0.24340874f, 0.07130417f, -0.01882707f, -0.02720014f, 0.09839328f, -0.13951632f, 
    -0.21204662f, 0.11757711f, -0.07109994f, -0.08965733f, 0.46458763f, -0.21286273f, 0.04560744f, -0.14867735f, 
    -0.19769561f, -0.08757747f, -0.13955262f, -0.24112520f, 0.01403803f, -0.04196122f, 0.02424717f, -0.09515500f, 
    0.12673326f, -0.17710792f, 0.03215202f, -0.09906872f, -0.13482609f, -0.02737276f, 0.10555918f, 0.04464973f, 
    0.25235501f, 0.19153117f, 0.12325666f, 0.14287075f, -0.07796836f, -0.17379063f, 0.07915235f, -0.06241812f, 
    -0.01564611f, 0.08031196f, 0.01877371f, -0.01286313f, -0.01904675f, -0.00591372f, 0.02418769f, 0.00871613f, 
    -0.05279134f, 0.10277895f, -0.14371125f, -0.04313920f, 0.15404135f, 0.26636183f, 0.18466312f, 0.10517535f, 
    -0.00974263f, -0.06523816f, -0.05184066f, -0.03968962f, -0.10649680f, 0.01887585f, 0.01813104f, 0.17377882f, 
    -0.11459034f, 0.01591926f, 0.16839533f, 0.18521053f, -0.06449824f, 0.20004611f, 0.14023794f, 0.10145985f, 
    -0.19606996f, 0.13543224f, -0.41852131f, 0.05646533f, -0.22311586f, 0.06662408f, 0.02452362f, 0.03758460f, 
    -0.05436185f, 0.14834614f, -0.14136854f, -0.08904432f, 0.16580044f, 0.02911784f, 0.11702854f, 0.19093411f, 
    -0.09549423f, -0.09387854f, -0.13351172f, -0.00482271f, -0.53629988f, -0.54041630f, 0.13068205f, -0.40576658f, 
    -0.26513675f, 0.00626165f, -0.08224846f, -0.08623914f, -0.02485318f, -0.28826541f, 0.07780157f, -0.15426075f, 
    0.05894694f, 0.09078117f, 0.04389251f, 0.15634561f, 0.12025736f, -0.11737373f, 0.00551818f, -0.02014682f, 
    -0.12052260f, -0.16169794f, -0.37937331f, -0.02709370f, -0.34572029f, -0.29388726f, -0.05185214f, 0.02853262f, 
    0.08756621f, 0.11900876f, -0.04201050f, -0.09945023f, 0.08461076f, 0.10117608f, -0.09449869f, -0.07830153f, 
    -0.03144764f, 0.02878043f, 0.01471529f, 0.22694595f, -0.40446016f, 0.76077920f, 0.09808042f, 0.51956809f, 
    0.24079975f, 0.03981297f, 0.09597886f, 0.11281482f, 0.07788820f, 0.12391904f, -0.14414424f, -0.01305501f, 
    -0.00604354f, -0.24181107f, -0.14595047f, -0.00024802f, 0.15923825f, 0.02442213f, 0.17514110f, 0.04575444f, 
    -0.56417048f, -0.72181743f, -0.25437993f, 0.27807191f, 0.29601410f, 0.11745566f, 0.15622842f, 0.04689308f, 
    -0.02795712f, -0.08759627f, 0.07406419f, 0.04435390f, -0.06860131f, -0.03626738f, 0.00506285f, 0.01013852f, 
    -0.02552764f, -0.18240456f, 0.18688467f, -0.08233131f, 0.11828873f, 0.26073670f, 0.49080479f, 0.09229372f, 
    0.10632384f, 0.06467739f, 0.07764173f, -0.02743770f, 0.14673093f, 0.04489877f, -0.03312349f, -0.04866700f, 
    -0.11820692f, 0.11409505f, 0.04055749f, -0.01286876f, 0.05072921f, -0.05075044f, -0.04231771f, 0.04396380f, 
    -0.02949943f, 0.02230393f, 0.16127561f, -0.00180537f, 0.02309983f, 0.15058987f, 0.24438719f, -0.12148660f, 
    0.24588029f, 0.08298459f, 0.19115165f, 0.09529848f, 0.01514004f, 0.06454978f, 0.13716553f, -0.00146890f, 
    -0.04549882f, -0.06690496f, 0.04025998f, 0.07835596f, -0.62112528f, 0.11825932f, -0.18720917f, -0.10331893f, 
    -0.26976764f, 0.12257668f, -0.01675442f, 0.08120668f, -0.18143347f, -0.04538302f, 0.14524665f, 0.01123075f, 
    -0.11929628f, 0.12136373f, 0.04563258f, -0.11019813f, 0.09328337f, -0.27295363f, 0.02123817f, -0.01135208f, 
    -0.81392705f, 0.20680486f, -0.09808550f, -0.19842426f, 0.00617983f, -0.10778684f, 0.04083316f, 0.08993514f, 
    0.06495769f, -0.05675057f, -0.15224549f, -0.05180843f, -0.00490111f, 0.01266975f, -0.06267554f, -0.08620695f, 
    0.06823106f, 0.15376975f, 0.08988200f, 0.04862756f, -0.48885119f, -0.24438496f, -0.08012287f, 0.07412294f, 
    0.36785176f, 0.13331841f, -0.06057689f, 0.01914557f, 0.07895162f, 0.13694867f, -0.20074393f, -0.09787554f, 
    0.12892197f, 0.09966644f, 0.08254303f, -0.13481654f, 0.28060082f, 0.03544090f, 0.16247354f, -0.18558671f, 
    -0.71687573f, 0.01902979f, -0.16391207f, 0.15759069f, 0.29362977f, 0.03810896f, -0.05315685f, 0.18017095f, 
    0.11179846f, 0.02288185f, -0.01451778f, -0.04405699f, 0.13790363f, 0.01243356f, 0.05852136f, 0.08280598f, 
    -0.11091035f, 0.13587545f, 0.06577405f, -0.15619439f, -0.48187390f, -0.19684274f, 0.44754478f, 0.27358332f, 
    -0.15152548f, -0.17291620f, 0.05168991f, -0.12246752f, -0.01985499f, 0.06832097f, -0.00262047f, 0.04494182f, 
    -0.00427891f, -0.05885696f, -0.02901108f, -0.12818620f, 0.08602488f, -0.01877159f, 0.11409059f, 0.11606382f, 
    -0.32049814f, -0.22552934f, 0.25051922f, -0.13609645f, -0.04140766f, -0.12046646f, 0.17706597f, -0.24814300f, 
    0.08554640f, 0.20011966f, 0.26314548f, 0.00574517f, 0.19696429f, -0.02684540f, -0.01713240f, 0.06739831f, 
    -0.09962919f, -0.15202565f, -0.09088557f, -0.14989765f, -0.62444365f, 0.25115651f, 0.01888740f, -0.13698006f, 
    0.31144071f, 0.12301695f, 0.03589838f, -0.14423063f, 0.12204337f, -0.01952857f, 0.09933971f, 0.07987896f, 
    -0.11840287f, 0.04158177f, 0.05818663f, 0.12052543f, -0.04181094f, -0.11517226f, 0.12476227f, 0.08837362f, 
    -0.06056201f, 0.46377411f, -0.01996858f, 0.29137596f, -0.15528618f, -0.01234808f, 0.05688931f, 0.12091274f, 
    0.03311507f, -0.16179788f, -0.03596872f, 0.03624672f, -0.03000076f, 0.05861875f, 0.12852921f, 0.02479275f, 
    -0.18079579f, 0.05106334f, -0.12934887f, 0.16715720f, 0.12215715f, 0.23584127f, -0.18765002f, 0.06453547f, 
    -0.11206737f, 0.11001583f, -0.02626801f, -0.18127336f, 0.03386797f, -0.26677468f, 0.10525512f, 0.08252590f, 
    0.01897695f, -0.00227203f, -0.00937255f, 0.11014255f, -0.10323781f, 0.09700625f, 0.22588892f, -0.21076351f, 
    -0.68884796f, -0.04581284f, -0.10539418f, 0.28743631f, -0.12411550f, -0.00725908f, -0.17671497f, 0.17727493f, 
    -0.31672102f, 0.22107011f, 0.09190667f, 0.06248900f, 0.01089223f, -0.00988255f, 0.11104306f, 0.12735638f, 
    -0.05594960f, 0.03367529f, 0.00557232f, -0.15115660f, 0.08596333f, 0.42059743f, -0.35934311f, -0.03225499f, 
    0.03026912f, -0.04424605f, -0.04915091f, 0.05153990f, 0.22990441f, -0.01473801f, -0.26192543f, -0.07783884f, 
    0.16132130f, 0.11962919f, 0.08684583f, -0.05053394f, -0.01413881f, -0.30903319f, -0.13621575f, -0.11797275f, 
    0.20877331f, -0.36439967f, -0.13070153f, 0.14892530f, -0.08102532f, 0.24037771f, -0.08794607f, 0.10140327f, 
    0.03264328f, 0.06068122f, -0.15135933f, -0.01086814f, 0.02338307f, -0.03877381f, -0.02585695f, 0.07281150f, 
    0.06357273f, -0.15045451f, 0.03872333f, -0.13305934f, -0.37579760f, -0.47025478f, 0.08616827f, 0.05424074f, 
    0.12982000f, 0.01294682f, -0.12621017f, 0.16936323f, -0.20762901f, 0.00933572f, 0.05695631f, -0.20214465f, 
    -0.06298953f, -0.16359879f, 0.08989283f, -0.05405829f, -0.08360300f, 0.04956438f, 0.08266336f, 0.03954908f, 
    0.12788676f, -0.22370543f, -0.01967870f, 0.05762811f, -0.05690370f, -0.30241454f, -0.26553926f, 0.09190926f, 
    -0.17720538f, -0.04310732f, -0.02999455f, 0.11907646f, -0.12923597f, -0.20934941f, -0.06925624f, 0.07804065f, 
    -0.08099554f, 0.03425276f, 0.14180160f, 0.02083497f, 0.35498646f, 0.26567635f, -0.02636933f, -0.05944753f, 
    -0.60145098f, -0.14458308f, 0.00715176f, 0.08605798f, -0.06299920f, -0.16683811f, 0.06122299f, -0.04820982f, 
    0.16274627f, -0.00255315f, -0.03057970f, -0.11454250f, 0.07195764f, 0.16067983f, -0.03371657f, 0.07222100f, 
    -0.56093466f, 0.01520573f, -0.21054271f, -0.02542333f, 0.18320809f, 0.08656769f, 0.04927625f, -0.00962649f, 
    -0.00166244f, 0.01253641f, -0.03464169f, 0.20000769f, 0.14423065f, 0.00332832f, 0.14168487f, 0.11390518f, 
    0.01281746f, 0.07888456f, 0.12801951f, -0.20205787f, -0.07505387f, -0.04929031f, 0.11405333f, 0.09371276f, 
    -0.27206960f, 0.04841116f, -0.12328317f, -0.09840237f, 0.06795234f, -0.03796196f, 0.01700373f, 0.01497213f, 
    0.14051248f, 0.08281497f, 0.11248193f, -0.18198285f, -0.09242262f, 0.04936621f, -0.27851474f, -0.02482212f, 
    -0.75369185f, 0.04727405f, -0.15202634f, -0.02075488f, 0.02175580f, 0.05746612f, 0.11359864f, 0.02477136f, 
    -0.00627532f, -0.09890349f, 0.07866902f, -0.22734466f, 0.06240712f, -0.14523955f, -0.05958225f, 0.05417423f, 
    0.15740938f, -0.19114237f, -0.03633941f, 0.12417606f, -0.17603156f, 0.41328302f, -0.38485643f, -0.28076977f, 
    -0.05666672f, 0.24399310f, 0.17632622f, 0.23945594f, 0.00225320f, 0.08133870f, 0.03835855f, -0.00096245f, 
    -0.33180702f, -0.14561723f, -0.14398947f, -0.06441941f, -0.12247790f, 0.02730835f, -0.27111772f, -0.04724058f, 
    -0.70224965f, 0.01648164f, -0.41246438f, -0.31564867f, -0.17669028f, 0.19946353f, 0.08218577f, -0.10495615f, 
    0.02334473f, -0.26467460f, 0.08959478f, 0.11369343f, 0.08562132f, -0.06660794f, 0.02314477f, 0.21317478f, 
    0.10014810f, 0.08752835f, 0.06856681f, 0.06082455f, 0.19961132f, -0.07838073f, -0.09103630f, 0.22202082f, 
    0.06072041f, -0.02685821f, -0.13379303f, 0.13315703f, -0.03089446f, 0.06975501f, -0.17540643f, -0.14585119f, 
    0.08160372f, 0.13564490f, 0.22999366f, -0.16736086f, -0.12607831f, 0.00467986f, 0.18239790f, 0.09680696f, 
    0.10273033f, 0.03912813f, 0.08691594f, 0.29443908f, 0.09080151f, -0.02156880f, 0.00148658f, 0.07438064f, 
    0.08611160f, -0.02195763f, -0.09955724f, 0.01247009f, -0.02389972f, 0.05340075f, 0.16568957f, 0.06943449f, 
    0.08941849f, 0.26396722f, -0.01661655f, -0.02791034f, -0.79453105f, 0.47970539f, -0.22857130f, 0.18632556f, 
    -0.07268670f, 0.09607315f, 0.08501764f, 0.08341762f, -0.18763748f, 0.15881689f, -0.00765393f, 0.06431914f, 
    -0.03368645f, -0.13222903f, -0.15623610f, 0.08890200f, 0.05562195f, 0.00308458f, 0.01026593f, -0.09783056f, 
    -0.31421968f, -0.22269556f, -0.12147272f, 0.08479840f, 0.10829116f, 0.19591466f, -0.01649353f, -0.08956335f, 
    0.01619176f, 0.09532352f, 0.13604306f, 0.05195241f, 0.23120105f, 0.03886704f, 0.04650849f, -0.22742578f, 
    0.03604848f, -0.00789305f, 0.06985148f, -0.19524859f, -0.31313857f, -0.28099513f, -0.11556916f, 0.10506679f, 
    0.06964768f, 0.11217923f, 0.00954376f, -0.16041736f, 0.11330188f, -0.04323577f, -0.10482237f, -0.05802901f, 
    0.07526042f, 0.03526908f, -0.08580170f, -0.07186975f, 0.01494550f, -0.07625274f, -0.13616656f, 0.05069443f, 
    -0.12295529f, 0.08253213f, 0.02466781f, -0.19676000f, 0.05769340f, -0.04596028f, 0.08044242f, -0.22749826f, 
    -0.11515557f, -0.21865185f, -0.00364064f, 0.06404327f, -0.06838798f, -0.05163180f, -0.01266854f, -0.09046146f, 
    -0.10127091f, -0.04870127f, 0.16373743f, -0.01180242f, -0.09696925f, 0.02896284f, 0.16256894f, -0.00366615f, 
    -0.24155533f, -0.01323089f, -0.10983633f, 0.09476899f, -0.09287854f, -0.07374971f, 0.17583895f, -0.14632958f, 
    -0.11216854f, -0.13726656f, -0.13873759f, -0.03475904f, -0.05295106f, 0.26140258f, 0.15176170f, 0.08334929f, 
    0.23654512f, 0.25428027f, 0.00173952f, -0.10910729f, -0.07839788f, -0.12359410f, 0.12398040f, -0.14131808f, 
    -0.27052534f, 0.10686474f, 0.06415872f, -0.00167679f, -0.05797318f, 0.04255220f, -0.01395370f, 0.13964388f, 
    0.00334290f, -0.12099691f, 0.18347368f, -0.08920781f, 0.06536382f, 0.09785381f, 0.24358632f, 0.06066020f, 
    0.08610404f, -0.20669203f, -0.09351659f, 0.02931909f, 0.21994762f, 0.09929367f, -0.08733518f, -0.15551016f, 
    0.09209116f, 0.12011809f, 0.23356502f, -0.04484832f, 0.10005818f, -0.01002786f, -0.45808178f, 0.03655585f, 
    0.06563231f, -0.01658206f, -0.00945736f, 0.22221449f, -0.52259988f, -0.14779083f, -0.06839984f, -0.15402655f, 
    0.09873787f, 0.05026278f, 0.04856618f, -0.00915910f, 0.08859686f, 0.19268210f, 0.09949072f, -0.10011153f, 
    -0.03800963f, 0.09259779f, 0.13214782f, -0.05758969f, -0.07188095f, -0.10592017f, -0.19193864f, 0.06208555f, 
    0.26480097f, -0.13522024f, -0.14503247f, 0.14749144f, 0.08467468f, 0.02587278f, 0.06587327f, -0.14034316f, 
    0.09103214f, 0.09064548f, -0.08113439f, 0.09334793f, -0.04071954f, -0.06822911f, -0.03690150f, 0.03477841f, 
    -0.19648139f, 0.08659385f, -0.09248689f, -0.37180480f, 0.07060956f, -0.05427807f, 0.03517042f, 0.00057445f, 
    -0.14044756f, -0.07656399f, 0.16029382f, 0.01852062f, -0.05482153f, -0.10309885f, 0.10977688f, -0.08005639f, 
    -0.15689154f, 0.03792605f, 0.00241405f, 0.13338134f, 0.02655608f, -0.04464527f, -0.06345824f, 0.23581152f, 
    0.37154043f, 0.15633665f, 0.05436744f, 0.16628157f, 0.05507911f, -0.21843104f, 0.09849219f, -0.11859219f, 
    -0.16369693f, -0.16388844f, 0.11390332f, -0.04794684f, 0.09918043f, 0.24218027f, 0.19441149f, 0.01210502f, 
    0.50209510f, -0.08362754f, -0.04907359f, 0.01156093f, 0.04965455f, 0.04696955f, 0.17852645f, -0.03755680f, 
    -0.15503123f, -0.09032481f, -0.05953187f, 0.14206651f, 0.12536925f, 0.08784880f, 0.22600244f, 0.06948093f, 
    -0.07186561f, 0.11447828f, -0.16572024f, 0.14977787f, -0.06634887f, -0.34175700f, -0.09480091f, -0.61845893f, 
    0.13923173f, 0.00099897f, -0.01692486f, 0.01865319f, -0.26865789f, 0.00275525f, -0.12616755f, -0.17051548f, 
    0.28148609f, 0.05101219f, 0.06493612f, 0.03520619f, -0.02980183f, -0.02592076f, 0.07672668f, 0.23133111f, 
    0.07055499f, -0.60440475f, 0.02706262f, -0.22070448f, 0.14496662f, -0.09117093f, -0.08669017f, 0.02753831f, 
    -0.10203433f, 0.10200609f, -0.05650265f, 0.08002875f, 0.03421948f, 0.17187953f, -0.08989313f, -0.13804428f, 
    -0.01110589f, -0.19187839f, -0.10401138f, -0.04907502f, -0.11311886f, 0.60447758f, 0.04691178f, 0.00430600f, 
    -0.68333328f, 0.20243432f, 0.00006544f, 0.02477063f, 0.18601596f, 0.01827498f, 0.20008129f, 0.24568301f, 
    -0.12747037f, -0.08637707f, -0.14191484f, -0.06660689f, -0.11579335f, 0.01972473f, -0.07838907f, -0.09184858f, 
    -0.30672938f, 0.57169354f, -0.05682237f, 0.22999115f, -0.22129877f, -0.21245867f, -0.19586340f, -0.09346405f, 
    0.15774767f, 0.10365091f, 0.05096938f, 0.03060674f, -0.01321653f, 0.07795727f, -0.11119001f, -0.04221880f, 
    0.12170073f, -0.09042268f, -0.03655796f, -0.09003882f, 0.11176404f, -0.74129021f, -0.01081099f, -0.04721376f, 
    0.16523993f, -0.10929884f, 0.02808940f, -0.01563124f, 0.02785144f, -0.02075321f, -0.18597130f, 0.02360901f, 
    0.00566720f, 0.05278229f, 0.05599006f, -0.06669682f, -0.05500801f, -0.07595986f, -0.03235817f, 0.15258798f, 
    -0.03190165f, -0.11223642f, -0.18924567f, -0.27927658f, 0.17874004f, -0.07904397f, -0.03251160f, 0.06285837f, 
    0.12635648f, -0.07234702f, 0.05015843f, -0.12778242f, -0.25289404f, -0.04451971f, -0.03089837f, 0.07995912f, 
    -0.00178780f, 0.28263098f, 0.04434605f, 0.21745451f, -0.02037109f, -0.07583891f, 0.08283231f, -0.33140379f, 
    0.30103564f, -0.16228074f, -0.01743239f, 0.23022814f, -0.23354052f, 0.06374604f, 0.00879355f, -0.26596206f, 
    0.09625255f, -0.06690703f, -0.19774227f, 0.16377121f, 0.06344384f, 0.00359982f, 0.11428072f, -0.02081494f, 
    -0.24012794f, -0.39617550f, 0.01640658f, -0.26212555f, 0.29715469f, 0.03741936f, -0.07948910f, 0.07261134f, 
    0.31531855f, -0.01238039f, -0.15215296f, -0.11776287f, -0.01462990f, 0.20511453f, 0.14054847f, 0.01126619f, 
    -0.06649710f, -0.01686093f, -0.17587408f, -0.13695678f, 0.45672202f, -0.70711261f, -0.17272994f, 0.44742781f, 
    -0.07516685f, -0.13381732f, 0.03705661f, -0.06602885f, 0.10551688f, 0.10023051f, 0.02653308f, 0.14251882f, 
    -0.01516147f, 0.07395144f, 0.19989008f, 0.05646515f, 0.09368515f, -0.24853878f, -0.09595720f, -0.29042432f, 
    -0.43110356f, 0.22236875f, -0.19610822f, 0.38421774f, -0.36233988f, -0.00333365f, -0.10526498f, 0.15693295f, 
    0.09301326f, -0.08219899f, -0.04841191f, -0.09729090f, 0.09946552f, -0.02816409f, 0.02582173f, -0.02997787f, 
    -0.15410554f, 0.03490691f, -0.23511937f, -0.10763641f, 0.26489189f, 0.08029728f, 0.00363116f, -0.19914463f, 
    -0.12218256f, -0.03105182f, 0.10689040f, 0.12178091f, -0.10868131f, 0.04837163f, 0.02867205f, -0.04606792f, 
    -0.06733046f, 0.08389181f, -0.06493954f, 0.04532811f, -0.08569104f, 0.16262014f, 0.22368069f, 0.02458550f, 
    -0.24299632f, 0.37680426f, 0.06441908f, -0.14984164f, -0.06547252f, 0.13494702f, 0.00284418f, 0.11214162f, 
    0.03563095f, -0.05103006f, 0.09322708f, -0.01505577f, -0.05713104f, -0.16357554f, -0.11712798f, 0.16734485f, 
    0.01811623f, -0.17325221f, -0.04691300f, 0.08792116f, -0.01518503f, -0.32640314f, -0.34388143f, 0.17814071f, 
    0.08885725f, -0.05723754f, 0.22652709f, -0.14171380f, -0.05917206f, 0.10934534f, -0.09615822f, -0.08193158f, 
    0.10662799f, -0.03062481f, -0.24917679f, 0.07937182f, -0.04114915f, 0.10442058f, 0.06413458f, 0.09361654f, 
    0.00675130f, 0.10905939f, 0.28366041f, 0.17942046f, 0.33172360f, 0.02104142f, 0.09137083f, -0.02821041f, 
    -0.06787547f, -0.08720409f, -0.02885026f, -0.02672047f, -0.13607748f, -0.17587908f, -0.15209238f, -0.02227899f, 
    -0.10182878f, 0.05662919f, 0.00172491f, -0.04031477f, 0.45627266f, -0.00697224f, 0.08576131f, 0.06437394f, 
    -0.12607865f, -0.01315308f, -0.13919133f, -0.19387420f, 0.09838957f, 0.12016275f, -0.05398629f, 0.16670069f, 
    -0.01354485f, -0.02453115f, -0.06726527f, 0.08982063f, -0.02945853f, -0.00803596f, 0.09813199f, -0.06603342f, 
    -0.27521411f, 0.34099188f, 0.30063680f, 0.00422396f, 0.13573888f, 0.03128466f, 0.16873701f, 0.04757129f, 
    0.06095903f, -0.06852014f, -0.06720272f, 0.09677062f, -0.00263192f, 0.10092198f, -0.16671741f, -0.04343171f, 
    0.01031616f, 0.06057574f, 0.07630927f, -0.07786899f, 0.32876131f, -0.04692686f, 0.37776637f, 0.03381729f, 
    0.15324564f, 0.17342985f, 0.18054540f, -0.05891317f, 0.00100538f, 0.02909540f, -0.01174789f, 0.08976496f, 
    0.01457713f, -0.05361956f, -0.04793146f, -0.09930860f, 0.02529158f, -0.11057691f, 0.03019769f, -0.14235416f, 
    -0.07394660f, 0.08349912f, 0.27021432f, 0.12563436f, 0.17588831f, -0.02801355f, 0.20872203f, 0.05597679f, 
    0.00885305f, -0.10085926f, -0.02924282f, -0.00593829f, 0.05123405f, -0.10001493f, -0.01866235f, -0.11197100f, 
    0.03586267f, 0.11871304f, 0.10049431f, -0.01370931f, -0.71735656f, -0.16640520f, -0.48487005f, -0.02245874f, 
    0.05781133f, 0.01551390f, -0.19636880f, -0.09919626f, -0.04466053f, -0.15155777f, -0.18302627f, -0.00514374f, 
    0.09996671f, -0.04531173f, -0.13553269f, -0.13454518f, -0.24621870f, 0.00838318f, 0.10889015f, 0.06519691f, 
    -0.51136076f, -0.23213570f, -0.51081014f, -0.27645296f, -0.17112163f, 0.03457516f, -0.19094306f, -0.01738614f, 
    -0.05522002f, -0.28100386f, -0.15962233f, -0.04053500f, -0.02502503f, -0.01764416f, -0.08922510f, -0.06430820f, 
    -0.00808696f, -0.08963540f, -0.02441906f, 0.10434004f, 0.09294096f, -0.15507035f, 0.24271418f, 0.17148980f, 
    0.51714730f, 0.08496581f, 0.18576558f, 0.06508274f, 0.01282065f, -0.03374648f, 0.04330112f, -0.01645545f, 
    -0.12337089f, -0.07665774f, -0.13924082f, -0.16084868f, 0.09085564f, -0.03704545f, -0.02095520f, -0.09506078f, 
    -0.11594439f, 0.09847932f, -0.09467820f, 0.18271688f, 0.18013035f, -0.11842289f, 0.02084972f, -0.13810970f, 
    0.03112515f, -0.00885360f, -0.05889321f, 0.03690727f, -0.20737045f, -0.05385987f, -0.13572913f, -0.02585226f, 
    -0.11413405f, 0.14968489f, -0.19684152f, -0.11038074f, 0.27300900f, 0.34402686f, 0.27663705f, -0.21074280f, 
    0.30327493f, -0.04739147f, 0.21712664f, -0.02057934f, -0.02095782f, -0.01875532f, -0.06002200f, -0.06677584f, 
    -0.15548496f, -0.05137830f, 0.02356182f, -0.09008633f, -0.01401824f, 0.10391518f, -0.01328394f, 0.07927556f, 
    0.17261223f, -0.12644956f, 0.20223837f, -0.02809368f, 0.04983909f, -0.10596479f, 0.17030437f, -0.00315260f, 
    0.08193160f, 0.12322813f, 0.04109384f, 0.15954112f, -0.11543033f, -0.00648257f, 0.02232162f, -0.11363478f, 
    0.13463585f, 0.07004251f, -0.06459779f, -0.04940586f, 0.16470818f, -0.08596204f, 0.01996786f, -0.15066439f, 
    -0.11646518f, -0.00112662f, -0.24822371f, -0.03967521f, -0.00985702f, 0.03866722f, 0.00663588f, -0.12112597f, 
    -0.13514344f, 0.00298379f, -0.13725990f, -0.07464552f, -0.12921223f, -0.08883280f, -0.04231318f, -0.07080073f, 
    -0.52432162f, 0.23342569f, 0.24456121f, -0.09404315f, -0.22266261f, -0.08101653f, -0.17023104f, -0.05122351f, 
    0.09367114f, -0.07334895f, 0.12163001f, 0.04140170f, -0.05367481f, 0.05438741f, -0.18969540f, 0.07629593f, 
    0.11196819f, -0.15764055f, -0.10960256f, -0.06086601f, 0.50915736f, -0.20135404f, -0.12149518f, -0.08023319f, 
    0.54516429f, -0.14216429f, -0.26412797f, -0.09847245f, -0.12357289f, 0.00157041f, -0.12984143f, 0.09656965f, 
    -0.07813945f, 0.04337121f, 0.00280952f, -0.08726394f, -0.00890227f, -0.01281922f, -0.05538942f, 0.00972994f, 
    -0.08631114f, -0.28828475f, -0.36950693f, -0.33079600f, -0.26808730f, 0.09182564f, -0.08546387f, -0.05499939f, 
    -0.11959237f, -0.16271745f, -0.09169247f, -0.03997322f, -0.17812887f, -0.13728140f, -0.09662864f, -0.10152236f, 
    0.06466612f, -0.05510958f, 0.01340078f, 0.06360129f, -0.04439268f, 0.25501004f, -0.17911084f, 0.07753143f, 
    0.12046304f, -0.11282482f, 0.17698219f, -0.12568606f, 0.03201463f, -0.03268024f, -0.22158685f, -0.05286554f, 
    -0.04015278f, -0.05717942f, -0.12317679f, -0.01503157f, -0.07828262f, 0.09263690f, -0.00056207f, -0.08327200f, 
    -0.17264830f, -0.09962197f, 0.25608957f, -0.20614919f, -0.26744798f, -0.18951285f, 0.15922929f, -0.09650610f, 
    -0.15188071f, -0.12216629f, 0.03709638f, 0.15882592f, 0.03470020f, 0.08016816f, -0.03840784f, -0.02111034f, 
    -0.01411161f, -0.14863005f, -0.45329595f, -0.01390414f, -0.17213438f, -0.21165369f, -0.22865233f, -0.27373987f, 
    -0.23273468f, 0.11446904f, 0.02701016f, -0.11898537f, -0.38625297f, -0.13555491f, 0.03166930f, 0.12461746f, 
    0.05119119f, 0.08537760f, 0.16064502f, 0.10612303f, 0.12985152f, -0.33018866f, 0.02419565f, 0.09442782f, 
    0.05466595f, -0.20640276f, 0.19197018f, 0.04554014f, -0.17625943f, -0.06373861f, 0.00966268f, -0.01217294f, 
    -0.06138898f, 0.08701627f, 0.01955457f, -0.09374425f, -0.09921937f, 0.01483200f, 0.09905159f, 0.07235082f, 
    0.09387848f, -0.18766278f, 0.08243959f, 0.00873319f, -0.35737324f, -0.12567858f, 0.27002192f, -0.14254071f, 
    0.15182100f, 0.08964179f, -0.05651928f, 0.16561416f, -0.12458072f, 0.06470969f, 0.06928370f, -0.03501310f, 
    -0.18984358f, -0.07254303f, 0.09467112f, -0.13197576f, -0.05560052f, 0.05280373f, -0.14550786f, -0.04932209f, 
    -0.12109456f, -0.00889566f, 0.30567273f, 0.15054122f, 0.25338948f, -0.21230757f, -0.03669293f, 0.12955485f, 
    0.08874402f, 0.02420974f, -0.04520658f, -0.06452968f, -0.14045183f, -0.14928755f, 0.06128551f, 0.02194257f, 
    0.01747869f, 0.04048594f, 0.07796113f, 0.08251560f, -0.08211273f, -0.07404248f, -0.30636322f, 0.16117722f, 
    0.17735755f, 0.17097600f, 0.00987785f, -0.17063287f, -0.04801800f, -0.20333125f, -0.02085157f, -0.00503891f, 
    0.05216074f, -0.02079034f, 0.17374265f, -0.06211791f, 0.11071561f, 0.06229072f, 0.16111943f, -0.17685974f, 
    0.31016651f, 0.07995559f, -0.34922686f, 0.15294801f, 0.25638005f, 0.18837470f, 0.05685799f, -0.09198532f, 
    -0.06940608f, 0.01103392f, -0.02717399f, 0.02496879f, -0.15321304f, 0.26500773f, -0.06436244f, -0.10540497f, 
    -0.09457262f, 0.16629438f, 0.09580582f, 0.00767582f, -0.36692217f, -0.16403922f, 0.31422806f, 0.01387156f, 
    0.22328046f, -0.19243765f, -0.14383219f, -0.10905913f, -0.09481922f, -0.16152455f, 0.06977877f, 0.00777442f, 
    -0.12812953f, -0.15093730f, 0.06169584f, -0.03885508f, -0.03082980f, -0.00778156f, 0.03491721f, -0.07323862f, 
    -0.03001115f, 0.22047786f, 0.26509762f, -0.18193215f, -0.26721513f, -0.22908813f, 0.02675288f, -0.13270316f, 
    -0.00949935f, -0.06778670f, 0.16717106f, -0.05243452f, 0.12304387f, 0.03610823f, -0.08678994f, -0.14370717f, 
    -0.05065599f, -0.18423618f, 0.05963448f, 0.03699569f, -0.40007120f, 0.39069355f, -0.00018589f, -0.28323060f, 
    -0.34477490f, -0.02772287f, 0.00433216f, 0.06655929f, 0.03022797f, -0.01801450f, 0.07664248f, -0.07174819f, 
    -0.06833144f, 0.09296008f, 0.04266532f, -0.07906923f, 0.15837692f, -0.24184473f, 0.12836941f, 0.05547003f, 
    0.14998296f, 0.19646607f, 0.00285402f, -0.13997576f, 0.01133785f, -0.15069126f, -0.11551280f, -0.05398076f, 
    0.01524740f, -0.16775365f, 0.10004606f, -0.00940506f, -0.21654797f, -0.09723761f, 0.02870742f, -0.03070278f, 
    0.08720606f, 0.05476266f, 0.11699138f, -0.05889305f, 0.29463279f, 0.25956982f, 0.02248658f, 0.11805693f, 
    0.34637004f, -0.00377702f, -0.00183571f, -0.09249199f, -0.16235547f, -0.13947082f, -0.01475790f, -0.08728807f, 
    -0.06979515f, 0.00235431f, -0.05741623f, 0.07799736f, -0.03602074f, 0.13188729f, 0.11888788f, 0.18690491f, 
    0.31400847f, 0.18058957f, -0.29938582f, 0.25927886f, 0.12925737f, -0.05978427f, 0.05546314f, -0.42575872f, 
    -0.08831442f, -0.04537417f, -0.08416100f, 0.06563489f, 0.05880840f, -0.30232683f, 0.00232504f, -0.03603386f, 
    -0.02878960f, 0.00118179f, 0.29089126f, -0.12353921f, -0.32352486f, -0.48151642f, -0.41327453f, -0.56257910f, 
    -0.18771647f, 0.07906485f, -0.13792045f, -0.18559551f, -0.29136819f, -0.18705496f, 0.15093197f, 0.22390524f, 
    0.13174666f, 0.10859183f, -0.04026972f, 0.00824156f, 0.02829329f, 0.12295680f, -0.41383970f, -0.11472341f, 
    0.21252345f, 0.18530196f, 0.07424615f, 0.05127280f, 0.09915864f, 0.25752324f, 0.00973737f, -0.12703466f, 
    0.02006169f, 0.01207509f, -0.00422057f, 0.12211201f, 0.07339543f, -0.04295195f, 0.01511606f, -0.11888573f, 
    -0.02729040f, 0.08958942f, 0.06179686f, -0.06330843f, -0.21806733f, 0.20200488f, -0.02174442f, 0.15272400f, 
    -0.22388390f, -0.24208425f, -0.11364093f, 0.00726071f, -0.16372778f, -0.13252224f, 0.19616468f, -0.04858001f, 
    -0.07310198f, -0.07105605f, 0.01642296f, -0.14421983f, -0.04496233f, -0.14850384f, 0.19291525f, 0.01481116f, 
    -0.21014313f, -0.17643774f, -0.04611794f, 0.39618030f, 0.10146040f, -0.07824676f, 0.08920434f, 0.14216025f, 
    -0.10123571f, -0.15933745f, 0.03542173f, 0.06663127f, -0.18864894f, -0.06552814f, -0.22436674f, -0.03224212f, 
    -0.05483180f, 0.04198436f, 0.05783320f, 0.14005642f, 0.40467912f, -0.48616111f, 0.07286955f, -0.12004588f, 
    0.33547035f, -0.03311755f, -0.03355027f, 0.08011183f, 0.16642061f, 0.05555458f, -0.05805476f, -0.05167185f, 
    -0.14773177f, -0.09525130f, -0.01386952f, -0.05974271f, -0.07299591f, 0.00040658f, 0.12015214f, 0.13271180f, 
    -0.66627485f, -0.28880423f, -0.12291116f, 0.19399008f, 0.16655627f, 0.12371765f, -0.04164540f, -0.20962092f, 
    -0.00099977f, 0.36026710f, -0.08064075f, 0.17457467f, -0.15383929f, 0.10757668f, -0.13008364f, -0.01779787f, 
    -0.08175881f, 0.06716923f, -0.19595614f, 0.01037509f, 0.23767863f, -0.12861928f, -0.06778266f, 0.30279830f, 
    -0.14524789f, -0.12381917f, 0.09964735f, 0.01383177f, -0.02638046f, -0.03975946f, 0.08165488f, 0.10922022f, 
    0.16332969f, 0.02919098f, 0.13640331f, 0.14800769f, 0.00428229f, -0.03771611f, 0.02722419f, -0.01812191f, 
    0.05304372f, -0.12452059f, 0.10299976f, 0.19773966f, -0.09513598f, 0.12045974f, -0.01280146f, -0.23049650f, 
    0.06250507f, 0.16921395f, -0.14175220f, 0.03807781f, -0.05071105f, 0.08733010f, 0.03218158f, -0.23379667f, 
    -0.08485866f, -0.06452116f, -0.07716084f, -0.00934755f, -0.23715973f, -0.07114223f, 0.27120477f, -0.40307212f, 
    -0.24857213f, -0.08495917f, 0.23479122f, -0.19178207f, -0.14893077f, 0.07395983f, 0.00990874f, -0.12774625f, 
    -0.16363186f, -0.13154913f, 0.05998088f, 0.00891639f, -0.03273088f, 0.12456176f, -0.28671283f, -0.01850574f, 
    0.16827959f, -0.01801075f, 0.18527348f, -0.36820468f, -0.35952163f, 0.13865176f, 0.12532823f, 0.16558312f, 
    -0.21017015f, -0.24402890f, -0.21988586f, 0.00492103f, 0.00983928f, -0.22067934f, 0.21609919f, -0.01488123f, 
    -0.00413723f, -0.17973273f, 0.17793430f, -0.00026770f, 0.81210893f, -0.22775500f, -0.38026142f, -0.20152622f, 
    0.17266355f, 0.24895136f, -0.25062326f, 0.09940648f, -0.05752265f, 0.12045727f, -0.19285083f, -0.13486151f, 
    0.17514743f, 0.17023230f, 0.06100506f, 0.11568807f, 0.07566590f, -0.09617028f, 0.03346514f, -0.00264136f, 
    -0.13487393f, 0.29936722f, 0.06526761f, 0.08358169f, -0.15154698f, -0.08192500f, 0.07306575f, -0.05594061f, 
    -0.10602815f, 0.02497956f, -0.10926657f, 0.03972319f, 0.04001843f, 0.08182840f, 0.10562178f, 0.11283758f, 
    -0.02255899f, -0.02647214f, -0.00678878f, -0.13858578f, -0.36777520f, 0.01945229f, -0.16335109f, 0.18746389f, 
    -0.22212259f, -0.00177338f, 0.04072209f, -0.14920409f, 0.03185342f, 0.09080760f, -0.07392253f, -0.00584240f, 
    -0.16679417f, 0.06555761f, 0.15776287f, 0.06139077f, -0.01424321f, -0.03681150f, -0.03710653f, 0.15437649f, 
    -0.29253983f, 0.45070931f, -0.08963095f, 0.19706203f, -0.00631899f, 0.00959130f, 0.09214259f, 0.01923553f, 
    0.09501543f, -0.07801492f, -0.07401787f, 0.04818373f, 0.15491106f, 0.03165188f, 0.08073919f, 0.02605473f, 
    -0.02463391f, 0.12365470f, -0.10310770f, -0.05443675f, -0.09846375f, 0.01515338f, -0.17868677f, -0.11708564f, 
    -0.08336223f, 0.22247933f, -0.00494114f, -0.06757171f, -0.17167632f, -0.24798757f, 0.19461437f, 0.10963205f, 
    -0.00696888f, 0.09654604f, -0.15017584f, -0.03612109f, 0.00114281f, -0.17511947f, 0.05321459f, -0.14508954f, 
    -0.45037532f, -0.21228796f, 0.35542744f, -0.20623644f, 0.14321262f, 0.09524159f, 0.13453448f, 0.12719728f, 
    -0.00582358f, -0.18471870f, 0.13512108f, 0.22041157f, -0.04728655f, 0.04637795f, 0.07897318f, 0.11883400f, 
    -0.10371702f, 0.04716853f, -0.40378487f, 0.27751219f, -0.01203517f, -0.19060184f, -0.01409328f, -0.46747613f, 
    -0.56084615f, -0.08234558f, 0.12316457f, 0.04568581f, -0.00546075f, -0.08089732f, -0.04521786f, 0.01603537f, 
    0.12126797f, -0.04475374f, -0.14076187f, 0.01531089f, -0.04924922f, 0.22639495f, 0.23374724f, 0.10944812f, 
    0.31363341f, -0.36257926f, 0.26741889f, -0.11993127f, -0.46656027f, 0.01243970f, 0.01382491f, 0.01989346f, 
    0.08100331f, 0.01806016f, 0.04882929f, -0.02124390f, 0.19211124f, -0.06698473f, -0.04165109f, 0.02545415f, 
    0.03876935f, 0.01077897f, -0.14819764f, -0.13243245f, -0.91213363f, 0.49488381f, -0.11727002f, 0.09610844f, 
    -0.08439690f, -0.02313276f, 0.13529962f, -0.02989156f, 0.02468231f, 0.13867016f, -0.23775502f, -0.05371224f, 
    -0.07021762f, 0.13047105f, 0.28265443f, 0.13697273f, 0.02639315f, 0.04159449f, -0.13195282f, -0.03123563f, 
    0.46843848f, 0.22827952f, -0.11185121f, -0.08404633f, -0.16180596f, 0.04889074f, -0.15876104f, 0.21672514f, 
    -0.12677202f, -0.00827040f, 0.05008614f, -0.18035978f, 0.06213821f, 0.05526263f, -0.11494920f, -0.02800477f, 
    0.15088323f, -0.12259288f, -0.13795884f, -0.00468696f, 0.00868975f, 0.00451224f, -0.16405749f, 0.05135100f, 
    0.21521597f, -0.02979159f, 0.16132514f, -0.00198057f, -0.11736093f, 0.16054071f, -0.03057452f, 0.05850054f, 
    -0.02575787f, -0.11192369f, 0.04325536f, 0.15382935f, 0.11329012f, 0.15647815f, -0.15915839f, 0.11206644f, 
    0.49143389f, 0.14391066f, -0.37628588f, 0.20295370f, -0.22009480f, -0.05630324f, -0.17583509f, 0.13727593f, 
    0.03108289f, 0.00142654f, 0.09551108f, -0.06432737f, -0.01173869f, -0.15628755f, -0.02883157f, -0.02637191f, 
    0.02513194f, -0.05307577f, 0.06193652f, 0.06316750f, 0.33241177f, -0.22870082f, -0.01493358f, -0.03225924f, 
    0.10184405f, -0.12036800f, -0.02908919f, -0.19668990f, 0.08250491f, -0.09003429f, 0.04797572f, 0.08948700f, 
    -0.06072365f, 0.00075460f, -0.08201972f, -0.26024804f, -0.00813152f, -0.15323286f, -0.31543860f, 0.06048024f, 
    0.47896600f, 0.10448589f, -0.02763790f, 0.05549250f, -0.05911330f, -0.23906423f, -0.15199687f, 0.04619055f, 
    0.06127163f, -0.18182567f, -0.17275929f, 0.00153977f, -0.02030857f, 0.03175708f, -0.03713779f, -0.14600696f, 
    0.13553816f, 0.00589629f, -0.01663226f, -0.14527765f, -0.86600393f, -0.47584134f, 0.01739700f, -0.29597193f, 
    -0.37228385f, 0.16777670f, -0.05815996f, -0.03913241f, -0.06946544f, -0.00406200f, 0.09929039f, 0.04173579f, 
    0.02040141f, 0.32152998f, 0.00686171f, 0.08821768f, -0.11479110f, -0.21654648f, -0.15134622f, -0.12152752f, 
    -1.13430166f, -0.87509179f, -0.34734616f, -0.17826536f, -0.34080508f, 0.20569006f, 0.02442910f, -0.16585641f, 
    -0.20565161f, 0.20914559f, 0.16867365f, 0.11154837f, -0.00200421f, 0.21944587f, -0.05953966f, 0.14349718f, 
    0.15125909f, 0.13377883f, 0.13776642f, 0.11343462f, 0.16439767f, 0.21892881f, 0.04942959f, 0.12340087f, 
    0.02139637f, -0.03022412f, -0.00294999f, 0.04209854f, -0.01892209f, 0.01778379f, -0.02961604f, 0.02918935f, 
    -0.03449758f, -0.16314588f, -0.00817850f, -0.05277534f, -0.04407786f, 0.18800488f, -0.15875345f, -0.01251149f, 
    -0.11127646f, -0.06217092f, 0.02032022f, 0.01201782f, 0.06206497f, 0.16686888f, -0.01936374f, -0.03689729f, 
    -0.00446270f, 0.24585584f, 0.05000035f, 0.00312894f, 0.09379216f, 0.02795472f, 0.00862015f, 0.04569972f, 
    0.05814684f, -0.20746800f, 0.20022902f, 0.04992554f, -0.07674374f, -0.19535583f, -0.06403675f, 0.04423768f, 
    0.11387727f, -0.01126084f, 0.14637807f, 0.08562943f, 0.07769823f, 0.02435057f, 0.00007275f, -0.00177395f, 
    0.12180594f, 0.02552585f, 0.04819272f, -0.07526678f, 0.14493637f, -0.29183862f, -0.13090594f, 0.01614086f, 
    0.01560545f, -0.07458807f, -0.03580063f, 0.01133739f, 0.02262090f, -0.09832548f, -0.02710655f, 0.00682320f, 
    0.11829455f, 0.01611831f, -0.08227435f, -0.22795968f, 0.02526917f, -0.19399990f, -0.01862512f, -0.18391378f, 
    0.03897319f, -0.05374134f, 0.16864546f, 0.09740842f, -0.14330581f, 0.01413846f, -0.32194749f, -0.23136102f, 
    -0.03297247f, 0.12728973f, 0.14458509f, -0.10601313f, 0.03693365f, 0.05559311f, -0.05888528f, 0.05386259f, 
    0.03149668f, -0.10425710f, 0.06767539f, -0.18886949f, 0.16318594f, 0.30544677f, 0.11696363f, 0.19261284f, 
    -0.61162639f, -0.40117991f, -0.35144368f, -0.20605963f, 0.02931234f, 0.03155555f, 0.09400652f, -0.21566224f, 
    -0.14152744f, 0.02141546f, 0.15782209f, -0.07619922f, 0.00956758f, -0.02781639f, 0.16412619f, -0.06420116f, 
    0.04107940f, 0.15416418f, 0.09554861f, 0.05683103f, 0.03499681f, 0.39490527f, 0.35319829f, -0.03734346f, 
    -0.22256973f, -0.03553607f, 0.06327906f, -0.06675145f, 0.17899348f, 0.15562961f, -0.10913945f, 0.10374125f, 
    0.09392561f, -0.03153487f, -0.00434145f, 0.34369329f, -0.02611667f, -0.21289244f, -0.20256890f, 0.07222563f, 
    -0.74353313f, 0.33863577f, -0.18578497f, -0.19493318f, -0.18169518f, 0.23464853f, -0.04504746f, 0.04110957f, 
    -0.06244406f, 0.09392208f, -0.18250263f, 0.13222687f, 0.01599702f, 0.17578502f, 0.14317161f, -0.06404759f, 
    -0.03360289f, 0.19259687f, -0.09223071f, 0.07685951f, -0.65041679f, -0.63447171f, 0.22158523f, 0.08647760f, 
    0.11063770f, 0.16155201f, 0.10470049f, 0.05981905f, -0.01702296f, 0.00685990f, 0.23043643f, 0.00844098f, 
    0.14786175f, -0.06264692f, 0.00225884f, 0.05220414f, 0.00078917f, -0.22637922f, -0.00303164f, -0.07746255f, 
    0.23041505f, 0.12026718f, -0.14715320f, -0.20814544f, -0.09862798f, -0.23065606f, -0.23616998f, -0.11301586f, 
    -0.07499624f, -0.30866548f, 0.05900828f, -0.09060532f, -0.10514022f, -0.00476091f, -0.06151017f, 0.07647599f, 
    -0.09948929f, -0.08423110f, 0.15392201f, -0.14731829f, -0.03595838f, 0.35832801f, -0.16687883f, 0.07320775f, 
    0.16135028f, -0.05785622f, 0.19742107f, -0.16117281f, -0.09214073f, 0.00714138f, -0.21859680f, 0.12307702f, 
    0.02583064f, 0.10658992f, -0.10613879f, 0.14076546f, 0.16169493f, -0.02711090f, 0.11685999f, -0.12368940f, 
    0.44308800f, -0.15052137f, 0.13701600f, 0.14811261f, -0.08921138f, 0.02869629f, 0.10824433f, 0.22253771f, 
    -0.10264019f, -0.04553330f, -0.31472689f, -0.17917922f, 0.14636891f, 0.01370642f, -0.10907858f, -0.13407534f, 
    0.01400589f, 0.03050044f, -0.20770718f, -0.16003500f, -0.42002794f, 0.49120614f, 0.06574114f, -0.06748831f, 
    -0.14175572f, 0.00276441f, -0.22367974f, -0.00665955f, -0.12868683f, -0.17251785f, 0.03260409f, -0.06020052f, 
    0.05259645f, 0.01225835f, 0.14101544f, 0.05466922f, -0.01641124f, -0.20042118f, 0.06549798f, 0.01935359f, 
    -0.05288341f, -0.06824430f, 0.24441960f, 0.01363228f, -0.03225067f, -0.02304685f, 0.01837563f, 0.14735678f, 
    -0.08894441f, -0.06416005f, -0.10476884f, -0.25633046f, 0.14884168f, -0.08174153f, -0.16843404f, -0.19663624f, 
    -0.07272668f, -0.29342309f, -0.07946771f, -0.08224192f, 0.78539711f, 0.18984777f, -0.58417428f, -0.15782619f, 
    0.07315902f, -0.04599850f, -0.01629755f, -0.15196145f, 0.02883965f, -0.12158818f, 0.19729657f, 0.11944354f, 
    0.05319658f, 0.10910578f, -0.04490937f, 0.10868028f, 0.11774024f, -0.02446384f, -0.04449151f, 0.05017037f, 
    0.76531452f, -0.07792713f, -0.36293158f, 0.00710276f, -0.16843984f, 0.20651165f, 0.01360837f, 0.03091305f, 
    -0.00510054f, 0.06221410f, 0.26861823f, 0.05998060f, -0.01763779f, 0.04658077f, -0.01016190f, 0.19933245f, 
    -0.19340613f, 0.08940444f, -0.01203725f, 0.25353524f, -0.58974743f, 0.15022279f, -0.03268228f, -0.17272671f, 
    0.23538700f, -0.28269523f, -0.03185753f, -0.00999448f, 0.19183387f, -0.14106837f, -0.04711792f, -0.02375402f, 
    0.06244715f, 0.03095867f, 0.05596224f, -0.01739128f, -0.17350642f, 0.09573347f, -0.22884831f, -0.13748832f, 
    0.09146626f, -0.20893379f, -0.04732950f, -0.07692942f, 0.14191325f, -0.00115393f, -0.27803242f, -0.04156283f, 
    -0.21935230f, -0.11461467f, 0.08279496f, 0.07212658f, -0.07442254f, -0.01141525f, -0.12977394f, -0.01939182f, 
    0.04198384f, -0.04366300f, 0.10577326f, 0.08315697f, -0.17331713f, 0.25616667f, -0.06150861f, 0.06566234f, 
    0.07124323f, 0.07255448f, -0.38110223f, 0.08535997f, -0.04056107f, -0.10084867f, 0.24384563f, 0.28455636f, 
    0.02812819f, -0.01005585f, 0.07460875f, 0.02596576f, 0.24897397f, -0.05828457f, -0.01802638f, 0.06610195f, 
    -0.13683274f, -0.34125578f, -0.18159793f, 0.06994464f, -0.06126394f, 0.09315666f, -0.10976125f, 0.01324793f, 
    -0.07283183f, -0.02357286f, -0.11402641f, -0.04478062f, 0.01164139f, -0.07202597f, -0.16084991f, -0.15283148f, 
    0.03082652f, -0.08258297f, -0.09133749f, -0.00357671f, -0.78204703f, -0.43594900f, -0.05133449f, -0.19556031f, 
    -0.06161694f, -0.03594210f, 0.09765417f, 0.09604913f, 0.06787623f, 0.17194626f, -0.10199966f, 0.13966899f, 
    0.11767152f, -0.10263675f, -0.12524541f, -0.11318269f, -0.06073441f, -0.11353131f, -0.29274631f, -0.12777458f, 
    -0.27941650f, -0.30849797f, -0.10828041f, 0.04864851f, -0.61805707f, 0.20725617f, 0.15711236f, -0.08970042f, 
    0.05051438f, 0.07887103f, -0.06492747f, -0.12246287f, 0.11112636f, -0.02814610f, 0.07720760f, -0.19880192f, 
    0.05679367f, -0.14724348f, -0.22335842f, 0.03253227f, 0.16494602f, 0.20091398f, -0.23456924f, -0.14157717f, 
    0.95609039f, 0.24137005f, -0.14537334f, -0.00905289f, 0.14208262f, 0.02547924f, 0.12119593f, 0.02897867f, 
    0.08741356f, 0.12374182f, 0.03518729f, -0.06360113f, 0.04995575f, 0.02061141f, 0.04232311f, -0.00940679f, 
    0.60151076f, -0.16811772f, -0.28600222f, -0.04381064f, -0.14395033f, -0.02719416f, 0.26368728f, -0.08732333f, 
    0.17504601f, 0.05958273f, 0.16126470f, -0.04700212f, -0.01355453f, -0.09176745f, 0.22682674f, -0.01806985f, 
    -0.06742740f, -0.06421655f, 0.04094969f, 0.06802759f, -0.05437418f, 0.21714664f, -0.18817152f, 0.12801380f, 
    0.29241407f, 0.18101084f, -0.06673679f, -0.04635896f, 0.09218713f, 0.06259879f, 0.00475109f, 0.09417551f, 
    -0.19263062f, -0.05618529f, 0.21867719f, -0.03308953f, 0.24274147f, 0.11270799f, -0.17902859f, -0.03710632f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09979240f, 0.07345614f, -0.10194299f, -0.07599763f, 0.01948204f, -0.06576841f, 0.06565408f, -0.15556005f, 
    -0.06126037f, -0.01349583f, 0.12677723f, 0.01961323f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
