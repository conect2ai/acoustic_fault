#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.26233006f, -0.37086022f, -0.00163086f, -0.04996091f, 0.29652163f, -0.28962323f, 0.14431408f, 0.33493885f, 
    0.04249550f, -0.18995951f, -0.33743796f, 0.11920386f, 0.24545680f, -0.14495404f, 0.17097542f, 0.04779006f, 
    0.08513715f, 0.15919854f, -0.08295935f, -0.32865840f, -0.08702553f, -0.15582590f, -0.40909648f, 0.30524576f, 
    0.39194968f, -0.49338099f, -0.26230764f, -0.36727035f, -0.30790868f, -0.32549623f, -0.27740982f, -0.38558042f, 
    -0.14433643f, -0.27491453f, -0.45766228f, -0.35182768f, -0.18378097f, 0.21246980f, 0.14508007f, -0.18129145f, 
    0.12145694f, -0.21847965f, 0.02658400f, 0.05140249f, 0.13107397f, 0.21669699f, 0.29977122f, 0.22098206f, 
    0.01564878f, 0.25629786f, -1.05912459f, -0.24696450f, -0.19815619f, -0.27890962f, -0.27181366f, -0.07455955f, 
    0.04680498f, 0.34747720f, 0.48127991f, -0.10022128f, 0.14394785f, 0.20274976f, 0.26840654f, 0.25549075f, 
    0.18325368f, -0.05122397f, -0.12368113f, 0.18577607f, 0.03812372f, -0.06160942f, -0.03226063f, 0.23359214f, 
    0.31793490f, -0.15795696f, -0.16330776f, 0.14702126f, 0.32805261f, 0.49183553f, 0.31706843f, -0.23619141f, 
    -0.33236772f, -0.23345570f, 0.07923511f, -0.06506030f, -0.26377499f, -0.14923202f, -0.32622716f, -0.17390522f, 
    0.01779857f, 0.16069515f, 0.51107210f, 0.36139059f, -0.00680842f, 0.07479381f, -0.33655912f, -0.14802870f, 
    -0.05177786f, -0.26299450f, -0.15398169f, -0.38983378f, 0.13993788f, -0.06079707f, 0.13346115f, -0.16612147f, 
    0.31662408f, -0.25408223f, -0.42654052f, 0.17375892f, -0.28177252f, 0.12514962f, 0.15478459f, 0.18922856f, 
    -0.20798929f, 0.01732689f, 0.19673863f, -0.24499153f, 0.10848825f, -0.06616990f, -0.07197567f, 0.26250508f, 
    -0.26094434f, 0.01441492f, 0.09476229f, 0.22959295f, 0.05021542f, 0.63017082f, -0.14960514f, -0.11930944f, 
    -0.11313614f, -0.43463540f, -0.17853244f, -0.61147499f, -0.32529348f, 0.35676721f, -0.07065438f, 0.48429391f, 
    -0.13440911f, 0.11463003f, 0.59118444f, -0.13028571f, 0.08891355f, 0.11541208f, -0.22932936f, 0.15097460f, 
    -0.22537705f, -0.17153238f, 0.04075736f, -0.19599688f, -0.07006298f, 0.14912941f, -1.19272435f, -1.00752616f, 
    -0.09185979f, 0.77352631f, 0.43818220f, 0.76622307f, 0.18367474f, -0.17701086f, 0.12948415f, 0.00487119f, 
    -0.18005235f, 0.00700926f, -0.21392225f, 0.19066980f, -0.10961881f, 0.36136946f, 0.11548661f, -0.12434659f, 
    0.15049596f, -0.20739622f, -0.02646997f, -0.11398213f, -0.12234400f, 0.13248837f, 0.16581757f, -0.72032928f, 
    -0.78885448f, -0.87764847f, -0.78864533f, -0.91736615f, 0.64845049f, 0.26689312f, 0.23687434f, 0.19351201f, 
    0.40804803f, -0.01067015f, -0.11811996f, 0.17004143f, 0.00497058f, -0.02309692f, 0.04823292f, -0.20995934f, 
    -0.25120690f, -0.29905549f, -0.24479951f, -0.12625298f, -0.21947208f, -0.09642142f, -0.12678915f, -0.39003778f, 
    0.22284526f, 0.13300966f, -0.36364225f, -0.08125911f, 0.31778479f, -0.39614561f, 0.00726159f, 0.04034910f, 
    -0.09216472f, 0.35292882f, 0.37006772f, -0.20270726f, -0.25725642f, -0.20152900f, 0.03160235f, 0.23150960f, 
    -0.19208471f, -0.21485947f, 0.19571951f, 0.04493403f, -0.14269018f, -0.01250630f, 0.26264483f, -0.11596017f, 
    0.06203027f, 0.67056984f, -0.40738437f, -0.29049700f, 0.23557128f, 0.42650339f, 0.20260479f, 0.50207764f, 
    -0.22490613f, -0.37589636f, -0.38847262f, -0.30699345f, 0.01807863f, 0.24428725f, -0.31638503f, -0.09092474f, 
    0.04198355f, 0.13520247f, 0.18085608f, 0.43273294f, -0.00946919f, 0.11755529f, -0.20588832f, -0.29185122f, 
    -0.11398064f, -0.12540649f, 0.50132269f, 0.15754955f, -0.12685573f, 0.22593234f, -0.57809711f, -0.61527282f, 
    -0.46872520f, -0.70031941f, -0.77296722f, -0.91380894f, 0.34887719f, -0.28924757f, -0.17437461f, 0.23710033f, 
    0.08152586f, -0.13473700f, -0.01414232f, -0.23707269f, 0.34058103f, -0.35788539f, -0.15734600f, -0.30745474f, 
    -0.03394065f, -0.20515403f, 0.05910333f, -1.06511223f, -0.38350150f, 0.04079818f, 0.40184361f, 0.58136284f, 
    -0.07903781f, -0.09337346f, -0.03251949f, 0.35413045f, 0.19327240f, -0.13804099f, -0.19663338f, 0.09275863f, 
    0.19489203f, 0.08908236f, 0.38000667f, -0.28743613f, 0.02134392f, -0.02503859f, -0.21419841f, -0.11562061f, 
    -0.27513820f, -0.22949186f, -0.27865833f, -0.59562469f, 0.96582663f, 0.44564480f, 0.04533409f, -0.44141954f, 
    -0.57122159f, 0.16304557f, 0.08676004f, 0.06301684f, 0.25272724f, -0.69485986f, -0.15797681f, -0.17878750f, 
    -0.14738101f, -0.14219609f, 0.22543482f, 0.00546490f, 0.18801838f, 0.10905641f, -0.19995296f, 0.08050005f, 
    -0.18100537f, -0.16772184f, -0.18722236f, 0.18803853f, -0.07949168f, 0.00159566f, -0.03390407f, 0.24967347f, 
    -0.24691156f, -0.53735131f, -0.55617321f, -0.17423213f, -0.61914402f, -0.38617122f, 0.07149972f, 0.13295873f, 
    -0.36086357f, -0.01692090f, -0.27943009f, -0.10346947f, -0.35721129f, -0.10462121f, -0.23927534f, -0.08160420f, 
    -0.33885214f, 0.00051337f, 0.10051330f, -0.15156834f, 0.35044366f, 0.15269926f, 0.66566396f, 0.64274603f, 
    -0.02519542f, 0.27244046f, -0.29697168f, 0.10734535f, 0.00033965f, -0.30914992f, -0.29661965f, -0.36617067f, 
    -0.05120639f, 0.39934021f, 0.04808731f, -0.26135322f, -0.00065735f, -0.22242618f, -0.14352201f, -0.06046435f, 
    0.04668299f, 0.22444648f, 0.13830973f, -0.12514517f, 0.15716875f, -0.03222394f, 0.00952597f, -0.21166046f, 
    -0.17889583f, -0.05330567f, 0.15698728f, 0.12441578f, 0.22590807f, -0.11081328f, -0.13783881f, -0.01685448f, 
    0.17093368f, -0.06003396f, 0.21827979f, -0.03198614f, 0.06894846f, 0.22211207f, -0.39314434f, 0.14349733f, 
    -0.14878930f, -0.09203294f, 0.14276299f, 0.17460182f, 0.20574491f, 0.15325914f, 0.02328443f, -0.13487965f, 
    -0.91143733f, -0.44285706f, -0.64865804f, 0.35719559f, 0.53716677f, 0.09754793f, 0.31386933f, -0.10552312f, 
    -0.03688657f, -0.10679147f, 0.14553054f, -0.21612801f, 0.06596085f, 0.37621006f, 0.00497572f, 0.13825509f, 
    -0.07183631f, -0.36725855f, -0.16918059f, -0.25214994f, -0.01192547f, 0.36645809f, 0.31528285f, 0.08627395f, 
    0.26111642f, 0.56197613f, 0.51064926f, -0.01416757f, -0.22529915f, -0.09309766f, -0.38019952f, 0.22039293f, 
    0.17890520f, -0.34413117f, -0.32604507f, -0.23542620f, 0.31315169f, -0.21993163f, -0.18855223f, 0.02401186f, 
    -0.08469541f, -0.24139653f, 0.01314946f, 0.05542843f, 0.02295968f, -0.13307309f, -0.21861336f, -0.36560473f, 
    -0.16915984f, -0.54349875f, 0.33091146f, 0.35786343f, -0.35730910f, 0.15585551f, 0.06468854f, -0.45088667f, 
    -0.24474515f, 0.28678751f, 0.31491575f, 0.28958598f, -0.07528806f, -0.04197089f, -0.27858299f, -0.25209960f, 
    -0.38463613f, 0.21646811f, -0.06717212f, 0.10787667f, 0.20484735f, -0.24096057f, -0.35056818f, 0.09545558f, 
    -0.01759118f, -0.07356934f, 0.12854815f, -0.33220804f, 0.09173986f, 0.20363423f, 0.36195660f, 0.49089152f, 
    0.47374749f, 0.46528134f, 0.11046651f, -0.11832653f, 0.08069630f, 0.07355904f, 0.18117890f, -0.07611034f, 
    -0.12322646f, -0.13082317f, -0.16982190f, 0.09966292f, -0.09075060f, 0.13375738f, -0.04627456f, 0.15917796f, 
    -0.17995697f, -0.06147901f, -0.11712290f, -0.00783881f, -0.54647136f, -0.98156893f, 0.36357483f, 0.36006042f, 
    0.36596671f, -0.41525289f, -0.78839642f, -0.31302649f, -0.33701086f, -0.55081439f, 0.02525103f, 0.13100979f, 
    -0.30887631f, -0.16917142f, -0.43041131f, -0.32178739f, -0.15839989f, -0.04573396f, -0.12103773f, -0.14482442f, 
    -0.38179341f, 0.05792082f, -0.09182882f, -0.16556132f, -0.26839548f, 0.12743294f, 0.50693619f, 0.44382557f, 
    -0.02909322f, -0.30923852f, -0.65275598f, -0.39159372f, 0.35624337f, 0.28596193f, -0.05718782f, -0.55211222f, 
    -0.14352925f, 0.26148248f, 0.24126749f, -0.43837953f, 0.33583501f, -0.00562997f, -0.21277389f, -0.01692306f, 
    0.37073216f, -0.04002436f, 0.07903525f, -0.25046128f, 0.03863796f, -0.17419884f, -0.33387333f, -0.76045710f, 
    0.18360122f, -0.20704313f, 0.13229674f, -0.51887083f, -0.50877905f, -0.23814736f, -0.41720375f, -0.65074599f, 
    0.31979740f, 0.39391115f, 0.22919752f, 0.66329527f, -0.07342665f, 0.19077633f, -0.22513773f, -0.35338897f, 
    -0.30190739f, -0.13462672f, 0.20873304f, 0.03229362f, -0.04157689f, -0.09072884f, 0.02277393f, 0.80531228f, 
    0.26959246f, 0.08825085f, -0.65725011f, -0.78294283f, 0.24654149f, 0.03459726f, 0.09445442f, 0.02206917f, 
    -0.26418757f, 0.07159521f, -0.16979656f, 0.57848531f, -0.48545629f, -0.31254935f, 0.23422052f, 0.23958689f, 
    0.06704868f, -0.02699319f, -0.05540649f, -0.11956657f, -0.13488163f, -0.00413967f, 0.34302053f, 0.09875702f, 
    0.24133180f, -0.04194615f, -0.18902808f, -0.03382117f, -0.41324773f, -0.21341084f, 0.05466325f, 0.25387779f, 
    0.36219952f, 0.14759000f, -0.37676194f, -0.54127616f, -0.19609416f, 0.68749040f, -0.38301557f, -0.26167986f, 
    -0.12859213f, 0.20048805f, 0.46339649f, -0.09290450f, -0.08177438f, -0.17826293f, -0.03520617f, -0.09911084f, 
    -0.26227298f, -0.79137498f, -0.40410525f, 0.02231784f, -0.80620778f, -0.14274536f, 0.28049642f, -0.46392280f, 
    -0.57248288f, -0.33345672f, -0.01625265f, -0.43438628f, -0.50788510f, -0.13017561f, 0.13687550f, -0.44001722f, 
    0.32062739f, 0.10519068f, -0.02802664f, -0.02972420f, -0.02966593f, -0.10437316f, 0.19682451f, -0.30028912f, 
    -0.25224307f, -0.22439654f, -1.66143215f, 0.20108132f, -0.32222316f, -1.32727063f, -1.04441023f, 0.49563220f, 
    0.34406272f, -0.19674137f, 0.01797539f, 0.40411970f, 0.06188374f, -0.25888744f, -0.24575892f, -0.69222486f, 
    -0.22882485f, 0.12092459f, 0.11044890f, 0.08545092f, 0.30517173f, -0.03330628f, 0.02829179f, 0.02735040f, 
    -0.17701417f, -0.02473734f, -0.06590565f, -0.65314376f, -0.56453961f, -0.53940213f, -0.32250506f, 0.09328388f, 
    -0.58928269f, -0.82466960f, -0.14888135f, 0.06085635f, -0.62869847f, 0.22492708f, -0.13944578f, -0.02563214f, 
    0.29071367f, 0.03991950f, 0.00342573f, -0.15787508f, -0.03557628f, 0.17752831f, 0.16900174f, 0.09056034f, 
    0.30768448f, -0.17311291f, -0.04688451f, 0.36506918f, 0.08193906f, -0.57389855f, 0.38336176f, -0.00770461f, 
    0.18872492f, -0.21849319f, -0.28982568f, -0.08967435f, 0.15471189f, 0.35696706f, -0.24435210f, -0.22005367f, 
    0.49841598f, -0.24003935f, 0.33157176f, -0.21995498f, -0.03227597f, 0.34490168f, -0.29834139f, 0.16139007f, 
    0.15054953f, -0.33460239f, -0.06452300f, 0.29125053f, -0.18619105f, -0.15317574f, 0.20029840f, 0.32659498f, 
    0.29798457f, 0.37774765f, -0.14147283f, 0.06012687f, 0.41904965f, 0.18840532f, -0.04220265f, 0.23681012f, 
    0.24047734f, 0.11709555f, -0.27912143f, -0.16806148f, -0.01150359f, -0.02797192f, -0.09687388f, -0.27160570f, 
    0.13832673f, -0.06589018f, 0.05928956f, 0.01652128f, 0.01682696f, -0.09103452f, 0.30528378f, 0.10669141f, 
    0.13720390f, 0.18134072f, -0.16000839f, -0.10985762f, -0.26769513f, -0.25300175f, -0.20238611f, -0.22155173f, 
    0.30354312f, 0.15202220f, -0.00831116f, 0.10404045f, -0.06605418f, 0.33371001f, -0.10800779f, 0.12223859f, 
    -0.38846380f, -0.20155790f, -0.12519671f, 0.02895231f, 0.11948387f, 0.27573940f, 0.41310832f, -0.58630818f, 
    -0.44604319f, 0.71169400f, 0.16158535f, 0.02037164f, -0.38593736f, -0.72032547f, -0.42122629f, 0.33498079f, 
    0.21099938f, 0.16649967f, -0.18162456f, -0.22427532f, 0.56458926f, -0.25429451f, -0.13343884f, 0.21078071f, 
    0.21366468f, 0.00750658f, -0.11371173f, 0.20790683f, 0.08085986f, -0.17678775f, -0.02333165f, -0.18604994f, 
    0.39393762f, 0.38172078f, 0.26665449f, 0.23564234f, 0.68616426f, -0.55510467f, -0.46493861f, -0.59568876f, 
    -0.49175444f, -0.41051683f, -0.03537579f, -0.21097584f, -0.05157062f, -0.23470855f, -0.11602851f, 0.02600737f, 
    0.31931636f, 0.09075608f, -0.12284013f, 0.17382175f, -0.10253226f, 0.00657067f, 0.07740880f, -0.13552262f, 
    -0.01774599f, 0.16411272f, 0.04810500f, -0.01577947f, -0.28868896f, -0.21058312f, 0.46221831f, 0.23789841f, 
    -0.18501155f, -0.07500599f, -0.02680155f, 0.25227123f, 0.16387665f, 0.07130309f, -0.03850028f, -0.39556596f, 
    -0.33180428f, 0.02518471f, -0.36761537f, 0.06795749f, 0.40638432f, 0.11557642f, 0.29988548f, 0.08166201f, 
    -0.05306502f, -0.15149595f, 0.33608928f, 0.54487079f, 0.81369424f, -0.42184234f, -0.47287562f, -0.36793485f, 
    -0.43259329f, -0.12288889f, -0.13051289f, 0.20130368f, -0.00741897f, -0.17135140f, -0.20237996f, 0.40919837f, 
    0.20975086f, -0.30950120f, 0.00310242f, 0.28670120f, -0.17365292f, 0.10684044f, 0.19714822f, 0.00686101f, 
    -0.11824882f, -0.36058819f, -0.30740577f, 1.01835108f, -0.59655285f, -0.50044656f, -0.43465960f, -0.53437525f, 
    0.40706784f, 0.49128139f, 0.40291029f, 0.27229524f, -0.37065434f, -0.01823691f, 0.02099729f, 0.07786875f, 
    0.11815506f, -0.18325391f, -0.09680279f, -0.28978688f, -0.01076477f, 0.21436955f, -0.03051197f, 0.10358379f, 
    0.14351469f, 0.10375872f, 0.03061506f, -0.29081920f, 0.65901315f, -0.34919643f, -0.02193466f, -0.14937718f, 
    -0.14335304f, 0.11105645f, -0.26603112f, 0.19357203f, 0.04419629f, -0.02366712f, 0.04869995f, 0.00289020f, 
    -0.22840557f, -0.11595132f, 0.32884604f, -0.08045470f, 0.27905548f, -0.01123351f, 0.17473324f, -0.31516507f, 
    0.07142743f, 0.16005877f, 0.01324269f, -0.21355350f, 0.04564261f, 0.21530333f, 0.10710292f, 0.06607141f, 
    0.11232843f, 0.08883734f, -0.15351571f, -0.14448135f, 0.14211471f, -0.19635677f, 0.18625505f, -0.07576745f, 
    -0.20463270f, 0.28272709f, -0.15546022f, 0.23153177f, -0.01922706f, -0.13848300f, -0.24716690f, 0.07793582f, 
    -0.05447848f, 0.19496086f, 0.07355064f, 0.13192303f, -0.04163230f, -0.16217156f, -0.73016554f, 0.03510895f, 
    0.44394073f, 0.70593554f, -0.48371783f, -0.28474936f, -0.67447251f, -0.36545140f, 0.17308725f, -0.04682009f, 
    0.23772635f, -0.05113259f, -0.05757437f, 0.05415351f, 0.14081584f, -0.18333577f, 0.15952092f, 0.16804756f, 
    -0.37816003f, 0.21442200f, 0.24159323f, 0.05167177f, 0.07980666f, 0.09953836f, 0.08591565f, 0.40251318f, 
    0.28758043f, 0.10854069f, 0.07379182f, -0.14052014f, -0.32773808f, -0.11415845f, 0.17653786f, 0.12342849f, 
    0.26056993f, 0.19275515f, -0.19575149f, 0.18374868f, -0.14172934f, -0.13146019f, -0.13568439f, 0.08287226f, 
    -0.19559191f, 0.21580948f, -0.25399652f, -0.18795095f, -0.16152133f, -0.00462696f, -0.20525880f, 0.03450416f, 
    0.68443692f, -0.07421992f, -0.11444584f, -0.13756165f, 0.18275940f, 0.32708743f, 0.34113488f, 0.34771132f, 
    -0.27493012f, -0.41191790f, -0.42537010f, -0.09753355f, 0.08947629f, -0.20817587f, -0.13394824f, -0.12747557f, 
    0.15723158f, 0.06478100f, -0.04810237f, -0.13903329f, -0.06923050f, -0.26768956f, -0.29975367f, 0.21782985f, 
    0.25580156f, -0.14002904f, -0.09133630f, 0.11728023f, 0.34594336f, 0.27867672f, 0.09483304f, 0.19416241f, 
    0.18699482f, -0.04656519f, 0.26286402f, 0.20782349f, 0.12798801f, -0.29239738f, -0.35318789f, 0.00081919f, 
    -0.18532746f, -0.10558168f, -0.04693981f, -0.13839154f, -0.09591731f, 0.22631189f, -0.24571542f, 0.18905984f, 
    -0.05058141f, -0.25983498f, -0.29680625f, -0.13019441f, 0.15575227f, 0.09905598f, 0.04308777f, 0.22669184f, 
    -0.26466769f, -0.22657630f, 0.12925884f, -0.20156935f, 0.02956286f, 0.01808934f, -0.19166867f, 0.08340602f, 
    -0.10750928f, -0.27568600f, -0.01753425f, -0.55630779f, -0.38532197f, -0.45881432f, -0.38725874f, -0.34472993f, 
    -0.36449701f, -0.24919988f, -0.07160643f, 0.14514768f, -0.02106870f, 0.01742254f, 0.18819281f, -0.05402138f, 
    -0.05171549f, -0.03389840f, -0.01572043f, -0.04042072f, 0.08260319f, 0.10672835f, 0.15016626f, 0.23221812f, 
    -0.19542846f, -0.25640488f, -0.09185635f, 0.19364925f, -0.28590012f, 0.08167317f, 0.09768244f, -0.37716290f, 
    0.14507644f, 0.13623022f, -0.20730133f, 0.30527908f, 0.64355683f, -0.12951340f, -0.38268819f, -0.15667707f, 
    -0.32992184f, 0.45927712f, -0.12871826f, 0.28151926f, 0.38825563f, 0.15140314f, 0.09637544f, 0.36448205f, 
    -0.21866669f, -0.24648446f, -0.37525117f, -0.24561143f, 0.10116161f, 0.15531091f, -0.29785290f, -0.43014693f, 
    0.10238411f, 0.24167866f, 0.11614258f, -0.07420224f, 0.23020712f, -0.15691873f, 0.31901646f, 0.64487100f, 
    -0.61125535f, -0.50868320f, -0.10695655f, -0.01522856f, 0.54483503f, 0.17289317f, -0.31455451f, -0.35067797f, 
    -0.20174098f, 0.57100844f, -0.07391614f, -0.10677776f, 0.17996354f, 0.27952415f, -0.06247989f, -0.27831775f, 
    -0.08088237f, -0.24534509f, -0.17210728f, -0.46706843f, -0.12287504f, -0.11038788f, -0.31991205f, -0.79378766f, 
    -0.22500771f, 0.49932933f, 0.61260641f, -0.13015659f, -0.83089620f, -0.16955307f, 0.76864290f, 0.48487520f, 
    -0.34384724f, 0.21027148f, 0.03914445f, -0.07936928f, 0.37376937f, 0.02035635f, -0.09570084f, -0.17787912f, 
    0.08893654f, -0.24012972f, 0.11928730f, -0.12939905f, 0.05508672f, -0.03882608f, 0.26916003f, 0.33460706f, 
    0.16536078f, 0.36603582f, -0.48482931f, -0.44806749f, -0.85531676f, -0.20309435f, 0.29706278f, 0.37668532f, 
    0.37115073f, 0.31473342f, 0.29685199f, -0.21237849f, -0.05152385f, -0.22345287f, 0.16799027f, -0.22331062f, 
    0.00107415f, -0.15998042f, -0.21789964f, -0.04886702f, 0.24987102f, -0.35377458f, -0.46101671f, -0.18021789f, 
    0.18084727f, 0.13760540f, 0.24646801f, -0.21090835f, -0.22993271f, -0.26335120f, -0.04675700f, 0.04785581f, 
    -0.24356636f, 0.18926339f, -0.30868605f, -0.04026131f, -0.54510653f, 0.23922114f, 0.33573267f, 0.31026244f, 
    -0.02075316f, 0.11178062f, -0.08054297f, -0.13764851f, -0.09731243f, -0.11372551f, -0.28933418f, -0.20026715f, 
    0.27240938f, 0.39456636f, 0.00714899f, 0.35140249f, -0.43474501f, -0.75412220f, -0.37577039f, 0.37454644f, 
    0.08630121f, 0.35557169f, 0.09443767f, 0.06315377f, -0.43234390f, 0.10151119f, 0.12658043f, -0.31751367f, 
    0.14219482f, -0.22163451f, -0.16909529f, 0.19483587f, 0.15338072f, 0.03695096f, -0.02525321f, 0.19825032f, 
    -0.06391288f, 0.25170386f, 0.52645725f, -0.49173784f, 0.36570877f, 0.31711060f, -0.31962010f, -0.28244394f, 
    -0.26136974f, 0.13121830f, 0.22002327f, -0.03343860f, 0.27987793f, -0.04180022f, -0.19959496f, -0.23128881f, 
    -0.20191441f, 0.09318127f, -0.29658827f, 0.30226177f, -0.04225209f, -0.05671602f, -0.12892678f, 0.15732604f, 
    0.01856242f, 0.05533355f, -0.20163964f, -0.31221440f, -0.10949500f, -0.25948033f, 0.08036247f, 0.18696387f, 
    0.29792315f, -0.15388760f, -0.13558938f, 0.49991786f, 0.02684410f, -0.21073167f, 0.02170633f, 0.05461424f, 
    0.22637768f, -0.02159669f, -0.12064703f, 0.02380028f, -0.26536039f, -0.25750116f, -0.28104404f, 0.08022638f, 
    0.37997976f, 0.22440416f, 0.26516610f, 0.08160472f, 0.06181430f, -0.15389851f, -0.04612849f, -0.17008767f, 
    -0.18167183f, -0.32195166f, -0.36636445f, -0.54649365f, -0.53096795f, 0.00441225f, 0.74534202f, 0.26283550f, 
    0.02221483f, 0.05073843f, 0.13779221f, -0.18315007f, -0.16620445f, 0.02118721f, -0.21036234f, -0.45470980f, 
    0.11333940f, 0.06841522f, 0.10121023f, -0.32862383f, -0.04694218f, -1.03869307f, -0.68338978f, -0.65899682f, 
    0.01621703f, 0.44487947f, -0.60919797f, -0.72374201f, -0.23789527f, -0.49422109f, -0.22149929f, 0.04186192f, 
    -0.07874515f, 0.02414578f, 0.07547366f, -0.38540110f, 0.17218611f, -0.28272706f, -0.18590862f, 0.17708252f, 
    -0.24737260f, -0.12793829f, -0.02284137f, -0.03054870f, -0.32947955f, 0.04664107f, -0.14310443f, -0.52647412f, 
    -0.52996564f, -0.38788062f, -0.16015083f, -0.34130058f, -0.39481929f, -0.16697106f, -0.16196300f, -0.40352806f, 
    0.42837638f, 0.19334501f, -0.01249933f, -0.40476641f, -0.04652906f, -0.41768128f, -0.18139066f, 0.00358954f, 
    -0.58847183f, -0.33625987f, -0.05824182f, 0.12952384f, 0.22988084f, 0.11985258f, -0.24274512f, 0.32510918f, 
    0.08476801f, 0.15071507f, -0.28354347f, -0.30407944f, 0.09248675f, 0.12789659f, -0.25935742f, -0.29669398f, 
    0.10990591f, -0.16510797f, 0.11307239f, -0.25577500f, -0.12274545f, 0.25977230f, 0.29854673f, -0.48225445f, 
    0.04263375f, 0.18327357f, -0.33939663f, 0.02395103f, 0.20875978f, 0.11998354f, -0.03089661f, 0.47870600f, 
    0.34447145f, 0.44440788f, 0.57595503f, -0.30834106f, -0.45090753f, -0.27639896f, -0.22301704f, -0.25400704f, 
    -0.03777952f, 0.24602625f, 0.21139455f, 0.19958577f, 0.05398063f, 0.31018621f, -0.01357116f, -0.05527548f, 
    -0.15787141f, 0.18396002f, -0.15730563f, 0.12635621f, 0.07374380f, 0.02053533f, -0.04279548f, -0.11309329f, 
    0.07808044f, -0.33179846f, -1.17287564f, 0.35467324f, 0.62131286f, 0.61638546f, 0.76919007f, -0.17415240f, 
    -0.74389094f, -0.25983691f, -0.37602013f, -0.22513278f, -0.07446761f, -0.24972120f, 0.09362789f, -0.39362550f, 
    -0.36530605f, -0.18023784f, 0.11231191f, -0.13964453f, 0.15701503f, 0.12038869f, -0.15607618f, 0.17226472f, 
    -0.18490063f, 0.08297356f, -0.39816707f, -0.38349870f, -0.46548322f, -0.03749277f, -0.48925334f, 0.26017666f, 
    0.02916980f, 0.05859356f, -0.11295056f, 0.04622253f, -0.45795354f, -0.36275429f, -0.15013492f, 0.08595426f, 
    0.35796261f, -0.30589855f, -0.35660377f, -0.28710797f, -0.15002970f, -0.38862553f, -0.19628759f, -0.26076567f, 
    0.17378545f, -0.01378919f, 0.04611400f, -0.18049359f, -0.17411926f, -0.24494237f, 0.11842026f, 0.22932093f, 
    0.47073919f, -0.01890720f, -0.35132965f, 0.34434021f, -0.12626515f, -0.20408341f, 0.22773293f, 0.13257784f, 
    -0.39084116f, 0.19408733f, -0.32844049f, -0.11462397f, -0.00783448f, 0.11885002f, -0.19946814f, 0.31390858f, 
    0.03227669f, -0.30300432f, 0.17604853f, 0.44218528f, 0.06869733f, -0.14912838f, -0.53480095f, -0.23878507f, 
    -0.45839167f, 0.18958598f, 0.04832600f, -0.19310679f, -0.06462799f, 0.17972919f, 0.28704786f, -0.39379984f, 
    -0.40535271f, -0.34900802f, 0.08117097f, -0.14854673f, -0.23907498f, -0.15625504f, -0.35334617f, -0.25847855f, 
    -0.36485043f, -0.35173592f, 0.12967397f, -0.00016817f, 0.30691132f, 0.04914377f, 0.57912511f, 0.16939181f, 
    -0.42327723f, 0.25239182f, -0.32248744f, 0.02404107f, 0.00468589f, -0.16864057f, 0.03996035f, -0.11989681f, 
    0.14926474f, 0.24071178f, -0.30921873f, -0.08121010f, -0.32802740f, 0.11546164f, 0.20006278f, 0.09653758f, 
    0.04158454f, 0.17818724f, 0.01161700f, -0.28058127f, 0.19405992f, -0.14795150f, 0.47794527f, 0.00321941f, 
    0.06675478f, -0.51226282f, -0.33078840f, -0.05930986f, 0.12026557f, -0.28273967f, -0.16946125f, -0.17567414f, 
    0.30798471f, 0.19845307f, 0.25714132f, -0.33428481f, 0.47476104f, 0.17792279f, 0.06782891f, -0.16958703f, 
    -0.30642241f, 0.15990922f, -0.32944441f, 0.10827807f, 0.14898114f, -0.07542669f, 0.14879119f, 0.42375210f, 
    0.31430611f, 0.18159339f, -0.01422003f, -0.05322273f, -0.05414562f, -0.13928866f, 0.38081709f, -0.02776710f, 
    0.00210506f, 0.07138175f, -0.02861845f, -0.14687076f, 0.00704589f, 0.18532065f, 0.15236126f, 0.10923480f, 
    -0.09066685f, -0.24960785f, 0.19023296f, 0.17285185f, 0.03792277f, -0.09766525f, -0.03110284f, -0.13471073f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09867308f, -0.28017980f, 0.32559660f, 0.08814368f, 0.21783727f, 0.11050892f, 0.30916283f, -0.07280503f, 
    0.15968598f, 0.05042346f, -0.15193821f, 0.05700607f, 0.37262279f, 0.21008512f, 0.27274817f, -0.00808622f, 
    0.24722639f, -0.12333583f, 0.36109349f, -0.22613840f, -0.26231384f, 0.14869596f, 0.14311384f, 0.27042663f, 
    -0.06599069f, -0.43528268f, 0.02542565f, -0.15236837f, 0.27789617f, -0.13457447f, 0.10678530f, 0.04048913f, 
    0.15700395f, 0.10404725f, 0.23499331f, 0.18251185f, 0.11866316f, 0.15946014f, 0.14003532f, 0.19681266f, 
    0.31146011f, 0.39774778f, 0.09852439f, 0.34590229f, 0.18202855f, 0.04996565f, 0.40535676f, 0.17552899f, 
    0.08965930f, 0.13672853f, 0.22114889f, 0.01546640f, 0.12146686f, -0.16782366f, -0.17664203f, 0.29910973f, 
    -0.02480205f, 0.15495156f, -0.01665313f, 0.28943083f, -0.25766137f, 0.17448822f, 0.05304039f, 0.00981884f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12369487f, -0.12523299f, -0.01245870f, 0.07970666f, -0.10784706f, -0.00024042f, 0.05932585f, -0.02229435f, 
    -0.01034372f, -0.01916080f, -0.01181683f, -0.19432481f, 0.25710958f, 0.14977829f, 0.05169401f, -0.15584469f, 
    0.05609978f, 0.05954031f, 0.01736045f, 0.06031931f, 0.00966601f, -0.03928596f, 0.02425032f, -0.02539356f, 
    0.13083629f, 0.07953958f, 0.08022443f, 0.00129978f, -0.00468670f, 0.07351428f, -0.02624643f, -0.15714788f, 
    -0.18769495f, -0.05993190f, -0.03518334f, 0.01429967f, -0.15002419f, -0.03947941f, 0.18724225f, -0.09822511f, 
    0.03184125f, 0.00974656f, -0.11487380f, -0.04299523f, -0.01202424f, 0.04323723f, -0.05328390f, 0.04257327f, 
    -0.04470557f, 0.05404828f, 0.00529217f, -0.07929157f, -0.11601595f, -0.15758079f, -0.11874042f, -0.05528655f, 
    0.01754902f, 0.05093250f, -0.01750420f, -0.02195797f, 0.25896543f, 0.00491362f, 0.01628995f, -0.24883240f, 
    -0.16425794f, -0.17133728f, 0.08969519f, -0.13037327f, 0.05113316f, -0.03514934f, -0.10425347f, 0.01175235f, 
    0.39354333f, 0.00755650f, 0.00681703f, -0.17858444f, -0.08993614f, -0.02361097f, 0.11441834f, -0.00066227f, 
    -0.01648467f, -0.01616292f, -0.07983685f, -0.10294499f, 0.14687105f, 0.02990655f, -0.15795638f, -0.03931218f, 
    0.18566416f, 0.22678378f, -0.01393237f, -0.13517854f, -0.02982087f, 0.03010067f, 0.01153876f, 0.09012920f, 
    -0.48321551f, 0.34302324f, -0.07174972f, -0.13039108f, -0.01197893f, 0.03127394f, -0.01293173f, 0.06608948f, 
    -0.01590296f, -0.01540640f, -0.01782580f, -0.05445470f, 0.08672461f, -0.15356436f, -0.22149342f, 0.07235461f, 
    -0.01922313f, -0.14391810f, 0.01942791f, -0.20206197f, -0.08410763f, 0.02810328f, 0.01818048f, 0.01535055f, 
    0.18806362f, 0.01201352f, -0.01454094f, -0.17268856f, 0.01959008f, -0.02664415f, 0.01140215f, 0.14036959f, 
    -0.04756198f, 0.04993855f, 0.05753119f, 0.02646023f, 0.12003433f, 0.13344155f, 0.13837929f, -0.03180046f, 
    0.03104440f, 0.05960327f, 0.06858605f, 0.03532515f, 0.02503214f, 0.04941815f, 0.04167100f, -0.02655536f, 
    -0.20598945f, -0.44724110f, -0.19437845f, 0.06104166f, -0.02154102f, 0.12757559f, -0.11682583f, -0.06302488f, 
    -0.01421466f, -0.02786851f, -0.02973221f, -0.03267933f, 0.14234115f, 0.12436740f, -0.03382700f, -0.20991120f, 
    0.05896414f, 0.00939772f, -0.02005769f, -0.02387363f, -0.02536760f, -0.05806113f, -0.07563939f, -0.02778058f, 
    -0.25926396f, -0.36298954f, -0.50848204f, 0.00049967f, 0.01809765f, 0.00123467f, -0.04711080f, -0.03125816f, 
    -0.01004363f, -0.00577588f, 0.04736647f, -0.03718289f, -0.00237896f, 0.06500497f, 0.02151351f, -0.00001645f, 
    -0.00917285f, 0.06590549f, 0.05069842f, 0.02599713f, -0.09849545f, -0.03833025f, -0.04578911f, -0.12849969f, 
    0.13129471f, 0.17011662f, -0.05610652f, -0.14668953f, 0.09069128f, 0.10625920f, 0.11583102f, -0.25899315f, 
    -0.02862005f, -0.01882367f, -0.08636055f, -0.08141335f, -0.14361317f, -0.22910070f, -0.11132988f, 0.02396747f, 
    0.04013891f, 0.00553592f, -0.17535703f, -0.08353769f, -0.04223838f, 0.01349822f, 0.07315119f, -0.05066868f, 
    -0.60685062f, 0.19247676f, -0.24677235f, -0.07804615f, -0.01655044f, 0.00440684f, 0.02027588f, 0.07911208f, 
    -0.01886933f, -0.00291499f, -0.04382477f, 0.04062686f, -0.03262407f, -0.05464875f, -0.02704692f, 0.07999661f, 
    0.05371311f, 0.02367548f, 0.06716144f, 0.05362734f, -0.14488752f, 0.00562142f, 0.07820830f, 0.10536200f, 
    0.34118554f, 0.19191855f, 0.01099300f, -0.18601474f, 0.13348784f, -0.02870094f, 0.08054192f, -0.07142636f, 
    -0.01544848f, -0.13814552f, -0.08459789f, -0.10761196f, -0.40656191f, 0.00016015f, 0.20611399f, 0.05363518f, 
    0.02197685f, -0.09934600f, -0.16822830f, -0.01051030f, 0.02251672f, -0.06793171f, -0.00598179f, 0.01522844f, 
    0.23823087f, 0.27266648f, -0.18559277f, -0.25583208f, -0.08866433f, -0.06168687f, 0.04690146f, 0.10478297f, 
    0.06734195f, 0.02473142f, -0.01601508f, -0.01729411f, 0.00661631f, -0.22242284f, -0.34827051f, 0.01455237f, 
    -0.05656268f, 0.05802698f, -0.12115066f, -0.07076281f, -0.02666752f, -0.02069344f, 0.03640146f, 0.10833205f, 
    -0.07407904f, -0.02535884f, 0.21126039f, 0.04852109f, 0.06735648f, 0.06344187f, -0.04540042f, -0.07572254f, 
    0.21100156f, -0.01127807f, -0.02818748f, -0.06346753f, 0.27315345f, 0.23105270f, -0.03238890f, -0.08092221f, 
    0.02604793f, 0.30671588f, 0.08388288f, 0.14951789f, 0.00924187f, -0.01326854f, 0.06776817f, -0.06381251f, 
    0.09698772f, 0.16979897f, -0.03788896f, -0.08720213f, 0.05785105f, 0.25760978f, 0.05175947f, 0.11226407f, 
    0.08308563f, 0.02828170f, 0.02638940f, -0.03269070f, 0.29797128f, 0.21517679f, -0.00939605f, -0.27025867f, 
    0.03616616f, 0.05210480f, 0.01874981f, 0.07367272f, 0.01985503f, 0.00499712f, 0.02490806f, -0.03554207f, 
    -0.22917870f, 0.11913952f, 0.06004385f, -0.07878907f, -0.11442105f, 0.00414198f, -0.07680010f, 0.00366687f, 
    -0.13799782f, -0.09446654f, -0.09681839f, -0.06554544f, -0.14952128f, -0.06457299f, 0.04602722f, -0.00954102f, 
    0.02236624f, 0.03008731f, 0.02132669f, 0.02841930f, -0.04307549f, -0.00719818f, 0.08611826f, 0.07424417f, 
    0.07184380f, 0.02762892f, -0.02284827f, -0.07804099f, -0.06937632f, -0.06158575f, -0.00868873f, -0.10973437f, 
    -0.02082330f, 0.03827516f, -0.04316801f, -0.00223350f, 0.10879752f, 0.29561207f, 0.19632494f, -0.38837400f, 
    -0.02086963f, -0.02290206f, -0.19431309f, 0.07798358f, 0.08130737f, -0.02003033f, -0.08013579f, 0.01186377f, 
    0.00356679f, 0.13255525f, 0.05634207f, -0.04893887f, 0.07632830f, 0.04329430f, -0.09580593f, -0.11210410f, 
    0.00714773f, 0.04092596f, 0.00736475f, 0.01577009f, -0.15289102f, -0.15458761f, -0.45931610f, 0.01424097f, 
    -0.05705525f, -0.06381006f, -0.00358138f, 0.06377371f, -0.08462466f, -0.04396196f, 0.05026883f, -0.22484307f, 
    -0.07635400f, 0.09874216f, 0.02582794f, -0.05504081f, 0.02876016f, 0.05274300f, -0.04775779f, -0.12126585f, 
    0.02689826f, -0.07503358f, 0.06449645f, 0.03810246f, 0.02374573f, -0.40876818f, -0.38449126f, 0.09167712f, 
    0.04332649f, -0.04388225f, -0.01812313f, -0.00438706f, 0.00009815f, -0.16567388f, -0.36572218f, -0.02866289f, 
    -0.02356458f, -0.06419870f, -0.05970353f, -0.03909272f, -0.12420573f, -0.19875127f, 0.00761984f, -0.05977533f, 
    -0.10252418f, -0.00192674f, -0.04388540f, -0.03377822f, -0.33965203f, -0.00711861f, 0.01342664f, -0.03968707f, 
    0.01934424f, -0.03035459f, 0.04720321f, 0.02868186f, 0.01793484f, 0.00962268f, -0.00803148f, 0.02002032f, 
    0.12174495f, 0.14688119f, 0.25762269f, -0.27870548f, -0.11138264f, 0.06240625f, -0.09979821f, 0.10006670f, 
    0.03390539f, -0.00047604f, -0.02184601f, -0.00631154f, -0.43159607f, -0.24990575f, 0.01573905f, 0.03027709f, 
    0.03095219f, -0.00298503f, 0.00810845f, 0.02962463f, -0.13505787f, -0.13768832f, -0.07566131f, 0.00993496f, 
    -0.12994775f, -0.35004717f, -0.39619404f, 0.10742450f, -0.02282715f, 0.00952564f, 0.01023724f, 0.05852368f, 
    0.01390413f, 0.02527515f, 0.00573573f, 0.03006753f, -0.13537499f, -0.33771881f, 0.05782295f, -0.05086674f, 
    -0.03670854f, -0.02236031f, 0.02122893f, 0.02902376f, 0.00508858f, 0.02629253f, 0.00469162f, 0.04174390f, 
    0.07607011f, 0.05707485f, -0.02685539f, -0.09264906f, -0.00807812f, -0.04658480f, -0.00587351f, 0.02442928f, 
    -0.09531896f, -0.04884468f, 0.08204325f, 0.00870202f, -0.22479065f, -0.07173498f, -0.00502853f, -0.07454274f, 
    -0.03583114f, 0.01461854f, -0.00912413f, 0.00113254f, -0.08580737f, -0.07534733f, -0.01470131f, -0.04048346f, 
    -0.21113771f, -0.57552701f, -0.33490643f, 0.00935189f, 0.01364438f, 0.06525274f, 0.03480119f, -0.00593454f, 
    -0.12608835f, -0.04108260f, -0.07434087f, -0.25212392f, -0.13999753f, -0.30687708f, 0.13500457f, 0.02610855f, 
    0.02333772f, 0.03972588f, -0.12455285f, 0.02886738f, 0.10905781f, -0.16106530f, 0.02593920f, 0.08317953f, 
    -0.21423951f, 0.35776532f, 0.19491357f, -0.16851319f, -0.12215668f, 0.08784508f, 0.03953583f, -0.15096571f, 
    -0.09018020f, -0.13249131f, -0.01729846f, -0.12695576f, -0.30434400f, -0.19980220f, 0.13341019f, 0.04310677f, 
    -0.03449810f, 0.01404248f, -0.00810175f, 0.03813836f, -0.19964907f, -0.12695572f, -0.00093393f, 0.09701904f, 
    -0.13857453f, 0.00395667f, 0.12269812f, -0.16217317f, -0.02226328f, 0.05578728f, -0.08391604f, -0.09305314f, 
    -0.10428298f, 0.08057851f, 0.14361268f, -0.09928481f, -0.15284425f, -0.16583323f, 0.08576845f, -0.01695823f, 
    -0.04004245f, 0.01247882f, -0.04296741f, -0.03198927f, 0.01444676f, -0.06176332f, 0.01015702f, -0.14278202f, 
    -0.32747036f, -0.29423895f, 0.11198913f, -0.38743773f, 0.00549041f, 0.00492575f, 0.04349031f, 0.03545135f, 
    -0.00745140f, -0.07993428f, 0.03468291f, 0.01283748f, -0.08798698f, 0.07452612f, 0.00979120f, -0.06485458f, 
    -0.02103244f, 0.00729483f, 0.00154832f, 0.03488746f, -0.04306544f, 0.02506769f, -0.05844065f, -0.16836917f, 
    0.16599584f, 0.26518333f, -0.14043112f, -0.07759442f, -0.02934200f, -0.03545923f, -0.09364884f, -0.00948214f, 
    -0.04798197f, 0.07885519f, 0.03898223f, -0.04304252f, 0.35978842f, 0.25159231f, 0.00673732f, -0.15001142f, 
    0.16350447f, 0.11250672f, 0.22751011f, 0.02405739f, -0.01457697f, -0.01869302f, -0.06010498f, -0.04479868f, 
    0.24466234f, 0.19763517f, -0.07367604f, -0.19101846f, 0.13348790f, 0.12407269f, 0.01728034f, -0.02032067f, 
    -0.04162399f, -0.08164343f, -0.12908533f, -0.01083889f, 0.00900787f, -0.05699616f, 0.00072779f, 0.01722374f, 
    -0.05517411f, 0.01656562f, -0.00313156f, -0.06789781f, -0.13135196f, -0.05276328f, -0.01760795f, -0.00100111f, 
    0.06630635f, -0.07458465f, 0.00697616f, 0.03231912f, -0.06399845f, 0.04938196f, 0.12274301f, -0.00081245f, 
    -0.06083727f, -0.03424789f, -0.01498297f, -0.00424198f, 0.46887985f, -0.14319296f, -0.22323640f, -0.27263716f, 
    -0.10068274f, -0.16036795f, 0.04730459f, -0.05358918f, 0.08829125f, -0.02449094f, -0.00456169f, 0.06677946f, 
    0.16125041f, 0.03427917f, -0.01246079f, -0.09060324f, -0.03427060f, -0.05874963f, -0.13237472f, -0.11356600f, 
    -0.03569805f, -0.26338658f, -0.03802372f, 0.03491203f, -0.09758861f, 0.13699716f, -0.14607984f, -0.02898863f, 
    -0.04968220f, -0.01706667f, 0.02307685f, -0.01690730f, -0.10580877f, -0.11750900f, -0.05518464f, -0.20722304f, 
    0.08792572f, 0.13846970f, -0.02119116f, -0.01639121f, -0.06798426f, -0.02015774f, -0.15198864f, -0.12519361f, 
    -0.18864195f, -0.16348235f, -0.07108316f, -0.04301872f, -0.25990337f, 0.02410107f, -0.30845892f, 0.20261279f, 
    -0.03219734f, 0.01833045f, -0.08419579f, -0.06115358f, 0.01709411f, 0.02692232f, -0.04098748f, 0.00685872f, 
    0.20292398f, -0.02051132f, -0.22375166f, 0.00310358f, -0.03373555f, -0.00452527f, -0.12328525f, -0.15908872f, 
    -0.15500222f, 0.00383480f, 0.01686355f, -0.05918823f, -0.10610484f, -0.02567463f, -0.01395451f, 0.03726143f, 
    0.01832053f, 0.04562839f, -0.02917029f, 0.01428516f, -0.03175353f, 0.02891604f, -0.05643531f, 0.03414082f, 
    0.11769781f, 0.08098967f, 0.01561036f, 0.05907806f, -0.09983706f, 0.03340150f, 0.14357726f, -0.08571138f, 
    0.18241063f, 0.02643076f, -0.06736970f, 0.13291706f, -0.00953182f, 0.20752153f, 0.26433933f, 0.24810177f, 
    -0.11592989f, -0.02446266f, -0.01176759f, -0.00505738f, -0.02240420f, -0.00493179f, -0.00876947f, 0.01259108f, 
    -0.38191158f, -0.12429956f, -0.11617146f, -0.11627644f, -0.03358553f, 0.10216211f, 0.05966565f, 0.14888908f, 
    -0.08402098f, 0.08038735f, 0.06104380f, 0.02165258f, -0.11924772f, -0.01813850f, 0.12190752f, 0.07074796f, 
    0.04555089f, -0.01347305f, 0.08909966f, 0.05219448f, -0.01227273f, 0.05823026f, -0.08552859f, 0.00349295f, 
    -0.01703455f, 0.01569219f, -0.04169074f, 0.00428949f, 0.08247939f, 0.00756222f, -0.01755130f, -0.01799839f, 
    0.04975924f, -0.01154584f, -0.01801039f, 0.07561853f, -0.17523074f, -0.20215005f, 0.02027465f, -0.16404450f, 
    0.12265928f, 0.01509976f, 0.07319218f, -0.21148206f, 0.11246054f, 0.03371752f, -0.05285653f, 0.09197684f, 
    0.10514522f, -0.14597535f, -0.00823050f, 0.09458982f, -0.07452342f, -0.07811866f, 0.08848228f, 0.03595987f, 
    0.19772938f, -0.11315037f, -0.01408494f, -0.13009740f, 0.25393605f, 0.01649551f, -0.10221867f, -0.07324389f, 
    0.00846287f, 0.07888300f, -0.01178636f, -0.09909730f, -0.04046711f, -0.04199567f, 0.11443762f, -0.12392876f, 
    0.01866947f, 0.00538916f, 0.10341246f, 0.09544576f, 0.03416501f, -0.03238103f, 0.02564024f, -0.11484974f, 
    0.01832627f, -0.04982911f, 0.00914610f, -0.00761886f, 0.27598724f, 0.02930990f, -0.08434739f, -0.01265512f, 
    -0.00747421f, -0.01066980f, -0.07930023f, -0.01310111f, 0.20439817f, -0.13467593f, 0.06194055f, -0.00477281f, 
    -0.02004864f, -0.05433858f, -0.15515935f, -0.47430333f, -0.14985812f, -0.33505622f, -0.05671839f, 0.02095954f, 
    -0.06157157f, -0.04262991f, -0.01263689f, -0.02893696f, -0.13083065f, -0.01204903f, -0.05480910f, 0.01071213f, 
    0.05034080f, -0.02835206f, -0.04359651f, 0.03221789f, -0.31697631f, -0.09013356f, -0.20358221f, -0.16482958f, 
    0.51791519f, -0.19316837f, 0.17068127f, 0.15507585f, -0.01686477f, -0.13781099f, 0.15015306f, -0.23962045f, 
    -0.00571594f, 0.12861267f, -0.06134607f, 0.03541018f, 0.11796769f, -0.11762746f, -0.20622350f, -0.04158138f, 
    -0.00816060f, 0.04934342f, -0.17819333f, 0.12121599f, -0.04792428f, -0.05825416f, 0.00989966f, 0.00998619f, 
    0.28802261f, 0.12710896f, 0.05373093f, -0.04964719f, -0.02717824f, -0.16650380f, -0.09715954f, -0.02944738f, 
    -0.02063036f, -0.03763513f, -0.02049397f, 0.03914011f, -0.04553347f, 0.01125177f, -0.00670778f, 0.00938585f, 
    -0.00074888f, -0.02568056f, 0.02229883f, 0.01406440f, -0.06511857f, -0.06397700f, 0.00491343f, -0.07018096f, 
    -0.25646934f, -0.14549835f, 0.08644391f, -0.01006854f, 0.05006951f, -0.00380309f, 0.24034886f, 0.00180938f, 
    0.00174615f, -0.05941026f, 0.13513377f, 0.02748306f, 0.27376947f, -0.10206639f, 0.19645904f, -0.15688953f, 
    0.01640156f, -0.03719849f, -0.17699352f, 0.05686428f, -0.11025287f, 0.04364729f, -0.06428822f, 0.05381783f, 
    -0.05474989f, 0.21091348f, 0.21856272f, 0.05235048f, 0.01380729f, -0.02117204f, -0.02279922f, -0.12321843f, 
    0.00803101f, -0.07794451f, 0.01636874f, 0.07090407f, 0.23586799f, 0.10693466f, 0.17448065f, 0.19798525f, 
    -0.08666107f, -0.01496169f, -0.07605565f, -0.03133254f, 0.18882047f, -0.08010703f, -0.03115991f, -0.01721786f, 
    -0.13936856f, 0.01742972f, -0.36444542f, -0.16935234f, -0.03472738f, 0.07293204f, 0.02889621f, 0.27698827f, 
    0.07226542f, 0.01062482f, -0.02342165f, -0.02481663f, -0.04496345f, -0.01019311f, 0.08299872f, -0.08615097f, 
    -0.01747842f, -0.09806217f, 0.02023647f, -0.03014048f, -0.02483221f, -0.06200232f, -0.05652899f, -0.02530428f, 
    -0.41203007f, -0.07099058f, 0.03556265f, 0.06790375f, -0.03483130f, 0.05141922f, 0.02548206f, 0.08869985f, 
    -0.03998588f, 0.01293695f, 0.04167955f, 0.05961257f, 0.37499231f, -0.19578451f, -0.13017444f, -0.31168166f, 
    -0.01518991f, -0.14776190f, 0.06456581f, -0.11639401f, -0.04995325f, 0.02420557f, -0.03910792f, -0.01634690f, 
    0.06978855f, -0.12443219f, 0.06070857f, -0.23824728f, -0.00536978f, 0.00127326f, 0.04041870f, -0.13410871f, 
    -0.02373805f, -0.26232481f, 0.05065534f, -0.12078714f, 0.20321836f, 0.24841280f, 0.10314673f, 0.47546878f, 
    0.32246250f, -0.14231548f, -0.25012937f, -0.07656189f, -0.04732487f, -0.01699199f, 0.07018010f, -0.02386739f, 
    0.33547270f, 0.19739200f, 0.06922626f, -0.17438573f, 0.00100912f, 0.07867648f, -0.24751562f, -0.22448350f, 
    -0.04595931f, 0.00070581f, -0.12186501f, 0.03042543f, -0.15315732f, 0.28841731f, 0.11053403f, 0.21525483f, 
    -0.07170001f, -0.10457934f, 0.07308903f, -0.20360959f, -0.06089915f, -0.02744469f, 0.03590129f, -0.03866450f, 
    -0.20788904f, 0.16457580f, 0.00071103f, 0.04276339f, -0.04744575f, 0.06742780f, -0.08107442f, -0.11132330f, 
    0.08654620f, 0.08355709f, 0.02438083f, 0.03079461f, 0.13463941f, 0.11842507f, 0.19630562f, 0.11378364f, 
    -0.02856385f, -0.04731135f, -0.06908830f, -0.01819799f, 0.01341097f, 0.04884291f, -0.03178407f, 0.13603604f, 
    0.06174082f, -0.01290652f, -0.07957174f, -0.01740638f, 0.04460442f, 0.00077882f, -0.08469196f, -0.02018120f, 
    -0.05274757f, 0.00001093f, -0.02429076f, 0.08683768f, -0.45222688f, 0.16727428f, -0.06373041f, -0.13487130f, 
    -0.01298229f, -0.27875808f, 0.02581138f, 0.11977150f, -0.06748308f, -0.11353451f, 0.06271441f, -0.07392219f, 
    0.03068306f, 0.11460317f, -0.53937912f, -0.15264432f, -0.04576587f, -0.22154823f, 0.13849416f, -0.12355177f, 
    -0.06945963f, -0.02410897f, -0.01941636f, 0.03028251f, 0.18282925f, 0.00528003f, -0.14263822f, -0.06049547f, 
    0.01259555f, -0.11808547f, 0.11238962f, 0.09626687f, -0.16375829f, 0.06029993f, -0.07630942f, -0.02524222f, 
    0.06515572f, -0.07548347f, 0.06447781f, -0.17966290f, 0.04938937f, -0.04642922f, -0.11148538f, 0.17007287f, 
    0.01952785f, 0.01443165f, 0.11899571f, -0.09096014f, 0.58428389f, -0.06020641f, -0.19791003f, -0.05818409f, 
    -0.05415318f, -0.01828128f, 0.00533313f, -0.01913465f, 0.00952160f, 0.02981848f, 0.06270567f, 0.06819286f, 
    0.21144332f, 0.02052618f, 0.02874419f, -0.05735763f, -0.04177836f, 0.05979045f, 0.00188498f, -0.08651230f, 
    -0.16480771f, 0.06783646f, -0.18591182f, -0.04791269f, 0.22256480f, 0.00828737f, -0.01948492f, 0.09956873f, 
    -0.01973717f, -0.02190650f, -0.00988360f, 0.00499877f, -0.01784500f, 0.00991210f, 0.04850476f, -0.04390042f, 
    -0.40169328f, 0.21757919f, -0.13723134f, -0.15115139f, 0.06913138f, -0.23928531f, -0.01037806f, 0.03455897f, 
    -0.11850230f, -0.00220196f, 0.06695602f, 0.05671067f, -0.05021915f, 0.10402567f, 0.13070969f, 0.00144913f, 
    0.01318538f, 0.04447428f, 0.04006001f, -0.07866412f, 0.06463993f, 0.01888713f, -0.05225766f, -0.03659293f, 
    0.65103751f, 0.02936335f, 0.19918716f, 0.26907435f, -0.05497952f, -0.04588827f, 0.02959006f, -0.07137353f, 
    0.08117463f, 0.04990516f, -0.00747098f, 0.04156072f, 0.25706866f, 0.04117832f, 0.24963063f, 0.18465987f, 
    -0.01553053f, 0.00562806f, 0.01980801f, -0.02103781f, -0.03343855f, -0.00076536f, -0.03345542f, 0.02233007f, 
    0.05413724f, 0.03476957f, -0.25125819f, 0.04466970f, 0.05235456f, 0.01791149f, 0.01657063f, 0.00946952f, 
    -0.11672144f, -0.29015189f, -0.43029982f, -0.29525051f, 0.02699637f, 0.16341098f, 0.08409163f, -0.03079538f, 
    -0.06802511f, 0.11535629f, -0.01490197f, -0.03227847f, 0.02115573f, 0.01251735f, -0.05857079f, -0.01255972f, 
    0.37577325f, 0.13448294f, 0.10618634f, -0.16705464f, 0.03088929f, -0.01416276f, -0.03132402f, 0.04230797f, 
    -0.04230215f, 0.10287493f, -0.11902818f, 0.11021862f, -0.07584392f, -0.18040784f, 0.07671472f, -0.15963735f, 
    0.07489084f, 0.00853449f, 0.03103325f, -0.14824624f, -0.08794449f, 0.08393905f, -0.15200777f, -0.17334595f, 
    -0.24005704f, 0.19877289f, -0.21548921f, 0.01559306f, -0.07286824f, 0.06421047f, 0.03278926f, -0.00889634f, 
    -0.15168139f, 0.06249334f, 0.08718368f, -0.05310084f, -0.08645871f, -0.09541853f, 0.19273351f, -0.09258099f, 
    -0.00128486f, -0.02722589f, -0.05343492f, 0.02355549f, 0.00501782f, -0.03832379f, -0.16268620f, -0.10108837f, 
    0.29111648f, -0.06748705f, -0.10191129f, -0.00968740f, 0.20643820f, 0.01026087f, -0.05357979f, 0.06837975f, 
    0.09539893f, 0.17214742f, -0.14728193f, -0.14957932f, 0.13030022f, -0.10412468f, 0.05912411f, -0.25300068f, 
    -0.07027300f, 0.01894741f, 0.05815068f, -0.05586961f, -0.08589394f, -0.02254429f, -0.04109076f, -0.01433318f, 
    -0.02413442f, 0.17604266f, 0.05436208f, -0.01926666f, 0.01846859f, 0.03027476f, -0.10172200f, 0.01437912f, 
    -0.06542095f, 0.06504707f, 0.06278370f, 0.00218058f, -0.10251451f, 0.04607178f, -0.07083149f, 0.06779496f, 
    -0.03164569f, -0.06738651f, 0.06351242f, 0.04850382f, -0.05251037f, -0.04266275f, 0.11877700f, -0.17560051f, 
    -0.31714356f, -0.19839020f, -0.11142471f, -0.21561526f, -0.14451815f, -0.02595951f, -0.06572141f, 0.22567828f, 
    0.00770308f, -0.08077641f, -0.07273950f, 0.06243649f, -0.08435342f, 0.05260531f, 0.01622937f, 0.29794791f, 
    -0.12293799f, -0.01863885f, 0.27337605f, -0.21176191f, -0.01410477f, 0.09632847f, -0.04612280f, 0.02629484f, 
    -0.16353647f, 0.02749681f, 0.00172209f, 0.13906281f, 0.00227311f, 0.14393164f, -0.03800916f, 0.27229795f, 
    -0.02409321f, -0.04374494f, -0.03365631f, 0.11524104f, 0.14508092f, -0.08991447f, 0.04182630f, -0.00174769f, 
    -0.10932866f, 0.14533447f, 0.01797358f, -0.02287320f, -0.06927183f, 0.06689814f, 0.00755345f, -0.09265533f, 
    0.05338373f, 0.02636686f, 0.09064650f, -0.06245093f, 0.04025065f, -0.02775065f, -0.17373206f, 0.06993330f, 
    0.09357811f, -0.06183404f, 0.07490634f, 0.05193529f, 0.07125560f, -0.23932154f, -0.17863239f, -0.11305737f, 
    0.04487342f, -0.09279266f, -0.13569057f, 0.08108890f, 0.06854872f, -0.01499546f, -0.03348773f, 0.00371013f, 
    0.06348420f, 0.08026582f, 0.18958828f, -0.11230435f, 0.15400961f, 0.09308894f, 0.14525983f, -0.03098199f, 
    0.05242760f, 0.01999206f, 0.12167937f, -0.34544125f, 0.03529941f, 0.04171974f, -0.31594265f, 0.23632024f, 
    0.04246060f, 0.01244936f, 0.00276862f, 0.08281841f, 0.18949458f, 0.09380865f, -0.04685106f, 0.12076084f, 
    0.20741378f, 0.07751965f, 0.07524566f, -0.28283760f, 0.13837898f, 0.07127768f, -0.00140663f, 0.01500691f, 
    0.15663032f, -0.08125511f, -0.42622650f, -0.14986798f, 0.09438141f, -0.07849976f, 0.09840674f, 0.07030822f, 
    0.09851599f, -0.08188099f, 0.07036399f, -0.06038643f, -0.04057120f, 0.00210653f, 0.04198160f, 0.05188943f, 
    0.18657745f, -0.17910574f, -0.11928305f, -0.05280180f, -0.04034076f, 0.13399187f, 0.05326680f, -0.13523881f, 
    0.25491744f, 0.17808241f, 0.02946849f, 0.05076090f, 0.09814168f, 0.07205844f, 0.08466356f, 0.03023775f, 
    -0.04045509f, -0.03822098f, 0.00814833f, 0.01944520f, 0.02605082f, 0.03223787f, -0.03039701f, 0.02177729f, 
    0.04222766f, 0.05394030f, -0.01484644f, 0.10614227f, -0.14396299f, -0.00386053f, 0.03775458f, 0.06289209f, 
    0.00642401f, 0.04568282f, 0.11619677f, -0.21628146f, -0.32053053f, -0.27711508f, -0.23727219f, -0.11995160f, 
    -0.00772202f, -0.04099482f, 0.15199670f, -0.19399194f, -0.03382903f, -0.02258677f, 0.00675668f, -0.03214687f, 
    0.02070974f, 0.16882081f, 0.07613082f, 0.15943022f, 0.00410937f, -0.00561488f, 0.08128035f, -0.17816925f, 
    0.01044810f, 0.04005584f, 0.04588358f, -0.01322639f, -0.03509251f, -0.05008954f, -0.12898536f, -0.05925009f, 
    0.00547681f, 0.10769004f, 0.01959879f, -0.16453864f, 0.09081326f, -0.06465384f, -0.06722722f, 0.10380509f, 
    -0.07510634f, -0.05039535f, -0.05154595f, 0.02858768f, -0.05318854f, -0.02855681f, 0.08903609f, 0.01657778f, 
    -0.00249296f, 0.02503439f, -0.04753146f, 0.00608770f, -0.41772133f, 0.19161706f, 0.02826099f, -0.00015205f, 
    -0.00578381f, -0.06765065f, -0.07856735f, 0.00351237f, 0.07830331f, -0.04084609f, 0.10633903f, 0.13931741f, 
    -0.01325949f, -0.02448517f, 0.19098884f, 0.29158297f, 0.04695749f, -0.02172103f, 0.03417500f, 0.19388124f, 
    0.07758509f, 0.09728248f, 0.06120767f, 0.06193929f, 0.16555624f, 0.39380741f, 0.57472527f, 0.41032949f, 
    -0.05797041f, -0.00775786f, 0.12304436f, 0.10402332f, -0.02092684f, -0.02856512f, 0.01729158f, -0.00712829f, 
    0.11235087f, -0.16852373f, -0.01596944f, 0.13289316f, 0.04930575f, 0.12950739f, 0.07383492f, -0.00148428f, 
    0.05078035f, -0.02051714f, -0.03255191f, 0.09992505f, -0.14610299f, -0.04972129f, -0.12863627f, -0.25595489f, 
    0.04619882f, -0.00558666f, -0.01608186f, 0.12252143f, 0.09126124f, -0.09272506f, 0.00751315f, -0.09983039f, 
    -1.02665448f, -0.15031947f, 0.02361407f, -0.14895633f, 0.13551970f, 0.06321197f, -0.06158677f, -0.19498080f, 
    0.06229277f, -0.09253342f, 0.02013222f, -0.02568729f, 0.09109332f, -0.01526392f, -0.01314227f, 0.16595243f, 
    0.03069469f, 0.02548453f, -0.00234208f, 0.03361578f, 0.01739395f, 0.06147264f, 0.13947089f, -0.00529143f, 
    -0.43852741f, 0.15048298f, 0.14664561f, -0.36911890f, 0.04173920f, -0.00930907f, 0.06052601f, -0.02036694f, 
    -0.02550073f, 0.10886979f, -0.10533454f, -0.02180909f, -0.15151663f, -0.04412701f, 0.19900426f, -0.33100730f, 
    0.21239661f, -0.00622507f, -0.14474997f, -0.06341507f, 0.05300909f, -0.01020157f, 0.05042795f, 0.03490222f, 
    -0.48560387f, 0.02944775f, 0.08023024f, -0.56582570f, 0.00130081f, -0.03340396f, -0.09012976f, 0.13719474f, 
    -0.00230420f, 0.01655639f, -0.04213424f, 0.04399903f, -0.04447139f, -0.09186342f, 0.02173577f, 0.02649369f, 
    -0.02092905f, -0.03477748f, 0.07029118f, 0.03929178f, -0.02208178f, 0.00664957f, -0.10980902f, -0.01032489f, 
    -0.00753250f, -0.15138362f, 0.09734066f, 0.20007844f, 0.10453179f, 0.02165583f, 0.04070920f, -0.00150766f, 
    -0.01755276f, -0.11157359f, -0.01034486f, -0.04702253f, 0.01056404f, -0.07845123f, 0.02105268f, -0.13061188f, 
    -0.00646559f, -0.03708998f, -0.10037016f, -0.04895855f, -0.01629327f, 0.01867573f, -0.12676433f, 0.17194216f, 
    -0.07793675f, -0.10019901f, 0.12755117f, 0.02975816f, 0.02021551f, 0.03775870f, 0.04002531f, 0.04540384f, 
    0.00789307f, -0.06881364f, 0.05098516f, -0.01641918f, 0.00219621f, -0.10474055f, -0.25351617f, -0.06061781f, 
    -0.01712600f, -0.03059518f, 0.02430061f, 0.06665397f, -0.06298442f, -0.12271326f, 0.01392767f, -0.02093152f, 
    -0.45999175f, 0.04208125f, -0.36361682f, -0.09023827f, -0.04204321f, 0.02017622f, 0.02735832f, 0.01531770f, 
    -0.04815865f, -0.03193944f, 0.02707739f, -0.03173168f, -0.11268692f, -0.04415463f, 0.00362257f, -0.01130386f, 
    -0.09388573f, 0.12250780f, -0.04400196f, 0.12186129f, -0.03085059f, -0.02362965f, -0.01522700f, 0.03001922f, 
    -0.09848001f, -0.47212428f, -0.34465107f, -0.10976789f, 0.03868029f, -0.07356373f, -0.00096741f, -0.10825889f, 
    -0.08304684f, -0.03732704f, -0.05112642f, -0.03919407f, -0.17923576f, 0.29464382f, 0.18491328f, -0.35278791f, 
    0.02257079f, -0.24613655f, 0.10228690f, -0.07750451f, -0.05851654f, 0.12344918f, 0.07243081f, -0.08742982f, 
    -0.27854887f, 0.17643219f, -0.02062387f, 0.03639841f, -0.03675716f, 0.01557242f, 0.01484296f, -0.01249672f, 
    0.02532890f, -0.07765104f, 0.20618333f, -0.20155349f, -0.58054167f, -0.38345894f, -0.05134567f, 0.23645560f, 
    0.01658555f, -0.03769166f, -0.15747391f, -0.05633607f, 0.03229312f, -0.03760953f, 0.03229933f, -0.04521480f, 
    0.35360882f, 0.57941043f, 0.48062027f, 0.59006971f, 0.07256313f, -0.03568581f, -0.12752631f, 0.09749883f, 
    0.05712648f, -0.02739560f, 0.03243052f, -0.00109666f, -0.74673122f, -0.18358141f, -0.41410890f, -0.05091312f, 
    -0.00948105f, -0.00679504f, -0.09070968f, 0.14135545f, -0.02605072f, 0.04497895f, -0.02700687f, -0.04650803f, 
    0.08464307f, -0.01522575f, -0.07483571f, 0.21863489f, -0.03311976f, 0.03711367f, 0.05303346f, -0.04723568f, 
    0.07033051f, 0.08674514f, 0.09535258f, -0.08991157f, -0.11779314f, -0.12764621f, -0.24671878f, -0.03136059f, 
    0.02565893f, -0.01346134f, 0.06753492f, 0.06996104f, -0.02539985f, -0.01424963f, -0.08119343f, 0.03633976f, 
    -0.17592579f, -0.09262273f, -0.03548883f, -0.03315099f, -0.12405950f, -0.10432868f, 0.02575117f, 0.00017674f, 
    -0.02384371f, -0.00327476f, -0.00495780f, 0.00527165f, 0.04988331f, -0.14884654f, -0.28913057f, 0.05088942f, 
    0.07632025f, 0.11557782f, -0.06371178f, 0.20045213f, 0.01557869f, -0.07038465f, 0.01101835f, 0.04819467f, 
    -0.65773284f, -0.02418767f, 0.04759629f, -0.13796106f, -0.23954412f, -0.15026402f, -0.02784923f, -0.10080092f, 
    -0.00127168f, -0.02042290f, 0.01273484f, 0.00549599f, 0.00967085f, -0.07667986f, -0.14101945f, -0.20022117f, 
    0.10302882f, -0.16178530f, 0.00283826f, 0.12457615f, 0.12382925f, -0.04360789f, 0.02173756f, -0.11373272f, 
    -0.03460250f, 0.02306952f, 0.11706027f, -0.23146425f, 0.06243727f, -0.08867011f, -0.24376753f, -0.13734151f, 
    0.10705944f, -0.01432576f, -0.00706765f, 0.08507145f, -0.40554905f, 0.30485541f, 0.12323779f, 0.02509516f, 
    -0.05012571f, -0.11795978f, 0.10250586f, -0.00266509f, 0.13653353f, -0.08350202f, 0.13553420f, -0.05127399f, 
    -0.25664210f, 0.04244983f, -0.08441404f, 0.09305823f, -0.01321059f, 0.02413910f, -0.07132567f, -0.00260065f, 
    0.09372386f, 0.06549327f, -0.03490634f, 0.11068191f, -0.09401098f, -0.10426052f, -0.12814161f, 0.02921383f, 
    0.02727803f, 0.00611147f, 0.07475530f, -0.01955931f, 0.01946635f, -0.00091216f, 0.02855662f, 0.00042362f, 
    0.00378196f, 0.01901535f, -0.08847316f, -0.08670704f, 0.07713254f, -0.02265311f, -0.03467698f, 0.21060114f, 
    -0.02466294f, 0.04639975f, 0.00668667f, -0.00295583f, -0.13595659f, 0.00755203f, 0.01011911f, -0.04756974f, 
    -0.00492408f, -0.00509168f, 0.00672124f, 0.01257982f, 0.09754947f, -0.10840063f, -0.03639362f, 0.04964759f, 
    -0.03231188f, 0.04894815f, -0.13170484f, -0.02719337f, -0.01602324f, -0.02904478f, 0.03926748f, -0.00540510f, 
    -0.01746074f, -0.04325413f, 0.06611538f, -0.09675884f, 0.00760682f, -0.03648340f, -0.13383771f, 0.03234848f, 
    0.02123654f, -0.05118954f, 0.05492236f, 0.04865789f, 0.04416713f, 0.03973217f, -0.06737842f, 0.06089114f, 
    -0.07768261f, -0.07366666f, -0.01566760f, -0.06186159f, -0.02891987f, -0.02953073f, -0.01443982f, -0.00670077f, 
    -0.05194364f, 0.05349594f, 0.10490008f, 0.16874339f, -0.04320495f, -0.02438618f, -0.10238332f, 0.11963594f, 
    -0.03886592f, 0.07719121f, 0.01018604f, 0.05332937f, 0.09878876f, -0.08571958f, -0.00090605f, 0.02882186f, 
    -0.40001267f, 0.38787618f, 0.06868569f, -0.19390886f, -0.04848855f, 0.01286134f, -0.03379594f, -0.02159129f, 
    0.06007287f, -0.11992439f, -0.20460801f, 0.04453997f, 0.05638826f, 0.05330258f, -0.12829617f, 0.00141897f, 
    -0.03519968f, -0.00583625f, 0.04469445f, -0.09048510f, 0.04325950f, 0.16107562f, 0.08395351f, -0.05879379f, 
    -0.07335647f, 0.04524650f, -0.15427960f, 0.19034411f, -0.08750994f, 0.06290169f, 0.03598228f, 0.11596499f, 
    -0.04135793f, 0.05289093f, -0.04187784f, 0.03682898f, -0.09865301f, 0.13779403f, -0.12843290f, 0.07469153f, 
    0.00064828f, 0.02420307f, -0.03190070f, -0.03962887f, 0.14496030f, 0.12914348f, -0.01804255f, 0.29245278f, 
    0.05359439f, -0.16514219f, 0.04511369f, -0.04446946f, 0.04402980f, 0.00267014f, -0.16488506f, 0.05399936f, 
    0.03179825f, 0.01286579f, -0.00233924f, 0.14189586f, -0.02858890f, 0.22102849f, -0.07297171f, -0.05818051f, 
    -0.13203847f, -0.03562446f, -0.02478703f, 0.07665803f, 0.01300177f, -0.09394203f, 0.02812798f, 0.02875759f, 
    -0.32163385f, 0.24987508f, -0.11576675f, -0.03000156f, 0.02142482f, 0.00018047f, 0.00491817f, 0.00639374f, 
    0.06163807f, 0.00198616f, -0.03383983f, 0.04324063f, -0.06581125f, -0.15491532f, -0.10139450f, 0.06139436f, 
    0.05248724f, 0.00675541f, 0.02661904f, -0.04387952f, 0.00741625f, -0.05004923f, -0.12417051f, -0.00614714f, 
    -0.31862774f, -0.25121704f, 0.03313935f, -0.21985848f, 0.09721798f, 0.10281435f, -0.01175470f, -0.02249575f, 
    0.08480186f, 0.02044638f, -0.04954886f, 0.07653123f, -0.46828833f, -0.41526255f, -0.26648682f, 0.00216048f, 
    0.09427874f, -0.00818396f, -0.00129772f, 0.04710718f, 0.01688592f, -0.01887943f, 0.04746155f, -0.04209693f, 
    -0.25978789f, 0.05890206f, 0.01361262f, -0.27563024f, -0.08255571f, -0.11730198f, 0.11612423f, -0.13256197f, 
    -0.00711312f, -0.02708474f, -0.05475269f, 0.01233757f, -0.01453875f, -0.05532135f, 0.04284627f, 0.00084944f, 
    0.01710100f, 0.03983591f, -0.10318502f, 0.12588401f, 0.02725765f, -0.07127070f, -0.01219753f, 0.01284241f, 
    -0.13421296f, 0.05839102f, 0.07892190f, -0.05940212f, 0.08485316f, -0.13644338f, -0.30670431f, -0.00604500f, 
    0.04539346f, -0.05054472f, 0.05187707f, 0.04852855f, 0.13021289f, 0.57186836f, -0.19456767f, -0.09565536f, 
    0.00669202f, 0.05028755f, -0.00775944f, 0.10333455f, -0.03460690f, 0.05486784f, 0.03290576f, -0.16530077f, 
    -0.03647275f, 0.09651846f, 0.47404709f, 0.19867888f, 0.01061066f, -0.04003242f, 0.01209131f, 0.01254400f, 
    0.01088342f, -0.02385014f, -0.05010872f, -0.11595169f, -0.07785337f, -0.03611698f, -0.06044715f, -0.06825347f, 
    0.12309288f, 0.00432044f, 0.00950100f, 0.12400015f, -0.00884943f, 0.06547668f, 0.08885507f, 0.06557785f, 
    -0.21004863f, 0.16247259f, 0.25038710f, -0.10801245f, 0.03039377f, 0.00219315f, -0.00836662f, -0.08627420f, 
    -0.07549259f, 0.00250661f, -0.16725025f, 0.04185169f, 0.16701840f, -0.19713189f, 0.20347884f, -0.16576508f, 
    0.05474833f, -0.01023778f, 0.05641630f, 0.11917718f, 0.04519986f, 0.00772108f, 0.02788729f, -0.00827730f, 
    -0.12111145f, 0.01373852f, -0.00181921f, -0.05341373f, -0.01003881f, -0.04661174f, -0.15106139f, -0.22713378f, 
    0.03855466f, 0.06130749f, -0.13195476f, 0.04537052f, -0.16167372f, -0.09747055f, -0.03538143f, 0.02639804f, 
    0.00001366f, 0.00091917f, -0.09221939f, 0.05414747f, 0.01070430f, 0.02853141f, -0.14279626f, 0.12516212f, 
    -0.36818585f, 0.40592238f, -0.05698974f, -0.07858986f, 0.06922406f, -0.33049509f, 0.07212850f, 0.06876630f, 
    -0.18517590f, 0.12547404f, -0.14067331f, -0.16694984f, 0.05987552f, -0.06601198f, -0.05538905f, 0.15911636f, 
    0.01057331f, 0.06247146f, -0.08679622f, -0.00315956f, 0.07451449f, 0.03682224f, -0.00024411f, -0.06782003f, 
    0.40833640f, -0.12095615f, -0.00158035f, 0.09038145f, 0.10743330f, 0.06900241f, 0.00067138f, -0.05733388f, 
    -0.05550647f, -0.01689171f, 0.01099216f, 0.00013352f, 0.18460861f, 0.07321925f, 0.29441819f, 0.15436910f, 
    -0.15997462f, -0.06032989f, 0.12853830f, 0.06744239f, 0.12058143f, 0.11952856f, 0.08770330f, 0.07176111f, 
    -0.02475802f, -0.21348116f, 0.03928940f, -0.08826172f, 0.08376084f, -0.16308333f, 0.07441652f, -0.01515220f, 
    0.02460138f, -0.14400305f, -0.04415568f, 0.06876598f, -0.12787561f, -0.15720184f, 0.01008002f, 0.07306850f, 
    0.00465817f, 0.21244198f, 0.01218169f, 0.03453336f, 0.05087031f, -0.04416896f, 0.03537088f, 0.02919693f, 
    -0.31185091f, 0.82913005f, -0.34670001f, -0.64429772f, 0.20282209f, 0.05114616f, -0.04772099f, 0.00533759f, 
    -0.48560342f, -0.01314264f, -0.09156451f, 0.03229557f, -0.02045314f, -0.16491407f, 0.06801980f, 0.20370562f, 
    0.15684892f, 0.09011471f, 0.06589817f, -0.07377237f, -0.04086204f, -0.00169786f, -0.02501215f, 0.10431340f, 
    -0.08130027f, 0.19542681f, -0.41307837f, -0.09159909f, -0.04575714f, -0.10068991f, -0.14284866f, -0.07756523f, 
    -0.09396383f, -0.03879601f, 0.04645642f, 0.05030704f, -0.02615531f, 0.72619843f, 0.03592205f, 0.46739861f, 
    0.04219283f, -0.13696364f, 0.11739846f, -0.07329550f, 0.11092214f, 0.09195330f, -0.03771491f, 0.00239714f, 
    -0.04033939f, -0.21482874f, 0.05962155f, 0.21764952f, 0.00922489f, 0.21418810f, 0.16005424f, 0.09013329f, 
    -0.02026678f, -0.00804570f, -0.04854520f, -0.04538953f, 0.15021010f, 0.35398054f, -0.20950454f, -0.18906312f, 
    0.14967306f, 0.09450060f, 0.07409682f, -0.06665380f, -0.18574882f, -0.02972514f, -0.05893239f, -0.03054152f, 
    -0.31851447f, -0.26708409f, 0.28740147f, 0.08554576f, -0.11270021f, -0.18910179f, 0.01198286f, 0.08338556f, 
    -0.00170756f, 0.10014033f, -0.13793059f, 0.03968845f, 0.04447716f, -0.01663416f, -0.01985043f, 0.15437840f, 
    -0.08182639f, 0.06186725f, 0.09649601f, -0.00478393f, -0.02400105f, 0.10377771f, -0.00535555f, -0.05424806f, 
    -0.41495448f, -0.01033547f, 0.32571128f, 0.20009702f, 0.01144203f, 0.03361269f, -0.14669858f, -0.05179403f, 
    -0.01153124f, -0.06241819f, -0.13308954f, 0.10104180f, -0.14157543f, -0.12978902f, 0.15355012f, -0.11855672f, 
    0.03478184f, -0.05194252f, -0.04231297f, 0.08349734f, 0.00824640f, -0.04376920f, -0.04380029f, 0.13565953f, 
    0.16106346f, 0.19860050f, -0.19000028f, -0.07493840f, -0.02755643f, -0.00190692f, -0.14121050f, 0.03106716f, 
    -0.05270683f, -0.00067450f, -0.02526613f, 0.01230163f, -0.06152678f, 0.01159081f, 0.41890630f, 0.09133430f, 
    -0.06102144f, -0.08963118f, -0.02257060f, 0.05684137f, 0.08452928f, -0.02084693f, 0.02375612f, 0.03324702f, 
    0.08269827f, -0.11667233f, -0.00605178f, -0.13364592f, -0.09806108f, -0.03180830f, -0.01049261f, 0.05259050f, 
    -0.08036576f, -0.09889710f, 0.04368971f, -0.00514458f, -0.34972027f, 0.01186834f, -0.23006670f, -0.20005712f, 
    0.22454776f, 0.18295819f, 0.20572101f, 0.04163623f, -0.12084597f, -0.00286978f, 0.00014023f, 0.02111479f, 
    -0.30903408f, 0.07925642f, -0.11741265f, 0.19573748f, -0.02363238f, 0.09780257f, 0.07497730f, 0.15915792f, 
    0.02285451f, -0.03195867f, -0.05083122f, 0.10102530f, 0.18729228f, -0.12471219f, 0.24272746f, -0.33385342f, 
    -0.24163553f, -0.20423765f, 0.00636521f, 0.02319598f, 0.08648013f, 0.08134384f, 0.17192137f, -0.03893658f, 
    0.00112554f, -0.16927943f, -0.09219468f, 0.03609966f, 0.10564976f, 0.06021840f, -0.06289373f, 0.20658076f, 
    -0.07262541f, 0.03355411f, 0.02362595f, -0.16395780f, -0.14862700f, 0.17953619f, 0.00417400f, 0.42782024f, 
    -0.13053712f, -0.02882118f, -0.09002737f, -0.05178604f, 0.02361317f, 0.13310695f, -0.00344658f, 0.10584372f, 
    0.13070397f, -0.34806454f, 0.00243872f, 0.08619110f, -0.11129492f, -0.00101251f, -0.02569876f, 0.03930228f, 
    -0.03715185f, -0.02614091f, 0.20303988f, -0.05047667f, 0.07275464f, -0.09107406f, 0.03682908f, 0.06722818f, 
    -0.01610835f, -0.00697357f, -0.09375321f, -0.06990600f, 0.01209753f, 0.13385993f, -0.01578130f, -0.06349266f, 
    0.44706085f, -0.20089535f, 0.11712261f, 0.24514115f, 0.10805136f, -0.11115853f, -0.08096737f, -0.04593941f, 
    -0.04224578f, 0.00503314f, 0.10842669f, 0.05812117f, 0.04663999f, -0.19694908f, -0.15655039f, -0.02414813f, 
    0.08347920f, 0.06511662f, -0.03324159f, 0.06174616f, 0.09277078f, -0.04925840f, 0.06511445f, -0.07839081f, 
    -0.03706115f, 0.04727686f, -0.21883515f, -0.33332768f, 0.23487632f, -0.11103573f, -0.03765731f, -0.24262442f, 
    0.02529581f, 0.12638040f, -0.17862190f, -0.01831758f, -0.27508017f, -0.50982755f, 0.11600503f, -0.12217695f, 
    -0.09145489f, -0.13276215f, 0.01981351f, 0.19158098f, 0.09753871f, 0.20626150f, -0.04392642f, 0.04110109f, 
    0.05485964f, 0.03282863f, 0.14922234f, 0.14341395f, 0.11948925f, -0.12845513f, 0.05447347f, -0.05109214f, 
    -0.04600181f, 0.09908735f, 0.04860579f, -0.06819956f, 0.16617768f, -0.05409353f, -0.02452543f, -0.02850236f, 
    -0.08159676f, 0.12957413f, -0.07117929f, -0.16867609f, -0.03387928f, 0.01442748f, 0.00948428f, 0.06001480f, 
    -0.04874800f, -0.16965632f, 0.15567350f, 0.22755761f, -0.07267123f, 0.07308275f, -0.05212137f, 0.10504416f, 
    0.03792418f, -0.01579640f, -0.04041073f, 0.12009795f, -0.25080517f, -0.02325025f, -0.10496596f, 0.06336495f, 
    0.03651534f, 0.03559737f, -0.10508676f, -0.03457930f, -0.07069983f, 0.01407204f, -0.06272403f, -0.00350824f, 
    -0.21356013f, -0.14338537f, 0.32252702f, -0.04484724f, -0.15604426f, 0.09921380f, -0.07566465f, -0.01693103f, 
    -0.04841367f, -0.00999079f, -0.14276169f, 0.06307777f, -0.57878745f, 0.01714325f, 0.06910582f, 0.33307210f, 
    0.26320967f, 0.14364429f, 0.02542669f, -0.05266057f, 0.01446931f, -0.12567671f, 0.12681535f, -0.03539558f, 
    -0.93891484f, 0.02431952f, 0.08362851f, -0.20955710f, -0.10380020f, 0.12348447f, -0.21012808f, -0.09042398f, 
    -0.17029798f, 0.10130435f, -0.04781194f, 0.07001834f, -0.13328040f, 0.12042507f, -0.18230037f, -0.14307785f, 
    0.05805351f, 0.01515395f, -0.23401149f, -0.10705640f, 0.03387123f, -0.06361113f, 0.11175214f, -0.02070378f, 
    0.25686249f, 0.09701049f, 0.01401552f, 0.00299064f, 0.12782930f, -0.08377425f, 0.05936854f, -0.09207508f, 
    -0.13173729f, 0.15876308f, -0.22290123f, -0.01993613f, -0.50239819f, 0.10884071f, -0.00729633f, -0.18321280f, 
    -0.17212011f, 0.04596759f, -0.20800053f, -0.09182700f, 0.06080071f, 0.05976540f, 0.07002552f, -0.10946543f, 
    -0.14372426f, 0.53802669f, -0.08584235f, 0.10648156f, 0.16571414f, -0.11854590f, 0.12576032f, -0.07682960f, 
    0.02483157f, -0.04333135f, -0.09754099f, -0.03246784f, -0.10375084f, 0.07137814f, -0.28820464f, -0.40937999f, 
    0.04898315f, 0.04535192f, 0.02508871f, 0.00532320f, 0.02123477f, 0.15819839f, -0.02740584f, 0.04595883f, 
    -0.04704297f, 0.10677473f, -0.07436673f, -0.01855517f, -0.00913037f, 0.03028157f, -0.09199961f, -0.04879530f, 
    0.01195203f, 0.09021821f, -0.01218796f, -0.05219875f, -0.34845611f, -0.10187947f, -0.07041385f, -0.02181629f, 
    -0.11393689f, -0.16984719f, -0.15775897f, 0.13464665f, -0.17035662f, -0.06407370f, -0.12083042f, -0.07538688f, 
    0.08825152f, -0.04114503f, 0.07516212f, 0.11213720f, 0.02788504f, 0.09806087f, 0.11162008f, -0.07142563f, 
    -0.17382728f, 0.19363026f, -0.02977810f, -0.02910239f, 0.38102201f, -0.03349867f, 0.02027501f, 0.00598025f, 
    -0.11357159f, 0.03737687f, -0.11971588f, 0.00674086f, -0.06208214f, 0.13076194f, 0.07596387f, 0.12068229f, 
    0.00386632f, 0.04336342f, -0.27328667f, -0.70864725f, 0.09534437f, -0.12783569f, -0.06212018f, -0.21131888f, 
    0.19487661f, 0.08556868f, -0.16334461f, 0.08358467f, 0.07126383f, 0.15911528f, 0.00578477f, -0.08743469f, 
    -0.08883546f, -0.02700277f, -0.09050574f, -0.07128228f, -0.06798648f, 0.02372151f, -0.08992085f, -0.08770861f, 
    0.10597689f, -0.13757513f, 0.04529470f, -0.02071404f, -0.10063951f, -0.02681992f, 0.04592505f, 0.07114414f, 
    -0.07624599f, -0.04197459f, 0.05859348f, -0.05894548f, 0.12662229f, 0.03435639f, 0.11208483f, 0.15356955f, 
    0.00021394f, -0.02823921f, -0.05800992f, -0.04949305f, 0.05574190f, -0.01588580f, 0.20497613f, -0.14631872f, 
    -0.58422959f, -0.03890496f, 0.27792069f, 0.04114887f, -0.03958866f, -0.20207229f, 0.04468271f, -0.12532724f, 
    -0.06248016f, 0.11259715f, -0.01212652f, 0.01575335f, 0.22121057f, -0.04007489f, 0.01191958f, -0.03847658f, 
    -0.05770366f, 0.03889661f, -0.08244549f, 0.08827896f, -0.04417330f, 0.07393015f, -0.07775575f, 0.16418314f, 
    0.03320093f, -0.03897240f, -0.10544167f, 0.10533159f, 0.07165562f, 0.09449917f, -0.04099317f, 0.05882141f, 
    0.02170833f, -0.09624181f, 0.04547334f, 0.04338017f, -0.07365724f, -0.05628747f, -0.27334732f, 0.05795355f, 
    0.08872558f, 0.03402837f, -0.01190947f, 0.05407682f, -0.01966344f, -0.04979202f, 0.02940911f, -0.02683237f, 
    0.02939730f, -0.04726860f, 0.03910067f, 0.17371207f, 0.06315793f, 0.03282441f, 0.08320344f, 0.03494374f, 
    -0.04092387f, 0.10357559f, -0.06226148f, -0.04325669f, -0.09671416f, 0.09080368f, 0.12980112f, 0.17256327f, 
    -0.00236143f, 0.03852239f, -0.24640720f, -0.20499982f, -0.06641501f, -0.16131012f, 0.09557413f, -0.06946635f, 
    -0.06830168f, 0.24736410f, -0.15841088f, -0.22361518f, 0.11765218f, -0.02497853f, -0.17110030f, 0.07112880f, 
    0.03935743f, -0.01403659f, -0.10087579f, 0.00417944f, -0.71484798f, 0.62487698f, -0.27670187f, 0.08711459f, 
    0.00987435f, 0.04501175f, -0.03796511f, -0.02960915f, -0.24918333f, -0.01839843f, 0.10794152f, 0.05182867f, 
    -0.03140368f, -0.04191560f, 0.02220127f, 0.13815023f, 0.06334059f, 0.01522251f, -0.10123083f, -0.00994719f, 
    -0.11890380f, -0.00090576f, 0.04215839f, -0.01097159f, -0.14749046f, 0.10145519f, 0.02190518f, -0.18234628f, 
    0.18315594f, -0.12553765f, -0.05098681f, -0.14524415f, -0.19738704f, -0.03220820f, -0.22020221f, -0.01834447f, 
    -0.10892820f, -0.11335283f, 0.00849913f, 0.19484043f, 0.06000957f, 0.03124802f, -0.05369172f, -0.08307444f, 
    0.04172483f, 0.06741906f, 0.03906293f, 0.02607969f, 0.07059952f, 0.13899438f, 0.22838330f, -0.25415933f, 
    -0.24724436f, -0.18292847f, -0.03509709f, -0.17454034f, -0.03815160f, 0.05886775f, -0.12997386f, 0.15719262f, 
    -0.09595218f, -0.27510110f, 0.06101841f, 0.16772068f, -0.05356658f, -0.03182475f, -0.14333934f, 0.10863425f, 
    -0.04103420f, 0.13330857f, -0.10084282f, -0.16247949f, -0.33265981f, -0.19308256f, -0.19996364f, -0.06710581f, 
    -0.01046786f, -0.06899566f, -0.01348463f, -0.11564884f, 0.02787117f, -0.06412238f, -0.04623262f, 0.02013391f, 
    0.04497686f, -0.14452398f, 0.08800001f, -0.05905585f, -0.01370964f, 0.07773552f, -0.12264246f, 0.03942637f, 
    -0.17376728f, -0.03771208f, -0.14237456f, -0.29338786f, 0.05760816f, 0.11368414f, 0.10294097f, 0.07669520f, 
    -0.01978081f, -0.05429870f, -0.00899178f, 0.03780280f, 0.02185796f, 0.02261852f, 0.04126746f, 0.00863711f, 
    0.00692599f, -0.02809837f, 0.10561974f, 0.01529536f, -0.04130749f, -0.06877686f, -0.11928372f, 0.06283998f, 
    0.13923302f, -0.09838451f, 0.00991926f, 0.03928294f, 0.17647322f, 0.17571762f, -0.18411864f, 0.16980739f, 
    -0.02794405f, -0.00237137f, -0.14034612f, -0.18385181f, 0.16011719f, -0.10434901f, -0.01356254f, 0.04327214f, 
    -0.05227581f, 0.06548991f, -0.04662177f, 0.01290650f, -0.16872735f, 0.06805708f, 0.03049492f, 0.00043431f, 
    -0.05924109f, -0.07556529f, 0.03816458f, -0.12968433f, 0.03704888f, 0.11521241f, 0.13233750f, 0.17200272f, 
    -0.02293371f, 0.11054567f, -0.25292948f, 0.00750651f, 0.02085499f, 0.08727997f, -0.11842210f, -0.07139990f, 
    0.11716613f, -0.61983895f, 0.11913151f, 0.08377758f, -0.18260276f, 0.05847311f, -0.06357256f, -0.08130873f, 
    -0.12539093f, 0.02625770f, -0.07454240f, -0.07437613f, -0.00731910f, 0.16345367f, 0.18359695f, 0.17365551f, 
    -0.10569038f, -0.14990768f, -0.03946812f, 0.06175254f, 0.20565285f, -0.12508096f, -0.07032322f, 0.15326296f, 
    -0.15077855f, -0.25049284f, -0.05932051f, -0.25960928f, -0.00101609f, -0.05636903f, -0.00382560f, 0.08723598f, 
    0.02532977f, 0.08748049f, -0.02193671f, -0.04669968f, 0.10236584f, -0.27509269f, 0.20963183f, -0.11581652f, 
    0.07842623f, 0.23328665f, 0.05950041f, -0.00963047f, -0.08531366f, -0.05296580f, 0.01489145f, -0.00305392f, 
    0.19141737f, 0.31061479f, 0.11008745f, 0.19397363f, 0.20945899f, 0.07771912f, -0.02874069f, 0.15098190f, 
    -0.02948756f, 0.00974774f, -0.10108594f, -0.02975275f, -0.13414013f, -0.14802401f, 0.01478938f, 0.04804549f, 
    -0.14197668f, -0.02442844f, -0.04681943f, -0.05854479f, 0.09838520f, 0.24751596f, 0.08823127f, 0.35262376f, 
    -0.04034178f, 0.27203861f, -0.33334616f, -0.14942643f, 0.02699186f, 0.06946611f, -0.19304617f, -0.02834515f, 
    0.00394091f, -0.02097724f, 0.13926648f, -0.00620436f, -0.10044236f, 0.12473773f, 0.06370678f, 0.14678961f, 
    0.03108136f, 0.03880382f, -0.03013016f, 0.01528275f, -0.07254419f, -0.01234404f, -0.08511854f, -0.07897892f, 
    -0.00221544f, 0.26692411f, -0.14039186f, 0.06209073f, 0.13553666f, -0.00669235f, 0.08032325f, 0.04839183f, 
    -0.00594552f, 0.01277343f, 0.02536479f, -0.07529880f, 0.07635168f, -0.00397326f, -0.03810468f, 0.01241528f, 
    0.07480019f, -0.02892467f, 0.02271469f, 0.04787041f, 0.03203530f, -0.07788413f, -0.07873126f, 0.04994325f, 
    0.18168287f, -0.18753734f, 0.03995162f, 0.05489910f, -0.14244162f, -0.04492825f, -0.18920305f, -0.02608131f, 
    -0.05853104f, -0.04270383f, -0.07950623f, -0.06017874f, -0.01201388f, 0.28757843f, -0.33564517f, 0.12938130f, 
    0.04531817f, -0.08554161f, 0.09729183f, -0.10361376f, 0.09628851f, 0.04537946f, 0.10939137f, 0.03347424f, 
    -0.24470097f, -0.32261601f, -0.23902582f, -0.13071796f, 0.02400895f, 0.05094241f, 0.06492903f, 0.06534126f, 
    0.12263951f, 0.00108725f, 0.04598053f, -0.03177980f, 0.01649010f, 0.00775972f, -0.01611714f, 0.04743634f, 
    0.09301347f, 0.05401587f, 0.05648299f, 0.06905403f, -0.08924916f, 0.11431716f, -0.07320573f, 0.12707931f, 
    0.02996482f, -0.02988424f, 0.26664558f, 0.13002238f, 0.02808214f, -0.01683223f, -0.03071629f, -0.02625795f, 
    -0.06410258f, 0.04485693f, 0.06626411f, 0.03337127f, 0.16067781f, -0.12461066f, -0.06037573f, -0.06606010f, 
    0.00300842f, 0.07549006f, -0.04590202f, 0.01648518f, 0.04074481f, -0.01857420f, -0.00435526f, -0.05306691f, 
    0.22201318f, 0.13652128f, 0.26460102f, 0.20316574f, -0.21560492f, -0.04696470f, -0.04539790f, 0.00867086f, 
    0.10365164f, 0.04115605f, 0.03839145f, 0.03921105f, -0.06280033f, -0.00468245f, -0.13287157f, -0.07218388f, 
    0.04919856f, -0.12429048f, -0.07138196f, -0.03343414f, 0.02744533f, -0.11722793f, 0.08060299f, -0.19015458f, 
    -0.45598334f, 0.04222634f, -0.10398275f, -0.16584750f, 0.04103889f, 0.00912476f, 0.08909550f, -0.01506633f, 
    -0.17151810f, 0.04337292f, -0.18529370f, 0.27726570f, -0.20424810f, -0.05187417f, -0.00406041f, -0.04022107f, 
    -0.09717314f, -0.04663723f, 0.00185540f, 0.00707925f, 0.04292754f, -0.05347485f, 0.01344422f, 0.07984819f, 
    -0.05120630f, -0.10689205f, -0.00900137f, 0.13286601f, -0.04759637f, -0.19117135f, -0.11317846f, -0.06561229f, 
    0.00715195f, -0.01338044f, 0.03518560f, 0.02242564f, 0.02324881f, 0.03764068f, 0.20671014f, 0.18671691f, 
    -0.22929765f, -0.07360505f, -0.10017470f, 0.05735270f, 0.11850245f, 0.00431605f, -0.05126998f, -0.01398358f, 
    -0.13166675f, 0.08529537f, -0.05698429f, -0.10584109f, -0.13609740f, -0.08795956f, 0.09614149f, 0.06051767f, 
    -0.12137003f, -0.14386830f, -0.16257489f, 0.01156405f, 0.00480421f, -0.04080788f, -0.03038837f, -0.07160758f, 
    0.04931060f, 0.01253234f, 0.07646548f, -0.00828526f, 0.05521548f, 0.02294154f, 0.02345356f, 0.11847678f, 
    -0.01996926f, 0.09084220f, 0.03803287f, 0.09684715f, -0.05457341f, -0.08654296f, 0.00070531f, 0.19431570f, 
    -0.05379547f, 0.01096539f, -0.05847833f, -0.09120249f, -0.12657547f, -0.11829757f, -0.02558130f, 0.17487106f, 
    -0.06632763f, 0.04314453f, -0.11289208f, -0.22158447f, -0.00195053f, 0.05661829f, -0.07224939f, 0.06830227f, 
    0.22279412f, 0.31378168f, 0.24435221f, 0.30282366f, 0.07642959f, 0.05752448f, 0.03436952f, 0.14450172f, 
    0.04810412f, -0.05534703f, 0.06308296f, 0.00475863f, 0.20004009f, 0.18963072f, -0.20998713f, -0.02819292f, 
    0.01600101f, 0.04574165f, 0.02279166f, -0.09571122f, -0.04463914f, -0.05020392f, -0.26327696f, -0.04191909f, 
    -0.00177608f, 0.10879376f, -0.29670030f, 0.23829456f, -0.16093180f, -0.09975047f, -0.18168391f, -0.15695356f, 
    0.09817548f, -0.05649669f, 0.05084936f, -0.00230420f, -0.20625268f, -0.09250795f, 0.19180867f, -0.00058496f, 
    -0.02798562f, 0.03588368f, 0.05179993f, -0.03938604f, -0.00793992f, -0.25908914f, -0.23485754f, 0.08376300f, 
    0.11401068f, -0.03063591f, 0.02614947f, -0.10457456f, 0.01885119f, -0.00420260f, 0.15441677f, -0.06798080f, 
    0.04823028f, -0.10163043f, -0.01621891f, 0.00601685f, 0.00954503f, -0.10170180f, 0.11168882f, -0.00827656f, 
    0.00689837f, -0.00120557f, 0.04473247f, 0.02200428f, 0.02696201f, -0.04227490f, -0.09445187f, -0.04553619f, 
    -0.06633598f, -0.07407038f, 0.01967672f, 0.10226309f, 0.01054419f, 0.01903807f, -0.02604196f, -0.09853608f, 
    0.01084907f, -0.02835094f, 0.00365579f, -0.00928845f, 0.00197016f, -0.23617354f, -0.13506192f, -0.00356242f, 
    0.02909714f, 0.01410042f, 0.05709169f, 0.05008978f, 0.05586733f, 0.06755396f, -0.01876860f, 0.06566294f, 
    -0.23949309f, -0.36294109f, 0.00645114f, -0.32184178f, 0.05934063f, 0.06613839f, 0.00633922f, 0.06637132f, 
    -0.04772739f, 0.03068242f, -0.01646662f, -0.15319921f, -0.25144276f, -0.22455502f, -0.27195901f, 0.01295179f, 
    0.06785829f, -0.03658727f, 0.07344202f, -0.02321461f, -0.03277939f, -0.07291964f, -0.09125093f, 0.06572866f, 
    0.05569976f, -0.02459340f, -0.01577209f, 0.04681345f, -0.00236514f, -0.01117802f, -0.01477703f, -0.02709514f, 
    0.09806607f, 0.11308006f, 0.06527599f, 0.20558622f, 0.09159104f, -0.12422933f, -0.06826035f, -0.08481451f, 
    -0.03236346f, 0.01122109f, 0.04231178f, -0.04650058f, 0.06055187f, -0.05865519f, 0.04922491f, -0.14879094f, 
    -0.01184502f, -0.03225068f, -0.07440069f, 0.08117490f, 0.07157574f, 0.01749116f, 0.01476127f, 0.05174660f, 
    -0.04806227f, -0.32217848f, -0.16443543f, -0.09072667f, -0.08363657f, 0.06834032f, -0.05790650f, -0.14843933f, 
    -0.00229774f, -0.11841300f, -0.01988156f, -0.05069139f, -0.18037762f, -0.10578358f, 0.03735757f, -0.04424379f, 
    0.02923042f, -0.11237762f, -0.02982780f, -0.01607934f, -0.10950413f, -0.00296377f, -0.11520301f, 0.07459683f, 
    -0.36871660f, -0.19251165f, -0.10443053f, 0.00641238f, -0.06925101f, -0.15200156f, -0.01357900f, -0.10401641f, 
    0.06900216f, -0.00798033f, 0.01121684f, -0.04043435f, 0.18125372f, 0.00677420f, 0.14421716f, 0.11598323f, 
    -0.07989677f, 0.14230937f, -0.19853589f, -0.02740067f, -0.11207614f, -0.04107831f, -0.05092900f, -0.08942961f, 
    0.00592536f, -0.00967602f, -0.20416689f, 0.12967356f, -0.10524997f, 0.01093732f, -0.08291314f, -0.03515165f, 
    0.11740357f, -0.17041045f, -0.14282978f, 0.13341084f, -0.09591918f, -0.04844726f, -0.04075967f, -0.03233114f, 
    0.01168321f, -0.30362695f, -0.03170488f, -0.37794912f, -0.04091234f, -0.10106868f, 0.09678714f, 0.08994813f, 
    0.08828978f, 0.04700471f, 0.04360200f, -0.14291877f, 0.11811036f, 0.01403789f, 0.01075207f, 0.11698878f, 
    0.00895282f, 0.03479833f, -0.03474308f, 0.02486533f, 0.01189073f, -0.15624510f, -0.11332814f, -0.13192417f, 
    -0.00711358f, 0.10657717f, 0.18993965f, 0.10851532f, 0.09354359f, -0.12038194f, 0.06443437f, -0.02044628f, 
    -0.04806789f, 0.03511085f, 0.09627751f, -0.07205509f, -0.01261236f, -0.09249061f, 0.23352513f, 0.05151543f, 
    -0.26196477f, 0.02129568f, -0.18472430f, 0.03072327f, -0.03393422f, 0.03937897f, 0.02491504f, 0.00149089f, 
    0.02703345f, 0.06438519f, 0.19885407f, 0.09951329f, -0.04396231f, -0.04331530f, 0.01295393f, -0.05131777f, 
    0.10245971f, -0.00616914f, 0.09730902f, -0.00358894f, -0.01611365f, 0.00752464f, -0.06875854f, 0.09105045f, 
    0.08493286f, -0.22531158f, 0.03950324f, 0.11990518f, -0.03805468f, 0.02308312f, -0.07515799f, -0.06642018f, 
    0.01264698f, 0.01982990f, -0.01190435f, 0.14297441f, 0.05099253f, 0.22103883f, -0.08587903f, -0.01061923f, 
    0.07494145f, 0.10957696f, 0.04219911f, -0.05056482f, -0.01031296f, -0.56528831f, 0.30689141f, -0.05695268f, 
    0.03276777f, 0.05020234f, -0.02478870f, -0.15943229f, -0.05701064f, -0.01254346f, -0.03573076f, 0.07622112f, 
    0.00589884f, 0.05874131f, -0.09419929f, 0.11472713f, -0.17505072f, -0.11231314f, 0.10822700f, -0.00681977f, 
    -0.01623996f, 0.04525448f, -0.02456120f, 0.04980825f, 0.21805774f, -0.01651207f, 0.08830937f, 0.01319232f, 
    -0.13601905f, -0.05701046f, -0.09628011f, 0.00459417f, -0.21376368f, -0.22304772f, -0.01328933f, -0.26726314f, 
    -0.00380370f, 0.10316053f, 0.05871352f, 0.11768489f, -0.00133913f, -0.06278151f, -0.01119864f, 0.07349085f, 
    -0.11093541f, -0.05235200f, -0.09574722f, 0.09254679f, 0.18744266f, 0.00674869f, -0.15519582f, 0.05178640f, 
    0.10060781f, -0.01366831f, 0.06849337f, -0.09804869f, 0.08853425f, -0.03359804f, -0.00378827f, -0.13778202f, 
    -0.01404619f, 0.11753739f, 0.10582129f, 0.04589660f, 0.01517051f, 0.08169361f, -0.08029123f, -0.05648452f, 
    -0.09259548f, -0.10036839f, 0.04278377f, 0.01369164f, -0.00683444f, 0.02825250f, -0.05071862f, -0.00349218f, 
    0.04927814f, 0.10188529f, -0.00401719f, 0.02841865f, 0.07851418f, 0.05778734f, 0.02018588f, -0.00892117f, 
    -0.10210601f, -0.40341765f, 0.04404315f, 0.03295147f, 0.19964673f, 0.00868641f, -0.18189614f, -0.06733064f, 
    0.01470790f, -0.09407640f, 0.08055285f, 0.26970518f, -0.01619471f, -0.02188936f, -0.01064214f, -0.07163126f, 
    0.21671441f, 0.07376813f, 0.23903796f, 0.11629509f, 0.05538839f, 0.05414863f, 0.06137418f, 0.07711355f, 
    -0.07418939f, -0.07111485f, -0.18246298f, 0.01688360f, -0.03504150f, -0.11026259f, 0.05244710f, -0.05653661f, 
    0.11998446f, -0.00330033f, -0.08243650f, -0.10592920f, -0.02804770f, -0.11438804f, -0.03237455f, -0.01733825f, 
    0.02309959f, 0.04021126f, -0.13297652f, 0.04136633f, -0.10871805f, 0.02337761f, 0.24226826f, -0.15153430f, 
    -0.06210072f, -0.08862044f, 0.12064303f, 0.01233837f, 0.07746069f, 0.07811285f, -0.15111813f, -0.09849640f, 
    -0.01877327f, 0.07183576f, -0.01333770f, 0.01939685f, 0.11750507f, -0.02654806f, -0.03428927f, 0.04010363f, 
    -0.13007043f, 0.17112689f, 0.06150536f, -0.03208690f, -0.18128939f, 0.01062731f, 0.15677209f, -0.01728385f, 
    -0.32540861f, -0.12189455f, 0.15820011f, -0.21090229f, -0.01347505f, -0.07989752f, -0.08601470f, -0.11997380f, 
    -0.02325631f, -0.10014997f, -0.06086968f, 0.20595424f, -0.24900608f, -0.15364240f, -0.20831245f, -0.42272320f, 
    0.01902363f, -0.03167334f, -0.03460684f, 0.04060482f, -0.00249832f, -0.05621487f, -0.07843378f, -0.18545321f, 
    0.11286431f, 0.04713993f, 0.12976941f, -0.05711286f, 0.04840935f, -0.05203637f, 0.00860123f, -0.01528938f, 
    0.06599864f, -0.02492535f, -0.13078912f, 0.12730232f, -0.12334827f, 0.05362304f, -0.08186565f, -0.17137818f, 
    -0.10003153f, -0.17553757f, -0.15377554f, 0.06103073f, -0.10241984f, 0.20285322f, -0.07794254f, -0.11282042f, 
    0.08425236f, 0.10341433f, 0.03343095f, -0.05328111f, -0.13239765f, 0.01697370f, -0.10301261f, -0.24890627f, 
    0.04387535f, -0.01470499f, 0.01172689f, 0.05296339f, -0.22470656f, -0.12987530f, 0.17433643f, -0.03409535f, 
    0.01845754f, -0.06166028f, -0.05559225f, 0.01071509f, 0.10651063f, -0.22106005f, -0.08037790f, -0.28860554f, 
    -0.02574845f, 0.03914139f, -0.52991247f, -0.22577056f, 0.01922415f, 0.14559707f, -0.12709814f, 0.24590878f, 
    0.08960816f, -0.20715457f, 0.00699079f, -0.01128554f, 0.12503257f, 0.17373614f, 0.20208097f, -0.01021222f, 
    0.03923549f, 0.04016301f, 0.07571489f, 0.03028950f, 0.04493051f, -0.00545038f, -0.01736948f, 0.05983125f, 
    0.31756130f, -0.22995870f, -0.37845433f, 0.10248136f, 0.11083589f, 0.05553111f, 0.06318884f, 0.00103116f, 
    0.09736795f, -0.05900037f, 0.07209674f, -0.02938190f, 0.08349353f, -0.11963332f, 0.01073156f, 0.06559499f, 
    -0.13387285f, -0.03706648f, 0.02951026f, 0.02370012f, 0.06731942f, 0.11860464f, 0.14336854f, -0.09974658f, 
    -0.21485361f, 0.07828348f, 0.02885970f, -0.05629327f, -0.05830179f, -0.05686999f, 0.02009751f, 0.00629637f, 
    0.13159905f, 0.03367444f, -0.07057773f, 0.07133824f, -0.01738880f, -0.08750781f, -0.38456282f, 0.12461183f, 
    0.00224897f, 0.14214370f, 0.12773077f, 0.03933143f, 0.01709854f, -0.19101810f, -0.12049831f, -0.50137210f, 
    0.57282650f, -0.06189347f, 0.05636085f, 0.22205824f, -0.00133084f, -0.04743125f, -0.02629961f, 0.03454176f, 
    0.02437101f, 0.00722127f, -0.01254700f, -0.00099383f, -0.02861886f, -0.02981219f, -0.08733083f, -0.05929435f, 
    0.01639936f, -0.04592770f, -0.07553626f, 0.00072790f, 0.02786289f, -0.16968279f, -0.02233450f, -0.14939779f, 
    0.28738472f, 0.03431506f, 0.25954139f, -0.07205712f, -0.05146427f, -0.10071666f, 0.02219820f, -0.28025693f, 
    0.06733587f, -0.00401951f, -0.01596479f, -0.02453325f, 0.00774194f, 0.01792084f, -0.31078503f, 0.36273262f, 
    0.06928014f, 0.03286415f, 0.04315986f, -0.01459441f, 0.00533652f, 0.01948691f, -0.01671110f, 0.04597329f, 
    0.19091208f, 0.04647001f, 0.01136425f, -0.02534164f, 0.14743094f, 0.01950276f, 0.01623248f, -0.16044702f, 
    -0.04559717f, 0.01490548f, -0.03675652f, 0.01625230f, 0.09511884f, 0.11420835f, -0.29055128f, -0.09588180f, 
    0.09133847f, 0.13530990f, -0.16955997f, -0.03334327f, 0.08888710f, -0.07044625f, -0.02091870f, 0.11398292f, 
    0.27003297f, 0.02109878f, -0.16653377f, 0.09060871f, -0.06745166f, -0.03382918f, -0.10595249f, 0.17893824f, 
    -0.03758594f, 0.05453240f, -0.14833908f, -0.27779463f, -0.09956275f, 0.03142457f, 0.13731994f, -0.23300107f, 
    -0.00498038f, -0.08554827f, 0.13801692f, -0.02574125f, -0.04976817f, 0.00561199f, -0.06017306f, 0.01924202f, 
    -0.58159125f, 0.11578169f, -0.15855041f, -0.29106009f, -0.04286088f, -0.11038831f, 0.17482007f, 0.14233886f, 
    0.00636253f, -0.05119904f, 0.08640639f, 0.01028271f, 0.05861467f, -0.03304064f, 0.06191305f, 0.02613861f, 
    0.12201393f, 0.25524950f, 0.14039285f, 0.01141579f, 0.07038579f, 0.03736349f, -0.03282436f, 0.12655513f, 
    0.20346360f, -0.46963808f, 0.17932639f, 0.04388965f, 0.04443980f, 0.04487749f, -0.11654805f, 0.17930146f, 
    -0.03937894f, -0.08117066f, 0.15501672f, -0.10500095f, -0.10864506f, -0.04880747f, -0.11242194f, 0.15679722f, 
    0.05622996f, -0.10414867f, -0.05890852f, -0.06076589f, 0.00551193f, -0.09052309f, 0.14491600f, -0.13488708f, 
    -0.06618318f, 0.03088005f, -0.01507901f, -0.06483881f, 0.02297748f, 0.30868313f, 0.01232341f, -0.10692494f, 
    0.12375153f, -0.01282153f, 0.04589482f, 0.03509494f, 0.16243333f, -0.14983186f, 0.37311125f, -0.08466803f, 
    0.01962985f, 0.05838671f, 0.06918817f, 0.05345934f, -0.00684464f, 0.02766988f, 0.05451946f, -0.11783785f, 
    -0.04505124f, -0.14296781f, 0.17587954f, -0.19953273f, 0.09953997f, -0.01767759f, 0.06518166f, 0.23007961f, 
    0.04664178f, -0.00853395f, 0.06973200f, -0.03441745f, -0.10495837f, -0.18492302f, -0.03685249f, 0.12892596f, 
    0.05118005f, 0.04794948f, -0.16668724f, -0.23610175f, 0.30640942f, -0.03048137f, 0.17890304f, 0.13325864f, 
    -0.11263826f, -0.08082663f, 0.03129608f, 0.15180890f, 0.07858058f, 0.09290219f, 0.15502445f, 0.04146370f, 
    -0.12432677f, 0.14656478f, -0.14681230f, -0.16859759f, -0.06490048f, -0.19676125f, -0.35762727f, -0.32985029f, 
    0.08621226f, 0.08327399f, -0.08935322f, -0.02426304f, 0.09247869f, 0.18990865f, 0.17198101f, -0.19871335f, 
    -0.04506093f, -0.16304994f, 0.01425074f, 0.10582943f, 0.00814595f, 0.02354653f, -0.01803972f, 0.27394027f, 
    0.24488468f, -0.11360197f, 0.25575212f, -0.03662464f, -0.11315986f, 0.04869644f, 0.11604810f, 0.06883779f, 
    -0.04154814f, 0.02616890f, 0.03495339f, 0.07057372f, -0.00222705f, 0.07259776f, -0.03335218f, 0.01869848f, 
    0.24020873f, -0.21377841f, 0.17278820f, 0.08934132f, -0.14587313f, 0.22388853f, -0.00600547f, 0.18914063f, 
    0.13586767f, -0.00361248f, 0.01951767f, -0.00849062f, 0.27103275f, -0.15317944f, -0.13691249f, 0.04467805f, 
    0.03981671f, -0.01106209f, 0.01728903f, 0.00005492f, 0.01673977f, 0.04285565f, 0.00908151f, 0.00814039f, 
    -0.32446718f, -0.07947955f, -0.32323092f, -0.12672171f, -0.01421053f, 0.01150449f, -0.06201280f, -0.02218378f, 
    -0.01541016f, -0.07444800f, 0.05081782f, 0.07914840f, -0.16324539f, -0.02902567f, -0.19009200f, 0.03320834f, 
    0.02083422f, -0.05358225f, -0.01524629f, 0.04961699f, -0.00085425f, -0.05012972f, 0.12805164f, -0.01450449f, 
    0.03138855f, -0.04362176f, 0.20169802f, 0.07568792f, -0.05479804f, 0.06492130f, 0.06820123f, 0.02750189f, 
    0.11910611f, -0.18376075f, -0.14291799f, -0.15943487f, 0.06872544f, -0.22395581f, -0.01450742f, 0.20569113f, 
    0.13828391f, -0.15336338f, 0.10372091f, 0.01331448f, 0.06911604f, 0.03684488f, 0.11242604f, 0.26113716f, 
    0.02113795f, -0.26282182f, -0.34587041f, -0.09552927f, 0.00169897f, -0.03084832f, -0.04635382f, -0.05123239f, 
    0.20421222f, -0.17219011f, 0.28060135f, 0.03318142f, 0.03782374f, -0.00944171f, -0.19801784f, 0.16305262f, 
    0.05107969f, 0.09851688f, -0.08613427f, -0.00698036f, 0.03630921f, -0.30712777f, -0.09635659f, -0.05098916f, 
    -0.07108920f, -0.34164253f, 0.46350235f, 0.13776299f, 0.02756514f, -0.08836856f, -0.04828331f, 0.07390191f, 
    0.16591461f, 0.04703356f, 0.00839640f, 0.11767460f, 0.10587680f, -0.09962212f, -0.21978033f, 0.25548497f, 
    0.01071387f, -0.02225964f, -0.02102422f, -0.00543118f, -0.06556363f, -0.13378505f, -0.09183159f, 0.01412965f, 
    -0.29360032f, -0.02895456f, 0.09739077f, 0.17766696f, -0.09995357f, -0.06263255f, -0.03532424f, -0.02934198f, 
    0.00058515f, -0.23537044f, 0.04039199f, 0.18873507f, 0.17846827f, 0.03102480f, -0.21378149f, 0.15688552f, 
    0.04624877f, -0.02332925f, 0.00359454f, -0.13446131f, 0.24723013f, 0.16202199f, -0.11396832f, 0.26134947f, 
    0.43274432f, -0.00356287f, -0.21127106f, 0.19663537f, 0.10435431f, 0.08405390f, -0.01071971f, -0.05275018f, 
    0.01153371f, -0.05489689f, -0.06889170f, 0.05633103f, -0.05107222f, -0.20485699f, 0.09077450f, -0.06736003f, 
    -0.06002294f, -0.04247174f, -0.01273129f, -0.09309054f, 0.05958150f, 0.05604485f, -0.00202833f, 0.13458046f, 
    0.22877875f, 0.19366278f, 0.07433420f, -0.05955232f, -0.03027026f, -0.06781921f, -0.04168423f, -0.13704070f, 
    -0.10675661f, -0.19046319f, -0.08304331f, -0.08456485f, -0.04669040f, 0.12357193f, 0.18953516f, -0.05068144f, 
    0.18858053f, -0.01588161f, -0.01498695f, -0.03481415f, 0.07069501f, -0.06763638f, 0.04510356f, 0.10743128f, 
    0.11276826f, 0.00536221f, -0.02273215f, -0.12616284f, -0.04221196f, 0.08516444f, -0.00124245f, -0.12569200f, 
    0.09179202f, 0.00549233f, 0.16454875f, -0.10660274f, -0.03201848f, 0.08293670f, -0.08288534f, -0.22356510f, 
    0.03911341f, -0.02369945f, -0.06702602f, 0.03749990f, 0.14885525f, 0.03488376f, 0.01331140f, 0.23663117f, 
    -0.14313169f, 0.00111264f, -0.15427770f, 0.05283730f, -0.11271680f, -0.08350440f, 0.19380678f, -0.07230193f, 
    -0.20525444f, -0.01370504f, -0.16139902f, -0.03732939f, 0.24151450f, 0.11584790f, 0.10653522f, 0.06574644f, 
    -0.14911012f, 0.00909615f, 0.14906323f, 0.01067452f, 0.06534783f, -0.04885202f, 0.02477295f, -0.03426106f, 
    -0.02686319f, -0.00620165f, -0.04576790f, -0.08094939f, -0.02939558f, 0.07504962f, -0.09426671f, 0.06796560f, 
    0.03298519f, -0.02482448f, -0.25190175f, -0.04266389f, -0.26341528f, -0.19803619f, 0.18085398f, -0.13322365f, 
    -0.15871942f, 0.06028961f, 0.01150888f, -0.14489926f, 0.06716994f, 0.08074214f, 0.12198766f, 0.15691735f, 
    0.04891387f, -0.06693806f, -0.14233676f, -0.04398762f, -0.12709834f, 0.03997122f, 0.06419502f, 0.02054866f, 
    0.10399974f, 0.07100507f, -0.00423439f, 0.03597101f, -0.21656072f, -0.00485532f, -0.25299603f, -0.01989117f, 
    0.00048339f, 0.12045365f, -0.21337740f, 0.23774785f, -0.07606063f, -0.02856926f, 0.02557587f, -0.08429132f, 
    -0.18630339f, 0.13901375f, -0.16815211f, -0.09199461f, 0.16657853f, -0.05047603f, 0.08732338f, 0.13079418f, 
    0.03306479f, -0.23930165f, -0.08586523f, -0.01216563f, -0.10107946f, -0.12799071f, -0.07208779f, 0.00262983f, 
    0.06003755f, -0.03559136f, -0.04001894f, -0.05507711f, -0.06944859f, -0.00576343f, 0.06984669f, 0.03630068f, 
    -0.07434455f, 0.07205031f, -0.08243916f, -0.14760524f, -0.12994561f, -0.06049258f, 0.04820268f, 0.09399668f, 
    -0.04190922f, 0.05114463f, 0.04166373f, 0.03540184f, -0.44110146f, -0.47218743f, -0.38438156f, -0.03068351f, 
    0.07179115f, -0.24066050f, -0.25551006f, -0.34060505f, -0.06091187f, -0.02948112f, -0.08935183f, -0.01666426f, 
    -0.24448748f, 0.24311702f, 0.22240391f, 0.04862696f, -0.13516562f, 0.01558957f, -0.08948438f, -0.09812269f, 
    -0.10311612f, -0.00795121f, -0.03488879f, -0.00793419f, 0.01461866f, -0.11408187f, -0.08294318f, -0.09515066f, 
    0.01215736f, 0.09646985f, 0.07606218f, -0.03829866f, 0.00385096f, -0.02318995f, 0.01388426f, 0.03799463f, 
    -0.02014227f, -0.09950069f, -0.01979392f, 0.16067940f, -0.03430039f, 0.10253651f, 0.11119694f, 0.08356286f, 
    -0.02513256f, -0.09993844f, 0.02742987f, -0.00009520f, 0.45657155f, 0.39078927f, -0.30067927f, -0.30459929f, 
    0.12217031f, 0.00647314f, 0.15703137f, -0.04845101f, 0.17030135f, -0.10172596f, -0.01677851f, -0.02430387f, 
    -0.12423908f, -0.15712243f, 0.16962242f, -0.02736246f, 0.02717827f, -0.15300509f, 0.09475808f, 0.04856845f, 
    -0.02137122f, 0.16970246f, 0.10372736f, -0.04940008f, -0.11201612f, 0.49637222f, 0.21835098f, -0.05553900f, 
    -0.00330622f, 0.06749240f, -0.00984676f, 0.09717233f, 0.03263404f, 0.13367313f, 0.05830324f, 0.10485701f, 
    0.17494191f, -0.07585612f, -0.24983285f, 0.09570913f, 0.05543065f, -0.07781010f, -0.01425840f, 0.15160042f, 
    -0.01353101f, 0.02421639f, 0.10556084f, -0.22126727f, -0.21036528f, -0.19702943f, -0.13861161f, 0.34757572f, 
    0.01346881f, 0.12844463f, 0.08658864f, -0.13613161f, -0.01104348f, 0.02287168f, 0.05593372f, 0.04560779f, 
    -0.14465293f, -0.66257972f, -0.27705821f, -0.15278198f, 0.08850471f, 0.04288164f, 0.14013252f, -0.26103666f, 
    0.07525930f, -0.01693131f, -0.01401437f, 0.06957980f, -0.07200707f, 0.02462668f, -0.00759313f, -0.07820952f, 
    -0.04122039f, 0.11715212f, 0.06229677f, 0.09790096f, 0.14477144f, 0.01300122f, 0.05349436f, 0.09285921f, 
    0.29831764f, 0.04595459f, 0.45791620f, -0.29067370f, 0.07310324f, -0.02522466f, 0.16185774f, -0.06138936f, 
    0.09581167f, 0.01348042f, 0.08057129f, 0.05720919f, -0.26005137f, -0.54900640f, -0.39416364f, -0.43602821f, 
    -0.02670540f, -0.10047398f, 0.10307559f, -0.10966067f, 0.03579967f, 0.04765969f, 0.01917999f, -0.02850106f, 
    0.01763656f, -0.33739218f, 0.02140557f, -0.02804145f, 0.16170242f, 0.04691356f, 0.20901045f, -0.12056497f, 
    -0.04421470f, -0.07202683f, 0.03207916f, 0.08506923f, -0.14741103f, -0.07783128f, 0.04788558f, 0.11301227f, 
    0.01851142f, 0.00344174f, -0.10097329f, 0.03094690f, -0.04951913f, -0.18102889f, 0.08664836f, 0.10692352f, 
    -0.31659880f, -0.14323901f, 0.23908609f, -0.05641824f, -0.08894718f, -0.24885084f, -0.10496426f, 0.17617983f, 
    -0.08944012f, 0.14691186f, 0.01173476f, 0.02171253f, 0.01369720f, -0.05193679f, -0.02179291f, -0.04919171f, 
    -0.02486438f, -0.01211352f, 0.19789666f, -0.08078092f, 0.00594003f, 0.06010298f, 0.10627777f, 0.04251776f, 
    0.09662183f, -0.01936112f, -0.25789398f, -0.14943339f, -0.00093761f, -0.00843891f, 0.00619861f, 0.08571338f, 
    -0.07515316f, 0.06503458f, -0.02085931f, -0.03821053f, -0.12779567f, -0.11795917f, -0.03394508f, -0.04547843f, 
    0.03054866f, -0.01311389f, 0.01393822f, -0.00321459f, 0.02096963f, 0.04363743f, -0.02851852f, 0.07929004f, 
    -0.40531754f, -0.47841930f, -0.28200713f, 0.10132295f, -0.05094611f, 0.03722148f, -0.17977303f, -0.19814152f, 
    -0.07024559f, 0.00180170f, 0.11275740f, 0.06423737f, 0.12754470f, -0.03380174f, -0.28952560f, -0.47014990f, 
    -0.16692400f, 0.15734018f, 0.17277144f, -0.12073066f, -0.08234577f, -0.04469982f, 0.05182143f, 0.01697247f, 
    -0.76500940f, -0.62095666f, 0.28321719f, -0.36625060f, -0.04814994f, -0.24110070f, -0.24388818f, -0.27542576f, 
    -0.00250001f, -0.07286936f, 0.09525821f, -0.04061719f, 0.31856337f, -0.02482887f, -0.11490485f, -0.09964882f, 
    -0.04091864f, -0.10092711f, 0.14418395f, 0.08029336f, 0.03043455f, 0.10026537f, -0.17401631f, -0.01839609f, 
    -0.06706175f, 0.33748892f, 0.00755506f, -0.05862509f, -0.07016052f, 0.00258319f, 0.07685877f, 0.00357112f, 
    0.01072159f, 0.08625874f, 0.04842485f, 0.20131291f, -0.19292219f, -0.48204249f, -0.42683417f, -0.19138962f, 
    0.02417598f, 0.02620715f, 0.02101191f, -0.14706028f, -0.03620627f, 0.03578767f, 0.00276998f, 0.02877210f, 
    -0.76219326f, -0.45895886f, 0.43820310f, 0.35288474f, -0.01247652f, -0.00437733f, 0.03938344f, -0.08251536f, 
    -0.05021698f, 0.03674180f, -0.02358507f, -0.04070149f, -0.47961810f, -0.62249207f, -0.34577382f, -0.26091462f, 
    -0.21405849f, -0.17365742f, -0.15972432f, -0.30643499f, -0.05445031f, -0.01945614f, -0.01181388f, -0.00669823f, 
    0.25730008f, 0.13359877f, -0.06997842f, 0.17549524f, -0.17645815f, -0.01114048f, 0.12058469f, 0.36492097f, 
    0.02408465f, 0.06009100f, -0.11225646f, 0.15136836f, -0.08389293f, -0.07514454f, -0.10775249f, -0.12481081f, 
    -0.04538254f, -0.04926279f, 0.00138007f, 0.06457997f, -0.05999966f, -0.04014678f, -0.01400907f, -0.26855767f, 
    0.03425340f, -0.13695750f, -0.11518926f, -0.14815983f, -0.03013283f, -0.05020758f, 0.15356679f, -0.01865899f, 
    0.01452588f, -0.03615129f, -0.08594609f, -0.09159996f, -0.10709071f, -0.51585984f, -0.24344032f, -0.03827634f, 
    0.08571818f, 0.15104184f, -0.11248252f, -0.11608628f, 0.06260893f, 0.02568984f, -0.03620098f, 0.05540958f, 
    -0.95485950f, -1.04374838f, -0.24651994f, 0.06347088f, 0.00664567f, 0.10238790f, 0.05974900f, -0.01147005f, 
    0.04380029f, -0.03792701f, 0.02412724f, 0.06895354f, 0.02671041f, 0.09993283f, 0.18125227f, 0.00491550f, 
    0.02532323f, 0.01833162f, -0.16182584f, -0.14420743f, 0.08385453f, -0.09358692f, 0.08629553f, 0.07337648f, 
    0.34960401f, -0.39217728f, -0.27960405f, -0.00676135f, -0.06380176f, 0.05248487f, 0.08896033f, 0.11207277f, 
    0.00476111f, -0.00715244f, 0.03553280f, 0.01690437f, -0.03098921f, 0.44633013f, 0.13122568f, 0.02772538f, 
    -0.05490692f, -0.05252787f, -0.08061911f, -0.07297201f, 0.02700662f, 0.03544943f, -0.05265415f, 0.15754358f, 
    0.14947900f, 0.12366442f, -0.09464579f, 0.00168267f, 0.01061561f, 0.02492799f, 0.23176774f, 0.06118783f, 
    0.11905236f, -0.12981269f, 0.13562298f, -0.06037714f, 0.02444509f, 0.00528727f, -0.12451404f, 0.08935361f, 
    -0.03239809f, -0.01285796f, 0.07566878f, 0.03512507f, -0.07241625f, -0.02174739f, -0.02546142f, 0.01135478f, 
    -0.37729621f, -0.37370551f, -0.21870150f, 0.18787396f, -0.06238820f, 0.10536212f, 0.01944702f, -0.24457131f, 
    0.00813223f, -0.04290634f, -0.04113295f, -0.10657260f, 0.11811843f, 0.07171975f, -0.15381625f, 0.00528579f, 
    -0.03949724f, -0.03255207f, 0.05293632f, 0.09171685f, -0.07086069f, 0.17154332f, 0.01789486f, -0.00476346f, 
    -0.23280366f, -0.02778987f, 0.13419873f, -0.19568121f, 0.02398218f, 0.03066478f, 0.00409896f, -0.02178827f, 
    -0.08520860f, 0.00261919f, -0.13057421f, 0.09236129f, 0.07261460f, 0.03407475f, -0.14404164f, 0.02265654f, 
    0.03289266f, -0.01070013f, -0.06423466f, -0.04013357f, 0.05161919f, 0.06011918f, 0.03750037f, -0.02002298f, 
    -0.19817318f, -0.00777789f, 0.12919116f, -0.15700285f, -0.00912322f, 0.01112973f, 0.00967020f, 0.07975911f, 
    -0.01114605f, 0.07158884f, 0.20728247f, 0.10229441f, 0.01524228f, -0.06604978f, 0.04829919f, 0.06051917f, 
    0.02192456f, -0.00131722f, -0.01172992f, 0.07162113f, -0.05033314f, 0.05457015f, -0.06903976f, 0.02582836f, 
    -0.14745218f, 0.02595651f, -0.12017439f, 0.14285107f, 0.01289483f, -0.09033310f, 0.05783437f, -0.00911845f, 
    0.06595730f, 0.21097238f, 0.08478916f, 0.01007664f, 0.18897788f, 0.07169762f, 0.09441512f, -0.15588193f, 
    -0.00235669f, -0.02963469f, 0.10373589f, 0.08341184f, -0.01996121f, 0.20591722f, 0.04173654f, 0.13948861f, 
    -0.05513217f, -0.13757443f, -0.15856151f, 0.16996437f, -0.00104860f, -0.05531401f, -0.02435896f, 0.22484617f, 
    0.00260961f, -0.04065919f, 0.08474991f, 0.05952932f, 0.38023183f, 0.06303256f, -0.20419894f, -0.03447700f, 
    0.00443006f, 0.04102533f, 0.04933994f, 0.02802486f, 0.06846514f, 0.23890546f, 0.10524426f, -0.09570182f, 
    0.23145257f, -0.01813527f, -0.32224798f, 0.07092752f, -0.05994468f, 0.00654512f, 0.27666336f, 0.00311198f, 
    -0.02206692f, -0.01583243f, 0.20066424f, 0.00102515f, 0.19396807f, 0.13321728f, -0.12198380f, 0.33996683f, 
    0.03134049f, -0.03033541f, 0.06303302f, -0.01243778f, 0.02289861f, -0.06399801f, -0.01806732f, -0.09932996f, 
    0.05852941f, 0.05588517f, -0.23191574f, -0.12824878f, 0.05770240f, 0.03973898f, -0.00445154f, -0.10755400f, 
    0.04211017f, -0.00045704f, -0.02013374f, -0.01038246f, -0.11810124f, 0.06327631f, 0.00936284f, -0.11602418f, 
    0.01856977f, -0.03743000f, -0.08397746f, 0.07113707f, -0.00699726f, 0.04813830f, 0.01841919f, 0.15914358f, 
    0.02009876f, -0.44995037f, -0.02762976f, 0.01548154f, 0.11049556f, 0.08833415f, -0.03300465f, -0.06651597f, 
    0.04247173f, 0.09066938f, -0.02012637f, 0.01941988f, -0.52865678f, -0.54834574f, -0.18348925f, -0.01945629f, 
    -0.29782009f, -0.21692421f, 0.05852554f, -0.08618485f, -0.05861796f, 0.02182301f, -0.03661224f, -0.02291803f, 
    -0.55634499f, -0.14957917f, -0.10384393f, -0.43208113f, -0.12853152f, -0.13450365f, -0.28371882f, -0.22386849f, 
    -0.04368074f, -0.02962600f, -0.05066152f, -0.11480125f, 0.05821694f, -0.08715352f, -0.05957310f, -0.02773333f, 
    0.09915657f, -0.15390414f, 0.19324575f, 0.01430233f, -0.01327039f, -0.01130627f, -0.08699449f, -0.08739964f, 
    0.27205929f, -0.13504398f, -0.31600085f, -0.08720425f, -0.04650216f, 0.04471232f, 0.01905585f, 0.01272122f, 
    0.03337609f, -0.01651411f, -0.22350122f, -0.03182533f, -0.17340964f, -0.23843205f, -0.04206951f, 0.34805104f, 
    0.10664345f, 0.13405365f, -0.09192995f, 0.02060597f, 0.10710175f, 0.01168147f, 0.06431288f, 0.08826164f, 
    -0.22463484f, -0.17072253f, -0.04252860f, -0.14974587f, -0.08556830f, -0.08166048f, -0.07287388f, 0.02114031f, 
    0.00070953f, 0.01522414f, 0.12302484f, 0.06304392f, -0.19558074f, -0.11541813f, 0.17993918f, 0.10596540f, 
    -0.00567093f, -0.12790412f, 0.15520866f, -0.01331110f, 0.14535229f, -0.01337321f, -0.06507359f, 0.11105544f, 
    -0.31310657f, -0.17343128f, 0.01843287f, 0.14843576f, 0.00307047f, -0.05464764f, 0.01250379f, 0.06435142f, 
    -0.04354791f, 0.02264783f, 0.27561086f, 0.01826291f, 0.02363933f, -0.18292435f, -0.06493711f, -0.14204900f, 
    0.05534581f, 0.07142728f, 0.09764390f, -0.05660599f, 0.01573954f, 0.07210160f, -0.00406527f, 0.02125750f, 
    0.33300740f, 0.21583265f, 0.14777309f, 0.01326127f, -0.04119331f, -0.11447774f, 0.04083787f, -0.10854173f, 
    0.03750011f, -0.16211633f, 0.12769435f, 0.01904914f, 0.13061513f, -0.07502776f, -0.01879195f, -0.05797646f, 
    -0.06097313f, -0.04764609f, -0.02779242f, -0.02558989f, -0.03006603f, -0.14105760f, 0.08823979f, -0.16671425f, 
    0.00093463f, 0.01738162f, -0.06924164f, 0.01806981f, 0.01721230f, 0.01626529f, -0.01858532f, -0.06706899f, 
    -0.06590455f, 0.07689058f, -0.09718242f, -0.01333761f, -0.21538958f, -0.31884542f, -0.25533658f, -0.07517473f, 
    0.16972752f, 0.02271490f, -0.06385840f, 0.08122361f, 0.04200413f, -0.02637206f, 0.00191420f, 0.01410450f, 
    0.34240445f, -0.10845676f, -0.06969245f, -0.06519226f, 0.04576730f, -0.13078283f, -0.05414813f, -0.10061484f, 
    0.03730889f, 0.01053900f, 0.05223928f, 0.01660381f, 0.05300382f, 0.09167419f, -0.00055074f, 0.05519383f, 
    -0.01154510f, -0.09768291f, 0.04275002f, -0.11378037f, -0.04776353f, -0.11015752f, -0.01669969f, 0.05769292f, 
    -0.01512640f, -0.04117172f, -0.04599760f, 0.04589152f, -0.01913430f, -0.10467568f, -0.06946141f, -0.06074755f, 
    0.05907803f, -0.01295575f, 0.04142238f, -0.09584158f, -0.19426231f, -0.28465760f, 0.04464801f, -0.01055296f, 
    0.02310391f, -0.06264376f, 0.00382456f, -0.02583102f, -0.13582815f, 0.09664235f, -0.05312659f, 0.08406363f, 
    0.39567226f, -0.01248733f, -0.01641104f, -0.44841889f, -0.04699069f, 0.02907975f, -0.07969014f, -0.02234270f, 
    -0.09340452f, 0.07717631f, 0.03626091f, -0.07054306f, 0.31581983f, -0.79579288f, -0.48158374f, -0.42715302f, 
    -0.12392946f, -0.08401655f, 0.01175948f, 0.11276809f, 0.16833563f, 0.07708113f, -0.01689781f, 0.08882549f, 
    -0.22033314f, -0.05932626f, 0.01794384f, -0.08825794f, -0.01701363f, -0.06583545f, -0.05679211f, -0.12556905f, 
    0.04153322f, 0.03268487f, -0.00035403f, -0.03596835f, -0.02417129f, 0.09828738f, 0.14370459f, 0.04037919f, 
    0.12510370f, -0.14894336f, 0.11068974f, 0.11779843f, -0.13831824f, -0.00065404f, 0.10582487f, 0.06759494f, 
    -0.44418424f, 0.32786125f, 0.07350744f, 0.19572479f, -0.01990625f, 0.03135359f, -0.00909199f, 0.13828237f, 
    -0.00959661f, -0.00447175f, -0.00467289f, -0.03737957f, 0.41955149f, -0.14275549f, -0.18097454f, -0.23291843f, 
    -0.00731784f, -0.08191288f, -0.03563024f, -0.06506006f, 0.01831253f, -0.00262924f, -0.12316427f, -0.00935390f, 
    -0.11942020f, 0.25493753f, -0.02520481f, 0.21416140f, -0.10071935f, 0.09690137f, 0.02144783f, 0.00556789f, 
    -0.00857239f, -0.04034010f, 0.11696380f, -0.03936693f, -0.44835511f, -0.11348054f, 0.15455981f, 0.44251853f, 
    -0.03576080f, -0.03755089f, -0.10675044f, -0.06487682f, -0.01057844f, -0.06481163f, -0.12530829f, 0.02663130f, 
    -0.10361433f, 0.18271510f, -0.00739344f, -0.13674717f, -0.00051628f, -0.11551400f, -0.00103630f, 0.06343263f, 
    0.01955764f, 0.02743749f, -0.00270052f, -0.03001147f, 0.04295172f, 0.00996964f, 0.07618033f, -0.10113043f, 
    0.01780109f, 0.03047493f, -0.02107755f, -0.02229057f, -0.00122211f, 0.00561670f, 0.09388820f, -0.00036167f, 
    0.55958033f, -0.16405879f, -0.01541810f, -0.23810099f, -0.13250740f, 0.01321716f, 0.12065417f, 0.00666597f, 
    -0.03486085f, 0.11999410f, 0.03903683f, -0.00772756f, -0.13259028f, 0.24133232f, -0.04973524f, 0.02772954f, 
    -0.04759444f, -0.08300300f, 0.05838964f, -0.04605751f, 0.06381954f, 0.13895117f, 0.06132700f, 0.10722757f, 
    -0.07751557f, -0.07943475f, 0.08768158f, -0.07708509f, 0.04087203f, -0.02547253f, -0.02902967f, -0.10465828f, 
    0.02914739f, 0.03074956f, 0.00068166f, -0.01547068f, 0.15432662f, 0.17269838f, 0.02945923f, -0.09171006f, 
    -0.01346521f, 0.02810959f, 0.01523717f, 0.02762681f, -0.08406483f, 0.01298717f, -0.02300496f, -0.14914344f, 
    -0.03970681f, -0.46629924f, 0.27105713f, 0.29107550f, -0.00414628f, -0.04750899f, 0.00179605f, 0.21261951f, 
    -0.00934965f, -0.04061432f, 0.01500407f, -0.00577235f, -0.17553154f, 0.18910304f, -0.27767274f, 0.13476145f, 
    0.00705640f, 0.04194438f, -0.03079928f, -0.15605323f, -0.00440035f, 0.04260297f, 0.02346821f, 0.05591968f, 
    -0.63042730f, -0.22811814f, -0.12045284f, 0.37498268f, 0.16140436f, 0.04139381f, 0.03111138f, 0.04720194f, 
    -0.03651805f, 0.06785738f, 0.01538610f, -0.00386452f, -0.33535087f, 0.26859593f, -0.10499579f, 0.24025080f, 
    -0.10008512f, 0.15590557f, 0.03004838f, 0.11076485f, 0.03910798f, -0.00595565f, -0.02848759f, 0.01183003f, 
    -0.24681045f, 0.12061153f, 0.12544614f, 0.07980023f, -0.01946381f, 0.10918605f, 0.04448298f, -0.03688700f, 
    -0.28009096f, 0.14107530f, 0.02844917f, 0.06760928f, -0.20496315f, -0.27834484f, 0.04702551f, -0.19225669f, 
    0.07261826f, 0.15911920f, -0.00117728f, 0.16890149f, 0.01026889f, -0.04067962f, -0.06231451f, 0.07735465f, 
    -0.06201191f, -0.40781647f, -0.43477067f, -0.37386507f, -0.03495827f, 0.03886119f, -0.04968180f, 0.11249312f, 
    0.08365036f, -0.04365435f, -0.02642977f, -0.00231533f, -0.09418047f, -0.37595618f, -0.24024884f, -0.05889418f, 
    0.04760869f, -0.00331387f, 0.05365120f, 0.07512908f, -0.01002209f, 0.03407678f, -0.02806043f, 0.03293182f, 
    0.07428005f, -0.34969032f, 0.02122605f, -0.14347818f, -0.08481424f, 0.03220525f, -0.13318686f, -0.12566818f, 
    -0.04635051f, -0.04204555f, -0.06714721f, -0.20772611f, 0.08723726f, 0.04586117f, -0.03484358f, -0.03248341f, 
    0.00931480f, -0.00786006f, 0.03780945f, -0.01489546f, -0.00023146f, 0.03001390f, -0.02708817f, -0.11199744f, 
    -0.08013271f, 0.10482635f, 0.08119227f, 0.01041791f, -0.14769025f, -0.13237020f, -0.05944113f, -0.00205770f, 
    0.01433533f, -0.02288915f, -0.02046085f, -0.01705540f, 0.03392512f, -0.37078002f, 0.08019418f, 0.26526666f, 
    -0.16771995f, 0.12988763f, -0.11164128f, -0.04100956f, 0.04181764f, 0.02272946f, -0.04448623f, 0.06424116f, 
    -0.20241605f, -0.13129218f, -0.17358416f, -0.08901632f, 0.09307736f, -0.06374177f, -0.11474416f, -0.06701522f, 
    0.02862796f, -0.00751243f, 0.02347393f, 0.02839463f, -0.11650498f, -0.02089905f, 0.19439207f, -0.01417826f, 
    0.00994176f, 0.02496064f, 0.06393391f, 0.01881230f, -0.00175699f, -0.02035329f, -0.06111451f, -0.06281698f, 
    -0.16992284f, 0.04335004f, -0.06430795f, -0.03512002f, -0.10489370f, 0.13048939f, 0.04331673f, 0.04050751f, 
    0.09864981f, -0.01103956f, 0.12405390f, -0.00218732f, -0.09701320f, -0.01019421f, -0.06538549f, 0.08397134f, 
    0.04386934f, -0.06231931f, 0.02996208f, -0.01603291f, -0.23045857f, 0.03342739f, -0.01823969f, 0.00609141f, 
    0.05376277f, -0.05315633f, 0.06372064f, -0.08438730f, -0.07403454f, -0.09353179f, 0.02681148f, -0.03116915f, 
    -0.01688156f, -0.03139089f, 0.00227939f, 0.07671724f, -0.03893802f, 0.04058645f, -0.02748188f, -0.01479428f, 
    -0.04185266f, -0.05811554f, -0.07157983f, -0.03160850f, 0.03938403f, -0.01788059f, -0.04350945f, -0.00765724f, 
    -0.01201964f, -0.31562120f, 0.15722689f, 0.38641259f, -0.11839782f, 0.06719323f, -0.02020998f, 0.05611208f, 
    0.04352722f, 0.05910694f, 0.04177703f, -0.01204302f, 0.01423565f, 0.02575701f, 0.06011672f, -0.01091918f, 
    0.00768609f, 0.00080461f, -0.06349883f, -0.05571086f, 0.03614198f, 0.01459238f, -0.00225223f, -0.07290297f, 
    0.01155113f, 0.03090306f, -0.02955218f, 0.04920980f, 0.05456704f, -0.02658942f, 0.03297837f, -0.04594852f, 
    -0.03074507f, -0.02102262f, -0.02757234f, -0.04640590f, 0.02545027f, 0.01001184f, 0.03538523f, -0.21694455f, 
    0.01768356f, 0.01008366f, 0.02694377f, -0.03251558f, -0.01088226f, -0.02661267f, -0.05119278f, -0.14850450f, 
    0.15086311f, -0.09669350f, 0.04573290f, -0.04946895f, -0.07641900f, -0.05024309f, -0.03631094f, 0.02471293f, 
    0.04080618f, 0.09419702f, 0.07657243f, 0.00173775f, -0.01363545f, 0.08776969f, 0.00286990f, -0.13560438f, 
    -0.02969046f, -0.04667982f, -0.00412041f, -0.10102464f, -0.02964926f, -0.03760872f, 0.03543135f, -0.10537649f, 
    0.01613462f, -0.12623996f, 0.07938422f, -0.27154735f, 0.00259099f, 0.06787575f, 0.07710496f, -0.00702870f, 
    -0.00747345f, -0.12017418f, -0.01651025f, -0.17955229f, -0.10786957f, 0.16920143f, -0.16810842f, 0.24153933f, 
    -0.08829117f, 0.11167106f, -0.04511846f, -0.01459337f, 0.06926858f, -0.06418452f, -0.03641543f, 0.00430303f, 
    0.30335331f, -0.37268096f, 0.15267938f, -0.26593503f, -0.03031433f, 0.06321896f, -0.04351713f, -0.08812054f, 
    0.00522244f, -0.01468716f, -0.04493836f, -0.20846005f, -0.07545996f, -0.09185505f, -0.02317447f, 0.08186035f, 
    -0.06031920f, 0.02026951f, 0.01981726f, -0.00569427f, 0.04796971f, -0.04044014f, -0.04053006f, 0.05084407f, 
    -0.04258319f, 0.15296675f, -0.04396406f, -0.00700655f, -0.07645282f, 0.04347954f, -0.01995526f, -0.09471364f, 
    -0.09618428f, -0.05381827f, -0.15944664f, 0.03237509f, -0.24761283f, 0.00207924f, 0.01839150f, 0.15957278f, 
    -0.01376958f, 0.14903724f, 0.05691420f, -0.06201705f, -0.11160253f, -0.00254777f, -0.01964810f, 0.01126942f, 
    0.01003809f, -0.08129553f, 0.09950525f, -0.07090153f, 0.03700197f, 0.04198172f, -0.02891710f, -0.03350807f, 
    0.05154589f, 0.02340904f, -0.00079492f, -0.00130439f, 0.14808206f, 0.00809559f, 0.14456996f, -0.06891682f, 
    -0.07992778f, 0.11154665f, 0.04911451f, 0.00818198f, -0.01496941f, -0.03725741f, 0.00174087f, -0.08292770f, 
    -0.40886194f, -0.23115966f, 0.12497537f, 0.28730401f, 0.01267626f, 0.12070569f, -0.06835611f, -0.01495129f, 
    0.04194661f, -0.12561235f, 0.06989580f, -0.03790721f, 0.42824957f, -0.50177753f, -0.07755145f, 0.04420921f, 
    0.06824026f, 0.04393299f, -0.05695004f, 0.17428251f, -0.02620755f, -0.10313039f, -0.07262567f, -0.08558366f, 
    -0.44906300f, -0.25653595f, -0.35466877f, 0.33471686f, -0.02652574f, -0.02071376f, 0.10753155f, -0.06448834f, 
    -0.03688490f, -0.02346121f, 0.07935911f, 0.02848127f, -0.03224244f, 0.08899408f, 0.06200538f, -0.01907827f, 
    -0.07117154f, 0.02421708f, 0.00877869f, -0.02462139f, -0.00739733f, -0.00393226f, -0.03231939f, -0.01166324f, 
    -0.11433666f, -0.07226554f, 0.02663439f, -0.00559573f, 0.00501395f, -0.00619062f, 0.04043071f, 0.11495726f, 
    0.05846492f, 0.02187690f, 0.09221136f, 0.05086066f, 0.16691874f, -0.28727639f, 0.16559550f, -0.32324034f, 
    -0.01034587f, 0.01107964f, -0.00008343f, 0.05649022f, 0.01811915f, 0.09323239f, -0.02014728f, -0.15026067f, 
    0.11779206f, -0.25782952f, -0.10925519f, -0.27091157f, 0.00689051f, -0.11358000f, -0.10437116f, -0.05048366f, 
    0.06233927f, 0.03643693f, -0.01027773f, 0.10727209f, 0.21546087f, 0.00559445f, 0.19858962f, -0.34397307f, 
    -0.06360978f, 0.02779911f, -0.08289492f, 0.07975268f, -0.06733526f, -0.11992642f, -0.14131622f, -0.16841760f, 
    -0.06874403f, -0.37161919f, 0.05610333f, 0.04985929f, -0.10760576f, -0.14897476f, -0.10794651f, -0.07287784f, 
    -0.10601337f, 0.02639372f, 0.17206557f, 0.00200707f, -0.02839598f, 0.14854845f, -0.04561017f, -0.01765904f, 
    -0.02806227f, 0.03406532f, -0.03532224f, -0.04377580f, 0.00234231f, 0.04934794f, 0.05679080f, 0.02460053f, 
    -0.14423841f, 0.04671272f, -0.00789610f, 0.18742590f, -0.03918694f, 0.00129732f, 0.06119993f, 0.01016006f, 
    -0.06667071f, 0.07175087f, -0.00487034f, 0.04225197f, 0.00319829f, 0.01773648f, 0.02754337f, 0.02060792f, 
    0.01574540f, -0.06325794f, -0.03157349f, -0.01868683f, 0.02685487f, 0.00375918f, 0.02287236f, -0.01350487f, 
    0.17763981f, -0.00320420f, -0.02421044f, 0.06862057f, -0.00491937f, -0.01607020f, 0.00450121f, 0.06368200f, 
    0.26393083f, -0.01095704f, 0.17283741f, 0.14707066f, -0.08112550f, -0.41566965f, -0.22254646f, -0.03836159f, 
    -0.01697179f, 0.00919247f, 0.06734511f, -0.06829794f, -0.01208310f, 0.05734298f, 0.06853240f, 0.10043453f, 
    -0.07795370f, -0.21653554f, -0.16635396f, -0.09628932f, 0.02589649f, 0.10223126f, 0.09943442f, 0.15136403f, 
    0.07309718f, 0.01869480f, -0.04972356f, 0.01101498f, -0.25625905f, -0.05969011f, 0.12633885f, 0.05496762f, 
    0.04214684f, 0.05190793f, -0.02480049f, -0.07470106f, -0.09162574f, -0.05465466f, -0.08876976f, -0.20757788f, 
    0.10195525f, 0.07639705f, -0.01823857f, 0.01239736f, -0.02937120f, -0.10379668f, 0.00245434f, 0.02357536f, 
    0.12521349f, 0.01315891f, 0.15457679f, 0.07793962f, 0.13121420f, -0.08709277f, 0.06322287f, -0.00103638f, 
    0.16611715f, -0.20812431f, -0.06763209f, 0.06871035f, -0.01368886f, -0.18116929f, 0.01966329f, -0.19219296f, 
    0.07227406f, 0.01185734f, -0.25819454f, -0.25536975f, -0.01136591f, -0.08903737f, 0.04850323f, 0.05902587f, 
    0.15201883f, -0.01628393f, 0.07608566f, 0.01726211f, -0.49943402f, -0.42618644f, -0.32313889f, 0.04504880f, 
    0.04226139f, 0.16232587f, 0.09902639f, 0.07415509f, -0.18815763f, -0.06541690f, -0.06177511f, -0.31342480f, 
    0.18374734f, 0.07921697f, 0.05102675f, -0.20902936f, -0.13009135f, 0.05556684f, 0.01940743f, -0.00007021f, 
    0.00289888f, 0.01404587f, 0.08483427f, -0.01427861f, -0.08617156f, -0.02796236f, -0.08443357f, 0.09396755f, 
    -0.09455916f, 0.03722256f, -0.00921212f, -0.19931151f, -0.12682053f, -0.15100491f, -0.08825449f, -0.00405399f, 
    -0.13239318f, 0.18672554f, 0.00860312f, -0.14693330f, 0.07632818f, -0.07821208f, -0.12840039f, -0.31011018f, 
    0.00651129f, 0.01363679f, -0.00521767f, -0.03399433f, 0.07870164f, -0.14946218f, -0.24700482f, -0.17098056f, 
    0.03612577f, 0.05049179f, 0.06429331f, 0.02839894f, -0.02192543f, -0.02369149f, -0.03646997f, -0.29197609f, 
    -0.84349948f, -0.05836600f, 0.22438806f, 0.19369933f, 0.06357490f, -0.12193681f, -0.20972829f, 0.03936990f, 
    0.04025234f, -0.13169692f, 0.06129097f, -0.09028790f, -0.07644224f, -0.28229472f, -0.11952911f, -0.16137764f, 
    -0.02377719f, -0.10650313f, -0.06901661f, 0.01331979f, 0.05827489f, 0.12345344f, 0.14761764f, 0.02249109f, 
    -0.37655485f, -0.02885500f, 0.19833921f, -0.00842478f, -0.18457590f, 0.07295550f, -0.13069177f, -0.04615948f, 
    -0.03647579f, 0.07125895f, 0.04152114f, 0.07640633f, -0.10328954f, -0.06763956f, -0.04417511f, -0.12262143f, 
    -0.03838212f, 0.05866689f, 0.04172684f, -0.02942235f, -0.01045648f, 0.10050464f, 0.09443288f, 0.10779931f, 
    0.06519911f, -0.17315310f, -0.27535072f, -0.26228541f, -0.08493528f, 0.02005112f, -0.03872288f, 0.05583157f, 
    0.07146773f, 0.10757910f, -0.02362946f, 0.07663968f, -0.27469221f, -0.03418658f, 0.21194807f, 0.05980355f, 
    -0.02625018f, 0.06024529f, -0.05576615f, -0.03865493f, -0.18406101f, -0.03430283f, -0.06309834f, -0.12006133f, 
    -0.06744254f, 0.11208162f, 0.04273134f, -0.10634755f, -0.10509872f, -0.06030384f, 0.02128840f, -0.04028774f, 
    0.01517537f, 0.00722942f, -0.03084259f, -0.00590748f, -0.01187897f, -0.10378429f, -0.13198540f, -0.24994677f, 
    -0.17591168f, -0.07442040f, 0.02846036f, -0.04134482f, -0.05942133f, 0.01666143f, -0.02658976f, 0.03292555f, 
    0.32293010f, 0.25161368f, -0.32269365f, -0.38688079f, -0.04328708f, -0.26074386f, -0.25536564f, -0.13198993f, 
    0.11921641f, 0.03471876f, -0.01510631f, 0.03928575f, 0.01575969f, 0.13662854f, 0.21293670f, 0.19962010f, 
    0.04246254f, -0.01962313f, -0.10513988f, 0.04885075f, -0.06904362f, -0.13439161f, 0.02017763f, -0.01783401f, 
    0.33623481f, -0.41651163f, -0.35032186f, -0.19744430f, -0.11783244f, 0.05303479f, 0.19108458f, 0.08781993f, 
    0.03791642f, 0.06182249f, -0.00337417f, 0.05370638f, -0.51302904f, -0.05086578f, 0.09585383f, 0.43478721f, 
    0.04912316f, 0.08932561f, -0.00464924f, 0.04038689f, -0.01371431f, -0.06233387f, -0.01019013f, 0.11722865f, 
    0.00448095f, 0.03475609f, 0.22028932f, 0.08894709f, 0.14568889f, 0.04468147f, 0.04530822f, 0.13222282f, 
    0.04562778f, -0.04550149f, -0.02722456f, -0.14713684f, 0.04285557f, -0.11178027f, -0.19696702f, -0.23646593f, 
    -0.12392906f, -0.16440180f, 0.11304692f, 0.04326547f, -0.05812312f, -0.04086894f, -0.05970871f, -0.09742248f, 
    -0.17896913f, -0.40629864f, -0.39555556f, 0.13977532f, 0.13984863f, 0.21805678f, 0.13675915f, 0.07078209f, 
    -0.11264621f, -0.03166273f, -0.00463896f, -0.08158514f, -0.01756886f, -0.45158678f, -0.16929087f, -0.11129715f, 
    -0.11292160f, 0.04272585f, 0.03858342f, 0.08293866f, -0.05007107f, -0.02505747f, 0.02523668f, 0.03046191f, 
    0.25330415f, -0.06465740f, -0.09430765f, 0.07650642f, 0.25769565f, 0.06290302f, 0.01601420f, -0.09140719f, 
    0.01262447f, -0.12777393f, 0.03431497f, 0.04748943f, 0.11708523f, 0.02205894f, -0.09049024f, -0.21906881f, 
    -0.05146863f, 0.00971405f, -0.02480307f, -0.08829778f, -0.00224463f, -0.04337144f, -0.06318768f, 0.01825275f, 
    -0.13035883f, -0.02628986f, 0.03850868f, 0.05110169f, 0.00401357f, -0.13061607f, -0.12547457f, 0.00216391f, 
    0.18992385f, 0.10477120f, 0.08801844f, 0.07346405f, 0.37402770f, 0.20951821f, -0.10156694f, 0.01276603f, 
    0.20394562f, -0.10921897f, 0.11393091f, 0.14184852f, -0.05078484f, -0.03261169f, 0.05022283f, 0.00735363f, 
    -0.13911375f, 0.25644568f, 0.12422058f, 0.11847454f, -0.05367992f, 0.09941447f, -0.06046315f, -0.32420149f, 
    0.05201958f, 0.02645629f, -0.08058104f, -0.01550861f, -0.11097525f, -0.02841217f, 0.04957470f, 0.08548045f, 
    -0.14411591f, 0.07160330f, 0.08905159f, -0.02387197f, -0.04537193f, 0.16204765f, 0.03949952f, 0.02007002f, 
    -0.35571724f, -0.01996980f, 0.06694759f, 0.16845420f, 0.19600967f, -0.07879744f, -0.06108866f, 0.02092693f, 
    -0.23738970f, -0.07320318f, -0.00535574f, -0.08781271f, -0.27813712f, -0.07556222f, 0.15304233f, 0.02470802f, 
    -0.02941791f, 0.04077881f, 0.00905304f, 0.00308975f, -0.04549517f, 0.07482719f, -0.04165766f, 0.14783041f, 
    -0.10285317f, 0.02768319f, -0.03654576f, 0.01012516f, 0.12989688f, 0.06789710f, -0.03101159f, 0.06537239f, 
    0.06091547f, 0.05575185f, 0.00455471f, 0.06383554f, -0.08081478f, 0.02696799f, 0.06014173f, 0.01877688f, 
    0.00960860f, 0.00367959f, 0.00449439f, -0.07399237f, -0.02211149f, 0.08109148f, 0.03188404f, 0.15027787f, 
    0.37172601f, 0.04339273f, -0.22376567f, 0.05389996f, 0.23946503f, -0.06679985f, -0.04289063f, -0.12444152f, 
    -0.01150398f, 0.03565061f, 0.10987350f, 0.10446034f, -0.05290993f, 0.09603287f, -0.10096764f, -0.07752912f, 
    -0.03032633f, 0.00030341f, -0.06336585f, -0.03183911f, -0.10366257f, -0.15078072f, -0.09570051f, -0.04411195f, 
    -0.18127511f, 0.04458293f, 0.13442425f, 0.11243179f, -0.06370293f, -0.07841574f, -0.06463680f, -0.04279261f, 
    0.08485605f, -0.03860703f, 0.10545201f, 0.06590069f, 0.04526086f, 0.06796642f, 0.10054123f, -0.24106055f, 
    -0.12258694f, -0.01751776f, -0.05206833f, -0.06830925f, -0.01185849f, 0.01190480f, 0.03841023f, 0.05738375f, 
    -0.06467527f, -0.01829876f, 0.06122141f, -0.31899992f, 0.03525980f, 0.01240893f, 0.07705344f, 0.06477795f, 
    0.09689832f, 0.05758395f, 0.01206563f, -0.17474860f, -0.00030328f, 0.07097517f, 0.01957249f, 0.01347519f, 
    -0.00849546f, -0.03970444f, 0.01959337f, -0.03697381f, 0.06358962f, 0.12047811f, 0.00713987f, 0.08900688f, 
    -0.45999521f, 0.10428789f, -0.09375090f, 0.23457752f, -0.03139134f, -0.10134645f, -0.04857329f, -0.07153399f, 
    0.08042876f, 0.13316949f, -0.09936150f, 0.28446785f, -0.27064082f, -0.11404677f, -0.12340313f, 0.12979522f, 
    -0.01199808f, 0.02316500f, 0.05161373f, 0.16905752f, -0.09797582f, 0.05848531f, -0.09728047f, -0.21892369f, 
    0.38484639f, -0.15910242f, -0.22335790f, -0.36202338f, 0.21463607f, -0.05471040f, 0.03147140f, -0.07654472f, 
    0.09057210f, 0.12833582f, 0.20484993f, 0.14970674f, -0.05543676f, 0.26065519f, -0.06325699f, -0.06783391f, 
    0.07086564f, 0.03793654f, -0.05540623f, -0.02796547f, -0.09271304f, -0.08737946f, -0.01545561f, -0.09285486f, 
    -0.12962863f, -0.09555406f, 0.20124133f, 0.06938082f, -0.02270461f, -0.03233745f, 0.04043632f, -0.04446280f, 
    -0.03877221f, 0.02516014f, 0.08249621f, -0.13907507f, -0.14204480f, 0.12826373f, 0.04432334f, 0.03183430f, 
    -0.03017540f, 0.03484973f, -0.13071108f, 0.00822609f, 0.03732507f, 0.08155914f, 0.07577441f, 0.06459642f, 
    0.05032544f, 0.19656081f, 0.07433227f, 0.06678726f, -0.06874666f, -0.08014436f, -0.09707186f, -0.05332233f, 
    -0.05038415f, 0.03430612f, -0.04166418f, -0.05322354f, -0.04638498f, -0.09733590f, -0.09615162f, -0.19551592f, 
    0.09075212f, 0.05474472f, -0.05891675f, -0.05516753f, 0.04999031f, 0.25468373f, 0.14032672f, 0.26015842f, 
    0.31496924f, -0.14410284f, -0.18301533f, -0.11272881f, 0.02204191f, -0.00087076f, 0.10376959f, 0.16223305f, 
    -0.04221370f, 0.10774472f, 0.05622379f, -0.03540038f, 0.16725098f, -0.05948782f, -0.59416181f, -0.26930007f, 
    -0.18868323f, -0.20851450f, -0.10196099f, -0.08174077f, 0.03184630f, -0.00096626f, 0.03009681f, -0.00040412f, 
    -0.17619430f, -0.66398358f, -0.45659608f, -0.22105129f, 0.10844113f, 0.00118207f, -0.02191636f, 0.10159854f, 
    0.00214301f, -0.00047878f, 0.00331073f, 0.04567765f, -0.12823334f, -0.09201117f, 0.11062475f, 0.06991451f, 
    -0.01241482f, -0.01208996f, -0.14729938f, -0.04663850f, 0.03004601f, 0.18647476f, 0.14258380f, 0.09736292f, 
    -0.10945635f, 0.03177411f, -0.02094652f, 0.08377676f, 0.06849311f, -0.09781062f, -0.04308695f, 0.01092195f, 
    -0.05474218f, 0.02962396f, 0.07682864f, 0.01177812f, 0.37518641f, 0.24984415f, -0.06176308f, -0.45703313f, 
    -0.08108752f, -0.11855863f, -0.04454291f, -0.00515812f, -0.01186589f, 0.00493154f, 0.06784894f, 0.13663214f, 
    -0.22043768f, -0.33224991f, -0.16247506f, 0.08197763f, 0.15900820f, 0.08178231f, 0.04936392f, 0.08605920f, 
    0.14078560f, 0.02067004f, 0.07875116f, -0.14385206f, 0.11709811f, 0.03421178f, -0.11507065f, -0.03149685f, 
    0.05139534f, -0.03876273f, 0.17766772f, -0.02829161f, 0.18098600f, 0.06098993f, 0.21360312f, 0.15266055f, 
    -0.33011732f, -0.36921826f, 0.13189159f, -0.08334993f, 0.02782297f, 0.00748741f, 0.10878716f, 0.06453412f, 
    0.03127354f, -0.08605874f, 0.13528284f, -0.06114821f, 0.03598535f, 0.10884207f, 0.05758215f, 0.11377815f, 
    -0.10329742f, -0.04979441f, 0.13690606f, 0.13078485f, -0.01062592f, -0.02560537f, -0.01364694f, 0.00685886f, 
    -0.13340646f, -0.03510455f, 0.10278774f, 0.13974789f, -0.02660110f, 0.03337599f, -0.14199722f, 0.07459495f, 
    0.03586368f, -0.12752700f, 0.03310075f, -0.06935862f, -0.27159423f, 0.08163698f, 0.07619666f, 0.04353466f, 
    0.03969993f, -0.03393166f, 0.01112504f, -0.02648198f, -0.07116674f, -0.04561966f, 0.04847566f, 0.04253124f, 
    -0.17624642f, -0.02323709f, -0.04911563f, 0.02426501f, 0.17591928f, -0.11805959f, 0.07444768f, -0.10801576f, 
    -0.22193184f, -0.08996755f, -0.15522800f, -0.00862329f, -0.30788288f, -0.03163136f, -0.11510427f, -0.20047539f, 
    -0.31780711f, -0.00837176f, -0.08704211f, 0.18739446f, 0.06186880f, 0.01996971f, -0.00206600f, 0.00746545f, 
    0.05723330f, 0.30803156f, 0.06259015f, 0.22562228f, 0.09978306f, -0.23445365f, -0.17057836f, -0.11772919f, 
    0.14752190f, -0.01433955f, 0.01050077f, 0.10045532f, -0.03425928f, 0.06086546f, -0.41067445f, -0.00884589f, 
    0.11531755f, -0.03556119f, 0.15410975f, 0.24307454f, 0.00027749f, 0.03591374f, -0.04648291f, -0.03956226f, 
    0.05134688f, -0.20369494f, -0.20182459f, -0.07542031f, 0.15022978f, -0.06748861f, 0.01200859f, 0.01687052f, 
    -0.05037386f, -0.12095885f, -0.07785323f, -0.01454189f, 0.05825811f, 0.08819355f, -0.08758856f, -0.14651327f, 
    -0.20361596f, -0.36366600f, 0.07232470f, 0.09790437f, -0.09792498f, 0.12033196f, 0.01975503f, -0.12299459f, 
    -0.00939869f, 0.08069518f, 0.05713986f, 0.55068517f, -0.08271059f, 0.11547113f, -0.21402092f, 0.10577462f, 
    0.14731596f, -0.03888912f, -0.05050246f, -0.04885730f, 0.08770121f, 0.10188250f, 0.21187529f, -0.02028223f, 
    -0.12627168f, -0.13623932f, -0.18278700f, -0.16471682f, -0.03635520f, 0.00483485f, 0.11848961f, 0.13093178f, 
    -0.08200474f, -0.48476249f, -0.03692754f, -0.25454545f, -0.06044644f, -0.02081450f, 0.04268148f, -0.06468301f, 
    -0.11371081f, 0.02575439f, 0.01569571f, 0.02552425f, 0.03120629f, -0.35779846f, 0.09631103f, -0.45967540f, 
    0.13221824f, -0.03025207f, 0.13998860f, 0.06986409f, 0.10427122f, 0.06254850f, -0.03472960f, 0.12855530f, 
    0.26617619f, -0.15562744f, -0.20668706f, -0.09963821f, -0.09919341f, -0.02924267f, 0.13895498f, 0.21924336f, 
    -0.00929399f, 0.07472964f, 0.02415265f, -0.11219906f, -0.11251757f, 0.04470724f, 0.19232358f, 0.48608446f, 
    -0.06406375f, -0.00406612f, -0.04849564f, -0.08853839f, 0.17198649f, 0.06224823f, 0.10839945f, 0.07713754f, 
    -0.19152600f, -0.14405420f, -0.61258423f, -0.07461154f, -0.06062464f, -0.07163890f, 0.08985718f, 0.00366393f, 
    -0.02141676f, -0.05055844f, -0.02307364f, -0.00514467f, 0.06475451f, 0.12086901f, -0.42787376f, -0.06920169f, 
    -0.17255512f, 0.02568910f, 0.09342560f, 0.07353380f, 0.09163775f, 0.05886915f, 0.01976584f, 0.08808354f, 
    0.10939704f, -0.17109606f, -0.22582208f, 0.05620549f, -0.06591984f, 0.11619796f, 0.01129333f, 0.13552272f, 
    0.03954798f, -0.04391413f, -0.11143456f, -0.01903894f, 0.25022054f, 0.03885162f, 0.12444228f, -0.01038268f, 
    0.06470756f, 0.02880155f, -0.04676849f, -0.10707344f, 0.00224416f, -0.09134600f, -0.02247345f, 0.03026568f, 
    -0.00002201f, 0.13454734f, 0.08123046f, 0.27353913f, 0.02517925f, 0.00258599f, -0.16836855f, -0.01252084f, 
    -0.10705889f, -0.19471736f, 0.02778606f, -0.04288569f, -0.16002935f, 0.03362264f, -0.03921612f, -0.20741180f, 
    0.03643840f, 0.10519452f, 0.13759451f, 0.19381885f, 0.19715212f, -0.11534767f, 0.00955302f, 0.13360989f, 
    -0.16842830f, -0.22143611f, -0.24708429f, 0.14735515f, 0.07445244f, 0.02166979f, 0.14697231f, -0.01109980f, 
    -0.04803362f, -0.01680821f, 0.01167309f, -0.03232624f, -0.16772828f, -0.25811920f, 0.25274894f, 0.15097354f, 
    -0.05103460f, 0.13693909f, -0.16400102f, 0.02182424f, -0.01631312f, 0.13405257f, 0.08107505f, 0.00205799f, 
    -0.45413512f, -0.39082167f, -0.16151641f, 0.04630797f, 0.03802987f, 0.00335690f, -0.02065828f, 0.10465949f, 
    -0.01268216f, 0.09147394f, 0.09871334f, -0.04091058f, -0.56051683f, 0.25048342f, -0.71888870f, 0.17524299f, 
    0.20852622f, -0.12745884f, -0.01400443f, 0.05656964f, 0.02363301f, -0.01246499f, -0.05071251f, 0.09199896f, 
    -0.26844367f, 0.30604160f, -0.30982822f, 0.00790606f, -0.04021407f, -0.07750696f, -0.07808352f, 0.07125521f, 
    0.02076078f, -0.02528344f, -0.01128946f, -0.08203883f, -0.30708438f, 0.27506417f, -0.11586863f, -0.49829084f, 
    0.01910249f, -0.04154370f, 0.24660230f, 0.09396686f, -0.11835348f, -0.01096288f, -0.06086061f, -0.04852444f, 
    0.10138579f, -0.18561092f, -0.41307810f, 0.07072895f, 0.07835847f, -0.13100938f, -0.00585431f, -0.15688403f, 
    0.10864102f, 0.03550862f, -0.00189171f, 0.24807225f, -0.17215063f, 0.17006688f, -0.10038276f, 0.05728349f, 
    -0.32436773f, 0.07327972f, -0.01517043f, 0.10968761f, 0.14717026f, 0.04558619f, 0.02770712f, -0.02086060f, 
    -0.25757936f, -0.06436279f, -0.05543806f, -0.55959606f, -0.16328044f, 0.02917908f, 0.05779350f, -0.09622645f, 
    0.10669309f, 0.02809331f, 0.07675170f, 0.00875812f, -0.28252831f, -0.01068608f, 0.15563379f, 0.12476227f, 
    0.13842693f, -0.29365531f, 0.16520013f, 0.10897890f, 0.00876386f, -0.02590925f, 0.00693570f, -0.00053087f, 
    -0.07538787f, -0.12681715f, -0.08786085f, -0.03549661f, -0.03321793f, -0.01894161f, 0.01575477f, -0.33944964f, 
    0.03750732f, -0.22693898f, -0.08464818f, 0.08006241f, -0.28457737f, -0.14713381f, -0.08898420f, 0.25634700f, 
    0.04053631f, 0.19179979f, 0.01873475f, 0.00920359f, 0.13379143f, 0.07656953f, -0.04994863f, 0.01128291f, 
    0.09274597f, -0.16484460f, -0.09476534f, 0.12808825f, 0.15325619f, 0.05528796f, 0.05623340f, 0.14467080f, 
    0.00034029f, -0.08703709f, -0.12592380f, -0.19718269f, -0.19630013f, 0.13516805f, -0.46655056f, 0.21845932f, 
    -0.13555025f, -0.01410720f, -0.00929474f, -0.15321380f, 0.04252257f, 0.04876750f, -0.02752567f, 0.06380343f, 
    0.40626642f, -0.51351267f, -0.34522033f, 0.03549781f, 0.10076122f, 0.05900807f, 0.14845061f, 0.09438043f, 
    -0.10106578f, -0.00385110f, -0.02116743f, -0.07181644f, 0.03500871f, 0.10299874f, 0.19470143f, -0.11544075f, 
    0.00991094f, 0.08081938f, -0.05247147f, 0.09918717f, 0.01393163f, -0.05044486f, -0.08119124f, -0.07928180f, 
    0.04841355f, 0.61367279f, -0.48450020f, -0.14154211f, -0.09832983f, 0.00614435f, 0.19000997f, -0.12487454f, 
    0.06693269f, -0.00403658f, -0.11020048f, 0.17836659f, -0.01749935f, 0.02074954f, 0.41537273f, -0.35836130f, 
    0.19868156f, -0.10654199f, -0.02616177f, 0.00565191f, 0.04967787f, 0.00901777f, 0.04519417f, -0.01565245f, 
    0.06854609f, -0.27757877f, -0.02810988f, -0.18750666f, 0.05144965f, 0.00948852f, -0.15052514f, -0.05855254f, 
    -0.02079722f, -0.02584133f, -0.12923224f, -0.09912416f, -0.00513943f, -0.26560590f, -0.15551606f, -0.00677687f, 
    0.11634529f, 0.06823138f, 0.02288734f, -0.05809468f, 0.05634977f, -0.12256177f, -0.07386982f, -0.05452497f, 
    0.23081756f, -0.04136042f, -0.34541994f, -0.00090037f, -0.08342592f, -0.05261388f, -0.03803919f, -0.03174014f, 
    -0.00053327f, -0.02691366f, -0.08778720f, -0.00547093f, -0.05099465f, -0.00057362f, -0.12223361f, 0.03716062f, 
    0.01233639f, 0.04935360f, 0.02967724f, -0.05296489f, 0.02256922f, -0.02973239f, 0.08009768f, 0.05565652f, 
    -0.06732714f, -0.15782297f, 0.02001640f, 0.05040930f, 0.12642884f, -0.02025727f, 0.14245267f, 0.04389107f, 
    -0.06661593f, 0.02455626f, -0.04825535f, -0.03534251f, -0.07443113f, -0.22319303f, 0.25280130f, 0.13393593f, 
    -0.03731383f, 0.14708485f, -0.04286595f, -0.03798743f, -0.01692973f, 0.02037847f, 0.09788273f, -0.08877230f, 
    -0.04049684f, -0.15709876f, -0.06694024f, 0.18898675f, 0.03406373f, 0.07653429f, 0.03640805f, 0.01104572f, 
    -0.10117023f, 0.16819604f, 0.15137862f, 0.07849131f, -0.06851912f, -0.20735079f, -0.05271652f, -0.04411561f, 
    0.11022836f, 0.06330214f, 0.02732118f, 0.07276077f, 0.02608484f, -0.04682181f, 0.01206847f, -0.09767064f, 
    0.36190546f, 0.05222610f, 0.34844828f, -0.23909934f, -0.02939889f, -0.15729181f, -0.00905087f, 0.00587758f, 
    -0.04703461f, 0.13287242f, -0.10772894f, -0.19212765f, -0.25641769f, 0.23561731f, -0.28265879f, 0.14285995f, 
    0.00954317f, -0.18153696f, 0.03563524f, 0.11843162f, 0.17289841f, 0.04238214f, -0.01789080f, 0.05831365f, 
    0.08134510f, -0.25131258f, 0.40575564f, 0.09423970f, 0.04545285f, -0.09331281f, 0.04311448f, -0.16360088f, 
    0.13204554f, 0.06192027f, -0.14931968f, 0.08831572f, -0.30708930f, 0.31930739f, 0.10003243f, 0.00144601f, 
    -0.06990910f, -0.06764675f, 0.11632853f, -0.13969439f, 0.09957805f, 0.11349707f, 0.05492893f, -0.02181029f, 
    -0.15460150f, 0.06860506f, -0.13265766f, -0.11919470f, -0.04457229f, -0.02662619f, -0.08950815f, 0.00922934f, 
    0.05198194f, 0.11683039f, 0.03517527f, -0.09263998f, -0.15044853f, 0.07673667f, -0.34619117f, -0.70287931f, 
    0.02465767f, 0.03246448f, 0.09005944f, -0.06854454f, -0.02548139f, 0.02926959f, 0.08709882f, -0.07043536f, 
    0.01474389f, -0.33460322f, -0.23054864f, 0.13239658f, -0.04472768f, 0.14763127f, 0.15179992f, 0.13933182f, 
    0.02128601f, -0.10901794f, 0.00859377f, -0.05953997f, 0.11931528f, 0.06806032f, -0.02555564f, 0.13778345f, 
    0.01379076f, -0.07889684f, 0.04707411f, -0.03839422f, 0.02452645f, -0.17374776f, 0.04220967f, -0.17725892f, 
    0.23449054f, 0.09079584f, 0.03366875f, -0.13919458f, -0.00508015f, -0.16311829f, 0.06484248f, -0.04951079f, 
    0.10964745f, 0.14243895f, -0.08262746f, -0.00253074f, -0.57288909f, -0.24152027f, 0.14448032f, 0.14322208f, 
    0.12416269f, -0.13742931f, -0.00343776f, 0.12178909f, 0.04116507f, 0.04239798f, 0.00747556f, -0.00902446f, 
    -0.04853305f, 0.08198605f, 0.27729174f, -0.14985219f, 0.13689950f, -0.20827697f, 0.00263631f, 0.08857463f, 
    0.06631590f, 0.04036760f, -0.02220090f, -0.04178143f, 0.10313073f, -0.14163710f, -0.02738402f, -0.20887069f, 
    -0.07068031f, 0.09557329f, 0.07318142f, 0.04993480f, 0.02985556f, -0.10265987f, -0.20315881f, -0.05774117f, 
    0.02734801f, 0.43024847f, -0.13841590f, -0.08850615f, -0.01414256f, 0.01577805f, 0.27826625f, 0.02335504f, 
    0.02525096f, 0.04914043f, -0.25603780f, 0.01841909f, -0.37233403f, -0.72375029f, 0.26515964f, -0.00839605f, 
    0.01840984f, 0.06666750f, -0.04931280f, 0.06233164f, -0.13054104f, 0.01935699f, 0.02504207f, 0.03908977f, 
    0.15956402f, 0.03068465f, -0.06519297f, 0.19081530f, -0.02578686f, 0.02727848f, 0.05175116f, 0.00187145f, 
    -0.02399252f, 0.03309821f, 0.08168226f, 0.06724115f, 0.22308780f, -0.20284054f, -0.03268006f, -0.05654068f, 
    0.07386781f, 0.00861534f, -0.03028763f, -0.07341477f, -0.20375983f, 0.14754346f, -0.05916928f, 0.12257927f, 
    0.19014908f, -0.06780294f, 0.22407971f, -0.32995087f, 0.01367639f, 0.02656620f, 0.10325773f, 0.04646642f, 
    -0.02338511f, 0.07399847f, 0.01751068f, -0.02779420f, -0.27915522f, 0.12999368f, -0.26161623f, -0.05417669f, 
    -0.03347284f, -0.05586311f, 0.14761534f, -0.06938192f, 0.04788259f, -0.04441288f, -0.09304055f, 0.05005778f, 
    0.04288653f, -0.02013877f, -0.00951200f, -0.27881968f, 0.02241533f, -0.05172905f, -0.04183390f, 0.12090386f, 
    -0.08849860f, -0.10953321f, -0.01785895f, -0.04755705f, -0.13601580f, 0.02681202f, -0.38126105f, -0.03154247f, 
    0.07500996f, 0.14049281f, 0.14301868f, 0.06234740f, 0.14425117f, 0.03543241f, -0.01996383f, 0.05015090f, 
    -0.31429055f, 0.06218679f, 0.02243113f, 0.02476444f, 0.07448363f, 0.10873234f, -0.13292959f, 0.16457260f, 
    0.13026898f, -0.14389805f, 0.22222979f, 0.19681220f, -0.13824375f, 0.05722061f, -0.03553961f, 0.02652672f, 
    -0.16246878f, -0.03477773f, -0.06773717f, 0.15409419f, -0.00889570f, 0.11234166f, 0.10471481f, 0.11110708f, 
    0.25032473f, 0.06440212f, 0.08979151f, -0.06322455f, -0.04597093f, -0.02149395f, 0.01189026f, 0.18753958f, 
    -0.16035865f, 0.04349617f, 0.02365894f, 0.01603727f, 0.06891639f, -0.23027064f, -0.08995838f, -0.18516329f, 
    -0.13961494f, -0.09137727f, -0.04508510f, 0.00646457f, -0.26443961f, -0.07065364f, -0.22514258f, -0.03731425f, 
    -0.17746614f, -0.03036878f, 0.25334662f, -0.09250749f, -0.09553800f, -0.02771514f, 0.16038461f, 0.15423502f, 
    -0.08674505f, 0.15843789f, 0.13636081f, 0.07388742f, -0.12473233f, 0.19033581f, -0.39881638f, 0.13007423f, 
    -0.14638600f, -0.08742246f, 0.16384232f, 0.11884802f, -0.14435934f, 0.15378112f, -0.20114608f, -0.13462394f, 
    -0.22851953f, 0.28341207f, -0.29097602f, 0.04922848f, 0.10725362f, 0.14603026f, -0.03430448f, 0.02395391f, 
    -0.08122228f, -0.00222204f, 0.17023452f, -0.01409454f, 0.03490383f, -0.08219720f, -0.07384546f, 0.00081035f, 
    0.13189317f, -0.12584940f, -0.21946998f, 0.04951315f, -0.06857665f, -0.02122436f, -0.20072925f, -0.47830355f, 
    -0.17126957f, 0.23034936f, -0.03951314f, 0.45419750f, -0.04235753f, 0.03856057f, 0.09504458f, -0.03111319f, 
    0.07124285f, 0.06610706f, -0.07431226f, 0.05085884f, -0.20725381f, 0.03069796f, 0.13518982f, -0.01031283f, 
    0.10722510f, -0.01122514f, -0.24486561f, 0.06290630f, -0.06949585f, -0.14942519f, 0.05995714f, -0.17742246f, 
    -0.04836952f, -0.31500065f, -0.17407048f, 0.02195656f, -0.06250155f, -0.08153000f, 0.04120445f, -0.05113731f, 
    0.09637674f, 0.06730182f, -0.01066541f, -0.05767220f, -0.17841889f, 0.07622575f, -0.00488799f, -0.32447332f, 
    -0.04188368f, 0.08701253f, -0.05049933f, 0.05886182f, -0.23562065f, -0.14184746f, -0.27972308f, -0.16478360f, 
    0.09458990f, 0.37906444f, 0.09385372f, 0.05236356f, 0.08459502f, 0.05361653f, -0.22317009f, 0.01822860f, 
    -0.05265805f, 0.02239728f, 0.04171434f, -0.13314590f, -0.07114194f, -0.24888836f, 0.12433506f, 0.07597963f, 
    -0.08239918f, 0.05801561f, 0.06079269f, -0.12301175f, 0.05998382f, 0.08236605f, 0.01833484f, 0.03753727f, 
    -0.05734816f, -0.21726070f, 0.15477116f, -0.11664180f, 0.02394509f, 0.18746315f, 0.00953752f, -0.07915736f, 
    0.07061027f, 0.03734105f, 0.03312571f, -0.01636098f, -0.20643935f, 0.13727994f, -0.03502258f, -0.03236354f, 
    -0.02649879f, -0.13054775f, -0.00206639f, -0.06162271f, -0.11542433f, 0.22379018f, 0.12253498f, 0.04024494f, 
    -0.00994955f, 0.33331290f, -0.11546448f, 0.13571961f, -0.06026358f, 0.08370212f, 0.01920844f, 0.14736958f, 
    0.05275222f, 0.21678627f, 0.06209699f, 0.18320604f, -0.02369048f, -0.02343952f, 0.29427138f, 0.01429994f, 
    -0.03371410f, 0.08928056f, -0.02404754f, -0.03945466f, -0.16208744f, -0.16077699f, -0.14205208f, -0.19471927f, 
    -0.15315744f, 0.18932213f, -0.08238281f, -0.18883215f, -0.07973330f, -0.00137767f, -0.05734737f, -0.08648757f, 
    0.05315372f, 0.10620677f, -0.06172587f, -0.00222234f, -0.26257131f, -0.57359642f, -0.04455119f, -0.26372918f, 
    0.05440463f, -0.00738027f, -0.18641528f, -0.05851354f, 0.03212379f, -0.05264950f, -0.10000277f, -0.23196465f, 
    -0.24271870f, 0.06137113f, -0.25979799f, 0.07303686f, 0.11049387f, 0.03365819f, -0.01050066f, 0.01673248f, 
    -0.00842461f, 0.13158853f, -0.04778844f, -0.05314317f, 0.12664290f, -0.00700918f, -0.04598881f, 0.01991454f, 
    -0.28413516f, 0.05631627f, 0.04393541f, 0.10976974f, 0.03790901f, 0.05227634f, -0.06245577f, -0.04812241f, 
    -0.21620242f, 0.27232781f, 0.09543510f, 0.07824136f, 0.01723988f, 0.16653952f, 0.13080496f, 0.10980216f, 
    0.08090273f, 0.11896668f, -0.06545027f, 0.03749061f, 0.13843188f, -0.34861159f, 0.26641071f, 0.37432352f, 
    -0.08585834f, 0.08938834f, -0.13025448f, 0.18198620f, -0.08493878f, -0.12955201f, 0.04089561f, 0.07041099f, 
    -0.10195094f, 0.22023273f, -0.07199204f, -0.04821802f, -0.08048089f, -0.18834542f, -0.05629328f, -0.05224200f, 
    0.23778912f, 0.15171714f, -0.33090556f, -0.19348709f, 0.12218896f, 0.05839238f, -0.53218621f, -0.02265159f, 
    -0.05633552f, -0.10461301f, 0.02736222f, -0.06935494f, 0.00344380f, 0.06389825f, -0.15324222f, -0.04884460f, 
    0.26295102f, -0.51084322f, 0.26650029f, 0.03838588f, -0.02073918f, 0.00414549f, -0.06204345f, -0.00725478f, 
    -0.15337616f, -0.00414069f, -0.04001426f, -0.13672803f, -0.24605171f, 0.13915384f, -0.25180647f, -0.00001807f, 
    -0.11706209f, 0.05467945f, -0.04038011f, 0.06853631f, -0.06521148f, 0.05724683f, 0.00896059f, 0.06979489f, 
    -0.38364682f, 0.26736432f, 0.26169476f, 0.14251442f, -0.00087154f, 0.11239212f, -0.05003357f, 0.20667942f, 
    -0.02155406f, 0.08454926f, 0.14934725f, 0.22377284f, -0.35611978f, -0.47005996f, 0.06497841f, -0.42306274f, 
    -0.13785930f, -0.09751702f, 0.03294887f, -0.07973868f, -0.02393768f, -0.18449777f, -0.10192776f, -0.08552187f, 
    -0.07456685f, -0.12818475f, -0.02861058f, -0.10166641f, -0.04496254f, -0.00194120f, 0.02069638f, -0.05256115f, 
    -0.07295492f, 0.14343350f, 0.12109845f, 0.14634793f, -0.23324801f, 0.34298006f, -0.23111361f, -0.20824182f, 
    0.07566579f, -0.11252890f, 0.11026801f, -0.18868016f, -0.13417254f, -0.00747530f, -0.20018543f, 0.00494906f, 
    -0.14972784f, -0.20125511f, -0.21745023f, 0.06831537f, -0.04869468f, 0.03921285f, -0.22281560f, -0.08286366f, 
    -0.02038148f, 0.05973016f, 0.02062076f, -0.01981946f, 0.14686482f, 0.03500568f, 0.14249162f, 0.04951942f, 
    -0.06204957f, -0.05632782f, 0.04651392f, -0.02758710f, -0.19215310f, 0.03461344f, -0.05811772f, 0.06013592f, 
    0.05700637f, -0.09125053f, -0.23206209f, 0.11920344f, -0.04928482f, -0.35125464f, 0.07537217f, -0.01994673f, 
    -0.13726611f, -0.03345527f, -0.10125239f, -0.01166281f, -0.01243052f, 0.24709815f, 0.18680015f, 0.05162035f, 
    -0.10706101f, 0.01979651f, 0.00871633f, 0.19081458f, 0.06498466f, 0.15013216f, -0.08393477f, -0.17328683f, 
    -0.26936516f, 0.21768449f, -0.03547218f, 0.21515554f, 0.08842233f, -0.15431288f, 0.04165824f, 0.28102753f, 
    -0.22391252f, -0.00499460f, 0.09249610f, -0.04015093f, -0.11727992f, 0.09388916f, 0.17424408f, -0.01852808f, 
    -0.14683843f, 0.01108302f, -0.06773620f, 0.02595782f, -0.03223424f, 0.04414812f, 0.12455076f, 0.07690791f, 
    -0.13079165f, -0.03034287f, -0.06346378f, -0.16695943f, -0.00375211f, 0.30572906f, 0.19921799f, -0.08825997f, 
    -0.13589890f, 0.00731261f, 0.01003558f, 0.16799676f, -0.12499236f, -0.02008332f, -0.04744056f, 0.07226164f, 
    -0.10713655f, -0.12448183f, 0.04551425f, 0.00749045f, -0.13049401f, -0.01276443f, 0.06405365f, 0.09493008f, 
    -0.02722692f, -0.03054431f, 0.00783642f, 0.13400048f, -0.05886855f, 0.01277863f, -0.19192554f, 0.09500247f, 
    0.06348444f, -0.04845595f, 0.12206011f, 0.08296766f, -0.15560107f, -0.04134898f, 0.09962040f, -0.08849235f, 
    -0.04596769f, -0.00054048f, -0.05682362f, 0.01882633f, 0.03616916f, -0.09210606f, -0.05233660f, -0.00158956f, 
    -0.00924786f, 0.24963626f, -0.03296370f, -0.06421515f, 0.05395934f, 0.05099551f, 0.03665749f, 0.03272371f, 
    -0.02043666f, -0.14350668f, -0.12519279f, -0.31819558f, -0.06886912f, 0.01480577f, 0.01803809f, -0.01020341f, 
    -0.08006427f, 0.07088481f, 0.03215458f, 0.03992948f, -0.06992521f, -0.05845724f, 0.13594623f, 0.07246804f, 
    -0.19297251f, 0.25502405f, -0.16748220f, 0.13240869f, -0.21098900f, -0.00518332f, 0.02497124f, -0.07165663f, 
    -0.02051149f, -0.08493480f, 0.13415731f, 0.11979041f, 0.27863300f, -0.10207626f, 0.25383753f, 0.08182444f, 
    -0.10599354f, -0.10040228f, 0.09059413f, 0.07995596f, -0.04460273f, -0.08650603f, -0.20682761f, -0.12906732f, 
    -0.76607639f, 0.27103126f, -0.10071462f, 0.03612072f, -0.06392365f, 0.08646581f, -0.01773821f, -0.00059159f, 
    -0.04621681f, -0.05567670f, 0.06905182f, -0.17485483f, -0.13078749f, -0.00983660f, 0.00132260f, -0.13328907f, 
    -0.06985676f, -0.13909659f, 0.11604759f, 0.09519865f, -0.11067195f, -0.11510484f, 0.09180089f, -0.05677546f, 
    -0.07677790f, 0.00228279f, 0.15556176f, 0.09177012f, -0.05026045f, -0.00095337f, 0.07935800f, 0.05178954f, 
    -0.11143074f, -0.13475005f, -0.13113464f, -0.03052267f, -0.00551440f, 0.08937700f, 0.29787120f, 0.06232962f, 
    -0.23253317f, -0.03057444f, 0.04978662f, 0.13441542f, 0.02887245f, 0.09608185f, -0.03645749f, 0.01342749f, 
    -0.09631030f, -0.01217001f, -0.06399436f, -0.12146896f, -0.00635106f, -0.02496488f, -0.13684119f, 0.12146024f, 
    -0.08166794f, -0.06641345f, -0.03585538f, 0.04334568f, -0.06817374f, 0.34571978f, -0.11906271f, -0.04419814f, 
    -0.00195390f, 0.05976440f, 0.02292256f, -0.06079558f, 0.00036754f, 0.20667562f, 0.16697146f, 0.16963547f, 
    -0.15431051f, -0.01341394f, -0.17842115f, 0.25638872f, 0.07702330f, -0.05645077f, 0.13112400f, -0.01772751f, 
    -0.03355178f, -0.00653678f, 0.02225967f, 0.02363544f, -0.33553553f, 0.07736064f, -0.27959514f, 0.02051089f, 
    0.13323158f, 0.11538020f, -0.20738527f, 0.12082161f, -0.03897360f, 0.05165884f, 0.05391597f, 0.00445019f, 
    -0.19842337f, -0.17208460f, -0.21324503f, 0.18486042f, -0.09071778f, -0.19623962f, -0.04861185f, -0.03301231f, 
    -0.00588169f, 0.00203933f, 0.07474494f, 0.13106446f, -0.00937631f, 0.12825367f, 0.01475966f, 0.03023552f, 
    -0.05725564f, -0.02783017f, 0.13624318f, -0.11785200f, 0.04693419f, 0.09444578f, 0.12849630f, 0.13935752f, 
    -0.11907404f, -0.17632338f, -0.09855263f, -0.18541776f, -0.11588468f, -0.09337405f, 0.16422448f, -0.05396970f, 
    -0.07257046f, 0.09620492f, 0.07636238f, 0.06305397f, -0.55247068f, 0.25578123f, -0.53385615f, 0.21597141f, 
    0.01383351f, -0.04642091f, 0.03289430f, 0.07397746f, -0.00900220f, -0.04670024f, -0.15637513f, 0.03520251f, 
    -0.08005980f, 0.11765394f, -0.24498190f, 0.09389181f, -0.00698341f, 0.11688776f, 0.05554310f, 0.06037007f, 
    0.10234717f, 0.13213728f, -0.10485820f, -0.20792551f, -0.04663466f, 0.25837764f, 0.03931623f, 0.02922879f, 
    0.03203074f, 0.04093555f, 0.09186141f, 0.08163385f, 0.14710650f, 0.01130999f, 0.14815597f, -0.02415342f, 
    -0.11437907f, 0.05938986f, -0.29934776f, 0.26631507f, 0.10177498f, 0.03849823f, -0.01212839f, 0.08423492f, 
    0.06599588f, -0.00102328f, -0.22163852f, -0.17080820f, -0.10812124f, 0.01845719f, 0.12379817f, 0.10224482f, 
    -0.08306374f, 0.00951511f, 0.07223629f, -0.04542771f, 0.00493123f, 0.02105408f, 0.00883928f, 0.02945663f, 
    -0.21514720f, 0.08458829f, 0.28044555f, 0.18016952f, -0.00038512f, -0.12497694f, 0.21784852f, 0.21906249f, 
    -0.28428462f, 0.12183231f, 0.11154219f, 0.15747710f, -0.00788185f, -0.21044888f, 0.09839948f, -0.18349716f, 
    -0.05853830f, -0.17942986f, -0.03133174f, 0.00002262f, -0.10350695f, 0.00142632f, 0.07359079f, -0.04038754f, 
    0.09249224f, 0.10279940f, 0.06640987f, -0.03071969f, 0.10454237f, -0.00123419f, -0.07933798f, 0.13492271f, 
    -0.10774372f, 0.08325924f, 0.10597773f, -0.06642760f, 0.10204373f, -0.34322962f, 0.07547309f, -0.29063803f, 
    -0.03672992f, -0.13161786f, -0.18696350f, -0.15990373f, 0.04961213f, -0.07232004f, -0.09443679f, -0.13201247f, 
    -0.02820685f, -0.17750736f, 0.04575915f, 0.00114197f, -0.01639607f, 0.08282462f, -0.08091789f, -0.14165202f, 
    -0.07653729f, 0.05732466f, -0.09781616f, -0.21383348f, 0.27904660f, 0.08054107f, 0.02000466f, -0.21759072f, 
    -0.00004233f, -0.06943496f, -0.02110444f, 0.09541132f, 0.09762133f, 0.07016116f, 0.04185596f, 0.00686827f, 
    0.22692911f, 0.14367081f, 0.15042530f, -0.07154378f, -0.05651435f, 0.17274140f, -0.02933101f, 0.04555222f, 
    -0.06566677f, -0.07601266f, -0.07722337f, -0.00277150f, 0.06305231f, -0.53639013f, 0.35753354f, 0.32807595f, 
    0.14965080f, -0.02187067f, -0.09375285f, 0.04225558f, 0.06073541f, -0.07463861f, 0.06926336f, 0.19213526f, 
    -0.50236386f, -0.05976843f, -0.15030140f, 0.25219026f, 0.25590670f, 0.00073139f, 0.11538578f, -0.04100666f, 
    -0.07411339f, 0.07103007f, 0.15558496f, 0.04807309f, -0.36392677f, -0.03669735f, -0.23741738f, -0.33678037f, 
    -0.09257908f, -0.16850331f, -0.01183733f, 0.04562803f, -0.11867415f, 0.06298281f, -0.02572249f, -0.08422906f, 
    0.20967397f, 0.15688519f, -0.02442624f, 0.25021666f, -0.09027185f, 0.09414251f, -0.01561477f, 0.00472603f, 
    -0.01044592f, -0.11683820f, 0.09579321f, 0.03569070f, -0.23232287f, 0.18995169f, -0.10218554f, 0.04608207f, 
    -0.17560157f, 0.08037697f, 0.06179300f, 0.04823702f, -0.07387321f, 0.04454480f, -0.12577040f, -0.02527309f, 
    0.10005336f, -0.32680398f, 0.21830472f, 0.07952961f, -0.22728631f, -0.06409353f, -0.12721913f, -0.01316439f, 
    0.00890494f, 0.07486684f, 0.07645234f, 0.09573024f, -0.07610548f, -0.14792462f, -0.17934379f, 0.02669145f, 
    0.11193313f, -0.11955459f, 0.03471835f, -0.01278206f, 0.02483621f, 0.17893836f, 0.19390638f, 0.15408324f, 
    0.19166997f, -0.19335103f, 0.09239474f, 0.06045824f, -0.08495708f, 0.06765231f, -0.04582069f, -0.00423138f, 
    -0.05761120f, 0.02771590f, -0.07938232f, 0.02566368f, 0.01439104f, -0.13653108f, 0.08770428f, 0.06257387f, 
    -0.14077839f, -0.17384884f, 0.04705358f, -0.18561503f, -0.00932099f, 0.02529809f, -0.00093097f, 0.06428649f, 
    0.20507392f, 0.14495505f, 0.21629667f, 0.19609322f, -0.20544215f, 0.00063934f, 0.15372120f, -0.04922833f, 
    -0.01932350f, 0.05827171f, -0.11632690f, 0.06793170f, -0.05752993f, 0.14875481f, -0.17962271f, -0.01328754f, 
    -0.00127335f, -0.01998767f, 0.02002474f, 0.01747892f, 0.03425224f, -0.14261657f, -0.21507953f, -0.06648031f, 
    -0.41217455f, -0.03298630f, -0.27254441f, 0.15406586f, 0.06852709f, -0.01396069f, -0.09275005f, -0.07067879f, 
    -0.07755764f, -0.13195777f, 0.03800310f, -0.16218945f, 0.17299911f, -0.05890255f, -0.10964428f, 0.06147297f, 
    -0.05786822f, 0.19497736f, -0.13374412f, 0.05539724f, 0.05186163f, 0.14045373f, 0.06288754f, 0.07125518f, 
    0.11766730f, -0.08133949f, 0.09220688f, 0.03807433f, 0.00268791f, -0.07208142f, -0.17996565f, -0.00139107f, 
    -0.08284301f, -0.05448787f, -0.00357921f, -0.06360025f, -0.35394722f, 0.04863110f, -0.27555767f, -0.12683628f, 
    0.00175056f, 0.07309716f, 0.08384095f, -0.03335503f, 0.03809933f, 0.18125275f, -0.02489263f, 0.02258868f, 
    -0.10011424f, -0.46570775f, 0.01092952f, 0.09125938f, -0.05847267f, 0.02649532f, 0.04955261f, -0.06959300f, 
    -0.00068276f, -0.05058785f, 0.00848156f, 0.02354542f, 0.48513967f, -0.38659424f, 0.44530797f, -0.22639847f, 
    0.00728894f, -0.05231133f, -0.07196863f, 0.06389450f, -0.14219448f, 0.11144769f, -0.03538007f, 0.04213923f, 
    -0.48386970f, -0.36944145f, 0.21921593f, -0.20695402f, -0.05384378f, 0.04463853f, 0.03277814f, -0.31783777f, 
    0.03386285f, -0.05964237f, -0.01156205f, 0.04902954f, -0.15471886f, -0.13798155f, 0.57436281f, 0.01899187f, 
    -0.01067722f, 0.01614645f, -0.08002599f, -0.00946447f, 0.00634274f, 0.04975264f, 0.07747244f, -0.04880540f, 
    0.33565798f, -0.18704619f, 0.13073468f, 0.20319133f, 0.03232432f, 0.09493188f, 0.13335691f, 0.14736897f, 
    -0.02682260f, 0.18609807f, 0.14063576f, 0.10207426f, 0.01198024f, -0.13638097f, -0.04481703f, -0.01479327f, 
    -0.11013212f, 0.01065926f, 0.20535848f, -0.05985712f, -0.00471691f, 0.08413579f, 0.10608075f, -0.00130032f, 
    0.07242113f, 0.18841903f, -0.23549370f, -0.23918267f, 0.04104651f, -0.00427615f, 0.14217702f, -0.00503653f, 
    -0.03934155f, 0.01462521f, 0.08029117f, -0.05576952f, 0.36588287f, -0.27871948f, 0.16300908f, -0.20045552f, 
    0.09210617f, -0.25883412f, -0.33778670f, -0.02795985f, 0.01392012f, 0.00244152f, 0.00080329f, -0.12660286f, 
    -0.09955992f, -0.02686916f, 0.01532574f, 0.05130175f, 0.11057195f, -0.06442770f, 0.07556309f, -0.12027492f, 
    0.06037807f, 0.11983960f, 0.06838664f, -0.05049652f, 0.11139459f, 0.13628657f, 0.02614557f, -0.17094195f, 
    -0.03949352f, 0.09162363f, -0.00176567f, 0.10554591f, -0.05677776f, 0.06266265f, 0.03124169f, -0.09643053f, 
    0.20557465f, 0.20753907f, 0.13711001f, -0.01730513f, 0.03636575f, 0.07095043f, 0.12205558f, -0.04861875f, 
    -0.12075242f, 0.02853911f, 0.01450097f, -0.12480509f, 0.12502059f, -0.36350536f, 0.12767941f, 0.31204790f, 
    0.12411899f, -0.16966660f, 0.36382490f, 0.01785849f, 0.02976044f, 0.14627200f, 0.07864588f, -0.04318067f, 
    0.54650646f, 0.24727596f, 0.23206112f, -0.24770696f, -0.22739069f, -0.00643812f, -0.20894261f, -0.10981429f, 
    -0.05559424f, 0.00509644f, -0.04345136f, -0.13124253f, -0.11304388f, 0.02394476f, 0.03670934f, -0.03646288f, 
    -0.17918709f, 0.04254251f, 0.02434384f, -0.00987781f, -0.08624954f, -0.02618884f, 0.09186117f, 0.02331281f, 
    0.27160406f, -0.00077343f, 0.51005000f, -0.04905509f, 0.12362962f, -0.03928967f, 0.04066523f, -0.11115962f, 
    -0.00013566f, -0.03895596f, 0.02536402f, 0.07099993f, -0.28190276f, -0.24681164f, 0.09744267f, 0.07383627f, 
    -0.12154689f, 0.19527000f, -0.01156046f, 0.11951926f, -0.12928066f, 0.06827205f, -0.00080999f, -0.06128764f, 
    -0.00717718f, 0.03533671f, -0.01364067f, 0.23292109f, 0.03662144f, -0.01341892f, 0.01022239f, -0.05780677f, 
    -0.02413653f, -0.00941380f, 0.02081306f, -0.00388480f, 0.17102587f, 0.07243550f, 0.11918670f, -0.25247613f, 
    -0.08285671f, -0.00434050f, 0.00859025f, -0.00576757f, -0.00726673f, -0.05464650f, -0.02699401f, -0.06430029f, 
    -0.11427597f, 0.07308772f, 0.18731458f, 0.15324664f, 0.01127758f, -0.27928764f, 0.11076710f, -0.08795232f, 
    0.04183587f, -0.05638242f, -0.02535963f, -0.17920431f, 0.17789753f, -0.06799021f, 0.17541246f, -0.08579364f, 
    0.00508413f, -0.01450543f, -0.01141701f, 0.08036578f, -0.11027210f, -0.07617526f, 0.03501359f, -0.03379439f, 
    -0.06727976f, 0.13072403f, 0.00594749f, -0.13281897f, -0.07411017f, 0.05350157f, -0.11876277f, 0.04058786f, 
    -0.16548854f, -0.00213467f, -0.09159633f, 0.00948870f, -0.19095197f, 0.11835007f, -0.17259817f, 0.02410167f, 
    -0.02583058f, 0.02710475f, 0.00983457f, -0.05683410f, 0.07566635f, 0.00258771f, 0.04961002f, -0.03968821f, 
    -0.32311246f, -0.15571009f, -0.04825685f, 0.06001017f, 0.02875660f, 0.06539892f, -0.02576739f, -0.10725283f, 
    0.03954827f, 0.09051402f, -0.08270819f, 0.13839139f, 0.05518166f, 0.14923370f, -0.00555861f, -0.05406897f, 
    -0.05713831f, 0.02807619f, 0.08442136f, 0.06286872f, -0.12216370f, -0.03459365f, -0.00499806f, -0.11263270f, 
    -0.10518290f, -0.11580330f, 0.00382461f, 0.23567083f, -0.03184876f, 0.09236993f, -0.02407874f, 0.06757398f, 
    -0.19644843f, -0.01056066f, 0.08636533f, -0.20724803f, 0.15145110f, -0.03701244f, 0.31612527f, -0.32368147f, 
    0.03494834f, 0.04360894f, 0.08580105f, 0.11219333f, 0.20756190f, 0.12870771f, 0.25547862f, 0.07191835f, 
    -0.08678688f, -0.05784330f, -0.12548915f, 0.36060733f, 0.14012557f, -0.08879235f, 0.05252220f, 0.02812516f, 
    -0.00912136f, 0.03896648f, -0.02814084f, -0.05556385f, 0.16657516f, -0.18679194f, 0.15828364f, -0.15940745f, 
    -0.04091889f, 0.11545847f, -0.02037947f, 0.07195474f, -0.18628787f, -0.00609023f, 0.13247737f, -0.02755746f, 
    0.13840504f, 0.14571910f, 0.17532679f, -0.16409057f, 0.03872995f, -0.03361295f, 0.09898705f, 0.01054533f, 
    0.12273266f, -0.02610500f, 0.14759837f, -0.04971275f, 0.10250553f, -0.18623255f, 0.19030143f, 0.04293307f, 
    0.14111269f, -0.08484408f, 0.17865142f, -0.04033231f, -0.02629525f, -0.00427809f, -0.11359951f, -0.09163621f, 
    0.01910035f, 0.03622638f, 0.11267567f, 0.27780461f, 0.01805397f, -0.08838738f, -0.03441218f, 0.09693246f, 
    -0.02408555f, -0.03672713f, -0.01546460f, -0.03855340f, -0.08603259f, -0.09785098f, 0.00944831f, -0.00464162f, 
    0.00393515f, -0.02151635f, -0.03732030f, 0.06932056f, -0.06866819f, -0.14231896f, -0.12718609f, -0.14921273f, 
    -0.42430359f, -0.11049312f, -0.23431222f, 0.15373176f, -0.21034841f, -0.01687819f, 0.09788929f, -0.14126793f, 
    -0.07909841f, 0.09260275f, 0.11938365f, 0.01102067f, 0.05767002f, -0.47084641f, 0.07660558f, 0.05760165f, 
    -0.05588751f, 0.02526648f, -0.15500736f, -0.13839251f, -0.02425761f, 0.04335583f, 0.08755133f, -0.07438779f, 
    -0.26306325f, -0.26803067f, -0.22736795f, 0.12374368f, -0.23949374f, -0.16539307f, -0.10259160f, -0.00516287f, 
    -0.00279356f, 0.14729105f, 0.00422895f, -0.03584413f, -0.12000605f, 0.11121732f, -0.08257940f, 0.03893097f, 
    0.00416958f, 0.05062857f, -0.00355423f, -0.12907089f, -0.12953074f, -0.09383254f, -0.02807399f, -0.11418199f, 
    0.27187771f, -0.04565779f, 0.51658612f, 0.03534838f, 0.07188705f, 0.06340211f, 0.09708702f, -0.15382309f, 
    -0.13433976f, 0.01067846f, 0.02454199f, 0.03327852f, -0.55124986f, -0.04675063f, -0.04444093f, 0.22761638f, 
    0.06479367f, 0.02964489f, 0.07715292f, -0.16816099f, -0.00246856f, -0.05181351f, 0.07433814f, 0.12988468f, 
    -0.24037781f, -0.16857983f, 0.05138304f, -0.18413760f, -0.09685800f, -0.08637916f, -0.03367591f, -0.04871833f, 
    -0.04541055f, -0.01094170f, 0.05500670f, 0.18248191f, -0.20636050f, -0.00299071f, 0.02094111f, 0.16026635f, 
    0.02574729f, 0.05942586f, -0.12108858f, 0.00007267f, -0.18524599f, -0.13549744f, -0.15103634f, -0.28166679f, 
    -0.40022007f, -0.08140226f, -0.21301512f, -0.13727042f, -0.00020935f, 0.12553212f, 0.03549323f, -0.10588434f, 
    -0.04045716f, 0.04584282f, 0.18316394f, 0.05889247f, 0.11392018f, 0.00559382f, 0.36459333f, -0.01016996f, 
    -0.09462351f, 0.12119256f, -0.05774030f, 0.03681934f, -0.06117200f, 0.01437434f, -0.09122171f, -0.00840909f, 
    -0.13883397f, 0.01246984f, 0.15737949f, -0.02772005f, -0.04543656f, 0.02975905f, 0.01385792f, -0.02589324f, 
    -0.03248899f, 0.05968644f, -0.06740152f, -0.03084340f, 0.26330498f, 0.10851663f, 0.04963902f, -0.02201542f, 
    0.01701123f, 0.00009666f, -0.02155231f, 0.02438816f, -0.03999875f, 0.01597774f, -0.06729932f, -0.08518930f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13917713f, 0.05411291f, 0.07044137f, -0.03966646f, -0.09425958f, 0.03577311f, 0.04057880f, -0.14071937f, 
    0.08150757f, 0.00956893f, 0.02094363f, -0.06821786f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
