#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.84807020f, 0.32208866f, 0.01349067f, -0.57444912f, -0.46388167f, -0.00135594f, 0.59409779f, -0.41470557f, 
    0.48441166f, 0.02394314f, -0.03770800f, 0.18374142f, -0.32728490f, -0.04144528f, 0.06792026f, 0.04474341f, 
    0.01685536f, -0.01790914f, 0.51509839f, 0.22575706f, 0.27715397f, 0.21430644f, 0.26537171f, 0.43453142f, 
    -0.21991494f, 0.01825945f, -0.97081190f, -0.16040792f, 1.04188776f, 0.86020917f, -0.98529518f, 0.23054036f, 
    0.17891937f, -0.57365137f, 0.44414800f, 0.48483196f, 0.45838237f, -0.00736427f, -0.00843671f, 0.33876327f, 
    -0.13192375f, 0.19153474f, 0.34201467f, -0.01530058f, -0.11791720f, 0.12450249f, 0.03233808f, -0.12334868f, 
    -0.23009276f, -0.07570498f, 0.62697691f, 0.76009363f, 0.17138860f, 0.56917578f, 0.99238753f, 0.38518906f, 
    -0.09867658f, -0.07003792f, 0.44549042f, 0.39299354f, -0.39011464f, -0.12393176f, 0.21239895f, -0.15068309f, 
    0.22360533f, 0.11827417f, 0.29916772f, -0.11057895f, -0.00696682f, 0.27626586f, -0.27482295f, 0.02748609f, 
    0.07405628f, -0.34711716f, -0.20119210f, -0.46424240f, 0.94632840f, 0.22204664f, -0.77065957f, 0.26972693f, 
    -0.77816164f, 0.38025275f, -0.05823024f, 0.16588978f, -0.60637236f, -0.07464613f, -0.18284565f, 0.02854589f, 
    0.21389982f, 0.43316725f, 0.25135595f, -0.20847191f, 0.17924649f, 0.20491582f, 0.17835942f, 0.29132718f, 
    0.30170566f, -0.28812557f, -0.10144082f, 0.32681477f, -0.32913804f, 0.01398251f, -0.69624072f, -0.70881873f, 
    0.32278404f, -0.31658345f, -0.28170490f, 0.44917715f, 0.30173102f, -0.55549216f, -0.36524832f, -0.29195902f, 
    -0.22846153f, -0.10667279f, -0.29767835f, 0.48369578f, -0.24100657f, -0.26203716f, 0.20624669f, -0.16046523f, 
    0.21288894f, 0.05179351f, 0.21492037f, 0.10608479f, 0.37598059f, -0.60546803f, 0.64695507f, -0.08632213f, 
    0.22144867f, 0.42947203f, -0.63318241f, -0.08369371f, -0.58234519f, -0.50292885f, -0.33272785f, -0.07754884f, 
    -0.14061984f, 0.36226925f, 0.23992902f, 0.09202623f, -0.16612861f, 0.31550485f, 0.12930581f, 0.01610809f, 
    0.03362477f, 0.05614576f, -0.29837260f, 0.02015288f, -0.06850978f, 0.31837106f, 0.45862067f, 0.46829903f, 
    0.81322968f, -0.79064322f, -0.87161487f, 0.28992435f, -0.07718115f, 0.49667266f, -0.02483473f, -0.64104581f, 
    0.19183595f, 0.16330612f, -0.19018501f, -0.15230331f, 0.02952216f, -0.10070337f, 0.41645962f, -0.01524398f, 
    0.20620416f, 0.05716866f, 0.23530354f, -0.03708153f, -0.17966084f, -0.31410348f, -0.36129948f, 1.07648087f, 
    0.69072348f, -0.19203633f, -0.12116996f, -0.63772714f, -0.31379840f, 0.05010775f, -0.29118279f, 0.13824314f, 
    0.55356544f, -0.01636503f, 0.02645586f, 0.17432876f, -0.17909884f, -0.13657835f, -0.14938049f, 0.15116180f, 
    0.03819379f, -0.26171267f, 0.12672704f, -0.05580940f, 0.09080248f, 0.30625930f, 0.30983344f, -0.06604514f, 
    -1.28114712f, 0.20362785f, 0.40743938f, -0.09032583f, -0.23712948f, 0.12949127f, 0.44490969f, 0.13591552f, 
    -0.38114026f, -0.12473345f, 0.19068307f, 0.05310771f, -0.05003185f, 0.00048178f, 0.42768586f, 0.14490269f, 
    -0.39992940f, 0.37908834f, -0.42559958f, -0.14867958f, 0.22692156f, 0.39100072f, 0.42039636f, 0.40197673f, 
    -0.54983586f, -0.25051671f, 0.75548434f, -0.03702534f, 0.76519769f, 0.23833489f, 0.87436146f, -0.58126998f, 
    -0.86062610f, -0.23465401f, -0.08068416f, -0.31510964f, -0.17421031f, -0.12613310f, 0.31165969f, -0.41998407f, 
    -0.10042747f, 0.01506556f, 0.17100397f, -0.08885480f, 0.02894605f, 0.04938890f, 0.17469393f, -0.27231351f, 
    -0.28370619f, -0.33840498f, 0.93094373f, 0.58559299f, 0.74068576f, 0.34396547f, -0.13894938f, -0.07662411f, 
    -0.89621049f, -0.12589495f, -0.25264493f, 0.01862984f, 0.61390853f, -0.19134365f, -0.47942945f, 0.15966301f, 
    -0.53462189f, 0.42944372f, 0.08091567f, 0.12074175f, 0.09384973f, 0.30431807f, -0.07506219f, -0.07655341f, 
    0.46992895f, -0.02624737f, 0.06614507f, -0.31227303f, -0.58998245f, -0.76151145f, 0.11529566f, 0.39501804f, 
    -0.51651806f, 1.03349352f, 0.78239840f, 0.49096641f, 0.40724221f, -0.06184605f, -0.14950372f, -0.29582393f, 
    -0.28301221f, -0.38016456f, -0.10416929f, -0.01964803f, 0.12863199f, -0.00271164f, -0.08982074f, 0.27177441f, 
    0.08551101f, 0.00555365f, 0.36187214f, -0.04710583f, -0.67646700f, -0.54222459f, -0.75991923f, -0.35072765f, 
    -0.25498587f, 0.36680123f, 1.07659590f, -0.54010469f, 0.40411484f, 0.42354754f, -0.19568381f, -0.35024732f, 
    0.19057912f, -0.11749433f, 0.25503376f, -0.13334331f, -0.08454399f, 0.03898367f, -0.11591830f, -0.30350503f, 
    0.08165947f, -0.00042038f, -0.05625781f, 0.03678735f, 0.00357015f, -0.12832874f, 0.74494368f, -0.12066082f, 
    -0.77317274f, 0.62402642f, 0.71029830f, -0.81802195f, -0.79062247f, -0.70308584f, -0.42870775f, 0.19410789f, 
    -0.27629811f, 0.01187836f, -0.03226392f, -0.42460650f, -0.11967020f, -0.03477656f, -0.53513747f, -0.28321141f, 
    -0.09436970f, 0.15640026f, 0.06711496f, 0.30495086f, -0.01843062f, -0.30718207f, -1.18426323f, -0.03752047f, 
    -0.02305356f, -0.41025874f, -0.81878573f, 0.58443260f, 0.01462344f, -0.00448265f, 0.54864383f, 0.58594239f, 
    0.35134694f, -0.49172586f, -0.07185280f, 0.48837507f, 0.23938692f, -0.09590851f, -0.07905437f, -0.11247422f, 
    -0.15064068f, -0.14491230f, -0.18310091f, -0.22730884f, -0.09457728f, -0.16887449f, -0.07548581f, 0.39985099f, 
    0.79456395f, 0.83866811f, 0.59458625f, -0.16094030f, -0.57324517f, 0.28308856f, -0.80388147f, -0.47650588f, 
    0.06174952f, 0.10874461f, 0.00456530f, -0.07950864f, 0.11734679f, 0.08840518f, -0.08688440f, -0.40566561f, 
    0.00498528f, -0.06813468f, -0.25946245f, 0.23217286f, 0.43952727f, 0.24007274f, 0.14470716f, -0.03680738f, 
    -0.59756500f, -0.13608387f, 0.95196885f, 0.27604997f, 0.47083390f, 0.49803308f, 0.54030406f, 0.50952268f, 
    0.03158024f, 0.29772055f, -0.24652025f, -0.34400293f, 0.16525076f, -0.25447959f, -0.24135250f, -0.61570555f, 
    -0.12346774f, -0.28273162f, -0.22933823f, -0.20832169f, -0.14668448f, 0.00566692f, -0.15434150f, 0.04857814f, 
    -0.26149952f, -0.28877401f, -0.49045074f, -0.16676930f, 0.05665904f, 0.38443038f, 0.34651941f, 0.70485497f, 
    0.58171505f, 0.45974877f, 0.56440878f, -0.26147932f, 0.05529745f, 0.32958260f, 0.21880716f, 0.03526247f, 
    -0.12095456f, -0.07371642f, -0.06270486f, 0.19678964f, 0.01007308f, 0.34406695f, -0.15305094f, -0.10260341f, 
    -0.17153819f, 0.09610056f, 0.51868492f, 0.55026686f, -0.80290008f, -0.96092665f, -0.66066915f, 0.82430321f, 
    0.10434801f, 0.30935100f, 0.51021522f, -0.13234812f, -0.05768965f, 0.05645209f, -0.23297790f, 0.27285236f, 
    0.04041524f, -0.00339791f, -0.14732732f, 0.13521637f, -0.08848529f, 0.19981638f, -0.04644664f, -0.05344113f, 
    -0.24409924f, -0.15499455f, 0.39143780f, -0.43481728f, -0.25398710f, -0.57685506f, -0.32900956f, 0.38457152f, 
    0.18862008f, 0.26938069f, 0.56897581f, 0.20538284f, 0.46083838f, 0.72380120f, -0.29273799f, 0.12064492f, 
    -0.22078699f, 0.63768029f, 0.37770474f, 0.09282567f, -0.12406026f, 0.38005197f, -0.04587628f, -0.21499558f, 
    -0.25742280f, -0.34726623f, 0.24246135f, 0.17007907f, 0.93269002f, 0.42190808f, 0.08572155f, -0.22263764f, 
    0.52184922f, -0.10354456f, 0.23393907f, 0.30334461f, 0.49764407f, 0.42012742f, -0.36526984f, 0.46030021f, 
    -0.18226841f, -0.48972562f, 0.14089751f, 0.14462693f, -0.03359281f, -0.19370544f, 0.17244251f, -0.15482357f, 
    -0.18673439f, -0.04310974f, 0.03188029f, -0.25419590f, -0.06210468f, 0.56760830f, 0.57856077f, 0.64017010f, 
    1.04229558f, 0.08288978f, -0.35250860f, -0.43193966f, 0.16952009f, -0.45503148f, -0.12873691f, -0.38127983f, 
    0.37130642f, 0.14235702f, 0.54678124f, 0.10202293f, -0.19028249f, -0.16700406f, 0.18112268f, 0.18986008f, 
    0.11654221f, -0.36882731f, 0.08680208f, -0.43763578f, 0.17165138f, -0.08501869f, 0.39858264f, 0.67622215f, 
    0.81853807f, -0.77251607f, 0.10689022f, 0.43248710f, -0.03364867f, 0.61203450f, -0.39093760f, 0.09791740f, 
    0.02995213f, 0.13666368f, 0.06122419f, 0.12040180f, 0.01019252f, 0.08928963f, 0.13554256f, 0.00701555f, 
    0.20264125f, -0.04820119f, -0.05303177f, 0.19926104f, 0.23791862f, -0.18877347f, 0.52584261f, -0.17725098f, 
    -0.76014793f, -0.60953885f, -0.63113111f, -0.50114930f, -0.15658979f, -0.39882565f, -0.40738785f, 0.49049023f, 
    0.59901667f, 0.30291146f, -0.13956210f, 0.12955378f, -0.17617573f, -0.48409349f, 0.16662546f, 0.31166640f, 
    0.39921743f, 0.22299647f, 0.38829517f, -0.14582995f, 0.22186467f, -0.21540953f, 0.29665211f, 0.15746202f, 
    -0.24803582f, 0.42623928f, 0.77651143f, -0.50160348f, -0.66185272f, -0.75458008f, 0.58028626f, -0.34598026f, 
    -0.65988165f, 0.01603060f, -0.15911490f, 0.41550955f, -0.24762549f, 0.01903426f, -0.21429905f, 0.01848133f, 
    -0.05225477f, 0.11447706f, -0.07681372f, -0.26267835f, -0.07323933f, 0.04002947f, -0.20923273f, -0.04477146f, 
    0.14176571f, -0.16265173f, -0.47773385f, 0.31776667f, 0.36972421f, -0.14982049f, -0.48554295f, -1.34269977f, 
    -0.41029751f, -0.09647569f, 0.30766320f, -0.33678469f, 0.32213509f, -0.01691029f, -0.26185945f, -0.20637727f, 
    0.38837227f, -0.00815794f, -0.13616149f, 0.00515755f, -0.17015441f, 0.20204717f, 0.34641421f, 0.42111504f, 
    -0.05559987f, -0.21669899f, 1.08526361f, 0.78713530f, -0.22840546f, -0.12669678f, 0.41649866f, -0.12078278f, 
    0.24376512f, -0.46854901f, 0.69170016f, -0.01498824f, 0.02911330f, 0.10007238f, -0.00997711f, 0.11512103f, 
    -0.11713987f, -0.22268371f, -0.38817459f, -0.03853335f, 0.03245993f, -0.32037574f, 0.28646269f, 0.18385537f, 
    -0.05285198f, 0.09244028f, 0.12243955f, 0.08462979f, -0.51043081f, -0.78478682f, -0.40438822f, -0.32154033f, 
    -0.23104680f, 0.05437668f, -0.15497756f, -0.00271207f, -0.40021878f, -0.43533447f, 0.19572014f, 0.45985559f, 
    0.05985777f, 0.11086059f, -0.07578538f, -0.16321258f, 0.14856870f, 0.15606430f, 0.22996804f, 0.05762614f, 
    0.59187371f, -0.34381363f, -0.04366877f, -0.33638352f, 1.18098378f, 0.19464923f, 0.37041458f, 1.16074145f, 
    0.61952108f, 0.64640623f, 0.24430084f, -0.59025407f, 0.30050382f, -0.12152280f, -0.21522845f, 0.22232065f, 
    -0.21744294f, 0.29098460f, -0.22419998f, 0.16380760f, 0.11463765f, 0.01811049f, 0.24393471f, -0.12122563f, 
    0.23358065f, 0.11146001f, 0.27508691f, -0.14890873f, 0.39852786f, -0.89881873f, -0.49689385f, 0.45849979f, 
    1.04574060f, 0.01787587f, 0.88621807f, 0.41878545f, -0.30608705f, -0.00731271f, -0.14198117f, -0.07256472f, 
    0.08929645f, 0.00736239f, 0.69989753f, 0.40601951f, 0.05646835f, -0.02260411f, -0.47958285f, -0.17848635f, 
    0.41271555f, -0.03734085f, 0.05677578f, 0.21209365f, -0.10672871f, 0.01712904f, -0.64152956f, -0.94047689f, 
    0.77074909f, 0.23259678f, -0.19058828f, -0.05243556f, -0.51692367f, 0.71515465f, 0.09133279f, -0.73416513f, 
    0.23050903f, -0.15885162f, -0.02499391f, 0.59069949f, 0.27943271f, 0.16483703f, 0.25886533f, 0.06069047f, 
    0.11680878f, -0.04406238f, 0.26757455f, 0.06664404f, 0.07620231f, -0.06624032f, -0.12305572f, -0.17734946f, 
    0.07405727f, 0.30553824f, -0.76165855f, -0.18094946f, 0.47826004f, -0.39725217f, 0.22613554f, -0.01342281f, 
    -0.14272264f, 0.14906517f, 0.61083919f, 0.15792511f, 0.21924616f, 0.14844088f, 0.37503013f, 0.62578356f, 
    -0.29763302f, -0.32154837f, 0.06613827f, 0.27468559f, -0.17913917f, -0.02026317f, 0.02848602f, 0.38840908f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20069367f, 0.36174163f, 0.27357078f, 0.32362670f, 0.07188047f, 0.32231903f, 0.05246254f, 0.04667380f, 
    0.16662078f, 0.08433447f, 0.09250692f, 0.21891950f, -0.01899761f, 0.22608237f, -0.12265623f, 0.28268284f, 
    0.20220977f, -0.05432443f, 0.23790687f, 0.17249629f, 0.21732026f, -0.03841692f, 0.09805755f, 0.19872554f, 
    -0.04761267f, 0.34043911f, 0.09695453f, 0.28205675f, 0.23764989f, 0.07742114f, 0.06964482f, 0.18153645f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05860737f, -0.02714027f, 0.01903631f, -0.00465422f, -0.04828896f, -0.00491433f, 0.02964989f, 0.02875956f, 
    -0.03794045f, 0.04431426f, -0.01892461f, 0.03026104f, -0.01901624f, -0.05110192f, -0.05511886f, -0.04988967f, 
    -0.00751677f, -0.00973436f, 0.00828621f, -0.01306714f, 0.03433991f, 0.00114544f, -0.01636978f, 0.02285475f, 
    -0.02555047f, -0.02828268f, 0.00220890f, 0.03807982f, -0.03574033f, 0.02130860f, 0.04614149f, 0.00952494f, 
    -0.05057921f, -0.00938440f, 0.02526016f, -0.02302595f, 0.01377252f, -0.01638316f, -0.04568012f, -0.05683687f, 
    0.03810594f, 0.00989028f, 0.01711035f, 0.04273426f, -0.02119402f, 0.02641653f, 0.01052096f, -0.05294900f, 
    -0.00241684f, 0.01859932f, 0.01125561f, -0.02500807f, -0.01579496f, 0.04106203f, -0.02145306f, -0.03078539f, 
    0.03900996f, -0.01740269f, 0.04705609f, -0.05589774f, 0.01906104f, -0.01929545f, 0.03209262f, 0.00820023f, 
    -0.00245439f, 0.04225536f, -0.05837390f, 0.00484856f, -0.03527894f, 0.01710967f, 0.03303190f, 0.01043166f, 
    -0.02898450f, -0.00600696f, -0.00093903f, 0.02176558f, -0.02683308f, 0.03984756f, 0.03688163f, -0.04540436f, 
    0.00625811f, -0.03734222f, -0.05048233f, 0.03007913f, 0.04478175f, -0.02091374f, 0.02717755f, -0.00109889f, 
    0.02053418f, -0.04908518f, -0.00288556f, -0.01745743f, -0.02251714f, 0.03992672f, -0.04431701f, 0.00617662f, 
    -0.03284700f, 0.01651149f, -0.02498322f, 0.03767270f, -0.01577820f, -0.04136615f, -0.03767360f, -0.04878131f, 
    0.01404766f, -0.01429171f, -0.01755017f, -0.03541185f, -0.00256893f, 0.01124630f, -0.01209424f, 0.03548289f, 
    0.03593957f, -0.04826051f, 0.01718394f, 0.01614203f, -0.03765383f, -0.00198344f, 0.00118560f, 0.03669301f, 
    0.00859940f, 0.03356783f, 0.04603628f, -0.00674915f, -0.03296021f, 0.00273945f, -0.03340073f, 0.03857578f, 
    0.00320376f, -0.04692688f, -0.03910221f, -0.02410257f, -0.02227524f, 0.00007993f, -0.00726044f, -0.03132634f, 
    -0.00047185f, 0.01993390f, 0.02053475f, -0.03648568f, 0.00761624f, 0.03262374f, -0.01242233f, 0.00652825f, 
    -0.02374824f, -0.00036362f, -0.06262644f, -0.02712253f, -0.03037525f, 0.02015370f, -0.01236868f, -0.04977549f, 
    0.00644333f, -0.03197148f, 0.03180602f, -0.03197294f, -0.04091672f, -0.02144568f, -0.01535905f, 0.01230944f, 
    -0.04581542f, -0.03415862f, 0.02784899f, -0.05626541f, -0.00071079f, -0.04354101f, -0.02247935f, 0.00696368f, 
    0.00231881f, -0.02081245f, 0.00911012f, 0.01845208f, 0.00529444f, 0.02139845f, 0.04810175f, -0.03045708f, 
    -0.04089013f, 0.03186155f, 0.02237210f, 0.02745133f, 0.02269221f, -0.02798567f, -0.02970276f, 0.01926047f, 
    -0.00095554f, 0.04486088f, -0.02707430f, -0.02913185f, 0.01819569f, -0.00430014f, 0.01391935f, -0.03575360f, 
    0.03183830f, 0.01180031f, 0.00082223f, 0.03792633f, 0.00839372f, -0.02445801f, 0.04163354f, -0.01068951f, 
    -0.02646799f, -0.00521739f, -0.02897090f, 0.04388001f, 0.03778753f, -0.02149482f, -0.03178583f, 0.04578995f, 
    0.05006178f, 0.01812278f, 0.05363674f, 0.02084439f, -0.00682268f, 0.04391681f, 0.04325084f, 0.02913822f, 
    0.02781437f, -0.04400167f, -0.01793063f, 0.00151422f, -0.02730565f, -0.00856793f, -0.04249702f, 0.00476659f, 
    -0.03789819f, -0.00621476f, 0.02705138f, -0.03168111f, -0.04063668f, -0.04783651f, -0.00539169f, -0.00981189f, 
    0.00970776f, 0.02362261f, -0.02770035f, -0.04740957f, 0.01005134f, -0.02905435f, -0.03456106f, -0.02979243f, 
    0.02851675f, -0.03412005f, -0.04309746f, -0.01719915f, 0.00247414f, 0.03579773f, 0.00118218f, 0.02027198f, 
    0.03655163f, 0.02280614f, 0.01205354f, -0.02555605f, 0.01382932f, 0.01437923f, 0.02341471f, 0.04820970f, 
    -0.00216350f, 0.01210330f, -0.03742649f, -0.04615632f, 0.03337737f, -0.00876662f, 0.02033485f, -0.03311552f, 
    -0.02823952f, 0.05031164f, 0.02959251f, -0.00810825f, 0.01481237f, -0.01726398f, -0.01114217f, 0.04825135f, 
    -0.02138368f, 0.02845714f, -0.04669075f, -0.04031568f, 0.03017816f, -0.05949318f, 0.01467246f, 0.03441037f, 
    -0.03657923f, -0.06193904f, -0.02308532f, -0.03591440f, 0.00363215f, 0.00562293f, -0.05199163f, 0.02371755f, 
    -0.03415766f, 0.00935198f, -0.04860112f, -0.01904995f, 0.03290351f, 0.03036194f, 0.03433036f, -0.00957241f, 
    -0.00760569f, -0.05035349f, -0.00954150f, 0.03207655f, -0.02875227f, 0.00890913f, -0.00541660f, 0.03817841f, 
    0.04271897f, 0.00390115f, -0.04691530f, -0.05326105f, -0.05006306f, -0.02564173f, -0.00430093f, -0.02204099f, 
    0.02798712f, 0.01758245f, -0.01591996f, 0.01974359f, -0.02555926f, -0.02778516f, -0.04647733f, -0.00922991f, 
    -0.02072830f, -0.01046160f, 0.04722546f, 0.03930413f, 0.01982342f, -0.05997351f, -0.03330293f, 0.03551073f, 
    0.02563744f, 0.00769145f, -0.01280685f, -0.01963215f, -0.05040471f, 0.00318980f, 0.02493505f, 0.02313029f, 
    0.03884463f, -0.02718314f, 0.02314098f, -0.02826784f, 0.03007828f, 0.03137612f, -0.02163512f, -0.03259489f, 
    0.03035360f, -0.03740083f, 0.02144751f, 0.04924805f, -0.01003301f, 0.02671531f, -0.04426892f, 0.00573140f, 
    -0.05271624f, 0.03990492f, -0.03962228f, 0.02688010f, -0.01587559f, -0.00371557f, -0.03975670f, 0.01473668f, 
    0.03652958f, -0.03664208f, 0.01995758f, 0.01320494f, 0.01054614f, 0.01766622f, -0.05001213f, 0.00762286f, 
    0.00981073f, 0.02407280f, 0.03147093f, -0.01964153f, -0.02934563f, 0.02602381f, -0.04484222f, -0.03192157f, 
    0.02324508f, -0.02266103f, 0.02982911f, -0.02593108f, -0.01437794f, -0.03527809f, 0.01310744f, -0.04630660f, 
    -0.03048785f, -0.03002938f, 0.00874031f, -0.03985180f, 0.02336523f, -0.05790151f, 0.03725621f, -0.02228488f, 
    -0.03344686f, 0.04052618f, -0.05417908f, 0.04192163f, -0.05664231f, 0.01821880f, -0.01690868f, -0.01746243f, 
    -0.02968942f, -0.04434783f, 0.00414756f, 0.02066822f, -0.00101562f, -0.03424003f, -0.00263078f, 0.04196315f, 
    0.02627708f, 0.02449272f, -0.00759053f, 0.02435814f, -0.04979925f, -0.04675641f, -0.00455204f, -0.04267517f, 
    0.03295124f, 0.00849551f, -0.05181416f, -0.04729724f, -0.02356286f, 0.03983998f, -0.00180627f, 0.03060232f, 
    -0.04455705f, -0.03704456f, -0.00767111f, -0.04167444f, -0.00819502f, 0.01618202f, -0.05612759f, -0.00886102f, 
    0.03768455f, 0.02920182f, -0.00435444f, -0.03497238f, -0.05723630f, -0.05896406f, 0.00071896f, 0.03211849f, 
    -0.01717363f, 0.03229680f, -0.05654269f, 0.03065661f, 0.02768228f, -0.04882484f, 0.01334764f, 0.00388300f, 
    -0.05273356f, -0.00653070f, -0.02946632f, -0.00303512f, -0.02003123f, 0.02081346f, -0.05251918f, 0.00109180f, 
    0.03597579f, -0.01190486f, 0.04011696f, -0.03213811f, -0.02677339f, 0.03216698f, -0.04058300f, 0.01241663f, 
    0.04048010f, -0.01858979f, -0.01911145f, 0.01158979f, -0.02496746f, -0.00674343f, 0.01905566f, 0.04404615f, 
    -0.03304431f, -0.05635264f, 0.03851635f, -0.00999129f, -0.01766132f, -0.01673461f, -0.00612235f, -0.04533955f, 
    -0.01701151f, 0.04235299f, -0.01088081f, 0.01980162f, 0.03113989f, -0.00552789f, -0.02205219f, -0.02389885f, 
    -0.02720929f, 0.03276448f, 0.03723730f, -0.03115687f, 0.01833293f, -0.01084810f, -0.03517051f, 0.00965941f, 
    -0.00674241f, -0.02047385f, 0.02233904f, -0.01455381f, 0.02467520f, -0.03659625f, 0.01119671f, -0.03280643f, 
    -0.01680723f, -0.03896767f, -0.03664578f, 0.02524323f, -0.03137903f, -0.00331384f, 0.03328987f, 0.03737133f, 
    -0.04876820f, -0.03897871f, 0.02159575f, -0.03925630f, 0.04199224f, -0.05279601f, -0.00921535f, 0.00662322f, 
    -0.05314524f, -0.05761733f, 0.03581750f, -0.04148996f, -0.03858898f, -0.05223876f, -0.02532355f, -0.02808155f, 
    -0.02973095f, 0.00355071f, 0.03296407f, 0.02275287f, 0.01353799f, -0.00879993f, 0.03202983f, -0.02848043f, 
    -0.02263057f, 0.04330067f, 0.03209354f, 0.03905128f, -0.00382306f, 0.01150939f, -0.00554394f, -0.05187246f, 
    0.02045062f, 0.00178838f, -0.04598226f, 0.02332643f, 0.02130132f, -0.04324350f, 0.02600629f, 0.01042439f, 
    0.04131270f, 0.01161851f, -0.01956300f, -0.03079608f, 0.03617717f, -0.05004967f, -0.04415901f, 0.02822032f, 
    -0.01010730f, 0.02044248f, 0.03733092f, -0.00087501f, -0.02289195f, -0.03309497f, -0.05259482f, -0.03585600f, 
    0.02261942f, -0.03321892f, -0.05294707f, -0.05742418f, -0.04671840f, -0.01245375f, 0.01206177f, -0.00808472f, 
    -0.03549292f, 0.00740724f, -0.04663643f, -0.02145673f, 0.03552401f, -0.05569343f, -0.05587751f, -0.04401067f, 
    0.02604845f, 0.00838065f, -0.05685727f, 0.00064542f, -0.02649724f, -0.04020694f, -0.02610550f, 0.01915329f, 
    -0.05024837f, 0.00405513f, -0.05657839f, -0.01455854f, 0.02176773f, 0.02282088f, 0.03285237f, -0.05371965f, 
    0.02887850f, -0.00615626f, 0.01547939f, -0.04094581f, -0.03288479f, 0.00211252f, -0.04467114f, -0.02237056f, 
    -0.03912340f, -0.05842812f, 0.03420084f, -0.05294369f, -0.02815740f, 0.00408332f, 0.00600760f, 0.03027507f, 
    -0.00013027f, 0.01386421f, -0.00350369f, 0.03453563f, -0.04165494f, 0.01752906f, -0.00257253f, 0.01072268f, 
    0.01626723f, -0.03248063f, -0.04318076f, -0.03220678f, -0.02987067f, -0.01043080f, -0.02956314f, 0.00016014f, 
    -0.02588957f, -0.03501426f, -0.02741843f, -0.05709391f, 0.03455110f, 0.00984869f, 0.00041081f, -0.04764935f, 
    -0.05027985f, -0.01505473f, -0.02078186f, 0.03053817f, 0.03197603f, 0.02079523f, 0.02743168f, 0.01940231f, 
    -0.02196613f, 0.00600447f, 0.02867182f, -0.05205480f, 0.02755876f, 0.01094085f, 0.03004036f, -0.00547365f, 
    0.03372514f, -0.01332534f, -0.05263956f, -0.03488169f, 0.01793919f, 0.01529458f, -0.00380804f, -0.00588403f, 
    0.03115220f, -0.00363114f, -0.00245602f, -0.01244025f, 0.00505406f, -0.04179445f, -0.01402759f, -0.04454654f, 
    -0.04493887f, 0.02028620f, -0.03387658f, 0.04489339f, 0.02896483f, -0.01591974f, 0.02406505f, -0.03202070f, 
    -0.00757007f, 0.00804683f, 0.00837099f, -0.03689827f, 0.04345353f, -0.02822695f, -0.00789267f, -0.03137755f, 
    0.01955556f, -0.02194249f, 0.00829436f, 0.03322432f, -0.03857383f, -0.02323590f, 0.02029648f, -0.02583095f, 
    0.02872925f, 0.03993699f, 0.00819387f, 0.02786692f, 0.04318547f, -0.01127533f, -0.01014820f, 0.00255610f, 
    0.02271869f, 0.01888855f, 0.01874413f, -0.01343415f, 0.02540781f, -0.02569701f, -0.01233095f, -0.00567051f, 
    0.01859579f, 0.01928401f, 0.02762615f, -0.01948008f, -0.05260072f, 0.00731927f, -0.05645452f, -0.01182028f, 
    -0.00031637f, 0.03831258f, -0.01077387f, -0.01673101f, -0.05308758f, -0.00202043f, -0.00284907f, 0.04152326f, 
    -0.00478745f, 0.02299701f, -0.00960091f, -0.04779090f, 0.03658205f, 0.01565728f, -0.00370137f, 0.01304941f, 
    -0.04963012f, -0.02532225f, -0.01378188f, -0.02593129f, -0.03740948f, -0.01750366f, -0.03260291f, -0.03756319f, 
    -0.02203120f, -0.01771468f, -0.05544000f, 0.02416605f, 0.01532446f, -0.02839939f, -0.04487085f, 0.04216522f, 
    -0.05481290f, -0.03350702f, -0.00623660f, -0.00101636f, -0.03469348f, -0.01349826f, 0.02528636f, -0.03095343f, 
    -0.05904023f, 0.02385947f, 0.01828180f, -0.05678200f, 0.00857448f, -0.01422986f, 0.02756775f, 0.02567789f, 
    -0.01469112f, -0.12370027f, 0.14677623f, 0.09910194f, 0.06924279f, -0.02244721f, 0.08638095f, -0.02347668f, 
    -0.05083247f, 0.02407403f, 0.21459587f, 0.03648505f, 0.15649088f, -0.06094616f, 0.19945058f, -0.16928391f, 
    0.12711270f, -0.01816361f, 0.08288451f, -0.10742788f, 0.08872605f, 0.03665109f, 0.00334692f, -0.02117715f, 
    -0.05576041f, 0.25417891f, 0.08485685f, -0.24825554f, 0.14252977f, 0.16691460f, 0.10467056f, 0.02107288f, 
    -0.04101184f, -0.06238273f, 0.04947590f, -0.03721064f, 0.37476385f, -0.19633538f, -0.07621942f, 0.26129559f, 
    0.22789650f, -0.08686060f, 0.07110655f, -0.17816254f, 0.10055739f, -0.06777222f, 0.02660921f, -0.06236196f, 
    0.24380443f, -0.22154830f, -0.18304566f, 0.47341010f, 0.01225129f, -0.00255339f, 0.04801456f, 0.11417593f, 
    0.03416129f, 0.09305815f, 0.02133837f, 0.15474905f, 0.18604687f, 0.00812391f, 0.13012013f, 0.11643541f, 
    0.07222091f, 0.12023979f, 0.04216031f, 0.16871873f, 0.00429051f, 0.05849834f, -0.10619842f, 0.05629326f, 
    0.08497799f, -0.04754512f, 0.22007345f, 0.06862856f, -0.05687357f, 0.08832562f, 0.15340699f, 0.21590519f, 
    -0.01160682f, 0.08255434f, 0.01287536f, 0.08215351f, -0.38469920f, 0.00154422f, 0.16537388f, 0.10802247f, 
    -0.19364719f, 0.14283808f, 0.04675651f, -0.03512488f, 0.02672383f, -0.08322284f, -0.05203881f, -0.07215630f, 
    0.28020009f, -0.02731207f, -0.01365257f, -0.09681457f, 0.01224266f, 0.02236972f, -0.05879763f, 0.00490384f, 
    -0.01074811f, -0.05411263f, -0.08887641f, 0.02170353f, -0.22045404f, 0.23140454f, 0.17060158f, -0.10540089f, 
    -0.01501165f, 0.28481999f, 0.12647757f, 0.04648373f, -0.20333596f, 0.00382281f, -0.03803035f, 0.11584003f, 
    -0.42153826f, 0.04892071f, 0.20093401f, -0.03731110f, -0.17625366f, 0.17226584f, 0.01674234f, -0.04459534f, 
    0.12429819f, -0.08635522f, -0.01617409f, -0.21168798f, 0.02407701f, -0.24563578f, 0.00906269f, 0.06271937f, 
    0.02075214f, 0.04206146f, -0.04946084f, 0.01158712f, -0.17759220f, 0.05814987f, 0.13558304f, 0.00941856f, 
    -0.55528009f, -0.23516566f, -0.02169203f, 0.16724564f, 0.06920386f, 0.00185103f, -0.03055408f, 0.04127175f, 
    -0.00666723f, -0.01857707f, 0.03123420f, 0.12803665f, -0.25548923f, 0.07250001f, -0.04127343f, 0.25271881f, 
    0.01952812f, 0.10299455f, -0.09666778f, 0.10635411f, -0.11786568f, 0.10569704f, 0.22367492f, 0.15122053f, 
    0.20026739f, 0.08049476f, -0.20395386f, 0.06374459f, 0.08374573f, 0.06860885f, 0.04197406f, 0.01774732f, 
    0.13224746f, 0.00729570f, -0.08754142f, 0.15526327f, -0.43315914f, 0.05834324f, 0.35177043f, -0.06822151f, 
    -0.02313978f, 0.20235738f, -0.09888852f, -0.00906245f, -0.10858946f, 0.06072410f, 0.00094208f, 0.04206078f, 
    0.27777541f, 0.04978699f, -0.01195945f, -0.07160155f, 0.08412909f, 0.01220270f, 0.06991417f, 0.12918893f, 
    0.05987811f, 0.06559954f, 0.03533459f, 0.16253749f, -0.17469285f, 0.00919894f, -0.00383262f, 0.06199677f, 
    -0.05279772f, 0.01486681f, 0.14041755f, -0.19612525f, 0.00215498f, -0.06835164f, 0.05741252f, 0.03883450f, 
    -0.17114311f, 0.17978765f, 0.30307287f, 0.36692750f, -0.02149020f, -0.00660400f, 0.07484601f, 0.03622635f, 
    0.20561455f, 0.02999450f, 0.02492422f, 0.05750748f, -0.12405287f, -0.11955397f, -0.11809822f, 0.13027327f, 
    0.08927409f, -0.19119930f, 0.09655401f, 0.10808926f, 0.08418050f, -0.09630113f, 0.14130872f, -0.07038499f, 
    -0.10453910f, 0.00955239f, 0.09747194f, -0.10793042f, 0.03119674f, 0.05385029f, 0.10469307f, -0.04227035f, 
    0.02315462f, 0.06139825f, 0.06422444f, -0.13181868f, -0.26052397f, 0.11277389f, 0.18407303f, -0.29039517f, 
    0.04630442f, 0.20209850f, 0.07573362f, 0.08833896f, -0.17893805f, 0.05625264f, -0.02638352f, -0.06676048f, 
    -0.01276151f, -0.07184612f, 0.24806280f, 0.02248792f, 0.04218788f, -0.02410917f, 0.06926279f, 0.09938493f, 
    -0.12483603f, 0.08368790f, -0.01407855f, 0.07202892f, -0.13588767f, -0.07174389f, 0.09656710f, 0.25854734f, 
    0.13897461f, 0.06997920f, 0.00459077f, 0.10280838f, -0.16621226f, 0.15381365f, 0.04005882f, -0.01699434f, 
    0.17068747f, -0.39426741f, 0.33124703f, 0.00808904f, 0.16726729f, -0.00380329f, 0.10820252f, 0.11364213f, 
    -0.08151664f, -0.02751479f, 0.02448768f, 0.04451599f, 0.18498987f, -0.03579862f, -0.06866728f, 0.00826333f, 
    -0.10356074f, 0.27054286f, -0.10279035f, -0.05977624f, 0.01395186f, 0.13074136f, 0.08429647f, 0.03050794f, 
    -0.26550159f, 0.09599449f, 0.06082530f, -0.03268860f, -0.02413253f, 0.05713714f, 0.12081590f, -0.07215229f, 
    -0.08325849f, 0.03917242f, 0.06062748f, 0.06935346f, -0.01180436f, -0.05050072f, 0.01757287f, 0.30609471f, 
    0.00825768f, 0.04147413f, 0.13288748f, 0.15115733f, 0.00988513f, 0.07915635f, -0.00144166f, 0.05204102f, 
    -0.26252559f, 0.58186609f, 0.00106720f, -0.43496290f, 0.14119619f, 0.06614850f, 0.08829009f, 0.09182654f, 
    -0.04430965f, -0.04183798f, -0.04026484f, -0.04866821f, 0.05463999f, 0.20999357f, -0.09166954f, -0.32415375f, 
    -0.03185050f, 0.04533861f, -0.01163377f, 0.15363868f, 0.10995039f, -0.01337363f, -0.02039406f, -0.18831389f, 
    0.60173923f, -0.17005743f, -0.15371174f, -0.23535807f, 0.18434381f, 0.00952690f, 0.03027771f, -0.10217582f, 
    -0.07190950f, -0.11998610f, -0.05572333f, -0.03782096f, 0.21191186f, -0.04249880f, -0.15898569f, 0.08716010f, 
    -0.01359041f, 0.05238261f, -0.13426429f, -0.10074931f, -0.08936705f, -0.05281113f, -0.00533423f, -0.00304202f, 
    -0.21863919f, -0.26602173f, -0.15658773f, -0.03022400f, 0.13054216f, 0.04970713f, 0.04814502f, -0.07366913f, 
    0.10136396f, 0.14488685f, -0.02324121f, 0.09932272f, -0.03961449f, -0.15195872f, -0.04637058f, 0.01464474f, 
    -0.09356819f, -0.00916962f, -0.03208393f, 0.18996418f, 0.05533355f, 0.03659762f, 0.12136716f, 0.08017882f, 
    0.08748820f, 0.15723614f, 0.31110448f, -0.08025227f, -0.11268114f, -0.01582158f, 0.08620661f, -0.01698255f, 
    -0.00907034f, 0.12832361f, 0.04679881f, -0.06630705f, 0.07467022f, -0.14309202f, 0.06932586f, -0.10460348f, 
    -0.00140205f, -0.02588887f, -0.00563913f, 0.08733400f, 0.03491688f, 0.10720386f, -0.00374610f, 0.05014525f, 
    0.16174045f, -0.14153671f, 0.11092371f, -0.37071693f, 0.06353962f, 0.19066754f, -0.01328914f, 0.08691511f, 
    0.01484361f, 0.05631319f, -0.03380018f, -0.01783126f, 0.11909089f, -0.09070666f, 0.04177888f, -0.09656691f, 
    0.13406192f, 0.01514920f, 0.02746476f, -0.05490118f, 0.06014697f, -0.08675459f, 0.18111169f, 0.05847069f, 
    0.19214267f, -0.19567476f, -0.16288745f, 0.17806874f, 0.08096074f, -0.21127397f, -0.00351840f, -0.05916191f, 
    0.06316638f, 0.00714188f, 0.05330817f, 0.05424938f, 0.27907062f, 0.17262970f, 0.14602612f, 0.10740995f, 
    -0.06324892f, -0.14453019f, 0.01382018f, -0.05314551f, -0.06073279f, -0.00832186f, 0.08889461f, -0.06930068f, 
    -0.16593540f, -0.19484921f, -0.13052507f, 0.06177823f, 0.16041456f, 0.03724955f, 0.03892583f, 0.02100189f, 
    0.04302290f, -0.08275429f, -0.18323809f, 0.10202072f, -0.28850824f, -0.12890720f, 0.04592567f, -0.20381360f, 
    0.03940843f, 0.11178761f, 0.01135312f, 0.05120304f, -0.01662595f, -0.02239880f, 0.01104517f, -0.09317800f, 
    -0.00645516f, 0.37764376f, 0.30990401f, -0.03483016f, -0.11453556f, -0.05412137f, 0.13353585f, 0.05809544f, 
    0.01240535f, -0.04064580f, -0.04327404f, 0.19094260f, 0.22544679f, -0.13293004f, 0.05377300f, -0.16329674f, 
    0.12596691f, 0.07667653f, -0.12357389f, -0.00645330f, 0.13680725f, -0.02530704f, 0.06786898f, 0.20145003f, 
    -0.05797247f, -0.22026201f, -0.07438544f, -0.25731993f, 0.17162855f, 0.05333656f, 0.03567614f, 0.12644912f, 
    0.02392471f, 0.16374832f, -0.09601299f, -0.01695288f, -0.41827554f, -0.12542398f, 0.11228471f, -0.32996383f, 
    0.07253423f, 0.02098120f, 0.23275886f, -0.09456138f, -0.06332669f, -0.03010959f, 0.00947282f, 0.11000032f, 
    -0.27493155f, -0.02254017f, -0.05663982f, 0.09510411f, 0.08122337f, 0.05480376f, 0.06409386f, -0.11706103f, 
    -0.09861854f, -0.02796060f, -0.00185269f, -0.00896140f, 0.05066225f, 0.13826393f, 0.26895592f, -0.01891057f, 
    -0.11671399f, 0.00740146f, 0.16474055f, 0.12337787f, 0.06660341f, 0.04460792f, -0.03925638f, 0.00174722f, 
    0.14433987f, 0.13985188f, 0.16980505f, 0.28136113f, -0.00315236f, 0.16808477f, 0.02297540f, -0.05678320f, 
    -0.08360513f, 0.00707334f, -0.03610531f, 0.00096337f, 0.04625832f, -0.10549798f, 0.00602285f, -0.14195749f, 
    0.09016544f, 0.01017051f, -0.05271596f, 0.19561994f, 0.08737639f, 0.14345963f, 0.11144881f, 0.12971546f, 
    0.17519487f, -0.24432583f, 0.04937272f, -0.25718218f, 0.06366616f, 0.00005057f, -0.07488930f, 0.04087410f, 
    0.00132548f, 0.10401886f, -0.03916054f, 0.01015665f, -0.07682860f, -0.04136298f, -0.13332270f, -0.15754595f, 
    0.24572912f, 0.21310969f, -0.15072788f, 0.02273189f, 0.07858037f, 0.00458144f, 0.01786961f, 0.16367853f, 
    0.37878922f, 0.03261109f, 0.36343741f, 0.08179937f, 0.05876783f, -0.04773852f, -0.04765702f, 0.03609895f, 
    0.06154825f, -0.08483164f, -0.12091100f, 0.01842076f, 0.14687167f, 0.28752887f, 0.10310619f, -0.09697777f, 
    -0.06425257f, -0.02891190f, -0.02988834f, -0.03332062f, 0.00586429f, 0.05953067f, 0.07493286f, 0.06916104f, 
    0.07633670f, 0.38522989f, 0.09707566f, 0.11428355f, -0.08894900f, 0.00963373f, 0.04294001f, 0.03409093f, 
    -0.03051032f, 0.03554860f, 0.05964410f, 0.02148623f, 0.00142761f, -0.22012337f, -0.05047061f, 0.03650390f, 
    0.24377532f, 0.05994404f, 0.01923932f, 0.06529247f, 0.05273430f, -0.00675603f, 0.07759821f, 0.12921681f, 
    -0.26815954f, -0.14855982f, -0.15964045f, -0.13996011f, -0.00497789f, -0.07072675f, -0.03978842f, -0.03667862f, 
    0.06711570f, -0.10943859f, 0.01228545f, -0.14154665f, -0.16544558f, 0.14910927f, 0.01688847f, 0.12117881f, 
    0.05685456f, -0.13004042f, 0.14769687f, 0.03125820f, -0.03747404f, -0.11686248f, 0.07785266f, -0.02655835f, 
    -0.08628429f, 0.14445144f, 0.20626074f, 0.25567934f, -0.04152825f, -0.05533237f, -0.00241622f, 0.05819183f, 
    0.03325353f, -0.02769518f, -0.18408576f, 0.03369377f, -0.08381726f, -0.17521919f, 0.16656701f, 0.03133031f, 
    0.26683021f, 0.00992307f, 0.03017613f, 0.06492931f, -0.00275925f, 0.05570346f, 0.05822665f, 0.06670039f, 
    0.12663625f, 0.29660231f, 0.20545904f, 0.04022742f, -0.05864153f, 0.01481788f, 0.04260362f, 0.02623349f, 
    0.05199041f, 0.10388582f, 0.00626015f, -0.02991442f, -0.07987425f, 0.20193782f, -0.29461658f, 0.05039834f, 
    -0.09205880f, 0.07970867f, -0.01767056f, -0.10485976f, -0.07308518f, 0.05542369f, 0.15155415f, -0.03264436f, 
    -0.12676308f, 0.16345572f, -0.22593765f, 0.15746094f, 0.24411860f, -0.05677683f, 0.04434593f, 0.08783536f, 
    -0.01493093f, 0.10846194f, -0.08699527f, 0.06957187f, -0.32940626f, 0.03292888f, 0.16981524f, 0.01968714f, 
    -0.00047758f, 0.02515182f, -0.01852121f, -0.06487737f, 0.06264770f, 0.11702021f, 0.06135449f, 0.08339122f, 
    0.04150211f, -0.03088540f, -0.00133447f, -0.00499700f, 0.01907917f, 0.02896680f, 0.01002437f, -0.01155252f, 
    -0.02545356f, 0.00054166f, -0.00149476f, 0.04212886f, -0.01574613f, 0.03651511f, -0.04598058f, -0.04805049f, 
    -0.00556787f, -0.05345924f, 0.01295476f, -0.04362715f, -0.04724992f, 0.00498820f, -0.02399065f, -0.01992644f, 
    -0.03309815f, -0.05046244f, -0.03994254f, -0.03836549f, 0.02866361f, 0.00161346f, -0.01436076f, 0.04077591f, 
    0.00706279f, 0.03230471f, -0.03005848f, -0.05622544f, -0.01447832f, -0.04649813f, 0.03517577f, 0.03628084f, 
    0.00517472f, 0.03834228f, -0.01720092f, -0.05203905f, -0.01059125f, -0.00985463f, -0.05272883f, 0.01364773f, 
    -0.00771001f, -0.00730309f, 0.02764935f, -0.04371733f, 0.00425318f, 0.01922181f, -0.00031629f, -0.01566367f, 
    0.01674145f, -0.04903056f, 0.02339584f, -0.01079239f, 0.02757778f, 0.01123897f, 0.00753406f, 0.04375280f, 
    -0.01924549f, 0.02087066f, -0.01909004f, -0.02550224f, 0.01032358f, -0.03357190f, 0.03162106f, -0.04446297f, 
    0.00341477f, -0.00438433f, 0.01800872f, -0.05312425f, -0.03591795f, 0.00027418f, 0.03784422f, -0.02867402f, 
    -0.05101752f, 0.03780365f, 0.01187711f, -0.01348029f, 0.00296147f, -0.05333558f, 0.00017559f, -0.02810222f, 
    -0.05608658f, -0.03279049f, -0.02083942f, 0.01077890f, 0.02130410f, -0.02598753f, 0.00313282f, -0.01083782f, 
    0.03988535f, 0.03335343f, -0.03219965f, -0.00588846f, 0.00871728f, -0.02432343f, -0.00921201f, -0.04956102f, 
    -0.01327127f, -0.01378379f, 0.00480952f, -0.03975547f, 0.04067427f, -0.01881516f, -0.05174139f, 0.01673214f, 
    -0.03965081f, -0.04704069f, -0.02269875f, -0.05674494f, 0.02636334f, -0.00972939f, 0.04245764f, -0.01416307f, 
    0.03323346f, -0.04947295f, -0.02563850f, -0.04427962f, -0.04328639f, -0.04989950f, 0.04156063f, -0.00775757f, 
    -0.03577718f, -0.04302830f, 0.01256461f, -0.00622620f, -0.04207977f, 0.04257744f, 0.01256286f, 0.03745167f, 
    -0.03313660f, -0.02703338f, -0.00761842f, -0.04897676f, 0.03108120f, -0.00957806f, -0.00583223f, -0.00673138f, 
    -0.01434913f, -0.02809025f, 0.01382190f, 0.03434830f, 0.02529352f, 0.02139980f, 0.01094004f, 0.04468567f, 
    -0.01586125f, 0.03278932f, -0.02360138f, -0.01950746f, 0.01928794f, -0.01564459f, -0.03816686f, -0.05281885f, 
    -0.05061875f, 0.01462209f, -0.04275856f, -0.02167092f, -0.04900419f, 0.02650447f, -0.02835983f, -0.03411831f, 
    0.03915209f, -0.03670777f, 0.03887194f, -0.00993717f, -0.05033614f, 0.04262758f, 0.00689811f, -0.03424535f, 
    0.03084150f, -0.03107133f, -0.01008072f, -0.04105190f, 0.00695448f, 0.04130126f, 0.01285896f, 0.03119626f, 
    0.03178554f, -0.04697512f, -0.04741246f, 0.01079104f, -0.04671948f, -0.04144568f, 0.00351980f, -0.01482263f, 
    0.00247901f, -0.03548293f, -0.01342671f, -0.03344394f, 0.00056632f, -0.05017154f, -0.01741223f, -0.04493242f, 
    0.00236815f, -0.04642461f, -0.05021170f, 0.04168116f, -0.00318594f, 0.02041954f, 0.01304384f, 0.03222992f, 
    -0.04105448f, -0.00356914f, 0.04339677f, 0.02828099f, -0.00867883f, -0.00237410f, -0.03081863f, 0.01599470f, 
    -0.03568057f, 0.01316463f, -0.03248902f, -0.05562485f, -0.04181144f, -0.01238070f, -0.04104570f, -0.01003204f, 
    -0.03311709f, -0.02593763f, -0.01306393f, 0.03547177f, -0.01563788f, 0.01081036f, 0.01275120f, -0.05444152f, 
    -0.03925088f, 0.00615489f, -0.00841073f, -0.04318662f, -0.02069697f, -0.00600858f, 0.03805004f, 0.03793029f, 
    0.03817564f, 0.00942770f, -0.04181049f, 0.04266327f, -0.05591182f, -0.04351230f, -0.00759090f, -0.01759460f, 
    -0.05216867f, -0.00129229f, -0.03734677f, -0.01201938f, -0.00464408f, 0.02510528f, 0.02317307f, -0.05473796f, 
    -0.03026578f, 0.03173520f, -0.00382696f, -0.00314289f, -0.01546506f, -0.03680927f, 0.02797811f, 0.04426283f, 
    -0.05554391f, 0.02461453f, 0.04338042f, -0.05073528f, 0.01427660f, 0.03813938f, 0.04176911f, -0.05078713f, 
    -0.00842214f, -0.04022429f, 0.02322865f, 0.04395158f, 0.02329107f, 0.02478865f, -0.02429702f, 0.03261036f, 
    0.02994560f, -0.02747613f, -0.00739635f, 0.04275449f, 0.03033016f, -0.01569473f, 0.00283082f, -0.03212467f, 
    -0.02604683f, -0.05165014f, -0.05302205f, -0.03303833f, 0.03700869f, -0.00672967f, 0.03441660f, -0.01919663f, 
    -0.04805611f, 0.01509405f, -0.01621786f, 0.00679438f, -0.00887559f, -0.03114481f, 0.00812104f, 0.03069699f, 
    0.02400639f, 0.01179741f, 0.02802333f, -0.03892010f, -0.03234588f, 0.01605403f, -0.00096415f, 0.02897720f, 
    0.01051809f, -0.02198914f, -0.05473138f, 0.01632803f, 0.03682543f, 0.02078263f, -0.00628783f, 0.00812251f, 
    -0.02368709f, -0.03682322f, 0.02951999f, 0.02448757f, 0.02229394f, -0.00845120f, 0.00140999f, -0.04409993f, 
    0.00211413f, -0.00664584f, 0.03115985f, -0.04070304f, -0.03404506f, -0.05359666f, -0.01110921f, 0.02265733f, 
    -0.02255118f, -0.00496620f, 0.00109157f, -0.00464142f, -0.03971796f, -0.05573845f, -0.01430693f, -0.04004132f, 
    -0.01314773f, -0.00183759f, -0.04748876f, 0.00980046f, 0.01340614f, 0.03854234f, -0.03467147f, -0.01463488f, 
    -0.04472951f, -0.04355182f, 0.01037002f, -0.00853220f, -0.01538396f, 0.01210698f, 0.03580247f, -0.01841932f, 
    -0.05457623f, -0.03188827f, -0.03163240f, -0.03697297f, -0.04669632f, -0.05001482f, 0.00915992f, 0.02458544f, 
    -0.00495920f, 0.00911144f, -0.00873569f, -0.04062994f, -0.03474428f, 0.01756090f, -0.01388302f, 0.01207077f, 
    0.02031906f, 0.01179978f, 0.04388762f, 0.00047362f, 0.02365170f, 0.00026574f, -0.04048802f, -0.05125442f, 
    0.01168757f, 0.03416262f, -0.03041610f, -0.01987433f, 0.01840986f, 0.03191088f, -0.00442416f, -0.01746595f, 
    0.01791021f, -0.02196084f, 0.02936026f, 0.03103207f, -0.04569229f, -0.05235530f, -0.06137185f, 0.01462801f, 
    -0.03635510f, -0.02990458f, -0.02272368f, 0.02003542f, -0.04326927f, -0.00151398f, -0.03049514f, 0.01812141f, 
    -0.00551419f, -0.00561855f, -0.05287658f, 0.03603505f, 0.00407389f, -0.05163945f, -0.01059479f, -0.00231400f, 
    0.02957189f, 0.04435837f, -0.00810843f, 0.04100353f, 0.01365911f, -0.00557983f, -0.04199342f, -0.04642599f, 
    0.01817239f, 0.02165545f, -0.04535259f, 0.03505859f, -0.00793562f, -0.00341790f, -0.01075875f, 0.03324585f, 
    -0.05502592f, -0.03092357f, 0.04595354f, -0.02869799f, 0.04120793f, -0.01008221f, 0.04526924f, 0.00757078f, 
    -0.05447575f, 0.04254267f, -0.04023886f, -0.00787984f, -0.01718006f, 0.03002498f, -0.05739364f, 0.01368952f, 
    -0.04918472f, 0.02336605f, 0.01412194f, -0.00123017f, -0.03722050f, -0.02542293f, 0.03461758f, -0.03247958f, 
    -0.01344624f, 0.01033828f, 0.01064115f, 0.02865513f, 0.01963155f, 0.03054973f, 0.01799444f, -0.00036423f, 
    -0.04241091f, -0.01676344f, -0.01428857f, -0.00805334f, -0.05448548f, 0.03385745f, 0.00295812f, 0.03713572f, 
    0.00265061f, -0.05437448f, 0.03066992f, 0.01052315f, -0.03073672f, 0.00737278f, -0.00285427f, 0.00920223f, 
    0.01072308f, -0.00469229f, -0.04281814f, 0.02455082f, 0.01774662f, -0.03581983f, 0.00156947f, 0.01402709f, 
    0.03245081f, -0.00228769f, -0.00723954f, 0.02331726f, 0.01703573f, 0.01581286f, -0.03628950f, -0.01370114f, 
    -0.04084812f, 0.00850043f, -0.03122674f, -0.04678980f, -0.04360292f, -0.04450687f, -0.02654095f, 0.02977113f, 
    0.01877895f, 0.00724213f, -0.02884783f, 0.01804359f, 0.04181716f, -0.05387390f, -0.03965998f, -0.00448012f, 
    -0.04741486f, -0.05387674f, -0.04192558f, -0.05172145f, -0.03166066f, -0.04644672f, 0.03253347f, -0.02011797f, 
    -0.03967852f, -0.03709219f, 0.03232123f, 0.04096002f, 0.00499780f, 0.01646312f, -0.01347725f, 0.00840546f, 
    -0.00463392f, 0.02154628f, -0.04046610f, 0.03258442f, 0.00239614f, -0.01615092f, 0.04772643f, -0.05200887f, 
    0.00581500f, -0.02855707f, 0.02807497f, 0.03423119f, 0.03238676f, -0.04035682f, 0.02782377f, -0.04373849f, 
    -0.01809633f, -0.02232122f, -0.05840260f, -0.04785298f, -0.01740718f, 0.02897661f, -0.00703492f, 0.03864584f, 
    -0.00702253f, -0.00443921f, -0.01426214f, 0.02412453f, -0.05823934f, -0.00399847f, 0.04690240f, -0.02723880f, 
    -0.02911150f, -0.01086606f, -0.01582220f, 0.00697140f, 0.00509419f, -0.04412350f, -0.04545768f, -0.00609573f, 
    0.00178786f, -0.03061759f, 0.03340816f, -0.00461078f, -0.06178569f, -0.00863752f, 0.00278182f, -0.00623087f, 
    0.05603976f, 0.01544578f, 0.02072532f, 0.02224283f, 0.01820796f, 0.01701512f, -0.02863956f, -0.01956165f, 
    0.00231171f, -0.02021186f, 0.02984394f, -0.02451915f, -0.01453347f, -0.04197424f, -0.05731877f, 0.03565949f, 
    0.00758125f, 0.03461641f, 0.04408626f, -0.02129094f, -0.01220949f, -0.01259577f, 0.03050109f, 0.02559131f, 
    -0.02085464f, 0.04721398f, 0.01856362f, -0.01961725f, -0.02732597f, 0.00089965f, -0.03868961f, 0.02689426f, 
    -0.00071839f, -0.03001870f, 0.03498651f, 0.03902315f, -0.04855719f, -0.05063014f, 0.01204222f, 0.01484791f, 
    -0.00464988f, 0.03703134f, -0.01231869f, -0.04496196f, -0.05345454f, 0.00046471f, -0.01722722f, 0.03440351f, 
    -0.05410585f, -0.01543583f, -0.01799413f, 0.00294719f, -0.05503025f, 0.01106826f, -0.04414460f, -0.00800249f, 
    -0.03816713f, -0.02155787f, -0.00442094f, 0.03691497f, -0.04809188f, -0.01214554f, 0.03356049f, -0.02456164f, 
    -0.03015010f, -0.01023963f, 0.01354467f, 0.01958557f, 0.01618340f, -0.06345811f, -0.01574071f, 0.03885745f, 
    0.02056226f, 0.02859734f, -0.03155898f, -0.02235458f, -0.03264673f, -0.01439615f, 0.03868131f, -0.00735738f, 
    -0.01105992f, -0.03463925f, 0.02471975f, -0.01952110f, 0.00803984f, -0.02873784f, -0.00172216f, -0.04189086f, 
    -0.01322386f, 0.04265090f, -0.04153507f, 0.02245988f, -0.02491995f, 0.02263892f, 0.01122001f, 0.01990198f, 
    -0.03787053f, 0.02092450f, 0.05686035f, -0.04005398f, 0.00537513f, 0.03504338f, 0.02645994f, 0.02203178f, 
    0.01618263f, -0.02752948f, -0.04731828f, -0.03899683f, 0.01156064f, 0.01226087f, -0.02644557f, -0.01906339f, 
    -0.03570193f, -0.01826587f, 0.01989195f, -0.05567371f, -0.03386884f, -0.03751438f, 0.03591374f, 0.00111189f, 
    0.03043243f, -0.00959042f, -0.00794460f, -0.03259538f, -0.00248350f, -0.01647159f, -0.00079495f, -0.02300383f, 
    -0.00100904f, -0.04826030f, -0.01161558f, 0.01431263f, -0.03670101f, 0.02233490f, -0.01149982f, 0.04978857f, 
    -0.00124629f, 0.01434268f, 0.00989956f, 0.03218437f, 0.03701635f, -0.02020803f, -0.05309554f, -0.04685049f, 
    0.00721354f, -0.03375342f, -0.05415282f, 0.00226575f, -0.05262814f, 0.00864035f, -0.01945639f, -0.00693267f, 
    -0.03780343f, 0.02161290f, 0.03392427f, -0.02995264f, 0.03816491f, 0.02262892f, 0.03083883f, 0.00252551f, 
    0.03197457f, -0.01976135f, 0.00694341f, 0.03946487f, 0.00589962f, -0.02647640f, -0.01250943f, -0.02800747f, 
    0.00175046f, 0.02582042f, -0.02277250f, 0.03745705f, -0.01940192f, 0.00247584f, -0.01798121f, -0.00124279f, 
    -0.02328230f, -0.05130678f, 0.00215785f, -0.03335473f, 0.00575308f, 0.03012007f, -0.01146842f, 0.02854228f, 
    -0.03845694f, 0.01267761f, 0.01011921f, 0.01320566f, -0.03973426f, 0.04431044f, -0.04914512f, -0.03391955f, 
    0.25626737f, 0.21508797f, 0.02786828f, 0.28327090f, 0.06386502f, -0.06846009f, 0.17528047f, 0.04291236f, 
    0.11207093f, 0.01082346f, -0.05949996f, 0.14911626f, 0.08626228f, 0.04665862f, -0.02746405f, -0.19957720f, 
    0.03581802f, 0.02289730f, -0.04292471f, 0.04471670f, -0.08524948f, 0.01831760f, -0.05885174f, 0.16879185f, 
    0.12719323f, 0.12664916f, 0.04767451f, -0.00667609f, 0.13688794f, -0.06639978f, -0.13415460f, -0.03644335f, 
    -0.02926861f, 0.08683634f, -0.01803500f, 0.07490757f, 0.05137894f, 0.15537049f, 0.13517711f, 0.08661643f, 
    0.08274120f, -0.03278237f, -0.07453463f, -0.00420324f, 0.04177076f, 0.20850106f, 0.22223142f, 0.01143448f, 
    0.21229666f, 0.25794247f, 0.16335706f, 0.11437343f, 0.06038932f, 0.27443871f, 0.07908307f, -0.01980249f, 
    -0.05255890f, -0.03305452f, 0.04787195f, -0.03744568f, -0.03837220f, -0.05914902f, 0.09342294f, 0.26852006f, 
    -0.04102463f, -0.06702341f, -0.02988591f, -0.05077507f, -0.04468790f, -0.07202038f, 0.11990798f, 0.04965637f, 
    0.16817172f, 0.20988154f, -0.14479600f, 0.07586496f, 0.14342308f, -0.00053727f, -0.06143120f, 0.03268265f, 
    -0.12205015f, 0.08707440f, 0.04828664f, -0.02484602f, -0.14298677f, -0.08560411f, -0.17148300f, -0.21884862f, 
    0.00368051f, -0.00419944f, 0.01304377f, -0.03789970f, 0.12622909f, -0.06847193f, -0.00536128f, -0.04744188f, 
    0.01712357f, -0.03851891f, 0.21160932f, 0.03504997f, 0.10067257f, -0.18758927f, 0.21166714f, 0.13633241f, 
    0.02168708f, 0.11212386f, -0.11446833f, -0.11085690f, 0.08356586f, 0.16132858f, 0.18996967f, 0.31227034f, 
    -0.06956898f, -0.11776266f, 0.13412234f, -0.01788065f, 0.01507188f, 0.02172085f, 0.12167699f, -0.06474197f, 
    -0.22624981f, -0.23654616f, -0.37674224f, 0.20593838f, 0.06759870f, 0.03388202f, -0.03272835f, 0.02859706f, 
    -0.02631084f, 0.02556473f, 0.15901540f, 0.20860444f, 0.21407647f, 0.25225681f, 0.14404280f, -0.12006845f, 
    -0.08939311f, 0.01752183f, -0.03312884f, 0.01774546f, 0.03761903f, 0.08144677f, -0.08306778f, -0.19721821f, 
    -0.29542387f, 0.40950325f, 0.05048028f, 0.11953476f, -0.02491910f, 0.14932504f, 0.17140748f, 0.02102981f, 
    -0.06062777f, -0.10192128f, 0.08299735f, -0.19530290f, -0.00862252f, 0.26115900f, 0.17789060f, 0.41271842f, 
    0.00579995f, -0.17128326f, -0.02307838f, 0.02332783f, 0.10961223f, -0.01223834f, -0.08157360f, -0.13476071f, 
    -0.00361350f, -0.08061401f, 0.12182546f, 0.36182451f, 0.07570745f, -0.05131270f, -0.04884932f, -0.20257592f, 
    0.08346723f, -0.03348003f, 0.06116205f, -0.00114298f, -0.08709974f, -0.30035701f, -0.27140883f, 0.26497918f, 
    0.12844887f, -0.11062441f, 0.08814824f, -0.00489499f, -0.04972983f, -0.04621271f, 0.04662606f, -0.04579826f, 
    -0.05862232f, 0.02035340f, 0.14986463f, -0.07309517f, 0.01780037f, -0.18776357f, -0.11951616f, -0.12970217f, 
    -0.00070004f, -0.11888345f, -0.19079162f, -0.27970085f, 0.01245718f, 0.21573208f, 0.08058986f, 0.05695159f, 
    -0.09706011f, 0.15683976f, -0.14480327f, -0.03812207f, -0.02038609f, 0.02417640f, 0.17688414f, -0.18337671f, 
    0.41948637f, 0.38241994f, -0.36807796f, 0.03921869f, -0.01175868f, 0.02530971f, -0.14167440f, -0.22322689f, 
    -0.08472285f, 0.00406071f, -0.07245401f, 0.01246379f, -0.21932167f, 0.20620824f, 0.15702558f, -0.05056618f, 
    -0.02927507f, 0.06630898f, 0.01350919f, -0.34793156f, -0.07686767f, 0.03732284f, -0.10365873f, 0.13819937f, 
    0.14440316f, -0.14450464f, -0.15316066f, -0.14103825f, -0.03983438f, -0.04623631f, -0.10251648f, -0.21967700f, 
    -0.18278392f, -0.06809591f, -0.05520445f, 0.00387422f, 0.23537840f, -0.23351873f, -0.16971813f, 0.09272964f, 
    0.11185304f, 0.07153490f, 0.08944989f, 0.05277298f, -0.23853296f, 0.03149711f, 0.27723998f, -0.01398379f, 
    -0.09692388f, 0.04617622f, 0.02984367f, 0.02386041f, 0.10684101f, -0.09917215f, 0.01589269f, -0.05357281f, 
    0.10240922f, 0.04094874f, -0.01407259f, 0.10344584f, -0.14255409f, 0.35280821f, 0.01563739f, 0.27565649f, 
    0.05196115f, 0.13688697f, -0.11599929f, -0.02211717f, 0.15509218f, -0.09089157f, 0.07929779f, 0.07564485f, 
    0.15880030f, 0.22923812f, -0.00071867f, 0.16803965f, 0.00720554f, 0.01450189f, -0.11993154f, -0.02727159f, 
    0.03038595f, -0.12532124f, -0.14380097f, 0.00803805f, 0.36022383f, -0.00697493f, -0.14331467f, 0.22561058f, 
    0.09462887f, -0.23042136f, 0.07434142f, 0.00876532f, 0.08805072f, -0.02682438f, 0.01171856f, 0.13911262f, 
    -0.08490424f, -0.14497137f, -0.26985458f, -0.13003848f, 0.12546106f, 0.09569682f, -0.01078000f, 0.00378843f, 
    -0.02994839f, -0.05353653f, 0.21465160f, -0.11702866f, 0.15976056f, 0.13445808f, 0.13116233f, -0.00772533f, 
    -0.10715847f, 0.02558136f, -0.17022233f, 0.08936220f, 0.06389415f, 0.01296384f, 0.11534716f, -0.13793963f, 
    -0.06365279f, -0.26633474f, 0.00168171f, 0.34649166f, 0.07216519f, 0.05947717f, 0.06468590f, -0.04717899f, 
    -0.01944476f, 0.00294017f, 0.02947107f, 0.17068833f, -0.30915356f, -0.22175054f, 0.28651381f, 0.06544831f, 
    -0.03399320f, -0.02908996f, 0.11908732f, -0.05232990f, 0.00540084f, 0.14336428f, -0.03763554f, 0.25944170f, 
    -0.17975444f, -0.33373988f, 0.20584947f, 0.08143291f, 0.05287879f, 0.09348383f, -0.03075837f, -0.03891387f, 
    0.02713815f, 0.11061492f, 0.15187332f, 0.03726846f, -0.04721564f, 0.12744707f, 0.04361280f, 0.24240258f, 
    0.10517923f, -0.00239814f, 0.05630905f, -0.06376349f, 0.08041644f, 0.16899422f, -0.06572116f, 0.32022798f, 
    0.51320380f, 0.05460025f, -0.03711514f, -0.19023141f, 0.03182710f, 0.19300979f, 0.02833872f, -0.03026005f, 
    -0.12460193f, -0.16496962f, 0.10484208f, -0.04814838f, 0.69709682f, -0.27010012f, 0.04382446f, 0.42236990f, 
    -0.17410801f, 0.10322960f, 0.09800861f, -0.03336267f, 0.03467081f, 0.05166831f, -0.07840020f, 0.06148589f, 
    -0.08511776f, -0.01990307f, 0.19816229f, 0.29366288f, -0.09558822f, 0.10166594f, 0.00380291f, -0.01053179f, 
    0.08710671f, 0.08774046f, -0.03357694f, -0.06670824f, -0.09758139f, -0.17403209f, -0.14891799f, -0.37661424f, 
    0.04977158f, -0.03935010f, -0.04692783f, -0.00870773f, -0.17716880f, -0.08668840f, -0.21759406f, -0.04027629f, 
    -0.43078887f, -0.08644534f, -0.12010104f, -0.16561924f, -0.10175245f, 0.00716126f, -0.04125128f, 0.02045514f, 
    0.13406001f, 0.05189902f, 0.13683186f, 0.11698127f, -0.08267701f, 0.01869869f, 0.06296012f, -0.13500795f, 
    0.00116859f, -0.12747525f, 0.05944491f, -0.11823414f, 0.05178006f, 0.04961729f, -0.19253483f, -0.13291764f, 
    -0.13620664f, 0.29269123f, -0.22881158f, 0.03431525f, 0.07463659f, -0.05730050f, 0.00542819f, 0.00368585f, 
    0.07171322f, -0.14699472f, -0.00034599f, 0.01337711f, -0.08469238f, 0.14567174f, 0.09254178f, 0.18506566f, 
    0.01619931f, 0.06501447f, 0.07781839f, 0.20088232f, -0.17092970f, 0.06974315f, 0.14475346f, -0.01168779f, 
    0.54897380f, -0.06568866f, 0.02692135f, -0.17022671f, 0.16618659f, 0.06569466f, -0.00471053f, -0.12182772f, 
    0.09108482f, 0.00352305f, 0.10013746f, -0.07459825f, -0.10702959f, -0.01199838f, -0.06990885f, 0.08559086f, 
    -0.02655545f, -0.10820939f, -0.11774483f, -0.05898557f, 0.04963642f, 0.17005008f, -0.10249106f, 0.09494358f, 
    -0.17916590f, 0.30583441f, 0.14393289f, -0.02272427f, -0.10543086f, 0.04935188f, -0.03937594f, 0.13512053f, 
    -0.09517254f, -0.07114200f, -0.09888994f, -0.14449152f, 0.16330606f, 0.11652873f, 0.17017227f, 0.21619868f, 
    -0.05246046f, 0.04524614f, 0.12660103f, 0.03608047f, -0.01248645f, -0.03721895f, 0.08347820f, 0.25721008f, 
    0.40461773f, 0.11626856f, 0.38782263f, -0.11668427f, -0.00798351f, 0.00685718f, -0.08653328f, 0.06029487f, 
    0.01856970f, 0.09115261f, -0.05898054f, 0.26752183f, -0.37603030f, -0.01168511f, 0.08567656f, -0.73785269f, 
    -0.05092587f, 0.00466760f, -0.03045350f, -0.07087091f, 0.09441992f, 0.06777587f, 0.04149703f, -0.07428069f, 
    0.60132593f, 0.13837355f, 0.14842439f, 0.01764008f, -0.08568700f, 0.06983169f, -0.01895245f, 0.05995867f, 
    -0.10060880f, 0.17550927f, 0.06127369f, 0.06070589f, -0.07365413f, 0.18315268f, -0.08042295f, -0.00457274f, 
    0.01806603f, 0.00764007f, 0.05687098f, -0.03440145f, 0.00050823f, 0.03911519f, -0.02132417f, -0.05468016f, 
    0.45591417f, -0.08383211f, 0.07473504f, 0.35794705f, -0.07026365f, 0.01100606f, 0.07764897f, -0.00530828f, 
    0.07918862f, -0.00284070f, 0.14522943f, 0.20432599f, 0.26566651f, -0.20663214f, 0.27387032f, 0.21774484f, 
    -0.02496829f, -0.01483306f, -0.00388224f, 0.02276918f, 0.17732045f, 0.09158514f, -0.08288845f, 0.06773071f, 
    0.17136352f, 0.36618471f, -0.15653725f, -0.06873684f, -0.02110708f, -0.09327908f, 0.17440541f, 0.17688935f, 
    0.00325420f, -0.14688393f, 0.07172815f, 0.04546773f, 0.07217581f, 0.10267049f, 0.04016261f, 0.01602436f, 
    -0.05270051f, 0.10077821f, -0.02682183f, 0.01023749f, 0.15462460f, 0.02489423f, 0.04405792f, -0.06780414f, 
    0.09419417f, 0.09582303f, 0.13176405f, 0.10461759f, -0.04512660f, 0.02374856f, 0.10487335f, 0.20775260f, 
    0.01235017f, 0.09483911f, 0.08912627f, 0.01048923f, 0.07037146f, 0.25809386f, 0.01700764f, 0.12548076f, 
    0.06332386f, 0.00472943f, -0.00885961f, -0.02139247f, 0.14239772f, 0.09691549f, -0.12493847f, 0.02035445f, 
    0.06732256f, 0.29683530f, -0.02346094f, 0.02001157f, 0.09291390f, 0.17372842f, -0.05819660f, 0.02015736f, 
    0.04865107f, 0.03087643f, -0.04179990f, 0.09234232f, -0.31269437f, -0.25185004f, 0.20611235f, -0.18835181f, 
    -0.10628883f, -0.01392152f, 0.07498521f, -0.13304932f, -0.18379071f, 0.00825483f, 0.03803432f, -0.06365271f, 
    -0.08641707f, -0.16454980f, -0.00906289f, -0.17917705f, 0.13016798f, 0.21047628f, 0.14712083f, 0.04624277f, 
    -0.01535203f, 0.14587767f, 0.06271937f, 0.12726654f, -0.43967748f, -0.29584447f, 0.07909401f, -0.04064619f, 
    -0.07010442f, 0.06216738f, -0.08434120f, 0.00212047f, -0.01508082f, 0.10578517f, -0.06827418f, 0.03929031f, 
    0.04649473f, 0.39392281f, 0.11858270f, -0.17041284f, 0.13830808f, 0.09037883f, 0.03464548f, 0.13330433f, 
    -0.04102000f, 0.06364254f, 0.08790067f, 0.11220609f, -0.41477415f, 0.01485834f, 0.00966402f, -0.17473014f, 
    0.07935085f, 0.04056602f, 0.21643540f, 0.17454816f, -0.06601465f, -0.25831896f, -0.12779589f, 0.06362707f, 
    0.23318429f, 0.13569941f, 0.03506948f, 0.28935009f, -0.10782082f, -0.01116644f, -0.10220827f, 0.09512546f, 
    -0.05699219f, 0.07610650f, 0.09301155f, -0.07999330f, 0.40675363f, -0.21962471f, -0.13601954f, 0.14010677f, 
    0.07744366f, 0.01233861f, -0.13984489f, 0.05752102f, 0.14915937f, 0.02135336f, 0.07537178f, -0.25091386f, 
    -0.06374647f, -0.10008188f, -0.00304266f, 0.25925690f, -0.00881141f, 0.01088975f, 0.13789992f, 0.04209657f, 
    0.12816541f, 0.07137439f, -0.06527273f, -0.02766764f, 0.14513384f, 0.23704097f, 0.15865152f, 0.04578974f, 
    -0.02870846f, 0.03620613f, 0.11984861f, 0.10244008f, -0.02974613f, -0.02912888f, 0.06020901f, -0.03290853f, 
    -0.17904922f, 0.00531668f, -0.30222371f, 0.11905719f, -0.08392353f, -0.15330230f, 0.04297882f, -0.06838459f, 
    0.22059594f, 0.13180561f, -0.12297481f, 0.11742616f, -0.07590723f, 0.04192954f, 0.05255973f, 0.12578861f, 
    -0.07074446f, -0.04539175f, -0.16204189f, 0.24387433f, 0.03223768f, 0.08661272f, 0.04453285f, 0.07483637f, 
    -0.10840549f, -0.02008839f, -0.02206296f, 0.04435264f, 0.03551960f, -0.07234680f, -0.05404509f, -0.05616906f, 
    -0.01708603f, 0.02722903f, 0.07379077f, -0.07720612f, -0.18744852f, 0.04775773f, -0.01415126f, -0.13534069f, 
    0.09322099f, 0.13930033f, -0.07512917f, 0.11034410f, 0.08514328f, 0.20055529f, 0.07410590f, 0.17028822f, 
    0.03857224f, -0.24123421f, -0.03375785f, -0.45371732f, 0.00794070f, 0.05784301f, -0.02652309f, -0.05461806f, 
    0.02561325f, -0.06204167f, -0.13027546f, -0.01789880f, 0.04586500f, 0.14694306f, -0.10709590f, -0.05408305f, 
    0.12893030f, 0.17007017f, -0.20417631f, 0.00934939f, 0.10250665f, 0.20189218f, 0.16516843f, -0.10451046f, 
    0.21796250f, -0.12087151f, -0.05232646f, -0.12723839f, 0.09324356f, -0.02280931f, 0.01545828f, 0.06187984f, 
    0.07790984f, -0.08367036f, -0.00994807f, 0.14153957f, -0.09690861f, -0.31383419f, 0.08640406f, 0.22826393f, 
    0.14184800f, 0.04053542f, 0.07085337f, -0.13133474f, 0.06982930f, 0.03210174f, -0.05056114f, 0.12181328f, 
    -0.16552803f, 0.04849098f, -0.12701727f, -0.14140688f, -0.02290762f, -0.05130944f, 0.19673318f, -0.08268695f, 
    -0.06764313f, 0.05779513f, -0.07873152f, 0.26715297f, -0.06328207f, -0.21507154f, -0.18463084f, -0.01942499f, 
    -0.00437567f, -0.01221895f, -0.20791918f, 0.21885383f, 0.13436103f, -0.15759036f, 0.19747432f, -0.20928919f, 
    -0.43902043f, 0.12403521f, 0.11300629f, 0.15528481f, 0.21327174f, 0.12051328f, 0.09853350f, -0.07065323f, 
    0.01611683f, 0.07737395f, 0.08130305f, 0.23277378f, 0.42100134f, -0.42684373f, 0.00582022f, 0.03402304f, 
    -0.02751021f, -0.04988868f, 0.07585212f, -0.03796243f, 0.14294697f, -0.08330492f, -0.06558033f, 0.08957918f, 
    0.08789974f, -0.01347648f, -0.30654532f, -0.05081376f, 0.03586099f, -0.09943205f, 0.02819331f, -0.02497754f, 
    0.01823410f, 0.09346227f, -0.06127356f, -0.16404484f, 0.14925393f, 0.24364811f, -0.21035258f, -0.26490906f, 
    0.20626748f, -0.01711367f, 0.09955457f, 0.15172461f, -0.04280583f, 0.04987343f, -0.04343997f, -0.02973227f, 
    -0.26317602f, -0.01612634f, 0.20291080f, -0.05366776f, -0.06048778f, -0.02337762f, 0.04898454f, 0.01015515f, 
    -0.30964139f, 0.00057729f, 0.01287070f, -0.14004435f, -0.35797468f, -0.12611744f, 0.21310356f, 0.03026243f, 
    0.04788231f, 0.02444077f, 0.09866446f, 0.11163791f, 0.20305032f, 0.00577361f, 0.15761499f, -0.03378602f, 
    0.34788874f, 0.12939110f, -0.01302792f, 0.13870378f, 0.04938075f, -0.01295559f, -0.09777693f, 0.07311406f, 
    0.02330764f, -0.07974993f, -0.07049077f, -0.03924108f, 0.31402370f, -0.10181706f, 0.08457660f, 0.08530832f, 
    -0.12234318f, -0.10294157f, 0.01009309f, 0.01969129f, -0.02044238f, 0.09806702f, 0.04228562f, -0.05267289f, 
    -0.04227089f, -0.13819990f, -0.14428392f, -0.10205747f, -0.06980437f, 0.07495662f, -0.18219464f, 0.22940695f, 
    -0.03452264f, -0.02024709f, 0.06191086f, -0.00569146f, 0.17116714f, 0.01004766f, 0.02086292f, -0.04281880f, 
    -0.04204461f, 0.07276535f, 0.04631989f, 0.00356484f, -0.16151473f, -0.05563789f, 0.05923842f, 0.20934312f, 
    -0.01006123f, -0.03751186f, 0.14171159f, 0.40362328f, 0.01189113f, 0.01651077f, 0.02504650f, -0.10882618f, 
    0.03814431f, -0.03320057f, -0.12797445f, 0.20091739f, -0.31273833f, -0.20994483f, 0.10100911f, 0.10891701f, 
    0.12715034f, -0.13942702f, -0.14442903f, -0.17369281f, 0.15753959f, 0.10802576f, 0.04440359f, -0.03046662f, 
    0.10076308f, 0.33470693f, -0.13259831f, 0.18146947f, 0.03093084f, 0.03529678f, 0.00893048f, -0.00021844f, 
    0.12030258f, 0.09517055f, 0.13072519f, -0.02382201f, -0.02210293f, 0.10577208f, -0.01981924f, 0.08441924f, 
    0.01308275f, -0.01994909f, -0.00817040f, 0.01448074f, 0.15460588f, 0.03998240f, 0.00715874f, 0.19324443f, 
    -0.35955256f, 0.02273518f, -0.37952930f, -0.13353935f, 0.00211903f, -0.01514232f, 0.07499979f, -0.01912849f, 
    0.20463111f, -0.03657039f, 0.04393516f, -0.07685842f, -0.04328685f, 0.22085233f, 0.22224768f, -0.04223403f, 
    0.03622415f, -0.07000802f, 0.25780863f, 0.00360028f, 0.06491393f, -0.02997868f, 0.16906235f, -0.03593591f, 
    -0.13839138f, -0.38523558f, 0.01278952f, 0.48443335f, 0.04042235f, -0.03416773f, -0.06443933f, 0.05035957f, 
    0.01789236f, -0.05415700f, -0.15630539f, 0.07750978f, 0.28652775f, -0.01871122f, 0.01732159f, -0.14432782f, 
    0.03146632f, 0.04295363f, -0.03119768f, 0.04567288f, 0.02381741f, 0.03013960f, 0.09075737f, -0.04402551f, 
    -0.00599837f, -0.15775464f, 0.27844799f, 0.03617257f, -0.00926264f, 0.05156412f, -0.02182273f, -0.03693034f, 
    0.17310587f, 0.07228979f, 0.16250095f, 0.07678512f, 0.14749493f, -0.07225955f, -0.07796978f, -0.01829632f, 
    -0.02362457f, -0.12768143f, -0.01624914f, -0.10755767f, -0.01063243f, -0.00585972f, 0.01207644f, -0.08957381f, 
    -0.30568033f, 0.11537775f, 0.09958969f, -0.05705597f, 0.05965670f, -0.05245951f, -0.10646914f, 0.08586036f, 
    -0.12008556f, 0.14276105f, 0.04787694f, 0.11959489f, 0.14789136f, 0.07464579f, -0.13866331f, -0.03353852f, 
    -0.00925699f, -0.06028816f, 0.07552531f, 0.02522885f, 0.02235211f, 0.07954709f, 0.01405420f, 0.13618854f, 
    -0.07308419f, 0.02160002f, -0.06290081f, -0.02242852f, -0.08090772f, -0.15866253f, 0.01858947f, 0.09874056f, 
    0.14184345f, 0.07778359f, -0.07199321f, -0.00673722f, 0.12262394f, -0.13056397f, 0.10538415f, 0.03766195f, 
    -0.01215343f, 0.14138009f, -0.20799050f, 0.07184680f, -0.10070559f, -0.07348038f, 0.08224521f, 0.08372710f, 
    0.28835824f, -0.18371657f, 0.03825144f, 0.09171169f, 0.13043644f, -0.05364021f, 0.01844111f, -0.14796782f, 
    -0.04574943f, 0.02684154f, -0.05002691f, 0.17278181f, -0.13580556f, 0.28488210f, -0.03427617f, -0.24718091f, 
    0.04351587f, 0.10149986f, -0.00472763f, 0.14398560f, -0.00865158f, 0.29680797f, 0.05748716f, 0.22627057f, 
    0.10532819f, -0.09532160f, -0.04307216f, -0.18277124f, 0.06752941f, 0.19449005f, 0.16094241f, -0.06390987f, 
    0.06233960f, -0.01105764f, -0.11291471f, 0.09313247f, 0.12324046f, 0.09201493f, -0.06481625f, 0.11250443f, 
    0.01722363f, 0.01212649f, -0.00576181f, -0.13781898f, -0.06221692f, -0.06325305f, 0.16695635f, 0.13478388f, 
    -0.32512218f, -0.01515855f, -0.09149253f, -0.02066605f, 0.06424487f, -0.15544260f, 0.01699897f, -0.01493764f, 
    -0.03046477f, 0.06913634f, 0.06634191f, -0.18267995f, 0.19800989f, -0.31139863f, 0.02039653f, -0.22069904f, 
    -0.01155371f, -0.06755501f, 0.15032339f, 0.02109888f, 0.14566824f, -0.04850865f, -0.05656255f, -0.04563553f, 
    -0.30093664f, 0.07575753f, -0.03432753f, -0.04553767f, -0.04864978f, -0.15179557f, -0.04114651f, 0.17980707f, 
    0.19560201f, -0.02558362f, -0.07153746f, -0.00112553f, 0.16926055f, -0.13545854f, 0.06943345f, 0.10426690f, 
    0.12940623f, 0.06221264f, 0.07072361f, 0.01270902f, 0.00634598f, -0.04731620f, 0.05758594f, -0.09058079f, 
    -0.20931417f, -0.05059227f, -0.11882666f, 0.44917619f, 0.04089920f, -0.09328858f, 0.05437833f, 0.07714405f, 
    -0.06541879f, 0.03542384f, 0.06076908f, 0.24667883f, 0.33171123f, 0.17555800f, -0.15463530f, 0.04994083f, 
    -0.04764638f, 0.11332638f, -0.06287661f, 0.00366785f, 0.16300751f, 0.04698110f, -0.08769976f, -0.02799014f, 
    0.13909912f, 0.13319916f, -0.15504487f, -0.04965923f, -0.08037762f, 0.02385195f, 0.15128452f, 0.10002322f, 
    -0.01481576f, -0.10035523f, -0.04117136f, -0.23578905f, 0.11972534f, 0.04333364f, 0.19035272f, -0.00880242f, 
    0.08408554f, -0.17623922f, 0.14025436f, -0.10141487f, 0.12658265f, 0.01342851f, -0.18032072f, -0.09836438f, 
    -0.18934655f, 0.20173843f, 0.04744774f, 0.02946610f, 0.04094722f, -0.00030040f, 0.04115142f, -0.07277707f, 
    -0.04755116f, -0.10337179f, -0.05557209f, -0.11215943f, -0.26481259f, 0.03923592f, -0.04494707f, 0.22111648f, 
    -0.01170686f, 0.06192429f, 0.09602298f, 0.07376965f, 0.07349724f, -0.01573971f, 0.09448116f, -0.03457424f, 
    -0.07508087f, 0.27076223f, 0.09550177f, 0.00439448f, 0.05574602f, -0.07955651f, -0.03438022f, -0.05369215f, 
    -0.00312160f, -0.05498657f, -0.15126467f, -0.22941571f, 0.13670933f, 0.40402779f, -0.12858321f, -0.00500432f, 
    -0.06724922f, 0.04112587f, -0.10001121f, 0.05288745f, 0.04594970f, 0.11285862f, 0.11818963f, -0.05884965f, 
    0.12396325f, -0.17071776f, -0.13090137f, -0.21529698f, -0.01761726f, -0.09681037f, 0.03802270f, -0.07000842f, 
    -0.12223399f, 0.03552619f, -0.02777671f, 0.03987221f, 0.19213919f, 0.30013099f, 0.02040470f, -0.12111805f, 
    0.02265923f, 0.07627282f, -0.12689635f, -0.19717583f, -0.13609561f, 0.00783740f, -0.12429547f, 0.23105451f, 
    0.35772684f, -0.15215313f, 0.14243473f, -0.04562578f, 0.10934638f, -0.04693361f, 0.06244769f, -0.04568874f, 
    0.01640179f, -0.11269114f, -0.02751555f, 0.15358475f, 0.11137916f, -0.07477133f, -0.03350775f, 0.40861180f, 
    -0.03496918f, 0.08186722f, 0.01257776f, -0.01053187f, -0.09563349f, 0.05334637f, 0.16669811f, -0.02395040f, 
    -0.20370655f, 0.00863009f, 0.12102347f, -0.09954505f, 0.05774578f, -0.11870066f, 0.12384176f, -0.00260704f, 
    0.04409119f, -0.01009550f, -0.01551132f, 0.14061913f, -0.13667816f, -0.13069850f, 0.12552704f, 0.03098899f, 
    -0.01376433f, 0.01348688f, 0.06546028f, 0.04376530f, 0.23829870f, -0.11920653f, 0.06129795f, 0.05220390f, 
    -0.43223900f, 0.47287089f, -0.21818939f, -0.09008478f, -0.16009286f, 0.05444490f, -0.13526137f, -0.06387152f, 
    0.09701216f, -0.17360339f, -0.04136808f, -0.16079532f, 0.05191375f, 0.08447699f, 0.00777498f, 0.34380063f, 
    0.06622253f, -0.18870895f, 0.08812829f, -0.00561069f, -0.01142817f, -0.13959979f, 0.07058010f, 0.10858391f, 
    0.30727613f, -0.32280627f, 0.05736142f, 0.07287591f, 0.02785091f, -0.12050877f, 0.07006244f, 0.10060936f, 
    0.01717000f, -0.10764039f, -0.02217908f, -0.06111697f, 0.11385392f, -0.28414285f, -0.05289332f, -0.02479612f, 
    -0.05823464f, -0.02395111f, -0.11430454f, 0.05815863f, 0.00644641f, 0.07332154f, 0.08518811f, 0.04893349f, 
    0.19497015f, -0.38060063f, 0.09688569f, 0.36751863f, 0.03820986f, -0.00052487f, -0.05436331f, -0.02125512f, 
    0.11407325f, 0.12737608f, -0.00480282f, 0.15808591f, -0.02457060f, 0.08673651f, -0.02061321f, 0.00037622f, 
    -0.06758053f, 0.08049047f, 0.06689239f, 0.01461921f, -0.03122281f, 0.15013841f, 0.01992806f, 0.08294585f, 
    -0.30157712f, 0.09942561f, -0.12921244f, 0.20088670f, -0.10610528f, 0.02699808f, -0.04549707f, 0.07798567f, 
    0.02064553f, 0.04290849f, 0.02403449f, 0.04494127f, -0.22864370f, 0.04926517f, 0.17337617f, 0.03862484f, 
    0.21142186f, -0.16274129f, 0.12291423f, -0.04152545f, 0.08135109f, 0.20437901f, -0.01624107f, 0.20545538f, 
    -0.01076250f, 0.01633949f, 0.00068519f, -0.00436440f, -0.02651724f, -0.04772816f, -0.01294921f, 0.00239776f, 
    -0.05354623f, 0.01204369f, 0.00979327f, -0.03324873f, -0.02836317f, -0.02137038f, 0.03968016f, 0.00191347f, 
    -0.05706584f, 0.04165483f, 0.01015133f, -0.03192328f, 0.04257862f, -0.02002312f, -0.04392745f, -0.04540712f, 
    0.02761604f, 0.02706345f, -0.02757276f, -0.03756651f, 0.01243334f, 0.04342884f, 0.01943532f, 0.03770094f, 
    0.00462789f, 0.04607745f, -0.05263583f, 0.03114553f, -0.05146896f, 0.01212457f, 0.02739957f, -0.02585158f, 
    -0.04385231f, -0.00062910f, -0.01103497f, 0.02980969f, -0.05457539f, -0.00546658f, 0.02152162f, -0.00222080f, 
    0.03420613f, -0.04026552f, -0.03653795f, 0.01260056f, -0.05061575f, 0.01337654f, -0.01745918f, -0.03944575f, 
    -0.05370226f, 0.02543202f, 0.02353292f, 0.05015261f, 0.02033948f, -0.03922855f, 0.02581173f, 0.00159010f, 
    -0.00809259f, 0.04351483f, -0.03613501f, 0.01377014f, -0.04822367f, -0.03162164f, -0.04369380f, -0.01795926f, 
    0.02801052f, 0.01010117f, 0.02520247f, -0.03988256f, 0.03655717f, 0.01552213f, -0.00369604f, 0.00858265f, 
    -0.04802584f, 0.02300121f, 0.01136625f, 0.01905052f, 0.04676156f, -0.02539648f, 0.01779198f, 0.00643212f, 
    0.01161676f, 0.02555759f, 0.00024629f, -0.04126307f, 0.00693358f, -0.00923678f, -0.01580327f, 0.02611678f, 
    -0.06111487f, 0.00508778f, -0.03961557f, -0.00232579f, -0.01570703f, 0.01509199f, -0.05279001f, -0.03296528f, 
    -0.05541215f, -0.03922020f, -0.03448583f, -0.00593204f, -0.00576057f, -0.00103253f, 0.02330706f, -0.04353328f, 
    0.02393717f, 0.02906588f, -0.04558984f, 0.03895156f, -0.03610006f, 0.00631339f, -0.04385702f, -0.05203832f, 
    -0.02935602f, 0.02380697f, -0.01392868f, 0.04131440f, 0.03473920f, 0.00773507f, -0.04204587f, 0.01996533f, 
    -0.03524452f, 0.00263020f, 0.01193819f, 0.02239126f, -0.06190801f, 0.03960318f, 0.02879392f, -0.02931479f, 
    -0.03214387f, 0.03678262f, 0.01539397f, -0.01148479f, 0.02844230f, -0.00726993f, -0.00045503f, -0.00916992f, 
    -0.01209598f, 0.04640024f, -0.01612333f, -0.01376401f, 0.04205750f, -0.03478659f, 0.01299164f, 0.01945723f, 
    -0.03274827f, 0.03254497f, -0.00451689f, -0.01340300f, 0.04556364f, 0.01920862f, -0.04959111f, 0.04621704f, 
    -0.02129557f, -0.01870503f, -0.05458726f, 0.03464057f, 0.03967128f, 0.03610622f, 0.04024643f, -0.04758449f, 
    -0.04861034f, 0.03372859f, -0.02651222f, -0.02844503f, 0.01203129f, 0.02271439f, -0.00022754f, 0.01368979f, 
    0.01123387f, -0.03148795f, 0.02698978f, -0.01361710f, 0.03590395f, 0.01722371f, -0.00122756f, 0.01793702f, 
    -0.00291876f, -0.01215107f, -0.04607019f, -0.00938511f, -0.03286193f, -0.03052335f, 0.01640064f, 0.01132786f, 
    -0.05824584f, 0.00448205f, -0.04793855f, -0.03005971f, -0.01879930f, 0.00133928f, -0.02153745f, -0.00039902f, 
    -0.03563182f, -0.02174916f, -0.05051408f, 0.04657009f, -0.00025216f, 0.02884949f, 0.04231423f, -0.01798300f, 
    -0.05900207f, -0.02165330f, 0.04118284f, -0.03239156f, -0.01699689f, -0.03579075f, 0.00208876f, -0.03319525f, 
    0.01862958f, -0.04464381f, 0.03604859f, -0.01101763f, -0.05276229f, -0.00273195f, -0.05023174f, -0.05409171f, 
    -0.04777415f, -0.02718059f, -0.00200092f, 0.02889783f, 0.05351325f, -0.02728509f, -0.01366025f, -0.01347488f, 
    -0.03419472f, -0.00525350f, 0.04579329f, -0.05306320f, -0.04500740f, -0.01069224f, -0.02409127f, -0.05686999f, 
    0.01034740f, 0.03128858f, -0.02049711f, -0.02464134f, -0.02325840f, 0.01525480f, -0.04002974f, -0.02328097f, 
    0.00211864f, -0.02027957f, 0.01012202f, -0.05953786f, -0.02592508f, 0.01052016f, -0.05205202f, 0.01598104f, 
    0.01164808f, -0.04491297f, 0.03841495f, 0.00925044f, -0.00204933f, -0.05733041f, -0.00314380f, -0.02358998f, 
    -0.02928116f, 0.00361698f, -0.03300622f, 0.03191946f, 0.03898288f, 0.01852621f, -0.02555320f, -0.00892478f, 
    0.03817742f, -0.02939066f, -0.05572350f, -0.03817654f, 0.01820707f, -0.00595817f, 0.00162589f, -0.05750547f, 
    -0.01389613f, 0.01434339f, 0.03232849f, 0.01931794f, 0.04212726f, -0.04455388f, 0.00588491f, -0.04912381f, 
    -0.03371579f, 0.00777846f, 0.02418990f, -0.04378404f, -0.01441153f, -0.02034129f, 0.01939481f, -0.03197108f, 
    0.02768095f, 0.01683713f, -0.04989588f, -0.04765015f, -0.02770990f, -0.00273233f, 0.01252977f, 0.02018078f, 
    0.00826306f, 0.03174166f, 0.00514196f, -0.03602829f, -0.02657693f, -0.02647914f, -0.00739083f, -0.04445771f, 
    -0.04183834f, -0.00051299f, -0.03781011f, -0.03443377f, 0.00884234f, 0.03100087f, 0.00162786f, 0.00097804f, 
    -0.05160411f, -0.03845678f, -0.05240152f, 0.03561422f, -0.01557549f, -0.01512670f, 0.00827322f, 0.03030360f, 
    0.00351484f, 0.02651183f, -0.02008108f, 0.04069078f, 0.02222330f, -0.05120724f, 0.01968494f, 0.03743808f, 
    0.02994212f, -0.05720304f, -0.05303172f, -0.00473962f, 0.04283534f, -0.00824970f, 0.04275155f, -0.02248591f, 
    0.01290243f, -0.00510579f, 0.01561347f, -0.04246476f, 0.03644172f, 0.02642797f, 0.02132859f, -0.02700923f, 
    -0.01353757f, -0.01080777f, -0.03161962f, 0.02355198f, 0.03518378f, -0.02959209f, -0.01318969f, 0.00324175f, 
    0.01919674f, -0.03698907f, 0.04598815f, 0.03430847f, -0.00663627f, -0.04927618f, 0.03923122f, 0.03716238f, 
    -0.01581764f, -0.04441467f, -0.01999644f, -0.00911425f, 0.03219340f, 0.03038348f, 0.02201240f, 0.03755489f, 
    0.02396294f, 0.01001948f, -0.01768780f, -0.01681008f, -0.00310383f, -0.04761116f, -0.05628270f, -0.04777510f, 
    -0.17952156f, -0.38650855f, 0.09258877f, 0.15538144f, 0.04677960f, -0.05690908f, 0.12194510f, -0.00018059f, 
    0.10313072f, -0.04790187f, 0.01782589f, 0.11385216f, -0.46213618f, 0.22897330f, -0.09191719f, -0.36694631f, 
    0.22659640f, -0.22527872f, 0.01153296f, 0.08260821f, 0.13766894f, 0.07807305f, 0.03002183f, 0.13487883f, 
    0.19339469f, 0.20738886f, 0.13046166f, -0.09652485f, 0.20128383f, -0.04692174f, -0.02325169f, 0.00727753f, 
    -0.04585295f, 0.12978828f, 0.01363326f, 0.12450881f, 0.20012459f, -0.09562416f, 0.03487880f, 0.21774119f, 
    -0.12443928f, 0.04034542f, -0.09648651f, -0.09345211f, 0.14739466f, 0.09667360f, 0.24692506f, -0.00829814f, 
    -0.04957187f, -0.04092287f, -0.16634417f, 0.08316910f, 0.09721598f, 0.18474047f, -0.06823044f, 0.10184199f, 
    -0.02058596f, -0.02831669f, -0.11663192f, 0.03920311f, -0.05323993f, -0.13127717f, 0.02425165f, -0.11301032f, 
    -0.14165661f, 0.10456618f, 0.00950825f, 0.03151961f, 0.00218811f, -0.03941602f, 0.24431577f, 0.20010155f, 
    0.72665268f, 0.17794243f, 0.12724344f, -0.00049106f, 0.08280367f, 0.05559387f, -0.05119164f, 0.09530433f, 
    -0.00693741f, 0.16872589f, 0.15558800f, 0.04387686f, 0.23063968f, 0.14862362f, 0.01690325f, 0.10067794f, 
    -0.04748953f, -0.02492050f, 0.05020113f, -0.17913623f, 0.17109501f, -0.16323923f, -0.02425752f, 0.04569225f, 
    -0.38649637f, -0.36890510f, 0.13723129f, 0.06753773f, 0.00356992f, -0.05873850f, 0.20071687f, 0.11463074f, 
    0.05643184f, 0.03179343f, -0.16503245f, -0.02418596f, -0.42307714f, -0.04066256f, 0.36656162f, -0.13072820f, 
    -0.01477860f, 0.03468272f, -0.01607176f, 0.13755471f, 0.05296865f, 0.05400802f, -0.01122987f, -0.02155198f, 
    0.29152191f, 0.10910014f, 0.18531495f, 0.08779528f, 0.07638938f, 0.05019926f, 0.02282441f, -0.16713822f, 
    0.13494503f, 0.01695950f, 0.01913056f, 0.11206280f, -0.31493869f, 0.10377124f, -0.01302133f, 0.05029107f, 
    0.00075129f, -0.06136153f, -0.07061407f, 0.04830571f, 0.04910216f, -0.13005145f, -0.06596800f, -0.22789665f, 
    -0.72626376f, -0.34098333f, -0.11211369f, -0.04293783f, 0.11978938f, 0.11549164f, -0.07415956f, -0.04743690f, 
    0.07229076f, -0.05103045f, 0.06363910f, -0.18059799f, -0.32220972f, -0.09740188f, 0.03367918f, 0.30858278f, 
    -0.00455960f, 0.10325328f, 0.02387732f, 0.06473311f, 0.09196535f, 0.02098659f, 0.05026650f, 0.10069417f, 
    -0.36269233f, -0.60939294f, 0.11371613f, -0.08204725f, -0.01238916f, 0.07262362f, -0.00447200f, -0.15546717f, 
    0.19446528f, -0.11854230f, 0.11332665f, -0.01874094f, 0.19938463f, 0.04309467f, 0.19979596f, 0.16363358f, 
    0.03751608f, -0.07995132f, -0.01522357f, 0.11687741f, 0.10372660f, 0.03472993f, 0.02610915f, 0.02027760f, 
    0.09110870f, 0.16819268f, 0.22077903f, 0.03725284f, 0.10990909f, -0.11718774f, 0.04386697f, -0.03423429f, 
    0.04130819f, -0.06850878f, -0.05678093f, -0.16162220f, -0.23615766f, 0.02519238f, 0.08497319f, 0.08019734f, 
    0.09584925f, 0.15040302f, -0.02760896f, -0.04313491f, -0.02874690f, -0.09720230f, 0.22390874f, -0.11532862f, 
    0.01590426f, 0.23862201f, 0.25040323f, 0.05899214f, 0.06368912f, 0.24952345f, -0.19771342f, -0.15979369f, 
    0.10353378f, -0.01608473f, -0.02689112f, 0.11847130f, -0.37025920f, -0.02002046f, 0.01181734f, 0.16561507f, 
    0.13047069f, 0.03487664f, 0.16028267f, -0.04211102f, -0.04365374f, 0.02916311f, 0.09432446f, 0.06067195f, 
    0.22484414f, 0.12008350f, -0.06516717f, -0.10051193f, 0.08504450f, -0.06825510f, -0.08290289f, -0.11408690f, 
    -0.04146951f, 0.13742740f, -0.09998612f, -0.00152318f, 0.23267257f, -0.06182396f, 0.13800205f, -0.07562315f, 
    0.19612823f, 0.04249693f, -0.06179320f, 0.04910265f, -0.19198020f, 0.01362792f, 0.32369593f, 0.04511689f, 
    0.26546985f, 0.05451521f, 0.09489886f, 0.20682728f, 0.05564976f, 0.08394859f, -0.06543122f, 0.03920238f, 
    0.04882717f, -0.00293906f, 0.12315215f, 0.08296912f, -0.03162812f, -0.15979156f, -0.09501448f, 0.18285218f, 
    0.12107890f, 0.09310801f, -0.24815287f, 0.03220797f, 0.01551404f, -0.04107221f, 0.01835869f, 0.11007978f, 
    0.24715278f, -0.26009965f, 0.03652798f, -0.13406165f, -0.12337451f, -0.04373540f, -0.06482848f, -0.05907656f, 
    -0.01302022f, 0.10735480f, 0.07465991f, 0.06126420f, -0.08049870f, -0.11432093f, -0.01740733f, -0.18097942f, 
    0.03974083f, -0.10371571f, 0.16032490f, 0.06469177f, 0.17935927f, 0.01377118f, -0.10890938f, 0.16893712f, 
    0.03212533f, -0.02209595f, -0.01600119f, 0.01262168f, 0.07084313f, 0.02942953f, -0.08937503f, -0.07402613f, 
    0.09327109f, -0.08345322f, 0.07039341f, -0.08048111f, -0.50084722f, 0.11630686f, -0.08311040f, 0.10730774f, 
    0.16266632f, 0.02618962f, -0.26368654f, 0.17687799f, 0.28267607f, 0.13080058f, 0.02504305f, -0.19087540f, 
    0.03909374f, 0.30718780f, 0.10003762f, -0.00131555f, 0.31320304f, 0.01604358f, 0.08272239f, -0.08880510f, 
    0.04143196f, -0.02629143f, 0.02022810f, 0.09098551f, -0.38533512f, -0.13373803f, 0.18912323f, -0.22639458f, 
    -0.01586425f, -0.00220642f, 0.06260795f, 0.11498649f, 0.00814425f, 0.10620312f, -0.04764386f, 0.19983743f, 
    0.11072422f, -0.21573099f, 0.07929359f, -0.33013257f, 0.21210031f, -0.09941783f, 0.00787095f, -0.03488971f, 
    0.03998795f, 0.01040971f, 0.18717912f, 0.02377365f, 0.21797763f, -0.05146490f, 0.00274272f, 0.04082061f, 
    -0.00698891f, 0.09248976f, -0.13823028f, -0.07562417f, 0.08583251f, 0.12496313f, -0.11514395f, 0.28350019f, 
    0.15163405f, 0.29691708f, -0.09473970f, 0.24376447f, -0.07118142f, 0.09078868f, 0.07470987f, -0.08988112f, 
    -0.09164976f, 0.22962844f, 0.00081165f, -0.01616131f, 0.25854701f, 0.21842392f, -0.03142450f, 0.03469869f, 
    -0.04205070f, -0.01100223f, 0.08629631f, 0.09690484f, -0.00191824f, 0.01675187f, -0.08712374f, 0.07354725f, 
    -0.33181158f, 0.09271763f, -0.14807343f, -0.18544292f, -0.03182051f, 0.02077797f, 0.08329966f, 0.09554622f, 
    -0.04058841f, -0.08054059f, 0.02864184f, -0.13127558f, 0.03424563f, 0.15430047f, 0.04075629f, 0.34250617f, 
    0.10551087f, -0.03179772f, -0.01777332f, -0.05292735f, 0.02640478f, -0.15322933f, -0.15918598f, -0.03776451f, 
    0.20093024f, 0.15483566f, 0.13561487f, 0.18990277f, 0.03792586f, -0.12258425f, -0.01888773f, -0.10148036f, 
    -0.02623936f, -0.17489974f, 0.10210907f, -0.09405620f, -0.09198802f, 0.15735422f, 0.15450756f, 0.24454246f, 
    0.02557713f, 0.08281334f, -0.00154790f, 0.08771797f, 0.00575195f, 0.07564194f, -0.16644163f, -0.10966495f, 
    -0.23160246f, -0.28466827f, -0.01049403f, 0.08730474f, 0.06325290f, 0.04174619f, -0.08285847f, -0.05666765f, 
    -0.04246671f, -0.16772781f, -0.11517470f, 0.09962364f, -0.36197588f, 0.03771309f, 0.06403424f, 0.08891696f, 
    0.20430067f, 0.07633307f, -0.15930022f, 0.03314373f, -0.01361391f, 0.15517664f, 0.04897291f, 0.00517401f, 
    0.30534557f, 0.10919486f, -0.07117119f, -0.10438643f, -0.12431557f, 0.04945373f, 0.04586202f, -0.06723358f, 
    -0.17444240f, 0.09265505f, 0.21653014f, 0.03720552f, 0.10049339f, 0.07832167f, -0.07608388f, 0.10060150f, 
    0.02465373f, 0.05135861f, 0.10327062f, 0.05671283f, 0.05625481f, -0.00329916f, 0.09872718f, 0.06883048f, 
    -0.19365357f, 0.02851243f, -0.02698374f, -0.17234227f, 0.12007857f, 0.09636471f, 0.01599404f, -0.00509945f, 
    0.02319468f, -0.01256515f, -0.00837730f, -0.03084190f, -0.12861237f, -0.22214361f, 0.10449346f, -0.02638840f, 
    0.15164359f, -0.05559177f, 0.10183301f, 0.05938819f, -0.03870263f, 0.01727728f, 0.12550436f, 0.03173579f, 
    0.17280044f, 0.14457424f, 0.04021307f, 0.26291519f, -0.05784660f, 0.04057742f, 0.10946520f, -0.04738995f, 
    -0.00238730f, -0.04955528f, 0.02173301f, 0.05518494f, 0.11362322f, 0.00857780f, -0.20983836f, 0.34124812f, 
    0.09466518f, 0.06074051f, -0.06576055f, 0.04501522f, -0.17122623f, 0.05685551f, -0.00047555f, 0.04151123f, 
    0.29432517f, 0.07661176f, 0.00615169f, 0.19455278f, -0.02509993f, 0.01559633f, -0.07225940f, 0.03630433f, 
    -0.17490886f, 0.16856703f, -0.05249328f, 0.05339973f, 0.20202400f, -0.08346830f, 0.04293531f, -0.10890962f, 
    0.08419612f, -0.03251843f, 0.01742569f, -0.04250329f, 0.07643452f, -0.03681303f, 0.10588279f, -0.01656211f, 
    -0.00396215f, -0.21431100f, -0.25388923f, -0.12334029f, 0.03127531f, -0.04689720f, -0.00778269f, 0.15830496f, 
    0.08191382f, 0.00186438f, -0.02318773f, 0.18607670f, -0.15823328f, -0.21812692f, 0.10424116f, 0.10887419f, 
    -0.13338676f, -0.07748282f, 0.12345612f, 0.12279056f, -0.07735525f, -0.06380185f, -0.00009181f, 0.10575646f, 
    -0.04408853f, -0.09240316f, -0.38985112f, 0.50303900f, -0.00651637f, 0.09996618f, -0.00629830f, -0.08348195f, 
    0.03241765f, 0.00746000f, 0.14598919f, -0.01748281f, -0.18657212f, -0.10577723f, 0.17205407f, 0.17695838f, 
    -0.05226295f, -0.07153250f, 0.04042989f, 0.18895814f, -0.01598730f, 0.06845779f, 0.10381123f, -0.14256854f, 
    -0.50203991f, -0.03335116f, -0.07917688f, 0.11503014f, -0.06932136f, 0.14410214f, 0.06199941f, 0.09016990f, 
    0.03622318f, 0.02190671f, 0.06980877f, 0.06393696f, -0.15582986f, 0.16738933f, 0.15833759f, -0.25164372f, 
    -0.00954361f, -0.18271522f, -0.06755994f, -0.00628036f, 0.21404780f, 0.05399104f, -0.11549191f, -0.06956133f, 
    -0.11558824f, 0.02286038f, -0.33033726f, 0.30440360f, -0.04920708f, 0.01582445f, 0.05271533f, -0.03751159f, 
    0.02788796f, -0.02622621f, -0.05045340f, -0.21164763f, 0.21873684f, 0.45631850f, 0.09613831f, 0.38004428f, 
    -0.08243699f, -0.15495761f, 0.07708450f, -0.13684367f, 0.00140399f, 0.09324239f, -0.09706822f, -0.09125546f, 
    0.26711076f, -0.28345698f, 0.03126030f, 0.18986654f, 0.02771570f, -0.01295752f, 0.12036932f, 0.06027014f, 
    0.02431000f, -0.03635656f, -0.04528539f, -0.02493979f, 0.18941061f, 0.14808165f, -0.05689172f, -0.10819568f, 
    0.01571267f, 0.10879505f, 0.02651569f, 0.01808952f, -0.03108849f, 0.18689449f, 0.10373842f, -0.06376303f, 
    -0.19862925f, -0.10247681f, -0.06675150f, 0.26658729f, 0.03531434f, 0.11662593f, 0.02712846f, 0.00520948f, 
    0.00869326f, 0.11584461f, 0.00535770f, 0.09160458f, 0.37658718f, 0.22476357f, 0.09829944f, 0.03368602f, 
    -0.00254504f, 0.06569891f, 0.15098418f, 0.01501151f, 0.06569880f, 0.05773995f, 0.05552687f, -0.06334278f, 
    -0.08449779f, 0.02264291f, 0.05048824f, -0.37609485f, -0.06526899f, -0.02338810f, 0.12342647f, 0.03015370f, 
    0.01614001f, -0.07849950f, 0.08134483f, -0.03608841f, 0.16471894f, -0.13463049f, 0.18747878f, -0.09211778f, 
    0.06765370f, -0.02643459f, -0.00908313f, 0.07855070f, 0.08070457f, -0.16307454f, 0.03237862f, -0.01681127f, 
    -0.36119407f, 0.01016697f, 0.20042285f, -0.19760795f, 0.02049937f, 0.14689726f, -0.06282834f, 0.00976284f, 
    -0.05593092f, -0.04386930f, -0.04077585f, -0.00901833f, 0.06832632f, -0.06038076f, -0.19639182f, 0.18049103f, 
    -0.08101296f, 0.15972902f, 0.06929798f, 0.03793978f, -0.13092735f, -0.07992990f, -0.02527235f, -0.17832974f, 
    -0.04321101f, 0.04413363f, 0.15620072f, -0.17700668f, 0.17657642f, 0.02484219f, -0.08168207f, 0.02621247f, 
    0.04425497f, -0.18851823f, 0.12451681f, -0.02666361f, -0.27509710f, -0.06695413f, 0.14115727f, 0.02435713f, 
    -0.04218910f, 0.00900351f, 0.16830128f, -0.07784794f, -0.02161616f, 0.07324854f, -0.00160725f, -0.05810555f, 
    -0.00351939f, 0.13776904f, 0.00784742f, 0.14882609f, -0.06061048f, 0.07920731f, -0.07068250f, -0.03179515f, 
    -0.01658977f, -0.01504204f, -0.04713519f, 0.11023110f, 0.09011469f, -0.16138060f, 0.17824040f, -0.10106345f, 
    -0.06160559f, 0.06139370f, 0.06398010f, 0.07413784f, -0.07454268f, -0.00680973f, 0.13460450f, -0.03312507f, 
    -0.10450581f, 0.06878568f, 0.22077464f, 0.10638153f, -0.07834158f, -0.08032916f, 0.12062161f, 0.09579387f, 
    0.03414964f, 0.20068559f, 0.10901184f, -0.06611118f, 0.17400011f, -0.20151231f, -0.15135516f, -0.26335797f, 
    0.07926889f, -0.03079275f, 0.05243438f, 0.01014048f, 0.02004373f, -0.01489331f, -0.03102121f, -0.08083744f, 
    0.17134528f, 0.19705611f, 0.00476352f, 0.20559692f, -0.05453006f, 0.06406779f, 0.04112176f, -0.06359154f, 
    0.10526329f, 0.10068318f, -0.01971786f, -0.04575685f, 0.20372128f, 0.12975697f, -0.15922903f, -0.02884111f, 
    -0.06518729f, 0.05433636f, 0.01705943f, 0.02704995f, -0.05227056f, -0.07114711f, 0.02114713f, 0.07583100f, 
    -0.00411281f, 0.07598026f, 0.18128932f, 0.29840097f, 0.19572897f, -0.01852061f, -0.17596009f, -0.08147603f, 
    0.08949925f, 0.05133532f, -0.09458800f, 0.10171612f, 0.11800052f, 0.11809482f, -0.15207745f, 0.15584454f, 
    0.01661096f, -0.11406749f, -0.04575447f, -0.05604417f, -0.04166467f, 0.12903798f, -0.07824406f, 0.05273482f, 
    0.45866919f, -0.27066824f, 0.03470153f, -0.00624838f, 0.07834829f, -0.02594881f, -0.03770583f, 0.07456713f, 
    -0.04412634f, 0.14631501f, -0.00197714f, -0.05607650f, -0.06568734f, 0.14070307f, 0.02993583f, -0.08149651f, 
    0.02319787f, 0.07613043f, 0.00024114f, 0.11496136f, -0.04303394f, 0.07196280f, 0.00609941f, 0.02388977f, 
    0.14482352f, 0.09564280f, 0.01985055f, -0.10510518f, 0.07740258f, 0.07019894f, -0.08392481f, 0.00038611f, 
    0.06047625f, 0.10132533f, 0.02392370f, 0.11015545f, 0.17900687f, 0.10776765f, 0.11572034f, -0.16765349f, 
    -0.15490034f, -0.01915442f, -0.06725985f, 0.00962971f, 0.07985058f, -0.12392530f, 0.15644194f, 0.02564843f, 
    -0.37159500f, 0.12065872f, 0.00361190f, -0.24595140f, 0.11999594f, -0.05466965f, 0.01744346f, 0.02818335f, 
    0.18492834f, -0.07915784f, 0.11751666f, -0.00907610f, 0.10078396f, -0.19418232f, -0.09476428f, -0.00190951f, 
    0.01660843f, 0.02039032f, 0.00255964f, -0.01415566f, -0.16761561f, -0.04518874f, -0.05603174f, 0.04062636f, 
    -0.21097228f, -0.09180643f, 0.13672741f, 0.04132967f, 0.07260272f, 0.10658547f, -0.03890631f, -0.21234122f, 
    -0.04886995f, 0.01315562f, 0.07209252f, 0.01321250f, 0.16526306f, 0.10524268f, -0.08125885f, -0.25746077f, 
    0.12380043f, 0.10741263f, -0.12872376f, -0.07146980f, -0.06163219f, 0.04101924f, -0.04758140f, 0.02686977f, 
    -0.05246940f, 0.00933006f, 0.41122997f, -0.41217846f, 0.00592397f, 0.03099168f, 0.09677174f, 0.22758052f, 
    0.03022592f, 0.05743672f, -0.08074985f, -0.06498089f, 0.13173038f, -0.03998740f, -0.10118186f, -0.26752600f, 
    -0.01983007f, 0.07838404f, -0.00485056f, 0.01254231f, 0.11009391f, -0.04342832f, 0.02806205f, -0.06111643f, 
    0.13425224f, 0.13661212f, -0.14482439f, 0.13371514f, 0.13914430f, -0.07172289f, -0.02247031f, -0.00787578f, 
    -0.05097406f, -0.00835674f, -0.11185194f, -0.08520517f, 0.17067252f, -0.28112507f, -0.04499828f, 0.10165936f, 
    0.04036960f, 0.03779133f, 0.14862804f, 0.00076593f, -0.12446768f, -0.21716106f, -0.08941213f, 0.02029150f, 
    0.10195321f, -0.19538336f, 0.15733172f, -0.22722703f, 0.06157083f, -0.03580590f, 0.03173433f, 0.02893862f, 
    -0.01918720f, 0.04259320f, -0.02738615f, -0.00522916f, 0.11682741f, -0.10887678f, -0.14376812f, -0.51183164f, 
    0.10003368f, 0.06955153f, -0.01927040f, 0.07418184f, -0.07878396f, 0.01775188f, 0.03783832f, 0.01239264f, 
    -0.04465003f, 0.37305444f, 0.07741114f, 0.23899397f, 0.10567818f, 0.01509438f, -0.10764666f, 0.16357362f, 
    -0.02254071f, 0.09577669f, 0.02871767f, 0.15403455f, -0.00572851f, -0.03603815f, 0.13169786f, 0.04629179f, 
    0.14694875f, 0.00262974f, 0.05566496f, 0.03843384f, -0.09688082f, -0.05224224f, -0.03695052f, -0.07345989f, 
    -0.02065742f, 0.18637204f, 0.03203528f, -0.14634271f, 0.00720289f, -0.05225737f, 0.00671492f, 0.08192944f, 
    -0.00478704f, -0.05611552f, 0.05746011f, 0.04572249f, 0.00945370f, -0.07011347f, 0.02190131f, -0.06616378f, 
    -0.06061869f, -0.04121844f, -0.09469146f, -0.15890266f, -0.12099689f, 0.00775053f, -0.14963661f, 0.09290837f, 
    -0.19704105f, 0.03066899f, -0.16302915f, 0.12948483f, -0.03399845f, 0.02788504f, -0.09676909f, -0.05484414f, 
    -0.22268581f, 0.04291435f, -0.05794979f, 0.01421758f, -0.11995982f, 0.23818287f, -0.00925887f, 0.39292631f, 
    0.04615978f, -0.04172469f, 0.05737244f, -0.13779360f, -0.04198306f, 0.04312684f, 0.06026568f, 0.14599672f, 
    0.58552313f, 0.20957735f, 0.05774089f, 0.28436139f, -0.11298674f, -0.10452734f, 0.11550622f, -0.02977894f, 
    0.08690283f, 0.10069130f, 0.09077005f, 0.01303559f, -0.09283809f, 0.05456617f, 0.09829559f, -0.02768600f, 
    0.00200302f, -0.12965700f, 0.01221656f, 0.14461204f, 0.20976706f, 0.02823765f, 0.04783649f, -0.08821759f, 
    -0.04528629f, -0.03981284f, 0.03675676f, 0.03372037f, 0.04368801f, -0.02520942f, -0.02557248f, 0.02194515f, 
    -0.02198527f, -0.01774504f, 0.02631840f, 0.03103259f, -0.01207951f, 0.00887946f, -0.02314020f, -0.02467838f, 
    0.03238076f, -0.04399637f, -0.00291561f, -0.00478585f, 0.03245715f, 0.03461029f, 0.01235429f, 0.02430782f, 
    0.00510686f, -0.01021360f, -0.00093171f, -0.01219894f, 0.02988950f, 0.02039107f, -0.00721805f, -0.05167921f, 
    -0.04536021f, -0.04507964f, -0.05178649f, 0.04334864f, -0.04324061f, 0.04221783f, -0.02140121f, 0.01220177f, 
    0.00753575f, -0.02181225f, -0.00514758f, 0.02828640f, -0.03978151f, -0.02975279f, -0.00318172f, -0.04378113f, 
    -0.03243924f, -0.04225636f, 0.03329164f, 0.01329112f, -0.02439293f, -0.04570432f, -0.02458502f, 0.04435278f, 
    -0.00299550f, -0.00432958f, -0.00123129f, 0.04182801f, -0.04434241f, 0.04844692f, -0.03406801f, -0.00572343f, 
    -0.03011909f, -0.02753254f, -0.01993936f, 0.01376458f, -0.03190252f, -0.02035577f, 0.04122714f, 0.02982515f, 
    0.04001682f, -0.01324906f, 0.03057218f, 0.01343053f, 0.00859460f, -0.03914398f, -0.01513250f, 0.04900442f, 
    -0.03628366f, 0.02792859f, -0.04178204f, 0.04301086f, -0.03682383f, -0.03774561f, 0.00473291f, -0.02504996f, 
    -0.01513369f, 0.04388602f, -0.03697943f, 0.03666761f, 0.01626940f, -0.01874282f, 0.02448052f, -0.02689257f, 
    -0.04142476f, -0.01319116f, 0.00657356f, -0.04328853f, -0.03970148f, 0.00806019f, 0.03496342f, 0.02035542f, 
    0.01020303f, -0.03321804f, -0.04775503f, 0.00751570f, 0.02607877f, 0.04041299f, -0.02917670f, 0.00445532f, 
    0.02098620f, -0.04273724f, -0.05644746f, -0.02575377f, -0.00696364f, -0.02375976f, -0.03714027f, 0.01735055f, 
    0.01111675f, -0.03182260f, 0.01478378f, -0.00200000f, -0.00236081f, 0.02162744f, 0.02529890f, -0.00447210f, 
    -0.03078367f, -0.01744967f, 0.04286730f, 0.03654299f, 0.03538868f, -0.03726274f, -0.02504673f, 0.00072014f, 
    0.02523741f, -0.02853719f, -0.00499487f, 0.00326260f, -0.00897228f, 0.04039146f, -0.00378972f, 0.01096867f, 
    0.02677866f, -0.05121520f, 0.03738366f, -0.02772797f, -0.04531193f, 0.00609241f, -0.04237611f, 0.00441813f, 
    -0.01114534f, 0.02992129f, 0.01644673f, -0.04336320f, 0.01460009f, 0.02536449f, 0.02225843f, -0.04320035f, 
    -0.04281376f, -0.01758786f, -0.01799856f, 0.02878219f, 0.00498859f, 0.02637377f, -0.00487636f, -0.03687545f, 
    -0.01307902f, 0.00692212f, -0.05583305f, -0.02943529f, 0.04406289f, 0.03155589f, -0.02761660f, 0.03391046f, 
    -0.02771072f, -0.00873205f, 0.00598953f, 0.01490662f, 0.01634081f, 0.00621267f, -0.02032916f, 0.01154544f, 
    -0.02050772f, -0.04974072f, 0.01612062f, 0.03353656f, -0.04307436f, 0.01109262f, -0.01878782f, -0.03376651f, 
    -0.01100113f, 0.02267798f, -0.04406307f, -0.00387036f, -0.02218937f, 0.02823430f, -0.04484434f, 0.04275016f, 
    0.02998358f, -0.00744981f, -0.05364747f, -0.02143557f, -0.01761982f, 0.02259850f, 0.01301867f, 0.03501415f, 
    0.02027745f, 0.01890234f, 0.01356974f, -0.02478415f, 0.00652739f, -0.02549999f, -0.04556479f, 0.03228299f, 
    -0.00025543f, -0.03916196f, 0.01181045f, 0.03738314f, -0.03749924f, 0.03779011f, 0.02991047f, 0.02871465f, 
    0.01249041f, 0.00996651f, 0.02952842f, 0.01175644f, 0.01457962f, 0.01784188f, 0.03949952f, -0.03560579f, 
    -0.02031299f, -0.04332495f, 0.01340437f, 0.01813928f, 0.04929203f, -0.03473982f, -0.04369793f, -0.05143389f, 
    0.04492059f, -0.03807195f, 0.04348821f, 0.00011186f, -0.01610836f, -0.00367215f, 0.01295361f, 0.02033638f, 
    0.01661439f, 0.03056974f, 0.01499920f, 0.01760392f, -0.03997322f, -0.01838756f, 0.00774897f, 0.02136630f, 
    -0.01627488f, 0.02260446f, -0.02076415f, -0.04509961f, 0.02117624f, 0.03728799f, -0.03801947f, -0.04595511f, 
    0.01104718f, 0.02785015f, 0.03182586f, 0.02907680f, -0.03165869f, -0.00885903f, 0.01351629f, 0.03937490f, 
    0.01591172f, -0.03160091f, -0.00024574f, -0.04167419f, 0.03819309f, -0.03736494f, -0.00181458f, -0.01417636f, 
    -0.04229983f, 0.04094494f, -0.00442234f, -0.04771516f, 0.01561400f, 0.00285919f, 0.04269150f, -0.05350174f, 
    0.02062368f, 0.00345424f, -0.03656468f, -0.01837964f, 0.02098200f, 0.03901360f, 0.01394792f, -0.03427539f, 
    0.02759236f, -0.03803264f, -0.03493026f, -0.00522206f, 0.04068874f, 0.01656073f, 0.01662989f, -0.01309699f, 
    -0.03817116f, -0.04446963f, -0.04130472f, 0.01690142f, -0.05135299f, -0.04865876f, -0.02551520f, -0.01440176f, 
    0.01663396f, -0.02852892f, -0.02408708f, -0.00790754f, 0.03278716f, -0.05506002f, 0.01824527f, -0.01061714f, 
    -0.03368570f, -0.03510173f, -0.02654466f, 0.04027758f, -0.00362263f, 0.02003639f, 0.02542799f, -0.00270145f, 
    -0.00066992f, -0.01571981f, -0.04689036f, -0.00935013f, 0.04032723f, -0.03989933f, -0.00907662f, -0.01165795f, 
    -0.02597804f, -0.01847398f, -0.04468114f, -0.04266495f, 0.00570928f, -0.02745813f, -0.00469490f, 0.01786668f, 
    -0.02374079f, -0.03487347f, 0.02964448f, -0.03144403f, 0.00273755f, 0.03361969f, 0.03973740f, 0.02655325f, 
    0.00603968f, 0.01600558f, -0.03088638f, 0.00134329f, -0.05067552f, 0.03652244f, -0.04275014f, -0.05013744f, 
    0.00599758f, -0.00922164f, -0.05703731f, -0.02780888f, -0.02642017f, -0.00884317f, 0.03283680f, 0.00101459f, 
    -0.01913265f, 0.04536777f, 0.00764816f, -0.01164055f, -0.00176185f, -0.04439894f, 0.02497513f, -0.03842774f, 
    -0.03671022f, 0.03047094f, 0.00554689f, -0.03873482f, 0.00345579f, 0.02254895f, -0.03485002f, 0.01801211f, 
    0.04350394f, 0.03199010f, 0.00489600f, -0.00639700f, -0.02786402f, -0.04712430f, -0.02953924f, -0.04246025f, 
    -0.06245236f, -0.00095104f, -0.03112501f, -0.04269119f, 0.06448712f, 0.03477180f, -0.03206708f, -0.04857283f, 
    0.02801699f, -0.01855019f, -0.01543779f, -0.06159176f, 0.00217162f, 0.03308002f, -0.04550444f, 0.03102397f, 
    0.02040810f, 0.00542211f, 0.01943502f, 0.01964476f, 0.04256901f, 0.02648654f, 0.01544873f, -0.03801423f, 
    -0.02178783f, 0.04770800f, -0.02695613f, 0.03175988f, 0.01669413f, -0.05890584f, -0.07424788f, 0.00900447f, 
    -0.03805463f, 0.03409576f, -0.00238765f, 0.01105572f, -0.01783889f, -0.05993942f, -0.06348702f, -0.06209859f, 
    0.01395776f, 0.05204804f, 0.01430061f, 0.04482524f, -0.02272776f, -0.05048684f, -0.02341677f, 0.02752218f, 
    -0.05090822f, -0.03107471f, -0.05890742f, -0.01447990f, -0.01124042f, -0.02077264f, -0.06361339f, -0.04827252f, 
    -0.03687545f, -0.00834156f, -0.06098499f, -0.00727306f, -0.00287123f, -0.00121931f, -0.03092224f, -0.04451356f, 
    -0.09076919f, -0.00194974f, -0.00738899f, -0.01913808f, 0.00514049f, 0.02031854f, -0.03467321f, 0.02520397f, 
    -0.02763641f, -0.00603509f, 0.00703196f, -0.04624793f, -0.02227027f, 0.00726235f, -0.02964518f, -0.06686751f, 
    0.02347282f, -0.03623475f, 0.04236498f, -0.02596694f, -0.04886991f, 0.00316778f, 0.00320495f, -0.03725312f, 
    0.04854264f, -0.01735502f, 0.05399328f, 0.01939690f, 0.00353345f, -0.02586059f, 0.03622881f, 0.00815375f, 
    -0.07240784f, -0.04753059f, -0.03449595f, -0.02961513f, 0.04409250f, 0.02456364f, -0.00845853f, 0.02666152f, 
    0.03863925f, 0.00047136f, 0.02640543f, -0.02967076f, 0.03322600f, 0.01168031f, 0.02129227f, -0.06515042f, 
    -0.00966836f, -0.01968512f, 0.02865592f, 0.03733253f, 0.01614171f, 0.02702446f, -0.01046532f, -0.00937687f, 
    -0.00113893f, -0.05074177f, -0.02365344f, -0.03788880f, 0.02068116f, 0.01178542f, 0.04345455f, 0.02141283f, 
    -0.05124326f, -0.02960553f, -0.04423011f, -0.04101157f, 0.00915837f, -0.03031696f, 0.00433099f, 0.00702006f, 
    0.01106447f, 0.01532677f, -0.03557108f, -0.06276542f, -0.04074306f, -0.09087982f, -0.07096657f, 0.03249929f, 
    0.03237050f, 0.00532483f, 0.00733681f, -0.01531761f, -0.01148548f, -0.03859762f, 0.00814953f, 0.05057850f, 
    0.04927570f, -0.03219701f, -0.03015336f, -0.00692444f, 0.00970766f, -0.00150416f, -0.03643036f, 0.01086908f, 
    -0.03315992f, 0.04419960f, -0.01590877f, 0.03473406f, -0.00379500f, -0.05709653f, -0.03777141f, -0.02601574f, 
    0.01627335f, -0.00595448f, -0.02489250f, -0.01590397f, -0.01241771f, -0.04419102f, 0.00277634f, -0.00048456f, 
    -0.03123074f, -0.01710035f, 0.01948822f, -0.08242688f, 0.03644220f, 0.01875295f, -0.01085676f, -0.05300737f, 
    0.01945788f, -0.01055819f, -0.01220688f, -0.02142150f, 0.04534940f, -0.04310642f, -0.02310618f, -0.00638034f, 
    -0.04605187f, -0.02814833f, -0.02702447f, 0.01038810f, 0.00102358f, -0.03681411f, -0.04466124f, -0.06596206f, 
    0.01065495f, -0.04550254f, -0.07495438f, -0.06962906f, -0.03377250f, -0.01932025f, -0.02752446f, 0.02847176f, 
    -0.01938812f, -0.00625797f, -0.03864660f, 0.04920523f, -0.02389455f, -0.06047137f, 0.02231690f, 0.02896658f, 
    -0.03130571f, -0.03005396f, -0.06085926f, 0.02797883f, 0.01463387f, -0.01682293f, -0.04629057f, 0.01129149f, 
    -0.02559742f, -0.06100262f, -0.03497923f, -0.04472902f, 0.00881767f, 0.02980540f, -0.03008043f, -0.03256008f, 
    0.03807016f, 0.03214837f, -0.01910067f, 0.05495532f, 0.04720388f, -0.01618409f, 0.00900610f, 0.01587221f, 
    -0.03293759f, -0.01268275f, -0.05837991f, 0.03399604f, -0.01307089f, 0.02411914f, 0.01898611f, -0.03955782f, 
    -0.03184871f, 0.02403980f, -0.03775069f, -0.07552922f, -0.06171146f, -0.02681358f, 0.02574010f, -0.02667231f, 
    -0.00402841f, 0.01434103f, -0.03757219f, -0.00917068f, -0.00735902f, -0.00680322f, -0.04813172f, 0.00900527f, 
    -0.04439083f, -0.01991776f, 0.00811601f, 0.03481728f, 0.00099448f, 0.00054672f, -0.00562176f, -0.01782345f, 
    -0.07244676f, -0.01809794f, 0.03428087f, -0.02271385f, -0.03054756f, -0.01983354f, -0.02017727f, -0.01535316f, 
    0.03460313f, 0.04112602f, 0.04556980f, -0.05829143f, 0.04107406f, -0.05636647f, -0.04369828f, -0.07457983f, 
    -0.05247129f, -0.04133697f, -0.06809359f, -0.02178257f, -0.06983493f, 0.01739283f, -0.03218193f, -0.06093672f, 
    -0.01608030f, -0.01254830f, 0.00818120f, -0.02822759f, -0.04521817f, -0.06544259f, -0.00663138f, -0.03918317f, 
    -0.03891673f, -0.02558457f, -0.03872082f, 0.02167240f, 0.02702160f, -0.00605005f, 0.04436385f, 0.02816458f, 
    -0.00080473f, -0.03068523f, 0.00686566f, 0.03595266f, 0.03993959f, -0.02374337f, -0.07011748f, 0.00648000f, 
    -0.07746287f, -0.03203465f, 0.02228079f, 0.00730467f, -0.04328996f, -0.05848184f, -0.05010608f, -0.02396682f, 
    -0.02497288f, -0.05310983f, -0.00390939f, 0.03273219f, 0.05082706f, -0.04950933f, -0.03091609f, -0.05461591f, 
    0.01893641f, -0.03940218f, -0.03589652f, 0.00572511f, 0.06704468f, -0.04558153f, 0.01137678f, 0.01894375f, 
    0.03169398f, -0.03482361f, 0.00719665f, 0.00298712f, -0.03480104f, -0.02717953f, -0.06260770f, -0.04739708f, 
    0.05003455f, 0.00119717f, 0.02077233f, -0.03757058f, 0.02557221f, 0.03109848f, -0.01196628f, 0.02761023f, 
    -0.01800861f, -0.01896315f, -0.00989034f, -0.00658444f, -0.03565267f, -0.00348050f, -0.03531822f, -0.00969588f, 
    -0.01330550f, -0.03757095f, -0.02741631f, 0.01749563f, -0.02554416f, 0.00250271f, -0.02082386f, -0.00357775f, 
    0.02490825f, 0.02459233f, -0.01759749f, 0.02136813f, 0.00649846f, -0.05189178f, 0.03737884f, 0.01514141f, 
    0.00925227f, -0.01312963f, -0.01365852f, -0.05499592f, -0.00655894f, 0.02306068f, 0.02430347f, 0.04052486f, 
    -0.01953882f, -0.04302751f, 0.04266310f, -0.01882797f, 0.00855275f, -0.00054347f, -0.00366717f, -0.01257755f, 
    -0.02576686f, -0.01458239f, -0.03707793f, -0.02263814f, -0.03594225f, -0.04843311f, 0.03988282f, -0.03822463f, 
    -0.00577512f, 0.00535579f, -0.02223398f, 0.02062635f, -0.05676206f, 0.00179074f, 0.04163837f, 0.00295500f, 
    0.02786318f, -0.05286390f, -0.03480246f, -0.04146354f, 0.03454681f, 0.03363771f, 0.02720698f, 0.03385141f, 
    -0.02705873f, -0.04529828f, 0.02513520f, -0.00028635f, 0.00647503f, 0.04397666f, 0.04130609f, -0.00130859f, 
    0.00206688f, -0.04740778f, 0.03286646f, -0.00924682f, -0.00474531f, -0.03140594f, -0.05297683f, -0.03493834f, 
    -0.00381875f, -0.03328580f, -0.05110766f, 0.00664344f, -0.01212074f, 0.03224298f, -0.03212346f, 0.00611170f, 
    -0.04316692f, 0.00086841f, -0.00184229f, 0.03906312f, 0.02040966f, 0.03999031f, -0.04726786f, 0.03803512f, 
    0.04443692f, 0.04117923f, -0.04155856f, -0.00962423f, 0.03236434f, 0.00748987f, -0.02759447f, 0.02313805f, 
    -0.00590321f, 0.00843929f, -0.01612112f, -0.00765067f, 0.02418846f, 0.01854509f, 0.02432597f, -0.00407470f, 
    -0.05108488f, 0.04107871f, -0.00032876f, 0.00700851f, 0.03036420f, 0.01441602f, -0.01514235f, 0.00140886f, 
    0.01484764f, -0.00430524f, 0.01501812f, -0.03407131f, 0.03763107f, -0.01371280f, -0.03380646f, -0.00241942f, 
    0.00184621f, -0.03244595f, -0.01298693f, -0.05261195f, -0.02057058f, -0.05509955f, 0.00730534f, -0.00570991f, 
    -0.05661535f, 0.03324816f, -0.03186720f, -0.02774808f, 0.01701906f, -0.02683588f, 0.02892927f, -0.03637576f, 
    -0.01998746f, -0.01952132f, -0.01859452f, 0.01127977f, 0.03364308f, 0.01363143f, -0.02656753f, 0.03040451f, 
    0.02107064f, -0.05026042f, 0.01477183f, -0.02572531f, -0.05148274f, 0.02480471f, -0.02874342f, -0.04009654f, 
    0.02057659f, -0.03958935f, 0.00331131f, -0.04583841f, -0.01153372f, 0.01577035f, 0.01534583f, 0.00936597f, 
    0.03688112f, 0.02161942f, 0.04005409f, 0.02606512f, -0.04315422f, 0.04293001f, -0.04811023f, -0.02251664f, 
    -0.01927562f, 0.02300877f, -0.01142068f, -0.02270200f, -0.01756219f, -0.01780587f, -0.01762544f, -0.00255849f, 
    -0.05476518f, -0.05152990f, -0.00202409f, 0.02892887f, -0.00168417f, -0.02680643f, -0.02895289f, -0.00163824f, 
    -0.00410055f, -0.03843787f, -0.02160517f, -0.03923751f, -0.04300794f, -0.03236666f, -0.03790552f, 0.01959419f, 
    0.01940732f, -0.04135339f, -0.02812929f, 0.00600128f, -0.01061492f, -0.04623252f, -0.02751242f, -0.04613411f, 
    0.02434356f, -0.04590501f, -0.03319593f, -0.03658360f, 0.04133509f, 0.03529566f, 0.03028153f, -0.02388391f, 
    -0.04530914f, -0.03242347f, 0.04374211f, -0.03018756f, -0.04731522f, 0.03057415f, 0.03234777f, -0.02963245f, 
    -0.04684090f, -0.03031734f, -0.05350212f, -0.00551147f, -0.04487081f, 0.01401429f, -0.00749934f, 0.00998421f, 
    -0.03485458f, -0.02766233f, 0.00785896f, 0.00661430f, -0.05318721f, -0.02740180f, -0.00583555f, -0.05029729f, 
    -0.00729783f, -0.02710997f, -0.05485889f, -0.00675187f, -0.05169314f, 0.03057751f, -0.05515596f, -0.02526511f, 
    -0.02313430f, 0.02765355f, -0.00702125f, -0.03456761f, -0.00064938f, -0.03872193f, -0.00134019f, -0.03640707f, 
    -0.03945107f, 0.00730350f, -0.04729611f, -0.05960919f, 0.02238623f, -0.02760973f, -0.00410228f, -0.03879015f, 
    0.02348462f, -0.04900013f, -0.01230868f, 0.00741592f, -0.00685029f, 0.02888606f, -0.03130542f, 0.01859993f, 
    -0.02054545f, -0.04689740f, 0.00717420f, -0.04847522f, -0.02267184f, -0.04383163f, -0.01119107f, 0.03637992f, 
    0.00097246f, 0.03877037f, -0.01923574f, 0.00752266f, -0.02245790f, 0.03065684f, -0.03171276f, -0.03490428f, 
    0.00343959f, 0.00249326f, -0.04814915f, -0.05121040f, 0.00284535f, -0.03973747f, 0.03218802f, -0.00522607f, 
    0.01797074f, -0.02091965f, -0.02472044f, -0.01733103f, 0.00744902f, -0.01549318f, 0.03500933f, 0.03328573f, 
    -0.00972306f, 0.00253568f, -0.02962910f, 0.03842012f, -0.03309191f, -0.03052261f, -0.04561746f, 0.03783931f, 
    -0.04908638f, 0.02791709f, -0.04628762f, 0.02795242f, 0.00353586f, 0.01836451f, 0.00989331f, 0.03487407f, 
    0.00857181f, -0.04213345f, -0.03928939f, 0.03159253f, 0.04243597f, 0.02492914f, 0.02565888f, 0.01654897f, 
    0.00057321f, -0.00222093f, -0.05538038f, 0.01000895f, 0.00714132f, -0.01698295f, -0.04666098f, 0.00930682f, 
    0.01205884f, 0.03112480f, 0.01787713f, -0.04895992f, -0.05566622f, 0.03943306f, -0.04798927f, 0.00493517f, 
    0.03295425f, -0.03009419f, 0.00393508f, -0.00647225f, -0.02331252f, -0.01122589f, -0.01932744f, 0.00695397f, 
    -0.04758656f, -0.00944743f, 0.03308181f, -0.01646698f, 0.03183826f, -0.02356295f, 0.04398156f, -0.04053149f, 
    -0.05223240f, 0.03373647f, 0.01595165f, 0.03000064f, 0.02074689f, 0.00560176f, -0.05423331f, -0.05690428f, 
    0.00954047f, -0.04114827f, -0.05790506f, 0.01588861f, -0.01804463f, 0.01127293f, -0.00440790f, 0.01134319f, 
    -0.04699448f, -0.01145587f, 0.03490754f, 0.02556412f, -0.02551291f, 0.01736617f, -0.03722760f, -0.03825681f, 
    -0.02504046f, 0.00371379f, 0.03626622f, -0.00472020f, 0.04337495f, -0.05573414f, 0.02514848f, 0.03873415f, 
    -0.04575801f, 0.04032673f, -0.01706612f, 0.03668947f, -0.02637246f, 0.00503973f, -0.03878842f, 0.03091541f, 
    0.06179600f, 0.22351998f, 0.20552526f, 0.08808775f, 0.18679504f, -0.08371992f, 0.06012082f, -0.05795972f, 
    0.05226055f, -0.08439172f, -0.02359754f, 0.02334633f, -0.52080953f, -0.20399414f, 0.19211966f, -0.15289895f, 
    -0.05994485f, -0.12635647f, 0.02472728f, -0.12426747f, 0.07693712f, 0.07834300f, 0.08624312f, -0.10911262f, 
    0.09824131f, 0.15164845f, -0.09075316f, -0.03082130f, -0.01638516f, 0.09918617f, -0.02637307f, 0.00780618f, 
    -0.07992056f, -0.07314590f, 0.04595559f, -0.00057106f, 0.13845484f, -0.24559282f, 0.08074357f, 0.15166736f, 
    0.07476036f, 0.00751639f, 0.06100720f, -0.08000889f, 0.03327959f, -0.20837085f, -0.07005049f, 0.00834429f, 
    0.35103175f, 0.01288757f, 0.00755117f, 0.22809866f, -0.00536499f, -0.07393079f, -0.11599701f, 0.15374082f, 
    0.00695292f, -0.07524466f, 0.02531893f, 0.12726401f, -0.05828521f, -0.06159672f, 0.10403317f, -0.05866451f, 
    0.09001236f, 0.01307226f, -0.05928312f, 0.05476890f, 0.02412025f, 0.09311322f, -0.02912728f, -0.11813485f, 
    0.40893519f, -0.01391315f, 0.19095363f, -0.12120437f, -0.11465440f, 0.08137505f, 0.06182363f, -0.01366889f, 
    0.01612493f, 0.04280893f, -0.12895504f, 0.00449233f, 0.00994295f, -0.03227049f, -0.05269481f, -0.03902476f, 
    -0.09757769f, -0.04149150f, 0.05742299f, -0.05398294f, -0.08089896f, -0.07173674f, -0.16151933f, -0.03329875f, 
    0.15245399f, 0.01937732f, -0.05798491f, -0.04835129f, 0.11582141f, -0.03260540f, -0.11160756f, -0.04458058f, 
    -0.09129336f, -0.11914989f, -0.19933915f, 0.16777262f, -0.31503940f, 0.23799410f, -0.08015776f, -0.07618274f, 
    -0.14823259f, 0.02743136f, -0.07206929f, 0.03829264f, -0.20277172f, 0.01410729f, -0.01186609f, 0.11043372f, 
    -0.14596398f, -0.14607036f, 0.15338258f, -0.15286636f, -0.09217166f, 0.00129593f, -0.07860294f, -0.05380196f, 
    -0.03744444f, -0.06543758f, -0.05545729f, -0.15482061f, 0.03045864f, -0.16298559f, 0.11995307f, 0.08722246f, 
    -0.02717856f, 0.15157650f, -0.11700887f, 0.00823076f, -0.00334859f, 0.07960869f, 0.08314990f, 0.05712556f, 
    -0.46239877f, 0.25298429f, 0.19977124f, 0.26777369f, 0.27510491f, -0.11725228f, -0.02283899f, 0.14211532f, 
    0.04131703f, -0.02827189f, -0.04596658f, 0.07257724f, -0.25918207f, 0.25730878f, -0.11172687f, 0.03762589f, 
    -0.05432821f, 0.01893819f, -0.12604123f, 0.03278090f, -0.17998494f, -0.01817761f, 0.12694260f, 0.05776228f, 
    -0.12274477f, 0.26807004f, 0.17715766f, 0.17456608f, 0.26504856f, 0.00399393f, 0.11772173f, 0.07811207f, 
    0.18577702f, -0.02305873f, 0.00735446f, 0.11243880f, -0.33543819f, -0.21182640f, 0.17335753f, -0.03481520f, 
    -0.15609811f, -0.01125600f, -0.07513796f, 0.01565429f, 0.01696279f, -0.15623681f, -0.00042865f, 0.07965052f, 
    -0.00466410f, 0.09413645f, -0.04969046f, -0.00940595f, -0.03807990f, 0.12344499f, 0.03415454f, 0.13489759f, 
    0.05963477f, 0.15240453f, 0.16296537f, 0.09008614f, -0.10127712f, 0.00540975f, 0.08129741f, 0.05531012f, 
    0.01841150f, 0.00334005f, 0.10417127f, -0.16885079f, 0.01074267f, -0.00184414f, 0.00193235f, 0.01666197f, 
    0.11973161f, 0.06886502f, 0.29103795f, 0.16304828f, -0.01264288f, -0.01280055f, 0.07574422f, 0.25821197f, 
    0.10619414f, 0.03023622f, 0.04494139f, 0.01019038f, 0.07053107f, -0.01100022f, -0.20977472f, 0.03293491f, 
    0.03288834f, -0.09898384f, 0.03038792f, 0.14960326f, 0.11841738f, -0.10850210f, 0.16162664f, -0.01717683f, 
    0.09083036f, 0.01796857f, -0.02225450f, 0.04751790f, 0.10167407f, -0.01831630f, 0.01993480f, -0.03254128f, 
    0.05554174f, 0.03688059f, -0.01469051f, -0.10458659f, -0.19653720f, -0.17725964f, 0.05219104f, -0.05453940f, 
    0.07344946f, -0.03271335f, 0.01348163f, 0.00879451f, 0.02231763f, -0.08342503f, -0.13186207f, -0.08261649f, 
    0.24524477f, -0.14608775f, 0.08597448f, -0.28263038f, -0.00708258f, -0.05279066f, -0.08366647f, -0.00135531f, 
    -0.19479439f, -0.00436580f, -0.02533966f, -0.08324853f, 0.31635752f, 0.15949693f, 0.11325461f, 0.24442282f, 
    0.26273558f, 0.09044077f, 0.20347925f, 0.24163949f, -0.17510939f, 0.13241480f, 0.02150033f, -0.09457807f, 
    0.09954549f, -0.22029717f, 0.28730533f, 0.06428204f, 0.15435490f, -0.00928371f, 0.01054426f, -0.02677794f, 
    0.05698454f, -0.02199169f, 0.03573061f, 0.02187883f, 0.06480063f, -0.06144685f, 0.12799156f, 0.07188122f, 
    -0.14071399f, 0.21747908f, -0.05090782f, -0.03566441f, -0.07212243f, 0.05784646f, -0.02822769f, -0.04587174f, 
    -0.11765733f, 0.03567722f, -0.17810620f, -0.03412444f, -0.13179122f, -0.08653945f, 0.00696066f, -0.11315275f, 
    -0.05895361f, -0.05158547f, -0.05534172f, 0.10564740f, 0.30593714f, 0.17684348f, 0.15418866f, 0.26716700f, 
    -0.02585518f, 0.10639267f, 0.03805417f, -0.09750556f, -0.18821689f, 0.17794397f, -0.16179235f, 0.05269264f, 
    -0.15582491f, 0.54162693f, -0.02410034f, -0.18661541f, -0.05013876f, 0.03836666f, 0.05557809f, 0.03092501f, 
    -0.11994072f, -0.03829381f, 0.00629826f, 0.04489355f, -0.26942107f, 0.25294250f, -0.14002955f, -0.30552807f, 
    0.03201737f, -0.01513892f, -0.00558458f, 0.07881383f, -0.00397687f, 0.03035394f, -0.06964894f, -0.02656285f, 
    0.52356166f, -0.04764692f, -0.09377483f, 0.11040298f, -0.04460230f, -0.16827537f, -0.04062637f, 0.06913678f, 
    -0.09425722f, -0.01266162f, 0.06307443f, -0.01840001f, 0.21099812f, 0.06495608f, -0.04994276f, 0.00523458f, 
    0.00669335f, -0.09326083f, 0.04260239f, -0.01370463f, -0.10717870f, -0.02183874f, -0.00041082f, -0.15690525f, 
    -0.08081491f, 0.19430402f, -0.01432886f, -0.12794329f, -0.03810495f, -0.13288234f, -0.11222528f, 0.02046676f, 
    0.07686243f, -0.08060311f, -0.08304285f, -0.07200522f, -0.50670612f, -0.10252761f, 0.09906499f, 0.23731728f, 
    0.03917644f, 0.12161447f, 0.03380779f, -0.09879015f, 0.09444115f, 0.01829685f, 0.00839852f, -0.11113323f, 
    0.43684667f, -0.21803176f, -0.10861765f, 0.48244277f, -0.01778863f, 0.00189706f, 0.06598637f, 0.05829262f, 
    -0.00042923f, -0.06053577f, 0.02392711f, 0.03538748f, -0.18402570f, 0.29080966f, -0.18911463f, -0.16122329f, 
    -0.01073604f, 0.04862219f, 0.05814515f, 0.09990300f, -0.01040490f, -0.07957799f, 0.01688880f, 0.18997037f, 
    -0.10964620f, -0.02686894f, -0.34194282f, -0.27097282f, -0.06241398f, -0.19212848f, -0.06480565f, 0.09634557f, 
    0.09018887f, -0.13447395f, -0.01533966f, 0.01447010f, -0.27017009f, -0.00608709f, -0.03835266f, -0.06512425f, 
    0.01912934f, 0.11449689f, -0.03401650f, -0.01351615f, 0.06467254f, 0.04862218f, -0.03086536f, -0.16490507f, 
    0.11417723f, 0.17364463f, 0.21205090f, -0.40767059f, -0.08112451f, 0.04017740f, 0.01260385f, -0.10208546f, 
    0.05604683f, -0.09781130f, -0.04853746f, 0.01205463f, 0.71388811f, -0.05543264f, -0.11183652f, -0.09122860f, 
    -0.11863618f, -0.03477148f, 0.00074138f, 0.09269988f, -0.05788495f, 0.01948297f, -0.07181187f, 0.05942466f, 
    -0.24140300f, 0.18975779f, -0.10517824f, -0.11234827f, -0.15513495f, -0.04152218f, -0.16049702f, -0.10699575f, 
    -0.10720683f, -0.10103261f, 0.05344102f, -0.02365891f, 0.23979592f, -0.11146197f, -0.26949728f, 0.07913603f, 
    -0.00081127f, 0.01086809f, -0.13063438f, 0.10710287f, -0.01592300f, -0.12457959f, 0.05514214f, -0.01085475f, 
    0.29305601f, -0.15749495f, 0.02895485f, 0.24707861f, 0.05463052f, 0.10103042f, -0.05210197f, 0.08625101f, 
    -0.02292378f, 0.09310289f, -0.02824808f, -0.02738754f, -0.24210292f, -0.07583758f, 0.00699229f, 0.29174891f, 
    0.03830152f, -0.04582068f, 0.08329918f, -0.04944507f, 0.14186776f, -0.06266336f, -0.04432803f, -0.00599203f, 
    -0.08060813f, -0.07243925f, 0.06088009f, 0.21716374f, -0.00748877f, -0.08785144f, -0.04629957f, 0.11151214f, 
    0.02088313f, -0.06720624f, -0.01041124f, -0.07925491f, 0.31958303f, -0.03250634f, -0.13185535f, -0.05659483f, 
    0.05080763f, -0.02602675f, -0.02440848f, 0.09142634f, -0.02235554f, 0.06738178f, -0.00542908f, -0.00672018f, 
    -0.21118201f, 0.26947787f, 0.21346931f, -0.10921240f, 0.17799263f, 0.02575181f, -0.04272141f, 0.21271622f, 
    0.08025806f, 0.10967340f, 0.06833135f, -0.04311957f, 0.12230841f, -0.15849364f, -0.04907848f, 0.19581243f, 
    -0.24021305f, 0.09285564f, 0.07394877f, 0.04749802f, 0.19245990f, -0.07771114f, 0.10686976f, -0.04832969f, 
    -0.04327678f, 0.17265126f, -0.07179761f, -0.00186056f, 0.02108949f, 0.10346603f, 0.12233585f, 0.16735096f, 
    -0.04416946f, 0.14219405f, 0.14188993f, 0.00003608f, -0.02223712f, 0.06101218f, 0.02412812f, 0.18039867f, 
    0.04355715f, 0.00292207f, 0.06640358f, -0.07922512f, -0.03882332f, -0.02498876f, 0.06771204f, -0.08748810f, 
    -0.26170200f, -0.14044181f, 0.19891557f, 0.00994332f, 0.02493489f, -0.02952241f, 0.03233524f, 0.20059353f, 
    -0.13313156f, 0.02218898f, 0.10079229f, -0.08993880f, 0.33592394f, -0.02051341f, -0.02280478f, 0.12190071f, 
    -0.05410678f, -0.09854648f, -0.13229625f, 0.09300057f, 0.04071467f, 0.06090558f, 0.10119548f, -0.03094213f, 
    0.18751293f, 0.23753498f, 0.01020167f, 0.20784660f, 0.12466376f, -0.00734356f, 0.15043575f, 0.10806811f, 
    -0.00106699f, 0.11582058f, -0.03574602f, -0.06829800f, -0.04421756f, -0.16593815f, 0.11017042f, 0.58311582f, 
    0.07421705f, -0.06080748f, 0.07034039f, 0.03170853f, 0.18628889f, -0.09901676f, 0.03735638f, -0.14076804f, 
    0.55507737f, 0.01102640f, -0.13394019f, -0.20766942f, -0.04829936f, 0.05606559f, -0.06357596f, -0.04353902f, 
    -0.01959142f, -0.15119818f, 0.07885026f, -0.18888955f, 0.25981706f, -0.00568658f, 0.08093398f, 0.01328791f, 
    -0.11712974f, -0.05615199f, 0.10656420f, 0.26142862f, 0.06834398f, 0.07151507f, 0.05047771f, 0.05171550f, 
    0.06433073f, 0.25724530f, -0.15398297f, -0.29064494f, -0.12357724f, -0.07427557f, 0.15889849f, 0.05846876f, 
    0.17034768f, 0.03224055f, 0.11109830f, 0.00067931f, -0.34159002f, -0.21110159f, 0.16702762f, -0.09947778f, 
    -0.08205211f, 0.15652555f, -0.03007865f, 0.13439359f, 0.16099234f, -0.01484667f, -0.01359724f, 0.04445273f, 
    0.68254596f, 0.01487981f, -0.04161943f, 0.05681138f, -0.28523317f, -0.10567514f, -0.05943729f, -0.02291824f, 
    -0.01311943f, 0.01246186f, -0.19941814f, 0.02430038f, 0.07459652f, 0.11664470f, 0.04626784f, 0.02897527f, 
    -0.07187875f, -0.01605795f, -0.08199483f, -0.02968033f, -0.04749884f, 0.00187994f, 0.04279038f, 0.11373058f, 
    0.60568351f, 0.03062390f, 0.20071599f, 0.33031133f, -0.11583558f, 0.06674325f, -0.04043390f, -0.02104636f, 
    -0.06394576f, 0.02880188f, 0.02542626f, 0.00968233f, -0.00787967f, 0.17065489f, 0.07120155f, -0.22171888f, 
    0.12254953f, 0.05015632f, -0.09666200f, -0.00776648f, -0.08308508f, 0.01884323f, -0.01423807f, 0.14746377f, 
    -0.05476222f, 0.33649138f, 0.09846740f, -0.00897634f, -0.13465136f, 0.00209746f, -0.04522087f, 0.03297636f, 
    0.03356832f, -0.05464432f, -0.05783122f, 0.03582729f, 0.23877679f, 0.08673281f, -0.00244781f, -0.25053883f, 
    -0.15561326f, -0.05910878f, 0.04431147f, 0.11423469f, 0.00892170f, -0.04252899f, -0.01323915f, -0.08734839f, 
    0.00323462f, -0.01373666f, 0.02274833f, 0.02929553f, 0.00689793f, 0.04051496f, -0.01378559f, 0.01816181f, 
    0.03940461f, 0.02030500f, -0.01437394f, -0.02232265f, -0.02076931f, 0.01168107f, 0.03350353f, 0.02830824f, 
    0.00125950f, -0.03029657f, 0.03069925f, 0.00857785f, 0.02040163f, -0.03801948f, -0.00930003f, -0.05126684f, 
    0.00951406f, -0.01702409f, 0.02987775f, -0.02420851f, 0.01335885f, 0.03942150f, -0.02315756f, 0.02574182f, 
    -0.02042384f, 0.03970870f, 0.03199947f, -0.03048490f, -0.02086576f, 0.03994003f, -0.02269126f, -0.05553939f, 
    0.02222609f, -0.01748659f, -0.00451691f, 0.02651856f, -0.05766133f, 0.00182598f, -0.04091022f, -0.00926204f, 
    -0.04162257f, 0.03403294f, -0.00437793f, 0.03238212f, 0.00578904f, -0.02726469f, -0.01783359f, -0.04779328f, 
    -0.04824139f, -0.03918258f, -0.05962798f, -0.01598467f, -0.02742622f, -0.05934749f, 0.03596546f, -0.01635994f, 
    0.00683158f, -0.00387721f, 0.02965210f, -0.02087684f, -0.00918658f, 0.04060003f, 0.01889081f, -0.01281030f, 
    0.00694153f, 0.01393304f, -0.05462392f, -0.01285731f, -0.00705256f, 0.02172337f, -0.05634013f, 0.02607322f, 
    0.04375168f, -0.04761645f, 0.03889258f, 0.03587137f, -0.05048148f, -0.02924591f, -0.02799113f, 0.04089348f, 
    0.03260634f, 0.04444141f, -0.03694111f, 0.00383273f, 0.04177264f, -0.01718646f, 0.03037273f, -0.02837623f, 
    0.03382844f, 0.03118629f, 0.03845361f, -0.00332629f, -0.03384115f, 0.03649924f, -0.04376248f, -0.00608996f, 
    -0.00478839f, -0.02539104f, -0.02346612f, 0.03581890f, 0.00859058f, -0.01125845f, 0.00468477f, 0.03460079f, 
    -0.05408522f, -0.01349872f, 0.00005401f, -0.04405528f, 0.02677774f, 0.02477005f, 0.00108452f, -0.00591278f, 
    0.00372215f, -0.05567433f, -0.01853504f, -0.03320248f, -0.01762810f, -0.01230963f, -0.01245321f, 0.02769769f, 
    -0.01899699f, -0.03886271f, -0.05300517f, 0.00745851f, 0.04251522f, -0.04214796f, -0.00047286f, -0.04254638f, 
    0.00334398f, 0.02714665f, -0.04531605f, -0.00043476f, -0.00712396f, 0.01487747f, -0.02951873f, -0.02923279f, 
    0.01815606f, -0.05800061f, 0.00345233f, -0.05663930f, 0.00982183f, -0.01133986f, -0.01079077f, 0.03344997f, 
    0.01741110f, -0.01921917f, -0.03767977f, 0.00169645f, 0.01908510f, 0.03199447f, 0.02208057f, -0.01084553f, 
    0.01916705f, -0.04652319f, -0.02612514f, -0.04403273f, 0.03694031f, -0.04397632f, -0.03552743f, 0.04310075f, 
    -0.02094770f, -0.01576054f, -0.05523526f, 0.01274096f, 0.04017819f, -0.03140659f, -0.05124755f, -0.01992145f, 
    -0.03900700f, 0.03989558f, -0.03092656f, -0.01837031f, 0.04057091f, -0.04562075f, -0.03487902f, 0.01254190f, 
    0.03618430f, 0.01002715f, 0.01626782f, -0.04659745f, -0.01448734f, 0.00087453f, 0.01609710f, -0.00550367f, 
    0.01514624f, 0.01896065f, -0.03901148f, 0.00296523f, 0.03491581f, -0.00420671f, 0.00725896f, -0.02896266f, 
    -0.02807244f, -0.00477728f, 0.01471561f, -0.03447316f, -0.02440465f, 0.04350372f, 0.04193558f, -0.04902012f, 
    -0.03689640f, -0.00883816f, -0.02096825f, -0.01757195f, -0.02346840f, 0.03172414f, -0.02324274f, -0.04941300f, 
    -0.01712023f, -0.02843201f, 0.02786502f, -0.06036264f, -0.05531773f, 0.03059539f, -0.04806229f, 0.03283467f, 
    -0.00907958f, -0.03276363f, 0.04439577f, -0.02734477f, 0.02381273f, 0.02810322f, -0.04327913f, 0.01656339f, 
    -0.04915454f, -0.05292015f, -0.00333222f, 0.03431359f, -0.01269130f, -0.03801009f, -0.00812896f, -0.04579352f, 
    -0.02239586f, 0.05284354f, 0.04494688f, -0.05355978f, -0.05348427f, -0.00736346f, 0.02351175f, -0.00832324f, 
    -0.03220904f, -0.01336666f, 0.02189508f, -0.01555308f, 0.04120925f, -0.01396096f, 0.01472501f, -0.03255270f, 
    -0.00109182f, 0.02979605f, 0.01922395f, -0.04381175f, 0.00408262f, 0.00263723f, 0.04258356f, 0.03658262f, 
    0.00366857f, -0.00656088f, -0.02691277f, -0.00600495f, 0.02915742f, 0.02742555f, 0.00012987f, 0.03425099f, 
    -0.00617467f, -0.00420253f, 0.04523370f, 0.01967159f, 0.00132921f, -0.01826813f, 0.02629969f, 0.03325305f, 
    -0.01761174f, -0.01683875f, -0.04042713f, -0.04014387f, -0.05379452f, -0.00254864f, -0.05123633f, -0.00648626f, 
    0.01996904f, -0.01986999f, 0.00359121f, 0.01866202f, 0.00413612f, 0.01584045f, 0.02257249f, 0.00719460f, 
    -0.03833379f, -0.01685268f, 0.02246868f, 0.01395223f, -0.04536617f, -0.02169699f, -0.01514384f, -0.01737652f, 
    -0.04649401f, 0.04398358f, 0.02087463f, 0.01444586f, -0.00800896f, 0.04576006f, 0.03471687f, 0.03086827f, 
    -0.04251473f, -0.04939447f, 0.03943947f, -0.05931373f, 0.00535372f, 0.01036429f, -0.00118626f, -0.01543566f, 
    0.02795226f, 0.00354298f, 0.00418202f, 0.04608482f, -0.02885775f, 0.01925279f, -0.01177762f, -0.05593395f, 
    0.00297585f, 0.01854561f, -0.02658879f, 0.02862973f, -0.05196238f, -0.03265917f, 0.03484234f, -0.00526117f, 
    0.01702835f, 0.00274981f, -0.03864630f, -0.04007320f, 0.02935081f, -0.04405992f, 0.00160156f, 0.00711553f, 
    -0.03560436f, -0.01445256f, -0.02425580f, 0.02224192f, -0.00798680f, -0.02586049f, -0.02787010f, -0.01660138f, 
    0.03404281f, -0.00633579f, 0.02240423f, -0.04305233f, 0.01480177f, -0.00461503f, 0.01766390f, 0.04624519f, 
    0.02084264f, -0.05300488f, 0.01347802f, -0.03113201f, -0.04580899f, 0.01901161f, -0.01041658f, -0.02881330f, 
    -0.04408565f, 0.03040597f, -0.00713194f, 0.03961917f, 0.04164035f, 0.04439497f, -0.01524512f, -0.02716775f, 
    -0.01699413f, -0.02531657f, -0.05083566f, -0.03244585f, 0.03228606f, -0.01203808f, -0.00054177f, -0.03833843f, 
    -0.05129043f, 0.01089763f, -0.06155114f, -0.05926320f, 0.00603135f, -0.04597240f, -0.05687199f, -0.03050224f, 
    -0.01777319f, -0.01455146f, 0.00424456f, -0.01333914f, -0.02740469f, -0.01323276f, -0.02984285f, -0.05143944f, 
    0.02212242f, 0.03414183f, -0.00891183f, 0.01745541f, -0.03329903f, -0.05141607f, -0.06476462f, -0.03654618f, 
    -0.02536324f, -0.05772502f, -0.01275101f, -0.05270838f, 0.00513295f, 0.03409644f, -0.02092906f, 0.01836132f, 
    0.03104664f, -0.04093532f, 0.00528140f, -0.05390505f, -0.02205013f, 0.03038426f, -0.03186997f, -0.05273904f, 
    -0.03771091f, -0.02660783f, -0.04631045f, -0.03501049f, 0.03546225f, 0.01719316f, 0.01088919f, -0.01850089f, 
    -0.01464912f, -0.04030078f, -0.01847495f, -0.05162680f, 0.02359058f, -0.02301451f, 0.01246435f, -0.04451415f, 
    -0.01682453f, 0.02873069f, -0.00603228f, -0.01319577f, -0.02632607f, -0.05448240f, -0.05479755f, -0.00417561f, 
    -0.03455151f, -0.02026092f, -0.02673850f, 0.02767537f, -0.05758194f, -0.01408568f, -0.05414144f, -0.02722692f, 
    0.01213615f, -0.04187611f, -0.02089718f, 0.02614987f, 0.02886963f, -0.02179471f, -0.05367012f, -0.01841358f, 
    -0.03963370f, -0.05756080f, 0.02992102f, -0.03223689f, -0.00090730f, 0.03546455f, 0.03882287f, 0.02544615f, 
    -0.04298436f, -0.06024235f, 0.00725322f, -0.04064356f, 0.02394103f, -0.03394404f, -0.05983550f, -0.04684649f, 
    -0.02308279f, -0.01255629f, -0.00654400f, 0.02081723f, -0.03935345f, 0.01419592f, 0.03092717f, 0.01636076f, 
    0.03804613f, 0.01866700f, 0.03214484f, 0.00681665f, 0.01516287f, -0.03637077f, 0.02329119f, -0.01880952f, 
    0.01652564f, -0.00942014f, 0.00714870f, -0.02081549f, -0.06176937f, -0.02415561f, -0.01558372f, -0.02214778f, 
    -0.01448874f, 0.00079673f, -0.00906522f, 0.03406305f, -0.05235432f, 0.00445770f, -0.04995803f, -0.03010964f, 
    0.00992471f, -0.03183871f, -0.02944847f, -0.01438895f, 0.04250903f, 0.01177322f, -0.01256909f, 0.01675839f, 
    -0.00814576f, 0.02163018f, 0.01003390f, 0.01422562f, 0.01859728f, -0.05262081f, 0.01871350f, 0.01845664f, 
    -0.03020327f, 0.03746459f, -0.03688850f, -0.02869093f, 0.00487010f, -0.04318139f, 0.01112155f, -0.03367898f, 
    0.03651677f, -0.01323877f, -0.02991822f, 0.04054542f, -0.02738297f, -0.00293388f, 0.03490837f, 0.00851098f, 
    0.02301022f, 0.01816959f, 0.01503497f, -0.04661078f, -0.04211150f, -0.01497210f, 0.00879503f, -0.02753018f, 
    0.01938227f, 0.02663487f, 0.02969272f, 0.03994248f, -0.03900685f, -0.03641099f, 0.00459254f, -0.05423116f, 
    -0.04798177f, 0.01363878f, 0.01138419f, -0.03079662f, 0.02314666f, -0.04238275f, -0.04799176f, -0.01570457f, 
    -0.05723397f, -0.05379662f, -0.00281828f, -0.02437015f, 0.03341705f, -0.04731748f, -0.06359522f, -0.06192026f, 
    -0.04776659f, -0.02814492f, -0.06056346f, -0.04037088f, -0.04035864f, -0.00225613f, -0.02542031f, -0.00506624f, 
    0.03130405f, -0.03921176f, -0.02670156f, -0.06612331f, -0.04130624f, -0.01510426f, 0.00656241f, -0.04457197f, 
    -0.04606182f, -0.01655161f, 0.00410706f, -0.03733261f, -0.04859497f, -0.00850371f, -0.01387311f, 0.00202252f, 
    -0.01126811f, 0.00984669f, -0.03109847f, -0.05130746f, -0.05860102f, -0.05836894f, 0.00942204f, 0.01263413f, 
    0.02190009f, -0.00230331f, -0.00544457f, 0.00191243f, -0.02889007f, 0.01945547f, -0.05072911f, 0.03725557f, 
    0.02441666f, -0.01920908f, -0.04348689f, -0.00458489f, -0.03021975f, 0.00952011f, -0.02600064f, 0.00168446f, 
    -0.00725276f, -0.03402897f, 0.02589955f, -0.01926435f, -0.02930418f, -0.04039698f, -0.05483872f, -0.02578292f, 
    -0.03543737f, -0.03368187f, -0.03684535f, 0.02993404f, 0.03322762f, -0.02608719f, -0.05274024f, 0.01359998f, 
    -0.01434569f, -0.04666536f, -0.03639939f, -0.05938704f, -0.02602888f, 0.03436609f, -0.03324019f, 0.00815602f, 
    -0.05697551f, -0.04217460f, -0.06551326f, -0.02720398f, -0.02332870f, -0.05438181f, -0.05710127f, 0.03550854f, 
    -0.06178142f, -0.00750682f, -0.05790699f, 0.01973350f, 0.02701767f, 0.01491451f, -0.00432646f, -0.01327212f, 
    0.01522364f, 0.00394231f, 0.01936387f, 0.01077266f, -0.01846354f, -0.06331959f, -0.02771539f, 0.00807274f, 
    -0.04663013f, -0.02008311f, 0.02557849f, -0.01705464f, 0.02409248f, -0.00730973f, -0.02921963f, -0.02612248f, 
    -0.05316493f, -0.03942739f, -0.02008937f, -0.04717051f, -0.02937710f, -0.02371335f, -0.06007580f, -0.00811164f, 
    -0.05460765f, -0.03126583f, -0.04021971f, -0.05801819f, -0.03003510f, 0.00230142f, -0.04578685f, 0.01055280f, 
    -0.03010720f, 0.02958465f, 0.01693336f, 0.00350152f, -0.02198946f, -0.03339285f, 0.00165944f, 0.03214011f, 
    -0.04309663f, -0.00996139f, -0.05292814f, -0.04845741f, -0.00871671f, 0.03267921f, -0.02704026f, -0.04253916f, 
    0.00689407f, 0.02804007f, -0.01057560f, -0.01696908f, -0.05646901f, -0.05110894f, 0.03721984f, -0.00812906f, 
    -0.05119431f, -0.03903377f, -0.06173590f, -0.00504707f, -0.03001101f, -0.04815377f, 0.01535056f, -0.04963978f, 
    0.02941044f, -0.03178756f, -0.01996283f, -0.03258421f, -0.03617650f, -0.04222238f, -0.01713700f, -0.04602723f, 
    -0.02150324f, -0.00768713f, -0.05633480f, 0.00819645f, 0.02891022f, 0.01918940f, -0.04020521f, 0.03007920f, 
    0.01480609f, 0.01586506f, 0.03014960f, 0.01542769f, 0.01863033f, 0.01202612f, -0.03926810f, -0.00638993f, 
    -0.02137762f, 0.00466892f, -0.01222199f, -0.01614892f, 0.03376538f, -0.04147969f, -0.02776309f, 0.01753435f, 
    0.03691606f, -0.02726409f, -0.02365384f, 0.03605947f, 0.00098557f, -0.05575968f, -0.02069147f, -0.05958794f, 
    0.03327982f, 0.03500926f, -0.04245330f, -0.04063121f, 0.02692371f, -0.04181850f, -0.04076273f, -0.02349684f, 
    -0.03609342f, -0.01638651f, -0.05265506f, -0.00320648f, -0.02119164f, -0.03960015f, -0.02603472f, 0.03356659f, 
    0.00150857f, 0.02963315f, 0.04656145f, -0.02258530f, 0.02668925f, -0.01000942f, -0.03423295f, 0.04233801f, 
    -0.03118148f, 0.03645167f, -0.04237098f, 0.00877843f, -0.01557613f, 0.04796631f, -0.04777436f, 0.02828154f, 
    -0.04075664f, 0.00479045f, -0.05032313f, -0.00782066f, 0.01969995f, 0.02284057f, 0.00450270f, -0.03438693f, 
    -0.00987374f, 0.00506629f, 0.02869293f, -0.01715084f, 0.04913924f, 0.03798812f, -0.03757020f, -0.01968496f, 
    0.02105337f, -0.04202837f, 0.03228447f, -0.04504475f, 0.01111779f, -0.02797393f, 0.02632493f, -0.03845962f, 
    0.03488627f, -0.00264519f, 0.01385001f, 0.03183629f, -0.00114802f, -0.01436997f, 0.02325468f, -0.04044599f, 
    0.03036473f, -0.03170512f, 0.01969039f, -0.01556360f, -0.04127291f, -0.02404954f, 0.00951857f, -0.02084867f, 
    -0.03745181f, -0.01059083f, -0.02826857f, -0.02513951f, 0.04833555f, 0.00064860f, 0.00227416f, 0.04853221f, 
    -0.01377957f, 0.02464802f, -0.04771914f, -0.00840384f, 0.01850483f, -0.02648201f, -0.03730354f, -0.01346119f, 
    -0.00261531f, 0.04043248f, 0.03689909f, -0.04064427f, -0.01539626f, 0.01117458f, 0.02904800f, 0.04591933f, 
    -0.01052153f, -0.02466705f, -0.02783966f, -0.02666567f, 0.04083997f, -0.02488456f, 0.01901716f, 0.03095678f, 
    0.03133091f, 0.03026925f, -0.03617488f, -0.01381613f, -0.01982453f, -0.04037044f, -0.04140466f, -0.05221516f, 
    0.04458971f, 0.01588794f, 0.03355586f, 0.04675062f, -0.05467936f, 0.00470374f, -0.00524793f, 0.02716363f, 
    -0.00574867f, -0.04989950f, 0.03784632f, -0.00016375f, -0.00029077f, -0.03082267f, 0.01528250f, -0.03961613f, 
    0.01418752f, 0.03858525f, -0.05830932f, -0.01822528f, -0.04768740f, 0.01514092f, 0.04000249f, 0.03264121f, 
    -0.04695857f, -0.02184680f, 0.00551909f, 0.02910633f, -0.00706119f, -0.04077311f, -0.00849808f, -0.01485019f, 
    0.01300492f, 0.04247868f, -0.01149018f, 0.03208809f, -0.00113570f, 0.00500412f, -0.01345036f, 0.01575791f, 
    -0.04762087f, -0.04933077f, -0.01881128f, -0.00929402f, -0.00121037f, -0.01890714f, 0.04513510f, 0.04502537f, 
    0.01723816f, -0.03778458f, 0.03650866f, -0.04295050f, -0.00988102f, 0.02324632f, -0.04940228f, -0.02439103f, 
    0.02534530f, -0.03460312f, 0.03702875f, 0.03751794f, -0.04487262f, 0.03050628f, -0.00769348f, 0.00638188f, 
    0.01500700f, -0.03242784f, -0.00831254f, -0.02924342f, -0.03947644f, 0.01804705f, 0.01636896f, -0.03190080f, 
    0.03649385f, -0.03937570f, -0.01493154f, -0.04741816f, -0.01672526f, -0.02293525f, -0.05208419f, -0.03440108f, 
    0.00353028f, -0.01824758f, -0.01052222f, 0.01682826f, 0.01622435f, 0.03874756f, 0.01154256f, 0.02221856f, 
    -0.05036965f, 0.04316278f, 0.02855700f, 0.01400536f, -0.02685625f, -0.01867874f, 0.00799394f, -0.00432760f, 
    -0.04111583f, -0.03932132f, 0.03270117f, -0.04477293f, -0.00548280f, -0.04696960f, -0.04745319f, 0.00123346f, 
    -0.03925517f, -0.05180377f, 0.01331013f, -0.03289682f, 0.02207720f, -0.01024071f, 0.03924578f, -0.02575561f, 
    -0.01192626f, -0.01428279f, -0.02651542f, 0.02569337f, -0.02988973f, 0.01127181f, 0.00966315f, -0.03370492f, 
    0.01775410f, 0.02950410f, 0.00258151f, 0.03349122f, 0.02462208f, -0.00174404f, 0.02084024f, -0.03683962f, 
    0.00271602f, 0.00468500f, -0.00690465f, 0.00686662f, -0.00333697f, 0.02293956f, 0.00857920f, -0.00138588f, 
    0.00457702f, -0.03474025f, -0.04329329f, -0.03446314f, 0.01938201f, 0.02087190f, 0.01253983f, 0.04300149f, 
    -0.04962470f, 0.02716659f, -0.03903829f, -0.04915070f, -0.04257787f, -0.01081513f, 0.00463871f, -0.02235919f, 
    -0.02844721f, -0.00799849f, -0.02661441f, -0.05573551f, -0.02893480f, 0.02808073f, -0.01621934f, 0.00508032f, 
    -0.01706319f, -0.01204236f, -0.03404065f, 0.03449611f, -0.01862206f, -0.03123762f, -0.02623113f, -0.03432825f, 
    0.05030745f, 0.01429127f, -0.04578343f, -0.02924954f, 0.02916832f, -0.05339166f, -0.03292426f, 0.01177008f, 
    0.01545063f, -0.00544658f, -0.01717137f, -0.00732387f, 0.00970149f, 0.04706952f, -0.00437879f, 0.01141188f, 
    -0.04855599f, 0.04817856f, -0.02260259f, 0.00854275f, 0.03021761f, -0.01682402f, -0.00183639f, -0.02084940f, 
    -0.00561207f, 0.03921027f, -0.00848648f, -0.02585972f, -0.01030698f, -0.01119765f, -0.04983456f, -0.02189607f, 
    0.01189977f, -0.04723119f, 0.02229067f, -0.01803661f, 0.01427823f, 0.03418523f, -0.04157913f, 0.02956168f, 
    -0.03583495f, -0.04892366f, 0.03608781f, -0.02039614f, 0.01624951f, 0.01382011f, -0.00743184f, -0.02135035f, 
    0.02417877f, 0.01028157f, 0.00325525f, 0.03590199f, 0.03919988f, -0.00941267f, 0.04084390f, -0.05155043f, 
    -0.01556717f, -0.04014942f, -0.01025550f, -0.00576995f, -0.04674232f, 0.04390898f, -0.04917268f, -0.00956517f, 
    -0.01186505f, 0.03866212f, 0.01406418f, -0.05470927f, 0.00321323f, 0.02320763f, 0.01845450f, -0.03080247f, 
    -0.00888928f, -0.01566615f, 0.02007630f, 0.00397806f, -0.02487032f, 0.01752975f, -0.00767638f, 0.03191693f, 
    0.00449264f, -0.01504476f, 0.03376049f, -0.03948212f, -0.02947549f, 0.00166123f, 0.04229937f, 0.03396374f, 
    0.02669894f, 0.02684298f, 0.02887693f, -0.04661304f, 0.01028361f, 0.01162616f, -0.01350426f, 0.00754393f, 
    -0.02227984f, 0.02352970f, -0.05272112f, 0.02058989f, -0.01114264f, 0.04230092f, 0.04358091f, -0.02089731f, 
    0.04021139f, 0.01649484f, 0.16070135f, -0.10469277f, -0.02024927f, -0.01694146f, -0.15743975f, 0.08332558f, 
    0.04092475f, 0.14806116f, 0.08576509f, -0.04027118f, -0.20126443f, 0.06206828f, -0.10011701f, 0.23652141f, 
    0.21102537f, -0.02834330f, 0.05866065f, 0.06105345f, -0.04879502f, 0.03619039f, 0.13763942f, 0.04635312f, 
    -0.14258136f, -0.43676203f, -0.42421311f, -0.02485095f, 0.09923049f, -0.09076872f, -0.07018313f, 0.02455365f, 
    0.18626711f, 0.01351799f, 0.06093749f, 0.24965037f, 0.12078583f, 0.08635310f, -0.06494353f, 0.00494538f, 
    -0.07823791f, 0.18450123f, 0.10758980f, 0.15804274f, -0.02799256f, 0.07737109f, 0.03913526f, 0.17101720f, 
    0.08026836f, 0.07982654f, 0.06272987f, 0.20673202f, 0.04770725f, -0.10121313f, -0.06842565f, 0.08295295f, 
    -0.02669392f, 0.04628386f, -0.02524696f, 0.06835327f, 0.18240619f, 0.16839010f, -0.15291795f, 0.01143341f, 
    0.02535136f, 0.14643212f, 0.02826359f, 0.12532715f, 0.04474750f, 0.12502123f, 0.11935728f, 0.05090481f, 
    -0.21107025f, -0.02849169f, 0.17320158f, -0.29009524f, -0.05089399f, 0.24742453f, 0.00351931f, -0.11605956f, 
    0.06614672f, 0.10744622f, 0.08111371f, 0.05660532f, -0.17458875f, -0.10183249f, 0.20713131f, -0.03611463f, 
    0.08552876f, 0.04287687f, 0.16996604f, 0.08095483f, 0.11184952f, 0.10081939f, -0.07054299f, 0.24264932f, 
    -0.14066593f, 0.19073975f, -0.13435590f, 0.17384544f, -0.12677240f, 0.16743828f, -0.06571002f, 0.16567066f, 
    0.13211377f, 0.04668057f, 0.27745920f, 0.21443722f, -0.17270435f, -0.04413887f, -0.02272369f, -0.28337088f, 
    0.14706892f, -0.08854721f, 0.03290567f, -0.04236303f, 0.07560974f, -0.05053630f, -0.08094676f, 0.06848233f, 
    0.14127044f, -0.18754870f, 0.09825442f, -0.20292984f, 0.22637813f, -0.10326919f, 0.00011846f, 0.07323888f, 
    0.09786109f, 0.13089813f, 0.03813865f, 0.06339361f, 0.06573524f, 0.06883752f, -0.17963146f, 0.23141199f, 
    -0.02044272f, -0.03052038f, -0.00756021f, 0.12761065f, 0.07855973f, 0.03778652f, -0.04873149f, -0.08092443f, 
    0.57562000f, 0.00225945f, 0.05459956f, 0.27874875f, -0.03183682f, -0.18972164f, 0.08776847f, 0.01536696f, 
    0.15500206f, -0.03954424f, 0.06585488f, -0.13658328f, 0.20125213f, 0.08799142f, 0.07586706f, -0.18717881f, 
    0.10317413f, 0.06541617f, 0.06424862f, -0.02015818f, 0.16742997f, 0.06931070f, -0.03289115f, 0.01541965f, 
    0.27329072f, 0.10709371f, -0.04928496f, -0.07252719f, -0.09747379f, -0.06927592f, 0.07969014f, 0.14238058f, 
    0.14922668f, -0.07700496f, -0.11800211f, 0.03502380f, 0.01109472f, 0.20854783f, 0.02023409f, -0.06373588f, 
    0.07904343f, 0.10189110f, -0.08268771f, -0.01907763f, 0.08464490f, 0.10708018f, -0.04686768f, 0.12937607f, 
    -0.36732870f, 0.15384990f, -0.18209545f, -0.23440412f, 0.10866507f, 0.01956532f, -0.01494864f, 0.05528852f, 
    0.03110602f, 0.10245211f, -0.00220763f, -0.09885854f, 0.20254116f, 0.25920296f, -0.14333577f, -0.05757220f, 
    0.11069059f, -0.05295376f, 0.13012025f, 0.13173647f, 0.04732041f, 0.03938998f, 0.01225473f, -0.03493559f, 
    -0.27270439f, -0.22548582f, 0.45241722f, -0.14306737f, -0.05805254f, 0.07649498f, 0.13113122f, 0.07280491f, 
    0.03680010f, 0.06593973f, -0.03574260f, 0.00207364f, 0.52933949f, 0.07284517f, 0.09308710f, 0.15172191f, 
    -0.07263811f, -0.12324308f, 0.14942972f, 0.19161789f, 0.03067577f, 0.11540695f, 0.09039943f, 0.00275576f, 
    -0.28824654f, -0.20648545f, -0.33808908f, -0.08397217f, 0.06893306f, 0.11274004f, 0.13598175f, 0.05651955f, 
    0.13190748f, 0.02253236f, 0.12157788f, -0.00442118f, -0.34226114f, -0.09103388f, -0.22321872f, -0.00591999f, 
    0.14510839f, -0.02969729f, -0.13918963f, 0.04967191f, 0.32601443f, 0.12473199f, -0.06678195f, 0.10766608f, 
    -0.16888255f, -0.30946901f, 0.16879337f, -0.24538307f, 0.11212148f, 0.11659021f, 0.01950244f, 0.01971882f, 
    0.05770818f, 0.06623525f, 0.11548851f, 0.13607042f, 0.35899234f, 0.06460173f, 0.21615809f, -0.23211755f, 
    0.05956245f, 0.06728414f, 0.09355931f, 0.01150289f, 0.14315347f, 0.14270124f, -0.00195571f, 0.02715816f, 
    0.07348716f, 0.30867347f, 0.16005859f, 0.02198877f, -0.06124560f, 0.03921282f, 0.02614796f, 0.08168504f, 
    0.03154142f, 0.05439563f, 0.03163089f, -0.05467387f, 0.27865764f, 0.18670738f, 0.24077524f, 0.14844351f, 
    0.06447983f, 0.12991393f, 0.09152773f, -0.01146748f, -0.02491315f, 0.01818810f, 0.00108957f, 0.04230267f, 
    0.04148149f, -0.22880200f, 0.15060136f, -0.03826110f, -0.06208016f, 0.12745333f, -0.01940495f, -0.04701593f, 
    0.17636962f, 0.14803049f, 0.00543612f, 0.05452683f, 0.06707875f, 0.15562519f, 0.00738991f, 0.11536230f, 
    -0.03561918f, 0.11887004f, 0.04237527f, -0.19598861f, 0.04234129f, 0.13779084f, 0.07130007f, -0.02348471f, 
    -0.25471169f, -0.25306734f, -0.37721831f, -0.31012529f, 0.17040069f, -0.09729771f, 0.03545171f, 0.05081617f, 
    0.01715152f, 0.07030720f, 0.11007629f, 0.03447349f, 0.10522007f, 0.24227032f, -0.05477048f, 0.30804628f, 
    0.06321555f, -0.04597772f, -0.03629055f, 0.24083012f, 0.14555000f, 0.12136394f, 0.02457622f, 0.21171837f, 
    0.34790552f, 0.29656032f, -0.19884355f, 0.12532958f, -0.10121465f, 0.09317358f, 0.03898461f, 0.22000720f, 
    0.06637881f, 0.01389433f, 0.11968733f, 0.06849193f, 0.13092133f, 0.04589633f, 0.04742298f, -0.33395627f, 
    -0.04511390f, 0.10465045f, 0.06045986f, 0.10635009f, 0.03455987f, -0.05823655f, 0.18721548f, 0.00699965f, 
    -0.05729089f, 0.01332230f, -0.03404364f, 0.03197748f, 0.00891222f, 0.02257333f, 0.02914099f, -0.00396199f, 
    -0.05223065f, 0.00999970f, -0.04203589f, -0.02694267f, 0.00489301f, -0.00617046f, 0.03910629f, -0.01331190f, 
    0.02365422f, 0.00505814f, -0.01961819f, 0.01387754f, -0.00771506f, -0.03707744f, 0.01061776f, -0.05719007f, 
    -0.05357287f, 0.00630719f, -0.03648830f, 0.01130941f, -0.03103156f, 0.03524424f, 0.00983758f, -0.00780537f, 
    0.00973542f, 0.00000981f, 0.00249692f, 0.02772549f, -0.06430219f, -0.03914804f, -0.04401194f, -0.03886854f, 
    0.02960759f, 0.00826656f, 0.04103338f, -0.05038570f, 0.03530338f, -0.04627085f, 0.04235763f, -0.03967740f, 
    -0.02401300f, 0.03461256f, 0.02111937f, -0.00474975f, 0.01714298f, -0.05078250f, 0.02892950f, -0.00703790f, 
    0.03848373f, -0.06127003f, 0.02108271f, 0.00978441f, 0.02260487f, 0.00733639f, -0.00087982f, -0.04421287f, 
    0.03562906f, -0.04199444f, 0.03902297f, -0.02946692f, -0.00501827f, -0.03817303f, 0.02926744f, -0.01244612f, 
    0.01088843f, 0.00506659f, 0.02963621f, 0.02382666f, 0.00760579f, -0.03369021f, -0.01796003f, 0.03113556f, 
    -0.04037614f, 0.03862307f, 0.02160702f, -0.05196905f, 0.01624753f, -0.00344989f, -0.03830913f, -0.01245462f, 
    0.03315289f, -0.00352488f, 0.01453385f, 0.02307950f, -0.00072749f, 0.02277399f, -0.00644193f, -0.00084257f, 
    0.02706038f, -0.00616960f, 0.02449282f, -0.03648254f, -0.01738852f, -0.04258956f, 0.02856257f, -0.04379758f, 
    -0.00917650f, -0.04509873f, -0.01172111f, 0.01897330f, 0.03385350f, 0.01192180f, -0.05621129f, -0.01068214f, 
    0.01451876f, -0.05378957f, -0.00400712f, -0.01801744f, 0.01641004f, 0.01656975f, -0.01880761f, 0.02016640f, 
    -0.01058347f, -0.01797129f, -0.03137155f, -0.03568529f, 0.03122544f, 0.03617296f, 0.02856239f, 0.02047884f, 
    0.01913537f, -0.04814724f, -0.01188213f, -0.02503511f, -0.04313547f, -0.02445610f, -0.01373667f, 0.01005008f, 
    -0.02614449f, -0.04830223f, -0.01362089f, -0.00922795f, -0.04110563f, 0.00718909f, 0.00250554f, -0.01685497f, 
    -0.02743831f, 0.03044226f, -0.01035874f, 0.04671502f, 0.01117800f, 0.03001177f, -0.04734869f, -0.03849497f, 
    0.02183778f, -0.02607537f, -0.05418718f, 0.01656442f, -0.04067400f, 0.01452739f, 0.03227683f, -0.06058305f, 
    0.02587686f, 0.02405729f, -0.03175216f, -0.01406720f, 0.01684517f, -0.01335350f, 0.03919553f, -0.03901264f, 
    -0.05943076f, -0.05292911f, -0.05035200f, 0.02601245f, 0.00916639f, 0.03887980f, -0.00070888f, -0.04456781f, 
    0.03123830f, 0.02319208f, 0.03612566f, 0.00515704f, 0.03018312f, 0.03669506f, -0.04324283f, -0.05254336f, 
    0.01022548f, 0.00649748f, -0.05178355f, 0.03199207f, -0.05371051f, -0.02389072f, 0.03468508f, 0.02081021f, 
    0.01531727f, 0.00417915f, -0.02140921f, -0.02510995f, -0.00746133f, -0.00854470f, -0.03459361f, -0.01841833f, 
    0.00444935f, -0.01215417f, 0.00952836f, 0.02387415f, -0.01266255f, 0.02261976f, 0.02271166f, -0.02979239f, 
    -0.03773665f, 0.03642901f, 0.04212932f, -0.00330567f, -0.00937621f, 0.03206669f, -0.02021418f, -0.04979615f, 
    0.03764209f, 0.01466599f, -0.03528488f, -0.01616233f, -0.04468532f, -0.04981621f, -0.05603707f, 0.01431244f, 
    0.01281127f, 0.03965269f, 0.02184079f, -0.01530393f, -0.05600951f, 0.02094444f, 0.02008586f, -0.00492803f, 
    -0.05643347f, -0.03073332f, 0.00070371f, 0.00796618f, -0.01262303f, -0.01069275f, -0.03065741f, 0.00299399f, 
    0.03549439f, 0.05274769f, 0.01135903f, 0.04463649f, -0.03702247f, 0.00810500f, 0.01263489f, -0.05841155f, 
    0.02856371f, 0.00577899f, 0.02812883f, -0.00552112f, -0.04121198f, -0.05845908f, 0.00859518f, 0.03440067f, 
    -0.02088524f, 0.04041000f, 0.01923825f, -0.00679990f, -0.01516617f, 0.00328327f, -0.02235053f, 0.00724529f, 
    0.00830857f, 0.02788154f, -0.04339417f, -0.01004893f, 0.02213470f, -0.02538115f, 0.03795106f, 0.01981624f, 
    0.03551852f, 0.01937842f, 0.01937016f, 0.04007510f, -0.05755910f, -0.05256712f, 0.03232036f, -0.03643419f, 
    0.01972750f, -0.04296662f, -0.02013990f, -0.02440179f, 0.03688923f, -0.05667932f, -0.00844384f, 0.01631278f, 
    -0.01707039f, -0.02507243f, -0.03588181f, 0.00641318f, -0.03393983f, -0.02822750f, -0.02010829f, 0.01872081f, 
    0.01976807f, -0.03145376f, -0.05273478f, 0.01888689f, -0.03088696f, -0.02632247f, -0.02595850f, -0.02264278f, 
    -0.01313359f, 0.03380081f, -0.04100987f, -0.04123478f, -0.00277363f, 0.01859211f, 0.02985382f, 0.02944084f, 
    -0.05146196f, -0.04570358f, -0.04544511f, -0.01444107f, -0.04507457f, -0.03327129f, -0.00295958f, -0.02641615f, 
    -0.02561603f, -0.04046269f, 0.01050327f, -0.00045630f, 0.03774816f, -0.04883207f, -0.03677304f, -0.03906272f, 
    -0.01851897f, 0.02881791f, 0.01586665f, -0.05218217f, 0.02888867f, -0.00688853f, -0.00764523f, -0.00421185f, 
    -0.04257125f, 0.02422460f, 0.02529951f, -0.03487298f, 0.03784397f, -0.04309173f, -0.02449316f, 0.00752003f, 
    -0.05029828f, 0.00756912f, -0.01817209f, -0.03626788f, -0.04899513f, 0.00039590f, 0.01323698f, -0.01754184f, 
    0.03961980f, 0.03190742f, 0.02848218f, 0.00626142f, 0.00854354f, -0.02883918f, 0.04080502f, -0.06020086f, 
    0.00383711f, 0.02094972f, 0.00292314f, -0.00678046f, 0.01395866f, -0.03648498f, 0.00825346f, -0.01197495f, 
    0.01796008f, -0.02439119f, -0.04653919f, -0.05644209f, 0.02872140f, -0.05256808f, -0.00030151f, -0.05385003f, 
    0.02154365f, -0.04118094f, -0.01455110f, -0.02816459f, 0.02767676f, 0.01580765f, 0.00173222f, -0.01094110f, 
    -0.01449453f, 0.03814239f, -0.01151790f, -0.00103008f, -0.00888969f, -0.00633025f, 0.03430161f, 0.04271729f, 
    -0.01385975f, 0.04849941f, -0.05761173f, -0.02465667f, -0.05449507f, -0.03065947f, -0.02280103f, -0.00391902f, 
    -0.03857475f, -0.03302903f, -0.02681477f, -0.04812978f, -0.05633745f, 0.02629219f, 0.01195717f, -0.02717291f, 
    -0.05387500f, 0.02554338f, -0.00101460f, 0.03415328f, 0.02539189f, -0.00023044f, 0.01029056f, -0.02436122f, 
    -0.00451934f, -0.02943781f, -0.02749506f, 0.00313298f, -0.01274825f, 0.02440011f, 0.01066917f, -0.03843947f, 
    0.00718327f, 0.00806195f, 0.01643158f, 0.02871956f, 0.00385714f, -0.05487747f, -0.04276751f, 0.02033282f, 
    0.03256376f, 0.01226221f, -0.05296165f, 0.01819098f, -0.02785510f, 0.00699771f, 0.03849611f, -0.01760454f, 
    -0.02892715f, -0.02960452f, -0.01891014f, -0.01201474f, 0.00989403f, 0.00471233f, 0.01741264f, -0.04171897f, 
    0.02607500f, -0.01467012f, -0.00094329f, -0.00097220f, -0.00632593f, -0.05413943f, 0.03912039f, -0.02958814f, 
    0.04320108f, -0.04375584f, -0.05438794f, -0.02693580f, -0.02279965f, 0.02016546f, -0.01126402f, -0.05569720f, 
    -0.01235920f, -0.00455079f, -0.02485426f, -0.02757817f, -0.03380254f, -0.01342881f, 0.03235236f, 0.02836196f, 
    -0.00682845f, -0.01822632f, -0.03436105f, -0.00625025f, -0.04863722f, 0.00496398f, -0.01568637f, -0.03932314f, 
    -0.04856576f, -0.01978270f, -0.01104894f, 0.04123724f, 0.02445298f, -0.05141887f, 0.04141872f, 0.03620957f, 
    -0.01604690f, -0.03291751f, -0.02323679f, 0.04445795f, 0.00723693f, 0.02758749f, 0.02456800f, -0.00803206f, 
    -0.01238976f, 0.03385618f, -0.05670678f, 0.01736538f, -0.00783570f, -0.01144049f, -0.00533908f, -0.03525841f, 
    -0.00557461f, 0.01587729f, -0.01105935f, 0.01085177f, -0.03116665f, -0.03438098f, -0.04276905f, 0.03688039f, 
    -0.01660368f, 0.04240411f, 0.04204778f, 0.02047828f, 0.02807052f, -0.00735547f, 0.02173064f, 0.00580538f, 
    0.00939826f, -0.01195040f, 0.00593848f, 0.01003748f, -0.02708578f, -0.00310752f, 0.02937938f, -0.02700490f, 
    -0.03545805f, -0.03842729f, -0.03628039f, -0.00389031f, -0.00729048f, 0.03681953f, 0.01730844f, -0.05002153f, 
    -0.02397357f, -0.02877892f, -0.05391696f, 0.02555157f, 0.00963383f, -0.05308899f, 0.00615493f, 0.01395843f, 
    0.02279734f, 0.03709270f, -0.02027092f, -0.04308693f, 0.01056012f, 0.03606950f, 0.02319845f, -0.00120888f, 
    0.01357728f, 0.03917785f, -0.03452640f, -0.04858181f, -0.04814669f, 0.02148417f, 0.00433568f, -0.00833941f, 
    -0.02499651f, -0.05758110f, -0.02870101f, 0.02891633f, 0.01475167f, -0.02678461f, 0.00879361f, -0.01640730f, 
    0.02881796f, -0.00230636f, -0.05381090f, 0.02187842f, -0.04994484f, -0.03769363f, -0.05767966f, -0.03438451f, 
    -0.04703073f, -0.05518292f, 0.03481903f, 0.01864467f, 0.00930876f, -0.01355498f, -0.04184389f, 0.04382220f, 
    0.00936773f, -0.03752925f, 0.01135547f, 0.00078869f, -0.02305908f, -0.01769664f, -0.00744864f, -0.02730155f, 
    0.01994145f, -0.04225239f, -0.05916334f, 0.01540005f, 0.02986517f, -0.03824164f, -0.05159270f, -0.05472750f, 
    0.01854563f, -0.05568811f, 0.00877407f, 0.00449027f, 0.04246289f, 0.03713550f, 0.00625955f, 0.01018657f, 
    0.00356575f, 0.00538419f, -0.05341515f, -0.00588094f, -0.03034409f, -0.01025020f, -0.03910541f, -0.01223642f, 
    -0.01944153f, 0.00660715f, 0.04169410f, 0.00306863f, -0.02867417f, 0.02230621f, 0.04319905f, 0.01113224f, 
    0.00471078f, 0.00684120f, -0.02224057f, -0.05663684f, -0.02023056f, -0.02220983f, -0.03482733f, -0.05390663f, 
    -0.02297167f, -0.04136615f, -0.01237448f, -0.02435058f, 0.01078618f, -0.01366154f, 0.02299580f, 0.00414273f, 
    -0.02268258f, -0.04081319f, -0.00612969f, -0.03203433f, 0.03504195f, -0.02774577f, -0.01704236f, 0.02681111f, 
    0.01890638f, -0.05748047f, 0.00635889f, -0.05856675f, 0.02386056f, -0.02350569f, 0.00695141f, 0.00304345f, 
    -0.00076388f, -0.01530628f, 0.00305387f, -0.04867493f, 0.01423123f, -0.05225226f, -0.02203578f, -0.03870087f, 
    -0.03311780f, -0.03132204f, 0.01111888f, -0.05266626f, -0.05543335f, 0.03862039f, 0.04300461f, 0.00186699f, 
    0.04081468f, 0.00357801f, -0.04497482f, -0.01163405f, -0.01832926f, -0.00015772f, -0.04592863f, -0.00914027f, 
    -0.04292869f, 0.00024567f, -0.01227869f, -0.00478822f, -0.00518694f, -0.01076472f, -0.04514793f, 0.02960989f, 
    -0.01827677f, 0.01910417f, -0.05090775f, -0.05863326f, -0.05223005f, -0.02574896f, 0.03561429f, -0.03348935f, 
    0.02191716f, 0.03737357f, 0.01724231f, -0.03648406f, 0.04331853f, -0.03933001f, 0.02823517f, 0.03332698f, 
    0.00235415f, -0.01187082f, -0.00638935f, -0.02356012f, -0.03959383f, 0.00341340f, 0.01469467f, 0.02546743f, 
    -0.03572269f, -0.01082254f, 0.01698927f, -0.01559630f, 0.03965133f, 0.00880361f, -0.02047819f, 0.01906526f, 
    0.04178178f, 0.03686959f, -0.00451565f, 0.02509158f, -0.03976992f, -0.03423722f, 0.00933753f, 0.03973621f, 
    -0.03904567f, -0.01049665f, -0.04032114f, -0.00750382f, 0.01022418f, -0.05603869f, -0.00398340f, -0.02411167f, 
    -0.01773131f, -0.02078856f, -0.01606389f, 0.00577492f, 0.00930285f, -0.00724300f, -0.03366185f, 0.04469284f, 
    -0.01556635f, -0.01451070f, 0.00053709f, 0.02584773f, -0.05794038f, -0.01712632f, -0.00362481f, 0.02061532f, 
    -0.02352275f, 0.00327305f, 0.02015758f, -0.01744563f, 0.00786021f, -0.02499064f, -0.04949563f, 0.00766393f, 
    -0.03855624f, 0.01236144f, -0.02731200f, -0.02084742f, 0.00061051f, -0.03581572f, 0.04102009f, -0.05650072f, 
    -0.09473323f, 0.07645367f, 0.07132839f, -0.01901821f, -0.01601094f, 0.18707903f, 0.04636037f, 0.09257443f, 
    -0.08009075f, 0.05188147f, -0.01880945f, 0.08422031f, -0.29951093f, 0.32532409f, 0.17476466f, -0.13965367f, 
    0.05549362f, 0.09298432f, 0.10464440f, 0.02593730f, 0.03756113f, -0.06653378f, -0.10110110f, -0.00273882f, 
    -0.06295824f, 0.23559377f, 0.10211246f, -0.01830702f, -0.17458971f, 0.03340868f, 0.17382380f, 0.18172580f, 
    0.12839419f, 0.02126749f, -0.00779688f, -0.05507738f, -0.02789917f, 0.24655226f, 0.32008559f, 0.38087487f, 
    0.03415862f, -0.14640504f, 0.16807835f, 0.04105758f, 0.08230507f, -0.04804617f, 0.09908231f, -0.03874307f, 
    0.09585016f, 0.15330783f, 0.15630464f, -0.02287127f, -0.07732700f, -0.13783874f, 0.21080117f, -0.09456488f, 
    0.02046466f, 0.04268794f, 0.16716766f, -0.18014751f, -0.01977452f, 0.10972651f, 0.26170924f, 0.25619352f, 
    0.02443157f, -0.00067241f, 0.22637273f, 0.07028616f, 0.07157399f, -0.10081876f, -0.08274893f, 0.09609539f, 
    -0.10518762f, -0.13152090f, 0.08051806f, 0.40207511f, 0.04307460f, 0.03052484f, -0.03030808f, 0.03431850f, 
    -0.07986774f, 0.04309442f, 0.01937208f, 0.02395379f, -0.09038086f, -0.09304864f, -0.24036795f, 0.15336001f, 
    -0.06809980f, 0.01789521f, -0.27171987f, 0.07075992f, 0.11456910f, -0.07560816f, 0.01465918f, -0.00234373f, 
    -0.16387208f, 0.19567545f, 0.23152351f, 0.07484423f, 0.03340161f, -0.03167440f, -0.09073552f, 0.00748255f, 
    -0.05579758f, 0.14739041f, -0.02322613f, -0.12238139f, 0.60009938f, 0.23311289f, 0.02501245f, 0.36132070f, 
    0.05081550f, 0.28986564f, 0.23693541f, 0.06503232f, 0.00092213f, 0.12440012f, 0.07022336f, 0.11147643f, 
    0.29762280f, -0.29931334f, -0.15259023f, 0.12577894f, -0.05900353f, 0.08279583f, 0.03499338f, 0.11736383f, 
    0.07794204f, -0.00779129f, 0.06883825f, -0.06607869f, -0.46821830f, 0.13521275f, -0.00022114f, -0.27731749f, 
    0.12086274f, -0.00770086f, 0.18661357f, 0.05943230f, -0.03158541f, 0.10219297f, 0.06661441f, -0.08136616f, 
    -0.29352319f, 0.02993880f, -0.22720662f, -0.18399844f, -0.17450882f, 0.15186262f, 0.14513573f, -0.09211276f, 
    -0.07906042f, 0.03949714f, 0.14822587f, 0.21182224f, 0.50106317f, -0.06741612f, 0.09575552f, 0.47968519f, 
    -0.15146387f, 0.11935098f, 0.02716787f, 0.08152270f, -0.06983754f, -0.02556819f, 0.04237553f, 0.16704302f, 
    -0.11858489f, -0.12654597f, -0.20012577f, -0.13054350f, -0.03135186f, 0.17113763f, -0.08998401f, -0.07959956f, 
    0.14856237f, 0.09932935f, 0.12187403f, 0.14473486f, -0.03919756f, 0.10921132f, 0.06126984f, 0.09719960f, 
    0.06552814f, 0.00106274f, -0.02663585f, 0.01380025f, -0.05988607f, -0.04477193f, 0.08339613f, 0.01583146f, 
    -0.36357304f, -0.15342005f, 0.04780034f, -0.00258051f, 0.01017175f, -0.06210824f, 0.11704455f, 0.11221811f, 
    0.00319316f, -0.00496276f, 0.09662966f, 0.18310827f, -0.47141987f, 0.04117989f, -0.17380746f, -0.17853449f, 
    0.01976950f, 0.01031857f, 0.06076259f, -0.02968423f, -0.03485625f, -0.01454396f, -0.03714122f, 0.03843004f, 
    0.02400283f, -0.27970582f, -0.25414407f, 0.11826725f, 0.04808055f, 0.10918469f, 0.07588083f, -0.09098306f, 
    0.02602988f, 0.16193956f, 0.03486125f, 0.03282897f, -0.32089216f, -0.12047426f, -0.10007446f, -0.19884364f, 
    0.13547671f, 0.06907528f, 0.11711373f, 0.06955525f, 0.02387003f, -0.00065545f, 0.02323211f, -0.05644489f, 
    -0.21208370f, -0.13861291f, -0.03894858f, -0.08602079f, 0.00099060f, 0.06685761f, 0.07821329f, 0.11479960f, 
    0.03748643f, 0.10554746f, -0.04775001f, 0.11661607f, 0.37336788f, -0.00767969f, 0.28086764f, -0.03961618f, 
    -0.09687165f, 0.05932377f, 0.25925240f, 0.17417897f, -0.01122301f, -0.11681557f, 0.07892271f, 0.07633106f, 
    -0.16225694f, -0.09801512f, 0.01137479f, 0.20549858f, -0.11143042f, -0.07430022f, 0.05632322f, 0.11423076f, 
    0.01176890f, -0.04548356f, -0.05824939f, -0.22469762f, 0.10039919f, -0.00057072f, -0.34360412f, -0.14146870f, 
    -0.03557042f, 0.06729557f, -0.02621665f, -0.12273628f, -0.01551090f, -0.16849758f, 0.02958683f, -0.03648332f, 
    -0.31562003f, 0.27717051f, 0.17197798f, 0.45227587f, 0.01308410f, -0.04416217f, -0.03073855f, 0.03346831f, 
    -0.01432966f, -0.01813680f, -0.04053379f, 0.11128972f, 0.26116705f, 0.04201262f, -0.07200770f, 0.19738637f, 
    0.15140167f, 0.04173271f, -0.10939533f, -0.01947318f, -0.02077878f, 0.04054886f, -0.08118857f, 0.03162357f, 
    0.06114384f, -0.09621121f, -0.02696305f, 0.00563581f, 0.05304882f, 0.07286055f, 0.05501818f, 0.04590769f, 
    0.01033125f, 0.06606653f, 0.04612467f, 0.02518385f, 0.17433038f, -0.08620165f, -0.11455946f, -0.00687427f, 
    -0.00553641f, -0.08789103f, 0.02196712f, 0.01368130f, 0.04887562f, 0.06485438f, 0.15489371f, 0.13369180f, 
    0.07618313f, -0.01398936f, -0.00974911f, -0.02321814f, -0.13318634f, 0.03581454f, 0.12931792f, 0.16664426f, 
    0.05156667f, -0.00828595f, 0.01597426f, 0.04910277f, -0.41636878f, 0.17369813f, 0.23089297f, 0.01715713f, 
    0.06260313f, 0.01723332f, 0.16957632f, 0.06633312f, -0.01443848f, -0.19940892f, 0.06925361f, 0.07215015f, 
    -0.23310614f, -0.04280229f, 0.31962693f, -0.12185287f, 0.07283653f, 0.04326111f, 0.03751535f, -0.12914599f, 
    -0.07955602f, 0.00496247f, 0.02094954f, -0.03974561f, -0.16688597f, -0.24570397f, -0.03254701f, 0.17296630f, 
    0.05194118f, 0.12279842f, 0.07174218f, -0.06040956f, -0.09020130f, 0.10575507f, -0.02725943f, -0.15289636f, 
    -0.00287155f, -0.00741591f, -0.01966365f, -0.05020381f, -0.02307736f, 0.03797832f, -0.05322291f, -0.04720111f, 
    -0.05454425f, 0.01359217f, -0.03652221f, -0.04081187f, -0.01902791f, -0.03481377f, -0.04878531f, -0.04690057f, 
    -0.04750672f, 0.02265562f, 0.01832488f, -0.01869163f, 0.01254995f, 0.00326278f, -0.05621992f, 0.03182139f, 
    0.01548981f, 0.02585623f, -0.05524545f, 0.03309341f, 0.00819830f, -0.00616213f, 0.04515087f, 0.03537105f, 
    0.00979362f, -0.04180698f, 0.04228676f, -0.00797086f, -0.05638565f, -0.00096378f, 0.01625194f, -0.03214448f, 
    0.01050198f, -0.01156584f, -0.02490343f, -0.00786765f, 0.03531886f, -0.03471369f, 0.00018857f, -0.02218220f, 
    0.02127696f, 0.03412114f, 0.00683904f, 0.01094053f, 0.03951553f, 0.03865115f, -0.04369851f, -0.03864541f, 
    -0.04879300f, 0.00755474f, 0.04708290f, -0.04096884f, 0.00759611f, 0.01170378f, -0.04114737f, 0.04684302f, 
    -0.04102055f, -0.03885831f, 0.03637322f, -0.00302210f, -0.04855135f, 0.03057459f, -0.02085324f, 0.00560698f, 
    0.02728909f, -0.01272443f, 0.01465511f, 0.01749819f, 0.00561255f, 0.04565131f, 0.04232247f, -0.04498158f, 
    -0.02140071f, -0.04406239f, 0.03807701f, -0.05037497f, 0.00091712f, 0.00626212f, -0.04284114f, -0.05981068f, 
    -0.02029565f, -0.04282970f, -0.02119102f, 0.01047348f, -0.01661114f, 0.02371830f, -0.01128473f, 0.01116167f, 
    0.01775066f, 0.03794693f, -0.00844496f, 0.02009383f, 0.01065906f, 0.00488571f, -0.01409123f, -0.00775023f, 
    0.01678561f, 0.02184720f, -0.04214779f, 0.02896396f, 0.04429864f, -0.02702789f, -0.00874976f, 0.02716591f, 
    -0.02919526f, -0.05097608f, -0.03604722f, -0.00139952f, -0.01992612f, 0.03081226f, -0.00122409f, 0.03712042f, 
    -0.04373555f, 0.03731970f, 0.01902006f, -0.05094907f, -0.01854205f, -0.04698594f, -0.00306576f, -0.05907928f, 
    0.03115819f, 0.03236928f, 0.03528902f, 0.02846511f, -0.00769819f, -0.04627517f, 0.03203576f, 0.01338836f, 
    -0.02301132f, -0.03209249f, -0.02905809f, -0.05364834f, -0.05071330f, -0.05442575f, -0.01154723f, -0.00716688f, 
    -0.00544476f, -0.00156321f, -0.04337904f, 0.00276349f, 0.00535157f, -0.02482600f, -0.01442230f, -0.01875697f, 
    -0.04581047f, 0.00892084f, 0.00238567f, 0.02605415f, 0.04067526f, 0.04380321f, -0.00597540f, 0.03546671f, 
    0.03079678f, 0.00969186f, 0.03300384f, -0.03019764f, 0.03800566f, -0.00995876f, -0.05004140f, 0.00451821f, 
    -0.01743364f, 0.03291386f, 0.03858792f, -0.02332532f, -0.00548912f, 0.03563116f, -0.03187924f, -0.02942122f, 
    -0.00608864f, -0.05536361f, 0.01140857f, 0.01244668f, -0.00503284f, -0.02105499f, -0.05194049f, -0.03899632f, 
    -0.01261138f, -0.03373229f, 0.01771146f, -0.05743351f, -0.05415995f, -0.03024017f, 0.03344487f, 0.04573414f, 
    -0.05084558f, -0.01264080f, 0.03535200f, -0.01406087f, -0.04010452f, -0.02018083f, 0.01497819f, -0.00683302f, 
    0.01294546f, -0.04580937f, 0.02798506f, -0.00667155f, -0.02218684f, -0.03938348f, 0.01395724f, 0.04687870f, 
    0.00851381f, -0.05372607f, -0.00795560f, 0.04208857f, 0.00939316f, 0.01531117f, -0.05373700f, -0.00795511f, 
    0.00014888f, -0.00105713f, 0.03892545f, -0.04876477f, 0.01355278f, -0.01845983f, -0.00945387f, 0.00936771f, 
    0.04254454f, 0.03819040f, 0.01656754f, 0.01344096f, -0.04467905f, -0.05376447f, -0.03313031f, -0.00575189f, 
    0.03357833f, -0.03958888f, 0.02171262f, -0.04585128f, 0.03619335f, 0.02998379f, -0.00880426f, -0.00973143f, 
    -0.04453463f, 0.03415438f, -0.03378192f, -0.04809574f, -0.02573722f, 0.01547151f, -0.05414658f, -0.02854334f, 
    -0.05483249f, -0.04640168f, -0.03690667f, 0.03681707f, 0.02607194f, -0.01367645f, -0.04447586f, -0.05012770f, 
    -0.04294588f, -0.02132794f, 0.03103753f, -0.01342974f, -0.03856105f, -0.01643974f, 0.03243651f, 0.04566267f, 
    0.00528996f, 0.03627691f, -0.04182656f, -0.03156245f, -0.03982187f, 0.00531408f, -0.04671454f, 0.02672867f, 
    -0.01436162f, 0.00716713f, -0.01804161f, 0.01249998f, -0.01312395f, 0.04235056f, 0.00374145f, -0.00908143f, 
    -0.01365474f, -0.02511934f, -0.01474419f, -0.00131315f, 0.00703196f, -0.00105785f, -0.03018630f, 0.01590728f, 
    -0.04740771f, -0.03669489f, -0.04024302f, -0.04784298f, 0.01544006f, 0.03399957f, 0.04660187f, -0.01809419f, 
    -0.03693180f, -0.00172034f, -0.04210592f, 0.00551052f, -0.05370337f, 0.02861149f, 0.01981447f, 0.04019352f, 
    -0.04618689f, 0.02140745f, 0.00643381f, -0.05383679f, 0.04436385f, -0.03260900f, -0.04874161f, 0.04392913f, 
    -0.04078831f, -0.04668311f, 0.01192222f, -0.02366895f, 0.01512190f, -0.01089560f, 0.01723891f, -0.00351074f, 
    0.02274148f, 0.02044533f, -0.02550993f, 0.00325123f, 0.00723504f, -0.04825951f, -0.04071940f, -0.02914817f, 
    0.03536292f, 0.01567685f, -0.03352636f, -0.04032551f, 0.02690327f, -0.01479532f, -0.00264791f, -0.01678754f, 
    0.00039891f, -0.00513071f, -0.01874541f, 0.02181554f, 0.03508526f, 0.03730012f, 0.00134774f, -0.04622697f, 
    0.03158822f, -0.04098275f, 0.00552815f, -0.05153912f, 0.03457135f, 0.01398435f, 0.03785782f, 0.01643462f, 
    -0.01297240f, 0.02445354f, 0.01144866f, 0.05110856f, 0.04335868f, 0.02839073f, -0.02515798f, 0.00682556f, 
    -0.00583928f, -0.05665197f, -0.03241576f, 0.02909167f, -0.02789830f, 0.04242519f, 0.04571103f, 0.02954559f, 
    0.01237191f, -0.02601177f, 0.00936884f, -0.04689369f, -0.05586783f, -0.03029705f, -0.03134854f, -0.04015110f, 
    -0.03164633f, -0.01643736f, -0.02030686f, -0.02735015f, 0.03568289f, 0.02216079f, -0.02599738f, -0.00843657f, 
    -0.01586091f, -0.05136772f, -0.03294033f, -0.03147488f, -0.01882844f, 0.01693805f, -0.01726460f, -0.01673938f, 
    -0.03942552f, 0.01127113f, 0.01941669f, -0.03318724f, 0.03127959f, 0.03429566f, -0.00152105f, -0.04589233f, 
    -0.05051686f, -0.00731676f, 0.02858079f, 0.00933287f, -0.04994257f, 0.02892811f, 0.00591512f, -0.02554358f, 
    0.00616750f, 0.00772552f, 0.04319072f, -0.05179960f, -0.00906152f, 0.01447816f, -0.01041593f, -0.03346593f, 
    -0.02305206f, 0.03474936f, -0.02757926f, -0.04678764f, -0.01352040f, -0.02545895f, -0.00264482f, -0.02113466f, 
    -0.02580459f, 0.02213386f, 0.03456970f, -0.04661349f, 0.03236631f, -0.01365294f, -0.04851862f, 0.01779516f, 
    0.02233862f, -0.01930926f, -0.01847755f, -0.04574985f, -0.01308071f, -0.04214046f, 0.00111391f, -0.01978485f, 
    -0.00476015f, -0.00272213f, -0.03753883f, 0.01050529f, 0.02415514f, -0.01002182f, -0.04453737f, 0.00904273f, 
    0.02708798f, -0.05274305f, -0.04400431f, -0.00321092f, -0.05252470f, -0.02841449f, 0.00399851f, -0.01184842f, 
    -0.04682622f, -0.03494744f, 0.01361472f, -0.01537623f, -0.02619594f, -0.02651853f, -0.00020147f, 0.03568213f, 
    0.04682881f, 0.04620809f, 0.02702190f, -0.03702203f, -0.02821652f, 0.03644457f, 0.00169405f, 0.02281096f, 
    -0.02458622f, 0.01716099f, 0.01464446f, -0.04534684f, -0.04227011f, 0.01967827f, -0.04336197f, 0.03255817f, 
    0.01987933f, 0.00088290f, -0.03074432f, 0.03111896f, -0.00586754f, 0.02383253f, 0.02899636f, 0.03414999f, 
    0.03383420f, 0.01208867f, -0.02477341f, 0.02049350f, -0.05504831f, 0.02021507f, -0.03681906f, 0.01930712f, 
    0.01585768f, 0.03081075f, -0.04518756f, -0.05762099f, 0.01074419f, 0.00923807f, -0.05382106f, -0.04558557f, 
    0.03373807f, -0.02346772f, 0.02763567f, -0.04200594f, 0.03591321f, 0.01603787f, -0.03003320f, 0.01607375f, 
    0.00883194f, 0.01732855f, 0.03571942f, -0.03086520f, 0.01199611f, 0.04519611f, -0.04857517f, -0.00074255f, 
    -0.03101696f, 0.02013454f, 0.03300242f, -0.01589292f, -0.02517398f, 0.04394410f, 0.03658690f, 0.01300598f, 
    0.04314911f, -0.01419854f, -0.00838825f, -0.02483983f, -0.02622892f, -0.01921779f, -0.01659929f, 0.02431465f, 
    -0.00492510f, -0.02973833f, -0.01695853f, -0.04809594f, -0.04443745f, 0.00714773f, 0.02825828f, 0.03881955f, 
    -0.01907346f, -0.00060276f, 0.03284076f, 0.04403543f, -0.01214841f, 0.01715012f, 0.04241711f, 0.03429408f, 
    0.03937928f, -0.02977139f, 0.01232987f, -0.02127335f, -0.01647978f, 0.01397921f, -0.00885002f, -0.04707866f, 
    0.03464817f, -0.00269342f, 0.00990824f, 0.03816090f, 0.04327854f, -0.00187203f, 0.02404294f, -0.04614922f, 
    0.03871621f, -0.04231448f, -0.00092182f, -0.04354981f, 0.04032556f, 0.02326550f, -0.02662295f, -0.02103171f, 
    -0.00033317f, -0.03133566f, 0.04308454f, -0.02308309f, 0.00415915f, 0.00473068f, 0.03935131f, 0.00638667f, 
    -0.01227152f, 0.02037697f, -0.00301654f, -0.00174401f, 0.00905220f, -0.00675839f, -0.03631531f, 0.01819384f, 
    -0.00530511f, -0.05536440f, 0.02093652f, -0.02713327f, -0.02757810f, 0.03481545f, -0.00817859f, -0.03557611f, 
    -0.02484043f, -0.05118599f, -0.04852375f, -0.05373112f, -0.02720044f, 0.04380691f, -0.02041900f, -0.02565007f, 
    -0.04351743f, -0.03434955f, 0.02368983f, 0.03463056f, -0.04800139f, -0.01902168f, -0.01384161f, 0.00665921f, 
    0.02264266f, -0.05034693f, -0.04763673f, -0.04709231f, 0.01731598f, -0.05099731f, -0.05384777f, -0.00049746f, 
    -0.02120974f, -0.02705543f, 0.02853437f, 0.02573478f, -0.03471773f, -0.04679541f, -0.04284652f, -0.04513118f, 
    -0.05238754f, -0.03774846f, -0.05578002f, -0.00883404f, 0.01647749f, -0.02561434f, -0.01398066f, -0.00365260f, 
    0.01111413f, -0.01081231f, 0.01279804f, 0.00773855f, -0.05230867f, -0.03845977f, 0.02580734f, -0.01083432f, 
    0.02487571f, 0.01775090f, -0.02192123f, -0.01100097f, -0.04137162f, -0.05096612f, -0.02633070f, 0.00101061f, 
    0.04026283f, -0.04944443f, 0.02000492f, 0.03586670f, -0.03529857f, 0.03108014f, 0.01251150f, -0.03334216f, 
    -0.02994446f, -0.04799600f, -0.01784284f, -0.04571194f, 0.00620105f, 0.00440905f, 0.01511263f, 0.02487402f, 
    -0.00951107f, -0.04933092f, 0.01947733f, -0.05473404f, -0.02389401f, 0.04745672f, -0.01438959f, -0.01254873f, 
    0.02097637f, -0.00168712f, 0.01396091f, -0.04715540f, -0.00484878f, -0.03884802f, -0.01935730f, -0.02760774f, 
    -0.02032071f, -0.04893150f, 0.03330708f, -0.05406087f, 0.04475089f, 0.00125537f, -0.03794518f, 0.03689515f, 
    0.02778550f, -0.05388590f, 0.01037654f, -0.03307397f, -0.02694268f, 0.03967398f, 0.02226832f, 0.01531537f, 
    -0.01711690f, -0.04262691f, -0.01234716f, -0.02828631f, 0.01989223f, -0.02735515f, 0.02430840f, -0.03536286f, 
    -0.02102042f, 0.01753762f, 0.04121372f, 0.00985156f, -0.01719218f, 0.04203245f, -0.03986273f, 0.04312579f, 
    0.02380168f, -0.04513521f, 0.00007830f, 0.04434187f, 0.00504384f, -0.01663141f, 0.02181262f, -0.04560455f, 
    0.00114065f, -0.02594238f, -0.02646000f, -0.02945783f, 0.02394158f, -0.03014637f, 0.00468090f, 0.02610282f, 
    0.03395585f, 0.02433049f, -0.00211783f, 0.01689146f, -0.03669008f, -0.03907229f, -0.03928905f, -0.01599886f, 
    0.00288860f, -0.02255093f, -0.05232598f, 0.01215682f, 0.01806653f, 0.02052199f, 0.03137403f, -0.04704515f, 
    0.02419946f, 0.01516946f, -0.03735397f, 0.00619548f, -0.01771721f, -0.00030873f, 0.00381006f, -0.01694319f, 
    -0.00979781f, -0.02535903f, -0.00621423f, 0.03259294f, -0.05412808f, 0.02403138f, -0.01548470f, -0.03242261f, 
    0.00091544f, -0.02259075f, 0.04319263f, 0.01075314f, 0.00741469f, 0.04208393f, 0.03520982f, 0.01617662f, 
    -0.04785772f, -0.00917741f, -0.02489221f, 0.00106310f, 0.04109413f, -0.04297649f, -0.02762143f, -0.04692324f, 
    -0.02539025f, 0.02810187f, -0.02079376f, -0.00361372f, 0.04646136f, 0.01357210f, -0.01037196f, -0.03499070f, 
    -0.01582957f, -0.04022785f, 0.02210104f, -0.04079681f, 0.03837173f, 0.01557989f, -0.04993856f, 0.00471783f, 
    0.01935991f, 0.02103415f, -0.03568922f, 0.02611600f, -0.02209603f, -0.05162523f, 0.00391148f, -0.03536277f, 
    -0.04417997f, 0.00399152f, -0.01524561f, -0.02294518f, -0.01055776f, -0.01138200f, 0.02630338f, -0.04841625f, 
    -0.00373574f, -0.01920226f, 0.03002879f, 0.02315499f, 0.04051039f, 0.04300720f, -0.02429615f, -0.02373881f, 
    -0.03233294f, -0.00003325f, -0.03315870f, 0.01014415f, -0.01200678f, 0.02466741f, -0.02675820f, 0.00953760f, 
    -0.05780207f, -0.04718897f, 0.00481715f, 0.03807128f, 0.00499838f, 0.00091901f, -0.02484681f, -0.03867405f, 
    -0.01401173f, -0.04726772f, -0.00724807f, -0.01528062f, -0.02545212f, 0.03386175f, -0.03643753f, -0.00255254f, 
    -0.02914784f, -0.04611503f, 0.02321894f, -0.05541577f, -0.04189309f, 0.04508031f, -0.01896508f, -0.03025066f, 
    0.01424620f, -0.04239365f, -0.00293287f, 0.04099059f, -0.03588149f, -0.04291573f, 0.01005197f, -0.01981434f, 
    -0.00021980f, -0.01198579f, -0.02074533f, -0.00327798f, 0.03267619f, -0.04670246f, 0.04024352f, -0.03744959f, 
    -0.02997344f, 0.00555520f, -0.02977162f, -0.01239180f, 0.03877714f, -0.01019898f, 0.02711905f, -0.02371412f, 
    0.01111639f, 0.03171106f, -0.01824231f, 0.01435995f, -0.01364782f, 0.01172992f, 0.02833475f, 0.03154354f, 
    0.03676215f, -0.01272252f, 0.04366411f, -0.02413812f, -0.04718382f, 0.00906739f, -0.01348842f, -0.04358115f, 
    -0.03931141f, -0.01814968f, 0.03665616f, -0.05146242f, -0.00319166f, -0.04982104f, -0.05304287f, 0.02215475f, 
    -0.03297561f, -0.03845578f, -0.00933163f, -0.03983548f, 0.00989896f, 0.02148380f, 0.01357509f, 0.01079315f, 
    0.02285869f, -0.00882657f, -0.02224089f, -0.00801112f, -0.00053142f, -0.04950507f, -0.05066456f, -0.00700290f, 
    -0.01237033f, 0.02039737f, -0.04758554f, -0.04667649f, -0.00153452f, 0.02840507f, 0.00595009f, 0.00948616f, 
    -0.03328067f, -0.04031480f, 0.01059383f, -0.04877836f, -0.05360630f, -0.05696379f, -0.03772139f, 0.03417455f, 
    0.03380469f, -0.01532073f, 0.01784291f, -0.05543163f, 0.00441011f, -0.00024300f, -0.00976581f, -0.03085786f, 
    -0.00966054f, 0.00467467f, 0.01193478f, 0.01590511f, -0.03015442f, 0.01904996f, -0.00224877f, 0.02985938f, 
    0.00124643f, -0.00660429f, -0.03284211f, 0.02311870f, -0.05250124f, 0.00095318f, 0.04741339f, -0.00855326f, 
    0.03195949f, -0.04723905f, 0.01927650f, -0.02698544f, -0.00617038f, 0.03195212f, -0.05109257f, 0.02673895f, 
    -0.03180559f, 0.03241925f, -0.02836517f, 0.02232435f, 0.03193418f, -0.03706565f, -0.01507148f, -0.02131929f, 
    -0.01588250f, 0.01152824f, -0.00493099f, -0.03065248f, -0.04203825f, 0.01883442f, -0.04254526f, 0.03955441f, 
    -0.03413409f, 0.01363274f, -0.05186028f, -0.00030527f, -0.04686926f, 0.00122196f, -0.02637630f, -0.04897866f, 
    -0.01383524f, -0.03674971f, 0.00755314f, -0.02193384f, -0.02901706f, -0.02690018f, 0.01665050f, 0.03279496f, 
    -0.01713313f, -0.04278603f, -0.04379860f, 0.03657913f, -0.04228913f, 0.04689429f, 0.00835575f, 0.01329402f, 
    -0.03708450f, -0.05462092f, -0.03235487f, 0.04093571f, 0.03643930f, -0.00832058f, -0.01916788f, 0.00237698f, 
    -0.03677189f, -0.01544595f, 0.03688386f, 0.00822618f, -0.01324627f, -0.04791815f, -0.01952964f, 0.03696793f, 
    0.01422377f, -0.02218436f, -0.03182540f, -0.01479743f, 0.05293517f, 0.03805982f, -0.01531813f, -0.05362838f, 
    -0.02997356f, -0.00429634f, 0.02188903f, 0.00140624f, 0.02394368f, 0.00257934f, -0.01625992f, -0.05189537f, 
    0.04642843f, 0.03575042f, 0.00776028f, -0.04054918f, 0.00922023f, 0.04123670f, 0.03533555f, -0.04147719f, 
    0.01488785f, 0.03986023f, -0.03267637f, 0.01566024f, -0.02010933f, 0.00166496f, -0.01236957f, -0.01172262f, 
    -0.04465939f, 0.02500130f, -0.04670623f, -0.02287023f, -0.02110639f, 0.03978978f, -0.05918460f, -0.01453162f, 
    0.04467451f, -0.01681589f, 0.01913368f, -0.02446665f, -0.02483137f, -0.02750976f, -0.01144232f, 0.03532658f, 
    -0.02917266f, -0.01902474f, -0.03723859f, -0.00447260f, 0.00569384f, -0.02910127f, 0.02213272f, 0.02024152f, 
    -0.04875481f, -0.00069328f, -0.04590536f, -0.00701145f, 0.03457457f, -0.02251246f, -0.04211828f, -0.01153074f, 
    0.01635734f, -0.00801604f, 0.02822475f, 0.04328481f, -0.01435453f, -0.02308287f, -0.01424866f, -0.03630209f, 
    0.03967428f, 0.03167718f, 0.04050688f, 0.03239277f, -0.03975195f, 0.03838551f, -0.03639902f, -0.02924850f, 
    -0.00923375f, -0.05310676f, 0.01713370f, -0.02539494f, 0.04175279f, -0.04786024f, -0.04713158f, -0.01930713f, 
    0.00008365f, 0.02283622f, 0.02952477f, 0.03317656f, -0.01145077f, -0.04241700f, 0.02547543f, -0.06152912f, 
    -0.03050419f, -0.04738723f, -0.01493370f, -0.01835322f, 0.02800498f, 0.02948922f, -0.03133960f, 0.00731221f, 
    0.04751056f, -0.00470892f, 0.04592765f, -0.00029426f, 0.02392272f, 0.02665779f, -0.00434801f, -0.02678224f, 
    -0.00348405f, 0.00122444f, 0.00126525f, 0.03558687f, -0.03702698f, -0.03526440f, 0.00588581f, -0.03559258f, 
    0.00809598f, -0.03955355f, 0.03524754f, 0.05045524f, 0.03535276f, 0.01376315f, 0.02980076f, 0.00869054f, 
    0.41359970f, 0.28407210f, 0.10137314f, -0.23775423f, 0.20881332f, 0.12960356f, 0.25360343f, -0.04161150f, 
    -0.08430688f, -0.00210207f, -0.16191171f, 0.00623249f, -0.28749496f, -0.14030087f, 0.01573916f, 0.31325793f, 
    0.08136879f, -0.03100004f, -0.09777573f, -0.16369249f, -0.02987680f, -0.05214153f, -0.13860939f, -0.09880301f, 
    0.26736438f, -0.22912334f, -0.04557221f, 0.19921052f, -0.17779712f, -0.07906944f, -0.11896602f, 0.00875443f, 
    0.01111072f, -0.03006294f, -0.04374732f, 0.17211287f, -0.12849200f, 0.43577069f, 0.09496381f, -0.23661013f, 
    -0.06186014f, -0.15572907f, 0.12522817f, 0.02595358f, 0.00415951f, -0.02342468f, -0.10978322f, -0.04992798f, 
    0.28916919f, 0.05809888f, -0.17086223f, -0.19377552f, -0.07589252f, -0.19207266f, 0.19513369f, -0.01608863f, 
    0.14674374f, -0.01912860f, 0.38420099f, -0.09311509f, -0.35877475f, 0.26908812f, 0.16824576f, 0.07765810f, 
    -0.03925378f, -0.05674840f, 0.16659904f, 0.02204420f, 0.03457845f, 0.06126657f, -0.07838804f, -0.00630587f, 
    -0.33041304f, 0.24812247f, 0.24940293f, -0.03233198f, 0.04599664f, 0.21346398f, 0.02754810f, -0.16676357f, 
    0.02859842f, -0.05112797f, 0.10710964f, 0.17907596f, -0.21709481f, -0.52424502f, -0.08915107f, 0.01500882f, 
    -0.20017169f, -0.18524720f, -0.07151038f, -0.02217361f, -0.00199605f, 0.15959863f, 0.09895167f, -0.05660087f, 
    -0.32127136f, -0.06147635f, 0.04394536f, -0.08253767f, 0.05815311f, 0.07887154f, -0.06616932f, -0.14376579f, 
    0.04436617f, 0.00156318f, 0.12816776f, -0.01136585f, 0.26790178f, 0.23343965f, 0.15985622f, 0.14031032f, 
    -0.06624389f, 0.04809063f, 0.01590158f, 0.01858490f, -0.03521413f, -0.05036866f, 0.05610452f, 0.26148796f, 
    0.04101650f, -0.23133767f, 0.21861517f, 0.11914660f, -0.20054461f, -0.08266423f, -0.20460148f, 0.05494949f, 
    0.02297966f, 0.01523996f, -0.03656911f, -0.14627032f, -0.43108514f, 0.54910403f, -0.02728408f, -0.09148332f, 
    0.10046271f, 0.22403170f, 0.06879346f, 0.13863884f, 0.00831504f, -0.01959485f, 0.15075247f, 0.10019176f, 
    -0.05226896f, 0.23777582f, 0.12180035f, -0.16545027f, 0.12727070f, 0.20992580f, 0.22570081f, 0.07273692f, 
    -0.05447047f, -0.06750573f, -0.04014835f, 0.13330379f, -0.02520013f, 0.14427194f, 0.39903688f, -0.03659946f, 
    -0.13264647f, 0.04239219f, 0.01970172f, -0.01919907f, 0.00032558f, -0.02663260f, -0.04895655f, 0.01330878f, 
    0.63962454f, -0.00110229f, -0.17387807f, 0.00185504f, 0.14803357f, 0.15155099f, 0.09410965f, 0.22177136f, 
    0.03947485f, 0.11103519f, -0.00289821f, 0.12739323f, -0.25940856f, 0.22880852f, 0.09257629f, 0.35371158f, 
    -0.01203745f, 0.07284438f, -0.18500970f, -0.14086635f, 0.08105308f, -0.10868900f, -0.10643423f, 0.00120548f, 
    -0.36279941f, 0.33554080f, -0.15327848f, -0.08794906f, 0.01265255f, 0.01140691f, 0.01308289f, 0.07549252f, 
    -0.11680487f, -0.09978282f, 0.03835550f, 0.10355055f, -0.18477176f, 0.28728932f, -0.25549561f, -0.09705684f, 
    0.15417907f, 0.11118488f, -0.02416678f, 0.03747411f, 0.13957001f, -0.09884039f, 0.04275413f, 0.06787186f, 
    0.12683021f, -0.29501882f, -0.26055649f, -0.39514855f, 0.09398830f, -0.01433107f, 0.25380844f, -0.04248445f, 
    0.00445463f, 0.02001166f, -0.03102263f, 0.13516574f, 0.09795664f, 0.12884434f, -0.04488770f, -0.14733364f, 
    0.20763069f, -0.14598192f, -0.10471869f, -0.05370941f, 0.05910102f, -0.06570666f, 0.09049688f, -0.11156024f, 
    0.20575882f, -0.47842738f, -0.04623602f, -0.31390008f, -0.23050033f, -0.05104220f, 0.06968042f, -0.00207216f, 
    0.05727527f, 0.07054459f, 0.08477733f, 0.02261073f, 0.20758013f, 0.11129611f, 0.03358828f, 0.33249906f, 
    -0.22253206f, 0.03513528f, -0.01553877f, -0.10437667f, 0.06897399f, -0.14799909f, 0.00028892f, 0.03061176f, 
    -0.19168933f, -0.10787792f, 0.10497865f, -0.44771820f, -0.03197371f, -0.11285380f, -0.04080058f, -0.20705813f, 
    0.14184076f, -0.28313461f, 0.02707449f, 0.02690004f, 0.14812915f, 0.01036750f, -0.01059905f, 0.09097890f, 
    0.12899378f, 0.07987132f, 0.07427082f, 0.13651279f, 0.14266208f, -0.03767798f, 0.10971060f, -0.12754990f, 
    -0.39929473f, 0.15448910f, 0.40095326f, 0.09847477f, 0.14108303f, 0.15267709f, -0.14954716f, 0.02787849f, 
    0.01733726f, 0.07142648f, -0.11174516f, 0.04575827f, 0.30878615f, -0.31444523f, 0.11024273f, 0.40304399f, 
    0.02925923f, 0.06908207f, -0.24221583f, -0.02320296f, 0.00488494f, 0.11124182f, -0.07194057f, 0.05762155f, 
    0.19628477f, -0.32148784f, -0.00992594f, -0.23043263f, -0.13481922f, -0.00097536f, -0.11465141f, 0.01092158f, 
    0.09965254f, -0.02300951f, -0.20550992f, -0.08033195f, 0.04942302f, -0.02533407f, -0.02817005f, 0.03966508f, 
    0.05001275f, 0.06311361f, 0.19864069f, 0.08302078f, -0.10689031f, -0.07536631f, 0.12306198f, 0.04499049f, 
    0.37245703f, -0.02722134f, -0.12787522f, 0.38626125f, -0.20278117f, -0.23295030f, -0.06652667f, -0.10738630f, 
    0.02224136f, -0.13012049f, -0.04758994f, 0.11821187f, -0.83702004f, 0.24547526f, -0.03147111f, -0.16298653f, 
    0.16566101f, 0.05647366f, -0.04560989f, 0.19623427f, 0.09851662f, -0.16199872f, 0.03757849f, 0.05860764f, 
    -0.39742082f, -0.08737151f, -0.01757343f, 0.19455150f, 0.08658442f, -0.03024061f, -0.11971618f, -0.01037239f, 
    -0.00623760f, 0.13317463f, -0.00350228f, -0.15048839f, -0.00082738f, -0.17062856f, -0.08782285f, -0.30782622f, 
    -0.00331453f, 0.03965637f, 0.14479743f, -0.17469497f, 0.10691716f, 0.23387361f, 0.10012165f, -0.09362207f, 
    -0.00567161f, -0.02822731f, -0.05324743f, -0.02879765f, 0.02607131f, -0.03093420f, 0.00885083f, 0.02395287f, 
    -0.00947818f, -0.06300028f, -0.01975346f, -0.01046008f, -0.02543087f, -0.04182937f, 0.01683057f, 0.02096074f, 
    -0.01065039f, 0.01953829f, 0.04307795f, 0.04042393f, -0.01508202f, 0.03015560f, -0.05218941f, -0.04847188f, 
    -0.04683188f, 0.05092800f, -0.03277925f, 0.04390384f, -0.03183074f, 0.03728336f, -0.05982482f, -0.00943982f, 
    0.01538879f, -0.01286454f, 0.00098227f, 0.00874166f, 0.02977879f, -0.02886767f, 0.03620945f, -0.03052858f, 
    0.04182395f, 0.03687224f, -0.05916626f, -0.02074980f, -0.02930797f, 0.03390042f, -0.04210700f, 0.03876588f, 
    -0.00829396f, -0.01928373f, -0.02156569f, -0.05658856f, -0.03150040f, -0.04965724f, 0.02588924f, -0.00004381f, 
    -0.01573820f, -0.04885811f, -0.01777367f, -0.03826139f, -0.04670177f, -0.04134330f, -0.04838351f, -0.01321807f, 
    0.02202977f, 0.02351915f, -0.03085190f, -0.05156652f, -0.01553705f, 0.03983592f, -0.05075893f, -0.00644629f, 
    -0.04523337f, -0.02826984f, 0.00951929f, -0.01957925f, 0.03100832f, -0.01830485f, 0.00674635f, 0.03835832f, 
    0.02879566f, -0.00203908f, -0.02645727f, -0.06396905f, -0.03843886f, 0.00527261f, 0.04520936f, 0.00305004f, 
    0.03116836f, -0.01631136f, -0.05785639f, -0.02599402f, -0.02476703f, 0.03144383f, 0.03053794f, 0.01861100f, 
    0.02552695f, -0.05509948f, 0.01065355f, 0.03094248f, -0.01800491f, -0.02657389f, 0.03120602f, 0.01018926f, 
    -0.02290408f, 0.00609157f, 0.02640890f, -0.01518904f, -0.00952658f, 0.00829548f, 0.03436648f, -0.04047652f, 
    0.00439847f, 0.02410963f, 0.00675131f, 0.04528724f, -0.03396906f, 0.02256227f, -0.04507737f, -0.04039709f, 
    -0.00365614f, -0.01900648f, 0.00340555f, -0.02714478f, -0.01733368f, -0.01485606f, 0.01351900f, -0.04469571f, 
    -0.00655917f, -0.05288872f, 0.00711587f, 0.04320700f, -0.05737426f, -0.04735641f, 0.04232099f, -0.02775493f, 
    -0.01165693f, -0.03813903f, 0.02964042f, -0.02753295f, 0.01945309f, -0.00442171f, 0.03057279f, -0.01774075f, 
    0.02557243f, 0.00983101f, -0.02320549f, -0.03833128f, 0.01282228f, -0.04397829f, -0.05359251f, 0.00024494f, 
    -0.04103938f, -0.05296495f, 0.03957751f, 0.03861604f, 0.05112357f, -0.04931253f, 0.04114235f, -0.03811387f, 
    -0.04134426f, -0.05381555f, -0.00804511f, -0.01024635f, 0.02595187f, 0.01141539f, 0.03055723f, -0.04214837f, 
    -0.03321298f, 0.02536701f, -0.05046693f, -0.00508477f, 0.00083040f, -0.03586990f, -0.01936965f, -0.00913901f, 
    -0.01178983f, -0.00096417f, 0.03321493f, -0.00840309f, -0.00445365f, 0.06320859f, -0.01093494f, 0.01466717f, 
    -0.00622113f, 0.01673633f, -0.03777209f, 0.00280189f, -0.04288443f, -0.01912014f, 0.02571968f, -0.03357360f, 
    0.02713363f, 0.00513568f, 0.06389648f, 0.01735444f, -0.04582905f, -0.03579380f, 0.00247535f, 0.03745311f, 
    0.01985764f, -0.02347225f, -0.05163741f, 0.02890551f, -0.04765331f, -0.01352391f, 0.00763814f, -0.05773853f, 
    -0.05732524f, -0.01384923f, -0.00685041f, -0.06685121f, -0.05612535f, 0.02378163f, -0.01660887f, -0.02116225f, 
    0.04750269f, 0.02694072f, 0.00075844f, 0.04142053f, -0.04540252f, -0.02815250f, 0.02148002f, -0.05331154f, 
    -0.05649216f, -0.02549321f, 0.01050170f, -0.04047000f, 0.02777418f, -0.02571889f, 0.01953069f, -0.03025648f, 
    -0.00709947f, 0.04068989f, -0.00156836f, 0.02406687f, 0.03300448f, -0.00476612f, 0.03614787f, -0.00042811f, 
    -0.04585612f, -0.04076647f, 0.00823134f, 0.04338469f, -0.01259839f, -0.05832855f, -0.03105929f, 0.02672802f, 
    0.02142151f, 0.03155960f, 0.03520299f, 0.00744880f, -0.04215536f, 0.00661590f, -0.02725825f, 0.02331629f, 
    0.03250658f, -0.01336164f, 0.05204407f, -0.05602590f, -0.00552357f, -0.05711239f, -0.00258119f, 0.02063282f, 
    -0.03357684f, -0.05195098f, 0.02360470f, -0.01585549f, -0.02057638f, -0.01189303f, -0.01092952f, -0.00365030f, 
    -0.03759009f, -0.03839492f, 0.01458241f, 0.03205132f, -0.00331961f, -0.05627369f, -0.05835265f, -0.04887015f, 
    0.03429895f, -0.02609391f, 0.01945948f, 0.04086688f, 0.03811207f, 0.03081349f, -0.04881990f, 0.00585943f, 
    0.03829055f, -0.00892242f, -0.03813592f, -0.02421102f, 0.05499168f, 0.01444206f, 0.02231966f, -0.01187617f, 
    0.01647339f, -0.01713489f, 0.01726608f, -0.00477979f, 0.03050655f, -0.03558327f, 0.00845031f, 0.03129110f, 
    0.03826319f, -0.04777515f, -0.00741914f, -0.01803289f, -0.03046876f, -0.04375879f, -0.00366462f, 0.02220691f, 
    -0.00680675f, 0.01463101f, 0.01712555f, -0.02786834f, -0.06282969f, -0.04150845f, -0.01013870f, -0.02481346f, 
    0.02605334f, -0.04573144f, 0.03194128f, 0.01123309f, -0.04557887f, 0.00973893f, 0.01498294f, 0.00987763f, 
    0.04205971f, 0.01551554f, -0.04353168f, -0.03435453f, -0.00626448f, -0.00915435f, -0.03796724f, 0.03609738f, 
    -0.04400234f, 0.01192028f, 0.05535922f, -0.03487346f, 0.01002616f, 0.01937708f, -0.04288676f, 0.01384968f, 
    -0.03318711f, -0.03806947f, 0.01770915f, 0.04457952f, -0.01950348f, -0.02725805f, 0.02677713f, -0.03147212f, 
    -0.01779144f, 0.05280848f, 0.04654613f, -0.00072402f, -0.03453339f, -0.02091098f, 0.03495670f, 0.03525580f, 
    -0.02800483f, -0.02153130f, -0.00152891f, -0.02546603f, 0.00280905f, 0.00533685f, 0.00445090f, 0.00052133f, 
    -0.02209369f, 0.01607214f, -0.03463457f, 0.02500901f, 0.02816821f, 0.03073787f, 0.02785620f, -0.02838575f, 
    0.00066653f, 0.03681901f, -0.04807179f, -0.04316161f, -0.01505639f, 0.03246655f, -0.06061725f, -0.00366213f, 
    -0.16683982f, -0.13710050f, -0.03714686f, 0.06004009f, -0.10425363f, 0.13899508f, -0.16660297f, 0.05190187f, 
    -0.08103934f, 0.09530441f, 0.01839032f, -0.06610385f, 0.45404017f, 0.10634102f, -0.14403352f, -0.17244546f, 
    0.00313202f, 0.03311503f, -0.00648614f, 0.11811663f, -0.10524513f, -0.02664056f, 0.11555646f, -0.02851884f, 
    0.08053881f, 0.11837466f, 0.21614030f, -0.01445238f, 0.04352983f, 0.00277314f, 0.11186811f, 0.01052194f, 
    0.02620932f, 0.04659558f, 0.01137493f, -0.10708611f, -0.00750136f, -0.09426079f, -0.01424306f, 0.17571051f, 
    -0.07340192f, 0.01053183f, -0.09028389f, 0.04123881f, 0.04553811f, -0.05862939f, -0.01950834f, 0.07412812f, 
    -0.18349011f, 0.19985421f, 0.19244589f, 0.04084069f, 0.11437947f, 0.03631341f, 0.01363022f, -0.05041995f, 
    0.01491937f, 0.06967319f, 0.03555284f, 0.00834831f, 0.04835422f, -0.02706190f, -0.10311222f, -0.03022826f, 
    0.01937385f, -0.06443021f, -0.03590936f, -0.02758210f, -0.10228804f, -0.08778235f, -0.04285868f, 0.13559948f, 
    -0.19019532f, -0.22001114f, -0.19798383f, 0.22665182f, -0.01457431f, -0.20845191f, 0.02582590f, -0.01785184f, 
    0.14691709f, -0.14138672f, -0.07632416f, -0.06323297f, 0.54528850f, 0.41399667f, 0.10513543f, -0.02835041f, 
    0.11629797f, -0.04948967f, 0.01201665f, 0.05312827f, -0.10858876f, 0.01421313f, 0.14308853f, -0.00502477f, 
    0.09597547f, -0.09137331f, 0.00650068f, 0.18002880f, 0.04889200f, 0.05337719f, -0.09856179f, 0.01820915f, 
    -0.00463741f, 0.00506267f, 0.09782356f, -0.06004487f, 0.01188536f, -0.23035434f, 0.07399925f, -0.09789420f, 
    0.05873799f, -0.01868329f, 0.01882874f, -0.16333205f, 0.06115860f, 0.10390487f, 0.05834584f, -0.08618197f, 
    0.47984612f, 0.37164801f, -0.01703829f, -0.04408541f, 0.07071206f, -0.00919037f, 0.09580342f, 0.03775966f, 
    -0.08242432f, -0.09103999f, -0.03815939f, 0.06223615f, 0.04812792f, -0.08284598f, -0.07803466f, -0.15466526f, 
    0.11484218f, -0.03075326f, 0.06695980f, 0.03694091f, 0.05595020f, -0.00767231f, 0.02896179f, 0.06198258f, 
    0.35461652f, -0.15823196f, -0.04733888f, -0.14308532f, 0.07554357f, 0.10998774f, 0.00220315f, 0.08008440f, 
    0.04823430f, 0.13096641f, -0.00485140f, 0.13831942f, -0.07973140f, -0.38005266f, -0.05879115f, 0.18581647f, 
    0.06545004f, 0.06938017f, 0.17902656f, -0.09576074f, 0.04725998f, 0.06993555f, 0.03138868f, 0.10552166f, 
    -0.16559924f, 0.05147811f, -0.07207756f, -0.09107639f, -0.02680483f, -0.00384744f, -0.07173419f, -0.02834669f, 
    -0.08558967f, 0.14243370f, 0.00462453f, -0.04179815f, 0.80783868f, 0.07484866f, -0.12380575f, -0.12977591f, 
    0.06667313f, -0.03855910f, 0.00301664f, -0.01085788f, 0.01568075f, 0.05970987f, 0.03675649f, 0.08433890f, 
    -0.01662661f, -0.26768059f, 0.05556869f, 0.01158696f, -0.03811576f, 0.06606088f, -0.03199818f, -0.03024460f, 
    -0.06986407f, 0.14430906f, 0.08295382f, 0.20227745f, -0.01044727f, -0.19314063f, -0.08924811f, -0.05529886f, 
    0.13132551f, -0.04261397f, 0.01209809f, 0.20814498f, -0.06136896f, -0.03338150f, -0.07766065f, 0.24414332f, 
    0.12955242f, -0.23572724f, -0.05743389f, 0.00028818f, 0.24248672f, -0.00368755f, -0.02061491f, -0.02346421f, 
    0.03833980f, 0.03677187f, 0.05301652f, -0.05031250f, -0.11524548f, 0.00295637f, 0.16086292f, -0.06165332f, 
    0.04875733f, 0.15737909f, -0.02264725f, 0.20032729f, 0.09514888f, 0.04303612f, -0.12278917f, 0.00177883f, 
    0.14790942f, 0.30190164f, 0.15809362f, 0.03300231f, 0.20370074f, -0.00186497f, 0.05867739f, 0.06910259f, 
    0.08617835f, -0.10185195f, 0.04789523f, 0.14280677f, 0.25792724f, 0.39720371f, 0.02287754f, -0.14449166f, 
    -0.10093596f, 0.01677599f, -0.03975502f, -0.05954557f, 0.02472955f, -0.04897292f, -0.14771083f, 0.03610393f, 
    0.10899302f, 0.07054733f, -0.12968032f, 0.20655644f, 0.02249380f, 0.06236058f, 0.12621850f, 0.02807053f, 
    -0.01074548f, 0.03347164f, 0.00729477f, -0.05774616f, 0.10037231f, -0.14692935f, -0.02882015f, 0.00217042f, 
    -0.11022274f, -0.12730232f, 0.04033465f, -0.05132888f, -0.01690164f, 0.02636326f, -0.07960884f, -0.08889805f, 
    0.31736737f, -0.00321626f, -0.32519615f, 0.04816772f, -0.16105956f, -0.08690456f, -0.01690779f, -0.02813602f, 
    0.01916056f, 0.03844678f, 0.06276081f, -0.08827259f, -0.36036679f, 0.09619590f, -0.17576027f, -0.20718412f, 
    0.06790187f, -0.07277521f, 0.05764356f, 0.09416921f, 0.04508758f, -0.00310488f, 0.09482934f, -0.01005151f, 
    0.23209509f, 0.33281457f, 0.14681017f, 0.17904995f, 0.12164167f, -0.02304007f, 0.06054367f, -0.06166436f, 
    0.08558543f, -0.00371803f, 0.02967020f, 0.04007166f, -0.02642846f, -0.00932960f, -0.08215385f, -0.02481016f, 
    0.02349352f, -0.10506303f, -0.06137745f, -0.06286552f, 0.10221822f, 0.01352601f, -0.05472071f, 0.06665661f, 
    0.29410446f, -0.19809130f, 0.13784467f, -0.14976653f, 0.03083853f, 0.05277582f, -0.01958601f, -0.04789151f, 
    0.02850583f, 0.07109857f, -0.01792487f, -0.07934832f, 0.46881270f, -0.08025324f, 0.08443331f, 0.17150845f, 
    0.03968119f, 0.11300752f, 0.00092772f, -0.15170701f, -0.09948938f, 0.01401483f, 0.04556722f, 0.00467536f, 
    -0.35197559f, 0.08413106f, -0.05833733f, 0.00812599f, 0.01609988f, 0.04564661f, -0.02827313f, 0.04918441f, 
    -0.02236715f, -0.06169279f, -0.09422956f, 0.05583925f, -0.23157983f, -0.06510069f, 0.15126924f, 0.13968895f, 
    -0.06757257f, 0.04343413f, 0.00733282f, 0.02544152f, 0.05630124f, -0.06143406f, -0.08199167f, -0.12569909f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00854525f, -0.02622386f, 0.05709827f, 0.07118387f, -0.01136149f, 0.03764779f, -0.04390174f, -0.07784456f, 
    0.13330738f, 0.04741041f, -0.03158493f, 0.08997071f, 0.07119479f, -0.05739430f, -0.00910342f, 0.00363749f, 
    0.02040929f, 0.02458607f, -0.00522769f, 0.03750595f, 0.02160021f, -0.04540326f, 0.12739666f, -0.05955257f, 
    -0.03124158f, 0.03744822f, 0.03309867f, -0.00738394f, -0.04789168f, 0.04321724f, -0.02610060f, 0.08767552f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15910192f, 0.14975931f, -0.38985825f, 0.12750921f, -0.12540278f, 0.03466579f, -0.01801056f, 0.31536251f, 
    -0.65211219f, 0.07450730f, 0.12983707f, -0.24578962f, -0.43584925f, 0.29217178f, -0.14094335f, -0.15578935f, 
    0.04028356f, -0.76338279f, -0.11670659f, -0.03664648f, 0.15548572f, 0.01945944f, 0.00439859f, 0.04407991f, 
    -0.11456412f, 0.05794076f, -0.02778780f, -0.15654901f, 0.03121109f, 0.52652121f, 0.05710408f, -0.06763206f, 
    -0.16441573f, -0.14263020f, -0.36656359f, 0.39801005f, 0.15741596f, -0.11789905f, -0.29362881f, -0.09866910f, 
    0.37790555f, 0.33932084f, -0.15594403f, -0.23608856f, -0.33415735f, 0.11498616f, 0.16956557f, -0.00005396f, 
    0.05715256f, 0.25414985f, 0.32804778f, 0.10384291f, 0.01125388f, -0.09424432f, -0.13342385f, -0.00725309f, 
    -0.02982728f, -0.19936183f, -0.15112607f, -0.10785988f, -0.09397592f, -0.34700117f, 0.08586231f, 0.20390725f, 
    0.05091843f, 0.12046878f, 0.22985573f, -0.18280964f, -0.05884077f, 0.15146720f, -0.25411871f, 0.47060966f, 
    -0.34859332f, 0.23741394f, -0.00694314f, -0.45353797f, 0.01971197f, -0.49247223f, -0.02373902f, 0.16203737f, 
    0.01460066f, -0.63082790f, 0.04698526f, -0.08366499f, 0.06029197f, -0.01550360f, 0.10404992f, 0.13360684f, 
    -0.12163831f, -0.74562681f, 0.13130635f, 0.01032167f, 0.15745446f, -0.46755642f, -0.14117523f, 0.29958764f, 
    -0.07615755f, 0.05639163f, -0.04997484f, -0.86864227f, 0.02963636f, -0.03493623f, 0.14629130f, -0.33765593f, 
    -0.11874721f, 0.25906932f, 0.14177459f, -0.53204292f, -0.12222886f, 0.50756902f, -0.06803790f, -0.01386082f, 
    0.06207584f, -0.16755839f, 0.17439106f, -0.13460185f, 0.01701252f, 0.04672766f, 0.04764795f, 0.08210607f, 
    -0.04025652f, 0.50037134f, 0.16397677f, 0.05068906f, -0.08773585f, 0.14480416f, -0.01036118f, -0.57271004f, 
    0.12476657f, 0.13189484f, 0.32468104f, -0.03163497f, -0.10548511f, 0.09118921f, -0.31350231f, -0.17667095f, 
    0.01742924f, -0.27878907f, -0.14832628f, 0.13908258f, 0.11024127f, -0.47288677f, 0.12955840f, -0.11162951f, 
    0.07933026f, 0.31093067f, 0.33152491f, -0.10984385f, 0.06172874f, 0.14857000f, -0.02354485f, 0.09076750f, 
    -0.07115638f, 0.01191706f, -0.09195575f, 0.09834939f, 0.07885338f, 0.39429438f, 0.06301236f, -0.46108988f, 
    0.16020516f, -0.12955588f, 0.06694161f, 0.26004544f, -0.11016449f, -0.02844759f, 0.32227743f, -0.36135048f, 
    -0.27766609f, 0.25883999f, 0.06051061f, 0.42713258f, -0.35168186f, -0.19113867f, 0.15820479f, -0.11370708f, 
    0.04859372f, -0.59414744f, -0.48355943f, -0.08110600f, 0.10852227f, 0.09099792f, -0.24912842f, -0.10719756f, 
    -0.15701003f, 0.17783532f, -0.15015009f, 0.04904059f, -0.04429816f, -0.13879080f, 0.00658305f, 0.15604778f, 
    0.02498886f, -0.11699813f, 0.16031329f, 0.24485648f, -0.06435987f, -0.07143003f, -0.37488964f, 0.17868675f, 
    0.13980410f, -0.67372280f, -0.10790700f, -0.08934998f, 0.48344481f, -0.31372580f, 0.15247957f, -0.15438722f, 
    -0.05911159f, -0.43977758f, -0.48177865f, -0.13108887f, 0.05825049f, 0.10930809f, -0.31709793f, 0.15440971f, 
    -0.15358450f, 0.25243536f, -0.12694831f, 0.06872170f, -0.01869852f, -0.66980177f, 0.12695773f, 0.33545902f, 
    -0.16005616f, 0.11110950f, 0.24407513f, -0.18979223f, -0.09456202f, -0.03732367f, 0.37683669f, -0.17585889f, 
    -0.30857357f, -0.39790916f, -0.10512983f, -0.45212936f, 0.36072376f, 0.09217203f, -0.14111343f, 0.12718025f, 
    0.07760599f, 0.49980494f, -0.33030722f, -0.14590876f, 0.15062073f, 0.02565175f, -0.22374797f, -0.03289039f, 
    -0.16996884f, -0.04731657f, 0.08507595f, -0.16938756f, -0.13741304f, -0.09793269f, -0.13300486f, -0.23597535f, 
    -0.10067989f, -0.12886834f, -0.47439855f, -0.16726395f, -0.08124078f, 0.09764659f, 0.39017206f, 0.17699166f, 
    0.46709687f, -0.10084193f, 0.02470377f, 0.48794818f, -0.18835725f, -0.13757505f, -0.13352022f, -0.03581182f, 
    -0.12797852f, -0.46646523f, 0.26964393f, 0.05583055f, -0.09107795f, -0.16412540f, -0.22644956f, 0.11776536f, 
    -0.02033780f, -0.59385163f, -0.01123732f, 0.09242938f, -0.08254664f, -0.63175064f, 0.04925081f, -0.20337975f, 
    0.00048171f, 0.02979140f, 0.39437929f, 0.12945423f, -0.05996041f, 0.14547408f, -0.68480116f, -0.05144440f, 
    -0.27866858f, -0.85096633f, 0.11631510f, 0.23064618f, -0.34600171f, 0.53183758f, 0.01854248f, -0.08680977f, 
    -0.02013995f, 0.39070538f, -0.09508459f, -0.06273130f, 0.10537907f, -0.06059885f, 0.19555786f, 0.01680377f, 
    0.07648185f, -0.22393833f, -0.11978198f, -0.01249234f, -0.12197379f, -0.57954901f, -0.16461053f, -0.08303507f, 
    0.11157195f, -0.02118946f, -0.06282809f, -0.03261172f, -0.14590423f, -0.03384843f, 0.04813808f, -0.30700523f, 
    0.59698600f, 0.26646444f, 0.11586426f, -0.36038619f, 0.26483023f, -0.40395716f, -0.07314008f, -0.14954253f, 
    -0.07863771f, -0.28958085f, -0.63062972f, -0.12963429f, -0.02071254f, -0.12133634f, 0.45218107f, -0.17269927f, 
    0.01815413f, -0.25847158f, -0.07890683f, 0.14461288f, 0.16268246f, -0.10970714f, -0.16854291f, -0.43664888f, 
    0.16158149f, 0.14355782f, -0.36683944f, -0.39136681f, -0.13705748f, -0.11424088f, -0.22872111f, -0.43326318f, 
    -0.52030736f, -0.43748111f, 0.13245825f, 0.05042057f, 0.40328965f, -0.00282470f, -0.02417427f, -0.14957671f, 
    0.06928131f, -0.62684667f, 0.35999608f, -0.14615342f, 0.02411339f, -0.03414633f, 0.26091313f, 0.01889668f, 
    0.07378872f, 0.23468049f, -0.03767150f, -0.12819116f, 0.11121453f, -0.29108658f, 0.11344412f, 0.56165701f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03748841f, -0.15856461f, -0.09628724f, 0.08744031f, -0.10340784f, -0.10882792f, 0.22179952f, -0.22381814f, 
    0.03616559f, 0.14236358f, 0.16119249f, -0.00702419f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
