#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.38112316f, -0.35520262f, -0.79421759f, -0.86892128f, -0.12431865f, 0.28532919f, 0.20622110f, 0.50008750f, 
    -0.00543753f, 0.09991018f, -0.03864184f, -0.18285364f, -0.41179323f, -0.09312841f, 0.09635025f, -0.24103312f, 
    -0.05978655f, 0.15563299f, -0.24746867f, -0.34952998f, -0.07452250f, -0.08651207f, -0.23940669f, 0.19394049f, 
    0.02304428f, -0.43300992f, -0.55045998f, -0.53506356f, -0.58854139f, -0.68957186f, 0.62500823f, 0.30269450f, 
    0.11260982f, -0.24060953f, 0.28575373f, -0.04907658f, -0.01834979f, -0.03641755f, -0.14885995f, -0.17621396f, 
    0.03632350f, 0.04557714f, 0.04391248f, -0.01325988f, -0.14598469f, -0.33769143f, -0.13470890f, 0.15288478f, 
    -0.27053255f, -0.18206157f, -0.08945788f, -0.30480185f, -0.34802848f, 0.24327922f, -0.30628595f, 0.41685587f, 
    0.08437137f, -0.02183246f, -0.43393886f, -0.17688784f, -0.29942340f, 0.12089953f, 0.35521057f, 0.13870984f, 
    0.21781048f, -0.21260768f, 0.10998163f, -0.34064552f, -0.33046672f, -0.13482979f, 0.14972843f, 0.05751195f, 
    0.22149964f, 0.14196910f, 0.23169112f, 0.85389858f, 0.65303403f, 0.28014052f, 0.15665133f, -0.20246282f, 
    0.05552137f, -0.39510646f, -0.36841440f, -0.41198769f, -0.32711577f, -0.19489412f, 0.03551076f, 0.10726345f, 
    0.16404583f, -0.10969555f, -0.00294427f, 0.30350080f, 0.14613564f, -0.29831150f, 0.15563898f, -0.07371289f, 
    -0.26273122f, 0.04475816f, -0.13455273f, 0.25273576f, -0.84037334f, -0.32450977f, -0.75063902f, -0.00759325f, 
    0.21319637f, 0.49270543f, 0.14386749f, 0.14652257f, 0.56857312f, 0.46995175f, 0.16714615f, 0.12810293f, 
    0.11265118f, 0.29108852f, 0.19335449f, -0.29318753f, 0.07194690f, -0.04479448f, -0.28568426f, -0.27616513f, 
    -0.09964639f, 0.11161769f, 0.21815528f, -0.04061788f, 0.23586620f, -0.43976676f, 0.43947917f, 0.41270092f, 
    -0.30726525f, 0.23248999f, -0.03333176f, 0.06216387f, 0.12984648f, -0.01108654f, -0.01708648f, 0.28757992f, 
    -0.64740646f, -0.27459279f, 0.18556598f, 0.28060424f, -0.31754357f, 0.01514995f, -0.00911522f, 0.24060109f, 
    0.11274909f, 0.02564032f, 0.45497522f, -0.32648620f, -0.17182806f, -0.20568971f, -0.37490478f, 0.83721185f, 
    -0.42337689f, -0.20522763f, 0.26341581f, -0.16482097f, 0.34738979f, 0.09677500f, -0.11818276f, 0.19986577f, 
    0.50300139f, -0.07362486f, -0.18092261f, -0.00673325f, -0.26492187f, 0.40660489f, -0.13251479f, -0.02019944f, 
    -0.12601271f, -0.17795233f, 0.15245315f, -0.04078090f, 0.14546533f, -0.01447660f, -0.27729571f, 0.25916222f, 
    0.27990326f, 0.21267071f, -0.69561422f, -1.00532520f, 0.21354918f, 0.51682764f, 0.12786534f, 0.05966990f, 
    -0.18139572f, -0.09220718f, -0.23466137f, 0.10755446f, 0.16742466f, 0.09797273f, -0.20831044f, 0.09374210f, 
    -0.23025365f, -0.33002326f, 0.27922189f, 0.06396778f, -0.03782205f, -0.17561893f, 0.26938963f, -0.05549680f, 
    -0.40804401f, -0.26098323f, 0.02354078f, 0.31897354f, -0.09643455f, -0.62992644f, -0.57415360f, -0.41054985f, 
    0.01113678f, -0.22197802f, 0.45596275f, -0.11753988f, 0.11871488f, 0.06945005f, -0.19887899f, 0.04226959f, 
    -0.01280073f, 0.26454118f, -0.36204889f, -0.26849619f, -0.02361818f, -0.01560463f, -0.20133778f, 0.22067086f, 
    0.27726737f, 0.29893154f, -0.16319817f, -0.58772004f, -0.77159148f, -0.65055019f, 0.13858946f, 0.31615138f, 
    0.21611798f, -0.11730703f, 0.07149076f, 0.14932249f, 0.54374617f, 0.33565861f, 0.16143806f, -0.36861917f, 
    -0.24277693f, -0.05924574f, 0.08201453f, -0.26245072f, -0.01172601f, 0.11242256f, -0.27022311f, -0.17637086f, 
    0.22924149f, 0.11930332f, 0.69201022f, 0.10011976f, 0.29999769f, 0.15336849f, -0.26851645f, -0.01096688f, 
    0.06563038f, 0.05228931f, 0.18108734f, 0.01818000f, 0.04416851f, -0.42067426f, -0.18668389f, 0.26830128f, 
    -0.24025565f, 0.12840807f, 0.10482801f, -0.01048966f, 0.12669529f, -0.43159357f, -0.03143680f, -0.23962812f, 
    -0.43689865f, -0.32010001f, -0.34131566f, 0.49972630f, -0.27948880f, -0.16975510f, 0.21932222f, 0.19306120f, 
    0.06416091f, -0.30464301f, -0.02614133f, -0.04469097f, -0.24150240f, -0.18888301f, 0.20695843f, -0.15644592f, 
    0.59745193f, -0.21522631f, -0.00832171f, 0.02362547f, -0.08572907f, 0.10501460f, 0.24185701f, -0.06799766f, 
    0.38736910f, 0.32648554f, 0.19189747f, 0.25281012f, -0.12810823f, 0.36817458f, -0.33942366f, -0.47505176f, 
    -0.12375895f, 0.14869352f, -0.07433482f, 0.12312754f, 0.29305682f, 0.37608796f, -0.35801527f, 0.03643351f, 
    0.19257633f, 0.00770032f, -0.28893098f, -0.07127710f, -0.19629472f, -0.06054163f, -0.26219523f, -0.08256852f, 
    0.19950281f, 0.59580690f, 0.24600899f, 0.22046310f, 0.12158082f, -0.94237274f, 0.17617752f, 0.26460567f, 
    -0.43073130f, 0.53328341f, -0.14296730f, -0.59083498f, 0.24284123f, -0.13881874f, -0.06820770f, -0.22909141f, 
    -0.32956085f, -0.21996339f, -0.11419614f, 0.24116921f, 0.11673844f, -0.29350135f, -0.07911279f, 0.14146206f, 
    -0.01687104f, -0.33103478f, 0.30958661f, 0.01724407f, -0.09225110f, -0.30741432f, 0.10106089f, 0.96891338f, 
    0.26893583f, -0.67364973f, -0.33100566f, 0.03108854f, -0.56552571f, -0.35215127f, -0.44689542f, -0.48249823f, 
    0.08560568f, 0.20130898f, -0.10116823f, 0.55702859f, -0.03308003f, 0.15758272f, -0.39213052f, -0.23034018f, 
    -0.04511699f, -0.20224726f, 0.35440877f, -0.00382443f, -0.10293530f, -0.02149124f, -0.00867411f, -0.24346201f, 
    -0.36599010f, -0.07374693f, 0.56386316f, 0.33933753f, -0.04825307f, -0.28445503f, 0.10089980f, -0.04288709f, 
    -0.08527831f, 0.09796522f, -0.23361343f, -0.09212551f, 0.11424114f, 0.08500228f, -0.15918604f, -0.25618830f, 
    0.37680551f, -0.15319213f, 0.09050954f, -0.15040155f, 0.06448705f, 0.26453272f, 0.16207536f, 0.21316671f, 
    0.47842935f, -0.47738746f, -0.34214878f, 0.33999839f, 0.13698554f, 0.31878015f, 0.24013533f, 0.28356713f, 
    0.27838194f, 0.06704403f, 0.17984778f, 0.17584619f, 0.04356069f, -0.19218317f, 0.24647427f, -0.00686913f, 
    -0.10631792f, -0.21594553f, -0.04855744f, 0.20866942f, -0.00240828f, -0.18079792f, 0.16521558f, 0.38501382f, 
    -0.37436751f, -1.02862668f, -0.46661848f, -0.29590645f, 0.96154112f, 0.21129699f, 0.61485046f, 0.73730326f, 
    -0.30293795f, -0.29980272f, -0.23779725f, -0.05914539f, -0.02754164f, -0.23616920f, 0.51927203f, -0.25434271f, 
    -0.05629531f, -0.03450435f, -0.00965579f, 0.27355257f, -0.05310818f, -0.03118035f, -0.10433470f, 0.16614325f, 
    0.17499045f, -0.18227249f, -0.11216395f, -0.60466290f, -0.21567787f, -0.42263830f, -0.00212758f, 0.31440729f, 
    0.34130913f, -0.38643667f, -0.51387364f, -0.41649029f, 0.21343677f, 0.43015590f, 0.14375807f, 0.12773180f, 
    0.27622530f, 0.05630727f, -0.13033998f, -0.16217096f, 0.11437114f, -0.25466958f, -0.05766682f, -0.24912529f, 
    -0.19507976f, 0.02042453f, -0.23640057f, -0.25064063f, -0.35064757f, -0.35643095f, -0.05606856f, -0.10528906f, 
    0.02784142f, 0.17984901f, 0.06530388f, 0.83471012f, -0.24680941f, -0.14932886f, -0.18977229f, 0.11636784f, 
    -0.21313542f, 0.26072642f, -0.09493087f, -0.06039820f, 0.01315323f, 0.10019074f, 0.09953268f, 0.41466379f, 
    0.40552855f, 0.08285845f, -0.26237094f, 0.07394703f, 0.10605565f, -0.07031252f, -0.57262385f, -0.27159232f, 
    -0.14404052f, -0.20291610f, -0.23013960f, -0.14767390f, -0.12526196f, 0.07313760f, 0.08058872f, -0.40690491f, 
    -0.16918503f, 0.13341166f, 0.00097424f, 0.19868343f, 0.19025305f, 0.06854863f, -0.37089020f, -0.35441747f, 
    -0.41901520f, -0.41523302f, 0.10437986f, -0.21396977f, -0.09123539f, -0.26127675f, -0.04364271f, 0.06049902f, 
    -0.38673991f, -0.48472786f, -0.06790756f, -0.16825531f, -0.22592999f, -0.12909850f, -0.36793503f, 0.07944282f, 
    -0.13955374f, -0.11722142f, -0.24886385f, 0.14251611f, -0.07338356f, 0.05367320f, -0.11913081f, 0.04500094f, 
    -0.17608677f, 0.11835452f, 0.37368372f, 0.25860742f, 0.14444020f, 0.25357622f, 0.02445133f, 0.03962040f, 
    -0.29957488f, -0.36818364f, 0.17516549f, -0.28756529f, 0.07808559f, 0.42670166f, -0.19210626f, -0.21998961f, 
    0.43914202f, -0.07301064f, 0.32446715f, 0.01731103f, -0.40066421f, -0.07874694f, -0.12891249f, -0.41848916f, 
    0.03243521f, -0.26269734f, 0.31674269f, -0.16844557f, 0.14607552f, 0.12022141f, 0.18075739f, -0.70274603f, 
    -0.45554933f, -0.10652853f, 0.23097995f, 0.42406327f, 0.17113332f, 0.72905654f, 0.57347000f, 0.26517293f, 
    -0.22828728f, -0.02159713f, 0.39330658f, -0.04924507f, 0.40771464f, -0.47220480f, 0.19335680f, -0.03777436f, 
    0.04987243f, -0.36329514f, -0.14429791f, 0.11156344f, -0.18450463f, -0.04207985f, -0.03832676f, 0.15432814f, 
    0.70970559f, 0.90709841f, -0.32036906f, -0.52353793f, 0.06644841f, -0.18256921f, 0.11676041f, 0.12418925f, 
    -0.26138481f, 0.19407906f, -0.36075026f, 0.38422656f, -0.13676617f, -0.06324527f, -0.03009040f, 0.01977970f, 
    0.12697676f, -0.01626124f, -0.09065759f, -0.01695278f, 0.00453430f, 0.10716154f, 0.00607215f, 0.01914124f, 
    -0.04221870f, -1.01000559f, -0.04806612f, 0.74951923f, 0.41649047f, 0.08173045f, 0.46552148f, -0.37158415f, 
    -0.49240160f, 0.07905106f, 0.08508976f, 0.09818775f, -0.20518942f, -0.14688219f, 0.66756052f, -0.47183850f, 
    0.20879175f, 0.03836088f, 0.10232055f, -0.27262798f, 0.15758878f, -0.05933729f, -0.02402976f, -0.02861879f, 
    -0.05721501f, 0.08738904f, -0.07971559f, -0.27242574f, 0.12269065f, 0.39089578f, -0.58545834f, -0.45634562f, 
    -0.18071970f, -0.43927857f, -0.49740025f, -0.68729252f, 0.26956481f, 0.13379075f, -0.08497950f, -0.18025355f, 
    0.04396022f, 0.07408500f, 0.06713527f, 0.31040370f, 0.09959934f, -0.05094742f, -0.18039156f, 0.05079486f, 
    -0.27961975f, 0.01725448f, 0.26525715f, 0.73997414f, 0.33490145f, -0.31665024f, -0.17832531f, 0.37457076f, 
    -0.17587654f, 0.51073462f, -0.31857392f, 0.03596996f, -0.03795008f, -0.37389585f, 0.33822882f, 0.03449558f, 
    -0.07864458f, 0.03854933f, 0.06322479f, -0.37360322f, -0.01940966f, 0.17257635f, -0.06176623f, 0.03914631f, 
    -0.01588121f, 0.40300629f, -0.15333530f, -0.02424752f, -0.56357461f, -0.19571255f, -0.15531050f, -0.30362931f, 
    -0.00718714f, 0.34830424f, -0.16939476f, -0.52931619f, -0.57265884f, -0.15016249f, -0.23436584f, -0.37348333f, 
    0.05399899f, -0.52412403f, 0.05451895f, 0.05757915f, -0.59589106f, -0.26543614f, -0.13323595f, 0.25062883f, 
    0.11674210f, -0.13716112f, -0.31887609f, -0.03166578f, -0.29780245f, -0.80386674f, -0.71885777f, 0.04182490f, 
    0.71327466f, 0.38034210f, -0.13212705f, -0.61772478f, 0.00863782f, 0.48678359f, 0.35970202f, -0.10394059f, 
    0.00607223f, -0.34922659f, 0.02871702f, 0.07964912f, 0.13869095f, -0.05761771f, 0.06704078f, -0.05232285f, 
    -0.08889811f, -0.15386765f, -0.07808915f, -0.07952352f, -0.21860106f, -0.05304388f, 0.64564592f, -0.37507716f, 
    -0.30409881f, -0.22717756f, -0.19882166f, -0.23097846f, -0.21833596f, -0.18691117f, 0.16145632f, 0.06656168f, 
    0.19740024f, 0.37848157f, 0.19226362f, 0.01881777f, -0.13000476f, -0.01530861f, -0.26838905f, 0.25712645f, 
    0.32995605f, -0.11472622f, -0.18279687f, -0.23595786f, -0.18981087f, -0.31074303f, -0.41678447f, 0.19311287f, 
    -0.40824711f, 0.36830828f, 0.48158416f, 0.36229631f, -0.42224255f, 0.22910918f, 0.28465834f, 0.36678460f, 
    0.46977428f, 0.08475551f, -0.16843866f, -0.03505830f, 0.25127280f, 0.40020251f, -0.32749629f, -0.29307604f, 
    -0.05789509f, -0.27466664f, -0.10539321f, -0.10267895f, -0.17816310f, 0.11718564f, 0.15573421f, 0.28512907f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14634266f, 0.17475064f, 0.23338145f, 0.24013726f, 0.13634653f, -0.02696212f, 0.35475364f, 0.23789541f, 
    0.21333955f, 0.29161134f, 0.00653794f, -0.00029324f, -0.20051154f, 0.06373353f, -0.10805592f, 0.30914554f, 
    -0.04648070f, 0.14802817f, -0.09993505f, -0.15933076f, -0.01042399f, -0.02098295f, 0.31567374f, 0.12740655f, 
    0.19661587f, -0.05581811f, 0.20067026f, 0.21476914f, -0.03429666f, -0.04475256f, -0.16781738f, 0.12431429f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01298498f, 0.02856130f, 0.03572743f, -0.02360844f, -0.01282691f, -0.06216696f, -0.00044131f, -0.05950505f, 
    -0.05832966f, 0.00555207f, 0.02206773f, 0.01152629f, -0.01777083f, 0.01591828f, -0.01249188f, 0.02571807f, 
    0.01302632f, 0.02888673f, -0.04437098f, -0.00201479f, -0.02806929f, -0.01153332f, 0.03579485f, 0.03539420f, 
    -0.02787370f, -0.02049525f, -0.05252542f, -0.01667978f, 0.03698796f, -0.05687128f, 0.00488531f, -0.05709631f, 
    -0.03489213f, -0.06109184f, -0.04090137f, 0.03742199f, 0.01787156f, -0.01483884f, 0.00096981f, 0.03050518f, 
    -0.01478203f, 0.00520374f, -0.02691103f, 0.01807781f, 0.01888837f, -0.01198943f, -0.04449919f, 0.00477875f, 
    -0.04095196f, -0.04542134f, -0.05077526f, -0.04609794f, 0.03007498f, 0.02628607f, 0.02608646f, -0.00969888f, 
    -0.01372722f, 0.00951265f, 0.02070970f, 0.00284185f, -0.02297407f, -0.04745300f, 0.04257992f, -0.00779608f, 
    0.04038135f, 0.03512517f, -0.04439390f, 0.01919032f, -0.05747141f, 0.03151894f, -0.01020626f, -0.00395802f, 
    -0.02960934f, -0.02802992f, -0.00953460f, -0.02865374f, 0.02004745f, -0.03880514f, 0.04076450f, 0.02545580f, 
    -0.04634624f, -0.01684269f, -0.03306544f, 0.02530737f, -0.05608507f, -0.00324527f, -0.03185016f, -0.04472831f, 
    0.02779366f, 0.01066783f, -0.02463917f, -0.05354545f, -0.01056286f, 0.02826953f, 0.04425944f, 0.00684797f, 
    0.02212238f, -0.00816287f, 0.01127825f, -0.01695829f, -0.05319902f, -0.03614697f, 0.02960793f, 0.00601030f, 
    0.02003572f, 0.00214733f, -0.05544410f, 0.03214371f, -0.02436030f, 0.01075733f, 0.00362435f, -0.00666001f, 
    0.01571995f, 0.00891948f, -0.01919905f, 0.01730176f, -0.05517233f, 0.04333935f, 0.00365587f, -0.00029850f, 
    -0.04077850f, 0.03697142f, -0.02477901f, -0.02816016f, -0.02117339f, 0.00198862f, -0.04569275f, -0.02647084f, 
    -0.03873833f, 0.01351069f, 0.03006989f, 0.01277766f, -0.00143220f, -0.03716785f, -0.00764656f, 0.03210960f, 
    -0.01137929f, 0.01221722f, -0.02615165f, 0.00607609f, 0.00046764f, -0.01510280f, -0.02456178f, -0.01778796f, 
    -0.04548517f, 0.03705306f, 0.01875030f, -0.01118224f, -0.04013466f, 0.00184160f, -0.02961967f, -0.01415796f, 
    -0.05774757f, -0.01482865f, 0.02423622f, -0.02957266f, -0.02191865f, 0.00724428f, 0.00504493f, 0.03306829f, 
    0.04057087f, -0.03628140f, -0.03151299f, -0.05363200f, -0.05379535f, -0.01332712f, 0.02686582f, 0.01269508f, 
    -0.00303754f, 0.00267679f, 0.01996368f, 0.02815067f, 0.04389136f, -0.01357817f, -0.02781915f, 0.01027051f, 
    -0.00064956f, 0.03731370f, -0.04440696f, 0.03944266f, -0.02438972f, -0.01202871f, -0.02633744f, -0.01373158f, 
    -0.00535446f, 0.00687390f, 0.03534671f, 0.01247438f, -0.01677397f, -0.05618780f, 0.00289507f, -0.02183126f, 
    0.04301980f, -0.02544562f, 0.00875102f, 0.02590226f, 0.03595662f, 0.02159362f, -0.03401149f, -0.01841610f, 
    0.03210698f, 0.01330905f, 0.02699516f, -0.05006861f, 0.02586586f, -0.04221462f, -0.01302878f, 0.04031519f, 
    0.01178056f, 0.00271483f, -0.02376303f, -0.04893897f, 0.02235290f, -0.01469778f, 0.00493038f, 0.02427006f, 
    0.03508734f, 0.04110458f, -0.02210355f, 0.02475562f, -0.00123765f, -0.05392922f, 0.01553147f, 0.03311673f, 
    0.04138897f, -0.00111317f, -0.00870921f, 0.02095793f, -0.01160991f, -0.04490347f, -0.05029344f, -0.05477255f, 
    -0.03399576f, -0.01696447f, -0.00881743f, -0.03882260f, -0.02795966f, -0.03344338f, -0.00455774f, 0.02276163f, 
    0.03754801f, 0.03515785f, 0.04215880f, 0.01766574f, -0.03737326f, -0.00748510f, -0.04839018f, 0.02381790f, 
    -0.00462739f, 0.00411615f, 0.00551076f, 0.00453161f, -0.05250228f, -0.01380226f, -0.04609964f, 0.02238996f, 
    -0.04021832f, 0.04179075f, -0.02104449f, 0.02636590f, -0.02261289f, -0.01847603f, 0.03802253f, -0.04919393f, 
    -0.03108378f, -0.04167095f, 0.03758403f, 0.00919836f, -0.04677512f, 0.01900763f, -0.05247514f, 0.02349314f, 
    0.00348472f, -0.03174665f, 0.03770168f, 0.03478660f, -0.00765357f, 0.00409655f, 0.02873030f, -0.05320354f, 
    -0.00635088f, -0.01674246f, -0.03904700f, -0.04412460f, 0.03522007f, 0.03080831f, 0.02336901f, -0.01888322f, 
    -0.01427625f, -0.01433367f, -0.02591068f, 0.01542482f, -0.00999404f, -0.00573819f, -0.04566643f, 0.00651812f, 
    -0.01236678f, -0.04799630f, -0.05667600f, -0.04353710f, -0.01499703f, -0.02022764f, -0.00605284f, 0.04296687f, 
    -0.00286355f, -0.04330400f, 0.02360026f, -0.05695847f, 0.03296691f, -0.00998383f, 0.02535152f, 0.03926296f, 
    -0.01496488f, -0.02426574f, 0.00365258f, -0.03954430f, 0.00847804f, 0.04138570f, -0.02717190f, -0.00550497f, 
    0.03613850f, -0.02390840f, -0.01860066f, 0.02159504f, -0.02840495f, -0.05589899f, -0.02699701f, -0.01217931f, 
    0.00135976f, -0.04785527f, 0.02490179f, -0.05841242f, -0.03979929f, -0.05188956f, -0.00748563f, -0.00773530f, 
    0.02571126f, 0.03428936f, 0.04057685f, -0.01554663f, 0.03998602f, 0.02751785f, -0.00270836f, -0.01702971f, 
    0.02853052f, 0.03064867f, 0.03105097f, -0.00391483f, -0.03734217f, -0.03343642f, 0.00036668f, 0.01432032f, 
    -0.02356046f, -0.04721832f, -0.02152919f, -0.00593401f, 0.02776634f, 0.03333872f, -0.01661119f, 0.03330397f, 
    -0.04443171f, 0.03866303f, 0.04144881f, -0.00503871f, -0.03864680f, 0.03126376f, 0.04413714f, -0.03956454f, 
    -0.01176677f, 0.00400390f, -0.03451760f, -0.05192403f, 0.04062146f, 0.02446026f, 0.03495863f, -0.04670152f, 
    0.00319963f, 0.03144798f, -0.03430266f, 0.03069079f, -0.01169315f, -0.00357179f, 0.00312539f, 0.02206082f, 
    -0.15309156f, 0.29118821f, 0.25425938f, 0.08222765f, -0.05329791f, 0.17838301f, 0.07440886f, 0.00048612f, 
    0.03215160f, -0.04259558f, 0.04712439f, 0.04604819f, -0.09347353f, 0.25709581f, 0.20164682f, 0.35238433f, 
    -0.02714151f, 0.10167304f, 0.09148421f, -0.14758010f, 0.02581867f, 0.08133393f, -0.04103686f, -0.06305906f, 
    -0.21076515f, -0.21619539f, 0.05742186f, 0.03644045f, 0.02183026f, -0.13308811f, 0.13154383f, 0.07143565f, 
    0.13248493f, 0.03162432f, -0.03902703f, 0.00607909f, -0.11480035f, 0.10793477f, 0.15368035f, -0.08245841f, 
    0.08399914f, 0.01022610f, 0.00345514f, -0.00227431f, -0.03056812f, 0.00008102f, -0.04187498f, 0.04260671f, 
    -0.43052420f, -0.25814778f, 0.04957501f, 0.10168786f, -0.09742478f, 0.05134146f, 0.10105337f, 0.12926723f, 
    0.05337559f, 0.01638903f, -0.17472896f, -0.08560542f, 0.07602040f, 0.15948026f, -0.04583006f, -0.02987430f, 
    0.14019094f, -0.06724151f, -0.16291231f, 0.13072887f, 0.02852164f, -0.01512191f, 0.05830891f, 0.11515377f, 
    0.06440779f, -0.21381287f, -0.08693220f, -0.00312163f, 0.06754261f, 0.08728574f, -0.13554038f, 0.18107478f, 
    0.03339727f, 0.13231790f, 0.13640758f, 0.12017420f, -0.00278992f, 0.02233144f, 0.14314540f, 0.02042727f, 
    0.17108020f, -0.10840145f, -0.14134128f, -0.01936270f, 0.11381213f, -0.09175020f, -0.14322567f, 0.02155866f, 
    0.02978973f, -0.37158114f, -0.27085608f, -0.15625221f, 0.17692806f, 0.07427104f, 0.06849997f, 0.03322418f, 
    0.05382428f, 0.01103094f, 0.12174165f, -0.02723021f, -0.01276207f, -0.09021390f, -0.09112937f, -0.02011155f, 
    0.10852510f, 0.09437656f, 0.15770327f, -0.18184517f, 0.13312368f, -0.11225150f, -0.09589404f, -0.03254937f, 
    -0.05232543f, 0.02557694f, 0.02772343f, 0.05222813f, -0.00173056f, 0.01859241f, -0.04671439f, 0.01829124f, 
    -0.08040928f, -0.06881206f, 0.07452210f, -0.00370741f, 0.02468293f, -0.07796111f, -0.07578146f, 0.07799966f, 
    -0.02637963f, 0.14552450f, -0.09318452f, -0.06140688f, -0.08386736f, 0.01156683f, 0.10132962f, 0.11549827f, 
    -0.16363661f, -0.14419825f, -0.04972171f, 0.10997843f, 0.05796034f, -0.01020426f, -0.17746906f, 0.11782528f, 
    -0.04149237f, 0.07493407f, -0.13523814f, 0.00886061f, 0.09644875f, -0.09987959f, 0.00804146f, -0.07207820f, 
    0.08534690f, -0.14105169f, 0.08719217f, 0.11339568f, 0.06590249f, 0.05398784f, 0.05183848f, -0.09551930f, 
    -0.04598231f, -0.60835952f, 0.16030364f, -0.10972020f, 0.28235149f, 0.07226199f, -0.26766497f, 0.04516030f, 
    0.00324163f, -0.09565683f, -0.04119043f, 0.23499207f, 0.02452384f, 0.07577592f, -0.01114037f, 0.07380327f, 
    0.05319853f, 0.00619789f, 0.00933635f, 0.03874744f, -0.02914745f, 0.12641968f, 0.02534650f, 0.16329888f, 
    -0.11802316f, -0.05167570f, 0.01750704f, 0.11503886f, -0.13109082f, -0.07618745f, 0.09688235f, 0.03040548f, 
    0.07128412f, 0.19072951f, 0.00011856f, 0.06814983f, -0.23760383f, -0.19771104f, 0.29135302f, 0.00539904f, 
    -0.14337340f, -0.18597506f, 0.33529750f, 0.17111817f, -0.02753151f, -0.05409663f, 0.25565892f, -0.17394815f, 
    0.06995293f, -0.03896484f, -0.02854431f, -0.25155261f, 0.05478404f, 0.02985308f, 0.16398057f, -0.07260042f, 
    0.02120538f, -0.02999065f, -0.07527597f, 0.08320740f, -0.24180612f, -0.20604084f, -0.08885872f, 0.29065514f, 
    -0.02206001f, 0.17513588f, 0.12125179f, -0.01406450f, -0.01596516f, 0.06265061f, -0.02624202f, -0.04861292f, 
    -0.27877289f, -0.24416460f, 0.13263395f, -0.24941039f, -0.01451404f, -0.06118807f, -0.10405500f, -0.17258264f, 
    0.11005328f, -0.01649183f, 0.12738761f, 0.01416386f, -0.22211710f, -0.09351010f, -0.01874213f, -0.09431800f, 
    0.00565714f, 0.04636578f, 0.05487129f, -0.09282321f, -0.04496721f, 0.05355492f, 0.03739565f, 0.02002013f, 
    0.18776198f, -0.04785054f, 0.01160209f, -0.21803722f, -0.01703567f, 0.06203169f, 0.08904984f, 0.08553983f, 
    0.04931641f, 0.10266949f, 0.14992952f, -0.10526170f, -0.13961646f, -0.37530953f, 0.09026306f, -0.01998946f, 
    -0.09754562f, -0.07267696f, 0.15057947f, 0.06812151f, -0.00386291f, 0.00597031f, 0.14199375f, 0.03486502f, 
    0.14814882f, -0.32893288f, 0.07342031f, 0.07203271f, 0.07301869f, 0.10073755f, -0.10019317f, 0.08032900f, 
    -0.10509756f, -0.01494018f, 0.04426921f, 0.13541922f, 0.27428856f, -0.23295695f, 0.02206956f, -0.02288288f, 
    0.05537988f, -0.01932221f, -0.26133281f, 0.12532613f, 0.06636710f, -0.16149721f, 0.26447806f, -0.10903542f, 
    -0.30557463f, -0.11692607f, -0.05287918f, -0.05050250f, -0.04508908f, 0.07042335f, 0.02036370f, -0.09134865f, 
    -0.03676825f, 0.00177770f, 0.05721375f, 0.16414385f, 0.12098942f, -0.16681127f, -0.03023821f, 0.11391161f, 
    -0.00868760f, 0.15817839f, -0.00495038f, 0.02114475f, -0.11372796f, -0.00042625f, 0.07771268f, 0.03518452f, 
    -0.07956871f, -0.12903956f, 0.12903672f, 0.14978248f, -0.04690620f, -0.10058917f, 0.04289792f, -0.11294886f, 
    0.08019187f, 0.02447345f, -0.14267671f, 0.03703502f, 0.06304143f, -0.07570239f, -0.43727973f, 0.07493474f, 
    0.06378772f, 0.02944954f, 0.03032490f, 0.22267811f, -0.08018991f, 0.03648217f, -0.01067112f, 0.11321108f, 
    -0.02607350f, 0.00369414f, -0.16568401f, -0.01426386f, -0.05576258f, 0.10338500f, -0.07546408f, -0.00619183f, 
    0.13706543f, 0.05144579f, 0.17812377f, 0.01891056f, -0.02736865f, 0.11754298f, -0.16700363f, 0.06835651f, 
    -0.04025894f, -0.00843539f, 0.06745237f, 0.07363995f, -0.05618559f, 0.05942864f, 0.05399394f, 0.17446803f, 
    0.00398370f, -0.03925441f, -0.05519903f, 0.01870881f, -0.04109252f, -0.02097409f, -0.00419566f, -0.01122306f, 
    0.01987268f, 0.02703614f, 0.03362641f, -0.00694771f, 0.01496067f, 0.03529346f, 0.03378481f, -0.04080202f, 
    -0.05477003f, 0.01034504f, 0.00316324f, 0.00197465f, 0.03269597f, -0.01666440f, -0.00582414f, -0.02532745f, 
    -0.05529169f, 0.01083091f, -0.05065947f, 0.00695750f, 0.00183685f, -0.04420772f, -0.03078240f, 0.02733597f, 
    0.03573090f, -0.06190920f, -0.03973304f, -0.01058752f, -0.01323721f, -0.02466745f, -0.03032605f, -0.00677689f, 
    -0.04335667f, -0.02106005f, 0.00334090f, -0.01952591f, 0.02120463f, -0.01216270f, 0.02771641f, -0.01313407f, 
    0.00201199f, -0.00978306f, 0.00489573f, 0.03483215f, 0.02685347f, -0.05939629f, -0.00607907f, -0.01052716f, 
    -0.04878609f, -0.02949905f, 0.03116979f, -0.01017830f, -0.04138013f, -0.06018887f, 0.01729558f, 0.00346240f, 
    -0.04876031f, 0.02296289f, 0.01081353f, -0.02776739f, 0.03163605f, -0.00029882f, -0.02190487f, 0.00695307f, 
    0.00331545f, -0.00599503f, 0.00997189f, 0.01383465f, 0.03585564f, -0.02843090f, 0.03134762f, -0.05082117f, 
    0.01853636f, -0.02894550f, 0.03057823f, -0.05247137f, 0.02043829f, 0.01210463f, -0.00588578f, -0.05823179f, 
    -0.00703469f, 0.03950316f, 0.03186212f, 0.02350578f, 0.02848342f, -0.04495219f, -0.04983103f, -0.05126430f, 
    -0.00423687f, -0.00614251f, -0.01591977f, -0.00390548f, 0.03344928f, -0.03501235f, -0.03007642f, -0.01685917f, 
    -0.05833229f, -0.01061023f, -0.05068033f, -0.03671132f, -0.05583671f, -0.01066050f, -0.00108050f, 0.04161930f, 
    -0.01345933f, 0.01915441f, -0.03860736f, -0.03585450f, -0.02550576f, 0.00805338f, 0.04084647f, 0.01581045f, 
    0.01877195f, 0.04164946f, -0.00652264f, -0.02256596f, 0.01698498f, 0.01471042f, 0.00182332f, 0.01703488f, 
    -0.00001569f, -0.04979416f, 0.02538233f, 0.01037954f, -0.03889921f, -0.06053266f, -0.02588211f, 0.00150093f, 
    -0.02914901f, 0.01041374f, -0.00209772f, -0.04096237f, -0.00337291f, 0.03815691f, -0.00827922f, -0.04416255f, 
    0.02731183f, -0.01380803f, -0.04080487f, -0.04870841f, -0.01777853f, -0.00352415f, -0.05147950f, 0.01908794f, 
    -0.01229808f, -0.01683806f, 0.00493239f, -0.03521435f, -0.00032339f, 0.03953610f, 0.03426769f, 0.01241292f, 
    0.00702928f, 0.00577598f, -0.04691318f, 0.01238599f, -0.03486240f, 0.03614579f, -0.00167348f, 0.02363658f, 
    -0.04188063f, -0.01820722f, 0.03546417f, -0.01024347f, 0.03970335f, 0.01369404f, 0.01988012f, -0.03801185f, 
    0.02384718f, 0.02235309f, -0.03043389f, 0.03728018f, 0.02231000f, 0.00565769f, -0.01452272f, -0.00542470f, 
    0.01338085f, 0.03515584f, -0.04030470f, -0.01333861f, 0.01853646f, 0.02567516f, -0.00258763f, -0.01465004f, 
    0.01426542f, -0.01102559f, 0.03489422f, 0.00184446f, 0.02783719f, 0.00381072f, -0.01837466f, -0.04367680f, 
    0.03590293f, 0.03409182f, 0.01476997f, -0.05615821f, 0.03459317f, 0.03297188f, 0.01577189f, 0.03091411f, 
    -0.03443764f, -0.01314791f, -0.04520207f, -0.00062056f, -0.01866260f, -0.02881490f, -0.00548044f, -0.03515588f, 
    0.01663925f, 0.03345780f, 0.03156007f, -0.02039153f, -0.03653282f, 0.00130070f, -0.05928234f, 0.01430732f, 
    -0.00776336f, -0.01585180f, 0.02185046f, -0.03604745f, 0.02259605f, -0.03959458f, -0.01316851f, -0.00965978f, 
    0.01619516f, -0.01991737f, -0.03927224f, -0.02940853f, 0.03471057f, -0.02513056f, -0.03031979f, -0.06180483f, 
    -0.00453048f, 0.01427720f, 0.00735033f, -0.04319245f, -0.02808355f, -0.01928101f, -0.01770136f, -0.00554459f, 
    -0.03886281f, -0.00027706f, -0.05421530f, -0.00483319f, -0.00405501f, -0.01699482f, 0.01870259f, -0.03032312f, 
    -0.06105793f, -0.01849315f, 0.03815923f, 0.03083843f, 0.01397021f, 0.01004831f, 0.01507651f, -0.01885103f, 
    0.01830880f, 0.00304906f, 0.00673561f, -0.02628918f, -0.05394754f, 0.00322656f, 0.03962938f, -0.03292055f, 
    0.03342687f, -0.03298132f, -0.00607163f, -0.03241068f, -0.05603039f, -0.04429293f, -0.00616428f, -0.01485150f, 
    0.02769960f, -0.04863252f, 0.00606027f, -0.03247075f, -0.00440071f, 0.03388955f, -0.02691270f, 0.00113814f, 
    -0.04754552f, -0.04610556f, 0.02528794f, 0.02369614f, -0.02322666f, 0.03007468f, -0.05176944f, -0.00666664f, 
    0.01954891f, 0.01680566f, -0.01741886f, 0.03543290f, 0.04011670f, 0.04150734f, 0.01047482f, 0.00343501f, 
    -0.03900083f, -0.04894332f, -0.05042070f, 0.01926336f, 0.02351506f, -0.02007258f, -0.05395104f, 0.00575201f, 
    0.03951562f, -0.02578659f, 0.01482848f, -0.04553319f, -0.06154971f, 0.00199909f, 0.01300267f, 0.02787460f, 
    0.02543375f, -0.02897382f, -0.02798031f, -0.00365074f, -0.02240988f, -0.01500840f, -0.05446256f, 0.01385335f, 
    -0.02777859f, -0.05839138f, 0.01413535f, -0.02769109f, -0.04881604f, -0.04593152f, 0.03331600f, -0.04488336f, 
    0.02237243f, -0.02066159f, -0.04691098f, -0.03123202f, -0.05966432f, -0.04137984f, -0.04456927f, 0.04981676f, 
    0.04360223f, -0.00224903f, 0.04480995f, -0.00293525f, -0.04326851f, 0.03152508f, -0.04422382f, 0.02165427f, 
    -0.02010094f, -0.04182850f, 0.01487255f, 0.03459629f, -0.01309116f, -0.04717559f, 0.01856027f, -0.01573307f, 
    -0.01886761f, -0.01799885f, 0.01182191f, 0.02595079f, 0.01710284f, -0.05614836f, -0.01315824f, -0.00341254f, 
    0.01348402f, 0.02002515f, -0.03925206f, -0.03934170f, 0.04256398f, -0.04911884f, 0.00014494f, 0.01419971f, 
    -0.05303906f, 0.02905030f, -0.02009512f, 0.00760235f, -0.00417556f, -0.00239934f, 0.00292165f, 0.00422873f, 
    -0.02168436f, -0.23429741f, -0.12167392f, 0.21797532f, 0.08728091f, -0.11038252f, 0.00520264f, -0.01190405f, 
    0.15000845f, 0.09757787f, -0.01061657f, 0.14194767f, -0.21335612f, -0.26841384f, 0.01125794f, 0.15519167f, 
    0.04328481f, -0.07225168f, -0.00486741f, -0.02444352f, 0.15738541f, 0.03310865f, 0.02476618f, 0.13129590f, 
    -0.03312573f, -0.01634607f, -0.05820006f, 0.02970604f, 0.02271332f, -0.00291935f, -0.02911229f, 0.18726562f, 
    -0.07215180f, 0.02891549f, -0.08207637f, -0.01050584f, -0.09210405f, -0.01941182f, 0.10348584f, 0.06376580f, 
    0.15680751f, -0.02171771f, -0.01471911f, 0.07288601f, -0.02269343f, 0.05565345f, -0.19284771f, -0.25405717f, 
    0.53582525f, 0.01817706f, -0.14802264f, -0.14971991f, 0.04792827f, -0.01430419f, -0.05686077f, -0.00943731f, 
    0.04511480f, 0.00440011f, -0.00224275f, 0.00122991f, 0.18626586f, -0.15420309f, 0.04236032f, -0.11125615f, 
    -0.08761018f, 0.13619119f, 0.07287177f, -0.26059896f, 0.03199504f, -0.14525825f, 0.00557173f, -0.05468113f, 
    0.24973622f, -0.03845309f, -0.12742069f, -0.12330931f, -0.09449548f, -0.17598803f, -0.08974781f, -0.36218163f, 
    -0.12230728f, -0.05112070f, 0.04863940f, 0.00851988f, -0.24548186f, 0.21269834f, 0.00726592f, 0.39496395f, 
    -0.11263800f, 0.11639517f, -0.10137612f, -0.04708221f, -0.07717483f, 0.09229928f, -0.10265610f, -0.07719224f, 
    -0.02794692f, -0.04427456f, 0.02611300f, 0.27167708f, -0.06536381f, 0.05048221f, 0.00122823f, 0.19994217f, 
    -0.00324973f, 0.19041584f, 0.02787014f, -0.08459216f, -0.17066534f, 0.02216031f, 0.05852058f, 0.29736000f, 
    0.02296716f, -0.05653879f, 0.02692719f, -0.04331077f, -0.01755639f, 0.06744470f, -0.07814722f, 0.06847586f, 
    0.09032212f, -0.08072619f, 0.12137687f, 0.08654880f, 0.00387702f, 0.00129419f, 0.03447450f, 0.02950668f, 
    0.12559968f, 0.15238477f, 0.11193432f, 0.15468618f, -0.12441552f, -0.25245038f, 0.15542218f, -0.28395930f, 
    0.07306253f, -0.15259634f, -0.05046366f, 0.06216695f, -0.20220703f, -0.13866444f, -0.08996230f, -0.19984905f, 
    0.22455226f, 0.08138985f, -0.01651959f, -0.04622219f, 0.06863035f, 0.12093193f, 0.01072979f, -0.10503985f, 
    0.09787806f, 0.04735241f, 0.03727371f, 0.03706932f, 0.28152642f, -0.06329909f, -0.10009196f, 0.18444690f, 
    0.02253533f, -0.01703432f, -0.12219802f, -0.10138059f, 0.08983997f, -0.16376284f, 0.08910809f, 0.13145965f, 
    -0.15395008f, 0.38285461f, 0.16034934f, 0.31012467f, 0.07497472f, 0.06815341f, 0.22580758f, 0.10727817f, 
    0.04081448f, 0.02293130f, 0.13297062f, -0.11456553f, -0.03623253f, -0.14121272f, -0.16384785f, -0.23867255f, 
    0.01915068f, 0.00661904f, -0.14019275f, -0.02298347f, -0.27378711f, 0.01364427f, -0.07089176f, -0.14407721f, 
    0.03233502f, -0.04221236f, -0.07158628f, -0.27357063f, 0.01129680f, -0.01158984f, -0.02662494f, -0.21494013f, 
    -0.10375468f, -0.01642667f, -0.10325871f, 0.01122488f, 0.01333779f, 0.24973910f, -0.23904201f, -0.08381394f, 
    -0.12240823f, 0.26528993f, -0.11188444f, -0.01208245f, -0.05601487f, -0.05950585f, 0.02152384f, 0.12861419f, 
    -0.20031558f, 0.10858649f, -0.01813003f, 0.17239326f, 0.11482482f, 0.08904132f, 0.09549225f, 0.02853189f, 
    0.00919341f, 0.03544566f, -0.06807263f, 0.09597003f, 0.10282454f, 0.14735839f, 0.07494802f, -0.10952742f, 
    0.07345135f, -0.01721428f, -0.13794960f, -0.10762388f, 0.04057454f, -0.00593354f, -0.05632840f, 0.15631633f, 
    0.01797167f, 0.03203203f, -0.08135805f, 0.17188609f, -0.03643285f, -0.02656595f, 0.05122358f, 0.04229714f, 
    0.05971399f, -0.03643068f, -0.01587999f, 0.06504722f, -0.02196901f, -0.10182296f, 0.01905882f, 0.29904816f, 
    0.00916401f, 0.09076858f, -0.03601709f, 0.06444847f, 0.04094051f, -0.01016380f, -0.05033975f, 0.04612974f, 
    -0.06003882f, 0.03810721f, -0.00552351f, 0.17571776f, 0.01606759f, -0.06821338f, 0.00926025f, -0.08594698f, 
    0.03518626f, 0.09693381f, 0.00365541f, -0.09977162f, 0.10800254f, 0.44751251f, -0.36882740f, -0.10232668f, 
    -0.03286852f, 0.13458930f, -0.15088484f, 0.05476565f, -0.02249061f, 0.05098848f, -0.11638157f, -0.08343942f, 
    -0.25619495f, 0.28009084f, 0.18393405f, -0.05921231f, 0.13980001f, -0.19760384f, 0.06837320f, -0.23186150f, 
    -0.10076911f, 0.01684806f, -0.07993391f, -0.04525679f, -0.08064176f, 0.42236674f, 0.15223327f, -0.18640715f, 
    -0.23007241f, 0.21016271f, 0.11059882f, -0.10609613f, -0.13797423f, 0.14039026f, -0.07691319f, -0.02245782f, 
    -0.04636132f, 0.00129224f, 0.07339061f, 0.46928313f, -0.04110434f, -0.03444975f, 0.11388907f, 0.14900079f, 
    0.05955671f, 0.12221135f, -0.03487750f, -0.05950613f, -0.15278693f, 0.14593863f, 0.18695024f, -0.12907396f, 
    0.21798794f, -0.11724156f, -0.03827661f, -0.12636507f, -0.16315223f, -0.06956459f, -0.01610491f, 0.06179365f, 
    -0.09298746f, -0.13853477f, 0.03364959f, 0.00092333f, 0.00743011f, 0.07869957f, -0.01056971f, 0.09177864f, 
    -0.04751912f, 0.03683974f, 0.03405550f, 0.02913470f, 0.01508842f, 0.12872611f, 0.06175339f, 0.02597578f, 
    -0.10888661f, -0.00689881f, 0.05485374f, -0.01993497f, 0.05625761f, 0.17801838f, -0.01050588f, -0.04247969f, 
    -0.08272152f, -0.00490929f, 0.17117327f, 0.20693417f, -0.03782510f, 0.03983875f, 0.12171881f, -0.10078727f, 
    0.05663392f, 0.00316681f, 0.21185139f, 0.10146628f, 0.16816752f, -0.08505276f, 0.07159857f, -0.22260173f, 
    -0.06150878f, -0.08663335f, -0.07899865f, -0.16661133f, -0.19672540f, 0.13605192f, 0.01071719f, -0.05862046f, 
    0.23986070f, 0.15055056f, 0.19692981f, 0.09792572f, 0.15102120f, 0.17653064f, 0.12969945f, -0.07358827f, 
    0.07530482f, -0.06917454f, -0.04606455f, -0.10283881f, 0.31658792f, 0.11944704f, 0.11846580f, 0.27731442f, 
    0.12326937f, 0.12639111f, 0.08484176f, -0.01323960f, -0.02887483f, 0.01059238f, -0.04264861f, 0.04963987f, 
    0.32230005f, -0.01967937f, 0.03457148f, 0.14707252f, 0.03155833f, 0.00320861f, 0.21318562f, 0.07716610f, 
    0.07389301f, -0.08582401f, 0.07640471f, -0.01297416f, -0.41077876f, 0.24172640f, 0.08427551f, -0.09445354f, 
    0.01290946f, -0.15092711f, -0.28216404f, -0.01146847f, 0.01573171f, 0.13564904f, -0.09100763f, -0.02853717f, 
    0.17161252f, 0.06729390f, -0.13143668f, -0.00278281f, 0.04175388f, 0.05073111f, 0.08534277f, -0.07117289f, 
    -0.07002950f, -0.07074832f, 0.00391221f, -0.00781285f, 0.31990770f, -0.03772954f, -0.27648571f, 0.10228145f, 
    0.01975934f, 0.03871432f, -0.21263003f, 0.02763665f, 0.12592691f, -0.21298151f, -0.04309623f, 0.06752750f, 
    -0.03958506f, -0.27116546f, -0.00340966f, 0.04346643f, -0.00212606f, 0.04255010f, 0.14690228f, -0.02847599f, 
    0.06573840f, -0.10677805f, 0.10736088f, 0.15295406f, 0.04249987f, -0.22679856f, 0.16440660f, 0.07361080f, 
    0.02116065f, -0.05081267f, 0.00374507f, -0.05521026f, -0.13535242f, -0.07561905f, -0.08372156f, -0.00309520f, 
    0.04936128f, 0.18569872f, 0.10420746f, -0.11368490f, -0.00882245f, 0.05166846f, -0.04732012f, 0.09248081f, 
    -0.03428272f, -0.02280296f, 0.06373467f, -0.01249653f, 0.32587740f, -0.16385855f, -0.23111218f, 0.08267242f, 
    -0.04591348f, -0.03748653f, 0.09467213f, -0.08466813f, 0.04224464f, 0.07637452f, 0.04289044f, 0.06470117f, 
    -0.16674973f, -0.02495942f, 0.23679353f, 0.21144825f, 0.04754328f, 0.06867152f, -0.11274413f, -0.04806158f, 
    0.09693763f, -0.06006918f, 0.14866030f, 0.27903342f, 0.14366677f, 0.08432628f, -0.20951034f, -0.01267971f, 
    -0.03030110f, 0.05908237f, -0.05908109f, -0.02519692f, -0.15801148f, -0.22523670f, -0.10573189f, -0.05595770f, 
    0.09545838f, -0.25648236f, 0.07195987f, 0.19298665f, 0.04371793f, 0.32692462f, -0.09574131f, 0.09365200f, 
    -0.00233366f, -0.32473600f, 0.10396044f, 0.13380788f, -0.09790303f, 0.02775205f, -0.22562400f, 0.03424818f, 
    0.06202925f, -0.03267068f, -0.19491220f, 0.11003981f, -0.09366713f, 0.02111765f, -0.12812859f, -0.13313617f, 
    0.09988250f, -0.27250123f, -0.00356435f, 0.16864268f, 0.22202893f, 0.14165980f, -0.02179922f, 0.09180378f, 
    0.03300828f, 0.02216163f, 0.09984466f, 0.09689288f, -0.14951730f, 0.16436568f, 0.13086468f, -0.15217483f, 
    -0.01159721f, -0.06534588f, 0.19398588f, -0.03258780f, -0.09915967f, -0.00814197f, -0.03917670f, -0.01996576f, 
    0.31848985f, -0.12093282f, -0.08116467f, 0.13062157f, -0.18261430f, -0.24073790f, 0.22937971f, -0.07756802f, 
    -0.07159427f, 0.06196778f, -0.00240260f, 0.06599509f, 0.28170902f, -0.19309211f, 0.38830507f, -0.12713812f, 
    -0.00711868f, -0.26559621f, 0.13743675f, 0.10164366f, 0.05021828f, -0.05905952f, 0.20878147f, -0.01046968f, 
    0.18935567f, -0.33389449f, -0.07377648f, 0.06207657f, 0.06406946f, -0.01602294f, 0.02652940f, 0.08038694f, 
    -0.02848923f, -0.05226233f, 0.13055937f, 0.13562448f, -0.09399530f, 0.01406993f, -0.22267635f, 0.14340784f, 
    -0.07833385f, 0.20424427f, -0.12533605f, 0.07281540f, 0.07007365f, -0.02328494f, -0.18530926f, -0.19114290f, 
    0.04644926f, 0.02830807f, 0.20038123f, -0.03154445f, 0.25244528f, 0.17093682f, 0.02878339f, -0.12968336f, 
    0.00546634f, 0.05137548f, 0.01308360f, 0.01300261f, 0.04835769f, 0.12289508f, 0.11804628f, 0.18144861f, 
    0.07398255f, 0.03768318f, -0.05132119f, 0.11290298f, -0.08688980f, 0.02113302f, -0.02190294f, -0.03615529f, 
    0.02002437f, 0.13183320f, -0.05738281f, 0.10948109f, 0.00537983f, 0.10646287f, 0.16125634f, 0.10151275f, 
    -0.07449609f, -0.04661961f, -0.09317369f, 0.00465714f, 0.11864775f, -0.25727445f, -0.09709097f, -0.07984937f, 
    -0.26126283f, 0.04701855f, 0.24772213f, 0.01867874f, -0.00480331f, 0.14876974f, -0.12356653f, -0.03257114f, 
    -0.30010942f, -0.50425267f, -0.01809885f, 0.10524052f, 0.04007658f, -0.05726712f, -0.09543554f, 0.00759860f, 
    0.01021020f, 0.09810127f, -0.16349578f, 0.05469068f, 0.11267015f, 0.17021978f, -0.18964125f, -0.05702267f, 
    0.07969747f, -0.14332682f, -0.10439861f, 0.09186448f, 0.04250776f, -0.05468107f, 0.12085176f, 0.00062470f, 
    -0.01587407f, 0.10020380f, 0.11069258f, -0.22177485f, -0.10016037f, 0.00617536f, -0.01987039f, 0.02594777f, 
    0.14849941f, 0.02219128f, 0.00192026f, -0.06646318f, -0.15803444f, -0.05692024f, -0.32328823f, -0.13617083f, 
    -0.11671511f, -0.16712846f, -0.05193445f, 0.16393937f, -0.03780732f, -0.01842694f, 0.08064707f, -0.16461907f, 
    0.11485069f, 0.14422035f, -0.20321038f, 0.02112598f, 0.08189971f, -0.03460200f, -0.04883764f, -0.04581527f, 
    -0.21848619f, 0.00888067f, -0.09446493f, -0.01772118f, 0.05589200f, 0.30190134f, -0.13766748f, -0.12214236f, 
    -0.01680221f, -0.06503802f, 0.12346551f, 0.08075853f, -0.05765004f, 0.03439793f, -0.11296090f, 0.18454659f, 
    -0.14106332f, 0.04444681f, -0.05504248f, 0.01302139f, 0.06329086f, 0.12337814f, 0.00641706f, -0.17593564f, 
    0.06443143f, -0.03670561f, 0.25799739f, 0.17093289f, -0.17652664f, -0.10982831f, -0.09788738f, -0.01920235f, 
    -0.12422102f, 0.12397240f, -0.00242715f, -0.14090882f, -0.12479316f, -0.07259163f, -0.07360376f, 0.01806546f, 
    0.09264463f, 0.21525332f, 0.32696053f, 0.05172405f, 0.08576339f, 0.01618964f, 0.09160462f, 0.00027262f, 
    -0.06506425f, 0.00771137f, -0.01410170f, -0.01391308f, 0.20276734f, 0.28407902f, 0.22248496f, 0.18041034f, 
    0.05629323f, -0.05093843f, 0.12552223f, 0.06121120f, 0.02380655f, -0.13266452f, 0.03478292f, 0.09849177f, 
    0.32103184f, 0.12977482f, 0.06818233f, 0.13612990f, 0.04158047f, 0.03984222f, 0.18619429f, 0.14771232f, 
    0.05670730f, -0.16410814f, -0.04262558f, -0.17826968f, 0.20414755f, 0.44438300f, -0.07071577f, -0.14091560f, 
    -0.14918812f, -0.03389718f, -0.03294879f, 0.11816797f, 0.00952400f, 0.13178505f, 0.03153086f, -0.08269531f, 
    0.01301085f, 0.09910458f, 0.07378781f, 0.15718780f, 0.05312274f, -0.01314060f, -0.01682603f, -0.05526654f, 
    -0.05048900f, -0.13322590f, 0.09826906f, 0.09695880f, -0.00944332f, -0.24051443f, -0.52869368f, 0.10179830f, 
    0.20389308f, -0.00775834f, -0.13749897f, -0.01030251f, 0.21708743f, 0.03410665f, -0.06920097f, 0.09279133f, 
    -0.28728935f, -0.28545240f, -0.11045536f, 0.08623333f, 0.03104840f, -0.02672878f, 0.18675181f, 0.10430463f, 
    0.17462918f, -0.08761079f, 0.07447571f, 0.22414215f, -0.15595739f, 0.09198307f, 0.01002327f, -0.35018191f, 
    0.11047678f, -0.08932291f, 0.09537620f, -0.08776446f, -0.03272774f, -0.02497295f, -0.22962837f, 0.09776797f, 
    0.05455857f, 0.15513621f, 0.20272705f, 0.22323582f, -0.01136000f, 0.06480641f, -0.02175101f, 0.03276456f, 
    0.00056015f, -0.06479698f, -0.06727301f, -0.09568685f, 0.18158606f, 0.09123213f, 0.06748921f, -0.05460384f, 
    0.05620022f, 0.03444722f, 0.06472552f, -0.05300384f, -0.02658172f, -0.13893193f, 0.03855163f, 0.01560960f, 
    -0.09405350f, -0.12352599f, -0.26703838f, 0.00840012f, -0.02079916f, -0.07811545f, -0.06143925f, -0.03758673f, 
    0.22627448f, 0.00179696f, 0.12495173f, 0.33712149f, 0.22243175f, 0.08571403f, -0.08408738f, -0.02380359f, 
    0.03104455f, 0.15855992f, 0.20332755f, 0.19172372f, 0.11655723f, -0.13698845f, -0.12837043f, -0.13168718f, 
    0.27106774f, 0.03892104f, 0.01060982f, -0.09220847f, 0.15331477f, 0.19615437f, -0.05006697f, 0.11743264f, 
    0.09287576f, -0.10638989f, 0.05954929f, -0.04473436f, -0.20027225f, -0.08575118f, -0.00523013f, 0.11931011f, 
    0.01419234f, 0.03887867f, -0.09228496f, -0.00219664f, -0.03266307f, 0.07718356f, -0.01956229f, -0.04924009f, 
    0.12915759f, 0.17873324f, 0.06360424f, 0.30456096f, -0.00184935f, 0.02137821f, -0.00204550f, 0.10322677f, 
    -0.00532485f, -0.02859342f, -0.00114492f, -0.08146925f, -0.04668495f, -0.05775256f, 0.03714339f, -0.05727139f, 
    0.05795855f, 0.05496333f, 0.18247584f, 0.02752225f, -0.21643117f, -0.05563759f, -0.13158190f, -0.35837808f, 
    -0.05780358f, -0.33095407f, -0.22308853f, 0.02360530f, 0.12847571f, -0.05702237f, 0.13769631f, -0.02973512f, 
    0.05618903f, 0.12543833f, -0.02873897f, 0.24121313f, -0.08341224f, -0.45778340f, 0.41135526f, 0.31568921f, 
    0.06030508f, -0.02962185f, 0.02645309f, -0.00287527f, 0.06607359f, 0.02091043f, 0.01187339f, 0.00740472f, 
    0.15603970f, -0.08039213f, 0.22326639f, 0.09610180f, -0.03378326f, 0.08572926f, -0.15446265f, 0.16594642f, 
    0.07167823f, 0.02920438f, 0.05389167f, 0.08403284f, 0.20203573f, 0.01256900f, 0.12241876f, -0.08837775f, 
    0.08335032f, 0.25105402f, -0.09439180f, 0.03834827f, 0.18909922f, -0.01137396f, -0.05065112f, -0.17481929f, 
    0.13202184f, 0.22643940f, 0.24388114f, 0.14391723f, 0.18361726f, 0.10180351f, 0.06074651f, -0.03045262f, 
    0.04177956f, 0.06528044f, -0.04434466f, 0.22565927f, 0.05091764f, 0.27799532f, 0.14349194f, 0.07910713f, 
    -0.01301440f, -0.10113034f, 0.11557148f, 0.06714427f, 0.03342671f, -0.02869640f, -0.12386677f, -0.17135708f, 
    -0.00928557f, 0.02604841f, 0.22819529f, 0.06954589f, 0.01433164f, 0.10900401f, 0.05270384f, 0.13089150f, 
    -0.05911857f, -0.14018711f, -0.08052878f, -0.12151985f, -0.19743794f, -0.43722725f, -0.01986646f, 0.09560287f, 
    -0.03198885f, 0.11916526f, 0.00380148f, 0.02808476f, 0.15574507f, 0.10642726f, 0.08969599f, -0.05007947f, 
    0.18849206f, -0.38684919f, -0.31163222f, -0.24056618f, -0.06474660f, -0.07162333f, -0.10902195f, 0.04133351f, 
    0.11200816f, 0.03641972f, 0.09371361f, 0.01267592f, -0.09322012f, -0.39787877f, 0.01194087f, 0.23358163f, 
    0.05159304f, -0.00896488f, -0.03639205f, -0.00365182f, 0.11964361f, 0.09993089f, -0.07207048f, -0.05854303f, 
    0.08118616f, 0.34125572f, 0.25237632f, 0.03185448f, -0.12907141f, 0.00263160f, 0.05383588f, 0.13143747f, 
    0.03334523f, 0.01125912f, -0.04222205f, -0.08957139f, 0.26254743f, -0.18769987f, -0.37678853f, -0.32552001f, 
    -0.02951081f, -0.14464328f, 0.04636646f, 0.10831136f, 0.09332863f, 0.00300861f, 0.12707652f, -0.10862095f, 
    -0.01766248f, 0.07260424f, 0.05377485f, 0.13666786f, 0.06852636f, 0.07013295f, -0.03599275f, 0.12967692f, 
    0.05140299f, 0.06030073f, -0.04316620f, 0.18033075f, -0.00528114f, -0.14752312f, -0.04208004f, 0.23885792f, 
    0.04360871f, 0.01975500f, -0.01558772f, -0.15599203f, 0.00174750f, 0.01832599f, -0.10184047f, 0.27927449f, 
    -0.08149605f, -0.00809341f, 0.20692611f, 0.02284649f, 0.10948007f, 0.08571894f, 0.06611744f, -0.03877622f, 
    0.12692015f, 0.08441956f, 0.18172413f, 0.09870991f, -0.29928938f, -0.38441253f, -0.27092814f, 0.12430739f, 
    -0.02442152f, 0.00505977f, -0.01258569f, -0.12673239f, -0.07926602f, 0.05154472f, -0.12401640f, -0.01869750f, 
    -0.03109567f, -0.00924617f, -0.03321640f, -0.04273131f, -0.05559022f, 0.01755584f, 0.01939382f, -0.04826530f, 
    -0.04599169f, -0.01705286f, 0.00557413f, -0.03927008f, -0.05805114f, -0.04233662f, -0.01038390f, -0.02807766f, 
    0.02977067f, -0.04445568f, 0.01076703f, -0.02429952f, 0.02802853f, -0.03897124f, 0.00652832f, 0.02287255f, 
    -0.03966917f, -0.05210919f, -0.02974416f, -0.00759027f, 0.00155492f, 0.01873128f, -0.00200704f, -0.05107791f, 
    -0.01871750f, -0.02318664f, 0.00854632f, -0.04181002f, 0.01486015f, -0.05987752f, -0.05892594f, -0.02670169f, 
    -0.01136820f, -0.02881293f, -0.04448296f, -0.00983526f, -0.06054761f, -0.00922639f, -0.04691932f, -0.04966092f, 
    -0.05236439f, -0.02398820f, 0.02545344f, -0.05647065f, -0.03151870f, 0.00582897f, -0.06732966f, 0.02747387f, 
    -0.01234936f, -0.05980327f, -0.02262061f, -0.04597836f, -0.06451480f, -0.01046428f, -0.00619710f, -0.05024778f, 
    -0.03657360f, 0.00888135f, -0.01429969f, 0.02300801f, -0.05945842f, 0.01909692f, -0.06639565f, -0.05105496f, 
    -0.00672516f, -0.00865061f, -0.03374226f, 0.01858121f, -0.04465364f, -0.02631985f, 0.01334381f, -0.02880692f, 
    0.01724278f, 0.00830206f, 0.02609857f, -0.02908229f, 0.01186024f, 0.01491761f, -0.02750788f, -0.04588765f, 
    -0.05144682f, -0.05718868f, 0.02117122f, -0.02675454f, -0.05033284f, -0.05108527f, -0.05682208f, -0.02378436f, 
    -0.01165187f, 0.00263320f, 0.02381952f, -0.04126664f, 0.01805383f, -0.00847996f, -0.04942007f, -0.02005423f, 
    -0.02270412f, -0.00413223f, -0.01010225f, -0.01842887f, 0.01169750f, 0.00296035f, -0.05275370f, 0.01312847f, 
    -0.00958357f, -0.05813784f, -0.06484262f, -0.01799671f, -0.02071662f, -0.03729926f, -0.00179254f, 0.01569688f, 
    0.00601823f, -0.00466780f, -0.01876011f, -0.00111306f, -0.02719243f, -0.04383230f, -0.02047061f, -0.00787574f, 
    -0.04667707f, -0.04877913f, -0.03652471f, -0.01055471f, -0.02014953f, 0.00618463f, -0.00873904f, -0.03986495f, 
    -0.00659431f, 0.01784634f, -0.03695822f, -0.03615976f, 0.00182656f, -0.02374485f, -0.04482519f, -0.04854523f, 
    0.01482018f, 0.01706998f, -0.05328832f, -0.01003072f, 0.02329786f, 0.01388841f, -0.06196794f, -0.00383400f, 
    0.02422598f, -0.04283524f, 0.01349889f, 0.02372739f, -0.01101012f, -0.03083816f, -0.05482911f, 0.00698599f, 
    0.02547398f, -0.05151900f, -0.04996764f, -0.06216336f, 0.02115079f, -0.00465634f, -0.00453051f, -0.04384042f, 
    0.00724932f, -0.02998732f, -0.02392663f, -0.05777552f, -0.03709671f, 0.00442179f, 0.02113358f, -0.06160910f, 
    -0.02034016f, -0.04000143f, 0.03130844f, 0.00941234f, -0.06259438f, -0.06273007f, -0.06373181f, 0.01023680f, 
    -0.03535831f, 0.02657237f, 0.02774428f, -0.04076964f, -0.01571404f, 0.03023637f, -0.06508852f, 0.02785002f, 
    -0.03302059f, -0.03695470f, 0.00767121f, -0.04312072f, -0.02900540f, -0.06712361f, -0.04862188f, 0.02321392f, 
    -0.05643986f, -0.02096893f, 0.00645933f, -0.00263217f, -0.05736316f, -0.05671647f, -0.03710289f, 0.02689570f, 
    -0.04676590f, -0.03680737f, -0.05128805f, 0.02635819f, -0.06547608f, -0.05310807f, 0.01372262f, 0.00090637f, 
    -0.01923937f, -0.06842960f, 0.00478337f, -0.04177148f, 0.03913579f, -0.03011302f, 0.02508017f, 0.00997769f, 
    -0.02110614f, -0.02898365f, -0.00659620f, -0.02488315f, 0.03647621f, 0.02576434f, 0.02586663f, -0.01179253f, 
    -0.01600333f, 0.01011105f, 0.02996136f, -0.05521939f, -0.03361657f, -0.00201636f, -0.01343778f, 0.00720647f, 
    -0.03276647f, -0.04992209f, 0.01892999f, -0.04957485f, -0.02836526f, -0.02991650f, -0.04176252f, 0.00749060f, 
    -0.03689610f, -0.01345661f, 0.00851381f, 0.03081414f, -0.00133972f, -0.01673231f, -0.05208586f, -0.06065329f, 
    -0.02458308f, -0.03427691f, -0.06812689f, -0.01822573f, -0.03806046f, 0.01315312f, 0.00892081f, -0.02009436f, 
    -0.06585772f, -0.04806162f, 0.01352229f, -0.05822270f, -0.03235261f, 0.02152676f, -0.04347606f, -0.00420903f, 
    -0.06913742f, 0.02409061f, -0.04118822f, -0.06638604f, 0.01846241f, 0.00205531f, -0.04614560f, 0.03518556f, 
    -0.06924865f, -0.03600536f, -0.05136627f, -0.00812465f, 0.00751708f, 0.02112797f, -0.04556420f, -0.00779162f, 
    0.02821650f, -0.03766514f, -0.03759667f, -0.03448227f, -0.03441726f, -0.02427151f, 0.01657153f, -0.01684163f, 
    -0.01175185f, -0.03410539f, -0.05412686f, 0.01814297f, -0.05534564f, -0.00844978f, -0.03157216f, -0.06562234f, 
    0.01619065f, 0.02695342f, 0.00048815f, 0.00272402f, 0.01618882f, -0.01249332f, -0.01413108f, -0.01734324f, 
    -0.04779673f, -0.05831626f, -0.04893189f, 0.03164154f, -0.01822406f, 0.00096438f, -0.05258280f, -0.04248911f, 
    0.00329216f, 0.01201376f, -0.03672671f, 0.04414650f, 0.00703785f, 0.00388196f, 0.02587011f, -0.05713269f, 
    0.02897184f, -0.04255676f, -0.04279699f, -0.00205910f, 0.00197601f, -0.06091816f, -0.04745320f, -0.04136054f, 
    -0.03798741f, -0.00979937f, -0.02141711f, -0.01620383f, 0.02738681f, -0.04524717f, 0.02244141f, -0.04387254f, 
    0.03145521f, -0.02903923f, -0.03310727f, 0.01676169f, -0.01913164f, -0.05692354f, 0.03690163f, -0.04766393f, 
    -0.02681602f, -0.03159830f, -0.06272138f, -0.00450487f, 0.00516238f, -0.02133988f, 0.01984259f, -0.00357561f, 
    -0.06163531f, -0.05772500f, 0.03997240f, 0.02144136f, 0.02814516f, -0.01160373f, -0.03117869f, -0.04113350f, 
    0.01596456f, -0.04336804f, -0.05700748f, -0.01960133f, 0.00645880f, -0.05473997f, -0.06145603f, -0.06480931f, 
    -0.05764276f, 0.01806915f, -0.02465046f, -0.06287187f, -0.03915578f, -0.02435776f, 0.00666739f, 0.00551516f, 
    -0.02922227f, -0.05372468f, -0.01745360f, -0.04447837f, -0.03187469f, -0.03021167f, -0.04125791f, -0.02185055f, 
    -0.03847677f, 0.03946479f, 0.01779521f, -0.02605659f, -0.03608892f, 0.01334173f, 0.00925266f, 0.04251680f, 
    0.01382739f, -0.00039448f, -0.02004999f, 0.01390752f, 0.00422833f, -0.05293665f, 0.01863725f, -0.02764287f, 
    -0.00671167f, 0.02015087f, -0.04679624f, -0.00681816f, -0.00829107f, 0.02208872f, -0.04019113f, -0.05944699f, 
    -0.01908182f, -0.02851171f, -0.01988397f, 0.00848511f, -0.04832510f, -0.03372024f, 0.02041107f, 0.00808996f, 
    -0.00748803f, 0.03359238f, 0.03415548f, 0.00597062f, 0.01221501f, -0.02329735f, -0.04299475f, -0.00409147f, 
    0.03039451f, -0.04462758f, 0.00405227f, 0.00543732f, 0.03332131f, -0.00534292f, -0.05418746f, -0.01352416f, 
    0.03106540f, -0.05115112f, 0.03834121f, 0.02257404f, -0.03042413f, -0.04378682f, -0.02971953f, 0.01883489f, 
    -0.01676789f, 0.04214329f, -0.01109776f, 0.01503814f, -0.04810017f, -0.04411881f, -0.00479692f, 0.02011872f, 
    0.01659913f, -0.03591852f, 0.01213176f, -0.03012881f, -0.01007732f, -0.00773514f, -0.04961985f, -0.04190417f, 
    -0.00080719f, -0.03839247f, -0.02263004f, -0.02780511f, -0.03702633f, 0.00303276f, 0.02357874f, 0.01851332f, 
    0.02919428f, -0.05369240f, -0.02736509f, -0.01185121f, 0.01074481f, 0.03120835f, -0.01021412f, 0.02785163f, 
    -0.01190853f, -0.05795478f, 0.04281728f, -0.05403577f, -0.02780722f, -0.01747580f, -0.01907636f, 0.04298102f, 
    -0.03287953f, -0.01084183f, 0.03378109f, 0.04171595f, -0.04506282f, -0.04526634f, -0.04803902f, 0.03161922f, 
    0.00705303f, -0.05500877f, -0.03530617f, 0.00447646f, -0.03894987f, 0.03616118f, -0.00250670f, 0.02556630f, 
    -0.02167143f, 0.00718444f, -0.05043437f, 0.00896591f, 0.00300448f, -0.01382689f, 0.00234339f, -0.05454906f, 
    0.01198195f, -0.03987556f, 0.04737556f, -0.02017837f, -0.02527976f, -0.01078896f, -0.03606063f, -0.04341336f, 
    -0.03257069f, 0.04606576f, -0.02898853f, -0.00952324f, -0.00657892f, 0.01203115f, 0.02875914f, -0.02395550f, 
    -0.00661698f, 0.04651747f, -0.00161425f, 0.00695241f, 0.04248911f, -0.03542179f, 0.01075547f, -0.02060708f, 
    -0.01370972f, 0.02021964f, -0.02853175f, -0.04814261f, 0.00411602f, -0.02390735f, -0.02193468f, 0.03851751f, 
    0.04166121f, -0.02485733f, -0.01904816f, 0.03169524f, 0.04120052f, 0.03320042f, -0.03297147f, 0.01227282f, 
    0.03146662f, 0.01466056f, -0.04721491f, -0.02027754f, -0.02382276f, -0.02238660f, -0.03324226f, -0.00563959f, 
    0.02505046f, -0.05044635f, 0.00008313f, 0.03198435f, 0.03151562f, -0.01027046f, 0.03367856f, -0.00010632f, 
    -0.02700815f, 0.02038332f, 0.00035588f, -0.01950976f, 0.00567893f, 0.02347677f, -0.05622501f, -0.04730665f, 
    0.02344171f, -0.04587565f, -0.04933834f, -0.04428196f, -0.03409109f, 0.01556423f, -0.00072432f, 0.00115544f, 
    -0.02040495f, -0.02668499f, 0.02191934f, -0.03136129f, -0.05232066f, 0.02891360f, -0.00642913f, 0.00719997f, 
    -0.01980451f, -0.04752218f, 0.03992745f, -0.00646848f, -0.04506251f, 0.01203995f, -0.04640743f, -0.05115040f, 
    0.03749835f, -0.01712793f, 0.04145181f, -0.02092713f, -0.00010919f, 0.01899311f, 0.04726882f, 0.00022969f, 
    0.01677624f, -0.05417228f, 0.02637308f, -0.04941703f, -0.01221171f, -0.01649584f, 0.01572992f, 0.01430675f, 
    0.04537355f, -0.02624347f, -0.02372393f, -0.02807876f, -0.04923536f, 0.00389676f, 0.02732403f, -0.04876470f, 
    0.01381972f, -0.04578467f, -0.05259147f, 0.04223459f, -0.04119635f, -0.01407988f, -0.05634486f, 0.02719207f, 
    0.01833128f, -0.01838880f, 0.02537474f, -0.02321696f, 0.02695424f, -0.01140409f, 0.01867721f, -0.05359822f, 
    -0.01837318f, 0.00872361f, -0.02394029f, 0.03381189f, -0.04121163f, -0.00706009f, 0.03014528f, -0.01727236f, 
    -0.01933059f, 0.04625768f, 0.02857993f, -0.05309477f, 0.03300382f, 0.04216173f, -0.05117369f, -0.02500239f, 
    0.02805622f, 0.01312117f, 0.02516411f, -0.02519812f, -0.03158708f, 0.01361710f, 0.03291436f, 0.02871411f, 
    -0.00735558f, 0.01071267f, 0.04225013f, 0.00777824f, -0.05758237f, -0.04251600f, -0.01788548f, 0.00173172f, 
    -0.03881210f, -0.05156199f, -0.01792858f, -0.04715521f, 0.03481763f, -0.04776433f, -0.01500068f, 0.01190928f, 
    0.02257170f, -0.00054022f, 0.03190375f, -0.05905658f, -0.03977091f, -0.01159212f, -0.01112749f, -0.00459070f, 
    0.02215727f, 0.03286926f, 0.02039788f, 0.02548962f, -0.01704191f, 0.03576612f, -0.00396830f, 0.04085122f, 
    0.04009071f, 0.01676105f, 0.01938548f, 0.00461963f, -0.05134065f, -0.05392505f, -0.00872671f, -0.00907375f, 
    -0.02854395f, -0.04517287f, 0.02538958f, -0.03290431f, -0.01844429f, 0.02250171f, -0.03412256f, 0.02911943f, 
    -0.05217211f, -0.05429141f, -0.04457950f, 0.02502040f, 0.00601880f, -0.01966672f, 0.02127820f, 0.00057018f, 
    -0.03864564f, -0.03269166f, -0.02274771f, -0.02380199f, -0.02914810f, -0.00991766f, 0.00559636f, 0.00879021f, 
    0.00956705f, 0.04177067f, 0.02694255f, 0.02746799f, -0.00916274f, -0.00216826f, -0.04345059f, -0.01711647f, 
    -0.05640255f, -0.00059988f, -0.03207876f, 0.00483521f, 0.02843121f, -0.04128087f, -0.05223944f, -0.01833872f, 
    -0.05833801f, 0.02969308f, -0.03552152f, 0.00577195f, 0.00130800f, 0.03470267f, 0.02977888f, -0.04284532f, 
    -0.00841935f, -0.02508383f, 0.01730784f, 0.01303810f, -0.05312882f, 0.03113978f, -0.02061684f, 0.01095237f, 
    -0.03983169f, -0.00383730f, -0.05811143f, -0.01592892f, -0.04818439f, -0.02404104f, 0.01250811f, 0.00953744f, 
    0.23964378f, 0.15142037f, -0.09706523f, -0.00382073f, 0.22286935f, 0.29175788f, 0.04616196f, 0.05051867f, 
    0.12465359f, -0.08476588f, 0.01949962f, 0.01168461f, 0.28207734f, -0.08215162f, -0.27258366f, -0.10079265f, 
    0.22064114f, 0.22928688f, -0.10220433f, 0.06864654f, 0.07428766f, 0.05847745f, -0.02056784f, -0.04880194f, 
    0.06007035f, 0.06346765f, 0.00822384f, 0.03883480f, 0.03786591f, 0.14564742f, -0.04237216f, -0.01479925f, 
    -0.00015182f, -0.07242925f, 0.12007758f, 0.04506489f, -0.37174538f, -0.25010917f, -0.26165393f, -0.12494880f, 
    0.00508698f, -0.11091824f, 0.00632323f, -0.03321989f, -0.04086487f, -0.11242998f, 0.10184541f, 0.11513083f, 
    -0.27383876f, 0.04123322f, 0.01927725f, -0.06983943f, -0.02240071f, 0.01651387f, 0.06126973f, -0.02308208f, 
    -0.01492474f, 0.13346560f, 0.09887468f, -0.03310603f, -0.18076171f, -0.26502019f, 0.04106778f, -0.06627978f, 
    -0.17655490f, 0.07416369f, -0.00412343f, 0.04372729f, -0.12951654f, 0.00455492f, -0.02616716f, -0.05181747f, 
    -0.34787837f, 0.05947523f, 0.10418301f, 0.08827930f, -0.10058392f, -0.07182185f, -0.06180733f, -0.28334370f, 
    0.03992983f, 0.12187306f, -0.02149613f, 0.00315842f, 0.36818805f, -0.36591038f, 0.02685792f, 0.17004383f, 
    0.00721082f, 0.31987712f, -0.04993173f, 0.13291326f, 0.11898963f, -0.00505150f, 0.25201449f, -0.10206126f, 
    0.08783769f, 0.14239120f, 0.04170313f, -0.23069543f, 0.13803361f, 0.03355893f, 0.04954089f, 0.11580266f, 
    0.13467906f, -0.00509639f, -0.00725438f, 0.10008258f, 0.17250203f, -0.09199796f, -0.08399983f, 0.01804464f, 
    0.05254241f, 0.16803694f, 0.00190479f, 0.16319507f, -0.00949643f, 0.09154874f, 0.01397714f, 0.17370105f, 
    -0.29812413f, -0.23327070f, 0.09852603f, -0.06973440f, -0.02495826f, -0.03276658f, -0.14320502f, -0.07001637f, 
    -0.27319255f, -0.20197612f, -0.00022904f, -0.19841222f, -0.09034742f, 0.01636605f, -0.16033955f, 0.00748250f, 
    0.10075009f, 0.02273680f, 0.02050595f, -0.14552546f, 0.04870725f, 0.27137858f, 0.21406056f, 0.09636842f, 
    -0.26665133f, -0.10114902f, 0.07461585f, 0.07001372f, 0.10769618f, -0.06772402f, 0.04840148f, -0.09912101f, 
    -0.07027503f, 0.14066391f, 0.10810948f, 0.23015390f, 0.20446806f, 0.26677847f, 0.05437898f, -0.05949657f, 
    0.04629683f, 0.05805619f, 0.05932363f, 0.16533977f, 0.07292944f, 0.14499474f, -0.03159922f, -0.17482838f, 
    0.12236222f, -0.02551729f, -0.03762429f, -0.25534344f, -0.12604116f, -0.09895200f, 0.04679359f, 0.10945946f, 
    0.07771172f, -0.05456360f, 0.15612856f, -0.00828633f, -0.09964712f, 0.10528304f, 0.01948218f, -0.14367439f, 
    -0.09185420f, 0.01616397f, 0.11350780f, -0.06011628f, 0.30073339f, 0.18064481f, 0.08209059f, 0.26413712f, 
    -0.07187974f, -0.05264496f, 0.07665170f, -0.06146827f, -0.07242080f, 0.02341162f, -0.09158045f, -0.11759387f, 
    0.04858439f, 0.08865971f, 0.18003313f, 0.00472794f, 0.04753766f, 0.31391990f, -0.10221452f, -0.20241235f, 
    0.01199878f, 0.05148793f, 0.01816779f, 0.00459799f, 0.20945100f, -0.15475275f, 0.21822676f, 0.03930131f, 
    0.25084588f, 0.12269091f, -0.13978113f, -0.05841731f, 0.01367607f, 0.09090851f, 0.07651060f, -0.02907887f, 
    -0.02879826f, -0.00897020f, 0.01135777f, -0.01601539f, -0.14939895f, 0.09984363f, -0.08752090f, 0.13193993f, 
    -0.03632176f, -0.11320008f, 0.19813454f, 0.00965757f, -0.08710803f, 0.01506433f, 0.05068282f, 0.06528608f, 
    0.07631576f, -0.00935141f, 0.08203216f, 0.00037240f, 0.05265117f, 0.10921461f, -0.01392589f, 0.10670744f, 
    0.01932471f, 0.06407578f, 0.07121008f, -0.11007921f, 0.16741897f, 0.12379923f, 0.04019855f, -0.08156300f, 
    0.01775367f, 0.16973859f, 0.02706444f, 0.30708686f, -0.02617758f, 0.03290251f, 0.06696536f, 0.12607200f, 
    -0.05638034f, 0.19889228f, -0.22523513f, 0.16989233f, 0.05300273f, -0.04155590f, 0.18101546f, -0.14911222f, 
    0.08909821f, 0.06762712f, 0.13335028f, 0.19244592f, 0.07224265f, 0.02373889f, -0.19976376f, 0.12262116f, 
    0.00069040f, -0.01583921f, 0.04921428f, -0.06109218f, 0.06603976f, 0.03264977f, 0.05057579f, 0.16658425f, 
    -0.40211758f, -0.04700673f, 0.03281723f, 0.02777159f, -0.03113879f, -0.08102603f, 0.09089383f, 0.02086904f, 
    0.00287766f, 0.02918712f, -0.13778579f, 0.20225993f, 0.02118966f, 0.42787778f, -0.35076386f, -0.19485141f, 
    0.03670252f, -0.10450906f, -0.03567424f, 0.21014023f, 0.05757559f, -0.10148270f, -0.00194980f, -0.02718389f, 
    0.13806432f, 0.02449805f, -0.13376425f, -0.19612625f, 0.12721319f, 0.06172960f, 0.07716965f, 0.01438075f, 
    0.02001929f, 0.06926245f, 0.02030507f, 0.15496682f, -0.36710188f, -0.10562966f, 0.01324069f, -0.12194001f, 
    -0.03965210f, -0.04111877f, -0.07445510f, -0.04115038f, -0.04043576f, 0.09453597f, 0.02158691f, -0.01397241f, 
    0.28401768f, 0.29498172f, -0.02866352f, -0.07726896f, 0.12223629f, 0.01287304f, -0.01740174f, 0.02869190f, 
    -0.03313957f, -0.06557496f, -0.05821420f, -0.11380870f, 0.02379465f, 0.45530820f, 0.31645527f, -0.14933592f, 
    0.11722215f, 0.01893536f, 0.10533526f, 0.10742284f, 0.13096224f, -0.04779980f, -0.04609038f, -0.27323529f, 
    -0.03508817f, -0.03621328f, -0.10573210f, -0.06012457f, -0.06273773f, -0.05810193f, -0.13119288f, 0.14491431f, 
    -0.07041295f, -0.21503817f, -0.08945316f, 0.03399688f, -0.28131548f, -0.09973751f, 0.06794338f, -0.11403228f, 
    -0.02170619f, 0.07420433f, -0.03185780f, -0.04318590f, 0.22771826f, 0.09035358f, 0.23618321f, 0.10317864f, 
    0.01616599f, -0.14186466f, -0.18080711f, 0.10400311f, 0.11676918f, -0.02630454f, 0.03133812f, 0.12363061f, 
    0.09942452f, 0.01474303f, -0.07055753f, 0.12009899f, -0.11549224f, -0.19345258f, -0.05169651f, -0.06741764f, 
    0.10177267f, -0.00359619f, 0.01333213f, 0.15021327f, 0.00723199f, -0.18568702f, 0.06083526f, -0.05456513f, 
    0.03479316f, 0.12722699f, -0.07690564f, -0.04363996f, 0.04023753f, 0.15741082f, -0.08677540f, -0.00901831f, 
    -0.02110367f, 0.21175183f, -0.03001570f, -0.07054718f, -0.30212271f, -0.11683422f, 0.08800942f, 0.20138726f, 
    -0.15905553f, 0.05741689f, 0.04330271f, 0.19267817f, 0.02796528f, 0.05277759f, 0.14938796f, -0.11166275f, 
    0.40949932f, 0.00674807f, -0.05810623f, -0.14278035f, 0.09145793f, -0.06299490f, -0.02616754f, -0.00383919f, 
    0.14201941f, 0.17590007f, 0.09097807f, 0.06679823f, -0.11773276f, -0.19129533f, 0.08335955f, -0.10793857f, 
    0.01726001f, -0.00060688f, 0.19755657f, -0.18261607f, -0.10033821f, 0.20010784f, -0.04367472f, 0.11143573f, 
    0.08791993f, 0.30361381f, -0.12376992f, -0.08899847f, 0.05348732f, -0.05174421f, 0.01488576f, -0.14570357f, 
    0.02398558f, 0.04520457f, -0.07006740f, -0.07717822f, -0.40716240f, 0.24773093f, -0.04349353f, 0.48081967f, 
    -0.01412235f, 0.20875931f, 0.10041408f, 0.05445745f, 0.04068034f, 0.17607550f, 0.02279261f, -0.06105110f, 
    0.35310629f, 0.08912641f, 0.27797389f, 0.38379306f, 0.03806510f, 0.14068952f, 0.09075255f, 0.09825300f, 
    0.09177689f, 0.02082315f, 0.03444902f, 0.06289348f, -0.16219299f, 0.16214891f, 0.10943336f, 0.34749582f, 
    -0.09746356f, 0.07538584f, -0.01021956f, 0.22415432f, -0.09268378f, 0.00751364f, 0.02142705f, -0.02073122f, 
    -0.17102696f, -0.04358573f, -0.03809347f, -0.08758747f, -0.06622070f, -0.12472202f, -0.03754883f, 0.00338677f, 
    0.14777836f, -0.04566957f, -0.07495074f, -0.19853355f, -0.05654429f, -0.04689962f, 0.03945542f, -0.11591114f, 
    0.06550258f, 0.02906103f, 0.10429852f, 0.09350140f, 0.21352196f, 0.10261437f, 0.00658996f, -0.04075197f, 
    0.03194186f, 0.05985328f, -0.06507117f, -0.13929330f, 0.02282901f, -0.01962028f, 0.12894952f, -0.15079892f, 
    0.12034027f, 0.11519302f, 0.14193638f, 0.11310124f, 0.36116582f, 0.20507251f, 0.21249337f, 0.07564780f, 
    0.01414055f, 0.02130374f, 0.02715037f, -0.10632838f, 0.04709652f, -0.01330917f, -0.05678712f, 0.26571462f, 
    -0.11737819f, 0.58197290f, 0.10452154f, 0.15993795f, -0.06442045f, -0.15813416f, 0.07843266f, 0.12811619f, 
    -0.11278351f, 0.15161794f, 0.03561461f, -0.03365504f, 0.25845483f, -0.02236820f, -0.02203805f, -0.07368422f, 
    -0.02795601f, 0.05096287f, 0.02463207f, -0.09147834f, 0.18425153f, -0.02478964f, 0.05820372f, 0.03081605f, 
    -0.16434494f, -0.03180152f, -0.07777944f, -0.21097349f, 0.03431497f, 0.01639632f, -0.14562097f, 0.00780644f, 
    0.04310269f, -0.01147824f, 0.07866968f, 0.15558690f, 0.10728599f, 0.47901392f, -0.42779526f, 0.05189681f, 
    0.01745316f, -0.00143485f, -0.18112867f, -0.09443406f, 0.06186506f, 0.24435291f, -0.20488811f, 0.08363447f, 
    -0.12215963f, 0.16598035f, 0.08274531f, 0.27641529f, 0.11513507f, 0.04815536f, 0.06057324f, 0.17650735f, 
    0.02813433f, -0.05389021f, -0.05918375f, -0.18162316f, 0.26660788f, -0.01303701f, 0.06426596f, -0.10728617f, 
    0.00878674f, -0.18942103f, 0.30641162f, -0.04226982f, 0.06016451f, 0.10331301f, 0.07482258f, 0.14528802f, 
    0.01983933f, 0.17417140f, 0.01691067f, 0.20201376f, -0.05598913f, 0.01980076f, 0.09765767f, 0.14878047f, 
    -0.13984661f, -0.11943827f, -0.09131631f, -0.02346183f, 0.20225932f, -0.01650891f, 0.00432625f, 0.19388722f, 
    0.04330938f, 0.09482563f, 0.08366215f, 0.11180847f, 0.12966229f, 0.03342347f, 0.09833667f, 0.16495383f, 
    0.09132411f, 0.12772024f, 0.10129531f, 0.18951266f, 0.05067587f, -0.18546361f, -0.11733624f, -0.13284658f, 
    -0.05850765f, -0.10795710f, 0.06229208f, 0.14926000f, 0.13962954f, 0.31326839f, -0.20201626f, -0.17848611f, 
    0.11799540f, 0.04342698f, -0.21449935f, 0.07851917f, 0.17294705f, -0.02327322f, 0.13090146f, -0.02458594f, 
    -0.29824483f, 0.35493225f, 0.06481847f, 0.14688140f, -0.05850972f, 0.03902155f, -0.03755372f, 0.00337986f, 
    -0.05018304f, -0.00938931f, 0.10796806f, -0.06013597f, -0.11752726f, 0.17897332f, 0.12252166f, 0.11872010f, 
    0.05981518f, -0.10452116f, 0.10382164f, -0.11923907f, -0.04397015f, 0.12054875f, -0.04410023f, 0.10198701f, 
    0.34374991f, 0.09168209f, 0.19279820f, 0.49392024f, 0.16293561f, 0.09166314f, 0.12634514f, 0.25573280f, 
    0.00242652f, 0.01279591f, 0.04535205f, 0.00894016f, -0.30001521f, 0.09638428f, 0.14005494f, -0.12506913f, 
    -0.01216225f, 0.11230905f, 0.04836408f, 0.06943206f, 0.10565613f, 0.05885381f, -0.00118205f, 0.20867561f, 
    -0.10086953f, 0.05880408f, 0.13384379f, -0.06815552f, 0.07548460f, 0.12072256f, 0.06599743f, 0.12106378f, 
    0.06425042f, 0.06773753f, 0.23413651f, -0.01090807f, 0.14073989f, -0.16845219f, 0.28166521f, -0.01880374f, 
    0.02122184f, -0.06056255f, -0.02365665f, -0.10703687f, 0.03782688f, -0.00319441f, 0.09220904f, -0.09548596f, 
    0.00084595f, -0.12865323f, 0.03219019f, 0.01540530f, 0.02114824f, -0.04185988f, 0.11384252f, 0.19982068f, 
    -0.11489443f, 0.00233568f, -0.08055319f, -0.19634266f, 0.09713680f, -0.09809449f, 0.07594119f, -0.04297871f, 
    0.14391965f, -0.07687224f, -0.11665834f, -0.01916653f, 0.04917111f, 0.08839408f, 0.17168711f, 0.12169423f, 
    -0.02884309f, 0.25927919f, 0.00790569f, -0.25072673f, -0.01271452f, 0.12623990f, -0.05007046f, 0.17330435f, 
    0.03807220f, -0.05255977f, -0.04775238f, -0.03683446f, 0.01681407f, 0.17805178f, -0.11834445f, -0.25834143f, 
    0.13513418f, 0.07713959f, 0.02945857f, 0.13730101f, 0.00094350f, -0.07705481f, 0.07716357f, -0.20972568f, 
    -0.00319291f, 0.23496361f, 0.15389889f, 0.00043200f, 0.09772623f, 0.03612196f, 0.02019729f, -0.02371006f, 
    -0.03967012f, 0.01445484f, -0.04791058f, 0.07567170f, -0.04809997f, -0.25008133f, -0.24296859f, -0.06045751f, 
    -0.01121908f, 0.18089096f, 0.06240541f, -0.03750649f, -0.02809890f, -0.12038280f, 0.25694433f, -0.08879609f, 
    -0.51649940f, -0.15008070f, -0.02238998f, -0.09246340f, -0.18184683f, -0.13715497f, -0.05946774f, 0.13937545f, 
    0.14947124f, 0.10703835f, 0.11083934f, 0.02243538f, -0.19396116f, -0.04235778f, 0.10329511f, 0.07660751f, 
    0.06154095f, -0.26862982f, 0.06120432f, 0.04714591f, 0.08067455f, 0.12554120f, -0.32896137f, -0.03565787f, 
    -0.20669028f, 0.15872316f, -0.01860294f, 0.16976757f, 0.07472310f, -0.13279685f, 0.06923083f, 0.14787573f, 
    0.16156913f, 0.05938753f, -0.05781979f, 0.14630124f, 0.43180427f, -0.12294205f, -0.10343515f, -0.06090572f, 
    0.06323817f, 0.00940439f, 0.07224631f, 0.10658398f, 0.15604703f, -0.09874719f, 0.06752849f, 0.00335073f, 
    0.14279960f, 0.10773301f, 0.23405635f, 0.05863213f, 0.09553661f, 0.24146877f, 0.07330202f, -0.01885228f, 
    0.00589183f, -0.14305995f, -0.07527074f, 0.20466147f, 0.10631130f, 0.08211867f, -0.21478303f, -0.10622693f, 
    -0.00781931f, 0.06032019f, -0.01235095f, 0.07139895f, 0.06761350f, -0.06608576f, -0.00109490f, -0.08374440f, 
    0.04358679f, -0.03227293f, -0.03739329f, 0.00268155f, -0.02765832f, 0.05725235f, -0.00026947f, 0.12681258f, 
    -0.00230242f, -0.17575726f, 0.00009792f, -0.15772644f, -0.23359060f, 0.04076673f, -0.18683566f, -0.10097358f, 
    -0.13134383f, 0.19438645f, 0.18332762f, -0.04895541f, 0.10976818f, 0.14222249f, 0.02644850f, -0.00464595f, 
    -0.24561325f, -0.19334659f, -0.15388371f, -0.19552626f, -0.06805689f, -0.15230872f, -0.00704361f, -0.12691109f, 
    0.03478101f, -0.02490899f, 0.06700051f, 0.00864994f, -0.07556025f, 0.22993460f, 0.42383999f, 0.00283573f, 
    -0.02025744f, 0.15487206f, 0.27080995f, 0.15519091f, 0.03449181f, 0.16986838f, -0.17827861f, -0.09250130f, 
    0.27090093f, 0.09360553f, 0.01614233f, -0.09146159f, 0.03385034f, -0.03286786f, -0.15636863f, 0.04615504f, 
    -0.09476183f, 0.00461610f, -0.14733638f, 0.10646268f, 0.04299610f, 0.10828394f, -0.00494509f, 0.11912452f, 
    -0.11000295f, 0.19501112f, 0.06889843f, -0.05492885f, 0.15326965f, -0.01854100f, -0.07998493f, -0.01180313f, 
    -0.01914180f, 0.08482801f, -0.13314722f, 0.14077649f, -0.10527748f, -0.09662894f, -0.12725668f, 0.06790939f, 
    0.10651557f, 0.04026812f, 0.07731134f, -0.09479828f, -0.28569940f, 0.28520489f, 0.12308718f, -0.07786833f, 
    0.01826726f, -0.11826500f, 0.23102029f, -0.14023356f, 0.14804107f, 0.28045478f, 0.01583936f, -0.21082331f, 
    0.15834829f, 0.38488492f, 0.09402060f, -0.10164741f, 0.02275277f, -0.12377139f, 0.06031884f, -0.01015532f, 
    0.03849293f, 0.08147341f, 0.15762822f, -0.02261702f, -0.12851314f, -0.08375072f, -0.07234520f, -0.06138208f, 
    -0.03223513f, -0.08848451f, 0.15145101f, -0.08655491f, -0.14432479f, 0.10670735f, 0.14037073f, -0.13011931f, 
    0.09617312f, 0.16962630f, 0.15524216f, 0.08506531f, -0.04540794f, 0.06759813f, 0.02917995f, 0.08535084f, 
    -0.05644156f, -0.13500796f, 0.01835401f, 0.11091156f, 0.11278875f, 0.15089643f, 0.06323368f, -0.03064459f, 
    0.14128819f, 0.14021803f, 0.22302453f, 0.13557315f, -0.05849917f, -0.02155297f, 0.03034513f, 0.01271881f, 
    0.15760441f, 0.15472418f, 0.00730070f, 0.06925624f, -0.11841538f, 0.03262765f, -0.07008383f, -0.03406945f, 
    0.07345180f, -0.09997842f, 0.14483362f, 0.23337901f, -0.03441282f, -0.15563953f, 0.05514219f, -0.10808302f, 
    -0.00670682f, -0.22429623f, -0.11722779f, -0.11770009f, 0.10809916f, 0.07476491f, 0.18051018f, 0.13817917f, 
    0.48838899f, -0.07109865f, -0.14173950f, 0.26461959f, 0.01840445f, 0.11700067f, 0.01829344f, 0.04489332f, 
    -0.00022768f, -0.17755461f, 0.18829793f, -0.04867369f, -0.07314698f, 0.03707041f, 0.17375176f, 0.08776084f, 
    0.13705271f, 0.00452241f, -0.10938813f, 0.03069323f, 0.09305800f, -0.05343461f, -0.02179306f, 0.14760955f, 
    0.16584028f, 0.13824995f, 0.15772215f, 0.01972048f, 0.26311526f, 0.28709367f, 0.12558363f, 0.05053254f, 
    -0.08648158f, -0.04102458f, 0.04347648f, 0.18465415f, 0.08137356f, -0.02727347f, -0.04583938f, 0.26152012f, 
    -0.11814283f, 0.00585190f, 0.22141173f, 0.06956358f, 0.04616909f, -0.05605735f, -0.02346440f, -0.07629067f, 
    0.17274849f, 0.38113725f, 0.35319948f, 0.06377918f, 0.10206465f, -0.07696487f, 0.04842983f, 0.09404442f, 
    0.05240533f, -0.00705035f, -0.06138304f, 0.04323045f, -0.03796972f, -0.24482766f, 0.33116424f, 0.05875637f, 
    -0.03235712f, 0.07959323f, -0.09897862f, 0.21709765f, -0.02655316f, -0.17051427f, -0.12461736f, 0.06028304f, 
    0.11195949f, -0.00086853f, -0.28490496f, -0.07340138f, -0.04106617f, 0.00278382f, -0.10178585f, 0.31403551f, 
    -0.01435451f, 0.10109971f, -0.10295825f, -0.02880665f, -0.22520845f, -0.00043060f, 0.10572204f, 0.28460205f, 
    -0.02159240f, -0.01510771f, -0.07254417f, 0.14663093f, 0.09013118f, 0.03472389f, -0.04515006f, 0.15886788f, 
    0.02560060f, 0.21109949f, 0.07231938f, -0.06681555f, 0.06666018f, 0.07018080f, 0.20937009f, 0.06622818f, 
    -0.02112947f, -0.02668590f, 0.06944267f, 0.11781140f, 0.17396294f, 0.19624750f, -0.05042489f, 0.09696937f, 
    0.01013712f, 0.09587126f, 0.25304493f, -0.06113077f, 0.01121947f, 0.02073571f, -0.05241873f, -0.04343925f, 
    -0.13969462f, -0.24861646f, -0.05009524f, -0.02491881f, -0.01178788f, -0.18058783f, 0.30441216f, -0.03439685f, 
    -0.06878112f, -0.04516540f, -0.07765613f, -0.02076222f, 0.11245911f, 0.29197687f, 0.35133183f, -0.09643044f, 
    -0.10342984f, -0.17461532f, -0.08295222f, -0.08162123f, 0.21228006f, 0.05958695f, -0.01181022f, 0.17196168f, 
    -0.30899850f, -0.41217768f, -0.02898529f, -0.14288165f, -0.08261580f, -0.02262582f, -0.02801809f, -0.06213987f, 
    0.00419450f, 0.01577330f, -0.05218512f, -0.06932050f, -0.06876514f, 0.28772441f, 0.12883031f, -0.07279809f, 
    -0.04503911f, 0.05232949f, -0.11765902f, 0.11600874f, 0.08862159f, 0.06990497f, 0.11116555f, 0.05388568f, 
    -0.07469081f, -0.05111286f, 0.03004012f, -0.12033929f, 0.08788455f, 0.10302407f, -0.26216865f, 0.15056530f, 
    0.02774336f, 0.10318412f, 0.17300984f, 0.13217679f, -0.04505031f, -0.15771511f, -0.00526096f, 0.28790110f, 
    0.04669355f, 0.04093012f, 0.13562860f, 0.16101937f, -0.01625311f, 0.03780610f, 0.11892620f, 0.14500916f, 
    0.20178273f, -0.12938702f, -0.08806811f, -0.11613175f, 0.22151463f, 0.01818984f, -0.02451489f, 0.07931736f, 
    0.07113960f, -0.09423064f, 0.15484399f, -0.15080817f, -0.21859317f, -0.26551163f, -0.20662591f, 0.09376426f, 
    0.11591871f, 0.07871547f, 0.29550824f, 0.13694967f, 0.08657266f, 0.05800400f, 0.09636633f, 0.06750754f, 
    -0.12898833f, -0.15773961f, 0.25620291f, 0.13664356f, -0.04818773f, -0.07770269f, -0.04815052f, -0.15806542f, 
    0.08265260f, -0.17215012f, 0.11326537f, -0.08017977f, 0.04750108f, 0.02520844f, -0.08328019f, -0.08235259f, 
    0.04124242f, 0.01545500f, -0.05773172f, -0.03907651f, -0.03986268f, 0.02014606f, -0.03695734f, 0.04503515f, 
    -0.15441959f, -0.23161222f, -0.04812327f, 0.01299133f, 0.06107619f, 0.12333334f, -0.20733763f, 0.06274995f, 
    -0.07175715f, 0.07635006f, -0.07845107f, -0.00146938f, 0.29946318f, 0.15857433f, 0.21538146f, -0.22278893f, 
    0.20456444f, 0.05096997f, -0.00983275f, 0.22810075f, -0.12704675f, 0.19117084f, -0.07014245f, -0.03395653f, 
    -0.00733729f, -0.46496361f, 0.29268885f, -0.16395974f, 0.18111639f, 0.05060623f, -0.09318126f, 0.10061206f, 
    -0.02436630f, -0.07036691f, 0.04880585f, 0.24631558f, 0.19933777f, 0.11255049f, -0.11252610f, 0.09167264f, 
    0.05027362f, -0.12325239f, 0.02284276f, 0.04590100f, 0.04295607f, 0.14406992f, 0.09404650f, 0.05651794f, 
    -0.01910749f, -0.15901895f, -0.01314661f, 0.00473810f, -0.17906404f, -0.11713357f, 0.02720290f, -0.04354634f, 
    0.17091952f, 0.09729154f, 0.02315118f, 0.11860073f, 0.05604691f, -0.05046736f, -0.16647728f, 0.06316885f, 
    0.03183573f, -0.11095873f, 0.20772049f, -0.06610119f, 0.12655137f, -0.11883152f, 0.20296445f, 0.08651622f, 
    -0.16438842f, -0.36583698f, -0.14958017f, 0.00357576f, 0.06514370f, 0.13339561f, 0.18679541f, -0.00129799f, 
    -0.04319418f, -0.02720945f, 0.12460238f, -0.11564834f, 0.03318350f, -0.29079524f, -0.19891094f, 0.11579998f, 
    0.16282459f, 0.15661758f, 0.11141279f, 0.07584686f, -0.09513427f, -0.07293972f, 0.07066213f, -0.02373848f, 
    -0.05858065f, -0.09196890f, 0.20775886f, -0.20421048f, 0.03775546f, 0.07466806f, -0.12251398f, -0.04692175f, 
    0.09614762f, 0.03892335f, 0.11189816f, 0.01728316f, 0.03147222f, -0.03661449f, 0.04241633f, -0.08022572f, 
    -0.03936630f, 0.06751660f, -0.01736297f, 0.07579900f, -0.10546203f, -0.03737978f, -0.06471947f, -0.07251077f, 
    0.12784049f, -0.04411850f, -0.08447035f, -0.04919341f, 0.19547080f, 0.14328921f, 0.27849936f, 0.05279198f, 
    0.02926194f, 0.14238137f, 0.14785971f, 0.16388154f, 0.02729413f, -0.32702565f, -0.13179116f, -0.11303414f, 
    -0.03756981f, -0.05926489f, 0.05766168f, -0.10994917f, 0.01913778f, -0.02229217f, 0.04231207f, 0.11987399f, 
    0.21665460f, -0.18693654f, 0.26237375f, 0.24108277f, -0.06059987f, -0.04756450f, -0.26852152f, 0.12109993f, 
    0.11064812f, 0.10029930f, -0.08622097f, 0.15658832f, 0.17378229f, -0.08450537f, 0.14178348f, -0.05847194f, 
    0.07055490f, -0.09796374f, 0.00287855f, -0.03028129f, 0.15725392f, -0.12602803f, 0.37486225f, -0.03489147f, 
    0.04705656f, -0.05919483f, -0.03285525f, -0.06163039f, -0.06546403f, -0.03852263f, -0.07847387f, -0.12123618f, 
    -0.02940674f, -0.08703750f, -0.00524147f, -0.00602106f, 0.26084197f, 0.13528471f, -0.00385631f, 0.15916555f, 
    -0.21272247f, 0.13797128f, -0.09270052f, 0.10264522f, 0.04698620f, 0.17980936f, 0.09123614f, -0.07095950f, 
    0.07193393f, 0.03182771f, 0.02709580f, 0.08801349f, 0.08237588f, 0.03452565f, 0.09908216f, -0.06302744f, 
    -0.15927602f, -0.03118566f, -0.08307851f, 0.00603542f, 0.25451529f, 0.10819479f, -0.28078943f, -0.14963984f, 
    0.07528476f, -0.16335279f, -0.08506429f, -0.04010004f, -0.01780996f, 0.14925757f, 0.07809392f, 0.02697825f, 
    -0.07614174f, -0.18273926f, -0.30786160f, 0.00422456f, -0.02736768f, 0.16793466f, -0.03323130f, -0.04384950f, 
    -0.04515329f, -0.07019750f, 0.08031747f, 0.06232175f, 0.25423121f, 0.09254900f, -0.10422601f, -0.03014585f, 
    -0.08269340f, 0.05914037f, -0.00313606f, -0.12989256f, 0.12711459f, -0.00366346f, -0.01140722f, -0.02832157f, 
    0.19861810f, -0.04571699f, 0.17078294f, 0.12684274f, -0.01480933f, -0.02275246f, 0.02875718f, 0.02858805f, 
    0.03777411f, 0.02828849f, 0.13398553f, 0.15680158f, 0.09564303f, -0.02836379f, 0.11270048f, 0.00521427f, 
    -0.03147326f, 0.12900597f, -0.03618589f, 0.13997051f, 0.07745408f, 0.04923708f, 0.07351220f, 0.31859693f, 
    0.27408332f, 0.02489551f, -0.15390322f, -0.06296755f, -0.12886988f, -0.04368573f, -0.00808189f, -0.04733449f, 
    -0.05812652f, -0.10101952f, -0.12628956f, -0.14261125f, -0.28092739f, -0.02387671f, -0.10362706f, -0.04008148f, 
    0.16197649f, 0.10748036f, 0.06578044f, 0.08112631f, -0.16525486f, -0.04358632f, -0.02801089f, -0.20132805f, 
    0.41054127f, 0.22073880f, 0.31467867f, 0.34571552f, -0.13358156f, -0.07072109f, -0.10724461f, 0.05480848f, 
    0.11758567f, -0.08067968f, -0.00708294f, 0.06678479f, -0.08097270f, -0.13098516f, -0.21072561f, 0.09804010f, 
    0.11779777f, 0.02173457f, -0.01315055f, -0.30790940f, 0.08888582f, -0.21859133f, 0.03117572f, 0.08921311f, 
    0.01423082f, -0.04969079f, -0.02917656f, 0.12655555f, -0.01484709f, -0.15007682f, 0.04971274f, -0.22252083f, 
    0.11410021f, 0.13528484f, 0.10845929f, -0.03412682f, -0.16268323f, 0.21374890f, -0.03730463f, -0.22147636f, 
    -0.02008321f, 0.02017999f, -0.09990337f, -0.04340544f, 0.10740592f, -0.04830264f, 0.00125286f, 0.11514918f, 
    0.08286012f, 0.16504398f, 0.01351835f, -0.12725160f, -0.03579292f, -0.04065222f, 0.10328650f, 0.08686844f, 
    -0.03903279f, -0.00935892f, -0.06364158f, -0.08206241f, 0.30492574f, 0.37264252f, 0.09004323f, -0.04112716f, 
    -0.13376249f, -0.11670086f, -0.06389382f, -0.00075335f, -0.11109413f, 0.05068547f, -0.10041233f, 0.08757062f, 
    -0.22212827f, -0.17373224f, -0.17245701f, 0.02742329f, 0.05853684f, 0.04336005f, 0.11626593f, 0.07961525f, 
    0.25619173f, 0.22415943f, 0.19794564f, 0.33010572f, -0.18204522f, -0.18558225f, 0.08144131f, -0.05745827f, 
    0.02719501f, -0.01900802f, 0.13522656f, 0.00867006f, -0.16592297f, -0.39915624f, -0.26906151f, -0.23809360f, 
    0.03738903f, -0.00923988f, -0.13576372f, 0.08016526f, 0.09316745f, 0.08678247f, -0.07988569f, 0.08409008f, 
    -0.05496583f, -0.21235025f, -0.21209927f, -0.16168042f, -0.06402554f, 0.08870947f, -0.26392636f, 0.02600738f, 
    0.10777930f, 0.05264795f, -0.18366784f, -0.09849890f, 0.18649167f, -0.10782388f, 0.06491771f, 0.14250487f, 
    -0.02931838f, 0.33621612f, -0.44686174f, 0.07116738f, -0.07188453f, -0.05835586f, 0.01059407f, -0.04139256f, 
    0.02564804f, -0.05968995f, -0.06512719f, -0.03864538f, -0.09915942f, -0.13653952f, 0.18107103f, -0.18767646f, 
    0.15721162f, 0.10154061f, -0.05997936f, -0.08147249f, -0.28556487f, -0.22778255f, -0.24054208f, -0.34171692f, 
    0.13252027f, 0.02228963f, 0.13215652f, 0.00148494f, 0.13073765f, -0.13927402f, 0.02359955f, -0.09147048f, 
    0.00650003f, 0.07624979f, 0.07911944f, 0.04809850f, 0.12743735f, -0.22308490f, 0.15597895f, 0.12870054f, 
    -0.05870435f, -0.13479906f, -0.16468772f, -0.05950550f, 0.02174848f, -0.03805977f, 0.05190942f, 0.15600669f, 
    0.20640907f, -0.00260540f, -0.00654325f, -0.05117440f, -0.06617039f, 0.03044335f, -0.03344180f, 0.09136222f, 
    0.07060704f, -0.00796080f, 0.12417334f, 0.23101573f, 0.20279175f, -0.12538880f, -0.24001445f, -0.03432715f, 
    -0.03054847f, -0.01140995f, -0.05108007f, -0.10937743f, 0.02678264f, -0.14586189f, -0.20839919f, 0.18324876f, 
    0.20657344f, 0.11621413f, 0.07434527f, -0.02217411f, 0.05311356f, 0.15984102f, 0.06136648f, 0.07024909f, 
    0.11425524f, 0.10109506f, 0.20899780f, 0.09722319f, -0.00791847f, -0.00092498f, -0.10648461f, -0.04660379f, 
    0.03553446f, 0.06423216f, -0.09344672f, 0.03834255f, -0.12895413f, -0.19078936f, -0.01285050f, 0.00678476f, 
    -0.06586433f, 0.26915962f, -0.07417174f, -0.05284778f, 0.17033577f, -0.13607094f, -0.01843870f, -0.10167235f, 
    -0.18208338f, 0.09042008f, -0.14270854f, -0.20384824f, 0.14258003f, 0.24461995f, -0.05394040f, 0.28042233f, 
    0.00891620f, -0.10447907f, 0.05022160f, 0.11583010f, 0.11330922f, 0.10936829f, 0.01497154f, -0.00758545f, 
    -0.35229048f, -0.11017799f, -0.23629281f, -0.14328986f, 0.10083652f, -0.10782167f, 0.06054679f, -0.06676310f, 
    0.09657783f, -0.09164450f, -0.12504947f, 0.14913332f, -0.08032630f, -0.21097605f, -0.15100974f, -0.16508068f, 
    0.06408779f, 0.16743323f, 0.04326884f, 0.03134622f, 0.05065398f, 0.12957378f, -0.02637171f, -0.01601323f, 
    0.21472298f, 0.12077735f, -0.04685101f, -0.13794017f, 0.02533064f, -0.06982207f, 0.05218076f, 0.12397867f, 
    0.05682798f, 0.14224204f, 0.00371352f, -0.03096208f, -0.18360533f, -0.14050196f, -0.22050741f, -0.23291795f, 
    0.31588417f, -0.18756697f, 0.04860730f, -0.13038269f, -0.12583585f, -0.15983614f, -0.12427206f, 0.19282593f, 
    0.11558665f, 0.13775054f, -0.21208990f, -0.05339754f, -0.02371212f, 0.09768678f, 0.02928897f, 0.19310400f, 
    0.13720159f, 0.08569763f, 0.20215282f, 0.16319211f, 0.27531034f, 0.16327447f, 0.30766416f, 0.21185122f, 
    0.05403746f, 0.01120827f, 0.09276443f, -0.09352382f, 0.23820117f, 0.16206490f, 0.16355914f, 0.14590204f, 
    -0.11291532f, 0.01577520f, 0.35343719f, -0.01495343f, 0.14524668f, -0.01031569f, 0.18703450f, -0.07537945f, 
    0.16965859f, 0.28909150f, 0.18000126f, 0.20917927f, -0.03641956f, -0.25640681f, 0.02022602f, 0.18483184f, 
    0.00810720f, -0.09292728f, -0.10540752f, -0.08654863f, -0.08736726f, 0.10303669f, -0.03206417f, -0.08236342f, 
    0.30500224f, 0.08233821f, 0.09439884f, 0.04068623f, 0.01155292f, 0.11193668f, 0.02035791f, -0.11494805f, 
    0.01544049f, 0.10027692f, -0.06752722f, -0.15201704f, 0.33663344f, 0.16004619f, -0.01496611f, 0.16628624f, 
    0.12660560f, -0.01391707f, -0.08432064f, -0.09355149f, 0.00020053f, 0.11648753f, -0.08324616f, -0.04073370f, 
    0.13228931f, 0.06631685f, 0.20500289f, 0.15253422f, 0.05412638f, 0.04304796f, 0.17296681f, 0.04929474f, 
    -0.02745439f, -0.03482731f, 0.14996825f, 0.01665876f, -0.04817760f, 0.11095362f, -0.16530235f, -0.30359340f, 
    0.09197898f, 0.00413605f, -0.12945680f, 0.03032442f, -0.20083669f, -0.00074726f, -0.08693044f, 0.06710344f, 
    0.03591643f, 0.42154187f, -0.48074007f, -0.14131908f, 0.01531703f, 0.07684214f, 0.07413267f, -0.13103849f, 
    -0.09120937f, 0.01524670f, -0.02040243f, -0.13638349f, 0.11225490f, -0.14104815f, -0.25787446f, -0.36825112f, 
    -0.14267457f, -0.01185623f, -0.08586551f, 0.05129780f, -0.08237192f, 0.00307110f, -0.06919837f, 0.08633986f, 
    -0.33555031f, -0.33036759f, 0.17738716f, 0.02065369f, -0.19546749f, 0.14914750f, 0.12205478f, 0.11723496f, 
    -0.00748452f, -0.07944297f, 0.01574679f, 0.06733049f, 0.07946929f, -0.21743289f, 0.45895123f, -0.04245777f, 
    0.02373393f, 0.14731582f, 0.01477217f, 0.01698721f, -0.18650706f, -0.09579753f, -0.00778364f, 0.00604241f, 
    -0.06997523f, 0.20210581f, 0.05499906f, -0.02315513f, -0.08565700f, -0.03180103f, -0.07098892f, 0.03793633f, 
    -0.09689324f, 0.01773722f, 0.05495141f, -0.01994843f, 0.40685403f, -0.25986123f, 0.02417145f, 0.05378685f, 
    0.00064195f, -0.00432177f, 0.03697521f, 0.12819143f, 0.07585867f, 0.05948504f, 0.01253674f, -0.11254597f, 
    0.09624968f, 0.30029282f, 0.29850960f, -0.04228384f, 0.01760859f, -0.02401256f, -0.19160120f, 0.06453338f, 
    -0.19849601f, -0.07377940f, 0.00126183f, 0.23658265f, 0.10154073f, 0.11067300f, -0.12008762f, 0.03935662f, 
    -0.01397115f, 0.27246761f, -0.05191054f, -0.01373610f, -0.28250736f, -0.11807065f, 0.03315509f, 0.05556896f, 
    -0.19589460f, 0.12804471f, 0.23349236f, 0.13623159f, -0.08350471f, 0.23785459f, 0.05625010f, 0.11023537f, 
    -0.16785440f, -0.21346012f, 0.09626129f, -0.08507489f, -0.11870112f, -0.06690603f, -0.21837206f, 0.09579185f, 
    0.01514900f, -0.01785849f, -0.00758923f, 0.01619771f, -0.09234998f, -0.00323883f, -0.04496153f, 0.02835346f, 
    0.15417676f, -0.19730841f, 0.10528951f, 0.28279492f, -0.12101103f, 0.02529154f, 0.12616672f, 0.21477318f, 
    -0.00000703f, -0.02538386f, 0.10929228f, 0.04524572f, -0.26711869f, 0.12537423f, 0.02289289f, -0.24313729f, 
    0.03151020f, 0.02401245f, 0.13124625f, 0.01868868f, -0.11912218f, -0.01581622f, -0.05751964f, 0.07905139f, 
    -0.13018310f, -0.01523179f, -0.26145583f, 0.00794955f, 0.00185944f, 0.06328528f, 0.15083590f, 0.04800985f, 
    -0.08966957f, 0.00157802f, 0.02108646f, 0.01040289f, 0.45909628f, -0.39211401f, 0.24827853f, -0.06396922f, 
    0.00541023f, -0.06760944f, 0.10093482f, 0.00679318f, 0.09462189f, -0.02803523f, 0.06318582f, 0.13043475f, 
    0.20243737f, -0.06055471f, 0.01221945f, 0.22400254f, -0.08618071f, 0.09308409f, -0.06079747f, -0.00330746f, 
    -0.00714698f, 0.10062510f, 0.14366761f, 0.08412840f, -0.14898130f, 0.26534647f, 0.10654018f, -0.00457042f, 
    -0.15469265f, 0.17780159f, -0.06677184f, 0.06903867f, -0.03310462f, -0.14629851f, -0.25901368f, -0.36653942f, 
    0.05724273f, 0.07001889f, 0.01577581f, 0.05001924f, 0.11396845f, -0.05365772f, 0.08632763f, 0.05437902f, 
    0.08566349f, 0.11782850f, -0.09907708f, -0.06682470f, -0.03768980f, 0.17181824f, 0.19451033f, 0.20634179f, 
    -0.05641515f, 0.04084446f, -0.07445357f, -0.00787146f, -0.12728281f, -0.04214421f, -0.04608078f, 0.05529156f, 
    -0.09517097f, -0.05691870f, 0.14369361f, 0.20651361f, -0.19547585f, 0.13706933f, 0.11440767f, 0.10079077f, 
    -0.12662888f, -0.13866472f, -0.05775145f, 0.00641827f, -0.07502352f, -0.18195623f, -0.11352596f, -0.04509668f, 
    -0.33526707f, 0.08255459f, 0.19964361f, -0.05827011f, 0.07087315f, 0.05732413f, -0.03589642f, -0.03077639f, 
    -0.50465596f, -0.59483427f, -0.01992662f, 0.05891350f, 0.12053782f, 0.21825889f, 0.12998581f, 0.09184858f, 
    -0.13324423f, 0.08140805f, 0.03898964f, -0.02753637f, -0.21090361f, 0.10157343f, -0.39984500f, -0.18240014f, 
    0.09579093f, -0.22292644f, 0.09766490f, 0.04200228f, 0.06041550f, 0.27133614f, 0.00253951f, 0.04224382f, 
    0.00499800f, 0.20144850f, 0.07578217f, -0.20294361f, -0.14394055f, -0.04598470f, -0.08050331f, 0.00420030f, 
    0.02730455f, -0.06594650f, -0.11951991f, -0.04795424f, -0.04874372f, -0.33356231f, -0.29329559f, -0.08773746f, 
    0.02287864f, 0.01406391f, -0.10238387f, 0.08579920f, -0.09557448f, 0.00566220f, 0.05168767f, -0.15292439f, 
    0.23304090f, 0.04830362f, -0.22647038f, 0.09135028f, -0.05559310f, 0.00002397f, 0.00126650f, -0.12762555f, 
    -0.11332505f, -0.07630417f, -0.06318273f, 0.12567520f, 0.06123844f, 0.29267180f, -0.17878376f, -0.13039418f, 
    0.00071770f, -0.09460592f, 0.17966014f, -0.07400829f, 0.06851126f, 0.19373924f, -0.02307957f, 0.12450895f, 
    0.08499993f, -0.04558374f, 0.05318664f, -0.02921241f, -0.02866915f, -0.05332596f, 0.06623497f, -0.03350373f, 
    0.00314645f, -0.19054541f, 0.05894573f, 0.04917901f, -0.54117692f, 0.07731462f, -0.21487734f, -0.43151885f, 
    -0.08193128f, 0.08502726f, 0.15247771f, -0.01313495f, -0.03478818f, -0.14235722f, 0.11754879f, -0.00713662f, 
    -0.22502293f, 0.10624022f, 0.21861507f, 0.02936879f, -0.17339714f, -0.08372361f, 0.06115995f, 0.11298359f, 
    0.03347687f, 0.12700854f, 0.04474410f, -0.16264138f, -0.07469238f, 0.14799505f, 0.35868469f, 0.00709869f, 
    -0.09842278f, -0.05683875f, 0.04878060f, 0.11790656f, -0.01046248f, 0.04644623f, 0.00516319f, -0.03995452f, 
    0.00572006f, 0.09107469f, 0.16448171f, 0.01407255f, 0.00985675f, 0.04874246f, 0.00674542f, 0.01391930f, 
    0.09457739f, 0.15736946f, 0.14280725f, 0.14280728f, -0.21666992f, -0.25605363f, -0.23441076f, -0.12156539f, 
    0.12941772f, 0.16705589f, 0.10470454f, -0.01760747f, -0.08013789f, -0.07765456f, -0.03217779f, 0.01984684f, 
    -0.24566546f, 0.09703094f, 0.28620940f, 0.13205265f, -0.15492308f, -0.15729383f, -0.07420649f, 0.12689047f, 
    0.06487540f, 0.07406408f, 0.13654363f, 0.17597800f, -0.02878016f, -0.05071336f, -0.07945181f, 0.01208322f, 
    -0.01803903f, -0.15609552f, 0.01378178f, -0.04087989f, -0.15088391f, -0.00223563f, -0.00867957f, 0.08957166f, 
    0.30568290f, 0.06904789f, 0.18357524f, -0.01969727f, 0.00113553f, -0.15158941f, 0.13349792f, 0.06044848f, 
    0.19042471f, 0.11303960f, 0.01780179f, 0.02515555f, 0.23066431f, 0.48893836f, 0.02993532f, -0.21518965f, 
    0.08250996f, 0.00892887f, 0.17148654f, 0.13142470f, 0.26478174f, -0.06892542f, 0.02761997f, 0.03422157f, 
    -0.21612370f, -0.07601169f, -0.19338159f, 0.13207525f, -0.10154377f, -0.02096542f, 0.02752440f, -0.07245173f, 
    -0.02207351f, -0.01112617f, 0.00240796f, 0.09952332f, 0.15951711f, 0.32067919f, 0.30843863f, -0.14128584f, 
    0.00186998f, -0.03191425f, -0.07055255f, 0.05576627f, 0.12763639f, -0.07882397f, -0.06489967f, 0.04268333f, 
    0.23788619f, 0.40281659f, -0.21319421f, -0.12366194f, 0.00708776f, 0.02600751f, 0.01412486f, -0.09376055f, 
    0.03271072f, 0.10287980f, -0.04163978f, 0.01015606f, -0.17480668f, -0.13767385f, -0.05015929f, 0.00133172f, 
    0.03933996f, 0.09060786f, 0.15792529f, 0.06219400f, 0.11400333f, 0.10339371f, 0.10665269f, 0.12607831f, 
    -0.15684769f, 0.01519004f, -0.25913760f, -0.12544993f, -0.20157681f, -0.36243856f, 0.07538175f, -0.04502802f, 
    0.10289393f, 0.18499304f, 0.00784637f, 0.08392540f, -0.37617868f, -0.17602208f, -0.11849886f, 0.33778653f, 
    -0.05891201f, -0.13303004f, 0.20833129f, 0.01567492f, 0.07363795f, 0.03580553f, -0.03755281f, 0.04783440f, 
    -0.10177367f, 0.06973566f, -0.12464494f, -0.12798229f, -0.03205407f, -0.03611628f, 0.03564260f, -0.15934537f, 
    0.04974927f, 0.14599074f, -0.03944493f, -0.01256475f, -0.08046532f, -0.22573036f, -0.12317951f, 0.16940330f, 
    0.02320456f, 0.16190013f, 0.08828010f, 0.18838793f, -0.03628183f, 0.00268854f, 0.04275124f, 0.07800901f, 
    -0.18181597f, 0.25692019f, -0.02801270f, -0.00744134f, -0.05623458f, 0.03585575f, -0.11600967f, -0.07859270f, 
    0.07840677f, 0.01954443f, 0.16921838f, 0.09018729f, -0.22353065f, -0.10709411f, 0.68103904f, 0.03388173f, 
    -0.11735144f, -0.13421354f, -0.13263251f, 0.15949486f, 0.18128994f, 0.18937062f, 0.03840338f, -0.07005519f, 
    0.00248454f, 0.07760567f, 0.45959982f, -0.27168235f, -0.01569448f, -0.09157248f, -0.03060477f, -0.03648435f, 
    0.06902875f, 0.03323802f, 0.01430808f, 0.03520332f, -0.28859219f, 0.06101844f, -0.11914786f, 0.04673264f, 
    -0.09554072f, -0.07049247f, 0.01551786f, -0.01426640f, 0.00572368f, 0.12614705f, -0.02326501f, 0.06646282f, 
    -0.06928047f, 0.04312979f, -0.01377582f, -0.00715467f, 0.10066003f, -0.02085310f, 0.05724143f, -0.02990832f, 
    0.04521670f, 0.03463634f, -0.08541010f, -0.08601878f, -0.24858163f, -0.09472291f, -0.02138692f, -0.01965536f, 
    0.02774231f, -0.04763824f, 0.10012446f, -0.08649193f, 0.01563141f, 0.03689851f, 0.14519832f, 0.06892122f, 
    0.10229857f, 0.00412866f, 0.03004570f, -0.04976680f, -0.00290476f, 0.01819932f, -0.02837662f, 0.16999063f, 
    0.10385741f, 0.15338649f, -0.00659561f, 0.06442685f, -0.16074018f, -0.00471457f, 0.39690968f, 0.03203208f, 
    -0.16688477f, -0.10006332f, -0.16073073f, -0.02474728f, 0.19140626f, 0.12674995f, 0.17902285f, 0.01145366f, 
    0.48364758f, 0.15859912f, -0.01277201f, -0.39106598f, 0.05918088f, -0.01143262f, 0.10926486f, -0.11270999f, 
    0.10513686f, 0.02503423f, 0.10093790f, -0.04669375f, -0.05505655f, -0.35824090f, -0.27768475f, 0.25240341f, 
    0.00281512f, 0.19830240f, -0.15629642f, 0.17543450f, 0.10355545f, 0.08237673f, -0.03536769f, 0.12010466f, 
    -0.28799576f, -0.10293271f, 0.01348487f, -0.06209493f, 0.07414691f, 0.12207748f, 0.10325266f, -0.05123192f, 
    0.03961966f, -0.05208281f, 0.04875866f, 0.09165666f, -0.07842835f, -0.20777234f, 0.11341567f, -0.18350402f, 
    0.15045410f, -0.01938686f, 0.13290700f, -0.07448948f, 0.00830464f, 0.01111351f, 0.03256275f, 0.03897734f, 
    -0.15928061f, -0.10435071f, 0.22712140f, 0.00674873f, 0.07091246f, 0.03129046f, -0.10179379f, -0.02448988f, 
    0.27907947f, 0.18174592f, 0.12281124f, -0.07357329f, -0.07472920f, -0.24841334f, -0.09506647f, 0.32572022f, 
    -0.20313224f, 0.09571030f, -0.03548620f, 0.21364051f, -0.05148581f, -0.05299708f, -0.01371114f, -0.02017679f, 
    -0.03890900f, 0.20479730f, -0.02525974f, -0.16124268f, -0.02649539f, 0.02071307f, 0.07172450f, -0.05700253f, 
    0.20670404f, 0.02104095f, -0.19478886f, -0.04317555f, -0.06829205f, 0.03885242f, -0.10733373f, -0.00724440f, 
    -0.09239436f, -0.03460387f, -0.05623922f, 0.02205142f, -0.02107842f, -0.03419254f, 0.08196757f, 0.07800594f, 
    -0.00595714f, -0.03099885f, -0.02156470f, -0.03327855f, -0.02976621f, -0.02320916f, -0.03560483f, 0.02990634f, 
    -0.03721487f, -0.04048995f, -0.02031522f, -0.00437695f, 0.00936919f, -0.03611369f, -0.00008081f, -0.03881052f, 
    0.03717569f, -0.03011644f, -0.03685290f, -0.02630836f, -0.00536160f, -0.02340354f, 0.02509551f, 0.01006358f, 
    -0.05241777f, -0.01320596f, 0.03589142f, -0.00624732f, -0.00772915f, -0.00430130f, 0.01398880f, -0.04066593f, 
    -0.02582593f, -0.00820907f, -0.04425584f, -0.05585119f, -0.02927792f, 0.04450225f, 0.03434714f, -0.03864122f, 
    -0.00967560f, 0.01317263f, 0.03040960f, 0.00420657f, -0.00063888f, 0.01398927f, -0.03850178f, 0.01227687f, 
    0.03837623f, 0.00992019f, -0.00079899f, -0.04685507f, -0.03876014f, 0.03769128f, -0.04207926f, 0.04189647f, 
    0.02160308f, 0.04035083f, -0.04389064f, -0.02949822f, -0.01682582f, 0.01347502f, -0.03325920f, 0.04098432f, 
    0.01356649f, 0.03812063f, -0.05592830f, 0.03210560f, -0.01097637f, -0.03643072f, 0.04769671f, -0.00629549f, 
    0.00667972f, -0.01013441f, -0.03262588f, -0.03397906f, 0.04088309f, 0.00163366f, -0.02456256f, 0.01601567f, 
    0.04357650f, -0.04432672f, -0.03962183f, -0.03013525f, 0.01894231f, -0.05159649f, -0.02775485f, -0.02930372f, 
    0.01058597f, -0.02492006f, 0.00187064f, 0.03397809f, 0.01263927f, -0.01077673f, 0.01995145f, -0.04122025f, 
    -0.03886639f, 0.03928613f, 0.03266629f, 0.03094563f, -0.03994977f, -0.00435388f, -0.03244361f, 0.02471347f, 
    -0.00775310f, -0.00550320f, -0.02105358f, 0.03103732f, 0.02567030f, -0.04374252f, -0.02936244f, 0.02831840f, 
    0.03908060f, -0.00109084f, 0.03378559f, -0.03551250f, 0.03683358f, 0.04456235f, -0.01379258f, 0.03199501f, 
    -0.03101815f, -0.00360060f, -0.01047211f, -0.03562058f, -0.00647127f, 0.01135710f, -0.03190378f, -0.02306521f, 
    0.01104757f, -0.01242420f, 0.00565491f, -0.03186716f, -0.03084406f, -0.01921066f, -0.01883990f, 0.00408392f, 
    -0.05195569f, 0.03300052f, 0.01276818f, -0.03316386f, -0.00753788f, -0.00183331f, 0.02334508f, 0.00359526f, 
    0.03472492f, -0.04598679f, -0.02051318f, -0.04284499f, -0.05615520f, 0.03159883f, 0.01615835f, -0.01424410f, 
    -0.02345805f, -0.05253249f, 0.02835180f, -0.02702093f, -0.02223582f, 0.02935224f, 0.03276665f, 0.00538854f, 
    -0.01482990f, 0.02222433f, -0.03754778f, -0.03959233f, 0.02107014f, 0.01913135f, -0.02389002f, 0.04121868f, 
    0.02908442f, -0.02164488f, -0.05161367f, -0.01002216f, 0.00116063f, 0.01400173f, -0.02130354f, -0.04511914f, 
    0.01659574f, -0.04098146f, -0.03603616f, -0.01415912f, -0.03677014f, -0.04541761f, 0.03857725f, -0.05060437f, 
    -0.03945386f, -0.00396768f, 0.02329677f, 0.03381484f, 0.02666451f, -0.04171370f, 0.03537247f, -0.02579354f, 
    -0.04799968f, 0.00167070f, 0.00852551f, 0.03034120f, 0.01094880f, 0.02866097f, 0.01313533f, -0.03344865f, 
    -0.03031310f, 0.01256907f, 0.02336721f, -0.03769218f, -0.04053027f, 0.00080052f, 0.03082908f, 0.04489814f, 
    0.01009224f, -0.05690390f, -0.02550467f, -0.02613508f, -0.04838504f, -0.02759203f, 0.04585640f, 0.00936013f, 
    0.02841149f, -0.02045694f, -0.00723689f, -0.03593806f, -0.03116360f, 0.03489134f, 0.01486846f, -0.00272067f, 
    -0.04698705f, 0.00406235f, -0.01863955f, 0.05279432f, -0.02704555f, -0.02957230f, -0.03613422f, 0.05259066f, 
    0.02528024f, -0.04946482f, 0.03128971f, 0.01639210f, 0.02818242f, 0.02985600f, 0.00627084f, 0.00682158f, 
    0.04143973f, 0.03826762f, -0.00681085f, 0.02011575f, 0.01283358f, -0.01281172f, -0.00662049f, -0.01729678f, 
    -0.03578535f, 0.01054973f, -0.02121984f, -0.02797610f, 0.00085954f, -0.03834857f, -0.01707456f, -0.03799301f, 
    0.04256465f, -0.02864691f, 0.05036118f, -0.01828039f, 0.01471207f, 0.02151375f, -0.02471432f, 0.02394303f, 
    -0.05431803f, 0.02345538f, 0.03318758f, -0.04494581f, -0.03141050f, -0.02609581f, 0.03602555f, -0.04808133f, 
    -0.03009206f, 0.03614771f, 0.01547839f, 0.02422331f, 0.00889243f, -0.00255166f, 0.03000771f, -0.01497111f, 
    0.00737425f, -0.03608952f, -0.03981280f, -0.02336431f, -0.03130621f, -0.01476407f, 0.00228957f, -0.00827373f, 
    -0.02183778f, 0.04142016f, 0.03712656f, 0.00177985f, -0.03602392f, -0.05538345f, -0.04935382f, 0.03934155f, 
    0.03306936f, -0.04604474f, -0.04208199f, 0.00877172f, -0.01765768f, -0.00789933f, 0.00050891f, -0.04142138f, 
    -0.00304940f, -0.04864525f, 0.01236127f, -0.04814635f, 0.04075339f, 0.02523628f, -0.01169338f, -0.02109582f, 
    -0.02061936f, 0.00839445f, -0.04975972f, 0.01571375f, -0.00093948f, -0.03497608f, 0.01006521f, 0.00543113f, 
    -0.01956950f, 0.01204649f, -0.00541958f, 0.02213666f, 0.00700404f, -0.00648617f, 0.02696702f, 0.01827474f, 
    -0.00040385f, 0.03559574f, -0.01771277f, -0.01200797f, 0.03751376f, 0.03322658f, -0.00931507f, 0.03958252f, 
    0.01565695f, 0.01475040f, -0.00258880f, -0.03026294f, -0.05226095f, 0.04382744f, 0.00092321f, -0.03548762f, 
    -0.03242070f, -0.01420671f, -0.02657185f, 0.03590202f, 0.02341664f, -0.03521538f, -0.00463622f, 0.03462701f, 
    0.00014445f, -0.04100713f, 0.01281409f, -0.04350920f, 0.01386271f, -0.00795459f, -0.00932087f, -0.03081659f, 
    -0.03698015f, -0.01847551f, -0.04527225f, -0.04750698f, -0.00112420f, 0.00662513f, 0.00078161f, 0.04956127f, 
    -0.03678661f, 0.04749271f, 0.01846124f, 0.00701334f, -0.01771372f, -0.02311299f, -0.04554070f, 0.00874524f, 
    -0.04805937f, -0.01630655f, 0.02978249f, -0.04366422f, 0.01781735f, 0.03562173f, -0.04400214f, -0.00101761f, 
    -0.09097856f, -0.08920207f, -0.00579198f, 0.05460970f, 0.07431966f, -0.03535831f, 0.13895309f, 0.09151251f, 
    -0.00433794f, 0.01238283f, 0.00963632f, 0.05374854f, -0.18150157f, -0.09261585f, 0.12090270f, 0.19807360f, 
    0.02073682f, -0.04550432f, 0.14010939f, -0.01482273f, -0.04675477f, -0.02613171f, -0.10151001f, -0.00235237f, 
    -0.26005605f, 0.01056254f, 0.08176349f, 0.07137209f, 0.10145874f, 0.00022280f, 0.11628562f, 0.18981417f, 
    -0.07764050f, 0.06224259f, 0.10758892f, 0.13841034f, -0.03943243f, 0.02763218f, 0.21334347f, 0.00378919f, 
    -0.00419482f, -0.14511567f, 0.06500346f, 0.04663536f, 0.02010393f, -0.00011622f, -0.04662009f, 0.05682412f, 
    0.17926399f, -0.09742592f, -0.10447653f, -0.14978196f, -0.04274125f, -0.03883440f, -0.03434067f, -0.03215024f, 
    0.04866886f, 0.13588682f, 0.08584274f, -0.09583779f, 0.20857453f, 0.18468876f, 0.08388563f, -0.10916153f, 
    -0.17743550f, 0.10614805f, -0.01568730f, 0.01850599f, -0.05923577f, 0.10366492f, 0.24406922f, -0.02700010f, 
    0.31150457f, -0.00156002f, 0.08074992f, -0.01184497f, 0.04189486f, 0.09303599f, -0.14091891f, -0.00672250f, 
    -0.02172550f, 0.11396230f, 0.07552589f, 0.00927199f, 0.13222271f, 0.12411532f, 0.15617107f, 0.45552531f, 
    -0.15432985f, 0.08896116f, 0.26221544f, 0.14293136f, 0.10791811f, 0.32891160f, 0.08941015f, -0.01092329f, 
    -0.23289298f, -0.17512526f, -0.14725682f, 0.09526598f, 0.01807419f, -0.03942372f, -0.07454079f, 0.05071198f, 
    -0.08803454f, 0.08061568f, 0.02650712f, -0.00517022f, -0.17367527f, -0.20352365f, 0.10253417f, 0.09918728f, 
    -0.06321607f, 0.00784294f, 0.13646352f, 0.15395990f, 0.17920843f, 0.07111861f, -0.01869797f, 0.09563451f, 
    0.08078296f, 0.08339831f, 0.14746103f, -0.05158693f, -0.04045477f, -0.10101128f, -0.09730495f, -0.00015744f, 
    0.09358858f, 0.04636125f, -0.01662767f, -0.04251454f, 0.04219132f, -0.03562158f, 0.06777129f, -0.09706492f, 
    0.30082315f, -0.00306881f, -0.00442525f, 0.04709021f, -0.14154096f, 0.05531241f, 0.09412827f, 0.01871825f, 
    -0.02201407f, 0.05850399f, 0.06375992f, 0.05259108f, -0.14102446f, 0.04350193f, 0.11575219f, -0.01408825f, 
    -0.13238719f, 0.20577031f, 0.01181663f, -0.05015734f, 0.12676521f, -0.21307912f, -0.04679576f, 0.01984481f, 
    0.12542044f, -0.08714482f, -0.00662279f, 0.10313985f, -0.13085969f, -0.00005136f, 0.04463548f, -0.00610532f, 
    -0.08312859f, -0.14031158f, 0.34417105f, -0.02710910f, 0.15128118f, 0.09353228f, 0.13750796f, 0.07177079f, 
    -0.10304035f, -0.12043939f, 0.14614953f, 0.09638890f, 0.04356821f, 0.10347944f, -0.16247234f, 0.02490096f, 
    0.14800064f, 0.14722712f, -0.04744448f, 0.03704707f, -0.00034268f, 0.13013048f, 0.04916346f, 0.07640386f, 
    -0.04536554f, 0.09806041f, 0.06702256f, -0.09794732f, -0.12933804f, 0.06532075f, 0.01571374f, -0.03294272f, 
    0.11898375f, -0.00840060f, 0.08783307f, 0.09680673f, -0.03061430f, 0.60129476f, -0.01855444f, -0.06328115f, 
    0.12949277f, 0.05861120f, 0.06981702f, 0.08552185f, -0.14596315f, -0.04848862f, 0.23980124f, 0.03719279f, 
    -0.37892932f, -0.08434552f, 0.08828299f, 0.20386186f, -0.00616015f, 0.03323315f, 0.03823897f, 0.05318503f, 
    -0.01623418f, -0.05161819f, -0.09273004f, 0.04066511f, -0.07574308f, 0.04434377f, 0.08506464f, 0.03230098f, 
    -0.07973927f, -0.10448130f, 0.14850911f, 0.19826226f, -0.13449301f, -0.01717573f, 0.00904922f, -0.09761817f, 
    -0.17302661f, -0.17790429f, -0.18034384f, 0.04227807f, 0.09599914f, -0.09834712f, 0.09178223f, -0.00513352f, 
    0.17247759f, -0.06904774f, -0.05630787f, 0.11004438f, -0.15974520f, -0.22594492f, 0.03872540f, 0.08985776f, 
    -0.09698714f, -0.03214883f, -0.05034982f, -0.04461144f, -0.09343224f, -0.03852221f, -0.07532252f, 0.04375689f, 
    0.01105083f, -0.14772297f, 0.07720910f, 0.10147899f, 0.02982145f, 0.03142592f, 0.17834601f, 0.17845607f, 
    0.04034707f, 0.01901018f, 0.15978727f, 0.28004521f, 0.09773141f, 0.18291076f, 0.04698974f, -0.15250500f, 
    0.04779783f, 0.09011588f, -0.01522487f, -0.12659973f, 0.02908529f, 0.00492569f, -0.02599709f, 0.04359672f, 
    -0.01855430f, 0.18915118f, 0.47969458f, 0.06983215f, -0.06382237f, -0.10724597f, 0.00310194f, 0.01300311f, 
    0.05067731f, 0.20212133f, 0.06109740f, 0.13837181f, -0.05438517f, 0.27083939f, 0.10660793f, -0.06670840f, 
    -0.00649846f, 0.13702552f, 0.04425990f, 0.01746741f, 0.02532194f, 0.12164461f, 0.32647589f, 0.01986342f, 
    -0.23527020f, -0.14883782f, -0.05224741f, 0.25159448f, -0.09855187f, -0.02363247f, -0.12647305f, -0.06296846f, 
    -0.05160062f, -0.11405344f, -0.09840458f, -0.01086005f, 0.02180576f, 0.12234722f, 0.39337778f, 0.08560012f, 
    -0.01702543f, 0.02597451f, -0.02156283f, 0.09311182f, 0.03542850f, 0.13898717f, 0.06615987f, 0.10347863f, 
    -0.18966730f, -0.34714144f, 0.10561609f, -0.00946550f, 0.11857512f, -0.02506181f, -0.00610570f, -0.08118512f, 
    0.00087971f, -0.05193901f, -0.11044680f, 0.09303211f, -0.16510382f, 0.20890661f, -0.26409662f, -0.15882351f, 
    0.03477432f, 0.04169365f, -0.12668140f, -0.08986083f, 0.09551796f, 0.07845344f, 0.01409520f, -0.09221251f, 
    -0.21937883f, -0.06163248f, -0.13330162f, -0.03331320f, -0.04171898f, 0.11763619f, -0.02885860f, 0.03977408f, 
    0.05332255f, -0.18736959f, -0.05337382f, 0.01518395f, 0.26412436f, 0.17550057f, -0.18572652f, -0.29441336f, 
    -0.09409283f, 0.06209902f, -0.00215452f, -0.00768205f, 0.12058782f, 0.11524710f, 0.15459542f, 0.13329220f, 
    -0.12150232f, -0.31394997f, 0.01205518f, -0.12452485f, 0.01902092f, -0.00939864f, -0.18075691f, 0.03994594f, 
    -0.02206288f, -0.05101649f, -0.04738585f, -0.09692631f, 0.06226125f, -0.14029700f, -0.04269565f, -0.34895325f, 
    -0.01281932f, -0.04982078f, -0.17685495f, 0.07040630f, -0.03546073f, -0.05329197f, 0.02336403f, 0.08387719f, 
    0.22983657f, -0.12325433f, -0.12458573f, 0.09290788f, -0.00272500f, 0.16608511f, 0.04657403f, 0.04774499f, 
    0.07935906f, -0.08772751f, 0.06937974f, -0.10835674f, 0.35855123f, 0.22057208f, -0.11805993f, 0.16441762f, 
    0.00395666f, 0.06234685f, -0.07550029f, -0.04407570f, 0.10467724f, 0.04662633f, 0.04987613f, 0.08515812f, 
    0.16213658f, 0.16788545f, 0.07958251f, 0.12863149f, -0.02000441f, -0.01469240f, -0.00676070f, -0.04743029f, 
    -0.09863148f, -0.20009749f, 0.12341743f, 0.07475597f, -0.10236293f, 0.12709732f, 0.01731167f, 0.25224465f, 
    0.07315376f, 0.02373196f, -0.03166788f, 0.07547069f, 0.23868336f, 0.02606323f, -0.00904195f, -0.00138013f, 
    -0.14504060f, 0.05309893f, 0.13875350f, 0.09503502f, 0.09188815f, -0.08780058f, 0.13908908f, -0.12180280f, 
    0.09487019f, -0.06739811f, -0.11769320f, 0.04104853f, -0.03197884f, -0.03680291f, -0.37862435f, -0.46606809f, 
    0.10201769f, -0.04685849f, -0.06180185f, -0.00789151f, 0.05601235f, 0.03131913f, 0.08686482f, -0.01460544f, 
    -0.12955245f, 0.33940414f, 0.07967258f, -0.10027581f, 0.06076525f, 0.11950592f, 0.10443518f, -0.02675905f, 
    -0.00829444f, -0.13663433f, -0.03052733f, -0.02419177f, 0.09234326f, -0.08485720f, 0.05156822f, -0.30654919f, 
    0.09373846f, 0.02857845f, 0.04678478f, -0.02974000f, 0.05068079f, 0.12804097f, 0.23552211f, 0.00373142f, 
    0.14122131f, 0.15088904f, 0.05103242f, 0.21253021f, -0.00317422f, 0.01837989f, 0.08649430f, 0.03052540f, 
    0.24492742f, -0.06837172f, -0.02650131f, 0.14919692f, 0.15468788f, 0.04404717f, 0.05874217f, 0.11325853f, 
    -0.04459499f, -0.05598023f, 0.05708091f, -0.05062865f, 0.02275106f, -0.05598637f, -0.07313403f, 0.00189613f, 
    0.17676063f, 0.17339218f, 0.06093515f, -0.02909201f, 0.06604078f, -0.06024107f, 0.05908233f, -0.07415932f, 
    0.09866101f, -0.10421554f, -0.04937163f, -0.14117762f, -0.63167083f, 0.01466272f, -0.10782360f, -0.09741972f, 
    0.01191407f, 0.10179252f, -0.10611275f, 0.00480142f, -0.03096907f, -0.01305613f, -0.03818752f, -0.23184158f, 
    0.14672214f, 0.32109317f, -0.49727198f, 0.10671745f, -0.13631485f, -0.01777530f, 0.24203706f, -0.02379024f, 
    0.03346274f, -0.04581759f, -0.03636983f, -0.17894551f, 0.06050455f, -0.06312531f, 0.16869985f, 0.10396747f, 
    0.03777747f, -0.01791893f, 0.07682479f, -0.01909885f, -0.12558584f, -0.06180420f, -0.00504131f, -0.00413588f, 
    0.35787684f, -0.03992622f, 0.20913771f, 0.16574925f, 0.10266681f, -0.02999906f, -0.02725143f, -0.00157441f, 
    -0.08015103f, -0.04455533f, 0.01989936f, -0.09607881f, 0.37957862f, -0.61953127f, 0.08486278f, 0.14771566f, 
    -0.09930520f, 0.14059789f, -0.16429004f, -0.04201306f, 0.02244548f, -0.05611220f, -0.08000053f, 0.20451702f, 
    0.31046849f, -0.18835874f, 0.05414309f, -0.21845652f, -0.01450868f, 0.12471844f, -0.12161128f, 0.15662177f, 
    0.20519722f, 0.07472359f, 0.01692493f, 0.04369086f, 0.03480749f, -0.02862830f, -0.06469706f, -0.10236820f, 
    0.10219253f, 0.06312852f, -0.19536209f, 0.01384848f, -0.01248936f, 0.00096581f, -0.02121619f, 0.03980464f, 
    0.15363939f, 0.17308594f, 0.21801895f, -0.04164204f, 0.22219986f, 0.02309815f, 0.02860274f, 0.06995755f, 
    -0.08691281f, 0.09665172f, -0.15394178f, 0.06534764f, -0.03152191f, 0.20126526f, -0.04492356f, -0.03778277f, 
    0.17866600f, 0.02606074f, 0.13021676f, 0.15856290f, 0.01960219f, 0.01175774f, 0.02514660f, -0.05428380f, 
    -0.09387270f, 0.09777094f, 0.06370939f, 0.06824490f, 0.09040824f, 0.11638486f, 0.01700230f, -0.14916132f, 
    -0.09254804f, 0.11385412f, -0.18117970f, -0.00172883f, 0.07054713f, -0.11179639f, 0.13990235f, 0.34966660f, 
    0.02795890f, -0.00787705f, -0.05388710f, -0.00980056f, -0.04153797f, -0.06797948f, -0.04059774f, -0.00280837f, 
    0.41538069f, 0.26105800f, -0.05944028f, -0.01777248f, 0.03884643f, -0.04929439f, 0.07933019f, 0.05243633f, 
    0.16826351f, 0.02376904f, -0.03880568f, 0.12913051f, 0.04543320f, -0.05262403f, -0.17334980f, 0.26609990f, 
    -0.01600321f, 0.07280898f, 0.06238791f, -0.14571679f, 0.11105108f, 0.08507891f, -0.02106304f, 0.08492282f, 
    0.11435139f, 0.36235949f, 0.12539053f, -0.28960365f, 0.14910170f, 0.06149921f, 0.08006047f, 0.16405953f, 
    -0.08759484f, -0.00672066f, -0.00109842f, -0.13594000f, 0.51184660f, 0.23844434f, 0.00740562f, -0.00381557f, 
    0.04797668f, -0.04885568f, 0.07939781f, -0.01278792f, 0.14191176f, 0.05235471f, 0.08262313f, -0.00051051f, 
    0.05552633f, 0.12780076f, -0.15424865f, -0.11560171f, -0.00051385f, 0.10369229f, 0.05713588f, 0.25701147f, 
    -0.05826836f, -0.00190921f, -0.02622913f, 0.08716822f, 0.06339319f, 0.06541687f, 0.36795315f, 0.11551296f, 
    -0.16076876f, -0.03582517f, -0.07560565f, -0.24721538f, 0.01430220f, -0.14118567f, -0.17117925f, 0.06154219f, 
    0.05920199f, -0.06016178f, 0.18768533f, -0.07088885f, 0.05317865f, -0.13836040f, 0.00017277f, -0.11544145f, 
    0.17337471f, 0.06995753f, 0.03377724f, 0.09247483f, 0.08370456f, 0.17891216f, 0.45069918f, 0.35304964f, 
    -0.00207953f, -0.00959891f, -0.03163183f, 0.01747730f, -0.01769718f, -0.07846080f, 0.04705480f, -0.16324244f, 
    0.02838027f, -0.01971088f, -0.02989062f, 0.03030241f, -0.04735826f, 0.03110345f, 0.00381914f, -0.04287820f, 
    -0.01804955f, -0.03704548f, -0.05049247f, -0.03015881f, -0.01070841f, -0.05737204f, 0.04149871f, -0.04277826f, 
    -0.02820252f, -0.02893825f, 0.01097050f, 0.00539896f, -0.05470452f, 0.02312733f, 0.02598642f, 0.02424581f, 
    0.02963035f, -0.05608231f, 0.00791908f, 0.01331508f, 0.03066651f, -0.00016304f, 0.02335606f, 0.01481075f, 
    -0.03388491f, -0.03385694f, 0.02713112f, 0.00530097f, 0.01516399f, -0.04698351f, -0.04210116f, -0.02580977f, 
    -0.02952112f, -0.02612549f, 0.00039543f, 0.01098058f, 0.02700653f, 0.00695044f, -0.01578327f, -0.02393378f, 
    -0.03414305f, -0.04732138f, -0.03050011f, -0.01292488f, -0.05008286f, -0.03008500f, -0.04127227f, 0.02850456f, 
    0.00939347f, -0.00294422f, -0.05784345f, 0.03853328f, -0.01452406f, 0.00425678f, -0.03537345f, -0.04606470f, 
    0.00812392f, -0.02113910f, 0.01239653f, -0.02566110f, -0.02748394f, 0.03121809f, 0.01618405f, -0.04830715f, 
    0.05064264f, -0.02719510f, -0.03832950f, 0.02437970f, -0.03755309f, -0.03900569f, 0.00237453f, -0.04783173f, 
    -0.04169982f, 0.02249287f, 0.02217116f, -0.05557067f, -0.03777482f, -0.02013879f, 0.01442043f, -0.05861388f, 
    -0.00309845f, 0.02098400f, -0.02162523f, 0.02681195f, -0.03497942f, 0.02501854f, 0.01721416f, -0.03244186f, 
    -0.02221936f, -0.03383741f, 0.00210138f, 0.02421370f, 0.00852990f, -0.01079543f, -0.04317001f, -0.03348099f, 
    0.00475799f, 0.03840631f, 0.01490710f, 0.01598396f, -0.00833217f, -0.03431113f, 0.00131869f, -0.03016482f, 
    -0.02228308f, -0.03288777f, -0.03504028f, 0.02832676f, 0.02661465f, 0.04042587f, 0.02500942f, 0.01863763f, 
    -0.00668083f, 0.00036426f, -0.00430181f, 0.01375889f, 0.04232983f, -0.00000617f, 0.01947971f, -0.01876540f, 
    0.03234771f, -0.01893205f, 0.03789314f, -0.05012073f, -0.01607985f, -0.02956849f, -0.01256059f, -0.05825138f, 
    -0.02871093f, 0.02381855f, 0.00146936f, -0.00416912f, -0.02651962f, 0.01228676f, 0.02860124f, 0.00277185f, 
    -0.05269948f, 0.03828082f, -0.02692420f, -0.02413089f, -0.01323277f, -0.01652533f, 0.00609502f, -0.03261588f, 
    0.00238575f, -0.02508334f, -0.02795947f, 0.03033593f, -0.00337942f, -0.03277824f, 0.01106426f, -0.05091971f, 
    -0.04360946f, 0.02534490f, 0.01622904f, 0.01192789f, -0.04799563f, 0.01963229f, 0.00174554f, 0.01335391f, 
    0.04234948f, -0.02498796f, -0.04502671f, 0.02040222f, -0.02739838f, -0.01821766f, -0.04586651f, 0.00033751f, 
    0.02779244f, -0.05334014f, 0.01561199f, -0.04203014f, 0.00790387f, -0.06030220f, -0.03089270f, -0.05558136f, 
    0.01465176f, -0.00560892f, 0.03208828f, -0.00471509f, -0.02980382f, 0.02490066f, 0.04007349f, -0.05637799f, 
    -0.00460248f, 0.00277267f, 0.03559184f, 0.03258927f, -0.02603364f, 0.01468576f, 0.00888687f, 0.03418212f, 
    0.03206173f, -0.03885175f, 0.01056132f, -0.04555587f, 0.03784397f, -0.00078332f, 0.04084283f, -0.01181029f, 
    -0.01350041f, -0.01693355f, -0.03734271f, -0.02842159f, 0.02780711f, -0.01289907f, 0.03090676f, 0.03443818f, 
    -0.00394848f, 0.03075682f, 0.03552259f, -0.01556007f, 0.00823054f, 0.02554679f, -0.00766783f, 0.02066202f, 
    -0.00129880f, 0.04046574f, -0.03763052f, -0.02595695f, -0.01294090f, 0.00370055f, 0.03200573f, 0.03069748f, 
    0.02451722f, 0.00897920f, 0.03336893f, 0.02215435f, 0.00408230f, -0.00049631f, 0.03209037f, -0.03123820f, 
    0.03106892f, 0.01770347f, -0.02361652f, -0.05777868f, -0.00107048f, 0.03093895f, 0.02815535f, -0.00345082f, 
    -0.05573276f, -0.05315886f, -0.00744780f, -0.01631319f, -0.03175520f, -0.00993111f, -0.01145289f, -0.04263249f, 
    -0.00030069f, -0.00589539f, 0.02068626f, -0.01522604f, -0.04963186f, 0.03932364f, 0.03503065f, 0.01464479f, 
    -0.01651957f, 0.00666476f, -0.05934597f, -0.05168194f, -0.04291948f, -0.00449910f, -0.04222162f, 0.03979338f, 
    -0.02937269f, 0.00667596f, -0.03160464f, -0.04265836f, -0.04708810f, 0.03737042f, -0.00257471f, 0.02900394f, 
    -0.04539684f, -0.03575736f, -0.01144787f, 0.00821747f, -0.02283608f, 0.01944714f, -0.04276718f, -0.02881020f, 
    -0.00682928f, -0.04354283f, 0.03829467f, -0.02934397f, -0.03258892f, -0.03552167f, -0.05321500f, 0.04064875f, 
    -0.03112643f, -0.01008323f, 0.02490004f, -0.00266376f, 0.00313581f, 0.02802602f, 0.03530701f, -0.02205427f, 
    -0.00553334f, 0.03965419f, -0.01353790f, 0.03683963f, -0.05599694f, 0.02782629f, 0.01527707f, -0.00865804f, 
    -0.03606176f, -0.01370175f, -0.03317673f, -0.05433111f, -0.03053797f, -0.01735777f, 0.01753784f, 0.02593455f, 
    -0.00386536f, -0.02701209f, -0.00524116f, -0.05070946f, 0.00081989f, -0.00225749f, -0.00078379f, -0.04981614f, 
    0.01948767f, -0.00331334f, -0.01102662f, -0.00459637f, -0.03667320f, -0.00522319f, -0.03814258f, -0.00129050f, 
    0.02119784f, 0.00931759f, 0.01524437f, 0.02609493f, -0.05147519f, 0.03369292f, -0.01019470f, 0.03699157f, 
    -0.01378945f, -0.04378070f, -0.05425531f, 0.03933547f, -0.03713724f, -0.01044502f, -0.01669899f, 0.00229605f, 
    -0.01144027f, 0.03648315f, 0.03819332f, -0.04337414f, 0.00516409f, -0.01718950f, -0.00832030f, -0.00921499f, 
    -0.02234729f, -0.03511582f, 0.05103148f, -0.05674939f, -0.01926132f, -0.02997152f, -0.02270110f, -0.02598798f, 
    -0.04366942f, 0.01097513f, -0.04561674f, -0.00425883f, 0.00173354f, -0.02034764f, -0.01289753f, -0.03572784f, 
    0.03517960f, 0.02207846f, 0.00678982f, -0.03344643f, 0.03071187f, 0.01276865f, -0.05893311f, -0.01305265f, 
    -0.17969318f, 0.02426274f, -0.13410404f, -0.29563403f, 0.04301770f, -0.02809102f, 0.07565089f, 0.10805882f, 
    0.17474453f, 0.04852998f, 0.03322491f, 0.16594508f, -0.08902381f, 0.08423268f, -0.26099598f, -0.22377416f, 
    -0.09309760f, 0.17025538f, 0.05554055f, -0.05166744f, 0.08894570f, 0.11586089f, 0.00799946f, -0.13512604f, 
    -0.29580647f, -0.05298905f, 0.03131724f, -0.01622899f, -0.00429071f, -0.09520254f, 0.11308832f, 0.02278504f, 
    0.04519073f, 0.00291708f, -0.15038536f, 0.05006827f, 0.20080625f, 0.15172169f, 0.24686445f, 0.02904812f, 
    0.08701751f, -0.00039226f, 0.03164988f, -0.10566013f, 0.02855903f, 0.01447383f, -0.03731191f, -0.02680420f, 
    -0.26984638f, -0.36293820f, -0.16659410f, -0.15243670f, -0.07257330f, 0.00792427f, -0.08797298f, -0.00557037f, 
    0.17509548f, 0.10948563f, 0.03086772f, -0.13802972f, -0.14553690f, 0.21966004f, 0.27197453f, -0.01435947f, 
    0.07813050f, 0.00339308f, -0.05917670f, 0.10115360f, 0.02763695f, 0.01641197f, 0.05894199f, 0.11515730f, 
    -0.12936527f, 0.02113926f, -0.13422669f, 0.02972954f, 0.01273531f, 0.08261666f, -0.14467643f, 0.22700135f, 
    0.00330978f, 0.15461487f, 0.11966893f, 0.07673839f, -0.23989995f, 0.00294893f, -0.10026551f, 0.01514984f, 
    0.13906854f, 0.09907985f, 0.04981624f, 0.00050052f, 0.06579539f, 0.05896411f, -0.05897942f, 0.11149257f, 
    0.22762486f, -0.21134475f, 0.14951058f, 0.08148006f, 0.08833392f, -0.06787551f, -0.04138064f, 0.04638365f, 
    0.10612229f, 0.04687100f, 0.04838660f, -0.02026541f, -0.35650125f, -0.20540205f, -0.07005554f, -0.13664214f, 
    -0.05433008f, 0.07159078f, 0.11351968f, 0.07641445f, 0.03641828f, 0.01074515f, -0.04134100f, -0.11199784f, 
    0.12611046f, -0.15226950f, 0.16266438f, 0.17282298f, -0.00107682f, -0.01887716f, 0.02380310f, 0.04920229f, 
    -0.04400540f, -0.10507756f, 0.07100636f, -0.14254484f, 0.04631818f, -0.04308295f, -0.02200887f, -0.10960931f, 
    0.10530294f, 0.13047180f, -0.14362721f, 0.06508692f, -0.09968711f, -0.06884720f, 0.02888184f, 0.02857952f, 
    -0.26161769f, -0.12499616f, -0.01694729f, -0.03287253f, 0.06357747f, 0.07206307f, -0.18810177f, 0.02617786f, 
    -0.08621814f, 0.02702512f, -0.18818514f, -0.11231466f, 0.24051687f, 0.16121824f, 0.47035748f, -0.14391929f, 
    0.10216320f, 0.01034587f, 0.26570919f, 0.11971114f, 0.14748979f, 0.17604519f, 0.04180652f, -0.04913535f, 
    -0.06507749f, -0.20771313f, 0.27076811f, -0.14253496f, 0.09809147f, 0.02824600f, -0.02287054f, 0.15501730f, 
    -0.05194317f, 0.01428178f, 0.00518567f, 0.23630591f, 0.14320765f, 0.07084143f, -0.09137712f, 0.11929814f, 
    0.08527598f, 0.01805197f, -0.08995628f, -0.00239944f, 0.09986428f, 0.03601236f, 0.02004451f, 0.00072312f, 
    -0.05448852f, -0.00239023f, -0.10948882f, 0.11256047f, -0.04381457f, -0.02982748f, 0.07978354f, 0.04861355f, 
    0.23087776f, 0.15415944f, 0.09451835f, 0.04002748f, -0.30115950f, 0.11580358f, -0.40190247f, 0.15282637f, 
    -0.06281173f, -0.08748553f, 0.18311466f, -0.06008277f, -0.01399282f, 0.10379110f, 0.15895303f, 0.04853483f, 
    -0.08710893f, 0.05779389f, -0.05308617f, -0.15180907f, -0.03392710f, 0.04687525f, 0.18338889f, -0.04019248f, 
    -0.00869345f, 0.07332319f, 0.00008484f, -0.03049088f, -0.06969853f, -0.39759433f, 0.04890442f, -0.03110349f, 
    0.18910253f, 0.03182890f, 0.20783198f, -0.13414653f, -0.11871139f, -0.06412300f, 0.02771612f, -0.05762204f, 
    -0.15759708f, -0.00819825f, 0.10683101f, -0.11137830f, -0.11974712f, -0.05741429f, -0.06843439f, 0.04455585f, 
    0.10603493f, -0.04386771f, 0.16060755f, 0.05499225f, -0.03032821f, -0.01103256f, 0.02352412f, -0.17316137f, 
    0.02770898f, -0.09127638f, 0.07149807f, -0.01670060f, -0.00771631f, 0.04153499f, -0.07877974f, -0.07757296f, 
    0.07109988f, -0.06220976f, 0.09638346f, -0.08187656f, 0.05491157f, 0.01965524f, -0.00334663f, 0.09759615f, 
    -0.01273520f, 0.02664328f, 0.25430465f, 0.10222300f, -0.07740179f, -0.17032239f, -0.19787498f, -0.07011680f, 
    0.04496465f, -0.05562216f, 0.02270663f, -0.06951595f, 0.12482397f, -0.04221975f, 0.11627997f, 0.12806067f, 
    0.36565286f, -0.05231373f, 0.12320197f, 0.45387593f, 0.09407996f, 0.18294910f, -0.11225933f, 0.13558036f, 
    -0.15707812f, 0.02815585f, 0.12816851f, -0.02901302f, -0.18251494f, -0.36244544f, 0.45468858f, 0.06195214f, 
    0.14673142f, -0.15460072f, 0.08882582f, 0.05020142f, 0.12696154f, -0.10714610f, 0.28060991f, 0.10502942f, 
    0.16859519f, 0.08660647f, 0.11040142f, 0.09770122f, -0.10404873f, -0.04926907f, -0.05509870f, -0.08039404f, 
    -0.09655505f, -0.04717036f, -0.06164379f, 0.07047643f, 0.36160022f, 0.07141095f, 0.00531961f, 0.32811561f, 
    -0.14858140f, 0.24946639f, -0.02154092f, 0.07354993f, -0.01313259f, 0.02354313f, -0.09606005f, 0.09097185f, 
    -0.09650808f, 0.02251765f, 0.34112006f, 0.01709473f, -0.00531040f, -0.10668452f, 0.20451562f, 0.07646112f, 
    0.07641122f, 0.09464489f, 0.03715465f, -0.01186953f, 0.12948896f, -0.39546067f, 0.04658401f, 0.19856884f, 
    0.22619455f, -0.03449949f, 0.03565831f, 0.03422399f, 0.09389587f, 0.13416678f, 0.16178229f, 0.06762438f, 
    0.22485119f, -0.23579460f, -0.22332358f, -0.05980799f, -0.07551531f, 0.13904141f, 0.02744830f, 0.17090462f, 
    -0.25236905f, 0.11735556f, -0.05252836f, -0.13533770f, 0.24187244f, 0.09124093f, -0.08562715f, 0.08545611f, 
    0.05198318f, 0.03795820f, -0.03776598f, 0.00780721f, 0.08091550f, 0.09937506f, 0.07997560f, 0.19813856f, 
    -0.04184477f, 0.00578751f, 0.25971562f, 0.04022468f, -0.12511382f, -0.12961392f, 0.01757902f, 0.03262657f, 
    -0.11447982f, 0.02787939f, 0.09806941f, 0.02460847f, 0.05495214f, 0.22934622f, 0.20104919f, 0.03647710f, 
    -0.24378583f, -0.17041188f, 0.11265279f, -0.02177407f, 0.03381794f, 0.10832702f, 0.10339092f, -0.01603257f, 
    0.04663489f, 0.05515530f, 0.07147111f, 0.02015442f, -0.07026510f, -0.09569944f, 0.15850516f, 0.16243106f, 
    0.06379317f, -0.09449226f, -0.03698657f, -0.01066330f, 0.45156744f, 0.08235235f, 0.04471694f, -0.09126297f, 
    0.06138153f, 0.11478811f, 0.17957072f, 0.02390724f, -0.04561276f, 0.01490661f, -0.12988786f, 0.00855045f, 
    -0.22470741f, 0.19940552f, 0.05472943f, 0.27240410f, 0.02722303f, -0.11511374f, -0.00659880f, -0.01975378f, 
    -0.07995923f, -0.08041443f, 0.03769500f, 0.12634531f, -0.11953113f, 0.09224731f, -0.18119942f, -0.03624739f, 
    0.00107497f, -0.04925695f, 0.04037752f, 0.02338479f, 0.00916438f, -0.05067369f, 0.07583233f, 0.09236060f, 
    -0.04608615f, -0.17768969f, -0.01890093f, 0.05606885f, -0.01735950f, 0.08272389f, 0.05905749f, 0.16565947f, 
    0.01911602f, 0.01651747f, 0.11714072f, 0.10879827f, -0.18906832f, 0.25267687f, 0.09192367f, -0.48516646f, 
    0.00555260f, -0.21638986f, 0.21163878f, 0.03057454f, -0.01685080f, 0.06486477f, -0.14251035f, 0.13529716f, 
    -0.18167639f, -0.03457595f, -0.03905235f, 0.03122694f, -0.06841723f, -0.14797987f, 0.01852743f, -0.02970924f, 
    -0.08901881f, -0.01363630f, -0.05473185f, -0.08745676f, 0.13140684f, 0.10666048f, 0.41177854f, -0.23928948f, 
    -0.01691864f, -0.10378014f, -0.07200273f, 0.04410117f, 0.01466805f, 0.02435136f, 0.06534861f, -0.07778324f, 
    0.20438778f, 0.12405909f, -0.09973965f, 0.02857096f, 0.00738087f, -0.09424397f, 0.06779578f, -0.03193828f, 
    0.06757654f, 0.19625743f, 0.13775332f, 0.23810175f, 0.13190524f, -0.02345945f, -0.03365196f, -0.02676448f, 
    0.06685960f, 0.20475103f, -0.01160981f, 0.20044027f, -0.02895606f, -0.13770908f, -0.02820844f, 0.01949387f, 
    -0.01645583f, 0.03393507f, -0.02045681f, -0.12153874f, 0.00532425f, 0.08214087f, -0.07877571f, 0.13477300f, 
    0.01751576f, -0.04118095f, -0.12881406f, -0.13587384f, -0.32527012f, -0.26424727f, 0.00686112f, 0.12090544f, 
    -0.00623291f, 0.03483969f, 0.10146689f, -0.11203765f, 0.09509613f, -0.04401609f, 0.08349095f, 0.14461541f, 
    0.00556896f, -0.07737124f, 0.12890448f, -0.00318450f, -0.01065487f, 0.02591415f, 0.06763393f, 0.03611575f, 
    0.12426905f, -0.00925155f, -0.02925294f, 0.05202897f, -0.06897673f, -0.00640477f, -0.12157592f, 0.05318347f, 
    0.23276150f, 0.06903867f, 0.02223490f, 0.07983613f, -0.16829309f, -0.01479183f, 0.01454988f, -0.07870045f, 
    -0.08877500f, 0.08443026f, -0.10151915f, 0.08043690f, 0.00854690f, 0.00008287f, 0.02802447f, 0.04032290f, 
    0.01378640f, 0.05698005f, 0.04012068f, 0.07510512f, -0.34980711f, -0.35310599f, 0.31788352f, 0.54991227f, 
    0.02371080f, 0.01364035f, -0.00831824f, 0.01820403f, 0.02570183f, 0.00271464f, 0.03921885f, 0.15043204f, 
    -0.09215505f, -0.05969571f, 0.27551088f, 0.00463422f, -0.25051937f, -0.27335480f, -0.09824312f, -0.06079867f, 
    0.01493718f, 0.09675809f, 0.09904442f, -0.01696098f, -0.05571014f, -0.02896059f, 0.11983921f, -0.06130299f, 
    0.16423595f, 0.27625957f, -0.14577116f, 0.07385047f, 0.10052351f, -0.00287124f, -0.01398263f, -0.00341906f, 
    0.05115771f, 0.12907605f, 0.04097430f, -0.03298602f, 0.07978455f, -0.04925502f, 0.00804509f, -0.08041804f, 
    0.12503076f, 0.13114965f, 0.03244043f, 0.10204175f, -0.17163756f, 0.00553467f, -0.03609591f, -0.05509936f, 
    -0.04764052f, -0.15937871f, 0.05341579f, -0.19196077f, 0.04906912f, -0.07240125f, -0.07783766f, -0.07267673f, 
    0.06548817f, -0.13477026f, 0.29214063f, -0.12181985f, -0.01606061f, 0.15534240f, -0.14498080f, 0.26171505f, 
    0.04271962f, 0.07148281f, -0.04276996f, -0.14117876f, -0.28926572f, -0.14224331f, 0.22265814f, 0.24484894f, 
    0.03898328f, 0.03436879f, -0.02559428f, 0.05251341f, 0.05755487f, 0.06615108f, 0.13987240f, 0.06656504f, 
    0.50044823f, -0.18380350f, 0.07145474f, -0.13166294f, -0.01588668f, 0.09635931f, -0.02966133f, 0.09191989f, 
    0.03927987f, 0.05762091f, 0.04348157f, -0.04448021f, -0.19964246f, -0.45542091f, 0.06969889f, 0.39032045f, 
    0.02251926f, 0.23888448f, 0.22522135f, -0.00471532f, 0.14368629f, 0.09599210f, 0.02352599f, 0.13786161f, 
    -0.10227017f, 0.01825112f, 0.04805452f, -0.06441772f, -0.18744612f, -0.10818379f, -0.01797753f, -0.00656476f, 
    -0.03828909f, -0.09136243f, 0.00099264f, -0.12404633f, 0.47598553f, -0.01218032f, -0.21755055f, -0.07805070f, 
    0.05417474f, 0.05971935f, 0.02797523f, 0.07376094f, -0.00237934f, -0.00828352f, 0.02661752f, -0.11465289f, 
    -0.21223038f, -0.26254797f, 0.00864897f, 0.11660598f, -0.00344506f, 0.05256623f, 0.08395521f, -0.05979324f, 
    0.22600524f, 0.15966876f, 0.00293797f, 0.13498579f, -0.11019272f, -0.13118760f, -0.20475005f, 0.43674535f, 
    -0.04227636f, 0.10917721f, -0.04511373f, -0.11265317f, 0.04978451f, 0.02293689f, 0.10789645f, 0.29999110f, 
    0.04555274f, 0.05834424f, 0.15189549f, -0.01550835f, 0.02341400f, 0.04088625f, -0.05083711f, -0.24894637f, 
    0.05528741f, 0.13544375f, 0.02718298f, -0.02372490f, -0.03234054f, 0.13613518f, -0.07530862f, 0.09979738f, 
    -0.02027650f, -0.04427258f, 0.03586582f, -0.03934513f, -0.02355614f, -0.09565573f, -0.15202899f, 0.03095638f, 
    0.01359558f, -0.03034669f, -0.04139417f, 0.02802851f, 0.05084102f, 0.00363320f, -0.01714992f, -0.04146589f, 
    0.04180174f, 0.03440772f, -0.04781939f, 0.03983351f, 0.01470191f, -0.01976952f, -0.00884192f, -0.03990391f, 
    -0.02610030f, -0.05232122f, 0.03258914f, 0.01097365f, 0.00145985f, 0.00382688f, 0.01995079f, -0.01628691f, 
    -0.00754671f, -0.02590917f, -0.01026757f, -0.04243651f, -0.04951012f, -0.03382321f, 0.00290066f, -0.02377165f, 
    0.03472383f, -0.01953102f, -0.03629186f, 0.00710487f, 0.04131315f, 0.00432512f, -0.05526717f, -0.03471582f, 
    0.02185470f, 0.02334010f, -0.02529421f, -0.03200737f, -0.02077070f, 0.04340062f, -0.01987638f, -0.04253480f, 
    -0.01376330f, -0.04961728f, 0.03298688f, 0.03480565f, 0.01542052f, -0.04061762f, -0.00962298f, -0.01217919f, 
    0.03262835f, -0.03146114f, -0.01452621f, -0.04436015f, -0.00184943f, -0.02682541f, -0.05468123f, 0.01390082f, 
    0.04482470f, 0.00400548f, -0.03391575f, 0.03344987f, 0.00555099f, -0.00908301f, 0.00105219f, 0.02120459f, 
    0.01052082f, 0.00468786f, -0.03890058f, -0.00179920f, 0.00923908f, -0.01670600f, -0.02384757f, -0.00753584f, 
    -0.01449428f, 0.03208620f, -0.05071880f, 0.02691780f, 0.00666918f, 0.01136287f, -0.00968652f, -0.05405157f, 
    0.03050614f, -0.04445330f, -0.01844468f, 0.02822842f, -0.04735926f, -0.04313282f, -0.00301875f, 0.00572206f, 
    0.04309595f, 0.00386693f, -0.05386775f, 0.01512345f, -0.02433752f, 0.02971304f, 0.02868111f, -0.03145368f, 
    0.02808039f, -0.00198973f, -0.00627819f, -0.02082875f, -0.03358076f, 0.01748140f, -0.04607843f, -0.05566193f, 
    0.01036403f, -0.03287958f, -0.02680190f, -0.04355309f, -0.00878631f, -0.04559642f, 0.02766837f, 0.01816378f, 
    -0.02809118f, 0.00175727f, -0.01889640f, -0.04382137f, -0.04154234f, 0.02722801f, 0.03780283f, -0.03532416f, 
    -0.02397243f, -0.01685878f, -0.05322813f, 0.03659190f, -0.03524300f, -0.00863959f, -0.00002275f, -0.04718935f, 
    0.04497905f, 0.04205781f, 0.00565570f, 0.01994522f, 0.03758116f, -0.01460994f, 0.01575440f, -0.05013466f, 
    0.00741217f, -0.01703961f, -0.05009816f, -0.04529445f, -0.03447192f, 0.00945390f, 0.03419987f, 0.04444506f, 
    -0.00739724f, -0.01402444f, -0.04890437f, 0.01521556f, -0.00930938f, -0.01860592f, -0.04054462f, -0.04666964f, 
    -0.05063647f, -0.05043847f, -0.04037940f, -0.00877398f, -0.00344759f, -0.03864306f, -0.03842158f, -0.05596384f, 
    -0.01385534f, -0.03966404f, 0.03585126f, -0.04892682f, -0.00272697f, -0.01901233f, -0.00654349f, 0.01259406f, 
    -0.04639336f, -0.00223001f, -0.03122787f, -0.01096083f, -0.01526691f, -0.01514885f, -0.00225446f, 0.03728156f, 
    0.04050351f, -0.02231036f, -0.02864021f, -0.00384675f, -0.03633117f, 0.02265451f, 0.02409474f, 0.02016624f, 
    0.01356695f, 0.03412978f, 0.01306968f, -0.04307222f, 0.00088041f, -0.03716386f, 0.01735013f, -0.02834345f, 
    0.00235561f, 0.01540458f, 0.02114875f, -0.01063410f, 0.01830452f, -0.01533430f, 0.00664996f, -0.00527167f, 
    -0.03833694f, -0.04285024f, 0.03879192f, -0.04066394f, -0.04068328f, 0.00041763f, -0.03623893f, -0.01508947f, 
    -0.03518544f, -0.05101439f, -0.00234759f, -0.01823222f, -0.00375455f, 0.00829351f, 0.01484951f, -0.03857828f, 
    0.01322101f, -0.03885299f, 0.03149600f, -0.04703194f, -0.02984263f, 0.03353065f, 0.03594781f, -0.01222012f, 
    -0.02396539f, 0.01072372f, -0.02334300f, 0.03155186f, 0.02651873f, -0.02343191f, -0.00030478f, -0.05169165f, 
    -0.02961253f, 0.00981056f, -0.03836541f, -0.03843359f, 0.02996419f, 0.04493744f, 0.03761625f, -0.04979022f, 
    -0.00795305f, -0.02399945f, 0.03616841f, -0.04476532f, -0.02222759f, 0.01526912f, 0.03620411f, -0.04291133f, 
    -0.05157197f, 0.03342175f, 0.03504897f, -0.00912446f, -0.05577162f, 0.04588956f, -0.01514716f, -0.02860786f, 
    0.01248392f, -0.00532001f, -0.03780793f, -0.02676870f, 0.01175783f, -0.03887425f, 0.02848477f, 0.03740895f, 
    -0.02801925f, -0.04198997f, -0.02644941f, 0.03313679f, 0.00212048f, -0.03344912f, 0.02496852f, -0.02272726f, 
    -0.03573303f, -0.01668275f, 0.00658589f, -0.03564471f, -0.01113075f, 0.01212946f, -0.05051727f, 0.01300704f, 
    0.03372480f, 0.00181266f, 0.02202848f, -0.01394478f, 0.01288325f, -0.04387712f, -0.00973519f, 0.02362654f, 
    -0.00468142f, 0.01417427f, -0.00892575f, 0.03474348f, -0.00175307f, -0.00373825f, -0.03882323f, 0.04201941f, 
    -0.03820040f, -0.00620970f, -0.03046349f, -0.00335512f, 0.03551336f, 0.02121771f, 0.00202423f, -0.05408532f, 
    -0.02406417f, -0.02280884f, -0.04054378f, -0.01529467f, 0.00518670f, -0.03025915f, 0.02349119f, -0.01454814f, 
    -0.01972738f, 0.01437652f, -0.04536337f, 0.01604385f, -0.03107711f, -0.04061079f, -0.02443396f, -0.03953547f, 
    -0.02809506f, -0.00412072f, 0.01101464f, 0.02922620f, 0.00210549f, 0.00367167f, -0.01319593f, -0.04772354f, 
    0.04252336f, 0.00929314f, 0.01194057f, -0.04109412f, 0.02769071f, -0.04217812f, 0.00333822f, -0.02415474f, 
    -0.02518466f, -0.04762245f, -0.04025071f, 0.01661900f, 0.02944637f, -0.00240624f, 0.02236327f, -0.04622316f, 
    0.01290947f, -0.05478454f, -0.03306887f, -0.04758859f, -0.04472223f, -0.03132365f, -0.00703035f, -0.04478675f, 
    -0.05365274f, 0.01217712f, -0.03340336f, -0.02818613f, -0.00908130f, -0.03124695f, -0.03042766f, -0.03664508f, 
    -0.01296785f, -0.05511711f, 0.02891004f, 0.03933331f, -0.02812584f, 0.03960707f, -0.01250700f, -0.00381608f, 
    0.03426178f, -0.04478631f, 0.01832692f, -0.01645557f, -0.01320085f, -0.01645797f, 0.00781261f, -0.03985621f, 
    -0.03179206f, 0.01471606f, -0.04946488f, 0.00430367f, -0.04218084f, 0.00402965f, 0.01479631f, 0.04037995f, 
    -0.00586396f, -0.01731627f, -0.04911260f, 0.00493869f, 0.02577413f, 0.02793181f, -0.05514688f, 0.03475928f, 
    -0.04177646f, 0.00285928f, 0.02771471f, 0.02189077f, -0.00601652f, -0.01655921f, 0.03033804f, -0.05056454f, 
    -0.04131960f, -0.05014114f, -0.01107017f, -0.01648879f, 0.02622215f, 0.03757367f, -0.05377478f, 0.04289220f, 
    -0.01080015f, -0.00780592f, 0.01837983f, -0.01136001f, -0.03092864f, -0.05409140f, 0.04676870f, 0.03674706f, 
    0.00410690f, 0.02473552f, 0.04557514f, -0.00791625f, 0.00256311f, 0.01789907f, 0.02151131f, -0.00903424f, 
    0.02025139f, -0.04536535f, 0.02198187f, -0.01895997f, -0.02613512f, 0.00647397f, 0.04036147f, -0.04094619f, 
    -0.04290942f, 0.03677160f, -0.00298713f, 0.03839800f, 0.01651490f, 0.04957332f, -0.04945475f, 0.03322109f, 
    0.04867840f, -0.03922126f, -0.01351748f, 0.01795710f, 0.02556387f, -0.02787619f, 0.00256245f, -0.03511066f, 
    0.02680704f, -0.03590814f, 0.04030871f, -0.00973189f, 0.03030932f, 0.02270805f, 0.03159128f, 0.01586971f, 
    0.00649943f, 0.03084258f, -0.05711511f, 0.00258174f, -0.03425291f, -0.04765340f, -0.00311836f, -0.02613036f, 
    0.03161215f, -0.03561751f, -0.02623331f, -0.04489262f, -0.01308024f, 0.00055811f, 0.03160110f, 0.02179049f, 
    -0.02652245f, 0.03126332f, -0.00119962f, -0.00284280f, -0.05179690f, 0.00179685f, 0.00601692f, -0.01290616f, 
    -0.04475969f, 0.00704140f, -0.00810251f, 0.04107123f, 0.02681633f, -0.02434605f, -0.03497595f, 0.02982243f, 
    0.01472242f, -0.03981284f, -0.05276757f, -0.02823168f, -0.04904491f, 0.03139319f, -0.04364276f, 0.03820841f, 
    -0.01716748f, 0.02459780f, -0.02462951f, 0.01193156f, 0.00459637f, 0.03150703f, -0.04028603f, -0.04241395f, 
    -0.04987606f, -0.05832908f, -0.04141011f, 0.00598373f, 0.04464883f, 0.04732112f, 0.03328786f, -0.05213992f, 
    0.00600556f, -0.00309131f, -0.00781277f, -0.01573804f, -0.03526388f, 0.01827639f, -0.03978746f, 0.02227939f, 
    -0.02853311f, 0.00869032f, -0.02947826f, 0.03217316f, 0.00478905f, -0.03467083f, -0.02999991f, -0.01502578f, 
    -0.04028632f, 0.03683199f, -0.01896145f, -0.04061035f, -0.02765257f, -0.03256990f, -0.00815895f, 0.02174104f, 
    0.00148771f, 0.00155948f, -0.03486489f, -0.00332856f, -0.02391811f, 0.03091831f, -0.05396975f, 0.00504663f, 
    -0.00293694f, -0.00705376f, 0.04836936f, -0.03869981f, 0.00883568f, 0.01556814f, -0.04201918f, -0.05197314f, 
    -0.02004220f, -0.04053295f, -0.05718822f, 0.03138839f, 0.01916527f, -0.00989065f, -0.00356259f, -0.02310222f, 
    -0.01418913f, -0.03670112f, 0.01094511f, 0.00605989f, -0.02877980f, 0.00181863f, -0.02493734f, -0.02148348f, 
    -0.04195503f, -0.03830362f, -0.04069909f, -0.00147158f, -0.02413630f, 0.02931743f, -0.04278345f, 0.03093167f, 
    -0.03998218f, -0.03379140f, 0.02797181f, -0.01910253f, 0.01635987f, 0.03673620f, -0.05006944f, 0.00857573f, 
    0.01876923f, 0.02290060f, -0.00810254f, -0.00069584f, -0.01715245f, 0.01970542f, 0.01853943f, -0.04255111f, 
    0.00207420f, 0.01262540f, 0.03424992f, -0.01719422f, -0.01916462f, 0.01783658f, -0.04994855f, -0.01460463f, 
    0.04377829f, -0.03716256f, -0.05030397f, 0.02424739f, 0.04249763f, 0.03496245f, -0.01050886f, -0.00943784f, 
    0.02398402f, -0.02340436f, 0.03404102f, 0.01692068f, -0.00351238f, -0.01827887f, -0.02116329f, -0.00338414f, 
    -0.00783748f, -0.03534850f, -0.05550569f, -0.05721823f, -0.02578503f, -0.04742491f, 0.01251959f, -0.04967352f, 
    -0.03281800f, -0.01150131f, 0.02674899f, -0.04910438f, -0.01577159f, -0.00757375f, 0.03934934f, 0.00222306f, 
    0.02161506f, -0.05279068f, -0.03445073f, -0.04154193f, 0.02140990f, -0.03310858f, -0.00819036f, -0.00293818f, 
    0.00677443f, -0.03005009f, -0.00665298f, -0.01073891f, -0.04531825f, 0.02087290f, 0.03068415f, 0.00651320f, 
    0.03507568f, 0.03777658f, -0.01640240f, 0.00118257f, -0.02175951f, -0.02749786f, -0.01072782f, -0.01618191f, 
    -0.02764792f, -0.01143810f, 0.03351880f, -0.05207724f, -0.02767850f, -0.01870267f, 0.02751953f, 0.00122489f, 
    -0.02077156f, -0.03617265f, 0.01683607f, 0.02460241f, 0.01376702f, 0.04276766f, 0.00499378f, -0.02667915f, 
    -0.00369621f, 0.00600764f, -0.03741902f, 0.02228699f, -0.01290108f, -0.03938776f, 0.03155340f, -0.01133557f, 
    0.00153856f, 0.04464992f, 0.00167040f, -0.01449553f, -0.00486070f, -0.04261903f, 0.01818415f, -0.04413579f, 
    -0.00920468f, -0.02051135f, 0.00188438f, 0.03898286f, -0.03887238f, -0.05787027f, -0.03878690f, -0.01188435f, 
    0.00952245f, -0.03855689f, -0.03005659f, 0.00664067f, -0.01730840f, -0.01876865f, -0.05152464f, -0.03583323f, 
    -0.01602245f, -0.05209366f, 0.03657219f, 0.02042381f, 0.03050866f, -0.03850199f, -0.01139913f, -0.03851090f, 
    -0.05639250f, 0.02641285f, 0.03104041f, -0.00303007f, -0.04542987f, -0.01733731f, 0.01294626f, -0.01354778f, 
    0.01805711f, 0.00272674f, -0.03906722f, -0.05353782f, -0.05850616f, 0.02015762f, 0.03964730f, -0.02098009f, 
    0.04717695f, -0.03440678f, 0.00101940f, -0.04814824f, 0.00917876f, -0.03134947f, 0.03298370f, 0.01922065f, 
    0.03157265f, 0.05063642f, 0.03391344f, 0.00013911f, -0.01315059f, -0.05463599f, -0.00601425f, -0.01806239f, 
    0.02747834f, 0.01817237f, 0.00155373f, 0.01951166f, -0.04687472f, -0.02865449f, 0.00549334f, 0.00926384f, 
    -0.04941338f, 0.00484314f, -0.02435854f, 0.02740176f, -0.03694716f, -0.02683801f, 0.00999701f, -0.03343746f, 
    0.25295249f, 0.34895635f, 0.39494544f, 0.24983411f, 0.08283966f, 0.08541995f, 0.10679594f, -0.04597259f, 
    0.08855400f, -0.00640376f, -0.06430074f, -0.20983176f, 0.26326737f, 0.19497301f, 0.33322671f, 0.43691280f, 
    0.14881842f, -0.00311144f, 0.14211172f, 0.00477835f, 0.03789069f, 0.01558060f, -0.05886545f, 0.00440328f, 
    0.33074084f, 0.13334970f, 0.13327308f, 0.18957131f, 0.02756571f, 0.12038158f, 0.13568668f, 0.16071893f, 
    0.11917337f, 0.05570160f, 0.01780112f, 0.00457939f, -0.40671128f, -0.04561641f, -0.05424298f, -0.14924406f, 
    -0.03946228f, -0.12858854f, -0.25345370f, -0.09590516f, 0.03782787f, 0.08411931f, -0.04001916f, -0.11551811f, 
    0.07463285f, -0.01214371f, -0.10430241f, -0.01008880f, 0.03456109f, -0.05934053f, 0.05645800f, 0.04050830f, 
    -0.18821648f, -0.10962633f, 0.06860942f, 0.04531708f, 0.23034224f, -0.26477167f, -0.38443303f, -0.03775582f, 
    -0.00191959f, -0.01626892f, -0.18017462f, -0.03152682f, 0.13961282f, -0.01537600f, -0.22556131f, 0.02385543f, 
    0.06223426f, -0.18067065f, 0.00776897f, -0.09414559f, -0.01821359f, -0.08574539f, 0.22567928f, -0.08699917f, 
    0.03990468f, -0.13715930f, 0.05144867f, 0.22128934f, 0.10273131f, 0.03535133f, 0.34173983f, 0.07974983f, 
    0.05575404f, 0.00961926f, 0.03683491f, -0.04122928f, 0.00634525f, 0.06940787f, -0.15687497f, -0.01522871f, 
    0.04430097f, 0.18111326f, 0.18776855f, 0.24729040f, -0.04642495f, 0.13649498f, -0.02695255f, 0.07651882f, 
    -0.05098707f, 0.08418369f, 0.07886450f, 0.01150487f, 0.39607489f, 0.03437831f, -0.04108573f, 0.17714764f, 
    -0.08591811f, -0.02722880f, 0.08950374f, -0.07170542f, 0.05543328f, -0.07156099f, -0.01891840f, 0.01744000f, 
    -0.17972216f, 0.05423824f, 0.00635675f, -0.08183792f, -0.08281373f, -0.03601921f, -0.22977538f, -0.02418669f, 
    0.01544967f, -0.12249277f, -0.01373719f, 0.02920309f, -0.00350036f, 0.02840430f, -0.16106838f, 0.02784464f, 
    0.02320709f, 0.10680201f, -0.01735252f, 0.05324048f, 0.03181443f, 0.06448152f, 0.10628796f, 0.06632774f, 
    0.10019428f, -0.08679557f, 0.04618260f, 0.11593474f, 0.10242587f, 0.22664978f, -0.10327370f, 0.02579511f, 
    0.16198157f, -0.06132783f, 0.15882373f, 0.30149159f, -0.16202569f, -0.06301862f, -0.21569550f, 0.21573734f, 
    0.06044154f, -0.08890502f, -0.22455606f, 0.09787562f, -0.06313181f, 0.08985962f, -0.04931968f, -0.06490238f, 
    -0.04388884f, -0.11053859f, 0.32536480f, 0.16653077f, 0.12324639f, 0.12175418f, 0.00273314f, 0.08751043f, 
    -0.03571709f, -0.04358319f, -0.01345087f, 0.01575358f, -0.06790303f, 0.16475014f, -0.10218397f, -0.12222375f, 
    0.03040792f, 0.08530676f, 0.14436345f, 0.10789733f, 0.04445049f, 0.14305605f, -0.01166566f, 0.08372345f, 
    -0.13043199f, -0.06337030f, -0.17873316f, -0.06848624f, -0.03019750f, -0.08240023f, 0.03382578f, -0.08007664f, 
    -0.08101502f, 0.03425578f, -0.03900015f, 0.16989483f, -0.09827866f, 0.19853346f, 0.45588258f, -0.07442471f, 
    0.07042098f, -0.05456050f, 0.02293742f, 0.14412920f, -0.08832546f, 0.00207776f, 0.09353057f, 0.01063518f, 
    0.04128890f, -0.15237357f, 0.18180890f, 0.03125447f, 0.12411224f, -0.08604992f, -0.02658410f, 0.13069504f, 
    0.06240733f, 0.01370153f, 0.04955184f, 0.02250165f, -0.07406591f, 0.17003866f, -0.08694839f, 0.15991549f, 
    -0.12119918f, 0.15251310f, -0.02002119f, 0.02439648f, 0.14977928f, 0.04485299f, -0.00106061f, -0.10226762f, 
    -0.07730909f, 0.09386459f, 0.28474274f, 0.18988089f, 0.19918522f, -0.02060738f, 0.13049933f, -0.13048540f, 
    0.06470936f, -0.01466172f, -0.15587890f, 0.06146909f, 0.19548035f, 0.31566995f, 0.24475391f, 0.32556659f, 
    -0.00799757f, 0.12919447f, 0.10190042f, 0.09899769f, 0.03240011f, 0.09605624f, 0.03282610f, 0.03707010f, 
    0.01438397f, 0.08222790f, -0.01262344f, 0.19975039f, -0.14190102f, 0.05676862f, 0.19866201f, 0.06734829f, 
    0.05232223f, -0.07314042f, -0.01979309f, 0.01584081f, 0.00260140f, -0.15550715f, -0.14780138f, -0.18233293f, 
    0.02871933f, 0.03524871f, 0.03614977f, 0.10674615f, 0.02539450f, 0.13198224f, -0.03938404f, 0.00623371f, 
    -0.10837156f, -0.29086348f, 0.04897375f, -0.16430350f, 0.01873060f, -0.13760991f, -0.12091459f, -0.10405042f, 
    -0.00048318f, -0.01841808f, 0.04134079f, 0.03282028f, -0.05771983f, 0.45792404f, -0.12418772f, 0.01731349f, 
    0.04289592f, -0.05443093f, -0.18417795f, 0.04437712f, -0.05467743f, -0.04119859f, 0.05391425f, 0.04225702f, 
    -0.10286073f, 0.21440199f, 0.31588477f, 0.02880607f, -0.05810001f, 0.16616672f, 0.01532060f, 0.16149357f, 
    0.02408622f, -0.00103723f, 0.00019902f, -0.03542585f, -0.20362754f, -0.11078295f, -0.10494656f, -0.28415996f, 
    -0.12765589f, -0.13049942f, -0.02426223f, 0.07378037f, 0.02775573f, -0.06115887f, 0.10643039f, -0.11620767f, 
    0.04465792f, 0.14769769f, 0.03500249f, 0.14955468f, 0.00290667f, -0.04448178f, -0.10557297f, -0.05297175f, 
    -0.05685176f, 0.11873769f, -0.09048942f, 0.04207648f, -0.36160037f, 0.11437731f, -0.10394574f, 0.01968949f, 
    -0.08271355f, 0.05605558f, -0.01316269f, 0.06830775f, -0.08494005f, -0.07404023f, -0.24573071f, 0.03252990f, 
    -0.27768603f, 0.08358416f, -0.06154595f, -0.00921684f, -0.04963761f, -0.00198788f, -0.12603828f, -0.13025483f, 
    0.11480545f, -0.13095851f, 0.23020403f, 0.01959357f, -0.35695025f, -0.11775021f, -0.13805570f, -0.07050930f, 
    -0.05660792f, -0.06671274f, 0.00212847f, -0.10237078f, -0.05392965f, 0.06522343f, -0.01989789f, 0.09221125f, 
    0.08820985f, -0.06388959f, -0.14389563f, -0.02975844f, 0.06330692f, -0.06664849f, 0.08549034f, 0.00654772f, 
    -0.07327024f, 0.06538823f, 0.00662242f, 0.00583666f, -0.01610760f, -0.04327494f, -0.07675824f, -0.05030790f, 
    0.06846959f, 0.01358605f, -0.00543502f, -0.01237025f, -0.00972429f, 0.21822576f, 0.01215944f, 0.07878206f, 
    -0.16032381f, 0.20488219f, 0.02599281f, 0.00006632f, 0.05156171f, -0.02900945f, -0.09030217f, 0.02462594f, 
    -0.11465306f, -0.03581493f, -0.11330621f, 0.00256542f, 0.41337147f, -0.22104469f, 0.04687025f, 0.03067843f, 
    -0.12590317f, -0.08245451f, 0.14067268f, -0.06186386f, 0.06592478f, -0.01119419f, -0.12429079f, 0.10566013f, 
    -0.09178001f, 0.20908827f, 0.20370482f, -0.09749215f, 0.01661447f, -0.12797605f, -0.02327790f, 0.02840037f, 
    -0.12328267f, 0.16577223f, 0.08504952f, -0.07467560f, 0.14099398f, -0.06749238f, 0.11123926f, -0.01581739f, 
    -0.27284381f, 0.17350970f, 0.10934486f, 0.01232637f, 0.10473882f, -0.03845079f, 0.13444452f, -0.00574222f, 
    0.10666849f, 0.05132727f, 0.09859733f, 0.15773791f, -0.11097072f, -0.00188234f, -0.00465680f, -0.06695897f, 
    0.02965091f, 0.18670550f, 0.12855522f, 0.10362823f, 0.77096808f, -0.26348534f, 0.07362301f, 0.11186178f, 
    -0.19187453f, -0.09721191f, 0.06626769f, 0.06233525f, -0.02267428f, 0.10216982f, -0.01303910f, 0.17282425f, 
    -0.15465365f, -0.10946664f, -0.15569559f, -0.12116943f, -0.05879575f, -0.04972111f, 0.03233957f, -0.08616320f, 
    -0.00977065f, 0.07993103f, 0.00210893f, 0.04600370f, -0.09228928f, 0.01021846f, 0.12395821f, 0.01825674f, 
    0.00468765f, -0.10801975f, -0.06978979f, 0.09984490f, 0.05839487f, 0.26273310f, -0.06318325f, 0.07788806f, 
    0.24845703f, -0.05127849f, -0.04046278f, -0.03614149f, -0.12993917f, -0.07366443f, 0.16843575f, 0.08611353f, 
    -0.00665649f, 0.26407653f, 0.21812737f, -0.12432208f, -0.01618756f, 0.07553546f, -0.06964967f, -0.00737457f, 
    0.17035873f, -0.01850001f, -0.16286287f, 0.02305483f, -0.17203315f, -0.06208849f, -0.04060434f, -0.11779532f, 
    0.12195685f, 0.11833345f, 0.04429873f, -0.14155518f, -0.05686406f, -0.15877311f, -0.06300402f, -0.11548353f, 
    0.00753646f, 0.07893042f, -0.13838214f, -0.16498084f, 0.23856284f, -0.04681245f, 0.04720637f, -0.12933393f, 
    -0.08457503f, 0.14491725f, 0.11216689f, 0.10115781f, 0.01917169f, 0.07690175f, 0.12177537f, 0.08464678f, 
    0.26531237f, -0.09544373f, 0.28541133f, -0.21686071f, -0.09779043f, 0.01749992f, 0.11305985f, 0.03540367f, 
    0.08907501f, -0.15639663f, 0.11886671f, 0.05519971f, -0.24584016f, 0.07587322f, -0.07985871f, 0.11499926f, 
    0.17754313f, 0.02860462f, -0.08134484f, 0.05655477f, 0.03125753f, 0.01572623f, 0.03019570f, 0.04587643f, 
    -0.10457729f, 0.13895154f, -0.00648892f, 0.03415323f, -0.00832439f, -0.03581271f, -0.05348074f, -0.00743377f, 
    0.01963039f, -0.01449862f, 0.07937206f, -0.14216627f, -0.43098277f, 0.81152624f, -0.22106656f, 0.16848478f, 
    0.22316061f, 0.19601646f, -0.13541444f, -0.03959468f, -0.17029428f, -0.06033768f, 0.09661943f, 0.02979951f, 
    -0.32077360f, 0.12090462f, 0.10607611f, 0.17316967f, 0.09573185f, -0.03746860f, 0.07624459f, -0.11058338f, 
    -0.03478764f, 0.07412632f, 0.10469154f, -0.09046663f, -0.06449298f, 0.25075388f, 0.14921677f, 0.03745244f, 
    0.04832132f, -0.06573792f, 0.00589627f, 0.00896360f, -0.07262213f, -0.18435039f, 0.00919245f, -0.11923309f, 
    0.11840809f, -0.06001760f, -0.20664610f, 0.06148820f, -0.06602643f, -0.10292466f, -0.07282788f, -0.03363942f, 
    0.08176714f, 0.12467078f, 0.10033212f, 0.04218290f, 0.12623152f, -0.09891661f, 0.03792638f, -0.07913374f, 
    -0.03325067f, -0.07573441f, -0.07265130f, -0.04301023f, -0.08336873f, -0.13835335f, -0.08157196f, -0.07471807f, 
    0.03684717f, 0.03858975f, -0.04487725f, 0.00346889f, 0.03035627f, 0.00672531f, 0.07257951f, 0.16703348f, 
    0.15224653f, 0.14370283f, 0.14679131f, 0.07135957f, -0.02626349f, 0.47524482f, 0.23501374f, 0.02744917f, 
    0.20383018f, 0.01777206f, -0.05442147f, -0.08301002f, -0.23462102f, -0.07860740f, -0.06439229f, 0.23340936f, 
    0.46404010f, 0.38835889f, 0.45863065f, 0.20103468f, -0.11190002f, -0.27070105f, -0.01961619f, 0.05567085f, 
    0.07313860f, -0.00596980f, -0.09199899f, 0.06991026f, -0.23284332f, 0.57461077f, 0.05433979f, -0.11021215f, 
    -0.12814279f, -0.02380191f, 0.06867234f, -0.03748416f, 0.04517082f, 0.15089992f, 0.19768712f, 0.02048232f, 
    -0.04836715f, -0.22601007f, -0.11674181f, 0.14630350f, -0.01397819f, -0.11074278f, -0.01563444f, -0.07000587f, 
    0.00572547f, -0.03341011f, 0.07365038f, -0.04788909f, 0.25193876f, 0.21033221f, 0.29801777f, 0.33573642f, 
    -0.07318768f, -0.03857096f, -0.09875622f, 0.04422494f, 0.07383868f, -0.01811145f, -0.00839709f, 0.02733352f, 
    0.06604551f, -0.12946165f, -0.02373498f, 0.02267766f, 0.03924799f, 0.14553857f, -0.06279849f, -0.09990264f, 
    -0.00602071f, 0.04677840f, 0.12599823f, -0.03822411f, -0.43649065f, 0.54061228f, -0.01071076f, 0.05025907f, 
    0.12448622f, 0.07370463f, 0.01332019f, 0.01873756f, 0.01442974f, -0.17483214f, 0.03225118f, -0.21907441f, 
    -0.24182917f, -0.01595681f, -0.11842166f, 0.09408782f, -0.14972559f, 0.04172586f, 0.07098973f, 0.06204497f, 
    0.10246268f, -0.05099475f, -0.10524693f, 0.22280850f, 0.02489245f, 0.39726129f, 0.13183196f, -0.08553602f, 
    -0.07396246f, -0.01944185f, 0.07098269f, -0.03724740f, 0.09314175f, -0.02313274f, 0.04514769f, -0.06201455f, 
    -0.25289294f, 0.18733567f, 0.19593497f, 0.29124323f, -0.03356697f, -0.06734408f, 0.04861162f, 0.08664520f, 
    0.08230410f, 0.11316002f, 0.00871108f, 0.04540164f, -0.18132986f, 0.04052225f, 0.39650303f, 0.42368034f, 
    0.00619069f, -0.01930556f, 0.08970431f, -0.00920533f, -0.03864915f, -0.00629749f, -0.04992265f, -0.04270225f, 
    -0.05160194f, -0.11758396f, 0.03633999f, 0.14110185f, 0.11606940f, 0.13858765f, 0.07741161f, -0.06233158f, 
    0.03820333f, 0.22147048f, -0.03143420f, 0.05761556f, -0.50099421f, -0.09702449f, 0.18985833f, 0.03045452f, 
    0.04846318f, 0.02462169f, -0.11779372f, -0.12647326f, 0.09230978f, -0.01242474f, -0.04855304f, 0.05316758f, 
    -0.24415809f, -0.04165849f, 0.03496201f, 0.00803433f, -0.11193082f, -0.04481542f, 0.05395394f, 0.05020439f, 
    0.00744741f, 0.12679359f, 0.04506289f, 0.17355484f, 0.10531207f, -0.01736039f, -0.07226767f, -0.26609138f, 
    0.01864799f, -0.07445693f, -0.18785574f, 0.01891371f, -0.02338833f, 0.23408656f, -0.08021427f, -0.00372401f, 
    0.54785210f, 0.06261647f, 0.17085740f, -0.19811916f, 0.04585468f, -0.00321721f, -0.05498160f, 0.14402911f, 
    0.05851652f, 0.10320476f, 0.06322369f, 0.18577923f, 0.26729566f, 0.15362266f, 0.29413813f, 0.53991634f, 
    0.16396736f, -0.00087449f, -0.02193720f, 0.22500372f, 0.15223153f, 0.13971429f, 0.20748638f, -0.01690803f, 
    -0.13135965f, -0.24375424f, -0.26596397f, 0.12369725f, 0.17934042f, 0.12658007f, 0.01352218f, -0.06430759f, 
    -0.02368788f, 0.11670329f, 0.15293543f, 0.01989653f, -0.00936075f, 0.11554391f, 0.14398596f, 0.29150173f, 
    0.06935152f, 0.04323455f, 0.05822532f, 0.06122530f, 0.15976065f, 0.00227379f, 0.06854814f, 0.02460026f, 
    -0.01471009f, 0.31526273f, 0.00523974f, -0.19777146f, -0.08232280f, -0.01411674f, -0.12215839f, -0.15781373f, 
    0.04091641f, 0.09345253f, -0.04761009f, -0.06085853f, -0.23039860f, -0.11597714f, -0.10151090f, 0.00264271f, 
    0.09474705f, -0.02487836f, -0.14444813f, -0.05575735f, -0.08154212f, 0.07859406f, 0.10582776f, -0.01788173f, 
    -0.19003904f, -0.09022582f, -0.16646460f, 0.17150584f, -0.14411248f, -0.17717095f, -0.19350742f, -0.14595729f, 
    -0.14019874f, 0.32359084f, -0.13950858f, 0.15636216f, 0.09425537f, -0.23671742f, -0.10054207f, 0.04982388f, 
    0.03367469f, -0.11212409f, 0.07005509f, 0.12813824f, -0.00111789f, 0.07437987f, 0.02486256f, 0.11806236f, 
    -0.09469493f, -0.32134193f, 0.20761085f, -0.12161998f, 0.28613144f, 0.14402595f, -0.18613119f, -0.04397337f, 
    -0.05477157f, -0.06964282f, -0.01737508f, 0.06812090f, 0.03698869f, -0.04371231f, -0.22575617f, 0.15997462f, 
    -0.00593414f, -0.06215893f, 0.12385913f, 0.07953687f, 0.01242712f, -0.03446483f, 0.12508142f, 0.14776078f, 
    -0.31143799f, 0.18239297f, -0.08453225f, -0.19288854f, -0.25050288f, -0.00567943f, -0.13518447f, -0.11132515f, 
    0.10999317f, -0.01473333f, -0.07410437f, 0.10503400f, -0.03499830f, 0.54057193f, 0.41288960f, -0.07273027f, 
    0.01631741f, -0.07059511f, 0.06314553f, 0.11025092f, -0.05009092f, 0.17944986f, 0.04202685f, 0.01461460f, 
    -0.16185322f, -0.02069554f, 0.12688972f, 0.01168233f, 0.04171366f, -0.02565521f, 0.02389843f, 0.07975512f, 
    0.09366350f, 0.01447914f, -0.13701728f, -0.06248614f, -0.30751246f, -0.08713879f, -0.09171026f, 0.16030483f, 
    -0.13293523f, -0.04694102f, 0.13108212f, -0.08589859f, -0.07558431f, 0.04608443f, -0.04300339f, -0.02365516f, 
    -0.22854422f, -0.20844497f, -0.13249962f, 0.04429753f, -0.01606820f, -0.06790146f, 0.07395770f, -0.14868644f, 
    0.08581965f, -0.07363772f, 0.02034154f, 0.14315492f, -0.21011350f, -0.22086018f, -0.08557881f, 0.02354444f, 
    0.08666311f, 0.16047777f, 0.10935035f, -0.11275557f, -0.00402054f, -0.01216671f, 0.00793358f, -0.02687994f, 
    0.25189754f, -0.01718890f, -0.03218610f, -0.01892604f, 0.03309316f, 0.04944685f, 0.13195150f, 0.05033700f, 
    0.19655631f, 0.09476757f, 0.17733265f, 0.04040944f, 0.05271487f, -0.16606395f, 0.28508842f, -0.35047400f, 
    -0.05052102f, 0.00394216f, -0.06589706f, 0.07706759f, 0.05981469f, 0.00205962f, 0.09367197f, 0.10629887f, 
    0.14417283f, 0.25433111f, 0.48761684f, -0.10707042f, -0.11728632f, 0.04033175f, -0.20257866f, -0.08103164f, 
    -0.00909483f, 0.09132471f, 0.11961883f, 0.11235616f, 0.39885655f, 0.16925715f, -0.02659724f, 0.06940887f, 
    -0.00585851f, -0.09284480f, -0.20603934f, 0.07270735f, -0.07441484f, 0.12876782f, 0.21619549f, 0.14965740f, 
    -0.36266488f, -0.21545340f, -0.09977727f, 0.22563085f, 0.10105863f, 0.24563335f, 0.02236982f, -0.09121291f, 
    0.06840874f, -0.03359649f, 0.04646822f, 0.02359527f, -0.26303536f, 0.03545048f, 0.41441748f, 0.05335581f, 
    -0.06000666f, 0.13319930f, -0.11864539f, -0.02138408f, 0.00100823f, 0.08141612f, 0.08951420f, 0.07966827f, 
    -0.16160756f, -0.24605308f, 0.14923905f, 0.09036394f, 0.03102331f, -0.02683947f, -0.02558090f, -0.10898770f, 
    0.10900663f, 0.10132785f, -0.01438953f, 0.01742337f, -0.16553393f, 0.05633209f, -0.46518993f, -0.21578510f, 
    -0.16188458f, -0.05493670f, -0.00071558f, 0.15392511f, -0.13249774f, 0.03674011f, -0.05760349f, -0.01473459f, 
    -0.22605658f, 0.23651357f, -0.33387670f, 0.02687353f, -0.08499763f, -0.00983651f, -0.09549154f, -0.07576564f, 
    0.21536849f, 0.00075913f, 0.05468372f, -0.07533965f, 0.02631137f, 0.27266046f, -0.19958758f, -0.29162419f, 
    -0.19288918f, -0.16943188f, -0.05351505f, 0.01581500f, -0.05846519f, 0.02514891f, 0.15017100f, 0.07342830f, 
    0.02570898f, -0.03744320f, 0.04809269f, -0.01533487f, 0.00493945f, 0.03594013f, -0.04862576f, -0.01299432f, 
    0.01170948f, 0.02409375f, -0.01959511f, -0.02198218f, -0.00185116f, -0.05173438f, 0.03413672f, -0.03422233f, 
    0.00558857f, -0.01027561f, 0.00481925f, 0.01036608f, -0.00111607f, -0.00272778f, 0.00280342f, -0.03065799f, 
    -0.00731443f, -0.00497859f, 0.00298235f, -0.05878612f, -0.02945010f, -0.01585233f, 0.00567930f, -0.01455347f, 
    -0.01227304f, -0.03015319f, 0.02518117f, -0.05891891f, 0.02473570f, -0.04560493f, -0.05101081f, -0.05610196f, 
    0.01702511f, -0.02582207f, -0.00301236f, 0.00673089f, -0.02809279f, 0.01331813f, -0.05455455f, -0.05061157f, 
    0.02178081f, -0.02546364f, 0.00620473f, 0.00632412f, 0.03248669f, -0.04294451f, 0.01253408f, 0.03042650f, 
    0.01655746f, -0.00810897f, -0.02449808f, 0.01052161f, 0.01139425f, -0.04901148f, -0.05036563f, -0.00981271f, 
    -0.01482734f, -0.04549013f, 0.02905870f, -0.02549696f, -0.05787765f, 0.01069803f, -0.04282019f, -0.05093589f, 
    -0.00269406f, 0.02808758f, -0.02872919f, -0.04082876f, 0.00416654f, -0.01536935f, -0.00297098f, 0.01015866f, 
    0.00560039f, -0.03441689f, -0.04853982f, -0.01384613f, 0.03587744f, -0.02518373f, -0.05402708f, -0.04320424f, 
    -0.05155394f, 0.00172779f, 0.01621494f, 0.03198395f, 0.03103823f, 0.02795580f, -0.00056677f, 0.02196603f, 
    0.02584788f, 0.02751004f, 0.03335453f, -0.01471149f, -0.01150044f, 0.03268278f, 0.02523640f, -0.00890761f, 
    -0.03259788f, -0.02351765f, -0.03944467f, 0.03990860f, 0.01155654f, -0.01052280f, 0.03045431f, -0.04115651f, 
    0.03257769f, -0.01775252f, 0.02414214f, -0.04427163f, -0.01911035f, -0.02675686f, -0.01484406f, 0.03842818f, 
    0.04116456f, 0.03250590f, -0.01376230f, 0.00252251f, 0.02990090f, -0.03949719f, -0.00409951f, -0.03167652f, 
    0.03117223f, -0.03851996f, 0.02404941f, 0.03181087f, -0.02484412f, -0.00526287f, 0.03755480f, 0.02159097f, 
    -0.03199970f, -0.02555244f, -0.05048576f, -0.00489003f, 0.02464769f, 0.01399906f, 0.00638858f, -0.00323289f, 
    -0.01476265f, 0.01658412f, -0.00066485f, 0.00055739f, -0.00089565f, 0.00151107f, 0.03236124f, -0.02712880f, 
    -0.01412118f, -0.00346805f, -0.03521157f, -0.01034024f, -0.00825868f, 0.01778632f, -0.03752895f, -0.01432430f, 
    0.02920908f, -0.04041766f, 0.00600058f, -0.01850019f, -0.00747785f, 0.03465981f, -0.03729953f, 0.01119628f, 
    -0.05387982f, 0.02978666f, -0.02313439f, 0.03893039f, -0.00479039f, -0.05392692f, 0.02588788f, -0.02540125f, 
    -0.03554512f, -0.01914246f, -0.00839095f, -0.05349404f, 0.00940999f, -0.05787385f, 0.01769773f, -0.04681824f, 
    -0.05601893f, -0.01967137f, 0.02005664f, 0.00380062f, -0.05315974f, -0.06426937f, -0.01282987f, -0.00972515f, 
    -0.03508682f, -0.02862239f, -0.02569019f, -0.05711617f, -0.03889322f, -0.03121316f, 0.00955639f, -0.02582733f, 
    -0.01884211f, 0.00934486f, -0.03864805f, -0.05630557f, -0.01601890f, 0.01328024f, -0.03206138f, -0.01597610f, 
    0.01400630f, 0.02204701f, -0.03723997f, 0.02759607f, -0.03473923f, 0.01215573f, 0.03838546f, 0.02780936f, 
    0.02944458f, -0.04200749f, -0.05304858f, -0.03813337f, -0.04560092f, 0.02993084f, -0.02014822f, 0.00519135f, 
    -0.00032437f, -0.01669514f, -0.02788422f, -0.00336417f, -0.02094494f, 0.01817431f, 0.01623379f, 0.02290784f, 
    -0.01976281f, 0.00718014f, 0.01143789f, -0.05742425f, -0.04352499f, 0.00248986f, -0.04679944f, 0.01473267f, 
    -0.04645277f, -0.03016640f, -0.02422125f, -0.03789034f, -0.01365273f, 0.00528294f, 0.03093372f, 0.01604129f, 
    0.00110639f, -0.02202730f, 0.00302923f, -0.02499395f, -0.02913136f, -0.02778434f, 0.02017513f, -0.02744084f, 
    -0.03374242f, -0.02256673f, 0.03106358f, -0.00627862f, 0.01839624f, -0.00744490f, 0.00758117f, 0.01690662f, 
    -0.00327269f, 0.00759841f, -0.04472149f, 0.02429026f, 0.03601500f, 0.01493759f, -0.03530172f, -0.00053892f, 
    -0.04147931f, -0.00220223f, -0.00239414f, 0.02828971f, -0.04836167f, -0.03117698f, 0.00766462f, -0.04824218f, 
    0.00169829f, -0.04316187f, -0.03681642f, -0.05619082f, -0.03997907f, 0.01053057f, 0.00839151f, -0.04267049f, 
    -0.02182751f, 0.00064404f, 0.02524936f, 0.00281808f, 0.00366003f, -0.04699623f, -0.00932211f, 0.01328703f, 
    0.00006111f, 0.01278162f, -0.05045410f, -0.02378445f, -0.03865242f, -0.05019636f, 0.04069798f, -0.00022692f, 
    0.00240919f, -0.00135498f, -0.00649961f, -0.00151115f, -0.05739820f, 0.03417932f, 0.01645677f, -0.01067444f, 
    0.02740344f, 0.03674525f, -0.05378796f, 0.00662496f, 0.03082864f, -0.00280535f, -0.00973526f, -0.02846283f, 
    -0.02188253f, -0.04923170f, -0.03704757f, 0.01635528f, 0.01726032f, 0.00063840f, -0.01479800f, -0.05509981f, 
    -0.04491092f, -0.05983771f, -0.00852014f, -0.01118464f, -0.03241739f, 0.02472329f, -0.02798371f, -0.04317237f, 
    0.00351909f, -0.04351952f, 0.04124467f, 0.03100986f, -0.01421721f, -0.02671745f, -0.04332328f, -0.05160375f, 
    0.01587093f, -0.00276163f, -0.05456475f, 0.03966357f, -0.03107615f, -0.04562307f, 0.03379858f, -0.03265403f, 
    -0.01384695f, 0.02477911f, 0.00183719f, -0.04665257f, -0.02226177f, 0.02975021f, 0.02620098f, 0.00235315f, 
    -0.05739022f, -0.04829067f, -0.03314617f, 0.03129198f, 0.01206298f, 0.01450826f, 0.02856726f, -0.03093364f, 
    0.03073782f, 0.01120655f, 0.05208216f, 0.04842308f, 0.02734826f, -0.01730294f, 0.00159759f, 0.02273003f, 
    0.01740047f, 0.03095324f, 0.03046465f, 0.01864394f, -0.00525496f, 0.01964273f, -0.04099372f, 0.02406422f, 
    0.03859079f, 0.01150258f, -0.00565191f, -0.01158565f, -0.04816194f, -0.00032225f, -0.00965530f, 0.03127718f, 
    -0.02479774f, -0.05559594f, -0.01451038f, -0.02057452f, -0.02816470f, -0.05454587f, -0.05559741f, -0.04168274f, 
    -0.00916534f, 0.03262493f, 0.02684386f, -0.01928284f, -0.01361900f, -0.03522772f, 0.00306282f, 0.00409623f, 
    -0.01131286f, 0.01868752f, 0.03948253f, -0.05307642f, -0.03774695f, -0.04947741f, 0.01234892f, -0.04831490f, 
    0.01872523f, 0.02782207f, -0.01543946f, -0.02479140f, -0.03659682f, -0.02681692f, -0.01006451f, -0.05000390f, 
    -0.04704430f, 0.00092592f, -0.03262569f, 0.02632969f, 0.00045309f, 0.02113789f, -0.04195603f, -0.01309085f, 
    0.02588232f, -0.01548183f, -0.05458860f, 0.03858121f, -0.01304576f, 0.03909212f, -0.05184254f, 0.00464973f, 
    0.02449283f, -0.03628989f, 0.03622214f, 0.02521990f, 0.00667118f, -0.04704617f, -0.05232905f, -0.01494726f, 
    0.01499353f, -0.01749520f, -0.00557822f, -0.02128202f, -0.03855947f, -0.00197835f, 0.00884899f, 0.01851219f, 
    -0.04065847f, 0.02428188f, -0.02198583f, -0.04378184f, -0.00727146f, -0.00254968f, 0.00652734f, 0.00646850f, 
    -0.00077596f, -0.02808700f, -0.04276285f, -0.04294476f, -0.03563071f, -0.01465925f, 0.02041445f, -0.00070326f, 
    0.01506929f, 0.03605466f, -0.05575616f, -0.05057575f, 0.01474850f, 0.02514445f, -0.01750369f, 0.00365922f, 
    -0.05194888f, -0.04370416f, 0.02157323f, 0.03863668f, 0.01243875f, -0.01792282f, 0.03599552f, -0.01824847f, 
    -0.04462947f, -0.06007301f, -0.05205557f, -0.02853524f, 0.03221728f, -0.00870916f, -0.03101820f, -0.05716788f, 
    -0.01509465f, -0.04919241f, 0.01515560f, -0.02622941f, -0.00887243f, 0.01911762f, 0.02921472f, -0.00859609f, 
    -0.03894660f, -0.03822206f, 0.03488290f, -0.01940633f, -0.00055235f, -0.00421779f, -0.00273641f, -0.03661014f, 
    -0.00524442f, 0.02035167f, 0.02513167f, -0.01918447f, 0.03265649f, 0.02437642f, -0.04249743f, 0.02317865f, 
    0.02947953f, -0.02274396f, 0.01010828f, 0.02609747f, -0.01790843f, -0.04567587f, -0.05642112f, 0.01114414f, 
    -0.00848327f, -0.00470419f, 0.02719510f, -0.01420699f, 0.04044193f, -0.02991225f, -0.04348886f, 0.02099739f, 
    -0.02045727f, -0.05827617f, 0.00325166f, 0.03601481f, -0.01706581f, 0.00159778f, -0.01367630f, 0.02285547f, 
    -0.03307110f, -0.04098663f, -0.00184997f, -0.04647990f, -0.00962425f, 0.02829445f, 0.02172963f, -0.03338395f, 
    -0.02883546f, -0.03756160f, 0.01438662f, 0.00143665f, -0.01289007f, -0.00783059f, -0.05210581f, 0.01445004f, 
    -0.03758719f, -0.01801318f, -0.05564606f, -0.02957633f, 0.03640885f, 0.02061439f, -0.00320803f, -0.04804613f, 
    0.01357653f, -0.01366622f, -0.05295603f, 0.01165295f, -0.03769157f, -0.00611915f, -0.03679513f, -0.01256589f, 
    -0.01836325f, -0.03134580f, 0.03187326f, 0.04111723f, 0.01856455f, 0.00492077f, -0.06041761f, -0.04078180f, 
    0.03314908f, 0.03589775f, -0.02060322f, -0.05906476f, 0.01799709f, -0.05370210f, 0.02136288f, 0.02302372f, 
    -0.05248635f, -0.03861798f, -0.03116228f, -0.05018152f, -0.02916468f, -0.02620178f, 0.02630704f, 0.00793805f, 
    -0.04966102f, -0.04093794f, -0.00303437f, 0.02949003f, 0.02302741f, 0.00830195f, -0.04917727f, -0.04180858f, 
    0.03928562f, 0.04488172f, 0.03000902f, 0.00243054f, 0.02498956f, -0.02472764f, -0.04285204f, 0.03686324f, 
    -0.00708286f, -0.04207212f, 0.03795971f, -0.02936444f, -0.00404044f, -0.02538398f, -0.02556261f, 0.03369376f, 
    0.01466298f, 0.00768643f, 0.00787666f, 0.03403682f, -0.04076734f, -0.00720431f, 0.02793627f, -0.00463196f, 
    -0.04301154f, 0.01117543f, -0.03653495f, 0.00789509f, 0.02885524f, 0.01845758f, 0.03548675f, 0.02411283f, 
    -0.04572007f, -0.00622487f, -0.05015666f, 0.01064865f, 0.00266399f, 0.03756727f, -0.00688107f, 0.03472148f, 
    -0.05436076f, -0.04180574f, 0.01018707f, -0.04741980f, 0.03650760f, -0.00304604f, 0.02988020f, -0.01021340f, 
    -0.05949462f, -0.00707228f, -0.03624061f, 0.00319123f, 0.04425097f, 0.00171719f, 0.03925555f, 0.04060872f, 
    0.02087208f, -0.04855606f, -0.05645685f, -0.03271992f, 0.01503153f, -0.01508486f, -0.00883924f, -0.03757457f, 
    -0.00947664f, 0.00385568f, -0.03379068f, 0.03249315f, -0.05379024f, 0.03039676f, -0.04251159f, -0.05631671f, 
    -0.01228709f, 0.01415139f, -0.03311232f, 0.02098293f, 0.01714313f, -0.04094247f, 0.02950696f, -0.01259372f, 
    0.02390280f, 0.04002513f, -0.03339258f, 0.00383525f, 0.01139236f, -0.04859482f, -0.05097203f, -0.05578920f, 
    -0.05462138f, -0.03269254f, -0.05739011f, -0.03718703f, -0.01465292f, -0.04949541f, -0.02873400f, -0.02527154f, 
    0.03889984f, 0.03142181f, -0.00160752f, -0.03215502f, 0.00232366f, -0.02691874f, 0.01007829f, 0.02430753f, 
    0.03881852f, 0.01473657f, 0.01636891f, -0.03862515f, 0.04125554f, -0.03742892f, 0.02770852f, 0.00544299f, 
    -0.01141687f, 0.01482643f, 0.00826228f, 0.00227886f, 0.00720792f, 0.01129429f, -0.01845750f, 0.03282738f, 
    0.00524864f, 0.00592656f, -0.01288877f, -0.05209706f, 0.03474838f, -0.05093741f, 0.03705790f, 0.02353140f, 
    -0.02903225f, -0.04013902f, -0.05386198f, -0.05794756f, -0.01651785f, -0.00385176f, 0.01224652f, -0.03711457f, 
    -0.05447660f, -0.02661227f, 0.01596290f, -0.02120670f, 0.04334874f, -0.01884739f, -0.01196688f, 0.01859193f, 
    -0.01743396f, 0.02398537f, -0.02015608f, -0.01762364f, -0.01285685f, -0.01159517f, -0.01697211f, 0.03329950f, 
    0.02852985f, -0.00040341f, 0.03155555f, 0.03293541f, 0.01602176f, -0.03606008f, 0.01509445f, 0.01882047f, 
    0.16253075f, -0.01164711f, -0.14709361f, 0.04316666f, 0.10181919f, 0.12503932f, 0.04842701f, -0.05092440f, 
    0.07819227f, -0.12766908f, -0.07007983f, 0.03720225f, 0.11426533f, -0.13193175f, -0.18575178f, -0.22245337f, 
    0.08100409f, 0.09340791f, -0.04931125f, 0.06225188f, 0.09260944f, -0.05681915f, 0.05761681f, -0.00333408f, 
    0.24800877f, 0.09549839f, -0.11732943f, 0.00404114f, -0.02506585f, 0.09704430f, -0.01783507f, 0.11080732f, 
    0.16991432f, 0.02498098f, 0.00298407f, -0.10189964f, -0.19929157f, 0.05385582f, -0.20473708f, 0.07640325f, 
    0.02035621f, -0.09840687f, -0.11275654f, 0.10951842f, 0.06279064f, -0.03476577f, 0.09013103f, -0.05843592f, 
    0.28949088f, -0.10523287f, -0.03111297f, -0.11550876f, 0.00103168f, -0.07600857f, -0.07675391f, -0.11406408f, 
    0.01131216f, -0.02662824f, 0.09123797f, -0.06795967f, 0.04609211f, -0.25691354f, -0.02721867f, 0.11550330f, 
    -0.02960624f, -0.04044095f, 0.07330738f, -0.17959210f, 0.06101914f, -0.05717812f, -0.20055300f, 0.08731176f, 
    -0.11893598f, 0.06165399f, -0.04125302f, 0.20093784f, 0.05267643f, -0.11996739f, 0.10039081f, -0.44904384f, 
    -0.05190178f, 0.01453995f, -0.08669250f, 0.10420968f, -0.03633564f, -0.08059182f, -0.24460770f, -0.05973244f, 
    -0.01301341f, 0.18037985f, -0.08188213f, 0.01534671f, 0.12814002f, 0.11258397f, -0.03034233f, -0.13947929f, 
    0.27148783f, 0.30137303f, 0.20169270f, 0.08072250f, 0.09018943f, 0.13509002f, 0.06137477f, 0.15835546f, 
    0.01934968f, 0.07341781f, 0.02755160f, 0.03952099f, 0.00741527f, 0.02669710f, -0.19138484f, -0.09841625f, 
    -0.13123095f, 0.07568944f, 0.05348236f, 0.02399254f, -0.04228993f, 0.07666022f, -0.02951805f, 0.01383235f, 
    -0.07825652f, -0.16550516f, 0.02657035f, 0.07503580f, -0.10377991f, -0.02584049f, -0.05921676f, -0.04230775f, 
    -0.10251416f, -0.07237280f, 0.02167285f, -0.04666771f, -0.07592309f, -0.04024794f, -0.02144205f, -0.06634448f, 
    0.02727375f, -0.00328724f, 0.09572407f, -0.02470956f, 0.18118320f, 0.19980001f, -0.02715636f, -0.09027143f, 
    0.06882946f, -0.11504716f, 0.05178504f, 0.00182707f, 0.29961488f, 0.16212748f, 0.03856661f, -0.18269734f, 
    0.16169716f, 0.04571763f, 0.21954677f, 0.30502063f, 0.05681116f, 0.22474520f, 0.09103496f, -0.06875948f, 
    0.02282511f, 0.03976239f, -0.01870571f, -0.04949312f, 0.06595819f, 0.06513982f, -0.09176920f, -0.08796640f, 
    -0.07181607f, 0.36503890f, -0.11863173f, 0.01644576f, -0.15370642f, -0.01489327f, 0.13542847f, 0.01304341f, 
    -0.07172391f, -0.02005508f, -0.05748329f, -0.07682621f, 0.13129131f, 0.02546870f, 0.12637162f, -0.17414044f, 
    0.01149194f, 0.10579648f, 0.05114587f, -0.04303142f, 0.13480262f, 0.05855891f, -0.03425442f, -0.01049908f, 
    0.23653860f, -0.18643518f, 0.13539521f, 0.03541309f, -0.00985041f, -0.13724670f, -0.11044730f, -0.13369280f, 
    0.09137844f, 0.15232243f, 0.14358619f, 0.07338726f, 0.19329919f, 0.14854042f, -0.23340158f, 0.01448080f, 
    -0.04734901f, -0.03948304f, -0.11773313f, 0.02564477f, 0.10603333f, -0.10932861f, 0.05870929f, 0.05872029f, 
    0.16843989f, -0.01705047f, -0.17761171f, -0.14708850f, 0.08890542f, 0.02996364f, 0.13221069f, 0.12348080f, 
    0.15488273f, 0.11118543f, 0.01045134f, -0.00860825f, 0.14582244f, -0.08613382f, -0.20776948f, -0.14121319f, 
    0.11768176f, -0.12811039f, 0.16030957f, -0.02223878f, 0.11209425f, 0.15641133f, 0.05526257f, 0.08217248f, 
    0.09308992f, 0.08566733f, 0.20490323f, 0.04982425f, 0.04500632f, 0.11806388f, 0.02867130f, 0.08782284f, 
    -0.03513006f, -0.03484973f, -0.03520722f, 0.07443290f, 0.21804105f, 0.12734339f, 0.03489391f, 0.12725148f, 
    0.06451925f, 0.23704427f, 0.02661651f, 0.32856044f, 0.13659835f, 0.09440846f, 0.05179343f, 0.14130625f, 
    -0.00598412f, 0.24045683f, -0.07955261f, 0.19183235f, 0.04687250f, -0.01688961f, 0.02927622f, -0.21246175f, 
    -0.07234936f, -0.01981441f, 0.10055669f, 0.11201026f, 0.28445876f, 0.19692671f, -0.40161234f, 0.09523063f, 
    0.05223691f, -0.04293475f, -0.10266307f, 0.05919582f, 0.06594034f, -0.01893087f, 0.05048930f, 0.06172700f, 
    -0.20100196f, 0.19870532f, -0.05935438f, 0.16830398f, -0.06702735f, -0.14693917f, 0.00376294f, -0.15283012f, 
    -0.03497238f, -0.08305320f, -0.02718988f, 0.13917041f, -0.08408852f, 0.38597310f, -0.15954889f, 0.04826368f, 
    0.04803918f, 0.01457029f, 0.00116983f, 0.02716013f, 0.00656368f, -0.15515028f, -0.01219643f, -0.03462712f, 
    0.25946787f, 0.11157412f, 0.08828450f, -0.11848979f, 0.22017476f, 0.09283217f, 0.13767874f, 0.19664833f, 
    -0.01197028f, 0.09261127f, 0.09998732f, 0.01953336f, -0.05925423f, 0.13611156f, -0.07717819f, -0.21823797f, 
    -0.05536645f, -0.14032480f, -0.04767641f, -0.02471987f, 0.05656303f, 0.01698467f, -0.04717046f, 0.13318424f, 
    0.07267485f, 0.37131858f, -0.10136437f, -0.13348758f, 0.00199015f, 0.08668149f, 0.07760173f, 0.16895713f, 
    -0.00515570f, 0.03906550f, 0.00354071f, -0.01849420f, -0.00753430f, 0.07909652f, 0.46479100f, 0.14067124f, 
    0.10459298f, -0.08773908f, -0.11962844f, -0.04860606f, 0.00113321f, -0.07745695f, -0.11484753f, -0.07764800f, 
    -0.08986360f, -0.09938142f, 0.11057670f, -0.10076666f, -0.04510023f, -0.13737129f, -0.01797640f, 0.12495539f, 
    -0.05598390f, -0.01578712f, 0.06394685f, 0.04063053f, -0.05957010f, -0.09847522f, 0.36926711f, 0.25788736f, 
    0.00801273f, -0.08965418f, -0.18369859f, -0.16435651f, -0.01517631f, 0.12465665f, 0.10207833f, 0.06849173f, 
    -0.08839035f, -0.02276726f, 0.00480245f, 0.18101436f, 0.00339494f, -0.20395064f, 0.01102925f, 0.11144555f, 
    -0.09630103f, 0.02491947f, 0.19760071f, 0.27291042f, -0.32895669f, -0.01658795f, 0.11816122f, -0.02267545f, 
    -0.14113522f, 0.11054648f, 0.13762431f, 0.07093285f, 0.05495956f, 0.00772441f, 0.05734495f, 0.19892938f, 
    0.06140872f, 0.06930183f, -0.05517730f, -0.04313297f, -0.06184241f, -0.08870299f, -0.01773562f, -0.04271420f, 
    -0.11380972f, -0.05237556f, -0.16046017f, -0.11201320f, 0.05646240f, -0.10011110f, 0.21983960f, 0.12018869f, 
    0.15919152f, 0.23362820f, 0.17872186f, 0.05441239f, -0.17622450f, 0.03058109f, 0.02212258f, -0.15595825f, 
    0.10184895f, -0.02687742f, 0.26954782f, 0.24080938f, -0.05976721f, -0.00524237f, -0.13108383f, 0.14754610f, 
    0.14480901f, 0.09071619f, -0.10611046f, 0.08480521f, -0.19522622f, -0.01064325f, -0.08023123f, 0.04963985f, 
    0.11279719f, 0.12318218f, 0.07354417f, -0.15267168f, 0.20855200f, -0.12005374f, 0.15525801f, 0.11778069f, 
    0.05146234f, 0.00838336f, -0.12572040f, -0.07879470f, 0.07122315f, -0.02719915f, -0.09945752f, 0.11617706f, 
    0.06699827f, 0.16918017f, 0.21277867f, -0.00459776f, -0.10880982f, 0.36666325f, -0.09743743f, 0.03630546f, 
    -0.00233728f, -0.00618149f, 0.06701590f, -0.08275640f, 0.09487857f, 0.07546560f, -0.10792313f, 0.11211646f, 
    0.18746597f, -0.16029699f, 0.03474772f, 0.11694922f, 0.01149867f, -0.09487502f, 0.04204484f, 0.02734883f, 
    0.00310731f, 0.02763175f, -0.13552441f, -0.23470533f, -0.08045950f, 0.63155377f, 0.21312885f, 0.21379428f, 
    -0.16306047f, -0.09895761f, -0.05741429f, -0.00645291f, -0.12947416f, 0.08452424f, -0.12366703f, -0.03248839f, 
    -0.19648087f, -0.30920663f, -0.34071407f, -0.17699093f, -0.06582929f, 0.01168801f, 0.14415082f, 0.13093330f, 
    0.24764797f, 0.36836207f, 0.17594397f, 0.20880951f, -0.25070971f, -0.21369694f, 0.20825939f, -0.06952007f, 
    0.15108913f, 0.03235428f, 0.02016523f, 0.01357256f, 0.14170675f, -0.24133764f, -0.25285861f, -0.21222441f, 
    -0.01567962f, -0.03166386f, -0.18035424f, -0.13714297f, 0.08081297f, 0.00856439f, -0.03261954f, 0.13589582f, 
    0.07846027f, 0.17358124f, -0.14127113f, -0.13288410f, 0.25931308f, 0.01631700f, 0.14508618f, -0.00918056f, 
    0.07631253f, 0.00933901f, -0.05887156f, -0.09350958f, 0.18692984f, -0.20054601f, 0.20767249f, 0.19295515f, 
    -0.05258976f, 0.44944930f, -0.05969463f, -0.03815576f, 0.12537420f, 0.09730700f, -0.08361416f, -0.08112863f, 
    -0.05855837f, -0.05310553f, -0.02739978f, 0.00100668f, 0.08074065f, -0.06915633f, 0.03625355f, 0.09434330f, 
    0.16388845f, -0.00163716f, -0.24446492f, -0.03166639f, -0.15165032f, -0.17539763f, -0.12857971f, -0.28791896f, 
    -0.21520849f, 0.08100361f, -0.24497142f, -0.10653502f, 0.10275056f, -0.03083172f, 0.06684675f, 0.13346425f, 
    -0.01512126f, 0.03053051f, -0.06962734f, -0.00127427f, -0.32028386f, 0.05667955f, -0.21395329f, 0.27618340f, 
    0.10033049f, -0.01950379f, -0.12080233f, -0.05622437f, 0.04728745f, -0.00909431f, 0.04853204f, 0.08873171f, 
    -0.15490954f, 0.14383033f, -0.09517792f, 0.09526347f, -0.00474656f, 0.03040485f, 0.09200129f, 0.00478099f, 
    0.08988243f, -0.04362826f, -0.10803125f, 0.10151119f, 0.21872379f, -0.30961719f, 0.11556857f, -0.01288986f, 
    0.22398818f, 0.15967633f, -0.03115668f, -0.02944939f, 0.04175428f, -0.17098029f, -0.00676490f, 0.22215842f, 
    0.09925124f, -0.02105892f, -0.07556201f, -0.05146521f, -0.21125300f, 0.09710944f, 0.00249675f, 0.01226997f, 
    -0.04791645f, 0.05473913f, 0.28011793f, 0.13754013f, 0.03836301f, -0.09934666f, -0.07894016f, -0.04802825f, 
    -0.03935567f, -0.04531069f, -0.07722717f, -0.28930628f, 0.01168037f, -0.15732320f, -0.13485862f, -0.12093127f, 
    0.08668505f, 0.20574570f, 0.13056478f, -0.13570255f, 0.06912179f, -0.08700168f, -0.17393905f, 0.00168442f, 
    -0.03416560f, 0.10225172f, 0.09216496f, -0.21192354f, -0.10755145f, 0.25072074f, 0.02278004f, -0.06373189f, 
    0.23471652f, -0.04484896f, -0.02819522f, 0.19183363f, 0.05721436f, 0.10673732f, 0.03222503f, -0.00856326f, 
    0.07261720f, 0.08838695f, -0.04319496f, -0.11666746f, -0.08923683f, 0.13021469f, -0.25503850f, -0.03504076f, 
    -0.04647271f, -0.06077690f, 0.00732309f, -0.01343600f, -0.08216853f, -0.42771146f, 0.33001146f, -0.04138605f, 
    -0.01760517f, 0.10091192f, -0.02149156f, 0.00601867f, 0.07891212f, 0.14102162f, 0.06682923f, -0.02918163f, 
    0.08435810f, -0.08613984f, -0.02081416f, 0.30187777f, 0.09555383f, -0.05727553f, 0.08127841f, -0.03868740f, 
    -0.02765997f, 0.01631248f, -0.02320338f, -0.05275333f, -0.04890170f, -0.16202721f, -0.13898349f, 0.06018670f, 
    0.21574321f, 0.14656770f, 0.11110641f, -0.12517677f, -0.08568383f, -0.22266869f, -0.05779594f, 0.25241888f, 
    -0.20914620f, -0.02664809f, 0.10967470f, 0.01117390f, -0.08723689f, 0.07992783f, 0.11676949f, 0.10787038f, 
    0.10339987f, 0.05752221f, 0.13399251f, 0.22395211f, 0.23376170f, -0.16124180f, 0.02679655f, 0.20816149f, 
    0.09577500f, -0.05810002f, 0.03503139f, 0.01225698f, 0.20680751f, 0.19554992f, 0.26282024f, 0.25462830f, 
    -0.03505838f, 0.03264335f, 0.03881091f, 0.07293957f, 0.04190142f, 0.10568428f, 0.18264078f, -0.08596534f, 
    0.10388834f, 0.45670030f, 0.09312993f, 0.14861490f, 0.19271991f, -0.20248708f, -0.16437666f, 0.11048990f, 
    0.19877376f, -0.14174227f, 0.00483625f, 0.03397174f, -0.05083392f, 0.16129105f, -0.04808403f, 0.05531628f, 
    -0.07454184f, 0.17275846f, 0.31625542f, 0.05933721f, -0.12109587f, 0.00198921f, 0.02335576f, 0.12786096f, 
    -0.01799604f, 0.04128534f, 0.04880938f, -0.09471636f, 0.12123438f, 0.21629494f, 0.37179568f, 0.03584903f, 
    -0.05980033f, 0.06947953f, 0.09480593f, 0.01123223f, -0.11808188f, -0.00694712f, -0.08221738f, -0.02850023f, 
    -0.00212643f, 0.01288438f, 0.19124217f, 0.04077091f, 0.05341008f, 0.09661029f, 0.06561181f, -0.04008617f, 
    -0.03206735f, 0.03056333f, 0.08922243f, 0.17141575f, 0.11022057f, -0.02778854f, -0.25654817f, -0.14688616f, 
    0.00549176f, 0.10661814f, 0.03684942f, -0.19210967f, 0.01323590f, 0.00166757f, -0.07647079f, 0.19766866f, 
    -0.36719906f, 0.09464481f, 0.16161552f, 0.07553943f, -0.07243001f, -0.04928597f, -0.03322233f, -0.00125115f, 
    -0.05575122f, 0.02695632f, 0.07673141f, 0.10438973f, -0.05327228f, 0.10422110f, -0.09545046f, -0.01979947f, 
    -0.02634848f, -0.08640370f, -0.19030215f, 0.01755890f, 0.03692174f, 0.07600802f, 0.12154724f, -0.02615661f, 
    -0.00897819f, -0.10660579f, 0.23784266f, -0.13212396f, -0.03441938f, -0.08270905f, 0.09012835f, 0.04880255f, 
    0.13407184f, 0.09506673f, 0.03085220f, -0.01183694f, 0.40192723f, 0.14473638f, 0.04903799f, -0.27624792f, 
    0.10231345f, -0.03607893f, 0.10768408f, 0.02484917f, 0.16498494f, -0.02839260f, 0.17437164f, 0.09318902f, 
    -0.32557115f, -0.01482693f, -0.19945370f, -0.13635878f, -0.07726955f, -0.04598133f, 0.04195513f, -0.07892988f, 
    -0.02396161f, -0.00986354f, -0.10308226f, 0.07835320f, 0.33925080f, 0.14924443f, 0.28023079f, -0.17991097f, 
    0.07637849f, -0.03305135f, 0.10895985f, 0.02125147f, 0.14561884f, 0.08353261f, 0.02793364f, 0.01738757f, 
    0.08982368f, 0.24439125f, -0.10436457f, -0.13031827f, -0.06029341f, 0.01063001f, -0.01562996f, -0.14814064f, 
    -0.00985880f, 0.11132712f, 0.12137901f, 0.12427835f, 0.00353362f, -0.01262473f, -0.18100993f, 0.11490465f, 
    0.09977098f, 0.11321416f, -0.06391301f, -0.02639002f, -0.06685811f, -0.05869190f, -0.02666034f, 0.04559936f, 
    -0.12380848f, 0.16918492f, -0.03419486f, -0.00019139f, -0.08205710f, -0.17038761f, -0.03358770f, -0.02774204f, 
    -0.10239694f, 0.04771236f, -0.04023246f, -0.08101646f, -0.42324138f, -0.20451623f, -0.20026237f, 0.25740585f, 
    0.15138456f, -0.01433931f, 0.11922776f, 0.11416424f, -0.03368513f, -0.00601960f, -0.06826358f, 0.00942846f, 
    0.03138896f, -0.22022822f, -0.07359592f, -0.16922379f, -0.00846418f, -0.04116966f, 0.08499081f, -0.11110142f, 
    0.02510773f, -0.02780433f, 0.06503016f, 0.02684088f, -0.13567999f, -0.02759565f, -0.03898121f, 0.11147497f, 
    0.05818656f, -0.03921606f, 0.07793988f, 0.18361035f, 0.06322688f, 0.00515994f, -0.07708868f, 0.11736240f, 
    -0.02860961f, 0.06283442f, -0.00470185f, 0.03111288f, -0.06816328f, -0.00185736f, -0.08892279f, -0.16346526f, 
    0.12387019f, -0.04226029f, 0.11168053f, 0.03967353f, 0.07452174f, -0.29015005f, 0.67171633f, 0.03123748f, 
    -0.01092341f, -0.08579298f, -0.03393950f, 0.20235091f, 0.14424582f, 0.11697002f, 0.04425182f, -0.03514873f, 
    0.06394540f, -0.14395356f, 0.28674221f, -0.21952081f, -0.02822235f, 0.01671937f, -0.03383080f, 0.01646384f, 
    -0.02811221f, 0.02171712f, 0.04652457f, 0.01514868f, -0.37927291f, 0.06606067f, -0.20531584f, 0.10084535f, 
    -0.02741585f, 0.09587748f, -0.10153156f, 0.08438730f, -0.01186777f, -0.05919984f, -0.10131145f, -0.01282268f, 
    0.02300548f, -0.01116583f, -0.00192272f, -0.07564081f, 0.19872379f, 0.03900127f, 0.08001616f, 0.02117762f, 
    0.12615970f, 0.07308866f, -0.04955983f, 0.00248701f, -0.28234121f, 0.07801380f, -0.01202380f, -0.03945755f, 
    -0.01097264f, -0.17590654f, 0.00040353f, 0.00410924f, -0.13710476f, -0.02222634f, -0.03336665f, -0.02744082f, 
    -0.00250997f, -0.02154608f, 0.04530664f, -0.10600136f, 0.02953116f, 0.07946054f, 0.18174595f, 0.15586782f, 
    -0.00429966f, 0.06717778f, 0.02299488f, 0.03029486f, -0.15366949f, -0.25913990f, 0.41780281f, 0.01916485f, 
    -0.19073147f, -0.08625095f, 0.04619695f, -0.04045204f, 0.12310819f, 0.08327015f, 0.00102123f, 0.02085918f, 
    0.39498287f, -0.09194045f, 0.00779133f, -0.34780046f, 0.04023642f, 0.00561392f, 0.10972153f, 0.00402974f, 
    0.17117169f, 0.18788272f, 0.00456818f, 0.10362032f, 0.05411622f, -0.40852880f, -0.33481151f, 0.07134403f, 
    0.00903202f, 0.00157579f, -0.14535762f, 0.12925065f, 0.21363306f, 0.11875326f, 0.04274649f, 0.08211033f, 
    -0.28369570f, 0.06204109f, -0.04792574f, -0.22007670f, -0.15509573f, -0.00496945f, -0.05518319f, -0.18440878f, 
    0.01851023f, -0.13801768f, 0.01566401f, -0.01577070f, 0.22426119f, -0.04766095f, 0.05739238f, -0.09809522f, 
    0.04908666f, -0.07912920f, -0.04228096f, -0.12140849f, 0.01350890f, 0.04054013f, 0.08047748f, -0.06626818f, 
    0.00362685f, -0.18939178f, 0.07628926f, 0.11041386f, 0.06835885f, 0.05466036f, 0.01435456f, -0.07622152f, 
    0.05924638f, 0.02399846f, 0.08863818f, 0.06514978f, -0.05707474f, 0.07283873f, -0.24507232f, 0.12666458f, 
    -0.20531830f, -0.04044705f, -0.03653970f, 0.13469981f, 0.01725508f, -0.07011160f, 0.04222362f, 0.09907216f, 
    -0.03610395f, 0.16374257f, -0.08631242f, -0.21683004f, -0.06174476f, 0.12554726f, 0.06849406f, -0.09880551f, 
    0.14454922f, -0.07114631f, -0.09855362f, 0.03315056f, -0.08057182f, 0.12608446f, -0.17239714f, -0.02762078f, 
    -0.16943446f, 0.01614125f, -0.06182436f, -0.04352405f, 0.09332423f, -0.10653479f, 0.09264926f, -0.00844028f, 
    -0.03491928f, -0.11667896f, 0.00932798f, 0.08702750f, 0.06440829f, -0.13686430f, 0.04868076f, 0.04417269f, 
    -0.08036366f, 0.06661025f, 0.04214857f, 0.11444425f, -0.15008496f, -0.03257260f, 0.13596436f, 0.00128495f, 
    0.03879449f, -0.07970414f, -0.01337339f, 0.02408241f, 0.08479678f, 0.02043924f, 0.08018477f, 0.16717657f, 
    0.02170992f, 0.11612248f, 0.01997168f, 0.02496589f, -0.05804335f, -0.05235071f, 0.06734969f, 0.10472648f, 
    -0.15075181f, -0.14094576f, -0.10346726f, -0.05148368f, 0.26072329f, 0.00168755f, 0.11747830f, -0.02854663f, 
    0.07681351f, 0.08226398f, 0.05967812f, -0.01122797f, -0.13271457f, 0.01832329f, -0.05932316f, -0.11240207f, 
    0.31406114f, -0.04689318f, -0.00677525f, -0.08291088f, 0.05031638f, -0.02279959f, -0.03196972f, 0.08441225f, 
    0.00608015f, -0.03082905f, -0.07447523f, 0.00264541f, -0.00801315f, -0.15567817f, -0.05660490f, -0.00227519f, 
    -0.03093040f, -0.01545812f, 0.05377601f, -0.21260893f, 0.10312771f, -0.06351231f, 0.20039484f, -0.06944675f, 
    0.11374051f, -0.07413378f, -0.20361346f, -0.06565818f, 0.02608430f, -0.15736327f, -0.07364790f, -0.06423614f, 
    -0.05773582f, -0.09899937f, 0.12284300f, -0.01736582f, -0.08564126f, 0.37669724f, -0.11240447f, -0.04244807f, 
    -0.07565036f, -0.06774508f, -0.04367911f, -0.09999633f, -0.02721978f, 0.10233235f, -0.09099640f, 0.10493633f, 
    -0.08775922f, -0.05601084f, 0.04259435f, 0.38079464f, -0.10258168f, 0.02283368f, 0.04132327f, 0.06529582f, 
    -0.03484839f, 0.15368655f, -0.03421129f, -0.12003246f, -0.09205595f, 0.16886137f, 0.22149369f, 0.09760345f, 
    -0.03353387f, -0.03333744f, 0.00499000f, 0.02698421f, -0.06452309f, -0.00504617f, -0.14028758f, 0.03851832f, 
    0.15768965f, -0.15398692f, -0.09921994f, 0.06289742f, 0.03106293f, -0.04439740f, 0.11554904f, 0.01969989f, 
    0.17622289f, 0.17050631f, 0.11916669f, 0.16811623f, 0.03398499f, -0.21695568f, 0.15254402f, -0.15302418f, 
    0.09470793f, -0.03391255f, -0.03093034f, 0.09508450f, 0.05865554f, -0.25473770f, 0.02537282f, -0.07054698f, 
    0.28679889f, 0.07979961f, -0.05298217f, -0.16604145f, 0.05018750f, -0.02005849f, -0.05823026f, 0.04726594f, 
    -0.05161059f, -0.01719938f, -0.01060688f, -0.23475499f, -0.00896393f, -0.12277739f, 0.03678056f, 0.11764296f, 
    0.11960938f, -0.03848253f, -0.11918461f, -0.15713924f, 0.05067233f, -0.06093709f, 0.14489143f, 0.09006856f, 
    -0.06732636f, 0.44898242f, 0.10819944f, 0.20634033f, 0.04934027f, 0.05210404f, 0.16696964f, -0.00888155f, 
    -0.08434637f, -0.04223833f, 0.04571615f, 0.00794667f, -0.11145893f, -0.06395276f, -0.15912509f, -0.03630195f, 
    0.10248593f, -0.00827893f, -0.14507656f, 0.01627759f, -0.22403657f, -0.08420258f, -0.07619344f, -0.27130824f, 
    0.00744140f, 0.00197039f, -0.18227719f, -0.19592726f, 0.08834440f, 0.02036572f, -0.05346043f, 0.07195920f, 
    0.00971224f, -0.03872106f, 0.01679797f, -0.05217103f, -0.26068681f, 0.19953464f, -0.03725241f, 0.21896724f, 
    0.06095216f, 0.14923504f, -0.21198696f, 0.06050657f, -0.12813470f, -0.14395978f, -0.09134430f, 0.03061854f, 
    -0.17555436f, 0.10285103f, 0.17613830f, 0.12483989f, 0.06162082f, 0.10463962f, 0.04041782f, 0.14257534f, 
    0.07649196f, 0.03081633f, -0.01749673f, 0.19582887f, 0.22102705f, 0.05282426f, 0.17577092f, -0.13442782f, 
    0.13830189f, -0.01261982f, -0.14673628f, -0.19139545f, 0.11533776f, -0.08937096f, 0.10412154f, 0.15144861f, 
    0.01873985f, -0.02565521f, -0.04151401f, 0.14173564f, -0.03286226f, 0.02809191f, 0.02456411f, -0.02900490f, 
    0.03904190f, 0.05418990f, 0.02044817f, 0.07207087f, 0.00226357f, 0.03666105f, 0.12224903f, 0.26871505f, 
    -0.04933885f, -0.00590845f, -0.02634249f, -0.01200857f, 0.08946745f, -0.01298651f, 0.04994447f, -0.01098880f, 
    0.04811922f, 0.03162282f, 0.16608110f, 0.05363062f, 0.05123220f, -0.14561260f, -0.17086406f, 0.04452007f, 
    -0.01301590f, 0.07809667f, -0.08418605f, -0.20100267f, -0.10727559f, 0.32193634f, -0.16915627f, -0.01163772f, 
    0.25082177f, 0.05477627f, -0.15229757f, 0.08282661f, 0.00565399f, -0.02076220f, -0.09885014f, -0.04169895f, 
    0.09436559f, 0.17271495f, 0.06248758f, -0.12060946f, -0.05789468f, -0.02752647f, -0.07376453f, -0.13332759f, 
    0.02540938f, 0.01780948f, 0.05045184f, 0.03884873f, -0.26801920f, -0.05567069f, 0.18622847f, 0.11649144f, 
    -0.14150921f, 0.15474641f, 0.13118072f, -0.25511235f, 0.00688118f, 0.10794197f, 0.00863852f, 0.00629256f, 
    -0.07609584f, -0.00495533f, 0.10099127f, 0.35538435f, 0.06715711f, 0.04694322f, 0.06978192f, 0.13953209f, 
    0.03777329f, 0.03409912f, 0.04224160f, -0.12904264f, 0.16227879f, 0.03641884f, -0.03123402f, -0.14912993f, 
    0.09821950f, -0.05314133f, -0.08120313f, -0.15214683f, -0.01121019f, -0.15927017f, 0.05131661f, 0.17070264f, 
    -0.21156153f, -0.15045641f, 0.17849238f, 0.04938106f, 0.03130038f, 0.09370454f, -0.02668553f, 0.07162037f, 
    0.18665843f, 0.06210966f, 0.02461226f, 0.15348189f, -0.07396615f, -0.04808171f, 0.01514104f, 0.23605348f, 
    0.03615300f, 0.02105881f, -0.09625299f, -0.16013922f, 0.10744377f, 0.17442061f, 0.06729726f, 0.09172781f, 
    -0.08102497f, 0.04154473f, 0.25988534f, 0.06914619f, 0.09065737f, 0.16727306f, 0.13330674f, -0.04945474f, 
    0.17182371f, 0.13378769f, 0.10290097f, 0.09306597f, 0.06209828f, -0.13117753f, -0.19005510f, -0.12929554f, 
    -0.02644257f, -0.10896723f, -0.06181923f, -0.01449869f, -0.14874153f, 0.23721661f, -0.03768365f, -0.21320286f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02572684f, 0.14114238f, 0.03969240f, -0.11357100f, 0.01066624f, 0.09346002f, -0.00252410f, 0.04177713f, 
    0.04693820f, -0.06195655f, 0.09124317f, 0.20023619f, -0.00140188f, -0.07908895f, 0.19332938f, -0.00177912f, 
    0.19789384f, 0.10214300f, -0.04829587f, 0.12558101f, 0.14927161f, -0.00212822f, 0.00699475f, 0.00363220f, 
    0.09580088f, 0.26268005f, -0.03456170f, 0.03092712f, 0.02200229f, -0.05173428f, 0.24808080f, -0.10212715f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.15150338f, 0.09950592f, 0.10946015f, -0.02283231f, 0.09846668f, 0.14449447f, -0.06448531f, -0.06789560f, 
    0.02510184f, 0.05803555f, -0.03878426f, 0.03508529f, 0.38496408f, -0.27523714f, 0.18241811f, -0.13204628f, 
    0.09421340f, 0.26432517f, 0.06397703f, -0.27741939f, -0.28313911f, -0.09504654f, 0.14111027f, 0.35956445f, 
    -0.14071277f, 0.17708023f, 0.01081743f, 0.05842089f, 0.42634419f, -0.11593056f, 0.25894314f, -0.05024836f, 
    -0.10096493f, -0.22952305f, -0.12426729f, -0.17879435f, 0.10364580f, 0.05276877f, -0.09354294f, -0.03016131f, 
    0.14120634f, -0.00824802f, 0.29540589f, -0.13327627f, 0.45041195f, -0.39361662f, 0.20554903f, 0.13998412f, 
    -0.32311630f, 0.19271432f, 0.01493642f, -0.03675262f, -0.03041638f, 0.15120624f, 0.08588712f, -0.22033237f, 
    0.24671434f, -0.10635684f, -0.07680368f, -0.14972487f, 0.12696187f, 0.39016479f, 0.19368435f, 0.16269267f, 
    0.04700929f, 0.05044258f, 0.14126937f, 0.09211413f, -0.15026763f, 0.06041108f, 0.01886805f, -0.13182470f, 
    -0.02125166f, -0.13336784f, -0.11896915f, -0.19562565f, 0.16234003f, -0.14173907f, -0.09381980f, -0.02773631f, 
    0.08275246f, -0.11884792f, 0.11974689f, -0.10587504f, -0.09305897f, 0.14242747f, -0.07806543f, -0.05358239f, 
    0.09314486f, 0.01147688f, -0.00757303f, -0.10951753f, -0.05299021f, -0.12412306f, -0.13418241f, -0.07350153f, 
    0.11005016f, -0.02630629f, 0.11880410f, 0.34979475f, 0.25775078f, -0.16115440f, -0.11783538f, 0.10457037f, 
    0.13716812f, 0.07155042f, -0.14734931f, 0.10934886f, 0.03597061f, 0.11732195f, -0.33402309f, -0.13788143f, 
    0.02646612f, 0.00275230f, 0.09039413f, -0.13069135f, -0.27282149f, 0.10492698f, -0.14959401f, 0.21423040f, 
    0.03040100f, 0.19885771f, 0.02804151f, 0.11014906f, 0.24732125f, 0.02254054f, -0.50429827f, -0.18571444f, 
    0.02632814f, 0.14692912f, 0.15544201f, -0.19866678f, 0.05348416f, 0.14249480f, 0.04310085f, -0.17321931f, 
    -0.24104770f, -0.16556425f, 0.16489722f, 0.05040001f, 0.02336467f, 0.25488251f, 0.24500588f, 0.07585996f, 
    0.22476338f, -0.23788562f, 0.13504821f, -0.26206139f, -0.09832830f, -0.08065812f, -0.13084257f, 0.12434946f, 
    -0.14405182f, 0.40648085f, -0.07297795f, -0.03363514f, -0.40299341f, 0.22022009f, 0.25553292f, 0.11544038f, 
    -0.01831391f, -0.38272136f, -0.12263922f, 0.54153740f, 0.00637328f, -0.13299178f, 0.14131877f, -0.00695855f, 
    -0.27537227f, 0.32099521f, -0.21973868f, -0.01113187f, 0.09633225f, -0.03386714f, -0.02868529f, 0.06397215f, 
    0.19584952f, 0.16387814f, -0.11315931f, 0.19835566f, -0.01161899f, 0.09144610f, 0.06407493f, -0.09771531f, 
    -0.23182955f, -0.07513133f, -0.10517520f, 0.06484920f, 0.23172212f, 0.05848416f, -0.22875893f, 0.41288450f, 
    -0.14718445f, 0.16864400f, 0.03737365f, -0.03126132f, 0.07572611f, -0.31172246f, 0.04183542f, -0.14196454f, 
    0.19585742f, -0.05222888f, 0.22418021f, 0.06888190f, 0.30319166f, -0.23601899f, 0.05714949f, -0.10110740f, 
    -0.03759924f, 0.33903766f, 0.10014658f, -0.00640132f, -0.23270845f, 0.08255470f, 0.14130192f, -0.40234396f, 
    -0.04384399f, 0.05188061f, 0.03604312f, 0.09875508f, -0.01776986f, -0.14952782f, 0.35324654f, -0.07734016f, 
    0.16160977f, -0.05669958f, 0.16073677f, -0.57526183f, -0.04419758f, 0.06118626f, 0.10861200f, 0.17808867f, 
    -0.03048504f, 0.00629511f, 0.03922585f, 0.18003441f, 0.16398521f, -0.27937546f, 0.14360872f, 0.10719366f, 
    -0.04921551f, 0.05736212f, 0.16209804f, 0.21781999f, 0.51951528f, -0.07728794f, -0.03324170f, -0.05129839f, 
    -0.09193679f, -0.03257240f, 0.07095756f, 0.03635494f, -0.22846733f, 0.26214945f, 0.38154784f, -0.22549330f, 
    0.01620742f, 0.11453423f, -0.11829159f, 0.01790398f, -0.27225795f, -0.14854458f, 0.04006511f, 0.03283455f, 
    -0.15356018f, -0.07308932f, -0.04943401f, 0.40568998f, -0.35083029f, -0.17763364f, 0.09200218f, -0.16110159f, 
    0.31139931f, 0.03400275f, 0.00649164f, 0.34623539f, -0.06016672f, -0.07793462f, -0.13072348f, -0.45882967f, 
    0.23880464f, 0.13470051f, -0.15189886f, -0.13427112f, -0.24422254f, 0.07811355f, -0.01912378f, -0.06040848f, 
    -0.17760417f, -0.10233078f, 0.07322887f, 0.16408649f, -0.36499450f, -0.16640681f, -0.03786520f, 0.15500481f, 
    0.10196006f, 0.30281946f, 0.23330007f, 0.06970390f, -0.01391023f, -0.52401608f, 0.12833115f, -0.04421528f, 
    0.12758178f, -0.28967190f, 0.11082327f, 0.30469641f, -0.26278293f, 0.12224697f, 0.09974708f, -0.05877062f, 
    -0.13498525f, -0.01770937f, -0.16774218f, -0.06115348f, 0.06475966f, 0.21933301f, -0.14124632f, 0.05005423f, 
    -0.10945752f, 0.08040990f, 0.07933331f, 0.21474704f, -0.54426324f, -0.19471931f, 0.05328700f, -0.08680454f, 
    -0.09069873f, -0.02146049f, -0.06191209f, 0.41319090f, -0.40142190f, -0.07791722f, -0.03764845f, 0.09760228f, 
    0.34799463f, 0.21245053f, 0.09239500f, 0.11453611f, 0.00756778f, -0.16897465f, -0.09529728f, -0.64332372f, 
    0.26017225f, 0.14169753f, 0.12341590f, -0.07858337f, -0.13656011f, 0.16365418f, 0.02886845f, -0.06549664f, 
    0.03071557f, -0.09557755f, 0.15951085f, 0.15029038f, -0.04073007f, -0.01893419f, 0.06778539f, -0.03361845f, 
    -0.21161829f, -0.00033540f, 0.12436945f, 0.11639221f, 0.04444275f, -0.17900428f, -0.36603695f, 0.04011389f, 
    -0.10506182f, 0.28738359f, -0.08497868f, 0.05098670f, 0.12517536f, 0.05794849f, -0.04520012f, 0.01815239f, 
    -0.12026588f, -0.02707349f, 0.14334331f, 0.05542365f, 0.07176115f, -0.27148277f, -0.17109442f, -0.07117391f, 
    -0.17268044f, -0.09961639f, -0.10924977f, 0.13767484f, 0.03721139f, 0.25265962f, 0.00593359f, -0.10224155f, 
    -0.27249047f, -0.16610186f, -0.09009157f, 0.02338680f, -0.14567454f, 0.05214529f, 0.12280016f, -0.07666077f, 
    0.29992202f, 0.14856723f, 0.00948968f, -0.16218193f, 0.38062236f, 0.02357686f, 0.14242072f, 0.24720423f, 
    0.37528396f, 0.12160813f, -0.11273770f, -0.03192904f, -0.07728934f, -0.20055248f, 0.15196939f, 0.41992706f, 
    -0.01060906f, 0.18365856f, -0.04365592f, -0.19353016f, -0.23198429f, 0.03976185f, -0.00734932f, -0.03696964f, 
    -0.16296571f, 0.26151502f, 0.32735422f, -0.06186249f, -0.46950743f, -0.18655498f, -0.07036047f, 0.10874455f, 
    0.05566804f, -0.07825696f, -0.13475190f, 0.48958632f, 0.05776266f, -0.03463976f, -0.03873654f, -0.10448258f, 
    -0.06969357f, 0.20470084f, 0.17537478f, 0.01874106f, 0.09549566f, 0.03558175f, -0.35170585f, 0.03674257f, 
    -0.03541975f, 0.26918396f, -0.07005131f, 0.13327037f, 0.29254457f, 0.03494512f, -0.16561900f, 0.16612796f, 
    0.24179778f, -0.11272191f, 0.11998635f, 0.64193499f, -0.10853799f, -0.25453952f, -0.13136873f, -0.16696890f, 
    0.24206847f, -0.21116608f, 0.06766979f, 0.21253523f, -0.22722764f, 0.14917347f, 0.16665515f, 0.28505087f, 
    0.10065970f, 0.19967900f, 0.00134813f, -0.09177458f, 0.20308918f, -0.05759940f, -0.18575273f, -0.11907080f, 
    0.04748036f, -0.41771001f, -0.15456425f, -0.09233702f, 0.12454970f, -0.01733056f, 0.06244736f, 0.15709238f, 
    0.20692813f, 0.10671492f, 0.14239247f, 0.08407816f, 0.24446653f, 0.07996207f, -0.14412908f, 0.14000198f, 
    -0.45939288f, -0.12744938f, 0.15029651f, -0.18430343f, -0.32928860f, -0.03904176f, -0.13919647f, -0.11758719f, 
    0.17230660f, -0.15754120f, 0.06793243f, 0.10260018f, 0.18055965f, -0.05057648f, -0.23963098f, 0.04506883f, 
    -0.06643373f, -0.22341448f, 0.02044604f, -0.05692081f, 0.32510456f, 0.41777784f, 0.03157138f, 0.07290602f, 
    0.08944563f, 0.06084293f, 0.16235287f, -0.15255590f, 0.10757762f, 0.70141846f, 0.03433234f, 0.03093567f, 
    -0.06369773f, -0.06776592f, -0.09979744f, 0.00932414f, -0.03384804f, 0.13652562f, -0.12992316f, 0.30916828f, 
    -0.34387136f, -0.32842621f, -0.13663264f, 0.05732775f, 0.11655860f, -0.35819104f, 0.09112418f, -0.17058247f, 
    -0.06653239f, -0.02434989f, 0.05763632f, 0.27147076f, -0.14603932f, -0.11931658f, -0.10957453f, -0.11926299f, 
    0.09227297f, 0.30146292f, -0.15950948f, -0.17159821f, -0.12635125f, -0.27653518f, 0.32631406f, 0.04879847f, 
    0.24643080f, -0.33605811f, -0.00811233f, -0.13206799f, 0.16569760f, -0.04770330f, -0.13147227f, -0.04321362f, 
    0.26285052f, 0.42134491f, 0.09140597f, -0.14903428f, -0.16797386f, 0.15139158f, 0.05300551f, 0.33853835f, 
    -0.16333517f, 0.11555789f, 0.04599633f, 0.23138539f, 0.23343360f, -0.00712973f, 0.01228481f, -0.01851143f, 
    0.23785892f, 0.26069701f, 0.22452872f, 0.30037239f, -0.16718742f, 0.11108685f, -0.27130404f, 0.10335616f, 
    0.19284545f, -0.14282967f, -0.04924737f, 0.14903316f, -0.18699840f, -0.11545540f, -0.06251331f, 0.34937385f, 
    0.02505373f, 0.25492448f, 0.11418875f, -0.01778988f, 0.39710388f, -0.17962360f, -0.28690642f, -0.18182938f, 
    0.12528357f, 0.26558411f, 0.13709158f, -0.21445307f, 0.39666614f, 0.38328433f, -0.12275893f, 0.06806934f, 
    0.04995191f, 0.04060713f, -0.18998115f, 0.42754319f, 0.49287349f, 0.25878558f, -0.21242958f, -0.13937162f, 
    -0.27427015f, -0.02114733f, -0.16592807f, 0.01521317f, 0.36984846f, -0.08036572f, -0.01182831f, 0.03747699f, 
    -0.21869197f, -0.12473064f, -0.04078028f, -0.14352587f, -0.09319041f, 0.28275844f, -0.00192824f, 0.11101058f, 
    -0.02476194f, 0.10721545f, 0.17775220f, -0.04361945f, -0.13322151f, 0.28084615f, -0.06355675f, 0.15892878f, 
    -0.17243741f, 0.02395894f, 0.01440683f, -0.34801722f, 0.45363057f, -0.18196104f, 0.29830059f, 0.00952618f, 
    -0.29469359f, 0.24185820f, 0.01459244f, -0.00989536f, 0.43838790f, 0.01975696f, 0.00385486f, -0.02402623f, 
    -0.19969834f, 0.12968948f, 0.15398218f, 0.13150352f, 0.12369283f, 0.41733178f, 0.13278989f, -0.00103367f, 
    -0.03901539f, 0.06440166f, -0.03305897f, -0.55472618f, 0.01207697f, -0.08481658f, -0.07788934f, -0.13983931f, 
    0.28173000f, -0.14610387f, 0.10031978f, 0.11667737f, -0.38913509f, 0.47597763f, 0.25970158f, -0.06499516f, 
    0.28993225f, -0.09274322f, -0.00006023f, 0.09416524f, 0.20030335f, 0.06698150f, 0.05960169f, 0.01162268f, 
    0.29214039f, 0.21382719f, 0.01620230f, -0.11863676f, -0.06457104f, -0.30036575f, 0.44593462f, -0.31692696f, 
    0.02861300f, -0.41525322f, -0.05055033f, 0.53307599f, -0.00031601f, 0.09687880f, 0.15491292f, 0.17204379f, 
    0.16057909f, 0.27467862f, 0.13667670f, -0.55677706f, 0.12390750f, -0.05620326f, -0.00698311f, 0.02299219f, 
    -0.00189271f, 0.16933395f, 0.00859757f, -0.21442643f, 0.01330774f, -0.08633564f, -0.00391513f, 0.20475118f, 
    0.13630298f, -0.16213687f, -0.08165953f, 0.00371357f, 0.28686255f, 0.01546094f, -0.17191194f, 0.16073228f, 
    -0.08432697f, -0.17005818f, -0.16326164f, 0.41544762f, -0.13698362f, -0.31807062f, 0.05154682f, -0.11996733f, 
    0.31404045f, 0.19351812f, -0.30739951f, -0.23427159f, 0.08729213f, 0.26129937f, 0.19812484f, -0.15069515f, 
    0.34936038f, -0.09944880f, 0.01178883f, -0.26305386f, -0.00054410f, 0.09102651f, 0.10442212f, -0.12793286f, 
    0.30937806f, 0.21397974f, 0.08696779f, -0.05427097f, 0.11739504f, 0.01244378f, 0.27306172f, 0.00205371f, 
    -0.01280112f, 0.00893780f, -0.12793259f, 0.44595426f, -0.05861650f, 0.20017034f, 0.08432948f, 0.12587908f, 
    -0.38350216f, 0.11468814f, -0.04468972f, -0.07631145f, 0.10592074f, -0.23147126f, 0.07352972f, -0.15696177f, 
    0.28969148f, -0.36063418f, 0.09898736f, 0.07805688f, 0.11892414f, 0.14427716f, -0.07147163f, -0.01593027f, 
    0.04795000f, 0.12654306f, -0.05767792f, 0.07862052f, -0.15652023f, 0.52360010f, -0.11376663f, 0.45357656f, 
    -0.14751673f, 0.00907264f, 0.16967557f, -0.27782482f, -0.08558869f, -0.08018472f, 0.03222318f, 0.16507126f, 
    0.02964673f, 0.09385785f, -0.06998892f, -0.24740435f, -0.33534005f, -0.01809603f, 0.00137298f, 0.05897895f, 
    0.06471121f, -0.32854837f, 0.17494795f, 0.05255749f, -0.02672998f, -0.15945692f, -0.01012173f, 0.03222328f, 
    0.15952499f, 0.05463323f, -0.09834819f, 0.01115543f, -0.22434966f, -0.09726837f, -0.33729026f, 0.08797279f, 
    0.10933094f, -0.25103888f, 0.18193853f, -0.34023729f, -0.21591794f, 0.09912256f, -0.10548586f, 0.05761234f, 
    0.01519227f, -0.09806999f, 0.31007674f, -0.07773869f, -0.33727482f, -0.02796239f, 0.11703295f, 0.09256107f, 
    -0.00268717f, -0.02683828f, -0.13883559f, 0.25627810f, 0.24614830f, 0.10999339f, -0.08847653f, -0.06603755f, 
    0.51851773f, -0.13856204f, -0.05308784f, 0.03241182f, -0.02001736f, -0.19026446f, 0.20613758f, 0.25160870f, 
    0.16759826f, -0.04181094f, -0.10164297f, -0.10079014f, 0.15331326f, 0.24005447f, -0.00157704f, -0.12563735f, 
    0.09437595f, 0.22334300f, 0.11756857f, -0.19040053f, 0.00405783f, 0.29560325f, 0.18833910f, 0.12982070f, 
    -0.06670333f, -0.13073394f, -0.08671740f, -0.18671067f, 0.08952873f, 0.12363055f, -0.02079460f, 0.21023504f, 
    -0.33537793f, 0.18465856f, -0.16990477f, 0.06244264f, -0.05175871f, -0.20145443f, 0.26448843f, -0.17299229f, 
    -0.15682565f, 0.13065401f, -0.05597648f, -0.55087340f, -0.24043123f, 0.07242048f, -0.18270625f, -0.11926460f, 
    0.02134749f, 0.07249419f, 0.27808991f, 0.16798754f, -0.34796801f, -0.28320083f, 0.19709098f, -0.07205473f, 
    0.04371078f, -0.01403471f, 0.10072129f, 0.37749946f, 0.22394653f, -0.10948166f, 0.17757934f, 0.01930030f, 
    -0.01753779f, 0.08625398f, -0.07309537f, -0.15333824f, 0.23529488f, -0.16864380f, 0.35409674f, -0.13845435f, 
    -0.11320958f, -0.34310356f, -0.08821223f, 0.01561658f, -0.06291642f, 0.18577558f, 0.17888983f, 0.05355287f, 
    0.10244631f, 0.24623844f, 0.28642413f, -0.18926275f, -0.07446158f, -0.12703221f, -0.13256240f, 0.15765743f, 
    0.00201717f, -0.14079864f, -0.02051027f, -0.20335671f, -0.26866508f, -0.17323883f, 0.12073766f, 0.26342118f, 
    0.45363557f, 0.03721436f, 0.00037754f, -0.13029155f, 0.22832336f, 0.00539191f, -0.33535290f, 0.09311843f, 
    0.15349886f, 0.15461974f, -0.10654847f, 0.00216531f, 0.13327147f, -0.24180518f, -0.03961508f, 0.03011838f, 
    -0.06721305f, 0.00919039f, 0.26687780f, 0.16465788f, -0.34306562f, -0.09115867f, 0.22877318f, -0.17429377f, 
    -0.03852835f, -0.26524776f, -0.14996958f, 0.10619283f, -0.09153004f, 0.13934736f, -0.06740220f, -0.02885091f, 
    0.19789045f, 0.33901727f, -0.09850652f, -0.08074019f, -0.19898629f, -0.09312484f, 0.27022633f, -0.10707972f, 
    0.10389703f, -0.13047624f, 0.14708705f, 0.32620835f, -0.27231097f, 0.20700383f, 0.10716681f, -0.00853449f, 
    -0.14359055f, 0.03747717f, 0.00982829f, 0.04948438f, 0.20117721f, -0.20917636f, -0.26585665f, 0.13578655f, 
    0.15975972f, -0.30147451f, 0.12467650f, 0.13920768f, 0.24381867f, -0.04914656f, 0.13426949f, -0.27024782f, 
    0.46747810f, -0.08933577f, 0.09992161f, -0.05793603f, -0.24634577f, 0.43038973f, -0.06491212f, 0.35761291f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.28314620f, -0.01115438f, -0.20107058f, -0.09277560f, 0.21787360f, 0.21923622f, 0.03083964f, 0.14516628f, 
    0.13883664f, -0.01529363f, 0.26106694f, 0.09151520f, 0.00577387f, -0.05933907f, 0.06960761f, -0.19151001f, 
    0.15766281f, 0.16115777f, 0.15427567f, 0.17376666f, 0.02783271f, 0.02612644f, 0.04716307f, 0.08366658f, 
    -0.15082227f, 0.05691268f, -0.07844964f, 0.04403789f, 0.17694227f, 0.03045144f, 0.23882473f, -0.00034387f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.09039605f, 0.15212451f, 0.01552643f, 0.20168790f, -0.60201931f, -0.36078534f, 0.16100752f, 0.01109261f, 
    -0.17764887f, -0.18162078f, 0.04087970f, -0.02835995f, -0.45961577f, -0.35490739f, 0.06146992f, 0.56634420f, 
    0.15123618f, -0.74907595f, 0.18665098f, 0.27429941f, 0.17759728f, -0.35055453f, 0.17619808f, -0.08562244f, 
    -0.36384705f, -0.19669749f, -0.00237645f, -0.04003943f, -0.31015125f, 0.23260744f, -0.31033313f, -0.41087556f, 
    0.13592510f, -0.15141605f, -0.05282702f, -0.25291598f, -0.00028035f, -0.05316916f, 0.05083270f, -0.04403862f, 
    0.06403808f, -0.46934277f, 0.21766885f, -0.10238827f, 0.26271328f, -0.21495111f, 0.07111844f, -0.58825421f, 
    0.37368271f, -0.33853674f, 0.10413176f, 0.18038942f, -0.29898888f, 0.38551822f, -0.09680261f, -0.19693257f, 
    -0.80572146f, -0.06266451f, 0.29607922f, 0.09097740f, 0.17033869f, -0.04651779f, 0.08532940f, -0.14683600f, 
    0.23257571f, -0.03324267f, -0.15019611f, -0.16112371f, 0.37629664f, -0.36254022f, 0.00154617f, 0.14748712f, 
    -0.22170624f, -0.23806866f, -0.26964712f, 0.22023985f, 0.35044393f, -0.62728035f, 0.25103030f, -0.01997069f, 
    -0.83243471f, 0.08382557f, -0.03404810f, 0.20532188f, 0.25548837f, 0.05866316f, -0.24441497f, -0.12154417f, 
    0.13659970f, -0.13272424f, -0.28372130f, 0.14864868f, -0.00980417f, -0.25968242f, 0.17495297f, -0.26569030f, 
    0.12646368f, -0.11386651f, -0.16889332f, 0.24551849f, -0.19406490f, 0.05759440f, -0.39648378f, -0.57683700f, 
    -0.33860034f, 0.06156761f, -0.53629041f, -0.22672671f, 0.02592687f, 0.00421381f, 0.20153801f, -0.17556627f, 
    -0.18229541f, 0.11655662f, 0.23598586f, 0.08884258f, -0.22960475f, -0.28014189f, 0.13335864f, 0.14747670f, 
    0.14013705f, -0.41326103f, -0.30409887f, -0.18052058f, -0.32311857f, 0.26671597f, -0.11723679f, 0.22146004f, 
    0.20213552f, -0.09967076f, -0.07836147f, -0.23811424f, 0.04298824f, 0.25735566f, -0.09282914f, -0.14542517f, 
    0.14354147f, -0.31767493f, -0.03677720f, -0.05989247f, 0.21190977f, 0.06168086f, -0.24445520f, -0.24455020f, 
    0.18321657f, -0.14190982f, 0.03974911f, 0.22983703f, 0.33115718f, -0.49985570f, 0.21419284f, -0.34264696f, 
    0.12043919f, -0.20769398f, -0.33611932f, 0.23724534f, -0.27370742f, -0.02112561f, -0.18968463f, -0.14870892f, 
    0.16765861f, 0.21268119f, -0.01572266f, -0.45089716f, -0.24939647f, -0.22310038f, 0.06188999f, 0.02525083f, 
    -0.27036446f, 0.51265359f, -0.25058132f, -0.04122655f, -0.20325774f, 0.23404770f, 0.03860070f, 0.00135502f, 
    -0.01957162f, -0.13244976f, 0.10556374f, -0.05083859f, 0.09289727f, -0.22533561f, 0.13668498f, -0.50984037f, 
    -0.20794234f, -0.20190856f, 0.23121193f, 0.05766019f, 0.30469614f, 0.16743751f, 0.10652810f, -0.57381850f, 
    -0.13243887f, 0.11372498f, -0.10802567f, 0.19050591f, 0.35491806f, -0.53934300f, 0.17456038f, 0.22525537f, 
    0.01982206f, 0.17889041f, 0.07509081f, -0.22466692f, -0.05548798f, -0.25278142f, -0.56105125f, -0.06754071f, 
    -0.41367817f, 0.16194598f, -0.58257002f, -0.00249724f, 0.26584905f, 0.25846249f, -0.41051513f, 0.19525917f, 
    0.12895240f, -0.42636034f, -0.00045275f, -0.40255612f, -0.07973805f, -0.53483111f, 0.33190632f, 0.31597921f, 
    -0.02940347f, -0.17995062f, 0.02740192f, 0.19319363f, -0.23968108f, 0.55504948f, 0.14842953f, -0.18784413f, 
    -0.09652714f, 0.34146291f, 0.05038383f, 0.00161437f, -0.00709484f, -0.25085086f, -0.12695077f, -0.46731210f, 
    -0.32628670f, 0.18284099f, 0.02654456f, -0.50023174f, -0.24080655f, -0.32776704f, 0.27965480f, 0.28953108f, 
    0.14068444f, -0.07429058f, -0.27206695f, -0.44486645f, -0.27016798f, -0.09460329f, -0.19250050f, 0.02397493f, 
    0.04768534f, -0.67180198f, 0.00479791f, 0.13763723f, -0.03379082f, 0.10246804f, -0.19052458f, 0.06344680f, 
    0.12790489f, 0.42850915f, 0.03142136f, -0.24055810f, -0.54957509f, 0.11612745f, 0.16400108f, -0.35394633f, 
    -0.27870634f, 0.13035156f, 0.20919119f, -0.11105880f, -0.52759749f, 0.17174420f, -0.32965031f, 0.30599356f, 
    -0.39532277f, 0.02082056f, -0.56888139f, 0.04648669f, 0.01073966f, -0.15546288f, 0.31801945f, -0.34470749f, 
    0.19612631f, 0.28248939f, -0.10479055f, -0.71272087f, -0.32516700f, 0.06627700f, -0.08292515f, 0.18334039f, 
    -0.31904930f, -0.04404477f, -0.16186513f, -0.79416221f, 0.12664759f, -0.58975148f, -0.35864276f, -0.12268297f, 
    -0.43989494f, 0.14244832f, -0.36512882f, 0.23019937f, 0.28156328f, -0.16653578f, 0.22112086f, 0.26621890f, 
    -0.00491591f, -0.23335266f, 0.05045447f, -0.05985372f, -0.01374953f, -0.25911263f, -0.66253859f, 0.14800444f, 
    0.07002083f, -0.32669824f, 0.06713894f, -0.21101137f, 0.03713037f, -0.62093812f, -0.61837405f, -0.33662713f, 
    -0.21261057f, -0.01311300f, -0.48291349f, -0.28672919f, 0.26788008f, 0.12732287f, -0.17248213f, -0.36819711f, 
    -0.11131064f, 0.23382314f, 0.08858822f, -0.66102135f, -0.34069386f, 0.17420805f, 0.28165030f, 0.55966210f, 
    -0.25726211f, 0.24742652f, 0.28143305f, 0.20028213f, -0.03563715f, 0.28008062f, 0.29442310f, -0.21584716f, 
    -0.58302581f, -0.22560623f, -0.12437615f, -0.34983239f, -0.20856713f, -0.16514626f, -0.49793169f, 0.25943980f, 
    0.14457053f, 0.12555392f, 0.10110694f, -0.61910480f, 0.16291009f, 0.29037163f, 0.08198408f, 0.20291267f, 
    -0.13659777f, -0.01666201f, -0.09313873f, 0.30966568f, 0.01975300f, -0.03080151f, -0.28360319f, -0.66396832f, 
    0.08579104f, -0.28460637f, 0.19666983f, -0.18790728f, 0.20970072f, -0.06773174f, 0.04241657f, 0.31914750f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.11242235f, 0.07460234f, 0.10626202f, 0.07813918f, 0.09184732f, -0.00321638f, -0.10915616f, 0.08582615f, 
    -0.10137030f, -0.12109402f, -0.16247392f, -0.06074788f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
