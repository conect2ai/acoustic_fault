#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.18622568f, 0.16142270f, 0.57888144f, 0.81136996f, -0.44278866f, -0.99185419f, -0.00429726f, -0.41163564f, 
    -0.35168883f, -1.35650122f, -0.27610311f, -0.59703690f, -0.18515156f, 0.66449881f, 0.63335764f, 0.58870524f, 
    0.02184606f, 0.32149822f, -0.67161691f, -0.90237588f, -0.31568626f, -0.91012561f, -0.31495696f, 0.23989531f, 
    -0.12968528f, 0.26974487f, 0.33660406f, 0.47980535f, -1.18709064f, -0.22504154f, -0.54620308f, -0.44412303f, 
    -0.33803198f, 0.01843918f, 0.05578185f, 0.38403013f, 0.83016843f, 0.30813682f, 0.59935588f, 0.77271515f, 
    0.02498916f, 0.34033418f, 0.10162764f, 0.46796030f, 0.04453024f, -0.44317546f, -0.33154136f, -0.33824182f, 
    0.27426025f, 0.90274990f, -0.25241849f, -0.08996121f, -0.15119836f, -0.03596613f, -0.11864202f, 0.42653120f, 
    0.87919074f, 0.88197529f, 0.58272904f, -0.36687085f, 0.40652514f, 0.34360164f, 0.15307689f, 0.62420028f, 
    0.62165076f, 0.55886334f, -0.77161545f, 0.40202644f, -0.91375035f, 0.14112423f, 0.19942191f, 0.19102168f, 
    -0.50113714f, -0.56803429f, -0.95746022f, 0.44732898f, -0.35728177f, 0.09361155f, -0.51067257f, 0.25281674f, 
    -0.14994046f, -0.49980998f, -0.55336601f, -0.26394197f, -0.11093676f, 0.80040431f, 0.56579250f, -0.31905505f, 
    -0.07882030f, -0.50640798f, -0.67964852f, -0.35159433f, 0.04459585f, -0.53146189f, -0.26388595f, -0.58705914f, 
    -0.42454344f, 0.07407780f, -0.83271617f, 0.02758127f, -0.98563945f, -0.52071315f, -0.06524408f, 0.01134800f, 
    0.10538103f, 0.39151320f, -0.13698280f, -0.70507294f, 0.57970697f, 0.53714073f, 1.02867794f, -0.25652844f, 
    0.09687705f, 0.27247581f, 0.23983751f, -0.11557042f, -0.01266029f, 0.86929840f, 0.87366217f, 0.07598958f, 
    -0.48988080f, -0.45577082f, -0.26049945f, 0.01021605f, -0.41092730f, -0.11126471f, -0.82344329f, 0.38526088f, 
    0.90714651f, -0.60685927f, -0.03602772f, -0.13836744f, -0.04732426f, 0.53632861f, -0.23487078f, -0.43506157f, 
    0.42485437f, -0.46765926f, -0.43573380f, -0.62388802f, -1.01343989f, -0.03582408f, 0.18907847f, 0.51327348f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.11132860f, 0.25636223f, -0.12810855f, 0.30619410f, 0.26615992f, -0.05794334f, -0.09584096f, 0.22446524f, 
    0.06684857f, -0.27090555f, 0.20588702f, -0.30359915f, 0.43266776f, -0.21638027f, -0.02016926f, -0.07777887f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03031227f, -0.00042324f, -0.20008601f, 0.04484055f, -0.16955869f, 0.12269542f, 0.20321314f, -0.00397169f, 
    0.02962810f, -0.35312507f, -0.12737870f, -0.12380277f, -0.05735671f, -0.07374211f, 0.00849101f, 0.02049743f, 
    0.01150759f, 0.04236250f, -0.29286590f, 0.25909182f, -0.44741589f, 0.14113285f, -0.03010403f, 0.01189423f, 
    0.10119469f, 0.05714735f, 0.09117687f, -0.19081448f, 0.21832588f, -0.26100984f, -0.00208548f, -0.07310775f, 
    0.03029883f, -0.14276887f, -0.03130957f, 0.03453584f, 0.08956852f, -0.00654280f, 0.21209829f, -0.06484737f, 
    0.10084856f, 0.09409510f, -0.00748532f, -0.05511336f, -0.09167252f, -0.44006526f, -0.84942043f, -0.12875888f, 
    0.03272256f, 0.25842568f, 0.21201849f, -0.04286622f, -0.10650614f, -0.01386861f, -0.13750993f, -0.22677915f, 
    0.04127912f, 0.16011886f, 0.15186460f, 0.15341835f, -0.01477817f, -0.07004578f, -0.04871790f, 0.41126543f, 
    0.27971381f, 0.05824500f, 0.00975252f, -0.02302543f, -0.15330063f, -0.04805622f, -0.06486794f, 0.11840173f, 
    -0.50096369f, 0.14577727f, -0.01689594f, -0.10024700f, 0.03612865f, 0.00246495f, 0.03494600f, -0.10171989f, 
    -0.01934259f, 0.16613150f, -0.09365910f, -0.44281772f, -0.03627867f, 0.13089685f, -0.08738713f, 0.05978090f, 
    -0.08528762f, -0.10006805f, 0.13912465f, -0.05961157f, -0.05327889f, 0.05506879f, 0.09443103f, 0.00771931f, 
    -0.04175343f, 0.00816755f, -0.22260273f, 0.29871577f, 0.28097206f, -0.75912374f, -0.01354131f, 0.10571330f, 
    -0.01476434f, 0.18524325f, 0.22572720f, -0.22182506f, 0.28097671f, 0.21931800f, 0.28372005f, 0.11165307f, 
    0.06083479f, 0.21712612f, 0.06932006f, -0.11216555f, 0.08311924f, 0.19676560f, 0.24732356f, -0.04376715f, 
    -0.04993556f, -0.02990142f, -0.20167640f, -0.01967000f, -0.17112954f, -0.11042234f, -0.07584859f, -0.19934832f, 
    -0.19278088f, -0.00789494f, -0.01157003f, -0.00034728f, 0.23057854f, 0.12757689f, 0.02578687f, 0.09504147f, 
    -0.10997325f, 0.15876240f, -0.21011159f, -0.01184080f, -0.01411634f, -0.06460755f, -0.06334019f, 0.18111148f, 
    -0.35389271f, -0.11003898f, -0.21307366f, 0.16916834f, 0.06110574f, -0.02941691f, -0.15545540f, 0.02432501f, 
    -0.24254891f, 0.17887947f, 0.08508672f, 0.29798058f, -0.05827227f, 0.06104741f, 0.06513987f, -0.04812573f, 
    -0.06519174f, 0.09171806f, -0.01301982f, 0.16172488f, -0.11465593f, 0.16765398f, -0.15352480f, 0.00439387f, 
    0.00459585f, 0.16150372f, -0.02545505f, 0.12652570f, 0.21786153f, -0.06423354f, 0.04379728f, -0.06078593f, 
    0.14637290f, 0.01851405f, 0.02411369f, -0.06096899f, -0.48835859f, -0.28334904f, -0.22398056f, 0.15104048f, 
    0.10379036f, -0.10262538f, 0.22783634f, -0.00734851f, 0.21186672f, 0.43592080f, -0.09790094f, -0.20559376f, 
    0.00896537f, -0.02114292f, 0.15004356f, 0.26110017f, 0.14825912f, -0.05955528f, -0.34550241f, 0.11712070f, 
    -0.36150399f, 0.07621520f, -0.06269549f, -0.22504009f, 0.09843421f, 0.10140356f, 0.12826523f, -0.23355648f, 
    -0.16536132f, 0.08441728f, 0.11883934f, 0.01438998f, 0.23207851f, -0.08545302f, 0.10798483f, 0.01073052f, 
    0.22439776f, 0.30463490f, -0.08455303f, -0.00891129f, 0.08677523f, 0.02447660f, -0.00100162f, 0.18953750f, 
    -0.06738789f, 0.30519223f, -0.14822362f, 0.13057105f, 0.08592385f, 0.18275608f, -0.23107754f, 0.13896926f, 
    0.10268409f, -0.08778892f, -0.08603407f, -0.01315472f, -0.00672780f, 0.16170007f, -0.03877348f, 0.16707616f, 
    -0.27660242f, 0.03018110f, -0.07965690f, 0.21664667f, -0.01091527f, 0.19130963f, -0.17924508f, -0.12000322f, 
    -0.02147601f, 0.08967265f, -0.09744869f, -0.05717431f, -0.37584549f, -0.26909477f, -0.14140010f, 0.08584581f, 
    0.07185965f, -0.00845249f, -0.20827055f, 0.04541602f, 0.12586759f, -0.11150580f, 0.34786561f, 0.30043876f, 
    0.12751353f, 0.06174619f, 0.08502827f, -0.16286485f, -0.03395908f, -0.07336462f, 0.15492779f, 0.04153668f, 
    -0.49528790f, -0.07333988f, -0.07056139f, -0.11944224f, -0.00841917f, 0.19310661f, 0.04836699f, 0.23263176f, 
    0.02851981f, -0.19935752f, 0.00293328f, 0.08165309f, 0.11143113f, -0.04053196f, 0.00690891f, 0.09101260f, 
    0.03354992f, -0.38220775f, 0.06533661f, -0.01013604f, 0.17499784f, 0.09051604f, 0.00940926f, 0.00980304f, 
    -0.00842636f, 0.30525434f, 0.09638233f, -0.29588974f, -0.12883733f, -0.09080943f, 0.12459415f, -0.01282054f, 
    -0.07693683f, -0.03192192f, 0.47551921f, -0.19523126f, -0.08995778f, -0.02859275f, -0.13775961f, 0.04181465f, 
    -0.21480298f, -0.17949679f, 0.01275190f, 0.26793155f, 0.02545715f, -0.24743751f, 0.01996168f, 0.19645114f, 
    -0.17645511f, -0.03981022f, 0.02017146f, -0.09492996f, -0.44007209f, -0.09167667f, 0.19228721f, 0.10833780f, 
    0.11074114f, 0.14026165f, -0.43980148f, 0.09197965f, -0.08332115f, 0.30981383f, -0.15862654f, 0.14325184f, 
    0.04177748f, -0.27006528f, 0.00251024f, 0.03243497f, 0.07540082f, -0.12828708f, 0.19703215f, -0.35926908f, 
    -0.02827936f, -0.08414718f, 0.16711381f, -0.00297374f, -0.07432804f, -0.06404228f, 0.11432222f, 0.45606038f, 
    0.42022726f, -0.06529578f, 0.11190867f, 0.16480111f, 0.02342272f, 0.08596364f, -0.08746891f, -0.12387162f, 
    -0.28346992f, -0.20524883f, 0.24767694f, -0.01789036f, -0.03773031f, 0.22722813f, 0.02569693f, -0.21960899f, 
    0.15681030f, 0.28617412f, 0.08128064f, -0.19914226f, -0.24250160f, -0.22096236f, 0.05484358f, 0.08045170f, 
    -0.01602222f, 0.06695852f, -0.27320147f, -0.18855073f, -0.34781760f, 0.10385440f, -0.00969610f, 0.03868552f, 
    -0.10121300f, 0.05288479f, -0.04339109f, 0.18277681f, 0.03600026f, 0.16816442f, -0.19866151f, 0.13854881f, 
    -0.17859723f, 0.05515861f, 0.00706023f, 0.11446409f, -0.17754921f, 0.18459912f, 0.05902501f, 0.06624832f, 
    0.20757709f, 0.01081986f, -0.00401383f, -0.13427804f, 0.06797633f, -0.12854557f, 0.03652757f, 0.13431436f, 
    0.07650408f, -0.02136659f, 0.03965905f, -0.14042048f, 0.11081390f, 0.13866958f, 0.26993799f, 0.05707363f, 
    -0.40054378f, -0.23895124f, 0.15225531f, 0.01086408f, -0.09295844f, 0.12302081f, -0.04464280f, -0.35718504f, 
    0.05612723f, -0.12428930f, 0.12627162f, 0.22001913f, -0.13718075f, 0.04793879f, 0.21795955f, 0.02086627f, 
    0.31308496f, -0.31224105f, 0.18573865f, -0.06729133f, 0.02871297f, 0.17554653f, -0.01019571f, 0.04080155f, 
    0.19554211f, 0.12057673f, 0.10018179f, 0.01566748f, -0.10296908f, -0.18412682f, -0.08138442f, 0.12281123f, 
    -0.05205542f, 0.22489843f, -0.30126554f, 0.13500732f, -0.11846391f, -0.12505136f, -0.18254147f, 0.00704986f, 
    0.13350479f, 0.16322523f, -0.05715529f, 0.09909100f, 0.19557586f, -0.21695311f, 0.01666000f, 0.05204316f, 
    -0.06270071f, 0.16212025f, -0.04738655f, -0.03163864f, -0.70212251f, -0.01850632f, -0.25146216f, 0.11948285f, 
    0.14343236f, 0.12219118f, -0.02620440f, 0.01783638f, -0.00756138f, -0.16509773f, 0.05435309f, -0.02634163f, 
    -0.17351781f, 0.04998636f, 0.02993938f, -0.16201453f, 0.04182635f, -0.21086395f, 0.18600754f, 0.04151843f, 
    0.00521324f, 0.14995730f, 0.03363338f, -0.07316199f, 0.03056092f, -0.03023144f, 0.06635153f, 0.00252718f, 
    -0.25749174f, 0.22517613f, -0.00626432f, 0.14173643f, 0.10502961f, 0.00804814f, -0.07784098f, 0.04615669f, 
    0.09764193f, 0.14640042f, -0.17909002f, -0.07827839f, 0.15543485f, -0.02068400f, -0.00484777f, -0.01922299f, 
    0.09503422f, 0.14499986f, 0.24825913f, 0.15048765f, -0.05109155f, -0.19365695f, 0.04850366f, 0.14277582f, 
    0.15651214f, 0.08432411f, -0.15765165f, 0.40786177f, 0.34970209f, 0.03595633f, -0.03826944f, 0.10882171f, 
    -0.14861056f, -0.17536475f, -0.05449606f, -0.00634944f, -0.19807769f, -0.26411003f, 0.16923122f, -0.05378429f, 
    -0.32812288f, -0.14223042f, 0.16356823f, -0.01584855f, -0.50427276f, -0.33200699f, 0.10388755f, -0.03382586f, 
    0.05193629f, 0.15723343f, 0.13794731f, 0.09407067f, -0.10482246f, 0.13023025f, -0.39201307f, -0.45268375f, 
    0.05169272f, -0.05021241f, -0.08813021f, 0.09287159f, 0.14422645f, -0.03816463f, 0.24525367f, 0.18279843f, 
    0.31978697f, -0.14504294f, -0.08770431f, -0.08049630f, 0.05122231f, -0.08536296f, 0.00323378f, 0.20343307f, 
    -0.07243780f, 0.20850499f, -0.04341130f, 0.04337923f, -0.27959910f, 0.03882972f, -0.03388316f, -0.14464839f, 
    0.11593870f, 0.09641549f, -0.00440057f, 0.00918764f, -0.02154347f, -0.47886717f, 0.10891461f, 0.23127037f, 
    0.23646466f, -0.70669729f, -0.04732285f, -0.24206048f, 0.17895912f, 0.19915648f, 0.21815410f, 0.02345649f, 
    0.04108682f, 0.07949075f, -0.17437883f, -0.26960018f, 0.10376250f, 0.38161653f, 0.22898355f, 0.04729272f, 
    -0.04413732f, 0.04161458f, 0.08490862f, 0.01388457f, -0.06873574f, -0.14226748f, -0.05331904f, -0.18729794f, 
    0.06614099f, -0.14806090f, -0.04843017f, 0.03637400f, -0.44171271f, 0.11700776f, 0.24134211f, 0.08643430f, 
    0.06978390f, -0.17705581f, 0.07474983f, -0.06575149f, -0.22996926f, -0.53862798f, -0.02504565f, 0.09497770f, 
    -0.05313656f, 0.04747686f, 0.13634123f, 0.02475321f, -0.12215859f, -0.22146516f, -0.38919574f, 0.01125095f, 
    0.21661720f, 0.23534916f, 0.05079088f, -0.03270970f, -0.14625499f, 0.00078645f, -0.06853011f, -0.18557468f, 
    0.13106714f, 0.36930373f, -0.04060258f, -0.07720251f, 0.11794267f, -0.09536293f, 0.18852390f, -0.06790055f, 
    -0.21986562f, 0.37417057f, -0.25571582f, 0.04513726f, 0.24633746f, -0.08909542f, 0.10894759f, 0.16566585f, 
    0.09793737f, -0.07048477f, 0.43808594f, -0.32782447f, 0.30404031f, 0.01274222f, 0.26161608f, -0.00794749f, 
    -0.15809633f, -0.03869465f, 0.14071573f, 0.18296620f, -0.00826338f, 0.15771469f, 0.21648513f, 0.10605884f, 
    0.00391436f, -0.07104903f, -0.16436119f, -0.39747754f, -0.10993169f, -0.22882588f, -0.00906190f, -0.22460102f, 
    0.16988353f, 0.14412820f, 0.21678123f, -0.10363010f, -0.05832663f, 0.09365093f, 0.41669947f, -0.01797584f, 
    0.22706242f, -0.18055935f, -0.03175125f, 0.10648600f, 0.02105336f, -0.02574814f, -0.02356873f, 0.04017244f, 
    -0.19697452f, 0.14174600f, -0.02655299f, -0.11278852f, 0.01604755f, 0.02907475f, -0.06428996f, -0.13489571f, 
    0.10930733f, 0.15472448f, -0.00562041f, -0.13380922f, -0.03564046f, -0.17105265f, -0.09507775f, -0.06216365f, 
    -0.01165935f, -0.04069189f, -0.14353135f, -0.10481234f, -0.01328973f, 0.04098776f, 0.07099991f, 0.17870408f, 
    -0.03880010f, 0.00429527f, 0.03229038f, -0.00430753f, 0.02525016f, -0.08058032f, -0.06749312f, -0.11811230f, 
    -0.06258787f, -0.11304298f, 0.00826352f, -0.08340658f, -0.10742692f, -0.05139747f, -0.10910066f, 0.04915067f, 
    -0.07516158f, 0.00088617f, 0.01335296f, -0.08394613f, -0.00220090f, -0.02251851f, -0.05045000f, 0.02844080f, 
    -0.04562049f, 0.03677004f, 0.04807851f, -0.05393641f, -0.10395349f, -0.07931247f, -0.07226104f, -0.06514694f, 
    0.03509554f, -0.06141578f, -0.04710642f, -0.03988317f, 0.00172124f, -0.05049433f, -0.06744853f, 0.00809221f, 
    0.01716154f, 0.05424404f, -0.02484302f, -0.05295699f, 0.05673091f, 0.00004058f, 0.00142718f, -0.09098645f, 
    0.01914288f, -0.01688316f, -0.01908213f, 0.03354196f, -0.01875821f, -0.07075733f, -0.04538094f, 0.00846518f, 
    -0.11084115f, -0.08787369f, -0.01538576f, -0.10262521f, -0.00548895f, -0.10276485f, 0.02266227f, -0.00655452f, 
    0.05047099f, -0.04228929f, -0.10214271f, 0.05270857f, -0.01507775f, 0.04076214f, 0.03692660f, 0.05082687f, 
    -0.09079140f, 0.01328760f, -0.09447353f, -0.05341680f, -0.06517773f, -0.08072034f, -0.01506051f, -0.01892146f, 
    -0.05600756f, -0.11146323f, -0.02731883f, -0.07325266f, 0.01464088f, -0.12061415f, 0.02502745f, 0.03375189f, 
    0.04886528f, 0.01108103f, 0.05451130f, -0.02292028f, -0.01250452f, 0.06629498f, -0.04037048f, -0.08929191f, 
    0.05378160f, -0.03490089f, -0.03361980f, -0.11302278f, 0.00338329f, -0.06420194f, 0.05166810f, 0.01137345f, 
    0.03785275f, 0.03750813f, -0.06247034f, -0.06589656f, -0.03258284f, 0.04364940f, -0.06159794f, -0.00252596f, 
    -0.04655257f, 0.03526897f, 0.01006738f, -0.07735651f, -0.05778731f, -0.05268931f, -0.07510267f, 0.00065142f, 
    -0.10119639f, -0.01800254f, -0.01629480f, -0.09356606f, -0.10368317f, -0.07140765f, -0.05134755f, -0.09629356f, 
    0.04296997f, -0.08334987f, -0.10038344f, -0.10683525f, -0.09990401f, -0.02154992f, -0.04941132f, -0.07994481f, 
    0.04000348f, -0.02030993f, -0.08619637f, -0.10475984f, -0.01416023f, 0.05614437f, -0.06692252f, -0.01973832f, 
    -0.02751701f, 0.02889165f, -0.10152204f, -0.00785823f, 0.05706489f, -0.03416725f, -0.02930901f, -0.00390330f, 
    0.03517979f, -0.00178734f, -0.09117807f, -0.03133509f, -0.02840315f, -0.07227386f, -0.07623385f, -0.03871650f, 
    -0.02518629f, -0.07798202f, -0.00905853f, -0.04647885f, 0.05076350f, -0.02569231f, -0.02240207f, 0.04976408f, 
    0.02990884f, -0.09105086f, -0.06885372f, 0.00619453f, 0.02434672f, 0.03744461f, -0.00558351f, -0.04102477f, 
    -0.05193339f, -0.02664414f, 0.06026474f, 0.04837202f, 0.06055038f, -0.09399089f, -0.07628967f, 0.01009620f, 
    0.02517795f, 0.03824076f, -0.07523672f, -0.05153069f, 0.05796039f, -0.07958442f, 0.01175522f, -0.09772821f, 
    -0.01798774f, -0.04516089f, -0.10004713f, 0.01331707f, 0.05531715f, 0.06045965f, 0.02628185f, -0.00099466f, 
    -0.05321020f, -0.07536633f, 0.04085208f, 0.01050099f, -0.02676855f, 0.02257281f, -0.06716137f, -0.04768566f, 
    -0.05199738f, 0.06824121f, -0.07731801f, 0.01431994f, -0.04646974f, -0.05746156f, 0.03098328f, -0.03866626f, 
    0.01054410f, -0.06875659f, 0.04172349f, -0.00169364f, 0.04378402f, -0.09283493f, -0.02280551f, -0.04764685f, 
    0.03348831f, -0.04465687f, -0.03186703f, 0.00827763f, -0.06973249f, 0.01666492f, 0.03385599f, -0.03243807f, 
    -0.00717121f, -0.07804882f, 0.02027732f, -0.08454418f, -0.03796983f, 0.02938408f, 0.04712808f, -0.09100503f, 
    0.01292616f, -0.08820107f, 0.03838124f, 0.02506556f, -0.03368174f, -0.03385005f, 0.04955690f, 0.05243880f, 
    0.05946575f, 0.03191955f, -0.07906753f, -0.04713929f, -0.03645252f, -0.00347942f, 0.06322815f, 0.01400324f, 
    -0.03899357f, 0.06872376f, -0.02403476f, -0.05334370f, -0.07317196f, 0.00145952f, 0.00083279f, 0.04094648f, 
    -0.01524178f, -0.07230981f, 0.00013538f, -0.05321672f, -0.05428757f, -0.03153997f, -0.01819681f, -0.05605967f, 
    -0.00507755f, -0.02732537f, -0.01667160f, -0.00023844f, 0.03497361f, -0.08567683f, 0.00786585f, -0.08186343f, 
    -0.02333296f, 0.04451203f, -0.02162747f, 0.02881349f, -0.05192931f, -0.04060230f, 0.03923314f, 0.01601731f, 
    0.32934481f, 0.00744729f, -0.15170804f, 0.18703806f, 0.08311576f, -0.05264809f, -0.15387672f, 0.13904710f, 
    -0.00824180f, 0.01294025f, -0.16794175f, -0.03069331f, 0.21494943f, -0.05666273f, 0.12761702f, -0.09918951f, 
    0.05758094f, 0.12327433f, 0.08285726f, -0.34743661f, 0.36710107f, -0.04909662f, -0.17241149f, -0.25247943f, 
    -0.10795411f, -0.08479991f, 0.01419119f, 0.47169203f, 0.17838678f, 0.03610118f, -0.21879785f, -0.15480906f, 
    -0.11063659f, -0.12733792f, 0.01315244f, -0.01604115f, -0.03917157f, -0.05785767f, -0.07514306f, -0.29190981f, 
    -0.00758307f, -0.07369816f, -0.19856097f, 0.09999968f, -0.02683169f, -0.25559324f, 0.19794625f, 0.08635892f, 
    0.04099896f, 0.17128468f, 0.00685732f, 0.18077055f, 0.01426792f, -0.01221495f, -0.07206932f, 0.18720081f, 
    -0.32568407f, 0.02336258f, 0.03964353f, 0.09449121f, 0.24592583f, 0.09990120f, -0.10670108f, -0.04878557f, 
    0.04888003f, 0.04198137f, -0.02789615f, 0.03493668f, 0.06751126f, -0.14516994f, -0.09568682f, -0.04063991f, 
    0.27132022f, -0.09332816f, 0.32709327f, -0.04882358f, 0.19110169f, 0.16801926f, -0.06300525f, -0.15659626f, 
    0.04572696f, 0.22631223f, 0.17316020f, 0.21938574f, 0.22050907f, 0.23441391f, 0.13301235f, 0.04907156f, 
    0.12325551f, 0.02567929f, 0.16250910f, 0.19628668f, 0.42688069f, 0.13619988f, -0.16379990f, -0.03263795f, 
    -0.14563310f, -0.07686111f, -0.07594500f, 0.01778625f, 0.04027962f, 0.27048755f, -0.03453420f, 0.14715156f, 
    -0.17388749f, -0.03684135f, -0.18685602f, 0.23760971f, -0.16230315f, -0.16898622f, 0.07646282f, -0.12206167f, 
    0.01547123f, 0.03668832f, -0.19238864f, -0.05092673f, -0.02824510f, -0.52069753f, 0.03384526f, -0.09414201f, 
    -0.10184112f, 0.16170418f, -0.11113449f, -0.25880739f, 0.09690724f, -0.13517275f, 0.46945962f, -0.07861037f, 
    -0.43788138f, 0.06376177f, -0.24702662f, 0.00585059f, 0.00248312f, 0.16156629f, -0.12551595f, -0.01133098f, 
    -0.10731801f, -0.18092135f, 0.06896291f, 0.03322921f, -0.18530102f, -0.08107012f, 0.06855465f, 0.12874104f, 
    0.19449140f, -0.17389207f, -0.11685022f, -0.06472587f, 0.10755339f, 0.00288071f, -0.18108614f, 0.04203932f, 
    -0.00372576f, 0.67923337f, 0.09541972f, -0.46435365f, 0.00563723f, 0.12702276f, 0.03750747f, 0.06105583f, 
    -0.03774394f, -0.09045762f, -0.10099737f, -0.34093922f, 0.15186420f, 0.04439981f, -0.15572712f, 0.08506469f, 
    -0.05361550f, 0.10543732f, 0.10856128f, -0.61989653f, -0.31462350f, 0.01006191f, 0.11950755f, 0.26148832f, 
    -0.02689222f, 0.14298274f, 0.10607436f, 0.04941140f, -0.29500932f, -0.06194059f, 0.23170976f, 0.16882478f, 
    0.27689138f, -0.04865253f, 0.01614238f, -0.03391843f, 0.21901178f, -0.35725456f, -0.27212977f, 0.07846417f, 
    -0.09122792f, 0.08194382f, 0.08987801f, -0.02604804f, -0.00159038f, -0.14936228f, -0.08386917f, -0.11217634f, 
    0.19257703f, 0.05390268f, 0.25661764f, -0.22913362f, -0.04334592f, -0.15257145f, 0.04137152f, 0.14346054f, 
    -0.11467633f, -0.03181705f, -0.13639572f, -0.00134561f, -0.02307734f, 0.10631210f, 0.10662243f, 0.16044334f, 
    0.29331142f, -0.28151846f, 0.06774095f, 0.17076083f, 0.13488479f, -0.20506491f, 0.06751195f, 0.10805906f, 
    0.00970591f, 0.11462929f, -0.03645162f, 0.10504237f, -0.24080086f, 0.02484038f, -0.01487952f, 0.00300838f, 
    0.06452691f, -0.06046985f, -0.04910081f, -0.23115966f, -0.11473915f, 0.06308097f, 0.20364121f, -0.04065507f, 
    0.03720141f, 0.12521853f, -0.14774489f, -0.51021320f, -0.43835950f, 0.16585521f, 0.05063131f, 0.01788458f, 
    -0.28432214f, 0.13176304f, -0.02891504f, -0.00242742f, -0.30637079f, 0.22889473f, 0.07459465f, 0.13718875f, 
    0.13126644f, 0.24076609f, -0.07168790f, -0.07523330f, -0.18808344f, -0.14859663f, -0.25566855f, 0.12883042f, 
    -0.03483995f, -0.09967964f, 0.03665290f, -0.21039572f, -0.19511206f, -0.00801570f, 0.01683504f, 0.05420705f, 
    -0.17710125f, -0.19829386f, 0.11541735f, 0.11459751f, 0.09177924f, -0.04301834f, -0.11242472f, -0.11100644f, 
    0.00921560f, -0.15100400f, -0.07185149f, -0.03588296f, 0.19036762f, -0.07149970f, -0.02281785f, 0.08457142f, 
    -0.37961090f, -0.16265981f, -0.08956289f, -0.22568649f, 0.10694008f, -0.05034191f, -0.03534336f, 0.18407790f, 
    0.02460395f, 0.47340116f, 0.26629892f, -0.04324593f, -0.01655865f, 0.10126831f, 0.03859956f, 0.02971594f, 
    0.00770536f, -0.13456453f, -0.26730394f, -0.10100013f, -0.01401858f, 0.08730247f, -0.13566113f, -0.13776232f, 
    -0.03549432f, -0.08971002f, -0.00325788f, 0.14191827f, -0.12019589f, 0.11374849f, -0.09169129f, 0.32609463f, 
    0.12775013f, -0.05685332f, 0.02218421f, -0.12536885f, 0.14706843f, -0.04208499f, 0.11654590f, -0.06586225f, 
    -0.13889737f, -0.03423547f, -0.00673336f, -0.07475741f, -0.07043044f, 0.28671435f, -0.02006728f, 0.05199353f, 
    0.12645890f, 0.13722064f, -0.09862534f, 0.00551944f, 0.02595538f, -0.20285709f, -0.12648807f, -0.12245187f, 
    0.37461606f, -0.06826890f, -0.01531445f, -0.10289695f, -0.09187850f, -0.05824707f, -0.04056243f, 0.10887778f, 
    -0.14347845f, -0.30879882f, -0.07882991f, -0.06597000f, -0.05951815f, -0.06957348f, 0.11606300f, -0.09335765f, 
    0.14387092f, -0.03054332f, -0.09556425f, 0.18236227f, -0.13157529f, -0.07424641f, 0.17645575f, -0.00390119f, 
    -0.15169719f, 0.00651917f, 0.35550430f, 0.05023107f, 0.32715067f, -0.01635647f, 0.09431971f, 0.22798891f, 
    0.31494984f, 0.16159819f, -0.12042019f, -0.00792896f, 0.02548016f, 0.12581322f, 0.18203515f, 0.10628954f, 
    0.17361622f, 0.06659070f, -0.22293900f, 0.08740376f, 0.22202128f, -0.30358595f, 0.01276132f, -0.17345701f, 
    0.15901810f, -0.11651854f, 0.00387030f, -0.10485122f, -0.00653377f, 0.26890263f, -0.02364298f, -0.12816450f, 
    -0.08477182f, -0.04060802f, -0.05497652f, 0.02979638f, 0.02888169f, 0.30227360f, 0.12002135f, 0.08933571f, 
    -0.09999391f, -0.12662044f, 0.07149669f, -0.04828591f, 0.00317306f, 0.11931755f, -0.49577609f, -0.00251422f, 
    -0.48178619f, -0.11175495f, 0.11337329f, -0.15651794f, -0.11252385f, -0.03081672f, 0.07355028f, -0.33048183f, 
    0.02214620f, -0.12267319f, 0.01569579f, 0.05259398f, -0.02830717f, -0.07455641f, -0.05017272f, 0.21954320f, 
    -0.26670158f, -0.08604433f, 0.25861192f, -0.01274387f, 0.18924072f, 0.03654367f, 0.13522710f, 0.08706108f, 
    0.21258140f, -0.23070952f, -0.08121590f, -0.01040952f, -0.18632297f, 0.04500522f, -0.11518265f, -0.00590759f, 
    -0.01453830f, 0.02362996f, -0.06512922f, 0.01333003f, -0.05169199f, 0.09644404f, 0.14566953f, -0.01079918f, 
    -0.14430048f, -0.04158106f, -0.10616947f, -0.23812464f, -0.08789039f, 0.15199636f, 0.06264322f, 0.17698127f, 
    0.23743322f, 0.04388326f, 0.07894547f, -0.03033716f, 0.13895355f, 0.16466154f, 0.04348807f, 0.21649992f, 
    -0.16449982f, -0.04081922f, -0.08759192f, 0.30299133f, 0.11342856f, 0.05433865f, -0.12319019f, -0.42778122f, 
    0.05199220f, -0.04534246f, 0.01029990f, -0.06062138f, -0.23063393f, -0.22459091f, 0.04079691f, -0.00048341f, 
    -0.11438240f, 0.02766448f, 0.13323693f, -0.14142379f, -0.14381325f, 0.14693852f, 0.13815960f, 0.30362311f, 
    -0.07295763f, 0.05356629f, 0.11471259f, -0.12982285f, 0.06804027f, 0.08035051f, 0.26223290f, 0.21712391f, 
    -0.11319114f, 0.18513969f, -0.05514910f, 0.29351199f, -0.15010893f, 0.09103535f, -0.19944400f, 0.09904344f, 
    -0.11146588f, 0.00415014f, 0.18216118f, -0.26440093f, 0.02406411f, -0.15829355f, -0.16196357f, -0.17270464f, 
    -0.31694922f, -0.22043754f, -0.30913445f, -0.03573170f, 0.10610410f, -0.14575368f, 0.18231894f, 0.39103204f, 
    -0.11260287f, -0.11366658f, -0.20446862f, 0.26852483f, -0.20363034f, -0.02422266f, -0.06070716f, -0.22215004f, 
    0.02858282f, 0.27246109f, 0.00667420f, -0.11523941f, 0.29471755f, 0.01955925f, 0.01796099f, 0.10119529f, 
    -0.15223902f, 0.13518089f, 0.07602704f, 0.17871356f, 0.05137524f, 0.08677713f, 0.12940013f, -0.08941892f, 
    0.08147935f, -0.00451861f, 0.17345643f, 0.04130303f, -0.06502540f, 0.02379433f, -0.06446855f, -0.36428863f, 
    -0.28564122f, 0.04268997f, 0.14789437f, 0.02226345f, 0.18008552f, -0.12708931f, 0.11116600f, -0.14963730f, 
    0.01094189f, -0.26041853f, 0.06495906f, 0.14111872f, 0.12773563f, 0.16737936f, -0.12727433f, -0.08404414f, 
    0.14527331f, 0.02976853f, -0.07999207f, -0.17688391f, -0.14858882f, -0.01707211f, -0.02531967f, -0.06533390f, 
    0.33485240f, 0.09025341f, 0.05867249f, -0.07771995f, 0.01175438f, 0.03898883f, 0.29878518f, -0.10242516f, 
    -0.07742806f, -0.16848505f, -0.17218108f, -0.20434320f, -0.00924600f, 0.04871829f, 0.04363380f, 0.19074735f, 
    0.16490898f, -0.06978518f, -0.23394102f, -0.39748356f, 0.03993193f, 0.15287620f, -0.09046284f, 0.02215911f, 
    0.00775950f, 0.16097775f, 0.00179290f, -0.14168558f, -0.11950658f, -0.23580100f, -0.14778399f, 0.12637627f, 
    0.28077751f, 0.09161025f, 0.18791384f, 0.13779770f, -0.20530973f, 0.10568977f, -0.31712824f, -0.02104539f, 
    0.22863795f, -0.02534197f, -0.01010032f, -0.06857464f, 0.04088368f, -0.02402117f, 0.06533506f, 0.00421365f, 
    -0.11897214f, 0.14146656f, 0.26936415f, 0.21741337f, 0.01246023f, -0.01642149f, 0.03650904f, -0.27357265f, 
    0.15878564f, 0.27914050f, 0.02250404f, -0.29547587f, -0.00318112f, 0.06213668f, 0.13740104f, -0.08236105f, 
    -0.11694303f, -0.19055133f, -0.25554329f, 0.19879289f, 0.02489833f, 0.36897668f, 0.09578072f, -0.36466965f, 
    0.21277842f, 0.13012767f, -0.31785950f, -0.39062282f, -0.00359914f, 0.25507951f, 0.34754294f, -0.29585016f, 
    -0.21501233f, 0.04954780f, 0.10650937f, -0.05605133f, 0.12928431f, 0.08754982f, 0.05074741f, -0.03167163f, 
    0.18807365f, -0.03344477f, 0.13662952f, -0.16521651f, -0.12519373f, 0.07484653f, 0.10164031f, -0.21330397f, 
    -0.01799656f, -0.03839753f, 0.21437202f, 0.02363470f, 0.23956305f, 0.00866335f, 0.34858847f, -0.08895217f, 
    -0.25075936f, -0.05275185f, 0.32512268f, 0.00743809f, 0.11789247f, -0.05108921f, 0.50609201f, 0.09169671f, 
    -0.07282975f, -0.27970853f, -0.34956303f, 0.39185312f, 0.08135700f, -0.08465084f, -0.16946185f, -0.02322282f, 
    0.24470818f, 0.08444016f, 0.01081229f, -0.07628141f, 0.00760801f, 0.08812417f, -0.02034269f, -0.06939986f, 
    -0.10054278f, 0.05492487f, -0.07018477f, 0.05941676f, -0.31555885f, 0.16425323f, 0.08135210f, 0.21952529f, 
    0.29320443f, 0.00162955f, -0.16847496f, 0.05099805f, -0.10485893f, 0.03652414f, -0.08261452f, 0.05986420f, 
    0.04364756f, 0.27293673f, 0.18560009f, -0.03594688f, -0.01699345f, 0.05144433f, -0.08884372f, -0.12906520f, 
    0.01645098f, 0.06880911f, -0.32586685f, 0.23800741f, 0.10295282f, 0.09028279f, -0.24501221f, -0.13193861f, 
    -0.01023928f, 0.15088648f, -0.07864229f, 0.23083687f, 0.24095808f, -0.04518209f, -0.04785901f, 0.00735098f, 
    -0.04261549f, 0.10541922f, 0.03025296f, 0.29238230f, -0.29968157f, -0.17472154f, -0.12021467f, 0.03813272f, 
    0.10876460f, -0.01117016f, 0.02536314f, 0.07036418f, 0.04969670f, -0.14272223f, -0.13047560f, -0.00872722f, 
    -0.27581427f, -0.08880761f, 0.15270360f, -0.10850959f, 0.24781865f, 0.06549026f, -0.21797346f, -0.25914586f, 
    -0.17245969f, -0.12573667f, 0.00977936f, 0.12354635f, -0.13148199f, 0.15818499f, -0.05931374f, -0.00722125f, 
    -0.05887870f, 0.22303531f, 0.03529407f, 0.03049807f, -0.20053028f, -0.01464508f, -0.03094614f, 0.03270454f, 
    -0.04937574f, -0.10623679f, -0.05681784f, -0.12212829f, -0.00766367f, 0.12741193f, -0.06017287f, -0.10867160f, 
    -0.05136380f, -0.37335211f, -0.10710593f, -0.06856079f, -0.17434005f, -0.10077342f, -0.08502603f, 0.07408748f, 
    0.03605288f, 0.12416782f, -0.29790270f, 0.17010248f, 0.03568468f, 0.05161005f, 0.00859188f, -0.09249680f, 
    0.08275481f, -0.02628920f, 0.17503798f, -0.18914193f, -0.16622588f, -0.11509296f, -0.00771179f, -0.06898842f, 
    0.11959788f, -0.06561858f, 0.04815674f, 0.08111361f, 0.05815481f, -0.06847447f, 0.28544936f, 0.13537329f, 
    0.06802970f, 0.06436493f, 0.13407201f, -0.12739825f, 0.06755345f, -0.25959411f, 0.16684967f, -0.13220996f, 
    0.28539675f, 0.24366325f, -0.33492786f, 0.18683833f, -0.18578361f, -0.12888576f, 0.09083366f, 0.08294737f, 
    -0.10203340f, 0.00903243f, -0.20834035f, -0.07085557f, -0.01703502f, -0.14547938f, 0.03346379f, 0.10912937f, 
    0.06131583f, 0.22243540f, 0.34020007f, -0.27000460f, -0.09092543f, 0.12295964f, -0.06307928f, 0.12988746f, 
    0.07157147f, -0.19991001f, -0.26918203f, -0.01447799f, 0.18488659f, -0.25930053f, 0.15229701f, 0.00380328f, 
    -0.14818104f, -0.25717944f, 0.05401988f, 0.22920112f, -0.01457837f, -0.03623459f, 0.11875785f, 0.00890608f, 
    0.03146333f, -0.12159729f, -0.28746441f, 0.10342751f, -0.13325119f, -0.01268137f, 0.09400477f, -0.03092659f, 
    0.14938393f, -0.14389446f, -0.03016365f, -0.00860367f, -0.19058685f, -0.08823591f, 0.03745581f, -0.24528532f, 
    -0.09100833f, -0.03961759f, 0.18055972f, 0.05720304f, 0.00181759f, -0.51970321f, -0.16399719f, 0.10013624f, 
    0.17358464f, 0.19016451f, 0.00212434f, 0.05153401f, 0.07835786f, -0.13810414f, -0.14039086f, 0.15561986f, 
    0.10205600f, 0.02264128f, 0.19023307f, -0.20245543f, 0.12193940f, -0.07103360f, 0.52894640f, -0.13727483f, 
    -0.27637580f, 0.14280866f, 0.04887847f, 0.13732263f, 0.00394387f, -0.08824573f, -0.01898258f, 0.34869006f, 
    0.06807151f, -0.23430182f, -0.00708624f, 0.03349211f, -0.04771855f, 0.07328962f, 0.13028492f, 0.18614262f, 
    0.28144455f, -0.00306125f, 0.30972081f, -0.02939850f, -0.08116432f, 0.05208829f, 0.09619845f, 0.14418218f, 
    0.10447754f, -0.51824826f, 0.01849405f, 0.12268399f, -0.01871066f, -0.09549025f, 0.15313336f, -0.10526201f, 
    -0.09378830f, 0.08418595f, -0.24524277f, 0.27679053f, -0.06426585f, -0.00447630f, -0.18650359f, -0.21552493f, 
    -0.00676418f, 0.16729946f, 0.10164856f, 0.07772516f, 0.11603793f, 0.31563011f, 0.22238085f, -0.03180918f, 
    0.03245163f, -0.40943226f, -0.02496597f, 0.14001015f, 0.25158978f, 0.18985040f, -0.23709558f, 0.14007750f, 
    -0.02096657f, -0.19230551f, 0.08714776f, 0.08297611f, 0.06511433f, 0.52754730f, 0.53261948f, -0.20155570f, 
    0.21074039f, 0.23803157f, -0.02045987f, 0.10746153f, 0.01839810f, 0.05767591f, 0.21160479f, 0.17638759f, 
    -0.26211554f, -0.14150622f, 0.04795682f, -0.09302782f, -0.02208300f, -0.20115209f, 0.05333636f, 0.01652653f, 
    0.17893618f, -0.30308846f, 0.11959127f, 0.03927889f, -0.26097134f, 0.21354435f, 0.07165135f, -0.17034285f, 
    0.07314320f, 0.04334668f, -0.52610683f, -0.15488259f, -0.05066558f, 0.02482971f, 0.13330764f, 0.24140304f, 
    0.07590828f, -0.40308613f, -0.21141586f, 0.21544498f, 0.05200494f, 0.10971852f, 0.11687505f, -0.16472332f, 
    -0.03786902f, 0.06000316f, -0.12725255f, -0.02291450f, 0.11047854f, 0.09619650f, -0.03328802f, 0.09896290f, 
    0.03479273f, -0.12518653f, 0.06783370f, 0.05857132f, -0.14377101f, -0.05932170f, -0.11731153f, -0.06434938f, 
    0.03887541f, 0.05261455f, -0.11038326f, 0.01930137f, 0.31607294f, 0.13083653f, 0.19643497f, -0.00321487f, 
    -0.16555245f, -0.10008208f, 0.00012992f, 0.03517587f, 0.15275621f, -0.38300738f, -0.22880280f, 0.15819138f, 
    0.12398676f, -0.21756044f, -0.15232407f, -0.08915895f, -0.11857191f, -0.11238047f, -0.12892738f, 0.09441269f, 
    -0.33004522f, -0.00042618f, -0.15652402f, 0.16093920f, 0.06248371f, -0.10914584f, 0.03795987f, 0.17400396f, 
    0.24778025f, -0.26523510f, 0.16977488f, 0.05889947f, 0.21672852f, 0.13507034f, 0.07860186f, 0.12402186f, 
    -0.34022981f, 0.27183712f, 0.40637270f, 0.01912575f, -0.14131916f, -0.00514664f, 0.01781356f, 0.01298463f, 
    -0.22003324f, -0.39276180f, -0.28233826f, -0.04715945f, 0.07686368f, -0.02255354f, -0.12096404f, -0.03862989f, 
    -0.15798531f, 0.04358269f, -0.25362495f, 0.03961118f, 0.08489269f, 0.20239758f, 0.28810570f, 0.11771783f, 
    0.16058312f, -0.06301256f, 0.13274184f, 0.18740390f, -0.26534316f, -0.10655895f, 0.11558088f, 0.05599038f, 
    -0.05682543f, -0.04437217f, 0.33423039f, 0.14208762f, 0.00293872f, 0.34218800f, 0.11570386f, 0.36525199f, 
    0.01197861f, 0.05454769f, 0.19710416f, 0.11233593f, 0.08833764f, -0.03488042f, -0.06702255f, -0.11496495f, 
    0.01667832f, 0.07805559f, -0.07095229f, -0.19134372f, -0.11667068f, -0.17868984f, -0.34788555f, 0.40572762f, 
    -0.16134022f, 0.04967500f, 0.02068844f, -0.16835374f, -0.10714978f, -0.08150385f, -0.19664700f, -0.25342998f, 
    -0.26728445f, -0.13296556f, 0.23634408f, 0.13499098f, 0.06282743f, 0.06391767f, 0.00927405f, 0.10954072f, 
    -0.46652734f, -0.31928703f, -0.15058860f, -0.15637355f, -0.04962795f, -0.08206119f, 0.07255883f, -0.00407688f, 
    0.07829398f, 0.21501875f, 0.17343543f, 0.30286169f, -0.11182102f, 0.11759617f, -0.07148275f, -0.08835021f, 
    -0.11694314f, 0.08124460f, -0.05622006f, -0.42342311f, 0.30822381f, 0.02039395f, 0.06911194f, -0.05941945f, 
    0.04411106f, -0.14406693f, 0.28193656f, -0.10363700f, 0.33772215f, -0.13235706f, -0.06785141f, -0.04122237f, 
    -0.10643857f, 0.19030248f, 0.04371649f, -0.05891579f, 0.11753735f, 0.06360256f, 0.01332848f, 0.07061550f, 
    0.02598988f, -0.03397025f, 0.18827812f, 0.19652227f, 0.21588033f, 0.00977604f, 0.07665884f, 0.13484074f, 
    -0.22315057f, -0.34020898f, 0.16115314f, -0.09029345f, -0.05666607f, 0.11170643f, 0.34949848f, -0.08829790f, 
    -0.21959449f, 0.02003238f, -0.04462514f, 0.02541941f, -0.03978702f, 0.01876253f, 0.17962334f, -0.21494661f, 
    -0.30246422f, -0.74737227f, 0.03966811f, 0.13130623f, 0.05893869f, -0.08461403f, -0.25477898f, 0.04822083f, 
    0.10504729f, 0.02111104f, 0.35727820f, -0.13382721f, -0.22807360f, -0.19010265f, -0.05200199f, 0.13518427f, 
    0.08190574f, 0.17666747f, 0.09569421f, 0.28293481f, 0.01888295f, -0.04944726f, -0.12988818f, 0.06358450f, 
    0.22929294f, -0.02314175f, 0.07276550f, -0.06108639f, -0.05347224f, 0.16468850f, 0.04788512f, -0.02217901f, 
    -0.02848273f, 0.06230944f, -0.13188058f, 0.27425942f, 0.36204651f, 0.30092099f, 0.10147528f, -0.08717335f, 
    -0.06267527f, 0.25807703f, 0.07919499f, 0.37608084f, 0.03074383f, -0.20347863f, 0.23840386f, 0.39760667f, 
    0.12368727f, 0.01032629f, 0.06757006f, 0.04742047f, 0.14686745f, -0.37156084f, 0.23995858f, 0.06610095f, 
    -0.02424036f, 0.05710623f, -0.03107961f, -0.01069283f, 0.01704761f, -0.03250721f, -0.21272828f, -0.12938407f, 
    0.13602211f, 0.04510186f, 0.11946569f, 0.12984087f, 0.02157476f, -0.27750355f, -0.10182407f, -0.23434126f, 
    -0.47857794f, -0.52704537f, 0.21385033f, -0.16030484f, -0.19060791f, 0.08537700f, 0.02711947f, 0.00441903f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03102258f, 0.11186648f, -0.15266569f, -0.05016339f, 0.32790259f, 0.02996968f, 0.03114371f, -0.16582938f, 
    0.21895443f, -0.05340376f, 0.20737976f, 0.23573810f, -0.04526518f, 0.03561903f, 0.22700943f, 0.04724539f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.30780986f, 0.35729006f, -0.24770884f, -0.29451567f, -0.17312013f, 0.03259397f, -0.00008980f, 0.25036055f, 
    -0.05270126f, 0.16076963f, 0.24146821f, 0.23490739f, -0.03925708f, -0.27315140f, 0.55972403f, 0.41420609f, 
    -0.26912224f, 0.15196142f, 0.25471893f, 0.11948986f, 0.31809729f, 0.10845650f, -0.24481796f, 0.43759662f, 
    0.59375393f, 0.06316334f, -0.28525341f, -0.17317992f, -0.09054229f, -0.31756419f, 0.32264024f, 0.59008127f, 
    0.46612996f, 0.49464199f, -0.39678141f, -0.42266187f, 0.01581473f, 0.03560407f, 0.19658941f, 0.06267961f, 
    -0.01111510f, 0.02956318f, 0.50793505f, 0.04861427f, -0.02219881f, -0.09244858f, 0.20165847f, -0.26815557f, 
    -0.20072757f, 0.32875061f, 0.40220493f, 0.07807053f, 0.22445573f, -0.25972810f, 0.08646791f, -0.33010370f, 
    0.83289254f, -0.27309403f, -0.04306020f, 0.17790771f, 0.12499315f, 0.10204530f, -0.40662870f, -0.33860970f, 
    -0.12586647f, -0.02040885f, -0.20334929f, -0.17250997f, -0.24380967f, 0.11374775f, 0.18707836f, -0.12344652f, 
    0.03791241f, 0.04319578f, -0.16154912f, -0.14664778f, 0.00319070f, 0.14149757f, -0.10361037f, -0.02288976f, 
    -0.18277332f, -0.43236202f, 0.19295782f, -0.32353908f, 0.38532043f, -0.05248867f, -0.14625566f, -0.39578909f, 
    -0.30551615f, 0.33506417f, 0.03571799f, 0.19501059f, 0.16356738f, 0.44787449f, 0.01076707f, 0.20985569f, 
    0.00686009f, 0.46711519f, 0.68228328f, 0.21475193f, -0.53234988f, -0.18881801f, 0.14057468f, 0.31850237f, 
    0.23963957f, -0.47160202f, -0.29344401f, -0.27231857f, -0.24812058f, 0.21989632f, -0.13798776f, 0.10858162f, 
    -0.03786694f, 0.24084941f, -0.30348259f, -0.01899165f, 0.07380859f, 0.00601351f, -0.22257452f, 0.00455676f, 
    0.05116830f, 0.53613293f, 0.56569386f, 0.32099250f, -0.56858748f, -0.30697021f, -0.12373826f, -0.27101833f, 
    0.17290463f, -0.21815699f, -0.29563355f, -0.14408365f, 0.20551065f, -0.11600347f, 0.00730212f, 0.11621144f, 
    0.30237561f, 0.58387566f, -0.03632027f, 0.34649390f, 0.30292267f, -0.10977308f, 0.24687791f, -0.37276429f, 
    -0.19118464f, -0.18494079f, 0.06275791f, 0.06010559f, 0.03769723f, -0.11192790f, 0.17233950f, -0.04502481f, 
    0.06211489f, -0.21286425f, -0.04177609f, -0.20360762f, -0.13195309f, -0.22157794f, 0.20757717f, -0.18365487f, 
    0.48795599f, 0.05822515f, 0.21909778f, -0.19996737f, 0.03128348f, -0.04281458f, -0.14761806f, 0.17598048f, 
    0.12876482f, 0.70811129f, 0.27544928f, 0.22159465f, -0.16177474f, -0.28998685f, -0.36260265f, -0.40210137f, 
    -0.02106532f, 0.25667477f, -0.23766473f, -0.25324449f, -0.35976252f, 0.07620752f, -0.14453806f, -0.01859476f, 
    0.43388078f, 0.27377361f, 0.16747977f, -0.10925426f, -0.17098184f, 0.38592911f, -0.00329281f, -0.10076472f, 
    -0.16412912f, 0.41417450f, -0.45519084f, 0.50875503f, -0.16573070f, 0.16492158f, 0.17644405f, -0.51821470f, 
    0.18405811f, 0.07050332f, 0.25507429f, 0.08148397f, -0.03013241f, 0.46484619f, -0.43315583f, 0.04873476f, 
    -0.16195916f, -0.13772961f, 0.55116594f, -0.53687024f, 0.30495301f, 0.08621873f, 0.12147837f, -0.08369843f, 
    0.37995350f, 0.40678415f, -0.03294172f, 0.25050861f, -0.09851097f, -0.03433112f, 0.22520642f, 0.00853381f, 
    -0.29153040f, -0.27929005f, -0.00319413f, -0.14226839f, 0.25818518f, 0.23253021f, -0.16798291f, -0.18955176f, 
    -0.35313779f, 0.26013991f, 0.14213832f, -0.09648518f, -0.21598092f, 0.16284549f, 0.45697272f, 0.47566944f, 
    -0.17409238f, 0.30246776f, 0.08693278f, 0.54740494f, -0.05481955f, -0.22746901f, 0.16435054f, -0.29320464f, 
    0.25531313f, 0.32642594f, 0.19339988f, -0.29804552f, -0.14858674f, 0.38927412f, -0.50744039f, 0.51550817f, 
    -0.25953948f, 0.41143376f, -0.24545315f, 0.46172944f, -0.00700331f, -0.17474298f, 0.01518453f, -0.14058559f, 
    -0.19275485f, 0.13842294f, -0.25079459f, 0.26792929f, 0.48034325f, 0.43581644f, -0.42858621f, -0.31128326f, 
    0.28845555f, -0.53994209f, 0.25978619f, -0.44510168f, 0.36177605f, -0.21277168f, 0.22451340f, 0.13501346f, 
    -0.30473375f, 0.26164770f, -0.02858493f, 0.39959112f, 0.10660861f, 0.32228839f, 0.18913563f, -0.30989808f, 
    0.10984109f, -0.12374753f, -0.13848440f, -0.07158346f, -0.02488079f, -0.12268438f, 0.24291088f, 0.00578113f, 
    0.18635496f, -0.20554624f, 0.08113454f, -0.19144987f, 0.18420035f, -0.17268468f, -0.25989190f, -0.02277965f, 
    0.15144925f, -0.07674410f, 0.01971843f, 0.67107719f, -0.15620345f, -0.20104548f, 0.22414403f, 0.56981695f, 
    0.22190191f, 0.53737277f, -0.47969371f, -0.26141000f, -0.46154293f, -0.26944721f, 0.46928790f, 0.23003522f, 
    -0.16124624f, 0.07754469f, -0.07710469f, -0.08750704f, -0.00984207f, 0.00776076f, 0.05033892f, -0.13315460f, 
    -0.02205092f, 0.02838832f, -0.06489071f, -0.10502949f, -0.06658316f, -0.17342359f, 0.20023042f, -0.06289718f, 
    0.05799100f, -0.08586660f, 0.08837239f, 0.52576077f, -0.08049370f, -0.06935330f, -0.22614157f, 0.08902098f, 
    0.62113917f, -0.33793437f, 0.35667709f, -0.20820911f, -0.03839597f, -0.34900615f, 0.29811701f, -0.43962380f, 
    -0.03305431f, -0.05452463f, -0.01410214f, -0.11712673f, -0.10103755f, -0.02433134f, -0.14944492f, -0.00193944f, 
    0.11711904f, -0.08921152f, 0.12904367f, -0.22856405f, 0.11922379f, -0.05231384f, -0.19507053f, 0.11611419f, 
    -0.12967466f, -0.05304895f, -0.23727831f, 0.21008527f, 0.54813349f, -0.17784414f, 0.20356745f, 0.20125590f, 
    -0.32966906f, 0.31080920f, -0.12843010f, -0.08116463f, -0.03570317f, 0.32938412f, -0.73054326f, -0.09464267f, 
    0.03410917f, -0.41025406f, 0.39317688f, 0.33974209f, 0.28935376f, 0.09689949f, -0.06845882f, 0.48479685f, 
    -0.04787467f, 0.06685490f, -0.10681709f, 0.29324105f, 0.51207006f, 0.47098580f, -0.33887610f, -0.69480181f, 
    0.14406668f, -0.16521370f, -0.10148796f, -0.01763682f, 0.09016922f, -0.15167549f, 0.15514797f, -0.13692844f, 
    0.16562678f, -0.02198841f, -0.06090477f, -0.13888268f, -0.07168248f, -0.10436407f, -0.07070892f, -0.21895058f, 
    0.23781595f, -0.07551582f, -0.06501934f, 0.23103671f, 0.14592600f, 0.19824290f, 0.21024719f, 0.11746842f, 
    0.55634499f, -0.40947974f, -0.05861592f, -0.00026094f, 0.71555209f, 0.09025033f, 0.77814436f, -0.14510477f, 
    0.67489058f, 0.21639866f, 0.67944950f, 0.27171573f, 0.22932130f, 0.03419157f, -0.05127169f, -0.33490250f, 
    -0.17657441f, -0.54900914f, -0.18562658f, 0.03893415f, 0.53650630f, 0.25976998f, 0.03764565f, -0.55911368f, 
    -0.25911552f, 0.35613847f, -0.08272788f, -0.40275142f, 0.28890568f, 0.18480182f, -0.09930201f, 0.20653671f, 
    0.49054790f, 0.10927478f, 0.42112806f, -0.14309122f, -0.42328215f, -0.04696194f, -0.25033423f, 0.39206058f, 
    -0.21460283f, 0.22198811f, -0.49674931f, -0.27565971f, -0.31394294f, 0.03464867f, 0.03314340f, -0.70987797f, 
    0.42382848f, 0.06494414f, 0.45859545f, -0.17851770f, 0.02016934f, 0.35970861f, 0.49502185f, 0.29134348f, 
    -0.35347691f, 0.33693564f, -0.52912480f, 0.22313191f, -0.11315027f, 0.19559626f, -0.04854725f, 0.01694194f, 
    -0.34859842f, -0.28461832f, -0.45180130f, 0.08850604f, 0.58227801f, 0.41200632f, 0.38423157f, 0.28234288f, 
    0.03320603f, -0.11355462f, 0.04900135f, 0.01835186f, -0.06739230f, 0.02844953f, -0.03710142f, -0.12213410f, 
    0.09114779f, -0.04940147f, 0.09268141f, -0.23814029f, -0.09089459f, -0.27885258f, -0.24877113f, 0.07592773f, 
    0.00100622f, 0.38453859f, -0.21602672f, 0.12198251f, 0.09868311f, -0.03717762f, 0.00002617f, 0.61881411f, 
    -0.29138923f, 0.01412833f, -0.65066987f, -0.29162449f, -0.33967483f, -0.19849502f, -0.01257148f, 0.75680453f, 
    -0.00811916f, -0.13361903f, -0.08538004f, -0.15649265f, -0.05340582f, 0.13232948f, 0.15858307f, -0.07633907f, 
    -0.23772585f, 0.12927251f, 0.07018495f, -0.10462105f, 0.14065708f, -0.14310429f, 0.21033014f, -0.26641604f, 
    -0.16788416f, -0.34990835f, 0.28100535f, 0.12293132f, 0.08241056f, 0.12946405f, -0.15778723f, -0.00474238f, 
    -0.46093684f, -0.18622538f, -0.43192506f, 0.20165583f, 0.45945531f, 0.42917970f, 0.41499680f, 0.24816899f, 
    0.38386095f, -0.12928785f, 0.34385297f, 0.08745327f, 0.25434825f, -0.09674553f, -0.21307890f, -0.26646209f, 
    -0.53488249f, -0.50262570f, -0.30356911f, 0.22173564f, 0.03406273f, 0.39023674f, -0.01972954f, -0.05620527f, 
    0.13757539f, -0.20091651f, -0.41193005f, -0.05407216f, 0.35731581f, -0.20322974f, -0.01544333f, 0.56728745f, 
    0.02856275f, 0.34795177f, 0.17661542f, 0.14115380f, -0.18128727f, -0.04395155f, 0.18487193f, -0.31282157f, 
    -0.03824484f, -0.34765744f, 0.10411457f, -0.25175229f, 0.27476776f, 0.16074315f, -0.11231757f, 0.45322251f, 
    -0.19616644f, 0.66554427f, 0.17944907f, 0.31951892f, -0.36249840f, -0.10929171f, -0.05054042f, 0.48854983f, 
    0.27947447f, -0.26358140f, -0.09164932f, 0.08485328f, 0.14008600f, -0.20047516f, 0.14686002f, -0.35843647f, 
    -1.02264249f, 0.51230633f, 0.34682262f, 0.19568790f, -0.30095056f, 0.05386046f, 0.27252749f, 0.06391158f, 
    -0.07745834f, 0.27362317f, -0.25965238f, 0.47323874f, -0.12132439f, 0.15348183f, 0.10706274f, 0.39744946f, 
    0.31789669f, -0.22368085f, 0.06061173f, 0.29863203f, 0.39416888f, -0.30475408f, 0.03844446f, -0.13672373f, 
    0.33922973f, 0.48484609f, 0.74419802f, 0.10830095f, -0.59438926f, 0.23119633f, 0.05947499f, 0.18247534f, 
    -0.29458326f, -0.07476921f, 0.08001462f, -0.40413037f, 0.24268486f, -0.02403091f, -0.04836893f, 0.22916447f, 
    -0.32810673f, 0.51024801f, 0.23836288f, 0.05179444f, 0.26328129f, -0.13679513f, 0.18463425f, 0.14790772f, 
    0.44728571f, -0.10577608f, 0.35758024f, -0.20788719f, -0.44342002f, -0.05500443f, -0.57986486f, 0.43384704f, 
    -0.20522648f, 0.31058723f, -0.24725458f, -0.05849138f, 0.23963778f, -0.00842467f, 0.20346886f, 0.60630304f, 
    0.04351764f, -0.48992500f, -0.46487296f, 0.11796995f, -0.02568651f, 0.09689071f, -0.39666638f, 0.05616251f, 
    0.54632103f, 0.26566553f, 0.14276679f, -0.36794007f, -0.14133869f, -0.22122185f, -0.17949980f, -0.12296078f, 
    0.32326522f, -0.35350657f, 0.42755172f, -0.03847578f, -0.47680175f, 0.33707738f, 0.41877705f, -0.21146081f, 
    0.11922704f, 0.19350581f, 0.25137311f, -0.14501676f, 0.13747157f, 0.10865651f, -0.11837254f, 0.35723966f, 
    -0.04619236f, 0.51301092f, 0.45050973f, -0.11969512f, -0.56080246f, -0.36898896f, -0.08817194f, 0.56901538f, 
    -0.19776784f, -0.00973949f, 0.39628497f, 0.27665633f, -0.20189127f, 0.20418814f, 0.08985305f, 0.20289934f, 
    -0.31724057f, -0.02434050f, -0.21069720f, 0.26048583f, 0.46027514f, 0.03963832f, 0.21859840f, 0.20662272f, 
    0.33972400f, 0.20597833f, 0.20002571f, -0.19668910f, -0.06047694f, -0.17154080f, 0.21453053f, -0.04263274f, 
    -0.26477832f, 0.22155197f, 0.20395370f, 0.25489354f, 0.10155784f, -0.20374659f, 0.20537476f, -0.17770728f, 
    -0.33419535f, -0.15103959f, -0.20079194f, 0.21969144f, 0.26238212f, 0.01272129f, 0.18887421f, 0.36193171f, 
    0.28620836f, -0.34981731f, -0.01517069f, -0.29992399f, -0.19420618f, 0.37348044f, 0.26763538f, 0.26990730f, 
    0.03169371f, 0.32245257f, 0.16863661f, 0.46456680f, 0.30364445f, 0.10032891f, -0.01163393f, 0.38321143f, 
    -0.23865668f, -0.05559380f, -0.08158840f, -0.27500403f, -0.04597596f, -0.29395497f, -0.62731868f, 0.17444941f, 
    -0.12450639f, -0.02354565f, -0.21149220f, -0.29844534f, -0.02776259f, -0.14770916f, 0.16984899f, -0.19666919f, 
    0.03926697f, 0.12457277f, -0.16893332f, -0.19958773f, -0.10675867f, -0.12672701f, 0.06212865f, 0.10278503f, 
    -0.36942992f, -0.28411162f, -0.03706650f, -0.28351545f, -0.17148194f, -0.03435379f, 0.14166725f, 0.28648111f, 
    0.62096691f, 0.59640342f, 0.13662282f, 0.06224109f, -0.45185900f, 0.38491374f, -0.37721434f, 0.09659185f, 
    -0.04909659f, 0.04876458f, -0.40336242f, 0.22555943f, 0.31475243f, -0.12227386f, 0.15767726f, -0.08144138f, 
    0.23653404f, -0.24762613f, -0.09416731f, 0.13658197f, -0.35652322f, -0.00744224f, -0.10667706f, 0.51062286f, 
    -0.80954993f, -0.18999879f, -0.50631076f, 0.21715283f, 0.02624305f, -0.11895645f, 0.10945112f, 0.31135380f, 
    0.02211603f, 0.33745089f, -0.14025830f, 0.26306292f, 0.23643897f, 0.34134239f, -0.25554723f, 0.32465386f, 
    0.18609922f, 0.50383681f, -0.05187452f, -0.28873068f, 0.07493317f, -0.10097650f, 0.04144861f, -0.41011941f, 
    0.17703468f, -0.08849497f, 0.45552838f, 0.20204996f, -0.47462711f, 0.31693569f, -0.12535909f, -0.21265005f, 
    0.12595885f, -0.07286061f, 0.50323611f, 0.27562469f, 0.17161512f, -0.08762700f, 0.02251431f, -0.19045106f, 
    -0.82646966f, 0.43278468f, 0.13119750f, 0.43021572f, 0.09887392f, -0.04072559f, -0.02619793f, -0.29935035f, 
    0.29469869f, -0.23289719f, -0.21007720f, -0.51528603f, 0.38954967f, 0.09306547f, -0.21496972f, -0.28387663f, 
    -0.55266160f, -0.05074370f, 0.33404833f, -0.02187810f, -0.16834117f, 0.10829915f, 0.67336780f, 0.44512442f, 
    -0.40833321f, 0.45460811f, -0.13711089f, -0.49579287f, 0.19466022f, 0.16071655f, 0.20855500f, -0.24706733f, 
    0.11432685f, -0.50054753f, 0.20789218f, 0.32182017f, -0.09880165f, 0.04609867f, 0.30982569f, -0.17270333f, 
    -0.56833875f, -0.16082524f, 0.43623039f, 0.31150225f, -0.14469412f, 0.18284859f, 0.15183999f, 0.48819613f, 
    0.32418147f, -0.23250751f, -0.51120967f, 0.29300487f, 0.06064062f, 0.26509786f, -0.29514092f, 0.12767364f, 
    0.43022415f, 0.18802971f, -0.43266109f, 0.12489948f, 0.33702913f, -0.20081799f, 0.17266487f, -0.35306984f, 
    -0.12143563f, -0.31716663f, 0.32200041f, -0.30792853f, -0.13653827f, 0.10928355f, 0.09742770f, 0.27363986f, 
    0.07559705f, 0.55232084f, -0.05024488f, 0.39749020f, -0.18697113f, 0.15915464f, -0.21003361f, 0.52290612f, 
    -0.22816856f, 0.24016590f, -0.23380515f, -0.13192093f, -0.09818251f, -0.44154137f, 0.20117870f, 0.20190220f, 
    -0.90157646f, -0.22238846f, -0.33712900f, -0.17377874f, 0.12812379f, -0.18480399f, -0.16459611f, 0.43043333f, 
    0.05440092f, 0.01266425f, -0.32831234f, 0.35235283f, -0.31711084f, 0.32486829f, 0.52848327f, -0.19067964f, 
    0.00291238f, -0.22197317f, -0.09828406f, 0.12594658f, -0.23170784f, -0.22164568f, -0.15620989f, -0.17630473f, 
    -0.46169826f, 0.26439285f, 0.28573832f, -0.14416444f, -0.00380869f, -0.03546888f, -0.09868103f, 0.19695914f, 
    0.24201638f, -0.12146541f, -0.14558533f, 0.31413031f, 0.42830974f, 0.18998554f, -0.03600664f, 0.33392677f, 
    -0.07907972f, -0.41290981f, -0.08581176f, 0.08451650f, 0.29931006f, 0.48027065f, -0.12781088f, -0.40119615f, 
    -0.04023827f, -0.03565788f, 0.09414336f, 0.14195488f, 0.15143640f, 0.16743244f, 0.14002293f, -0.19709732f, 
    0.69692940f, 0.74657178f, 0.14365293f, 0.31130344f, -0.16181238f, -0.03664634f, -0.46186969f, -0.38662153f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01202197f, -0.01313475f, 0.40496516f, 0.16715531f, 0.06458765f, 0.00768016f, -0.15030095f, 0.26283577f, 
    0.21320352f, 0.10981128f, -0.10506738f, 0.16085869f, -0.02623984f, -0.11872863f, 0.31257677f, -0.07861701f, 
    0.36812896f, 0.03177471f, -0.24067838f, 0.02757485f, 0.06822148f, -0.04805311f, -0.15305822f, 0.23442502f, 
    0.18584979f, -0.11329700f, -0.03163531f, -0.15160561f, -0.17361774f, -0.02186116f, -0.17414796f, 0.22987102f, 
    0.05193309f, -0.14676358f, 0.00749160f, 0.55312705f, 0.21041378f, 0.00844884f, 0.14429879f, 0.25500613f, 
    0.19641788f, -0.04753312f, 0.06767380f, -0.13048206f, -0.27624965f, 0.17625280f, 0.23660351f, 0.12856044f, 
    -0.19860363f, 0.16144966f, 0.09768198f, 0.10853241f, 0.05791609f, 0.31763351f, 0.31995997f, 0.44726580f, 
    0.52888316f, 0.11824520f, 0.41359091f, 0.26194638f, -0.14883707f, 0.15698221f, 0.09695826f, -0.22069836f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.27120695f, -0.07633355f, 0.01733672f, -0.10106076f, 0.07118166f, -0.08085456f, -0.71887648f, 0.41851375f, 
    0.11667356f, -0.06749155f, 0.37838659f, 0.08965521f, 0.02212548f, 0.04655510f, 0.11192251f, 0.00987534f, 
    0.16753022f, -0.05817719f, 0.01559920f, 0.10071351f, 0.10966155f, -1.46913350f, 0.03889105f, 0.14511935f, 
    0.09527506f, -0.06790591f, -0.66415381f, -0.61561286f, -0.02372218f, -0.33000273f, -0.19766413f, -0.07772399f, 
    -1.41356432f, 0.03186247f, -0.14433122f, -0.26597905f, 0.18183815f, 0.35069832f, 0.20346956f, 0.21025410f, 
    -0.43806455f, 0.14993952f, -0.09219716f, -0.41213542f, 0.23926271f, 0.18110563f, 0.07125962f, -0.27435136f, 
    -0.42991453f, 0.06942824f, 0.42640927f, 0.01837374f, 0.40907580f, -0.08699205f, 0.26970392f, -0.27513662f, 
    -0.09841800f, 0.32096934f, -0.46163037f, 0.13781844f, 0.32896996f, 0.05505664f, -0.24185927f, 0.33272743f, 
    0.07941355f, 0.12035585f, 0.19155613f, 0.14540046f, 0.09743100f, -0.09900561f, -0.18754707f, 0.35736212f, 
    0.26054752f, 0.01576230f, 0.49304435f, 0.08067216f, 0.09722640f, 0.19218709f, -0.16258366f, 0.09462606f, 
    -0.22221208f, -0.07383503f, 0.00989377f, 0.34229809f, 0.11766064f, 0.13740304f, -0.08386128f, -0.92293942f, 
    -0.16753136f, -0.02799875f, -0.06120883f, -0.21384002f, 0.27777305f, 0.28359616f, 0.00084836f, 0.04345498f, 
    0.65272170f, -0.07934711f, -0.34231481f, -0.41611528f, -0.01281732f, 0.03392918f, -0.08760016f, -0.05629301f, 
    0.02586060f, 0.02055589f, -0.52452618f, 0.18226723f, 0.24495295f, -0.22921859f, 0.10886691f, -0.27791557f, 
    -0.05674283f, -0.10294255f, 0.21404998f, -0.15637751f, 0.11652935f, 0.18315400f, -0.06793675f, -0.11227825f, 
    -0.03539209f, -0.30711204f, -0.20182504f, 0.21333341f, 0.15013508f, -0.54447699f, -0.50369859f, 0.45617518f, 
    -0.25221217f, 0.16151097f, -0.61657381f, 0.08592021f, 0.03729241f, 0.17636506f, 0.62903017f, -0.23756491f, 
    -0.47674158f, -0.01185818f, 0.00223662f, -0.16967948f, -0.84490550f, 0.29313856f, 0.12978652f, -0.09026033f, 
    -0.87897539f, 0.24995433f, -0.10431922f, -0.85591918f, 0.04527716f, -0.82947814f, 0.09240115f, -0.35723197f, 
    0.10449190f, 0.01969926f, -0.22776078f, 0.33906084f, -0.00480834f, -0.57001078f, -0.58520716f, 0.02738034f, 
    -1.14507949f, -0.11499834f, 0.26965222f, 0.35454068f, -0.42503786f, 0.21275085f, 0.08480637f, -0.44120720f, 
    0.86690575f, 0.14966984f, -0.51914704f, 0.07233533f, 0.28088084f, 0.18193935f, 0.00033099f, -0.23671229f, 
    -0.31143624f, -0.01057435f, 0.08243446f, -0.36552188f, -0.82272148f, -0.03982648f, 0.25141180f, 0.18069497f, 
    -0.12917484f, 0.34872425f, -0.27036381f, -0.84044355f, 0.17527999f, -0.35927388f, -0.17835791f, -0.14601222f, 
    -0.24625677f, 0.01291228f, -0.45832631f, 0.11982480f, 0.02886095f, -0.57456529f, 0.06872895f, -0.40024137f, 
    0.05287101f, 0.10476972f, -0.52249098f, -0.27180064f, 0.22031724f, -1.05051076f, -0.47036874f, 0.05023536f, 
    0.29229563f, -0.34448031f, -0.09821838f, 0.30377868f, 0.07830435f, 0.78372586f, -0.09036019f, -0.03634422f, 
    0.19442883f, 0.10794580f, 0.48101601f, 0.33128050f, -1.17011857f, -0.81029612f, 0.33862677f, 0.06255762f, 
    -0.38198817f, -0.10234012f, 0.23580360f, 0.03277344f, -0.13678488f, -0.79787421f, -0.59575617f, 0.32260311f, 
    0.19681667f, -0.21096319f, 0.08402295f, -0.43613163f, -0.76432604f, 0.25021273f, -0.11348014f, 0.00324351f, 
    0.14910381f, -0.12160294f, -0.40332529f, -0.12173961f, 0.21115489f, -0.34749308f, 0.06374013f, -0.94607043f, 
    -0.29103869f, 0.23993632f, -0.18730932f, 0.04378355f, 0.10586999f, 0.06695643f, 0.25610718f, -0.03504816f, 
    -0.03275943f, 0.17038697f, -0.16741590f, 0.24406134f, 0.08690878f, 0.15161677f, -0.51250011f, -0.40128645f, 
    0.20546637f, 0.04433610f, -0.48646396f, -0.70404148f, -0.29332119f, 0.17163529f, 0.11399003f, -0.21446338f, 
    0.08280363f, 0.09995443f, 0.07973047f, -0.81496227f, 0.01329505f, -0.06759957f, -0.03200049f, 0.16582933f, 
    0.15382077f, -0.04254460f, 0.23166750f, -0.08564642f, 0.01904295f, -0.41049945f, 0.19739717f, -0.06132412f, 
    0.13215274f, 0.06572700f, 0.28489989f, 0.07663160f, 0.14026709f, 0.01404120f, -0.36657277f, 0.06219400f, 
    -0.86597872f, -0.03196437f, 0.44013625f, -0.15545270f, -0.21649584f, 0.07660133f, -0.16385932f, 0.25251305f, 
    -0.37337840f, -0.08052390f, -0.15356940f, 0.11204917f, 0.25451019f, -0.15102293f, -0.14406522f, -0.05160879f, 
    0.11531150f, 0.23771417f, -0.16979319f, -0.49091744f, 0.41351825f, -0.43387923f, 0.10575037f, -0.07085097f, 
    -0.21275830f, -0.04233995f, 0.25370160f, 0.05382227f, 0.04455678f, -0.11583443f, -0.25228250f, 0.28126299f, 
    -0.02638321f, 0.00072062f, 0.07235361f, 0.03104083f, 0.02344975f, -0.10170735f, -0.02547186f, -0.17590398f, 
    -0.33943608f, -0.05338842f, -0.04095524f, -0.50358516f, -0.06682013f, 0.55065328f, 0.00615731f, 0.71983331f, 
    0.00378857f, -0.03348571f, -0.08082432f, -0.07954659f, 0.19342689f, 0.38009337f, -0.80534035f, 0.02104169f, 
    0.00713134f, -0.04162758f, -0.66265619f, 0.06055117f, 0.22759919f, -0.10116890f, 0.05685233f, -0.05963747f, 
    -0.74439055f, 0.15189548f, 0.34618345f, 0.19377255f, 0.01238325f, -0.41841185f, -0.05790566f, 0.10547402f, 
    0.73553813f, 0.08047022f, -0.23055358f, 0.09464877f, -0.15624140f, 0.20423149f, -0.01510513f, 0.22539811f, 
    0.15025795f, -0.38710979f, 0.47257265f, -0.15719628f, -1.39363348f, -0.79052323f, 0.18883002f, -0.01193268f, 
    -0.18864211f, -0.59259230f, 0.35543895f, -0.15382211f, -0.00444851f, 0.03391614f, -0.84795469f, -0.05109546f, 
    0.35740319f, -0.11390448f, 0.26027736f, -0.89581931f, -0.19426578f, 0.06087270f, -0.11191452f, -0.43057454f, 
    0.18171731f, 0.32334441f, -0.08509670f, -0.20561828f, -0.09291607f, -0.06007649f, -0.03720506f, -0.13591045f, 
    0.38027164f, 0.01727396f, 0.12151386f, 0.47549441f, -0.61517859f, -1.10131943f, -0.06546089f, -0.04489185f, 
    -0.91729969f, -0.06135374f, 0.12929435f, 0.27615601f, 0.22493017f, 0.03442224f, 0.31597403f, 0.10350690f, 
    -0.23500681f, -0.64860159f, -0.53127831f, 0.05576732f, -0.11260844f, 0.06063087f, 0.32227343f, -0.53166378f, 
    -0.49348113f, -0.09812693f, -1.03244066f, -0.33062997f, -0.38673368f, 0.01811269f, 0.41830358f, 0.00739829f, 
    -0.01873504f, -0.57149553f, 0.07959384f, -0.26346010f, -0.77008975f, -0.02163726f, 0.29661584f, -0.05381115f, 
    -0.11327294f, 0.41101813f, -0.33960226f, -0.25081107f, -0.06122826f, 0.05428491f, 0.37432984f, -0.53207332f, 
    -0.16595145f, -0.02128503f, -0.22139439f, -0.13831861f, -0.32851362f, -0.06435076f, 0.11265342f, 0.12883973f, 
    -0.16451606f, -0.18738918f, -0.08851910f, 0.48671040f, 0.00116996f, -0.06190282f, -0.05151233f, -0.02510436f, 
    -0.10054944f, 0.05496309f, 0.05534456f, -0.55998570f, 0.11755038f, 0.29822278f, 0.05136675f, 0.00090136f, 
    0.58882141f, -0.08752260f, -0.31314901f, -1.10005784f, 0.18843070f, -0.00551699f, 0.14925212f, 0.09684918f, 
    0.03389069f, 0.25751281f, 0.23017462f, -0.32999265f, 0.20875776f, -0.22326948f, -0.43913400f, 0.39894640f, 
    0.17882936f, -0.10356557f, -0.00697909f, 0.10674101f, 0.14228505f, -0.92456549f, -0.79548055f, 0.26459366f, 
    -1.01594651f, 0.18634155f, 0.12771024f, 0.15609924f, -0.09306839f, -0.04368636f, -0.06568796f, -0.33669451f, 
    0.31909049f, 0.00574067f, 0.03877310f, -0.78149951f, 0.01741464f, 0.11562496f, -0.38311169f, -0.04487606f, 
    -0.30697432f, 0.09476852f, -0.69149786f, -0.27264455f, 0.18301219f, -0.15130664f, 0.29615933f, 0.23109709f, 
    -0.45770720f, -0.27492592f, 0.09365877f, -0.10340513f, -0.10305245f, -0.59635347f, -0.06167074f, -0.93262869f, 
    -0.89086950f, -0.14389132f, -0.11800051f, -0.39637053f, 0.09864078f, 0.41830760f, 0.25388166f, -0.07575215f, 
    -0.17621337f, -0.09998895f, 0.07357807f, 0.15832745f, -0.22875808f, 0.09732096f, 0.21274379f, -0.17448160f, 
    0.43969899f, 0.06169788f, -1.06081998f, -0.01644834f, 0.24573822f, 0.00086458f, 0.03828578f, 0.07262401f, 
    -0.25434744f, -0.08558976f, -0.75305521f, 0.35462782f, -0.04622621f, -0.01246560f, -0.00427143f, 0.34825218f, 
    -0.02561828f, -0.58699340f, 0.55747813f, -0.11702215f, -0.40156001f, 0.22429787f, -0.48099411f, -0.60995281f, 
    0.17908777f, -0.14210513f, 0.19899791f, -0.39178860f, -0.06799868f, 0.08239930f, 0.04282506f, -0.12943745f, 
    0.19252293f, 0.04653600f, -0.38964659f, 0.04172866f, -0.35111523f, 0.01475739f, 0.17339656f, -0.69155967f, 
    -0.28105628f, 0.15204370f, -0.01176386f, 0.72728115f, 0.07777527f, -0.55420899f, -0.09053493f, -0.13912190f, 
    -0.05081768f, -0.16135055f, 0.28034484f, -0.18415970f, -0.30729473f, 0.22301637f, 0.06900129f, -0.03705402f, 
    0.60821259f, -0.16801821f, 0.28433961f, 0.10803863f, 0.06407962f, -0.04758067f, 0.21398267f, -0.08836006f, 
    -0.12741968f, -0.71049887f, 0.02748220f, 0.22466658f, -0.33620849f, 0.06585996f, 0.05484751f, 0.07397267f, 
    0.22652058f, 0.02689630f, 0.19451277f, -0.19690442f, -0.16007525f, 0.04892121f, -0.09107140f, 0.22130062f, 
    0.19414908f, -0.04925187f, -0.07362568f, 0.50418913f, 0.31976190f, -0.42181480f, -0.01558250f, -0.32836255f, 
    0.25974768f, 0.10500292f, 0.46017185f, 0.34676373f, -0.13187408f, -0.93844444f, 0.42462018f, -0.12082157f, 
    -0.75974643f, 0.01657227f, -0.21744820f, 0.16138886f, 0.16232574f, -0.20240755f, -0.49065238f, 0.06080753f, 
    0.08671422f, -1.14916241f, -0.00618498f, -0.55752879f, 0.00923321f, -0.00924254f, 0.00170497f, -0.34500891f, 
    -0.30841005f, 0.03164342f, -0.00588719f, 0.24887590f, 0.17293778f, 0.19035457f, 0.11757328f, -0.00517497f, 
    -0.19527005f, 0.02478258f, -0.30339450f, -0.20592193f, -0.50941831f, -0.69158739f, -0.66115254f, 0.24572872f, 
    0.45368460f, 0.32039312f, 0.04074322f, 0.29060701f, 0.04842437f, 0.06880008f, 0.17977898f, -0.27673331f, 
    0.00764067f, -0.03855352f, -0.58895171f, -0.06920136f, -0.22826746f, 0.30240986f, -0.23331170f, -0.49309701f, 
    0.40060753f, -0.15964724f, 0.17051607f, 0.19211303f, -0.63423175f, -0.11454365f, -0.22556829f, -0.28995314f, 
    -0.67567307f, -0.67392248f, -0.28779215f, 0.25911146f, 0.10223561f, 0.22840267f, 0.12929207f, -0.25973240f, 
    -0.31897905f, -0.10297179f, -0.16314062f, 0.50594467f, 0.46314552f, -0.21305911f, -0.15223181f, 0.46145812f, 
    0.46640107f, 0.00522971f, 0.01839586f, -0.55593866f, -0.09525786f, 0.00917774f, -0.00121280f, 0.52700341f, 
    0.20870520f, -0.01347448f, -0.31286597f, 0.21272774f, -0.21224751f, 0.12731576f, 0.11409988f, -0.01054859f, 
    -0.64009565f, 0.01160469f, 0.19392844f, 0.30527303f, -0.20822042f, -0.44937626f, -0.03541993f, -0.27548248f, 
    -0.13493045f, 0.04486897f, -0.25940952f, 0.13499479f, -0.51321077f, -0.09892160f, -0.30293709f, 0.04706706f, 
    -0.60900533f, -0.03976502f, 0.46438986f, 0.07643951f, 0.11243097f, 0.24898601f, -0.03364933f, -0.43792188f, 
    -0.16092548f, 0.22261973f, 0.11311693f, -1.15032041f, -0.48083574f, -0.06661069f, 0.22163689f, 0.14806521f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.22647126f, -0.24856292f, -0.20471579f, -0.12258817f, -0.02742968f, 0.30373260f, 0.05551061f, -0.45988637f, 
    -0.15176851f, -0.00551825f, 0.13275801f, -0.01196900f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
