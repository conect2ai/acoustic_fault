#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.90437746f, -0.18516800f, 0.45271429f, 0.85409057f, 0.29201105f, -0.22669406f, 0.37851426f, 0.40543082f, 
    0.02203029f, -0.89418423f, -1.19802582f, -0.25225943f, 0.33434069f, 0.36098605f, -0.19298512f, -0.19528113f, 
    -0.44315574f, 0.26509595f, -0.91194969f, 0.81977355f, -0.35371789f, 0.81604624f, -0.72238541f, 0.04207930f, 
    0.30191028f, -0.20254542f, -0.08350891f, -0.33309188f, -0.44390711f, 0.27040955f, -0.36632189f, 1.00193238f, 
    -0.56927580f, 0.12262207f, 0.11628819f, -0.32873842f, 0.76281065f, 0.80690283f, 0.67657667f, -0.05701210f, 
    -1.08547616f, -0.56834620f, 0.28496119f, -0.21407653f, -0.05029263f, -1.21561408f, 0.69366145f, 0.73152012f, 
    0.75050652f, 0.44592807f, 0.20757981f, -0.35148031f, -0.18165563f, -0.33987570f, 0.99539739f, -0.47658584f, 
    0.18721008f, -0.72376490f, 0.47210747f, 0.62391692f, -0.29293132f, -0.12586977f, -0.08859330f, 1.07979131f, 
    0.73867708f, 0.69020933f, 0.23634821f, 0.13579901f, 0.20060770f, -0.43357953f, 0.05512085f, -0.29259157f, 
    -1.01183474f, 0.76596129f, 0.93695474f, -0.77612495f, 0.53361005f, 0.06574460f, -0.10816324f, 0.14262728f, 
    0.20413944f, 0.02352927f, 0.20287606f, -0.24960415f, 0.42350689f, 1.19361186f, 0.19293779f, -0.46011442f, 
    -0.25829160f, -0.37107533f, 0.23399623f, -0.94373858f, 1.35282707f, 0.32204863f, -0.55007291f, -0.17961714f, 
    -0.02005371f, -0.33357590f, -0.38100186f, 1.05533946f, 0.78401119f, -0.38796833f, -0.09728372f, -0.47656086f, 
    0.19003274f, 0.19811228f, 0.17106916f, 0.45287549f, -0.64228934f, -0.79778075f, -0.33931687f, 0.59994882f, 
    0.96991575f, 0.71265030f, 0.36728173f, 0.51068032f, 0.17440814f, 0.16686405f, 0.80475199f, 0.71427268f, 
    0.11511045f, 0.57699716f, 0.47117323f, 0.24403214f, 0.58975852f, 0.01719651f, -1.08843076f, 0.71718174f, 
    -0.70126331f, -0.18781404f, 0.43266886f, -0.62195939f, -0.24957055f, -0.13968308f, 0.09722195f, -0.31601354f, 
    0.88695061f, -0.63982147f, -0.44625616f, -0.53057462f, -0.75487459f, 0.37248468f, 0.20752475f, -0.34535763f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04103171f, 0.25384754f, -0.13828568f, -0.11524802f, 0.14237137f, 0.02896572f, 0.18873239f, 0.37443540f, 
    0.05554100f, 0.12355561f, 0.08141377f, 0.03552121f, 0.15685779f, 0.07299833f, 0.07071672f, -0.13690327f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05500044f, 0.04076570f, 0.02789974f, 0.04442107f, 0.00147661f, -0.03172517f, -0.02722808f, -0.03451817f, 
    -0.00773245f, 0.02298414f, -0.02569868f, 0.01271338f, 0.01197873f, -0.00439271f, -0.06197926f, -0.04614769f, 
    -0.00238321f, -0.05150549f, -0.00771791f, -0.01876829f, 0.01382809f, -0.04552717f, 0.03993341f, 0.02572875f, 
    0.02075604f, 0.03304912f, 0.00760327f, -0.01510157f, 0.03726851f, -0.01446357f, -0.05712865f, 0.01607077f, 
    -0.01341108f, 0.00533521f, 0.04342456f, -0.00260840f, 0.04490355f, -0.05373623f, -0.05019476f, -0.04502349f, 
    0.00482749f, 0.02954506f, 0.04309946f, 0.04264729f, -0.02777029f, 0.04565552f, 0.03816843f, -0.01359104f, 
    -0.03425704f, 0.05384754f, -0.00202939f, -0.05308596f, 0.02609674f, 0.02373360f, 0.01756257f, 0.03373540f, 
    0.02735863f, 0.03331520f, -0.01248915f, 0.00838718f, -0.03422371f, 0.01379338f, 0.05386351f, -0.05830620f, 
    -0.03325040f, -0.02971438f, -0.05199479f, 0.00048755f, -0.01300288f, 0.04762737f, -0.03365590f, -0.01222678f, 
    0.02158613f, -0.03168475f, -0.04550981f, -0.04554135f, 0.02490713f, -0.06031956f, -0.05917787f, 0.05114871f, 
    -0.01029187f, 0.03654670f, 0.05564691f, -0.03128679f, 0.01342077f, -0.04358130f, -0.01839067f, 0.00605207f, 
    -0.01372046f, -0.01334389f, -0.02907252f, -0.06371459f, -0.03676418f, -0.05041836f, 0.02688024f, -0.01719936f, 
    0.00048586f, 0.03964126f, -0.03229081f, -0.04531960f, 0.02798261f, -0.03136151f, 0.04518849f, 0.01234542f, 
    -0.05351960f, 0.04804274f, 0.00481744f, -0.05032607f, -0.03315650f, 0.03469618f, -0.04800941f, 0.03865129f, 
    0.03044762f, 0.01869590f, 0.03558137f, 0.00311924f, -0.04113799f, 0.00601287f, -0.02633890f, -0.00180825f, 
    0.01022709f, -0.05100468f, -0.00473558f, 0.01045334f, -0.05399669f, -0.03390441f, -0.04158572f, -0.01755134f, 
    -0.00020085f, -0.00450167f, 0.03725437f, 0.04134421f, -0.04038601f, 0.04793065f, -0.04147745f, -0.00195925f, 
    0.02757893f, 0.01076928f, -0.04883954f, -0.04157979f, -0.04038857f, 0.00290805f, 0.02904679f, -0.01725780f, 
    0.00487349f, 0.01765245f, -0.05007074f, 0.04272114f, -0.02419968f, 0.00602644f, 0.03744742f, 0.02981677f, 
    0.02142176f, -0.02850621f, -0.03755582f, 0.04795890f, -0.05521473f, -0.00322417f, 0.03716330f, -0.02404901f, 
    0.01208611f, 0.04697746f, 0.01083947f, -0.01234549f, -0.03736600f, -0.01656363f, -0.02453032f, 0.03225986f, 
    0.04793937f, -0.02357738f, 0.01835679f, -0.03654661f, -0.04248168f, 0.00997430f, -0.04656970f, 0.02958720f, 
    -0.03484523f, -0.01927958f, -0.00451261f, 0.04242180f, -0.02399752f, 0.04641952f, -0.01322696f, -0.05177731f, 
    0.03806888f, -0.05395922f, -0.03091446f, 0.00040766f, 0.01907616f, 0.00279119f, -0.00466445f, -0.03874779f, 
    -0.03014748f, 0.00724680f, -0.00724270f, 0.02259000f, 0.04909650f, 0.02695830f, -0.06104624f, 0.01833307f, 
    -0.03441898f, -0.00548789f, -0.05231267f, -0.04226696f, -0.02281077f, 0.00851802f, -0.01335865f, -0.01517007f, 
    -0.02875459f, -0.00898947f, -0.04159632f, 0.02025976f, -0.05445156f, -0.04538824f, 0.01422636f, -0.01857113f, 
    0.01641225f, -0.04728157f, 0.04749822f, 0.02756825f, 0.01194138f, 0.00264732f, 0.06097972f, -0.01879257f, 
    -0.04075089f, 0.04854035f, 0.02763443f, 0.02951824f, 0.02419146f, -0.00757821f, -0.04628681f, 0.01907830f, 
    0.03180336f, -0.01943067f, -0.03507705f, 0.01688997f, -0.00643579f, -0.05400779f, -0.04018839f, -0.02915503f, 
    0.02134334f, 0.00504651f, 0.04290472f, 0.02097418f, 0.04855363f, -0.05239034f, -0.02259678f, 0.01562185f, 
    0.01514484f, -0.00703390f, -0.00198616f, 0.02640329f, -0.04035219f, 0.01914430f, -0.06237324f, 0.03936256f, 
    -0.02654639f, -0.05788669f, -0.03961194f, -0.04410918f, -0.01631817f, -0.00397270f, 0.03705466f, -0.03538751f, 
    -0.02468273f, 0.00384245f, -0.05059903f, -0.05070665f, 0.01220131f, 0.00885196f, 0.02749510f, -0.05354485f, 
    -0.00390853f, -0.02430457f, -0.05615849f, 0.03435630f, -0.05203711f, -0.01236502f, -0.03701693f, -0.05819612f, 
    0.04532008f, -0.02452127f, -0.03998753f, -0.03538461f, 0.00744836f, -0.06203402f, 0.03042344f, 0.04857927f, 
    -0.04989261f, -0.05518433f, 0.01972052f, 0.03587111f, -0.01232113f, 0.02036227f, -0.04857447f, 0.01353565f, 
    0.00237577f, -0.04503133f, -0.02187244f, -0.04995300f, -0.01084416f, 0.00871969f, 0.01420162f, -0.02857987f, 
    0.01388093f, 0.04051527f, 0.00996103f, 0.05203918f, -0.04648453f, 0.00151387f, 0.01390972f, 0.03605233f, 
    -0.04016969f, 0.00549914f, -0.02641390f, 0.00373174f, -0.00690268f, 0.05202079f, -0.03977488f, 0.00552380f, 
    -0.30483016f, -0.24296185f, 0.08063263f, -0.05271352f, 0.16143885f, -0.10052593f, -0.00036713f, -0.14174579f, 
    -0.04021964f, 0.05166378f, 0.01274646f, 0.03209294f, -0.07207383f, 0.05300407f, 0.00401002f, -0.07931575f, 
    -0.03710631f, 0.10913103f, -0.05309470f, 0.16348648f, 0.44751269f, 0.14096993f, 0.23963602f, 0.00761255f, 
    0.11266919f, -0.04231307f, -0.21363364f, 0.08396438f, -0.01465124f, 0.04191393f, 0.03579063f, 0.00136206f, 
    -0.06776129f, 0.10647640f, 0.00254342f, -0.04651577f, -0.05064058f, -0.08049734f, 0.02859783f, 0.00174177f, 
    0.20483862f, 0.58239871f, -0.28138530f, -0.00547207f, 0.19920996f, 0.17073935f, -0.04941583f, -0.07317077f, 
    0.00696185f, -0.20439018f, -0.05496075f, -0.09646280f, -0.04423043f, 0.21480787f, 0.14498761f, -0.06915450f, 
    -0.01839091f, 0.03604859f, 0.07695448f, 0.09479982f, 0.54564738f, -0.03257392f, -0.02166578f, 0.09490078f, 
    -0.08432021f, -0.17061985f, 0.22528192f, 0.03350852f, -0.13268542f, 0.10111934f, 0.05369407f, 0.22294620f, 
    0.06840167f, 0.06610068f, 0.10502964f, 0.08128794f, 0.07267079f, -0.09145220f, 0.06981808f, 0.01286721f, 
    -0.36317176f, 0.04546749f, -0.00410405f, -0.00374971f, 0.07747276f, 0.12391543f, -0.04916924f, 0.08640996f, 
    0.01743103f, -0.06803748f, -0.01175717f, 0.10642390f, 0.03670002f, -0.11208499f, -0.19318438f, 0.01024614f, 
    0.04013116f, -0.18208243f, -0.07664187f, -0.02980859f, 0.38736758f, 0.02771073f, -0.50816870f, 0.03090454f, 
    0.23217088f, 0.03384366f, 0.08182193f, -0.08291910f, -0.05787449f, 0.23524266f, 0.01692650f, 0.16255975f, 
    -0.04905785f, -0.01861694f, 0.12360516f, 0.01314492f, 0.00198647f, 0.05124122f, -0.09228024f, -0.03707769f, 
    0.17476849f, -0.24637993f, -0.01070985f, -0.06714001f, 0.14475037f, -0.03827280f, -0.15249132f, 0.14371955f, 
    0.18203013f, -0.08362260f, 0.06219945f, 0.06254248f, -0.13878790f, -0.00690501f, 0.00062499f, 0.01772825f, 
    0.00809096f, 0.01033776f, -0.02423176f, -0.09299528f, -0.34362131f, -0.02925585f, -0.08560292f, -0.06779533f, 
    0.07520413f, 0.01763791f, 0.06999664f, 0.03191611f, 0.05038580f, 0.09059148f, 0.04801362f, -0.02632066f, 
    -0.14127706f, -0.00596167f, 0.07830711f, -0.02462133f, 0.10271395f, -0.05664491f, -0.02600935f, -0.03391581f, 
    0.10139737f, 0.15805176f, -0.03381597f, -0.18494780f, 0.04798526f, 0.11952721f, 0.03887375f, 0.20584720f, 
    0.06245589f, 0.11813071f, -0.08296034f, -0.08740675f, -0.01025036f, -0.14230318f, -0.14744055f, 0.05954137f, 
    0.13654855f, -0.00952543f, -0.07465479f, 0.02687407f, 0.14896257f, -0.16379660f, -0.00601246f, 0.17354828f, 
    0.07515739f, 0.01982830f, -0.04467085f, -0.23626609f, 0.12375541f, -0.01433094f, -0.13350400f, -0.05343341f, 
    0.02178636f, 0.10088176f, 0.02355510f, -0.12955540f, 0.01902092f, 0.08723171f, -0.09945571f, 0.01091796f, 
    -0.39494002f, 0.04064167f, 0.16986859f, -0.12754841f, -0.03535572f, -0.02663236f, 0.00381818f, 0.04780009f, 
    -0.10064156f, 0.06618437f, 0.02700702f, 0.00282079f, 0.06139648f, 0.02619007f, -0.01936636f, 0.01695003f, 
    -0.10279441f, -0.01614417f, 0.07900812f, 0.07341512f, -0.31542656f, -0.18988672f, -0.20687929f, -0.11161995f, 
    0.02115612f, 0.09625590f, -0.05093570f, 0.06628375f, 0.13980681f, -0.11697570f, 0.12849717f, 0.28419122f, 
    0.13327691f, -0.04682082f, -0.05247678f, -0.06968592f, 0.07248131f, 0.17788622f, 0.00031196f, -0.10093383f, 
    0.74366647f, -0.18254031f, 0.31081858f, 0.28866085f, 0.12467907f, -0.14559720f, -0.00365420f, -0.01512600f, 
    0.02772147f, 0.00378384f, -0.04604554f, -0.03965056f, -0.15120780f, 0.11184483f, -0.03670761f, 0.01783986f, 
    0.05382745f, -0.04694423f, -0.06335215f, -0.04490581f, -0.01332149f, 0.27548105f, -0.11715937f, 0.21252476f, 
    0.19506457f, -0.07036982f, 0.00917351f, 0.08734569f, 0.00180877f, -0.07603045f, 0.11304360f, 0.14653991f, 
    0.03330287f, -0.10237010f, -0.10472331f, 0.03147975f, -0.10724115f, 0.02901975f, -0.08888558f, -0.02950497f, 
    -0.19893481f, 0.33465269f, -0.32425401f, 0.08105319f, 0.22936270f, 0.18483356f, -0.06448064f, -0.10359918f, 
    0.12116073f, 0.15716510f, -0.05986685f, 0.07680860f, 0.01057611f, -0.03785226f, 0.07633632f, -0.01329314f, 
    0.02883388f, 0.09498908f, 0.07981423f, -0.12180236f, -0.06541904f, 0.29149535f, -0.39900318f, -0.29797801f, 
    -0.06855110f, 0.11551055f, 0.04129743f, 0.09768641f, -0.19426984f, -0.08256759f, 0.04425705f, 0.01961750f, 
    0.31660685f, -0.02271494f, -0.07981273f, -0.15044999f, -0.03978594f, 0.05762120f, 0.12380223f, 0.10551944f, 
    0.00454081f, -0.00774908f, 0.02904745f, -0.05125486f, 0.01069170f, 0.01210268f, 0.04508336f, -0.01997989f, 
    -0.02025929f, 0.02108120f, -0.03846386f, -0.01961997f, -0.04852000f, 0.00136847f, -0.05786065f, -0.03185220f, 
    -0.05773281f, 0.03264606f, 0.03892589f, 0.00050205f, 0.00555810f, -0.03136373f, -0.06017974f, 0.00477117f, 
    -0.01173026f, 0.04767224f, -0.03941796f, 0.01943052f, 0.04816320f, 0.04607164f, 0.01340922f, 0.02839161f, 
    0.04646952f, 0.04943902f, 0.03202952f, 0.00930875f, -0.01410188f, 0.04184853f, 0.01630952f, 0.00075141f, 
    0.02162372f, 0.04803129f, 0.01686620f, -0.02027820f, 0.03946140f, 0.00198062f, -0.01205594f, 0.02884525f, 
    -0.05451844f, -0.03192786f, 0.00617765f, 0.00782795f, -0.01279551f, -0.03341820f, -0.03676394f, -0.02708138f, 
    0.02646791f, -0.00529194f, 0.04025156f, -0.04428894f, 0.03515729f, 0.02611094f, -0.00863953f, -0.01118159f, 
    -0.02010032f, -0.01249180f, 0.04247677f, -0.05466358f, 0.03975513f, -0.01271237f, -0.02887803f, -0.03879398f, 
    -0.03076067f, 0.00084394f, 0.02409652f, -0.03318702f, 0.01152630f, 0.00000368f, 0.01265647f, -0.02844073f, 
    -0.04263739f, 0.02758175f, -0.00451273f, 0.03318566f, 0.01744667f, -0.01984576f, -0.03304999f, -0.00920540f, 
    -0.02134105f, -0.01746526f, -0.00221558f, 0.01786634f, -0.04162212f, -0.05051800f, -0.05306203f, -0.03096319f, 
    0.04962718f, -0.01520367f, -0.00105687f, -0.04611073f, -0.03946659f, 0.03681827f, -0.05177226f, -0.01046239f, 
    -0.03759215f, -0.05623646f, 0.04901586f, 0.03564238f, -0.01180628f, -0.01359568f, 0.02804211f, 0.00660287f, 
    -0.04124719f, 0.01518431f, -0.02767850f, 0.04544443f, 0.01329191f, 0.01442168f, 0.00586543f, -0.03452531f, 
    0.01334998f, -0.00603809f, -0.05555143f, 0.01375068f, -0.06180577f, -0.03847259f, -0.02758327f, -0.02925787f, 
    0.00131228f, -0.02958602f, 0.01465873f, -0.00326819f, -0.03105680f, 0.04452164f, 0.02270843f, -0.02297925f, 
    0.03409111f, -0.03379907f, 0.01312584f, 0.00160376f, 0.02618447f, -0.04902271f, -0.00681799f, -0.03706891f, 
    -0.05474834f, -0.02560294f, -0.01939787f, -0.02587293f, -0.02643476f, 0.00291117f, -0.04596160f, 0.04419683f, 
    -0.05366981f, 0.02726268f, -0.01984060f, -0.03690236f, -0.01102487f, 0.03646554f, -0.05839838f, -0.05045575f, 
    0.00830881f, 0.03348937f, 0.01117499f, 0.02381907f, 0.03262609f, -0.06114602f, -0.05985555f, -0.04314836f, 
    0.02168156f, 0.03048063f, 0.00035813f, 0.02510471f, -0.00111408f, -0.02698294f, -0.05254871f, -0.05100129f, 
    -0.04105615f, 0.02215622f, -0.02391219f, -0.04294591f, -0.00731195f, 0.04113686f, -0.05781271f, 0.00508164f, 
    0.01665081f, -0.04265084f, 0.03199976f, -0.06143938f, -0.00982047f, -0.05128130f, -0.05454831f, 0.04610697f, 
    -0.02203983f, -0.05018070f, 0.00178327f, -0.05918979f, 0.02997493f, -0.04084478f, -0.02826495f, 0.04504409f, 
    -0.01926643f, -0.04004149f, 0.03804288f, -0.00197141f, -0.05842574f, 0.00195891f, -0.03057292f, -0.02172865f, 
    -0.01719990f, -0.01074822f, -0.05773095f, -0.01980635f, -0.04854346f, 0.01089185f, 0.01244002f, -0.06007292f, 
    -0.03663718f, -0.05863338f, -0.05267706f, -0.02049788f, 0.01468653f, -0.02380534f, 0.03568992f, 0.04477562f, 
    0.00931789f, 0.03402382f, 0.00491698f, -0.00534032f, -0.05655106f, 0.03995422f, 0.01134564f, 0.02007553f, 
    -0.02544447f, -0.03678668f, 0.01071540f, 0.04925209f, 0.00190585f, 0.00501931f, -0.00150391f, -0.00334920f, 
    0.01260241f, 0.04109552f, 0.00516274f, -0.04625574f, -0.05087870f, -0.03817412f, -0.05545538f, -0.05752378f, 
    -0.06111522f, 0.01151280f, 0.01528314f, -0.05950775f, -0.02784856f, -0.00935735f, -0.03081554f, -0.05716473f, 
    0.04252717f, -0.01061780f, -0.01776639f, -0.01888849f, -0.04289005f, 0.01409214f, 0.03528368f, -0.03353309f, 
    -0.02083416f, 0.00288686f, -0.04491685f, -0.01573758f, 0.03188997f, -0.03795747f, -0.05314595f, -0.04867426f, 
    -0.01608080f, -0.05815655f, -0.04951030f, -0.04637822f, 0.03033710f, -0.04180034f, -0.04957456f, -0.01588192f, 
    -0.03245719f, -0.04634060f, 0.02024732f, 0.04018095f, 0.04759179f, 0.04804884f, -0.00239642f, -0.01712660f, 
    0.00195789f, -0.00839486f, -0.01253401f, -0.00692258f, 0.03415198f, -0.00389833f, -0.00930029f, -0.04280370f, 
    -0.06079279f, 0.02021146f, -0.04575146f, 0.01441207f, 0.04893617f, 0.00349789f, -0.04657280f, 0.00586193f, 
    0.01570519f, -0.05926605f, -0.01917485f, -0.03690466f, -0.05537957f, -0.00027760f, -0.02261639f, -0.05981641f, 
    0.04549459f, 0.00804938f, 0.04165906f, 0.02714873f, 0.03707465f, 0.00971931f, 0.03382812f, -0.00003874f, 
    -0.13198912f, -0.22867776f, -0.08173097f, -0.27564433f, 0.05399608f, -0.06406470f, -0.07404666f, 0.06759299f, 
    -0.03482240f, 0.01213188f, -0.02770023f, -0.06649320f, -0.04171357f, -0.06116734f, 0.01503096f, 0.03412589f, 
    -0.24457400f, 0.04205792f, -0.39516646f, -0.06891488f, 0.27095905f, 0.07482065f, 0.18221816f, -0.01085650f, 
    0.22556457f, -0.16818365f, -0.11371963f, -0.04499419f, 0.20374434f, -0.05531774f, 0.00798417f, -0.11799098f, 
    -0.08668546f, 0.09726754f, 0.00685683f, -0.02258600f, 0.00729642f, 0.09282613f, 0.06504088f, 0.22926407f, 
    0.64711589f, 0.15209846f, -0.11467838f, 0.01407983f, 0.15202411f, 0.01333509f, 0.01305249f, -0.11296838f, 
    0.12343725f, -0.07317418f, -0.09172046f, -0.12782779f, -0.11089016f, 0.03484569f, -0.04356825f, 0.18513165f, 
    0.06116581f, 0.00256601f, -0.16531853f, 0.00567866f, 0.20960794f, 0.16974309f, 0.26799554f, -0.13928606f, 
    -0.20130309f, -0.05831712f, 0.10067040f, 0.02313705f, 0.15057375f, 0.02913955f, -0.12845089f, 0.19815810f, 
    0.01537659f, 0.04891092f, 0.05122768f, 0.16495433f, -0.00125903f, -0.12813215f, 0.06249956f, -0.19229040f, 
    0.25396803f, -0.05832584f, 0.04730741f, 0.08674479f, 0.21178381f, -0.03229166f, 0.09932619f, -0.07213150f, 
    -0.08545782f, -0.00621548f, -0.00880026f, 0.16525081f, -0.07774394f, -0.03961847f, -0.12421726f, 0.04931113f, 
    0.05974008f, 0.10939607f, -0.02625503f, 0.05108957f, 0.59805310f, 0.08795686f, -0.27530688f, -0.20063290f, 
    0.27757597f, -0.09120456f, 0.16407160f, -0.00772790f, 0.09849166f, 0.07640171f, -0.04833421f, -0.01891602f, 
    0.05412318f, 0.31059289f, 0.09508102f, 0.15132017f, 0.06763124f, -0.38921708f, -0.29070988f, 0.12853383f, 
    -0.10316885f, 0.26444724f, -0.06798485f, -0.13857755f, 0.10478316f, 0.04990014f, -0.08030597f, 0.20628703f, 
    -0.03249963f, -0.01767168f, -0.15283638f, 0.03122413f, 0.14330752f, 0.11433671f, 0.06722315f, 0.03872674f, 
    0.08963800f, -0.28642845f, -0.18246518f, -0.11233244f, 0.07126121f, -0.03406943f, -0.17565952f, -0.32441252f, 
    0.04675132f, -0.02249270f, 0.05058561f, 0.01872435f, -0.02617906f, -0.03363591f, 0.06412496f, 0.03246995f, 
    0.07471241f, 0.14667912f, -0.07283469f, -0.04532215f, 0.03358769f, -0.20219146f, -0.23275919f, -0.04963337f, 
    0.23595299f, 0.33635581f, -0.05103705f, -0.01353620f, 0.20171829f, -0.07342558f, 0.20093109f, -0.03320814f, 
    0.00547721f, 0.05834358f, -0.20640434f, 0.06388012f, -0.05963136f, -0.08758105f, -0.00550269f, 0.17200497f, 
    0.07461520f, -0.25483996f, 0.15128449f, 0.03502253f, -0.10395719f, -0.05466704f, 0.11366192f, -0.01673699f, 
    0.03984493f, -0.03790476f, -0.10458623f, 0.16986355f, 0.17470193f, 0.17979340f, -0.08630132f, -0.10267682f, 
    0.14030401f, 0.35724074f, 0.05905053f, -0.02461690f, -0.00236274f, -0.13268289f, -0.10672822f, 0.03794354f, 
    0.09537663f, -0.16170833f, 0.00441938f, -0.13266823f, 0.05579427f, -0.14016883f, 0.06375897f, -0.14404182f, 
    -0.09715832f, -0.04926199f, -0.07209996f, 0.04933618f, -0.03580261f, 0.12229694f, -0.02719674f, 0.05371966f, 
    0.08901224f, -0.18634571f, -0.03521331f, -0.00982237f, 0.16054647f, -0.14186575f, -0.03040381f, -0.07674024f, 
    0.11906524f, 0.06916325f, -0.13424645f, 0.24344236f, -0.15130019f, -0.21079800f, -0.11739568f, 0.17464100f, 
    0.11227588f, -0.07874348f, -0.04569874f, 0.00857825f, -0.02767105f, 0.22685091f, -0.11220390f, -0.05158477f, 
    0.37794921f, 0.27072144f, 0.44540876f, -0.11865649f, 0.09771883f, -0.02527489f, 0.06684603f, -0.05493312f, 
    0.02851642f, 0.03021011f, -0.12271381f, -0.06916966f, -0.05035881f, 0.06773838f, -0.02877879f, 0.02653998f, 
    -0.08085600f, -0.12657583f, -0.07669293f, 0.03112160f, 0.18338837f, -0.06642108f, -0.20259272f, -0.25083193f, 
    0.13993908f, -0.18290003f, 0.12436505f, 0.13817540f, -0.12334075f, 0.01563412f, 0.04594775f, -0.02036818f, 
    0.06762874f, -0.12441649f, -0.03480176f, 0.20513654f, -0.13043441f, -0.36188546f, 0.02908444f, -0.00688289f, 
    0.39597514f, 0.12151309f, -0.33666000f, -0.11514428f, -0.00040796f, 0.00596686f, -0.04941771f, -0.19594431f, 
    0.03422175f, -0.02350466f, -0.04431072f, 0.01892483f, -0.12607193f, 0.09647115f, 0.18161368f, 0.15205796f, 
    0.13852105f, -0.00260366f, 0.17697766f, -0.09429887f, 0.03754026f, -0.05193809f, 0.04630705f, -0.27189794f, 
    -0.20369999f, 0.07696249f, 0.11920652f, 0.05925324f, -0.33056584f, -0.01358104f, 0.06237404f, 0.12075701f, 
    0.03510653f, -0.12790631f, -0.09437951f, 0.10781837f, 0.09328707f, 0.25073209f, 0.24824587f, 0.08034526f, 
    -0.02706633f, 0.01211439f, 0.02329459f, -0.04709463f, -0.01779960f, -0.02279394f, -0.05417447f, 0.01748747f, 
    0.03131137f, 0.01374368f, 0.02837068f, -0.05303049f, 0.04525318f, -0.03196468f, 0.01359401f, 0.04291477f, 
    0.00711918f, 0.05185992f, -0.02145250f, -0.05859302f, 0.03987629f, 0.01063280f, 0.03930341f, -0.05260776f, 
    -0.03640016f, -0.01870579f, -0.00231880f, 0.03361623f, -0.03403808f, 0.01860134f, 0.01098636f, -0.05146892f, 
    -0.05388431f, 0.02399493f, -0.04108076f, 0.03393441f, -0.03732220f, 0.02037488f, -0.04375859f, -0.00038001f, 
    -0.05982789f, 0.04983435f, -0.05555337f, -0.01742125f, 0.00096433f, -0.04303835f, 0.03299117f, 0.04872607f, 
    0.00151767f, 0.00766332f, -0.02113461f, -0.04347857f, -0.04797816f, 0.00966323f, 0.04650067f, -0.04160371f, 
    0.02918885f, 0.03736945f, -0.00192195f, 0.02779956f, 0.02102179f, -0.02335951f, 0.03936910f, 0.02366362f, 
    -0.05701999f, -0.02302370f, -0.02987032f, -0.00533227f, 0.01297211f, 0.04371044f, 0.04177469f, -0.00356112f, 
    -0.01501810f, -0.03489734f, -0.05573702f, -0.00274927f, -0.01843631f, -0.05618357f, -0.05785686f, 0.03025829f, 
    0.02790930f, -0.00907802f, 0.02114398f, -0.01390545f, -0.04611678f, -0.05749917f, -0.00164582f, -0.04837942f, 
    0.03001595f, 0.00043020f, 0.04787805f, 0.03801930f, -0.02514109f, -0.01319323f, 0.03524693f, -0.04072861f, 
    0.00950320f, 0.00276458f, -0.03761559f, -0.02201628f, -0.00858694f, -0.00405591f, -0.00302283f, -0.02815483f, 
    0.01791142f, -0.02815006f, 0.02075405f, 0.04186232f, 0.03481111f, -0.00501188f, 0.03927894f, -0.05728598f, 
    0.00772082f, 0.04336646f, 0.00491160f, 0.04148630f, 0.03858293f, -0.05242474f, 0.00881697f, 0.00867896f, 
    0.01167630f, -0.03513244f, 0.04833823f, -0.00717102f, 0.03275479f, 0.03427985f, -0.01225712f, -0.04084821f, 
    -0.03510929f, -0.01382770f, 0.00929922f, 0.01101840f, -0.04533884f, 0.02345573f, 0.01859726f, -0.03277294f, 
    -0.05280603f, -0.00305008f, -0.04446750f, -0.01734030f, 0.01649189f, 0.00442320f, 0.05082861f, 0.00471629f, 
    -0.02887019f, -0.05960989f, -0.04737995f, -0.05523363f, -0.04477046f, 0.00706550f, -0.03815946f, -0.05929816f, 
    -0.00361709f, -0.03010584f, -0.02468363f, 0.02919587f, -0.02783734f, -0.03707052f, 0.03360206f, -0.05762208f, 
    -0.02975466f, -0.01633820f, -0.00659507f, -0.03603462f, -0.05128362f, -0.04855115f, 0.02256841f, -0.04218579f, 
    0.04196222f, -0.05079705f, -0.05713760f, 0.03716912f, -0.05000656f, -0.04567247f, -0.06111968f, 0.01007925f, 
    -0.01258665f, -0.04669524f, -0.00033527f, 0.05318001f, 0.01200410f, -0.00962156f, -0.02246528f, -0.02800157f, 
    -0.02285126f, -0.04284627f, -0.04833199f, 0.00399366f, 0.04384509f, 0.00930220f, -0.04966983f, 0.01497302f, 
    -0.02567604f, 0.04684719f, 0.01298519f, -0.02116328f, -0.03054043f, -0.03218907f, -0.03430735f, 0.01544240f, 
    -0.05467002f, 0.02232801f, -0.01482512f, -0.03397923f, 0.02507644f, -0.05875134f, 0.01255187f, 0.02835538f, 
    0.02420476f, -0.04498936f, -0.04460438f, -0.00719204f, -0.00883497f, 0.04269805f, 0.00980432f, -0.02272099f, 
    -0.01882107f, -0.03364514f, -0.03067673f, -0.01417398f, -0.01463643f, -0.02835502f, 0.02184764f, -0.03617491f, 
    -0.01002701f, -0.00207225f, -0.01741851f, 0.01228078f, 0.04391414f, 0.02812879f, 0.00814524f, -0.04108963f, 
    -0.00442817f, -0.01521712f, 0.02395955f, 0.04368972f, -0.01036079f, 0.01566466f, 0.01091240f, 0.02986657f, 
    -0.06106346f, 0.04666755f, 0.00330404f, 0.02679160f, 0.04247909f, -0.01887442f, -0.05441774f, 0.00528752f, 
    -0.03521059f, -0.06362104f, 0.01210678f, -0.04393684f, -0.01630282f, 0.02543321f, -0.02157309f, -0.04897297f, 
    0.01303702f, -0.03573234f, 0.02947525f, 0.02395723f, -0.01956631f, 0.01299983f, 0.00087716f, 0.00026602f, 
    -0.04102664f, 0.00928609f, 0.00709175f, 0.03846949f, 0.02404844f, -0.04737611f, 0.00976487f, -0.01148298f, 
    0.04337663f, -0.04626427f, -0.02479750f, -0.00577597f, -0.05851583f, 0.00848262f, -0.06237382f, -0.02651336f, 
    -0.03701624f, -0.03522195f, 0.01067681f, 0.03110885f, -0.00671923f, -0.05031909f, 0.02022571f, 0.04001074f, 
    -0.02325740f, -0.00666891f, 0.04778431f, 0.02828424f, -0.06214434f, -0.05755820f, 0.04384740f, -0.02724565f, 
    -0.02767324f, -0.00707261f, -0.05615804f, 0.00193622f, 0.01378218f, -0.01867225f, -0.01906342f, -0.00723246f, 
    0.01378987f, 0.01652941f, 0.02750411f, -0.03486183f, -0.01910574f, 0.02608917f, 0.00898347f, -0.04322695f, 
    0.01065639f, -0.01426508f, 0.03083014f, 0.02912127f, -0.04179136f, -0.03177116f, 0.03464314f, -0.01132736f, 
    0.03857776f, -0.00514630f, -0.03168194f, -0.02741258f, 0.02251308f, -0.02409478f, -0.04466464f, -0.03768678f, 
    -0.00905420f, 0.02856353f, -0.03649403f, 0.05012461f, 0.02645721f, -0.02130032f, -0.02771441f, 0.02605619f, 
    -0.02732394f, 0.00279376f, -0.04343245f, 0.03872508f, -0.04626186f, -0.03127929f, 0.01839804f, 0.02361276f, 
    -0.01008350f, -0.02193458f, -0.04541370f, 0.03155817f, -0.00159035f, -0.03083483f, -0.02885924f, 0.02918535f, 
    -0.00378012f, 0.03158482f, 0.01634906f, -0.02873294f, -0.03299169f, -0.05930667f, -0.01540402f, -0.03789420f, 
    0.04461520f, -0.02184724f, -0.02750378f, 0.04709031f, -0.00797616f, -0.00026503f, -0.02017942f, 0.02162602f, 
    0.02363158f, 0.00370894f, 0.02038276f, -0.04833272f, 0.01090691f, -0.00584583f, 0.03142424f, 0.02159834f, 
    -0.03281287f, -0.02686246f, -0.03511263f, -0.00670289f, 0.03536989f, 0.02032714f, 0.00652184f, 0.05032277f, 
    0.00894145f, 0.03899625f, -0.04478830f, -0.04654311f, 0.02126682f, -0.04834665f, -0.05478019f, -0.00425985f, 
    -0.01528701f, 0.03270450f, 0.00182804f, -0.03366374f, 0.02071689f, -0.00911449f, -0.00648868f, -0.01591141f, 
    -0.05759961f, -0.00371733f, -0.04741742f, -0.03701599f, -0.03493178f, 0.01144459f, 0.03213823f, -0.03424574f, 
    -0.02849250f, 0.00182884f, -0.02944616f, -0.05163766f, -0.03953185f, -0.03231821f, -0.03800312f, 0.01314806f, 
    -0.03194612f, -0.04599999f, 0.04316414f, 0.04151154f, -0.05286385f, -0.05901576f, 0.03151568f, -0.00390013f, 
    -0.03188046f, 0.04515750f, 0.04571242f, 0.02699377f, 0.01512985f, 0.01024328f, 0.02792798f, -0.02812054f, 
    -0.04998071f, 0.02755310f, -0.02472654f, -0.02130870f, 0.00266923f, -0.02013293f, 0.04481294f, 0.02605732f, 
    -0.03829274f, 0.01845767f, -0.05068099f, -0.05477087f, 0.01299649f, -0.03986317f, -0.03677933f, 0.01992530f, 
    0.02033386f, 0.01908179f, 0.00500812f, -0.05107939f, -0.04589256f, -0.01689114f, -0.01430623f, 0.04450419f, 
    0.00585528f, -0.00731566f, -0.02496110f, 0.00522380f, 0.01155469f, 0.03239800f, 0.00111046f, -0.05303260f, 
    -0.03652835f, 0.04538014f, -0.05795498f, -0.04848714f, -0.04343308f, 0.00553679f, -0.00521802f, -0.02718383f, 
    -0.00612353f, 0.01459622f, -0.00255060f, -0.05836195f, 0.03847726f, -0.00363221f, -0.04993868f, 0.04680835f, 
    0.03797285f, -0.01567925f, 0.04733085f, 0.02222354f, -0.05511803f, 0.01934299f, -0.01323499f, -0.03431843f, 
    -0.03178096f, -0.02973943f, -0.02718753f, -0.03865921f, 0.02771704f, -0.01020029f, 0.02125319f, 0.00028250f, 
    -0.02763029f, 0.01778295f, 0.04637605f, 0.04528579f, -0.01871884f, 0.02631138f, -0.04746404f, -0.01980362f, 
    0.03552558f, -0.00723155f, -0.02912653f, 0.00618710f, -0.01072895f, 0.00547837f, 0.01381673f, 0.00884215f, 
    0.03084046f, 0.04847951f, -0.03046871f, 0.00710356f, 0.00709524f, 0.00974914f, -0.01633032f, -0.02866220f, 
    0.01865114f, 0.03400972f, 0.00322151f, 0.04148401f, 0.02971304f, 0.03238972f, 0.03181907f, 0.02731229f, 
    0.00991053f, 0.03043529f, -0.03665027f, -0.03033232f, -0.00083222f, 0.00606107f, -0.04236759f, -0.05778702f, 
    -0.01487384f, 0.00086605f, -0.01319582f, 0.03471506f, 0.03295244f, -0.01706085f, 0.03274291f, 0.03462306f, 
    -0.06102043f, -0.00383218f, -0.00755486f, -0.04653293f, 0.00861007f, -0.04894406f, 0.03232252f, 0.04008578f, 
    0.00532284f, -0.05755397f, -0.02892668f, -0.03142335f, -0.04030435f, -0.02802534f, 0.03433633f, 0.04419206f, 
    -0.02534886f, -0.03561121f, -0.04729931f, -0.00692451f, -0.04108052f, -0.04751680f, -0.01813493f, -0.04036130f, 
    -0.02145400f, -0.05913136f, -0.03983438f, 0.02477362f, 0.00438531f, -0.02455772f, -0.05648271f, -0.04921565f, 
    -0.02164327f, 0.04733509f, -0.03657852f, -0.05463839f, 0.02242163f, 0.02204932f, -0.00800654f, -0.00619363f, 
    -0.00119919f, 0.00730302f, 0.02021972f, -0.04845172f, 0.00569413f, 0.03779315f, -0.01553189f, -0.03824838f, 
    0.04907009f, 0.01677000f, -0.03062587f, -0.04579283f, -0.04476654f, 0.04771242f, -0.05235016f, -0.03319010f, 
    0.00469513f, 0.03572961f, 0.00883001f, 0.04498642f, -0.03415719f, -0.04661168f, -0.00623206f, -0.04708685f, 
    -0.03532499f, 0.04752010f, -0.04559357f, -0.04358682f, -0.01272541f, 0.03403322f, -0.03893832f, -0.01375472f, 
    0.03426379f, -0.02408642f, -0.05827708f, 0.04979375f, 0.01867728f, -0.03303770f, -0.01942550f, 0.03770501f, 
    -0.03025126f, -0.00002492f, 0.02983857f, 0.02474704f, 0.00275174f, 0.00836214f, -0.02117280f, -0.05277352f, 
    -0.04914071f, 0.00475979f, 0.04554289f, 0.03362842f, -0.04050164f, -0.03840388f, -0.01722807f, -0.00333848f, 
    0.10897300f, 0.16904587f, 0.02855165f, -0.36740258f, -0.03721422f, 0.03361764f, 0.01815024f, -0.13703069f, 
    -0.04598451f, -0.17113499f, -0.05364898f, -0.08155514f, 0.03575907f, 0.01845369f, -0.00041578f, 0.08847424f, 
    -0.01656063f, 0.12354644f, 0.06609686f, 0.12356344f, 0.28142771f, 0.27811733f, 0.06843740f, 0.48164961f, 
    0.00260453f, 0.12413734f, 0.05928669f, -0.01282460f, 0.12022809f, 0.21969865f, -0.12815754f, 0.12672506f, 
    -0.09584650f, 0.06875049f, 0.05940028f, -0.00392002f, 0.04747097f, -0.01756412f, 0.24568374f, -0.10526477f, 
    -0.16354360f, 0.05037308f, 0.10236205f, -0.10327960f, -0.00388695f, 0.20469271f, -0.02050987f, 0.08906173f, 
    -0.04492787f, -0.03153498f, 0.08609819f, 0.10302342f, -0.03187775f, 0.03906825f, 0.18870044f, -0.02349358f, 
    -0.00173157f, 0.04448316f, 0.05534153f, -0.01733661f, -0.16876565f, -0.00886140f, 0.27437860f, -0.05162268f, 
    0.03173557f, -0.24211776f, 0.03463743f, -0.07674961f, -0.01193971f, 0.29053193f, 0.28637266f, 0.17331509f, 
    -0.04344760f, 0.04143088f, 0.13210870f, -0.06840965f, -0.00123386f, -0.07704233f, 0.12342767f, 0.01554367f, 
    -0.29620215f, -0.20774272f, 0.17007722f, -0.24107675f, 0.14474095f, -0.10668055f, -0.16424504f, -0.14988072f, 
    -0.04186169f, 0.01258553f, -0.10461509f, -0.02648777f, 0.07681844f, -0.04371121f, 0.01115687f, 0.01780954f, 
    0.01197059f, -0.08940329f, 0.01532931f, -0.03648591f, 0.02421415f, 0.26877877f, 0.02948782f, 0.04524204f, 
    0.36621395f, 0.14409471f, -0.01694789f, 0.10627080f, -0.02028613f, 0.07332175f, -0.05202680f, 0.11172289f, 
    0.09324583f, 0.07620142f, 0.01777465f, -0.07594607f, -0.12217832f, -0.07277077f, 0.03259555f, -0.14254606f, 
    0.27559119f, -0.23493376f, -0.24821258f, -0.12719359f, -0.15408592f, -0.29637480f, 0.08793478f, -0.05312409f, 
    0.00042506f, -0.11066910f, -0.03201707f, 0.02897507f, -0.10082196f, -0.02164726f, -0.04547974f, -0.03899672f, 
    -0.15416770f, 0.13785824f, -0.10944079f, 0.10275810f, 0.40741640f, -0.17813632f, -0.07379739f, -0.26674885f, 
    0.22616957f, -0.11507288f, -0.15395160f, -0.11345121f, -0.00673592f, -0.07773118f, 0.00294620f, -0.06055871f, 
    -0.13364105f, 0.03806638f, -0.06322106f, 0.14469521f, 0.03186750f, -0.02514643f, -0.05518618f, 0.01676926f, 
    -0.16660829f, -0.26797006f, 0.03123318f, -0.15196191f, 0.20653577f, -0.03389947f, 0.10974269f, 0.01043310f, 
    -0.02112461f, -0.00789861f, -0.00966032f, -0.07693759f, 0.24366602f, 0.07967763f, -0.13533023f, 0.09513684f, 
    0.09455120f, -0.08576103f, -0.10480333f, 0.10304751f, -0.00955721f, 0.29953656f, 0.10494707f, -0.06397343f, 
    0.24504095f, 0.08529532f, -0.01342422f, -0.04094276f, 0.00252019f, -0.04851508f, 0.10071060f, 0.20623374f, 
    -0.02216677f, -0.20924959f, 0.07539169f, -0.06947983f, 0.07976609f, 0.05174846f, 0.14420187f, 0.03134124f, 
    0.15607156f, 0.09293855f, 0.14804311f, -0.09697285f, -0.49403989f, -0.05687099f, -0.09965854f, 0.07052063f, 
    -0.09719760f, 0.01101452f, 0.01191696f, 0.07742902f, 0.00328740f, 0.06466087f, -0.04121254f, 0.05976732f, 
    -0.04021836f, -0.00703482f, -0.08195548f, -0.02229050f, 0.11000818f, -0.17257294f, 0.28038818f, -0.27557361f, 
    0.03156240f, -0.09255838f, -0.13914418f, -0.12006555f, 0.07397663f, -0.09004959f, -0.02933807f, 0.01024864f, 
    -0.04455006f, 0.14792009f, -0.01697225f, -0.05995589f, -0.01230494f, 0.04083829f, 0.09333497f, -0.01466442f, 
    0.36659464f, 0.45881745f, -0.07055555f, 0.23881851f, -0.07838260f, 0.06170340f, 0.08657271f, 0.02394070f, 
    0.05430017f, 0.18317962f, -0.06337902f, 0.04810931f, -0.01791492f, -0.04063539f, -0.04600715f, 0.10922340f, 
    0.04283222f, 0.01248807f, 0.08034080f, -0.13808306f, -0.11915955f, 0.20439324f, 0.23384313f, -0.30039516f, 
    0.31444362f, 0.08429852f, -0.01430787f, 0.08893976f, -0.12991996f, -0.04138942f, -0.07374822f, 0.00356974f, 
    0.03593966f, 0.00947401f, -0.02239257f, 0.02497804f, 0.06357411f, 0.08025423f, -0.11498077f, 0.11468985f, 
    0.37940317f, -0.17567103f, 0.03525885f, 0.00588123f, -0.00591879f, 0.24324226f, 0.06871986f, -0.00469283f, 
    0.14375825f, 0.03887864f, 0.08600266f, 0.00096600f, 0.06089050f, 0.05971718f, 0.00444401f, 0.09304608f, 
    -0.08494794f, -0.05110872f, -0.10657559f, -0.15297258f, -0.30134624f, -0.07474787f, 0.23427482f, -0.16188408f, 
    0.16167426f, 0.01952454f, -0.16741686f, 0.22439192f, 0.01502877f, 0.03288997f, 0.06680114f, 0.04646508f, 
    0.04104776f, 0.00912088f, -0.06843784f, 0.05363880f, -0.05345224f, -0.02857617f, 0.03125122f, -0.06837717f, 
    0.14764804f, -0.61660975f, -0.07870611f, 0.07352641f, -0.27345923f, -0.00092051f, -0.00936239f, 0.04314465f, 
    0.03024548f, 0.12613347f, 0.03750698f, -0.03255453f, -0.09369151f, 0.06782252f, -0.07266299f, -0.02686076f, 
    0.20234042f, -0.00145589f, 0.05724715f, 0.05929881f, 0.57763577f, 0.28301141f, 0.19724084f, 0.05734874f, 
    -0.08220908f, -0.16938981f, 0.02797849f, 0.13185942f, -0.04734411f, -0.22315450f, 0.01882789f, 0.01703309f, 
    -0.02666061f, 0.03018630f, -0.01030277f, -0.02148493f, -0.07993925f, 0.01729708f, -0.09980840f, -0.04356872f, 
    -0.28941399f, 0.02264843f, 0.08932197f, 0.08247572f, 0.33633569f, -0.00736158f, 0.11106799f, 0.05061687f, 
    0.09182177f, 0.02139176f, -0.05296924f, 0.03345371f, -0.21545143f, -0.05593278f, 0.12453301f, 0.06720128f, 
    -0.07366922f, 0.00029948f, -0.05670098f, 0.01923517f, 0.43474749f, 0.13722306f, -0.29277411f, 0.12369028f, 
    0.25438562f, 0.15271994f, -0.13372348f, 0.01557085f, -0.07091486f, 0.08787288f, 0.01856114f, -0.12715420f, 
    0.04650528f, 0.04221440f, -0.10766498f, 0.11252881f, 0.05671189f, -0.04820640f, -0.13742077f, 0.05156788f, 
    0.46501788f, -0.02685191f, -0.25892964f, -0.12998927f, 0.09426408f, 0.13960537f, -0.05652767f, 0.03502934f, 
    0.06744857f, 0.02848932f, 0.06714388f, 0.05911985f, 0.04953445f, 0.06780849f, 0.03953134f, 0.08077416f, 
    -0.00801847f, -0.08619268f, -0.01108143f, -0.03266633f, -0.67881316f, -0.25819197f, -0.03838156f, 0.01508848f, 
    -0.02468146f, 0.04802814f, 0.04652959f, -0.11301243f, -0.12967198f, -0.03956418f, -0.04361675f, 0.02545476f, 
    0.09761155f, 0.02677625f, 0.00830570f, -0.04350328f, -0.06665176f, 0.06325673f, -0.09065334f, 0.01114642f, 
    -0.20409502f, 0.12788515f, 0.00942980f, -0.01047712f, 0.06870684f, 0.24204797f, 0.00221323f, 0.20417774f, 
    0.14295523f, -0.03296275f, -0.02916189f, 0.06820163f, -0.06232337f, 0.02036163f, -0.06119922f, 0.00597805f, 
    0.06542610f, 0.05366523f, -0.07294876f, -0.00037006f, -0.02357162f, -0.30682084f, -0.30036220f, -0.11348926f, 
    -0.31754357f, 0.07385359f, 0.18326871f, 0.17617500f, -0.09717290f, 0.05435803f, 0.08780301f, -0.04861319f, 
    0.08103731f, 0.14141169f, 0.01119775f, -0.02256573f, 0.00775555f, 0.10772554f, 0.00504077f, -0.01027973f, 
    -0.00282422f, 0.28170952f, -0.19288376f, 0.01065892f, -0.00516765f, -0.08592717f, 0.14470868f, -0.04094540f, 
    0.10547937f, -0.05560247f, -0.03299205f, 0.07503966f, 0.12537821f, 0.03577210f, 0.02252753f, 0.14935613f, 
    -0.07332107f, 0.06179978f, -0.01760918f, 0.15080692f, 0.18723270f, -0.22547995f, -0.13263379f, 0.01905763f, 
    -0.15811348f, -0.10104290f, 0.08601091f, -0.03708684f, -0.04330387f, 0.00420438f, -0.06869891f, 0.11853299f, 
    0.03029014f, -0.03270478f, 0.03888323f, -0.04948790f, -0.08608237f, -0.05773619f, -0.04825749f, 0.00251903f, 
    -0.29816085f, -0.13228890f, 0.10642917f, 0.21049079f, 0.32979280f, -0.09530266f, 0.00013815f, 0.05594045f, 
    0.02132458f, 0.02090683f, -0.05728684f, -0.07530837f, 0.08717047f, 0.08030104f, 0.15065311f, 0.04155380f, 
    0.16270991f, -0.10677499f, 0.03433413f, -0.10067247f, 0.07381865f, 0.16840877f, -0.15617354f, 0.01641129f, 
    0.26153746f, 0.22134577f, 0.01397493f, 0.10247608f, 0.08940297f, -0.00397552f, 0.14205584f, 0.02138019f, 
    0.02102843f, 0.15997660f, -0.06347093f, 0.08869605f, -0.00298734f, -0.02455159f, -0.06546514f, 0.05981923f, 
    0.37881035f, 0.06478167f, 0.08219982f, 0.02820603f, -0.03287259f, -0.11318688f, 0.00500621f, 0.06388106f, 
    0.16704775f, -0.09549710f, -0.04273615f, 0.03426166f, -0.09335361f, -0.04654794f, 0.01861795f, -0.06332629f, 
    -0.03488504f, -0.01705697f, -0.11114191f, 0.11676352f, 0.31461701f, -0.06771536f, -0.23248602f, -0.12476274f, 
    -0.25174284f, -0.09229494f, 0.11343452f, -0.00818902f, -0.10374162f, 0.14908028f, 0.00817912f, -0.03809062f, 
    -0.05503133f, 0.00786640f, 0.06005473f, -0.06345593f, 0.05285180f, 0.08733234f, -0.03423414f, -0.03492896f, 
    -0.14875858f, 0.12282092f, -0.20129119f, 0.08555409f, 0.14712581f, -0.15232581f, 0.05046782f, -0.11336838f, 
    0.13014485f, -0.01887985f, -0.05080180f, -0.03673625f, 0.17090206f, 0.05224043f, 0.10697304f, 0.11628263f, 
    0.03352027f, -0.00752207f, -0.00296192f, -0.14918043f, 0.34143302f, 0.22267863f, -0.39629677f, -0.18498076f, 
    -0.04317784f, 0.07716236f, 0.04129581f, 0.01990465f, 0.06262072f, 0.13351020f, 0.11438967f, 0.07471633f, 
    0.03201413f, 0.00175184f, -0.06727288f, 0.19278954f, 0.11796498f, -0.28681627f, -0.03531832f, 0.01316509f, 
    0.00824149f, 0.00851912f, 0.01507351f, -0.01401833f, -0.01338601f, 0.02879747f, -0.00278535f, -0.02932024f, 
    0.02446499f, 0.04050101f, -0.03335097f, 0.02818485f, -0.03890398f, -0.02693870f, 0.04956961f, 0.03327695f, 
    -0.02548230f, -0.01186217f, -0.03787078f, -0.05174199f, 0.02954731f, 0.01921179f, -0.01662329f, 0.02910791f, 
    -0.04109111f, 0.00642164f, -0.02119128f, -0.05759104f, -0.04303784f, -0.01215175f, -0.02144359f, 0.03689407f, 
    -0.04838409f, 0.00082939f, 0.04185937f, -0.04134678f, -0.03152655f, 0.01656062f, -0.05915088f, 0.00952643f, 
    0.01663383f, 0.01241672f, -0.00877872f, 0.00767291f, -0.03254913f, -0.00942691f, -0.00214841f, -0.02211891f, 
    -0.02857942f, -0.03899152f, -0.05489012f, -0.00850200f, 0.01048340f, 0.04409785f, 0.01297950f, -0.04210015f, 
    -0.00749325f, -0.04077566f, 0.00186254f, -0.04641921f, 0.04663778f, 0.00866127f, -0.05966710f, 0.00223842f, 
    -0.05964520f, 0.03388429f, 0.00297675f, 0.03518279f, -0.04913222f, -0.04864785f, -0.03033597f, 0.04914758f, 
    -0.03398350f, -0.03203737f, -0.04375188f, -0.05515461f, 0.02632833f, 0.00502083f, -0.05196059f, -0.03748462f, 
    -0.03718141f, -0.00860955f, -0.01644318f, 0.02510530f, -0.04942779f, -0.00216576f, 0.00950698f, -0.01000630f, 
    0.00146492f, 0.01143001f, -0.03643965f, -0.02807229f, 0.01188118f, -0.05426751f, 0.01030745f, 0.01747632f, 
    -0.03414761f, -0.00969708f, 0.02081936f, 0.01222568f, -0.00132879f, -0.04410502f, -0.01991333f, 0.03942423f, 
    0.03071657f, 0.03263452f, 0.03785759f, -0.03868557f, -0.02746202f, 0.01975184f, -0.05803047f, 0.00072881f, 
    0.03567665f, -0.02259284f, -0.05129624f, -0.02605579f, -0.04972204f, -0.02141350f, -0.03522447f, 0.03002470f, 
    0.00185316f, 0.02465921f, -0.02245342f, -0.00621449f, 0.02300852f, -0.05743819f, 0.02444391f, 0.04055910f, 
    0.01934905f, 0.02034580f, 0.00445860f, 0.04626074f, 0.01396415f, 0.03865035f, 0.04379912f, -0.02787017f, 
    -0.02593333f, -0.02165590f, 0.00470867f, -0.00760639f, 0.00424210f, 0.02197684f, -0.02069756f, -0.04897198f, 
    0.00113438f, -0.02900012f, -0.05665414f, 0.04297112f, 0.01721521f, 0.04126642f, 0.02654418f, -0.01653852f, 
    -0.03131260f, -0.04188972f, -0.04003842f, 0.00774236f, -0.01751102f, 0.00700249f, 0.03042723f, -0.03149359f, 
    -0.01688014f, -0.03319428f, 0.02526756f, 0.00629645f, -0.02461718f, -0.02825126f, 0.04428732f, -0.03917587f, 
    -0.02240907f, -0.05439961f, -0.04552918f, 0.03089496f, -0.05134179f, 0.03728851f, -0.00092621f, 0.00546975f, 
    -0.05122601f, -0.05310107f, 0.04469287f, -0.00577455f, -0.05974828f, -0.01523994f, -0.00928621f, -0.01264167f, 
    0.00999708f, -0.03969851f, 0.00083312f, 0.02203010f, 0.03352324f, 0.00051198f, 0.02867206f, -0.05733851f, 
    -0.01844736f, 0.02840123f, -0.04626851f, 0.00644708f, -0.01582980f, -0.03288469f, 0.03178193f, 0.01807574f, 
    0.03180103f, 0.04541376f, 0.01340960f, 0.00413219f, 0.01278215f, -0.00919102f, -0.04254899f, 0.01194231f, 
    -0.02708155f, -0.05639828f, -0.01972295f, -0.03167096f, 0.04689502f, 0.03913590f, 0.01625511f, -0.05787873f, 
    -0.04988158f, 0.03148689f, 0.02529936f, 0.04690277f, 0.04485435f, -0.01490017f, 0.00772198f, 0.00860338f, 
    -0.00754018f, -0.03090244f, 0.00907560f, 0.00251933f, -0.00324524f, 0.04342609f, -0.02641526f, -0.00294003f, 
    -0.04697711f, 0.01706801f, -0.03665917f, -0.03578509f, 0.03807481f, 0.00214594f, 0.01320804f, -0.04588806f, 
    -0.04887860f, -0.00864800f, -0.05933998f, -0.02022751f, -0.05657116f, 0.02806431f, -0.03057112f, -0.03456111f, 
    -0.05412122f, 0.01831341f, 0.04108918f, -0.04444218f, 0.03213508f, 0.00007811f, -0.02237369f, -0.01882065f, 
    0.01058109f, -0.00861996f, -0.01261026f, -0.00114241f, 0.04775108f, -0.04650201f, 0.01743335f, 0.02564062f, 
    -0.02682181f, 0.04956338f, -0.00217180f, 0.00753204f, -0.05337175f, -0.00547241f, 0.04399760f, -0.03130208f, 
    -0.02062633f, 0.01575400f, 0.00057969f, 0.03924570f, 0.02755872f, 0.04011284f, 0.02563871f, -0.04253577f, 
    -0.03393773f, -0.01797052f, -0.05910144f, -0.03954619f, -0.03670779f, -0.05317419f, -0.02989484f, -0.02081260f, 
    -0.04781710f, -0.03648764f, -0.00870771f, -0.01620695f, -0.05005325f, -0.02618312f, -0.00808145f, 0.03230110f, 
    0.04249626f, -0.05002596f, -0.03499634f, 0.02155680f, -0.01890507f, -0.05347776f, -0.04395971f, 0.00451696f, 
    -0.04304007f, -0.03784279f, 0.02154510f, 0.00845855f, 0.02572116f, 0.04466682f, -0.04707785f, -0.03543224f, 
    0.00857080f, -0.04173873f, -0.05196821f, -0.02768959f, -0.04621532f, -0.01149506f, -0.03030512f, -0.02538840f, 
    0.27427125f, 0.13271080f, -0.12824829f, -0.04725339f, -0.15652381f, 0.02005096f, 0.02786767f, 0.01825372f, 
    0.06474075f, -0.09225142f, 0.13046990f, -0.12376498f, -0.16294205f, -0.05503179f, -0.09334785f, -0.10546298f, 
    0.10827646f, -0.03711586f, 0.14862634f, -0.08160030f, -0.47372383f, 0.18960719f, 0.19158305f, 0.34742984f, 
    0.01754259f, 0.08458222f, 0.02513167f, 0.05204155f, 0.14978884f, -0.08175062f, -0.00694608f, -0.07229104f, 
    0.03361194f, 0.07790498f, 0.04425320f, -0.05997985f, -0.06977774f, 0.07034878f, 0.12877546f, -0.00485398f, 
    0.18619353f, 0.02495545f, -0.06555920f, 0.02671870f, -0.03138846f, 0.14877227f, 0.03111472f, 0.05983136f, 
    0.12099175f, -0.02656740f, 0.16473666f, -0.01219717f, -0.10986613f, -0.00735762f, -0.06816518f, 0.00802621f, 
    -0.08573923f, -0.09616454f, 0.06568222f, -0.00218162f, -0.54141957f, 0.25329041f, 0.09068401f, 0.13174276f, 
    0.21829808f, -0.02344155f, -0.01925260f, -0.04159404f, 0.06826057f, 0.07231324f, 0.05254938f, 0.05457295f, 
    -0.09364465f, 0.08337061f, -0.05501723f, -0.02264329f, 0.03918318f, -0.14236479f, -0.00521778f, -0.03850411f, 
    0.30781493f, -0.27160582f, -0.17695266f, 0.31750068f, 0.51359367f, 0.14249066f, 0.05594992f, -0.03755914f, 
    -0.03883934f, 0.00159508f, 0.07543006f, 0.00797366f, 0.00531600f, 0.04653398f, 0.12407281f, 0.02075439f, 
    0.03201147f, 0.08835158f, 0.13750909f, -0.05772091f, -0.26245448f, 0.19467835f, 0.23905417f, -0.11126827f, 
    0.07033823f, 0.02831225f, -0.06429212f, -0.06832235f, 0.12746800f, -0.25814500f, -0.06575045f, -0.02727568f, 
    -0.00375769f, -0.01057512f, -0.03739625f, -0.14618975f, 0.05643146f, 0.03993232f, 0.19655618f, 0.02143589f, 
    -0.33606544f, 0.10684916f, 0.03287556f, -0.25388014f, 0.09487715f, -0.05387055f, 0.06917661f, -0.00756746f, 
    -0.04949341f, 0.11226118f, 0.10883518f, 0.07237214f, -0.09830853f, -0.03898145f, 0.02791256f, 0.05080529f, 
    -0.01266000f, 0.14857130f, 0.10056309f, 0.07028982f, 0.71133327f, -0.33350292f, -0.22357152f, -0.09225859f, 
    0.32949984f, 0.00960858f, 0.04959396f, 0.00307879f, -0.14993256f, 0.03331027f, 0.06356097f, 0.01954130f, 
    0.02504455f, -0.00913649f, -0.12535939f, -0.05472922f, -0.10975309f, 0.05618891f, -0.00551674f, -0.09390118f, 
    -0.37867475f, 0.32252124f, -0.00680824f, 0.03159902f, 0.14980780f, -0.02647582f, 0.10999575f, -0.13156208f, 
    0.01789316f, -0.05658696f, -0.00266236f, 0.04597367f, 0.03305071f, 0.15327628f, 0.05453560f, 0.13907546f, 
    -0.00900189f, -0.11342346f, 0.07078873f, 0.15694915f, -0.08697451f, 0.23020057f, 0.01610659f, 0.05306756f, 
    -0.02974026f, -0.13155611f, 0.09068234f, 0.20219965f, -0.13283736f, 0.01263143f, -0.07719916f, 0.16099106f, 
    -0.01694986f, -0.13859381f, 0.16982444f, -0.03902759f, 0.00507807f, -0.09796362f, 0.15670882f, -0.00303842f, 
    -0.09052429f, -0.01958387f, 0.12525818f, 0.20397851f, -0.05045939f, 0.08955041f, 0.09128018f, -0.02770989f, 
    -0.06684716f, -0.13619772f, 0.06530553f, 0.05296738f, -0.02000464f, 0.12365260f, -0.08333780f, 0.00342745f, 
    0.06220744f, 0.01115012f, -0.04250248f, -0.06190727f, 0.38607028f, -0.12886448f, -0.15706214f, 0.14590913f, 
    0.14725846f, -0.03878507f, -0.01352321f, 0.00028253f, -0.00177349f, -0.12149073f, 0.16876891f, -0.00507876f, 
    -0.10338490f, -0.04351710f, 0.06885573f, -0.01148601f, -0.02353958f, -0.12586413f, 0.11145341f, -0.03154125f, 
    -0.27713773f, 0.54363751f, 0.17078078f, 0.05561059f, -0.01103786f, -0.02633583f, 0.02206027f, 0.10207026f, 
    -0.01822170f, 0.13238043f, -0.05781015f, 0.06401067f, 0.11612465f, 0.00492565f, 0.01599179f, 0.11103148f, 
    0.02246376f, -0.04686894f, 0.00837306f, 0.08544592f, 0.26588091f, -0.04898262f, -0.09647439f, -0.24484178f, 
    0.32546329f, 0.05061740f, 0.15507469f, -0.02859180f, -0.02890359f, 0.12922262f, 0.03672608f, -0.06562382f, 
    0.00576424f, -0.06485263f, -0.03517042f, 0.10583369f, 0.01716286f, 0.07035937f, 0.09477948f, 0.13142081f, 
    0.01016567f, 0.21428649f, 0.02294834f, -0.20930934f, -0.37102750f, 0.08354462f, -0.04655837f, -0.00880904f, 
    -0.00048833f, 0.11950307f, 0.14129126f, -0.00257804f, 0.19319794f, 0.20702980f, -0.01791565f, -0.16170764f, 
    -0.14271389f, -0.06867118f, 0.01387334f, -0.03041308f, 0.44418290f, 0.25561121f, -0.10765643f, -0.04881824f, 
    -0.07015269f, -0.01126373f, -0.05913468f, 0.03783778f, 0.12291162f, 0.00716322f, 0.19557522f, -0.01801731f, 
    -0.07048059f, -0.00760597f, 0.05877463f, 0.00452397f, 0.13628075f, -0.12822776f, 0.06062738f, 0.05545695f, 
    -0.04364131f, -0.08738331f, 0.06979361f, -0.05575408f, -0.11126377f, -0.12723622f, -0.15909487f, -0.02959494f, 
    0.25842643f, 0.02848195f, -0.01372645f, -0.04429296f, -0.10100890f, -0.05261102f, 0.04571019f, -0.05081699f, 
    0.02087016f, -0.19413783f, -0.12758641f, -0.04141299f, -0.10969151f, 0.10511117f, -0.47407261f, 0.07918832f, 
    0.24263182f, -0.06297685f, 0.18434440f, -0.23260827f, 0.14959516f, 0.03955387f, -0.00214613f, -0.01748172f, 
    0.04522958f, 0.22156413f, 0.06319825f, 0.07152630f, -0.02260506f, 0.13425560f, 0.03611008f, -0.06402913f, 
    0.38607207f, -0.25741416f, -0.19068739f, 0.01962315f, 0.28697291f, 0.10032860f, 0.04023897f, 0.01367936f, 
    0.03838849f, 0.08573765f, -0.11205222f, 0.06912272f, 0.10534222f, -0.16778791f, -0.18794148f, 0.12573077f, 
    -0.04976109f, -0.03774875f, -0.02602740f, -0.09501529f, -0.50351310f, 0.22749306f, 0.29045001f, -0.10550392f, 
    0.19058122f, 0.11558683f, -0.09244131f, -0.02931331f, 0.17918876f, -0.04371866f, -0.12241523f, -0.07990055f, 
    0.06812006f, -0.10227609f, -0.12797597f, 0.00849642f, 0.06171832f, -0.07527114f, -0.08939750f, -0.05422264f, 
    0.48491636f, -0.09283681f, 0.05263754f, 0.16557293f, -0.00947618f, -0.10934956f, 0.01576139f, 0.03066669f, 
    0.05011767f, 0.12538418f, -0.03708701f, -0.01587123f, -0.04859749f, 0.09185077f, 0.00238131f, 0.09783249f, 
    -0.06298077f, 0.05018094f, 0.00384436f, 0.12717344f, -0.12064975f, 0.06567184f, 0.00526686f, -0.06766938f, 
    -0.19799823f, 0.04816248f, 0.11203308f, 0.24078593f, 0.12180577f, -0.20098428f, -0.04858290f, -0.01769365f, 
    -0.01484333f, 0.20429283f, -0.08234639f, 0.01589618f, 0.12152462f, -0.01677043f, -0.05560303f, 0.03013626f, 
    -0.05043664f, 0.29845253f, 0.31369147f, -0.01776521f, -0.05746530f, 0.04677403f, -0.04867668f, -0.02716126f, 
    0.08995482f, 0.22293493f, -0.11488082f, 0.09341527f, 0.07022319f, 0.09223409f, -0.04203428f, 0.03699319f, 
    0.01721797f, -0.04484350f, -0.04163753f, -0.05229850f, 0.48227000f, 0.14591472f, 0.20669252f, 0.08314133f, 
    -0.06235211f, -0.05497062f, -0.11529910f, 0.23037359f, 0.21229173f, 0.12314093f, 0.10342539f, 0.08269109f, 
    0.02294343f, -0.04061628f, -0.04727671f, 0.09783540f, 0.07723576f, -0.02818251f, -0.03243369f, 0.08439591f, 
    -0.11754328f, 0.20669290f, 0.00848995f, 0.08132219f, -0.10801146f, -0.08652592f, 0.00036807f, 0.02057699f, 
    -0.02513643f, -0.06618727f, 0.04443878f, -0.05255165f, -0.01885900f, 0.14913940f, 0.03997047f, -0.00459011f, 
    -0.03721173f, -0.10640197f, -0.13345136f, -0.10339744f, -0.59634471f, -0.16450411f, 0.14069754f, 0.11147485f, 
    -0.12865600f, 0.19091852f, 0.02906171f, 0.28924939f, 0.10226961f, 0.02375308f, 0.09832340f, 0.13514501f, 
    0.03939306f, 0.14000703f, -0.06565653f, 0.02309184f, -0.01102581f, -0.05284332f, -0.12244526f, -0.06801904f, 
    0.24162516f, -0.18678419f, -0.23844294f, -0.01180713f, 0.21230008f, 0.11284786f, 0.02597582f, 0.15524600f, 
    0.19500531f, 0.06252158f, 0.03611604f, -0.13311972f, 0.07542461f, 0.12219425f, -0.03804159f, 0.18953942f, 
    0.12963586f, -0.02872322f, 0.11967678f, 0.04064456f, 0.55158198f, -0.17215908f, 0.32519922f, 0.21543501f, 
    0.05422121f, -0.08701151f, -0.17878206f, 0.01092324f, 0.02292570f, 0.07952554f, -0.12058046f, 0.09174239f, 
    -0.03113199f, -0.18839213f, -0.00872322f, -0.17662013f, -0.01139928f, -0.17104164f, -0.19443052f, -0.03194903f, 
    -0.33043373f, 0.17401767f, -0.25142404f, -0.03227191f, -0.12549843f, 0.13903269f, 0.08574640f, -0.13669346f, 
    -0.01776163f, 0.07821534f, 0.04114508f, 0.18410291f, -0.01088918f, -0.06152014f, 0.07653666f, -0.00599578f, 
    -0.01821486f, -0.02061255f, -0.05127193f, -0.12114490f, -0.12677135f, 0.00601187f, 0.28359401f, -0.03602739f, 
    -0.12829380f, -0.14411961f, -0.05697284f, 0.16529770f, 0.13975546f, 0.08070371f, -0.01311346f, 0.05701685f, 
    0.05070031f, -0.09743216f, 0.03914843f, -0.01510997f, 0.03864754f, -0.13339752f, -0.10809830f, -0.13598891f, 
    0.11452997f, -0.04792111f, 0.12408814f, -0.27704039f, -0.07532221f, -0.03931716f, 0.15677896f, 0.16252616f, 
    0.05818092f, 0.07873452f, 0.04380617f, -0.00462423f, 0.07743649f, 0.18301804f, -0.02506175f, 0.04904829f, 
    0.06067807f, 0.10858035f, 0.03662860f, 0.12571180f, 0.25449660f, -0.24667817f, 0.15093726f, 0.14588474f, 
    0.11668351f, -0.11091325f, 0.11008761f, -0.07365621f, -0.01131306f, 0.09003172f, -0.04369856f, 0.04470233f, 
    -0.08161629f, 0.09230164f, 0.12906870f, -0.05611322f, 0.03166763f, 0.08033569f, 0.03369383f, 0.05877879f, 
    0.09439611f, 0.23043518f, -0.00687863f, 0.21295229f, 0.14898933f, 0.02925530f, 0.01947028f, 0.00125620f, 
    -0.13935786f, -0.00382337f, -0.00807054f, -0.03446802f, 0.02445798f, -0.06614394f, 0.02418364f, -0.14131577f, 
    0.03113955f, -0.13325793f, 0.04345032f, -0.00788189f, -0.15144283f, -0.02666548f, 0.23297724f, -0.10441583f, 
    0.29392642f, 0.22122486f, 0.23319837f, 0.15587826f, -0.04539393f, 0.16215299f, -0.05302647f, 0.14368737f, 
    0.09157089f, -0.02648260f, 0.07004976f, 0.14134602f, 0.08302996f, -0.04337694f, 0.06205247f, -0.01305501f, 
    -0.46865898f, 0.02948814f, 0.19292116f, 0.07736509f, -0.29901609f, 0.08557384f, -0.08720365f, -0.10694335f, 
    0.00273006f, 0.07754710f, -0.00010683f, 0.11370756f, 0.17526801f, -0.01572073f, -0.08339826f, 0.00903534f, 
    0.06298322f, -0.05775831f, 0.10089581f, 0.05628884f, 0.14164245f, -0.14345188f, -0.28379676f, -0.16758236f, 
    0.10215688f, 0.11451232f, 0.13126698f, 0.12432892f, 0.00704807f, -0.06430341f, 0.04027370f, -0.06932086f, 
    0.03704411f, 0.01532681f, 0.04628238f, -0.06613339f, 0.06544059f, 0.03672123f, -0.05647909f, -0.01475879f, 
    -0.32931450f, 0.13752839f, -0.09119117f, 0.12693208f, -0.13537557f, 0.00919748f, 0.08418126f, -0.04555169f, 
    0.05690125f, 0.05417866f, -0.07582176f, -0.04638740f, 0.13555259f, 0.08392273f, 0.02810986f, 0.00423220f, 
    -0.04612437f, -0.06092888f, 0.11130449f, -0.03756536f, 0.12692344f, -0.15571821f, -0.14499775f, 0.03666682f, 
    -0.11761537f, 0.07355978f, -0.05482817f, -0.04744201f, -0.20334928f, 0.03873616f, 0.04047805f, 0.07603379f, 
    0.04590205f, 0.01860093f, -0.02120594f, 0.10682982f, 0.06261633f, 0.15668558f, 0.01870445f, -0.03754487f, 
    0.51859355f, -0.13095908f, -0.02666012f, 0.00379223f, -0.06012002f, -0.00156369f, 0.00243004f, 0.06590936f, 
    -0.07609989f, -0.04107673f, 0.03790658f, -0.03579735f, -0.09273501f, 0.11353321f, 0.03691680f, -0.04149529f, 
    0.14476626f, 0.05327183f, -0.02022600f, -0.07632759f, -0.12267235f, 0.23754945f, 0.14831547f, 0.37437984f, 
    -0.12754115f, -0.09441933f, 0.19044392f, 0.01418465f, -0.08309270f, 0.01168147f, -0.02248906f, 0.00301196f, 
    0.12811661f, -0.00908859f, 0.03460785f, -0.01233900f, 0.03582092f, 0.01117772f, 0.03421493f, -0.12250155f, 
    0.45418948f, -0.39824876f, 0.13540822f, -0.01030201f, -0.16773939f, 0.01301511f, -0.03478098f, 0.03059802f, 
    -0.21771207f, 0.07040780f, -0.01686054f, 0.13547751f, -0.07484485f, 0.08182856f, 0.03339974f, -0.10456953f, 
    -0.04409748f, 0.16226624f, -0.07402562f, -0.01255274f, 0.19302742f, -0.06089675f, -0.15537345f, 0.04663694f, 
    0.14774287f, -0.07169878f, -0.07386469f, -0.06597776f, 0.01642072f, -0.08090539f, 0.00329655f, -0.06960522f, 
    -0.07678565f, 0.01681811f, 0.00741688f, 0.10991832f, -0.08354778f, 0.03008830f, 0.07873657f, -0.05528617f, 
    0.01448093f, 0.42457065f, -0.01065037f, -0.04082135f, 0.44598711f, 0.00294893f, -0.08816805f, -0.08048896f, 
    0.05462857f, 0.02333120f, -0.07578706f, -0.06217482f, 0.15464912f, -0.03852293f, -0.02299316f, 0.02514675f, 
    -0.08313115f, -0.10745606f, -0.08354236f, 0.05699367f, -0.28372827f, 0.35700607f, -0.13325681f, 0.12686636f, 
    -0.28812617f, -0.04232440f, 0.05020661f, -0.06041421f, -0.07264379f, 0.06189479f, 0.00144501f, -0.05397981f, 
    -0.00004466f, 0.01194375f, -0.03032671f, 0.04187753f, 0.05849473f, -0.00977685f, 0.06524238f, 0.04802063f, 
    -0.19991812f, -0.44686165f, -0.01386249f, 0.22659288f, 0.34643510f, -0.01949396f, 0.07876080f, 0.11287710f, 
    0.05788066f, -0.02899497f, 0.02943843f, -0.05088702f, -0.03578992f, -0.12162049f, 0.01664763f, 0.01961064f, 
    0.03874626f, 0.05382098f, 0.05517242f, 0.06911062f, 0.16186014f, -0.09972708f, 0.02978215f, 0.23060139f, 
    -0.22887288f, -0.08226896f, 0.03350306f, -0.11035310f, 0.01762835f, 0.03670711f, 0.02939359f, 0.01290243f, 
    -0.07107585f, 0.06396016f, -0.08584150f, 0.06122609f, 0.05864975f, 0.10214409f, 0.09123369f, -0.06630181f, 
    -0.60654598f, -0.02761556f, 0.32055673f, 0.25793952f, 0.21365382f, 0.08638723f, 0.05465021f, 0.04681165f, 
    0.01765892f, 0.12953693f, -0.11618661f, 0.09129260f, 0.13964227f, 0.06483874f, -0.13860168f, 0.10793308f, 
    0.15413478f, -0.13486269f, 0.00795411f, 0.22363652f, -0.30404690f, 0.02388125f, -0.09947863f, 0.24264914f, 
    0.14906392f, 0.24004149f, -0.03963724f, -0.16806085f, -0.05061661f, -0.02643351f, -0.02596258f, -0.06201244f, 
    0.08958537f, 0.17698802f, 0.07624148f, 0.06559881f, -0.03932146f, -0.20473284f, -0.09686936f, 0.08753217f, 
    0.29095986f, -0.07100584f, 0.16744982f, 0.01465994f, 0.03716082f, 0.18210666f, 0.07117016f, 0.06238728f, 
    -0.16075654f, 0.04706632f, -0.01310615f, 0.01293895f, 0.07898034f, 0.10055414f, -0.11594415f, 0.11588976f, 
    0.01163706f, 0.10494852f, 0.15518332f, 0.07804003f, 0.47255537f, 0.01508936f, 0.30388823f, 0.06892762f, 
    -0.01626593f, 0.02857124f, -0.01313755f, 0.17964864f, -0.13744248f, 0.15003817f, 0.04596940f, 0.01759864f, 
    0.03035477f, 0.04811151f, 0.00921037f, -0.02648545f, 0.02672812f, -0.08226113f, -0.03123153f, 0.03395176f, 
    -0.52515674f, -0.07647775f, 0.12690683f, -0.09187629f, 0.08629216f, -0.07029131f, -0.03419017f, -0.04968373f, 
    -0.10552517f, 0.05405138f, 0.05230799f, -0.03684214f, -0.07920647f, 0.07278842f, 0.06817738f, -0.02829377f, 
    0.13319705f, 0.08939107f, 0.04670548f, 0.08486015f, 0.56555623f, -0.23640777f, -0.16963287f, -0.03730153f, 
    0.17900558f, -0.04052684f, -0.03644027f, 0.00147624f, -0.14737409f, 0.20252682f, 0.12611850f, 0.11341146f, 
    -0.03146679f, 0.04223450f, 0.09950062f, 0.09855934f, 0.03953085f, 0.06255436f, 0.05451493f, 0.09502658f, 
    0.02184905f, -0.06215037f, 0.06626505f, -0.26359087f, -0.00326678f, 0.06923924f, -0.02071198f, -0.00674337f, 
    -0.06052441f, -0.04915097f, -0.04272947f, -0.06984556f, 0.10402402f, -0.04584980f, 0.00955064f, 0.01164458f, 
    0.07814279f, -0.11853575f, -0.09936505f, -0.08121023f, -0.14894739f, -0.03403069f, -0.12077690f, 0.05325430f, 
    0.29496461f, 0.00024580f, 0.00725219f, -0.10856289f, -0.09262038f, 0.08440423f, 0.03089155f, 0.02816501f, 
    0.01264718f, 0.05806135f, 0.03569439f, -0.07354426f, 0.02763475f, -0.06942645f, -0.01271412f, -0.14279774f, 
    0.23200326f, 0.07541137f, -0.34648606f, 0.06262942f, -0.02083677f, 0.15528938f, -0.05091595f, 0.05623521f, 
    0.07952663f, -0.07548968f, 0.04396256f, 0.00531976f, -0.12679780f, 0.07739317f, -0.05151319f, -0.00953344f, 
    -0.01498645f, 0.09540991f, 0.05154930f, -0.00150003f, 0.06537858f, -0.13212955f, -0.08354851f, -0.01207932f, 
    0.05816688f, 0.12398426f, 0.17505182f, 0.05832779f, -0.08338803f, -0.02759901f, -0.04766012f, -0.05089067f, 
    -0.05835178f, -0.08813899f, 0.00507764f, 0.00136891f, 0.02038645f, 0.05018028f, 0.00998743f, -0.06960981f, 
    0.35581675f, -0.14820305f, -0.08797186f, 0.01915274f, -0.01477221f, -0.13232663f, 0.11277483f, 0.07060101f, 
    -0.00000195f, -0.01038966f, -0.03163028f, -0.01511775f, 0.04096651f, 0.02462786f, -0.02545894f, 0.07072882f, 
    -0.05728065f, -0.00506623f, 0.02570862f, 0.10867327f, 0.30073428f, 0.05299581f, 0.02246496f, -0.04570994f, 
    0.20359044f, 0.05069723f, -0.03505477f, -0.20346987f, 0.04908785f, 0.03930733f, -0.09679187f, 0.01351320f, 
    -0.04864270f, -0.07714147f, 0.03759850f, 0.02890918f, -0.06457336f, 0.06169868f, -0.07892404f, -0.03861557f, 
    0.07802506f, 0.09327224f, -0.01128518f, -0.08336728f, -0.01316717f, -0.02880757f, 0.05235647f, 0.10304761f, 
    -0.05757852f, -0.02812768f, -0.08867950f, -0.05089736f, 0.01482345f, 0.03381094f, 0.00026700f, 0.00281727f, 
    0.10188767f, 0.02975143f, -0.07271013f, -0.03419647f, -0.27577734f, 0.24265286f, 0.07073236f, -0.13474087f, 
    -0.03272731f, 0.18368882f, -0.07734472f, 0.14282192f, 0.05883121f, -0.09352239f, 0.11526377f, -0.04240663f, 
    0.09723097f, 0.06594013f, 0.04355631f, 0.03227436f, -0.04716970f, 0.07194214f, 0.05064976f, 0.01676916f, 
    0.32619560f, -0.08863539f, 0.12668329f, 0.16954660f, 0.16968897f, -0.11662012f, 0.03249809f, 0.00598311f, 
    0.07644156f, 0.06677670f, 0.06903950f, -0.07306262f, -0.10278522f, 0.02233506f, -0.05088194f, -0.10225195f, 
    -0.03293302f, -0.02532053f, -0.04281988f, 0.08787956f, 0.35777104f, 0.14750829f, 0.08915311f, 0.09897493f, 
    0.01184205f, 0.02207048f, 0.11813715f, 0.01198042f, -0.17127843f, -0.08395462f, -0.07659196f, 0.02601422f, 
    -0.12029196f, -0.00695070f, 0.03179240f, 0.11074213f, -0.03488382f, 0.02386057f, -0.02370398f, 0.08438450f, 
    -0.03584062f, -0.21458149f, -0.13935535f, 0.14135714f, 0.12390991f, 0.08575258f, 0.05456568f, -0.02362113f, 
    0.03074425f, -0.05097292f, 0.00642252f, -0.06201224f, 0.00135618f, -0.07189627f, -0.00557296f, -0.03088951f, 
    0.07394180f, -0.02241199f, -0.09807380f, -0.03518854f, -0.22962603f, -0.13592680f, -0.25536475f, -0.38877568f, 
    -0.17793429f, 0.11305953f, -0.01592633f, 0.12011433f, -0.01723013f, 0.00711009f, 0.10381518f, 0.02377758f, 
    0.16052604f, -0.03099121f, -0.26045591f, 0.04324088f, -0.05815400f, -0.07780826f, -0.02144444f, 0.01091974f, 
    -0.28482354f, 0.13918619f, -0.37422019f, -0.07819039f, 0.01062269f, 0.00509797f, 0.03977933f, -0.06345807f, 
    0.10047486f, -0.03443832f, 0.13442947f, 0.14995602f, -0.06266071f, 0.05306435f, 0.11934557f, 0.03203789f, 
    -0.04285619f, -0.00808278f, -0.11726618f, -0.11093941f, -0.18502681f, 0.07584994f, 0.19140050f, 0.11039538f, 
    0.34918305f, 0.03865882f, 0.16692239f, 0.02444742f, 0.24310111f, -0.07456128f, 0.05326420f, -0.00523614f, 
    0.03575157f, -0.01751791f, -0.01577131f, 0.07956766f, -0.01171761f, 0.13837278f, 0.02763414f, 0.06272814f, 
    0.40519029f, 0.08380438f, -0.04278124f, 0.26789337f, -0.30385807f, -0.00546544f, -0.03928828f, 0.05685260f, 
    0.23643364f, 0.04632198f, -0.03563164f, 0.08823276f, 0.16739331f, -0.14591321f, 0.08182549f, 0.06906290f, 
    -0.06634079f, 0.01643035f, -0.04408907f, -0.07781124f, -0.23612361f, 0.32413602f, 0.38319382f, 0.11766981f, 
    -0.06697511f, 0.11658585f, 0.03514354f, 0.08650844f, 0.18409874f, -0.21088952f, -0.04551188f, 0.08682921f, 
    0.01586664f, 0.02102424f, -0.02773896f, 0.04152180f, -0.07554026f, -0.02083072f, -0.03266986f, -0.03210988f, 
    0.10556547f, 0.01296527f, -0.07331613f, 0.13884723f, -0.07355827f, -0.11906967f, -0.02894166f, -0.11904895f, 
    0.02436350f, 0.02802678f, 0.03089505f, 0.14733894f, -0.03497067f, -0.01566569f, 0.12970607f, 0.13043922f, 
    -0.00467539f, 0.18585058f, 0.13545172f, 0.01692871f, 0.27598062f, 0.08706676f, 0.21925652f, 0.04800488f, 
    -0.17291313f, -0.02453657f, 0.01903375f, 0.17670673f, 0.21942742f, -0.02136332f, 0.07327194f, -0.07952476f, 
    0.07829294f, 0.06483379f, -0.01231956f, 0.00286280f, 0.13447797f, -0.08699299f, 0.04191716f, 0.11416655f, 
    -0.07094964f, 0.01354495f, 0.18906122f, -0.06207180f, -0.03171033f, -0.09084733f, 0.06844780f, 0.01638360f, 
    0.01178679f, 0.02345210f, -0.01380191f, -0.00333764f, 0.29541788f, -0.00544524f, 0.15604055f, -0.03408323f, 
    0.16967148f, -0.10247836f, -0.02811162f, 0.05759255f, 0.04275344f, 0.05459675f, -0.05426046f, -0.06683807f, 
    -0.12913235f, -0.11317491f, -0.16307023f, -0.03817776f, 0.04657084f, 0.00805350f, -0.01379758f, 0.14830920f, 
    0.13966745f, 0.09566730f, -0.09349652f, 0.05429317f, 0.01255786f, -0.07492194f, -0.10411651f, 0.03206172f, 
    0.05509434f, -0.11867533f, 0.23711573f, 0.19867927f, 0.07526175f, 0.16109560f, -0.05414408f, -0.04484552f, 
    0.09917096f, 0.05920980f, 0.05140701f, 0.09849212f, -0.05217745f, 0.03022867f, 0.02093273f, 0.05067416f, 
    0.07482319f, -0.02275539f, 0.09702059f, -0.07221166f, -0.26509917f, 0.07103692f, -0.04112435f, 0.01262723f, 
    -0.20130402f, -0.02592452f, 0.10412448f, 0.25676784f, 0.01728632f, 0.07361165f, 0.11625423f, 0.06073032f, 
    0.06702109f, 0.17555897f, -0.07487499f, 0.01160157f, 0.12814097f, 0.05871746f, -0.00906573f, 0.07519605f, 
    0.28785035f, -0.01765484f, -0.13522395f, 0.07945472f, 0.23134303f, 0.06491040f, -0.04875156f, -0.04100231f, 
    0.06023357f, -0.00592324f, 0.02071535f, 0.12973844f, -0.08835197f, 0.13132617f, -0.00779606f, 0.05805104f, 
    -0.06328689f, 0.03088064f, 0.09999657f, -0.02103345f, 0.22077017f, 0.01437194f, 0.04720806f, 0.08201817f, 
    -0.01940136f, -0.06772961f, 0.08200879f, -0.21143712f, -0.06952284f, 0.08297965f, -0.05371171f, 0.02442590f, 
    -0.06556219f, -0.12585917f, 0.06457964f, 0.03304096f, -0.02167609f, 0.03542929f, -0.05899220f, 0.14786631f, 
    -0.20255005f, 0.10891147f, 0.03462971f, -0.16457061f, 0.03753109f, 0.12947717f, 0.19367857f, 0.12716317f, 
    0.03646239f, -0.01483322f, 0.06033173f, 0.17333265f, 0.15087974f, -0.03000722f, 0.07696809f, -0.07147275f, 
    0.02064255f, 0.08300121f, 0.08010305f, -0.00513217f, -0.14266710f, -0.25976467f, -0.03949668f, -0.11567903f, 
    -0.03069643f, 0.11511084f, -0.02206442f, -0.01930371f, 0.03427804f, 0.05941240f, 0.12635969f, -0.05385905f, 
    0.02550305f, 0.00805172f, 0.05376159f, -0.07355599f, 0.06759354f, -0.06072692f, 0.01576333f, -0.02470735f, 
    0.36119008f, 0.10441358f, 0.30927187f, 0.15047674f, 0.01406540f, 0.06243851f, -0.04879190f, 0.04237387f, 
    0.00872176f, -0.00252513f, 0.06575580f, 0.06941573f, -0.01738972f, 0.09243843f, -0.02073175f, 0.15862994f, 
    -0.07086788f, 0.11074975f, 0.05045295f, 0.12032389f, 0.22936045f, 0.25576389f, 0.44514331f, 0.41822559f, 
    0.31864002f, -0.03918645f, -0.02974946f, -0.13438301f, 0.13182323f, -0.04542936f, 0.05634118f, 0.10303330f, 
    -0.15033315f, 0.17590447f, 0.22685228f, 0.03290674f, 0.15295544f, 0.22132631f, 0.22627641f, 0.01270576f, 
    -0.00142766f, -0.01293971f, -0.03277620f, 0.03505423f, -0.05448699f, -0.04584962f, -0.04898788f, 0.04399961f, 
    -0.02224597f, -0.01051737f, -0.00651619f, -0.01527274f, 0.01689493f, -0.01300977f, -0.02397221f, 0.05098591f, 
    -0.05258271f, -0.03558652f, 0.05812660f, 0.02473442f, -0.01858169f, -0.03372229f, 0.00183442f, 0.00813663f, 
    -0.04401361f, -0.02278999f, 0.00071200f, -0.04560576f, -0.00382495f, -0.05461184f, -0.04710943f, 0.01332035f, 
    -0.04468600f, -0.05855050f, -0.03349500f, -0.02196234f, 0.04416711f, 0.02465807f, -0.01846931f, -0.00191034f, 
    -0.02449997f, 0.01781699f, 0.04009611f, 0.01309192f, 0.02062291f, 0.05095891f, -0.00062909f, 0.04538215f, 
    -0.01711292f, 0.01695941f, 0.04820355f, -0.04496752f, -0.02555921f, -0.05562049f, -0.04391005f, 0.02385445f, 
    -0.03100073f, 0.03643759f, 0.05067085f, -0.04573708f, 0.05210669f, 0.03093155f, 0.01555295f, 0.02012566f, 
    0.03541615f, -0.03631819f, 0.02965252f, -0.05002754f, -0.02588450f, -0.05010946f, -0.05622976f, -0.02307649f, 
    -0.02904635f, 0.00943439f, -0.04475101f, -0.01341601f, 0.05221871f, 0.05454213f, -0.02058970f, -0.01452765f, 
    -0.04375435f, -0.03292627f, 0.03711541f, 0.05170759f, 0.02530391f, -0.05227046f, 0.05119767f, -0.05164649f, 
    -0.02692581f, -0.02432800f, 0.03473571f, 0.00148437f, -0.04886103f, 0.02934497f, -0.05504102f, 0.03539701f, 
    0.01857313f, 0.05052369f, -0.01207340f, -0.05007955f, -0.06251467f, 0.02202534f, 0.05123931f, -0.04672237f, 
    -0.02719692f, -0.06140400f, 0.05125034f, 0.01996134f, -0.01737007f, -0.02765412f, -0.04860034f, 0.03254062f, 
    0.01752771f, 0.01863234f, 0.05608252f, 0.00635602f, -0.00684952f, 0.01493544f, 0.00342780f, -0.04269808f, 
    0.04587190f, 0.00200833f, -0.04165180f, -0.00836978f, 0.00057620f, 0.01746618f, -0.04634274f, -0.05173219f, 
    -0.03561131f, 0.03620298f, 0.00660287f, -0.04301632f, -0.05434247f, -0.00566031f, 0.00132357f, 0.03672310f, 
    0.04954917f, -0.05621640f, 0.03898612f, 0.01062270f, -0.04721066f, -0.02130102f, -0.05315414f, -0.01642199f, 
    0.02739288f, 0.02981027f, -0.02017257f, -0.01753520f, -0.01204439f, -0.00127740f, -0.05621510f, -0.03874963f, 
    -0.04315645f, 0.00850905f, -0.02997727f, -0.00844028f, -0.01152244f, 0.02086422f, 0.02458961f, -0.01580973f, 
    0.03228974f, -0.01096854f, -0.01134367f, -0.00932490f, -0.01237833f, -0.00209039f, 0.04574135f, -0.00235409f, 
    -0.04567879f, 0.01453924f, 0.04579895f, 0.02869065f, -0.03756101f, -0.01795486f, 0.02675146f, -0.05078896f, 
    -0.03841114f, -0.00157628f, 0.02465266f, -0.03784490f, 0.00068133f, -0.03961788f, -0.04302086f, -0.04311555f, 
    0.00483407f, 0.04553904f, 0.01389219f, 0.00833540f, -0.00950713f, 0.03508584f, -0.03449729f, 0.00565262f, 
    0.04156457f, 0.04420350f, -0.05016033f, 0.01372017f, 0.03719763f, -0.01417243f, 0.01582692f, -0.02902490f, 
    -0.03737467f, 0.01953925f, -0.00344945f, -0.00586373f, 0.04151959f, -0.04535505f, -0.00813776f, -0.02581554f, 
    -0.05808977f, -0.02879800f, -0.00070705f, -0.05681625f, 0.01768800f, -0.01237466f, -0.00909050f, -0.04992367f, 
    -0.02339414f, -0.00930626f, -0.03191969f, -0.00847511f, -0.03188810f, 0.00558179f, 0.01982836f, 0.03942034f, 
    0.04535512f, 0.01891527f, -0.04507465f, -0.05075788f, -0.02831661f, -0.00839306f, -0.04909762f, 0.05140092f, 
    -0.01293481f, -0.02272777f, -0.04306979f, -0.05270042f, -0.02799064f, -0.03788612f, 0.03315047f, -0.03700801f, 
    -0.05554817f, -0.02500437f, -0.00163948f, 0.02843152f, -0.04122583f, 0.02357659f, 0.00866917f, -0.02617601f, 
    0.01542502f, 0.03724469f, -0.04412770f, -0.04805266f, 0.00774121f, 0.05509206f, 0.01410720f, -0.02347756f, 
    -0.01067201f, -0.00432995f, -0.00879689f, 0.00135073f, 0.01758077f, -0.01321832f, -0.00688706f, -0.02699000f, 
    -0.02439669f, 0.03653918f, 0.00082859f, -0.06011019f, -0.03581434f, -0.02623885f, 0.00733910f, -0.05524589f, 
    -0.00201454f, -0.01222576f, 0.01002453f, 0.02700492f, 0.04488870f, -0.00998410f, -0.04283416f, -0.04311962f, 
    0.04403514f, 0.04620098f, -0.02014901f, 0.01586357f, -0.03368259f, 0.03241185f, -0.03312963f, -0.04352001f, 
    0.01798672f, 0.05370359f, -0.00166149f, 0.00322756f, -0.05514086f, -0.03757554f, 0.02594568f, -0.02853493f, 
    0.01973598f, 0.04565876f, -0.02955937f, 0.03356090f, -0.00976705f, -0.05893211f, -0.01664102f, 0.02668783f, 
    -0.03839048f, 0.00492392f, 0.05093864f, 0.05534196f, 0.01226311f, -0.01961897f, -0.03086806f, -0.00727741f, 
    0.02449814f, 0.05374341f, 0.00439651f, -0.05569785f, -0.02613912f, 0.04276536f, -0.02550272f, 0.03679255f, 
    -0.00796970f, -0.03600796f, -0.02086934f, 0.04610303f, -0.02914201f, 0.00208738f, -0.05709022f, 0.03533054f, 
    -0.00065802f, -0.00672083f, -0.02538783f, -0.01385101f, 0.01574898f, 0.04461965f, 0.01542758f, -0.00542785f, 
    -0.01298727f, -0.04048232f, -0.06049867f, 0.02998989f, -0.05662052f, 0.03296655f, 0.02107601f, 0.00762395f, 
    0.01066565f, -0.00377290f, 0.02935551f, -0.05730611f, -0.00791863f, -0.05515440f, 0.02483831f, -0.04205525f, 
    0.01525053f, -0.02939677f, 0.03433580f, 0.00296218f, -0.03942506f, 0.01063566f, -0.05401642f, -0.02731391f, 
    0.04599278f, 0.03665201f, -0.00089662f, -0.04453330f, 0.04542451f, 0.00380906f, -0.03274687f, -0.03436761f, 
    0.04610550f, -0.05170556f, 0.00189552f, 0.01651895f, -0.03162779f, -0.02050130f, -0.03435334f, -0.03824725f, 
    -0.04073237f, -0.01527176f, -0.05619327f, -0.03125882f, 0.01947697f, -0.04380498f, -0.05644714f, -0.03209569f, 
    -0.03099179f, 0.01091475f, -0.00068514f, 0.02700970f, 0.00326177f, -0.05213238f, 0.01244127f, -0.02680700f, 
    0.04409159f, -0.04252460f, 0.04177779f, -0.00958454f, -0.01897892f, -0.06039927f, -0.01991279f, -0.00783995f, 
    0.02424505f, 0.02191779f, 0.00140178f, -0.03575811f, -0.04315417f, 0.04955950f, -0.04414243f, -0.06049830f, 
    -0.00970169f, 0.04537398f, -0.04358651f, 0.04726696f, 0.01409750f, -0.05352596f, -0.01962760f, -0.02644285f, 
    0.03827214f, -0.01453604f, -0.05331731f, 0.03908297f, 0.00771161f, -0.02804835f, -0.05859526f, 0.02543725f, 
    -0.03621665f, 0.04800671f, 0.02899761f, -0.05571143f, 0.04437319f, 0.04258931f, 0.02516814f, -0.03664022f, 
    0.00553467f, -0.00463491f, 0.01054588f, 0.01074571f, -0.00889577f, 0.03613066f, -0.03616803f, -0.04122510f, 
    0.00072461f, -0.04058541f, -0.03349172f, -0.03613950f, -0.04237972f, -0.03039328f, -0.05194377f, -0.03496551f, 
    -0.00125128f, 0.01855253f, 0.02499341f, 0.05018938f, 0.00854743f, 0.02788387f, 0.04846284f, 0.00026892f, 
    -0.01004347f, -0.03619095f, 0.04426008f, 0.03622213f, 0.02419810f, -0.02765371f, -0.02878132f, 0.03113244f, 
    -0.00583080f, -0.04847624f, -0.02345155f, -0.02885459f, 0.02425512f, 0.03085909f, -0.03550329f, -0.03832460f, 
    -0.03292090f, 0.05379680f, -0.01581511f, -0.00488036f, 0.04639323f, 0.00583430f, 0.01280375f, 0.02476037f, 
    0.02572116f, -0.00868935f, -0.05380251f, -0.00553237f, -0.00232973f, 0.01883018f, -0.04415940f, -0.04916261f, 
    -0.01029649f, -0.05585665f, -0.01015997f, -0.03988346f, 0.04594347f, 0.04233675f, -0.05732415f, -0.05025231f, 
    -0.00302680f, -0.04976296f, 0.00928587f, 0.03113470f, 0.01139203f, -0.00074248f, 0.01228965f, -0.01502277f, 
    0.02363241f, 0.04508996f, 0.02027010f, 0.00075936f, 0.01761811f, -0.00141642f, -0.04776042f, 0.03047978f, 
    -0.02833178f, 0.01002331f, 0.00266493f, -0.05219507f, 0.01648563f, -0.05581201f, 0.01945247f, -0.02248751f, 
    0.02141630f, -0.02381151f, 0.02073440f, 0.00165110f, -0.04766888f, 0.03386276f, -0.03592344f, -0.03727589f, 
    -0.03379812f, -0.04794109f, 0.01852913f, -0.04557621f, -0.04061626f, -0.04096111f, 0.01750842f, -0.01198745f, 
    0.02017878f, 0.02261294f, 0.04939828f, 0.04856024f, -0.00511616f, -0.03252257f, -0.02566162f, -0.04382999f, 
    0.02120502f, -0.02424072f, -0.05751105f, -0.02656363f, 0.03538638f, 0.04125055f, -0.02533597f, -0.05308498f, 
    0.01746994f, 0.02482385f, -0.00275102f, -0.00249708f, -0.02127571f, 0.03932632f, 0.03110202f, 0.00495939f, 
    0.01360287f, -0.03009884f, -0.04181560f, 0.02524553f, -0.03880544f, 0.00566288f, -0.01316717f, 0.01499121f, 
    -0.04438199f, 0.00897576f, -0.02115701f, 0.03281222f, 0.01172997f, -0.00696476f, -0.05420288f, -0.00251913f, 
    0.01538552f, -0.03519243f, 0.01336920f, 0.03639730f, 0.00484002f, -0.05524153f, 0.02065881f, 0.04879393f, 
    0.03861157f, 0.03177482f, -0.03671821f, -0.00858610f, -0.03694702f, 0.01320971f, -0.01285251f, 0.03638259f, 
    -0.03433925f, 0.03540616f, 0.02680972f, 0.01476468f, 0.02696858f, -0.00734989f, 0.03679761f, -0.05730489f, 
    -0.05383635f, 0.03665293f, -0.00318582f, 0.01792503f, 0.04143006f, 0.03019227f, -0.00355810f, 0.04852707f, 
    0.00488769f, -0.02896627f, -0.03989610f, -0.04701691f, -0.00822654f, 0.01544039f, 0.04924363f, -0.04206576f, 
    0.03689396f, -0.05207265f, 0.01836780f, 0.02208900f, -0.05248724f, 0.01043446f, -0.00780346f, -0.04588419f, 
    0.02574854f, -0.04857895f, -0.01230394f, -0.03366446f, -0.00060876f, 0.04307574f, -0.01625019f, 0.02207842f, 
    0.04342609f, -0.00940434f, -0.01742865f, 0.05066443f, -0.00305875f, 0.02073461f, -0.05213939f, -0.03287153f, 
    -0.04131111f, -0.01962244f, -0.03741372f, -0.05028530f, 0.05145741f, 0.00276994f, -0.05381572f, 0.02894380f, 
    -0.00374317f, 0.04520495f, -0.03214525f, 0.00780616f, -0.00564610f, -0.00399254f, -0.04576106f, -0.03339957f, 
    0.01795640f, 0.03602362f, 0.04624053f, -0.02709524f, -0.04675379f, 0.00998468f, -0.05859122f, -0.02837530f, 
    -0.03791077f, 0.01251426f, 0.01673698f, 0.04276471f, 0.04221888f, 0.01042666f, -0.00129045f, -0.05559961f, 
    -0.02261389f, -0.05126153f, -0.01652005f, -0.02540289f, -0.01802496f, 0.02392687f, -0.02661051f, -0.03671725f, 
    0.01460842f, 0.02888824f, -0.01331070f, 0.04490923f, 0.02888830f, 0.02855576f, 0.00405117f, 0.01445087f, 
    0.00426167f, 0.03208669f, -0.02352467f, -0.03855168f, 0.03147982f, 0.04067698f, 0.04590196f, -0.05038104f, 
    -0.01936151f, 0.01604345f, 0.01704581f, 0.01672560f, -0.01082711f, 0.03810375f, -0.01526959f, -0.00308319f, 
    -0.01244867f, -0.01152234f, 0.02508748f, 0.01073636f, -0.04619290f, 0.03123152f, 0.01994024f, -0.01328514f, 
    -0.00169163f, -0.02512369f, -0.05854172f, 0.02242110f, -0.02900453f, -0.00860855f, -0.02410315f, -0.01456823f, 
    0.02558928f, 0.04361115f, 0.03399433f, -0.02709658f, -0.01488885f, -0.03423245f, 0.00207567f, -0.01352161f, 
    0.01542062f, -0.03141640f, -0.02276998f, 0.04405066f, 0.00066086f, -0.01576708f, -0.03092368f, 0.02213928f, 
    -0.02472880f, -0.04688409f, -0.02033350f, -0.02936615f, -0.02734020f, 0.04273931f, 0.01915194f, -0.05131422f, 
    0.04207598f, -0.02494428f, 0.04328931f, 0.01439198f, 0.03041589f, 0.01513320f, -0.04984115f, -0.02784525f, 
    -0.02531173f, -0.05031508f, -0.01528101f, -0.04111965f, -0.01116409f, 0.02664226f, 0.00266165f, 0.03143746f, 
    -0.01894788f, -0.04489233f, 0.00982080f, 0.01499747f, 0.04735394f, 0.02410149f, -0.06020910f, 0.04748302f, 
    -0.02418848f, -0.04046585f, -0.05773775f, 0.01645482f, -0.05279586f, 0.02868794f, 0.04103445f, -0.00373831f, 
    0.00815617f, -0.00919883f, -0.04974426f, -0.01987555f, -0.03102976f, 0.03482676f, 0.05617228f, 0.00766164f, 
    -0.02232022f, -0.03412560f, -0.04821637f, 0.02191113f, -0.01750100f, -0.05046362f, 0.03037368f, -0.05373022f, 
    -0.04427946f, 0.02791942f, -0.05232949f, 0.03320592f, 0.02889229f, -0.01864189f, 0.04094583f, -0.05479788f, 
    -0.01482140f, 0.04429568f, 0.03484694f, -0.02793408f, 0.04199138f, 0.04084908f, -0.01208585f, -0.03927192f, 
    -0.02606948f, -0.04517659f, -0.02663971f, 0.04892835f, -0.05827412f, -0.04615481f, -0.04981538f, 0.02641225f, 
    -0.05895961f, 0.02327187f, 0.00489763f, -0.01809982f, 0.03236997f, -0.05636011f, -0.02474953f, -0.05032620f, 
    -0.02318602f, -0.03865615f, 0.04147508f, 0.02250168f, -0.05189077f, -0.01163398f, -0.03174160f, -0.02497444f, 
    -0.05257164f, -0.05017617f, 0.02500735f, -0.02493433f, 0.00252128f, 0.04167863f, -0.05996024f, 0.03704425f, 
    0.03236098f, 0.04867742f, -0.03013090f, 0.00698540f, 0.04801439f, -0.03534198f, 0.01234227f, -0.00147785f, 
    0.02632534f, -0.03260862f, -0.03605511f, 0.04606222f, -0.02485238f, 0.00300782f, 0.02140221f, 0.01919405f, 
    0.04473162f, -0.00845827f, -0.00436348f, -0.02591285f, 0.02572881f, 0.01644239f, -0.01279845f, -0.03950543f, 
    -0.04228821f, -0.00217937f, -0.03299085f, 0.03144446f, -0.01129246f, 0.01384915f, -0.03882861f, -0.05330262f, 
    -0.04701695f, -0.06022652f, 0.02021526f, 0.02830967f, -0.05671761f, -0.03942988f, 0.04850304f, -0.04325286f, 
    0.04318748f, 0.00467594f, 0.02547897f, -0.04244060f, -0.01974211f, -0.04822110f, -0.03165852f, -0.04457606f, 
    -0.02041590f, -0.03052708f, -0.05025120f, -0.03595178f, 0.01849271f, 0.01554573f, 0.04314996f, -0.04206463f, 
    -0.00945446f, 0.03106667f, -0.02785445f, 0.00782490f, -0.03186252f, -0.02170929f, -0.03666701f, -0.00512846f, 
    0.05394740f, 0.02114460f, 0.03280398f, 0.02781023f, -0.04980466f, -0.05579354f, -0.02131392f, 0.01014134f, 
    0.01655618f, -0.04357367f, -0.02610654f, 0.04385782f, 0.03673605f, 0.02441758f, 0.02379651f, 0.01468481f, 
    -0.05340132f, -0.00296256f, -0.05767477f, 0.03759469f, 0.03441647f, 0.02555137f, 0.00260443f, -0.01991635f, 
    0.02151585f, 0.01887186f, -0.05972866f, -0.03025742f, -0.06024023f, 0.03764753f, 0.02880075f, 0.03046676f, 
    -0.02968756f, 0.04250886f, 0.04383149f, -0.03745706f, 0.03920567f, -0.03487463f, -0.06835426f, -0.03266988f, 
    -0.01906843f, -0.00916497f, 0.04636499f, -0.01190315f, -0.02607436f, -0.04122172f, 0.04366204f, 0.03552235f, 
    0.00305298f, 0.05611924f, 0.02820441f, -0.06039076f, 0.01879573f, -0.04967919f, -0.06191186f, 0.04432650f, 
    0.31116906f, -0.08392466f, 0.63805956f, 0.13415362f, 0.06426729f, 0.01827456f, -0.01350085f, 0.14719430f, 
    0.00272918f, 0.02457215f, 0.09168150f, 0.05759166f, 0.11369237f, -0.03911357f, 0.01422822f, 0.00007201f, 
    0.07974616f, 0.05638543f, 0.05173899f, 0.15505469f, -0.04153871f, -0.17485954f, -0.26910815f, -0.28150278f, 
    -0.40679118f, -0.00762555f, 0.04623445f, 0.02481459f, -0.08728274f, 0.02170586f, 0.07495330f, 0.06380156f, 
    0.02160672f, -0.06015215f, 0.03933178f, 0.05089219f, 0.07697155f, 0.00319936f, -0.06626795f, 0.08171487f, 
    0.08515370f, 0.01626731f, 0.27006951f, -0.11287027f, 0.17795621f, 0.07256120f, 0.07077409f, 0.01517628f, 
    -0.17018707f, -0.01916306f, 0.08804884f, 0.09609328f, 0.06437352f, 0.08577360f, -0.08241539f, 0.08405797f, 
    0.12367678f, -0.03752669f, 0.03044089f, 0.18203051f, 0.18284225f, -0.35690215f, -0.30934095f, -0.20461670f, 
    -0.19164799f, 0.02506478f, 0.00491149f, 0.06407686f, -0.03288947f, 0.05028041f, -0.07072821f, -0.05722586f, 
    -0.01604194f, -0.05506749f, 0.00732632f, 0.09627257f, -0.00009581f, 0.01703899f, -0.07033657f, 0.08024260f, 
    -0.08546049f, 0.30686831f, 0.29790369f, 0.06044600f, -0.02069395f, 0.03327262f, -0.04810189f, 0.19316223f, 
    0.06250990f, -0.08499268f, 0.12937355f, -0.01229064f, 0.09798860f, 0.25224292f, -0.03207181f, 0.05706055f, 
    0.07463217f, -0.08727717f, -0.01962125f, -0.03349955f, 0.07941797f, 0.08363544f, 0.05361981f, 0.07024964f, 
    0.07636971f, -0.03989256f, 0.07917693f, -0.00772619f, -0.00512387f, 0.15297563f, 0.07290652f, 0.07214453f, 
    -0.00664983f, -0.14865381f, 0.14454807f, 0.15417834f, -0.13541277f, 0.20729244f, 0.04972186f, 0.02537876f, 
    0.18236437f, 0.02764946f, 0.11532689f, 0.19303524f, 0.20361069f, 0.03960437f, -0.00580761f, -0.01388407f, 
    -0.05652598f, -0.01762702f, 0.09636570f, 0.08233810f, -0.01728244f, -0.07131541f, -0.05881885f, 0.03037809f, 
    -0.01599568f, 0.03106468f, 0.05457992f, -0.01891226f, 0.08303659f, 0.41337961f, 0.34345767f, 0.16387154f, 
    0.19993678f, 0.04808820f, -0.04335109f, -0.03291842f, 0.01930116f, 0.07283521f, -0.02508087f, -0.00144110f, 
    0.10270073f, 0.11985265f, 0.24713613f, -0.00726328f, -0.02019991f, 0.05588744f, -0.00211084f, -0.01883283f, 
    -0.12317130f, 0.42351025f, -0.47868466f, -0.15611282f, -0.04578172f, -0.13456482f, 0.08017977f, 0.01208207f, 
    -0.10991759f, -0.01493042f, 0.01378207f, 0.02691203f, -0.02349326f, -0.05514265f, 0.11997481f, -0.07684068f, 
    -0.00133539f, 0.14609119f, 0.00109355f, 0.05537201f, 0.50776827f, 0.04803434f, 0.12604153f, -0.12479152f, 
    0.14011659f, -0.02609007f, 0.14071150f, -0.07310566f, 0.09025103f, -0.05266657f, 0.08515966f, -0.08022537f, 
    -0.03708997f, 0.00370122f, 0.13689576f, -0.01833518f, 0.10405480f, 0.05466358f, 0.01178241f, -0.05129618f, 
    -0.45207423f, 0.16573583f, 0.30958265f, 0.16151491f, -0.33201766f, -0.04968610f, 0.12314072f, 0.05433412f, 
    -0.02121249f, 0.09802677f, 0.00599620f, 0.03451785f, 0.03644216f, -0.03114988f, 0.24482110f, -0.01376165f, 
    0.05468468f, 0.02542105f, 0.06835020f, 0.12672235f, -0.06113361f, 0.06327046f, 0.08938516f, -0.02043664f, 
    0.22211756f, 0.01093365f, -0.04845586f, 0.19588582f, 0.02015647f, 0.04252775f, -0.03496019f, 0.04104831f, 
    0.06731559f, 0.05009861f, -0.04004854f, 0.11126243f, 0.11845648f, 0.03833200f, -0.02814666f, -0.06096089f, 
    0.03213031f, -0.08862683f, -0.22416830f, -0.16505435f, -0.09423617f, -0.02772839f, 0.05825528f, 0.08902142f, 
    0.09206388f, 0.01077335f, 0.01994561f, -0.15619932f, 0.01965840f, 0.02102965f, 0.00937529f, 0.08063185f, 
    0.12240048f, -0.10079487f, -0.10841382f, 0.03361193f, -0.24226034f, 0.44764531f, -0.02003112f, 0.21558200f, 
    0.06317181f, -0.02283691f, 0.06821986f, 0.03352936f, -0.02703561f, 0.15113546f, 0.07540126f, -0.02434554f, 
    0.08061875f, 0.03389125f, 0.05228807f, -0.06593660f, -0.07559772f, 0.03396378f, -0.01745007f, -0.04642544f, 
    -0.15637255f, 0.07986148f, -0.10441987f, 0.00322458f, 0.03800524f, -0.12256132f, 0.08991901f, 0.01024913f, 
    -0.09713113f, -0.02471879f, -0.01534594f, 0.07694518f, 0.02111098f, -0.03406033f, 0.13729930f, -0.14529862f, 
    0.09853844f, -0.00951914f, 0.01794672f, -0.03728874f, 0.02094747f, -0.27640846f, -0.10765786f, -0.05368209f, 
    -0.34694338f, 0.02097929f, 0.12030346f, 0.24344809f, -0.06659392f, 0.00658484f, -0.15918626f, 0.06014444f, 
    -0.05479601f, 0.17729995f, 0.12008195f, 0.06140413f, -0.02654187f, -0.07981688f, -0.06798768f, -0.10661305f, 
    0.04532387f, -0.04611373f, 0.03156949f, -0.01980185f, 0.00336346f, -0.03993594f, 0.00855547f, 0.02283562f, 
    0.01303013f, -0.00729573f, 0.03533400f, 0.04344750f, -0.03797261f, -0.04096989f, -0.03849457f, -0.03511881f, 
    -0.02488329f, -0.03942133f, -0.04823254f, -0.01834879f, 0.00225071f, 0.01110832f, -0.03145348f, -0.00648536f, 
    -0.00204993f, -0.00186151f, -0.06066614f, -0.02344727f, 0.03005605f, -0.01244957f, 0.01761176f, 0.02728057f, 
    -0.02840064f, -0.05825105f, -0.02028940f, 0.03610008f, 0.04496785f, -0.03396344f, 0.04334343f, -0.00121308f, 
    0.00599231f, -0.05539693f, 0.03645654f, 0.01321063f, 0.00983511f, 0.02643263f, -0.03209068f, -0.01199366f, 
    0.00674211f, -0.03956836f, 0.01116171f, 0.01249889f, 0.00335481f, 0.00259451f, -0.04769641f, 0.04347635f, 
    -0.01190967f, -0.00993245f, -0.04441352f, 0.00813326f, 0.00039970f, 0.03318682f, -0.00451996f, -0.00019310f, 
    -0.00647962f, 0.03688170f, 0.01459428f, -0.05125136f, 0.04938201f, -0.02171556f, -0.03571494f, 0.02519328f, 
    0.03936730f, -0.03523814f, -0.01498817f, -0.00958265f, 0.03568209f, 0.02599783f, -0.02424489f, 0.04807327f, 
    -0.05740967f, 0.02101260f, 0.03454829f, 0.01356212f, 0.00966130f, -0.00874387f, 0.03541204f, 0.03011554f, 
    0.02911406f, -0.02957950f, -0.03257394f, -0.01544094f, -0.02861581f, 0.05147575f, -0.00953148f, 0.03255632f, 
    0.00226745f, 0.02236466f, -0.01543309f, -0.01819343f, 0.02341428f, -0.02489993f, -0.03357483f, -0.04243859f, 
    -0.05371219f, -0.06449553f, -0.03536233f, -0.05089866f, 0.00214750f, 0.03266890f, 0.02135438f, -0.04396340f, 
    -0.05389803f, -0.02494450f, 0.01481196f, -0.04172734f, 0.02927808f, 0.00863482f, -0.04359599f, -0.02619662f, 
    -0.05938320f, 0.03468589f, -0.04652311f, 0.03077567f, 0.02822085f, 0.02798527f, 0.00251135f, -0.01765376f, 
    -0.02969524f, -0.05739442f, 0.04238063f, 0.02750064f, -0.04702776f, -0.05577683f, -0.03713196f, 0.02733383f, 
    0.02154052f, -0.06240425f, -0.00270784f, -0.04846109f, -0.01798237f, -0.04047604f, 0.03650730f, -0.04701344f, 
    0.02133823f, 0.02328103f, 0.00162113f, 0.00272657f, 0.01197007f, -0.02419051f, -0.00335078f, -0.04156406f, 
    0.02084637f, -0.01340936f, -0.02152480f, 0.03928119f, -0.01639207f, -0.04942062f, -0.04484256f, -0.02189614f, 
    -0.05632425f, 0.03280939f, 0.01866836f, -0.01068623f, -0.06063570f, 0.02278426f, 0.04563667f, -0.05530126f, 
    0.01535810f, 0.02317984f, 0.02332780f, -0.00277401f, 0.02814643f, -0.02080202f, 0.03650590f, -0.04251131f, 
    -0.04569769f, 0.00361010f, -0.06250765f, 0.00972097f, -0.00251842f, -0.05603446f, -0.00846495f, 0.04253178f, 
    -0.01825153f, -0.01551418f, 0.04317945f, 0.03611642f, 0.01922371f, -0.04441088f, 0.00670350f, -0.06067024f, 
    -0.02396981f, 0.02576014f, 0.02148196f, -0.03923093f, 0.04625386f, -0.00388700f, 0.04189035f, -0.01433237f, 
    -0.05327792f, -0.01910101f, -0.02421476f, -0.00020559f, -0.03730590f, 0.03151724f, 0.04323994f, -0.03916944f, 
    -0.00826581f, -0.03999056f, 0.01591222f, -0.03092677f, -0.04900376f, 0.01108911f, -0.02475377f, -0.06073913f, 
    0.03477188f, -0.03241311f, 0.01579506f, 0.03676677f, -0.02244161f, -0.01259444f, -0.04853318f, -0.03755855f, 
    -0.01780288f, -0.03260305f, 0.02370181f, 0.02332917f, -0.03368042f, 0.03496706f, -0.01387520f, 0.00071088f, 
    0.00181675f, 0.04877326f, -0.02499733f, -0.04821885f, 0.00780265f, -0.05590298f, -0.02986839f, 0.03541372f, 
    -0.04414625f, -0.01285792f, 0.00469076f, -0.03957110f, -0.01857504f, 0.01957207f, 0.03784175f, -0.00361795f, 
    -0.02942882f, -0.03740314f, -0.00429064f, 0.02588416f, 0.00057344f, 0.03258324f, -0.05250065f, 0.04104486f, 
    -0.01044392f, 0.00498510f, 0.01826372f, -0.02085033f, 0.03273712f, -0.02642357f, 0.04879802f, 0.04214234f, 
    -0.05289603f, 0.01424931f, -0.00034087f, 0.00110113f, 0.03805537f, 0.01895440f, -0.04497809f, -0.04903173f, 
    -0.03440178f, -0.00180661f, 0.04782639f, 0.03410313f, -0.00567859f, -0.01548540f, 0.02389316f, -0.04500487f, 
    0.02969091f, -0.04985384f, 0.02436189f, 0.01743693f, -0.04539428f, -0.04299064f, -0.03401730f, -0.01739656f, 
    -0.01380477f, -0.03643014f, -0.04031563f, 0.03974752f, -0.04462219f, 0.00474575f, 0.02881541f, -0.05024728f, 
    0.00674536f, -0.00707655f, -0.03312817f, 0.05142749f, 0.03281681f, 0.01508613f, 0.01307711f, -0.03738010f, 
    0.02605823f, -0.06084561f, -0.01575596f, -0.01380185f, -0.03628837f, 0.02166158f, -0.01603640f, -0.02504064f, 
    -0.03345203f, -0.02906834f, -0.03798185f, 0.00753402f, -0.06482106f, 0.01423769f, 0.00544324f, -0.02888626f, 
    0.30671147f, -0.07248255f, 0.34379035f, -0.01002976f, -0.15232256f, -0.05343967f, -0.02691053f, 0.00968166f, 
    0.02179463f, -0.00670848f, -0.04940247f, 0.10440003f, 0.04777796f, -0.03037187f, -0.04171722f, 0.07134402f, 
    0.19004098f, 0.02231197f, 0.13747293f, 0.04784002f, 0.19940311f, 0.10765209f, -0.36059326f, 0.13417400f, 
    -0.48550382f, 0.10385537f, 0.08320496f, -0.01628365f, -0.05826849f, 0.04204113f, -0.08011553f, 0.06748623f, 
    -0.05596746f, 0.02600879f, 0.07122000f, 0.01987487f, 0.08141825f, -0.00988217f, 0.02052110f, -0.07628804f, 
    -0.27084610f, -0.22465953f, 0.30389589f, -0.18582428f, 0.19001345f, 0.16848807f, 0.07421027f, 0.09147335f, 
    -0.15487763f, 0.10970722f, 0.05447939f, 0.13535452f, 0.06817345f, 0.05840128f, -0.00189282f, 0.02290636f, 
    0.03692207f, -0.01911232f, 0.02621949f, 0.10028350f, -0.08082446f, -0.25408483f, -0.16431433f, -0.00580145f, 
    0.06398717f, -0.08372268f, -0.03774908f, -0.04085666f, 0.08614283f, 0.18625638f, 0.13844278f, 0.05230223f, 
    0.01502544f, -0.00584749f, -0.07196896f, 0.00063253f, 0.02219046f, -0.04705352f, -0.05644249f, 0.14202486f, 
    0.15329039f, 0.00281603f, 0.14955181f, -0.16437393f, 0.02952118f, 0.01896765f, -0.19774552f, 0.09061605f, 
    -0.00637909f, 0.03285191f, -0.09001746f, -0.11680477f, 0.09324639f, 0.13887228f, -0.01752727f, 0.11908484f, 
    0.02213227f, -0.08865616f, 0.00347622f, -0.06539453f, -0.43970951f, 0.11275182f, 0.21987133f, 0.03256471f, 
    0.06930811f, -0.01252772f, 0.10524020f, -0.02153444f, -0.10794276f, 0.07120548f, -0.00120994f, 0.06888953f, 
    0.12214304f, -0.07970349f, 0.07276610f, 0.01079539f, -0.19767366f, 0.06238483f, 0.09029354f, -0.03766287f, 
    0.20643650f, -0.05932048f, 0.01489720f, 0.23578446f, 0.04637755f, -0.05234077f, -0.01578407f, -0.09959519f, 
    -0.04723951f, -0.05323969f, -0.02643348f, 0.03104291f, -0.05086962f, -0.06032238f, -0.07359037f, 0.04778687f, 
    -0.08465376f, 0.18120688f, 0.01797435f, 0.04090451f, 0.35126480f, 0.03049086f, 0.10820030f, 0.10338312f, 
    0.18525437f, -0.10148311f, -0.13388547f, -0.05804406f, 0.01819958f, 0.03025348f, -0.03029524f, -0.05963475f, 
    -0.02167958f, 0.00829609f, 0.11326122f, 0.04777424f, 0.01886072f, 0.03352803f, 0.07943899f, 0.02310133f, 
    -0.33848387f, 0.02976215f, -0.27393582f, -0.20147526f, 0.00116085f, -0.12412808f, 0.07879967f, -0.07736780f, 
    -0.06556066f, -0.05080793f, -0.01130565f, -0.03897947f, 0.08724130f, 0.04614958f, 0.01959404f, 0.08363008f, 
    0.04997044f, 0.12303191f, -0.12017706f, 0.13912185f, 0.29033929f, 0.28993681f, -0.00806671f, -0.11866940f, 
    0.07856897f, -0.00340278f, 0.20603365f, -0.02300616f, 0.11732724f, -0.17533539f, 0.23458992f, 0.15873441f, 
    -0.04406055f, -0.19080217f, 0.20691116f, -0.03260235f, 0.16815411f, -0.04680584f, 0.06122437f, -0.08005069f, 
    -0.26173896f, 0.13355030f, 0.19254912f, 0.07635257f, -0.51227707f, -0.06069659f, 0.02051190f, 0.07700605f, 
    -0.00782919f, 0.09458622f, -0.01836457f, 0.08758570f, 0.14250129f, 0.05964059f, 0.15321678f, 0.06969945f, 
    0.09318832f, -0.02495026f, 0.01462614f, 0.12021845f, 0.07746165f, -0.03445299f, 0.27571699f, -0.11791098f, 
    0.37321270f, 0.00487795f, -0.15135778f, -0.08638851f, 0.08131128f, 0.02519270f, -0.09360900f, -0.01754078f, 
    -0.04021860f, 0.12730996f, 0.05482684f, 0.11986659f, 0.01264399f, -0.07038824f, -0.00994495f, -0.06951191f, 
    0.09030698f, 0.21262065f, -0.35580277f, -0.03930501f, -0.34903789f, 0.01758587f, 0.13128121f, -0.00100985f, 
    0.12479566f, 0.09036502f, -0.00649580f, -0.04502035f, -0.01325912f, -0.02561767f, 0.01881538f, 0.04037757f, 
    0.14365767f, -0.04746461f, -0.06553641f, 0.05385579f, -0.27338612f, 0.30972463f, 0.13454796f, 0.01955666f, 
    0.00556384f, 0.02155769f, -0.03728882f, -0.01584532f, -0.07281210f, 0.17580712f, 0.07108374f, -0.05127352f, 
    -0.01542339f, -0.01149788f, -0.02050498f, -0.12975454f, 0.11678685f, 0.07496799f, -0.08050027f, 0.05916139f, 
    0.05289657f, -0.15407285f, -0.09184320f, -0.08145609f, 0.10842457f, 0.07125147f, 0.07931238f, 0.08915830f, 
    0.03382449f, 0.01515881f, 0.14917000f, -0.02835876f, 0.10337771f, 0.04838675f, 0.14133392f, -0.02037931f, 
    0.00167575f, -0.07422319f, -0.06012642f, -0.17564496f, -0.01387078f, -0.30242953f, 0.08668947f, -0.05582653f, 
    -0.03079109f, -0.02285212f, -0.10552845f, 0.18222149f, 0.05917866f, 0.07884353f, -0.03700944f, 0.02409766f, 
    -0.06355493f, 0.07632319f, -0.01757975f, 0.11764449f, 0.00064043f, -0.35268933f, -0.12005799f, -0.11979096f, 
    -0.02463740f, -0.02350578f, -0.00591969f, -0.05026222f, -0.04254542f, -0.01136397f, -0.00216952f, 0.03891056f, 
    0.00010035f, 0.00146392f, 0.03491955f, -0.04208934f, -0.02343187f, 0.04180796f, -0.05133268f, -0.04049323f, 
    -0.01350620f, -0.03863200f, 0.00888588f, 0.01957069f, -0.02246160f, -0.01864878f, -0.01926214f, 0.00608348f, 
    0.01268499f, -0.02787961f, -0.05771680f, 0.00228995f, 0.01540586f, -0.05859417f, 0.04151729f, -0.02189979f, 
    -0.04144790f, -0.03323353f, -0.00247931f, -0.05670625f, 0.01105373f, 0.04402396f, -0.05354334f, -0.00518264f, 
    -0.00040742f, 0.01647563f, 0.00142319f, -0.03960806f, -0.05301951f, -0.02132714f, 0.02666650f, 0.02996049f, 
    -0.02779393f, -0.04182767f, 0.01237935f, 0.02428018f, -0.04967572f, 0.04887316f, 0.04903263f, 0.03644765f, 
    0.00890912f, -0.00161699f, 0.00843557f, 0.01737628f, 0.00659346f, -0.05097502f, -0.05617173f, -0.00179264f, 
    -0.05928565f, -0.00860706f, 0.01474815f, -0.00717202f, 0.01548908f, -0.05805861f, -0.01634736f, 0.02951974f, 
    0.03620431f, 0.01730631f, -0.01133857f, 0.04680710f, 0.00522746f, -0.04133247f, -0.02022488f, -0.03614420f, 
    0.01132272f, 0.01619143f, -0.02533486f, -0.03557672f, -0.02114318f, -0.04108283f, 0.03877324f, -0.05568447f, 
    -0.01895968f, 0.02719429f, -0.03719166f, -0.02487999f, 0.03552322f, 0.02372989f, 0.01882670f, 0.00352568f, 
    -0.03964512f, -0.05546299f, -0.02108108f, -0.00829316f, 0.00015550f, 0.04590374f, -0.03106184f, 0.04516406f, 
    0.01249179f, -0.06097007f, -0.04183981f, 0.03743422f, 0.01058653f, 0.05058321f, 0.03372728f, -0.04447743f, 
    -0.02709072f, 0.01041858f, 0.04257881f, 0.04380593f, -0.03667868f, -0.04380596f, -0.04206019f, -0.05617776f, 
    -0.03252173f, 0.05507340f, -0.04194641f, -0.03978807f, -0.03899387f, -0.04286689f, -0.00479829f, 0.02781520f, 
    -0.00540493f, 0.00464524f, -0.00353052f, -0.05083770f, 0.03877448f, -0.05603415f, -0.05815958f, -0.01461395f, 
    0.01523902f, -0.04207383f, -0.04536966f, 0.01832257f, -0.01285597f, -0.01596472f, 0.03010720f, -0.03040963f, 
    -0.04169308f, 0.00562132f, -0.02759917f, 0.00931510f, 0.00280747f, -0.04087800f, -0.05522543f, 0.04781877f, 
    0.02984023f, -0.03610649f, -0.05212338f, -0.04354410f, -0.00396238f, -0.06170942f, -0.00536897f, -0.03335682f, 
    -0.04336939f, 0.04628396f, 0.04717060f, 0.04175760f, 0.02207366f, -0.04347474f, 0.02769922f, -0.02028643f, 
    -0.02534578f, -0.02941711f, -0.04231482f, -0.05065904f, 0.02118389f, 0.05641046f, -0.03281732f, 0.04350252f, 
    0.01255679f, -0.00718802f, -0.01369230f, 0.00979806f, -0.04741102f, -0.05715520f, -0.02589936f, -0.02135904f, 
    -0.03762538f, 0.00961807f, -0.05277240f, 0.01571071f, -0.04160194f, -0.03889419f, 0.00252246f, 0.03746577f, 
    0.02170921f, 0.04710817f, 0.01959342f, 0.00449747f, 0.02542828f, 0.02448506f, -0.01059125f, 0.03952174f, 
    0.03015221f, -0.00334479f, 0.04098615f, 0.03823973f, -0.01143423f, 0.01083565f, -0.00978906f, -0.05056326f, 
    -0.00840333f, 0.04339870f, -0.00384754f, 0.04857785f, -0.04959517f, -0.05850140f, 0.00790332f, -0.03750597f, 
    -0.01248057f, 0.03659014f, 0.01100282f, 0.00147430f, 0.03419767f, 0.00385689f, 0.00809412f, -0.03882580f, 
    -0.03038460f, 0.04205613f, -0.03691725f, -0.00233854f, 0.01753997f, -0.04959898f, 0.03773642f, -0.02620655f, 
    0.03352093f, 0.03305789f, -0.02623346f, 0.03671791f, -0.02959548f, 0.03248285f, -0.01109275f, -0.01566256f, 
    -0.00083578f, 0.01553041f, 0.03471746f, 0.00591637f, -0.01398805f, 0.05450453f, -0.03334545f, -0.01176681f, 
    -0.01274740f, -0.02327135f, 0.03607402f, -0.02183438f, 0.02772482f, 0.02639928f, 0.03076484f, 0.04170421f, 
    0.02566856f, -0.00981087f, 0.00229132f, 0.01376132f, -0.00833869f, 0.01767948f, -0.03324990f, 0.04342688f, 
    -0.02504602f, -0.02184342f, 0.02378637f, 0.04432185f, 0.03635748f, 0.04053087f, 0.00091004f, -0.04026241f, 
    -0.01620449f, 0.03514938f, 0.04236392f, -0.03999487f, -0.03038771f, -0.03071426f, -0.04537875f, 0.00258631f, 
    0.05371476f, 0.01761772f, 0.03418873f, -0.03777948f, 0.02919638f, -0.04208105f, -0.02278072f, -0.04145413f, 
    0.00837066f, -0.01242714f, 0.03378474f, 0.02084731f, -0.02838845f, 0.00056557f, 0.02893886f, 0.02415190f, 
    -0.00855990f, -0.04871637f, 0.00150077f, 0.03286545f, -0.02688207f, -0.00158814f, 0.01445260f, -0.03324628f, 
    0.00874572f, 0.02785328f, 0.03278753f, 0.04349688f, 0.02925351f, -0.01675466f, -0.01349679f, 0.00310906f, 
    -0.05013114f, 0.02897321f, 0.03132401f, -0.06023532f, 0.04027389f, 0.03230705f, -0.04961540f, 0.01656840f, 
    0.41826266f, 0.24343483f, 0.22688980f, 0.13140649f, 0.06629084f, 0.14370899f, 0.06036632f, 0.16041172f, 
    -0.04791468f, 0.00407686f, 0.02185729f, -0.06215875f, 0.09085499f, -0.06703858f, -0.13007921f, -0.07130811f, 
    0.10190366f, -0.05940163f, 0.06252333f, 0.03874210f, -0.24443713f, -0.11530977f, -0.04574465f, -0.22250721f, 
    -0.07963643f, 0.02120745f, 0.08228844f, 0.02771208f, -0.02658454f, 0.07515016f, 0.09074163f, 0.08274498f, 
    0.00628433f, 0.03116256f, 0.02778098f, 0.05067937f, 0.01854531f, 0.00678847f, -0.03522190f, 0.04214473f, 
    -0.22171913f, -0.31136549f, 0.12502834f, -0.16784029f, -0.03897673f, -0.17043298f, 0.01060344f, -0.11397425f, 
    0.01250403f, 0.01953271f, 0.06341811f, 0.02604805f, 0.01420074f, 0.09069571f, -0.12177726f, 0.00281124f, 
    0.06156861f, -0.06367754f, 0.05156330f, 0.07682379f, -0.02038921f, -0.20350604f, -0.38648257f, -0.18610416f, 
    0.01227269f, 0.15868445f, -0.06390020f, -0.00654582f, -0.13330922f, 0.10775292f, -0.01477876f, -0.02415790f, 
    0.04386168f, 0.01173011f, -0.01458899f, 0.03184725f, 0.03493992f, 0.03892387f, -0.02542085f, 0.03499798f, 
    0.06907901f, 0.15229645f, 0.18615521f, 0.03735070f, 0.02764381f, 0.01890851f, 0.01231549f, -0.05709292f, 
    0.03157628f, 0.04325189f, 0.18227862f, 0.01902413f, 0.11663413f, 0.18946551f, 0.08038462f, -0.07317386f, 
    0.01913480f, -0.04573597f, 0.07660553f, -0.01832564f, -0.13793537f, -0.06744689f, -0.03531016f, -0.04826491f, 
    0.09855316f, 0.01722301f, 0.01003841f, -0.09759961f, -0.08433186f, -0.11887439f, -0.00583274f, 0.02424772f, 
    -0.01140009f, -0.10251261f, 0.02915848f, 0.07633211f, 0.06940784f, 0.16953221f, 0.01496868f, 0.09620091f, 
    0.00150236f, 0.17401749f, 0.03041021f, 0.03777857f, 0.10723657f, 0.27705616f, 0.03669950f, -0.06602183f, 
    -0.07808276f, 0.00833304f, 0.13130055f, -0.00678127f, 0.03646329f, 0.11009619f, -0.03436413f, 0.02683538f, 
    0.06346370f, 0.01761690f, 0.04489458f, -0.12286759f, 0.07611351f, 0.21274902f, 0.29560047f, 0.23752116f, 
    0.03881435f, 0.04965604f, 0.21365146f, -0.01394248f, -0.11860736f, 0.10740716f, 0.12836236f, 0.01705671f, 
    0.03946966f, 0.01238276f, 0.13479859f, -0.13620400f, -0.00166316f, 0.11688755f, 0.08010104f, -0.08647417f, 
    0.00344291f, 0.10783031f, -0.11867820f, -0.00608873f, 0.09271080f, -0.08299476f, 0.09529994f, 0.03874011f, 
    -0.02688839f, 0.01584421f, 0.02439282f, 0.13130219f, -0.00778920f, 0.04127841f, 0.13552152f, -0.03704214f, 
    -0.03696334f, 0.12822835f, -0.01485810f, 0.06064264f, 0.19762617f, -0.12115178f, -0.00061671f, 0.11583192f, 
    0.14358184f, -0.00759163f, -0.03921921f, 0.04106324f, 0.03066919f, -0.06162554f, -0.01839620f, -0.05635807f, 
    -0.04504604f, -0.04507758f, 0.10499401f, 0.03420196f, 0.01536310f, 0.03256801f, 0.03384124f, -0.11127639f, 
    -0.10476595f, 0.21034604f, 0.21086639f, -0.03483891f, 0.04076351f, 0.11767609f, 0.05276879f, -0.03532378f, 
    0.00108694f, 0.03871331f, -0.06860573f, -0.06121471f, -0.02380874f, 0.01665924f, -0.00767890f, 0.10139710f, 
    0.10985068f, -0.04401547f, -0.01116805f, 0.04994929f, -0.17457680f, 0.20841467f, -0.08299614f, 0.31154209f, 
    0.05798849f, -0.00866158f, 0.06729091f, 0.09447233f, -0.16603537f, -0.01904721f, 0.08842909f, -0.06700212f, 
    0.10663164f, 0.05445079f, 0.01471493f, -0.07373760f, -0.02837346f, -0.11840209f, 0.09893039f, 0.03225696f, 
    -0.28109187f, -0.17873217f, -0.01236252f, 0.07312816f, 0.29868528f, -0.02280994f, -0.03254161f, 0.10569614f, 
    0.10591364f, 0.02239058f, 0.00819000f, -0.08135635f, 0.09307792f, 0.00735708f, -0.00329249f, 0.12367229f, 
    0.00484880f, -0.05437808f, -0.08143717f, 0.17775853f, 0.19879843f, 0.13779709f, -0.06689907f, 0.24646193f, 
    0.06441282f, -0.02695269f, 0.08379900f, -0.10497424f, -0.00850618f, 0.13460790f, 0.02974607f, 0.05473001f, 
    0.00793240f, 0.05235491f, -0.10880830f, 0.10052098f, 0.04154439f, 0.10369663f, -0.00781822f, 0.04538614f, 
    -0.44364589f, -0.17136940f, -0.03228766f, -0.02322584f, -0.16831878f, -0.08903202f, 0.08664348f, 0.07287185f, 
    -0.07343168f, 0.00599367f, 0.03337595f, -0.02162111f, 0.12181928f, 0.00690061f, -0.00358603f, -0.05576703f, 
    0.21526241f, -0.13866058f, -0.00044094f, 0.08530714f, 0.07668316f, -0.22197148f, -0.32664847f, -0.15855770f, 
    -0.39609179f, -0.06281422f, 0.14426918f, -0.11124887f, -0.06162011f, -0.10209263f, -0.07228097f, 0.02826841f, 
    -0.04025233f, 0.12437009f, 0.10577802f, 0.12552084f, -0.09805411f, -0.15034012f, -0.08879304f, -0.01302124f, 
    -0.05039337f, -0.00548210f, 0.03845181f, 0.02663875f, -0.00634898f, 0.02340409f, 0.03419514f, 0.00249103f, 
    0.00556955f, -0.01868543f, 0.04083727f, 0.03989636f, -0.06372152f, -0.03933829f, 0.00818031f, 0.00986498f, 
    0.02104431f, 0.03978223f, 0.00212089f, 0.00994901f, 0.04241929f, 0.02700345f, -0.00627424f, -0.03751664f, 
    -0.05739352f, 0.00371534f, 0.00682825f, 0.01800055f, 0.03815745f, 0.03078575f, -0.00589985f, -0.04644182f, 
    -0.05830880f, 0.02888692f, 0.00740791f, -0.02820081f, -0.05294240f, -0.04026888f, 0.02669620f, -0.00982952f, 
    -0.06066117f, 0.00004123f, 0.04428085f, 0.04801464f, -0.00740533f, 0.02844100f, 0.04854738f, 0.03564051f, 
    -0.01627451f, 0.03086829f, 0.00612236f, 0.03166769f, -0.02550994f, 0.00985370f, -0.05853010f, -0.03498686f, 
    -0.05728448f, -0.00258391f, 0.03295758f, -0.03445492f, 0.01264341f, -0.03353614f, -0.00998813f, -0.04975803f, 
    0.02276542f, 0.04560438f, 0.04839056f, -0.02064540f, 0.02812078f, 0.04197342f, 0.00347435f, 0.01795017f, 
    -0.02748668f, 0.04507154f, -0.02045178f, -0.01117623f, -0.03569680f, -0.00199023f, 0.01424906f, -0.00379531f, 
    -0.04847244f, -0.05532475f, -0.02709034f, -0.05364224f, 0.03408389f, -0.02467825f, -0.05634058f, 0.01363230f, 
    0.02064040f, 0.01656306f, -0.04350391f, 0.03841308f, -0.05247074f, -0.01726806f, 0.03645049f, 0.02572111f, 
    0.04851825f, 0.01933234f, 0.03608935f, 0.03619713f, 0.01628737f, -0.02517087f, 0.00076867f, 0.04362302f, 
    0.02787848f, -0.05802001f, -0.05708809f, 0.01842785f, 0.01606006f, -0.04416308f, 0.01958077f, -0.03710530f, 
    -0.05769596f, -0.00118441f, 0.00095859f, 0.04836505f, -0.02554671f, -0.03846391f, 0.00690033f, -0.03758568f, 
    0.03603524f, -0.01409275f, -0.00668179f, 0.02929514f, 0.04160644f, -0.00211029f, -0.05144465f, -0.04539339f, 
    -0.06232107f, -0.01143523f, 0.04559711f, -0.01166472f, -0.05704810f, 0.01670934f, 0.00542026f, -0.05246262f, 
    -0.01744924f, -0.01059323f, -0.04614704f, -0.00000801f, -0.05898353f, 0.00433205f, -0.06348597f, -0.02557607f, 
    -0.02963538f, 0.00522920f, -0.04344152f, 0.00474448f, -0.02463567f, 0.00153393f, 0.00739314f, -0.01551538f, 
    0.02648111f, -0.06074330f, 0.03153358f, 0.04305298f, -0.00597969f, -0.05450100f, 0.02868094f, -0.02288151f, 
    0.00389355f, 0.04309136f, -0.00421808f, -0.04660994f, -0.03120188f, 0.00269783f, 0.02650620f, 0.00216586f, 
    0.03596894f, 0.02407593f, -0.00827982f, -0.00052814f, -0.03509082f, -0.04459976f, -0.04949647f, -0.00252679f, 
    0.03036621f, 0.05373543f, -0.05204756f, -0.03558787f, 0.02633499f, 0.03546784f, 0.04385339f, 0.02372860f, 
    -0.05614943f, 0.04514927f, -0.00002313f, -0.04934195f, -0.04102313f, -0.05327221f, 0.03476889f, -0.00110539f, 
    0.03308465f, 0.03960458f, 0.04046570f, -0.02971341f, -0.02748205f, 0.01688756f, -0.04178608f, -0.05738277f, 
    -0.00915702f, -0.04689439f, 0.02301515f, -0.01805365f, -0.01282622f, -0.03528519f, -0.05842945f, 0.00123910f, 
    0.02757785f, -0.01183402f, -0.00113591f, 0.01032401f, 0.04376127f, -0.05538997f, -0.06099468f, 0.04239557f, 
    -0.00180915f, -0.02990253f, -0.00098432f, -0.05085297f, -0.01257524f, -0.00014814f, 0.03947112f, -0.01260975f, 
    -0.03765313f, 0.03553606f, -0.03775499f, -0.04012937f, 0.00601611f, -0.05717805f, -0.03522739f, -0.04701704f, 
    0.04822882f, -0.04554434f, 0.00834260f, 0.03060493f, -0.02995992f, -0.05239950f, -0.02492440f, 0.02599972f, 
    0.04581590f, -0.00778453f, -0.02339127f, -0.05468379f, 0.00059417f, -0.03327101f, -0.05513560f, 0.03489780f, 
    -0.03985581f, -0.05139967f, 0.03637520f, 0.03662157f, 0.04854387f, 0.01375894f, 0.00043697f, 0.01255287f, 
    0.00014797f, -0.05295089f, 0.01191086f, -0.06005373f, 0.02069533f, 0.04386204f, 0.02280852f, -0.00545212f, 
    -0.01207387f, -0.02694974f, -0.04831296f, -0.04761886f, -0.04917345f, 0.02065283f, 0.02432817f, 0.02038176f, 
    -0.01419446f, 0.04688253f, 0.00880171f, -0.01714626f, 0.01652045f, 0.02225085f, -0.00168710f, -0.02756052f, 
    -0.02069913f, -0.01053687f, 0.01461290f, 0.00247765f, 0.03573982f, -0.02654057f, 0.03081892f, 0.02716740f, 
    -0.05158529f, 0.02669354f, -0.03385267f, -0.03212482f, 0.01717343f, -0.06500160f, -0.00210256f, -0.05716244f, 
    -0.05252240f, -0.05418771f, -0.02763485f, -0.04917184f, -0.02246418f, -0.05629264f, -0.05530331f, -0.01123007f, 
    0.00990828f, -0.00999565f, -0.03876660f, 0.00430494f, -0.00070237f, -0.02252715f, 0.02564425f, -0.02704106f, 
    0.04831417f, -0.00924020f, -0.03907524f, 0.00799587f, 0.03281081f, 0.04533776f, 0.01521637f, -0.02497468f, 
    -0.78697824f, -0.27752429f, -0.29304853f, -0.10123353f, -0.17764211f, -0.15092947f, -0.04146300f, -0.23437862f, 
    0.01824524f, -0.03002904f, 0.17529279f, -0.02259651f, 0.01227659f, -0.06595054f, 0.12226773f, -0.08759817f, 
    0.05018678f, 0.10814373f, 0.01243733f, 0.02757995f, 0.02281867f, 0.20445992f, -0.07658190f, -0.01438712f, 
    0.06045710f, -0.05637311f, -0.13461654f, 0.04224578f, 0.13208397f, 0.13503805f, 0.04461380f, 0.01272458f, 
    0.13129815f, 0.05678878f, -0.08344755f, 0.11205710f, 0.02760069f, 0.12523325f, -0.04696656f, -0.03697467f, 
    0.21407285f, 0.33180517f, -0.14559333f, 0.06182578f, 0.13542221f, 0.17865539f, -0.03985582f, 0.06725479f, 
    0.08139003f, -0.02349866f, 0.02936090f, 0.06049539f, -0.02127656f, 0.00083306f, 0.10673807f, 0.06997627f, 
    -0.04289616f, -0.07794774f, -0.01371814f, 0.16702732f, -0.21447124f, 0.29535052f, -0.12170988f, 0.14951275f, 
    0.01246975f, -0.10437573f, 0.19345713f, 0.01875557f, 0.04070754f, -0.05497023f, 0.10392781f, -0.02929744f, 
    -0.18824579f, 0.02825980f, -0.01648181f, -0.01014081f, 0.10925160f, -0.10386813f, 0.09715403f, -0.00079736f, 
    -0.47544658f, -0.05183081f, 0.09863878f, 0.16913347f, -0.01030861f, 0.23580424f, 0.11012094f, 0.10536817f, 
    0.03402744f, 0.05320386f, 0.03659619f, 0.08124370f, 0.04361600f, 0.15742588f, -0.03110356f, 0.05222649f, 
    0.00445365f, -0.04824973f, 0.03645155f, -0.11056909f, 0.05342001f, 0.00338296f, -0.40502670f, -0.08957800f, 
    -0.19168860f, 0.05720053f, -0.05416393f, -0.02987685f, -0.01121196f, 0.06513614f, 0.14289212f, 0.09052145f, 
    -0.08102505f, -0.04320895f, 0.14987005f, 0.01798749f, 0.07294277f, 0.12415358f, 0.13370401f, 0.07444215f, 
    -0.25878736f, -0.36865282f, 0.42128375f, 0.00972378f, 0.22840241f, 0.01908314f, 0.12192926f, -0.08392517f, 
    0.06776267f, 0.00099223f, 0.02500028f, 0.10042667f, 0.07344378f, -0.00977831f, 0.07234443f, 0.03525248f, 
    0.08622641f, -0.01723478f, 0.07003003f, 0.01859337f, -0.67715627f, -0.10812506f, -0.09184939f, 0.18340461f, 
    -0.36269400f, 0.02126033f, 0.06239506f, -0.04521007f, -0.08153073f, 0.03689981f, 0.09284618f, -0.06836637f, 
    0.07589557f, 0.10818560f, 0.01665117f, 0.08883011f, -0.00983618f, 0.07784650f, 0.06581216f, -0.00847672f, 
    -0.41955426f, 0.41307583f, -0.13172598f, -0.21193935f, 0.22114909f, 0.16428705f, -0.11248357f, 0.07026096f, 
    0.01489231f, 0.11910341f, 0.11114036f, -0.04493361f, -0.06984802f, 0.12904993f, -0.10288777f, 0.07097999f, 
    0.07247973f, 0.02701028f, -0.20177339f, -0.03949695f, -0.02918594f, -0.23534513f, -0.13655040f, 0.15642753f, 
    -0.14037827f, -0.00629946f, -0.02746913f, -0.05627448f, -0.05916556f, -0.11808784f, -0.04209101f, -0.11717809f, 
    0.03459951f, -0.08360581f, -0.04410617f, -0.02781027f, 0.12204529f, -0.09915614f, 0.14934582f, -0.05286185f, 
    -0.59604543f, 0.16908000f, 0.28319657f, 0.05236901f, -0.03822333f, 0.19504789f, 0.09592044f, -0.02600813f, 
    -0.03411732f, -0.02247773f, 0.11016566f, 0.06179712f, 0.05634466f, -0.06312188f, 0.08983423f, -0.03816925f, 
    -0.05583435f, -0.07361607f, 0.04709813f, 0.06017230f, -0.30802643f, -0.53448409f, -0.36253199f, 0.16943069f, 
    0.04375440f, -0.01884544f, 0.22900856f, 0.00674108f, -0.12353645f, -0.10717581f, 0.13888086f, 0.07865404f, 
    0.01099816f, 0.05637736f, 0.02151405f, 0.04894717f, 0.11002134f, -0.02052792f, 0.08718132f, -0.05304692f, 
    0.19289033f, 0.09130452f, -0.02442603f, -0.00353305f, -0.04180125f, -0.08851220f, -0.16841137f, -0.02925901f, 
    -0.02237717f, 0.01346977f, -0.08291557f, 0.07692416f, -0.01415422f, 0.01775739f, 0.01166322f, -0.02807584f, 
    0.07203946f, 0.02755622f, 0.02852007f, -0.02515998f, -0.49449262f, -0.08024933f, -0.31293467f, -0.07133834f, 
    -0.11345603f, -0.03833961f, -0.08752763f, -0.12088883f, 0.03750121f, -0.01972130f, 0.03020083f, 0.11404489f, 
    -0.07038375f, 0.06051153f, -0.10225732f, 0.01383073f, 0.08091166f, 0.15992856f, 0.10702948f, 0.09478850f, 
    -0.22085603f, 0.40092486f, 0.06590787f, 0.11295603f, 0.11326894f, 0.06625045f, 0.05060950f, 0.09610336f, 
    0.07733814f, 0.17109887f, -0.03999274f, 0.14222132f, 0.07189349f, 0.04875825f, 0.07317028f, 0.05324166f, 
    0.05201865f, -0.12430818f, -0.00108537f, -0.04251665f, 0.37743142f, 0.46463639f, 0.00200930f, 0.12751397f, 
    -0.10455219f, 0.06243071f, 0.11144017f, 0.06332368f, 0.05842161f, 0.06788632f, -0.01374644f, 0.02918766f, 
    0.10396036f, -0.00438742f, 0.17283820f, -0.00946450f, -0.00288104f, -0.17930609f, -0.01227153f, -0.02713314f, 
    -0.03153590f, -0.02230181f, -0.04212927f, 0.01151113f, 0.01564736f, -0.04247362f, 0.02108474f, 0.05041126f, 
    0.00290744f, 0.02544621f, -0.06138140f, 0.03230771f, -0.04019010f, -0.03214988f, -0.03640280f, 0.04721893f, 
    0.04354726f, 0.04237153f, -0.02324220f, -0.05776476f, 0.02996021f, -0.06140471f, 0.02334013f, -0.02468063f, 
    -0.01591990f, -0.05168475f, -0.04413447f, -0.02217871f, 0.00163913f, -0.04207690f, 0.02047967f, 0.01577796f, 
    -0.05455174f, 0.01550861f, -0.01294746f, 0.03029775f, -0.00335152f, 0.01571832f, 0.02658166f, -0.00896326f, 
    0.02291652f, -0.00158994f, 0.02262972f, 0.02265490f, -0.05801487f, 0.04620001f, -0.00775986f, -0.03334566f, 
    -0.03533589f, -0.03286408f, 0.00894680f, -0.00667497f, -0.01298423f, 0.04691255f, -0.01364159f, 0.01739995f, 
    -0.04828000f, 0.02104413f, -0.03021865f, 0.04098364f, 0.01683658f, -0.00437608f, 0.03049185f, -0.03519674f, 
    -0.02611834f, -0.02577424f, -0.01687003f, -0.02848647f, 0.00006353f, 0.04915723f, 0.01644037f, 0.02460505f, 
    0.04442406f, 0.02856620f, -0.05722696f, -0.02126374f, -0.02247380f, -0.03232998f, 0.02224290f, -0.04479875f, 
    -0.03731104f, -0.00731084f, 0.03242881f, -0.02707434f, -0.04791602f, -0.05557171f, 0.03315501f, 0.01641333f, 
    0.03712954f, -0.01550430f, -0.01080577f, 0.04841333f, -0.01024974f, -0.00598187f, -0.02069016f, 0.02543848f, 
    0.04741863f, -0.04030844f, -0.04894485f, 0.03822664f, 0.00928354f, 0.03401405f, 0.01861645f, -0.01402492f, 
    0.04465364f, 0.00039113f, -0.02014201f, -0.00545959f, -0.02620862f, -0.02090819f, -0.04662532f, -0.02880115f, 
    0.01450305f, -0.02676388f, 0.00615993f, 0.03525798f, 0.02460288f, 0.04405175f, -0.03379009f, -0.03422039f, 
    0.04989212f, 0.02162057f, 0.02218959f, 0.01259972f, -0.00301025f, 0.01078271f, -0.01597391f, -0.04391901f, 
    0.04089827f, -0.05669968f, 0.00309433f, -0.00802815f, 0.03670869f, 0.05005844f, -0.05801919f, 0.00614011f, 
    -0.05190225f, -0.00201493f, 0.00835989f, -0.03000377f, -0.04694445f, -0.02308272f, -0.00480691f, 0.00087305f, 
    -0.04050709f, 0.01709120f, 0.01366313f, -0.00204410f, 0.03921258f, -0.03674033f, 0.00292973f, 0.04585900f, 
    -0.00733516f, -0.00998412f, -0.01456532f, 0.03586937f, 0.00304861f, -0.01490288f, 0.01986082f, 0.03005332f, 
    0.05633248f, -0.05379650f, 0.03913767f, 0.00111687f, 0.03195766f, 0.00271406f, -0.04392962f, -0.03813471f, 
    -0.06121356f, 0.01406926f, 0.03973681f, -0.03776134f, -0.03543043f, -0.00776544f, 0.03739849f, -0.06049566f, 
    -0.00433955f, -0.00456474f, -0.01618381f, -0.04138703f, -0.04220529f, 0.04720292f, 0.00439400f, 0.00666826f, 
    0.03623305f, -0.00252397f, 0.04304806f, 0.02358606f, -0.05562987f, -0.01690825f, -0.02516319f, 0.01590484f, 
    -0.02373398f, -0.05059883f, 0.02942082f, -0.00362147f, -0.03442115f, 0.04951122f, -0.02985173f, -0.01821681f, 
    0.04689068f, 0.01036933f, -0.02847550f, -0.05143582f, -0.01049758f, 0.01246312f, 0.02160571f, 0.04062038f, 
    0.01042355f, -0.00963347f, 0.00628200f, -0.01133467f, -0.05449834f, -0.02541337f, -0.01491809f, -0.00165557f, 
    0.03230618f, -0.03676081f, -0.04438451f, -0.04816784f, 0.04940319f, -0.02446936f, -0.04536523f, -0.03259746f, 
    -0.02013767f, 0.02999520f, 0.02402074f, -0.02973423f, 0.03745541f, 0.00241535f, -0.02293227f, -0.06160942f, 
    0.02703386f, 0.02588140f, -0.02338625f, -0.03592763f, -0.05919718f, -0.01408252f, 0.01178160f, 0.03633441f, 
    0.03220847f, -0.00463802f, -0.03126621f, -0.04269606f, -0.04802081f, 0.03285836f, 0.03101226f, -0.02039694f, 
    0.01557356f, 0.02847144f, -0.03897350f, 0.04128808f, -0.01786857f, 0.04231864f, -0.03882001f, -0.00477889f, 
    -0.04548694f, -0.04684514f, -0.03967704f, 0.03534605f, -0.04798338f, -0.02712713f, -0.00251574f, 0.04936284f, 
    -0.03100578f, 0.00777689f, 0.02619558f, -0.04247411f, -0.01870539f, -0.04724230f, 0.02678038f, 0.00270131f, 
    0.01950370f, -0.05792715f, -0.04814571f, 0.00362651f, -0.05843703f, -0.04235636f, 0.00925592f, 0.02796183f, 
    0.04931571f, -0.01238463f, -0.04141852f, -0.03407565f, -0.02659841f, -0.04141800f, 0.02900655f, -0.02632155f, 
    -0.01757236f, 0.00968525f, 0.02408367f, -0.05828611f, -0.03140034f, -0.04744409f, -0.03546788f, -0.03678798f, 
    -0.05772275f, -0.04981316f, 0.02047320f, -0.04559822f, -0.04396084f, 0.01793119f, -0.05626710f, -0.04935047f, 
    -0.05666000f, 0.01486598f, -0.02714252f, -0.00763916f, -0.04956469f, 0.01398236f, -0.01353365f, -0.02059476f, 
    0.04132812f, -0.01717812f, -0.04506142f, 0.00511126f, 0.03592351f, -0.04749114f, -0.00826144f, 0.04065110f, 
    0.00655605f, -0.05444622f, 0.01065925f, 0.00603953f, 0.00910539f, 0.01481728f, -0.04216374f, -0.01073021f, 
    -0.00838893f, 0.03734672f, 0.04711825f, -0.01696261f, -0.02966537f, -0.01368010f, 0.01793653f, -0.02644399f, 
    0.04378179f, -0.00396732f, -0.01915810f, 0.01146765f, 0.03571916f, -0.04976137f, -0.05296743f, 0.03356671f, 
    -0.01792431f, 0.01785475f, 0.01886632f, -0.03819146f, 0.04852465f, -0.05817050f, 0.02387143f, -0.00415403f, 
    -0.00768005f, -0.00172581f, -0.01351759f, -0.00503608f, -0.04327543f, 0.00416838f, -0.06087781f, 0.01793507f, 
    -0.01621105f, 0.04791419f, -0.05031963f, -0.05001426f, -0.00744051f, -0.05979508f, 0.01622092f, -0.04798351f, 
    -0.04793549f, 0.04637393f, 0.00520869f, 0.00276521f, -0.05029161f, -0.00660982f, 0.00605654f, 0.02323683f, 
    -0.02053000f, 0.03060823f, -0.02065363f, -0.03695231f, -0.03978218f, 0.03326752f, -0.05214298f, -0.02665417f, 
    0.02715951f, -0.05857017f, -0.04395294f, -0.05267747f, -0.03041359f, -0.05239719f, -0.04638695f, -0.00153141f, 
    0.02627628f, -0.01518238f, -0.00964674f, -0.02562086f, 0.03041954f, -0.02832870f, -0.05014900f, -0.00933542f, 
    -0.04498426f, 0.01596425f, -0.04440199f, 0.01686825f, 0.00835064f, -0.00214110f, 0.00281514f, 0.01869735f, 
    0.02324728f, 0.00148337f, 0.00385485f, 0.01510706f, 0.01883359f, -0.01877659f, -0.03093701f, -0.03759969f, 
    0.00696152f, 0.02204093f, 0.02414986f, -0.06056415f, 0.03050673f, 0.04371847f, 0.02566454f, -0.00584604f, 
    0.03651243f, -0.05923579f, 0.02471472f, 0.02938628f, -0.01201233f, -0.04652865f, -0.05473427f, -0.02419785f, 
    0.01947436f, -0.02653262f, -0.01765650f, -0.04286809f, -0.05361588f, -0.05571834f, -0.04872792f, 0.04950612f, 
    -0.03473791f, 0.04129662f, 0.02496717f, 0.01629167f, -0.06113202f, 0.00837221f, 0.01223867f, 0.01823714f, 
    -0.05365037f, -0.01840851f, 0.03940334f, -0.06172904f, -0.01458044f, 0.00219712f, -0.03215593f, 0.00952964f, 
    0.02291424f, -0.04547173f, -0.05134518f, -0.03876720f, 0.04163498f, 0.00226808f, 0.01507025f, -0.04975794f, 
    -0.01728101f, 0.02792285f, -0.00669249f, 0.04660533f, -0.01964198f, 0.04088808f, 0.01529830f, 0.01800988f, 
    0.04754586f, -0.04588863f, -0.01660810f, 0.00771001f, 0.01125986f, 0.01703111f, -0.05586981f, 0.01285012f, 
    -0.06120245f, -0.06126820f, -0.01754652f, -0.04950197f, -0.01678119f, 0.03821617f, 0.03448272f, -0.03497829f, 
    -0.03571576f, -0.05264267f, -0.05123118f, 0.04543195f, 0.01656157f, -0.02048136f, -0.05225467f, 0.04920743f, 
    -0.02401219f, 0.02522550f, 0.00105308f, 0.03267630f, 0.02550692f, -0.05216815f, 0.03729093f, 0.00086986f, 
    -0.05258129f, -0.03407836f, -0.00191832f, 0.00024978f, -0.05920933f, -0.00816965f, -0.04530559f, -0.00342452f, 
    0.02611898f, -0.05156294f, -0.04619162f, -0.00277824f, -0.01144053f, -0.01146544f, 0.01319295f, -0.03696204f, 
    0.02697878f, -0.01625859f, -0.01601861f, -0.00492175f, -0.01197595f, -0.02379746f, 0.03204152f, 0.00459183f, 
    -0.00984998f, 0.02407802f, 0.00958738f, 0.01560012f, -0.01407002f, 0.04845049f, -0.04448457f, -0.06032879f, 
    0.01221099f, 0.01028163f, -0.06061570f, 0.03774256f, -0.03226805f, 0.01239053f, 0.02278151f, -0.00279066f, 
    0.00658554f, 0.00266274f, -0.01330656f, -0.00782346f, 0.00824606f, 0.01755245f, -0.02744810f, -0.00832399f, 
    0.01229648f, 0.01208858f, 0.00753984f, 0.03874505f, -0.03451328f, 0.03519992f, -0.04554154f, 0.01422601f, 
    -0.06094329f, 0.04272114f, 0.00170864f, 0.04292462f, -0.01076812f, -0.06034818f, 0.02970796f, -0.05591070f, 
    0.05140287f, -0.05967133f, -0.01730150f, 0.01869421f, -0.02293164f, -0.02536057f, 0.00918646f, -0.01112587f, 
    -0.00637229f, -0.02399844f, -0.02330708f, -0.04893764f, -0.05488089f, -0.01160775f, -0.06031252f, 0.03876350f, 
    0.01513172f, 0.04902345f, 0.00585387f, 0.03455934f, -0.00001507f, 0.01322027f, -0.02358458f, 0.00624111f, 
    -0.02671182f, 0.02291443f, 0.04436033f, -0.01524983f, 0.01232554f, -0.01687832f, 0.01348173f, 0.01605841f, 
    -0.04141442f, 0.02132699f, 0.04051650f, 0.03048792f, 0.02756595f, -0.02790375f, 0.01012116f, -0.00787336f, 
    -0.01820480f, 0.04945375f, -0.01186789f, 0.03777706f, 0.02080569f, -0.00989658f, 0.03360438f, -0.05515662f, 
    0.03156799f, -0.04562313f, 0.01924584f, -0.01892348f, -0.01934604f, 0.02657008f, 0.04303205f, 0.03049104f, 
    0.00964702f, -0.00156306f, 0.03492761f, 0.02160863f, -0.05748955f, -0.02719673f, -0.04387299f, 0.00675216f, 
    0.03787730f, -0.03348614f, 0.00054077f, -0.03642959f, 0.00976338f, -0.03152462f, -0.02514670f, 0.02171095f, 
    -0.12755589f, 0.27946672f, -0.26682675f, -0.22187805f, -0.19996765f, 0.36104470f, 0.06199718f, 0.16185972f, 
    -0.09451506f, 0.00108213f, 0.13082555f, -0.08812846f, 0.14512597f, 0.13568464f, -0.01468857f, 0.09322976f, 
    -0.08181697f, 0.19504395f, -0.06585743f, -0.11837608f, 0.22677103f, 0.03460091f, -0.14043558f, -0.04353113f, 
    0.36069205f, -0.04425542f, -0.02162530f, -0.06140577f, 0.04317318f, 0.22118463f, 0.04952206f, -0.01148994f, 
    0.04475216f, 0.06124649f, -0.00945756f, 0.09531742f, 0.07631438f, -0.01301193f, 0.03199954f, 0.12669137f, 
    -0.35054258f, -0.51217878f, -0.03389835f, 0.06247646f, -0.00993613f, -0.31093541f, -0.01976077f, 0.06112887f, 
    0.10096008f, 0.14436522f, -0.05838584f, -0.01882977f, 0.04469378f, 0.00523402f, 0.10197315f, 0.04395310f, 
    0.00778561f, 0.06177771f, 0.01570707f, -0.07980466f, -0.02023293f, -0.02590442f, -0.00891626f, -0.17457990f, 
    0.22796501f, 0.04916443f, -0.11614554f, -0.10378952f, -0.09670375f, 0.12732570f, 0.04327930f, 0.04960404f, 
    0.04345570f, 0.01137495f, -0.01616650f, 0.07536239f, 0.06457146f, 0.17606373f, 0.12779461f, -0.00685021f, 
    0.05484774f, -0.03083769f, 0.21772566f, -0.29614863f, -0.42844599f, 0.05097440f, 0.09875078f, -0.15794833f, 
    -0.10724279f, 0.06206415f, 0.01088204f, 0.01745783f, -0.04342254f, -0.12883577f, 0.14893548f, 0.03765714f, 
    0.06867899f, 0.01045045f, -0.03369935f, -0.02400463f, 0.05849030f, 0.05230647f, -0.31759977f, -0.11694562f, 
    0.06680821f, 0.01835394f, 0.03449126f, 0.00110138f, 0.01245925f, 0.04071571f, -0.05663934f, -0.03391261f, 
    0.03141515f, 0.23856871f, 0.02462898f, -0.05654522f, 0.16781509f, -0.16523464f, -0.18577099f, -0.04618872f, 
    -0.32519311f, 0.22588089f, -0.09882465f, 0.07424066f, -0.21736617f, 0.11980908f, 0.08481219f, -0.01156661f, 
    -0.00231514f, 0.07928769f, 0.05662727f, -0.11628895f, 0.21235520f, 0.15800405f, 0.06374507f, 0.07367682f, 
    0.25182912f, -0.08538859f, 0.01935404f, -0.01762747f, -0.33796743f, 0.07925186f, 0.16290917f, -0.06879521f, 
    -0.33795530f, 0.21091971f, 0.24864179f, 0.06063516f, -0.05610257f, -0.00737051f, 0.09830032f, 0.09050858f, 
    0.09115392f, 0.00771176f, 0.01109339f, 0.16273472f, 0.09198202f, 0.07392594f, -0.00121997f, 0.07995646f, 
    0.44867915f, -0.20065504f, 0.30491695f, -0.00507153f, 0.19820857f, 0.00866803f, -0.03995344f, 0.00610368f, 
    0.14199479f, 0.10819095f, 0.00135057f, -0.01189387f, 0.07679562f, -0.08539255f, 0.11345595f, 0.06026770f, 
    -0.09409022f, -0.12643750f, 0.07508085f, 0.07662903f, -0.25602522f, -0.16099128f, -0.06062247f, 0.11975088f, 
    -0.08543875f, 0.01957329f, -0.20850541f, 0.04711556f, -0.00007924f, 0.24913990f, -0.01285489f, -0.01292492f, 
    0.09711944f, 0.04401160f, 0.02446318f, 0.04969977f, 0.01856839f, -0.00277127f, -0.20579550f, -0.04164559f, 
    0.70161557f, 0.13705119f, -0.13306029f, -0.41950080f, 0.20274088f, 0.06657085f, -0.08417406f, 0.00555678f, 
    -0.05262731f, -0.03430784f, -0.04753728f, -0.08994527f, 0.03142419f, 0.12069615f, -0.03124962f, 0.15619519f, 
    0.15994206f, -0.01493919f, -0.04045158f, 0.03242523f, -0.45899007f, 0.12231382f, 0.13825378f, 0.18184054f, 
    -0.27283081f, 0.11974300f, 0.18225531f, 0.04743077f, -0.17885651f, -0.13717869f, 0.07594373f, 0.02871364f, 
    0.01427120f, -0.05493993f, 0.02462662f, -0.04239578f, -0.00940026f, 0.08493168f, -0.04212319f, 0.03254166f, 
    0.01539667f, -0.06013536f, 0.04055836f, 0.10261834f, 0.36815596f, 0.14393431f, -0.03940936f, -0.06050017f, 
    0.07897720f, 0.08085810f, -0.03416932f, -0.13073489f, 0.04518263f, -0.03082517f, -0.01516282f, -0.16555542f, 
    -0.10536446f, 0.04466668f, -0.11353826f, -0.08442242f, 0.27379683f, -0.30839869f, 0.02788702f, -0.19737493f, 
    -0.29123074f, 0.12539788f, 0.09266139f, -0.16874507f, -0.07214748f, -0.02825250f, 0.02189874f, 0.04658537f, 
    0.10097343f, -0.06458066f, 0.03960561f, 0.02827631f, 0.04633276f, -0.00894314f, 0.02199505f, 0.08505452f, 
    0.07352236f, -0.52785146f, 0.22453228f, 0.20152020f, 0.07101893f, -0.16393052f, 0.09457278f, 0.14593410f, 
    0.05136127f, -0.08137322f, 0.00779912f, -0.01338312f, 0.02670266f, 0.03974073f, 0.02861075f, 0.10600967f, 
    0.18594538f, 0.08959285f, -0.02057983f, 0.17273541f, -0.09428997f, -0.37324527f, 0.21102396f, -0.15248133f, 
    -0.19462685f, -0.23620461f, 0.25416374f, -0.06648801f, 0.10653254f, -0.02882365f, 0.06117442f, 0.02431341f, 
    0.07773361f, -0.14227839f, -0.02487404f, -0.02206980f, -0.02141079f, 0.22619005f, 0.08398427f, 0.04654697f, 
    0.02344632f, -0.04837380f, 0.00115919f, 0.02668636f, 0.02002996f, 0.01642414f, 0.04361286f, 0.03587143f, 
    -0.01266604f, -0.04067887f, -0.01044919f, -0.00598789f, 0.00576564f, 0.02329136f, -0.06004142f, 0.01506707f, 
    -0.01802018f, 0.04222686f, 0.01560067f, -0.03958578f, -0.02612510f, 0.00175580f, 0.01088546f, -0.05471956f, 
    0.00889918f, 0.03423659f, 0.03865106f, -0.00361546f, -0.06069046f, -0.04849639f, -0.01183776f, -0.00701186f, 
    0.03741528f, 0.04574092f, 0.04313179f, -0.02528346f, -0.04468770f, 0.02185234f, -0.05022441f, 0.01215488f, 
    -0.04809991f, -0.04015511f, 0.03214917f, -0.00971352f, 0.02065877f, -0.06046280f, -0.04325112f, 0.02264851f, 
    -0.00415289f, 0.03432772f, -0.01211620f, 0.04344756f, 0.02629110f, -0.01525944f, 0.04238296f, -0.06389178f, 
    -0.02038526f, -0.02476995f, -0.03712719f, -0.04112143f, 0.00531291f, -0.00440969f, -0.00769246f, -0.05592261f, 
    0.00148346f, -0.05545009f, -0.00298275f, -0.03628896f, -0.05358946f, 0.04299775f, 0.04907473f, 0.00764085f, 
    -0.00915013f, -0.01079449f, 0.04503483f, 0.00869175f, -0.04678027f, 0.02961829f, -0.04962403f, -0.05549674f, 
    -0.05184121f, -0.01785125f, -0.02124177f, -0.00422147f, -0.03282683f, -0.05060045f, 0.01546933f, 0.01390167f, 
    -0.04373469f, 0.01440245f, 0.00318129f, 0.02538772f, 0.00625671f, -0.03439350f, 0.00289480f, -0.00168872f, 
    -0.00476566f, -0.05411552f, -0.03258827f, 0.03348653f, -0.00622241f, -0.03029538f, 0.00694464f, 0.02396954f, 
    -0.06520976f, -0.00837857f, 0.04152961f, 0.02909344f, 0.00583905f, -0.05466644f, 0.02096910f, 0.00788728f, 
    -0.04442268f, -0.00960680f, 0.04143443f, 0.00687218f, -0.03866603f, -0.02527820f, -0.01388330f, -0.02286383f, 
    -0.05167925f, -0.06254250f, -0.03012061f, -0.01933583f, -0.02104105f, 0.03302003f, 0.00102893f, 0.03705255f, 
    0.01094854f, 0.02787498f, -0.04780602f, 0.02042249f, 0.04223487f, -0.04690831f, 0.03423918f, -0.01718946f, 
    -0.03697675f, 0.04316636f, 0.00067952f, -0.00587160f, 0.03485077f, -0.04045039f, -0.04174108f, 0.02317354f, 
    -0.02196014f, 0.03674316f, -0.00193742f, 0.02762316f, -0.00969700f, 0.00809037f, -0.00408530f, -0.03065017f, 
    0.03969863f, 0.01342264f, -0.02933140f, 0.01516296f, 0.03963955f, -0.02363964f, 0.02255622f, -0.01947862f, 
    0.03478962f, -0.02492733f, -0.03333414f, -0.01200985f, -0.01923026f, -0.04827794f, -0.02602573f, 0.01962447f, 
    -0.05752777f, 0.01539962f, 0.05006077f, 0.00223691f, -0.02851902f, 0.03980027f, 0.01089502f, -0.01805815f, 
    -0.05540250f, -0.01208091f, -0.05610481f, 0.00821583f, -0.00935886f, -0.02169446f, -0.06201891f, -0.01693117f, 
    -0.04571106f, 0.02771132f, 0.04605868f, -0.03192867f, 0.03152285f, -0.05627277f, -0.01744327f, 0.02457698f, 
    -0.05785295f, 0.05007796f, 0.01697737f, 0.04474676f, 0.04450411f, 0.04439231f, -0.02623064f, 0.04446331f, 
    -0.01723071f, 0.04065799f, -0.00994554f, -0.02544036f, 0.00251055f, -0.02534865f, -0.04070481f, -0.00538285f, 
    0.03384200f, 0.03763890f, -0.04938627f, -0.05221139f, 0.03305366f, 0.02799012f, -0.05493036f, -0.01400593f, 
    -0.03483347f, -0.02971889f, -0.02969778f, -0.03113548f, -0.05183643f, 0.03141993f, 0.00449140f, -0.03817007f, 
    -0.05299186f, -0.04582221f, -0.04574121f, 0.03965798f, -0.05777821f, -0.04751405f, 0.02582629f, 0.04729711f, 
    0.04169253f, -0.01923864f, -0.02925610f, -0.03154725f, -0.05834595f, 0.03601035f, 0.03964462f, -0.05536541f, 
    -0.04602289f, -0.00851695f, -0.02075774f, 0.03123775f, 0.03970492f, -0.05687267f, 0.00105685f, 0.01566771f, 
    -0.05178444f, 0.00304966f, 0.03005747f, -0.04724978f, 0.00138423f, 0.00451932f, 0.04555040f, -0.02944460f, 
    -0.01127012f, 0.01438818f, -0.04945144f, 0.01517482f, 0.04339695f, -0.01430063f, -0.05224257f, 0.04014651f, 
    0.02428273f, 0.03554362f, -0.00510397f, -0.03938784f, -0.03268671f, 0.02445336f, 0.04899946f, 0.02962759f, 
    -0.05651891f, 0.01352475f, 0.01226169f, 0.03831265f, 0.01909120f, 0.01638782f, -0.03101432f, -0.06312321f, 
    -0.06046100f, -0.01716459f, 0.04859219f, -0.02704629f, 0.03063541f, 0.03424483f, 0.03335069f, -0.02299061f, 
    0.01304855f, -0.00392796f, -0.01425853f, -0.00575568f, -0.04860672f, 0.03945668f, -0.01472975f, 0.00903099f, 
    -0.06178275f, 0.00444233f, 0.00662030f, 0.01047886f, -0.02735844f, 0.02070638f, -0.00212376f, 0.01246983f, 
    0.03307740f, 0.03169907f, -0.02656344f, 0.02005484f, -0.04409134f, 0.03620831f, 0.01668291f, -0.01181845f, 
    -0.00790466f, -0.02603385f, -0.05474409f, 0.03379915f, -0.01061192f, -0.03548969f, 0.03553076f, 0.04856467f, 
    0.04590613f, -0.02282899f, 0.03636205f, -0.00319968f, -0.02590070f, -0.05039020f, 0.04975935f, -0.00794635f, 
    0.03786375f, -0.02345203f, -0.03087278f, 0.02952552f, 0.02189461f, 0.00348500f, -0.04188416f, 0.01327594f, 
    -0.01879027f, 0.02591278f, -0.05622642f, -0.00186133f, 0.03039269f, 0.02342515f, -0.03654435f, 0.01103443f, 
    0.02028615f, -0.01495543f, -0.04357354f, 0.00935710f, 0.04533918f, -0.04212223f, -0.03733018f, 0.00878055f, 
    -0.00008845f, -0.04984303f, -0.04364062f, -0.04095895f, -0.03363107f, -0.03865353f, 0.01159241f, -0.01052753f, 
    -0.02526099f, -0.05964563f, -0.02213663f, 0.04470966f, -0.03948536f, -0.00908608f, 0.00221096f, -0.00332196f, 
    -0.04098197f, -0.01090299f, -0.01677960f, -0.01126613f, -0.02708663f, 0.03371746f, 0.02138701f, -0.01377688f, 
    0.04545952f, 0.00762031f, 0.00464906f, -0.01027496f, -0.04079835f, 0.02164096f, 0.02773193f, -0.02852187f, 
    -0.02531544f, 0.04771527f, -0.02956507f, -0.00011641f, -0.03322150f, -0.05538807f, 0.04795516f, -0.04736693f, 
    -0.05394537f, 0.03073936f, -0.04015237f, 0.04028962f, 0.00845163f, 0.00129643f, -0.05985467f, -0.02245409f, 
    0.00712268f, 0.04235955f, -0.00361867f, -0.04995577f, -0.04273118f, 0.01484573f, 0.00206522f, -0.03662879f, 
    -0.04943654f, -0.02552754f, 0.01771973f, 0.00064333f, -0.02306563f, 0.04652895f, -0.03770756f, 0.04773410f, 
    -0.03519408f, -0.01374482f, -0.05662423f, 0.04350294f, 0.01976793f, -0.00401787f, 0.03355429f, -0.01299583f, 
    -0.05164436f, -0.01542243f, -0.00771743f, 0.03338683f, 0.03620964f, -0.05801597f, 0.00498402f, -0.01890911f, 
    0.01041166f, 0.01068964f, -0.02741656f, -0.04463566f, -0.01007841f, -0.00952176f, 0.02197051f, 0.00949992f, 
    -0.02981958f, -0.00600724f, 0.01938503f, -0.06034767f, 0.02127142f, 0.01337249f, -0.05443119f, -0.01786536f, 
    0.03911134f, -0.02249101f, 0.00726068f, 0.03273841f, -0.03141512f, -0.03054123f, -0.00409170f, -0.00215846f, 
    -0.00716040f, 0.01024774f, -0.03890657f, 0.00452651f, 0.04362942f, -0.05265787f, 0.00946180f, -0.02090385f, 
    -0.00273009f, 0.03534200f, 0.04081642f, -0.00673118f, -0.05499915f, 0.02947304f, -0.02291240f, -0.05693696f, 
    0.03267271f, -0.05545364f, 0.01171008f, 0.01595584f, -0.02302576f, 0.02236572f, -0.01683427f, 0.01171533f, 
    -0.04157084f, 0.01705424f, -0.02734480f, -0.05275467f, 0.03937251f, 0.00241853f, -0.02027261f, -0.05516024f, 
    0.02307803f, -0.05649048f, -0.03417153f, 0.01017470f, 0.04362566f, 0.04418483f, -0.02832010f, -0.01670167f, 
    0.03181620f, -0.03115962f, -0.01339822f, -0.01191437f, -0.00794205f, -0.04779626f, -0.00559457f, -0.03001613f, 
    -0.01655013f, 0.03187504f, 0.04821738f, 0.01043949f, -0.01610568f, -0.01013025f, 0.02562220f, -0.00392409f, 
    -0.04638964f, 0.01071589f, 0.01290288f, -0.05711584f, -0.04343728f, -0.04888519f, -0.00902306f, -0.05553294f, 
    -0.05101768f, 0.00076696f, -0.01010139f, 0.03021696f, 0.00233534f, -0.04737570f, 0.00286062f, 0.03698846f, 
    -0.00066086f, -0.05999441f, -0.04894852f, -0.02447592f, 0.03519109f, 0.01868690f, -0.02674980f, -0.04273997f, 
    0.00675290f, -0.01578936f, 0.02102477f, -0.05677390f, 0.00758097f, -0.03540413f, -0.05370962f, -0.00688773f, 
    -0.05836686f, 0.03796706f, -0.03549160f, -0.03844897f, -0.01001461f, -0.05634174f, -0.05122981f, 0.00660411f, 
    0.04891004f, -0.01451254f, -0.02550247f, -0.02175055f, -0.00408998f, -0.05459329f, -0.03917002f, -0.01167154f, 
    0.03990992f, 0.00670978f, -0.04814846f, -0.03683287f, 0.02141893f, 0.05018274f, 0.04687573f, 0.02492342f, 
    -0.03205712f, 0.02997411f, -0.03874670f, -0.05528239f, -0.05222212f, 0.01358428f, 0.00543623f, 0.04262358f, 
    -0.05188712f, 0.02646595f, 0.04405861f, 0.00661639f, 0.01825785f, -0.02604896f, 0.03364156f, 0.01311028f, 
    -0.03193320f, 0.00505202f, -0.02054629f, 0.01570399f, -0.01848754f, -0.01164024f, 0.02074507f, -0.04586636f, 
    0.04149705f, 0.04819978f, -0.00827243f, -0.01587190f, -0.00062541f, -0.06083008f, -0.02817595f, 0.02035374f, 
    -0.03533946f, 0.01033006f, -0.06005427f, -0.01760744f, -0.05991196f, -0.05440110f, -0.03831119f, 0.01316131f, 
    -0.01206270f, 0.02569392f, 0.03744249f, -0.01468727f, 0.03588121f, -0.03640307f, -0.02001831f, 0.01036553f, 
    -0.04504215f, -0.01396171f, 0.01333047f, -0.02261461f, -0.00954972f, -0.01198405f, 0.00027768f, -0.01145926f, 
    0.03805365f, -0.03881653f, 0.02599376f, 0.03765575f, 0.03929467f, 0.01353028f, 0.02470799f, 0.01928127f, 
    0.02756889f, -0.04529547f, 0.03632976f, 0.00938449f, 0.02457010f, -0.05097612f, -0.03375440f, 0.04003662f, 
    -0.18185505f, -0.03771127f, 0.33428949f, -0.00306002f, 0.21551691f, -0.12141053f, -0.01196618f, -0.04618561f, 
    0.01712429f, -0.02325614f, -0.06518188f, 0.08721823f, 0.05864274f, 0.04003263f, 0.09676597f, 0.11189159f, 
    -0.15885995f, 0.03295450f, -0.17449524f, 0.17753781f, 0.14873970f, -0.23430803f, -0.16712485f, -0.21960413f, 
    -0.12506607f, -0.14198282f, -0.21081452f, -0.07595579f, 0.05222695f, 0.05535438f, 0.08849359f, -0.08546032f, 
    -0.02761394f, 0.00185721f, 0.00767767f, 0.02787673f, 0.08009870f, 0.04702852f, -0.09585484f, 0.11226775f, 
    0.40315753f, 0.39682114f, -0.10848037f, 0.01964050f, 0.07989981f, 0.09444266f, -0.01734078f, 0.02727310f, 
    0.00887805f, -0.04226969f, -0.01220793f, 0.00155896f, 0.11316310f, 0.15230905f, 0.06711302f, 0.02771640f, 
    0.05881722f, 0.03744563f, -0.01208204f, 0.02925548f, 0.25771707f, -0.08203420f, 0.14442807f, 0.05062963f, 
    -0.25984889f, -0.01533136f, 0.06095873f, 0.08704095f, 0.04365750f, -0.08618437f, -0.11034424f, 0.05165937f, 
    0.13718140f, -0.02800101f, 0.07180924f, 0.05487612f, -0.07514221f, 0.07726602f, 0.07288922f, 0.07770374f, 
    -0.24168794f, 0.23918661f, 0.11869241f, -0.01320791f, -0.00821213f, -0.07173745f, 0.10586640f, 0.12181534f, 
    0.02050011f, -0.06959767f, -0.03383885f, 0.02060641f, -0.06108495f, -0.09980804f, -0.15523896f, 0.03765823f, 
    0.14122106f, 0.03243747f, -0.09725387f, 0.04568460f, 0.54474986f, 0.07758469f, 0.00032577f, 0.06660693f, 
    0.12319593f, 0.00135561f, 0.07735322f, 0.13965049f, 0.08441523f, 0.21940370f, 0.10766736f, 0.00231965f, 
    0.02372221f, 0.08592916f, 0.14840077f, 0.12937450f, -0.02454224f, -0.06130636f, -0.06989259f, -0.02286958f, 
    0.20691784f, -0.13844590f, 0.02215254f, 0.16173558f, 0.06023185f, -0.04712235f, -0.02896260f, 0.09252460f, 
    0.05753951f, 0.00716936f, -0.04380097f, 0.02629542f, 0.02075821f, -0.06616867f, -0.02312014f, 0.04607746f, 
    -0.04290715f, -0.09268861f, 0.04384606f, 0.07745273f, -0.31561753f, 0.23723364f, 0.06092281f, -0.08544814f, 
    0.21148159f, 0.11945099f, -0.03785632f, 0.00761576f, 0.13504559f, -0.10468259f, -0.17840704f, 0.00777227f, 
    0.00703972f, -0.00074128f, 0.10625871f, 0.06036782f, 0.03270839f, -0.07734247f, -0.03447024f, 0.05579542f, 
    0.19737621f, 0.06680376f, -0.15276048f, -0.09012048f, -0.11398611f, 0.15913700f, -0.11311267f, 0.16422784f, 
    0.00030228f, 0.01925964f, 0.00976129f, -0.09608365f, -0.08264206f, -0.13034488f, -0.01960337f, -0.11590155f, 
    0.12122483f, -0.00036752f, 0.09033386f, -0.16900751f, 0.05380591f, 0.08257183f, 0.13212579f, -0.12482262f, 
    0.07425272f, 0.18246759f, 0.03527123f, -0.01264972f, 0.11783862f, 0.06258185f, 0.01259127f, -0.08848803f, 
    0.07276487f, 0.20222925f, -0.07681011f, 0.02015687f, -0.00423469f, 0.05280290f, -0.15589574f, 0.12156717f, 
    -0.14885221f, -0.12412901f, -0.13322681f, 0.03714209f, -0.20728458f, 0.01286393f, 0.10171476f, 0.01920577f, 
    0.05870738f, 0.03780477f, 0.04439485f, -0.00911140f, -0.00732986f, -0.03408502f, 0.16386376f, -0.07162764f, 
    -0.09121390f, 0.07882912f, 0.15557092f, 0.15804309f, 0.01707758f, -0.10542237f, 0.24152973f, -0.22842008f, 
    0.00447174f, -0.02263737f, 0.00042623f, 0.11154450f, 0.04687070f, 0.08004098f, -0.17259680f, 0.05239482f, 
    0.03880644f, -0.05415922f, -0.04135612f, 0.10593005f, 0.01301157f, 0.16609015f, 0.04655809f, -0.00634847f, 
    0.38827157f, -0.01115610f, 0.06320596f, -0.18302418f, -0.28518939f, -0.03449749f, 0.02054455f, -0.07206147f, 
    -0.06046271f, -0.00919395f, 0.01606370f, -0.02492374f, 0.02705764f, 0.15368159f, 0.06484026f, 0.03348812f, 
    0.10527043f, -0.04581134f, 0.04883489f, -0.07962526f, -0.23029274f, 0.33843616f, 0.13565999f, 0.14132443f, 
    0.11109651f, 0.03252249f, -0.10513174f, 0.17426917f, -0.01312585f, -0.18243992f, -0.02590206f, 0.00653332f, 
    0.08422475f, -0.04012443f, 0.11194647f, -0.02451634f, -0.16297570f, -0.08133806f, -0.09076765f, -0.14434308f, 
    0.17170064f, 0.19176906f, -0.13920055f, -0.03307983f, 0.24207428f, 0.01195676f, -0.07474042f, 0.01151684f, 
    -0.01741963f, 0.07099036f, 0.00450975f, 0.08011636f, -0.24679394f, -0.01008887f, 0.08834689f, -0.03142285f, 
    0.07560366f, 0.17203176f, 0.12473705f, 0.00825172f, -0.27189282f, -0.08516707f, 0.07299578f, 0.08637610f, 
    0.13067585f, 0.02755578f, -0.00561308f, 0.13325451f, -0.08998520f, 0.02127546f, -0.15761577f, -0.02740978f, 
    0.04864416f, 0.03295823f, -0.03028932f, -0.11112877f, -0.01540471f, 0.27003902f, 0.17305312f, 0.05265673f, 
    0.03054293f, 0.03924718f, 0.02353035f, -0.00174727f, 0.00244418f, -0.04066281f, 0.01874942f, 0.00240871f, 
    0.04165809f, -0.00059415f, -0.04249254f, 0.04638637f, -0.00183071f, 0.00086604f, 0.04434565f, -0.00845481f, 
    0.02318646f, 0.04130355f, 0.03131082f, -0.03518111f, 0.00535253f, -0.05483028f, -0.00070519f, -0.04304973f, 
    -0.00423958f, 0.03460935f, -0.05122706f, 0.03811423f, -0.04979530f, -0.02581468f, -0.04728046f, -0.04790724f, 
    0.04149673f, 0.01402830f, -0.05876186f, -0.00984709f, -0.03522627f, 0.00474560f, 0.02777232f, 0.04325660f, 
    0.02500948f, -0.04184141f, 0.02073118f, -0.03703088f, 0.03072644f, -0.01084654f, 0.00845814f, -0.04385845f, 
    -0.03936860f, 0.03143482f, -0.05983625f, 0.02262007f, 0.01648337f, -0.00283133f, -0.01052731f, -0.06053340f, 
    -0.01036242f, -0.04295402f, 0.00793014f, 0.01318840f, -0.04299938f, -0.01171743f, 0.04566264f, -0.02838948f, 
    0.00802834f, -0.03331332f, 0.03462140f, 0.02451027f, -0.02470748f, -0.00539238f, 0.00485227f, 0.02855316f, 
    -0.01300866f, 0.00883081f, -0.00792433f, -0.05813144f, 0.01259675f, -0.05795123f, 0.01898337f, 0.02029231f, 
    0.03603683f, -0.00725017f, -0.00042088f, -0.01317805f, 0.00722973f, -0.03847214f, -0.03718970f, 0.02034842f, 
    0.01540332f, 0.00761381f, -0.05491842f, -0.00796489f, -0.03260387f, -0.04958967f, -0.04022292f, 0.01217337f, 
    -0.02861075f, 0.02350155f, -0.02024986f, -0.02222447f, -0.03324106f, -0.04501054f, -0.04324841f, 0.03987337f, 
    -0.05776202f, -0.02077757f, -0.00559407f, 0.00696379f, 0.03276768f, -0.03937337f, 0.03590809f, -0.04499890f, 
    0.03043049f, -0.03368896f, 0.04186883f, 0.02583428f, 0.04972996f, -0.04176883f, -0.02372944f, -0.01036191f, 
    0.00056099f, -0.00493351f, 0.02012577f, -0.01245613f, 0.03699186f, 0.04456866f, -0.02332316f, -0.00296120f, 
    -0.03999882f, 0.00852484f, 0.03458359f, -0.05856617f, 0.04808706f, 0.00816096f, -0.03130441f, 0.02021074f, 
    -0.04970220f, 0.03552643f, -0.03610093f, -0.04345998f, -0.03215971f, -0.00257152f, -0.00139325f, -0.00016174f, 
    -0.01453158f, -0.03089190f, -0.04125600f, 0.02190253f, -0.06089458f, 0.02250288f, -0.04618594f, 0.03699797f, 
    -0.01437861f, 0.03135522f, -0.05810026f, 0.04061799f, -0.00572825f, 0.00435193f, -0.04605452f, -0.04676645f, 
    0.04767081f, -0.03841394f, 0.00778118f, -0.02674531f, -0.00812123f, 0.01180960f, -0.02612957f, 0.01592829f, 
    -0.02079531f, 0.01432788f, -0.01467535f, -0.00611850f, -0.02056769f, 0.02014669f, 0.01035012f, 0.04850353f, 
    0.02237691f, -0.03097719f, 0.00738304f, -0.00105995f, -0.05847471f, -0.02367352f, 0.02622877f, -0.05584612f, 
    0.00242154f, 0.03331384f, -0.06105099f, -0.03372194f, -0.01903595f, 0.00010769f, -0.06163751f, 0.03070922f, 
    0.04280952f, -0.00370502f, -0.00128064f, -0.04360475f, 0.02302261f, -0.05168661f, -0.01388023f, 0.04239733f, 
    0.02610500f, -0.06092110f, -0.03445486f, 0.00763010f, 0.02058591f, 0.04528773f, -0.01878523f, -0.01044899f, 
    -0.02579113f, 0.04293894f, 0.01695260f, -0.02504296f, -0.02901373f, -0.03216053f, -0.03108813f, -0.04124143f, 
    -0.03395093f, 0.02301794f, -0.04097471f, 0.01840322f, -0.05820224f, 0.03742336f, -0.06074208f, -0.05316722f, 
    0.03435151f, 0.01156686f, 0.02550249f, -0.00755025f, -0.02506759f, 0.00721770f, -0.03965981f, 0.01134135f, 
    -0.05607935f, 0.04279176f, -0.02513626f, -0.04494397f, -0.02925343f, -0.02282595f, 0.03381401f, 0.04271187f, 
    -0.02250388f, -0.01163409f, -0.04441077f, -0.00304043f, -0.05448393f, 0.03759723f, -0.04942456f, -0.04539543f, 
    0.02672536f, -0.02986706f, 0.03698023f, -0.04138785f, 0.04713169f, -0.03219965f, -0.00498452f, -0.03980137f, 
    0.00913979f, 0.03602313f, 0.00098006f, -0.01647574f, -0.01063602f, 0.02417155f, -0.05861282f, 0.00547184f, 
    -0.02884227f, -0.03798313f, -0.02356783f, -0.05228670f, -0.02265815f, 0.04079549f, 0.04581248f, 0.00417506f, 
    -0.00050877f, -0.05501196f, 0.00001660f, -0.03013864f, -0.00362910f, -0.04420612f, 0.01781450f, -0.04558264f, 
    0.03536179f, 0.02546733f, -0.03493881f, -0.02735875f, 0.02595785f, 0.03425984f, 0.01774029f, -0.06145407f, 
    -0.05491691f, -0.03225755f, 0.00628650f, -0.05823090f, -0.02992958f, 0.02310582f, 0.01527317f, -0.04771771f, 
    0.01699072f, -0.02964573f, 0.03613505f, -0.05111196f, 0.04225505f, -0.02268023f, 0.02948667f, 0.02384223f, 
    0.03750587f, 0.00419980f, -0.03866675f, 0.02055364f, -0.03709406f, 0.03949623f, 0.04968383f, 0.03224303f, 
    -0.02287951f, -0.00117296f, 0.04345544f, -0.04800965f, -0.01322553f, -0.04592391f, 0.00855583f, -0.00835684f, 
    -0.03344423f, 0.03901603f, -0.20021258f, 0.12849249f, 0.23633386f, -0.04368985f, 0.10999481f, -0.02866681f, 
    -0.10816219f, -0.03545850f, -0.13435881f, 0.14911912f, 0.00920542f, 0.03583294f, 0.00663147f, 0.08054158f, 
    -0.05119807f, 0.08591304f, -0.12515531f, -0.06867963f, 0.14001927f, -0.14902237f, 0.14813197f, -0.01799109f, 
    0.00019712f, 0.01989807f, 0.05002309f, 0.04852670f, -0.04091588f, -0.03308766f, 0.00974948f, 0.03746463f, 
    0.05472607f, -0.02599606f, 0.06024247f, 0.03498582f, 0.03470058f, 0.00116165f, -0.02098369f, -0.05547059f, 
    -0.08143713f, 0.06902301f, 0.20127803f, 0.02999294f, -0.30827031f, -0.21805613f, 0.09254088f, -0.03471677f, 
    -0.00850912f, 0.05042323f, 0.07183240f, 0.01484397f, 0.05793222f, 0.01037277f, 0.09870146f, -0.12512852f, 
    0.01247328f, 0.02951832f, 0.01613687f, -0.14292569f, 0.23052835f, 0.03744972f, 0.22640708f, 0.23732516f, 
    -0.15759088f, 0.11068241f, -0.00037882f, 0.06881267f, 0.16209628f, -0.17950597f, 0.00424706f, 0.03573098f, 
    0.08925071f, 0.01413133f, 0.01956554f, 0.08522230f, -0.06634922f, 0.05206787f, 0.02050607f, 0.14913511f, 
    0.11761716f, 0.20732072f, -0.21999219f, -0.12899725f, -0.19181679f, -0.06220507f, -0.03596872f, -0.05382017f, 
    0.03475461f, -0.07543076f, -0.05414311f, -0.00219591f, 0.03143931f, -0.10731404f, 0.03912863f, 0.11053911f, 
    0.05510291f, 0.14087936f, 0.01128494f, 0.04487799f, 0.04963056f, -0.10630182f, 0.47123587f, 0.18516921f, 
    -0.14067787f, -0.01187439f, -0.07588475f, 0.03348443f, 0.04539483f, 0.11494665f, 0.08468076f, -0.08798610f, 
    -0.00544470f, 0.11377201f, -0.04118480f, 0.08855434f, 0.12423441f, -0.16132563f, -0.02659287f, -0.03671961f, 
    0.20123127f, -0.16270231f, -0.15640424f, 0.18007708f, -0.08718903f, -0.06896930f, 0.04312982f, -0.02164104f, 
    0.03981076f, -0.04316903f, -0.01480416f, -0.00899201f, 0.10560632f, -0.03763508f, 0.13207595f, 0.10834607f, 
    0.06755508f, -0.03637394f, -0.10455960f, 0.08932398f, -0.18688650f, -0.00541838f, -0.14051537f, 0.09931320f, 
    0.10403290f, -0.03994630f, -0.08168638f, -0.11189339f, 0.01834115f, -0.18360467f, -0.19083056f, 0.14148238f, 
    -0.12312014f, -0.12445942f, -0.00883893f, 0.05569728f, 0.08081978f, -0.07991945f, -0.08464988f, 0.02376046f, 
    0.40308395f, -0.47004074f, 0.39270073f, 0.13388018f, -0.02507838f, 0.22023576f, -0.16222890f, -0.12002266f, 
    -0.03122264f, -0.05866451f, 0.02168456f, 0.05723863f, -0.05501180f, 0.00312410f, 0.02403158f, -0.12307747f, 
    0.11576840f, 0.01194037f, 0.11658049f, -0.02942877f, 0.09691603f, 0.16978414f, -0.04144778f, -0.11820181f, 
    -0.15172675f, 0.04126054f, 0.06501106f, -0.10643084f, -0.05317464f, 0.13063453f, 0.07650734f, -0.04424776f, 
    -0.03878742f, 0.02547853f, -0.08879395f, 0.14146157f, 0.02156420f, 0.04582325f, -0.03848442f, 0.16004270f, 
    0.39464229f, -0.17069229f, -0.27278951f, 0.16894259f, 0.19308917f, -0.06457437f, -0.11234348f, -0.00164856f, 
    0.06659891f, -0.01301847f, -0.03640992f, 0.12867968f, 0.01600071f, -0.03589984f, -0.02489164f, -0.08242077f, 
    -0.05226574f, 0.08665681f, -0.05675346f, -0.07321867f, 0.08967590f, 0.35002348f, 0.06206015f, -0.19702612f, 
    -0.06124242f, 0.06425769f, 0.09418093f, -0.21326776f, 0.05973309f, 0.09032735f, -0.04517473f, -0.10750814f, 
    -0.07085883f, 0.04592273f, 0.01614659f, 0.05992683f, 0.05723210f, 0.02661278f, 0.02521292f, 0.19095615f, 
    0.01459032f, -0.19027302f, 0.06224471f, -0.04821529f, -0.21257183f, 0.13430095f, 0.10325481f, -0.05179235f, 
    -0.08899525f, -0.19237500f, 0.17511877f, 0.07851370f, 0.03122492f, 0.05800244f, 0.04961129f, -0.04570008f, 
    0.06136128f, -0.00520674f, 0.10497469f, -0.00421017f, 0.01776367f, -0.16782354f, 0.17572773f, 0.16100566f, 
    -0.05121347f, 0.17978075f, -0.06115644f, -0.05881786f, -0.07840461f, -0.12551624f, -0.00308723f, -0.03897340f, 
    -0.04311585f, 0.03527088f, 0.12126803f, -0.10387624f, 0.12332855f, -0.11297567f, 0.05914799f, -0.05711315f, 
    0.46534786f, 0.01928893f, 0.11499643f, 0.25343433f, 0.22574975f, -0.02238394f, 0.00240921f, -0.04023977f, 
    0.05957662f, -0.10016925f, -0.05948606f, 0.00119073f, -0.20705032f, -0.06714599f, -0.10785133f, 0.10667211f, 
    0.02702689f, 0.11459418f, 0.04557062f, 0.22059089f, -0.29128671f, 0.14200801f, 0.31920725f, 0.19007938f, 
    0.37097338f, 0.04000346f, -0.04180615f, -0.08991875f, 0.08832863f, 0.10262333f, 0.00493494f, 0.03773134f, 
    -0.06542430f, -0.04665470f, -0.08352257f, 0.07575549f, 0.07225990f, 0.01924710f, 0.16312194f, -0.00505908f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04647512f, -0.02362699f, 0.02197240f, 0.00929471f, -0.03699073f, -0.03843401f, -0.01079475f, 0.16088934f, 
    -0.04090655f, 0.10594335f, 0.06950884f, 0.07741759f, -0.00480200f, 0.05160399f, -0.04349585f, 0.02494159f, 
    -0.05024881f, 0.10735316f, -0.02582652f, 0.04397758f, -0.02497961f, 0.16643158f, 0.02407908f, 0.16749133f, 
    0.01435533f, 0.04282139f, 0.07786574f, -0.00129245f, -0.01594880f, -0.08219765f, -0.00541576f, -0.10210373f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05618329f, -0.07025608f, 0.12965921f, 0.02049811f, -0.08427954f, 0.11379644f, -0.12199228f, -0.11532184f, 
    -0.07128311f, 0.15182628f, -0.04782167f, -0.09269411f, 0.08428306f, -0.06132816f, 0.07772963f, -0.07687847f, 
    -0.17740700f, 0.10366371f, -0.10556848f, -0.12952803f, 0.03169965f, -0.13323328f, -0.17913190f, 0.09579201f, 
    0.05899363f, 0.07303844f, -0.18698193f, 0.00262328f, 0.10956120f, -0.02450400f, -0.16854680f, 0.14432132f, 
    -0.07505562f, -0.20332824f, -0.09312523f, -0.12726726f, 0.01152111f, 0.09260663f, 0.09638376f, 0.09569938f, 
    0.00287882f, -0.12067430f, 0.02861727f, 0.11855421f, -0.16245703f, -0.07174287f, -0.08996979f, -0.15816203f, 
    0.12696378f, 0.06433687f, 0.11773217f, -0.16463502f, -0.12672554f, -0.02124136f, -0.05111821f, -0.00008934f, 
    0.12234737f, -0.07414979f, -0.04019657f, -0.17141959f, 0.12173194f, -0.01862701f, -0.10808370f, -0.16096982f, 
    0.12632531f, -0.03566850f, 0.16587669f, -0.44399759f, -0.09319242f, 0.04216182f, -0.33448794f, 0.45892256f, 
    0.15086403f, -0.21753401f, -0.08636081f, 0.34373632f, 0.11475664f, -0.09246182f, -0.01896450f, 0.10740703f, 
    -0.05256608f, 0.33529314f, 0.04865925f, 0.32688811f, -0.09244990f, 0.19305106f, 0.12062284f, 0.21716601f, 
    0.11933204f, -0.08183023f, 0.10995914f, -0.13531937f, 0.06981437f, 0.12898551f, -0.08897685f, 0.03450582f, 
    -0.00357294f, 0.25674096f, 0.13669835f, 0.26024792f, 0.14075764f, -0.01194855f, 0.02090160f, -0.56073439f, 
    0.11435609f, -0.19609307f, 0.21629538f, 0.13818549f, -0.30718303f, 0.16811210f, -0.03926236f, -0.04028073f, 
    0.04123753f, -0.19932607f, 0.07807083f, -0.36478478f, -0.16306452f, 0.02256880f, 0.07071020f, 0.48956436f, 
    -0.00611447f, 0.07023014f, 0.54749101f, 0.08757583f, -0.06659589f, 0.28648639f, 0.12638304f, -0.08974376f, 
    -0.11754232f, -0.11072385f, -0.11512803f, -0.21791773f, 0.07670324f, 0.07978099f, 0.21508017f, -0.63477612f, 
    -0.03340316f, -0.15263128f, 0.34288344f, -0.08863954f, -0.15760784f, 0.10192977f, -0.14289732f, -0.04310687f, 
    0.04428536f, 0.41211155f, 0.08023036f, 0.44130263f, -0.07756346f, 0.03013143f, -0.05935465f, -0.48969293f, 
    -0.08205318f, 0.07957778f, -0.41323221f, 0.02998588f, -0.10530192f, 0.27509290f, 0.02115462f, 0.24174561f, 
    0.02419730f, -0.22143143f, 0.15646496f, 0.09230401f, -0.09582716f, -0.05096495f, -0.10170039f, -0.06390735f, 
    -0.10940361f, 0.06010446f, 0.12828055f, -0.00557315f, -0.37242144f, 0.30320364f, -0.01476259f, 0.13667187f, 
    -0.09096972f, -0.03515166f, -0.02811228f, 0.03818315f, -0.10907017f, -0.27909884f, -0.03510506f, -0.07084598f, 
    -0.07068598f, 0.05056818f, -0.47357586f, -0.01061602f, -0.17902689f, 0.14456421f, -0.09390139f, 0.48760945f, 
    -0.17378311f, 0.06183070f, -0.15434422f, -0.07904255f, -0.10006372f, -0.09401611f, 0.00644684f, -0.01141641f, 
    -0.00425232f, 0.16548382f, 0.02180295f, -0.15375400f, 0.01890077f, -0.12618890f, 0.12582983f, 0.03255474f, 
    0.12468729f, -0.17945588f, -0.04956554f, -0.14315352f, 0.09023009f, 0.06610502f, -0.13681863f, -0.14024067f, 
    -0.15031061f, 0.17647298f, -0.11324948f, -0.16918309f, -0.05911673f, -0.18810822f, 0.03640152f, 0.18078145f, 
    0.11409200f, -0.15171327f, 0.08394181f, -0.15645877f, -0.05609941f, 0.13678636f, 0.03593142f, -0.08265296f, 
    0.15607345f, -0.17392315f, 0.10060730f, 0.08822396f, 0.04566383f, -0.06339582f, 0.17258438f, 0.14834434f, 
    -0.08072491f, -0.03964085f, 0.04810312f, -0.07116494f, 0.13863190f, -0.02329690f, -0.04392213f, -0.17923000f, 
    0.14338085f, -0.03039909f, -0.08108283f, -0.09543576f, -0.15854691f, -0.12273818f, -0.08588236f, -0.13143091f, 
    0.05475790f, 0.09837721f, 0.04432858f, 0.00230868f, -0.01217558f, -0.01209715f, -0.20550629f, 0.24614091f, 
    -0.06635886f, 0.00994401f, 0.25775880f, -0.35739213f, -0.34386411f, 0.14868951f, 0.03389897f, 0.08938098f, 
    0.04707380f, 0.24335372f, 0.10499488f, 0.11567081f, -0.00856724f, -0.17663825f, -0.09334480f, 0.58794492f, 
    -0.12086470f, -0.02996181f, -0.45705810f, -0.13806966f, 0.06016061f, 0.30076402f, 0.05480759f, 0.04752676f, 
    0.13453315f, -0.66364723f, 0.15013987f, 0.08446919f, 0.16372558f, -0.14817998f, 0.21518730f, -0.20852207f, 
    0.02281920f, 0.31746244f, 0.30755106f, -0.43290725f, -0.12077816f, 0.30284452f, 0.02747626f, -0.00397282f, 
    -0.08189413f, -0.14172669f, 0.13100274f, 0.04751853f, 0.09795011f, 0.14190632f, -0.09911611f, -0.51121432f, 
    0.01260360f, 0.12356514f, 0.61825019f, -0.13365127f, -0.11955795f, -0.13452101f, 0.13502485f, -0.10487922f, 
    -0.04085262f, -0.02379778f, 0.07763398f, -0.14546351f, 0.07300705f, -0.05643981f, -0.16440114f, -0.11773409f, 
    0.10024013f, -0.14941983f, -0.11672652f, 0.11118010f, 0.10400251f, -0.19770403f, -0.07705936f, 0.16691418f, 
    0.01225742f, 0.08851050f, 0.04017888f, 0.09312709f, -0.05645476f, 0.01594952f, -0.08538454f, -0.09915793f, 
    0.08044443f, -0.07453548f, 0.01464700f, -0.14099330f, 0.05727896f, -0.07214463f, 0.08475070f, -0.02796376f, 
    -0.06902448f, -0.11586925f, -0.01058417f, -0.14623995f, 0.13439322f, 0.11284511f, 0.05260728f, 0.04636975f, 
    0.00310801f, -0.10599106f, 0.10174488f, -0.02044341f, -0.04496843f, -0.17053078f, 0.03486581f, -0.08303694f, 
    -0.00026898f, -0.17491269f, -0.11852054f, 0.04131742f, -0.09235653f, 0.11360708f, 0.16301490f, 0.01400580f, 
    -0.13212873f, -0.12105490f, -0.16358221f, -0.11311933f, 0.14550816f, -0.04785956f, 0.13851303f, -0.13473131f, 
    0.03014891f, 0.04660482f, -0.03953598f, -0.10064281f, -0.16225344f, -0.01484955f, -0.05828302f, 0.02829982f, 
    0.15764812f, 0.12774700f, -0.01808190f, 0.08760408f, 0.06232421f, -0.15494558f, -0.17143808f, -0.18521085f, 
    -0.09455325f, 0.03690138f, 0.10200914f, -0.18819028f, -0.13169979f, -0.20533654f, 0.07594004f, -0.03037476f, 
    0.04446804f, -0.05827173f, -0.13578472f, 0.14543903f, -0.12039340f, -0.08406814f, -0.07030638f, 0.04472533f, 
    0.10638320f, -0.16209696f, -0.14532375f, -0.48151386f, -0.06858774f, -0.15744631f, -0.03925013f, 0.29213539f, 
    0.16856876f, 0.09512035f, 0.17755540f, 0.33492798f, -0.28465927f, 0.20406659f, -0.03366429f, -0.05956690f, 
    0.00241206f, 0.18694909f, -0.08060675f, 0.37901279f, 0.07284804f, 0.10799236f, 0.15010524f, 0.23847421f, 
    -0.03575757f, 0.15091401f, -0.42428476f, 0.02026163f, -0.09796128f, -0.15546338f, 0.11590468f, -0.00289649f, 
    -0.10038509f, 0.37243861f, -0.10241706f, 0.09583027f, 0.16319102f, 0.03481726f, -0.35073459f, 0.33879259f, 
    0.10327312f, -0.29083991f, -0.24661559f, 0.37135944f, 0.29445252f, 0.10816621f, 0.14258838f, -0.12973978f, 
    -0.12493691f, 0.06569225f, -0.17043188f, -0.38604420f, -0.06525826f, 0.21959047f, -0.11213388f, 0.12492400f, 
    -0.00483293f, 0.15025565f, 0.23266257f, 0.09778144f, -0.17020240f, 0.21431321f, 0.03344112f, 0.06092665f, 
    -0.07596350f, -0.02547932f, 0.12290704f, 0.23885873f, -0.05675176f, 0.13104743f, 0.02500498f, -0.44693375f, 
    0.07683174f, 0.38065505f, 0.09680210f, 0.09424005f, -0.34692827f, 0.18141766f, 0.04317126f, 0.12363647f, 
    0.13914821f, -0.01123658f, 0.04557208f, -0.43123636f, 0.03632308f, -0.18536142f, -0.02525084f, 0.36546546f, 
    0.15203698f, 0.08253272f, -0.15926191f, 0.02557847f, -0.15948726f, 0.12451787f, -0.10576066f, -0.15375723f, 
    -0.07004436f, 0.20062616f, 0.14243092f, 0.35541412f, 0.08858903f, 0.15231508f, -0.36027312f, -0.62133694f, 
    -0.06863574f, -0.03163266f, -0.12200315f, 0.25992191f, 0.04133353f, 0.11033102f, -0.00774702f, -0.05237402f, 
    -0.07113475f, 0.39508337f, -0.15564415f, -0.42919075f, -0.08930927f, 0.35894728f, -0.03586869f, -0.14832328f, 
    0.06914649f, 0.02517573f, -0.09203265f, -0.12205738f, -0.10365576f, 0.16817860f, -0.14645247f, 0.00799909f, 
    -0.12675889f, 0.27422237f, 0.15109824f, -0.09716381f, -0.09456699f, 0.01423721f, 0.38089895f, -0.33030707f, 
    -0.04773349f, 0.14238936f, -0.12603401f, 0.33575100f, 0.46218684f, -0.04142684f, -0.01303625f, -0.14452179f, 
    -0.05372165f, -0.13095906f, 0.08183690f, -0.24928913f, 0.13680322f, 0.14989913f, 0.07630994f, -0.42732555f, 
    -0.01490033f, 0.05239618f, 0.35915828f, -0.06573730f, -0.17784913f, -0.01169970f, -0.01207712f, 0.29374370f, 
    0.04671242f, -0.03364161f, -0.01152217f, 0.01488041f, 0.02089261f, -0.15073986f, 0.14525712f, 0.02232354f, 
    0.01226223f, -0.10719769f, -0.08301540f, -0.16196483f, 0.04862026f, -0.10574442f, 0.13173030f, -0.15715525f, 
    -0.00875426f, -0.14038780f, 0.04059589f, 0.06538818f, 0.07570291f, -0.12145288f, 0.16591084f, -0.15161879f, 
    0.16013356f, -0.03544803f, -0.03383110f, 0.05742704f, 0.14470753f, -0.14212671f, 0.07239252f, 0.13652325f, 
    0.15719111f, 0.06823797f, 0.05566705f, 0.18568036f, -0.06457089f, -0.12668149f, 0.43717703f, -0.58077598f, 
    0.06903662f, -0.14106143f, 0.36430600f, 0.06082619f, -0.13239326f, -0.00054646f, -0.14562118f, -0.05078286f, 
    0.00231548f, -0.02101037f, 0.15007395f, 0.33558688f, -0.04600994f, -0.09612169f, -0.04854643f, -0.04732325f, 
    0.13535747f, -0.07897626f, -0.12538485f, -0.10790633f, 0.15928230f, 0.24273738f, -0.01091304f, 0.03831299f, 
    -0.17261775f, 0.09736267f, 0.00426041f, -0.04781621f, -0.03067556f, 0.03590376f, 0.44584635f, 0.39141604f, 
    0.15467164f, 0.11763757f, 0.14816825f, 0.33891332f, 0.19261949f, 0.23548593f, 0.12101067f, -0.12848368f, 
    0.17977171f, -0.55681992f, 0.13459148f, -0.29454267f, -0.12375774f, -0.27483866f, 0.11193228f, -0.19696455f, 
    -0.14540771f, 0.06997912f, 0.18406777f, -0.12642929f, 0.16505237f, -0.28296694f, -0.06655660f, 0.15940556f, 
    -0.17312412f, -0.03185029f, 0.17070374f, -0.12433680f, 0.00198006f, -0.09505741f, -0.11652737f, -0.16353606f, 
    -0.03564068f, -0.15918149f, -0.05226971f, -0.11289131f, 0.14977831f, -0.00456774f, 0.16773647f, 0.09360079f, 
    0.01323905f, -0.02879843f, -0.09387814f, -0.17005065f, 0.04163431f, -0.13175882f, 0.16216478f, -0.14395465f, 
    -0.09967294f, -0.03607627f, -0.06428584f, -0.15668966f, 0.15082158f, -0.00498143f, 0.02488333f, -0.17356044f, 
    -0.12932071f, -0.10377920f, 0.07014061f, -0.22328210f, 0.09657776f, 0.04582892f, 0.40075788f, -0.41231409f, 
    -0.00649155f, 0.56589276f, -0.19465509f, -0.12986733f, -0.11592071f, 0.13048109f, -0.01214394f, 0.09024358f, 
    -0.05399398f, 0.19003974f, -0.10544572f, 0.31529933f, -0.00970167f, 0.22704765f, 0.15396568f, 0.28948158f, 
    0.10755254f, 0.15059531f, -0.47850448f, 0.02825715f, 0.02837826f, -0.10139429f, 0.00618219f, -0.23820356f, 
    0.11060407f, 0.46270660f, 0.11540969f, 0.41172343f, -0.12754685f, 0.12243417f, 0.45366636f, 0.29393330f, 
    -0.02659636f, 0.08809833f, -0.03574011f, -0.49772790f, 0.36117718f, -0.11445221f, -0.16556923f, 0.17901817f, 
    0.13014981f, 0.13101634f, -0.00735840f, 0.27621964f, -0.08682092f, -0.20267087f, -0.12418697f, -0.14953424f, 
    0.06370118f, -0.12954307f, -0.60918999f, 0.08917618f, 0.10071050f, 0.27769735f, -0.07728431f, -0.14269587f, 
    0.06552710f, -0.08434448f, 0.16296482f, -0.29620007f, -0.12377356f, -0.05597682f, -0.03795781f, 0.02130620f, 
    0.06858411f, -0.21746722f, 0.17139396f, 0.37465909f, 0.16447166f, -0.02429288f, 0.17011063f, -0.08944983f, 
    0.10385653f, 0.31680408f, 0.06216154f, 0.44002357f, 0.05773466f, 0.26971519f, -0.09414252f, 0.07246949f, 
    -0.02393873f, 0.17782888f, 0.43433991f, 0.04879709f, 0.14104809f, -0.09139358f, 0.03413443f, -0.18716362f, 
    0.17328276f, -0.13261655f, 0.16580287f, -0.04226300f, 0.07462540f, -0.02324781f, 0.03771353f, -0.37621579f, 
    0.01174145f, -0.21530153f, -0.09557899f, 0.55981708f, 0.41700155f, 0.05554664f, 0.12752579f, -0.01784278f, 
    0.15707533f, 0.21848507f, -0.06618361f, 0.11157507f, 0.10702993f, 0.08342118f, 0.17269844f, -0.57082933f, 
    0.14825881f, -0.09101402f, -0.05372766f, -0.11498014f, 0.16765052f, 0.32947123f, 0.12286037f, 0.37317154f, 
    -0.14982232f, 0.21317524f, 0.01147785f, 0.12811874f, 0.13735576f, 0.01351249f, 0.20739979f, 0.24408972f, 
    -0.10690107f, 0.37519845f, 0.03072610f, -0.22547030f, 0.20229426f, -0.18408088f, 0.16051745f, -0.14515528f, 
    0.10988782f, 0.34976861f, -0.13365701f, 0.49290848f, -0.16016613f, 0.27523816f, 0.11978626f, -0.10801890f, 
    0.07809465f, -0.10134333f, -0.24013244f, 0.07216592f, 0.05131207f, 0.12748770f, 0.10178482f, -0.40518630f, 
    -0.04103072f, -0.43221536f, -0.15952620f, -0.04670230f, -0.11301759f, 0.02977793f, -0.42812368f, 0.35041767f, 
    0.17974848f, 0.45321876f, 0.28339455f, 0.01890764f, -0.00521914f, 0.14745949f, -0.00142199f, 0.05734058f, 
    -0.05886327f, -0.13974112f, -0.11423320f, -0.01742051f, 0.10913282f, 0.15543462f, -0.03705037f, -0.48502514f, 
    -0.03003711f, -0.11714451f, -0.06187294f, 0.03346432f, -0.06454829f, -0.01699994f, -0.06554826f, 0.50193340f, 
    0.09222937f, 0.03627900f, 0.03156708f, 0.59533638f, -0.13121746f, 0.07993415f, -0.01415598f, 0.00784360f, 
    -0.01681501f, -0.22534327f, 0.01035763f, -0.30364066f, 0.04085591f, 0.31077337f, -0.10732836f, -0.14089383f, 
    -0.03139048f, -0.01877268f, 0.02514027f, -0.14594494f, 0.13306475f, -0.19382527f, -0.05250053f, -0.18937966f, 
    -0.08381601f, 0.06107730f, 0.54602712f, -0.05332151f, 0.07661454f, 0.11355607f, -0.09775627f, 0.41866508f, 
    -0.03941923f, 0.15298957f, -0.04989003f, 0.39688092f, -0.01667099f, -0.01633249f, -0.42276567f, 0.32560822f, 
    -0.10645419f, 0.35446742f, 0.44518334f, -0.14975968f, -0.02339128f, 0.09412009f, 0.09245113f, 0.15278248f, 
    -0.14760344f, 0.00853546f, 0.15598401f, -0.39160395f, 0.13087584f, 0.15332873f, -0.07807428f, 0.46946359f, 
    -0.03107895f, 0.04953525f, 0.29929364f, -0.03372113f, 0.07563047f, -0.07127804f, 0.09112529f, -0.34057167f, 
    -0.10755885f, 0.42567214f, -0.01747139f, 0.31573260f, 0.11271939f, 0.12571920f, 0.26553282f, -0.05313914f, 
    -0.06067380f, 0.16126671f, -0.35263249f, -0.03745655f, 0.02853363f, 0.24007727f, -0.08015005f, -0.11472975f, 
    -0.02432826f, -0.18259341f, -0.05941481f, -0.15233493f, 0.03258456f, -0.17872734f, 0.02166213f, 0.56664318f, 
    -0.09943622f, 0.04317513f, -0.03558476f, 0.03732011f, 0.04418728f, 0.14441396f, -0.03710939f, 0.30250055f, 
    0.12417920f, -0.33428586f, 0.17540002f, -0.38469082f, 0.04302942f, -0.13489239f, 0.64985961f, -0.19539167f, 
    0.15644319f, 0.13516417f, -0.08724295f, -0.08089323f, 0.21815717f, -0.01257040f, 0.01507883f, 0.04651389f, 
    0.09477680f, 0.02464002f, 0.07716339f, 0.22645997f, -0.02074807f, -0.06839052f, 0.00310091f, 0.14401494f, 
    -0.11753662f, 0.13973989f, 0.39285535f, -0.09061477f, -0.11365138f, -0.06335357f, 0.07546642f, 0.07904441f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00857101f, -0.07392109f, 0.09939987f, 0.15967838f, 0.04299102f, -0.03873526f, 0.08819552f, -0.22029312f, 
    -0.03687116f, 0.10807018f, -0.19178890f, -0.06903862f, -0.14216749f, 0.12135367f, 0.03727473f, 0.10062305f, 
    0.14429925f, 0.06172584f, -0.04450838f, 0.16598856f, -0.02108152f, 0.04821121f, 0.04988749f, -0.16237161f, 
    0.33564287f, 0.07943211f, 0.16076192f, -0.12312112f, -0.05418402f, 0.05063675f, -0.18415986f, 0.12473957f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.07831009f, -0.17510928f, -0.33638811f, -0.27104750f, 0.37859228f, 0.34141046f, 0.01297611f, -0.05229098f, 
    0.10657552f, 0.21161062f, -0.11739486f, 0.04580749f, -0.03953689f, -0.07340816f, -0.44885534f, -0.20427553f, 
    -0.08204373f, -0.24340910f, -0.13188641f, 0.24005456f, -0.91711187f, -0.16955587f, 0.25319788f, 0.33538055f, 
    -0.13595270f, 0.04217961f, -0.01216972f, -0.00831673f, 0.21217383f, -0.58007437f, 0.05656200f, 0.21149814f, 
    0.14437477f, -0.05435421f, 0.09717032f, -0.30275476f, 0.19236340f, -0.46540418f, -0.05085374f, 0.06091082f, 
    0.11974695f, -0.34176460f, 0.10306060f, -0.03124293f, 0.06926984f, 0.21309134f, -0.20079428f, -0.55313176f, 
    -0.15193038f, -0.10022321f, 0.03428275f, 0.22999908f, 0.59145570f, 0.06324729f, 0.18740767f, 0.40366998f, 
    0.23808317f, 0.00209548f, 0.28176382f, -0.20359063f, -0.51188993f, -0.24128567f, -0.36832833f, 0.01131527f, 
    0.01639008f, 0.15805517f, -0.03562128f, -0.06918334f, -0.03351604f, -0.38330078f, -0.06987992f, 0.11477232f, 
    0.01863443f, -0.30308315f, -0.04259233f, 0.04222792f, 0.14523937f, -0.82245517f, 0.30547029f, -0.10567193f, 
    0.29809931f, -0.00344534f, 0.13816419f, -0.16769588f, -0.68065476f, -0.11443103f, -0.51096874f, 0.52318823f, 
    -0.08930364f, 0.33404303f, 0.09189939f, -0.31834435f, 0.25821531f, 0.02544427f, -0.09372535f, -0.39107457f, 
    -0.13480406f, 0.01372832f, -0.36436388f, 0.13977203f, -0.41725677f, 0.32262129f, -0.05671160f, -0.02275137f, 
    0.37865886f, -0.12819839f, -0.17767575f, 0.15938346f, 0.13264985f, -0.03739919f, -0.13210191f, 0.42770970f, 
    -0.41618705f, -0.50995708f, -0.17348422f, -0.15088727f, -0.12694547f, -0.17272469f, 0.17933966f, 0.17486703f, 
    -0.68043363f, -0.71713859f, -0.17784677f, 0.22884381f, -0.02690233f, 0.26924229f, 0.22446211f, -0.43404198f, 
    0.04089993f, -0.18122235f, -0.33958894f, 0.46898720f, -0.02921642f, -0.18298842f, -0.14778170f, -0.19807452f, 
    -0.05478346f, 0.25212806f, -0.04798216f, 0.09033836f, 0.05465289f, -0.13880359f, -0.14040744f, 0.58506918f, 
    0.27344644f, -0.11068208f, -0.06013004f, 0.16570237f, -0.06651843f, -0.02631802f, 0.23608880f, -0.44531757f, 
    0.05399745f, -0.15447427f, -0.06062868f, -0.18934740f, -0.13010000f, 0.26005813f, -0.22038439f, 0.07480680f, 
    -0.17450845f, -0.11944198f, 0.23578253f, -0.32912683f, 0.14228079f, 0.22517048f, 0.16188009f, -0.09342333f, 
    0.08417398f, 0.09614483f, -0.07305780f, 0.01306986f, -0.08251256f, 0.45434299f, -0.02768156f, -0.08153318f, 
    -0.06232741f, -0.21660800f, 0.09411637f, -0.16194265f, -0.08167416f, -0.12471987f, 0.17984833f, -0.84320581f, 
    0.19989403f, 0.24934965f, -0.11071280f, 0.30194935f, -0.45881802f, -0.15402457f, -0.55273342f, 0.21137635f, 
    0.02169404f, 0.08881867f, 0.18313828f, 0.34846404f, 0.14225556f, 0.05791847f, -0.06602442f, -0.05424198f, 
    0.16457652f, -0.47957942f, -0.09144384f, 0.01603131f, 0.00501195f, -0.03572907f, 0.37257686f, -0.39098331f, 
    0.37468454f, -0.16158161f, 0.00661838f, -0.07759167f, -0.74922097f, -0.11474029f, -0.52118987f, -0.75234413f, 
    0.18833256f, 0.22676234f, -0.36513484f, -0.06264259f, 0.21975157f, -0.03734598f, -0.05710053f, -0.63401186f, 
    -0.05151503f, 0.10355511f, -0.31045356f, 0.11247081f, -0.35938489f, 0.09911654f, -0.06739921f, -0.08103281f, 
    -0.15880848f, -0.13926195f, 0.10896208f, -0.03512889f, -0.01493788f, -0.13885617f, 0.08195783f, 0.22474092f, 
    -0.34943444f, 0.27740592f, 0.13530925f, 0.08806804f, 0.62599689f, 0.07212340f, -0.33496249f, -0.05124344f, 
    -0.28810045f, 0.08946852f, -0.56425083f, -0.06203605f, 0.00922435f, -0.30727059f, 0.36365366f, -0.16182518f, 
    0.12680592f, -0.04626328f, 0.05861160f, -0.58630544f, -0.31038219f, -0.47146520f, -0.02284380f, -0.03941619f, 
    -0.47380319f, -0.49904218f, -0.11355816f, 0.12888083f, -0.06884952f, -0.05930840f, 0.19906721f, -0.08298614f, 
    0.32718351f, 0.45978752f, -0.17102937f, -0.84976828f, 0.06944108f, 0.04284903f, 0.47747228f, -0.07905838f, 
    0.06109813f, 0.19551817f, 0.23015574f, 0.12256184f, -0.59847629f, -0.29384223f, 0.02759323f, 0.09094236f, 
    -0.16533388f, -0.14925861f, 0.04390124f, 0.14942247f, -0.03089203f, -0.37665680f, -0.07518063f, 0.04442837f, 
    -0.42034966f, 0.39249748f, -0.06486006f, -0.10981915f, 0.11886256f, -0.40009931f, 0.02989352f, -0.73446977f, 
    -0.23266375f, 0.27030680f, 0.00374422f, -0.00134852f, 0.09846819f, 0.01932336f, -0.69667864f, -0.27032486f, 
    0.22263953f, 0.20947354f, -0.17276086f, 0.11825715f, 0.36653370f, -0.19349906f, -0.23541002f, 0.55561912f, 
    -0.11384623f, -0.05430016f, 0.24853827f, 0.05070706f, -0.79106212f, -0.37285835f, -0.17381819f, 0.10531670f, 
    0.27404574f, -0.38247254f, 0.13105756f, -0.09420678f, -0.11179972f, 0.12932335f, 0.13530537f, -0.18376572f, 
    -0.46014193f, -0.54506260f, -0.10645006f, -0.50557250f, -0.11337957f, 0.00012556f, 0.19958314f, 0.05227757f, 
    0.22061399f, -0.54449111f, 0.15007345f, -0.76614618f, -0.07737714f, 0.04950196f, 0.33644795f, 0.49556231f, 
    -0.01326237f, 0.06773090f, 0.00926403f, -0.22562416f, -0.43912944f, -0.07654302f, 0.20430201f, 0.08996113f, 
    0.05344927f, 0.49647731f, 0.10989931f, 0.06761478f, -0.13659427f, 0.03462514f, -0.03863342f, -0.36567071f, 
    -0.10819662f, -0.32088223f, -0.08784509f, -0.64666444f, 0.18843517f, 0.06822330f, -0.23595290f, -0.02671756f, 
    0.14322546f, -0.41880956f, 0.18507200f, 0.62554920f, 0.20995805f, 0.38211611f, -0.35803786f, -0.44008681f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.28660947f, 0.09429505f, -0.08137695f, -0.18803792f, 0.22001635f, -0.00815338f, -0.09020303f, -0.18203975f, 
    -0.09197392f, -0.03813019f, 0.21345651f, 0.02684531f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
