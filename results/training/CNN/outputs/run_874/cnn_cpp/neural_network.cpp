#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.60477710f, 0.05775920f, 0.12735331f, 0.08434376f, 0.42266044f, 0.32624856f, -0.50940973f, 0.01046725f, 
    0.28281435f, -0.81556600f, 0.39480701f, 0.28461623f, 0.42692015f, -0.31619576f, 0.10627663f, -0.04773101f, 
    -0.09234939f, -0.02871970f, -0.70852524f, -0.45757458f, -0.48581791f, 0.12593524f, 0.61390656f, 0.47244000f, 
    0.29120648f, -0.23944369f, 0.24485660f, 0.39241934f, 0.35306138f, 0.37988731f, -0.74463814f, 0.01897128f, 
    -0.64030945f, 0.10373320f, 0.12177387f, 0.00226733f, 0.02944785f, 0.46081898f, -0.14137055f, -0.37694257f, 
    0.70947999f, 0.37374243f, 0.33136448f, 0.37637687f, 0.01082562f, -0.17898956f, -0.56329459f, -0.46712193f, 
    0.44774133f, 0.22631629f, 0.39762843f, -0.38969982f, -0.06248097f, -0.36090741f, -0.75800955f, -0.80711931f, 
    -0.23410447f, -0.13796268f, -0.34841913f, 0.22828773f, -0.08136389f, -0.01125070f, 0.09308357f, 0.75342929f, 
    -0.42928210f, -0.68245637f, -0.21425569f, 0.09913543f, -0.16958129f, -0.22597328f, -0.30550352f, 0.14368770f, 
    0.40808642f, 0.54387248f, 0.62029213f, 0.30047077f, -0.09783690f, 0.15506312f, 0.39493054f, 0.30303407f, 
    0.18480898f, 0.79966110f, 0.44092736f, 0.39248455f, 0.54347450f, -0.05842705f, 0.13267559f, -0.31686214f, 
    0.16719259f, -0.42377284f, 0.43076470f, -0.03347373f, 0.25432190f, -0.12930505f, -0.65678483f, 0.69124830f, 
    -0.00990696f, 0.04911531f, -0.13965531f, -0.67089480f, 0.65771776f, -0.44381198f, -0.00037503f, 0.22543660f, 
    -0.47120309f, 0.16376185f, 0.00549093f, -0.19821961f, 0.22665727f, -0.73941475f, -0.37778577f, -0.19999838f, 
    -0.40142071f, -0.11435446f, 0.21101008f, 0.49706995f, -0.08661783f, -0.09690206f, -0.29793382f, 0.00175996f, 
    0.21881853f, 0.11623103f, -0.59303230f, 0.41613683f, -0.52015662f, -0.31643733f, 0.28308544f, 0.40507212f, 
    0.69331777f, 0.06643331f, -0.13585180f, -0.46915969f, -0.01444773f, 0.01619433f, 0.07154293f, -0.53172523f, 
    0.30797589f, 0.02069521f, 0.55177057f, 0.33432162f, -0.47231770f, 0.15066329f, 0.25646892f, 0.14127813f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.36317536f, -0.22856629f, 0.09309594f, 0.30143741f, -0.22572970f, -0.08600847f, -0.42431867f, 0.27991074f, 
    -0.02460471f, -0.06130086f, -0.11035903f, -0.02486936f, 0.02997178f, -0.41422126f, -0.47515327f, -0.08928990f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.13752474f, 0.03892803f, 0.19183022f, 0.09499227f, 0.14674756f, -0.01353341f, 0.10534178f, 0.00257945f, 
    0.18347892f, -0.45424026f, -0.26207790f, -0.32530946f, -0.00212914f, 0.04991413f, -0.02429850f, -0.17576954f, 
    -0.06650825f, 0.12257812f, 0.22857860f, 0.12349896f, 0.06453663f, -0.07273981f, 0.05618609f, -0.09804675f, 
    0.18437676f, -0.02450603f, 0.01272952f, -0.01768904f, -0.01522277f, -0.04239494f, 0.15324733f, 0.05763835f, 
    0.18899807f, -0.17717959f, 0.14348905f, 0.10333076f, -0.10055898f, 0.00074578f, -0.22981228f, 0.00216338f, 
    -0.02825026f, -0.11523502f, 0.05961052f, 0.03690258f, -0.04823393f, 0.25917712f, 0.28358504f, 0.14241718f, 
    -0.16658461f, -0.17427735f, -0.20682459f, -0.07884637f, 0.01157346f, -0.13017923f, 0.13418590f, 0.48017442f, 
    0.09649302f, 0.05815695f, 0.00240790f, -0.10160874f, -0.09633707f, -0.09070435f, 0.31255695f, -0.11467727f, 
    -0.10479677f, 0.35741073f, -0.11636820f, -0.13056706f, 0.05524928f, 0.04595493f, 0.02764710f, -0.13507317f, 
    0.03504248f, 0.01987235f, -0.02238638f, 0.11909345f, 0.01868317f, 0.05675858f, -0.04436135f, 0.04934710f, 
    0.19927107f, -0.04254265f, -0.09101187f, -0.05476487f, 0.23406397f, 0.30901372f, 0.15521415f, 0.06404439f, 
    0.10576334f, -0.04164347f, -0.23052123f, -0.32334769f, 0.00320942f, 0.10903474f, 0.04904578f, 0.02408662f, 
    0.19422434f, 0.17088789f, 0.08259977f, -0.50614244f, 0.04686353f, 0.07457612f, 0.01505320f, -0.09508098f, 
    -0.09376968f, -0.11931081f, -0.04443998f, -0.03221355f, -0.04255562f, -0.35894459f, -0.02229924f, 0.09187564f, 
    -0.03790893f, 0.04752789f, 0.16517185f, -0.07860070f, -0.10498833f, -0.14422685f, -0.15475932f, -0.04870788f, 
    0.12001570f, 0.06227777f, 0.03158495f, 0.15872873f, 0.03735004f, -0.01279301f, -0.19284765f, -0.21667774f, 
    -0.42068976f, 0.14471675f, 0.02299085f, 0.14341891f, -0.17111889f, -0.15126188f, -0.11566103f, 0.02665850f, 
    -0.16138254f, -0.45984659f, 0.02695643f, -0.10084016f, 0.08863411f, 0.15633859f, -0.05187193f, 0.23065183f, 
    -0.04048496f, -0.08326287f, -0.06445489f, 0.01380525f, -0.06838582f, 0.04670044f, -0.00928485f, 0.02756778f, 
    -0.06924371f, 0.09071755f, -0.08559195f, 0.01639171f, -0.01110759f, 0.03104832f, -0.02824419f, 0.06854758f, 
    -0.05926720f, 0.02538302f, -0.06708691f, 0.01266670f, -0.04325024f, -0.02419095f, -0.03885562f, -0.04759121f, 
    -0.07217833f, 0.03530220f, 0.01185807f, 0.03013367f, -0.07518356f, -0.09050145f, 0.02793978f, -0.04637171f, 
    -0.04090102f, -0.07294334f, -0.00842324f, 0.04432281f, -0.04710471f, -0.10835662f, -0.04111595f, 0.06860022f, 
    0.03601996f, 0.05336234f, -0.05683194f, -0.04356743f, -0.04610538f, -0.07899904f, -0.07199334f, 0.00783553f, 
    -0.00037473f, -0.03946151f, 0.01613781f, -0.02029411f, 0.04436127f, 0.01871503f, -0.00859794f, 0.01135267f, 
    -0.07620385f, 0.07225179f, -0.00539129f, 0.01643667f, -0.00324854f, -0.01381640f, -0.06567587f, -0.10723989f, 
    0.02341189f, 0.00825980f, 0.00310858f, 0.03912742f, 0.05454962f, 0.04090823f, 0.04730055f, -0.06911310f, 
    -0.06666597f, 0.07564605f, 0.01714067f, -0.06314133f, -0.04105948f, -0.07532445f, 0.00891025f, 0.00646062f, 
    0.05335410f, 0.04167117f, -0.06626565f, 0.06585990f, 0.07158722f, 0.01695696f, 0.03652515f, 0.04154220f, 
    0.07020400f, -0.03892736f, -0.05009783f, -0.03392433f, 0.05452619f, -0.00927933f, 0.02134704f, -0.03803187f, 
    -0.02542372f, -0.07696937f, 0.06364530f, -0.01522633f, 0.05217028f, -0.06409074f, 0.05295270f, -0.04870072f, 
    0.05417864f, -0.06976292f, -0.04710906f, 0.01474027f, -0.02581383f, 0.03853730f, -0.03578115f, -0.08946488f, 
    -0.03975013f, -0.06340741f, -0.05933963f, -0.05190780f, -0.05969819f, -0.09448468f, 0.04082374f, -0.07117020f, 
    -0.00794272f, 0.01407958f, 0.00633987f, -0.11806367f, -0.10251567f, -0.07825636f, -0.03237513f, -0.01997090f, 
    -0.05237975f, -0.08337369f, -0.01077112f, -0.06284856f, 0.00523377f, -0.06603897f, -0.06378336f, -0.03145391f, 
    -0.10345797f, -0.11243751f, -0.01130477f, -0.04772011f, 0.00417515f, -0.02484748f, 0.02677122f, -0.07548718f, 
    -0.09560911f, -0.02873997f, 0.02821866f, 0.05810032f, -0.03671761f, 0.04340212f, -0.07385471f, -0.07480122f, 
    0.05514609f, -0.04508314f, -0.06562999f, -0.05264047f, -0.06582736f, 0.00194468f, -0.07412679f, 0.05114287f, 
    0.07194360f, -0.07589949f, -0.07124492f, -0.08228118f, 0.02728385f, -0.09117311f, 0.07158019f, -0.04287610f, 
    -0.06615331f, -0.04023934f, 0.01491120f, -0.05391872f, 0.01876630f, -0.09196942f, -0.01809995f, 0.04272963f, 
    0.02816162f, -0.03384309f, -0.05888912f, 0.06108624f, -0.06454059f, 0.03457836f, 0.02539384f, 0.01164345f, 
    -0.09253079f, 0.05344104f, 0.06869826f, 0.06112456f, -0.04487514f, 0.06167744f, -0.05406290f, -0.03978742f, 
    0.04202903f, -0.06492093f, 0.03773764f, -0.01417808f, -0.02250349f, 0.01375288f, 0.04880142f, 0.06613926f, 
    -0.03813374f, 0.03864241f, -0.03402730f, -0.05615343f, -0.05342445f, -0.06941035f, -0.02911470f, -0.00103001f, 
    -0.06526241f, 0.02137856f, -0.06786116f, -0.02694933f, 0.01732003f, 0.01148994f, 0.00670017f, 0.02755292f, 
    -0.00546497f, 0.00369972f, -0.01209113f, -0.01799069f, 0.00362354f, 0.01379358f, 0.03896794f, -0.05958697f, 
    -0.06948660f, 0.02822685f, -0.00601337f, 0.02313371f, 0.06609765f, -0.03762247f, -0.03942522f, -0.03807887f, 
    -0.01050952f, 0.03715631f, -0.04915584f, 0.04254051f, -0.03967147f, 0.01490908f, 0.06636772f, -0.05108105f, 
    0.01004835f, -0.02472401f, 0.06016857f, 0.07075856f, -0.08950935f, -0.06038861f, -0.08076363f, 0.05674496f, 
    0.06870656f, 0.03544429f, -0.06475521f, 0.00728815f, -0.07314901f, -0.07152218f, 0.01717191f, 0.01390769f, 
    -0.06414291f, -0.02480008f, -0.06244989f, 0.02984482f, -0.05961196f, -0.04209680f, -0.07668119f, -0.05664749f, 
    -0.02849270f, 0.01888653f, 0.05229640f, -0.01846931f, 0.04385679f, -0.08028343f, -0.06141637f, -0.02416411f, 
    0.03256628f, 0.05504226f, 0.04358374f, 0.06436228f, 0.00504807f, -0.06018574f, 0.05809206f, 0.01146268f, 
    0.00142092f, -0.09443808f, -0.02772884f, -0.04446734f, -0.04372779f, 0.03194708f, -0.08105719f, -0.08340564f, 
    0.05995152f, -0.06686175f, -0.06494880f, -0.03747631f, 0.03992538f, -0.04092664f, 0.06975018f, -0.08513889f, 
    -0.06377695f, -0.03761714f, 0.02932242f, 0.05443919f, -0.09078471f, -0.06241797f, 0.05132557f, -0.04653671f, 
    0.00052915f, -0.02958683f, 0.05008784f, -0.03721539f, 0.00967119f, -0.01641897f, 0.04036740f, 0.05845784f, 
    -0.07903708f, 0.02426130f, 0.05662201f, -0.00102382f, -0.01812992f, 0.04213130f, -0.01194578f, 0.00292537f, 
    -0.03986514f, -0.05176864f, 0.00856379f, 0.05255927f, -0.05529838f, -0.06614039f, 0.00930844f, -0.02718383f, 
    0.00142687f, 0.00687923f, 0.01710043f, 0.03940389f, -0.05711306f, -0.01868659f, 0.05417815f, -0.00500002f, 
    -0.05746736f, 0.00725565f, -0.03676865f, -0.05664888f, -0.06915005f, 0.04329915f, -0.06220667f, -0.04323804f, 
    -0.01437585f, 0.06640664f, -0.03184784f, -0.02155764f, -0.03871407f, -0.04048848f, -0.03868586f, 0.03155541f, 
    -0.04234393f, 0.01065536f, -0.07257912f, -0.01602088f, -0.07766590f, 0.04813447f, -0.03656504f, 0.05141881f, 
    0.00888066f, -0.00435822f, 0.04062477f, -0.04030852f, -0.04654138f, -0.08292468f, -0.04449148f, -0.06054875f, 
    -0.06527214f, -0.02001804f, -0.06421932f, -0.00111842f, -0.04740356f, -0.04141564f, -0.02332857f, -0.05732714f, 
    -0.01593817f, -0.00926725f, -0.01615239f, 0.02272159f, -0.00625537f, -0.04776097f, -0.05707949f, -0.04410504f, 
    0.01666941f, -0.02237115f, -0.00142522f, -0.08455856f, 0.00399717f, -0.02213142f, 0.00685947f, 0.04901681f, 
    -0.06564116f, -0.08072007f, 0.04239915f, -0.08230849f, -0.02094549f, 0.06733620f, 0.02297648f, 0.01872625f, 
    0.01833410f, -0.06128836f, 0.02764990f, 0.06405205f, -0.09063265f, -0.07068547f, 0.00053161f, -0.00895084f, 
    0.05792724f, 0.05176860f, 0.00754226f, -0.01000801f, -0.01878046f, 0.02381768f, 0.05643729f, 0.03540029f, 
    0.06095697f, -0.04627256f, 0.01217866f, 0.05906735f, -0.04022407f, -0.01441284f, -0.03744341f, -0.07520591f, 
    0.02731345f, 0.04174463f, -0.06040466f, 0.06733134f, -0.06636693f, -0.04526201f, -0.08077259f, -0.08329935f, 
    -0.06895988f, 0.01694259f, -0.17524719f, -0.05879593f, 0.02570512f, -0.12788233f, 0.13467211f, 0.01529098f, 
    0.03607377f, 0.31268087f, 0.00813641f, 0.10230154f, -0.00447507f, 0.04876803f, -0.06013472f, 0.01798990f, 
    0.11189623f, -0.05005377f, 0.07176208f, 0.10452066f, -0.02507128f, 0.12309811f, 0.09331804f, 0.06563672f, 
    -0.06380596f, -0.06964495f, -0.05211584f, -0.26703218f, -0.28397608f, -0.13279296f, -0.30670288f, -0.13930531f, 
    -0.09547321f, -0.08006439f, 0.00561670f, -0.06664257f, -0.48410255f, -0.03509994f, 0.18113530f, 0.23764722f, 
    -0.17501982f, 0.00724077f, 0.11029212f, -0.05213071f, 0.04920384f, 0.55237734f, 0.14224845f, 0.32098186f, 
    0.15417628f, 0.04403580f, -0.06861424f, 0.07635833f, 0.22520587f, 0.20499270f, -0.16894130f, 0.28777811f, 
    0.26427320f, 0.27262995f, 0.01138343f, 0.06709717f, 0.02619500f, 0.09999207f, -0.04109916f, -0.08746978f, 
    0.11548940f, 0.03144188f, -0.27167132f, 0.06561249f, -0.02287964f, -0.12980050f, 0.12096202f, -0.13476439f, 
    0.10075995f, 0.28551832f, -0.23956566f, -0.05913590f, 0.03872029f, 0.01002569f, -0.08757959f, 0.00939982f, 
    0.09866419f, 0.18455525f, 0.14186959f, 0.19591305f, -0.04674035f, -0.00494648f, 0.01339722f, 0.04721755f, 
    -0.15781960f, -0.10557045f, 0.13892543f, -0.21307264f, -0.24537273f, -0.24806894f, 0.03970694f, -0.05590085f, 
    0.04919012f, 0.00718605f, -0.01644365f, 0.24898776f, -0.16901182f, 0.14827225f, -0.03147304f, 0.06462269f, 
    -0.19556104f, -0.09740764f, -0.00779615f, -0.05838820f, 0.15337497f, 0.18803659f, 0.00383043f, -0.10855210f, 
    -0.11782797f, 0.00367603f, -0.06673671f, 0.05201786f, -0.10269986f, 0.16976549f, 0.35031152f, -0.20891272f, 
    -0.05788776f, -0.16105963f, 0.30627796f, 0.02197262f, 0.08846073f, 0.01946381f, -0.43737864f, 0.18555477f, 
    -0.03530866f, -0.17902364f, 0.02184017f, 0.02817296f, -0.04745676f, 0.08983405f, 0.02266463f, -0.02696058f, 
    0.09927812f, -0.17578699f, -0.03591876f, 0.01904816f, 0.01179094f, 0.08665854f, 0.09812582f, 0.07855159f, 
    -0.22476688f, 0.05730858f, -0.12413561f, 0.00132405f, 0.12114919f, 0.23306903f, 0.05441828f, -0.17815873f, 
    -0.03367684f, 0.06298489f, -0.24571046f, -0.31113738f, 0.07260395f, -0.04013439f, 0.02092971f, -0.20463826f, 
    -0.05207539f, -0.15743455f, -0.24449250f, -0.05415045f, 0.29142019f, -0.11048224f, -0.08781872f, -0.07395839f, 
    -0.04483002f, -0.07058082f, -0.00547426f, 0.23975623f, 0.21619007f, -0.33964670f, 0.09182575f, 0.01363165f, 
    -0.20013197f, 0.03275435f, -0.03939855f, 0.05868817f, -0.03497082f, 0.03477590f, 0.06951115f, -0.17901736f, 
    0.17329355f, 0.01228680f, 0.02354560f, 0.09393764f, 0.05919752f, -0.04627972f, 0.04852609f, 0.32232544f, 
    -0.08013517f, -0.04131506f, 0.35859346f, -0.12863640f, 0.16404939f, 0.14354679f, 0.13977483f, 0.12560998f, 
    0.06718351f, 0.06108872f, -0.00764251f, -0.04726481f, 0.04779990f, -0.03736258f, -0.01345280f, 0.08317105f, 
    0.24187051f, 0.07163976f, -0.17927721f, 0.09197681f, 0.02161559f, 0.04080229f, -0.03166319f, -0.06017268f, 
    0.25799984f, -0.27245945f, 0.11867672f, -0.03983099f, 0.21538852f, -0.08674650f, -0.02207788f, -0.05442008f, 
    -0.07982361f, 0.28256398f, 0.08940405f, 0.17123856f, 0.27367204f, 0.14292471f, -0.00208942f, -0.16948847f, 
    0.10099708f, -0.14400078f, -0.22257671f, -0.01301321f, -0.21985425f, 0.06225524f, 0.15068769f, 0.14695384f, 
    -0.06660138f, -0.01337552f, -0.15786657f, 0.22679973f, -0.00850104f, -0.21182452f, -0.19742295f, -0.01217587f, 
    -0.11417762f, -0.08097612f, 0.00587520f, 0.08556417f, 0.10649286f, 0.11521763f, -0.03169452f, 0.01497175f, 
    0.06484515f, -0.18269154f, -0.03158928f, 0.09681847f, -0.12797622f, -0.09518731f, -0.12962769f, 0.10962103f, 
    0.12555522f, -0.00055939f, 0.12063365f, -0.12774649f, 0.15459807f, 0.11097456f, 0.40383321f, 0.11395954f, 
    -0.14886688f, 0.09304917f, 0.02122268f, -0.03131246f, 0.36406311f, -0.03542868f, -0.01655162f, 0.25628230f, 
    -0.10628930f, -0.13511254f, 0.00708498f, -0.05084295f, 0.07748191f, -0.06717330f, -0.20011885f, -0.08361854f, 
    0.17515309f, 0.24619906f, 0.09667397f, -0.08946648f, 0.04336779f, 0.03297762f, -0.04136430f, 0.20580494f, 
    0.08383466f, -0.19971041f, -0.22364140f, 0.04660809f, 0.05505172f, -0.20484999f, -0.15427612f, -0.02307710f, 
    0.01388702f, -0.07686146f, 0.10069769f, -0.11329074f, -0.28844568f, 0.00676423f, 0.11296399f, 0.14316370f, 
    -0.14650851f, 0.01076681f, -0.09445132f, 0.06249798f, 0.08694953f, -0.11698515f, -0.00881645f, 0.04272509f, 
    0.33390290f, 0.04295509f, 0.14061214f, 0.35865882f, 0.35853818f, 0.10220858f, -0.37968430f, -0.09968028f, 
    -0.28305426f, -0.13746454f, 0.08582055f, 0.02746841f, 0.02384710f, 0.36131176f, 0.24098796f, -0.36772838f, 
    0.04300002f, 0.03871233f, -0.15441686f, 0.05788712f, 0.04114617f, -0.08843909f, -0.48477030f, -0.02697465f, 
    0.01535637f, 0.11401274f, -0.00551722f, 0.12541063f, -0.02756988f, 0.15845700f, 0.00064032f, -0.07807351f, 
    -0.26944536f, -0.05899174f, 0.18456990f, -0.05904720f, 0.14195247f, -0.08694404f, -0.06247394f, 0.10617485f, 
    -0.02735443f, 0.10815085f, 0.01336215f, -0.14013673f, 0.02471644f, -0.07586912f, 0.01674876f, -0.09711098f, 
    0.02954848f, 0.16577077f, 0.12325988f, 0.13106649f, -0.30902916f, -0.08832734f, -0.24407031f, 0.18672298f, 
    0.07049919f, 0.00429196f, 0.00454401f, 0.17951354f, 0.18606775f, 0.10908920f, -0.01540671f, -0.15648969f, 
    0.06539096f, 0.03850142f, 0.08932232f, -0.16735980f, -0.46407819f, 0.03036334f, -0.02281903f, 0.17843457f, 
    0.09915894f, -0.07850638f, -0.23534195f, -0.08910287f, -0.25241929f, -0.18731199f, -0.03934198f, -0.11820429f, 
    0.02639952f, -0.03966680f, 0.10388350f, -0.04754429f, 0.08046553f, -0.13418898f, -0.04072909f, 0.01437015f, 
    -0.03374894f, 0.25018248f, -0.04504926f, -0.04256856f, 0.06132803f, 0.10131217f, -0.07642957f, -0.09965747f, 
    0.13867296f, 0.05028896f, -0.15158309f, -0.09710116f, -0.02014439f, -0.02609491f, 0.01908506f, -0.32220691f, 
    -0.07564951f, 0.10577349f, -0.04519702f, 0.05577178f, 0.01569666f, -0.04923667f, -0.09197307f, 0.14288144f, 
    0.05260162f, 0.27726191f, -0.09119019f, 0.08147140f, -0.13148390f, 0.03350230f, -0.06703229f, 0.00086021f, 
    0.26911038f, 0.37566417f, 0.33723122f, -0.08145488f, 0.12254443f, 0.05231373f, 0.12632038f, -0.04715252f, 
    -0.05755408f, -0.08497833f, 0.46798030f, 0.42162207f, -0.01117492f, 0.06748645f, 0.02905077f, 0.03701032f, 
    0.10954562f, -0.07323945f, -0.03077077f, 0.21272492f, 0.18995932f, -0.26428765f, 0.03680729f, -0.04105848f, 
    -0.06215078f, -0.13452923f, -0.01845928f, -0.06507524f, 0.00449990f, 0.11214779f, -0.21037880f, -0.02142415f, 
    -0.07701092f, -0.03741783f, 0.01125259f, 0.00185746f, 0.05940982f, 0.05232122f, 0.04877226f, -0.03081859f, 
    0.03049688f, -0.02375933f, 0.04946767f, 0.05857180f, 0.00344045f, 0.05353747f, -0.30234244f, -0.05362236f, 
    0.09114748f, -0.03763114f, 0.05647373f, 0.03161479f, -0.11690069f, 0.05670897f, 0.03457732f, -0.02793784f, 
    -0.53799284f, -0.16066149f, -0.14263088f, 0.17089298f, 0.06596489f, 0.00901168f, 0.03721255f, -0.10055341f, 
    -0.17158517f, 0.22802153f, 0.09194447f, 0.06599522f, 0.06357718f, 0.01458238f, -0.10011653f, -0.07454740f, 
    -0.08534682f, 0.07464986f, -0.07483827f, 0.10747405f, -0.00488537f, -0.02287124f, -0.01541684f, -0.16681406f, 
    0.13891217f, -0.02486093f, -0.62361008f, 0.20397942f, -0.38369408f, 0.06371828f, -0.00117839f, 0.04683275f, 
    -0.02358485f, 0.03304468f, -0.03906735f, 0.33263502f, -0.26406020f, -0.33359700f, 0.04479972f, 0.06219444f, 
    -0.02243620f, -0.07035099f, 0.02513785f, -0.05312800f, -0.14055896f, -0.28658053f, 0.07348959f, 0.04430027f, 
    0.15368937f, -0.06049863f, 0.09938297f, -0.14930159f, 0.07374797f, -0.09446585f, -0.53764540f, 0.00031066f, 
    -0.00027232f, 0.00538258f, 0.03559784f, -0.11321889f, 0.14312370f, 0.01681075f, -0.22586110f, -0.11772441f, 
    0.08554244f, -0.01085981f, 0.17635311f, -0.06445663f, 0.22786377f, 0.07321299f, 0.13858658f, 0.09860060f, 
    -0.19915953f, 0.07002975f, -0.13086833f, -0.16667454f, -0.03968241f, 0.10145123f, -0.03329603f, 0.09638360f, 
    -0.07229530f, 0.14664766f, -0.05802110f, 0.05868052f, -0.07980035f, -0.01085266f, 0.03114766f, 0.09589151f, 
    0.13875574f, -0.73321879f, -0.05913006f, -0.16204958f, -0.06564362f, -0.06539150f, -0.01242567f, -0.10975229f, 
    -0.11899076f, -0.00160393f, -0.20249809f, 0.18363866f, 0.12402163f, -0.02818447f, 0.21516304f, 0.03246673f, 
    -0.03253692f, 0.06218319f, -0.06292035f, 0.25792900f, -0.21437421f, -0.16468242f, 0.11748169f, -0.07327897f, 
    0.07355677f, -0.02472219f, -0.02909567f, 0.12042060f, 0.01924528f, -0.13839267f, 0.09496932f, -0.15230104f, 
    0.16820118f, -0.09386549f, -0.04062033f, 0.11354140f, -0.09604842f, 0.14340913f, -0.09177662f, -0.09137582f, 
    -0.04044866f, 0.10911577f, -0.18265063f, -0.11826010f, 0.08564688f, 0.00606203f, -0.21750870f, 0.53657675f, 
    -0.21802089f, -0.02927357f, 0.05393391f, 0.07994700f, -0.08245459f, 0.10278087f, 0.04417956f, 0.26304719f, 
    -0.12787880f, -0.03644522f, 0.05162503f, -0.03978824f, 0.00196042f, -0.01014986f, -0.12319612f, -0.02883059f, 
    0.55753726f, -0.27794057f, 0.17361677f, -0.01228545f, 0.01677713f, -0.10824993f, -0.01016822f, 0.15319653f, 
    0.06458621f, 0.23434322f, 0.10801850f, 0.08820843f, 0.05647234f, 0.13891965f, -0.01369668f, 0.17777967f, 
    -0.06834444f, -0.14706162f, 0.05123024f, -0.01605930f, -0.08581432f, 0.27808043f, 0.21402387f, 0.16761205f, 
    0.04129276f, -0.00168842f, 0.13233265f, -0.08037687f, -0.27341503f, 0.33203125f, -0.29184017f, -0.18498378f, 
    -0.03443373f, 0.02599414f, -0.11107454f, 0.02257387f, 0.54105198f, 0.15957616f, -0.55458564f, 0.08125576f, 
    -0.08110446f, 0.08934624f, -0.04082151f, -0.07853094f, 0.01736612f, 0.00787404f, -0.09828279f, -0.25143009f, 
    -0.00420226f, 0.04371742f, -0.01008499f, 0.10672472f, 0.25453869f, 0.23635828f, 0.01924928f, -0.05580232f, 
    -0.10559738f, -0.01308793f, -0.06090834f, -0.11420520f, -0.00253597f, -0.12379207f, -0.02013756f, -0.40868106f, 
    -0.32570511f, 0.01521974f, 0.08042151f, 0.04690060f, -0.01848083f, -0.01457500f, 0.02189681f, -0.08705590f, 
    -0.00071981f, 0.19967040f, -0.02634942f, 0.14575581f, 0.13971481f, 0.16184554f, -0.05026073f, -0.02818916f, 
    0.18822137f, 0.40901369f, -0.17322282f, -0.05980606f, -0.19247916f, -0.09442794f, 0.00621416f, -0.00330797f, 
    -0.22601862f, -0.06235559f, -0.25046322f, -0.08304060f, -0.32247534f, 0.09662008f, 0.12046834f, 0.11594103f, 
    0.07666215f, -0.09361762f, -0.03683427f, 0.07941795f, 0.32970423f, 0.16233179f, 0.00667457f, 0.06877571f, 
    0.16762070f, 0.06434820f, -0.00456059f, 0.04728436f, -0.08890657f, -0.04686096f, -0.10553855f, 0.01429142f, 
    -0.02825482f, 0.03602704f, 0.01653807f, -0.06693721f, -0.16635297f, -0.28010961f, -0.08550278f, -0.17919253f, 
    -0.00762493f, -0.07298467f, 0.02636124f, -0.09447822f, -0.03170300f, -0.08228815f, -0.48771510f, -0.03119762f, 
    0.16398306f, 0.26737517f, 0.14467016f, -0.03481066f, 0.00790584f, -0.03788178f, 0.06291400f, 0.12123340f, 
    -0.59669757f, -0.17624472f, 0.02865802f, 0.07007021f, -0.09530574f, 0.05524406f, -0.06704427f, 0.06042009f, 
    0.03065342f, -0.13009340f, 0.23862182f, 0.04116843f, -0.11680931f, 0.08278665f, -0.01223723f, 0.01426358f, 
    -0.11487265f, -0.23662987f, 0.16778547f, 0.21381570f, 0.11633066f, 0.17495260f, -0.04506013f, 0.12522401f, 
    0.06612695f, -0.04058985f, -0.21799034f, -0.01395892f, -0.05804130f, -0.19193593f, 0.05987314f, 0.04031445f, 
    0.07808160f, 0.01709087f, -0.06041165f, -0.11555968f, 0.07473568f, -0.06269220f, 0.00849873f, 0.11242943f, 
    -0.10236087f, -0.05809358f, -0.00173260f, 0.01457089f, -0.16759865f, 0.21181385f, -0.15455329f, 0.03616062f, 
    -0.06223155f, 0.04769981f, 0.04023247f, 0.10867330f, 0.00693129f, -0.10198507f, -0.09347346f, -0.24107611f, 
    -0.01526814f, 0.12350921f, -0.15729205f, 0.09315299f, 0.09927428f, 0.18181562f, 0.13054197f, 0.00518170f, 
    0.30181560f, -0.10532358f, 0.06059192f, -0.05837887f, 0.13085796f, 0.20660672f, 0.17771646f, -0.15613405f, 
    -0.14412722f, -0.13777636f, 0.14107201f, -0.09282890f, 0.03681611f, 0.02181942f, 0.06804636f, 0.03002904f, 
    -0.16008316f, 0.02169899f, -0.13233590f, 0.07880006f, 0.25028124f, 0.18275309f, 0.06367933f, 0.00496098f, 
    -0.27641538f, -0.17851254f, -0.01960028f, -0.01773278f, 0.02061222f, -0.18296927f, 0.12214005f, 0.07025083f, 
    -0.09083276f, -0.28579828f, 0.15311904f, 0.05560312f, 0.12174697f, 0.07671223f, 0.05362672f, 0.14136164f, 
    0.07791660f, -0.04236713f, 0.21779406f, 0.02530060f, 0.19760166f, 0.05529976f, 0.03093322f, 0.10522068f, 
    -0.07077731f, -0.06697695f, 0.05820538f, 0.03627409f, -0.34483969f, 0.24265532f, 0.07696801f, 0.07806172f, 
    -0.02513815f, -0.08473001f, 0.06360866f, -0.12877916f, -0.07006831f, 0.05041016f, 0.11866397f, 0.14261313f, 
    -0.13130598f, 0.02894649f, 0.12969649f, -0.04537991f, 0.06512549f, 0.03669669f, 0.24030048f, -0.31856412f, 
    -0.20791642f, -0.11381029f, 0.16524488f, -0.29206532f, 0.07947010f, -0.04113283f, 0.02800471f, 0.16502459f, 
    0.05530651f, 0.07567061f, -0.09266944f, 0.09083802f, -0.10874845f, 0.09890861f, 0.11191435f, 0.06909645f, 
    -0.55825353f, -0.31128618f, -0.28697056f, -0.02457442f, -0.10188682f, -0.08253632f, -0.07997311f, -0.05945117f, 
    -0.10258958f, -0.34177643f, -0.17745428f, -0.24924611f, 0.13624705f, 0.09013066f, 0.22332875f, -0.07621729f, 
    0.07454176f, -0.06182918f, -0.10415149f, -0.08758080f, -0.05327553f, -0.04576120f, 0.03186722f, -0.02375651f, 
    0.21709354f, -0.03038163f, -0.18148787f, 0.24793726f, 0.19481860f, 0.12354148f, -0.29425901f, -0.19907919f, 
    -0.04259558f, 0.02040796f, 0.00957286f, 0.18504420f, 0.02339818f, -0.09921855f, -0.09004261f, 0.02130868f, 
    0.08164656f, -0.10366011f, 0.01655109f, 0.05645451f, 0.08295014f, -0.19609658f, 0.02575907f, 0.14812234f, 
    -0.00156756f, -0.12227347f, 0.07777108f, -0.25579181f, -0.08935039f, -0.03127222f, -0.11937179f, -0.27797431f, 
    0.09738257f, 0.07984485f, -0.03357998f, -0.00237818f, 0.05873818f, -0.03246193f, 0.03724053f, 0.05789176f, 
    0.18616407f, 0.11439781f, 0.17258792f, -0.09783512f, 0.07384163f, 0.04009377f, 0.13284042f, -0.10826558f, 
    -0.05645800f, -0.03669696f, -0.04796677f, -0.04136381f, -0.08103420f, 0.03222974f, 0.04296753f, -0.01627548f, 
    -0.05144190f, 0.00892260f, 0.06155521f, -0.05496210f, 0.05442967f, -0.08096808f, 0.00965680f, -0.03972724f, 
    -0.07618337f, -0.02187289f, -0.03384264f, -0.07566379f, -0.06078258f, 0.07527494f, 0.00611878f, -0.08399406f, 
    0.06409644f, -0.00469117f, -0.01298370f, -0.02943114f, -0.01387901f, -0.12798545f, 0.04733313f, -0.03977428f, 
    0.07209932f, -0.05985386f, -0.04237309f, -0.02493086f, -0.00136224f, -0.00755668f, -0.09831620f, -0.02896615f, 
    -0.04197244f, 0.05991349f, -0.03136663f, 0.07267909f, -0.07601780f, -0.03870514f, -0.09243711f, 0.01759069f, 
    -0.01263909f, -0.07635809f, -0.02626644f, 0.00068793f, 0.00836203f, -0.00147152f, 0.02238559f, 0.02098520f, 
    0.05888399f, -0.03510735f, 0.02294197f, 0.03466756f, -0.05167654f, 0.05016439f, -0.09801556f, -0.05403024f, 
    -0.02091052f, 0.08515542f, 0.02720294f, -0.07799486f, 0.06714232f, 0.05989518f, -0.01098697f, -0.06687044f, 
    0.00325567f, -0.00626276f, -0.08031355f, -0.09453373f, -0.06339496f, -0.10102826f, 0.00511449f, -0.00528252f, 
    -0.06000211f, 0.03024841f, -0.02692276f, -0.09154662f, 0.06958970f, 0.05598985f, -0.01838958f, -0.01600261f, 
    -0.01827507f, -0.06753857f, 0.07353364f, 0.08283021f, 0.03784750f, 0.02777844f, 0.04520005f, -0.09660625f, 
    -0.02241168f, -0.02326555f, -0.00275948f, -0.04707979f, -0.06731336f, -0.01040096f, 0.05805203f, 0.01121081f, 
    0.03062377f, 0.03739854f, 0.05645104f, 0.07563432f, -0.07701590f, -0.08141400f, 0.01569616f, -0.00629181f, 
    -0.07268807f, -0.01789536f, -0.02533101f, 0.04600625f, 0.03929573f, -0.09066626f, 0.01458712f, -0.03078231f, 
    -0.04050470f, 0.02663039f, 0.04611864f, 0.03798784f, 0.02501858f, -0.06042665f, -0.04504256f, 0.04298488f, 
    0.00231447f, 0.02130399f, -0.02346476f, -0.04756024f, 0.01816810f, -0.11507316f, -0.04280953f, -0.00648687f, 
    -0.03558335f, 0.00667645f, 0.02127511f, 0.06840775f, -0.07724968f, 0.00329527f, -0.02923066f, 0.01434201f, 
    -0.04122123f, -0.03863603f, 0.04499686f, 0.02480623f, 0.05919638f, -0.02401971f, -0.09611382f, -0.01614499f, 
    0.05574835f, -0.02331225f, -0.05495115f, -0.05775357f, 0.01101420f, -0.06103407f, 0.06845586f, 0.04701733f, 
    0.04174645f, -0.08700572f, 0.05223496f, -0.05574600f, 0.00552791f, -0.10920831f, 0.02283047f, 0.05906651f, 
    -0.03972048f, -0.03173243f, 0.04026315f, 0.05077238f, 0.01160113f, -0.06511931f, 0.04596350f, 0.03785549f, 
    0.00340239f, -0.09223127f, -0.07724524f, 0.01272105f, 0.07232879f, -0.04284242f, -0.00521444f, 0.02431964f, 
    0.05698826f, 0.00056159f, 0.02484815f, -0.06728012f, -0.00679796f, 0.05190463f, -0.01017862f, -0.01967739f, 
    -0.00287863f, -0.00977437f, 0.01349980f, -0.09180696f, 0.02273650f, 0.04824526f, -0.06818707f, -0.01836852f, 
    0.05193574f, 0.04709413f, -0.07547759f, -0.06450175f, -0.09020290f, -0.07590689f, 0.05442419f, -0.08444341f, 
    -0.11074369f, 0.01622945f, -0.05945562f, 0.03264208f, -0.01441740f, -0.08890719f, -0.11246589f, -0.04386666f, 
    0.04938391f, -0.05830849f, -0.06003996f, -0.05241788f, -0.00903897f, 0.05041570f, 0.04342749f, 0.08535062f, 
    0.04125205f, -0.06072908f, -0.00063007f, 0.01188082f, 0.02696959f, -0.06604259f, 0.00421930f, 0.03456273f, 
    0.07118937f, 0.06509502f, -0.04075455f, -0.07101915f, 0.00618448f, 0.00117305f, -0.08809835f, -0.05909545f, 
    -0.01594621f, 0.02705953f, -0.09559642f, 0.02916307f, -0.04649568f, -0.07397815f, 0.03593335f, -0.10381708f, 
    -0.03675126f, 0.03652899f, 0.02215489f, -0.03247035f, 0.00190802f, -0.07701324f, -0.01607986f, 0.01800411f, 
    -0.08369675f, -0.05575223f, 0.05887977f, 0.02327819f, -0.07257968f, -0.00522996f, 0.04228856f, -0.02459840f, 
    -0.09673620f, -0.06094475f, -0.04828682f, 0.02621569f, 0.05419137f, -0.04180005f, 0.00591412f, -0.01502407f, 
    -0.07984471f, -0.09647173f, -0.02883725f, -0.04390721f, 0.03699133f, -0.03072333f, 0.01109937f, -0.07764363f, 
    -0.05908600f, -0.01484910f, 0.01132323f, -0.07653774f, 0.02232488f, -0.03053358f, -0.03110951f, 0.06175383f, 
    0.05803110f, 0.06788196f, 0.00875540f, -0.02712292f, 0.04025809f, -0.09005594f, -0.06505544f, 0.01873652f, 
    -0.05454754f, 0.07814940f, 0.07463112f, -0.02758936f, -0.06082363f, -0.08058045f, -0.01017409f, -0.05029426f, 
    -0.01214755f, 0.07151181f, 0.01887290f, -0.08142981f, 0.02437613f, 0.00447678f, -0.08437231f, -0.05583843f, 
    0.01857464f, 0.02671682f, -0.01645691f, -0.03762580f, -0.08987723f, -0.07649665f, -0.02875492f, -0.04234715f, 
    -0.05577208f, 0.07112614f, 0.02256812f, -0.01497322f, -0.08731969f, -0.02595157f, -0.03061814f, -0.08543511f, 
    -0.07941010f, -0.00208859f, -0.08091644f, 0.07224419f, -0.00086022f, -0.03742994f, -0.03253197f, -0.04818409f, 
    0.03057986f, 0.07095782f, -0.06958389f, -0.00953962f, -0.05045916f, -0.03035798f, 0.02935031f, 0.03669199f, 
    0.03105927f, 0.03622553f, 0.02877592f, -0.00257629f, -0.02634909f, -0.07239141f, -0.03749593f, -0.00841682f, 
    0.06957915f, 0.03400571f, 0.01459387f, 0.03976711f, -0.00910375f, 0.04644709f, -0.03652580f, -0.03943221f, 
    -0.02552046f, -0.00210817f, 0.04134724f, -0.03554432f, -0.04517022f, 0.04576926f, -0.06721471f, 0.00922578f, 
    -0.01408404f, 0.03091752f, 0.01112052f, -0.08490913f, 0.03416568f, -0.03178259f, -0.07511714f, -0.03248490f, 
    -0.06223439f, 0.03886186f, -0.04771028f, -0.06933941f, 0.01198451f, -0.02007804f, 0.05958089f, 0.03423774f, 
    -0.01553628f, -0.06181132f, -0.07970767f, 0.03803910f, 0.03990206f, -0.07779580f, 0.06703644f, -0.08450622f, 
    -0.06341800f, -0.04957754f, -0.02703641f, 0.01051386f, -0.06627386f, 0.05571830f, -0.07739528f, -0.00135120f, 
    0.05922119f, -0.01749853f, -0.04528707f, -0.00469310f, -0.08600751f, -0.08836483f, -0.03940307f, 0.00423974f, 
    -0.07371999f, 0.04222346f, 0.02081721f, 0.07108442f, -0.05348254f, 0.00090943f, 0.06322251f, -0.00956262f, 
    0.01364963f, -0.05346825f, 0.07384115f, -0.06775457f, 0.05403237f, 0.05937871f, -0.06934904f, 0.06141609f, 
    0.01862650f, 0.03185831f, 0.02416486f, 0.01312625f, -0.07279775f, 0.06007237f, -0.00497705f, -0.04039733f, 
    0.01739111f, 0.06403732f, -0.04735136f, -0.04212149f, 0.06305791f, 0.04317505f, -0.04722658f, -0.02739599f, 
    0.06294334f, -0.02975867f, -0.02839716f, -0.03918812f, -0.01060305f, -0.05721385f, 0.07165147f, 0.05182210f, 
    0.02298178f, -0.00118991f, -0.08541347f, -0.04713075f, -0.01878518f, -0.02069001f, -0.08973601f, 0.06157832f, 
    -0.03133222f, 0.03469630f, -0.02984688f, -0.08006746f, -0.06889418f, 0.03035252f, -0.05445489f, -0.01297345f, 
    -0.05446449f, 0.01750293f, -0.09326806f, -0.07871067f, 0.04724779f, -0.04075987f, -0.02934815f, 0.03892374f, 
    -0.07044905f, 0.01313032f, 0.06942865f, 0.01407202f, 0.04425206f, -0.09061893f, -0.00743531f, 0.07137045f, 
    -0.05821338f, -0.02536385f, -0.07710841f, 0.00114007f, -0.04266592f, -0.03144896f, 0.04031183f, -0.06620004f, 
    0.04292430f, -0.02235898f, 0.00726391f, -0.00257472f, -0.09151649f, -0.02458648f, -0.04753165f, -0.03252805f, 
    -0.07190967f, 0.08675607f, -0.05907788f, -0.00726728f, -0.04219628f, 0.06465633f, 0.01561802f, 0.06457645f, 
    0.05352106f, -0.08530973f, -0.03321264f, -0.05958816f, -0.02556112f, 0.05128985f, -0.08537424f, -0.05980172f, 
    0.04371739f, 0.06691017f, -0.06295937f, -0.06475539f, -0.06862881f, 0.00697178f, 0.00460049f, 0.06117588f, 
    0.05488957f, -0.00935454f, -0.01298374f, 0.07769968f, -0.08493832f, -0.00485933f, -0.07695828f, -0.05407148f, 
    -0.07271177f, 0.04096756f, -0.06553695f, -0.03936497f, 0.01940551f, 0.02821181f, 0.03176840f, 0.04088043f, 
    0.01129013f, -0.00078518f, -0.01841944f, -0.03765207f, -0.07869297f, 0.07375769f, -0.04145389f, -0.03659526f, 
    -0.07540976f, 0.07497851f, -0.02565600f, 0.01242662f, 0.05961347f, -0.03908457f, 0.04418059f, 0.01719016f, 
    0.05000989f, 0.06418509f, -0.08454292f, 0.03299141f, 0.01479233f, -0.06432320f, -0.05437016f, -0.05363975f, 
    -0.07747144f, -0.06122860f, -0.07267065f, -0.01708849f, -0.04433120f, 0.04163183f, -0.04459350f, -0.03334131f, 
    0.01272743f, -0.06392121f, -0.01384168f, 0.03144003f, -0.03782527f, -0.02539081f, 0.00550713f, -0.06699692f, 
    -0.20891298f, -0.29020858f, 0.13739066f, -0.17256469f, 0.06512687f, -0.11168742f, 0.08786806f, 0.20044832f, 
    0.32853928f, -0.05212982f, -0.27229905f, -0.23824678f, 0.15492609f, -0.18400273f, -0.12680587f, 0.01108183f, 
    0.07887246f, 0.06781069f, 0.37503645f, 0.35961148f, 0.06146070f, 0.05580696f, 0.10402112f, -0.05924223f, 
    -0.06936079f, 0.14218366f, 0.06999115f, -0.03072340f, -0.27323663f, 0.12057547f, 0.02652320f, 0.01779074f, 
    0.13741873f, -0.01428483f, -0.11318971f, 0.06893677f, -0.29653010f, 0.15523149f, -0.13064992f, 0.08770031f, 
    -0.07271750f, -0.15885042f, 0.08930828f, 0.15570085f, -0.03137887f, 0.21453185f, 0.05850878f, -0.05242044f, 
    0.19751197f, 0.20340282f, 0.00970014f, -0.00935003f, 0.17643937f, -0.02134806f, -0.10693155f, 0.19938581f, 
    0.29393131f, 0.04102944f, -0.15031196f, -0.01792225f, -0.08661682f, 0.00656659f, 0.15624003f, 0.23297386f, 
    0.14385639f, -0.06093783f, 0.11271513f, 0.02583007f, -0.02367674f, -0.18071046f, -0.12631378f, -0.06729822f, 
    -0.46622404f, -0.11968726f, -0.11471664f, 0.05646863f, -0.11502719f, 0.26663253f, 0.01322091f, 0.06453167f, 
    -0.04835203f, -0.21559840f, 0.07711244f, 0.15095054f, 0.05604798f, -0.12112100f, 0.21519652f, -0.09932760f, 
    -0.10889218f, -0.22731087f, -0.14028619f, -0.49200127f, 0.04304392f, 0.03560021f, 0.04843807f, -0.10713273f, 
    -0.06450173f, -0.03882438f, 0.03368722f, 0.26655990f, -0.01458532f, 0.02446329f, 0.02464222f, 0.06139871f, 
    -0.04649312f, -0.08325960f, -0.04417449f, -0.05027962f, 0.14560574f, 0.18951939f, -0.11166584f, -0.23226802f, 
    -0.22533210f, 0.10717237f, -0.19707289f, 0.05277076f, -0.05719592f, -0.20681451f, 0.17853107f, 0.01573801f, 
    0.16357520f, 0.08094063f, 0.09134746f, 0.02455461f, 0.13858995f, 0.00136653f, -0.13241692f, -0.46646217f, 
    0.05366191f, 0.12084164f, -0.09367777f, 0.04518692f, 0.02476396f, 0.02502215f, 0.12429636f, 0.27634969f, 
    -0.15143560f, -0.06885480f, -0.19770898f, -0.06546285f, 0.15900987f, 0.16829491f, -0.05677855f, 0.03329651f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01975835f, 0.02025034f, -0.09009402f, -0.08751623f, -0.15850753f, -0.12614332f, 0.13523634f, -0.01606190f, 
    -0.03489721f, 0.32959655f, 0.18545166f, -0.05897639f, -0.09138844f, -0.03304675f, 0.00403186f, -0.01766520f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25615180f, -0.14571285f, 0.14002253f, 0.19140713f, 0.08675260f, -0.35302413f, -0.03559339f, -0.09761374f, 
    -0.22100647f, -0.21351199f, -0.03691002f, -0.15582493f, 0.20896670f, 0.17112032f, 0.12082155f, 0.66169864f, 
    0.27183267f, -0.07741546f, -0.07682630f, 0.15901691f, -0.19304703f, -0.37150034f, 0.33745289f, 0.02091995f, 
    0.30842963f, -0.07295106f, -0.24011077f, 0.15829426f, -0.02039807f, -0.15747240f, 0.22353061f, 0.42087752f, 
    0.38550127f, 0.18349448f, -0.02685311f, 0.23692894f, -0.35763791f, -0.38502681f, 0.11280822f, -0.26656967f, 
    0.21972011f, 0.10133746f, 0.14105175f, -0.02560080f, -0.17343107f, -0.22008371f, -0.12507106f, 0.08866525f, 
    0.23719735f, -0.06681458f, 0.07081845f, 0.03772022f, 0.17620429f, 0.00468014f, -0.10632118f, -0.14196856f, 
    -0.13792184f, 0.17711797f, -0.30754831f, 0.07967594f, -0.22355363f, 0.21001497f, 0.02742251f, 0.19540255f, 
    0.07141338f, 0.24179719f, 0.13077091f, 0.21839121f, -0.08367635f, -0.33993870f, -0.21888147f, 0.27925763f, 
    -0.20164470f, 0.08569676f, 0.30390400f, -0.27558032f, 0.24968792f, 0.10860105f, 0.10287913f, 0.10669143f, 
    -0.11638411f, 0.08127547f, -0.13940182f, 0.13377061f, 0.24900009f, 0.00026021f, 0.46808702f, 0.11612972f, 
    0.47463086f, -0.25084269f, -0.14462617f, 0.19495092f, 0.21864423f, 0.01115628f, 0.11602515f, -0.06841230f, 
    -0.50224549f, -0.15262349f, -0.00454778f, 0.04207567f, 0.27200782f, 0.25074092f, -0.06391203f, 0.27271602f, 
    -0.53283083f, 0.14315617f, -0.53131866f, 0.23089185f, 0.18280128f, 0.17576396f, -0.03725287f, 0.19052671f, 
    -0.03979873f, 0.13033798f, -0.21933518f, -0.14219356f, 0.16487207f, 0.48800442f, 0.12924275f, -0.05650153f, 
    0.04997513f, -0.31507730f, 0.32849100f, 0.17604524f, 0.18775213f, -0.23948559f, -0.09380530f, -0.18255703f, 
    0.27932164f, 0.18442960f, 0.13394229f, -0.07386844f, 0.09118959f, -0.09077080f, -0.06518024f, -0.28704652f, 
    0.49677458f, -0.38544232f, 0.08089335f, -0.25126815f, 0.03723636f, -0.17830026f, 0.24955638f, 0.42830753f, 
    0.28551978f, -0.12404989f, -0.04673786f, 0.22902572f, 0.41444969f, 0.34427893f, -0.17559639f, 0.30685505f, 
    0.02713721f, -0.05046476f, -0.20115986f, 0.21921709f, -0.10835146f, -0.04999671f, -0.22350024f, -0.08216397f, 
    0.64739496f, -0.07419049f, -0.16284335f, 0.07567906f, -0.74074900f, -0.31492031f, 0.03211962f, 0.29039553f, 
    0.34246120f, 0.03537533f, -0.22130090f, 0.17709668f, -0.12201985f, 0.04694057f, 0.11356682f, 0.22299196f, 
    0.06098861f, 0.02613408f, -0.03817178f, -0.13016894f, 0.79332525f, -0.06096911f, 0.09042276f, -0.44722831f, 
    -0.36763585f, -0.07011010f, -0.04655842f, 0.01555982f, 0.05980943f, 0.04363369f, 0.09380291f, 0.28380030f, 
    -0.47736478f, 0.22520953f, 0.17608345f, 0.09851632f, -0.17609034f, 0.28191480f, 0.38992253f, 0.09485005f, 
    0.48374057f, 0.25845245f, -0.11896053f, -0.20659293f, 0.07063452f, 0.17525733f, -0.21023585f, -0.58127534f, 
    0.29631633f, -0.09876642f, 0.10589159f, -0.17139721f, -0.15282707f, 0.07428399f, -0.02345762f, -0.38324815f, 
    0.44113246f, -0.45525488f, 0.09777769f, 0.13438347f, -0.25301802f, 0.11876552f, 0.12127905f, 0.25643390f, 
    0.34772974f, 0.05560633f, 0.02832223f, -0.18027045f, -0.18136123f, -0.41886345f, 0.29508376f, -0.12814096f, 
    0.38792926f, -0.00030083f, -0.23577304f, 0.06101459f, -0.24802367f, 0.11423244f, 0.06509402f, 0.11910679f, 
    0.45653495f, -0.03769355f, 0.23122232f, -0.23110220f, 0.21750017f, -0.35414979f, 0.41312563f, 0.03411428f, 
    -0.03001468f, -0.18632844f, -0.03867708f, -0.17161739f, 0.21975866f, 0.14516442f, 0.19979170f, 0.11690025f, 
    0.23994681f, -0.08212876f, 0.19066648f, -0.13982245f, -0.40709576f, -0.20147659f, 0.33011329f, 0.03110831f, 
    0.24701639f, -0.26277182f, 0.31499323f, -0.21075742f, 0.05830066f, -0.05706650f, -0.05509793f, -0.01329031f, 
    0.17977947f, -0.08531543f, -0.14723802f, -0.18401183f, -0.26095411f, -0.08782076f, -0.11472000f, -0.35031664f, 
    0.08682210f, 0.40361935f, 0.35778034f, 0.22878565f, -0.16851814f, -0.02769697f, -0.14527056f, -0.28314653f, 
    -0.18223205f, -0.08446022f, -0.09949853f, -0.18536918f, -0.40914568f, 0.06119902f, -0.00920316f, 0.10706159f, 
    0.56904364f, -0.18464829f, -0.16135299f, 0.24167904f, 0.23815767f, 0.16481461f, -0.14624321f, 0.40347752f, 
    0.07993255f, 0.05949017f, 0.22324085f, -0.16650897f, 0.18175825f, -0.09911995f, -0.14772309f, 0.28882816f, 
    -0.00515223f, -0.15041776f, -0.03966135f, 0.18793979f, -0.15351528f, -0.12441197f, -0.05911937f, -0.14271878f, 
    0.25368914f, 0.22264242f, -0.04339606f, 0.17475063f, -0.38293201f, 0.02525183f, -0.31375057f, 0.37946796f, 
    -0.34249276f, 0.04171007f, 0.12982935f, 0.20127954f, -0.06969124f, 0.11235452f, -0.12763011f, 0.39244506f, 
    -0.32593185f, 0.05708273f, -0.07283162f, 0.20955592f, -0.05295883f, -0.05287209f, 0.30038020f, -0.12620410f, 
    0.04371571f, 0.25160870f, 0.06439841f, -0.08015401f, -0.16907509f, 0.05962085f, 0.17642048f, 0.35452968f, 
    0.09522125f, 0.13262488f, 0.08825963f, 0.03061563f, 0.29238769f, -0.37096345f, 0.41282135f, -0.22630215f, 
    0.20210198f, 0.42055064f, -0.28588146f, -0.16443202f, -0.14209352f, 0.09766321f, 0.04617830f, 0.09013901f, 
    -0.40213162f, 0.18832019f, 0.05507093f, -0.24579830f, 0.50847876f, 0.19345734f, 0.09242611f, -0.12048019f, 
    -0.00990706f, 0.47723648f, 0.23244794f, 0.14993522f, -0.01049701f, 0.08163866f, 0.12711781f, -0.03495548f, 
    0.52956545f, 0.08204555f, 0.02595699f, 0.18340591f, -0.17390485f, 0.58025759f, -0.04116193f, 0.13426593f, 
    -0.33446085f, -0.35347924f, 0.08075406f, -0.08711865f, -0.10098868f, -0.08982176f, 0.04374539f, -0.71452713f, 
    0.15118425f, 0.09754518f, -0.21780489f, -0.19334097f, -0.20355472f, 0.19109152f, 0.06941864f, -0.32960680f, 
    -0.26081258f, 0.07005604f, 0.18802236f, 0.11310676f, -0.13169500f, 0.03887336f, 0.16317691f, 0.03100223f, 
    -0.13705251f, -0.10362484f, 0.16097961f, -0.23046930f, 0.39959332f, 0.29412386f, -0.13043630f, -0.12141373f, 
    0.25179577f, 0.50707924f, 0.03860047f, -0.14961241f, -0.16185908f, -0.11129788f, -0.02275833f, -0.26879966f, 
    0.01640715f, -0.26055640f, -0.24119294f, -0.17313570f, 0.24305479f, -0.21685921f, -0.62335074f, -0.13128842f, 
    -0.04577531f, 0.08873748f, 0.27140158f, 0.16789259f, -0.23144731f, 0.22127540f, 0.23753303f, 0.25209489f, 
    0.22383232f, -0.12283397f, 0.06230629f, 0.08276177f, -0.69693559f, 0.18411319f, 0.03716955f, 0.05412563f, 
    0.24584715f, -0.15756927f, 0.11926020f, 0.17247131f, -0.08030516f, 0.09124540f, -0.20589139f, 0.26453799f, 
    0.18147154f, 0.15199827f, 0.06776677f, 0.22696142f, -0.33955127f, -0.28477290f, -0.32501870f, 0.15374504f, 
    0.47267503f, 0.32922578f, 0.09467666f, 0.25171712f, 0.00813951f, -0.05303511f, 0.10906395f, -0.13131879f, 
    0.07753919f, -0.19181322f, -0.20941240f, 0.06639303f, 0.76751089f, 0.05419485f, -0.12601583f, 0.38245833f, 
    -0.28066915f, 0.23920415f, -0.04734768f, -0.20354719f, 0.14114732f, -0.07369596f, -0.03892419f, -0.29576838f, 
    0.30327725f, 0.10389399f, 0.19705789f, -0.07934567f, -0.14234495f, -0.28001305f, 0.10804795f, -0.32086328f, 
    0.06198609f, 0.31930828f, -0.03367093f, 0.22827880f, -0.02455629f, 0.22592308f, 0.09432142f, 0.27229047f, 
    -0.20258039f, 0.03430107f, 0.18939197f, 0.24677655f, -0.04631874f, -0.19147924f, -0.22654366f, 0.16292617f, 
    -0.18090710f, -0.13559756f, 0.07957828f, 0.14813268f, -0.01228210f, -0.09168416f, 0.12051085f, -0.04073516f, 
    -0.05501624f, -0.19366744f, 0.01259107f, -0.09916934f, 0.71636856f, -0.28384590f, 0.19849905f, 0.03957331f, 
    -0.05352379f, 0.32753351f, 0.11908827f, 0.11879661f, -0.07895990f, 0.19008070f, 0.20989642f, -0.36572647f, 
    -0.18140441f, -0.03717570f, 0.01139998f, -0.24058950f, -0.00849475f, -0.04183184f, 0.16489907f, -0.19555451f, 
    -0.09574099f, 0.48597547f, -0.06641216f, -0.05217005f, 0.01027934f, 0.20121640f, -0.04182737f, 0.18826033f, 
    0.32830077f, -0.03288195f, 0.02081008f, -0.23670363f, 0.32257661f, 0.39516592f, 0.17209850f, 0.22316179f, 
    -0.01139914f, -0.27147129f, -0.28351122f, 0.02592142f, -0.06587946f, 0.21484530f, 0.04410885f, -0.24411276f, 
    0.36309031f, -0.14886215f, 0.13644317f, -0.10657597f, -0.23495768f, -0.26041210f, 0.59817165f, -0.35640451f, 
    -0.17964530f, 0.32797533f, -0.15484983f, -0.16065468f, -0.10300499f, -0.00475404f, 0.12403893f, -0.16023426f, 
    -0.02097402f, 0.02770264f, -0.14568846f, -0.08209078f, 0.32253021f, 0.15189335f, -0.01119813f, -0.45245251f, 
    -0.14498891f, -0.04609035f, 0.35162467f, -0.12491836f, 0.11775963f, 0.11206655f, -0.01524174f, -0.20450835f, 
    -0.06319803f, 0.21322244f, 0.12801388f, 0.24358191f, 0.16771141f, -0.06750931f, -0.09043888f, 0.00166145f, 
    -0.05216177f, -0.62431145f, 0.50154078f, 0.17525372f, -0.10862289f, 0.00875245f, -0.09705805f, 0.19280282f, 
    0.43572620f, 0.06585493f, 0.02380943f, 0.20075202f, 0.09274022f, 0.33625412f, -0.24600439f, 0.11382605f, 
    -0.10027535f, -0.16773309f, 0.23340653f, -0.19184652f, 0.15461314f, 0.22700079f, 0.12722965f, -0.16511953f, 
    -0.06398676f, -0.17854428f, 0.21088576f, -0.07201532f, 0.15588418f, -0.06994592f, 0.38817614f, 0.20578468f, 
    -0.40018398f, -0.11709684f, -0.32014042f, 0.01300064f, 0.22671446f, -0.23792237f, 0.03926583f, -0.18859752f, 
    -0.32332337f, 0.08747307f, 0.13300924f, -0.00868350f, 0.28961304f, 0.27088764f, -0.28937167f, -0.29345080f, 
    0.02072898f, 0.38086769f, 0.38960990f, 0.14613934f, 0.12447245f, -0.07667869f, 0.24365887f, 0.04266210f, 
    0.09052016f, -0.18442857f, 0.23828657f, -0.13267431f, -0.44308427f, 0.28060278f, -0.24059162f, -0.19533046f, 
    0.45337853f, 0.14464831f, -0.03349697f, -0.20546001f, -0.05872657f, -0.21702057f, -0.02602406f, 0.20918553f, 
    0.11349094f, 0.23749414f, -0.04447734f, 0.10594714f, -0.30930796f, 0.43376637f, -0.52710092f, -0.14713305f, 
    -0.31338653f, 0.13965032f, 0.19001921f, -0.11281826f, -0.17951438f, 0.16919629f, -0.21540336f, 0.51169223f, 
    0.31238261f, 0.21371938f, 0.16018134f, 0.10634535f, -0.54394770f, 0.22814883f, 0.14868277f, 0.52218103f, 
    -0.16152884f, -0.08141260f, -0.12263212f, -0.18440975f, 0.11297264f, 0.10496832f, 0.02202635f, -0.05170905f, 
    -0.24815881f, 0.01824725f, 0.10701460f, -0.21287124f, 0.31157860f, -0.19351046f, -0.06165741f, 0.04214060f, 
    -0.07955668f, 0.22038199f, 0.22996557f, -0.12220945f, -0.16299482f, 0.08620071f, 0.18631068f, 0.18838164f, 
    -0.09580024f, -0.14527382f, 0.04222845f, -0.08943762f, 0.29918242f, -0.00652376f, 0.41328984f, -0.25326917f, 
    0.31374118f, 0.36694270f, -0.39528552f, -0.18669616f, 0.02055889f, -0.16299331f, 0.24543053f, 0.17335734f, 
    0.41757965f, 0.01759178f, 0.04876627f, 0.08973542f, -0.27180687f, -0.11219120f, 0.09891329f, 0.46314770f, 
    -0.26622805f, -0.00962775f, -0.23830271f, -0.12684576f, -0.20335542f, -0.20093930f, 0.11671616f, -0.86410755f, 
    0.33848006f, 0.09062215f, 0.13617849f, 0.05701337f, -0.28270826f, 0.20590422f, -0.58873194f, 0.02819544f, 
    -0.32057285f, 0.09841395f, -0.08888838f, 0.03529563f, -0.12050266f, 0.09606733f, -0.15705256f, 0.51450831f, 
    0.04453683f, -0.09507322f, 0.07350994f, -0.23316918f, -0.12412470f, -0.10295913f, -0.09569570f, -0.15863375f, 
    -0.12524252f, 0.02474723f, 0.08326709f, 0.21149349f, -0.11732883f, 0.07476250f, 0.20065437f, -0.06732790f, 
    -0.53792387f, -0.10439456f, 0.23326406f, -0.06299423f, -0.36166599f, 0.06162369f, 0.16896206f, -0.36200628f, 
    0.34543437f, 0.35598239f, 0.20280838f, 0.21363850f, -0.13892913f, -0.09804577f, -0.03506941f, 0.17194681f, 
    0.23903933f, 0.17269807f, -0.21627164f, 0.00623231f, -0.04067040f, -0.07827979f, 0.05976444f, -0.01773129f, 
    0.37146434f, 0.01854280f, -0.06364365f, -0.18946479f, -0.07439532f, -0.16469322f, 0.18263407f, -0.19867724f, 
    -0.33272940f, 0.13990030f, 0.07626227f, 0.10173074f, -0.40274447f, -0.32507578f, -0.06179333f, 0.06699542f, 
    0.22902368f, 0.16764100f, 0.30683416f, -0.16838779f, -0.16018462f, -0.24527560f, -0.02419200f, 0.39028245f, 
    -0.23548222f, 0.06124244f, -0.03540928f, 0.17742777f, 0.40480202f, -0.42816848f, 0.34345257f, 0.03129852f, 
    0.07706233f, 0.40838522f, -0.15566900f, -0.08687928f, -0.07090596f, 0.11883681f, 0.14987516f, 0.09291377f, 
    0.17952606f, -0.20511590f, -0.14517331f, -0.17500001f, -0.39630157f, 0.50566351f, -0.26137853f, 0.14429930f, 
    0.26195160f, -0.21972078f, 0.02980539f, -0.21727739f, -0.22777571f, -0.18904546f, -0.17378041f, -0.45717552f, 
    0.27334329f, -0.14981025f, 0.21121480f, 0.24826676f, -0.17691334f, 0.44005287f, -0.54577500f, -0.05562992f, 
    -0.06159480f, 0.10464254f, -0.02197457f, -0.14141464f, -0.21451150f, -0.12458188f, -0.17532393f, 0.27473298f, 
    -0.05418899f, -0.29490244f, -0.09947415f, -0.23509681f, 0.26874354f, -0.14897300f, 0.26712677f, 0.38330081f, 
    -0.16950092f, -0.11575869f, -0.05042409f, -0.27493373f, 0.16259246f, -0.02468857f, -0.08306075f, 0.31366965f, 
    -0.04032378f, -0.02230107f, 0.22631891f, 0.19348414f, -0.08472537f, 0.42451626f, -0.21599728f, 0.25476313f, 
    0.19811635f, -0.31246063f, 0.32915434f, 0.25606230f, -0.17754042f, -0.02781311f, -0.02439258f, -0.00402563f, 
    -0.44083047f, -0.04084867f, -0.06386559f, 0.21399544f, -0.22125986f, 0.54505849f, -0.70539039f, 0.28081617f, 
    0.16937640f, 0.32465184f, 0.09821220f, 0.14914405f, 0.18520936f, 0.12544477f, -0.07842977f, -0.12494427f, 
    0.02334546f, -0.09442090f, -0.12806244f, -0.19182701f, -0.33929065f, -0.18362704f, -0.20525517f, 0.38435772f, 
    0.03615549f, -0.02057821f, 0.65561455f, 0.00759337f, -0.11528840f, -0.13174406f, 0.17053968f, -0.06810284f, 
    -0.07489314f, 0.18634763f, 0.07228025f, -0.22601335f, -0.06132565f, -0.51181674f, 0.08494416f, 0.46760395f, 
    0.10900483f, 0.18339227f, 0.02846255f, -0.02494826f, 0.19988912f, -0.00476387f, 0.19641504f, 0.04070326f, 
    0.39072976f, -0.05365065f, -0.22943634f, 0.14221826f, -0.76500154f, -0.09825816f, 0.06760642f, 0.38332328f, 
    -0.17975473f, -0.52994615f, 0.32965341f, -0.11975247f, -0.11741358f, 0.03251264f, -0.22617921f, 0.15168104f, 
    0.34971321f, -0.02225295f, 0.00477113f, 0.20903486f, -0.25556901f, -0.02551259f, -0.11683326f, 0.16715838f, 
    0.53779161f, -0.24478060f, -0.10367771f, -0.18162383f, -0.18203108f, 0.00928060f, -0.17934452f, 0.01834869f, 
    0.31785598f, -0.03611218f, 0.24642046f, 0.06047019f, 0.29490656f, 0.01456971f, 0.03977130f, 0.16778016f, 
    -0.31329975f, -0.04501680f, 0.11316269f, 0.07658482f, -0.07817193f, 0.13767627f, -0.06316227f, -0.18672688f, 
    0.34360245f, 0.21830098f, -0.15844381f, 0.04810466f, 0.36111090f, 0.30780834f, -0.06334800f, 0.19736564f, 
    -0.29662937f, -0.12130880f, 0.14046408f, -0.12051152f, -0.10469212f, -0.23317984f, 0.09410509f, -0.19486772f, 
    0.09618659f, -0.19952643f, -0.02599475f, 0.07637960f, -0.02868739f, -0.02056515f, 0.03029963f, -0.15698487f, 
    -0.20311794f, 0.01987375f, -0.03258649f, 0.10520557f, 0.15027076f, -0.17622155f, -0.24139738f, -0.26774129f, 
    0.39599171f, -0.07198700f, 0.07660228f, -0.18978350f, -0.41821983f, 0.02619594f, -0.14681605f, 0.32904482f, 
    -0.15727526f, -0.26114446f, 0.20775361f, -0.16819207f, 0.13352405f, 0.24088009f, -0.08212519f, 0.10266368f, 
    0.43242306f, 0.24435152f, -0.14008434f, 0.10678676f, -0.15409243f, 0.15111777f, -0.38078621f, 0.08203723f, 
    0.38452059f, -0.30281535f, -0.08843112f, -0.17160471f, -0.11154021f, -0.13418610f, -0.09643371f, -0.05582305f, 
    -0.14392255f, 0.12683915f, 0.04983852f, 0.02440098f, 0.39532658f, -0.03031393f, 0.22735640f, 0.31936306f, 
    -0.36663866f, -0.18470247f, 0.25889897f, -0.12456849f, -0.07215366f, -0.12765124f, -0.03903509f, 0.22018613f, 
    0.07978245f, 0.07179268f, -0.16258705f, 0.17214276f, 0.41316879f, 0.29496053f, -0.76647389f, -0.13497466f, 
    -0.03860895f, -0.21701676f, 0.30092099f, -0.13509029f, -0.18248105f, 0.10110986f, -0.02165555f, 0.26240641f, 
    -0.02875060f, 0.07936723f, -0.12716636f, 0.22768439f, 0.24146004f, 0.12192684f, 0.05393627f, 0.18878596f, 
    -0.21157408f, -0.41640189f, 0.39764601f, 0.07183060f, -0.11957102f, -0.12438811f, 0.00198546f, 0.35336044f, 
    -0.09627519f, -0.23667786f, 0.01661605f, -0.12135753f, 0.25851113f, -0.25887915f, -0.06017287f, -0.04991963f, 
    -0.30210608f, 0.11627910f, 0.19876216f, -0.20833167f, -0.08908463f, -0.24056536f, -0.10796341f, -0.22828735f, 
    0.43336967f, 0.12806672f, -0.19378388f, 0.17454265f, 0.26055685f, 0.19214962f, 0.11092281f, -0.00231940f, 
    -0.38182396f, -0.35230947f, 0.17394698f, 0.05981328f, -0.09544403f, -0.03475333f, -0.14731213f, -0.34316298f, 
    -0.21854991f, 0.03349687f, -0.05254101f, -0.12281016f, 0.22412999f, -0.19110116f, 0.40535417f, 0.68993002f, 
    -0.34631434f, -0.14190949f, 0.06036011f, 0.07802210f, 0.12683688f, 0.07302113f, -0.24557763f, -0.18691713f, 
    0.18308957f, -0.07462101f, 0.05945940f, 0.20097144f, 0.06685436f, 0.51310617f, -0.31938577f, -0.00944213f, 
    -0.03260699f, -0.17499788f, 0.36483285f, 0.16013698f, 0.12747338f, -0.14414591f, -0.08678228f, 0.02211778f, 
    0.41933706f, 0.03725398f, 0.23754406f, 0.13355932f, -0.20150931f, 0.14218873f, -0.31751910f, 0.09515254f, 
    0.49548653f, -0.38322398f, -0.14959146f, -0.15232794f, -0.11499858f, -0.20311293f, 0.17344998f, 0.06996653f, 
    0.27257732f, -0.05751122f, 0.09300401f, -0.09628993f, -0.03384419f, -0.28965572f, 0.13982494f, 0.16749406f, 
    0.34164944f, -0.08669446f, -0.39843121f, -0.04646268f, -0.02540200f, -0.08646062f, 0.00884920f, 0.10830346f, 
    -0.45683032f, -0.12816387f, -0.12927881f, -0.04074645f, -0.14257176f, 0.20831251f, -0.27414587f, 0.29285106f, 
    0.42729890f, 0.17573075f, 0.00944785f, -0.09928976f, 0.05407063f, -0.22959830f, -0.09270117f, 0.09777347f, 
    0.14947362f, 0.01004999f, 0.15931414f, 0.11601177f, 0.02314119f, 0.19359425f, -0.21595287f, 0.31396291f, 
    0.29439843f, -0.27435079f, 0.01327494f, 0.03977157f, -0.14491297f, 0.10264227f, 0.17144953f, 0.26400256f, 
    -0.21817645f, -0.18700352f, -0.06046530f, 0.25275138f, -0.10001551f, -0.07592179f, 0.22069480f, 0.02746189f, 
    0.34627602f, 0.25833416f, -0.16427705f, 0.02510974f, 0.03071923f, -0.22937392f, 0.11889147f, -0.02477044f, 
    0.07484881f, 0.04281013f, -0.10265406f, 0.09697332f, 0.48709705f, 0.07349062f, 0.41828024f, -0.18764704f, 
    -0.00491107f, 0.47588599f, -0.06324354f, 0.24044326f, 0.22882700f, -0.04889853f, 0.15256479f, -0.25858736f, 
    -0.23463374f, -0.21695039f, -0.12846108f, -0.01200771f, -0.51169932f, 0.07719967f, 0.19524957f, 0.53304154f, 
    -0.23900974f, 0.49538535f, 0.22902794f, 0.23254523f, 0.00687613f, 0.05416754f, -0.09657439f, -0.21268347f, 
    -0.20917495f, -0.20929870f, 0.18663141f, 0.06587859f, -0.72501540f, 0.30564445f, -0.19834946f, 0.21655811f, 
    -0.00142492f, 0.01276562f, 0.47790983f, 0.10787037f, 0.24696885f, -0.20196645f, 0.20135149f, 0.24840966f, 
    -0.71891689f, -0.08407171f, -0.20069198f, 0.18841876f, 0.38868356f, 0.20500194f, -0.04441293f, 0.05859797f, 
    -0.16096865f, 0.42248112f, 0.16083652f, 0.04847424f, -0.19016759f, 0.08883149f, -0.22620603f, -0.39724463f, 
    -0.19055609f, 0.05574020f, 0.19840144f, -0.23289871f, -0.18582034f, -0.17595780f, -0.09486457f, -0.24649082f, 
    -0.22093421f, -0.05913738f, 0.13394742f, 0.18072160f, 0.00496889f, -0.05898389f, -0.07651633f, -0.15825815f, 
    -0.03325029f, 0.04959219f, 0.19393215f, -0.22478801f, 0.34014302f, 0.30212140f, 0.19545098f, -0.26675552f, 
    0.23516344f, -0.08882061f, -0.29434955f, 0.02808238f, 0.22241354f, 0.14938205f, 0.16086486f, 0.18028499f, 
    0.45512456f, -0.12277211f, 0.10145283f, -0.21916991f, 0.21170995f, 0.41538158f, -0.49416733f, 0.23528512f, 
    -0.14568597f, 0.19596229f, -0.28247347f, -0.22206439f, -0.06366924f, -0.24049872f, 0.14922243f, -0.55783355f, 
    -0.24917589f, 0.17156425f, 0.21729167f, -0.00813631f, 0.21974553f, -0.27591574f, 0.34959739f, 0.44364405f, 
    -0.17213525f, 0.13385411f, 0.09493378f, 0.22036436f, 0.23338160f, 0.13372923f, 0.11309802f, -0.03439986f, 
    0.25036988f, -0.05675609f, 0.03604509f, 0.07606477f, -0.14758138f, 0.23910888f, -0.15124796f, 0.39119279f, 
    -0.34843931f, -0.09454108f, 0.20433778f, 0.17891838f, 0.04169479f, 0.17032543f, -0.03019597f, 0.26229498f, 
    0.41629139f, -0.06330752f, -0.15963081f, 0.06771374f, -0.30809641f, 0.10062425f, -0.35182354f, 0.29542059f, 
    0.08531122f, -0.35245392f, 0.12119468f, 0.04491550f, 0.14673163f, 0.21118535f, -0.03351216f, 0.25604969f, 
    0.02737106f, 0.12983817f, -0.07410626f, -0.17133676f, -0.26801246f, -0.24769658f, 0.43166345f, -0.11308789f, 
    0.26407272f, 0.11335301f, -0.23639268f, -0.24251442f, 0.19356313f, -0.19141392f, 0.23045923f, 0.21796621f, 
    -0.27676275f, 0.00157134f, 0.08887389f, 0.19754751f, -0.50657934f, 0.03892167f, -0.24384509f, 0.14830251f, 
    0.23090504f, 0.34886149f, 0.10944377f, -0.26474038f, 0.21699557f, 0.04607392f, -0.07308792f, 0.31976363f, 
    0.03258594f, -0.24355103f, -0.14266761f, 0.06187649f, -0.03103465f, 0.26014119f, -0.38037387f, 0.25577885f, 
    -0.26151180f, 0.10809581f, 0.47636575f, -0.20219822f, 0.17099935f, 0.15997607f, 0.10644539f, 0.06592111f, 
    0.03291659f, -0.02909630f, -0.06268223f, 0.21348880f, -0.12395779f, 0.46539065f, -0.17725630f, -0.20412959f, 
    -0.01058795f, 0.17562233f, 0.19696446f, 0.00588148f, 0.18028472f, -0.23366559f, -0.17723548f, 0.13914466f, 
    0.13568912f, 0.01951478f, -0.03470229f, 0.19057199f, -0.04264457f, 0.11033044f, 0.23954856f, 0.17219521f, 
    0.27586859f, -0.17866085f, -0.46728531f, 0.22858520f, 0.24267653f, -0.03264074f, -0.00705606f, -0.40562493f, 
    -0.28838819f, 0.24191727f, 0.08993295f, -0.21730532f, -0.07432307f, 0.04769268f, -0.20182371f, -0.01358624f, 
    0.00122517f, 0.58105767f, 0.00051981f, 0.17195067f, -0.05765242f, 0.07560911f, -0.18194962f, 0.26262054f, 
    0.07632869f, 0.05536693f, 0.03606509f, 0.14207524f, -0.28585166f, 0.29772088f, -0.28185058f, -0.11851173f, 
    -0.25053471f, -0.04260686f, 0.36425957f, -0.19981904f, -0.21650246f, -0.22830176f, -0.21414012f, 0.27752757f, 
    -0.17754045f, -0.06692626f, -0.12531406f, 0.18409918f, -0.25791544f, 0.46829125f, -0.18425435f, 0.26468450f, 
    0.08198716f, 0.09022603f, 0.24420974f, 0.02763420f, 0.20301777f, 0.12180136f, 0.08963192f, -0.13244572f, 
    0.15514459f, -0.01822540f, 0.19881895f, -0.15615354f, 0.23038490f, 0.14268371f, -0.77603537f, 0.19215062f, 
    -0.02808974f, -0.31850490f, 0.23215023f, -0.02888541f, -0.08076841f, 0.21543336f, 0.00022604f, 0.34457430f, 
    -0.40166754f, 0.15929960f, -0.03777127f, -0.00767526f, 0.28002140f, -0.19591285f, -0.16329840f, -0.07603677f, 
    0.21200331f, 0.33030728f, 0.46011084f, 0.24048741f, -0.06864159f, -0.12590557f, 0.22417180f, 0.00613627f, 
    -0.08444590f, 0.10587010f, -0.17675145f, 0.18263026f, 0.14011337f, 0.27111682f, -0.37083367f, -0.30968323f, 
    0.06217806f, 0.32963336f, 0.40554640f, 0.22464819f, -0.22197476f, 0.07122119f, -0.07805976f, 0.06771455f, 
    -0.06515682f, 0.05854143f, 0.04193280f, 0.17455888f, -0.10086794f, -0.33053410f, 0.21961072f, 0.36384633f, 
    0.44375309f, -0.01059400f, -0.18754227f, 0.03311750f, 0.17413822f, -0.18982983f, 0.05821921f, 0.30767104f, 
    -0.16377360f, -0.13416439f, -0.02746326f, 0.10457996f, 0.46867564f, -0.23931308f, 0.06911843f, 0.31612277f, 
    -0.59196234f, 0.38290122f, 0.06446150f, 0.17786236f, -0.19844525f, -0.02984189f, -0.16443731f, 0.02504231f, 
    -0.05659311f, -0.15150121f, -0.02680698f, 0.02778922f, -0.13871284f, -0.18893994f, -0.06558694f, -0.25984550f, 
    0.03139165f, -0.17478906f, 0.45529974f, 0.04405047f, 0.23815072f, -0.02175259f, -0.05755609f, 0.23344211f, 
    -0.34604305f, -0.09276746f, -0.14490877f, 0.25282344f, 0.45956492f, -0.09660287f, -0.04594054f, 0.21051915f, 
    -0.14708036f, 0.29633236f, -0.16477579f, 0.25373131f, 0.16947003f, -0.22421867f, 0.21026944f, 0.29795048f, 
    0.24043737f, 0.10030118f, -0.00555715f, -0.00671998f, 0.40511146f, 0.11351253f, 0.59557354f, -0.25070989f, 
    -0.42046514f, -0.23006423f, -0.11306264f, -0.19394238f, -0.16398464f, 0.17000273f, 0.15547565f, 0.01686402f, 
    0.47818139f, -0.03916876f, -0.20962825f, -0.08716507f, 0.39207667f, 0.09516257f, 0.28273582f, -0.14700812f, 
    0.02891116f, -0.01307136f, -0.13390625f, -0.09823424f, -0.01969742f, 0.11933475f, -0.14869913f, -0.24875151f, 
    -0.33378851f, 0.06114726f, -0.05605872f, 0.14863829f, 0.49618629f, -0.10386460f, 0.34181580f, 0.61612850f, 
    0.06783895f, -0.14398864f, -0.23788659f, -0.18735883f, -0.06448137f, 0.03918789f, 0.15996809f, -0.22795093f, 
    0.01179616f, -0.04027770f, 0.03769353f, 0.00432674f, 0.19274978f, -0.35131347f, -0.01763018f, -0.18681936f, 
    0.20698605f, 0.53604668f, 0.24980289f, -0.20338303f, 0.15453453f, -0.06794399f, 0.15681539f, -0.52824324f, 
    0.18966281f, -0.04772975f, -0.14423917f, -0.08108291f, -0.39367384f, 0.17590372f, -0.19420752f, 0.10255951f, 
    -0.15075450f, 0.00976320f, 0.51313627f, -0.06457382f, -0.08431208f, -0.19040535f, 0.13598059f, -0.22273129f, 
    -0.11005314f, 0.13850480f, 0.20139073f, 0.25510517f, -0.17762581f, -0.17280573f, -0.01208113f, -0.03013083f, 
    -0.45268795f, 0.53053528f, 0.10470495f, -0.16858125f, 0.22064087f, 0.13149965f, -0.10949539f, 0.13115513f, 
    0.05019754f, -0.12880777f, 0.15518275f, -0.16726685f, 0.38150859f, 0.28415835f, -0.96036673f, 0.20221570f, 
    0.15785314f, -0.51077998f, 0.27206126f, 0.14820538f, 0.10652994f, 0.07872944f, -0.06185874f, 0.38157684f, 
    0.38378528f, -0.10285601f, 0.10472056f, 0.08696088f, 0.00542338f, -0.31486413f, 0.01594141f, 0.36871764f, 
    -0.11730710f, -0.02682656f, 0.26723689f, -0.15456942f, -0.01810721f, 0.03656492f, -0.05803490f, -0.35879833f, 
    0.06670500f, -0.22887547f, -0.11844452f, -0.22007915f, 0.20439503f, 0.21681771f, -0.62515593f, 0.01336024f, 
    -0.24345696f, -0.18010134f, 0.16044609f, -0.22958863f, 0.04193296f, -0.02923171f, -0.04178501f, 0.49644721f, 
    0.11988425f, -0.19698510f, 0.12028237f, -0.08133007f, 0.16585568f, -0.02696976f, 0.07617380f, -0.22656943f, 
    0.26952916f, -0.24661760f, -0.21950109f, 0.04282537f, 0.05978895f, -0.11891355f, 0.06978010f, 0.02041473f, 
    -0.04376437f, -0.13931674f, -0.09853310f, -0.24449253f, 0.63883090f, -0.05951139f, 0.15992901f, 0.15624057f, 
    -0.47713548f, -0.12214393f, 0.11275691f, -0.04136908f, -0.00693317f, -0.07934215f, -0.19196676f, 0.19335800f, 
    0.03291945f, -0.10905048f, -0.15388718f, -0.00006171f, -0.43315902f, 0.11889832f, -0.00075355f, 0.47362503f, 
    -0.05433270f, 0.28941017f, -0.23153636f, 0.20063594f, -0.16005380f, -0.20668411f, -0.20116132f, -0.74572498f, 
    -0.08865974f, -0.01193258f, 0.23799948f, 0.19284233f, 0.16619633f, 0.62398320f, -0.37928972f, 0.19502693f, 
    0.06254160f, -0.06468668f, 0.19724889f, 0.11986826f, 0.08352247f, -0.24611978f, 0.16952729f, -0.11921602f, 
    -0.38851804f, -0.03029846f, 0.16531292f, -0.13798943f, 0.03993970f, 0.00094302f, 0.51880848f, -0.27059138f, 
    0.11642552f, 0.30019581f, -0.08933638f, 0.02655333f, -0.18080921f, -0.21513456f, 0.09113267f, 0.06288532f, 
    -0.32542780f, -0.18990226f, 0.23180375f, -0.12029152f, -0.22558939f, -0.37699345f, 0.24667576f, 0.34560046f, 
    0.24468155f, 0.08496650f, 0.46189490f, 0.12464570f, -0.15809080f, -0.04986992f, 0.03727319f, -0.00855538f, 
    -0.12095979f, -0.25357953f, -0.04856526f, 0.04152250f, 0.17096087f, -0.17975830f, 0.21243438f, 0.38081118f, 
    -0.10652989f, 0.29834118f, -0.08184200f, -0.05655107f, -0.21423587f, 0.20019728f, -0.00044666f, -0.04088917f, 
    0.35758939f, -0.16034876f, 0.23019269f, 0.21314415f, 0.21478203f, 0.21340699f, -0.39942378f, -0.01897740f, 
    0.63174403f, -0.34816474f, -0.11894959f, -0.11299028f, -0.15322161f, 0.15509596f, -0.18766409f, -0.20704447f, 
    -0.42280796f, 0.11625238f, -0.20166709f, -0.07478888f, 0.24068739f, -0.31563854f, 0.40646431f, 0.11906512f, 
    0.32427141f, 0.04672381f, 0.07765169f, 0.23491623f, 0.05748519f, -0.23257729f, -0.09138177f, 0.02291253f, 
    0.22245714f, -0.21841973f, -0.20007895f, -0.06366684f, 0.32980624f, 0.37986520f, 0.03498396f, -0.11394010f, 
    -0.18048671f, -0.22910939f, 0.07922795f, 0.21459882f, -0.22122335f, -0.00548243f, 0.13980463f, -0.09650146f, 
    0.44581893f, -0.19148850f, 0.09261996f, -0.15771474f, 0.51287091f, 0.09100792f, 0.14409964f, -0.10181402f, 
    0.23794886f, -0.30100530f, -0.12648310f, 0.22414529f, 0.22021900f, 0.06972872f, 0.12689029f, -0.31372568f, 
    0.00125430f, -0.17041992f, -0.07668168f, 0.08324638f, 0.19128577f, 0.14399265f, 0.11095449f, 0.14579900f, 
    -0.05562709f, 0.17573951f, 0.03289003f, -0.05390413f, 0.03951011f, -0.12027267f, 0.00894224f, -0.45585001f, 
    -0.49352121f, 0.17724341f, -0.02495688f, 0.18129945f, -0.40695485f, 0.02025586f, 0.04697881f, 0.24470550f, 
    0.06935681f, 0.47847745f, -0.13960071f, -0.07645296f, 0.13711461f, 0.09962875f, -0.03889525f, 0.05969851f, 
    -0.31091666f, 0.19581430f, -0.17138945f, -0.06619250f, 0.08492975f, -0.35410193f, 0.34298095f, 0.51444525f, 
    0.17378773f, -0.67417294f, 0.32861862f, -0.13950564f, 0.03282602f, -0.09218875f, 0.00261623f, -0.37801963f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.34209993f, -0.41989520f, 0.60323977f, 0.34880462f, 0.65331888f, -0.11543807f, 0.33495507f, 0.02159924f, 
    -0.00387803f, -0.29372793f, -0.51709634f, 0.23596002f, 0.18353419f, 0.37145612f, 0.17064691f, 0.14897741f, 
    -0.32150057f, 0.63001722f, 0.10384341f, -0.18245752f, 0.22450882f, 0.28155315f, 0.31644458f, 0.02211365f, 
    0.51268405f, 0.40908542f, 0.05990501f, 0.13482985f, -0.72304058f, 0.28455251f, -0.31036335f, 0.57356566f, 
    -0.22650883f, 0.19823392f, 0.17594023f, -0.13087183f, 0.23153085f, 0.59948021f, 0.39761961f, 0.13931377f, 
    0.08180468f, -0.11968429f, -0.29095322f, -0.04427559f, -0.49951360f, 0.44470572f, -0.01342207f, 0.37145957f, 
    0.20507607f, -0.08402014f, 0.13822994f, 0.61543643f, 0.11634582f, 0.10065024f, 0.34189606f, -0.10142409f, 
    -0.26745823f, 0.23084567f, 0.22916237f, 0.42239735f, -0.06788909f, 0.09437606f, 0.32674184f, -0.16142011f, 
    -0.24356048f, -0.26752523f, 0.56231976f, 0.20551592f, -0.41119686f, -0.35976508f, -0.30094206f, -0.06302185f, 
    0.44409040f, -0.20445105f, 0.24413057f, 0.00336020f, 0.07943445f, -0.06695049f, -0.47608775f, 0.63177788f, 
    0.51413524f, -0.24797101f, 0.38398445f, 0.22689034f, -0.01144892f, -0.72782397f, 0.28597027f, 0.30823851f, 
    -0.31398794f, -0.33526427f, 0.12152254f, 0.02377906f, 0.28719556f, 0.29555312f, 0.49859816f, 0.06338772f, 
    0.44230345f, 0.17384392f, -0.34819552f, -0.06693328f, 0.28140458f, -0.29762235f, -0.22389419f, 0.63195157f, 
    -0.49517378f, -0.65092462f, 0.34520590f, -0.17809556f, 0.80290598f, 0.61966628f, 0.34783658f, -0.54677749f, 
    0.40921754f, -0.35517561f, 0.39299995f, 0.15606146f, 0.73511261f, 0.21012892f, -0.17624857f, 0.19208141f, 
    -0.57195842f, -0.14491504f, 0.32416549f, 0.28631496f, 0.02206630f, 0.71688145f, 0.01409700f, 0.39354661f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04027119f, -0.17552221f, -0.19396546f, 0.25102544f, 0.13503884f, 0.03304083f, -0.19588965f, 0.14265585f, 
    -0.06104928f, 0.15655047f, -0.19693570f, 0.13691697f, -0.72837579f, 0.01385475f, -0.06943112f, 0.15418062f, 
    -0.05505858f, -0.04707962f, 0.02902714f, -0.16203313f, -0.05546487f, -0.01330170f, -0.08773278f, -0.00151454f, 
    -0.24948767f, -0.20799226f, -0.01815554f, -0.07019871f, -0.12385336f, 0.02843381f, 0.15876904f, -0.11713871f, 
    -0.04153148f, 0.13957828f, -0.21408130f, 0.00109512f, -0.44568887f, 0.25400996f, 0.40890619f, 0.10771451f, 
    -0.40362677f, -0.08911500f, -0.42969295f, -0.50072002f, -0.04515582f, 0.19309768f, -0.07197618f, -0.17467457f, 
    -0.16947785f, 0.07626006f, -0.42967364f, 0.05331324f, -0.07851078f, 0.04356716f, -0.10319722f, -0.24557738f, 
    0.16054501f, 0.10479502f, -0.58879012f, 0.15408009f, 0.14915830f, 0.15253384f, 0.11367404f, 0.10320133f, 
    0.13409954f, 0.00004290f, 0.10102580f, -0.18465233f, 0.18233608f, -0.58942443f, 0.03321954f, -0.30638364f, 
    0.06332175f, 0.40615574f, 0.08654308f, -0.13512626f, 0.01690575f, 0.02992904f, 0.00956946f, -0.05738452f, 
    0.00313432f, -0.20641297f, -0.12082963f, -0.25614524f, -0.07420080f, -0.39489493f, 0.27987951f, 0.23195815f, 
    0.02474285f, -0.09483607f, -0.19064556f, -0.21905260f, 0.09403524f, -0.10865452f, -0.11272977f, 0.06518723f, 
    -0.26193607f, 0.00736312f, -0.82228738f, 0.07331519f, 0.02113799f, -0.09225059f, 0.25349075f, 0.25170487f, 
    -0.04652221f, -0.28268650f, 0.10729703f, 0.25625494f, 0.05348021f, 0.02897560f, 0.11107331f, -0.82695657f, 
    0.15315479f, -0.82845485f, 0.15927437f, 0.21524657f, -0.32631317f, 0.03481459f, -0.13426952f, 0.09618232f, 
    0.05076510f, -0.20509994f, 0.16061884f, 0.17455649f, 0.09845406f, 0.10481966f, -0.12438861f, 0.60820925f, 
    -0.05711947f, 0.23440801f, 0.05046007f, -0.09469112f, -0.08326110f, 0.06029589f, 0.64273190f, -0.36932117f, 
    0.15988614f, -0.08019479f, 0.18274888f, -0.21130693f, 0.24772726f, 0.37163985f, 0.21406309f, 0.13477200f, 
    0.08535381f, -0.29742381f, -0.00840476f, -0.19971371f, 0.08600116f, 0.00121911f, 0.20578992f, -0.05449048f, 
    -0.16780159f, -0.25229055f, -0.23976088f, -0.03023304f, 0.12707907f, -0.00559854f, 0.10599428f, -0.05392139f, 
    -0.05192363f, 0.10842910f, -0.00301609f, -0.02601486f, 0.04690059f, -0.18241717f, -0.18725421f, -0.36621058f, 
    0.46895880f, -0.31796008f, 0.06300654f, 0.20413709f, 0.04423404f, -0.07257148f, 0.10505196f, 0.48280793f, 
    -0.12113798f, -0.00642606f, -0.17179397f, -0.05338912f, -0.05785788f, 0.15705177f, -0.10994252f, -0.20724326f, 
    0.19964147f, -0.33017957f, -0.41666472f, -0.17137511f, 0.23414712f, 0.04025910f, -0.00930838f, 0.04727894f, 
    -0.10544489f, -0.03524897f, -0.02611418f, 0.20296650f, 0.11374296f, 0.22860700f, -0.05328240f, -0.38505003f, 
    -0.41103554f, 0.36651120f, -0.35205397f, 0.21470974f, 0.05501515f, -0.07805277f, -0.03180034f, -0.02154436f, 
    0.02640421f, 0.45328632f, -0.23352511f, -0.07523910f, 0.05589207f, 0.08833288f, -0.39380372f, 0.17941736f, 
    0.10046878f, -0.24284431f, 0.08960555f, 0.11201862f, -0.21739824f, -0.39615509f, 0.35556617f, 0.02051073f, 
    -0.02927248f, -0.16926251f, 0.12928770f, -0.08530670f, -0.39304036f, 0.23544703f, 0.28702211f, -0.26659551f, 
    0.27179837f, -0.24221033f, -0.07386924f, 0.25857067f, 0.04588521f, -0.32366401f, -0.00614763f, 0.30463621f, 
    0.06894836f, 0.09977151f, 0.15501252f, 0.03312308f, 0.29132792f, -0.64445567f, 0.10590795f, 0.14810494f, 
    0.20613575f, 0.57429498f, 0.11699300f, -0.31803736f, 0.02277455f, 0.03169728f, 0.26494953f, 0.32723537f, 
    -1.00302517f, -0.10638554f, -0.25335541f, -0.21178974f, 0.01398909f, 0.02744088f, -0.22976099f, 0.08939883f, 
    -1.21500504f, 0.25290605f, 0.08276149f, -0.08936426f, -0.11889200f, -1.07883048f, -0.13237724f, -0.15348773f, 
    0.05070795f, -0.11256096f, -0.07387335f, 0.01657663f, 0.18436265f, -0.62395608f, -0.56933397f, -0.14308760f, 
    0.26738808f, -0.03128375f, -0.11836519f, -1.16415930f, 0.04670913f, 0.12992518f, 0.19308682f, -0.68544555f, 
    -0.06151994f, -0.06244876f, -0.63059545f, 0.18416686f, -0.56050831f, -0.26715702f, -0.18544954f, 0.19864979f, 
    0.03432432f, -0.12772557f, 0.05043111f, 0.11566410f, 0.29385808f, -0.29628021f, -0.58885282f, 0.08757787f, 
    0.33958194f, -0.08011584f, -0.89603943f, 0.02945229f, -0.33793488f, -0.34894451f, 0.26993975f, 0.21920379f, 
    -0.04657117f, 0.25719342f, 0.51494640f, 0.29678842f, 0.08974280f, 0.11243398f, 0.02928992f, 0.14969361f, 
    0.19445613f, -0.06095544f, 0.19968466f, 0.22160608f, 0.19745487f, -1.06613052f, 0.02842778f, -0.12572455f, 
    0.00129684f, 0.29513618f, 0.05921537f, 0.08702326f, 0.02622925f, 0.12413492f, 0.07756766f, -0.11530519f, 
    -0.15919800f, 0.24834616f, 0.17244945f, -0.22185139f, 0.01572194f, -0.50752938f, 0.23142761f, 0.09198648f, 
    0.27519807f, 0.05272620f, -0.23545171f, 0.15381150f, 0.17750865f, -0.17271470f, -0.00667601f, -0.15662311f, 
    -0.21210006f, 0.36159262f, -0.65367955f, -0.08534111f, -0.22760500f, 0.08943735f, -0.14556509f, -0.41958627f, 
    -0.40747419f, 0.18158142f, -0.06188891f, 0.22360809f, -0.19965886f, 0.16365601f, -0.48986167f, -1.19054079f, 
    0.16918440f, -1.03007174f, -0.67262661f, -0.07769591f, 0.05689772f, 0.26256919f, -0.26148477f, 0.05063264f, 
    0.17980456f, -0.04736609f, -0.03791006f, -0.03542584f, -0.06665552f, 0.14082496f, 0.16313311f, 0.43370146f, 
    0.11341005f, 0.00222216f, -0.06881671f, -0.09911781f, 0.10233983f, -0.23762234f, -0.66652530f, 0.03133842f, 
    0.06360316f, -0.15603910f, 0.00910306f, -0.21629675f, -1.01546192f, 0.19932550f, -0.26959538f, -0.33445647f, 
    -0.15648563f, -0.37599888f, 0.16515140f, 0.02976626f, 0.24496059f, 0.14236087f, -0.37735018f, -0.05319187f, 
    -0.94965994f, -0.02825241f, -0.24024567f, 0.22208293f, 0.15336791f, -0.14926989f, -0.27793217f, -0.07366206f, 
    0.01964646f, -0.71753091f, 0.07535134f, -0.42521185f, 0.81969595f, -0.05673574f, 0.09256510f, -0.07032510f, 
    -0.37084097f, 0.14933990f, 0.02906762f, 0.32567960f, -0.36362284f, 0.14307398f, -0.23703749f, -0.12157134f, 
    0.21726429f, -0.06940713f, 0.31269068f, -0.53213406f, 0.30967888f, -0.40159428f, -0.86077249f, 0.09510536f, 
    0.06082887f, 0.07342290f, 0.12750325f, 0.24425560f, -0.07228040f, 0.26833442f, -0.23785505f, -0.33084512f, 
    -0.15985979f, 0.06696956f, 0.10423647f, -0.26676592f, 0.13670911f, 0.14777836f, 0.20215327f, -0.16800709f, 
    -0.36646867f, -0.29382461f, 0.06437261f, -0.24521315f, -0.12143520f, 0.11317541f, 0.11927781f, -0.21880953f, 
    -0.61411995f, -0.16762443f, 0.35383296f, -0.16313587f, 0.05618824f, -0.11727358f, -1.28475440f, -0.19139645f, 
    0.23300998f, 0.05215392f, -0.18865633f, 0.42238587f, 0.14754134f, 0.18771392f, -0.52546787f, 0.20440428f, 
    0.26671720f, 0.10437919f, 0.31278321f, 0.06596113f, 0.19564711f, 0.15150096f, -0.12897022f, 0.15329456f, 
    -0.02568801f, -0.77174497f, -0.65035254f, -0.81879228f, -1.05697060f, 0.16378772f, 0.00451541f, 0.29130405f, 
    -0.35446873f, 0.27044165f, -0.05042102f, -0.02495728f, -1.42949533f, 0.04577899f, 0.05304875f, -0.01749971f, 
    -0.32731399f, -0.42696860f, -0.13645592f, -0.07403125f, -0.59970444f, -0.50122541f, -0.51802516f, -0.81274503f, 
    0.15867122f, -0.46535137f, 0.07655464f, 0.28033918f, 0.05290746f, -0.30449116f, 0.08799139f, 0.06122945f, 
    -0.21204671f, 0.01498387f, -0.49150413f, 0.16186227f, 0.27194619f, -0.13645470f, -0.16341983f, -0.24593087f, 
    -0.31955144f, 0.23360062f, -0.32644406f, -0.04068257f, 0.07485952f, 0.02716608f, -0.04786162f, 0.12038659f, 
    0.13189805f, 0.12321915f, 0.20185424f, 0.26171649f, -0.30892822f, 0.05919274f, 0.11038509f, 0.10238186f, 
    0.06662887f, 0.03904732f, 0.16800146f, 0.03871558f, -0.59378272f, 0.10542700f, -0.20487517f, 0.04489177f, 
    0.36326498f, 0.23074749f, 0.01336530f, 0.40167943f, -0.30197397f, 0.06293636f, -0.02371971f, -1.25473058f, 
    0.38089302f, -0.00150337f, -0.03902677f, -0.06404861f, -0.06645875f, -0.18290873f, -0.13769360f, 0.17044033f, 
    -0.20869717f, -0.06861489f, -0.00620656f, 0.16407318f, -0.25821742f, -1.02900434f, -0.24562848f, 0.05378958f, 
    0.06780894f, 0.01589320f, 0.02732072f, -0.37954533f, -0.00146626f, -0.11311863f, -0.22510064f, 0.13353650f, 
    0.14362276f, 0.08645670f, 0.04077377f, -0.47195789f, -0.08520695f, -0.10700604f, -0.31749862f, -0.05539350f, 
    0.20238310f, -0.06534325f, 0.14834052f, 0.00690072f, 0.06368136f, -0.30187938f, 0.11701716f, -0.00366234f, 
    -0.03626397f, -0.53582340f, -0.17039922f, 0.01843566f, 0.10049527f, 0.19762312f, 0.26419473f, 0.13161667f, 
    0.20445324f, 0.07508708f, -0.24838595f, 0.01318762f, 0.23868258f, -0.52784705f, 0.13855898f, 0.01330157f, 
    -0.05707794f, 0.15865035f, 0.07998876f, -0.16370308f, 0.23711486f, 0.27370480f, 0.19168472f, -0.56468016f, 
    0.10609204f, -0.00735269f, 0.01363609f, 0.07347456f, -0.31337360f, 0.04700801f, -0.08773187f, -0.01525148f, 
    -0.16611077f, -0.44328919f, -0.21349189f, 0.09343085f, -0.07457020f, 0.15642199f, -0.32302231f, 0.25955430f, 
    0.07914262f, 0.04595563f, 0.13431822f, -0.07926121f, 0.12875317f, 0.06296093f, -0.62349534f, -0.23506398f, 
    -0.11993571f, -0.21620460f, -0.01334487f, 0.34288388f, -0.09367447f, -0.38454434f, 0.03798573f, 0.13987175f, 
    -0.14215928f, 0.18788974f, -0.07304724f, 0.08638300f, -0.22587568f, 0.06364853f, 0.27253914f, 0.00401832f, 
    0.02770764f, 0.09094963f, -0.02700915f, -0.04267081f, -0.42593637f, 0.08723374f, 0.01622692f, 0.15853907f, 
    0.08401047f, 0.22023635f, 0.13756488f, -0.13115403f, 0.61803931f, -0.09720933f, -0.00828376f, -0.28180742f, 
    -0.38733611f, -0.13744842f, -0.33877996f, -0.61923891f, -0.27487668f, 0.07514801f, 0.14386109f, 0.21842869f, 
    -0.54854935f, -0.03238272f, 0.18930621f, 0.06601487f, -0.04246591f, 0.30584788f, 0.12689352f, -0.34372747f, 
    0.14709562f, -0.29188135f, 0.08084692f, -0.26171091f, 0.09779792f, -0.48759481f, -0.07276841f, -0.08935828f, 
    -0.20644367f, 0.01187271f, -0.12882993f, 0.39202365f, 0.15327488f, 0.21700415f, 0.08868218f, 0.01807681f, 
    -0.01286002f, -0.04320255f, -0.26370382f, 0.24484409f, 0.10623417f, -0.02948708f, -0.31650460f, 0.05531045f, 
    0.25755584f, -0.11487754f, -0.38228139f, -0.11086663f, 0.07579744f, -0.12972678f, 0.01580967f, 0.23374166f, 
    -0.19888996f, -0.14254349f, 0.13233569f, -0.04478144f, -0.21147011f, -0.24056882f, -0.03593042f, 0.03238200f, 
    -0.64373082f, -0.25234145f, 0.17449099f, 0.03194407f, -0.23113446f, 0.01964658f, 0.22304347f, -0.42280254f, 
    0.20274304f, 0.22879049f, 0.12404606f, 0.14741245f, 0.20921819f, -0.35931095f, 0.19417720f, 0.53002000f, 
    0.04050272f, -0.02485397f, -0.06867124f, 0.13809322f, 0.33493146f, -0.26628256f, 0.14985171f, 0.07333551f, 
    0.14083861f, 0.41403791f, 0.12261068f, -0.19958831f, -0.20246230f, 0.05744241f, 0.13177477f, -0.39780039f, 
    0.03032657f, -0.09214539f, 0.06758942f, -0.23175278f, 0.07174015f, -0.04198030f, 0.39217785f, -0.03885769f, 
    0.06259790f, -0.32587910f, 0.19212927f, -0.32643685f, 0.26669973f, -0.18964648f, 0.04948312f, -0.32473919f, 
    0.12702671f, 0.28550988f, 0.11389618f, -0.03728104f, -0.25614873f, 0.12669104f, 0.13166687f, 0.15282270f, 
    -1.01340628f, 0.05377467f, 0.16785686f, -0.50410378f, 0.10386429f, 0.19023837f, -0.05555715f, 0.13353027f, 
    0.06253303f, 0.09306948f, 0.19037054f, -0.34309027f, -0.32191715f, 0.07788189f, -0.36450520f, -0.24969670f, 
    0.01389330f, 0.12573080f, 0.15873733f, -0.07484213f, -0.59478372f, 0.14044286f, 0.14381728f, -0.81254178f, 
    0.09828353f, 0.04297287f, 0.37988964f, 0.15514059f, 0.26061141f, 0.15302421f, -0.41824374f, -0.07761112f, 
    -0.30321160f, -0.07095966f, 0.46600008f, 0.17231384f, 0.12298867f, 0.05201259f, 0.04195166f, -0.39338359f, 
    -0.55761898f, -0.02800832f, -0.25325075f, -0.18371405f, -0.48166561f, -1.01312840f, -0.51097316f, -0.03142910f, 
    -0.69260794f, -0.34675765f, -0.02941577f, -0.21762173f, -0.03723442f, 0.13180013f, -0.33932745f, 0.11229393f, 
    0.09088417f, 0.01640840f, 0.12557109f, 0.80228740f, -0.05936884f, -0.05395468f, 0.01583344f, 0.06306074f, 
    -0.46835026f, 0.11309417f, 0.04264059f, 0.29468033f, -0.10096058f, 0.01772572f, -0.40027136f, 0.21159640f, 
    -0.39171073f, 0.10642437f, -0.54640239f, 0.29551750f, 0.17543307f, 0.01195841f, -0.18846643f, 0.04701428f, 
    -0.14584246f, -0.54664242f, -0.14019766f, 0.05293100f, 0.25429666f, 0.03805828f, 0.11111385f, -1.09321165f, 
    -0.08724649f, -0.38280347f, -0.10995347f, -0.26694179f, 0.07982644f, 0.06722728f, 0.15039442f, 0.24638757f, 
    -0.13029732f, -0.54085904f, 0.15273882f, -0.29308647f, -0.29730269f, 0.13028541f, 0.16389266f, -0.36826140f, 
    -0.07033148f, 0.00595583f, -0.60877860f, -0.11777403f, -0.12794751f, -0.07682016f, -0.82703137f, 0.19312482f, 
    0.07183040f, 0.12339417f, 0.06766054f, 0.17897493f, 0.82825905f, -0.16519597f, -0.35699496f, 0.00835477f, 
    -0.89604342f, -0.22580698f, -0.52255803f, -0.06711151f, -0.14187232f, -0.06893504f, -0.18536152f, 0.08725702f, 
    -1.48275518f, -0.19034533f, 0.05343330f, 0.07765839f, -0.05275459f, -0.25768214f, 0.20463701f, -0.31209952f, 
    -0.03339982f, 0.07567441f, -0.12109225f, 0.11059687f, 0.82276416f, 0.08886857f, 0.05801071f, 0.01059277f, 
    0.00767779f, 0.22982828f, -0.30435273f, 0.06992068f, 0.53292227f, 0.02974346f, -0.04432048f, -0.34076226f, 
    -0.08386011f, -0.06850205f, -0.07387086f, -0.47286925f, -0.22817454f, -0.09617846f, -0.59772491f, 0.07587114f, 
    0.18410783f, -0.05565950f, -0.25600064f, -0.38860011f, -0.28310689f, -0.23230807f, -0.50385344f, 0.18248791f, 
    0.21981995f, -0.06404083f, -0.45763534f, -0.25436065f, 0.22222579f, 0.26557794f, 0.20139389f, 0.11481702f, 
    0.10448429f, -0.13740498f, 0.03210612f, -0.20856243f, -0.13319857f, -0.16261441f, 0.16884135f, -0.45615432f, 
    -0.13001691f, 0.30968109f, -0.35517523f, 0.58561271f, 0.00454911f, 0.35259512f, -0.76545841f, -0.16213244f, 
    0.16770296f, 0.14352226f, -0.34459287f, -0.31398243f, 0.03488658f, 0.00354596f, 0.39193064f, -0.11544061f, 
    -0.16511643f, -0.21887197f, 0.22175236f, 0.21959104f, 0.09177186f, -0.32472861f, 0.18861641f, -0.23478411f, 
    0.10730991f, 0.44023263f, -0.06429463f, 0.13809074f, 0.08021950f, -0.68734998f, 0.10213490f, 0.22012877f, 
    -0.56502825f, 0.18109375f, -0.10872921f, 0.11244276f, -1.52597857f, 0.03386280f, 0.09887422f, -0.48649523f, 
    0.30604693f, -0.05135214f, -0.13536799f, 0.14414302f, 0.11812500f, -0.47472230f, -0.09797041f, -0.54900706f, 
    0.04641247f, 0.34765843f, -0.00443985f, 0.02561595f, -0.50160080f, 0.32068932f, 0.62972832f, 0.01605647f, 
    0.24749872f, 0.12761004f, 0.17702696f, -0.02575359f, 0.33725038f, 0.25959074f, 0.28178251f, 0.02476192f, 
    0.09835749f, -0.42920914f, 0.43773764f, 0.09821262f, -0.45883396f, 0.09321889f, 0.16405779f, -0.25236315f, 
    -0.16885097f, -0.22750428f, -0.08487392f, -0.81192499f, 0.29659387f, -0.06370791f, -0.09153387f, 0.04381700f, 
    0.04158268f, -0.44029748f, 0.05770841f, 0.21050742f, 0.33746719f, -0.68078190f, -0.79291391f, -0.14118455f, 
    -0.26938194f, -0.54911745f, 0.44520706f, -0.42472097f, -0.06022818f, -0.46161193f, 0.36524281f, -0.54656005f, 
    -0.17507389f, -0.00181852f, -0.16880140f, 0.08395854f, -0.61447471f, 0.03980802f, 0.18315224f, 0.10203277f, 
    -0.02466335f, -0.10792145f, 0.14539382f, -1.20219183f, -0.42532256f, -0.26275730f, 0.25438100f, -0.35314655f, 
    -0.09895733f, -0.00801413f, -0.37242857f, 0.21912663f, -0.06798827f, -0.31920826f, -0.35066360f, -0.08769617f, 
    -0.67256624f, -1.24000382f, -0.14316282f, 0.38402352f, 0.24742709f, 0.10983428f, 0.27324313f, 0.02906936f, 
    -0.07817046f, -0.69299036f, -0.31975541f, 0.29752609f, -0.04992709f, 0.58877116f, -0.33614647f, -0.29722324f, 
    -0.14314699f, 0.04212440f, 0.23301247f, -0.12285317f, -0.75627762f, -0.10466856f, 0.30042636f, -0.03233219f, 
    -0.96680784f, -0.08349586f, -0.45729810f, -0.57215208f, -0.27665731f, 0.34789786f, -0.11270600f, -0.85157436f, 
    0.18719909f, 0.13196285f, 0.11518789f, 0.21933052f, -0.40022191f, -0.93476641f, -0.45059285f, -0.23935507f, 
    -0.49095586f, -0.20127037f, 0.08602279f, -0.25580347f, -0.19811583f, -0.12099301f, 0.28396994f, -0.47987610f, 
    -0.03517063f, 0.46180156f, -0.06822922f, -0.12597449f, 0.24576710f, -0.22510727f, -0.03108387f, -1.42539907f, 
    0.39426914f, -0.26347497f, 0.12065876f, 0.02478819f, 0.03292578f, 0.08001259f, -0.10673977f, 0.18619435f, 
    -0.03692861f, -0.10745408f, -1.50906491f, 0.37697643f, -0.02556347f, 0.06813681f, 0.06067585f, 0.01196029f, 
    0.04304391f, 0.15304412f, -0.15930843f, 0.01739620f, -0.28337467f, 0.02110999f, 0.18740280f, 0.07019387f, 
    0.82879752f, 0.03190886f, 0.15670745f, 0.11404486f, -0.36177638f, -0.19448742f, -0.01150974f, 0.20172423f, 
    0.01282859f, 0.05804816f, 0.01554263f, 0.05264845f, 0.15147074f, 0.25103408f, -0.04589128f, 0.11821418f, 
    -0.17064942f, 0.08168659f, -0.22653632f, -0.19021635f, -0.21511477f, 0.11845683f, 0.02795166f, 0.71526021f, 
    -0.68970650f, 0.02414992f, 0.18878394f, 0.14393808f, 0.20037514f, -0.06861306f, 0.24071817f, -0.15226275f, 
    -0.42901856f, 0.05921157f, -0.18524766f, -0.03895907f, -0.24161640f, 0.15040357f, -0.07222508f, -0.11301264f, 
    -0.08225544f, 0.01335541f, 0.00433170f, -0.35566232f, -0.36599261f, -0.06994107f, -0.02159740f, -0.38978872f, 
    0.33198622f, -0.84432691f, 0.01566960f, -0.66858178f, -0.07404596f, -0.13040459f, -0.29168350f, 0.04755006f, 
    0.24654290f, -0.46615317f, -0.21054779f, -0.78334486f, -0.03811983f, 0.29268217f, 0.56626344f, 0.04326058f, 
    -0.54381621f, -0.64748067f, -0.00941228f, -0.54797518f, -0.14459722f, 0.05900753f, 0.18610232f, -0.08483206f, 
    -0.06624458f, -0.07353611f, -0.55065995f, 0.18958628f, 0.13345863f, -0.36583939f, -0.52533835f, 0.28594607f, 
    0.04396516f, -0.07108008f, 0.29246625f, -0.74303025f, 0.23130822f, 0.15838988f, -0.29505628f, -0.56463808f, 
    0.02916220f, -0.23497210f, 0.07930204f, -0.02056269f, 0.33854896f, -0.01339038f, 0.04716083f, -0.04341833f, 
    -0.64811486f, -0.15373869f, 0.10704200f, 0.22213994f, 0.21770135f, 0.15652226f, -0.73987925f, -0.57874769f, 
    0.32187128f, 0.17682254f, 0.22670108f, 0.12967171f, 0.14607415f, -0.16093604f, -0.29827839f, -0.08935729f, 
    0.20679229f, -0.11936668f, 0.39554995f, -0.01876485f, -1.19268191f, 0.33992499f, 0.16030094f, 0.29981819f, 
    0.03165781f, -0.13439505f, 0.02875566f, -0.20101993f, 0.29435506f, -0.11620509f, -0.12549862f, -0.56120902f, 
    -0.64667517f, 0.10488660f, -0.73928899f, -0.00537779f, -0.01360186f, -0.07901717f, -0.65993971f, 0.21540582f, 
    0.04237217f, -0.31894860f, -0.08932053f, -0.08526549f, -0.23094846f, 0.08636537f, 0.13484851f, 0.14601280f, 
    -0.02797914f, -0.37788162f, -0.12715949f, 0.16691758f, 0.38145873f, -0.06847014f, -0.30680877f, -1.04556859f, 
    0.33398664f, 0.01770413f, -0.87388831f, 0.00612868f, -0.00990038f, -0.35635656f, -0.16884495f, 0.12490109f, 
    -0.04715420f, 0.00011066f, -0.40303999f, 0.04636905f, 0.15556754f, 0.35371605f, 0.16845758f, 0.08923971f, 
    -0.02017768f, 0.04162103f, 0.44400248f, 0.09243838f, -0.15129040f, 0.06319421f, 0.09283105f, -0.36177146f, 
    0.23310128f, 0.22991601f, 0.01368690f, 0.08272272f, 0.11334752f, -0.35212335f, 0.05693599f, -0.20569795f, 
    -0.34361005f, 0.33753875f, 0.01912694f, -0.76861328f, 0.06978262f, -0.64457625f, -1.05450070f, -0.16106559f, 
    0.15069857f, 0.19806156f, -0.02015810f, -0.09955651f, -0.02035737f, -0.00551288f, -0.73712051f, -0.30901733f, 
    0.23440494f, -0.22767869f, 0.06922187f, -0.43988147f, -0.13700743f, -0.08364840f, -0.44985867f, 0.10794288f, 
    -1.11223185f, -0.42184219f, 0.06480516f, -0.57018584f, -0.54776543f, 0.03684238f, -0.00572457f, -0.07829057f, 
    0.12339840f, 0.14487547f, 0.05881194f, -0.01843902f, -1.13648808f, -0.13247204f, -0.64454758f, -0.20964579f, 
    0.03050281f, -0.53179014f, -0.26032251f, 0.01907979f, 0.04082541f, -0.40952539f, 0.23986833f, -0.79279065f, 
    -0.66543555f, -0.21567099f, 0.06764132f, -0.04485976f, -0.14958331f, -0.04849771f, 0.62277013f, 0.13349001f, 
    -0.07286108f, -0.07586810f, -0.07056566f, -0.58527595f, -0.31976986f, 0.16229115f, -0.11803906f, -0.32744244f, 
    0.25844580f, 0.36460006f, 0.12557766f, -0.07125559f, -0.07653791f, 0.04526289f, -0.30152857f, -0.12740456f, 
    -0.11413853f, 0.00756116f, 0.09459025f, 0.05177319f, 0.21747239f, 0.07584818f, -0.11763436f, -0.16460536f, 
    -0.01829082f, -0.51103920f, -0.01643908f, -0.05346584f, -0.27509901f, -0.02542844f, 0.00848692f, 0.07842969f, 
    0.46767733f, -0.07486811f, 0.27500135f, 0.14060451f, 0.11145677f, -0.06081248f, -0.12475689f, -0.16456470f, 
    -0.14705658f, -0.07583674f, 0.36478513f, -0.03643530f, 0.05279611f, 0.02792263f, 0.23207156f, 0.19522500f, 
    -0.41656986f, 0.16957535f, 0.40680322f, 0.05811530f, -0.09477372f, 0.10268806f, 0.06646343f, -0.02189186f, 
    0.09410364f, 0.03997938f, 0.04655129f, 0.02184580f, -0.28707492f, 0.04721447f, -0.04846238f, -0.49457157f, 
    0.08924881f, 0.10631739f, 0.10420281f, 0.02625900f, -0.13733770f, 0.12969288f, 0.02645552f, 0.00349001f, 
    -0.16540478f, -0.34955162f, 0.26901466f, -0.87392288f, -0.03634556f, 0.03494577f, -0.33925083f, -0.10535350f, 
    0.07046107f, 0.08097455f, -0.00624832f, 0.24311613f, 0.08316835f, 0.19167177f, -0.30335671f, 0.14435950f, 
    0.10732689f, 0.25654253f, 0.13670479f, -0.22979702f, 0.14540939f, -0.09716252f, -0.39561865f, 0.08010890f, 
    -0.00455195f, 0.56743580f, -0.13541007f, -0.07115106f, -0.01057283f, 0.16934955f, -0.24719977f, -0.02906206f, 
    -0.11489228f, 0.08033130f, -0.18442455f, -0.27911502f, -0.89607990f, 0.10865602f, 0.12338822f, 0.13267861f, 
    0.04118792f, -0.09168873f, 0.02049842f, -0.00782237f, -0.12521353f, -0.02189492f, 0.30057496f, 0.31579575f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.15772532f, -0.19100247f, -0.17728457f, -0.07480765f, 0.11676923f, 0.04281731f, 0.07825725f, -0.52961367f, 
    -0.25682253f, 0.19291052f, 0.06970875f, -0.02220194f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
