#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.80991328f, 0.38062027f, -0.44609919f, 0.18738121f, 0.18270902f, -0.34262627f, -0.36586052f, -0.16148958f, 
    -0.33745286f, -0.35645229f, -0.26520136f, -0.42079088f, 0.03363491f, 0.08058828f, -0.71232891f, 0.06206843f, 
    -0.19773184f, -0.10876405f, -0.93243170f, -0.63298702f, 0.80769658f, 0.76279193f, -0.31402516f, 0.14914393f, 
    -0.29291880f, 0.25955656f, -0.29635537f, 0.22706871f, 0.27685356f, 0.33629957f, 0.03217170f, -0.37860790f, 
    0.55028725f, 0.38787493f, -0.56549013f, -0.52434087f, -0.25047415f, 0.63536054f, 0.31764674f, -0.66539907f, 
    -0.19037835f, 0.59387583f, -0.51838291f, 0.35567603f, 0.35706133f, -1.00282371f, -0.75468236f, -0.43688384f, 
    0.56150937f, 0.26807839f, 0.14653316f, 0.08303122f, 0.63424748f, 0.53524941f, 0.27995333f, 0.77946627f, 
    0.43209109f, -0.29841524f, -0.59809715f, -0.45955741f, 0.18310702f, 0.54732388f, -0.34901199f, 0.16276576f, 
    0.12514076f, -0.26979223f, -0.52889556f, -0.68875611f, -0.49678543f, 0.12800552f, -0.44647464f, -0.24537979f, 
    0.09438805f, -0.33213884f, -0.19374779f, 0.64824724f, -0.44860044f, -0.38678449f, -0.15901692f, -0.19599292f, 
    -0.26149586f, -0.47502285f, 1.27762234f, -0.89211184f, 0.25177875f, 0.19666940f, 0.53581429f, -0.18400015f, 
    -0.00822212f, 0.17245398f, -0.38695353f, 0.41171947f, -0.19287011f, 0.33962601f, 0.17088832f, 0.72383970f, 
    -0.63444924f, -0.58207953f, -0.24791284f, 0.03966584f, -0.10408708f, -0.41359013f, -0.41391060f, -0.41068169f, 
    0.37173134f, 0.13851528f, 0.39494440f, 0.60540974f, -0.39122015f, 0.64473301f, 0.36655682f, -0.22173868f, 
    -0.46514070f, -0.36394683f, -0.21615809f, -0.32424214f, -0.39625716f, 0.11984956f, 0.21097586f, -0.02449248f, 
    -0.17645207f, 0.15201589f, 0.20898002f, 0.21812837f, 0.49272254f, 0.55464309f, -0.14262451f, 0.29400617f, 
    0.46278888f, 0.15536135f, 0.31117743f, -0.43379018f, -0.08504295f, -0.11188182f, -0.00127844f, 0.03273527f, 
    -0.76765418f, 1.01248157f, -0.37236077f, -0.75630355f, 0.61264026f, 0.28096920f, 0.02228170f, -0.02871455f, 
    -0.36053303f, 1.11122119f, -0.73876578f, -0.44743431f, -0.00718682f, -0.04005961f, 0.17542951f, -0.19163266f, 
    0.48197389f, -0.66734725f, -0.41407177f, -0.55497378f, 0.47787702f, 0.59685981f, 0.04208992f, -0.02794469f, 
    -0.23590307f, -0.43440187f, -0.22358671f, -0.22103333f, -0.35592315f, -0.55455935f, -0.68286371f, 0.00364955f, 
    -0.17522949f, -0.39771956f, 0.70000237f, 0.38801199f, 0.48070070f, 0.60317427f, 0.32201734f, 0.34027460f, 
    0.01510363f, 0.46587908f, -0.47439355f, -0.42785826f, 0.70882177f, -0.50406134f, -0.07142614f, 0.36680436f, 
    -0.23342969f, 0.13048066f, 0.02178600f, 0.12701698f, -0.15588704f, 1.04588675f, 0.38573501f, -0.22053201f, 
    -0.04092679f, -0.29691234f, -0.40706620f, -0.01772549f, 0.20042843f, 0.09720602f, -0.40060189f, -0.66201192f, 
    -0.44576323f, 0.87171346f, 0.35191399f, 0.31737456f, -0.15758669f, -0.31719851f, 0.10133711f, -0.75676763f, 
    0.09888124f, 0.17302896f, -0.59586889f, -0.67782086f, -0.31846002f, 0.56723267f, 0.06623427f, 0.01969238f, 
    0.39906684f, -0.22242889f, -0.07373391f, 0.51755768f, 0.52244711f, -0.07436815f, 0.19806510f, 0.57062578f, 
    0.04869489f, -0.46367258f, 0.07037555f, 0.27653137f, -0.09253480f, -0.73938441f, -0.43518782f, -0.17291537f, 
    0.03460156f, -0.15475497f, 0.30546299f, 0.48496553f, -0.58402306f, 0.68999010f, -0.76289207f, -0.12257598f, 
    -0.18311803f, 0.28607440f, 0.09428445f, 0.13771752f, 0.43458623f, 0.62677419f, -1.11917424f, 0.32883221f, 
    -0.26617110f, 0.34609145f, 0.09936058f, 0.19683152f, 0.73661274f, -0.82349658f, 0.57383013f, -0.45178458f, 
    0.54159033f, -0.31324276f, 0.20020291f, -0.36335585f, 0.05996696f, -0.87210071f, 0.41860488f, 0.42071247f, 
    -0.17415175f, -0.13563988f, 0.00574762f, 0.00318881f, -0.71265793f, -0.21856077f, 0.47026175f, -0.95538849f, 
    0.64643610f, -0.29676744f, -0.38235286f, 0.45529103f, -0.14108938f, -0.09146237f, 0.23343775f, -0.66421580f, 
    -0.63302732f, 1.06263459f, -0.52120548f, -0.19866022f, 0.13354403f, 0.14604414f, 0.13615498f, -0.08664853f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29248464f, -0.36666888f, -0.26215607f, -0.23711818f, 0.42157611f, 0.51119578f, -0.01526012f, 0.25768256f, 
    0.41199332f, 0.14802849f, -0.17957902f, 0.39022782f, -0.24276938f, 0.27751121f, 0.24084854f, -0.02448221f, 
    0.18007293f, -0.11376820f, -0.09695824f, -0.06692331f, 0.25232571f, 0.32448748f, 0.21293345f, 0.10822611f, 
    -0.05020700f, 0.18603213f, 0.19584480f, -0.04903879f, -0.12708253f, 0.27685046f, 0.37724692f, 0.07085932f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.23316069f, -0.13654229f, -0.06818955f, 0.00928261f, -0.05966404f, 0.06084717f, -0.02663555f, 0.18488652f, 
    0.18723024f, -0.22682330f, -0.44097134f, -0.24516957f, 0.07481108f, 0.07492556f, 0.15039627f, -0.07921201f, 
    -0.13510241f, 0.09878860f, -0.12465707f, 0.10004197f, -0.43744177f, 0.28338212f, -0.09232888f, 0.06092186f, 
    0.09897282f, -0.04504985f, 0.27740598f, 0.10849866f, 0.36667913f, 0.08926962f, -0.14933020f, -0.04110862f, 
    -0.17777215f, 0.02315799f, -0.06632295f, 0.04235329f, 0.22107235f, -0.17542815f, 0.06192472f, -0.13038504f, 
    0.04877749f, 0.00082827f, 0.04815771f, 0.07439695f, -0.20922364f, -0.08872543f, -0.33180565f, -0.35071880f, 
    0.15711898f, -0.12436660f, 0.07374328f, -0.08083254f, -0.01559430f, -0.10614099f, 0.07270788f, 0.29324561f, 
    0.21061210f, 0.00051229f, 0.04279249f, 0.05183797f, -0.06919412f, 0.07595059f, -0.06160585f, -0.05198143f, 
    0.00100426f, 0.11737833f, 0.08922797f, 0.03338839f, 0.03112758f, 0.08708929f, 0.00578474f, 0.09430117f, 
    -0.25877130f, 0.22993433f, -0.15267691f, 0.02202403f, -0.01833554f, 0.00988181f, -0.05769539f, 0.00882159f, 
    -0.01876477f, 0.09147994f, -0.19263320f, -0.09937437f, 0.04837345f, 0.16122539f, 0.10163716f, 0.12198949f, 
    0.05639928f, -0.08925790f, -0.00301887f, -0.27336133f, 0.01180023f, -0.00884390f, 0.09055918f, 0.14670746f, 
    0.05192363f, 0.14889105f, 0.09086175f, -0.08780697f, -0.14697973f, 0.11739147f, 0.08208650f, 0.05459265f, 
    -0.05783082f, -0.18035005f, -0.14011846f, -0.14543495f, 0.16901629f, 0.09402527f, 0.17111577f, 0.09395251f, 
    0.02097755f, 0.00833304f, -0.13266526f, 0.02823872f, 0.07040174f, 0.04637996f, -0.15186206f, 0.05291753f, 
    -0.02892984f, 0.02820811f, 0.00416647f, -0.04146596f, -0.17361695f, -0.08330853f, 0.14810067f, 0.17591834f, 
    0.04040472f, -0.03655948f, -0.02788320f, 0.00446172f, 0.00856000f, -0.03286887f, -0.04438274f, 0.25999731f, 
    0.22087371f, 0.14785174f, 0.21967834f, 0.10713435f, -0.17732322f, 0.25283614f, -0.19754647f, 0.05872414f, 
    0.07502721f, 0.00698330f, 0.00897082f, -0.04461195f, 0.10884019f, -0.18421242f, -0.10863844f, 0.10977514f, 
    -0.04547302f, -0.30225202f, -0.36560157f, -0.39018309f, 0.10173853f, -0.07893048f, 0.18855371f, 0.08313684f, 
    0.09103661f, 0.12926021f, 0.08594899f, -0.10165145f, -0.03625682f, 0.08634156f, -0.03917386f, 0.09456255f, 
    -0.12528028f, -0.07799999f, -0.07570588f, -0.02274066f, 0.32581285f, 0.03481723f, -0.01725463f, -0.11090937f, 
    -0.04883270f, 0.02396330f, -0.12192869f, -0.04791005f, -0.01370167f, 0.09288933f, 0.04576253f, -0.00063770f, 
    0.20138893f, -0.08864742f, 0.11894869f, 0.08358607f, 0.08785782f, 0.26523551f, 0.19752321f, 0.08780301f, 
    -0.08572976f, 0.12025660f, -0.06673279f, 0.01412732f, -0.07144215f, -0.20591399f, -0.34254649f, -0.38767973f, 
    -0.36823022f, 0.01925891f, -0.14975320f, 0.14611530f, 0.03547362f, 0.15396716f, 0.08997396f, -0.00535925f, 
    -0.03788457f, 0.18082102f, 0.07468190f, -0.04401309f, -0.00327835f, 0.09388629f, 0.04331333f, -0.10047483f, 
    -0.05448762f, 0.01186345f, -0.20550133f, 0.05614091f, 0.10643532f, 0.00890338f, -0.10668580f, -0.06984638f, 
    -0.28653052f, 0.00458334f, 0.10543419f, 0.12116282f, 0.03114590f, -0.08132945f, -0.00328295f, 0.05798901f, 
    0.00054223f, 0.08614451f, 0.08280268f, 0.37358752f, 0.02384194f, -0.05973166f, 0.16201538f, 0.19354934f, 
    0.06619503f, -0.04349311f, -0.16505875f, 0.10131343f, 0.29898706f, 0.23319271f, 0.19840229f, 0.02453418f, 
    0.19624603f, 0.11762868f, 0.06935259f, -0.15574370f, 0.11780444f, 0.27096176f, -0.06251398f, 0.16530728f, 
    -0.10318413f, -0.00362773f, 0.09441628f, -0.15433687f, -0.14569861f, 0.11838164f, 0.24304222f, 0.13026248f, 
    -0.03720119f, 0.05257763f, 0.12587847f, -0.07404918f, 0.06641167f, 0.10670892f, 0.07271903f, 0.06880084f, 
    0.07368509f, 0.15923795f, 0.10077463f, -0.11700854f, 0.10448467f, -0.07908893f, 0.04358050f, 0.00295411f, 
    -0.30684862f, 0.18823217f, 0.16601422f, 0.14607510f, 0.03218755f, 0.11894746f, -0.04647103f, 0.12907417f, 
    0.01399444f, 0.09832302f, 0.09142347f, -0.08674254f, 0.01089622f, 0.00606581f, 0.01576713f, 0.09901246f, 
    -0.08333725f, 0.22400647f, -0.06318863f, 0.02186639f, 0.12488795f, -0.02098722f, 0.08129065f, -0.01948471f, 
    -0.11370390f, -0.08346936f, 0.19585487f, 0.08221026f, 0.26146737f, 0.03104998f, -0.19031005f, 0.10986659f, 
    0.02488247f, 0.09027421f, -0.05958921f, -0.21418101f, -0.13216983f, -0.09369152f, -0.00355562f, -0.02753532f, 
    -0.12816830f, 0.07602314f, -0.01034197f, 0.10554318f, -0.06175788f, -0.27531713f, -0.11179293f, -0.07668746f, 
    0.10661768f, -0.11942644f, -0.06813228f, 0.06185802f, 0.10151307f, 0.04510048f, 0.06748608f, -0.02532378f, 
    0.16716674f, 0.02791923f, 0.05983534f, 0.00410487f, 0.06076583f, 0.18010157f, 0.27724132f, -0.11405107f, 
    0.02047374f, 0.05809077f, 0.06775432f, -0.26402527f, 0.00981170f, 0.00299400f, 0.06750613f, 0.01374670f, 
    0.24167445f, 0.12585685f, -0.02399327f, 0.09689625f, 0.03746542f, -0.00941947f, -0.15465634f, 0.06906008f, 
    0.22935738f, 0.03798731f, 0.10512151f, 0.13322850f, 0.02639536f, 0.09032342f, -0.04376994f, -0.08009644f, 
    0.02223117f, -0.01355983f, -0.11679682f, -0.38200974f, -0.26859918f, -0.08092238f, -0.06072024f, 0.08857228f, 
    -0.11868914f, 0.09375542f, 0.09953130f, -0.03619774f, 0.12235277f, -0.02669307f, 0.01867436f, -0.07448801f, 
    0.00410470f, 0.07737543f, 0.08036526f, 0.35166848f, 0.29967302f, 0.09400231f, -0.03463665f, -0.03191569f, 
    -0.01193911f, 0.06430518f, -0.04364410f, 0.01299551f, 0.01933646f, 0.09023576f, 0.06236533f, -0.06755216f, 
    0.00639767f, -0.05240266f, 0.02338064f, -0.07847232f, 0.01496782f, 0.13048342f, -0.01519181f, -0.16717197f, 
    -0.04004182f, -0.05951133f, 0.00902284f, 0.01853295f, 0.05125618f, 0.02452802f, -0.16425866f, -0.08854292f, 
    -0.05281007f, 0.07889657f, -0.02647951f, -0.03747117f, 0.11727200f, 0.02110135f, -0.06029793f, -0.08901709f, 
    -0.32068485f, -0.05390509f, -0.04610587f, 0.05491780f, 0.00260885f, 0.12561308f, -0.05505574f, 0.17055860f, 
    0.31812790f, 0.21532577f, -0.28320876f, -0.19544291f, -0.02409592f, 0.00547920f, 0.10303391f, 0.01030434f, 
    -0.08683362f, 0.23840128f, -0.05415503f, 0.06124601f, -0.02289006f, -0.10716140f, 0.01940583f, -0.08727270f, 
    0.00753083f, 0.01681447f, 0.11595923f, 0.17776451f, 0.04107087f, 0.03532299f, -0.01409215f, -0.02182534f, 
    0.13141459f, -0.02358976f, -0.04893708f, -0.26067573f, -0.26088801f, -0.12958400f, 0.13895325f, -0.06429401f, 
    -0.07463454f, -0.01322271f, -0.03634699f, -0.03811422f, 0.06957332f, -0.21087895f, -0.32977533f, 0.07761747f, 
    0.03265426f, -0.05927861f, 0.06247080f, -0.03351533f, 0.07888746f, -0.17829677f, -0.21460432f, -0.35923037f, 
    -0.04797702f, 0.15588829f, 0.00711112f, -0.00369934f, 0.07953898f, 0.04668842f, 0.22426000f, -0.14785431f, 
    0.06335883f, -0.03674378f, 0.00624511f, 0.01090457f, 0.01147664f, 0.15804657f, 0.01443857f, 0.27389136f, 
    0.23574260f, 0.36563280f, -0.19935569f, 0.16640368f, -0.21511337f, -0.08734718f, -0.00837633f, -0.03698615f, 
    -0.16400360f, -0.09197978f, -0.30111873f, 0.03236054f, -0.04139582f, 0.01741854f, 0.17825510f, 0.04692113f, 
    0.12464404f, 0.09217628f, 0.13991393f, 0.13607867f, -0.13027121f, 0.13693267f, -0.03179892f, -0.01976754f, 
    -0.09175225f, 0.13944089f, -0.11603424f, 0.11032260f, -0.45092791f, 0.00354730f, 0.12810825f, -0.01871166f, 
    -0.00998932f, -0.09014157f, 0.14528820f, 0.02967058f, -0.27652210f, 0.15093517f, 0.04458567f, 0.20465457f, 
    -0.25180945f, 0.05531124f, 0.04828648f, 0.09552658f, -0.08732856f, -0.19991347f, -0.17882246f, 0.03440062f, 
    0.01256706f, -0.08846416f, 0.06628427f, 0.07793371f, -0.08280820f, 0.00641019f, 0.06240306f, 0.16343372f, 
    0.04521331f, -0.02602434f, -0.03549600f, 0.02524298f, -0.09226935f, 0.01471394f, -0.04638789f, -0.22915450f, 
    -0.12262632f, 0.07107754f, 0.26228774f, -0.00750510f, 0.11056601f, 0.05065991f, 0.11439708f, 0.23410617f, 
    0.13835226f, 0.28890365f, -0.00090622f, -0.01673683f, -0.02698992f, 0.01048787f, -0.01117416f, -0.00258533f, 
    -0.07341253f, 0.14089313f, 0.14588362f, 0.08688215f, 0.12758100f, 0.11254200f, 0.29547882f, 0.15656723f, 
    -0.00351398f, -0.19985299f, 0.15015143f, 0.18165126f, -0.07891931f, -0.05348838f, -0.12620014f, -0.03025390f, 
    0.04199407f, -0.34756809f, -0.50878274f, -0.21140809f, 0.05380101f, -0.11498308f, -0.07373700f, -0.01395341f, 
    0.22735240f, 0.03818897f, 0.09192707f, -0.41544950f, -0.09098490f, -0.12444142f, -0.10484960f, -0.04364022f, 
    -0.02450352f, -0.19188720f, 0.02707394f, 0.02167423f, -0.01887435f, -0.21603200f, -0.12735213f, 0.11568645f, 
    -0.03716801f, 0.12106427f, 0.14889111f, 0.08469839f, 0.02910549f, 0.12630214f, -0.05092090f, 0.33169913f, 
    -0.10536832f, 0.06828515f, 0.05999193f, 0.01282750f, 0.08643454f, 0.19463719f, -0.06137452f, -0.29838565f, 
    -0.01272101f, -0.12561817f, -0.09213752f, 0.11780623f, -0.21182467f, -0.22695792f, 0.06985626f, 0.25862494f, 
    0.40308344f, 0.04407360f, -0.07377288f, 0.00651236f, 0.05093787f, 0.02769239f, -0.04038011f, -0.26523137f, 
    0.16100228f, 0.21893428f, 0.13414003f, 0.18985373f, 0.20046847f, 0.03735707f, 0.27111477f, 0.01417999f, 
    -0.11327024f, -0.06912655f, -0.25599831f, -0.36012369f, -0.15157300f, -0.23506927f, -0.01194199f, 0.14657570f, 
    0.05743828f, 0.02724302f, -0.27616057f, -0.04034751f, -0.23367585f, -0.05697253f, -0.06835794f, -0.04806015f, 
    0.15608113f, -0.06709846f, -0.10797825f, 0.14609805f, 0.11128527f, 0.25504154f, -0.07722908f, 0.07824988f, 
    0.10185501f, -0.09899200f, -0.04618480f, -0.05976380f, -0.11719406f, 0.10649718f, 0.02333098f, -0.08595148f, 
    -0.13210547f, 0.11296330f, -0.04019072f, 0.03632107f, -0.30056819f, 0.02907905f, -0.02345119f, -0.03060845f, 
    -0.11843970f, -0.00125758f, 0.10340258f, 0.06677254f, -0.17790848f, 0.04245801f, -0.16159141f, -0.23087102f, 
    -0.18140085f, 0.13064639f, -0.08569486f, 0.19286008f, 0.07741805f, 0.00241578f, -0.02305732f, -0.32566696f, 
    -0.25696701f, -0.20636211f, -0.12429828f, 0.15180457f, -0.08052833f, 0.01271342f, 0.18078880f, -0.04837863f, 
    0.06012259f, 0.03772372f, -0.20756125f, 0.11181322f, 0.03078747f, 0.11136732f, -0.04121811f, -0.06440639f, 
    -0.01851593f, -0.31881210f, 0.03579031f, 0.21436642f, -0.00890256f, 0.07722817f, -0.05300667f, 0.20111352f, 
    -0.09769950f, 0.00561169f, 0.00342927f, 0.32535535f, 0.15097804f, -0.08771218f, 0.17806448f, 0.00061696f, 
    0.14272158f, 0.05515090f, -0.12822035f, -0.31480396f, -0.14886978f, -0.10829554f, -0.01753993f, -0.09059252f, 
    -0.04172223f, -0.15395629f, -0.13289319f, 0.09648415f, 0.38285494f, -0.25466207f, -0.08116643f, 0.01887330f, 
    0.05861327f, -0.06774491f, 0.13844395f, 0.01720628f, 0.04788844f, -0.03483818f, -0.50680214f, -0.27059901f, 
    0.06019967f, 0.19823237f, -0.04247135f, 0.15563074f, -0.15564480f, 0.16571295f, -0.09310026f, 0.05482930f, 
    0.15691598f, -0.09242255f, 0.06854974f, -0.07746113f, 0.16835675f, 0.11179895f, 0.13562128f, -0.00680704f, 
    0.14774914f, 0.09982882f, 0.07402875f, -0.01654570f, 0.01421218f, -0.01779780f, -0.08149292f, -0.20440949f, 
    -0.08063517f, -0.37222117f, -0.15344630f, -0.18483998f, -0.23911808f, 0.03116744f, 0.14571434f, -0.02339442f, 
    0.07005344f, -0.07656815f, 0.14944719f, 0.08235116f, -0.08454438f, 0.03989991f, 0.02624962f, 0.02046510f, 
    -0.00785771f, -0.11832397f, 0.12366968f, -0.14327495f, -0.22717988f, 0.08298693f, 0.04861689f, -0.01995572f, 
    0.09085306f, 0.09677070f, 0.08758350f, -0.38234800f, -0.26920438f, -0.12204243f, 0.00884671f, -0.01389362f, 
    -0.10155486f, -0.09746217f, -0.12930404f, -0.10790979f, -0.19372647f, -0.41614914f, -0.34330040f, -0.02605299f, 
    0.20140101f, -0.36642680f, -0.16750559f, -0.02543674f, 0.01740291f, -0.26669270f, 0.00002597f, -0.04244857f, 
    0.00610928f, -0.14220692f, 0.18988733f, 0.32151774f, -0.16655931f, -0.05181148f, 0.14915130f, -0.10391351f, 
    -0.20445739f, 0.01993821f, 0.29063118f, -0.04825262f, 0.22417048f, 0.18331653f, -0.01459189f, 0.10210895f, 
    0.02287092f, 0.04451454f, 0.10273378f, 0.09892405f, 0.15064177f, 0.13614093f, 0.06894123f, -0.06440254f, 
    0.17351079f, -0.12616111f, -0.10512333f, 0.18840022f, 0.07419159f, 0.14286058f, 0.04852102f, 0.05136772f, 
    0.04997617f, -0.16819154f, 0.01719713f, -0.16397876f, 0.05979548f, -0.17694288f, 0.15683116f, -0.13575512f, 
    -0.02980102f, -0.02530370f, -0.34515005f, 0.03916944f, -0.69964153f, 0.30151954f, -0.28744659f, 0.15123622f, 
    0.18566009f, -0.02096814f, -0.03812546f, -0.24493434f, 0.13973320f, 0.15961766f, -0.01473696f, -0.06593469f, 
    -0.17586014f, 0.01650879f, 0.10818789f, 0.04029457f, 0.36957785f, 0.14667942f, 0.17228012f, -0.07068099f, 
    -0.04950619f, 0.06549781f, -0.08488549f, 0.06173486f, -0.00936229f, -0.00022560f, -0.31921244f, -0.35695216f, 
    0.11605856f, -0.02372123f, 0.04476573f, -0.02325509f, 0.01163106f, 0.10507198f, -0.13968778f, 0.14576457f, 
    0.26843047f, -0.06849931f, -0.00752115f, -0.11372062f, 0.04237428f, -0.08230494f, -0.14739789f, 0.00565439f, 
    -0.14678235f, 0.06436388f, -0.02831017f, -0.04867686f, 0.05912874f, 0.07773302f, 0.21701039f, 0.00850823f, 
    -0.17031924f, 0.15053064f, -0.09384698f, 0.06382819f, -0.11802186f, 0.20591904f, 0.07032376f, 0.10185049f, 
    0.00323934f, -0.19208001f, -0.47660583f, -0.12782422f, 0.03868721f, -0.10111830f, 0.03883731f, 0.15192416f, 
    -0.05479913f, -0.01314319f, -0.01074724f, -0.16645372f, 0.03564567f, -0.21589582f, 0.06447741f, 0.01508186f, 
    0.07426637f, 0.19122629f, 0.01634156f, 0.18741597f, -0.15680374f, 0.12046304f, -0.04655007f, 0.13215718f, 
    0.12418770f, -0.11571116f, -0.03420762f, -0.12326198f, 0.24422319f, 0.02603550f, 0.18374413f, 0.05248015f, 
    -0.07356635f, 0.04292854f, -0.05231288f, 0.02810853f, 0.02444274f, 0.07059252f, 0.00872264f, 0.07014155f, 
    -0.05796671f, -0.05898301f, 0.16004670f, 0.07578610f, -0.11215254f, -0.00165289f, -0.20703807f, 0.14792368f, 
    0.08754762f, -0.02882429f, -0.01610695f, 0.11808482f, 0.02156680f, -0.10364120f, 0.03462582f, 0.75554305f, 
    -0.35527357f, -0.26529422f, 0.09164856f, -0.09963772f, 0.09243435f, 0.13965937f, 0.03719551f, -0.04187371f, 
    0.27499175f, -0.30623814f, -0.28694990f, 0.04647765f, -0.06031350f, -0.14630076f, 0.04525663f, -0.04221128f, 
    -0.06743021f, -0.02413754f, -0.01768694f, -0.24115266f, -0.08153323f, 0.01937961f, 0.16874979f, -0.01947964f, 
    0.05092158f, 0.11408228f, 0.05522956f, -0.15891625f, -0.11218504f, 0.13437897f, 0.02471535f, -0.06115165f, 
    -0.01739130f, -0.01214151f, -0.00729593f, -0.39611202f, 0.35413480f, 0.09050847f, 0.01036056f, -0.02973128f, 
    -0.10505276f, -0.12667844f, -0.09719614f, 0.17042477f, -0.03967915f, -0.15098394f, -0.05403459f, 0.14911319f, 
    -0.02957091f, -0.09366228f, 0.05204453f, 0.15250809f, -0.16188732f, -0.17921767f, 0.06196338f, 0.10879810f, 
    -0.02967824f, 0.00117581f, 0.00386017f, -0.02718613f, -0.04187300f, -0.06108944f, -0.02824058f, -0.13907133f, 
    -0.11852638f, -0.07484637f, -0.01048832f, 0.15526900f, 0.09106980f, 0.03684524f, 0.16729496f, 0.37267944f, 
    0.02420281f, 0.11031354f, -0.02386213f, -0.03754277f, -0.12488911f, 0.01799749f, 0.15007624f, -0.04559613f, 
    -0.20658468f, 0.06176138f, -0.12740229f, -0.05929105f, -0.06839539f, -0.06303628f, 0.21070622f, 0.05593521f, 
    0.03337925f, 0.17149647f, 0.13499604f, 0.09531078f, 0.12055668f, -0.11802476f, -0.00784110f, 0.15830030f, 
    0.15079339f, 0.06129707f, -0.36620530f, -0.04211672f, -0.03130667f, -0.02337740f, -0.00930482f, 0.06901456f, 
    0.12531441f, -0.11057387f, -0.26347783f, 0.30344149f, 0.20862816f, -0.10421776f, -0.05526303f, -0.06230097f, 
    -0.26427576f, -0.02957274f, -0.20914237f, -0.13330261f, 0.28080687f, -0.12594785f, -0.46164647f, 0.10654440f, 
    0.04196188f, -0.11725688f, -0.07880428f, -0.00992513f, -0.15555730f, 0.31576365f, 0.32333040f, 0.23062079f, 
    0.03426054f, 0.06865886f, 0.13740645f, 0.04763174f, 0.20967336f, 0.21792074f, 0.51306152f, -0.22407131f, 
    -0.08243866f, 0.20146310f, -0.00499906f, 0.05584983f, 0.20121227f, 0.13816465f, -0.04824337f, 0.15544654f, 
    -0.12564842f, -0.11820609f, 0.07725544f, 0.03907566f, 0.02218615f, 0.08057339f, 0.05805252f, -0.04019362f, 
    0.00400160f, -0.03976982f, -0.00388203f, -0.03000968f, -0.03282141f, 0.00361896f, 0.01871099f, -0.00434445f, 
    -0.03936592f, 0.03965536f, 0.05372564f, 0.02272951f, 0.00184757f, -0.00066245f, 0.03140916f, -0.05226622f, 
    -0.02529813f, 0.00707297f, -0.04872750f, -0.00371591f, -0.00794035f, -0.01607380f, 0.00022692f, 0.03717043f, 
    -0.01762554f, 0.02516691f, -0.03199489f, -0.03829719f, -0.06717791f, -0.01308722f, -0.04752386f, 0.03250592f, 
    -0.04908186f, 0.04855083f, -0.01332911f, 0.01057091f, 0.03347148f, 0.04043990f, -0.00915255f, 0.00377936f, 
    0.03251949f, -0.01418904f, 0.00691194f, -0.06679373f, -0.00215917f, -0.05516436f, 0.05169489f, -0.03330157f, 
    0.00473833f, 0.03651806f, 0.02401847f, 0.02528053f, -0.00067042f, -0.06563243f, 0.03934259f, 0.03610611f, 
    0.04548132f, -0.06283010f, 0.02418255f, 0.03625729f, -0.06610537f, 0.02647698f, -0.00281058f, 0.04961404f, 
    -0.01525382f, -0.02777311f, -0.02840982f, -0.01335451f, -0.01290139f, -0.06322259f, -0.03603704f, 0.01985526f, 
    0.03650617f, -0.05568659f, -0.04500504f, 0.04096645f, -0.03390511f, 0.04062631f, -0.02694724f, -0.01121280f, 
    0.01279818f, -0.00191560f, 0.01475755f, -0.05967411f, -0.00486024f, 0.04162704f, -0.00021909f, 0.04202208f, 
    -0.00737224f, 0.02718220f, -0.05268497f, -0.02059867f, -0.05281541f, -0.04367149f, -0.00605213f, -0.03597647f, 
    -0.00526053f, -0.03617686f, 0.02589043f, -0.05324233f, -0.02377870f, 0.02413980f, 0.03355556f, -0.00613371f, 
    0.03270001f, -0.01918298f, -0.00031404f, 0.03479200f, -0.05643190f, 0.02183139f, 0.03018191f, 0.00212624f, 
    -0.02749194f, -0.03879121f, 0.02530490f, -0.00126013f, 0.00378921f, -0.01010744f, 0.00437272f, -0.06210709f, 
    -0.00294645f, -0.06443073f, -0.00740630f, -0.04243884f, 0.02089439f, 0.03494785f, -0.03791409f, -0.04576955f, 
    0.04703257f, -0.05525836f, 0.05091696f, -0.01858561f, 0.02937872f, 0.02931470f, -0.03465624f, 0.03614002f, 
    -0.05377204f, -0.06112871f, 0.04420774f, -0.05355449f, 0.00353288f, 0.03590578f, -0.03257346f, -0.00828865f, 
    0.03603408f, 0.03005737f, -0.00697527f, -0.01452335f, -0.05446934f, 0.04237033f, 0.01929089f, 0.05123574f, 
    -0.01008166f, 0.05528759f, -0.03524856f, -0.05503323f, -0.01878439f, -0.00730616f, -0.01057604f, 0.03515020f, 
    -0.03372038f, -0.00235855f, 0.04928684f, -0.04729725f, -0.02374608f, -0.04908142f, 0.03437272f, 0.00771694f, 
    -0.01503511f, 0.01309221f, -0.04341176f, -0.00950736f, -0.05758845f, 0.01064791f, 0.00561816f, -0.00657836f, 
    0.03559106f, -0.04537228f, -0.03036998f, 0.00932783f, 0.03266175f, -0.03670965f, 0.01283961f, -0.02191013f, 
    0.01296950f, 0.02075261f, -0.01428883f, -0.05245405f, -0.05636483f, -0.04127493f, -0.04423674f, -0.03602544f, 
    -0.03858755f, 0.01115724f, 0.03271945f, -0.04244849f, 0.03922050f, 0.00202112f, -0.04882514f, -0.01472872f, 
    0.05067621f, 0.03085902f, -0.05525985f, 0.03002909f, -0.00550954f, 0.00881028f, 0.00558097f, -0.00659939f, 
    -0.05799503f, -0.05900843f, 0.04215498f, 0.05448219f, -0.00629324f, -0.03823992f, 0.00511164f, -0.02665354f, 
    0.04187886f, -0.03163749f, -0.01723485f, -0.06541134f, 0.01260024f, 0.02779875f, 0.00577816f, -0.00434471f, 
    -0.06842402f, -0.00701192f, -0.04496569f, -0.05355229f, -0.04338963f, 0.04176057f, -0.02704247f, 0.03278033f, 
    0.00570943f, 0.04466588f, -0.06102665f, 0.04773011f, -0.00265198f, -0.05101045f, -0.05943085f, 0.03214777f, 
    0.02391867f, -0.05105850f, -0.01445489f, -0.00741059f, -0.03590610f, 0.03093802f, -0.03866525f, -0.01700569f, 
    0.02269609f, -0.04020852f, -0.00203802f, 0.00529005f, 0.03203752f, 0.05047242f, -0.05187607f, 0.03635471f, 
    -0.03357134f, -0.05244881f, -0.02597013f, -0.06250377f, 0.03204619f, -0.05728040f, 0.03286666f, 0.03996537f, 
    -0.05624731f, -0.02047478f, 0.04958073f, 0.00985947f, -0.02514832f, 0.03520547f, -0.03787487f, -0.03673959f, 
    -0.00862184f, -0.05570380f, 0.01752821f, -0.02905595f, 0.02294919f, -0.05430548f, 0.01188813f, 0.00624700f, 
    0.01933519f, 0.05315830f, 0.03410085f, 0.04045783f, -0.06143250f, -0.03587496f, 0.02924538f, -0.03651020f, 
    -0.00100062f, -0.05650691f, -0.00290488f, -0.00174287f, -0.01502940f, -0.05582374f, -0.04612527f, -0.02856872f, 
    0.01580141f, -0.06081597f, 0.04104340f, -0.03254460f, 0.01511320f, 0.03282484f, -0.03249079f, -0.05191808f, 
    -0.05436621f, -0.05169247f, -0.04341396f, -0.04707917f, 0.02062509f, -0.04389391f, -0.05115484f, -0.02406617f, 
    -0.01404523f, 0.03446693f, 0.01667273f, 0.04271461f, 0.04245987f, 0.00415849f, 0.00394504f, -0.02861703f, 
    0.00297649f, -0.01428155f, 0.03894603f, -0.00035251f, 0.03424359f, -0.01657355f, -0.03214877f, -0.03849534f, 
    -0.03567183f, -0.03009025f, 0.02970445f, 0.04504449f, -0.02261806f, 0.00164732f, -0.02957492f, 0.04024485f, 
    -0.00513222f, 0.03357946f, 0.03813054f, 0.02551167f, 0.04406886f, -0.06025071f, -0.06464601f, -0.03320119f, 
    -0.01835230f, 0.04253688f, -0.00813280f, 0.02642319f, -0.06646954f, -0.05032593f, -0.05701305f, -0.02020954f, 
    0.01167007f, 0.04134271f, 0.02403604f, -0.02115640f, 0.04932626f, -0.02848945f, -0.04771616f, -0.05529626f, 
    0.00447201f, 0.00913626f, 0.03902231f, 0.02801774f, -0.00490876f, -0.04880417f, 0.03669385f, -0.01260481f, 
    0.03226601f, -0.01389111f, -0.06264766f, -0.05690373f, -0.02316073f, -0.04348586f, 0.05034352f, -0.02089905f, 
    0.01474030f, 0.04364121f, -0.04974604f, -0.00570796f, 0.00239030f, -0.00635744f, -0.05788971f, 0.02743255f, 
    0.00552110f, -0.04366921f, -0.05979208f, -0.03408155f, -0.00052497f, 0.00754046f, 0.03088757f, -0.05974174f, 
    -0.01959329f, 0.01208702f, -0.03648565f, 0.00056834f, 0.02309095f, -0.05238353f, -0.01690404f, -0.01136844f, 
    -0.00814223f, 0.02799663f, -0.04128253f, 0.04910246f, -0.04520413f, -0.05057467f, -0.00986672f, 0.01378853f, 
    -0.05898488f, -0.01110754f, 0.01916410f, -0.04893414f, -0.00198951f, -0.03134385f, -0.00287780f, -0.04799134f, 
    0.04527939f, -0.02996045f, -0.02909164f, -0.03316427f, -0.05963273f, 0.01354499f, -0.00897878f, 0.05495625f, 
    0.00426888f, -0.03624730f, 0.01692075f, 0.01291247f, 0.00868687f, -0.01171054f, 0.04678255f, 0.04005608f, 
    -0.05469992f, -0.04732724f, -0.04494617f, 0.05077150f, -0.05634861f, -0.02391052f, 0.04424122f, -0.06469247f, 
    -0.05644191f, 0.01071123f, -0.00808700f, 0.04811618f, 0.05113279f, 0.02495246f, -0.06260014f, -0.04295884f, 
    -0.04500746f, -0.03989550f, -0.00319301f, 0.03331600f, 0.04970580f, 0.04415139f, -0.03562142f, -0.00771004f, 
    -0.03446484f, -0.00069744f, 0.02362859f, -0.01993212f, -0.03389693f, -0.00921225f, -0.02264689f, 0.05071046f, 
    0.04385889f, 0.02380873f, -0.00447833f, 0.02080137f, -0.02973089f, 0.04950582f, 0.00625338f, -0.03545733f, 
    0.03943218f, 0.00349557f, 0.01091157f, 0.00624934f, -0.04445388f, 0.02148711f, -0.02627135f, -0.03359922f, 
    -0.05031967f, 0.01450276f, -0.01093888f, 0.01082129f, -0.01283858f, 0.04215843f, -0.03033225f, 0.02347977f, 
    -0.02034556f, -0.03896238f, -0.05920774f, 0.00620955f, -0.04614445f, -0.05084367f, 0.04057664f, 0.04496669f, 
    -0.02000836f, -0.04700761f, 0.03660207f, -0.00263612f, -0.02159445f, -0.06136721f, 0.02033256f, 0.02644298f, 
    -0.01918226f, -0.03237332f, -0.03059228f, -0.02660022f, -0.03038424f, -0.02875571f, -0.01316041f, -0.03640562f, 
    -0.03419890f, -0.05375750f, -0.04712353f, -0.00637070f, -0.01937377f, -0.05093640f, 0.01997519f, -0.03591027f, 
    -0.02294465f, -0.04580843f, -0.04992592f, 0.01199425f, -0.03004950f, -0.06338976f, 0.03649454f, -0.06104469f, 
    -0.04108568f, -0.00999505f, -0.02387064f, 0.00650515f, -0.00450003f, 0.02592715f, 0.00708699f, 0.00475059f, 
    0.02827540f, -0.00608181f, -0.01387757f, 0.01114878f, -0.02453206f, -0.03757247f, 0.00807354f, 0.00162546f, 
    0.02106306f, -0.01273331f, -0.00774570f, 0.00004993f, -0.04688207f, -0.01293130f, -0.03259054f, -0.01655963f, 
    0.05005215f, -0.02639012f, 0.04148542f, -0.00377113f, 0.05067244f, 0.03676441f, 0.03708228f, 0.01692918f, 
    0.00448745f, -0.04216382f, -0.03130709f, -0.06227854f, -0.00467980f, -0.03330186f, -0.03374058f, 0.02586713f, 
    -0.03147184f, 0.04914732f, -0.02748019f, 0.04822551f, -0.05558065f, 0.01478085f, -0.01884655f, -0.04119522f, 
    -0.01599525f, 0.12453344f, 0.04977869f, 0.17805761f, 0.08419949f, 0.00226849f, -0.00784123f, 0.09619505f, 
    0.10499620f, 0.10963091f, -0.13160013f, 0.17729068f, -0.18983576f, -0.05106810f, -0.21459240f, 0.04417478f, 
    0.06680425f, 0.08048705f, -0.93721467f, -0.19870283f, 0.13211901f, -0.28302744f, 0.08404392f, -0.39377552f, 
    -0.00404018f, -0.15055528f, -0.14882560f, -0.23447429f, 0.06934044f, 0.54927570f, -0.03434797f, -0.13000454f, 
    -0.08931436f, -0.12726344f, 0.08588722f, -0.09982261f, -0.04054400f, 0.14361434f, 0.04826739f, 0.22196290f, 
    -0.15841693f, -0.04424609f, 0.10136902f, 0.06114128f, 0.09997119f, -0.39093542f, -0.13472962f, 0.11718822f, 
    -0.14762343f, -0.01639869f, 0.00609755f, 0.10930036f, -0.03020255f, -0.09597723f, -0.09095730f, 0.12373654f, 
    0.32218078f, -0.08570120f, 0.03940943f, -0.17229074f, -0.00908803f, 0.07360599f, 0.00143799f, -0.00681192f, 
    0.13563536f, 0.05029091f, -0.17157158f, -0.00618154f, -0.07383254f, 0.10729569f, -0.02080003f, 0.00020486f, 
    0.34575388f, 0.21795064f, 0.32105514f, 0.01371921f, 0.08079350f, -0.07184435f, 0.05597390f, -0.08366694f, 
    0.00297931f, -0.34932816f, 0.04924351f, -0.24825966f, 0.04910333f, -0.18255645f, 0.03629277f, -0.00631600f, 
    -0.07607593f, 0.02853856f, -0.28130752f, -0.04358232f, -0.08001507f, 0.05263105f, 0.00829310f, -0.20388155f, 
    0.04325614f, -0.14462735f, 0.05617017f, 0.01334250f, 0.24063791f, 0.03523121f, 0.12202487f, -0.01923098f, 
    0.00734802f, 0.12065231f, -0.09252996f, 0.00826777f, -0.17672907f, -0.08350042f, 0.09185684f, -0.06989918f, 
    -0.13773346f, 0.06100222f, 0.01151085f, -0.04660036f, -0.00796095f, 0.06997117f, 0.13809116f, -0.01617751f, 
    0.10599612f, -0.05976863f, -0.09220734f, 0.20625438f, 0.15335615f, -0.06789720f, -0.02243913f, 0.18719441f, 
    0.23358217f, 0.09206303f, 0.01375390f, -0.01124675f, 0.26801249f, -0.09135134f, -0.01999539f, -0.31669304f, 
    0.35358965f, 0.25163406f, -0.09726172f, -0.03805819f, -0.02384825f, -0.17300095f, 0.13505521f, 0.05803040f, 
    -0.29724485f, 0.01891268f, -0.03528897f, 0.02242615f, 0.02008862f, 0.15698178f, 0.26619771f, -0.08592661f, 
    0.02151325f, -0.15938993f, 0.16743511f, -0.00378639f, -0.08343480f, -0.10430406f, -0.18292664f, -0.09159826f, 
    0.12943225f, 0.01227213f, 0.05952644f, 0.28720495f, -0.03520251f, -0.08594161f, -0.21746887f, -0.13311689f, 
    0.17638460f, -0.02831999f, -0.00292553f, -0.05005517f, 0.19135605f, 0.34620318f, 0.00572063f, -0.05328669f, 
    -0.14376146f, 0.10065001f, 0.09958709f, -0.00436789f, -0.03765286f, -0.18717362f, 0.11985000f, 0.00233479f, 
    -0.13773343f, 0.12911023f, 0.02688692f, -0.03925619f, -0.01762373f, 0.02950227f, 0.02854015f, 0.20518856f, 
    -0.00974158f, 0.03611566f, 0.12403062f, 0.00144346f, 0.07059287f, 0.04380972f, -0.15182962f, 0.01636967f, 
    0.12198259f, -0.09812900f, -0.07746006f, -0.16424274f, -0.12717946f, 0.09215323f, 0.09621497f, -0.27218527f, 
    -0.07465994f, 0.25405157f, -0.12335251f, -0.08020163f, -0.08867376f, 0.02414193f, -0.00373308f, -0.01013274f, 
    0.07915777f, -0.15804297f, 0.01310213f, 0.07147978f, -0.05066239f, 0.12797296f, 0.10820608f, 0.07368463f, 
    -0.00700337f, -0.00287340f, 0.00860642f, 0.07806376f, -0.13813446f, 0.02268564f, -0.11765809f, 0.06858042f, 
    0.03587705f, 0.06248512f, -0.04808121f, -0.22783306f, 0.22887152f, 0.18060486f, -0.09330394f, -0.15738007f, 
    -0.01555376f, -0.04361747f, 0.06164476f, 0.09139688f, 0.18754938f, 0.03159283f, 0.00312357f, -0.17843756f, 
    -0.25224525f, -0.02345438f, 0.02165390f, -0.15048410f, -0.22675639f, -0.03478270f, 0.30804461f, -0.19380577f, 
    0.20362639f, 0.32229716f, -0.26400205f, -0.05874577f, -0.15573888f, -0.35308605f, 0.09499518f, -0.08358841f, 
    0.01923537f, -0.03397506f, 0.15507603f, -0.01690935f, -0.06236965f, -0.03729686f, -0.24183302f, 0.25053930f, 
    0.17418483f, -0.01777987f, 0.04063508f, 0.23683032f, -0.17132121f, -0.01262130f, -0.00820294f, -0.22630551f, 
    0.05320911f, -0.10278574f, 0.02450474f, 0.21368209f, 0.18364148f, -0.12489204f, -0.06961757f, 0.03286672f, 
    0.01510030f, 0.02001715f, 0.01493304f, -0.04748012f, -0.02014278f, -0.01803224f, -0.00517669f, 0.00180795f, 
    0.03453024f, 0.03223338f, -0.03005004f, 0.00644107f, -0.03199426f, -0.02584917f, -0.04340127f, -0.04131180f, 
    -0.00068842f, 0.02890158f, 0.03071143f, 0.00614503f, 0.05018516f, 0.03727729f, 0.02888841f, -0.01715647f, 
    -0.05473363f, 0.01514316f, -0.00782669f, -0.00690659f, 0.01606334f, 0.03791610f, -0.05987171f, 0.05210621f, 
    0.03589623f, 0.04959697f, -0.01058760f, -0.05686653f, -0.01913128f, 0.01829449f, -0.03015379f, -0.03245062f, 
    0.03145488f, 0.03050589f, -0.03059398f, 0.03322612f, -0.04963049f, -0.00642794f, -0.04023540f, -0.02429697f, 
    -0.02943466f, -0.02915244f, 0.03866957f, -0.04853282f, 0.04840560f, 0.02311286f, 0.04331325f, -0.02450500f, 
    -0.04979190f, -0.01810600f, -0.04652557f, 0.00611433f, 0.01487554f, 0.02440557f, -0.01378418f, -0.01013856f, 
    0.03238413f, 0.03720856f, -0.05780029f, 0.01391068f, -0.05104041f, -0.04406726f, -0.06219864f, 0.00272356f, 
    -0.00521557f, -0.05236709f, 0.01459118f, -0.02123166f, 0.01126529f, -0.04139597f, -0.04585227f, 0.01101222f, 
    0.01955648f, 0.00831548f, 0.03661007f, -0.05813014f, -0.02899995f, -0.05096103f, -0.05209083f, -0.00846715f, 
    0.00169755f, 0.00890626f, -0.06472261f, -0.02607301f, -0.04973302f, -0.05331780f, 0.01817420f, 0.01832878f, 
    -0.04652016f, 0.04749268f, -0.04824415f, -0.02631450f, -0.05314218f, 0.03888714f, -0.01392089f, 0.01867395f, 
    0.01099612f, -0.01267874f, 0.02573575f, 0.01387534f, -0.01054075f, 0.01102256f, -0.02935175f, -0.02357604f, 
    -0.04702412f, -0.04836553f, -0.03770580f, 0.04847005f, -0.00182168f, 0.02041899f, 0.00606021f, -0.04725521f, 
    -0.01968780f, -0.06133211f, -0.03455474f, -0.03556148f, -0.03988117f, -0.03482567f, -0.04126458f, -0.05547656f, 
    0.00106272f, 0.01795325f, -0.03949587f, -0.05426297f, -0.04599009f, 0.03300669f, 0.03921639f, -0.04935600f, 
    0.00375634f, 0.04246156f, -0.02669553f, 0.03271445f, 0.04440883f, -0.02720701f, -0.02946536f, -0.06044550f, 
    -0.03276971f, -0.01558155f, 0.00328009f, -0.03066739f, 0.02097392f, -0.06119108f, -0.00180808f, -0.05576292f, 
    0.04969403f, -0.04181163f, -0.01491262f, -0.06178765f, -0.03515170f, 0.02672105f, -0.05657553f, -0.05261976f, 
    0.03431188f, 0.04812904f, -0.01969114f, -0.01551495f, -0.02940547f, -0.01607708f, 0.04297517f, 0.03533301f, 
    -0.04968226f, -0.03133966f, -0.04176453f, -0.03132274f, 0.02093248f, -0.03057818f, 0.03003128f, -0.01490830f, 
    0.01187156f, -0.01634792f, 0.03024390f, 0.00596807f, -0.00675224f, 0.01377342f, 0.01480516f, -0.03844337f, 
    -0.01161539f, -0.04024759f, 0.02976485f, -0.04273741f, -0.04077683f, 0.04030428f, 0.00950694f, 0.03945626f, 
    0.04319014f, -0.01950823f, -0.02466957f, -0.04164545f, -0.04013622f, 0.03192785f, -0.02999957f, 0.00925979f, 
    0.05054089f, 0.02742168f, 0.02720709f, 0.05044277f, 0.03816692f, -0.01131799f, 0.02413926f, 0.05480032f, 
    0.04237672f, -0.00803204f, 0.00714946f, 0.00890663f, -0.00037279f, 0.02886082f, 0.02354200f, 0.02286491f, 
    -0.00463983f, 0.00786763f, 0.04475201f, 0.01264808f, 0.00956670f, 0.03624050f, -0.00561502f, 0.01134653f, 
    0.01039122f, 0.04873083f, 0.01078864f, -0.00370113f, -0.05578062f, 0.04100151f, 0.02149279f, 0.00709310f, 
    -0.04275389f, 0.03433011f, -0.00498438f, 0.01362597f, 0.04929919f, -0.05714026f, -0.00530879f, -0.03805741f, 
    0.04514543f, -0.05312274f, -0.01336903f, 0.04045948f, -0.04705688f, 0.00009981f, 0.05191491f, -0.05579073f, 
    -0.02360995f, -0.03511478f, -0.05388873f, 0.04629474f, -0.03144321f, 0.00682310f, 0.02956954f, -0.01129115f, 
    0.00732295f, -0.03692062f, -0.04217879f, 0.04724536f, 0.00271662f, 0.00629560f, -0.01186525f, 0.03903912f, 
    -0.02296964f, -0.04268432f, 0.03393424f, -0.03941553f, 0.03797825f, -0.02165909f, 0.01571720f, -0.05364731f, 
    -0.05908986f, -0.03761902f, 0.01724263f, -0.02290561f, 0.05199995f, -0.01538920f, 0.00183429f, 0.04048696f, 
    0.00982458f, -0.03369756f, -0.00366632f, -0.01682677f, 0.00126114f, -0.00078939f, -0.05772325f, -0.02875574f, 
    -0.14348121f, -0.42375150f, -0.42946604f, -0.03532259f, 0.24482739f, 0.12051198f, 0.09937602f, -0.00368003f, 
    -0.05532979f, 0.17998868f, -0.33615661f, -0.18975487f, -0.40371785f, -0.15408663f, -0.29230350f, -0.15241371f, 
    -0.05143222f, -0.08364940f, -0.24721327f, -0.65058249f, -0.10282265f, -0.18547748f, -0.05533513f, -0.19366941f, 
    -0.14634089f, -0.25205630f, 0.08954233f, 0.00538179f, 0.30588216f, 0.33583543f, -0.13002509f, -0.20010918f, 
    -0.08541176f, -0.07998370f, 0.02847721f, 0.13051869f, 0.25005490f, 0.20419610f, -0.03424888f, 0.15520030f, 
    0.12322509f, -0.00623569f, 0.19225404f, 0.19657621f, 0.12417381f, -0.23753211f, -0.62108731f, -0.35809568f, 
    -0.01237177f, 0.01068710f, 0.02222900f, 0.07871564f, 0.08282819f, 0.01244738f, 0.04325995f, 0.33873975f, 
    0.19744916f, -0.03458763f, 0.01429095f, -0.30035117f, -0.07757129f, 0.14399171f, 0.12178737f, -0.03308327f, 
    -0.09428350f, -0.04889238f, -0.19209962f, -0.02069588f, -0.01018969f, -0.04278636f, -0.02415424f, 0.12248830f, 
    -0.07216941f, -0.05043112f, 0.28946105f, -0.12189738f, -0.07164162f, 0.20244633f, -0.03150182f, -0.10122515f, 
    0.02097735f, 0.18199071f, 0.06619651f, -0.43201551f, -0.00307274f, -0.04303958f, 0.16498603f, 0.01693350f, 
    -0.20878816f, -0.19431435f, -0.22865857f, -0.19692165f, -0.11351967f, -0.04997966f, 0.02492604f, 0.06863015f, 
    -0.04316806f, -0.00070483f, 0.06017047f, -0.49487197f, -0.33631885f, -0.10746484f, 0.21678524f, 0.13030457f, 
    0.08501048f, 0.22915015f, 0.17796831f, 0.15359767f, -0.02201408f, 0.14630075f, -0.05024551f, -0.18874751f, 
    -0.22480337f, 0.09962725f, -0.04433944f, 0.12572390f, 0.02665750f, 0.04555361f, 0.17186302f, 0.00790533f, 
    -0.02650579f, 0.05477559f, 0.05309233f, 0.04304155f, -0.05205595f, 0.12409784f, 0.27247986f, 0.17414334f, 
    0.06615823f, -0.04428807f, -0.01101829f, -0.05343220f, 0.07409271f, 0.03450128f, 0.10443493f, 0.08403627f, 
    -0.07594655f, 0.02626678f, -0.11598879f, 0.03090663f, -0.29923275f, -0.10534895f, -0.14217275f, -0.13867781f, 
    -0.07184935f, -0.15124317f, -0.48375672f, 0.15176603f, 0.15432699f, 0.24734601f, 0.14229666f, 0.24097200f, 
    -0.00481068f, -0.09947492f, -0.72286201f, -0.69721806f, -0.04820300f, 0.09152246f, -0.23463380f, -0.11428862f, 
    -0.19540457f, 0.12763071f, 0.04061790f, 0.02003161f, -0.35083160f, -0.05580609f, -0.04546490f, -0.08106049f, 
    -0.03820840f, 0.05229231f, 0.02904028f, 0.12929322f, 0.09893853f, 0.35126144f, -0.12405278f, -0.05211988f, 
    -0.10260890f, 0.00258557f, 0.02443698f, 0.15429823f, 0.28491452f, 0.08873571f, 0.15289298f, -0.03735003f, 
    -0.04358081f, 0.07053094f, 0.09902464f, 0.05682931f, 0.16933124f, 0.37104341f, 0.28691369f, 0.08326984f, 
    -0.06028202f, -0.05121868f, 0.04387678f, 0.01553817f, 0.09868463f, 0.17745085f, -0.33678722f, -0.49859211f, 
    -0.47650573f, -0.09687556f, -0.01276811f, -0.09308795f, -0.22447014f, -0.10957418f, 0.02461315f, 0.09668770f, 
    -0.42951220f, 0.32007584f, -0.11535089f, -0.02995077f, -0.14287233f, 0.03561674f, 0.05161504f, 0.13828620f, 
    0.00385669f, 0.05689953f, 0.10547671f, -0.07516677f, 0.02281300f, 0.05251249f, 0.07740279f, -0.08431539f, 
    -0.05068638f, 0.10912444f, 0.04675388f, 0.27677590f, -0.10228192f, -0.00099272f, -0.08714460f, 0.02349700f, 
    0.11774468f, 0.05461322f, -0.22280329f, 0.01516005f, 0.27212879f, -0.03649774f, -0.00995865f, 0.17837135f, 
    0.08387811f, 0.13861260f, -0.04317125f, 0.19621460f, 0.08627917f, -0.06989986f, -0.06690966f, 0.06000200f, 
    -0.18284400f, -0.03341884f, 0.07893629f, 0.00545821f, 0.41331401f, -0.00925930f, 0.08357304f, -0.19704223f, 
    0.12807074f, -0.31995806f, -0.16147521f, 0.06192032f, -0.20657101f, 0.01766265f, 0.04597356f, 0.16999573f, 
    -0.09769108f, 0.00467478f, 0.09007782f, 0.11944535f, 0.26147076f, -0.02572587f, 0.35446015f, -0.11447826f, 
    -0.08449864f, 0.12025094f, 0.15891947f, -0.05245031f, 0.01659680f, 0.01809140f, 0.02624254f, -0.14456896f, 
    -0.39886391f, -0.16863415f, -0.02360600f, 0.07805149f, 0.15747888f, 0.07054405f, 0.17482388f, -0.06737841f, 
    0.14278023f, 0.09558018f, 0.09177223f, -0.01668984f, 0.09035462f, 0.12279447f, 0.10163005f, 0.13266660f, 
    0.33663693f, 0.18236212f, -0.62391537f, -0.24448833f, 0.24268991f, 0.10581917f, 0.07646191f, -0.06680802f, 
    0.00365747f, 0.15228967f, -0.11075731f, 0.60564464f, -0.24696600f, -0.07767349f, -0.23213036f, 0.03723946f, 
    0.03404047f, 0.02033569f, 0.27214232f, -0.03921932f, -0.05135382f, 0.07082629f, 0.06565248f, 0.01179446f, 
    0.04085498f, 0.01937474f, 0.00364584f, -0.04540898f, -0.14109717f, 0.17979115f, -0.03895996f, -0.00713718f, 
    -0.05767709f, -0.00348618f, 0.11791510f, -0.12381602f, -0.28882465f, -0.15711160f, -0.04061492f, 0.00714373f, 
    0.07302182f, -0.04904231f, -0.03518126f, -0.07066119f, 0.00426450f, -0.03595338f, 0.33999440f, 0.26129237f, 
    0.06024608f, -0.04841701f, -0.06208430f, -0.15752219f, -0.05243916f, -0.18571794f, -0.01922244f, 0.05396442f, 
    -0.10469157f, 0.14780217f, 0.12239160f, 0.08936223f, 0.02790018f, 0.04395553f, -0.05631091f, 0.10957616f, 
    0.02134014f, -0.06104228f, 0.09878729f, 0.08812748f, -0.05127304f, 0.12708592f, 0.10167794f, 0.04431344f, 
    0.17103645f, -0.05374188f, 0.01971423f, 0.09955263f, 0.08339892f, 0.04086612f, 0.02455199f, -0.05801085f, 
    0.09861978f, 0.08010872f, 0.08917106f, -0.13076012f, -0.00667799f, 0.05411102f, -0.00645776f, -0.01183166f, 
    0.12228686f, 0.00884248f, -0.12321287f, 0.04475604f, -0.06958424f, 0.09540083f, 0.03350675f, 0.08604255f, 
    -0.09394724f, -0.21299584f, -0.11998333f, -0.05482786f, 0.16464017f, 0.17647859f, 0.12021136f, 0.09438857f, 
    0.06605527f, 0.07711413f, 0.00937057f, 0.03762574f, 0.05516997f, 0.00115366f, -0.11342241f, -0.06138254f, 
    0.02926784f, 0.02940736f, -0.04688114f, -0.18793295f, -0.16311273f, -0.29610986f, 0.20963986f, 0.21331610f, 
    -0.05755399f, 0.01548355f, -0.04682919f, 0.02708168f, 0.14348555f, -0.03540387f, 0.06354906f, -0.00778014f, 
    0.35940355f, 0.10134309f, 0.10078716f, 0.10690954f, -0.07478241f, -0.17374079f, -0.04158793f, 0.01539914f, 
    0.01677404f, 0.34867427f, 0.25825390f, 0.06561106f, -0.09395201f, -0.16681647f, 0.05705444f, -0.03387767f, 
    0.03261716f, 0.09900242f, -0.23040025f, -0.13818224f, -0.06965302f, 0.08132228f, 0.14692296f, 0.06986407f, 
    0.04184285f, 0.21296027f, -0.06946436f, -0.28716892f, 0.06892577f, 0.16426182f, 0.04696647f, 0.06001032f, 
    -0.00009138f, -0.09206212f, -0.03888492f, -0.01854518f, -0.01568188f, -0.08283021f, 0.13855648f, 0.03467850f, 
    0.04112437f, -0.02363819f, 0.00828024f, -0.03780502f, -0.00418930f, 0.09100170f, 0.30652541f, 0.05422083f, 
    0.06520147f, 0.13270575f, 0.07414047f, 0.06932684f, 0.13037626f, 0.28288668f, 0.08740783f, 0.24016817f, 
    -0.08602706f, -0.05074266f, -0.06948365f, -0.00414879f, 0.05237862f, -0.07374451f, 0.09998937f, -0.06538473f, 
    -0.13569087f, -0.12762867f, -0.07320387f, 0.15073411f, 0.01415819f, 0.05185760f, 0.10148630f, -0.15526871f, 
    -0.03532752f, -0.24028230f, 0.15743543f, -0.05028938f, 0.11293512f, 0.03221510f, -0.20981374f, -0.04483403f, 
    0.10670399f, -0.13534442f, 0.01681008f, 0.01878037f, 0.00390501f, 0.15698218f, -0.16404466f, -0.27592012f, 
    -0.23229682f, 0.00573217f, 0.00401828f, -0.02831777f, 0.09308588f, -0.01462615f, 0.07673870f, 0.04140740f, 
    -0.01615436f, 0.02496787f, 0.26504928f, -0.06309825f, 0.10510196f, 0.11378138f, 0.05788087f, -0.08455208f, 
    0.11546420f, -0.03459658f, 0.12154371f, 0.16822541f, 0.41104206f, -0.20817943f, -0.03420764f, -0.15341927f, 
    -0.32259613f, -0.11414985f, -0.23510732f, -0.14503157f, -0.04169779f, 0.04823454f, 0.55710614f, 0.00019476f, 
    -0.14241959f, 0.16288112f, 0.09680629f, 0.08794385f, 0.02307642f, 0.04151430f, 0.19416682f, 0.03670489f, 
    -0.07965762f, 0.16889001f, 0.19713512f, 0.16755088f, -0.00846925f, 0.05915262f, -0.06260279f, 0.23808652f, 
    0.28750211f, -0.00249016f, 0.05017196f, 0.00223738f, -0.08154927f, -0.00000940f, 0.12467343f, -0.14256476f, 
    0.31139702f, -0.21018478f, 0.03121341f, 0.06672167f, 0.08382511f, -0.07361286f, -0.12927543f, -0.01783766f, 
    0.02992890f, -0.04555023f, -0.02223519f, -0.06724703f, -0.00398366f, 0.02041668f, -0.03054903f, -0.01105533f, 
    -0.02717974f, -0.03935269f, -0.05353897f, -0.04234564f, 0.02269444f, -0.01308522f, -0.02809910f, -0.05073642f, 
    0.01046933f, -0.01425030f, 0.02938171f, -0.03880030f, 0.03099324f, -0.07382470f, -0.08447395f, -0.02667564f, 
    -0.07227681f, -0.01572404f, -0.07466513f, -0.07053805f, 0.00822281f, -0.00978898f, -0.02908946f, -0.06767695f, 
    -0.05125637f, -0.01933053f, -0.02851541f, 0.01049560f, -0.06653897f, -0.01614670f, -0.03900068f, -0.09075301f, 
    -0.04743787f, -0.06027781f, -0.03452519f, -0.02373433f, -0.03667970f, -0.00309172f, -0.06659887f, -0.02173098f, 
    -0.01067145f, -0.03602830f, -0.09525450f, 0.03082849f, -0.03158753f, -0.09693151f, -0.07167996f, -0.08415252f, 
    0.00551246f, -0.08390587f, 0.00119317f, 0.00316876f, -0.03036546f, -0.00297929f, -0.02577298f, -0.05159529f, 
    0.01598862f, -0.04356966f, 0.04146750f, -0.06726524f, 0.00037487f, 0.01685340f, -0.08447387f, 0.01321797f, 
    -0.04844546f, 0.00666764f, -0.05182450f, -0.00615722f, -0.01700548f, -0.07660342f, -0.05362168f, 0.00393750f, 
    -0.07721627f, 0.00165500f, -0.07688427f, -0.02055128f, 0.02600719f, 0.02232849f, 0.00522111f, 0.01256635f, 
    -0.03261044f, -0.00777868f, -0.00035206f, 0.01030819f, -0.03150796f, -0.01985442f, -0.05581805f, -0.02655917f, 
    -0.08982416f, 0.01696775f, -0.00301467f, -0.00071040f, -0.03188350f, 0.00062654f, 0.02493331f, -0.05366221f, 
    -0.00663296f, -0.01390001f, -0.01803753f, 0.01004225f, -0.05177836f, 0.01148845f, -0.03412233f, 0.01218522f, 
    -0.01468515f, -0.07743622f, 0.00931205f, -0.02979018f, 0.01469243f, -0.07010776f, -0.03789493f, -0.06054110f, 
    -0.05080688f, -0.07634636f, -0.02923294f, -0.01409291f, 0.02572601f, -0.08802131f, -0.05850640f, -0.08691707f, 
    -0.06720751f, -0.02243904f, -0.07309359f, -0.01958769f, -0.01120821f, -0.00091236f, -0.07407606f, 0.03193020f, 
    -0.02271869f, -0.07217176f, -0.08071701f, -0.05393004f, -0.07566616f, -0.03104162f, -0.03777185f, -0.03568023f, 
    -0.02343836f, 0.01579859f, 0.00633364f, -0.05378956f, 0.02430722f, -0.07756894f, 0.00305565f, 0.01231639f, 
    -0.00607751f, 0.03608821f, 0.00067608f, -0.01833792f, 0.01481401f, -0.04502938f, -0.02584823f, 0.01418478f, 
    -0.03797286f, -0.04441103f, 0.01742218f, -0.04230435f, -0.05444816f, 0.03795207f, -0.05165010f, -0.03229365f, 
    -0.02599441f, -0.06375346f, -0.02734410f, -0.01824371f, 0.00925792f, -0.01849178f, -0.05084734f, -0.06212901f, 
    -0.07922153f, 0.02527635f, -0.07470222f, 0.00857187f, 0.01396364f, -0.09061763f, -0.01519796f, -0.04878982f, 
    -0.03893548f, -0.02141577f, -0.02265642f, -0.07467843f, 0.01652152f, -0.08622745f, -0.07043326f, -0.02876388f, 
    -0.07525981f, -0.01588656f, 0.00065066f, -0.02219521f, 0.01597798f, -0.01075248f, -0.02260488f, -0.02260175f, 
    -0.05932096f, -0.03716285f, -0.05371813f, -0.03222110f, 0.02140231f, -0.09093128f, -0.05037268f, -0.01098257f, 
    -0.05213885f, 0.01999576f, -0.01992941f, 0.01379697f, 0.01711982f, -0.04327206f, 0.00280950f, 0.00003875f, 
    -0.07842679f, -0.03987030f, -0.00725230f, -0.02282288f, -0.00970653f, -0.07148778f, -0.03777593f, 0.03018708f, 
    0.02557983f, -0.04458254f, 0.00587584f, -0.02066821f, -0.01179314f, -0.02571115f, 0.00056386f, 0.02443513f, 
    -0.07279926f, -0.02487747f, -0.08692620f, -0.04987024f, -0.05436037f, -0.02047127f, -0.00112467f, -0.02193538f, 
    0.01344398f, -0.03004214f, 0.00606533f, -0.00797341f, -0.00468481f, -0.01120007f, 0.00890836f, -0.06764580f, 
    -0.03786290f, 0.01352000f, 0.00919241f, 0.01697801f, -0.01895132f, -0.04231809f, -0.04147030f, 0.03093593f, 
    -0.01034450f, 0.01301083f, -0.05410496f, -0.06930351f, -0.06592795f, -0.01078949f, 0.01108458f, -0.01995632f, 
    -0.08557694f, -0.00011804f, -0.03650129f, -0.07480652f, -0.05124855f, -0.01232528f, -0.07890467f, -0.00466491f, 
    -0.05644717f, 0.00117847f, -0.01174456f, -0.03112504f, -0.02578381f, -0.01423473f, -0.00218235f, -0.04851033f, 
    -0.03712619f, -0.01523963f, 0.04512221f, -0.03269010f, 0.01770425f, 0.01791381f, -0.04050202f, -0.01140242f, 
    0.10896486f, 0.15830207f, 0.00007537f, -0.02496072f, 0.02829932f, 0.01270233f, 0.06526235f, -0.00908651f, 
    0.23878318f, 0.26999974f, 0.41210994f, -0.29790428f, -0.17592828f, -0.08577383f, -0.26969737f, 0.02768348f, 
    -0.20871782f, 0.07421741f, 0.10338288f, -0.20086522f, 0.23852906f, -0.10552903f, 0.08873956f, 0.07645006f, 
    -0.09660216f, 0.00959230f, -0.11963839f, 0.03433618f, 0.04400115f, 0.11267208f, -0.13277274f, -0.02307820f, 
    -0.18008314f, 0.09505673f, 0.20656735f, 0.23549059f, -0.05245807f, -0.09422103f, 0.09172339f, 0.06859873f, 
    0.20702685f, 0.30658367f, 0.22785939f, 0.18510559f, 0.04321574f, -0.10471988f, 0.18922855f, -0.13608818f, 
    -0.03274146f, 0.04912041f, -0.04759983f, 0.09862821f, 0.01563066f, 0.02043423f, 0.02516923f, -0.73905474f, 
    0.05615300f, 0.03088674f, 0.12409051f, 0.04909822f, 0.12402678f, -0.27182412f, 0.16639158f, -0.30891839f, 
    -0.33116668f, -0.58438945f, 0.07532650f, 0.08880835f, 0.07754688f, 0.11662554f, -0.09154318f, 0.03348981f, 
    -0.05339207f, -0.09684110f, -0.05929770f, -0.03366159f, -0.00982385f, -0.04260428f, 0.02141858f, -0.06103858f, 
    0.06162372f, 0.03418981f, 0.23603916f, -0.25571769f, -0.18208380f, -0.03829501f, 0.12334122f, -0.00363320f, 
    -0.10843908f, -0.06985415f, -0.17338412f, 0.13336959f, -0.14819722f, 0.07940517f, -0.06815434f, -0.13496201f, 
    -0.02453736f, 0.01383897f, 0.29345638f, -0.07203007f, -0.01563049f, -0.33993432f, 0.05374982f, -0.05449057f, 
    0.16385365f, 0.05436638f, -0.06166645f, -0.06118418f, -0.54727095f, -0.43144929f, -0.30764416f, -0.02573348f, 
    0.02574761f, 0.12733975f, 0.15279536f, -0.13715658f, 0.08125624f, 0.04908326f, 0.01298065f, 0.01823747f, 
    0.01385884f, -0.10087089f, 0.13862979f, -0.07257238f, -0.11107915f, -0.01058461f, 0.12348483f, -0.03552767f, 
    -0.03767050f, -0.05033880f, 0.09343810f, 0.00555465f, 0.04828043f, 0.01695962f, 0.19958127f, -0.13806430f, 
    0.37676233f, 0.17953162f, -0.00945771f, 0.05907624f, 0.13103944f, -0.14724459f, -0.01757046f, 0.00302123f, 
    -0.24981877f, -0.02903728f, -0.11650230f, 0.08341159f, 0.09766619f, 0.16006237f, -0.00493011f, 0.06600975f, 
    -0.09994524f, 0.00289634f, -0.21557762f, -0.47826800f, -0.08057641f, -0.08556720f, -0.07277723f, 0.01197775f, 
    -0.03116216f, 0.05080403f, -0.00319056f, -0.11955423f, -0.38943267f, -0.09153336f, 0.08689103f, -0.08613533f, 
    0.01076952f, -0.06068440f, -0.21809481f, 0.09703774f, 0.08564562f, 0.05083603f, -0.11097812f, -0.16611667f, 
    -0.27443275f, -0.06466106f, -0.02037032f, 0.15547609f, 0.30337727f, 0.14182745f, 0.07767829f, 0.10715353f, 
    0.10599153f, 0.29163936f, 0.11026823f, 0.04083113f, -0.04273080f, 0.35383713f, -0.19604497f, -0.10453178f, 
    0.14913377f, 0.09801950f, 0.22097167f, 0.10897119f, -0.03980883f, 0.11086830f, -0.02305197f, -0.14712253f, 
    -0.40600780f, -0.15119818f, 0.13647929f, -0.12747654f, 0.00666371f, -0.06300721f, 0.03074059f, -0.87983829f, 
    -0.18125595f, 0.00264535f, 0.07006028f, 0.02584134f, -0.06530296f, 0.01410960f, -0.07710153f, 0.02350571f, 
    0.11332492f, 0.01521745f, 0.07137434f, 0.04618963f, -0.11989488f, -0.09658600f, -0.04583795f, 0.01028012f, 
    0.02284448f, -0.42960450f, -0.42753702f, 0.04522433f, -0.05495112f, 0.07824740f, -0.03981278f, 0.03706104f, 
    -0.08035387f, -0.05966048f, 0.14178587f, 0.10516955f, 0.02576520f, -0.06516576f, -0.06174733f, 0.03332407f, 
    0.23580539f, 0.02671983f, 0.15806811f, 0.11862007f, -0.34977618f, 0.15462701f, -0.06074242f, 0.12203730f, 
    -0.01575546f, 0.04908117f, -0.11943191f, 0.08050815f, 0.16472022f, 0.11763521f, -0.02702807f, -0.17470771f, 
    0.00401339f, 0.13248837f, -0.14521199f, 0.05245628f, 0.23883635f, -0.15414669f, -0.09522169f, -0.02681815f, 
    0.00720994f, 0.08080540f, -0.12628171f, 0.04515685f, 0.23651749f, -0.10567012f, 0.08985347f, 0.18351717f, 
    -0.18319482f, -0.03988370f, 0.09825908f, 0.30646884f, 0.11895584f, 0.16649336f, -0.00767070f, -0.65810657f, 
    0.10320340f, 0.05330099f, 0.10510234f, 0.08888785f, -0.04667791f, -0.12439661f, 0.02461625f, -0.18281302f, 
    0.01344459f, 0.01996416f, 0.17621148f, 0.03038721f, 0.00789158f, -0.12663856f, -0.09409288f, -0.30132985f, 
    -0.00568104f, -0.22452350f, -0.10324275f, 0.10537668f, 0.07792801f, -0.04918503f, -0.04634011f, 0.00853156f, 
    0.03624289f, 0.07993650f, -0.30664930f, 0.01181565f, 0.08772910f, 0.31016845f, 0.20165046f, 0.12523232f, 
    -0.21311186f, -0.16586693f, -0.41793445f, 0.02809697f, -0.06744424f, -0.03675323f, -0.13909552f, 0.06410454f, 
    0.12513506f, -0.07771193f, -0.03517764f, -0.11570904f, 0.14922833f, 0.04592631f, 0.33707356f, 0.20242199f, 
    0.06635740f, 0.05487695f, 0.11320069f, -0.26528504f, 0.24161319f, -0.05226408f, 0.04455033f, 0.01309175f, 
    -0.02206646f, 0.02589777f, 0.02532290f, 0.03067312f, -0.05771162f, 0.17921057f, 0.00808748f, 0.21254116f, 
    -0.04283438f, 0.02307754f, -0.00623729f, 0.15881300f, 0.17346501f, 0.24424024f, 0.14771391f, -0.14380319f, 
    0.14049453f, -0.27640218f, -0.04219228f, 0.09232532f, 0.03020402f, 0.02050203f, 0.11957705f, -0.28001145f, 
    0.10973287f, -0.04015465f, -0.06550378f, -0.15788670f, 0.09366485f, -0.08974709f, -0.15307774f, -0.13823777f, 
    -0.08727385f, -0.03534402f, 0.18510893f, -0.01487578f, 0.17193373f, 0.17267694f, -0.12764011f, 0.09946562f, 
    -0.28739533f, 0.10553918f, -0.02175580f, -0.09139106f, -0.13966903f, -0.07198240f, 0.07985700f, -0.02694325f, 
    -0.02296880f, -0.51572341f, -0.29976451f, -0.00857325f, -0.05355123f, -0.01204646f, 0.00939232f, 0.03522830f, 
    0.00176004f, 0.17742808f, 0.11838244f, 0.22054213f, -0.21931313f, -0.25578901f, -0.13282563f, 0.02882228f, 
    0.02000728f, 0.14792374f, -0.23912893f, -0.24331306f, -0.37340555f, -0.04806917f, 0.01603233f, 0.03277021f, 
    0.16049543f, -0.05234648f, -0.01877236f, 0.13695738f, 0.06505536f, 0.26101866f, -0.05890714f, 0.01383856f, 
    0.06835083f, 0.11335818f, -0.03641009f, 0.04288870f, -0.08226577f, -0.00988289f, -0.06414725f, -0.17823941f, 
    0.22906579f, 0.16493396f, 0.28395635f, -0.09861439f, 0.25451407f, -0.31310517f, 0.18479338f, 0.17024623f, 
    0.01780414f, 0.14373681f, 0.15719602f, -0.04749829f, 0.02368932f, 0.05536225f, 0.19561654f, 0.24263701f, 
    0.20210765f, 0.00433296f, -0.12022362f, -0.08227839f, 0.05524595f, -0.03256204f, -0.09984643f, -0.22935537f, 
    -0.23529284f, -0.07252859f, -0.06172535f, -0.15410005f, 0.00421203f, 0.08024640f, -0.01003306f, 0.02669896f, 
    0.12621540f, 0.04345104f, 0.10915051f, -0.06663054f, -0.07990569f, 0.07137951f, -0.21816573f, -0.04611879f, 
    -0.01708381f, -0.04973280f, -0.14072835f, -0.30132061f, 0.12228614f, -0.13866907f, -0.03691999f, -0.15120634f, 
    -0.01383411f, -0.02258845f, -0.18717070f, -0.04721253f, -0.19386916f, 0.14495397f, -0.17558338f, 0.17515752f, 
    0.00629692f, 0.16082312f, 0.02599197f, -0.12629452f, 0.00158484f, 0.07904838f, 0.01437069f, -0.07138430f, 
    -0.12146000f, 0.01544502f, 0.02946770f, 0.01662442f, -0.20583318f, -0.28522903f, -0.11016580f, -0.26867479f, 
    -0.00486444f, 0.04950389f, -0.03581501f, 0.07104170f, 0.13912533f, 0.07948390f, 0.19505459f, 0.02484230f, 
    0.00501492f, -0.12368387f, -0.06689719f, 0.14596160f, 0.31713563f, 0.05242313f, -0.13010223f, 0.02317911f, 
    0.12274886f, -0.20380197f, -0.08864251f, -0.03381836f, 0.06097192f, 0.13380639f, 0.16306151f, 0.02470372f, 
    -0.01949843f, -0.24690270f, 0.32061931f, -0.11877964f, 0.05455737f, -0.33821496f, 0.22192693f, 0.08285414f, 
    0.02895089f, -0.05865252f, 0.21994810f, -0.00418900f, 0.03569090f, 0.02920418f, 0.17106071f, 0.02186914f, 
    -0.02298593f, 0.06128827f, 0.18301576f, 0.26605135f, 0.25840771f, 0.19344422f, 0.12490630f, -0.05332997f, 
    0.12306879f, -0.02170306f, -0.14210755f, -0.08073787f, 0.01498580f, -0.16135581f, -0.13875626f, 0.07277101f, 
    0.06577124f, -0.08665060f, 0.05348555f, -0.15301248f, -0.11254020f, -0.13138081f, 0.05031316f, 0.07230745f, 
    0.21551155f, 0.25601137f, -0.07108986f, 0.04510664f, -0.18856317f, 0.09485373f, 0.08735745f, -0.40424258f, 
    0.05383015f, 0.10550091f, 0.24232516f, -0.04993945f, 0.15217985f, -0.22786282f, -0.01428017f, -0.06308646f, 
    0.01316858f, 0.03508930f, 0.06306455f, 0.15273109f, 0.19946043f, -0.01405568f, 0.07929026f, 0.05673733f, 
    -0.01332109f, -0.06310480f, 0.05110557f, 0.12449642f, -0.04002181f, 0.10333721f, -0.08840314f, 0.15898661f, 
    -0.24740976f, -0.32120696f, 0.02535339f, 0.35876393f, -0.05723726f, -0.00927213f, -0.18558416f, 0.14648564f, 
    -0.10535562f, 0.04803330f, -0.25192958f, -0.16122368f, -0.10555508f, 0.02394235f, -0.00265867f, -0.20630181f, 
    -0.17283069f, 0.21039546f, -0.11815790f, 0.12252034f, 0.11495738f, 0.19226056f, 0.04514266f, -0.33569127f, 
    0.01458878f, -0.00582690f, 0.30984595f, 0.09922936f, 0.13394199f, -0.31284735f, 0.12116213f, 0.28060082f, 
    0.09392755f, 0.15780470f, 0.11353986f, 0.13370776f, 0.17816930f, 0.06004788f, -0.38025451f, -0.12630638f, 
    0.11142186f, -0.25892767f, -0.11200558f, -0.00349052f, -0.15133192f, -0.39550966f, 0.18346913f, 0.08335996f, 
    0.07961175f, 0.06704472f, 0.10429133f, 0.07550372f, -0.02718348f, 0.02422921f, 0.08689541f, 0.02743015f, 
    0.25982603f, 0.11668079f, 0.12258773f, 0.01201277f, 0.22534135f, -0.08390327f, 0.23142079f, 0.23959050f, 
    0.01359631f, -0.05457378f, -0.02596271f, -0.15927435f, 0.12177964f, 0.15437183f, 0.05879348f, 0.12297224f, 
    0.06508916f, 0.13138944f, -0.04363905f, -0.12291402f, 0.00850576f, 0.23779251f, -0.04652055f, -0.22169061f, 
    0.29239103f, -0.03455495f, -0.17364098f, -0.12125531f, 0.04306937f, 0.22302713f, 0.14219292f, 0.12745723f, 
    -0.02445535f, 0.05894983f, -0.07088477f, -0.14143471f, -0.06031616f, -0.02351382f, -0.01088995f, -0.00055508f, 
    -0.03585448f, -0.02278017f, 0.15524912f, -0.15130427f, 0.11123035f, -0.30555010f, -0.27016395f, -0.07474833f, 
    -0.05075576f, -0.00681284f, -0.07002635f, 0.02387639f, -0.07249165f, 0.03011371f, 0.00921041f, 0.15370831f, 
    0.16068396f, -0.14805563f, -0.07831856f, 0.10130390f, 0.17340021f, 0.14045332f, 0.08898001f, -0.31720334f, 
    -0.34647921f, -0.10818190f, -0.02189570f, 0.06023550f, -0.16136181f, 0.02370156f, 0.08862451f, -0.11108661f, 
    -0.01421674f, 0.02402832f, -0.02420665f, 0.06376854f, 0.04000636f, 0.30111146f, -0.02607668f, -0.00089892f, 
    0.11433085f, -0.25353080f, 0.23568259f, -0.03280162f, -0.08084715f, 0.11001246f, -0.14719367f, 0.17927453f, 
    -0.01452049f, -0.04511497f, -0.07746413f, -0.08001789f, 0.13307121f, 0.03449992f, 0.05933601f, -0.05600606f, 
    0.19559716f, -0.02647254f, -0.56875366f, -0.21896884f, -0.15949436f, 0.11819756f, 0.00664632f, -0.14693020f, 
    0.05750139f, -0.01737281f, 0.07668254f, -0.03384147f, 0.22620526f, 0.01072879f, 0.06010536f, 0.10851239f, 
    0.02997398f, 0.01110894f, 0.18467729f, 0.14521180f, 0.01830796f, -0.34110042f, -0.16743763f, 0.07107231f, 
    -0.26734704f, -0.12741353f, -0.12143363f, -0.04172749f, 0.06066342f, 0.13616742f, -0.12920785f, 0.22791608f, 
    0.14147620f, 0.05818302f, 0.03323397f, -0.18856110f, 0.25298187f, 0.19156931f, 0.02749721f, 0.17759420f, 
    -0.02278242f, 0.05683150f, 0.07341850f, 0.06052617f, 0.20067474f, 0.10437299f, 0.01549711f, -0.22621250f, 
    -0.11538366f, -0.17763959f, -0.20499267f, 0.03367313f, 0.06331944f, -0.09667304f, 0.01332096f, 0.22615632f, 
    0.07435356f, 0.16459566f, 0.04845390f, 0.11678229f, 0.05970358f, 0.17708842f, 0.14009874f, 0.15020609f, 
    0.05318499f, 0.02928651f, 0.22669572f, -0.09998587f, 0.17527591f, 0.06392652f, 0.23764083f, -0.15114254f, 
    -0.11736134f, 0.03103713f, 0.09935541f, -0.54956895f, -0.30330619f, 0.04514304f, -0.39456156f, -0.11458553f, 
    0.09405669f, -0.16861615f, -0.15228970f, 0.14082354f, -0.15680569f, -0.01285554f, 0.17078739f, -0.18829378f, 
    -0.15000351f, -0.06578355f, -0.22194478f, 0.08614910f, -0.04936444f, 0.11584784f, 0.12750497f, -0.04919950f, 
    0.04703557f, 0.10024547f, -0.06733420f, 0.28782645f, 0.06137663f, -0.05576028f, 0.01249412f, 0.03344680f, 
    -0.08074536f, 0.13902330f, 0.07238312f, -0.08914037f, 0.15879458f, -0.04607641f, -0.04432414f, 0.28224936f, 
    0.20000689f, -0.08848611f, 0.15935202f, -0.00867856f, 0.09554481f, -0.04074748f, 0.06300741f, -0.48697722f, 
    0.07275268f, 0.16403267f, 0.02754558f, 0.02711013f, 0.05473061f, 0.17048036f, 0.01123102f, -0.00712995f, 
    -0.05265488f, 0.28076655f, 0.33878294f, 0.04803862f, 0.08022562f, 0.11818457f, 0.09943620f, 0.07542418f, 
    0.07782030f, 0.16267900f, 0.39895511f, 0.21292770f, -0.03031478f, -0.13675107f, 0.06231640f, 0.21058382f, 
    0.00478931f, 0.06362536f, 0.06991500f, -0.07809698f, -0.17102310f, 0.00632411f, -0.02242873f, -0.05204784f, 
    -0.01529490f, -0.10670061f, -0.22620080f, -0.13034929f, -0.13940923f, -0.25435346f, 0.02034028f, -0.00848514f, 
    0.14838980f, -0.02477286f, -0.16151327f, -0.12594470f, 0.05844127f, 0.22776982f, 0.19074799f, -0.15331043f, 
    -0.06945982f, 0.06732444f, -0.02678468f, 0.01994046f, 0.12085150f, -0.01865883f, -0.16714840f, -0.15764353f, 
    -0.21934441f, -0.03930072f, 0.07241976f, 0.14769010f, -0.28289321f, 0.06632950f, 0.35152099f, 0.07360810f, 
    0.15924394f, -0.01828492f, 0.12137616f, 0.10283622f, -0.07427266f, -0.01490753f, -0.08313029f, -0.02865114f, 
    0.11051469f, 0.03143705f, -0.10043705f, -0.02702882f, 0.02746936f, -0.09952837f, 0.16336225f, 0.11244445f, 
    -0.14546020f, 0.09088152f, 0.02048768f, 0.20005082f, -0.03687789f, -0.18667822f, 0.44435069f, 0.06404345f, 
    -0.05179522f, 0.22691894f, -0.06347041f, 0.02401182f, 0.10079581f, 0.10951848f, 0.02561356f, 0.00922049f, 
    -0.03201717f, -0.13025944f, -0.22371098f, 0.08993851f, 0.04421667f, 0.04400026f, -0.04451729f, -0.10913946f, 
    -0.05093584f, -0.03449724f, -0.10656056f, -0.03270800f, -0.20543759f, 0.05651825f, -0.08319184f, 0.13846079f, 
    0.15462634f, 0.06062512f, -0.09099691f, 0.00282933f, -0.19132933f, -0.02708755f, -0.05639533f, 0.04100895f, 
    -0.24924284f, -0.04209716f, -0.13288964f, -0.11555333f, 0.04404812f, 0.03176588f, 0.01425947f, -0.24088576f, 
    0.06096085f, 0.08891524f, 0.00689609f, 0.03752799f, 0.13756059f, -0.04511400f, -0.00160086f, -0.32818410f, 
    0.07796595f, 0.47397396f, -0.00855951f, -0.16239072f, 0.30545551f, 0.16676013f, 0.00635210f, 0.00921564f, 
    0.04026246f, -0.02894482f, 0.46082997f, -0.04033843f, 0.09413750f, 0.27667224f, -0.13961431f, 0.01496429f, 
    0.15042172f, 0.05979552f, 0.08820084f, -0.17422093f, 0.06731156f, 0.03921181f, -0.02681331f, -0.05510581f, 
    0.05422691f, -0.01945887f, -0.00566667f, 0.12513532f, 0.31643960f, 0.02357481f, -0.03628418f, 0.02219414f, 
    0.06105832f, -0.15930463f, -0.00371322f, -0.10280822f, -0.17229581f, -0.10595281f, -0.03809781f, 0.02750799f, 
    0.00914884f, 0.06945900f, 0.07262558f, -0.18247972f, -0.11634992f, -0.07902259f, 0.08832787f, 0.00517240f, 
    0.04882685f, 0.08344069f, 0.01346425f, 0.07092111f, -0.10452303f, -0.18810435f, -0.27109173f, -0.12134481f, 
    -0.01816322f, 0.07951742f, 0.00904993f, -0.15663980f, 0.08333047f, 0.18761741f, 0.10276962f, 0.05269656f, 
    -0.10345274f, -0.07323033f, 0.06274688f, -0.02686423f, 0.04038208f, 0.03322988f, -0.09921901f, -0.02304742f, 
    0.19224447f, -0.10048041f, -0.09121519f, 0.06600669f, -0.15478118f, -0.13252433f, 0.06143292f, 0.01283012f, 
    0.00240061f, -0.01596974f, -0.01710857f, -0.42751464f, -0.11295579f, -0.12306418f, -0.15487972f, 0.08075404f, 
    -0.06225074f, -0.03994730f, 0.26904091f, -0.12304986f, -0.00655648f, 0.08946971f, -0.06871727f, -0.08480539f, 
    -0.06360926f, -0.14035104f, 0.10025197f, -0.24860346f, -0.00316369f, -0.08628454f, -0.05332345f, 0.05419495f, 
    0.05102635f, 0.11056037f, 0.39530626f, -0.45536327f, -0.08100628f, 0.25038564f, -0.06562888f, 0.12560351f, 
    0.03402014f, -0.06629352f, 0.19182014f, 0.29880461f, -0.12555850f, 0.19672257f, 0.43262517f, -0.17525415f, 
    -0.06462827f, 0.13771680f, 0.05809854f, 0.06802003f, -0.04063660f, -0.15515403f, 0.02847587f, -0.11196721f, 
    -0.03401954f, -0.03778160f, -0.04434248f, 0.01623224f, -0.03744239f, -0.09593469f, -0.18244480f, -0.01641542f, 
    0.08079926f, -0.03809757f, -0.20034723f, 0.28999570f, -0.02141903f, -0.15956828f, -0.02758320f, 0.22009000f, 
    0.35648596f, 0.04652877f, -0.04069559f, -0.15901262f, 0.07404894f, -0.00198992f, -0.00879979f, 0.02955961f, 
    0.05293392f, -0.08672749f, 0.03498929f, 0.01737763f, -0.01850362f, 0.14716546f, -0.04668905f, 0.10952748f, 
    0.30539411f, -0.03866298f, -0.40095964f, 0.02922611f, -0.08259037f, 0.05610901f, -0.13997354f, -0.15614285f, 
    -0.03650599f, 0.05175819f, -0.12472977f, 0.09180676f, -0.11211974f, 0.01560681f, -0.02371159f, 0.27634615f, 
    -0.12787345f, -0.07908075f, 0.08261752f, -0.15416224f, 0.12570058f, 0.01075641f, -0.18183483f, -0.00870589f, 
    -0.12287186f, 0.05290898f, -0.05199509f, -0.05704393f, 0.06695816f, 0.10272300f, -0.09012114f, -0.05302313f, 
    0.13171482f, 0.00293125f, 0.10793336f, -0.16337661f, -0.01348851f, -0.33640468f, 0.13072133f, 0.07366754f, 
    0.03733528f, -0.07554868f, -0.06967540f, -0.33510455f, -0.14234824f, -0.17199017f, 0.09105773f, -0.13376568f, 
    -0.00860901f, -0.11553826f, 0.04389926f, 0.02733527f, -0.05214217f, 0.03366932f, 0.03352163f, -0.08802915f, 
    0.07587153f, 0.05420280f, 0.08490686f, -0.08775636f, -0.02584892f, -0.04196213f, 0.07618123f, 0.10582224f, 
    -0.05725625f, 0.05559414f, 0.17304766f, -0.06005228f, 0.03842487f, 0.12114616f, -0.10255264f, 0.14238998f, 
    0.12882617f, 0.15288699f, 0.07223547f, 0.03358119f, 0.05122010f, 0.11639424f, 0.07482632f, -0.03255721f, 
    0.24078827f, -0.01804328f, -0.11537712f, -0.13118935f, 0.00625830f, -0.16814643f, 0.02322316f, 0.00855337f, 
    0.13597086f, 0.11002686f, -0.11271671f, -0.13817385f, -0.03216987f, -0.08429410f, 0.16707839f, 0.25634003f, 
    -0.03650172f, -0.14731266f, -0.28748015f, -0.31906885f, 0.03592897f, 0.07446472f, -0.05997649f, -0.26821166f, 
    -0.09365526f, -0.00112813f, -0.00624209f, -0.04978972f, 0.04024176f, -0.00447773f, -0.04576848f, -0.12873068f, 
    -0.02269609f, 0.09178187f, -0.05258226f, -0.07439418f, -0.11983346f, -0.27392039f, 0.07935936f, 0.13041623f, 
    -0.04966168f, -0.17880364f, -0.00533110f, -0.03873399f, 0.20070951f, 0.15474695f, -0.04901436f, 0.14557759f, 
    -0.00609294f, 0.14480652f, -0.06435316f, 0.25350764f, -0.14391318f, 0.02474908f, 0.09160789f, -0.01841974f, 
    -0.08182953f, -0.05914205f, 0.08203158f, 0.13198236f, 0.23793550f, -0.04008964f, -0.15320158f, -0.11200918f, 
    -0.06950259f, -0.07130685f, -0.19779682f, 0.04697510f, -0.11658058f, 0.14666048f, 0.02182934f, -0.18623158f, 
    -0.06423781f, 0.27961838f, -0.07285074f, -0.09677332f, -0.02674197f, 0.23826085f, 0.05951367f, 0.15569264f, 
    -0.13898486f, -0.16088040f, -0.00924342f, -0.00927264f, 0.15378064f, -0.02851155f, -0.12301034f, 0.08522779f, 
    -0.00742713f, 0.07300684f, 0.07464734f, -0.12709031f, -0.01855210f, 0.23864634f, 0.21550444f, -0.01891113f, 
    0.07382122f, 0.20907594f, 0.02497779f, 0.29007089f, 0.02999662f, 0.16738045f, 0.11344104f, 0.04490576f, 
    0.10925876f, -0.05328412f, 0.05328048f, 0.04243727f, 0.12782770f, -0.01116209f, -0.00282145f, -0.05720707f, 
    0.25632066f, -0.03654375f, -0.01742228f, 0.08224999f, -0.09795173f, -0.02904306f, 0.10325808f, -0.21643145f, 
    -0.30192667f, -0.24267554f, 0.13390414f, 0.01778292f, 0.10711031f, -0.07427859f, -0.23732986f, 0.00326196f, 
    -0.06083555f, 0.05559478f, -0.01431242f, 0.00091086f, -0.01611828f, 0.14584243f, -0.09511576f, -0.04781211f, 
    -0.29928127f, 0.02045323f, 0.08799397f, 0.03386855f, -0.04267818f, -0.17651074f, -0.00510185f, -0.03994963f, 
    -0.04129643f, 0.13820253f, -0.01350500f, 0.13299207f, 0.32477185f, 0.19909500f, -0.17153534f, -0.04414408f, 
    0.18947984f, 0.30694243f, 0.12955938f, -0.01924584f, -0.11414184f, -0.10478099f, -0.01199200f, 0.12398876f, 
    0.02417550f, -0.07301895f, -0.13186091f, 0.02987145f, -0.01596991f, -0.00784519f, -0.08256061f, 0.07583142f, 
    -0.08305859f, 0.05173634f, 0.18570542f, 0.01487693f, 0.03707780f, -0.03528655f, 0.07117843f, -0.08054804f, 
    -0.25941780f, 0.05393729f, 0.18927108f, 0.10267208f, 0.00393363f, 0.03972874f, 0.14245039f, 0.03024581f, 
    0.09536426f, 0.02463078f, 0.13773318f, 0.06885815f, -0.00574922f, 0.20948695f, 0.04119438f, -0.01172101f, 
    -0.12489723f, -0.03940373f, 0.03027472f, 0.11239105f, 0.18887524f, 0.04114249f, -0.05374295f, -0.06099109f, 
    0.06965607f, 0.18480597f, 0.15372087f, 0.09034382f, 0.16800368f, 0.11971074f, 0.13707429f, 0.01198701f, 
    -0.06080624f, -0.34427124f, -0.15472050f, -0.04479782f, -0.06852218f, -0.13869075f, -0.12256812f, 0.09383885f, 
    0.03051432f, -0.13043661f, -0.68182158f, 0.06980202f, -0.09883820f, -0.38883376f, 0.00337128f, -0.27076200f, 
    0.10400239f, -0.11621964f, 0.05631143f, -0.34268588f, -0.29270896f, -0.23217835f, -0.04227325f, 0.02080991f, 
    -0.07745546f, -0.00573471f, 0.05326300f, 0.24469176f, -0.07060246f, -0.03915048f, -0.16375691f, -0.00039094f, 
    0.17268318f, 0.15691389f, -0.05612551f, 0.19574064f, 0.06604505f, -0.16135278f, 0.28446877f, 0.47818074f, 
    -0.01874051f, -0.02938480f, -0.30614692f, 0.12597215f, 0.20300417f, 0.13802829f, -0.00110314f, -0.36872873f, 
    -0.50755358f, -0.01872798f, 0.21281774f, -0.14589809f, 0.02986262f, 0.11142161f, 0.00572994f, 0.14162204f, 
    -0.06597171f, -0.30670431f, 0.07030277f, 0.09567047f, 0.00636289f, 0.01340659f, 0.01531499f, -0.01222909f, 
    0.16884917f, -0.04284094f, -0.22007532f, 0.03648101f, 0.06626933f, 0.07975795f, 0.03120824f, 0.17476808f, 
    -0.00703432f, -0.04776195f, 0.16500272f, 0.15218256f, -0.03654771f, -0.01299020f, 0.11080492f, 0.12938276f, 
    0.18539280f, -0.02739746f, -0.10048128f, -0.13173635f, -0.16632725f, -0.22031057f, -0.13900532f, -0.11757217f, 
    0.25053048f, 0.06362823f, 0.03958289f, 0.10318187f, 0.22667007f, 0.01464768f, -0.05821228f, -0.17051733f, 
    0.03691869f, 0.07324578f, 0.22955248f, 0.04968842f, -0.28664485f, -0.39190713f, -0.53751379f, 0.07344700f, 
    -0.08525006f, -0.10248214f, 0.01590908f, 0.06701572f, 0.02437285f, 0.11141571f, 0.03147261f, 0.06866057f, 
    0.06510971f, 0.05292524f, 0.10808017f, 0.26571649f, 0.18893760f, 0.07646955f, -0.28094617f, -0.09674026f, 
    0.13604951f, 0.16673744f, -0.00533405f, 0.06343323f, 0.10047014f, 0.10173064f, 0.07959371f, -0.04167758f, 
    -0.31484434f, -0.27526343f, -0.11952700f, -0.15940630f, 0.30372068f, -0.04409273f, 0.04667516f, -0.01475920f, 
    0.00901247f, -0.02299566f, -0.11098400f, -0.04897605f, 0.00885228f, 0.02335075f, 0.09425950f, 0.12137737f, 
    -0.07563617f, -0.11894628f, 0.12766506f, 0.22054029f, -0.12674798f, -0.12821099f, -0.12753902f, 0.00098190f, 
    0.06538783f, 0.03375558f, -0.37279069f, -0.06424732f, 0.09733512f, -0.13027725f, -0.18712072f, -0.06525394f, 
    0.00661133f, 0.03007873f, -0.00642541f, -0.09079048f, -0.07579233f, -0.03145288f, -0.00722366f, -0.02532814f, 
    -0.00413580f, 0.03772787f, -0.04009623f, 0.13270627f, -0.10136632f, -0.02033187f, 0.05890061f, 0.02812734f, 
    0.06177182f, -0.05208620f, 0.18642876f, -0.05423252f, 0.15566225f, 0.12023704f, -0.15116641f, -0.23882316f, 
    0.18172908f, 0.19435576f, 0.14626887f, 0.08754247f, 0.04925139f, 0.02538603f, 0.15553196f, 0.28620547f, 
    0.39220774f, -0.10568098f, -0.09671459f, -0.07507102f, 0.10310319f, 0.14665419f, 0.01165336f, -0.28035676f, 
    -0.24369869f, -0.25719553f, -0.09136678f, -0.00599582f, -0.00743700f, 0.00334730f, -0.05511556f, 0.02351282f, 
    0.06220908f, 0.05589443f, 0.07813090f, -0.04527742f, 0.00436495f, 0.06600609f, 0.11985736f, 0.09403474f, 
    0.13489598f, -0.10875859f, -0.03381322f, -0.37099242f, 0.08687458f, 0.03582226f, 0.03778673f, 0.12255660f, 
    -0.03996347f, -0.04550238f, 0.13165024f, -0.24862699f, -0.18137176f, 0.01189702f, -0.07061735f, 0.12778792f, 
    0.33205268f, 0.18268184f, 0.00135182f, 0.07945503f, -0.15618132f, -0.46197608f, -0.09036892f, -0.00748067f, 
    -0.05674057f, -0.01540506f, 0.13164696f, -0.04660491f, -0.29023391f, -0.39144680f, -0.00718299f, 0.03380390f, 
    -0.16647758f, 0.12485565f, 0.11650115f, -0.10028343f, -0.06858234f, -0.21320216f, -0.04380462f, -0.06351816f, 
    0.14019744f, -0.09664275f, -0.03707815f, -0.12083849f, 0.06555372f, 0.19712985f, -0.14206976f, -0.16503644f, 
    0.07060468f, 0.08163866f, 0.06401462f, 0.33947504f, 0.01445138f, 0.03013820f, 0.03513218f, -0.18982925f, 
    -0.37212282f, 0.02849443f, -0.26591128f, -0.15786085f, 0.15151292f, -0.22751844f, -0.09506910f, 0.12570325f, 
    0.01400764f, -0.04047189f, -0.00318209f, 0.02605178f, 0.01357713f, 0.00930885f, 0.04875680f, -0.02115687f, 
    -0.02594668f, 0.02481174f, -0.01104456f, -0.02555577f, -0.01105835f, 0.01780368f, 0.01843856f, -0.05415545f, 
    -0.02556404f, -0.03880738f, -0.05334864f, 0.03809502f, -0.04021332f, 0.01024905f, -0.04328742f, 0.02152289f, 
    -0.01936640f, 0.05260725f, 0.03697305f, 0.04271368f, -0.02561975f, 0.03247805f, -0.01630266f, -0.03098263f, 
    -0.00449273f, 0.02829532f, -0.01678561f, -0.05416505f, -0.03793922f, -0.00266964f, -0.02456087f, -0.00771236f, 
    0.04812501f, 0.04328148f, -0.03857008f, -0.05482451f, 0.05172301f, 0.03451880f, -0.02559749f, 0.00652362f, 
    -0.04292097f, -0.04030872f, -0.00898960f, 0.00111421f, -0.02049911f, -0.05646257f, -0.05444105f, 0.01466959f, 
    -0.03181529f, 0.03121387f, 0.05320686f, -0.01122202f, 0.01353731f, -0.05454520f, 0.01323449f, 0.02215063f, 
    -0.01024198f, -0.02641120f, -0.03218885f, 0.04748355f, -0.05556563f, -0.01576728f, 0.04407965f, -0.01983768f, 
    -0.02432687f, 0.04421844f, -0.04076368f, 0.00508371f, -0.01427470f, 0.01335804f, 0.00871307f, -0.02555260f, 
    -0.03117914f, -0.01173533f, -0.04142911f, -0.05691190f, -0.05344093f, 0.03300780f, 0.03352928f, 0.03573988f, 
    -0.00720580f, 0.02292966f, -0.01582702f, 0.00615698f, -0.03293297f, -0.03169215f, 0.02808571f, 0.01425801f, 
    -0.03096540f, 0.05420232f, -0.04040884f, 0.01585619f, -0.05023391f, 0.03313372f, 0.00084487f, -0.03998272f, 
    0.04532285f, -0.01776447f, 0.00717153f, 0.02991416f, 0.02324159f, -0.02349631f, -0.02734558f, -0.02499973f, 
    0.05173850f, 0.02226530f, 0.01148007f, -0.04334434f, -0.00891945f, -0.06567521f, -0.02148360f, -0.03465498f, 
    -0.00252168f, 0.02077596f, -0.06098177f, -0.04173183f, 0.01041440f, -0.04958614f, 0.02292461f, 0.01451141f, 
    -0.02427652f, -0.00239536f, -0.00224857f, 0.05022398f, 0.04914737f, 0.01240134f, 0.01897573f, -0.06386116f, 
    0.04568967f, 0.03195820f, 0.02676334f, 0.01460931f, -0.01611423f, 0.01476329f, 0.00386381f, 0.01332378f, 
    -0.01220986f, 0.03375921f, 0.03416349f, 0.03526616f, -0.02355792f, -0.04165285f, -0.05650320f, -0.06069617f, 
    0.00822549f, -0.02732510f, -0.05683472f, -0.02667078f, 0.02852553f, 0.03000265f, 0.00323227f, -0.05070842f, 
    -0.04547946f, -0.03709550f, 0.04127907f, 0.01034429f, -0.05421931f, 0.04307683f, -0.00783479f, -0.05243704f, 
    -0.05522961f, -0.00471532f, -0.03111690f, -0.01736842f, -0.05296366f, -0.01287068f, -0.02318191f, -0.01700232f, 
    -0.01613454f, 0.00949356f, -0.04484135f, -0.01801837f, -0.03080422f, 0.02143919f, -0.00562230f, -0.02187887f, 
    -0.02903855f, 0.01797319f, 0.01712197f, -0.02750500f, 0.00018595f, 0.02698382f, 0.00408262f, -0.05245527f, 
    -0.00469865f, -0.01810575f, -0.06290209f, -0.04322094f, -0.03279896f, -0.05147825f, -0.02303470f, -0.04192591f, 
    0.01593032f, 0.00036651f, -0.00237500f, -0.01893378f, 0.04846321f, -0.04662384f, 0.03845831f, -0.01186922f, 
    0.00591765f, -0.04837336f, -0.06032906f, -0.05761281f, 0.00124424f, 0.04584903f, -0.05937473f, 0.01811816f, 
    -0.03122913f, 0.04064059f, -0.03069618f, 0.03767366f, -0.03744389f, -0.02494457f, -0.02161715f, 0.04832143f, 
    0.01871755f, 0.03453132f, 0.02650480f, 0.05325368f, -0.03889635f, 0.03069012f, 0.01790684f, 0.01044393f, 
    0.02416397f, 0.00099526f, -0.05459886f, -0.00579738f, 0.02331638f, -0.00838185f, 0.04639886f, 0.05389770f, 
    -0.01282429f, -0.00703042f, 0.03173847f, -0.01561961f, 0.02071905f, 0.03308128f, -0.04323264f, -0.01380905f, 
    -0.05705272f, -0.01419633f, -0.04074989f, -0.03093453f, 0.04674941f, -0.03027365f, 0.04897852f, 0.03652035f, 
    -0.02061210f, -0.01110713f, -0.04499757f, 0.02873186f, -0.01024920f, 0.02509167f, -0.05608509f, 0.04808416f, 
    -0.04775431f, 0.02499570f, 0.00513799f, 0.04949465f, 0.02555931f, 0.03405736f, 0.01239210f, -0.01811456f, 
    -0.00893073f, -0.03153900f, -0.01856752f, -0.05790657f, -0.05694923f, -0.02508980f, -0.02154686f, 0.05398994f, 
    -0.01278502f, -0.04321446f, 0.03754894f, -0.01573917f, -0.03734922f, -0.06333505f, -0.02816993f, -0.05071575f, 
    0.13504620f, 0.00517728f, -0.10391773f, -0.10356321f, 0.19781230f, 0.09604309f, -0.02853950f, -0.04625383f, 
    0.29505837f, 0.12614037f, -0.07114862f, -0.21811065f, 0.04297218f, -0.06258185f, -0.20324816f, -0.08195617f, 
    -0.03690916f, 0.00320034f, 0.18461446f, 0.57508796f, -0.18407471f, -0.33462721f, -0.11127252f, 0.20977634f, 
    -0.12685515f, 0.03806974f, 0.12699974f, 0.01189595f, -0.12953250f, 0.07262039f, -0.00737033f, -0.06331172f, 
    -0.04544200f, -0.08149494f, -0.05683982f, -0.22425035f, -0.08705648f, 0.05481021f, 0.00365887f, 0.21068634f, 
    0.05753415f, 0.12682399f, 0.16967615f, -0.04933535f, -0.16297406f, 0.01277111f, 0.05237170f, 0.00945863f, 
    -0.09910448f, -0.22640347f, -0.08908947f, -0.08410959f, -0.01460275f, -0.11592663f, -0.08273478f, -0.23397490f, 
    0.06284820f, 0.09243005f, -0.01368672f, 0.04347612f, -0.09245206f, -0.08212028f, -0.16697130f, -0.16680074f, 
    -0.11909027f, -0.02472597f, 0.01427300f, 0.09892630f, -0.14021637f, -0.09559422f, 0.04059513f, 0.09202069f, 
    -0.24909794f, 0.06812038f, 0.14423265f, -0.00381003f, 0.10765968f, -0.04471407f, -0.14304708f, 0.22285895f, 
    0.20361651f, 0.30837247f, -0.13751625f, 0.20433675f, -0.00656645f, 0.05946015f, 0.01029789f, -0.06453175f, 
    -0.08386197f, 0.07502580f, 0.04176378f, 0.03243054f, 0.12840499f, -0.08160489f, -0.03383156f, 0.00856881f, 
    0.06031481f, 0.14725831f, 0.21083073f, 0.02469575f, -0.02062169f, -0.01734358f, 0.15250780f, 0.13506518f, 
    -0.08396283f, -0.01817220f, 0.11192930f, -0.12630303f, 0.00910449f, 0.07169668f, -0.00395276f, -0.01380862f, 
    0.14737551f, -0.13310179f, -0.03087238f, -0.11512021f, 0.12412535f, 0.06583563f, -0.09577163f, -0.11183166f, 
    0.10442480f, -0.03381240f, 0.00803438f, -0.09556987f, -0.11604429f, -0.14911988f, 0.08209009f, 0.06367366f, 
    -0.21965751f, -0.11355188f, 0.05788172f, 0.00233874f, 0.08522951f, -0.02653519f, 0.18455556f, -0.09176815f, 
    0.35451052f, -0.05472581f, 0.02882238f, 0.08880173f, -0.03759718f, 0.31657258f, 0.28477374f, -0.22559758f, 
    -0.03896582f, -0.00134362f, 0.28108722f, 0.02401053f, 0.07062876f, -0.04413849f, 0.10451118f, -0.28260627f, 
    0.10735941f, 0.23486827f, 0.06773942f, -0.18348685f, -0.14753287f, 0.07504751f, 0.09704446f, -0.11054451f, 
    -0.03201732f, 0.10952533f, 0.04271816f, -0.01968409f, 0.07067239f, 0.00001104f, 0.05353927f, -0.08094025f, 
    0.05653486f, 0.03490849f, -0.10091531f, -0.02043588f, 0.03315675f, -0.08467089f, 0.00490662f, 0.08176107f, 
    0.05227538f, -0.02160072f, 0.07014301f, -0.01421710f, -0.10412139f, 0.24376339f, 0.29343683f, 0.01134306f, 
    -0.01104439f, 0.14711958f, 0.11066320f, 0.45507035f, 0.11196684f, -0.18114224f, -0.07952274f, 0.09461176f, 
    0.12134369f, -0.06271630f, -0.04201977f, 0.02351255f, 0.20195261f, 0.10581119f, 0.26837495f, 0.15589891f, 
    0.02817665f, -0.09854694f, 0.06900302f, -0.01180507f, -0.09492348f, 0.01858881f, -0.05072714f, -0.05808996f, 
    0.11001109f, -0.06894363f, -0.04009956f, 0.04646943f, -0.15207037f, -0.10854542f, 0.08397819f, -0.04872433f, 
    0.00637101f, -0.05062792f, 0.03127921f, -0.04924297f, -0.05551733f, 0.03068746f, -0.01595515f, -0.03062561f, 
    -0.15325850f, -0.08032396f, 0.08923563f, -0.05145451f, 0.11146419f, 0.11903723f, -0.07489461f, -0.16800170f, 
    0.01976604f, 0.11569721f, 0.07132572f, -0.09986542f, 0.28480235f, 0.20736161f, -0.05087734f, -0.27891633f, 
    -0.21243782f, 0.45326623f, 0.13350753f, -0.14494912f, 0.10288223f, -0.12354103f, -0.05572013f, 0.04588907f, 
    0.12864676f, -0.02637950f, -0.32216617f, 0.01599138f, -0.27204117f, 0.07653838f, 0.04386982f, 0.01267594f, 
    0.13090125f, -0.10934585f, 0.14686432f, 0.26780608f, 0.25932276f, 0.07986002f, 0.18693157f, -0.16442063f, 
    -0.05368047f, 0.24977231f, -0.01427203f, 0.12246177f, -0.13733792f, 0.13362585f, -0.12007856f, 0.17549920f, 
    -0.12520541f, -0.15952770f, -0.02195535f, -0.09329250f, 0.15932834f, 0.32600003f, 0.03023492f, 0.02891824f, 
    0.20244926f, -0.19405767f, 0.08643248f, -0.00681252f, -0.12041808f, -0.02278700f, 0.16971752f, -0.13760939f, 
    0.26578563f, 0.20512734f, 0.05589715f, -0.10834469f, 0.02496719f, 0.08756608f, 0.01964442f, 0.01033136f, 
    -0.11709340f, 0.18333979f, 0.26107636f, -0.02781512f, 0.13311400f, 0.01326073f, -0.05705258f, -0.09079017f, 
    -0.01015558f, 0.05487339f, -0.20088346f, 0.60374373f, -0.16011596f, 0.35812938f, 0.15899076f, 0.13781968f, 
    -0.13816981f, 0.08816940f, -0.08604986f, 0.16050749f, -0.37378836f, -0.20053290f, -0.09873566f, 0.04831454f, 
    -0.04031239f, 0.07505993f, 0.00127306f, 0.03618497f, 0.10860583f, -0.09987621f, 0.36483416f, 0.00015787f, 
    0.06054328f, -0.20949063f, 0.12445615f, 0.10284276f, -0.01324681f, -0.30998123f, -0.09415117f, -0.21610807f, 
    -0.02700848f, 0.03021892f, -0.09553184f, -0.09539259f, 0.07574682f, -0.00805595f, -0.07111404f, -0.09360423f, 
    0.07629667f, -0.05254670f, -0.02720136f, 0.01483617f, 0.06180040f, 0.03952966f, 0.02372596f, 0.10213374f, 
    0.07721397f, 0.00061493f, -0.10531069f, -0.10466764f, -0.14197277f, 0.00812520f, -0.03906268f, 0.04833523f, 
    0.06456660f, 0.21091020f, -0.13080715f, -0.04499085f, -0.11829345f, -0.11346258f, 0.08478351f, 0.04976392f, 
    0.05578117f, 0.13599966f, -0.00051535f, -0.15863542f, 0.03660224f, -0.00226525f, 0.16090605f, -0.09856598f, 
    0.09861459f, -0.11754545f, 0.53717881f, -0.06033402f, -0.10961162f, -0.08760062f, -0.02672198f, 0.02972968f, 
    -0.02628176f, 0.02140793f, 0.04383485f, -0.06224161f, -0.09610919f, -0.06545141f, -0.06535646f, 0.00616218f, 
    -0.15665931f, 0.04323518f, 0.17629024f, -0.05645700f, 0.17563707f, 0.34205541f, 0.37999490f, -0.13821760f, 
    0.02124095f, 0.02369313f, 0.01956821f, 0.02083851f, 0.03954496f, -0.19406828f, 0.05197055f, -0.04059606f, 
    -0.06097579f, 0.09141660f, -0.00820420f, -0.01743079f, 0.20324256f, -0.02905043f, -0.06331892f, 0.00666785f, 
    0.07407813f, -0.04797221f, -0.03307581f, 0.06775093f, -0.03221746f, -0.05714759f, -0.00908708f, 0.05661291f, 
    -0.22451209f, 0.19524319f, 0.32391569f, -0.00590687f, 0.06687967f, -0.02629915f, -0.12073649f, -0.00729605f, 
    -0.03864691f, 0.20677336f, 0.13074145f, -0.15533586f, 0.18039896f, 0.14760719f, -0.08456726f, 0.22831327f, 
    -0.01261878f, 0.08797346f, 0.00898936f, -0.05815297f, 0.12427904f, 0.05712548f, 0.15997902f, -0.05681745f, 
    0.05570474f, -0.02053397f, 0.19641674f, 0.10497577f, 0.15682085f, 0.19062302f, -0.02652013f, -0.12373821f, 
    0.00622958f, -0.00470662f, 0.10175209f, -0.04073047f, -0.11611573f, -0.05780962f, -0.05671111f, 0.03003620f, 
    0.02776603f, -0.03978843f, -0.02799297f, 0.11283787f, -0.39694938f, 0.19620581f, 0.15041941f, -0.12705609f, 
    -0.03741970f, -0.04967126f, 0.06910522f, -0.00692661f, -0.01921285f, -0.25444588f, -0.07574295f, 0.15874512f, 
    -0.16324903f, 0.09437858f, -0.02775856f, -0.00036676f, -0.05497584f, -0.00605116f, -0.09750671f, 0.00754317f, 
    -0.16133052f, 0.16760166f, 0.09032933f, 0.00815055f, 0.01411245f, 0.10282336f, -0.01429316f, 0.28321895f, 
    0.14317977f, 0.06320534f, 0.01302569f, -0.19735342f, 0.03620411f, -0.10858563f, 0.14932673f, -0.00584444f, 
    0.05853248f, 0.15345666f, 0.08508109f, -0.17505489f, 0.00581038f, -0.13653056f, -0.14115603f, 0.13980441f, 
    0.00698646f, 0.15717854f, 0.19830941f, 0.04606427f, -0.00615185f, -0.14576417f, -0.03093535f, -0.06436367f, 
    -0.11217975f, -0.01667357f, -0.26069438f, -0.11859366f, 0.02454001f, -0.27658853f, 0.25785795f, 0.04870995f, 
    0.11297477f, 0.18943037f, 0.08920527f, -0.09781013f, -0.30657119f, 0.21634109f, -0.06130297f, 0.03725160f, 
    0.02503994f, -0.07054915f, 0.12572594f, 0.06633282f, -0.53438944f, 0.42428869f, 0.10683534f, 0.07129953f, 
    0.04851335f, 0.07320035f, 0.07883251f, 0.14532751f, 0.12219915f, 0.42685729f, 0.45800614f, 0.41085920f, 
    -0.22205587f, 0.02389549f, -0.06389394f, 0.06771250f, -0.08406818f, -0.04295610f, -0.17101458f, 0.18424477f, 
    0.10137055f, -0.04357015f, -0.13765362f, 0.01664306f, 0.10650244f, -0.00362203f, -0.13023478f, 0.13892552f, 
    0.25087801f, 0.07261296f, 0.32878500f, -0.07680140f, 0.16236994f, -0.00814043f, -0.07480302f, -0.02486671f, 
    0.02958982f, 0.10360534f, -0.10536990f, 0.03139096f, 0.02153971f, 0.04860992f, -0.06190201f, -0.00540962f, 
    -0.02739866f, 0.36361834f, 0.22534430f, -0.06308471f, 0.06363920f, 0.09469754f, 0.18143858f, 0.02968333f, 
    -0.01872631f, 0.24471547f, 0.47936848f, 0.20642228f, 0.07342820f, -0.24146830f, -0.30916014f, -0.04848288f, 
    -0.03223725f, -0.04485778f, 0.02465912f, -0.41179901f, 0.06486540f, 0.13234012f, -0.06854615f, -0.09536076f, 
    -0.05583604f, 0.07575424f, 0.03132585f, 0.12644169f, -0.36006674f, -0.24661805f, 0.14034860f, -0.11498611f, 
    0.01129400f, -0.13613096f, 0.11321770f, 0.25982976f, -0.15196279f, 0.11995508f, 0.07521397f, -0.29580066f, 
    0.05477439f, 0.06628857f, -0.00407948f, -0.00324287f, 0.06186185f, -0.06952326f, -0.12958837f, 0.09092410f, 
    -0.10680569f, -0.09958620f, -0.06962156f, -0.09809822f, 0.11650015f, 0.19422832f, 0.10653770f, -0.05012978f, 
    0.16495074f, 0.12975082f, -0.02487022f, 0.06466908f, 0.02388070f, -0.05065424f, -0.03158790f, 0.12331269f, 
    0.12443160f, -0.02202459f, -0.08525189f, -0.00743181f, -0.01847030f, -0.01491960f, -0.00844379f, 0.00829352f, 
    0.04318837f, 0.03780782f, -0.36467722f, -0.15154991f, -0.02080223f, -0.14832157f, 0.06818882f, 0.03516579f, 
    -0.01141979f, -0.11792685f, -0.02362730f, -0.16134636f, 0.19972152f, -0.24157354f, -0.12913144f, -0.05387124f, 
    -0.11281103f, -0.01068870f, 0.01957973f, 0.10083490f, 0.01302231f, -0.07374460f, -0.00732057f, -0.06899493f, 
    -0.05981737f, 0.14832087f, 0.13375381f, 0.04311751f, -0.12185426f, 0.30278453f, 0.14011471f, -0.02944161f, 
    0.16925025f, -0.12630704f, -0.03224942f, -0.02819942f, 0.06138947f, 0.02693923f, -0.09177639f, -0.03934317f, 
    0.06694431f, 0.05855796f, -0.02216927f, 0.21271615f, 0.14981827f, -0.02387202f, -0.05383770f, 0.00770739f, 
    0.01491045f, 0.07712749f, -0.07241169f, -0.03121903f, 0.00299900f, 0.10048752f, 0.04785164f, -0.56633985f, 
    0.12705393f, 0.47258413f, -0.19910261f, -0.01935462f, -0.09571527f, 0.00340464f, 0.04078525f, -0.14055622f, 
    0.12806582f, -0.04790739f, -0.06351781f, -0.09915169f, 0.02014521f, 0.09078608f, 0.12029870f, 0.11518993f, 
    -0.07069892f, 0.26366845f, -0.16507286f, -0.53504115f, 0.05575182f, -0.20938948f, 0.08463909f, -0.14531413f, 
    -0.04043521f, 0.04388446f, 0.09789445f, 0.30966362f, 0.04540356f, -0.07310155f, -0.07773038f, -0.08335157f, 
    0.01901446f, -0.04067831f, -0.07658602f, -0.21178545f, -0.04703512f, 0.25452200f, 0.08072049f, 0.06025866f, 
    -0.08133572f, 0.09060390f, 0.04673975f, 0.05284772f, -0.30205932f, -0.35360959f, 0.03777986f, 0.02216893f, 
    0.03309434f, -0.02359635f, 0.13824542f, -0.09012443f, -0.11641733f, -0.29921088f, -0.25202915f, -0.13208923f, 
    0.13640049f, -0.00970396f, 0.02739022f, 0.13432820f, 0.13997871f, 0.12310358f, 0.18671204f, -0.28596026f, 
    -0.50556922f, 0.03279663f, -0.05956112f, 0.00652094f, -0.10412781f, -0.00958454f, -0.04722489f, 0.15216884f, 
    0.32956880f, 0.06779610f, -0.09843175f, -0.04646524f, -0.20930253f, -0.00025698f, 0.00951089f, 0.00029092f, 
    -0.17337343f, -0.15263224f, -0.10680124f, 0.08183322f, 0.16663039f, 0.00083299f, 0.26154432f, 0.08640087f, 
    0.00442373f, 0.05945168f, 0.25997165f, 0.05603734f, -0.15915130f, 0.11338048f, -0.15810357f, -0.01148581f, 
    -0.14941980f, 0.05884987f, -0.11019283f, -0.34791729f, -0.49814624f, 0.02679023f, 0.07367922f, -0.09347504f, 
    0.19776992f, 0.05790517f, 0.09978559f, -0.35516474f, 0.04486395f, 0.28480721f, 0.07191037f, 0.05481837f, 
    -0.14465314f, 0.10987655f, 0.06743474f, 0.06380240f, -0.39190179f, -0.15618496f, 0.54096925f, -0.16383542f, 
    0.03010360f, 0.01344937f, -0.01491976f, 0.07496075f, 0.08254080f, -0.08605113f, 0.22148034f, 0.03455354f, 
    -0.14768603f, 0.01697617f, -0.05139640f, -0.01289552f, -0.16535293f, 0.09837802f, -0.33890936f, -0.11699176f, 
    0.21078055f, -0.25615069f, 0.09217536f, 0.02128365f, -0.02254709f, -0.00707816f, -0.05273560f, 0.23192304f, 
    0.13769777f, 0.13239929f, -0.06021561f, 0.08510267f, 0.03147962f, -0.04023438f, -0.09764479f, -0.06725698f, 
    -0.01473094f, 0.00645216f, -0.00715752f, 0.04035519f, -0.06193499f, -0.03339285f, 0.03074979f, -0.00814135f, 
    0.00778914f, -0.03271768f, 0.01550465f, -0.01472720f, 0.02506228f, 0.03158233f, -0.03769742f, -0.05592008f, 
    -0.04909379f, 0.01969783f, -0.04146251f, 0.01798789f, -0.03507289f, -0.00917496f, 0.02613277f, 0.02912880f, 
    -0.04441324f, -0.06194770f, 0.05545738f, -0.06718057f, -0.04951148f, 0.01598273f, 0.01792484f, 0.03763655f, 
    0.03044059f, 0.05291760f, -0.01106146f, 0.02637289f, -0.04288775f, 0.00603191f, -0.00594975f, -0.00677748f, 
    0.06028182f, -0.05940637f, -0.05149026f, 0.02696898f, 0.01202094f, 0.00946919f, -0.03669908f, -0.00379698f, 
    0.01041193f, -0.02147917f, -0.05986957f, -0.04023289f, -0.03618036f, -0.05408999f, 0.04281657f, 0.00765223f, 
    -0.01462866f, -0.02084595f, -0.06436310f, 0.05204114f, -0.05556948f, 0.03475234f, -0.03148247f, -0.00375950f, 
    -0.03498709f, -0.04096504f, 0.05529351f, 0.03948588f, -0.05655262f, -0.03427516f, 0.04050294f, 0.00204868f, 
    0.00406308f, -0.01459417f, 0.00494721f, -0.05071464f, 0.03830993f, -0.01945043f, -0.05000941f, -0.05865268f, 
    0.00824033f, -0.04292698f, 0.03356769f, -0.00429038f, -0.05769257f, 0.03381610f, 0.03432138f, 0.01434221f, 
    0.02287713f, -0.05951678f, 0.02688413f, -0.02951631f, 0.00358735f, 0.03006175f, -0.04723404f, 0.00248344f, 
    0.05010276f, 0.05279388f, 0.03745547f, -0.05558056f, 0.04895668f, 0.04253263f, -0.06338193f, -0.01629110f, 
    -0.01829981f, -0.02334076f, 0.01386679f, -0.01554082f, 0.03635325f, -0.04686537f, -0.02853907f, -0.03661979f, 
    -0.00638899f, 0.00256705f, 0.03979711f, -0.01110282f, 0.03638179f, -0.04024907f, -0.03465066f, -0.05045963f, 
    0.00017399f, -0.05754402f, -0.04745148f, -0.00128841f, -0.01006263f, -0.00965976f, 0.00666818f, 0.01836204f, 
    0.03796025f, -0.00815378f, 0.04615434f, -0.00668253f, -0.03330239f, 0.01880230f, -0.05740898f, 0.01288661f, 
    -0.03534260f, -0.04293371f, -0.00431366f, 0.01495868f, 0.03063096f, -0.02905472f, -0.00481801f, 0.01002975f, 
    -0.04110503f, -0.02300681f, -0.00661286f, -0.03099200f, 0.00342781f, -0.03715854f, -0.02450660f, -0.00581081f, 
    0.04740763f, 0.03040005f, -0.05464152f, -0.04984257f, -0.06190268f, -0.02222686f, 0.02498794f, -0.02998411f, 
    -0.02906857f, -0.04465827f, -0.03693294f, -0.01606970f, 0.00759516f, -0.05212384f, -0.02674807f, 0.03968965f, 
    0.03825862f, 0.02208180f, 0.02924332f, 0.03346046f, 0.01455347f, -0.01816107f, 0.02024651f, 0.01763616f, 
    -0.05210633f, -0.03923510f, -0.00703877f, -0.05184997f, -0.00486924f, 0.01322964f, -0.05816437f, 0.02000669f, 
    -0.01269999f, 0.00428476f, 0.02389555f, 0.00475012f, 0.03729723f, -0.02790341f, 0.04607887f, -0.05072723f, 
    -0.01333636f, -0.01537443f, 0.02842492f, 0.04697961f, -0.05944373f, -0.04276901f, 0.01029293f, -0.06331815f, 
    -0.01172504f, -0.05122756f, 0.03234509f, 0.04757307f, 0.01443913f, -0.05843954f, -0.02024547f, 0.02811526f, 
    0.03004913f, -0.03137710f, 0.01908552f, -0.02910720f, -0.04804658f, 0.04731942f, 0.00963701f, -0.04672920f, 
    -0.02519653f, -0.01080419f, 0.00077352f, -0.01828433f, -0.05286663f, 0.01848122f, -0.04104812f, 0.02080206f, 
    0.03900149f, 0.04232958f, -0.01614825f, -0.00843433f, 0.02232814f, 0.01054650f, -0.02686364f, 0.05292160f, 
    0.01839789f, 0.03651232f, 0.00850299f, 0.05051596f, -0.03528674f, 0.01820165f, 0.02857397f, -0.02747821f, 
    0.02503032f, -0.02730203f, 0.00065219f, 0.01349354f, 0.04513719f, 0.05913588f, 0.05062446f, -0.03950657f, 
    -0.00274279f, -0.04314558f, -0.00533014f, -0.01558237f, -0.04592263f, 0.02458147f, 0.03744623f, -0.05453203f, 
    -0.01478813f, -0.02186262f, 0.03438128f, 0.01062909f, 0.04288264f, -0.04622799f, 0.03145332f, -0.04374298f, 
    -0.05856932f, -0.03101374f, -0.03091571f, -0.01075732f, 0.03260535f, 0.04497185f, -0.06163840f, 0.00540915f, 
    0.02664251f, -0.00438980f, -0.02005872f, -0.05080086f, -0.02259923f, -0.00973395f, 0.02996043f, 0.00579845f, 
    -0.01641863f, -0.02022127f, -0.01397964f, -0.04776737f, 0.04040077f, -0.00730449f, -0.01699636f, -0.05573958f, 
    -0.02660301f, 0.11493855f, 0.15070294f, 0.05728973f, -0.08239937f, -0.01287956f, 0.08409119f, -0.12421517f, 
    -0.07708600f, -0.08484769f, 0.18831819f, 0.01843985f, -0.03193927f, -0.10136040f, -0.07648065f, 0.04766072f, 
    0.13117051f, 0.07561950f, -0.40666327f, -0.25072458f, 0.20466092f, 0.02368646f, -0.06119226f, 0.09407513f, 
    -0.12331711f, -0.09778285f, -0.34096763f, -0.07165121f, -0.03191305f, 0.08535936f, -0.12487669f, 0.08217795f, 
    0.08816493f, -0.07951742f, -0.15350088f, -0.08503593f, -0.07468373f, -0.06106804f, 0.00144291f, 0.04745157f, 
    0.10476773f, -0.07036374f, -0.09797678f, -0.10808484f, 0.12923919f, 0.24214293f, 0.01498422f, 0.02190172f, 
    -0.05275435f, -0.21310848f, -0.02403151f, 0.01282431f, 0.12280605f, -0.02820517f, -0.05987372f, -0.27243868f, 
    0.04449915f, -0.04015885f, 0.07055993f, 0.03075426f, -0.22674052f, 0.31283042f, 0.13541698f, 0.18573448f, 
    0.13991116f, 0.08859541f, -0.03076699f, 0.03181061f, -0.03290259f, 0.06413554f, 0.00822873f, -0.10754088f, 
    0.06693657f, 0.14912714f, 0.08200933f, 0.00171580f, -0.01816944f, -0.06285583f, -0.01746210f, -0.15208557f, 
    -0.22707792f, -0.01122805f, 0.06379510f, -0.00352426f, 0.05820099f, 0.22796479f, -0.07776922f, -0.13093498f, 
    -0.18058442f, -0.06652152f, -0.03153088f, -0.10964025f, 0.07733177f, 0.12664416f, 0.07137258f, -0.01477083f, 
    -0.11981509f, -0.32226810f, 0.08013429f, 0.03264322f, -0.00321312f, -0.03601388f, -0.05868072f, 0.04767694f, 
    0.10842554f, 0.05032589f, 0.02687255f, 0.04007629f, 0.03065065f, -0.53753144f, 0.06150981f, 0.07663067f, 
    -0.01793466f, 0.05218844f, 0.00885263f, -0.22942121f, -0.16420287f, 0.03671432f, 0.01351323f, 0.10855272f, 
    0.00933717f, 0.02820238f, 0.02859001f, -0.02803441f, 0.11327722f, 0.07770975f, -0.00802314f, -0.09123828f, 
    0.10254004f, -0.04690253f, 0.14535214f, 0.07401392f, -0.01616392f, -0.09711815f, -0.18062881f, -0.45175952f, 
    0.13786376f, -0.02627429f, -0.01683527f, 0.01873092f, 0.04845104f, -0.08699787f, 0.09947029f, 0.07646101f, 
    -0.05452640f, 0.06939664f, 0.09725588f, 0.22346564f, 0.31607401f, -0.03962127f, 0.09910935f, 0.03223544f, 
    0.17563291f, -0.07089440f, 0.14949860f, 0.02950153f, -0.02726332f, -0.24141827f, -0.19290906f, -0.09840901f, 
    -0.26910722f, -0.13482454f, -0.02207678f, 0.28383061f, 0.23701766f, -0.10076483f, 0.04979366f, -0.03428055f, 
    0.01337042f, 0.05241689f, 0.06451798f, -0.03098997f, 0.01535717f, 0.11266027f, -0.04696436f, 0.08109228f, 
    0.01773293f, -0.00129627f, -0.11875553f, -0.22110727f, 0.02900154f, -0.02427561f, -0.00972073f, 0.18530288f, 
    0.03594283f, 0.10612726f, -0.13529390f, -0.13675755f, -0.22242862f, 0.03662098f, -0.29409286f, -0.11545569f, 
    0.04948428f, 0.00357084f, 0.22486140f, -0.12983797f, 0.12019299f, 0.06063999f, -0.08826544f, -0.10701688f, 
    0.17722438f, 0.02160443f, -0.22408780f, -0.15968259f, -0.04123805f, -0.11455926f, -0.10956158f, -0.03953423f, 
    0.04067571f, 0.50402629f, 0.09629311f, 0.02391327f, 0.07490571f, 0.06612192f, 0.09813305f, 0.01567052f, 
    0.10552104f, 0.03155865f, 0.07626655f, -0.06592806f, -0.10024165f, -0.00410832f, 0.00371345f, 0.02987211f, 
    -0.02112315f, 0.01771720f, 0.03798489f, 0.17700067f, -0.07619306f, 0.09146905f, 0.07897187f, 0.03954480f, 
    0.10132697f, -0.15640986f, -0.05917093f, -0.06498499f, 0.32087526f, -0.03666496f, -0.13173829f, 0.19692373f, 
    -0.00738393f, 0.27522570f, -0.03600606f, -0.05338186f, -0.19487023f, -0.07832325f, 0.17635295f, 0.01791913f, 
    -0.03295776f, -0.20878309f, 0.16795294f, 0.00561478f, -0.02303923f, 0.09658308f, 0.03732862f, -0.03066315f, 
    0.11629652f, 0.12840264f, -0.35817805f, 0.08040951f, -0.02895407f, -0.29147413f, -0.44175333f, 0.04544179f, 
    0.01220817f, 0.04168521f, 0.11686888f, -0.00777028f, 0.01654742f, -0.07506757f, -0.04199320f, 0.00213339f, 
    0.04353264f, 0.10652455f, 0.13729621f, 0.14521962f, -0.06924417f, -0.04103321f, 0.03889096f, -0.08338333f, 
    -0.03388662f, 0.17948030f, -0.02929980f, 0.10833602f, 0.10980764f, -0.10579664f, 0.07955110f, -0.08812332f, 
    0.22192484f, -0.10241869f, 0.09607508f, -0.09710347f, -0.08175476f, -0.01605440f, -0.22716005f, -0.00634095f, 
    0.04830098f, -0.20588635f, -0.07786521f, 0.11380807f, -0.22505780f, -0.07220536f, -0.17799038f, -0.16283043f, 
    -0.07713194f, -0.08038240f, -0.25907061f, 0.18807915f, -0.21367599f, 0.38422695f, -0.34157923f, -0.02408311f, 
    -0.10050382f, 0.04535605f, 0.02119512f, -0.09025715f, -0.24563849f, -0.29210299f, 0.00753077f, 0.02957151f, 
    0.13233918f, 0.08544724f, -0.03106905f, 0.01778989f, -0.11394597f, -0.17575471f, -0.15802222f, 0.10728176f, 
    -0.09493143f, -0.11689594f, 0.09862351f, -0.00179432f, -0.01758284f, -0.02044816f, -0.33862081f, 0.00120871f, 
    0.13122767f, 0.06298468f, 0.15421848f, 0.14241351f, -0.03872528f, -0.08683905f, -0.06339931f, -0.03789483f, 
    0.00684441f, 0.04646948f, -0.00348669f, 0.07644407f, 0.04587540f, -0.06653381f, 0.02471243f, -0.05679469f, 
    0.13657121f, 0.22545896f, -0.14412433f, -0.03346716f, 0.01197506f, -0.04883605f, -0.00656456f, -0.04434668f, 
    -0.10541808f, 0.10371326f, 0.23077588f, -0.14846654f, 0.03773231f, -0.13040657f, -0.06367239f, 0.08325341f, 
    0.04437747f, 0.27856624f, -0.11303568f, -0.41259748f, 0.06388380f, 0.04140836f, 0.26357865f, -0.12000888f, 
    -0.12315894f, -0.00524863f, 0.55583119f, -0.04312846f, -0.19891292f, -0.02559004f, -0.01223037f, 0.12716971f, 
    -0.13516301f, -0.01217546f, -0.11751892f, -0.03546470f, -0.06491330f, 0.13074911f, 0.05730683f, 0.12015132f, 
    0.06817601f, 0.00721916f, 0.05281703f, -0.27384755f, 0.32666966f, 0.05009899f, 0.34408844f, -0.32493615f, 
    -0.09151507f, 0.11916447f, -0.09671954f, 0.00689802f, -0.08376436f, -0.05764770f, -0.11097901f, -0.08694947f, 
    -0.01441372f, 0.03193866f, 0.04190221f, 0.05407098f, 0.14079307f, -0.06845673f, 0.19179828f, -0.08558235f, 
    0.00560469f, 0.15172343f, -0.06957619f, 0.14600201f, -0.00171808f, -0.08625546f, 0.08598133f, 0.21826012f, 
    -0.39430162f, -0.68093377f, 0.01226252f, -0.07768419f, -0.00371011f, 0.11760648f, 0.28915578f, 0.01488009f, 
    0.14625883f, 0.14339100f, 0.04347566f, 0.04407488f, 0.10341340f, 0.01065132f, -0.07445420f, -0.16747501f, 
    -0.07735480f, -0.19243467f, -0.12816349f, 0.07420994f, 0.02320302f, -0.09062992f, 0.08574855f, -0.22265589f, 
    0.01664105f, 0.01249724f, -0.00615442f, 0.00752138f, 0.08634473f, 0.18185692f, 0.22402991f, 0.07661512f, 
    -0.12756984f, -0.09486002f, -0.14944346f, -0.04083818f, -0.17527139f, -0.12724301f, 0.05266468f, 0.06622658f, 
    0.23693143f, 0.12963015f, -0.01564921f, 0.13411325f, -0.41368952f, 0.08558085f, -0.01146443f, 0.09884667f, 
    -0.03988409f, 0.05715700f, 0.12359314f, 0.03097113f, 0.18341435f, -0.28062844f, 0.06113358f, -0.09859499f, 
    0.10937546f, -0.01969963f, -0.07125027f, 0.21262901f, -0.00358279f, 0.09683172f, 0.02754385f, 0.00969692f, 
    0.08755655f, 0.04741557f, 0.07629109f, 0.11556742f, -0.04839110f, 0.10512785f, 0.01482519f, 0.49385354f, 
    0.08718748f, 0.07242769f, -0.07224896f, -0.00085636f, 0.13195528f, 0.09422960f, -0.02486827f, -0.11433642f, 
    -0.00345053f, 0.01852940f, -0.06866592f, 0.05474455f, -0.01397300f, 0.05590498f, 0.09760155f, 0.03136554f, 
    0.07185735f, 0.24350566f, 0.04455884f, 0.28123781f, -0.09783833f, -0.23865977f, 0.00889182f, -0.07839407f, 
    0.01144596f, -0.07595293f, -0.15266320f, 0.08885514f, -0.05337910f, -0.09439617f, 0.04270884f, -0.01161667f, 
    0.29886988f, -0.06629553f, -0.00702161f, -0.17073213f, -0.27103180f, -0.26908550f, 0.11586155f, -0.01568401f, 
    0.21754111f, 0.03954757f, -0.05800032f, 0.10315566f, -0.43299249f, -0.14687182f, -0.35528693f, 0.09080600f, 
    -0.07596068f, -0.05299819f, 0.20407425f, -0.16893637f, 0.20216462f, 0.33687496f, 0.11410698f, 0.18117566f, 
    -0.23346427f, -0.04653481f, 0.08062490f, -0.02692352f, 0.02015990f, 0.07023069f, -0.14463231f, -0.14166453f, 
    -0.27776173f, 0.08774550f, 0.02844368f, 0.00902177f, 0.05267757f, 0.08673993f, 0.06248423f, 0.33533245f, 
    -0.08049501f, -0.14098851f, -0.20398526f, -0.11550321f, 0.04314666f, 0.14664337f, 0.13491677f, -0.03819150f, 
    -0.24113147f, 0.08177637f, 0.00328248f, -0.06638935f, 0.00412703f, 0.21292083f, 0.14502943f, 0.09725257f, 
    0.08320553f, -0.41209155f, -0.17732117f, 0.00294491f, -0.10556392f, -0.16218060f, 0.09228117f, -0.14012204f, 
    -0.00685387f, -0.03627325f, -0.53444839f, -0.75659204f, -0.15458611f, -0.12733179f, 0.24245045f, -0.18606329f, 
    0.13671593f, 0.02208162f, 0.02322264f, 0.11325577f, 0.10963465f, 0.00763864f, -0.07386945f, 0.05053856f, 
    -0.18209928f, -0.14791997f, -0.03435358f, 0.02110363f, -0.33372229f, 0.03558299f, -0.46855193f, 0.04820682f, 
    0.04582062f, 0.05343206f, 0.08562163f, 0.13981560f, 0.03538697f, -0.22188848f, -0.03633620f, 0.14565383f, 
    0.13266146f, 0.28066856f, -0.22590491f, 0.09390616f, -0.03352230f, 0.07045340f, 0.09112819f, -0.17468333f, 
    -0.20930922f, 0.04519415f, -0.03846695f, -0.15613526f, -0.09716389f, 0.10054778f, 0.11441405f, 0.19680913f, 
    0.03348952f, 0.07843231f, -0.00422820f, 0.03443274f, 0.10435552f, 0.16454719f, 0.07100466f, -0.06968176f, 
    -0.05129180f, 0.00472378f, 0.09212535f, 0.02474671f, 0.02692328f, 0.06092441f, 0.12999900f, 0.06675245f, 
    0.04378723f, 0.22036560f, 0.10439258f, -0.22227348f, -0.26919270f, 0.01690316f, 0.16337959f, 0.10768120f, 
    0.05251307f, -0.10865554f, 0.05662660f, 0.10066264f, -0.23634851f, -0.12489031f, -0.22992443f, -0.09010196f, 
    -0.14653109f, 0.15472539f, -0.08256422f, 0.22814353f, 0.07132652f, -0.05575240f, -0.02783961f, -0.07407273f, 
    -0.00780179f, 0.02286960f, 0.06221209f, -0.02485622f, -0.08882125f, 0.00879485f, 0.26690808f, 0.02319320f, 
    0.06306470f, -0.06109010f, -0.00462635f, 0.13635445f, -0.05383298f, 0.17977913f, 0.05840579f, -0.18979999f, 
    -0.19697462f, -0.05671597f, 0.05721230f, 0.02786879f, 0.11931681f, 0.12224194f, -0.06458549f, -0.00004523f, 
    -0.03681493f, 0.00755652f, -0.12741961f, -0.04901659f, 0.02568016f, -0.10160778f, -0.15870398f, 0.60673076f, 
    -0.88467956f, -0.33816546f, -0.06690590f, 0.06204190f, 0.02684677f, -0.22960559f, -0.03535725f, -0.07072051f, 
    0.18266411f, 0.01200976f, -0.45581791f, -0.07823918f, -0.02071308f, 0.05579471f, 0.06201598f, -0.01503520f, 
    -0.11990451f, -0.42338657f, 0.01077882f, -0.02540187f, -0.06830528f, 0.05495929f, 0.04390926f, -0.03466042f, 
    0.02969094f, 0.11463994f, 0.19854771f, -0.02763972f, 0.13468862f, 0.09973375f, 0.00770466f, -0.11676998f, 
    0.03257284f, -0.05767541f, -0.06881709f, 0.02139504f, 0.09351804f, -0.04857508f, 0.01465048f, -0.10763061f, 
    -0.15282984f, 0.02614092f, -0.09367409f, -0.01852037f, -0.01094610f, -0.05518615f, -0.04698470f, -0.02641875f, 
    0.15991135f, -0.11886097f, 0.08295114f, -0.07167438f, 0.13894163f, 0.56786770f, -0.06626689f, -0.16767372f, 
    0.07681740f, 0.11212726f, -0.03989639f, 0.03664738f, -0.17779344f, 0.10486306f, -0.27041692f, -0.08233032f, 
    0.00459960f, -0.02705760f, 0.14405759f, -0.00178875f, -0.01760864f, 0.01854330f, 0.09037076f, 0.12075949f, 
    0.01485518f, 0.16319945f, -0.10960423f, 0.05222857f, -0.03091992f, 0.06087295f, -0.06872100f, -0.10409344f, 
    0.09833099f, 0.16024412f, -0.08914778f, -0.12178281f, -0.00878125f, -0.07859099f, 0.17892855f, 0.10298831f, 
    0.19476375f, 0.02409992f, -0.07227926f, 0.32026476f, -0.05295772f, -0.02836964f, -0.08268888f, 0.08535367f, 
    0.03541441f, -0.11950054f, 0.36929372f, 0.06900475f, 0.14419894f, -0.21877514f, -0.03606175f, 0.15696114f, 
    0.10428879f, 0.04505158f, -0.01905112f, -0.42981809f, -0.47065550f, -0.74330997f, 0.04180181f, -0.02490227f, 
    -0.16557808f, 0.02727828f, -0.12237560f, 0.03900695f, 0.41401452f, -0.54607761f, -0.31032816f, 0.15182768f, 
    -0.11329739f, 0.00998055f, 0.23085640f, -0.05111158f, -0.14689705f, -0.10780580f, 0.21457593f, 0.21076579f, 
    -0.12603921f, -0.04004775f, 0.03703368f, 0.02233906f, 0.12134711f, 0.17721802f, 0.61636370f, -0.28916448f, 
    -0.03792148f, 0.12013392f, -0.08175345f, 0.14505377f, 0.11295762f, 0.14711687f, 0.02137105f, 0.00777884f, 
    -0.43413135f, -0.00585772f, -0.06236053f, 0.05219268f, 0.17809880f, 0.08161376f, 0.09188565f, -0.03532145f, 
    0.26916915f, 0.10529631f, -0.01988952f, 0.13286231f, 0.09319220f, 0.18333474f, 0.13632922f, 0.00376965f, 
    -0.08149357f, 0.03748991f, 0.03263487f, 0.05171448f, -0.24409638f, -0.09811668f, 0.01069717f, -0.26912162f, 
    -0.03063302f, -0.01715652f, -0.50171107f, -0.46029988f, -0.09800852f, -0.23136583f, -0.10280848f, 0.04990838f, 
    0.09881059f, 0.05320232f, -0.11794183f, -0.13863793f, 0.08174460f, 0.22487614f, -0.16003574f, -0.03958749f, 
    -0.15855351f, -0.21966520f, -0.04783627f, -0.16951430f, 0.40310428f, 0.16338706f, 0.20708072f, 0.21790464f, 
    0.01611007f, 0.02224270f, 0.16628668f, -0.00419672f, -0.09977731f, -0.14423303f, -0.28887099f, -0.08903270f, 
    0.02662209f, 0.01620619f, 0.17866591f, 0.05086493f, -0.05327998f, 0.02716481f, -0.27158338f, -0.18235333f, 
    -0.07960010f, -0.08250072f, -0.06200084f, -0.04777702f, 0.07897841f, -0.10425415f, 0.10859047f, -0.02335452f, 
    -0.03149813f, -0.00534411f, -0.06791345f, -0.07599420f, 0.03404263f, 0.03021944f, 0.09728879f, -0.08689775f, 
    0.20478861f, -0.03879041f, 0.00773848f, 0.11922505f, -0.08152688f, 0.26928470f, 0.08255774f, 0.10449440f, 
    0.01183687f, -0.06656145f, -0.05039922f, -0.04736723f, 0.01316512f, -0.03135093f, 0.04258914f, 0.05985659f, 
    -0.03886396f, -0.07887306f, -0.01648219f, 0.06035826f, 0.21529134f, -0.15584148f, -0.24623621f, -0.13762598f, 
    -0.24909173f, -0.11762942f, -0.07207309f, -0.02532220f, -0.09196999f, 0.11457743f, 0.21555120f, 0.04709335f, 
    0.06914631f, -0.04805278f, 0.15953878f, 0.23530227f, -0.32371214f, -0.14486735f, -0.22179620f, -0.30875134f, 
    -0.46175650f, -0.12335274f, 0.20484467f, -0.05731252f, 0.02672839f, -0.00563932f, 0.13652341f, 0.06368684f, 
    0.14692971f, -0.02784727f, 0.07047020f, 0.05372156f, -0.00965775f, 0.09323112f, -0.06671640f, 0.07034033f, 
    0.08872852f, -0.01656969f, -0.05261827f, 0.00283971f, 0.13598722f, 0.06938959f, 0.17810243f, 0.43248007f, 
    -0.06152277f, -0.40519357f, 0.01296252f, 0.06996880f, 0.05390289f, -0.05056468f, 0.10997796f, 0.00621006f, 
    -0.03662004f, -0.25180048f, -0.19949229f, 0.05983880f, -0.00424139f, -0.22051196f, 0.02154946f, 0.12729819f, 
    0.03320057f, 0.13597798f, 0.20602451f, -0.01709406f, -0.14097296f, 0.13316230f, 0.03269021f, 0.01489457f, 
    -0.04018246f, -0.25038728f, -0.05969935f, -0.14882731f, -0.05802143f, -0.14016326f, 0.04461261f, -0.08831982f, 
    -0.05630352f, 0.08233584f, 0.08095694f, -0.24490097f, 0.14655858f, 0.14436641f, -0.11556012f, 0.02318208f, 
    -0.11066591f, -0.17872030f, -0.07371196f, 0.01314778f, 0.09452867f, 0.02045534f, -0.05565137f, -0.11633546f, 
    -0.09314185f, -0.04046173f, -0.03806475f, 0.21294905f, 0.00222797f, -0.36244658f, -0.13675354f, -0.13824567f, 
    -0.02199122f, 0.03793253f, 0.06428605f, 0.19122374f, 0.12854132f, 0.18969736f, 0.06131616f, 0.08087841f, 
    0.18194588f, -0.08007830f, 0.09698232f, 0.06036466f, 0.14369512f, -0.15680788f, -0.09614595f, 0.17108589f, 
    -0.11898696f, -0.03499487f, -0.11010193f, 0.01621938f, 0.08309669f, -0.08079997f, 0.05293146f, 0.01216808f, 
    -0.14582498f, 0.06110289f, -0.05197247f, 0.01731721f, -0.13040835f, 0.00015235f, 0.12164444f, 0.07438282f, 
    -0.10094898f, 0.10227111f, -0.11483245f, -0.15139018f, -0.13088979f, -0.05267606f, 0.09976999f, 0.03369913f, 
    0.08228479f, 0.13969174f, -0.39163539f, -0.35309392f, 0.04247989f, -0.08466382f, 0.02075231f, 0.17038223f, 
    0.13921674f, 0.04125130f, -0.01025770f, 0.09012178f, 0.23505032f, -0.25717631f, 0.09247133f, -0.16119076f, 
    -0.03970548f, -0.03566227f, -0.16094922f, 0.14434396f, 0.29159060f, -0.04987180f, -0.14328100f, -0.34739596f, 
    0.17106642f, -0.17572799f, -0.18644805f, 0.20502481f, 0.12796402f, 0.06352222f, -0.02760694f, 0.06218904f, 
    0.12663476f, -0.07620095f, -0.04229021f, 0.04417343f, -0.02553675f, 0.16968815f, 0.50351542f, -0.00832281f, 
    -0.19508290f, 0.05750193f, 0.06608345f, 0.06055730f, 0.02114672f, 0.07111835f, 0.03050595f, 0.07232908f, 
    -0.01609680f, -0.30845582f, 0.10975818f, 0.07094280f, -0.01483751f, -0.02085060f, -0.02116416f, -0.25499374f, 
    0.01592503f, 0.03194597f, 0.02828990f, 0.03890506f, -0.04613880f, -0.00657041f, -0.03110584f, -0.02781653f, 
    0.00079607f, 0.04776924f, -0.05499721f, 0.05434918f, -0.03829926f, -0.05540306f, 0.00518914f, 0.03156814f, 
    -0.02779203f, 0.01779308f, -0.05559780f, -0.01249087f, 0.00727337f, 0.00596987f, 0.02137193f, -0.05357387f, 
    -0.06058653f, 0.01133861f, -0.02302817f, -0.05659951f, 0.01653565f, -0.01464156f, 0.03251706f, 0.03793203f, 
    -0.05713245f, -0.05264986f, 0.05095548f, -0.00536659f, -0.00096112f, -0.04627349f, -0.06567241f, 0.01807220f, 
    -0.05119111f, -0.02309006f, -0.02271819f, 0.00369740f, -0.04337833f, -0.03636906f, -0.03256164f, -0.04540522f, 
    0.02207525f, -0.03288905f, 0.03605549f, -0.02269672f, -0.04280178f, -0.01133885f, -0.06399402f, 0.03606242f, 
    -0.02903205f, 0.00381286f, 0.00051649f, -0.04784643f, -0.01802602f, 0.03405667f, 0.02341305f, -0.00789113f, 
    0.02206515f, 0.05112447f, 0.02212961f, 0.02689305f, 0.02817323f, -0.04990511f, 0.03356041f, -0.02861762f, 
    -0.01794360f, 0.03216277f, 0.01897154f, 0.03951535f, -0.02777958f, -0.00345961f, -0.03358148f, -0.04471293f, 
    0.03096880f, -0.02311533f, -0.04755502f, -0.01031448f, 0.04581778f, -0.03633953f, -0.00951676f, -0.06584005f, 
    0.04019952f, -0.04331648f, 0.01425597f, -0.00951557f, 0.04236604f, 0.01278403f, -0.06447817f, 0.01295988f, 
    0.01218530f, -0.03816466f, -0.01764623f, 0.01591115f, 0.03032209f, 0.03258777f, -0.00506862f, 0.01648463f, 
    0.00564054f, -0.03370899f, 0.03683152f, -0.04110216f, -0.03910481f, 0.03393051f, 0.04028711f, -0.01800802f, 
    0.03414566f, 0.00654603f, -0.06071339f, 0.04637241f, -0.02938679f, -0.01648789f, -0.04708558f, 0.05114403f, 
    0.00327029f, 0.04408933f, 0.03065525f, 0.00139070f, -0.02750824f, -0.06646753f, 0.04365583f, -0.02053596f, 
    -0.05899747f, -0.03152210f, 0.00917003f, -0.00170946f, 0.03979150f, 0.02569192f, 0.04564561f, 0.00067242f, 
    0.01657784f, -0.01074249f, -0.01237093f, 0.03849408f, -0.01545937f, -0.03312356f, -0.03091827f, -0.04344511f, 
    0.04245433f, 0.02754921f, -0.03607523f, -0.00268039f, -0.01616347f, -0.03023085f, -0.03581451f, 0.00348262f, 
    0.02402301f, -0.02212226f, -0.06777449f, 0.03660874f, -0.02105243f, -0.02116781f, 0.01751178f, -0.00155439f, 
    0.04278116f, 0.02688856f, -0.06332485f, 0.03573406f, 0.02172751f, 0.01808150f, -0.05582741f, -0.04529994f, 
    0.00265331f, -0.03202997f, -0.05157911f, -0.04582646f, -0.00726407f, 0.03508503f, -0.00512900f, -0.02548236f, 
    0.04543056f, 0.02500017f, -0.06692429f, -0.05972063f, -0.04028040f, 0.00836834f, 0.02598856f, 0.00142103f, 
    0.01886249f, 0.04534027f, -0.05080190f, 0.00978285f, -0.03988370f, -0.00000164f, 0.01826125f, 0.00332238f, 
    0.01804631f, 0.01666727f, -0.00938097f, -0.02570995f, 0.03396606f, -0.05013545f, -0.01667746f, 0.01388064f, 
    0.01115184f, -0.05631804f, -0.05101133f, -0.01209825f, -0.03298735f, 0.01747700f, 0.04592871f, -0.00253028f, 
    -0.02255390f, -0.02955467f, -0.04765904f, -0.01989014f, 0.00068559f, 0.03458592f, 0.00331741f, 0.02793991f, 
    0.02317626f, -0.02423525f, -0.01542713f, 0.04313895f, -0.06607042f, 0.00532112f, 0.00742926f, -0.02005539f, 
    -0.06075653f, -0.05145800f, 0.01792724f, -0.03161387f, 0.01784197f, -0.02616522f, -0.05279785f, -0.05867741f, 
    0.00310390f, -0.01524153f, -0.05905268f, -0.03095338f, -0.02572034f, -0.06599512f, -0.04715569f, -0.04674094f, 
    0.00418575f, -0.00665317f, 0.01545630f, -0.01205178f, -0.00601611f, 0.04876498f, -0.03262877f, -0.05913887f, 
    -0.00954752f, -0.01318657f, -0.00417966f, -0.03202284f, 0.01789122f, -0.00745110f, -0.00448582f, -0.04241357f, 
    0.02598194f, 0.00381423f, 0.00389520f, -0.02158115f, 0.04051233f, -0.03959054f, 0.03201472f, 0.02496424f, 
    -0.03209964f, -0.04105943f, -0.05025029f, -0.02117708f, -0.02405400f, -0.03872341f, -0.02918390f, -0.06132450f, 
    -0.00699193f, 0.04743869f, 0.01739458f, -0.03288228f, -0.03306140f, -0.06412883f, -0.01761816f, -0.03964546f, 
    0.02630887f, 0.04291456f, -0.03139610f, -0.02730856f, -0.01452819f, 0.03750705f, -0.02290886f, 0.03799248f, 
    0.00593278f, 0.20355482f, 0.01109203f, -0.01573140f, 0.03182190f, 0.03010681f, -0.07222921f, 0.02088495f, 
    -0.07373075f, 0.18093292f, 0.02175387f, 0.11655478f, -0.08703351f, 0.01107215f, -0.04652253f, 0.00581392f, 
    -0.05018618f, 0.24831991f, 0.11231527f, 0.20715855f, -0.15912771f, 0.09846411f, 0.17104186f, -0.14493647f, 
    -0.06859588f, -0.15022872f, -0.09316309f, -0.20577262f, -0.10569718f, -0.05748902f, 0.13339877f, -0.11435081f, 
    -0.04510040f, -0.39614266f, 0.10872735f, -0.17239437f, 0.11241486f, 0.00627413f, 0.06272598f, 0.00982548f, 
    0.14926223f, -0.05699216f, 0.04090185f, 0.11992200f, 0.07686005f, 0.04544927f, -0.11251394f, -0.21714056f, 
    -0.02132392f, 0.00566036f, -0.26357287f, 0.06790954f, 0.12319250f, 0.16285682f, -0.33585384f, 0.08056336f, 
    -0.02555856f, -0.02824940f, 0.02114914f, 0.10615765f, 0.07480948f, 0.24462397f, -0.13162360f, 0.03353150f, 
    0.03461703f, 0.09016310f, 0.01035175f, -0.05406016f, 0.08290219f, -0.01745661f, 0.03959275f, -0.21343505f, 
    0.10065563f, 0.00752260f, -0.03699498f, -0.03474206f, -0.02816755f, -0.00338156f, 0.03798252f, -0.03532214f, 
    0.03429096f, -0.22781818f, 0.21613030f, -0.18815245f, 0.41129741f, -0.04506769f, -0.00564246f, -0.04582009f, 
    0.10805132f, 0.01731095f, -0.24159484f, -0.00321141f, -0.11494655f, 0.09541752f, 0.01764859f, 0.18060243f, 
    -0.23727174f, -0.06006259f, -0.32826808f, 0.10390199f, 0.08335679f, 0.05567216f, -0.22352304f, -0.19067416f, 
    -0.05822778f, 0.11560620f, 0.04971728f, 0.08381014f, -0.13076927f, -0.03211518f, 0.02337899f, 0.14824615f, 
    -0.00192939f, 0.11185624f, -0.22029623f, -0.10301775f, -0.52554709f, -0.12855843f, -0.01370513f, -0.06281020f, 
    -0.14392029f, -0.07572437f, -0.13427679f, -0.01874929f, 0.12306147f, 0.10806933f, -0.27877870f, -0.13039206f, 
    -0.05409991f, 0.01003999f, 0.09691393f, 0.00075845f, -0.21600232f, 0.01187545f, -0.18835656f, 0.03506153f, 
    0.27761298f, 0.08697354f, 0.24753879f, -0.15083025f, -0.09401292f, 0.03696099f, 0.15035433f, -0.06592787f, 
    0.02648202f, 0.42317587f, 0.05421444f, -0.05629583f, 0.19616395f, 0.10196683f, 0.11252941f, 0.32098740f, 
    0.03697444f, 0.17577383f, -0.02370750f, -0.17102870f, -0.11097134f, -0.08141100f, 0.06210530f, 0.03787501f, 
    -0.11891912f, 0.01322546f, 0.26993692f, -0.11131789f, 0.08388141f, -0.07515387f, 0.00087966f, -0.02323323f, 
    0.09349901f, -0.02978230f, -0.02758233f, -0.19845970f, -0.10851991f, 0.02703086f, -0.04091634f, -0.05121113f, 
    0.05741206f, -0.28288001f, -0.07184847f, -0.47112051f, -0.20452145f, -0.15451866f, 0.01973954f, 0.20775218f, 
    0.19829324f, -0.13683298f, -0.16438870f, -0.09951071f, -0.14352086f, -0.50355399f, -0.14507680f, 0.08095847f, 
    -0.03679927f, 0.02614127f, 0.00505390f, -0.07039424f, -0.11880492f, 0.07999913f, 0.00786747f, -0.04746857f, 
    -0.21448539f, 0.06416856f, -0.01431211f, 0.02443866f, -0.02450759f, -0.08112321f, -0.01169886f, 0.25198311f, 
    0.08896580f, -0.02510647f, 0.02431190f, -0.08776741f, -0.04185475f, -0.04433549f, 0.06332605f, 0.06453267f, 
    -0.19204685f, -0.12742081f, -0.15700342f, 0.00178041f, -0.02006680f, -0.04436490f, -0.10989738f, 0.04892539f, 
    0.14516522f, 0.07903626f, -0.03564953f, 0.04177834f, 0.06606138f, -0.00440659f, 0.11250911f, 0.04330716f, 
    -0.04476739f, -0.14929476f, -0.24300633f, 0.12242321f, -0.04783894f, 0.02581278f, 0.08963629f, 0.10871016f, 
    0.08976310f, 0.21771368f, 0.27248597f, -0.19839773f, 0.14112733f, 0.03299420f, -0.04500961f, 0.01032837f, 
    0.00700497f, -0.06250076f, 0.27618375f, -0.07078259f, -0.00207495f, 0.29124507f, 0.03417736f, 0.14568596f, 
    0.17174815f, 0.17646314f, -0.15336776f, 0.22744721f, 0.30993575f, 0.02785988f, 0.13848427f, 0.00952704f, 
    0.14903745f, 0.10404691f, 0.16933899f, -0.04823675f, 0.05555035f, -0.26876807f, 0.19751984f, 0.17397238f, 
    0.13457778f, 0.12785710f, 0.04596660f, 0.02399229f, 0.02766867f, -0.02476114f, 0.06584752f, 0.26145947f, 
    0.19603039f, -0.00401873f, 0.12572409f, -0.12918778f, 0.07037812f, 0.14481534f, 0.11621965f, -0.04607638f, 
    -0.31887168f, 0.10476509f, -0.14951386f, -0.05030967f, 0.05042804f, 0.18694322f, -0.11690459f, -0.04645513f, 
    -0.02165671f, 0.16260530f, 0.31827495f, 0.22443725f, -0.11065026f, -0.06334369f, 0.04516518f, 0.05195136f, 
    -0.02294323f, 0.25176665f, -0.08102843f, -0.02276383f, -0.28891045f, -0.10869306f, 0.12178556f, -0.02116534f, 
    0.14466396f, -0.01030794f, -0.24213934f, 0.02914752f, 0.27810401f, 0.07388428f, 0.07522006f, 0.08622785f, 
    -0.04075496f, 0.04868499f, -0.11770219f, -0.10032585f, -0.13569552f, -0.20892301f, 0.06854200f, 0.08606270f, 
    0.20348585f, 0.02197042f, 0.09650224f, 0.00376051f, -0.01493587f, 0.15073939f, -0.10788798f, -0.43367946f, 
    -0.04749928f, -0.01066756f, -0.08111376f, 0.10690374f, 0.07114745f, 0.17608920f, 0.05964651f, 0.04415641f, 
    0.15000534f, 0.04345004f, -0.10831150f, -0.14465229f, -0.12737319f, 0.16847889f, 0.16624236f, -0.08282094f, 
    0.30967540f, 0.27608329f, 0.07727417f, -0.00326032f, -0.07511771f, 0.10887288f, -0.08156992f, 0.02417416f, 
    -0.06810854f, 0.21878003f, -0.35618681f, 0.07002830f, 0.11110847f, -0.02179077f, 0.20760058f, -0.06476254f, 
    0.04170088f, 0.22405703f, 0.02216997f, -0.02985712f, -0.20775777f, 0.15268071f, -0.17408545f, -0.16224274f, 
    0.05609807f, -0.00024113f, 0.00157595f, 0.05785283f, 0.18791281f, 0.19121937f, 0.04803322f, -0.13236563f, 
    -0.25807944f, -0.06873197f, -0.20048317f, -0.27444059f, -0.12219874f, -0.12727408f, 0.09403218f, -0.02146558f, 
    0.02067358f, 0.05875977f, 0.07132001f, 0.04619602f, -0.16624336f, 0.05469671f, 0.19108917f, 0.08133422f, 
    -0.07218685f, 0.08774205f, 0.10553879f, 0.01027279f, 0.20418178f, -0.00025251f, -0.02059508f, 0.01661873f, 
    -0.18211693f, -0.12151431f, -0.05668610f, 0.02333697f, 0.23521362f, 0.12355865f, 0.11081515f, -0.13651244f, 
    0.01881234f, 0.07928381f, -0.15755260f, -0.02702749f, -0.11458830f, -0.11079884f, 0.04569948f, -0.11734728f, 
    0.32865468f, 0.29349467f, 0.12566251f, -0.10402279f, -0.22473054f, -0.09767408f, -0.10048489f, 0.19140393f, 
    -0.21166666f, -0.01334715f, -0.16265631f, -0.01681266f, 0.05099112f, 0.15247099f, -0.01420751f, 0.07748907f, 
    -0.13576752f, 0.10044845f, 0.11208159f, -0.35761833f, -0.06279388f, -0.05169442f, -0.05400604f, 0.00740317f, 
    -0.18057999f, -0.07461804f, 0.03835108f, -0.00574832f, 0.17080709f, 0.04775433f, -0.01569156f, 0.03520625f, 
    -0.04076772f, -0.03938003f, 0.04676019f, 0.12865400f, 0.18732914f, 0.11311174f, 0.03345548f, -0.18651742f, 
    -0.05370765f, 0.06036394f, -0.26067621f, -0.02498112f, 0.15965810f, 0.03895848f, -0.07371567f, 0.05483309f, 
    0.06523314f, -0.18785176f, 0.11813813f, -0.07669297f, -0.06558675f, -0.08118909f, -0.02729849f, -0.34533238f, 
    0.00516777f, -0.11710952f, -0.10952916f, 0.28623545f, -0.06347272f, -0.13831231f, 0.01822752f, -0.21730699f, 
    -0.32223320f, -0.08022495f, 0.00380345f, -0.22445458f, 0.06223309f, -0.09054713f, -0.17097709f, -0.10666110f, 
    0.13852116f, 0.35639888f, 0.06129448f, -0.00556258f, 0.07110159f, -0.02144619f, -0.13724270f, 0.08153372f, 
    0.20294292f, 0.08267596f, 0.06274758f, -0.17036302f, -0.25695047f, -0.06042432f, 0.07195085f, 0.18999454f, 
    0.12735787f, -0.05602269f, 0.17424551f, 0.14188084f, -0.06421389f, -0.08549047f, -0.01127510f, 0.14100415f, 
    -0.14457300f, 0.07791290f, -0.03342631f, 0.22738251f, -0.35207871f, -0.03816405f, 0.09844782f, 0.01995792f, 
    -0.00464229f, 0.04667000f, -0.05957242f, 0.02162814f, 0.03850605f, 0.49525553f, 0.04248016f, -0.09777297f, 
    -0.07261013f, 0.03593766f, 0.02299953f, 0.11467812f, 0.27020863f, 0.33440283f, -0.18828580f, -0.08934480f, 
    0.17927167f, 0.07326081f, 0.07015277f, -0.08854103f, 0.15383020f, -0.16886570f, -0.03488664f, 0.03679348f, 
    0.00670312f, -0.00694145f, 0.09444643f, 0.20703019f, -0.12441973f, -0.08353814f, 0.20959319f, -0.04529893f, 
    -0.09936488f, 0.06125274f, 0.17002364f, -0.04936883f, 0.06507310f, -0.12004273f, 0.08488674f, 0.17162071f, 
    -0.13718061f, 0.06594923f, 0.03213758f, -0.01229813f, 0.05858093f, 0.10918127f, -0.02101497f, 0.16733369f, 
    -0.11254489f, 0.05084788f, 0.15740493f, -0.00471244f, 0.04863612f, -0.04123883f, 0.10340481f, 0.06070156f, 
    0.06383900f, 0.26845986f, 0.23356594f, 0.25610358f, 0.07129554f, -0.04568980f, 0.01352291f, 0.19518401f, 
    0.00969636f, 0.04666876f, 0.05727457f, -0.07201906f, -0.07104097f, -0.17006981f, -0.10897004f, 0.36747605f, 
    0.07034077f, 0.03065989f, -0.22405896f, -0.37945965f, -0.17777504f, -0.37544516f, 0.01672718f, -0.02531041f, 
    0.01520258f, 0.17056443f, -0.08806264f, -0.11575183f, -0.21096787f, -0.36269578f, -0.20702340f, -0.04292772f, 
    0.01436129f, 0.04583177f, -0.03691535f, -0.00730250f, 0.04018029f, 0.18931414f, 0.08153304f, 0.14107952f, 
    0.05646359f, 0.05836295f, 0.22162825f, 0.04023523f, -0.01153571f, 0.05036072f, 0.09991787f, -0.47610107f, 
    0.05007919f, -0.13021298f, -0.03379325f, -0.32408544f, -0.04028209f, -0.04289288f, -0.03820973f, 0.10043702f, 
    0.27297515f, 0.14765228f, -0.09681505f, -0.07579013f, -0.09979411f, -0.06390121f, -0.10653782f, 0.02595584f, 
    0.08660895f, 0.05140816f, 0.09979908f, 0.08687121f, 0.02851941f, -0.04182207f, 0.20255280f, 0.00195317f, 
    -0.06221431f, -0.32474518f, -0.62902004f, -0.27180871f, -0.07683939f, -0.27790675f, 0.14078730f, -0.00184873f, 
    0.08615372f, 0.03871386f, -0.20019257f, -0.04891362f, 0.17358346f, -0.03697720f, 0.00829592f, 0.08283971f, 
    0.09379472f, 0.06721743f, 0.20905697f, 0.15393262f, 0.18218531f, 0.09948025f, -0.03483179f, 0.00408064f, 
    -0.06363470f, 0.09860063f, 0.02712834f, 0.12375157f, 0.05916628f, 0.14465258f, 0.11859141f, 0.09152112f, 
    0.00812177f, -0.16894214f, 0.05466292f, -0.01252787f, -0.00812306f, 0.09306242f, -0.13552438f, -0.13302259f, 
    -0.01841155f, 0.09213588f, -0.06799921f, 0.29539165f, -0.00301195f, 0.08780940f, -0.34712896f, -0.24631625f, 
    -0.28897181f, -0.00202978f, -0.01173590f, -0.09320223f, -0.00681010f, 0.10489798f, -0.05926337f, -0.48195511f, 
    -0.13066913f, -0.13020205f, -0.20217031f, -0.11934994f, -0.08127463f, 0.16128245f, 0.11269137f, 0.06450956f, 
    0.05659316f, -0.04939966f, -0.13460569f, -0.03166853f, -0.17576596f, -0.23839730f, 0.12198413f, 0.10633927f, 
    0.11981805f, 0.24159451f, -0.04021437f, 0.33176574f, 0.12160791f, 0.11879008f, 0.13930228f, 0.07442164f, 
    0.01443339f, -0.04064644f, 0.11263613f, 0.29190812f, 0.06264438f, -0.01149730f, 0.19111365f, 0.08414645f, 
    0.11185844f, 0.11070303f, -0.01760644f, -0.23502688f, -0.53296816f, -0.68848795f, 0.06652767f, 0.04793361f, 
    -0.07779865f, -0.07440943f, 0.03487822f, -0.01078217f, 0.58299285f, -0.43622261f, -0.35647646f, -0.07512560f, 
    0.01263461f, -0.03732281f, 0.02332542f, 0.04416126f, -0.03092870f, -0.21288368f, -0.49131814f, -0.24862917f, 
    0.02692901f, -0.03988766f, -0.14734034f, -0.05118464f, 0.15506418f, 0.11671887f, 0.26871145f, -0.04980122f, 
    0.22238687f, -0.10271814f, 0.18290119f, 0.08119006f, 0.13265602f, 0.02526673f, 0.05083181f, 0.03482240f, 
    0.20755140f, 0.21032609f, -0.12838925f, -0.00287395f, -0.05185449f, -0.01821190f, 0.06366614f, -0.04049605f, 
    -0.02688096f, -0.19620465f, -0.38439378f, -0.09565988f, -0.10172167f, 0.18562976f, 0.16335867f, 0.10350254f, 
    0.05533139f, 0.12972254f, 0.11091997f, 0.12844667f, -0.02481160f, -0.01742294f, -0.11484004f, 0.01866895f, 
    -0.02846802f, 0.12459186f, -0.10202908f, -0.14195527f, -0.19937208f, -0.14065751f, -0.07788351f, -0.10623064f, 
    -0.13628270f, 0.03409160f, -0.03520708f, -0.00954577f, -0.15719089f, -0.14628835f, -0.15588978f, -0.06556126f, 
    -0.39514440f, 0.05169741f, 0.02112528f, -0.11101366f, -0.08835481f, -0.81789845f, -0.70309013f, -0.38742790f, 
    0.25146136f, -0.29698819f, -0.20308685f, -0.13039397f, -0.16115639f, -0.08109182f, -0.08321588f, -0.07829869f, 
    0.00538920f, -0.08907219f, -0.14582472f, -0.02796965f, 0.06003255f, -0.05128894f, -0.19012873f, -0.16004722f, 
    -0.36868542f, -0.09653362f, 0.26432991f, 0.03984060f, 0.09202290f, 0.01968687f, 0.05777928f, 0.20897597f, 
    0.18602102f, 0.09006958f, -0.03039742f, -0.15678884f, 0.02962937f, 0.06158027f, 0.15063009f, -0.01324515f, 
    0.16441391f, -0.06122931f, 0.23677021f, 0.04467048f, -0.04193432f, 0.06750857f, 0.10425653f, 0.05085277f, 
    0.06661970f, -0.23350012f, -0.52535737f, 0.19888318f, -0.19028321f, -0.29943967f, -0.15683173f, -0.15882477f, 
    -0.08962407f, 0.07945382f, 0.21874209f, -0.35670921f, -0.09110526f, -0.10735077f, -0.12784036f, -0.09090287f, 
    -0.08128136f, -0.01275003f, -0.18280216f, -0.10278255f, 0.07619647f, -0.10821497f, -0.05009830f, -0.07400794f, 
    -0.13705304f, -0.02164173f, 0.13364802f, 0.03472442f, 0.22536683f, 0.06367358f, 0.04652647f, 0.06816690f, 
    0.03311669f, 0.08048935f, 0.10042885f, 0.04354437f, 0.16444699f, -0.08579309f, 0.46199745f, 0.40743190f, 
    -0.02263063f, 0.07815058f, 0.04819924f, 0.08149677f, 0.04429013f, 0.00737694f, -0.08563865f, -0.40571758f, 
    0.04823903f, 0.01244211f, -0.02058476f, -0.23768748f, -0.10475225f, 0.01532159f, 0.05264855f, -0.40868491f, 
    -0.10182831f, -0.04758660f, 0.08731814f, 0.10033276f, 0.02405620f, 0.04307560f, 0.04630890f, 0.16664281f, 
    -0.03496554f, -0.08759902f, -0.01204681f, 0.01083047f, 0.00813895f, 0.00046915f, 0.22547495f, 0.11156317f, 
    0.12697914f, 0.13032390f, -0.20281594f, -0.18465725f, 0.21995427f, -0.00459969f, 0.23652224f, 0.13373049f, 
    -0.00219361f, -0.02604038f, -0.54085857f, -0.27429986f, -0.17676973f, -0.06393196f, -0.20511918f, -0.07118947f, 
    0.08831926f, 0.00832012f, -0.09449121f, -0.19825038f, -0.07986995f, -0.22389746f, 0.04648835f, 0.18301822f, 
    -0.07639105f, 0.14599890f, 0.07963484f, 0.09989120f, -0.14503296f, -0.05290484f, -0.09260251f, -0.02363287f, 
    -0.07945031f, -0.11835027f, 0.02458109f, -0.06268290f, -0.05083581f, -0.11721743f, -0.24821468f, -0.15334900f, 
    -0.23572591f, -0.01884470f, -0.11517546f, -0.03834420f, -0.10276645f, 0.13190891f, 0.02413986f, 0.03585987f, 
    0.19070548f, 0.01619699f, 0.05621389f, -0.13614188f, -0.00501044f, 0.04849147f, -0.01064139f, 0.20472921f, 
    -0.04889782f, -0.71137899f, -0.08833077f, -0.01706293f, 0.21031104f, -0.15221050f, -0.04031788f, 0.14406975f, 
    0.19085361f, -0.62615710f, 0.11807884f, 0.19227058f, -0.07182308f, 0.07652783f, 0.10269451f, 0.04122556f, 
    0.17542431f, -0.38348562f, -0.17740081f, 0.23922780f, -0.13874169f, -0.15380453f, -0.03714420f, -0.16225487f, 
    0.03637138f, 0.05419596f, -0.42224729f, -0.29529890f, -0.08197258f, 0.06514952f, -0.10669097f, -0.07057548f, 
    -0.04807492f, -0.10956232f, 0.14241415f, 0.03189395f, 0.01255348f, 0.11811915f, -0.15597771f, -0.17897417f, 
    -0.13791344f, -0.23226187f, 0.01249550f, -0.05823932f, 0.03369175f, 0.31184033f, -0.04217444f, 0.15456027f, 
    0.06521041f, 0.15507919f, 0.08870653f, 0.03808402f, -0.04517521f, -0.06658366f, 0.18127157f, 0.01209148f, 
    -0.02636490f, 0.00434846f, -0.20950690f, -0.02760196f, 0.08030835f, 0.00817670f, -0.10027971f, 0.09689753f, 
    0.33485833f, 0.05441393f, 0.06287388f, 0.06713446f, 0.03326297f, 0.08929057f, 0.02979843f, -0.29908460f, 
    -0.19491746f, -0.49334845f, 0.15203434f, -0.00039077f, -0.14737773f, -0.08286750f, 0.02054086f, 0.00569463f, 
    -0.18248650f, 0.01989835f, -0.10502285f, -0.15562330f, -0.02008860f, -0.02387216f, -0.02747960f, 0.06874151f, 
    0.12202720f, -0.06784888f, -0.24644631f, -0.38572752f, 0.01601035f, 0.10660563f, -0.01372155f, 0.10765028f, 
    0.05471459f, 0.03654119f, -0.03489321f, -0.13179581f, 0.10931519f, 0.14707012f, 0.04407614f, -0.07274023f, 
    0.23904999f, 0.01187207f, 0.13616858f, -0.17098565f, -0.86579823f, 0.12826885f, -0.16897266f, -0.19416299f, 
    -0.16509761f, -0.03896185f, 0.07540353f, -0.02911955f, 0.06366493f, -0.23966184f, -0.22141938f, -0.03479232f, 
    -0.14441863f, -0.04619639f, 0.07030891f, -0.16964909f, 0.02713933f, 0.20263331f, 0.13270354f, -0.12202328f, 
    0.09807205f, -0.01734079f, -0.12960044f, 0.03613037f, 0.03391976f, 0.13504224f, 0.35965535f, 0.34311005f, 
    -0.15773679f, 0.11173984f, 0.17529163f, 0.21306443f, 0.01542696f, 0.00831782f, 0.17436221f, 0.41584122f, 
    -0.08242036f, -0.60599524f, 0.04875585f, 0.13112769f, 0.04277759f, -0.11889890f, 0.01569210f, 0.00857011f, 
    -0.05434840f, 0.11587659f, 0.19019997f, 0.01557988f, 0.03265200f, 0.17255853f, -0.07708307f, 0.03375581f, 
    0.09702056f, -0.37176982f, -0.18596740f, 0.06516894f, -0.10807989f, -0.02868248f, 0.10412394f, -0.13230182f, 
    0.03946464f, 0.02007751f, -0.00739415f, -0.03686043f, -0.10712151f, -0.10938986f, 0.10039976f, -0.24478437f, 
    -0.00638557f, -0.10985065f, -0.01971060f, -0.04199008f, -0.05337398f, -0.12743536f, -0.08433598f, -0.08077041f, 
    -0.16817723f, -0.11265799f, -0.19869572f, 0.03577586f, 0.14618778f, -0.00028124f, -0.02802700f, -0.10152398f, 
    0.03359579f, 0.01749206f, 0.01229491f, 0.16633171f, -0.00385533f, -0.27835792f, 0.06157250f, -0.01435727f, 
    0.09932640f, -0.02481611f, -0.11615884f, 0.02357289f, 0.11948280f, 0.09274435f, -0.17657556f, -0.12549812f, 
    0.21888633f, -0.03309399f, 0.00944660f, -0.18263534f, 0.12045407f, 0.07627910f, 0.07988393f, -0.06775387f, 
    -0.22998831f, 0.00618985f, 0.06827166f, -0.01590345f, 0.09846924f, -0.04579585f, 0.02992068f, -0.01634768f, 
    -0.05116524f, 0.18627876f, 0.19926855f, -0.01915943f, -0.05688694f, -0.04355804f, 0.02033255f, -0.01379699f, 
    0.13900991f, 0.06771795f, -0.00880522f, 0.06487659f, 0.10969353f, 0.07863377f, 0.06939042f, 0.09797583f, 
    0.18004319f, 0.05511495f, -0.07464992f, -0.00407553f, -0.14822698f, -0.22643745f, -0.18905608f, 0.01017525f, 
    -0.09457209f, 0.08341791f, -0.19613346f, 0.03849254f, -0.14672348f, -0.01666834f, -0.12159552f, -0.04549001f, 
    -0.07448454f, 0.26697683f, 0.19945453f, 0.16050458f, -0.17545243f, -0.07447511f, 0.16239376f, -0.04807293f, 
    0.02411903f, 0.09540863f, -0.06756607f, -0.19785242f, -0.21138257f, -0.15160623f, -0.07905858f, -0.13689977f, 
    -0.03590925f, -0.04777003f, -0.11575190f, 0.09111726f, 0.05846630f, 0.16555086f, -0.11631821f, -0.00770149f, 
    0.04064349f, -0.01671855f, -0.04351866f, -0.05362920f, 0.12770624f, -0.11144648f, -0.11417883f, 0.44539472f, 
    -0.19771306f, -0.35533881f, 0.06638326f, 0.05243016f, -0.05006117f, 0.08474294f, 0.09884024f, 0.09184258f, 
    0.20008877f, -0.17221364f, 0.04464841f, -0.01437257f, -0.02632543f, -0.01654757f, 0.17210099f, 0.20528752f, 
    0.19989824f, -0.20939125f, 0.04496130f, 0.11712944f, -0.14952101f, 0.08983409f, 0.14629248f, -0.01618687f, 
    0.01071811f, 0.09179615f, -0.10981834f, -0.25237834f, -0.03487208f, 0.12651031f, -0.00930393f, 0.02134635f, 
    0.01426704f, 0.07797214f, 0.07266873f, -0.03717708f, 0.00488638f, -0.13884947f, -0.22175559f, -0.15385213f, 
    -0.14194059f, 0.04828038f, 0.11529106f, -0.03174805f, -0.05455443f, 0.03239404f, 0.01021927f, 0.00524838f, 
    -0.00608217f, 0.08657802f, 0.02268300f, -0.03453016f, 0.04305833f, 0.11062596f, 0.10538986f, 0.05116281f, 
    -0.08544306f, 0.10269329f, -0.14874737f, 0.07158704f, 0.05576940f, -0.07694830f, -0.10066255f, 0.12770070f, 
    0.22829968f, 0.08372008f, 0.03238948f, 0.02967223f, 0.00462956f, -0.02160916f, 0.13248941f, -0.04687206f, 
    -0.21189603f, -0.06953447f, -0.00998749f, -0.12425581f, -0.07388355f, -0.01862270f, 0.11936593f, 0.09787643f, 
    -0.19193324f, -0.07059384f, -0.18391685f, 0.04685346f, 0.10478278f, -0.01610857f, -0.02828259f, 0.11122429f, 
    0.09840487f, -0.12145152f, -0.11505708f, 0.10173999f, 0.01434129f, 0.07286236f, -0.03943927f, 0.03825191f, 
    -0.00236634f, -0.09118480f, 0.05710620f, 0.04044383f, 0.16636965f, 0.15806450f, 0.19545007f, -0.23038572f, 
    0.09195293f, -0.04371712f, -0.03359288f, -0.18606049f, -0.22267078f, -0.12946555f, -0.03104659f, -0.05479998f, 
    0.02438455f, -0.09498075f, 0.23287816f, 0.04807965f, 0.33734408f, -0.07502745f, -0.07338426f, 0.06845585f, 
    -0.19997597f, -0.06778456f, 0.19133380f, 0.05607663f, 0.12512110f, 0.03683656f, 0.19712760f, 0.13277714f, 
    -0.14515235f, -0.03726701f, 0.16674487f, -0.19398357f, -0.13349035f, 0.10707227f, 0.31395364f, 0.06435747f, 
    0.02488478f, 0.16249004f, 0.05195950f, 0.15359280f, 0.08812590f, -0.04067053f, 0.02075357f, 0.10987853f, 
    -0.12692441f, -0.13077238f, -0.05628048f, 0.06796340f, 0.02205129f, -0.01689207f, 0.00090449f, -0.10310058f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03822216f, 0.14083607f, 0.19283341f, 0.21548161f, -0.03494548f, -0.03599222f, 0.11779975f, -0.05612320f, 
    0.19362415f, 0.01752324f, 0.00097004f, 0.08637304f, 0.05090844f, 0.16241109f, -0.12881523f, 0.15935853f, 
    0.30318436f, -0.02027698f, -0.07052618f, -0.04036711f, -0.05534984f, -0.02738893f, 0.12376194f, 0.10475035f, 
    0.15374163f, 0.16586526f, 0.03367024f, 0.01938229f, 0.01033910f, -0.04913653f, 0.18156931f, 0.13231406f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02325049f, 0.21957146f, 0.28767222f, 0.17045401f, -0.17613725f, 0.08864789f, 0.12439508f, -0.01455036f, 
    0.03668241f, 0.12694511f, 0.09533581f, -0.16614297f, -0.05580328f, 0.15030450f, -0.30464247f, 0.11886213f, 
    0.31955171f, 0.16270216f, -0.16662015f, -0.13290866f, -0.25671703f, -0.00192651f, 0.27086598f, 0.09587293f, 
    -0.09529710f, -0.03242343f, 0.13895564f, -0.33948979f, -0.13161361f, 0.31000784f, -0.29172942f, -0.09458560f, 
    -0.13481306f, -0.01226471f, -0.01264473f, -0.00248183f, 0.13997170f, 0.00032521f, -0.03045608f, 0.03992308f, 
    -0.16495483f, -0.03525399f, 0.06145463f, -0.12888226f, -0.02963408f, -0.08648933f, -0.09272167f, 0.11851513f, 
    0.11962328f, 0.14447923f, -0.21476661f, -0.13810851f, 0.01559698f, -0.16882032f, 0.03444740f, -0.15767643f, 
    -0.18498316f, -0.07889229f, -0.13346288f, 0.00366852f, -0.02824919f, 0.11124823f, 0.00198082f, -0.00761732f, 
    0.33995801f, 0.13175513f, -0.14855511f, 0.28308940f, 0.12358858f, 0.00815234f, -0.36815059f, -0.10897747f, 
    -0.00881330f, 0.13287286f, 0.14652407f, -0.24765323f, -0.42495340f, -0.19978771f, -0.01724473f, 0.16644575f, 
    -0.36638400f, 0.07112076f, 0.31988612f, 0.23238216f, 0.10948670f, -0.13299644f, -0.08706108f, 0.20106328f, 
    -0.10047889f, -0.33512160f, -0.12809013f, 0.14808717f, 0.01694918f, 0.22405055f, -0.63302213f, -0.14810844f, 
    -0.02471297f, 0.09520126f, -0.26760837f, 0.01889816f, -0.16347475f, -0.14214168f, -0.40856150f, 0.09983309f, 
    0.26277712f, -0.20348965f, 0.03212950f, 0.11737034f, 0.08480950f, -0.02714793f, 0.37984091f, -0.09626881f, 
    -0.20830157f, -0.10548992f, 0.16171642f, 0.27629837f, 0.17626895f, 0.04005617f, 0.04327919f, 0.02384470f, 
    -0.13155456f, 0.42006281f, 0.08481426f, 0.32673103f, 0.16172688f, -0.23302017f, -0.13816391f, -0.08959646f, 
    -0.10602391f, -0.16168700f, 0.12913288f, 0.05039360f, -0.00810381f, -0.13029499f, 0.12468326f, -0.11625011f, 
    -0.13695268f, -0.19420542f, 0.11608811f, 0.06989703f, 0.05633081f, -0.12932447f, -0.10700640f, -0.00721342f, 
    -0.06727918f, -0.04590403f, -0.03446343f, 0.11398680f, 0.07123722f, 0.03762415f, -0.13786064f, -0.11087992f, 
    -0.05212741f, -0.09888463f, 0.07153880f, -0.08986813f, -0.02433475f, -0.14116214f, 0.13901915f, -0.07798295f, 
    0.21608293f, -0.10050155f, -0.13590816f, -0.16602479f, -0.12743562f, -0.15161861f, -0.18128785f, -0.01348420f, 
    0.48503780f, -0.05090160f, -0.08454874f, 0.25460979f, -0.17377302f, 0.20291783f, -0.20664454f, 0.25775108f, 
    -0.26150882f, 0.15117843f, 0.02197914f, -0.03313657f, -0.04923044f, 0.12990950f, 0.00304046f, 0.07628256f, 
    -0.02013442f, -0.33006963f, 0.01009867f, 0.07004441f, 0.06705516f, 0.01030270f, 0.49533308f, -0.17448258f, 
    0.02741297f, -0.03283043f, 0.11944348f, 0.21932608f, 0.15144816f, -0.11357524f, -0.16178669f, 0.12454263f, 
    -0.82273805f, 0.27578819f, 0.10311092f, -0.19787657f, -0.52954543f, 0.25137296f, -0.08508915f, 0.36079109f, 
    -0.21337327f, 0.01631204f, 0.35916579f, 0.09720583f, -0.45479336f, -0.16569926f, -0.30016592f, 0.31427369f, 
    -0.08454018f, -0.05264718f, 0.15865840f, -0.19443356f, -0.69244999f, -0.36018464f, 0.60035539f, 0.15969981f, 
    0.27430174f, -0.25063258f, -0.17813048f, -0.05888128f, -0.10486785f, -0.12402831f, 0.15756939f, 0.12428182f, 
    -0.25774533f, 0.17815308f, 0.01734089f, 0.14161663f, -0.21902841f, 0.26737130f, -0.03694234f, 0.14608170f, 
    0.14430326f, -0.12209897f, 0.17457560f, 0.18490073f, -0.50782955f, 0.05678906f, -0.14097668f, -0.10653201f, 
    -0.12547943f, -0.11234374f, 0.03723082f, -0.37083843f, -0.10145976f, -0.34583065f, 0.57913923f, 0.28080124f, 
    -0.00177028f, 0.02924177f, -0.04556904f, -0.05224452f, -0.11134369f, -0.11226329f, -0.14408116f, -0.11694724f, 
    -0.24670310f, -0.01391525f, -0.10935649f, 0.06529898f, -0.16661984f, -0.12176047f, 0.11091860f, -0.19970742f, 
    0.08188431f, -0.13652380f, -0.03171844f, 0.21231514f, -0.11307166f, 0.05032854f, -0.06442284f, -0.06366395f, 
    -0.16196634f, 0.13204572f, -0.13544758f, 0.31890595f, 0.10771998f, -0.17936338f, -0.09909826f, 0.08568664f, 
    0.18228088f, 0.28855103f, -0.10726614f, 0.31042555f, -0.15848775f, 0.16110279f, 0.31280404f, 0.00099591f, 
    0.12713552f, 0.11161964f, -0.12049666f, -0.10539075f, 0.00224660f, -0.27650499f, 0.00073327f, 0.24716176f, 
    -0.07472256f, -0.04855945f, 0.06264400f, -0.12257729f, 0.18166253f, 0.04029566f, 0.10927075f, -0.05047840f, 
    0.15834382f, 0.05341629f, 0.00262087f, -0.05875405f, -0.11502770f, 0.37110493f, -0.47361159f, -0.09885453f, 
    -0.06510673f, 0.21558264f, 0.37039995f, -0.44187629f, 0.16823488f, -0.03041474f, 0.52674448f, -0.05150132f, 
    -0.07285853f, 0.27083042f, 0.08244821f, 0.18381616f, 0.02390245f, 0.07337830f, 0.03777638f, 0.07576911f, 
    0.12940092f, -0.11875074f, -0.12376764f, -0.01024207f, 0.05009898f, -0.12705967f, 0.07198825f, -0.28202260f, 
    0.04074765f, -0.24697843f, 0.01162672f, -0.19217955f, -0.01258480f, 0.07660211f, 0.34546888f, -0.08011786f, 
    0.21953185f, 0.02906254f, 0.18966782f, 0.42747217f, -0.05001212f, 0.04329624f, -0.24417725f, 0.04991239f, 
    0.22891389f, -0.02476864f, 0.11157455f, 0.06776208f, 0.08559019f, -0.02751426f, -0.09325064f, 0.18911430f, 
    0.18640584f, 0.17111719f, 0.12686585f, -0.21705115f, -0.21507485f, 0.10562468f, 0.07552847f, 0.05169764f, 
    -0.25649625f, 0.19606495f, 0.12511739f, -0.20598356f, -0.05619073f, 0.27137277f, -0.34765527f, -0.11785854f, 
    -0.00414573f, -0.01384363f, 0.03165102f, -0.08723683f, -0.17246750f, 0.10929655f, 0.62365443f, -0.04653709f, 
    -0.32602108f, 0.22868213f, -0.20784149f, 0.00596749f, -0.20494448f, 0.25178838f, 0.02944921f, 0.29691285f, 
    0.21132995f, 0.06953792f, 0.09550896f, 0.07332932f, -0.20050733f, 0.04502400f, -0.26281253f, 0.19979168f, 
    0.36124724f, -0.27300966f, -0.06855033f, -0.17598023f, -0.20092355f, 0.03414783f, 0.00896901f, -0.03636618f, 
    0.09483177f, 0.33226129f, 0.25825471f, 0.21880999f, -0.11683582f, -0.17832644f, -0.03042382f, -0.03410256f, 
    0.14988436f, -0.09231746f, 0.06111333f, -0.36380416f, 0.21702249f, 0.05271716f, 0.00301183f, -0.01642039f, 
    -0.02097780f, 0.07342590f, -0.27824739f, 0.08954220f, 0.03787117f, 0.14279296f, 0.34619763f, -0.14947724f, 
    -0.00188718f, 0.49335998f, 0.11865047f, 0.47239044f, -0.03064304f, -0.16079764f, -0.24501963f, 0.12806883f, 
    -0.16605659f, 0.25595525f, 0.10344739f, 0.17451137f, -0.02922515f, 0.12060205f, 0.68486893f, -0.14212926f, 
    0.27762285f, -0.02534641f, -0.17692676f, -0.31705728f, 0.06436691f, 0.17737663f, 0.12531739f, -0.09189890f, 
    -0.29256603f, 0.06051820f, 0.22184540f, 0.19889295f, 0.52394927f, -0.01145729f, 0.16145179f, 0.34751922f, 
    -0.24710935f, 0.22667983f, 0.09616910f, 0.44607151f, -0.11104328f, -0.14371926f, -0.31153241f, 0.25265595f, 
    0.25342816f, -0.50812411f, -0.06141639f, 0.11378109f, -0.08515282f, -0.13473220f, 0.28249550f, -0.03377029f, 
    0.09522408f, 0.20040636f, 0.12255099f, -0.11685362f, 0.04267668f, 0.02488267f, 0.21453571f, -0.08093420f, 
    -0.10888474f, 0.11421429f, 0.08622203f, -0.37446392f, -0.11563265f, 0.08680427f, -0.04798969f, -0.49209836f, 
    -0.24433185f, -0.34111494f, -0.10665197f, -0.09088539f, 0.00033354f, -0.21279877f, -0.33219859f, -0.06660124f, 
    0.31590825f, 0.16027406f, 0.19462956f, 0.28121907f, 0.09500542f, -0.00179125f, -0.11600419f, -0.15652989f, 
    0.06779082f, -0.03004695f, -0.14457232f, 0.02680424f, -0.01425297f, -0.21612969f, -0.26791576f, 0.06669684f, 
    -0.20466971f, -0.14865004f, -0.04136223f, 0.19660439f, 0.05693004f, -0.08036749f, 0.01086364f, 0.10588539f, 
    0.73203397f, 0.00837463f, 0.03645229f, 0.12631087f, 0.21994425f, 0.04326862f, -0.42475417f, 0.14726567f, 
    -0.01801603f, 0.09414472f, -0.05176467f, -0.11047336f, 0.10756601f, 0.16957162f, 0.21679415f, -0.16957535f, 
    -0.11013943f, -0.19777180f, -0.12075645f, -0.10216442f, -0.09291270f, -0.23039001f, -0.14621508f, 0.13988476f, 
    0.12056911f, -0.16530000f, -0.10222542f, 0.12313122f, 0.04817542f, 0.15219168f, 0.03243789f, -0.00443507f, 
    -0.00907939f, -0.13016932f, -0.13442740f, -0.04984387f, -0.02955136f, 0.13069585f, 0.13261731f, -0.02297023f, 
    0.34659761f, 0.07482120f, 0.23062867f, 0.19517674f, 0.11919991f, -0.15213980f, -0.16303770f, 0.08709693f, 
    0.01271335f, 0.12269136f, 0.12407947f, -0.31950140f, -0.53842235f, 0.12667991f, -0.29768530f, 0.30029854f, 
    -0.29143304f, 0.00804734f, 0.13958320f, 0.17366411f, -0.29041308f, -0.03924785f, -0.18383990f, 0.33864340f, 
    0.03101393f, -0.32564753f, -0.08266811f, -0.11062136f, -0.04307384f, -0.03751071f, -0.04126866f, -0.16076003f, 
    -0.10221051f, 0.03631842f, -0.19177018f, -0.02538547f, 0.06347311f, -0.15224347f, 0.03017865f, -0.06053115f, 
    0.08515483f, -0.05884493f, -0.01868850f, -0.25276569f, 0.06393772f, -0.05433025f, -0.09760133f, -0.11311672f, 
    -0.13770673f, -0.06979798f, -0.03697936f, -0.08724754f, 0.07949234f, 0.17170835f, -0.14793296f, -0.06216386f, 
    -0.00577933f, 0.07950798f, 0.17209971f, 0.03142739f, -0.04960220f, 0.10896002f, 0.08431674f, -0.15785964f, 
    -0.18955605f, 0.14289534f, 0.18998571f, 0.07149550f, 0.00525878f, -0.05450395f, 0.29329786f, -0.00097887f, 
    0.25318184f, -0.25213063f, -0.07930213f, 0.04649282f, 0.09827086f, 0.01539811f, 0.38191682f, -0.00610761f, 
    -0.29139188f, -0.08719190f, 0.22799598f, -0.01261085f, 0.23308033f, 0.06028823f, -0.01030037f, -0.06512582f, 
    -0.12116425f, 0.22026692f, -0.10340130f, 0.11835271f, 0.06891444f, -0.12325295f, -0.01448203f, 0.14023328f, 
    -0.16442153f, 0.16631474f, 0.20457716f, -0.10293446f, -0.06340007f, 0.07653596f, -0.00816895f, 0.05111142f, 
    -0.29141018f, -0.16494928f, -0.08350707f, 0.08530271f, 0.11783938f, 0.52590334f, -0.09236297f, -0.20423912f, 
    -0.30029091f, -0.12483856f, 0.06420251f, 0.20067978f, -0.20258354f, -0.13353728f, -0.31406388f, 0.04336589f, 
    -0.29844099f, 0.31953043f, -0.06574196f, 0.06956369f, 0.23069483f, -0.08160987f, 0.53025061f, 0.13161004f, 
    -0.22810063f, 0.20063673f, 0.23375472f, -0.17769122f, 0.16938581f, -0.04263156f, 0.01962878f, -0.11208358f, 
    -0.20461448f, 0.14647041f, 0.02510295f, 0.05991815f, -0.06041348f, 0.09275783f, 0.04023271f, 0.16048516f, 
    0.14793132f, -0.02853257f, 0.22771800f, -0.04887675f, 0.10545252f, 0.03689961f, -0.04576266f, 0.36207899f, 
    -0.49710301f, 0.17447221f, 0.15432557f, 0.03542085f, -0.05591831f, 0.60879606f, -0.51680368f, -0.15792498f, 
    -0.36893252f, -0.29272181f, -0.34592059f, -0.16370617f, -0.08460908f, -0.05790017f, 0.20658107f, 0.16889644f, 
    -0.24534695f, 0.18781954f, -0.04250487f, 0.11696431f, -0.09742323f, 0.21860535f, 0.31040961f, 0.21472810f, 
    -0.04689775f, 0.07479010f, 0.15462603f, 0.00907210f, 0.23583922f, -0.01343848f, -0.00701328f, 0.14170106f, 
    -0.18735962f, 0.05611098f, -0.14072257f, 0.05925903f, -0.14963834f, -0.25732121f, 0.48981988f, 0.09095941f, 
    0.07934670f, -0.22232901f, 0.05798334f, 0.19937672f, 0.04151447f, 0.07192286f, -0.24733327f, -0.03195744f, 
    -0.34322083f, -0.07893277f, -0.16398832f, 0.18576029f, 0.16848069f, 0.21506032f, -0.10736859f, 0.23519520f, 
    0.16591355f, 0.00933811f, -0.04934948f, 0.20154092f, -0.11403452f, 0.00617543f, -0.27220285f, -0.09340324f, 
    0.02398005f, 0.23903298f, -0.11713221f, 0.04912788f, 0.02124377f, -0.35258660f, 0.93393731f, 0.22095124f, 
    -0.12923229f, -0.03795697f, 0.15231930f, 0.06871492f, 0.04068619f, -0.02230089f, 0.04374251f, -0.09036436f, 
    -0.08153643f, 0.09908854f, 0.08445716f, 0.13696520f, -0.09574547f, -0.16974474f, -0.05201850f, -0.18936047f, 
    -0.07288215f, -0.10340137f, -0.17851560f, -0.14303370f, -0.12339161f, 0.15772082f, -0.13338789f, 0.05166937f, 
    -0.00247030f, -0.02546069f, 0.03850075f, 0.12523969f, -0.04371909f, -0.13137981f, -0.00580094f, -0.14530723f, 
    0.12150899f, 0.32504767f, 0.53547305f, 0.10325605f, 0.08881622f, 0.07575523f, 0.06601626f, -0.01318610f, 
    -0.54744649f, 0.03149643f, 0.06543450f, -0.46864986f, -0.10147086f, 0.08456290f, -0.40578938f, -0.12731394f, 
    0.12151459f, 0.14341345f, 0.10754498f, -0.04328367f, -0.09224509f, 0.14390278f, 0.09216058f, 0.37725964f, 
    -0.00866875f, -0.11558238f, 0.16316897f, -0.09039873f, -0.14304200f, 0.19589370f, -0.06267388f, 0.07379978f, 
    0.22812223f, 0.19409724f, 0.21528389f, -0.24322540f, 0.09078135f, -0.00544166f, -0.22873753f, -0.06140545f, 
    -0.16950843f, 0.04742796f, -0.14369825f, -0.04040936f, 0.06625541f, -0.04904215f, 0.27812201f, -0.17020951f, 
    -0.27975884f, -0.04874924f, -0.12941635f, 0.38578391f, 0.55097598f, -0.17009127f, 0.24761434f, 0.24408893f, 
    0.15140973f, -0.38658065f, 0.07498910f, 0.32406396f, 0.15707633f, 0.08422960f, -0.28645703f, -0.11395089f, 
    0.00912486f, 0.06116609f, -0.01324398f, 0.05393607f, 0.11294465f, -0.03451151f, -0.06469285f, 0.04663014f, 
    0.08712652f, -0.19287276f, 0.12040461f, -0.08748901f, -0.04405839f, -0.01387826f, -0.02483830f, -0.11940605f, 
    -0.03545692f, -0.06060369f, -0.21229549f, -0.08854780f, -0.13653447f, 0.00970381f, -0.08352143f, 0.00059396f, 
    0.06412287f, -0.12070493f, 0.08319998f, -0.01868686f, -0.07046711f, 0.01176171f, -0.17817695f, -0.08452319f, 
    -0.34405538f, -0.06373031f, 0.36712703f, -0.22381809f, 0.07471266f, -0.14942060f, 0.11808064f, -0.02574237f, 
    -0.63576162f, -0.05222525f, 0.13381517f, -0.07453054f, 0.11133943f, 0.11405112f, 0.45238730f, -0.30799767f, 
    0.05976792f, -0.05278804f, 0.00420973f, 0.22944485f, 0.27700689f, -0.17071390f, 0.03047233f, -0.21078737f, 
    -0.30387685f, -0.03648086f, -0.15750231f, 0.44670308f, -0.04175397f, 0.08765917f, -0.00872657f, -0.09182144f, 
    0.00633320f, -0.24667144f, -0.13402702f, 0.01253918f, 0.11593138f, 0.10738454f, 0.28532794f, -0.06479198f, 
    -0.19008301f, 0.17463806f, 0.18686105f, -0.14479087f, -0.10155508f, -0.08225735f, 0.23019867f, 0.17206647f, 
    0.18371242f, -0.01595281f, 0.32644206f, 0.23537457f, 0.18715988f, 0.14536612f, -0.31540895f, 0.08453628f, 
    -0.01972763f, -0.24629121f, 0.07126839f, 0.03056188f, -0.24626365f, -0.46514508f, -0.14357336f, 0.20096278f, 
    -0.05650757f, -0.21213497f, -0.19365238f, -0.73007870f, -0.02562911f, -0.06600211f, -0.23271912f, -0.12020397f, 
    -0.03056768f, -0.05111897f, 0.01500639f, 0.08764203f, 0.07878174f, 0.02926482f, 0.32314906f, 0.10414653f, 
    0.18729454f, -0.08682432f, 0.07367301f, 0.06869690f, -0.07700442f, 0.04352716f, 0.33512086f, 0.35121915f, 
    -0.32241374f, -0.17339425f, -0.15278959f, 0.09950554f, 0.21942393f, -0.26007906f, 0.34226263f, 0.07619356f, 
    0.26032484f, 0.25631273f, -0.02306009f, 0.09664229f, -0.01337355f, -0.01601517f, 0.25920227f, 0.02782557f, 
    -0.00277320f, 0.15220547f, -0.01693516f, 0.12546383f, 0.10934972f, 0.06307184f, -0.31190354f, -0.07311662f, 
    -0.10383699f, 0.15867168f, 0.03684161f, -0.12420271f, 0.26399711f, -0.04982939f, -0.11300039f, -0.09292302f, 
    -0.23011160f, -0.30434746f, 0.11154423f, -0.21456082f, -0.01199680f, -0.60029441f, -0.70384610f, -0.01826009f, 
    -0.00690847f, -0.11650486f, -0.08400749f, -0.08392598f, 0.03980850f, 0.09161039f, -0.11607888f, -0.13438942f, 
    -0.16070259f, -0.09703537f, -0.08999469f, -0.11056040f, -0.04145934f, 0.12191212f, -0.07309001f, -0.09750760f, 
    -0.06049150f, -0.07840654f, 0.03164988f, -0.11500105f, 0.15394816f, -0.04026914f, 0.00322798f, 0.00124170f, 
    -0.14275706f, 0.10743816f, 0.09211786f, -0.13134515f, -0.10860078f, -0.13349380f, -0.07194174f, 0.16634388f, 
    0.20739836f, 0.08044510f, -0.02876795f, -0.24205890f, 0.08880244f, -0.09326379f, -0.24571730f, 0.02499066f, 
    -0.15268569f, 0.14399150f, -0.08229366f, 0.05017721f, 0.14137295f, -0.02408239f, -0.21664181f, 0.09326858f, 
    0.30470452f, -0.01501062f, -0.05957508f, -0.18770468f, 0.24800432f, -0.06427432f, 0.09579080f, -0.07984465f, 
    0.03107296f, -0.02062004f, -0.14955655f, -0.26808757f, 0.09895740f, -0.06905755f, 0.49180511f, -0.16128682f, 
    0.19400547f, 0.14827767f, -0.22445607f, -0.15805940f, 0.06145249f, 0.10297149f, -0.19890046f, -0.02635690f, 
    -0.14031495f, 0.06318943f, -0.03456334f, -0.06195096f, -0.10809830f, -0.10996394f, 0.00345562f, -0.15236218f, 
    0.10491923f, 0.03904904f, -0.18547295f, 0.05221428f, 0.12041201f, -0.14663242f, -0.00607791f, 0.12145172f, 
    -0.27978978f, -0.17771292f, 0.13789414f, 0.05875158f, -0.07135689f, 0.02035289f, -0.10536209f, 0.02169728f, 
    -0.16944440f, 0.13490382f, -0.04367207f, -0.01853595f, 0.02290483f, 0.15161254f, -0.47419170f, 0.02879673f, 
    0.10187695f, -0.18517998f, 0.00743165f, 0.03970695f, -0.15908615f, 0.12602560f, 0.14552240f, -0.11117937f, 
    -0.04406994f, 0.12665635f, 0.03505928f, 0.18399915f, 0.37053517f, -0.00337908f, -0.40556189f, 0.11586253f, 
    -0.28372115f, -0.26681462f, 0.14598307f, 0.06943489f, 0.02603118f, 0.07658998f, -0.04637587f, -0.34981808f, 
    -0.21660292f, -0.04857882f, -0.28864169f, 0.32790956f, 0.01695133f, 0.03032552f, -0.26951209f, -0.01452815f, 
    0.01306120f, -0.05264046f, 0.16831635f, 0.22343853f, -0.07641716f, 0.25201255f, -0.01194063f, 0.02552412f, 
    -0.21772359f, -0.15941925f, 0.10638187f, 0.23311605f, -0.27667701f, 0.04042123f, -0.07183558f, 0.22974373f, 
    -0.51388216f, 0.70477873f, 0.18206321f, 0.00460311f, -0.24639355f, 0.09973853f, 0.44377828f, 0.00012198f, 
    0.33250096f, 0.07631039f, 0.27540112f, 0.23000056f, -0.01415536f, -0.14689091f, -0.44199777f, -0.06881012f, 
    -0.03693110f, -0.12909451f, 0.01670851f, 0.00499515f, -0.00958787f, -0.04604790f, -0.26499119f, -0.11158879f, 
    -0.00523806f, 0.17839192f, -0.15227571f, 0.03597793f, 0.09760157f, 0.03193978f, 0.33015385f, 0.23776737f, 
    0.48758817f, 0.20710884f, -0.16772373f, -0.07862025f, 0.49791548f, 0.23418325f, -0.22473159f, -0.03025750f, 
    0.21984231f, -0.25536811f, -0.50175041f, 0.25160265f, 0.09164802f, 0.02754103f, -0.25130862f, -0.06912904f, 
    0.14716637f, -0.13814530f, 0.04719611f, 0.12413345f, 0.09943054f, -0.25993976f, -0.06741325f, 0.12221745f, 
    0.04599919f, -0.01647199f, 0.00878834f, 0.02883609f, 0.01959374f, 0.07831149f, -0.10728053f, -0.15326640f, 
    0.32429075f, 0.22528315f, -0.14554039f, 0.14663225f, 0.10944473f, -0.25915712f, 0.25498745f, 0.22474466f, 
    -0.09870376f, 0.01610988f, 0.33587152f, -0.50850981f, 0.07458210f, -0.07349496f, 0.59450936f, 0.15601771f, 
    0.12152112f, 0.23422571f, -0.00739679f, 0.10775843f, -0.02120900f, -0.00951653f, 0.23531802f, -0.10597100f, 
    -0.26295272f, -0.00419287f, 0.15789162f, 0.19619213f, -0.00589326f, -0.06388994f, 0.12495338f, 0.02653931f, 
    -0.01728746f, -0.40995067f, -0.09251302f, 0.07785308f, 0.08453134f, 0.22079185f, 0.03655699f, 0.02750253f, 
    0.19339649f, -0.07478186f, -0.11845058f, 0.23924223f, 0.15734315f, -0.11304986f, 0.07931096f, -0.13175784f, 
    0.11436623f, -0.15958279f, -0.05786875f, 0.17041531f, -0.09276562f, 0.03295506f, -0.34439203f, 0.16976920f, 
    -0.03111821f, 0.16338030f, 0.31089070f, 0.42127985f, -0.04499806f, -0.06900702f, -0.29917300f, 0.01463917f, 
    0.65706092f, -0.26592112f, 0.04943209f, -0.14826041f, -0.09421058f, 0.07412427f, -0.07168116f, 0.16488391f, 
    -0.07585301f, -0.29301536f, -0.25188440f, 0.19656357f, -0.16834581f, -0.08958146f, 0.05636916f, -0.15221998f, 
    0.30193239f, 0.19204599f, -0.04240746f, 0.20828983f, 0.10744623f, 0.26193175f, -0.10095020f, 0.10601875f, 
    -0.11739261f, 0.12448689f, 0.24806611f, 0.27811176f, -0.04665810f, 0.15968621f, -0.21755329f, -0.11567022f, 
    0.37165731f, 0.17305349f, 0.17146492f, 0.26493248f, -0.07779460f, -0.25832069f, -0.17060351f, 0.39519507f, 
    0.07278505f, 0.03030397f, 0.11736315f, 0.27772844f, -0.08687899f, 0.03936040f, -0.15461431f, -0.11683038f, 
    0.02910567f, -0.08459333f, 0.15605681f, -0.21260099f, 0.15141882f, -0.20835824f, -0.11698560f, 0.11321013f, 
    -0.00956112f, -0.00841206f, -0.21272722f, 0.11905494f, -0.09752487f, -0.02527006f, -0.16940545f, 0.13377336f, 
    0.48744690f, 0.07035910f, 0.03882831f, 0.14877884f, 0.18998480f, -0.29238984f, 0.50161856f, 0.33833364f, 
    -0.07964804f, -0.05987630f, 0.03244715f, -0.11350547f, -0.07257782f, 0.02219864f, -0.04692027f, -0.04432253f, 
    -0.16928655f, -0.04948773f, 0.12230662f, -0.08259387f, -0.07256255f, -0.16604502f, -0.09969628f, -0.00302962f, 
    0.01673097f, 0.05500566f, -0.15540639f, -0.09156154f, 0.14200830f, -0.02989459f, -0.14427747f, -0.08081681f, 
    0.11867277f, -0.10886942f, 0.10172293f, 0.03841837f, 0.06218607f, -0.02326820f, -0.08372263f, 0.01156569f, 
    0.49129391f, 0.10501552f, -0.06114074f, 0.17811348f, 0.04295949f, 0.13155405f, 0.02532996f, 0.17433688f, 
    -0.03016673f, 0.17078033f, -0.01064466f, -0.33307555f, -0.37989944f, -0.01366583f, 0.12087397f, 0.06506821f, 
    -0.07614718f, 0.05442437f, 0.08914292f, 0.07576068f, 0.48068669f, 0.00467052f, -0.04785485f, -0.10349428f, 
    -0.13701074f, -0.41198868f, -0.04936270f, 0.22419861f, -0.52890265f, 0.06414790f, -0.50122082f, -0.08565991f, 
    -0.27019262f, 0.20284219f, 0.12467872f, 0.30975887f, -0.11154346f, 0.02733394f, 0.45531705f, -0.09577228f, 
    0.50850058f, -0.28163153f, -0.07954969f, 0.10329834f, -0.06171954f, 0.33850670f, -0.28648230f, 0.04919103f, 
    -0.38346332f, 0.13082886f, 0.24712855f, 0.06213276f, -0.26160619f, -0.07387853f, 0.03835300f, -0.05446704f, 
    -0.54179204f, 0.66472483f, 0.05974404f, 0.06258528f, -0.11210814f, 0.20562327f, 0.27348083f, 0.05948475f, 
    -0.06923097f, -0.03650257f, 0.27515283f, 0.29889786f, -0.04409812f, 0.12068056f, 0.52369267f, 0.16907984f, 
    -0.16880642f, 0.29748303f, 0.14140597f, -0.21291922f, 0.07237833f, 0.14788662f, 0.19160646f, 0.08536373f, 
    0.09017697f, -0.00696496f, -0.12586823f, -0.26872563f, -0.23612602f, -0.02008938f, 0.21605927f, -0.13602398f, 
    0.11933105f, 0.28739920f, 0.04697831f, -0.00384303f, -0.31144011f, -0.10141502f, 0.03779251f, 0.31887931f, 
    -0.09240419f, 0.34588590f, -0.09709331f, 0.20015165f, 0.06269957f, -0.16491199f, -0.22357054f, 0.10944121f, 
    0.22160956f, -0.20640695f, -0.07040903f, -0.27574566f, -0.40280730f, 0.03869743f, 0.20296527f, -0.16661026f, 
    -0.20999900f, -0.15293902f, 0.24868685f, 0.29473600f, 0.45858091f, 0.00127615f, -0.43280298f, -0.07770722f, 
    -0.65611929f, -0.00230498f, 0.12052757f, 0.18217024f, 0.05168905f, 0.01620199f, 0.17224662f, -0.37913874f, 
    0.06639454f, -0.23966497f, 0.23439230f, -0.12625954f, 0.14503370f, 0.12214334f, 0.20342523f, -0.14888920f, 
    -0.63190979f, 0.31599283f, 0.16294794f, -0.29047105f, -0.06910291f, 0.15521275f, -0.14521605f, 0.33551472f, 
    0.21752340f, -0.07096941f, 0.04365119f, 0.17456034f, -0.26475072f, 0.13735546f, 0.03790104f, 0.15499069f, 
    0.49627581f, -0.27451164f, -0.06716496f, -0.11073845f, -0.51303715f, -0.25104460f, 0.42864498f, 0.22805992f, 
    0.06217998f, 0.20087908f, 0.10551186f, -0.15850976f, 0.13625547f, 0.05865886f, 0.15287545f, -0.04935852f, 
    0.18451340f, -0.19526614f, 0.07600208f, -0.09399372f, 0.21380232f, -0.06318501f, 0.38335428f, -0.18210889f, 
    -0.05140756f, 0.08727508f, -0.10094857f, 0.18540229f, 0.42918548f, 0.13469234f, 0.27171481f, -0.02609788f, 
    -0.17554039f, 0.01172018f, 0.10516960f, 0.30459613f, 0.26557651f, -0.07141634f, -0.14253330f, -0.11785294f, 
    -0.32904711f, 0.12716906f, 0.28323463f, 0.01856138f, -0.11609288f, -0.14562884f, 0.02543920f, -0.16874948f, 
    -0.24646203f, -0.06046525f, -0.04421285f, 0.05366708f, -0.15115608f, 0.23181118f, 0.05375370f, -0.00462061f, 
    -0.15396176f, 0.12741075f, -0.04704712f, 0.19257054f, 0.25813749f, -0.10427631f, 0.18870710f, 0.11332276f, 
    -0.36275467f, -0.01175478f, 0.10539336f, 0.37282923f, 0.16110367f, 0.54969418f, -0.35303274f, -0.15490428f, 
    0.16179170f, 0.21622048f, -0.22344688f, -0.02731629f, 0.13502046f, -0.05572524f, 0.04794073f, 0.05375106f, 
    -0.26591665f, -0.08327317f, 0.11528465f, -0.23494919f, 0.08008125f, -0.22011237f, -0.06195970f, -0.20054772f, 
    0.13741201f, -0.15273134f, -0.04801980f, 0.14437854f, -0.05671202f, -0.02221649f, -0.04619241f, 0.21233897f, 
    0.00255496f, -0.28889263f, -0.01753463f, -0.06648076f, -0.09129491f, 0.10203854f, -0.32888541f, -0.07908575f, 
    -0.25246617f, -0.09055131f, 0.02334441f, 0.23182824f, -0.09589898f, -0.06337866f, -0.16959167f, 0.16510844f, 
    -0.45729592f, -0.30009741f, 0.04478806f, -0.45708293f, 0.20057930f, 0.42039266f, -0.05403509f, -0.23344967f, 
    0.10412084f, -0.04639942f, -0.18945499f, 0.06139154f, -0.18126987f, 0.03521504f, -0.02435853f, 0.25793982f, 
    0.33519429f, 0.53088760f, 0.01782938f, 0.37466571f, -0.05228915f, -0.21886729f, 0.47329956f, 0.46878439f, 
    0.17123190f, 0.26259431f, 0.27252427f, 0.22123003f, 0.13626453f, -0.13239591f, -0.03657623f, 0.03901621f, 
    -0.10185508f, 0.17583503f, -0.16761908f, -0.00539178f, -0.30118823f, 0.32663885f, -0.26396066f, -0.10381480f, 
    0.00713262f, 0.01341020f, 0.13683903f, -0.16122168f, -0.10368597f, -0.09089576f, 0.11681940f, 0.16912718f, 
    -0.33255637f, 0.12340334f, -0.14808320f, -0.08155680f, -0.10928385f, 0.49499300f, -0.48916712f, -0.30007297f, 
    0.23169436f, -0.04414935f, -0.47760713f, 0.28383300f, -0.03658075f, 0.12434140f, -0.43888065f, -0.03909007f, 
    0.05706740f, 0.15926525f, -0.11607506f, 0.17690554f, 0.05524978f, 0.11545730f, -0.44353330f, 0.07420313f, 
    0.13777943f, -0.02954283f, 0.00083498f, -0.01819988f, -0.04885808f, 0.06602903f, -0.26664713f, -0.00704825f, 
    0.36152491f, -0.18338986f, -0.07217317f, -0.36278480f, -0.11227168f, -0.30640155f, 0.44783035f, 0.23009746f, 
    -0.09985881f, -0.23389573f, 0.21216051f, 0.17313348f, 0.15047953f, 0.16656633f, -0.26570323f, 0.17716187f, 
    -0.30584010f, -0.15011941f, -0.10689932f, -0.16714171f, 0.19112907f, 0.20129736f, -0.12273249f, 0.02608554f, 
    0.18542774f, -0.09929637f, -0.15857413f, -0.03159560f, -0.18795452f, -0.15993488f, 0.11256006f, 0.12733479f, 
    0.23212273f, 0.46960479f, 0.14931020f, 0.20263271f, 0.19713293f, -0.22578771f, 0.77572501f, 0.22400433f, 
    -0.17933048f, 0.02344379f, 0.03024232f, -0.01650644f, 0.10524961f, -0.08921175f, 0.06505548f, 0.10019437f, 
    0.02855666f, -0.06439871f, -0.16154344f, -0.03529399f, -0.00112478f, -0.01806779f, -0.11571267f, -0.17660536f, 
    -0.15189946f, -0.09523295f, -0.13602780f, -0.04955032f, 0.08885882f, 0.12034070f, -0.04913796f, -0.01571658f, 
    -0.15950295f, 0.07360693f, 0.06628975f, -0.18245459f, 0.05685597f, 0.14003929f, 0.09209468f, -0.17470327f, 
    0.14906521f, 0.11216502f, 0.10213923f, 0.04263636f, 0.07018867f, -0.03829037f, 0.09120019f, -0.01662991f, 
    0.05537189f, 0.04073813f, -0.14460310f, -0.49946076f, -0.44090495f, -0.04809839f, -0.09109108f, -0.02143344f, 
    -0.36335108f, 0.06286323f, 0.29972434f, 0.05384576f, 0.26287079f, -0.06602158f, -0.04434687f, 0.46091285f, 
    0.44854832f, -0.19010562f, 0.16540855f, 0.32921523f, 0.04481668f, -0.09954166f, 0.17689291f, -0.10279031f, 
    -0.07119169f, 0.04858840f, -0.12383360f, -0.03515319f, -0.07883133f, 0.04839093f, -0.16731094f, -0.04588484f, 
    -0.01766711f, -0.11904143f, 0.10500770f, 0.13154554f, -0.17089222f, 0.03429789f, -0.04989162f, -0.00363716f, 
    -0.11343168f, -0.00167196f, -0.04253541f, 0.03114799f, -0.11093382f, 0.01999352f, -0.14472826f, 0.13924047f, 
    -0.00647261f, -0.09162726f, 0.07877504f, 0.06834221f, -0.04869390f, -0.06936196f, -0.06333389f, -0.15387461f, 
    0.00213825f, 0.23915865f, 0.24086690f, 0.02542574f, 0.11637695f, 0.04894189f, 0.04191974f, 0.15902992f, 
    0.22984321f, -0.18822670f, 0.00818281f, -0.06666216f, -0.14762129f, -0.14989129f, 0.12976328f, -0.08399329f, 
    0.02111951f, -0.05660391f, 0.00321628f, 0.05389606f, 0.04736018f, 0.00585647f, 0.12924044f, 0.25841540f, 
    -0.12417428f, 0.19697967f, -0.11840497f, -0.09005553f, 0.29525858f, 0.11394940f, 0.23894583f, -0.06070052f, 
    -0.12169412f, -0.07895783f, -0.02425826f, 0.49570841f, -0.03854742f, 0.08582264f, 0.25871199f, -0.07113682f, 
    0.13799527f, 0.15715623f, -0.04311215f, 0.00076370f, 0.18278806f, 0.17996368f, -0.16296214f, 0.05164677f, 
    0.14688775f, 0.13659623f, 0.27396634f, -0.14018254f, -0.34793293f, 0.14118513f, 0.11726529f, -0.11174996f, 
    -0.16906716f, 0.68136537f, -0.08453844f, -0.05699319f, -0.44304252f, 0.01217313f, -0.19212571f, 0.02066594f, 
    0.15470640f, 0.21001306f, 0.25844169f, -0.20514022f, 0.03990978f, -0.13938072f, -0.00786237f, 0.06108905f, 
    0.22980094f, 0.07074810f, 0.02540249f, 0.31761032f, -0.02909653f, -0.07186721f, 0.02724380f, 0.01924989f, 
    0.04774794f, -0.00843835f, -0.07786582f, -0.05765915f, -0.06761431f, 0.06147725f, 0.28627717f, -0.22793062f, 
    0.22844361f, -0.15222478f, 0.17007732f, -0.04536704f, 0.28767210f, 0.45811099f, 0.25066254f, -0.12563440f, 
    0.11508641f, 0.17437097f, 0.38237181f, -0.16935261f, -0.02428493f, 0.03322048f, -0.09683775f, 0.07430289f, 
    -0.43536061f, -0.06055677f, 0.17287397f, 0.12733485f, -0.10045504f, 0.04067999f, 0.17664491f, 0.08778388f, 
    0.16927786f, 0.13813992f, -0.21269627f, -0.03493573f, 0.12579641f, 0.10725180f, 0.04171135f, -0.16960555f, 
    0.39839950f, -0.02469398f, -0.12202968f, 0.21938351f, 0.25006515f, 0.24698909f, 0.37860686f, -0.00023228f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12771635f, 0.04667434f, 0.02144763f, -0.18944609f, -0.09023157f, 0.09172785f, -0.07057852f, 0.16251020f, 
    -0.03627377f, 0.07044367f, 0.31919083f, 0.23377864f, 0.07271904f, 0.26234350f, 0.25000820f, 0.01331934f, 
    0.14175190f, -0.04605824f, -0.14256051f, -0.20462169f, 0.13010889f, 0.28399366f, -0.04495898f, 0.00765624f, 
    0.18759921f, 0.05417609f, -0.04378134f, 0.00078590f, 0.08372686f, 0.15155759f, 0.01032254f, 0.00918877f, 
    0.30786702f, 0.11584909f, -0.12359613f, 0.11903338f, -0.28131813f, 0.17921498f, 0.16149983f, -0.10868677f, 
    0.09563902f, -0.16394995f, 0.03228455f, 0.13797939f, 0.01889770f, -0.10498419f, -0.03525417f, 0.10994905f, 
    0.00229647f, 0.08467185f, 0.15410364f, -0.15122610f, -0.12849446f, 0.20538336f, 0.09930580f, 0.29856849f, 
    0.32810739f, 0.16229412f, 0.13842337f, 0.04293991f, 0.01972632f, 0.32784250f, 0.00856524f, 0.03014070f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.11650499f, 0.04179094f, 0.25901124f, 0.01242858f, 0.05026882f, -0.27179238f, -0.32065147f, -0.12320375f, 
    -0.02653686f, 0.06352255f, 0.07592028f, -0.08453092f, -0.17897983f, -0.08945084f, 0.01230269f, -0.41645503f, 
    -0.16675141f, -0.22359455f, -0.06077903f, -0.07870678f, 0.03036022f, 0.02819600f, 0.15856493f, -0.05977655f, 
    -0.07672109f, 0.05434028f, -0.09493104f, 0.17974915f, -0.06403400f, 0.14306629f, -0.06149554f, 0.06720944f, 
    -0.14844425f, -0.10505290f, 0.10743864f, -0.17437670f, 0.53333157f, -0.27962923f, 0.00594374f, 0.10315682f, 
    -0.00510587f, -0.31088391f, -0.48314604f, -0.17434247f, -0.02650501f, 0.36686143f, -0.08873038f, -0.27713433f, 
    0.63761365f, -0.63509035f, 0.16525191f, 0.10394367f, -0.29174197f, -0.49957484f, 0.10584424f, 0.12828116f, 
    -0.20252123f, 0.07092727f, 0.12749904f, -0.03895284f, 0.14014514f, -0.34885561f, 0.11854266f, 0.24655274f, 
    0.08349164f, -0.05993760f, -0.52009356f, 0.01691446f, 0.01567854f, 0.38705197f, -0.50601315f, 0.00191738f, 
    -0.13774510f, -0.00776361f, 0.10910922f, 0.11987643f, -0.30579790f, -0.00172412f, 0.00360224f, -0.04453378f, 
    -0.16271728f, -0.04183792f, -0.19451511f, -0.03494803f, 0.11187687f, 0.39313516f, 0.29206005f, -0.07614741f, 
    -0.07497017f, 0.01488921f, 0.00832598f, -0.03888034f, -0.05034710f, 0.22771357f, -0.31462276f, -0.11804607f, 
    0.10728385f, 0.04465945f, 0.01565916f, -0.01143206f, -0.56767577f, 0.33375096f, -0.02344242f, -0.09347253f, 
    0.04907694f, -0.07881221f, 0.01922079f, -0.12911068f, 0.07976754f, -0.89251018f, 0.51584029f, -0.10401257f, 
    -0.75896287f, -0.49152631f, 0.07405694f, 0.22472997f, -0.45220736f, 0.07088023f, 0.26548788f, 0.10955434f, 
    -0.04346670f, -0.06425567f, -0.57480758f, -0.05735936f, 0.05871143f, 0.07219780f, 0.10097472f, 0.06982983f, 
    0.14936888f, -0.06975834f, -0.64847028f, -0.31765908f, -0.07638455f, -0.14712374f, 0.70318401f, 0.18723850f, 
    -0.09492189f, -0.45109791f, 0.13363580f, -0.05777163f, 0.11104461f, -0.23492527f, -0.29210621f, -0.38451555f, 
    -0.35146034f, -0.05919031f, 0.21863088f, -0.06660435f, -0.13444956f, 0.43323892f, -0.15883633f, 0.14116466f, 
    0.16127653f, -0.01455219f, 0.15951510f, -0.26165047f, 0.05423095f, -0.26305595f, -0.08829264f, 0.15001278f, 
    0.15337911f, 0.14853245f, 0.25315168f, 0.08519527f, -0.02399768f, 0.21530610f, 0.05622912f, -0.24573894f, 
    -0.03567463f, -0.29347804f, -0.31861752f, 0.06765138f, -0.10842007f, -0.70578384f, 0.07394610f, 0.08969520f, 
    -0.30255282f, 0.30602500f, -0.16658044f, -0.50680423f, -0.03495084f, 0.27081004f, -0.15892899f, -0.13153516f, 
    0.27880412f, -0.00567937f, -0.01593631f, 0.07785458f, 0.00716213f, -0.04932982f, -0.14793400f, -0.11837461f, 
    -0.17847072f, -0.03928011f, 0.31831825f, 0.14696388f, 0.08433712f, -0.04526900f, 0.43036097f, -0.28241396f, 
    -0.06151775f, -0.16796912f, -0.65668535f, -0.02735444f, 0.05324366f, -0.12004934f, 0.22141384f, -0.32252306f, 
    -0.08617953f, -0.02647473f, 0.26911226f, -0.08367198f, -0.11556859f, 0.16338268f, 0.15861139f, 0.16608101f, 
    -0.19078170f, 0.06895598f, 0.07479777f, 0.12537168f, -0.10293990f, -0.02240065f, 0.16233744f, 0.51488167f, 
    -0.89050078f, 0.10871395f, 0.23289004f, 0.00365486f, 0.14994249f, 0.36076438f, -0.00005325f, -0.18651068f, 
    -0.11262874f, -0.01530446f, 0.07743845f, -0.11791059f, 0.07419014f, 0.08968868f, 0.08471924f, -0.25391245f, 
    0.24980730f, -0.00184437f, -0.04903945f, 0.12504442f, -0.05071906f, 0.19645520f, -0.00429229f, -0.58246875f, 
    -0.13472728f, 0.01301974f, 0.27768737f, 0.07746014f, -0.04662238f, -0.02462247f, -0.73573178f, -0.45658252f, 
    0.19745871f, -0.07752957f, 0.11080316f, -0.21338096f, 0.00341406f, 0.06897247f, 0.02035851f, -0.38187310f, 
    -0.12921225f, 0.12312511f, 0.23534703f, -0.04672557f, 0.10238285f, -0.06236612f, 0.05429852f, -0.29531601f, 
    0.03779009f, -0.16306344f, 0.12166232f, -0.10819712f, -0.06591713f, -0.22742853f, 0.20935118f, -0.01178396f, 
    -0.64694595f, -0.06757496f, 0.11377300f, 0.12783810f, 0.03430512f, -0.06760298f, -0.20357928f, -0.10484083f, 
    -0.00008537f, -0.04089390f, 0.10440411f, -0.02425192f, -0.56969309f, -0.37875840f, 0.11029794f, 0.05848197f, 
    0.31143677f, -0.20074098f, -0.25924310f, -0.21257722f, 0.08467592f, 0.12781072f, -0.11541106f, 0.04709463f, 
    -0.68345171f, 0.16386445f, 0.05511149f, 0.07396134f, 0.05045282f, -0.34854898f, 0.21566100f, -0.06738299f, 
    -0.39482355f, -0.02262780f, 0.13192520f, -0.05501702f, 0.10787636f, -0.09735216f, 0.27242967f, -0.02772684f, 
    -0.18735690f, 0.01024966f, -0.15057041f, -0.04455998f, 0.03137404f, -0.30699858f, -0.54823679f, -0.19626346f, 
    -0.01175080f, -0.02772813f, -0.01915650f, -0.16906886f, -0.07853075f, 0.10235944f, 0.10578028f, 0.35331994f, 
    0.31921181f, 0.10867709f, -0.24938060f, -0.06688563f, 0.05744414f, 0.10587435f, -0.21043603f, -0.38053852f, 
    -0.09299795f, -0.07996447f, 0.06691437f, 0.18991131f, 0.05803174f, 0.03538587f, -0.16725421f, -0.24695386f, 
    0.23014326f, 0.05819959f, -0.03277741f, 0.10701277f, -0.02921238f, -0.54895377f, 0.24517566f, -0.28799370f, 
    0.10705902f, 0.12397745f, 0.08911190f, 0.31748819f, -0.09056754f, -0.21173917f, -0.22972813f, -0.06821329f, 
    -0.20391855f, 0.06987608f, 0.14771470f, -0.00277935f, -0.00864176f, 0.29951751f, -0.33357665f, -0.39803979f, 
    0.15830320f, 0.05386731f, 0.19118471f, -0.08082008f, 0.06555368f, -0.20397039f, -0.02129350f, 0.05620624f, 
    -0.17015693f, -0.07377400f, -0.32969087f, -0.17175686f, -0.02657652f, 0.00932243f, 0.33545411f, 0.27291301f, 
    -0.13046940f, -0.22400181f, 0.11269669f, -0.06616996f, 0.16295014f, -0.40477884f, -1.05581272f, 0.27568832f, 
    -0.06236222f, 0.02263126f, -0.10641260f, -0.18009943f, -0.29908577f, -0.65146363f, -0.58708805f, 0.32126051f, 
    0.31728762f, 0.01102482f, -0.68037659f, -0.21699095f, 0.06559364f, -0.38470882f, 0.20239899f, -0.03512968f, 
    -0.25707844f, 0.13798086f, 0.12897408f, -0.11758320f, -0.01517571f, 0.15098305f, -0.15724535f, 0.23845504f, 
    -0.01006245f, 0.28181618f, 0.24198067f, 0.09966232f, 0.07056184f, -0.34823790f, -0.47466081f, -0.07019102f, 
    -0.19398920f, 0.37330070f, -0.24395438f, -0.24226059f, -0.38108468f, -0.38860801f, -0.50202757f, 0.29060638f, 
    0.02942376f, 0.06460840f, -0.95771194f, -0.01280556f, -0.42148370f, 0.00143884f, 0.02378780f, 0.06512429f, 
    -0.41199523f, 0.04659126f, 0.66998953f, 0.32870996f, -0.02178347f, 0.20870318f, -0.20778558f, 0.03397874f, 
    0.05782736f, -0.10505999f, -0.20441398f, 0.09456032f, -0.62531936f, -0.04503402f, -0.06977078f, -0.45164010f, 
    0.24082801f, -0.07003292f, 0.45305502f, -0.08937840f, 0.13590574f, -0.58807772f, -0.55661941f, -0.26248929f, 
    -0.04551707f, 0.03475247f, -0.68927872f, 0.00394487f, -0.08057286f, -0.47802305f, -0.14464697f, -0.03025430f, 
    -0.11077602f, 0.10704385f, -0.14626393f, 0.05193083f, -0.14826494f, -0.10783586f, 0.16383123f, 0.13709721f, 
    0.00763837f, 0.19673836f, 0.11787519f, 0.06061216f, -0.05220124f, 0.22010252f, -0.11126500f, -0.80570894f, 
    0.02805538f, -0.25825164f, 0.11503088f, -0.43704882f, -0.09714113f, -0.63382077f, -0.05198891f, -0.03556605f, 
    -0.29658636f, 0.11181583f, 0.26035461f, 0.07782178f, 0.05913148f, -0.15092987f, 0.17429680f, -0.19365853f, 
    -0.00469658f, -0.01640358f, -0.32301420f, 0.16208835f, 0.00460164f, -0.24074963f, -0.28972170f, -0.14191920f, 
    -0.18848529f, 0.14508411f, -0.42035979f, 0.11529301f, -0.93941826f, 0.39780918f, 0.15017131f, 0.06526857f, 
    -0.02677936f, -0.07007291f, -0.68548489f, -0.03128759f, 0.16771401f, -0.20041080f, -0.77212214f, -0.00142157f, 
    0.02187837f, 0.09440441f, -0.36589795f, -0.26334274f, -0.10231964f, -0.53295124f, -0.19287165f, -0.36608329f, 
    -0.23094645f, 0.13002986f, -0.14388855f, 0.02660368f, -0.13509876f, 0.45709348f, 0.15316235f, 0.23977882f, 
    -0.53721797f, -0.19320066f, -0.00247349f, 0.26882267f, -0.05244869f, -0.24114291f, 0.30291277f, 0.33170724f, 
    0.13523260f, -0.56832862f, 0.14702579f, -0.41035131f, -0.15193799f, 0.36439762f, -0.47175872f, -0.09312107f, 
    0.29537603f, -0.08312062f, -0.51522601f, -0.13824755f, 0.08588924f, 0.32591459f, -0.12699997f, -0.33874619f, 
    0.49118564f, 0.04131609f, 0.13315898f, -0.48933497f, -0.02318190f, -0.54782140f, -0.00515794f, 0.13950036f, 
    -0.04980687f, 0.21656494f, 0.01216940f, 0.25128892f, 0.13842520f, 0.15762429f, -0.23791607f, -0.57474679f, 
    0.13734289f, 0.10600240f, 0.11238542f, 0.02485390f, -0.34711990f, -0.34979236f, 0.01068656f, -0.43288419f, 
    -0.02238286f, 0.05045243f, 0.20560168f, -0.19797048f, -0.06643501f, -0.46568966f, 0.04903489f, -0.44837901f, 
    0.13928555f, -0.01955354f, 0.12227164f, -0.15844272f, -0.29275963f, -0.64396876f, 0.08763649f, -0.07796998f, 
    -0.46665025f, 0.05963935f, 0.00222116f, 0.00072550f, 0.04262045f, 0.36167437f, -0.46740267f, 0.22448848f, 
    -0.70128804f, 0.28610185f, -0.27278769f, -0.47772712f, -0.21584329f, -0.08810054f, 0.29367775f, 0.18298054f, 
    -0.05385241f, 0.09395550f, -0.45008853f, -0.07025894f, -0.37520716f, 0.22277485f, -0.12918231f, 0.04356158f, 
    -0.36436537f, -0.09362641f, -0.44409502f, 0.16023809f, -0.03563113f, -0.50124002f, -0.38774586f, 0.08238310f, 
    0.26434520f, -0.59429663f, 0.28809014f, -0.41865295f, -0.21687679f, 0.19567573f, 0.15694654f, -0.21538019f, 
    -0.66652083f, -0.12994193f, -0.68483305f, -0.03624756f, 0.16838098f, 0.19677930f, -0.09766091f, 0.33472064f, 
    -0.00958000f, 0.09042501f, -0.48201802f, 0.21720070f, -0.03059891f, 0.40469414f, 0.15656106f, 0.19630094f, 
    -0.45464224f, 0.04886024f, -0.15301740f, -0.05260917f, -0.37831250f, -0.14686251f, -0.61832660f, -0.29857174f, 
    0.31405789f, -0.50109035f, 0.06949469f, -0.15238477f, -0.11672218f, 0.08613051f, -0.21920297f, 0.20432460f, 
    -0.35655099f, 0.19178185f, 0.22364445f, -0.06288043f, -0.24725519f, 0.19869541f, -0.62435406f, -0.16201144f, 
    0.00430407f, 0.05823101f, -0.44207969f, 0.06821738f, -0.21937224f, -0.06920745f, -0.33355919f, -0.28185841f, 
    -0.16070212f, -0.05758747f, -0.08991149f, -0.19923900f, -0.00303901f, -0.18683769f, -0.12827408f, 0.14610803f, 
    0.06218882f, 0.11762689f, 0.10040308f, 0.03080472f, 0.26876771f, -0.17282125f, 0.30730671f, 0.36168250f, 
    -0.17023584f, 0.09042993f, -0.00866562f, -0.08054148f, 0.29316738f, -0.58283007f, 0.23306710f, 0.23294924f, 
    -0.14743823f, 0.09281723f, -0.29987079f, -0.59522676f, -0.12931021f, -0.54261863f, 0.33160302f, -0.49280408f, 
    0.05908584f, -0.13005944f, -0.33218634f, -0.20485210f, -0.17241119f, -0.07112297f, -0.75082260f, -0.06574687f, 
    0.26326901f, 0.21321380f, 0.15426277f, -0.07351350f, -0.02118501f, -0.08534855f, 0.32856503f, 0.27095351f, 
    -0.24686806f, -0.02365306f, -0.05866643f, -0.56259185f, -0.06146191f, -0.31432161f, -0.24066477f, -0.22032562f, 
    -0.38994044f, -0.10191428f, 0.31130591f, -0.02109630f, -0.25692967f, 0.28585872f, -0.32112753f, -0.95359558f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13900000f, 0.21955138f, -0.12607120f, -0.18324779f, -0.01847127f, 0.14694992f, -0.05440697f, -0.03171593f, 
    -0.07710639f, 0.05581781f, 0.17701998f, -0.00100580f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
