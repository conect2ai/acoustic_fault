#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34605315f, 0.43174008f, 0.52217072f, -0.47338477f, -0.34572169f, 0.23216529f, -0.03996662f, -0.34172675f, 
    -0.56538665f, -0.47828627f, -0.22999607f, -0.05273292f, -0.01876314f, 0.55184162f, 0.16243167f, -0.17013955f, 
    0.40016198f, -0.10811398f, -0.39187792f, -0.26335433f, -0.51220018f, -0.02334801f, -0.09845970f, -0.08671014f, 
    -0.14148863f, 0.18723166f, -0.30990756f, -0.58450347f, -0.17393389f, 0.18807198f, 0.53509748f, 0.20641539f, 
    0.10275471f, 0.51050925f, 0.28149834f, 0.34017897f, 0.02999059f, 0.05484850f, -0.08824845f, -0.34459892f, 
    0.14801511f, -0.21174094f, 0.46453428f, 0.27894381f, -0.42936966f, -0.02802323f, 0.02559502f, 0.00033170f, 
    0.01555454f, 0.05079225f, -0.52054811f, -0.12376371f, -0.26535302f, 0.15346456f, 0.44442651f, -0.09043624f, 
    0.39892557f, -0.60550648f, -0.21927914f, -0.05044850f, 0.18248530f, 0.05642522f, 0.47694665f, -0.11345357f, 
    -0.33687732f, -0.23461731f, 0.15172936f, 0.29871726f, -0.21505761f, -0.01478734f, -0.21862261f, -0.02481348f, 
    0.26279229f, 0.26692978f, -0.16555901f, -0.26668596f, -0.17902787f, 0.34488347f, -0.05295268f, 0.20991510f, 
    0.33753103f, 1.02522027f, -0.57263678f, -0.20378655f, -0.01622680f, 0.24697700f, 0.55777955f, -0.06682380f, 
    0.17399675f, 0.27624744f, 0.11562596f, -0.25306633f, -0.33792537f, -0.15869807f, 0.20100941f, -0.06687611f, 
    -0.01532891f, 0.21222402f, 0.09486109f, 0.18525915f, 0.13669892f, 0.53536570f, 0.25749466f, 0.47115400f, 
    0.22424842f, -0.05949827f, 0.20999193f, 0.51184440f, 0.35251459f, 0.44273242f, -0.40585518f, 0.27387398f, 
    -0.44743070f, -0.34798771f, -0.06741167f, -0.05021736f, -0.17096578f, -0.20883107f, 0.36895403f, 0.24771249f, 
    -0.11576097f, -0.20264339f, 0.09029801f, -0.22972456f, -0.16558109f, -0.56702477f, -0.61402529f, -0.83382344f, 
    -0.45112982f, 0.12857588f, 0.18493563f, 0.70192617f, 0.33815643f, -0.04968549f, 0.26099053f, -0.04866933f, 
    0.19246201f, 0.24223553f, 0.11877950f, -0.17937599f, -0.21936724f, -0.24614500f, 0.02137645f, -0.21884167f, 
    -0.23696530f, -0.20174474f, -0.22114076f, 0.20211922f, -0.14134134f, -0.01498534f, 0.70068145f, 0.23206611f, 
    0.25916424f, 0.35176048f, 0.69553131f, -0.62632686f, 0.31098181f, -0.45702684f, -0.45323482f, -0.50341934f, 
    0.06186816f, 0.19182029f, 0.25136802f, 0.13839003f, 0.11403044f, -0.02015320f, 0.39267245f, 0.25312525f, 
    0.12611523f, 0.03930356f, -0.09260944f, 0.16582078f, 0.05601262f, 0.19816092f, 0.15978709f, -0.58048916f, 
    0.08702637f, 0.40174145f, 0.07545674f, 0.51959741f, -0.72339737f, 0.02234137f, -0.00982770f, -0.23243566f, 
    -0.50969028f, 0.18022871f, 0.45440504f, -0.05511405f, -0.01653030f, 0.19039866f, 0.25408104f, -0.15294598f, 
    0.09568349f, 0.02869737f, 0.38634902f, 0.19814847f, -0.12919909f, -0.18001552f, -0.24236815f, -0.34168622f, 
    -0.48314992f, -0.06037698f, -0.30830571f, -0.60667515f, -0.40202674f, -0.02334442f, -0.03640284f, -0.18035688f, 
    0.05901916f, 0.33137259f, -0.13460974f, -0.04592660f, 0.00901049f, -0.15295070f, -0.14100359f, 0.05045691f, 
    -0.17153089f, -0.02587705f, 0.19444311f, 0.56533754f, -0.44418427f, 0.01658717f, -0.44060224f, 0.02219613f, 
    -0.35887918f, 0.29603043f, -0.27115384f, -0.50745821f, -0.36881706f, -0.65011203f, -0.17240712f, 0.70400333f, 
    0.42144668f, -0.29097208f, 0.32667267f, 0.21470504f, 0.34277415f, -0.19326387f, -0.08991110f, -0.08741728f, 
    -0.31157678f, -0.01756395f, 0.13503714f, -0.04794183f, -0.06911346f, -0.06922969f, 0.02559514f, 0.08567274f, 
    -0.08912478f, -0.14459221f, -0.17440031f, -0.48003712f, 0.52917242f, 0.62519056f, -0.49522966f, 0.17024197f, 
    0.10777523f, -0.46009526f, -0.41420221f, -0.13474700f, -0.09771251f, 0.32640514f, -0.15706658f, 0.36580241f, 
    0.06928802f, 0.08327539f, 0.15657163f, -0.32284164f, 0.03891445f, -0.08591051f, 0.02949012f, -0.03186417f, 
    0.42339429f, -0.06779096f, -0.14047806f, 0.02158695f, -0.33037892f, -0.30226821f, -0.17967273f, 0.44458905f, 
    -0.14571439f, -0.68539429f, -0.24886249f, -0.03778253f, 0.40191808f, 0.42960438f, -0.06339265f, -0.32835603f, 
    -0.11792371f, -0.46548638f, 0.01764112f, 0.36346433f, 0.12186914f, 0.32163072f, 0.27572680f, -0.11342562f, 
    0.11337785f, -0.08699714f, 0.07079118f, -0.20357162f, 0.68526250f, 0.51250392f, 0.18186393f, -0.24707244f, 
    0.16999757f, 0.51842898f, 0.20310543f, 0.21014228f, 0.29117060f, 0.11611041f, -0.04556797f, 0.39381605f, 
    -0.37278146f, -0.08852967f, -0.20663346f, -0.18559541f, -0.18306610f, -0.33973294f, -0.20502235f, -0.41251832f, 
    0.26277637f, 0.00543297f, 0.03611150f, 0.02124719f, -0.04730895f, 0.90020865f, -0.09468960f, 0.28590438f, 
    0.39257169f, 0.28247598f, 0.11631506f, 0.51583338f, 0.08055127f, 0.24941789f, 0.44873998f, -0.64714265f, 
    -0.10243656f, -0.10993227f, -0.02417811f, -0.14924496f, 0.07882250f, 0.25160426f, 0.14530453f, -0.09411830f, 
    -0.01890515f, -0.30746517f, 0.25180253f, -0.16405655f, 0.01525302f, -0.07105812f, -0.09209669f, 1.07537091f, 
    0.24268135f, -0.40307289f, -0.01785515f, -0.34368393f, 0.76614988f, 0.33719736f, -0.56742167f, 0.15999001f, 
    0.34005314f, -0.12362074f, -0.15336530f, -0.26430100f, -0.39563242f, -0.02289772f, -0.22577429f, -0.03508966f, 
    -0.22032207f, -0.32207939f, -0.07466382f, 0.10073676f, -0.05649510f, -0.08728059f, 0.23060943f, -0.14685459f, 
    -0.90896451f, 0.06986006f, 0.71053714f, 0.44473121f, -0.98356384f, 0.81063437f, 0.37285563f, -0.40203616f, 
    0.14960410f, 0.32793015f, 0.02113498f, 0.17412809f, 0.08586629f, 0.20011507f, -0.22253963f, 0.15951125f, 
    -0.11985432f, 0.04579300f, 0.02692117f, 0.15819782f, -0.16588333f, -0.00012732f, -0.12159237f, 0.09054194f, 
    -0.57938945f, 0.17296110f, 0.26001188f, -0.34930989f, -0.05006721f, 0.50397593f, 0.28993675f, 0.32144499f, 
    0.19371526f, 0.15120974f, 0.33355358f, -0.15199426f, 0.29838043f, -0.37317809f, -0.02024681f, -0.04715367f, 
    -0.01557346f, -0.02430714f, 0.33104897f, -0.37234250f, -0.01234775f, 0.07495609f, 0.32383192f, 0.62587643f, 
    0.08682425f, -0.56772220f, 0.89890432f, -0.39317620f, -0.29569030f, -0.45511052f, 0.36015791f, -0.55790365f, 
    -0.60737360f, 0.10880058f, -0.37764344f, -0.31055787f, -0.00173185f, -0.00405139f, 0.16905287f, -0.09132855f, 
    -0.21695848f, 0.01547613f, -0.04974046f, 0.13671687f, 0.17174576f, -0.00195411f, -0.18079005f, 0.07949955f, 
    -0.02910750f, -0.07139323f, -0.46937349f, -0.40771276f, -0.48753834f, -0.24118586f, 0.17014144f, -0.53500307f, 
    -0.49417073f, -0.16667324f, 0.10245610f, -0.54646337f, 0.30077785f, 0.41917184f, 0.08906879f, 0.14531688f, 
    0.20083994f, 0.21251784f, 0.12513402f, 0.31543082f, 0.07734400f, 0.03244710f, -0.27717963f, 0.15004556f, 
    0.17720909f, 0.02495233f, 0.16678071f, -0.39145693f, -0.63374251f, -0.60630035f, -0.42638150f, -0.43477619f, 
    0.17170261f, -0.29964846f, -0.13277911f, 0.12991956f, 0.26545769f, -0.35715395f, -0.15497413f, 0.12968528f, 
    0.04680609f, -0.40482682f, 0.04740847f, 0.25312698f, 0.27562082f, -0.21400183f, 0.22981384f, 0.04910896f, 
    0.17539272f, 0.02392323f, -0.14444265f, 0.01121391f, -1.16380692f, 0.14991020f, -0.15538388f, -0.07152069f, 
    -0.13850881f, 0.16238323f, 0.75915146f, -0.27574822f, 0.01430608f, 0.60595179f, -0.34529620f, -0.40439883f, 
    0.21821953f, -0.48527360f, 0.33292669f, -0.28148621f, -0.22863312f, -0.17327815f, -0.08443493f, -0.02441305f, 
    0.06886920f, 0.09075337f, -0.09598087f, -0.17157960f, -0.13815276f, 0.72236210f, 0.06083947f, -0.57344639f, 
    -0.73948771f, 0.01306320f, -0.12870933f, -0.11021753f, 0.43228811f, 0.05780123f, 0.34396613f, -0.36524802f, 
    0.29510736f, -0.18021795f, 0.05524339f, -0.14042436f, -0.01347588f, 0.04587125f, -0.14318959f, -0.00865436f, 
    -0.01010986f, -0.22230163f, 0.07947657f, -0.07202699f, -0.08161505f, 0.24010949f, 0.45064992f, 0.78099847f, 
    0.53359389f, 0.54781038f, 0.28162718f, 0.38493055f, -0.04342802f, -0.29286811f, -0.08265565f, -0.45633176f, 
    0.21227951f, 0.12985779f, -0.05740489f, 0.01702121f, 0.25865945f, 0.28871268f, 0.09340547f, 0.18912308f, 
    0.17226781f, 0.12959200f, 0.25036779f, -0.01654502f, 0.18061286f, 0.17460619f, 0.36145389f, 0.15765709f, 
    0.22554237f, 0.85789144f, 0.99579531f, 0.39739168f, 0.34798640f, -0.02366140f, 0.09744596f, -0.39639145f, 
    0.51600826f, 0.30505267f, 0.17781204f, -0.19351023f, -0.11967120f, -0.09323250f, -0.20063202f, -0.08032381f, 
    0.03915519f, -0.16310468f, -0.32137507f, 0.02602455f, 0.00749751f, 0.06106216f, 0.13055266f, -0.10464313f, 
    -0.66758305f, -0.58436024f, -0.32416111f, -0.13625816f, -0.29949614f, 0.60524857f, 0.89561492f, 0.37446502f, 
    0.07893702f, 0.30399573f, -0.08710206f, -0.27536267f, -0.12100000f, -0.35135502f, -0.02473125f, -0.10665115f, 
    0.17991661f, 0.00714662f, 0.28404015f, -0.28158242f, -0.12909718f, -0.28848708f, 0.02573178f, 0.01173053f, 
    0.07536073f, -0.24691971f, 0.24568047f, 0.59547061f, 0.18770415f, -0.17295304f, -0.63122970f, -0.08112136f, 
    -0.48856178f, -0.03332819f, -0.25975120f, 0.32155102f, 0.38134709f, 0.21367279f, 0.01068137f, 0.07808903f, 
    -0.34319893f, -0.08659096f, 0.13565300f, 0.20237616f, -0.14948285f, 0.01546774f, -0.04040376f, 0.01642867f, 
    0.24582580f, -0.16770130f, 0.73988825f, 0.01677311f, -0.46441799f, -0.43346730f, -0.43436706f, -0.01504784f, 
    0.09929023f, 0.03168036f, -0.14642034f, 0.29285243f, 0.28034481f, -0.57500017f, 0.38983718f, 0.00308995f, 
    0.10893778f, 0.10766059f, 0.01885630f, -0.23346470f, 0.01082891f, 0.50724083f, 0.31956649f, -0.20551638f, 
    0.01129761f, 0.31770176f, -0.32277697f, 0.64723200f, 0.59319872f, -0.12684448f, -0.59682876f, -0.14560723f, 
    0.38316038f, 0.21058950f, -0.10449562f, 0.21290040f, 0.36684155f, 0.22356172f, 0.46877334f, -0.14496733f, 
    -0.02671522f, 0.00725143f, -0.01388323f, 0.19824661f, 0.11205838f, 0.16241454f, 0.27593121f, -0.26718590f, 
    0.01121018f, 0.16572720f, -0.20359403f, 0.18283983f, -0.01368105f, -0.43655169f, -0.29042539f, -0.31904483f, 
    -0.12011518f, -0.03279122f, -0.44857427f, 0.27038583f, 0.34182766f, -0.42330122f, -0.24492854f, -0.50415301f, 
    0.21821858f, -0.17937280f, -0.05090283f, 0.08642682f, -0.30618393f, -0.33115089f, -0.25255537f, -0.03547773f, 
    -0.05782631f, 0.09534718f, 0.05320204f, -0.01242618f, -0.28137726f, 0.45586640f, 0.21745692f, 0.26555178f, 
    0.17411982f, 0.43174526f, -0.71084982f, -0.88978368f, -0.51866710f, -0.35817403f, 0.10397884f, 0.05608971f, 
    0.16814709f, -0.10111420f, 0.14571413f, -0.21052141f, -0.07029799f, -0.05635202f, -0.29285386f, -0.17230354f, 
    0.23898673f, 0.22015092f, 0.21749313f, 0.01828381f, 0.18859871f, -0.02389667f, -0.13651660f, -0.38964009f, 
    -0.62949294f, -0.41793987f, -0.02647869f, 0.32765752f, -0.28893441f, -0.55334556f, 0.02659667f, -0.02968585f, 
    -0.38413328f, -0.18953073f, 0.61329871f, 0.15635356f, -0.00867458f, 0.22190145f, 0.17927404f, 0.08813625f, 
    0.05105520f, -0.26862308f, 0.20607868f, -0.00664653f, -0.03748599f, -0.00039611f, -0.12359995f, 0.24973139f, 
    0.01703647f, 0.52036983f, 0.76557279f, 0.05013111f, -0.15872848f, -0.42598298f, 0.63128275f, 0.71889478f, 
    -0.41479808f, -0.20912138f, -0.04633879f, 0.00792937f, -0.27357885f, -0.17408289f, -0.12136368f, -0.03361520f, 
    0.17287198f, 0.04097686f, -0.09759127f, 0.03257472f, -0.15650027f, -0.31379923f, 0.18790221f, -0.14308983f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20184614f, 0.03020309f, 0.23323599f, 0.25777566f, 0.23665291f, 0.18835638f, 0.07297660f, 0.02841111f, 
    -0.13881478f, 0.05744503f, 0.19639239f, 0.22118236f, 0.01998132f, 0.02776161f, 0.24872763f, 0.15970920f, 
    -0.08451289f, -0.06381421f, 0.20749237f, 0.18434332f, -0.07662864f, -0.08562716f, 0.04129443f, 0.18129711f, 
    0.01924103f, 0.07965479f, 0.18382335f, 0.23450975f, 0.13040432f, 0.31210861f, 0.06622937f, 0.08540631f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17085108f, -0.25250056f, -0.04198737f, -0.08517303f, -0.01468212f, 0.03339775f, -0.03841693f, -0.04973864f, 
    -0.02687976f, -0.10628980f, -0.01309648f, 0.06709426f, -0.01862373f, 0.07289061f, 0.12605543f, 0.21130943f, 
    0.05407816f, 0.03183012f, -0.00787144f, 0.05007992f, -0.06836282f, -0.15565497f, 0.07038381f, 0.02001181f, 
    -0.14391981f, 0.08038006f, 0.07139789f, -0.03594277f, 0.14278509f, -0.03652606f, 0.10166132f, -0.09296022f, 
    0.05824442f, -0.00971699f, 0.00479799f, 0.15148950f, 0.16706361f, 0.04499713f, -0.13340892f, -0.03598328f, 
    0.02039532f, -0.03139703f, 0.08191023f, 0.06048102f, -0.01593573f, 0.07777013f, -0.02495758f, 0.11402676f, 
    0.29551530f, 0.04937179f, -0.12402763f, 0.15584216f, 0.10587225f, -0.06483369f, -0.07501645f, -0.00260795f, 
    -0.06149628f, 0.17433961f, -0.09706174f, 0.02352109f, -0.16504955f, -0.03040851f, 0.05090094f, 0.02614475f, 
    -0.00987631f, 0.06293549f, 0.02259401f, -0.06935842f, 0.00381094f, -0.02009694f, 0.12894559f, -0.03098517f, 
    0.02188197f, -0.18511923f, 0.05765861f, 0.10471054f, 0.15669365f, 0.06438245f, 0.03112763f, -0.10097245f, 
    0.12949246f, -0.00557859f, 0.07837090f, 0.08526141f, -0.19698468f, -0.23372485f, 0.06042868f, 0.00891495f, 
    -0.05109377f, -0.05693947f, -0.07989912f, 0.03223281f, -0.04834716f, 0.12787309f, -0.03517443f, 0.13107552f, 
    -0.16748540f, 0.19828962f, 0.01213238f, -0.08165915f, 0.10393510f, -0.20735019f, -0.02306558f, -0.12920924f, 
    -0.11953195f, -0.05679603f, -0.02007408f, 0.03650956f, 0.30326882f, 0.28087288f, -0.22550064f, 0.00188279f, 
    -0.09089995f, -0.06931258f, -0.08588695f, 0.18778007f, 0.07486669f, 0.04774171f, -0.09114909f, 0.16033773f, 
    0.03975933f, -0.25606233f, -0.03197949f, -0.01532722f, 0.01904761f, -0.14370191f, 0.10707779f, -0.08209091f, 
    -0.01468514f, 0.06262105f, 0.00284482f, 0.08522050f, -0.23361585f, 0.00309923f, -0.05397171f, 0.04657198f, 
    0.08268888f, -0.11188453f, -0.06455221f, 0.09917891f, -0.02143118f, -0.00144700f, 0.03181767f, 0.12907046f, 
    0.27477279f, -0.00474102f, -0.11800413f, 0.01963896f, 0.00937946f, 0.10464894f, -0.05811133f, 0.03820955f, 
    0.07473680f, 0.04754819f, -0.17966944f, -0.11444385f, 0.19889353f, -0.03976417f, -0.05891536f, 0.18786922f, 
    0.05017043f, -0.07295489f, -0.06876556f, -0.05141961f, 0.08618266f, 0.04122210f, -0.02336149f, -0.03670442f, 
    0.35031673f, 0.17396797f, -0.10711634f, 0.11946292f, -0.03241351f, 0.06545667f, -0.13139082f, -0.00378610f, 
    0.15325311f, 0.09783576f, 0.12141690f, 0.05325369f, -0.06377625f, 0.03891035f, -0.05967632f, -0.09838318f, 
    0.13340047f, -0.07643326f, 0.03990303f, 0.10788609f, 0.05512055f, 0.06466113f, 0.05148249f, -0.07913914f, 
    0.02259376f, 0.04704834f, 0.09203655f, 0.02272348f, -0.00744631f, 0.10026183f, 0.24760301f, -0.00756944f, 
    0.13696469f, -0.09495050f, 0.05684225f, -0.05404904f, -0.21358496f, -0.19816196f, -0.14862984f, -0.30133182f, 
    0.05659436f, -0.18236782f, -0.20268536f, 0.02823571f, 0.00405218f, -0.05322652f, 0.06810450f, -0.18341479f, 
    -0.23531997f, 0.14924818f, 0.06786630f, -0.16751982f, -0.10638931f, 0.01625504f, -0.15110964f, -0.13548557f, 
    0.05286013f, 0.07661749f, 0.00441277f, 0.30956456f, -0.23646295f, -0.04175149f, 0.29245552f, 0.13665558f, 
    -0.07850924f, 0.14787467f, -0.13040312f, 0.00203291f, 0.01963612f, -0.12896425f, 0.03686326f, -0.10812019f, 
    -0.41508532f, -0.10528596f, 0.09840538f, -0.03313703f, -0.01600099f, -0.02588625f, -0.08189666f, 0.03456459f, 
    -0.01724332f, 0.08083888f, -0.01980964f, -0.26758283f, -0.20554768f, 0.18411970f, -0.14646378f, -0.06925121f, 
    -0.04299602f, 0.01276075f, -0.09184934f, -0.19326547f, 0.19898622f, -0.01210152f, -0.06074172f, 0.16283502f, 
    0.03427799f, -0.14442873f, 0.07369160f, 0.13573214f, 0.10425622f, 0.12259659f, -0.11939265f, -0.01485922f, 
    0.09985482f, 0.13831308f, 0.10749377f, 0.19582570f, 0.09490047f, -0.10441653f, 0.07557058f, 0.14787613f, 
    0.14083451f, -0.08249057f, -0.11746877f, -0.09754568f, 0.02558706f, 0.01052734f, 0.05954044f, -0.08256504f, 
    -0.14601617f, 0.00875457f, 0.10620402f, 0.04137290f, -0.12987688f, 0.02557484f, -0.11455561f, -0.06937464f, 
    0.05215690f, -0.05454855f, 0.03542451f, -0.04579076f, 0.38501489f, -0.02367950f, 0.04120293f, -0.16420302f, 
    -0.01036995f, 0.00925432f, -0.05680943f, -0.01076461f, 0.13453591f, -0.04108670f, 0.00657252f, 0.06513675f, 
    0.07235772f, 0.25982496f, -0.06261352f, 0.05707617f, -0.03518184f, -0.06047903f, 0.07060705f, 0.06168577f, 
    0.03549360f, 0.04320913f, -0.03641263f, -0.06690391f, 0.26595405f, 0.21125303f, -0.18188345f, 0.00767145f, 
    -0.03763003f, 0.11171011f, 0.11972467f, -0.02147926f, 0.05847720f, -0.00441237f, 0.05631240f, 0.09785707f, 
    -0.18002266f, 0.16866215f, 0.09036022f, -0.24721125f, 0.00297935f, 0.03322232f, 0.04485623f, 0.05252254f, 
    -0.08998565f, -0.03649841f, -0.08988588f, -0.18395482f, -0.07504413f, -0.14589588f, -0.19290641f, 0.01897917f, 
    0.00565085f, -0.08589330f, 0.08118388f, -0.00179942f, 0.06852882f, 0.09061597f, -0.06444099f, 0.05342888f, 
    -0.12719056f, 0.09450837f, 0.04148543f, 0.02521613f, 0.03115340f, 0.07877873f, -0.02720257f, 0.04186870f, 
    0.03422607f, -0.04820723f, 0.12739082f, -0.07953227f, -0.00058983f, -0.10610978f, -0.04985269f, 0.15625171f, 
    0.09863713f, -0.13772210f, -0.14283361f, 0.00983882f, -0.07082270f, 0.02667487f, 0.19826043f, -0.00208499f, 
    0.04274352f, 0.03146375f, -0.04040670f, 0.02317995f, 0.00225213f, -0.01255402f, -0.00105453f, -0.00774073f, 
    0.01611861f, 0.00231371f, 0.00071004f, -0.04971028f, -0.00343945f, -0.05016682f, 0.02601251f, -0.00060084f, 
    0.01232854f, -0.01889565f, -0.01749748f, 0.02791194f, -0.01203599f, 0.01908483f, 0.01824934f, -0.02687282f, 
    0.04322832f, -0.05230470f, -0.01133734f, 0.02769446f, 0.01278340f, -0.03516387f, -0.02969049f, -0.01820635f, 
    -0.04347871f, 0.02672783f, 0.02842328f, -0.04926879f, 0.00603636f, -0.03407173f, 0.01594461f, -0.00045528f, 
    -0.01350608f, 0.03155398f, -0.04624866f, -0.01519305f, 0.02448471f, 0.03299267f, -0.00117998f, 0.02890229f, 
    -0.05645742f, 0.02156155f, -0.03889738f, 0.04387234f, 0.01997178f, -0.04361240f, 0.01778825f, -0.00771017f, 
    0.02343528f, 0.04394665f, -0.00479637f, -0.01669908f, -0.00612827f, 0.00691980f, -0.01956300f, -0.02204956f, 
    0.00127723f, 0.01122559f, 0.02101633f, 0.03940417f, -0.03580489f, 0.04146053f, -0.05688745f, -0.00759237f, 
    0.00623321f, -0.03942756f, -0.02116777f, -0.03596428f, -0.04930993f, -0.01427527f, 0.02350250f, -0.05736182f, 
    0.01207116f, -0.03212326f, 0.00017878f, -0.02359349f, -0.00455494f, 0.03005230f, -0.03143757f, 0.01257715f, 
    0.03018889f, -0.02773044f, 0.00312507f, -0.01343902f, 0.00827478f, 0.01000443f, -0.01625648f, -0.02512570f, 
    -0.05060929f, -0.00851528f, -0.04743462f, -0.04859680f, -0.03344343f, -0.03077235f, 0.00439613f, 0.01881410f, 
    0.02507124f, -0.00111978f, -0.04569835f, -0.04175221f, 0.01533768f, 0.03414704f, 0.03322848f, 0.02369347f, 
    -0.03923542f, 0.02568569f, 0.04086689f, 0.00177997f, -0.05016192f, 0.00652073f, -0.05621153f, 0.00560612f, 
    -0.02669324f, 0.02488827f, 0.04697262f, 0.01226560f, -0.04561211f, 0.02296121f, -0.04718800f, -0.02068339f, 
    -0.04812179f, -0.00385536f, 0.02535250f, 0.01671755f, 0.02241194f, -0.02800688f, -0.04708510f, -0.04167132f, 
    -0.00315757f, 0.04026595f, -0.01804419f, 0.04551979f, -0.00606987f, -0.02271910f, -0.00053384f, -0.01705777f, 
    -0.03854252f, 0.00262617f, -0.00076372f, -0.01395995f, -0.03482798f, -0.02584757f, -0.02171736f, 0.00078808f, 
    -0.05294134f, 0.02597834f, 0.00113289f, 0.03739249f, 0.04495998f, -0.05858340f, -0.02188450f, -0.03152514f, 
    -0.02805252f, 0.02719157f, -0.02510318f, 0.02468386f, 0.01200556f, -0.01896849f, -0.04213349f, 0.02645436f, 
    -0.01806310f, -0.05520976f, -0.00503509f, -0.01733305f, 0.02670654f, 0.01301960f, -0.05432915f, -0.04782073f, 
    -0.00993179f, 0.01036085f, -0.05570125f, 0.04383755f, 0.02117096f, -0.00495674f, 0.04569359f, -0.04329275f, 
    0.00428480f, -0.04296174f, -0.01600860f, -0.02797727f, 0.01626620f, -0.03148023f, -0.05438112f, 0.00341514f, 
    -0.01437445f, 0.02032590f, -0.00113640f, 0.03691518f, 0.00722328f, -0.00085862f, -0.00201436f, 0.02888107f, 
    0.00039068f, 0.03231314f, 0.04038311f, -0.04032649f, -0.04522648f, 0.00088475f, -0.00366980f, 0.00729581f, 
    0.04165075f, 0.04190445f, 0.02271483f, 0.00817678f, -0.05108096f, -0.01602433f, 0.01748353f, -0.01421184f, 
    -0.00143893f, -0.02486655f, -0.04119698f, 0.01712399f, -0.04432337f, 0.01765763f, -0.04014685f, -0.01022448f, 
    -0.01984125f, 0.00144784f, 0.02842387f, -0.01002777f, -0.00027620f, -0.02089407f, -0.04206556f, 0.03057422f, 
    0.01213374f, 0.00365975f, -0.01864092f, -0.01550003f, 0.00110139f, 0.02537431f, 0.00888588f, -0.03673959f, 
    0.02704475f, -0.01323298f, -0.03842911f, -0.02191720f, -0.05211807f, 0.00844391f, 0.01777818f, 0.01588673f, 
    0.02912330f, -0.03531462f, 0.00344574f, -0.04508895f, -0.01412728f, 0.01780408f, 0.01123258f, 0.01974501f, 
    -0.03022550f, 0.03204250f, -0.00149832f, 0.02195424f, -0.04820751f, 0.03153445f, 0.01231100f, -0.00025131f, 
    -0.03761749f, 0.02268318f, 0.04229836f, -0.04180440f, 0.00618007f, -0.03465251f, -0.01974510f, 0.03580224f, 
    0.00427290f, -0.05556868f, 0.03219758f, 0.02861460f, 0.04532006f, 0.00544088f, -0.04927169f, -0.03927053f, 
    0.00402180f, 0.03344794f, 0.00031305f, -0.02437559f, 0.00958262f, 0.02565060f, -0.03752965f, -0.00256344f, 
    0.04162052f, -0.00105431f, -0.04303893f, -0.05707986f, -0.05393399f, 0.01139171f, -0.02017468f, -0.02369073f, 
    -0.03695787f, 0.03176452f, 0.02983742f, -0.04365455f, 0.04316365f, -0.00693432f, -0.03485534f, -0.00957065f, 
    -0.03480090f, 0.00768774f, -0.00729713f, -0.03007920f, 0.01064967f, 0.01210394f, 0.02655814f, 0.00191319f, 
    -0.04009166f, -0.00112541f, -0.01385745f, 0.04061728f, -0.01606799f, 0.01130830f, -0.04446987f, 0.02592182f, 
    -0.02411335f, -0.05485907f, -0.03050674f, 0.03198699f, 0.00899836f, 0.01773508f, -0.01842043f, -0.01894981f, 
    0.02330259f, 0.01633765f, 0.03795656f, 0.03233475f, -0.02170108f, -0.01250477f, -0.00359041f, 0.03808438f, 
    0.01996745f, 0.02579274f, -0.03327748f, -0.03833985f, 0.03528679f, 0.00747965f, -0.03741920f, 0.01968264f, 
    0.00641195f, 0.03052932f, 0.00834196f, -0.01344592f, -0.02399952f, 0.03988038f, -0.04742192f, 0.03077732f, 
    -0.03852750f, -0.01627419f, -0.02999817f, -0.02111908f, 0.04177539f, -0.03630075f, 0.01104904f, -0.01735710f, 
    0.03050921f, 0.01881614f, -0.05038484f, -0.05572602f, 0.01697236f, 0.01559270f, 0.01105940f, -0.03798708f, 
    -0.02139004f, -0.04879623f, -0.01601076f, 0.01197490f, -0.03217713f, -0.01828321f, -0.00426255f, -0.00045741f, 
    -0.05135415f, -0.04897255f, -0.03205707f, 0.01849121f, -0.02917822f, -0.04017143f, 0.01523262f, 0.02380692f, 
    0.03367000f, 0.03964169f, -0.04795065f, -0.00740654f, 0.01871014f, -0.04392887f, 0.03920757f, -0.00493758f, 
    0.00736084f, 0.01538347f, 0.02711158f, -0.06022387f, 0.03246555f, 0.03869294f, -0.03681635f, -0.03701065f, 
    -0.05188187f, 0.00240316f, 0.00182990f, -0.03607066f, -0.02373412f, 0.00296125f, -0.00689456f, 0.00385779f, 
    -0.01883123f, -0.05892385f, -0.02182630f, -0.04943524f, -0.03636272f, 0.02129495f, -0.03186221f, -0.05377213f, 
    -0.04361297f, -0.00523743f, 0.03036231f, 0.03453315f, -0.04225993f, 0.00753156f, -0.05668824f, -0.03714098f, 
    -0.00588552f, -0.05846550f, -0.05517568f, 0.04304255f, 0.00088279f, 0.04238365f, -0.00147573f, -0.03611251f, 
    -0.03562278f, 0.02233493f, 0.03170769f, -0.02524319f, -0.02374020f, -0.03240913f, 0.03300216f, -0.01778610f, 
    -0.03433577f, 0.01242842f, 0.02630532f, 0.02590163f, 0.03293232f, 0.02786167f, -0.03042985f, 0.03117499f, 
    -0.00988233f, 0.01356421f, 0.03526264f, -0.03353938f, -0.01097719f, -0.02211219f, -0.00158549f, -0.00970251f, 
    -0.03858161f, 0.02974291f, 0.03083697f, -0.03836208f, 0.01227185f, 0.02345624f, -0.05306584f, 0.03980035f, 
    0.00340540f, -0.03095483f, -0.02094302f, -0.03844520f, -0.05069356f, -0.05043479f, -0.00517113f, 0.04538164f, 
    0.00300980f, 0.01611180f, -0.02626655f, 0.01121451f, -0.00396510f, 0.03507433f, -0.04847432f, -0.02027606f, 
    0.04322949f, 0.03821156f, -0.00322989f, -0.04722385f, -0.02289033f, -0.04495599f, -0.00042101f, -0.02220816f, 
    -0.00628851f, -0.01776921f, 0.00331113f, 0.02088943f, -0.00453766f, 0.02277632f, -0.04158588f, 0.01613245f, 
    -0.02572742f, 0.01117886f, 0.01537985f, 0.01727499f, 0.03451573f, 0.03319903f, 0.03683124f, -0.01019834f, 
    -0.00444299f, -0.00041042f, -0.05049043f, -0.04705288f, 0.00190395f, 0.04066509f, 0.01748174f, -0.01218830f, 
    -0.00818456f, -0.05925756f, -0.03600666f, 0.00792851f, -0.00439266f, 0.01850731f, 0.04253717f, 0.01136461f, 
    -0.03880687f, 0.00967144f, -0.01292831f, -0.04548658f, -0.04655325f, -0.02116276f, 0.00351626f, -0.05914767f, 
    -0.03446242f, 0.03337819f, 0.01637971f, 0.01308756f, -0.03618680f, 0.03875529f, 0.00263921f, 0.03657909f, 
    0.03536276f, -0.03676035f, -0.01442115f, -0.05261703f, -0.03952553f, 0.01952652f, -0.00677860f, 0.02458421f, 
    0.01784730f, -0.03275404f, -0.04484619f, -0.00217526f, 0.00644513f, -0.02789850f, -0.05049416f, 0.02650228f, 
    0.03910243f, -0.01962017f, 0.00561723f, 0.01000607f, -0.04480249f, 0.02486271f, -0.03009873f, -0.01700083f, 
    -0.04436282f, -0.03097610f, -0.02931147f, 0.03256289f, 0.02640151f, -0.02186981f, -0.00463510f, -0.01340896f, 
    0.01216544f, 0.03316651f, 0.01546514f, 0.02615052f, -0.03315976f, 0.00630225f, 0.03151023f, 0.00868034f, 
    0.02189222f, 0.02239812f, 0.03173655f, 0.00901876f, -0.05566696f, -0.05189338f, -0.01844364f, -0.02047975f, 
    0.01313970f, -0.03580749f, -0.04981117f, 0.02169896f, 0.00436077f, 0.05037707f, -0.00781327f, 0.01335722f, 
    0.04467620f, 0.02302633f, 0.02961034f, -0.05411766f, 0.03125644f, -0.03805507f, 0.04274875f, 0.02304970f, 
    0.01923070f, -0.01278258f, -0.03763662f, -0.04803629f, -0.00398745f, 0.00674725f, -0.02122323f, -0.02670168f, 
    0.03686045f, -0.04845209f, -0.02406075f, 0.01637390f, -0.01593416f, 0.03080423f, -0.02413027f, 0.00708088f, 
    -0.02362547f, -0.00183411f, 0.02158139f, 0.02641325f, -0.04531628f, 0.00082051f, 0.02711370f, 0.00054353f, 
    -0.01372438f, -0.02503026f, -0.02895273f, -0.04067744f, 0.03212591f, -0.05151815f, -0.03640400f, 0.03574318f, 
    -0.01195749f, 0.02969962f, -0.03686877f, -0.00038057f, 0.02431673f, -0.02197828f, 0.03724877f, 0.01321392f, 
    0.01764316f, -0.00925896f, 0.03577987f, 0.00262292f, -0.04241861f, 0.00849520f, 0.02643610f, 0.03415227f, 
    -0.02272784f, 0.01193604f, -0.03686051f, -0.03298382f, -0.02831077f, 0.02114493f, 0.00230120f, -0.01626660f, 
    -0.00379715f, 0.02084146f, -0.02401507f, -0.00087066f, 0.03813245f, 0.00380572f, 0.03273751f, 0.00084760f, 
    0.00927307f, 0.00436202f, -0.04278213f, -0.01711416f, 0.00363212f, -0.04998287f, 0.03961296f, -0.04097380f, 
    0.04606776f, -0.05845845f, -0.02922829f, -0.00560622f, 0.01847932f, -0.00570734f, -0.03404181f, 0.03427807f, 
    -0.03018135f, -0.01867721f, 0.02404711f, 0.03138753f, 0.03628831f, 0.02063422f, -0.02349856f, 0.01794420f, 
    0.03880104f, -0.02436399f, 0.03262632f, 0.03369875f, -0.02521913f, -0.00631901f, 0.02067404f, 0.02121129f, 
    -0.03508680f, -0.01968191f, -0.05751295f, -0.04068936f, 0.00657131f, -0.05478417f, -0.04516875f, 0.03866432f, 
    0.02164024f, -0.05737936f, -0.02240876f, -0.01008781f, 0.01369628f, 0.03168739f, 0.02487216f, -0.05412655f, 
    -0.04203326f, -0.02396749f, -0.03084609f, 0.01187826f, 0.01360320f, 0.01759355f, 0.00164663f, -0.02827274f, 
    -0.03305933f, -0.02278164f, -0.03220294f, -0.02438265f, 0.02127383f, -0.03706846f, 0.04365256f, -0.05618670f, 
    -0.04790829f, -0.05147065f, 0.01080561f, -0.00550318f, 0.00324963f, -0.01903078f, -0.03790747f, -0.04603947f, 
    0.03936748f, -0.05773123f, 0.00446511f, 0.02491251f, -0.00624636f, 0.00918724f, 0.01781080f, 0.01126324f, 
    -0.00410887f, 0.03670829f, -0.04987951f, 0.04090070f, -0.02296923f, 0.02277934f, -0.01250472f, -0.00544569f, 
    -0.03028602f, 0.02991773f, -0.01152031f, -0.04704690f, -0.02151203f, 0.00432563f, 0.02396480f, 0.00714160f, 
    0.02119459f, 0.01003185f, -0.02222479f, -0.02656299f, 0.01859536f, 0.00933620f, -0.03839274f, 0.03121839f, 
    0.14175178f, 0.01631335f, 0.14709629f, 0.10865283f, 0.03026190f, 0.02108939f, 0.09939460f, 0.09692206f, 
    0.14534165f, 0.04733215f, 0.02807008f, 0.16209780f, 0.28239766f, 0.11085849f, -0.23740040f, -0.26980785f, 
    0.08549401f, -0.00684129f, 0.18598023f, 0.03680825f, 0.17085989f, 0.04697545f, 0.01361538f, 0.05486576f, 
    0.05362699f, 0.15732123f, 0.19157512f, 0.23070848f, 0.03680271f, 0.05890564f, 0.06509846f, 0.07266658f, 
    0.10051870f, 0.20138299f, 0.06785701f, 0.21146671f, -0.11009146f, 0.06369632f, 0.23529758f, 0.16387701f, 
    -0.02394811f, 0.14129519f, 0.07088998f, 0.16217186f, -0.02835413f, 0.08282088f, 0.05364181f, 0.06568804f, 
    -0.12077886f, 0.00124309f, -0.08969134f, -0.29172993f, -0.06086060f, 0.01591187f, -0.05301009f, -0.01330327f, 
    0.20681904f, 0.11533419f, 0.15317254f, -0.06388669f, -0.11237638f, 0.18502061f, -0.19157554f, -0.20892625f, 
    0.09598882f, 0.04457195f, -0.01465312f, 0.08888424f, 0.10558878f, 0.10546864f, 0.06828787f, 0.03212320f, 
    -0.16223863f, 0.10412253f, 0.04492836f, -0.03297490f, 0.08994805f, -0.01814465f, 0.04945452f, 0.05496258f, 
    0.06379391f, 0.02858730f, 0.13652354f, 0.13327941f, -0.24813381f, 0.35293579f, -0.07366082f, 0.06944124f, 
    0.01687260f, -0.00447318f, -0.04642357f, 0.21069166f, 0.12036927f, -0.08422609f, 0.07775008f, 0.11487743f, 
    0.16057564f, -0.13748309f, -0.18921594f, -0.14329240f, -0.14648134f, -0.02927775f, -0.14796785f, 0.07463326f, 
    0.05638644f, -0.21289042f, -0.00434106f, 0.14097805f, -0.35063082f, -0.19049628f, -0.16639276f, -0.12515081f, 
    0.11772075f, 0.08713334f, -0.12545517f, 0.07660481f, -0.00924223f, 0.13509604f, 0.01481056f, 0.08498173f, 
    -0.17967013f, 0.24424291f, 0.19012196f, 0.31464097f, 0.06142041f, 0.09611845f, 0.00374037f, 0.06243578f, 
    0.02654078f, 0.17113325f, 0.06079538f, 0.22959657f, 0.30229455f, 0.08162390f, -0.08118901f, 0.19986133f, 
    0.20154147f, 0.14751333f, 0.03094242f, 0.01958494f, 0.00111031f, 0.20998734f, -0.09804874f, -0.03220535f, 
    -0.04777547f, -0.25339249f, 0.00244619f, -0.21049094f, 0.10243702f, 0.11269718f, -0.07237893f, 0.11616995f, 
    -0.01001027f, 0.14344811f, -0.04321698f, 0.05048823f, -0.20386791f, -0.03600939f, -0.21361879f, -0.04279776f, 
    0.05795611f, -0.08474479f, -0.02163676f, 0.01243765f, 0.10962031f, 0.13052523f, 0.14968900f, 0.19287442f, 
    -0.27681562f, -0.12894677f, 0.09449320f, -0.04467682f, -0.08474704f, 0.07192557f, 0.02765385f, 0.02615245f, 
    0.12053423f, 0.15094008f, 0.07321341f, 0.01120315f, -0.74067295f, 0.12016867f, -0.00784772f, 0.08606663f, 
    0.12715109f, 0.02181682f, 0.09088156f, 0.00968175f, -0.01504383f, -0.09327738f, -0.11117260f, 0.09868696f, 
    0.05222166f, -0.01156772f, -0.01986757f, -0.16931427f, 0.12088508f, 0.08632638f, 0.00668486f, 0.15432581f, 
    0.07673615f, 0.07048550f, -0.00563474f, 0.12175222f, 0.46016443f, 0.12124350f, 0.00952006f, 0.10804059f, 
    -0.01870135f, 0.10397550f, 0.08055369f, 0.00306255f, -0.05103584f, -0.14735678f, -0.05401950f, 0.06637441f, 
    -0.19672047f, 0.11233243f, -0.16691263f, 0.20114967f, 0.10092790f, -0.08169176f, 0.03902075f, -0.10501524f, 
    -0.00060303f, -0.04928276f, -0.07173733f, -0.02343663f, 0.17040172f, -0.06054885f, -0.36951676f, -0.34079620f, 
    -0.06328974f, -0.17236038f, 0.10040904f, -0.04406617f, 0.04352577f, -0.06759905f, -0.05943299f, -0.00823380f, 
    -0.03790283f, 0.05203420f, 0.01906459f, -0.14996435f, -0.12232359f, 0.09775472f, -0.04485283f, 0.02963205f, 
    0.09366042f, -0.19890527f, -0.06579227f, 0.04655401f, 0.10805021f, -0.12378374f, 0.03549767f, -0.11736905f, 
    0.15685682f, -0.14229245f, 0.16836435f, 0.01232013f, -0.12201121f, 0.10141181f, 0.12503217f, -0.09436909f, 
    0.40931731f, 0.10074851f, -0.13912781f, 0.05840387f, -0.05271086f, -0.03296713f, 0.05759702f, 0.02505020f, 
    0.06947383f, -0.02271467f, 0.03574364f, 0.09801296f, 0.14194167f, -0.14399195f, -0.11358306f, -0.15229882f, 
    -0.08437673f, -0.12019980f, 0.00487188f, -0.05686072f, 0.12125117f, 0.03907503f, 0.05270578f, 0.28693694f, 
    0.01908207f, 0.14062832f, -0.10821088f, -0.30407640f, -0.12305174f, 0.05068238f, -0.04857351f, 0.10187320f, 
    0.03879511f, -0.04865367f, -0.05233549f, -0.03172136f, -0.16058941f, 0.30087405f, -0.00038575f, 0.13029678f, 
    0.09273621f, 0.03575182f, 0.06905723f, -0.01270587f, -0.07538688f, 0.24586278f, 0.03815498f, 0.11383661f, 
    0.01260662f, -0.20801042f, -0.01107242f, -0.11879244f, 0.20947719f, 0.02051717f, 0.00559904f, 0.16217749f, 
    0.00775651f, 0.00928056f, 0.05422578f, 0.16050740f, 0.04029609f, -0.14081411f, -0.00495789f, -0.12913135f, 
    0.17632049f, 0.02018655f, 0.07452591f, 0.14164940f, 0.11930969f, 0.09381484f, -0.01487629f, 0.08675323f, 
    0.18420123f, -0.16084583f, -0.07986266f, -0.00501193f, 0.05548168f, 0.09046368f, 0.08040654f, -0.00109207f, 
    -0.07984489f, 0.14591558f, 0.03140594f, 0.10420990f, 0.57264596f, 0.03255761f, 0.09076405f, 0.22769941f, 
    0.15899618f, 0.03863885f, 0.04468804f, 0.07321729f, 0.11249173f, 0.07286911f, 0.04785378f, 0.20328316f, 
    0.26333970f, -0.17328551f, -0.17908449f, -0.06308053f, 0.00804689f, 0.04822555f, 0.07054663f, -0.05881835f, 
    0.02486278f, 0.17779535f, 0.01836638f, -0.01842106f, 0.18564636f, -0.03105019f, -0.21694705f, 0.04117713f, 
    0.01495211f, 0.11324453f, -0.00217829f, -0.10121752f, 0.15329652f, 0.03777907f, 0.01990370f, -0.00928539f, 
    -0.21856639f, -0.16336563f, 0.19451712f, -0.06651660f, 0.00155440f, 0.12147392f, -0.03363736f, 0.04733446f, 
    -0.02763611f, -0.04437775f, 0.05206614f, 0.03925920f, -0.16552366f, 0.29548073f, -0.04910179f, 0.13718186f, 
    0.13478267f, 0.00343221f, 0.10625479f, 0.03075417f, 0.07833750f, 0.11971667f, 0.12332585f, -0.12582779f, 
    -0.09269333f, 0.10877968f, 0.20336224f, 0.01826887f, -0.08011756f, 0.07219315f, -0.03324993f, 0.20361422f, 
    0.05889994f, 0.17512582f, 0.08891967f, -0.01811491f, -0.11969370f, 0.25496399f, 0.07798983f, -0.07757743f, 
    0.15201327f, -0.05502191f, -0.03657686f, 0.06869956f, 0.05037857f, 0.06001340f, 0.05944079f, -0.00779599f, 
    0.10411850f, -0.15096644f, 0.00419328f, -0.04071878f, 0.06438775f, 0.17898263f, -0.04542078f, 0.00188759f, 
    0.10815299f, 0.01847045f, 0.02924478f, -0.01668029f, -0.07549684f, 0.03712440f, 0.09136512f, 0.21104318f, 
    0.09087521f, -0.00296017f, -0.02543804f, 0.21781389f, 0.22233786f, 0.12028677f, -0.14892834f, -0.17280012f, 
    -0.08221378f, 0.01538401f, -0.29695180f, -0.15834734f, -0.01282029f, -0.13414459f, -0.13686554f, -0.00032432f, 
    -0.04161218f, -0.01019484f, 0.00059531f, 0.00121460f, 0.24281016f, -0.25477377f, -0.09936184f, 0.13082254f, 
    -0.09397516f, -0.10935188f, 0.02695601f, -0.01483854f, 0.17643191f, 0.04560928f, 0.07013527f, -0.09291265f, 
    0.24534400f, -0.04890063f, 0.08416974f, 0.17987232f, 0.11440331f, 0.03919113f, -0.00427480f, 0.16626963f, 
    0.00459654f, 0.01046101f, 0.09138757f, -0.05567427f, -0.21209829f, 0.16370784f, 0.17762274f, 0.12308229f, 
    -0.06842840f, 0.00861443f, 0.11041401f, -0.06462473f, -0.01678246f, -0.03865269f, 0.04606627f, 0.00600330f, 
    0.06815007f, 0.12017609f, 0.15394287f, 0.05991228f, 0.05523932f, -0.05158137f, -0.10325102f, 0.27510893f, 
    0.08282616f, -0.01759550f, -0.08571840f, 0.05570799f, 0.05411736f, -0.13945860f, 0.14208113f, 0.15953884f, 
    0.04873032f, -0.02606886f, -0.00643341f, 0.07544008f, 0.07306057f, 0.11396292f, 0.10644243f, -0.10319879f, 
    -0.10848869f, 0.22419079f, 0.09709845f, -0.16852920f, 0.14252126f, 0.15530628f, 0.05360127f, -0.08681038f, 
    0.02255393f, 0.09776363f, 0.16354463f, -0.00245044f, -0.13288869f, 0.06731367f, -0.13902897f, -0.06088420f, 
    0.03827404f, -0.06430471f, -0.01680853f, 0.07359389f, -0.03448788f, 0.08092725f, -0.03652837f, 0.11368365f, 
    0.34696928f, -0.44807634f, 0.22350231f, 0.04877067f, -0.00579424f, 0.00458284f, -0.07656101f, -0.10505436f, 
    -0.04054359f, 0.08879372f, -0.03743832f, 0.06909475f, -0.09823310f, 0.08038832f, -0.13981666f, -0.22648802f, 
    0.16089574f, -0.07432107f, 0.01677193f, 0.04673381f, -0.07390725f, -0.03435709f, 0.03719978f, 0.06938915f, 
    0.01573086f, -0.05698524f, 0.01050219f, -0.06413605f, 0.22275296f, 0.02241239f, 0.08013497f, 0.18453717f, 
    0.08428019f, 0.09659184f, 0.00609542f, 0.02216766f, -0.14567253f, 0.19663438f, 0.15206125f, 0.09049287f, 
    -0.02108985f, 0.03561484f, 0.09247237f, 0.05396422f, -0.23277326f, -0.05604313f, -0.03354940f, -0.01601897f, 
    0.11643463f, -0.15757436f, 0.00340455f, 0.21459591f, 0.04583307f, -0.09632841f, 0.05882227f, -0.07818926f, 
    0.05947583f, 0.02056126f, 0.08527011f, -0.16956970f, 0.15296033f, -0.02365810f, -0.08961301f, 0.16385710f, 
    0.15430655f, 0.04727418f, -0.06791079f, 0.07794028f, -0.00499242f, 0.00749829f, -0.05219592f, 0.07208099f, 
    0.33584356f, -0.21674994f, 0.19206911f, -0.06953735f, 0.08769067f, -0.06181423f, 0.19946414f, -0.06138027f, 
    0.06423710f, 0.01088828f, 0.03255868f, 0.05471521f, 0.06875523f, -0.03096318f, 0.04047166f, 0.31053668f, 
    -0.08333836f, 0.02472568f, 0.10134387f, 0.12317092f, -0.07589534f, 0.10800607f, -0.05036111f, -0.05217621f, 
    -0.09628066f, 0.20023675f, -0.09188521f, -0.41577190f, 0.16673514f, -0.11481556f, 0.02789303f, -0.04293996f, 
    -0.16284558f, -0.01392599f, -0.01451130f, -0.05969638f, -0.21975005f, 0.22073996f, -0.20040376f, -0.51794297f, 
    0.15358108f, 0.08048465f, -0.00707852f, -0.01226739f, -0.10723740f, -0.01358831f, 0.02224977f, 0.01319187f, 
    -0.00618661f, 0.28956965f, 0.12027074f, 0.16786502f, 0.27866161f, -0.04605814f, 0.15380800f, 0.14521419f, 
    0.00893799f, 0.07071769f, 0.09646711f, 0.05616256f, -0.02847569f, 0.02053429f, -0.03012572f, -0.11701529f, 
    -0.10828397f, 0.15921293f, -0.07938674f, 0.00184714f, -0.06711297f, -0.07583739f, 0.05165093f, -0.00048595f, 
    -0.23156074f, 0.09668714f, 0.15862405f, 0.17226979f, -0.04397770f, 0.10356805f, -0.02513702f, -0.00221440f, 
    -0.07331213f, -0.03195537f, -0.03174772f, 0.08836126f, -0.03112851f, 0.12840214f, 0.37823331f, -0.04948447f, 
    0.12152993f, 0.08117685f, 0.01941320f, 0.08234204f, 0.13754882f, 0.06972917f, 0.03354148f, -0.09118879f, 
    0.36887053f, 0.18179840f, -0.01049819f, 0.25633121f, 0.02700665f, 0.11137823f, -0.03450214f, 0.18863747f, 
    -0.04005750f, 0.03942699f, 0.16125645f, -0.07516491f, -0.09943739f, -0.11166579f, -0.01441096f, -0.05329192f, 
    -0.09467196f, -0.03089142f, -0.08982946f, -0.10686252f, 0.03886053f, 0.00020285f, -0.04969397f, 0.08612756f, 
    -0.16742206f, 0.18520536f, 0.01150263f, 0.21640049f, 0.17891927f, -0.04462267f, -0.02436997f, 0.01377775f, 
    0.02034579f, -0.08708762f, -0.15476622f, 0.02385033f, 0.24959892f, 0.13979775f, 0.00398826f, -0.00282746f, 
    -0.03260285f, 0.10102436f, -0.04122752f, -0.12354744f, -0.01550177f, -0.06042059f, 0.15206966f, -0.00678823f, 
    -0.01451871f, 0.00627506f, 0.00862068f, 0.04428000f, 0.03250995f, -0.00064563f, 0.01204932f, 0.03696812f, 
    -0.03566358f, -0.05396057f, -0.04458712f, 0.00902115f, -0.01085842f, 0.01180097f, 0.03267462f, 0.00824046f, 
    0.03131130f, -0.01895770f, -0.02611183f, -0.01933756f, 0.03302195f, -0.01084942f, 0.01781619f, -0.00236751f, 
    -0.03420210f, 0.04401914f, 0.04150148f, 0.01402065f, -0.05000605f, 0.00926527f, -0.04914980f, 0.03874120f, 
    -0.04264633f, -0.01560270f, 0.03921109f, -0.02049141f, -0.03812577f, 0.03252020f, 0.00054167f, -0.05331174f, 
    -0.01348951f, -0.03554620f, -0.01856896f, 0.03661643f, 0.00932644f, 0.00551612f, -0.02375103f, -0.02040856f, 
    -0.02858939f, 0.00394377f, -0.00741847f, 0.04352642f, -0.03276101f, -0.04648666f, 0.01206811f, 0.02353530f, 
    -0.04439416f, 0.03060735f, 0.01544790f, -0.01248018f, -0.00762538f, 0.01588373f, -0.02805506f, -0.00391125f, 
    0.02243565f, -0.02887925f, -0.02011483f, -0.01752343f, 0.04282492f, -0.00016011f, -0.02382177f, -0.02675164f, 
    -0.04044391f, -0.00733228f, 0.02386137f, 0.01930717f, 0.00622851f, -0.00979898f, 0.04057124f, -0.01883087f, 
    0.03106009f, -0.05434766f, 0.01788643f, -0.00369902f, -0.05409393f, -0.01608406f, 0.01099302f, 0.02171395f, 
    0.00855472f, 0.03061638f, -0.04331547f, -0.04617134f, 0.02344244f, -0.01118521f, -0.05173054f, 0.02429449f, 
    -0.03384590f, 0.01229619f, -0.03978362f, 0.00437182f, 0.03877610f, 0.00766512f, -0.01857261f, 0.00504298f, 
    0.00830366f, -0.04074417f, 0.04072759f, -0.01569466f, -0.02005688f, 0.04569748f, 0.03938935f, -0.02111692f, 
    -0.03253764f, -0.02822449f, -0.02424355f, -0.05217730f, -0.02248708f, 0.00380487f, -0.04132347f, -0.05308070f, 
    -0.03862940f, 0.03939403f, 0.04171858f, -0.01950908f, 0.04195418f, 0.02901906f, 0.02428099f, -0.05079947f, 
    0.03830146f, -0.03346160f, -0.03861317f, 0.02206249f, 0.00489615f, -0.04665465f, 0.03786508f, 0.00847771f, 
    -0.02403994f, 0.01887422f, -0.01147650f, -0.03316270f, -0.02696890f, -0.01077257f, -0.01955825f, -0.01359316f, 
    0.01906034f, 0.05041404f, -0.00142329f, -0.04226102f, -0.04684662f, 0.01779893f, -0.01647070f, -0.04937962f, 
    -0.01100602f, -0.03967901f, -0.03026448f, 0.04000267f, -0.03942635f, -0.01808142f, -0.02514138f, 0.01202410f, 
    0.04393814f, -0.04505711f, -0.04868711f, -0.00970482f, -0.05036264f, -0.03712396f, 0.00230465f, -0.05257480f, 
    -0.00278998f, 0.03271117f, 0.00062492f, -0.00914373f, 0.04093640f, -0.01198264f, -0.02195270f, -0.02765810f, 
    0.04587293f, -0.03523971f, -0.02011527f, 0.03926388f, 0.04052890f, 0.00702218f, 0.03093659f, 0.02146635f, 
    -0.02740304f, -0.00405604f, 0.03640111f, -0.03907652f, -0.03774119f, 0.03368348f, -0.04161894f, 0.03450357f, 
    -0.02215553f, 0.04629143f, -0.04210136f, 0.00929015f, 0.00108588f, 0.00685334f, 0.03468148f, 0.01729093f, 
    -0.01596144f, 0.01285832f, -0.02050995f, 0.03915342f, -0.03231157f, -0.01458838f, -0.00725859f, -0.03996849f, 
    -0.04082747f, 0.00109116f, -0.05121851f, 0.04615473f, 0.01876663f, 0.00146455f, -0.01356242f, -0.04367808f, 
    -0.03799139f, 0.02673266f, 0.03119632f, -0.05106711f, 0.02144874f, 0.02573433f, -0.05220474f, -0.02020948f, 
    0.03134587f, -0.01072534f, -0.00982813f, -0.01193112f, -0.01183268f, 0.02923372f, 0.01868486f, 0.04116969f, 
    0.03296556f, 0.00134262f, 0.03676732f, 0.01067476f, -0.03397711f, -0.04275824f, 0.00419822f, -0.04006447f, 
    -0.03851981f, -0.04928061f, -0.01703582f, -0.01539952f, -0.05011251f, -0.01464016f, -0.03332090f, 0.03106261f, 
    -0.04163038f, -0.01010141f, -0.04581295f, -0.00051823f, -0.03276922f, 0.00501209f, -0.00844758f, 0.02571944f, 
    -0.04053745f, -0.01877682f, 0.01610886f, 0.00450423f, -0.01152908f, 0.02916665f, -0.03594219f, 0.04315554f, 
    0.01424370f, 0.00890193f, 0.02904019f, -0.03551742f, -0.04377043f, -0.03155534f, 0.03010465f, 0.01018715f, 
    0.02382511f, -0.02329500f, -0.04460613f, -0.01727893f, 0.03187469f, 0.02605605f, 0.04128887f, -0.02928364f, 
    -0.01990995f, 0.02709632f, -0.04350102f, 0.01365554f, 0.02259443f, 0.03999464f, -0.04946258f, -0.04444484f, 
    -0.04949277f, -0.04072588f, -0.03640910f, -0.03842398f, -0.04836303f, 0.02377261f, -0.00547812f, -0.04065534f, 
    0.03778854f, 0.03653071f, -0.04239924f, 0.03574677f, -0.01473238f, -0.00343889f, 0.01739769f, -0.03060915f, 
    0.03609639f, -0.03022726f, -0.05012659f, 0.03983922f, 0.03840732f, 0.03505955f, -0.02565103f, 0.00672051f, 
    0.03552791f, -0.00233148f, 0.01143652f, 0.03862144f, -0.00995823f, -0.04572144f, -0.00616024f, 0.03559716f, 
    -0.05324110f, 0.04912327f, -0.00157726f, 0.00245313f, -0.01349678f, 0.04376464f, -0.01295094f, 0.04806235f, 
    -0.03614764f, -0.04898158f, -0.00498307f, 0.03217831f, -0.04550119f, -0.02719907f, 0.03668111f, -0.04291552f, 
    0.00733520f, -0.00822600f, -0.02475158f, -0.03598082f, 0.03270784f, -0.04744428f, -0.00649235f, 0.04105742f, 
    -0.00660935f, 0.04968687f, -0.05003111f, 0.00245990f, -0.04420764f, -0.01961647f, -0.00711404f, -0.03326755f, 
    0.03725521f, -0.01955715f, -0.05470846f, -0.04101223f, -0.03899555f, 0.02244291f, -0.03003637f, 0.02100708f, 
    -0.04012406f, -0.00445774f, -0.00608403f, 0.03165188f, 0.04087526f, 0.03637709f, -0.05069596f, 0.04851760f, 
    -0.05288594f, 0.00448699f, -0.01851777f, -0.03970068f, -0.05384554f, -0.04021319f, 0.04026679f, -0.00367115f, 
    -0.00139716f, 0.03524571f, -0.01898376f, -0.01127639f, 0.01498783f, -0.05539456f, -0.01680650f, -0.05048781f, 
    -0.01883352f, -0.03989546f, 0.03842572f, 0.03482907f, -0.05730394f, 0.03205273f, -0.02096258f, 0.01484175f, 
    -0.00265511f, 0.00286769f, 0.04884769f, 0.01561303f, -0.02193132f, 0.04154810f, -0.01557125f, -0.05064329f, 
    -0.00192873f, 0.03850418f, -0.00021900f, -0.03087541f, -0.00089989f, -0.05619659f, -0.02044944f, 0.02661319f, 
    0.00689799f, -0.02976370f, -0.00702371f, 0.01524818f, -0.03384643f, -0.00393217f, 0.00531629f, -0.00228578f, 
    -0.03711670f, 0.03601194f, 0.01351403f, 0.02725232f, 0.02923396f, 0.00693132f, -0.04224011f, -0.03993144f, 
    -0.05292832f, 0.04358802f, -0.01294148f, 0.00739172f, -0.02154783f, -0.00164116f, 0.03795087f, -0.02036778f, 
    -0.02851716f, -0.05530843f, 0.03712869f, -0.03628227f, -0.02937616f, 0.02092635f, 0.03110548f, 0.00725558f, 
    0.05370658f, 0.02326914f, -0.04425479f, -0.01038118f, 0.00466948f, -0.01349749f, -0.00333190f, -0.02383827f, 
    0.00491976f, -0.01063924f, -0.05042398f, 0.03050014f, 0.03022758f, -0.02308637f, 0.01054228f, 0.03873085f, 
    0.00061579f, 0.04647845f, -0.00897769f, -0.03971181f, 0.02311987f, 0.00965938f, 0.01572134f, 0.03831898f, 
    -0.03251156f, -0.02720788f, -0.03694428f, 0.01267579f, -0.04376335f, -0.01506234f, 0.04129458f, -0.02569782f, 
    -0.02952398f, 0.00607528f, -0.02737960f, -0.05958692f, 0.02780048f, -0.02799421f, -0.01248990f, -0.00445409f, 
    -0.01321998f, -0.05507649f, -0.05467144f, -0.03406217f, -0.01422305f, -0.03127120f, -0.01552124f, -0.04872037f, 
    0.01992276f, -0.02480398f, 0.01201143f, -0.04584645f, 0.03562732f, -0.06039897f, 0.00772993f, -0.04609246f, 
    0.03048849f, -0.00205494f, -0.03699036f, -0.02330124f, 0.01651531f, 0.01656139f, -0.04705596f, 0.02218201f, 
    -0.01132836f, 0.00371537f, -0.01845298f, 0.03184546f, 0.02900160f, -0.00201287f, 0.02377060f, 0.03336244f, 
    -0.01548536f, 0.03721349f, -0.00610820f, -0.04990473f, 0.01209222f, -0.03548192f, -0.05681731f, -0.00809981f, 
    0.01516800f, -0.02379567f, 0.04081025f, -0.01872507f, -0.00861035f, 0.03812692f, 0.04048655f, -0.01120576f, 
    -0.02545937f, -0.00571129f, -0.01256731f, 0.00878014f, -0.05347846f, 0.01430897f, -0.01010058f, -0.00670804f, 
    -0.03246868f, -0.03081797f, -0.02569606f, 0.00904902f, -0.01846177f, -0.04034484f, -0.01754844f, -0.03020658f, 
    0.03166884f, -0.00846421f, 0.02890312f, -0.04962834f, -0.03848738f, 0.02262438f, -0.02297630f, -0.03384954f, 
    -0.05540835f, -0.00810172f, -0.00235625f, -0.06527199f, 0.04330532f, 0.05363103f, -0.05504803f, 0.03550543f, 
    -0.00572744f, -0.03897721f, 0.00757316f, -0.00603248f, 0.03195572f, 0.03948898f, 0.00828858f, 0.00497125f, 
    0.03161228f, -0.01686980f, 0.01290367f, -0.02408604f, -0.04379721f, 0.02956440f, -0.01736837f, 0.04650769f, 
    -0.00214182f, -0.04543957f, -0.01506937f, 0.01858343f, -0.03440166f, 0.03923574f, 0.00086293f, 0.02905682f, 
    0.01196680f, 0.04274620f, -0.05320692f, 0.03626671f, 0.03880220f, -0.00083931f, -0.04701949f, -0.01323954f, 
    -0.02367355f, 0.01071942f, 0.00608002f, 0.01869916f, -0.04307704f, -0.01730065f, -0.04025110f, 0.01783833f, 
    0.00740241f, 0.01264422f, 0.01258012f, 0.01595894f, -0.04956251f, -0.02379145f, -0.00326934f, 0.01412677f, 
    -0.04046858f, -0.04783135f, -0.00476325f, -0.04572290f, -0.00624129f, 0.01441524f, -0.01375505f, 0.04146459f, 
    -0.02756818f, -0.03311620f, 0.00782395f, -0.03387119f, -0.03796679f, -0.04102531f, 0.03731576f, -0.01857937f, 
    -0.05396224f, -0.00483709f, -0.04624286f, -0.03723764f, -0.02619188f, -0.02375571f, -0.03279050f, -0.05429430f, 
    0.01367429f, 0.00298750f, -0.03778129f, -0.03308000f, 0.04115855f, 0.03050840f, -0.01724234f, 0.04804583f, 
    0.01266154f, -0.05148532f, 0.04489518f, -0.06202197f, 0.00740572f, 0.00766736f, 0.04204419f, -0.02435472f, 
    -0.05171015f, -0.02558852f, 0.02586917f, 0.03146347f, 0.04447483f, 0.02100891f, 0.03382846f, -0.00170943f, 
    -0.05079354f, -0.03254623f, -0.02368867f, -0.05689454f, -0.04764767f, -0.04985231f, -0.03449149f, -0.06303534f, 
    -0.00579000f, -0.04556694f, 0.00042675f, 0.02542903f, 0.02169577f, -0.01160997f, -0.05473633f, 0.02883011f, 
    0.01103265f, -0.02371936f, -0.02559210f, -0.03561251f, -0.00798712f, -0.00072765f, 0.00989825f, 0.04144946f, 
    0.02854084f, -0.01971254f, -0.03036165f, 0.01803501f, 0.03827266f, -0.04848668f, 0.01632489f, -0.01152207f, 
    -0.04832218f, -0.03251379f, -0.04626920f, 0.01802716f, -0.05203272f, 0.00680938f, 0.02533059f, -0.03479530f, 
    0.01311503f, -0.04995303f, -0.01786185f, -0.00092371f, 0.02719212f, 0.03498691f, -0.01631521f, -0.05822401f, 
    0.02660781f, 0.00409883f, 0.01928530f, -0.05992939f, -0.05931547f, -0.01574730f, 0.01479439f, 0.04476348f, 
    0.04423268f, -0.00776972f, -0.03058380f, -0.01399561f, 0.03420368f, -0.03343875f, 0.01561646f, -0.04038944f, 
    0.00363744f, -0.01131051f, -0.00876262f, -0.05217526f, -0.04713755f, -0.04084451f, -0.00016889f, 0.03005660f, 
    -0.06094387f, 0.04671260f, 0.03999332f, 0.00101557f, -0.01709922f, -0.01130919f, -0.07005917f, 0.03772475f, 
    0.03655035f, -0.03411018f, -0.02543902f, 0.00643321f, -0.01105691f, 0.01972502f, -0.00125838f, -0.01654248f, 
    -0.00153149f, -0.01890899f, -0.04757565f, -0.00369453f, 0.02620853f, -0.00550976f, -0.02363911f, -0.01922189f, 
    -0.01691749f, -0.02619451f, -0.01025932f, 0.02774054f, -0.04368241f, -0.03631236f, -0.02136876f, 0.02762710f, 
    -0.01397675f, -0.02582848f, -0.04947678f, -0.04670212f, 0.04768234f, 0.00489505f, -0.00153866f, 0.05194626f, 
    0.15113133f, 0.04395562f, 0.16056131f, 0.24698588f, -0.04705751f, -0.00731871f, 0.11584259f, -0.01047457f, 
    -0.00695349f, 0.14002240f, 0.11682098f, 0.05320944f, 0.03815525f, 0.05319853f, -0.15708163f, -0.07361340f, 
    -0.08709090f, 0.02460301f, 0.01068203f, -0.19506098f, 0.05717198f, -0.16962431f, 0.01282058f, 0.04526865f, 
    -0.17237984f, 0.03759347f, 0.11008935f, 0.00773792f, 0.14088060f, 0.06962230f, 0.14985310f, -0.16222496f, 
    0.07960020f, 0.00663849f, -0.02555620f, 0.20645535f, -0.13124780f, 0.04924941f, 0.16070318f, -0.02357639f, 
    -0.07184937f, 0.02450194f, 0.06865335f, 0.19325036f, -0.13533443f, 0.03573235f, 0.00231667f, 0.12003973f, 
    0.04175003f, 0.13512161f, 0.00459023f, -0.35238445f, -0.01231844f, 0.02361664f, -0.04128142f, 0.06313743f, 
    -0.09420300f, 0.01370618f, -0.00753909f, -0.05859415f, -0.16759980f, 0.02659932f, -0.17262779f, -0.12885351f, 
    0.03038702f, 0.07918017f, 0.17892392f, -0.14674564f, -0.04412343f, -0.01613592f, 0.08761913f, 0.15133737f, 
    -0.11540695f, -0.12141610f, 0.49486950f, 0.16677254f, 0.00599752f, 0.02224846f, 0.17479448f, -0.01747382f, 
    -0.00728177f, 0.03455767f, 0.06102493f, 0.07404249f, -0.04645689f, 0.00315992f, 0.00224784f, 0.10217405f, 
    0.09702692f, -0.07179217f, 0.08802050f, 0.16504392f, 0.07911198f, 0.06145200f, -0.00851883f, 0.21280104f, 
    0.34348834f, 0.20761205f, -0.15791161f, 0.32937905f, -0.02407522f, -0.10048274f, 0.00053638f, -0.02202592f, 
    0.05837459f, 0.01533424f, -0.03743735f, -0.00712423f, 0.08161942f, 0.22500879f, 0.05659050f, 0.07808084f, 
    -0.03192914f, -0.07611955f, -0.13304465f, 0.06194931f, -0.03811634f, 0.16619506f, -0.03799489f, 0.10269275f, 
    0.00148575f, 0.11957102f, 0.22847801f, 0.09164083f, 0.09623314f, 0.10480188f, 0.03819424f, -0.04998770f, 
    -0.02118378f, 0.09626492f, 0.01786890f, -0.01150783f, 0.00736880f, 0.04550398f, -0.34784582f, 0.03625961f, 
    0.05255361f, 0.04845862f, -0.06533139f, 0.03442235f, -0.09266844f, 0.04761614f, -0.07716795f, 0.06084104f, 
    -0.11477672f, -0.43486980f, -0.11474712f, -0.00095223f, 0.00337984f, -0.06676181f, -0.12034518f, 0.16583385f, 
    -0.06524872f, -0.11627408f, -0.17907405f, -0.03969092f, 0.00575833f, -0.00244497f, 0.09697828f, -0.04994743f, 
    -0.20166455f, -0.00003993f, -0.07140901f, -0.00341587f, -0.00815146f, 0.12621658f, 0.01011230f, -0.05101505f, 
    -0.37169093f, 0.26528749f, 0.07296968f, 0.32604355f, -0.01025080f, -0.09499829f, 0.00911432f, -0.00663931f, 
    0.09061587f, -0.05787562f, -0.01829173f, -0.13133284f, -0.28049085f, 0.12155586f, 0.12558083f, -0.17605250f, 
    0.02602326f, 0.08458199f, 0.11146240f, 0.07051153f, 0.00138552f, -0.00733785f, -0.00894313f, -0.00204336f, 
    -0.11095853f, 0.25764292f, -0.06872869f, -0.02744451f, 0.02815170f, -0.01501961f, 0.12490568f, 0.12131383f, 
    0.06894811f, -0.10666209f, -0.10669283f, -0.07224620f, 0.45942071f, 0.37333429f, -0.06117672f, 0.34814224f, 
    0.13402787f, -0.13340105f, 0.04494584f, 0.00746472f, 0.01786867f, -0.02880858f, 0.09752363f, 0.05885309f, 
    -0.00560437f, 0.23825437f, 0.09029908f, -0.01159649f, 0.20111208f, -0.03788768f, 0.02142525f, -0.06066586f, 
    0.00428709f, -0.09213995f, -0.05426576f, 0.16326725f, 0.16721231f, 0.09075334f, -0.20995037f, 0.31761298f, 
    0.00059718f, 0.04926430f, 0.11322117f, 0.04246737f, -0.01496009f, 0.02620024f, -0.04742752f, -0.02573310f, 
    -0.52183312f, 0.28454858f, -0.07120541f, 0.13928358f, -0.06105182f, 0.00618295f, -0.02237839f, 0.04388481f, 
    0.04694778f, -0.14248578f, 0.02827077f, -0.02629184f, -0.11152533f, -0.17488307f, -0.10690997f, 0.01302665f, 
    0.03003297f, 0.01770178f, 0.12610604f, -0.23789309f, 0.09060977f, 0.01936269f, 0.01799699f, 0.06997966f, 
    0.06022672f, 0.00029460f, 0.22129023f, 0.26705912f, -0.08126330f, 0.02223064f, 0.08030089f, 0.08854324f, 
    0.12375603f, 0.01825669f, 0.16915599f, 0.20830490f, 0.11564116f, -0.22089246f, 0.13333452f, 0.06128760f, 
    -0.05093073f, -0.07883317f, 0.03358551f, 0.00763194f, 0.16398606f, -0.01790545f, 0.00009727f, 0.00124774f, 
    -0.28970417f, 0.15874672f, 0.06611050f, 0.01811406f, -0.09565842f, 0.04533723f, 0.00882420f, -0.02457030f, 
    -0.07086942f, 0.05490076f, 0.03164942f, -0.03671182f, -0.02891789f, -0.00092060f, 0.01986497f, 0.19649608f, 
    0.12191746f, -0.10524935f, 0.07402512f, 0.12315752f, -0.03501123f, 0.03559878f, -0.06812350f, 0.10809328f, 
    0.15107325f, -0.13787833f, -0.10031499f, -0.14772598f, 0.07028607f, -0.10821807f, -0.05023402f, -0.02510246f, 
    0.10190417f, -0.02190323f, -0.01189700f, -0.11865663f, -0.28796911f, -0.17555562f, -0.21506968f, -0.02499437f, 
    -0.09707378f, -0.02401461f, 0.05110007f, -0.13520588f, -0.03230290f, -0.04129314f, 0.03413067f, 0.03185205f, 
    0.23780425f, 0.03933062f, -0.09616475f, 0.03566194f, 0.12995417f, 0.13997459f, 0.04409752f, -0.01880127f, 
    -0.05123039f, -0.04932242f, -0.04647861f, 0.03403014f, 0.29224759f, -0.02250035f, -0.11095387f, 0.41657236f, 
    -0.02392219f, -0.13834400f, -0.01093913f, 0.04581490f, -0.07122629f, 0.15515599f, -0.03544778f, 0.06584985f, 
    0.29518625f, -0.10568795f, -0.14769498f, 0.03799262f, -0.07783248f, 0.11980358f, 0.03327310f, 0.02449465f, 
    -0.07536518f, 0.03170931f, 0.17654364f, -0.04728212f, 0.12056784f, -0.09623348f, 0.06809596f, -0.19427507f, 
    -0.01343897f, 0.03830534f, 0.00540590f, 0.01650626f, 0.10907179f, 0.01671970f, 0.02470116f, -0.03493658f, 
    0.07139882f, -0.24247538f, 0.13784187f, -0.12471678f, 0.01730577f, 0.16390976f, -0.02592229f, 0.04991919f, 
    0.06902305f, -0.00394512f, 0.13702130f, 0.19689943f, -0.03857812f, 0.14337094f, -0.03052629f, 0.24231242f, 
    0.02662413f, -0.09146681f, 0.07093760f, -0.08885233f, 0.05135482f, 0.12011465f, 0.04247420f, -0.04150515f, 
    0.01775789f, 0.26272476f, 0.20975618f, 0.09220400f, -0.04231309f, 0.08516844f, 0.03798431f, 0.18807842f, 
    -0.08056507f, 0.06080286f, 0.10273820f, 0.01082370f, 0.07035086f, 0.31826803f, -0.12326369f, 0.09054980f, 
    0.13103466f, -0.09643406f, -0.04287044f, -0.00706105f, -0.10699379f, -0.04728429f, 0.02557895f, -0.01990398f, 
    -0.15124002f, -0.11879161f, -0.06016202f, 0.03949269f, 0.14778307f, 0.05373527f, 0.01299977f, 0.12448643f, 
    0.12835963f, 0.00811517f, 0.13542020f, -0.01868152f, -0.03875447f, -0.02893429f, -0.00277677f, 0.35885364f, 
    0.13728295f, -0.09482349f, 0.10529872f, 0.13215981f, 0.06279315f, -0.04919688f, 0.11857118f, -0.03577391f, 
    -0.45137495f, -0.11551995f, 0.09585787f, 0.06043089f, 0.16404396f, 0.05790310f, -0.10884199f, -0.05050106f, 
    0.09533837f, 0.01101051f, -0.03849490f, -0.07883708f, -0.26028863f, 0.17377204f, 0.03898012f, 0.19801883f, 
    -0.06102115f, -0.15477125f, 0.04270066f, 0.06672848f, 0.05762152f, 0.06227384f, -0.01622025f, -0.00419090f, 
    0.01908695f, 0.09751020f, -0.06681883f, 0.23742755f, -0.09231161f, 0.01619804f, -0.04936537f, 0.17602606f, 
    0.07578182f, -0.01387525f, 0.03976088f, 0.12329166f, -0.15653835f, 0.08661313f, 0.10920686f, 0.02083129f, 
    -0.02093185f, 0.17796187f, -0.04834165f, 0.01926652f, 0.02550810f, 0.11702737f, 0.00834686f, 0.04786433f, 
    -0.04050223f, 0.04182671f, 0.18629561f, 0.00405188f, 0.04178442f, 0.02418721f, -0.06046686f, 0.03403401f, 
    0.01489420f, -0.05117110f, -0.12178964f, 0.20547026f, 0.19038537f, 0.07252060f, -0.18638965f, 0.25603974f, 
    0.19211856f, -0.02321685f, -0.09599418f, 0.09739776f, -0.03304696f, 0.16959131f, 0.02694583f, -0.10399779f, 
    -0.07846704f, 0.00428780f, 0.11726341f, -0.09343344f, 0.21044196f, 0.26581627f, 0.05722490f, -0.07836559f, 
    0.00855105f, 0.07634283f, 0.03001967f, 0.03478004f, -0.41047642f, 0.00762227f, -0.23161495f, -0.14942625f, 
    0.04024275f, 0.04237803f, -0.03849214f, 0.07862534f, 0.10154498f, 0.04264743f, 0.05610224f, 0.07796166f, 
    -0.00028630f, -0.18527469f, -0.01552244f, 0.08246067f, 0.09949355f, 0.07791375f, -0.01255692f, 0.02503268f, 
    -0.00291452f, 0.14429238f, 0.02140430f, 0.03737069f, -0.77135926f, 0.12466550f, -0.03464398f, -0.03059229f, 
    0.10657319f, -0.13723168f, 0.09681123f, -0.02220878f, -0.11920891f, 0.06605463f, -0.02035380f, 0.10724334f, 
    -0.21315467f, -0.02153195f, -0.09721886f, -0.11412419f, 0.12524769f, -0.08191978f, -0.04705077f, 0.16245192f, 
    -0.08133832f, 0.00288528f, 0.11928716f, 0.05832555f, 0.24866530f, 0.13892652f, -0.21475396f, -0.06622367f, 
    0.03717616f, 0.12329743f, 0.04266938f, 0.15600306f, 0.03867101f, -0.13300838f, 0.00943761f, -0.00231230f, 
    0.01567631f, 0.14788377f, -0.05033513f, 0.15136559f, -0.00698939f, -0.01307647f, 0.07491268f, -0.00211047f, 
    0.06108242f, 0.05674303f, 0.06341718f, -0.08117697f, 0.12938400f, 0.09646428f, -0.09494253f, 0.16964194f, 
    -0.08313267f, -0.21645057f, -0.04011668f, 0.14151198f, 0.04883172f, 0.05222927f, 0.01372785f, 0.01959358f, 
    -0.35189196f, -0.08323880f, 0.03258650f, 0.06463339f, -0.11439011f, -0.09443510f, 0.05506221f, 0.05161272f, 
    0.12063481f, 0.01597315f, -0.06185738f, 0.02804021f, -0.20744675f, 0.06612303f, -0.17186266f, 0.38357198f, 
    -0.04273098f, 0.04744630f, 0.08236957f, -0.01208121f, 0.05641592f, 0.15150301f, -0.01230037f, 0.00903419f, 
    0.11746121f, -0.02821897f, -0.16699418f, -0.07369659f, 0.14801744f, -0.05687077f, -0.06205743f, -0.00167546f, 
    -0.10954930f, -0.07044965f, 0.02032828f, -0.02947999f, -0.08615108f, -0.07829337f, -0.15206765f, -0.24931110f, 
    0.09836339f, 0.01440227f, -0.04754461f, -0.00752854f, 0.05341545f, 0.03605739f, 0.00294128f, 0.13645303f, 
    -0.26928350f, -0.23589332f, -0.08575179f, 0.17689192f, -0.12992364f, -0.22473904f, 0.06342909f, 0.06180621f, 
    -0.07013954f, 0.11068271f, 0.16757245f, -0.06976483f, -0.03160069f, 0.04285028f, 0.06657619f, -0.06320918f, 
    0.00714692f, 0.15169406f, -0.05653435f, 0.06824716f, -0.05045766f, 0.01516635f, -0.12162191f, 0.09749637f, 
    0.16007434f, 0.05741848f, 0.12937066f, 0.06064933f, -0.01390123f, 0.06794162f, -0.03610542f, -0.05562391f, 
    0.13265431f, 0.05158895f, -0.07068645f, -0.02176100f, -0.15302542f, -0.04747618f, 0.20935541f, 0.08349285f, 
    0.15293615f, -0.01684971f, -0.02875974f, 0.10513237f, 0.13603128f, 0.08600991f, -0.01847402f, -0.05304678f, 
    0.20860475f, 0.11423637f, 0.02924793f, 0.07328937f, -0.03714348f, -0.06646276f, -0.05254188f, 0.19960113f, 
    -0.00974999f, 0.06034316f, 0.10512536f, 0.07058416f, -0.07313061f, -0.14549990f, -0.02517943f, 0.16921993f, 
    0.19574049f, 0.06044002f, 0.00948032f, 0.05069849f, 0.19071721f, 0.18620199f, -0.02749817f, -0.06163625f, 
    0.18442211f, 0.04654357f, -0.14926541f, 0.15686779f, -0.07283292f, -0.02229343f, 0.04884341f, 0.19032489f, 
    0.01136616f, -0.01117735f, -0.11703073f, -0.06174798f, 0.17683080f, -0.04954044f, -0.05192293f, -0.10897984f, 
    -0.02550089f, 0.01583023f, -0.07873706f, -0.00392344f, 0.04640673f, 0.14484885f, 0.01015728f, -0.04667054f, 
    -0.02505664f, 0.04226948f, -0.01243419f, 0.00222904f, -0.04423065f, 0.02283291f, 0.04051060f, -0.00317430f, 
    0.00838439f, 0.02048125f, 0.00523038f, -0.03368123f, -0.02170205f, 0.02161014f, -0.04877754f, -0.01652147f, 
    -0.03361354f, -0.05167480f, -0.05178325f, -0.04493069f, 0.03308243f, -0.00325016f, 0.01290000f, -0.02626494f, 
    -0.01888435f, 0.00649147f, -0.01556493f, -0.01079469f, -0.03559989f, 0.00987679f, 0.03980153f, -0.02196740f, 
    -0.02084113f, -0.04955133f, 0.00017119f, 0.02547069f, -0.00975634f, -0.00837381f, -0.02582701f, 0.02520826f, 
    -0.01102301f, 0.04528388f, -0.02826219f, 0.03882971f, 0.01794043f, 0.03967542f, 0.01884687f, -0.05387067f, 
    0.03667619f, -0.03469421f, -0.00280188f, 0.03875371f, 0.00152370f, -0.04440156f, -0.03185063f, 0.03999181f, 
    -0.05002724f, 0.04157716f, -0.03343076f, 0.02653236f, -0.04262118f, -0.01204496f, -0.03944004f, -0.02202599f, 
    -0.01274777f, -0.03221891f, -0.00407357f, 0.02040739f, 0.03306582f, 0.03414511f, -0.03469342f, -0.05132591f, 
    0.04083796f, 0.02725640f, 0.04488867f, 0.03349862f, 0.02115390f, -0.05032651f, -0.03939584f, -0.02961787f, 
    -0.02651812f, -0.00762519f, -0.05285168f, -0.04249562f, 0.02638279f, 0.01666854f, -0.04241332f, 0.01160231f, 
    -0.00411772f, -0.01910653f, -0.02260899f, -0.05998183f, -0.04079687f, 0.00809783f, -0.02253015f, -0.05175681f, 
    0.02795990f, -0.02097175f, 0.02359278f, 0.02825842f, -0.02657429f, -0.00494064f, -0.05161441f, -0.02140802f, 
    -0.02124412f, -0.05329514f, -0.05152484f, -0.02501712f, 0.01429387f, -0.04059586f, -0.01429471f, 0.00078883f, 
    0.02330744f, 0.01663053f, 0.00023939f, 0.01413479f, 0.03986852f, -0.02427923f, -0.01483480f, -0.05612627f, 
    0.03963869f, 0.02764657f, -0.00970322f, 0.00974275f, -0.03904616f, 0.03087029f, -0.01619405f, -0.00326235f, 
    -0.00879950f, 0.02398128f, 0.01751516f, -0.05849709f, 0.03101614f, -0.01684630f, 0.01976328f, -0.04457775f, 
    -0.04528338f, -0.05824705f, 0.03243849f, 0.00672578f, -0.05606397f, 0.02598903f, 0.04141898f, -0.05266819f, 
    0.02478286f, -0.04298804f, 0.02575832f, -0.02093171f, 0.02593043f, 0.00492497f, -0.03868102f, 0.01195875f, 
    -0.05389253f, 0.00182817f, -0.02614577f, 0.01957601f, 0.01811491f, 0.01074301f, 0.03650260f, -0.00202332f, 
    0.01497080f, 0.04221388f, 0.00704943f, 0.02773346f, 0.00483080f, -0.04069076f, 0.01090205f, 0.02962863f, 
    -0.03329533f, -0.04915499f, -0.00984104f, -0.00169811f, 0.03866600f, -0.03202720f, -0.04033636f, 0.01764494f, 
    -0.00424740f, -0.00934153f, -0.04103327f, 0.02507503f, 0.03189769f, -0.02410684f, 0.02831552f, -0.03636811f, 
    0.03559716f, 0.01231401f, 0.01747793f, -0.01016831f, -0.03121494f, -0.01290056f, 0.00708447f, -0.04309807f, 
    -0.05303748f, -0.00058144f, 0.04407002f, -0.04921192f, -0.05337414f, 0.04098447f, 0.01316267f, 0.01691516f, 
    -0.00781122f, 0.01310552f, 0.00397226f, -0.05203580f, 0.04541317f, -0.05425907f, -0.05684531f, -0.05260587f, 
    -0.01360643f, -0.01813490f, -0.01568381f, -0.05755303f, -0.01670501f, -0.02021164f, -0.05042261f, 0.02462730f, 
    -0.00762314f, 0.03235543f, -0.02013340f, -0.04146165f, -0.04788938f, 0.02425858f, 0.02533524f, 0.00048205f, 
    -0.04497311f, -0.03915665f, -0.00903527f, -0.04467870f, -0.02115346f, -0.01577111f, -0.00241361f, 0.00701133f, 
    -0.01859105f, -0.02732394f, 0.02577935f, -0.00265908f, -0.02670179f, 0.01289794f, 0.02108159f, 0.03933782f, 
    -0.04245431f, -0.00347594f, -0.00066956f, -0.00610564f, -0.04928658f, -0.01102283f, 0.03080644f, -0.05322686f, 
    -0.04160680f, -0.03602447f, -0.04751141f, 0.02135805f, 0.00974634f, 0.02431342f, 0.00323839f, 0.02318700f, 
    0.00135490f, 0.02653722f, -0.03749482f, -0.00046959f, -0.03774746f, -0.02960850f, -0.00956782f, -0.05564429f, 
    0.03864762f, -0.05120282f, -0.01460371f, -0.03332378f, 0.01834119f, 0.04077410f, 0.03312930f, -0.04509126f, 
    0.00036316f, 0.01972144f, 0.02014764f, -0.03475057f, -0.05457320f, -0.00040416f, -0.01284520f, -0.03347068f, 
    0.02169971f, 0.01547628f, -0.02081332f, 0.01577342f, 0.03190157f, -0.02226741f, 0.03363040f, -0.02053244f, 
    -0.04950060f, 0.03046976f, 0.00994944f, -0.04505527f, 0.03740044f, 0.03523451f, 0.01859014f, 0.02946546f, 
    0.01975378f, -0.04051005f, -0.02944761f, -0.00860675f, 0.02559735f, -0.00810158f, -0.03764120f, -0.03315040f, 
    -0.00618601f, -0.03286012f, -0.04081038f, 0.02288653f, 0.04256642f, -0.03288578f, 0.03033172f, 0.00791574f, 
    0.03133561f, -0.03043158f, -0.03575696f, -0.03600287f, -0.04074810f, -0.01704495f, -0.03673437f, 0.03809733f, 
    0.01263051f, -0.02738131f, -0.03422307f, -0.03929303f, -0.00437561f, 0.03450766f, -0.03800575f, 0.03811729f, 
    -0.00212752f, -0.00133962f, 0.02352312f, 0.02295084f, 0.00184862f, 0.01543196f, -0.03163801f, 0.01740471f, 
    0.00928331f, -0.03298374f, -0.02878103f, 0.01323007f, 0.03751339f, -0.00221204f, 0.00076492f, 0.00182756f, 
    0.03658408f, -0.04635648f, -0.01967395f, -0.03671908f, -0.02401730f, 0.02450882f, 0.04277002f, -0.02919221f, 
    -0.01879219f, -0.04003368f, -0.01952594f, -0.00456984f, 0.00782496f, -0.02355417f, 0.01835700f, -0.05262626f, 
    0.00292950f, 0.00121914f, -0.04707883f, -0.00941879f, -0.03798075f, -0.02612426f, 0.03663795f, -0.05188699f, 
    -0.02915472f, 0.00966814f, 0.01300876f, -0.01545206f, 0.04661141f, 0.01571466f, 0.02985344f, 0.00597513f, 
    0.04185757f, 0.00862896f, 0.01048864f, -0.05093972f, -0.01262152f, -0.02876378f, -0.02834436f, -0.02077813f, 
    -0.02017589f, -0.03541394f, -0.04701346f, -0.01024854f, -0.02995995f, 0.03317079f, -0.01163306f, 0.03650200f, 
    -0.00692466f, 0.03523517f, -0.04528083f, -0.00339958f, -0.01911700f, -0.00566800f, 0.01135989f, -0.00491436f, 
    -0.05240718f, 0.00145847f, -0.02089066f, 0.02333271f, 0.00396338f, -0.04164762f, -0.01718172f, 0.03473610f, 
    -0.03088704f, -0.04045717f, -0.03394846f, 0.04479740f, -0.05449107f, -0.00846243f, 0.00977276f, -0.01176669f, 
    -0.00857535f, 0.02807608f, 0.03830705f, -0.02933831f, -0.04019952f, 0.02546086f, -0.01618772f, 0.03222650f, 
    -0.05519288f, -0.04294152f, -0.04164503f, -0.03416841f, 0.02311003f, -0.05215013f, -0.00156599f, 0.01025807f, 
    0.03108250f, 0.03671955f, -0.03386610f, -0.04045908f, -0.03045069f, 0.03685379f, -0.05792324f, 0.01390555f, 
    0.02095686f, -0.01789953f, -0.05317014f, -0.04001886f, 0.03455587f, 0.01306108f, -0.03656602f, 0.00781496f, 
    0.01135053f, -0.03125818f, -0.01178287f, -0.01382206f, 0.01421691f, -0.04194470f, 0.03003025f, -0.03185834f, 
    -0.04493387f, -0.04394694f, 0.00935621f, 0.01407325f, -0.04139671f, -0.00598258f, -0.00098980f, -0.01452570f, 
    -0.02041649f, 0.03470880f, -0.04161011f, 0.04707762f, -0.01966211f, -0.04724454f, -0.01690127f, -0.04896791f, 
    -0.03281350f, -0.05959729f, 0.01741054f, 0.01172926f, 0.03264272f, 0.03706919f, 0.00591310f, -0.00441873f, 
    0.01728578f, -0.01983588f, -0.04575339f, 0.02933316f, 0.03136449f, -0.04572545f, -0.02456784f, 0.00928670f, 
    -0.04702280f, 0.03114262f, -0.02034786f, -0.00029028f, 0.02938599f, -0.00887197f, -0.02416170f, 0.02328937f, 
    0.01631472f, -0.00208786f, -0.03881643f, 0.02149907f, 0.00254639f, -0.00669409f, 0.01751165f, -0.03286131f, 
    -0.00666824f, -0.03405211f, -0.04681829f, -0.04752415f, -0.00477086f, 0.03278009f, 0.03884719f, -0.03613853f, 
    0.03432924f, -0.01742178f, -0.03375368f, 0.01744605f, 0.04355796f, 0.01677406f, 0.00364547f, -0.02828301f, 
    0.03534799f, 0.04542417f, 0.05553870f, -0.04407039f, -0.01139398f, 0.02505110f, -0.02271498f, -0.01115718f, 
    -0.01198578f, -0.03235195f, -0.01351892f, -0.03847453f, 0.02165630f, -0.04880498f, 0.00221985f, 0.00984587f, 
    -0.04900990f, -0.01680951f, 0.02351020f, 0.03361913f, 0.00214536f, 0.00299492f, -0.04187257f, 0.05081737f, 
    -0.00539786f, -0.05226303f, 0.02763773f, 0.04185660f, -0.01680885f, 0.02368198f, 0.03129434f, -0.05992757f, 
    -0.01059365f, 0.00808901f, -0.03963022f, -0.03097269f, -0.00035463f, 0.01517589f, -0.05576316f, 0.00607719f, 
    0.01140419f, -0.04340569f, -0.04470207f, -0.00887306f, -0.03669548f, -0.02995291f, -0.05615586f, 0.01248864f, 
    -0.01038725f, 0.04369020f, 0.01269833f, 0.03438744f, -0.02275937f, -0.02573058f, -0.00986263f, 0.00232693f, 
    -0.00907718f, 0.01954822f, -0.00265184f, -0.01567183f, -0.00770957f, -0.00855346f, -0.01110776f, -0.05078626f, 
    0.02088229f, -0.03021091f, 0.03626271f, 0.01061279f, -0.05625456f, 0.01360157f, 0.04290283f, 0.03584425f, 
    -0.04762984f, 0.02183184f, 0.03939293f, 0.00895032f, 0.02013895f, 0.00914889f, 0.02984749f, 0.00209682f, 
    0.02786096f, -0.01794352f, 0.03728640f, 0.01325810f, 0.00956884f, -0.02982334f, 0.01833777f, 0.01811596f, 
    -0.01098835f, -0.00246516f, 0.03284958f, -0.03122640f, 0.03425109f, -0.05948041f, -0.06481413f, -0.02309248f, 
    0.02924417f, 0.00439419f, -0.02069741f, -0.05174243f, 0.01307589f, 0.00294520f, 0.01356324f, -0.04186448f, 
    0.01820361f, 0.01627193f, 0.00216729f, -0.03768687f, -0.02505700f, 0.01556556f, 0.04423300f, -0.00256964f, 
    -0.01084245f, -0.01315094f, 0.01293812f, -0.04380292f, -0.00534772f, -0.01693934f, 0.03788080f, 0.03712818f, 
    0.03435793f, 0.01033995f, 0.00623938f, 0.03506629f, -0.01548747f, 0.00981848f, -0.00965496f, 0.02398269f, 
    -0.03333658f, 0.02792327f, 0.03326090f, -0.03914753f, 0.02241165f, 0.05457579f, -0.02270873f, 0.04171318f, 
    -0.02732953f, -0.01250136f, -0.02825185f, -0.03020221f, 0.00633232f, -0.00281821f, -0.05020418f, -0.00773876f, 
    -0.03311748f, 0.00094830f, 0.04519383f, 0.00049608f, -0.04544513f, -0.02395486f, -0.05482113f, 0.00461827f, 
    0.04700859f, -0.00647301f, -0.03673285f, 0.03777895f, -0.01581341f, -0.04090052f, 0.00486980f, 0.00310345f, 
    0.03496474f, -0.04958082f, 0.03747286f, 0.01988154f, -0.00004902f, 0.00817863f, -0.00489280f, -0.00716075f, 
    -0.04844186f, 0.00280944f, -0.00411399f, -0.01021505f, 0.00969434f, -0.03783912f, -0.04363097f, -0.00925254f, 
    -0.01938556f, -0.03819317f, 0.03605678f, -0.01715378f, -0.04956380f, 0.00786847f, 0.01597166f, -0.04439494f, 
    -0.02053971f, 0.02014520f, -0.04508942f, 0.02061649f, 0.01426917f, -0.00460656f, -0.05354033f, 0.01047568f, 
    -0.00238266f, 0.00992992f, -0.00508574f, 0.00288012f, 0.00840403f, 0.00086540f, -0.04464425f, -0.04129431f, 
    -0.04933076f, 0.00930052f, 0.00946112f, -0.03038732f, -0.00542786f, -0.03806153f, 0.01884614f, -0.01207329f, 
    0.04560503f, -0.03203729f, 0.02354658f, 0.02903107f, -0.04756134f, -0.02195946f, -0.00103647f, 0.02790722f, 
    -0.02007569f, -0.02919639f, 0.00323963f, 0.02563244f, -0.03596527f, 0.00505620f, 0.00807624f, -0.02019416f, 
    -0.03295681f, -0.04182180f, -0.02306717f, -0.00747130f, -0.04860359f, -0.00431905f, -0.02547188f, -0.00550962f, 
    -0.04609414f, 0.01113040f, 0.01313825f, 0.03181833f, 0.00869029f, 0.00558298f, 0.03488325f, -0.04741281f, 
    -0.02657980f, -0.00227484f, -0.00536507f, -0.03731509f, 0.03922497f, -0.03474234f, -0.00620187f, 0.03310227f, 
    -0.30729949f, -0.01846998f, -0.14983244f, 0.06044368f, 0.14031971f, 0.03499078f, -0.05842888f, -0.08129931f, 
    0.06837236f, 0.02322261f, -0.10517350f, -0.10101131f, 0.15584724f, 0.08869561f, 0.06935959f, 0.11726753f, 
    0.07614424f, 0.02054609f, 0.04073140f, 0.09966358f, 0.01359287f, 0.01589461f, 0.08364698f, -0.05422485f, 
    0.06496321f, 0.03214852f, -0.02482562f, 0.08064082f, 0.04355858f, 0.01206451f, 0.05240544f, 0.05398810f, 
    -0.03639108f, 0.02545697f, 0.17434208f, 0.10141619f, 0.23798126f, 0.03035498f, 0.01881394f, -0.08556392f, 
    -0.03337467f, 0.00899904f, 0.02402451f, 0.06826892f, 0.11403844f, 0.00605810f, 0.04590897f, 0.01493865f, 
    0.08147383f, -0.08907556f, -0.24706307f, -0.09271070f, 0.09507772f, 0.02768894f, -0.06399138f, -0.00682521f, 
    0.01747615f, 0.01307461f, -0.05871533f, -0.01106731f, 0.26566789f, 0.10766341f, 0.17003280f, 0.05144329f, 
    -0.00910863f, -0.03786069f, 0.05312934f, 0.06771358f, -0.03120930f, 0.05688439f, -0.05756892f, -0.01333864f, 
    0.11387693f, -0.16511546f, -0.43290234f, 0.24072637f, 0.03939037f, -0.00336437f, -0.08974014f, -0.03065348f, 
    -0.03026713f, 0.04587655f, -0.05719864f, 0.03198085f, 0.15725504f, -0.17143048f, -0.05572298f, 0.11759096f, 
    0.00550444f, -0.12438031f, -0.12234403f, 0.03430800f, -0.11321255f, 0.08946818f, 0.01205899f, -0.05806996f, 
    0.23679687f, -0.03496308f, 0.04672757f, 0.00851138f, 0.17963998f, -0.00924051f, -0.09667373f, -0.06641275f, 
    -0.04977381f, -0.05132798f, -0.05925438f, -0.17511982f, 0.20901307f, 0.32893333f, 0.03475324f, -0.07571840f, 
    -0.05641795f, -0.11390046f, 0.30809411f, 0.07569562f, 0.01481034f, -0.07147485f, 0.12180495f, 0.01983492f, 
    0.16997455f, -0.19740334f, -0.00829258f, 0.28370747f, -0.05648378f, -0.02180303f, 0.10236589f, 0.04288201f, 
    0.03454676f, -0.00288120f, 0.02477951f, -0.04262792f, -0.06764216f, -0.08710483f, 0.27584249f, 0.13333209f, 
    0.00861034f, -0.07362828f, 0.09075081f, 0.05385872f, 0.04194420f, -0.05873255f, 0.15631716f, 0.04549694f, 
    0.19585979f, 0.00220643f, -0.14166468f, -0.14100493f, 0.00961592f, 0.01229905f, 0.10098715f, -0.06472224f, 
    -0.00842067f, 0.06151028f, 0.14877036f, 0.04352320f, -0.13160521f, -0.26973289f, -0.18235627f, 0.04188504f, 
    0.02246811f, -0.01472552f, 0.06720080f, -0.05302848f, -0.10482477f, 0.00288738f, -0.02040919f, 0.02478984f, 
    0.32677740f, 0.09452733f, -0.11178835f, -0.15316215f, 0.07988504f, 0.07319665f, -0.13581455f, -0.03162655f, 
    -0.02740320f, 0.04222525f, -0.00560356f, 0.03722927f, 0.35178715f, 0.11359370f, 0.00739565f, 0.06757235f, 
    0.09931489f, 0.02928179f, -0.05879483f, 0.04127796f, -0.08675139f, 0.09761494f, -0.04138655f, 0.03383697f, 
    0.04575752f, 0.04854050f, 0.15808932f, 0.04803170f, -0.07543089f, 0.02564879f, 0.03503334f, 0.14336990f, 
    0.20650993f, 0.08540680f, 0.04214135f, 0.04497373f, -0.42024025f, 0.01875721f, -0.17136714f, -0.09206802f, 
    0.14118809f, -0.05166003f, -0.06070600f, 0.00614936f, -0.04226825f, 0.17103112f, 0.05911154f, -0.13672599f, 
    0.41191286f, 0.11809262f, 0.01697562f, -0.15119080f, 0.13744751f, 0.01865443f, 0.03343792f, 0.05642252f, 
    -0.13455260f, 0.05095116f, 0.02039772f, 0.01180568f, 0.33957282f, 0.10678915f, 0.17250738f, 0.28487366f, 
    0.17930058f, 0.17863207f, 0.00497408f, -0.05994930f, 0.01335906f, -0.10835002f, 0.00823134f, -0.03017970f, 
    0.47509915f, 0.05062024f, 0.02113362f, 0.02029077f, 0.11449216f, -0.06684887f, 0.01452432f, 0.06053576f, 
    0.03064454f, 0.10550820f, -0.07811955f, 0.00379943f, -0.08168589f, 0.15782043f, -0.05608920f, -0.09130518f, 
    -0.04564558f, -0.08941822f, 0.10249612f, 0.06653181f, -0.03937810f, 0.06487001f, 0.00215196f, 0.01340766f, 
    -0.15259235f, -0.40878057f, -0.18751942f, -0.07229077f, 0.06690269f, 0.00139735f, -0.05764732f, -0.03736451f, 
    -0.06928201f, 0.04915608f, 0.06713632f, 0.12821595f, -0.15127720f, -0.19291189f, -0.13034931f, -0.00241459f, 
    0.04601074f, 0.05931445f, -0.05663935f, -0.11766900f, -0.08424425f, -0.00886854f, 0.03751043f, -0.13543347f, 
    0.30629173f, 0.47924381f, 0.26205587f, 0.09599035f, 0.01782577f, -0.02531666f, 0.12370943f, 0.14983350f, 
    0.01056141f, -0.09287521f, -0.03389369f, -0.09999888f, 0.21030407f, 0.15699381f, -0.19548304f, 0.09953716f, 
    0.03002485f, 0.12065578f, 0.00181497f, -0.04502480f, 0.03605255f, 0.01531304f, 0.07625949f, -0.13379355f, 
    -0.07260783f, 0.08580051f, 0.02162689f, -0.03412894f, -0.14714645f, -0.08750037f, 0.14657368f, -0.00943274f, 
    0.09440129f, 0.01987553f, -0.04964386f, 0.09183492f, 0.07452025f, -0.02634566f, 0.00537240f, -0.03675153f, 
    0.05907783f, 0.01185181f, 0.17749436f, -0.00423861f, 0.01717349f, 0.07405358f, 0.17069134f, 0.01167165f, 
    0.01802939f, 0.18419917f, 0.12757857f, 0.05827715f, 0.21869721f, 0.14022122f, 0.07870928f, 0.04134884f, 
    0.07063060f, 0.05789349f, -0.01595856f, -0.19317189f, 0.12126700f, 0.11570526f, -0.07136065f, 0.00250264f, 
    -0.05244656f, -0.06995923f, -0.01129545f, 0.02968767f, 0.20602039f, 0.03501262f, 0.02734441f, 0.06976880f, 
    0.22006853f, 0.19380023f, 0.09021302f, 0.10061901f, 0.15937865f, 0.04012404f, 0.06230762f, -0.02454376f, 
    0.08965647f, -0.14598259f, 0.04704700f, 0.05032713f, -0.31490093f, 0.03844014f, -0.07266146f, 0.05090810f, 
    0.12017422f, 0.05033248f, -0.24501574f, -0.06290131f, 0.06775054f, -0.10634183f, 0.14789549f, -0.06091692f, 
    0.04379889f, 0.02640889f, 0.01305528f, 0.02909149f, 0.02474979f, -0.00642627f, -0.01140049f, -0.01968041f, 
    0.02783970f, 0.01685485f, 0.02164361f, -0.00408523f, -0.03465643f, 0.03235395f, 0.03739388f, -0.03346615f, 
    -0.01404588f, 0.01914252f, 0.01090471f, 0.02500395f, -0.02282082f, 0.04172746f, -0.03653536f, -0.00118646f, 
    -0.05452088f, 0.00336739f, -0.01247206f, 0.02933492f, 0.02283108f, -0.00623016f, 0.02607711f, 0.01971264f, 
    -0.01243660f, -0.01546325f, 0.03441410f, -0.01098250f, -0.02611853f, -0.03106377f, -0.03775112f, 0.04444900f, 
    -0.01345974f, -0.01978748f, 0.02448348f, -0.02440930f, -0.04122917f, 0.02448325f, 0.00019332f, 0.03625567f, 
    -0.01669779f, 0.03613085f, -0.00581932f, 0.04308620f, 0.02576340f, -0.01301463f, -0.02447863f, 0.01645372f, 
    0.01062748f, -0.00692760f, -0.01976895f, -0.02692848f, -0.01308536f, -0.01337638f, 0.02523289f, 0.02270711f, 
    -0.03899486f, 0.04298875f, 0.04553334f, -0.03590664f, -0.03465372f, -0.04969946f, -0.00300490f, 0.00659284f, 
    0.01305393f, -0.00080357f, 0.00482937f, -0.00062627f, 0.03529178f, 0.02721748f, -0.03960059f, 0.00570044f, 
    -0.00644676f, -0.04048065f, -0.00983805f, -0.00194988f, -0.00667367f, -0.02455616f, -0.02370457f, -0.03187453f, 
    0.01034092f, 0.01125201f, 0.04489105f, -0.01933574f, 0.00019568f, -0.01741945f, 0.04284094f, -0.02711801f, 
    -0.03187428f, -0.01480906f, -0.02311985f, 0.00230041f, 0.00110682f, 0.02388021f, 0.02358940f, -0.03084902f, 
    -0.04120469f, 0.04471613f, -0.04035402f, -0.00273256f, 0.01555375f, 0.00747910f, 0.00631430f, -0.01897719f, 
    -0.04603608f, -0.02199010f, 0.01742842f, -0.03829643f, -0.01868618f, 0.03543343f, 0.01942752f, 0.00665263f, 
    -0.02293969f, 0.01718979f, -0.05193689f, -0.00639193f, 0.03028508f, 0.01690775f, -0.01975809f, -0.03039020f, 
    0.00680842f, -0.00631915f, 0.04508419f, -0.01820649f, -0.05910536f, 0.02087884f, 0.00674582f, -0.01077540f, 
    0.00691145f, 0.02843791f, 0.03691941f, 0.00745268f, 0.00246106f, -0.02014434f, -0.00714770f, 0.04504370f, 
    -0.01220310f, -0.00823128f, 0.03582170f, -0.03408324f, -0.03482483f, -0.02644845f, 0.01034384f, 0.02472628f, 
    -0.03611337f, 0.01061636f, 0.03845700f, -0.01403753f, -0.02155338f, -0.04404799f, 0.00093580f, -0.04805776f, 
    0.02072922f, -0.03867020f, 0.03562588f, 0.04378346f, -0.05451653f, -0.03029355f, 0.00710106f, -0.00738175f, 
    -0.03269941f, 0.00326234f, -0.00700347f, 0.01119181f, 0.00749935f, -0.03357699f, -0.05057713f, 0.03887236f, 
    -0.05148276f, -0.03355633f, 0.01069376f, -0.00704388f, -0.03341739f, 0.04066102f, -0.01811895f, 0.02117221f, 
    -0.03152566f, 0.01921204f, -0.01118724f, -0.00972956f, 0.04049024f, 0.03389042f, -0.03962514f, 0.01911860f, 
    0.02275657f, 0.02675150f, -0.01482994f, 0.00582093f, 0.03878906f, -0.01176039f, -0.05153476f, -0.01203271f, 
    0.02874334f, -0.04133117f, 0.02234062f, 0.03418159f, -0.05462968f, 0.01416876f, 0.02827957f, 0.00079176f, 
    -0.00160156f, -0.04962765f, -0.02846540f, 0.01524263f, 0.01119477f, 0.02927585f, -0.04745930f, -0.01490606f, 
    -0.00752222f, -0.04737307f, 0.01940216f, 0.02423143f, 0.02282782f, 0.00317195f, 0.03580184f, -0.04809580f, 
    -0.03821266f, -0.03077738f, -0.01257168f, -0.00565314f, 0.01917285f, 0.03481877f, -0.02025343f, -0.02397308f, 
    -0.00294236f, 0.02710384f, 0.02919678f, -0.01445260f, -0.01847779f, -0.02884465f, 0.03067000f, -0.04471895f, 
    0.02422405f, -0.01871288f, 0.00699446f, -0.05146114f, -0.02370718f, -0.01976246f, -0.04556401f, -0.03176039f, 
    0.02310400f, 0.00985702f, 0.02191569f, 0.01157817f, 0.01233370f, 0.00842734f, 0.03132560f, -0.02300118f, 
    0.00430183f, -0.04368164f, -0.01501448f, 0.01380712f, 0.01305234f, 0.02982387f, -0.03959400f, -0.03241128f, 
    -0.03212133f, 0.00824911f, 0.01817608f, -0.02195347f, -0.03365847f, 0.04682719f, -0.02665477f, -0.04992451f, 
    0.03700647f, 0.00434636f, -0.03920064f, -0.01867435f, -0.00119446f, -0.02550479f, 0.03688755f, 0.04133636f, 
    0.04142525f, -0.02145534f, -0.04154821f, 0.02724747f, -0.03124786f, -0.01613090f, -0.00493937f, -0.00712646f, 
    -0.02681929f, 0.04050953f, -0.02431065f, -0.03595698f, -0.03853565f, 0.03111097f, 0.02446751f, -0.03762959f, 
    -0.02047699f, -0.02495829f, -0.02999849f, 0.00873180f, -0.04999152f, 0.02410969f, 0.00248615f, -0.02129400f, 
    0.01257335f, 0.01301027f, -0.00355009f, 0.00330013f, -0.02392252f, 0.03185935f, 0.01448377f, -0.01022405f, 
    0.02372272f, -0.05062967f, 0.02360939f, -0.02898303f, -0.02621472f, -0.02437653f, -0.04265601f, 0.01532141f, 
    -0.00776734f, -0.04842930f, 0.03243897f, -0.02933884f, -0.02492912f, -0.05462836f, -0.01144478f, 0.01839382f, 
    -0.04703226f, 0.01350605f, -0.05305354f, 0.00922989f, 0.02819600f, 0.02314793f, -0.00941266f, -0.02265811f, 
    -0.05648544f, -0.05495581f, -0.02247982f, -0.05066508f, 0.03575489f, -0.05152201f, -0.05494823f, -0.03065507f, 
    0.02308957f, 0.03965359f, -0.02695433f, -0.05631250f, -0.03561560f, -0.03358044f, -0.04682979f, 0.02509914f, 
    0.01882984f, -0.02944077f, 0.00817499f, -0.02926672f, 0.02144420f, 0.04051836f, -0.02934655f, 0.01757740f, 
    -0.05798222f, 0.04622927f, -0.04416640f, 0.03635001f, -0.05037921f, 0.02238680f, 0.02001922f, -0.03693060f, 
    -0.04111399f, -0.04955598f, -0.01344264f, 0.01275136f, -0.04560500f, -0.02724076f, 0.04390192f, -0.01822470f, 
    -0.04608267f, -0.01816392f, -0.04326935f, 0.00411592f, 0.02833175f, -0.02802621f, -0.00795337f, 0.03615468f, 
    0.12362716f, -0.00465690f, 0.07297266f, -0.13638790f, 0.02454339f, 0.05835782f, -0.06528252f, 0.06040553f, 
    0.03416620f, 0.11295168f, 0.08339370f, 0.10664505f, -0.14687642f, 0.21508965f, 0.06746987f, 0.13390338f, 
    -0.02109998f, 0.04369954f, 0.06631655f, 0.01670535f, -0.05588259f, 0.15118618f, -0.00243071f, -0.01748294f, 
    -0.15958762f, -0.03787344f, 0.12441345f, -0.03868015f, -0.09551764f, -0.06764753f, -0.14023471f, 0.13110597f, 
    0.02787818f, 0.01543129f, -0.20351787f, -0.09957457f, -0.19021554f, 0.00779557f, 0.05960981f, -0.08163485f, 
    0.03402856f, -0.04845521f, -0.08790606f, -0.04668684f, 0.02773361f, -0.02235994f, 0.05893433f, -0.03011215f, 
    0.06532925f, -0.05956833f, 0.10016033f, 0.32765296f, -0.03512251f, 0.08864782f, 0.05541610f, 0.02318914f, 
    0.06397502f, 0.02133761f, 0.19584426f, 0.00590794f, -0.18516411f, 0.08657955f, 0.05516635f, 0.15922262f, 
    0.13567695f, -0.04521751f, -0.05045768f, 0.07761741f, 0.02456370f, 0.14924817f, -0.14325957f, 0.03086874f, 
    0.15508707f, 0.17358385f, 0.10769855f, -0.08525646f, -0.00931073f, -0.08926757f, -0.12314839f, 0.11674974f, 
    -0.03329900f, -0.03980644f, -0.03827302f, -0.05373675f, 0.08488885f, -0.02274325f, 0.25694820f, 0.06316552f, 
    0.01915549f, 0.18950759f, 0.05747607f, -0.01535603f, 0.20031436f, -0.07214493f, 0.03294144f, -0.14363246f, 
    -0.21485788f, -0.13368596f, 0.25979435f, 0.02206867f, -0.00433133f, 0.19717366f, 0.16690345f, 0.15698121f, 
    -0.05390523f, 0.03937412f, 0.12666911f, 0.11668256f, -0.31950676f, -0.13062833f, 0.18163241f, 0.05334424f, 
    0.05308666f, 0.23191524f, -0.01535404f, -0.09810867f, -0.02015689f, 0.10485201f, 0.02915793f, 0.02447215f, 
    -0.04749677f, 0.01338267f, 0.02517232f, -0.24923474f, 0.10016567f, 0.02652407f, -0.18874323f, 0.16419876f, 
    -0.02353081f, -0.04845786f, 0.00819240f, -0.01489403f, -0.01160980f, 0.12737058f, 0.09328823f, -0.00611299f, 
    -0.00899974f, 0.09624409f, -0.03978607f, -0.05029954f, 0.00600633f, 0.00085501f, 0.01550615f, -0.04120462f, 
    0.02201256f, 0.19138347f, -0.01995469f, -0.03033859f, 0.03863909f, 0.06839075f, 0.09854227f, -0.02006900f, 
    0.03501375f, 0.16640320f, 0.21201803f, -0.03648879f, 0.08080767f, 0.26104102f, 0.09264031f, 0.09445003f, 
    0.01438396f, 0.01350569f, -0.05294306f, 0.15133019f, -0.02741316f, 0.14044197f, 0.05302183f, 0.12478629f, 
    0.01469782f, -0.21125354f, 0.17261535f, -0.02293450f, 0.03262301f, -0.09820883f, 0.12709750f, -0.06154698f, 
    -0.08825491f, 0.01624007f, -0.01620311f, 0.01399016f, 0.18302837f, -0.02513683f, 0.08135738f, 0.03410899f, 
    0.06608247f, 0.00704399f, 0.04514867f, -0.03665214f, 0.00431506f, 0.01956054f, -0.05265714f, -0.01024861f, 
    0.34904093f, 0.05472148f, -0.01971917f, -0.11965695f, 0.23526447f, 0.12989479f, -0.02012439f, -0.01947907f, 
    -0.18473436f, 0.06126206f, -0.01255949f, 0.11137890f, 0.34226811f, 0.19045755f, 0.05436986f, -0.17812006f, 
    -0.12407555f, 0.05762309f, 0.00051781f, -0.07944303f, 0.05319303f, -0.21871780f, -0.01768475f, 0.17285328f, 
    -0.22020426f, -0.23877785f, -0.00402126f, 0.21281460f, -0.08254007f, 0.00162951f, -0.06401656f, -0.07221197f, 
    0.19902796f, -0.11050940f, -0.00273602f, -0.23343068f, -0.13561948f, -0.16403323f, 0.09496439f, -0.09866044f, 
    0.05730503f, 0.03350894f, -0.01676596f, 0.05339297f, -0.12169888f, 0.08045832f, -0.08395234f, 0.16749445f, 
    0.37403643f, -0.02178895f, 0.22019832f, 0.03652097f, 0.02623797f, 0.06691322f, 0.00223126f, 0.07765701f, 
    0.02141852f, 0.02991244f, 0.11616896f, 0.26119995f, 0.16528669f, -0.07273822f, 0.01796484f, 0.18324164f, 
    -0.03682217f, 0.03260123f, 0.03909048f, 0.16132304f, -0.14262438f, 0.14777312f, -0.03400039f, 0.01147549f, 
    0.09090710f, 0.36877105f, 0.10941156f, -0.02731564f, 0.05880082f, -0.12921885f, 0.05428209f, 0.01638461f, 
    -0.11649165f, -0.07443620f, -0.11280572f, -0.21928835f, -0.08079257f, 0.30869618f, 0.02437238f, 0.08569380f, 
    -0.04200809f, -0.04912791f, 0.05748694f, 0.04211532f, -0.03898055f, 0.05201462f, 0.03201712f, 0.09312558f, 
    -0.04449989f, -0.12852143f, 0.16027910f, 0.09039593f, 0.21647188f, 0.04051790f, 0.09367231f, 0.15954950f, 
    0.02243260f, 0.04596939f, 0.02892195f, 0.24178991f, -0.19990876f, -0.16533710f, 0.14812762f, -0.10423569f, 
    -0.06761002f, 0.04473855f, -0.00548425f, -0.14929502f, -0.04313732f, 0.00646949f, -0.11784154f, 0.05380585f, 
    -0.27961180f, 0.06589214f, 0.11813830f, 0.02165913f, 0.05413575f, 0.17487855f, 0.01432505f, 0.00842438f, 
    -0.11898858f, -0.14092559f, 0.05919818f, -0.04854674f, 0.16425130f, 0.11363065f, 0.17597200f, 0.06919701f, 
    0.05295181f, 0.13641174f, 0.03487043f, 0.06351838f, 0.17947055f, 0.00121534f, -0.04350043f, -0.07704651f, 
    -0.00953199f, 0.08463041f, -0.08934019f, 0.12553965f, -0.09629269f, -0.04711284f, -0.13590316f, 0.06065089f, 
    -0.03689467f, 0.04597844f, 0.18052427f, 0.12873065f, -0.29149830f, -0.00398318f, 0.10771297f, -0.13194442f, 
    -0.10576199f, 0.07757849f, -0.07751368f, -0.16890532f, -0.07168911f, -0.08893021f, -0.05828585f, -0.06211495f, 
    -0.32544801f, -0.11558022f, 0.14581719f, 0.02065438f, 0.12069542f, -0.05958844f, -0.07267692f, 0.03801110f, 
    -0.03334036f, 0.02297250f, -0.19144067f, -0.00492122f, 0.31031168f, 0.06760998f, 0.16343942f, 0.21368441f, 
    -0.05846367f, 0.03805450f, 0.22576126f, 0.05636404f, 0.00148961f, 0.12874730f, -0.05682052f, 0.07107365f, 
    0.04540069f, -0.02013520f, 0.01757641f, -0.00865229f, 0.00732032f, -0.04505987f, -0.04507607f, 0.03893775f, 
    0.01606925f, 0.02250216f, 0.01360651f, 0.03538685f, 0.02239425f, 0.02240741f, 0.01637591f, 0.02600186f, 
    0.03537485f, -0.01203734f, -0.03469060f, -0.04161941f, 0.04414337f, -0.01120613f, 0.01432293f, -0.03417134f, 
    -0.05034818f, 0.01592799f, -0.01432844f, -0.04330284f, 0.01779954f, -0.04440833f, -0.05552401f, -0.04591534f, 
    -0.03457307f, -0.03599034f, 0.03706437f, 0.02943042f, 0.01836659f, 0.02600744f, -0.02702929f, -0.04313141f, 
    0.00978720f, 0.00023117f, -0.00200368f, -0.00911684f, -0.00048427f, 0.02214481f, -0.01598012f, -0.03827793f, 
    -0.03908818f, 0.00989296f, -0.00182615f, -0.02979751f, 0.00558973f, -0.04363525f, 0.03128976f, 0.03565572f, 
    -0.05565792f, -0.04421953f, 0.01527323f, -0.01455488f, 0.03959650f, 0.03634028f, 0.04225647f, -0.03159750f, 
    0.03847356f, -0.03982453f, -0.02829542f, 0.03788215f, 0.00682728f, -0.01029894f, 0.02301674f, -0.00503025f, 
    0.01365906f, -0.02686197f, -0.04734279f, 0.04230187f, -0.02549271f, -0.05621057f, -0.03532913f, 0.03691792f, 
    -0.03422146f, -0.04149637f, 0.00592738f, 0.03164338f, -0.02451695f, -0.00362758f, -0.00214788f, -0.01729384f, 
    -0.01192243f, -0.03795319f, -0.04156771f, 0.04548000f, 0.01453063f, 0.01151697f, -0.03107561f, 0.01863411f, 
    -0.03242711f, -0.01621819f, 0.02371895f, -0.04860244f, -0.01289889f, -0.00365701f, 0.01656741f, -0.03682387f, 
    -0.00504621f, -0.03545605f, -0.02149847f, 0.00476024f, 0.04531172f, -0.04418302f, 0.01224019f, -0.00888693f, 
    0.04541994f, 0.03280023f, 0.01677892f, -0.03811882f, 0.02187906f, 0.00583625f, -0.01618163f, -0.04110291f, 
    0.02870782f, -0.04876544f, -0.04372324f, 0.03488712f, -0.05237031f, 0.02983641f, -0.03639926f, 0.02168020f, 
    -0.05277431f, 0.00543307f, -0.01804304f, 0.02420093f, -0.03642970f, 0.02951036f, -0.00319019f, -0.04097133f, 
    0.01306190f, -0.04224458f, -0.05124995f, -0.01695302f, -0.05022374f, 0.03449978f, 0.03360264f, -0.01754939f, 
    -0.04794427f, -0.02715212f, 0.00450482f, -0.03938948f, -0.02822797f, -0.04973720f, -0.02880610f, -0.01516382f, 
    -0.02956404f, -0.04924268f, -0.02045444f, -0.02142218f, 0.04103888f, 0.00499748f, -0.00132154f, -0.02216978f, 
    0.02363113f, 0.03051912f, 0.01220533f, 0.01122924f, -0.00528662f, -0.00905619f, 0.02329051f, -0.04494008f, 
    -0.03532324f, -0.03402382f, 0.00923687f, -0.03022217f, 0.03192775f, 0.04544051f, 0.00101699f, -0.02840056f, 
    0.01453613f, 0.00811503f, -0.05273752f, -0.04311711f, 0.01531162f, -0.04877065f, -0.00862967f, -0.04729710f, 
    0.01802635f, 0.01988856f, -0.03098012f, 0.02908106f, -0.04177511f, -0.01628589f, -0.04967291f, -0.03092058f, 
    -0.01830847f, 0.00887731f, 0.00527878f, 0.01619814f, 0.03397872f, -0.02830188f, 0.01420423f, -0.01818961f, 
    -0.05528006f, -0.01935651f, 0.02766740f, 0.04379296f, -0.02586030f, -0.01952613f, -0.02508861f, -0.03303136f, 
    0.00974090f, 0.00401076f, -0.01860401f, -0.00720420f, -0.02801881f, -0.04846712f, -0.02609450f, -0.02362715f, 
    0.02478289f, 0.03013756f, 0.03484426f, 0.02617118f, -0.02041966f, -0.01584044f, -0.03778460f, -0.03823436f, 
    -0.01359789f, -0.01104652f, -0.05171484f, -0.00161127f, 0.00328023f, 0.03492759f, -0.01429095f, 0.04322011f, 
    0.01623186f, 0.03607677f, -0.02838997f, -0.02520550f, -0.00877186f, -0.00021920f, -0.01119486f, 0.00255651f, 
    0.02161476f, -0.01942684f, 0.03054515f, -0.00794951f, 0.01137531f, -0.05264144f, 0.03494712f, -0.04610423f, 
    -0.00675880f, -0.04525126f, -0.00362229f, -0.04312693f, -0.01920019f, -0.03925845f, -0.04121391f, -0.03725031f, 
    0.02446828f, 0.02197920f, -0.01571526f, -0.01935051f, -0.00395394f, 0.02567083f, -0.05535072f, -0.05505939f, 
    -0.02753269f, -0.04435836f, 0.01143232f, -0.00163875f, 0.01165793f, -0.01971949f, -0.05356634f, -0.03764781f, 
    -0.01936551f, -0.02004057f, -0.00790387f, 0.03531981f, -0.05619959f, -0.01076819f, -0.04248573f, -0.04943065f, 
    -0.02925858f, 0.01020332f, -0.01022281f, -0.02913634f, 0.00837571f, 0.04564161f, -0.01333559f, -0.04898189f, 
    0.04195601f, -0.02136294f, -0.00203420f, -0.03335937f, -0.03438084f, -0.00598000f, -0.04505178f, -0.00797714f, 
    -0.01408556f, 0.03373233f, 0.00740208f, 0.03476835f, 0.00959308f, -0.04278760f, 0.03247148f, -0.00870180f, 
    0.00478695f, 0.02845696f, 0.00558533f, -0.05025053f, -0.04006068f, -0.02085314f, 0.00417466f, -0.02831813f, 
    -0.02135192f, 0.01782064f, -0.04633955f, -0.02943175f, 0.03403899f, -0.04251891f, 0.01213569f, 0.00263298f, 
    0.01764844f, -0.05498122f, -0.01327760f, -0.03552312f, 0.03133500f, 0.01512417f, -0.00713076f, -0.00448516f, 
    -0.01495304f, -0.04413238f, 0.01078136f, -0.00319715f, 0.03234852f, 0.03855177f, 0.01367080f, -0.03141757f, 
    -0.03919434f, 0.01814814f, 0.00635455f, -0.04525823f, -0.01869093f, -0.03360036f, 0.02657207f, -0.03385799f, 
    0.02152691f, -0.00005571f, -0.05579489f, -0.02057759f, 0.01074348f, 0.00521895f, -0.04315667f, -0.04004423f, 
    0.02678557f, -0.03734901f, -0.02332604f, 0.03313640f, -0.02219325f, 0.03115863f, 0.04079343f, -0.01729170f, 
    -0.00799038f, -0.02005860f, 0.04229959f, -0.04585091f, -0.03919131f, -0.01377771f, -0.02299124f, -0.01449460f, 
    -0.05085033f, 0.04282474f, 0.01673996f, -0.02420331f, 0.04288533f, 0.01760584f, 0.00071438f, 0.00263074f, 
    0.00144114f, -0.00888969f, 0.03444928f, -0.04737156f, -0.00550354f, -0.05126559f, -0.04182593f, 0.00624835f, 
    0.10709492f, 0.18663110f, -0.02705725f, 0.17481276f, -0.11368272f, 0.03613261f, 0.05432154f, -0.05005387f, 
    -0.03912363f, -0.04367250f, 0.00197231f, 0.03258396f, -0.11758094f, -0.25839308f, -0.03745585f, -0.10399694f, 
    0.12946996f, 0.00186411f, -0.00763213f, 0.06623917f, 0.03844343f, -0.07986990f, -0.05520751f, 0.01511176f, 
    -0.06466984f, -0.13323617f, -0.15773812f, -0.08929084f, 0.12540352f, 0.15715310f, 0.10963825f, -0.21342747f, 
    -0.07993782f, -0.00009387f, 0.19552378f, 0.10887580f, -0.06822047f, -0.15350766f, -0.02674294f, -0.11441209f, 
    -0.01067768f, 0.04824985f, 0.11932065f, 0.01120083f, 0.05113913f, 0.05395148f, 0.00552791f, 0.02446918f, 
    0.30826360f, 0.22531573f, 0.10081724f, -0.06475401f, -0.05808637f, 0.00670757f, 0.02911994f, 0.04481677f, 
    -0.02970954f, 0.01989449f, -0.04384762f, -0.01681830f, -0.07733915f, -0.17265530f, -0.10517342f, -0.17572731f, 
    0.11793109f, 0.04342201f, 0.12537497f, -0.06873347f, -0.08791565f, -0.08581287f, 0.12826663f, -0.04740165f, 
    0.43442526f, 0.15320940f, 0.01275487f, 0.12954901f, -0.02408908f, -0.01458014f, 0.08932661f, -0.05520102f, 
    -0.04307729f, 0.03633864f, 0.05061590f, 0.13845693f, 0.21553773f, -0.13191335f, -0.31221476f, -0.18552074f, 
    0.03928326f, -0.15215965f, -0.07684045f, -0.02767942f, -0.07484110f, 0.04231572f, 0.05272911f, 0.11691598f, 
    0.28899845f, -0.07740601f, -0.08302332f, 0.15970251f, 0.06472459f, -0.17685705f, -0.02708692f, -0.21710098f, 
    0.02343810f, -0.00555840f, 0.02028858f, -0.17462569f, 0.10822782f, 0.01659365f, 0.00645340f, 0.01767623f, 
    0.03132851f, -0.14073123f, 0.12866652f, 0.14248693f, 0.05808648f, -0.06213401f, -0.07854356f, -0.08835317f, 
    0.03253209f, 0.09610106f, -0.02380489f, 0.03164994f, -0.11523205f, 0.05703089f, 0.01286234f, -0.04868967f, 
    -0.03864291f, -0.02234272f, -0.05114984f, -0.12527622f, 0.10750504f, -0.22789420f, -0.08500274f, 0.01614303f, 
    -0.03889402f, 0.01211534f, 0.06529976f, 0.19860138f, 0.02966716f, -0.04231143f, -0.00646784f, 0.10601790f, 
    0.15200983f, 0.03084026f, 0.17758617f, 0.13950473f, 0.06186441f, -0.00659816f, -0.11260881f, -0.02265408f, 
    0.10447653f, -0.25306037f, -0.12220520f, -0.02044769f, 0.28129372f, 0.10525570f, 0.17423934f, -0.08319046f, 
    0.05028307f, -0.02663700f, 0.06704290f, 0.02479185f, 0.08312475f, -0.00082364f, -0.01849160f, 0.00477498f, 
    0.41400412f, 0.21897700f, -0.08030035f, 0.10450622f, -0.14805187f, 0.12167068f, 0.04296002f, -0.06622826f, 
    0.05543751f, 0.04314874f, 0.09585080f, -0.00797054f, 0.10540242f, 0.12993708f, -0.13104531f, -0.11827774f, 
    0.11792589f, -0.02338524f, -0.12861492f, 0.11257088f, 0.07052413f, 0.03463788f, 0.18180880f, 0.04682099f, 
    -0.21769135f, -0.15515839f, 0.08994571f, 0.07847115f, -0.07573161f, -0.00939814f, -0.01459713f, 0.10575747f, 
    0.05842534f, 0.01556798f, -0.04104917f, -0.13233948f, -0.53412062f, -0.18134862f, 0.16601141f, 0.00311493f, 
    -0.01753356f, 0.01336404f, -0.02206622f, 0.02321263f, -0.04818745f, 0.16311641f, 0.11189043f, -0.01268702f, 
    0.11061388f, -0.00723736f, 0.10477505f, -0.08670216f, 0.16183387f, 0.05695241f, 0.05560759f, 0.04925805f, 
    -0.10826674f, 0.07814908f, 0.11623772f, 0.19163617f, -0.01764907f, -0.10494456f, -0.05451269f, 0.12738979f, 
    0.09173236f, 0.05957231f, 0.05465453f, -0.04599454f, 0.09129091f, -0.01195729f, -0.00308780f, -0.11395533f, 
    -0.22414841f, -0.17213789f, -0.13763008f, -0.02443627f, 0.09424696f, 0.13969244f, 0.08214203f, -0.00637273f, 
    0.01400983f, 0.07877747f, 0.04871100f, -0.15289038f, 0.08649212f, 0.00222622f, 0.01196518f, -0.11826251f, 
    0.04773648f, -0.04984398f, 0.02830783f, -0.10834783f, 0.01915359f, -0.02651890f, 0.09968552f, -0.06360474f, 
    0.36209294f, -0.04935911f, 0.26409131f, 0.16317952f, -0.07429156f, 0.10666128f, -0.00287683f, -0.00677441f, 
    -0.02030548f, 0.13777940f, 0.04745014f, 0.03930385f, 0.41983029f, 0.17098853f, 0.19916715f, 0.02174955f, 
    -0.04323918f, 0.01445556f, -0.01254785f, 0.07845839f, 0.05652702f, -0.09005962f, -0.00043133f, -0.01277445f, 
    -0.22433037f, 0.08790605f, -0.20849662f, 0.02614567f, 0.08457562f, 0.12353191f, -0.01920321f, -0.02319141f, 
    0.05183298f, 0.01323424f, -0.04362253f, -0.02436947f, 0.25351095f, -0.06452125f, -0.04484695f, 0.06614891f, 
    -0.02264467f, -0.05835260f, -0.08544976f, 0.08326814f, 0.03542168f, -0.02103909f, 0.11807148f, 0.10955765f, 
    0.33933091f, 0.00082049f, 0.02138296f, 0.00328193f, 0.09008774f, -0.19580773f, 0.02827850f, 0.07928615f, 
    0.08929823f, 0.08850291f, -0.07882195f, -0.10495000f, 0.17919511f, -0.11415774f, 0.02777413f, 0.05995276f, 
    -0.05640539f, -0.12982129f, 0.08921608f, -0.14239296f, -0.18255214f, -0.01434886f, 0.03139323f, 0.02279455f, 
    -0.14201085f, -0.02448181f, -0.08456625f, -0.10254335f, 0.21440415f, 0.00504173f, 0.00697198f, 0.05647133f, 
    0.08278137f, -0.00033291f, -0.10595595f, -0.00236422f, 0.15552853f, 0.09551513f, 0.05001040f, 0.13588664f, 
    -0.04804556f, -0.14873919f, 0.05328953f, 0.05859771f, -0.03293893f, 0.05926358f, 0.03189610f, 0.14506115f, 
    0.00041054f, -0.09402175f, -0.06183262f, -0.00611639f, 0.11334820f, 0.12517941f, 0.01500593f, -0.01266155f, 
    0.06839462f, -0.00151554f, 0.15220819f, 0.02501755f, -0.20169404f, 0.17605028f, -0.12510435f, -0.06003553f, 
    -0.01276808f, 0.06480022f, -0.11282955f, 0.00499356f, 0.09950408f, -0.05680864f, 0.07922607f, 0.03562847f, 
    -0.27834564f, 0.05826199f, -0.08636666f, -0.13171731f, 0.06624237f, -0.10628570f, 0.19482173f, -0.06839788f, 
    -0.00204751f, -0.03670130f, 0.02248563f, -0.08794777f, 0.18979770f, -0.02096845f, 0.14713873f, 0.04755458f, 
    0.09821375f, 0.09140781f, -0.09716243f, 0.09155738f, 0.01329625f, -0.00185165f, -0.00082378f, -0.06271701f, 
    -0.01321667f, -0.13236764f, -0.07571571f, -0.16428141f, 0.06275368f, -0.07079607f, -0.04791039f, -0.07331939f, 
    -0.07543268f, -0.11294130f, -0.01725328f, -0.09719282f, 0.03939165f, -0.01042100f, 0.04307162f, -0.15393315f, 
    -0.15105808f, -0.02383065f, -0.04266431f, -0.02549312f, 0.03897095f, -0.03757506f, -0.10327398f, -0.07733774f, 
    0.22066893f, 0.04893133f, 0.04659490f, 0.33915207f, 0.12524727f, -0.04345746f, 0.00312618f, -0.00493105f, 
    0.02695789f, -0.04756428f, -0.04439710f, -0.06001062f, 0.26959792f, 0.16819388f, 0.09316920f, -0.12053389f, 
    -0.10725742f, -0.08368414f, -0.06236678f, 0.01616773f, -0.11414900f, 0.05033308f, -0.03325577f, -0.01405712f, 
    0.24505633f, 0.04418128f, -0.05606299f, 0.22126721f, -0.10627401f, 0.09214421f, -0.00134871f, 0.00699715f, 
    0.05665510f, 0.02031272f, -0.09717248f, -0.11903305f, -0.30547491f, -0.01383056f, -0.07254522f, -0.09297686f, 
    -0.01576311f, -0.02640354f, -0.13652906f, -0.11681289f, -0.14165302f, -0.07570180f, 0.03255404f, 0.02559677f, 
    -0.11013458f, -0.08267299f, 0.20000155f, -0.12470206f, 0.01059154f, -0.03770255f, -0.00703558f, -0.06576311f, 
    -0.07868856f, -0.00697958f, 0.03601310f, -0.10380209f, 0.32490399f, -0.15814063f, -0.03949221f, -0.06645623f, 
    -0.19547091f, -0.09730736f, 0.17085607f, -0.02579745f, -0.01509640f, -0.11345156f, 0.05936773f, 0.08784714f, 
    -0.07317031f, -0.05655823f, -0.35485289f, 0.10242070f, -0.07900269f, -0.06537686f, 0.11877991f, -0.11328647f, 
    -0.07664219f, -0.02324677f, -0.05343324f, 0.06844949f, -0.08980297f, -0.24340063f, 0.12888116f, -0.00849533f, 
    -0.15684088f, 0.06160864f, 0.01737021f, 0.14263065f, 0.18284428f, -0.01396602f, 0.09766630f, 0.00291610f, 
    0.27332658f, 0.08715484f, 0.04620528f, 0.01918920f, -0.01217223f, 0.06792991f, 0.21371241f, -0.00438330f, 
    -0.03223380f, -0.04731222f, 0.06214727f, 0.04235329f, 0.47476503f, -0.05930117f, 0.07487469f, 0.33617446f, 
    0.00852151f, 0.05692527f, 0.07995402f, -0.03287501f, 0.06265133f, 0.01545799f, -0.08255636f, -0.13184607f, 
    0.18255857f, 0.22537936f, 0.07816821f, -0.20172146f, -0.02729218f, 0.05791953f, 0.06877831f, 0.04095368f, 
    -0.01725036f, -0.16228744f, 0.04708149f, 0.05608277f, 0.34550011f, -0.07563333f, 0.03390312f, 0.17280677f, 
    -0.14848723f, 0.09363066f, -0.13973707f, -0.13432404f, -0.00061439f, 0.08191344f, -0.02101977f, -0.05211645f, 
    0.14767747f, 0.21050867f, 0.15110655f, -0.02690953f, 0.08929479f, -0.01683153f, -0.13172707f, -0.10445308f, 
    0.17184080f, -0.07823132f, 0.05030277f, 0.03704127f, -0.36539724f, -0.26833889f, -0.13921732f, -0.42228162f, 
    -0.02490445f, -0.03149324f, -0.03726388f, 0.07419651f, 0.07442929f, 0.20302799f, 0.09262724f, -0.00519507f, 
    0.07208952f, -0.04181106f, 0.06970262f, -0.15876926f, 0.09217308f, 0.03142701f, 0.06452746f, 0.12093138f, 
    -0.06961668f, 0.03085903f, 0.06347082f, 0.07471898f, 0.03956778f, -0.10239489f, 0.24414957f, -0.03546753f, 
    0.05515284f, -0.02347208f, 0.02496147f, 0.01256891f, 0.10233778f, -0.01947139f, 0.04756502f, 0.00263579f, 
    0.26549560f, 0.12428192f, -0.05173917f, -0.01061398f, 0.08804853f, -0.08079220f, -0.12890260f, 0.06688438f, 
    -0.00135135f, 0.13337091f, 0.11244498f, 0.03427783f, 0.23283418f, -0.14644977f, 0.16904947f, -0.30205929f, 
    0.03215400f, -0.06240046f, -0.03442294f, 0.03555706f, -0.16508290f, 0.02110147f, 0.04376094f, 0.10395812f, 
    -0.06943101f, 0.00918530f, 0.06034632f, 0.21824393f, -0.11581335f, -0.03707202f, 0.06183970f, -0.01219852f, 
    0.01484973f, 0.11492875f, -0.04122900f, 0.04085736f, -0.01821267f, 0.10001689f, 0.16533712f, 0.46506441f, 
    -0.08138462f, 0.14599223f, 0.00934683f, 0.01876984f, -0.06259935f, -0.02855064f, 0.05166801f, -0.09063979f, 
    0.38995260f, 0.27199978f, 0.04371101f, 0.06741581f, -0.01274260f, -0.00501988f, -0.02667155f, 0.04694352f, 
    0.12847221f, 0.03501632f, -0.01857381f, -0.07810835f, -0.17508471f, -0.12990737f, -0.19246775f, -0.00823500f, 
    -0.09496289f, -0.03810917f, 0.03846648f, -0.10509822f, 0.16640474f, -0.00687606f, 0.13049625f, -0.17514966f, 
    0.15754467f, -0.21440868f, 0.04609141f, -0.13638927f, -0.14143877f, 0.05492933f, 0.08842584f, -0.05953677f, 
    -0.04690996f, 0.04795604f, 0.03392638f, 0.10010088f, 0.30426437f, 0.00338479f, 0.13182443f, -0.12663354f, 
    0.01221178f, -0.11323426f, 0.08974646f, 0.04095918f, -0.10156972f, 0.08271972f, 0.13064735f, 0.04105204f, 
    -0.22682130f, -0.12507364f, 0.05473414f, -0.20643243f, -0.13686624f, -0.05742004f, 0.04634160f, -0.15870440f, 
    -0.08542291f, 0.02032010f, -0.05701293f, -0.05717847f, -0.14797300f, -0.12970740f, 0.10075937f, -0.06389824f, 
    0.00396675f, 0.08727527f, 0.04862459f, -0.00409503f, 0.02469359f, 0.01006860f, 0.06889655f, 0.02266805f, 
    -0.09868568f, 0.07361753f, 0.22298068f, -0.07736663f, -0.01319088f, -0.06299859f, 0.00104898f, -0.04391827f, 
    0.01510543f, -0.06934017f, -0.00127243f, 0.06752253f, -0.07707292f, 0.03951050f, -0.10749158f, 0.34080362f, 
    0.06678853f, -0.08116855f, 0.05566758f, -0.04927658f, -0.01966907f, -0.04139839f, -0.04644539f, -0.00049448f, 
    -0.02037474f, 0.01654461f, 0.02881902f, 0.03805290f, -0.04287100f, -0.03185948f, -0.00950261f, -0.01607206f, 
    0.00221421f, 0.03107082f, -0.03193466f, -0.04418841f, -0.03014199f, -0.01806858f, -0.00074373f, 0.00175814f, 
    0.01772333f, -0.01410584f, -0.03000481f, 0.03179457f, 0.03980159f, -0.02335586f, 0.00447603f, -0.00247568f, 
    -0.05220304f, -0.01613092f, -0.01919071f, 0.03921774f, 0.00702959f, -0.03359547f, 0.03646369f, 0.01682188f, 
    0.00956997f, -0.00028883f, 0.03511978f, 0.00899029f, -0.02253613f, -0.01396406f, -0.02357414f, 0.00870536f, 
    -0.01548720f, -0.05790529f, -0.00383378f, -0.01415291f, 0.02661244f, 0.02584632f, -0.01133719f, -0.01933897f, 
    -0.03823825f, -0.03407321f, -0.03119276f, 0.02038178f, 0.05385587f, -0.02170072f, 0.01413055f, 0.00956259f, 
    0.02989686f, 0.02758506f, -0.01516806f, 0.01307472f, 0.00047495f, 0.03383407f, -0.04178778f, -0.05961331f, 
    -0.01073542f, -0.05109515f, -0.01683969f, -0.02014332f, 0.03791561f, -0.00698278f, -0.05079953f, 0.01339165f, 
    0.04613578f, -0.01119441f, 0.02474974f, 0.00124700f, -0.02137334f, -0.05107394f, -0.05666935f, 0.03872963f, 
    -0.01033013f, 0.00134488f, 0.02388022f, -0.04607555f, 0.01180955f, 0.04488382f, 0.00435511f, -0.03895495f, 
    -0.05431191f, -0.01694587f, 0.01071341f, -0.02340983f, -0.04530973f, -0.05628187f, 0.00992170f, -0.03618009f, 
    0.00888450f, -0.02409309f, 0.00925426f, 0.01744635f, -0.01922569f, -0.00651101f, 0.05140195f, -0.05570140f, 
    -0.02460101f, 0.04500616f, -0.00169893f, -0.01131089f, -0.00423051f, -0.00183914f, 0.00854060f, -0.00814289f, 
    -0.01564828f, -0.01513366f, -0.04150742f, -0.02118808f, 0.04139972f, 0.03247827f, 0.01589814f, -0.00043196f, 
    0.01933665f, 0.00323325f, -0.02688276f, -0.03047847f, 0.02586029f, 0.02652354f, -0.04267722f, -0.03929680f, 
    0.00760447f, -0.00380794f, 0.04310615f, 0.02719822f, -0.00293223f, -0.00490185f, 0.01187555f, 0.03817542f, 
    -0.00433172f, -0.00825098f, -0.05117978f, -0.04631118f, 0.03047539f, 0.03405271f, 0.01360670f, -0.02414873f, 
    -0.02546965f, -0.02016221f, -0.04537090f, -0.02831518f, -0.01745318f, 0.03924004f, 0.03635993f, -0.01295468f, 
    0.00643822f, 0.03081101f, 0.02983046f, 0.01134172f, 0.03568308f, 0.01487476f, 0.01924570f, -0.00216694f, 
    0.02414439f, 0.03805428f, 0.00932716f, -0.00820346f, -0.00113995f, -0.05888373f, -0.04559916f, -0.05179940f, 
    -0.00102246f, 0.00740914f, -0.01652724f, -0.00619563f, -0.03513047f, 0.04218970f, 0.02476896f, -0.03035151f, 
    -0.03516665f, 0.00654686f, -0.01807031f, -0.02034829f, 0.03989404f, -0.01438522f, -0.00610966f, 0.02191311f, 
    -0.03199865f, -0.03997848f, -0.02630120f, -0.00040110f, -0.00217286f, -0.04007846f, -0.01106126f, -0.01384686f, 
    -0.04593877f, -0.00655629f, 0.00197962f, -0.01942405f, 0.00206849f, 0.02563415f, 0.01674609f, -0.02417592f, 
    -0.00697224f, 0.03527964f, 0.01600697f, -0.04522952f, -0.04353792f, 0.01975651f, 0.02820580f, -0.03653540f, 
    -0.00109728f, 0.02797613f, -0.04544478f, 0.01978486f, -0.05744939f, 0.00845735f, -0.03255504f, 0.02099654f, 
    0.03079826f, -0.05522259f, -0.03151296f, 0.03409278f, 0.00824090f, 0.02897191f, 0.00253684f, -0.02139824f, 
    0.03193943f, 0.02020613f, 0.02225822f, 0.04478151f, 0.03271978f, -0.02953729f, -0.01152523f, -0.02338731f, 
    -0.01252424f, 0.00954426f, 0.03813576f, -0.00979708f, -0.03470835f, -0.00026633f, -0.05202144f, -0.01748271f, 
    -0.05472444f, 0.02748504f, -0.03063933f, 0.01403522f, -0.02989856f, -0.04956409f, -0.04274751f, -0.01089013f, 
    0.02082970f, -0.00099861f, -0.00880756f, -0.00898754f, -0.01911825f, 0.02253536f, -0.00699201f, -0.04147094f, 
    -0.01111665f, 0.00603118f, -0.03548363f, 0.04962645f, -0.04992751f, 0.03695067f, 0.02047217f, -0.00403694f, 
    0.01671426f, -0.05068959f, -0.00679471f, -0.01751943f, 0.02410237f, -0.03227985f, -0.02273920f, -0.04252224f, 
    0.02318684f, -0.02015846f, -0.00804731f, 0.00557290f, -0.02551342f, -0.03779172f, 0.03285974f, 0.00208475f, 
    0.00869519f, -0.05463743f, -0.04410825f, -0.00207624f, -0.03197262f, -0.00821818f, -0.04884576f, 0.01230698f, 
    -0.03930776f, -0.04878633f, 0.04181211f, 0.03136206f, -0.00114567f, 0.04787999f, 0.02474370f, -0.05201278f, 
    -0.04037563f, 0.04436904f, 0.00860489f, -0.04929516f, 0.01598728f, -0.02034339f, 0.00912744f, -0.02148002f, 
    -0.05518649f, -0.01507123f, -0.02041821f, 0.01894371f, -0.00239736f, 0.02280699f, 0.02459124f, -0.03672534f, 
    -0.04672720f, -0.00585925f, 0.03014364f, -0.01276047f, 0.04681192f, -0.03051803f, -0.01250408f, 0.00048729f, 
    -0.03877916f, -0.05232057f, 0.03193947f, -0.04943307f, -0.00530741f, 0.03402521f, 0.03745127f, -0.00197142f, 
    -0.02404381f, -0.00565268f, -0.03610431f, -0.03417278f, -0.03390349f, 0.02752417f, -0.03424165f, 0.00522148f, 
    0.03561432f, -0.02029580f, -0.05413380f, 0.02500838f, 0.02297776f, 0.00471864f, 0.00773508f, 0.01489320f, 
    -0.03037254f, 0.01674655f, 0.04331049f, 0.00916699f, 0.01088386f, 0.02958746f, 0.00249642f, 0.01968752f, 
    -0.05656729f, -0.03679367f, -0.03077011f, -0.04686040f, -0.02444781f, -0.04642747f, -0.02542938f, -0.00302192f, 
    -0.04551507f, 0.00047463f, 0.04367619f, -0.04242400f, -0.00391515f, 0.02846160f, -0.00279899f, -0.02916342f, 
    0.03475117f, 0.01274895f, 0.01016825f, -0.01182706f, 0.04636813f, -0.00162929f, -0.05192657f, -0.02111628f, 
    0.01709147f, -0.05950081f, -0.04173050f, 0.00792392f, -0.03272659f, -0.03343919f, -0.03985054f, 0.05099600f, 
    -0.09985574f, 0.08436458f, 0.18669423f, 0.15664065f, 0.01823429f, 0.08247063f, 0.03799937f, 0.00240101f, 
    -0.14695378f, -0.09578400f, 0.00295358f, -0.08581610f, 0.01326240f, -0.14432366f, -0.00345436f, -0.10845041f, 
    0.07821243f, 0.13580364f, -0.15655243f, 0.02924071f, 0.11433025f, -0.26734161f, 0.02702879f, 0.09102581f, 
    -0.03443935f, -0.08694087f, -0.10631416f, -0.10106435f, 0.14152098f, 0.04259724f, 0.20011558f, -0.05043818f, 
    0.05315202f, 0.04768009f, 0.08198126f, -0.02003741f, -0.26324525f, 0.00388622f, 0.00638561f, -0.05970636f, 
    -0.06436177f, 0.10143916f, 0.09217671f, 0.02161451f, -0.02573998f, 0.03739093f, -0.06142450f, 0.01972238f, 
    0.20923115f, 0.08037737f, 0.14019054f, 0.01673585f, 0.04764058f, -0.08761146f, 0.01841057f, -0.10888898f, 
    -0.07777178f, 0.06023764f, -0.21515043f, -0.00427512f, 0.08068579f, -0.06106753f, -0.16858578f, -0.11675651f, 
    -0.03148267f, 0.13025235f, 0.00541448f, -0.02305347f, -0.01825804f, -0.03632721f, 0.09382156f, 0.05063308f, 
    0.00001313f, 0.00867703f, 0.30811828f, 0.01697299f, -0.01579784f, 0.12735116f, 0.08602343f, 0.00908174f, 
    -0.02215264f, 0.02162902f, 0.14944106f, 0.12675059f, -0.05725881f, -0.06774651f, -0.07706985f, -0.20722899f, 
    0.06096494f, -0.04943556f, 0.03682356f, 0.00008433f, -0.04900860f, 0.07981320f, 0.02948997f, 0.26586089f, 
    -0.05558138f, 0.14487599f, -0.00378878f, -0.11560430f, 0.13092762f, -0.17179924f, -0.16496779f, -0.19664624f, 
    0.02966987f, -0.01234991f, 0.02975105f, 0.04178425f, 0.24837297f, -0.11732659f, -0.15958938f, 0.06831353f, 
    -0.05717762f, -0.13530961f, 0.02847946f, 0.20691052f, 0.08883243f, -0.01736475f, -0.00111114f, 0.07243577f, 
    -0.15272138f, 0.06391338f, -0.07787807f, 0.10011531f, 0.05349646f, -0.02111332f, 0.10981925f, -0.07863241f, 
    -0.09023445f, -0.02883775f, 0.08708078f, 0.10355406f, -0.15504968f, -0.01974189f, -0.13461116f, -0.10365272f, 
    0.08941893f, -0.00450238f, -0.02553760f, 0.15394780f, 0.15520257f, -0.05517612f, 0.02791454f, 0.09286802f, 
    0.08371019f, -0.06272336f, 0.07652129f, 0.06863081f, -0.08861472f, -0.00250275f, -0.13655393f, 0.03919905f, 
    0.04781589f, -0.13027073f, -0.27130142f, 0.06080279f, 0.28952682f, -0.02771933f, 0.21352066f, 0.17596041f, 
    0.01413414f, 0.15994902f, -0.06418668f, -0.12684445f, 0.10744800f, -0.02092027f, -0.01135784f, -0.01780274f, 
    -0.00565255f, 0.23976877f, 0.02180043f, 0.15663685f, -0.00141304f, 0.05938507f, -0.07543424f, 0.00559139f, 
    0.17933868f, -0.01634843f, -0.04173064f, 0.09852730f, -0.03070282f, -0.13737877f, -0.03295574f, 0.00491565f, 
    -0.07842269f, 0.04593962f, -0.14087421f, 0.03861686f, 0.18258214f, 0.01687589f, 0.01298828f, -0.15356207f, 
    -0.22508325f, 0.06771210f, -0.00492176f, 0.09002027f, -0.02061106f, -0.04528903f, 0.09539878f, -0.04969389f, 
    0.18538533f, -0.17402928f, 0.01049432f, 0.03747443f, -0.23870896f, -0.19849601f, 0.25068104f, 0.08233348f, 
    0.14640300f, -0.13236365f, 0.06408528f, 0.13633306f, -0.05239158f, 0.19320652f, 0.00155112f, -0.00364811f, 
    0.08686373f, 0.03509750f, 0.13481875f, -0.02395567f, 0.03461207f, 0.12842578f, 0.11581986f, 0.13172941f, 
    -0.10347662f, 0.19381768f, 0.12117008f, 0.35209444f, -0.18780553f, -0.03973192f, 0.01685421f, 0.12585151f, 
    -0.01024349f, 0.07692765f, 0.12606266f, 0.08359811f, 0.09503806f, 0.03843417f, 0.06678770f, -0.08367071f, 
    -0.45718202f, 0.13162540f, -0.18964276f, -0.00839063f, 0.02952143f, -0.09700026f, -0.00036419f, -0.07151702f, 
    0.00779175f, 0.02332616f, 0.01554325f, -0.14753203f, 0.04825253f, -0.14604399f, 0.18339868f, -0.20172817f, 
    -0.01895193f, 0.22964528f, -0.04415689f, -0.08263449f, 0.09256569f, -0.20407827f, -0.05418205f, 0.03152706f, 
    -0.24749549f, -0.02527149f, 0.28228837f, 0.06960212f, -0.02995203f, 0.14817165f, 0.06814668f, 0.04064535f, 
    0.10775685f, 0.10214035f, 0.16866207f, 0.15617171f, -0.05349464f, -0.00741143f, 0.15382123f, 0.28644258f, 
    0.11719108f, 0.11025198f, -0.00272011f, 0.01917122f, -0.01423788f, -0.13199097f, -0.05391639f, -0.12053806f, 
    -0.01708701f, 0.04815136f, -0.24072818f, -0.03185073f, 0.08272322f, 0.11905886f, -0.09725045f, -0.21516016f, 
    0.06215506f, -0.03257135f, -0.06884690f, -0.02062440f, 0.00287507f, 0.03311646f, 0.03672165f, 0.01927713f, 
    0.04635859f, -0.10872696f, 0.01246902f, 0.09748915f, -0.00608233f, -0.01540922f, 0.08832385f, 0.03116319f, 
    0.23462458f, -0.10973041f, -0.08071423f, -0.00398608f, 0.00712208f, 0.01234868f, 0.09731137f, 0.03471893f, 
    0.07869498f, 0.15835281f, 0.01743804f, 0.08061050f, -0.01455155f, 0.01202702f, -0.19662514f, -0.05357774f, 
    -0.08593004f, -0.06207240f, 0.03795875f, -0.07968371f, -0.07279848f, 0.02849285f, 0.09868735f, 0.14532195f, 
    -0.12017771f, -0.14799458f, 0.01753017f, -0.04105983f, 0.01257928f, 0.13691044f, 0.11865050f, -0.00982463f, 
    -0.05778472f, 0.00526555f, -0.17273496f, -0.10911305f, 0.01205378f, -0.10068079f, 0.18693632f, 0.10403554f, 
    0.01893382f, 0.00682846f, 0.16574952f, 0.04603747f, -0.01016195f, 0.00939371f, 0.02614364f, 0.06674162f, 
    -0.16644733f, 0.08307720f, 0.01100548f, -0.01971401f, 0.00722572f, 0.06665043f, 0.07350606f, -0.03749771f, 
    0.05662084f, 0.05552707f, 0.23750973f, 0.05881675f, 0.00646148f, -0.07499186f, -0.05036445f, 0.08165772f, 
    0.07055385f, -0.09997986f, -0.04110857f, -0.03965617f, -0.09764997f, -0.01696165f, 0.03255433f, 0.12257025f, 
    -0.04603356f, 0.00688643f, 0.02239488f, -0.02100438f, -0.02375544f, 0.01831332f, 0.02410440f, -0.03742099f, 
    0.00738010f, 0.00049427f, -0.04352582f, -0.03703329f, 0.01235958f, 0.00422170f, -0.05180289f, 0.00349922f, 
    0.02603739f, 0.00250429f, 0.02228679f, -0.00251868f, 0.04709275f, 0.02758308f, -0.05029907f, -0.00112580f, 
    0.03313429f, -0.02052250f, 0.04642222f, -0.00587838f, -0.04221972f, -0.01526114f, 0.02190832f, 0.04264949f, 
    0.03441537f, 0.04723091f, -0.02705597f, 0.03619544f, -0.04401535f, 0.03903199f, 0.04328416f, -0.01185268f, 
    0.01869944f, -0.02594894f, 0.05335759f, -0.03338342f, 0.02983189f, -0.00433223f, -0.05667624f, -0.01718773f, 
    -0.02434329f, -0.00756756f, 0.02049720f, 0.00124828f, -0.01687664f, 0.04071204f, -0.04275073f, -0.03157326f, 
    0.03109141f, 0.03406102f, -0.03897737f, 0.02221209f, 0.04177853f, 0.02556131f, -0.01311810f, -0.05435391f, 
    0.03988193f, -0.05094467f, 0.00126234f, 0.03647769f, -0.01391622f, -0.01878432f, -0.00702697f, -0.04623159f, 
    -0.01795437f, 0.04912435f, -0.00012615f, -0.04819451f, -0.04313701f, 0.01350846f, -0.04964666f, -0.00752821f, 
    0.00792823f, -0.05122668f, 0.00020264f, -0.00336195f, -0.02899988f, -0.02499941f, 0.01695691f, 0.00666992f, 
    -0.00077080f, 0.03264201f, -0.03609981f, 0.00396556f, 0.03263480f, -0.00924194f, 0.00845186f, -0.00778477f, 
    0.04143625f, -0.03248532f, -0.04651086f, 0.01088336f, 0.00012548f, -0.04234225f, 0.03660307f, 0.00811981f, 
    -0.04272404f, 0.04279657f, -0.02050721f, -0.03822801f, 0.01339902f, 0.00995470f, 0.00697302f, -0.00166132f, 
    -0.01257968f, -0.01504051f, 0.02570317f, -0.00910553f, -0.05012862f, -0.00967926f, -0.05173050f, 0.05055103f, 
    -0.01527457f, -0.00431517f, -0.04530880f, 0.00916211f, -0.01296231f, -0.00905839f, 0.02237567f, 0.04725156f, 
    -0.01909146f, -0.03484222f, 0.02065906f, 0.00140996f, -0.00394583f, -0.02386789f, -0.03726009f, -0.04550238f, 
    0.00263225f, 0.04122725f, -0.02011262f, -0.03479426f, 0.01136333f, 0.03190279f, 0.01663392f, -0.00308557f, 
    0.00883218f, 0.02531039f, -0.04785214f, -0.04327660f, 0.03720627f, -0.04238613f, 0.03876510f, 0.03386547f, 
    0.00359639f, -0.01125265f, -0.02502849f, -0.03291725f, 0.02609798f, 0.04050956f, -0.00601486f, -0.00077323f, 
    0.03681131f, 0.04434554f, -0.01242747f, 0.01955172f, 0.00676664f, -0.05436699f, -0.02412493f, 0.00744428f, 
    0.02432853f, 0.00286835f, -0.05201746f, 0.05144269f, -0.06079164f, -0.03776321f, -0.03911783f, 0.02459620f, 
    0.02659370f, 0.04120966f, -0.03137296f, -0.00281086f, 0.01034779f, 0.00101610f, 0.02284996f, -0.02308453f, 
    -0.03488360f, -0.01532911f, -0.03202258f, -0.00741989f, -0.04698582f, 0.03582275f, -0.00242128f, -0.03480260f, 
    0.00757948f, 0.01997544f, 0.02083895f, -0.04720080f, -0.03918748f, -0.03808664f, 0.00709829f, 0.03000809f, 
    -0.02416349f, -0.00126645f, -0.04596040f, -0.05470737f, -0.03295518f, 0.04408437f, -0.04361194f, 0.01542270f, 
    0.04060724f, -0.00122537f, -0.00741905f, -0.05643658f, 0.02575224f, -0.01309209f, 0.00966125f, 0.03409239f, 
    -0.03283121f, -0.04508477f, 0.00690119f, 0.01934322f, 0.04039845f, 0.04637916f, 0.00455349f, -0.01002312f, 
    0.03264635f, -0.04381756f, -0.04545351f, 0.00028348f, -0.02011896f, 0.03268785f, 0.03354144f, 0.04223619f, 
    -0.01381842f, -0.05138657f, -0.05190118f, -0.02380472f, -0.04361859f, -0.02186490f, -0.00606351f, 0.03791924f, 
    -0.02089303f, -0.01589069f, 0.02099380f, 0.03434015f, -0.03658058f, 0.03042621f, -0.01402379f, -0.03844975f, 
    -0.00443098f, -0.05071213f, 0.02514562f, 0.01633356f, 0.00926187f, -0.05675735f, -0.02658411f, 0.00086434f, 
    -0.02358199f, -0.04673999f, -0.02219419f, -0.04715772f, 0.01162117f, 0.03993842f, 0.02958616f, 0.00944132f, 
    0.04571586f, 0.02944244f, -0.03142263f, -0.05222915f, -0.04206854f, -0.03270412f, 0.03108523f, 0.01463682f, 
    -0.01462188f, -0.00048814f, 0.01244914f, 0.02525106f, -0.04003680f, -0.00674705f, -0.01944668f, 0.02572200f, 
    0.00679984f, 0.03966591f, -0.00860382f, 0.04193573f, 0.00650710f, 0.00380440f, -0.00342688f, -0.02640375f, 
    -0.04079393f, -0.01228849f, -0.03574867f, 0.01130783f, -0.05208203f, 0.00464611f, -0.04960054f, 0.00809852f, 
    -0.02282836f, 0.00104790f, -0.05505049f, -0.02587795f, -0.02872319f, -0.01219540f, -0.01831738f, 0.04464380f, 
    -0.04507330f, 0.03093270f, 0.00188221f, -0.01140169f, -0.04560868f, -0.03635052f, 0.01447538f, 0.03967066f, 
    -0.00186043f, -0.04995242f, 0.00491034f, -0.02168621f, 0.03368876f, -0.03258473f, 0.03996657f, -0.02406336f, 
    0.04016873f, 0.01201824f, -0.01298082f, 0.03349977f, 0.01494620f, -0.03592002f, -0.04685082f, 0.01069579f, 
    -0.01853640f, 0.03272445f, 0.01199771f, -0.00763433f, -0.04909971f, -0.00132121f, 0.00617956f, -0.00188106f, 
    -0.05087678f, 0.02333402f, 0.03420570f, -0.04483729f, 0.03736061f, -0.04256761f, -0.02373574f, -0.04795897f, 
    0.00294628f, -0.00927654f, -0.03129537f, -0.02840145f, -0.01280822f, -0.00521905f, 0.01363581f, 0.00699132f, 
    0.03525295f, -0.03137821f, 0.01390850f, 0.03690135f, -0.04557046f, 0.03695906f, -0.05087299f, -0.05227334f, 
    -0.05473417f, -0.01407977f, -0.03470635f, -0.00381375f, -0.03438067f, -0.02659100f, -0.05041352f, -0.01602403f, 
    0.00558626f, -0.03792962f, 0.04888457f, -0.00005772f, -0.05211136f, -0.01247275f, -0.00240767f, -0.01602842f, 
    -0.00407394f, -0.02473127f, -0.04636518f, 0.01243521f, 0.03997930f, -0.05190307f, -0.03730068f, 0.03486674f, 
    0.01539194f, -0.13760561f, 0.03996080f, 0.25811613f, 0.09062538f, 0.12872227f, -0.03277984f, 0.17237537f, 
    0.05538402f, 0.03645923f, -0.06089912f, 0.07326637f, -0.05334759f, -0.12282333f, 0.13210997f, -0.11393651f, 
    -0.15565902f, -0.06553900f, -0.04174289f, 0.17411229f, 0.11592860f, -0.03676053f, 0.15678692f, 0.05967572f, 
    0.18562591f, 0.05016156f, -0.01547013f, 0.26233459f, 0.09942147f, 0.02300962f, -0.01293452f, 0.13622475f, 
    -0.03089839f, 0.15913269f, 0.05683991f, 0.08836749f, 0.37401754f, 0.00951961f, -0.05217572f, 0.25799134f, 
    0.23698263f, 0.09297238f, 0.13685508f, -0.01577362f, 0.07552282f, 0.06152694f, 0.11853167f, 0.01579889f, 
    -0.01484208f, 0.14198114f, 0.00469024f, -0.27425697f, 0.05676144f, 0.03600970f, -0.06472115f, -0.09338780f, 
    0.04236971f, 0.09008779f, -0.09366009f, 0.09168045f, 0.17882632f, -0.10940134f, 0.05964724f, 0.05441936f, 
    -0.08301264f, 0.04613682f, -0.04662558f, 0.07310615f, 0.18089844f, -0.06224188f, 0.10165740f, -0.01949654f, 
    -0.08794167f, 0.04517316f, 0.01618005f, -0.30333447f, 0.13747185f, 0.14473800f, 0.11179248f, 0.05549647f, 
    -0.08696564f, 0.00250911f, 0.14687355f, 0.15281811f, 0.38524723f, 0.00385871f, 0.07505906f, -0.01341787f, 
    0.11259960f, 0.08255599f, 0.02825328f, 0.01547751f, -0.00451930f, 0.06222051f, 0.05032718f, 0.06671388f, 
    -0.22614273f, 0.12916675f, -0.11224689f, -0.18389170f, 0.01376632f, 0.00602578f, 0.10322201f, 0.00000597f, 
    0.07490675f, -0.00471673f, -0.00528382f, 0.06040032f, 0.37461492f, 0.11371058f, -0.14340891f, 0.05842410f, 
    0.07875212f, -0.00700467f, -0.05500541f, 0.20487617f, 0.06820729f, -0.06885151f, -0.03608869f, 0.03824214f, 
    0.10642771f, -0.07866558f, 0.08400110f, -0.01180897f, 0.17566074f, 0.05827781f, 0.14546944f, 0.14783153f, 
    0.09220618f, -0.00787451f, 0.27182367f, -0.06645037f, -0.08415338f, 0.09232853f, -0.04987802f, -0.17724063f, 
    0.13356830f, -0.04640905f, 0.06371101f, -0.06496035f, -0.09092098f, 0.06489962f, 0.00328840f, 0.07945356f, 
    -0.04934121f, 0.29824090f, 0.00994976f, 0.21649328f, -0.00582318f, 0.01256833f, -0.16358477f, 0.11273274f, 
    0.11939792f, 0.05495579f, -0.09359799f, 0.09078795f, -0.20127188f, 0.09230011f, 0.10439844f, -0.18336020f, 
    0.19397354f, 0.17610984f, 0.03510123f, -0.13439436f, 0.08875415f, -0.11803856f, 0.07197095f, 0.00318081f, 
    0.08897210f, -0.04007903f, -0.14247571f, 0.31896070f, 0.08404184f, 0.15125377f, -0.08251175f, 0.07445249f, 
    0.04012852f, 0.11537541f, 0.10188819f, 0.16288851f, 0.54095268f, -0.06637943f, 0.04540752f, -0.31536645f, 
    0.15647413f, -0.01507909f, 0.02113456f, 0.06048935f, 0.14084308f, -0.03945161f, 0.11485131f, -0.10638715f, 
    -0.13331228f, -0.17285953f, 0.10202978f, 0.17982842f, -0.18243311f, 0.05450271f, 0.23473200f, 0.00025429f, 
    -0.05155183f, 0.02409394f, 0.10184433f, 0.10168278f, -0.07669725f, -0.20987447f, 0.31478783f, 0.54048771f, 
    0.07838372f, 0.02022058f, -0.03030886f, 0.13124757f, 0.00732110f, 0.05252366f, 0.06380223f, 0.00465118f, 
    0.05737136f, -0.10664155f, -0.02371330f, 0.01087177f, -0.05287598f, 0.02094832f, -0.01149077f, -0.00763965f, 
    -0.04543008f, 0.17339660f, 0.07313560f, 0.16003004f, -0.16151284f, 0.21098883f, 0.07654895f, -0.03663901f, 
    -0.08922499f, 0.11824954f, 0.00290794f, -0.00795484f, 0.04502428f, -0.04994460f, 0.04034915f, 0.02393843f, 
    0.02524827f, -0.04986641f, -0.03441463f, -0.03214061f, -0.02098976f, 0.09092905f, -0.05174246f, 0.00728471f, 
    0.03078315f, 0.00351593f, -0.01318584f, -0.01751660f, -0.22020708f, 0.31462756f, -0.00487366f, 0.28448913f, 
    -0.04453254f, 0.23197794f, -0.04257797f, 0.07720181f, 0.23478022f, -0.00651199f, -0.03124546f, 0.05699414f, 
    -0.20959987f, -0.00209383f, -0.07252830f, -0.16222771f, 0.23733199f, 0.15707365f, -0.07326883f, -0.10417027f, 
    0.04402623f, -0.03207130f, 0.11409075f, -0.04780712f, 0.23991205f, 0.00375551f, 0.08272052f, -0.22151786f, 
    0.28266886f, 0.11252656f, 0.10264430f, -0.09343927f, 0.13458301f, -0.04122855f, 0.06230376f, 0.07709785f, 
    0.23618490f, -0.18410678f, -0.08377563f, -0.12608203f, -0.02713558f, 0.02961810f, -0.00547202f, -0.13975330f, 
    0.10976779f, -0.12369209f, -0.03324674f, -0.05636929f, 0.34249339f, 0.23574248f, 0.24843216f, -0.15924118f, 
    0.25327724f, 0.03951432f, 0.05375227f, 0.19948129f, -0.08371369f, -0.08126879f, 0.03388637f, 0.16297390f, 
    -0.21180081f, 0.18086413f, -0.05069011f, 0.23321728f, 0.07046553f, 0.03576908f, 0.05503159f, 0.13041796f, 
    0.07896924f, 0.07062572f, 0.01415693f, 0.09582686f, -0.22638394f, 0.20630720f, -0.06919651f, 0.22960937f, 
    -0.05751631f, 0.05423556f, 0.04425464f, 0.11295739f, 0.13782586f, 0.01070982f, 0.00922754f, -0.04194648f, 
    -0.00552602f, 0.01064792f, 0.02774603f, 0.17266250f, 0.15759355f, -0.06074730f, 0.07910245f, 0.19690904f, 
    0.15510651f, 0.10949952f, -0.04417058f, 0.13852714f, 0.08421431f, 0.16885383f, -0.06246350f, -0.21168871f, 
    0.20778967f, 0.13401458f, 0.07922036f, 0.12396706f, -0.01671236f, -0.08924797f, 0.05692906f, 0.07923210f, 
    0.06959945f, 0.13073038f, -0.18685569f, -0.02547743f, -0.00170258f, 0.00367636f, -0.05846605f, 0.00519585f, 
    0.06845427f, 0.11353338f, 0.07356237f, 0.07617078f, -0.02070362f, 0.01809958f, 0.16553469f, -0.37989539f, 
    0.24799012f, 0.04937248f, 0.01807806f, 0.04193882f, 0.04777716f, 0.07197044f, 0.06702533f, 0.12363242f, 
    -0.25815704f, 0.22275783f, 0.07554048f, -0.01775469f, 0.20093022f, -0.11958971f, 0.08212728f, 0.01319758f, 
    -0.00914702f, -0.07685217f, -0.16651216f, -0.06079892f, 0.27348721f, 0.09498528f, -0.01680302f, -0.21607541f, 
    -0.01412393f, 0.07257186f, -0.07344740f, 0.18063898f, 0.20021082f, -0.08091725f, -0.02724958f, 0.11660290f, 
    0.19441752f, 0.07044976f, -0.12622225f, 0.17233537f, -0.00356251f, -0.07384803f, 0.06166467f, 0.07392233f, 
    0.09774225f, 0.06617872f, -0.06970119f, -0.00882124f, -0.08324359f, -0.05650676f, 0.08552885f, -0.00288459f, 
    -0.07386425f, 0.10163381f, 0.04705181f, 0.03896928f, 0.05626388f, 0.02608900f, 0.06544936f, -0.04257031f, 
    -0.40435010f, -0.14855295f, -0.10245656f, 0.04888665f, -0.06261632f, -0.20326519f, -0.10188070f, -0.04601685f, 
    -0.03326199f, -0.05504670f, -0.11470539f, 0.03981458f, 0.27320370f, 0.19376895f, 0.03448861f, -0.11434916f, 
    -0.20127033f, -0.05160023f, -0.01117431f, 0.00569930f, -0.01906533f, 0.18878070f, 0.00461221f, 0.05713627f, 
    -0.16887948f, 0.12007540f, -0.03057618f, -0.03436630f, 0.00145141f, 0.00477737f, 0.01137934f, 0.09932042f, 
    0.03896885f, 0.08191863f, 0.07683599f, 0.04557268f, -0.18287130f, 0.36876786f, 0.14997655f, -0.08415191f, 
    0.12352870f, 0.11175465f, -0.07491159f, 0.07151755f, -0.08214734f, -0.05554519f, 0.09838247f, 0.10556252f, 
    -0.20823553f, -0.01623736f, 0.07857950f, -0.32023796f, -0.04428937f, 0.06685574f, -0.01141767f, -0.04913494f, 
    0.02996833f, -0.09844272f, -0.04183003f, 0.12037542f, -0.02313443f, -0.20707855f, -0.22484182f, -0.15496802f, 
    0.04753883f, 0.05998337f, 0.04850708f, -0.02140843f, 0.08415402f, -0.04046872f, 0.08030437f, 0.02694522f, 
    -0.26312292f, 0.07343678f, 0.00199347f, 0.11055809f, 0.07142468f, 0.01728364f, 0.11353645f, -0.00554925f, 
    0.00378959f, 0.09797621f, 0.21178839f, 0.09456985f, 0.03277948f, 0.09916694f, 0.21288714f, -0.03154698f, 
    0.11963157f, 0.02193821f, 0.12626839f, -0.10308200f, 0.02726794f, -0.09248442f, -0.02037952f, 0.08890981f, 
    -0.05812566f, -0.00552260f, -0.16946027f, -0.05885577f, -0.23302393f, -0.04656165f, 0.07072677f, 0.02335485f, 
    -0.08529662f, 0.11204258f, -0.06987495f, 0.10621405f, -0.10811657f, -0.25499055f, -0.09913777f, 0.17686276f, 
    -0.05574814f, 0.12383803f, -0.03922256f, -0.12895863f, 0.03550299f, -0.06758927f, 0.12215336f, -0.00073710f, 
    -0.56409299f, 0.23176280f, -0.06489550f, -0.35791263f, 0.06701007f, -0.04416867f, -0.01920049f, 0.13273792f, 
    0.09392669f, -0.12906194f, -0.08079432f, 0.07958863f, 0.31502771f, -0.20722204f, 0.06073407f, 0.32712039f, 
    -0.07120135f, 0.08817106f, 0.01771943f, -0.02514279f, 0.06456913f, 0.04683539f, -0.13016582f, -0.06273540f, 
    0.08790663f, 0.05042766f, -0.11457356f, 0.03214848f, -0.06465878f, -0.06364843f, -0.10166151f, -0.10351258f, 
    0.12437215f, -0.00138973f, 0.01313789f, 0.16873641f, 0.18993387f, -0.09172693f, 0.10026252f, 0.03030547f, 
    0.12594765f, 0.06894647f, 0.14918964f, 0.07923669f, 0.06691772f, 0.04358501f, -0.00287155f, 0.09123353f, 
    0.05020507f, -0.00546690f, -0.08764011f, -0.01666589f, -0.08071547f, -0.01115105f, 0.10846451f, 0.12444729f, 
    -0.01576952f, 0.05876972f, -0.02495638f, 0.06676400f, -0.01533939f, 0.15017965f, -0.00311994f, -0.26038787f, 
    -0.09705482f, -0.04615570f, 0.08346051f, 0.00917749f, -0.02275197f, 0.10572546f, 0.08833370f, -0.01991752f, 
    0.35918155f, 0.24547799f, -0.10873836f, -0.00159322f, -0.09063035f, -0.14263529f, -0.07053310f, -0.01734180f, 
    -0.00160577f, 0.06795993f, -0.04568881f, 0.00503173f, -0.04352637f, -0.10628301f, 0.18095933f, -0.24267887f, 
    0.11205110f, 0.09833453f, 0.00957720f, 0.06325306f, 0.00057109f, -0.14870253f, 0.01030075f, -0.00253670f, 
    -0.31735229f, -0.09257264f, -0.11776897f, -0.08916929f, -0.03987613f, -0.05360945f, 0.02870511f, 0.04929308f, 
    0.11837623f, 0.05369524f, 0.04623585f, 0.08597831f, -0.26472339f, 0.01616138f, -0.07007698f, 0.26499352f, 
    -0.02545186f, -0.06149392f, 0.00401861f, -0.01725324f, -0.02172624f, 0.03178960f, 0.11762851f, 0.01364149f, 
    0.43589690f, -0.00356692f, -0.08015069f, -0.23941275f, -0.20067671f, 0.00108077f, -0.04282526f, -0.01051635f, 
    0.14324544f, -0.06724934f, -0.14818916f, 0.01362119f, -0.28547657f, 0.37049803f, 0.06280613f, 0.08991910f, 
    0.06244403f, 0.01548556f, 0.09270316f, -0.01239371f, 0.03087565f, 0.20751506f, 0.05380042f, -0.01613919f, 
    -0.12157732f, -0.26449141f, -0.06560802f, -0.09478765f, 0.03148934f, 0.15661766f, 0.04963921f, 0.08508114f, 
    -0.05838578f, -0.07673431f, 0.21704079f, 0.20525891f, -0.18147340f, -0.08918804f, -0.19990987f, -0.11951405f, 
    0.02210410f, -0.02272973f, 0.06572547f, 0.11550833f, 0.12104030f, 0.04188786f, 0.07599593f, 0.15446931f, 
    -0.12896134f, -0.25903854f, 0.10692059f, -0.05777176f, -0.12153529f, 0.00465513f, 0.10186294f, -0.13763662f, 
    -0.06630167f, 0.07485478f, 0.03340028f, 0.03290426f, 0.04583730f, 0.08374787f, 0.40679368f, -0.01901478f, 
    0.15521008f, 0.28836444f, 0.12211212f, 0.02243054f, 0.10746194f, -0.05731985f, 0.10776263f, -0.01704437f, 
    0.07826898f, 0.09595482f, 0.03562415f, -0.07890236f, -0.04822757f, -0.08470640f, 0.00683644f, -0.01953467f, 
    0.00582808f, 0.18503158f, 0.05855966f, -0.06362018f, -0.19095239f, -0.19870621f, -0.00975978f, 0.22476600f, 
    0.02188549f, -0.05662671f, 0.05866645f, -0.00941628f, -0.09060989f, 0.06104787f, -0.14031151f, 0.10671031f, 
    0.04017559f, 0.00864871f, 0.02183595f, -0.00556398f, 0.00771950f, 0.02879172f, -0.04292629f, -0.05138241f, 
    -0.04655648f, -0.04264978f, 0.00040461f, 0.01105386f, 0.00732823f, -0.04827610f, -0.05852621f, -0.04390639f, 
    0.02747159f, -0.04025413f, 0.01348399f, 0.02153913f, -0.03709122f, 0.00116503f, -0.03789660f, 0.02272981f, 
    -0.04125400f, -0.05041447f, -0.03835336f, -0.00108618f, -0.02183978f, -0.05047120f, 0.00012702f, -0.02785291f, 
    -0.01874161f, -0.00819717f, 0.03982100f, -0.02046903f, 0.02384931f, 0.03429899f, -0.03265551f, -0.01113524f, 
    0.01996813f, -0.00929113f, -0.03050905f, -0.03448649f, -0.00070272f, -0.01817361f, 0.00837467f, 0.02993733f, 
    -0.04941239f, -0.01284751f, 0.02219422f, -0.01162109f, 0.01726270f, -0.01031903f, -0.00655419f, 0.04043543f, 
    -0.01181655f, 0.03798148f, 0.00535865f, -0.05141276f, 0.03729113f, -0.05165987f, 0.03753838f, -0.02456556f, 
    -0.00738585f, -0.00198878f, 0.01833714f, 0.04101393f, 0.02927767f, -0.03425396f, -0.02310888f, -0.04676978f, 
    -0.04234183f, -0.05750208f, 0.04285642f, 0.03193932f, -0.04457891f, -0.04339169f, -0.01543646f, -0.00549855f, 
    0.00610229f, 0.00519167f, -0.00228422f, 0.02668034f, -0.00320091f, 0.02246201f, 0.01332018f, -0.01564307f, 
    -0.01829759f, 0.00878059f, -0.04985064f, 0.04309853f, 0.00759040f, -0.05098159f, 0.02673220f, 0.02870172f, 
    0.03365970f, 0.01192632f, -0.02453617f, 0.02492502f, -0.00220926f, -0.02787109f, 0.03287441f, -0.02345237f, 
    0.01181888f, 0.03655867f, -0.02614888f, -0.04932036f, 0.03260156f, 0.01801003f, -0.02069525f, 0.01397214f, 
    0.01334113f, -0.03051675f, -0.01508826f, -0.05988455f, 0.03486681f, 0.04178208f, -0.01113579f, 0.03475182f, 
    -0.04869526f, 0.03044525f, -0.02505820f, -0.05358250f, 0.00951063f, 0.01620329f, 0.02743738f, -0.01821806f, 
    -0.01770440f, -0.03999058f, -0.05004888f, -0.03702103f, -0.04417101f, -0.00953498f, -0.00680550f, 0.02273891f, 
    -0.04586142f, 0.03254915f, 0.02366347f, -0.04606475f, -0.04097325f, 0.03018289f, 0.03941560f, 0.02358370f, 
    0.01794210f, -0.03898415f, 0.02842697f, 0.01770603f, -0.00563086f, -0.02754314f, 0.03302342f, -0.05477356f, 
    0.00587852f, -0.04927885f, 0.03719667f, -0.00663287f, -0.02177224f, -0.04053761f, 0.02745045f, -0.00424747f, 
    0.01774893f, -0.04889257f, 0.01794426f, 0.00416219f, -0.05448833f, 0.04058664f, -0.03954260f, 0.01354023f, 
    -0.01687686f, -0.04685025f, -0.03746162f, 0.02688528f, 0.03608153f, -0.00102255f, -0.05820077f, -0.04712832f, 
    0.02540817f, -0.00768320f, 0.01877326f, 0.03056428f, 0.01977306f, -0.05847096f, 0.04558836f, -0.05724733f, 
    0.04128088f, -0.00003956f, -0.00544164f, -0.02703073f, -0.03237030f, 0.03697037f, 0.01453919f, -0.01671491f, 
    0.02841162f, 0.02028422f, 0.02421598f, -0.04494943f, 0.03739404f, 0.00828143f, -0.03333909f, -0.05050554f, 
    -0.01331781f, 0.01891916f, 0.00635045f, -0.01454233f, -0.04264977f, 0.02180536f, -0.02136185f, -0.03229976f, 
    0.00445630f, -0.03250138f, 0.04668560f, 0.02133037f, -0.02713293f, 0.04585803f, -0.01639001f, 0.03356184f, 
    -0.05104359f, 0.03399302f, 0.04275195f, -0.00328298f, -0.03108416f, 0.01749001f, -0.00861697f, 0.03939121f, 
    -0.02019690f, -0.03266567f, -0.04234366f, 0.00830572f, -0.03005079f, -0.03192368f, 0.03844267f, -0.02165376f, 
    0.01394085f, -0.01575952f, -0.03929331f, 0.02293923f, -0.05363060f, -0.02733489f, 0.04161876f, -0.02039406f, 
    0.01901352f, -0.05145148f, 0.00179685f, -0.04489505f, -0.02453036f, 0.03128946f, 0.02227239f, -0.04195945f, 
    -0.03590360f, 0.02857837f, 0.03641643f, 0.05018169f, 0.04044931f, -0.02776608f, -0.04223986f, 0.01918483f, 
    -0.04360570f, -0.01998066f, 0.04730170f, -0.05058502f, 0.02845281f, 0.01508007f, -0.02675628f, 0.02737036f, 
    -0.01288248f, 0.03487474f, 0.01683229f, 0.04302951f, 0.03422480f, -0.00349297f, 0.03735872f, -0.05224819f, 
    0.04563140f, -0.03451517f, -0.05258677f, 0.02152311f, 0.03193932f, -0.05707436f, -0.03679242f, 0.01757310f, 
    -0.00690176f, 0.03773810f, 0.01914829f, -0.02441477f, -0.00611919f, 0.04147590f, 0.02253434f, -0.04453564f, 
    0.00974289f, 0.03075773f, 0.00351062f, 0.03799758f, 0.04154516f, 0.00845949f, -0.04138710f, 0.02972719f, 
    -0.02961880f, -0.03344818f, -0.03300131f, -0.00680232f, -0.05133523f, -0.02708322f, -0.00771947f, -0.05082748f, 
    0.03691107f, 0.02091785f, -0.00631348f, 0.01839124f, 0.00624764f, -0.05317408f, -0.03632748f, -0.04342728f, 
    -0.00713006f, -0.03720271f, -0.03772481f, -0.04802270f, -0.03722427f, -0.03615457f, 0.00851164f, 0.00720592f, 
    -0.03627253f, -0.00563022f, 0.04284255f, 0.02101765f, -0.04708601f, 0.00221815f, 0.01530420f, 0.02989299f, 
    0.02288648f, 0.00678446f, -0.01851161f, 0.02173227f, -0.00201021f, -0.02289760f, -0.03694469f, -0.05607328f, 
    0.03216913f, -0.00909852f, 0.01024314f, -0.02312594f, -0.02304087f, -0.04933285f, 0.01096243f, 0.00196856f, 
    -0.03082501f, -0.02827763f, -0.00891456f, 0.03178811f, 0.02834365f, -0.04462169f, 0.01414450f, 0.01260345f, 
    -0.00511937f, 0.03799718f, 0.03647909f, -0.02888838f, 0.00024832f, -0.03529285f, -0.01343184f, 0.00054096f, 
    -0.01148204f, -0.02833328f, 0.00441542f, -0.01497270f, 0.02878404f, -0.02151045f, 0.00919960f, -0.00249199f, 
    0.00955935f, -0.00680448f, 0.04164749f, 0.02537104f, -0.01530909f, 0.02671529f, 0.04432175f, 0.03538567f, 
    -0.02311812f, -0.00866971f, 0.03564934f, 0.01136311f, -0.00188370f, 0.00919103f, -0.02511322f, 0.02617843f, 
    -0.04489294f, 0.01509703f, 0.00613745f, -0.02756650f, -0.04446113f, -0.02352520f, -0.00707229f, -0.02780489f, 
    -0.00711989f, -0.04610687f, 0.01872347f, 0.00530524f, 0.01801849f, -0.02916266f, -0.04726101f, -0.04780285f, 
    -0.04388632f, -0.01751853f, -0.01313179f, -0.03473030f, -0.02628081f, -0.01677712f, -0.00590212f, -0.03828808f, 
    0.00526562f, -0.03549089f, 0.00246596f, -0.00457938f, 0.02491998f, 0.02991234f, -0.00261196f, -0.02815548f, 
    -0.04141610f, 0.02368899f, -0.00076070f, -0.04323609f, -0.01092817f, 0.04600237f, -0.01698456f, 0.01809098f, 
    0.00715972f, -0.00196154f, -0.04939023f, 0.02856150f, 0.00880026f, -0.04888610f, 0.00559450f, -0.02830313f, 
    0.01173730f, -0.00982822f, -0.00024709f, 0.00525828f, -0.01034813f, -0.00309451f, 0.02197940f, -0.04288806f, 
    -0.05480320f, -0.02067514f, 0.00306174f, -0.05060913f, 0.02639726f, -0.04264257f, 0.03538433f, -0.04237024f, 
    -0.05075686f, 0.04055398f, -0.03872277f, -0.05459215f, -0.03753614f, -0.01909371f, -0.03021505f, 0.01042323f, 
    -0.01253231f, 0.01465261f, 0.03405777f, 0.03189825f, -0.02470283f, 0.01021026f, 0.02709721f, -0.00518463f, 
    -0.01528926f, -0.03528611f, -0.03784164f, 0.02964303f, -0.00639894f, -0.03461653f, -0.03727781f, 0.03058520f, 
    0.02032608f, 0.01878243f, 0.02575283f, 0.04226753f, -0.04388740f, -0.04622566f, -0.03961556f, -0.04943172f, 
    -0.05022013f, 0.00860760f, 0.00489367f, -0.01457347f, -0.03284968f, -0.01106034f, -0.00718303f, 0.02174862f, 
    0.03100572f, 0.00188551f, 0.03332203f, -0.04054242f, -0.03309512f, 0.00782698f, -0.05863054f, -0.04468942f, 
    -0.03237823f, -0.00198717f, 0.00614628f, 0.01971633f, 0.03464481f, -0.00359749f, 0.00768495f, 0.00703133f, 
    0.03614385f, 0.00886577f, 0.00861719f, -0.00126591f, 0.03501687f, 0.04409774f, -0.02781911f, 0.00522722f, 
    -0.01873847f, -0.01508356f, -0.00793687f, 0.02742640f, -0.04253609f, -0.03756160f, 0.04366751f, -0.04189566f, 
    -0.00553583f, -0.02697637f, 0.01460760f, 0.00132902f, 0.02694817f, 0.00132010f, 0.04545509f, 0.01459849f, 
    0.03792050f, 0.01991712f, 0.02113596f, 0.01717606f, 0.01554490f, -0.00171441f, 0.04571350f, -0.02021967f, 
    -0.02060493f, 0.01697743f, 0.00189405f, 0.02308407f, 0.02550724f, 0.02465372f, 0.01722009f, 0.00574325f, 
    -0.02008947f, 0.00826539f, 0.04109081f, -0.04158007f, 0.00238136f, 0.04155422f, -0.01154842f, -0.05047992f, 
    -0.02904865f, 0.00392393f, -0.03415134f, -0.00899090f, 0.01858767f, -0.01433195f, 0.00342469f, 0.03204438f, 
    -0.01750300f, -0.01197660f, -0.00894769f, -0.05183973f, 0.01036864f, -0.00440699f, -0.04317519f, -0.05190892f, 
    -0.05627171f, -0.04469319f, 0.00754273f, -0.05040742f, -0.04733971f, -0.03791050f, 0.02001117f, 0.01493652f, 
    -0.03601358f, -0.03525521f, -0.00614639f, 0.03824580f, -0.04354838f, 0.01693195f, 0.02126609f, -0.04750290f, 
    0.03688713f, 0.04346636f, -0.04795218f, -0.04125378f, -0.04209724f, -0.01724138f, 0.02509611f, -0.02153271f, 
    -0.03172333f, -0.02964774f, 0.02197089f, -0.00417452f, -0.02510742f, 0.04280035f, -0.04201400f, 0.02494046f, 
    0.03883587f, 0.01084929f, -0.00084328f, 0.02277913f, -0.03561653f, 0.02087904f, 0.02196466f, 0.00537953f, 
    -0.03292044f, -0.01978234f, -0.01830621f, -0.04313234f, -0.01816858f, 0.01971985f, 0.04036399f, 0.03311406f, 
    0.04140406f, 0.02048674f, -0.02373431f, -0.01204180f, 0.02525114f, -0.02103700f, -0.01956370f, -0.02871535f, 
    0.02652209f, 0.01083367f, -0.00613995f, 0.00727344f, -0.00343628f, 0.03449779f, -0.02762343f, -0.04489958f, 
    0.02056857f, -0.03055834f, 0.03156403f, 0.03712865f, 0.02196546f, 0.01242577f, 0.01623675f, -0.00794944f, 
    -0.05118581f, 0.04168556f, -0.03406740f, -0.05237706f, -0.03771485f, 0.01703935f, -0.01409489f, 0.03008918f, 
    -0.02684935f, 0.00719341f, 0.02333033f, -0.04155637f, 0.01364218f, -0.02298870f, 0.03936195f, 0.02649327f, 
    -0.01590363f, 0.01246742f, -0.04697356f, -0.04042951f, -0.02268798f, -0.01350400f, -0.03680810f, 0.03900391f, 
    0.04613858f, -0.05071502f, -0.02564149f, 0.02003628f, 0.00554999f, 0.03092191f, -0.05263548f, 0.00540151f, 
    -0.00743019f, 0.02446189f, -0.00776011f, -0.04105938f, -0.00469258f, -0.00916890f, -0.02068323f, 0.00054851f, 
    -0.03213997f, 0.00443532f, -0.00334736f, 0.00604353f, -0.02064761f, 0.02096219f, 0.02031551f, -0.02603837f, 
    -0.02431689f, -0.04952243f, -0.02831508f, -0.05657762f, 0.02260620f, -0.04528416f, 0.05914214f, 0.01993599f, 
    -0.01785690f, -0.04129023f, 0.02750998f, -0.02809339f, -0.04699126f, -0.01467539f, 0.02708373f, 0.03129502f, 
    0.01738627f, -0.05796921f, 0.03739713f, -0.03384259f, 0.00075228f, 0.03187014f, -0.01452539f, 0.00520889f, 
    -0.04036144f, -0.01144578f, -0.02509332f, -0.03938677f, -0.05132329f, -0.01900264f, 0.03221421f, 0.04310686f, 
    -0.05815438f, -0.00449874f, -0.03557257f, -0.01766213f, -0.02278549f, -0.02073479f, 0.01653825f, 0.00725007f, 
    0.02579335f, 0.00061697f, -0.04389099f, 0.01943657f, -0.01751625f, -0.00696438f, 0.02682460f, 0.00188409f, 
    -0.00487729f, 0.03609970f, 0.00866395f, 0.02041249f, 0.02070405f, -0.03610349f, -0.00080312f, 0.04254453f, 
    0.03885815f, 0.02322689f, 0.00788956f, 0.04091344f, -0.03188683f, -0.04375869f, 0.02889243f, 0.04619864f, 
    0.03040463f, -0.02071342f, -0.02195903f, -0.05837280f, -0.02520093f, 0.02807094f, -0.03575620f, -0.01801660f, 
    -0.04106991f, -0.04744483f, -0.04294776f, -0.03253566f, 0.01525742f, -0.02625567f, 0.00461539f, 0.02591101f, 
    -0.02530944f, 0.03865499f, -0.04808509f, -0.05687198f, 0.01517018f, -0.03243982f, 0.03400833f, -0.02649905f, 
    0.04664996f, 0.02185548f, -0.01420518f, -0.04242250f, -0.04222478f, -0.03396278f, 0.02785022f, 0.03995899f, 
    0.02261385f, -0.00553522f, 0.00189458f, -0.02415110f, 0.02351218f, 0.04794360f, -0.00722071f, 0.03639868f, 
    0.04096786f, -0.04763618f, -0.04661754f, -0.03167778f, -0.00612103f, 0.03168203f, -0.04756928f, -0.04360905f, 
    -0.01036994f, 0.03853884f, -0.00571456f, -0.02658363f, -0.04861907f, 0.01603382f, -0.01928435f, -0.04138850f, 
    0.03907661f, -0.02735663f, 0.03939792f, -0.01944417f, 0.02966071f, -0.04668039f, 0.03172459f, -0.00986057f, 
    -0.05021676f, 0.02961074f, 0.03238144f, 0.00333582f, -0.04987607f, -0.02052212f, -0.04244544f, -0.03008197f, 
    -0.04339212f, 0.00643728f, -0.00957108f, 0.02454636f, 0.00889838f, 0.03814574f, -0.00270771f, -0.02884878f, 
    0.00089104f, -0.04927153f, -0.02114593f, 0.05192035f, -0.03724846f, 0.01588772f, -0.03925037f, 0.02293045f, 
    0.03356827f, -0.01968923f, -0.01843936f, -0.03757940f, 0.02167368f, 0.02542468f, -0.01787645f, -0.00562814f, 
    -0.04251065f, 0.01226307f, -0.00020008f, 0.02689789f, -0.04726813f, 0.00691256f, -0.00713405f, 0.03253710f, 
    0.00386198f, 0.00033020f, -0.01654244f, -0.04629420f, -0.00484985f, 0.01440221f, -0.02018764f, -0.01538462f, 
    -0.00670152f, -0.00860087f, -0.03359416f, 0.02761527f, 0.04005439f, 0.00910113f, -0.01991177f, 0.01503751f, 
    -0.03671102f, -0.03132822f, 0.00046600f, 0.04347924f, -0.02510532f, -0.01240828f, 0.01531236f, 0.00292118f, 
    0.00976622f, -0.03955156f, -0.03291867f, -0.04494141f, -0.04499920f, 0.03140980f, 0.00042795f, -0.01729473f, 
    0.03256109f, -0.00042237f, -0.00265671f, -0.00252739f, 0.00059816f, -0.00441045f, -0.03500491f, -0.02976655f, 
    -0.05262232f, 0.00802209f, 0.04043844f, -0.01665511f, 0.02469021f, 0.01165913f, -0.01090112f, 0.04432255f, 
    -0.01123458f, -0.02399348f, -0.01035581f, -0.03495877f, -0.04887322f, -0.01579387f, 0.02514736f, 0.00949175f, 
    -0.03192241f, 0.04764374f, 0.04521172f, -0.02268706f, -0.02182380f, 0.01511788f, 0.04441203f, 0.03328576f, 
    0.00379578f, -0.00492127f, -0.04669699f, -0.04517490f, -0.01404356f, -0.02503405f, -0.01278427f, -0.01914646f, 
    -0.02049602f, 0.03214801f, -0.00203915f, -0.02704703f, 0.03994438f, -0.00345745f, -0.01481757f, -0.00395898f, 
    -0.03609286f, 0.03193927f, 0.01884126f, 0.02756210f, 0.02085183f, -0.02221558f, -0.03431279f, -0.02150634f, 
    0.04256321f, 0.01245906f, 0.01457283f, 0.00792567f, 0.03230908f, 0.01599437f, -0.05537839f, -0.02901370f, 
    0.01856294f, -0.04856888f, -0.00888352f, 0.04224712f, -0.04917337f, -0.00260159f, 0.02682563f, -0.00937786f, 
    -0.02723771f, 0.00458816f, 0.04885140f, 0.02007667f, -0.00358654f, -0.04487019f, -0.01731726f, 0.03283642f, 
    -0.00349706f, -0.04035405f, 0.02158616f, -0.05036759f, 0.03298593f, 0.01334323f, -0.03825050f, 0.02627091f, 
    -0.03143549f, 0.04356441f, -0.03505298f, 0.00097331f, -0.04739759f, 0.05514213f, -0.03479840f, 0.03964854f, 
    -0.03070416f, -0.00288411f, -0.00896094f, 0.02282996f, -0.01876391f, -0.01244298f, 0.01777681f, 0.03038217f, 
    -0.04945939f, -0.03564796f, 0.00651072f, -0.03274282f, -0.02835541f, -0.04961882f, 0.01089030f, -0.02340219f, 
    0.00875605f, -0.02467910f, 0.02190986f, -0.05475516f, 0.01931396f, -0.02279727f, -0.03940028f, -0.04626534f, 
    0.01164688f, -0.00542020f, -0.00424240f, -0.01450866f, -0.02289005f, -0.04069186f, 0.00013265f, 0.03238548f, 
    -0.01159919f, 0.01375260f, 0.03225965f, -0.03082258f, 0.01418921f, 0.01847642f, 0.05289155f, -0.00822187f, 
    0.00572496f, 0.00106121f, 0.03724924f, 0.03161015f, -0.01672756f, -0.01205733f, -0.02717404f, 0.00448000f, 
    0.01808459f, -0.02100481f, -0.03339002f, -0.03826436f, -0.03250767f, 0.02647208f, 0.04085919f, -0.03395183f, 
    -0.03903297f, 0.05120473f, 0.03196901f, -0.04378566f, -0.03866957f, 0.01172237f, -0.03466805f, 0.01835728f, 
    -0.03594972f, -0.03314755f, -0.03836761f, -0.03425982f, 0.02729310f, 0.02761861f, -0.02218656f, -0.03064530f, 
    0.03971099f, -0.00500782f, -0.01790215f, 0.03928206f, -0.02030642f, 0.00263566f, -0.01797656f, 0.03969993f, 
    0.03683220f, -0.02521744f, 0.02732649f, -0.05168169f, 0.01474464f, 0.01700880f, -0.02384588f, -0.03713963f, 
    -0.04524584f, 0.03326682f, 0.00116556f, 0.00241501f, -0.01045430f, -0.01836860f, -0.00709342f, -0.04046354f, 
    0.02997083f, -0.00555413f, 0.00770483f, -0.01991677f, -0.02486444f, 0.03601885f, -0.04505174f, 0.02975852f, 
    0.01140059f, -0.02436164f, -0.00801375f, 0.02506012f, 0.01701378f, 0.02013211f, -0.04937056f, 0.01161698f, 
    0.02207553f, 0.00318270f, -0.00966564f, -0.00195185f, -0.00102758f, 0.00913644f, -0.00174042f, -0.02996655f, 
    -0.01485784f, -0.03232659f, 0.02473772f, 0.04328926f, -0.05068237f, -0.04997103f, -0.01577852f, 0.02154661f, 
    -0.04896608f, -0.05696465f, -0.00908192f, 0.00749463f, 0.01558412f, 0.04413521f, -0.00553437f, 0.03847713f, 
    -0.01203811f, 0.01797190f, 0.01630529f, -0.02172996f, -0.04924170f, -0.03950602f, -0.04200821f, -0.01989421f, 
    0.03263518f, 0.00357561f, 0.04974765f, 0.02767117f, -0.04841250f, -0.02453764f, 0.03379528f, -0.03164828f, 
    0.01881548f, 0.00134939f, 0.01510580f, -0.04889268f, -0.04356369f, -0.01768900f, -0.01599832f, -0.00697582f, 
    -0.04485436f, 0.00442341f, 0.03702681f, 0.01501144f, 0.03124723f, -0.00105986f, 0.04640738f, 0.00696606f, 
    -0.20745791f, 0.22356585f, -0.03209857f, -0.27861792f, 0.02827290f, -0.04621211f, 0.03833897f, -0.08841314f, 
    0.08270045f, -0.06149732f, 0.15694892f, 0.08249181f, -0.05096636f, -0.20135845f, 0.05336372f, 0.15433361f, 
    0.27326691f, 0.04844103f, -0.06032697f, 0.13147709f, -0.02355423f, 0.10135230f, -0.04305243f, 0.01388372f, 
    0.20786704f, -0.09483562f, -0.25695646f, -0.10212853f, 0.11490274f, 0.06190347f, 0.06376839f, -0.05271737f, 
    0.02564791f, -0.11342498f, 0.13775702f, -0.02611777f, -0.01965123f, 0.02350367f, -0.16430557f, -0.11689187f, 
    0.02405537f, -0.11797778f, 0.06472502f, 0.04579841f, 0.11719307f, 0.02640695f, -0.00027668f, -0.03873393f, 
    0.17679304f, 0.01665310f, 0.05363956f, 0.26607081f, 0.11843634f, 0.05377994f, 0.13035904f, 0.13068934f, 
    0.10901786f, 0.02788067f, 0.01401939f, 0.06411481f, 0.08951126f, -0.02029558f, -0.04306776f, 0.01510887f, 
    0.02996009f, -0.10747778f, 0.12037263f, 0.09603105f, -0.04310064f, -0.03263656f, 0.04578760f, -0.00606579f, 
    0.20952155f, 0.30663228f, 0.03570328f, 0.20981741f, -0.04468441f, 0.12530248f, -0.02089088f, -0.03349709f, 
    0.18156761f, 0.13208641f, -0.08910274f, 0.02390740f, -0.18687445f, 0.22949956f, -0.19143894f, -0.18041618f, 
    -0.06198735f, -0.10147201f, -0.08810297f, -0.02575921f, -0.15052126f, 0.05836140f, 0.08297937f, 0.13093087f, 
    0.02918175f, -0.14419273f, 0.13814223f, 0.11007442f, 0.00106811f, -0.05814102f, -0.03367799f, -0.12417384f, 
    -0.07915829f, 0.08869687f, -0.05682052f, 0.01124594f, -0.08784921f, -0.11369383f, 0.13910758f, -0.08503867f, 
    -0.00581554f, 0.01271728f, 0.24688001f, 0.04085038f, 0.00445874f, -0.06771925f, 0.09099179f, -0.10667279f, 
    -0.15305707f, 0.09234750f, -0.17496179f, -0.10290305f, -0.08271325f, 0.09502342f, 0.00200647f, -0.11742849f, 
    0.03615632f, -0.00580056f, -0.02934983f, 0.09951743f, 0.21007253f, -0.17999642f, 0.19477132f, 0.15036629f, 
    -0.02102321f, 0.02643262f, 0.10603414f, 0.22219230f, 0.05047180f, -0.06887121f, 0.06339963f, 0.07562421f, 
    0.16326454f, 0.02578675f, 0.15063021f, 0.00028270f, 0.00303922f, 0.07306451f, 0.17767838f, -0.01200724f, 
    0.08217150f, -0.02906861f, 0.11513242f, 0.05320602f, 0.23389925f, 0.01892649f, -0.03433997f, 0.06800345f, 
    0.13039342f, 0.20458955f, 0.02161496f, 0.08343192f, 0.15788373f, 0.03633890f, 0.04536704f, -0.00482793f, 
    0.18070652f, 0.25177279f, -0.19884706f, -0.36113751f, -0.03174309f, 0.06943282f, 0.16186741f, 0.03561287f, 
    0.06927968f, 0.02325913f, 0.17439282f, 0.04952510f, 0.02913670f, 0.08707684f, -0.23071741f, 0.33178023f, 
    -0.03079903f, 0.12542804f, -0.17704244f, 0.12223360f, -0.00586315f, 0.04101952f, 0.09680805f, 0.07249086f, 
    -0.01101872f, 0.03937707f, -0.03140195f, 0.08899532f, 0.00880302f, -0.02686838f, -0.15741268f, -0.05134811f, 
    0.02147964f, 0.14080016f, 0.07246727f, 0.00560255f, -0.43021712f, -0.28667217f, -0.05881140f, -0.42647812f, 
    -0.04119591f, 0.30783415f, 0.01840119f, -0.06786510f, 0.06009807f, 0.13668598f, 0.12576832f, 0.10622276f, 
    0.21535872f, 0.05686766f, -0.04752896f, -0.10043675f, 0.03267327f, 0.21517377f, 0.13798919f, 0.22642976f, 
    -0.08828188f, 0.08795179f, 0.11816992f, 0.09724292f, -0.03421094f, -0.17262712f, 0.15452571f, 0.12788726f, 
    0.13132049f, -0.13321672f, -0.04031639f, 0.00534081f, 0.07877403f, 0.11300230f, 0.04364306f, -0.01202794f, 
    -0.02048289f, -0.13974631f, -0.16408983f, 0.04128182f, 0.00104540f, -0.08129538f, 0.05130921f, 0.09251819f, 
    0.05927943f, 0.23998927f, -0.05637232f, -0.00010339f, 0.06339399f, -0.04881751f, 0.14935558f, -0.07341686f, 
    0.10089456f, -0.00659014f, 0.13618740f, 0.08489311f, -0.00216220f, -0.14370716f, 0.18934186f, -0.00220342f, 
    0.15398577f, 0.01203629f, 0.28253818f, 0.11753375f, -0.04476057f, -0.00188236f, -0.00920366f, -0.00271424f, 
    0.06774738f, 0.09723248f, 0.00969558f, -0.01823654f, 0.06374172f, 0.23383358f, 0.15027697f, 0.15862872f, 
    -0.06446923f, 0.05058377f, -0.06210778f, 0.19859011f, -0.00961528f, 0.08363222f, 0.10487620f, 0.06236717f, 
    -0.02962417f, -0.07992329f, -0.12843999f, 0.10764799f, -0.09781048f, -0.03500022f, -0.01576768f, 0.09492125f, 
    0.05234373f, 0.07365806f, -0.09036659f, 0.05071143f, -0.11672873f, -0.03928778f, -0.06222616f, 0.01046535f, 
    -0.13789122f, 0.05605269f, -0.12790510f, -0.03916886f, 0.08123341f, 0.13089578f, 0.06267631f, -0.00056481f, 
    0.35468596f, -0.14350827f, 0.16459805f, 0.10682904f, 0.11319153f, -0.04197275f, 0.19513498f, -0.10206734f, 
    0.11624034f, 0.05233676f, -0.01006603f, 0.03077144f, 0.16114825f, -0.06161667f, 0.23503231f, -0.02284592f, 
    0.08426478f, -0.05881586f, 0.11959577f, 0.00702807f, -0.19565432f, 0.02269719f, 0.15708496f, 0.05661444f, 
    -0.35652566f, -0.20692936f, 0.01199724f, -0.17031288f, -0.07092818f, -0.09885238f, -0.00914251f, -0.05088226f, 
    0.02042196f, 0.00521540f, -0.06034663f, -0.02408287f, -0.08007660f, -0.08386166f, 0.45987225f, 0.08007582f, 
    0.03180489f, 0.08731215f, 0.10229357f, 0.02093524f, 0.09576324f, 0.06303792f, 0.04046168f, 0.02085708f, 
    0.02136611f, -0.09947295f, 0.14264935f, 0.11257084f, 0.06851611f, -0.06249389f, 0.12545532f, -0.00438609f, 
    0.01905248f, -0.12765698f, 0.01297046f, -0.00259595f, -0.23995176f, 0.11061926f, -0.15394484f, 0.16167776f, 
    -0.02743680f, -0.02799132f, -0.02837899f, 0.09074668f, 0.00207028f, 0.07050984f, 0.02944531f, -0.01706035f, 
    0.18410842f, -0.01807974f, 0.20734124f, -0.01116791f, -0.04551152f, 0.08105888f, 0.08969322f, 0.10867658f, 
    -0.02207807f, 0.02036399f, 0.05905895f, 0.07047027f, 0.04166256f, 0.20862664f, -0.14653008f, -0.01550303f, 
    -0.03641194f, 0.02448143f, 0.07120753f, -0.14453635f, -0.07517707f, -0.06648710f, -0.01701023f, -0.06830865f, 
    -0.22942640f, 0.15848868f, 0.28180391f, -0.07379812f, -0.07795659f, 0.01284851f, -0.05569300f, 0.04619860f, 
    0.03486333f, -0.03717263f, -0.13737084f, -0.00793079f, -0.36203092f, 0.19293030f, 0.09450497f, -0.18691353f, 
    -0.00841533f, -0.05275071f, -0.08612633f, 0.11090960f, -0.01484853f, -0.02040975f, -0.02320099f, 0.02459819f, 
    0.09866799f, -0.16769259f, 0.05383375f, 0.07985613f, 0.00702328f, -0.03051566f, 0.00162533f, -0.02876978f, 
    -0.02529664f, 0.08664873f, 0.11637070f, -0.05919195f, -0.23449919f, 0.15147004f, 0.07746758f, 0.08517575f, 
    0.15581290f, 0.00485800f, 0.01946792f, 0.18142198f, -0.05543330f, 0.05717922f, -0.03847481f, 0.05864099f, 
    -0.23381460f, -0.09974863f, 0.30187723f, 0.12850162f, -0.04727243f, -0.07158205f, -0.05564502f, -0.07476180f, 
    0.00808977f, -0.13525476f, -0.04923799f, -0.11069728f, -0.26178953f, -0.01365576f, 0.21867009f, 0.09581338f, 
    -0.05768977f, 0.05104994f, 0.15369116f, -0.03466826f, 0.15278047f, -0.05870453f, -0.04636054f, -0.07256617f, 
    0.03098281f, 0.19434561f, 0.22265749f, 0.23065655f, 0.05486832f, 0.00947120f, 0.12080408f, 0.15783951f, 
    0.03546866f, 0.08881823f, 0.12888263f, 0.14412971f, -0.11798141f, -0.00904994f, 0.22150041f, 0.20224486f, 
    -0.05681032f, 0.21693511f, -0.09517787f, -0.03807050f, 0.02063430f, 0.19919080f, -0.03895945f, 0.15319614f, 
    -0.09934060f, 0.12391640f, 0.06912810f, -0.12437241f, 0.04246623f, -0.00262099f, -0.13423909f, 0.06019961f, 
    0.00898965f, 0.02049510f, -0.02049945f, 0.08641443f, -0.02809108f, 0.18667427f, -0.15970320f, 0.19674562f, 
    0.06609561f, 0.10637221f, -0.03245344f, 0.02151172f, 0.10802133f, 0.02282483f, -0.02936543f, -0.10554306f, 
    0.05462376f, -0.17888758f, -0.08593864f, -0.19791745f, 0.09875747f, 0.09499242f, 0.05387846f, -0.03015145f, 
    0.00340174f, 0.08756960f, 0.03028200f, 0.03226489f, 0.19913693f, 0.14638942f, -0.09431876f, 0.21244404f, 
    -0.13540547f, -0.07867394f, -0.15606277f, 0.04288265f, 0.00145282f, 0.15669522f, -0.04863412f, 0.05351040f, 
    -0.31925780f, -0.07618270f, 0.23406126f, 0.07381058f, 0.09531583f, -0.09877673f, -0.04090458f, -0.08081720f, 
    0.03507078f, 0.08580719f, -0.08073688f, -0.04103246f, -0.62828296f, -0.02646663f, 0.06184097f, 0.00888193f, 
    -0.02390065f, -0.13177428f, -0.00820863f, -0.10037884f, -0.00837811f, -0.00839774f, -0.04293606f, -0.01614501f, 
    0.08492929f, 0.21131808f, -0.08695833f, -0.25865957f, 0.25506911f, -0.03027433f, 0.05701287f, -0.04622788f, 
    -0.06647922f, -0.16549774f, -0.07595063f, 0.11314208f, 0.63133425f, 0.39216226f, -0.08816795f, -0.09331031f, 
    0.03710665f, -0.05358656f, 0.04696284f, 0.07687313f, 0.03015047f, -0.06374484f, -0.03295826f, 0.09345160f, 
    -0.12986045f, -0.00955597f, 0.09400702f, 0.21002533f, -0.01498795f, -0.00264941f, -0.00907573f, -0.04785215f, 
    0.17875950f, -0.07856693f, 0.03427074f, -0.03756673f, 0.05672954f, 0.00808436f, 0.11268284f, 0.27240795f, 
    0.04904607f, 0.01691737f, 0.09202292f, 0.13195665f, 0.02526973f, 0.15615088f, -0.00597399f, 0.02076744f, 
    -0.21846285f, 0.18775848f, 0.16569957f, 0.06752138f, 0.05439736f, -0.01931508f, -0.00684756f, 0.03104962f, 
    0.13889274f, -0.11058397f, 0.12883593f, 0.15945458f, 0.11780049f, -0.22365712f, -0.05308643f, 0.08221554f, 
    0.04655670f, 0.14183727f, 0.03026835f, -0.07316851f, -0.07291818f, 0.16414107f, -0.08045965f, 0.00461987f, 
    -0.02637502f, 0.22467978f, 0.14942695f, 0.12160642f, 0.02203222f, -0.05763039f, 0.00228255f, -0.01733948f, 
    -0.08251387f, -0.14676772f, -0.04460015f, -0.04811166f, -0.33972874f, -0.07421612f, -0.01329498f, 0.22062333f, 
    -0.04414217f, -0.00100443f, -0.06372503f, -0.08443350f, 0.04398683f, -0.09044923f, -0.01928863f, -0.00147712f, 
    -0.20622799f, 0.15501690f, 0.14626324f, 0.08496613f, 0.16763583f, 0.11969997f, 0.10883648f, 0.04884722f, 
    0.00918747f, 0.01442619f, 0.07697262f, 0.04110660f, -0.35024121f, -0.20589377f, 0.06365155f, -0.04452952f, 
    -0.06317057f, 0.04076973f, -0.05083594f, -0.03158493f, 0.01425468f, -0.03377424f, -0.12056330f, 0.01544241f, 
    -0.00197188f, -0.07523988f, -0.10463969f, -0.05718445f, -0.00903042f, 0.06725718f, 0.04152071f, -0.06045469f, 
    -0.01976258f, -0.02658413f, 0.05737420f, -0.10885248f, -0.08760020f, -0.06342101f, -0.07556796f, -0.18011199f, 
    -0.01197966f, 0.03892604f, -0.07585362f, 0.02947516f, 0.02188764f, -0.04584513f, -0.05361613f, 0.05837478f, 
    0.23743455f, 0.19866405f, -0.06922486f, 0.14461617f, -0.11112400f, 0.15481581f, 0.07134292f, 0.05854136f, 
    -0.14146924f, 0.00664982f, 0.07177161f, 0.15692456f, -0.13874602f, -0.21622711f, 0.03273489f, 0.19075598f, 
    -0.13955227f, 0.05721199f, -0.00747999f, -0.17356388f, 0.04563935f, 0.00936337f, -0.14928818f, 0.00858563f, 
    -0.12448591f, 0.03904397f, 0.14516978f, 0.10780694f, -0.02253529f, 0.03991453f, 0.11883326f, 0.07513676f, 
    -0.09455271f, 0.08207797f, -0.06466436f, -0.03213074f, 0.53045493f, -0.11705722f, 0.17409341f, 0.19608474f, 
    -0.08451737f, 0.00801016f, 0.11061515f, -0.06984080f, -0.01113922f, 0.12315826f, 0.04579323f, 0.08785421f, 
    0.21061930f, 0.18950236f, 0.07060696f, 0.07088736f, -0.08830836f, 0.10418756f, -0.03873605f, 0.00825522f, 
    -0.01431648f, 0.04651575f, 0.00343648f, 0.11179550f, -0.09173191f, 0.01979954f, -0.00168159f, -0.18092017f, 
    0.11524334f, -0.04669328f, 0.14997277f, 0.10464000f, 0.05706314f, 0.02623608f, 0.05114883f, 0.09892533f, 
    -0.15615484f, -0.14048867f, -0.03750039f, -0.14647380f, 0.06725540f, -0.06330372f, -0.09824309f, 0.03917953f, 
    0.20362404f, 0.12857263f, 0.00485678f, -0.07253700f, -0.27411878f, -0.17991403f, 0.13462292f, -0.05492004f, 
    -0.00852426f, 0.08081261f, 0.01486155f, -0.00919288f, 0.01109767f, 0.04588076f, 0.06650294f, 0.11314889f, 
    0.30180377f, 0.05881299f, 0.23972604f, 0.17231758f, -0.11437442f, -0.00086105f, -0.01266481f, -0.13918447f, 
    -0.02899575f, 0.05769538f, 0.09535904f, -0.01130506f, -0.27505273f, -0.04384210f, -0.16227554f, -0.27553758f, 
    0.05889382f, 0.03329869f, -0.05139302f, 0.02809208f, -0.00917617f, 0.06764641f, -0.00335628f, 0.05425099f, 
    0.41957635f, 0.30793685f, 0.00135791f, -0.09945224f, -0.13958439f, -0.08072975f, -0.04749576f, 0.05520857f, 
    0.08879297f, -0.09812266f, 0.14069396f, 0.12055083f, 0.16182664f, -0.11328842f, 0.14617790f, -0.09178625f, 
    0.10075928f, 0.17310427f, -0.02048098f, -0.02083692f, 0.09558685f, 0.04832971f, 0.15396588f, 0.05234070f, 
    -0.14650320f, -0.28803787f, -0.02196632f, -0.21562918f, 0.03932824f, 0.02969453f, 0.16635238f, -0.00241389f, 
    0.01618629f, 0.05118323f, 0.07699620f, 0.07561985f, -0.34227926f, -0.13011606f, -0.11337595f, -0.05547344f, 
    0.18995503f, 0.01407056f, 0.00878752f, 0.02330184f, 0.06826968f, 0.06182503f, 0.08614540f, 0.00794116f, 
    -0.08788484f, 0.06108528f, -0.06249313f, -0.14702791f, -0.00833907f, 0.03028132f, -0.05682273f, 0.08133459f, 
    -0.03032352f, 0.08366770f, 0.09490658f, 0.03075293f, -0.02573784f, 0.00817811f, 0.08042965f, -0.07944392f, 
    -0.01639410f, 0.11698485f, 0.05444034f, 0.01831625f, 0.11399318f, -0.05482469f, 0.02001950f, 0.08775406f, 
    0.10928950f, 0.19614443f, 0.03136560f, 0.02191586f, 0.03590313f, -0.01928984f, -0.07623345f, 0.05924806f, 
    0.05156560f, 0.05883902f, -0.01973584f, -0.04353946f, 0.43479294f, 0.28012866f, 0.17391409f, 0.11605003f, 
    -0.00281000f, -0.04564226f, -0.07318535f, -0.03090157f, -0.03751272f, -0.00757344f, -0.02321382f, 0.13821879f, 
    0.25806352f, -0.07458610f, 0.22314772f, -0.05141655f, -0.07797456f, -0.04993354f, 0.00077024f, -0.12225483f, 
    -0.02965862f, -0.06735387f, 0.05923331f, 0.10107265f, 0.17676724f, -0.01065446f, -0.04830147f, -0.01111988f, 
    0.05800872f, -0.03509703f, -0.03691680f, 0.00644403f, 0.21520992f, 0.08640920f, 0.10993211f, -0.00241527f, 
    0.26953995f, -0.03852551f, -0.00334096f, -0.09121390f, 0.10596196f, 0.06439921f, 0.08855453f, -0.01392695f, 
    -0.03971731f, 0.08594757f, 0.11081192f, 0.09150357f, -0.12606582f, -0.18743904f, 0.14461263f, -0.08060423f, 
    -0.10811170f, 0.03827033f, -0.02968748f, -0.12430069f, 0.00553007f, -0.05743012f, 0.04067951f, 0.11658346f, 
    -0.35116678f, -0.24839589f, -0.06940012f, 0.03271995f, -0.07895947f, 0.03094921f, -0.04606647f, 0.07203926f, 
    0.00904674f, -0.04591218f, -0.01285075f, 0.07266348f, -0.26583776f, -0.28797862f, -0.10744491f, -0.30544099f, 
    0.14983372f, 0.09254467f, 0.00153655f, 0.06287560f, 0.02161450f, 0.00447755f, -0.05372319f, 0.04596891f, 
    0.36574456f, -0.16046265f, 0.10749456f, -0.17058165f, 0.05374623f, 0.19206004f, -0.02259870f, -0.02824403f, 
    -0.01477983f, 0.01564627f, 0.12030371f, -0.02925415f, 0.13947606f, 0.07755494f, 0.08849934f, -0.19463657f, 
    0.06251720f, -0.09099752f, -0.07046870f, 0.13912745f, -0.03008151f, -0.08086760f, 0.06980769f, 0.01332113f, 
    0.17239515f, 0.33710286f, 0.27222690f, 0.13623755f, -0.10423397f, 0.08297920f, 0.06322429f, 0.04741742f, 
    0.02655437f, 0.02159710f, 0.04641749f, 0.01310404f, 0.21433294f, 0.36263078f, 0.16626459f, 0.23126630f, 
    -0.06570768f, -0.07699507f, 0.03213134f, -0.06833796f, -0.06254450f, -0.03379007f, -0.10961938f, 0.05664448f, 
    -0.08251811f, -0.10434715f, -0.07529448f, -0.16498344f, 0.19259287f, 0.19903557f, 0.01530425f, 0.06758358f, 
    0.10109599f, -0.01440384f, 0.00719190f, 0.22033131f, 0.03871749f, -0.07837710f, 0.12403115f, -0.03973956f, 
    0.00212777f, -0.00110142f, 0.04761750f, -0.07265580f, 0.04980634f, -0.03198289f, 0.15538640f, 0.09562889f, 
    -0.29393551f, 0.00684477f, -0.06683414f, -0.03786004f, 0.15590638f, 0.13937844f, 0.01509508f, 0.18051241f, 
    -0.07458559f, 0.05445030f, 0.08857159f, 0.00463556f, 0.27507612f, 0.21692427f, 0.00761157f, -0.01789759f, 
    0.04252446f, 0.03646122f, 0.06315007f, -0.03403340f, 0.00508976f, -0.00841787f, 0.00069904f, 0.09631444f, 
    -0.25824079f, -0.12874311f, -0.04057981f, -0.05720117f, 0.05459810f, 0.04978405f, -0.04846608f, 0.05223782f, 
    0.09963566f, 0.04942006f, 0.02269257f, -0.01310415f, -0.06511153f, 0.03035281f, 0.24162719f, -0.15057442f, 
    -0.07503226f, -0.02544877f, -0.01510968f, -0.02776464f, -0.11850381f, -0.14863843f, 0.01194566f, 0.06715942f, 
    -0.38823658f, -0.22902568f, 0.17220052f, -0.20324546f, 0.13203500f, -0.06154076f, -0.01663045f, -0.01596379f, 
    0.13142005f, 0.13350527f, 0.00183182f, 0.09831069f, 0.12655465f, 0.19552980f, 0.06860837f, 0.31694090f, 
    -0.05147098f, 0.07981211f, 0.09727360f, -0.12224267f, -0.01034895f, -0.10448702f, 0.03593378f, 0.14589006f, 
    0.01429984f, -0.03323556f, -0.04960041f, 0.02341184f, -0.05447952f, -0.00778762f, -0.01095729f, -0.05070363f, 
    0.02094483f, 0.01230472f, 0.02807286f, -0.05186389f, 0.00391054f, -0.02630093f, -0.04407623f, -0.00506768f, 
    -0.05472729f, -0.02950250f, 0.00552188f, 0.03021311f, -0.04832180f, 0.02023641f, 0.04052005f, 0.03340635f, 
    -0.03866309f, -0.05475971f, 0.00149995f, -0.04900324f, -0.05676261f, -0.05065752f, -0.00490073f, 0.00701160f, 
    0.02037783f, -0.03198358f, -0.05777422f, -0.04886534f, -0.00362553f, -0.00472025f, -0.04418043f, -0.01319701f, 
    -0.03310495f, -0.01052377f, -0.00132015f, -0.01268916f, 0.01933256f, -0.00255430f, -0.02149906f, -0.00608021f, 
    -0.05651489f, -0.01945411f, 0.00218292f, 0.00242187f, 0.00492700f, -0.02725870f, -0.01444119f, 0.02610824f, 
    0.01380331f, 0.04175754f, -0.04326296f, 0.02995965f, 0.02616468f, -0.02238677f, 0.01036047f, 0.02727395f, 
    -0.02423596f, -0.05649009f, 0.03667331f, 0.01233003f, 0.03695577f, 0.04018157f, -0.01530711f, -0.00737219f, 
    -0.02390409f, -0.03415262f, -0.03408518f, 0.01898415f, -0.05390264f, 0.00892763f, -0.04794225f, -0.01442569f, 
    -0.01475678f, 0.01565912f, -0.02291347f, -0.03303201f, -0.02595888f, 0.03547259f, 0.00951296f, 0.03161135f, 
    0.03037553f, 0.04441630f, -0.01354449f, 0.00485208f, -0.00780924f, 0.00664438f, 0.00032031f, 0.03238127f, 
    0.03814897f, 0.02762463f, -0.03112883f, -0.05154768f, -0.01178333f, 0.02731516f, 0.03420625f, -0.03017491f, 
    -0.00571310f, 0.03987106f, 0.02635743f, -0.03847006f, 0.02486272f, -0.02942449f, -0.04899162f, 0.01010152f, 
    -0.01581980f, 0.01215618f, -0.03493438f, -0.05125888f, -0.01678059f, -0.02221839f, -0.03437977f, 0.02442174f, 
    -0.04023999f, 0.00611015f, -0.02151951f, 0.01883614f, -0.00207986f, -0.03073198f, -0.05496283f, 0.03325848f, 
    0.02982579f, -0.01858520f, -0.02581771f, -0.01726729f, -0.05511694f, 0.04347391f, -0.05512949f, -0.01712499f, 
    0.01180844f, 0.02235400f, 0.01149444f, -0.04206165f, -0.02028287f, 0.00674173f, -0.02836907f, 0.01850575f, 
    -0.00447109f, -0.01080292f, -0.00700844f, -0.01648922f, -0.01685020f, 0.03403644f, -0.05148607f, 0.02002315f, 
    0.01902542f, 0.02676156f, -0.01423176f, -0.01730705f, -0.03440787f, -0.02547014f, -0.00060806f, 0.00289822f, 
    0.01063586f, 0.03407316f, 0.01646577f, -0.04355071f, -0.01218096f, 0.01354895f, -0.02829478f, 0.02958249f, 
    0.03400394f, 0.02113935f, 0.02944293f, -0.04209661f, -0.05899524f, -0.03040883f, -0.00045500f, 0.01467286f, 
    0.01669028f, -0.00681904f, -0.02866541f, 0.03227244f, -0.01574038f, -0.02346096f, 0.03018129f, -0.04205076f, 
    -0.00217024f, 0.04391917f, 0.01389995f, 0.01042443f, 0.01255827f, -0.04666016f, 0.03570755f, -0.01183135f, 
    0.00835184f, 0.04250472f, 0.03838034f, 0.02068961f, -0.02946966f, 0.02216046f, -0.05539241f, 0.00665849f, 
    -0.02631749f, -0.04509305f, 0.00404901f, -0.02086413f, -0.03140857f, 0.02886246f, -0.02670507f, -0.01160296f, 
    -0.05058557f, 0.01167417f, -0.05033832f, -0.03452380f, 0.02196005f, -0.02034784f, -0.01885945f, -0.02610703f, 
    0.01072108f, -0.05740504f, 0.01718794f, -0.00112151f, 0.01862263f, -0.02984638f, -0.04245558f, -0.01836708f, 
    0.03191113f, -0.02307148f, -0.04611506f, -0.02770053f, 0.02516832f, 0.04419721f, -0.00100307f, -0.00769874f, 
    -0.02552317f, 0.04391795f, 0.03178779f, 0.01932445f, -0.05485411f, -0.02666271f, -0.00021944f, 0.02408124f, 
    -0.01624647f, 0.02157429f, 0.01642714f, 0.02823525f, -0.03682947f, -0.04962678f, 0.01005678f, -0.03449656f, 
    0.00149749f, -0.01261047f, 0.01557242f, 0.01311920f, -0.03350394f, 0.03447048f, -0.04166992f, 0.01713816f, 
    -0.00975822f, 0.03092705f, -0.01619911f, 0.02164390f, -0.02532965f, 0.04124158f, -0.03082799f, 0.01347217f, 
    0.00313673f, -0.03464076f, 0.02871757f, 0.03201523f, 0.03992730f, 0.02820217f, -0.01714752f, -0.04555724f, 
    -0.02367195f, 0.03119516f, -0.01821298f, -0.01177865f, -0.04107607f, -0.02031896f, 0.01401977f, 0.04114774f, 
    -0.04083685f, 0.00877103f, -0.01390336f, -0.04219263f, -0.03255842f, 0.03887196f, -0.05694286f, 0.03597190f, 
    -0.04478481f, 0.00264494f, -0.03600321f, 0.03625284f, 0.03256890f, -0.01501836f, -0.01171666f, -0.04753148f, 
    -0.01699085f, -0.01155168f, 0.01828738f, -0.04486293f, 0.03993093f, -0.02566836f, 0.01543950f, 0.04023679f, 
    -0.05373870f, -0.01758457f, -0.00057492f, -0.04859816f, 0.00534086f, -0.02757852f, -0.04523091f, 0.04101978f, 
    -0.04745338f, -0.01421620f, 0.03685966f, 0.01707030f, -0.03792305f, -0.02791077f, -0.03138949f, -0.05473214f, 
    -0.02531640f, 0.02955526f, -0.04672999f, -0.04604024f, -0.04981845f, 0.02105196f, 0.04225014f, 0.02873945f, 
    -0.03591678f, 0.00083582f, 0.03732406f, 0.04034139f, -0.03991396f, -0.01696598f, -0.04724805f, 0.02609100f, 
    -0.02020471f, -0.00544832f, 0.01292202f, -0.04862527f, -0.01408223f, -0.05646409f, 0.00026572f, 0.03674451f, 
    0.00885411f, -0.03671527f, -0.02665345f, -0.00570699f, -0.04618220f, 0.02308645f, -0.05635509f, -0.02594289f, 
    -0.01417224f, -0.02769496f, 0.01832025f, 0.00727624f, 0.04307748f, 0.00724855f, -0.01947040f, -0.01846482f, 
    0.03970738f, -0.05607970f, 0.00905745f, -0.04909795f, -0.04651798f, -0.03206502f, -0.04492206f, -0.04088573f, 
    -0.02466387f, 0.01991546f, -0.04967719f, -0.02658373f, 0.01548301f, -0.01001401f, -0.01022655f, 0.00737432f, 
    -0.03913943f, -0.00562855f, 0.03887836f, -0.05078409f, 0.02923247f, -0.02574525f, 0.00949878f, -0.04077693f, 
    -0.04150004f, -0.03745480f, 0.03157840f, 0.01210779f, -0.05333938f, -0.00090993f, -0.03911090f, -0.00318911f, 
    -0.02285971f, -0.00211339f, 0.00313672f, 0.00624624f, -0.03337702f, 0.04104952f, 0.05090132f, -0.00922022f, 
    -0.02193699f, -0.03167007f, -0.02293400f, 0.02016952f, 0.04391645f, -0.02531042f, 0.00616655f, -0.00172856f, 
    -0.02604413f, -0.05091650f, -0.02287575f, 0.04284145f, -0.04901882f, -0.02689894f, 0.03904438f, -0.01544665f, 
    -0.01315930f, -0.01781027f, -0.02805928f, 0.02540634f, 0.00382386f, -0.04463802f, -0.01566704f, -0.00814375f, 
    0.03973561f, -0.05379257f, -0.01785219f, -0.01468402f, 0.00207128f, -0.03210190f, -0.01004627f, -0.04580202f, 
    -0.01532406f, 0.01944178f, 0.00784185f, -0.04002916f, -0.01683865f, 0.03193249f, -0.01803180f, 0.01317431f, 
    -0.03171837f, 0.00432336f, -0.00659341f, -0.01278234f, 0.04116832f, 0.04267277f, 0.03918738f, 0.02264532f, 
    -0.00246842f, -0.00433248f, -0.00125648f, 0.01900371f, 0.04354435f, 0.00991659f, 0.03938371f, 0.02339869f, 
    0.01560775f, 0.01942242f, 0.03602263f, -0.04291925f, 0.02641441f, 0.03845785f, -0.04095938f, -0.00537889f, 
    -0.01555095f, -0.05047816f, -0.05441210f, -0.03125448f, -0.00729143f, 0.02449720f, 0.01521598f, 0.02992668f, 
    0.00129868f, -0.03891227f, -0.04071330f, -0.00118361f, 0.02901945f, -0.04699335f, -0.04784868f, 0.01094067f, 
    0.04895168f, -0.03668063f, 0.03356857f, -0.00875104f, 0.04186632f, 0.00560199f, -0.02861033f, -0.03059927f, 
    0.01993830f, -0.05052474f, -0.02749470f, 0.01767715f, -0.05615650f, -0.03240633f, -0.02430866f, -0.03929556f, 
    -0.03020948f, -0.01058576f, 0.04408715f, -0.01368872f, 0.01858957f, -0.03000740f, -0.00129404f, -0.03186918f, 
    0.00449294f, 0.03032747f, -0.02367001f, -0.05298033f, -0.00893537f, 0.03404029f, -0.05728679f, -0.00861396f, 
    -0.04416396f, -0.05668495f, 0.04114341f, -0.03914519f, -0.02917921f, -0.03925446f, 0.03965083f, -0.00067703f, 
    -0.01072508f, -0.03596708f, -0.01924885f, -0.00752277f, -0.02440196f, -0.04139055f, 0.04355499f, -0.05360470f, 
    -0.02093299f, 0.01812411f, 0.03301027f, 0.02433082f, -0.02235593f, 0.00162379f, 0.01475672f, -0.03086021f, 
    -0.04817033f, -0.01090591f, -0.02776095f, -0.03753905f, 0.02837654f, -0.03701078f, -0.01532247f, -0.03510611f, 
    -0.01503029f, -0.05706415f, -0.05114322f, -0.03870013f, 0.03905623f, -0.01859379f, -0.03141198f, -0.02305911f, 
    0.02223898f, 0.00680211f, 0.01071125f, 0.01315759f, 0.02907116f, 0.03600409f, -0.05613831f, -0.05350384f, 
    -0.04883157f, 0.00987931f, -0.01069612f, 0.04078398f, 0.02747883f, -0.01795695f, -0.04676514f, -0.02959765f, 
    -0.05608869f, 0.03145897f, 0.01217946f, 0.01339294f, -0.03554284f, 0.00649424f, -0.03565615f, 0.03423559f, 
    0.03815818f, -0.02147895f, -0.02343636f, -0.03056889f, 0.04216353f, -0.03633764f, 0.03371417f, -0.04396544f, 
    -0.04525736f, -0.04992220f, 0.01296123f, -0.04196749f, -0.03507344f, -0.01151401f, -0.04498513f, -0.04196514f, 
    -0.01469210f, -0.02320911f, -0.03715741f, -0.03856084f, 0.00482232f, 0.02082064f, -0.02370190f, 0.03781995f, 
    -0.05274540f, -0.03213017f, -0.03175209f, -0.01577515f, -0.01647969f, 0.00603067f, 0.03546514f, 0.03845149f, 
    -0.02079478f, -0.04801233f, 0.01752979f, -0.03597880f, -0.02617201f, -0.02226063f, -0.03497586f, 0.02871542f, 
    -0.02359151f, -0.05046499f, 0.00548376f, -0.01289234f, -0.03646404f, -0.00826224f, -0.01130323f, -0.05697120f, 
    0.00021114f, 0.04013840f, -0.03938061f, 0.01984526f, -0.03451585f, -0.04568104f, -0.03411442f, -0.03283316f, 
    0.01731043f, -0.01572460f, -0.03675280f, -0.01100576f, -0.03895061f, -0.00099416f, -0.00044029f, -0.02069133f, 
    -0.00371830f, -0.01974213f, 0.02820764f, -0.04375108f, -0.01080407f, -0.05619108f, -0.02184924f, 0.02693127f, 
    -0.01499624f, 0.00006341f, -0.00384345f, 0.03063375f, -0.03185428f, 0.00451822f, 0.01309849f, 0.00501174f, 
    0.01406132f, -0.00362314f, 0.01079756f, 0.00714827f, 0.01426586f, -0.05665465f, 0.00537748f, -0.00132681f, 
    0.03582096f, 0.00674860f, -0.00324429f, 0.02172718f, -0.03244089f, 0.04148786f, 0.00309608f, -0.04344026f, 
    -0.03551340f, -0.04638733f, -0.02540524f, -0.04334726f, -0.05431867f, 0.00326837f, -0.03325548f, -0.02506049f, 
    0.02805297f, -0.01068633f, 0.04017820f, 0.00715095f, -0.02154317f, -0.01508428f, 0.02783232f, 0.02437098f, 
    -0.00137967f, 0.01271798f, -0.03614340f, -0.03787105f, 0.03281026f, 0.03613058f, -0.02403084f, -0.02154703f, 
    -0.04056940f, 0.03270271f, 0.01944760f, 0.00128369f, -0.03352734f, -0.01125932f, -0.04209133f, 0.02023855f, 
    -0.00037157f, -0.04566496f, -0.01198644f, 0.03469547f, 0.01351439f, -0.03550838f, 0.00361332f, -0.03764736f, 
    -0.00477452f, -0.05318734f, -0.03047968f, -0.02911966f, -0.02087902f, -0.02813030f, -0.04143190f, 0.01050385f, 
    -0.04660506f, 0.01104567f, -0.03204413f, -0.02376731f, 0.03713145f, 0.03923765f, -0.00673893f, -0.02527840f, 
    -0.01401196f, -0.00704884f, -0.04589219f, -0.02473559f, -0.03309397f, 0.03049442f, -0.03671769f, 0.01121220f, 
    -0.03839961f, -0.01984511f, 0.01815672f, 0.00163265f, 0.01086443f, 0.04391228f, -0.02429533f, 0.00552364f, 
    0.00162887f, -0.00447547f, -0.01784838f, 0.03912576f, -0.05585993f, -0.02782075f, -0.00876135f, -0.02793529f, 
    -0.05175871f, -0.00259685f, -0.02214491f, -0.01433240f, 0.00159184f, -0.02562255f, 0.03096182f, -0.02184521f, 
    -0.04752281f, -0.04619662f, -0.02467009f, 0.04164527f, -0.01183517f, -0.00231228f, 0.01002896f, -0.00507220f, 
    0.21501553f, -0.02857544f, -0.28811172f, 0.05898481f, 0.07817211f, -0.03525717f, -0.06950422f, 0.02811741f, 
    0.19206673f, 0.07696488f, -0.03136554f, 0.10401953f, -0.07070474f, -0.10814565f, 0.13610332f, 0.05959652f, 
    -0.22575302f, -0.08884179f, 0.04210977f, 0.13445383f, -0.10463956f, 0.10656089f, -0.05508823f, 0.04982899f, 
    0.21675670f, 0.01986333f, -0.03584618f, 0.14281899f, 0.04770577f, -0.02796173f, 0.00142394f, -0.00672664f, 
    -0.10428438f, -0.00319986f, -0.02429555f, 0.05931959f, 0.59249526f, -0.14893842f, -0.20064650f, 0.28254646f, 
    0.11139558f, -0.00180802f, 0.00448774f, -0.02797852f, -0.06571083f, -0.05076388f, 0.08878855f, -0.01729657f, 
    -0.13308272f, 0.18430641f, -0.03665875f, -0.01791467f, 0.11086356f, 0.11922093f, 0.05456548f, 0.11816359f, 
    -0.01344181f, -0.00708425f, 0.12547430f, 0.16118619f, 0.03541442f, -0.05011110f, 0.08273224f, 0.08709042f, 
    0.02594625f, -0.11445744f, 0.05637151f, -0.00955536f, 0.02528766f, -0.10009324f, 0.08695135f, 0.09908002f, 
    0.12645325f, 0.06108633f, 0.00105292f, -0.06723774f, 0.26432675f, -0.01867435f, -0.01121753f, -0.03081945f, 
    0.02123388f, 0.06359309f, -0.07041966f, 0.00616517f, 0.22169171f, 0.09302063f, 0.17453821f, 0.12699482f, 
    0.08514092f, 0.23135580f, 0.03198376f, 0.12243854f, 0.00738036f, 0.06491003f, 0.00126177f, -0.12404519f, 
    -0.27391523f, -0.02211276f, -0.15884560f, -0.01665120f, -0.17204851f, 0.16168493f, 0.25875083f, 0.12402514f, 
    0.11804345f, 0.06432960f, -0.08965027f, -0.00181318f, 0.01452333f, 0.20689110f, -0.04800984f, -0.08010846f, 
    0.10501483f, 0.07361114f, 0.00285551f, -0.02763546f, 0.07082763f, -0.04066600f, 0.05981663f, -0.12003972f, 
    0.29747668f, -0.21131885f, 0.09699633f, -0.29991624f, 0.01258171f, 0.07394215f, -0.03891835f, 0.02636374f, 
    0.09981736f, 0.05294922f, 0.10114306f, -0.21571641f, 0.03157615f, 0.16036981f, 0.03196243f, -0.10432961f, 
    -0.02706387f, -0.05946504f, 0.08478600f, -0.14711978f, -0.20682824f, 0.03579830f, -0.08597196f, 0.06477287f, 
    -0.03898373f, 0.17775437f, -0.15356399f, 0.21764208f, -0.00385506f, -0.01472156f, 0.05538803f, 0.06895439f, 
    0.08301937f, 0.02359304f, 0.13768560f, 0.08629221f, -0.30744737f, 0.06060962f, 0.09410487f, -0.22902127f, 
    0.16125655f, 0.00492557f, 0.05324966f, 0.04690384f, 0.03555146f, -0.06045983f, 0.09039933f, -0.03135760f, 
    0.05485837f, 0.12462490f, -0.26988745f, 0.11640582f, 0.09493054f, -0.03840931f, 0.10348500f, -0.00055908f, 
    -0.11658124f, 0.02665554f, 0.10193720f, 0.12717395f, 0.51303637f, 0.12429842f, 0.07205637f, 0.02791017f, 
    0.07957984f, 0.05274742f, 0.18531686f, 0.04741019f, 0.02471916f, 0.03904031f, 0.09553018f, 0.03549122f, 
    0.14044319f, -0.14610358f, 0.00906476f, 0.11211740f, -0.31633678f, 0.13236284f, 0.02469833f, -0.10483053f, 
    -0.28235629f, 0.15301032f, 0.04426917f, -0.06091013f, 0.06288286f, -0.11587862f, -0.12679507f, 0.09764272f, 
    0.02261165f, 0.09344871f, -0.05140702f, -0.11916526f, 0.18673423f, -0.13687703f, 0.08878247f, 0.09502688f, 
    -0.10693066f, 0.03772863f, -0.10360537f, -0.23749787f, -0.06081044f, 0.07339240f, -0.15306675f, -0.05126480f, 
    0.05253043f, -0.02837665f, -0.11884806f, -0.07672868f, -0.08450317f, 0.06312295f, 0.04397222f, -0.18509440f, 
    -0.14887655f, -0.07894887f, -0.13140075f, -0.00149464f, -0.05240706f, 0.03722484f, 0.02955734f, -0.01356510f, 
    0.08540207f, -0.10042605f, 0.01801876f, 0.06377786f, -0.10354455f, 0.08939302f, -0.05036632f, 0.10800461f, 
    0.07426983f, 0.07603452f, -0.00939762f, 0.11292770f, -0.31468388f, 0.37681168f, -0.22718832f, 0.26456133f, 
    0.10946246f, -0.01365131f, -0.01856080f, -0.01707856f, 0.17007820f, 0.15095849f, 0.03569822f, 0.15560773f, 
    0.25578806f, -0.06256975f, -0.08796955f, 0.10183156f, 0.17758469f, 0.01842722f, -0.07204748f, -0.04747023f, 
    0.10367965f, -0.05258026f, -0.01830550f, -0.06530666f, 0.38788381f, -0.02857436f, 0.08450367f, -0.12248999f, 
    0.05235003f, -0.12184810f, 0.03298995f, -0.00013910f, 0.12430775f, 0.16179000f, 0.10871055f, 0.08040696f, 
    0.02588160f, -0.54401487f, 0.03421379f, -0.01738866f, -0.23010473f, -0.05833252f, 0.04491218f, 0.05875697f, 
    -0.07429942f, -0.00632938f, 0.01034533f, 0.09474418f, 0.32363558f, -0.00653670f, 0.14081661f, -0.11248243f, 
    0.14632343f, 0.11526955f, 0.08388143f, 0.03775061f, 0.04053606f, 0.08726998f, -0.13810723f, 0.05563442f, 
    -0.14903931f, 0.17265458f, 0.10552850f, 0.11595121f, 0.08124632f, -0.02945767f, 0.06613108f, 0.06171331f, 
    -0.00185747f, -0.04800047f, 0.02404284f, -0.07125831f, 0.03166577f, 0.22130935f, -0.14185756f, 0.35387060f, 
    -0.01799376f, 0.05231204f, 0.04773973f, -0.01992089f, 0.04938266f, 0.00156749f, 0.00919433f, -0.07706176f, 
    -0.25221482f, 0.07618997f, -0.03067092f, -0.13596573f, 0.01475142f, -0.12628135f, -0.03468669f, 0.01297589f, 
    0.17888275f, 0.06918737f, 0.14233786f, 0.22578795f, -0.02833648f, 0.31992376f, -0.17196019f, -0.11215167f, 
    0.22158046f, 0.07953632f, 0.01166852f, 0.14834602f, 0.03835754f, 0.08090193f, 0.06684002f, -0.10146245f, 
    0.24468356f, -0.00233000f, -0.22989094f, -0.17367290f, -0.04219329f, -0.00581513f, -0.12003305f, 0.03339067f, 
    -0.01307881f, 0.02113851f, -0.15546194f, -0.00236581f, -0.17778555f, 0.06629707f, 0.14463392f, -0.37543970f, 
    0.05278170f, 0.09975088f, 0.04011686f, 0.17972705f, 0.02896539f, 0.13983849f, -0.01047867f, -0.03793078f, 
    -0.00130593f, -0.05009392f, -0.04118146f, 0.02200466f, -0.05789294f, -0.04660656f, -0.01402888f, -0.03956584f, 
    0.02570774f, -0.05121076f, 0.01696677f, -0.05485101f, -0.01334684f, 0.03977872f, -0.03701649f, -0.01392535f, 
    -0.04521655f, 0.00771705f, -0.02647989f, -0.05007810f, -0.01422646f, 0.01926181f, -0.00756962f, 0.03817031f, 
    -0.01638032f, 0.00707873f, 0.02574467f, 0.00140177f, 0.04326063f, 0.01407449f, -0.02561554f, -0.05302321f, 
    0.02290130f, -0.01691794f, -0.00314696f, -0.04028857f, 0.01903321f, -0.03202699f, -0.02822790f, -0.05694789f, 
    -0.00649168f, -0.05943617f, -0.02317401f, -0.01438881f, -0.04558290f, 0.02785308f, -0.00255542f, -0.00832371f, 
    -0.06017844f, -0.04279161f, -0.02534429f, -0.04419609f, 0.01332785f, 0.03537595f, 0.03418785f, -0.00796713f, 
    0.01946770f, 0.02638143f, 0.01397487f, 0.01628986f, -0.04141952f, 0.00517684f, -0.04838882f, -0.02187487f, 
    0.00964412f, 0.01871261f, 0.03194490f, 0.03774437f, -0.05127898f, -0.04928436f, 0.00825089f, -0.03938325f, 
    -0.05157654f, -0.03711804f, 0.00481704f, -0.02212795f, 0.02684840f, 0.00449144f, -0.02049788f, 0.03950657f, 
    0.00709102f, 0.02959035f, -0.03429461f, -0.04691250f, -0.01909237f, 0.05323004f, 0.00767946f, 0.03635204f, 
    0.02613673f, 0.02018593f, 0.01012703f, -0.00922620f, -0.05227410f, -0.02728277f, -0.05402974f, 0.02205408f, 
    -0.00936781f, 0.03524468f, 0.03095601f, -0.05748481f, -0.02158494f, 0.01408362f, 0.03907294f, 0.03370729f, 
    0.03048756f, -0.00561593f, -0.00041121f, 0.03113389f, -0.01472950f, 0.02681066f, -0.04331348f, 0.03309174f, 
    -0.02877235f, -0.00440614f, -0.01569940f, -0.02734095f, -0.03525342f, 0.00071686f, -0.03677082f, -0.04166409f, 
    -0.02296496f, 0.02678440f, 0.02377402f, -0.02329605f, 0.03854575f, -0.01686196f, 0.00414626f, -0.02247476f, 
    0.02385920f, -0.03167026f, 0.00126565f, -0.01972495f, -0.02950829f, -0.03492316f, -0.01578220f, -0.00371586f, 
    -0.05166133f, -0.02716616f, 0.01592496f, 0.01648093f, -0.00365735f, -0.06079362f, 0.01475966f, 0.01738384f, 
    0.01650172f, -0.03273229f, 0.03590880f, -0.04949785f, -0.00501362f, -0.01202037f, 0.00832485f, -0.00407623f, 
    0.03599012f, -0.04153169f, -0.00023539f, -0.05273290f, -0.04184647f, 0.04112431f, -0.02272666f, 0.05070511f, 
    -0.00932224f, 0.01111196f, 0.01269383f, -0.01886079f, 0.01194147f, -0.02093373f, -0.01464727f, -0.04701266f, 
    0.00243198f, -0.04035510f, 0.02976474f, -0.03053300f, 0.00807447f, -0.00402525f, -0.01808262f, -0.05820633f, 
    -0.00484763f, 0.03664792f, -0.02676605f, -0.00743913f, 0.02761423f, 0.03712512f, 0.03087091f, 0.00823874f, 
    -0.04428025f, 0.04069740f, 0.03692823f, -0.03429445f, -0.00006436f, -0.03089872f, -0.00906613f, -0.04870202f, 
    -0.00288008f, 0.01576583f, -0.01812607f, -0.04059304f, 0.00555811f, 0.04271309f, -0.01635670f, 0.00449612f, 
    0.04222770f, -0.02561101f, 0.04077313f, 0.03796931f, 0.00087330f, 0.03026555f, -0.05264029f, 0.03180790f, 
    0.02353885f, 0.01742537f, -0.04070622f, -0.03738442f, -0.00804936f, 0.03536576f, -0.03422321f, -0.01717644f, 
    0.03633681f, 0.03941059f, -0.00150053f, -0.04555320f, -0.04878161f, 0.03805328f, 0.02310638f, -0.00297865f, 
    0.04143934f, -0.01398931f, 0.00724788f, -0.02013938f, 0.02769054f, -0.01308921f, 0.01149860f, 0.00603130f, 
    0.02674070f, -0.02430391f, -0.04043167f, 0.01113108f, -0.04916645f, -0.05330405f, 0.03775001f, -0.04345464f, 
    0.03816508f, -0.05575985f, -0.01149652f, 0.02832573f, 0.03945676f, -0.05044840f, -0.03298618f, -0.02926214f, 
    -0.05724329f, -0.04729186f, -0.03593868f, -0.01837443f, 0.01028221f, -0.01875491f, 0.03678225f, -0.03635336f, 
    0.04243018f, -0.05119915f, -0.05100287f, -0.01576985f, 0.01273024f, -0.03264244f, -0.03222479f, -0.04677545f, 
    -0.00280019f, -0.01179071f, -0.03972957f, 0.01951469f, 0.03543207f, 0.02910427f, 0.02512007f, 0.02989026f, 
    -0.00611230f, 0.02267523f, 0.01513044f, 0.02980615f, -0.03450383f, 0.00575621f, 0.05233375f, -0.04001921f, 
    -0.04158220f, -0.04720137f, -0.02514587f, -0.05153356f, -0.00395045f, -0.03644767f, -0.00203512f, -0.04760711f, 
    -0.03351285f, -0.05077252f, 0.01089341f, 0.03627083f, 0.03232886f, -0.05378772f, -0.03672554f, 0.00624066f, 
    -0.00487150f, 0.00898392f, -0.04076954f, -0.00115853f, -0.01967095f, 0.00195988f, -0.05256334f, 0.01035825f, 
    -0.05572305f, 0.04413868f, -0.03867884f, 0.03994890f, -0.04439617f, -0.01096568f, -0.00687786f, -0.00145453f, 
    -0.01285614f, -0.00244627f, 0.01255761f, -0.01286418f, -0.01859665f, -0.03786021f, -0.06061054f, -0.00599236f, 
    -0.03273633f, 0.04460921f, 0.00354735f, 0.03205709f, 0.03642626f, -0.02010184f, -0.04249465f, -0.04988188f, 
    -0.02990420f, -0.05047370f, 0.03640600f, -0.05745680f, 0.03473829f, -0.05627970f, -0.02497024f, -0.03078667f, 
    0.00958322f, -0.04315979f, -0.05116237f, 0.01082795f, -0.00221844f, 0.01594925f, 0.00456863f, -0.00909465f, 
    -0.02011710f, 0.00757513f, 0.03891156f, 0.03868224f, -0.03311354f, 0.02523835f, 0.00800452f, -0.01169411f, 
    0.02291743f, -0.02000960f, 0.03631016f, 0.02637029f, 0.04023609f, -0.02216612f, -0.05409739f, 0.04300234f, 
    -0.00816336f, -0.04742096f, -0.00704935f, -0.04620431f, 0.00545284f, 0.00891976f, -0.02815604f, -0.02369442f, 
    -0.00808813f, 0.02673971f, -0.04713859f, -0.00864259f, -0.01387275f, 0.04757111f, 0.04448785f, -0.01432251f, 
    -0.02144799f, 0.04021067f, -0.02690263f, 0.03148325f, 0.03685933f, -0.04819337f, 0.01101780f, 0.01919067f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01667084f, -0.01301987f, 0.00334720f, 0.20589033f, -0.01390877f, 0.00326641f, 0.02224221f, 0.08367982f, 
    0.09535370f, -0.00875397f, -0.01284003f, -0.03304737f, 0.03471305f, -0.07099088f, -0.02236873f, 0.01908330f, 
    -0.03118797f, 0.02260541f, 0.05657314f, 0.04637922f, 0.12794846f, 0.06675262f, -0.03652049f, -0.04500311f, 
    -0.02316472f, 0.12729348f, -0.04760925f, -0.03619933f, -0.01678389f, -0.00856278f, 0.02425712f, 0.01449868f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03657887f, 0.09792395f, 0.15216759f, -0.10628238f, -0.11872284f, 0.04099357f, -0.13750610f, -0.18573365f, 
    0.02541704f, 0.16757427f, -0.02682582f, -0.11125983f, 0.06967021f, -0.02530952f, -0.10209071f, -0.09545086f, 
    0.03574731f, -0.09496853f, 0.10575971f, 0.04575757f, 0.06037822f, 0.12056413f, 0.07128318f, 0.13174424f, 
    -0.09692603f, -0.17334388f, -0.01039497f, 0.06274709f, 0.04706993f, 0.09922156f, -0.09611017f, 0.15340979f, 
    0.10210401f, 0.13847649f, -0.00140362f, 0.27145135f, -0.05147177f, 0.00770666f, 0.06587822f, -0.02112251f, 
    0.09257687f, 0.00526886f, 0.12635385f, -0.30511320f, -0.06888930f, -0.08335486f, 0.12695231f, 0.06460457f, 
    -0.34951276f, 0.04295896f, 0.47162095f, 0.01817852f, 0.13624108f, 0.32377887f, 0.09385329f, -0.03180531f, 
    -0.02198010f, 0.10236750f, -0.07140268f, 0.22581597f, -0.03612860f, -0.14420433f, -0.17812584f, 0.08405066f, 
    -0.47768402f, -0.08302679f, -0.09168024f, 0.11303579f, 0.18630844f, 0.11412384f, -0.01250798f, -0.12357603f, 
    0.02417874f, -0.12432411f, 0.12382921f, -0.31813169f, -0.00741610f, 0.06162315f, 0.01072941f, 0.46102709f, 
    0.10076122f, -0.08507930f, 0.18479577f, -0.06014590f, -0.08358701f, -0.31322768f, 0.10950671f, 0.06770886f, 
    -0.09357496f, 0.40129048f, 0.14055111f, 0.39350435f, -0.12615134f, -0.15546340f, -0.30780786f, 0.14944421f, 
    0.40635675f, 0.09583697f, -0.02109336f, 0.13500503f, -0.16056591f, 0.08734377f, -0.13421658f, -0.22788954f, 
    0.22759299f, 0.08527174f, 0.03806245f, -0.29564250f, 0.15173632f, 0.15362322f, 0.10884268f, -0.01356869f, 
    -0.23758608f, 0.15609522f, -0.24593587f, 0.02679082f, 0.10490506f, -0.06750051f, 0.05373601f, -0.08156715f, 
    -0.15401833f, 0.00044209f, 0.20813814f, 0.14367063f, 0.10207912f, 0.06916329f, 0.45465738f, -0.12702532f, 
    -0.46733350f, -0.07699178f, -0.04621261f, 0.10731678f, 0.28966957f, 0.04141140f, -0.11658088f, -0.43772209f, 
    0.20919016f, -0.13505392f, 0.06445738f, 0.43228200f, -0.18731244f, 0.22835089f, -0.08917412f, 0.00221151f, 
    0.04329306f, -0.03871733f, -0.53521109f, 0.02386053f, 0.05810178f, -0.00600832f, -0.06643531f, 0.10922953f, 
    0.02139751f, 0.21611905f, -0.24661456f, -0.05321207f, 0.11436764f, -0.10842651f, 0.21474810f, -0.16655751f, 
    -0.33329657f, 0.09387305f, 0.08602934f, 0.05203609f, 0.03156459f, 0.00646606f, 0.10403118f, -0.11431090f, 
    0.17092595f, -0.02087021f, -0.18339828f, -0.50589424f, -0.13407373f, 0.46051556f, 0.07982533f, 0.12914760f, 
    -0.27553907f, 0.17370227f, -0.08184928f, -0.17134266f, 0.05539840f, -0.30009127f, 0.14650540f, 0.13759540f, 
    0.10640535f, 0.30832922f, -0.03780973f, 0.17525144f, 0.05370067f, -0.00287609f, 0.28970033f, -0.14715336f, 
    0.49323863f, -0.04391830f, -0.08923829f, -0.20448855f, 0.40549862f, -0.04626936f, 0.09055202f, -0.17721152f, 
    0.12643254f, 0.06292069f, -0.04876601f, 0.21140236f, -0.06051045f, 0.00690749f, -0.07669179f, 0.13492431f, 
    -0.40485790f, -0.13262084f, -0.12562677f, 0.02209492f, 0.26624224f, -0.48463494f, -0.05132119f, 0.04831618f, 
    -0.03462830f, -0.25203133f, -0.17010587f, 0.04935651f, 0.11015286f, -0.07277735f, 0.37914753f, -0.00471368f, 
    0.53294122f, 0.01188417f, 0.12407055f, 0.08182632f, 0.25089470f, 0.06526293f, 0.16646199f, -0.16736835f, 
    0.07870171f, 0.08410752f, 0.03495514f, 0.24439120f, -0.07814341f, -0.37312859f, 0.04405446f, 0.05872001f, 
    -0.08451827f, -0.10391914f, 0.31606755f, -0.14289896f, 0.29770446f, 0.02289761f, 0.00513653f, -0.01030853f, 
    -0.09964576f, 0.05295283f, -0.35366517f, -0.28200153f, -0.02195091f, -0.00080114f, -0.10867231f, -0.10235810f, 
    -0.33514196f, 0.16271457f, 0.11045972f, 0.07253044f, 0.39415628f, 0.17216045f, 0.07416342f, 0.14758836f, 
    -0.15233365f, -0.07140243f, 0.07010645f, 0.36469498f, -0.05687758f, -0.03544213f, 0.16287003f, 0.33895034f, 
    -0.38257569f, -0.10544871f, -0.26338479f, -0.00882475f, 0.19748724f, -0.34673062f, -0.02103343f, -0.03632976f, 
    -0.16046008f, -0.18609577f, -0.24056853f, -0.02824973f, 0.10447749f, -0.04216324f, 0.14237961f, -0.04601670f, 
    0.39027297f, 0.05130442f, 0.04123731f, -0.29347539f, -0.11899135f, 0.01016448f, 0.14097309f, -0.24386953f, 
    -0.25208864f, -0.00481202f, -0.02251631f, 0.34424967f, 0.04742282f, -0.11372446f, -0.08517868f, 0.16565827f, 
    0.56048185f, -0.16256218f, 0.23911484f, -0.07635258f, 0.26617146f, 0.21321836f, -0.07682921f, -0.05095121f, 
    0.01144368f, 0.34486613f, -0.26744357f, 0.17216814f, 0.11886170f, -0.13569720f, 0.10917264f, 0.11611046f, 
    0.40462548f, -0.00143818f, 0.07408804f, 0.12171652f, -0.05509236f, -0.06140159f, 0.15922207f, 0.53254569f, 
    0.19862010f, -0.17000087f, -0.04572720f, 0.04091119f, 0.12216381f, -0.05758502f, -0.15607654f, -0.21626474f, 
    -0.40337706f, 0.14110161f, 0.03539131f, -0.06552931f, 0.20397486f, -0.22072725f, 0.16214220f, -0.09109234f, 
    0.07281145f, -0.16732998f, 0.21063091f, -0.11508577f, -0.00465378f, 0.15404953f, 0.14868195f, 0.05167169f, 
    0.10337146f, -0.10387149f, 0.12403029f, 0.12227095f, 0.15130010f, 0.04909105f, -0.07183218f, -0.17612609f, 
    -0.10843093f, -0.03232686f, -0.02333669f, -0.03040387f, -0.10063736f, -0.11645447f, 0.09282323f, -0.12468687f, 
    -0.15654992f, -0.06332967f, -0.13984218f, -0.16170987f, -0.05382966f, -0.06072325f, -0.09765336f, 0.13362671f, 
    0.16571662f, -0.08277865f, -0.03657150f, -0.06383799f, -0.16332881f, -0.08192085f, -0.10199700f, 0.11243723f, 
    -0.20338060f, -0.09160139f, 0.13357915f, 0.51433843f, 0.22431356f, -0.14024515f, 0.11155649f, 0.30542538f, 
    0.18418263f, -0.05519947f, -0.12553979f, -0.22583927f, -0.15115131f, -0.14491458f, -0.13122319f, 0.22213157f, 
    -0.53299326f, -0.10384812f, -0.06395371f, -0.08706757f, 0.26863125f, 0.05863975f, -0.13856314f, -0.00657702f, 
    -0.13571893f, -0.13924807f, -0.00216402f, -0.00020074f, 0.16560182f, 0.07906456f, -0.16428316f, 0.06931806f, 
    -0.14082965f, 0.12352875f, -0.13921171f, 0.07679229f, -0.20294218f, 0.04407467f, 0.03416283f, 0.37658370f, 
    -0.01382160f, -0.11846714f, 0.12033297f, -0.06949151f, -0.07155620f, -0.18460628f, 0.01509755f, 0.32340679f, 
    0.00746156f, -0.13638952f, -0.07277266f, 0.02093912f, -0.10917876f, -0.29593080f, -0.10358188f, -0.17009252f, 
    -0.17579010f, 0.26787645f, -0.13118625f, -0.02124655f, 0.12109468f, 0.00614292f, 0.37462845f, 0.01441577f, 
    -0.35572237f, 0.18068570f, 0.02542863f, -0.12024202f, 0.32097456f, -0.09134258f, 0.02746360f, -0.17707196f, 
    0.23732537f, 0.15962464f, -0.00246958f, -0.08631492f, -0.15603141f, 0.49156931f, -0.15120582f, -0.28296322f, 
    -0.31058037f, 0.01202359f, -0.57831830f, -0.13173889f, 0.20283069f, -0.02070059f, -0.16329291f, -0.15113808f, 
    0.01991111f, -0.01954249f, 0.11493420f, 0.11217545f, 0.07476124f, -0.00639624f, 0.44408253f, 0.07780812f, 
    -0.08926953f, -0.09808891f, 0.01121094f, -0.01705828f, -0.02699206f, 0.15777174f, -0.06072240f, -0.05393707f, 
    0.12528552f, -0.12022246f, -0.08148066f, -0.06375467f, 0.04881722f, -0.07877295f, 0.15345421f, -0.18262205f, 
    0.13135365f, 0.06213219f, -0.06931165f, 0.00055164f, 0.00165455f, 0.13318145f, 0.10957871f, -0.12350676f, 
    -0.15748364f, -0.16748610f, -0.02810675f, -0.18736078f, -0.02002901f, 0.03983895f, -0.15402895f, 0.15543199f, 
    -0.39550346f, 0.11907467f, -0.06572133f, 0.08442163f, 0.36268485f, -0.03642438f, 0.07916034f, 0.04338226f, 
    0.11332860f, -0.03765802f, -0.01801200f, -0.05183179f, -0.03569577f, 0.23191522f, -0.12562917f, -0.21313323f, 
    0.41865280f, -0.12723130f, -0.16512568f, 0.14043206f, -0.14931345f, 0.11658516f, -0.00185232f, -0.07639995f, 
    0.07672802f, 0.10021167f, 0.39264119f, 0.15733096f, -0.17009906f, 0.07756988f, -0.19299772f, -0.15174395f, 
    0.17333458f, -0.13912405f, 0.13992050f, -0.05803838f, -0.28199673f, -0.07740783f, -0.11932894f, 0.37172964f, 
    -0.44860658f, -0.00207681f, -0.16255556f, -0.34003383f, -0.15549541f, 0.01875985f, -0.04513871f, 0.33930215f, 
    -0.22003542f, 0.05033178f, 0.41682291f, -0.10068220f, 0.14358619f, -0.08528989f, -0.05369442f, -0.00832386f, 
    0.07035575f, -0.11880076f, -0.08184706f, 0.29300472f, 0.10938359f, 0.10325019f, 0.21336973f, -0.00760226f, 
    -0.04493402f, 0.13897495f, -0.13001195f, -0.08072084f, -0.14926575f, 0.16038048f, -0.16261780f, -0.12768571f, 
    -0.14616698f, -0.12139193f, -0.04587904f, -0.16981354f, -0.12673804f, 0.02816752f, -0.06173268f, -0.04781508f, 
    0.12364437f, -0.03612802f, -0.11393202f, -0.15537980f, 0.08521107f, -0.08891417f, -0.12720878f, -0.02676605f, 
    0.05279828f, 0.01871325f, -0.17288111f, 0.00347799f, 0.04760299f, 0.03092068f, -0.04219140f, 0.11943896f, 
    -0.01170849f, 0.13193314f, -0.15924431f, 0.27196622f, -0.02197215f, -0.06664243f, 0.10703846f, -0.01633013f, 
    -0.36314449f, -0.06206534f, 0.14729156f, 0.13753501f, -0.12967448f, 0.36777136f, -0.10612573f, -0.18960859f, 
    0.01252357f, -0.11909990f, -0.18919802f, -0.13888742f, -0.01871940f, 0.24192031f, -0.11485434f, -0.09284999f, 
    0.05304479f, -0.25825372f, 0.30135745f, 0.39463046f, -0.03320077f, -0.07267292f, -0.03623392f, 0.11764828f, 
    0.47590944f, -0.13054106f, 0.12199564f, -0.11868414f, 0.24342154f, -0.11208901f, 0.12357827f, 0.03744965f, 
    0.13482365f, -0.04577247f, -0.09699317f, -0.25244829f, -0.14248674f, 0.22256549f, -0.07212644f, 0.04699357f, 
    0.04868881f, -0.06717984f, 0.49217367f, -0.16061462f, 0.10931137f, -0.31970716f, 0.13244905f, -0.05615078f, 
    -0.04173265f, -0.04972589f, 0.45551747f, 0.32586670f, 0.13071825f, 0.07214760f, -0.39748624f, 0.05125438f, 
    0.13698225f, 0.16640395f, 0.04293253f, 0.20634031f, -0.09277468f, 0.11802197f, -0.09693092f, 0.10732847f, 
    -0.55303442f, -0.18152472f, -0.07028326f, 0.24473669f, 0.15542138f, 0.20305547f, 0.09226859f, 0.06248899f, 
    0.17746852f, -0.12178765f, -0.06616928f, 0.15446874f, -0.10684898f, 0.17087030f, -0.14636892f, -0.09449072f, 
    -0.10394216f, 0.18466660f, 0.17921771f, 0.32935968f, -0.03918913f, 0.06917070f, -0.24653883f, -0.17849861f, 
    0.59374619f, 0.12224375f, -0.06892189f, -0.00645505f, -0.24021965f, -0.12192578f, 0.12137608f, 0.13461390f, 
    0.07170893f, 0.13005275f, 0.06266911f, 0.47315586f, -0.14760891f, -0.39551613f, -0.04896626f, 0.30142102f, 
    -0.10510109f, -0.11094365f, 0.00014648f, -0.10639325f, 0.12664120f, -0.06024534f, -0.14243323f, -0.14466907f, 
    0.14657892f, 0.15243109f, -0.32637489f, -0.17890321f, -0.15996410f, 0.09216017f, 0.22106999f, -0.00306558f, 
    0.04598349f, 0.12394755f, -0.02911633f, 0.02389986f, 0.15503867f, -0.12035322f, -0.08800226f, 0.38873041f, 
    0.23242146f, -0.16543061f, -0.00424163f, 0.15679795f, -0.10189050f, 0.05584230f, 0.00999540f, -0.24435467f, 
    0.33811489f, -0.14383595f, 0.10693307f, 0.00501629f, 0.07916798f, -0.05757914f, -0.14413679f, -0.11955432f, 
    -0.10462137f, -0.08097909f, 0.62875342f, -0.57670701f, 0.06901155f, -0.02527412f, -0.28139713f, 0.16527548f, 
    0.21739615f, -0.08795676f, -0.16435324f, 0.19524594f, 0.07450063f, 0.06205611f, -0.01132783f, 0.15252724f, 
    0.27408150f, -0.04721360f, 0.08156075f, -0.05360429f, 0.17275156f, -0.23315996f, -0.04527952f, 0.29095900f, 
    0.13191088f, 0.02286770f, 0.06930126f, -0.13973370f, -0.23922184f, 0.07068209f, -0.13712959f, -0.13671325f, 
    0.03991127f, 0.36343414f, 0.11674392f, -0.08657306f, -0.05445581f, -0.12648134f, -0.14605328f, -0.07829034f, 
    0.30163476f, 0.10433636f, 0.08374467f, 0.26039129f, -0.03973674f, -0.07101972f, -0.11291494f, 0.33325610f, 
    0.55474132f, -0.04872587f, 0.03613876f, -0.02352442f, 0.09440192f, -0.14101745f, -0.12318672f, -0.09809712f, 
    -0.36638805f, -0.13897452f, 0.09254345f, 0.05063708f, 0.03814500f, -0.03064224f, 0.00228372f, 0.05681037f, 
    0.16871309f, 0.06578421f, 0.35928690f, -0.32764974f, -0.10313178f, -0.13971375f, 0.15085854f, -0.15312938f, 
    0.05657867f, -0.07390328f, -0.10178244f, -0.11693960f, -0.12391093f, -0.12157777f, -0.15037765f, -0.19583420f, 
    0.01782526f, 0.01254247f, 0.14216663f, 0.04816675f, 0.17556044f, -0.17264998f, -0.12334327f, -0.14810179f, 
    -0.16103390f, -0.04912348f, 0.07688223f, 0.05621684f, 0.04652015f, 0.12976205f, 0.16424632f, -0.12481660f, 
    -0.02408484f, 0.08137026f, -0.15205427f, -0.07577001f, 0.04867360f, 0.08783471f, 0.00051695f, -0.09272511f, 
    0.46152815f, 0.11265142f, 0.00995903f, 0.11293261f, 0.14416160f, -0.04014922f, -0.09763336f, 0.14816342f, 
    0.14517947f, 0.04267138f, -0.15287384f, 0.34963641f, 0.08545522f, 0.08395097f, -0.14166258f, 0.22637214f, 
    0.72801286f, 0.09684575f, 0.19440328f, 0.11909139f, -0.18870875f, -0.37347904f, -0.15741761f, 0.00257257f, 
    -0.13345876f, 0.01315322f, 0.24714245f, 0.01045633f, -0.01097010f, -0.13533397f, -0.32814214f, -0.14528002f, 
    -0.42404014f, -0.02347516f, -0.10285804f, 0.35556817f, 0.21042281f, -0.16671702f, 0.10338522f, -0.25769210f, 
    0.12453789f, 0.09265650f, -0.06553779f, 0.29390836f, -0.03062547f, -0.15732765f, -0.16593534f, -0.28708029f, 
    0.17013207f, -0.00277024f, 0.01423484f, 0.02079547f, 0.08390524f, 0.50167882f, 0.16449337f, 0.03014448f, 
    -0.01266698f, 0.02401163f, -0.05830514f, -0.05768904f, 0.16205247f, -0.03668779f, -0.15039018f, 0.12469673f, 
    -0.02543571f, -0.16254492f, -0.02993638f, -0.26969463f, -0.05676840f, 0.11484781f, -0.04140170f, -0.36194399f, 
    -0.48508728f, -0.04764983f, 0.03913044f, 0.29872814f, 0.00344150f, 0.09845678f, 0.14479603f, 0.20866995f, 
    0.48992762f, 0.09848601f, 0.39614075f, -0.04293372f, 0.22883338f, 0.49508148f, 0.08038059f, -0.14636798f, 
    0.09852272f, 0.36466077f, -0.24596354f, 0.19535217f, -0.10663340f, 0.06788371f, 0.20546763f, -0.07906200f, 
    -0.59397089f, 0.01401439f, -0.15745005f, 0.31570637f, -0.24348198f, -0.02941089f, 0.10117837f, 0.30611172f, 
    0.02489625f, 0.14177948f, 0.01832902f, -0.15280494f, -0.14049290f, 0.00280967f, 0.06584983f, -0.12178529f, 
    -0.21784385f, 0.13619192f, 0.16029453f, -0.02845574f, 0.22484106f, 0.71744710f, 0.06014670f, 0.09377106f, 
    -0.00496676f, -0.07541297f, -0.06187708f, -0.09898281f, -0.01938992f, -0.13432674f, 0.28465751f, 0.15606748f, 
    0.11173914f, -0.08258641f, 0.02929208f, 0.16296805f, 0.16759402f, 0.00155412f, 0.06198708f, 0.08745523f, 
    -0.16758697f, -0.16285230f, -0.09409408f, -0.14074667f, -0.14828277f, -0.16628680f, 0.08523203f, -0.03232798f, 
    -0.05763341f, -0.14066125f, -0.15280667f, -0.02375521f, -0.18059018f, 0.12152806f, 0.09617274f, -0.03110812f, 
    -0.05174632f, -0.17908004f, -0.16405392f, -0.01883464f, 0.00870522f, -0.07754914f, -0.03227370f, 0.02597803f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07774360f, 0.28737807f, -0.05276239f, 0.06153867f, 0.18563737f, 0.02796988f, 0.09634857f, 0.17454335f, 
    0.07623987f, 0.22148384f, 0.20381752f, 0.08118186f, 0.17437698f, 0.03225222f, 0.13750342f, 0.03961824f, 
    0.03933591f, -0.18396613f, 0.16105089f, -0.06115592f, -0.16641830f, -0.09878824f, -0.01992439f, 0.14378867f, 
    -0.03741111f, -0.08065741f, -0.05701492f, 0.11389700f, 0.25870463f, -0.10945968f, -0.10929244f, -0.17250887f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.08342090f, -0.09082719f, 0.17064604f, -0.32453337f, 0.06415632f, -0.18193680f, -0.71823692f, -0.45476353f, 
    -0.04460791f, 0.02086724f, -0.39039382f, 0.01603618f, -0.03330143f, -0.35204995f, -0.12523751f, 0.07037386f, 
    0.38954127f, -0.27145261f, 0.13646960f, 0.53251380f, -0.10268924f, 0.41561806f, -0.50166780f, -0.32458842f, 
    0.06042673f, -0.46119529f, 0.12502730f, 0.20885478f, 0.33686566f, 0.06657255f, 0.09580012f, -0.09824256f, 
    0.00255170f, 0.19181356f, 0.29191965f, -0.07068500f, -0.22637351f, -0.05906532f, -0.61041045f, -0.04477418f, 
    -0.35975525f, 0.37372881f, -0.52610052f, -0.04268301f, -0.18586251f, 0.21762145f, -0.62151539f, -0.09161342f, 
    -0.08228751f, 0.10241011f, -0.05011288f, -0.27483699f, 0.02833720f, -0.05352180f, 0.01714720f, 0.41564021f, 
    0.16522360f, -0.38057294f, 0.12039544f, 0.18106471f, -0.03000176f, 0.30621669f, -0.14384241f, 0.10166959f, 
    0.13297340f, -0.55769908f, -0.02735142f, -0.25721112f, 0.39226580f, -0.12856686f, 0.08473007f, 0.04490042f, 
    0.24581562f, 0.29077584f, -0.45897573f, -0.02879135f, -0.59071779f, 0.01047064f, 0.19030805f, 0.02942571f, 
    0.00228165f, -0.21190487f, -0.07951444f, -0.14178620f, -0.32664025f, -0.03139844f, 0.24411348f, -0.42216951f, 
    -0.28036803f, -0.35320616f, -0.18684001f, -0.01208914f, -0.02632135f, 0.29847419f, -0.21766466f, -0.00902262f, 
    0.13131484f, 0.18640055f, -0.56007856f, 0.24998157f, -0.17066371f, -0.27960360f, -0.49651411f, -0.08447908f, 
    -0.38975185f, -0.41488385f, 0.29306778f, 0.09329372f, 0.12202764f, -0.42079905f, -0.02319059f, 0.09221423f, 
    0.10495710f, -0.52535099f, -0.06380926f, 0.22190510f, 0.01079122f, -0.21923907f, -0.23090841f, 0.31666839f, 
    -0.10149112f, 0.17122491f, 0.10158887f, -0.12751739f, 0.24818623f, -0.59712714f, 0.35267431f, -0.12466010f, 
    -0.16524425f, -0.01025471f, 0.28662756f, -0.00721500f, -0.16593631f, 0.23107532f, -0.30011919f, -0.44382557f, 
    -0.15219459f, -0.33590123f, 0.01735508f, -0.09345835f, -0.02706791f, 0.17375116f, 0.11262147f, 0.07285003f, 
    0.26690170f, -0.23771107f, -0.00616527f, -0.16926183f, 0.25303620f, -0.10246293f, -0.35237479f, 0.12467877f, 
    0.28954676f, 0.23515539f, 0.03029896f, 0.09565738f, -0.24952319f, -0.31859228f, -0.17037404f, 0.13340391f, 
    -0.04503231f, 0.31602654f, 0.18366660f, -0.22187659f, -0.55916864f, -0.12195173f, 0.05880916f, 0.21988288f, 
    0.24926694f, -0.12138604f, 0.05107311f, -0.09187655f, 0.22199079f, -0.05883866f, -0.49407491f, 0.03327572f, 
    -0.24589495f, 0.39002159f, -0.15684415f, 0.02544898f, 0.21227838f, 0.03818569f, 0.04774104f, -0.36239511f, 
    0.03631476f, -0.04692069f, 0.10704087f, -0.04647814f, -0.16991441f, -0.07034565f, 0.00197814f, -0.10038126f, 
    -0.13067257f, 0.17558461f, -0.14573379f, 0.37977436f, -0.05967694f, 0.11052513f, 0.06431077f, -0.22543436f, 
    0.03797005f, -0.06142369f, -0.02786332f, -0.06138425f, 0.10768626f, 0.12098137f, 0.30244410f, -0.10352322f, 
    -0.20147099f, 0.42216912f, 0.11048835f, 0.12148122f, -0.32413071f, -0.16772848f, -0.25113311f, -0.41747469f, 
    -0.66926736f, -0.22922444f, 0.11433981f, -0.81896788f, -0.18783832f, 0.09756919f, 0.38900325f, 0.16203417f, 
    0.01678406f, -0.62132108f, -0.28324601f, -0.50091928f, -0.23418610f, -0.51631385f, 0.36439183f, 0.14274380f, 
    0.41255403f, -0.17874661f, 0.22102091f, -0.18100585f, 0.08119289f, -0.50688344f, 0.05385097f, -0.06648671f, 
    0.19508359f, 0.03342292f, -0.08354950f, 0.00837694f, 0.16842763f, -0.31894279f, -0.18592313f, 0.37074012f, 
    -0.53482193f, -0.06858762f, 0.03814002f, 0.27482551f, -0.07926612f, -0.17546587f, -0.20430344f, -0.10596068f, 
    -0.02512163f, -0.07361648f, -0.55759430f, 0.26500407f, -0.41225901f, -0.27093408f, 0.34698814f, 0.18824884f, 
    -0.52777857f, 0.31772983f, 0.12140995f, 0.00429134f, -0.56033063f, -0.37038359f, -0.22341454f, -0.00113330f, 
    -0.42715135f, 0.21303540f, -0.00959984f, 0.03456138f, 0.19741133f, 0.01612992f, 0.24177991f, -0.01005251f, 
    -0.00450673f, -0.01955973f, -0.01339328f, 0.10451789f, -0.42248011f, 0.20267372f, -0.44774368f, 0.14380990f, 
    0.06844916f, 0.15638378f, 0.09388737f, 0.27630612f, 0.36952460f, 0.13896446f, 0.33269581f, 0.16037592f, 
    0.06418964f, -0.11828662f, -0.26871595f, -0.02217422f, 0.06640698f, -0.69935423f, 0.26057148f, 0.00659399f, 
    0.09698841f, -0.49251229f, -0.10956633f, 0.03727706f, 0.18278103f, -0.27509779f, -0.44244996f, -0.66369498f, 
    -0.38260517f, -0.26075077f, -0.09358727f, -0.22330530f, 0.16402979f, -0.11497337f, -0.32547310f, 0.09483611f, 
    -0.11275107f, 0.20046593f, -0.42734060f, -0.69275498f, 0.08706553f, -0.36201927f, -0.25047401f, 0.37831351f, 
    0.12833847f, 0.03459569f, 0.03144776f, 0.12149847f, 0.15040320f, -0.24220736f, -0.31823909f, -0.10807434f, 
    -0.15885471f, -0.34550959f, -0.17172894f, -0.60875744f, -0.51362562f, -0.37796515f, 0.19432245f, 0.05037891f, 
    0.11008577f, 0.11690942f, -0.01960089f, -0.28051353f, 0.28467435f, 0.19912636f, 0.26124337f, 0.08437927f, 
    0.08103820f, -0.22676174f, -0.07018692f, 0.23017956f, 0.19766933f, -0.06765652f, 0.19297621f, -0.01685784f, 
    0.33943513f, -0.26829261f, 0.16501278f, -0.08654040f, 0.20943731f, 0.51158911f, -0.06417768f, 0.00941074f, 
    -0.33336127f, -0.32359341f, -0.11991705f, -0.36007431f, -0.57768148f, -0.25992000f, 0.39931127f, -0.43614158f, 
    0.13949385f, 0.08720618f, -0.06369200f, 0.05709429f, 0.01263769f, -0.53087175f, -0.05734478f, 0.01023578f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.12896182f, 0.03366769f, -0.20539562f, 0.03708298f, 0.13601589f, -0.16431063f, -0.09774541f, -0.15432565f, 
    -0.02099855f, -0.15549222f, 0.01586772f, 0.03883116f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
