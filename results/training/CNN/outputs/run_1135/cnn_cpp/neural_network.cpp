#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.08254336f, 0.13119419f, 0.11218149f, 0.51665020f, -0.30934140f, -0.95008808f, -0.88066691f, -0.62408799f, 
    -0.76035690f, -1.05598748f, 0.94206727f, -0.52381998f, 0.32479659f, 0.47929227f, 0.27696151f, -0.33012953f, 
    0.39106956f, -0.35975537f, -0.39295107f, -0.71637720f, -0.13867432f, 0.10763373f, -0.00335315f, 0.05981664f, 
    -0.17951755f, 0.13251597f, -0.66370583f, -0.36007816f, -0.04772325f, 0.35198250f, 0.18766907f, 0.01225255f, 
    0.15480472f, 0.27735206f, -0.16641882f, -0.02167551f, 0.37267664f, -0.30798936f, -0.42119065f, 0.08362979f, 
    -0.35849407f, -0.06663785f, 0.16574985f, -0.46596757f, -0.20154017f, 0.39735359f, 0.38920861f, 0.02741797f, 
    0.11204938f, 0.33184433f, 0.74810821f, 0.88542271f, 0.79130077f, -0.22174977f, -0.88340169f, -0.33553395f, 
    -0.44296896f, -0.14785537f, -0.25699958f, -0.19526289f, -0.08268716f, -0.19912747f, -0.17376581f, 0.41389462f, 
    0.15896675f, -0.06088729f, -0.06858169f, 0.33308783f, -0.07752619f, 0.14038105f, 0.08025064f, -0.17857839f, 
    -0.01767724f, -0.35258514f, -0.11800532f, -0.43214536f, -1.25924921f, -1.01733184f, -0.60552973f, -0.91637528f, 
    1.15034997f, 0.72131252f, 0.20525908f, -0.16376290f, 0.65751249f, 0.36350355f, -0.08286414f, -0.11295781f, 
    0.09980142f, 0.30430749f, -0.51823413f, 0.11335439f, -0.17383848f, -0.48590621f, -0.48917621f, 0.09108607f, 
    -0.28155464f, 0.42637491f, 0.43772423f, 0.18780348f, 0.50543648f, 0.20997643f, -0.31288701f, -0.48366630f, 
    0.26871911f, -0.73751378f, -0.05666494f, 0.24734932f, -0.35241705f, 0.16677669f, -0.00263158f, -0.72582197f, 
    1.20632446f, -0.63525218f, -0.20504953f, 0.32593051f, -0.03462210f, 0.07881795f, -0.01310205f, -0.23113649f, 
    -0.09439172f, 0.19316685f, 0.04768358f, 0.33785403f, 0.06276736f, 0.00687521f, 0.23958763f, 0.27544993f, 
    0.43863928f, 0.57041568f, 0.08527477f, -0.00718473f, 0.19010419f, 0.20720783f, 0.13189273f, 0.10693000f, 
    0.24566354f, 0.12372653f, 0.08516353f, 0.01333518f, -0.16761993f, 0.01949256f, 0.11487235f, -0.25741252f, 
    0.16504881f, -0.02202850f, -0.10720290f, -0.00048412f, 0.06751281f, 0.07453339f, -0.81158566f, 0.63032687f, 
    -0.90818286f, -0.79872572f, 0.87356359f, -0.00952641f, 0.90371668f, -0.44283253f, -0.12059315f, -0.60772455f, 
    0.20756154f, -0.53287303f, -0.58629107f, -0.42012566f, 0.38884947f, 0.31360534f, -0.06485331f, -0.26432154f, 
    -0.35104069f, -0.32245296f, -0.44763687f, -0.07997412f, 0.01475128f, -0.37924677f, -0.15013751f, -0.01080193f, 
    0.57914591f, 0.00939752f, 0.05565070f, -0.14960690f, -0.13676657f, -0.68748152f, -0.22043222f, 0.33483216f, 
    0.39847836f, -0.18318182f, -0.32877705f, -0.14684427f, -0.21512435f, -0.40664771f, 0.10207917f, 0.07131917f, 
    -0.23754361f, -0.06617814f, 0.39379400f, -0.52594680f, 0.22699705f, 0.07362438f, 0.04503272f, -0.13536891f, 
    0.55438155f, 0.86031502f, -0.01573871f, -0.56877571f, -1.04041970f, -0.66890651f, -0.21319027f, 0.08845621f, 
    0.37080246f, 0.39759257f, -0.03401852f, -0.03797676f, -0.08816297f, 0.58114910f, 0.00076776f, 0.45767668f, 
    -0.27952152f, -0.04663067f, -0.50081450f, -0.03030222f, 0.16791628f, 0.38074347f, -0.07801293f, -0.08809347f, 
    0.11661641f, 0.74239028f, 0.93281901f, -0.35393110f, -0.42574596f, 0.34260121f, -0.67973840f, 0.18487796f, 
    0.04120563f, 0.00558961f, 0.07915603f, -0.05790397f, 0.36397436f, -0.17171763f, -0.45901415f, -0.30960947f, 
    0.18395884f, -0.24606575f, 0.41806826f, -0.18885483f, -0.26978251f, -0.01090266f, 0.16390343f, 0.09879192f, 
    0.04564832f, -0.30779207f, -1.26593733f, -0.47078243f, 0.45682552f, 0.67821723f, 0.38157079f, -0.60135436f, 
    -0.16980919f, -0.32455587f, 0.36320865f, -0.06490714f, -0.25505584f, -0.37104377f, -0.06317010f, 0.97191155f, 
    -0.45769382f, -0.29004088f, 0.21177395f, 0.05748545f, -0.25557259f, -0.09165356f, 0.35993481f, 0.12580660f, 
    0.03695266f, -0.28326413f, -0.20950298f, -0.84107059f, -0.86685395f, -0.88654327f, -0.57133001f, -0.32057422f, 
    0.27735320f, 0.19768405f, -0.63418579f, -0.15040012f, 0.65241987f, -0.58283424f, -0.59935856f, -0.69201529f, 
    -0.27994454f, -0.16045952f, 0.24063601f, 0.29045072f, -0.18484873f, 0.15909524f, -0.21530385f, -0.13611634f, 
    -0.33880937f, -0.24622275f, -0.20883918f, -0.20801891f, 0.27737916f, -0.03879618f, 0.11326523f, 0.21259442f, 
    -0.03147159f, -0.75324434f, -0.59594566f, -0.66193247f, -0.44099322f, -0.51580894f, -0.05150306f, 0.44868174f, 
    0.29724312f, 0.05515312f, 0.11185407f, -0.08107851f, -0.19500726f, 0.20772181f, 0.19447145f, -0.05186736f, 
    -0.16126019f, 0.09092849f, -0.19045976f, -0.04456429f, 0.27160105f, 0.30183789f, 0.22057535f, -0.07554101f, 
    0.04338306f, -0.15933123f, -0.68185359f, 0.05202240f, -0.09897322f, 0.21125019f, 0.22778985f, 0.44689324f, 
    -0.31313190f, 0.19055183f, -0.26987234f, -0.32652813f, 0.06811663f, -0.12388051f, 0.26597250f, -0.24205655f, 
    0.17019650f, 0.04295037f, -0.07933146f, -0.49930856f, 0.00860272f, 0.55318522f, -0.67147875f, -0.23953091f, 
    0.29372808f, 0.58886313f, 0.59753734f, 0.37983093f, 0.39042968f, 0.12918134f, -0.04268458f, -0.25096992f, 
    -0.31217635f, -0.03987975f, -0.12648220f, 0.25316083f, 0.03737745f, 0.18854403f, -0.27091864f, -0.13645162f, 
    -0.24300982f, -0.14748710f, -0.01339384f, 0.01008159f, 0.25855520f, -0.12096375f, -0.40589270f, 0.43088683f, 
    0.42684785f, 0.46515748f, 0.08532243f, -0.29848453f, -0.55263036f, -0.32795855f, 0.11271811f, 0.43839762f, 
    -0.53175145f, -0.34399927f, -0.40760794f, -0.34242386f, -0.10124880f, 0.24871905f, 0.12218433f, 0.00395900f, 
    0.13895069f, 0.35638732f, 0.12640017f, -0.11599933f, -0.20634100f, -0.25637496f, -0.26789099f, -0.24240683f, 
    -0.47114325f, 0.10040142f, 0.45759445f, -0.28637752f, -0.65538687f, -0.10175305f, 0.19624735f, -0.04204113f, 
    -0.46698818f, -0.43765715f, 0.08226813f, 0.35224804f, 0.08098682f, -0.08880813f, 0.04482079f, 0.23001622f, 
    0.10163573f, 0.29032740f, 0.17270161f, -0.29848200f, 0.38751647f, -0.36435974f, -0.22441341f, -0.38519540f, 
    -0.43078989f, -0.90451193f, -0.48308897f, -0.88962364f, -0.98167223f, -0.27974325f, -0.16965924f, -0.30995235f, 
    0.34476110f, 0.34668010f, 0.07842430f, -0.72923219f, -0.60367870f, -0.45780033f, 0.46128157f, -0.28407359f, 
    -0.03368448f, -0.48658720f, -0.21714056f, 0.31495401f, -0.19987929f, -0.28013557f, -0.03383790f, -0.04264442f, 
    -0.17283425f, -0.70699900f, -0.81568569f, -0.78493476f, 0.12068075f, -0.03019178f, 0.58542240f, -0.46979424f, 
    -0.87191868f, -0.17345123f, -0.06582329f, -0.25722480f, 0.56334603f, 0.82005286f, 0.46281129f, -0.36574134f, 
    -0.29408422f, -0.18361153f, -0.23240954f, -0.03339880f, -0.68007213f, -0.51330185f, 0.19774394f, 0.18236978f, 
    -0.01299535f, -0.08037462f, 0.04565167f, 0.38037333f, -0.12708077f, 0.03848777f, 0.51141053f, 0.04678934f, 
    0.40981781f, 0.28692865f, -0.05280073f, 0.07851756f, 0.08004990f, -0.27734849f, -0.36586013f, -0.08676001f, 
    0.06454859f, 0.01258576f, -0.03341753f, -0.19129214f, -0.16648819f, 0.23950794f, -0.17260818f, -0.31810153f, 
    -0.08063007f, -0.16693066f, -0.49371812f, -0.63920146f, -0.36537385f, -0.79294723f, -0.78531533f, -0.28245273f, 
    -0.13502142f, -0.35821873f, -0.35374853f, -0.80379790f, -0.69550776f, -0.17023554f, 0.32266423f, 0.00706652f, 
    0.26521358f, -0.36294165f, 0.12060857f, 0.16337582f, 0.20650516f, 0.22174475f, 0.44124508f, 0.45179996f, 
    -0.06897531f, -0.38521540f, -0.01495411f, 0.32251760f, -0.21502918f, 0.33618224f, -1.02365983f, -0.07442038f, 
    -0.25903377f, 0.78489745f, -0.07220264f, -0.50318491f, -0.37106419f, -0.06070111f, 0.36675754f, -0.15192008f, 
    -0.24632470f, 0.31602925f, -0.34988767f, 0.20967783f, -0.30210340f, -0.13433477f, -0.01141111f, -0.37104866f, 
    -0.59283334f, -0.50928795f, -0.24621977f, -0.29434851f, -0.30940393f, -0.44250017f, -0.45084259f, 0.15676616f, 
    0.28780422f, 0.17978381f, -0.39987335f, 0.02171718f, -0.34734052f, 0.09765688f, 0.30063224f, 0.05567587f, 
    -0.25110584f, 0.11073901f, -0.06731281f, -0.30942300f, 0.19265793f, 0.12313066f, -0.17048886f, -0.28589961f, 
    -0.07622679f, -0.09874068f, -0.34329265f, -0.41689563f, -0.16682062f, -0.41071889f, -0.62078619f, 0.23784693f, 
    -0.00186480f, 0.50803691f, -0.46384636f, -0.24953987f, 0.02689183f, 0.49716744f, -0.31479663f, -0.19437551f, 
    -0.03891258f, 0.14758021f, 0.19083402f, -0.08836985f, 0.22911797f, 0.01652546f, 0.15178411f, 0.06557685f, 
    0.24063534f, 0.24819015f, 0.07615082f, 0.16727854f, -0.07915826f, 0.29580763f, 0.01488875f, -0.22712630f, 
    -1.12551451f, -0.87299180f, -0.96731508f, 0.02021802f, 0.51841682f, -0.34827024f, -0.10665526f, -0.38190362f, 
    -0.71645063f, -0.20502014f, 0.66428775f, 0.62403494f, -0.05880035f, 0.55198914f, -0.54521066f, 0.05231513f, 
    -0.09862849f, 0.03019966f, -0.05263653f, 0.08863621f, -0.28449583f, 0.00010570f, 0.39341435f, -0.27587476f, 
    -0.05194636f, 0.57093185f, -0.24598049f, -0.16452514f, -0.01298178f, -0.13978870f, 0.07661489f, 0.14177850f, 
    0.28309703f, 0.37480304f, -0.24583720f, -0.09794209f, 0.10532381f, -0.46413884f, -0.29744691f, 0.21647848f, 
    -0.27430722f, 0.10460245f, -0.19504921f, 0.16461192f, 0.14435405f, 0.03959274f, -0.04401965f, -0.15159830f, 
    -0.35337606f, 0.50842673f, 1.02452695f, 0.69181377f, 0.58950353f, -0.55341679f, -1.24895728f, -0.50187522f, 
    0.14363323f, 0.19939989f, 0.08570428f, 0.01666362f, -0.24911714f, 0.06956568f, 0.44045192f, -0.28092718f, 
    0.11135910f, -0.23617788f, 0.39043230f, -0.05323030f, -0.24804543f, -0.20956072f, 0.06271128f, 0.06235767f, 
    -0.38940361f, -0.32481995f, -0.02299565f, -0.66193742f, -0.13488078f, 0.02999550f, 0.53207803f, 0.04191996f, 
    0.61389422f, 0.80798799f, -0.29843017f, -0.35925946f, -0.02670367f, -0.34750518f, 0.16552405f, -0.10736205f, 
    -0.10154302f, 0.00124260f, 0.08839356f, -0.36598942f, -0.30451474f, 0.20590839f, 0.42244777f, -0.13262738f, 
    -0.19442572f, 0.15550847f, 0.02784245f, -0.07261840f, -0.66602510f, -0.05593150f, 0.12901717f, -0.77682364f, 
    -0.71134335f, -0.32443482f, -0.67385775f, -0.62607461f, -0.60959417f, -0.63648039f, -0.16028559f, -0.34616053f, 
    -0.43982702f, -0.45112029f, -0.10032023f, -0.28147358f, -0.36487502f, -0.49193853f, -0.27264890f, -0.26966307f, 
    -0.08793037f, 0.22177689f, 0.23261210f, 0.16094950f, 0.09636997f, -1.40726805f, -0.29238757f, 0.23761974f, 
    0.63724768f, 0.25939524f, -0.44683817f, -0.63188201f, -0.27995881f, 0.73622566f, 0.93635887f, 0.03577062f, 
    0.05621708f, -0.31094679f, 0.27884990f, 0.28835407f, 0.07616555f, 0.03210470f, -0.11548174f, -0.30533591f, 
    -0.26012924f, 0.17300239f, -0.17934926f, 0.14126317f, 0.12622172f, 0.16815284f, -1.07781971f, 0.45073250f, 
    -0.12033297f, -1.08211505f, -0.62246221f, -0.24429661f, 0.05182102f, 0.36597571f, 0.73057401f, 0.72155046f, 
    0.05940245f, 0.29474467f, -0.09546818f, -0.00563991f, -0.26532334f, 0.02621369f, 0.31175938f, 0.12869792f, 
    0.17645909f, -0.15856688f, -0.00869346f, 0.09350412f, 0.22028230f, -0.36704436f, -0.23006472f, 0.21998203f, 
    -0.61384070f, 0.01335525f, 0.37394524f, 0.04220640f, -0.54404521f, -0.73373359f, 0.42892596f, 0.57076252f, 
    0.53427392f, 0.51283962f, -0.65200531f, -0.23115097f, -0.19841574f, 0.45189282f, -0.32556671f, -0.12731285f, 
    0.27083653f, 0.18390003f, -0.26528245f, -0.06745372f, 0.04342974f, 0.20382859f, 0.11428071f, 0.12551959f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.29853973f, 0.19263957f, 0.25784048f, 0.46319997f, 0.01041576f, -0.08567204f, 0.36342177f, 0.23894890f, 
    0.31106052f, 0.36024949f, 0.16670798f, -0.42226040f, 0.03075405f, 0.35737208f, 0.46944827f, -0.06119964f, 
    0.01879603f, -0.28005674f, 0.25061002f, 0.24943636f, 0.07616113f, 0.15971743f, 0.02907567f, 0.04594665f, 
    0.11650839f, 0.37598059f, 0.40030318f, 0.47613689f, 0.00735016f, 0.37402305f, 0.17080304f, 0.54531550f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20917343f, 0.02560386f, 0.09352812f, -0.50083601f, -0.08272941f, 0.11153299f, -0.17924008f, 0.04730117f, 
    0.02939110f, 0.10552493f, 0.02119640f, -0.01488407f, 0.04027055f, -0.04087631f, -0.13898949f, 0.01630728f, 
    -0.07202634f, 0.02046863f, -0.03366293f, -0.03427086f, -0.15988323f, -0.12420422f, -0.00657594f, -0.13812591f, 
    -0.09559013f, -0.05304536f, -0.05072669f, -0.07293506f, 0.00638203f, -0.06323107f, -0.07180618f, -0.09330284f, 
    -0.07560475f, 0.03805285f, 0.03322888f, 0.10407180f, 0.23772922f, -0.08751580f, -0.38670006f, -0.06979755f, 
    0.13636981f, 0.11469388f, -0.06291886f, -0.26081222f, -0.08664026f, -0.14314577f, -0.19006126f, -0.04925698f, 
    -0.28590119f, 0.39962617f, 0.04871220f, 0.03130282f, 0.24902838f, -0.14016375f, -0.08255755f, -0.00354973f, 
    -0.07774340f, -0.06885551f, -0.11488043f, 0.15184246f, -0.00709545f, -0.03385064f, 0.04981406f, 0.11462556f, 
    0.04826089f, 0.05170144f, 0.03437562f, 0.07067009f, -0.11978786f, 0.02521480f, 0.03621001f, -0.00474382f, 
    0.17973520f, -0.07712953f, -0.08443449f, 0.00783623f, -0.24096899f, 0.12208343f, -0.26634943f, -0.13364005f, 
    -0.26130849f, -0.13050933f, -0.07982740f, 0.05986819f, -0.78064561f, 0.44598389f, 0.05446792f, -0.35187349f, 
    -0.02008207f, 0.07638124f, 0.09940130f, 0.00656598f, -0.04911385f, 0.00304467f, -0.07340002f, 0.01520285f, 
    -0.02333945f, -0.08776043f, 0.02749896f, -0.00184089f, -0.17463857f, -0.17008364f, -0.08329583f, -0.31491938f, 
    -0.21776025f, -0.13065964f, -0.04320356f, -0.18959078f, -0.90200704f, -0.16118798f, -1.01314521f, 0.18492031f, 
    0.04314348f, -0.00106678f, 0.05606670f, 0.02313726f, -0.01133893f, -0.02872992f, -0.05512404f, 0.06306094f, 
    0.50660419f, 0.15855387f, 0.14606555f, -0.30496001f, 0.09642028f, -0.16523333f, -0.12891847f, 0.09147515f, 
    0.09748791f, -0.09344495f, -0.13521072f, -0.21480444f, 0.40223023f, 0.33696413f, 0.07050610f, -0.05613902f, 
    0.29552492f, 0.15776247f, 0.11749640f, 0.00630166f, -0.05203442f, 0.07306697f, -0.05687530f, -0.11512505f, 
    0.18283032f, 0.22562176f, -0.12206960f, -0.19609459f, -0.11671039f, -0.10265400f, 0.08682583f, 0.09406135f, 
    0.00945924f, 0.10060699f, 0.03736401f, -0.03859639f, -0.03205463f, -0.11883675f, -0.13230488f, -0.12600030f, 
    0.03196007f, 0.07790519f, -0.09007037f, -0.11283933f, -0.15925539f, -0.13492881f, 0.03442074f, -0.01675707f, 
    0.44046560f, -0.62129921f, 0.03356959f, -0.16184947f, 0.06577351f, -0.08106163f, 0.08772285f, -0.04533451f, 
    -0.01316173f, 0.00476131f, 0.15016598f, 0.03579484f, -0.25584874f, -0.01767931f, 0.38428113f, -0.04712802f, 
    0.03140538f, -0.01064985f, -0.07169238f, 0.00445038f, 0.11141776f, -0.01719631f, -0.03621503f, 0.02380852f, 
    0.18822718f, 0.15314507f, 0.02472222f, -0.04111208f, -0.10481900f, -0.07040233f, -0.14971539f, 0.15215661f, 
    -0.02538914f, -0.00837986f, 0.07955543f, 0.13697076f, 0.36729136f, 0.20766197f, 0.09942181f, -0.06188858f, 
    0.14269122f, 0.29291624f, 0.11349289f, -0.04079143f, -0.06628089f, -0.14170267f, -0.01898344f, -0.04180082f, 
    0.16362658f, 0.35169917f, 0.20451343f, -0.30942312f, -0.09585649f, 0.22758880f, 0.02996757f, -0.13578464f, 
    0.01726435f, -0.11773080f, -0.06998532f, -0.04692698f, -0.49816757f, -0.44396242f, 0.01632965f, 0.04585415f, 
    0.05805422f, 0.01926615f, -0.00287598f, 0.05178510f, -0.03758898f, -0.12610796f, 0.06185343f, 0.32561743f, 
    0.49962762f, 0.35329595f, -0.20711045f, -0.19601344f, 0.20222233f, 0.17366205f, 0.00324972f, 0.02804160f, 
    -0.03774255f, 0.09370784f, 0.03398881f, 0.08606089f, 0.13856241f, 0.10014422f, 0.04670933f, 0.00047987f, 
    -0.18255766f, 0.03795055f, 0.00616265f, -0.24613811f, -0.17063959f, -0.03499476f, -0.01301982f, 0.09261930f, 
    -0.14447132f, 0.01691075f, 0.09436160f, 0.12142789f, 0.04675606f, -0.03846082f, 0.01100352f, 0.02659347f, 
    -0.02215096f, 0.03349926f, 0.21364611f, 0.12380752f, 0.05620481f, 0.03591071f, 0.02758247f, 0.10049517f, 
    -0.35033935f, -0.44065905f, -0.18141854f, -0.26363501f, -0.02167587f, 0.05997005f, -0.00728961f, 0.05247043f, 
    0.55110341f, 0.42873707f, -0.17619120f, -0.28029341f, 0.04373068f, -0.00434778f, 0.06937757f, -0.07325675f, 
    -0.06214897f, 0.00490945f, -0.06083073f, -0.05335675f, -0.18949738f, -0.32616213f, -0.22227079f, -0.00750299f, 
    -0.04451901f, 0.00385223f, -0.01081031f, 0.03346119f, -0.15850420f, -0.00219545f, -0.08909363f, -0.28397638f, 
    -0.30146420f, -0.97580612f, 0.23845305f, 0.11661453f, 0.00144557f, 0.11217427f, -0.26994631f, -0.08137573f, 
    -0.11239818f, -0.13813937f, -0.16544633f, -0.07564019f, 0.14312936f, -0.07649666f, -0.16915138f, -0.05416439f, 
    0.04872221f, -0.06679241f, 0.01767499f, -0.07136410f, -0.18871196f, -0.22009419f, 0.03481257f, -0.18175237f, 
    0.14692953f, 0.23700972f, -0.23782505f, -0.34623539f, 0.08696166f, 0.15329896f, -0.03716072f, 0.06716814f, 
    -0.02869636f, -0.10010480f, -0.11121961f, -0.11673425f, 0.02947796f, 0.25136361f, 0.50163853f, -0.56733376f, 
    0.03549884f, 0.15797293f, 0.09747398f, 0.10285717f, -0.00587770f, -0.10077801f, -0.22417636f, -0.17834331f, 
    -0.04166312f, -0.12083600f, 0.08093558f, -0.01108917f, 0.03213902f, 0.14268216f, 0.10612884f, -0.04424606f, 
    0.02103526f, 0.01941650f, 0.05501608f, 0.00985983f, -0.59605074f, 0.00643154f, 0.06781181f, -0.32740727f, 
    -0.12306510f, -0.04620918f, -0.04423436f, -0.03629954f, 0.00532159f, -0.22790489f, -0.10809964f, -0.17084639f, 
    -0.35680249f, 0.20080236f, -0.23715025f, -0.50705403f, -0.33814436f, -0.48557416f, 0.26759139f, 0.19531991f, 
    -0.17103052f, 0.00022426f, 0.01047412f, 0.02620873f, 0.10679266f, 0.12632132f, -0.02346699f, 0.07910649f, 
    0.04330097f, 0.15185562f, -0.05408258f, 0.10227825f, -0.10963383f, 0.02306228f, -0.19273569f, -0.04660536f, 
    0.20479809f, -0.05660729f, 0.09414825f, -0.21197404f, 0.07408586f, -0.14904031f, -0.14760754f, 0.03669247f, 
    0.05893847f, 0.05457220f, 0.08522560f, -0.09247878f, 0.45802101f, -0.31202573f, -0.09708553f, -0.42103210f, 
    -0.07221474f, 0.00832132f, 0.09661394f, -0.01593216f, 0.00116239f, -0.04272311f, 0.20629299f, -0.32390699f, 
    0.43071029f, -0.16657592f, -0.02834832f, -0.00607141f, -0.07793561f, -0.05854708f, 0.12313285f, -0.01064271f, 
    -0.08705273f, -0.02185815f, -0.09795709f, 0.06693538f, 0.07633248f, 0.11439750f, 0.19850880f, 0.19138709f, 
    -0.00833104f, -0.00053548f, -0.07817920f, -0.09239000f, 0.06930522f, 0.06904851f, 0.04035413f, 0.11353043f, 
    -0.05211888f, -0.34027135f, 0.08261736f, -0.23059475f, 0.22778489f, -0.06893808f, -0.05456861f, 0.12412447f, 
    0.01747495f, 0.09793512f, -0.16081204f, -0.08882236f, -0.07550813f, 0.42510843f, -0.07416762f, -0.07698771f, 
    0.00428491f, -0.03947233f, -0.04132869f, 0.01674901f, -0.01836867f, -0.03274943f, 0.02885049f, 0.01321715f, 
    0.08723977f, -0.33629465f, 0.13572371f, -0.28587839f, 0.14155303f, 0.21138619f, 0.00316658f, 0.02828303f, 
    0.05898952f, 0.06701986f, -0.10384312f, 0.03278456f, 0.15432061f, 0.02615629f, 0.61562014f, 0.06790870f, 
    -0.02389196f, -0.09648228f, -0.05487145f, -0.02441614f, -0.01347294f, 0.01492263f, -0.11745790f, 0.15129283f, 
    -1.00556159f, -0.14345102f, -0.31182665f, -0.31115717f, 0.00750803f, -0.37316972f, 0.21446933f, 0.02381377f, 
    0.06889913f, -0.19151704f, 0.16585360f, -0.00058151f, 0.62346005f, 0.29742491f, 0.18680061f, 0.10504436f, 
    0.18325569f, 0.02475605f, -0.33071458f, -0.40430564f, 0.07174912f, -0.05678924f, -0.10102500f, -0.11190755f, 
    0.11564469f, 0.11493710f, -0.21868657f, -0.05044762f, -0.03347037f, 0.10632436f, -0.16820502f, -0.17041712f, 
    -0.16396278f, -0.00805344f, -0.01530197f, 0.17814314f, -0.02169764f, 0.15158837f, 0.15885529f, -0.00857629f, 
    0.01287174f, 0.12475850f, -0.00673349f, -0.10428283f, 0.01869734f, -0.13481975f, -0.01240086f, 0.14529046f, 
    0.31815246f, -0.05622309f, 0.51273292f, 0.29526794f, -0.02059708f, -0.00589392f, -0.08942217f, 0.06919785f, 
    -0.05007705f, 0.09589373f, 0.03147928f, -0.17635763f, 0.12352972f, 0.00367178f, -0.01354939f, -0.22562324f, 
    0.02969946f, -0.08372436f, 0.01797175f, -0.34531242f, 0.03737168f, 0.03421221f, 0.01211854f, -0.11091201f, 
    -0.13698405f, -0.09982577f, 0.14746730f, -0.19064337f, -0.15121853f, 0.02166097f, 0.02765830f, 0.06386771f, 
    -0.00540872f, -0.07547764f, -0.02195605f, 0.02660739f, 0.09601556f, 0.32397148f, -0.00453132f, 0.15607066f, 
    -0.00300370f, 0.04809878f, 0.02276849f, -0.22537500f, -0.05570378f, -0.06237819f, 0.09786203f, -0.07294426f, 
    -0.82958597f, -0.20756257f, -0.49274701f, 0.21706119f, -0.00142248f, 0.06504867f, -0.00398017f, 0.27164420f, 
    -0.06559855f, 0.06885996f, -0.17365891f, 0.15523082f, 0.16516465f, 0.23056851f, 0.05873829f, 0.21399851f, 
    -0.03339886f, 0.05448171f, -0.08465339f, -0.00851689f, -0.32368150f, 0.09202681f, 0.19821249f, -0.01056778f, 
    0.21960375f, 0.17098463f, 0.07082198f, 0.11724251f, -0.17110451f, -0.02350820f, 0.04572658f, -0.03957643f, 
    -0.00295297f, -0.10912576f, -0.02201687f, 0.00412636f, -0.08298634f, -0.00582430f, -0.36063406f, 0.10985021f, 
    0.07585419f, 0.12058077f, -0.03308890f, -0.04140028f, -0.01057347f, -0.41651469f, -0.30339018f, -0.45913741f, 
    -0.16095081f, 0.02574955f, -0.01279255f, -0.15124674f, 0.02819428f, 0.01411343f, -0.09755298f, -0.02627448f, 
    -0.63535762f, -0.16871852f, -0.03246662f, -0.60028893f, -0.01948783f, -0.12831092f, -0.07234005f, -0.04572846f, 
    0.05030477f, 0.02346862f, -0.00155442f, 0.09712183f, -0.14703704f, -0.22510152f, -0.04206887f, -0.04935192f, 
    -0.18862601f, -0.06578967f, -0.02096807f, 0.20874316f, -0.02949590f, 0.15991843f, 0.29682565f, -0.13151646f, 
    -0.03172729f, 0.00401957f, -0.05569488f, 0.07468881f, 0.54118568f, 0.29060978f, -0.00841828f, 0.15311053f, 
    0.09555838f, -0.02539113f, -0.02871529f, -0.05345096f, 0.19860390f, 0.29277638f, -0.23923150f, -0.08534233f, 
    0.49155644f, -0.42076695f, 0.21290007f, -0.43559912f, 0.05689697f, 0.11316295f, -0.07684454f, -0.03528685f, 
    0.10134568f, -0.03687020f, -0.08741121f, 0.00628870f, 0.37998948f, 0.04039454f, 0.17319848f, 0.19010594f, 
    -0.06705945f, 0.03179788f, -0.02431128f, -0.02937898f, 0.20598435f, 0.28281775f, 0.15926996f, 0.10513399f, 
    0.06869665f, 0.16217355f, 0.13475445f, 0.18550861f, 0.12454143f, 0.01611394f, 0.08173530f, 0.21013664f, 
    0.01733485f, 0.04591642f, 0.00126134f, 0.01792229f, -0.80692232f, 0.15748049f, 0.01065571f, -0.20795630f, 
    0.04082832f, 0.04716940f, 0.04422721f, 0.15814191f, -0.05150465f, -0.08775255f, 0.18040960f, 0.06043059f, 
    -0.39495099f, -0.10987845f, 0.14695761f, -0.17432594f, -0.01737001f, 0.13111426f, -0.49234226f, -0.18663873f, 
    -0.17330857f, -0.06092419f, -0.07524494f, 0.02615887f, -0.54049242f, 0.47973606f, 0.03952190f, -0.05691044f, 
    -0.03976776f, 0.11542496f, -0.01036509f, -0.06352103f, -0.00343802f, 0.06153679f, -0.04190165f, 0.19407941f, 
    -1.12137365f, -0.10797926f, -0.10315395f, -0.24489227f, -0.09482046f, -0.23571999f, -0.04511290f, -0.33004233f, 
    0.02097485f, 0.03191420f, -0.11704786f, 0.02528334f, -0.08981250f, -0.13256595f, 0.01077742f, 0.12813377f, 
    -0.08448557f, 0.05902689f, -0.03727854f, -0.00210642f, -0.00040734f, -0.02857188f, -0.14598770f, -0.05345762f, 
    -0.29115421f, 0.01484645f, 0.27590221f, -0.69290280f, 0.03122045f, -0.07441717f, -0.12975183f, -0.17367025f, 
    0.02433554f, 0.05027133f, -0.00565814f, 0.02182510f, -0.00824645f, 0.37161541f, 1.01498532f, 0.11121640f, 
    0.01058003f, 0.04786746f, 0.12556972f, -0.22192764f, -0.11769097f, -0.18808953f, -0.08329631f, 0.14339787f, 
    0.02456417f, -0.62695253f, -0.27134886f, -0.07108238f, -0.26647112f, 0.09234748f, 0.19147599f, -0.00615055f, 
    -0.00549167f, -0.02014766f, 0.12030392f, -0.01177360f, -0.17897080f, -0.03907983f, -0.11299810f, -0.00580859f, 
    -0.10934942f, -0.07267648f, 0.05877991f, 0.10871475f, -0.06607564f, -0.02637175f, -0.06278007f, -0.02509440f, 
    0.42983690f, -0.12870355f, 0.13537219f, -0.17627497f, 0.13860865f, -0.14412722f, 0.03802251f, -0.05890249f, 
    -0.09644590f, 0.00534928f, -0.10186098f, 0.18668160f, -0.33035979f, 0.08568486f, 0.29358935f, -0.12159804f, 
    0.08329049f, -0.00433516f, -0.00458886f, 0.14687665f, 0.01464520f, 0.02868818f, -0.06241236f, 0.02669111f, 
    0.07194885f, -0.02030312f, -0.05489245f, 0.10567704f, 0.00822161f, 0.13936728f, -0.32348129f, 0.10647346f, 
    0.00939443f, -0.20787743f, -0.12968369f, 0.23655081f, 0.12773180f, -0.72492641f, 0.41445613f, -0.33849111f, 
    -0.01220674f, -0.06632234f, 0.02569892f, -0.01324234f, 0.00545373f, -0.03769024f, 0.02473687f, 0.03846887f, 
    0.14201485f, -0.05451414f, -0.21319775f, -0.09854624f, 0.05176235f, -0.11108772f, -0.09960451f, 0.07008653f, 
    0.04495869f, -0.03094309f, 0.15538143f, -0.05920000f, -0.57047379f, -0.26356468f, 0.62292373f, 0.18681921f, 
    0.10062683f, -0.13103762f, -0.07363804f, 0.00053939f, 0.04739448f, 0.03810292f, 0.08224475f, -0.01594370f, 
    -0.34909517f, -0.06195943f, 0.05180351f, -0.03971360f, 0.01326590f, 0.06968866f, -0.27456468f, -0.01075219f, 
    0.11187637f, -0.12653042f, 0.05176579f, -0.08345893f, -0.10515776f, 0.07252644f, -0.00221544f, -0.07772851f, 
    0.24632093f, 0.14395492f, 0.00751813f, 0.11839265f, -0.03316781f, -0.04596957f, 0.01864373f, 0.01448890f, 
    0.01721942f, 0.16107890f, -0.33407825f, 0.08559854f, -0.02094655f, 0.02259040f, 0.06085508f, 0.11273681f, 
    -0.10725658f, 0.03791443f, -0.02039370f, -0.07157571f, -0.22277531f, -0.10057539f, -0.16175751f, -0.11948518f, 
    -0.01487861f, -0.02666217f, 0.12425650f, -0.15216097f, -0.03231166f, 0.02186465f, -0.13490182f, -0.02196247f, 
    0.25303766f, -0.08822678f, 0.12263867f, -0.28922817f, 0.18347067f, 0.10271824f, 0.15425019f, -0.14655095f, 
    0.12099507f, 0.11506195f, 0.08924288f, 0.05988609f, -0.35753995f, 0.70879066f, 0.55181020f, 0.38776830f, 
    -0.04353444f, -0.19848520f, 0.09153599f, 0.02164288f, -0.01004814f, 0.04566815f, 0.17945318f, -0.29120404f, 
    0.23233791f, -0.02836924f, -0.86457926f, -0.13008411f, 0.18562157f, -0.09656996f, -0.07972496f, 0.19576766f, 
    0.03323849f, -0.07063232f, -0.21587366f, 0.01837555f, -0.07092380f, 0.05968839f, -0.13676301f, -0.02158175f, 
    0.01818134f, -0.01481583f, -0.01875506f, 0.05211917f, 0.12599014f, 0.19315316f, 0.37331843f, -0.09167830f, 
    -0.38579318f, -0.37643003f, 0.14995661f, -0.08025490f, 0.04815954f, -0.19065975f, 0.19734342f, -0.01988720f, 
    -0.00456675f, 0.04226162f, 0.08192199f, -0.06867789f, -0.35572761f, -0.09486064f, 0.04891555f, 0.02735630f, 
    -0.06327045f, -0.02944645f, -0.11819720f, -0.01016949f, -0.20824520f, 0.14178212f, 0.19148780f, 0.16299421f, 
    0.22580719f, 0.08074906f, -0.03641258f, 0.20199387f, 0.01562336f, 0.02858151f, 0.05167435f, -0.07491415f, 
    0.08056639f, 0.26658449f, 0.22334802f, 0.08555402f, -0.00568818f, -0.07878749f, 0.02073945f, -0.06089864f, 
    -0.20014349f, -0.13784154f, 0.08902591f, 0.03578649f, 0.00795211f, 0.00319907f, 0.05611640f, -0.03227640f, 
    -0.14669783f, -0.39608881f, 0.20972227f, -0.42428604f, 0.01729648f, -0.13356982f, 0.02055523f, 0.14393421f, 
    0.03909140f, -0.03048516f, 0.01545530f, -0.00584886f, -0.18926829f, 0.17263940f, -0.25372121f, 0.07660624f, 
    -0.01659826f, 0.02389823f, -0.05028753f, 0.01288765f, 0.07893143f, -0.01788062f, -0.20766172f, 0.06803495f, 
    -0.20261131f, 0.35725471f, 0.13218687f, -0.37052462f, -0.06978092f, -0.01977807f, -0.11556958f, -0.17250872f, 
    0.06703475f, -0.02522243f, -0.19324857f, 0.17169203f, 0.18017218f, -0.07162670f, -0.04110570f, 0.00650860f, 
    0.03731957f, -0.01895390f, -0.00882825f, 0.12958382f, -0.18819474f, 0.20974320f, 0.06409475f, -0.13872692f, 
    -0.66511178f, -0.14323616f, -0.17778882f, -0.59501553f, 0.18461294f, 0.03742381f, -0.17841765f, -0.13105483f, 
    -0.04976410f, -0.12452567f, -0.08165013f, 0.04194600f, 0.20675787f, -0.27996871f, -0.10190933f, 0.24789497f, 
    -0.02496330f, 0.14344670f, -0.12169532f, 0.11583842f, -0.10338639f, -0.00511769f, -0.24366423f, 0.14343919f, 
    0.33663657f, 0.44649592f, -0.00772508f, 0.18378812f, 0.01412214f, 0.09566665f, 0.17207539f, -0.05079889f, 
    0.10759850f, 0.10380258f, 0.01475510f, 0.34123346f, -0.51703137f, 0.12472264f, -0.21203995f, 0.09460589f, 
    0.09753577f, 0.11765017f, 0.03142471f, -0.09469978f, 0.00894190f, 0.12808770f, -0.10444982f, 0.05589536f, 
    0.24858676f, -0.25299779f, 0.03911575f, 0.30789873f, -0.02695350f, 0.05233036f, 0.08934609f, 0.27328694f, 
    0.02760155f, -0.00917714f, 0.12812737f, -0.00866839f, -0.03613072f, 0.30837917f, 0.05099281f, -0.06350547f, 
    0.09056614f, -0.07925798f, 0.07119674f, -0.25775650f, -0.02689536f, 0.32784012f, 0.12705804f, 0.04920465f, 
    -0.49975282f, -0.30143660f, 0.53753662f, 0.04134109f, -0.18470813f, 0.14053142f, 0.07873610f, -0.01629193f, 
    0.06725956f, -0.05608167f, 0.04098514f, -0.05089855f, -0.22743250f, -0.11616563f, -0.05314777f, 0.19316310f, 
    0.29305488f, 0.13498405f, 0.19279706f, -0.06445061f, -0.12873128f, 0.06269524f, -0.08363091f, 0.04400967f, 
    -0.08998729f, 0.36915642f, -0.51636881f, 0.13563134f, -0.13355833f, -0.07565748f, -0.25388271f, -0.38385665f, 
    0.04122498f, 0.16839424f, 0.22847444f, -0.30419728f, -0.42352054f, -0.22249228f, 0.09344386f, -0.35013562f, 
    -0.23921494f, -0.17607212f, 0.04113478f, -0.04056689f, 0.07808359f, 0.09954792f, -0.24927169f, 0.02825405f, 
    0.35289302f, -0.20013571f, -0.40738600f, 0.04749303f, 0.01569352f, -0.15732650f, -0.21726683f, -0.06830118f, 
    -0.25929558f, -0.04215849f, -0.05384375f, 0.16886789f, 0.04681779f, -0.11467593f, 0.26466435f, -0.31440017f, 
    -0.24618109f, -0.06361257f, -0.16010614f, 0.09654435f, -0.06375741f, -0.00828206f, 0.13315707f, 0.00871995f, 
    -0.01577608f, 0.04528096f, 0.19493660f, 0.33633807f, -0.06500180f, -0.14038381f, -0.06884245f, 0.08462866f, 
    0.03562430f, -0.11635799f, 0.20692810f, -0.16164944f, -0.29467389f, 0.15389815f, 0.61511534f, -0.17494342f, 
    -0.27630949f, -0.04019165f, -0.28445473f, 0.04313118f, -0.17746814f, 0.11451486f, 0.11976891f, 0.13450944f, 
    -0.09468101f, 0.34489274f, -0.25810587f, -0.17842697f, -0.06216267f, 0.08998470f, -0.06986545f, 0.05770459f, 
    -0.21544544f, -0.09412949f, -0.02756682f, 0.08487564f, 0.00473307f, -0.09805721f, -0.16181618f, 0.25812995f, 
    0.08967567f, -0.04195679f, 0.07730906f, 0.00809189f, 0.00836855f, 0.05344386f, 0.05868107f, 0.19678101f, 
    0.01264346f, -0.24034108f, 0.07966401f, 0.23249923f, 0.11487366f, 0.14452110f, 0.04397273f, -0.00737181f, 
    0.04499987f, 0.02756549f, -0.03914490f, 0.00621992f, 0.04898142f, -0.16313028f, -0.17299044f, -0.09782973f, 
    -0.18180652f, -0.09502319f, -0.09787751f, -0.00736888f, -0.03466836f, -0.06012876f, 0.10597512f, -0.53561515f, 
    -0.35216033f, 0.93992966f, -0.42998865f, -0.26932305f, -0.03493150f, 0.16475943f, -0.09362739f, 0.17432360f, 
    -0.25790945f, -0.18374182f, 0.14132033f, 0.02904307f, 0.09603731f, -0.34617135f, 0.32896698f, 0.04480914f, 
    -0.39746040f, 0.09555360f, -0.05463694f, 0.17255810f, 0.03311070f, 0.17435101f, 0.11792012f, -0.07732703f, 
    0.14124598f, -0.04463557f, 0.06007312f, 0.30412149f, 0.17855139f, 0.15892413f, 0.04156851f, -0.10034177f, 
    -0.02067591f, -0.03949593f, 0.14757025f, -0.04383439f, 0.30272219f, -0.26822466f, -0.09828980f, 0.22735593f, 
    -0.04807958f, -0.04773245f, 0.00745002f, -0.02520832f, 0.08002526f, 0.08376545f, 0.26955050f, 0.15139861f, 
    0.15521500f, 0.05356134f, -0.11580441f, -0.07191488f, 0.10051402f, -0.03202004f, 0.02433452f, 0.17550346f, 
    -0.07623719f, 0.06013845f, -0.29328087f, -0.06274302f, -0.42181221f, 0.32945260f, -0.05179406f, -0.00767825f, 
    -0.01363411f, 0.16786093f, 0.02817781f, 0.15943423f, -0.04538007f, -0.03984411f, 0.11500294f, -0.13395952f, 
    -0.13757987f, -0.02117021f, -0.23708898f, 0.22961359f, 0.06753661f, -0.01529963f, 0.09138730f, -0.26129788f, 
    0.00051755f, -0.01871344f, 0.00319809f, 0.06751049f, -0.42024338f, 0.19401947f, -0.31795892f, 0.06614141f, 
    -0.00695236f, -0.15278047f, -0.11943218f, -0.04202723f, -0.04276231f, 0.10742339f, -0.16134380f, 0.03645545f, 
    0.24023972f, 0.03331382f, 0.04970754f, -0.10242882f, -0.05976841f, 0.04372166f, 0.04018081f, -0.06826100f, 
    0.14387064f, -0.03345269f, -0.17837423f, -0.07495085f, 0.00699878f, 0.16506243f, -0.12127492f, 0.25873265f, 
    0.20126277f, 0.13884082f, 0.07254303f, -0.19598451f, 0.13606384f, -0.03687103f, -0.28584674f, -0.16639848f, 
    -0.05565926f, -0.24023315f, -0.48074442f, 0.05829823f, 0.12781569f, 0.15232681f, 0.02277127f, 0.04086541f, 
    -0.07759426f, 0.06795724f, 0.19086981f, -0.01041490f, -0.15534510f, 0.15363398f, -0.20442519f, -0.08358942f, 
    -0.01176931f, 0.14985159f, -0.08263751f, -0.07894604f, -0.04676106f, -0.18814231f, -0.03215549f, -0.03651825f, 
    -0.18913072f, 0.04218980f, 0.04462500f, -0.05006700f, -0.19066063f, -0.12864520f, -0.19456881f, 0.00277993f, 
    -0.02237196f, 0.12316088f, -0.18593812f, 0.10494477f, -0.54580581f, 0.68029714f, -0.52552831f, -0.51320946f, 
    0.22755204f, 0.16608706f, -0.02824423f, 0.05607835f, -0.35489994f, -0.34371105f, 0.04949206f, -0.05828976f, 
    0.14787342f, -0.17189291f, 0.19621271f, 0.28593639f, 0.03786787f, 0.04095231f, -0.02719653f, 0.10106426f, 
    -0.11373161f, -0.05349734f, -0.01968314f, -0.03250882f, 0.35603565f, 0.21931145f, -0.15344255f, -0.65404773f, 
    -0.06227348f, -0.19489093f, -0.12166029f, -0.20539202f, 0.03263571f, 0.14033628f, -0.09490775f, 0.08792485f, 
    1.01344848f, -0.06169690f, -0.09809878f, 0.25714725f, 0.15597333f, 0.11367267f, 0.00120258f, -0.16753021f, 
    -0.21687225f, -0.08680137f, -0.16870117f, 0.10099997f, -0.01293285f, -0.10556434f, 0.01884380f, -0.63412935f, 
    -0.02265024f, -0.08695566f, -0.20389894f, -0.06832819f, -0.12891638f, 0.07094728f, -0.01078723f, -0.07768872f, 
    -0.06607874f, 0.32956013f, 0.28581429f, 0.44613469f, 0.14131567f, -0.05496203f, -0.18099779f, 0.15963845f, 
    0.00070060f, -0.04809015f, -0.00060152f, -0.02483840f, 0.24168476f, -0.04166788f, 0.11498163f, -0.02473249f, 
    -0.04672965f, 0.03854048f, -0.01057164f, 0.06796822f, -0.02319838f, -0.20222415f, -0.26831344f, -0.19268326f, 
    0.05408893f, 0.25030437f, -0.23993032f, 0.40051591f, -0.03054125f, -0.16752715f, -0.28810048f, -0.10276085f, 
    0.09655755f, 0.02183577f, -0.00166156f, 0.07443956f, 0.28978544f, 0.30599195f, 0.11157869f, 0.23123986f, 
    -0.02558517f, -0.16137010f, -0.03831597f, -0.03127307f, -0.04102202f, -0.12670834f, -0.02163948f, 0.05207743f, 
    -0.08320943f, -0.27876115f, 0.38586715f, -0.35856283f, -0.26828009f, 0.16111034f, -0.05796961f, 0.09458476f, 
    0.20138395f, -0.22116555f, -0.16435166f, -0.12690955f, 0.03056528f, -0.00037688f, -0.03049188f, -0.00809967f, 
    0.19338021f, 0.00971978f, 0.10347559f, 0.02192799f, 0.04032230f, 0.06149496f, -0.02330983f, 0.04528046f, 
    -0.14129560f, -0.00907855f, -0.18982801f, -0.11817142f, 0.17286380f, -0.00427866f, -0.10584656f, 0.08086572f, 
    0.05461383f, 0.05634798f, 0.13485759f, -0.01128877f, 0.26466066f, -0.44700125f, -0.29234096f, 0.09138045f, 
    -0.04391079f, 0.06493390f, 0.08589466f, 0.05277862f, 0.10258956f, 0.02628579f, 0.02262563f, -0.04336023f, 
    -0.21673419f, -0.12971540f, -0.14013430f, 0.00139553f, -0.04222906f, 0.23044458f, -0.29212505f, 0.01951673f, 
    0.05496239f, 0.04294756f, -0.06637224f, -0.07064437f, -0.03673049f, -0.02804806f, -1.04153645f, -0.02449020f, 
    0.01767710f, -0.09610445f, 0.04224107f, -0.07680136f, 0.19382875f, -0.06371204f, 0.15638246f, -0.03036056f, 
    -0.20846567f, -0.48926914f, 0.12091552f, 0.13105731f, -0.34542003f, 0.05970628f, -0.15332530f, -0.47996867f, 
    -0.00128990f, -0.11214776f, -0.05169166f, 0.09961691f, -0.30876911f, -0.05745558f, -0.02257924f, -0.05628654f, 
    -0.11721732f, 0.11376551f, -0.14846735f, -0.07295159f, -0.04087472f, 0.04988369f, -0.00051160f, 0.21610720f, 
    0.00134139f, 0.02559956f, 0.32137862f, 0.04758953f, -0.11713409f, -0.02181490f, 0.11498600f, 0.21010306f, 
    0.10495010f, -0.04403664f, -0.01404232f, -0.05963674f, -0.12934688f, -0.04765357f, 0.01396639f, -0.09340451f, 
    -0.22940947f, -0.12513535f, -0.16477102f, 0.18890971f, 0.20207773f, 0.05782138f, -0.25771353f, -0.00928001f, 
    -0.37480757f, -0.87875718f, 0.38922486f, 0.07374697f, 0.12192637f, 0.05262638f, -0.02695622f, 0.05592309f, 
    0.08559729f, -0.10207585f, -0.05871202f, 0.10049996f, 0.18200773f, 0.38817137f, -0.22976072f, 0.20314558f, 
    -0.00618345f, 0.08365282f, -0.08527572f, -0.08177312f, 0.11984894f, 0.00967887f, 0.02061771f, 0.07734843f, 
    0.05532758f, -0.05408620f, 0.00723323f, 0.17948835f, 0.08453533f, -0.19429815f, 0.02726697f, -0.13360335f, 
    0.05178365f, -0.00954923f, -0.03906601f, -0.06256817f, -0.33639669f, 0.08009246f, 0.01813509f, 0.05759694f, 
    -0.03772230f, 0.04311955f, -0.06069975f, -0.00716702f, -0.05898972f, 0.07810254f, -0.13624860f, 0.29618904f, 
    0.08924478f, 0.21855000f, 0.28832680f, 0.16634004f, -0.01775864f, -0.10561848f, -0.12231193f, -0.22654904f, 
    -0.09536849f, -0.24269244f, 0.22661288f, -0.07020568f, 0.06883723f, -0.14341877f, -0.05293136f, -0.05548815f, 
    0.06929388f, -0.03156752f, 0.07819603f, -0.04783157f, 0.13552906f, 0.05217519f, -0.14258181f, 0.40587324f, 
    0.04437141f, 0.03377064f, 0.26692304f, 0.25033119f, -0.16617832f, -0.17048006f, -0.16696289f, 0.10063418f, 
    0.02143188f, 0.08346192f, -0.03411372f, 0.04971394f, 0.23053080f, 0.03924482f, 0.24205719f, -0.06980330f, 
    -0.08251721f, -0.06501432f, -0.04501664f, -0.07066462f, 0.00154576f, 0.08827683f, 0.03009298f, 0.33262005f, 
    0.03677778f, 0.02214904f, -0.09146050f, 0.00788540f, -0.08190986f, -0.08466066f, 0.05253479f, -0.03391460f, 
    0.18656486f, 0.18336944f, 0.06368263f, 0.37195265f, 0.11022665f, 0.10207344f, 0.02611443f, 0.15825085f, 
    0.12805972f, 0.06619254f, -0.16205600f, -0.32747114f, 0.03065112f, 0.01897242f, 0.07194108f, 0.00323902f, 
    0.15100148f, 0.11074092f, 0.35658070f, 0.09812563f, -0.14590873f, -0.21329914f, -0.12472271f, -0.06991522f, 
    0.10777313f, 0.12978877f, -0.00408105f, 0.08800499f, -0.33298457f, 0.22435437f, 0.12153677f, -0.21854238f, 
    0.08778600f, 0.00183758f, -0.07847869f, 0.13051572f, -0.10162272f, 0.08571970f, -0.02504271f, -0.08866557f, 
    -0.15841003f, 0.09566951f, -0.29459220f, 0.03361883f, 0.00002567f, -0.07662982f, -0.18457532f, -0.24229859f, 
    -0.10069205f, 0.13131556f, 0.05797585f, -0.09690398f, 0.15871502f, -0.67329144f, 0.24227022f, 0.00145847f, 
    0.04459982f, 0.01595149f, 0.03828222f, -0.06799427f, -0.35146314f, -0.02106917f, -0.32589573f, -0.10116458f, 
    -0.07800413f, 0.09486041f, 0.05378062f, 0.15990829f, 0.09725780f, -0.00546219f, 0.10766657f, -0.02648522f, 
    -0.03577535f, -0.09763661f, 0.00184814f, 0.01410378f, -0.07070887f, 0.02244901f, -0.52648228f, 0.20161846f, 
    -0.17368560f, -0.11206660f, -0.00653666f, -0.15653072f, -0.22202985f, -0.24201165f, -0.27082664f, 0.04168306f, 
    -0.05126806f, 0.02624938f, -0.00461359f, 0.04566934f, -0.04981661f, -0.15460327f, 0.08343244f, -0.09062828f, 
    0.21456468f, -0.07831181f, 0.20151177f, -0.17689595f, -0.22547902f, -0.07659433f, 0.00459589f, -0.40596932f, 
    -0.07939636f, -0.22372812f, 0.12772030f, 0.15057100f, -0.13011819f, -0.18702056f, -0.07198440f, -0.19501132f, 
    0.23132837f, -0.01141877f, 0.08045160f, -0.07438748f, 0.18518716f, 0.15789680f, -0.11949028f, -0.18059251f, 
    -0.03465233f, -0.01141972f, 0.03199842f, -0.06466598f, 0.00093364f, -0.32438776f, 0.01713783f, -0.03812463f, 
    -0.18281080f, 0.05216612f, 0.03766487f, -0.06480768f, 0.24740297f, -0.05183467f, 0.23099956f, 0.03575611f, 
    -0.25470400f, -0.07850198f, -0.32564217f, 0.22734576f, 0.02267987f, 0.26268384f, 0.03719912f, 0.06894424f, 
    -0.15420789f, 0.10732491f, -0.03822349f, -0.09400196f, -0.46353346f, -0.30665097f, -0.31586751f, -0.47875014f, 
    -0.04716836f, 0.11955477f, -0.15020724f, 0.04252278f, 0.29943413f, 0.02509428f, -0.12088716f, -0.04896622f, 
    0.04785528f, 0.22407204f, -0.20284405f, -0.01327468f, 0.19862927f, 0.12647210f, -0.23581174f, -0.09173880f, 
    0.02993017f, 0.02659511f, 0.16286430f, 0.07473767f, -0.11216033f, -0.05804199f, -0.02586361f, 0.02796387f, 
    -0.01671153f, -0.00159152f, -0.09666533f, 0.01944177f, -0.18282589f, -0.11932468f, 0.24823898f, -0.05453362f, 
    -0.23800045f, 0.72048879f, 0.03230873f, -0.16618703f, -0.19657563f, -0.05833929f, 0.13100116f, -0.23771073f, 
    0.14670672f, -0.32875791f, -0.41562113f, -0.08295958f, 0.26069340f, -0.05482107f, 0.02126922f, 0.40761602f, 
    0.04208769f, -0.02497759f, 0.06402722f, 0.00057329f, 0.08883760f, 0.04449489f, -0.03300853f, 0.07867913f, 
    0.09509611f, 0.18781318f, -0.25705996f, -0.00763651f, 0.10020740f, -0.35031921f, 0.05599347f, 0.09891421f, 
    -0.01711063f, 0.04935649f, -0.08857412f, 0.22761880f, 0.38270894f, 0.19859014f, -0.74012214f, 0.06434795f, 
    0.05497988f, 0.00818603f, 0.09062514f, 0.07672493f, 0.03888890f, -0.03705898f, -0.00756642f, -0.13126464f, 
    0.40635371f, -0.15696038f, 0.56175965f, 0.21063206f, 0.15216054f, 0.01934269f, 0.08515171f, 0.19889633f, 
    0.03627340f, 0.20596288f, -0.09931486f, -0.03097829f, -0.21397637f, 0.04483143f, 0.18066353f, -0.27035880f, 
    -0.06927227f, -0.23547694f, -0.06222146f, 0.13895091f, -0.10180321f, -0.11268222f, -0.02144585f, -0.00963000f, 
    -0.04411659f, 0.01380652f, -0.03673494f, -0.11330608f, 0.09779035f, -0.08792081f, 0.05213916f, -0.03208966f, 
    0.02917830f, 0.02064349f, 0.01463633f, 0.09616583f, 0.13261086f, -0.16896129f, -0.13270329f, 0.30200213f, 
    0.11725833f, -0.23142648f, -0.01806818f, -0.04627972f, -0.01493392f, 0.05504793f, 0.06747191f, 0.31934354f, 
    -0.27935618f, -0.15056472f, -0.12233001f, 0.13517632f, -0.03047566f, -0.06437153f, -0.04809342f, -0.09256131f, 
    0.06452119f, -0.03184557f, -0.07422198f, -0.14491680f, 0.03749525f, -0.15684395f, -0.19992873f, 0.16929112f, 
    0.05660574f, 0.10005288f, -0.03600678f, 0.27621317f, -0.12096698f, -0.01708295f, -0.05994899f, -0.11480068f, 
    -0.05083196f, 0.22281112f, -0.21306607f, 0.01240814f, 0.03638232f, -0.07590668f, -0.21101654f, 0.06697965f, 
    -0.02494087f, 0.02482257f, 0.08679944f, -0.12182225f, -0.13301225f, 0.00744344f, 0.07078735f, -0.17458263f, 
    0.04999466f, -0.21550801f, -0.03892890f, 0.06188716f, 0.06571969f, 0.04647399f, -0.20458782f, -0.36195633f, 
    0.34129289f, 0.02304485f, 0.31007126f, -0.13418347f, -0.24454549f, 0.07123013f, 0.19675900f, -0.11988501f, 
    0.06740870f, -0.13905187f, 0.14505601f, -0.03918873f, 0.05786015f, -0.29727566f, -0.01968621f, -0.05515282f, 
    0.02997016f, 0.06082867f, 0.09000658f, 0.03613914f, -0.08045986f, -0.11495031f, -0.48048237f, -0.62328559f, 
    -0.01140786f, 0.08067535f, 0.19233947f, -0.22114654f, 0.23891935f, 0.31421232f, 0.15523808f, 0.08882597f, 
    -0.03183667f, 0.07589832f, 0.08979589f, 0.07836507f, 0.29189926f, -0.20378403f, 0.47717792f, -0.10498320f, 
    0.06982385f, 0.04151142f, 0.16114980f, -0.05311422f, 0.09470682f, -0.06588414f, 0.10014641f, -0.20336567f, 
    -0.07456796f, -0.15410432f, -0.05741112f, 0.08757728f, -0.01813812f, 0.00592234f, -0.04639965f, 0.10250369f, 
    -0.02957525f, -0.24063969f, -0.37263456f, -0.21332929f, -0.07017489f, 0.06017967f, -0.15585485f, -0.07328402f, 
    -0.07364658f, -0.09302031f, 0.03208120f, 0.35117516f, 0.04921697f, 0.24889019f, 0.05847905f, -0.05814043f, 
    -0.04555301f, 0.17624323f, 0.18692267f, -0.09231950f, 0.13856183f, 0.07214238f, 0.02245507f, 0.00250564f, 
    0.05884361f, -0.08126394f, -0.01259755f, 0.03224720f, -0.23669885f, -0.78018838f, 0.04758156f, -0.02415258f, 
    -0.09484121f, -0.07630781f, 0.06868539f, 0.01986774f, 0.06294170f, -0.13586678f, 0.08010404f, 0.26520294f, 
    0.17588048f, -0.23316112f, -0.61346567f, 0.41292641f, 0.07227733f, 0.00805968f, 0.06027351f, 0.06601723f, 
    0.07788003f, -0.18167356f, 0.05453757f, -0.21688287f, -0.47205034f, 0.10882465f, -0.31153536f, -0.11866867f, 
    -0.08085994f, -0.27888143f, 0.07570755f, 0.18396045f, 0.25939345f, -0.07621625f, -0.13604777f, -0.02191545f, 
    0.09973916f, 0.27867341f, 0.19409730f, -0.10475468f, -0.03152785f, 0.01895622f, 0.07762023f, -0.07749075f, 
    0.10759267f, 0.08924513f, 0.06636199f, 0.04721887f, -0.39889878f, -0.50454509f, 0.44667616f, 0.30394346f, 
    -0.21813776f, -0.17185676f, -0.05130415f, 0.12275298f, 0.14218245f, 0.01225020f, -0.07380723f, -0.09108616f, 
    -0.46077886f, -0.25920421f, -0.30142185f, -0.05966832f, -0.03836917f, -0.20706657f, 0.15019871f, 0.28351527f, 
    -0.04835696f, -0.06054552f, 0.13404554f, -0.07384872f, 0.48992109f, -0.23814616f, -0.02294267f, 0.20540054f, 
    0.09883111f, -0.09048548f, -0.11771630f, 0.14567934f, 0.09354106f, 0.11010087f, 0.16190910f, -0.09443408f, 
    -0.42471436f, -0.89069295f, -0.01311756f, -0.52998877f, 0.18522319f, -0.00680967f, -0.07910454f, -0.18201061f, 
    -0.05169298f, 0.01188155f, 0.02769583f, -0.04245167f, -0.19313043f, -0.02983110f, -0.09592794f, 0.02118430f, 
    -0.05586236f, -0.22543041f, -0.08685017f, 0.03965520f, 0.03201725f, -0.00440470f, -0.03720816f, -0.15321162f, 
    0.26692533f, -0.35163033f, -0.32045037f, -0.15118566f, -0.08246203f, 0.14048874f, 0.18018469f, 0.19211225f, 
    -0.01242193f, -0.13675027f, -0.04325016f, 0.07498709f, -0.30573067f, 0.57666373f, 0.31600422f, 0.03689273f, 
    0.01907931f, -0.10075773f, -0.06179745f, 0.05733849f, -0.05630130f, 0.09398709f, 0.24100234f, 0.12639764f, 
    -0.02010185f, 0.00187629f, -0.60108244f, -0.07570492f, -0.02632442f, -0.09871680f, 0.06562513f, 0.35091388f, 
    -0.03181547f, 0.16952626f, -0.17093088f, -0.05699863f, -0.15072723f, -0.10126846f, -0.14783870f, 0.04663498f, 
    0.01688648f, -0.02252471f, 0.01326963f, 0.01049232f, -0.08830628f, -0.23009221f, -0.20118377f, -0.04446656f, 
    -0.22208287f, -0.32655385f, 0.08174014f, 0.28693080f, 0.01878596f, -0.05501466f, -0.00986752f, 0.18216968f, 
    -0.00498347f, 0.03992578f, 0.33429047f, -0.14695683f, 0.21265692f, -0.03527415f, -0.10160064f, 0.03559744f, 
    -0.04648059f, 0.09845787f, -0.00821786f, 0.01067355f, -0.06871684f, -0.02250346f, 0.08101647f, -0.03692482f, 
    0.85974002f, 0.10895464f, -0.31910005f, 0.03218049f, -0.06649981f, -0.15271030f, 0.22576554f, 0.20735809f, 
    0.12018266f, -0.22022575f, 0.01256283f, -0.13847408f, -0.08396810f, -0.45919171f, -0.42498428f, -0.26332381f, 
    0.09191073f, 0.02594896f, 0.04944214f, -0.01744951f, -0.08059309f, 0.14051920f, -0.06512588f, -0.17506744f, 
    -0.20198774f, -0.19751759f, -0.19751953f, -0.12101776f, 0.07728328f, 0.11205418f, -0.11252747f, -0.24401605f, 
    -0.03995760f, -0.01705653f, 0.03046673f, 0.16381526f, -0.39644656f, -0.83502418f, -0.56330532f, 0.24123307f, 
    -0.17167027f, 0.04638104f, 0.01334269f, 0.13243847f, -0.00909745f, 0.02152348f, 0.12882926f, 0.00780200f, 
    -0.21160969f, -0.41646135f, -0.68951511f, 0.16542333f, 0.16637254f, 0.08265341f, 0.11171558f, -0.34203437f, 
    0.06259425f, -0.04839116f, -0.15685077f, 0.05639817f, 0.16057862f, -0.08154257f, -0.07571803f, 0.11692793f, 
    0.12346648f, -0.07720570f, 0.42602232f, 0.08847981f, 0.18397799f, 0.16338882f, -0.14907970f, -0.17734851f, 
    -0.04031079f, -0.14076491f, -0.20863566f, 0.05118858f, 0.07607897f, 0.13245484f, 0.07025922f, -0.01210399f, 
    0.09495425f, -0.03757537f, -0.03182637f, -0.08100148f, -0.38920730f, -0.03768680f, 0.05631326f, -0.10334995f, 
    0.04209862f, 0.05798206f, 0.20249332f, -0.24053180f, -0.12732179f, -0.00606547f, 0.14909273f, 0.19561757f, 
    -0.18021409f, -0.28806642f, -0.00232027f, -0.12294659f, -0.06630678f, 0.31860620f, 0.08525132f, -0.41275594f, 
    0.02608284f, 0.04812548f, -0.05214450f, 0.10378504f, -0.29549360f, -0.81402141f, -0.05099116f, -0.15277262f, 
    -0.42855743f, 0.20736624f, -0.19193321f, 0.03904437f, 0.01008481f, 0.03006319f, 0.02317739f, 0.15409060f, 
    -0.58714461f, 0.25707066f, 0.11901141f, -0.57293797f, -0.06754031f, -0.06843335f, -0.21694168f, -0.12234534f, 
    -0.03465490f, 0.08185168f, 0.15634480f, -0.04388023f, -0.02119737f, 0.10164218f, -0.00250417f, -0.04069101f, 
    -0.04184725f, 0.01991815f, 0.00927358f, 0.05358069f, 0.10595506f, -0.03632813f, 0.16211744f, 0.16593014f, 
    -0.90476120f, -0.53052014f, -0.38979995f, -0.35283095f, -0.31015301f, -0.00305372f, -0.05933888f, -0.27472782f, 
    0.07134979f, -0.01851028f, -0.04426036f, -0.02401524f, -0.05018032f, 0.08191141f, -0.42491660f, -0.01093489f, 
    0.00843454f, -0.05549946f, 0.02561195f, 0.32859099f, 0.04595906f, 0.27466244f, 0.11417122f, 0.14090638f, 
    -0.02619149f, 0.05083641f, -0.07216487f, 0.13353772f, -0.04203837f, 0.07920197f, 0.04305178f, 0.06712319f, 
    0.32672265f, 0.07113211f, 0.21804366f, 0.07014456f, 0.19232568f, -0.09737064f, 0.01837612f, 0.08680588f, 
    -0.00583588f, -0.07584666f, 0.09928485f, -0.08070978f, -0.02664467f, -0.02155216f, -0.10024404f, 0.02864888f, 
    -1.11489153f, -0.75290918f, 1.04941404f, 0.14030290f, -0.60098249f, -0.09305310f, -0.21755672f, -0.01105499f, 
    -0.08771880f, 0.12451789f, 0.00645945f, -0.08040038f, -0.00187286f, 0.33422881f, -0.17733997f, 0.24766755f, 
    0.13149257f, 0.00040958f, 0.13192768f, -0.05224687f, 0.13796489f, -0.23644681f, 0.19333953f, 0.04009444f, 
    0.67255235f, -0.13514167f, -0.29526961f, -0.20808104f, -0.08754336f, -0.12709285f, 0.34189498f, 0.09634995f, 
    -0.01231784f, 0.27046517f, -0.07755112f, -0.10460207f, -0.08883247f, -0.15815631f, 0.07762124f, 0.17466572f, 
    0.09822378f, 0.11232928f, 0.04369599f, -0.00288894f, 0.00540725f, -0.06014836f, 0.11843882f, 0.06071215f, 
    -0.96551448f, -0.94584763f, -0.27527714f, -0.68890429f, -0.10474743f, -0.26302049f, -0.08294014f, -0.44340983f, 
    -0.02090949f, -0.09565108f, -0.02340691f, -0.13353792f, -0.02504016f, -0.52446878f, -0.46027264f, 0.32382256f, 
    -0.03866850f, -0.04098247f, 0.03936201f, 0.25012088f, -0.00068974f, 0.13548703f, 0.19642842f, -0.12340685f, 
    0.20214088f, 0.13779345f, 0.20051675f, 0.25661540f, -0.08846617f, 0.12532856f, -0.11795105f, 0.30069903f, 
    0.09833299f, 0.19756816f, 0.09105460f, -0.16010511f, 0.05044457f, 0.19471437f, -0.33045381f, 0.51344234f, 
    -0.08972342f, 0.03642418f, -0.07083876f, 0.21463497f, -0.01462152f, 0.07838450f, 0.13645288f, 0.03284185f, 
    -0.72198826f, 0.25527841f, -0.00299336f, 0.45947507f, -0.11277184f, 0.07311665f, 0.06012709f, -0.01838609f, 
    0.09963204f, 0.00022484f, -0.04881296f, -0.12223376f, 0.14970997f, -0.04059975f, 0.06624693f, -0.18970546f, 
    -0.02107365f, -0.09124165f, 0.12330445f, -0.02880303f, 0.01202682f, 0.00874449f, -0.09249931f, -0.09431035f, 
    -0.04348139f, 0.20802961f, -0.12147626f, -0.00979873f, -0.16761054f, 0.17598036f, -0.10375047f, 0.21255963f, 
    0.06151958f, 0.00064317f, 0.13452515f, 0.03307546f, 0.40690288f, -1.17671764f, -0.80655748f, -0.54103178f, 
    -0.11916131f, 0.02298124f, -0.00895386f, 0.09059285f, 0.03806062f, 0.04913022f, -0.09337488f, 0.06993257f, 
    -0.85529011f, 0.05933654f, -0.41936439f, 0.11790267f, 0.19438072f, 0.06400681f, -0.01037812f, -0.21221900f, 
    0.03843278f, -0.02244342f, 0.12135916f, 0.01585417f, 0.11283720f, 0.07496949f, 0.00771397f, -0.09810653f, 
    0.00134880f, 0.00951740f, 0.03359165f, -0.05584332f, -0.03525707f, 0.02847801f, -0.08197924f, -0.11075881f, 
    -0.04769524f, -0.17847720f, 0.03887162f, 0.28326616f, -0.15513393f, -0.20261545f, 0.17771618f, -0.22627722f, 
    0.00997732f, -0.07827972f, 0.22031836f, -0.14933260f, 0.12829486f, -0.05582952f, 0.11812967f, -0.18037394f, 
    0.06783005f, 0.08651730f, -0.08721634f, -0.03618384f, 0.03720561f, 0.05084638f, 0.09397045f, -0.02009235f, 
    -0.42016503f, -0.19975452f, 0.01432174f, 0.30117598f, -0.18303865f, 0.10461853f, 0.11809969f, -0.11726657f, 
    -0.05501174f, 0.02961248f, -0.05848023f, 0.01304641f, -0.15525635f, -0.04690335f, 0.13798283f, -0.13867992f, 
    0.03729560f, -0.07337747f, -0.02426548f, -0.05641011f, 0.13281910f, 0.01721612f, 0.10300528f, 0.04233065f, 
    0.63639545f, 0.10850648f, 0.06180437f, 0.07462153f, -0.17602912f, -0.02883727f, -0.06532627f, -0.08775135f, 
    -0.02723879f, 0.17393558f, -0.11349650f, -0.09460910f, -0.19869296f, -0.50812823f, 0.03494949f, -0.54755980f, 
    -0.11631317f, -0.01575538f, 0.09731670f, 0.22694275f, 0.00595549f, -0.05739155f, -0.05907524f, 0.04049420f, 
    -0.49627534f, -0.02506039f, 0.27282611f, 0.09065352f, -0.03082173f, -0.15524457f, -0.10319295f, 0.13998553f, 
    0.05103119f, 0.06353986f, 0.05667062f, -0.01337063f, -0.03821322f, -0.03852519f, 0.10765641f, -0.11538440f, 
    -0.10036433f, 0.02347335f, -0.27050370f, -0.20891997f, -0.04022012f, 0.00127590f, -0.02046397f, -0.02227173f, 
    0.17283739f, 0.04378631f, -0.13830519f, -0.15780805f, -0.05101598f, -0.06412769f, -0.01796626f, 0.01137156f, 
    0.09018110f, 0.11199643f, -0.17191049f, -0.26901221f, 0.06569005f, 0.28162825f, -0.07167798f, 0.08968644f, 
    0.04233775f, 0.07926570f, 0.03986764f, -0.05721212f, 0.00133086f, 0.08079193f, 0.00960413f, 0.08646415f, 
    -0.34739909f, 0.06376662f, -0.31267732f, 0.17727961f, 0.38537705f, 0.13323827f, 0.12530880f, -0.15624678f, 
    0.03560461f, -0.06016007f, 0.05998485f, 0.00749783f, 0.04912835f, -0.78787297f, -0.69043833f, -0.41509053f, 
    -0.01625604f, -0.06156456f, 0.14392918f, 0.14672060f, 0.02043381f, -0.07937263f, -0.15391982f, 0.15781645f, 
    -0.02511425f, -0.57041126f, 0.21771541f, 0.54043406f, 0.04958053f, 0.05873517f, 0.03379162f, 0.05184102f, 
    -0.00858977f, -0.05440873f, 0.09433738f, -0.03017664f, 0.18288106f, 0.06831298f, 0.02570471f, -0.04194622f, 
    -0.01915900f, -0.01000271f, -0.00129723f, -0.06217336f, 0.05456655f, -0.00927644f, -0.00591086f, -0.01543038f, 
    -0.43859532f, -0.46730089f, -0.27173585f, -0.34037200f, -0.08282867f, -0.04798554f, -0.08955360f, 0.11193042f, 
    0.01659390f, -0.02938700f, 0.00004245f, -0.00980696f, -0.02100787f, -0.68743706f, 0.08551174f, -0.19184364f, 
    -0.16070993f, -0.08911198f, -0.00703417f, -0.01989696f, 0.13974988f, -0.02038819f, 0.06365588f, -0.13726659f, 
    0.25010088f, -0.03049902f, -0.02397733f, 0.02842848f, 0.05040627f, 0.00115960f, -0.04381270f, -0.06400412f, 
    0.07321447f, 0.17742097f, -0.02447192f, 0.15476695f, -0.05920241f, 0.04350702f, 0.02569799f, -0.01839454f, 
    -0.16649957f, -0.00389368f, 0.00114976f, -0.30227363f, 0.06222665f, 0.00014407f, 0.04849716f, 0.09286992f, 
    0.73389125f, -0.65231860f, -0.27664667f, 0.06060057f, 0.09729160f, -0.00643831f, 0.08767296f, 0.18314965f, 
    0.04081750f, -0.08537965f, -0.01557768f, 0.02451301f, 0.16509871f, -0.11853159f, -0.10934895f, -0.03953773f, 
    -0.00074721f, 0.03032396f, 0.11767183f, -0.09350701f, -0.21817112f, 0.08993205f, 0.08278468f, -0.16746667f, 
    -0.19454536f, 0.33551279f, -0.35362580f, 0.26668158f, -0.11237049f, 0.15729263f, 0.05925075f, 0.05452345f, 
    0.02281900f, 0.06870230f, -0.03144414f, -0.04591099f, 0.18359768f, 0.07881013f, 0.01409120f, -0.01801087f, 
    0.06446961f, 0.02940670f, 0.01455710f, -0.08851897f, -0.18805782f, 0.01834510f, -0.14574206f, -0.32780167f, 
    -0.48892719f, -0.14392418f, -0.02638723f, 0.76915538f, -0.06336769f, 0.09179528f, -0.16036478f, 0.00715275f, 
    -0.04327790f, -0.07260661f, -0.09825393f, 0.03873732f, 0.75699109f, -0.56500775f, 0.17642349f, 0.01756429f, 
    0.05544716f, -0.02436819f, -0.06280050f, -0.06331518f, -0.24506164f, 0.15748669f, -0.02460507f, -0.24864607f, 
    0.44040361f, -0.00978242f, -0.06320044f, -0.04832075f, -0.06200154f, -0.00959475f, 0.02699437f, -0.00989989f, 
    0.12170540f, -0.06543919f, -0.11558576f, -0.00956065f, 0.31390902f, -0.78133959f, 0.19129725f, -0.24422415f, 
    0.00221667f, 0.14980093f, -0.02722658f, -0.16445099f, -0.09727956f, 0.00454745f, -0.09014326f, -0.02030378f, 
    0.24609649f, 0.17675948f, -0.00141925f, -0.28528044f, -0.08987629f, -0.22313888f, -0.06407159f, -0.03060013f, 
    0.03825330f, 0.13789882f, 0.01309965f, 0.01179486f, -0.22732794f, -0.14431322f, -0.01471986f, -0.05957571f, 
    -0.04686734f, -0.01466607f, -0.01042913f, -0.10822081f, 0.06178342f, 0.19296691f, 0.15136439f, 0.33302581f, 
    -0.65371674f, -0.03776690f, 0.10585937f, 0.11320170f, 0.11961871f, -0.11049809f, -0.14834818f, -0.13738480f, 
    -0.18368928f, -0.12990291f, -0.02388280f, -0.15007982f, -0.76459461f, -0.48887679f, -0.04469747f, 0.09571671f, 
    -0.01112885f, 0.24516211f, 0.18001358f, 0.19205326f, 0.09261274f, 0.02638257f, 0.05428995f, 0.17093296f, 
    -0.21913217f, -0.17263350f, -0.14483620f, 0.22397606f, -0.04236602f, 0.07534257f, 0.10370137f, -0.10727066f, 
    -0.02095790f, 0.09355962f, -0.20134492f, 0.07428971f, 0.04039115f, 0.05939765f, -0.09686711f, -0.15220217f, 
    -0.13375762f, -0.09856118f, -0.04406703f, -0.08072548f, 0.00990534f, -0.09063967f, -0.00341968f, 0.07768527f, 
    -0.00578012f, -0.03636469f, 0.04061350f, -0.19658290f, 0.10923729f, 0.01182147f, 0.20262174f, 0.08282672f, 
    -0.14221297f, 0.20524609f, -0.10626974f, -0.31612256f, 0.16737196f, 0.26097289f, 0.11605470f, -0.05958940f, 
    -0.12713730f, -0.10031550f, -0.04498281f, -0.07654485f, -0.04026286f, -0.04066906f, 0.02568837f, -0.00758621f, 
    -0.66685247f, 0.15454701f, 0.08006302f, 0.16306019f, 0.14086872f, 0.09114299f, -0.22324234f, 0.16111228f, 
    -0.18348537f, 0.02531794f, 0.27100947f, 0.06622116f, -0.35312462f, 0.28857201f, 0.23998860f, -0.04413600f, 
    -0.13023925f, 0.11458140f, -0.01429438f, -0.02716337f, -0.02189556f, 0.01705121f, -0.15263291f, 0.07367108f, 
    0.60628802f, 0.06155926f, -0.27112329f, -0.13315420f, 0.06703123f, -0.00174841f, 0.30701774f, 0.03182822f, 
    -0.03439410f, 0.03699648f, 0.09049942f, 0.13948201f, 0.13125271f, -0.30913457f, -0.18599467f, 0.03545164f, 
    -0.19070475f, -0.01061657f, 0.23318233f, -0.03050804f, -0.01603107f, -0.07544778f, -0.04607446f, -0.16148208f, 
    0.27869970f, 0.02364963f, 0.02078196f, 0.17534974f, -0.18302554f, -0.14495489f, -0.04566991f, -0.09893816f, 
    0.11508761f, 0.16009641f, 0.01903143f, 0.01302524f, -0.14336772f, 0.06135987f, 0.03551415f, -0.00476037f, 
    0.09337064f, 0.02380727f, 0.04541954f, 0.00315237f, 0.02613857f, 0.10452728f, 0.09630293f, -0.00276288f, 
    0.00921554f, 0.03044092f, -0.16731836f, -0.43183050f, -0.01953045f, -0.08029860f, -0.01863824f, -0.08662932f, 
    -0.01083979f, -0.04980445f, -0.12474903f, 0.14145298f, -0.42795047f, -0.07058317f, 0.36765942f, 0.03289417f, 
    0.09026233f, 0.10387968f, -0.00473920f, -0.02333740f, -0.13430803f, -0.25396407f, -0.06869218f, -0.16576202f, 
    0.04942580f, -0.00406461f, 0.02556209f, 0.15425090f, -0.05080397f, 0.23461147f, -0.05150687f, 0.22666518f, 
    -0.18378055f, -0.02804400f, -0.33734295f, -0.20787942f, 0.20722157f, -0.76396650f, -0.49659121f, 0.00922392f, 
    0.18581550f, 0.02808020f, 0.04830867f, 0.08973778f, -0.09158954f, -0.13399011f, -0.10581567f, -0.22474359f, 
    0.43010670f, -0.51447874f, -0.81046659f, -0.22313114f, 0.00383346f, 0.03927180f, 0.15193211f, 0.08242323f, 
    0.02819540f, 0.29772857f, 0.09044896f, -0.00976859f, -0.34111571f, -0.06410687f, 0.01203094f, -0.10461580f, 
    -0.04606727f, 0.01301404f, -0.02038419f, -0.10128842f, 0.05725777f, 0.02717697f, -0.14629665f, -0.25405493f, 
    0.16648079f, -0.39132547f, -0.47549921f, 0.09771010f, 0.10621039f, 0.10412576f, 0.12123088f, -0.14105605f, 
    -0.04958817f, -0.12194113f, -0.01707238f, -0.03030209f, 0.52873081f, -0.07803082f, -0.19199452f, -0.23594730f, 
    0.23572890f, 0.06508492f, 0.07025603f, 0.09049504f, -0.03061159f, -0.10600041f, -0.31196538f, -0.36490947f, 
    -0.19143948f, -0.12202004f, 0.06720325f, 0.02781845f, 0.18680927f, 0.04815261f, 0.08133455f, 0.12525423f, 
    -0.24942897f, -0.10918111f, -0.17101829f, -0.26030874f, -0.18216664f, -0.10014623f, 0.06516916f, -0.02031931f, 
    0.09071446f, 0.07120753f, -0.02140917f, 0.15580852f, -0.00426043f, 0.02442274f, -0.00124037f, 0.00603672f, 
    -0.06576621f, -0.37783554f, -0.78420055f, -0.12504414f, -0.10154019f, -0.02699712f, 0.11005034f, 0.02771395f, 
    -0.05455666f, -0.11174491f, -0.06013230f, -0.05239945f, -0.06505276f, 0.05960969f, 0.15951814f, -0.10684295f, 
    -0.03936643f, -0.01862989f, -0.03873089f, -0.09090224f, -0.07121110f, 0.01898310f, 0.09434094f, 0.14694752f, 
    -0.69161141f, 0.31708705f, -0.02213514f, 0.40567279f, -0.00263467f, 0.04383499f, -0.19491400f, 0.08824217f, 
    -0.05504450f, -0.08171193f, 0.03518509f, -0.04824011f, 0.13480444f, 0.00703357f, 0.08113224f, -0.09075164f, 
    -0.15678295f, -0.00701476f, 0.05339707f, 0.04400949f, 0.13004398f, -0.00338297f, 0.25857177f, -0.00238329f, 
    -0.42532992f, -0.40089962f, -0.37235340f, -0.26830977f, -0.29448605f, -0.19515535f, -0.02666055f, 0.02494062f, 
    0.09900159f, 0.11283251f, 0.09132078f, 0.06816114f, 0.62174022f, -0.24154842f, -0.26883101f, -0.52000529f, 
    0.30363446f, -0.01539946f, 0.15164360f, -0.07541897f, 0.02477955f, 0.10768335f, 0.34178725f, 0.11670092f, 
    -0.47723830f, -0.18179688f, -0.25406411f, 0.09360272f, 0.06626572f, 0.17587964f, 0.18756944f, 0.35105878f, 
    -0.11608762f, -0.01893102f, -0.24729241f, -0.12187697f, 0.38833591f, 0.26358643f, -0.24065228f, -0.08083136f, 
    0.32243949f, -0.03923467f, 0.09931514f, 0.12529133f, 0.05375786f, -0.02140743f, 0.04473438f, 0.22967364f, 
    0.28998566f, -0.32376894f, -0.63180447f, 0.01032867f, 0.06849906f, 0.10024186f, 0.04955027f, 0.06128701f, 
    0.09320012f, 0.00509760f, -0.07075819f, -0.24907610f, 0.27325764f, 0.02063157f, 0.18039088f, -0.11891458f, 
    0.30971932f, -0.31132969f, 0.03120765f, 0.03982266f, -0.04747503f, -0.00196275f, -0.06174861f, -0.03653205f, 
    0.05872177f, 0.51066375f, -0.63010365f, 0.02999479f, 0.08359394f, 0.14579518f, 0.26331294f, -0.08686551f, 
    -0.03221128f, -0.14580092f, -0.10721343f, 0.11681931f, 0.63016754f, 0.27508938f, 0.33536288f, -0.08987120f, 
    -0.08279816f, -0.09961198f, -0.29769686f, -0.08137115f, -0.19912452f, 0.06403116f, 0.07021360f, -0.07193732f, 
    -0.34242070f, -0.01431931f, -0.67877012f, -0.47846946f, 0.16388775f, -0.25926965f, 0.16216467f, 0.00462933f, 
    -0.02959243f, -0.08660271f, -0.20648229f, -0.15597039f, -0.05144060f, -0.27284351f, 0.01399570f, 0.07324069f, 
    0.13304102f, 0.30807066f, 0.08826163f, -0.04158598f, 0.05989807f, -0.04600629f, -0.01864769f, -0.17573678f, 
    -0.29430735f, -0.09935796f, 0.01229982f, 0.06025891f, 0.12884988f, 0.23638636f, 0.19597600f, -0.11691558f, 
    0.16913979f, 0.15379101f, 0.05389231f, -0.08435900f, -0.55988115f, -0.49857938f, -0.49570930f, 0.17426412f, 
    0.12790483f, 0.04970798f, 0.15192863f, -0.06150053f, -0.02731475f, -0.06280805f, 0.00115213f, -0.01258933f, 
    -0.35175535f, 0.71148401f, -0.47551927f, -0.58282661f, -0.14825091f, -0.18885918f, 0.21259785f, -0.41221067f, 
    0.23236631f, 0.12898289f, 0.05143059f, -0.20988210f, -0.16954331f, -0.12727056f, -0.29198125f, -0.20644987f, 
    0.15689145f, 0.05217374f, 0.19798441f, -0.07022278f, 0.18886693f, -0.03901763f, -0.19730859f, -0.08168488f, 
    -0.61819500f, -0.25633410f, -0.70347708f, 0.40671545f, -0.00775274f, 0.09243813f, -0.09021454f, 0.06779853f, 
    -0.03323203f, -0.12485132f, -0.01257265f, 0.05730246f, 0.04521729f, -0.29664963f, 0.13608798f, 0.05732043f, 
    -0.14157201f, 0.01962695f, -0.07833198f, 0.12243335f, 0.09703422f, 0.09170755f, 0.10788234f, -0.06897486f, 
    0.27961436f, 0.13545898f, -0.47706097f, -0.16494592f, 0.17616612f, -0.14819868f, 0.24617472f, 0.00858870f, 
    0.00205751f, 0.05042978f, -0.12775706f, -0.04843240f, -0.19546132f, 0.16178066f, -0.42572162f, -0.07551506f, 
    -0.20238703f, 0.09869923f, 0.11489680f, -0.16423902f, -0.11931654f, 0.10005292f, -0.23705193f, -0.10328398f, 
    -0.26494870f, 0.11904690f, 0.26087421f, 0.20239849f, 0.09632414f, 0.10075080f, -0.02371530f, -0.00056023f, 
    -0.06379360f, -0.13461398f, 0.01921433f, 0.06890038f, -0.28485671f, -0.21847871f, -0.51384145f, 0.07027024f, 
    0.05311915f, 0.00849265f, 0.00671083f, 0.15477423f, 0.05690376f, -0.08483716f, 0.06305193f, 0.14178886f, 
    -0.25105998f, 0.30554220f, -0.06084241f, -0.10828213f, -0.39491385f, -0.03927981f, 0.07881860f, 0.07956760f, 
    0.10994887f, 0.02719101f, -0.03150143f, 0.01467352f, -0.16453457f, -0.12572590f, -0.01279804f, 0.33423966f, 
    0.02652553f, -0.11820552f, -0.01852590f, -0.05343627f, 0.08398177f, -0.03027063f, 0.13220519f, 0.05603250f, 
    -0.39129066f, -0.13401166f, 0.17816581f, 0.40396830f, 0.07152650f, -0.13319264f, -0.16463690f, -0.00574254f, 
    0.05384145f, 0.11967345f, -0.16034774f, -0.04673075f, 0.15162502f, -0.16062774f, 0.17347750f, 0.12745500f, 
    0.01223495f, 0.03497384f, 0.02919543f, 0.01440086f, -0.05375966f, 0.01314181f, 0.13130783f, 0.20962703f, 
    0.08619390f, -0.03789632f, 0.44801202f, -0.20480549f, -0.20504902f, -0.10406572f, -0.15561481f, 0.23074061f, 
    -0.01144189f, -0.03281812f, 0.09341990f, 0.07359940f, 0.18828575f, -0.38520405f, 0.33731335f, 0.02993187f, 
    0.00443828f, -0.02519567f, 0.05452176f, -0.22845075f, -0.03292522f, -0.04541716f, -0.06710619f, 0.11693063f, 
    -0.02896578f, 0.12185456f, 0.06830272f, -0.00513067f, -0.09218290f, -0.06545730f, 0.00727655f, -0.02935679f, 
    0.02999316f, -0.01057736f, 0.13775538f, 0.17705730f, 0.06552684f, 0.23816198f, -0.09849460f, -0.18156733f, 
    0.14289488f, 0.27164084f, -0.10266734f, 0.03572439f, 0.16282763f, 0.01284547f, -0.08804373f, 0.01862486f, 
    -0.65893918f, -0.05161450f, -0.06636801f, 0.12064777f, 0.07855044f, -0.07480560f, -0.19603719f, 0.09729131f, 
    0.01317078f, -0.12933320f, 0.08208452f, 0.02319170f, 0.08029763f, -0.29567075f, 0.19550216f, -0.19969590f, 
    -0.08243468f, -0.10777284f, -0.02600857f, 0.04030237f, -0.18338363f, 0.14029223f, 0.11269985f, -0.19798104f, 
    -0.46596500f, 0.69757658f, -0.48296270f, -0.32254687f, 0.00900942f, -0.05568975f, 0.16933741f, 0.07863398f, 
    0.18082891f, 0.01299424f, 0.11363535f, 0.12571774f, -0.31959867f, -0.11320515f, 0.24456967f, -0.02978404f, 
    -0.09275144f, 0.13226843f, -0.37661079f, -0.07469465f, 0.06813292f, -0.16816890f, 0.06419057f, 0.07188980f, 
    -0.31001410f, -0.00332877f, -0.18077153f, -0.16710632f, -0.35169715f, -0.22388767f, -0.00105157f, 0.24977948f, 
    0.09607501f, 0.08314022f, 0.12253973f, 0.00382301f, -0.12392816f, 0.45336586f, 0.35335255f, 0.44353428f, 
    -0.10752068f, -0.07270967f, -0.12821431f, -0.41271859f, 0.10052232f, 0.02556415f, 0.03240617f, 0.05984433f, 
    -0.26060978f, 0.25322956f, 0.25122994f, -0.18758574f, -0.06299207f, -0.33552623f, -0.03293002f, -0.43134767f, 
    0.08362737f, -0.08640871f, 0.09214860f, 0.14998633f, 0.24285361f, -0.50359565f, 0.31423658f, -0.12833290f, 
    -0.12207764f, -0.18429050f, 0.16638604f, -0.15633130f, 0.07611048f, -0.00386599f, -0.04895518f, -0.20644619f, 
    -0.18299328f, -0.53031874f, -0.45964989f, 0.31459603f, -0.05243333f, 0.11664110f, 0.15527390f, -0.25134099f, 
    0.06919389f, 0.24735180f, -0.01758558f, 0.13114631f, -0.26959908f, 0.34774101f, 0.04400280f, 0.13329802f, 
    -0.20940195f, -0.07917819f, -0.02590659f, 0.04989602f, 0.13408987f, 0.09454399f, 0.42090905f, 0.18960366f, 
    0.08010294f, -0.32759282f, -0.29955319f, -0.16348442f, -0.09513137f, -0.50034148f, -0.00841116f, -0.02255380f, 
    -0.07642059f, -0.10128260f, -0.20531581f, -0.12750119f, 0.00933028f, 0.46770898f, -0.06660451f, 0.33949214f, 
    -0.03670554f, 0.05200344f, -0.03084745f, 0.16178927f, -0.05993153f, 0.26296452f, -0.17116481f, -0.00983017f, 
    0.06468507f, -0.06112003f, 0.42954177f, 0.53461671f, -0.15150119f, 0.07037549f, -0.00608471f, 0.40672055f, 
    -0.00796140f, -0.07474100f, 0.15437877f, 0.12158643f, -0.41460359f, -0.37987417f, -0.33249953f, -0.58017063f, 
    -0.22574472f, -0.02468443f, -0.05784956f, -0.02734718f, -0.05849607f, -0.06240738f, 0.07185038f, -0.08459533f, 
    0.28661028f, 0.11839615f, 0.45922673f, 0.44843805f, -0.08266171f, 0.15249047f, -0.01716194f, 0.20623118f, 
    -0.01238279f, -0.09043684f, -0.18362941f, 0.06702711f, 0.03120359f, -0.00338958f, -0.20147014f, -0.06772289f, 
    -0.18991309f, 0.01340040f, 0.04297818f, -0.21692272f, 0.10679145f, 0.14708877f, -0.04921437f, 0.08211014f, 
    0.01337513f, 0.11403332f, -0.02325626f, -0.01503930f, -0.03292949f, -0.06098109f, 0.24163938f, 0.03669718f, 
    -0.17200200f, -0.05668245f, -0.09377450f, 0.10567381f, -0.17032431f, 0.23915060f, 0.13430536f, 0.14339888f, 
    -0.10290141f, -0.12005568f, -0.05450129f, 0.05963451f, -0.19480757f, 0.02450984f, 0.19101210f, 0.04637475f, 
    -0.33060232f, 0.66983134f, -0.14032629f, 0.16973576f, -0.07323367f, 0.14254111f, -0.00959361f, 0.02298652f, 
    -0.12905085f, 0.27732474f, -0.14536785f, 0.09400514f, -0.38389438f, -0.02264550f, -0.40701875f, 0.12571217f, 
    -0.04121012f, -0.03276971f, 0.06677774f, -0.17142232f, -0.03608704f, 0.00962424f, -0.02189249f, -0.41500023f, 
    -0.55994487f, -0.39375195f, -0.00906478f, -0.17568687f, -0.01893233f, 0.06196184f, -0.06634402f, 0.13891189f, 
    0.02073061f, -0.04570942f, 0.02082854f, -0.05996907f, -0.12268759f, 0.17889535f, 0.09397348f, 0.15958126f, 
    -0.16073759f, 0.03261958f, 0.04280705f, -0.07922574f, 0.05974675f, -0.10793159f, 0.22793177f, -0.01463829f, 
    0.17654322f, -0.03807551f, -0.16070673f, -0.16080441f, -0.14233553f, 0.11212016f, 0.00618585f, -0.11697206f, 
    0.18403412f, -0.02637332f, -0.17132199f, 0.12477747f, 0.02312945f, 0.07760402f, -0.15084633f, -0.22940138f, 
    -0.11491671f, -0.13644776f, -0.14973976f, -0.18081652f, -0.03690717f, 0.05797828f, -0.16812700f, -0.13863409f, 
    0.29065681f, -0.48941603f, -0.04255567f, -0.13558087f, -0.00559398f, -0.27222455f, -0.11216586f, 0.20941770f, 
    -0.40291101f, -0.15482217f, -0.21202274f, -0.11007391f, -0.02540403f, 0.00398398f, -0.10693824f, -0.24004599f, 
    -0.05975898f, -0.06495475f, 0.05933657f, -0.08058260f, 0.12939548f, 0.20620711f, -0.66035753f, -0.43350473f, 
    -0.26003924f, -0.18576638f, 0.19598019f, 0.02097607f, -0.07465092f, 0.03168028f, 0.01514578f, 0.01498662f, 
    -0.05361092f, -0.01091061f, 0.06911828f, 0.07774293f, -0.22119132f, -0.07593229f, 0.09572605f, -0.15838833f, 
    -0.18958777f, 0.05503230f, 0.04862007f, -0.10475922f, 0.02916938f, 0.05453514f, -0.44003752f, -0.39437690f, 
    -0.41890514f, -0.03749504f, -0.12601870f, 0.23425590f, 0.01621688f, 0.03536004f, -0.23894480f, -0.13304533f, 
    -0.09189640f, -0.02133062f, -0.00875767f, 0.00590466f, -0.65369737f, 0.51087934f, -0.14522523f, 0.11395309f, 
    -0.08938957f, 0.09227338f, 0.26071036f, 0.26661518f, -0.18859316f, -0.26644170f, -0.32748905f, -0.30181077f, 
    0.14228177f, -0.00898884f, 0.08361257f, -0.16698740f, 0.01876569f, 0.06197908f, -0.03022539f, -0.00689327f, 
    0.05704955f, -0.17477691f, -0.45160463f, -0.40691125f, -0.07739508f, -0.14387952f, 0.48842970f, 0.06378748f, 
    -0.03722287f, -0.09287190f, 0.06311982f, -0.01182931f, -0.26393771f, 0.02615726f, 0.00718472f, 0.05767762f, 
    -0.48571426f, 0.47647142f, 0.05058973f, 0.20595875f, 0.14702213f, -0.08878858f, -0.04171154f, 0.15320060f, 
    -0.06916124f, 0.13239218f, 0.06351384f, -0.00135216f, -0.18384402f, 0.44961250f, 0.24131574f, -0.07980008f, 
    0.10394224f, -0.07453441f, 0.00028677f, -0.01436377f, 0.07968645f, 0.07820230f, 0.21058972f, -0.05276115f, 
    -0.02854478f, -0.42257258f, 0.49696431f, 0.28359330f, -0.26414517f, -0.10362730f, 0.10799967f, 0.21036635f, 
    -0.29205295f, -0.16353422f, 0.08099580f, -0.09975187f, 0.14657563f, -0.18697084f, 0.36967269f, 0.02579095f, 
    0.03705113f, 0.21728007f, -0.18164811f, -0.17003946f, 0.04337992f, 0.01822725f, -0.06588357f, 0.05522219f, 
    -0.01787601f, -0.54148388f, -0.14727302f, 0.01279036f, -0.09597121f, 0.06563716f, 0.00692447f, -0.02877912f, 
    0.15908878f, 0.05443544f, 0.16857195f, 0.09059009f, -0.53789467f, 0.22115640f, -0.22457135f, -0.54224050f, 
    0.08737602f, 0.00514541f, 0.08657730f, 0.20896584f, -0.24620780f, -0.07321597f, -0.00657196f, 0.03412946f, 
    0.41372490f, -0.00595708f, 0.08464504f, -0.10047750f, -0.03051364f, -0.27795357f, 0.03760521f, 0.16820861f, 
    -0.13956700f, 0.06939555f, -0.12304896f, -0.13214689f, -0.49300924f, 0.30132011f, 0.04595178f, 0.21568868f, 
    -0.02914348f, 0.06334640f, 0.08034364f, 0.15655150f, -0.11990979f, -0.07153100f, -0.09956238f, 0.08257385f, 
    0.05678612f, -0.11462043f, 0.17207366f, 0.05165285f, -0.19975016f, 0.08668955f, -0.11454705f, -0.31960770f, 
    0.10180181f, -0.08341570f, 0.13458575f, 0.07273675f, -0.32598400f, -0.08212058f, -0.21651217f, 0.11901256f, 
    0.06080613f, 0.11200938f, -0.01778973f, 0.15552878f, -0.01325200f, -0.17837027f, 0.07183094f, -0.24145855f, 
    0.33356151f, -0.09476175f, 0.71065694f, 0.03062023f, 0.09205698f, 0.10384107f, 0.12709852f, -0.02472645f, 
    0.05087574f, -0.13320184f, 0.18975484f, -0.06101050f, -1.25178277f, 0.07555643f, -0.46246770f, 0.26005167f, 
    0.04557556f, -0.25191551f, 0.01321238f, 0.07372043f, -0.14384413f, -0.02468226f, -0.16704652f, 0.01447829f, 
    0.52434856f, 0.00156245f, 1.10511398f, -0.15272228f, -0.12559129f, -0.03609488f, -0.38539159f, 0.27606517f, 
    -0.12419470f, -0.00583646f, -0.09621455f, -0.12169718f, 0.14535905f, 0.16755742f, -0.06232798f, -0.04111692f, 
    0.03265410f, 0.00694608f, -0.00813634f, -0.02013720f, -0.07840095f, 0.06619767f, -0.08284216f, -0.14962652f, 
    -0.70693082f, -0.03889863f, 0.25416419f, 0.09997778f, -0.11463121f, 0.20449910f, -0.22182995f, 0.10521467f, 
    0.07200922f, 0.11073867f, 0.45169738f, 0.11626539f, 0.19543830f, -0.20102614f, 0.18982522f, -0.01250790f, 
    0.06007047f, -0.11425975f, -0.11894355f, -0.03383373f, -0.07685301f, -0.06752941f, -0.10135182f, -0.04406413f, 
    0.19526602f, -0.61150515f, 0.61808109f, -0.10540403f, 0.06861579f, -0.02232369f, 0.11207616f, -0.02257488f, 
    -0.01950642f, 0.07792230f, 0.04885418f, 0.05591858f, 0.54767531f, 0.03933348f, 0.15920544f, 0.42217135f, 
    -0.00714195f, 0.29456332f, -0.23253441f, 0.20425683f, -0.23758687f, 0.02321067f, -0.02288783f, -0.11275844f, 
    -0.23866491f, -0.43932080f, 0.08795752f, 0.32479233f, 0.08538283f, 0.11157906f, 0.03033023f, 0.05654185f, 
    0.11070270f, 0.09484030f, 0.18635844f, 0.05279260f, -0.20400977f, 0.00056000f, -0.27893668f, -0.02568034f, 
    -0.04486197f, 0.00450644f, 0.34132075f, 0.00692352f, -0.00021809f, 0.16236192f, 0.14919771f, 0.05029420f, 
    0.33167133f, 0.04407946f, 0.27492759f, 0.20189765f, -0.20631777f, -0.10430337f, -0.17822616f, -0.06449173f, 
    -0.05479177f, -0.01956750f, 0.07833639f, -0.04469856f, 0.13185450f, -0.13363388f, 0.29759675f, -0.01513792f, 
    0.07937729f, -0.11770480f, -0.06304844f, 0.11379531f, -0.15736537f, -0.23607816f, -0.11717124f, -0.36013564f, 
    -0.10568114f, 0.08573171f, -0.28442690f, -0.19008686f, 0.10049561f, -0.06300563f, -0.05415450f, -0.11239997f, 
    -0.01093777f, 0.07456910f, 0.13852267f, 0.08412927f, 0.73213810f, -0.11489929f, 0.08317418f, -0.07054316f, 
    -0.08354881f, -0.21029936f, 0.00653253f, 0.23048781f, 0.05360213f, 0.00643662f, -0.06061774f, -0.02287031f, 
    0.03489303f, 0.04471162f, 0.04261590f, -0.01901085f, -0.27468956f, 0.14605778f, 0.09974699f, 0.15551323f, 
    -0.00325086f, 0.03129722f, 0.02677388f, -0.12061544f, 0.29150993f, -0.28022456f, 0.13515045f, -0.80839604f, 
    0.09562220f, -0.19843592f, -0.05086743f, 0.07967531f, 0.02842410f, 0.05857069f, 0.17608160f, 0.09838061f, 
    -0.22301018f, -0.41430601f, -0.34567311f, 0.03077835f, -0.03541898f, -0.07579450f, 0.05119446f, -0.01139795f, 
    -0.03235142f, -0.04861888f, 0.18531442f, -0.09124585f, -0.10417309f, -0.00176147f, -0.30823335f, -0.06509125f, 
    0.01629384f, -0.10582937f, -0.07141837f, 0.11337984f, 0.09866902f, 0.13190018f, 0.08447451f, 0.07175762f, 
    0.06908727f, -0.18646571f, -0.26931700f, 0.19570370f, -0.19632450f, -0.10397366f, -0.03523883f, -0.13456729f, 
    -0.08866171f, -0.01276997f, -0.19390948f, -0.12654735f, -0.59308445f, -0.11798086f, -0.32853600f, -0.02344971f, 
    0.05868546f, -0.04114533f, -0.02288381f, -0.03135349f, 0.09628164f, 0.10267790f, 0.19090414f, -0.01410241f, 
    -0.00353119f, -0.10644247f, -0.01474146f, -0.17638153f, 0.01874838f, -0.13731453f, -0.00429249f, 0.10266921f, 
    0.10325568f, 0.06153764f, -0.05403858f, 0.19940050f, -0.08802498f, 0.05885292f, 0.07097857f, 0.13093685f, 
    0.03811089f, 0.09787173f, 0.11652272f, -0.12955678f, 0.06019066f, 0.06689857f, -0.11532148f, -0.05600215f, 
    -0.08989684f, -0.46437672f, -0.48868355f, 0.32715425f, -0.12888218f, -0.00842621f, -0.31262761f, -0.46602023f, 
    -0.04115418f, 0.07251596f, 0.14135702f, -0.10084476f, -0.08649488f, -0.14443219f, -0.09407907f, 0.15995146f, 
    -0.08656086f, -0.00060495f, 0.05423950f, 0.00760582f, -0.15417555f, -0.14300634f, 0.03453040f, 0.00781499f, 
    -0.04559942f, -0.12075496f, 0.55880898f, -0.20862594f, 0.09497210f, 0.03479354f, 0.14970905f, -0.06706872f, 
    -0.02280667f, -0.06073923f, 0.24214129f, 0.04822237f, -0.38298905f, 0.02958478f, -0.53363800f, 0.15030453f, 
    0.14264861f, -0.03171271f, 0.16862142f, -0.14274003f, 0.05915863f, 0.01579623f, -0.22371893f, 0.11694489f, 
    -0.09411529f, -0.55791014f, -0.00891997f, -0.12593140f, -0.23653419f, -0.30751616f, -0.12142786f, -0.28853220f, 
    0.02698668f, 0.02281885f, -0.10740022f, 0.01023826f, -0.33063710f, -0.04194083f, -0.18844981f, 0.06552040f, 
    0.23478076f, -0.12747607f, 0.13012294f, -0.16105126f, 0.16833785f, 0.18181895f, 0.10265444f, 0.03609427f, 
    0.02758603f, -0.10741989f, -0.14560235f, -0.27732852f, 0.04994664f, 0.11266207f, 0.13436271f, -0.17498550f, 
    0.05299802f, 0.13830625f, 0.05469703f, -0.18713889f, 0.30578384f, -0.10951766f, -0.19208233f, 0.33865309f, 
    -0.00295099f, 0.03486394f, 0.16249178f, -0.06921769f, 0.16754074f, -0.16874307f, 0.18875499f, -0.04061111f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19700682f, 0.22337919f, 0.09026486f, -0.08863913f, -0.11240638f, 0.05213520f, 0.05111627f, -0.15957093f, 
    0.11389200f, 0.02791005f, 0.00989624f, -0.08095226f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
