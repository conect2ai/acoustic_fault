#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.44864932f, -0.16746376f, 0.09333937f, 0.00519816f, 0.40996921f, 0.11912865f, -0.18325241f, 0.45428869f, 
    -0.00058965f, 0.29382193f, -0.23242840f, -0.11670571f, 0.40788972f, 0.05635222f, -0.12217636f, 0.12854534f, 
    0.09357964f, -0.48428595f, -0.06995198f, -0.01303295f, -0.09107166f, -0.41522285f, -0.03546119f, 0.06562199f, 
    0.06725024f, -0.01168352f, -0.24683541f, 0.15499754f, 0.47941437f, -0.27760565f, -0.06630474f, 0.15972614f, 
    -0.53049481f, -0.45903558f, -0.60071468f, 0.28314117f, 0.23175856f, -0.03324356f, -0.02961425f, -0.22965191f, 
    0.14741917f, -0.09735114f, 0.17893240f, -0.12243931f, 0.00413980f, -0.28575119f, -0.00552118f, -0.22973160f, 
    -0.00252454f, -0.28426293f, -0.33594802f, -0.38863316f, -0.28738469f, 0.07400445f, 0.32019261f, -0.54404598f, 
    -0.41467449f, -0.55896115f, -0.21479115f, -0.29272726f, 0.41113985f, 0.63412678f, 0.13924403f, -0.12902947f, 
    0.31936923f, -0.34842831f, 0.29803351f, -0.23249701f, -0.08742582f, -0.30693257f, 0.12147363f, -0.27330628f, 
    0.03769095f, -0.07104505f, 0.05947628f, 0.12885639f, -0.31124687f, 0.38130075f, 0.41794670f, -0.41389176f, 
    -0.19930369f, -0.45082924f, -0.44633141f, -0.20061436f, -0.15131508f, 0.34482118f, -0.48678559f, -0.21545990f, 
    -0.06056131f, -0.13150340f, -0.05085218f, 0.21194689f, 0.32380202f, 0.06563579f, -0.15189616f, 0.08627773f, 
    0.02194489f, -0.25364909f, 0.17483932f, 0.26128456f, -0.28905588f, 0.54874974f, 0.48868009f, -0.05079053f, 
    -0.25324106f, -0.03708695f, -0.04438445f, 0.01570390f, 0.35021454f, -0.39158341f, -0.41637912f, -0.10645760f, 
    0.32403851f, 0.05234113f, 0.15917796f, 0.10869423f, -0.04254961f, -0.06588462f, -0.13256447f, 0.00890116f, 
    -0.26689890f, -0.31782088f, 0.02618906f, 0.27428275f, 0.06200710f, 0.12265401f, -0.33181122f, -0.14676002f, 
    0.03355014f, 0.38641274f, 0.00801064f, -0.09473654f, 0.18216451f, -0.08530219f, 0.09478725f, -0.12916952f, 
    -0.17724606f, 0.27315405f, -0.11052658f, -0.00737917f, -0.01415037f, -0.37485382f, 0.20963891f, -0.09670571f, 
    -0.33776835f, 0.03876876f, 0.31046131f, 0.14287359f, 0.06217717f, 0.13290229f, -0.51413608f, -0.26162937f, 
    0.05388119f, -0.22014333f, -0.21600714f, 0.10409294f, 0.37197301f, 0.06604907f, 0.42506048f, 0.16625358f, 
    -0.09486298f, -0.05668531f, 0.03505866f, 0.13581696f, 0.24243699f, -0.24244289f, 0.29449537f, -0.26621321f, 
    -0.23977797f, 0.11794712f, -0.07629584f, -0.27884459f, 0.40408760f, -0.20226955f, 0.17794777f, -0.95609677f, 
    0.43128079f, 0.26583040f, 0.06037821f, 0.28994915f, 0.01302950f, -0.62622768f, -0.52477622f, 0.15968405f, 
    0.06821688f, 0.23016106f, 0.26404211f, -0.09034321f, -0.15152055f, 0.11705508f, 0.00676794f, -0.13094701f, 
    0.15880813f, -0.20398600f, -0.13410617f, -0.13078086f, -0.21024841f, -0.00958142f, -0.24441336f, -0.42589679f, 
    -0.59082252f, 0.56245857f, 0.03480639f, 0.04694834f, 0.30553555f, -0.65785128f, -0.35297847f, 0.38653472f, 
    0.04657590f, -0.01913600f, 0.31543231f, -0.04627192f, 0.33058095f, -0.17927980f, -0.08925147f, 0.08481883f, 
    -0.23565312f, 0.08505551f, -0.19573617f, -0.50819665f, -0.08067217f, 0.03259343f, 0.00015596f, 0.24193111f, 
    0.17134629f, 0.59132874f, 0.58992290f, 0.48133337f, 0.09458167f, 0.06445134f, -0.73255074f, -0.43942946f, 
    -0.14845634f, -0.02695145f, -0.11939987f, 0.21466599f, 0.13719121f, 0.16162229f, 0.03666721f, -0.20985486f, 
    -0.07854293f, -0.04650116f, -0.23354268f, 0.27958128f, -0.08650242f, -0.01751888f, 0.06929032f, 0.02985542f, 
    0.08890401f, 0.26350227f, -0.41069642f, 0.91422486f, 0.37914082f, -0.31765535f, 0.29753694f, -0.59902126f, 
    -0.28966877f, -0.00985537f, 0.54583603f, -0.40745306f, -0.32706183f, -0.07010971f, -0.16028479f, -0.14070322f, 
    0.11724707f, 0.13592978f, 0.16853362f, 0.05288358f, -0.04148904f, 0.23192273f, -0.04596423f, 0.16053386f, 
    -0.09914654f, 0.05607167f, -0.14754495f, 0.05307532f, -0.04848458f, -0.42319888f, -0.28252274f, -0.07845824f, 
    -0.46423382f, -0.42923751f, -0.43857732f, -0.45223385f, -0.44826901f, 0.04768832f, -0.22713666f, 0.09569323f, 
    0.39886665f, 0.15134950f, 0.08079001f, -0.04366364f, 0.08171238f, 0.08347082f, -0.10333072f, -0.11160250f, 
    0.28161362f, 0.31407753f, 0.04231431f, 0.12543318f, 0.32943875f, -0.15029313f, 0.17924254f, -0.08651057f, 
    -0.36587182f, 0.01989982f, 0.09395202f, -0.15571260f, -0.02249884f, 0.25871983f, 0.03737871f, -0.14023399f, 
    -0.01852563f, -0.05322894f, 0.00564362f, -0.46012679f, 0.16580674f, -0.15156920f, 0.26699182f, -0.32785472f, 
    0.14994989f, 0.25691390f, 0.32709318f, 0.41109589f, -0.00798861f, 0.68342739f, -0.03081620f, 0.17202917f, 
    0.11995487f, 0.17468536f, 0.10849077f, 0.17985994f, -0.20667914f, -0.41614309f, -0.32772654f, 0.23042360f, 
    0.16115016f, -0.16381328f, -0.28615490f, -0.13086498f, 0.11261312f, 0.10321936f, 0.20493984f, 0.21604495f, 
    -0.20416337f, -0.36492038f, -0.15367667f, 0.11148720f, 0.15385503f, 0.09711115f, 0.24381852f, -0.44216937f, 
    -0.35197014f, -0.41463244f, -0.12581895f, 0.10294176f, 0.11117399f, -0.20673200f, -0.41455734f, -0.06899212f, 
    0.11127879f, 0.08931107f, 0.33521771f, -0.11483072f, 0.23872519f, -0.05907110f, -0.18478267f, 0.16037904f, 
    -0.14630543f, 0.11946370f, 0.02276530f, -0.47565749f, 0.18649644f, 0.38244417f, -0.21354897f, 0.55574363f, 
    0.40462419f, -0.22655304f, -0.65865576f, -0.44230387f, -0.21037398f, -0.03216850f, 0.26195297f, 0.22469665f, 
    -0.15634273f, -0.02125895f, -0.12384845f, 0.31460473f, 0.02711656f, -0.22344628f, -0.16175991f, 0.08905672f, 
    -0.20566359f, -0.10258006f, 0.28621891f, 0.07336585f, 0.03864772f, -0.33130720f, 0.27148673f, 0.27651760f, 
    -0.69809669f, -0.72288746f, -0.09621266f, 0.39379066f, 0.47784090f, 0.26286101f, 0.23023964f, 0.03917204f, 
    0.32218939f, 0.25690618f, 0.34386006f, -0.19734079f, 0.15685599f, -0.16536058f, -0.16548389f, -0.18282896f, 
    -0.15658231f, 0.01541953f, 0.12002075f, 0.21038273f, -0.10029949f, -0.09682576f, -0.06713440f, 0.04740755f, 
    -0.03423454f, 0.32079670f, 0.41414186f, 0.00988594f, 0.12462772f, -0.31839004f, -0.04640204f, -0.30773166f, 
    -0.20624030f, 0.44550538f, 0.03589238f, 0.10687570f, -0.25668260f, -0.21999526f, 0.39743972f, -0.06924577f, 
    0.05165083f, -0.00089265f, -0.00805974f, -0.24012062f, 0.20277581f, 0.10558011f, 0.07524519f, -0.20247877f, 
    -0.02590416f, 0.00159145f, 0.57375687f, 0.14070608f, -0.07439168f, -0.00942989f, -0.07738373f, -0.38149047f, 
    0.34551680f, -0.18036534f, -0.11707211f, 0.72431153f, 0.00198648f, 0.06810555f, -0.14456420f, -0.23606272f, 
    -0.27308840f, -0.07625206f, -0.36132833f, 0.11475387f, 0.13220298f, 0.12959704f, -0.17681026f, 0.04782783f, 
    0.13321428f, -0.21540743f, 0.21373376f, 0.37853670f, 0.06094566f, 0.16504155f, -0.10789349f, 0.23470607f, 
    -0.28256625f, 0.03867028f, 0.17035162f, 0.03400267f, 0.04822667f, 0.00866123f, -0.20194501f, -0.13377920f, 
    -0.30113789f, -0.08727845f, 0.13412076f, 0.19611263f, 0.21595837f, -0.01162007f, 0.05187750f, -0.18538339f, 
    -0.02652993f, -0.13386261f, -0.35774240f, -0.17531784f, 0.27137545f, 0.61494708f, -0.08374748f, -0.39789483f, 
    -0.72549570f, 0.25074530f, -0.33847734f, -0.37748504f, -0.14150822f, -0.14192967f, 0.01455526f, 0.30010477f, 
    0.17564508f, 0.39878613f, 0.11815087f, -0.38945931f, -0.10692172f, 0.03493912f, -0.09153746f, -0.18274660f, 
    0.28183174f, 0.07907339f, -0.21269651f, 0.41053069f, 0.07166120f, -0.40711099f, -0.62581486f, 0.19852436f, 
    0.52991265f, 0.47289157f, -0.31973866f, 0.11789879f, -0.30777293f, -0.46465826f, -0.28921267f, 0.00149902f, 
    -0.21141578f, 0.13824250f, -0.15483958f, -0.12344520f, 0.00717375f, 0.14895378f, -0.03337587f, 0.17295942f, 
    -0.12447146f, 0.05334425f, 0.09337013f, -0.06573741f, -0.14494598f, 0.27750662f, -0.00304859f, 0.55484092f, 
    -0.27909651f, 0.15456669f, -0.07499418f, 0.12060769f, -0.08567899f, -0.16963047f, 0.24481738f, -0.25361559f, 
    0.01585861f, 0.04362987f, -0.12426592f, 0.07380576f, -0.19828962f, 0.21605530f, 0.02334703f, -0.19382401f, 
    -0.14143631f, -0.01388106f, -0.24675219f, 0.29685301f, -0.14255635f, -0.21385260f, -0.34386876f, -0.53248060f, 
    0.13292478f, 0.18681228f, -0.33901551f, 0.06888420f, -0.16339524f, -0.43237630f, -0.47452271f, -0.12702698f, 
    0.31914845f, -0.11088519f, -0.19156364f, -0.40342852f, -0.37890810f, 0.18216565f, 0.09259579f, 0.01591943f, 
    0.15399091f, 0.19891255f, -0.02098303f, 0.10016438f, -0.01153886f, -0.42335734f, -0.26858282f, -0.15723610f, 
    0.65521657f, 0.18418536f, -0.06606361f, -0.04707665f, -0.17341745f, 0.23865330f, -0.00612108f, 0.05964947f, 
    0.21463773f, 0.16476767f, 0.17488702f, 0.17896408f, -0.19684500f, -0.45132053f, -0.11276691f, 0.17797875f, 
    -0.18433152f, 0.05343206f, -0.04960297f, -0.07237311f, -0.02719170f, 0.29056835f, 0.14237349f, -0.20520662f, 
    -0.30076924f, -0.31746635f, -0.08609959f, -0.09234884f, 0.04660572f, 0.31491551f, 0.26038733f, 0.16498332f, 
    0.43430847f, -0.28658402f, -0.02424593f, 0.25359678f, -0.30634922f, 0.17151091f, 0.03127325f, -0.10367965f, 
    -0.24985859f, 0.19420828f, -0.08955207f, -0.13953914f, 0.10181621f, 0.02208333f, 0.10622857f, -0.12148184f, 
    -0.00851987f, 0.39111608f, -0.07395191f, -0.32070166f, -0.58492970f, -0.34137404f, -0.61317438f, 0.08304887f, 
    -0.16480929f, -0.08867861f, 0.30431926f, 0.04662152f, 0.23960300f, 0.10023741f, 0.24394876f, 0.46468145f, 
    -0.04702491f, -0.40641218f, 0.03725870f, 0.16602701f, -0.02335766f, -0.18403596f, -0.38407135f, -0.30480573f, 
    -0.12336269f, -0.11474349f, -0.35902813f, -0.74362195f, 0.37193134f, 0.35665637f, -0.32438585f, -0.50055546f, 
    -0.40544021f, 0.16841879f, 0.16443221f, 0.07311856f, 0.08672781f, 0.12893240f, 0.11335617f, -0.01547673f, 
    -0.29088196f, -0.15135087f, 0.07723124f, -0.47144026f, -0.04137601f, -0.20440596f, -0.30202174f, -0.03872339f, 
    0.38784379f, 0.13710426f, 0.09916978f, 0.26753345f, 0.19221051f, 0.36149025f, 0.23169500f, 0.36018419f, 
    0.12676416f, 0.21544690f, 0.17173705f, -0.13407266f, -0.14659260f, 0.13803740f, 0.24001782f, -0.28848121f, 
    0.00553211f, -0.00369669f, 0.14375268f, 0.19996250f, 0.13538627f, -0.16478842f, -0.11141516f, -0.39977524f, 
    -0.19301647f, -0.22533287f, -0.36761814f, -0.23958780f, -0.28027081f, -0.65572041f, 0.08672630f, 0.00876653f, 
    -0.28479263f, -0.05839872f, -0.10842967f, 0.05170037f, -0.13089277f, -0.18309546f, 0.01252843f, -0.17771830f, 
    -0.32292977f, -0.25859961f, -0.46111277f, -0.27742547f, 0.31803370f, -0.23677526f, -0.08141071f, -0.10149402f, 
    0.04906503f, -0.10792850f, -0.21065681f, -0.11401881f, 0.09926097f, -0.20866112f, -0.70828044f, 0.27291945f, 
    0.44384411f, -0.50507843f, -0.03108788f, -0.07483508f, 0.47677612f, -0.27197883f, 0.26040173f, -0.35229218f, 
    0.04940673f, -0.01202089f, -0.13080043f, -0.22952674f, -0.18931560f, -0.08499723f, -0.27455491f, -0.13052934f, 
    0.33300701f, -0.16578710f, 0.08856505f, 0.07970217f, 0.27224383f, -0.35067672f, 0.14259385f, 0.02629547f, 
    -0.35802531f, 0.20304310f, 0.11167144f, 0.43732291f, -0.00779972f, 0.16520368f, 0.10286760f, 0.21621180f, 
    0.10151061f, 0.21034434f, 0.14295679f, -0.15725298f, -0.31834093f, 0.31797475f, 0.07612433f, 0.08601841f, 
    -0.13248983f, -0.12034608f, -0.11566309f, 0.17589636f, 0.14376903f, 0.00491761f, 0.21638976f, -0.24877977f, 
    0.17777811f, -0.16608891f, 0.20271863f, 0.30032694f, -0.43212065f, 0.01441426f, -0.05241946f, -0.19200179f, 
    0.33582240f, -0.35383958f, 0.34442189f, -0.20234548f, -0.03009184f, 0.26435915f, -0.17249674f, 0.10828608f, 
    0.15005192f, 0.14266236f, -0.23050933f, 0.08820945f, -0.02060291f, 0.10306722f, -0.09369092f, 0.15130019f, 
    -0.15855046f, -0.34834573f, -0.53772622f, -0.21421075f, 0.10432871f, 0.42102054f, -0.12060178f, -0.09651354f, 
    0.13553235f, 0.42069271f, -0.14020361f, -0.29715315f, -0.52261275f, -0.06940708f, 0.11591474f, 0.18681404f, 
    0.25227377f, 0.05281188f, -0.16337430f, -0.20802931f, 0.21044712f, -0.18484040f, -0.40530366f, 0.12160227f, 
    -0.22765307f, -0.34901023f, 0.57512313f, -0.25664428f, -0.10093114f, -0.03751765f, -0.26886177f, 0.71618152f, 
    0.23611651f, -0.21720619f, -0.05931049f, 0.29787460f, -0.02222060f, 0.67741549f, -0.29706326f, -0.25869530f, 
    -0.04126068f, -0.22881855f, -0.18520188f, 0.03736973f, -0.22365671f, -0.00424071f, -0.04435354f, -0.03086649f, 
    0.10216670f, 0.17194758f, 0.22583787f, -0.07210416f, -0.01412839f, -0.33025661f, -0.08785336f, -0.12027442f, 
    -0.09045739f, -0.29225159f, 0.01488897f, -0.13762692f, -0.14665745f, -0.20246170f, -0.30879912f, 0.25961292f, 
    -0.17070599f, 0.17970681f, 0.03071313f, -0.08637305f, -0.16098848f, -0.12636103f, -0.30075541f, -0.05593771f, 
    -0.04722099f, -0.33369616f, -0.32027185f, -0.31666303f, -0.43664426f, -0.28728372f, 0.07134896f, -0.24516997f, 
    0.13921587f, -0.05293010f, -0.42780471f, -0.07338431f, -0.22822417f, -0.56862891f, 0.22920558f, 0.50145227f, 
    -0.15640572f, -0.25914001f, 0.22737251f, -0.24261777f, -0.18756212f, 0.07382267f, 0.22942276f, -0.27584308f, 
    -0.08144898f, 0.38256392f, 0.07051439f, -0.16546029f, 0.40034580f, 0.06409512f, -0.03005921f, -0.40008506f, 
    -0.19272523f, -0.20598604f, -0.01954855f, -0.13109002f, -0.63617444f, -0.40938565f, -0.01080740f, 0.23538032f, 
    -0.08222848f, 0.08847848f, -0.11397240f, -0.07238189f, -0.13414273f, 0.37438694f, 0.16750705f, -0.26657042f, 
    -0.17347784f, -0.13909264f, -0.12612282f, -0.21123612f, 0.25614500f, -0.36597499f, 0.95236468f, -0.87047201f, 
    -0.03997923f, 0.43406048f, 0.30579430f, 0.14300272f, -0.09500895f, -0.42176089f, -0.30031940f, 0.02497491f, 
    -0.13566729f, 0.27815750f, -0.21284971f, -0.48944458f, 0.39383492f, 0.10118658f, 0.29279745f, -0.12206504f, 
    0.19599499f, 0.11503828f, 0.01199446f, -0.25413954f, -0.17906378f, -0.10261717f, -0.35576767f, -0.00199231f, 
    0.09774090f, 0.26059183f, 0.24277064f, -0.10173780f, 0.11930969f, 0.02383692f, 0.26460382f, -0.39251888f, 
    -0.17619778f, 0.06323330f, 0.17609586f, 0.24350084f, -0.39296177f, 0.16869067f, -0.33137226f, -0.24360679f, 
    0.12194765f, -0.02007014f, 0.32142323f, 0.08320718f, 0.26838374f, -0.14344919f, -0.05119518f, -0.27503407f, 
    0.33485264f, 0.09141546f, 0.16751990f, 0.36216649f, -0.00349369f, 0.17843179f, -0.30202535f, -0.50921613f, 
    0.24164747f, 0.01489303f, -0.40024161f, -0.16579112f, 0.15744859f, 0.02313831f, -0.17942417f, -0.23536226f, 
    0.22457896f, -0.01055668f, -0.25381884f, 0.06679212f, 0.09759783f, 0.01505095f, 0.08586270f, 0.10375766f, 
    0.06474193f, -0.36163837f, -0.23271516f, 0.20412439f, 0.46127126f, 0.11130261f, 0.70674562f, 0.64481497f, 
    -0.41475523f, -0.56926769f, -0.10688930f, 0.15017854f, -0.09069546f, 0.02024389f, -0.09458744f, -0.18410407f, 
    -0.44387710f, 0.07741002f, -0.00196116f, 0.13154663f, -0.13323496f, 0.27206060f, -0.16503665f, -0.33139935f, 
    0.08545446f, 0.04205818f, -0.59701204f, -0.50847083f, -0.35231197f, -0.49930328f, -0.61936271f, 0.79524261f, 
    0.02825313f, -0.12397634f, 0.09233573f, 0.27519923f, -0.32360211f, -0.37560281f, -0.34077427f, -0.23018432f, 
    -0.28783819f, 0.33875239f, 0.04209411f, 0.00969490f, 0.11086182f, 0.09786130f, -0.13626190f, -0.20315789f, 
    -0.18454130f, -0.21212323f, -0.32320014f, 0.20554243f, -0.64075696f, -1.07548106f, -0.51748312f, -0.17057507f, 
    0.54760367f, 0.60908037f, -0.00654121f, -0.16300371f, 0.14795369f, 0.18231259f, 0.38674295f, 0.17080817f, 
    -0.14326102f, 0.27005067f, 0.06425538f, -0.21607386f, 0.29212907f, -0.19279730f, -0.16488495f, -0.09566895f, 
    -0.22148827f, -0.29090375f, 0.30281410f, 0.22807218f, -0.28172570f, -0.29512858f, 0.19518737f, 0.10276360f, 
    -0.09425485f, 0.03565385f, 0.23017579f, 0.24495533f, -0.15144032f, 0.12147288f, 0.06275301f, -0.07461450f, 
    0.15913208f, -0.25414920f, 0.07763007f, 0.00453259f, -0.26017591f, -0.29072735f, -0.10215592f, 0.30372825f, 
    0.27585545f, 0.16937965f, -0.12125029f, -0.28367695f, 0.39895165f, -0.62939370f, -0.05984015f, 0.04552018f, 
    0.77221698f, 0.00962577f, 0.02375717f, -0.19534880f, -0.34578419f, -0.27361616f, 0.18635865f, -0.54332381f, 
    0.48432279f, 0.17071621f, -0.00838260f, -0.07460716f, -0.06994537f, 0.35858822f, 0.13676050f, 0.22207004f, 
    0.19968474f, 0.11499487f, -0.26506329f, 0.11618327f, -0.12695083f, -0.14869019f, 0.50272942f, 0.29634720f, 
    0.09006099f, -0.22111163f, -0.33344921f, -0.31116730f, -0.14601071f, -0.31826779f, 0.06055630f, 0.52430767f, 
    0.42221263f, -0.24457961f, -0.27621317f, -0.08668010f, 0.19544742f, -0.00802910f, -0.29900372f, 0.02004358f, 
    0.57757735f, -0.34544787f, 0.04412493f, -0.19727954f, 0.05265899f, 0.18147866f, -0.18187714f, 0.35858184f, 
    0.25150090f, 0.23092793f, -0.53807884f, -0.62773377f, 0.07307651f, -0.10543358f, -0.15863764f, 0.13246706f, 
    0.51048893f, -0.11172741f, 0.23146158f, 0.10354348f, -0.18587284f, 0.08424745f, -0.14100561f, -0.01367387f, 
    -0.06021645f, 0.21820690f, -0.32273525f, 0.20299625f, -0.12295623f, 0.00758380f, -0.05321425f, -0.27749801f, 
    -0.54478467f, -0.08968465f, 0.22319147f, 0.32938874f, 0.31489721f, -0.16390441f, 0.00447783f, 0.23354709f, 
    0.04927474f, 0.39600742f, -0.00018414f, 0.10521915f, 0.22360368f, 0.29671356f, -0.22922044f, -0.27233011f, 
    -0.19009055f, -0.12877461f, 0.17941967f, -0.01385835f, -0.17090741f, -0.14735843f, -0.08378989f, 0.34507871f, 
    0.34325582f, -0.85266173f, 0.67514104f, -0.21350126f, -0.51207942f, -0.00498940f, -0.09739555f, 0.40183976f, 
    0.47674447f, 0.17754574f, -0.15037586f, -0.34301907f, 0.28179768f, -0.06281863f, 0.09406868f, -0.18882899f, 
    0.12584618f, -0.20188136f, -0.11928388f, 0.15956165f, 0.09656978f, 0.08730338f, 0.23878954f, -0.29123348f, 
    -0.26660734f, 0.05465498f, -0.79568845f, -0.19187838f, 0.26457924f, 0.47779155f, -0.19171557f, -0.17613687f, 
    -0.70677412f, -0.15482464f, 0.63540578f, 0.19249082f, 0.46652639f, 0.01132566f, -0.06532876f, 0.34018174f, 
    -0.00991325f, 0.20137222f, 0.07886665f, 0.01095274f, -0.35358602f, -0.38907081f, 0.15544537f, 0.07117920f, 
    0.33843550f, -0.11827046f, -0.01014712f, -0.27254352f, -0.14501442f, 0.02912051f, 0.34318230f, 0.29235792f, 
    -0.48780638f, -0.60260773f, -0.57777506f, 0.28371078f, 0.11593404f, 0.15659633f, -0.22557911f, -0.02455308f, 
    0.71326470f, -0.35147604f, -0.27251643f, -0.24002501f, 0.17003217f, 0.14794548f, -0.49436116f, 0.06331940f, 
    -0.26063392f, -0.36225948f, 0.23777473f, -0.09195679f, 0.09763458f, -0.17174608f, -0.06455398f, 0.23896335f, 
    0.00544638f, 0.45724878f, -0.35152784f, -0.12643933f, 0.06371059f, 0.22080255f, 0.10574125f, 0.02646428f, 
    -0.06572750f, -0.09032768f, -0.19842705f, 0.13039324f, 0.20976283f, 0.02144030f, 0.01838248f, -0.36372685f, 
    0.18138699f, -0.11831127f, 0.14284618f, -0.10042845f, 0.07583097f, -0.74703711f, -0.74313515f, -0.20331329f, 
    0.65500593f, 0.76655650f, 0.09122791f, 0.22319409f, -0.22121644f, -0.04917698f, 0.38338518f, -0.02913047f, 
    0.08678674f, -0.39868402f, -0.08145159f, 0.09647322f, 0.20364982f, -0.13595493f, 0.05770225f, 0.28582972f, 
    -0.16554256f, 0.24556588f, -0.03011296f, 0.12518005f, -0.04032183f, -0.09086946f, -0.64453030f, -0.26780406f, 
    0.38784042f, -0.35235813f, -0.11910012f, 0.34053847f, -0.71120554f, -0.73558491f, -0.06722045f, -0.24652462f, 
    -0.14761016f, -0.11621132f, -0.21288399f, -0.42709634f, -0.36948287f, 0.01614000f, -0.38062850f, -0.24338919f, 
    -0.06065964f, 0.16285253f, -0.12867875f, 0.04317168f, 0.19929036f, -0.22122782f, 0.16670288f, -0.80502915f, 
    -0.69323319f, -0.62507039f, -0.36534393f, -0.27877784f, 0.70155221f, 0.30647591f, 0.01203212f, 0.01840921f, 
    0.68932879f, 0.06240900f, -0.28167921f, -0.13175690f, 0.31430280f, 0.48057279f, -0.26537251f, -0.03321780f, 
    -0.15849832f, -0.21941903f, -0.33800223f, 0.09987034f, 0.22168422f, -0.00717727f, 0.25441441f, 0.05860363f, 
    0.35792512f, 0.46922967f, 0.26552564f, 0.35596108f, -0.31218439f, -0.37796810f, -0.38641736f, -0.23852676f, 
    0.09866642f, -0.04409049f, 0.28484762f, -0.18389434f, 0.06246512f, 0.07650074f, 0.19856040f, 0.26533645f, 
    0.10884716f, 0.00086231f, 0.00385525f, -0.27823201f, -0.11395833f, 0.08842859f, 0.11358395f, 0.15030766f, 
    0.09568679f, 0.36194882f, 0.30719441f, 0.77749312f, -0.64888132f, -0.25185663f, -0.25315347f, -0.24811283f, 
    -0.03841623f, 0.11495746f, -0.22831003f, -0.04364390f, -0.17583145f, -0.15935518f, 0.25862435f, 0.20327304f, 
    0.23500174f, -0.08439802f, -0.11025990f, 0.16544120f, 0.23018412f, 0.04464858f, 0.26908925f, -0.31707901f, 
    -0.42504546f, -0.33350757f, -0.37374210f, -0.18079592f, 0.01239917f, -0.36078078f, -0.12545440f, 0.07270633f, 
    -0.37034121f, -0.12011285f, -0.26296091f, 0.10116618f, -0.13133331f, 0.03141167f, -0.03464396f, 0.08324949f, 
    -0.15113416f, -0.00481059f, -0.13372961f, 0.08082383f, 0.20280959f, -0.15912302f, 0.16102940f, 0.29698765f, 
    0.16705593f, -0.06055034f, 0.30813083f, 0.20743330f, 0.27431682f, 0.32719037f, 0.36385250f, -0.44170290f, 
    0.00558538f, -0.11005133f, -0.11004110f, -0.10815340f, -0.19823448f, 0.00534624f, -0.07154831f, -0.10195886f, 
    0.11926591f, -0.19690870f, 0.13350888f, 0.23755942f, 0.08217331f, -0.22586857f, 0.08760306f, -0.06234463f, 
    -0.22520241f, -0.08372117f, -0.06112256f, -0.26964968f, 0.41222763f, 0.18979266f, 0.08644699f, -0.24286218f, 
    0.12029991f, -0.10843585f, 0.30472353f, 0.15386666f, -0.27581584f, -0.09032275f, 0.14682233f, 0.25058964f, 
    -0.38178122f, -0.47530845f, 0.52067804f, -0.26798415f, 0.05379716f, 0.02509371f, -0.28885975f, 0.17923269f, 
    0.03481128f, -0.05569004f, -0.07553287f, -0.05253325f, -0.18391247f, -0.11396033f, 0.43446216f, -0.20962860f, 
    0.49869868f, -0.21844955f, -0.62203044f, -0.53032869f, -0.22734231f, 0.52329528f, 0.35993659f, -0.09497594f, 
    -0.00619332f, -0.36407605f, 0.03142998f, 0.01505222f, -0.12276371f, 0.31435844f, -0.08886956f, -0.16021736f, 
    0.09542454f, -0.16456814f, -0.12022559f, -0.18262848f, -0.19222896f, -0.06939822f, -0.12135851f, -0.21611263f, 
    0.22237672f, -0.06558292f, -0.29367656f, -0.29254550f, -0.47499385f, -0.48047343f, -0.32550749f, -0.04520020f, 
    0.03062479f, 0.03987879f, 0.05964674f, -0.22554757f, -0.00899473f, 0.04296747f, -0.17533654f, -0.25317425f, 
    -0.22769418f, -0.33254719f, -0.05799408f, -0.33390355f, -0.10921732f, 0.17974740f, 0.13773896f, -0.66570359f, 
    0.19100256f, -0.13964793f, 0.24545726f, 0.47152248f, 0.19980198f, -0.33205599f, 0.30002898f, 0.26383269f, 
    -0.02108403f, 0.17113484f, -0.00674303f, -0.07891461f, 0.00786751f, -0.07938199f, 0.02242436f, -0.29514495f, 
    0.17067893f, -0.45714241f, 0.14201374f, 0.05548163f, -0.21625896f, -0.09727601f, 0.28385368f, -0.04019194f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01139248f, 0.04376206f, 0.13184930f, 0.21162273f, 0.01810907f, 0.19412330f, 0.07067902f, -0.24199486f, 
    -0.01910151f, -0.00524601f, 0.07615186f, -0.15500291f, -0.04050232f, 0.03625401f, 0.09151664f, 0.31801304f, 
    0.05005400f, 0.09191154f, 0.01946770f, -0.18167327f, 0.05381615f, 0.06770474f, 0.14365414f, -0.14295343f, 
    0.26904559f, 0.11801344f, -0.17442879f, -0.09935538f, 0.03272642f, -0.15997106f, 0.12372973f, -0.17658512f, 
    0.15502022f, -0.05001925f, 0.07858151f, -0.21905217f, 0.10511784f, 0.03380224f, -0.03893266f, -0.06344475f, 
    0.06797489f, 0.02608125f, -0.14526941f, 0.13175768f, 0.21063729f, -0.12662931f, 0.21757041f, 0.13084804f, 
    -0.22593491f, 0.26816800f, 0.17758220f, 0.02774149f, 0.18425092f, 0.15796582f, -0.04576597f, 0.14969636f, 
    0.12514487f, 0.06357489f, 0.10656914f, 0.01366471f, 0.21997808f, 0.23455432f, -0.18218923f, 0.12026086f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05865749f, -0.04712649f, 0.06804799f, -0.03926233f, -0.05284674f, -0.02676214f, 0.02831497f, 0.07755224f, 
    -0.07328778f, -0.05836988f, -0.04145776f, -0.12089322f, 0.01098434f, 0.02702474f, 0.01649272f, -0.05447532f, 
    0.16538922f, -0.02711871f, 0.08966911f, 0.09409098f, -0.11035083f, 0.02619189f, 0.01498574f, 0.05911553f, 
    0.02779121f, 0.16897675f, -0.08956778f, -0.04712080f, -0.04654552f, 0.05611640f, 0.07620559f, -0.05858466f, 
    0.03237501f, 0.12843165f, 0.04555840f, 0.03031557f, 0.11156180f, -0.00378184f, -0.00246831f, -0.05516418f, 
    0.22491083f, 0.17023288f, 0.05376622f, 0.07526044f, -0.01429235f, 0.05797109f, 0.06501888f, -0.00247670f, 
    0.09917650f, 0.02789440f, 0.05308831f, 0.21951099f, -0.09533038f, -0.03993376f, -0.07766210f, -0.00003816f, 
    0.04334237f, -0.08750607f, 0.03809129f, 0.06153016f, 0.02556710f, 0.09516984f, 0.13423537f, 0.16394182f, 
    -0.02297266f, 0.12373923f, 0.03027117f, -0.07100344f, -0.04462034f, 0.00600918f, 0.00593834f, 0.11871465f, 
    -0.09186139f, -0.08760503f, -0.07152835f, -0.02851439f, 0.00433392f, 0.04805984f, -0.00456931f, 0.06030187f, 
    0.02046333f, 0.11403618f, -0.11802471f, -0.08466555f, -0.06382614f, 0.20432712f, 0.06313238f, -0.04232084f, 
    -0.00354840f, -0.04198086f, 0.14685293f, 0.11143694f, -0.05304256f, -0.09116516f, -0.26222444f, -0.11089204f, 
    -0.09371871f, -0.05571735f, 0.19842798f, 0.12372909f, 0.01191670f, 0.05403246f, 0.00897496f, -0.14066719f, 
    -0.01619034f, -0.01397324f, 0.07249971f, 0.25440821f, 0.07603272f, 0.24744622f, 0.01968616f, 0.19948551f, 
    0.03787158f, -0.21219622f, -0.17490904f, -0.13741252f, 0.03169178f, 0.02326768f, -0.06360968f, 0.03525238f, 
    -0.08700450f, 0.11993672f, 0.14736807f, 0.21720622f, -0.08942996f, 0.06695841f, -0.07956441f, 0.05424314f, 
    -0.09512044f, 0.05188523f, 0.00350511f, -0.00315511f, -0.02690788f, -0.09558732f, -0.16629566f, -0.15277104f, 
    0.25603011f, 0.14116013f, 0.16338640f, 0.11294047f, -0.04176426f, 0.01462968f, 0.00846416f, 0.05193844f, 
    0.07723401f, -0.00175616f, 0.09261732f, 0.13031337f, 0.06377083f, 0.14282499f, -0.11509748f, -0.04095642f, 
    -0.03356530f, -0.05553051f, 0.00537746f, 0.02645229f, 0.04129962f, 0.17064129f, 0.09496064f, 0.23848745f, 
    0.06333327f, -0.00432069f, -0.03954144f, -0.03980401f, 0.08907145f, 0.04147488f, 0.03173855f, 0.00798096f, 
    -0.13297059f, -0.13657911f, -0.33620870f, 0.02912911f, 0.18482435f, 0.15786867f, -0.02085238f, -0.06957933f, 
    0.13871056f, 0.03107000f, 0.06096414f, 0.02920149f, 0.00207372f, -0.18890157f, -0.04832356f, 0.24786806f, 
    -0.01278911f, 0.08243386f, -0.12370003f, 0.06104582f, 0.15762132f, -0.12226527f, 0.00829255f, 0.17741390f, 
    0.22947712f, 0.01274368f, -0.03913256f, -0.11155691f, -0.01159989f, -0.08639956f, -0.05516453f, -0.04447938f, 
    -0.05976715f, -0.02153211f, -0.00205442f, -0.05233181f, 0.12863363f, 0.11324104f, 0.08758831f, 0.09296366f, 
    0.04810437f, 0.01303177f, 0.00333941f, 0.01052454f, -0.01341152f, 0.07371713f, 0.01228816f, 0.06228717f, 
    0.13833477f, 0.30000365f, -0.12093827f, 0.14888443f, 0.05906219f, -0.07367928f, 0.00461001f, -0.02832687f, 
    0.05867008f, 0.02337717f, 0.00698331f, 0.08916503f, 0.01231899f, 0.08880316f, 0.02246827f, 0.13102378f, 
    -0.00665916f, -0.06634712f, 0.01483130f, -0.14439860f, -0.08963642f, 0.00342202f, 0.07747746f, 0.02067312f, 
    0.01885031f, -0.17824584f, -0.15747878f, -0.10304911f, -0.14682530f, 0.21909617f, 0.01826265f, 0.16204248f, 
    -0.15164649f, -0.11388003f, 0.12452320f, -0.11252943f, 0.24276654f, 0.11021038f, 0.05624809f, -0.19498426f, 
    0.16405053f, 0.11006820f, 0.17544536f, -0.10772000f, -0.04936660f, 0.04649502f, -0.01415558f, 0.04659326f, 
    0.06525136f, -0.00512779f, 0.08096091f, 0.05246815f, 0.02970033f, -0.01096617f, 0.04326621f, -0.04377878f, 
    -0.00021785f, 0.00235061f, -0.21910006f, -0.03154352f, -0.04296962f, 0.00924265f, 0.03651760f, -0.09575789f, 
    0.17328288f, 0.07105800f, -0.01721468f, 0.11173373f, -0.01049805f, -0.01876157f, 0.08452000f, 0.01301766f, 
    0.12056396f, 0.27973270f, 0.01270276f, 0.03437937f, 0.05349900f, -0.05910650f, 0.02768080f, 0.01309683f, 
    0.07480387f, -0.04633651f, -0.06415127f, 0.07094477f, 0.14339896f, 0.03023290f, 0.07589556f, 0.10612050f, 
    -0.03655097f, -0.05796402f, 0.01348746f, -0.06444072f, -0.03573180f, -0.07290132f, -0.01943261f, 0.06935858f, 
    -0.10064747f, -0.21146801f, -0.18797091f, -0.22649370f, 0.02729926f, 0.09204716f, 0.12429596f, 0.09882284f, 
    -0.02335422f, -0.08215427f, -0.01191270f, -0.27060202f, -0.15618639f, -0.07865659f, 0.09013883f, -0.04754167f, 
    0.02687634f, 0.04591241f, 0.04972766f, -0.04834345f, -0.02697999f, -0.05874320f, 0.02562993f, 0.12018083f, 
    0.05006357f, 0.09640073f, 0.16222489f, 0.16662051f, -0.03013289f, 0.01894978f, 0.00291348f, -0.04789380f, 
    0.11182937f, -0.08129256f, -0.21879426f, -0.04006388f, 0.03627943f, 0.01737514f, -0.12851526f, -0.11196931f, 
    -0.01870710f, 0.00570416f, 0.00098660f, -0.00617361f, -0.00746723f, 0.00461855f, -0.06259726f, 0.05993126f, 
    -0.03021854f, -0.01972417f, -0.11759873f, -0.06892342f, 0.04248378f, -0.05942945f, 0.08616874f, 0.08640008f, 
    0.03587221f, 0.07996930f, -0.07231603f, 0.03389917f, 0.14448951f, 0.03118941f, 0.15945603f, 0.09347577f, 
    -0.00786333f, -0.09636500f, -0.05514049f, -0.05911536f, 0.05493512f, -0.03718860f, -0.03105885f, 0.05202656f, 
    0.07615104f, 0.05621626f, -0.00254021f, -0.03038793f, 0.13674781f, 0.06828959f, -0.06088177f, -0.02959121f, 
    -0.10796611f, 0.10151630f, 0.00358140f, -0.04100597f, -0.09210154f, -0.15665883f, -0.05028583f, -0.28528804f, 
    -0.04123635f, 0.00194231f, -0.02220403f, -0.04371777f, -0.09221069f, -0.08539274f, -0.30771226f, -0.01952091f, 
    0.16049609f, 0.13668352f, 0.14914621f, 0.18530920f, -0.04442337f, -0.00062869f, 0.00808075f, -0.00788252f, 
    0.18262336f, -0.09717040f, -0.02880039f, -0.17776357f, 0.21583895f, -0.04505619f, 0.02682923f, -0.05295226f, 
    0.02997491f, 0.05975702f, 0.08280564f, 0.10061780f, 0.00361858f, -0.13543972f, -0.10282278f, -0.08005156f, 
    -0.06618637f, -0.10286379f, -0.24312331f, -0.06426723f, 0.11269699f, 0.15927990f, 0.14362706f, -0.08158161f, 
    0.01394054f, 0.04209613f, 0.10934594f, 0.06295633f, 0.00533161f, 0.09571546f, -0.02651754f, -0.12892914f, 
    0.17258941f, 0.10163167f, 0.03785241f, -0.02350683f, -0.03833526f, -0.09284494f, 0.08189189f, 0.05780265f, 
    0.08145960f, -0.01190629f, 0.16099371f, 0.04160414f, 0.06852576f, -0.12255644f, 0.10681242f, -0.06284828f, 
    -0.01157761f, 0.12475000f, 0.20746079f, -0.07721675f, 0.13521515f, -0.03418589f, 0.12119325f, 0.18835483f, 
    0.04387969f, 0.01861758f, -0.02372763f, -0.02205756f, -0.01243509f, 0.04020813f, 0.05276828f, -0.00589142f, 
    0.07978795f, 0.17226817f, 0.04079322f, 0.20576733f, -0.04900873f, -0.02680814f, -0.02811230f, -0.04219954f, 
    0.01851222f, 0.00478174f, 0.01872497f, 0.11238358f, 0.41897187f, 0.12583126f, 0.00609702f, 0.17327403f, 
    -0.07258787f, -0.14235981f, -0.05418708f, 0.00603764f, 0.12404258f, -0.04426688f, 0.00009693f, 0.00939581f, 
    -0.12015569f, -0.21124528f, -0.34248689f, -0.11246579f, 0.02510876f, -0.19556496f, -0.15925503f, -0.11181007f, 
    -0.05463457f, -0.02780882f, -0.09170448f, -0.10738923f, -0.03560310f, -0.28470609f, -0.52662867f, -0.08041839f, 
    -0.03059418f, 0.05861031f, 0.05756346f, 0.02567249f, 0.21206407f, -0.00885918f, -0.03882417f, -0.08633097f, 
    0.00186464f, -0.07029237f, 0.06911551f, 0.01006511f, 0.00729507f, -0.06497121f, 0.01450370f, 0.04236438f, 
    -0.08108062f, 0.07368653f, -0.07897668f, 0.10056204f, 0.05954622f, -0.03373192f, 0.03472697f, -0.11454652f, 
    0.06593078f, 0.06849771f, -0.05808738f, -0.03582296f, -0.12278292f, -0.01361902f, 0.04045826f, -0.02997120f, 
    -0.15364721f, 0.07729512f, 0.01855492f, -0.04486170f, 0.08966469f, 0.02445246f, -0.06845912f, 0.21141784f, 
    0.00281334f, 0.06467328f, 0.02920819f, -0.01212101f, 0.07575569f, -0.10146840f, -0.06469804f, 0.09310607f, 
    -0.07813141f, 0.00656309f, 0.05258886f, 0.17200671f, 0.04192653f, -0.08513381f, 0.07415915f, -0.16497159f, 
    0.13539383f, -0.01568585f, 0.12641861f, 0.02709673f, -0.06759897f, -0.06642868f, -0.05477982f, -0.05286928f, 
    0.01835794f, -0.06393665f, 0.12008124f, -0.08100612f, -0.21150519f, -0.02461417f, -0.09049801f, 0.03622821f, 
    -0.09307557f, 0.00642739f, -0.06569048f, 0.21989766f, -0.02095242f, 0.09034887f, -0.07877415f, -0.00104071f, 
    0.07175034f, -0.06711748f, 0.01147751f, -0.40692884f, 0.16795734f, -0.06195787f, 0.10176358f, -0.08676346f, 
    -0.15008576f, 0.04466056f, 0.00878012f, 0.12002987f, 0.09686015f, 0.28111041f, 0.14054787f, -0.23761892f, 
    -0.07081572f, -0.01045314f, 0.18801269f, -0.06819887f, 0.01141798f, 0.05808797f, -0.02370132f, 0.08976588f, 
    0.12072966f, 0.08971749f, 0.00963549f, 0.11721736f, 0.08652086f, -0.01043135f, 0.02163803f, -0.11294313f, 
    0.03322261f, -0.04976735f, 0.03080921f, 0.14420888f, 0.17092708f, 0.08020433f, -0.03234323f, -0.33990121f, 
    -0.10623730f, -0.05493901f, 0.10601391f, -0.11954247f, -0.18297760f, 0.01142645f, -0.10237416f, 0.05609250f, 
    0.23157749f, 0.18576980f, -0.07632019f, -0.40842906f, 0.16367108f, 0.16506848f, 0.10003892f, 0.07321344f, 
    0.05069954f, 0.04701272f, -0.02125775f, 0.14103727f, -0.32544723f, -0.22275992f, -0.46443424f, -0.28989536f, 
    -0.10022168f, 0.01907331f, 0.06195427f, 0.04245399f, 0.09373693f, 0.03142629f, -0.10942791f, -0.12581396f, 
    -0.07128908f, 0.04929567f, 0.04250599f, 0.02455719f, 0.15681429f, 0.03024276f, -0.20846088f, -0.10973413f, 
    0.02163057f, -0.00511921f, 0.01582502f, 0.02284354f, -0.09433488f, -0.14406706f, -0.00414643f, 0.07355496f, 
    0.00495699f, 0.11019760f, -0.09303167f, 0.24879876f, -0.12008837f, 0.02156062f, -0.02049648f, -0.11800609f, 
    -0.14944306f, -0.13973770f, -0.19866802f, -0.11616000f, 0.15307674f, 0.19049948f, 0.07082234f, 0.07568669f, 
    -0.00414789f, 0.07947440f, 0.05875205f, 0.03084573f, 0.02848502f, 0.01538263f, 0.10085683f, 0.19558001f, 
    0.00860368f, 0.03220263f, -0.01710334f, -0.04037026f, 0.06095884f, -0.00289628f, 0.10077601f, 0.04117269f, 
    -0.04871293f, 0.11451065f, 0.17528088f, 0.25614032f, 0.05640681f, -0.04547783f, -0.06577862f, 0.05398840f, 
    0.05750500f, -0.00317943f, 0.08300499f, 0.05697131f, -0.23867548f, 0.06192120f, 0.16557825f, -0.01663231f, 
    0.05028567f, 0.07556023f, 0.02672976f, 0.03289122f, -0.01049438f, 0.06357997f, -0.10504723f, 0.03272237f, 
    0.09055331f, 0.03703182f, -0.13931008f, -0.10038816f, 0.17118572f, 0.10614772f, -0.03366951f, 0.12186368f, 
    -0.00036065f, -0.06742437f, 0.09381557f, 0.14745241f, 0.22648217f, 0.03092939f, 0.08939096f, 0.02166355f, 
    -0.02948897f, -0.00171185f, 0.05957605f, -0.08279362f, 0.17779860f, 0.00275438f, 0.03901406f, 0.05346679f, 
    -0.02576187f, -0.03483764f, 0.02636949f, -0.00139059f, -0.03581351f, 0.02090411f, 0.00870632f, -0.01499236f, 
    -0.03009033f, -0.03985027f, 0.01388605f, 0.01111382f, -0.01004706f, -0.01861789f, -0.03015262f, -0.03517203f, 
    0.01305052f, -0.02872906f, 0.02594601f, -0.00784201f, -0.02335879f, -0.03214723f, -0.00745199f, 0.00201181f, 
    -0.00040772f, -0.03222070f, -0.03648493f, -0.03579534f, -0.00276652f, 0.01566454f, 0.00091693f, -0.03748759f, 
    -0.00351082f, -0.01932840f, -0.01603301f, -0.03406917f, 0.00303044f, 0.00167991f, 0.00518357f, -0.02147301f, 
    -0.00664827f, 0.00467277f, -0.03513440f, -0.01749900f, -0.02826097f, 0.01922785f, 0.01310186f, 0.01340275f, 
    -0.03621370f, -0.04112989f, -0.00581753f, -0.00048353f, 0.01355677f, -0.01255066f, 0.00259508f, -0.00569003f, 
    -0.00466662f, -0.01929304f, -0.02607531f, -0.03773244f, -0.01507903f, -0.01983929f, 0.02963583f, 0.00077596f, 
    0.00904987f, 0.02568565f, 0.00329846f, -0.00001521f, -0.00110907f, 0.01738213f, -0.03717984f, -0.02440117f, 
    -0.01315772f, 0.01172462f, 0.01791387f, 0.02611409f, -0.02663974f, -0.00844412f, -0.03398514f, -0.01759720f, 
    -0.00804047f, 0.02573158f, -0.01811077f, 0.02659834f, -0.00481635f, 0.02038519f, -0.02100326f, -0.03785074f, 
    -0.02270852f, -0.03748524f, -0.03426645f, -0.01904829f, -0.01015444f, -0.02787564f, -0.01625463f, -0.02834629f, 
    -0.02595642f, -0.03222535f, 0.02653189f, 0.01138376f, 0.00159327f, -0.03347475f, -0.00818516f, 0.02295140f, 
    -0.04114481f, 0.00473393f, 0.01315797f, -0.01561897f, -0.01674280f, -0.00108290f, -0.02419471f, -0.01693264f, 
    -0.00943580f, -0.01555791f, -0.03253967f, -0.00220775f, -0.03956797f, -0.03029691f, -0.02857778f, 0.00537094f, 
    -0.01358025f, -0.04125084f, 0.02984234f, -0.02443333f, 0.01878822f, -0.00723808f, -0.00590886f, -0.03688186f, 
    -0.03279978f, 0.01359233f, 0.01515868f, 0.02013443f, 0.02507055f, -0.04045229f, -0.03884146f, -0.01127669f, 
    -0.04115160f, -0.03517691f, 0.02815204f, -0.00883739f, -0.01121540f, 0.02332574f, -0.02509790f, -0.00818699f, 
    -0.01870277f, 0.00102424f, -0.03618445f, 0.00290968f, -0.03245044f, -0.01332954f, 0.02120827f, -0.02795757f, 
    0.02741814f, -0.01729081f, 0.02337558f, -0.02644367f, -0.02035505f, -0.02720309f, -0.02822175f, -0.01331760f, 
    -0.01796464f, -0.00611293f, -0.04137952f, 0.03755188f, 0.02628997f, -0.03859205f, 0.02202939f, 0.00841382f, 
    -0.00450140f, -0.02855826f, -0.02044739f, -0.03451362f, 0.01496888f, 0.01301492f, -0.03889492f, -0.02726717f, 
    -0.00092269f, -0.03535609f, 0.01747615f, 0.00271490f, -0.00627271f, 0.02498743f, -0.02440253f, 0.00531551f, 
    -0.01858238f, -0.00214219f, 0.01189490f, -0.02930809f, 0.01990050f, -0.00615210f, -0.00146911f, -0.02108795f, 
    0.00509598f, 0.00440046f, -0.02453839f, -0.01500575f, 0.01918697f, 0.01041698f, -0.01970257f, 0.00285611f, 
    0.01758490f, -0.00935297f, 0.02420919f, -0.00346698f, -0.01057055f, 0.00182680f, -0.03943522f, 0.02139859f, 
    -0.00237817f, 0.01776558f, 0.01041790f, -0.02565721f, 0.01507679f, -0.04127483f, 0.01686942f, -0.00915708f, 
    0.02201118f, -0.03370663f, -0.03630079f, -0.01924391f, -0.02460234f, 0.01109454f, 0.00349582f, 0.02242315f, 
    -0.04205082f, 0.01108601f, -0.00099629f, -0.01644385f, -0.00553361f, -0.03644407f, -0.02586224f, 0.00549440f, 
    0.00544018f, -0.01698807f, -0.02420707f, 0.02075245f, 0.01709802f, -0.00400005f, -0.02290448f, -0.00378122f, 
    -0.03367402f, -0.02999955f, -0.03946272f, -0.03414034f, 0.01380977f, 0.02267819f, 0.00715451f, -0.00723064f, 
    -0.01257709f, -0.03491612f, 0.01719494f, 0.00212234f, 0.02878402f, 0.00582463f, -0.01643282f, 0.02999911f, 
    -0.02414854f, 0.02885443f, -0.02069450f, 0.02908763f, 0.02069491f, 0.00752603f, -0.04086598f, -0.00670679f, 
    -0.01799035f, -0.00121371f, 0.02776431f, 0.01319499f, -0.01223262f, -0.00444700f, -0.03219989f, -0.00623084f, 
    0.01036496f, -0.03634321f, -0.02446098f, 0.01491832f, -0.01139048f, -0.01197122f, -0.03167092f, 0.02973873f, 
    0.01261274f, -0.01052666f, -0.03240609f, 0.01991499f, 0.00788231f, 0.01622340f, -0.04186443f, -0.00163872f, 
    0.00474139f, -0.03091087f, -0.04107425f, -0.01799784f, 0.00672203f, -0.00842735f, -0.03476688f, -0.01027072f, 
    -0.03074699f, 0.02104637f, -0.00523681f, -0.01691481f, 0.01383503f, -0.00117052f, 0.02002009f, -0.00180985f, 
    0.02646014f, -0.04055943f, -0.03057433f, -0.02069308f, -0.02361904f, -0.01654870f, 0.01702818f, -0.03905506f, 
    0.00416253f, 0.02811908f, -0.01513699f, -0.01985947f, -0.03114393f, 0.00531754f, -0.04038680f, -0.00647355f, 
    0.01506510f, -0.01980646f, 0.01939917f, -0.02575760f, 0.01108981f, -0.01369503f, -0.03761127f, 0.00794689f, 
    -0.02119244f, -0.01839195f, 0.01914980f, -0.01372230f, 0.01489360f, -0.03533474f, -0.01906528f, 0.01323903f, 
    0.00231812f, 0.01234997f, -0.02425301f, -0.01879187f, -0.00795957f, -0.01988188f, -0.03929321f, 0.00221783f, 
    -0.00238419f, -0.02749360f, 0.01090056f, 0.00806033f, -0.01436647f, -0.00680500f, 0.02014801f, 0.01050387f, 
    -0.03986939f, 0.01764519f, 0.01529579f, 0.01829779f, 0.02170240f, 0.02428095f, -0.01443410f, -0.00223964f, 
    0.02061155f, 0.00597445f, 0.00707671f, 0.01118816f, -0.04024812f, -0.04138803f, 0.01856265f, 0.02463874f, 
    -0.02070616f, -0.02924364f, -0.00844564f, 0.00313881f, 0.02767296f, -0.02352117f, -0.01631081f, 0.01519581f, 
    -0.02299761f, -0.01593231f, -0.03381694f, -0.01773791f, 0.03835402f, -0.00857422f, 0.02502389f, -0.02136837f, 
    -0.02730944f, 0.02352597f, -0.01072235f, -0.01300091f, 0.00720655f, -0.00240451f, 0.01309153f, -0.00231261f, 
    0.01415678f, 0.01756317f, 0.02421437f, -0.03768395f, 0.01332122f, -0.03378613f, -0.03428701f, 0.01068541f, 
    -0.03580014f, 0.02487347f, 0.00868759f, -0.01405210f, -0.02397120f, -0.00661622f, 0.02402448f, -0.00643586f, 
    -0.02367096f, 0.01261029f, -0.03199420f, 0.00556404f, -0.01176829f, -0.00380668f, 0.01867718f, -0.00688109f, 
    -0.02104716f, 0.00899971f, -0.01555287f, -0.02184260f, 0.02228431f, -0.03208757f, -0.03213347f, -0.03909977f, 
    0.00557281f, 0.00967571f, -0.01069253f, 0.01196191f, -0.02484410f, 0.00708585f, -0.03257794f, -0.00402007f, 
    -0.02155062f, 0.01360148f, -0.03005293f, 0.02734816f, 0.00379997f, -0.03966036f, -0.01083785f, -0.03539101f, 
    -0.01571508f, 0.01747649f, 0.01309665f, 0.00586120f, 0.00534912f, -0.03566072f, -0.02767295f, -0.03421962f, 
    0.00222301f, -0.02297281f, 0.01238766f, -0.01713788f, -0.01745904f, 0.00684468f, 0.02918794f, 0.01456955f, 
    -0.02051682f, -0.03604311f, 0.01661243f, -0.03704531f, -0.02654414f, 0.02086663f, 0.00627855f, -0.01123720f, 
    -0.00244631f, -0.01903232f, 0.00821008f, -0.02341018f, -0.02522118f, -0.01206122f, 0.00151926f, -0.02856904f, 
    0.02161230f, -0.02595261f, -0.04005051f, -0.03033267f, 0.01807925f, 0.02323265f, 0.02236523f, -0.03401347f, 
    0.02012100f, -0.02867534f, 0.00090381f, -0.02790030f, 0.01857635f, -0.02265230f, -0.03737311f, 0.02447130f, 
    -0.03390050f, 0.02224502f, -0.00298877f, 0.01870140f, 0.00540368f, -0.00669907f, -0.03114668f, 0.02373787f, 
    -0.02346618f, 0.00260467f, -0.00419664f, 0.00371925f, 0.01937680f, 0.01662773f, -0.01307498f, -0.00682920f, 
    -0.02547000f, -0.00173600f, -0.01257996f, 0.00802156f, 0.01561420f, -0.03931911f, 0.02695153f, 0.01211051f, 
    -0.03760808f, -0.01829561f, 0.01652289f, 0.01077088f, -0.01284989f, -0.01173518f, -0.02943273f, -0.01065099f, 
    -0.02369191f, 0.00378846f, 0.01887673f, 0.01543888f, -0.04205748f, -0.03837387f, -0.01188299f, -0.02445394f, 
    -0.02194864f, -0.02452049f, -0.02959208f, -0.02387300f, 0.00084634f, 0.01109419f, 0.02265485f, 0.00303612f, 
    -0.00758146f, 0.02843395f, -0.03217024f, -0.03574355f, -0.03416597f, -0.03613747f, -0.02944751f, 0.01660217f, 
    0.02872648f, -0.02479758f, -0.03658169f, -0.02228507f, 0.02255061f, -0.02447560f, 0.01574797f, -0.03774834f, 
    0.02647926f, 0.00854806f, 0.01137430f, 0.02517238f, 0.00128074f, -0.03553934f, 0.01634543f, 0.01119298f, 
    -0.03035631f, -0.02865953f, 0.02196021f, -0.01558131f, -0.03779285f, 0.00502137f, -0.03815953f, -0.02777252f, 
    0.02293115f, 0.00224853f, -0.02529847f, -0.02377039f, 0.02056880f, -0.04054372f, 0.01413498f, -0.03158000f, 
    0.02232674f, -0.03311438f, 0.02730956f, 0.02123767f, -0.00994449f, 0.01622764f, -0.02601452f, -0.01715254f, 
    -0.02465978f, 0.00163850f, -0.02673335f, -0.01993139f, -0.00452903f, 0.02667220f, 0.02706994f, -0.03146840f, 
    -0.00156188f, 0.02009704f, -0.03829606f, -0.01975254f, 0.02278282f, 0.01404494f, 0.00612186f, 0.02253893f, 
    -0.02548437f, -0.01377297f, 0.00321850f, -0.03733585f, -0.00581260f, -0.01704208f, 0.01104738f, -0.00472938f, 
    0.02635940f, 0.02623626f, 0.02414158f, -0.03968952f, -0.01141995f, 0.01428008f, -0.03282460f, -0.01480620f, 
    0.01416521f, 0.00370038f, -0.01061142f, 0.02559384f, 0.01541376f, -0.00449300f, -0.01772889f, -0.00012648f, 
    -0.02056788f, 0.02047771f, -0.04164949f, -0.01893838f, -0.02527564f, 0.01053033f, 0.02487485f, -0.02517632f, 
    0.02745388f, -0.03200668f, -0.02937168f, -0.02007505f, 0.02822659f, 0.01966961f, 0.02431758f, -0.01462271f, 
    0.00247435f, -0.01009794f, 0.00277668f, -0.00778808f, -0.03513040f, -0.02198193f, 0.00206774f, -0.00080405f, 
    0.00272870f, -0.02531615f, 0.00603013f, -0.02723484f, -0.00758416f, 0.01985651f, -0.03671066f, -0.03369780f, 
    0.02946728f, 0.02145348f, 0.01890511f, -0.01987966f, -0.02346451f, -0.01452029f, -0.02465918f, -0.00665750f, 
    0.00327044f, 0.01181170f, -0.02869366f, -0.00224357f, -0.02694457f, -0.02772663f, -0.02291279f, -0.00891823f, 
    -0.00613541f, -0.03593289f, -0.01894892f, -0.04113290f, -0.01136920f, -0.01788652f, 0.01991516f, 0.01060996f, 
    0.00187420f, -0.03116793f, -0.03629379f, -0.01624805f, 0.02083005f, 0.01758978f, 0.02989564f, 0.02871549f, 
    0.02379656f, -0.02298741f, -0.00230082f, 0.00544577f, -0.03330502f, 0.00057087f, -0.03916650f, -0.02612608f, 
    -0.02274003f, 0.02187806f, -0.03120478f, -0.01900082f, -0.00226991f, -0.02832859f, 0.01345900f, 0.00963861f, 
    -0.03298517f, -0.02057570f, 0.01292322f, -0.00168634f, 0.02025319f, 0.00145396f, -0.01278779f, -0.01066695f, 
    -0.01563830f, 0.00031738f, 0.02014931f, -0.02943652f, 0.03820430f, -0.04206006f, -0.00816192f, -0.02899923f, 
    0.01969322f, 0.02805496f, -0.00060474f, 0.00914286f, -0.00009580f, -0.04166988f, -0.01816541f, 0.00028626f, 
    -0.01722280f, -0.00418370f, 0.01568637f, -0.00936486f, -0.03686882f, -0.03284136f, -0.03592591f, 0.01589509f, 
    -0.01944687f, -0.01576773f, 0.00666782f, -0.03499694f, -0.03704607f, 0.01543280f, -0.01138444f, 0.00928250f, 
    -0.01721749f, -0.01481535f, 0.00910150f, -0.03271516f, 0.02774866f, 0.02721797f, 0.00982719f, 0.00410402f, 
    -0.00671645f, -0.02519949f, 0.00572513f, 0.00652126f, -0.01206645f, -0.01757143f, -0.01700185f, 0.00200388f, 
    0.02764548f, 0.01209234f, 0.01413237f, -0.02106375f, 0.02763711f, 0.00801484f, 0.00958813f, -0.03347568f, 
    0.01274096f, -0.02519996f, 0.03203621f, -0.03958492f, -0.02981103f, 0.00491045f, -0.01936210f, -0.02992831f, 
    -0.03974140f, -0.03617167f, -0.02660633f, 0.02101883f, -0.00921429f, 0.01676988f, -0.03938768f, -0.03980992f, 
    0.01156497f, 0.01450891f, -0.02462190f, 0.01797853f, -0.00455077f, 0.00051509f, -0.03397880f, -0.00452871f, 
    0.02101743f, 0.02327861f, -0.02864629f, -0.00361460f, -0.04132095f, 0.01481741f, -0.03752372f, -0.01026387f, 
    -0.02365896f, 0.02753443f, 0.00134846f, -0.00783343f, -0.02961769f, -0.01124210f, 0.00331255f, 0.01129831f, 
    0.01899678f, 0.02531064f, 0.00984498f, -0.01710722f, -0.00880210f, -0.02758125f, 0.00127507f, -0.02687754f, 
    0.00680098f, -0.00878099f, 0.01388351f, 0.00685152f, 0.01862563f, 0.00497643f, 0.00252868f, 0.01663567f, 
    0.02712541f, 0.02920836f, -0.02011899f, -0.02963469f, -0.00433338f, -0.02487195f, 0.02564948f, -0.00642712f, 
    0.00654534f, 0.02652995f, -0.01221955f, -0.01489430f, 0.02401532f, -0.02682359f, -0.02363985f, 0.02279949f, 
    -0.00922856f, -0.03884686f, 0.01284146f, 0.01673118f, -0.01115982f, 0.00061277f, 0.00761652f, -0.02935697f, 
    -0.00776125f, 0.00341700f, -0.01963817f, 0.00737292f, -0.01433850f, 0.03583151f, -0.02802015f, -0.01863169f, 
    -0.01404459f, 0.01730517f, -0.00880766f, 0.01707918f, 0.00383087f, -0.03475492f, 0.00604744f, 0.02562060f, 
    -0.00980498f, -0.00230037f, 0.01091732f, 0.02256063f, 0.00266756f, 0.01294915f, -0.03097984f, 0.02382995f, 
    -0.03538135f, -0.00220187f, -0.00230834f, -0.00543430f, -0.01275957f, 0.01600885f, -0.02317576f, 0.00123801f, 
    0.02149323f, -0.00088371f, -0.02427031f, 0.02735282f, -0.03019208f, -0.01016350f, 0.03405880f, -0.00889162f, 
    -0.01778648f, -0.02200097f, 0.00123005f, -0.04053236f, 0.02448134f, -0.03124325f, -0.00579017f, 0.00872609f, 
    0.02461087f, -0.02587657f, -0.03179904f, 0.00363405f, -0.03143894f, -0.01804778f, -0.03416681f, 0.02714987f, 
    -0.00408090f, -0.01280271f, 0.01650874f, 0.02919155f, 0.02144655f, -0.01221482f, -0.00073330f, 0.01314320f, 
    -0.03975915f, 0.02724769f, -0.01594496f, -0.01494459f, 0.01890359f, 0.01804578f, 0.01212697f, 0.00270245f, 
    0.00750130f, -0.01065778f, 0.02096310f, -0.02463534f, 0.01421944f, -0.02807334f, -0.00180661f, -0.02198987f, 
    0.03932689f, -0.00438542f, 0.02372654f, 0.02601692f, 0.02368242f, 0.00056368f, -0.00270876f, 0.01938721f, 
    -0.01297064f, -0.03308930f, -0.01205155f, 0.02490026f, 0.02697367f, 0.02199593f, -0.00213281f, 0.00586511f, 
    0.02470748f, -0.02495155f, -0.01858022f, -0.02769690f, 0.02122434f, 0.01808152f, 0.00490368f, -0.02360614f, 
    0.00194386f, -0.02568740f, -0.02625305f, 0.00091400f, -0.01561822f, 0.01737633f, -0.02561297f, 0.00655646f, 
    0.02396818f, 0.00838622f, -0.01336201f, -0.01674403f, -0.03325450f, -0.02812991f, 0.02076231f, -0.02832661f, 
    -0.01607929f, -0.02812751f, 0.01665761f, 0.01613548f, -0.03055838f, -0.03169142f, 0.00386763f, -0.01402992f, 
    -0.00494542f, -0.03676480f, -0.01362309f, 0.02221649f, 0.01279773f, 0.00385088f, 0.00967085f, -0.01602466f, 
    0.01638982f, -0.01866638f, 0.02015365f, 0.01986262f, 0.00879013f, 0.01277338f, -0.01450077f, -0.00144373f, 
    0.01297268f, -0.00322724f, 0.00221310f, 0.00267920f, 0.01719527f, -0.01494172f, 0.00573468f, 0.01184439f, 
    -0.02140299f, -0.00050826f, -0.02213888f, -0.00317620f, 0.03931572f, -0.03545116f, 0.00081489f, -0.04016785f, 
    -0.00472921f, -0.00859713f, 0.00281547f, 0.00910748f, 0.03065410f, -0.00714556f, -0.00448117f, 0.01080502f, 
    -0.01546297f, 0.01054463f, 0.03240441f, -0.01942517f, 0.02191159f, -0.02510110f, 0.01111726f, 0.01547607f, 
    0.01730199f, 0.00890606f, -0.01384935f, -0.01828539f, -0.01792578f, -0.00249769f, -0.00778753f, -0.02383228f, 
    -0.01141548f, 0.01886908f, -0.01006799f, -0.02403025f, -0.01384484f, -0.02218640f, -0.03236942f, -0.02932397f, 
    0.00160960f, 0.00746258f, 0.02756036f, 0.00535442f, 0.02389739f, -0.02610869f, -0.03634625f, -0.03324059f, 
    -0.02633733f, 0.01051562f, 0.01512603f, 0.00949453f, 0.00510233f, -0.03146528f, 0.00416530f, 0.02193855f, 
    -0.02795590f, -0.02739780f, 0.02868831f, -0.01906375f, -0.00030773f, -0.01976952f, -0.00605003f, -0.00583115f, 
    -0.03413441f, -0.03071986f, -0.01524671f, 0.02415156f, 0.00984229f, -0.02756408f, 0.01623436f, 0.02034889f, 
    0.00016350f, 0.01634170f, -0.03538135f, 0.02241887f, 0.00975535f, 0.02914640f, 0.03196962f, 0.02582326f, 
    -0.02585368f, -0.02665678f, -0.03353338f, -0.03046868f, 0.02882585f, 0.02824635f, -0.03452037f, -0.02663462f, 
    -0.03563836f, -0.00872365f, -0.02126332f, 0.00390548f, -0.02956480f, -0.02704562f, 0.00435103f, -0.03805888f, 
    -0.00623775f, 0.02181977f, 0.02437706f, 0.00854401f, 0.02340473f, -0.01621993f, -0.00250186f, -0.00010132f, 
    -0.02010273f, 0.00281370f, -0.02339963f, 0.01686185f, 0.01540678f, -0.00018883f, -0.03424585f, 0.01317063f, 
    0.02039026f, 0.02446280f, 0.03889210f, -0.03830846f, -0.03846533f, -0.02274448f, -0.02936113f, -0.03210196f, 
    0.00396608f, 0.00723617f, 0.02490633f, -0.00127343f, 0.01823343f, 0.00372022f, 0.01191031f, -0.03028589f, 
    -0.03920186f, 0.01964501f, 0.02597456f, -0.03836325f, 0.01588619f, 0.00232141f, 0.00413578f, -0.02139040f, 
    0.02361125f, -0.01085474f, 0.01501408f, 0.02806276f, -0.02390073f, -0.03505387f, -0.02977066f, -0.02462089f, 
    0.02629420f, 0.03405700f, -0.03050801f, -0.03769851f, 0.03491259f, 0.01213804f, 0.00115316f, -0.01147790f, 
    0.02083123f, -0.00760923f, -0.02155703f, -0.00782989f, -0.01195511f, 0.00703328f, 0.01174067f, -0.02309301f, 
    -0.01674880f, 0.01718787f, 0.02855089f, 0.03260094f, -0.00115351f, 0.01840372f, 0.01570089f, 0.02320930f, 
    0.00395910f, 0.01147516f, -0.00413161f, 0.02091241f, -0.03563816f, -0.02005134f, -0.03259590f, -0.02297976f, 
    -0.02382311f, -0.01201348f, 0.01297805f, 0.00215483f, 0.03170983f, -0.02647061f, 0.02969655f, -0.01472605f, 
    0.02942456f, -0.03129377f, 0.01084311f, 0.00975711f, 0.02466664f, 0.01695703f, 0.00027738f, -0.01013850f, 
    0.00413686f, 0.00943415f, -0.01465591f, -0.02586828f, 0.02386866f, 0.02030479f, 0.00013172f, -0.04059412f, 
    -0.03367924f, 0.02186064f, -0.02062945f, -0.01578782f, -0.03952232f, 0.00257073f, 0.00204700f, -0.00325896f, 
    -0.01864146f, -0.02192639f, -0.03740438f, -0.00586528f, -0.02435993f, -0.03100862f, 0.01188142f, -0.03512134f, 
    -0.01427154f, 0.02920890f, -0.01634050f, -0.03437852f, 0.00143675f, 0.02967754f, -0.02964740f, -0.03297425f, 
    -0.02347991f, 0.01822035f, -0.00396014f, -0.01235487f, 0.00981288f, -0.03681508f, 0.00245577f, -0.03962385f, 
    -0.01552688f, -0.02826421f, -0.00564537f, 0.01887936f, -0.02531694f, 0.01048571f, 0.01719079f, 0.00585539f, 
    -0.02053442f, 0.01548057f, -0.00934376f, -0.02175932f, 0.02089845f, 0.01379756f, 0.00689096f, 0.02992360f, 
    0.00290829f, 0.00546783f, -0.00813048f, -0.00355463f, 0.00353301f, -0.02281517f, 0.03928945f, 0.02111740f, 
    -0.01045013f, -0.04035033f, -0.00418371f, -0.03275202f, -0.01716652f, 0.01679578f, -0.03025834f, -0.00246659f, 
    0.00289114f, -0.03210057f, 0.01953383f, 0.01558636f, -0.03628888f, -0.02854205f, 0.00293575f, -0.03613783f, 
    0.02874142f, -0.02470776f, 0.00017177f, 0.01419512f, 0.00344176f, -0.01617822f, -0.03370503f, -0.01929908f, 
    -0.01340435f, -0.02327267f, -0.01989851f, -0.02350815f, -0.02587772f, -0.01230879f, -0.00814742f, 0.03204224f, 
    -0.02726212f, -0.02421452f, 0.02506606f, -0.01430727f, -0.02788353f, 0.01864245f, 0.01537162f, -0.02221726f, 
    -0.00115146f, -0.00449351f, -0.00845378f, -0.03145307f, -0.03471944f, 0.01623057f, 0.00813934f, 0.01901301f, 
    -0.02994486f, -0.00704383f, 0.00588480f, -0.00840850f, -0.00926358f, -0.00006053f, 0.02740458f, -0.00082239f, 
    0.01730436f, -0.00090885f, 0.00077417f, -0.02036601f, 0.01197506f, -0.02104822f, -0.01865278f, 0.02005682f, 
    -0.02681414f, -0.02633800f, 0.01426066f, 0.01686829f, 0.01006206f, 0.01666239f, 0.00854730f, 0.02722177f, 
    -0.02962344f, -0.00803020f, 0.02767748f, 0.02743177f, -0.00349620f, -0.00691146f, -0.00966034f, -0.03001723f, 
    -0.00943043f, 0.02759811f, -0.00422174f, -0.00238923f, -0.00924542f, -0.00586326f, 0.03588681f, 0.02261207f, 
    0.01982462f, 0.02296790f, 0.00109655f, 0.00558046f, -0.00365009f, 0.01877029f, -0.02166964f, -0.01677181f, 
    -0.04153297f, -0.02333376f, -0.03000919f, 0.03662518f, -0.00219887f, -0.01629712f, 0.01371359f, -0.00838002f, 
    -0.03114582f, 0.02794271f, 0.02261569f, -0.01687271f, 0.02897892f, -0.02062736f, -0.02651937f, 0.01101122f, 
    0.04088414f, -0.00114131f, -0.03817816f, -0.01142862f, -0.01793376f, 0.02951832f, -0.01445267f, -0.03439740f, 
    -0.01690968f, -0.00497673f, 0.03958846f, -0.01984083f, -0.02494071f, -0.02298870f, 0.01580052f, 0.01340474f, 
    0.02938957f, -0.01103614f, 0.00154768f, -0.02689532f, -0.00660284f, 0.01931455f, -0.00405131f, 0.01292865f, 
    0.03041903f, 0.03836068f, -0.01952994f, -0.01120800f, -0.02601488f, -0.03425170f, -0.01184377f, -0.02382011f, 
    -0.04147454f, 0.00161483f, -0.00804161f, -0.01197462f, 0.03528478f, -0.00026062f, 0.02329539f, -0.01673988f, 
    0.02961974f, -0.02207187f, -0.00428909f, -0.02104605f, 0.03678366f, -0.00634381f, 0.02427676f, 0.03621033f, 
    -0.01967108f, 0.02064041f, -0.03980894f, 0.02851935f, -0.03787743f, 0.02759822f, -0.02661552f, -0.02901927f, 
    -0.00486210f, -0.02699283f, -0.02154795f, 0.01346439f, 0.01259890f, 0.00056234f, 0.01385465f, 0.01448351f, 
    -0.00761066f, 0.01072716f, 0.00108601f, 0.00765805f, -0.02164768f, -0.01770690f, 0.02677636f, 0.02656079f, 
    -0.01811237f, -0.00966860f, 0.00493148f, -0.03126618f, -0.03365158f, -0.01080147f, -0.00948826f, 0.00906647f, 
    0.02373400f, -0.00904849f, -0.03110623f, 0.02330834f, -0.02345142f, 0.01573633f, 0.02199811f, -0.03168242f, 
    -0.00213964f, -0.02098961f, -0.02228540f, 0.03317428f, -0.04031744f, -0.00233625f, 0.00742922f, 0.00661275f, 
    0.00573508f, -0.01113465f, 0.01447309f, -0.02505983f, -0.03858013f, -0.00503916f, -0.04075306f, 0.01119005f, 
    -0.01892718f, 0.00286130f, 0.00049375f, -0.01415275f, -0.02373178f, -0.00506377f, -0.03532309f, -0.02895767f, 
    -0.02112845f, 0.02324356f, 0.01660099f, 0.01195128f, 0.01590796f, -0.01917452f, 0.02304387f, 0.00112482f, 
    -0.02790194f, -0.00927092f, -0.01884963f, -0.03455229f, 0.02886530f, 0.02741566f, 0.01789526f, -0.02547273f, 
    -0.03306510f, 0.01730715f, 0.00300105f, 0.02521606f, 0.01778563f, -0.01476129f, 0.02636967f, -0.02143499f, 
    -0.02136983f, 0.02936910f, -0.01097581f, -0.01693370f, 0.00562677f, -0.03962706f, -0.02443009f, 0.00795249f, 
    -0.00042666f, 0.00151528f, -0.00715269f, -0.03390596f, 0.00310715f, 0.02936911f, -0.02558566f, -0.00329420f, 
    -0.02575064f, 0.01784693f, -0.03349677f, -0.01418613f, 0.02968093f, 0.00232147f, 0.00011668f, 0.00250794f, 
    -0.01954881f, -0.03700080f, -0.02520047f, -0.02272124f, -0.03393245f, -0.01735355f, 0.00444848f, 0.02896061f, 
    -0.05621932f, 0.11141083f, 0.01911693f, -0.24088633f, 0.01246196f, 0.17440556f, 0.12798743f, 0.02203775f, 
    0.08236784f, -0.00943534f, 0.26770642f, 0.06709189f, 0.08192656f, 0.02016106f, 0.00296744f, 0.06393235f, 
    -0.01283722f, -0.05235337f, -0.00786257f, 0.06377534f, 0.04663267f, 0.08288731f, 0.10607336f, 0.19974725f, 
    0.11994987f, 0.07765514f, -0.09094354f, -0.08789105f, 0.05470208f, -0.00755505f, -0.02959389f, 0.07484798f, 
    0.05096270f, -0.02536254f, 0.00327526f, -0.00939867f, -0.15805446f, 0.00794485f, 0.14355373f, -0.10619313f, 
    0.07035617f, 0.04359905f, 0.00299263f, 0.06819120f, 0.00946527f, -0.05126138f, -0.06175027f, -0.07760751f, 
    0.23162076f, -0.01271699f, 0.07278030f, -0.20253575f, 0.01062553f, -0.09584657f, -0.06590147f, 0.10467516f, 
    -0.34716547f, 0.08249471f, -0.03248543f, -0.19490185f, -0.22996627f, 0.05830175f, -0.18592173f, 0.05087140f, 
    0.10024941f, -0.04726768f, -0.02124406f, -0.02741672f, -0.20042050f, -0.25452554f, -0.05820999f, -0.17507358f, 
    0.22917566f, 0.11509095f, 0.26791447f, -0.06961892f, 0.04763196f, 0.03661234f, -0.13803606f, -0.04555019f, 
    -0.00946536f, 0.02399551f, -0.03169842f, 0.05582360f, 0.21845965f, 0.34642190f, -0.21334510f, 0.10946647f, 
    0.01985485f, 0.09792095f, -0.02804962f, -0.00384525f, 0.13242103f, 0.17052823f, 0.00402853f, 0.41029310f, 
    0.10046294f, 0.12800002f, 0.21135025f, -0.12897103f, -0.10614154f, 0.00733854f, 0.00238119f, -0.11010688f, 
    -0.18315816f, 0.03871324f, -0.03627872f, -0.21360809f, -0.02908160f, 0.04053841f, 0.41381660f, -0.03551713f, 
    -0.15285330f, 0.20728870f, -0.10737597f, 0.00210708f, -0.15945658f, -0.16405401f, -0.12842712f, -0.20280319f, 
    0.26549217f, -0.15462001f, 0.31346092f, -0.21174051f, -0.09439220f, 0.16088182f, -0.05467626f, 0.03489946f, 
    -0.03601994f, -0.11798117f, -0.15036857f, -0.05237015f, 0.11940798f, -0.09503053f, -0.10096288f, -0.04278946f, 
    -0.02373900f, 0.05550741f, 0.01228741f, 0.08967140f, 0.01805438f, -0.04047612f, -0.05813568f, -0.14544208f, 
    -0.31100652f, -0.18124329f, -0.11865938f, 0.13584080f, 0.04207827f, -0.07518096f, 0.03398509f, -0.02459249f, 
    -0.31517428f, -0.32385188f, -0.25354302f, -0.11307209f, -0.32108256f, 0.01282719f, -0.00420976f, 0.25828773f, 
    -0.01427275f, -0.09394239f, -0.06887601f, 0.00510963f, -0.10595024f, 0.06840553f, -0.09935462f, -0.08469968f, 
    0.07739040f, 0.03478044f, -0.08362666f, 0.07571854f, -0.01300406f, -0.09230929f, 0.11565421f, -0.17489240f, 
    -0.01803887f, -0.03086249f, -0.04431897f, -0.01921944f, -0.07945018f, -0.13036792f, 0.09640684f, 0.13501291f, 
    0.04706503f, 0.10699667f, -0.05496862f, 0.07765543f, -0.06473707f, -0.07646035f, 0.02652105f, -0.13661796f, 
    0.03996692f, 0.42209139f, 0.08420312f, -0.05668134f, -0.06175569f, 0.00626289f, 0.13467987f, -0.03099796f, 
    0.01768078f, 0.04351431f, 0.19580545f, -0.00455734f, -0.15503569f, -0.02802869f, 0.00304519f, -0.18705024f, 
    -0.11536087f, 0.08686955f, -0.08890463f, 0.03291893f, 0.00149111f, -0.02163807f, -0.18195625f, -0.08256207f, 
    -0.52832586f, 0.02284156f, -0.31086972f, 0.00245153f, -0.00475314f, 0.13386981f, -0.05731268f, 0.18295172f, 
    -0.10315410f, -0.09940016f, 0.12789097f, -0.10619736f, -0.19145344f, -0.06104077f, -0.10042980f, 0.12455778f, 
    0.16166814f, 0.13688348f, 0.00028710f, 0.14237800f, 0.18270260f, 0.22319409f, 0.06496010f, 0.17610797f, 
    0.14322400f, -0.18113770f, -0.15494822f, 0.04978212f, 0.07182329f, -0.11981214f, -0.17615484f, 0.03870649f, 
    -0.04304918f, -0.06241893f, -0.24965133f, -0.00453437f, 0.15197954f, 0.10464913f, -0.06351133f, -0.01132079f, 
    0.10208904f, 0.00953487f, 0.06280717f, 0.03742835f, -0.11451991f, -0.15699492f, -0.09920841f, -0.08604360f, 
    -0.06455370f, -0.12982509f, -0.04111381f, 0.12709045f, -0.07738075f, -0.07133146f, -0.11276679f, -0.01759431f, 
    0.05955262f, 0.13678417f, -0.04587647f, 0.15337482f, 0.18574986f, 0.00143488f, -0.05590099f, -0.03197464f, 
    0.08258365f, 0.18086198f, 0.09792051f, 0.02687823f, 0.08450006f, 0.00681255f, 0.05884824f, 0.08230759f, 
    -0.21956876f, 0.00414322f, -0.04199804f, 0.06585836f, 0.03270568f, 0.10393965f, -0.06312545f, 0.05025122f, 
    -0.02546366f, 0.05454201f, -0.03597727f, 0.19405220f, 0.02936707f, 0.09089115f, -0.10589818f, -0.09693031f, 
    0.01707335f, -0.02586814f, -0.06875286f, 0.06547574f, 0.06580874f, -0.07047134f, -0.12777223f, -0.26807588f, 
    0.07173445f, 0.01124986f, -0.00021507f, 0.23836777f, 0.08783675f, 0.00986138f, 0.06561798f, -0.01184852f, 
    0.13912557f, 0.22248943f, 0.13080877f, 0.29473621f, 0.16855511f, 0.01683067f, 0.20967400f, 0.07411037f, 
    0.06850860f, 0.10914237f, -0.04107483f, -0.07555377f, -0.20654407f, -0.15227664f, -0.01000616f, -0.13601328f, 
    -0.11541596f, 0.00297476f, 0.03423286f, 0.14089693f, 0.00027936f, 0.04846704f, -0.04703524f, -0.00432101f, 
    0.02900087f, 0.15774915f, 0.18941157f, 0.25176191f, 0.13766451f, 0.03568039f, -0.06592082f, -0.00530633f, 
    0.02996809f, 0.06038267f, 0.06711973f, 0.08291796f, -0.03360486f, 0.04647361f, 0.03060401f, 0.04671109f, 
    0.25876883f, -0.05831354f, -0.05952354f, -0.02285355f, 0.00648553f, 0.09467065f, -0.12632397f, 0.03779981f, 
    0.01135673f, -0.03951716f, 0.11659155f, -0.11336580f, -0.06069131f, -0.08349880f, -0.17295665f, 0.04962850f, 
    -0.00793510f, 0.02066046f, -0.12938309f, -0.01702824f, -0.15761697f, -0.01245441f, -0.22289246f, 0.03339043f, 
    -0.19156232f, -0.20654190f, 0.20049813f, -0.09116628f, -0.06178094f, -0.07796631f, -0.06795467f, 0.03097646f, 
    0.02671070f, 0.15521732f, -0.14536229f, -0.15789855f, 0.11946011f, 0.04925866f, -0.06213304f, -0.11132456f, 
    -0.04625381f, 0.12858078f, 0.18433090f, 0.03610359f, 0.00799667f, 0.21639700f, 0.15013517f, 0.18080734f, 
    -0.00517851f, 0.03780407f, -0.13598287f, 0.14000167f, -0.03313432f, 0.02161116f, -0.01856782f, 0.07146319f, 
    -0.08447171f, -0.02533591f, -0.07673611f, -0.00289451f, 0.05377237f, -0.02474733f, 0.03765711f, 0.05638207f, 
    -0.00892571f, 0.03004979f, -0.03439089f, 0.09915350f, -0.04389133f, 0.12209411f, 0.07257403f, 0.26092416f, 
    0.15561774f, 0.00379450f, -0.11471014f, -0.05227886f, 0.06135222f, 0.04327077f, -0.11535442f, 0.09462129f, 
    0.04128686f, -0.10917482f, 0.02242461f, -0.06988537f, 0.13984002f, -0.04218124f, -0.11567780f, 0.04069149f, 
    0.09013281f, -0.02755170f, -0.02473470f, 0.01488442f, 0.07641424f, 0.15719496f, 0.01870365f, 0.11089946f, 
    -0.40687796f, 0.17689744f, -0.27946827f, 0.33979639f, -0.06016456f, 0.16702457f, 0.17156753f, -0.00870645f, 
    0.19814615f, 0.23562771f, -0.04941034f, 0.23445831f, 0.04882786f, 0.18860772f, 0.03934579f, 0.06290841f, 
    0.04143654f, -0.06622772f, -0.14048086f, -0.01423052f, -0.02757661f, 0.01151682f, -0.03005991f, 0.03561531f, 
    -0.17275415f, 0.11533459f, 0.01856181f, -0.06546278f, 0.05488830f, 0.06516036f, -0.02905368f, -0.03345422f, 
    -0.23504263f, -0.11102881f, -0.02435369f, -0.18118072f, 0.19395283f, 0.25628158f, 0.01657068f, -0.01445563f, 
    0.11098153f, -0.11417878f, 0.15285993f, -0.08257178f, -0.09598681f, -0.07104567f, 0.10361845f, 0.18199685f, 
    0.10725155f, 0.12289859f, 0.06280518f, 0.11470626f, 0.05565920f, 0.10984463f, 0.08726364f, 0.01245278f, 
    0.05606918f, 0.20253848f, 0.17996101f, 0.17388193f, 0.13892102f, 0.14366944f, -0.12495493f, 0.28870386f, 
    0.07140080f, -0.02753914f, 0.05082983f, -0.09563851f, 0.01980784f, -0.03735065f, 0.08639173f, -0.03055146f, 
    0.01583316f, 0.04479920f, -0.02625322f, -0.02957091f, -0.06832188f, -0.10830643f, -0.02123210f, -0.06992600f, 
    -0.04242676f, -0.11786792f, -0.08905265f, -0.26362199f, 0.02538960f, 0.27856916f, -0.16032353f, -0.07659584f, 
    0.16480032f, 0.05934357f, 0.13785301f, -0.07753482f, 0.00418379f, -0.02404139f, -0.13526005f, 0.00161187f, 
    -0.22539429f, 0.05990923f, -0.03619701f, 0.01203560f, -0.09601135f, 0.14132296f, 0.08958612f, -0.09510105f, 
    -0.07765649f, -0.06562099f, 0.06376514f, 0.11634839f, 0.06690528f, 0.01172783f, -0.13540921f, 0.07090826f, 
    0.13191225f, 0.10391437f, -0.00278153f, -0.02421254f, -0.01285230f, -0.07013372f, -0.10376907f, 0.19572330f, 
    -0.18143703f, 0.13044772f, 0.17879003f, -0.18985371f, -0.08957699f, -0.18128590f, 0.03975859f, -0.06094198f, 
    -0.09931283f, -0.12809399f, -0.02487954f, -0.15133657f, 0.41815513f, -0.22253174f, 0.04298013f, 0.06511995f, 
    -0.01847190f, 0.03100012f, -0.02906442f, -0.01885821f, 0.03436314f, 0.02295391f, -0.02800529f, -0.00353159f, 
    0.05235725f, 0.18657422f, 0.16779470f, -0.20410012f, 0.09074846f, -0.00214333f, -0.07135932f, 0.02194704f, 
    -0.04411970f, 0.01407120f, -0.08884857f, -0.04182344f, -0.00835339f, 0.09583418f, -0.05747484f, 0.06659070f, 
    0.03723669f, 0.03788028f, -0.11604197f, 0.04387661f, -0.00560165f, -0.12940003f, 0.11126653f, 0.08255859f, 
    -0.11614028f, 0.06473415f, 0.01321586f, -0.09202491f, -0.05334017f, -0.05109081f, 0.04941527f, -0.09863564f, 
    -0.04126029f, 0.06260571f, 0.00310216f, -0.04914979f, 0.03452692f, 0.37089050f, -0.15394676f, -0.06858123f, 
    0.07141192f, -0.04906597f, -0.02175611f, -0.25311708f, -0.06896671f, -0.02461495f, -0.02931878f, 0.08824015f, 
    0.18640782f, 0.13383831f, -0.18265420f, -0.08706167f, 0.06094643f, 0.07002996f, -0.04118057f, 0.08281250f, 
    -0.08205495f, 0.00867842f, -0.00803409f, -0.03266012f, 0.19099428f, 0.07373084f, 0.11707122f, 0.20950113f, 
    -0.01726867f, 0.03441472f, 0.04686574f, -0.12980613f, -0.01193570f, -0.14582151f, -0.09285286f, 0.06130659f, 
    -0.03125677f, -0.24465482f, 0.31187296f, 0.07866950f, -0.17607275f, 0.03569204f, -0.01720075f, -0.03174915f, 
    -0.23977610f, -0.15527096f, -0.18617387f, -0.30605686f, -0.04602019f, -0.02378786f, 0.23744920f, -0.04690284f, 
    0.00322519f, 0.15935460f, 0.08196472f, -0.10204633f, 0.20995905f, -0.03795017f, 0.02982505f, 0.09501305f, 
    0.03493415f, 0.03926162f, -0.11964776f, -0.01450398f, 0.05990013f, 0.01284104f, -0.09180064f, -0.02787537f, 
    -0.13283536f, -0.15186279f, -0.09860905f, -0.16984755f, -0.18539387f, 0.03630158f, 0.13714844f, -0.00624978f, 
    0.02808891f, -0.02001774f, 0.07169037f, 0.10023766f, 0.07225797f, 0.14599529f, -0.04149899f, 0.12354103f, 
    0.05455116f, -0.00443789f, 0.01747283f, 0.19829895f, 0.02087665f, -0.07498042f, -0.01068064f, -0.02349530f, 
    0.05837938f, -0.04691427f, -0.10809559f, 0.02431531f, -0.10226429f, 0.18270610f, 0.01334524f, -0.16748364f, 
    -0.02466085f, 0.12709203f, -0.00264377f, 0.06428163f, 0.05445139f, -0.00066870f, 0.02648805f, 0.15832007f, 
    0.14526501f, 0.14609613f, -0.10431169f, 0.10412240f, -0.06574380f, 0.05486831f, 0.06419849f, 0.09630495f, 
    -0.08464382f, 0.10979353f, -0.01261456f, 0.07752017f, -0.04978056f, 0.00416469f, 0.14120597f, -0.18555261f, 
    0.08633242f, 0.01164917f, 0.03116544f, 0.20840095f, -0.13774848f, 0.25653270f, -0.15290418f, 0.00880696f, 
    -0.02137795f, 0.03742144f, 0.20542146f, 0.30489388f, -0.02909559f, -0.03826975f, -0.05495770f, 0.04678084f, 
    0.01865865f, 0.15661941f, -0.19980110f, 0.03700278f, 0.08875852f, 0.10758863f, -0.03920480f, -0.18446051f, 
    0.01944731f, 0.11152644f, 0.04438949f, -0.09292583f, 0.05144017f, 0.01821445f, -0.04244404f, -0.02123231f, 
    -0.07816554f, 0.09454178f, 0.01583616f, -0.16635910f, -0.04355855f, -0.10519525f, 0.08405861f, -0.01561794f, 
    -0.02089331f, 0.05612172f, 0.02435319f, 0.07830186f, 0.09217110f, -0.01547354f, -0.21710284f, -0.17022456f, 
    0.16191582f, 0.06225565f, 0.10472707f, -0.00915069f, 0.01772482f, 0.02536957f, 0.02407634f, 0.08388149f, 
    -0.16028346f, -0.09914298f, -0.00125242f, 0.08475429f, 0.03056453f, 0.09645914f, -0.03707999f, -0.04456045f, 
    0.04846111f, -0.18258476f, -0.02238869f, -0.00933306f, -0.14599842f, -0.14076002f, 0.03797194f, 0.05586229f, 
    -0.14986250f, -0.06032785f, 0.01366646f, 0.05631148f, -0.01252870f, 0.05164799f, -0.00323394f, 0.18452917f, 
    -0.05395360f, -0.00313709f, 0.00819851f, 0.28360727f, -0.05625196f, -0.00445106f, -0.01224685f, 0.07438566f, 
    -0.01250632f, 0.03975865f, 0.12845267f, 0.07366654f, -0.22234556f, -0.01110480f, 0.14226753f, -0.11387255f, 
    -0.07383341f, -0.07486236f, 0.05952702f, 0.14731365f, 0.04613766f, -0.07667978f, -0.09711003f, -0.16344289f, 
    -0.32765839f, -0.08951741f, -0.08801574f, 0.09328043f, -0.03298977f, -0.00440797f, 0.08448463f, 0.14046444f, 
    -0.04233498f, 0.04063562f, -0.06542634f, 0.08626896f, -0.19814146f, -0.31751981f, -0.49064457f, -0.13454466f, 
    0.08592163f, 0.20093082f, 0.18871434f, -0.06757049f, -0.02569706f, -0.02993605f, -0.03909804f, -0.00547980f, 
    -0.59099746f, 0.06652906f, -0.13335414f, 0.16919522f, 0.03874821f, 0.12594791f, 0.05700590f, 0.00573602f, 
    0.00173956f, 0.01042674f, -0.01472323f, 0.03452038f, -0.06448030f, 0.11344899f, -0.01781674f, -0.04344938f, 
    0.14033517f, -0.02348220f, 0.00797240f, -0.17018496f, 0.01664667f, 0.02409913f, 0.00319747f, 0.06089972f, 
    -0.04031626f, -0.15597911f, -0.11846609f, -0.14011192f, -0.11257766f, -0.12536229f, -0.01656667f, 0.06147605f, 
    0.09861858f, 0.06520654f, 0.01189034f, 0.03187170f, -0.06347033f, -0.17941527f, -0.00432660f, -0.19714072f, 
    0.22959879f, 0.01542558f, -0.02428870f, -0.00067790f, 0.00561396f, -0.07676737f, -0.00640272f, -0.06157161f, 
    0.15759768f, 0.19457142f, -0.00524806f, -0.07314271f, 0.00023904f, 0.17066607f, -0.13957797f, 0.09725679f, 
    0.05217331f, 0.05411002f, 0.02749172f, 0.04983636f, 0.17519784f, 0.31881511f, -0.17134506f, -0.11017074f, 
    -0.00485377f, 0.00012133f, 0.16091123f, 0.01144690f, 0.12515685f, -0.04703809f, 0.00560744f, 0.05728953f, 
    -0.10707345f, 0.00061210f, 0.32164231f, 0.25789377f, 0.01326118f, -0.03262442f, -0.06002268f, 0.06475963f, 
    0.10713518f, -0.06735463f, -0.06137956f, 0.13680938f, -0.05889983f, 0.12394501f, -0.10645911f, -0.02561579f, 
    0.02595997f, 0.03211420f, 0.01430370f, -0.11313809f, -0.06762108f, 0.02754967f, 0.03955368f, 0.01151968f, 
    0.20092306f, -0.15888993f, 0.06901142f, -0.07137305f, 0.00295152f, -0.02453605f, 0.02971728f, 0.07925612f, 
    0.09064072f, -0.02989754f, -0.06311372f, 0.08218812f, -0.08265193f, -0.04685267f, -0.06872293f, 0.00697837f, 
    0.03550779f, -0.02684467f, 0.03518280f, -0.02255338f, -0.07513543f, -0.02542342f, -0.08628269f, -0.03296904f, 
    0.24329180f, 0.02703454f, -0.07042742f, -0.11468158f, -0.09824803f, -0.01161831f, 0.06609369f, -0.10408229f, 
    0.19564968f, -0.09053817f, 0.00537704f, -0.02834926f, 0.06350109f, -0.06922762f, -0.05963329f, -0.06372578f, 
    0.04365923f, 0.03514393f, 0.11293311f, 0.10789900f, 0.06249768f, 0.13286658f, 0.03212553f, 0.02709628f, 
    0.00492897f, 0.03862093f, -0.03739776f, -0.04780469f, 0.06397545f, 0.07000475f, 0.02738934f, 0.01670008f, 
    0.02625422f, 0.08180449f, -0.04369930f, -0.01855066f, -0.04808511f, 0.20141856f, 0.08440860f, 0.04840587f, 
    0.00227469f, 0.06061604f, -0.01695122f, 0.07204770f, 0.02386462f, 0.04231235f, 0.02881597f, 0.03475522f, 
    0.11639614f, -0.07193630f, -0.16962966f, 0.03332606f, -0.05085693f, 0.00494520f, -0.02635977f, -0.02471763f, 
    0.03156221f, -0.02786147f, -0.07353114f, 0.04195675f, -0.07210436f, -0.15001714f, 0.11547349f, 0.09027900f, 
    -0.06856134f, -0.11889328f, -0.00912910f, 0.01488814f, -0.08086936f, 0.00097753f, -0.02255385f, 0.04917017f, 
    0.14757799f, 0.30097148f, 0.07075643f, -0.12381749f, -0.09491433f, 0.05287138f, 0.05271842f, -0.05821858f, 
    -0.08700552f, -0.09077477f, -0.11311527f, -0.10918453f, -0.18931894f, -0.01944549f, 0.05236851f, -0.15886055f, 
    -0.09412529f, -0.00774993f, -0.03554871f, 0.14832671f, 0.06260829f, -0.00859648f, 0.06010390f, 0.06345235f, 
    0.01948402f, -0.10783955f, 0.01301586f, 0.02189544f, 0.09091311f, 0.05072768f, -0.00145481f, 0.04641919f, 
    -0.12746048f, -0.08401792f, -0.13038655f, -0.10078067f, -0.01329405f, 0.18966091f, 0.09934291f, -0.01712884f, 
    0.05450940f, 0.03642870f, -0.10579509f, -0.01519410f, 0.05682090f, 0.04887510f, -0.00804870f, -0.14829284f, 
    -0.23814677f, 0.23462975f, 0.18869357f, 0.00431737f, 0.02461543f, -0.00179747f, 0.05074379f, 0.10554420f, 
    0.06454351f, 0.02145424f, -0.00106272f, 0.06139136f, -0.06197379f, -0.01189031f, -0.05060104f, 0.11733036f, 
    -0.00209970f, -0.14020927f, -0.00294716f, -0.03662306f, -0.18706563f, -0.04636332f, 0.07892758f, -0.01616655f, 
    -0.03626328f, 0.00772994f, -0.13325554f, -0.16122179f, -0.01433127f, 0.07166927f, 0.06470618f, -0.11039962f, 
    -0.09920296f, -0.08374681f, -0.03453292f, 0.04102036f, -0.15282148f, -0.01410913f, 0.08699413f, 0.18331474f, 
    0.01286020f, 0.00257796f, 0.02215036f, 0.06094975f, -0.02907771f, -0.09403762f, -0.03581724f, 0.02638504f, 
    -0.08158140f, -0.05227584f, 0.02854477f, 0.11412837f, 0.02657849f, -0.08081600f, -0.05944825f, -0.07264123f, 
    0.15703434f, -0.04982686f, 0.08477728f, 0.06157317f, 0.05981996f, 0.08241021f, 0.03319766f, -0.00619513f, 
    -0.05455548f, -0.04834203f, 0.04246496f, -0.18185867f, 0.00390776f, -0.09232334f, -0.14528789f, -0.10443073f, 
    -0.12316356f, 0.08815544f, 0.09518214f, -0.02616085f, -0.01176660f, 0.02410850f, 0.21901292f, -0.12836684f, 
    0.07350937f, 0.03775852f, -0.00989352f, 0.07530142f, 0.08891695f, 0.13614999f, 0.02373088f, -0.07641355f, 
    0.01886666f, 0.12008972f, 0.01953177f, 0.03703805f, 0.08720336f, 0.02578434f, 0.03356659f, 0.03332908f, 
    0.02663075f, -0.15363590f, 0.00411167f, -0.17903075f, 0.11927659f, 0.08076195f, -0.03306577f, -0.05715565f, 
    -0.00282773f, -0.19329946f, 0.06155786f, -0.24787956f, -0.01754258f, -0.18564263f, 0.03113105f, 0.10347369f, 
    0.04614874f, 0.02872304f, 0.04885581f, 0.03615550f, 0.01219952f, -0.07157528f, -0.06367633f, 0.04272830f, 
    -0.26972961f, -0.10725458f, -0.15578787f, -0.01504403f, 0.02511541f, 0.09416524f, 0.00781164f, -0.00850385f, 
    0.01472286f, -0.04021263f, -0.00552573f, 0.06809350f, 0.10941597f, -0.16246147f, 0.10596639f, -0.01780177f, 
    0.03374089f, -0.10544486f, -0.07021286f, 0.03385933f, 0.08186879f, 0.02562379f, -0.05925516f, -0.13928516f, 
    0.01672063f, 0.04988573f, -0.00243454f, -0.11898128f, 0.01399426f, 0.04614459f, -0.01237002f, -0.03632217f, 
    0.06632251f, 0.05137134f, -0.05449524f, -0.04398924f, 0.32160035f, 0.28830758f, 0.30941638f, -0.29888427f, 
    -0.00935973f, 0.01953827f, 0.02549950f, -0.08503822f, 0.03153548f, 0.04612203f, -0.06122412f, 0.03195631f, 
    -0.12248471f, -0.10279057f, 0.24265942f, 0.20553786f, 0.09963584f, -0.03351758f, -0.01026632f, 0.07935741f, 
    -0.00554539f, -0.09345231f, 0.16188741f, 0.13669309f, -0.07112531f, -0.17901486f, -0.04332129f, 0.11814240f, 
    0.00867012f, 0.01318407f, 0.01688457f, 0.13979346f, 0.03774011f, 0.09649566f, 0.01759479f, 0.03201173f, 
    0.14279775f, 0.00277151f, 0.01215667f, -0.09201482f, 0.11963398f, 0.07568890f, 0.13952637f, 0.00042576f, 
    0.16696405f, 0.03855805f, -0.10315394f, 0.00532747f, 0.33715171f, -0.00351768f, 0.13718450f, 0.01991754f, 
    -0.06226423f, -0.02500518f, -0.03076563f, 0.00906458f, 0.10740789f, 0.13364121f, 0.08388361f, 0.00994552f, 
    -0.30938551f, -0.13258819f, 0.23176219f, 0.22159402f, -0.16601619f, -0.09159588f, -0.05848996f, 0.11255386f, 
    -0.08523940f, -0.03907746f, 0.20049408f, -0.02665164f, -0.38653001f, 0.29251695f, 0.06565666f, 0.06625238f, 
    0.05609095f, 0.01672451f, -0.00262732f, 0.14189547f, 0.11699982f, 0.16926670f, -0.00513183f, -0.00054644f, 
    -0.13801573f, 0.10041165f, -0.03238213f, -0.06992495f, -0.04197466f, -0.01011995f, 0.01134600f, 0.19135325f, 
    -0.09676203f, 0.00830098f, -0.06144430f, 0.12450249f, -0.11038660f, 0.07681124f, 0.01224096f, -0.20040351f, 
    -0.08265912f, -0.14217718f, 0.25998521f, 0.20672876f, 0.13669205f, 0.12581693f, -0.00029165f, 0.00137828f, 
    -0.02429658f, -0.09227922f, -0.11455962f, 0.08979875f, 0.01665685f, 0.04606400f, -0.09269919f, 0.03592227f, 
    0.00606210f, -0.03406584f, 0.05840894f, -0.00961196f, -0.18068460f, -0.19879054f, 0.34003550f, 0.14958082f, 
    -0.02817531f, -0.12045839f, 0.17451824f, 0.20159560f, 0.04471881f, -0.02800668f, 0.00865266f, -0.01363215f, 
    0.04160145f, 0.16144527f, -0.18317616f, -0.15006797f, 0.05049494f, 0.16187824f, 0.10154647f, 0.08175258f, 
    0.08379114f, 0.09030624f, 0.08567465f, 0.07768461f, -0.07858568f, 0.12955382f, 0.27138525f, 0.00701460f, 
    0.00424075f, 0.09766244f, 0.01365193f, -0.03769548f, 0.06567992f, 0.00682991f, 0.00296737f, 0.00645090f, 
    -0.13473742f, -0.07981133f, -0.17390299f, -0.13683000f, 0.10453915f, 0.15530525f, 0.06183192f, -0.04034508f, 
    0.04032863f, 0.00002372f, 0.02017487f, 0.06103181f, 0.03341678f, -0.00053827f, -0.11649435f, -0.07145984f, 
    0.03613472f, 0.00890350f, 0.08805835f, 0.08629368f, -0.06348471f, 0.05308853f, -0.06292706f, 0.01331725f, 
    -0.10153230f, 0.07169281f, 0.07532212f, -0.02711594f, 0.01031057f, 0.07219660f, 0.17514370f, 0.14138740f, 
    0.00006297f, 0.07207213f, 0.03132105f, 0.05217646f, -0.08368011f, -0.11601859f, -0.09546030f, -0.10281529f, 
    0.05165320f, 0.13461284f, -0.09743359f, 0.01130477f, -0.05957347f, -0.06897301f, -0.07013971f, -0.07149751f, 
    0.05474416f, -0.11240500f, 0.04661080f, -0.03653167f, 0.14096555f, -0.02858125f, 0.01974035f, 0.03231177f, 
    -0.06972160f, -0.03022735f, 0.06989128f, 0.11246753f, -0.12583484f, 0.01193114f, 0.07549323f, 0.19326560f, 
    0.14084007f, 0.12448305f, 0.20617551f, 0.12733382f, -0.04162066f, 0.12111871f, -0.04510086f, -0.01937156f, 
    0.03106476f, -0.06308128f, -0.16579132f, -0.37910140f, 0.05007172f, 0.03426525f, -0.04003651f, 0.03375499f, 
    0.17339167f, 0.05799742f, -0.03526231f, 0.02294135f, -0.22786084f, 0.10308681f, 0.04278908f, 0.39448583f, 
    -0.00333468f, -0.03216634f, 0.02434625f, 0.01459378f, 0.11301050f, -0.15152445f, 0.12265690f, -0.08255674f, 
    0.31801346f, 0.11073864f, -0.22760336f, 0.07546810f, 0.12262580f, -0.06831510f, -0.05719177f, -0.03119450f, 
    0.12213214f, 0.11142806f, 0.18683062f, 0.15461349f, -0.29755589f, -0.18846561f, -0.12651993f, 0.09760332f, 
    0.02960940f, -0.01183415f, 0.07442560f, -0.09072994f, 0.00744610f, -0.01454368f, 0.12539950f, 0.11118528f, 
    -0.22616896f, -0.36300427f, -0.14605722f, -0.05386841f, -0.00976569f, 0.08956218f, 0.01830527f, -0.06932292f, 
    0.09503486f, -0.08305863f, 0.02542702f, 0.07511806f, -0.12295012f, -0.09768271f, 0.05872273f, 0.13265143f, 
    -0.11878119f, 0.02653726f, 0.09771563f, -0.06231897f, 0.01296450f, -0.06099115f, -0.03272279f, 0.09686092f, 
    0.03909193f, 0.34037307f, 0.10572878f, 0.02525642f, -0.01214173f, 0.10467022f, 0.00249019f, 0.03674955f, 
    -0.11533909f, -0.00757992f, 0.01446852f, 0.01688415f, 0.11103432f, 0.03410972f, -0.12519562f, -0.01667488f, 
    0.10044030f, -0.13485710f, 0.03562806f, 0.06103930f, 0.05496241f, 0.02598840f, -0.10397924f, -0.21192755f, 
    0.29073176f, -0.08305769f, 0.04633855f, 0.14709494f, 0.01034024f, 0.06350463f, -0.13934256f, -0.15567100f, 
    0.07885720f, 0.09900600f, 0.10568212f, 0.20801412f, 0.06570239f, -0.26321521f, 0.06773388f, -0.05491922f, 
    0.00686296f, -0.00787269f, -0.05843938f, 0.06479590f, 0.30579123f, 0.14566940f, 0.11180047f, 0.00234214f, 
    0.31445992f, 0.00576254f, -0.42947939f, -0.16521490f, 0.13185796f, -0.12295613f, -0.05877434f, 0.14343490f, 
    -0.01612723f, 0.02642471f, -0.03013117f, -0.19200720f, 0.32160485f, -0.18031275f, -0.01207543f, -0.15479468f, 
    0.10676181f, 0.07223295f, -0.02491869f, -0.02706998f, 0.00863552f, -0.07228743f, -0.05981641f, -0.03529686f, 
    0.10108538f, -0.12485550f, 0.03145882f, -0.33723351f, -0.07019240f, 0.14833325f, -0.01276934f, 0.03868348f, 
    -0.07837480f, 0.07860735f, 0.06578929f, 0.03859199f, -0.22128071f, -0.28995085f, -0.18643056f, -0.19880672f, 
    -0.06037192f, 0.02304804f, -0.11222415f, -0.19656718f, -0.00895130f, -0.04630851f, -0.04795599f, -0.11091168f, 
    -0.04246352f, -0.02157743f, -0.04634021f, -0.09484559f, 0.02343765f, 0.19650479f, 0.13288732f, 0.07965334f, 
    0.12246554f, -0.06754010f, -0.10721555f, -0.08791080f, 0.03395708f, 0.11925551f, 0.06797350f, -0.17521767f, 
    0.00942129f, 0.05817418f, 0.09962063f, -0.04663187f, -0.01411751f, -0.00920460f, -0.00734049f, 0.04531625f, 
    -0.16544080f, -0.03097039f, 0.04747554f, -0.13863978f, -0.06309056f, -0.00625309f, 0.14643341f, -0.02903036f, 
    -0.04075398f, 0.01493531f, -0.05917191f, -0.01717533f, 0.17870155f, 0.17393579f, -0.09618700f, 0.14600597f, 
    0.08272637f, 0.14740862f, 0.17671758f, -0.02232946f, 0.07398382f, 0.14858429f, 0.02202410f, 0.08945142f, 
    0.04263669f, 0.08757814f, 0.11156008f, -0.13160878f, 0.08022410f, -0.03091094f, -0.01883021f, 0.01301917f, 
    0.10761941f, 0.05975987f, 0.13453880f, -0.02653914f, 0.27179033f, 0.01087078f, 0.21599025f, -0.01170004f, 
    -0.04483927f, -0.00367853f, -0.03984851f, -0.01301074f, 0.03975406f, 0.00648153f, 0.24645990f, -0.12785514f, 
    0.22120911f, -0.33089444f, 0.10712638f, 0.03911537f, 0.06323446f, 0.11891912f, -0.02606484f, -0.00819115f, 
    0.04533081f, -0.00734615f, -0.01014509f, 0.03556307f, 0.08706357f, 0.06706187f, 0.02390740f, 0.01003138f, 
    -0.01917941f, -0.03661320f, 0.00881324f, -0.00972955f, 0.11155503f, 0.19140099f, 0.11896870f, 0.14977923f, 
    0.00269526f, 0.17997600f, 0.11288115f, -0.10263637f, -0.06544471f, -0.18342331f, 0.08555483f, 0.05604246f, 
    0.18752772f, -0.01378652f, -0.10176846f, 0.06064245f, -0.30161363f, -0.01601968f, -0.09663109f, 0.16019870f, 
    0.04211458f, -0.06653339f, 0.00091923f, 0.04399007f, -0.00616912f, -0.00319301f, -0.07180857f, -0.02791121f, 
    0.17437528f, 0.03142165f, 0.08487576f, 0.00111556f, -0.01859140f, 0.00205459f, -0.06575022f, 0.04135321f, 
    0.19668368f, 0.02884465f, 0.14809552f, 0.02128987f, -0.10042790f, -0.21208303f, 0.10320557f, -0.04752408f, 
    0.05826433f, 0.05584871f, 0.13803004f, 0.08640753f, 0.07174623f, -0.04106129f, -0.11643010f, 0.12020557f, 
    0.04489710f, 0.06299746f, 0.27087346f, 0.01851699f, 0.04566776f, -0.00444108f, -0.09033373f, -0.05238641f, 
    0.06941881f, 0.07188503f, -0.02330056f, -0.08414733f, -0.00251325f, 0.17755999f, -0.10826704f, -0.12497365f, 
    0.04906011f, 0.01767785f, 0.06754152f, 0.00147623f, -0.11769209f, 0.04177277f, -0.00256225f, 0.14526440f, 
    -0.14963493f, -0.06450175f, 0.05426609f, -0.11917136f, -0.12314662f, -0.02535900f, -0.10291021f, -0.03510995f, 
    0.09684891f, 0.12196846f, 0.10396525f, 0.13776742f, -0.04292248f, 0.11701575f, -0.23314334f, 0.15047814f, 
    0.01347227f, -0.15044382f, 0.03486649f, 0.05619302f, -0.02764494f, 0.17034982f, 0.04405943f, -0.04745331f, 
    0.22005260f, 0.06512856f, 0.09033792f, -0.04629848f, 0.01864325f, 0.02079437f, 0.02793104f, 0.00820857f, 
    0.10117742f, 0.12943098f, 0.19891755f, 0.00546165f, -0.05416559f, -0.05288814f, 0.02542663f, 0.00232866f, 
    -0.03760602f, -0.07727223f, -0.00676616f, 0.07400741f, -0.03636703f, 0.04535304f, 0.03814930f, 0.05561099f, 
    -0.24458601f, -0.07535397f, -0.04459564f, 0.09567309f, 0.02954170f, 0.06773903f, -0.00813865f, -0.02590772f, 
    -0.00921564f, -0.03537339f, 0.06397526f, -0.04277929f, 0.17206125f, -0.01183892f, -0.01268531f, -0.00115997f, 
    0.05470733f, -0.09876975f, -0.04241044f, -0.00442783f, 0.04009005f, 0.00468699f, -0.11775436f, -0.15999502f, 
    0.11457998f, -0.04356745f, 0.10035737f, -0.02878845f, 0.05768393f, -0.04343328f, 0.04192305f, -0.02045458f, 
    0.12926067f, -0.07354895f, 0.02433700f, 0.09706181f, -0.02832249f, 0.02517105f, -0.09695495f, 0.15036710f, 
    0.13207866f, -0.10227340f, -0.02876016f, -0.00702678f, 0.11404928f, 0.01587111f, 0.11393968f, 0.04539105f, 
    -0.09555588f, 0.05831771f, 0.08443315f, 0.02649150f, 0.12170994f, -0.00972242f, -0.02777433f, 0.02479183f, 
    0.16739537f, 0.03484353f, 0.11935412f, 0.01357867f, -0.15211457f, -0.06745249f, -0.01950962f, -0.00779459f, 
    -0.03757183f, -0.03867545f, 0.01678470f, -0.05262647f, 0.06594355f, 0.05953254f, 0.06962261f, -0.02934342f, 
    -0.27688870f, -0.09615122f, -0.11829361f, -0.04330085f, 0.01849657f, 0.01213400f, -0.04816984f, -0.01545198f, 
    -0.08680078f, -0.06290386f, -0.01680224f, 0.04180160f, -0.21625854f, -0.15033403f, 0.15070409f, -0.06876406f, 
    -0.06599814f, 0.04151623f, 0.10127617f, -0.00581197f, 0.05707250f, 0.05211056f, 0.03250267f, 0.00881623f, 
    -0.03950953f, -0.14648211f, -0.14577992f, -0.01031910f, 0.12186053f, 0.10019437f, 0.30524862f, -0.07909744f, 
    0.18035899f, 0.01097803f, 0.02810782f, 0.18019779f, 0.08837131f, 0.20853978f, -0.15136921f, 0.06610971f, 
    0.04028016f, 0.06927934f, -0.05376108f, 0.03595847f, 0.08552557f, 0.03602861f, 0.01988229f, -0.04643911f, 
    0.00476562f, -0.05432656f, 0.14915110f, -0.20337166f, 0.06481445f, -0.02110810f, 0.02309018f, -0.09360863f, 
    -0.00320776f, -0.04749261f, -0.06406225f, -0.08257891f, -0.14773561f, 0.23463136f, -0.07421701f, -0.07768643f, 
    0.14802521f, 0.06637123f, 0.11410031f, 0.04312332f, -0.00759220f, 0.11537743f, -0.07254405f, -0.02390614f, 
    -0.14149322f, -0.08623741f, 0.08597991f, -0.13140838f, 0.00384902f, 0.05819488f, 0.08073899f, 0.14981994f, 
    0.03881764f, 0.05665771f, 0.13884833f, 0.17715997f, -0.36478165f, 0.05982325f, 0.28649959f, -0.10754878f, 
    -0.09320343f, -0.09464955f, 0.01091990f, 0.05567747f, -0.02686142f, 0.18705963f, 0.07012670f, 0.07086048f, 
    0.14882965f, 0.09010457f, -0.05267120f, 0.08473293f, 0.04675322f, 0.08924044f, -0.06472033f, -0.03275711f, 
    0.06773685f, 0.10612839f, -0.01530951f, 0.06692046f, 0.03084749f, -0.03279111f, -0.23051992f, -0.04456646f, 
    0.06707136f, -0.05778689f, 0.00024318f, -0.01687878f, 0.06537475f, 0.03442593f, -0.09947670f, 0.23797430f, 
    0.41932726f, -0.06719210f, 0.11829259f, -0.02429248f, 0.01530689f, 0.06038241f, 0.10571415f, 0.17673312f, 
    0.03195995f, 0.10424189f, 0.21049294f, 0.01144356f, 0.27963206f, 0.05249761f, -0.03387108f, -0.01333683f, 
    -0.00216952f, 0.06354238f, -0.09334697f, 0.06332703f, 0.09906394f, 0.10131530f, 0.06188686f, -0.06370626f, 
    0.25808868f, 0.03221523f, -0.09410698f, 0.00814491f, 0.05668004f, 0.02492897f, 0.06967084f, 0.00531091f, 
    -0.03210049f, 0.02668804f, -0.17162801f, 0.01769797f, 0.22008096f, 0.06128886f, -0.02793454f, 0.19691463f, 
    0.06506466f, 0.04776969f, 0.10857510f, -0.15320101f, 0.14355394f, 0.02818349f, 0.15593871f, 0.18634909f, 
    0.09670222f, -0.28048861f, 0.16042729f, 0.25380787f, -0.04992380f, -0.01489831f, -0.15488665f, 0.14548422f, 
    -0.01855727f, 0.16261402f, 0.25306606f, -0.06509190f, 0.09906368f, -0.39012095f, 0.00436131f, 0.11381625f, 
    0.09892146f, 0.01798354f, 0.00952878f, 0.17675856f, -0.02035671f, 0.03050702f, 0.02535362f, 0.22284739f, 
    0.02568905f, 0.04539801f, 0.30636308f, -0.17968184f, 0.11436632f, 0.00904575f, -0.01219752f, 0.00829447f, 
    0.05183119f, 0.17870092f, 0.00190455f, 0.09543058f, 0.11089283f, -0.09513815f, -0.00100455f, -0.07166358f, 
    0.14226207f, -0.11437300f, 0.04500245f, 0.21460141f, 0.11875658f, 0.10473052f, 0.14123659f, -0.16769424f, 
    -0.18201342f, -0.17601125f, 0.30780447f, 0.18661846f, 0.04467169f, 0.02838857f, -0.07240504f, -0.04400150f, 
    -0.02200379f, -0.09522717f, 0.04289052f, -0.06135559f, -0.14202830f, -0.23973624f, 0.23724163f, -0.05779435f, 
    -0.03390894f, -0.15357967f, -0.04395879f, 0.11207525f, 0.00016854f, 0.22616674f, 0.19855148f, 0.17654452f, 
    0.05432492f, -0.03053944f, 0.02078612f, -0.09535072f, -0.03396037f, 0.06032147f, 0.06432560f, 0.07055663f, 
    -0.04689826f, -0.05632493f, 0.01338081f, -0.03274904f, 0.13429058f, -0.10719109f, -0.05764324f, -0.08089729f, 
    0.00308025f, 0.29741806f, -0.07154626f, 0.01963928f, 0.03732524f, -0.06086486f, 0.29279795f, 0.17755954f, 
    -0.19481339f, -0.26987487f, -0.13463691f, -0.17803459f, 0.03554969f, -0.04183649f, -0.02900733f, -0.06804279f, 
    0.01151524f, -0.02244722f, -0.10598416f, -0.03910305f, 0.14341937f, 0.14210059f, 0.03174956f, 0.01976514f, 
    0.01090165f, -0.04647143f, 0.02378435f, 0.08816232f, 0.00684525f, -0.03269982f, 0.09338591f, 0.06348228f, 
    0.19916487f, 0.04531844f, 0.03798287f, 0.06098712f, 0.01920054f, 0.06234629f, 0.04255303f, 0.04362552f, 
    0.16039948f, 0.07791539f, -0.14033774f, -0.06140018f, 0.31963503f, -0.17720737f, -0.01591433f, 0.09047252f, 
    0.01734923f, -0.02109640f, -0.04337412f, 0.24908805f, 0.03172364f, 0.11266707f, 0.06998585f, 0.06598596f, 
    -0.13508114f, -0.12961151f, 0.13355145f, 0.11243626f, -0.04942863f, -0.04063797f, 0.12955588f, -0.02934575f, 
    -0.00370425f, 0.06552711f, -0.09324235f, -0.10525338f, 0.25266138f, -0.00115661f, 0.08897049f, 0.01673111f, 
    0.06802465f, -0.08513194f, 0.02500053f, -0.01203417f, 0.02543180f, 0.12197170f, -0.08148947f, -0.03230013f, 
    -0.22921905f, -0.24911188f, 0.24783321f, -0.14653508f, -0.01831991f, -0.07339250f, -0.11342040f, 0.16227029f, 
    -0.08039854f, 0.09714644f, -0.10045684f, 0.07141900f, 0.21104814f, 0.09961228f, 0.15290152f, 0.04960260f, 
    0.04772536f, -0.06693279f, 0.04154909f, -0.21216218f, 0.08687977f, 0.04594070f, 0.00478378f, -0.06769437f, 
    0.30269456f, 0.18610176f, 0.30456835f, -0.07432890f, 0.13799196f, -0.08614069f, 0.01436867f, -0.16602953f, 
    -0.00379321f, 0.05821738f, 0.04539704f, -0.09532068f, 0.37693453f, 0.06552342f, 0.18141398f, 0.23156771f, 
    0.03406448f, 0.05990672f, 0.14242910f, 0.05258668f, 0.05586373f, 0.03366861f, -0.06496415f, -0.06465182f, 
    -0.09501591f, 0.04310946f, -0.14508684f, 0.41423017f, -0.03172839f, 0.05907327f, -0.12395124f, 0.10338513f, 
    -0.07825246f, -0.05590990f, 0.04626358f, 0.21392438f, 0.11354019f, -0.14448847f, 0.01129554f, -0.15169834f, 
    0.09628919f, -0.04637643f, -0.08795195f, -0.04096225f, 0.05201365f, -0.08660041f, -0.11846314f, 0.00822158f, 
    -0.22873741f, -0.39558664f, -0.36777541f, -0.04211374f, -0.04174728f, -0.02698998f, -0.05198629f, 0.07922426f, 
    -0.03430666f, -0.08044147f, -0.01254771f, 0.06036282f, -0.02567500f, 0.03292491f, 0.17411828f, 0.20397541f, 
    -0.09782927f, -0.03049068f, -0.01503677f, -0.01744379f, 0.16262612f, 0.09441800f, 0.09355000f, 0.13587475f, 
    -0.22042698f, 0.07758909f, 0.21578903f, 0.15999106f, -0.06343122f, -0.05274911f, 0.00292978f, 0.17273521f, 
    -0.06074091f, -0.07653119f, -0.04744944f, -0.10555018f, 0.24021691f, 0.20871824f, -0.12625244f, 0.18432401f, 
    0.03555217f, -0.07135309f, 0.15688312f, 0.04151439f, 0.01896323f, -0.03809189f, -0.05615493f, 0.03264704f, 
    -0.25011173f, 0.18641046f, -0.02989362f, 0.37421960f, 0.01069182f, 0.00665155f, -0.02129261f, 0.03664328f, 
    0.09893756f, -0.06010547f, 0.04598275f, -0.04104107f, 0.18049780f, 0.28675881f, 0.16469346f, -0.06800794f, 
    0.14102547f, 0.14115340f, 0.04136656f, 0.15243155f, 0.05800561f, -0.02074595f, 0.01788748f, 0.02126693f, 
    0.03457692f, -0.06697994f, -0.08028105f, 0.14988610f, 0.02861332f, 0.12416369f, -0.05392534f, -0.15539010f, 
    0.01039747f, 0.01126397f, -0.12519407f, -0.19933765f, 0.17480457f, -0.01348957f, -0.15712067f, -0.03241994f, 
    0.18868713f, 0.10717899f, 0.15422876f, 0.10571773f, 0.11493718f, 0.07877043f, -0.04392749f, -0.04550568f, 
    0.18516849f, 0.16668710f, -0.09853569f, -0.10061960f, 0.11622091f, 0.07243095f, -0.11988053f, 0.06164952f, 
    -0.09323154f, -0.02103239f, -0.14213838f, 0.00341618f, -0.06962663f, -0.06717370f, -0.14518875f, -0.15411927f, 
    0.00217466f, -0.03177902f, -0.25075230f, 0.07041409f, 0.05076060f, -0.01762355f, 0.06968252f, 0.13947342f, 
    0.00093099f, -0.28807464f, 0.05067267f, 0.04946671f, -0.05542604f, -0.08601286f, 0.01695647f, 0.11098434f, 
    0.07102237f, 0.02552436f, 0.06057198f, 0.14956097f, 0.42884269f, -0.22787932f, -0.05030475f, 0.20596310f, 
    0.00080131f, 0.03317728f, -0.03971481f, 0.08452901f, -0.02349286f, -0.02263458f, 0.06830462f, 0.05493522f, 
    0.26438576f, -0.12314540f, -0.56257790f, 0.47890645f, 0.01075576f, -0.13599290f, 0.12837243f, 0.01607445f, 
    0.04435718f, -0.08909624f, -0.06374002f, 0.26089552f, 0.05043672f, -0.17441833f, -0.12619257f, -0.03774246f, 
    0.02759006f, 0.02206758f, 0.12508897f, 0.12410822f, 0.11798231f, -0.12245610f, 0.05036070f, 0.02416340f, 
    0.17855613f, 0.24104786f, -0.17093176f, -0.02747663f, -0.05225276f, 0.08367562f, -0.11620001f, -0.00266624f, 
    0.02789932f, 0.06494620f, -0.10666948f, -0.22451654f, 0.34720701f, -0.03959614f, 0.30788833f, -0.13711374f, 
    0.14606445f, 0.03920412f, 0.00500899f, 0.00818853f, 0.04749715f, 0.01336787f, -0.07326116f, 0.03233149f, 
    0.14519413f, -0.24137133f, -0.07155745f, -0.00685800f, 0.04739904f, 0.12268824f, 0.02051136f, -0.07153567f, 
    0.07635325f, -0.15946920f, 0.11865901f, -0.14569554f, -0.06074547f, 0.16003519f, 0.15844630f, 0.05008693f, 
    -0.03600120f, -0.02787150f, 0.06700747f, 0.12078146f, -0.07575292f, 0.02208709f, 0.12238480f, 0.08057254f, 
    0.23954305f, -0.07009038f, -0.43737218f, -0.01421598f, 0.01440851f, -0.00663808f, 0.06361795f, 0.01777544f, 
    0.14045270f, -0.01895915f, 0.07704180f, -0.01420717f, 0.06520771f, 0.07588707f, 0.01810410f, -0.00650544f, 
    -0.02706504f, -0.04843938f, -0.12084167f, 0.03795759f, -0.11950343f, -0.04045511f, -0.02467472f, 0.08223590f, 
    0.14325093f, -0.03163218f, -0.03742255f, -0.12847714f, 0.04063509f, 0.04253175f, 0.04440019f, 0.08153445f, 
    0.00020772f, -0.06935096f, 0.04300865f, -0.18399754f, -0.35137776f, -0.09147218f, -0.10673176f, 0.06959655f, 
    0.06154375f, -0.12696387f, 0.04189596f, -0.01905817f, 0.08840809f, -0.05610095f, -0.01423332f, 0.01729240f, 
    0.02805687f, -0.16263600f, -0.15100020f, -0.00653525f, 0.04761710f, 0.07759651f, 0.01196782f, 0.01129733f, 
    0.10168604f, 0.03491311f, -0.04726083f, 0.13078460f, -0.18299207f, 0.09006488f, 0.05157728f, 0.00765802f, 
    -0.03134022f, -0.09594522f, 0.08029453f, 0.14614925f, 0.06062407f, -0.00418775f, 0.13431662f, 0.06296204f, 
    -0.33517003f, 0.10441881f, -0.05592862f, 0.09145673f, 0.02440654f, -0.00613829f, 0.13112251f, -0.08918335f, 
    0.02300750f, -0.01263774f, -0.03371596f, 0.18079175f, 0.01532928f, 0.03261914f, -0.02941335f, 0.07126963f, 
    0.10331438f, -0.07048716f, -0.03438630f, 0.00951013f, 0.09637316f, -0.00874759f, 0.02330908f, -0.03596234f, 
    0.11545724f, -0.28685066f, -0.01234074f, 0.08626133f, 0.10210268f, 0.07561693f, -0.07378697f, -0.04572769f, 
    -0.00539564f, -0.11573033f, -0.09225551f, -0.15488461f, 0.06539603f, -0.18796657f, 0.20873699f, -0.06188262f, 
    -0.04921350f, -0.00526805f, 0.02338304f, 0.10966378f, 0.05557206f, -0.11114854f, -0.09408528f, 0.20745423f, 
    -0.27862987f, -0.13785321f, -0.20415418f, 0.05445982f, 0.04423996f, 0.00841618f, 0.00290677f, -0.03353153f, 
    0.10034561f, -0.03411364f, 0.20189483f, 0.05387861f, 0.07096637f, 0.07310858f, 0.13064070f, -0.08536401f, 
    0.04402469f, 0.07635233f, 0.07282408f, 0.02801021f, 0.08379274f, -0.18346670f, 0.11325970f, 0.03814569f, 
    0.05957490f, 0.11556864f, 0.15718701f, 0.05192763f, 0.03591387f, -0.00641463f, 0.13040459f, -0.28831592f, 
    0.21177308f, -0.07564863f, 0.00478139f, 0.02054882f, 0.06056587f, 0.24887915f, 0.15272868f, -0.02437839f, 
    -0.03116756f, -0.00963891f, -0.13536747f, -0.01753869f, -0.08051482f, -0.00867577f, 0.17265417f, -0.06090083f, 
    0.20315774f, -0.25833064f, 0.26096404f, -0.12602593f, 0.00746774f, -0.04705283f, 0.15322500f, -0.00660554f, 
    -0.17779826f, 0.04752743f, 0.04823058f, -0.06558486f, -0.23484331f, -0.04123149f, -0.06310796f, 0.18872580f, 
    0.06084118f, 0.10582621f, 0.03631398f, -0.03105398f, 0.06737577f, -0.06269583f, -0.10279527f, -0.00527420f, 
    0.41343981f, -0.16946341f, 0.24639215f, 0.20395741f, 0.03614447f, -0.01025131f, -0.04784200f, 0.08775147f, 
    0.02623460f, -0.07118797f, -0.02071235f, -0.06194101f, 0.00716444f, -0.20438924f, -0.24895957f, 0.04975250f, 
    -0.04822167f, 0.03361588f, 0.02314745f, 0.06156634f, 0.11007163f, 0.10526753f, -0.05965661f, -0.01319667f, 
    -0.27952677f, -0.17330305f, -0.07404229f, -0.26050434f, -0.02169172f, -0.05885181f, 0.09497887f, 0.14539392f, 
    -0.12362407f, -0.13157651f, -0.04788043f, 0.16987219f, -0.12230372f, -0.11459431f, -0.20182396f, -0.16888893f, 
    -0.03469137f, 0.09308191f, 0.01680508f, 0.00619869f, -0.09943607f, -0.08396508f, -0.19795972f, 0.00105393f, 
    -0.10460354f, -0.13242801f, -0.05780458f, 0.00804216f, 0.03515420f, -0.11054607f, 0.01520758f, 0.00994776f, 
    -0.03368002f, -0.00764630f, -0.12933974f, 0.09600134f, 0.37346029f, -0.29854146f, 0.28111973f, 0.05806812f, 
    0.09878501f, -0.10711686f, 0.06254222f, -0.05333438f, -0.04654812f, 0.12219184f, 0.04339223f, -0.10087347f, 
    0.12868023f, -0.03195766f, -0.36389500f, 0.14458637f, -0.01609785f, -0.12591656f, 0.08361177f, 0.08579199f, 
    -0.04181030f, 0.06557205f, -0.14480768f, -0.01116896f, 0.03665339f, -0.23896770f, -0.35322854f, 0.07361259f, 
    -0.11153506f, -0.06432588f, 0.11563171f, 0.11911383f, 0.06809386f, 0.03472710f, 0.05650042f, -0.15186062f, 
    0.02291198f, -0.21926834f, 0.20268402f, 0.34154624f, 0.02500461f, -0.07341745f, -0.03328742f, 0.11514436f, 
    -0.12241225f, 0.10668182f, 0.16008236f, 0.05717836f, -0.35243374f, 0.05145105f, -0.11861013f, -0.21232113f, 
    0.14482649f, 0.08837843f, -0.08991497f, 0.16889758f, 0.04711918f, 0.00824165f, 0.04546537f, 0.00399152f, 
    0.13022290f, -0.09644214f, 0.39806184f, 0.08904034f, -0.06304009f, 0.07521032f, -0.00554155f, -0.11720486f, 
    0.08845171f, -0.02791863f, -0.09031576f, -0.12581144f, 0.13528921f, 0.00929634f, 0.37653103f, 0.05940765f, 
    0.11482480f, 0.11857630f, 0.04622372f, 0.05526597f, 0.04415343f, 0.16372724f, -0.11932980f, 0.17297196f, 
    0.12968913f, -0.12633567f, -0.03013036f, -0.10756471f, -0.08558369f, -0.03723805f, 0.03185763f, -0.02992445f, 
    0.10690181f, -0.13219509f, 0.11742831f, -0.02912020f, 0.05197555f, -0.12674901f, 0.01163519f, 0.00540104f, 
    -0.00365179f, -0.05179862f, 0.10692377f, 0.03425846f, -0.00919310f, 0.02350540f, -0.02343461f, -0.08472393f, 
    0.00221275f, 0.00227536f, 0.23321691f, -0.19646169f, -0.03878343f, 0.00414646f, 0.03631113f, -0.12512080f, 
    0.04907687f, -0.04658425f, 0.08427840f, 0.16329327f, -0.27893165f, 0.00117347f, -0.27303934f, -0.13446110f, 
    -0.00612144f, 0.01902522f, -0.00878853f, 0.02986160f, 0.31007382f, 0.02754234f, -0.16401939f, -0.00297353f, 
    0.14126417f, 0.05873225f, -0.03465202f, 0.13359912f, 0.18586725f, -0.00494401f, 0.02669246f, 0.18996896f, 
    0.07578944f, 0.04863028f, -0.01256670f, -0.02382519f, -0.10077910f, 0.11065418f, -0.10560167f, 0.19249530f, 
    0.00383904f, -0.00170807f, 0.12780605f, 0.08416039f, -0.01367378f, 0.06582024f, -0.10834593f, -0.00076468f, 
    -0.05182469f, 0.02081372f, 0.02452884f, -0.16194116f, 0.00711406f, 0.04805764f, 0.05332809f, -0.02001219f, 
    0.17637177f, -0.04504766f, 0.03446674f, -0.01634959f, 0.16554902f, -0.27493834f, -0.14601952f, 0.26905546f, 
    0.01175912f, 0.04763245f, -0.00247443f, 0.05195164f, 0.00969089f, 0.00095846f, 0.06905532f, -0.12041382f, 
    -0.12274726f, 0.26954135f, -0.53422892f, 0.14998041f, 0.10907435f, 0.01995724f, 0.01708032f, 0.02141560f, 
    -0.06975600f, -0.00838958f, 0.19930927f, 0.05565952f, 0.26465741f, -0.19744445f, 0.07047971f, 0.22952412f, 
    -0.02374258f, -0.13867787f, -0.00831281f, 0.06948631f, -0.02089543f, 0.04222812f, -0.01261204f, -0.09696060f, 
    0.13604496f, 0.12964624f, 0.16430177f, -0.00118991f, 0.08486982f, -0.03731115f, 0.04122909f, -0.07244934f, 
    0.01800542f, 0.04514663f, 0.05236954f, 0.06734725f, -0.13912837f, -0.05576482f, 0.12614088f, 0.14441404f, 
    -0.11512707f, -0.00647076f, 0.00558408f, -0.04591127f, 0.06586036f, -0.09483964f, 0.23778768f, 0.05971789f, 
    0.08242949f, 0.15939659f, 0.23236090f, -0.07719023f, -0.04251047f, 0.04553283f, 0.07565904f, 0.20889953f, 
    -0.19295947f, 0.04101861f, 0.07500118f, 0.12638861f, -0.25183719f, -0.25730479f, 0.17139277f, 0.00868170f, 
    -0.12625882f, 0.10206582f, -0.02816652f, -0.07500251f, 0.10757150f, 0.04953720f, 0.09452529f, 0.01500251f, 
    -0.73442048f, -0.38338253f, -0.26358756f, -0.11650357f, -0.14882998f, -0.01672592f, -0.11337911f, 0.02381593f, 
    -0.01072455f, -0.12103930f, -0.08817507f, 0.05801589f, 0.06402384f, 0.06153241f, -0.11290435f, -0.00073726f, 
    -0.03601218f, 0.06983833f, 0.03003260f, -0.02796135f, -0.04535483f, -0.00869552f, -0.06433625f, 0.01072802f, 
    0.12608297f, 0.04888632f, 0.25234392f, -0.16963635f, -0.08010878f, 0.08890165f, 0.10524862f, -0.08437254f, 
    -0.02934720f, 0.14532095f, -0.08891973f, -0.02477754f, 0.01026163f, 0.02906214f, -0.02497661f, 0.06280615f, 
    0.01487358f, -0.02290344f, -0.12389830f, 0.03801143f, -0.05873492f, 0.02151755f, -0.01965224f, -0.10901418f, 
    -0.04965410f, 0.00153014f, 0.21274829f, 0.03764891f, -0.03111317f, 0.02964417f, 0.10306234f, 0.04933877f, 
    -0.00289669f, -0.04305064f, 0.03764281f, 0.13777465f, -0.32304963f, -0.16363844f, -0.19032235f, -0.02692129f, 
    -0.08603300f, 0.11073373f, -0.16175421f, 0.10613962f, 0.07406914f, -0.05633264f, 0.20286089f, -0.00062002f, 
    -0.15965217f, -0.08673860f, -0.05391467f, -0.34164488f, -0.18735598f, 0.09255178f, 0.04490420f, 0.13948767f, 
    -0.12216472f, 0.10663361f, 0.05452095f, 0.02659289f, 0.55718994f, 0.04788231f, -0.00224452f, -0.25212571f, 
    -0.11485363f, 0.14788251f, 0.01320148f, -0.12823689f, -0.08191939f, -0.09939860f, -0.04537570f, -0.02777460f, 
    0.02030269f, 0.04907465f, 0.21116336f, -0.09373536f, -0.19284202f, 0.03993332f, 0.04265833f, -0.02487874f, 
    -0.09017347f, -0.02001437f, 0.01144074f, -0.07885247f, -0.06481379f, -0.24181758f, -0.15924539f, -0.02247002f, 
    -0.08306152f, -0.18969533f, -0.21315929f, -0.19498868f, -0.11334296f, -0.12340317f, -0.05211864f, -0.09099568f, 
    0.07087365f, 0.04652127f, -0.06197033f, -0.03509640f, 0.00506744f, -0.22743009f, 0.02047676f, -0.05337864f, 
    -0.09275687f, -0.11593869f, -0.04415582f, -0.14809810f, 0.21421173f, -0.03723644f, -0.00341941f, 0.00222952f, 
    -0.05231759f, -0.05415080f, -0.03627535f, -0.10802371f, -0.00477518f, 0.04205558f, 0.02019149f, -0.01156081f, 
    -0.15609227f, 0.14682944f, -0.01270526f, 0.03267808f, -0.12226088f, -0.09625562f, -0.01898436f, -0.06132429f, 
    0.08897687f, 0.11434831f, -0.06472719f, -0.00957406f, 0.56398040f, 0.09263385f, 0.04327125f, -0.11598177f, 
    0.07193402f, -0.03227432f, 0.08233828f, 0.02067745f, 0.03300192f, 0.04913381f, -0.07110120f, -0.16619326f, 
    -0.10334519f, 0.17870757f, 0.14562380f, 0.06658100f, 0.02725744f, 0.09779233f, 0.04475079f, 0.06151415f, 
    -0.02033687f, -0.07202235f, -0.00445349f, 0.03726350f, 0.24984020f, 0.15051186f, 0.06705111f, 0.02533393f, 
    -0.13253470f, -0.02754091f, 0.02775614f, 0.01379957f, 0.07566153f, -0.04746545f, 0.05225686f, -0.00835405f, 
    0.38300875f, 0.08363685f, -0.01637058f, 0.19052723f, -0.05750099f, -0.02318021f, 0.12932047f, 0.09009326f, 
    -0.00375097f, 0.04631731f, -0.02689262f, -0.06497683f, 0.09646821f, -0.02916364f, 0.00735410f, 0.03212528f, 
    -0.05079512f, -0.07153101f, 0.02603478f, 0.05432354f, 0.12555410f, 0.15799463f, 0.06031939f, 0.13132581f, 
    0.25726974f, -0.20805427f, -0.13462411f, 0.00957401f, 0.12889311f, -0.16406262f, -0.06577770f, 0.06922842f, 
    -0.00012808f, -0.17583109f, -0.13715211f, -0.07819274f, -0.24323282f, -0.01256487f, -0.20991208f, 0.20604691f, 
    -0.04471786f, -0.05228024f, -0.05549677f, 0.01883397f, -0.04543909f, 0.03548238f, -0.02795140f, -0.09676734f, 
    0.03439425f, 0.06321938f, 0.09359954f, 0.02634582f, -0.03078755f, -0.01375449f, 0.04906990f, 0.06639548f, 
    0.07791102f, 0.02836670f, 0.15227404f, 0.06956762f, 0.12990333f, -0.19139090f, -0.17507504f, 0.14197852f, 
    0.01849841f, 0.17666847f, 0.06430645f, -0.02521284f, 0.01579270f, -0.00466077f, 0.03447547f, 0.02439697f, 
    0.37531257f, 0.05029187f, -0.10053088f, 0.17965116f, 0.02827789f, -0.02070160f, -0.02992475f, 0.03462696f, 
    0.00545526f, -0.03491324f, 0.07448526f, -0.00327329f, -0.05229555f, -0.04069883f, 0.09082291f, 0.02460169f, 
    0.05032169f, 0.00483580f, 0.03286448f, 0.06399936f, 0.00799543f, 0.05289679f, 0.07047990f, 0.00590705f, 
    -0.14251448f, 0.30802506f, 0.13579428f, 0.05558471f, -0.15309596f, 0.06670287f, -0.02707395f, -0.13303240f, 
    0.13137801f, 0.02734027f, -0.04821416f, 0.14417566f, -0.09488852f, -0.18119194f, 0.03546867f, -0.27088121f, 
    -0.17620976f, -0.14619453f, 0.05223290f, -0.11768739f, -0.01615425f, -0.05386437f, -0.02980201f, -0.20771816f, 
    0.08500017f, 0.12747478f, 0.00873528f, -0.02312798f, 0.05810291f, 0.07006062f, 0.02993209f, 0.01227045f, 
    0.18202463f, 0.24380895f, 0.20548481f, 0.23332626f, 0.07310689f, -0.23936842f, 0.00992020f, 0.07666671f, 
    -0.00798057f, 0.06870166f, 0.00259540f, -0.02994498f, -0.05284995f, 0.10185632f, 0.08496001f, 0.03362618f, 
    -0.12410791f, -0.23328325f, 0.23835237f, -0.11242757f, 0.04676454f, 0.01144293f, 0.04703994f, -0.12462021f, 
    0.01658419f, 0.03714755f, 0.06691958f, -0.03748739f, 0.07162698f, 0.02719266f, -0.08772139f, 0.09907784f, 
    0.01955511f, -0.04210617f, 0.03231834f, 0.06881676f, 0.06504741f, -0.09048790f, -0.04435347f, 0.01551946f, 
    0.12416712f, 0.01399137f, 0.12265413f, -0.01548968f, 0.05363182f, -0.03985592f, 0.05348095f, -0.11374050f, 
    0.07548381f, 0.01007063f, -0.01766930f, -0.00514184f, -0.22172357f, -0.12675969f, -0.11743831f, -0.00967643f, 
    -0.08529738f, 0.21505636f, -0.00357262f, 0.11604402f, -0.12776993f, -0.09404936f, 0.11147795f, 0.11783244f, 
    0.28497338f, 0.07459147f, -0.15182255f, 0.23895958f, 0.01661607f, -0.08346565f, -0.00673010f, 0.08250316f, 
    -0.03430278f, 0.14106043f, -0.04393772f, 0.04215063f, -0.01173453f, -0.07877320f, 0.01516665f, 0.27486926f, 
    -0.08378365f, -0.01798437f, 0.13646767f, -0.09481993f, -0.10898236f, 0.06446789f, 0.03056757f, 0.14433962f, 
    -0.47607246f, -0.16296475f, 0.09604888f, -0.15141089f, -0.15055956f, -0.06175848f, -0.18859819f, -0.07855552f, 
    -0.15343231f, -0.10888524f, -0.13833022f, -0.03146787f, -0.09754467f, -0.13717866f, -0.06169792f, 0.23855893f, 
    -0.03834384f, 0.05171679f, 0.03220147f, -0.02574643f, 0.09959050f, 0.02766909f, 0.05735403f, -0.01961225f, 
    -0.04788324f, -0.01830387f, -0.18653974f, 0.10828446f, 0.03969532f, 0.13053547f, 0.13520259f, 0.12131282f, 
    0.37551370f, 0.01174163f, -0.11142551f, 0.09017699f, 0.01547022f, -0.01513140f, -0.00583417f, 0.13885078f, 
    0.11246520f, -0.05190555f, 0.00956320f, -0.01749860f, 0.06349076f, -0.05347233f, -0.04775126f, 0.12680930f, 
    0.08772956f, 0.19837773f, 0.03907558f, -0.07800035f, -0.11866181f, 0.03651209f, -0.03273513f, -0.04153615f, 
    -0.05962866f, -0.04693171f, 0.00962664f, 0.08370354f, 0.20943490f, 0.07009448f, 0.05126624f, 0.08010145f, 
    0.11771692f, -0.01234932f, 0.21029672f, -0.02487690f, 0.03075522f, 0.12504843f, 0.08473388f, 0.09799989f, 
    -0.05586181f, -0.00755115f, 0.36305571f, 0.44057733f, 0.07074820f, 0.14299756f, 0.06484157f, -0.06818308f, 
    -0.04231507f, 0.09229828f, 0.06347835f, -0.00311206f, 0.05869205f, 0.43627304f, 0.17335340f, 0.00552660f, 
    -0.02534451f, -0.11092771f, 0.01722753f, -0.00124077f, 0.04580096f, 0.18442154f, -0.05725264f, -0.03679840f, 
    0.04460903f, 0.02007129f, 0.07107544f, 0.02818323f, 0.01749003f, -0.05598868f, 0.11755660f, -0.02238695f, 
    0.15528134f, -0.03042318f, 0.10004853f, -0.04168638f, -0.27103826f, 0.01869824f, 0.09531476f, 0.13830833f, 
    -0.12292363f, 0.08347124f, -0.02695336f, 0.07283025f, -0.03939556f, -0.08371047f, -0.07343472f, 0.10997186f, 
    0.55432838f, 0.00975292f, -0.09378976f, 0.20869030f, 0.01107738f, 0.13013761f, 0.24352580f, -0.03708650f, 
    0.01114102f, 0.01599498f, 0.11944719f, -0.02684940f, 0.36018458f, -0.03845664f, -0.15837690f, 0.03932015f, 
    0.07944445f, -0.00716276f, 0.01058478f, 0.05953517f, -0.03512781f, 0.13746782f, 0.00541065f, -0.00717177f, 
    -0.12281484f, 0.13845800f, 0.15047751f, -0.00746934f, -0.10604143f, -0.00009235f, 0.08336201f, 0.03630573f, 
    0.02013434f, -0.03775243f, -0.08309036f, -0.06689098f, -0.19465134f, -0.15774837f, 0.09872366f, -0.19706486f, 
    -0.01471265f, -0.04622599f, 0.28930601f, -0.00576687f, 0.13707170f, 0.21007963f, 0.02668048f, 0.04336769f, 
    -0.59271038f, -0.02749710f, -0.03485638f, -0.03177452f, -0.01173205f, 0.16689485f, -0.11335431f, 0.06946367f, 
    0.10669830f, -0.01973124f, 0.10154282f, -0.04351092f, -0.19542077f, -0.11295262f, -0.23290537f, -0.10986355f, 
    -0.06164198f, -0.05706883f, 0.00677749f, 0.15321115f, 0.06446247f, 0.04472275f, -0.04274506f, 0.04107862f, 
    0.05146639f, 0.00107506f, -0.01121321f, 0.12376708f, 0.10930813f, 0.03589111f, -0.03679747f, 0.01417303f, 
    0.01269218f, 0.17826046f, 0.06344360f, -0.09728819f, -0.27653044f, -0.04280874f, -0.06092539f, 0.19099376f, 
    0.02625655f, 0.12727234f, 0.11151819f, 0.09582543f, 0.05856299f, -0.07569984f, 0.02333560f, -0.09022243f, 
    -0.23107794f, -0.18278128f, -0.25418547f, 0.12337790f, 0.19171102f, 0.04198273f, -0.07483651f, -0.14394397f, 
    -0.04240983f, -0.01991458f, 0.08956117f, 0.01735056f, -0.45999235f, 0.03388407f, 0.13773580f, 0.06923374f, 
    -0.04293552f, -0.14666326f, -0.08988083f, 0.05523963f, -0.08925046f, -0.05172197f, 0.03170172f, -0.01324408f, 
    0.27582586f, -0.04181315f, -0.00126359f, -0.02283534f, -0.09750233f, 0.07339595f, 0.06023294f, -0.08831950f, 
    -0.12202013f, 0.00408874f, -0.03644401f, -0.05990214f, 0.25196972f, -0.13253327f, 0.04203979f, -0.00873659f, 
    0.11835655f, 0.21346506f, 0.01966211f, -0.12693092f, 0.19439596f, -0.15386660f, 0.10667580f, 0.07422638f, 
    -0.10127218f, 0.00636402f, 0.03323323f, 0.07194686f, -0.03636171f, -0.11768623f, -0.03190707f, -0.13652644f, 
    -0.09147321f, -0.06567331f, -0.11336411f, -0.12315685f, 0.12383843f, -0.00343062f, 0.11321585f, -0.12789673f, 
    -0.07725636f, 0.02646735f, 0.01424971f, -0.03995865f, 0.15358160f, 0.14581703f, -0.04305203f, 0.09701663f, 
    0.32096729f, -0.06303753f, 0.07868659f, 0.08451597f, 0.07386257f, -0.06393263f, 0.06658044f, -0.05554302f, 
    0.20753245f, 0.01256849f, -0.02528254f, 0.24259654f, -0.12849326f, 0.13681415f, -0.06203839f, 0.01568197f, 
    -0.07822850f, 0.16102186f, 0.09728333f, 0.18857846f, 0.01150447f, 0.10204954f, -0.04928959f, 0.13083781f, 
    -0.39137706f, -0.24004906f, -0.27547967f, -0.10514531f, 0.02832800f, 0.00171406f, 0.10397735f, -0.02138264f, 
    -0.01797859f, 0.04937758f, 0.05225553f, -0.08273146f, -0.15618230f, 0.10747065f, 0.01980362f, 0.23644085f, 
    0.00866285f, 0.05594369f, 0.08747080f, 0.07668091f, 0.10611182f, 0.18053852f, -0.03996983f, 0.06149281f, 
    -0.00990676f, -0.00551081f, 0.03287188f, 0.03431398f, 0.01055748f, -0.01932353f, 0.00154708f, 0.00879324f, 
    -0.03988375f, -0.02948370f, -0.00752645f, -0.02936902f, 0.01903616f, 0.02433211f, -0.03242559f, -0.01951786f, 
    -0.01805336f, 0.01242954f, 0.00714242f, -0.01952351f, 0.01620698f, -0.02988881f, -0.01423186f, 0.01040228f, 
    -0.00850182f, -0.01786092f, -0.02815739f, -0.00817448f, 0.00677380f, 0.02680309f, -0.03624308f, -0.02504596f, 
    0.01188165f, -0.00804274f, -0.01061626f, -0.02104393f, 0.00498086f, 0.00941351f, 0.00015040f, 0.00635314f, 
    0.00595640f, -0.02314389f, 0.01334941f, -0.03339980f, -0.00185126f, 0.01039058f, -0.00737326f, 0.00532274f, 
    0.01567031f, 0.02495687f, 0.02732055f, 0.00490510f, -0.02829148f, -0.01228440f, 0.00614623f, -0.03919519f, 
    -0.00684112f, 0.01232906f, -0.01933355f, -0.02716505f, -0.03205696f, -0.01352689f, -0.01798254f, -0.03639856f, 
    0.01586332f, 0.02159131f, -0.02216608f, 0.01146070f, -0.01058010f, 0.01755340f, -0.00743494f, -0.03257051f, 
    0.02593376f, 0.03340832f, 0.02999320f, 0.01607592f, -0.02628520f, -0.01022492f, -0.01347452f, 0.02584167f, 
    -0.04280208f, 0.00551123f, 0.00538271f, -0.02977545f, -0.03961534f, 0.01362729f, 0.02953582f, -0.00079639f, 
    -0.02374581f, -0.00062822f, 0.00216492f, 0.02062931f, -0.02023491f, -0.01979478f, 0.01847423f, -0.02371383f, 
    -0.02446945f, 0.00398557f, -0.00336477f, 0.00705036f, 0.02288671f, 0.01216862f, -0.00747265f, -0.00456753f, 
    0.00691477f, 0.02657951f, 0.02196771f, -0.02260568f, 0.00557230f, 0.00013919f, -0.01499425f, 0.00353544f, 
    0.03279747f, -0.01869975f, 0.01857335f, -0.00582852f, -0.01763985f, 0.00073670f, -0.04210388f, -0.00621854f, 
    -0.02752366f, -0.02274199f, 0.00454429f, -0.02823021f, -0.01346932f, -0.02101697f, -0.01791386f, -0.02445345f, 
    0.01940154f, -0.01637685f, -0.03069894f, 0.00877193f, 0.00422968f, 0.01793732f, 0.02497166f, -0.00266159f, 
    0.01053131f, -0.02241741f, 0.01708438f, -0.00972801f, -0.00740175f, -0.02114105f, -0.01543898f, 0.01147395f, 
    0.02901679f, -0.02652704f, -0.03147609f, -0.01876365f, -0.01164734f, 0.01553036f, -0.02908556f, 0.00903382f, 
    0.01642662f, 0.01092943f, 0.00677258f, 0.00086907f, -0.00915471f, 0.01478223f, -0.01545787f, -0.01814958f, 
    0.02283121f, 0.02655786f, -0.03876396f, 0.02822733f, -0.03169635f, -0.03476106f, -0.03139096f, 0.00430684f, 
    0.00746185f, -0.00658406f, 0.00801883f, 0.00974041f, -0.03685439f, -0.01563385f, -0.00248501f, 0.00109153f, 
    0.00356127f, 0.02648195f, 0.00076867f, 0.01714834f, -0.03387564f, 0.01038383f, 0.02162416f, -0.01553378f, 
    0.01112346f, -0.02298653f, -0.01757231f, 0.00492983f, 0.01134044f, 0.01689538f, 0.02164410f, 0.01209562f, 
    -0.00661032f, -0.03452833f, 0.01672460f, 0.02575595f, 0.01897134f, -0.00495756f, -0.00429825f, -0.00562059f, 
    0.01690506f, -0.02240927f, 0.03000125f, -0.03392865f, -0.00505541f, -0.00257716f, 0.02909661f, 0.00252759f, 
    -0.01739844f, 0.01029083f, -0.00809750f, -0.00030142f, -0.02078958f, 0.00149660f, 0.02054036f, 0.01360059f, 
    -0.01778183f, -0.00043994f, 0.00475104f, -0.01726984f, 0.00577717f, -0.03539808f, -0.00435612f, 0.00883660f, 
    -0.02337988f, 0.01494618f, -0.01629834f, 0.02451137f, 0.02498252f, 0.02337350f, 0.01625269f, -0.03226432f, 
    0.00198691f, -0.00248170f, -0.02687572f, -0.02765182f, -0.00606889f, 0.02218672f, -0.02488658f, -0.00111871f, 
    0.02841099f, 0.01363525f, 0.02767361f, -0.00606897f, -0.04385917f, 0.01870845f, -0.01896754f, 0.01900117f, 
    0.01361234f, -0.00777450f, -0.04399760f, 0.01426814f, -0.03063371f, -0.03146745f, -0.02598982f, -0.00316367f, 
    0.01610934f, -0.01198969f, -0.02520913f, -0.03180463f, -0.03142235f, -0.00357576f, 0.01584786f, 0.00123651f, 
    -0.00372936f, -0.04280131f, 0.02490804f, 0.00386499f, -0.00470048f, -0.01243571f, 0.00481018f, 0.00545433f, 
    0.02861608f, -0.02559295f, 0.00837072f, 0.02729974f, -0.03458088f, 0.01663611f, 0.02104107f, 0.01494202f, 
    -0.00830246f, 0.01725818f, 0.00524052f, -0.03655197f, -0.01209471f, 0.02052850f, -0.01495450f, -0.01722916f, 
    0.02116578f, -0.01703604f, -0.02582566f, -0.03666460f, -0.03003482f, -0.02733081f, 0.01981132f, -0.02189001f, 
    0.02727407f, -0.03401496f, -0.02040361f, 0.00796100f, -0.02249735f, 0.01637916f, -0.01134823f, -0.03749566f, 
    0.01703325f, -0.00980153f, 0.02701660f, -0.03184612f, 0.00714329f, -0.02642509f, -0.00558789f, 0.02289439f, 
    -0.03547659f, 0.01780736f, 0.01954379f, 0.00433584f, 0.02638964f, -0.01639288f, 0.01297789f, 0.01661544f, 
    -0.01404649f, 0.01491945f, -0.01776543f, 0.03717733f, -0.01363472f, -0.00427737f, 0.01744890f, -0.02720996f, 
    0.02842790f, 0.02278636f, 0.02201333f, 0.01077685f, 0.02415437f, -0.02865130f, -0.00180577f, -0.01748343f, 
    -0.02397212f, -0.00845525f, -0.00075945f, 0.00689707f, 0.00717190f, -0.02197262f, 0.00101413f, 0.02361409f, 
    -0.03368353f, -0.02518567f, 0.03278996f, 0.01182718f, 0.02189197f, -0.00583050f, 0.00605988f, -0.03265157f, 
    -0.00812955f, 0.02877084f, -0.00145055f, 0.03419794f, 0.02918470f, 0.01466007f, 0.00322135f, 0.02921990f, 
    0.00670915f, -0.00926114f, -0.00773617f, -0.00650210f, -0.03011064f, 0.00161191f, -0.01233340f, -0.00690796f, 
    0.02117355f, -0.03182860f, 0.02680557f, 0.01537369f, -0.00778832f, -0.01199890f, -0.02007294f, -0.01730044f, 
    -0.00016297f, 0.02655580f, -0.02417592f, -0.02261739f, 0.02173130f, -0.04226214f, -0.00682516f, -0.01365261f, 
    -0.02692670f, 0.01090282f, -0.03911283f, -0.00828075f, 0.01080016f, -0.00855222f, -0.03252947f, -0.02232196f, 
    0.00817402f, 0.01051386f, -0.04059549f, -0.03100907f, -0.03965449f, -0.04033848f, -0.01196666f, -0.02526482f, 
    0.01611861f, 0.02228997f, -0.01734097f, -0.02668239f, -0.03639473f, 0.00386643f, -0.01682915f, 0.01467868f, 
    -0.03272939f, -0.03516074f, 0.00071794f, 0.01329078f, 0.01883532f, -0.00038966f, -0.02447505f, -0.01825145f, 
    0.02071065f, 0.01275029f, 0.00594465f, 0.02937447f, 0.03130036f, 0.01506726f, -0.01916639f, 0.03205546f, 
    -0.02979961f, -0.04090678f, 0.02087310f, -0.03598675f, -0.01998468f, 0.01588533f, -0.00127917f, 0.02317526f, 
    0.03059235f, 0.01328740f, -0.02929099f, 0.00639248f, -0.00797134f, -0.01652712f, 0.01286048f, -0.00399377f, 
    0.02116496f, 0.01804917f, -0.02541181f, -0.03745578f, -0.03261493f, -0.03754246f, 0.00031948f, -0.01887708f, 
    -0.00629053f, 0.01340445f, 0.00481181f, -0.02043290f, 0.01974065f, 0.01047214f, -0.03959870f, -0.00925012f, 
    -0.02299566f, -0.02619742f, 0.00957950f, -0.00024321f, 0.02495782f, 0.01888306f, -0.00912909f, -0.03829211f, 
    0.01315724f, 0.02758090f, -0.03063600f, 0.01829023f, -0.02700920f, 0.02266789f, -0.03870846f, 0.02944638f, 
    0.02009555f, -0.01576905f, 0.01554948f, -0.00824248f, -0.02342360f, -0.02740443f, -0.00814697f, 0.01125673f, 
    -0.03709419f, -0.03536410f, 0.01226581f, 0.00215142f, -0.02045039f, 0.02615737f, -0.00190025f, -0.00522701f, 
    -0.02418018f, -0.03098256f, -0.00405489f, 0.02115944f, -0.01860991f, 0.01135296f, -0.00436847f, 0.03116291f, 
    -0.00415051f, 0.01384774f, 0.01417896f, -0.01588640f, -0.02611318f, -0.03652168f, -0.02144935f, 0.00444369f, 
    -0.00944665f, -0.01052216f, -0.00124094f, 0.01030057f, 0.02296699f, -0.03314242f, 0.00398065f, 0.00553311f, 
    0.02627689f, -0.01860654f, 0.03740174f, -0.00798659f, 0.02178136f, -0.00615471f, 0.01399013f, -0.00597490f, 
    -0.01466462f, 0.02004361f, 0.00390268f, -0.00368694f, -0.03346241f, -0.02177164f, 0.01866495f, 0.00716244f, 
    -0.02028003f, 0.02877593f, 0.02441608f, 0.02082964f, -0.02718241f, -0.03691212f, -0.01017297f, -0.01315647f, 
    -0.03804540f, -0.02376151f, 0.00610722f, -0.00573311f, 0.00589648f, -0.00686393f, 0.01338930f, -0.04164094f, 
    -0.03359398f, -0.01683986f, -0.00616569f, -0.02031585f, -0.01672723f, -0.01734658f, -0.01911151f, 0.01779560f, 
    0.02132974f, -0.02475978f, -0.03200035f, 0.01394624f, -0.04150385f, 0.03026753f, 0.01116441f, -0.03314254f, 
    0.01350942f, -0.01310981f, -0.00194994f, -0.00806468f, -0.03123604f, 0.00362436f, 0.02746112f, -0.03194432f, 
    0.01203933f, -0.02177364f, 0.02640760f, 0.02953511f, -0.02716276f, -0.03228382f, -0.01913878f, 0.00942358f, 
    0.03089192f, -0.03429046f, 0.02943800f, -0.00268655f, -0.00411151f, 0.02657051f, -0.01018176f, -0.00264474f, 
    0.00566337f, -0.02808726f, 0.00991091f, -0.00969641f, -0.01131254f, -0.03313810f, 0.00636519f, 0.00218629f, 
    -0.04079362f, 0.01120038f, -0.01768166f, 0.01739117f, -0.00348123f, -0.00931652f, 0.00557419f, -0.00840485f, 
    -0.02414942f, -0.00726327f, -0.01165031f, -0.01379792f, -0.00784327f, -0.02378373f, 0.02702875f, 0.01670079f, 
    0.01391224f, -0.00262822f, -0.02525966f, -0.04020576f, 0.01544165f, -0.02921944f, 0.01869731f, -0.00350120f, 
    -0.02357475f, 0.00550333f, -0.01405586f, -0.00880306f, 0.02588018f, -0.03755155f, 0.02727505f, -0.03535490f, 
    -0.00252818f, 0.02287209f, 0.01991966f, -0.02649014f, -0.03611299f, -0.03840214f, 0.02583959f, -0.02390442f, 
    0.00272607f, -0.00099579f, 0.02026126f, 0.00838802f, -0.03906480f, -0.00702311f, 0.01543653f, 0.02544180f, 
    -0.00575731f, 0.01346766f, 0.02687103f, -0.02378570f, -0.03332241f, -0.01334040f, -0.01787342f, 0.00329875f, 
    -0.00894638f, -0.02847389f, -0.01958661f, -0.00363761f, 0.01981569f, -0.00968504f, -0.00093118f, -0.00165974f, 
    0.01614622f, -0.03473880f, 0.03229108f, 0.01714269f, 0.02177273f, -0.02583923f, 0.02722662f, 0.03646549f, 
    0.00307422f, 0.01922675f, -0.02300712f, -0.02126866f, 0.01480568f, 0.02207209f, -0.03650725f, 0.02674300f, 
    -0.03455381f, -0.02771681f, -0.03096439f, 0.01324306f, -0.04014269f, -0.02145446f, -0.03546157f, 0.02107417f, 
    -0.00874806f, -0.01353468f, -0.00579237f, -0.01165172f, -0.02823220f, -0.03404232f, 0.00096325f, -0.01628363f, 
    -0.03942126f, -0.04173965f, 0.02111867f, 0.03224732f, -0.00968153f, 0.01016069f, -0.00650157f, -0.01635610f, 
    -0.00589745f, -0.02992566f, 0.02508127f, -0.01179089f, -0.03231468f, -0.03121333f, 0.02780940f, 0.01048462f, 
    -0.00551867f, -0.03027252f, -0.03686457f, -0.02338448f, -0.02955310f, -0.02850308f, 0.00210658f, 0.02816784f, 
    -0.00064332f, 0.02509094f, 0.03635399f, 0.02349916f, -0.02612482f, -0.00587227f, 0.02254013f, -0.03879737f, 
    0.02039848f, 0.02033594f, -0.03892479f, 0.01950576f, 0.03134135f, -0.01771639f, -0.00483644f, 0.01997624f, 
    -0.02095507f, -0.00601775f, 0.01245258f, 0.02081394f, 0.00831036f, -0.01462086f, -0.01014722f, -0.00640954f, 
    -0.03186705f, -0.01429319f, 0.01867147f, -0.01398984f, -0.01009642f, -0.02031972f, 0.02240176f, -0.01263016f, 
    -0.00989366f, -0.01981705f, -0.02348867f, -0.00082954f, -0.00333540f, -0.02873775f, -0.03221750f, 0.01735955f, 
    0.02651956f, -0.01712644f, -0.01554739f, 0.02779661f, -0.04182655f, 0.01952478f, 0.02456179f, -0.02878988f, 
    -0.01466515f, -0.02985518f, -0.00044059f, -0.02631374f, -0.00546626f, 0.01222991f, -0.01865007f, 0.02342248f, 
    0.02968911f, 0.01716749f, 0.02260960f, 0.01537909f, 0.02082111f, 0.02840482f, -0.02205752f, -0.02801909f, 
    0.03701274f, 0.01905038f, 0.03204525f, -0.02492988f, -0.02499670f, -0.01144354f, -0.01474012f, 0.02917993f, 
    0.02913309f, -0.02313465f, 0.00283622f, 0.01053202f, -0.04172525f, -0.02668076f, -0.01132448f, -0.03960120f, 
    0.02609691f, -0.00615351f, -0.03782225f, 0.01714863f, -0.02921099f, 0.00701630f, -0.02640819f, -0.01892431f, 
    -0.03492171f, 0.02992939f, -0.01364140f, 0.01944903f, 0.01558264f, 0.01099292f, 0.02748006f, -0.03274722f, 
    -0.01037001f, 0.02386386f, 0.01335604f, 0.00753279f, -0.01999534f, 0.02955481f, -0.04191433f, -0.02987104f, 
    -0.00460578f, -0.04071154f, -0.01515881f, 0.00530533f, 0.02058309f, 0.01294188f, -0.03728182f, -0.02143681f, 
    -0.01488402f, 0.02737270f, 0.02946074f, 0.02794314f, -0.02382585f, -0.00888710f, 0.01372486f, -0.00697646f, 
    -0.03611170f, -0.03699298f, -0.03862879f, -0.02551362f, 0.02103039f, -0.03027994f, -0.02456752f, -0.03842362f, 
    -0.01086115f, 0.00871903f, 0.00306740f, -0.01660552f, 0.00490531f, -0.01108867f, -0.03419458f, 0.02469621f, 
    -0.01970486f, -0.03315054f, -0.01601338f, -0.03872249f, -0.01639686f, -0.01510868f, 0.02604249f, 0.00271773f, 
    0.00719205f, 0.02237527f, 0.00326868f, -0.03900307f, -0.01612071f, -0.03931322f, 0.03652709f, -0.00998485f, 
    -0.01893240f, -0.01647108f, 0.03358512f, 0.01201274f, 0.00459778f, -0.01964194f, 0.01019054f, -0.00741303f, 
    -0.02764880f, 0.00196992f, -0.02407378f, -0.01323405f, 0.02536958f, 0.02073890f, 0.02639524f, -0.02199271f, 
    -0.01256609f, 0.01927939f, 0.02882019f, 0.02139906f, -0.00269921f, 0.01834143f, 0.00928325f, -0.00490164f, 
    -0.01857628f, 0.01537607f, 0.00474211f, 0.01995980f, 0.03808188f, -0.02654962f, -0.00758804f, 0.00242745f, 
    0.01795445f, 0.02913588f, -0.00020015f, 0.01357251f, -0.03852068f, 0.02636024f, -0.01575222f, 0.01243860f, 
    0.01815702f, 0.03270258f, -0.02951219f, -0.03713914f, -0.00527378f, -0.00363105f, -0.03234280f, 0.02587499f, 
    -0.01230106f, 0.00870741f, 0.03009028f, 0.02611220f, 0.00588991f, -0.03800555f, -0.03166804f, -0.02563866f, 
    -0.01966577f, -0.01960339f, 0.00352687f, -0.02924007f, -0.02741635f, 0.03376821f, 0.00277062f, -0.01548401f, 
    -0.02808585f, -0.01772220f, 0.02893043f, -0.01597974f, -0.01898384f, 0.00453721f, -0.03535748f, -0.01791482f, 
    -0.01333646f, 0.02451275f, 0.00947459f, -0.00495852f, 0.01049442f, 0.02065947f, 0.02769079f, 0.03832477f, 
    -0.02700779f, -0.01573174f, 0.00119503f, -0.04077693f, -0.00636306f, 0.03826256f, 0.02905521f, -0.00487395f, 
    -0.02890735f, 0.02371413f, -0.01757522f, -0.01426949f, -0.00927685f, 0.02361255f, -0.00227380f, 0.01764445f, 
    0.00721545f, 0.01979145f, 0.01736666f, 0.02754301f, 0.01316904f, -0.02299752f, -0.00544954f, 0.02235769f, 
    -0.02208784f, -0.04195412f, 0.01736689f, -0.02600311f, -0.00876522f, -0.01185034f, -0.01726511f, -0.03482262f, 
    -0.03882652f, -0.03241969f, -0.01214641f, -0.02250791f, 0.03159412f, 0.00875022f, 0.01677331f, -0.02341455f, 
    -0.03261023f, -0.04085443f, 0.01646480f, 0.02445049f, 0.01002567f, -0.00769954f, -0.03795341f, 0.01452624f, 
    -0.00013313f, -0.03302524f, -0.00420218f, -0.01550749f, -0.00788762f, -0.01845501f, 0.01927978f, 0.00541777f, 
    0.01886304f, 0.02663348f, -0.02565857f, 0.01449859f, 0.00277752f, -0.02421087f, -0.02819222f, 0.01816184f, 
    -0.02607438f, -0.02361418f, -0.03335638f, 0.03602817f, -0.00305003f, -0.01666037f, 0.00872364f, 0.01366528f, 
    0.03539372f, 0.03584235f, -0.01748655f, 0.00365754f, -0.04090846f, 0.00970595f, 0.02956649f, -0.01118907f, 
    -0.02243677f, 0.00262517f, 0.00417027f, -0.03698995f, 0.01001417f, -0.03636749f, -0.00683285f, -0.03532980f, 
    -0.02978300f, -0.03934825f, 0.01994058f, -0.01257476f, -0.00479367f, -0.00667975f, 0.01661761f, -0.01423638f, 
    0.02027576f, -0.04019438f, -0.01291851f, 0.01827764f, -0.01270181f, 0.00041357f, -0.03613161f, -0.00277996f, 
    0.02636330f, -0.01915555f, -0.02056705f, 0.01267051f, -0.03950725f, 0.00938329f, 0.00524878f, 0.02428379f, 
    0.02987061f, -0.00969845f, -0.00855183f, -0.00753493f, 0.00674228f, -0.01290248f, -0.03929561f, 0.01107293f, 
    -0.03249312f, 0.00348199f, -0.00340519f, 0.03808865f, -0.01807245f, 0.00972019f, -0.00747329f, -0.01535669f, 
    -0.02936380f, 0.01155663f, -0.01671528f, -0.00463734f, 0.04126574f, 0.04171933f, -0.00219045f, 0.03817720f, 
    0.02637497f, -0.03218671f, 0.00157401f, 0.01991525f, -0.01133475f, -0.01314840f, -0.02003267f, -0.00068132f, 
    0.00931372f, -0.01273230f, 0.02577899f, 0.02668070f, -0.00906858f, 0.00613697f, -0.00497147f, -0.03116282f, 
    0.02314956f, -0.01999185f, 0.02835581f, 0.02784565f, 0.01171762f, -0.01658584f, -0.00831042f, 0.00710161f, 
    -0.00324592f, -0.01826957f, -0.00979365f, 0.00933080f, 0.01811492f, -0.03584469f, -0.03735039f, -0.02986342f, 
    -0.01168597f, 0.00391498f, 0.01881947f, 0.02902803f, 0.01315238f, -0.03484520f, -0.03641967f, -0.00314040f, 
    0.02888696f, -0.03069649f, -0.02875239f, -0.01535500f, 0.00582518f, -0.02498835f, -0.03860052f, 0.00145664f, 
    -0.03733845f, 0.02771893f, -0.01639078f, 0.01641385f, -0.00819373f, 0.01710833f, -0.02691204f, -0.03800369f, 
    -0.02416120f, -0.03079247f, -0.01066925f, 0.01759657f, -0.02508140f, 0.01116058f, -0.02608037f, -0.00198319f, 
    -0.00140935f, 0.00518617f, 0.02284858f, 0.01590238f, -0.03176265f, 0.02264679f, -0.00412590f, -0.00818618f, 
    -0.02305261f, -0.00957809f, -0.03265838f, -0.03479511f, 0.02842325f, -0.00641865f, 0.01990761f, -0.02022150f, 
    -0.04136076f, 0.01726613f, -0.01571184f, -0.02020727f, -0.04048995f, 0.00922183f, 0.01491464f, -0.02665719f, 
    0.01384255f, -0.02093845f, 0.01447401f, 0.00595372f, 0.02905793f, 0.01275864f, -0.00706530f, 0.02102450f, 
    0.00316279f, -0.00357163f, -0.01155627f, -0.01073291f, -0.02660191f, 0.01214382f, -0.03562343f, 0.02995500f, 
    0.01396116f, 0.02948236f, 0.03136170f, -0.01438458f, 0.01171453f, 0.01154254f, 0.00315041f, -0.03874980f, 
    0.00249145f, -0.02673964f, -0.01992972f, -0.00039282f, -0.01853359f, -0.03685628f, -0.03545066f, -0.03019477f, 
    0.00714059f, 0.02161631f, -0.01292263f, 0.00102465f, -0.00888957f, 0.00207262f, -0.03424263f, -0.01948653f, 
    -0.00318451f, 0.02569898f, 0.02096621f, 0.00163511f, 0.02655957f, 0.01796504f, -0.00360457f, -0.02248664f, 
    0.00979915f, 0.00556473f, -0.02180857f, 0.03621861f, 0.00859325f, 0.00304948f, -0.02396646f, -0.03970820f, 
    -0.02947146f, -0.03556935f, 0.00689354f, -0.02226807f, 0.02291016f, -0.02471015f, 0.02582521f, 0.02814354f, 
    -0.03634142f, -0.01833940f, -0.02807315f, -0.00014756f, -0.02239267f, -0.02233247f, 0.01467352f, -0.00156705f, 
    0.02775726f, -0.02710715f, -0.03378062f, 0.01701322f, 0.00618965f, -0.03576166f, -0.03761386f, -0.03754627f, 
    0.01178459f, -0.00650111f, -0.02777264f, 0.00228264f, -0.03340665f, -0.02666315f, -0.01987796f, 0.02027402f, 
    -0.02006317f, 0.01090090f, 0.00631356f, 0.00679756f, -0.03192943f, -0.01877312f, -0.00608815f, 0.00764438f, 
    0.00639722f, -0.00532466f, 0.00129428f, -0.02498007f, 0.00282912f, 0.01435967f, 0.01591248f, 0.00454917f, 
    -0.01494447f, -0.00287811f, -0.02109621f, 0.00633375f, 0.00342006f, -0.02320858f, -0.03881892f, 0.00120240f, 
    0.00884719f, -0.02481459f, -0.02724428f, 0.00998628f, 0.02129022f, -0.02607062f, 0.01401102f, 0.02971623f, 
    -0.00898437f, -0.01327674f, -0.02965745f, 0.03606647f, 0.00069066f, -0.02263550f, -0.02366025f, 0.02676231f, 
    -0.00587100f, -0.01609786f, 0.01843674f, 0.00553114f, -0.00120017f, 0.00786066f, 0.01339422f, 0.01568900f, 
    0.00099745f, 0.01960340f, 0.01442544f, 0.01547366f, -0.00074411f, 0.02204222f, -0.01359327f, 0.01787601f, 
    -0.02707908f, -0.00840169f, -0.00915620f, 0.04026918f, -0.01963564f, -0.00380204f, -0.03766556f, -0.03631141f, 
    -0.03221500f, -0.01845699f, -0.01837954f, 0.02761921f, -0.04163688f, 0.02239347f, -0.03497537f, -0.02757189f, 
    -0.01420403f, -0.02753692f, 0.01092117f, 0.01217184f, -0.00554280f, 0.02522362f, 0.00107022f, 0.00592408f, 
    -0.01702287f, -0.03890533f, -0.02804752f, -0.00099586f, 0.02450950f, 0.02087830f, -0.02070622f, -0.02930713f, 
    -0.01632925f, -0.01820277f, 0.01845169f, -0.02958329f, 0.01790445f, -0.00548919f, 0.00551202f, 0.00793123f, 
    -0.00360419f, 0.00295500f, 0.03187767f, -0.01511837f, -0.03701336f, -0.03374109f, -0.02026800f, 0.01985848f, 
    0.01115708f, -0.02965138f, -0.02070799f, -0.03184883f, 0.02827458f, -0.02639564f, 0.01792505f, -0.03745745f, 
    -0.03595704f, 0.01311870f, -0.02977145f, -0.00221482f, -0.02478213f, 0.02311890f, 0.01194985f, -0.01043407f, 
    0.00650451f, 0.01229237f, -0.02605142f, -0.03919695f, -0.00902742f, -0.00261567f, 0.01731246f, 0.02333958f, 
    -0.01121921f, -0.00079045f, -0.03040970f, -0.03716022f, -0.02208729f, 0.02208149f, -0.01294290f, -0.03583475f, 
    -0.02518615f, -0.02847218f, -0.01217825f, 0.00493673f, -0.01113988f, 0.00160902f, -0.01673518f, 0.01514937f, 
    -0.01621590f, -0.02321702f, 0.01808980f, 0.00828257f, -0.02203179f, -0.01493717f, -0.01788734f, -0.04082743f, 
    0.00550362f, -0.03578322f, -0.02114023f, -0.02002208f, 0.00749905f, 0.01146616f, 0.02843102f, 0.01412722f, 
    0.00499520f, 0.02049083f, 0.02853676f, -0.00037994f, 0.02036762f, -0.01095580f, -0.00896231f, -0.02197891f, 
    -0.00732840f, 0.00571462f, -0.02529472f, -0.01253880f, -0.00997121f, 0.00555255f, -0.00988964f, 0.02689857f, 
    0.01134461f, -0.00611050f, -0.00221401f, 0.02714718f, 0.01464298f, 0.01776779f, -0.02410777f, 0.02588371f, 
    -0.03537558f, 0.01625212f, -0.01813276f, 0.02047221f, 0.00927012f, 0.01822894f, 0.02672147f, -0.00848771f, 
    0.00485927f, -0.02513174f, 0.02326013f, 0.00544020f, 0.02272722f, 0.01544357f, -0.03601417f, -0.03868013f, 
    0.01434036f, 0.03684293f, 0.01019958f, -0.02008915f, -0.02217559f, -0.01698136f, 0.00281504f, -0.00702384f, 
    -0.03639463f, -0.03011331f, -0.04204689f, -0.02335874f, -0.02257483f, 0.00246194f, 0.01074595f, 0.02841894f, 
    0.02473868f, -0.01948668f, -0.00023232f, -0.03491655f, 0.00216538f, -0.00164868f, 0.02993104f, -0.00461140f, 
    -0.02789295f, -0.02775356f, 0.01020817f, 0.01297624f, 0.01333276f, 0.00014649f, 0.02619591f, -0.00128765f, 
    -0.00743176f, -0.03966952f, 0.02145654f, 0.02791340f, -0.01783216f, 0.00106560f, 0.02912845f, 0.02573061f, 
    -0.00902810f, 0.00097602f, -0.02724221f, 0.01274761f, -0.00986530f, 0.02783756f, -0.03095587f, 0.00010720f, 
    -0.03224766f, -0.02567097f, 0.02459617f, -0.02046997f, -0.04063514f, -0.03424121f, -0.02145411f, -0.00597132f, 
    -0.02343650f, -0.00905313f, 0.02921155f, -0.02024115f, 0.00125735f, -0.00385616f, 0.02637570f, 0.02083445f, 
    -0.02636915f, -0.01454998f, -0.00463969f, -0.03490066f, -0.00127543f, 0.02132626f, 0.01220361f, 0.00700677f, 
    -0.00268849f, -0.00831650f, 0.02689637f, 0.02475935f, 0.01152565f, -0.03915818f, 0.00197089f, -0.02426059f, 
    0.00290540f, -0.04006256f, -0.02711453f, -0.00465975f, -0.01669711f, -0.00353354f, -0.00272986f, 0.01942194f, 
    0.00997011f, 0.02502603f, -0.03007771f, -0.03363135f, -0.02582739f, -0.01615608f, -0.01199087f, 0.02474776f, 
    -0.00198874f, -0.03162375f, 0.01063996f, -0.02621535f, -0.02035770f, -0.03839933f, -0.02381846f, -0.03666972f, 
    -0.00826271f, -0.01776210f, 0.01375063f, 0.00139046f, 0.00919316f, -0.02398214f, -0.04095562f, -0.02808474f, 
    -0.02783116f, -0.03656169f, -0.03507871f, -0.01518058f, -0.00353467f, -0.02975580f, 0.00994235f, -0.03749745f, 
    -0.01301396f, -0.03983947f, 0.02646903f, 0.02323675f, -0.00761177f, -0.02470128f, -0.04241627f, -0.00707804f, 
    -0.01224798f, -0.02642394f, -0.03796495f, 0.01545356f, -0.00408985f, 0.00684914f, 0.01261133f, -0.04240287f, 
    0.02405520f, -0.03719890f, 0.01335795f, -0.00525607f, 0.00830400f, -0.02116279f, 0.00187588f, 0.01802088f, 
    -0.03844096f, -0.02671809f, -0.01546994f, 0.00338146f, 0.01768804f, -0.00492552f, 0.02230829f, 0.02348794f, 
    0.00376447f, 0.02805664f, -0.03622903f, 0.01273793f, -0.00505759f, 0.02728713f, -0.01580273f, 0.00574140f, 
    0.00862147f, -0.01374844f, -0.00100310f, -0.03785681f, -0.00894903f, 0.00665969f, -0.02840510f, 0.00501106f, 
    0.00703259f, 0.02584417f, -0.00992843f, 0.02358459f, 0.00717856f, 0.02096907f, 0.00109409f, -0.03878697f, 
    0.01612869f, 0.01959776f, 0.01258776f, -0.03063598f, 0.01592010f, -0.01658402f, 0.01012614f, 0.01998881f, 
    0.00384582f, -0.00986816f, 0.02629878f, -0.01678968f, 0.00549822f, 0.01323004f, 0.02050677f, -0.01802954f, 
    0.02651853f, 0.00565304f, -0.01016377f, -0.01798237f, -0.00549054f, -0.02598036f, 0.01579450f, 0.00955394f, 
    0.01801731f, -0.01498438f, 0.00570651f, -0.03344523f, -0.00100910f, -0.04003224f, 0.00150697f, 0.00692515f, 
    -0.03548077f, -0.00382616f, -0.01266053f, 0.00116186f, -0.01678920f, -0.02033514f, -0.01522215f, -0.03260384f, 
    -0.03795117f, -0.03584782f, 0.02146214f, 0.01673823f, -0.03742923f, -0.00609298f, -0.02454548f, 0.01934402f, 
    0.00488672f, -0.00499824f, -0.03506728f, 0.02148209f, 0.00377857f, -0.03617644f, -0.00182584f, 0.00491707f, 
    0.03197079f, 0.01451100f, -0.00340407f, -0.03953392f, 0.01931377f, -0.00612488f, -0.02241706f, -0.02346148f, 
    -0.03638080f, -0.00960609f, 0.02148793f, 0.00675200f, -0.01189665f, 0.01905758f, -0.01231375f, 0.00369608f, 
    0.02059668f, -0.03547329f, -0.00278679f, -0.02138999f, -0.00542828f, 0.00140529f, -0.01921562f, -0.00975053f, 
    0.00615915f, -0.02130525f, -0.04244907f, 0.00039974f, -0.02937731f, -0.00733767f, 0.02436480f, -0.01639761f, 
    0.02566664f, -0.02026212f, 0.01457410f, 0.02099962f, -0.01520704f, -0.00577889f, -0.02780766f, -0.03822400f, 
    0.02835861f, -0.00853580f, 0.00772492f, -0.02364807f, -0.02263569f, 0.01826466f, -0.01209184f, -0.00181220f, 
    0.02339857f, -0.01955519f, -0.00019414f, 0.01780317f, 0.01893850f, -0.02140068f, -0.02696709f, -0.03263738f, 
    -0.03550117f, -0.02609796f, -0.01143663f, -0.03521892f, 0.02124147f, -0.03752944f, 0.02226447f, -0.03049329f, 
    -0.01112372f, -0.03844955f, -0.01430107f, -0.04408350f, -0.02686483f, -0.03964600f, -0.04239542f, 0.00727889f, 
    -0.03400104f, -0.01606234f, -0.02423534f, 0.02565906f, -0.00959877f, -0.02169615f, -0.00711856f, -0.01886050f, 
    -0.02587201f, 0.00257520f, -0.00859962f, -0.00570420f, -0.04326737f, -0.03568079f, -0.01991977f, -0.00982731f, 
    -0.02875900f, 0.00386252f, -0.03700364f, -0.02344323f, -0.03652165f, 0.00619969f, -0.00999851f, -0.02021587f, 
    -0.00713545f, -0.00362198f, -0.01189993f, 0.01634911f, 0.00551226f, -0.03252939f, -0.01111455f, 0.01551083f, 
    -0.02550190f, 0.00693752f, 0.00918479f, -0.01886440f, -0.02335242f, -0.03097964f, -0.02664153f, -0.00847187f, 
    -0.00432954f, -0.01909115f, 0.01435150f, 0.01529564f, 0.00393593f, 0.02428316f, 0.00760828f, -0.01290715f, 
    0.02139113f, -0.02047158f, 0.02758364f, 0.00439715f, -0.03226666f, -0.02062862f, 0.00905250f, -0.02942983f, 
    -0.02110732f, 0.01841942f, -0.00971108f, 0.01688653f, -0.03126399f, 0.02308697f, -0.03610042f, -0.01503908f, 
    0.00920613f, -0.02143327f, 0.01363096f, 0.00853599f, 0.01626894f, 0.01554258f, 0.00661089f, -0.01902393f, 
    0.01730469f, -0.00118989f, 0.01810268f, 0.00887457f, 0.02684851f, -0.02547203f, -0.00007731f, 0.01469370f, 
    -0.02690179f, 0.02074998f, 0.02920336f, -0.01905288f, -0.01311213f, -0.01353042f, 0.01618248f, 0.01890921f, 
    0.01430483f, -0.00184998f, 0.00860797f, -0.01347978f, -0.02984545f, -0.01450263f, 0.01061961f, 0.02949028f, 
    -0.00542537f, 0.00247500f, 0.00447935f, -0.00580870f, -0.01529817f, -0.03418159f, -0.01826436f, -0.04286333f, 
    -0.01097273f, -0.00174922f, 0.02474212f, -0.01967125f, -0.03516205f, -0.03757961f, -0.03032518f, 0.01853142f, 
    -0.02472844f, -0.04234203f, 0.01873032f, -0.03907886f, 0.01226262f, -0.01138409f, 0.00030616f, -0.02959681f, 
    0.00163303f, -0.00884817f, -0.03868556f, 0.00155979f, -0.02946383f, 0.02519778f, -0.00455057f, -0.03430437f, 
    -0.03330743f, -0.03605214f, -0.00341808f, 0.01552806f, 0.03119649f, 0.00659970f, 0.00097414f, 0.01126459f, 
    0.00012342f, -0.03331918f, -0.01222941f, 0.02173703f, -0.01987117f, -0.00919107f, -0.01915226f, -0.04399746f, 
    0.01662488f, -0.03090439f, 0.01049560f, -0.01258333f, -0.02125049f, 0.01765328f, -0.01926062f, 0.01475614f, 
    0.01412484f, 0.02615055f, 0.00195348f, -0.02556515f, 0.00647067f, 0.02316723f, 0.00399542f, -0.03294206f, 
    -0.02266896f, -0.00512830f, -0.00097560f, -0.04186305f, -0.01147129f, -0.01509721f, -0.03079369f, -0.02327270f, 
    -0.02118129f, 0.01038938f, 0.01433933f, 0.00341696f, 0.01728388f, -0.01928920f, 0.01421378f, -0.02202019f, 
    0.02168951f, -0.03418400f, 0.01651315f, -0.02419582f, 0.02125161f, 0.02515928f, -0.02028501f, -0.04202501f, 
    -0.03541951f, 0.02488776f, -0.00372858f, -0.02498795f, -0.03560664f, -0.03157239f, -0.01614155f, 0.01532211f, 
    0.02323986f, -0.03937023f, -0.00198961f, 0.02509424f, -0.03993692f, -0.03917842f, 0.00105908f, 0.00570735f, 
    -0.01957678f, 0.02082542f, -0.00583336f, -0.01023831f, -0.01696802f, -0.00863049f, -0.03767189f, 0.01107221f, 
    0.01332203f, -0.00976386f, -0.03441742f, -0.02617705f, -0.03896745f, -0.02116521f, -0.02106536f, -0.01241592f, 
    -0.02931484f, -0.03970938f, -0.01289492f, 0.00188014f, -0.02194787f, -0.02015499f, -0.01867552f, -0.00564688f, 
    -0.00465470f, -0.00597894f, 0.00525975f, 0.00404253f, 0.01414066f, -0.01669823f, 0.02040439f, -0.03012058f, 
    -0.00026886f, 0.01733286f, -0.03256425f, -0.01644293f, -0.01640889f, 0.00015095f, -0.02542964f, -0.03282015f, 
    0.02431201f, -0.04284628f, -0.01835548f, -0.04021488f, 0.02519203f, -0.00614463f, -0.02590020f, -0.00487652f, 
    -0.01251732f, -0.03157845f, -0.00165711f, 0.00348240f, -0.01647967f, -0.01560417f, -0.03291524f, -0.00065763f, 
    -0.02341087f, -0.03810057f, -0.01425370f, -0.03446539f, 0.00349812f, -0.03324764f, -0.01871095f, 0.01078206f, 
    0.02140065f, -0.00666878f, 0.00686676f, -0.02401344f, -0.03547018f, -0.03572050f, -0.02827466f, 0.01683705f, 
    0.00230349f, -0.02732587f, 0.00586094f, 0.02426962f, 0.00206730f, -0.01213297f, -0.04116568f, -0.01754674f, 
    -0.01011494f, -0.00567062f, -0.01500239f, 0.00947618f, 0.00989954f, -0.00869762f, 0.02272734f, 0.00777852f, 
    -0.02742448f, 0.02289606f, 0.00772542f, 0.00240010f, -0.04199673f, -0.04176492f, -0.01099315f, -0.00919537f, 
    0.00933875f, -0.02284211f, -0.04268205f, -0.04291294f, 0.00707096f, -0.01334034f, 0.02102852f, -0.01449777f, 
    -0.03334390f, -0.04140795f, -0.04051618f, -0.02737582f, -0.03929384f, 0.02107312f, -0.00484524f, 0.01961671f, 
    0.01796805f, 0.00428176f, 0.01005351f, -0.03562158f, -0.03251391f, -0.02035408f, 0.01902036f, -0.03253300f, 
    -0.00566594f, 0.00425610f, 0.02480622f, -0.01514123f, -0.01685484f, 0.02777255f, -0.02917105f, -0.00888923f, 
    -0.01403648f, -0.03135534f, 0.01769082f, -0.00422234f, 0.00792936f, -0.04067901f, 0.02873774f, 0.01378622f, 
    0.01163377f, -0.03201750f, -0.01078964f, -0.01374782f, 0.01984862f, -0.02882079f, 0.02466338f, 0.01216496f, 
    0.00836877f, 0.02354967f, -0.00487201f, -0.00187903f, -0.00611499f, -0.00005024f, 0.01892958f, -0.02604818f, 
    -0.00356616f, 0.00488904f, 0.00677391f, 0.02771804f, -0.02819137f, 0.02802011f, -0.00649471f, 0.02029188f, 
    0.02740119f, -0.04263963f, 0.02756867f, -0.01871124f, 0.00644591f, -0.03715334f, -0.02862021f, 0.02064835f, 
    0.01570567f, 0.01448036f, 0.02178386f, -0.01728414f, -0.01264704f, 0.00649391f, 0.01745026f, -0.02674472f, 
    -0.03221122f, -0.00580935f, -0.02186679f, -0.01765107f, -0.02206143f, -0.00918603f, -0.02902959f, -0.02854582f, 
    0.02331192f, -0.03314779f, -0.02660899f, 0.01939491f, -0.00515481f, -0.02141338f, -0.02267163f, 0.01042841f, 
    0.00375924f, -0.01976598f, 0.00115246f, -0.04056103f, 0.01865033f, -0.01476152f, 0.00989553f, -0.00743921f, 
    0.02076416f, -0.03662281f, 0.02508510f, -0.03087645f, 0.00901981f, -0.00808255f, -0.02368764f, -0.04213396f, 
    -0.01902983f, -0.01653543f, 0.02674148f, -0.01141495f, -0.02054884f, 0.02297759f, -0.04232082f, 0.01187699f, 
    0.00422691f, 0.02275595f, -0.01332485f, -0.03036921f, 0.02385054f, -0.01050316f, -0.00520164f, 0.01454658f, 
    0.00355421f, -0.00882561f, 0.02578949f, -0.00948338f, -0.00735415f, 0.01529050f, -0.00720820f, 0.02191504f, 
    0.01734679f, -0.03044799f, -0.03260699f, -0.01556031f, -0.01401276f, 0.02615510f, 0.02209933f, 0.01582018f, 
    0.02773525f, -0.02895151f, -0.02020133f, 0.00492161f, -0.00442955f, -0.03316685f, 0.02661117f, -0.00446934f, 
    -0.01960700f, 0.01186339f, 0.01424933f, 0.01739419f, -0.03179104f, 0.02289222f, 0.02833901f, -0.00271776f, 
    0.01463569f, 0.02909553f, -0.01508163f, -0.02971207f, -0.02823187f, -0.00433653f, -0.03946291f, 0.00313485f, 
    -0.03023641f, -0.04069120f, -0.00303411f, -0.03507987f, 0.02506001f, -0.00766828f, -0.03585669f, 0.01605952f, 
    -0.00220217f, -0.03162394f, -0.04187587f, -0.02079390f, -0.01190079f, -0.00459288f, 0.02426800f, 0.02475730f, 
    -0.03241900f, -0.00313821f, -0.00488537f, -0.02233420f, -0.03106143f, -0.02534575f, 0.00488599f, -0.02123133f, 
    -0.03353155f, 0.02316742f, 0.00572798f, -0.02220083f, 0.01299052f, -0.00197716f, 0.01132722f, -0.02441849f, 
    0.02148230f, -0.01660702f, -0.04419195f, -0.01619389f, 0.02026383f, 0.02177010f, -0.04074780f, 0.00674013f, 
    0.01788766f, 0.02253466f, -0.01393586f, -0.00402377f, 0.01416663f, 0.01507172f, 0.00835194f, 0.02351385f, 
    0.00628027f, -0.03847712f, 0.01176440f, -0.02813729f, 0.01105087f, -0.02893058f, -0.02669207f, 0.01477712f, 
    -0.00399139f, -0.02003601f, 0.00091954f, -0.00142958f, 0.00005183f, -0.00376934f, 0.01250317f, 0.01335935f, 
    -0.01932824f, -0.03562656f, -0.01189455f, -0.03776604f, -0.02771613f, 0.02176735f, -0.04386792f, -0.02675910f, 
    -0.01862242f, 0.00965217f, -0.01620633f, 0.01108645f, 0.01334968f, -0.04084880f, -0.04386444f, -0.01051356f, 
    0.00986887f, -0.01027294f, 0.01468408f, -0.00592945f, -0.02033772f, -0.02537121f, -0.00639213f, -0.03721540f, 
    -0.02175007f, -0.01746761f, -0.01360098f, -0.00541734f, -0.03261162f, -0.02693475f, -0.03695843f, -0.01011525f, 
    -0.02603910f, -0.03187006f, 0.01816874f, -0.03210178f, -0.02359912f, -0.02477987f, -0.00278163f, -0.02385855f, 
    -0.00952365f, 0.01195194f, -0.02940117f, -0.03755791f, -0.03871576f, -0.01951940f, 0.00717551f, 0.01384052f, 
    -0.03016792f, -0.00730519f, -0.01268475f, -0.02829619f, 0.01162841f, -0.02106150f, -0.02181505f, -0.00705118f, 
    -0.00945821f, -0.02378906f, -0.00313301f, 0.02925180f, -0.00393334f, 0.03046255f, -0.02093431f, 0.00950728f, 
    -0.00938539f, 0.00998679f, -0.01978654f, 0.01516524f, -0.02348422f, 0.02531066f, 0.00035020f, -0.01017099f, 
    -0.02540883f, -0.00749803f, -0.02166636f, 0.01513096f, 0.02190122f, 0.01270211f, -0.00530853f, -0.02042426f, 
    0.01734954f, -0.03705015f, -0.02812248f, 0.02083063f, -0.03456435f, 0.01862143f, 0.02971753f, 0.02051328f, 
    -0.02828758f, -0.01741227f, -0.02500925f, -0.00231101f, -0.03948458f, 0.01334283f, 0.02650985f, -0.04021205f, 
    -0.00059513f, -0.03038981f, -0.03904273f, -0.02052223f, -0.01408260f, -0.02434624f, 0.00587225f, -0.02458932f, 
    0.01297715f, -0.01528013f, -0.01313146f, -0.02251791f, -0.03403898f, 0.02383331f, 0.03326193f, -0.02076499f, 
    0.02159695f, 0.00961892f, 0.00772745f, -0.01000328f, 0.02816876f, -0.01581144f, 0.01460578f, 0.00840892f, 
    0.00923633f, 0.02360788f, -0.00517606f, -0.03363105f, 0.02175159f, -0.02244887f, -0.00897644f, -0.01711943f, 
    0.02901288f, 0.01399021f, -0.02194941f, 0.02384297f, -0.03640868f, -0.03617442f, 0.00201458f, -0.00463927f, 
    0.01024346f, -0.02120011f, -0.01213864f, 0.02540656f, -0.01617977f, -0.01846937f, 0.02424062f, 0.02724198f, 
    0.00040915f, -0.00152691f, -0.03256743f, 0.02564926f, 0.01976977f, 0.00479773f, -0.02533495f, 0.01782651f, 
    0.00202184f, -0.03788682f, -0.03925110f, -0.00244939f, 0.01439029f, 0.02102786f, -0.00956431f, 0.02158519f, 
    -0.01358809f, 0.01632311f, -0.02169275f, 0.01432667f, -0.02527661f, -0.00352981f, -0.02113175f, -0.01586686f, 
    -0.00713971f, 0.00177785f, -0.01264698f, -0.03217193f, -0.03561373f, -0.04183780f, 0.02380075f, -0.04203260f, 
    0.01203538f, -0.04150397f, -0.00318998f, -0.01639550f, 0.00070413f, -0.00982473f, 0.01375628f, 0.00682185f, 
    -0.02293946f, -0.02999221f, 0.01773812f, 0.02848226f, -0.01538170f, 0.01734088f, 0.01568056f, 0.02187918f, 
    0.02984619f, -0.01424389f, 0.02196252f, -0.02584766f, -0.00462605f, -0.00174431f, -0.03031583f, 0.02904157f, 
    -0.03636734f, 0.01489082f, -0.03576966f, -0.01758628f, 0.01378134f, 0.00976989f, -0.03127087f, -0.00808434f, 
    0.02551967f, 0.02155269f, 0.03815334f, -0.01895196f, 0.02269123f, -0.04074793f, -0.04174203f, 0.01813862f, 
    0.01472743f, -0.00156939f, -0.00811578f, 0.01639418f, -0.03578801f, -0.03221204f, -0.01370311f, 0.02800015f, 
    0.01697992f, -0.00051859f, -0.03508644f, -0.01829855f, 0.02540393f, -0.01927750f, 0.00265536f, -0.02716239f, 
    -0.01713912f, 0.00250800f, 0.02834573f, -0.03617394f, -0.02585305f, 0.02839865f, 0.01990041f, 0.01229872f, 
    -0.01617688f, -0.02248304f, 0.00096884f, -0.02900840f, -0.03500890f, -0.00476284f, -0.00360111f, -0.03331155f, 
    -0.01930880f, 0.01746907f, -0.01570689f, -0.00984150f, -0.04113190f, -0.00050456f, -0.02494378f, 0.01437828f, 
    -0.02662215f, -0.00135094f, -0.01684298f, -0.00712238f, 0.01975091f, -0.03514969f, -0.00671253f, -0.00003771f, 
    0.02378632f, 0.02393786f, -0.02077203f, -0.00090041f, -0.01596203f, -0.02464378f, -0.02934589f, 0.00409333f, 
    -0.01795835f, -0.02312280f, 0.03196735f, -0.01408777f, -0.03662378f, 0.00983993f, 0.00818677f, 0.00711552f, 
    0.01660408f, -0.01142401f, -0.01902727f, -0.00874139f, 0.00890623f, -0.02880383f, 0.01803411f, 0.00788019f, 
    0.00593320f, -0.02547510f, -0.01011597f, -0.03665977f, -0.03007360f, 0.00696357f, -0.01478296f, -0.00673109f, 
    -0.01047885f, -0.01195167f, 0.01707733f, -0.03993999f, 0.02783230f, 0.01864315f, -0.01144056f, -0.02680514f, 
    -0.00179346f, 0.01915772f, 0.00205266f, -0.00687813f, -0.02605061f, 0.02812510f, 0.01899318f, -0.03867679f, 
    0.02895419f, -0.01292165f, -0.00193018f, 0.00221510f, -0.02043716f, 0.00872529f, -0.02218440f, 0.01004945f, 
    -0.01307476f, 0.02943687f, 0.00155643f, -0.04075365f, -0.01742544f, 0.01941357f, 0.01033842f, 0.02491111f, 
    0.03372622f, -0.04222353f, -0.01794370f, -0.03238594f, 0.01293311f, 0.02555637f, -0.02273167f, 0.00681536f, 
    -0.01987411f, 0.00747795f, -0.01433654f, -0.00311443f, -0.03579156f, -0.01109970f, 0.00536603f, 0.00475951f, 
    0.04106928f, -0.02303391f, 0.02554524f, 0.01519538f, -0.01109776f, -0.01328258f, -0.03036890f, -0.01678322f, 
    -0.00283457f, -0.01464725f, 0.02568873f, -0.03583071f, -0.03786222f, -0.03062318f, -0.01845611f, 0.00754103f, 
    0.01271376f, 0.01447846f, 0.00398632f, 0.00092450f, 0.03152459f, 0.02436291f, 0.02884614f, -0.01570905f, 
    0.02090924f, -0.02858472f, -0.01587228f, -0.00667298f, -0.01973599f, -0.01666036f, -0.02034757f, 0.01026351f, 
    -0.00415471f, 0.02599041f, 0.01653852f, -0.03048720f, 0.01596527f, -0.02321627f, -0.02413694f, -0.03224361f, 
    0.01884430f, -0.01266057f, -0.00926760f, 0.03186425f, 0.00337892f, -0.03806740f, -0.01203315f, 0.02694822f, 
    -0.00574584f, -0.02621231f, 0.00374103f, -0.03083524f, 0.01885510f, -0.01138473f, -0.02545401f, 0.02990083f, 
    0.01995197f, 0.02101581f, -0.00191538f, -0.03868621f, -0.02073888f, -0.02943162f, -0.02364798f, -0.03785392f, 
    -0.03946586f, 0.00890641f, -0.02350520f, 0.02762876f, 0.03420797f, 0.03205828f, 0.01034488f, 0.02012545f, 
    0.01424844f, -0.03911024f, -0.03197993f, -0.00722495f, 0.01151681f, 0.00903491f, -0.02030113f, -0.00147200f, 
    0.00537265f, -0.02513795f, 0.00288389f, 0.01135669f, -0.02445770f, -0.01120297f, -0.03758902f, -0.03857301f, 
    0.02920053f, 0.03125801f, -0.02988402f, -0.01301899f, -0.01925245f, -0.01840228f, -0.01661490f, 0.01387873f, 
    0.00225668f, -0.01425108f, -0.02380680f, -0.03705455f, -0.01674495f, 0.00884207f, -0.00977382f, 0.00085182f, 
    0.03367797f, -0.02543346f, -0.00139659f, 0.02429110f, 0.02006201f, 0.00319685f, 0.01751462f, 0.01245888f, 
    -0.02669246f, -0.00284443f, -0.02734553f, -0.01238151f, -0.01054977f, 0.00083825f, -0.00521616f, -0.00917246f, 
    0.02613876f, 0.00151931f, 0.02746040f, 0.00771585f, 0.01591707f, -0.01982367f, -0.01452498f, -0.01023686f, 
    -0.00831711f, -0.00521019f, -0.02319610f, 0.01961777f, -0.04070797f, 0.02818334f, -0.01604688f, -0.00586760f, 
    -0.03110585f, -0.01570094f, 0.00237718f, -0.02891949f, -0.02475161f, -0.03404790f, 0.02660095f, 0.00636075f, 
    -0.00518133f, -0.03780977f, 0.01892686f, 0.01267271f, -0.01890192f, -0.01782665f, -0.03395014f, -0.01548425f, 
    0.02068955f, -0.01902604f, -0.03231002f, 0.01219442f, -0.03122646f, -0.02447476f, 0.01909111f, 0.02599330f, 
    -0.00701594f, 0.02106144f, -0.00611044f, -0.00188316f, -0.00126238f, 0.00675320f, 0.01161172f, 0.03542215f, 
    -0.01234910f, -0.00000418f, 0.00940754f, -0.02290321f, 0.00781034f, 0.02303433f, -0.00131435f, -0.01777213f, 
    0.03240470f, 0.01390557f, 0.01082946f, 0.00738932f, -0.03298087f, 0.01120303f, 0.01883383f, 0.03377089f, 
    -0.01822584f, -0.01664228f, 0.00270840f, -0.02569404f, 0.01168762f, 0.00739671f, -0.03708580f, -0.03906288f, 
    -0.01707865f, 0.02733284f, -0.03393032f, -0.01480252f, 0.02525700f, -0.01439387f, 0.01728815f, 0.01588896f, 
    -0.03750089f, 0.02066088f, -0.02724595f, -0.04249522f, -0.03373478f, -0.03194361f, -0.03130217f, 0.02169516f, 
    -0.02865527f, 0.00925759f, -0.02484274f, 0.00358274f, 0.00596404f, 0.02620513f, -0.00128652f, -0.01796365f, 
    0.01792438f, 0.00419234f, 0.00510500f, -0.00896384f, -0.03881338f, -0.02321348f, -0.00598593f, -0.00349861f, 
    -0.03923941f, -0.01729528f, -0.01908521f, -0.02071830f, -0.02249865f, -0.03021190f, -0.01801390f, -0.01760552f, 
    -0.03744861f, -0.01752872f, -0.03677771f, 0.00814434f, 0.01515224f, -0.02587663f, 0.03043411f, 0.02128091f, 
    -0.02966379f, 0.02821728f, -0.02244111f, -0.02527756f, -0.01608112f, 0.01047238f, -0.03463714f, -0.00443520f, 
    -0.02458112f, -0.03232216f, -0.01742344f, -0.00671737f, -0.00452074f, -0.00243663f, 0.00490578f, 0.02649254f, 
    -0.00994333f, 0.03088528f, -0.00406295f, -0.03735069f, -0.03603429f, 0.02101978f, 0.01178421f, 0.01796078f, 
    -0.02924684f, 0.02044532f, -0.00218687f, -0.00228431f, -0.02041605f, -0.04058059f, -0.03168928f, 0.01571751f, 
    -0.00017210f, 0.00384508f, 0.01113010f, -0.01599422f, -0.00528270f, -0.02349463f, -0.00913705f, -0.01584668f, 
    -0.02240012f, -0.02796555f, 0.01676125f, 0.01056767f, 0.00918519f, 0.00505278f, -0.03014501f, 0.00780005f, 
    0.01551911f, -0.03096591f, 0.01911202f, -0.01716419f, -0.00960906f, -0.03101409f, -0.00291629f, 0.02340460f, 
    0.02368062f, 0.00775338f, -0.03766738f, 0.00414067f, -0.03887315f, -0.02291013f, -0.01988294f, -0.00939326f, 
    -0.00052155f, -0.02560111f, 0.01634801f, -0.00436917f, 0.00008582f, 0.00173977f, -0.01908177f, -0.03781345f, 
    -0.01674695f, -0.01973011f, 0.00190850f, -0.00800688f, 0.00258649f, -0.01188562f, -0.01799018f, -0.03876445f, 
    0.00957194f, 0.04168061f, 0.01552683f, -0.03816584f, -0.00649639f, 0.03349095f, 0.00862231f, -0.02129073f, 
    -0.00933063f, -0.01789954f, -0.02832818f, -0.00898962f, 0.03125382f, -0.00122718f, 0.01346937f, -0.00547192f, 
    -0.03086163f, 0.04241177f, 0.00151576f, -0.03402921f, -0.02893257f, -0.00203640f, -0.01613632f, -0.03091704f, 
    0.00709839f, 0.02537806f, 0.02442005f, 0.01977930f, -0.03391806f, -0.03273543f, -0.03084422f, 0.02190090f, 
    -0.01059952f, 0.01857366f, -0.03140834f, -0.03760826f, 0.01489573f, -0.03295952f, -0.02108397f, 0.01596557f, 
    -0.00010711f, -0.03473023f, -0.03477873f, -0.01481645f, -0.01571695f, 0.01914106f, 0.01750126f, -0.03276389f, 
    0.01271024f, -0.03191207f, -0.03651264f, 0.01561275f, -0.00290852f, 0.02633728f, 0.00391573f, 0.02789754f, 
    -0.03540224f, -0.03793827f, -0.04243633f, -0.01229927f, -0.01329195f, -0.00593682f, 0.00194021f, 0.01184467f, 
    -0.01814401f, 0.00650516f, 0.02500311f, 0.01739679f, 0.00287983f, -0.02644977f, 0.02833541f, -0.01983923f, 
    -0.00418596f, -0.01421071f, 0.01533844f, 0.01765629f, -0.03659160f, 0.01717784f, -0.02413407f, -0.03178231f, 
    0.02052671f, -0.03553113f, 0.00451298f, -0.03016211f, 0.02504170f, 0.02795268f, 0.01543104f, 0.01200921f, 
    0.01768940f, -0.02260999f, 0.00137139f, -0.02618976f, -0.03096141f, -0.01017062f, -0.00798936f, 0.02727184f, 
    -0.01664037f, -0.00008735f, 0.00807786f, 0.03736239f, 0.01014494f, -0.01730076f, -0.01091367f, -0.00229215f, 
    0.02513513f, -0.01694755f, 0.03991137f, -0.00559532f, 0.03707848f, 0.00940184f, -0.03964207f, 0.02116046f, 
    0.02473579f, 0.01573979f, 0.00559122f, 0.02033263f, -0.01230654f, 0.00510220f, -0.02875203f, 0.02348098f, 
    0.09848814f, 0.08211189f, -0.24519257f, 0.20739348f, -0.06430084f, -0.04568131f, -0.17072575f, -0.17178725f, 
    0.08978719f, 0.06785930f, -0.01289504f, -0.06070928f, 0.06637751f, 0.03454972f, 0.04527622f, 0.13489872f, 
    0.15291782f, -0.02861251f, 0.05577321f, 0.07639147f, 0.08930573f, 0.08961020f, 0.02885874f, 0.00783368f, 
    0.15689747f, -0.20830482f, 0.27247068f, 0.03997035f, 0.29749984f, -0.05664374f, 0.13406023f, 0.09851459f, 
    -0.03757644f, 0.02943658f, -0.00742302f, -0.04874118f, 0.09179183f, 0.01509142f, 0.23023136f, 0.25105530f, 
    -0.00140350f, 0.12025584f, 0.13412750f, 0.14790110f, 0.05950228f, 0.02482909f, -0.05830842f, -0.02055427f, 
    -0.18434694f, 0.31597775f, -0.11682571f, 0.20990385f, -0.23079215f, -0.00578614f, -0.12670089f, -0.03926207f, 
    -0.14980897f, -0.09039006f, 0.10306750f, 0.09306897f, 0.17960146f, -0.15017112f, 0.04673226f, -0.15570480f, 
    0.12548651f, -0.00905665f, -0.04895152f, -0.12214877f, -0.05273767f, -0.12070572f, -0.00942003f, -0.05992768f, 
    0.28173360f, 0.06535759f, -0.21694553f, 0.05726111f, -0.08568430f, -0.04181490f, -0.18181910f, -0.14144593f, 
    0.08678140f, 0.03187070f, 0.00906099f, 0.09389500f, 0.33143598f, -0.22084087f, 0.18730448f, 0.18467024f, 
    -0.03721921f, -0.03945868f, 0.03260571f, -0.11537576f, 0.16230434f, 0.05891668f, 0.09452288f, 0.10976618f, 
    -0.24657173f, 0.04924189f, -0.32035911f, 0.32747740f, -0.02210500f, -0.01015586f, -0.07255413f, -0.22230989f, 
    0.02030444f, -0.16094135f, -0.03189409f, -0.16457972f, -0.52665758f, 0.01536732f, -0.21764725f, 0.20368281f, 
    0.09747574f, 0.01447813f, -0.07254668f, -0.02772328f, 0.11424571f, -0.06893448f, -0.00242738f, -0.14920749f, 
    -0.05003465f, 0.22668949f, -0.22184552f, 0.11244135f, 0.03430572f, 0.05125445f, 0.07427051f, -0.01479974f, 
    0.00366741f, -0.10484805f, 0.02738446f, -0.02517102f, -0.15281117f, 0.02892730f, 0.07343905f, 0.07114290f, 
    0.14113253f, 0.15758727f, 0.13903955f, 0.18465628f, -0.00212732f, -0.12470052f, 0.00745047f, -0.08656800f, 
    -0.02742823f, -0.10639875f, 0.05841200f, 0.03347085f, -0.04710346f, 0.18281211f, -0.08858174f, -0.18678091f, 
    0.06151974f, -0.08480679f, -0.16158061f, -0.07693320f, 0.03932750f, -0.05744049f, 0.05989467f, -0.13999797f, 
    0.06397763f, -0.04390311f, 0.14971182f, 0.18905453f, 0.12103365f, -0.00991737f, -0.01588392f, -0.02844772f, 
    -0.04794279f, -0.11033213f, 0.09742650f, -0.13582374f, 0.08434848f, 0.09106687f, 0.08930299f, 0.02222804f, 
    -0.08413421f, -0.00070155f, -0.03477360f, -0.01525189f, -0.35745114f, 0.40073735f, -0.19655074f, -0.03363505f, 
    -0.06595362f, -0.03756925f, -0.04437630f, -0.04785822f, -0.00001877f, 0.12347474f, -0.00587620f, 0.18724717f, 
    0.27962863f, 0.05828458f, 0.11715232f, -0.10269769f, -0.10419217f, 0.03213613f, -0.12978500f, 0.11998906f, 
    0.09493269f, 0.04193018f, 0.05852276f, -0.00494374f, 0.04011569f, 0.00821684f, -0.00043785f, -0.01848499f, 
    -0.20631514f, 0.01849212f, -0.07921658f, 0.04424778f, 0.03329314f, -0.03396801f, 0.10289124f, 0.05174796f, 
    -0.01344539f, -0.36057624f, -0.14621726f, -0.25835094f, 0.07981993f, -0.07361845f, -0.01261695f, -0.02673350f, 
    0.16786225f, -0.17631647f, -0.03112946f, 0.13436739f, -0.12927082f, -0.08564388f, -0.04164787f, 0.04235986f, 
    -0.01381555f, -0.10382861f, 0.25267431f, -0.00362956f, 0.14585017f, 0.03001111f, 0.03177039f, 0.11816499f, 
    -0.10826080f, 0.45602351f, 0.01263046f, 0.00136822f, -0.10154883f, 0.05399358f, -0.10856404f, -0.07709321f, 
    0.02401468f, -0.08562515f, -0.14508489f, -0.21834731f, -0.00513188f, -0.02237742f, 0.13723800f, -0.03948716f, 
    0.18712822f, 0.09649189f, 0.00599401f, 0.17294790f, -0.00972111f, -0.07032315f, -0.07351165f, -0.01925429f, 
    0.20706470f, -0.06347857f, -0.10198153f, 0.06413506f, -0.04374713f, 0.00619290f, 0.00814565f, -0.09904066f, 
    0.19807856f, -0.09670440f, 0.13410822f, 0.02514133f, -0.11266798f, -0.11215065f, 0.22674428f, 0.16412763f, 
    0.05112237f, 0.05355009f, -0.03338063f, 0.08856884f, 0.04903647f, 0.04513492f, -0.02260054f, 0.13983494f, 
    0.03077062f, -0.05976732f, 0.02929454f, -0.14836480f, 0.03533738f, -0.01555287f, 0.07470966f, 0.05212412f, 
    0.25709298f, -0.03621392f, 0.01814037f, 0.06771269f, 0.16702861f, 0.17285733f, -0.15799788f, -0.18090639f, 
    -0.12023337f, -0.01232142f, -0.13937134f, -0.04133566f, -0.09184197f, 0.01788837f, 0.03509330f, -0.05263606f, 
    0.05289361f, -0.06405879f, 0.10991152f, 0.03915903f, -0.09718011f, -0.02841986f, -0.05654249f, -0.01483839f, 
    0.05044793f, -0.04157068f, 0.16174665f, 0.09026609f, -0.07471928f, 0.15062816f, -0.17102847f, 0.22922830f, 
    0.09182604f, 0.02178449f, -0.01961542f, -0.01103120f, 0.01970351f, 0.02452604f, -0.04819321f, 0.04280441f, 
    0.01291193f, -0.10952392f, 0.07893763f, 0.01235686f, -0.09436084f, 0.00597552f, 0.04702978f, 0.02741239f, 
    0.15046625f, 0.07189497f, -0.00890063f, 0.08092673f, -0.23875800f, 0.01112646f, 0.01288345f, 0.09553804f, 
    0.10018384f, -0.14455053f, 0.00122802f, 0.16886573f, 0.10056554f, 0.03706954f, 0.08940111f, 0.05536716f, 
    -0.25312683f, 0.14436895f, -0.09176118f, 0.17570032f, 0.05255727f, 0.03830687f, -0.01067982f, 0.01664303f, 
    -0.00817666f, -0.05056333f, -0.03364716f, 0.05331170f, 0.12557210f, -0.09573768f, 0.04517184f, -0.03774647f, 
    0.05124295f, -0.07940181f, 0.00321240f, -0.09861805f, 0.05825149f, 0.00214967f, -0.07485958f, 0.02834562f, 
    0.02793169f, -0.18802197f, -0.18019636f, -0.07265140f, -0.06935929f, 0.02817432f, -0.01304940f, 0.03185882f, 
    0.05649599f, -0.06463957f, 0.07167444f, -0.09058454f, 0.10977837f, 0.04847616f, -0.03390941f, 0.15413649f, 
    0.00721391f, 0.01841194f, -0.11453893f, -0.04802096f, 0.10130079f, 0.09134549f, 0.01188438f, 0.12622635f, 
    -0.07898825f, 0.01018909f, 0.22630648f, -0.29498211f, -0.03084570f, -0.06954725f, -0.14176369f, -0.11500140f, 
    0.24248275f, 0.00088196f, 0.18240362f, 0.00257016f, -0.09071035f, 0.04407247f, 0.01741857f, 0.02509744f, 
    0.08508499f, 0.09621549f, 0.05606766f, 0.03808815f, 0.14663647f, -0.01333135f, 0.07260191f, 0.06599382f, 
    -0.15511750f, 0.01137878f, -0.03983933f, 0.00364978f, 0.14030822f, 0.04716229f, 0.11871532f, 0.07038276f, 
    0.09144434f, -0.13840562f, -0.09767133f, 0.03519008f, -0.09528806f, -0.03002436f, 0.27329794f, -0.03664897f, 
    -0.04747578f, 0.07192233f, -0.05920145f, 0.08068267f, 0.02413572f, -0.02197398f, 0.09258154f, 0.02244525f, 
    -0.01096603f, -0.38401052f, 0.25939488f, -0.25125775f, 0.10053519f, 0.05740822f, 0.06693482f, -0.06135108f, 
    0.00608523f, 0.14570102f, 0.05257607f, 0.07398873f, -0.00620235f, -0.01164181f, -0.03695146f, -0.02328681f, 
    -0.02019880f, 0.04648889f, -0.05717510f, 0.11075309f, 0.14025904f, 0.08627360f, -0.08867314f, -0.01088355f, 
    0.23940490f, -0.15005098f, 0.19001780f, -0.04608896f, -0.02948901f, -0.08638857f, -0.08722988f, 0.01535457f, 
    -0.04271440f, -0.14787699f, -0.02729151f, -0.25345847f, 0.07807368f, 0.03432604f, 0.22375700f, -0.07780350f, 
    -0.14815411f, 0.09860804f, -0.14002194f, 0.27973971f, 0.02298693f, 0.17863987f, 0.00509442f, -0.12956743f, 
    -0.31418854f, -0.24714802f, -0.00155843f, -0.22024634f, -0.04039756f, -0.06197932f, -0.02752479f, 0.16362178f, 
    0.00915769f, -0.04872685f, 0.02257681f, 0.20905714f, -0.12420971f, -0.30551693f, 0.24505432f, -0.27839744f, 
    -0.01941867f, -0.03042861f, 0.00969062f, -0.06519002f, 0.06865226f, 0.05321822f, -0.03466071f, 0.07629438f, 
    0.19672646f, 0.04735345f, -0.02646540f, 0.01389326f, 0.03821851f, 0.03150465f, -0.20792642f, -0.00544341f, 
    0.00968099f, 0.14485584f, -0.12731744f, 0.05782738f, 0.41486484f, -0.33256602f, 0.13341694f, -0.13552937f, 
    0.09983317f, -0.02130872f, -0.08104552f, 0.04885811f, -0.02278629f, 0.14193182f, 0.12341774f, -0.00361302f, 
    -0.22264035f, 0.08352517f, -0.06175373f, -0.03778643f, -0.14222069f, -0.03486358f, -0.09832957f, -0.10229914f, 
    0.06469539f, -0.00468892f, -0.06895484f, 0.10757056f, -0.20415340f, 0.22158524f, -0.05430406f, 0.05465511f, 
    -0.22527276f, -0.05805044f, -0.11381225f, -0.11301784f, 0.17123827f, -0.01615434f, 0.08079255f, 0.05051335f, 
    0.10959419f, 0.05114306f, -0.12867920f, 0.02047198f, -0.02151554f, 0.20406768f, -0.07688604f, 0.09196581f, 
    -0.09217892f, 0.01453720f, 0.04327431f, -0.06393404f, 0.08387911f, 0.16584130f, -0.13869956f, 0.11240253f, 
    0.24216276f, -0.03372716f, 0.03182754f, -0.01695832f, 0.03619906f, -0.06673915f, -0.01167342f, 0.09826738f, 
    0.45496923f, -0.12922464f, 0.09139364f, 0.19082874f, -0.10125112f, 0.09366216f, -0.00278216f, -0.09043680f, 
    0.05753671f, -0.06593586f, -0.08839729f, 0.05566501f, -0.03977365f, -0.13140295f, 0.15401109f, 0.06211784f, 
    -0.09313653f, 0.09963988f, -0.02694507f, -0.06188872f, -0.05836959f, -0.01127463f, 0.03983497f, 0.07255161f, 
    0.07802840f, -0.15329485f, 0.18159680f, -0.22249933f, -0.02790909f, 0.09689080f, -0.03485354f, 0.07227848f, 
    0.09670863f, -0.13555984f, 0.05209491f, 0.02461140f, 0.41794592f, -0.14450845f, 0.21692380f, -0.19217847f, 
    0.05671800f, 0.10512006f, -0.13389236f, 0.00280804f, -0.01185705f, -0.01046788f, 0.06831414f, -0.12658507f, 
    -0.22990066f, -0.08228781f, 0.38207451f, -0.08668536f, -0.03396236f, 0.08746172f, -0.07713697f, 0.10151766f, 
    0.08301082f, 0.04294167f, 0.03702476f, -0.05094073f, 0.39028877f, -0.25049737f, 0.09453645f, 0.06297570f, 
    -0.00302556f, 0.01687430f, 0.02556197f, 0.01447289f, 0.16243328f, 0.02233911f, -0.10217807f, 0.05786988f, 
    -0.30617139f, 0.05447232f, -0.07497470f, 0.13293727f, 0.03117272f, 0.05394407f, -0.16189723f, 0.12639165f, 
    0.07097251f, -0.06760045f, 0.03092145f, -0.06398185f, -0.22815360f, 0.32140326f, -0.19669719f, 0.08258876f, 
    -0.05697759f, 0.06859750f, 0.01270315f, 0.03221669f, 0.05967135f, 0.14726900f, 0.00882761f, 0.24688551f, 
    -0.11667337f, -0.05520843f, -0.01830517f, -0.05962049f, 0.00764765f, 0.05373506f, -0.00311585f, 0.12879218f, 
    0.09052358f, -0.12506588f, -0.03928140f, 0.05198660f, 0.09623542f, -0.02857493f, -0.17146379f, 0.21097468f, 
    -0.05602883f, -0.00970975f, 0.07364853f, 0.16459343f, 0.07701180f, 0.01482146f, 0.03142687f, -0.04902804f, 
    -0.02152914f, 0.00640123f, -0.12835747f, -0.04427810f, -0.00427670f, 0.01661717f, -0.03623758f, 0.05682979f, 
    0.02607064f, 0.08793891f, 0.02133266f, 0.07993251f, 0.22998221f, -0.28651673f, 0.02700262f, 0.12661658f, 
    -0.13095342f, 0.03988076f, -0.03659787f, -0.03545816f, -0.00206875f, 0.07773651f, 0.05028973f, -0.00557388f, 
    0.01985968f, 0.02470095f, 0.35897973f, 0.21418069f, 0.10553854f, 0.09394170f, 0.02680666f, -0.00939967f, 
    0.11132439f, 0.05807243f, -0.01375876f, 0.07812551f, 0.16027220f, 0.25326952f, 0.00775643f, -0.14774013f, 
    -0.15811285f, 0.11753671f, -0.11060829f, -0.09416284f, -0.06833121f, 0.04547027f, 0.01335649f, -0.00363577f, 
    0.06992323f, -0.15920058f, -0.23443621f, 0.06340197f, 0.03961961f, -0.00894865f, 0.08023759f, -0.15377200f, 
    -0.03577519f, -0.07947582f, 0.09836483f, -0.07574187f, -0.14477381f, 0.09422746f, -0.12616798f, -0.20770831f, 
    0.02016263f, -0.10692287f, 0.05155092f, 0.00178490f, -0.04298976f, -0.17669702f, 0.05774684f, 0.14869817f, 
    -0.05559029f, 0.04098878f, -0.24017499f, 0.08151174f, -0.18297344f, 0.13348889f, 0.03848220f, 0.01431358f, 
    0.11207432f, 0.04137180f, -0.10002538f, 0.09584740f, -0.12020710f, 0.23044719f, 0.15966080f, -0.24396910f, 
    0.05007745f, -0.02340289f, -0.03945675f, 0.14258699f, 0.01336788f, 0.04546238f, 0.11284631f, 0.02404428f, 
    0.24428582f, -0.08839995f, -0.05080983f, 0.03276563f, 0.06697033f, -0.16950220f, 0.04789820f, -0.00696802f, 
    0.12283592f, -0.01175972f, 0.05985134f, -0.01873101f, 0.03023486f, 0.15191405f, 0.01663536f, 0.05131107f, 
    -0.08908080f, -0.06281362f, 0.01618589f, -0.11847508f, -0.02811608f, 0.12514159f, 0.00198234f, 0.01974488f, 
    -0.19129086f, -0.19865116f, -0.03700562f, -0.10394545f, -0.04598965f, 0.06956062f, 0.00057934f, -0.12731075f, 
    0.07208655f, 0.06943321f, -0.02317498f, 0.08383048f, -0.01714886f, 0.14745507f, 0.16816142f, -0.22291288f, 
    0.05383262f, 0.00040889f, 0.00921424f, 0.09106358f, -0.17085861f, -0.09251229f, -0.16500619f, -0.24717495f, 
    0.10007742f, -0.06973577f, -0.01545152f, -0.04369438f, 0.02981688f, 0.03189808f, -0.09106915f, -0.02816544f, 
    0.03067483f, 0.15599623f, 0.08328590f, 0.20237610f, 0.08061969f, 0.26518062f, 0.36138362f, 0.06514724f, 
    0.04285748f, -0.23493205f, -0.27049336f, -0.05533771f, -0.07478468f, -0.14754389f, -0.03543795f, 0.07941017f, 
    -0.14420022f, -0.10823324f, 0.47442806f, -0.11195974f, 0.17034599f, -0.03221173f, -0.05411425f, 0.19520253f, 
    -0.08336565f, 0.10344107f, -0.01277665f, 0.03405400f, -0.05706605f, -0.12866208f, 0.06293127f, -0.22869176f, 
    0.00227081f, 0.03446442f, 0.07701284f, -0.16592529f, -0.12502395f, 0.01816340f, 0.04012672f, -0.02626519f, 
    -0.05960369f, -0.08223013f, 0.10121537f, -0.02838969f, 0.04378373f, -0.07239503f, -0.27248487f, -0.05402363f, 
    0.01654938f, 0.00086643f, 0.13375510f, 0.11498645f, 0.00878566f, 0.08569576f, 0.07276363f, 0.08558200f, 
    -0.17631988f, -0.10243779f, -0.05194078f, -0.15289518f, -0.02389186f, -0.09458045f, 0.05524263f, 0.10768192f, 
    -0.04066153f, -0.24640237f, 0.13128710f, 0.01398581f, 0.07258917f, 0.10268794f, 0.15450476f, -0.17498147f, 
    0.04389703f, 0.04990564f, 0.12648112f, -0.10833409f, 0.17473090f, 0.00902159f, 0.07248837f, 0.20478347f, 
    0.20734243f, 0.06334063f, 0.03099638f, 0.05082810f, 0.04997210f, 0.02515125f, 0.06274445f, 0.16956156f, 
    0.10477425f, -0.15529004f, -0.39070255f, -0.15078662f, -0.05331313f, -0.02327019f, 0.00657487f, -0.01310357f, 
    -0.00592792f, -0.04058132f, 0.12284545f, -0.00840874f, 0.00047499f, 0.02666719f, 0.30062562f, 0.01655662f, 
    0.01409004f, -0.05192164f, -0.03362833f, 0.14303315f, 0.00188985f, -0.03877833f, -0.05434740f, 0.07629295f, 
    0.15943518f, 0.21337737f, 0.34145772f, 0.11895634f, -0.05761057f, 0.05968501f, -0.17773592f, 0.05709158f, 
    0.00665958f, 0.04991244f, -0.03399904f, 0.06747955f, -0.13661934f, -0.02522364f, 0.06053068f, -0.01880314f, 
    -0.00822361f, -0.06654926f, -0.09603117f, -0.03221954f, -0.15395831f, -0.06628100f, -0.13760236f, -0.09382975f, 
    -0.31902018f, -0.32488343f, -0.12502337f, -0.15112272f, -0.01314957f, -0.00462271f, -0.13745917f, 0.22049688f, 
    -0.04483330f, -0.04210508f, 0.05343466f, 0.07268666f, 0.05355750f, 0.33215466f, 0.00226982f, -0.16453023f, 
    0.02641338f, -0.01937166f, 0.20773619f, 0.11888048f, 0.02902780f, 0.07839558f, 0.01109120f, 0.01353991f, 
    -0.14585397f, -0.06817908f, 0.00936001f, 0.03463913f, 0.04759808f, -0.06197332f, -0.08474084f, 0.08036416f, 
    -0.12468257f, 0.01759650f, -0.15974188f, 0.00976221f, -0.03052187f, 0.05411273f, 0.16841900f, -0.15488859f, 
    0.23684327f, -0.11701256f, -0.15648055f, 0.20266737f, 0.00427568f, -0.03927487f, 0.02906152f, -0.08020564f, 
    0.07030202f, 0.23327386f, 0.23164199f, 0.04434452f, -0.11842775f, -0.01397555f, -0.11092515f, 0.03746966f, 
    -0.04623679f, 0.00094659f, -0.05736298f, 0.09002673f, -0.05684581f, -0.11294760f, -0.21489531f, -0.04185203f, 
    -0.01950683f, 0.02134373f, 0.06185810f, 0.00654801f, 0.20133168f, 0.14452988f, 0.04725214f, 0.21857975f, 
    -0.06160960f, -0.25165623f, -0.10549866f, -0.13691244f, 0.04398542f, 0.11852545f, 0.06728344f, -0.03613257f, 
    -0.07606537f, -0.05290968f, 0.10637484f, -0.16515993f, -0.05243989f, -0.00309502f, -0.08132498f, 0.02426136f, 
    0.14720008f, 0.10494391f, -0.13259776f, 0.01671358f, 0.06007037f, 0.13227776f, -0.04093509f, 0.03208036f, 
    -0.07824448f, 0.05649089f, 0.06757942f, 0.06084972f, -0.01836229f, -0.03176720f, -0.09391592f, -0.07544119f, 
    -0.09893380f, -0.19819404f, -0.13841023f, -0.19723375f, 0.12891980f, 0.26114789f, 0.05714808f, -0.08434892f, 
    0.01651282f, -0.01550240f, 0.04589375f, -0.11152092f, 0.06220520f, 0.04453584f, -0.21780311f, -0.02315592f, 
    0.06244170f, 0.16550830f, -0.18028866f, -0.15450537f, 0.06795485f, 0.13944715f, 0.01421883f, 0.21246383f, 
    0.04464335f, 0.14237823f, 0.13875340f, -0.06164831f, 0.03100482f, -0.16045719f, 0.06973290f, 0.11626765f, 
    -0.17588414f, -0.06812473f, -0.07592413f, -0.06183406f, 0.06355385f, 0.09381279f, 0.08017562f, 0.18850079f, 
    -0.12772761f, 0.00812118f, -0.06291895f, -0.04023221f, -0.00938438f, -0.03160489f, 0.10806538f, 0.07684959f, 
    0.05926839f, 0.00826152f, 0.13325310f, 0.09841631f, 0.14361605f, -0.02481373f, 0.11616524f, 0.07601205f, 
    0.12000395f, -0.01661131f, 0.09647933f, -0.04090430f, 0.01481812f, 0.04443795f, -0.11972450f, -0.20241427f, 
    0.26576081f, 0.03722448f, -0.03430007f, -0.02476754f, -0.17703354f, -0.03327806f, 0.03490257f, 0.01670479f, 
    0.21845481f, 0.00898315f, -0.12896876f, -0.02500575f, 0.00386674f, 0.04634036f, 0.04214482f, -0.03593031f, 
    0.12401208f, 0.00608202f, -0.04838039f, -0.01497144f, -0.06151553f, 0.10346401f, -0.05223427f, -0.22479989f, 
    0.02391058f, 0.10043286f, -0.21514748f, -0.01492673f, 0.01255351f, 0.26734170f, -0.01678984f, 0.23211436f, 
    -0.05530365f, 0.08742489f, 0.02245897f, 0.08988437f, -0.01840032f, -0.01663896f, 0.16871381f, -0.22988579f, 
    0.12381805f, -0.00897303f, 0.07778473f, -0.02443884f, -0.05535774f, -0.04946192f, 0.06438401f, 0.00761061f, 
    -0.09051565f, -0.04504362f, -0.01621876f, -0.06628739f, 0.01298830f, -0.00325450f, -0.03699743f, 0.02567687f, 
    0.08272444f, 0.06368132f, -0.06774466f, -0.04593881f, 0.22771847f, 0.06303927f, -0.11151243f, -0.04313657f, 
    -0.07522333f, -0.18775068f, -0.10795145f, 0.06087670f, -0.07215545f, 0.11698391f, 0.05984319f, -0.03670494f, 
    0.07183868f, 0.28349891f, 0.00564832f, 0.09741107f, -0.07731318f, -0.13189140f, 0.00642515f, -0.09585999f, 
    -0.02722806f, -0.06177947f, -0.01968719f, 0.06364526f, 0.25338683f, 0.26455647f, -0.24000235f, 0.03744003f, 
    -0.13772810f, -0.12914641f, 0.02661465f, 0.13939533f, 0.11380848f, -0.04535360f, 0.15103273f, 0.05168710f, 
    0.20892213f, 0.37521410f, 0.18533699f, -0.03727293f, -0.03870881f, -0.00499321f, -0.04552474f, -0.08913979f, 
    -0.04461779f, -0.00823991f, 0.00845896f, -0.15836947f, -0.11939169f, -0.27093270f, -0.10013322f, -0.14154863f, 
    0.00256410f, 0.14329021f, 0.12019143f, 0.04775551f, 0.17190182f, -0.00787202f, -0.03946595f, 0.08161572f, 
    -0.04022141f, -0.13590330f, -0.27909598f, 0.03715235f, 0.11079758f, -0.01850053f, -0.02112817f, 0.06769297f, 
    0.11425711f, 0.21305111f, 0.06443281f, 0.21267948f, -0.11512230f, 0.32338211f, 0.01122273f, -0.19587517f, 
    0.02803613f, -0.04650239f, 0.01091537f, 0.07437610f, 0.00768274f, -0.05475944f, 0.08823048f, 0.01619319f, 
    -0.02246054f, 0.13362071f, 0.43592376f, -0.07167909f, 0.06615438f, 0.06272310f, 0.00107921f, 0.16190350f, 
    0.02224357f, -0.09101199f, 0.20567554f, -0.00412182f, -0.06291791f, -0.12094426f, 0.20753480f, 0.09267118f, 
    0.07492448f, 0.08211144f, -0.11167029f, 0.00297971f, 0.08675439f, 0.07966931f, 0.15005182f, -0.02868219f, 
    0.08713089f, -0.11683349f, -0.19643459f, -0.12691022f, -0.00155367f, -0.10960869f, 0.02020894f, -0.09650634f, 
    0.30747107f, 0.03850701f, 0.26494569f, 0.04735975f, -0.17092606f, 0.04201194f, -0.14462090f, 0.11394883f, 
    -0.07733345f, 0.05535615f, 0.08486260f, 0.02503525f, -0.00803937f, 0.05667483f, 0.03059696f, 0.15943621f, 
    0.01980731f, -0.17831157f, 0.06655809f, -0.02023574f, 0.15956421f, -0.13177228f, 0.05379481f, 0.15509140f, 
    0.05815083f, -0.06249777f, 0.16165467f, 0.10148162f, 0.18868148f, -0.01918744f, 0.21183430f, -0.10576969f, 
    0.04435951f, -0.09311968f, 0.00052640f, 0.13518550f, 0.06585461f, -0.19474782f, 0.25149670f, -0.13358015f, 
    -0.01114154f, 0.14018975f, 0.12835804f, 0.07103223f, 0.02477300f, -0.05280548f, -0.09787808f, -0.00011761f, 
    0.02237118f, -0.01529855f, 0.12434421f, 0.22415185f, 0.05003018f, 0.07720874f, -0.07157823f, -0.06740491f, 
    0.04724853f, 0.01346816f, 0.22993991f, 0.16545737f, 0.07837711f, -0.01854079f, 0.06007188f, 0.13907301f, 
    0.11388046f, 0.30335242f, 0.07452040f, -0.11744661f, 0.03972828f, 0.10216243f, 0.06434888f, 0.11849510f, 
    0.05739604f, 0.08559075f, -0.04855617f, 0.00116720f, -0.21080202f, -0.30433697f, 0.06988558f, -0.08551608f, 
    0.04544275f, 0.18516320f, 0.09033891f, 0.13235950f, 0.05409535f, -0.02409947f, 0.05554628f, -0.04700305f, 
    -0.13415475f, 0.05826073f, 0.13911495f, -0.04243579f, -0.01719716f, -0.06804423f, -0.10528917f, -0.03098239f, 
    -0.06001189f, -0.05075693f, 0.08787238f, 0.10060409f, -0.15598285f, -0.19089246f, 0.17641300f, -0.11293172f, 
    0.09184518f, -0.00973153f, -0.23412955f, 0.14626375f, -0.07617880f, 0.03160660f, 0.06812484f, -0.13128638f, 
    -0.01029432f, -0.16252527f, 0.01223338f, 0.02898987f, 0.21949770f, 0.18590868f, 0.00916507f, 0.15437782f, 
    -0.14672071f, 0.00780573f, 0.04234595f, 0.02614326f, -0.17061083f, 0.03248469f, 0.05964065f, -0.00324906f, 
    -0.01648250f, -0.11871541f, 0.01041000f, -0.01378935f, -0.06785375f, -0.19092499f, -0.06094344f, -0.02753701f, 
    0.06172862f, -0.04445067f, 0.23611155f, -0.01271425f, -0.06241831f, -0.06942638f, -0.23687129f, 0.06267913f, 
    0.05815399f, 0.02637992f, -0.28037232f, -0.01039534f, -0.21290636f, 0.04282826f, 0.37400687f, -0.05708301f, 
    0.21174219f, 0.01619533f, -0.11284379f, 0.04030898f, 0.09364302f, 0.01041538f, -0.06307498f, 0.01776708f, 
    -0.02395211f, -0.07081365f, 0.04022491f, -0.11135751f, 0.10265566f, 0.08277152f, -0.06481072f, 0.06233180f, 
    0.04470823f, -0.08168036f, 0.07488020f, 0.04246752f, 0.21850160f, -0.08451854f, -0.08632014f, -0.13969345f, 
    -0.08012764f, -0.02993532f, 0.14252228f, 0.00428145f, 0.20856270f, 0.13898088f, -0.02666867f, 0.15623857f, 
    -0.03413764f, -0.26614231f, -0.16235177f, 0.16560008f, -0.10287070f, 0.11313507f, 0.05924263f, 0.04008460f, 
    0.08959778f, 0.04037432f, -0.13660496f, 0.07447274f, 0.03966181f, 0.09565188f, 0.17689325f, 0.05535171f, 
    0.09871198f, 0.05235834f, 0.01463283f, -0.05352026f, 0.09804770f, 0.02580689f, 0.05469474f, 0.09337762f, 
    0.08288630f, -0.02875051f, 0.19087698f, 0.10447741f, 0.22687230f, 0.05719666f, 0.10737405f, 0.10165964f, 
    -0.10801575f, -0.03406951f, 0.06385491f, 0.01216785f, -0.23603152f, 0.05583035f, 0.15431070f, 0.06976237f, 
    0.04305331f, 0.01617021f, -0.02852633f, 0.16958642f, 0.04733337f, 0.08409675f, -0.05424359f, -0.00795341f, 
    -0.14121379f, -0.04884725f, -0.20147388f, -0.09252385f, -0.03354213f, -0.00546172f, -0.19366655f, -0.05533923f, 
    -0.04087155f, 0.00125167f, -0.00475779f, -0.04079515f, 0.01310332f, -0.03304124f, 0.06943671f, 0.00394728f, 
    -0.04445135f, 0.00682172f, 0.00616869f, 0.11415006f, 0.15137874f, -0.01629999f, 0.10763525f, 0.06123219f, 
    0.25910777f, 0.07972217f, 0.22156273f, 0.18219545f, 0.00489672f, 0.02134811f, -0.05555257f, -0.01697526f, 
    0.01026039f, 0.10302276f, -0.02185587f, 0.12666413f, -0.00439522f, -0.08588990f, -0.23005731f, 0.07096434f, 
    0.09065953f, -0.15385149f, -0.05547937f, -0.05325256f, 0.05090381f, 0.00300311f, -0.07007940f, 0.22458370f, 
    -0.11097955f, -0.09191559f, -0.12359188f, 0.15813768f, -0.05494391f, 0.01469969f, 0.05208149f, -0.16610935f, 
    0.00850457f, -0.11234446f, 0.10920068f, 0.05791139f, -0.69727749f, -0.53370368f, -0.03277759f, 0.08513857f, 
    0.02682670f, 0.19008408f, -0.13131201f, -0.20296575f, 0.06853650f, -0.06783999f, 0.00472779f, -0.08250696f, 
    0.02296169f, -0.17501658f, -0.04319989f, 0.09114964f, -0.11118386f, -0.03242061f, -0.18528253f, -0.05172258f, 
    0.16698673f, 0.01543168f, 0.04319014f, -0.05351020f, -0.09664035f, 0.05426964f, 0.18682961f, 0.32212326f, 
    0.12402605f, 0.04959672f, 0.02249208f, -0.06381916f, 0.06902828f, -0.04322349f, 0.00851356f, -0.02080461f, 
    -0.07547005f, -0.03049249f, -0.10834727f, -0.07018722f, 0.01146462f, 0.01061302f, 0.00024186f, 0.05729232f, 
    0.16143365f, -0.03041084f, -0.05491740f, -0.02573272f, -0.29546610f, -0.12381237f, -0.12502347f, -0.02219075f, 
    -0.00037273f, -0.19459575f, -0.06975222f, -0.03655222f, 0.15157719f, -0.00460462f, -0.00807200f, -0.03639656f, 
    0.18606538f, 0.22184347f, 0.22051825f, 0.21022829f, 0.09732295f, 0.02974125f, 0.09863263f, -0.06894317f, 
    0.04014304f, 0.01093751f, -0.00736196f, -0.03692837f, 0.17005235f, 0.39500660f, -0.05898808f, 0.27108186f, 
    0.04900422f, 0.13146463f, -0.06332115f, -0.09430012f, 0.05382481f, -0.03808655f, 0.01590103f, 0.01162799f, 
    -0.07258408f, 0.08237451f, 0.16907930f, 0.08901601f, -0.02658094f, -0.04488256f, -0.00826707f, 0.08317377f, 
    -0.13302682f, -0.04960907f, -0.00681542f, 0.00249910f, -0.27664244f, 0.01857357f, -0.27506909f, -0.28907540f, 
    -0.14466082f, 0.02302752f, -0.20118597f, -0.02648144f, 0.04498227f, 0.07691885f, -0.08361249f, 0.05364639f, 
    -0.09411570f, -0.34305188f, -0.35652110f, -0.25039193f, 0.00594290f, -0.12666281f, -0.08975059f, 0.18009494f, 
    0.19938828f, -0.03449018f, -0.05927249f, -0.04173763f, -0.11416951f, -0.13692366f, -0.18749146f, -0.10257345f, 
    -0.09399068f, -0.08677025f, -0.11703917f, 0.05965788f, 0.18480888f, -0.02298378f, 0.07831457f, 0.08014663f, 
    0.12199267f, -0.02606603f, -0.19155644f, -0.15783979f, 0.23689976f, 0.07262532f, -0.13353506f, 0.12279550f, 
    0.07042266f, -0.01839107f, -0.01544007f, -0.11538000f, -0.07788457f, 0.15585744f, 0.02870721f, 0.31983846f, 
    -0.03678049f, -0.04485334f, 0.07000151f, 0.17329916f, 0.04096882f, -0.00321544f, -0.06521206f, 0.07414012f, 
    0.10317305f, -0.14240299f, -0.08252411f, -0.15343612f, -0.00043477f, 0.01733680f, -0.01314470f, -0.02932194f, 
    0.10583033f, 0.03403004f, 0.04591702f, 0.14463155f, -0.02716350f, -0.14158297f, 0.11420815f, 0.20402110f, 
    0.09363706f, 0.08633380f, -0.21019667f, -0.03311050f, 0.00208836f, -0.01790091f, -0.01646690f, -0.06292216f, 
    0.09136792f, 0.00739572f, -0.20934008f, -0.20271280f, -0.02577009f, 0.01704836f, -0.03908025f, 0.05355038f, 
    0.13132824f, -0.00730517f, -0.09568269f, 0.12134022f, 0.02809261f, -0.04191026f, -0.04597877f, -0.03490405f, 
    0.03821725f, 0.04963986f, -0.08284870f, -0.00089854f, 0.07420731f, 0.06006720f, -0.04421015f, 0.04675183f, 
    -0.00413470f, 0.32820287f, 0.26293701f, 0.33909974f, 0.00871884f, 0.08468463f, 0.15166409f, -0.01759022f, 
    0.07028285f, -0.01673526f, -0.06879175f, 0.11398668f, 0.36087868f, 0.17295410f, 0.10617995f, 0.12016311f, 
    0.09700249f, -0.04663634f, -0.07698864f, -0.08944698f, -0.07884165f, -0.18389571f, -0.04990777f, 0.09825478f, 
    -0.21636020f, -0.23280139f, -0.16553740f, -0.17985170f, 0.04495727f, -0.11688489f, -0.19003566f, -0.06475327f, 
    0.05442703f, 0.09421828f, -0.03163275f, 0.12438222f, -0.07037214f, 0.05702960f, 0.05580351f, 0.06029986f, 
    0.12056845f, -0.16562961f, -0.01507385f, -0.01916700f, 0.03697987f, -0.01830889f, 0.02438695f, -0.02573071f, 
    0.26205632f, 0.17537674f, 0.11620345f, 0.09090061f, 0.22804058f, -0.07044808f, -0.05326147f, 0.00705048f, 
    -0.00622347f, -0.04478278f, -0.04299819f, 0.01062001f, -0.04773781f, -0.18844798f, -0.19489667f, -0.10590819f, 
    -0.01899829f, -0.22100550f, -0.07340056f, 0.02116156f, -0.03394518f, 0.02592918f, -0.05215294f, 0.11153571f, 
    -0.11185231f, -0.01749215f, -0.16346222f, -0.33567670f, 0.00217681f, -0.00036780f, -0.02421890f, 0.02163797f, 
    0.10314734f, 0.10251197f, 0.04674387f, 0.04211502f, -0.24603334f, -0.00440654f, 0.05314970f, 0.12706454f, 
    -0.08208404f, 0.07743586f, 0.02264280f, 0.01109555f, 0.09896682f, 0.11810322f, -0.13896117f, 0.11849649f, 
    0.07296474f, 0.12115711f, -0.08446334f, -0.17927742f, 0.00464088f, -0.06654596f, 0.01093322f, -0.03518225f, 
    -0.05252851f, -0.00410955f, 0.00308050f, -0.00178285f, -0.03308608f, -0.08321980f, 0.05413562f, 0.15381180f, 
    0.05010476f, 0.11169671f, 0.01308546f, -0.08963780f, 0.08717585f, -0.08989848f, 0.02782021f, 0.07618064f, 
    0.05101357f, 0.13762355f, 0.06758749f, 0.10513416f, 0.15635788f, 0.03959136f, 0.22224616f, 0.02435215f, 
    0.11619794f, -0.02115816f, -0.06822752f, 0.07505091f, 0.10195614f, 0.01340783f, 0.25040063f, 0.03170881f, 
    0.16345555f, 0.00567942f, -0.04566261f, 0.02519869f, 0.04541777f, -0.04165612f, -0.02423448f, 0.08796342f, 
    -0.11978462f, -0.06424419f, -0.02568883f, 0.08207837f, -0.04664908f, 0.05857608f, -0.12370782f, -0.11110492f, 
    0.18668574f, -0.00426857f, -0.02329966f, 0.07092655f, 0.03602667f, -0.21602917f, -0.26560462f, 0.06238903f, 
    0.11969644f, -0.14505339f, -0.18725136f, -0.08953240f, -0.01656010f, 0.05166418f, -0.03025074f, 0.13066162f, 
    -0.31970569f, -0.01846906f, -0.08478818f, -0.09172281f, -0.11579857f, -0.00521335f, -0.11168583f, 0.01542523f, 
    0.03216982f, -0.01367275f, 0.05610155f, -0.08056555f, 0.18832147f, 0.03946806f, 0.02143353f, -0.27551621f, 
    0.26207748f, -0.11073414f, -0.12519725f, 0.02230103f, -0.06638922f, 0.09324165f, -0.04874865f, 0.01907001f, 
    -0.17658177f, 0.13150159f, 0.45331979f, 0.38676485f, 0.05673846f, -0.00094086f, -0.01145362f, 0.03897929f, 
    -0.06256568f, -0.03294527f, -0.03823151f, 0.13298513f, 0.33426994f, 0.41753918f, 0.47237048f, 0.00805218f, 
    -0.01896191f, 0.04787873f, 0.10914714f, -0.05351507f, 0.05235760f, -0.02302149f, 0.06995640f, 0.02749041f, 
    0.20744957f, 0.07586065f, 0.11647218f, 0.15752517f, -0.03332023f, -0.05491151f, -0.14612375f, -0.00765681f, 
    0.05109509f, 0.11762592f, -0.00361725f, 0.17886630f, -0.04884895f, -0.31883454f, -0.01565108f, 0.24086061f, 
    -0.02235370f, -0.06188230f, 0.10180308f, 0.09510828f, 0.05284726f, 0.11291477f, -0.00257003f, -0.00924089f, 
    -0.20281065f, 0.19633336f, 0.03586965f, -0.06964030f, 0.21530317f, 0.22219284f, 0.00970388f, 0.14047743f, 
    0.12223431f, -0.02090007f, -0.02135828f, -0.01260908f, 0.22832961f, 0.26676628f, -0.19426866f, 0.01298165f, 
    0.13398705f, -0.01528917f, -0.12822492f, 0.19756417f, 0.06170973f, -0.02055264f, 0.10065252f, 0.03399204f, 
    -0.12167289f, -0.12622222f, -0.21900652f, -0.04243791f, -0.13345480f, -0.02192639f, -0.11833756f, 0.13412584f, 
    -0.06971885f, -0.16573237f, 0.02275899f, -0.04204203f, 0.35462552f, 0.15377161f, 0.21422815f, 0.31112692f, 
    0.15194623f, 0.04505387f, 0.02253429f, 0.13460344f, 0.16613632f, 0.05718939f, -0.02202809f, -0.01645050f, 
    0.04132511f, 0.09765748f, -0.06386419f, -0.16421677f, 0.00268978f, 0.10229053f, 0.03958805f, 0.23085345f, 
    0.12143633f, 0.05590119f, -0.04876275f, 0.17303935f, -0.36740589f, -0.21106264f, -0.04306795f, -0.00186656f, 
    -0.09069879f, 0.10444625f, -0.07346459f, 0.07369442f, -0.08266600f, -0.00764663f, 0.10634048f, 0.07745890f, 
    -0.05087689f, -0.10770517f, -0.05552126f, -0.27162692f, 0.06216205f, 0.08175263f, -0.04329126f, 0.19926636f, 
    0.07839458f, 0.01591937f, 0.00290208f, 0.14119849f, -0.12966177f, -0.06920668f, 0.36727992f, 0.09058880f, 
    -0.02822472f, -0.02447463f, -0.03011783f, 0.13637619f, -0.00325394f, -0.10909960f, -0.05465165f, 0.05155036f, 
    -0.12730314f, 0.10980048f, -0.14629439f, -0.06374708f, 0.15995519f, -0.04578561f, -0.05468001f, 0.02672634f, 
    -0.01607559f, -0.04146286f, -0.08125050f, 0.00253371f, 0.24561980f, 0.22375315f, 0.72241259f, 0.45608523f, 
    0.04426457f, 0.01990872f, 0.07597126f, 0.17271730f, 0.10199370f, -0.10021477f, -0.04585340f, 0.07904200f, 
    -0.44313428f, -0.28633285f, -0.08989460f, -0.04574358f, -0.00932865f, 0.03728320f, -0.18339947f, -0.05778418f, 
    0.08451564f, 0.05777000f, -0.03865471f, 0.06330495f, 0.01686055f, 0.07304304f, -0.01145428f, 0.02179528f, 
    0.03043955f, 0.02265226f, -0.12655060f, -0.06696337f, 0.21036036f, 0.20487075f, 0.09471773f, -0.00265101f, 
    0.06367281f, 0.13465203f, 0.12159850f, 0.21613637f, 0.04210492f, -0.02461170f, 0.05899975f, 0.18361661f, 
    0.09310194f, -0.02923475f, 0.07384787f, 0.04625038f, -0.14130846f, 0.01922306f, -0.19897251f, -0.20850132f, 
    -0.03240385f, -0.07699382f, -0.20782888f, -0.08728895f, 0.06974968f, 0.07012312f, -0.07576719f, 0.01215681f, 
    0.03319404f, -0.07216530f, -0.09580852f, 0.02997440f, 0.13173580f, -0.13986136f, -0.00209259f, -0.09722653f, 
    0.05942814f, 0.07697139f, 0.04912274f, 0.16418649f, -0.08393322f, -0.11550273f, -0.07174332f, 0.15642580f, 
    -0.08494658f, 0.13284993f, -0.02750980f, 0.04130007f, 0.08117397f, 0.14688587f, 0.04188747f, 0.19385193f, 
    0.15746707f, 0.07826945f, -0.00533093f, 0.10633779f, 0.14477491f, 0.08705460f, -0.26195714f, 0.03995381f, 
    -0.02373059f, -0.09982317f, -0.08071438f, 0.00618611f, -0.01639894f, 0.14074761f, -0.31346354f, -0.05442569f, 
    -0.09000325f, -0.08116400f, -0.02280464f, 0.19917946f, -0.22305100f, 0.04533654f, -0.10829005f, 0.10515841f, 
    0.01438541f, 0.00950129f, 0.02669886f, -0.02357468f, -0.00169519f, 0.02346293f, -0.00286216f, 0.02195622f, 
    0.02865051f, 0.01262217f, -0.02543933f, -0.02671585f, -0.03792063f, 0.02974548f, -0.02599935f, -0.00335948f, 
    -0.00614390f, 0.01540718f, 0.01928685f, 0.01929516f, -0.02021518f, 0.01772938f, -0.01499587f, -0.03746859f, 
    0.00306708f, 0.00360429f, 0.02868635f, -0.04124529f, -0.04044206f, -0.01412382f, 0.02791587f, -0.02228398f, 
    -0.01961822f, -0.01675965f, 0.01836044f, -0.04086248f, -0.02201430f, -0.03199367f, 0.02065373f, -0.03952661f, 
    -0.02539841f, -0.03055052f, 0.03775763f, -0.03323975f, -0.03655770f, -0.02854847f, -0.03488890f, 0.00851564f, 
    0.03285892f, -0.00986491f, 0.02170776f, -0.02000077f, 0.00614088f, -0.03026216f, -0.01850112f, 0.02395224f, 
    0.01922572f, -0.02854475f, -0.02972667f, 0.04134217f, 0.00258249f, -0.02210026f, -0.02533523f, 0.00990662f, 
    0.00800436f, -0.01347451f, -0.02805837f, -0.00862779f, 0.01428027f, -0.01301152f, 0.01723771f, -0.00939189f, 
    0.02675384f, -0.00980711f, -0.01850111f, -0.01904282f, 0.00808754f, -0.01249122f, -0.03208916f, -0.01624596f, 
    -0.00220616f, 0.00478476f, -0.02465632f, 0.02305146f, -0.03814470f, 0.00642430f, 0.00268599f, -0.00910967f, 
    -0.04063802f, -0.00426282f, -0.01333364f, -0.02768747f, 0.01535981f, -0.03512319f, -0.03520766f, -0.02251750f, 
    0.01226116f, -0.00356658f, -0.01204493f, 0.02712821f, 0.01084894f, 0.00877502f, -0.01892980f, 0.01637362f, 
    -0.00508349f, 0.01958730f, -0.02252237f, -0.03911214f, -0.02607498f, -0.01731453f, -0.00694495f, -0.01147794f, 
    0.02358955f, -0.00487428f, -0.00904545f, -0.02148720f, 0.02940375f, -0.01227017f, -0.01965450f, 0.00385673f, 
    0.02814330f, 0.00203430f, 0.01119707f, 0.02067871f, 0.01770987f, 0.04058196f, -0.03169901f, -0.00909776f, 
    -0.01993173f, -0.00307887f, 0.02662001f, 0.02568089f, 0.01894685f, -0.03937586f, -0.01017779f, -0.01503525f, 
    -0.02018906f, 0.02006037f, -0.02048734f, 0.00935752f, 0.01123304f, 0.02256351f, 0.00513508f, -0.03393473f, 
    0.02141497f, 0.03986256f, 0.00574042f, 0.00973692f, -0.02448798f, 0.01233946f, 0.02894226f, 0.02020706f, 
    -0.00866733f, -0.02097338f, 0.01908362f, -0.01975097f, 0.00075366f, 0.00512632f, 0.00870208f, -0.00359864f, 
    -0.02499831f, 0.00270666f, -0.00522509f, 0.03716442f, -0.01342214f, -0.01249059f, -0.00160742f, 0.01857208f, 
    -0.00678437f, -0.00501124f, -0.02711620f, -0.00209440f, 0.00081854f, -0.03286824f, 0.02574418f, 0.00753875f, 
    -0.02519192f, -0.00820768f, 0.02516648f, -0.01270808f, -0.03221317f, 0.02779288f, -0.00297242f, -0.00798776f, 
    -0.03789647f, 0.00002800f, -0.03786586f, -0.04132604f, -0.03463523f, 0.02841493f, -0.00135242f, -0.03926431f, 
    -0.01483376f, -0.03511672f, 0.01200710f, 0.01966393f, -0.01864354f, 0.01329726f, -0.02320870f, -0.00186359f, 
    -0.01926696f, 0.00731639f, 0.00040261f, 0.02138067f, -0.01714186f, -0.01397654f, -0.01097372f, 0.02731512f, 
    0.01433438f, -0.02602862f, 0.01459961f, -0.02935775f, 0.02250737f, -0.00248620f, 0.03125820f, 0.03825505f, 
    0.02748113f, -0.04154032f, 0.03019569f, -0.00876486f, -0.02062704f, -0.00942481f, 0.00689065f, -0.02199136f, 
    0.00855723f, -0.01910611f, 0.00491657f, -0.00653062f, 0.02879361f, -0.04206158f, -0.01471352f, -0.02849057f, 
    -0.00387028f, -0.03301157f, -0.03597083f, -0.02464561f, -0.00481045f, -0.01835770f, 0.01189459f, -0.02215107f, 
    -0.00648324f, 0.03001685f, 0.00521704f, -0.00941961f, 0.02247523f, -0.00952388f, 0.01628411f, 0.01925927f, 
    -0.00301904f, -0.01568444f, 0.01244424f, -0.01573699f, -0.03420402f, -0.00284171f, 0.00218930f, -0.03010798f, 
    -0.02512734f, 0.01997189f, 0.02903209f, -0.02542538f, 0.01373543f, -0.01537516f, 0.00385176f, 0.01238848f, 
    -0.01557361f, 0.02277146f, -0.03061703f, -0.01841017f, -0.02538217f, -0.02319364f, -0.02100238f, -0.01362121f, 
    0.00232194f, 0.02151403f, 0.02022417f, -0.02033760f, 0.00743505f, -0.00545517f, -0.01295215f, -0.01231238f, 
    0.02280014f, 0.00414901f, -0.02555689f, -0.00250019f, -0.02345925f, -0.00503930f, -0.04064095f, -0.02636487f, 
    0.02460163f, 0.02560733f, -0.04022880f, -0.00487785f, 0.01101126f, 0.01710024f, 0.00660604f, -0.03282408f, 
    -0.03744024f, 0.00626653f, 0.03413832f, -0.01994525f, -0.01735509f, 0.01647276f, 0.02587064f, -0.01717715f, 
    0.00593302f, -0.00682058f, 0.01248311f, -0.01091012f, 0.01452801f, -0.00733797f, -0.02363993f, 0.02496653f, 
    0.02752131f, 0.01390847f, 0.01172818f, 0.00398217f, 0.00746174f, -0.00305212f, -0.02800102f, 0.01371729f, 
    0.01515281f, 0.02911038f, 0.02296869f, 0.00843790f, 0.01557405f, -0.02177058f, 0.00345017f, -0.02170737f, 
    -0.00981666f, 0.02258045f, -0.02977280f, -0.01012628f, -0.00913848f, -0.01826729f, 0.01418426f, -0.00246243f, 
    -0.02069081f, 0.02374133f, 0.01124109f, 0.02414759f, -0.04012873f, 0.00069952f, 0.00708337f, 0.00338805f, 
    0.00757964f, 0.02984562f, -0.01185012f, 0.00514814f, 0.02993204f, 0.02721612f, 0.01370982f, -0.03811931f, 
    -0.02263716f, 0.00831816f, -0.02906268f, -0.01489565f, -0.01617422f, -0.03910841f, 0.01429032f, -0.02212389f, 
    0.01136056f, 0.01136541f, -0.01381157f, -0.03885384f, 0.00993582f, -0.02636094f, -0.03931845f, 0.00189346f, 
    0.01422808f, -0.01941801f, -0.01323911f, 0.01365931f, 0.00046602f, -0.01881444f, -0.01318621f, -0.01185480f, 
    0.02577469f, -0.01682913f, -0.01458433f, -0.03372457f, -0.00676297f, 0.04086919f, -0.01787519f, -0.03679416f, 
    0.03505351f, 0.00158327f, -0.03604824f, -0.02983448f, 0.00576712f, -0.02230617f, -0.01907584f, -0.01730101f, 
    0.02474145f, -0.00853491f, 0.03254763f, 0.00237290f, -0.02128358f, -0.01616360f, -0.00787826f, 0.01711483f, 
    -0.02734663f, -0.00336019f, 0.01188380f, 0.01122308f, 0.03830513f, 0.02713333f, 0.01899130f, -0.00941980f, 
    0.03329499f, 0.03782289f, 0.03822421f, 0.02658506f, -0.01623398f, -0.02781240f, -0.01358274f, 0.01177576f, 
    -0.03328731f, -0.03950857f, -0.01430194f, 0.04042345f, -0.01180938f, 0.00167079f, 0.00478521f, -0.02340427f, 
    0.02804923f, -0.03202901f, 0.00317417f, 0.02873503f, -0.03467676f, -0.00214916f, 0.02624949f, -0.00242477f, 
    -0.00507001f, -0.03283874f, 0.00302534f, -0.03631216f, -0.00287080f, -0.00455340f, 0.00862038f, -0.02738435f, 
    0.02366025f, 0.00092550f, -0.02558183f, 0.02345139f, 0.02932255f, -0.02489508f, 0.00170238f, 0.01697513f, 
    -0.02904967f, -0.03797251f, -0.03098849f, -0.03424464f, -0.00827674f, -0.02271526f, 0.02624205f, -0.02395972f, 
    0.00723945f, 0.02703583f, -0.03176642f, 0.02957754f, -0.04112900f, -0.00914660f, -0.01451613f, 0.03748879f, 
    -0.03079451f, 0.01261438f, -0.00872869f, -0.03251813f, 0.00054897f, -0.01752727f, -0.04088316f, -0.02179401f, 
    -0.03311879f, 0.00381472f, 0.00480773f, -0.03574779f, 0.00115117f, -0.01815721f, 0.00739646f, -0.00685719f, 
    -0.02860409f, -0.01316653f, 0.01231285f, -0.02565056f, 0.02358248f, -0.02560017f, -0.04181041f, 0.02430415f, 
    -0.00491849f, 0.00503729f, -0.00917238f, -0.00239001f, 0.00929094f, -0.00094732f, 0.01264415f, -0.03514333f, 
    0.00415577f, 0.01269948f, -0.01148618f, -0.02346133f, -0.03837247f, 0.02992015f, -0.00594212f, 0.02686322f, 
    0.00302266f, -0.01503302f, -0.03577230f, -0.01113701f, -0.03295277f, -0.01705705f, 0.02120522f, 0.02406511f, 
    0.00849848f, -0.03064880f, -0.00734382f, -0.00675879f, -0.00134194f, -0.01463155f, 0.02609540f, 0.02230743f, 
    0.02974201f, -0.01378710f, -0.03741788f, -0.00870912f, -0.00577882f, 0.01832999f, -0.04022849f, -0.00482695f, 
    0.01358578f, -0.00950201f, -0.03644096f, -0.01308385f, 0.01914892f, -0.00415528f, 0.01863646f, -0.03804544f, 
    0.01406170f, 0.01218428f, 0.01113215f, 0.00636413f, 0.00733743f, -0.02320770f, -0.00633752f, -0.02975627f, 
    -0.01452772f, 0.03002305f, -0.02888091f, 0.02692658f, -0.00390592f, -0.02337758f, 0.02339601f, 0.02866279f, 
    -0.02205984f, -0.01293940f, -0.03193268f, 0.01099566f, 0.02900200f, -0.04007059f, -0.00164998f, 0.00966852f, 
    -0.03228160f, 0.02388723f, -0.02870018f, 0.00917091f, -0.02743581f, 0.01222317f, 0.00727661f, -0.01673873f, 
    -0.00418395f, -0.03909254f, -0.01717444f, -0.01810238f, 0.00383513f, -0.01117677f, -0.00950013f, 0.01530747f, 
    -0.01562759f, 0.03894994f, 0.01681792f, -0.03800559f, -0.01566983f, -0.02096866f, -0.00397850f, -0.00756823f, 
    0.02308731f, 0.00029991f, 0.02867780f, 0.02306547f, 0.00474760f, 0.02978509f, -0.01731838f, -0.02117050f, 
    0.00857856f, -0.03276109f, 0.01684181f, 0.01491503f, -0.02320340f, 0.01088867f, -0.01966257f, -0.02495131f, 
    0.02633114f, -0.03242105f, 0.00376953f, 0.03744102f, 0.01591225f, 0.00716389f, -0.02030158f, -0.01343442f, 
    -0.02774463f, -0.00069767f, -0.03815290f, -0.02545172f, 0.02745642f, -0.02594174f, -0.00397450f, -0.04098519f, 
    -0.01955735f, 0.01225705f, -0.00719434f, -0.02666984f, 0.00241642f, 0.04020366f, -0.03023152f, 0.00040903f, 
    0.01499002f, -0.01202388f, -0.01300585f, -0.00441885f, 0.01211682f, -0.03216597f, 0.01923612f, -0.01941695f, 
    -0.00744620f, -0.01089581f, -0.00928867f, -0.03533269f, -0.03269429f, 0.00203600f, -0.01916515f, -0.02046584f, 
    0.02217590f, -0.02760703f, -0.02249952f, -0.00130157f, 0.01185044f, 0.03499920f, 0.00915804f, -0.02257727f, 
    0.03978942f, -0.01152582f, 0.00338921f, -0.00001191f, -0.01693934f, -0.00566568f, -0.01581347f, -0.03310483f, 
    -0.02409356f, 0.00227688f, 0.01270787f, -0.03266168f, -0.01122328f, -0.00913205f, 0.01900514f, -0.02336383f, 
    -0.00404873f, -0.04185992f, 0.01618229f, 0.00459100f, -0.02594124f, 0.02612315f, 0.02734332f, 0.01869546f, 
    -0.02340857f, -0.01578196f, 0.02151555f, -0.01559578f, -0.02216267f, 0.02760457f, 0.01255683f, 0.02055479f, 
    -0.01496825f, 0.01729238f, 0.02076601f, -0.00687703f, -0.01236332f, -0.03403539f, 0.02698167f, -0.00195425f, 
    -0.02380426f, -0.03862943f, -0.04123027f, 0.00995976f, 0.01495689f, 0.00314163f, -0.00813918f, 0.01836708f, 
    0.02446704f, 0.02624018f, -0.00897985f, -0.00691677f, -0.00664425f, -0.03045879f, 0.01022809f, 0.00116552f, 
    -0.00551380f, 0.02613086f, -0.00486588f, 0.02254798f, 0.01138898f, -0.01496454f, 0.02714252f, -0.02394585f, 
    -0.03725696f, 0.03026226f, -0.03333915f, 0.00227652f, -0.03529701f, -0.03671751f, -0.00488537f, 0.00346724f, 
    0.00558806f, -0.03675237f, -0.00344417f, 0.00505844f, -0.02216229f, -0.01563856f, -0.02427281f, 0.02396074f, 
    -0.01494341f, 0.00317708f, -0.02842236f, 0.00415550f, -0.00856068f, 0.02537789f, 0.00161504f, -0.01688626f, 
    -0.02016085f, -0.00019674f, -0.00266754f, -0.01271507f, 0.01267675f, 0.00792176f, -0.01435378f, -0.01520075f, 
    0.02194236f, 0.02021637f, -0.01227045f, 0.01080322f, -0.00084184f, 0.00736161f, 0.00714298f, 0.01077649f, 
    0.01596256f, -0.01844343f, 0.02925838f, -0.00268506f, -0.01248662f, -0.03991808f, -0.03090134f, -0.01824158f, 
    -0.03987211f, -0.01302951f, -0.00125616f, -0.01118362f, -0.00150776f, -0.00725085f, -0.00515961f, -0.00740738f, 
    -0.00577295f, 0.01800219f, -0.02976965f, 0.02576383f, -0.00082861f, 0.00307269f, -0.01023102f, -0.00508073f, 
    0.01689062f, 0.00629935f, 0.02209987f, -0.01790945f, -0.02363301f, -0.01792403f, -0.02979729f, -0.03696147f, 
    -0.01434544f, 0.02660295f, -0.03346659f, 0.00215352f, 0.01782226f, -0.01395144f, -0.03508981f, 0.00394100f, 
    -0.03670029f, -0.01363776f, 0.00606748f, -0.03407544f, -0.00481559f, -0.01943940f, 0.01238630f, -0.02679731f, 
    0.01242889f, -0.01485074f, -0.03306992f, -0.02635686f, 0.00940529f, -0.03373205f, 0.01088327f, -0.03821342f, 
    -0.03808071f, -0.02548497f, -0.01915018f, 0.01075284f, -0.02805805f, 0.02407064f, -0.02077030f, 0.01216835f, 
    -0.02566134f, 0.02534813f, 0.00320855f, -0.03847399f, 0.02677250f, 0.01078403f, -0.02184802f, -0.03641715f, 
    0.02104485f, -0.00529598f, 0.01083861f, -0.04039166f, -0.02693480f, 0.02432401f, -0.01074246f, 0.01628786f, 
    -0.00246917f, -0.02306943f, 0.01376706f, 0.00098666f, -0.02741515f, 0.00698224f, -0.00742652f, 0.03569088f, 
    0.02466109f, 0.02526428f, -0.02970317f, -0.01057929f, 0.00354553f, -0.00019645f, -0.00243946f, -0.03422911f, 
    0.01213631f, -0.00903536f, -0.01664475f, 0.01540136f, -0.03371163f, 0.02700468f, 0.01952013f, 0.01215224f, 
    0.00633260f, 0.02891571f, 0.02069106f, -0.04041945f, -0.03529359f, -0.01826569f, 0.01851716f, -0.01885512f, 
    0.00724637f, -0.00595721f, -0.01093643f, -0.00597665f, 0.01538785f, 0.02584872f, 0.01345318f, 0.01571865f, 
    0.02929981f, 0.02690137f, 0.01550180f, 0.00873681f, 0.02096386f, 0.00338716f, 0.02136920f, 0.00040686f, 
    0.02205468f, -0.03909708f, -0.00649524f, -0.04029183f, 0.04083183f, 0.01436584f, -0.00838682f, 0.02225137f, 
    0.02374031f, 0.00682752f, -0.03191682f, -0.03189910f, 0.02527470f, -0.00455320f, -0.03014232f, 0.00019058f, 
    0.00110662f, 0.01409786f, 0.00415780f, 0.02073621f, 0.00429493f, 0.00549420f, -0.03763296f, 0.01248699f, 
    -0.01246509f, -0.04377982f, 0.02438854f, 0.01011628f, -0.01782169f, 0.01998565f, -0.01225698f, -0.01628153f, 
    -0.04063210f, -0.02651452f, -0.02334257f, -0.03505053f, 0.02474297f, -0.02964788f, -0.01327610f, -0.01004899f, 
    -0.01728539f, 0.03741986f, 0.02906232f, -0.02340883f, -0.01264721f, -0.03383659f, 0.00678437f, 0.02058241f, 
    -0.04089944f, -0.01784720f, -0.04360695f, 0.00049443f, -0.02422398f, -0.02191930f, 0.00914726f, -0.00963317f, 
    0.00264617f, 0.02112345f, 0.00060792f, -0.00991772f, 0.01759771f, -0.02264108f, -0.02820658f, 0.00394827f, 
    -0.00514482f, 0.02423223f, 0.01639029f, -0.02847900f, -0.00204961f, -0.01121690f, 0.02801346f, 0.00020121f, 
    0.02229833f, -0.02400671f, -0.00463153f, -0.01572383f, -0.00042683f, -0.02836431f, -0.02207309f, 0.02116461f, 
    0.00469653f, -0.03843495f, 0.02573545f, -0.01045562f, -0.00486720f, 0.03348855f, -0.04047701f, 0.01774092f, 
    -0.03455953f, -0.00589262f, -0.03978724f, -0.01029457f, -0.01131106f, -0.03416976f, -0.03184366f, -0.00971457f, 
    0.01561089f, 0.00092498f, -0.00371005f, -0.02092881f, -0.02225826f, -0.02012862f, -0.00901067f, -0.01544114f, 
    -0.03507595f, -0.01702536f, -0.02315019f, -0.00739330f, 0.02670430f, -0.01249854f, 0.00413623f, 0.01968139f, 
    -0.02688697f, -0.01718950f, -0.01622789f, -0.00842363f, 0.02175614f, 0.02185163f, 0.02622044f, 0.01240239f, 
    -0.01792846f, 0.01543209f, -0.01463953f, -0.03621072f, 0.01212336f, -0.01914876f, 0.00021792f, 0.00352647f, 
    -0.02755601f, 0.00016108f, -0.03541157f, -0.00401685f, -0.00477098f, -0.01529584f, 0.01645176f, -0.03602361f, 
    -0.00810014f, -0.03546078f, 0.02220624f, 0.03896458f, 0.00118870f, -0.02552311f, 0.01565866f, -0.01012475f, 
    -0.00421986f, -0.03980620f, 0.02445416f, -0.01591060f, 0.03404731f, -0.01822883f, 0.00645256f, -0.03544974f, 
    0.01090228f, -0.00434160f, -0.00971268f, 0.00693864f, -0.02021526f, 0.02746173f, 0.01983755f, -0.02337188f, 
    -0.01954974f, -0.03439379f, -0.01410040f, -0.01308795f, -0.00608738f, -0.01262396f, -0.00774729f, -0.00626395f, 
    0.02971456f, -0.02968273f, 0.02370961f, -0.03518411f, -0.00583820f, -0.03445068f, -0.02149755f, -0.00835472f, 
    -0.03151299f, -0.04197264f, 0.01195190f, 0.02811407f, -0.02695095f, 0.01890188f, 0.01628508f, -0.03542829f, 
    0.02424525f, -0.01236561f, 0.01679684f, -0.03628312f, -0.03762270f, 0.02341397f, -0.00952446f, 0.01393533f, 
    -0.04150846f, 0.02449487f, -0.03202477f, 0.01916206f, 0.02531253f, -0.01677548f, -0.03778449f, -0.02086408f, 
    0.00136027f, 0.01884679f, -0.01950741f, -0.00201478f, -0.03147068f, 0.01734873f, 0.02603355f, -0.02082914f, 
    -0.01196182f, -0.01353961f, -0.04029651f, 0.01905960f, 0.00513958f, 0.00818215f, -0.00040481f, 0.00851387f, 
    0.00967789f, -0.00283478f, -0.01174615f, 0.01225385f, -0.02523998f, 0.01764853f, -0.02967949f, 0.01186247f, 
    -0.02388484f, -0.03884733f, 0.00478828f, 0.02407524f, 0.01828346f, -0.00103685f, 0.00873840f, -0.00547272f, 
    -0.02766281f, 0.01769493f, 0.01279193f, 0.00419456f, 0.03245159f, 0.00208138f, -0.04251826f, -0.03594824f, 
    0.01689843f, -0.02280685f, 0.02696592f, 0.01152751f, -0.01948560f, 0.00709636f, 0.01414709f, 0.02618701f, 
    -0.02532403f, -0.01742231f, 0.00831929f, -0.00074125f, 0.02376576f, -0.03201584f, -0.02707475f, -0.01150688f, 
    -0.01561579f, -0.01490785f, -0.02524226f, 0.00076606f, 0.00996163f, 0.00636535f, 0.00238032f, -0.03803582f, 
    -0.02007500f, 0.00902723f, 0.02311862f, 0.00771479f, 0.01104663f, -0.00878620f, 0.02841347f, -0.01353293f, 
    0.02523677f, -0.02272820f, -0.03996435f, 0.01781397f, -0.00141599f, 0.02293987f, -0.01620509f, -0.02784106f, 
    -0.02032891f, -0.03192400f, -0.03832657f, -0.02598396f, -0.03061463f, -0.00169166f, -0.04162565f, 0.01490559f, 
    -0.03196701f, -0.00509460f, -0.00169247f, 0.01455800f, 0.01157267f, 0.00977187f, 0.02733619f, -0.01622382f, 
    0.02051210f, 0.01080714f, 0.01114861f, -0.03349215f, 0.01933607f, -0.00621805f, -0.03820559f, 0.02419817f, 
    -0.00298238f, 0.02565612f, -0.03952643f, 0.01545758f, -0.02192109f, -0.00568661f, 0.01739885f, 0.01722053f, 
    0.00513568f, -0.03441378f, 0.00122522f, -0.02229983f, -0.02750484f, -0.01522144f, 0.01839087f, -0.00506166f, 
    0.02514016f, 0.02159774f, -0.02556390f, 0.00180709f, -0.01892186f, -0.02414708f, -0.00166339f, -0.03259077f, 
    0.00016372f, 0.00692196f, 0.02651589f, 0.00929470f, -0.00002087f, -0.02805717f, 0.01229437f, -0.01407294f, 
    0.02856961f, -0.00803939f, -0.03434552f, -0.03157586f, 0.02100770f, 0.01531055f, -0.00942195f, -0.01068569f, 
    0.01894085f, 0.02639365f, 0.00779556f, 0.02585495f, 0.02315139f, 0.02205218f, -0.02156800f, 0.02912604f, 
    -0.02070857f, -0.01585473f, 0.01128510f, -0.00594750f, -0.00286852f, 0.01149204f, -0.03688756f, 0.00305108f, 
    -0.02129191f, -0.00606452f, 0.02162138f, -0.04020920f, -0.03400782f, 0.01159792f, -0.01330300f, -0.01184273f, 
    0.01555458f, -0.01615018f, 0.01456951f, -0.00475594f, -0.02777811f, 0.02523782f, -0.00327259f, -0.02765664f, 
    -0.01638037f, 0.01796064f, 0.02139376f, 0.02389844f, 0.01717011f, -0.00113016f, -0.03340638f, 0.01195727f, 
    -0.03919652f, 0.01022833f, -0.00419162f, -0.01432703f, 0.00544879f, -0.00659419f, -0.02695163f, 0.02681727f, 
    0.03045949f, 0.03478191f, -0.02865173f, 0.01023374f, -0.03141687f, -0.01673241f, -0.01433804f, 0.01317430f, 
    -0.03932617f, -0.00623399f, 0.02114641f, -0.00662034f, -0.03958027f, -0.00100018f, -0.03534217f, -0.01658489f, 
    -0.01653082f, 0.00405116f, -0.01404339f, 0.03423024f, 0.00012610f, -0.01743857f, -0.00263018f, -0.01625356f, 
    -0.03676818f, -0.02825759f, 0.00647142f, -0.03286215f, 0.02116400f, 0.01481227f, 0.01929227f, -0.02902595f, 
    0.00476139f, -0.04040892f, -0.03128560f, 0.03513834f, 0.04098102f, -0.01208323f, 0.02597623f, 0.01946149f, 
    -0.00540517f, -0.00914826f, 0.00138381f, -0.01955658f, 0.01773642f, -0.01583230f, 0.01765046f, -0.03164792f, 
    0.00287170f, -0.00882032f, -0.03955157f, 0.01522016f, -0.01253299f, -0.01732877f, -0.01357396f, 0.00523986f, 
    0.01215677f, -0.01425916f, -0.01763421f, 0.02038840f, -0.01230853f, 0.01501365f, 0.02353474f, -0.03464347f, 
    -0.03962427f, -0.02381594f, -0.00218263f, 0.00559180f, -0.03932453f, 0.01911565f, 0.00473524f, -0.02872741f, 
    -0.03869922f, -0.02606676f, -0.00140048f, -0.00044616f, 0.00050635f, 0.00997696f, 0.00207288f, 0.01252282f, 
    0.01085157f, -0.01316526f, 0.02504085f, 0.01551911f, 0.00496493f, 0.00928455f, -0.03039593f, -0.01430819f, 
    -0.04296691f, -0.02668058f, -0.00884250f, 0.01203561f, -0.00931668f, -0.02975559f, -0.00753990f, 0.01978688f, 
    0.02917801f, 0.00159497f, 0.02258378f, -0.02683461f, -0.03161271f, -0.00013887f, 0.01491355f, -0.03665338f, 
    -0.01388191f, -0.01559302f, 0.00831022f, 0.00733740f, -0.01975875f, -0.03399196f, -0.03086263f, 0.02474192f, 
    -0.03089091f, 0.03091438f, -0.01614409f, 0.02825124f, -0.01604776f, -0.00541919f, -0.02397871f, -0.00182158f, 
    0.01754571f, -0.03949255f, -0.03784913f, -0.02598025f, -0.02561168f, -0.00773787f, -0.04115807f, -0.00026705f, 
    -0.01743658f, 0.02492844f, 0.00479144f, -0.03314155f, 0.01723554f, -0.03214819f, -0.03286075f, 0.02278094f, 
    -0.04097052f, 0.00257304f, -0.00073728f, 0.00283971f, 0.01335823f, -0.04349325f, -0.03219255f, -0.01169551f, 
    0.01300200f, -0.02370819f, 0.01275917f, 0.01554646f, 0.01024083f, -0.02962898f, -0.00966348f, -0.04037413f, 
    -0.02184338f, 0.01092314f, -0.03867716f, 0.00084980f, 0.00455834f, 0.00692267f, -0.00502869f, -0.02867449f, 
    -0.02500385f, 0.03431851f, -0.00429635f, -0.00100345f, -0.01680950f, -0.02069486f, 0.00446034f, 0.02212046f, 
    0.01368640f, -0.00912710f, 0.00712255f, -0.00755142f, -0.00311872f, 0.02010429f, 0.01996741f, -0.01188568f, 
    -0.00091904f, -0.00024447f, 0.01781049f, 0.01443957f, -0.00882589f, -0.01308258f, 0.00499140f, 0.00007405f, 
    -0.04140308f, 0.01381504f, -0.03424190f, -0.00092290f, -0.02969773f, -0.01019167f, 0.02461282f, 0.00164230f, 
    0.00838656f, 0.00331064f, -0.02637304f, 0.01027614f, 0.02504279f, -0.02599064f, -0.02977033f, 0.01049861f, 
    -0.02404848f, -0.01305263f, 0.00847347f, 0.00457889f, -0.01664221f, -0.03726228f, -0.01353688f, -0.03909930f, 
    0.00971009f, 0.02148260f, -0.03400170f, -0.03887575f, -0.01075661f, -0.01571354f, -0.03706449f, -0.01615613f, 
    -0.03384103f, -0.03554928f, -0.00570276f, 0.02780567f, -0.00187291f, -0.00679297f, 0.02150880f, -0.02875933f, 
    0.02533697f, -0.02466403f, 0.02204827f, 0.01639102f, -0.02025123f, -0.01780464f, -0.00115354f, -0.01941659f, 
    0.01885670f, -0.03954308f, -0.03593631f, -0.01239201f, -0.03745152f, 0.02380523f, 0.01883960f, 0.00851645f, 
    -0.02874112f, -0.03477419f, -0.01472899f, -0.03737829f, 0.03035287f, 0.01212616f, 0.02266433f, -0.04003006f, 
    -0.00143018f, 0.03062589f, -0.03309419f, -0.03538644f, 0.01455119f, -0.04055910f, -0.03401672f, -0.03077262f, 
    -0.03288116f, -0.03028396f, 0.00267600f, 0.00306282f, -0.01639621f, 0.02474088f, 0.01242999f, 0.00410606f, 
    0.01012781f, 0.02194410f, -0.01847958f, -0.04438452f, -0.04518877f, -0.04573577f, -0.04752741f, -0.02821602f, 
    -0.04690124f, -0.04955934f, -0.01328992f, -0.03185607f, -0.05656378f, -0.06791621f, -0.07314784f, -0.00738325f, 
    -0.04336255f, -0.07979044f, -0.04197242f, 0.01850021f, -0.00604914f, -0.02094395f, -0.01727479f, -0.05912437f, 
    -0.02225273f, -0.04188025f, -0.04320416f, -0.07535222f, -0.01750210f, -0.08469083f, -0.04049298f, -0.05403243f, 
    -0.00748264f, -0.01602807f, -0.06464966f, -0.07884244f, -0.03749938f, -0.04458009f, -0.05528732f, -0.03876475f, 
    0.00346276f, -0.04288562f, -0.02440764f, -0.01728971f, -0.01769371f, -0.00209247f, -0.00336513f, -0.05013366f, 
    -0.02976449f, 0.05454905f, 0.02783344f, 0.04609295f, 0.00362418f, -0.04679768f, -0.01415954f, -0.05435648f, 
    -0.05007303f, 0.01722278f, 0.00973477f, -0.01971068f, 0.03519054f, 0.02000025f, 0.03774588f, 0.05957371f, 
    0.01148660f, 0.00250619f, -0.03402636f, 0.00278617f, -0.02549680f, -0.01721693f, -0.03423650f, 0.00670116f, 
    0.00571682f, 0.00581132f, -0.02522500f, 0.00668610f, -0.05744764f, 0.01884901f, -0.00892919f, 0.02023096f, 
    0.02235308f, -0.02139269f, -0.03250120f, -0.04464206f, -0.07605723f, -0.06626627f, -0.07277655f, -0.05821032f, 
    -0.01627712f, -0.06705362f, -0.08799510f, -0.04093701f, -0.06718996f, -0.05346512f, -0.05356804f, -0.03386462f, 
    0.01314361f, 0.01884307f, 0.03594232f, 0.02220790f, 0.03232335f, -0.00116143f, -0.01702962f, 0.02243997f, 
    -0.03946957f, 0.00598502f, -0.01673980f, -0.02550531f, 0.00713682f, 0.05804430f, 0.05914254f, 0.01042891f, 
    0.03768517f, 0.02573059f, 0.00792404f, -0.02653984f, -0.03894310f, -0.02648716f, 0.00472921f, 0.01546150f, 
    -0.06147938f, 0.01833014f, -0.01150019f, 0.01906898f, -0.05562986f, -0.03633066f, 0.00084564f, 0.00820692f, 
    -0.03433784f, 0.00135192f, 0.00312623f, -0.00574717f, -0.05598219f, -0.01162634f, -0.05463169f, -0.02904550f, 
    0.00566048f, -0.02556691f, -0.02848501f, -0.02676325f, -0.04818326f, -0.05911235f, -0.01383845f, -0.01438274f, 
    0.02931595f, 0.01395313f, 0.04318214f, 0.01191784f, 0.01152367f, 0.02131895f, -0.02686102f, -0.06694783f, 
    -0.01143026f, -0.05986116f, -0.06274259f, -0.00657830f, -0.01056413f, 0.00276646f, 0.01366589f, 0.00110854f, 
    -0.00554022f, -0.00686138f, -0.00527890f, -0.00734805f, -0.01508383f, -0.01583833f, -0.03419923f, -0.00619363f, 
    -0.05033652f, -0.01424736f, -0.02598993f, -0.03831819f, -0.05291289f, -0.00981943f, -0.01672806f, -0.05040779f, 
    -0.00344587f, 0.00280863f, -0.05628398f, -0.02580287f, -0.00742268f, 0.01786192f, -0.02064700f, 0.00218159f, 
    -0.02917456f, -0.04160567f, 0.02065183f, -0.03668959f, -0.04792731f, -0.02945505f, -0.06024234f, -0.02195139f, 
    0.01339394f, 0.02033930f, -0.01651651f, -0.04719726f, -0.02763841f, -0.05181077f, -0.01468251f, 0.01125335f, 
    -0.01798774f, 0.01387719f, -0.00828356f, -0.03185890f, 0.03363474f, 0.01991471f, 0.02456036f, 0.01007151f, 
    -0.02537747f, 0.01104451f, 0.00430404f, -0.01387340f, -0.04035005f, -0.02153927f, -0.03438469f, -0.00574532f, 
    0.03179496f, 0.06507368f, 0.03764122f, 0.01282244f, -0.01303048f, -0.00124202f, -0.03185284f, -0.03060355f, 
    -0.00037024f, -0.06039081f, -0.02254952f, -0.01658793f, 0.02585347f, 0.01818744f, -0.03028249f, 0.01562286f, 
    -0.03581910f, -0.04962021f, -0.00906020f, 0.02930144f, 0.04450734f, -0.00536788f, -0.02098731f, -0.00727863f, 
    0.01691659f, -0.01063344f, -0.06920881f, -0.00022529f, 0.04080478f, 0.07222842f, 0.04377056f, 0.01903318f, 
    0.00503434f, 0.00111578f, -0.01757286f, -0.05799844f, -0.05898495f, -0.01674994f, 0.01054136f, -0.02963143f, 
    -0.02656221f, -0.01037450f, -0.05928447f, -0.00493117f, -0.03859982f, -0.03329946f, -0.00247996f, -0.00830886f, 
    0.02186606f, 0.04780973f, -0.02281629f, 0.02284840f, -0.02883459f, -0.00629067f, 0.00071416f, -0.04051033f, 
    -0.02138424f, -0.04334600f, -0.02986798f, -0.02807934f, -0.01685020f, 0.00366402f, -0.03967828f, -0.05627765f, 
    -0.04763533f, -0.04199008f, -0.02264154f, -0.04218350f, -0.04431892f, -0.06161535f, -0.05594849f, -0.06220548f, 
    0.03766529f, 0.07236336f, 0.01659062f, 0.01106476f, 0.00099012f, -0.02096653f, 0.00484685f, 0.00033304f, 
    -0.01917150f, -0.05942686f, 0.00121810f, 0.00839906f, 0.01532214f, 0.03842394f, -0.00516184f, 0.04679674f, 
    0.00991899f, 0.02340218f, -0.00436354f, 0.02331561f, -0.01669590f, -0.01025716f, 0.01945421f, 0.01933250f, 
    -0.03038853f, -0.07697583f, -0.06931426f, -0.03785658f, -0.07480523f, -0.01753939f, -0.01903782f, -0.01592121f, 
    -0.03550534f, -0.05190460f, -0.05663997f, -0.01817167f, -0.06834016f, -0.08511329f, -0.02034504f, -0.06348190f, 
    -0.05850914f, -0.01263281f, -0.03704321f, -0.03304264f, -0.07513417f, -0.06816838f, -0.00838913f, -0.03809385f, 
    0.00218585f, -0.00513728f, 0.05319503f, 0.02701859f, 0.00369575f, -0.00716280f, -0.04768660f, -0.03868235f, 
    0.02691221f, 0.06691864f, 0.05155330f, 0.04693389f, -0.03186378f, -0.05853563f, -0.07092845f, -0.04858850f, 
    0.01249767f, -0.01715630f, -0.07448170f, -0.04376861f, -0.05661513f, -0.01578161f, -0.05402105f, -0.08216339f, 
    -0.04407135f, -0.03715165f, -0.05767957f, -0.02186334f, -0.01456716f, -0.05668915f, -0.08449551f, -0.05168447f, 
    -0.03750408f, -0.01251877f, -0.03008407f, -0.02891070f, 0.07526235f, 0.07400046f, 0.03023210f, 0.00399682f, 
    0.03215048f, -0.03612867f, 0.01217440f, 0.00873324f, -0.02402723f, -0.02115824f, -0.02684984f, -0.01220693f, 
    0.03115148f, 0.03728928f, 0.02124832f, 0.00090412f, 0.02043467f, 0.03030813f, -0.03345786f, -0.01624616f, 
    -0.02972225f, -0.02442037f, 0.00046670f, -0.02988745f, 0.00206348f, -0.01092605f, -0.06767394f, 0.01167254f, 
    -0.02359529f, -0.01656215f, -0.02509599f, -0.05364019f, -0.05906161f, -0.08547220f, -0.03490632f, -0.06610490f, 
    0.08384686f, 0.09567168f, 0.04430863f, 0.02258522f, -0.03882352f, 0.00101005f, -0.01661130f, -0.00946506f, 
    -0.01066622f, -0.01389715f, 0.01883253f, -0.00122960f, -0.05897436f, -0.04689347f, -0.05025547f, -0.05279545f, 
    -0.03976021f, -0.00246153f, -0.03050916f, -0.02424937f, -0.03996388f, -0.03988796f, -0.07995510f, -0.07470089f, 
    -0.08022738f, -0.06447081f, -0.05693796f, -0.07149380f, -0.06182561f, -0.02838554f, -0.05163803f, -0.03103948f, 
    -0.08546533f, -0.04561249f, -0.02323303f, -0.08223975f, -0.05142706f, -0.03249699f, -0.00560797f, 0.00353885f, 
    -0.00337573f, -0.05651245f, -0.06886183f, -0.06059097f, -0.01333161f, -0.03749688f, -0.01846684f, -0.06753124f, 
    -0.03574225f, 0.00230285f, -0.02342135f, -0.02116915f, -0.02404349f, -0.03291883f, 0.03263840f, -0.04661425f, 
    0.06835159f, 0.00928303f, 0.00623852f, 0.00819779f, 0.05293667f, 0.01262890f, -0.02862220f, 0.02304355f, 
    -0.01610916f, -0.00041729f, -0.02208687f, -0.03630285f, 0.03739245f, -0.01002428f, 0.01024397f, 0.00306516f, 
    -0.01481174f, 0.04119699f, 0.05596496f, 0.03753017f, -0.03165963f, -0.00635899f, 0.00755252f, -0.03227585f, 
    -0.02898553f, -0.04496985f, -0.03261279f, -0.00611904f, 0.01388738f, 0.04606147f, 0.04525216f, 0.03115219f, 
    -0.04873585f, -0.05457218f, -0.02878003f, -0.01537273f, -0.01961463f, -0.02974020f, -0.01255462f, -0.01652755f, 
    -0.04377848f, -0.05542980f, -0.02862764f, -0.04072699f, -0.00980467f, 0.00292241f, -0.03629789f, -0.03951452f, 
    -0.08163991f, -0.03989955f, -0.03678694f, -0.04432430f, -0.02954510f, -0.01433579f, -0.02185233f, -0.06789381f, 
    -0.05698752f, -0.00707784f, 0.04855806f, 0.01915541f, 0.02768141f, -0.01067602f, 0.00693112f, -0.02452424f, 
    0.05500350f, 0.02129815f, 0.02073186f, 0.03421524f, -0.03346651f, -0.04945252f, 0.00882876f, -0.04117201f, 
    0.04062670f, -0.00594403f, 0.01970879f, 0.01878467f, 0.00041071f, 0.02277032f, 0.03545537f, -0.03283409f, 
    -0.06903072f, -0.00513865f, -0.00974014f, -0.08455241f, -0.03453322f, -0.08385466f, -0.04296261f, -0.02852452f, 
    0.00555654f, -0.08377997f, -0.03482953f, 0.00947211f, -0.02173699f, 0.04467098f, -0.02431336f, 0.00618255f, 
    -0.04787304f, -0.05707583f, -0.03611104f, -0.02969193f, 0.03510179f, -0.00987685f, -0.02006507f, -0.00442531f, 
    -0.01817773f, 0.02912779f, -0.01390808f, -0.02890952f, -0.06248059f, -0.01650385f, 0.01089772f, -0.06045048f, 
    0.03041020f, 0.03091216f, 0.03645441f, 0.04253360f, 0.00128763f, -0.02758655f, 0.00786500f, -0.01444566f, 
    -0.00937104f, 0.00470518f, -0.03592430f, -0.01011370f, -0.04061776f, 0.02894698f, -0.02167315f, -0.02224124f, 
    -0.00475010f, -0.02700407f, -0.01698851f, -0.00706900f, -0.03256844f, -0.03230387f, -0.03640392f, 0.02617785f, 
    -0.08563081f, -0.04352442f, -0.06070013f, -0.05335305f, -0.03406905f, -0.01895087f, 0.00866378f, 0.01976005f, 
    -0.06066514f, -0.01745068f, -0.04635887f, -0.07427178f, -0.04197594f, -0.03309882f, -0.05656477f, -0.03338683f, 
    -0.01274472f, -0.02862637f, -0.04605084f, -0.05367417f, -0.05013635f, 0.00335724f, -0.07407098f, -0.00665926f, 
    0.00068415f, 0.00111522f, 0.02344254f, -0.02070840f, -0.00822921f, 0.00770968f, -0.00128267f, 0.00834495f, 
    0.00584904f, 0.02934926f, 0.01468325f, -0.03777387f, 0.03587483f, -0.00058718f, 0.00272325f, 0.02137531f, 
    -0.02806173f, -0.00929177f, 0.02593506f, 0.05850436f, -0.05516596f, -0.08598879f, -0.02143187f, -0.01085094f, 
    -0.03424467f, -0.04063358f, -0.00970004f, -0.08355260f, -0.03550706f, -0.07584274f, -0.00544685f, -0.07358009f, 
    -0.03613608f, -0.07123764f, -0.02451435f, -0.01622776f, -0.08939207f, -0.04112053f, -0.04536689f, -0.10340994f, 
    -0.07593846f, -0.04621007f, 0.02491814f, 0.01139913f, 0.00163577f, -0.05358323f, -0.00843322f, -0.06494255f, 
    -0.00215377f, -0.03105735f, 0.02787417f, 0.02951607f, 0.00083037f, 0.00528408f, -0.02619051f, -0.05027973f, 
    -0.01011209f, 0.01836757f, 0.01112592f, -0.01799266f, -0.02489938f, -0.03399540f, 0.03824675f, 0.05425647f, 
    -0.04922226f, -0.00419886f, -0.03187209f, 0.00970408f, 0.00511067f, -0.05966848f, -0.05255443f, -0.05468854f, 
    -0.05982536f, -0.04894259f, -0.05020332f, -0.01714810f, -0.06564976f, -0.05673353f, -0.05709858f, -0.03468018f, 
    -0.02690764f, -0.03520036f, -0.02858277f, -0.05161818f, -0.00535790f, -0.00484038f, 0.01505055f, 0.03526653f, 
    -0.03162195f, -0.01049215f, -0.03411234f, -0.02570170f, 0.03521474f, 0.00892637f, 0.03505095f, 0.02387158f, 
    0.02285274f, 0.03090759f, -0.01474789f, 0.01219664f, -0.02506534f, -0.02953574f, 0.00145130f, -0.02097761f, 
    -0.01033161f, -0.01105171f, -0.00022605f, 0.06760674f, -0.08538826f, -0.00031813f, 0.01158656f, 0.02084445f, 
    -0.03981808f, -0.02935326f, -0.01847852f, -0.01339469f, -0.02188658f, -0.03708996f, -0.00078403f, -0.02106968f, 
    -0.01720889f, -0.00434932f, -0.00939936f, -0.03285066f, -0.03659850f, -0.02288510f, -0.06329276f, -0.02953466f, 
    -0.09665863f, -0.04756249f, -0.04710501f, -0.04686555f, 0.00780094f, 0.03877448f, 0.01127318f, 0.03007180f, 
    0.00900423f, -0.03121486f, -0.01706863f, 0.00119092f, -0.03716743f, 0.00122436f, 0.01117196f, 0.00016970f, 
    -0.09639472f, -0.12724507f, -0.07055584f, -0.08730926f, 0.07798532f, -0.02420947f, 0.06236112f, 0.10847648f, 
    0.07613049f, -0.06705538f, 0.27767140f, 0.11906695f, 0.01853887f, 0.10039440f, 0.04397722f, 0.12211760f, 
    0.00610035f, -0.06665543f, -0.04550464f, -0.15534312f, -0.01576726f, -0.04458826f, 0.14108507f, -0.01130162f, 
    0.25554463f, 0.05103081f, -0.11399930f, -0.12099651f, 0.03611584f, 0.11894586f, -0.00677220f, 0.00007397f, 
    0.04108904f, 0.08793786f, -0.04619859f, -0.01455763f, 0.08801504f, 0.18352342f, 0.33623427f, 0.16788343f, 
    -0.06773076f, -0.10140818f, -0.03073831f, -0.01839187f, 0.01110768f, -0.02553342f, 0.01653982f, -0.02808296f, 
    0.16731913f, -0.12502870f, -0.04437654f, 0.00914251f, 0.12946346f, -0.10322642f, -0.11586749f, 0.14998969f, 
    0.01656912f, 0.02723486f, -0.10718493f, 0.19213705f, 0.02390867f, 0.12294213f, -0.10177096f, -0.08663719f, 
    0.00083192f, -0.07442763f, -0.08456011f, -0.01122625f, 0.07204720f, -0.04684238f, 0.01830929f, -0.11065292f, 
    -0.05893021f, -0.09900238f, -0.02481367f, 0.01388433f, 0.13140972f, 0.07434937f, -0.01121186f, 0.04270113f, 
    0.00812536f, 0.09939957f, -0.07652390f, 0.06478802f, 0.14098345f, 0.15877029f, 0.03566575f, 0.00066466f, 
    0.00505399f, 0.04993538f, 0.01176268f, -0.13187119f, 0.08828774f, 0.08146331f, -0.03254576f, 0.12824290f, 
    0.57784712f, 0.11120617f, 0.09326985f, -0.03270832f, 0.17651498f, -0.11077379f, -0.07176327f, 0.04011006f, 
    0.05587947f, 0.06668246f, 0.01651459f, -0.06595936f, 0.09947352f, 0.04545722f, 0.49386266f, 0.13831763f, 
    0.03149564f, -0.02763096f, -0.09804514f, -0.01629265f, -0.00709745f, -0.02808588f, -0.00478057f, -0.00648452f, 
    0.47825971f, -0.19059733f, 0.37564930f, -0.09348588f, 0.17203198f, -0.06744440f, -0.10089028f, 0.13172339f, 
    0.03917179f, 0.05198670f, -0.03848555f, 0.04068814f, 0.12741779f, -0.06806128f, 0.05096860f, 0.03233009f, 
    -0.06097294f, 0.08499518f, 0.01490297f, -0.00554087f, 0.05728848f, -0.06878431f, -0.02565062f, 0.00931380f, 
    -0.05524028f, -0.07297732f, -0.05094670f, 0.09236464f, -0.01711858f, 0.00809023f, -0.14661695f, -0.10112514f, 
    0.01089528f, 0.01491490f, -0.03814631f, -0.02492647f, -0.21349120f, 0.22349697f, -0.09894161f, 0.08519635f, 
    -0.01605345f, 0.04397861f, 0.02331948f, -0.03477479f, 0.00373458f, 0.00210504f, -0.03494968f, 0.00027905f, 
    -0.04756675f, -0.09627280f, -0.11145803f, 0.04373740f, 0.07484701f, -0.07436839f, 0.22628473f, -0.11523464f, 
    -0.01172492f, -0.04000477f, -0.02530729f, -0.00414993f, -0.08115812f, -0.16783518f, 0.13977784f, 0.22531979f, 
    0.11784832f, 0.05678322f, -0.20162776f, 0.06474747f, -0.12013254f, 0.09017278f, -0.02019739f, 0.12024649f, 
    -0.13946368f, 0.00585223f, -0.15261014f, -0.00267258f, 0.02760945f, 0.06171167f, 0.09790128f, 0.02776738f, 
    -0.01518865f, -0.01647446f, 0.20187807f, -0.03143192f, -0.16698819f, -0.26023793f, 0.14368045f, 0.07120763f, 
    0.12212530f, -0.00302824f, -0.03305444f, 0.07708457f, -0.00602451f, 0.00432654f, -0.00193093f, 0.05828578f, 
    -0.33194593f, -0.11444598f, -0.13452065f, 0.34224090f, 0.00741200f, 0.01730255f, -0.03081913f, 0.05609568f, 
    0.02840965f, -0.01858427f, 0.01803118f, 0.03797147f, -0.07109044f, -0.01581238f, 0.06580275f, 0.01433741f, 
    0.02287335f, 0.11231758f, 0.02885930f, -0.00829595f, 0.01805885f, 0.12453450f, 0.05369785f, -0.08414069f, 
    -0.16395515f, -0.09791207f, 0.06258129f, 0.09776482f, 0.05678599f, -0.03458181f, -0.15801769f, 0.06348550f, 
    -0.14461371f, 0.10204749f, -0.09681407f, 0.00422487f, 0.11348002f, 0.40332934f, 0.07374184f, 0.09652442f, 
    -0.02083547f, -0.04415276f, -0.09533479f, 0.01546370f, 0.01921993f, -0.04217778f, 0.06450775f, 0.01292268f, 
    -0.04258130f, -0.09553230f, -0.01257039f, 0.02067151f, 0.04964808f, 0.08437385f, -0.05028912f, -0.02818648f, 
    0.03617099f, 0.05819617f, 0.03846801f, 0.06949562f, 0.09732629f, -0.04577611f, 0.09473027f, -0.08199947f, 
    0.01382562f, -0.10520979f, 0.02949615f, -0.01569624f, -0.03704451f, 0.05318515f, 0.06351850f, -0.13249807f, 
    -0.26960489f, 0.05332642f, 0.06638970f, 0.01434146f, 0.00468246f, 0.11490905f, 0.01872999f, 0.00451869f, 
    -0.00246109f, 0.10928474f, 0.03375677f, -0.09082344f, -0.06001406f, -0.03312180f, -0.15418172f, -0.07175352f, 
    0.04775411f, -0.00755402f, -0.00464008f, 0.01043400f, -0.06187904f, -0.18287487f, -0.10925436f, -0.09687047f, 
    0.00614165f, -0.13970421f, 0.01553551f, 0.27793756f, 0.12307896f, 0.04783948f, 0.03281705f, -0.03678933f, 
    -0.04388155f, 0.10247062f, 0.09921451f, 0.13890412f, 0.29242885f, 0.10360775f, 0.00436492f, 0.19985656f, 
    0.14389311f, -0.03753189f, -0.05533849f, -0.02699652f, -0.11084615f, 0.10265996f, 0.05403381f, 0.13838920f, 
    -0.13621184f, 0.06466860f, -0.03282482f, 0.00387372f, 0.02744877f, 0.01557837f, 0.04282373f, 0.02315594f, 
    0.02078678f, -0.00795663f, 0.13973300f, -0.02815673f, 0.07611638f, 0.04991222f, 0.01564746f, -0.06976219f, 
    -0.12614898f, 0.00725787f, 0.12560308f, 0.04668000f, -0.03790465f, -0.05252857f, 0.03589998f, 0.07888106f, 
    0.29289189f, -0.04708561f, -0.07522839f, -0.06237616f, 0.01178915f, 0.05020774f, -0.00759991f, -0.05324748f, 
    -0.04051676f, -0.02137176f, 0.07118322f, -0.04062175f, -0.14829290f, -0.07676538f, -0.01013129f, -0.00669652f, 
    -0.03917316f, -0.01119037f, 0.00060395f, -0.00539213f, 0.01106297f, -0.01243543f, -0.09731544f, -0.01355626f, 
    -0.09785758f, -0.07304926f, 0.01442269f, 0.08684772f, 0.01555174f, -0.07097501f, -0.04107412f, -0.01936419f, 
    0.04853814f, -0.02239205f, 0.02894502f, -0.07832593f, 0.13917707f, -0.02028009f, -0.00436508f, -0.02331455f, 
    -0.11803503f, -0.08385603f, 0.09148054f, 0.06499849f, 0.05272936f, 0.03222103f, 0.03329383f, 0.01216478f, 
    -0.32719895f, -0.01604005f, -0.08814194f, 0.05498229f, 0.01026066f, 0.06977776f, 0.08479603f, -0.03995433f, 
    0.00955492f, 0.00835485f, 0.03981075f, 0.05140767f, -0.06204996f, -0.05475183f, -0.00347137f, 0.02258342f, 
    -0.05254686f, 0.00615639f, -0.06277288f, 0.07825973f, 0.02078155f, 0.10984594f, 0.11124758f, -0.06063894f, 
    0.23632565f, 0.01411387f, -0.07898739f, -0.08669925f, 0.04610151f, 0.09038366f, -0.04147873f, 0.06843583f, 
    0.07390299f, -0.04379221f, -0.00561570f, -0.00268636f, -0.00748442f, -0.08870551f, -0.00103780f, -0.06194574f, 
    -0.02091594f, -0.01451134f, 0.02370555f, -0.07981913f, -0.01675051f, 0.08502431f, 0.07887881f, 0.02498721f, 
    -0.17532711f, 0.11236611f, 0.01455075f, 0.26199353f, -0.10946330f, 0.04140416f, -0.01676365f, -0.06442797f, 
    0.02760864f, 0.15403308f, 0.03120182f, 0.20978972f, -0.06510700f, 0.13933651f, -0.04631435f, -0.09806067f, 
    -0.01679900f, -0.04103738f, -0.09503701f, 0.03899432f, -0.04175245f, 0.00736387f, 0.02039263f, -0.12731351f, 
    0.00408997f, 0.03623959f, 0.12897792f, 0.02263698f, 0.09154949f, -0.02612983f, -0.04099524f, 0.03351035f, 
    -0.00011534f, 0.01359904f, -0.04271307f, -0.04744544f, -0.28899601f, 0.44246581f, -0.26064786f, -0.18686816f, 
    -0.00619703f, -0.00495724f, -0.00002461f, 0.01933805f, -0.09591132f, -0.11487391f, 0.21631844f, 0.12852897f, 
    0.03162197f, 0.18860811f, 0.14303257f, 0.02477785f, 0.00076686f, 0.04973466f, 0.18758208f, 0.06948999f, 
    -0.07773962f, 0.05378132f, 0.18582925f, 0.08646754f, -0.21010940f, -0.04060213f, -0.21053459f, 0.23415345f, 
    0.15509287f, 0.10553452f, 0.05997110f, 0.02224589f, -0.03581862f, -0.10730802f, 0.10756016f, -0.02091620f, 
    -0.22625870f, 0.05429400f, -0.21127483f, -0.11305758f, 0.07162029f, -0.05997914f, -0.02766725f, -0.06587207f, 
    -0.12119363f, -0.00748110f, -0.06961291f, -0.05536054f, 0.21103917f, 0.10907169f, -0.17840932f, -0.01384422f, 
    0.14917015f, -0.01643382f, 0.07447553f, -0.01681397f, -0.02247076f, 0.06393386f, -0.09107435f, -0.07447071f, 
    -0.24217311f, 0.12483285f, 0.13222934f, 0.09803414f, -0.01697659f, -0.04882511f, -0.10278711f, 0.06370568f, 
    -0.06232841f, 0.00541903f, 0.06368457f, 0.10090453f, -0.08233947f, 0.02000966f, -0.00602650f, 0.26010674f, 
    0.02005979f, 0.01778695f, 0.04477636f, -0.05382289f, 0.01488444f, -0.00217947f, -0.04350076f, 0.07029456f, 
    -0.00212231f, -0.16821635f, -0.05265018f, 0.02811089f, 0.10093051f, -0.10473391f, -0.04477612f, 0.07877865f, 
    -0.10124618f, -0.00812826f, -0.19208160f, -0.05629494f, 0.40154582f, -0.10135604f, -0.04227614f, 0.09122033f, 
    0.05745617f, 0.11737528f, -0.10630613f, 0.10328002f, -0.05507910f, -0.04539149f, 0.11369635f, 0.05224312f, 
    0.26787961f, -0.08858174f, 0.23244971f, 0.00703372f, -0.00397460f, -0.07342406f, 0.09916062f, 0.00218315f, 
    0.07786956f, 0.03346759f, 0.01230195f, -0.03959193f, 0.17404814f, -0.15177727f, 0.06316043f, 0.07678545f, 
    0.17404214f, 0.06359596f, -0.06024248f, 0.09923964f, -0.04687402f, -0.11676423f, 0.21116987f, 0.08624165f, 
    -0.02581796f, 0.05045142f, -0.02733354f, -0.04941428f, -0.05436795f, -0.03736169f, 0.11019029f, -0.10412803f, 
    -0.00946292f, -0.06593236f, -0.00686104f, -0.02057479f, -0.14968343f, 0.29158932f, -0.13547006f, -0.10325676f, 
    -0.01204064f, -0.03056427f, 0.02590621f, -0.13359053f, -0.09794552f, 0.06625651f, -0.09014535f, 0.13006762f, 
    0.07066170f, -0.01019300f, 0.10465693f, -0.06056524f, -0.08514564f, -0.06980011f, -0.05471998f, 0.06193542f, 
    -0.03172291f, 0.01090382f, -0.09628824f, -0.04093726f, -0.16860953f, -0.10922164f, 0.02585435f, 0.17639330f, 
    0.18611357f, 0.07067275f, 0.11101296f, -0.02255593f, 0.07353545f, -0.00892950f, -0.03568717f, 0.22172034f, 
    -0.03737014f, -0.00665570f, 0.17121860f, 0.12757882f, -0.04667133f, -0.12288098f, -0.07899237f, 0.00994097f, 
    0.08102319f, -0.05573043f, -0.05722624f, -0.03823566f, -0.14393032f, -0.13893825f, 0.31092802f, 0.05585014f, 
    -0.01080638f, 0.03226298f, -0.02259020f, -0.02370979f, 0.07868353f, 0.01538001f, -0.06424750f, 0.09409929f, 
    0.10269935f, -0.02153218f, -0.02157424f, 0.05278197f, 0.14369063f, -0.01600156f, -0.01611118f, -0.04228837f, 
    0.01126267f, -0.01399408f, -0.04647456f, -0.04885832f, -0.18669055f, 0.13727643f, 0.09364542f, 0.03200687f, 
    0.01505159f, -0.02819296f, 0.07413339f, -0.03154232f, 0.03701156f, 0.05263573f, 0.04483237f, 0.03705958f, 
    -0.28664920f, 0.14335957f, -0.05146042f, 0.10947772f, -0.03817580f, 0.10858729f, -0.00130115f, -0.01779367f, 
    0.01389446f, 0.00430661f, -0.08088753f, -0.00111449f, 0.15603304f, -0.07222728f, 0.13245696f, 0.08520492f, 
    0.03310097f, -0.15644351f, -0.10773656f, -0.08251909f, 0.05363764f, -0.05098285f, -0.04347476f, 0.13011937f, 
    0.09829420f, 0.13499202f, 0.03758100f, 0.02365210f, -0.06875290f, -0.03586349f, -0.00416332f, -0.00247160f, 
    -0.03460846f, 0.07670831f, 0.06570185f, 0.00509665f, 0.08837302f, -0.20254672f, -0.12613782f, -0.20736891f, 
    0.03925340f, -0.05059063f, 0.05777214f, 0.19715768f, -0.23008187f, -0.01607390f, -0.02375415f, 0.14211021f, 
    0.01330948f, 0.01003636f, 0.02161735f, 0.00444683f, -0.00107867f, -0.03534255f, 0.02665322f, -0.03045575f, 
    0.00583211f, 0.02058576f, -0.01257152f, -0.02381141f, 0.01369577f, -0.02615438f, 0.00637744f, -0.01010721f, 
    -0.03799560f, 0.00171892f, -0.01811773f, -0.00894106f, -0.02898743f, 0.00143291f, 0.02417699f, 0.00089778f, 
    -0.01960760f, -0.01450005f, -0.00617833f, -0.03445578f, 0.02979305f, -0.01847190f, -0.03077465f, -0.01339362f, 
    0.01034221f, -0.01354330f, -0.01480043f, 0.01844517f, -0.03803768f, -0.02364849f, -0.00203239f, -0.03808476f, 
    -0.02628999f, -0.02419550f, 0.00110200f, -0.02168752f, -0.01957921f, 0.03490523f, -0.01775379f, 0.02078662f, 
    -0.01108095f, 0.01388013f, 0.00382338f, -0.02975612f, 0.02321081f, 0.00493496f, -0.02396204f, -0.03883756f, 
    0.00129591f, 0.01013246f, 0.01366348f, -0.02339337f, -0.01189454f, -0.00064833f, -0.02185904f, -0.02461393f, 
    0.00498022f, 0.01302290f, 0.02583679f, 0.01030292f, 0.00705349f, -0.03647885f, -0.00727588f, -0.02596257f, 
    -0.02355352f, -0.02261741f, -0.01499282f, 0.01872445f, 0.00453654f, 0.01737544f, 0.01723087f, 0.03488173f, 
    -0.00273700f, -0.01278323f, -0.01661213f, -0.04124551f, -0.02426120f, 0.02280356f, -0.03576981f, 0.02249513f, 
    0.02430210f, 0.01663279f, -0.02415507f, -0.02195492f, 0.02526094f, 0.01121145f, 0.01770952f, -0.03118742f, 
    -0.03821647f, -0.00480331f, -0.04014862f, 0.02358937f, -0.01563812f, -0.01254028f, -0.01769027f, -0.04195400f, 
    0.00006763f, 0.00653179f, 0.02032373f, -0.04132768f, -0.02398217f, -0.02353605f, 0.01207302f, -0.01163713f, 
    0.00414358f, -0.00038375f, -0.01030712f, 0.02064872f, 0.01831143f, -0.01178842f, -0.02537757f, 0.04029497f, 
    -0.02948142f, -0.03545577f, -0.01109873f, 0.02854430f, 0.02010159f, 0.00707615f, -0.04177694f, 0.00037329f, 
    -0.00437550f, -0.00397706f, 0.00081563f, -0.01367179f, 0.02091725f, -0.01463026f, -0.01859418f, -0.01413326f, 
    -0.03544629f, 0.02738343f, -0.00610339f, 0.00827299f, -0.02416881f, 0.03559544f, -0.02962350f, -0.02525311f, 
    -0.02607798f, -0.02592995f, -0.02666524f, 0.02882107f, -0.03197635f, 0.00055284f, 0.02565129f, 0.02385062f, 
    -0.01753559f, 0.00992746f, 0.00431436f, -0.03257168f, -0.03314958f, 0.00246850f, -0.01763929f, 0.02075584f, 
    0.00817033f, 0.02428619f, 0.00268286f, -0.01627236f, -0.03966940f, -0.02381165f, -0.00599296f, -0.01370768f, 
    -0.01491331f, -0.01301230f, -0.00865724f, 0.01234765f, -0.03591578f, -0.01349705f, 0.01008331f, 0.00918164f, 
    0.01718606f, 0.00179539f, -0.00667302f, -0.01166017f, -0.03002612f, 0.00329696f, -0.01649547f, 0.01283925f, 
    0.02823185f, 0.03908591f, -0.02126265f, 0.00249164f, -0.02637274f, 0.02134434f, 0.02783463f, 0.01785329f, 
    -0.02405331f, -0.01420015f, 0.02978968f, -0.00343910f, 0.04170524f, -0.02166016f, -0.01761397f, -0.02776828f, 
    0.02557633f, -0.02850486f, 0.02696488f, 0.02251437f, 0.01647144f, -0.01009149f, -0.02625551f, 0.02518558f, 
    -0.02179824f, 0.01338440f, -0.01755457f, -0.00118659f, 0.00324438f, 0.01151915f, 0.00829832f, 0.01236852f, 
    0.00796142f, 0.02646457f, -0.03399508f, -0.03597290f, -0.01893687f, -0.02071830f, 0.00487312f, 0.00864397f, 
    0.00153368f, 0.03423749f, -0.04043492f, -0.02423916f, 0.02961768f, 0.01223314f, -0.02842605f, -0.02143247f, 
    0.00323788f, 0.01272130f, 0.02855271f, -0.00519246f, -0.03553126f, -0.00020179f, 0.00560716f, 0.02043193f, 
    -0.01491774f, -0.03516746f, 0.00824631f, -0.00545582f, -0.03701024f, -0.01530036f, -0.04021879f, -0.02357742f, 
    -0.01858045f, 0.00776768f, -0.00595775f, -0.02297511f, -0.02230680f, -0.02016698f, -0.03875700f, -0.02891113f, 
    0.01808096f, -0.01679574f, -0.01174467f, -0.00488928f, -0.00466585f, -0.03230348f, 0.02700013f, -0.00343539f, 
    0.00567934f, 0.00395972f, -0.04141568f, -0.02552737f, 0.02679186f, -0.00949581f, -0.03041847f, -0.01983393f, 
    0.00565309f, 0.02854400f, -0.03388677f, 0.00663077f, 0.00009711f, -0.01605405f, -0.00799206f, 0.01600840f, 
    -0.00679026f, -0.00051685f, -0.02510091f, -0.00494526f, 0.02230059f, 0.00780566f, -0.01552398f, 0.01035523f, 
    -0.03732903f, -0.02647453f, 0.01446791f, -0.01391321f, -0.02956524f, 0.02521921f, -0.02376836f, 0.02314721f, 
    -0.02509115f, 0.02316479f, 0.01523310f, 0.00991990f, 0.00414357f, -0.02686294f, -0.00019290f, 0.02214401f, 
    -0.02892547f, 0.01658285f, 0.01762226f, 0.01111035f, -0.03701919f, 0.02596870f, -0.01120057f, 0.01831336f, 
    -0.00172212f, -0.01064233f, 0.03345607f, 0.01182899f, -0.02316908f, -0.01614751f, -0.02530920f, -0.00427188f, 
    -0.01358853f, 0.01048558f, 0.02756517f, -0.04048022f, 0.01171229f, 0.02298601f, 0.02922830f, -0.03602752f, 
    0.02893203f, 0.01104892f, -0.01539676f, -0.00720077f, 0.01754528f, -0.02850930f, 0.01842202f, -0.02877689f, 
    -0.00637577f, -0.00697346f, -0.01172957f, -0.02909392f, -0.00617015f, -0.01606242f, -0.00314489f, 0.02926149f, 
    0.00958321f, 0.02194369f, -0.02417229f, -0.03170041f, -0.02528182f, -0.02248949f, -0.01520553f, 0.01806620f, 
    -0.02518686f, -0.02202465f, 0.02638489f, 0.02862741f, -0.01578052f, 0.00790105f, -0.03693208f, 0.02007294f, 
    0.01171751f, 0.00322584f, -0.02462250f, 0.00934180f, 0.02355932f, -0.04098342f, -0.00932004f, 0.02791052f, 
    -0.01734559f, -0.00386214f, 0.04025434f, 0.03685370f, -0.01834295f, -0.03193372f, 0.01827065f, 0.00455497f, 
    0.00163654f, 0.04154616f, 0.01200978f, -0.01523144f, -0.03907456f, -0.02327094f, 0.02569674f, 0.00933213f, 
    0.01567782f, -0.00131435f, 0.01702949f, 0.01730431f, -0.03330033f, -0.01120538f, -0.00518672f, -0.00123974f, 
    -0.00713397f, -0.01564627f, -0.00386266f, 0.00918759f, -0.01430821f, -0.02094024f, -0.03989321f, -0.01810770f, 
    -0.03779237f, -0.03088350f, 0.01760339f, -0.03255972f, -0.01017973f, -0.02553022f, -0.03891906f, 0.02516009f, 
    0.01545028f, -0.02287542f, -0.03897363f, -0.01409523f, -0.00293755f, -0.00266747f, 0.02364053f, 0.01366104f, 
    0.02289815f, 0.02229473f, -0.00388470f, -0.02791763f, -0.02927007f, 0.01939903f, -0.00129472f, 0.00320615f, 
    -0.00257308f, -0.01803796f, 0.01129643f, -0.00608910f, 0.03891364f, -0.01545850f, -0.00032744f, -0.00858869f, 
    0.04130815f, -0.03193314f, 0.01202282f, -0.00505515f, 0.00574020f, 0.01643488f, -0.02231883f, -0.00268609f, 
    0.00227635f, 0.03516126f, -0.02006839f, 0.00676361f, 0.03837358f, 0.01015149f, 0.01889217f, -0.00363088f, 
    0.01089012f, 0.00303237f, -0.00491372f, -0.02187873f, 0.01131080f, 0.03950499f, 0.00843217f, 0.02475573f, 
    -0.00729055f, -0.03856756f, -0.01527753f, -0.00094142f, -0.00078032f, 0.02941327f, -0.03744870f, -0.00961700f, 
    -0.02721631f, 0.00203073f, 0.02314221f, 0.02951592f, -0.02761941f, -0.00330588f, -0.01987048f, 0.01119792f, 
    -0.03807008f, -0.01651145f, 0.01083733f, -0.01096426f, -0.01171713f, -0.03680342f, -0.03867572f, -0.01591062f, 
    -0.04059166f, -0.03066033f, 0.01380802f, 0.01531187f, 0.02936001f, 0.00065819f, 0.01978266f, -0.00843123f, 
    0.01009094f, -0.00764621f, 0.01846245f, -0.03492093f, 0.00681039f, 0.01617249f, -0.01586019f, 0.00690002f, 
    0.02610442f, -0.00803187f, -0.02338485f, -0.02732112f, -0.00965532f, 0.02845548f, -0.00595299f, -0.03366029f, 
    -0.03596159f, 0.03233609f, -0.00048115f, -0.00790390f, 0.02882218f, 0.02494625f, -0.03325006f, 0.00219523f, 
    0.00760858f, 0.01341015f, -0.01143925f, 0.02573421f, 0.02634366f, -0.02965629f, -0.02938524f, -0.01213318f, 
    -0.00597590f, 0.01175899f, -0.01119800f, 0.02703230f, -0.02040232f, -0.03298234f, 0.00163703f, 0.02028186f, 
    0.02444380f, 0.01101360f, 0.02448368f, -0.00005897f, -0.02361931f, 0.00035851f, -0.00889414f, -0.02389810f, 
    -0.02961994f, -0.01740996f, 0.02306585f, 0.00217972f, -0.03594420f, -0.03503526f, 0.02356133f, -0.01081217f, 
    -0.03510713f, -0.03958691f, -0.02181597f, -0.01953550f, -0.01958523f, -0.01188051f, -0.02895724f, -0.01834962f, 
    -0.03392348f, -0.01209853f, -0.01472619f, 0.02511363f, -0.01009350f, -0.00618300f, 0.01227294f, -0.02246833f, 
    0.02860916f, 0.02139357f, 0.02435778f, 0.02166145f, 0.02610246f, 0.01616556f, -0.01598805f, 0.01231123f, 
    0.00719036f, -0.02348428f, 0.04069052f, -0.00177808f, 0.01215334f, -0.02505951f, 0.02125895f, -0.02385958f, 
    -0.01048180f, -0.01893585f, 0.02019914f, 0.00980803f, -0.01658887f, 0.00564976f, 0.02773120f, -0.00550927f, 
    -0.03692551f, -0.02238378f, 0.02143819f, -0.00398981f, 0.01539609f, 0.02796025f, 0.02786730f, -0.00113991f, 
    -0.03544033f, -0.00575247f, -0.04023704f, 0.02983328f, -0.01387803f, 0.02723393f, 0.01388914f, 0.01376400f, 
    -0.00669157f, -0.01276357f, -0.03527762f, 0.01400629f, 0.01461566f, -0.00065172f, 0.02349755f, 0.01731202f, 
    -0.04129578f, 0.00486562f, 0.00504341f, -0.03547125f, 0.02218321f, -0.00528627f, 0.00070040f, -0.01868323f, 
    0.02543782f, -0.03129095f, -0.02283883f, -0.02745247f, -0.00751265f, 0.01442542f, -0.00135514f, -0.04103961f, 
    0.02294617f, 0.02576648f, -0.02896610f, 0.02699146f, -0.01636069f, 0.02906317f, 0.01540832f, -0.01377139f, 
    -0.01155644f, 0.00694877f, -0.01437305f, -0.01669012f, -0.01353118f, 0.01812593f, -0.04103202f, 0.03507964f, 
    -0.03400458f, 0.03937785f, -0.00763842f, -0.01023123f, -0.02351730f, -0.02343872f, -0.00031587f, -0.03543751f, 
    -0.02493168f, 0.02381499f, -0.01109283f, -0.03552857f, 0.03165977f, 0.01294297f, 0.00905399f, 0.01993012f, 
    -0.02159414f, -0.02445248f, -0.02580849f, -0.01187845f, 0.01999080f, 0.02359872f, -0.00696612f, 0.01058013f, 
    0.01954803f, -0.00947707f, 0.00021909f, -0.00297912f, -0.02302318f, -0.01224116f, 0.02167613f, -0.01900639f, 
    -0.01103378f, -0.00973535f, -0.03108340f, -0.03525485f, -0.03745952f, -0.01857533f, -0.03032772f, -0.00728222f, 
    -0.00334219f, -0.01223595f, -0.02531930f, -0.00464357f, -0.00752917f, -0.02503532f, -0.02082112f, -0.02155711f, 
    0.01660085f, -0.03595041f, -0.03031415f, -0.02386768f, -0.01174231f, -0.01035781f, 0.01352219f, -0.03755300f, 
    -0.01091989f, -0.01357693f, 0.01312298f, 0.02623426f, -0.02551809f, 0.00983831f, 0.02753058f, 0.01611246f, 
    0.00598901f, -0.03159470f, -0.02945036f, -0.02116948f, -0.01796565f, -0.02317869f, 0.02446029f, -0.04115454f, 
    0.02271284f, -0.04164208f, -0.01618773f, 0.02511520f, -0.00637605f, 0.00617853f, -0.00007453f, 0.02760204f, 
    -0.02770853f, -0.04029758f, -0.01473596f, -0.00204221f, -0.01930570f, 0.04061143f, -0.02490756f, 0.00267286f, 
    -0.03261821f, -0.00446406f, 0.00914285f, -0.02556368f, 0.03382031f, 0.02467146f, -0.01557488f, -0.02223810f, 
    0.03482905f, -0.01660558f, 0.01876511f, -0.01913847f, 0.00582588f, -0.04007213f, 0.00012958f, -0.02329345f, 
    -0.02815088f, -0.02943701f, -0.00631469f, -0.00250467f, 0.00922582f, 0.00794278f, -0.01934555f, 0.01930059f, 
    0.04160310f, 0.00832082f, -0.02684547f, -0.03339536f, -0.02961989f, 0.02786400f, 0.01418101f, 0.00066559f, 
    0.01512220f, -0.00104831f, -0.02742216f, 0.01705191f, -0.01873857f, 0.00497854f, 0.01002467f, -0.00799814f, 
    0.01420397f, 0.00793173f, 0.00900380f, 0.03734009f, 0.01660716f, 0.00219218f, -0.00966224f, -0.03004371f, 
    0.03667734f, -0.01946245f, 0.00465561f, -0.02181863f, 0.01747408f, -0.03569890f, 0.02741500f, -0.02737243f, 
    -0.02509384f, -0.02212513f, 0.03824018f, -0.01605668f, -0.00255237f, 0.01321963f, 0.02654441f, -0.01815751f, 
    0.00810035f, 0.02043952f, -0.00986794f, 0.02212871f, -0.02351755f, -0.00470248f, 0.02938088f, -0.02982731f, 
    0.01283181f, -0.00319959f, 0.00652769f, -0.03303680f, 0.02008543f, -0.01207179f, 0.03004321f, -0.00338778f, 
    -0.01787453f, -0.02189248f, -0.03431601f, -0.00500658f, -0.01851999f, -0.00804037f, -0.01340952f, -0.03350124f, 
    -0.01910728f, -0.02592606f, 0.01826040f, 0.01757286f, -0.00301093f, 0.01112796f, 0.02559550f, -0.03210776f, 
    0.01072652f, 0.01267123f, 0.01256188f, 0.00887971f, 0.00683313f, -0.02988608f, -0.02010424f, -0.03205168f, 
    0.00991325f, 0.00616820f, -0.01101444f, 0.02129230f, 0.01449301f, -0.00172341f, 0.00247859f, -0.01069462f, 
    -0.00976621f, -0.02124567f, -0.02597074f, -0.01808254f, -0.01468128f, 0.00623859f, 0.02130814f, 0.01091989f, 
    0.03133501f, -0.02253514f, 0.00452351f, 0.01603780f, 0.00551779f, -0.01065705f, 0.01689725f, 0.02563228f, 
    0.00624907f, -0.02709346f, -0.04004724f, -0.01293185f, -0.02698879f, -0.03717742f, 0.00453977f, 0.01030327f, 
    -0.03580197f, -0.01439395f, -0.03143351f, 0.01953884f, -0.00174235f, -0.03573730f, 0.01234136f, 0.02059753f, 
    0.01784700f, 0.01193274f, 0.02489632f, -0.03363022f, 0.00635810f, -0.01810747f, 0.00290968f, 0.00617306f, 
    0.01252796f, 0.00044453f, -0.00901599f, -0.02419422f, 0.01200405f, 0.00369786f, 0.02521848f, 0.00848111f, 
    0.01606040f, 0.01549107f, -0.02424913f, 0.00826999f, 0.01572635f, -0.02782425f, -0.00753165f, 0.02978071f, 
    -0.02967560f, -0.00249950f, 0.01535856f, -0.00738543f, -0.01797861f, 0.01506233f, -0.00910907f, 0.02007561f, 
    0.01495362f, -0.00593430f, -0.03261333f, 0.00763119f, 0.02207989f, -0.01906726f, -0.02548912f, -0.03870443f, 
    -0.01599491f, 0.02013077f, 0.00629578f, -0.01244354f, -0.02446837f, -0.03214036f, -0.02775773f, -0.00226731f, 
    -0.02533133f, -0.03223531f, 0.01289206f, -0.02312585f, -0.03021626f, 0.00970662f, -0.01270250f, -0.02361032f, 
    0.00043744f, 0.00219350f, -0.01823533f, 0.00456838f, 0.01168503f, -0.02296937f, 0.01462658f, 0.01894885f, 
    0.01305561f, -0.01393019f, -0.03044140f, 0.00942777f, 0.01286669f, -0.02293854f, 0.02765886f, 0.02342780f, 
    -0.02072425f, -0.03348465f, -0.01667109f, -0.02883651f, -0.01454865f, 0.02611171f, 0.02023730f, 0.01327584f, 
    -0.01124950f, 0.01978645f, -0.01731478f, 0.01049197f, -0.03969058f, -0.03043707f, -0.02510269f, -0.03354990f, 
    -0.02014622f, 0.02762371f, 0.00968718f, -0.03084292f, -0.01116500f, -0.02445206f, -0.02260856f, 0.02126574f, 
    0.00049314f, 0.02562705f, -0.01665697f, -0.01723036f, -0.03705037f, 0.00107936f, 0.02985774f, 0.03039715f, 
    -0.01585622f, 0.02892003f, -0.02610338f, 0.02223948f, -0.02720685f, -0.03601716f, 0.03021307f, -0.03186163f, 
    -0.03562710f, 0.02158749f, 0.00260950f, -0.03132347f, -0.03354783f, -0.00904937f, -0.04051924f, -0.00485241f, 
    0.01857404f, -0.01571951f, 0.01192732f, -0.03356822f, 0.00893601f, 0.02722158f, -0.02014719f, 0.03083889f, 
    0.00158433f, -0.02839241f, -0.03654432f, 0.01320632f, -0.03983631f, 0.02026756f, -0.04116233f, -0.01498735f, 
    -0.00102874f, 0.01520582f, 0.02567296f, -0.02700111f, -0.02717319f, 0.01417697f, -0.03777860f, -0.02203383f, 
    0.02331133f, -0.02661351f, -0.03644517f, -0.02361840f, -0.03916303f, -0.02559548f, 0.02422516f, 0.02409077f, 
    0.00285543f, 0.00880381f, 0.02283566f, -0.03350864f, 0.01858099f, -0.02769187f, -0.02353626f, 0.03138065f, 
    -0.03051920f, -0.00162595f, -0.03461465f, -0.02331888f, -0.01118684f, 0.01009545f, 0.00341210f, -0.00788220f, 
    -0.01123999f, 0.00614748f, 0.01166299f, 0.02476712f, -0.00100940f, 0.01623770f, -0.02968142f, 0.01687441f, 
    0.01694085f, -0.00516809f, 0.00793740f, 0.02888494f, -0.03004920f, -0.02075063f, -0.01130324f, 0.00167376f, 
    0.00958459f, -0.03088261f, -0.00698043f, -0.02861172f, -0.02498348f, -0.03674737f, 0.00841119f, -0.00091938f, 
    -0.04113102f, -0.00637465f, -0.02348102f, -0.00023664f, -0.01156404f, 0.01868831f, 0.02600468f, 0.03109794f, 
    -0.02910462f, -0.00914074f, 0.01543901f, 0.01304148f, -0.04018229f, 0.02124253f, 0.00573533f, 0.02609949f, 
    0.02232532f, 0.00186737f, -0.00030838f, -0.02235583f, -0.03693566f, 0.02267822f, -0.01110163f, 0.02510149f, 
    -0.02247084f, -0.03474614f, -0.01186388f, 0.01445514f, -0.02586149f, 0.02014752f, 0.01835416f, -0.02389787f, 
    -0.00970975f, 0.02227736f, 0.01018573f, -0.03269223f, 0.00061277f, -0.01973173f, 0.02181354f, 0.02597554f, 
    0.00180697f, 0.01806400f, 0.01165200f, 0.03062290f, 0.00376244f, -0.03211749f, -0.01417423f, -0.03548124f, 
    0.01986375f, 0.03091930f, -0.00702448f, -0.02872446f, -0.03474284f, -0.01721135f, -0.02414859f, -0.00697529f, 
    -0.01315865f, -0.02490581f, -0.00717631f, -0.01821731f, 0.02845151f, 0.00382427f, 0.02592772f, 0.01245964f, 
    -0.02363814f, -0.03577469f, 0.01019579f, -0.00428485f, -0.00271888f, -0.02279343f, 0.00089293f, -0.01885893f, 
    0.01840310f, 0.00999696f, -0.01120026f, -0.00785744f, 0.00854961f, -0.01002680f, 0.01809769f, 0.02192409f, 
    0.00308042f, 0.01723525f, 0.02436987f, -0.01147615f, 0.01374268f, 0.02094208f, 0.00336352f, -0.01509254f, 
    -0.02313123f, -0.00160764f, -0.00352291f, -0.01915280f, -0.01377592f, -0.02573924f, 0.00446906f, 0.02116987f, 
    -0.00474355f, 0.02027138f, -0.03324668f, -0.03119694f, 0.02532074f, -0.03560759f, -0.00740932f, 0.01107039f, 
    0.00681510f, 0.00483496f, -0.00680923f, -0.03931486f, 0.01054582f, 0.03116466f, -0.01563838f, 0.02878857f, 
    0.01762496f, -0.03027556f, 0.00728078f, -0.02967409f, 0.01674108f, -0.03121757f, -0.00913827f, 0.00033034f, 
    -0.00740017f, -0.03059281f, 0.00218278f, -0.02973444f, -0.01395621f, 0.01090295f, -0.03316758f, -0.02939075f, 
    -0.02424762f, 0.03100107f, 0.00314814f, 0.00763935f, 0.02149135f, -0.03617034f, 0.01332925f, 0.00220658f, 
    0.02476187f, -0.03050406f, 0.01880006f, 0.02513672f, -0.00944740f, -0.02156852f, 0.02602467f, 0.02952281f, 
    0.01450912f, -0.00191908f, -0.00353681f, -0.01792836f, 0.02211367f, 0.01318505f, 0.03350654f, 0.02000950f, 
    -0.03206245f, -0.02101701f, 0.03076887f, 0.00069715f, -0.03118739f, -0.03373362f, 0.00656068f, -0.02030745f, 
    -0.02714775f, -0.00765304f, 0.00614533f, -0.01395211f, 0.01534663f, -0.03754564f, 0.03153211f, 0.03016445f, 
    -0.00424727f, 0.00018988f, -0.01821195f, 0.03526844f, 0.00316107f, 0.01933918f, -0.02849918f, -0.01047432f, 
    0.02534057f, -0.02890983f, 0.00773177f, -0.02682109f, -0.01204281f, -0.01018674f, -0.00887171f, -0.01247595f, 
    0.02270548f, -0.00065520f, -0.03084637f, -0.01087239f, -0.00931710f, -0.03936370f, -0.01630430f, 0.00104659f, 
    -0.02747017f, -0.01360548f, -0.00400121f, -0.00190194f, -0.00824310f, 0.01422552f, -0.03027949f, -0.02519584f, 
    -0.00127548f, -0.02908125f, 0.01350483f, 0.00944129f, -0.03024739f, 0.01458404f, -0.01963240f, 0.01399124f, 
    -0.00043459f, -0.02492703f, -0.00245805f, 0.02043243f, -0.01889797f, 0.02715893f, 0.01735945f, -0.01618087f, 
    0.01246773f, -0.03376545f, -0.02659142f, 0.00274266f, -0.02676518f, 0.00455429f, -0.01636269f, 0.03127505f, 
    0.02559669f, 0.02397970f, -0.02287084f, -0.01156627f, -0.02607401f, 0.00308113f, -0.03596007f, 0.00733283f, 
    -0.00790472f, -0.00902570f, -0.01712274f, -0.04028968f, -0.02742465f, 0.00339184f, -0.04154700f, 0.00655745f, 
    0.01270096f, -0.03190572f, 0.02245585f, -0.03071664f, -0.02903532f, -0.02868197f, 0.03061395f, -0.03019902f, 
    -0.00403384f, 0.02328493f, 0.02090856f, -0.00307643f, 0.00436093f, 0.00407329f, 0.00397191f, -0.00559378f, 
    -0.01579623f, 0.00460570f, 0.01273914f, 0.03146276f, 0.01079353f, 0.00981276f, -0.03503821f, -0.01516753f, 
    -0.00972652f, -0.03798924f, 0.01494150f, 0.03080407f, -0.01552015f, -0.01936963f, 0.00181967f, 0.00384595f, 
    -0.02212703f, 0.01503760f, 0.00085655f, -0.02562800f, -0.01362192f, 0.01132349f, 0.01454504f, -0.02431654f, 
    -0.02403833f, -0.03455888f, -0.03345225f, -0.01006613f, 0.00518498f, 0.00683636f, -0.03673412f, -0.01024830f, 
    0.02525593f, 0.02710038f, -0.02481318f, -0.03404991f, 0.00859363f, -0.02974827f, -0.02567864f, 0.00103140f, 
    -0.00726251f, 0.01001865f, 0.02334783f, 0.02440267f, -0.02321117f, 0.02560083f, -0.02156649f, -0.02504191f, 
    -0.01487279f, 0.01680402f, -0.03165428f, -0.00455072f, 0.02623055f, -0.04078170f, -0.01208773f, -0.00842279f, 
    -0.01765960f, -0.00331320f, 0.02063801f, 0.00796941f, -0.01255881f, -0.00214613f, -0.01494123f, -0.00817506f, 
    -0.03839903f, -0.01516438f, -0.03303269f, 0.02211927f, 0.01486698f, 0.00043763f, 0.01576544f, 0.01320022f, 
    -0.02024181f, -0.01596730f, -0.03740468f, -0.02309572f, 0.01198662f, 0.01936979f, -0.02389012f, 0.00880345f, 
    -0.01259975f, 0.01100621f, 0.02291852f, -0.04054184f, 0.03050539f, -0.01643131f, 0.00976246f, 0.00534687f, 
    -0.03529460f, 0.01927868f, 0.01741851f, 0.02812125f, -0.03969952f, -0.02354376f, -0.03661924f, 0.01139186f, 
    -0.01981942f, -0.02995914f, 0.02083560f, -0.00827398f, -0.03188940f, -0.02761311f, 0.01134033f, -0.01987585f, 
    -0.04131132f, 0.01472909f, -0.03968205f, 0.03263527f, -0.00298883f, -0.03049073f, -0.02433736f, 0.02871637f, 
    -0.00130608f, 0.02029732f, -0.03940951f, 0.01600244f, -0.01993889f, 0.02831641f, -0.01368501f, -0.02351021f, 
    0.01396967f, 0.00545997f, 0.02314265f, -0.03839272f, 0.00970061f, -0.00991436f, -0.02280767f, -0.03998065f, 
    0.01913037f, 0.00358497f, -0.01261160f, -0.03051632f, 0.01610536f, 0.02857469f, -0.03606167f, -0.00233668f, 
    -0.00936455f, -0.00806661f, 0.03075548f, -0.00770688f, -0.01581524f, -0.02858650f, -0.01847192f, 0.02265146f, 
    0.00801243f, -0.00442531f, 0.00990750f, 0.01799652f, -0.00583942f, -0.00838685f, 0.02690342f, -0.00832616f, 
    0.00735959f, -0.04142660f, -0.02337690f, 0.02229260f, -0.00086108f, 0.02349571f, 0.02518875f, -0.03320072f, 
    0.00886192f, 0.01638812f, 0.00597201f, -0.00069428f, -0.04080294f, 0.00946022f, -0.03652541f, 0.00572921f, 
    -0.03902705f, -0.00732524f, 0.02496833f, 0.00159714f, -0.03294615f, 0.00577082f, -0.03026685f, -0.01423992f, 
    0.01641739f, -0.01025714f, 0.01070729f, 0.02019307f, 0.02228008f, -0.03157045f, -0.03381693f, -0.03131178f, 
    -0.04060883f, -0.00644727f, 0.01727297f, -0.01755317f, -0.03213805f, -0.03269670f, -0.01171661f, -0.02281971f, 
    -0.02737368f, 0.01212941f, -0.00853454f, 0.02690708f, -0.00975152f, 0.00910623f, 0.03769780f, 0.02723343f, 
    0.02000553f, 0.00431215f, -0.03612022f, 0.03028265f, -0.03085343f, 0.03509399f, -0.00802140f, 0.03458885f, 
    -0.01594458f, -0.01041249f, -0.01998834f, -0.02574283f, 0.03230665f, -0.01217113f, -0.00484373f, -0.01565627f, 
    -0.08097345f, 0.15688922f, 0.19313161f, 0.05406629f, -0.00199761f, 0.02907789f, -0.13864054f, -0.12875398f, 
    0.13370478f, 0.02399140f, 0.03860845f, 0.02599200f, 0.11458919f, 0.05113405f, 0.22477864f, 0.22978289f, 
    -0.04619578f, 0.11853958f, 0.03596419f, 0.24889714f, 0.11616058f, 0.12765273f, -0.00025723f, 0.06254681f, 
    -0.11590343f, -0.08633129f, 0.20740598f, 0.42027819f, 0.01316879f, -0.12717226f, 0.03143748f, 0.13500869f, 
    -0.00369064f, 0.01397109f, -0.04658384f, 0.00910942f, -0.03230941f, 0.08968408f, -0.03191612f, 0.29853594f, 
    -0.02146219f, -0.08532314f, 0.02578529f, 0.04080810f, -0.01085484f, -0.05961978f, -0.07928853f, -0.10900287f, 
    0.08378452f, 0.11771380f, 0.03095139f, -0.05049352f, 0.11639882f, -0.09392454f, 0.03012344f, -0.09070903f, 
    0.08221613f, 0.11435757f, 0.00256927f, -0.09190454f, 0.04822971f, -0.10675322f, 0.04154940f, 0.00735594f, 
    -0.01356280f, 0.16963036f, -0.06488021f, -0.00196007f, -0.01950042f, -0.07783629f, 0.06398132f, -0.12632720f, 
    0.09742728f, 0.29139245f, 0.13954513f, -0.10607932f, -0.06098182f, -0.12431400f, -0.00136956f, -0.05646285f, 
    0.11595399f, 0.00777847f, 0.02548462f, 0.04906160f, 0.04895583f, -0.19899571f, -0.08957093f, 0.35044554f, 
    0.18882090f, 0.01057151f, -0.06705412f, -0.15265745f, -0.04112743f, -0.06142897f, 0.20793022f, 0.17899643f, 
    -0.07425240f, -0.09179795f, -0.01549665f, -0.07073495f, 0.08686972f, -0.01771971f, -0.04548273f, 0.00100339f, 
    -0.01852798f, -0.07330746f, 0.08713745f, 0.02641277f, 0.36531857f, 0.14217322f, 0.32291785f, 0.04289169f, 
    0.12353225f, 0.12895125f, 0.03209995f, 0.15581124f, -0.06386138f, -0.06820805f, -0.00002783f, -0.06221247f, 
    0.51763272f, -0.16316387f, -0.29255551f, 0.04545081f, 0.15872368f, -0.02022904f, 0.22902708f, 0.02920338f, 
    -0.03293651f, -0.14067684f, -0.14992027f, -0.08280484f, -0.04397818f, 0.00799652f, 0.20780247f, 0.25403160f, 
    -0.14113690f, -0.03393621f, -0.07295248f, 0.12424372f, 0.02342653f, -0.08018927f, -0.06922133f, -0.09073541f, 
    0.00016543f, 0.11912265f, -0.03636687f, -0.09575868f, 0.19837514f, 0.08607329f, 0.13967319f, 0.00642218f, 
    -0.11094943f, -0.01940896f, -0.07516333f, -0.08829071f, 0.20904434f, -0.02153766f, 0.02982147f, 0.02830162f, 
    -0.15556450f, 0.06205526f, 0.01848193f, 0.17492349f, 0.00825531f, -0.03279955f, -0.04701125f, -0.12450454f, 
    -0.05972004f, 0.09269211f, 0.35467985f, 0.20420283f, -0.10045137f, -0.05486663f, 0.14524730f, 0.17733309f, 
    0.01927004f, 0.08177203f, 0.00721833f, 0.02902296f, 0.10150822f, 0.08841332f, 0.42321509f, -0.19451852f, 
    0.06812607f, 0.02789777f, 0.00475999f, 0.19744812f, -0.10477477f, 0.08743819f, -0.01131500f, -0.08355527f, 
    -0.28348774f, -0.07759464f, -0.10394380f, 0.22834742f, 0.00567939f, 0.05171826f, -0.04911001f, -0.06194356f, 
    0.10305580f, 0.17895667f, -0.03893743f, 0.14346744f, 0.07887342f, -0.18409033f, -0.01744086f, 0.18323848f, 
    0.02301881f, -0.10504742f, -0.03017883f, -0.05310472f, 0.08506692f, -0.02338309f, -0.07948233f, 0.04173619f, 
    0.26003504f, 0.21097019f, 0.15380970f, -0.06590007f, -0.00998661f, 0.12367897f, 0.00327693f, -0.04074153f, 
    -0.08348610f, -0.07178276f, -0.09766666f, -0.21266109f, 0.11975860f, -0.03506235f, -0.04080363f, -0.10564460f, 
    -0.10939685f, 0.00121837f, -0.02591152f, 0.09176671f, 0.08516665f, 0.01833789f, -0.10012536f, -0.10886934f, 
    -0.13167231f, 0.20185363f, 0.20599501f, -0.01030348f, 0.03536168f, 0.14731890f, 0.19049644f, 0.04149094f, 
    -0.09770321f, 0.01745046f, -0.07166153f, -0.00609858f, -0.24306557f, -0.11376278f, 0.07437161f, 0.35981655f, 
    -0.08433606f, 0.17633033f, -0.00935276f, 0.12243871f, 0.02621711f, -0.14057764f, 0.05485095f, -0.07466107f, 
    0.05748473f, 0.11417725f, 0.03831473f, -0.00015106f, 0.04607531f, -0.00407857f, 0.02717755f, -0.02245850f, 
    0.19152412f, 0.04339973f, 0.25515342f, 0.38114339f, -0.02729157f, -0.13797067f, -0.03502115f, 0.12415683f, 
    -0.09209332f, -0.17037612f, -0.00093106f, -0.08822468f, 0.13271101f, 0.14831412f, 0.08145796f, 0.16282293f, 
    0.16587920f, -0.00409163f, 0.16557036f, 0.15393505f, -0.06440601f, 0.11514235f, -0.03929619f, -0.05803590f, 
    0.03992736f, -0.05347543f, 0.06897879f, 0.05237250f, -0.07975227f, -0.14754578f, 0.07120411f, 0.08706252f, 
    0.04858697f, 0.09694470f, -0.03580273f, -0.02227543f, 0.11375637f, 0.06023077f, 0.19010016f, -0.09397577f, 
    -0.01179245f, 0.17688388f, 0.25598630f, 0.27202639f, -0.07018844f, -0.20179468f, 0.00206747f, -0.00601223f, 
    0.12632661f, 0.00554679f, 0.08478938f, 0.13475369f, 0.14094010f, 0.00703548f, 0.01302773f, -0.07149372f, 
    -0.00352455f, 0.00207283f, 0.02852858f, -0.00812940f, 0.01925954f, 0.05409762f, -0.02887412f, 0.02063579f, 
    0.08483910f, 0.11074807f, -0.08916235f, -0.01494883f, -0.05448791f, -0.02519516f, -0.03041770f, -0.08872443f, 
    0.16151199f, 0.19139272f, 0.21584055f, 0.23798059f, -0.14948852f, -0.21636659f, 0.12335082f, 0.10609203f, 
    0.22838959f, 0.09049208f, 0.08615518f, -0.03517338f, 0.20607102f, 0.15319204f, 0.11787375f, 0.18135130f, 
    0.11010139f, -0.13423303f, 0.18474770f, 0.11629564f, 0.12227333f, 0.04788006f, 0.12174423f, -0.00172339f, 
    0.09882607f, 0.03967559f, 0.08975490f, 0.14697264f, -0.15318693f, 0.20899093f, -0.14343609f, -0.07197833f, 
    -0.01267655f, -0.00204636f, 0.03951772f, -0.07755041f, 0.07567672f, 0.05380832f, 0.02563178f, 0.08687773f, 
    -0.01578435f, 0.10371682f, 0.04006581f, 0.19498631f, 0.07887945f, 0.05189165f, 0.10364681f, 0.22266883f, 
    0.15409844f, -0.00444107f, 0.07808279f, -0.00655922f, -0.19474669f, 0.15628628f, 0.12771033f, 0.20054650f, 
    0.20929053f, 0.02430752f, 0.01383547f, 0.09886049f, 0.11177621f, 0.09808150f, 0.19823633f, 0.15151586f, 
    0.08660794f, 0.22536902f, 0.02651441f, 0.11570564f, -0.03998595f, 0.04376280f, -0.05001643f, -0.00025364f, 
    -0.26833498f, -0.00369456f, -0.05633282f, 0.16226195f, -0.01716299f, 0.07283281f, 0.10008264f, 0.09203019f, 
    0.15373673f, 0.01274655f, 0.01489527f, 0.16288760f, 0.16158502f, 0.13215859f, 0.19470748f, 0.19736435f, 
    0.03276888f, 0.02603722f, 0.23391879f, 0.19706582f, -0.01036248f, -0.05802607f, 0.00342766f, 0.22371593f, 
    -0.04281189f, 0.09187269f, -0.03849658f, -0.05889273f, 0.02328464f, 0.07628447f, 0.08351228f, 0.27976131f, 
    -0.08763026f, -0.07073211f, 0.16645287f, 0.12941068f, 0.14584501f, 0.20782295f, -0.00562594f, 0.09729631f, 
    0.06222158f, 0.19298807f, -0.07693229f, 0.14336108f, -0.06433300f, 0.01948470f, 0.01902782f, 0.26592273f, 
    0.08866863f, -0.00975353f, -0.18398410f, 0.22915745f, -0.06927329f, 0.12814896f, 0.11856601f, -0.21425474f, 
    0.05863370f, -0.03847931f, -0.06067903f, -0.08761841f, 0.02732371f, -0.07556742f, -0.03675667f, 0.16812153f, 
    0.13568120f, -0.15409867f, 0.09180567f, 0.17422578f, 0.08695070f, -0.01988170f, 0.02160860f, -0.00601177f, 
    0.01382553f, -0.02616620f, -0.06988112f, -0.10696155f, -0.38937950f, -0.20420887f, 0.29331070f, 0.26685923f, 
    0.07667392f, 0.12179860f, -0.07592978f, -0.10357922f, -0.08026106f, 0.01951859f, 0.01199171f, 0.08754007f, 
    -0.09447861f, -0.09110636f, 0.12334901f, 0.27104518f, 0.02736466f, -0.05990741f, -0.12611905f, -0.09136504f, 
    0.12676412f, 0.06419130f, 0.08071324f, 0.13682491f, 0.11841872f, 0.18002126f, 0.36635715f, 0.28519225f, 
    0.01760943f, -0.05907838f, -0.10969377f, 0.30867705f, -0.03745798f, 0.10269276f, 0.05716207f, 0.10414843f, 
    -0.03570717f, 0.16943352f, 0.03939919f, -0.08280909f, -0.14514138f, 0.09748902f, -0.06810841f, 0.01178728f, 
    0.21776579f, -0.00898355f, 0.05161154f, -0.01335024f, -0.26092827f, -0.23619854f, -0.06317891f, 0.16828252f, 
    -0.03148841f, 0.05548295f, 0.02465631f, 0.10980787f, 0.06701526f, -0.09506860f, -0.01384884f, 0.04607782f, 
    0.15080139f, 0.19347803f, 0.04384637f, 0.15113816f, 0.04236707f, 0.11624661f, 0.08123329f, -0.01444489f, 
    -0.02974090f, 0.01692286f, 0.00023999f, 0.15254571f, -0.06473456f, 0.50757194f, 0.28943539f, -0.18647489f, 
    0.07882328f, 0.07287686f, 0.14153349f, -0.16657329f, -0.11956833f, -0.01192060f, 0.07767282f, 0.15644944f, 
    -0.13485341f, 0.13157743f, -0.11903464f, 0.07531661f, -0.01007614f, 0.01554962f, -0.07153888f, -0.12493805f, 
    0.01970390f, 0.00263454f, -0.15940025f, 0.06880299f, 0.25237793f, -0.10880003f, 0.26770440f, -0.02586523f, 
    0.05667945f, -0.04784720f, 0.00653378f, 0.16856033f, 0.00637930f, 0.01556894f, 0.15221195f, 0.07602847f, 
    -0.26365405f, 0.25434262f, -0.22135402f, 0.45056006f, 0.10727068f, -0.03674059f, 0.12530877f, -0.07502684f, 
    0.12345026f, 0.01411197f, 0.16144127f, 0.14698313f, -0.15742995f, -0.09158713f, -0.08319071f, 0.43500274f, 
    0.08152397f, -0.00207337f, 0.05349673f, -0.04702795f, 0.02354266f, 0.09950949f, 0.11342689f, 0.06315019f, 
    -0.03954659f, 0.07946977f, -0.13823844f, 0.22720136f, -0.02568225f, 0.03493353f, 0.07988189f, -0.00606126f, 
    0.04548073f, 0.04141622f, -0.05749999f, 0.05613209f, -0.51567596f, -0.18903361f, -0.16347441f, 0.54394972f, 
    0.11069496f, 0.21436846f, -0.12153884f, 0.06393009f, 0.09158435f, -0.01768317f, 0.09507950f, 0.10299496f, 
    -0.16811350f, -0.19480509f, 0.14690903f, 0.38886103f, -0.01162747f, -0.11001182f, 0.13939394f, -0.07468445f, 
    0.07876718f, 0.11249836f, 0.04331906f, 0.09561717f, 0.08694696f, 0.28126207f, 0.16707376f, 0.33768713f, 
    0.00421018f, -0.15042213f, 0.10449997f, 0.07910727f, -0.07739487f, -0.06690909f, 0.04804745f, 0.06930602f, 
    0.14032538f, 0.02503579f, -0.07655998f, 0.04615544f, 0.18797113f, 0.07493345f, 0.13930158f, 0.14112075f, 
    -0.07775572f, -0.06414226f, -0.08381180f, -0.07004908f, 0.10489574f, 0.11704122f, -0.00174064f, 0.01506183f, 
    0.15449950f, -0.04591677f, 0.12398867f, 0.01968080f, -0.01774299f, 0.04014801f, -0.03800254f, -0.00210278f, 
    0.11673263f, 0.11849561f, 0.17128468f, 0.14610495f, -0.13516560f, -0.03670676f, 0.06329273f, -0.08330555f, 
    0.06855287f, -0.02443733f, -0.04882198f, -0.04298848f, 0.24772403f, 0.09197155f, 0.04252264f, 0.01136863f, 
    0.01220458f, -0.01668976f, 0.04557514f, 0.00936891f, 0.02680010f, 0.03547801f, -0.04104307f, -0.01426159f, 
    0.25155765f, 0.41828337f, -0.04782275f, 0.05852421f, -0.11414374f, 0.12964191f, 0.08861302f, -0.10682708f, 
    0.07109219f, 0.17197239f, 0.00056151f, 0.29698575f, 0.27748308f, 0.02961867f, -0.18401261f, 0.22234859f, 
    0.13035825f, -0.05922075f, 0.14916170f, -0.01859975f, 0.13400112f, 0.04174463f, 0.08954205f, 0.05752177f, 
    -0.12432955f, -0.03737751f, 0.18658891f, 0.34430790f, 0.00071908f, -0.02164672f, 0.07577992f, 0.00938920f, 
    0.04829516f, 0.19861308f, 0.13407591f, 0.11015635f, -0.32357201f, 0.15038334f, -0.04581233f, 0.33024889f, 
    0.02457645f, -0.05265909f, -0.10312408f, -0.06794396f, 0.04088636f, -0.01548690f, 0.03843798f, 0.08165778f, 
    0.02643636f, 0.02407914f, 0.01431827f, -0.00496637f, 0.01048704f, -0.02896442f, -0.02201793f, 0.00145606f, 
    -0.03375171f, -0.01352601f, 0.01928938f, -0.02521460f, -0.04129953f, 0.00175949f, 0.02273576f, 0.01954160f, 
    -0.01179626f, -0.01880743f, -0.00714466f, -0.00612901f, -0.02637713f, 0.00451070f, -0.00159103f, -0.03948105f, 
    0.02710648f, -0.00817423f, 0.01803046f, 0.01937284f, -0.00704314f, 0.01738186f, 0.02560252f, 0.02617438f, 
    0.00807095f, -0.02175400f, -0.00408646f, 0.00412778f, 0.01707401f, 0.01389686f, -0.00803973f, -0.04376187f, 
    0.01273546f, -0.04281236f, -0.02315463f, 0.00774435f, 0.03094882f, 0.00588645f, 0.03027215f, -0.00820271f, 
    -0.03724239f, 0.01423405f, -0.00029734f, -0.01062876f, 0.00013434f, -0.00765714f, 0.02744105f, -0.02612028f, 
    0.02092601f, 0.02513170f, -0.00716675f, -0.04474828f, -0.01209884f, 0.00850916f, 0.00504565f, -0.00388835f, 
    -0.04091578f, -0.00737219f, -0.04327052f, 0.01011297f, 0.00997427f, -0.01130218f, 0.03172403f, 0.02804249f, 
    0.00109296f, 0.01253458f, -0.01670290f, -0.04304013f, -0.01496239f, -0.01105249f, -0.03626838f, 0.02240743f, 
    0.02506308f, -0.02353252f, -0.01112598f, 0.02041372f, 0.02693596f, -0.03362679f, 0.00443960f, -0.01897446f, 
    -0.00466550f, 0.01000684f, 0.02198324f, 0.01081855f, -0.04435432f, -0.03607319f, 0.01738543f, 0.00249491f, 
    -0.00676315f, -0.00530135f, -0.03367905f, -0.00103417f, -0.03148485f, -0.02553305f, 0.01412343f, -0.02587929f, 
    -0.03699182f, 0.03883810f, -0.00308678f, -0.03851491f, 0.02038302f, -0.01959832f, 0.03269987f, 0.01349884f, 
    -0.01503138f, -0.02171680f, -0.01216965f, -0.02378028f, 0.02076204f, 0.01283691f, -0.04420941f, -0.02489896f, 
    -0.00335874f, -0.01344748f, -0.02355660f, -0.01756356f, 0.00171247f, -0.01394140f, 0.02751507f, -0.02986788f, 
    0.01476568f, 0.03013626f, 0.00486050f, 0.00551879f, 0.01993059f, 0.01676803f, -0.02227204f, 0.02108806f, 
    -0.04125576f, -0.00542910f, 0.02869770f, -0.00420864f, -0.04181231f, -0.03531947f, 0.00928086f, -0.01545416f, 
    0.01332300f, -0.03063519f, -0.02834573f, 0.01794570f, -0.01927968f, -0.01042648f, -0.01651591f, 0.00345827f, 
    0.00292094f, 0.00264274f, 0.03139333f, 0.00663806f, -0.00048140f, -0.00722396f, -0.01868801f, -0.03157035f, 
    -0.02294056f, -0.01717543f, 0.00472615f, -0.03491540f, -0.03223020f, -0.00403573f, 0.02462162f, -0.00298033f, 
    -0.02914271f, 0.02651833f, 0.01384980f, -0.02079568f, -0.03424942f, 0.00454637f, 0.01737319f, -0.04167618f, 
    0.01867677f, 0.00861209f, -0.02134743f, -0.03446873f, -0.04104451f, -0.02701959f, 0.00930872f, -0.03543240f, 
    -0.02951360f, -0.03243095f, -0.01829873f, 0.01732077f, -0.03484164f, -0.00664239f, 0.02180750f, 0.00116869f, 
    -0.03820721f, 0.01309140f, 0.01433224f, 0.02771149f, -0.01463434f, -0.03577057f, -0.03406788f, 0.00211237f, 
    0.02180833f, 0.01431462f, 0.01262956f, 0.01725129f, 0.00300673f, -0.02116606f, -0.00704213f, -0.01386854f, 
    0.00345743f, 0.00496277f, 0.00355041f, -0.03352211f, 0.02631837f, 0.02113609f, -0.02068136f, -0.03479555f, 
    0.01520178f, 0.02618549f, -0.01959145f, 0.01290811f, -0.00703111f, -0.02040404f, 0.00116495f, 0.01245604f, 
    0.01479037f, -0.01168013f, 0.00022613f, -0.00137124f, -0.02130044f, -0.01576912f, -0.03465484f, -0.00179716f, 
    -0.01099169f, 0.00527424f, -0.02618082f, -0.04247006f, 0.01841342f, -0.01480603f, 0.03009866f, -0.02443620f, 
    -0.00079209f, 0.02799977f, 0.02003844f, 0.01859942f, -0.02785132f, -0.00436400f, -0.02644699f, 0.02034911f, 
    -0.00015940f, -0.03338326f, 0.01122250f, 0.03008178f, 0.00546271f, -0.03353855f, 0.02332534f, -0.03794189f, 
    0.01544001f, 0.00366418f, -0.03677828f, 0.00816189f, -0.01258523f, 0.00689057f, -0.03611184f, -0.03370381f, 
    0.02534675f, 0.00370652f, -0.03315179f, -0.00429203f, 0.01957615f, -0.00257056f, -0.02800859f, -0.01813614f, 
    -0.01169322f, -0.00850975f, 0.02438005f, 0.00875123f, 0.02979147f, -0.02238414f, -0.01713806f, -0.00784939f, 
    0.00541125f, -0.02579989f, -0.01969779f, -0.02466549f, 0.02112498f, 0.01282032f, -0.02443651f, -0.02954007f, 
    0.02364788f, -0.04082496f, -0.01367787f, -0.02920037f, -0.01245365f, -0.02256849f, -0.01696828f, -0.01500070f, 
    0.02187740f, -0.01730028f, -0.00249477f, -0.01308124f, -0.02911919f, -0.00402754f, -0.00268914f, 0.01565736f, 
    -0.00823325f, 0.00933772f, -0.00719069f, -0.04504849f, 0.01553902f, 0.02026860f, -0.01119962f, -0.02232435f, 
    -0.00086885f, -0.01269271f, 0.01169070f, 0.00815473f, 0.01368691f, -0.01204807f, 0.02857923f, -0.04216817f, 
    -0.00856436f, -0.02931530f, 0.02256760f, -0.00498498f, 0.01758712f, -0.03794623f, -0.01084601f, -0.02921147f, 
    -0.03021552f, -0.01398997f, -0.00115726f, -0.04336987f, 0.02460054f, 0.02605926f, -0.02615158f, -0.01683601f, 
    0.02427542f, 0.01384242f, -0.00320494f, -0.00736339f, 0.01823539f, -0.03750505f, -0.02699329f, -0.00768481f, 
    -0.00072409f, 0.00448088f, -0.01050419f, -0.04113244f, 0.01684639f, -0.03361899f, 0.00084148f, -0.01353822f, 
    -0.01701581f, -0.02219669f, -0.02523191f, 0.02055439f, -0.02868110f, 0.00986047f, -0.01761869f, 0.01695913f, 
    -0.02471870f, -0.00949838f, 0.02522648f, -0.04329827f, 0.00607014f, -0.00456605f, 0.02151417f, 0.01177017f, 
    -0.00109755f, 0.02269919f, -0.00317353f, -0.00388001f, -0.01056938f, 0.00471226f, 0.00321714f, -0.00860505f, 
    0.03120665f, -0.03802172f, -0.00235520f, -0.02139170f, 0.00591188f, -0.03602148f, -0.01412787f, 0.02896843f, 
    0.01700192f, 0.02871939f, -0.00204629f, -0.03770573f, 0.02302211f, -0.00326570f, 0.00210196f, 0.00286842f, 
    0.00587209f, -0.01752586f, 0.02236019f, 0.01941215f, -0.01487157f, 0.01920881f, -0.00644481f, -0.03352513f, 
    -0.02219507f, -0.02703974f, -0.02949341f, -0.03446512f, -0.02668313f, 0.02428822f, 0.00564211f, -0.04134133f, 
    0.00348434f, 0.02049811f, 0.00689980f, -0.00544185f, -0.01909306f, -0.00814822f, 0.00295562f, -0.02890437f, 
    -0.02958179f, 0.00411140f, -0.04416375f, 0.01353514f, -0.00829357f, 0.02538557f, 0.01925683f, -0.02161087f, 
    -0.01518460f, 0.02047222f, 0.01854601f, 0.02193850f, -0.01500969f, -0.00082664f, 0.02079786f, -0.02926641f, 
    0.02634679f, -0.02923074f, 0.00345888f, -0.00245489f, -0.02453905f, 0.02372564f, -0.00158134f, -0.01115188f, 
    -0.00689022f, 0.02560971f, -0.00741385f, -0.03636149f, 0.01821675f, -0.02991416f, -0.04368038f, 0.02564809f, 
    -0.00577816f, -0.00866928f, -0.03756386f, -0.03726816f, 0.02614431f, 0.02204788f, -0.03807784f, -0.01853624f, 
    -0.01696057f, -0.02425596f, -0.03278260f, -0.00945468f, -0.01968168f, -0.04167236f, 0.02287746f, -0.02572520f, 
    -0.00483855f, -0.02574118f, 0.00757955f, 0.02132723f, 0.02565474f, -0.00235355f, -0.01605662f, 0.02682639f, 
    -0.03015850f, -0.01997994f, -0.03342165f, 0.01430200f, 0.02554184f, 0.02556564f, -0.00809158f, 0.01704251f, 
    -0.03933089f, -0.01341077f, 0.02260656f, -0.01880541f, -0.02885063f, -0.02387099f, -0.01255716f, 0.00576510f, 
    0.02602183f, 0.01694083f, 0.01056526f, -0.02025479f, 0.02657716f, -0.04354975f, 0.02431958f, 0.01563658f, 
    0.02235882f, -0.01494439f, -0.02470435f, -0.02850935f, 0.01065569f, 0.02184831f, -0.03670639f, 0.01091240f, 
    -0.01570077f, 0.00073070f, 0.00119774f, 0.02355630f, -0.01155810f, 0.02361145f, 0.01477885f, -0.00216484f, 
    -0.02297781f, -0.02110047f, 0.02551751f, 0.02815765f, 0.02303449f, -0.00155340f, 0.00253623f, 0.01781577f, 
    0.00309596f, 0.00568683f, 0.01496694f, -0.03350957f, 0.02428829f, -0.00376579f, 0.01928934f, -0.01137657f, 
    0.02138240f, -0.02097180f, -0.01909822f, -0.00342479f, 0.01801323f, 0.01950785f, -0.02398775f, -0.01765164f, 
    0.02625534f, -0.01630971f, -0.03327594f, 0.00474458f, 0.02805668f, -0.01475716f, 0.01505193f, 0.00527845f, 
    -0.03536238f, -0.01645892f, -0.02193199f, -0.03007613f, 0.01263971f, -0.01267457f, -0.01966286f, 0.01339081f, 
    -0.04277987f, 0.02750149f, -0.01023296f, -0.03489904f, 0.02312271f, 0.00913746f, 0.02784202f, 0.02436995f, 
    -0.01430055f, -0.00476964f, 0.02453455f, -0.00255707f, -0.01608953f, -0.01423798f, -0.02471675f, -0.03596338f, 
    -0.01668138f, -0.02335751f, -0.00799930f, 0.02233296f, 0.02590520f, -0.03975642f, -0.01385365f, -0.02941452f, 
    0.02013091f, -0.00033225f, 0.01056888f, -0.03413960f, 0.02110463f, -0.02658813f, -0.00933745f, 0.00734015f, 
    -0.01546779f, -0.00107699f, -0.02472104f, -0.00865748f, -0.00974715f, 0.00086852f, 0.01977901f, -0.04403058f, 
    -0.03163189f, -0.02418484f, -0.02924392f, -0.02515068f, -0.03106916f, -0.03186594f, -0.03282226f, 0.01676406f, 
    -0.04220032f, -0.02411624f, -0.00991731f, -0.03035523f, -0.00306068f, 0.01233040f, -0.02620055f, 0.00399462f, 
    0.00983961f, 0.00320374f, -0.02520176f, -0.02952375f, -0.01245152f, -0.00643970f, -0.01737083f, -0.03449134f, 
    -0.01549334f, 0.01854037f, -0.01310426f, -0.03142072f, -0.00113016f, -0.01887066f, -0.03711867f, -0.04125632f, 
    -0.01330545f, -0.03440114f, -0.03580078f, 0.01205699f, -0.01404851f, -0.01659928f, -0.01274475f, -0.00228179f, 
    -0.02476855f, 0.02429386f, -0.00200848f, -0.02520454f, -0.02496838f, 0.00216529f, -0.01274789f, 0.01760953f, 
    -0.01365819f, -0.00079221f, -0.01771608f, 0.01293951f, -0.01764420f, -0.04400465f, -0.03312740f, 0.00146602f, 
    0.02243962f, -0.03891909f, 0.00509066f, 0.02438587f, -0.00013852f, -0.00054942f, -0.03439292f, -0.00424758f, 
    -0.01931616f, 0.02588163f, -0.03999178f, 0.02501169f, -0.00606122f, 0.01784412f, 0.01075436f, -0.02975418f, 
    -0.02927944f, -0.00807624f, 0.01193703f, 0.00762750f, -0.00867857f, -0.04112342f, 0.00527148f, 0.01930453f, 
    -0.03509896f, 0.01513175f, 0.03034549f, -0.03812739f, 0.01710862f, -0.02694997f, 0.02550070f, -0.01116851f, 
    -0.00199202f, 0.03305643f, -0.01145768f, -0.02327768f, 0.00691981f, -0.03545409f, -0.02765683f, 0.01881131f, 
    -0.00836842f, -0.01993210f, -0.03872521f, -0.01672743f, -0.02673175f, 0.02742269f, -0.00230263f, 0.00784630f, 
    -0.02979181f, 0.01131408f, -0.00076673f, -0.00756837f, 0.01487750f, -0.02644966f, -0.00005465f, -0.02228703f, 
    0.01874280f, 0.02688644f, 0.00292306f, 0.02425772f, -0.04374264f, -0.00974943f, -0.02222322f, -0.03824506f, 
    -0.00006933f, -0.01464131f, -0.02273753f, 0.02270348f, -0.01183903f, -0.01200962f, 0.00621766f, -0.02637101f, 
    0.02223490f, 0.02349895f, -0.00574018f, 0.01972427f, 0.01000751f, -0.02900363f, -0.00585547f, 0.01339649f, 
    -0.02282182f, -0.02982062f, -0.02508425f, -0.03501428f, 0.02528743f, -0.02664930f, -0.01405850f, -0.02082950f, 
    0.02327188f, -0.03215008f, 0.01692064f, -0.02601656f, -0.02484015f, 0.00723752f, -0.01636194f, -0.04329361f, 
    -0.01556875f, -0.01657322f, 0.01751276f, 0.01351036f, 0.02331117f, 0.02767152f, -0.03360980f, -0.02987135f, 
    0.00892336f, -0.00433264f, -0.00614544f, -0.00216443f, 0.01465590f, -0.02028579f, -0.00575514f, -0.03349333f, 
    -0.01615056f, 0.00900217f, -0.03663084f, 0.02649304f, 0.01954472f, 0.03565408f, -0.01548913f, -0.03542823f, 
    -0.25773031f, -0.03483601f, -0.00676688f, -0.15011798f, 0.02490516f, 0.05575711f, -0.02343884f, -0.03343483f, 
    -0.10334959f, -0.05081994f, -0.16640589f, -0.04160274f, 0.19464904f, 0.12173760f, 0.12103296f, -0.02393627f, 
    0.00749242f, 0.00779572f, 0.05095705f, 0.12335880f, -0.06122909f, -0.05540928f, 0.00690136f, 0.09794915f, 
    0.23456508f, 0.35038191f, 0.14857699f, 0.11181511f, 0.03781673f, 0.17029192f, 0.00969459f, 0.15597098f, 
    0.05660056f, -0.05725558f, -0.02110823f, 0.01794245f, 0.08955245f, 0.06081544f, -0.04999154f, -0.24433754f, 
    0.05352659f, -0.00753526f, -0.02274848f, 0.00312661f, 0.05466917f, 0.00111741f, -0.01270005f, 0.02228918f, 
    -0.05236260f, -0.24654782f, -0.24277754f, -0.11480475f, -0.06681154f, 0.01480936f, 0.01940638f, -0.06728718f, 
    -0.07278856f, 0.04319638f, -0.03030731f, -0.10104873f, -0.22220431f, 0.00579499f, 0.01240361f, 0.01076591f, 
    -0.07819662f, -0.03051457f, 0.04189448f, -0.01870989f, -0.00842461f, 0.02053463f, 0.01220746f, 0.13847943f, 
    -0.06999835f, -0.12498216f, -0.06223965f, -0.22966698f, -0.02220781f, 0.03135056f, -0.03602719f, -0.02218843f, 
    -0.10122375f, -0.02262634f, 0.03087675f, -0.18081102f, -0.18898627f, 0.26807201f, -0.00570866f, -0.05252384f, 
    -0.05508314f, 0.08381523f, 0.03090225f, 0.10644463f, -0.04982846f, -0.03163753f, 0.00971848f, -0.07379486f, 
    -0.23457757f, 0.09649409f, 0.42788899f, 0.06533440f, -0.00337701f, 0.18702647f, 0.05573442f, -0.03997535f, 
    0.00763858f, 0.05420600f, -0.00034652f, 0.07002288f, -0.20427547f, 0.03894427f, -0.01701027f, -0.04719212f, 
    -0.07084388f, -0.02858746f, -0.03748704f, -0.06464933f, 0.00035298f, 0.11872491f, -0.02666420f, 0.07297300f, 
    -0.24898309f, -0.11712264f, -0.03936511f, 0.05212719f, -0.02101528f, -0.03840730f, 0.01222274f, -0.01386650f, 
    0.05551739f, 0.14246662f, -0.03070549f, -0.05203023f, 0.29651472f, 0.30249533f, 0.13099946f, 0.08975809f, 
    0.03495634f, -0.03974041f, 0.07909514f, 0.09310514f, -0.10713976f, 0.07009128f, -0.02474612f, -0.05289895f, 
    0.06330343f, 0.01047963f, 0.02966016f, 0.04184519f, -0.02857033f, -0.04743559f, -0.09534041f, -0.00230438f, 
    0.05664188f, 0.12062778f, 0.08877353f, 0.14745016f, -0.09189878f, -0.12297397f, -0.10210146f, 0.02876842f, 
    -0.10443492f, -0.12387745f, -0.07226866f, -0.05913451f, -0.04307277f, 0.03343307f, -0.01371747f, 0.04247547f, 
    0.28711322f, 0.11349288f, 0.05765772f, 0.21219416f, 0.10496383f, 0.06571139f, -0.03925597f, 0.05160894f, 
    0.00587773f, -0.04426576f, -0.01245956f, 0.00430125f, 0.22691609f, -0.24995752f, -0.04582144f, 0.20962845f, 
    -0.03713448f, 0.05224215f, 0.09082627f, -0.03673486f, 0.05978692f, -0.03732238f, 0.09163079f, 0.08261477f, 
    -0.12426404f, 0.01481778f, -0.26366884f, -0.10430206f, 0.03760977f, -0.01902830f, -0.01746137f, -0.16394995f, 
    -0.08881016f, -0.05686802f, -0.06285542f, 0.09317251f, -0.18025680f, -0.11274442f, -0.23444310f, -0.10137577f, 
    -0.19714652f, -0.10302714f, 0.05594566f, -0.09758259f, 0.06378111f, -0.00315506f, -0.06372338f, 0.04766557f, 
    -0.20285980f, 0.22687018f, -0.09104200f, -0.04902944f, -0.11468124f, -0.11949889f, -0.22006942f, -0.01161231f, 
    0.01349417f, 0.09889966f, 0.02599234f, -0.19143778f, 0.02289248f, -0.02274633f, -0.07367697f, -0.06609049f, 
    0.02877438f, -0.12830135f, -0.08994687f, 0.13977137f, 0.02072359f, -0.06125560f, 0.10258877f, -0.04853913f, 
    0.23057550f, -0.12753341f, -0.05505185f, 0.15273514f, 0.06866006f, 0.03995087f, 0.09407592f, 0.20106252f, 
    0.10469542f, 0.08423379f, 0.15749843f, 0.14772075f, 0.18135780f, 0.02317308f, 0.08373956f, -0.17897743f, 
    -0.00218719f, -0.06629939f, 0.11781848f, 0.03598566f, -0.00053240f, -0.00156024f, 0.02967611f, 0.02499277f, 
    -0.29339063f, -0.09630504f, -0.04731990f, -0.02920682f, -0.09263103f, -0.10836159f, 0.08374525f, 0.00035546f, 
    -0.08046488f, 0.04475130f, -0.06372588f, -0.11475012f, 0.17794390f, 0.30421650f, 0.08151238f, 0.07285380f, 
    0.13023594f, 0.14933011f, 0.01549237f, 0.09829219f, -0.07612748f, -0.07677236f, 0.01437036f, 0.01234393f, 
    -0.05317453f, -0.17346074f, -0.12698291f, -0.01240961f, -0.18476279f, -0.09330103f, -0.02787901f, 0.00989937f, 
    -0.01853222f, -0.06326943f, 0.06272207f, -0.02157549f, -0.12576422f, -0.12633829f, -0.14449336f, 0.00472122f, 
    0.09572709f, 0.06057934f, 0.05845056f, -0.02892909f, 0.20382318f, 0.09102155f, 0.06986684f, 0.14258729f, 
    0.16275817f, -0.02299641f, -0.12654136f, -0.07479292f, 0.07901620f, 0.09430561f, -0.00197132f, 0.11242878f, 
    -0.00684908f, 0.05490124f, 0.00765705f, -0.10841158f, 0.12002286f, -0.01568545f, 0.27037072f, 0.03561573f, 
    0.01355341f, 0.10882664f, 0.03368810f, -0.00467751f, -0.02749966f, -0.01502427f, -0.01382596f, 0.09752425f, 
    -0.23780632f, -0.12512422f, -0.00457904f, 0.02336199f, -0.09110044f, -0.03928515f, -0.07862075f, -0.05908074f, 
    -0.13233781f, -0.10868307f, -0.07051323f, -0.05695352f, 0.19933742f, 0.28857830f, 0.09315669f, 0.08121131f, 
    0.13471383f, 0.11476728f, 0.05863946f, -0.00780696f, 0.00298707f, -0.07516488f, -0.11029597f, -0.03610228f, 
    0.21280679f, 0.22315088f, 0.09448814f, 0.01025441f, 0.02636081f, 0.10781347f, 0.02760651f, 0.17789070f, 
    0.00682301f, -0.05336870f, 0.00271193f, -0.03849164f, -0.21636996f, -0.10546602f, 0.03662871f, -0.11293464f, 
    0.00126666f, 0.03410291f, -0.08572835f, -0.05053356f, 0.02854206f, 0.06390595f, 0.16771361f, 0.08034204f, 
    -0.07110137f, -0.01805548f, -0.12687604f, -0.18774027f, -0.12378727f, 0.14525680f, 0.03926075f, -0.02969739f, 
    0.02246685f, 0.07132825f, 0.06690003f, 0.03736506f, 0.18938164f, 0.09756926f, 0.15917028f, -0.07075099f, 
    0.05126518f, 0.10262660f, 0.00066776f, -0.03961761f, -0.07523604f, 0.11682618f, -0.07229621f, -0.09227753f, 
    0.24861610f, -0.16126145f, -0.09446677f, -0.09566405f, -0.05761426f, -0.02547546f, 0.01261277f, -0.00003297f, 
    -0.06083627f, 0.03150829f, -0.03030702f, -0.13331656f, 0.28472596f, 0.18693462f, 0.10573576f, 0.10716574f, 
    0.10187304f, 0.04565749f, 0.03495725f, 0.07933565f, -0.07408736f, 0.01383203f, -0.04374562f, -0.02066703f, 
    0.27056193f, 0.26720157f, 0.14427762f, 0.08636264f, 0.03042478f, 0.19072840f, 0.00544275f, 0.06317041f, 
    -0.07871583f, -0.02606699f, -0.02647757f, -0.00332272f, 0.23247054f, 0.15274414f, 0.08995901f, 0.11167987f, 
    0.05800075f, 0.03837033f, 0.00900232f, 0.12308978f, -0.01075272f, -0.19540256f, -0.09302635f, 0.05619748f, 
    -0.07386982f, 0.09374713f, 0.03727682f, -0.17603052f, 0.06136309f, -0.01334526f, 0.07298665f, 0.11343041f, 
    -0.03849903f, 0.01650142f, 0.23254038f, -0.22709207f, 0.02006294f, -0.29261306f, -0.05034608f, -0.06814729f, 
    -0.00998775f, -0.04156493f, 0.01934336f, -0.12887804f, -0.00064396f, 0.08389938f, 0.09556545f, 0.12207855f, 
    -0.10405818f, -0.10605041f, -0.35413975f, -0.11342268f, -0.25498319f, -0.07502433f, -0.09495408f, -0.06387090f, 
    0.01084050f, -0.01307987f, 0.02205023f, 0.00632974f, -0.00084965f, -0.12612957f, -0.10760026f, -0.04719551f, 
    -0.16492872f, -0.12049955f, -0.01569600f, -0.13339321f, -0.02395757f, -0.07894775f, 0.02315811f, 0.16291249f, 
    0.41770202f, 0.39618072f, 0.04140558f, 0.04403553f, 0.15553236f, 0.20668569f, 0.07212075f, 0.06639823f, 
    0.07942586f, 0.04564323f, -0.01831268f, -0.07979049f, 0.30228457f, 0.02395057f, -0.24198949f, -0.00008743f, 
    0.09367830f, 0.03921764f, 0.08835097f, -0.04101008f, 0.11175486f, -0.02975326f, 0.10949425f, -0.01110055f, 
    -0.02884176f, -0.07370563f, -0.08328130f, -0.02992057f, 0.07718877f, 0.01011671f, 0.07573304f, -0.04137879f, 
    0.05335712f, 0.15107980f, 0.14616390f, 0.09403312f, -0.10477881f, 0.18360992f, 0.18526678f, -0.18940137f, 
    -0.06743342f, 0.12904476f, 0.09774276f, -0.01961037f, -0.02103194f, -0.03213618f, -0.01272263f, -0.07488503f, 
    -0.17657487f, 0.03323185f, 0.26348317f, -0.03715824f, -0.10154794f, 0.00262933f, 0.03882087f, 0.09520069f, 
    -0.00266021f, 0.04229971f, -0.00907112f, -0.05169177f, -0.03510167f, -0.30527988f, 0.07962836f, -0.00670434f, 
    -0.02501119f, -0.05329064f, 0.03794780f, 0.03057604f, 0.00646735f, 0.13822034f, -0.03332983f, -0.06480820f, 
    -0.34344581f, 0.04790036f, 0.12103987f, -0.19170474f, -0.00341893f, -0.05089554f, 0.00315155f, -0.10895542f, 
    0.13806845f, 0.12371739f, 0.02665912f, 0.16403908f, -0.13861157f, 0.06479784f, -0.00588270f, 0.00964918f, 
    -0.02028649f, 0.12203863f, 0.08943287f, -0.08577824f, 0.04595096f, 0.08862630f, 0.03320894f, 0.04196881f, 
    -0.10997523f, 0.14021353f, 0.30157503f, -0.14547987f, 0.12082192f, 0.08163095f, 0.04749677f, 0.16119048f, 
    0.03044013f, 0.05690813f, 0.02432356f, -0.01447334f, 0.11314944f, 0.29986396f, 0.16566347f, -0.06277039f, 
    -0.07201084f, 0.10673022f, -0.05964249f, 0.04783912f, 0.03619627f, -0.12638958f, -0.05691589f, -0.07037073f, 
    -0.13251974f, -0.04617351f, 0.04418204f, -0.15996449f, -0.00766535f, -0.01435075f, 0.03024028f, 0.02390296f, 
    -0.07970558f, 0.10946023f, 0.14684632f, 0.08482545f, -0.01318247f, 0.19682437f, 0.02801442f, -0.25010344f, 
    0.07848088f, 0.04550825f, 0.21751973f, 0.04412527f, 0.06230357f, 0.03949313f, -0.00958413f, 0.13669236f, 
    0.27404723f, 0.40371582f, -0.04253672f, 0.07394812f, -0.00349939f, 0.11447858f, 0.07575676f, 0.23014724f, 
    -0.01868559f, -0.01099120f, -0.11818722f, -0.00026443f, 0.31494442f, 0.21627808f, -0.03686121f, -0.14417130f, 
    0.08119518f, 0.08866240f, -0.03559130f, 0.00879522f, 0.01804285f, 0.01953362f, 0.09343787f, -0.12636575f, 
    -0.04030197f, -0.02734415f, -0.05096581f, -0.21386255f, -0.02811887f, 0.11435769f, 0.08698565f, -0.13154902f, 
    0.01542600f, 0.11946261f, 0.08761358f, 0.09948792f, 0.15536760f, -0.02083955f, 0.06944916f, 0.05388887f, 
    -0.06458801f, -0.01836604f, 0.12858328f, 0.18390128f, 0.08191644f, 0.04381877f, 0.02834501f, -0.10376046f, 
    0.11985268f, 0.18649653f, 0.13088500f, 0.13116100f, 0.00403136f, 0.09538388f, 0.04696348f, 0.13422449f, 
    -0.03028552f, 0.06229457f, 0.04538275f, -0.02266930f, -0.09174112f, -0.17683131f, -0.08309178f, -0.16307104f, 
    -0.09816854f, -0.07513170f, -0.00871714f, 0.06537931f, -0.04444554f, -0.06214093f, -0.04205219f, -0.02539195f, 
    -0.02012263f, -0.31496322f, 0.10413224f, 0.01620706f, -0.02611665f, -0.24552245f, 0.09843526f, -0.03382848f, 
    -0.03532299f, -0.12749967f, 0.06484567f, -0.17680851f, -0.22997309f, 0.15942347f, 0.09974881f, -0.10822196f, 
    0.01563056f, 0.04922924f, -0.02602992f, 0.01173515f, 0.02928671f, -0.01916022f, 0.01330706f, -0.03390766f, 
    0.18616399f, 0.23899336f, 0.05700563f, 0.07903443f, 0.02147759f, 0.06488985f, -0.03438213f, 0.16701134f, 
    -0.03511044f, -0.11443955f, 0.03971655f, 0.09818594f, -0.30662587f, -0.13850248f, 0.10321219f, -0.13452905f, 
    -0.00467081f, 0.04899578f, -0.01669671f, -0.07502596f, 0.00886716f, 0.04235586f, 0.06282569f, 0.05238657f, 
    0.19039570f, 0.05059346f, 0.07706870f, -0.34988171f, -0.02943959f, -0.04914093f, -0.04907204f, -0.02575118f, 
    0.14028311f, -0.02195240f, 0.09300193f, 0.11445557f, -0.15725359f, 0.01852275f, 0.06547359f, 0.19001152f, 
    0.18040688f, 0.17057502f, -0.06039168f, -0.10272712f, 0.07673541f, -0.08675566f, 0.04574585f, -0.06046906f, 
    -0.01454898f, -0.00392236f, -0.19031805f, 0.00826871f, -0.01406860f, 0.22380973f, 0.03157330f, -0.02988662f, 
    0.01632006f, 0.05944899f, 0.03759743f, 0.08262942f, -0.02088301f, -0.02638143f, 0.07779701f, 0.25610134f, 
    0.10310314f, 0.05779654f, 0.11027137f, -0.05090855f, -0.02252236f, 0.04268579f, 0.00529239f, -0.02752399f, 
    0.27658913f, -0.03257273f, 0.12467366f, -0.05368932f, -0.07578911f, -0.10275495f, -0.01398535f, 0.09143092f, 
    0.11687651f, -0.06664471f, 0.11956266f, 0.08281009f, -0.03437100f, 0.10591808f, -0.09935988f, -0.00351669f, 
    0.00875917f, 0.00779630f, -0.10640827f, -0.06006429f, 0.05353407f, 0.15210521f, 0.08127143f, 0.21131651f, 
    -0.01164593f, 0.00572257f, -0.00636102f, -0.15996675f, -0.05910182f, 0.05938226f, 0.09837315f, 0.10273091f, 
    0.17753574f, 0.19224811f, -0.00677864f, 0.11289103f, 0.24265282f, 0.16170606f, -0.03175912f, -0.07509444f, 
    0.09344630f, -0.04442592f, 0.13895582f, -0.00359866f, -0.04167324f, -0.05185068f, -0.22009356f, -0.09382742f, 
    0.70227945f, -0.09290243f, 0.04134636f, -0.00724900f, 0.07558034f, -0.07852094f, 0.09630249f, -0.00009846f, 
    0.10021234f, 0.13160700f, 0.10739059f, 0.20028105f, -0.00738740f, -0.14173812f, 0.00275199f, 0.01059224f, 
    -0.09055062f, -0.04776087f, 0.13723493f, 0.06520840f, -0.05725409f, -0.00683602f, -0.00411603f, -0.04130322f, 
    0.27903748f, 0.11851874f, 0.27613702f, -0.09476717f, 0.03985341f, 0.18068914f, 0.18191271f, 0.06380641f, 
    -0.11050259f, -0.00871786f, -0.03407882f, -0.01942762f, -0.18917161f, -0.28803790f, -0.31544927f, -0.01927081f, 
    0.20881239f, 0.11998706f, -0.05085970f, -0.09750807f, -0.07189795f, 0.00738714f, -0.05449121f, 0.09539624f, 
    -0.08504611f, 0.01045491f, -0.05597012f, -0.00237208f, 0.04572185f, 0.04175431f, -0.13273466f, -0.07152355f, 
    0.05874031f, 0.20489359f, 0.20354423f, 0.16515975f, -0.25419384f, 0.08952551f, 0.15336831f, 0.03446149f, 
    -0.03305913f, -0.03298120f, 0.00667667f, -0.02408539f, 0.02214722f, -0.00607927f, 0.00969766f, -0.03066465f, 
    -0.21018657f, -0.01865133f, -0.07819880f, 0.08450881f, 0.04794016f, 0.05116180f, -0.01743721f, 0.07751291f, 
    0.05055420f, -0.01799883f, 0.01527203f, -0.00126190f, 0.05747902f, 0.10992196f, 0.11695875f, 0.41441828f, 
    0.13823658f, 0.00515915f, 0.12839454f, 0.10799769f, 0.08088536f, 0.03060837f, 0.15559953f, 0.12382281f, 
    -0.06677840f, 0.02252984f, -0.12593837f, -0.36512229f, -0.00914981f, -0.02235951f, -0.03622945f, -0.02107851f, 
    0.16996139f, -0.00585511f, 0.09560531f, -0.04262682f, -0.03500250f, 0.18012966f, -0.00523541f, 0.05925979f, 
    -0.03573838f, -0.08439071f, 0.04794903f, -0.04631346f, -0.13007753f, 0.13665228f, 0.00504638f, -0.09500109f, 
    -0.18409064f, 0.36846253f, 0.19902880f, 0.26988882f, -0.15328215f, -0.16341150f, -0.02780793f, -0.05599720f, 
    -0.06230575f, 0.05245605f, 0.06927382f, 0.07803218f, -0.16921484f, -0.06221825f, -0.11568480f, -0.15717779f, 
    -0.12836803f, 0.02250467f, -0.04863248f, 0.03977845f, -0.12743737f, -0.01017530f, -0.13213271f, -0.14703500f, 
    -0.17804907f, -0.21316211f, 0.11485025f, 0.02547292f, 0.16446519f, 0.04826365f, 0.23411493f, -0.07146721f, 
    -0.03495196f, 0.02128864f, 0.03943707f, 0.03012408f, 0.04010163f, 0.22242321f, -0.03449243f, 0.16012610f, 
    -0.00081238f, 0.11346890f, -0.06233907f, -0.04997949f, -0.02688324f, 0.07403509f, 0.00628720f, 0.06943598f, 
    -0.00348549f, -0.02410416f, 0.03508094f, -0.02938363f, -0.05774671f, -0.00882083f, 0.09255027f, -0.04270828f, 
    0.04298349f, 0.03673803f, 0.01806065f, 0.00559936f, 0.01545439f, -0.10279823f, -0.03631786f, -0.11413351f, 
    0.12185828f, -0.15406410f, 0.08178191f, -0.00578301f, -0.04417722f, 0.04469024f, -0.09153584f, -0.10332475f, 
    -0.28566450f, 0.17445324f, 0.07037728f, 0.01215294f, -0.11873979f, -0.04807240f, -0.06621935f, -0.08576971f, 
    -0.09070785f, 0.07128743f, 0.02576385f, 0.05455249f, -0.04689870f, 0.01960932f, 0.07261994f, -0.05860322f, 
    -0.06272393f, -0.05791178f, 0.04685338f, -0.03998047f, 0.09805938f, 0.13570498f, 0.10617065f, 0.20116337f, 
    -0.11180530f, 0.02074075f, -0.20083334f, 0.05071682f, 0.02546201f, 0.04705323f, 0.10443101f, 0.20800160f, 
    -0.17358330f, -0.14700852f, -0.27358830f, -0.15695697f, 0.56674826f, 0.00807329f, 0.06975878f, 0.01407669f, 
    -0.13211876f, -0.08186478f, -0.01946955f, 0.07525989f, 0.13965441f, 0.11242650f, 0.23064560f, 0.24434261f, 
    -0.15487726f, -0.02631098f, -0.08811425f, -0.15201253f, -0.10244729f, -0.04866059f, -0.01146778f, -0.04441414f, 
    -0.05984251f, -0.02744340f, -0.09230065f, -0.20549454f, 0.16651413f, -0.24245264f, -0.06079630f, -0.12875378f, 
    0.02706175f, 0.08288473f, 0.06614876f, -0.02152813f, 0.05076307f, 0.03010041f, 0.06880937f, 0.09544272f, 
    0.36244437f, -0.09083267f, 0.09650224f, 0.00367453f, 0.06662761f, 0.09306289f, 0.11986482f, 0.06675819f, 
    -0.01111317f, 0.14544003f, 0.15944824f, 0.07563310f, -0.13580067f, -0.07465120f, -0.06120390f, -0.21163434f, 
    -0.14964750f, 0.04049241f, -0.00965580f, -0.01576822f, 0.00306221f, 0.04508938f, 0.15808357f, 0.17695850f, 
    -0.02034605f, 0.08961103f, 0.04066014f, 0.04910515f, 0.07972588f, 0.11141569f, 0.11069104f, -0.00432299f, 
    0.01658526f, 0.10460953f, 0.13591704f, -0.00906091f, 0.31886098f, 0.21955051f, -0.15410106f, -0.07394852f, 
    0.10742855f, 0.11652549f, 0.10050748f, 0.23400110f, 0.02089271f, -0.01169362f, -0.03703454f, -0.09679358f, 
    -0.29173133f, 0.17300360f, 0.18382514f, 0.27743906f, -0.04083407f, -0.03582982f, -0.00347199f, -0.05375767f, 
    0.29898053f, 0.04385710f, 0.19454138f, 0.19307919f, -0.03936201f, -0.11830197f, -0.01918933f, -0.04246124f, 
    0.07703261f, 0.01973597f, 0.06631430f, 0.10934121f, 0.04320444f, 0.02440817f, -0.07094650f, -0.18919726f, 
    0.09896744f, -0.21248183f, -0.02309395f, -0.06814138f, 0.01097651f, 0.15138780f, 0.10194045f, 0.06506633f, 
    0.05125088f, 0.05911424f, 0.09343676f, 0.10722373f, -0.15800849f, -0.06547678f, -0.28503469f, 0.05233133f, 
    0.07827403f, 0.16149028f, 0.11522541f, 0.04724416f, 0.02108683f, -0.01424182f, 0.05591208f, 0.01071173f, 
    -0.28378204f, 0.15626217f, -0.10195921f, 0.09810720f, 0.13547355f, 0.10043355f, -0.09095856f, 0.16895263f, 
    -0.00616200f, -0.06219938f, -0.05070518f, -0.16253147f, -0.05052831f, -0.05027871f, 0.18150763f, 0.01382217f, 
    -0.18019252f, -0.04165185f, 0.01955638f, -0.00155746f, -0.04825679f, -0.04368048f, 0.05630577f, -0.05880975f, 
    -0.24587938f, 0.13236000f, -0.07598852f, 0.08857810f, 0.00152938f, -0.06661563f, -0.05938287f, -0.07735651f, 
    -0.05273384f, 0.08374200f, -0.04150986f, 0.09591860f, -0.03534340f, 0.33293262f, -0.04671808f, -0.04284249f, 
    -0.08225599f, -0.10547143f, 0.05185109f, -0.03338867f, 0.02105470f, -0.03114494f, 0.02913959f, -0.03295643f, 
    0.03669432f, -0.18700962f, -0.26016974f, 0.20558298f, 0.15884417f, -0.09500768f, 0.03563322f, -0.03154081f, 
    -0.05132790f, -0.01964469f, -0.07916445f, -0.19613437f, -0.30698660f, 0.20073716f, -0.05468094f, 0.19167270f, 
    0.00013232f, 0.07165771f, 0.09675296f, 0.24279878f, 0.17226575f, -0.01184315f, -0.00372477f, -0.03649193f, 
    -0.09165461f, 0.02789288f, 0.13866688f, -0.08288482f, 0.01605280f, -0.08129445f, 0.05036365f, 0.03741194f, 
    0.13261360f, 0.06815249f, 0.29178816f, 0.04464442f, 0.04156619f, 0.14107338f, -0.10456968f, -0.04255276f, 
    0.08996837f, 0.19761530f, 0.10948879f, 0.19980349f, -0.12425575f, 0.08816790f, 0.08653896f, -0.02371952f, 
    0.01958389f, 0.18376066f, -0.02141666f, 0.24644196f, 0.10930285f, 0.06510712f, 0.13415527f, 0.12318253f, 
    -0.01042942f, 0.07372121f, -0.04046260f, 0.06417028f, 0.03463083f, 0.14361516f, 0.10894887f, 0.40049604f, 
    -0.00973503f, 0.00719950f, 0.14771563f, 0.00463691f, 0.03195433f, 0.14148040f, 0.02477027f, 0.09868692f, 
    0.17758621f, 0.07331143f, -0.10020816f, -0.25345120f, -0.09371359f, -0.05601022f, -0.04691189f, -0.04938857f, 
    0.18238118f, 0.08555515f, 0.09727431f, 0.06219057f, 0.55911857f, 0.08870100f, 0.17042613f, 0.05498470f, 
    0.01631537f, 0.06888326f, 0.21371754f, 0.15042105f, -0.04792504f, 0.14374234f, 0.07483838f, -0.01842158f, 
    0.41327143f, 0.08397084f, -0.11615253f, -0.04440458f, 0.07389783f, 0.03247227f, 0.02989621f, 0.02829409f, 
    -0.01059126f, 0.05505853f, -0.06975737f, 0.16563246f, 0.19972469f, 0.38815996f, -0.09227351f, -0.10081978f, 
    0.07219654f, 0.20105375f, 0.20536925f, 0.02458599f, 0.01526487f, 0.23048763f, -0.02363536f, 0.07255159f, 
    -0.13578425f, 0.04668430f, -0.09820712f, 0.14661226f, 0.02084903f, -0.01590720f, 0.06465389f, -0.07946344f, 
    0.03823904f, 0.10197815f, 0.10741213f, 0.08032779f, -0.13406846f, 0.23169206f, -0.08591812f, -0.25529534f, 
    0.07233367f, -0.01049250f, 0.07778493f, 0.01337759f, -0.04808793f, 0.07771826f, 0.16813688f, 0.08449623f, 
    0.10408367f, -0.20218769f, 0.00806660f, -0.09344685f, 0.06429248f, -0.07595860f, 0.04061569f, -0.00921283f, 
    0.02276061f, 0.04300917f, 0.07911103f, 0.14225380f, -0.37813818f, 0.01767620f, -0.25756079f, -0.07666820f, 
    0.00439458f, 0.02485626f, 0.16933373f, 0.16545056f, 0.08551559f, 0.12180296f, -0.02013019f, 0.11804024f, 
    -0.16560863f, -0.10015570f, 0.02459140f, -0.00852721f, 0.07106056f, 0.07827748f, 0.14917095f, 0.01157065f, 
    0.03958661f, 0.06039692f, 0.01796454f, 0.01496342f, -0.01173646f, -0.22329947f, 0.08144516f, 0.09359173f, 
    0.12330419f, -0.00842082f, 0.26184249f, 0.11924513f, -0.00034861f, -0.05937793f, -0.14703932f, -0.13048390f, 
    0.04113989f, -0.11979298f, -0.12730770f, 0.03508991f, 0.20642342f, -0.02463815f, 0.04119865f, 0.01217952f, 
    -0.05504224f, 0.05555004f, 0.03739729f, 0.03613410f, -0.28818604f, 0.00891722f, 0.08336323f, 0.02730940f, 
    -0.09449050f, -0.01766708f, -0.03949594f, -0.02840188f, -0.08156034f, -0.06083838f, -0.10389777f, -0.07044020f, 
    -0.26243421f, 0.20666111f, 0.39701176f, 0.03480048f, -0.09917682f, -0.05106204f, 0.03315731f, 0.00104661f, 
    -0.04870605f, -0.04840541f, -0.01145391f, 0.00710364f, 0.20433159f, 0.13392937f, 0.06293561f, 0.04655854f, 
    0.04169980f, 0.15319192f, 0.29680464f, 0.12317891f, -0.00573274f, 0.05586968f, -0.02570802f, -0.05408458f, 
    -0.04108545f, -0.22846961f, -0.05003467f, -0.17618324f, 0.08033150f, -0.01219027f, 0.06141506f, -0.03006457f, 
    0.06791738f, 0.03435688f, 0.04097873f, 0.03233412f, 0.40250099f, 0.00041673f, -0.09231465f, -0.27970031f, 
    -0.07665543f, -0.08549390f, 0.03023940f, 0.01289885f, 0.07852063f, 0.00845459f, 0.08246835f, 0.14999314f, 
    -0.02498386f, -0.07357205f, -0.09246760f, 0.21091573f, 0.00870395f, 0.10446522f, 0.09697479f, -0.00542537f, 
    -0.08515633f, -0.08857562f, -0.01167682f, -0.16467404f, 0.08329527f, 0.03699097f, -0.01450768f, -0.31245744f, 
    -0.03651336f, -0.02008733f, 0.06548849f, 0.21995117f, 0.02986730f, 0.07363674f, -0.03332680f, 0.04356484f, 
    0.06399685f, 0.11804551f, -0.02290769f, -0.00348405f, -0.02924132f, 0.00124269f, -0.00975680f, 0.08526137f, 
    0.00736165f, 0.08782604f, -0.00787754f, -0.03049324f, -0.12356932f, 0.03779785f, -0.06553657f, -0.35573837f, 
    0.06844808f, 0.05938955f, -0.12249582f, 0.17495628f, -0.00500589f, 0.02346241f, 0.05969621f, 0.02497948f, 
    0.02404314f, 0.01027361f, -0.10172702f, -0.03410129f, 0.06077631f, -0.03500340f, 0.09791891f, -0.04381745f, 
    0.07241496f, 0.06786995f, -0.00473389f, -0.14975211f, 0.00971503f, 0.00620964f, 0.16143753f, 0.06904250f, 
    0.03821646f, 0.05354010f, 0.09138931f, -0.03247648f, -0.07336156f, -0.04624585f, -0.01011448f, -0.02179318f, 
    -0.01390469f, 0.14776154f, 0.11445596f, 0.00325156f, 0.05696237f, -0.03330904f, 0.04977414f, -0.00225637f, 
    -0.09357436f, -0.09457585f, 0.02427806f, -0.10676532f, -0.10484448f, 0.13497989f, -0.08437563f, -0.01968597f, 
    -0.00140322f, 0.02518151f, -0.01782568f, 0.09977419f, -0.18546650f, 0.05247948f, 0.02474298f, -0.06425013f, 
    -0.47240388f, 0.07295291f, 0.16168144f, 0.11442211f, 0.01455756f, 0.20530070f, -0.01274003f, -0.13742425f, 
    0.02740941f, 0.03465258f, 0.01443978f, 0.02272845f, -0.13309902f, 0.22622830f, 0.12691586f, 0.15748505f, 
    -0.06011182f, -0.04995790f, -0.06776443f, 0.03105315f, 0.05993146f, 0.02492691f, 0.06931452f, 0.05623029f, 
    -0.24997686f, 0.02489204f, -0.06237366f, 0.13715756f, 0.00445044f, -0.13028492f, -0.06396617f, -0.10370731f, 
    0.08918919f, 0.09046146f, -0.03256352f, -0.00167147f, 0.13815767f, 0.13227113f, 0.15328854f, 0.01790311f, 
    -0.05049770f, -0.06713489f, 0.09461103f, 0.11821702f, -0.03866940f, 0.05770935f, 0.04277305f, -0.03670058f, 
    0.13548657f, 0.03120587f, 0.13391165f, 0.01795470f, 0.02889796f, -0.08966684f, -0.00906187f, 0.12289866f, 
    -0.08953375f, -0.11555313f, 0.01072768f, 0.05233563f, 0.19395389f, -0.10099317f, -0.00639964f, 0.19667765f, 
    -0.05070586f, -0.01848987f, -0.07111760f, 0.03553836f, -0.04575780f, 0.01484040f, 0.03894177f, 0.09833901f, 
    0.21968821f, -0.14177385f, 0.03255076f, 0.00866258f, 0.00779989f, 0.01836629f, 0.06477090f, -0.08859107f, 
    0.02851434f, -0.05549409f, 0.07491831f, -0.05159096f, -0.10047568f, -0.07455756f, -0.08125596f, -0.07991659f, 
    -0.00014381f, 0.06117188f, 0.04851437f, 0.01026873f, -0.00477354f, -0.08887146f, 0.00261615f, -0.00968838f, 
    0.36918193f, 0.00544118f, -0.09613204f, 0.24730253f, -0.06196100f, 0.04217551f, 0.00846734f, 0.02627834f, 
    -0.06936567f, 0.02981901f, -0.01121507f, -0.05191869f, -0.10129897f, 0.18904948f, -0.02253092f, -0.02654524f, 
    -0.03321745f, 0.01326175f, -0.01562875f, 0.04295886f, 0.09486932f, 0.01436482f, -0.10483291f, 0.14386389f, 
    -0.02966863f, 0.18311584f, 0.13683590f, -0.18888725f, 0.01777593f, 0.17965585f, -0.07340030f, 0.11047998f, 
    -0.02849655f, 0.05075135f, 0.07015208f, -0.18331088f, 0.02046359f, 0.03270547f, 0.12014793f, 0.16466321f, 
    0.02585393f, 0.00719260f, -0.07324369f, -0.00677513f, -0.00794634f, -0.07885453f, 0.12748061f, 0.08328405f, 
    -0.03505293f, -0.11525881f, -0.16738296f, 0.06003945f, 0.02257332f, 0.09139565f, -0.09233242f, 0.11822505f, 
    -0.00027718f, -0.00565211f, 0.04714828f, 0.06381240f, 0.16978237f, -0.02776417f, -0.00326005f, -0.24302074f, 
    0.09374550f, -0.01545198f, 0.17985398f, 0.09958054f, 0.03172391f, -0.01145190f, 0.00254858f, -0.01468699f, 
    -0.13314518f, 0.03146414f, -0.02709196f, 0.10244682f, 0.09076494f, -0.01490734f, -0.03354120f, 0.03776025f, 
    -0.17435813f, 0.06562100f, -0.15686558f, 0.01794316f, -0.00404884f, 0.09030073f, -0.13805912f, -0.07412670f, 
    0.08669250f, 0.14975941f, -0.22040321f, 0.02282807f, -0.03231484f, 0.01654685f, 0.08083307f, -0.06221820f, 
    0.19019096f, 0.07767558f, 0.05351840f, 0.10314491f, 0.01745986f, 0.04319558f, 0.09022732f, 0.09323458f, 
    -0.00562915f, 0.05521765f, 0.01622502f, 0.07305283f, 0.05865584f, -0.04623143f, -0.03667063f, 0.06352369f, 
    -0.00801560f, 0.05591122f, -0.01160290f, 0.01738323f, 0.13707693f, 0.07101549f, -0.05555019f, -0.09463878f, 
    0.06073029f, -0.05961307f, -0.04516949f, -0.01140804f, 0.11774890f, 0.08523295f, 0.08612502f, -0.02206337f, 
    0.15792546f, 0.04987857f, 0.13351089f, -0.02313894f, -0.24117060f, 0.00849911f, 0.08135412f, -0.07644866f, 
    0.07378635f, 0.26254091f, -0.02743366f, -0.02149890f, -0.05495860f, -0.14172737f, -0.05016676f, -0.04624829f, 
    -0.01512902f, 0.03744655f, 0.09073856f, 0.21977851f, 0.06419005f, 0.00021730f, -0.03924396f, 0.01233789f, 
    0.00456653f, -0.04583912f, -0.00681544f, 0.09683587f, 0.05773178f, 0.17102377f, -0.09397253f, -0.04197753f, 
    -0.03735055f, -0.01089650f, -0.04553328f, -0.05771835f, -0.01729105f, 0.02633784f, -0.11135983f, -0.01921287f, 
    -0.01920068f, 0.12713264f, -0.17386518f, -0.13963594f, 0.00510942f, 0.02299252f, -0.13416868f, 0.08111504f, 
    -0.02651064f, -0.05242352f, -0.00245841f, -0.07995243f, 0.09211190f, -0.04889882f, 0.13078520f, 0.11051615f, 
    -0.00804270f, 0.02616855f, -0.02996877f, -0.02799305f, 0.03131592f, -0.01887859f, -0.07672741f, 0.00500331f, 
    -0.02925837f, 0.06084844f, -0.04216563f, -0.05858464f, -0.05652362f, 0.00780120f, -0.00853802f, 0.00136797f, 
    0.01161800f, 0.02886539f, -0.03871262f, 0.01697268f, -0.07035141f, -0.13064772f, 0.06538069f, -0.06136366f, 
    0.00582659f, 0.11002471f, 0.05398425f, -0.16278081f, -0.05567474f, 0.09488041f, -0.01785129f, 0.00604810f, 
    0.56641400f, -0.04379949f, 0.04032336f, -0.10410099f, -0.06799554f, 0.05881892f, 0.04512590f, 0.15327318f, 
    -0.09858674f, 0.05242662f, -0.20178835f, -0.13806967f, 0.09226374f, 0.04214772f, -0.06365295f, 0.00178180f, 
    0.05290141f, 0.06855606f, -0.07861385f, -0.02333630f, -0.08522536f, 0.00808659f, -0.05758498f, 0.06492691f, 
    -0.00013932f, 0.15237871f, -0.10148225f, -0.01351559f, 0.02181754f, 0.06538319f, -0.09938990f, 0.08841258f, 
    0.00058815f, 0.09418553f, -0.01683675f, -0.02886309f, 0.13943747f, -0.04047721f, 0.08809928f, -0.12487972f, 
    0.10667282f, -0.08351794f, -0.05224502f, 0.02860416f, -0.00883578f, -0.03053004f, -0.03712473f, 0.03784839f, 
    0.17369542f, 0.01843769f, 0.11034682f, -0.09606617f, -0.06310859f, -0.03352993f, -0.09365740f, -0.03243321f, 
    0.02897601f, 0.04156314f, 0.04966354f, -0.01303125f, 0.17231780f, 0.04843990f, -0.00872386f, -0.05744217f, 
    -0.06948936f, -0.02865274f, 0.01385175f, -0.03912152f, -0.05676221f, 0.15692602f, 0.07409488f, 0.02628044f, 
    0.12162881f, 0.15432632f, 0.01757728f, 0.09940477f, -0.04877524f, -0.00031721f, 0.00673311f, 0.01673704f, 
    -0.01136841f, 0.01825815f, 0.03293974f, 0.00236887f, 0.47616139f, -0.21374957f, 0.13042277f, 0.15918633f, 
    -0.13096808f, 0.00454298f, -0.02750343f, 0.01073161f, 0.10744727f, -0.05139193f, 0.15214908f, 0.06107007f, 
    0.13597821f, 0.31988963f, 0.08764625f, 0.00293378f, -0.05881447f, 0.01652616f, -0.11250404f, -0.03345050f, 
    0.02180085f, -0.03266839f, -0.05772186f, -0.05627194f, 0.40094325f, -0.28283432f, -0.12770917f, -0.06360896f, 
    0.05301563f, 0.08405822f, 0.06220653f, -0.17776337f, 0.09947003f, 0.02569314f, 0.05863761f, 0.04785627f, 
    0.16392531f, -0.00895187f, -0.09634109f, 0.09056189f, 0.01902220f, 0.06508594f, 0.02116470f, -0.01300925f, 
    -0.06675659f, 0.08170829f, 0.01706904f, -0.01464886f, -0.03633291f, 0.11692470f, 0.12229385f, -0.07994843f, 
    -0.07881632f, -0.01704957f, -0.00853696f, -0.05752792f, 0.12532306f, -0.14684132f, -0.04087223f, -0.07122532f, 
    -0.23148912f, -0.03534089f, 0.26928592f, -0.15774451f, -0.09157553f, 0.08593553f, 0.02223615f, -0.06234132f, 
    0.09359241f, -0.17353472f, 0.14622338f, -0.08017825f, -0.10452398f, -0.03573298f, 0.13550812f, -0.18638198f, 
    0.08730569f, 0.06188588f, -0.05567541f, -0.05560701f, 0.03879160f, -0.03312512f, 0.00227456f, 0.05731220f, 
    -0.06210167f, -0.05466852f, -0.02891109f, 0.00029295f, 0.04995279f, 0.03918986f, 0.04523793f, -0.02049949f, 
    0.00383107f, -0.12983689f, 0.12582281f, -0.01845536f, -0.26346350f, -0.01698292f, -0.07513221f, 0.05759779f, 
    -0.08868224f, -0.02337277f, -0.05649184f, -0.07715803f, -0.00767398f, -0.02256291f, -0.07573819f, 0.00011787f, 
    -0.17010398f, 0.08349955f, 0.06079175f, -0.21682161f, 0.16462006f, 0.05583761f, 0.01650632f, 0.05583966f, 
    0.01626077f, -0.01275874f, 0.07536133f, -0.02633755f, -0.16515063f, 0.11492878f, 0.08744477f, -0.14214455f, 
    -0.05829733f, -0.02023213f, -0.11966700f, -0.03688234f, 0.01533622f, -0.37475598f, 0.09964500f, -0.22132865f, 
    0.13173679f, 0.09140623f, 0.05178073f, 0.05702624f, -0.01902536f, -0.03135164f, -0.02636799f, 0.15701491f, 
    0.05827210f, 0.02255869f, 0.02119228f, -0.01963816f, 0.38009530f, -0.04584128f, 0.11784799f, 0.13433167f, 
    -0.07450189f, 0.01823705f, 0.00150821f, 0.02621995f, 0.01396673f, -0.07844643f, -0.11642145f, -0.01678316f, 
    0.01559487f, 0.32049620f, -0.28368622f, -0.10017861f, 0.02062779f, 0.05363855f, -0.03575392f, 0.17807212f, 
    0.00674440f, 0.01795806f, -0.02780609f, -0.09926304f, 0.33402660f, 0.02821548f, 0.15820371f, -0.05889668f, 
    -0.02645875f, 0.07965800f, -0.07103290f, 0.02184217f, -0.07642502f, -0.13447538f, 0.04496438f, -0.17635661f, 
    0.00784778f, 0.09621944f, 0.07085287f, -0.00814315f, -0.03124800f, -0.06468944f, -0.09700865f, -0.06966731f, 
    -0.00602449f, -0.04037604f, -0.01575000f, 0.05111785f, -0.10350737f, 0.15184225f, 0.02286148f, -0.06530760f, 
    -0.00485989f, -0.05210258f, -0.16867629f, -0.04951176f, -0.02492839f, 0.06435453f, 0.06653912f, -0.00392184f, 
    0.03043156f, 0.11524046f, 0.01664318f, 0.02964984f, -0.02118564f, 0.18818644f, -0.03358970f, 0.10559018f, 
    -0.04469774f, 0.02273757f, 0.09172792f, 0.01290163f, 0.13337614f, 0.04365226f, 0.04682072f, -0.02036331f, 
    0.05648734f, -0.04687873f, 0.06459686f, -0.00605561f, -0.00347310f, 0.03121898f, 0.00355769f, 0.11255244f, 
    0.17931984f, -0.22533880f, 0.08235735f, -0.06350353f, -0.01956268f, 0.01119180f, -0.06369969f, -0.01350557f, 
    0.03558821f, 0.03776181f, 0.01349488f, -0.06303430f, -0.46307656f, 0.13508716f, 0.07885937f, -0.19622003f, 
    0.01825021f, 0.00540063f, -0.20036557f, -0.07857215f, 0.04583896f, -0.09493936f, 0.03624954f, 0.06623574f, 
    0.03898851f, 0.08994937f, -0.09231516f, -0.00762807f, 0.08771113f, 0.08366425f, -0.09331977f, 0.15316154f, 
    -0.06789079f, -0.08388814f, 0.02846617f, 0.05092778f, 0.02486707f, -0.03935084f, 0.13835058f, 0.10514314f, 
    0.03313361f, 0.11240655f, -0.00926425f, 0.06681117f, 0.01612798f, 0.12824556f, -0.10883540f, -0.01436679f, 
    -0.02730864f, 0.01719876f, -0.00407319f, -0.00621410f, 0.02251113f, -0.02523656f, -0.02296887f, -0.02950021f, 
    -0.01961775f, 0.00730763f, -0.02872083f, 0.00143088f, -0.00637482f, 0.01967289f, -0.03960703f, 0.01336780f, 
    0.01486252f, -0.01469185f, 0.02478187f, -0.03397948f, -0.00656029f, -0.03428175f, -0.02088960f, 0.02122146f, 
    0.00546829f, -0.00497173f, -0.02655474f, -0.04024080f, -0.00246341f, -0.03870135f, 0.02692808f, 0.01421676f, 
    0.00362190f, 0.02677336f, -0.01951745f, 0.01621792f, 0.00968048f, -0.00949268f, 0.00917751f, -0.03549465f, 
    -0.00094621f, -0.01537072f, -0.02977188f, -0.00299462f, -0.00320264f, -0.02812870f, 0.00460238f, -0.04128629f, 
    -0.00437373f, 0.02274489f, -0.02161245f, -0.04096860f, 0.02398346f, -0.01434470f, -0.00473823f, -0.01149632f, 
    -0.04002568f, 0.02358150f, -0.00630631f, -0.04210136f, -0.03165877f, -0.02280478f, 0.01987747f, 0.00729303f, 
    0.01772370f, -0.03475915f, -0.01820951f, 0.00354262f, -0.01296831f, 0.01471735f, 0.01181849f, -0.02895650f, 
    -0.03725002f, 0.01449218f, -0.04152616f, 0.00892930f, -0.00568559f, -0.00893129f, -0.01517465f, 0.01092782f, 
    0.01194512f, -0.02211633f, 0.00745984f, -0.00396270f, -0.01123701f, 0.02743813f, -0.01934490f, -0.00258688f, 
    0.00147404f, 0.01357138f, -0.00509005f, -0.00205179f, -0.01974439f, 0.02719162f, 0.02412697f, -0.00300313f, 
    0.00517243f, 0.00422871f, 0.00829446f, 0.00100840f, -0.00227043f, 0.02385761f, -0.04041629f, -0.02118701f, 
    -0.02134930f, -0.01264704f, -0.03452576f, 0.02462911f, -0.00902097f, 0.02351640f, 0.02177174f, -0.03170392f, 
    0.02391475f, -0.01675244f, -0.02029451f, 0.02128791f, 0.02568137f, -0.01761997f, -0.01042076f, -0.03647472f, 
    -0.02985067f, -0.01461434f, 0.02210718f, -0.01739912f, -0.01689574f, 0.01595001f, 0.01173734f, 0.00693558f, 
    -0.00668706f, 0.00516214f, 0.00131502f, -0.00918400f, 0.00671907f, 0.03043940f, 0.02120415f, 0.01804489f, 
    0.02509252f, -0.01282417f, 0.00233604f, -0.02420378f, -0.02085303f, -0.00408870f, -0.04171903f, 0.01031390f, 
    -0.04073752f, 0.02699368f, 0.00108329f, -0.00682148f, 0.00073532f, -0.02115187f, -0.00577174f, -0.00539979f, 
    -0.00926204f, 0.01958210f, -0.02731514f, 0.02715340f, -0.03349664f, -0.02071040f, -0.01788969f, -0.00916864f, 
    -0.04601984f, -0.04450748f, 0.02111986f, -0.00870270f, -0.04507828f, 0.01378111f, -0.02745081f, -0.02023784f, 
    -0.00388357f, 0.00852044f, 0.00875057f, -0.00262658f, -0.03203798f, 0.00252390f, 0.02333519f, -0.00769122f, 
    -0.03123861f, -0.04545133f, -0.03954891f, 0.02500212f, 0.02335443f, -0.02666838f, 0.00799773f, -0.02993134f, 
    -0.02778875f, 0.02071737f, -0.03441736f, 0.01874117f, 0.00937185f, 0.00014212f, -0.02374842f, -0.00485200f, 
    -0.03142745f, -0.04099704f, -0.01348965f, -0.00228121f, 0.00567396f, -0.01833655f, -0.04450000f, 0.01333662f, 
    -0.02855123f, -0.02540898f, 0.01670860f, -0.00722522f, 0.00091860f, -0.00184945f, -0.03093565f, -0.02318558f, 
    -0.00136770f, -0.01909143f, -0.01330678f, 0.02059291f, 0.02354512f, 0.01065379f, 0.00685067f, 0.00413333f, 
    -0.01810244f, -0.00191177f, 0.01885899f, -0.02900970f, -0.02881014f, 0.01110414f, -0.00545759f, 0.01755105f, 
    -0.01313719f, 0.00561897f, -0.01872372f, 0.01366710f, -0.01168189f, -0.00758478f, -0.02251871f, -0.02042111f, 
    -0.02182910f, 0.02608134f, -0.01262606f, -0.01905627f, -0.01313656f, -0.02619172f, -0.01562469f, -0.00480336f, 
    -0.04219898f, -0.03606936f, 0.01218023f, 0.00957544f, 0.02481603f, 0.00568990f, -0.04128786f, 0.00766376f, 
    -0.04121809f, -0.03959703f, 0.00022230f, -0.02656307f, 0.01461960f, -0.04010488f, -0.02750726f, -0.00919051f, 
    0.02435253f, 0.02588832f, 0.00151608f, -0.01740312f, 0.01509718f, -0.01560943f, -0.02715656f, -0.04181042f, 
    -0.00742015f, 0.02095102f, -0.01827562f, 0.01087254f, -0.02677750f, -0.04394132f, 0.02681416f, -0.01022802f, 
    0.00160427f, -0.03287870f, -0.02625489f, 0.02388896f, -0.03112879f, -0.01662090f, 0.01215137f, -0.02574707f, 
    -0.03247151f, 0.00929290f, -0.02454827f, -0.00527430f, -0.02823309f, -0.01216415f, -0.00765513f, -0.02149530f, 
    -0.04364860f, -0.03893073f, -0.04247044f, 0.00297597f, -0.00014483f, -0.00791675f, 0.00051423f, -0.04532011f, 
    -0.01665113f, -0.00959903f, 0.00839063f, 0.01428146f, 0.01209667f, 0.00754958f, -0.03479470f, 0.02378011f, 
    -0.03710299f, -0.00351882f, 0.02033802f, 0.02008523f, -0.00144359f, -0.03986564f, -0.02340630f, -0.03459824f, 
    0.02959885f, -0.01155671f, -0.00652275f, -0.02145286f, -0.02054024f, -0.01674599f, -0.00719591f, -0.02318848f, 
    -0.02474964f, -0.01666957f, 0.01675623f, 0.01583616f, 0.00175209f, 0.00394415f, 0.02459805f, 0.02354125f, 
    -0.01913832f, -0.01075093f, -0.01945245f, -0.02862235f, -0.03394004f, -0.00830359f, -0.02598539f, -0.01465014f, 
    -0.02568966f, -0.01363859f, 0.01588195f, -0.01348922f, 0.00048700f, 0.00484240f, 0.02258229f, -0.00609652f, 
    0.02226564f, -0.03685462f, -0.00355647f, -0.02947667f, -0.01932290f, 0.01675578f, -0.03136896f, 0.00026164f, 
    0.00042345f, -0.00918310f, 0.00656370f, -0.02408047f, -0.03412396f, -0.02914695f, 0.00725657f, -0.03070888f, 
    0.01283902f, -0.02489291f, -0.04459166f, -0.04163499f, 0.02106209f, -0.03388001f, -0.00054587f, -0.01455593f, 
    0.02565463f, -0.01128369f, -0.01136220f, -0.00942869f, 0.01121571f, -0.01984185f, -0.01438796f, 0.01959164f, 
    -0.04273761f, -0.00596737f, 0.03011294f, 0.01952125f, -0.04603691f, -0.02582579f, -0.01705089f, -0.01144395f, 
    -0.03527158f, -0.01520348f, -0.00371763f, 0.01614473f, 0.00514530f, -0.00855473f, -0.04549422f, -0.02654362f, 
    0.01987082f, -0.01296558f, 0.00327916f, -0.01869232f, -0.02767428f, -0.03758056f, -0.01876039f, 0.01241850f, 
    -0.02121082f, 0.01410305f, 0.00335847f, -0.02071329f, 0.01879528f, -0.03154312f, -0.01043131f, -0.01658830f, 
    0.02940610f, -0.01838965f, 0.00333964f, -0.01281930f, -0.04317199f, -0.04478474f, -0.04530488f, -0.04071365f, 
    0.00665133f, -0.01710918f, -0.03878004f, -0.00995585f, -0.00009691f, 0.01955721f, -0.04037644f, 0.02951975f, 
    -0.03742405f, -0.04268271f, -0.04065841f, 0.02505155f, -0.01126807f, -0.01406956f, 0.00495075f, -0.03372137f, 
    -0.04170363f, 0.00424101f, -0.03090460f, -0.03961303f, -0.01207608f, -0.01122411f, -0.02986004f, -0.02796145f, 
    -0.04116392f, -0.01686183f, -0.02151681f, 0.02581673f, -0.00714671f, -0.02127609f, -0.04280482f, 0.01441570f, 
    0.02277076f, 0.00898292f, -0.03093901f, -0.02635391f, 0.01733673f, -0.00072463f, 0.01871763f, 0.02870447f, 
    -0.02819952f, 0.00678222f, 0.00785869f, 0.02456875f, -0.01036037f, 0.02728929f, 0.02352643f, 0.01956094f, 
    0.02485579f, -0.01619206f, 0.01514325f, 0.02216363f, -0.01254699f, 0.00512265f, -0.04404128f, -0.03931346f, 
    -0.03339611f, 0.02662384f, -0.00763571f, -0.00955918f, -0.00032227f, -0.01625800f, 0.01901618f, 0.01707286f, 
    0.00444335f, 0.02567174f, -0.03030651f, 0.02442051f, -0.00060238f, 0.01783822f, -0.00921496f, 0.02140850f, 
    -0.02904127f, -0.02707604f, -0.03241103f, 0.02581874f, -0.02587238f, -0.01406356f, 0.01981189f, -0.00880140f, 
    -0.02967150f, 0.02061828f, -0.03394904f, 0.00702899f, 0.01002225f, 0.00312515f, -0.03602470f, -0.02528645f, 
    -0.04126422f, -0.04028085f, 0.01366448f, -0.03919294f, 0.02424381f, 0.02706339f, 0.00612179f, -0.03541334f, 
    -0.01262007f, -0.02425421f, -0.03121841f, 0.02178295f, -0.02613696f, 0.02486227f, -0.00673680f, -0.00886854f, 
    -0.01193372f, -0.03547951f, 0.01507014f, 0.00921783f, 0.00747397f, 0.00723086f, 0.00440797f, 0.01573645f, 
    -0.01030237f, 0.00841544f, 0.02447462f, -0.03361486f, -0.02004784f, 0.01962200f, 0.01075393f, -0.00111164f, 
    -0.01105917f, -0.04514708f, 0.00375931f, -0.01520337f, 0.02466442f, -0.00054479f, -0.03227273f, -0.03884806f, 
    0.01206327f, 0.03265873f, -0.01032578f, -0.03283115f, -0.03718414f, -0.04313622f, 0.01864088f, -0.03137381f, 
    -0.02947152f, 0.00763083f, 0.02403499f, -0.00539263f, 0.00857167f, 0.00891727f, -0.03569718f, -0.01514266f, 
    -0.02181279f, -0.02731800f, -0.00787976f, 0.02302461f, -0.01732043f, -0.01422054f, 0.00248917f, -0.02662707f, 
    0.00138915f, 0.01195815f, -0.02276820f, 0.00149569f, 0.02762113f, -0.02504786f, -0.04547010f, -0.03456839f, 
    0.01957048f, 0.02431978f, 0.02175536f, 0.00946205f, 0.02413299f, -0.02829896f, -0.01622584f, -0.02986039f, 
    0.00894457f, -0.02845533f, 0.02374488f, 0.00912050f, -0.03509177f, -0.00248829f, 0.01062185f, -0.00018319f, 
    -0.01046461f, 0.01480473f, 0.00851738f, -0.02623914f, -0.00310999f, -0.02799401f, 0.00480969f, 0.00737295f, 
    0.02127369f, 0.01588576f, 0.02252273f, 0.02474225f, -0.02077721f, 0.02339641f, 0.03109848f, -0.00621800f, 
    -0.02719704f, -0.00112776f, 0.01265855f, -0.00807005f, 0.01039842f, 0.00665184f, -0.01823892f, 0.02007954f, 
    -0.02499858f, -0.03072590f, 0.02415704f, 0.02618624f, -0.03251134f, -0.03162328f, -0.04236888f, -0.00245407f, 
    0.00164372f, 0.01225391f, 0.00882188f, 0.02221552f, 0.02337760f, -0.04048008f, -0.01875023f, -0.01471362f, 
    -0.03791588f, 0.01512875f, 0.01237624f, 0.00334513f, -0.01346675f, 0.02592099f, -0.00828239f, 0.01491809f, 
    -0.01061364f, 0.00955215f, -0.00600071f, -0.03711275f, -0.02860601f, -0.03181962f, -0.03073737f, 0.00389720f, 
    -0.02794367f, 0.00099116f, -0.02742735f, -0.04062507f, -0.02507183f, -0.02232601f, 0.00392607f, -0.03172286f, 
    -0.03984553f, 0.02520394f, 0.00122371f, -0.00309184f, -0.00659122f, -0.02378000f, 0.02938537f, -0.00376772f, 
    -0.01029067f, -0.01179477f, 0.02093348f, -0.01753985f, -0.00855695f, 0.01411341f, -0.04220453f, -0.02705736f, 
    0.02448890f, -0.04052472f, 0.02207440f, -0.03942570f, 0.01770028f, -0.01869750f, -0.01129274f, 0.00717234f, 
    0.00221361f, -0.04410491f, -0.01563749f, 0.02190387f, 0.00820327f, -0.02415455f, 0.00746953f, 0.02450701f, 
    0.02362005f, 0.01111397f, -0.02552381f, -0.01603994f, 0.01253898f, 0.02407528f, 0.02042637f, -0.03743949f, 
    -0.02981998f, -0.01076137f, -0.04509772f, -0.02148120f, -0.01496355f, -0.01515352f, -0.01471570f, -0.03414237f, 
    0.02540998f, -0.03176668f, 0.00379003f, 0.01739155f, -0.02915904f, -0.03170167f, 0.02227717f, 0.00391824f, 
    0.01147796f, -0.00183143f, 0.01973413f, 0.01917909f, -0.01101611f, 0.01038322f, 0.00983267f, 0.00196098f, 
    -0.01671520f, 0.02091099f, 0.01932745f, 0.01968400f, -0.04183039f, -0.03847884f, -0.01135797f, -0.04119750f, 
    -0.04410019f, -0.02011595f, 0.00975969f, -0.01616992f, 0.01731936f, -0.02142884f, -0.00447003f, 0.00684074f, 
    0.02115017f, -0.03373390f, -0.00962690f, 0.00572970f, -0.03886229f, -0.04102353f, 0.00086789f, 0.01237309f, 
    0.02017657f, -0.02292363f, -0.02358310f, 0.00152785f, -0.03320233f, 0.00513062f, -0.01454763f, -0.01556583f, 
    -0.04006499f, -0.00011946f, -0.02700251f, -0.00339317f, 0.00049295f, 0.02502399f, -0.01510628f, -0.03184228f, 
    0.02077279f, -0.00229885f, 0.01172304f, -0.00839723f, -0.04199185f, -0.01009553f, -0.00807293f, -0.01900450f, 
    0.02240308f, -0.01780346f, -0.02510825f, -0.01199071f, 0.00415503f, -0.00960960f, 0.00281316f, -0.00204520f, 
    -0.00996218f, -0.02175354f, 0.00964300f, 0.01592185f, 0.00221402f, 0.01228951f, -0.04240911f, 0.03367871f, 
    0.00714313f, -0.02821235f, -0.03495279f, -0.02782654f, -0.00181876f, -0.02562257f, -0.00883765f, -0.03539266f, 
    -0.00109617f, -0.02196212f, 0.00466944f, -0.01702914f, 0.01852182f, -0.02753865f, 0.00315455f, 0.01721874f, 
    0.02817020f, -0.01413092f, 0.01124488f, -0.00367749f, -0.00755434f, 0.02449868f, -0.02784263f, -0.00332248f, 
    -0.02478445f, 0.01178953f, 0.00674857f, -0.02381817f, -0.02303409f, -0.03005618f, -0.00898942f, -0.00788944f, 
    0.02707122f, -0.01995487f, -0.01812436f, 0.00995497f, -0.00352539f, -0.02008164f, 0.00317372f, 0.00513152f, 
    0.02559062f, 0.02449262f, 0.01696355f, -0.00235854f, -0.00490338f, 0.02455795f, 0.00591389f, 0.01244402f, 
    -0.03743799f, 0.02138450f, -0.01804399f, -0.00157111f, 0.00956483f, -0.03728702f, 0.01044275f, -0.01950767f, 
    -0.02283321f, -0.03098930f, -0.01384470f, -0.04296148f, -0.02094943f, 0.02396233f, -0.01023626f, 0.02391248f, 
    0.00546918f, -0.01757001f, 0.02220753f, -0.04309892f, 0.01802105f, -0.00954695f, -0.03243109f, -0.02583176f, 
    0.01703722f, 0.01145986f, -0.00915476f, 0.00524920f, 0.02303898f, -0.04031228f, -0.01961225f, -0.03799869f, 
    -0.02438843f, 0.01152161f, -0.00562377f, -0.02974243f, -0.04248693f, -0.02472050f, -0.01345913f, -0.03158059f, 
    -0.00292906f, 0.01582004f, -0.01691056f, -0.03055348f, 0.02138864f, 0.01244614f, -0.00706553f, 0.02339261f, 
    -0.04096186f, -0.01288923f, -0.02105377f, 0.01765363f, -0.01938071f, -0.02863695f, -0.03472067f, 0.00357978f, 
    0.00976985f, 0.01375992f, 0.01653225f, 0.01807752f, -0.02948804f, 0.02070476f, -0.02263033f, -0.01558945f, 
    -0.00015456f, -0.03039574f, -0.01770313f, 0.02455439f, 0.00554631f, 0.02380653f, 0.01002607f, -0.01913972f, 
    0.00032084f, -0.02936838f, -0.01506494f, 0.02128854f, -0.02468448f, 0.02993351f, 0.02305094f, -0.00395154f, 
    0.00941021f, -0.02843316f, 0.02001486f, -0.03182391f, -0.03254930f, -0.02750171f, -0.01799959f, -0.02999804f, 
    -0.01464771f, -0.03189196f, 0.02070701f, -0.03676937f, -0.02480502f, -0.00127488f, 0.02009384f, 0.01717335f, 
    -0.01920819f, -0.02993059f, 0.03875992f, 0.01989264f, 0.03854054f, -0.01860734f, -0.03110760f, -0.00583202f, 
    0.01155106f, -0.01038007f, -0.00614194f, 0.00897846f, 0.02235563f, -0.01800087f, -0.04019295f, -0.02560253f, 
    0.01372654f, -0.02868118f, -0.02983702f, -0.02865249f, -0.04273639f, 0.00158257f, 0.01237924f, -0.00530418f, 
    0.00970291f, 0.01603819f, 0.02203855f, -0.00414083f, 0.01490539f, 0.02422100f, -0.04295703f, 0.01918131f, 
    0.01787379f, -0.04296126f, 0.02592140f, -0.03419049f, 0.01130054f, 0.01109773f, 0.01865342f, 0.01227511f, 
    -0.01162951f, 0.01772898f, -0.03318113f, 0.02152674f, -0.02921331f, -0.00543289f, -0.03152989f, 0.01495829f, 
    0.00151315f, 0.02327437f, -0.02753150f, -0.01952057f, 0.00694398f, 0.03274061f, 0.00294136f, 0.01636564f, 
    0.00426621f, -0.01389133f, 0.01696074f, -0.02544867f, -0.00546629f, -0.02030263f, -0.01537090f, 0.00478419f, 
    0.02816646f, -0.02501303f, 0.03239657f, -0.04362843f, 0.01023764f, 0.00294758f, -0.01426304f, 0.00653736f, 
    -0.00680988f, 0.03151734f, -0.01461143f, 0.02979627f, -0.02706887f, 0.00501660f, -0.01099519f, 0.02860011f, 
    0.00060410f, -0.02318848f, 0.02819815f, -0.00900694f, -0.02874589f, -0.02181055f, -0.00405083f, 0.00401636f, 
    0.03336939f, 0.03647502f, 0.00426673f, -0.00868753f, 0.01646989f, 0.02945996f, -0.03980818f, -0.00953104f, 
    0.02556255f, 0.01700138f, -0.01466910f, 0.02679575f, -0.02114331f, 0.01026175f, 0.00203505f, 0.01933385f, 
    -0.03882566f, -0.00451283f, 0.00693686f, -0.00935935f, 0.01714822f, -0.03856840f, -0.00772838f, -0.01008243f, 
    0.01264564f, 0.00041707f, -0.00431669f, 0.01926539f, -0.01727788f, 0.02240483f, 0.00878162f, 0.02820270f, 
    -0.02023590f, 0.00929300f, -0.01816061f, -0.00678690f, 0.02069896f, 0.00236981f, 0.00555851f, -0.00507072f, 
    -0.01651203f, -0.00268718f, -0.02805587f, 0.01770228f, -0.04056196f, -0.02747679f, 0.02123226f, 0.03012861f, 
    -0.03069513f, -0.01038000f, -0.03002703f, 0.00683260f, 0.00061107f, -0.00588227f, 0.02212750f, -0.01111269f, 
    0.01675148f, -0.01810307f, 0.00912978f, -0.02828654f, -0.00380166f, -0.03820387f, -0.00625965f, -0.02175520f, 
    0.00189030f, -0.00098483f, -0.02487169f, 0.01110257f, -0.04193580f, -0.00561685f, 0.02534810f, -0.02478775f, 
    -0.02697603f, 0.01099338f, 0.00439792f, 0.00917343f, 0.02295590f, -0.04147854f, 0.00594405f, 0.01900540f, 
    0.00140902f, -0.02859284f, 0.00738451f, -0.00026465f, -0.01038451f, 0.01122331f, 0.00015373f, -0.00925949f, 
    0.01479645f, 0.01719574f, -0.02787340f, -0.02400709f, 0.00657856f, 0.02352523f, 0.00639104f, -0.03152768f, 
    -0.03727192f, 0.02665186f, -0.01964658f, -0.00665781f, -0.02100261f, -0.02593721f, -0.00328325f, 0.01922368f, 
    -0.00652012f, 0.01753297f, 0.01974404f, -0.02893109f, -0.01663185f, -0.00124552f, 0.01971053f, -0.00502871f, 
    -0.02765489f, -0.01784834f, -0.02104082f, -0.03764877f, -0.02703713f, -0.03727720f, -0.00424348f, 0.02324087f, 
    0.01326636f, -0.03119295f, -0.02841505f, 0.01259933f, -0.01213632f, 0.01026546f, -0.02374136f, -0.04238613f, 
    0.00476894f, -0.03215369f, 0.00119917f, -0.03169938f, -0.00787421f, 0.02924222f, 0.02288438f, -0.02536940f, 
    -0.01332937f, -0.02599899f, -0.00915104f, -0.00650769f, -0.01932383f, -0.03797773f, 0.03786621f, -0.04369994f, 
    0.02192814f, -0.00596374f, 0.02294493f, -0.00444222f, 0.02638916f, -0.02084263f, 0.01738320f, 0.02331004f, 
    -0.02586722f, -0.03576604f, -0.01032584f, 0.00252032f, -0.02689326f, -0.03325992f, -0.02555251f, -0.02265711f, 
    -0.00012526f, -0.01557454f, -0.03146138f, -0.01836228f, -0.01645606f, 0.02111855f, -0.01554546f, 0.01527561f, 
    0.00097750f, 0.00203255f, -0.03003935f, -0.04014201f, 0.02890170f, 0.02014378f, -0.01905358f, -0.03013727f, 
    0.00451637f, -0.04228874f, -0.01938620f, 0.02116494f, -0.04001163f, -0.01328961f, -0.02522777f, -0.01788540f, 
    -0.02601756f, 0.00415380f, -0.03403348f, 0.00169330f, -0.04021635f, 0.01355485f, 0.01717539f, -0.00015049f, 
    0.01084342f, -0.01457069f, -0.00527402f, 0.00854145f, -0.01374971f, 0.02654886f, -0.01957423f, 0.02019637f, 
    0.02838909f, -0.04129101f, 0.00755278f, 0.02761034f, 0.00826854f, 0.00165017f, 0.01790847f, -0.01950053f, 
    0.02815140f, -0.03867164f, -0.01229803f, -0.01735794f, -0.03082657f, -0.00985035f, 0.02662914f, -0.03395576f, 
    0.01597268f, 0.02245117f, -0.01950854f, -0.02608013f, 0.00795490f, -0.01565913f, -0.02198000f, -0.01460489f, 
    -0.01121898f, 0.00546485f, -0.00657461f, -0.00772406f, -0.03603261f, 0.00473435f, -0.02983894f, -0.02974896f, 
    0.02462535f, 0.03286809f, -0.00198933f, 0.00202379f, 0.02029884f, -0.00562166f, -0.00716173f, -0.03138939f, 
    0.03779611f, -0.00802284f, 0.02599288f, -0.00563720f, -0.03215053f, -0.00479135f, -0.00834480f, -0.03344825f, 
    0.00851416f, 0.02117162f, -0.01818054f, 0.00858123f, 0.00915140f, -0.02128249f, 0.02528615f, 0.01308511f, 
    -0.00693052f, -0.02826224f, -0.01581513f, 0.03200717f, -0.00202629f, -0.02538859f, -0.03748098f, -0.02729178f, 
    0.03216017f, 0.01891193f, 0.00710951f, 0.02590641f, 0.02319410f, -0.00212080f, -0.02177483f, -0.00613742f, 
    -0.03822835f, 0.02563996f, 0.00309626f, -0.01390616f, 0.01482969f, 0.00407260f, -0.00498205f, -0.01784916f, 
    0.01281626f, -0.00823696f, 0.02162384f, -0.01233071f, 0.02911022f, -0.00500588f, 0.01314232f, 0.02913586f, 
    0.01502157f, 0.01315971f, 0.01841180f, 0.03187043f, 0.01775655f, -0.01670760f, 0.02747937f, -0.01581127f, 
    -0.02623541f, -0.01997588f, 0.03668064f, -0.01842553f, -0.02370473f, 0.01423412f, 0.02367872f, 0.00117380f, 
    -0.02964521f, -0.01564285f, -0.03990513f, 0.00126691f, -0.03577274f, -0.02555077f, 0.00305738f, -0.00255931f, 
    -0.01369716f, 0.00286960f, 0.01827574f, 0.02267888f, -0.03019095f, -0.00160470f, -0.02456681f, 0.01917792f, 
    0.01107970f, -0.03889599f, 0.01606931f, 0.03435450f, -0.01053340f, -0.01073666f, -0.02870384f, 0.03363970f, 
    0.01438244f, 0.00038375f, 0.01388696f, 0.01556882f, -0.00213648f, 0.03214343f, -0.01595770f, 0.00337364f, 
    0.03157583f, -0.01733153f, -0.04028434f, 0.00549581f, -0.00076897f, -0.01500459f, 0.00793448f, 0.02547548f, 
    0.02214827f, 0.00462552f, 0.01076749f, -0.02166561f, -0.02511580f, 0.01285314f, -0.00062757f, 0.02793789f, 
    -0.04403597f, 0.00739415f, -0.03835507f, -0.01863933f, -0.04311431f, 0.00078419f, 0.02448444f, 0.03170965f, 
    -0.02864364f, -0.03763796f, -0.01319594f, 0.02268999f, 0.02685371f, -0.00484540f, 0.00901632f, 0.02471965f, 
    0.01397994f, 0.02253429f, 0.02584723f, -0.03276860f, 0.02280408f, 0.01307051f, -0.03678748f, -0.01134535f, 
    0.01596839f, -0.03107523f, -0.03167178f, -0.03972221f, -0.00419769f, -0.02441451f, 0.02700031f, -0.01839059f, 
    0.00852443f, -0.03455960f, -0.00344036f, -0.00765640f, -0.02918600f, -0.02467406f, -0.02694963f, 0.00359083f, 
    -0.02334359f, -0.04261469f, -0.02556878f, -0.01361393f, -0.00628264f, 0.00744556f, 0.00459297f, -0.02975231f, 
    -0.03639113f, 0.01124122f, 0.00761049f, -0.01561219f, -0.01702148f, -0.00799910f, -0.02783090f, 0.02358956f, 
    -0.04288982f, -0.00677281f, -0.04363415f, -0.00910467f, -0.03846698f, 0.01911495f, 0.01431516f, -0.03048071f, 
    0.01978152f, 0.00343637f, 0.00114927f, -0.02032671f, 0.00229904f, 0.03382513f, 0.00228060f, 0.02078780f, 
    0.03229742f, 0.03153574f, 0.01033934f, -0.00377419f, 0.01562114f, -0.02875064f, -0.03054726f, -0.01353872f, 
    0.00659747f, -0.01701257f, -0.00952526f, -0.03270838f, -0.03121533f, -0.02461639f, 0.02755819f, -0.00348869f, 
    0.02889434f, 0.01304549f, 0.00224959f, -0.02029651f, -0.02610108f, 0.01359829f, -0.00813941f, -0.03740361f, 
    0.02887848f, 0.00804834f, -0.03249240f, -0.01936682f, -0.01163551f, -0.01758163f, -0.01283388f, -0.01183357f, 
    -0.02484353f, -0.02563602f, 0.02726747f, -0.00570386f, -0.03411624f, -0.01803779f, -0.02208880f, -0.03937291f, 
    0.00377012f, 0.02516432f, -0.02624204f, 0.03879231f, -0.01090715f, -0.02211155f, -0.01375665f, 0.01950685f, 
    -0.04314426f, 0.00031268f, -0.01256481f, -0.00670112f, -0.03796559f, -0.00673348f, 0.00793732f, -0.01531713f, 
    -0.02684903f, -0.00670814f, -0.02541796f, -0.02193032f, -0.03866791f, -0.01409982f, -0.00143812f, -0.00139022f, 
    -0.04047995f, -0.03586707f, -0.03254930f, -0.00849000f, 0.00772821f, -0.00325308f, -0.03602785f, -0.03996696f, 
    0.00429570f, -0.00458200f, 0.01847059f, -0.03232447f, -0.03455893f, -0.02872655f, 0.01331022f, 0.01185969f, 
    0.01035789f, 0.02473322f, -0.00836588f, 0.01910806f, -0.02086844f, -0.01081504f, 0.02169936f, 0.01663256f, 
    -0.04016000f, -0.02157107f, -0.01044920f, 0.02457932f, -0.01446615f, -0.02479571f, 0.02620474f, -0.01942690f, 
    -0.03975277f, -0.00963909f, -0.00679919f, -0.01946891f, -0.01160660f, 0.01019947f, -0.00693282f, 0.02019316f, 
    -0.02456617f, -0.00997180f, -0.01415053f, -0.03223692f, -0.00501463f, 0.02373550f, 0.02352913f, -0.00692902f, 
    -0.01674725f, -0.02695260f, -0.00505824f, -0.01032044f, -0.00201633f, -0.02531056f, -0.02927873f, 0.00551491f, 
    0.02132436f, -0.00689305f, -0.02321159f, 0.04060286f, 0.00325485f, 0.02031408f, 0.02307739f, 0.00766685f, 
    0.01410442f, -0.02477293f, -0.02146201f, 0.01253333f, -0.01614825f, 0.02465397f, -0.03722469f, -0.02423737f, 
    -0.00301464f, 0.02437408f, -0.00207222f, 0.03844035f, -0.02796943f, -0.03567614f, 0.01170312f, -0.02985164f, 
    -0.03191016f, -0.03787974f, 0.01514396f, -0.00211832f, 0.00056222f, -0.01666201f, 0.01347074f, -0.02331328f, 
    0.02447104f, -0.00175432f, -0.04143666f, 0.01624650f, 0.02348298f, 0.00066770f, -0.02712202f, 0.02500013f, 
    -0.02111645f, -0.02206277f, 0.02434148f, 0.00401094f, 0.02838829f, 0.02114209f, -0.00734010f, -0.02359550f, 
    -0.03023173f, 0.02301764f, 0.01697733f, 0.01851827f, -0.01559574f, -0.02736102f, -0.00410663f, 0.00628466f, 
    0.00600885f, -0.01887905f, 0.01504396f, -0.01442717f, 0.02405690f, 0.02824392f, -0.01480258f, -0.01071638f, 
    -0.00162197f, -0.00173467f, 0.00194194f, -0.00918600f, -0.01552496f, -0.02123159f, 0.02671446f, -0.01570803f, 
    0.01487017f, -0.03009786f, 0.00243144f, -0.00356701f, -0.01392527f, -0.03526072f, -0.04182924f, 0.00990675f, 
    0.01537843f, -0.00375565f, -0.03026077f, -0.00876305f, 0.00189860f, 0.01811597f, -0.01309446f, -0.03348519f, 
    -0.01633156f, -0.03213666f, 0.02274501f, -0.00541444f, 0.02009883f, -0.04106095f, 0.00468311f, 0.00506587f, 
    -0.01714781f, -0.04186473f, -0.03065714f, -0.02503788f, -0.01420568f, 0.01816466f, 0.02007342f, 0.01878469f, 
    -0.01761433f, -0.01378176f, 0.01626625f, 0.02963836f, 0.03169448f, 0.01696147f, 0.00983764f, 0.03552807f, 
    0.00839931f, -0.01994687f, 0.01161759f, 0.03739608f, 0.02637296f, 0.02578950f, 0.00008376f, -0.00261309f, 
    -0.00785158f, -0.03152969f, 0.02517041f, 0.02626996f, 0.03225819f, -0.02187407f, -0.01889761f, -0.01643896f, 
    -0.02624741f, -0.03747156f, 0.00918632f, -0.03869046f, -0.01457110f, 0.02111818f, 0.00103201f, 0.00160659f, 
    0.00482243f, -0.02381631f, 0.01197950f, 0.00406887f, 0.00187528f, 0.01821568f, 0.00136046f, 0.00929568f, 
    -0.00647328f, 0.01359060f, 0.02964682f, 0.00145527f, 0.02216447f, 0.00499025f, -0.00661871f, -0.02324393f, 
    0.01437991f, 0.00727807f, -0.03181833f, -0.02664289f, -0.02426933f, -0.00008343f, -0.01139917f, -0.00522176f, 
    -0.04092659f, -0.03246954f, -0.02930319f, -0.00290332f, 0.01186243f, 0.01721425f, 0.00254545f, -0.01581794f, 
    0.01576197f, 0.00440145f, -0.01819050f, -0.01336038f, 0.01418140f, -0.01893529f, -0.01453195f, -0.01210053f, 
    0.00927943f, -0.02952173f, 0.00224437f, 0.01891080f, 0.01975756f, -0.02093278f, -0.03142158f, 0.00791116f, 
    0.01252690f, -0.02881286f, -0.02102389f, 0.00260973f, 0.00339200f, 0.00996385f, 0.02661930f, -0.00023510f, 
    -0.02693203f, -0.01350502f, -0.01284351f, -0.03981424f, -0.01603998f, 0.00515484f, 0.01516368f, -0.00394416f, 
    -0.00480876f, 0.00312434f, -0.02917758f, -0.03561573f, 0.00866457f, -0.00156027f, 0.01261729f, 0.02369734f, 
    0.00031669f, -0.03820440f, -0.02873368f, 0.00330359f, -0.02576342f, -0.01585753f, 0.02817174f, 0.02682311f, 
    0.02710973f, -0.01042530f, 0.01330066f, 0.02694583f, -0.02031092f, -0.00760398f, 0.02247798f, 0.00551280f, 
    0.02672097f, -0.03325153f, -0.02939871f, -0.03565026f, -0.01743344f, -0.01250249f, -0.03952963f, 0.01902962f, 
    -0.03005488f, 0.01283893f, -0.01743310f, 0.00553506f, -0.00558276f, 0.01578942f, -0.00775019f, -0.01759712f, 
    -0.03607134f, 0.01618050f, -0.00527973f, -0.01219573f, -0.01513972f, -0.03699378f, 0.02815798f, 0.00303310f, 
    0.01772184f, 0.01599826f, -0.00173974f, 0.00782118f, 0.02547503f, 0.01898318f, 0.00708900f, -0.02263115f, 
    0.02903365f, -0.00593279f, 0.02084339f, 0.00925107f, 0.02615961f, -0.01977816f, 0.01238322f, 0.03105985f, 
    0.00584071f, 0.00301475f, -0.00546499f, 0.01112879f, -0.01736949f, -0.03665038f, -0.01507140f, -0.03186428f, 
    -0.01225688f, -0.03691661f, 0.01560317f, -0.01791591f, -0.02406042f, -0.03745930f, 0.02241472f, -0.00475108f, 
    -0.02082703f, -0.01726025f, 0.01897193f, -0.01356012f, 0.02791082f, 0.02613008f, -0.02889264f, -0.03199913f, 
    0.02160067f, 0.00678472f, 0.02783005f, 0.02812502f, 0.01651289f, -0.00475559f, -0.01450891f, -0.04142680f, 
    0.01232128f, 0.01315216f, -0.02516263f, 0.02192644f, 0.02247661f, -0.00419207f, 0.01644271f, -0.00089010f, 
    -0.03020732f, -0.03606370f, -0.00032721f, -0.03304245f, -0.00149608f, -0.01667040f, -0.02205223f, 0.02897091f, 
    -0.00108232f, -0.00173596f, 0.02376006f, -0.00297384f, 0.02399231f, 0.01841772f, 0.02443197f, 0.02257048f, 
    -0.03127407f, -0.04084414f, -0.02459800f, -0.03814717f, 0.03027934f, 0.03151171f, 0.02645349f, 0.00977769f, 
    -0.03280299f, 0.01268819f, -0.00720240f, 0.00254046f, -0.00829038f, 0.00439970f, -0.00655486f, -0.00384608f, 
    0.01557658f, 0.00826550f, 0.02115363f, 0.00393553f, 0.01161603f, -0.00516100f, 0.03745087f, -0.00550878f, 
    -0.02940347f, -0.00686994f, -0.00952322f, 0.01062133f, -0.03876653f, -0.02481108f, 0.02337537f, -0.03761946f, 
    0.00715847f, -0.00712930f, -0.01735485f, 0.01403094f, -0.00012222f, -0.03731842f, -0.03572403f, -0.02537883f, 
    -0.00067173f, 0.01350072f, -0.02532769f, -0.03500312f, -0.03586682f, -0.04030039f, 0.02730819f, 0.00394931f, 
    -0.00061587f, 0.00163459f, 0.01738684f, -0.01459269f, -0.02532717f, -0.01391048f, -0.01949666f, -0.02506879f, 
    -0.00523520f, -0.01650535f, 0.03638645f, 0.02013171f, -0.02488403f, -0.00078318f, 0.02310243f, -0.02472008f, 
    0.02679321f, -0.00038699f, -0.03091431f, 0.01233646f, -0.00567158f, 0.02008794f, 0.02147553f, 0.01066371f, 
    0.02734326f, 0.02435186f, 0.02461683f, -0.02961876f, -0.01682413f, -0.00160034f, -0.00875732f, 0.02126493f, 
    0.02775824f, 0.02326654f, 0.01498157f, 0.00527968f, -0.02812077f, -0.00907188f, 0.03118929f, 0.01442848f, 
    -0.01187127f, 0.02114483f, -0.02395482f, 0.02473195f, -0.02681207f, -0.00725185f, 0.04178336f, 0.03764010f, 
    -0.00280056f, -0.00593392f, -0.02545741f, -0.01720663f, 0.00648705f, -0.00508007f, -0.02659863f, -0.03623001f, 
    -0.03934433f, 0.01355822f, -0.01915395f, -0.02652691f, -0.03784279f, 0.01967141f, 0.02611555f, 0.01250487f, 
    0.02780645f, 0.02895004f, -0.04017865f, 0.00582791f, 0.00746476f, -0.03510541f, 0.00309705f, -0.00073627f, 
    -0.00365612f, 0.02205377f, -0.00092544f, 0.02438239f, 0.00869632f, -0.02563167f, 0.02403321f, -0.03785436f, 
    0.00177061f, 0.02033157f, 0.02828789f, -0.03848766f, 0.01819868f, 0.01907268f, 0.01379854f, -0.02885124f, 
    0.00011210f, 0.00093065f, 0.02385704f, -0.03931827f, -0.02172078f, 0.01153623f, -0.03490696f, -0.01895058f, 
    -0.00694921f, -0.04065001f, 0.01836114f, -0.00850397f, 0.02763017f, 0.01731326f, -0.02478266f, 0.01397837f, 
    -0.03200046f, -0.00364680f, 0.01455331f, 0.01007363f, 0.00227678f, -0.03976017f, 0.00131589f, -0.03030179f, 
    0.00574313f, 0.01080964f, -0.01650835f, 0.04062065f, -0.00825457f, -0.03098718f, -0.02046763f, 0.02074715f, 
    -0.02673186f, 0.00951392f, -0.01123183f, -0.00769436f, 0.02234163f, 0.00266620f, 0.02289597f, -0.01094026f, 
    0.02064998f, -0.00512082f, -0.02552241f, -0.02975819f, 0.03192848f, -0.02313924f, 0.02208107f, -0.00505387f, 
    -0.02606354f, -0.01277934f, 0.00353538f, 0.02651441f, -0.01620661f, 0.02986320f, 0.00627350f, 0.00229307f, 
    -0.00636107f, 0.03587582f, -0.03182945f, -0.03185203f, -0.02097094f, -0.00272950f, -0.03864806f, -0.00981204f, 
    -0.00979654f, 0.02761420f, 0.01600629f, 0.03193966f, 0.02027168f, -0.03810814f, 0.02060102f, 0.00573297f, 
    0.01950347f, 0.02515881f, -0.02407719f, -0.01314429f, 0.01185548f, 0.00559297f, -0.02678339f, 0.01625521f, 
    0.02976019f, 0.00527403f, -0.01234139f, -0.02369698f, 0.01641683f, -0.03020189f, 0.00689887f, 0.02287424f, 
    0.01681498f, 0.01460043f, -0.00104016f, 0.01288288f, -0.02839579f, -0.01614815f, 0.00511188f, -0.04117833f, 
    0.01976040f, 0.00187934f, -0.04047858f, 0.01136481f, -0.02131496f, 0.01280872f, -0.03491053f, 0.02238586f, 
    0.00041004f, -0.02601684f, 0.01083213f, -0.01070851f, 0.00958417f, 0.01456083f, -0.02390884f, -0.03263209f, 
    -0.02720373f, -0.03470771f, -0.01998939f, -0.01630983f, -0.01932346f, -0.02351905f, -0.02244532f, -0.02507537f, 
    0.02470718f, -0.03753724f, 0.01797711f, -0.02855514f, -0.03474084f, 0.02895791f, 0.00136913f, -0.03162905f, 
    0.02553644f, -0.03590211f, -0.00973834f, -0.01944784f, -0.01052058f, -0.01649381f, 0.00729500f, 0.02965863f, 
    -0.01530340f, -0.00286853f, -0.02128898f, -0.00920691f, -0.00069968f, 0.00981856f, -0.02731693f, 0.01559815f, 
    0.02072847f, 0.01953628f, 0.00069613f, 0.00781382f, -0.01982568f, 0.02001055f, 0.00110700f, 0.00889591f, 
    -0.01283476f, -0.02111061f, -0.00011926f, -0.03422591f, -0.03990823f, -0.02815004f, -0.01439946f, -0.02174168f, 
    -0.00927412f, -0.02423985f, -0.00098562f, -0.03683473f, -0.02215984f, -0.02449199f, -0.00667349f, -0.00126645f, 
    -0.02912445f, -0.02896303f, 0.01935202f, -0.01058720f, -0.02018024f, 0.00553589f, 0.01654766f, -0.01020176f, 
    -0.03589524f, -0.03312137f, 0.00617323f, -0.00184095f, 0.04013985f, 0.02620019f, -0.00776837f, -0.01170484f, 
    0.02222933f, -0.02148468f, -0.01596290f, 0.02189182f, -0.00809076f, -0.02057309f, 0.02960475f, -0.01323063f, 
    -0.02150804f, -0.03709195f, 0.01982838f, -0.00408706f, -0.03978697f, 0.02230566f, 0.01844446f, 0.02436457f, 
    0.02754955f, -0.01439852f, -0.01955628f, 0.02901714f, -0.00896706f, 0.02892497f, -0.02026484f, 0.01676281f, 
    -0.02369033f, 0.01726093f, -0.00931929f, -0.01736797f, -0.02970286f, -0.03686059f, 0.00439492f, -0.00317699f, 
    -0.03357720f, 0.01863603f, 0.01121980f, -0.01396284f, 0.00685414f, -0.01445694f, -0.00049704f, 0.00594703f, 
    -0.00837976f, -0.01670852f, -0.02516464f, 0.00816734f, 0.01940766f, -0.03158769f, -0.00489052f, -0.00268787f, 
    -0.02137676f, 0.00311696f, 0.03002385f, -0.00365302f, 0.01485932f, -0.04119624f, -0.02447250f, -0.02665740f, 
    0.01929029f, -0.02768790f, -0.02448684f, -0.02653829f, -0.02500479f, 0.02552658f, -0.02083619f, 0.01152876f, 
    -0.03856278f, -0.03574574f, 0.02446982f, 0.00070254f, 0.00426875f, -0.01950511f, -0.03441327f, 0.00772375f, 
    -0.03123591f, -0.02461616f, -0.02844726f, -0.01035618f, -0.01511190f, -0.01590136f, -0.01138856f, -0.01698680f, 
    -0.00835905f, -0.00334343f, 0.00451739f, 0.03446002f, 0.01612727f, 0.02572359f, 0.02439302f, 0.03637419f, 
    -0.00731994f, -0.02253007f, -0.03148449f, 0.01800814f, -0.00033389f, -0.00790630f, -0.04197117f, -0.00736265f, 
    0.00057334f, -0.03425391f, 0.01176834f, 0.02084309f, -0.02220406f, -0.03995397f, 0.02927803f, -0.00567571f, 
    0.03289124f, 0.06111599f, 0.40082711f, 0.14205278f, -0.09110015f, -0.10073666f, -0.09927395f, -0.01688562f, 
    -0.00370603f, 0.11086164f, -0.07691141f, 0.02966365f, -0.01358665f, -0.02323972f, 0.01392077f, -0.05020875f, 
    0.06538879f, 0.10185422f, 0.02263667f, -0.11437979f, 0.03458051f, 0.02120637f, -0.05532186f, -0.07998253f, 
    -0.16022281f, 0.00094440f, 0.10994306f, 0.01059244f, 0.01400409f, -0.03563230f, 0.02849681f, -0.11156186f, 
    -0.02510703f, 0.01529227f, 0.04590378f, -0.00153397f, 0.16661131f, 0.01530317f, -0.14553091f, 0.07552853f, 
    0.08838010f, 0.06280303f, 0.12291428f, -0.04992640f, -0.06756192f, -0.00902751f, -0.02867790f, -0.01786484f, 
    -0.09089153f, 0.00400563f, 0.19062705f, 0.18369009f, -0.01097551f, 0.08493523f, 0.00661362f, -0.08599716f, 
    0.01076454f, -0.10534696f, 0.01904768f, 0.09444682f, 0.04360445f, -0.07934351f, 0.08964051f, -0.01406793f, 
    -0.12054193f, 0.02163449f, -0.02635881f, 0.02461360f, 0.02310534f, -0.01178287f, 0.00002984f, 0.10464701f, 
    -0.13517983f, -0.05826249f, -0.12918495f, 0.07878988f, -0.11934533f, -0.05735505f, 0.05306763f, 0.05696092f, 
    0.08328795f, 0.04245058f, 0.10713240f, 0.06709204f, -0.28516626f, -0.15134956f, 0.10479854f, -0.04721494f, 
    -0.08903015f, -0.04198650f, 0.05441916f, 0.04602893f, 0.03143748f, -0.03251757f, -0.03968283f, -0.14386855f, 
    -0.17951012f, -0.13494509f, -0.01910026f, 0.01533018f, -0.04945891f, 0.03670117f, 0.07506071f, 0.14728732f, 
    -0.02165580f, -0.06933011f, -0.03740691f, 0.12789921f, 0.21510117f, -0.16676791f, -0.32614911f, -0.05621301f, 
    0.08302438f, 0.00328854f, 0.04935030f, 0.01265511f, -0.08621223f, -0.04124848f, -0.03887403f, -0.01098400f, 
    -0.30458972f, 0.27308896f, -0.15111896f, 0.08901845f, 0.00005308f, 0.00371476f, 0.08331345f, 0.11617414f, 
    -0.15144840f, -0.05786659f, -0.04051349f, -0.08731386f, -0.09769333f, 0.10380831f, -0.00793153f, -0.07022782f, 
    0.06336423f, 0.00855366f, -0.03151499f, -0.14931415f, -0.09998377f, 0.01555319f, -0.02418880f, 0.01357680f, 
    0.08258484f, -0.01148634f, -0.05099571f, -0.14567608f, -0.02417413f, -0.02438792f, 0.02183616f, -0.08515497f, 
    0.02561646f, 0.10585711f, 0.06819881f, -0.14178348f, 0.17563529f, -0.08288750f, -0.04932505f, -0.15611029f, 
    0.10574257f, 0.08734060f, 0.10165580f, -0.03100498f, 0.04821685f, -0.03757701f, -0.00261043f, -0.08648118f, 
    -0.00713677f, 0.13270879f, 0.01047766f, -0.06774711f, -0.03365102f, 0.15824614f, -0.17740811f, 0.11763883f, 
    0.01195874f, 0.02789124f, -0.03554530f, 0.02696798f, 0.21103345f, 0.14701688f, 0.08931800f, -0.13586837f, 
    -0.05265288f, 0.03574048f, 0.04705847f, 0.03061528f, 0.09157740f, 0.01107109f, 0.07637168f, 0.09764428f, 
    -0.15265347f, -0.18932348f, 0.17309338f, 0.14753060f, 0.05987727f, -0.02488372f, -0.10603854f, -0.01109268f, 
    0.06725853f, -0.00839064f, -0.11789379f, 0.10315485f, 0.40561861f, 0.19602892f, 0.07343436f, 0.22956988f, 
    -0.04334413f, -0.06180603f, -0.01749315f, -0.06842351f, -0.11027274f, 0.13089012f, 0.09050847f, -0.06522829f, 
    0.46672031f, 0.21331461f, 0.22716381f, 0.15261166f, -0.03879365f, -0.12843692f, 0.14899246f, -0.13919951f, 
    0.04066524f, 0.00987126f, -0.06972136f, 0.10690767f, 0.03068534f, -0.06950939f, -0.03452189f, -0.11253151f, 
    -0.15333986f, -0.08000950f, -0.01341280f, -0.01614564f, -0.02232053f, -0.03558565f, -0.01087944f, -0.07552136f, 
    0.12270543f, 0.09826472f, 0.13569441f, -0.13218197f, -0.08888140f, 0.04217401f, 0.12654905f, -0.09881328f, 
    -0.00597161f, 0.00801658f, 0.10171539f, -0.17085609f, -0.01644060f, -0.11003470f, 0.01370671f, 0.01028119f, 
    0.05455641f, 0.09422481f, -0.01070200f, 0.00275548f, -0.00876145f, 0.05080197f, -0.00221357f, 0.06186789f, 
    0.16787872f, 0.06443813f, 0.09698551f, 0.02521351f, 0.00478316f, 0.09820347f, 0.06790499f, -0.05144119f, 
    0.09153187f, -0.00855931f, 0.10051857f, -0.01297524f, -0.09321952f, 0.09342197f, 0.05728391f, 0.06328584f, 
    -0.04442482f, -0.03700054f, 0.09763668f, 0.08246044f, -0.03318487f, 0.03006000f, 0.00687985f, 0.01421222f, 
    0.24686849f, 0.09405228f, -0.12051313f, 0.10634173f, -0.05207546f, -0.04585254f, 0.01135089f, -0.01104018f, 
    0.09071971f, -0.01595356f, 0.03432054f, -0.04647271f, 0.01626585f, -0.06353138f, 0.20849867f, 0.06707061f, 
    -0.09163856f, -0.09102499f, -0.05463487f, -0.02070930f, -0.10687113f, 0.05284136f, 0.05886506f, 0.15524198f, 
    -0.00388301f, 0.15564719f, -0.02813118f, -0.15677740f, -0.14814234f, -0.03729393f, -0.02533605f, 0.00829727f, 
    -0.02939690f, -0.10746532f, -0.02009148f, -0.19771352f, -0.17123385f, -0.07667495f, -0.06818591f, -0.15476562f, 
    -0.18952124f, -0.05406329f, 0.03984699f, 0.05143988f, 0.11291356f, -0.02059794f, 0.02127113f, -0.00672877f, 
    0.10209092f, 0.01808146f, 0.01240598f, -0.04070777f, -0.03727421f, 0.01843328f, 0.04668232f, -0.02537906f, 
    0.05771424f, -0.03396332f, -0.13852949f, -0.03744401f, -0.09192888f, 0.01294428f, 0.10959458f, 0.02136980f, 
    0.03824777f, 0.00522978f, -0.02517278f, 0.05859543f, 0.09455434f, -0.02318844f, 0.11521229f, -0.00600054f, 
    -0.21395965f, 0.07987635f, 0.13235283f, 0.07880901f, 0.06621738f, 0.02977431f, 0.20020640f, 0.07251075f, 
    0.03789471f, -0.00106638f, -0.08622700f, 0.14336447f, -0.04417097f, 0.24761735f, -0.02782779f, 0.04178093f, 
    -0.02710334f, -0.07130643f, 0.04812380f, -0.05596126f, 0.07121839f, -0.02554952f, 0.12060627f, -0.16858062f, 
    0.10335915f, 0.08303457f, 0.02501926f, 0.00481852f, 0.04462179f, 0.03320852f, 0.05326180f, -0.04838084f, 
    -0.02408103f, -0.03151434f, 0.00622162f, 0.02144529f, -0.12509634f, -0.03660808f, 0.12190586f, 0.12232284f, 
    0.10389771f, -0.04228308f, -0.01452014f, 0.08837555f, 0.05545089f, -0.14629203f, -0.00256521f, -0.02280941f, 
    -0.22519989f, 0.16143981f, 0.05448287f, 0.09599574f, -0.02826488f, -0.08027068f, -0.06809062f, -0.09285110f, 
    0.12004204f, 0.01467645f, 0.08984928f, 0.11673167f, -0.03042571f, 0.05986504f, 0.08448157f, -0.06784996f, 
    0.05172638f, -0.06612628f, 0.04841637f, -0.11450105f, 0.09734549f, -0.06591091f, 0.03214436f, -0.05720140f, 
    -0.10031552f, 0.00054459f, 0.15840352f, 0.04565082f, -0.00580578f, 0.00912921f, 0.17476128f, -0.12371282f, 
    -0.00191619f, 0.04375633f, 0.01587499f, -0.01856794f, -0.00561662f, 0.14905977f, -0.01667805f, 0.01448490f, 
    -0.02315835f, 0.09388471f, 0.04879116f, 0.01942810f, 0.05469149f, -0.00334109f, 0.09068275f, -0.07004233f, 
    0.07875757f, -0.11293510f, 0.06840230f, -0.14859821f, 0.18277825f, -0.03354410f, -0.07262443f, 0.12807086f, 
    -0.13108706f, -0.03093232f, 0.05875103f, -0.15846705f, -0.10504365f, -0.07988606f, 0.09500336f, 0.11539556f, 
    -0.02018750f, 0.07008631f, 0.08767632f, 0.03228806f, 0.11182269f, -0.04362037f, -0.07278457f, 0.00843055f, 
    0.10453792f, 0.00327172f, 0.05524627f, 0.18399820f, -0.04204695f, -0.03665377f, -0.05981449f, -0.00840258f, 
    -0.01000175f, -0.01461484f, 0.00124024f, 0.02763843f, 0.01100923f, -0.08482619f, 0.06815897f, 0.15255158f, 
    0.00328415f, -0.01430470f, -0.03123943f, 0.03096162f, 0.10484420f, 0.10775661f, -0.11919715f, -0.07698128f, 
    -0.15901619f, -0.19270609f, -0.09432229f, -0.10635800f, 0.06583657f, -0.02836499f, -0.06478884f, 0.01548781f, 
    -0.00576508f, -0.08289538f, -0.05887554f, -0.01135600f, -0.00254021f, 0.12055554f, 0.16147850f, -0.12861219f, 
    -0.09417681f, 0.04007290f, -0.09728626f, 0.13301094f, -0.02506780f, 0.04348912f, -0.09735943f, 0.03062610f, 
    -0.02113467f, -0.02596913f, 0.23343909f, 0.08911306f, -0.00949557f, -0.00348944f, -0.01485979f, 0.02264405f, 
    0.07768091f, -0.05226626f, 0.05486543f, 0.17251280f, -0.05631774f, -0.22835587f, 0.01031207f, 0.04081702f, 
    0.02615570f, 0.02539751f, 0.01704822f, 0.17376795f, -0.11191460f, 0.02044835f, 0.09438217f, -0.11130141f, 
    0.32428068f, 0.03874684f, -0.15471780f, 0.09204566f, 0.16511475f, -0.01312333f, 0.14465517f, 0.04092727f, 
    0.00107591f, 0.16232781f, -0.14111981f, -0.04502091f, 0.19565323f, 0.05465797f, 0.10804456f, 0.06926920f, 
    -0.14171728f, -0.05582116f, 0.10474806f, 0.12516683f, 0.03832672f, 0.10905059f, 0.11741544f, -0.08065965f, 
    -0.06236788f, -0.01952005f, 0.13841006f, 0.09670370f, -0.19454160f, -0.05659441f, -0.05920061f, -0.04531096f, 
    0.01690149f, -0.04355036f, 0.03295389f, 0.02543421f, -0.35071349f, 0.19553643f, 0.13024408f, -0.11640163f, 
    0.09114581f, 0.03922397f, -0.01331844f, 0.09589424f, 0.08922701f, 0.11679309f, 0.10781956f, 0.11679003f, 
    -0.11186998f, 0.03905434f, -0.00827741f, 0.16257074f, -0.03700713f, 0.03433894f, 0.09266043f, -0.01482875f, 
    -0.02725077f, -0.04983472f, -0.03423564f, 0.10611700f, 0.00866847f, 0.07210053f, 0.05923558f, -0.06056875f, 
    0.01094302f, 0.02854083f, 0.16672385f, -0.01139796f, 0.06861002f, 0.24730937f, -0.10087865f, 0.05113311f, 
    -0.04450331f, -0.02406343f, -0.10759579f, 0.27114287f, 0.06986068f, 0.06147157f, -0.04856681f, -0.01619587f, 
    0.09378725f, -0.05582597f, 0.02895968f, 0.07530107f, -0.25004056f, -0.19880456f, 0.09601936f, 0.21117420f, 
    0.03554321f, 0.05110232f, 0.08114440f, 0.18448997f, -0.00363568f, -0.12258957f, -0.01055616f, -0.06935555f, 
    -0.05958078f, -0.00059528f, 0.06000038f, 0.01973300f, 0.04312723f, 0.07851495f, 0.18663214f, -0.11952777f, 
    0.08167025f, 0.05413279f, 0.03390793f, 0.14568578f, -0.28765532f, 0.11776321f, -0.11689972f, -0.09109881f, 
    0.01717966f, -0.02223749f, -0.06883910f, 0.03868703f, 0.03070613f, 0.08791022f, -0.04248680f, -0.10475274f, 
    0.06983014f, 0.00984576f, -0.21670981f, -0.15909705f, 0.15022852f, 0.06589911f, 0.06260031f, -0.03569160f, 
    -0.03058662f, 0.02229234f, -0.02670265f, 0.03116868f, 0.06874399f, -0.05826040f, -0.16662939f, 0.01548368f, 
    0.19295038f, -0.01810996f, 0.19995885f, 0.18400118f, -0.06541590f, 0.09956967f, -0.06055675f, -0.02623689f, 
    -0.05704373f, 0.04400767f, 0.06049316f, -0.06003559f, -0.03202450f, 0.00835986f, 0.13767159f, 0.07735945f, 
    -0.08723382f, -0.04410277f, -0.02122415f, 0.01852653f, 0.15117225f, -0.10192806f, 0.02083221f, 0.00987769f, 
    0.00450707f, 0.05845148f, -0.10244271f, -0.01172745f, -0.01879032f, -0.02084374f, 0.03246308f, -0.08272601f, 
    0.08270587f, 0.25272316f, 0.03845492f, 0.01748737f, 0.06186972f, -0.02159509f, 0.05484776f, 0.05553202f, 
    -0.04319380f, 0.08431592f, 0.08258801f, 0.16829379f, 0.12930153f, -0.01975237f, -0.00737711f, 0.17181809f, 
    0.07619872f, 0.03689484f, 0.20385912f, 0.09755840f, -0.03875966f, 0.09148017f, -0.03080936f, -0.06847582f, 
    -0.05568434f, -0.11676008f, 0.02686036f, -0.13170488f, 0.06739736f, 0.02385434f, 0.00910813f, -0.10345861f, 
    0.05502594f, -0.05047207f, 0.07818851f, 0.04959378f, -0.12237654f, 0.19613568f, 0.11935787f, 0.40973255f, 
    -0.12194110f, 0.00050344f, 0.02334722f, -0.16575682f, 0.23003928f, -0.21828490f, 0.20455547f, 0.00360698f, 
    0.03817548f, 0.01253118f, 0.01102350f, 0.02020652f, -0.04017070f, -0.03802243f, -0.02545125f, -0.03114376f, 
    0.01796713f, 0.00524501f, -0.02642142f, -0.03629879f, -0.00780697f, 0.01953760f, 0.02480478f, -0.01610932f, 
    -0.02333046f, 0.00366952f, -0.02975519f, -0.02350155f, 0.02405448f, 0.00235850f, -0.03366612f, -0.02631165f, 
    -0.02194476f, -0.01953792f, -0.02791741f, -0.00693370f, -0.03783348f, 0.01114408f, -0.00158097f, 0.02391201f, 
    0.01936010f, 0.02297498f, 0.02127670f, 0.02728476f, 0.01885197f, -0.01050175f, 0.02090809f, -0.00182513f, 
    0.03449954f, -0.00183207f, 0.00284633f, -0.03344784f, -0.00238477f, 0.01274186f, 0.02010504f, 0.00181649f, 
    -0.02378261f, -0.00710600f, 0.00388589f, 0.03587420f, -0.00737689f, -0.01338444f, -0.00370071f, -0.02463030f, 
    -0.03748232f, -0.00251383f, -0.02801818f, -0.00034225f, -0.00608301f, 0.03144651f, 0.03060114f, -0.02868347f, 
    -0.01523855f, 0.01343108f, -0.03290332f, -0.03246947f, -0.03655509f, 0.02004947f, -0.02579604f, 0.02849852f, 
    -0.03283307f, 0.02858363f, -0.00033746f, 0.02598137f, -0.01826756f, 0.02426517f, 0.00027555f, 0.00503481f, 
    -0.00852819f, 0.01414589f, 0.00944985f, -0.02997331f, 0.00530038f, 0.01611714f, 0.02892817f, 0.00990676f, 
    0.02515364f, -0.02892718f, 0.01736152f, 0.02573838f, -0.01469065f, 0.00230834f, -0.03069058f, -0.03008436f, 
    -0.02079629f, 0.02467943f, -0.03017510f, 0.00794871f, -0.01055009f, 0.02078897f, 0.01709054f, 0.01806816f, 
    0.02148910f, -0.03482180f, -0.01774152f, -0.02057032f, -0.03659201f, -0.01995465f, 0.01796004f, 0.02660059f, 
    0.04069324f, -0.02122293f, 0.01111270f, -0.01587582f, 0.00659852f, -0.01737400f, -0.00903525f, -0.00184862f, 
    -0.01356598f, -0.01581939f, -0.03818589f, 0.01196989f, -0.00492018f, 0.02612109f, 0.03072600f, -0.03580042f, 
    0.02371836f, 0.00303888f, -0.03684179f, -0.00776428f, 0.00401946f, -0.03100184f, -0.01007466f, 0.00971854f, 
    0.03682224f, -0.01013763f, 0.00663187f, -0.03307911f, -0.01914440f, 0.00345720f, -0.01228192f, 0.02441547f, 
    -0.00061748f, 0.02588382f, -0.01526460f, 0.00188972f, -0.00662289f, 0.01169900f, 0.02589697f, 0.00760726f, 
    -0.01933396f, -0.02564875f, 0.00924347f, -0.02193714f, 0.00046527f, 0.01095550f, -0.00447928f, -0.02611120f, 
    -0.01645777f, -0.01538715f, -0.02232157f, 0.00430317f, 0.00292432f, 0.02621428f, 0.02896757f, 0.00735536f, 
    -0.02677489f, -0.00279869f, -0.01485104f, -0.03983046f, 0.02927344f, -0.01769779f, -0.02873240f, 0.01199418f, 
    -0.02844097f, -0.01632643f, -0.01910191f, -0.00960125f, 0.00722132f, -0.02189825f, -0.01826672f, -0.00397434f, 
    0.02697761f, -0.01297787f, -0.03749698f, -0.03197109f, -0.03998996f, 0.02503548f, 0.01953214f, -0.00990219f, 
    0.03990519f, -0.03991813f, 0.02225555f, -0.02685973f, -0.03370064f, -0.01504748f, -0.01247878f, -0.00248999f, 
    -0.01046742f, -0.00015431f, -0.02786206f, -0.03328633f, -0.02265339f, -0.00448433f, -0.00349514f, 0.00214475f, 
    0.01944877f, 0.02154718f, -0.01999415f, 0.02503771f, -0.03219899f, -0.01897907f, 0.02382762f, 0.02105291f, 
    0.00564997f, 0.01300735f, 0.01320388f, -0.00860698f, -0.01294894f, -0.01281608f, -0.04203752f, 0.02267501f, 
    -0.02275642f, -0.02013736f, -0.01640168f, 0.03068450f, 0.01513220f, 0.00833724f, 0.00363052f, -0.02683084f, 
    -0.03504870f, 0.01767671f, 0.02069148f, 0.02497797f, -0.02024846f, 0.00232891f, -0.02523844f, 0.00552560f, 
    0.02274122f, -0.02680049f, -0.00875012f, -0.03007345f, 0.02702417f, -0.02449114f, -0.03407586f, -0.03052735f, 
    0.02787993f, 0.01074620f, 0.01956175f, 0.02539539f, -0.02778462f, 0.02691199f, 0.02425575f, -0.00954900f, 
    0.01459636f, 0.02802615f, -0.01404049f, 0.00917974f, 0.02463083f, -0.02722365f, -0.02099973f, -0.03716654f, 
    -0.01779180f, -0.03068952f, -0.01368271f, -0.03295730f, -0.01426874f, -0.00840722f, -0.03786108f, 0.01317336f, 
    -0.01588945f, -0.00465005f, -0.01860772f, -0.03396190f, -0.00160719f, 0.01114229f, -0.02105601f, 0.00577702f, 
    0.00910423f, -0.03406473f, 0.01593169f, 0.01637588f, -0.02359876f, -0.03717942f, 0.01891450f, -0.02365862f, 
    -0.03166319f, 0.01447303f, 0.00176686f, -0.00256096f, -0.02641875f, -0.00688541f, -0.02498778f, -0.03204226f, 
    -0.00898057f, 0.02745773f, -0.00830046f, -0.00655009f, -0.01674994f, -0.01052119f, -0.03529987f, -0.03076439f, 
    0.00453068f, 0.03309197f, -0.00874582f, 0.00847123f, -0.00536083f, 0.02796428f, -0.01772519f, 0.02694534f, 
    -0.01787220f, 0.01044606f, -0.03131264f, 0.02185758f, 0.01945322f, -0.01990412f, 0.01851189f, -0.01105044f, 
    0.02560299f, -0.03261459f, -0.01829853f, -0.01521986f, 0.02959610f, 0.03063334f, 0.02040939f, -0.03715462f, 
    0.01117515f, -0.01859979f, 0.01434232f, -0.03178637f, -0.02432675f, -0.03359093f, -0.04422395f, 0.02162552f, 
    -0.00739287f, -0.04196372f, -0.03004433f, 0.00336519f, -0.02409383f, 0.02336835f, 0.01534997f, -0.03218162f, 
    0.01165950f, -0.01451502f, 0.03107364f, -0.03066560f, 0.01652724f, -0.00671525f, -0.00402505f, 0.00352066f, 
    0.00258990f, -0.00709455f, 0.02279978f, -0.00712415f, -0.01782561f, -0.00115549f, 0.02461187f, -0.02427003f, 
    -0.03153270f, 0.01352958f, 0.02404333f, -0.02438259f, 0.01037395f, 0.03116877f, -0.01241556f, 0.00824714f, 
    -0.02169598f, -0.00613886f, -0.03036025f, -0.03959741f, -0.02484420f, -0.02922638f, 0.01434978f, 0.03302480f, 
    0.02082889f, -0.02084105f, 0.01778706f, 0.01552157f, 0.03501407f, 0.02160938f, -0.03213963f, -0.03823218f, 
    -0.01629998f, 0.01043681f, -0.03457020f, 0.02039940f, -0.03059276f, 0.02402217f, -0.01398173f, 0.02199925f, 
    -0.01887906f, 0.03545552f, -0.02529422f, -0.01269680f, 0.00258515f, 0.01802798f, -0.00095036f, 0.02654403f, 
    0.01613137f, 0.00881662f, -0.00441170f, 0.02602180f, -0.01681077f, -0.03091683f, 0.00680511f, -0.01350470f, 
    -0.01153987f, 0.03170858f, 0.01078253f, 0.00315505f, -0.02238149f, -0.01642670f, 0.02417553f, -0.02975553f, 
    -0.02526194f, 0.01991406f, 0.02776374f, 0.03403808f, 0.02142354f, -0.03063352f, -0.00650854f, 0.02451524f, 
    0.01732651f, -0.00833417f, -0.02984260f, 0.01287815f, -0.03274867f, -0.00695865f, -0.03160926f, -0.03430275f, 
    -0.00010209f, 0.02576727f, -0.02303376f, -0.02024265f, 0.00176638f, -0.03491519f, -0.03611936f, -0.02675570f, 
    -0.01238022f, 0.00641476f, -0.00828362f, 0.00911378f, 0.02130075f, 0.02604017f, -0.00142605f, 0.01824874f, 
    0.01556632f, -0.01226279f, -0.01783590f, 0.00514470f, -0.01592163f, 0.00686820f, 0.02475172f, -0.03784864f, 
    0.00502927f, -0.02926931f, -0.02060453f, -0.03440252f, 0.01672218f, 0.01783314f, 0.00200946f, -0.00710114f, 
    -0.01726664f, 0.01462060f, 0.01643508f, -0.02426233f, 0.02053510f, 0.02358678f, 0.01168301f, -0.02164149f, 
    -0.00686188f, -0.01678038f, -0.04487477f, -0.03245867f, 0.03609943f, -0.01464377f, 0.01046792f, -0.01144818f, 
    -0.01941066f, 0.01882057f, 0.02451416f, -0.01536080f, -0.01825481f, 0.00765523f, -0.03681552f, -0.04021875f, 
    -0.00185330f, 0.01204466f, -0.03022607f, -0.01939064f, -0.00695540f, 0.03794222f, 0.01007532f, 0.02558939f, 
    -0.03544937f, -0.00445463f, 0.01393710f, -0.01807241f, -0.00505425f, -0.00950303f, 0.00296738f, 0.03547802f, 
    -0.04141943f, -0.01606003f, 0.01589998f, -0.02033648f, 0.00720145f, 0.00025301f, -0.03022611f, 0.01036970f, 
    -0.01680527f, 0.00793915f, 0.02281800f, 0.00396460f, 0.02230498f, 0.00577230f, 0.00611942f, -0.00801373f, 
    -0.01893851f, 0.00164349f, -0.00936092f, 0.02028563f, 0.03477839f, 0.02193028f, 0.02764991f, 0.02793500f, 
    0.02928637f, -0.03388506f, -0.03210822f, -0.04118837f, 0.01255911f, -0.00695171f, -0.00221980f, 0.00556290f, 
    0.00200234f, -0.01527854f, -0.01016423f, 0.02326987f, 0.01565308f, 0.02699672f, -0.02494463f, 0.02688103f, 
    0.01157437f, -0.02045545f, -0.00731032f, -0.03315230f, 0.02895311f, -0.00091264f, -0.03722804f, 0.02760358f, 
    -0.01688408f, 0.02794806f, -0.02507911f, 0.00503209f, -0.03310098f, -0.02237230f, -0.02862986f, -0.01377982f, 
    0.01677098f, 0.00330831f, -0.04070514f, -0.00364274f, -0.01008493f, -0.01073471f, 0.03670909f, -0.00840492f, 
    0.01704148f, 0.01426370f, -0.03171289f, -0.00641510f, 0.00368284f, 0.00141767f, -0.00130109f, 0.02842902f, 
    0.03682280f, -0.03812123f, -0.03288702f, -0.01242570f, 0.00152074f, 0.00826097f, -0.04234196f, 0.01929764f, 
    0.02518164f, 0.02809436f, 0.00730913f, 0.00666668f, -0.03476410f, 0.00550415f, 0.02520740f, -0.00159839f, 
    0.00814372f, 0.02351935f, -0.03346992f, -0.03549791f, -0.01099094f, 0.02043187f, -0.02202246f, 0.02984038f, 
    0.00446024f, 0.01542306f, 0.03072907f, -0.00424141f, 0.00362538f, -0.00812433f, -0.03280054f, -0.00117080f, 
    -0.03267583f, 0.00575334f, 0.01283870f, -0.01114397f, 0.01615397f, -0.00321773f, -0.00540286f, 0.00115817f, 
    0.00525720f, -0.00113182f, 0.01732770f, 0.00584238f, -0.01121312f, -0.03469603f, -0.02010542f, -0.00184773f, 
    0.00868964f, -0.00966469f, 0.00769660f, -0.02033358f, -0.01098058f, 0.03478413f, -0.00355071f, 0.02147645f, 
    0.02753590f, -0.01496842f, 0.01919465f, 0.02169447f, -0.00186831f, -0.00008053f, -0.01764988f, 0.02985205f, 
    0.01704826f, -0.02530047f, -0.01424131f, -0.01687870f, -0.00952050f, -0.00072230f, 0.00521127f, -0.02932378f, 
    0.03442493f, -0.02458531f, -0.01056238f, -0.00701025f, -0.01282912f, -0.00556745f, -0.04134682f, -0.00811400f, 
    -0.01163633f, 0.01589816f, -0.00358211f, -0.02214040f, -0.02614715f, 0.02240105f, -0.01495781f, -0.02049982f, 
    0.00805552f, -0.03875354f, -0.03146033f, -0.02587358f, -0.00993956f, 0.00277108f, 0.03310480f, 0.00272418f, 
    -0.02884289f, -0.02106430f, 0.02849308f, -0.00280690f, -0.00248727f, -0.02031890f, 0.01889865f, -0.02253061f, 
    -0.01693852f, -0.03037430f, 0.01203237f, 0.00435006f, -0.02539389f, -0.04552133f, -0.03222327f, 0.01364887f, 
    -0.00201430f, 0.02172514f, 0.03168466f, 0.02016556f, 0.00646909f, -0.02747345f, -0.03010758f, 0.02160687f, 
    -0.03835239f, -0.02207514f, -0.04269532f, 0.01212085f, -0.02624973f, -0.00169667f, -0.02866922f, 0.01116098f, 
    0.02569748f, 0.02753765f, -0.03787601f, -0.01590604f, 0.03129416f, 0.03274110f, 0.02433812f, 0.00376683f, 
    0.02913706f, -0.02235318f, 0.02930821f, -0.03349192f, -0.03331186f, 0.01617318f, -0.03172787f, 0.01930563f, 
    0.02670043f, -0.03005252f, 0.03344249f, 0.02376722f, 0.02430291f, -0.03217874f, 0.02041814f, 0.02159469f, 
    -0.02083432f, -0.00050936f, -0.02047784f, -0.03067083f, 0.01382557f, -0.02766798f, -0.04160996f, -0.03775274f, 
    -0.03523200f, 0.00235488f, 0.01641870f, 0.01750254f, 0.00726344f, -0.03741566f, -0.00254743f, 0.00489551f, 
    0.00158167f, 0.02153475f, -0.00444532f, -0.00077067f, -0.02509499f, -0.01774472f, -0.02845536f, 0.02691782f, 
    -0.00494354f, 0.00697251f, -0.00953872f, -0.01772916f, -0.00220007f, -0.00430523f, 0.02464366f, 0.03593073f, 
    -0.01039636f, 0.00446609f, -0.03480265f, -0.03596482f, 0.00848678f, 0.02301959f, -0.03431081f, 0.00339781f, 
    -0.01557774f, 0.00270668f, 0.18506645f, 0.38144410f, -0.05018568f, -0.04299916f, -0.11316197f, 0.02950870f, 
    0.04672763f, 0.15794156f, -0.08344346f, -0.03850465f, 0.28015259f, -0.01460877f, -0.00496883f, -0.15072493f, 
    -0.02063349f, 0.06735846f, 0.02142104f, 0.06733572f, 0.05016504f, 0.08693807f, -0.05736401f, -0.01929128f, 
    0.19830674f, 0.14745100f, 0.22557507f, -0.13114609f, 0.02934550f, -0.14686489f, -0.00445710f, 0.04258397f, 
    -0.02533864f, 0.01550082f, 0.00392645f, -0.06072420f, 0.11477584f, -0.02313840f, -0.17146492f, -0.15640533f, 
    0.13759917f, 0.05069631f, 0.12542763f, 0.06557792f, 0.04239011f, -0.01354794f, -0.04068731f, -0.00782771f, 
    -0.22872722f, -0.00503301f, -0.14270765f, 0.10813623f, 0.06421188f, 0.04027333f, -0.02923428f, -0.04475925f, 
    -0.00507080f, -0.10285272f, -0.00676205f, -0.05637791f, -0.05615998f, -0.22752999f, 0.13659517f, 0.00018594f, 
    0.05111321f, 0.06299232f, 0.12768033f, 0.04607431f, -0.05758006f, -0.09392304f, -0.13734627f, 0.05907753f, 
    0.10499788f, 0.15453866f, -0.00280605f, 0.12969863f, -0.08071042f, -0.14315082f, -0.15546070f, 0.07592665f, 
    0.03425893f, -0.08747198f, 0.13098976f, -0.00117539f, -0.21306993f, -0.05821685f, -0.02256709f, 0.11457124f, 
    -0.00229738f, 0.00353295f, -0.02256079f, -0.03506483f, 0.02556234f, 0.04929013f, 0.12070686f, 0.00850958f, 
    -0.58452535f, 0.05785418f, -0.02199971f, 0.11330247f, 0.02543051f, 0.05030533f, 0.01963703f, -0.04835473f, 
    -0.01336224f, -0.12297882f, -0.17144519f, -0.07375641f, -0.13550033f, 0.12235863f, -0.30331022f, 0.06806777f, 
    0.21381380f, 0.18010072f, 0.19026352f, 0.12598027f, 0.07767391f, -0.03994099f, -0.01856692f, -0.07966559f, 
    -0.59580511f, 0.01314488f, -0.44289121f, 0.37218627f, 0.13851450f, 0.04885777f, -0.02872657f, 0.01207404f, 
    0.07939837f, -0.07272768f, -0.05469529f, -0.03994156f, 0.12646763f, 0.33591637f, 0.11713972f, -0.07995427f, 
    0.03439413f, -0.03185065f, 0.04640273f, 0.06688178f, -0.06287116f, 0.03721571f, -0.03304614f, 0.01823271f, 
    0.12426651f, -0.09460568f, -0.03597614f, 0.00614823f, 0.06600175f, 0.07288414f, 0.11787537f, 0.04731550f, 
    -0.05321397f, -0.07249782f, -0.10385514f, -0.03870600f, 0.11496912f, -0.31902930f, -0.04537868f, 0.02537160f, 
    0.12759383f, 0.18154632f, 0.09019147f, 0.03081843f, 0.03331512f, -0.00630321f, -0.00707766f, -0.03135129f, 
    0.29293504f, 0.13128084f, 0.03125201f, -0.12418608f, 0.02437571f, 0.04782615f, -0.05072349f, 0.01292682f, 
    -0.10945757f, -0.04210373f, -0.04312329f, 0.06822146f, -0.06918803f, 0.20613940f, -0.04637837f, -0.36442199f, 
    -0.02589767f, 0.02164702f, -0.03153605f, -0.05485685f, 0.00024241f, -0.05484149f, 0.04358307f, -0.00952818f, 
    0.22780864f, -0.03364374f, 0.33523920f, 0.39081404f, -0.06212706f, -0.08499226f, -0.08133308f, -0.04148786f, 
    0.10043599f, 0.08118897f, 0.03649993f, 0.14567676f, 0.00782241f, 0.05737735f, -0.21391855f, -0.00697899f, 
    0.07926212f, -0.00518244f, 0.00805655f, -0.03744011f, -0.00481657f, -0.01482755f, -0.02940388f, 0.05893777f, 
    0.01791923f, -0.23777261f, -0.14254837f, -0.23997992f, 0.03541418f, 0.01992341f, 0.05755394f, -0.03740806f, 
    0.09163754f, 0.00621667f, -0.08456194f, -0.01814590f, -0.05601905f, -0.11984762f, -0.10903566f, 0.02154416f, 
    0.05229242f, -0.02727140f, 0.01734403f, -0.05570583f, 0.01584141f, -0.02552549f, 0.05924606f, 0.11329401f, 
    0.24668480f, 0.21943381f, -0.21935147f, -0.18380839f, -0.11510044f, 0.08462416f, -0.05037755f, 0.04101846f, 
    0.05674892f, -0.00642395f, -0.02555740f, -0.10169188f, 0.10833583f, -0.25919175f, 0.01346783f, -0.15402262f, 
    0.09538338f, 0.02666761f, 0.11443300f, 0.09270628f, 0.05117924f, -0.05513376f, 0.01810060f, 0.00868104f, 
    -0.09662753f, 0.01795104f, -0.04201426f, 0.00646178f, 0.04179553f, 0.00349050f, 0.00958566f, -0.06624471f, 
    0.03139578f, 0.05121958f, -0.00138029f, 0.06649815f, -0.03883466f, 0.26043248f, -0.02184016f, 0.04142905f, 
    -0.03991570f, 0.05247777f, -0.02051864f, -0.02393124f, 0.04007945f, 0.00996240f, 0.08665662f, 0.13327827f, 
    0.16480918f, -0.10332517f, -0.05920663f, -0.04705958f, -0.03628425f, -0.00899361f, 0.08068911f, 0.07587396f, 
    0.05513133f, 0.00505641f, -0.00149731f, 0.06861062f, 0.08404446f, -0.05281094f, 0.11933889f, 0.15613090f, 
    -0.00484733f, -0.01986992f, -0.15594725f, 0.02311492f, 0.01484027f, -0.00072608f, 0.00905788f, -0.03233868f, 
    0.25426343f, 0.14267890f, 0.09575524f, -0.07396626f, -0.05233972f, -0.09556184f, -0.03864262f, -0.00059167f, 
    0.03572662f, 0.05195941f, 0.10547674f, 0.08392148f, -0.40441570f, 0.10176871f, -0.02370682f, -0.08317393f, 
    -0.01121208f, 0.03166230f, 0.03530836f, 0.04307543f, 0.01059625f, -0.06868207f, -0.08378434f, 0.01474151f, 
    0.02626043f, -0.16287835f, -0.00434528f, 0.10670003f, 0.08168661f, 0.01977785f, 0.02954370f, -0.04418749f, 
    0.01877187f, 0.03874832f, -0.01695426f, 0.09151752f, -0.14913468f, 0.20863496f, 0.01977922f, 0.04822608f, 
    0.06670412f, -0.00717073f, 0.06155372f, 0.03461946f, 0.08725687f, 0.03221624f, 0.08230434f, 0.00625090f, 
    -0.27335873f, 0.19706547f, -0.03135721f, -0.02934592f, 0.02040029f, -0.02937856f, -0.03470360f, 0.05283336f, 
    0.05391338f, -0.09472011f, -0.08266367f, 0.05172212f, 0.05787974f, 0.11345933f, 0.10639710f, 0.26858470f, 
    0.08722161f, -0.06383280f, -0.02580670f, -0.07642210f, 0.05666389f, -0.02112311f, 0.08451170f, -0.02210227f, 
    -0.00360229f, -0.10732266f, -0.19924021f, -0.12505929f, 0.07194159f, 0.06804228f, -0.00639575f, 0.01689917f, 
    0.02085666f, -0.07081925f, -0.05998709f, -0.03738892f, -0.06262836f, -0.07280672f, 0.19448313f, 0.10961793f, 
    0.11829044f, 0.00996634f, -0.05852283f, -0.05621139f, 0.11591072f, 0.00936789f, 0.04874972f, 0.11580997f, 
    0.16951104f, -0.10009147f, 0.05383181f, -0.06372540f, -0.07696311f, -0.05279842f, -0.02488135f, -0.01927534f, 
    -0.11661214f, 0.10703831f, -0.00176851f, 0.03930289f, 0.09561289f, 0.14184497f, 0.06721212f, -0.05044344f, 
    0.07959475f, 0.02705396f, 0.07497255f, -0.05588502f, 0.06538771f, -0.05103098f, 0.05550297f, 0.16262184f, 
    -0.02309192f, 0.13496695f, 0.09344096f, -0.01812867f, 0.00079176f, -0.13733268f, 0.06165573f, -0.07824259f, 
    0.04250758f, -0.04784969f, -0.06672857f, -0.05176193f, 0.18375860f, 0.20721278f, 0.06163172f, -0.03137007f, 
    -0.02867104f, 0.02423105f, -0.06444152f, 0.04213260f, -0.02827010f, 0.04504468f, 0.01311078f, 0.01242502f, 
    0.26239666f, -0.37042096f, 0.15713876f, -0.28061527f, -0.03075064f, 0.04110189f, -0.01143601f, -0.11066625f, 
    -0.04684426f, -0.08854207f, 0.15608534f, -0.00381188f, -0.05853491f, -0.04951142f, 0.04796274f, 0.12576988f, 
    0.08459757f, 0.12846623f, -0.01595812f, -0.06203046f, 0.03972965f, 0.02469638f, -0.05275401f, 0.06425020f, 
    -0.00593091f, -0.27029151f, -0.03157421f, 0.10192267f, 0.09235176f, 0.09114289f, 0.02884464f, 0.08400770f, 
    -0.00145540f, -0.10943928f, -0.00056028f, -0.11774808f, 0.10706967f, -0.39634532f, 0.24840744f, 0.17735195f, 
    -0.04238026f, 0.03811294f, -0.16446312f, 0.02672613f, 0.04476402f, 0.06855234f, -0.01902389f, 0.02682600f, 
    0.02386182f, 0.01204792f, -0.02230642f, -0.14463283f, 0.02314605f, 0.03908726f, -0.06026615f, -0.04371278f, 
    0.07126515f, -0.04316285f, -0.02720569f, 0.04902828f, 0.40401280f, -0.01516400f, 0.11509718f, -0.25264201f, 
    -0.12636973f, -0.01974581f, -0.10059994f, 0.02405178f, -0.08932930f, 0.04575661f, -0.01059246f, 0.14947054f, 
    0.07449140f, 0.03136719f, 0.13865082f, 0.20776360f, -0.04446621f, 0.02011819f, -0.02567618f, -0.04243599f, 
    -0.02343330f, -0.06984304f, 0.04114589f, 0.07454776f, -0.04950860f, -0.38924104f, 0.04830610f, 0.10096430f, 
    0.11439710f, -0.10948133f, 0.06546786f, -0.02415453f, 0.16258053f, 0.00844676f, 0.08483513f, -0.07656042f, 
    0.05033680f, -0.01447933f, -0.12154333f, -0.13339689f, -0.01237570f, 0.03815128f, 0.04184048f, -0.07847716f, 
    0.07102653f, 0.00692586f, -0.09440026f, -0.00138772f, 0.10881002f, -0.02109015f, -0.00921920f, -0.19513991f, 
    -0.12064561f, -0.06390350f, 0.04735425f, 0.01467596f, 0.00266307f, 0.05891642f, 0.01423270f, 0.02888379f, 
    -0.03745838f, -0.14259279f, 0.25755385f, 0.40584886f, 0.05229030f, 0.04599111f, -0.05833075f, -0.02658489f, 
    -0.02317799f, -0.04727563f, 0.13171118f, 0.05289414f, -0.53579891f, 0.12782131f, 0.04435169f, -0.01112316f, 
    0.04972820f, -0.01882282f, -0.11803614f, 0.06151722f, 0.10698520f, 0.00220710f, 0.02784962f, -0.00362178f, 
    -0.11153029f, 0.10992840f, 0.03107559f, -0.06325590f, 0.05839424f, 0.11394856f, 0.00982022f, -0.04541915f, 
    0.05253963f, -0.02100079f, 0.01569627f, -0.05345794f, -0.07421021f, 0.02416118f, 0.11249357f, -0.02691998f, 
    0.12723982f, -0.02206649f, 0.03869533f, -0.01574691f, 0.09872673f, -0.05377563f, 0.02069833f, -0.05058637f, 
    0.09150366f, -0.17421545f, 0.02665776f, 0.01345629f, 0.03022400f, -0.01185344f, -0.05146949f, 0.09505660f, 
    0.07877794f, -0.02659001f, -0.01363188f, 0.03330931f, 0.19318463f, -0.33347985f, 0.30416840f, 0.27725235f, 
    0.00957896f, 0.00422675f, -0.02133967f, 0.03761934f, 0.12619384f, -0.02483110f, -0.03707602f, 0.03780437f, 
    0.01862872f, 0.15670329f, -0.16066554f, -0.17221726f, -0.05565017f, 0.00569603f, 0.05708784f, -0.01268458f, 
    0.08608945f, -0.01286680f, 0.04527239f, 0.04655012f, 0.25339273f, 0.13959417f, 0.12740137f, 0.06119194f, 
    -0.08324941f, -0.02979497f, -0.13184220f, -0.06076694f, 0.00697036f, -0.10319069f, 0.02254150f, -0.04040139f, 
    -0.01995905f, 0.01162372f, -0.19863586f, -0.06899334f, 0.25652322f, 0.12460634f, 0.12157079f, 0.15029193f, 
    0.00689026f, -0.03878549f, -0.02344756f, -0.00896662f, -0.13223253f, 0.28716743f, -0.26229468f, -0.08119687f, 
    0.09250305f, 0.06603294f, 0.03921881f, 0.04384343f, -0.06857104f, 0.11681688f, 0.01400556f, 0.11089186f, 
    -0.02429788f, 0.14716336f, 0.08965847f, -0.04104191f, -0.09957866f, 0.05840436f, 0.08823174f, 0.04982847f, 
    0.00324243f, -0.04210245f, 0.00100131f, 0.01456991f, 0.01766934f, -0.19950584f, -0.17621954f, 0.01101012f, 
    0.09188733f, 0.00723293f, -0.06029997f, 0.02106010f, -0.03771051f, -0.02953550f, -0.03937844f, 0.01863658f, 
    0.01849295f, -0.07642033f, -0.15655179f, -0.01345531f, -0.02875187f, 0.17309274f, 0.06870507f, -0.00194074f, 
    -0.04048664f, -0.04977674f, 0.13516450f, 0.03586935f, -0.07419762f, 0.06067171f, -0.11931813f, 0.02113265f, 
    0.01943194f, -0.01950382f, 0.04645219f, -0.00487830f, 0.02073719f, 0.04107557f, 0.03973439f, 0.05060787f, 
    0.12073373f, 0.13959542f, -0.06700820f, -0.14511982f, 0.03257978f, 0.01461856f, -0.00169355f, 0.06948947f, 
    0.01087982f, 0.01807237f, 0.01106290f, 0.03299556f, -0.19784825f, 0.03813023f, 0.21244039f, 0.34064317f, 
    -0.00692008f, -0.00287438f, -0.10910892f, -0.12100781f, 0.11673937f, -0.07510857f, 0.06492446f, -0.05008191f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05268064f, 0.02116285f, 0.00378115f, -0.07101586f, 0.11427972f, 0.03979296f, -0.04882889f, 0.15660046f, 
    -0.03833127f, 0.01853259f, 0.02447410f, 0.02729771f, 0.00316049f, 0.10465297f, 0.12916768f, 0.00139043f, 
    0.00800051f, -0.04345684f, -0.05570931f, -0.03869310f, -0.02114885f, 0.10568084f, -0.00980594f, 0.02842984f, 
    0.12110830f, 0.00360161f, 0.02085744f, -0.02448551f, -0.01310977f, 0.10725250f, -0.03185016f, 0.03494636f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12970360f, -0.15650339f, -0.01317204f, -0.20177190f, -0.17209800f, 0.06632102f, 0.42663246f, -0.51534534f, 
    -0.02303337f, -0.08647501f, -0.03340293f, 0.16442183f, 0.24235755f, 0.21669754f, 0.06131858f, 0.11683837f, 
    0.15625666f, 0.13451229f, 0.19104524f, -0.15858524f, 0.10437825f, 0.07093398f, -0.04170245f, -0.14854228f, 
    0.19678703f, -0.10948376f, -0.12382339f, 0.00247065f, 0.15735328f, 0.12663689f, 0.06024658f, -0.23428565f, 
    -0.12856077f, -0.10886361f, 0.03575859f, 0.21365969f, 0.13542873f, 0.20371519f, -0.15954338f, 0.15623060f, 
    0.17046914f, 0.16171721f, -0.05310471f, -0.14953057f, -0.10913002f, -0.30693531f, -0.11591474f, -0.03404816f, 
    0.04313388f, 0.04240551f, 0.22736867f, -0.06917684f, -0.10117837f, 0.20005418f, 0.00826433f, -0.17232785f, 
    0.12444820f, -0.30937904f, -0.10767472f, -0.16062959f, -0.14697759f, -0.03705618f, -0.04531965f, -0.01896223f, 
    -0.15629378f, 0.08249655f, -0.07409402f, 0.06674906f, -0.13709421f, 0.11199474f, 0.05951205f, 0.26435217f, 
    0.14666112f, -0.01181089f, 0.13269910f, 0.03021914f, -0.45749554f, -0.07493395f, 0.06199818f, 0.00531908f, 
    -0.11362012f, 0.07037499f, 0.15817632f, 0.16815905f, 0.13255614f, 0.19947705f, 0.03868426f, -0.14671813f, 
    0.33291432f, -0.51858914f, -0.08343910f, -0.17382307f, -0.11203474f, 0.08757173f, 0.15417592f, -0.40098697f, 
    -0.05170313f, -0.13127536f, -0.16977325f, 0.05015495f, 0.00732125f, -0.24703282f, -0.08897319f, -0.31572652f, 
    -0.07102408f, 0.16631441f, 0.15915397f, 0.11102425f, 0.10725459f, 0.34032011f, 0.27943301f, 0.10081350f, 
    0.09985910f, -0.05365051f, 0.02067321f, -0.12486821f, -0.09641486f, 0.20493282f, 0.06557624f, 0.09314241f, 
    0.08580017f, 0.21302931f, 0.12246443f, 0.07073805f, -0.06788343f, -0.13408428f, -0.10833074f, 0.16099155f, 
    -0.29295003f, -0.07329337f, -0.00001111f, 0.40820056f, -0.19885258f, -0.11597875f, -0.44674897f, 0.12931177f, 
    -0.04466975f, -0.02899779f, -0.16871758f, 0.01755129f, 0.02830831f, 0.26185313f, 0.13469662f, -0.16307856f, 
    -0.16686817f, -0.14488155f, 0.28692225f, 0.04949073f, -0.05387941f, 0.10694516f, -0.00093535f, 0.16527788f, 
    0.18156849f, 0.21662991f, 0.00409567f, 0.13636966f, -0.13624926f, -0.16003868f, -0.04066012f, -0.29024035f, 
    -0.27649498f, 0.04106911f, 0.10497404f, 0.12647605f, -0.19792798f, -0.13411875f, 0.29578081f, -0.15543233f, 
    -0.09461197f, 0.14443624f, -0.17542875f, 0.13429075f, 0.26354492f, -0.29865003f, 0.00009974f, -0.02908634f, 
    0.06645603f, -0.13155808f, 0.29824978f, 0.14478643f, -0.00876943f, 0.24466507f, -0.06814532f, 0.20083733f, 
    -0.11275147f, 0.03370572f, 0.01926404f, 0.00006411f, 0.08770755f, -0.23820415f, 0.14452213f, 0.21054764f, 
    -0.16357873f, 0.10636353f, 0.05179877f, 0.48086065f, 0.06142922f, 0.01701238f, 0.20345022f, 0.14365275f, 
    -0.10220526f, -0.06362469f, 0.00743740f, -0.05703088f, -0.13993454f, 0.03457292f, 0.09714738f, 0.05082433f, 
    0.00638203f, -0.16396751f, 0.18086238f, -0.12016541f, -0.01627237f, -0.08400301f, -0.16926208f, -0.22661856f, 
    0.08497728f, 0.08075535f, -0.02745688f, 0.12043634f, -0.08084395f, -0.02219450f, -0.05101223f, 0.16601688f, 
    0.14178611f, 0.13562667f, -0.05023487f, -0.01805165f, 0.19141567f, -0.06159066f, 0.30767208f, 0.36859399f, 
    0.13458405f, 0.01355714f, -0.16213490f, -0.17184055f, -0.06467916f, 0.20077421f, 0.26381046f, 0.07363272f, 
    0.15444769f, 0.05727438f, -0.04375356f, -0.07067714f, 0.08582103f, -0.09623657f, -0.04999332f, 0.32414547f, 
    -0.28794795f, 0.11721043f, -0.00088770f, -0.03846918f, -0.08234820f, 0.04378375f, -0.16921906f, 0.35293680f, 
    0.12037071f, -0.04060450f, 0.07733569f, -0.38635689f, -0.04860349f, -0.04120924f, 0.05893185f, -0.18669958f, 
    0.00629946f, 0.04410099f, -0.16357195f, -0.12422343f, 0.33875802f, 0.11103614f, -0.17158778f, 0.15027376f, 
    0.13852052f, -0.01678394f, 0.16364366f, -0.07128338f, -0.15671723f, -0.12327141f, -0.03008415f, -0.26944986f, 
    0.25037920f, 0.06621402f, 0.16204867f, 0.02825214f, 0.09494838f, -0.12739950f, 0.09126267f, 0.04825689f, 
    0.12779339f, 0.05132735f, 0.15453216f, -0.01453425f, -0.06220333f, -0.02346399f, -0.29478440f, 0.13278213f, 
    0.11289041f, -0.09188221f, 0.03103662f, -0.15446858f, -0.29472351f, 0.14681916f, 0.16918609f, -0.10367618f, 
    0.04311878f, 0.01493666f, 0.11835760f, -0.03572856f, 0.12999892f, 0.09428351f, 0.05754928f, 0.22639176f, 
    0.35422871f, -0.17985001f, 0.03264135f, 0.14118345f, -0.04879707f, -0.05356841f, -0.01203052f, -0.38890037f, 
    0.31278628f, 0.06593372f, 0.02331272f, 0.03563888f, -0.25346950f, 0.25681469f, 0.17390968f, 0.15561783f, 
    -0.00071955f, 0.03325541f, 0.04241383f, -0.00457805f, 0.28368232f, 0.06970277f, -0.14035237f, -0.10608795f, 
    -0.15494055f, 0.15892987f, -0.53156126f, -0.09863095f, 0.04473241f, -0.05759636f, -0.12890553f, -0.29507256f, 
    0.06786710f, -0.08762459f, -0.08673243f, -0.01825759f, -0.04095077f, 0.09650194f, -0.16721423f, -0.12579533f, 
    0.23840050f, 0.04870734f, -0.04837924f, 0.04746589f, -0.30805424f, 0.09592043f, 0.26990455f, 0.05889868f, 
    -0.14238015f, 0.14614744f, -0.15429059f, 0.07250268f, 0.31370935f, 0.03939707f, -0.48685342f, -0.10493992f, 
    -0.11725317f, 0.08122490f, -0.24650240f, 0.03630344f, 0.15527779f, 0.16869506f, -0.04133372f, 0.03486428f, 
    0.01881245f, 0.13416043f, -0.02208467f, -0.08997240f, -0.11619888f, 0.08637582f, -0.00122472f, -0.13007721f, 
    0.11608942f, -0.08877789f, -0.12745064f, -0.05591663f, -0.05890798f, -0.09224993f, -0.07543571f, -0.21912327f, 
    0.08292013f, -0.12350753f, 0.03073542f, -0.18384051f, 0.34300351f, 0.13677651f, 0.12392623f, -0.12680274f, 
    -0.03503304f, 0.13340062f, 0.09184319f, 0.02977361f, -0.07468417f, 0.12956443f, -0.10989154f, 0.08892229f, 
    0.06744795f, 0.01450607f, 0.03901616f, -0.12257244f, -0.12730131f, -0.06821398f, 0.13070674f, 0.03618666f, 
    -0.09889662f, 0.12268981f, 0.14277139f, -0.29067329f, -0.12878381f, 0.05473797f, -0.27261463f, 0.32869458f, 
    -0.13164409f, 0.04069017f, 0.07574484f, -0.01152189f, -0.23485976f, 0.16092934f, 0.02817579f, 0.11903912f, 
    -0.07400568f, -0.14117125f, 0.02044322f, 0.05222740f, 0.04872377f, 0.30051550f, 0.07848655f, 0.01308406f, 
    0.27823216f, -0.15306884f, -0.09343866f, -0.00264555f, 0.09368013f, 0.01930297f, -0.15069118f, -0.28942192f, 
    0.10932904f, -0.09423342f, -0.15493304f, 0.11729275f, -0.10962092f, 0.00214789f, 0.41221783f, -0.45655450f, 
    -0.06070444f, -0.09326469f, -0.16960910f, 0.15752536f, -0.02421776f, -0.07669022f, 0.31721851f, 0.00488831f, 
    -0.17079842f, 0.19428775f, 0.32274720f, 0.05143203f, -0.15065809f, -0.08077250f, 0.14370650f, 0.33482590f, 
    -0.09673872f, 0.09295436f, -0.04514943f, 0.00477278f, -0.06255512f, -0.24952465f, -0.17043482f, -0.11019076f, 
    -0.49690160f, 0.15329686f, -0.03116984f, -0.10234199f, -0.19022125f, 0.27189118f, -0.16398591f, 0.30535728f, 
    0.10533527f, -0.03796344f, -0.01229431f, -0.16031319f, 0.22999637f, 0.13423091f, 0.26130968f, 0.07951809f, 
    -0.14004497f, -0.01496843f, 0.08164007f, -0.00475228f, 0.14355792f, 0.31578821f, 0.02325529f, -0.24916473f, 
    -0.16113631f, -0.22344564f, -0.16808508f, -0.02993761f, -0.01868181f, 0.03446235f, 0.09586842f, -0.15066658f, 
    -0.24816500f, 0.03216521f, -0.05318360f, -0.44839838f, 0.35708985f, 0.30132276f, -0.27491301f, 0.31393534f, 
    -0.08451978f, 0.05023260f, -0.12074320f, 0.06389563f, 0.19728898f, 0.24005264f, 0.24675313f, -0.02115155f, 
    -0.12187811f, 0.03007339f, -0.20717292f, 0.14145340f, 0.11964211f, 0.17163132f, 0.09825813f, -0.20272861f, 
    -0.08831146f, 0.09379435f, -0.07556843f, -0.17557530f, 0.15636565f, 0.10614878f, -0.02780742f, 0.21249188f, 
    -0.21818516f, -0.09795231f, 0.03873883f, -0.06468693f, 0.06912337f, -0.15139748f, 0.14966545f, 0.19844761f, 
    0.10345399f, 0.12622492f, -0.09357702f, 0.04503076f, -0.22618227f, -0.54713452f, 0.11489331f, -0.04591142f, 
    0.15930486f, 0.07732870f, -0.25938129f, -0.11032350f, 0.00747729f, 0.27665368f, 0.03068435f, -0.19985189f, 
    0.19421116f, 0.00240701f, 0.02855222f, 0.16469702f, 0.07124109f, 0.14075923f, -0.11848984f, 0.24129039f, 
    -0.03670726f, -0.13904448f, -0.15509325f, -0.25247365f, 0.19863299f, -0.08105455f, 0.39848518f, -0.15628904f, 
    -0.13931945f, 0.01203929f, 0.13872312f, 0.03953544f, 0.16510619f, -0.30723298f, 0.00397476f, 0.13970599f, 
    0.11003868f, 0.17994776f, -0.11667109f, -0.06124112f, -0.13232729f, 0.23216067f, 0.16127306f, -0.07541326f, 
    -0.05400659f, -0.24165075f, 0.13242120f, -0.10942979f, 0.16165981f, 0.38433337f, 0.14036302f, 0.12175620f, 
    0.02328938f, -0.10471500f, -0.14104560f, 0.16191745f, -0.03242787f, -0.11449851f, -0.13039215f, -0.09236342f, 
    0.05557403f, 0.15873067f, -0.10056727f, -0.04856042f, 0.14914876f, -0.09706485f, -0.05150663f, -0.05227478f, 
    -0.06100855f, 0.03009995f, -0.14860144f, -0.01833900f, 0.01350425f, -0.01056396f, 0.09057444f, -0.01846371f, 
    -0.15796590f, -0.03407697f, 0.07358134f, 0.03221614f, -0.03005730f, -0.01449396f, 0.08439089f, -0.08872794f, 
    0.27825937f, -0.10853372f, -0.08245435f, 0.11071000f, -0.07148060f, 0.25420347f, -0.21093820f, -0.27299795f, 
    -0.10308181f, 0.02369538f, 0.06893770f, -0.13622756f, -0.22217315f, -0.06720278f, -0.09881007f, 0.16872972f, 
    0.16247134f, 0.06101501f, 0.08856745f, 0.04567016f, 0.16303383f, -0.22990723f, -0.06594764f, -0.23930246f, 
    -0.00063830f, 0.09130877f, -0.05728848f, -0.13946700f, 0.01724752f, -0.02107259f, -0.07775822f, -0.29938972f, 
    0.07136098f, -0.09056793f, -0.04515348f, 0.14667739f, 0.05481351f, -0.16968006f, 0.36382759f, -0.41785377f, 
    -0.18158738f, -0.06193015f, -0.04286413f, -0.16718173f, 0.05063961f, -0.23028663f, 0.09641703f, 0.16651082f, 
    -0.00183260f, 0.01721470f, -0.11721765f, 0.11531014f, -0.01039222f, 0.03498310f, -0.02935369f, 0.23249415f, 
    -0.03158846f, -0.02950671f, 0.10576805f, -0.16002563f, 0.04986393f, 0.13073586f, -0.09951001f, 0.11139635f, 
    0.25395915f, 0.16276439f, -0.07996535f, -0.49665552f, 0.05035331f, -0.11572109f, 0.11865471f, -0.17713268f, 
    -0.13197780f, -0.02453069f, 0.05816185f, -0.01219896f, -0.12385525f, 0.49916071f, -0.17514923f, -0.07617501f, 
    0.13271093f, -0.07590391f, -0.10948759f, -0.08153034f, 0.10413774f, 0.02688851f, 0.14511441f, 0.17487031f, 
    0.15429169f, -0.24673222f, -0.00854784f, -0.04648441f, 0.10902152f, 0.26691902f, 0.11559743f, 0.12416183f, 
    0.00977266f, 0.03468517f, 0.13932464f, -0.29868880f, -0.01339823f, 0.00402372f, 0.11698533f, 0.43538412f, 
    0.01518706f, -0.10555142f, -0.01604532f, 0.02092843f, -0.30549294f, 0.08291335f, -0.08788459f, 0.12218417f, 
    -0.13780221f, 0.12186438f, -0.21904120f, -0.10408235f, 0.12992905f, 0.25788954f, 0.08945242f, 0.19860034f, 
    -0.17358819f, -0.08036760f, 0.17831700f, -0.14154020f, -0.10220111f, 0.24187334f, 0.13134561f, 0.31686071f, 
    -0.15950257f, 0.08102792f, -0.11737168f, -0.07489929f, -0.00154492f, 0.24544473f, 0.41104767f, -0.33151776f, 
    0.00661778f, 0.12592925f, 0.02763712f, 0.12970063f, 0.60573786f, -0.17744520f, 0.17636454f, -0.12056651f, 
    0.06876227f, -0.14983535f, 0.01761600f, -0.08568076f, 0.08594009f, -0.04421842f, -0.13555770f, -0.19576892f, 
    0.17006867f, -0.42281520f, 0.15665640f, -0.17068918f, -0.09045931f, 0.03104081f, 0.12111413f, 0.14845520f, 
    0.05374252f, 0.13909619f, 0.03975186f, -0.35186321f, 0.27758858f, -0.01809961f, 0.21180141f, -0.13623507f, 
    -0.11819834f, -0.08865773f, 0.06320693f, -0.03428629f, -0.36645880f, 0.28045663f, -0.11527448f, -0.06846359f, 
    -0.02646540f, 0.05242584f, -0.01271559f, 0.03906785f, 0.12845720f, -0.11206051f, -0.13108386f, 0.36852649f, 
    0.22794567f, -0.05390404f, -0.15570275f, -0.14491177f, 0.09613228f, 0.25077626f, 0.05893823f, 0.11916445f, 
    0.12603766f, 0.16734117f, 0.04003822f, -0.32370460f, -0.06365114f, 0.17586270f, -0.11227140f, -0.31189802f, 
    0.13372652f, -0.14394130f, -0.09344875f, 0.17271978f, -0.05994705f, 0.13731359f, -0.34010121f, -0.12469225f, 
    -0.00440670f, -0.12714331f, 0.08523194f, -0.08407103f, -0.11143107f, 0.07412222f, -0.03217568f, -0.34797812f, 
    0.15676728f, -0.12594345f, -0.07764300f, 0.07895777f, -0.03126916f, 0.07203344f, 0.14017572f, -0.34533057f, 
    -0.05608465f, -0.05235245f, 0.03899642f, 0.50357825f, 0.10951310f, -0.15217693f, -0.46122414f, 0.17103772f, 
    -0.09173959f, 0.08331846f, -0.08174743f, 0.09285195f, 0.04758535f, -0.38967878f, 0.32488430f, 0.07701902f, 
    0.03184126f, 0.11556389f, -0.26062009f, -0.15066186f, -0.06321658f, 0.14161545f, -0.03388873f, 0.32726854f, 
    0.10079035f, 0.08715694f, -0.15821049f, -0.11982226f, 0.04355657f, 0.05369060f, -0.09670303f, 0.43839619f, 
    0.16052018f, -0.14409913f, 0.07283404f, -0.35438210f, 0.37348887f, -0.15238178f, -0.13895288f, 0.09799960f, 
    -0.05704758f, -0.07778584f, 0.16365273f, 0.03984292f, 0.24370447f, -0.16350956f, 0.24843667f, -0.01494795f, 
    -0.14836569f, 0.02260011f, -0.22765537f, 0.05224819f, 0.07175402f, -0.03234930f, -0.08234967f, 0.01207823f, 
    0.23656148f, -0.10319790f, 0.01498999f, -0.10820813f, -0.06341104f, 0.23940955f, 0.15364785f, -0.07651425f, 
    0.02675759f, -0.16335917f, 0.12809338f, 0.11364544f, -0.02161805f, 0.06900632f, -0.13765004f, 0.35303667f, 
    0.04094591f, -0.15558474f, -0.07455112f, -0.11830033f, -0.13552082f, 0.29365724f, 0.20155776f, -0.14846835f, 
    0.16144684f, 0.17745781f, -0.06542218f, 0.13229373f, -0.08345331f, -0.06655985f, 0.05024422f, 0.14130206f, 
    0.02895157f, -0.05855048f, -0.14938523f, 0.08497033f, 0.03118540f, -0.08809787f, -0.03926804f, -0.13731380f, 
    0.12506448f, 0.06179955f, 0.14782262f, -0.09180085f, 0.07092699f, -0.09370704f, -0.13118120f, -0.09176846f, 
    0.15002501f, -0.12438759f, -0.02119881f, -0.14395612f, -0.03276303f, 0.15546389f, -0.05336655f, -0.00111051f, 
    -0.01689168f, -0.03673896f, -0.10969619f, -0.03330716f, 0.03558165f, -0.09948806f, 0.13878885f, -0.15629505f, 
    -0.13673458f, -0.15089129f, -0.15294664f, -0.12754363f, -0.02995551f, -0.08319857f, 0.03314976f, -0.03663687f, 
    -0.11806858f, 0.09677472f, 0.11336454f, -0.14315885f, -0.25522619f, 0.00935472f, 0.15343988f, 0.31827995f, 
    -0.02294203f, 0.09984462f, -0.03706673f, 0.00743584f, -0.02951224f, 0.06462532f, -0.09678132f, -0.02529028f, 
    0.03424110f, 0.21853131f, -0.20313996f, -0.04835173f, -0.08097869f, -0.05401947f, 0.16454898f, -0.13616636f, 
    -0.11930941f, 0.12797064f, 0.05048208f, -0.17522711f, -0.09940933f, -0.09435032f, 0.10503528f, 0.07596586f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12426456f, 0.21057160f, 0.06309921f, 0.12330748f, -0.00221936f, -0.15315805f, 0.03703021f, -0.13284296f, 
    0.17960864f, 0.05264821f, 0.08793290f, -0.01972700f, -0.10855077f, 0.19856687f, -0.19535986f, 0.24475509f, 
    0.29746833f, -0.11289596f, 0.09586765f, -0.06513578f, -0.19553947f, -0.13422257f, -0.00254951f, 0.16275170f, 
    0.21188653f, 0.03802565f, 0.19809142f, -0.01651419f, -0.05808203f, 0.11075914f, -0.09971409f, 0.24118476f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.07214636f, -0.53820187f, -0.27744946f, 0.18655615f, 0.14843328f, 0.14240615f, 0.26433909f, 0.27762976f, 
    -0.19810082f, -0.04029056f, -0.21545027f, -0.42434078f, -0.04485179f, -0.65418708f, 0.15174447f, -0.71573007f, 
    -0.47553852f, -0.13305016f, -0.22857127f, -0.16236989f, 0.07436879f, 0.09444547f, -0.15252043f, -0.12655650f, 
    -0.40096685f, 0.06933399f, -0.10053269f, 0.26472914f, -0.15214162f, 0.07456832f, -0.10764066f, -0.17435502f, 
    -0.26414350f, -0.26918674f, -0.36947042f, 0.17250592f, 0.04076614f, -0.07597652f, -0.19245712f, 0.23268874f, 
    0.01362017f, 0.00483216f, 0.26059723f, 0.23482245f, 0.05932250f, 0.10703454f, 0.01831626f, -0.02078238f, 
    0.15963866f, -0.30815876f, -0.29234868f, 0.16562383f, -0.10471349f, -0.14713584f, 0.14297573f, 0.34184361f, 
    -0.83647174f, 0.13304169f, 0.00384881f, 0.09950966f, 0.00599695f, 0.20919511f, 0.09310552f, 0.12317456f, 
    0.11183310f, -0.02247351f, -0.10593162f, 0.06231794f, 0.21215813f, -0.49566832f, 0.28343448f, 0.04969414f, 
    0.14209744f, -0.13400805f, -0.31297693f, -0.62038618f, 0.16495095f, 0.00689583f, -0.51969421f, 0.39118591f, 
    0.26748365f, -0.13811561f, -0.12200452f, 0.04363545f, -0.10826699f, -0.26656291f, -0.43736556f, -0.23092054f, 
    -0.01769457f, -0.31204388f, -0.15727645f, 0.10300720f, 0.15845616f, 0.05235828f, 0.11566019f, 0.18073119f, 
    -0.03750699f, 0.26709762f, 0.07572506f, -0.05547010f, 0.22826990f, 0.11243469f, -0.02228259f, -0.05581985f, 
    -0.21626994f, 0.30983868f, -0.11799000f, 0.10376548f, 0.16912575f, 0.08246559f, 0.21586743f, 0.11433440f, 
    -0.45651811f, -0.44111076f, -0.31048831f, -0.04123987f, -0.41315517f, -0.19555689f, -0.24743067f, -0.63620591f, 
    -0.06990079f, -0.23128600f, -0.16935568f, 0.12130750f, -0.22068012f, 0.11963192f, -0.02340768f, -0.39378276f, 
    0.08056272f, -0.14446288f, -0.19617410f, 0.11448084f, -0.18649869f, 0.28481254f, -0.02578019f, 0.13076219f, 
    0.11459204f, -0.04441047f, 0.06051291f, 0.12310412f, 0.04083119f, -0.25483301f, 0.12719484f, 0.02777091f, 
    -0.22219501f, 0.27073541f, 0.25620535f, 0.04182512f, 0.20226221f, -0.00315253f, -0.77757615f, -0.07224636f, 
    0.00020288f, -0.31022662f, -0.10953382f, 0.16095591f, -0.02982396f, -0.07535919f, 0.06918918f, 0.07067911f, 
    0.25207466f, -0.25451332f, -0.20094186f, -0.04169716f, -0.27492982f, -0.19294049f, -0.06379779f, 0.19120535f, 
    -0.04047865f, -0.13583614f, -0.19020039f, -0.14297745f, 0.17356977f, -0.15905321f, 0.15859404f, -0.22783062f, 
    -0.04399223f, -0.25842732f, 0.25705835f, 0.12658457f, 0.03425473f, 0.02501824f, 0.30719349f, -0.07240734f, 
    0.28472596f, 0.23157816f, -0.05636491f, -0.06066056f, 0.19050822f, -0.12085403f, 0.03632315f, -0.56269383f, 
    -0.24942462f, 0.35394514f, 0.24971370f, -0.86941838f, -0.45962125f, -0.54575157f, 0.18217856f, 0.02938234f, 
    -0.18428235f, -0.33221593f, 0.19543430f, -0.49074340f, -0.32027110f, 0.09046017f, -0.05400217f, 0.09285873f, 
    0.24509205f, 0.25712243f, 0.06718674f, 0.02084132f, 0.13616608f, -0.24880180f, -0.43544567f, 0.07071286f, 
    0.17138498f, 0.03434435f, -0.08241390f, -0.01848281f, 0.13269994f, 0.00507909f, 0.03071918f, -0.23906839f, 
    0.22726315f, -0.16764340f, -0.35620266f, -0.18106119f, 0.04272848f, -0.15953910f, -0.12462559f, -0.31193012f, 
    0.16837695f, -0.32523742f, 0.38273376f, 0.25011754f, 0.04846861f, 0.07031103f, -0.05322009f, 0.17612919f, 
    0.10792949f, -0.43189904f, -0.12825765f, 0.08896431f, 0.34388128f, -0.16377884f, -0.26613554f, -0.31687465f, 
    0.45101121f, -0.32585767f, 0.16046374f, -0.40866238f, 0.01231342f, -0.06322544f, -0.00816652f, -0.13703619f, 
    0.28658271f, -0.08999021f, 0.11739744f, 0.18895994f, 0.01927862f, -0.52782547f, 0.08998371f, -0.36455026f, 
    0.34519830f, 0.26290387f, -0.06570024f, -0.16051963f, -0.01800017f, 0.05487939f, -0.32657573f, -0.11424411f, 
    -0.05866319f, -0.32277906f, -0.75702018f, 0.03774549f, -0.20816416f, -0.20863636f, 0.29581439f, -0.44496652f, 
    -0.10821365f, 0.22141692f, 0.31552392f, -0.51724124f, 0.03323150f, -0.09999700f, -0.18789227f, 0.05359576f, 
    -0.20718239f, 0.15899022f, -0.67005044f, -0.03593137f, -0.34184211f, 0.21903417f, -0.10871577f, -0.04327455f, 
    -0.20453548f, -0.72339410f, 0.01548574f, -0.04453565f, 0.14246878f, -0.24061912f, -0.61415786f, 0.20850687f, 
    0.24289149f, 0.13642494f, 0.23565510f, 0.14988358f, -0.05528484f, -0.09935330f, -0.22820540f, 0.18163450f, 
    0.18735944f, -0.13498771f, -0.00144942f, 0.26236674f, -0.08068984f, -0.63913512f, -0.00676321f, -0.32132733f, 
    -0.11706828f, -0.09668215f, 0.25248185f, -0.02685118f, 0.03700024f, -0.50224197f, -0.34624922f, -0.28943735f, 
    -0.40333307f, 0.31010264f, -0.58892184f, -0.31389576f, 0.12041511f, 0.21683136f, -0.35278332f, -0.31408212f, 
    -0.14332703f, 0.22043566f, 0.15974353f, -0.02152589f, -0.31542385f, -0.02681793f, 0.04310908f, -0.00481714f, 
    -0.46717232f, 0.10895291f, -0.15964212f, 0.25158742f, 0.41901758f, -0.18397766f, 0.06885890f, -0.03441833f, 
    0.16193694f, 0.26077566f, 0.34382200f, -0.30829906f, 0.05668838f, 0.11551621f, 0.15512471f, -0.25694272f, 
    -0.43965375f, 0.03596030f, -0.12044759f, 0.07145851f, -0.10456307f, 0.27663055f, -0.23780233f, 0.26614082f, 
    -0.15456568f, -0.02850557f, -0.05050727f, 0.02266925f, -0.15113303f, -0.11325260f, -0.06976583f, 0.25147057f, 
    -0.30948523f, 0.02087093f, 0.15331618f, -0.46682343f, -0.55081856f, -0.19632003f, -0.01229902f, -0.43307102f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03361717f, 0.02145530f, 0.26749182f, -0.08559056f, -0.01231007f, 0.07834676f, 0.02137494f, -0.18855689f, 
    0.01497313f, -0.05414469f, 0.02480632f, 0.02562355f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
