#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.51986217f, -0.77243608f, -0.95033979f, -0.18022110f, 0.38595939f, 0.67951071f, 0.34171423f, -0.06230066f, 
    -0.10212298f, -0.24584857f, 0.77176768f, -0.25222707f, -0.52648938f, -0.64504117f, -0.67367136f, 0.19855416f, 
    -0.02218172f, -0.15515895f, 0.78575408f, 0.68128163f, 0.44758838f, -0.13613516f, -0.50669760f, 0.41608816f, 
    0.20242809f, 0.36218783f, -0.35318848f, 0.77521509f, 0.71423382f, -0.75245380f, 0.51769447f, 0.36373252f, 
    -0.25003135f, 0.56147587f, 0.10605445f, -0.25270963f, -0.29734454f, -0.81700915f, -0.48705339f, -0.77467197f, 
    0.04249575f, -0.31322587f, 0.05490297f, 0.21938813f, -0.38149381f, 0.68660253f, -0.37109640f, -0.46175671f, 
    -0.90608716f, 0.16354862f, 0.53528965f, 0.09438603f, -0.03480822f, 0.45786580f, -0.54994857f, -0.54093933f, 
    -0.65287095f, 0.44021225f, 0.57999694f, -0.58389181f, -0.26948926f, 0.16427819f, 0.09112131f, 0.01838429f, 
    0.61567038f, 0.55236912f, 0.00455717f, 0.60835910f, -0.13398744f, -0.30408606f, 0.43167040f, -0.44979435f, 
    0.49171346f, 0.11520527f, 0.91722882f, -0.57260925f, 0.02058574f, -0.21074001f, -0.10158700f, -0.52769434f, 
    -0.43843505f, 0.53209323f, 0.26875198f, 0.50628328f, 0.38623533f, 0.38345256f, 0.20919348f, -0.40964702f, 
    -0.03854392f, 0.23800616f, 0.09619208f, 0.50898403f, -0.63288617f, 0.47241893f, -0.82470500f, -0.08112546f, 
    -0.33093166f, -0.05486028f, 0.31408513f, 0.71433008f, 0.65245610f, 0.63977695f, -0.23061040f, -0.22532520f, 
    -0.45063192f, 0.03989869f, 0.35110894f, 0.35362777f, -0.54277831f, 0.03257646f, -0.17563862f, 0.39297760f, 
    0.60964394f, 0.77120417f, -0.49434292f, -0.10066198f, -0.36849415f, -1.06232250f, 0.21076691f, 0.56335580f, 
    -0.48842287f, 0.08895414f, 0.48681712f, -0.45836020f, 0.00834157f, 0.27475733f, -0.16499473f, 0.20128632f, 
    1.12528157f, 0.48794988f, -0.11495237f, 0.16809008f, 0.09099407f, 0.15704235f, -0.01312337f, -0.22869448f, 
    0.33597752f, 0.17994721f, 0.71330911f, -0.25654516f, 0.39407647f, 0.01005828f, -0.50061655f, 0.56302881f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15907630f, 0.22164023f, 0.21204504f, -0.24329774f, 0.23453595f, -0.47753623f, 0.08201142f, 0.11065247f, 
    -0.11103590f, 0.13565777f, 0.22364645f, -0.30902597f, 0.05649268f, -0.11988768f, 0.04340458f, -0.41148686f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04054467f, 0.01539436f, -0.07942881f, -0.07701020f, -0.04793907f, -0.07278866f, -0.02086740f, -0.08436451f, 
    0.00461226f, -0.09069817f, -0.02623078f, -0.01843524f, 0.05489774f, -0.07237376f, 0.04666974f, -0.03402222f, 
    -0.05080086f, -0.06183454f, -0.08250315f, 0.06342019f, -0.04768880f, -0.08811533f, 0.07594182f, -0.04708951f, 
    -0.07139134f, -0.07483309f, 0.06579013f, -0.04744310f, -0.04390545f, 0.05560459f, 0.00821044f, -0.04156559f, 
    -0.06198272f, 0.02364937f, 0.03833345f, 0.01997447f, 0.01429680f, -0.02395812f, 0.00506535f, 0.05350937f, 
    0.00348603f, 0.03456572f, 0.02285669f, -0.06775147f, -0.04285450f, -0.05584633f, -0.08796907f, 0.05249391f, 
    0.05917328f, -0.02192961f, 0.07124964f, 0.05504514f, 0.05497974f, -0.05418050f, -0.02984606f, -0.04559198f, 
    -0.01949974f, 0.04405881f, -0.01783503f, -0.08822247f, 0.07142571f, -0.02956480f, -0.01133552f, -0.00274226f, 
    -0.01657642f, -0.06582008f, -0.00697694f, -0.06232560f, 0.05819678f, 0.07898989f, -0.03902438f, 0.06030674f, 
    -0.07750966f, -0.03319410f, -0.02690240f, -0.00654138f, -0.07844830f, -0.01463193f, -0.03779000f, -0.07853995f, 
    -0.08726521f, -0.04522545f, -0.01796655f, 0.04011403f, -0.02157586f, 0.03281645f, -0.00818411f, -0.02345113f, 
    -0.06540778f, 0.04017330f, -0.07513496f, -0.01282872f, -0.04160506f, 0.01084589f, 0.07126217f, -0.03662043f, 
    0.04681091f, 0.06707396f, -0.07977387f, 0.02440838f, -0.00277659f, -0.06051142f, -0.08794271f, 0.02691131f, 
    0.07494028f, -0.03632214f, 0.02438250f, -0.01704485f, -0.07650242f, -0.01459935f, -0.02783715f, 0.04072751f, 
    0.01997150f, 0.00871221f, -0.08288188f, 0.05007611f, 0.01385038f, 0.01290593f, 0.05431025f, -0.07938682f, 
    0.00921996f, -0.05947930f, -0.01736039f, -0.03185136f, -0.08115423f, -0.06126571f, 0.01240115f, 0.01448533f, 
    0.05643673f, -0.04782408f, -0.05903947f, 0.02111803f, -0.04978808f, -0.05629077f, 0.06054830f, 0.06224116f, 
    -0.01235358f, -0.00618312f, -0.02519069f, 0.04539976f, 0.00170199f, -0.07650958f, 0.02397981f, -0.07507138f, 
    0.13191365f, -0.00754410f, 0.21732774f, -0.06837399f, -0.14873321f, -0.04804895f, 0.10284433f, 0.10355493f, 
    -0.07399042f, -0.26243863f, -0.21802908f, -0.02960104f, -0.00000157f, -0.04001171f, 0.03885904f, -0.02784377f, 
    -0.08176547f, -0.21973296f, -0.28610015f, 0.21709509f, -0.01943445f, 0.06284049f, 0.01432973f, -0.07358363f, 
    0.04813758f, 0.02837496f, 0.26242182f, 0.25349236f, 0.06161271f, 0.12409136f, -0.12037978f, -0.13448581f, 
    0.06384142f, 0.12381400f, -0.03277327f, 0.00303452f, 0.34910947f, -0.29304945f, -0.31474474f, -0.01162503f, 
    0.06795920f, -0.05553978f, -0.11821997f, -0.07936758f, -0.01327795f, 0.39275709f, -0.09265649f, -0.16917671f, 
    0.10446940f, -0.18312362f, 0.02247045f, -0.14485864f, 0.10860305f, 0.32060480f, 0.17725398f, -0.14570306f, 
    0.26437381f, -0.07177567f, -0.03927896f, -0.03080394f, -0.06838456f, 0.07346710f, 0.02594655f, 0.00997964f, 
    -0.27733594f, -0.31358632f, 0.09614777f, 0.23271218f, 0.17442338f, -0.19302399f, 0.10366979f, -0.19481438f, 
    -0.34218189f, 0.10608023f, -0.31203333f, 0.09648682f, 0.26795277f, 0.05213965f, -0.05482083f, -0.14172770f, 
    0.11890797f, -0.27715248f, -0.28984290f, 0.09827040f, 0.21525362f, 0.12203977f, 0.20874780f, 0.10007961f, 
    0.10959394f, 0.38709071f, -0.10828009f, 0.15751646f, -0.17632781f, -0.00622020f, 0.00141858f, 0.04158219f, 
    -0.09477431f, 0.02556541f, -0.04787220f, -0.16906631f, 0.42296779f, -0.05177170f, 0.02991295f, 0.08879888f, 
    0.13612860f, -0.14250202f, 0.18580441f, -0.09867714f, 0.32601687f, 0.20429461f, 0.04375401f, -0.15508966f, 
    -0.22484569f, 0.09553472f, -0.10510990f, -0.04153164f, 0.08145759f, 0.14856163f, -0.14559029f, -0.06454144f, 
    -0.24703854f, -0.07395755f, 0.21021701f, -0.14522547f, -0.09147137f, 0.07527050f, 0.10829328f, -0.05196646f, 
    -0.22147562f, -0.16328958f, 0.18284069f, 0.08652599f, 0.10836659f, -0.03330276f, -0.06740264f, -0.01839787f, 
    0.22653887f, 0.06939784f, 0.04826923f, 0.17928205f, 0.11663032f, -0.01787656f, 0.08598403f, 0.09638139f, 
    0.26027781f, 0.11709252f, 0.00205226f, -0.07431705f, 0.11940546f, -0.08321135f, -0.04555656f, 0.10176130f, 
    0.03068118f, 0.66640556f, 0.36686897f, 0.14140552f, 0.07391457f, -0.03029571f, 0.16528997f, -0.07108072f, 
    0.07439820f, -0.08464430f, -0.33849576f, -0.19027956f, 0.01095529f, 0.16764235f, -0.03312584f, -0.02645622f, 
    0.02077525f, -0.02369945f, 0.10348680f, -0.46109077f, -0.03736732f, -0.16748884f, 0.10271419f, -0.08133791f, 
    0.05730585f, 0.12305475f, 0.10925671f, 0.04902466f, -0.07580947f, -0.31880909f, 0.15383744f, 0.24394807f, 
    -0.03803177f, -0.03072176f, -0.06081741f, 0.09556486f, -0.17567098f, -0.22060525f, -0.34469795f, 0.02046465f, 
    0.00513719f, -0.08222525f, -0.29931638f, 0.03152172f, 0.06274137f, -0.06524621f, 0.16795722f, 0.11953166f, 
    -0.07761984f, -0.34321371f, -0.11209358f, 0.28189957f, 0.20820437f, 0.15119736f, -0.01784861f, -0.00942101f, 
    0.12367108f, -0.22142179f, -0.05535879f, 0.26628000f, 0.04718476f, 0.01120738f, 0.09952925f, -0.15243098f, 
    -0.17645326f, 0.18277505f, 0.02575788f, 0.06186645f, 0.17560649f, 0.01420421f, -0.20663013f, -0.10309603f, 
    -0.00186645f, -0.24701901f, -0.08108195f, -0.12479422f, -0.01066601f, 0.08278534f, -0.04949038f, 0.03543213f, 
    0.10704605f, 0.27383119f, 0.22347479f, -0.10114076f, 0.11613886f, 0.17314287f, 0.32067996f, 0.00668166f, 
    -0.03671097f, 0.03106898f, -0.10976175f, -0.60093474f, -0.22595358f, -0.01852580f, 0.10137877f, 0.05469498f, 
    0.09508693f, -0.17902626f, -0.02416585f, 0.14978713f, 0.43863350f, 0.09409307f, 0.24191456f, 0.23785301f, 
    0.01439605f, -0.11348528f, -0.08284499f, -0.05161254f, 0.00666186f, -0.39174059f, -0.11331142f, -0.20901632f, 
    -0.16257873f, -0.06794818f, 0.19923648f, -0.02972207f, -0.03855242f, 0.06150201f, -0.71353596f, 0.14471093f, 
    0.04530778f, 0.22905661f, 0.14438307f, -0.14036077f, 0.02713790f, -0.13532327f, 0.13052627f, 0.00984840f, 
    -0.12875788f, -0.11766498f, 0.00720737f, -0.13328287f, 0.09349442f, 0.37531233f, -0.04664411f, 0.11919115f, 
    0.36915785f, 0.21689855f, 0.08530246f, -0.08663250f, -0.05033628f, -0.03000122f, 0.13650988f, -0.06593314f, 
    0.04953432f, -0.12755919f, -0.38447586f, -0.57019198f, -0.00618677f, 0.02324996f, 0.11737254f, -0.00186163f, 
    0.11534334f, 0.12211552f, -0.24291536f, 0.06755672f, -0.05390028f, 0.07854662f, -0.13192749f, -0.00044211f, 
    -0.02377412f, -0.06547794f, 0.05411300f, 0.16992605f, -0.89099097f, -0.15514486f, -0.17379266f, 0.02824044f, 
    -0.15179418f, -0.10371252f, -0.06300266f, 0.03573515f, -0.00234860f, -0.20344779f, 0.34469548f, 0.04788952f, 
    0.20546852f, 0.19541256f, -0.12330037f, 0.04265859f, -0.07725055f, 0.24577253f, -0.61906379f, -0.21308081f, 
    0.05555394f, -0.22162564f, -0.03725999f, 0.11480128f, -0.06227062f, 0.07385681f, -0.05207197f, -0.25592810f, 
    -0.05044409f, 0.13715550f, -0.18842360f, -0.01854394f, 0.00898249f, 0.03856731f, 0.06304014f, 0.18634412f, 
    0.04232326f, 0.05447732f, -0.19962293f, 0.12868783f, 0.03712604f, 0.13375533f, 0.02602584f, -0.01021859f, 
    -0.02645308f, 0.06395357f, -0.14618793f, 0.14730121f, -0.10318722f, -0.01170073f, 0.00659635f, -0.03515151f, 
    0.07922473f, -0.05747142f, 0.08632560f, 0.24846315f, -0.06608517f, -0.09603023f, -0.12103777f, 0.08409020f, 
    0.01961370f, 0.15414964f, -0.27747723f, -0.23779844f, -0.20425232f, -0.08972751f, 0.04496658f, 0.07626861f, 
    -0.01985926f, -0.02596153f, 0.07862609f, 0.11931675f, -0.01373736f, 0.04189616f, 0.01700083f, 0.07214949f, 
    -0.16504735f, 0.01691121f, -0.10583208f, 0.00798466f, 0.06003289f, 0.11261617f, -0.01408544f, 0.13866620f, 
    0.07034066f, -0.16370755f, 0.11563903f, 0.11778428f, 0.02482705f, -0.32348916f, 0.21827765f, -0.16799170f, 
    0.19252937f, 0.05434068f, 0.13097735f, -0.00743019f, 0.12044224f, -0.02209525f, 0.21046312f, 0.02490353f, 
    0.03314307f, -0.05273017f, 0.15110359f, -0.09115356f, -0.13691588f, -0.05112367f, -0.04052771f, 0.05582143f, 
    0.42842042f, 0.02117799f, 0.01897156f, 0.14520173f, 0.02908616f, -0.09257371f, -0.16829205f, 0.02422004f, 
    -0.07231067f, -0.04291079f, -0.07795595f, -0.05832299f, -0.02704666f, -0.05439943f, -0.02117431f, -0.10685727f, 
    -0.04131215f, 0.00969533f, -0.11697301f, 0.01444106f, 0.01327950f, 0.02128421f, -0.01178180f, 0.01678346f, 
    0.04029387f, -0.01589739f, 0.04786496f, -0.10304897f, 0.01772606f, 0.03974262f, -0.00785669f, -0.10792542f, 
    -0.08613344f, 0.01854128f, -0.07634211f, -0.08589362f, -0.09751415f, 0.03385117f, -0.11066255f, -0.02939101f, 
    -0.09837339f, -0.02573722f, -0.06166274f, 0.00920975f, 0.04086688f, -0.05687934f, -0.10655881f, 0.00364334f, 
    -0.03629094f, 0.03885134f, -0.05360003f, 0.00976061f, 0.00795852f, -0.12458281f, -0.04224592f, -0.04574764f, 
    -0.08662003f, -0.10465675f, -0.07639470f, -0.09836733f, 0.04791332f, -0.05051198f, -0.10996543f, 0.01538030f, 
    -0.05768729f, -0.05073910f, -0.04614553f, 0.02977559f, -0.00159273f, 0.03875379f, -0.02941186f, -0.03110432f, 
    -0.09422991f, -0.05595398f, -0.12863451f, -0.00859137f, -0.09638449f, -0.07556401f, -0.09054668f, -0.00415951f, 
    -0.03620628f, 0.03522771f, -0.08278638f, -0.01168444f, -0.04124296f, 0.01586504f, 0.02543524f, -0.01207648f, 
    -0.02095240f, -0.01345301f, -0.03473351f, -0.05175570f, -0.03992300f, -0.03993254f, -0.10125930f, 0.05232017f, 
    -0.08918108f, 0.00128178f, -0.08060122f, -0.11136752f, 0.03225309f, -0.07447621f, 0.04892962f, -0.02364006f, 
    -0.09758304f, -0.04260946f, -0.04910208f, -0.00082872f, -0.00969781f, 0.01733917f, -0.08291026f, -0.02038242f, 
    -0.09466017f, -0.10249060f, -0.05722675f, 0.00274703f, 0.00261341f, 0.01543463f, -0.04112475f, 0.06885920f, 
    -0.01075075f, -0.11000172f, 0.06006880f, -0.03414697f, -0.09113772f, -0.08864129f, -0.08795057f, -0.12315074f, 
    -0.10082988f, 0.04848281f, -0.07836976f, -0.10993797f, -0.04737459f, 0.03139597f, -0.08487344f, -0.00285726f, 
    -0.05410307f, -0.11075485f, 0.03421985f, 0.03767390f, -0.03631199f, -0.04711791f, -0.09046153f, -0.03323334f, 
    -0.07062379f, -0.11700699f, 0.02912472f, -0.03135393f, -0.00270092f, -0.03308974f, 0.05025428f, -0.05170564f, 
    0.12976833f, 0.39379123f, -0.26905832f, 0.19379185f, 0.08486363f, 0.09148820f, -0.00587663f, -0.07607642f, 
    -0.03292949f, 0.00649403f, -0.01918449f, -0.00567361f, 0.12770019f, 0.06548075f, -0.00980923f, -0.01480914f, 
    0.26212308f, 0.11177839f, 0.21678874f, 0.09041908f, -0.11280920f, -0.29008427f, -0.16721228f, -0.00842060f, 
    0.01686640f, 0.17805676f, 0.14531533f, -0.04531134f, 0.22586291f, 0.01377333f, -0.10799565f, -0.05239704f, 
    0.15131538f, -0.06927545f, 0.01450557f, 0.03712390f, -0.36158144f, 0.04094844f, -0.09601285f, 0.09189386f, 
    0.03470987f, 0.02236887f, 0.07611390f, -0.09324736f, -0.03633559f, -0.29676533f, -0.44678676f, -0.02054456f, 
    -0.16419199f, -0.05029910f, -0.24263729f, 0.01365767f, 0.03060636f, 0.15478216f, 0.23532325f, -0.17941365f, 
    -0.02363471f, 0.33362392f, 0.09118352f, 0.17905350f, 0.04930151f, -0.25907326f, 0.06559344f, 0.01224599f, 
    -0.00585240f, 0.07682276f, 0.17759138f, -0.18999082f, -0.03103784f, -0.05779592f, -0.11086387f, 0.11334006f, 
    -0.02042500f, -0.29430759f, -0.07208114f, -0.21101375f, -0.07729981f, 0.25053066f, 0.06396593f, 0.05543100f, 
    0.15654132f, 0.05559659f, 0.10549830f, 0.12399337f, -0.11281603f, 0.01764866f, -0.20004953f, 0.27022260f, 
    0.08997779f, 0.10027102f, -0.28246877f, -0.08457661f, 0.18723120f, 0.19951485f, -0.03430403f, -0.08283947f, 
    -0.06720650f, 0.07255183f, 0.07093980f, 0.15467122f, 0.20504971f, -0.03882489f, -0.41940767f, -0.17856091f, 
    -0.03664681f, -0.13795401f, 0.08936261f, -0.12354264f, 0.23336789f, 0.14057148f, 0.11276588f, 0.00214297f, 
    -0.09725324f, 0.04616256f, -0.06249657f, 0.05632692f, -0.07165096f, 0.00410227f, -0.19457117f, 0.28034532f, 
    -0.14070195f, -0.04258613f, -0.25477389f, -0.00409566f, -0.08300465f, 0.19235544f, -0.38880908f, 0.30450955f, 
    0.22512479f, -0.22828288f, 0.14212033f, 0.08591951f, -0.11203481f, 0.07524592f, 0.05874882f, -0.11011787f, 
    -0.23498218f, -0.45066679f, 0.10419206f, 0.04581369f, -0.00421572f, -0.00550449f, 0.00063534f, -0.08167253f, 
    -0.53890586f, -0.05338459f, 0.44083509f, 0.11389634f, -0.03808432f, -0.06858865f, 0.04336255f, -0.01063827f, 
    0.10207852f, 0.43691704f, 0.10609870f, -0.30778900f, 0.10226783f, 0.15863051f, 0.23748034f, 0.20995170f, 
    -0.03981444f, 0.00164902f, 0.34723300f, 0.16360037f, -0.36413234f, -0.05879211f, 0.07697526f, 0.05971522f, 
    0.02094029f, 0.25321603f, 0.11503724f, 0.00430909f, 0.17936859f, -0.23961912f, 0.18782011f, 0.17403585f, 
    -0.24628538f, 0.07495890f, 0.04446325f, 0.08003476f, 0.02788861f, 0.13458024f, -0.31972486f, 0.22627099f, 
    -0.16747825f, -0.12363669f, -0.16539986f, 0.20113111f, 0.18632571f, -0.38161376f, -0.09417345f, 0.10173455f, 
    0.13921864f, -0.45306665f, 0.10995463f, -0.19988370f, -0.21663782f, -0.30526361f, 0.45485359f, -0.02525537f, 
    -0.01229857f, -0.00915095f, 0.07625885f, 0.17774598f, 0.03159574f, -0.11071960f, 0.04211064f, 0.21081154f, 
    -0.12564765f, 0.11782991f, -0.06499884f, -0.23243943f, 0.09532017f, -0.01832820f, 0.16730660f, 0.02241623f, 
    0.38795328f, 0.22276372f, -0.46345729f, 0.08235800f, 0.25613105f, -0.09986998f, 0.18477389f, 0.07041766f, 
    0.05497199f, -0.29238731f, 0.00303534f, 0.08845159f, 0.17482015f, 0.08611461f, 0.14786589f, 0.20608965f, 
    -0.43659985f, 0.07513596f, 0.03155385f, -0.07262116f, -0.04739306f, 0.07469861f, 0.15690900f, 0.03182654f, 
    -0.00716382f, 0.16123192f, 0.00692625f, 0.36019623f, 0.36815786f, -0.34862334f, 0.11890152f, -0.17576338f, 
    -0.33038703f, 0.16961142f, -0.03847801f, -0.04563601f, -0.17768544f, -0.09376244f, 0.00561814f, 0.10243095f, 
    0.06931236f, 0.26801601f, -0.18088260f, 0.03123489f, 0.14101522f, -0.40125561f, 0.31201482f, -0.22656809f, 
    0.00076517f, -0.21643789f, 0.02762235f, 0.03568008f, -0.00228902f, 0.04962029f, 0.31597665f, 0.11425215f, 
    -0.06188164f, -0.05636016f, 0.18223202f, -0.08240630f, 0.17889127f, 0.19763175f, 0.10444500f, -0.11963741f, 
    -0.63967824f, -0.13693869f, -0.06303382f, 0.10862395f, 0.12642273f, -0.18946329f, -0.04459945f, -0.84005451f, 
    -0.57081372f, -0.26955080f, -0.11802737f, 0.25177181f, 0.08162785f, -0.06470431f, 0.11835022f, -0.03279234f, 
    0.06231214f, 0.21852762f, -0.05711422f, -0.03175094f, -0.15626033f, 0.05666137f, -0.12006383f, -0.02806354f, 
    0.10017004f, 0.15420879f, -0.28535607f, -0.09933767f, 0.31779227f, -0.00092494f, 0.12798308f, 0.16730882f, 
    -0.06041454f, 0.13563052f, -0.04393362f, -0.13008949f, -0.05516168f, -0.07258476f, 0.00672775f, -0.01200981f, 
    -0.32965448f, 0.12787215f, -0.01501162f, -0.00796998f, -0.20811464f, 0.34605968f, -0.12162296f, 0.27608415f, 
    0.17297350f, 0.14067245f, 0.14587745f, -0.22434197f, -0.18860403f, -0.44906276f, -0.10220257f, -0.53316176f, 
    0.02748500f, -0.16431335f, -0.09922521f, -0.19590196f, -0.08372892f, -0.02084510f, -0.92934293f, -0.07250776f, 
    -0.01591929f, 0.32583857f, -0.07553153f, -0.01701817f, 0.01659190f, 0.11439789f, 0.00613825f, -0.13264504f, 
    0.08770005f, 0.17902382f, 0.18308912f, 0.25773364f, -0.02952907f, 0.01306199f, 0.15349233f, 0.16795948f, 
    0.02157287f, 0.15715472f, 0.22348014f, 0.10401182f, 0.17858505f, -0.09748795f, -0.05633744f, -0.03987157f, 
    0.13384373f, -0.11756269f, -0.00326359f, 0.28138149f, 0.23589973f, 0.14784132f, -0.04087878f, 0.16872236f, 
    -0.06587424f, -0.05327343f, -0.30127990f, -0.11522537f, 0.08894446f, 0.23750973f, -0.04397021f, -0.15505350f, 
    0.11728105f, 0.06833730f, 0.01627221f, -0.27442002f, 0.03457582f, 0.51030630f, 0.08239292f, 0.11493969f, 
    -0.05481711f, -0.02281340f, -0.02209002f, 0.09389199f, 0.09113271f, 0.19601440f, -0.17740290f, -0.04463949f, 
    -0.22828425f, 0.09009884f, 0.00118843f, 0.20741624f, -0.20733064f, 0.32179534f, -0.20928830f, -0.32559913f, 
    -0.03618736f, -0.17090309f, 0.07100856f, -0.20572336f, 0.10473952f, 0.16058849f, 0.38793337f, -0.27119464f, 
    -0.15588711f, -0.06676478f, 0.03207576f, 0.06462406f, -0.05464644f, 0.00556563f, -0.06525289f, 0.07205192f, 
    -0.02499707f, -0.20678407f, -0.06118117f, -0.19357109f, 0.13068061f, 0.02880252f, -0.13033462f, -0.34871182f, 
    0.07071831f, -0.10326484f, -0.26298222f, 0.16763747f, 0.19557725f, 0.09755237f, 0.12426669f, 0.15644501f, 
    0.06146864f, 0.02251725f, -0.01911800f, -0.09667192f, -0.11781920f, -0.01775254f, 0.09529602f, 0.12930998f, 
    0.22056410f, 0.25220981f, -0.24564698f, 0.22288959f, 0.42611307f, -0.35363835f, 0.07934894f, -0.02483038f, 
    0.17663705f, 0.10785036f, -0.00050592f, -0.12380780f, -0.42432246f, -0.06160915f, 0.07323644f, 0.01799543f, 
    -0.07874922f, -0.19884086f, -0.08601648f, 0.02714902f, 0.09296828f, 0.12475802f, 0.07626183f, 0.15893166f, 
    0.09124149f, 0.14793241f, 0.14696717f, -0.00420291f, 0.03887638f, -0.30782688f, -0.54777372f, -0.33432406f, 
    0.05295675f, 0.00614282f, 0.01933469f, -0.22180688f, -0.12189230f, 0.14805083f, 0.01302263f, -0.19297022f, 
    -0.03686701f, 0.09634586f, -0.10267565f, 0.10688037f, -0.05804845f, 0.05314218f, 0.00654966f, 0.01187691f, 
    0.43506899f, 0.05267386f, 0.21704127f, 0.15993360f, 0.14359668f, 0.08319736f, 0.21096303f, -0.01979306f, 
    -0.14838681f, 0.37094039f, 0.33410186f, -0.05848675f, -0.25443578f, -0.14090505f, 0.08849907f, 0.07065655f, 
    0.05488756f, 0.06760219f, 0.14446475f, 0.32868618f, -0.07487439f, 0.16655022f, 0.39613461f, 0.35251185f, 
    0.09500542f, 0.26663265f, 0.17552300f, -0.09556703f, 0.06711143f, -0.13339534f, 0.12266195f, -0.13095991f, 
    0.35650426f, -0.05264382f, 0.08409248f, 0.03487005f, 0.20732880f, 0.39724508f, -0.31534517f, 0.06881818f, 
    -0.14728132f, -0.13183250f, -0.11173617f, 0.02011670f, 0.18584743f, -0.05732882f, -0.36844838f, 0.22375081f, 
    0.28716171f, 0.23941696f, 0.21086207f, -0.12785491f, 0.25836328f, -0.21604997f, -0.27505159f, -0.30254009f, 
    -0.16206163f, -0.14080626f, -0.09440177f, -0.06887195f, 0.02467915f, 0.11614949f, 0.18551500f, 0.01201003f, 
    0.20474355f, 0.12059629f, 0.19459040f, 0.02272262f, -0.04872664f, 0.04079749f, -0.17876881f, 0.45191121f, 
    -0.15909639f, -0.04500457f, 0.05331624f, -0.01482873f, 0.09257645f, 0.04625003f, 0.08140617f, -0.38808823f, 
    0.04925553f, 0.13928570f, -0.04971584f, 0.00872530f, -0.02629206f, -0.16590439f, 0.01831038f, 0.11057957f, 
    0.01687019f, 0.45558149f, 0.20853598f, 0.04241237f, -0.09971199f, -0.01231311f, 0.09660899f, 0.07383752f, 
    -0.01294412f, 0.00160214f, -0.35374391f, -0.55022067f, 0.11280152f, 0.11609092f, 0.02140660f, -0.06383383f, 
    0.00962551f, 0.04990928f, -0.08466255f, 0.27031696f, -0.28431213f, -0.00147582f, -0.01190317f, -0.23620380f, 
    -0.04834792f, -0.05399171f, 0.04213772f, 0.02713111f, -0.24075802f, 0.25689235f, -0.12679189f, -0.02866011f, 
    -0.04143373f, -0.13897994f, -0.01714871f, 0.01553167f, -0.09844533f, -0.14134000f, 0.01605508f, -0.40820640f, 
    -0.07374392f, -0.05645612f, -0.07413965f, 0.16430907f, 0.06880581f, 0.09485989f, -0.11219996f, 0.09825537f, 
    -0.02546761f, -0.07068931f, -0.02876822f, 0.03033341f, -0.04803127f, 0.13583831f, -0.04879576f, 0.40669164f, 
    0.04089184f, -0.01448529f, -0.13119587f, -0.04751645f, 0.19519931f, 0.03020764f, -0.11918010f, -0.08003724f, 
    -0.04924093f, -0.43721429f, 0.26650038f, 0.11643855f, 0.07138793f, 0.04900218f, 0.06831373f, 0.02740918f, 
    0.01707811f, -0.63797790f, -0.07301395f, 0.01451333f, -0.10502031f, 0.16429216f, 0.18049084f, 0.08503664f, 
    0.27297726f, 0.04433175f, 0.46401507f, -0.17413563f, -0.03577258f, -0.12462912f, 0.03269261f, -0.03373242f, 
    0.05518606f, 0.12895292f, 0.19245897f, 0.09099155f, -0.54799700f, -0.08366049f, 0.06184572f, 0.00791441f, 
    0.21279964f, 0.05890124f, 0.32529995f, -0.00385585f, -0.10072765f, 0.18431702f, 0.16038172f, -0.01376753f, 
    0.08275390f, -0.03235573f, -0.04025968f, 0.00203907f, 0.13510814f, -0.07954792f, -0.11624573f, 0.04231955f, 
    -0.20543192f, -0.29296252f, 0.06181926f, 0.20892562f, -0.07067434f, 0.05562247f, -0.27669713f, 0.07359041f, 
    -0.14166915f, 0.25777513f, 0.13921779f, 0.01489484f, -0.14502132f, -0.04254049f, 0.05570100f, 0.09137152f, 
    -0.25051770f, -0.00547112f, -0.07799295f, 0.20798343f, 0.12610736f, 0.00589623f, 0.02110163f, -0.13712369f, 
    0.07163703f, -0.03600406f, 0.24889921f, -0.06519908f, -0.09191574f, -0.06228368f, 0.03942115f, 0.00112345f, 
    0.12737799f, 0.41457278f, -0.13585769f, -0.06056858f, 0.13693868f, 0.20581864f, -0.23603371f, 0.11548503f, 
    0.02532276f, 0.02559440f, -0.12285893f, -0.08650388f, 0.12158893f, 0.27608803f, 0.01518649f, -0.06297848f, 
    -0.13322167f, -0.25856277f, -0.12171113f, -0.01941761f, 0.17990929f, 0.18966097f, 0.04866756f, -0.16081044f, 
    0.20529236f, -0.28857616f, 0.06971265f, 0.12575948f, 0.09831028f, -0.07615209f, 0.18591955f, -0.10197406f, 
    -0.17550364f, -0.04582960f, 0.01725005f, -0.03969578f, -0.06919058f, 0.06720998f, -0.11240094f, 0.07223123f, 
    -0.07630384f, 0.10289850f, -0.12510219f, 0.10136437f, 0.09003829f, -0.04302813f, 0.12215686f, -0.03664064f, 
    0.08901923f, -0.13275176f, -0.08257186f, -0.11018115f, -0.03942497f, 0.09074372f, 0.00133307f, -0.11503041f, 
    -0.00769731f, 0.12651910f, 0.16658451f, 0.05840299f, 0.18620154f, -0.06575793f, -0.08032785f, -0.11846559f, 
    -0.11308912f, 0.10245758f, 0.18535602f, 0.19214574f, 0.05086248f, 0.16909978f, -0.13774948f, 0.10568529f, 
    -0.10150156f, -0.40173846f, -0.06720340f, -0.22887307f, 0.01743629f, -0.13882671f, 0.27995986f, 0.12296828f, 
    0.11382163f, -0.29965913f, -0.02179480f, -0.06651933f, 0.10954387f, 0.14303362f, -0.02066438f, 0.08777957f, 
    -0.03515979f, -0.06817646f, 0.26118165f, -0.41431460f, -0.32115826f, 0.33217242f, 0.00285655f, -0.04593354f, 
    0.02321180f, -0.03687776f, -0.12239133f, -0.10380836f, 0.08947887f, -0.15102853f, 0.01663118f, -0.06548745f, 
    0.08585656f, 0.07638903f, 0.02048281f, -0.01083771f, 0.14500266f, 0.31723386f, -0.09757292f, -0.16635787f, 
    -0.16819431f, 0.03660646f, 0.16397870f, 0.23755133f, -0.17097974f, -0.06132257f, 0.05049422f, -0.10040440f, 
    -0.12089802f, -0.02055579f, -0.10587901f, 0.34155336f, -0.07900894f, 0.02237887f, -0.27257195f, -0.07240716f, 
    -0.15170324f, -0.09278172f, 0.01406076f, -0.18893954f, 0.10459295f, -0.01247670f, -0.14714032f, -0.24170075f, 
    -0.24381506f, 0.03052431f, -0.29670599f, 0.11338997f, -0.02702377f, 0.18497862f, 0.10958875f, 0.00821559f, 
    -0.22610678f, -0.02912704f, -0.14035384f, -0.02937970f, 0.00440474f, -0.05300159f, 0.06280565f, -0.17658283f, 
    0.01306384f, 0.02034926f, 0.19309282f, 0.31484073f, -0.18762870f, 0.04572265f, -0.32955256f, 0.18488567f, 
    -0.07931161f, -0.10594288f, -0.07427897f, 0.04713972f, 0.00036003f, 0.07448684f, -0.03957546f, -0.00201826f, 
    -0.12504748f, -0.00480050f, -0.08305307f, -0.09607866f, -0.05609278f, -0.25654954f, 0.34893772f, 0.12556325f, 
    0.30810988f, 0.10484026f, 0.03038877f, -0.08982998f, -0.07566018f, -0.02455706f, 0.02312225f, 0.40570694f, 
    -0.00516892f, -0.10314939f, 0.04760464f, -0.04574498f, -0.06388381f, 0.16556630f, -0.16764536f, -0.20528427f, 
    -0.35593790f, -0.11063756f, 0.22870648f, 0.10069048f, 0.16569573f, 0.15115938f, -0.10162642f, 0.14895128f, 
    -0.13422711f, 0.22738761f, 0.02322571f, 0.01883506f, -0.19155796f, 0.01834674f, 0.23700041f, -0.03019421f, 
    -0.24033898f, -0.08366595f, 0.03296602f, -0.10879402f, 0.00165734f, 0.11938525f, 0.12420033f, -0.01005922f, 
    -0.06836154f, 0.15819842f, 0.29958138f, 0.18141623f, -0.01940772f, 0.01635183f, 0.07160212f, 0.09896868f, 
    -0.01008239f, 0.11635780f, 0.04520250f, 0.10710320f, -0.05202125f, 0.13440335f, -0.00726502f, -0.12293983f, 
    0.02802230f, 0.10577326f, -0.03585773f, 0.16022059f, 0.18382044f, -0.08904982f, -0.02381811f, 0.06976064f, 
    0.17250444f, -0.21243218f, -0.00950414f, 0.06604996f, 0.22295249f, 0.22422883f, -0.14675388f, 0.26773083f, 
    -0.11565542f, -0.18566842f, 0.17354320f, -0.07805416f, 0.02536510f, -0.16792278f, 0.02062635f, -0.20004784f, 
    0.22381420f, -0.15227821f, 0.08423597f, -0.04254473f, 0.04739964f, 0.03607306f, -0.33231205f, 0.02340762f, 
    0.26166478f, 0.23283966f, -0.12572844f, -0.21669963f, 0.00675913f, -0.26555696f, 0.05938910f, -0.10315629f, 
    0.08207475f, 0.09400537f, -0.08651644f, 0.06572530f, 0.09702708f, 0.20551831f, -0.01822513f, 0.06533475f, 
    -0.44637340f, -0.13066320f, 0.45729238f, -0.21164016f, 0.03663525f, -0.04912937f, -0.24856417f, 0.18172359f, 
    0.03757233f, -0.18600751f, 0.07509191f, -0.68025541f, 0.32145050f, -0.04963054f, 0.12665334f, 0.12601995f, 
    0.12208978f, -0.02580653f, -0.05982907f, 0.08743440f, 0.16362740f, 0.12275494f, 0.14156982f, -0.02587146f, 
    0.03358614f, 0.01039876f, -0.28553736f, 0.26794216f, 0.27676675f, -0.41399053f, -0.11010354f, -0.01543459f, 
    -0.10872137f, -0.04947695f, 0.04611041f, 0.07180774f, -0.07274527f, 0.59452230f, 0.06189477f, 0.27374372f, 
    0.10209125f, -0.08211187f, 0.17443880f, -0.13518712f, 0.01673001f, 0.06772309f, 0.12903555f, -0.05135327f, 
    -0.06406879f, -0.18347867f, 0.15631266f, 0.05882587f, -0.04113771f, 0.02703759f, -0.23566991f, -0.28519216f, 
    0.28937128f, -0.07786712f, -0.26939252f, 0.18548599f, -0.24059394f, -0.16946523f, 0.05289204f, -0.02129752f, 
    -0.00174426f, -0.04231830f, -0.07201642f, -0.06910323f, 0.12517314f, 0.14047641f, 0.11024642f, -0.11641048f, 
    -0.35848573f, -0.06388952f, -0.12980273f, 0.16564490f, 0.02823159f, 0.09106302f, 0.09828908f, -0.04387259f, 
    0.17383677f, 0.15029782f, 0.18171450f, -0.04800669f, -0.05522624f, 0.21708614f, -0.20866016f, 0.10413156f, 
    0.02625765f, 0.03730404f, -0.66042149f, 0.12686045f, -0.29130718f, -0.08904965f, -0.09255358f, -0.08225930f, 
    0.23753446f, -0.05736960f, 0.08974634f, 0.13992940f, -0.07055415f, -0.25112364f, 0.18493114f, -0.16895933f, 
    0.11654659f, -0.07492927f, -0.18940356f, 0.05889311f, 0.07468266f, -0.01519945f, 0.03079437f, 0.16929723f, 
    -0.02534141f, -0.01855433f, 0.01089971f, 0.16091405f, -0.09937689f, -0.25912151f, 0.23435611f, 0.32691094f, 
    0.00949572f, -0.02783061f, -0.25110760f, -0.00697451f, 0.01589451f, 0.17024232f, 0.20250876f, 0.08618488f, 
    -0.01711611f, -0.09961672f, -0.08072019f, -0.02589110f, 0.11055554f, -0.02279185f, 0.18502632f, 0.11695798f, 
    0.24248712f, -0.10574885f, 0.05263098f, 0.05883343f, -0.01513976f, 0.08653795f, -0.00220678f, 0.06992299f, 
    0.14633693f, -0.00924315f, 0.28604388f, 0.03402733f, 0.23094386f, 0.10682041f, 0.09256273f, 0.18767883f, 
    0.12792379f, -0.13407668f, 0.16291967f, -0.29996365f, -0.09743011f, 0.00575194f, -0.22243136f, -0.00919942f, 
    0.15449940f, 0.07773805f, -0.16540176f, 0.19305956f, -0.06697235f, 0.02700316f, -0.02315538f, -0.28096533f, 
    -0.11445046f, 0.11412022f, -0.15038198f, -0.42897722f, 0.11461490f, 0.29330054f, 0.11916570f, -0.00675916f, 
    -0.09402864f, -0.05677068f, 0.11526044f, -0.17389175f, 0.03780277f, -0.04415811f, 0.33431983f, 0.09125426f, 
    0.10347736f, 0.08219302f, -0.00053910f, 0.02500636f, -0.08986465f, 0.08737429f, 0.02559549f, 0.16378711f, 
    -0.21800697f, 0.09682064f, -0.04680881f, -0.16600114f, 0.01188150f, -0.09053826f, -0.37894103f, -0.03415385f, 
    0.40700784f, 0.21598031f, 0.01964215f, -0.01507254f, 0.02567760f, -0.00432416f, 0.04041766f, -0.21605921f, 
    -0.13969553f, 0.05894962f, 0.15789130f, -0.01450796f, 0.02143888f, 0.09806927f, -0.01599650f, 0.03710496f, 
    0.24056268f, -0.19084945f, -0.09315832f, -0.11009382f, -0.16367427f, -0.01633071f, 0.00217941f, 0.01908295f, 
    0.09651574f, 0.02592377f, 0.08960093f, -0.08507490f, 0.02517654f, 0.06549122f, 0.19381934f, 0.02218491f, 
    0.07701248f, -0.09830154f, 0.41317490f, 0.18601415f, 0.02120795f, -0.07401598f, 0.04208146f, 0.01825443f, 
    -0.04265075f, -0.00683161f, 0.06622531f, 0.11581617f, 0.07854511f, -0.37634268f, 0.17143680f, -0.08977912f, 
    -0.21854579f, -0.13958281f, -0.09563223f, -0.12791391f, 0.07039601f, -0.03248337f, 0.19191714f, 0.10531434f, 
    -0.06431662f, 0.31172276f, -0.12720636f, 0.03255762f, 0.05539136f, -0.04807695f, -0.09671701f, -0.02913338f, 
    0.05404997f, -0.16309708f, -0.01338174f, 0.02284766f, 0.01057897f, -0.13428773f, 0.26496872f, -0.18809085f, 
    -0.21635571f, -0.00314298f, 0.02685797f, 0.04734134f, -0.07895043f, -0.00723816f, -0.02982899f, -0.14123575f, 
    -0.14077730f, -0.14770742f, 0.19855411f, -0.18397312f, 0.10962985f, -0.08228693f, 0.12535478f, -0.11238158f, 
    0.03344246f, 0.11135925f, -0.08999947f, -0.01162587f, 0.03789337f, 0.16409065f, 0.00011431f, 0.08301651f, 
    0.03222049f, 0.11720292f, -0.11907977f, -0.10856023f, 0.19441707f, 0.16777778f, -0.08520292f, 0.07979321f, 
    -0.03372602f, -0.05400459f, 0.32902056f, -0.03042656f, 0.14874482f, -0.06019456f, -0.09927041f, -0.04705262f, 
    0.15927716f, 0.16206567f, 0.05767380f, 0.10204149f, -0.48732156f, 0.20435941f, -0.09328522f, 0.08170268f, 
    0.04610106f, 0.04296826f, 0.02655709f, 0.11665905f, 0.24761775f, 0.11436037f, -0.38440168f, -0.03343394f, 
    -0.02880063f, -0.00915512f, -0.05116953f, 0.01387545f, 0.02941884f, -0.00298789f, -0.14062949f, 0.20947428f, 
    -0.05844341f, -0.05948265f, 0.02664138f, 0.04926570f, -0.02322677f, 0.08285314f, -0.13324712f, -0.01687994f, 
    -0.22523394f, -0.03318978f, 0.10553182f, -0.03447715f, -0.07707787f, -0.30501986f, -0.10448131f, 0.26238516f, 
    -0.15933248f, -0.20541228f, -0.14136881f, -0.10195632f, -0.03035091f, -0.07639980f, 0.06854361f, -0.03144906f, 
    0.20227671f, -0.14261691f, -0.00193720f, -0.02370998f, -0.02220444f, -0.01571549f, 0.07907326f, -0.16657028f, 
    0.15965074f, -0.01713504f, 0.09485725f, 0.03239229f, 0.04590315f, 0.09271811f, -0.08555185f, 0.07946311f, 
    0.09069975f, 0.10518646f, -0.16689597f, -0.02917646f, -0.17561847f, 0.15592681f, 0.07472848f, -0.06435262f, 
    -0.02190398f, 0.03349770f, 0.08788463f, 0.49959025f, 0.31085086f, -0.05723973f, -0.02481873f, 0.04474686f, 
    0.14700250f, 0.10315625f, -0.03041446f, 0.07113155f, -0.38759342f, -0.19113366f, -0.02123215f, -0.03636994f, 
    -0.11370081f, -0.07659890f, -0.08234715f, 0.01788478f, -0.11860055f, -0.32122687f, -0.10041786f, -0.07416489f, 
    -0.11322621f, 0.08557843f, -0.07194175f, -0.06916023f, -0.10033493f, 0.00966605f, 0.06622657f, -0.00515738f, 
    0.14473170f, 0.11348704f, -0.04457152f, -0.13364971f, 0.09641206f, -0.07260748f, -0.13350016f, -0.58118558f, 
    -0.18232664f, 0.00629935f, -0.12671821f, 0.33886197f, 0.13589925f, 0.02681812f, -0.09459949f, 0.06756034f, 
    0.06315236f, 0.04853898f, 0.00378680f, -0.07514469f, 0.04347669f, 0.01546071f, 0.01399457f, -0.03674286f, 
    -0.08090807f, -0.04198067f, 0.01516974f, -0.00631287f, -0.08621074f, -0.03473511f, -0.04242171f, -0.06773219f, 
    -0.06686947f, 0.04204447f, 0.02860889f, -0.01081637f, 0.05341543f, -0.04757262f, -0.07621697f, 0.01642680f, 
    0.04739640f, -0.08029552f, -0.04766473f, 0.01851059f, 0.03525607f, 0.01852172f, 0.05481757f, 0.05145033f, 
    0.00653262f, -0.03853386f, -0.09349205f, -0.02539720f, 0.04790074f, -0.08278355f, 0.02422622f, -0.07502934f, 
    -0.00025269f, -0.01985312f, 0.05140110f, 0.01933830f, -0.07316072f, -0.01482336f, -0.07362790f, 0.05510208f, 
    0.01122916f, -0.07389943f, 0.00210155f, -0.08298105f, -0.06131503f, -0.07952742f, 0.01444636f, -0.05156849f, 
    -0.05212101f, -0.01538564f, 0.02641585f, -0.04615517f, -0.01664358f, -0.10343027f, -0.07038821f, -0.02448370f, 
    -0.09463397f, 0.02071020f, 0.06267886f, 0.06814605f, 0.04841133f, -0.06892021f, 0.00106198f, -0.08520234f, 
    0.00569288f, -0.00246791f, 0.04583693f, 0.05322557f, -0.09769842f, -0.06057815f, 0.03620986f, -0.04381766f, 
    -0.00667304f, -0.02976146f, 0.05579448f, -0.06361699f, -0.05859486f, -0.05963591f, -0.00190244f, -0.03737419f, 
    0.06372719f, -0.01327249f, 0.06074961f, 0.00107480f, 0.03568521f, -0.02562285f, -0.06632108f, -0.04602401f, 
    0.02422342f, -0.02101378f, 0.04933643f, -0.00016873f, -0.02937260f, 0.05243506f, -0.07596014f, -0.01316137f, 
    -0.08598113f, 0.00995803f, 0.05681272f, 0.06122680f, 0.00683190f, 0.01296155f, 0.03127351f, 0.05996136f, 
    -0.02120216f, -0.03007504f, 0.02144965f, -0.06107128f, 0.02128813f, 0.00219968f, -0.03374956f, -0.05535374f, 
    -0.08671469f, 0.01329354f, 0.06712454f, 0.01810417f, -0.00393488f, -0.00500961f, 0.05158941f, -0.02147699f, 
    -0.07251739f, -0.03457809f, -0.04462888f, 0.04619724f, -0.04827581f, -0.02193270f, 0.06239552f, -0.03192752f, 
    -0.04596299f, 0.02415411f, -0.08357707f, -0.03222932f, 0.05898181f, -0.09653196f, -0.05109594f, 0.04849698f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.07227513f, -0.10518084f, 0.33157191f, 0.18563476f, -0.09589560f, -0.00111620f, 0.30813211f, 0.20304349f, 
    0.26496369f, -0.08001299f, 0.13922596f, 0.06868933f, 0.12821649f, -0.03189899f, 0.03704650f, -0.02647059f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06172267f, -0.12612483f, 0.35976553f, 0.67640930f, -0.18026735f, -0.54717767f, 0.39643446f, -0.21328072f, 
    0.17416705f, -0.12681471f, -0.03244985f, 0.07102472f, -0.39088255f, -0.28214061f, 0.44554991f, 0.13840362f, 
    0.18403813f, -0.10071056f, 0.27089342f, 0.32670736f, -0.13884908f, -0.06041692f, 0.28097352f, -0.21762712f, 
    0.06694090f, -0.22433482f, 0.03895384f, 0.26620248f, 0.48433840f, -0.49715811f, 0.58421254f, 0.12174839f, 
    0.06241033f, -0.53451800f, -0.32353994f, -0.00081802f, 0.01776608f, 0.40561864f, -0.09308429f, 0.43780941f, 
    -0.06714769f, 0.19183277f, -0.33081734f, 0.50216854f, 0.68279850f, -0.04238093f, 0.41193610f, -0.05285291f, 
    -0.02852735f, -0.03452496f, -0.05493924f, -0.25175965f, -0.15615135f, -0.18600316f, -0.21374263f, 0.23339462f, 
    -0.04546134f, -0.21552779f, -0.16031973f, -0.11148871f, -0.01402384f, 0.17508209f, 0.08415088f, -0.19007246f, 
    0.08537383f, 0.08874432f, 0.55314833f, 0.25172704f, -0.17608972f, -0.58479810f, 0.22705182f, 0.09359304f, 
    -0.24600933f, 0.34110513f, 0.23102090f, -0.28512391f, -0.04941490f, 0.33459446f, -0.36217612f, -0.11845957f, 
    0.00824109f, -0.10492229f, 0.03637640f, -0.34521201f, 0.17786615f, -0.11975209f, -0.17401840f, 0.05704449f, 
    -0.17494991f, 0.04637352f, 0.03326454f, 0.32889199f, -0.14376448f, 0.35991275f, 0.18318427f, -0.03421856f, 
    -0.21153983f, -0.07984833f, -0.31390357f, 0.08170874f, 0.15480831f, -0.07564873f, 0.58048952f, -0.56073260f, 
    -0.18429360f, 0.11231202f, 0.03673376f, 0.16092092f, -0.06396954f, 0.45616114f, 0.46161222f, -0.02629029f, 
    0.15925722f, -0.48940498f, 0.46489775f, -0.37055227f, 0.10827245f, -0.14104427f, 0.41242385f, -0.03823705f, 
    0.34768531f, 0.14486775f, 0.03634651f, 0.34263793f, -0.48249134f, 0.02816619f, 0.28753996f, -0.22451788f, 
    0.06721242f, -0.01794083f, 0.24502192f, -0.42649144f, -0.15674610f, 0.03695517f, 0.29694012f, 0.35280272f, 
    -0.04418832f, -0.17058840f, -0.19809474f, -0.20750239f, 0.76925713f, -0.19616665f, -0.35924014f, 0.05156112f, 
    0.13775368f, -0.43595225f, -0.28677720f, -0.86286449f, 0.06235896f, 0.32862675f, 0.42544672f, -0.33834293f, 
    0.21697652f, 0.03251956f, 0.27100113f, -0.19871765f, -0.19846690f, 0.30096126f, 0.11315541f, -0.23278198f, 
    -0.20087233f, -0.05097390f, 0.56036097f, 0.23537925f, -0.04443767f, -0.34024194f, -0.24267784f, 0.19520079f, 
    -0.05336422f, 0.40123260f, 0.19267204f, 0.02723530f, 0.31190920f, -0.23685728f, 0.46348166f, 0.06637087f, 
    -0.04293540f, -0.40273669f, 0.16425283f, -0.57364362f, 0.14337917f, -0.22705330f, 0.28256616f, 0.12998322f, 
    0.27023655f, 0.37252572f, 0.19995539f, -0.37043855f, 0.09934770f, -0.00041933f, -0.13537556f, 0.06220614f, 
    0.05256153f, 0.41225556f, -0.05050702f, -0.09427240f, -0.05436074f, -0.03206793f, -0.01651918f, 0.42875218f, 
    0.22475232f, -0.18292789f, -0.15189958f, -0.06916413f, -0.37564480f, 0.60339350f, -0.52323157f, 0.15639399f, 
    -0.23024759f, -0.25001135f, 0.11654803f, -0.11902416f, -0.05136245f, 0.15460169f, 0.10505554f, -0.08660019f, 
    -0.23087847f, -0.01173926f, -0.29244408f, -0.16477746f, -0.19657218f, -0.00886216f, 0.03339994f, 0.03699616f, 
    0.04882076f, -0.25433490f, -0.16557781f, 0.01515881f, 0.18065776f, -0.31192636f, -0.11291204f, 0.00550682f, 
    0.28565148f, 0.49146724f, 0.50399965f, -0.57733977f, 0.37057650f, 0.25989544f, 0.10603420f, -0.08729281f, 
    -0.17150876f, 0.16658150f, 0.04794765f, -0.08850142f, 0.05062369f, 0.19483034f, 0.07489011f, -0.22918598f, 
    -0.14047766f, 0.16172622f, 0.32912701f, -0.01344972f, -0.17095236f, -0.26771697f, -0.10574988f, -0.03671662f, 
    -0.05842832f, 0.09349751f, 0.32192263f, -0.35392642f, 0.06570575f, -0.16729134f, 0.26380646f, -0.02579999f, 
    -0.27007487f, 0.31221110f, 0.38496155f, -0.07407302f, 0.01913604f, 0.32908213f, -0.03811820f, -0.17872843f, 
    -0.02403814f, 0.34606290f, 0.52415454f, -0.18168534f, 0.16449636f, -0.53249574f, 0.48196718f, -0.26942676f, 
    -0.32544652f, -0.22973728f, 0.09133551f, -0.08487240f, 0.01922689f, 0.06744339f, 0.30018362f, -0.17540656f, 
    -0.05163076f, -0.04647591f, 0.33843446f, 0.28201762f, -0.15159261f, 0.52937609f, 0.20402595f, -0.53416353f, 
    -0.15245929f, 0.01910541f, 0.01478837f, 0.52581012f, -0.03031839f, -0.10462746f, -0.43873033f, 0.22994331f, 
    0.09594008f, -0.36721382f, 0.25402042f, -0.47719330f, 0.10412224f, 0.10985708f, 0.47702783f, -0.03394285f, 
    0.32395017f, 0.35177290f, -0.07777823f, 0.07739979f, 0.22652546f, 0.03430495f, -0.24827255f, 0.13493015f, 
    0.16077971f, -0.36812699f, -0.09015123f, 0.88310558f, 0.01144943f, 0.11003275f, -0.08629314f, -0.26776612f, 
    0.34044790f, -0.22555605f, 0.10845252f, -0.26156938f, 0.01290238f, 0.27168098f, -0.00771859f, 0.04695058f, 
    0.11238846f, -0.14557545f, -0.32319045f, -0.08520344f, -0.04875035f, -0.19154157f, 0.12699853f, 0.46569070f, 
    0.29814097f, -0.67488736f, -0.13834341f, 0.12176818f, -0.18960463f, 0.43405786f, 0.55267888f, 0.24328502f, 
    -0.07900876f, 0.19957542f, 0.38855940f, -0.46511033f, -0.00088180f, 0.23636027f, -0.04807236f, 0.10377952f, 
    0.22416045f, -0.14390227f, -0.26530516f, 0.62052840f, -0.53625697f, 0.31788462f, 0.05305755f, 0.06539845f, 
    -0.24319980f, 0.52692008f, -0.15749927f, 0.11490934f, 0.27350545f, 0.28530660f, 0.49590266f, -0.13096455f, 
    -0.33852836f, -0.37743002f, 0.08103877f, -0.21297987f, 0.21016392f, 0.44038782f, -0.32028514f, -0.07000578f, 
    -0.20449889f, -0.42947176f, 0.46490601f, -0.10929465f, 0.10476795f, 0.40610334f, -0.15475084f, -0.14284052f, 
    0.13532536f, 0.25044036f, 0.10443097f, -0.52043480f, 0.02398361f, 0.49418530f, -0.61181891f, -0.01602240f, 
    0.24804430f, 0.23196477f, 0.36092320f, 0.69495559f, 0.20502265f, 0.15492454f, -0.17198105f, -0.27580234f, 
    0.16617793f, 0.00266645f, -0.31844515f, 0.32912543f, -0.09840105f, -0.40051222f, 0.51507992f, 0.02457876f, 
    -0.13803986f, -0.06129834f, -0.22774678f, -0.17937125f, -0.03034136f, -0.06417092f, 0.06087198f, -0.13175473f, 
    -0.04371426f, -0.22037593f, 0.17020640f, -0.23502624f, -0.02434764f, 0.02689867f, 0.02791226f, 0.01837733f, 
    0.22593093f, -0.00808491f, -0.01466566f, -0.18804626f, 0.04492483f, -0.11786669f, -0.04158739f, 0.09602124f, 
    -0.15064424f, -0.13855997f, 0.17387435f, -0.16982166f, -0.09634621f, 0.05664586f, -0.05994534f, -0.14178719f, 
    -0.01278243f, 0.49223489f, -0.18127099f, 0.01526699f, 0.03052302f, -0.43174890f, 0.09885378f, 0.04929378f, 
    -0.01181956f, 0.40938053f, 0.50222176f, -0.29806781f, 0.04469483f, 0.43923098f, -0.36556450f, 0.17404538f, 
    0.12755865f, -0.22118834f, 0.06692049f, 0.15735865f, 0.19983837f, -0.06341839f, -0.21705312f, -0.21238741f, 
    0.00338009f, -0.08189145f, -0.03834966f, -0.05074629f, -0.10026479f, -0.22090083f, -0.22870702f, -0.16958740f, 
    -0.07190359f, 0.09250438f, -0.25113338f, 0.60561353f, 0.13774990f, 0.39029595f, -0.05775778f, 0.56069970f, 
    0.13832934f, -0.55941141f, -0.18098952f, -0.17226119f, 0.62643194f, 0.30226597f, -0.08653179f, -0.02197081f, 
    0.07820354f, 0.04321459f, -0.45112303f, 0.49070016f, -0.04765049f, 0.11445967f, 0.42387426f, 0.17778844f, 
    0.23313454f, 0.15122561f, 0.10095033f, 0.12509848f, 0.32534704f, -0.27832755f, 0.33490065f, -0.19633399f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.34228852f, 0.36429894f, 0.15340240f, -0.02455207f, 0.13950656f, 0.15393949f, -0.01034833f, 0.69019145f, 
    0.34527194f, 0.04271920f, -0.08233213f, 0.58268958f, -0.18964067f, -0.01104391f, -0.16996676f, -0.15251851f, 
    -0.32350507f, -0.06349209f, -0.00148484f, 0.61436009f, -0.12499508f, 0.27771407f, 0.51695228f, 0.27883792f, 
    0.17194064f, 0.22499496f, -0.20892979f, -0.00049202f, -0.18293431f, -0.12338474f, 0.13599250f, -0.14471973f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00123680f, -0.09126541f, 0.01343497f, 0.03493617f, -0.14093177f, -0.07355779f, -0.00079526f, -0.04438015f, 
    0.02560887f, -0.12506594f, 0.11749617f, -0.08719166f, 0.08734135f, -0.13123213f, -0.15743349f, -0.15047757f, 
    0.16652547f, 0.03570741f, 0.05239156f, -0.01890326f, 0.14434594f, -0.02144914f, 0.12105784f, 0.09475561f, 
    0.12625465f, 0.00282153f, -0.16819845f, 0.01132549f, -0.15056048f, 0.09343695f, -0.04730213f, -0.22570370f, 
    -0.13700114f, -0.21379809f, -0.10283305f, -0.10084897f, 0.77866143f, -0.05431464f, 0.56535965f, 0.21218425f, 
    0.04364327f, 0.21560292f, 0.23704040f, 0.27911350f, -0.10192775f, -0.05936198f, 0.34953532f, 0.15006123f, 
    0.75962764f, 0.17507385f, 0.52023071f, 0.24468808f, -0.26083568f, -0.65489310f, -0.10699017f, -0.05088221f, 
    0.64988238f, -0.20207863f, 0.15418595f, -0.05959276f, 0.63663161f, -0.09660944f, -0.38776207f, -0.03623746f, 
    -0.15235223f, -0.12073631f, 0.86943698f, -0.12420014f, -0.66659194f, -0.16915862f, -0.28857660f, 0.35599548f, 
    0.30366191f, 0.19040400f, -0.51936078f, 0.14496475f, 0.21687934f, -0.07404349f, -0.20051812f, -0.19274519f, 
    -0.27874866f, -1.03926575f, 0.46006912f, 0.21039662f, -0.29574135f, 0.21099499f, 0.39805448f, 0.31921828f, 
    0.30794567f, 0.11674476f, 0.02034834f, 0.11060657f, -0.43202120f, 0.11833376f, 0.37688994f, 0.14319488f, 
    0.13419214f, 0.65441102f, -0.23357511f, -0.04108546f, -0.32227975f, -0.48964578f, -0.09531403f, 0.12732804f, 
    0.69655377f, 0.29614261f, -0.17639615f, 0.09614246f, -0.36459002f, -0.05030550f, 0.13841328f, -0.18390468f, 
    -0.22119243f, -0.11781815f, 0.23200460f, 0.29450238f, -0.26951051f, -0.14038870f, -0.06694410f, 0.54444659f, 
    -0.03908378f, 0.06995602f, 0.10940243f, -0.05724809f, -0.27349898f, -0.13596305f, 0.25772461f, 0.16830841f, 
    0.00994406f, 0.01518678f, -0.14834678f, 0.08043590f, 0.01425892f, 0.01214736f, 0.14325488f, -0.22670209f, 
    0.10210500f, -0.20751922f, -0.12466903f, -0.07931912f, -0.01944868f, -0.10120583f, -0.06350023f, 0.17513639f, 
    -0.24285877f, 0.09009741f, -0.10415459f, -0.07842042f, -0.00523213f, 0.09843016f, -0.05711712f, 0.20433764f, 
    0.09482464f, -0.09583600f, -0.07345071f, 0.00518124f, 0.08589787f, 0.12191005f, 0.22569807f, -0.08683141f, 
    0.16901247f, 0.51227915f, 0.19667710f, -0.00319754f, -0.30217630f, -0.11726534f, 0.69313490f, -0.07024880f, 
    -0.03989653f, 0.60588509f, -0.54917800f, 0.11292278f, -0.48472276f, -0.13613243f, -0.14797534f, -0.11122165f, 
    0.02458330f, -0.27849415f, 0.03583271f, 0.08374745f, 0.08068278f, 0.15050022f, -0.15911165f, 0.10220101f, 
    -0.43171245f, 0.09096765f, 0.02597104f, 0.10890111f, -0.42674693f, -0.00140349f, 0.10943349f, 0.14483611f, 
    0.33743128f, -0.09057690f, -0.61971635f, -0.02217891f, 0.09499675f, 0.06913438f, 0.25141340f, 0.09316646f, 
    -0.28814000f, 0.68586344f, -0.09534366f, 0.31197274f, 0.00018768f, -0.15629719f, 0.58648527f, -0.10128600f, 
    0.18447089f, -0.40193513f, -0.09254984f, -0.02597382f, 0.64359313f, -0.06379868f, 0.05623858f, -0.47280768f, 
    0.21448435f, 0.18967322f, 0.00182620f, 0.09197430f, 0.54587710f, 0.03004362f, -0.18400705f, -0.02111085f, 
    0.02478020f, 0.36385277f, 0.88900387f, -0.01270409f, -0.35057467f, -0.17569673f, 0.16787578f, 0.17000458f, 
    0.55127448f, 0.04660112f, -0.19354132f, 0.11179542f, -0.25290987f, 0.16117868f, -0.17468728f, 0.05211788f, 
    -0.29866120f, -0.09828225f, 0.18253838f, 0.26978871f, -0.29465303f, 0.48723519f, 0.07899687f, -0.05048800f, 
    -0.09793301f, 0.21874431f, -0.13396782f, 0.09512510f, -0.52777725f, -0.09926023f, 0.34733719f, 0.27833235f, 
    0.13254760f, 0.03099926f, -0.10656504f, -0.15438594f, -0.06072193f, 0.13836743f, -0.11294787f, -0.11399209f, 
    0.07078168f, 0.13996525f, -0.03061053f, -0.13127372f, -0.12038688f, -0.17354277f, 0.11997659f, 0.04457410f, 
    0.08188243f, 0.01584928f, 0.07299917f, -0.19606364f, -0.07703473f, -0.03086476f, 0.07807601f, -0.18109313f, 
    0.10118336f, -0.06816954f, -0.15356718f, -0.16043425f, 0.03454947f, -0.12594700f, 0.01934019f, -0.04959175f, 
    0.29060727f, -0.14103252f, -0.24158357f, -0.02933413f, 0.00523009f, 0.02934677f, -0.51169747f, 0.05642387f, 
    0.22794507f, 0.30560103f, -0.52910858f, 0.26910061f, 0.58885235f, 0.06171263f, -0.11814962f, -0.24788778f, 
    0.06406213f, -0.56049436f, -0.30592057f, 0.03632896f, -0.22032474f, 0.68835139f, 0.18530427f, 0.43107978f, 
    0.31910378f, -0.52531570f, -0.12122876f, 0.08212183f, 0.11254340f, 0.10785010f, 0.14798880f, 0.01783285f, 
    0.04848757f, -0.07830581f, 0.09076437f, -0.15590258f, 0.08980273f, -0.06657733f, -0.15234555f, -0.14435466f, 
    -0.05372235f, 0.03020603f, 0.11844794f, 0.00360935f, -0.04241697f, 0.15062706f, 0.09572007f, 0.11227166f, 
    -0.11908112f, -0.01437132f, 0.02075521f, 0.07168854f, -0.16632636f, -0.15344396f, -0.07841206f, -0.04777054f, 
    -0.07313294f, -0.13561568f, -0.08240253f, 0.04868673f, -0.00631825f, 0.02045631f, -0.10971159f, -0.11584643f, 
    0.06872641f, 0.13494702f, -0.10881882f, 0.03813286f, -0.05582897f, 0.07767759f, 0.03216520f, -0.12594114f, 
    -0.10835996f, 0.09069968f, -0.18073611f, -0.05436659f, -0.12031720f, 0.12477064f, 0.05104142f, 0.00860434f, 
    -0.18873157f, 0.13672820f, 0.15363993f, -0.17379515f, -0.09527796f, 0.05912665f, 0.01464161f, -0.09715664f, 
    0.03953277f, 0.02585636f, 0.08901618f, -0.12870766f, 0.12847947f, -0.11754137f, -0.18320897f, -0.02341186f, 
    -0.13106556f, -0.17779531f, 0.02489900f, -0.06993468f, -0.30969766f, -0.24185687f, -0.08783320f, -0.09935320f, 
    -0.00878395f, 0.44046238f, -0.57548839f, -0.07601085f, 0.08105706f, -0.11477850f, -0.04243300f, -0.18202288f, 
    -0.32300267f, -1.07649779f, 0.43485337f, 0.01754571f, 0.48107553f, -0.23272862f, 0.08586864f, 0.24470453f, 
    0.34804481f, -0.02946630f, -0.11417978f, 0.09837250f, -0.25005051f, -0.16530381f, -0.03349616f, -0.02143305f, 
    -0.52630341f, -0.19569397f, 0.53406322f, -0.03040994f, 0.30865523f, 0.04736312f, -0.19650619f, -0.12622353f, 
    0.47790533f, 0.09572878f, 0.13112290f, 0.29284754f, 0.05107348f, 0.10462474f, 0.70468348f, -0.08470789f, 
    0.01845396f, -0.46366987f, -0.66954267f, 0.23418018f, -0.05043042f, 0.17735472f, -0.34093216f, 0.36826360f, 
    0.40058205f, -0.52272451f, -0.06177447f, 0.15969434f, 0.36613932f, 0.17497252f, 0.53448272f, 0.19426291f, 
    0.53853303f, -0.09752675f, -0.18179084f, 0.01475240f, -0.30671737f, -0.12755850f, -0.61922520f, 0.41093200f, 
    -0.28851336f, 0.33540586f, -0.19877277f, 0.32503423f, 0.25155899f, -0.15952930f, 0.28709978f, 0.16635956f, 
    -0.41060409f, -1.02349663f, -0.06815273f, 0.32215053f, 0.30216730f, 0.47640258f, 0.22675169f, -0.56723517f, 
    0.30143267f, -0.10262084f, 0.00813325f, 0.11370381f, -0.25875929f, 0.04913756f, -0.20649712f, -0.00352672f, 
    0.13394107f, -0.05636127f, -0.12189598f, -0.01724894f, 0.09121903f, 0.05590661f, 0.32025442f, 0.31140113f, 
    -0.10433767f, 0.56054515f, 0.22504185f, 0.39302289f, -0.15140337f, 0.07062351f, -0.00503327f, 0.16489945f, 
    0.34815261f, 0.58219630f, 0.25035918f, 0.30798629f, -0.41557819f, -0.22436097f, 0.38969061f, -0.59991860f, 
    0.12278946f, -0.09242330f, -0.10326675f, 0.09686031f, 0.05834829f, 0.08396032f, -0.67980862f, 0.00338544f, 
    -0.03235032f, -0.12186844f, -0.18483865f, -0.01137248f, 0.04367248f, 0.33578223f, 0.00373023f, -0.17751148f, 
    -0.14523974f, 0.13175319f, -0.09593792f, -0.04209791f, 0.15134473f, 0.07166559f, 0.03148147f, 0.11093272f, 
    0.14343545f, -0.03550997f, 0.05804881f, -0.17151080f, 0.03816305f, -0.03636807f, -0.07129531f, -0.00733556f, 
    -0.08032297f, -0.22044605f, -0.08567102f, -0.01209077f, 0.00717053f, -0.04545776f, -0.15605170f, -0.12113596f, 
    0.12949947f, -0.06406303f, 0.05242663f, -0.14543520f, -0.09657399f, 0.00388040f, 0.00977148f, -0.00912104f, 
    -0.15928426f, 0.08363803f, 0.02601391f, -0.15218468f, -0.15383314f, -0.04333136f, -0.12302659f, -0.00003764f, 
    -0.09629148f, 0.12672280f, 0.09447323f, -0.07495227f, -0.14318019f, 0.12183359f, -0.11640573f, 0.03207573f, 
    -0.04273065f, 0.10342811f, -0.06735018f, 0.10803710f, 0.01114617f, 0.15311971f, -0.20655945f, -0.06486878f, 
    0.11473323f, -0.16306433f, -0.31182376f, 0.14600880f, 0.21875629f, 0.07810584f, -0.07460419f, 0.18763058f, 
    -0.18695797f, -0.11914015f, -0.22443049f, -0.28976458f, 0.58796322f, 0.14085500f, -0.19424991f, -0.21628922f, 
    0.06312977f, -0.24754271f, -0.17350154f, -0.12170570f, 0.51975387f, 0.71054500f, 0.23537900f, 0.38918394f, 
    0.05065026f, -0.07537191f, 0.00392682f, 0.16526751f, -0.07664493f, 0.13913327f, 0.52021086f, 0.00591570f, 
    0.08507351f, 0.06118785f, 0.54473931f, -0.11486333f, 0.25553125f, -0.10221086f, -0.04276960f, -0.00261218f, 
    0.33133906f, -0.30790916f, -0.03150408f, -0.12052273f, -0.18146925f, -0.01031045f, -0.56779152f, -0.01050164f, 
    0.27982304f, 0.39194888f, 0.31202504f, 0.04551208f, 0.32007983f, -0.09790082f, -0.07373992f, 0.48547876f, 
    0.43947354f, 0.27701345f, -0.15886201f, 0.12848717f, -0.34335849f, 0.10294403f, 0.31456199f, -0.22306791f, 
    0.11141624f, -0.24881455f, -0.48134866f, 0.00794198f, 0.77094686f, -0.14730300f, 0.24456024f, -0.04898321f, 
    0.10959975f, -0.11515611f, 0.10166313f, 0.03582818f, 0.24110660f, -0.01668162f, 0.26364675f, -0.06504821f, 
    0.37824771f, 0.46471435f, 0.29000220f, 0.06618515f, 0.25568873f, -0.39698517f, -0.08805508f, 0.82583070f, 
    0.42312524f, -0.11918645f, -0.09234233f, -0.13847539f, 0.62925857f, -0.15855281f, -0.03710674f, 0.04249992f, 
    0.22858068f, -0.02713478f, -0.09733140f, 0.11451491f, 0.45702404f, -0.03397866f, -0.59704405f, 0.15147406f, 
    0.34854001f, -0.26943651f, 0.05792334f, 0.41150546f, 0.19208582f, 0.05557282f, -0.29619607f, 0.01761318f, 
    0.06803801f, 0.32269910f, -0.38499850f, 0.15869209f, -0.27167481f, 0.33479217f, 0.12307636f, 0.16993625f, 
    0.28823370f, -0.10135499f, -0.19583227f, 0.14224312f, -0.12747994f, -0.08298748f, -0.24282761f, -0.22227263f, 
    -0.39224762f, -0.33123040f, -0.23519400f, -0.00302965f, -0.35950381f, 0.22119719f, 0.39812630f, -0.06237142f, 
    -0.23993851f, 0.41730365f, -0.34763369f, -0.25857118f, 0.72581291f, -0.13547371f, -0.20211069f, -0.15205464f, 
    -0.03865995f, -0.29228771f, 0.19803263f, 0.15092161f, -0.14749104f, 0.32294810f, 0.27782476f, 0.96316439f, 
    -0.17003457f, 0.06781792f, -0.10472832f, 0.04010111f, 0.25855583f, 0.09133036f, 0.17792314f, 0.16174661f, 
    -0.03492228f, 0.16323400f, 0.14292309f, -0.07689214f, -0.10306116f, -0.01833097f, 0.03610435f, -0.13987161f, 
    -0.17050244f, 0.03829597f, -0.02403111f, 0.08893926f, -0.04523596f, -0.01916070f, -0.03416379f, -0.00617751f, 
    -0.04434965f, 0.11397841f, -0.11687884f, -0.11286252f, 0.01692780f, 0.17249256f, -0.09954776f, -0.04365519f, 
    -0.01325893f, -0.08992941f, -0.16698383f, 0.16474065f, 0.16072050f, -0.07382313f, -0.02192957f, -0.14181069f, 
    -0.03822189f, 0.05923522f, 0.02316365f, 0.14177689f, -0.05079805f, 0.09441530f, -0.20697986f, -0.20160678f, 
    0.10907249f, -0.09164877f, -0.01558233f, 0.12897381f, 0.13023320f, 0.10897472f, 0.01352210f, 0.06875655f, 
    0.13024715f, 0.01797872f, 0.07401560f, -0.05264701f, 0.03175716f, -0.03408282f, -0.04279874f, 0.01496531f, 
    -0.23355456f, -0.08801110f, 0.06330814f, 0.02167424f, 0.00305567f, -0.02105775f, -0.05104166f, -0.05024656f, 
    0.31041986f, 0.06508288f, 0.12891231f, 0.08900316f, 0.13360138f, 0.06511507f, 0.49327704f, 0.22404535f, 
    0.04078607f, 0.25893348f, 0.31440651f, 0.16560832f, -0.41903487f, 0.16530778f, 0.44359696f, 0.10409815f, 
    0.23705895f, -0.12906970f, -0.12747255f, -0.07499899f, 0.16500792f, 0.12150868f, -0.30655029f, -0.28313875f, 
    -0.18379089f, -0.12323244f, 0.21344522f, -0.00667577f, 0.01155266f, -0.16560540f, 0.17663662f, 0.13342586f, 
    0.05232073f, -0.09404345f, -0.32912737f, -0.10752168f, 0.00352098f, -0.26368031f, 0.02942366f, -0.10162924f, 
    -0.18626724f, 0.00859577f, -0.07028348f, -0.29331174f, 0.07270228f, -0.00447764f, -0.37428260f, 0.04570112f, 
    -0.12859119f, -0.12982027f, 0.05718768f, -0.24873769f, 0.16891403f, 0.24843267f, 0.23825197f, 0.21762928f, 
    -1.10113525f, 0.13614695f, -0.02993303f, 0.16129093f, 0.05556189f, 0.09621413f, 0.08232577f, 0.16747205f, 
    0.95063114f, 0.61554819f, -0.30007955f, -0.16066854f, 0.09876676f, -0.12763159f, 0.14702149f, 0.15325415f, 
    -0.22595094f, -0.21715537f, 0.40114146f, -0.03496879f, -0.33106077f, 0.02262664f, 0.17179416f, 0.04898778f, 
    -0.20737937f, 0.12711439f, 0.33551741f, 0.18514232f, 0.65461755f, -0.05787404f, 0.03764991f, -0.45742711f, 
    -0.24952613f, 0.68228269f, -0.08969376f, -0.16465607f, -0.15434542f, 0.00314574f, -0.29671204f, 0.25334722f, 
    0.41065997f, 0.12633795f, -0.17964782f, -0.12038785f, 0.29147121f, 0.20273435f, 0.81621814f, -0.00955661f, 
    -0.00128066f, 0.03142393f, -0.33731148f, -0.20586583f, -0.02334266f, -0.11709581f, -0.29418749f, 0.18060955f, 
    0.15252443f, 0.74775845f, 0.01035265f, -0.06819187f, -0.50723988f, 0.29489025f, -0.18489143f, 0.66841495f, 
    -0.75478840f, -0.09037293f, 0.03563834f, 0.04643692f, 0.48732349f, -0.12805167f, -0.09233433f, 0.22063966f, 
    0.24849734f, 0.36634406f, 0.62461567f, -0.03969561f, 0.11211852f, 0.01055768f, 0.16408573f, -0.15942685f, 
    -0.15342779f, -0.49624145f, 0.34429076f, -0.40939370f, -0.02906417f, 0.07335446f, -0.31122315f, -0.00135882f, 
    -0.35404006f, 0.63123637f, 0.13995548f, 0.09832276f, 0.36220294f, 0.27888343f, 0.10078643f, 0.03871193f, 
    -0.14236023f, 0.46575883f, 0.11002014f, 0.09001629f, -0.38474786f, 0.14110801f, 0.41806135f, 0.22416383f, 
    0.49719959f, 0.15716986f, -0.04208744f, 0.14258669f, 0.20106590f, 0.06034683f, -0.01342122f, 0.22518250f, 
    -0.04177076f, -0.54482889f, 0.29432651f, -0.15132317f, 0.04740250f, -0.02809079f, -0.54865324f, -0.02091563f, 
    0.03459926f, 0.75321281f, 0.43977574f, 0.02592333f, -0.46734157f, -0.17111117f, 0.30242220f, 0.37859684f, 
    -0.46765882f, 0.36662886f, -0.22191803f, -0.09090950f, -0.13738014f, -0.15565486f, -0.15019238f, 0.07997428f, 
    -0.04647663f, -0.16264826f, 0.07584883f, 0.10037643f, 0.04891955f, 0.09913464f, 0.08571822f, 0.02998581f, 
    -0.17925358f, -0.18301846f, 0.08533696f, 0.11556868f, -0.05515301f, 0.00586712f, 0.02110948f, -0.10895430f, 
    -0.01824249f, -0.02147982f, -0.14798233f, -0.02846119f, 0.12410194f, -0.14493248f, -0.11098868f, -0.05148716f, 
    -0.11896715f, 0.02492617f, -0.14545874f, 0.08247282f, -0.16952001f, 0.09618665f, 0.04725982f, -0.17710654f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06184188f, -0.00210876f, 0.43422624f, 0.33266371f, 0.11004884f, 0.25408593f, -0.03473508f, 0.38084748f, 
    -0.01320628f, 0.36273634f, -0.13047364f, 0.01704993f, 0.08121659f, 0.01310833f, 0.17357397f, 0.11530955f, 
    -0.03457424f, 0.04042587f, -0.14286764f, 0.11048113f, -0.04968860f, 0.51374084f, -0.02344723f, -0.16934489f, 
    -0.05385434f, -0.25965807f, -0.13285293f, 0.31361783f, 0.20755669f, -0.28224418f, 0.29630747f, 0.06425347f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.02188613f, -0.13072218f, 0.30911765f, 0.19083792f, 0.01086009f, 0.25922352f, 0.16546489f, 0.01491206f, 
    0.03734310f, -0.05679728f, -0.04308352f, 0.14151871f, 0.71198571f, -0.37759930f, 0.02935013f, 0.02629179f, 
    -0.13273188f, -0.05697270f, -0.07484487f, 0.13187836f, -0.12146433f, -0.77750963f, 0.41554153f, -0.08891860f, 
    -0.00725342f, -0.36048833f, -0.06917800f, 0.04319686f, -0.94113123f, -0.10146343f, -0.13531493f, 0.05842379f, 
    -0.19722350f, -0.09875594f, -0.00334553f, -0.03834801f, 0.07479846f, 0.23437703f, -0.12577304f, 0.11493222f, 
    -0.10925128f, -0.16820051f, -0.09875881f, -0.00640323f, -0.30034268f, -0.32515460f, 0.13305645f, -0.51362938f, 
    0.02882819f, -0.17678630f, 0.28881019f, 0.39424777f, -0.12572826f, -0.11690269f, -0.28162074f, 0.00947391f, 
    0.14777540f, 0.13138576f, 0.20349148f, 0.28795040f, -0.67934352f, 0.35469565f, -0.04917097f, -0.06219680f, 
    -0.09394746f, -0.67224920f, -0.36152038f, 0.05926808f, 0.27113950f, -0.27195442f, -0.45220587f, -0.25804800f, 
    0.01017090f, -0.22791763f, 0.09664057f, -0.05874285f, -0.24392700f, -0.31838396f, -0.86541766f, -0.47851571f, 
    0.05091975f, -0.06616747f, 0.41628599f, -0.18279032f, 0.41062379f, -0.09917358f, 0.42954680f, 0.00900044f, 
    -0.01443330f, -0.33792201f, 0.34713537f, 0.08068764f, 0.56192410f, 0.24679150f, 0.45869598f, -0.04216550f, 
    -0.12761009f, 0.41859341f, -0.80028486f, -0.29527426f, -0.12705423f, -0.25195789f, 0.39573976f, -0.68597800f, 
    -0.17425625f, -0.24709705f, 0.15702040f, 0.13714954f, 0.23441748f, -0.01115236f, 0.15763225f, 0.25354454f, 
    0.03659884f, -0.05405558f, -1.04786813f, -0.28026590f, 0.09935685f, -0.12371580f, -0.68767643f, -0.13373628f, 
    -0.11005317f, 0.34349465f, -0.04967652f, 0.23963138f, -0.45304880f, -0.61442000f, -0.12310028f, -0.04859173f, 
    -0.12231176f, -0.15815996f, -0.12580507f, -0.02049168f, -0.20307840f, -0.36135316f, 0.08728106f, -0.21351114f, 
    -0.16224110f, 0.43094271f, 0.00435339f, 0.08424002f, 0.38682720f, 0.45736539f, 0.17275712f, -0.29135579f, 
    -0.04767365f, 0.06016539f, 0.15151633f, -0.32860452f, 0.14995898f, 0.43376830f, -0.06333830f, -0.10136652f, 
    -0.12308821f, -0.04287422f, 0.12962885f, -0.05472054f, 0.07344241f, -0.36646783f, -0.31645852f, -0.08823431f, 
    0.18168300f, -0.39971498f, 0.43161434f, -0.14025837f, -0.13700165f, -0.25162834f, -0.26379374f, 0.08916069f, 
    -0.06502090f, -0.00441798f, 0.09282295f, -0.10864899f, -0.21636726f, -0.14476661f, 0.27174112f, 0.16079964f, 
    0.00089540f, -0.00572885f, -0.01730814f, -0.05595320f, -0.61705691f, 0.21898861f, 0.08663879f, 0.10339601f, 
    0.07211570f, -0.51364213f, -0.69121069f, 0.06979370f, -0.01857760f, 0.10095968f, 0.27391809f, -0.16071637f, 
    -0.02939007f, -0.57734370f, 0.04700551f, 0.26504871f, -0.11106115f, 0.19731408f, 0.20039341f, 0.14509484f, 
    0.08015928f, 0.08460616f, -0.05010268f, -0.03860037f, -0.52288240f, -0.17670546f, 0.38362396f, 0.21572664f, 
    -0.02879751f, 0.00112923f, -0.03582519f, -0.66436118f, -1.16686046f, -0.02819183f, -0.03807144f, 0.00131913f, 
    -0.06098097f, 0.27576816f, 0.24524941f, 0.18421882f, -0.47779649f, -0.14806204f, -0.18580754f, -0.06502799f, 
    -0.01525308f, 0.20807946f, -0.63704532f, -1.14070308f, -0.17077877f, -0.72962081f, 0.27571350f, -1.00240874f, 
    -0.02682537f, 0.30698329f, 0.08578854f, 0.07691986f, 0.50835061f, 0.29014224f, -0.10839517f, 0.07215900f, 
    0.19710928f, -0.17781045f, 0.62284142f, -0.00354322f, 0.39078864f, -0.35319805f, 0.49891025f, -0.02060060f, 
    0.04403071f, 0.03824131f, -0.17072861f, -0.74203920f, 0.00660298f, -0.06267855f, -0.78353280f, -0.13902354f, 
    0.00081816f, -0.15538213f, -0.00082519f, 0.19587296f, -0.08739077f, 0.22955957f, -0.44326529f, 0.25602016f, 
    -0.08515517f, -1.01862741f, 0.06287654f, -0.07649159f, -0.10301994f, 0.66329610f, -0.52205366f, -0.57283598f, 
    0.05247529f, -0.02917828f, -0.51460707f, 0.29973122f, -0.23658195f, -0.50879008f, -0.37407672f, 0.00907849f, 
    -0.06134866f, 0.38282594f, -0.56462049f, 0.08545817f, 0.10290276f, 0.47187924f, -0.15912059f, -0.10894269f, 
    0.13692848f, -0.00838575f, 0.29881883f, 0.13629587f, -0.14844024f, 0.28373340f, -0.32185271f, 0.13105504f, 
    0.11309814f, 0.31993616f, 0.14466818f, -0.09588835f, -0.58342153f, 0.29517367f, -0.16316465f, -0.03561562f, 
    -0.09403537f, -0.10320131f, 0.05532272f, 0.11816419f, -0.17217609f, 0.21033588f, 0.21161118f, -0.10384797f, 
    -0.01169818f, -0.09468920f, -0.45331648f, -0.59175301f, -0.05989017f, -0.36675537f, -0.35602099f, -0.13215631f, 
    0.10591358f, 0.12426930f, -0.66926682f, 0.05928039f, -0.02251056f, -0.20750852f, -0.06741347f, -0.21294013f, 
    0.01217820f, -0.21717259f, 0.10920355f, 0.11579340f, -0.91731489f, -0.52230603f, -0.45312029f, 0.38679445f, 
    0.06757271f, -0.12784055f, -0.14326555f, 0.42565903f, 0.13105235f, 0.39450976f, -0.98007584f, -0.10061180f, 
    0.09179185f, -0.26971227f, -0.30923679f, 0.16316251f, -0.30242753f, 0.10047827f, 0.28988123f, 0.03983936f, 
    0.07400158f, 0.08766473f, -0.33865803f, -0.05549845f, 0.03358486f, 0.23779644f, -0.08898439f, 0.06201300f, 
    0.15109301f, -0.32404160f, 0.02713766f, -0.06664748f, 0.19490872f, -0.13171706f, -0.15602194f, 0.23042375f, 
    0.02518534f, 0.01952521f, -0.49963298f, -0.48099557f, -0.08241943f, -0.28709558f, -0.16247895f, -0.16354248f, 
    -0.06310112f, 0.34322670f, -0.33068839f, 0.11660890f, 0.69322354f, -0.11361018f, 0.13590232f, -0.04080298f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.05472349f, -0.23289964f, -0.12023007f, -0.10880557f, 0.42893401f, -0.13557725f, 0.04416100f, -0.58364666f, 
    -0.21132377f, 0.10722785f, 0.35051036f, 0.03080569f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
