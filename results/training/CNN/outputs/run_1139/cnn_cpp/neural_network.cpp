#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.45143464f, -0.36029449f, 0.20990323f, -0.14252159f, -0.39329189f, -0.54666859f, -0.51329577f, -1.01456845f, 
    -0.38168147f, 0.50081241f, -0.10384607f, -0.15402704f, -0.35381430f, -0.47104704f, -0.47102600f, -0.20388708f, 
    -0.22411683f, -0.43629789f, -0.68921298f, -0.62565833f, 0.13587560f, -0.03522245f, 0.26724172f, 0.20194951f, 
    0.24447086f, 0.41131112f, 0.41723368f, 0.20513444f, -0.42204008f, -0.06284363f, -0.22248361f, 0.33502001f, 
    0.47029042f, 0.11752017f, -0.85428667f, -0.21092120f, 0.46474299f, -0.23367158f, -0.43235609f, -0.01417961f, 
    -0.10285346f, 0.26411515f, -0.02034652f, -0.26637930f, -0.11497520f, -0.18208449f, 0.10180101f, -0.34319925f, 
    0.23971157f, 0.19948885f, -0.10694285f, -0.62787539f, 0.36326644f, 0.55351728f, 0.16860552f, -0.34375846f, 
    -0.63774920f, -0.62757254f, 0.28298384f, 0.18636452f, -0.26163635f, -0.43611383f, -0.30185652f, 0.37254646f, 
    0.45224094f, -0.02859842f, -0.01955406f, 0.20139058f, -0.09391551f, 0.18703720f, -0.19195646f, -0.28392187f, 
    -0.26304838f, -0.02916551f, -0.49106011f, -0.34610140f, 0.57851386f, 0.50497162f, -0.22937527f, 0.05827486f, 
    0.08444605f, 0.33890647f, -0.14855048f, 0.40749878f, -0.03755972f, -0.35728714f, -0.45476395f, -0.11141871f, 
    0.00255045f, 0.07157747f, -0.09000961f, 0.06229172f, -0.17040186f, 0.04144154f, -0.01302871f, -0.30679598f, 
    -0.45065579f, -0.19603574f, -0.53723568f, -0.71557999f, -1.29077542f, -0.51259667f, -0.58582437f, -0.82904273f, 
    -0.55753464f, 1.14583457f, 0.27059272f, 0.13498820f, 0.41500920f, 0.83923179f, 0.38953954f, 0.07552529f, 
    -0.03804759f, 0.11417479f, -0.30774599f, -0.31056759f, 0.04914950f, 0.03447540f, 0.03099841f, -0.27162495f, 
    0.03573875f, -0.11428594f, 0.28279164f, -0.04975073f, 0.03192679f, 1.50627410f, -0.76718473f, -1.05144858f, 
    -0.66411549f, -0.81275076f, 1.10903609f, 0.42382333f, 0.58100092f, -0.19752997f, -0.04870857f, -0.15605396f, 
    0.55697072f, -0.33405051f, -0.30556864f, 0.00833184f, 0.20775197f, 0.18657161f, 0.08888961f, -0.18329982f, 
    -0.20546843f, -0.04902807f, 0.14082521f, -0.15212354f, 0.04546043f, 0.09474333f, -0.27016300f, -0.98944199f, 
    -0.01946266f, 0.38106096f, 0.15885973f, -0.99008667f, -1.19680321f, -0.54859936f, -0.14138538f, -0.69270229f, 
    0.20084542f, 0.80337822f, -0.16289422f, 0.03737925f, 0.04957808f, -0.00525018f, 0.28740183f, -0.33157033f, 
    -0.48463780f, -0.44499251f, -0.12189458f, 0.32767135f, 0.04208863f, 0.01639691f, 0.24279615f, 0.46249652f, 
    0.55734056f, 0.06277880f, 0.43973377f, -0.22129527f, 0.16565856f, -0.25591493f, -0.48562592f, 0.17154992f, 
    -0.35781267f, -0.00735127f, 0.21344151f, -0.01881669f, 0.07399014f, -0.32645905f, -0.37024030f, 0.16636486f, 
    0.44512632f, -0.00663231f, -0.08675206f, -0.04895684f, -0.03078300f, 0.12975673f, -0.03598159f, -0.53540838f, 
    -0.17602047f, 0.64857209f, 0.34449804f, -0.78971899f, -0.73601311f, -0.62792456f, 0.33312026f, -0.15370801f, 
    0.24850363f, 0.73952192f, -0.12880202f, 0.07646844f, -0.01224429f, -0.28400099f, -0.24749947f, 0.02587344f, 
    -0.42624959f, 0.10270450f, 0.19815046f, 0.13695307f, -0.15251760f, 0.06800658f, 0.23616613f, 0.14303248f, 
    0.46287227f, 0.30564013f, -0.20499615f, 0.19384727f, 0.07378069f, 0.11338303f, 0.00476851f, 0.25339898f, 
    -0.24763088f, 0.08074213f, 0.24281143f, -0.27605674f, -0.24541795f, 0.03157751f, -0.15964551f, -0.25702363f, 
    0.09393758f, -0.40719056f, 0.34867105f, 0.07360105f, -0.38001090f, 0.02010076f, 0.15988427f, 0.22715406f, 
    0.17955357f, 0.32356003f, -0.06371611f, -0.07396109f, -0.09669199f, -0.03376314f, 0.03502895f, 0.29350743f, 
    0.54870677f, -0.63236862f, -0.48414344f, 0.32945099f, -0.17820752f, 0.73922098f, -0.14815429f, -0.46334001f, 
    0.21064088f, -0.24490148f, 0.15114973f, 0.27775079f, -0.03420990f, -0.61392450f, -0.23215935f, 0.26513004f, 
    0.08954459f, 0.18393503f, 0.21240012f, -0.51416385f, -0.63631344f, -0.77994931f, -0.13888250f, -0.00084364f, 
    0.20263311f, 0.41407007f, 0.37039134f, 0.17585000f, 0.05610242f, 0.24629717f, 0.37689227f, 0.21315473f, 
    0.15020658f, -0.03816045f, 0.21694002f, 0.04698889f, -0.27369949f, 0.01543229f, -0.32052428f, -0.22479959f, 
    0.11197116f, -0.15473466f, -0.28156304f, -0.21765314f, -0.45394251f, -0.25747186f, -0.77383858f, -0.14688793f, 
    0.11563668f, -0.58796942f, -0.68545657f, -0.54446757f, 0.08143950f, 0.53058934f, 0.28299296f, -0.37990737f, 
    -0.25933576f, -0.35904431f, 0.29544488f, 0.23164526f, 0.39567026f, 0.13971376f, -0.04639464f, 0.10359526f, 
    -0.38085735f, -0.20757277f, -0.08092841f, 0.05394118f, -0.09180067f, -0.48297074f, -0.74781477f, 0.78460008f, 
    0.58702350f, -0.35859466f, -0.19225179f, 0.61519414f, -0.18321384f, -0.36245266f, 0.44021609f, 0.06357710f, 
    -0.47748131f, 0.23182757f, 0.23349716f, 0.15720722f, -0.51368237f, -0.00593415f, -0.31095293f, 0.26970944f, 
    -0.15469997f, 0.09234629f, 0.28027895f, 0.30785576f, -0.07600261f, -0.05213128f, -1.54252589f, 0.60547310f, 
    -0.15987998f, -1.12995458f, -0.43277365f, 0.21834545f, 0.39814648f, -0.18067722f, 0.25839320f, 0.88906938f, 
    -0.24968372f, -0.14800717f, -0.24567309f, -0.44539642f, 0.37114367f, 0.05414560f, 0.36327833f, -0.19356138f, 
    0.18774635f, 0.15273601f, 0.00498894f, -0.07501432f, -0.01076257f, -0.35702795f, -0.31890732f, -1.13216567f, 
    0.13744405f, 1.38184881f, -0.10877856f, -0.44116807f, -0.33109632f, 0.08485261f, -0.16430001f, 0.06542444f, 
    -0.07855482f, 0.19467190f, -0.29381385f, -0.55639547f, 0.94966280f, -0.67042297f, -0.05553954f, -0.02791147f, 
    -0.15790787f, -0.10591650f, 0.04666397f, 0.16166559f, -0.09681317f, 0.20370647f, -0.24414004f, 0.02722699f, 
    0.06666392f, -0.16628148f, 0.16226821f, 0.42155281f, 0.09878423f, 0.47772565f, -0.36638215f, 0.41844413f, 
    -0.49855340f, -0.16507155f, 0.10682300f, 0.24705589f, 0.15435058f, -0.07680611f, 0.10175926f, -0.22577977f, 
    0.27639613f, 0.18513469f, -0.03677807f, 0.45801130f, 0.02846627f, 0.02851348f, -0.02412433f, 0.36296278f, 
    0.13808127f, -1.39594805f, -0.95001030f, -0.31699738f, 0.91752237f, 0.89722562f, 0.07689442f, -0.20897105f, 
    -0.37590647f, -0.33656734f, 0.20294653f, 0.38130844f, 0.05448070f, 0.20113260f, 0.41179839f, 0.02968925f, 
    0.41777185f, -0.34048679f, -0.10786308f, -0.13441403f, -0.35304892f, -0.06972587f, -0.17212856f, -0.01930564f, 
    -0.16162388f, -0.47941267f, -1.28050256f, -0.41422865f, -0.48265925f, -0.42099151f, -0.26859438f, 0.07240911f, 
    0.10274397f, -0.79453945f, -0.03994261f, 0.04501196f, 0.52195019f, 0.55037397f, -0.45030865f, -0.04225967f, 
    -0.99079502f, -0.30651471f, -0.40324813f, -0.57718557f, 0.24303846f, -0.03046607f, 0.04682348f, -0.00781809f, 
    0.28865924f, 0.52280301f, -0.05948405f, 1.11678040f, -0.66361868f, -0.29430911f, -0.14150801f, -0.90661937f, 
    0.07518589f, -0.80603498f, -0.82080960f, -0.88153398f, -1.00384104f, 0.11398596f, 0.10059525f, -0.00256590f, 
    -0.41827786f, -0.45694512f, -0.15728608f, 0.23027724f, 0.05887119f, -0.28322750f, -0.12316819f, -0.50314206f, 
    0.04394883f, 0.02830355f, -0.09969226f, 0.03863908f, 0.50668848f, 0.47319126f, 0.20550682f, -0.18498254f, 
    -0.36574045f, -0.10171766f, 0.13957278f, 0.33960068f, 0.44924456f, -0.11143125f, 0.12534297f, -0.23607473f, 
    -0.24230033f, -0.61731416f, -0.19306707f, 0.16083755f, 0.32325357f, -0.34062132f, -0.05707719f, -0.07534314f, 
    0.17978363f, -0.10209754f, 0.16307022f, 0.05738289f, -0.54182059f, -0.01509593f, -0.63734066f, -0.32001364f, 
    0.48552072f, 0.25064304f, 0.11561427f, -0.35669577f, 0.07570477f, -0.93709940f, -0.62537038f, -0.05951858f, 
    0.18890598f, 0.24909669f, -0.19308349f, -0.35061598f, -0.15941910f, 0.04000792f, 0.00581358f, 0.24093185f, 
    0.52416450f, -0.13390137f, -0.01227757f, -0.31991574f, -0.18429182f, -0.38772571f, 0.83770484f, 0.86811686f, 
    0.74162960f, 0.26464701f, -0.27993423f, -0.74370813f, -0.23004735f, -0.25611833f, -0.26015684f, -0.39448598f, 
    -0.01081944f, -0.05174544f, -0.00399237f, -0.01368202f, 0.08096989f, -0.09219107f, 0.18580523f, 0.13821088f, 
    -0.10761979f, 0.21696182f, -0.11144163f, 0.15390563f, -0.12259262f, 0.00920612f, -0.15048446f, 0.00590344f, 
    -0.68224627f, -0.96924925f, -0.39116168f, -0.27720824f, 0.36950648f, 0.70885885f, -0.44848955f, -0.55554760f, 
    -0.34023646f, 0.37910566f, 0.24903868f, 0.38343188f, 0.08807315f, 0.14987895f, -0.21438833f, -0.35802674f, 
    -0.23027448f, 0.32345694f, 0.25421792f, -0.17150666f, -0.37814301f, 0.05505000f, 0.41517362f, -0.11091647f, 
    0.47550154f, -0.06137451f, 0.30208454f, 0.36017153f, 0.25928167f, 0.23497385f, 0.18568985f, 0.22509716f, 
    0.36097038f, 0.23553024f, 0.00875641f, 0.07666725f, 0.03245711f, -0.09968325f, -0.26470292f, -0.26791778f, 
    -0.11906261f, -0.13763681f, -0.08003895f, -0.29932246f, 0.20465329f, -0.00788164f, -0.06710938f, 0.05818151f, 
    0.27371001f, -0.73884070f, 0.18690893f, 0.41830248f, 0.04782103f, 0.35967708f, 0.05665483f, 0.33086914f, 
    -0.08114596f, -0.45713967f, -0.44335791f, -0.06357983f, 0.14867882f, -0.55086178f, 0.35777289f, -0.00316236f, 
    0.51344377f, -0.17116693f, -0.47216886f, 0.31774414f, -0.20522398f, -0.37340602f, 0.22195010f, 0.34968391f, 
    -0.04741313f, 0.13054790f, -0.84972185f, -0.62656742f, -0.35035259f, -0.41497141f, 0.01117800f, -0.31814185f, 
    -0.63208675f, -0.56001902f, -0.07264652f, 0.00353319f, -0.36683691f, -0.24584913f, -0.29820350f, 0.03591160f, 
    -0.16717289f, 0.03345169f, 0.31551769f, 0.25273353f, 0.20753932f, 0.21537802f, 0.03793719f, 0.34232593f, 
    -0.25271305f, -0.22453652f, -0.01149283f, -0.98887855f, -0.68286020f, -0.53857964f, -1.23540652f, -0.80628026f, 
    0.47366115f, -0.10507900f, -0.30873403f, 0.04810438f, -0.20811859f, -0.63787436f, -0.54904515f, -0.28104019f, 
    -0.19304413f, -0.24148524f, -0.17207119f, -0.43410853f, -0.12822543f, -0.18360768f, -0.20980245f, -0.34346786f, 
    0.11963706f, 0.06892969f, -0.23532926f, -0.06361783f, 1.03304458f, 0.31401423f, -0.69749671f, -0.64460313f, 
    -0.13402939f, -0.48778680f, -0.07099006f, 0.01055423f, -0.34159914f, -0.58790988f, 0.13562310f, 0.27034611f, 
    0.38718557f, 0.05527359f, 0.08941311f, 0.25176007f, -0.34604573f, -0.10380735f, 0.18884690f, -0.29219621f, 
    -0.31787381f, -0.04613542f, -0.17312799f, -0.21004456f, -0.31809884f, 0.17500933f, 0.01570687f, 0.35511824f, 
    -0.37789729f, -0.68711108f, 0.10915539f, -0.32487836f, 0.24320889f, -0.03746738f, 0.07555977f, 0.23274967f, 
    0.18130055f, -0.22567677f, -0.00897758f, 0.02594609f, 0.01997461f, 0.16436777f, 0.01832554f, -0.23451169f, 
    -0.25653860f, 0.29941189f, 0.30820036f, -0.06379932f, 0.29730967f, 0.69284165f, -1.15474951f, -0.70741957f, 
    -0.41227773f, 0.80438435f, 0.44656366f, 0.06137249f, -0.52187216f, 0.27285832f, 0.89254665f, 0.63530117f, 
    0.10232083f, 0.17557636f, 0.25590768f, -0.11090370f, -0.23979986f, -0.29804882f, -0.14342821f, 0.04085127f, 
    -0.37959352f, -0.12021237f, 0.18925291f, -0.05851111f, 0.08356408f, 0.12705845f, 0.55023974f, 1.14163411f, 
    0.70089442f, 0.13148542f, -0.46738890f, -1.20254052f, 0.11906184f, 0.29163748f, 0.02280685f, 0.20169002f, 
    0.09926705f, -0.13993873f, -0.20472722f, -0.26649469f, 0.27908289f, -0.46359941f, 0.14596681f, -0.20527026f, 
    -0.19362354f, 0.02074885f, 0.18020938f, 0.03974333f, -0.07210112f, -0.11341156f, -0.07736176f, 0.17639846f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08919320f, 0.57696021f, 0.44072229f, 0.05143639f, 0.21762615f, 0.52993941f, 0.38770720f, 0.26866743f, 
    0.16022179f, 0.20526862f, 0.40832165f, 0.09128059f, -0.07734623f, 0.32556838f, 0.10726631f, 0.19504344f, 
    0.27847886f, 0.19174221f, -0.13430841f, -0.21551803f, 0.49534300f, -0.09116211f, 0.40906101f, 0.67414582f, 
    -0.23228580f, 0.19421978f, -0.29770145f, -0.28726095f, 0.09526382f, 0.12220137f, 0.56757027f, 0.48370674f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21869344f, 0.22262278f, 0.02373228f, -0.27818474f, 0.13126191f, 0.10280845f, -0.00924325f, -0.13713005f, 
    -0.16969299f, -0.08923601f, -0.16140863f, -0.10422559f, -0.24861853f, -0.48667094f, -0.34183913f, 0.13721941f, 
    -0.10054775f, 0.02911320f, -0.11191966f, -0.00011148f, -0.01290442f, 0.06619812f, 0.03495243f, -0.15159984f, 
    0.09947060f, 0.26330301f, 0.31409711f, -0.39018697f, -0.05696652f, -0.12169147f, -0.15405896f, -0.05934367f, 
    -0.06970883f, -0.05420531f, -0.08733334f, 0.13092339f, -0.68805456f, -0.38483909f, -0.02655919f, 0.05170058f, 
    0.00152640f, 0.10384420f, 0.04650183f, 0.01083311f, -0.03110733f, 0.04197937f, -0.04060137f, 0.26155838f, 
    0.17765880f, -0.08631036f, -0.01553329f, -0.11050981f, 0.11981812f, 0.23406823f, 0.02475659f, -0.06896587f, 
    0.02080264f, 0.16044509f, -0.06738610f, -0.03857645f, 0.07743632f, -0.24033350f, -0.94040763f, 0.06782766f, 
    -0.00383030f, -0.06067442f, -0.16179717f, -0.13105264f, -0.02388228f, -0.00052933f, -0.05112665f, -0.20131418f, 
    0.29489338f, 0.26467079f, -0.03432175f, -0.34181604f, -0.03129418f, -0.06862985f, -0.03991054f, -0.02139475f, 
    -0.00380075f, -0.01654140f, -0.12223922f, -0.09067219f, -0.34829316f, -0.18550168f, -0.16680641f, -0.13476580f, 
    0.04923274f, 0.05531085f, -0.06268941f, 0.07508345f, -0.04990220f, 0.01616425f, -0.00625746f, 0.05418564f, 
    -0.06633605f, -0.12486462f, 0.10608020f, 0.04019688f, -0.14960612f, -0.15847062f, -0.05337051f, -0.06306841f, 
    0.01358348f, -0.12266966f, -0.00109545f, -0.11830334f, -0.04693670f, -0.00564050f, -0.06429862f, 0.06074718f, 
    0.00511183f, -0.00951543f, 0.08224570f, 0.03100488f, 0.04514381f, -0.06115758f, -0.08383530f, -0.01378749f, 
    0.04210308f, -0.06504373f, -0.16967039f, 0.07866244f, -0.07449429f, 0.00898825f, -0.02308303f, -0.20327619f, 
    -0.16254388f, -0.13913378f, -0.17969984f, -0.00632866f, 0.16540843f, 0.07045346f, -0.14017284f, 0.11269625f, 
    0.08572145f, 0.09334803f, 0.03373222f, -0.08431140f, -0.20873404f, 0.08364408f, -0.20748509f, 0.15079242f, 
    0.17716795f, 0.39229044f, 0.17277046f, -0.14733259f, 0.17909601f, 0.17726591f, 0.07021650f, 0.02025768f, 
    -0.00857825f, -0.04158880f, 0.04318589f, 0.01500459f, 0.03581048f, -0.19721079f, 0.00360839f, -0.23453714f, 
    -0.04269800f, -0.19512893f, 0.03789087f, -0.13881633f, 0.05396016f, -0.23624259f, -0.23111981f, -0.12938039f, 
    -0.35288575f, 0.16114657f, 0.02761979f, -0.14942639f, -0.07575789f, 0.34906274f, 0.02308547f, 0.08143288f, 
    0.00538841f, 0.09525280f, 0.03696168f, -0.13136455f, 0.20173931f, 0.13926260f, -0.12528498f, -0.39426672f, 
    -0.02326804f, -0.07250221f, -0.09345005f, 0.26071185f, 0.00963881f, -0.06540887f, -0.09277505f, -0.09907594f, 
    -0.00921640f, 0.04245399f, 0.15210058f, 0.02311152f, -0.46667916f, -0.21896712f, -0.08974657f, -0.13418527f, 
    -0.07466541f, -0.08689819f, -0.05071485f, -0.11429972f, 0.50306094f, 0.26543587f, 0.09148589f, -0.28445515f, 
    -0.04568407f, 0.03840342f, 0.09546857f, -0.00233195f, -0.02817199f, -0.08299351f, -0.08319456f, 0.04380673f, 
    0.36485800f, 0.17288435f, 0.03746698f, -0.24149840f, 0.12356303f, 0.08598638f, 0.25548777f, 0.24074869f, 
    -0.01307780f, -0.17895898f, -0.08726431f, -0.04392026f, 0.26675799f, 0.01580098f, -0.20412074f, -0.12352220f, 
    0.13356929f, -0.00393387f, 0.00052961f, 0.18196246f, -0.08728015f, 0.12450293f, -0.05996662f, 0.02581460f, 
    -0.75054902f, -0.49539563f, -0.27746186f, -0.04617434f, 0.00259126f, 0.09486750f, 0.03383786f, 0.06231952f, 
    -0.03158529f, -0.12953459f, -0.04241973f, 0.06339252f, 0.47430915f, 0.04337272f, -0.01946748f, -0.06390737f, 
    0.09103652f, -0.12940125f, 0.18853571f, 0.04468812f, -0.01490723f, -0.01038426f, 0.01533121f, 0.03538363f, 
    -0.12894040f, -0.09313580f, 0.02477064f, -0.04363054f, 0.00003316f, 0.02757192f, -0.06478864f, -0.06544441f, 
    0.03155722f, -0.00483494f, -0.00001348f, 0.05138684f, 0.34091100f, 0.05817254f, -0.48720556f, -0.09526411f, 
    0.09390053f, -0.18090251f, -0.07166259f, -0.24837600f, -0.04781775f, -0.15294738f, -0.08335511f, -0.01143048f, 
    -0.11580157f, -0.26139492f, -0.35634860f, 0.22786398f, 0.06431209f, 0.06740340f, 0.09478603f, 0.10658012f, 
    -0.00806275f, 0.02719375f, 0.08041558f, -0.02061105f, 0.07258510f, -0.12575027f, -0.16169704f, -0.07231717f, 
    -0.05505465f, -0.07890413f, 0.05879410f, -0.07715786f, -0.14030266f, -0.08822385f, -0.22185940f, 0.01998420f, 
    0.46740767f, 0.32073063f, 0.10768120f, -0.24296388f, 0.14366385f, 0.23844318f, 0.13749039f, 0.16242301f, 
    0.01188250f, 0.02535764f, 0.05113256f, -0.06031110f, 0.25990334f, 0.12666945f, 0.01656680f, -0.14065839f, 
    0.10618651f, 0.31307921f, 0.14300659f, 0.01411334f, -0.11104256f, -0.14337471f, -0.07227080f, 0.14301564f, 
    0.23470664f, -0.00345368f, -0.32649893f, -0.07782915f, -0.02066815f, -0.26360324f, -0.01905104f, -0.17585745f, 
    -0.11528700f, 0.07062062f, -0.08514322f, 0.00208717f, 0.08802673f, -0.11437827f, 0.04144581f, -0.00192290f, 
    -0.08266527f, 0.00741254f, -0.24896717f, -0.11168464f, -0.04720176f, -0.04705849f, 0.04845953f, -0.11372582f, 
    -0.04771649f, 0.47571051f, 0.41320068f, -0.33070636f, 0.03977871f, 0.06178504f, 0.10297681f, -0.12497611f, 
    -0.23592611f, -0.22782561f, 0.13706833f, -0.35205761f, -0.58423072f, -0.71893978f, -0.15030497f, 0.02559352f, 
    0.04024993f, 0.04788851f, 0.01988684f, 0.01092144f, -0.21887876f, -0.10008377f, -0.02264660f, -0.14555489f, 
    0.13318735f, -0.07781307f, -0.10725420f, 0.04817271f, 0.00245788f, 0.08296143f, 0.02095328f, 0.05517767f, 
    0.01500274f, -0.01088899f, -0.11036936f, 0.03962313f, 0.54834706f, 0.02342271f, 0.42371559f, 0.06254396f, 
    0.03424155f, -0.05771179f, 0.11308340f, -0.11877663f, 0.02915753f, 0.11763482f, -0.13009425f, 0.18907008f, 
    -0.15670405f, 0.11863296f, -0.10637124f, -0.38374236f, 0.20882671f, -0.22029760f, -0.14951411f, 0.16071324f, 
    0.04448564f, 0.05918896f, 0.16334158f, -0.08409793f, 0.04366115f, 0.10388808f, 0.10692035f, 0.11658549f, 
    0.03548210f, -0.05326878f, -0.14904484f, 0.02168091f, -0.41713709f, -0.05290323f, -0.16536620f, -0.33746049f, 
    0.11947923f, -0.06019910f, -0.39722523f, -0.33332643f, -0.08285973f, -0.00057518f, -0.03598083f, 0.02665309f, 
    -0.11179125f, 0.04977001f, 0.05594020f, -0.16030659f, 1.12455606f, -0.16720806f, -0.17648284f, -0.17847987f, 
    -0.04762317f, -0.10296006f, 0.02716460f, -0.13951378f, 0.05059164f, 0.01949136f, -0.21218717f, 0.00908710f, 
    -0.50784069f, 0.20229264f, -0.42483875f, -0.06275233f, -0.13450554f, 0.00047686f, 0.00681728f, 0.09046057f, 
    -0.09231240f, 0.02945963f, -0.01119279f, 0.13667405f, -0.04245215f, 0.06248188f, 0.01323429f, -0.08175155f, 
    0.02682733f, -0.08159457f, -0.03969095f, 0.08858654f, -0.08957037f, 0.07823706f, 0.02232489f, 0.07744379f, 
    0.11715573f, -0.00283999f, 0.33831871f, -0.34306300f, -0.02642398f, 0.17797467f, -0.12431635f, -0.00818863f, 
    -0.03078128f, 0.09794474f, 0.01140369f, -0.09930217f, -0.01697201f, 0.08530859f, 0.16425489f, -0.04646922f, 
    -0.10095175f, 0.01669669f, 0.08710475f, -0.02904847f, -0.08910427f, 0.06862692f, 0.04183259f, -0.07040469f, 
    0.10512342f, -0.07046029f, 0.05210900f, 0.14803898f, -0.02779570f, -0.04555400f, 0.03238912f, 0.10043188f, 
    0.09731393f, 0.00960628f, -0.21678720f, 0.14753990f, -0.04108339f, -0.19990331f, -0.12235966f, 0.02073929f, 
    -0.09106121f, 0.00893361f, 0.05959620f, -0.07688779f, -0.04385059f, 0.02261419f, -0.03753505f, 0.00493991f, 
    -0.06365199f, 0.19609386f, 0.00365484f, 0.10952050f, 0.14015822f, -0.25641489f, -0.17049621f, -0.38067457f, 
    0.06212319f, -0.02326552f, -0.11491985f, 0.10119061f, -0.03094876f, 0.00844392f, 0.15561612f, -0.21462004f, 
    -0.11866403f, 0.14960812f, 0.17887917f, 0.06517214f, -0.02337489f, 0.20888694f, 0.36034998f, 0.01668042f, 
    -0.21510087f, 0.23919979f, 0.09887150f, -0.13051102f, 0.10639831f, 0.10467272f, -0.46277225f, -0.32888374f, 
    -0.04733878f, 0.07233660f, -0.13995096f, -0.18728572f, -0.24223313f, -0.55072773f, -0.39115429f, -0.20847732f, 
    0.17628892f, -0.27915907f, 0.02874744f, -0.02250127f, 0.07527526f, -0.03049300f, 0.06065868f, -0.12699832f, 
    0.03891674f, 0.01257541f, -0.08665056f, 0.00069175f, 0.16949785f, 0.01092126f, 0.05251032f, -0.10292289f, 
    -0.04102923f, 0.05990418f, -0.02579248f, 0.09040652f, -0.16135597f, -0.21919265f, -0.21762072f, 0.16973500f, 
    0.03055046f, -0.00677858f, 0.12121990f, -0.00139458f, -0.16263145f, -0.13193123f, 0.04822838f, -0.14532739f, 
    0.23512164f, -0.10232981f, -0.10916242f, 0.13597254f, -0.03898676f, 0.07170154f, 0.00044351f, 0.24431887f, 
    -0.04909305f, -0.01650908f, -0.27921942f, 0.11268609f, 0.35547525f, -0.01453650f, -0.15715307f, -0.25383687f, 
    -0.21907926f, -0.04032455f, -0.37849066f, -0.17721264f, 0.07325816f, -0.07097134f, -0.05174581f, 0.05326008f, 
    0.12555614f, 0.20365347f, 0.53296310f, 0.03814388f, -0.04851804f, -0.00897242f, 0.04804960f, -0.05773896f, 
    -0.05238304f, 0.08954351f, -0.05739092f, 0.02994620f, 0.00564889f, 0.07325016f, -0.49935001f, -0.12485363f, 
    0.03684582f, 0.01047839f, -0.04479827f, -0.13050777f, 0.05453080f, -0.07401595f, 0.03978130f, 0.08382266f, 
    0.18951464f, 0.03781170f, -0.00647643f, -0.09180360f, -0.10235236f, -0.08408888f, -0.13126880f, -0.01061715f, 
    -0.05295020f, -0.05141147f, 0.02453815f, 0.06459276f, 0.05791400f, -0.12084860f, -0.19390562f, -0.08641750f, 
    0.05331787f, 0.10626139f, 0.21143213f, 0.16074246f, 0.15623492f, 0.04843954f, 0.02431939f, 0.05877072f, 
    0.31240666f, 0.27403912f, 0.26343367f, 0.30502829f, -0.08064986f, 0.04702985f, -0.06585059f, 0.04224847f, 
    -0.04443994f, 0.05137581f, -0.06269891f, 0.01350422f, 0.01027002f, -0.50965977f, 0.02753891f, 0.29587054f, 
    -0.02803410f, -0.07155756f, 0.08786204f, -0.00160322f, -0.05901972f, 0.13066201f, 0.08942280f, 0.02560870f, 
    0.03989651f, 0.20018858f, 0.05294738f, 0.25527108f, -0.06728213f, -0.13218153f, -0.27190122f, -0.23696727f, 
    -0.03063638f, -0.06165553f, -0.07392290f, -0.04200440f, 0.13451289f, 0.38423049f, 0.28074229f, 0.23200771f, 
    0.03137178f, 0.02554718f, -0.02497120f, 0.13367502f, 0.03216490f, 0.06710325f, -0.03424488f, -0.17570190f, 
    0.12183684f, -0.10351552f, -0.20123067f, -0.09669592f, -0.15171449f, -0.03650314f, -0.10766479f, 0.10691433f, 
    0.01053216f, -0.09185825f, -0.11575610f, 0.13741264f, -0.00177744f, 0.03847392f, 0.07872280f, -0.09683341f, 
    0.19898871f, 0.08050836f, -0.12735933f, -0.00233859f, -0.14175805f, -0.00932151f, -0.00071728f, -0.01798295f, 
    -0.53717226f, 0.15934364f, -0.31230471f, -0.06092628f, -0.12620233f, 0.09689262f, 0.03417869f, 0.03726579f, 
    0.07264457f, 0.04244654f, 0.06999292f, 0.31490207f, 0.72900146f, -0.10554935f, 0.17005305f, -0.44533530f, 
    0.00255140f, -0.07573894f, 0.03617685f, -0.01744337f, 0.04762199f, 0.00870833f, -0.00685347f, -0.16828638f, 
    -0.04149892f, -0.17009903f, 0.09930487f, -0.20068559f, 0.17531118f, 0.15654215f, -0.02251094f, 0.07942186f, 
    -0.00549501f, -0.08625698f, 0.00351774f, 0.03949889f, 0.23549478f, -0.10983255f, 0.00176368f, -0.19317214f, 
    0.06208791f, -0.02106315f, 0.00854894f, 0.03104250f, 0.07601118f, 0.01814166f, -0.15449265f, 0.16051386f, 
    -0.15898430f, 0.00102248f, -0.12264978f, 0.15101735f, 0.01065901f, -0.06069341f, -0.09367483f, 0.01246649f, 
    -0.08618882f, 0.09012756f, -0.03887668f, -0.02029131f, 0.00006593f, -0.12320917f, -0.27746570f, -0.09032926f, 
    0.04045715f, -0.07060584f, 0.03346382f, 0.00113477f, 0.19908185f, 0.27273449f, 0.24562703f, -0.04409732f, 
    0.02465770f, 0.47584066f, 0.44720820f, 0.32994637f, -0.06246859f, -0.02121958f, 0.05786775f, -0.04556446f, 
    0.01569292f, -0.13808864f, 0.05411873f, 0.06615657f, -0.25744754f, 0.46361476f, 0.50982928f, -0.18078710f, 
    -0.03670963f, 0.05057539f, -0.10230516f, -0.04718769f, 0.10880279f, 0.03573008f, -0.27748814f, 0.13919115f, 
    -0.28834149f, -0.35795519f, -0.56971991f, 0.01631618f, -0.12892671f, 0.11866038f, 0.04671685f, -0.09889801f, 
    0.08699284f, 0.00060187f, -0.13624559f, 0.04946758f, -0.37387118f, 0.06520797f, 0.16498615f, -0.50649363f, 
    0.01388730f, -0.14893612f, 0.02558080f, 0.00884201f, 0.01975085f, -0.08585547f, 0.12619725f, 0.00969815f, 
    0.23629883f, 0.10562332f, 0.09602425f, -0.26003236f, 0.19618261f, 0.06503924f, -0.20870326f, 0.12626237f, 
    -0.09767622f, 0.09064910f, -0.02419266f, -0.12271491f, -0.12907489f, -0.03114778f, 0.05924218f, -0.13540262f, 
    0.06488339f, 0.00697240f, 0.01330595f, 0.08411622f, -0.03811628f, -0.07575225f, 0.11469317f, -0.17214924f, 
    -0.08099820f, -0.22739978f, 0.15650177f, -0.06239184f, 0.04837677f, -0.02219248f, -0.14306515f, 0.00200487f, 
    0.04907133f, -0.01183326f, 0.07194611f, -0.01348123f, 0.05105145f, 0.09974685f, 0.15161258f, 0.09567784f, 
    -0.03510965f, -0.04388751f, 0.11993746f, 0.03131475f, 0.06425493f, -0.07653569f, 0.11195204f, 0.13962288f, 
    -0.16192698f, -0.31928024f, -0.19495800f, 0.17068996f, 0.07759117f, -0.03912744f, 0.05537051f, -0.03917934f, 
    -0.05680277f, 0.02663168f, -0.04274310f, 0.13085812f, 0.39446086f, 0.21372935f, 0.04012674f, 0.12106810f, 
    0.11297569f, 0.01416238f, 0.00828328f, 0.03942503f, -0.28925034f, -0.05376846f, 0.05339370f, -0.10040106f, 
    0.43957812f, -0.22693419f, 0.26594627f, 0.28699818f, 0.05920294f, -0.08488082f, 0.02443836f, 0.02213877f, 
    0.09639284f, 0.13761534f, -0.08535349f, 0.27208838f, 0.87718874f, -0.16082616f, -0.08470810f, 0.05673053f, 
    0.03445311f, -0.08815605f, -0.09446392f, 0.19260727f, 0.01570590f, -0.14985104f, 0.19588776f, 0.05212958f, 
    -0.03107370f, 0.02743412f, -0.09074134f, -0.01128845f, -0.18779984f, -0.20531002f, 0.00208325f, 0.17432289f, 
    0.05174980f, 0.08184899f, -0.06837479f, -0.03075564f, 0.10185999f, -0.17306483f, 0.20574814f, 0.24269038f, 
    0.00020045f, -0.08338944f, -0.05259944f, 0.10308396f, -0.07192338f, 0.08149461f, 0.11600462f, -0.05504939f, 
    0.14247434f, 0.22276704f, 0.02227043f, 0.00989835f, 0.02962413f, -0.12464125f, 0.08409232f, 0.10442372f, 
    -0.01638261f, -0.06334926f, -0.03184289f, -0.01378430f, -1.19414866f, -0.24765483f, -0.19374955f, -0.60603690f, 
    -0.15337487f, 0.08306992f, -0.05869977f, -0.42965275f, 0.01066278f, -0.03404655f, -0.05900988f, -0.07719862f, 
    -0.18801074f, -0.10124487f, 0.11551477f, -0.06266256f, 0.04395032f, -0.02829356f, 0.05490270f, 0.01166551f, 
    -0.02421164f, -0.03633478f, -0.26613438f, 0.16167954f, -0.28388017f, 0.03025205f, -0.20428671f, -0.38232422f, 
    0.05113391f, 0.10393615f, 0.08801885f, 0.06272394f, 0.00768740f, -0.03736415f, 0.08793253f, -0.07206236f, 
    -0.50138676f, 0.02020520f, 0.31319124f, -0.23397934f, -0.03608944f, -0.06376084f, -0.08879814f, 0.01796983f, 
    0.02884164f, 0.03471189f, -0.06163644f, 0.05956807f, -0.05994049f, -0.13069290f, 0.25723636f, -0.28157991f, 
    -0.08676814f, -0.21639158f, 0.06435068f, 0.08552991f, -0.04322605f, 0.03423231f, 0.07582843f, -0.04174217f, 
    -0.53445679f, -0.37171379f, -0.28961253f, -0.02691351f, -0.06780386f, 0.05932668f, 0.05162968f, 0.02328053f, 
    -0.06513920f, -0.04582942f, 0.01975411f, -0.20022936f, 0.05235131f, -0.14555332f, -0.16084339f, 0.12676190f, 
    0.09941990f, -0.03288701f, 0.05722727f, 0.06757928f, -0.09846589f, -0.08079534f, 0.11328426f, 0.04656483f, 
    -0.92957342f, -0.50105226f, -0.24759504f, -0.01855855f, -0.17386390f, 0.09686628f, -0.20111719f, 0.12052783f, 
    0.03655029f, -0.04751689f, -0.04952677f, -0.05808253f, -0.58238620f, 0.48519892f, 0.41815555f, 0.58085251f, 
    -0.08621298f, -0.05354372f, 0.09391540f, 0.02244120f, -0.02024557f, -0.02085365f, -0.05585577f, -0.07577409f, 
    -0.26976758f, -0.03395588f, 0.07102997f, -0.18680283f, -0.03839035f, 0.00627300f, -0.01885624f, -0.28062218f, 
    0.09559848f, 0.01569299f, 0.00079997f, -0.07510176f, -0.03692604f, -0.03355718f, -0.01000798f, -0.04841520f, 
    -0.12106269f, -0.06967670f, -0.21408769f, 0.08447579f, -0.07023188f, -0.02856395f, -0.11849894f, 0.09655257f, 
    -0.23665909f, 0.01762206f, -0.44525415f, 0.08419799f, 0.07681307f, 0.08031500f, 0.01348232f, 0.10466706f, 
    -0.05914947f, -0.07821764f, -0.18700519f, -0.06888383f, -0.27658370f, 0.54266745f, 0.17332254f, -0.42600754f, 
    0.00732803f, 0.02583779f, -0.09648705f, 0.15494177f, -0.02829938f, 0.00435650f, -0.04635435f, -0.03522980f, 
    0.09741686f, 0.00282543f, 0.04599018f, 0.29208872f, -0.11152945f, 0.03437711f, 0.02581590f, -0.11867150f, 
    -0.07941786f, 0.14283977f, -0.23128052f, 0.11425366f, 0.05279279f, -0.31827468f, 0.17330585f, -0.13322426f, 
    -0.14986755f, -0.30604333f, -0.35208175f, -0.00177413f, -0.25058162f, -0.02137271f, -0.30231586f, 0.02150182f, 
    -0.24107775f, 0.17641115f, -0.11595748f, 0.13780107f, -0.24948557f, -0.03047185f, 0.00460500f, -0.12506370f, 
    0.01649990f, 0.09482793f, 0.01633235f, 0.09980986f, 0.78982615f, 0.37873343f, 0.23448266f, -0.29883432f, 
    -0.19302262f, 0.23576611f, 0.10866936f, 0.14951886f, 0.00172849f, -0.01552886f, 0.17177890f, -0.09800848f, 
    0.43101931f, -0.37244493f, 0.02458264f, 0.05316869f, 0.30247617f, 0.16626500f, 0.14759853f, 0.04013228f, 
    -0.10386120f, 0.01665374f, -0.00522483f, 0.05743849f, -0.53303933f, 0.09568163f, -0.09008019f, 0.34502402f, 
    0.10118759f, 0.11149252f, 0.00300994f, -0.15809432f, -0.03129145f, 0.03186969f, 0.12101255f, 0.19718051f, 
    0.06213078f, -0.04208762f, -0.23651627f, 0.04805214f, 0.07764166f, -0.13782372f, 0.11153099f, 0.13066491f, 
    -0.06562004f, 0.01722125f, -0.07255339f, -0.12273816f, -0.36620429f, -0.06725363f, 0.13553959f, 0.23280349f, 
    -0.36902988f, 0.10421091f, -0.12574051f, -0.03843879f, 0.02528530f, 0.09476995f, -0.23952140f, 0.23934902f, 
    0.62879086f, 0.07936604f, -0.06768576f, 0.32595873f, -0.08675850f, 0.02910630f, -0.11876845f, -0.13010862f, 
    -0.19021088f, -0.01853478f, 0.08673397f, 0.08602059f, -0.01797027f, 0.25054684f, -0.17095388f, 0.04555321f, 
    0.12945957f, 0.08470473f, -0.03270060f, -0.19256507f, -0.26316783f, -0.05616201f, 0.22735371f, 0.12889236f, 
    -0.21991131f, -0.17470558f, -0.43482959f, -0.06138449f, 0.06550679f, -0.05460187f, 0.07854535f, -0.15965733f, 
    -0.11719322f, -0.00440953f, -0.08060061f, -0.01086798f, -0.16303672f, 0.01426380f, -0.07921814f, 0.21614781f, 
    0.15712264f, 0.00737645f, 0.01355080f, 0.00491277f, -0.20900872f, 0.08110537f, -0.08968376f, -0.05337994f, 
    0.13446702f, -0.21122065f, -0.09665353f, -0.07397667f, -0.09134901f, -0.11224938f, 0.06276300f, -0.09847206f, 
    0.11823165f, -0.09729704f, -0.07164223f, -0.04178862f, -0.11340588f, 0.12469715f, 0.24222185f, -0.14267622f, 
    0.06801607f, -0.16177307f, -0.29450214f, -0.03691307f, 0.20895223f, -0.44611281f, 0.28566623f, -0.02409702f, 
    1.20286024f, -0.23648234f, -0.02712396f, 0.19338271f, 0.24165060f, -0.02287379f, 0.03073924f, -0.28685877f, 
    -0.14053276f, -0.06971436f, -0.03821630f, 0.26534185f, 0.20283800f, 0.40861902f, 0.16525947f, -0.21368939f, 
    -0.09516059f, 0.08107238f, -0.31257614f, -0.42817312f, -0.04361401f, 0.14246397f, 0.11502237f, -0.39605704f, 
    -0.34924838f, 0.00164885f, -0.04422978f, -0.24448361f, 0.07593811f, -0.22899307f, -0.12563324f, 0.06155372f, 
    -0.09208228f, -0.17033739f, -0.22918053f, 0.10069430f, -0.29285875f, 0.42105857f, -0.46883366f, -0.19570625f, 
    0.12394611f, 0.04587477f, 0.03423088f, -0.11909171f, -0.22086361f, -0.09845420f, -0.04126779f, 0.02363960f, 
    -0.00460677f, -0.07878665f, -0.10749340f, 0.13816310f, 0.09295645f, 0.09292186f, 0.08338071f, -0.01980648f, 
    -0.01756262f, 0.08626037f, 0.08699509f, 0.09081121f, -0.43570650f, -0.14861158f, -0.00402923f, 0.43502891f, 
    -0.01561755f, -0.02192703f, 0.19731018f, 0.00558105f, -0.16302827f, 0.06683031f, -0.24761848f, -0.02903371f, 
    0.19430491f, -0.23219635f, -0.05607684f, -0.07781109f, -0.01986344f, 0.17613338f, -0.15332676f, 0.15747143f, 
    -0.22807731f, 0.42931300f, -0.10872104f, 0.04415082f, -0.11642011f, 0.18656614f, -0.05543525f, 0.30704945f, 
    0.12978056f, -0.02134802f, -0.08626967f, 0.12409432f, 0.08853766f, -0.14622013f, 0.00682666f, 0.17713381f, 
    -0.26768953f, -0.72035891f, 0.62384421f, 0.23675205f, -0.24582002f, -0.13440183f, 0.00070591f, 0.00952914f, 
    0.07909855f, -0.02116003f, -0.06069249f, 0.20584279f, -0.39387667f, -0.00843932f, -0.16726963f, 0.21212998f, 
    0.15406023f, -0.05231313f, 0.02310754f, -0.12290715f, -0.03735186f, -0.04340324f, 0.11458827f, -0.12300655f, 
    -0.44053334f, -0.24508227f, 0.12740886f, 0.00484205f, 0.13860187f, 0.02417578f, 0.21450627f, -0.08044846f, 
    -0.24956432f, 0.17654790f, -0.09569715f, 0.04045463f, 0.26974836f, 0.71611851f, -0.30652002f, -0.30845305f, 
    -0.17303386f, 0.16646208f, -0.52868950f, -0.13705108f, -0.16280171f, -0.46225831f, 0.23504446f, 0.09515899f, 
    0.06239419f, -0.12959139f, -0.10885124f, 0.00881936f, -0.08235507f, 0.00701497f, -0.04528971f, -0.07259348f, 
    -0.01153647f, 0.05617268f, -0.01333866f, -0.05915505f, 0.21875593f, -0.18247727f, 0.07938879f, 0.27885601f, 
    -0.01599308f, 0.05117498f, -0.01581374f, -0.01770990f, -0.04153369f, 0.05730323f, 0.08019042f, 0.07073366f, 
    -0.19360586f, -0.00540459f, 0.21667470f, 0.34113866f, 0.06889504f, 0.18245073f, -0.05124753f, 0.05316916f, 
    0.03800517f, -0.04480362f, 0.25513259f, -0.12771678f, -0.13634792f, -0.03240876f, 0.02648474f, 0.27059615f, 
    -0.01127841f, -0.17232755f, -0.20367201f, -0.03173888f, 0.00243320f, 0.33438435f, -0.26021653f, 0.11306958f, 
    0.07044324f, -0.16441056f, -0.08609352f, -0.59700847f, 0.21992145f, -0.09250367f, -0.05163106f, -0.05073711f, 
    -0.06527468f, 0.19012187f, -0.15516536f, -0.06579684f, -0.49289465f, -0.04462418f, -0.03296762f, 0.34908408f, 
    -0.00209331f, -0.09457147f, -0.23920895f, -0.00700743f, 0.05832809f, 0.00814787f, 0.01274426f, -0.09861599f, 
    -0.13475952f, 0.08937284f, -0.10904402f, 0.25096834f, 0.15492789f, 0.07441434f, -0.01509523f, -0.02498738f, 
    -0.04869513f, -0.10957932f, 0.11024913f, -0.06275640f, -0.22979271f, 0.06075312f, -0.55249017f, -0.15223376f, 
    0.05707218f, -0.07272447f, 0.04491787f, -0.08880167f, 0.00292083f, -0.03778675f, 0.02959973f, -0.42279133f, 
    0.04199709f, -0.08003629f, -0.05715565f, -0.04569514f, -0.28086913f, 0.12276997f, -0.07857943f, -0.02689072f, 
    -0.14760283f, -0.11471051f, -0.18297209f, 0.07662895f, 0.13137472f, -0.11622719f, -0.18065614f, -0.12014966f, 
    0.06686374f, -0.00325332f, 0.06967493f, -0.07944421f, 0.05280667f, 0.11137176f, 0.17049538f, 0.57186228f, 
    0.06989882f, 0.44984812f, 0.13455157f, 0.14073324f, 0.03798564f, -0.03423800f, -0.00653688f, 0.03858446f, 
    0.15591577f, -0.22729744f, -0.15150408f, 0.04916243f, -0.31055748f, -0.23116493f, -0.03763467f, 0.04112707f, 
    0.01414295f, 0.01839114f, -0.12442887f, -0.06322982f, -0.05265055f, -0.05918888f, -0.09814122f, 0.07100686f, 
    0.13113651f, 0.16421296f, 0.45411626f, 0.25381786f, -0.03890089f, 0.10172173f, 0.01080221f, -0.05485047f, 
    -0.06709852f, -0.07197359f, 0.09677073f, -0.15606330f, 0.34126779f, -0.06714702f, -0.29102090f, 0.30613515f, 
    0.11249609f, -0.07597038f, 0.08835258f, -0.13794559f, 0.07163453f, -0.08742431f, 0.00048650f, 0.00096428f, 
    -0.18437469f, 0.00376015f, -0.38885614f, -0.03752007f, 0.11812771f, -0.13166970f, -0.05777963f, 0.01974283f, 
    0.04837696f, -0.17724548f, 0.02725656f, -0.08426388f, -0.00568546f, -0.13555776f, 0.02076496f, 0.10581952f, 
    0.14030737f, 0.04084894f, 0.01712129f, 0.10834002f, -0.00300851f, -0.10239225f, -0.09216528f, -0.13378645f, 
    0.14877319f, 0.08290012f, -0.22868437f, 0.04892575f, 0.11469144f, -0.06617402f, -0.09945147f, -0.22404791f, 
    -0.19930713f, -0.15180664f, 0.01853368f, -0.35677120f, 0.15194917f, -0.10567012f, 0.11125180f, 0.06163990f, 
    -0.04653931f, 0.00933077f, -0.02447473f, 0.10307257f, 0.16921005f, -0.19508049f, 0.15305512f, -0.02059215f, 
    -0.01920366f, 0.11000796f, 0.05644148f, 0.12945668f, -0.07872754f, 0.16177613f, -0.07297118f, -0.07668722f, 
    0.02963527f, -0.03055011f, 0.06093062f, -0.04382173f, 0.22208732f, 0.07106950f, -0.18841039f, 0.21749549f, 
    -0.03237943f, 0.01361606f, -0.00365572f, -0.17409864f, -0.12997404f, -0.13112815f, -0.33382273f, -0.31332856f, 
    -0.28471136f, -0.08453047f, -0.16140290f, 0.03420377f, -0.13503064f, -0.22045793f, 0.09047214f, -0.04346262f, 
    -0.05024413f, -0.03037182f, 0.04216942f, 0.03444589f, -0.13116106f, -0.28046840f, -0.27148005f, 0.17269796f, 
    -0.25505161f, 0.03775504f, -0.04261510f, -0.40889475f, -0.05711792f, -0.11551914f, -0.21960388f, 0.03280278f, 
    0.11087026f, 0.08072479f, 0.00837740f, 0.04854359f, 0.14155608f, 0.00070056f, 0.08658617f, 0.04918488f, 
    -0.03382472f, -0.00872128f, 0.01008386f, -0.04188965f, 0.04241277f, -0.17474818f, 0.24680136f, 0.17421846f, 
    -0.06902594f, -0.14038999f, -0.09327733f, -0.00183421f, -0.04861855f, 0.35491717f, 0.06740589f, 0.24386854f, 
    0.02764688f, 0.17001523f, 0.02451529f, 0.22181499f, -0.02810869f, -0.19035093f, -0.19474864f, -0.24169299f, 
    0.04183838f, 0.04821992f, -0.02439052f, 0.03526765f, 0.22425352f, 0.25177214f, 0.33353251f, 0.00836823f, 
    0.12227828f, 0.18345605f, 0.13801399f, 0.18782477f, 0.03957166f, -0.04849966f, 0.12985758f, -0.11140500f, 
    0.09585872f, 0.12892219f, -0.48915464f, -0.45678923f, 0.11174210f, -0.01215892f, 0.01627458f, 0.04075884f, 
    0.15238272f, -0.13047309f, -0.00947668f, -0.06166700f, 0.02471603f, -0.22380944f, 0.29340902f, 0.04049417f, 
    -0.11673716f, -0.05497464f, 0.02404039f, 0.06881921f, 0.01927520f, 0.00445163f, -0.02085701f, 0.01234301f, 
    0.20759118f, 0.18567573f, -0.05895749f, 0.27595150f, -0.03502702f, 0.11378026f, 0.06197690f, 0.08017430f, 
    0.11655255f, 0.01808873f, 0.00609369f, -0.10285834f, 0.15621339f, 0.03997089f, 0.08186686f, 0.13554268f, 
    -0.15582232f, -0.10674710f, -0.13914552f, -0.08067211f, -0.26783639f, -0.05313344f, -0.02236897f, 0.09922794f, 
    0.16804001f, 0.03331651f, 0.05010662f, -0.03294518f, 0.11620276f, 0.05767124f, 0.07456228f, 0.11640894f, 
    0.04709873f, -0.00801500f, -0.00828408f, -0.01326840f, 0.12209412f, -0.23200434f, 0.09652928f, 0.24765156f, 
    0.09130798f, -0.15126893f, 0.04036475f, 0.08598503f, 0.07626393f, -0.11079566f, -0.38918135f, -0.13880475f, 
    -0.05620440f, 0.01890433f, 0.16906293f, 0.02496183f, -0.10253061f, 0.02234460f, -0.04485426f, 0.01413595f, 
    0.00420777f, 0.01862191f, 0.02117239f, -0.00988411f, -0.27922350f, -0.08946060f, 0.01951806f, 0.16037796f, 
    -0.00516506f, -0.06096428f, -0.04592290f, -0.05870483f, -0.03249937f, -0.01752378f, 0.10933261f, 0.19314371f, 
    -0.03324858f, 0.10484444f, 0.20997012f, 0.16920766f, -0.01664986f, -0.00040542f, 0.05424749f, -0.12368844f, 
    0.07570233f, -0.03064183f, 0.11438305f, 0.07613735f, -0.02340422f, 0.08006938f, 0.11815631f, 0.08497833f, 
    -0.02644960f, -0.18440893f, 0.17360091f, -0.04661791f, -0.02816471f, -0.02683440f, 0.05416710f, -0.22641532f, 
    0.19577658f, 0.02057387f, -0.30002150f, 0.03969193f, -0.10096720f, -0.01728963f, -0.03316377f, 0.02213853f, 
    -0.17998850f, -0.07868153f, -0.26643980f, -0.21160506f, -0.25413468f, 0.13476016f, -0.88864607f, -0.08185673f, 
    0.12248992f, 0.04457559f, -0.21033609f, 0.12046877f, -0.01527518f, 0.05912048f, -0.09410062f, 0.11907203f, 
    0.13029215f, 0.12497412f, 0.24372120f, -0.16891837f, -0.03606012f, -0.09347902f, -0.01343244f, 0.14081241f, 
    0.11510819f, -0.08600512f, 0.00537738f, 0.02142670f, -0.28427058f, -0.11118404f, -0.49984807f, 0.06545489f, 
    0.12463819f, 0.08660908f, -0.09401561f, 0.14566576f, 0.01177781f, -0.30058813f, 0.14345650f, 0.23472145f, 
    0.07875527f, -0.28548875f, 0.32193205f, 0.27970955f, -0.03077794f, -0.03953022f, 0.03561569f, -0.15854287f, 
    -0.03012632f, -0.09471331f, -0.07935865f, -0.13162704f, -0.35595486f, -0.22384858f, -0.04181381f, 0.01263265f, 
    0.02772005f, -0.01108658f, 0.06043340f, 0.05692152f, 0.03433480f, -0.44563463f, -0.50377989f, -0.64489663f, 
    -0.90717727f, -0.36043286f, -0.19431269f, -0.34734207f, -0.07002715f, -0.01637503f, -0.02419917f, -0.01524694f, 
    0.13030314f, -0.07009458f, 0.06338222f, -0.07024840f, -0.20313676f, -0.03032104f, -0.12858431f, -0.45078239f, 
    0.03737830f, 0.02842259f, -0.13205816f, 0.19721714f, 0.15998584f, -0.20549685f, 0.08838108f, -0.18933365f, 
    0.33398351f, 0.02744427f, 0.25606319f, 0.03925428f, 0.19148907f, 0.13922474f, 0.11032455f, -0.22146857f, 
    0.03779961f, -0.03350537f, 0.00787978f, 0.06312761f, 0.06221396f, -0.09531501f, -0.04966885f, -0.12976174f, 
    0.02914098f, 0.13766675f, -0.11251958f, 0.07248207f, 0.01477597f, -0.08205916f, 0.06329975f, -0.14978862f, 
    -0.27045599f, 0.07587732f, -0.21238355f, 0.23524942f, 0.07900050f, -0.20763627f, 0.10374041f, 0.04805466f, 
    0.10544883f, 0.12865223f, -0.14517882f, 0.28390068f, 0.09869517f, -0.06289764f, -0.05488380f, 0.03374174f, 
    -0.11429574f, -0.17600247f, -0.07757091f, -0.03636117f, 0.16386363f, 0.06428716f, -0.06334755f, 0.24132746f, 
    0.01373706f, 0.13144417f, 0.11288333f, -0.24631940f, -0.08264845f, 0.11944640f, -0.02754917f, 0.06096432f, 
    0.23663114f, -0.01078947f, 0.23770741f, -0.01622668f, -0.07331701f, 0.08179239f, -0.16970544f, -0.17552416f, 
    0.04551212f, -0.05979716f, -0.04548155f, 0.02718640f, 0.02282724f, -0.08555770f, 0.03358037f, -0.07924308f, 
    -0.04779348f, -0.08240782f, 0.19470175f, -0.13191725f, -0.02205257f, 0.01440545f, 0.02087531f, 0.22853267f, 
    -0.01832479f, -0.03094885f, 0.05033643f, 0.11024094f, -0.05098670f, -0.20187943f, 0.06164884f, 0.08520706f, 
    0.16930351f, -0.27104330f, -0.10848426f, 0.18799412f, -0.06075230f, 0.12841298f, -0.28925809f, -0.01258544f, 
    -1.01451886f, 0.12688597f, -0.10915279f, -0.12280660f, -0.15270689f, -0.19857253f, 0.09650009f, 0.40805051f, 
    -0.00183311f, -0.16483541f, 0.04451042f, -0.12408415f, -0.08062192f, -0.06185242f, 0.43070546f, 0.34502816f, 
    0.20326054f, 0.10250207f, 0.22022729f, 0.19770785f, 0.01005638f, 0.09486854f, -0.09780694f, 0.11244351f, 
    -0.02348169f, -0.09842599f, -0.12286074f, 0.02167983f, -0.15573701f, 0.26424167f, 0.04875492f, 0.04819824f, 
    0.08823945f, 0.06463391f, 0.07178587f, -0.02778111f, 0.01161383f, 0.16938099f, 0.46478325f, -0.33799955f, 
    0.13296717f, -0.15010834f, -0.03847079f, 0.00448732f, 0.23374788f, -0.23857477f, -0.07223991f, 0.00747000f, 
    -0.40397015f, -0.00042042f, 0.18645357f, -0.19603501f, -0.15641840f, 0.15891267f, 0.11802752f, -0.38070813f, 
    0.13265298f, 0.16537203f, 0.04950402f, -0.13530901f, 0.16170357f, 0.17987122f, 0.16922821f, -0.19775280f, 
    0.13846134f, -0.04587707f, 0.05313998f, -0.14962876f, -0.06043590f, -0.08960562f, 0.10978492f, 0.08584221f, 
    0.25857157f, -0.02944878f, -0.50547045f, 0.07384157f, 0.00873648f, -0.00582406f, -0.10658575f, 0.04909565f, 
    -0.02052706f, -0.17019664f, 0.06180771f, -0.12472811f, 0.11013125f, 0.15443787f, 0.10425698f, -0.01345213f, 
    -0.19491974f, -0.14671493f, -0.22156398f, -0.01786124f, -0.18048638f, 0.17587636f, -0.05735828f, -0.07134140f, 
    -0.22863869f, -0.27579275f, -0.23903582f, 0.20641130f, 0.21610710f, -0.00656183f, -0.00343231f, 0.05532521f, 
    -0.02324801f, -0.05246251f, 0.00508617f, -0.10820725f, 0.01993225f, 0.12903100f, 0.03338896f, -0.24889088f, 
    0.15396130f, 0.28944686f, 0.07402762f, -0.07662328f, 0.15302984f, 0.18904558f, -0.08579518f, 0.03245363f, 
    -0.24289089f, -0.10043983f, -0.04046731f, 0.07556837f, -0.00614425f, -0.07102551f, 0.01540305f, -0.04171258f, 
    0.09773745f, -0.04217179f, 0.09537761f, 0.15923843f, -0.21832132f, 0.26935896f, 0.04142897f, -0.33255783f, 
    0.01854408f, 0.07147348f, 0.11133403f, 0.05300741f, 0.22809005f, -0.08076412f, 0.00036123f, 0.06754518f, 
    0.03863887f, -0.01501759f, 0.21158974f, -0.05718166f, 0.18525113f, -0.17626013f, 0.18352646f, 0.10847485f, 
    0.02655794f, 0.02578864f, 0.03118953f, 0.08449678f, 0.07462013f, 0.11033368f, -0.08439539f, -0.37515768f, 
    0.07544461f, -0.16283648f, 0.03980898f, -0.07008085f, 0.03249146f, 0.00882228f, -0.06427088f, -0.12200032f, 
    0.12758659f, 0.15255523f, -0.18480687f, -0.23331192f, 0.04599603f, -0.06144130f, -0.04355119f, -0.04926179f, 
    -0.05213207f, -0.15608412f, -0.11429796f, -0.14306909f, 0.05386744f, -0.02327940f, -0.22964120f, -0.03337234f, 
    -0.11438341f, 0.16546719f, -0.11925001f, -0.01180457f, 0.07406394f, -0.03865578f, -0.05118703f, 0.22161795f, 
    -0.03263164f, -0.44359308f, 0.32073116f, 0.33436871f, -0.11428063f, -0.10677493f, -0.03064809f, -0.07746909f, 
    0.16377424f, 0.02359473f, 0.12430296f, 0.02512131f, 0.28290758f, -0.04045588f, -0.42504701f, 0.37232965f, 
    -0.06370006f, 0.07471398f, -0.00248749f, -0.06499876f, 0.23751968f, -0.06627736f, -0.12050092f, 0.15806854f, 
    -0.49643460f, -0.82253045f, -0.70474672f, -0.48948121f, -0.06219803f, -0.18557939f, 0.10818642f, 0.03451022f, 
    -0.00307875f, 0.11701176f, 0.11926953f, -0.28694570f, -0.11409958f, 0.07608229f, 0.36923888f, -0.32277319f, 
    0.14260998f, -0.03495056f, 0.03017868f, -0.10233422f, -0.00281475f, 0.10649277f, 0.02424669f, 0.08266120f, 
    -0.14911537f, -0.31530157f, -0.43460101f, 0.38057911f, -0.03400404f, 0.39366409f, 0.15537408f, 0.09302153f, 
    0.16311572f, -0.08028255f, 0.13559471f, 0.19297363f, -0.01882597f, 0.08993302f, 0.13178401f, -0.10723293f, 
    -0.04837091f, -0.00987374f, -0.00946831f, 0.04676866f, 0.07693451f, 0.08264092f, 0.24761142f, 0.19762050f, 
    -0.64311236f, 0.31190401f, 0.57203895f, 0.17996475f, -0.06303949f, -0.06397657f, -0.13711549f, -0.03850535f, 
    -0.09515990f, 0.20374849f, 0.00514307f, 0.03379715f, 0.20044111f, 0.42963615f, -0.12678117f, 0.24062867f, 
    0.10008016f, -0.00513554f, 0.15623084f, 0.13509667f, 0.08772840f, 0.06527732f, 0.30952334f, -0.17741825f, 
    -0.80562085f, -0.60217369f, -0.74459314f, -0.60484540f, -0.11211350f, -0.11033967f, -0.23645060f, -0.16396716f, 
    0.02714003f, -0.00263926f, 0.09294423f, -0.04892429f, -0.09387607f, -0.19565266f, 0.13055013f, -0.16841586f, 
    0.01351007f, 0.18549825f, 0.05164440f, -0.00719847f, 0.02820382f, -0.00036204f, -0.12056261f, 0.00588030f, 
    0.12248397f, -0.37022603f, -0.34984711f, 0.46298897f, -0.09329058f, -0.24711874f, 0.10814441f, 0.03497567f, 
    -0.00367930f, -0.04451380f, -0.14149494f, -0.12023073f, -0.09832254f, -0.07985748f, -0.15111169f, -0.04301329f, 
    0.00279584f, -0.00872067f, -0.00730264f, 0.01880919f, 0.04229945f, 0.08617834f, -0.12891991f, 0.03494394f, 
    0.11325081f, -0.11721031f, 0.23052092f, 0.09185191f, -0.01625267f, -0.02819102f, 0.10086824f, 0.08790010f, 
    -0.04455525f, 0.00802904f, -0.00108223f, -0.05996638f, -0.20763630f, 0.38792345f, 0.31599572f, -0.11445004f, 
    -0.09653673f, 0.03699360f, 0.02928067f, 0.10414404f, 0.02026008f, 0.07471558f, -0.03251696f, 0.02185511f, 
    -0.52310264f, -0.58153600f, -0.48274377f, 0.00868892f, -0.28549471f, 0.12179049f, -0.02884289f, 0.28337047f, 
    0.05651744f, 0.05005386f, 0.09533191f, -0.08203413f, -0.38684812f, 0.05358439f, -0.04104649f, -0.03864754f, 
    -0.20900090f, 0.04418055f, -0.04058937f, -0.02625977f, 0.15286370f, 0.08443266f, -0.01737938f, 0.16271158f, 
    -0.09682052f, -0.27989253f, 0.08152293f, 0.29183891f, -0.03919978f, 0.13772504f, 0.12400363f, 0.13277385f, 
    0.11332409f, -0.04970218f, 0.15214118f, 0.14687192f, -0.20970884f, -0.17947763f, 0.16380566f, -0.32386249f, 
    0.09007674f, 0.11182635f, -0.17834082f, -0.29320788f, -0.05431067f, -0.03076828f, 0.08470011f, 0.07891949f, 
    -0.13175626f, -0.00437461f, 0.09222826f, 0.24878901f, -0.13965382f, -0.04646175f, -0.02836330f, -0.19508880f, 
    -0.21479703f, -0.16656169f, -0.10424376f, 0.02265040f, -0.35859156f, -0.01925571f, 0.12162432f, -0.04450992f, 
    0.00219792f, 0.01663260f, 0.06942483f, 0.06363977f, 0.21481226f, 0.22110829f, 0.12195481f, 0.01587308f, 
    -0.46098205f, -0.63931078f, 0.74533880f, 0.46624067f, -0.12467565f, -0.11761949f, -0.08510613f, -0.18463321f, 
    -0.17195985f, 0.05870267f, -0.00199530f, -0.08246870f, -0.66466409f, -0.89078200f, 0.11520295f, -0.24391505f, 
    -0.03687377f, -0.07088460f, -0.03963589f, -0.33747280f, 0.07525526f, -0.04829636f, -0.10407226f, 0.07837711f, 
    0.03224457f, 0.04434256f, -0.02582381f, 0.04057291f, 0.00253948f, -0.01961908f, 0.02136961f, -0.03129753f, 
    -0.00851779f, 0.08955767f, 0.12045372f, -0.18549030f, -0.34123537f, -0.34811333f, 0.08489938f, 0.59794343f, 
    -0.05932113f, 0.19203676f, 0.00080346f, -0.26447627f, 0.03432499f, 0.13439022f, 0.07145514f, 0.12979496f, 
    0.21792223f, -0.46891329f, -0.31384635f, -0.32709306f, -0.05615271f, 0.12547584f, 0.24612793f, -0.01719025f, 
    -0.02503341f, 0.06271012f, -0.02454532f, 0.02210229f, -0.68432689f, 0.30990154f, 0.38580075f, -0.00232412f, 
    -0.20613129f, -0.20300037f, -0.16843687f, -0.01819667f, -0.09605998f, -0.07982643f, -0.03349855f, 0.04121704f, 
    -0.17885597f, 0.01028382f, -0.29726234f, -0.24906935f, 0.02426255f, -0.06988697f, 0.00725014f, -0.07671525f, 
    -0.13429794f, -0.04024455f, -0.12069800f, -0.09101323f, -0.03677026f, -0.21488531f, -0.00679140f, -0.02173106f, 
    0.07280353f, 0.01409839f, -0.08201972f, 0.04240800f, -0.04853241f, 0.08664403f, 0.05078467f, -0.17531890f, 
    -0.53389692f, -0.45126384f, -0.77192670f, -0.14827414f, -0.16558543f, -0.15944494f, 0.16827887f, -0.11199801f, 
    -0.04423125f, -0.03174968f, 0.02953070f, 0.02384599f, -0.37188500f, -0.66878325f, -0.23751168f, -0.23917437f, 
    -0.12427144f, -0.20453157f, -0.15685731f, -0.24919255f, -0.07182728f, -0.00993737f, -0.04019352f, 0.10648332f, 
    0.18245889f, 0.18417023f, -0.49009007f, -0.23297842f, -0.06875747f, 0.14441687f, 0.22860315f, -0.07972314f, 
    0.05975061f, 0.03706204f, 0.04135033f, 0.09606197f, 0.12278488f, 0.03076480f, -0.07462133f, -0.11501393f, 
    0.06494334f, -0.49110731f, 0.15194626f, -0.04400118f, 0.08606841f, -0.16266945f, -0.01120046f, -0.22415882f, 
    -0.08907891f, -0.02505298f, 0.20314631f, 0.29289836f, -0.12386240f, -0.17573282f, -0.05447539f, 0.05366459f, 
    0.02216105f, 0.11306625f, 0.13263176f, 0.01243658f, 0.54126626f, 0.23968868f, 0.11291523f, 0.05914686f, 
    -0.01136849f, -0.09779530f, 0.23505005f, -0.05064492f, -0.03026162f, 0.10383699f, 0.16883612f, -0.00253440f, 
    -0.36363372f, -0.59931237f, 0.38770378f, 0.50741941f, -0.05103175f, 0.03568165f, -0.15660529f, 0.08001039f, 
    0.04284168f, -0.05912652f, -0.09517917f, -0.08075996f, -0.06384923f, 0.15341300f, -0.16367710f, 0.12864822f, 
    -0.07271994f, 0.03049153f, -0.00201779f, -0.11476032f, -0.01314194f, 0.00658910f, -0.06240196f, -0.19980559f, 
    0.16002430f, -0.36964375f, 0.13504258f, -0.16164802f, -0.09285029f, 0.22986959f, -0.04299439f, -0.20700541f, 
    0.07853107f, -0.04486440f, 0.07239882f, 0.03127547f, 0.19113478f, 0.06395680f, 0.01644405f, 0.03596503f, 
    0.04597358f, -0.03651112f, -0.01504419f, -0.05807073f, 0.09094555f, -0.00879949f, 0.07338777f, 0.02870818f, 
    0.76021749f, -0.85219502f, -0.54203957f, -0.43085191f, -0.09450666f, -0.01339780f, -0.20427708f, 0.11070058f, 
    0.17450869f, -0.11681410f, 0.01682034f, 0.04481806f, -0.46566862f, 0.11334892f, 0.18591668f, 0.03380382f, 
    -0.12303846f, -0.07044798f, 0.25516164f, -0.01592918f, 0.01674745f, 0.00365530f, 0.05651891f, -0.12583980f, 
    -0.76990491f, -0.63213336f, 0.25313598f, 0.50556904f, -0.02547940f, -0.00772073f, -0.03038674f, -0.02094220f, 
    -0.02238716f, -0.01034036f, -0.02468612f, -0.10776682f, 0.07764656f, 0.11470316f, -0.01424402f, -0.10871540f, 
    0.00224527f, -0.15068807f, -0.06535257f, 0.03533766f, 0.06695309f, -0.03230974f, 0.06055516f, -0.03517234f, 
    -0.24274275f, -0.13467228f, -0.15990514f, 0.15770777f, -0.16162781f, 0.25657871f, 0.06474344f, -0.00446158f, 
    0.08631628f, -0.03450048f, 0.05999702f, 0.03802754f, 0.20226689f, 0.01025471f, 0.03819475f, -0.12861362f, 
    0.01172744f, 0.06565949f, 0.04167621f, 0.04048466f, 0.02934185f, -0.01980983f, 0.03224587f, -0.04806313f, 
    0.03809693f, 0.00069435f, 0.17468156f, -0.15371826f, -0.10546235f, -0.06609295f, 0.03754584f, 0.04767642f, 
    -0.01587924f, -0.03116374f, 0.13818170f, -0.11263898f, 0.23197018f, -0.09373548f, -0.19144414f, -0.16845015f, 
    0.03517336f, 0.03903582f, 0.04319739f, -0.04596409f, 0.18957487f, -0.11259632f, -0.02999279f, 0.08594755f, 
    -0.01877050f, -0.22444513f, -0.04873721f, 0.13200693f, -0.02655347f, 0.03818876f, -0.00254892f, 0.02537639f, 
    0.00457972f, 0.02178781f, -0.10597333f, -0.14116122f, 0.29488611f, -0.07436106f, -0.01025674f, -0.05402028f, 
    -0.01067889f, 0.05043855f, -0.04715062f, -0.05722832f, -0.01442564f, 0.07293154f, -0.06432140f, -0.05573278f, 
    0.66077238f, -0.35624829f, -0.37081224f, -0.34088513f, 0.02502848f, -0.00702704f, -0.14934745f, -0.10516611f, 
    0.10407863f, -0.04274377f, -0.03828377f, -0.01896286f, -0.31236774f, 0.46170914f, -0.52017522f, 0.40885201f, 
    -0.15292110f, 0.09499002f, -0.26783490f, 0.17063044f, -0.01492564f, 0.12816487f, -0.12994337f, -0.03024360f, 
    0.06027000f, 0.05072711f, -0.01899939f, -0.04651726f, -0.16892008f, -0.06731109f, -0.02507501f, -0.00815195f, 
    -0.10947380f, 0.01078403f, 0.08516075f, -0.03970267f, 0.53063130f, -0.58160013f, 0.04093992f, -0.40635246f, 
    0.07402246f, 0.09313668f, 0.03335620f, -0.05075056f, 0.02449594f, 0.19225582f, -0.05869678f, -0.05186814f, 
    0.27942637f, -0.76634169f, -0.60150433f, -0.21751758f, 0.05343894f, -0.01167390f, -0.09731033f, 0.18722619f, 
    -0.01822191f, -0.09022352f, 0.03870702f, 0.01870715f, -0.61759269f, -0.08709104f, 0.51059884f, -0.35436055f, 
    -0.11254260f, 0.01540197f, 0.11485817f, 0.08842143f, -0.08888101f, -0.06299956f, -0.00047010f, -0.12648323f, 
    -0.16695228f, 0.00637922f, 0.05968420f, 0.06891683f, 0.11881291f, 0.08715322f, 0.04234815f, -0.08206654f, 
    0.03329771f, -0.00828357f, 0.01804487f, -0.07333766f, -0.22956795f, 0.13452129f, -0.01821515f, -0.31986910f, 
    0.21814962f, 0.05235113f, 0.02904077f, 0.23723723f, -0.03287029f, -0.00298689f, 0.12349562f, 0.12754130f, 
    -0.02291072f, 0.09652921f, -0.08507069f, -0.05955534f, -0.07522011f, -0.08345331f, -0.09633751f, 0.04467939f, 
    0.03703802f, 0.02011988f, 0.08927963f, 0.04966540f, -0.70319188f, -0.16612323f, 0.38492778f, -0.06961171f, 
    0.03453027f, -0.20423152f, -0.02956251f, -0.02074818f, -0.13059106f, 0.00960924f, 0.01869222f, 0.04082793f, 
    0.11406446f, 0.02220679f, -0.01819143f, -0.07683742f, 0.10830527f, 0.03969629f, 0.05395876f, -0.05500479f, 
    0.02652253f, -0.02494925f, -0.06661520f, -0.12524685f, -0.05627877f, 0.15231010f, -0.15654977f, 0.02623432f, 
    -0.38750997f, -0.15860507f, 0.04260499f, -0.14536785f, -0.04957280f, 0.04861502f, -0.10190754f, -0.05441906f, 
    -0.32970789f, -0.33326280f, -0.21165356f, -0.31390920f, 0.05442728f, 0.04513359f, -0.09166202f, 0.04743068f, 
    0.05714278f, 0.01214437f, -0.07204393f, -0.11217523f, -0.35277343f, -0.29683289f, -0.19055215f, -0.29389787f, 
    0.09576450f, 0.11691515f, -0.12268638f, 0.27236822f, -0.00125155f, -0.01979438f, -0.06009809f, 0.10365624f, 
    -0.32285649f, 0.26857132f, -0.17233184f, 0.17436896f, 0.11506179f, -0.02356431f, 0.17516553f, 0.01943145f, 
    -0.15365942f, 0.22664842f, 0.05318259f, 0.00479254f, -0.01643248f, 0.03062922f, -0.06025841f, -0.02672116f, 
    -0.26647589f, 0.00137966f, 0.07324224f, 0.09165280f, -0.01272948f, 0.06014496f, 0.04634766f, 0.05769068f, 
    0.48947740f, -0.05054688f, -0.04491689f, -0.41926247f, 0.02879955f, 0.09751990f, -0.09078277f, -0.00110511f, 
    -0.23014030f, 0.08000610f, -0.25516668f, -0.21842441f, -0.26677257f, -0.02459882f, -0.20622575f, 0.27289328f, 
    -0.03228058f, 0.20885311f, 0.11127334f, -0.05071156f, -0.11367109f, -0.01076516f, 0.12497514f, -0.03333691f, 
    0.09521515f, -0.28049794f, -0.01605654f, -0.06132034f, 0.06451876f, 0.16864498f, 0.07070088f, 0.12932871f, 
    0.11470169f, 0.18118702f, 0.13702472f, 0.05631522f, -0.36242965f, 0.20227702f, 0.11763829f, 0.25646913f, 
    -0.09812909f, 0.02782090f, -0.09787956f, 0.09826022f, 0.07167070f, -0.12761575f, 0.03996586f, 0.03556193f, 
    0.28919902f, 0.20798305f, 0.05259867f, -0.06141229f, 0.29085407f, 0.20457636f, 0.15630424f, 0.04037776f, 
    0.03111626f, -0.16952889f, 0.00426490f, -0.15347505f, -0.35097644f, 0.00354142f, -0.04188673f, -0.23244688f, 
    -0.08790096f, -0.07454539f, -0.17400333f, 0.00155195f, -0.04944197f, 0.13461578f, -0.14594549f, -0.35955742f, 
    -0.41748816f, -0.43985626f, -0.46079081f, -0.00381398f, -0.01300547f, 0.14168307f, 0.12689394f, 0.14995161f, 
    0.03945593f, 0.05778101f, -0.11271468f, -0.05032825f, -0.49978241f, -0.33410326f, 0.26606739f, 0.31307900f, 
    -0.06425040f, 0.12545808f, 0.08517225f, 0.00364271f, 0.12885696f, 0.19412369f, -0.02203692f, 0.23924485f, 
    0.91453898f, -0.64741355f, -0.32195586f, -0.24004444f, 0.11031166f, -0.09681391f, -0.20819008f, 0.20384619f, 
    0.11174741f, 0.18100114f, 0.10023968f, 0.10121581f, -0.30978274f, 0.27746886f, 0.09345941f, 0.03827520f, 
    0.08478159f, -0.10147431f, -0.17686373f, -0.02536607f, 0.01980118f, 0.03820470f, -0.17647608f, -0.01212402f, 
    -0.22543237f, -0.14191423f, -0.10843430f, 0.18393227f, -0.07371270f, 0.07406712f, 0.03849144f, 0.15779524f, 
    0.08158718f, 0.12273160f, 0.23408671f, 0.05268137f, -0.09706452f, 0.06934249f, 0.05558933f, 0.12159065f, 
    -0.15189260f, -0.06537420f, -0.14861442f, -0.02206081f, 0.09521510f, 0.16324003f, 0.04308902f, 0.15847309f, 
    -0.03900211f, -0.13904332f, 0.11380799f, 0.11957052f, -0.12628829f, 0.01360507f, 0.00636624f, 0.05370913f, 
    0.14975685f, 0.13837792f, 0.00848436f, 0.15657221f, -0.19490805f, -0.28093350f, -0.21971749f, -0.12226073f, 
    -0.10701700f, 0.05455134f, 0.03050196f, 0.03759568f, -0.13809796f, -0.13782342f, -0.21068023f, -0.14526549f, 
    0.15605350f, 0.01372805f, -0.12935917f, -0.10170269f, 0.13601372f, 0.05958634f, 0.23728514f, -0.06145810f, 
    -0.05216355f, -0.05689703f, -0.06387529f, -0.05770084f, 0.01895244f, -0.04588725f, -0.24577597f, -0.10704999f, 
    0.00498443f, 0.12213941f, -0.03095374f, 0.09515698f, 0.08376519f, 0.02334190f, 0.13754615f, 0.17547667f, 
    -0.15391016f, -0.26108134f, -0.17498371f, 0.06124163f, 0.08735529f, 0.29436398f, 0.06436445f, -0.00462763f, 
    -0.12728912f, 0.01819055f, 0.01113377f, -0.27705649f, 0.48695138f, -0.01768779f, -0.21994655f, 0.03326546f, 
    0.17448853f, -0.08533043f, 0.02376566f, 0.35580930f, 0.00735676f, 0.07394789f, 0.20236915f, 0.12638229f, 
    -0.06755879f, -0.01620300f, -0.07025395f, -0.05921919f, -0.02045848f, -0.08976647f, -0.03938951f, -0.03109122f, 
    0.09651016f, 0.07498665f, 0.09800481f, 0.17959096f, 0.27127707f, -0.15416932f, -0.35334197f, -0.47589275f, 
    -0.06998941f, 0.03085113f, 0.05625656f, -0.10401985f, 0.01751555f, -0.18962646f, -0.17338772f, -0.08917406f, 
    -0.16530269f, -0.55226439f, -0.78754181f, -0.04453126f, 0.14251368f, 0.14168437f, 0.10366847f, -0.17906944f, 
    0.04446672f, 0.00160621f, 0.17898293f, -0.02191619f, -0.43569705f, -0.36387882f, -0.01622937f, -0.20401798f, 
    -0.14281638f, -0.03645014f, -0.29961404f, -0.24105863f, 0.01846609f, 0.11584765f, 0.06571042f, -0.01494608f, 
    -0.50616491f, 0.14374624f, 0.18905784f, 0.09250964f, -0.11863796f, -0.06566796f, -0.16598313f, -0.13930549f, 
    -0.14329995f, -0.00279717f, -0.12649652f, 0.04154905f, 0.30974096f, 0.21914917f, -0.32157794f, 0.14641421f, 
    -0.20983127f, -0.02308697f, -0.15039469f, -0.24370807f, 0.02984434f, -0.14526591f, -0.20021413f, -0.15194489f, 
    -0.44241908f, 0.14345475f, 0.11401021f, 0.21475300f, 0.03710554f, -0.09169552f, -0.10506269f, -0.10416532f, 
    -0.16175550f, -0.08369517f, 0.04882567f, -0.09827776f, 0.16388872f, -0.47840282f, -0.05346655f, 0.06096314f, 
    -0.24441060f, -0.02363477f, 0.20342800f, 0.10748962f, 0.09890839f, -0.14943926f, 0.12207179f, -0.05808764f, 
    -0.14254750f, 0.09455185f, -0.02864476f, -0.10136406f, -0.07739513f, -0.02230166f, -0.10937301f, -0.10689007f, 
    0.09498370f, 0.03658741f, 0.08616689f, 0.11012227f, 0.15186140f, 0.07593154f, -0.00801158f, -0.20523900f, 
    -0.00851126f, -0.14433901f, -0.10709068f, 0.08735695f, 0.14796045f, 0.17629969f, 0.06926343f, 0.13432366f, 
    -0.00616085f, -0.09670573f, -0.45108494f, -0.15336613f, 0.05500929f, -0.08929861f, 0.01842525f, -0.06763591f, 
    -0.01421602f, -0.00602767f, -0.07244389f, -0.01449728f, -0.00777563f, -0.57713091f, -0.52262366f, -0.15793689f, 
    -0.08549131f, -0.22256353f, 0.02997660f, -0.15456964f, -0.06801787f, -0.00526100f, -0.00935527f, -0.02047133f, 
    -0.22230171f, -0.28520420f, -0.04166348f, 0.14120236f, -0.01082240f, 0.16433750f, -0.05766916f, 0.09446182f, 
    -0.05130371f, -0.21766071f, -0.12452566f, -0.00565453f, -0.26287410f, -0.00378268f, -0.04565234f, 0.16004387f, 
    0.13589631f, 0.05713896f, -0.08821005f, -0.00923832f, -0.01867460f, 0.07398351f, 0.09335964f, 0.20351557f, 
    0.23512778f, -0.12773053f, -0.48366103f, -0.25850645f, 0.14573710f, -0.03307949f, 0.11174627f, -0.04923211f, 
    0.22144009f, 0.04347730f, 0.12781344f, 0.21305276f, -1.12745571f, 0.14101823f, 0.13926913f, 0.37686092f, 
    -0.04485723f, -0.03799266f, -0.28656292f, -0.03494668f, -0.12358658f, -0.02478695f, 0.20316873f, 0.03508098f, 
    -0.15678054f, -0.01928643f, -0.03121462f, 0.09742934f, -0.33730221f, 0.10561902f, -0.00414110f, -0.03152184f, 
    0.03488034f, 0.11739793f, 0.10000813f, 0.04675784f, -0.31011531f, -0.08652580f, -0.32287824f, 0.06192185f, 
    0.00131773f, 0.03251136f, 0.12511872f, 0.16095568f, 0.09145379f, 0.09220325f, -0.06735036f, -0.22981308f, 
    0.30434799f, -0.10982211f, -0.02656052f, -0.09481882f, 0.05058443f, -0.05166037f, 0.11492170f, 0.11761461f, 
    -0.09638173f, 0.01182066f, 0.05732435f, 0.03402681f, -0.08699658f, -0.05963503f, -0.10175974f, 0.14571808f, 
    0.05887396f, 0.10022284f, 0.04699000f, 0.08030301f, 0.08776009f, 0.03130070f, 0.31573293f, 0.44448829f, 
    0.31003442f, 0.09103352f, 0.39097312f, -0.08922329f, -0.13210516f, -0.10861602f, -0.20193113f, -0.14859949f, 
    -0.00102413f, -0.07912057f, -0.02302052f, 0.16605540f, 0.15989679f, -0.25427622f, 0.47340766f, -0.67720431f, 
    0.03005271f, -0.04396877f, 0.00218009f, 0.17270920f, -0.15815343f, 0.15033832f, 0.00912844f, -0.01556288f, 
    -0.20118253f, -0.22161512f, -0.24125779f, -0.01275425f, 0.23422888f, -0.10337185f, 0.13140050f, 0.13324504f, 
    0.03749414f, -0.07623535f, -0.01597465f, -0.11962926f, 0.23405324f, -0.44402593f, -0.38456371f, 0.22945501f, 
    0.05034919f, 0.19584350f, 0.04867980f, 0.06030282f, -0.00585424f, -0.10650431f, -0.03075175f, 0.02058070f, 
    -0.44622946f, 0.23895656f, -0.03684755f, -0.74530888f, -0.08586513f, -0.10012165f, 0.18112713f, -0.09362996f, 
    -0.05957469f, -0.07296925f, -0.05555121f, 0.14402363f, -0.04227240f, -0.31980565f, 0.00809445f, 0.07049331f, 
    0.13237326f, 0.10742067f, 0.05843471f, 0.04986892f, -0.12186265f, -0.02136716f, -0.21089756f, -0.09256899f, 
    0.20052253f, -0.33405355f, -0.01196823f, -0.12193621f, -0.06592958f, -0.02572435f, -0.05880474f, -0.00274055f, 
    -0.03495042f, 0.07807815f, -0.18389767f, 0.09020263f, 0.13216184f, 0.06729653f, 0.37293389f, 0.32124922f, 
    0.01115648f, -0.10960602f, -0.19596621f, -0.19342732f, 0.09763516f, 0.18305284f, 0.08479130f, 0.11356568f, 
    0.08387776f, -0.18296684f, 0.35072979f, 0.04075432f, 0.17550975f, -0.12897238f, 0.06315306f, -0.00980333f, 
    0.09252559f, 0.02388214f, -0.00680853f, -0.00087415f, 0.22263266f, -0.40658125f, -0.05132106f, 0.22932506f, 
    0.24839777f, 0.04730056f, -0.35918033f, -0.03069116f, -0.04323705f, -0.40927324f, -0.21091270f, 0.01190468f, 
    -0.27931422f, 0.09076131f, 0.02934546f, -0.29614714f, -0.40168580f, -0.01109843f, -0.16303851f, -0.24187613f, 
    0.11011881f, -0.05737127f, 0.07628191f, 0.01324337f, -1.10558701f, 0.00600997f, -1.08772516f, 0.02919791f, 
    -0.25245398f, -0.03022883f, -0.05698584f, -0.00430148f, -0.12285446f, -0.00341100f, -0.04170237f, 0.00549651f, 
    0.08775853f, -0.15195899f, -0.04759600f, -0.22270903f, 0.24805431f, 0.13291904f, -0.04188844f, 0.04936497f, 
    0.07745552f, -0.17776300f, -0.01223296f, -0.04866289f, -0.02467373f, -0.20905627f, 0.16875695f, 0.54974711f, 
    -0.06759712f, 0.10274899f, -0.23438759f, -0.09469850f, 0.04858775f, 0.06631639f, -0.09074797f, -0.13488242f, 
    -0.55134767f, -0.14568934f, 0.25348869f, -0.17325300f, 0.02477877f, -0.06205362f, -0.06900003f, 0.16299087f, 
    0.08541535f, -0.11679543f, -0.00623711f, 0.07914352f, 0.30836859f, 0.17368940f, -0.04805820f, -0.04033485f, 
    -0.06424424f, 0.00231278f, 0.13054186f, 0.35027659f, -0.02907029f, 0.09557012f, 0.04879376f, -0.14392911f, 
    -0.24534293f, 0.02810945f, -0.41583014f, -0.13192073f, -0.00183069f, 0.01343953f, 0.22470862f, -0.06032499f, 
    0.03506109f, 0.06401394f, 0.05028509f, -0.05223367f, -0.35668764f, -0.20242622f, -0.06772023f, -0.52859783f, 
    0.11523244f, 0.11161030f, -0.00884491f, 0.10076506f, 0.12070716f, -0.05225177f, -0.01307738f, -0.12717676f, 
    0.05475890f, 0.20795175f, -0.76005185f, 0.05728371f, 0.14389856f, 0.25008133f, 0.22927603f, 0.12266388f, 
    0.03372139f, -0.06931609f, 0.08812089f, 0.04802471f, 0.25859743f, -0.00951034f, 0.25705346f, -0.52981681f, 
    -0.06144002f, -0.05473613f, -0.22731134f, 0.04235917f, -0.11408819f, -0.17920475f, -0.00415319f, 0.13267119f, 
    0.06882332f, -0.32972249f, 0.07507038f, 0.08223292f, 0.08779530f, 0.05690571f, 0.02823971f, -0.11477162f, 
    -0.04375704f, 0.05843960f, -0.04906531f, -0.07093802f, -0.54949194f, 0.15631458f, 0.22048631f, -0.03549561f, 
    0.20260157f, 0.15362866f, -0.13914539f, 0.01066996f, -0.00694756f, -0.35436547f, -0.04189204f, -0.27845827f, 
    -0.16403642f, -0.13838592f, 0.10385917f, 0.22671568f, -0.05048578f, -0.04974980f, 0.01365882f, 0.04357859f, 
    0.08608311f, -0.03756033f, 0.04700663f, 0.10609490f, -0.15669096f, -0.11908189f, -0.20263323f, -0.26093811f, 
    -0.12442969f, 0.06836866f, 0.01708302f, 0.19758525f, 0.04870979f, 0.00755996f, 0.11362346f, -0.09488811f, 
    -0.02624779f, 0.26323146f, 0.45934781f, -0.48038155f, 0.08441654f, -0.26946977f, 0.20205334f, 0.00816413f, 
    0.14983660f, -0.00406944f, 0.04121504f, 0.03368004f, -0.02221339f, 0.17051432f, -0.22279002f, -0.08022682f, 
    -0.01356226f, 0.09734781f, 0.11276293f, 0.05483358f, 0.06975297f, -0.03509094f, -0.02148104f, -0.27896935f, 
    0.24085903f, 0.25213665f, 0.58569223f, 0.49403444f, 0.10061475f, -0.08453190f, -0.18375370f, -0.13081358f, 
    0.08156160f, -0.03810049f, -0.14593416f, 0.14505361f, -0.46951953f, 0.25096476f, -0.55178654f, -0.74763125f, 
    0.00662836f, -0.08589507f, 0.28061688f, -0.04981453f, -0.06024916f, 0.17857495f, -0.05000881f, 0.08286943f, 
    -0.18642740f, 0.11899671f, -0.13482630f, -0.10979061f, -0.00141161f, 0.08296762f, 0.17614241f, -0.02856614f, 
    -0.00990571f, -0.01666549f, 0.04778507f, 0.07904561f, 0.02560558f, 0.27970269f, 0.36862692f, -0.10913239f, 
    0.00727924f, -0.02734058f, 0.15961546f, -0.01104458f, 0.01458650f, -0.05235226f, 0.10512695f, -0.05540488f, 
    -0.37169218f, 0.24604093f, -0.22475465f, -0.12591806f, -0.03437513f, 0.07728172f, -0.00046269f, -0.06685167f, 
    -0.08558019f, -0.06999820f, -0.14494674f, -0.21936008f, 0.30486745f, -0.09045099f, 0.35737145f, -0.23943223f, 
    -0.29899129f, -0.18283495f, -0.10643840f, -0.13043810f, -0.11785360f, -0.21672466f, -0.43498433f, -0.52364635f, 
    0.18512422f, 0.06151008f, -0.15544565f, 0.17434990f, 0.12625535f, -0.21407451f, 0.06318537f, 0.05791300f, 
    -0.10934519f, 0.21038865f, -0.09625475f, -0.02097454f, -0.09472673f, 0.03912834f, 0.15016481f, 0.42265981f, 
    0.00185452f, -0.04447108f, -0.06463068f, 0.13495946f, -0.14215879f, -0.06466225f, 0.02256785f, -0.08174424f, 
    -0.55640948f, 0.05270883f, 0.15172480f, 0.24530435f, -0.01830845f, -0.07354539f, -0.01032609f, 0.00395419f, 
    -0.12895507f, 0.25800243f, 0.10826909f, 0.06499342f, -0.05237754f, 0.22730389f, 0.07961682f, 0.01965292f, 
    -0.13018373f, 0.13156003f, 0.08824090f, -0.10244326f, -0.03190070f, 0.08666981f, -0.09615160f, -0.04991225f, 
    0.22777082f, 0.08017998f, 0.33712766f, -0.05809859f, -0.22868410f, 0.12449090f, 0.13461782f, -0.06899580f, 
    0.20202528f, 0.01451741f, 0.29468539f, 0.15025821f, -0.18586826f, 0.10135800f, 0.06123504f, -0.16284633f, 
    -0.14064960f, 0.12446418f, -0.04693646f, -0.01106152f, 0.16140984f, 0.13816403f, 0.11028017f, 0.19768584f, 
    -0.04754656f, 0.30874348f, 0.19697802f, 0.12826605f, -0.05279500f, -0.09676234f, -0.03217219f, -0.08117057f, 
    -0.11214363f, 0.16275208f, 0.14779145f, 0.22408798f, -0.13494191f, 0.06133870f, -0.02018792f, -0.23878346f, 
    0.04514146f, -0.16345048f, -0.13440326f, 0.00685688f, -0.17423075f, -0.03074057f, -0.26095417f, -0.32632884f, 
    -0.37446108f, 0.24859770f, -0.22261207f, 0.13611287f, 0.02505465f, -0.09513214f, -0.01707830f, 0.03378965f, 
    -0.02281944f, 0.09107350f, -0.06672462f, 0.00957645f, -0.29696268f, -0.11951396f, 0.31949565f, -0.05557652f, 
    -0.27710301f, 0.02703324f, 0.06761727f, 0.15816103f, 0.01079986f, 0.26160854f, 0.00852312f, 0.22285742f, 
    0.43747646f, -0.04143339f, 0.19896927f, -0.10391571f, 0.11392432f, -0.35670355f, 0.14065672f, 0.10591348f, 
    -0.19298348f, 0.25978881f, 0.05741873f, -0.27579263f, 0.30476272f, 0.73728538f, 0.14145604f, -0.36970338f, 
    -0.44999260f, -0.12012118f, 0.09207974f, 0.13217516f, -0.02850551f, 0.20756693f, -0.16802478f, 0.13199884f, 
    -0.29428178f, -0.42316654f, 0.36105928f, 0.26023921f, -0.19209008f, -0.18381158f, -0.27038282f, -0.12117749f, 
    -0.12915550f, 0.08589362f, 0.21324915f, 0.08239493f, -0.62427574f, 0.28313544f, -0.42121640f, -0.15568945f, 
    -0.01082649f, 0.30812460f, -0.22519575f, 0.12039715f, -0.09447510f, -0.08670146f, -0.37868515f, 0.07639180f, 
    -0.20661372f, 0.03206778f, 0.25111282f, -0.14506419f, -0.03006594f, -0.14563143f, -0.25885871f, 0.11390616f, 
    -0.12344943f, 0.07644308f, 0.26794034f, 0.08946788f, -0.32977048f, -0.09023912f, -0.60712218f, 0.08300985f, 
    -0.10558448f, -0.13565445f, -0.30668542f, 0.23016150f, 0.07286167f, 0.03729690f, -0.07277512f, -0.08747979f, 
    0.17038293f, -0.02132029f, -0.11031521f, -0.03396683f, -0.20398776f, -0.00506500f, -0.29748887f, -0.02762927f, 
    -0.10886665f, -0.12638964f, -0.10413260f, 0.11152319f, -0.17500852f, -0.36134470f, 0.13528405f, -0.06473502f, 
    0.05233086f, 0.17533226f, -0.10233932f, -0.12102213f, -0.13336320f, -0.11801482f, 0.01242006f, -0.24102822f, 
    -0.06744450f, -0.58155113f, -0.13180773f, -0.20885386f, -0.34071228f, -0.12413464f, 0.11099488f, -0.19567446f, 
    -0.14405653f, 0.14706466f, 0.00907281f, -0.10382459f, 0.06153617f, 0.04165304f, 0.21578859f, 0.29015774f, 
    0.01011975f, 0.23805386f, -0.18598111f, -0.11364329f, 0.01709705f, 0.09130073f, 0.10876763f, -0.01203800f, 
    -0.53517687f, -0.15746048f, -0.45119441f, -0.71840417f, -0.11551318f, -0.05503128f, -0.04187216f, 0.01764776f, 
    0.01285567f, -0.13039072f, 0.23131703f, 0.09292050f, 0.31270072f, 0.16567159f, 0.24527463f, -0.11599856f, 
    -0.17650485f, 0.07009109f, 0.21057555f, 0.23366587f, 0.05852073f, 0.27906865f, 0.14051412f, 0.23738328f, 
    -0.33419177f, -0.06538253f, -0.62111932f, 0.09740634f, 0.09237431f, -0.11859930f, -0.01969112f, -0.07697018f, 
    -0.05989679f, 0.17924727f, 0.05645997f, -0.00443725f, -0.03864202f, -0.37349987f, -0.07867062f, -0.08170925f, 
    0.02338562f, -0.07115008f, 0.04256133f, 0.02150698f, 0.11086208f, 0.12470962f, -0.16251396f, -0.18411963f, 
    -0.01669269f, -0.32202995f, -0.05247416f, 0.18493606f, 0.18703748f, -0.16350642f, -0.01948198f, 0.12897711f, 
    -0.31676540f, -0.12684609f, -0.22961321f, -0.15249655f, 0.18658884f, -0.14761382f, 0.20910773f, 0.05691871f, 
    -0.15265498f, 0.05492795f, 0.17636335f, -0.03937425f, 0.24834390f, 0.07582287f, 0.26346484f, 0.18394698f, 
    -0.39757013f, 0.21515307f, 0.13621932f, -0.34199235f, -0.20182610f, 0.04722887f, -0.07083853f, -0.09647010f, 
    0.04394216f, -0.14002693f, 0.14763178f, 0.14270455f, 0.13689715f, -0.15778537f, 0.15203293f, -0.02023284f, 
    -0.21816456f, -0.13815041f, 0.04006535f, -0.14136697f, -0.05713698f, -0.04745203f, -0.13498943f, -0.13596755f, 
    -0.28218922f, 0.06531272f, -0.61220765f, -0.20004228f, -0.00336858f, -0.43793866f, -0.08683556f, -0.37598759f, 
    -0.00604354f, 0.15049720f, -0.00012019f, 0.01560181f, 0.23835939f, 0.07824696f, 0.02757430f, -0.10469734f, 
    -0.10685894f, 0.03811508f, -0.16786532f, 0.01284768f, -0.07360502f, 0.17900506f, 0.20133492f, -0.07045291f, 
    0.23493285f, -0.16504136f, -0.06090368f, 0.18128680f, 0.17525388f, -0.11327377f, 0.19598661f, 0.16127062f, 
    0.07853171f, 0.22133349f, 0.08606318f, 0.11580765f, 0.07900018f, -0.10551346f, -0.12431904f, -0.06156018f, 
    -0.04776043f, 0.05362952f, 0.11340453f, 0.11464331f, 0.14973383f, 0.24161924f, 0.08868034f, 0.04840379f, 
    -0.45882562f, 0.23375596f, -0.36308062f, 0.02201115f, 0.02726873f, -0.02718678f, 0.01697726f, 0.02914889f, 
    -0.13656430f, -0.02122710f, -0.03349189f, -0.06413496f, -0.88508266f, 0.09529208f, -0.13220225f, 0.20401242f, 
    -0.06075512f, 0.03107244f, -0.02834475f, 0.18484920f, -0.30911446f, -0.04189338f, 0.00586659f, -0.14807256f, 
    -0.10149469f, -0.13831951f, 0.12695219f, 0.27780113f, -0.05578952f, -0.08884186f, -0.14503372f, 0.00368857f, 
    -0.06806228f, 0.06933137f, 0.10664825f, 0.03829686f, 0.36282006f, 0.13629062f, 0.19578521f, 0.16652438f, 
    -0.00999664f, -0.04615487f, -0.01571496f, 0.01768930f, -0.08163555f, 0.02954348f, -0.02641778f, -0.05210296f, 
    0.08751567f, 0.10488804f, 0.37496582f, 0.08759379f, 0.24458919f, 0.03866953f, -0.03093754f, -0.13991824f, 
    -0.29983479f, 0.09490920f, -0.21959835f, -0.00439452f, 0.00336780f, 0.14431162f, -0.15530930f, -0.05195880f, 
    -0.03532543f, -0.04324846f, -0.06656081f, -0.07290047f, -0.14404184f, -0.13699362f, -0.13135460f, -0.17452517f, 
    -0.31813565f, 0.37620664f, -0.49062067f, 0.21705788f, 0.13127190f, -0.06858918f, 0.16604964f, 0.01631685f, 
    -0.12144752f, 0.04407166f, -0.10998481f, -0.17618833f, -0.18317179f, 0.03955362f, -0.27213106f, 0.05691356f, 
    0.01866270f, -0.04980549f, -0.07882304f, -0.07225069f, -0.01780622f, 0.03693732f, 0.18063864f, -0.09879164f, 
    0.18566313f, -0.05337023f, -0.13431700f, -0.22194371f, -0.10792197f, -0.21687107f, 0.01595489f, 0.11120830f, 
    0.07309699f, 0.11166076f, 0.05687473f, -0.15740138f, -0.69090492f, 0.31815040f, -0.62399799f, 0.46306723f, 
    0.16292016f, 0.11612630f, 0.34210297f, -0.22718656f, -0.02050883f, -0.19828045f, -0.13731647f, 0.13231634f, 
    -0.06732781f, 0.41839972f, -0.25561631f, -0.10698900f, -0.04200606f, 0.08325239f, 0.21435578f, 0.05704708f, 
    0.17262146f, 0.09144074f, 0.01604157f, 0.03146811f, -0.35433105f, -0.66300642f, 0.90270597f, 0.31481442f, 
    0.10233787f, 0.04341700f, 0.44361940f, -0.12015687f, 0.08677312f, -0.05169446f, 0.13166967f, 0.10948589f, 
    0.06240411f, 0.30131862f, 0.05252027f, -0.18482831f, 0.14690742f, 0.16988945f, 0.08871049f, 0.07531348f, 
    0.06018958f, -0.00067641f, -0.20836927f, -0.08608666f, -0.71898335f, -0.27212840f, -0.55044246f, 0.51532215f, 
    -0.02388351f, -0.12825303f, 0.08677551f, -0.13086918f, -0.12964126f, -0.02187448f, 0.25410816f, 0.05202418f, 
    0.13108976f, -0.09154727f, -0.51516318f, -0.10098234f, 0.10165367f, -0.14335799f, -0.08443192f, 0.01642446f, 
    0.02692303f, 0.01418582f, 0.14024204f, 0.02596308f, -0.62218404f, -0.17202899f, -0.22479592f, 0.39327553f, 
    -0.12983093f, -0.23017822f, 0.07026497f, -0.08449599f, -0.06968976f, 0.08567703f, -0.08859849f, 0.13265187f, 
    0.18354760f, -0.21841982f, 0.17562318f, 0.04986997f, -0.03313427f, 0.12505618f, 0.04267083f, -0.11804568f, 
    -0.07979321f, 0.11704424f, 0.19344774f, -0.06273422f, -0.11381282f, -0.11274236f, 0.32689393f, -0.30613583f, 
    -0.24098101f, -0.10029210f, 0.19623475f, 0.05838721f, -0.01390117f, 0.08676767f, -0.04947438f, 0.04466685f, 
    0.59514868f, 0.35945031f, 0.51527232f, -0.05182211f, 0.09232980f, 0.02562152f, 0.00231611f, 0.02739895f, 
    -0.05598540f, 0.00434608f, -0.02302461f, -0.00938647f, -0.15602317f, 0.05322131f, -0.09648551f, 0.38697559f, 
    -0.04854404f, 0.00255839f, -0.03484996f, 0.05508694f, -0.11059357f, -0.05219938f, -0.24207368f, -0.05848075f, 
    -0.04778767f, -0.07458849f, -0.10649426f, -0.01464883f, 0.00651175f, -0.10959015f, -0.05361787f, 0.03536744f, 
    -0.11698174f, 0.07217031f, -0.13418041f, -0.19155312f, 0.00665395f, 0.21162656f, 0.06263118f, -0.12570512f, 
    -0.01622825f, 0.21360683f, -0.20070365f, -0.21487962f, 0.02951745f, -0.07315277f, 0.14609011f, 0.09776304f, 
    0.31091979f, -0.04563439f, 0.05904844f, -0.42781255f, -0.07542761f, -0.04892481f, 0.18282850f, -0.02059346f, 
    0.00377054f, -0.01444650f, 0.02008095f, -0.03868552f, 0.09405158f, -0.26247129f, 0.16058245f, -0.46801841f, 
    -0.17543103f, -0.05134334f, 0.09064542f, -0.18634543f, 0.07881612f, 0.01484222f, 0.11779795f, -0.00616555f, 
    -0.07156459f, -0.47919834f, 0.34892282f, -0.10878104f, -0.12134347f, 0.33290133f, -0.37513772f, 0.04982455f, 
    -0.17731702f, 0.11818022f, 0.05008432f, 0.05541863f, -0.03152464f, 0.00248370f, 0.16982865f, -0.01058005f, 
    0.11944905f, -0.02083228f, 0.25778764f, -0.08505502f, -0.19588426f, -0.08884908f, -0.29676449f, -0.17801580f, 
    -0.21730818f, -0.31985509f, -0.23182850f, 0.17603162f, 0.27774507f, -0.17261882f, -0.05429741f, 0.07940556f, 
    -0.00879286f, 0.18256855f, -0.02602240f, -0.24502861f, 0.14195499f, -0.48249456f, 0.74661511f, 0.02769650f, 
    0.14562665f, 0.03436307f, -0.03852991f, 0.09494483f, -0.10162097f, -0.08454113f, 0.17612952f, 0.00480722f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.24109431f, 0.16178466f, 0.12644106f, -0.16518466f, -0.04382477f, 0.06705514f, 0.04205106f, -0.15873344f, 
    0.05621517f, 0.01767718f, -0.01879411f, -0.02410130f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
