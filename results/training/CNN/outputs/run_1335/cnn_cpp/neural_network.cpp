#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.28236115f, -0.68879217f, -0.15703042f, 0.62997293f, 0.25906301f, -0.02775461f, 0.31027707f, -0.07861731f, 
    0.14331374f, -0.77173024f, -0.58139062f, -0.52753842f, 0.86809248f, -0.51608276f, -0.24295361f, 0.32786986f, 
    0.06986590f, 0.66682160f, 0.97000492f, 0.77150548f, -0.44047555f, -0.40893608f, -0.54127491f, 0.05903122f, 
    -0.06894992f, -0.06684349f, -0.21781136f, 1.09436953f, -0.10847551f, 0.16434328f, -0.56640834f, -0.73931462f, 
    -0.28059241f, -0.08255431f, 0.31646335f, 0.52934456f, 0.37300721f, -0.33989930f, -0.91906321f, -0.55818772f, 
    -0.22461411f, 0.22256349f, 0.49273753f, 0.26784036f, 0.48233482f, 0.49334240f, -0.35594165f, -0.10939121f, 
    -0.35045245f, 0.10448094f, 0.42410886f, -0.11435387f, -0.17712188f, 0.40238836f, 0.26687399f, -0.21121073f, 
    0.14349775f, -0.47163606f, 0.86393499f, -0.42902774f, -0.56207234f, 0.24251941f, 0.40584767f, -0.08627551f, 
    -0.59377748f, 0.10888410f, -0.37683421f, 0.09377845f, 0.14418969f, -0.35628334f, 0.38409001f, 0.36248612f, 
    0.51484108f, -0.36696953f, -0.00769080f, -0.17570627f, 0.29577821f, -0.05850542f, 0.18226524f, -0.05302298f, 
    0.24334475f, 0.56393576f, 0.62022972f, 0.35271358f, 0.26054174f, -0.85125101f, -0.29654124f, 0.00551865f, 
    -0.07216879f, 0.13831083f, 0.06386154f, 0.56683195f, 0.39769191f, -0.35836217f, -0.02356948f, 0.33318847f, 
    0.16404416f, 0.12711988f, -0.27676359f, 0.74432611f, 0.72327757f, -1.14593565f, -0.34844533f, 0.01216172f, 
    0.31268871f, -0.02508546f, 0.04364029f, -0.00070670f, -0.60757953f, -1.00879586f, -0.03913752f, -0.97748840f, 
    -1.29455423f, -0.43176603f, 0.41402683f, -0.33573127f, 0.65221691f, 0.30104968f, 0.63383985f, 0.40470296f, 
    -0.38480428f, -0.05714197f, 0.10690550f, 0.34211755f, 0.21127664f, -0.44112131f, -0.51915514f, -0.45752198f, 
    -0.80578625f, 0.52173179f, -0.52992612f, -0.62071770f, -0.69686478f, -0.57556540f, -0.53305691f, -0.11989690f, 
    -0.23857173f, -0.72304052f, 0.30878946f, 0.57754475f, 0.36605379f, 0.01122937f, 0.28559721f, 0.02584776f, 
    0.03462717f, 0.50472593f, 0.20837092f, 0.35016337f, 0.25132474f, 0.54101425f, -0.19360843f, -0.16212049f, 
    0.14116797f, -0.74269521f, 0.44851699f, 0.04482365f, -0.97993362f, -0.61716336f, -0.95764542f, -0.22710966f, 
    0.09197989f, -0.60693669f, -0.69457972f, 0.16580105f, 0.63595474f, 0.80089146f, 0.51386559f, -0.82781881f, 
    0.17747851f, 0.28792915f, -0.63223445f, -0.31327355f, -0.24976176f, 0.65580904f, -0.54441756f, 0.49586189f, 
    0.03636840f, 0.01242162f, -0.10987850f, 0.23709370f, -1.35693300f, 1.24187684f, -0.52497637f, -0.86473560f, 
    0.13333929f, 1.11094487f, -0.14091820f, -0.05875711f, -0.11380479f, 0.49810243f, 0.59064937f, -1.25018692f, 
    -0.26415932f, 0.00596712f, 0.11782826f, -0.44916025f, -0.62203419f, -0.51407456f, 0.01978814f, -0.59394509f, 
    0.71563733f, -0.14995964f, -0.39354348f, -0.67471105f, 0.32556799f, 0.38396424f, 0.49730033f, -1.00764239f, 
    -0.29045120f, -1.01284623f, -0.04823640f, 0.21381809f, 0.77534854f, -0.13818760f, -0.59673536f, -0.68179542f, 
    1.25591409f, -0.94180250f, -1.18566644f, 0.39951324f, 0.61079329f, 0.35478681f, -0.37885043f, 0.49794251f, 
    -0.44189343f, -0.29059184f, -0.94036621f, -0.97672790f, 0.24454063f, 0.70330226f, -0.38199139f, 0.14223097f, 
    -0.47084856f, -0.54322445f, -0.42301390f, -0.34240401f, -0.26747459f, -0.87447047f, -0.46688089f, -0.66372275f, 
    -0.13995552f, -0.71660942f, -0.77841777f, 0.30505407f, 0.23207550f, 0.09874213f, -0.65514243f, 0.11581404f, 
    0.20975569f, -0.38808462f, -0.21143970f, -0.47523826f, 1.57674956f, -0.90361470f, -0.78475463f, 0.74004859f, 
    -0.39606583f, -0.96804380f, -0.18994659f, -0.05836745f, -0.12740050f, 0.37720245f, 0.05811383f, -0.14720407f, 
    -0.05958520f, 0.06955507f, 0.25025880f, -0.41812631f, 0.74135029f, -0.20267543f, -1.31609416f, -0.91697431f, 
    -0.27355292f, 0.77250087f, 0.62948793f, -0.14399894f, -0.24688503f, 0.34782064f, 0.09698227f, 0.44367918f, 
    0.40344384f, -0.69722718f, 0.27993110f, 0.53478062f, 0.01937626f, -0.39875939f, 0.09693619f, -0.20700622f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.13900806f, 0.27182752f, 0.23613797f, -0.18492693f, 0.21382444f, 0.35386601f, 0.06105326f, 0.34955513f, 
    -0.05913011f, 0.36617401f, -0.00317148f, 0.17558973f, 0.00082129f, -0.18281689f, -0.31008056f, 0.11076950f, 
    -0.34497473f, -0.17887950f, 0.24021283f, 0.19270805f, 0.23556648f, -0.12642895f, 0.03028987f, -0.06965310f, 
    0.30352232f, 0.02024863f, -0.27339101f, 0.09263429f, 0.35744405f, -0.09528492f, -0.06423706f, 0.50566089f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20276071f, 0.12667988f, -0.16592915f, 0.05034851f, 0.05612502f, 0.01279400f, 0.03079368f, 0.01686386f, 
    0.04419709f, 0.14736103f, 0.14652914f, 0.07772409f, -0.07983173f, 0.01301405f, 0.04844617f, 0.01531024f, 
    0.05805587f, 0.07765313f, 0.04217831f, 0.01851387f, 0.41962934f, 0.28924951f, -0.05921407f, -0.22233844f, 
    0.03333898f, 0.02813544f, 0.19092643f, 0.05887700f, -0.19263703f, -0.17710751f, -0.02579087f, -0.18689886f, 
    -0.01280378f, -0.06270138f, 0.04237542f, -0.08203363f, -0.00706350f, 0.04126382f, 0.01997682f, 0.02679540f, 
    -0.60570401f, 0.17732470f, -0.29785961f, -0.05989254f, -0.39353383f, -0.02669649f, -0.05169425f, -0.10698158f, 
    0.00780412f, 0.04671423f, -0.01504055f, 0.00314029f, 0.00371004f, 0.06072798f, 0.03558978f, -0.02858497f, 
    0.06467013f, -0.01183556f, 0.01085216f, -0.14973719f, 0.09492695f, 0.05704064f, 0.01751876f, -0.07935011f, 
    -0.10979330f, -0.20972507f, 0.00346453f, -0.23909146f, -0.12271373f, -0.23559180f, 0.00816671f, 0.09390283f, 
    0.02063151f, 0.12116517f, 0.00495690f, -0.02531155f, 0.04755792f, -0.00222221f, -0.13848293f, -0.01972094f, 
    0.31032780f, 0.26427838f, -0.04787996f, -0.10701057f, -0.05687270f, 0.03716164f, -0.04312032f, 0.06345022f, 
    0.02845903f, -0.19996296f, -0.15817408f, -0.03029077f, -0.01424556f, 0.03443719f, 0.07853368f, -0.00549975f, 
    -0.05488071f, -0.04729968f, -0.03904152f, -0.01115450f, -0.19995344f, -0.11202663f, -0.05745964f, 0.02380700f, 
    0.02186524f, 0.01808001f, -0.14184453f, -0.04881075f, 0.03760029f, -0.01897634f, -0.04022409f, -0.14810467f, 
    -0.19992462f, -0.05327367f, -0.12772755f, 0.07498936f, -0.03151142f, 0.01698447f, -0.11104356f, -0.09601738f, 
    -0.27532318f, -0.23863895f, 0.13899359f, 0.08849879f, -0.16857389f, -0.00978537f, -0.28976330f, -0.01743642f, 
    -0.14120832f, 0.02848787f, -0.15196858f, 0.06021164f, -0.08542585f, -0.28066015f, -0.06405624f, -0.33409184f, 
    -0.16512927f, 0.02106403f, -0.28311631f, 0.01649645f, 0.07225003f, 0.19027992f, 0.04709754f, -0.06091707f, 
    -0.12358701f, 0.02264408f, 0.00233720f, 0.07047881f, -0.18741708f, -0.17323358f, -0.21080223f, -0.18089384f, 
    0.00521553f, -0.02946035f, 0.01272107f, -0.02702256f, -0.07087314f, -0.06848530f, -0.02782246f, -0.08204419f, 
    -0.00893162f, -0.00484332f, 0.00794096f, -0.01146305f, 0.02554879f, 0.01391473f, -0.00183330f, 0.04777796f, 
    0.04292143f, 0.02614002f, -0.33009642f, 0.05729441f, -0.26582646f, -0.07327516f, -0.12033585f, 0.01341555f, 
    -0.03943115f, -0.07334658f, -0.11824735f, 0.03403244f, -0.42126364f, -0.14620718f, -0.25157613f, 0.12494930f, 
    -0.10075536f, 0.01804444f, -0.08890317f, -0.06203283f, 0.02395162f, -0.07924280f, 0.01640177f, -0.00562333f, 
    -0.01659841f, 0.05126765f, 0.01254505f, -0.03431818f, 0.09255550f, -0.14644653f, 0.01416735f, -0.09880930f, 
    -0.17479280f, -0.04767030f, -0.03557804f, 0.11151104f, 0.09349626f, 0.05706615f, 0.01012787f, 0.04938139f, 
    0.01282753f, 0.00304566f, -0.00260330f, 0.07756548f, 0.07615763f, 0.07201964f, 0.08359206f, 0.09507495f, 
    -0.07131208f, 0.01981211f, -0.02250847f, -0.01650115f, -0.78018683f, -0.12619969f, -0.33767876f, 0.05166105f, 
    -0.21950239f, -0.06171019f, 0.05705694f, -0.00924821f, 0.06888807f, 0.00534021f, 0.08182812f, -0.00009409f, 
    -0.15821284f, -0.00823524f, 0.11059338f, -0.01455352f, -0.00844726f, -0.05653873f, 0.05285207f, -0.07976044f, 
    0.39080718f, 0.43023944f, 0.18287681f, -0.70374548f, -0.11095060f, 0.16290030f, 0.15061045f, 0.08297815f, 
    0.05990045f, 0.01500092f, 0.05980195f, -0.08267261f, 0.00862873f, -0.01176043f, -0.08064649f, -0.02878961f, 
    -0.04298363f, 0.04235492f, 0.05927077f, -0.08863930f, -0.10208920f, -0.02203604f, -0.02071884f, 0.04290473f, 
    0.10619526f, 0.04365164f, 0.03608882f, -0.00589178f, -0.03841520f, 0.02741800f, -0.02197456f, 0.04751296f, 
    0.04641777f, 0.09505932f, 0.05162639f, 0.08176371f, -0.17455952f, 0.03141452f, -0.03016483f, 0.01137042f, 
    0.33044633f, 0.21410264f, 0.07367472f, -0.25784659f, -0.07237521f, 0.08150586f, 0.13688475f, 0.11025283f, 
    -0.18688715f, 0.10118409f, -0.05594555f, 0.04108473f, 0.02613745f, -0.02826374f, -0.00959550f, 0.06561294f, 
    -0.21058881f, -0.02697231f, -0.07989411f, 0.10092529f, 0.06046337f, 0.00319442f, -0.16520827f, 0.05865074f, 
    0.04158289f, 0.04650090f, 0.01087519f, 0.03983850f, 0.04193229f, 0.07785071f, -0.10980556f, -0.03640453f, 
    -0.09214228f, -0.05242819f, -0.09946452f, 0.04041102f, 0.03831098f, -0.03634703f, 0.03889000f, 0.02555378f, 
    -0.03525538f, -0.06434869f, -0.02585159f, 0.00574212f, 0.04235482f, 0.08685289f, 0.05506428f, 0.06878032f, 
    0.09314759f, 0.04019741f, 0.08268169f, 0.15839279f, 0.11149555f, 0.02962014f, -0.01865030f, -0.09247858f, 
    -0.18152130f, 0.05448799f, 0.02766051f, 0.02865574f, 0.14119722f, 0.43215558f, -0.01963007f, -0.23006052f, 
    -0.20315111f, -0.02629033f, 0.08658548f, -0.04386467f, 0.08730544f, 0.04320072f, 0.02382617f, -0.06337016f, 
    -0.00699990f, 0.03307284f, -0.06909381f, -0.07586399f, -0.03555611f, 0.05297445f, -0.13758831f, 0.08844785f, 
    0.02038755f, 0.00493337f, 0.06170515f, -0.12437662f, -0.02586724f, -0.13496202f, -0.03906118f, -0.04172489f, 
    0.06628900f, 0.05811651f, -0.10556172f, -0.18390045f, -0.06495234f, -0.04009225f, -0.09645116f, -0.14096181f, 
    0.01397476f, -0.07066549f, 0.01285735f, 0.17627232f, -0.07673988f, -0.14771150f, 0.31212267f, -0.01685902f, 
    0.05215086f, -0.08347998f, -0.11599716f, 0.15138662f, 0.04112449f, -0.04221848f, -0.05488314f, -0.00241647f, 
    -0.05108861f, 0.01525409f, -0.19049792f, -0.11868166f, -0.11585923f, -0.04948066f, 0.01684866f, -0.03515220f, 
    -0.64302152f, 0.03688333f, 0.42161885f, 0.04108366f, -0.18118532f, -0.32307512f, -0.04737085f, -0.07387263f, 
    -0.09889083f, -0.19601817f, 0.06106896f, -0.04946078f, -0.00893894f, 0.01205969f, 0.06869714f, -0.09243096f, 
    0.04083529f, -0.11426798f, -0.17321746f, 0.02262630f, -0.00862651f, 0.11996391f, 0.52286047f, 0.06530637f, 
    -0.59791327f, -0.02411351f, -0.02041361f, -0.07645552f, 0.04578268f, 0.04817374f, -0.01398639f, -0.04004892f, 
    -0.04585609f, 0.02264143f, 0.02969186f, 0.10928290f, 0.11017726f, 0.00916554f, -0.04220420f, 0.03890731f, 
    0.19593181f, 0.20195536f, 0.08563796f, -0.18879668f, -0.00337628f, -0.17971949f, 0.04995634f, 0.04837334f, 
    -0.15280661f, -0.02689025f, 0.24446745f, 0.03804464f, 0.01147555f, -0.02390957f, -0.03465744f, -0.04584611f, 
    -0.00911017f, -0.10825381f, -0.01516557f, -0.16992249f, 0.41263852f, 0.06497875f, 0.07564007f, -0.11174842f, 
    -0.05655399f, 0.05938688f, 0.14388944f, 0.14417723f, 0.04702585f, -0.02501132f, 0.01685367f, -0.00176819f, 
    0.02402567f, 0.03585442f, -0.07040021f, 0.12863892f, 0.02941396f, -0.09086303f, -0.00584315f, -0.11046506f, 
    0.07876937f, -0.34166634f, -0.83953440f, 0.12745754f, -0.02192326f, 0.10173899f, -0.10844170f, -0.06906059f, 
    -0.16683106f, 0.05802486f, -0.06288007f, 0.04228047f, -0.29287642f, -0.23926820f, -0.12139612f, 0.00045655f, 
    0.06125763f, -0.06658843f, -0.06065257f, 0.06601491f, 0.46922976f, -0.03145378f, -0.21587922f, -0.09887891f, 
    -0.15407670f, 0.15774375f, -0.02025512f, 0.14913104f, -0.22778432f, 0.20196171f, 0.01581423f, 0.02913583f, 
    -0.14985450f, 0.03893702f, 0.01778172f, 0.05089368f, 0.07992449f, -0.18014862f, -0.03339556f, 0.06348328f, 
    0.36126986f, 0.32049897f, 0.30062759f, -0.37404928f, -0.06687025f, 0.11605689f, 0.18297258f, 0.19090654f, 
    0.03807184f, 0.07471535f, -0.02743882f, -0.01699736f, -0.04227997f, -0.08110750f, -0.06548021f, -0.06602029f, 
    -0.16765676f, -0.05868432f, 0.09608710f, 0.14161150f, -0.18370403f, 0.21656106f, 0.35237533f, -0.00050582f, 
    -0.14776044f, 0.00140477f, -0.07864378f, -0.06741706f, 0.05767388f, 0.07594179f, 0.05806668f, -0.01087322f, 
    -0.01659551f, 0.01693427f, 0.00374272f, 0.16200818f, 0.03844949f, -0.08620200f, 0.14534061f, -0.11415994f, 
    0.01871568f, -0.06611323f, -0.45013013f, 0.15654300f, -0.02513279f, -0.08747725f, -0.16611594f, 0.04179828f, 
    -0.13918543f, 0.00841413f, -0.10500183f, 0.00379028f, -0.08051182f, -0.04888415f, -0.04278794f, -0.02443724f, 
    0.03552319f, 0.08592666f, -0.15703718f, 0.18024091f, -0.06080969f, -0.02706073f, 0.05875663f, 0.07093108f, 
    -0.00419713f, 0.02325225f, 0.06989492f, 0.00715868f, 0.07031461f, 0.06810722f, -0.15375488f, 0.16069634f, 
    -0.03460862f, -0.19517250f, 0.00227799f, -0.09901220f, -0.10253850f, -0.05082841f, -0.03401987f, -0.00453942f, 
    0.50481701f, 0.24861132f, -0.28426668f, -0.16940266f, 0.06997111f, 0.13000563f, 0.17282130f, 0.10867254f, 
    -0.17923097f, 0.02084432f, -0.10931752f, -0.07128573f, -0.01620669f, -0.00075885f, 0.06446924f, -0.03887908f, 
    0.09997370f, 0.05347815f, -0.00791460f, 0.00939940f, -0.44659939f, -0.37910116f, -0.47185716f, 0.17659476f, 
    -0.12534015f, -0.01774363f, -0.00087090f, -0.05294390f, 0.00198243f, 0.08527885f, 0.00142873f, -0.00795328f, 
    -0.09504152f, -0.05676273f, -0.06076756f, -0.02499021f, 0.03302999f, -0.10511324f, -0.07911264f, 0.02809530f, 
    0.13765009f, -0.07506152f, -0.12987080f, -0.04373897f, -0.02627670f, -0.05100177f, -0.05432168f, 0.06814984f, 
    -0.01413041f, -0.12123410f, 0.06208867f, 0.02055984f, 0.11132570f, -0.10216594f, -0.11404238f, -0.02460330f, 
    -0.06294106f, -0.00340389f, -0.03948783f, -0.07151909f, -0.26273903f, 0.02789094f, -0.17368995f, -0.11822523f, 
    0.02957814f, 0.12416774f, 0.11209436f, 0.21234025f, 0.09912837f, -0.24461363f, -0.10212675f, -0.08571757f, 
    0.08207046f, -0.01785872f, -0.08922696f, 0.03151434f, 0.06989665f, 0.04307254f, -0.00112490f, 0.05679417f, 
    0.28914860f, -0.00126465f, 0.20898946f, 0.00046133f, -0.31167078f, 0.03885157f, -0.07637294f, -0.03081363f, 
    -0.10206187f, -0.01762617f, -0.05775196f, -0.00370340f, -0.00720418f, 0.07793688f, -0.02179565f, -0.03414061f, 
    0.17029430f, -0.01413436f, 0.02376477f, 0.08774238f, -0.08750021f, 0.00509489f, -0.10370551f, -0.16766168f, 
    -0.07224781f, -0.01123610f, 0.01732462f, -0.19686697f, -0.42717499f, 0.10407967f, -0.05040874f, -0.09374221f, 
    0.03292884f, 0.12822272f, -0.00255704f, -0.03361254f, 0.00599782f, -0.07244409f, 0.05477866f, -0.00591255f, 
    -0.28289333f, -0.19144048f, -0.16492006f, 0.01336063f, -0.02725365f, 0.06419731f, 0.16370139f, 0.16275927f, 
    -0.09875410f, 0.14103644f, 0.25702596f, -0.01422490f, 0.03812323f, 0.09652945f, 0.05480544f, 0.01204131f, 
    -0.03326561f, -0.05300564f, -0.03580269f, 0.07364188f, 0.19163916f, 0.05280964f, 0.09540663f, 0.04247853f, 
    -0.03803525f, -0.10373844f, 0.09903065f, 0.00002570f, -0.02401461f, 0.06445494f, 0.07082856f, -0.10012688f, 
    -0.01048203f, 0.08625094f, -0.04355264f, -0.13249592f, -0.00473882f, 0.07707109f, 0.01201024f, -0.05091658f, 
    0.27321163f, 0.05715103f, -0.06546504f, 0.01171206f, 0.06428127f, -0.24188927f, 0.08354048f, 0.02642246f, 
    -0.00048331f, 0.11615971f, -0.14732820f, 0.01088254f, 0.19811696f, 0.00878565f, 0.01264922f, -0.06653897f, 
    0.18207909f, -0.35093457f, -0.01400149f, 0.01920627f, -0.25010994f, -0.01052983f, -0.05057948f, 0.04086036f, 
    0.11439031f, 0.01016320f, 0.14334795f, 0.16673693f, -0.14816900f, 0.13211691f, -0.05132334f, 0.02038640f, 
    -0.00330287f, 0.12762298f, -0.01453831f, 0.03804835f, 0.12533927f, 0.06026941f, 0.07417514f, 0.09620895f, 
    0.05047503f, -0.02467151f, 0.01060360f, -0.04525646f, -0.04819591f, -0.04548454f, 0.03615377f, -0.05529850f, 
    -0.01671116f, 0.02866955f, 0.07919867f, -0.01512557f, 0.13378052f, 0.03669950f, 0.00863841f, -0.22849573f, 
    -0.04448993f, 0.01704106f, -0.02721727f, -0.07538706f, 0.09354427f, 0.04679891f, -0.06667235f, -0.10812820f, 
    -0.04451410f, 0.03096213f, -0.10403458f, -0.09434197f, 0.03830746f, -0.08097485f, 0.00668604f, -0.02463185f, 
    0.03539661f, 0.04382847f, 0.02215230f, 0.00614721f, 0.11144277f, 0.00017633f, 0.09296016f, 0.12551637f, 
    0.19462202f, 0.03626369f, 0.15690395f, 0.05347667f, 0.08592047f, -0.02980703f, 0.00488222f, 0.00452883f, 
    -0.02982307f, 0.01725291f, 0.07029676f, -0.07840956f, -0.01496861f, 0.01104697f, -0.01493712f, 0.09536754f, 
    0.16051616f, -0.08899350f, 0.02783011f, -0.06206696f, -0.06631219f, -0.04421499f, 0.29704088f, 0.09456398f, 
    -0.13884465f, 0.06406716f, -0.00091184f, -0.00651811f, 0.00159277f, 0.00070372f, -0.04133534f, 0.00153708f, 
    -0.05784151f, 0.13450697f, -0.12070355f, -0.11804536f, -0.08841257f, 0.00273408f, 0.06465026f, -0.05642141f, 
    -0.71143752f, 0.16956875f, -0.33014381f, 0.24260302f, 0.14613476f, -0.21666954f, -0.12113000f, 0.16419111f, 
    -0.21551614f, -0.03258747f, 0.00516584f, 0.00783652f, 0.06206267f, -0.04383082f, -0.01783492f, 0.00331405f, 
    0.02387086f, 0.06888966f, -0.41576695f, 0.14997749f, 0.18915187f, 0.05153581f, 0.10617381f, 0.13127139f, 
    0.05466680f, 0.00261728f, 0.00737751f, -0.04497667f, -0.05763854f, -0.02813372f, 0.04763074f, -0.07597842f, 
    -0.02663003f, 0.01762575f, -0.04855097f, -0.00498513f, 0.20181617f, -0.14142545f, -0.01638919f, -0.08932608f, 
    0.19674674f, 0.27145267f, 0.17578790f, 0.13057329f, -0.02452232f, 0.16269645f, -0.10103472f, 0.01804708f, 
    0.13010497f, -0.05355066f, 0.05546275f, -0.00086514f, 0.02899783f, -0.07885681f, -0.06530133f, -0.17287461f, 
    -0.11167232f, -0.17685887f, -0.08160833f, 0.04031277f, 0.15737216f, -0.11698243f, -0.07003637f, 0.04502138f, 
    -0.08622453f, -0.02396359f, -0.00604821f, 0.00908798f, 0.00787563f, -0.01673369f, 0.15476477f, 0.08800355f, 
    -0.05013369f, -0.07214022f, -0.03277444f, -0.04261214f, 0.00923310f, -0.09469939f, 0.04364476f, -0.00992463f, 
    0.12995023f, 0.11604644f, 0.17229420f, 0.11465815f, 0.16572957f, -0.04546524f, -0.05450113f, -0.00176499f, 
    -0.07353538f, -0.07140455f, 0.00838017f, -0.04080468f, -0.02703094f, 0.08913677f, -0.01671338f, -0.07856478f, 
    -0.16081396f, -0.19067657f, 0.02485717f, -0.02671745f, -0.09331041f, -0.09705521f, -0.41215020f, -0.00861194f, 
    -0.18725848f, 0.01522659f, -0.04640957f, -0.39663321f, 0.18871158f, -0.08651721f, -0.00181060f, 0.11652594f, 
    0.02331324f, 0.06809295f, 0.04442907f, -0.06463339f, 0.00286208f, 0.04766923f, -0.31174341f, -0.28450641f, 
    0.21842565f, -0.04812870f, -0.02634000f, 0.21884592f, 0.14790866f, -0.08704168f, -0.01819600f, -0.00841527f, 
    0.10905915f, -0.02074700f, 0.01328302f, 0.03344737f, 0.06257707f, 0.00827689f, 0.19100586f, -0.00044990f, 
    -0.18388559f, 0.06322648f, 0.03652885f, -0.16367558f, 0.16808422f, 0.08669986f, -0.06333826f, 0.04122443f, 
    0.20460433f, -0.13579269f, -0.04524813f, 0.05366302f, -0.04977560f, 0.07454772f, 0.15226640f, -0.02458104f, 
    0.15132019f, -0.11998772f, -0.09154748f, -0.03031204f, -0.03248963f, 0.07268457f, 0.02833532f, -0.10073855f, 
    -1.73957729f, -0.79961270f, 0.16767119f, 0.06047090f, -0.18183406f, 0.20305751f, 0.01385381f, -0.11256647f, 
    -0.39956373f, -0.06970669f, -0.03835176f, 0.06492662f, -0.08804592f, 0.02357323f, -0.09052461f, 0.09986655f, 
    -0.02710663f, 0.02765191f, 0.10462458f, 0.01863487f, -0.01171539f, 0.11347387f, 0.05421758f, 0.04393655f, 
    -0.69798183f, 0.02411397f, -0.03566173f, 0.00670764f, -0.12884322f, -0.08061199f, 0.00903349f, 0.01446450f, 
    -0.01280528f, 0.01146919f, -0.03005556f, -0.05568092f, -0.47608182f, -0.36172464f, -0.16138130f, -0.27753338f, 
    -0.26850501f, 0.05497369f, -0.11480065f, -0.14297856f, 0.06141113f, 0.02200840f, 0.02837272f, 0.17212757f, 
    0.19737591f, -0.00563958f, -0.03557649f, 0.02815643f, 0.06666689f, 0.04952132f, -0.00354999f, -0.07001666f, 
    -0.00766968f, 0.07382540f, 0.06195432f, 0.03608987f, -0.15505083f, 0.09837983f, 0.20962964f, 0.15343417f, 
    -0.20502552f, 0.10104991f, -0.10232033f, 0.15811346f, -0.15660638f, -0.04621011f, 0.01424616f, 0.02304822f, 
    -0.03488539f, -0.05741904f, 0.05684983f, 0.24005486f, -0.00017781f, -0.00553213f, -0.09884588f, -0.05193774f, 
    1.31828928f, 0.04947123f, -0.23318863f, 0.08110373f, -0.30217424f, -0.09947965f, 0.12400243f, 0.00214936f, 
    -0.04598774f, 0.08909241f, 0.18535584f, -0.07854341f, -0.08820932f, -0.02732476f, 0.02013213f, 0.00753959f, 
    -0.00366752f, -0.09097482f, -0.05151803f, 0.07633287f, 0.16750520f, 0.11041171f, 0.24173808f, -0.10256416f, 
    -0.18921009f, -0.00554579f, -0.15089031f, -0.12798676f, 0.15903480f, 0.00227484f, 0.09831995f, -0.09285157f, 
    0.05730303f, -0.13980952f, -0.08264869f, 0.07687384f, -0.10004093f, -0.17964944f, -0.06922486f, 0.04010664f, 
    0.10654385f, 0.12964807f, -0.02298971f, -0.11250415f, 0.13771120f, 0.11294922f, -0.18907824f, -0.06378379f, 
    -0.00616346f, 0.12287539f, -0.03309556f, 0.03188806f, 0.07026809f, 0.06052227f, 0.09094103f, -0.07314533f, 
    -0.05626161f, 0.24608083f, -0.27144778f, -0.13058785f, 0.41110441f, 0.11933888f, -0.04478365f, -0.07249843f, 
    -0.06587764f, -0.04108723f, -0.08063476f, 0.00398122f, -0.08449005f, 0.00106023f, -0.03306758f, 0.01570603f, 
    0.01186651f, -0.04792261f, 0.00871298f, -0.01628338f, -0.32825214f, -0.05966612f, -0.02110362f, -0.17591406f, 
    0.64874619f, 0.05329610f, -0.59336978f, 0.03169648f, -0.54646289f, 0.02094274f, -0.11653454f, -0.13423692f, 
    -0.16026635f, 0.09945087f, 0.08752794f, 0.07333045f, 0.13259523f, 0.09556510f, 0.08095085f, -0.01034564f, 
    -0.00629828f, 0.01539332f, 0.18047805f, -0.00248952f, 0.16540940f, -0.01897390f, 0.09478601f, -0.03078490f, 
    0.08528095f, 0.06351183f, -0.04713564f, -0.05784839f, -0.02768844f, -0.03449258f, -0.04493860f, -0.00448565f, 
    -0.11120366f, -0.00238422f, -0.05486852f, -0.34128213f, 0.00846563f, -0.05244699f, 0.03608528f, 0.04843633f, 
    -0.00810236f, -0.21336849f, 0.07017440f, 0.09135292f, 0.02279908f, -0.04610578f, 0.09470768f, 0.17085198f, 
    0.15274538f, -0.17780705f, 0.17182063f, -0.08932469f, -0.10009541f, -0.03508284f, -0.08355988f, -0.01034765f, 
    -0.01561779f, -0.03865411f, 0.03891132f, -0.01852883f, 0.39789027f, 0.00363342f, 0.07678577f, 0.09556807f, 
    0.01406450f, -0.02191391f, -0.01976486f, -0.02938894f, 0.02541858f, -0.03445242f, -0.10917057f, 0.14680833f, 
    0.08573631f, -0.06548209f, -0.03344958f, 0.09100451f, -0.02144944f, -0.10856147f, 0.17676695f, 0.10050222f, 
    0.01736894f, -0.15766910f, 0.33376858f, 0.05228736f, 0.14354822f, 0.01851606f, -0.07528725f, -0.02015169f, 
    0.17134589f, -0.29561517f, -0.12938792f, -0.12698857f, 0.03203982f, -0.06442673f, 0.04404799f, -0.00377449f, 
    -0.05023506f, 0.01217037f, 0.01448845f, -0.06093039f, 0.03440533f, -0.10146227f, 0.12051000f, 0.31758258f, 
    0.01246039f, 0.07738733f, -0.16732009f, -0.03529476f, 0.22815692f, -0.22839043f, 0.02380486f, 0.16866478f, 
    0.04027238f, 0.01011048f, -0.04688258f, -0.01057727f, -0.11973989f, 0.04038783f, 0.05955369f, -0.03985947f, 
    -0.67072350f, -0.07783181f, 0.41274139f, -0.02363808f, -0.23984618f, -0.01734784f, 0.09011286f, -0.02366298f, 
    -0.02865815f, 0.12456792f, -0.00293654f, 0.00518514f, -0.02221098f, 0.03498465f, 0.02799392f, 0.10752939f, 
    -0.07789577f, 0.00138082f, -0.09090007f, -0.11931431f, -0.50749707f, 0.05982459f, 0.05628744f, 0.05821797f, 
    -0.02376341f, -0.20357393f, 0.13486071f, -0.52551842f, -0.44668236f, 0.03826368f, 0.03394879f, -0.00952742f, 
    -0.00692935f, 0.00492241f, -0.03515246f, -0.01631518f, 0.00876313f, -0.03563767f, -0.24404308f, -0.06871849f, 
    -0.06613060f, 0.07493898f, 0.02387422f, 0.07820657f, 0.16954857f, 0.02191279f, 0.00726712f, -0.19630051f, 
    -0.09264264f, -0.21427056f, 0.06276203f, 0.17360842f, 0.04561494f, 0.01911862f, 0.06853348f, 0.00319667f, 
    0.02327671f, -0.02376894f, 0.03577228f, -0.03303233f, -0.05086894f, 0.15659788f, -0.08073257f, 0.06198139f, 
    0.00702413f, -0.08097471f, 0.12201491f, 0.04870135f, -0.00514960f, -0.05686068f, 0.02953593f, 0.08014350f, 
    0.09968560f, -0.07850844f, 0.04251358f, -0.00142470f, -0.01566533f, 0.01841307f, 0.01840178f, -0.04229725f, 
    0.01527495f, 0.07014213f, -0.14586090f, -0.16694631f, 0.04162612f, 0.02411255f, -0.04136373f, 0.04589720f, 
    0.03286717f, 0.03252655f, -0.05298631f, -0.11456180f, 0.07627637f, 0.04579661f, 0.08798408f, 0.03612690f, 
    -0.09034325f, -0.35156080f, 0.21964359f, -0.00774949f, 0.22540049f, 0.00630098f, -0.12121534f, 0.03392189f, 
    0.16071108f, -0.12686203f, 0.02934035f, 0.05816735f, -0.00868327f, 0.01521895f, 0.04829739f, -0.01635621f, 
    0.06572529f, 0.02976109f, 0.10784788f, 0.04588017f, -0.03194384f, -0.01504418f, 0.05241653f, -0.06492057f, 
    -0.16034736f, 0.02592413f, -0.01852082f, 0.01987626f, 0.00226467f, -0.02117347f, -0.02927694f, 0.02186904f, 
    0.05485922f, 0.01708875f, -0.02075573f, -0.25824240f, 0.08483024f, -0.02508815f, 0.05595697f, 0.02798426f, 
    -0.03877763f, -0.07738355f, 0.03710726f, 0.01970548f, -0.47352114f, -0.00103269f, 0.19032848f, -0.35636261f, 
    -0.00194212f, -0.00047976f, 0.05886955f, -0.03518953f, 0.03380179f, 0.11985880f, 0.03390920f, 0.04085825f, 
    0.03900147f, 0.04822941f, -0.02872128f, -0.01374123f, -0.18354648f, -0.08470206f, -0.00334691f, 0.00536472f, 
    -0.13014065f, -0.24750507f, 0.00761305f, -0.15111133f, 0.04508698f, -0.04144367f, -0.05348352f, -0.00385694f, 
    0.00068971f, 0.09239954f, 0.06211991f, -0.03466028f, -0.05123348f, 0.11373410f, -0.08901237f, -0.20415567f, 
    -0.16763869f, 0.02439333f, 0.01051070f, -0.06237562f, -0.44612220f, 0.06403238f, 0.15949532f, -0.00435696f, 
    -0.03852896f, 0.03220804f, -0.14148478f, -0.01073056f, 0.00426039f, 0.11357620f, -0.06345150f, -0.05505182f, 
    -0.12363939f, 0.05416983f, 0.08495615f, -0.09491878f, -0.11923593f, 0.14448249f, 0.15533361f, -0.12424370f, 
    -0.50095522f, -0.86996669f, -0.94638777f, 0.04485815f, -0.70807463f, -0.01529548f, 0.17372926f, 0.07355627f, 
    -0.10610241f, -0.02050641f, 0.00313238f, 0.05186650f, 0.03064341f, -0.05211269f, -0.07766385f, -0.09385640f, 
    -0.01627148f, 0.04601338f, -0.32087871f, -0.16396771f, -0.14487354f, -0.26278213f, 0.09009791f, -0.14060426f, 
    -0.07871743f, -0.01085668f, -0.02275985f, 0.04080881f, 0.00854595f, 0.04870425f, 0.06374824f, -0.02540649f, 
    -0.04672728f, 0.08304990f, -0.13808115f, -0.11915934f, -0.18565431f, -0.07924411f, -0.01273597f, -0.07283539f, 
    -0.26198217f, -0.25170639f, 0.25067005f, 0.46182221f, -0.29186100f, -0.13020036f, -0.03951983f, 0.00816183f, 
    0.10414551f, -0.13426828f, -0.01717118f, -0.02325110f, -0.02686387f, 0.02329070f, 0.11336965f, -0.11090848f, 
    -0.02963590f, 0.10343105f, 0.07627867f, 0.09081731f, 0.04965702f, 0.07233093f, 0.29189020f, 0.02613334f, 
    0.12026981f, 0.00280090f, 0.01535175f, 0.10473022f, 0.10737079f, -0.06918435f, -0.08640635f, -0.16922110f, 
    -0.05793062f, -0.02480479f, 0.12310600f, 0.01362271f, -0.01883129f, 0.00398403f, 0.00142101f, -0.10671765f, 
    -0.21874148f, -0.31007504f, -0.20997854f, -0.10171090f, 0.01086287f, -0.00211736f, 0.01134927f, -0.00146689f, 
    0.06363322f, 0.01777028f, 0.07478148f, -0.11071716f, 0.03303565f, 0.05946801f, 0.03214798f, -0.00107411f, 
    0.20192234f, 0.06170492f, 0.03834924f, -0.03368356f, -0.07742900f, -0.83417940f, -0.07713372f, -0.21028225f, 
    -0.19685376f, 0.11360160f, -0.04422289f, -0.15052406f, 0.04014044f, 0.01157592f, -0.03667903f, -0.00691568f, 
    -0.03308337f, -0.03638993f, -0.03758581f, -0.04571829f, -0.03743817f, 0.00139811f, 0.11525035f, 0.17689304f, 
    0.16655707f, -0.05054646f, -0.36735910f, -0.27762246f, 0.21528623f, 0.09126599f, -0.02639893f, 0.02792194f, 
    0.10363639f, 0.11625983f, -0.15617026f, 0.02389544f, 0.13685012f, -0.07922833f, -0.10614231f, 0.10707998f, 
    0.00782902f, -0.02425628f, 0.10828580f, 0.07165449f, 0.31235144f, 0.12573883f, -0.15877827f, -0.06374601f, 
    0.09597652f, 0.01730074f, -0.04405213f, -0.04032295f, -0.05422545f, 0.14703518f, -0.16927560f, 0.08248764f, 
    0.15416984f, -0.06357910f, 0.06975380f, 0.16598158f, 0.06632362f, 0.08924471f, -0.00897501f, 0.03442882f, 
    0.32740641f, 0.64510047f, -0.23533621f, -0.01286545f, 0.01393381f, -0.00065796f, 0.08641863f, -0.08370086f, 
    -0.33959088f, 0.12448157f, -0.08189377f, -0.12776187f, 0.09005049f, -0.02468757f, 0.08810231f, 0.00986869f, 
    0.17346637f, 0.09443717f, 0.01441804f, 0.19759588f, 0.16797934f, -0.35166642f, 0.33322373f, 0.25393918f, 
    -0.36845773f, -0.05036866f, -0.10573778f, 0.04217361f, -0.03954787f, 0.10386014f, 0.01073045f, -0.03364807f, 
    -0.02370916f, -0.07015841f, -0.02709299f, 0.17732421f, 0.12427839f, 0.00058457f, 0.13024107f, 0.02352712f, 
    0.04406839f, -0.08309991f, -0.05466220f, 0.01994954f, -0.00576339f, -0.09098157f, -0.19513454f, -0.33802131f, 
    -0.15063709f, 0.07510146f, -0.03652148f, -0.14190699f, 0.05383957f, -0.00255270f, -0.07985346f, 0.02271904f, 
    -0.01719709f, -0.03815181f, -0.05399993f, -0.07269526f, -0.22817087f, 0.19948758f, 0.46183988f, 0.25579441f, 
    0.44101283f, 0.09238138f, -0.04401370f, 0.07582165f, -0.01064547f, 0.02725506f, -0.01690675f, -0.01434886f, 
    0.02224447f, -0.09708963f, 0.02043812f, -0.03109867f, 0.05315772f, 0.01257722f, -0.03187805f, 0.10306930f, 
    -0.28127509f, 0.42292836f, 0.51067007f, -0.08683857f, 0.12232927f, -0.05318654f, -0.01006075f, -0.00235634f, 
    -0.09034518f, 0.25700718f, 0.13574688f, 0.00846624f, -0.20208314f, 0.11232864f, 0.05516608f, 0.03896033f, 
    -0.02633968f, -0.05057453f, 0.14719976f, -0.12268288f, 0.07187485f, -0.19644433f, 0.76758355f, 0.27315682f, 
    0.32533523f, 0.09374399f, -0.09643365f, 0.01228661f, 0.12678921f, -0.01109204f, 0.03423086f, 0.01848798f, 
    0.03277127f, -0.10288688f, 0.09061467f, 0.04285855f, 0.03453681f, -0.01102514f, 0.03287729f, -0.04027887f, 
    -0.51948726f, -0.71800488f, -0.43261161f, 0.03989081f, -0.51261032f, -0.03004513f, -0.03279463f, 0.04258858f, 
    0.01350528f, -0.05491540f, -0.02965252f, -0.03300336f, -0.05343422f, -0.00383596f, -0.03108823f, -0.12437852f, 
    -0.06306601f, -0.07568505f, -0.04876867f, 0.09649656f, 0.05562697f, -0.35750586f, -0.01301454f, -0.02334294f, 
    -0.14805904f, -0.00965762f, 0.06065321f, 0.03526568f, 0.01548062f, 0.02268649f, 0.05791983f, 0.02460201f, 
    0.02282873f, 0.02034547f, -0.03680496f, 0.14597887f, 0.19106250f, 0.26816291f, 0.04997196f, 0.10287394f, 
    -0.60307842f, 0.75841296f, 0.10391527f, -0.01770698f, -0.74927670f, 0.05865776f, -0.11689338f, -0.13277926f, 
    -0.15152545f, -0.21418293f, 0.01730475f, 0.00301154f, -0.07248848f, -0.19293573f, -0.02297762f, 0.04497542f, 
    0.13143227f, 0.02302081f, 0.16780235f, 0.03191658f, -0.15669496f, -0.02996603f, -0.00316284f, -0.09114228f, 
    0.07409041f, -0.05028224f, -0.01330063f, 0.00308722f, 0.01562449f, 0.05701435f, 0.03687070f, -0.04857214f, 
    -0.27116352f, 0.22880465f, 0.04637130f, 0.14837383f, -0.24246110f, 0.05168211f, 0.05744562f, -0.04858474f, 
    0.02885073f, -0.46013060f, 0.67743480f, 0.30741176f, 0.20224863f, -0.02608645f, -0.14673103f, 0.03717503f, 
    0.28033942f, -0.02561456f, 0.05816674f, 0.05778972f, 0.04441923f, 0.03324907f, 0.01579288f, 0.04090438f, 
    -0.07319102f, 0.02618556f, 0.01435081f, -0.05631288f, 0.04178427f, -0.10180122f, 0.04440754f, -0.21961085f, 
    -0.00160174f, 0.00617096f, -0.08192825f, 0.00722675f, 0.02254832f, 0.05548846f, 0.06275667f, -0.05803545f, 
    0.00487256f, -0.02750684f, 0.11267868f, 0.06683153f, 0.09128992f, -0.13915634f, 0.13738146f, -0.05352214f, 
    -0.66820073f, 0.75005972f, 0.02314809f, -0.13266417f, 0.39714137f, 0.45240682f, 0.24592254f, 0.03397091f, 
    -0.03112417f, -0.03375331f, -0.26185495f, -0.03476930f, 0.00052696f, 0.02401396f, 0.09422843f, 0.00453883f, 
    0.16773695f, -0.04893538f, 0.20502274f, 0.00886802f, -0.34497079f, -0.15508392f, -0.42089415f, -0.11422184f, 
    0.40916494f, 0.17812470f, 0.10913795f, -0.06346722f, 0.03348794f, -0.15612413f, -0.09981073f, 0.14472766f, 
    -0.14260642f, 0.12868904f, 0.01504747f, -0.02646805f, -0.01398924f, 0.41057169f, 0.22758782f, -0.04810018f, 
    -0.26604417f, -0.54060555f, 0.62496895f, 0.27997348f, 0.61413127f, -0.13962598f, 0.02262460f, -0.09129804f, 
    0.14316420f, -0.15672067f, 0.12902129f, 0.07917672f, -0.10038009f, -0.05801194f, 0.05264854f, -0.08536688f, 
    -0.05998980f, 0.05935247f, 0.04365253f, -0.04557396f, -0.31882033f, 0.19892716f, 0.23703171f, 0.29860818f, 
    0.30963460f, 0.11082689f, 0.08391822f, 0.35013986f, 0.02496934f, 0.14129302f, 0.03621715f, 0.16066696f, 
    -0.11701337f, -0.05716119f, 0.05638724f, -0.15303096f, -0.03055972f, 0.16639881f, 0.02382074f, -0.25646994f, 
    -0.09168993f, -0.00675912f, -0.12034646f, 0.26651454f, 0.27932149f, -0.04700086f, 0.00913950f, 0.12783130f, 
    -0.04960612f, 0.10275394f, 0.04304116f, 0.18392459f, 0.03881866f, -0.09864794f, -0.05258749f, 0.19552886f, 
    -0.03347411f, 0.01837647f, 0.06881487f, 0.05220584f, -0.64558065f, 0.15850258f, -0.13142821f, 0.00945405f, 
    -0.21587186f, 0.09282984f, -0.29258329f, -0.17627001f, 0.00834007f, -0.07912916f, -0.03836826f, 0.07261793f, 
    -0.08017253f, -0.24006949f, 0.00502333f, -0.01819606f, -0.19383031f, -0.11818112f, -0.03041049f, -0.14191225f, 
    -0.56157959f, 0.46899161f, -0.25877824f, -0.18084536f, -0.37073973f, 0.07299376f, -0.52786165f, 0.20405555f, 
    0.07250184f, -0.01498680f, 0.04995780f, -0.09876757f, -0.18586244f, 0.06192235f, -0.06279872f, -0.02100261f, 
    -0.06583171f, -0.26350784f, 0.08699940f, -0.21891098f, -0.22797650f, 0.02981349f, -0.21945834f, -0.24933742f, 
    0.16246116f, -0.01140500f, -0.05902105f, 0.01734694f, 0.01091525f, 0.07216959f, 0.02170528f, 0.05679625f, 
    -0.14876337f, -0.11085820f, 0.00783696f, 0.04435339f, -0.09619551f, 0.09614818f, -0.16542916f, 0.21052344f, 
    -0.49905932f, -0.10922506f, -0.27948868f, 0.07747406f, -0.22052421f, 0.07571536f, -0.25486401f, 0.09878885f, 
    0.09476364f, -0.02237726f, 0.01784230f, 0.09333995f, -0.04289204f, -0.33530551f, -0.20416935f, 0.17309473f, 
    0.12101170f, 0.17478640f, 0.01029336f, -0.20533602f, -0.65786052f, -0.38993230f, 0.63966686f, -0.32622108f, 
    0.16689342f, -0.37761056f, -0.00448803f, -0.11100221f, -0.09142525f, -0.08944108f, 0.09265378f, -0.03164393f, 
    -0.09091265f, -0.08427246f, 0.10738079f, -0.00936772f, 0.01909243f, 0.18277413f, -0.27255517f, -0.08927041f, 
    -0.53420573f, -0.35318229f, 0.04403374f, -0.16669759f, -0.44209537f, -0.02669768f, -0.26262298f, -0.07390795f, 
    0.09670418f, -0.01799318f, 0.02964151f, -0.06905197f, 0.06783763f, -0.03784808f, 0.01169436f, -0.05282336f, 
    -0.12679714f, -0.18953167f, -0.01496738f, -0.06866137f, -0.14508159f, 0.18151423f, 0.27308929f, 0.67761981f, 
    0.58857352f, 0.05431255f, -0.06149334f, -0.28179318f, -0.02026603f, -0.32001281f, -0.01130024f, -0.06723586f, 
    0.10887125f, 0.00336073f, -0.15313835f, 0.05724834f, 0.02957887f, 0.28791705f, -0.00294657f, -0.00881540f, 
    0.06151466f, -0.13640438f, -0.39526618f, -0.05347620f, 0.23707825f, 0.03538727f, -0.00150943f, -0.12915681f, 
    0.02559100f, 0.00685978f, -0.03938413f, 0.01633047f, -0.00164241f, -0.06658387f, -0.06929585f, -0.09832519f, 
    -0.05358689f, 0.15659083f, -0.22236800f, -0.03486112f, -0.26214531f, -0.31618303f, -0.26211274f, -0.27465609f, 
    -0.40520421f, -0.14893003f, -0.30491033f, -0.07186115f, 0.16493198f, -0.08692659f, 0.02810366f, -0.08580936f, 
    0.08512865f, -0.01941211f, -0.06102237f, -0.05091978f, -0.06824045f, -0.22624767f, -0.11660614f, 0.04439491f, 
    0.02276059f, -0.07571212f, -0.26071113f, 0.02074320f, 0.25151643f, -0.02363178f, 0.04913171f, -0.02617706f, 
    0.03786426f, 0.09784068f, -0.02062469f, 0.05096870f, 0.00340969f, -0.06270704f, 0.06560493f, -0.07905566f, 
    -0.00003200f, 0.12517923f, 0.07821151f, 0.00919894f, 0.33245945f, 0.22238372f, -0.16478056f, 0.03962089f, 
    0.07504494f, 0.23206700f, 0.00646831f, 0.06459893f, -0.07118506f, -0.01767155f, -0.12731044f, -0.11048950f, 
    -0.11300403f, -0.05853893f, -0.02499941f, -0.03898899f, -0.07165144f, -0.13893254f, 0.03013614f, -0.04039888f, 
    -0.41441214f, -0.26816654f, -0.32748124f, -0.11760541f, -0.48469409f, 0.43289274f, 0.41154003f, 0.21434489f, 
    0.23749779f, 0.16391544f, -0.09732176f, -0.12976156f, 0.28620079f, -0.09915281f, -0.04887908f, 0.02603927f, 
    0.06878584f, -0.12149716f, -0.24091026f, -0.06423255f, 0.16752084f, -0.02470392f, -0.09487300f, -0.16806780f, 
    0.42465767f, 0.01524444f, 0.12287872f, 0.02485851f, 0.05392021f, 0.12439252f, -0.01257104f, 0.06018130f, 
    -0.03592018f, 0.06102574f, -0.09453337f, -0.10697283f, 0.03082448f, -0.06219197f, 0.02623520f, -0.04296164f, 
    0.18745458f, 1.40809584f, -0.17360635f, -0.18703321f, -0.40162849f, 0.04231488f, 0.00171119f, 0.05932531f, 
    -0.34763932f, 0.00246957f, -0.11681461f, -0.16829379f, -0.00346299f, -0.23388006f, -0.03753584f, -0.10151473f, 
    -0.11096024f, -0.06752164f, 0.08429337f, 0.11959981f, 0.07190114f, 0.38856265f, 0.01268457f, -0.45635712f, 
    -0.47784325f, 0.01760419f, -0.15135935f, -0.24101430f, -0.23029380f, -0.10764474f, 0.34913689f, -0.10239767f, 
    0.30178523f, -0.41593689f, 0.06745794f, 0.15981501f, 0.27252689f, -0.12126894f, 0.03152222f, 0.01938753f, 
    1.19811392f, 0.20475355f, -0.39355761f, -0.29506648f, -0.04044252f, 0.00240118f, 0.05364672f, 0.11813939f, 
    -0.13931665f, -0.41139501f, -0.17285587f, 0.00752545f, -0.06419171f, 0.09289831f, 0.08704609f, 0.08433212f, 
    -0.08445685f, 0.07327844f, -0.08366209f, -0.06805657f, 0.30937287f, -0.23947948f, -0.31755361f, 0.24662262f, 
    0.27044863f, -0.11096445f, 0.06436290f, -0.13818060f, 0.10767365f, 0.07417557f, -0.03752170f, -0.06216221f, 
    0.11446920f, -0.06204114f, -0.06716964f, 0.01276933f, 0.00445151f, 0.08712014f, 0.15125825f, 0.00584250f, 
    0.01682362f, -0.13355260f, -0.38192233f, 0.20276746f, 0.15398926f, 0.20319562f, 0.04158822f, 0.04358973f, 
    0.19326921f, 0.04249905f, 0.10717151f, -0.07537924f, -0.30050465f, -0.09027584f, 0.01917249f, 0.21099782f, 
    -0.17381413f, 0.26385063f, -0.32341471f, -0.04596829f, 0.38028526f, -0.05418507f, -0.25070044f, -0.09709457f, 
    0.22815254f, 0.24046548f, 0.04678374f, 0.09176179f, -0.02979021f, -0.14156672f, -0.07953940f, 0.03441149f, 
    0.11682183f, 0.13663678f, 0.14855689f, -0.16309945f, 0.08521175f, 0.04236473f, -0.10154421f, 0.02197706f, 
    -0.20792264f, 0.64624333f, 0.02099437f, 0.22390804f, 0.34825581f, -0.04764095f, -0.06840293f, 0.12325252f, 
    -0.06026385f, -0.09933691f, -0.14198184f, -0.03642092f, 0.18062301f, 0.05573457f, -0.01707149f, -0.00229594f, 
    -0.04948539f, -0.00364665f, -0.00865488f, -0.11024231f, -0.10468946f, 0.32871279f, -0.26610681f, 0.01433804f, 
    0.36140174f, 0.08975733f, -0.00150427f, -0.05481138f, -0.08490460f, 0.03262265f, -0.02141937f, 0.03621151f, 
    0.10725775f, 0.06978349f, 0.17287408f, 0.01597678f, -0.02952993f, 0.07015757f, -0.00886817f, 0.05948456f, 
    -0.00470844f, -0.14491810f, -0.21897760f, 0.07206240f, 0.28158846f, -0.09743784f, 0.18077728f, -0.06191914f, 
    -0.05213627f, 0.10256880f, -0.03802821f, -0.03509600f, -0.09995973f, -0.14949383f, -0.00771125f, 0.01353892f, 
    0.00469471f, 0.05605232f, -0.09958378f, -0.14835416f, -0.00960865f, -0.18747970f, 0.26515523f, -0.24227098f, 
    -0.06162149f, -0.20102848f, 0.01685034f, 0.21082976f, 0.22754939f, 0.08326413f, -0.05284003f, 0.00174429f, 
    0.14242356f, 0.02962352f, 0.03814754f, -0.08397614f, -0.07090255f, -0.15260789f, 0.08066498f, -0.02421344f, 
    -0.56737208f, 0.04411390f, -0.31819752f, 0.28715828f, 0.12396888f, -0.04197534f, -0.07603063f, -0.00714262f, 
    -0.20188546f, -0.02736055f, -0.06429745f, 0.02823994f, -0.08953399f, -0.05352064f, -0.11787993f, 0.00226726f, 
    -0.00280447f, -0.06162387f, -0.00088532f, -0.01362892f, -0.20016949f, -0.14826331f, -0.01918941f, -0.00282933f, 
    -0.00034556f, -0.06068248f, -0.07117603f, -0.16195817f, -0.13223337f, -0.32797194f, 0.02992511f, 0.03515195f, 
    0.01232271f, 0.11122048f, -0.05955737f, 0.06526133f, 0.09125791f, 0.39632243f, -0.19128782f, 0.08084077f, 
    -0.42913276f, 0.27752683f, -0.23845293f, -0.07132520f, 0.34181303f, 0.30039164f, 0.09690926f, 0.05462347f, 
    -0.04670686f, -0.20520656f, -0.27393395f, 0.06896342f, -0.02749570f, 0.09951474f, 0.17111050f, -0.06263655f, 
    0.00269257f, -0.08443091f, 0.13308235f, 0.05913271f, 0.32903102f, 0.07193475f, -0.06473693f, 0.22868881f, 
    -0.52239126f, 0.13119584f, 0.02217006f, -0.15703352f, 0.05236557f, -0.05010566f, -0.05757843f, -0.23751576f, 
    0.05876308f, 0.01336696f, -0.04684258f, -0.09612298f, -0.15796930f, -0.09358712f, 0.05959649f, -0.13132726f, 
    0.08138764f, 0.00223042f, 0.12791011f, 0.02403014f, -0.04384963f, -0.00873915f, -0.01822992f, 0.02561182f, 
    0.01910119f, 0.14330205f, 0.11296459f, -0.06999383f, -0.05048687f, -0.02718311f, -0.01786213f, 0.10237426f, 
    0.04940257f, 0.05961212f, -0.04327532f, -0.01693052f, 0.20549421f, 0.09225444f, 0.12152286f, 0.15160695f, 
    -0.03348647f, -0.07917800f, -0.17648640f, -0.08799351f, -0.04725264f, -0.05502313f, 0.08574382f, -0.02028878f, 
    -0.03363825f, 0.11453194f, 0.06604739f, 0.08813825f, 0.01285897f, -0.14382029f, -0.14354901f, -0.14045912f, 
    -0.05933416f, 0.15779190f, -0.39327267f, -0.01850165f, 0.30943933f, -0.02950124f, -0.05250116f, 0.04171493f, 
    -0.00708897f, 0.05814530f, 0.04830202f, -0.01038182f, 0.04614874f, 0.00000449f, -0.01899269f, -0.03080934f, 
    0.11063913f, -0.00492347f, 0.01120639f, 0.00504587f, 0.13715629f, -0.04910539f, 0.19332230f, 0.02999717f, 
    0.31461275f, -0.08269852f, 0.04308771f, 0.30819753f, 0.00405115f, 0.11311147f, 0.04761545f, 0.05715346f, 
    -0.04013472f, -0.12770846f, -0.00204411f, -0.00120204f, -0.08380309f, -0.07566758f, -0.17338358f, -0.19957297f, 
    0.17470814f, -0.02172549f, 0.20232043f, 0.07192261f, 0.01566788f, 0.00606846f, 0.03032390f, -0.09993719f, 
    -0.20028543f, -0.07081368f, 0.11056001f, -0.12416352f, 0.09918433f, -0.06167656f, -0.01363187f, -0.01761155f, 
    0.00216515f, -0.04907458f, 0.02467842f, -0.11535129f, 0.02682681f, -0.19066778f, -0.01750427f, -0.16255632f, 
    -0.04355793f, 0.00507572f, 0.07717437f, 0.07723520f, -0.06002387f, -0.08698770f, -0.22495165f, -0.13322727f, 
    -0.10461482f, -0.06532704f, -0.03868430f, -0.01412108f, -0.06986839f, 0.00716436f, -0.06451141f, -0.13544886f, 
    0.09411156f, -0.18691541f, -0.00342514f, -0.06966700f, -0.05963050f, 0.09722155f, -0.02373758f, 0.04584435f, 
    0.05115920f, -0.16833633f, 0.02014992f, 0.01849413f, -0.07417016f, -0.15564603f, 0.12711914f, 0.07309884f, 
    -0.26843283f, 0.22235143f, -0.21055414f, -0.28596029f, 0.04536085f, -0.01383098f, 0.09794488f, 0.03419883f, 
    -0.07151397f, 0.08457728f, -0.15054645f, -0.11757636f, -0.01794727f, 0.00884645f, -0.07283926f, -0.05638627f, 
    -0.01545547f, -0.01972816f, 0.06448769f, -0.04794450f, -0.13684136f, 0.00991307f, -0.14561214f, -0.15659547f, 
    0.06831020f, -0.01829334f, -0.03615190f, -0.02061827f, 0.01917187f, 0.07495055f, 0.03726969f, 0.07764582f, 
    -0.02368934f, 0.01400485f, 0.04806475f, 0.04845231f, -0.16796507f, -0.00590829f, 0.05384566f, 0.06943151f, 
    0.00764467f, -0.03740239f, -0.03584926f, -0.12234847f, 0.27665544f, -0.05325714f, -0.20268165f, 0.15372054f, 
    0.26449651f, 0.02571558f, 0.00869032f, 0.04444634f, -0.03837417f, 0.02943677f, -0.00542601f, 0.03661403f, 
    -0.05639989f, 0.01351471f, 0.02331878f, -0.03663358f, -0.19397260f, 0.00360712f, 0.01324613f, -0.05274060f, 
    0.08473007f, 0.06901933f, -0.04553922f, 0.02860285f, 0.09004428f, 0.10917167f, 0.06561873f, 0.05949200f, 
    0.05786164f, 0.00600669f, 0.08805789f, -0.01583328f, 0.05397744f, -0.00397631f, 0.08515331f, 0.02172467f, 
    -0.07981008f, -0.02457541f, -0.05882880f, 0.08826473f, -0.20411786f, -0.09356306f, -0.15174760f, -0.14210004f, 
    0.03505046f, 0.02309823f, -0.10322256f, 0.00273795f, -0.00425818f, -0.00967996f, 0.01490261f, -0.00569827f, 
    0.19770922f, -0.11043493f, 0.01609001f, 0.05004612f, -0.14972973f, 0.04063416f, -0.16148083f, 0.01655843f, 
    0.15111186f, 0.28310248f, 0.40748906f, 0.47288465f, 0.28553870f, -0.32192370f, 0.00531791f, -0.08130985f, 
    0.11179094f, 0.10538521f, 0.04760917f, -0.00645234f, 0.00294552f, 0.05930927f, 0.08813215f, -0.06900147f, 
    -0.03722296f, -0.16261321f, 0.08037046f, -0.27918708f, 0.03047265f, 0.03020522f, -0.02719873f, 0.02495212f, 
    0.16174179f, 0.05970811f, 0.03840855f, 0.03518049f, -0.01027658f, 0.02289184f, 0.08883028f, 0.02175380f, 
    0.05922456f, 0.04018892f, 0.10905866f, -0.01579572f, 0.04775763f, -0.05022046f, 0.01051286f, 0.06262758f, 
    -0.19417861f, -0.11379952f, 0.25150359f, 0.07477317f, 0.01713153f, -0.14252344f, 0.06589960f, -0.02615102f, 
    -0.04656116f, -0.16416356f, -0.00864912f, 0.02915414f, 0.03387924f, -0.00159873f, 0.10193198f, -0.05944362f, 
    0.28599659f, -0.02078170f, 0.06911391f, 0.13940111f, -0.01136245f, 0.00116434f, 0.07182001f, -0.00234016f, 
    -0.01773780f, -0.03763060f, 0.00158720f, -0.00524686f, 0.02887157f, 0.05852615f, 0.10015921f, -0.12836404f, 
    -0.01787548f, -0.08399495f, -0.04071162f, 0.09249858f, -0.00133259f, 0.07922078f, -0.06891442f, -0.03877372f, 
    0.19078916f, 0.14051372f, 0.06619631f, -0.04795124f, -0.03331818f, 0.03741544f, 0.09434087f, -0.00652651f, 
    0.06807172f, 0.07353213f, 0.15958047f, 0.14659065f, -0.09915936f, -0.04738253f, 0.14868544f, 0.04215908f, 
    -0.00719979f, 0.01579984f, 0.03579904f, 0.05490198f, 0.05943518f, 0.03832759f, 0.17954978f, 0.42932758f, 
    0.09443209f, 0.16467427f, 0.11240389f, 0.10067324f, -0.11050397f, 0.11355043f, 0.00646217f, -0.06391681f, 
    -0.03772647f, -0.06504926f, -0.02292019f, -0.01329946f, 0.09097260f, -0.16377535f, 0.07266792f, 0.07352676f, 
    0.20434652f, -0.50860626f, -0.05071693f, 0.10426877f, -0.11227564f, 0.18178417f, -0.02226458f, 0.00157278f, 
    -0.17349447f, 0.08328132f, -0.10230596f, -0.10727137f, -0.16907790f, 0.02294796f, -0.15578008f, 0.07173698f, 
    -0.04942098f, 0.00686758f, -0.22110473f, 0.07763204f, -0.08777087f, -0.10157307f, -0.04843468f, -0.07076249f, 
    -0.12180673f, 0.10072146f, 0.03669531f, -0.07827949f, -0.00210420f, 0.01890753f, -0.05979915f, -0.17948578f, 
    -0.13671346f, 0.09292212f, 0.12775649f, -0.08629002f, -0.19883865f, -0.06232554f, -0.14012808f, -0.04182472f, 
    0.14723873f, -0.32517055f, 0.03741172f, -0.45209798f, 0.02008907f, 0.04252833f, 0.01492383f, -0.01790233f, 
    0.35810384f, 0.07946590f, 0.15111232f, -0.04346996f, -0.02825097f, -0.06449132f, -0.01703146f, -0.16899595f, 
    -0.18566449f, -0.08442017f, -0.22780077f, 0.06990952f, -0.57725191f, 0.16829813f, -0.20847847f, -0.33138263f, 
    -0.10307320f, 0.07643351f, -0.04425834f, -0.04742068f, 0.01057064f, 0.04337759f, 0.02488266f, 0.02399210f, 
    0.00338986f, 0.09427702f, -0.02795749f, -0.03513584f, 0.01865641f, 0.20249714f, -0.02539802f, 0.32726270f, 
    -0.08280969f, 0.05929188f, 0.15485533f, 0.09878055f, 0.10205051f, 0.15951598f, 0.00007353f, -0.17234766f, 
    -0.07011095f, 0.23758535f, -0.21976377f, 0.11562624f, -0.01750454f, 0.04026421f, 0.11639582f, 0.03558408f, 
    -0.11740781f, -0.21178007f, -0.25546548f, -0.42752087f, -0.42379093f, -0.19532955f, 0.05044127f, 0.00244924f, 
    0.06741893f, -0.12348293f, -0.00056895f, -0.03256934f, 0.00151509f, 0.09244277f, 0.05807991f, 0.08136875f, 
    -0.09432194f, 0.00835272f, -0.06973535f, -0.03762305f, -0.05196583f, -0.03398684f, 0.09940507f, 0.11264390f, 
    -0.40789354f, -0.30110478f, 0.05539370f, -0.25261244f, -0.09058551f, -0.13995460f, 0.03525349f, -0.01817508f, 
    0.03463621f, -0.12807156f, -0.00179553f, -0.25920650f, -0.17272089f, 0.13152465f, 0.06640299f, -0.01248907f, 
    0.09521845f, -0.07069146f, -0.05151420f, -0.11368220f, -0.22043207f, -0.05413554f, 0.10057998f, 0.10190195f, 
    0.15473993f, -0.21510158f, 0.05921292f, -0.22823928f, -0.18248677f, -0.15660077f, -0.08203872f, 0.05018939f, 
    -0.02361539f, 0.07631245f, -0.13502823f, -0.14076966f, -0.01414612f, 0.07421069f, 0.05360827f, -0.06706598f, 
    -0.14949559f, 0.09001216f, 0.17276128f, 0.12721659f, 0.11481061f, -0.07523832f, 0.08829569f, -0.02343720f, 
    -0.06476779f, 0.11674200f, 0.02048238f, -0.03418604f, -0.01342177f, 0.13080855f, 0.03309432f, 0.12692200f, 
    0.20680670f, -0.16902997f, 0.00348919f, 0.27980405f, 0.04861566f, 0.24203430f, -0.47369662f, -0.05393298f, 
    -0.01832892f, 0.07447548f, 0.04702531f, 0.00108134f, 0.09391006f, -0.02170473f, 0.08578709f, -0.00580588f, 
    -0.00358867f, -0.02438435f, 0.03425469f, 0.06833044f, 0.13864270f, 0.34389552f, -0.11745173f, 0.40443078f, 
    0.26081324f, -0.09527882f, 0.64167613f, -0.38844284f, 0.12956704f, 0.06984947f, 0.16955186f, -0.07032990f, 
    -0.06026189f, -0.22965232f, 0.02241710f, -0.08304686f, -0.02115063f, 0.06684919f, -0.13861169f, -0.08762273f, 
    -0.02211847f, -0.33284149f, -0.22997639f, -0.10289849f, 0.03939138f, 0.01073785f, -0.04774050f, -0.07221672f, 
    -0.05536889f, 0.06853402f, -0.00865906f, 0.08548652f, -0.01334524f, 0.01528537f, 0.12108350f, 0.10091253f, 
    0.03106917f, -0.27660623f, 0.04783300f, 0.10217544f, -0.00601918f, -0.11451555f, -0.11565755f, -0.03012009f, 
    0.23395760f, -0.27327624f, 0.33310646f, 0.20109338f, 0.05873701f, -0.24811703f, -0.17738409f, -0.11162230f, 
    -0.02384750f, 0.11058243f, 0.02429439f, -0.05312225f, 0.05637348f, 0.00561208f, 0.09512310f, 0.00382988f, 
    0.01545224f, 0.05597764f, -0.05452208f, -0.03575362f, -0.37973776f, 0.09618396f, -0.18405135f, -0.38334855f, 
    -0.25088340f, 0.12735081f, 0.00451450f, 0.00157120f, 0.05006608f, 0.08334261f, 0.00459679f, 0.05917637f, 
    0.14208966f, 0.00099503f, -0.04612797f, -0.14765799f, -0.02735212f, -0.01989202f, -0.21230529f, 0.04556478f, 
    -0.19358899f, -0.03692044f, -0.21225291f, -0.15504389f, -0.15304805f, 0.03004090f, 0.06211424f, -0.01497163f, 
    -0.06938119f, 0.11137762f, 0.04675350f, 0.08265845f, -0.12466475f, 0.02225186f, -0.05230332f, -0.06291681f, 
    -0.04040599f, 0.04318589f, 0.00106480f, 0.06827030f, -0.24906768f, -0.02200402f, 0.09440479f, -0.18519875f, 
    -0.33865431f, -0.04498854f, 0.15595597f, 0.02397027f, -0.04389147f, 0.21106307f, 0.17343697f, 0.05173099f, 
    -0.14385521f, 0.01037666f, 0.02753247f, 0.00240336f, 0.00944386f, -0.03299350f, 0.07320452f, 0.13512579f, 
    0.45606056f, -0.00831113f, -0.29081061f, -0.16348828f, 0.10624725f, 0.05844636f, 0.11809640f, -0.03135509f, 
    0.00802123f, 0.03884169f, 0.04911022f, 0.05731543f, -0.01006000f, -0.09947804f, -0.01276288f, -0.03372094f, 
    -0.20782232f, -0.02843163f, 0.09507470f, -0.04066740f, -0.00360789f, -0.03529273f, -0.05261003f, 0.06820934f, 
    0.03753810f, -0.00953776f, -0.02747727f, 0.07338852f, 0.12793754f, -0.03092045f, 0.00809738f, -0.07511149f, 
    -0.01806467f, -0.16535650f, -0.04211884f, -0.01453764f, 0.01689768f, 0.09411252f, -0.13310400f, 0.09225798f, 
    0.25932631f, -0.02414574f, 0.03164281f, -0.05079940f, -0.17134623f, -0.02803729f, -0.02034791f, 0.07125814f, 
    0.00247841f, 0.12163933f, -0.22059627f, -0.07761183f, -0.14968520f, -0.07346119f, -0.08370867f, -0.02417772f, 
    0.17124377f, 0.03290230f, 0.02095129f, 0.10185696f, 0.00694097f, -0.27305263f, -0.03065323f, -0.00308418f, 
    0.15046233f, 0.14824915f, -0.08863313f, -0.10346440f, 0.00521815f, 0.09180589f, 0.10880695f, 0.18736374f, 
    0.15969908f, 0.02740370f, 0.01612633f, 0.06850684f, 0.04696533f, -0.10129835f, -0.00593422f, 0.26914069f, 
    -0.09846009f, -0.53386468f, -0.25857702f, 0.08873321f, 0.19580357f, 0.14718851f, -0.09184263f, -0.19032912f, 
    -0.04375084f, 0.06075963f, 0.18573219f, -0.10040232f, -0.03281303f, 0.10625672f, -0.17312372f, 0.23772848f, 
    -0.05452599f, 0.32768974f, 0.11217409f, 0.26014501f, 0.20205064f, -0.20838924f, 0.07005066f, 0.05671419f, 
    -0.13016318f, 0.06425480f, 0.01145288f, -0.07453380f, 0.16156088f, 0.02421753f, 0.15455721f, -0.04076495f, 
    0.04254644f, 0.01297870f, -0.06478034f, 0.08124548f, 0.03831884f, -0.10566831f, -0.01663344f, 0.17340687f, 
    0.03340999f, -0.08498292f, -0.06962647f, 0.03543419f, 0.11808279f, 0.12121505f, -0.03693711f, -0.01245845f, 
    -0.08106011f, 0.01708486f, 0.08002269f, 0.06395065f, 0.11160117f, -0.10803777f, -0.12686004f, 0.11943293f, 
    0.10819149f, -0.04349042f, -0.06501808f, 0.07402794f, -0.04833184f, -0.02836420f, -0.16168430f, 0.01446007f, 
    0.07343213f, -0.06798020f, 0.07158294f, -0.01165353f, -0.04587767f, 0.07909973f, 0.03054668f, -0.03056249f, 
    0.01969331f, -0.04960660f, -0.10155604f, 0.10012983f, -0.00535492f, 0.03688027f, -0.11420342f, -0.05697167f, 
    -0.38603562f, -0.13360700f, -0.14404255f, 0.14600334f, 0.07887296f, 0.06329171f, -0.06934972f, -0.09018399f, 
    -0.03219340f, 0.09052158f, -0.08596744f, 0.07807852f, -0.00797162f, -0.06517994f, 0.03568772f, -0.04562659f, 
    -0.07739512f, 0.21897455f, 0.02435621f, -0.06657644f, 0.85451400f, -0.14645618f, -0.42415589f, -0.11265509f, 
    0.22756407f, 0.02872536f, 0.11190001f, 0.09747362f, -0.15780281f, 0.09506420f, 0.07454646f, -0.02359385f, 
    -0.02698871f, -0.14126571f, -0.00736772f, 0.19516195f, 0.26571858f, -0.23058768f, -0.12683807f, 0.05105347f, 
    0.22999331f, -0.06166218f, 0.39188391f, -0.03762071f, -0.27978352f, 0.36849701f, 0.17016584f, 0.01429707f, 
    -0.15275463f, -0.07094677f, 0.06689321f, 0.03102132f, 0.03147885f, 0.07816651f, 0.10138357f, -0.05579384f, 
    0.06704640f, -0.01253653f, 0.22338736f, 0.17019179f, -0.30830488f, -0.06078484f, -0.15208651f, 0.09063286f, 
    0.11744141f, 0.12924010f, -0.03562602f, -0.04014130f, -0.00993697f, 0.07290711f, -0.11945587f, 0.10042030f, 
    -0.01412781f, -0.01076965f, -0.00058186f, 0.08182891f, -0.05071461f, 0.20936903f, -0.00496619f, 0.04217125f, 
    -0.13973287f, 0.08297275f, 0.10858385f, -0.14992002f, -0.11194654f, 0.13349883f, -0.10498203f, -0.02983796f, 
    -0.03796484f, 0.07264719f, 0.02504299f, -0.01054490f, -0.00846178f, 0.12543190f, 0.02618670f, 0.18555160f, 
    -0.06969345f, -0.29492551f, -0.19333416f, -0.16178225f, -0.14132749f, 0.02418487f, -0.34018755f, -0.11257742f, 
    0.00093218f, 0.05219199f, 0.01041733f, 0.01661102f, -0.06291700f, -0.03882778f, 0.05297102f, 0.06913854f, 
    0.08421617f, 0.11856920f, -0.05828010f, -0.02187008f, -0.01464544f, 0.16401599f, -0.08751296f, 0.04623242f, 
    -0.05717835f, -0.07183138f, -0.07357259f, 0.11254018f, 0.09114433f, 0.04881143f, 0.03422315f, -0.03251595f, 
    -0.02564179f, -0.01083459f, -0.14815137f, -0.11221262f, -0.11547584f, -0.01060470f, 0.00140940f, -0.20529269f, 
    0.19211723f, 0.18701103f, 0.07322197f, 0.04340294f, -0.14710005f, 0.08408727f, 0.62229848f, 0.05305381f, 
    -0.26902422f, 0.06319077f, -0.03968863f, 0.21586289f, 0.02823211f, -0.14857668f, 0.07215693f, 0.01643342f, 
    0.04096965f, 0.02108316f, 0.07301017f, 0.07431783f, 0.06648639f, 0.08078385f, -0.21870634f, -0.11864170f, 
    -0.37458748f, 0.17116968f, 0.09665506f, -0.34934688f, -0.12007506f, 0.05802605f, -0.11409257f, -0.13108349f, 
    0.06315139f, -0.13060451f, 0.40603200f, -0.01990168f, -0.06670821f, 0.13962206f, -0.08310037f, -0.11000764f, 
    0.14126487f, -0.05610161f, 0.05821641f, 0.04277533f, -0.17402770f, -0.42969191f, 0.01914526f, 0.23726822f, 
    -0.00216216f, 0.15400483f, -0.18344469f, -0.14940484f, 0.15594794f, -0.02108635f, -0.13779747f, 0.07254597f, 
    -0.14496660f, 0.26507843f, 0.18132001f, 0.08240262f, -0.01483005f, 0.03271647f, 0.03984125f, 0.17924331f, 
    -0.54300517f, 0.81509501f, -0.32805017f, 0.50351131f, -0.04793863f, -0.10776902f, -0.23347095f, -0.06728011f, 
    0.02473347f, 0.25966600f, 0.03173467f, 0.01207745f, 0.00058753f, -0.04001917f, -0.15002507f, 0.03701351f, 
    0.00371122f, 0.03024635f, 0.01029055f, -0.05459540f, 0.57069951f, 0.23000449f, -0.14778724f, -0.25209704f, 
    0.33612421f, 0.06704974f, -0.02393673f, -0.05833958f, 0.04593424f, 0.00257168f, 0.02732696f, 0.04779554f, 
    0.03115285f, -0.03464515f, 0.02554907f, -0.24460536f, 0.03219958f, -0.25522557f, -0.01192434f, -0.27627087f, 
    0.17332743f, -0.13578109f, 0.22785278f, -0.11149747f, -0.14385085f, -0.16266088f, -0.03995216f, 0.02837443f, 
    0.00349088f, -0.07965399f, 0.00646169f, -0.23578905f, 0.09950687f, -0.04860417f, 0.05272812f, -0.04209345f, 
    0.11151679f, -0.02353912f, 0.04673748f, 0.26214924f, -0.24749513f, 0.24478243f, -0.25085694f, -0.07061026f, 
    -0.14486989f, -0.19575220f, -0.08438642f, -0.08264387f, -0.05684423f, 0.00463587f, 0.02543074f, -0.06426951f, 
    -0.01646962f, -0.08816040f, 0.06672840f, -0.30090845f, -0.11145154f, 0.08610872f, -0.01224156f, -0.17340316f, 
    -0.55092514f, -0.24390998f, -0.07816865f, -0.33846897f, 0.08519966f, 0.17706381f, -0.02780924f, 0.01003324f, 
    -0.03041836f, -0.17781141f, -0.00079835f, 0.12502654f, 0.14044303f, -0.26995164f, 0.01901021f, -0.10804030f, 
    -0.12139638f, 0.12710318f, 0.00019119f, -0.07042900f, -0.14268307f, 0.06666489f, -0.09060185f, -0.20483628f, 
    -0.10731076f, -0.04033805f, 0.02314410f, 0.19273280f, -0.10067873f, -0.03344521f, -0.01138901f, -0.00451845f, 
    -0.08876175f, 0.03734181f, 0.08900168f, -0.15994214f, -0.04149778f, 0.06615223f, 0.07987107f, -0.02787931f, 
    -0.05358024f, 0.00272318f, 0.32103640f, 0.23503706f, -0.23235543f, 0.08167949f, -0.11546737f, 0.08039793f, 
    0.14690009f, -0.15087287f, 0.08137909f, -0.01734482f, 0.00906547f, -0.01173040f, 0.00828122f, 0.08457474f, 
    0.01764538f, -0.30121118f, -0.19874366f, -0.33918574f, -0.08722971f, -0.16841203f, 0.12121946f, 0.17662922f, 
    0.08815666f, 0.08181025f, -0.03513389f, -0.03237536f, 0.04296639f, 0.00447891f, 0.00466374f, 0.01737306f, 
    0.05451537f, -0.00811771f, 0.01477922f, -0.31438416f, -0.16444248f, -0.03701713f, 0.05112255f, -0.18657802f, 
    -0.17702883f, 0.19985311f, 0.20967144f, -0.43651754f, 0.27859068f, 0.00513262f, 0.18261285f, 0.01030537f, 
    0.06892896f, 0.12743989f, 0.02538599f, 0.00884049f, -0.01957596f, -0.08629955f, -0.04386076f, 0.00591412f, 
    -0.10323539f, -0.20729874f, 0.11697526f, 0.00139076f, -0.00198942f, -0.09193529f, -0.24723764f, 0.18021978f, 
    0.01445897f, -0.01362675f, 0.01838685f, -0.02110099f, -0.01885543f, 0.02321086f, 0.09681234f, -0.09035812f, 
    0.30649409f, 0.11910836f, 0.04501414f, 0.23361591f, -0.05274961f, 0.07454785f, 0.01178632f, -0.11926913f, 
    -0.66406566f, 0.06048342f, -0.25213945f, -0.30930716f, -0.50172645f, 0.04663825f, -0.02678622f, -0.03202985f, 
    -0.09635361f, -0.02150105f, 0.00947984f, 0.10608351f, -0.09885219f, -0.15224044f, -0.02014342f, -0.03996540f, 
    -0.00216403f, 0.01920020f, -0.00429946f, 0.09314733f, 0.13863842f, 0.13319455f, -0.28751245f, -0.20840396f, 
    0.16686089f, -0.01681583f, -0.03470050f, 0.01028079f, -0.07414373f, -0.03747694f, 0.14211795f, -0.14336099f, 
    -0.12320682f, 0.01210438f, 0.00898675f, -0.03706324f, -0.12028820f, 0.16154061f, 0.02102797f, -0.12368221f, 
    -0.38992405f, 0.31053647f, 0.51346719f, -0.14759019f, 0.10242562f, -0.06535896f, -0.05124949f, -0.11657578f, 
    -0.07321215f, 0.09084582f, -0.03230321f, -0.04381388f, 0.05967938f, 0.06966738f, 0.18347323f, 0.02734270f, 
    0.00156437f, -0.05056829f, -0.09482829f, 0.01574631f, -0.70679778f, 0.50088638f, 0.54424006f, -0.05008280f, 
    -0.07465488f, -0.18837036f, -0.16969508f, -0.22192904f, -0.11932030f, 0.07657224f, -0.01444141f, 0.10307027f, 
    -0.01752704f, 0.08128779f, 0.05527865f, -0.00559059f, 0.04743303f, 0.05914182f, -0.08427894f, -0.00627928f, 
    0.17156038f, -0.23452690f, -0.21552801f, -0.44907460f, -0.03102478f, -0.00819721f, 0.06931441f, 0.19532827f, 
    0.01363751f, -0.15559113f, 0.02565226f, 0.01261254f, 0.01411146f, -0.01721698f, 0.01457285f, 0.02051328f, 
    0.02154377f, 0.01823818f, 0.06278600f, 0.17802814f, 0.31936848f, -0.07013887f, -0.50556195f, -0.17024729f, 
    0.17549251f, -0.14882185f, 0.03134158f, 0.23578191f, 0.22681153f, -0.04336032f, 0.03523041f, -0.02574632f, 
    -0.16594514f, -0.04168580f, 0.10735337f, -0.05025661f, -0.00634879f, 0.17092192f, 0.03018950f, 0.00934222f, 
    -0.00318206f, 0.47321635f, -0.06463172f, -0.19760227f, -0.05790095f, -0.24863109f, 0.01346592f, -0.35166392f, 
    0.08587365f, -0.01520990f, 0.06559186f, -0.05890627f, -0.03801327f, -0.03539077f, 0.04673272f, -0.01320093f, 
    -0.02469851f, 0.03022697f, 0.03776131f, -0.12303474f, 0.03111512f, 0.20002583f, -0.18010186f, -0.08091699f, 
    0.07106649f, 0.01850131f, -0.03083143f, -0.04250235f, 0.14453231f, 0.15818776f, 0.06894548f, 0.03538107f, 
    0.00165694f, 0.07848229f, 0.05152410f, 0.08962768f, -0.00012489f, -0.10275507f, -0.03883418f, 0.01527482f, 
    -0.03783513f, -0.01958968f, 0.05133782f, 0.14681888f, 0.10991880f, 0.01519583f, -0.00472795f, -0.01389787f, 
    -0.01909468f, 0.05682895f, 0.18788533f, -0.03178647f, -0.15464509f, 0.01415110f, -0.02154375f, 0.03759165f, 
    -0.08509090f, 0.01403024f, -0.15567094f, 0.00906338f, -0.30891493f, 0.33557847f, 0.09880225f, -0.05457319f, 
    0.13563114f, -0.13060296f, -0.01412039f, -0.12825632f, 0.01681934f, 0.09668727f, -0.04304783f, 0.06713346f, 
    -0.04738241f, 0.02690116f, 0.04247414f, -0.03219337f, -0.00749311f, 0.03205344f, 0.05098961f, -0.08725119f, 
    0.07867810f, 0.11287365f, -0.00280668f, -0.04820661f, 0.00286915f, -0.05706363f, -0.08991186f, -0.02998164f, 
    -0.05442831f, 0.04834648f, 0.02265151f, 0.06030408f, -0.20585953f, -0.04641044f, 0.16411178f, 0.04750556f, 
    -0.07804216f, -0.04646379f, -0.15203322f, -0.04702836f, 0.10056606f, -0.30615142f, -0.03947801f, 0.03039050f, 
    0.22360352f, -0.04520683f, 0.19599116f, 0.16460977f, 0.05639984f, -0.07675680f, 0.05793929f, -0.07850754f, 
    -0.06924393f, -0.01660464f, 0.07816595f, -0.05429005f, -0.01578517f, -0.01771026f, 0.01941951f, 0.11014180f, 
    0.09052411f, -0.04927687f, -0.26365659f, -0.07475016f, 0.02491863f, -0.00847305f, 0.05452109f, 0.02835792f, 
    -0.00082872f, 0.05802468f, -0.05224766f, -0.06497477f, -0.05176060f, -0.11727177f, -0.09251723f, -0.13746209f, 
    -0.11197520f, -0.26039329f, 0.07113554f, 0.04121782f, 0.52794755f, 0.13573946f, -0.28646642f, -0.34959009f, 
    -0.01338399f, -0.03765771f, -0.04555638f, 0.09774640f, 0.16398400f, -0.11479652f, 0.02797354f, 0.07010165f, 
    0.00855082f, -0.18968153f, -0.00729180f, 0.05111710f, -0.10591938f, -0.11128134f, -0.14920950f, 0.11881074f, 
    -1.24734294f, -1.17754638f, -0.59387064f, -0.10941389f, -0.03095733f, -0.04821848f, 0.04592831f, -0.17371312f, 
    -0.06420972f, -0.39719382f, -0.00437805f, -0.03003164f, -0.05508946f, -0.00890356f, 0.01280684f, -0.01161395f, 
    -0.00296236f, 0.01375859f, 0.15902294f, -0.04511781f, 0.13969946f, -0.13701020f, -0.28569856f, -0.11138194f, 
    0.02540426f, 0.05630235f, -0.02437445f, 0.04121324f, -0.01988551f, 0.06760954f, -0.04768406f, -0.01375946f, 
    -0.04187728f, -0.17484784f, -0.04889571f, -0.20137194f, -0.16271830f, -0.28712040f, 0.09334603f, 0.04791355f, 
    -0.26101270f, -0.54867345f, -0.73581117f, -0.32470793f, -0.10030217f, -0.00351919f, -0.02779527f, -0.14845777f, 
    -0.14737909f, -0.21741140f, -0.03376151f, -0.01330546f, 0.00804292f, -0.03706319f, -0.02489283f, -0.05143883f, 
    0.02148248f, 0.25328127f, 0.06742678f, -0.11801263f, -0.17515795f, 0.22137368f, 0.28041276f, 0.02657972f, 
    0.17548352f, -0.05915203f, -0.03208447f, -0.05227128f, -0.10056132f, 0.02836024f, -0.06881968f, 0.01953913f, 
    0.04865002f, 0.13159329f, 0.13665108f, 0.02183302f, -0.07827631f, -0.04196391f, -0.04917017f, 0.02438552f, 
    -0.06677204f, 0.03510820f, 0.00835185f, -0.16207011f, -0.01510515f, -0.05952169f, -0.07784677f, -0.10919353f, 
    -0.10271563f, 0.01428957f, -0.08099151f, 0.05425953f, -0.26439536f, -0.14465232f, -0.20141265f, -0.01109751f, 
    0.01431096f, -0.00910149f, 0.02414784f, 0.05620494f, -0.85008204f, -0.84775758f, -0.96108979f, -0.34682527f, 
    0.33748680f, -0.21480836f, 0.22887193f, -0.11568517f, -0.00483729f, -0.37667027f, -0.06549564f, -0.06550520f, 
    -0.03406998f, -0.00527299f, 0.12665683f, -0.01376604f, -0.01741310f, 0.08720106f, 0.37059969f, 0.09162112f, 
    0.01615399f, -0.17600448f, 0.19528742f, 0.19234550f, -0.27035674f, 0.01049331f, 0.10669102f, -0.06091195f, 
    0.00651541f, 0.02803883f, 0.06171627f, -0.05033593f, 0.01324895f, 0.08439407f, -0.22443679f, 0.13610788f, 
    0.14903907f, 0.02790144f, -0.00046454f, -0.03016749f, -0.08261818f, -0.02926786f, -0.06854938f, -0.09422405f, 
    0.12799121f, -0.04022979f, 0.11982788f, -0.02840151f, -0.01881402f, 0.25055614f, 0.11956806f, -0.03210470f, 
    -0.03488772f, -0.01745639f, 0.03208646f, -0.04375400f, 0.27998939f, -0.13007961f, 0.06473595f, -0.01569984f, 
    -0.29648218f, -0.17519671f, -0.50057375f, -0.23936915f, 0.54343987f, -0.37156793f, -0.11022265f, 0.09360979f, 
    0.31093660f, 0.32246736f, 0.15633586f, 0.08518705f, 0.18807021f, -0.05330530f, -0.04618396f, -0.02832283f, 
    0.03731861f, -0.07468775f, 0.20391160f, -0.02057772f, -0.53331059f, -0.19548482f, 0.18091069f, -0.18060914f, 
    0.10413732f, -0.06986981f, 0.03846583f, 0.02230657f, 0.12862150f, -0.10962514f, 0.08076046f, -0.05699456f, 
    0.07557234f, 0.07511742f, -0.01935547f, 0.05186738f, 0.22104187f, 0.26210514f, 0.07947743f, 0.06143918f, 
    -0.05570619f, -0.22840428f, -0.13176730f, 0.02740160f, 0.14598270f, -0.06369387f, 0.01529665f, -0.13935806f, 
    0.08894897f, -0.30319697f, -0.00130418f, 0.04076803f, -0.14645635f, 0.03209837f, 0.07356147f, -0.02308268f, 
    -0.01127483f, 0.01814197f, 0.22083434f, -0.32375103f, -0.30856150f, -0.36562073f, -0.34598407f, -0.11069450f, 
    0.52363110f, -0.10974618f, -0.09571322f, -0.00894730f, 0.01471126f, 0.07123760f, 0.06772017f, 0.00671346f, 
    0.11722968f, -0.16024442f, -0.11696447f, -0.01765806f, 0.07005638f, -0.04686345f, 0.15818423f, -0.04986732f, 
    -0.22975165f, 0.42526102f, 0.08467403f, 0.10370067f, 0.23415381f, 0.04949979f, 0.05792123f, -0.02674351f, 
    0.09746084f, -0.03295559f, 0.11908686f, 0.13676001f, 0.24540648f, 0.06451926f, 0.03298393f, 0.12576799f, 
    -0.02503442f, 0.03177603f, -0.06982303f, 0.01975181f, -0.66024154f, -0.36137918f, -0.23153499f, -0.03315011f, 
    0.47254276f, -0.06820217f, 0.09393132f, -0.07046625f, 0.03499993f, -0.06850079f, 0.04378458f, 0.07950298f, 
    0.07268544f, -0.04213489f, -0.07274311f, 0.02303836f, 0.05846001f, 0.06828157f, 0.08597442f, -0.04689499f, 
    -0.42360708f, -0.40533984f, -0.83674902f, -0.38584545f, 0.04315950f, -0.21697111f, 0.09437140f, -0.02278766f, 
    -0.21521756f, -0.45071426f, 0.02196745f, -0.03110096f, -0.04768135f, -0.03675747f, 0.05098097f, -0.11394458f, 
    -0.04500785f, 0.08417659f, 0.20030613f, 0.05771340f, -0.62628818f, -0.02858793f, -0.25206110f, -0.36229995f, 
    -0.05464312f, -0.03713799f, 0.08394571f, 0.08142862f, 0.00146975f, -0.00139330f, 0.00370443f, -0.03069449f, 
    0.02093785f, 0.03023374f, -0.05466891f, 0.04048665f, 0.18595217f, -0.02560200f, 0.04129741f, 0.05020156f, 
    -0.13459098f, -0.02998854f, -0.34844393f, -0.00002893f, -0.65376765f, 0.08264335f, 0.10675936f, 0.07935379f, 
    -0.07102861f, -0.44198564f, -0.02966624f, -0.00750046f, -0.03313354f, 0.17089143f, 0.24329142f, -0.05950840f, 
    -0.10239004f, 0.29217261f, -0.19197240f, 0.07515400f, 0.08717265f, 0.05545628f, -0.03451718f, -0.21084107f, 
    -0.00118713f, 0.00270998f, -0.11790827f, 0.03512506f, -0.00127738f, 0.03558256f, -0.12920691f, -0.06653967f, 
    -0.02745977f, -0.05914250f, -0.08010620f, -0.06053577f, -0.10683467f, -0.19664879f, -0.03604918f, 0.03924803f, 
    -0.73740917f, 0.23662686f, 0.73562562f, 0.02081299f, 0.10079500f, -0.06131005f, -0.11315455f, -0.01626646f, 
    -0.26724201f, 0.21771574f, -0.07095543f, 0.20043427f, 0.04120287f, 0.05914686f, -0.01559739f, -0.01274752f, 
    0.02479651f, -0.01614216f, -0.01725193f, 0.01525515f, -0.01527385f, 0.00142465f, 0.21178347f, -0.04270964f, 
    0.09508599f, 0.04867483f, 0.00525327f, 0.01647677f, 0.02555852f, -0.07604054f, -0.08253068f, -0.01804523f, 
    0.07751421f, 0.01832495f, 0.03214441f, -0.00931568f, -0.10389873f, 0.07766929f, -0.13430642f, 0.01141391f, 
    0.18860291f, 0.01621022f, 0.03138106f, -0.09185930f, -0.03398101f, -0.02212280f, 0.02384702f, 0.01387330f, 
    0.00697284f, -0.01013660f, 0.05409151f, 0.06915668f, -0.00188090f, 0.14068587f, 0.09174281f, 0.04647942f, 
    0.06141884f, -0.01513928f, 0.06584234f, 0.05094062f, 0.70094156f, -0.66575968f, 0.23045217f, -0.58557880f, 
    0.01203843f, -0.18882886f, 0.13909665f, -0.01852402f, 0.12692904f, -0.26692009f, 0.04884275f, 0.06922156f, 
    0.07238318f, 0.05121359f, 0.06890701f, -0.04242667f, 0.02723825f, -0.06197409f, 0.05114281f, -0.01524667f, 
    -0.21828249f, 0.07964479f, -0.08491331f, -0.12636892f, -0.08561554f, -0.03033524f, 0.01164475f, 0.04334978f, 
    -0.07184280f, -0.07567368f, 0.03920199f, 0.03396463f, 0.05947082f, 0.00204032f, 0.00116373f, 0.14665970f, 
    -0.01095503f, -0.00344650f, -0.00056168f, 0.03545272f, -0.13339393f, -0.13374791f, -0.00172689f, 0.12770401f, 
    -0.13165863f, 0.08790298f, -0.04423522f, 0.02208754f, 0.13948983f, 0.07508976f, 0.11979450f, 0.01752907f, 
    0.06959007f, 0.00182036f, -0.04691605f, 0.11630791f, 0.06102094f, -0.13640179f, 0.05640177f, 0.09016031f, 
    -0.17359923f, -0.26297507f, -0.27312523f, -0.04647646f, 0.00820982f, 0.09683450f, -0.09203164f, 0.10986761f, 
    0.22557889f, 0.12368797f, -0.08439373f, 0.18185967f, 0.09069612f, 0.07222024f, 0.04131928f, 0.02115955f, 
    0.04826451f, 0.07676587f, -0.12749654f, -0.10509638f, -0.02162611f, 0.00731774f, -0.15570988f, 0.01104241f, 
    -0.09138416f, 0.01517056f, 0.03732528f, 0.00972383f, -0.01185451f, -0.07709535f, -0.23126641f, -0.08587693f, 
    -0.05909475f, -0.10078681f, -0.11389074f, -0.08655763f, -0.07164816f, -0.01144606f, -0.01836368f, -0.01341689f, 
    -0.00810887f, 0.14515145f, 0.11476894f, -0.00248760f, -0.14246064f, -0.08643862f, 0.06744779f, 0.00347003f, 
    -0.11901084f, -0.10175392f, -0.08547260f, 0.06312451f, -0.04174029f, -0.00595679f, -0.08716065f, -0.16831258f, 
    -0.15079285f, 0.09796676f, -0.13667843f, 0.03585406f, 0.06797519f, -0.30447450f, -0.14435130f, -0.07176682f, 
    -0.18115468f, -0.16028614f, 0.05975543f, -0.04452834f, 0.01622654f, -0.18577912f, 0.08230743f, -0.06289063f, 
    0.05915265f, -0.07747180f, -0.09643131f, -0.00169151f, -0.04780339f, 0.02707487f, -0.08957229f, -0.08276701f, 
    0.00444090f, 0.03392974f, 0.01088155f, -0.01971780f, -0.05063962f, -0.02466029f, 0.01424247f, 0.01849496f, 
    0.03521078f, 0.00229464f, -0.19647110f, -0.24422167f, -0.25233027f, 0.10869455f, -0.01174249f, 0.03127958f, 
    -0.02062882f, 0.01061538f, 0.01337325f, -0.01014142f, -0.01527868f, 0.10098825f, 0.03698969f, -0.04333728f, 
    -0.12024304f, 0.00468186f, -0.04491330f, -0.04734373f, -0.05862083f, -0.02836275f, -0.00058254f, 0.02943206f, 
    0.07699895f, 0.04402710f, 0.00813118f, 0.00860735f, -0.23923697f, -0.17061636f, 0.11747219f, 0.01195251f, 
    0.03843065f, 0.06901482f, 0.01871511f, 0.01885194f, -0.09275960f, -0.04426413f, 0.03438083f, -0.03731189f, 
    -0.02923263f, -0.01751968f, 0.02080765f, 0.05190770f, 0.00649880f, -0.06578740f, 0.03145054f, -0.18754354f, 
    -0.19159874f, 0.20841487f, 0.04347742f, 0.03836542f, -0.12153956f, 0.19896287f, -0.10564718f, 0.00122508f, 
    -0.00326638f, -0.00985921f, 0.03835296f, 0.04063154f, -0.09296000f, 0.00318328f, 0.17919761f, 0.03211943f, 
    0.05751690f, 0.05835500f, 0.08499321f, -0.01779033f, -0.07322162f, 0.01703522f, -0.04835688f, 0.14131241f, 
    -0.04467779f, -0.97162962f, -0.10886057f, 0.64796793f, 0.01122178f, 0.03630500f, 0.20872279f, -0.03192592f, 
    0.09914669f, 0.08910035f, 0.04321840f, 0.03165973f, -0.01897108f, -0.04708589f, 0.02733204f, 0.02184069f, 
    -0.00559058f, -0.03445474f, 0.06212708f, -0.07554074f, -0.01859972f, 0.11183432f, -0.01748897f, -0.07023713f, 
    -0.14456749f, -0.02754937f, 0.01147229f, -0.06310149f, 0.05233774f, -0.01477369f, 0.06983346f, 0.05786706f, 
    0.00708634f, -0.01372510f, -0.01131466f, -0.12030241f, -0.19451600f, 0.16783719f, 0.10303944f, 0.00095211f, 
    -0.25499138f, -0.32656285f, 0.37135929f, -0.52784693f, -0.08093404f, 0.01809150f, -0.06522457f, -0.02768709f, 
    0.23783723f, 0.07441621f, 0.00513620f, 0.02492043f, -0.07407387f, -0.06140235f, -0.01701825f, -0.00661717f, 
    0.14581953f, 0.17252706f, 0.03800133f, -0.10494799f, 0.09964605f, 0.04125666f, -0.02578812f, -0.10047885f, 
    -0.05881221f, 0.01094889f, -0.02590636f, -0.02767239f, -0.04791909f, -0.02940022f, -0.15119612f, -0.11955707f, 
    -0.03219368f, -0.01806152f, -0.05502758f, -0.00589524f, 0.02164830f, 0.03571162f, 0.05994081f, -0.02116857f, 
    0.04006567f, 0.12469658f, -0.07331182f, 0.05954263f, -0.18845671f, 0.00133898f, 0.03796294f, 0.01602283f, 
    0.00790383f, 0.00202167f, 0.02649577f, -0.03981381f, 0.01346108f, -0.07007876f, -0.06492305f, -0.04059031f, 
    -0.00899653f, 0.07653968f, 0.01798868f, -0.05096141f, -0.23712209f, -0.55042356f, -0.15346798f, 0.67782092f, 
    -0.19232991f, 0.08051441f, -0.00056951f, -0.11749712f, 0.00829002f, 0.22094840f, 0.01574546f, -0.02781569f, 
    -0.06580643f, -0.03493482f, -0.09583061f, -0.01641716f, 0.01723957f, -0.21579732f, 0.06518287f, -0.02014877f, 
    0.06493841f, 0.06736358f, 0.07442453f, -0.16654070f, 0.03235377f, 0.04965844f, 0.09508209f, 0.00387533f, 
    0.06074286f, 0.03309086f, -0.06181085f, -0.04835369f, -0.08813479f, -0.24001713f, -0.05984560f, -0.09149078f, 
    0.05244582f, -0.04760337f, -0.03813244f, -0.06320331f, 0.01941036f, 0.16858768f, -0.12303443f, 0.05430935f, 
    -0.17138098f, -0.00668181f, 0.13005060f, -0.02341851f, -0.08209934f, -0.08878766f, -0.20328176f, 0.11885503f, 
    -0.06617193f, -0.02534243f, -0.12933309f, -0.03765703f, -0.07401545f, 0.07251740f, -0.04678121f, -0.04484442f, 
    0.97516125f, 0.33857772f, -0.43687826f, 0.12170420f, -0.49229193f, 0.04757746f, -0.14422029f, 0.23029120f, 
    -0.38575518f, -0.20962071f, -0.08707557f, -0.00429173f, 0.00389816f, 0.12290622f, -0.09362432f, -0.10423245f, 
    -0.20345807f, 0.07460209f, -0.16715898f, -0.11143288f, -0.28069356f, 0.42282876f, 0.27631530f, 0.37101996f, 
    0.25198269f, -0.02667473f, 0.10394822f, 0.15064321f, -0.08326449f, 0.04538023f, 0.02090730f, 0.01367372f, 
    0.02291709f, 0.08274765f, 0.03154959f, 0.13228588f, 0.11851603f, 0.10146653f, 0.04222643f, 0.06837815f, 
    -0.34223595f, -0.19806574f, 0.10811109f, 0.27267081f, 0.04656449f, 0.13214934f, 0.10549589f, 0.05533432f, 
    0.03237403f, 0.02998326f, 0.09107533f, -0.02519577f, 0.01241477f, -0.00837044f, 0.02548581f, 0.03913687f, 
    -0.02830143f, -0.01841603f, -0.04494493f, 0.05180162f, 0.41563243f, -0.52431679f, -0.74949682f, -0.79735565f, 
    -0.27218407f, 0.20001204f, 0.00720363f, -0.10351661f, 0.12420660f, 0.01484865f, 0.05192053f, 0.07580569f, 
    -0.12614980f, 0.06681791f, 0.01327488f, -0.14844534f, -0.06384732f, 0.02542539f, -0.00528083f, 0.04478276f, 
    -0.40009734f, -0.26403567f, -0.08697364f, 0.01708508f, -0.04300120f, 0.10746984f, -0.09003428f, 0.12895207f, 
    -0.05541590f, 0.02440078f, -0.20834294f, 0.06669676f, 0.03894110f, 0.10051966f, -0.12712973f, 0.03799662f, 
    0.03513097f, 0.03179330f, 0.03439512f, 0.05981669f, -0.14275835f, -0.76119715f, -0.19380462f, -0.57019067f, 
    -0.38372216f, -0.02088599f, -0.26896667f, 0.25321874f, 0.19958840f, -0.03703355f, -0.03235365f, 0.07313851f, 
    -0.03669982f, 0.01526356f, 0.06733135f, -0.09554583f, 0.00613675f, 0.08594617f, 0.03554194f, 0.02597606f, 
    -0.33319378f, -0.39128098f, -0.31502232f, 0.39470199f, -0.07067244f, 0.03881411f, 0.03917971f, -0.11282108f, 
    0.08217081f, 0.21391664f, -0.02519895f, -0.05351299f, -0.10623108f, -0.14617541f, -0.11800578f, -0.05861501f, 
    0.07683677f, 0.04200221f, 0.13967170f, -0.01543389f, -0.03855810f, 0.24660833f, 0.09183822f, 0.07954448f, 
    -0.16028918f, 0.01373246f, 0.12964399f, 0.01933826f, -0.12457168f, -0.00327367f, 0.04728770f, 0.07086939f, 
    0.04052337f, -0.02652968f, 0.03853460f, 0.05758182f, 0.14448179f, -0.08385369f, -0.03788117f, -0.02616209f, 
    -0.26578054f, -1.15201306f, 0.65482128f, -0.64043391f, 0.46898553f, 0.02689746f, -0.19163048f, 0.11132285f, 
    -0.05945643f, 0.00154056f, -0.03830120f, 0.04431710f, -0.05396661f, 0.01097610f, -0.18345575f, 0.10423069f, 
    -0.14238456f, 0.09801628f, -0.11546379f, -0.30818638f, -0.00001548f, 0.12289226f, 0.02409795f, -0.00569025f, 
    -0.09436688f, -0.06635191f, -0.00046751f, -0.00965203f, 0.00438243f, -0.03854561f, 0.08114897f, -0.05791267f, 
    0.04185429f, -0.00203601f, -0.11992509f, -0.06326517f, -0.02021676f, 0.02088147f, 0.04036152f, 0.02201326f, 
    0.82283902f, -0.58363611f, -0.64573789f, -0.32722822f, -0.20465788f, -0.03613501f, 0.09377312f, -0.36704916f, 
    0.18781553f, -0.08624950f, -0.00682816f, 0.01934725f, 0.14222959f, -0.06778452f, 0.03729612f, -0.04943090f, 
    0.06488037f, -0.00860329f, 0.06738975f, 0.03295930f, -0.00621726f, 0.05461194f, -0.03355156f, 0.11009619f, 
    0.01100698f, 0.03139166f, 0.03550356f, 0.07157228f, -0.03618291f, -0.05800926f, 0.08234082f, -0.15518300f, 
    0.00966763f, 0.01847463f, -0.02510195f, -0.07987935f, -0.03056800f, -0.04792129f, -0.14495084f, -0.01460890f, 
    -0.24530677f, -0.18937051f, -0.18033306f, -0.10627356f, -0.07701939f, -0.07939380f, 0.01586901f, 0.06460948f, 
    0.08007012f, 0.10741266f, 0.15732917f, 0.00688585f, 0.05960460f, -0.07040837f, -0.01171130f, 0.00999946f, 
    0.06218401f, 0.02816462f, 0.05113085f, 0.07031251f, 0.01918325f, -0.50114197f, -0.50173944f, -0.15001220f, 
    0.07159998f, 0.06764170f, 0.03590642f, 0.07508593f, -0.00326607f, 0.25132543f, 0.01199604f, -0.00533598f, 
    -0.04759335f, -0.04452472f, -0.08863074f, -0.05247482f, 0.08261705f, 0.06178798f, -0.06416439f, 0.09920262f, 
    -0.67784131f, 0.12723386f, 0.23382409f, 0.33023331f, 0.06440528f, 0.02716817f, -0.09161191f, -0.03095235f, 
    -0.09953596f, -0.09489459f, -0.08107314f, -0.06576637f, -0.00455492f, -0.02010914f, -0.06100264f, -0.14540735f, 
    -0.18737482f, -0.10470764f, -0.26032561f, -0.07472431f, 0.29317316f, -0.00947110f, -0.04234624f, 0.08429886f, 
    -0.27048355f, -0.02858164f, -0.20562139f, -0.36210144f, -0.26661390f, -0.15466532f, 0.02693821f, 0.05830086f, 
    0.11770093f, 0.00795059f, 0.00988923f, -0.08019214f, 0.10295866f, 0.13742669f, 0.12863593f, 0.18996406f, 
    -0.12827359f, -0.33509979f, -0.30762666f, -0.08025612f, 0.13372786f, -0.10224795f, 0.02037693f, -0.02680246f, 
    0.13553341f, 0.06923427f, 0.04995557f, -0.04443967f, -0.01066968f, -0.03520112f, -0.05394694f, -0.00089864f, 
    0.04527724f, 0.08475615f, 0.12764585f, 0.05543524f, -0.00594380f, 0.06302068f, 0.03060918f, 0.08963553f, 
    0.00768323f, 0.08243901f, 0.05233961f, 0.04950023f, -0.05563062f, -0.01935957f, 0.14596702f, 0.07862464f, 
    0.00684512f, 0.21068582f, 0.00180023f, 0.04776657f, -0.01029261f, 0.10547999f, 0.11253023f, 0.06605361f, 
    0.04432192f, -0.04716739f, 0.06428497f, 0.11670715f, -0.15605919f, -0.02808746f, 0.24900568f, 0.01420711f, 
    -0.02790590f, 0.06350237f, 0.01456893f, 0.15481958f, -0.01697440f, 0.13868792f, 0.13896774f, 0.12016548f, 
    0.24960357f, -0.00158054f, 0.12707445f, 0.08946377f, 0.34182447f, -0.13396491f, -0.26327637f, 0.08059091f, 
    -0.05241381f, 0.06168338f, 0.09371776f, 0.09910417f, -0.04574191f, -0.00048408f, 0.09403937f, -0.03001230f, 
    -0.09016193f, -0.04540517f, -0.01128268f, -0.02556812f, 0.09309252f, -0.02089767f, 0.21338741f, -0.00289374f, 
    -0.01362552f, -0.08138727f, -0.04361922f, -0.02608392f, -0.00675326f, -0.02224478f, 0.00638324f, -0.08196835f, 
    -0.10679460f, -0.00259394f, 0.09592447f, 0.07794596f, -0.00567462f, 0.12624566f, -0.00960190f, -0.00433589f, 
    0.06749665f, 0.08020474f, 0.12832959f, 0.08562043f, -0.22144379f, 0.11329076f, 0.23769346f, 0.07569058f, 
    -0.11527103f, 0.03565313f, -0.05349036f, 0.04414475f, -0.03050813f, -0.09508994f, -0.06661480f, 0.04001860f, 
    -0.03007232f, -0.01223252f, 0.01998695f, 0.00931736f, 0.01436297f, 0.03844496f, -0.04854062f, 0.06601959f, 
    -0.06090175f, 0.21647063f, 0.06977341f, -0.08164790f, -0.22419947f, -0.07549220f, -0.04325560f, -0.04749998f, 
    0.00336308f, -0.12569845f, -0.05455402f, -0.03034469f, -0.00485577f, -0.03366350f, 0.01505835f, 0.03189601f, 
    0.04604040f, -0.08082096f, 0.06317452f, 0.00874934f, -0.64518410f, -0.05706254f, 0.18738352f, 0.05359073f, 
    0.18245068f, -0.07018035f, 0.10331581f, -0.09710493f, 0.02760554f, -0.00913426f, -0.06670244f, -0.03150289f, 
    0.05693966f, 0.06717511f, 0.03951044f, -0.01489426f, 0.03431814f, -0.00173590f, 0.02758967f, -0.01359275f, 
    0.14946833f, -0.83627373f, -0.73559952f, -0.30373597f, -0.14763319f, 0.08201788f, -0.14016229f, 0.09977014f, 
    0.13460906f, -0.05509302f, -0.03785120f, 0.01020907f, -0.01706969f, 0.01860300f, 0.00479806f, 0.04481671f, 
    -0.00552353f, 0.11217127f, 0.07677069f, 0.23010391f, -0.19734091f, 0.15726060f, 0.05659032f, -0.02422616f, 
    -0.15922314f, -0.02140704f, -0.00357115f, -0.02898473f, 0.00418994f, -0.15084031f, -0.10334541f, -0.08378496f, 
    -0.01525722f, 0.00059280f, -0.00226457f, -0.01299389f, 0.11596502f, 0.06802887f, 0.11638309f, 0.02893751f, 
    0.22848676f, -0.13448951f, -0.35069758f, -0.27144393f, -0.03832876f, -0.02525061f, -0.18909685f, 0.11865028f, 
    -0.06472480f, -0.05227757f, 0.03803160f, -0.02495666f, 0.00386454f, 0.00572534f, 0.12719354f, 0.09043685f, 
    0.03867620f, -0.07476079f, -0.14068796f, -0.44072536f, -0.22919257f, -0.16560760f, -0.02315391f, -0.04064052f, 
    -0.01482169f, -0.07343797f, 0.05820468f, 0.10252982f, 0.04974612f, 0.02235420f, 0.09730997f, 0.14532365f, 
    0.09728117f, 0.01819658f, 0.04322080f, -0.01173973f, 0.03542482f, 0.02830062f, 0.10427095f, 0.01232116f, 
    -0.17739177f, -0.02724399f, 0.05749647f, -0.08864015f, -0.23718293f, -0.11136708f, -0.04850743f, -0.07110232f, 
    -0.05322699f, -0.10947735f, -0.13132985f, -0.03542558f, 0.06313048f, 0.09658949f, 0.00728900f, 0.05695212f, 
    0.08904387f, -0.03519546f, -0.01676919f, -0.02125821f, 0.24629568f, 0.06324095f, -0.03286956f, -0.36174130f, 
    -0.40269414f, 0.09604941f, -0.03769379f, -0.10030164f, -0.18932354f, -0.54558229f, -0.00231051f, -0.00269130f, 
    0.03398581f, 0.07797744f, 0.11188026f, 0.08677846f, 0.13165277f, 0.10312434f, -0.03451988f, -0.42332110f, 
    -0.14717761f, 0.04767570f, -0.06545180f, -0.04710371f, -0.17284267f, -0.01454132f, -0.05185631f, 0.03537306f, 
    0.09957600f, -0.10320810f, 0.04083030f, 0.17241724f, 0.02456946f, 0.08619264f, 0.19762947f, -0.18455034f, 
    -0.00893814f, 0.04194259f, -0.01496594f, 0.08852571f, 0.10328549f, 0.14586648f, -0.00675123f, -0.08100083f, 
    -0.25126371f, -0.04762580f, 0.05808978f, -0.04881231f, 0.10046676f, -0.05998087f, 0.09932076f, -0.00251450f, 
    0.05365019f, -0.04156755f, 0.07221620f, 0.03231127f, 0.11721569f, -0.05800009f, 0.01201737f, -0.01634560f, 
    0.88285333f, -0.54006851f, -0.19825514f, -0.10070883f, 0.22311139f, -0.03496788f, 0.46222776f, -0.07377902f, 
    0.25814846f, -0.06616946f, 0.11275623f, 0.02130977f, 0.02999969f, -0.04598996f, -0.01103253f, 0.15202217f, 
    0.02961522f, -0.12930164f, 0.07692091f, -0.19147278f, -0.39118111f, -0.44597399f, 0.32096407f, 0.17181195f, 
    0.52674770f, -0.07578558f, 0.01790871f, -0.09688174f, -0.03694190f, -0.02061195f, 0.04422203f, -0.05933297f, 
    0.05034194f, -0.04485369f, 0.02356850f, -0.24333695f, -0.08916993f, -0.23384044f, -0.08074073f, -0.29412258f, 
    0.52829438f, -0.11995834f, -0.07069959f, 0.00962283f, -0.25942406f, -0.12238975f, -0.21507053f, -0.28464296f, 
    -0.20468067f, -0.17258441f, 0.01453072f, 0.15533584f, 0.05833428f, -0.04599775f, 0.05715362f, -0.02551077f, 
    0.14545310f, 0.06207384f, 0.25371054f, 0.19785501f, 0.05794908f, -0.38061458f, -0.63565534f, -0.33681434f, 
    0.13052690f, -0.01065082f, 0.18478800f, 0.07012620f, 0.12468905f, -0.02723309f, 0.00903794f, -0.04824891f, 
    -0.06285935f, -0.00027556f, -0.02840568f, 0.14724141f, -0.03396964f, -0.08635419f, -0.07901436f, -0.10720709f, 
    -0.22228545f, -0.52721757f, 0.14448155f, 0.00630096f, 0.22282487f, -0.10859638f, 0.11858440f, 0.08454682f, 
    -0.13986136f, 0.06120441f, 0.05801518f, 0.10365082f, 0.01203105f, 0.08497820f, 0.04646769f, -0.06633092f, 
    0.03770544f, -0.08878705f, 0.03646278f, -0.04367783f, 0.15529417f, -0.43667936f, -0.58035880f, -0.27993509f, 
    0.03053490f, 0.00215547f, 0.18885797f, 0.21040212f, 0.01791080f, -0.08904410f, -0.05301595f, -0.11563122f, 
    -0.04918116f, 0.05281953f, 0.09053365f, 0.02507339f, -0.00752727f, 0.10178404f, -0.09994808f, -0.06494585f, 
    0.06900027f, -0.09679157f, -0.38966352f, -0.36512122f, -0.16633722f, -0.09591230f, -0.18871668f, -0.19788776f, 
    -0.17049013f, -0.37175480f, 0.01686415f, 0.00345299f, 0.03169520f, 0.10267359f, 0.05966146f, 0.13253587f, 
    0.06909455f, 0.18819657f, 0.02385861f, -0.19330780f, -0.25140676f, 0.21466090f, 0.26645494f, 0.17269251f, 
    -0.05440864f, -0.06913449f, -0.06381616f, -0.09486679f, -0.04557927f, -0.08593354f, -0.03263617f, -0.08591472f, 
    -0.02626360f, -0.08774126f, -0.01088296f, -0.13810109f, 0.00405963f, -0.20661032f, -0.19387768f, -0.28094873f, 
    0.06868064f, -0.77827805f, -0.36591494f, 0.23303789f, 0.23040831f, 0.07390166f, 0.14640243f, 0.07600787f, 
    -0.00776439f, 0.14800385f, 0.08489083f, 0.02380311f, 0.14430666f, 0.11536574f, 0.13126902f, 0.08323264f, 
    0.09633954f, -0.07440577f, -0.20767534f, 0.10823583f, -0.24139376f, -0.02667488f, 0.07092869f, 0.01405113f, 
    -0.12260523f, -0.05837722f, -0.01830989f, -0.03088085f, -0.03512596f, 0.02324977f, -0.03765011f, -0.00179166f, 
    -0.08150747f, 0.08729000f, 0.04183030f, 0.02513293f, 0.13294438f, 0.02198594f, 0.08132160f, 0.03655839f, 
    -0.11151223f, -0.20528865f, -0.83576155f, -0.22764872f, 0.20454116f, 0.03189200f, 0.11871653f, 0.25822327f, 
    0.12059446f, 0.00459252f, 0.12131102f, -0.12553391f, -0.04721770f, -0.04540510f, -0.07071196f, 0.01583777f, 
    0.05473740f, -0.01947691f, -0.00944193f, -0.07180037f, -0.48544037f, -0.02222791f, 0.20734747f, 0.11318883f, 
    -0.01448132f, -0.13250232f, -0.02880864f, -0.04499765f, 0.02738089f, -0.04358209f, -0.11292981f, 0.03750234f, 
    0.10441773f, 0.01882075f, 0.06249297f, 0.01379695f, -0.07859753f, -0.08441865f, -0.00907925f, 0.03566042f, 
    0.23274124f, -0.01273360f, 0.30124238f, 0.32114753f, -0.12824193f, 0.01039602f, -0.05663940f, -0.37224168f, 
    -0.23330577f, -0.28539377f, 0.01311693f, -0.04513297f, 0.19136709f, 0.15302381f, 0.08364879f, 0.09355699f, 
    -0.07050041f, -0.07030583f, -0.06724654f, -0.03737842f, 0.25997299f, -0.08944759f, 0.18875767f, -0.06421838f, 
    -0.16262898f, -0.12431425f, 0.06974196f, -0.21739289f, -0.02953572f, -0.03104724f, 0.02000589f, -0.07275809f, 
    0.07395607f, 0.02914818f, 0.07670698f, 0.06216710f, -0.09703968f, -0.11396919f, -0.06027728f, -0.11132944f, 
    0.02338841f, 0.09648080f, -0.69076413f, 0.11015250f, 0.08156297f, 0.09486423f, 0.04051980f, 0.20169891f, 
    0.01817790f, 0.11224114f, -0.00433057f, -0.01233930f, 0.01856558f, -0.04477382f, 0.02025883f, -0.06388288f, 
    0.12300355f, -0.01869602f, 0.00096366f, -0.07570834f, 0.07878925f, 0.17282285f, -0.32836047f, -0.16602992f, 
    -0.25092244f, 0.17795673f, -0.00166516f, 0.25798631f, -0.03358628f, 0.05769430f, 0.09410501f, -0.07353167f, 
    0.00842759f, -0.23338558f, -0.14253469f, 0.03679795f, -0.08959974f, -0.12511335f, -0.02148749f, -0.18873093f, 
    -0.15716112f, 0.24887758f, 0.64028978f, -0.14271419f, -0.31834316f, 0.16021827f, -0.31058082f, -0.03757866f, 
    0.10949089f, 0.07130112f, -0.17835616f, -0.01263774f, 0.09537471f, -0.02742031f, -0.00503202f, 0.01023440f, 
    -0.07564487f, -0.05353008f, -0.06938298f, -0.10661439f, -0.13551527f, 0.14568920f, 0.15037110f, -0.10229164f, 
    -0.02477818f, 0.14072822f, -0.08907086f, 0.07051968f, -0.09611892f, -0.16845585f, -0.01430557f, 0.07010035f, 
    -0.02243155f, 0.04117818f, 0.11115674f, -0.04226684f, -0.05876394f, -0.03783328f, -0.05140856f, 0.00183000f, 
    -0.34251028f, 0.03188989f, -0.10969503f, -0.49624842f, 0.12097248f, 0.19852449f, 0.04467959f, -0.06946789f, 
    0.02757816f, -0.06360308f, 0.13318066f, 0.02657027f, -0.11527663f, 0.09864427f, 0.10106552f, -0.08533536f, 
    -0.07977331f, 0.00454243f, -0.19371687f, -0.02135281f, -0.21342057f, 0.06129254f, 0.27380648f, 0.05540455f, 
    -0.14985056f, -0.04670701f, -0.13208756f, -0.00437981f, -0.05492868f, -0.04561552f, 0.02768881f, 0.12706013f, 
    0.00325279f, 0.03780998f, 0.02512671f, -0.03838902f, -0.02501222f, 0.00953702f, -0.04901727f, -0.05616645f, 
    -0.04135261f, 0.04965946f, 0.33331186f, -0.11862444f, 0.12942863f, 0.05564078f, -0.02326415f, 0.00343919f, 
    -0.01991189f, -0.13640288f, 0.11398945f, -0.06164394f, -0.01136900f, 0.05083282f, -0.05204463f, 0.02795366f, 
    -0.02268193f, -0.11281465f, -0.06109878f, 0.01880892f, 0.19533470f, 0.06451131f, -0.40485787f, 0.09265450f, 
    -0.12968953f, 0.15730001f, 0.14686228f, 0.32112294f, -0.00354227f, 0.14438026f, -0.00657805f, -0.01521181f, 
    -0.09680830f, -0.00327344f, -0.03232552f, -0.02267377f, 0.02724224f, -0.06258592f, -0.02881443f, 0.03167803f, 
    -0.32282779f, -0.00382818f, -0.41200346f, 0.11755921f, 0.10009485f, -0.13144627f, 0.24285643f, 0.21521351f, 
    -0.02000901f, -0.03024157f, 0.00759607f, -0.05508328f, 0.02777396f, -0.07301084f, 0.01151741f, 0.10079061f, 
    0.14757799f, -0.00200336f, 0.04803345f, 0.08018295f, -0.37871492f, 0.17128322f, 0.01552231f, -0.46293890f, 
    -0.10733897f, -0.04775867f, -0.15626326f, 0.02167261f, -0.07005706f, 0.02500966f, 0.05743515f, 0.03496729f, 
    -0.09305988f, -0.09190634f, 0.13160162f, -0.01766157f, 0.19335417f, -0.17071147f, 0.05391706f, 0.10773310f, 
    -0.20158318f, -0.23449206f, -0.00425242f, 0.12688942f, -0.56059456f, -0.13516667f, -0.31684470f, 0.19531672f, 
    0.13741621f, 0.23663320f, 0.02495692f, 0.08699791f, 0.01048967f, -0.07775026f, -0.02030064f, 0.01031403f, 
    -0.00574652f, 0.07492166f, 0.04283730f, -0.17755432f, -0.22892074f, -0.03740441f, -0.47830054f, -0.02310575f, 
    0.12049092f, -0.23685423f, 0.19207036f, 0.25976160f, 0.08225262f, 0.02876210f, 0.04673817f, -0.01760573f, 
    -0.07751648f, -0.04238503f, -0.06189251f, 0.09853663f, 0.08718648f, -0.07315077f, 0.06540011f, 0.00749290f, 
    0.17921700f, -0.34275508f, -0.05752724f, 0.17835391f, -0.27386051f, -0.25466087f, 0.07825085f, -0.05949695f, 
    0.05332411f, 0.00259023f, 0.07670778f, 0.04531484f, 0.08395416f, 0.07004236f, 0.00139859f, -0.07316328f, 
    0.04482884f, 0.03897025f, 0.06851980f, 0.10038366f, 0.16753097f, 0.17546219f, 0.28836504f, 0.14619108f, 
    0.00428429f, 0.11143592f, -0.10572400f, -0.23614821f, -0.07240762f, -0.14225139f, -0.01654248f, 0.13812305f, 
    0.03983735f, 0.21466492f, 0.09207243f, 0.04951507f, -0.01156163f, -0.03307465f, -0.05126317f, 0.05162454f, 
    -0.20161375f, -0.02981654f, 0.02143178f, 0.13990413f, 0.12134060f, -0.02162964f, -0.16415349f, 0.09142044f, 
    -0.01946833f, 0.04236633f, 0.02287912f, 0.10153166f, 0.01968577f, 0.09999079f, -0.23652107f, 0.14572239f, 
    -0.06735968f, 0.07292511f, 0.02479915f, 0.09632329f, -0.47688642f, 0.12482009f, -0.84010220f, -0.02511733f, 
    -0.26218456f, -0.01810670f, -0.22646327f, 0.18529771f, -0.16183494f, 0.21863917f, 0.04123191f, 0.04738950f, 
    0.03820682f, 0.03687454f, -0.14448710f, 0.06077813f, 0.05915139f, 0.08957569f, 0.20036012f, 0.10409848f, 
    -0.47268507f, -0.42108753f, -0.09343220f, 0.14088954f, 0.35987744f, -0.33949599f, 0.28830418f, -0.32111681f, 
    -0.14199126f, 0.07512572f, -0.11223423f, 0.01437619f, 0.06667425f, -0.06626835f, 0.06328838f, 0.18425502f, 
    0.15275525f, -0.07796444f, -0.17264171f, 0.03144749f, -0.33635646f, 0.00257420f, -0.21156722f, 0.13532907f, 
    -0.00904563f, 0.15708435f, 0.14052552f, -0.11864796f, 0.13264033f, -0.37602484f, -0.09970792f, 0.08450053f, 
    -0.10842431f, -0.12108978f, -0.02320434f, -0.11460236f, -0.15519635f, -0.13686796f, -0.12007979f, 0.01024454f, 
    -1.50073838f, -0.08728017f, -0.52656323f, 0.37145635f, -0.55524927f, 0.29432821f, -0.29838383f, -0.19065723f, 
    -0.52522051f, -0.14526413f, 0.01493229f, -0.02660341f, 0.00999121f, -0.11055429f, 0.03899894f, -0.08343122f, 
    -0.08245252f, -0.07044601f, 0.06102266f, 0.13262151f, 0.11436325f, -0.60895199f, -0.44991744f, -0.32161626f, 
    -0.12727791f, 0.09016443f, -0.11546960f, 0.06074839f, 0.03385735f, 0.09482506f, -0.11133041f, 0.07355794f, 
    -0.07749853f, -0.02187826f, 0.05415477f, 0.04750867f, 0.23084126f, 0.31977782f, -0.02309353f, 0.37014985f, 
    0.14985916f, 0.08136009f, -0.14708653f, 0.18339881f, -0.08128808f, -0.03668387f, 0.17001712f, -0.00008466f, 
    0.03406095f, -0.02951606f, 0.10491832f, -0.07324658f, -0.04860419f, -0.18533644f, -0.01992896f, 0.05682130f, 
    -0.08366217f, -0.13995770f, -0.14998960f, -0.18269651f, 0.01713448f, 0.14806317f, 0.27932563f, 0.67979872f, 
    -0.74860936f, 0.13303386f, -0.09320556f, -0.23967649f, 0.02924920f, -0.13208716f, 0.01144495f, 0.00856837f, 
    0.04726034f, 0.02828037f, 0.11867060f, 0.07156258f, 0.07119920f, 0.04917754f, 0.01877599f, 0.18875881f, 
    0.05658592f, -0.16626783f, 0.39670464f, -0.44699240f, -0.19888857f, -0.01202455f, -0.34579828f, 0.00712613f, 
    0.12987955f, -0.18919747f, -0.19416805f, 0.09355308f, 0.00613650f, 0.01277281f, 0.07523905f, 0.11274573f, 
    0.01226175f, 0.11872508f, -0.07898644f, 0.09765445f, 0.20712656f, -0.19560657f, 0.12756193f, 0.33737946f, 
    -0.92897159f, -0.13316406f, -0.00459751f, -0.15124115f, 0.24252911f, 0.04406520f, 0.00846501f, -0.03797691f, 
    0.01398426f, 0.08956730f, -0.10617214f, 0.07250886f, 0.07805632f, 0.00952696f, 0.03869504f, 0.12247141f, 
    -0.25772181f, 0.00746896f, 0.05621577f, 0.20127466f, -0.11442711f, 0.05980648f, -0.21154174f, -0.05399446f, 
    0.06482363f, 0.17638221f, 0.01706315f, 0.06546549f, 0.04558761f, 0.06801250f, -0.02357821f, 0.01338486f, 
    0.07324538f, 0.19566447f, 0.20823693f, 0.22870763f, -0.12810166f, -0.10242552f, -0.52229142f, -0.05267315f, 
    0.16029543f, 0.13740394f, 0.05918472f, 0.19248411f, 0.10455079f, 0.02230795f, 0.00513400f, -0.05357529f, 
    -0.00483070f, 0.01414850f, -0.02790505f, 0.01541187f, 0.09542677f, 0.02538218f, 0.06146048f, 0.09266490f, 
    0.31590483f, -0.63670272f, 0.13307570f, -0.42985377f, -0.06379582f, -0.27710420f, -0.08643062f, 0.04199376f, 
    0.07039118f, 0.20057775f, -0.11074317f, -0.01415368f, -0.03468528f, -0.03234827f, -0.03018118f, -0.03754196f, 
    0.03015816f, 0.18294756f, -0.16299316f, -0.19818161f, -0.20154846f, 0.04193038f, -0.11390656f, -0.26926538f, 
    0.07382213f, 0.11582334f, -0.00279684f, 0.02114698f, 0.01063754f, -0.12912484f, 0.13915716f, -0.10577704f, 
    -0.07399174f, -0.14132319f, 0.00984513f, 0.16579899f, -0.08790758f, -0.15272655f, 0.06407794f, 0.04773830f, 
    -0.20520961f, 0.20803331f, -0.00855156f, 0.23363461f, -0.20520987f, -0.13031104f, -0.05744249f, -0.46248195f, 
    -0.01066127f, -0.13996878f, 0.16545977f, -0.00735909f, 0.05675858f, 0.18096238f, 0.04264858f, 0.06875154f, 
    0.04994161f, 0.05239290f, 0.01694984f, 0.01194060f, -0.00861313f, -0.05152478f, 0.02454654f, -0.28075725f, 
    0.10039532f, 0.03634097f, 0.01410201f, 0.08740958f, 0.06509620f, 0.06379250f, -0.07547645f, 0.04341494f, 
    -0.03212989f, -0.00019731f, 0.00241895f, 0.14212607f, 0.22626626f, 0.06244723f, -0.00857739f, 0.12419055f, 
    -0.01592831f, 0.37662685f, -0.39976668f, 0.16909832f, 0.12906310f, 0.00336532f, -0.05779092f, -0.16859297f, 
    -0.21219511f, 0.02427058f, -0.22371507f, 0.03429252f, -0.16666251f, -0.10209191f, -0.13215463f, 0.02358117f, 
    -0.03479224f, -0.10430697f, -0.00542374f, 0.18555993f, -0.19235168f, 0.13262443f, -0.16858903f, 0.23755190f, 
    0.31705973f, 0.01304615f, 0.10548875f, 0.05329238f, -0.18680890f, 0.12177213f, -0.11159417f, 0.02407482f, 
    0.06680357f, -0.03601382f, -0.00798164f, 0.14312626f, 0.08937366f, -0.29009989f, 0.10269931f, 0.26033697f, 
    -0.03877886f, -0.05065983f, -0.15422249f, 0.03288766f, 0.06730541f, -0.01153402f, -0.03102247f, 0.13681330f, 
    -0.09245229f, -0.12370629f, -0.14367044f, 0.05303210f, -0.03721288f, 0.03345468f, 0.02508475f, -0.00674516f, 
    -0.11719961f, -0.01923762f, -0.15937012f, -0.02031863f, -0.54775846f, -0.42883313f, -0.19384161f, 0.03721197f, 
    -0.09479111f, 0.11459181f, -0.08656970f, -0.03195871f, 0.33304411f, 0.02157172f, -0.24840111f, -0.10828175f, 
    0.04643580f, -0.00424110f, -0.03270311f, 0.18936455f, -0.03182740f, -0.01382019f, 0.27733415f, 0.16857742f, 
    -0.29850617f, -0.06991758f, -0.16884075f, 0.18496789f, 0.00787399f, -0.10725590f, 0.09003008f, -0.07516710f, 
    0.00453330f, -0.08008293f, 0.04392454f, -0.12513767f, 0.02761884f, 0.01896722f, 0.07983050f, 0.04595564f, 
    0.01963814f, 0.00855312f, 0.08883208f, 0.26255560f, -0.19068497f, -0.04416168f, 0.09355994f, 0.05106577f, 
    0.00639661f, -0.05254439f, -0.01732889f, -0.12314986f, 0.19165406f, -0.04635647f, -0.00092786f, -0.11951234f, 
    0.01948766f, 0.03801237f, 0.09288561f, 0.07623256f, 0.01157957f, -0.07697851f, 0.17084372f, 0.05259622f, 
    -0.26603261f, -0.00721883f, 0.33676651f, 0.19972147f, -0.01591063f, -0.10815293f, 0.12506838f, -0.18270621f, 
    0.18461166f, 0.06808001f, -0.19555269f, -0.04307800f, -0.06990159f, 0.01961301f, 0.14857152f, -0.05318133f, 
    0.30956069f, 0.12929903f, 0.21189718f, 0.12805896f, -0.29087830f, 0.04883100f, 0.07310388f, 0.09166975f, 
    0.01025342f, 0.01902950f, 0.07164342f, -0.07382784f, 0.10595429f, 0.02617441f, 0.07148924f, -0.01318411f, 
    -0.00393091f, 0.09216114f, 0.02945333f, 0.03419049f, 0.13182437f, -0.12190008f, 0.14173256f, 0.00703472f, 
    -0.27143785f, -0.10900678f, 0.01660122f, 0.11763810f, -0.06085748f, -0.11328417f, 0.11551475f, -0.09849030f, 
    0.16327846f, -0.01337311f, -0.12187628f, -0.09111493f, 0.13760675f, -0.02721940f, 0.05433046f, 0.00757951f, 
    -0.00352021f, 0.00806385f, 0.22136629f, 0.28843603f, -0.06126685f, -0.28878391f, -0.26342759f, 0.26219299f, 
    -0.11466836f, -0.09416823f, -0.13294390f, 0.08933311f, -0.00550026f, -0.00881176f, -0.05792762f, 0.03045365f, 
    0.00304488f, -0.02625593f, -0.02607460f, 0.00961689f, -0.09403005f, 0.00647904f, 0.08654695f, 0.11308857f, 
    0.03946648f, -0.41539773f, -0.02808424f, -0.32765347f, -0.17195608f, -0.07898197f, -0.28929281f, 0.03549819f, 
    -0.11250437f, -0.08699007f, -0.12076604f, 0.01771764f, 0.02072033f, 0.02571365f, 0.06202156f, 0.09358457f, 
    -0.02836060f, 0.05147332f, -0.10338464f, -0.02855844f, -0.05446885f, -0.12158026f, -0.10678013f, 0.12670775f, 
    -0.22604769f, 0.01937696f, 0.09266250f, 0.24891590f, -0.01643268f, -0.14273709f, -0.00373547f, 0.04666510f, 
    0.09108789f, 0.11633767f, 0.00851833f, -0.13188080f, -0.06634075f, 0.07065871f, -0.04025567f, 0.01241113f, 
    -0.64692354f, -0.18867317f, 0.11126418f, 0.13083071f, 0.27514389f, -0.13371676f, -0.15513149f, -0.23928113f, 
    0.00740692f, -0.10940465f, -0.08554623f, 0.16907464f, 0.00971019f, 0.13670956f, 0.11062741f, 0.11116866f, 
    -0.10687056f, -0.19621225f, 0.19281751f, 0.18869580f, 0.10123020f, -0.35954401f, -0.09569689f, -0.32511923f, 
    -0.15958974f, -0.01814449f, -0.21135971f, 0.07963563f, -0.15450329f, -0.10067511f, -0.16130868f, 0.07936473f, 
    0.11437503f, 0.00101322f, 0.09155432f, 0.06749239f, -0.07639969f, 0.09406384f, -0.14407973f, 0.02119117f, 
    -0.23770732f, -0.02982589f, -0.84840268f, 0.14678107f, 0.04709834f, -0.02863017f, 0.03543067f, 0.02331280f, 
    -0.16349880f, 0.04739665f, -0.03321723f, 0.09935614f, -0.08705091f, -0.00116109f, 0.00841412f, -0.03552118f, 
    -0.07798211f, -0.14869766f, -0.03445510f, -0.07366770f, 0.19964847f, -0.04520406f, 0.10259327f, -0.06868588f, 
    -0.02495876f, 0.01909480f, -0.03947815f, -0.11897134f, -0.00090526f, -0.01187742f, -0.05986476f, -0.04482582f, 
    -0.10147609f, -0.03980526f, -0.10077845f, -0.05703816f, -0.02883662f, 0.03770910f, 0.02221069f, 0.00643761f, 
    0.03617771f, -0.63032335f, -0.00968667f, -0.08288628f, -0.46319422f, -0.10083868f, -0.26534843f, 0.08903216f, 
    -0.24733903f, -0.07281750f, 0.01080538f, 0.13530773f, -0.10400402f, -0.06077909f, -0.12631389f, 0.21442702f, 
    -0.09139396f, 0.00422376f, -0.01917973f, -0.28955305f, -0.28845736f, -0.15434079f, 0.01643765f, -0.10466379f, 
    0.08538831f, -0.04678180f, 0.00469085f, 0.19468240f, -0.02780814f, -0.06006339f, -0.00834886f, 0.11726650f, 
    0.09327989f, -0.00247270f, -0.00143021f, 0.11426839f, -0.12144423f, -0.17772584f, -0.20237750f, -0.26735333f, 
    0.33409327f, -0.09753275f, 0.47267252f, 0.07207776f, -0.10695545f, 0.07701025f, -0.17997192f, 0.08782665f, 
    -0.02573118f, -0.08383099f, 0.00630779f, 0.07953054f, 0.05726321f, 0.10371892f, 0.14729871f, -0.05530873f, 
    0.01082795f, 0.01004298f, -0.02240463f, 0.03372635f, -0.11749620f, -0.34666243f, 0.41755047f, -0.14711706f, 
    -0.12803449f, -0.01648100f, -0.13809749f, 0.13918377f, 0.20661384f, 0.04474686f, -0.09536243f, 0.04883585f, 
    -0.12506369f, 0.19025713f, -0.08252999f, 0.01428763f, 0.12214097f, 0.14460567f, 0.12690210f, -0.01972684f, 
    0.38869074f, -0.55415535f, 0.30883133f, -0.16849194f, -0.01824658f, -0.13003722f, 0.17694606f, 0.31806153f, 
    0.33074036f, 0.01014551f, -0.16063866f, -0.03988294f, -0.28803760f, 0.05211154f, 0.03978920f, 0.03782337f, 
    0.16086583f, 0.14635605f, 0.12073465f, -0.08888158f, -0.10130341f, -0.07766260f, -0.42611286f, 0.12392698f, 
    -0.23083234f, -0.11615833f, 0.08009527f, 0.24946003f, -0.18597931f, -0.09116825f, 0.11713452f, 0.06031432f, 
    -0.16950953f, 0.17024863f, -0.07053453f, -0.13340169f, -0.28115878f, -0.20073104f, -0.57002115f, -0.17333969f, 
    -0.59294474f, -0.15321364f, 0.02115545f, -0.19429803f, -0.03948700f, -0.02360104f, 0.02714808f, 0.17221981f, 
    0.11820744f, 0.11180454f, -0.00170356f, 0.07126920f, 0.04478182f, 0.18828098f, 0.00018290f, 0.05451708f, 
    0.13590376f, 0.12641416f, 0.28832057f, 0.34228250f, -0.02411755f, -0.07460777f, 0.09807419f, -0.03495206f, 
    -0.02574371f, -0.02273540f, -0.02380233f, -0.02321376f, 0.13634276f, 0.08543646f, 0.00687325f, 0.03363006f, 
    -0.15995665f, -0.08306755f, -0.28780696f, -0.04407438f, -0.17353326f, 0.07685044f, -0.13823619f, -0.08866373f, 
    -0.15754639f, 0.37732974f, 0.11545151f, 0.02681203f, 0.00387572f, 0.10108467f, -0.03843974f, -0.08919431f, 
    0.00496174f, 0.01776309f, -0.05093582f, -0.04367871f, -0.08115231f, -0.01502685f, -0.09320334f, -0.16721730f, 
    -0.04406271f, -0.01136964f, 0.03934522f, -0.04309685f, -0.25645170f, 0.17672893f, -0.09949896f, 0.20819020f, 
    0.12828197f, 0.06189170f, -0.12240720f, 0.01034549f, -0.03989001f, -0.04327238f, -0.03365311f, 0.06764705f, 
    -0.09128957f, -0.04880321f, -0.18120898f, 0.05185270f, -0.06645538f, 0.01306347f, -0.15097716f, -0.08195514f, 
    -0.32621911f, -0.09323602f, -0.60189402f, -0.04220576f, -0.01385422f, 0.03033087f, 0.00200562f, -0.06709278f, 
    -0.03962356f, -0.07937738f, -0.00741801f, 0.09591904f, 0.00193794f, 0.02269437f, -0.00332754f, 0.11390340f, 
    -0.13189998f, -0.11028014f, -0.05923901f, -0.12493444f, -0.02649307f, -0.12400825f, 0.02481568f, 0.00414804f, 
    0.07814012f, -0.04070092f, 0.08567139f, -0.00213861f, -0.13574336f, -0.15719602f, -0.12109830f, -0.02485644f, 
    -0.07201581f, 0.07915358f, 0.02967536f, 0.07108403f, -0.16536745f, -0.15789640f, -0.30151597f, -0.21912609f, 
    -0.29031187f, 0.40139940f, -0.56586111f, 0.31374493f, 0.18655732f, 0.04004956f, -0.07071738f, -0.02638327f, 
    0.32356432f, 0.22556007f, -0.02679471f, -0.06969291f, -0.13066573f, -0.02745438f, 0.07517762f, -0.16293746f, 
    0.11340860f, -0.62011701f, 0.05183120f, 0.10959826f, -0.24390653f, -0.18615952f, 0.27179965f, -0.07433864f, 
    0.00914355f, -0.01390094f, -0.03541986f, -0.33164334f, 0.04529032f, 0.09089445f, -0.07143018f, -0.05462055f, 
    0.08659346f, -0.17498808f, -0.05267585f, -0.08961239f, 0.16679671f, 0.02115150f, 0.12084087f, 0.05300820f, 
    0.17960143f, 0.32013440f, -0.05447541f, 0.02694313f, 0.05861443f, 0.06568101f, -0.01149307f, -0.13008372f, 
    0.08526024f, -0.05333296f, -0.17274813f, 0.10824443f, -0.03137776f, -0.17016418f, -0.21760951f, -0.03731078f, 
    0.01667841f, -0.10251969f, 0.05201054f, -0.07670485f, 0.05618533f, -0.02621732f, 0.24265790f, 0.14287083f, 
    -0.10269573f, 0.00232815f, 0.05860256f, 0.10084710f, -0.12259784f, -0.04461697f, -0.00255969f, 0.01238587f, 
    -0.03332531f, 0.17532010f, -0.11314998f, -0.01589919f, 0.05814835f, 0.15040573f, -0.17254964f, -0.12622119f, 
    -0.59379083f, -0.12273850f, -0.42849857f, 0.35039565f, -0.23659059f, 0.01699558f, -0.00481220f, 0.12808010f, 
    0.03860769f, 0.15500583f, -0.11199705f, -0.02125180f, 0.02771344f, -0.05108899f, -0.14706494f, 0.02946166f, 
    -0.07578479f, -0.05516696f, -0.16035332f, -0.10285794f, -0.11022430f, -0.27714828f, -0.07118680f, 0.48336652f, 
    -0.28856793f, -0.11346453f, -0.31845263f, 0.05318297f, -0.04147444f, 0.13906668f, -0.05340161f, -0.16486406f, 
    -0.07012429f, -0.13490054f, -0.14376771f, -0.02509605f, -0.07156830f, -0.04129969f, 0.03114500f, -0.24118927f, 
    0.60399085f, -0.02773216f, 0.33519554f, 0.20607567f, -0.13495544f, -0.09578671f, -0.00033275f, -0.26576927f, 
    0.12501474f, -0.07543254f, -0.16683061f, 0.00881513f, 0.03731386f, -0.01497768f, -0.03003615f, -0.02863275f, 
    0.14296377f, 0.00169165f, 0.16091016f, 0.08127235f, 0.48690212f, 0.21732458f, 0.51357335f, 0.27169588f, 
    -0.15124652f, -0.07708560f, -0.02510639f, -0.14501141f, 0.21231243f, -0.14789174f, -0.16084988f, 0.08700520f, 
    -0.00297703f, 0.05941045f, 0.07183553f, -0.10771362f, -0.06437597f, 0.03814987f, 0.07844303f, -0.01105869f, 
    -0.00877428f, -0.57267970f, 0.02899011f, 0.00870881f, 0.12992780f, -0.06671519f, -0.04830522f, 0.07691592f, 
    -0.00459496f, -0.19695002f, 0.07095826f, -0.00030629f, -0.09557064f, -0.11300470f, 0.13174103f, -0.09612965f, 
    -0.01017248f, 0.02117917f, 0.02419570f, -0.11877320f, 0.15428858f, -0.04338244f, 0.18998633f, -0.01160434f, 
    -0.07936710f, -0.07438476f, 0.13824876f, -0.03470768f, 0.17107637f, -0.09750395f, -0.03697124f, -0.06721715f, 
    0.06420971f, -0.04028896f, 0.14155909f, -0.01609962f, 0.02713617f, -0.02236028f, -0.17327119f, -0.07098272f, 
    0.24003935f, 0.41185915f, -0.18552659f, 0.15027425f, 0.14657542f, 0.00293327f, 0.02961091f, 0.04980922f, 
    0.18140955f, 0.07151378f, -0.05496292f, 0.01863013f, 0.00156149f, -0.03598526f, -0.06568280f, -0.00770160f, 
    -0.07142338f, 0.09298865f, -0.01331319f, -0.07400023f, 0.10508646f, -0.02583095f, 0.00693590f, 0.17582066f, 
    0.05830864f, 0.07433178f, -0.11175351f, -0.12248787f, 0.02608858f, -0.04014662f, -0.01871291f, 0.07258326f, 
    0.05969273f, -0.11355242f, 0.04444201f, 0.05773742f, -0.09837320f, 0.09968106f, -0.16874802f, 0.04359871f, 
    -0.02550432f, 0.05608615f, -0.08237370f, 0.09985618f, -0.09424248f, -0.13664156f, 0.06106460f, 0.05688719f, 
    0.12347225f, -0.07229952f, -0.02584010f, -0.06864763f, 0.05272324f, -0.06887093f, 0.01556832f, 0.01071444f, 
    -0.03855637f, -0.10756376f, -0.17863348f, -0.04221859f, 0.40842730f, 0.16393754f, 0.32951707f, 0.00857039f, 
    -0.38237110f, -0.08544082f, -0.01142192f, -0.08750668f, 0.01858086f, -0.00741544f, -0.12753130f, 0.05167166f, 
    -0.01595648f, 0.01502518f, -0.04656180f, -0.04695718f, 0.11008003f, 0.12516235f, 0.09272062f, 0.02213746f, 
    0.32050690f, 0.03468422f, 0.20372353f, -0.09202839f, -0.10051511f, -0.10540114f, 0.02881252f, -0.21167646f, 
    0.12706244f, 0.08558016f, -0.11424375f, -0.01553548f, 0.01133422f, -0.11743548f, -0.11140024f, 0.05080425f, 
    0.09424184f, -0.03233478f, -0.13239542f, 0.11547938f, 0.35775816f, -0.43575576f, 0.06804173f, 0.39720759f, 
    0.11727584f, -0.01878068f, 0.19442509f, -0.18454707f, 0.32623357f, -0.00398504f, -0.24057172f, -0.00003558f, 
    -0.05806563f, 0.07998431f, -0.04317876f, -0.03444441f, -0.00974327f, 0.05906678f, 0.11758559f, 0.01455628f, 
    0.32512873f, -0.55277109f, 0.04271359f, -0.27762276f, -0.03603131f, -0.05893472f, -0.55292219f, -0.23949943f, 
    -0.23433320f, -0.05893823f, 0.03682328f, 0.00367834f, 0.07076020f, 0.02335507f, -0.12648356f, 0.02629616f, 
    -0.02205335f, -0.00713519f, 0.00109682f, -0.19633053f, 0.24110743f, 0.15546449f, 0.27739182f, 0.02520281f, 
    -0.15043682f, -0.17005952f, 0.01355251f, -0.22516082f, 0.09703117f, 0.07256406f, -0.18596385f, -0.00653366f, 
    -0.05591108f, -0.01423823f, -0.03981806f, 0.04208485f, 0.02735846f, -0.04537307f, -0.14005914f, 0.09734761f, 
    -0.13616553f, -0.20220429f, -0.05902334f, 0.03313991f, -0.11527018f, -0.04619925f, -0.01962430f, 0.02951061f, 
    -0.06911911f, -0.05337482f, -0.01479114f, 0.04695696f, 0.09294185f, -0.04243017f, -0.08455200f, 0.13944735f, 
    0.05306581f, 0.07347473f, 0.04758692f, 0.08041958f, -0.45911640f, 0.00656294f, -0.29412502f, 0.07394072f, 
    -0.10645303f, 0.00349523f, 0.10839327f, -0.01527570f, 0.07414493f, 0.05149543f, -0.06999699f, 0.01749195f, 
    0.07073390f, 0.02154538f, -0.00751659f, -0.04508170f, -0.04472958f, -0.04748055f, -0.12624139f, 0.02331048f, 
    -0.01472170f, -0.36293542f, -0.06122862f, -0.31655148f, 0.00726523f, 0.03986993f, 0.15799637f, -0.03127377f, 
    0.11649561f, 0.02632810f, -0.13496539f, -0.00333869f, 0.02950250f, -0.18348010f, -0.07670808f, 0.02264042f, 
    0.03968393f, -0.06483156f, -0.18432765f, -0.17871886f, 0.08557627f, -0.19876230f, -0.22011599f, -0.22385365f, 
    0.24673136f, -0.23835365f, -0.37200224f, 0.06078356f, -0.18333229f, -0.15310679f, 0.03624918f, 0.06907523f, 
    0.03429535f, 0.03395172f, -0.04761076f, 0.01892988f, -0.04084436f, -0.11944898f, 0.03390643f, 0.16858850f, 
    -0.68272471f, 0.11096576f, -0.21101399f, 0.06134975f, 0.12909278f, -0.05566058f, 0.09517219f, 0.32461047f, 
    -0.35867330f, 0.19812225f, -0.16352779f, 0.09986360f, -0.08184776f, 0.13973373f, 0.12842345f, 0.18468729f, 
    0.00068694f, 0.23222412f, 0.06253765f, -0.18086325f, -0.05305272f, 0.05555552f, -0.06789268f, 0.12406141f, 
    0.28995475f, 0.13556077f, 0.16186365f, 0.18597418f, -0.05454334f, -0.02160485f, -0.09712368f, -0.03162208f, 
    -0.01481080f, -0.07898569f, -0.12080257f, 0.10099950f, -0.01281895f, -0.06101770f, 0.03937710f, -0.05543403f, 
    0.12250789f, -0.44611055f, 0.57280374f, -0.65057760f, 0.27313015f, 0.14329508f, 0.23573120f, -0.41501975f, 
    0.27003512f, -0.03742657f, -0.05898030f, 0.11935784f, -0.03240769f, 0.10406678f, 0.03425923f, 0.06310818f, 
    0.15703692f, 0.01008015f, 0.00993395f, 0.00843395f, -0.12971568f, -0.18715531f, -0.29845271f, -0.02257643f, 
    0.24566814f, 0.01170422f, 0.13096330f, 0.00463360f, 0.04755210f, -0.07626075f, -0.08136057f, 0.03814681f, 
    0.03433549f, 0.00831601f, 0.06937436f, 0.18353938f, -0.22082783f, 0.01505086f, 0.16950922f, 0.00405295f, 
    -0.14651388f, 0.22320326f, -0.07961521f, 0.27996185f, -0.20068461f, -0.10086598f, -0.19057235f, 0.19822767f, 
    -0.27175948f, -0.14334074f, -0.05749797f, 0.09441614f, -0.05813174f, 0.02972518f, -0.07834843f, 0.08789445f, 
    -0.36203545f, -0.10725574f, -0.13210653f, -0.12589152f, 0.00903106f, -0.28423738f, 0.34688103f, -0.28825781f, 
    -0.32231948f, 0.11884458f, 0.07704745f, -0.17561038f, -0.10988625f, -0.03954457f, -0.05287379f, -0.00700646f, 
    0.15376115f, 0.15298198f, 0.02271989f, -0.05424273f, 0.06334697f, 0.08264240f, 0.17272131f, 0.09031632f, 
    -0.61890817f, 0.01511701f, -0.65893734f, 0.53309834f, 0.07374644f, 0.02965176f, 0.29532307f, -0.00828844f, 
    0.30157614f, 0.01264606f, -0.23202968f, -0.11330089f, -0.08745319f, 0.09878694f, 0.07110050f, -0.00146967f, 
    -0.04578327f, 0.17992030f, -0.03808692f, 0.21756862f, -0.32666972f, 0.08727443f, -0.26487005f, 0.28879836f, 
    -0.49432132f, 0.12141573f, 0.17283654f, -0.03163121f, -0.08872030f, 0.02852925f, -0.05136060f, 0.09409632f, 
    0.11173122f, 0.06343628f, 0.02393501f, 0.05309933f, 0.09962529f, 0.06741347f, 0.07545971f, 0.13128544f, 
    0.21231857f, -0.32047611f, -0.43191308f, -0.33313635f, -0.05279899f, -0.15371738f, -0.21343334f, 0.03076109f, 
    -0.08593970f, -0.18678220f, 0.05174534f, 0.02849706f, 0.03235538f, -0.09444124f, -0.07072397f, 0.08397466f, 
    -0.08372256f, -0.07717162f, 0.07249197f, -0.06702188f, 0.47123638f, -0.26151213f, -0.01025776f, 0.13022473f, 
    0.13485618f, 0.02419288f, 0.02945283f, -0.15555595f, 0.01027677f, -0.20354103f, -0.05836322f, -0.03053594f, 
    0.00052241f, -0.03124942f, -0.00102379f, 0.12400831f, -0.07159261f, 0.00008722f, -0.04943660f, 0.03542038f, 
    -1.04465723f, -0.29112706f, 0.13482454f, 0.49140564f, -0.15061072f, -0.02678795f, -0.00276292f, 0.05921547f, 
    0.06145942f, -0.00353240f, -0.09942178f, 0.05061001f, 0.04267355f, -0.05812721f, 0.02738561f, 0.14727576f, 
    0.11635979f, 0.29715449f, 0.10600217f, -0.15024386f, 0.15273969f, -0.11344474f, -0.16462964f, 0.32866558f, 
    0.12831129f, -0.06878083f, 0.29399526f, -0.06594940f, 0.18519388f, -0.00698260f, -0.21070431f, 0.04276653f, 
    0.09560043f, -0.04733412f, 0.05209268f, -0.03818932f, -0.04845598f, 0.22370538f, -0.29028815f, -0.06754917f, 
    -0.59128857f, 0.02695691f, -0.31701946f, 0.16387822f, -0.60888052f, 0.05676721f, -0.03659346f, -0.01150041f, 
    -0.15315369f, 0.08544548f, -0.12083364f, -0.16225111f, -0.05593009f, 0.00905467f, 0.06217105f, 0.04672644f, 
    -0.03507375f, -0.02549674f, 0.04160016f, 0.07253497f, -0.03090241f, -0.04777101f, -0.23839267f, 0.13659215f, 
    0.31312656f, -0.08189286f, 0.20609447f, -0.11496811f, 0.05661348f, 0.00536218f, -0.14004041f, 0.03482016f, 
    -0.00976334f, 0.10335543f, 0.08761199f, 0.08932847f, 0.00138412f, 0.00034722f, -0.09499938f, 0.00192719f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17032458f, 0.12827103f, 0.03032806f, -0.09890065f, -0.07030736f, 0.04890336f, 0.02484659f, -0.08315543f, 
    0.07999557f, 0.07638571f, 0.00171516f, 0.01024772f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
