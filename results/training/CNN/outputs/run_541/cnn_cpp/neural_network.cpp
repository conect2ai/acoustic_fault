#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.61483997f, -0.63604176f, -0.02840229f, -1.04043126f, -1.12135577f, -0.97702670f, -0.06306472f, -0.08672883f, 
    0.09968202f, -0.88434279f, -0.98721611f, -1.04777086f, -0.55697387f, -0.77506322f, -0.18020822f, -0.15278058f, 
    0.02892356f, -0.22768441f, -1.22814989f, 0.54086208f, 0.78612316f, 0.27135992f, 0.45422065f, -0.55423009f, 
    0.35843512f, 0.53609139f, -0.18884180f, -0.26901543f, 0.80232835f, 0.22497863f, -0.57234520f, -0.60255086f, 
    -1.67449093f, -0.33102208f, 0.29241070f, 0.13614272f, -1.03315771f, 0.62242639f, -0.23195563f, 1.02441025f, 
    1.34502554f, 0.07773332f, 0.04954215f, -0.24325718f, 0.14463957f, 1.12221694f, 1.12304842f, -0.90657008f, 
    0.24310777f, -0.53646475f, 0.16293857f, 0.37142962f, 0.05145594f, -0.00989329f, -1.20820582f, 0.65445447f, 
    0.69178617f, 0.30970034f, -0.73910367f, 0.36344653f, 0.33260807f, -0.43919921f, 0.36280784f, 1.01564598f, 
    0.75960886f, 0.93845069f, 0.49462017f, -0.76713616f, 0.81082028f, 0.25157881f, 0.36126816f, 0.12857775f, 
    1.01709139f, 1.08355188f, 1.12367427f, -0.79679126f, 0.65204632f, -0.58672971f, -0.32850012f, -0.12020207f, 
    -0.23265004f, -0.87233275f, 0.97740036f, 0.29871938f, -0.03991173f, 0.54836679f, 0.85715175f, -0.46811634f, 
    0.35554874f, 0.12366799f, -0.13485014f, -0.42448920f, -0.31129619f, 0.61967129f, -0.91093898f, 0.30366436f, 
    -0.05471084f, 0.34730178f, 0.95038068f, -1.41972125f, 0.75724590f, -0.75340480f, 0.10595157f, -0.43226722f, 
    -0.78592539f, 0.01026254f, -0.03059237f, -0.12945823f, -0.84100759f, -0.73721772f, -0.64150178f, 1.03395498f, 
    0.74844104f, 0.02782098f, 0.80282545f, -0.06943599f, 0.22152750f, -0.61259574f, -1.09334707f, -1.27797210f, 
    -0.11279653f, 0.78212029f, 0.92353201f, -0.21495135f, -0.36068645f, -0.38615254f, 1.18134892f, 0.76752508f, 
    0.87947375f, 0.62191713f, 0.69942838f, 0.71146810f, -0.30028889f, -0.03309977f, -0.17608622f, 1.15617311f, 
    -1.26915491f, -0.56766367f, 0.48043400f, -0.71009648f, -0.32944852f, -0.12448269f, -0.10983297f, 0.00138655f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18427749f, -0.84029967f, -0.10875330f, 0.54804754f, -0.10645048f, -0.00970023f, 0.17465669f, 0.60259676f, 
    0.20422557f, -0.44670334f, -0.05944879f, 0.49956700f, 0.56598532f, 0.05224190f, 0.73795772f, 0.49709332f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.02238155f, 0.02923318f, -0.08856949f, 0.00408165f, -0.07986077f, -0.04318397f, 0.05912528f, -0.08406463f, 
    0.00740455f, -0.04318240f, 0.05961887f, -0.07289816f, 0.04369823f, -0.02825344f, 0.05279092f, 0.04334395f, 
    0.02641557f, -0.05233847f, -0.02115120f, 0.03736925f, 0.01762415f, -0.01121575f, 0.07127956f, -0.00606363f, 
    -0.09404957f, -0.07957605f, 0.04912051f, 0.00280568f, -0.02395733f, 0.06637552f, -0.02531682f, 0.03305232f, 
    0.01449838f, 0.00678986f, -0.00658943f, -0.00139546f, 0.07576951f, 0.00396328f, -0.06074353f, -0.03387493f, 
    -0.03098324f, 0.04816792f, -0.03975713f, 0.01836230f, -0.08109682f, -0.05802304f, 0.04297946f, -0.00259963f, 
    -0.07434399f, -0.01568546f, 0.04745023f, -0.06520887f, -0.09485788f, -0.00294998f, 0.03868885f, 0.03245026f, 
    0.01356155f, 0.03240881f, -0.05698092f, 0.04599356f, -0.02838901f, 0.05713138f, -0.07546696f, -0.02009706f, 
    0.03166449f, 0.03463859f, -0.05105556f, -0.04751835f, -0.05614131f, -0.07058910f, -0.08865780f, 0.04907277f, 
    0.02547482f, -0.02895761f, -0.06880472f, 0.03124067f, -0.08355818f, -0.07583908f, 0.02664529f, -0.00862054f, 
    -0.03721062f, 0.00827767f, 0.07157381f, -0.01324001f, 0.01133490f, -0.00545995f, 0.02250436f, -0.04674830f, 
    -0.02577590f, -0.07748876f, 0.05666026f, -0.07664122f, -0.00693703f, -0.02114196f, 0.02935765f, 0.03471256f, 
    0.02190858f, 0.07579146f, -0.04075224f, -0.05851901f, 0.02336704f, 0.05765939f, 0.01679367f, 0.05453496f, 
    0.03951899f, 0.02326069f, -0.06442894f, 0.07155322f, -0.03353190f, -0.01777161f, 0.01188865f, -0.01299420f, 
    0.05817034f, -0.01720139f, -0.03763587f, -0.05944403f, 0.03525893f, 0.01155231f, -0.08867312f, 0.00684277f, 
    0.02252212f, -0.00887978f, -0.08752511f, -0.02466358f, 0.03740968f, -0.06656756f, 0.02345137f, 0.06937511f, 
    -0.09490889f, 0.06644192f, 0.06279029f, -0.08207623f, -0.09009891f, -0.07349516f, -0.08177219f, -0.09510962f, 
    -0.07058323f, 0.04477318f, -0.00374949f, -0.09558227f, -0.03940710f, -0.00504285f, -0.08924729f, -0.02689269f, 
    0.65000880f, 0.20638806f, 0.49806318f, 0.14507143f, -0.02116151f, 0.00034658f, 0.35322928f, -0.00524180f, 
    0.17799619f, -0.27618164f, -0.03208145f, -0.61704171f, -0.27527806f, 0.16528708f, 0.05810144f, -0.03788919f, 
    0.06971645f, 0.14767861f, 0.49929184f, 0.13978857f, -0.17810328f, -0.04758392f, -0.32157102f, 0.01787107f, 
    0.18476865f, -0.02303436f, 0.03680758f, 0.47312760f, -0.37198380f, 0.12369288f, 0.04025801f, -0.01520872f, 
    -0.04457435f, -0.11080708f, 0.04618540f, 0.11212607f, 0.03869804f, 0.32250106f, 0.15639551f, -0.06391030f, 
    -0.01586249f, -0.09336749f, -0.11094600f, 0.25168338f, -0.03293585f, 0.57623261f, -0.06839567f, 0.04037395f, 
    0.00724957f, 0.06035859f, -0.00765146f, 0.09421502f, 0.03773578f, -0.07406367f, -0.47441185f, 0.16546513f, 
    -0.13030891f, 0.08363431f, 0.00403279f, -0.00990613f, 0.04399396f, -0.06579519f, 0.05620978f, -0.95100009f, 
    -1.28022361f, -0.43072888f, 0.19893236f, 0.21087150f, 0.44489029f, 0.09645043f, -0.03035657f, -0.06473090f, 
    0.65552843f, -0.30217972f, 0.00874279f, 0.29186362f, 0.31037158f, 0.13981518f, 0.04234832f, -0.19862364f, 
    -0.13229163f, -0.51424181f, -0.25846592f, 0.16093630f, -0.04440144f, -0.12556893f, 0.04164330f, -0.05951015f, 
    -0.11650123f, 0.04764596f, 0.70864952f, -0.10654307f, -0.02987847f, 0.13532913f, 0.01987658f, 0.14973055f, 
    0.10644608f, 0.08453562f, 0.11088009f, 0.41948396f, -0.13875084f, -0.07114427f, -0.18029419f, 0.02065277f, 
    -0.12881662f, -0.06055601f, -0.16273880f, -0.06824537f, 0.05224309f, 0.43055630f, 0.03129571f, -0.05674493f, 
    -0.23600036f, 0.15319392f, -0.06463856f, 0.48521408f, 0.22778152f, -0.05516537f, 0.13694343f, -0.01290347f, 
    -0.07024662f, 0.14093223f, -0.37971115f, -0.03562969f, 0.26588103f, -0.03913637f, -0.90621209f, -0.25821313f, 
    -0.28036872f, 0.03172857f, 0.43857938f, 0.14870027f, 0.31797954f, 0.02614805f, 0.08116972f, -0.05104472f, 
    0.01649590f, -0.14819151f, -0.21273693f, -0.02682557f, -0.16227460f, 0.03134236f, -0.11829290f, 0.04250750f, 
    -0.10263950f, 0.15986128f, -0.18682545f, 0.16618662f, 0.13648529f, 0.30230388f, -0.14981692f, 0.04319848f, 
    -0.06192337f, -0.23498480f, -0.11403993f, 0.23067142f, 0.15597139f, -0.14870535f, -0.03160038f, -0.28739521f, 
    0.00718634f, 0.23896144f, 0.19387874f, -0.00020971f, -0.45092100f, -0.37570915f, -0.09145235f, 0.16891573f, 
    0.11218815f, -0.07965408f, 0.04289026f, 0.06923462f, -0.21809709f, -0.50565565f, 0.03941294f, 0.07374790f, 
    -0.02686879f, 0.03361537f, 0.02666158f, 0.19844620f, 0.46352193f, 0.12504385f, -0.11481696f, 0.04645198f, 
    -0.29884389f, 0.00522102f, 0.02001396f, 0.06373826f, -0.02899628f, 0.11510050f, -0.31199735f, -0.38983098f, 
    0.08287262f, -0.24919669f, 0.02561824f, 0.00731739f, 0.11045989f, 0.04388806f, 0.30887204f, 0.47244659f, 
    -0.30817312f, 0.10479844f, -0.02438492f, 0.13469785f, -0.01366073f, -0.16371267f, 0.00961029f, -0.55227047f, 
    0.05684443f, 0.30281031f, 0.36630091f, 0.28281125f, 0.03298118f, 0.03110868f, -0.16563234f, 0.26278073f, 
    -0.08836193f, -0.04899205f, -0.22034445f, 0.18676247f, 0.17751291f, 0.05106088f, -0.11585650f, 0.02682084f, 
    -0.12342549f, 0.30211779f, 0.18544072f, -0.07452383f, -0.22335231f, -0.18112360f, -0.10859460f, -0.20772223f, 
    0.10046145f, 0.13335322f, -0.41608945f, 0.03491902f, -0.12121557f, -0.14496642f, -0.00236503f, -0.04660385f, 
    0.00381430f, -0.03197395f, -0.00209074f, -0.57174057f, -0.74496835f, -0.63975519f, 0.11963389f, 0.00570053f, 
    -0.02019359f, 0.02643661f, 0.08419976f, -0.01104581f, 0.35414270f, 0.29334980f, 0.57134545f, -0.16696216f, 
    0.04396880f, -0.04504108f, 0.14685944f, -0.04117275f, -0.11441406f, 0.31113544f, 0.25375172f, -0.00408297f, 
    -0.03075685f, -0.05077157f, -0.22881727f, 0.12833793f, -0.02377577f, 0.06104376f, -0.22699857f, -0.11902241f, 
    0.04447328f, 0.30089211f, -0.07214084f, -0.15015411f, 0.08945604f, 0.21597421f, 0.29335162f, -0.70227945f, 
    0.24149196f, 0.42901197f, -0.13670871f, 0.02607675f, -0.12156241f, 0.16922921f, 0.08046531f, -0.27765697f, 
    -0.01197701f, -0.05041019f, 0.00292495f, -0.03001472f, -0.01248439f, 0.01978657f, 0.06240180f, -0.04881559f, 
    -0.04905112f, 0.03191296f, 0.04500525f, 0.01214535f, -0.08348824f, -0.00760774f, 0.06288704f, 0.06352516f, 
    -0.04659887f, 0.04010226f, 0.03051508f, 0.01748281f, -0.04493032f, 0.01484418f, -0.07507052f, 0.04138108f, 
    -0.09057654f, -0.04437546f, -0.05195534f, -0.03742650f, -0.04160642f, 0.05742661f, -0.04111525f, 0.05841275f, 
    -0.02035042f, -0.03000830f, 0.06545229f, -0.03272258f, 0.01254553f, -0.02187510f, 0.05653644f, -0.07513949f, 
    -0.03868990f, -0.04428143f, -0.08202806f, -0.07446738f, -0.04611298f, 0.03461948f, -0.02307311f, -0.04301620f, 
    -0.03617256f, -0.07958259f, 0.05029647f, -0.03286598f, -0.03857623f, -0.03383782f, 0.05641441f, 0.06809226f, 
    -0.03346647f, 0.06742772f, 0.07800167f, -0.06313992f, 0.00348616f, -0.07463228f, -0.03547196f, 0.06006548f, 
    -0.00293378f, 0.00141196f, -0.07307976f, -0.00340845f, -0.07207992f, 0.06892084f, -0.05466653f, -0.04445963f, 
    -0.03869857f, 0.01441241f, 0.00979778f, -0.05078909f, -0.01080273f, 0.02505780f, 0.03315467f, 0.01663130f, 
    0.03951493f, -0.08918171f, -0.08947781f, -0.02181776f, -0.07554063f, 0.07222060f, -0.00613894f, 0.02869616f, 
    0.08760668f, 0.02317528f, 0.02507443f, 0.02766763f, 0.02180158f, 0.04256716f, 0.00859252f, -0.07123108f, 
    -0.00816427f, 0.01939842f, 0.06384864f, -0.04583484f, -0.01412346f, -0.06284498f, -0.06695662f, -0.04576572f, 
    -0.04988106f, -0.00817791f, -0.10325988f, -0.07667303f, 0.06076790f, 0.05120341f, -0.07523496f, -0.07484701f, 
    0.05472306f, 0.06386839f, -0.03365173f, -0.06389534f, 0.05013257f, -0.03862156f, -0.02385682f, -0.03618782f, 
    0.05173530f, 0.02182616f, -0.05371691f, -0.04232420f, 0.06583463f, 0.03166641f, 0.02056256f, -0.00683842f, 
    -0.02566642f, 0.06461298f, -0.00486854f, -0.07341816f, 0.00437107f, -0.05487987f, -0.00583504f, 0.02209359f, 
    -0.06887987f, -0.03914397f, -0.00595203f, -0.05208877f, 0.05980631f, -0.05633973f, 0.06681035f, -0.06484247f, 
    0.05155576f, -0.06961393f, -0.06187271f, 0.11328819f, 0.21573547f, -0.04535275f, -0.11271865f, -0.09847224f, 
    0.02209558f, -0.79217976f, -0.72305876f, -0.04287117f, -0.34042618f, 0.00114116f, -0.11622210f, 0.21105018f, 
    -0.02482332f, 0.12844248f, 0.45034236f, -0.28909034f, 0.15522660f, -0.18860526f, -0.11618692f, -0.04675984f, 
    -0.09395325f, -0.00491468f, -0.09133224f, -0.07218111f, 0.17380135f, -0.02654643f, 0.05276430f, -0.01242978f, 
    -0.17168550f, 0.06703778f, 0.17350076f, -0.01128427f, 0.98228002f, 0.19513009f, 0.24725468f, -0.07945181f, 
    -0.22774757f, 0.06290442f, 0.11121306f, 0.13633630f, 0.19981967f, 0.04139907f, -0.07076389f, -0.03922850f, 
    -0.33418983f, 0.08895947f, -0.07977308f, -0.00217924f, 0.07230751f, 0.04734354f, 0.16954128f, 0.38820106f, 
    -0.11611766f, 0.14371455f, -0.17009883f, 0.10750268f, -0.01031635f, -0.11883669f, -0.01642861f, -0.53827256f, 
    0.28928399f, -0.18215255f, -0.13257904f, 0.07631469f, -0.05305357f, -0.08247918f, -0.14617434f, -0.26494792f, 
    0.11276139f, 0.48701715f, -0.04480680f, -0.01937028f, 0.09004191f, 0.00390144f, 0.19545659f, -0.12111461f, 
    -0.02122675f, 0.26762974f, -0.19841640f, -0.25693491f, -0.12675048f, 0.28793713f, 0.26322532f, 0.04603113f, 
    -0.12832023f, -0.34213847f, -0.15325773f, -0.06235407f, -0.10263485f, 0.16708349f, -0.12276285f, -0.20028910f, 
    -0.27791533f, -0.09079827f, -0.48302230f, 0.30386490f, -0.00326524f, 0.12605490f, -0.11016861f, 0.01693521f, 
    0.18535694f, 0.16799210f, 0.08901410f, 0.08876678f, 0.31392011f, 0.02561065f, -0.05373089f, 0.20443432f, 
    -0.04064492f, -0.10797095f, -0.04606752f, -0.05303590f, -0.03531807f, -0.12957501f, 0.44421458f, -0.29914081f, 
    -0.16448581f, -0.11254565f, 0.27810264f, 0.04508081f, -0.02562176f, 0.20532456f, -0.51163715f, 0.02175377f, 
    0.03584305f, -0.21778421f, 0.14802235f, 0.18815704f, 0.03706909f, 0.09636456f, 0.16859725f, 0.20406716f, 
    -0.42500216f, -0.17877218f, -0.16353956f, -0.04109956f, 0.22968322f, 0.09486017f, -0.05081221f, 0.02104405f, 
    -0.11601525f, 0.05470521f, 0.20537499f, 0.08071521f, 0.10089491f, 0.20198056f, -0.34059343f, 0.11782254f, 
    -0.03051491f, -0.22428893f, 0.01110090f, 0.82652354f, 0.06151524f, -0.06710754f, 0.01262433f, -0.19620058f, 
    -0.06290985f, -0.08083700f, -0.23778190f, 0.04017334f, -0.39228356f, -0.11021722f, -0.01187427f, -0.06763964f, 
    0.03670968f, 0.05649457f, -0.04664931f, 0.12129001f, -0.03623991f, -0.41932574f, 0.05147403f, 0.00798643f, 
    -0.03352824f, -0.28337219f, 0.08502948f, 0.02304968f, -0.23298085f, -0.09947570f, 0.30305746f, 0.11475357f, 
    0.14813897f, 0.05360688f, 0.05889059f, 0.13628198f, 0.06269984f, -0.94267434f, -0.22176877f, -0.13227870f, 
    -0.33267364f, -0.20959720f, -0.05593566f, -0.17418253f, 0.16343947f, -0.15636444f, 0.26114628f, 0.07953849f, 
    -0.39992088f, -0.13053575f, -0.02233492f, 0.00595141f, -0.10572398f, -0.06576580f, 0.04162697f, -0.57239860f, 
    -0.33598548f, -0.21325360f, 0.06843523f, -0.03205386f, -0.00795691f, -0.09996578f, -0.11786106f, 0.11370251f, 
    -0.44175345f, 0.24471356f, 0.30211273f, 0.15713623f, 0.21797979f, 0.11591973f, 0.02565056f, -0.09362638f, 
    0.02234824f, 0.15212730f, 0.11635271f, -0.42938370f, 0.06446300f, 0.23748997f, 0.01002029f, -0.19405791f, 
    -0.14328754f, 0.16616605f, -0.04143272f, 0.08069686f, -0.16105509f, -0.14604917f, -0.00869713f, -0.25001922f, 
    0.21435502f, 0.05097945f, -0.05292283f, 0.67497522f, 0.24606870f, -0.23348753f, 0.11120639f, 0.13698734f, 
    0.17816088f, 0.21884596f, -0.03216225f, -0.05663442f, 0.25162461f, 0.35990983f, 0.13373455f, -0.25194234f, 
    -0.13784030f, 0.08420447f, 0.17044665f, 0.16321607f, 0.00869068f, 0.24810360f, 0.04938308f, 0.13724700f, 
    0.15683600f, 0.02424661f, -0.05628030f, -0.11119077f, 0.09952889f, 0.17571899f, -0.15804882f, 0.08763295f, 
    0.18209398f, -0.03261218f, 0.04692160f, 0.02461574f, 0.08562459f, 0.13848661f, 0.21193819f, -0.19638152f, 
    0.06487602f, 0.15333396f, -0.03599231f, 0.06507084f, -0.13495925f, -0.04820121f, 0.18077490f, 0.10525616f, 
    -0.02475529f, -0.02239653f, -0.08104725f, 0.01664014f, -0.06777854f, -0.02124795f, -0.02777769f, -0.02051798f, 
    0.02429435f, -0.01399249f, 0.05175149f, 0.01442795f, 0.02144037f, -0.01160282f, 0.00552715f, 0.00444404f, 
    -0.06979120f, 0.06818394f, 0.01982257f, -0.02225299f, -0.05488440f, 0.01216706f, -0.03896507f, -0.04104304f, 
    0.04368434f, -0.04495422f, -0.04850096f, 0.03287042f, -0.03883270f, -0.05685253f, 0.01375181f, 0.03391970f, 
    0.06423520f, 0.01778827f, -0.05128938f, -0.06756757f, 0.02035638f, 0.04852226f, -0.00008029f, 0.06627181f, 
    -0.01866083f, -0.04402936f, -0.05619007f, 0.06497553f, -0.03335413f, 0.05183475f, 0.05262928f, -0.02012317f, 
    0.02029160f, -0.03427944f, 0.04946368f, -0.08743533f, 0.06443126f, -0.07989526f, -0.07661787f, -0.00287728f, 
    0.04425519f, -0.03030530f, -0.01833748f, -0.03759195f, -0.03565849f, -0.03080786f, -0.08667534f, -0.06938037f, 
    -0.06963758f, -0.06038808f, -0.07519721f, -0.04051795f, 0.06383900f, 0.01318894f, -0.03462307f, -0.06487148f, 
    0.03949962f, 0.01024515f, -0.07866551f, 0.03303269f, -0.07787874f, -0.00942328f, 0.00221512f, -0.01439341f, 
    -0.04683981f, -0.02734102f, 0.00033221f, 0.00946982f, 0.04972916f, 0.01260456f, 0.05975346f, 0.02054338f, 
    -0.08771987f, -0.08276240f, 0.03543651f, 0.05029269f, -0.07315687f, 0.05509321f, -0.04267104f, -0.00639635f, 
    -0.08773077f, -0.03813277f, 0.02741697f, -0.02280465f, -0.00063877f, -0.03845802f, 0.01947724f, 0.03363623f, 
    -0.06915874f, -0.00495098f, -0.06583302f, 0.01697177f, -0.01854546f, -0.07245471f, 0.03727735f, -0.05639494f, 
    0.04580521f, 0.00819462f, -0.07228351f, -0.03482201f, -0.08692161f, 0.06862637f, -0.08411015f, -0.08987300f, 
    -0.03785029f, -0.01427354f, -0.05539023f, -0.03262055f, 0.01013885f, 0.01558771f, 0.06446542f, -0.02852423f, 
    -0.02205569f, -0.03526877f, -0.02357479f, 0.03859945f, -0.04316521f, -0.00178830f, 0.00985408f, 0.02066949f, 
    -0.00122016f, -0.01238966f, 0.05777271f, 0.03743785f, -0.04227301f, -0.01068516f, 0.05434881f, -0.05411869f, 
    -0.00127644f, 0.03951640f, -0.01877029f, 0.03657232f, 0.00238725f, 0.00850836f, -0.03981466f, 0.02089675f, 
    0.01878580f, 0.02561740f, 0.00741173f, 0.00155466f, 0.06354918f, -0.09404298f, 0.03145941f, -0.01549826f, 
    -0.03969343f, -0.02585988f, 0.06769855f, 0.03795138f, -0.01675552f, -0.01415926f, 0.04625423f, 0.01944967f, 
    -0.07580604f, 0.05409205f, 0.04468698f, -0.02995530f, -0.02215408f, -0.00025972f, 0.03620357f, -0.01037466f, 
    0.04493438f, -0.04728440f, -0.01754414f, 0.05404945f, -0.05756400f, -0.06982245f, -0.05184037f, -0.04290295f, 
    -0.07492036f, 0.03092027f, 0.05290036f, -0.06398584f, -0.08768728f, -0.09273710f, -0.03731726f, 0.04867745f, 
    0.05152498f, 0.02000066f, -0.08036646f, 0.02888510f, 0.03378103f, -0.05144411f, -0.07064564f, -0.05776728f, 
    -0.06029560f, 0.05724265f, -0.03927237f, 0.04736403f, -0.02872482f, -0.00738163f, 0.06179468f, 0.00803432f, 
    -0.05278954f, -0.07360952f, -0.00169765f, -0.06681781f, -0.05205353f, -0.09219562f, -0.07481932f, 0.06275307f, 
    0.01315907f, -0.07623132f, -0.05681518f, 0.00766937f, 0.01844123f, -0.04413408f, -0.07518015f, -0.03047469f, 
    -0.03443567f, -0.07054386f, 0.02663940f, -0.06918210f, -0.03550125f, 0.06878894f, -0.03372274f, -0.04749352f, 
    -0.05179750f, -0.03433550f, -0.05736673f, 0.05401680f, -0.05442269f, 0.06261840f, 0.04774417f, 0.05718218f, 
    0.04260809f, 0.05284911f, -0.06816094f, 0.00489316f, 0.00320333f, 0.03835226f, -0.03955435f, -0.05692428f, 
    -0.02561703f, -0.06988340f, 0.00987689f, 0.00386708f, -0.00293281f, 0.05782927f, 0.02122139f, 0.03195835f, 
    -0.07279584f, 0.06776743f, -0.09254752f, 0.02068243f, 0.07276826f, 0.07395986f, 0.05461026f, -0.02956124f, 
    0.02547627f, -0.09674744f, -0.00539359f, -0.06365795f, 0.00944535f, -0.06412338f, -0.03003112f, 0.00900050f, 
    -0.01557678f, -0.07209790f, -0.07611365f, 0.05761744f, -0.03981097f, 0.03929110f, -0.06479956f, -0.07552195f, 
    -0.00468630f, 0.02166392f, 0.04494767f, 0.02298937f, -0.08403624f, 0.06463922f, -0.09273145f, -0.08242881f, 
    0.04454472f, -0.06909021f, -0.05048160f, -0.05207144f, -0.06560402f, 0.02016154f, 0.04642357f, 0.00644282f, 
    0.05463506f, -0.08471578f, -0.00282045f, 0.02579327f, 0.05599650f, 0.00287349f, -0.00138929f, -0.05390147f, 
    0.03108409f, -0.05158789f, -0.05427120f, -0.09356132f, 0.05852035f, 0.04297777f, -0.04647620f, 0.06358624f, 
    0.05436685f, -0.07053819f, -0.00821297f, 0.05311874f, 0.05624156f, 0.06705427f, -0.02889707f, 0.05376663f, 
    0.03327126f, 0.05284140f, 0.06970541f, 0.00371863f, -0.00720708f, -0.06986956f, -0.09281678f, 0.02111227f, 
    -0.05813869f, 0.04995734f, 0.05775229f, -0.06936543f, 0.05524307f, -0.05299206f, -0.02500502f, 0.02439069f, 
    -0.00700325f, -0.07954346f, -0.06220489f, 0.01404523f, -0.04549528f, -0.01338010f, -0.00574772f, -0.08648916f, 
    -0.09313215f, -0.08396102f, 0.02768593f, 0.00468458f, -0.00409400f, 0.03105407f, -0.05465034f, -0.03853654f, 
    -0.07423408f, -0.03395473f, 0.03512235f, -0.02217999f, -0.06692089f, 0.06139671f, 0.00759481f, 0.01512765f, 
    0.06587766f, -0.00567995f, 0.06394817f, -0.01455218f, -0.06688096f, 0.00233964f, -0.08227637f, 0.05847006f, 
    -0.06104807f, -0.03913277f, 0.03186951f, -0.04335889f, -0.06177366f, 0.02022316f, -0.07134554f, 0.03635311f, 
    -0.07867698f, -0.05648264f, 0.07154489f, -0.01529084f, 0.02473452f, -0.07658578f, 0.07308652f, -0.03236075f, 
    0.04464084f, 0.06737940f, -0.08288150f, -0.01116414f, -0.07833748f, -0.06492736f, 0.06068027f, 0.04680671f, 
    -0.05634335f, -0.03249738f, 0.02664883f, 0.06884670f, 0.05804987f, 0.02995064f, 0.02127043f, -0.09591145f, 
    0.06071960f, -0.08782472f, -0.04114599f, -0.09200829f, -0.06501225f, -0.03005684f, -0.09423291f, -0.09587182f, 
    0.02184719f, 0.03673633f, -0.08625647f, 0.06577788f, -0.10153488f, -0.05199319f, -0.05920630f, -0.06375683f, 
    -0.08984442f, -0.08889966f, -0.00024614f, 0.06160842f, -0.06597846f, -0.07749230f, -0.06018977f, 0.00571480f, 
    0.05039526f, 0.05559115f, -0.05150594f, 0.06410269f, -0.05657322f, -0.04463530f, 0.06156087f, -0.09536819f, 
    -0.01031511f, 0.05047833f, -0.02519497f, -0.06719182f, 0.00198258f, 0.00275711f, -0.03001016f, 0.05799230f, 
    -0.09500296f, 0.03652034f, 0.02637604f, -0.02256466f, 0.00518475f, -0.05016431f, -0.01243998f, -0.09448472f, 
    0.00488368f, 0.00621185f, -0.03510792f, -0.02952671f, -0.04285581f, -0.05879600f, -0.04776103f, 0.04849183f, 
    -0.00540826f, 0.05230995f, -0.06459757f, -0.03021921f, 0.05634935f, 0.04764933f, -0.07224391f, 0.06535957f, 
    -0.09532697f, -0.04135646f, 0.00869916f, -0.00537164f, -0.04934932f, -0.01247027f, -0.06761203f, -0.03369034f, 
    0.00539898f, -0.02993583f, -0.02338562f, -0.00321208f, 0.02674037f, 0.00741898f, 0.03663689f, -0.07069203f, 
    -0.04212662f, -0.09407905f, -0.03905461f, 0.06715460f, -0.06442846f, -0.07664271f, 0.06541988f, -0.03978622f, 
    0.03251977f, 0.04997244f, -0.05452089f, -0.06338388f, -0.00732578f, -0.06051891f, -0.01950960f, 0.01000029f, 
    0.06380548f, -0.05620613f, 0.05541276f, 0.02860938f, -0.03358529f, -0.05766320f, 0.06592709f, -0.03633423f, 
    -0.06394003f, -0.08687293f, -0.04057050f, -0.00311803f, -0.02388968f, -0.08140741f, 0.03561218f, 0.03929371f, 
    0.00635157f, 0.05697513f, 0.05330907f, -0.01323818f, -0.03131528f, -0.02331458f, 0.03805026f, -0.02053831f, 
    -0.04040517f, -0.01721418f, 0.06094512f, 0.05519287f, 0.03628061f, -0.02881329f, -0.01016362f, 0.00910754f, 
    0.02809148f, 0.04569401f, -0.03064859f, 0.00775525f, -0.05602819f, -0.01781906f, 0.02773919f, -0.09302846f, 
    -0.02893197f, 0.03584260f, 0.04333983f, -0.08491489f, 0.03672932f, -0.07655733f, -0.01554906f, -0.03460450f, 
    0.02514651f, -0.08728770f, -0.02972144f, 0.06793427f, -0.03588317f, 0.05128429f, -0.03544715f, -0.06592550f, 
    0.03350853f, 0.02736445f, -0.09609952f, 0.02836417f, 0.00635570f, -0.00659691f, -0.02583335f, 0.07363369f, 
    -0.07715262f, -0.07441816f, 0.01608844f, -0.03255717f, -0.00367127f, -0.08417078f, -0.08972550f, 0.00093389f, 
    0.01545634f, -0.05978175f, -0.08744621f, 0.00269793f, 0.00395350f, -0.06840158f, -0.03501907f, 0.06255002f, 
    -0.11260846f, -0.05651411f, -0.10337535f, -0.05043858f, 0.03228733f, 0.05465281f, 0.01539268f, 0.07611055f, 
    -0.04018788f, 0.01371801f, 0.05059891f, 0.03360799f, -0.04595261f, 0.03621365f, 0.02315732f, -0.02940150f, 
    -0.04989492f, -0.01510255f, -0.05085645f, -0.03442813f, -0.05845912f, -0.01008285f, 0.02172972f, -0.00259445f, 
    -0.05462975f, 0.06313292f, 0.04167522f, 0.06242172f, 0.01644180f, 0.02711689f, -0.02587030f, 0.00751014f, 
    0.00149056f, 0.05179429f, -0.04000045f, 0.00957245f, -0.01116756f, 0.01867894f, 0.04723861f, -0.03737326f, 
    -0.00025962f, -0.07619381f, -0.01976451f, -0.00655682f, 0.00769017f, 0.04149616f, -0.01991033f, -0.09546588f, 
    -0.01229005f, -0.05579852f, 0.00030778f, -0.02471502f, -0.01607677f, -0.01766932f, -0.06340807f, -0.03916674f, 
    0.02047341f, 0.03870383f, -0.06022516f, -0.06304973f, 0.03170611f, 0.00787382f, 0.08049846f, 0.00895461f, 
    -0.02603299f, -0.00105468f, -0.10641611f, -0.03271685f, -0.08706548f, 0.01807763f, -0.01195104f, -0.02314804f, 
    0.00146794f, 0.02806138f, 0.04237575f, -0.01907495f, -0.07662310f, -0.03151385f, -0.09063143f, 0.03133675f, 
    0.02534552f, 0.03968632f, 0.06452653f, -0.08038486f, 0.01747905f, 0.03885330f, -0.06739400f, 0.00048343f, 
    0.02241062f, 0.08857358f, 0.02702131f, -0.03254804f, 0.04363713f, 0.08178629f, 0.01235058f, -0.02775111f, 
    0.03516850f, -0.08724351f, 0.08700594f, 0.05226577f, -0.01792550f, 0.05101170f, -0.01782662f, 0.08288868f, 
    -0.02133983f, -0.08878554f, 0.06089266f, -0.02002668f, -0.06404329f, -0.06598280f, -0.07999950f, -0.03634216f, 
    -0.01692575f, -0.09695303f, -0.05012160f, 0.06428337f, 0.00297275f, 0.02208809f, -0.08303581f, -0.09813357f, 
    0.01717350f, -0.03060372f, 0.02108339f, -0.08340812f, -0.00350985f, -0.08281574f, 0.01639804f, 0.04762886f, 
    -0.08218339f, 0.05734425f, 0.03304064f, -0.08117486f, 0.06518331f, -0.06265054f, -0.09259193f, -0.08218427f, 
    0.00150301f, -0.08731714f, -0.04954958f, -0.05389764f, -0.05909277f, -0.06493875f, -0.00403426f, -0.06406085f, 
    0.19399770f, 0.07594064f, -0.37884685f, 0.22739907f, -0.17924531f, 0.08073276f, 0.33718282f, 0.06121821f, 
    0.12896600f, 0.58660436f, 0.09099379f, 0.34838971f, 0.08571558f, -0.27405459f, 0.01234663f, -0.15183611f, 
    0.15643770f, 0.06791322f, 0.22350730f, -0.08012206f, -0.70048112f, -0.07890319f, -0.32591477f, -0.20087056f, 
    0.04655658f, 0.00965940f, 0.15725128f, 0.27400333f, 0.39231864f, -0.31023058f, 0.09239568f, -0.11168625f, 
    0.25572973f, 0.11974865f, -0.15706615f, 0.01962610f, -0.52794927f, -0.75002223f, 0.08545259f, 0.14518481f, 
    0.06095546f, 0.01797771f, -0.10570233f, -0.04435861f, 0.04201365f, 0.23358825f, 0.43312457f, 0.01426781f, 
    0.21573287f, -0.17770755f, -0.05570476f, 0.07203966f, 0.00439736f, -0.18902856f, -0.43657714f, -0.33893704f, 
    -0.58808875f, -0.04946293f, 0.10322858f, 0.15175681f, -0.15380269f, -0.14244848f, 0.05220189f, 0.25991198f, 
    -0.07563102f, 0.17028674f, 0.16515498f, 0.33569604f, 0.20232610f, 0.31189388f, 0.08229003f, 0.03664069f, 
    0.42254409f, 0.61414099f, -0.01840637f, 0.13678662f, -0.10047906f, 0.10490099f, 0.02318726f, -0.20104070f, 
    0.02521943f, -1.14203477f, -0.08821467f, 0.15601771f, 0.19433650f, 0.27426377f, -0.16238806f, -0.06946786f, 
    0.03525114f, 0.08244435f, -0.15923509f, -0.37239909f, -0.51349050f, 0.18859306f, 0.12364131f, -0.01069779f, 
    0.22237304f, -0.56851095f, -0.36541820f, -0.77432823f, -0.01166854f, 0.40706781f, 0.04683333f, 0.16143315f, 
    0.09158017f, 0.07032465f, 0.14158718f, 0.06077203f, -0.09852135f, -0.17377934f, 0.20781690f, -0.17733836f, 
    -0.07083686f, -0.01784102f, -0.22105479f, 0.15874237f, -0.20788904f, -0.52693528f, -0.26868480f, 0.36078084f, 
    -0.14239036f, 0.00215734f, 0.00965040f, -0.12259567f, 0.10479195f, 0.14328101f, 0.38420647f, 0.30282062f, 
    0.22237433f, 0.26416045f, 0.12149338f, 0.14212604f, 0.20623478f, -0.16807775f, 0.20501769f, 0.30680630f, 
    -0.33469066f, 0.28252688f, -0.14593554f, 0.00996775f, -0.23969170f, -0.01593126f, -0.02133324f, 0.31713092f, 
    -0.09024183f, -0.02628034f, -0.05660697f, 0.01333804f, -0.07485059f, -0.00418795f, 0.03897718f, 0.00947748f, 
    -0.03094248f, 0.00272579f, -0.07623006f, 0.05583009f, 0.05608945f, -0.05055730f, 0.03328697f, 0.01897343f, 
    -0.00246457f, -0.03481672f, 0.04392187f, 0.02615050f, -0.04806591f, -0.02118083f, -0.00553500f, -0.03233054f, 
    -0.07536597f, -0.05872720f, -0.00763536f, 0.04910739f, 0.02268179f, -0.05187251f, -0.05542713f, 0.06031125f, 
    -0.04007353f, 0.02692396f, -0.05333352f, -0.08901446f, -0.00267892f, 0.00974179f, 0.01912361f, -0.03123369f, 
    -0.08966827f, -0.02714806f, 0.04144711f, -0.06485313f, -0.02624744f, 0.06753203f, -0.01378442f, -0.03086778f, 
    -0.07317483f, -0.06602436f, -0.05066209f, 0.03962583f, 0.05226109f, -0.01221377f, -0.02004117f, 0.03494384f, 
    0.00346024f, -0.02227041f, 0.02000801f, -0.06613322f, -0.04838056f, -0.08330744f, -0.05571724f, -0.05774796f, 
    -0.08076886f, -0.03817930f, 0.05439423f, 0.01884674f, 0.04776271f, -0.03275763f, 0.07083905f, -0.08984145f, 
    0.00558088f, 0.06671906f, 0.00649811f, 0.02751956f, 0.06566092f, -0.08713923f, 0.06099682f, 0.04726511f, 
    0.06734208f, -0.08145123f, 0.06187346f, -0.01626778f, -0.09002534f, 0.02217401f, 0.06024364f, 0.06599288f, 
    -0.05818165f, 0.01675327f, -0.04474785f, -0.07570658f, 0.07156223f, -0.06667204f, 0.03510606f, 0.01693860f, 
    0.01320881f, -0.00968657f, 0.01376274f, -0.04622627f, 0.04821189f, 0.04430882f, 0.03874356f, -0.01020766f, 
    -0.02077317f, 0.03312178f, 0.00862366f, -0.01103005f, 0.01342771f, 0.05305291f, -0.07219619f, 0.01361896f, 
    -0.01945751f, 0.02379665f, -0.04115729f, 0.04960731f, -0.05574998f, -0.09014977f, -0.05129523f, 0.05273446f, 
    -0.02408895f, -0.00389580f, -0.04327539f, -0.08669423f, 0.03812312f, 0.01106131f, -0.08359456f, -0.05161731f, 
    -0.03321046f, -0.00142242f, 0.00770200f, 0.01958070f, 0.04253905f, 0.03338467f, -0.07723384f, -0.05608625f, 
    -0.01696103f, 0.00508412f, -0.03180715f, 0.04207426f, -0.05855342f, 0.04421964f, -0.07783858f, 0.03527077f, 
    -0.11015061f, -0.08653187f, -0.00102532f, -0.06975470f, -0.08387464f, 0.02254221f, -0.04758935f, -0.09945071f, 
    -0.06426534f, 0.04976064f, -0.01821757f, 0.03031934f, -0.10774162f, -0.03127242f, 0.04301004f, -0.09513602f, 
    -0.08658955f, -0.10642863f, 0.00822299f, 0.02294023f, 0.02949981f, -0.11748695f, -0.05629237f, 0.01358926f, 
    -0.10406265f, -0.04155025f, 0.00222743f, -0.05413171f, -0.05341103f, -0.01803850f, -0.04734952f, -0.01564723f, 
    -0.11446213f, -0.02094441f, -0.08051499f, -0.08854160f, -0.06093713f, -0.03608247f, -0.09647829f, 0.00481262f, 
    -0.11500893f, -0.05830817f, 0.03780010f, 0.02798761f, -0.05898495f, -0.01544674f, -0.08422607f, -0.09220514f, 
    -0.01329230f, -0.06244704f, -0.04041939f, -0.03467932f, -0.10436700f, -0.10017632f, -0.02431402f, -0.07210632f, 
    0.00651079f, -0.10926910f, -0.02590733f, -0.09279912f, -0.02140202f, -0.00720164f, 0.00210100f, -0.01844584f, 
    0.02361742f, 0.02725095f, -0.06478564f, -0.00800728f, -0.09179579f, -0.07517823f, -0.04360283f, -0.06951167f, 
    0.03111942f, -0.11573706f, -0.00278324f, -0.06146454f, -0.02984550f, -0.05008503f, -0.08079649f, -0.06986082f, 
    0.03077527f, -0.00139774f, -0.06103596f, -0.07307176f, -0.04580951f, -0.07725193f, -0.00188244f, -0.09109066f, 
    0.01753337f, 0.02261818f, -0.09599180f, -0.05275996f, 0.03522202f, -0.10310120f, -0.07269184f, -0.07218710f, 
    0.00666538f, -0.05574784f, 0.03569750f, -0.02714084f, -0.03964208f, -0.03118917f, 0.01014320f, -0.09726091f, 
    -0.01903692f, 0.03205735f, -0.07021564f, -0.07768760f, 0.02008983f, -0.00335887f, -0.08056241f, -0.08477636f, 
    0.00182665f, -0.01380678f, 0.00694269f, -0.03316274f, 0.03193536f, -0.08217562f, -0.06424839f, -0.09610784f, 
    0.02968630f, -0.08056962f, -0.08811356f, -0.07401420f, 0.00268110f, 0.02758049f, -0.11735144f, 0.01831592f, 
    -0.03783906f, -0.09396220f, -0.00568122f, -0.07582629f, -0.00983294f, 0.01708844f, -0.08531059f, -0.03071668f, 
    -0.04807627f, 0.00953164f, -0.02886748f, -0.00199078f, -0.00395815f, -0.06771893f, 0.03048216f, -0.07266483f, 
    -0.13350704f, 0.14392444f, 0.12773474f, -0.07427420f, 0.21558718f, 0.33419254f, 0.09551109f, 0.18428028f, 
    0.21144712f, -0.90877670f, 0.21239302f, 0.21744780f, 0.21546653f, 0.02342447f, -0.08408769f, -0.01396941f, 
    0.29373547f, -0.15410341f, -0.58303440f, -0.53608978f, 0.24098350f, -0.04709164f, 0.13458775f, -0.00903083f, 
    0.03970221f, -0.06689256f, 0.08100718f, 0.42492118f, 0.27941409f, -0.24493447f, 0.26965410f, -0.07516094f, 
    0.29250824f, -0.24198042f, 0.37363014f, 0.24545820f, 0.10341882f, 0.25155574f, 0.21432158f, 0.28703463f, 
    0.15954559f, 0.07764671f, 0.18715848f, -0.14337741f, -0.08576960f, -0.32424632f, -0.20562500f, -0.08052732f, 
    -0.05568048f, -0.05079766f, -0.21709895f, -0.36807150f, -0.09382356f, -0.07684103f, -0.23167431f, -0.65200669f, 
    -0.02805058f, -0.17367351f, 0.07420220f, 0.06738888f, -0.09349547f, -0.02926354f, 0.13507339f, 0.36044854f, 
    0.61841238f, 0.23476909f, -0.04319200f, -0.04483967f, 0.06493986f, 0.06639234f, 0.20314303f, 0.02952552f, 
    0.28143319f, 0.30693334f, 0.23706552f, 0.25399065f, -0.05838219f, 0.03840535f, -0.33682591f, 0.32124680f, 
    0.04692325f, 0.07885723f, -0.22091930f, -0.08099493f, 0.01119441f, -0.43947577f, -0.03807897f, 0.08167025f, 
    -0.07028363f, 0.14307179f, -0.34928668f, -0.41772088f, -0.47444335f, 0.47413510f, -0.04811966f, 0.06040267f, 
    0.13308784f, -0.17458615f, 0.00576500f, -0.53058052f, -0.31776443f, 0.06926887f, 0.15592489f, -0.06992399f, 
    -0.01646236f, 0.21595529f, 0.08915952f, 0.07741880f, -0.17261237f, -0.34799132f, -0.16158757f, 0.28183734f, 
    0.26537144f, 0.08601258f, 0.20036076f, 0.15414025f, -0.26992345f, 0.44123629f, -0.11808909f, -0.95947152f, 
    0.25483787f, 0.16911180f, 0.06422924f, -0.07291404f, -0.07575706f, -0.02967801f, 0.36280176f, 0.38985220f, 
    0.39156705f, 0.06169976f, -0.10527702f, -0.01602528f, 0.10719868f, 0.49178544f, 0.15435492f, -0.41645533f, 
    -0.43675807f, -0.04744035f, 0.03972862f, -0.05187281f, 0.03591743f, 0.01231982f, -0.10365832f, -0.13536125f, 
    0.25250345f, 0.57937241f, -0.53050554f, 0.02346415f, 0.01796663f, -0.14803492f, 0.11524075f, 0.01636716f, 
    -0.01008177f, 0.22588277f, 0.00098857f, 0.98211777f, 0.27475008f, -0.01480531f, 0.01669464f, 0.03206038f, 
    -0.13834174f, -0.02929925f, 0.54675412f, -0.04000084f, -0.43014699f, -0.07339386f, 0.01877425f, 0.14080106f, 
    0.22539660f, -0.11491656f, -0.07847300f, -0.31840733f, 0.03456828f, -0.72983587f, -0.00402261f, 0.11780790f, 
    -0.25109699f, -0.05538340f, 0.16819836f, -0.13351309f, 0.00901422f, 0.22039795f, 0.23520195f, 0.14214890f, 
    0.05524210f, 0.03729906f, 0.01950801f, 0.06477987f, 0.10340811f, -0.13602261f, 0.17253365f, -0.03303359f, 
    -0.10875931f, -0.09853022f, -0.30394644f, 0.12069838f, -0.07318068f, -0.10901380f, 0.37982079f, -0.13157307f, 
    -0.26587293f, -0.02384208f, -0.01858932f, -0.15583980f, -0.11199671f, -0.14953759f, -0.14395903f, 0.06454650f, 
    0.04743427f, -0.08681919f, 0.03303580f, -0.08003803f, -0.15695639f, -0.08512360f, -0.08153509f, -0.12828135f, 
    -0.15562001f, -0.54491973f, -0.10817805f, 0.20563866f, 0.19641204f, 0.13929740f, -0.00124272f, 0.02990759f, 
    0.11270403f, -0.13170305f, 0.47749779f, 0.07316236f, -0.09501640f, 0.01676406f, 0.01611986f, -0.09101314f, 
    -0.03683248f, 0.12084193f, -0.15945025f, 0.11489581f, -0.02470808f, 0.03990185f, 0.02023983f, 0.27147934f, 
    0.05216003f, -0.19595778f, -0.09552217f, -0.44483215f, 0.12891619f, 0.15235110f, 0.19291362f, 0.03519228f, 
    0.10263634f, -0.05605153f, 0.08025972f, 0.29064259f, -0.47258303f, -0.09556761f, 0.36427662f, 0.10214373f, 
    -0.06145195f, 0.04290944f, -0.01590621f, 0.00926097f, 0.11201043f, 0.06075267f, -0.17658438f, 0.67059934f, 
    -0.08616218f, 0.21428727f, 0.13489372f, -0.12071929f, 0.01531451f, 0.28740236f, 0.29105330f, 0.02551279f, 
    -0.14269042f, -0.05459752f, 0.16718204f, 0.08706038f, -0.04399780f, 0.19375369f, -0.18997261f, 0.18218115f, 
    0.12187289f, 0.17918329f, -0.42472628f, 0.05162511f, -0.19616203f, -0.04971408f, 0.08565202f, -0.08624175f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01300978f, 0.00964049f, 0.27262619f, -0.08762480f, 0.05454095f, 0.16574846f, 0.02203834f, -0.05458967f, 
    -0.04622541f, -0.09207191f, -0.06293242f, 0.22946735f, 0.00694986f, -0.00715607f, 0.37344745f, -0.28538528f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20331016f, -0.17961779f, -0.29091081f, -0.07413174f, 0.74220121f, 0.08534538f, -0.03687253f, 0.04324925f, 
    0.22267911f, 0.08608211f, 0.16573913f, -0.67331755f, -0.13204391f, 0.17682041f, 0.18416861f, -0.12685423f, 
    -0.15366513f, -0.55336034f, 0.25596353f, 0.16230324f, -0.36807001f, 0.54250389f, 0.10627875f, -0.13405940f, 
    -0.01782749f, -0.13266592f, -0.05737695f, -0.39799920f, 0.11297685f, -0.15231690f, 0.36617488f, -0.47798464f, 
    0.14701696f, -0.35612142f, 0.85599726f, 0.16630071f, 0.78402054f, -0.11342569f, 0.02275350f, -0.16381630f, 
    0.23931615f, -0.03885253f, -0.10263350f, -0.22598518f, 0.12300020f, -0.08578791f, -0.36334598f, -0.30877572f, 
    0.14275043f, 0.79103160f, -0.33774599f, -0.00975771f, 0.15932730f, 0.17180547f, 0.11900192f, 0.13054782f, 
    -0.07170207f, 0.16574572f, -0.14518984f, -0.09437726f, -0.18611540f, -0.07171255f, -0.73613679f, -0.43580896f, 
    -0.17406555f, -0.14464514f, -0.24310674f, 0.23393624f, 0.01821449f, 0.00491311f, 0.18461384f, -0.07185081f, 
    -0.15946759f, 0.12552331f, 0.08194025f, 0.23949340f, 0.06543558f, -0.16235039f, -0.10941388f, 0.11190352f, 
    -0.04251514f, -0.41102612f, -0.23207526f, 0.11542756f, -0.64807874f, 0.19326264f, 0.09750463f, 0.16328800f, 
    0.14275196f, -0.04598515f, 0.24081144f, -0.16813704f, -0.04284802f, -0.04588632f, 0.55826104f, -0.58185631f, 
    0.15619957f, -0.17341565f, -0.69888163f, 0.12064420f, 0.23863325f, -0.21179450f, -0.14825584f, 0.06808054f, 
    -0.18471107f, 0.19668777f, 0.08195332f, 0.33499849f, 0.23114513f, -0.00966079f, 0.20519945f, -0.63492066f, 
    0.03974824f, 0.11429135f, -0.08555783f, -0.06184071f, -0.16828503f, -0.14953114f, -0.05196378f, -0.07677943f, 
    -0.11173605f, -0.21191718f, 0.20097338f, -0.43832788f, -0.07638555f, -0.22745602f, -0.53753871f, 1.12466276f, 
    -0.13753495f, -0.36955288f, 0.63118678f, -0.03596824f, -1.21812427f, -0.75136906f, 0.05867817f, 0.22734320f, 
    0.08791021f, -0.20218000f, 0.18412502f, -0.05003834f, -0.18141423f, 0.01484699f, 0.09386376f, 0.62018132f, 
    0.13854820f, -0.20703863f, -0.48996618f, 0.20764039f, 0.01860088f, -0.62359977f, -0.13908368f, -0.11391727f, 
    0.07670546f, 0.09339561f, -0.19128720f, 0.48481372f, 0.05208435f, 0.10791605f, -0.01312489f, 0.26036412f, 
    -0.09745541f, 0.46233857f, 0.42712322f, -0.10898937f, -0.31281075f, 0.45410335f, 0.08342281f, 0.24135594f, 
    0.18172041f, -0.19366957f, -0.15899993f, -0.08626701f, -0.15225708f, 0.22959910f, -0.49521014f, -1.01152992f, 
    -0.05605241f, 0.50698608f, -0.14431477f, -0.10652805f, 0.13894659f, -0.90906423f, 0.02517428f, -0.20890358f, 
    0.04779122f, -0.10221071f, -0.24271066f, 0.48579761f, 0.23141113f, -0.13152175f, -0.50068253f, -0.16287117f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19488494f, 0.59574932f, -0.89572424f, -0.47929406f, 0.58571994f, 0.06719291f, -0.68368047f, -1.18192410f, 
    -0.11225863f, -0.06351674f, 0.39709130f, 0.33386791f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
