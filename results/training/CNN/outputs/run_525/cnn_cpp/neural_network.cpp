#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.22652318f, 0.35459816f, -0.33472675f, -0.48095411f, -0.52518016f, -0.60874248f, -0.48465806f, -0.20054853f, 
    0.16166475f, -0.08075026f, -0.06689771f, -0.02191091f, -0.64891130f, -0.00170365f, -0.20035218f, -0.40875179f, 
    0.14494096f, 0.02235024f, -0.21212469f, 0.08057513f, 0.14350136f, 0.21008870f, 0.43903419f, 0.01715552f, 
    0.00105985f, -0.05119927f, 0.04386362f, -0.04159126f, -0.64068252f, -0.21642739f, 0.47881779f, 0.22343890f, 
    0.37756974f, -0.50847614f, -0.43193641f, 0.38937569f, 0.31712043f, 0.09340174f, 0.23515537f, 0.42960954f, 
    -0.39296982f, -0.32626089f, -0.24074973f, -0.19141005f, 0.15147841f, 0.04988761f, -0.10921472f, 0.19891021f, 
    0.35315907f, -0.21378443f, -0.87420458f, 0.64950985f, 0.61011428f, -0.91416687f, 0.87732005f, 0.87730134f, 
    -0.28673863f, -0.64601684f, 0.09972272f, -0.56556714f, 0.03504105f, 0.08673199f, 0.12459541f, 0.18606240f, 
    -0.25108325f, -0.16740783f, 0.11852860f, -0.07383087f, -0.16416872f, -0.37887377f, -0.12508918f, 0.16590397f, 
    -0.04315092f, 0.08707822f, 0.14980306f, -0.24676557f, 0.15100470f, -0.48130998f, -0.54241717f, -0.45623738f, 
    0.83899754f, -0.34148902f, -0.44769666f, 0.57793200f, -0.04970753f, -0.37840375f, 0.06125955f, 0.20078315f, 
    -0.29406962f, 0.05011293f, 0.18903469f, 0.27728301f, -0.24769016f, -0.07288941f, -0.23479028f, -0.31384626f, 
    0.17152046f, 0.03066178f, 0.10099898f, 0.05003677f, -0.54513144f, -0.69637036f, -0.57812285f, 0.83904648f, 
    0.37996808f, 0.63210171f, 0.28735462f, -0.22799748f, 0.48118228f, -0.35244790f, 0.11290471f, 0.14492629f, 
    -0.11642884f, 0.01541123f, -0.37978637f, -0.44235793f, 0.04536637f, -0.51867282f, -0.24832368f, -0.21568161f, 
    -0.14883831f, -0.25771129f, 0.01085742f, -0.30485019f, -0.10285306f, 0.19383502f, 0.85943884f, 0.19952050f, 
    0.73221964f, 0.35672599f, 0.48356694f, 0.20416649f, -0.37343463f, 0.11254421f, 0.24742745f, -0.49817428f, 
    0.21221489f, 0.24120407f, 0.00715072f, 0.09634538f, -0.17752992f, 0.27596983f, -0.07316092f, -0.05478965f, 
    0.32737741f, -0.29626185f, -0.29249534f, 0.13553044f, -0.56030780f, -0.23433188f, -0.36332721f, 0.51894730f, 
    0.00901481f, 0.07053702f, 0.04697473f, 0.08379490f, -0.39039987f, -0.51504570f, -0.48982218f, -0.01161214f, 
    -0.09249711f, 0.23050719f, 0.00522319f, 0.37994635f, -0.15349473f, -0.32235569f, 0.30089206f, -0.05029533f, 
    -0.04375001f, 0.49567598f, -0.36128834f, 0.36920273f, 0.02576290f, 0.28036261f, -0.24532652f, -0.28622419f, 
    0.05242087f, -0.65393287f, -0.04677829f, -0.09878238f, -0.07397281f, 0.10665314f, 0.18845336f, -0.14561850f, 
    -0.17448211f, -0.04367093f, 0.32989383f, 0.20966096f, 0.30001384f, 0.28201914f, -0.57029694f, 0.21744193f, 
    -0.06421740f, -0.22294107f, -0.08597930f, 0.54880714f, -0.27003390f, -0.37164032f, -0.23265933f, -0.35401773f, 
    -0.13114631f, 0.72352451f, 0.44461134f, 0.34240863f, 0.47834179f, -0.25130022f, -0.16854751f, -0.13686472f, 
    0.28180623f, 0.30710551f, -0.21292405f, -0.61555171f, 0.14839430f, -0.40538532f, 0.39529431f, 0.21808055f, 
    0.24165520f, -0.12529825f, -0.16105317f, 0.09822429f, 0.08284455f, 0.23949118f, -0.33012074f, 0.28372326f, 
    -0.25878093f, -1.56587350f, 0.49559650f, 0.71489215f, 0.00433148f, -0.69937706f, 0.20774199f, 0.18885477f, 
    0.26113179f, 0.27744722f, 0.05195075f, -0.17500347f, -0.19598982f, 0.10564964f, 0.37093648f, 0.24259813f, 
    -0.04811993f, -0.13288969f, -0.08170492f, -0.06598641f, -0.05521737f, 0.07017133f, 0.10313081f, 0.03720655f, 
    0.29612121f, -0.07302404f, 0.61564702f, 0.92984164f, 0.60770863f, 0.41063821f, -0.32309544f, -0.70070815f, 
    -0.16377102f, 0.28428879f, -0.69188690f, 0.07790446f, 0.15434581f, 0.33661234f, 0.10652435f, 0.20028338f, 
    0.08804199f, -0.16253740f, 0.15910061f, 0.24073814f, -0.08977818f, 0.06430894f, 0.34506279f, -0.07562840f, 
    -0.20808639f, 0.42579481f, 0.14457892f, 1.16559863f, 0.50795102f, -0.33729923f, 0.58707148f, 0.33014894f, 
    -0.37491077f, 0.11682653f, 0.52058429f, 0.31383237f, 0.17816432f, -0.15491761f, -0.28545284f, 0.15407816f, 
    -0.20292677f, 0.05774787f, 0.29088658f, -0.18741873f, -0.03471334f, -0.10717468f, 0.27859306f, 0.07080227f, 
    -0.09277537f, 0.07779060f, 0.33150837f, -0.15522808f, 0.91532511f, 0.73890901f, 0.02504690f, -1.19278741f, 
    -0.59740275f, -0.25100487f, 0.56038332f, -0.04766458f, -0.43421072f, -0.24803510f, 0.25096154f, 0.06006912f, 
    -0.10315955f, 0.18110287f, 0.08954813f, 0.18001360f, 0.02914551f, -0.02020154f, 0.05982174f, 0.22071998f, 
    -0.02859032f, 0.11750396f, 0.04064994f, -0.14407380f, 0.08995578f, -0.05270265f, 0.12232595f, 0.18927835f, 
    -0.49523836f, 0.22507380f, -0.33738977f, -0.27848497f, -0.62905467f, -0.42917079f, -0.03797495f, 0.30793115f, 
    0.57707083f, 0.39290789f, 0.00856357f, -0.21737300f, 0.22472435f, -0.40665388f, 0.17836390f, 0.55571783f, 
    0.34557697f, 0.00971043f, -0.00244838f, -0.22828554f, -0.03249831f, -0.12175357f, -0.19654992f, -0.64152855f, 
    0.10601094f, 0.51466751f, -0.30056936f, -0.18460603f, -0.43427759f, 0.01104519f, -0.53304261f, -0.61205363f, 
    0.39638013f, 0.33464301f, 0.25056109f, -0.06995931f, -0.04086581f, 0.21605748f, 0.34613025f, -0.37080607f, 
    -0.22314933f, 0.28331614f, -0.12605166f, -0.10634328f, 0.37382481f, 0.12187009f, 0.28561628f, 0.68376940f, 
    -0.56379485f, 0.84172213f, 0.32375965f, 0.35632214f, 0.46364179f, 0.08694313f, 0.48958772f, -0.23342319f, 
    -0.51598769f, -0.17158286f, -0.30681014f, -0.22401300f, 0.33888790f, -0.01121773f, 0.05397359f, -0.04222585f, 
    0.22603339f, 0.20244986f, 0.30354881f, -0.28129411f, -0.30153796f, -0.21081579f, -0.24000615f, -0.22221932f, 
    -0.18438375f, -1.00538433f, -0.37263682f, -0.17640486f, -0.52574128f, -0.35936776f, 0.86526960f, 0.51786113f, 
    -0.19460513f, 0.43414745f, -0.09744334f, -0.13175485f, -0.18033959f, 0.02410639f, -0.17362072f, -0.14131176f, 
    0.05479122f, -0.20286013f, -0.02194397f, 0.00487866f, 0.06524774f, 0.34268510f, 0.11013000f, 0.03002135f, 
    0.17888826f, 0.43438056f, 0.90340173f, 0.75522053f, 0.67881697f, -0.11711824f, -0.08293752f, 0.25898573f, 
    -0.42454153f, -0.10073522f, -0.00250425f, 0.45650730f, 0.15926592f, -0.23529172f, -0.34543845f, -0.31055591f, 
    -0.08933642f, -0.28417963f, 0.41915181f, -0.16018732f, -0.26954994f, -0.08179883f, 0.42399359f, 0.11105357f, 
    0.29978690f, 0.18440318f, 1.02170253f, 0.35765263f, 0.58459032f, 0.03108577f, -0.32761070f, -0.07631145f, 
    0.26560542f, -0.25634786f, 0.50393462f, 0.42114565f, 0.04189268f, 0.36688736f, -0.10795727f, 0.29707459f, 
    0.10291728f, -0.09793360f, -0.22965041f, -0.20091954f, -0.00443060f, 0.37588570f, -0.18862705f, 0.38326794f, 
    -0.13072760f, 0.13223018f, -0.02447370f, 0.77497584f, -0.69679052f, -0.44009569f, 0.78773701f, -0.11115225f, 
    -0.67845351f, 0.59380060f, 0.53398800f, -0.54371411f, 0.10028163f, -0.08886684f, -0.01462335f, 0.16054574f, 
    -0.43702534f, 0.26991245f, -0.47655588f, -0.09004413f, -0.39727992f, 0.07226393f, -0.25725874f, 0.17612229f, 
    -0.16897543f, 0.08398297f, -0.09465976f, -0.02271425f, -0.60901982f, 0.52572012f, 0.06736231f, -0.58896869f, 
    -0.67193282f, 0.46575454f, -0.09417446f, -0.23144709f, -0.20979005f, 0.46997321f, 0.11312237f, -0.11029948f, 
    -0.06600548f, 0.29217342f, 0.18909208f, -0.19000243f, 0.11327630f, 0.05210539f, -0.23655632f, 0.44213286f, 
    -0.22931112f, -0.14538419f, -0.14391176f, -0.45696574f, 0.30265489f, -0.37580457f, -1.09410441f, -0.63891941f, 
    0.11153067f, 0.07825303f, -0.55483514f, 0.59011233f, 0.56885445f, -0.55326301f, -0.01691008f, 0.51751637f, 
    -0.00392248f, -0.09037166f, 0.13605234f, 0.21615610f, 0.08923981f, -0.10354447f, -0.17765807f, -0.18944046f, 
    -0.12629099f, -0.02187865f, -0.09468529f, -0.08355460f, -0.09249683f, 0.19382064f, -0.17487368f, -0.63060713f, 
    0.08162994f, -0.14915255f, 0.32945073f, -0.32590711f, 1.03057778f, -0.40724838f, -0.41816044f, 0.17504425f, 
    0.46961308f, -0.31473404f, -0.15769455f, -0.39014906f, 0.11743758f, 0.07893687f, 0.04712401f, -0.02633576f, 
    -0.00187583f, -0.02305960f, 0.14498517f, 0.00245939f, 0.21236186f, 0.16137542f, 0.20577459f, -0.32820502f, 
    -0.44712678f, 0.79987848f, 0.65400338f, -0.51783484f, -0.19095041f, 0.00615103f, -0.14869063f, -0.09401000f, 
    -0.48502570f, 0.22080618f, 0.35594872f, 0.33119848f, 0.06187438f, 0.33267802f, 0.17177764f, 0.10448694f, 
    0.29052886f, 0.03103106f, -0.27895281f, 0.03626169f, 0.24520831f, -0.01939656f, 0.30094948f, -0.39996678f, 
    -0.44100583f, -0.71264672f, 0.74594575f, 0.18609832f, -0.73775178f, 0.36415923f, -0.16158454f, 0.18125133f, 
    -0.31889457f, 0.34531549f, 0.26901418f, 0.15406188f, -0.07001312f, -0.04669311f, 0.23231679f, 0.33638102f, 
    0.21870463f, -0.00937448f, 0.05576326f, -0.38764134f, 0.15115568f, 0.03175084f, 0.21370956f, -0.09307268f, 
    0.03877889f, 0.24585150f, -0.46579489f, -0.45218447f, -0.05292164f, 0.18048610f, 0.11786895f, 0.02469316f, 
    -0.64762753f, 0.59120923f, -0.15794256f, 0.06930778f, 0.18213518f, -0.01229193f, 0.06260662f, -0.10640216f, 
    0.02439382f, -0.09647433f, -0.06345956f, 0.26170561f, -0.22722942f, 0.33859459f, 0.21623392f, -0.22930428f, 
    0.08271904f, 0.06317084f, -0.07444736f, -0.83144146f, -0.21853645f, -0.33993953f, -0.56360751f, 0.29685387f, 
    0.07431629f, 0.66327202f, 0.18281542f, -0.03210636f, 0.01049319f, -0.48479274f, -0.36219719f, -0.13857087f, 
    0.22676486f, -0.03767492f, -0.21437404f, -0.12557955f, -0.26777062f, -0.17442712f, -0.34311807f, 0.15639907f, 
    -0.19756764f, -0.04309374f, -0.09422411f, -0.69523925f, -0.03871047f, -0.18934405f, -0.50011468f, 0.10276767f, 
    -0.03444646f, 0.47238916f, -0.09285592f, 0.15673950f, -0.65325493f, -0.41213936f, -0.00905291f, -0.32196778f, 
    -0.03461367f, -0.26667303f, 0.03582940f, -0.08312007f, 0.13433418f, -0.50072628f, -0.49415565f, -0.11955013f, 
    0.08444558f, 0.43151671f, 0.56190079f, 0.44495973f, -0.61368424f, 1.12166178f, 0.13108546f, -0.91495317f, 
    0.37275934f, -0.22615743f, 0.51836854f, 0.58474559f, 0.02583843f, 0.41179442f, 0.06591190f, 0.10235062f, 
    -0.16361980f, -0.02108516f, 0.13597579f, 0.15222391f, -0.00145204f, -0.00674156f, 0.10728941f, -0.34085867f, 
    0.19987209f, 0.14350300f, 0.17996439f, 0.20190643f, 0.31354436f, 0.50065422f, 0.11713453f, 0.61313409f, 
    -0.00239628f, 0.67779034f, -0.05852221f, -0.73079544f, -0.56696075f, -0.38749489f, -0.49195331f, 0.50583029f, 
    0.37407494f, 0.10933459f, 0.24085790f, 0.14174825f, -0.12987053f, 0.21360025f, -0.40832150f, 0.03633466f, 
    -0.06598646f, -0.01152469f, 0.08217475f, 0.01264729f, 0.07005013f, -0.08030334f, 0.44480234f, -0.32414722f, 
    -0.90158254f, -0.48824832f, -0.41914713f, -0.73431700f, 0.45004311f, 0.09590229f, 0.40734658f, 0.26203290f, 
    0.18656175f, -0.12034598f, 0.00557510f, -0.28626338f, -0.22167340f, 0.11911330f, 0.37341520f, 0.07125586f, 
    -0.24125385f, -0.18390799f, -0.19651185f, -0.03169767f, 0.03278962f, -0.03225440f, -0.01782114f, -0.67388517f, 
    0.81651801f, 0.27457270f, -0.62746894f, 0.50991029f, -0.77282113f, 0.41253769f, 0.64582628f, -0.41819885f, 
    -0.41021603f, -0.19429681f, 0.07094344f, 0.08930971f, -0.18390949f, -0.29208225f, 0.11605872f, -0.22786085f, 
    0.00297723f, -0.07371166f, -0.18870655f, -0.38743600f, -0.34499663f, -0.03807086f, -0.30162665f, 0.28513399f, 
    -0.95580661f, 0.03292658f, -0.09633062f, 0.00807407f, -0.57335156f, 0.71700734f, 0.39659962f, -0.24740088f, 
    0.55358249f, -0.01936312f, 0.33913088f, -0.34693259f, 0.36999211f, 0.20699508f, -0.36500710f, -0.26786759f, 
    -0.21365620f, -0.02022114f, -0.02976804f, -0.34854585f, 0.04184381f, -0.07094216f, -0.03951792f, -0.03368047f, 
    0.03799953f, -0.48285055f, -0.73098278f, -0.80010104f, -0.16533250f, 0.04257844f, -0.19300734f, 0.46886557f, 
    0.62545156f, 0.04637377f, 0.55924559f, 0.05146404f, 0.11639208f, -0.06960323f, -0.25014439f, 0.07197957f, 
    -0.02530536f, 0.21903302f, 0.11861435f, -0.09189064f, 0.02655880f, 0.09502389f, -0.05702180f, 0.14791770f, 
    -0.04360443f, 0.40657818f, 0.98693156f, 0.26336423f, 0.41685963f, -0.49102494f, -0.00576869f, 0.25275207f, 
    -0.46473187f, -0.02725587f, 0.60210586f, 0.64809668f, -0.25482804f, 0.17682564f, -0.00815002f, -0.26708624f, 
    -0.23819080f, 0.09850197f, 0.04308990f, -0.38955310f, -0.22805047f, 0.15621738f, -0.11931127f, 0.12497621f, 
    0.01098856f, -0.11216073f, -0.00783369f, -0.17405297f, -0.04013386f, 0.72863936f, 0.20034678f, 0.17284131f, 
    0.55177128f, 0.59433264f, 0.27297536f, -0.03049291f, 0.46026739f, 0.28185749f, -0.25709558f, 0.30179471f, 
    -0.26987091f, -0.43580908f, -0.00677779f, -0.38408712f, -0.35483873f, -0.31673026f, -0.29970372f, -0.34551352f, 
    -0.13255537f, 0.31900162f, 0.02813629f, -0.10866778f, -0.81179833f, -0.15863933f, -0.87262607f, -0.53255546f, 
    -0.19649506f, 0.50350404f, 0.09297758f, -0.00060181f, 0.11887886f, 0.53687173f, -0.13250686f, -0.40418160f, 
    0.21987508f, -0.17887820f, 0.30478257f, 0.10405571f, 0.18887231f, -0.03242900f, 0.01546971f, -0.11467271f, 
    -0.03873804f, -0.09426241f, -0.21237682f, 0.14700885f, 0.07256223f, 0.47516024f, -0.18167160f, -0.08441319f, 
    -0.76872230f, -0.14711237f, 0.66406244f, -0.66112399f, -0.29084143f, -0.24803253f, -0.53356171f, 0.29768744f, 
    0.42804658f, 0.35896066f, -0.00131622f, 0.12080138f, -0.10893577f, -0.09339112f, -0.03538693f, -0.06621690f, 
    0.08639286f, 0.21870826f, 0.15627050f, 0.12527524f, 0.46449047f, -0.02346051f, -0.72143316f, 0.56483972f, 
    0.63024801f, -0.25500259f, -0.29156518f, -0.87161672f, 0.36643326f, -0.03759122f, -0.10699816f, -0.55635381f, 
    -0.19724360f, -0.05606956f, -0.05809936f, 0.11486519f, 0.26441237f, 0.17222598f, 0.15251482f, 0.13471803f, 
    -0.05365898f, 0.04191427f, 0.14666376f, 0.14358421f, 0.02315387f, -0.19938050f, -0.24482781f, 0.63198388f, 
    -0.36064690f, 0.80793041f, 0.39983723f, 0.33189583f, 0.33456922f, -0.46324092f, 0.03886155f, 0.17515250f, 
    -0.39394292f, 0.19273086f, -0.45544887f, -0.10613666f, 0.11050055f, -0.24745058f, 0.37173039f, 0.01851217f, 
    0.21937369f, -0.09544201f, 0.13051285f, -0.49788088f, -0.20864461f, 0.04575409f, -0.13080600f, -0.10079590f, 
    -0.52236015f, 0.78170347f, 0.43891883f, -0.45471007f, -0.25628075f, 0.54852903f, -0.29804918f, -0.27584174f, 
    -0.03253384f, -0.75080025f, -0.16161495f, 0.12572829f, 0.11135309f, -0.14507930f, 0.12359621f, -0.24747908f, 
    0.19841707f, -0.21931334f, -0.15660858f, 0.25973457f, 0.18846038f, -0.11589528f, -0.37231639f, 0.21302751f, 
    -0.02310122f, -0.48634210f, -0.60474992f, 0.25592175f, 0.98113716f, 0.13785326f, 0.21463218f, -0.35273054f, 
    0.45486560f, 0.12726228f, -0.52261657f, 0.22228119f, -0.34604836f, -0.45513621f, 0.13541692f, -0.24064277f, 
    0.03784889f, 0.09895968f, 0.10435110f, 0.09666869f, 0.29435208f, 0.06419876f, 0.30448934f, 0.17758256f, 
    0.22363481f, -0.25243282f, 0.60435373f, 0.79505479f, 0.51499295f, -0.21243161f, -0.10091573f, -0.13443415f, 
    -0.58661151f, -0.40390354f, -0.55522442f, -0.22757462f, -0.30148786f, -0.15550567f, -0.08855230f, -0.30412331f, 
    -0.43427339f, -0.34956723f, -0.30341747f, -0.07219362f, -0.37662590f, -0.22819260f, 0.05284751f, 0.02184788f, 
    0.25513005f, -0.21624032f, -0.01003298f, 0.87901437f, -0.75583428f, -0.27273646f, -0.69109064f, 0.32057449f, 
    0.90063232f, 0.07734866f, 0.43997848f, 0.30849501f, -0.02674796f, -0.08991998f, 0.16777815f, -0.24652655f, 
    -0.17234476f, -0.06653796f, -0.12408461f, -0.15748078f, -0.12899116f, -0.01848600f, -0.15436193f, -0.04376415f, 
    0.00226743f, -0.00155365f, 0.06542787f, 0.03894611f, -0.68007427f, -0.94565845f, -0.59762782f, -0.14208178f, 
    0.11124096f, 0.24983071f, 0.66450763f, 0.48825344f, 0.00615394f, -0.27746835f, 0.15822892f, 0.26840171f, 
    0.06634500f, 0.13159505f, -0.27337950f, -0.14777920f, 0.15993968f, 0.42258093f, 0.40071529f, 0.04068349f, 
    -0.06228170f, -0.17479065f, -0.34676942f, -0.09396638f, -0.25810075f, 0.22638702f, -0.27412146f, -0.83917540f, 
    -0.55583793f, -0.32704499f, 0.40300733f, -0.23335531f, -0.28634492f, -0.03079196f, 0.44885910f, -0.15011145f, 
    -0.39142388f, -0.08238767f, -0.00595444f, -0.23756813f, -0.25686225f, -0.20675252f, -0.02565778f, 0.36676991f, 
    0.07182176f, 0.44675022f, -0.11908560f, -0.10803823f, -0.05537138f, 0.32392663f, -0.45902607f, -0.24933802f, 
    0.27683961f, 0.16145086f, 0.69988489f, -1.03820848f, -0.22660188f, -0.27961859f, -0.50474250f, -0.40464494f, 
    0.30253151f, -0.02180340f, 0.09334444f, 0.36800936f, 0.04644632f, -0.08651827f, 0.24098162f, 0.23275454f, 
    0.01037235f, 0.27832410f, 0.04011215f, -0.19993843f, -0.44915658f, -0.01783556f, 0.38203594f, -0.41249406f, 
    -0.68195140f, -0.31896022f, -0.37958798f, -0.45639527f, -0.63308144f, -0.18653113f, 0.21766557f, -0.19479837f, 
    0.05050476f, 0.23060764f, 0.23206979f, 0.07691325f, 0.25795594f, 0.08346611f, -0.47112748f, -0.24903464f, 
    0.20167772f, -0.13186842f, -0.09397299f, 0.23614989f, 0.15197778f, -0.48123908f, 0.17343040f, -0.10800678f, 
    -0.92739367f, 0.61194646f, 0.50345570f, 0.54911244f, -0.12687482f, 0.24713331f, 0.89862275f, -0.26530772f, 
    -0.16927701f, 0.35251254f, -0.32570773f, -0.30030549f, 0.43892923f, -0.28384244f, 0.10130168f, 0.06586783f, 
    -0.02511465f, 0.22119610f, -0.15949982f, -0.08933109f, 0.17646058f, -0.21684523f, -0.22082503f, -0.04492934f, 
    -0.18587732f, 0.00619379f, -0.83130574f, -0.54929268f, 0.25619197f, 0.00166750f, -0.62447470f, 0.79277158f, 
    0.41977784f, 0.03445994f, -0.14251822f, 0.25693050f, -0.09238862f, -0.21385550f, -0.24498992f, 0.35471353f, 
    -0.19261481f, 0.07638374f, 0.07194454f, -0.08983775f, -0.27322719f, 0.27031419f, 0.32840449f, -0.54291296f, 
    0.69784820f, -0.33918279f, 0.94532764f, 0.54126614f, 0.51489305f, 0.96816289f, 0.72279888f, 0.41046718f, 
    -0.04906778f, -0.39220279f, 0.37055045f, -0.02376150f, -0.04707086f, 0.01204531f, -0.24926677f, 0.24069875f, 
    -0.12889551f, 0.32870680f, 0.12963434f, 0.03414584f, 0.18489383f, -0.17729516f, 0.28094527f, -0.07513741f, 
    0.01052576f, -0.03732683f, 0.56039941f, -0.29321823f, 0.30139780f, 0.76536155f, 0.14015530f, 0.27866778f, 
    0.64160824f, 0.68731457f, 0.41005194f, 0.13773839f, 0.13720341f, -0.40698820f, 0.16213411f, 0.28161037f, 
    -0.08123851f, -0.39395887f, -0.28224084f, -0.08702742f, -0.05469010f, -0.32464129f, -0.31253770f, -0.12454168f, 
    -0.37818691f, -0.01979212f, 0.27777785f, -0.16388829f, 0.00109334f, 0.78184491f, -0.52096242f, -0.73020709f, 
    0.20871644f, -0.38126725f, -0.72266668f, 0.06442323f, -0.30770320f, -0.22707830f, 0.26994604f, -0.20462093f, 
    -0.45890650f, -0.04523957f, -0.21057513f, 0.06464432f, 0.09124196f, 0.02153975f, 0.02178714f, -0.06112156f, 
    0.17360532f, -0.14044359f, 0.10716878f, -0.33263874f, 0.21732448f, 0.63904315f, 0.38039571f, -0.16582367f, 
    0.12501302f, 0.22701763f, -0.54812092f, -0.51240838f, -0.21652095f, -0.19832438f, -0.03165218f, -0.27124617f, 
    -0.31801465f, 0.49295700f, -0.14246000f, 0.21573836f, 0.34694570f, 0.06538033f, 0.34709865f, 0.42033228f, 
    0.49559766f, -0.22794041f, 0.03035741f, -0.16130790f, -0.19287983f, 0.07195356f, 0.87539726f, -0.08268074f, 
    -0.19802450f, -0.62304777f, 0.90098560f, 0.20030990f, -0.06340127f, -0.36666030f, 0.02742457f, 0.26185715f, 
    -0.22488755f, 0.44286019f, -0.28741872f, 0.26074824f, 0.17352672f, -0.32818708f, -0.09456083f, -0.19634329f, 
    0.40692216f, 0.12909056f, 0.11382652f, 0.01680278f, -0.27684826f, -0.05766282f, 0.04416412f, 0.80845004f, 
    0.47896370f, 0.21666448f, 0.29333806f, -0.47719902f, -0.43709135f, -0.42778993f, -0.40772972f, 0.26234826f, 
    0.11730658f, 0.06297451f, 0.16100517f, 0.25056019f, -0.21192992f, 0.18720725f, -0.23993331f, 0.00099948f, 
    0.01439054f, -0.25861320f, 0.46794057f, 0.37785676f, 0.14235300f, 0.20432539f, -0.01383441f, 0.10249177f, 
    0.55490804f, 0.33966985f, -0.69957513f, 0.81655949f, 0.68404555f, 0.35533062f, 0.43657452f, 0.52651405f, 
    0.54518610f, -0.16638893f, -0.04137532f, -0.30988395f, 0.32714796f, -0.22379287f, 0.16881159f, -0.08572732f, 
    -0.36994508f, 0.18751961f, -0.24439144f, 0.21697244f, 0.29345915f, -0.20903881f, 0.26773891f, 0.26585779f, 
    0.15832575f, 0.66174865f, 0.56712222f, 0.18997800f, 0.79587483f, 0.82588220f, 0.47672054f, 0.22206335f, 
    0.34758618f, -0.05109851f, 0.34713727f, -0.54442322f, -0.11358938f, -0.44131318f, -0.10268933f, 0.03408932f, 
    -0.13930237f, -0.04709657f, 0.05153606f, -0.07384824f, 0.17958714f, 0.12725824f, -0.11303884f, 0.20767850f, 
    -0.03942106f, 0.10977521f, 0.38650724f, 0.38208297f, 0.69742918f, 0.82924455f, 0.42983565f, -0.63766879f, 
    0.08037492f, -0.69988412f, -0.23960401f, 0.01604924f, 0.22577526f, 0.16999252f, 0.07708240f, 0.01686554f, 
    -0.31595343f, -0.31846994f, -0.05169247f, 0.22245868f, -0.15620145f, 0.05588048f, -0.19849184f, 0.37330994f, 
    -0.26492816f, -0.13043046f, 0.16354388f, 0.58442652f, -0.08390356f, -0.37544188f, -0.35226715f, 0.88551188f, 
    0.76522732f, -0.16124031f, 0.43025786f, 0.03646741f, 0.27273074f, -0.26700309f, 0.07882234f, -0.22668824f, 
    0.23185265f, -0.27525586f, -0.07935221f, -0.29745463f, 0.10744101f, 0.25664249f, -0.12534632f, 0.14017978f, 
    0.05343834f, -0.06731433f, -0.32421777f, -0.32723606f, -0.63770759f, 0.81001073f, -0.81435692f, 0.17215830f, 
    -0.65606010f, 0.90122372f, -0.43790683f, -0.61259276f, -0.19686870f, -0.46273652f, -0.02216034f, -0.02505868f, 
    -0.11311803f, 0.38260078f, 0.03307424f, -0.27183905f, -0.01084620f, -0.14275098f, -0.01501471f, -0.26723844f, 
    -0.03388996f, -0.00187704f, 0.35225224f, -0.25337556f, -0.03075237f, -0.18902247f, -0.66401190f, -0.12245912f, 
    -0.59310633f, -0.64371598f, -0.00622945f, -0.62751466f, -0.48926538f, -0.31944472f, -0.05811793f, 0.15793148f, 
    -0.02993406f, 0.15980951f, 0.28400618f, -0.20406823f, 0.31127757f, 0.32866165f, 0.14009072f, 0.14608376f, 
    0.22815119f, 0.10638355f, -0.02227761f, 0.20280889f, -0.13543802f, 0.22245488f, -0.44567564f, 0.61327034f, 
    0.21371742f, -0.34776124f, 0.67943871f, -0.66419691f, -0.12432328f, -0.10278841f, -0.44133335f, -0.45315742f, 
    0.13516182f, 0.37077382f, -0.23443079f, 0.06501705f, 0.12283447f, -0.23943204f, -0.16108645f, -0.25189689f, 
    -0.27528271f, 0.05059382f, 0.17588371f, 0.27667695f, 0.30384287f, 0.35242683f, -0.18786645f, -0.14331982f, 
    0.14257647f, -0.47572160f, -0.75377452f, -0.48951626f, 0.72834796f, 0.57585049f, 0.15946877f, 0.61476302f, 
    0.50866538f, 0.01985484f, -0.38778344f, -0.45718414f, -0.45261252f, -0.44138265f, 0.07531795f, -0.18073082f, 
    -0.18363748f, 0.06267407f, 0.24766187f, -0.07921128f, -0.50656575f, -0.31865078f, -0.28587693f, -0.01952920f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14145201f, 0.16715589f, 0.10185999f, 0.01443792f, 0.14495510f, 0.16448988f, 0.00811967f, -0.06166602f, 
    0.02365762f, 0.21000360f, 0.15592380f, 0.23548289f, 0.20361097f, 0.12584910f, 0.20020810f, 0.05693550f, 
    0.06539828f, 0.13709354f, 0.30149907f, 0.09937422f, 0.01606976f, 0.21501899f, 0.13262302f, 0.11819537f, 
    0.20282081f, 0.16748469f, 0.12705472f, 0.11890327f, 0.08405042f, 0.01571955f, -0.02118388f, 0.29286480f, 
    0.18243439f, -0.00863594f, -0.00414650f, 0.10923389f, 0.06487715f, 0.22706553f, 0.22963472f, 0.16753212f, 
    0.01735179f, 0.05414907f, 0.02725970f, -0.06201309f, 0.24620858f, 0.26934528f, 0.18644360f, 0.17555845f, 
    -0.10225363f, -0.01373797f, 0.34537920f, -0.11009664f, 0.24022384f, 0.04923039f, 0.13785864f, 0.02628461f, 
    0.19377173f, 0.20855421f, 0.18476693f, 0.09471688f, 0.13490644f, 0.24201941f, 0.18584101f, 0.02566555f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.10741156f, -0.14056708f, -0.10994642f, -0.00737828f, 0.04125240f, -0.01476817f, 0.03670415f, 0.03018460f, 
    -0.00149449f, 0.02193227f, 0.00417226f, -0.09201150f, -0.23017798f, 0.07854503f, 0.12534165f, -0.13924330f, 
    0.03890826f, 0.11000954f, 0.02383180f, -0.05771256f, 0.02400225f, 0.00846889f, 0.07840271f, 0.10654382f, 
    -0.26191372f, -0.13274199f, 0.25980702f, -0.08655236f, 0.00971070f, 0.01033923f, 0.01923623f, -0.18156146f, 
    0.06837305f, 0.02051349f, -0.00965465f, -0.00506872f, 0.41935214f, -0.05104023f, 0.02553710f, -0.13267013f, 
    -0.11886176f, -0.08330173f, 0.00140141f, -0.04845838f, 0.00401408f, 0.06380728f, 0.06093331f, 0.03287813f, 
    -0.14561193f, 0.15713428f, -0.21097243f, 0.15466681f, 0.08784834f, 0.05234004f, -0.05128697f, 0.02570714f, 
    -0.05578963f, -0.00827319f, -0.02911711f, -0.06101536f, -0.00345793f, -0.04308111f, -0.13629487f, 0.10534122f, 
    -0.12471815f, 0.02592030f, 0.01431033f, -0.01324355f, 0.05059297f, 0.06641015f, -0.08828938f, 0.06251264f, 
    -0.17890446f, 0.16550435f, -0.02977465f, -0.06137522f, -0.07991371f, 0.04765869f, 0.01748815f, -0.04807489f, 
    -0.02738535f, 0.02590236f, -0.04260806f, 0.02470598f, -0.09653875f, -0.05048341f, -0.00088269f, 0.00041590f, 
    0.05217476f, 0.04128674f, 0.02012949f, 0.03014903f, -0.05068320f, 0.01613916f, 0.02003590f, 0.07425665f, 
    -0.04833566f, -0.01580062f, -0.03992472f, 0.02952970f, -0.17842685f, -0.12176409f, 0.04385215f, -0.10802551f, 
    -0.02859307f, 0.08087391f, -0.09188749f, 0.01962581f, 0.24298640f, 0.10285558f, 0.00365460f, 0.31197220f, 
    -0.14145328f, 0.05527222f, -0.05930134f, 0.07102656f, 0.06434039f, 0.01092947f, 0.00631486f, 0.00187457f, 
    0.01573303f, 0.10021961f, 0.01147170f, -0.04833915f, -0.06182165f, -0.03944733f, 0.01414980f, -0.06133205f, 
    -0.15129314f, -0.13219802f, -0.10439594f, 0.02686892f, 0.12297139f, 0.02279878f, -0.07566523f, 0.18721613f, 
    -0.17724307f, 0.03836436f, -0.06079419f, 0.02937419f, -0.08212578f, 0.01027779f, 0.17126465f, -0.09857724f, 
    -0.46499628f, 0.28831044f, 0.10883826f, -0.43972513f, -0.07194478f, 0.00306590f, -0.04390427f, 0.09011422f, 
    -0.01044101f, -0.10855696f, -0.00473387f, -0.01972359f, -0.19942957f, -0.16091116f, 0.12883691f, -0.09249025f, 
    0.03186254f, 0.03176658f, 0.02971180f, 0.01392817f, 0.08460872f, 0.04447420f, -0.02548337f, -0.02837780f, 
    -0.17985567f, -0.11630169f, 0.00479816f, 0.17059992f, 0.05022351f, 0.04909008f, -0.05304569f, -0.02126909f, 
    -0.01188299f, 0.05917454f, -0.01850914f, -0.12016912f, 0.07267603f, 0.02166353f, -0.02697186f, 0.03337909f, 
    -0.17241049f, -0.01101546f, 0.05120739f, 0.00561376f, 0.01283024f, -0.05389877f, -0.01762728f, 0.02965734f, 
    -0.19347531f, 0.10578022f, -0.00402585f, -0.17964609f, -0.01427048f, 0.05842894f, 0.06593465f, -0.00262857f, 
    -0.01920893f, -0.03511422f, -0.01510284f, 0.03925155f, 0.01128231f, 0.13439417f, -0.05526739f, 0.10845727f, 
    -0.21294799f, -0.04838378f, -0.07404220f, -0.01676103f, -0.06321006f, 0.09224819f, -0.15812400f, -0.07492882f, 
    0.17381428f, -0.07232223f, -0.07733461f, -0.01562480f, 0.01698018f, -0.10005782f, -0.15275292f, 0.07515829f, 
    0.01077705f, 0.02685707f, -0.02179422f, 0.04114092f, -0.24170877f, 0.05273201f, -0.04435731f, 0.25243780f, 
    -0.03941121f, -0.04909327f, -0.04690196f, -0.09768552f, 0.03981621f, 0.08715830f, -0.00559536f, 0.07325129f, 
    0.14036232f, -0.01146762f, -0.08854838f, -0.13658831f, 0.07301563f, -0.04107662f, 0.05879001f, 0.03539973f, 
    0.03739695f, -0.05149544f, -0.01686426f, 0.09829050f, -0.42251754f, 0.12578142f, -0.02427086f, 0.03295590f, 
    -0.09227709f, -0.04318763f, -0.00226110f, -0.02058134f, 0.05337919f, 0.03106214f, -0.08359008f, 0.05033795f, 
    -0.12043831f, -0.05705173f, 0.21063603f, -0.04913916f, -0.05231477f, -0.08217668f, -0.03910323f, 0.04131275f, 
    0.00063276f, 0.02744474f, 0.01784410f, 0.02798483f, -0.06007855f, 0.05602510f, -0.14605314f, 0.16090335f, 
    0.06627509f, 0.07541268f, 0.04076655f, -0.02743872f, 0.02805941f, 0.09551247f, -0.01777801f, -0.10556043f, 
    -0.17324156f, 0.04378113f, 0.00743761f, 0.09380095f, 0.06037078f, 0.11871921f, 0.03634911f, -0.02151774f, 
    0.05259318f, 0.10825521f, -0.00218149f, -0.02364812f, -0.24530099f, 0.01997584f, 0.02222711f, 0.01986587f, 
    0.04011154f, -0.01437710f, 0.05187517f, -0.05007086f, 0.04766600f, -0.01385020f, 0.02722528f, -0.07745492f, 
    0.11869013f, 0.05008988f, 0.01300833f, -0.17751300f, -0.00514054f, 0.01993064f, 0.10384583f, 0.08601781f, 
    0.00176669f, -0.11445707f, -0.06879149f, 0.05007992f, -0.11976923f, 0.03584236f, 0.10395177f, -0.27343902f, 
    0.09523483f, 0.02295211f, -0.06464058f, -0.02006378f, 0.01887663f, 0.03737448f, -0.02232264f, -0.11407878f, 
    0.04012669f, -0.01419465f, 0.15348840f, -0.28072596f, 0.06691995f, -0.06065841f, 0.03059150f, -0.16108328f, 
    0.00228678f, -0.00133365f, -0.06708952f, -0.07352723f, 0.12916762f, -0.01207855f, 0.11366542f, 0.00489522f, 
    -0.12349778f, 0.03665243f, -0.00914253f, -0.10010850f, 0.03220536f, 0.00565122f, -0.00479035f, 0.03933743f, 
    -0.24812604f, 0.10938979f, -0.03150342f, -0.19633894f, 0.01157692f, -0.03825258f, -0.01392256f, -0.13178879f, 
    0.06746643f, 0.08802944f, 0.01446315f, -0.04254491f, -0.29174298f, 0.00873471f, 0.04269390f, -0.10882084f, 
    -0.14966117f, -0.15969552f, 0.05856019f, 0.06773161f, 0.07375113f, -0.05646174f, 0.05256635f, -0.07584093f, 
    0.35764724f, -0.05969252f, -0.11710171f, -0.09558973f, 0.03090619f, -0.00149706f, -0.05364941f, -0.02432920f, 
    -0.00601362f, -0.03187158f, -0.04719956f, 0.05997328f, -0.00880337f, 0.21174149f, -0.08558190f, -0.18600455f, 
    0.16192324f, -0.02666397f, 0.00674756f, 0.06433025f, 0.02839075f, 0.01561958f, -0.01765423f, 0.00862010f, 
    0.27035773f, -0.18068393f, -0.01230296f, -0.14382000f, 0.06470010f, -0.10950992f, -0.08537459f, 0.10434730f, 
    -0.05779518f, -0.08329467f, 0.03896182f, 0.13870519f, -0.04645654f, 0.00319158f, 0.09138350f, 0.08052016f, 
    -0.17937572f, -0.00260407f, -0.02207675f, 0.02861049f, -0.04726508f, 0.03653184f, 0.01286094f, -0.07605791f, 
    0.38272732f, -0.01979041f, 0.01747364f, -0.18215606f, 0.08041786f, 0.00763489f, -0.04736871f, 0.10260827f, 
    0.06716919f, -0.01690265f, -0.00358883f, -0.02929937f, -0.02604859f, -0.15984295f, 0.14476049f, -0.22592320f, 
    0.01622321f, 0.06476898f, 0.08629110f, -0.10948171f, -0.07373317f, -0.07523619f, 0.02065631f, 0.02185875f, 
    -0.17769197f, 0.12919688f, -0.03302315f, 0.13787532f, 0.01218303f, -0.02528078f, -0.00593516f, -0.02297616f, 
    0.00043848f, 0.02682182f, 0.04206363f, -0.07028150f, 0.20760417f, -0.08424053f, -0.02865134f, 0.12179010f, 
    -0.05644716f, 0.03481860f, 0.05346606f, 0.10044478f, 0.02592545f, -0.04349560f, -0.11691231f, -0.07266371f, 
    -0.29242826f, 0.17268802f, 0.22176802f, -0.00651400f, -0.03364575f, -0.02265469f, 0.18564987f, -0.03965966f, 
    0.01741203f, -0.07026964f, -0.07013380f, -0.00128369f, -0.07368527f, -0.05025071f, -0.05421696f, 0.21285249f, 
    -0.01884198f, 0.04924584f, 0.00894045f, -0.00888001f, 0.04840335f, -0.18262465f, 0.17715563f, 0.01536511f, 
    0.05341279f, 0.13036393f, 0.12909023f, -0.13430859f, -0.10235634f, -0.15043530f, -0.04141165f, 0.11112703f, 
    -0.05122958f, -0.03063953f, -0.03970315f, 0.07966547f, 0.32794055f, 0.15172915f, 0.09200010f, -0.11114453f, 
    0.08960040f, 0.01335038f, 0.03762056f, -0.05732913f, -0.17097341f, 0.02118630f, 0.03761959f, 0.02837288f, 
    -0.25285265f, 0.10348785f, -0.00012720f, -0.27675280f, 0.04249184f, -0.01537974f, 0.09314774f, 0.09680608f, 
    0.06048060f, -0.00111257f, 0.00647743f, 0.02417334f, 0.02225658f, -0.22420488f, -0.03608197f, -0.32319915f, 
    0.10882282f, -0.15880322f, 0.02972027f, 0.05765931f, -0.01465049f, -0.01544864f, -0.00604983f, 0.04095709f, 
    -0.10040317f, -0.09756298f, -0.04363017f, -0.00077899f, -0.05201996f, -0.11823979f, 0.02349916f, 0.05503510f, 
    -0.09996060f, -0.09147223f, -0.11379077f, -0.01850877f, -0.36187539f, -0.28821796f, -0.13445129f, 0.02604736f, 
    -0.03457278f, -0.01299208f, -0.07488863f, 0.00730541f, 0.02405337f, -0.10394109f, -0.06955204f, 0.06240839f, 
    0.26418677f, 0.08652736f, 0.11011831f, 0.10975380f, 0.00250186f, 0.01606253f, 0.06127853f, -0.00793364f, 
    0.12585537f, -0.02248527f, 0.01630301f, 0.01661105f, -0.39179245f, 0.26026687f, -0.08976258f, -0.00526447f, 
    0.08032597f, 0.11361904f, -0.07216363f, -0.12836158f, -0.00521375f, -0.14098737f, -0.10407200f, -0.07817520f, 
    0.08183822f, -0.08220993f, -0.05023897f, 0.18063165f, -0.09254324f, -0.05719412f, -0.02197436f, 0.01713028f, 
    -0.02916482f, -0.03741276f, 0.03035185f, -0.06014489f, -0.16156867f, 0.02549935f, -0.00196258f, 0.11515055f, 
    0.02444630f, -0.08137183f, 0.07654350f, -0.03843498f, -0.04656154f, -0.04534828f, 0.02960053f, -0.02296485f, 
    -0.02797823f, 0.01072667f, 0.22890592f, -0.13299236f, -0.06062885f, -0.11866669f, 0.05333139f, 0.09989223f, 
    0.03709049f, -0.04834111f, 0.06942526f, -0.08700108f, 0.14902277f, 0.14648265f, 0.11292891f, -0.00668205f, 
    -0.07170687f, -0.04247199f, -0.07682353f, 0.10020065f, 0.04342030f, 0.05025028f, 0.01362540f, 0.09699340f, 
    0.13970415f, -0.23735130f, 0.20238757f, -0.49510971f, -0.01991616f, 0.07505014f, 0.04280872f, -0.01166951f, 
    -0.10904899f, 0.03878090f, 0.10443774f, 0.04558236f, 0.09389199f, -0.10462195f, -0.08462410f, 0.09526303f, 
    -0.00261232f, -0.09989768f, -0.01467284f, 0.05199115f, 0.02350756f, 0.00520317f, 0.02129032f, -0.04589714f, 
    -0.00369138f, 0.16958274f, -0.13326144f, 0.03310314f, -0.20767614f, 0.09893329f, -0.04225428f, -0.02549043f, 
    -0.07942045f, 0.10540759f, 0.02393969f, 0.01266465f, 0.06342173f, -0.06730296f, 0.08122630f, 0.21239957f, 
    -0.15416494f, 0.00392979f, -0.02175569f, 0.02921386f, -0.04104076f, -0.08033381f, -0.02213828f, 0.00063552f, 
    0.07551852f, 0.06001155f, -0.19830680f, 0.16568360f, -0.18006988f, -0.03646094f, -0.01109525f, 0.00611325f, 
    0.01150483f, 0.02609318f, -0.20933463f, 0.00449550f, 0.23398091f, -0.12430286f, 0.23791765f, -0.03715460f, 
    -0.01502829f, 0.09191230f, 0.06609758f, -0.06932338f, 0.03606255f, -0.02603836f, -0.07633520f, 0.04503842f, 
    0.19395682f, 0.07979229f, -0.10892444f, -0.03120161f, 0.02419321f, -0.03973697f, -0.03935423f, -0.00375447f, 
    -0.00345396f, 0.07043850f, -0.06822813f, 0.04056455f, -0.33623978f, -0.27660969f, 0.09939392f, -0.07469667f, 
    -0.04380132f, -0.03314191f, 0.00172165f, 0.03528490f, -0.10237093f, 0.00809400f, -0.12114671f, 0.05881213f, 
    -0.08875974f, 0.10261683f, 0.07699333f, -0.11904629f, 0.07742443f, 0.00977044f, -0.06375381f, 0.01744023f, 
    -0.04096031f, -0.15838723f, 0.02365106f, -0.02086984f, 0.32472998f, 0.15918623f, 0.03219333f, -0.21089265f, 
    0.05396843f, 0.04328747f, 0.07973266f, 0.00880161f, -0.00908731f, 0.02102937f, 0.01560264f, 0.02517977f, 
    -0.20602122f, -0.04282881f, -0.14440331f, -0.32210648f, -0.12229178f, 0.01447701f, 0.03830387f, 0.03880735f, 
    0.06383524f, -0.04741811f, 0.06468543f, 0.08969536f, 0.13006602f, -0.04816211f, -0.04876416f, -0.03247370f, 
    -0.03248915f, -0.05915287f, -0.11111868f, 0.06524912f, -0.09430625f, -0.00817833f, -0.10794057f, -0.15783273f, 
    0.00678455f, -0.02265996f, -0.11148552f, -0.13184464f, -0.03424270f, -0.01260878f, -0.00009615f, 0.04744606f, 
    0.02862086f, 0.00630908f, -0.02061528f, -0.09215813f, -0.37730494f, -0.09884445f, 0.01245400f, -0.14141648f, 
    0.12165108f, -0.03094662f, -0.00652439f, 0.02758353f, 0.07484490f, -0.11602117f, 0.04114159f, -0.05780277f, 
    0.06948475f, -0.04421831f, -0.11680094f, 0.14357215f, 0.02070495f, 0.06780075f, -0.06945820f, -0.06713258f, 
    -0.09924059f, -0.12588070f, -0.05247962f, -0.11102038f, 0.23234469f, 0.02330497f, 0.00878362f, 0.09547089f, 
    -0.02554953f, -0.09350544f, -0.01888333f, -0.08528028f, 0.00293298f, -0.04245443f, 0.14379506f, -0.03913252f, 
    0.04952741f, -0.07939118f, -0.02591803f, -0.19630066f, 0.12946549f, -0.14066164f, 0.09835906f, -0.06860528f, 
    -0.01869179f, 0.00461036f, 0.13762590f, -0.17303374f, 0.02430499f, -0.00447100f, 0.00909692f, -0.00608076f, 
    0.06531074f, -0.05326449f, -0.19936083f, -0.03602119f, 0.03307768f, -0.11688207f, -0.01442759f, -0.23675208f, 
    0.19471550f, 0.06597149f, -0.08101705f, 0.08779441f, -0.03422482f, 0.02476684f, 0.04174611f, -0.04438085f, 
    -0.02811348f, -0.18381456f, -0.02117220f, 0.19883928f, -0.52880180f, 0.08456326f, -0.05268543f, -0.05764251f, 
    -0.00901580f, 0.01067481f, 0.05028094f, -0.01384075f, -0.04251260f, -0.01773256f, -0.02071732f, -0.04630644f, 
    -0.05490093f, 0.11165056f, -0.10347049f, 0.20142460f, -0.07472041f, -0.01288283f, -0.02787257f, 0.02969131f, 
    0.07025180f, 0.13571458f, 0.11860419f, 0.10341417f, 0.21739925f, -0.07480451f, 0.14697513f, 0.12797178f, 
    -0.13133962f, -0.11520506f, 0.03074474f, 0.04862921f, 0.09225417f, 0.07555841f, -0.26946923f, 0.09885181f, 
    0.27489442f, 0.08690513f, -0.12412373f, -0.23002051f, 0.00839748f, -0.04623776f, 0.04509636f, -0.04501151f, 
    -0.09869303f, 0.09915262f, 0.05000696f, 0.14999263f, -0.10345323f, -0.04388833f, 0.00407815f, -0.10818581f, 
    0.06043806f, 0.03566813f, 0.05156421f, -0.00222271f, 0.00775517f, 0.03446478f, 0.05449156f, 0.01687977f, 
    -0.26342550f, 0.08072590f, -0.19198027f, -0.05729795f, -0.00625750f, 0.02874382f, 0.01803532f, 0.03872178f, 
    0.00399709f, 0.05740387f, 0.01699405f, -0.03327233f, 0.11864880f, -0.00492228f, -0.02980082f, 0.09242816f, 
    0.08246586f, -0.02445698f, -0.03684674f, -0.02252936f, 0.00353124f, 0.09424348f, 0.03547575f, 0.02015609f, 
    0.10827514f, -0.12201846f, -0.17680189f, 0.01246900f, -0.04877231f, -0.12379672f, -0.04331274f, 0.04426626f, 
    0.06568424f, -0.00593061f, -0.16796753f, -0.08692002f, 0.12881568f, 0.01101405f, 0.07288063f, 0.15841848f, 
    -0.11266995f, 0.09099708f, 0.15378298f, 0.05408059f, -0.12819828f, -0.13305920f, 0.04064211f, 0.04368060f, 
    0.23840138f, 0.03434520f, 0.07895213f, 0.07359495f, 0.00731480f, -0.12950833f, 0.01343150f, -0.06871737f, 
    -0.14313796f, 0.05201571f, -0.05438330f, -0.04685859f, 0.15263845f, -0.20176581f, 0.05055733f, 0.05687749f, 
    -0.03325801f, 0.09129840f, -0.06857304f, 0.04323658f, -0.06713212f, 0.03057460f, -0.09911549f, -0.12374725f, 
    -0.44842881f, -0.00078860f, 0.05271523f, -0.05923028f, -0.15436172f, 0.05750000f, 0.09037749f, -0.10368027f, 
    -0.08097576f, 0.08110841f, 0.00140736f, -0.02149883f, 0.24015030f, -0.04195821f, -0.05207093f, 0.12211751f, 
    -0.13284223f, 0.05208101f, -0.02786954f, 0.03215201f, -0.10626662f, -0.01237502f, 0.00072157f, -0.00684896f, 
    0.15524310f, -0.08306784f, -0.16900872f, -0.07809860f, -0.07217060f, 0.05027790f, 0.00605446f, 0.05612728f, 
    0.16843805f, 0.03276531f, -0.08138143f, 0.04016061f, -0.32207814f, -0.02013582f, -0.22603783f, 0.03074624f, 
    -0.11366754f, -0.09192508f, -0.02418250f, -0.02898937f, 0.02907972f, -0.07990611f, 0.04939184f, 0.16370936f, 
    -0.31354648f, 0.16591151f, -0.23100701f, 0.18708415f, -0.09520850f, -0.03895293f, -0.02369207f, 0.05404362f, 
    0.04374726f, -0.02062112f, -0.03727739f, 0.10896128f, 0.17001717f, -0.18349099f, -0.00426201f, 0.03705927f, 
    -0.04855110f, 0.00624581f, -0.05696186f, -0.01272435f, -0.01085762f, 0.01342255f, -0.04329497f, 0.03730540f, 
    -0.09093710f, 0.02887199f, 0.00425576f, -0.01122557f, 0.00744005f, -0.01838779f, -0.05377930f, -0.05560055f, 
    0.07102516f, 0.06146087f, -0.04681439f, 0.03935507f, -0.22837231f, -0.07347261f, -0.24326633f, -0.18141076f, 
    0.04211971f, 0.01186879f, -0.01601540f, 0.05003112f, 0.08978621f, -0.10075724f, -0.05744733f, 0.11778829f, 
    -0.16261782f, 0.14766917f, -0.08980171f, -0.30038574f, 0.00877177f, 0.15351595f, -0.08780898f, 0.06907783f, 
    0.16180335f, 0.02065372f, 0.05444800f, 0.05601616f, -0.19585148f, -0.05209796f, 0.06540313f, -0.01353411f, 
    -0.01039632f, -0.03361268f, 0.04602306f, 0.01980500f, 0.01552474f, 0.01450793f, -0.01807951f, -0.01470740f, 
    0.27744141f, -0.19025847f, -0.23416820f, -0.07966828f, 0.00626550f, -0.06120397f, 0.00657318f, 0.07521055f, 
    -0.01285921f, -0.13488548f, -0.05711682f, -0.01372490f, -0.03060222f, 0.15115795f, -0.14691408f, -0.24267712f, 
    0.06269237f, 0.07597014f, -0.02846049f, 0.01573010f, -0.14021623f, -0.08288764f, 0.00951954f, 0.03518146f, 
    -0.46868974f, 0.05913476f, 0.01158416f, 0.09155624f, 0.01183445f, 0.05136233f, -0.01055655f, 0.07350595f, 
    -0.05006805f, -0.04341539f, -0.06638280f, -0.07546315f, 0.27322367f, -0.08259370f, -0.08321609f, -0.13289446f, 
    0.00296647f, -0.02173225f, -0.04362738f, 0.02287559f, 0.08275791f, -0.05855340f, 0.07856555f, 0.02981752f, 
    0.17498264f, -0.04819109f, 0.08730017f, 0.06749200f, 0.01667069f, 0.05154449f, 0.02986223f, -0.06434620f, 
    -0.07675681f, -0.00905503f, 0.04133207f, -0.08755413f, -0.07221373f, 0.12272551f, 0.11982419f, 0.05879588f, 
    -0.05203461f, 0.15243427f, 0.01756939f, -0.03370202f, -0.02239232f, -0.06941291f, 0.03098431f, -0.02088425f, 
    0.00967935f, 0.03180376f, 0.03818696f, -0.16739991f, -0.06670237f, -0.04099314f, 0.05655581f, -0.05030290f, 
    0.03254698f, 0.03674938f, -0.01210189f, 0.08247496f, 0.04416833f, -0.10595622f, 0.05340304f, -0.12631726f, 
    -0.01704368f, -0.01394395f, 0.03483610f, 0.04550891f, 0.03121897f, 0.09852111f, -0.01235425f, -0.01891603f, 
    -0.36160257f, 0.06471325f, -0.13178143f, -0.11507405f, -0.00533243f, 0.00862106f, 0.02581561f, -0.00404251f, 
    0.04021426f, -0.07977022f, -0.01232434f, 0.00624280f, -0.05002601f, 0.10026819f, 0.08337367f, -0.01246045f, 
    0.07325531f, 0.01767912f, -0.03849900f, -0.06058238f, 0.01188725f, -0.05001193f, 0.00007323f, 0.04990508f, 
    -0.18552224f, -0.03492645f, -0.09613813f, -0.06061679f, -0.12843075f, 0.09380874f, -0.07593808f, -0.14264575f, 
    -0.00356267f, 0.03889334f, 0.03555082f, -0.02264970f, -0.14470020f, 0.22619723f, -0.12353253f, 0.21248975f, 
    0.00513436f, 0.00950805f, -0.00246329f, 0.02394962f, 0.02122885f, 0.10518610f, -0.16246052f, 0.05891749f, 
    0.17317945f, -0.04713215f, -0.17895678f, -0.04940040f, -0.02069268f, -0.01485111f, 0.09353023f, -0.00557632f, 
    -0.00863403f, -0.06803314f, -0.03598870f, -0.03188880f, 0.19617201f, -0.48915422f, 0.19057015f, -0.10884832f, 
    0.05315018f, 0.08537918f, -0.14269964f, -0.03459662f, 0.01435198f, -0.03605209f, -0.05407881f, 0.07343739f, 
    0.23475435f, 0.00041842f, -0.17481680f, 0.03534861f, 0.17256783f, -0.03165788f, 0.01749258f, 0.07274922f, 
    0.00053099f, 0.00165288f, 0.01880193f, 0.07468948f, 0.04756171f, 0.02690250f, 0.08586563f, -0.31289223f, 
    -0.08691522f, 0.07594396f, 0.01913857f, 0.04320944f, -0.06723586f, -0.03197590f, 0.00816078f, 0.02471240f, 
    -0.14258869f, -0.03723331f, 0.02791730f, -0.10302656f, 0.12928331f, 0.11102506f, -0.19222178f, 0.02045034f, 
    0.02924266f, 0.05642627f, 0.12645826f, 0.02196245f, 0.06197289f, -0.05140625f, -0.04775741f, 0.04506208f, 
    0.07999412f, 0.04252624f, -0.02200657f, 0.10231200f, -0.01862447f, -0.09224407f, 0.02584331f, 0.00857642f, 
    -0.11119618f, -0.05982969f, -0.11722872f, 0.08020941f, 0.03435207f, 0.03944267f, -0.02358674f, -0.10193940f, 
    -0.06280489f, -0.06377522f, 0.17775373f, -0.04894443f, 0.26296464f, -0.21062618f, -0.08728165f, 0.16256416f, 
    -0.05211703f, -0.07438447f, -0.12387092f, -0.01583556f, 0.22442108f, 0.03580318f, 0.00520892f, 0.21794020f, 
    0.28684860f, -0.03636706f, 0.11703654f, 0.21978135f, -0.17397472f, 0.04039703f, -0.02746496f, 0.03171108f, 
    0.01392651f, 0.05036363f, -0.09483240f, 0.05849933f, 0.03262313f, 0.18747491f, 0.02338470f, 0.03839676f, 
    -0.02564305f, 0.03385225f, -0.00019642f, -0.10209319f, -0.08071560f, -0.06381316f, 0.14467099f, -0.04093029f, 
    -0.06355008f, 0.00396538f, -0.13396327f, -0.41179240f, -0.02721390f, 0.08949192f, -0.05472915f, -0.02654498f, 
    0.05430218f, 0.04236851f, 0.02978589f, 0.00198057f, 0.21354651f, -0.09677076f, -0.06291031f, -0.02452807f, 
    -0.02739009f, -0.00469168f, -0.00920037f, -0.00642578f, -0.01587122f, -0.04277611f, -0.06518663f, 0.03356224f, 
    0.24524009f, -0.05446259f, 0.08014277f, 0.00345044f, 0.08287176f, -0.10778892f, -0.16634744f, 0.07556383f, 
    -0.03460601f, -0.03723028f, -0.11854644f, 0.01761605f, 0.10823186f, -0.01070858f, -0.05279170f, 0.08309371f, 
    -0.04636706f, 0.08406131f, 0.07807090f, 0.07063393f, -0.18101923f, 0.02344181f, 0.04292599f, 0.04213963f, 
    0.08132101f, -0.02169783f, 0.09741732f, 0.22819498f, -0.00852883f, 0.05418934f, -0.11765468f, 0.08960002f, 
    -0.02141344f, 0.06243466f, -0.02081979f, 0.05354857f, 0.27009615f, 0.02911406f, 0.05381635f, 0.19105101f, 
    -0.07800644f, 0.05099792f, -0.03621044f, 0.00043330f, -0.01658542f, 0.05941641f, -0.03778112f, 0.12091723f, 
    0.13720043f, -0.01860518f, 0.14207804f, 0.08879978f, -0.07709025f, 0.04649057f, 0.04486258f, 0.01895867f, 
    0.03669298f, -0.08275129f, 0.07126778f, -0.15059970f, 0.20260142f, -0.09526002f, 0.03179245f, -0.16534570f, 
    0.07736914f, -0.09231713f, -0.17226064f, 0.10150593f, 0.05925841f, -0.00337513f, -0.01136386f, -0.00515851f, 
    -0.30760878f, -0.11915129f, -0.11681412f, -0.16848205f, 0.02398253f, -0.12400582f, 0.10885248f, 0.05294931f, 
    0.05701404f, 0.00416041f, -0.11994489f, -0.10847570f, -0.06894505f, 0.13721348f, 0.09939662f, -0.00467316f, 
    0.08693146f, 0.14927012f, 0.18240441f, 0.11057281f, 0.02240810f, 0.06657099f, 0.10260487f, 0.05695843f, 
    -0.05626881f, 0.08273152f, -0.06773494f, -0.19947097f, 0.05392846f, 0.00567156f, 0.03487843f, -0.02418518f, 
    0.02858554f, 0.11969551f, -0.04470502f, -0.03240298f, -0.19144945f, -0.14041026f, 0.05928506f, -0.12024344f, 
    0.06020709f, -0.05328588f, -0.12257452f, -0.00951185f, -0.02108005f, 0.01021793f, -0.15142846f, 0.06477152f, 
    -0.30844864f, -0.19516943f, 0.06591256f, -0.12352847f, -0.05287001f, 0.06484251f, -0.00170317f, -0.08226231f, 
    -0.08741473f, 0.00311851f, 0.07412101f, 0.03809847f, -0.01943456f, 0.08034737f, 0.03353961f, -0.13026255f, 
    -0.03804993f, -0.06182098f, 0.01922904f, 0.04040364f, 0.02802631f, -0.05170492f, 0.05877700f, -0.07288773f, 
    0.11071505f, -0.06842062f, -0.04735955f, 0.06558439f, -0.00431201f, -0.02094351f, -0.01674100f, -0.00664446f, 
    -0.09813914f, 0.09793246f, -0.08115231f, 0.04996226f, -0.02143318f, 0.02240158f, 0.06011938f, 0.11161317f, 
    0.08316451f, -0.05292539f, 0.01891896f, -0.03256625f, -0.05974028f, 0.01709440f, -0.10572217f, -0.01177061f, 
    0.04719831f, -0.28408566f, 0.03176173f, -0.01403338f, -0.02083609f, 0.02474980f, -0.10550918f, 0.02693270f, 
    0.06448132f, 0.11403809f, -0.05060066f, 0.05396137f, 0.15860738f, -0.22282207f, 0.03015518f, -0.00004808f, 
    0.07182150f, 0.09822608f, 0.04546789f, -0.04282644f, -0.05126079f, 0.01869407f, -0.02266661f, 0.06212454f, 
    -0.07943409f, 0.13278493f, -0.10045493f, -0.11759574f, -0.03691208f, 0.07802302f, -0.03236628f, 0.02470426f, 
    -0.15297684f, -0.03266219f, -0.04224209f, -0.06615947f, 0.08691439f, 0.10746193f, -0.08347636f, -0.03755678f, 
    -0.17164621f, -0.09490204f, 0.11569835f, 0.07433503f, -0.08609936f, -0.06199057f, -0.09472793f, -0.03458632f, 
    0.02658482f, -0.01267691f, -0.07333242f, 0.03343519f, -0.05378920f, -0.00917218f, -0.01184208f, -0.12315843f, 
    -0.00202962f, -0.07210481f, -0.03433280f, -0.13997804f, 0.27508372f, 0.13014525f, -0.40803888f, -0.15772732f, 
    -0.10612494f, 0.09634325f, -0.05597208f, -0.00186141f, -0.03217692f, -0.01956872f, 0.09258921f, -0.03077108f, 
    -0.04980423f, 0.12509111f, -0.12602334f, -0.13336639f, -0.06641451f, 0.03464610f, 0.04889972f, 0.03820528f, 
    -0.03252741f, -0.05835968f, -0.11743674f, -0.00220934f, -0.02186195f, 0.05712766f, -0.05986342f, 0.02535262f, 
    0.06039602f, 0.00720598f, 0.06128716f, 0.04744032f, -0.07509813f, -0.02579778f, 0.11471471f, -0.07600079f, 
    -0.21595994f, -0.04597461f, -0.11121650f, -0.20353930f, -0.00108369f, -0.07039084f, 0.08822908f, -0.01871786f, 
    0.04565703f, -0.05620570f, 0.02091730f, 0.02046076f, -0.05849103f, 0.02504268f, 0.06682434f, -0.10985272f, 
    0.01564697f, 0.02851969f, 0.06974603f, -0.07514282f, -0.00161024f, -0.06899124f, -0.03163190f, -0.20119947f, 
    0.11300683f, -0.11074237f, -0.07000810f, -0.03866329f, -0.12591267f, 0.03951986f, -0.06259284f, -0.08624607f, 
    -0.00714615f, -0.02930972f, 0.01249849f, -0.21778381f, -0.34701777f, 0.05385967f, 0.03613329f, -0.10757007f, 
    0.04179182f, 0.04395078f, -0.07972705f, 0.05234859f, -0.02056893f, -0.06443618f, -0.15193295f, -0.03175013f, 
    0.26703328f, 0.06764411f, 0.13306864f, 0.22912699f, -0.14453356f, -0.11407086f, 0.01037688f, -0.01189163f, 
    -0.01358748f, -0.04837492f, 0.03151629f, 0.09966124f, 0.02269303f, 0.09407616f, -0.04246771f, -0.04026768f, 
    -0.01893768f, -0.00101487f, 0.01394798f, 0.04395396f, 0.00798615f, 0.10677157f, 0.01921389f, 0.03288421f, 
    -0.05451017f, 0.14288352f, 0.07932216f, -0.10643358f, -0.05517267f, 0.03347782f, 0.04085014f, 0.04230122f, 
    -0.02435292f, -0.01065582f, 0.01571668f, -0.02520744f, 0.39541727f, 0.01335393f, -0.06582051f, 0.01017094f, 
    0.01852069f, -0.08545858f, 0.02911450f, -0.00692353f, 0.03597078f, 0.05602070f, 0.04833813f, -0.04226197f, 
    0.14852922f, 0.12582920f, -0.00073745f, -0.13625987f, -0.03101518f, 0.02713162f, -0.00930275f, 0.02819012f, 
    0.06980311f, -0.03379906f, -0.03935244f, -0.03643682f, 0.44596717f, 0.09333521f, 0.04701516f, 0.03617153f, 
    -0.05699892f, 0.03172491f, 0.00250996f, 0.02125405f, 0.06743283f, 0.01172057f, 0.03950799f, -0.08159158f, 
    0.28231242f, -0.18845531f, 0.12428269f, -0.13131645f, 0.02974034f, -0.06790847f, -0.04128909f, 0.05347438f, 
    -0.02768866f, -0.03731213f, 0.03833048f, -0.01370645f, 0.16467063f, -0.09086430f, -0.06803883f, -0.07460912f, 
    -0.21981654f, 0.09274527f, -0.03272109f, -0.00317609f, 0.05298001f, -0.09587377f, -0.02074151f, -0.05494231f, 
    0.07923456f, -0.13619493f, 0.00829754f, -0.14957644f, -0.14140081f, 0.00617051f, 0.00021038f, 0.11367320f, 
    0.04715722f, -0.04087362f, -0.05130830f, -0.13183667f, -0.17085594f, -0.06403669f, -0.05389401f, -0.01892440f, 
    -0.08317454f, -0.01972639f, 0.03197708f, 0.02112743f, 0.02283182f, 0.01353103f, -0.03118647f, -0.08073436f, 
    -0.06390886f, 0.14644857f, 0.05191572f, 0.18313779f, -0.12529594f, -0.04233445f, 0.01191352f, 0.08380401f, 
    -0.02719972f, 0.01309940f, 0.06978343f, -0.05777391f, 0.06136164f, -0.09480890f, -0.22619599f, -0.07630347f, 
    -0.07975012f, -0.02296977f, -0.01895935f, -0.10465103f, 0.05493978f, 0.04476601f, -0.04223174f, 0.02724122f, 
    0.22242038f, -0.02081083f, 0.00101406f, 0.06885321f, 0.07243565f, 0.06101054f, -0.00534621f, -0.03202332f, 
    -0.00960485f, -0.07401588f, -0.01254801f, 0.04541322f, 0.04094348f, 0.12501976f, -0.06880518f, -0.01897706f, 
    0.11021423f, 0.10690075f, 0.04269845f, -0.09270581f, 0.04741217f, -0.06148132f, -0.02572720f, -0.14123607f, 
    0.10879909f, -0.15160580f, 0.05618303f, 0.08443053f, -0.05703447f, -0.08672657f, 0.11035805f, 0.06907508f, 
    -0.03431756f, 0.00120351f, -0.03780193f, -0.07384693f, 0.21855159f, 0.04180811f, -0.24730819f, 0.02271415f, 
    0.09612250f, 0.02698105f, 0.00143236f, -0.08097518f, -0.01652515f, -0.00964455f, -0.05675071f, 0.05897171f, 
    0.23136863f, 0.14946999f, 0.01081130f, 0.01552465f, -0.07966527f, -0.02889849f, -0.06810297f, 0.02403105f, 
    -0.05448103f, 0.04697686f, -0.05870192f, 0.02755457f, 0.28242677f, -0.01361614f, 0.08145118f, 0.29653886f, 
    -0.14930855f, -0.08054503f, -0.04885249f, -0.02182011f, -0.01940610f, -0.04414869f, -0.02892568f, 0.10829940f, 
    -0.08586460f, 0.08353046f, 0.09336714f, -0.00484208f, -0.01963495f, 0.04962289f, 0.14625205f, 0.08976206f, 
    0.00291558f, 0.04622066f, 0.02137204f, -0.02308054f, 0.20714739f, -0.04279457f, 0.05494862f, -0.01895008f, 
    -0.04304370f, 0.05687222f, 0.02240722f, 0.05437673f, -0.09863944f, 0.06399771f, 0.04959990f, -0.08379770f, 
    0.10529358f, 0.15837155f, 0.12537843f, 0.14069858f, 0.00769157f, -0.11935201f, -0.02525607f, 0.06285775f, 
    0.01875366f, -0.04515063f, -0.01523617f, 0.02407204f, -0.43151152f, -0.09930421f, 0.04934236f, -0.23312686f, 
    -0.01949048f, 0.00976769f, -0.01317566f, -0.07246908f, -0.08619247f, -0.02722984f, -0.06121312f, -0.04768781f, 
    0.04830229f, 0.06192424f, -0.32905528f, -0.13704742f, -0.07308947f, -0.02493614f, -0.05748587f, -0.00705283f, 
    0.01854103f, -0.06133929f, -0.08707560f, -0.01789081f, -0.18798141f, 0.03392217f, -0.12157313f, 0.07744421f, 
    0.01035288f, 0.04298865f, -0.07024302f, 0.03200138f, -0.09738857f, -0.00922243f, -0.10825356f, -0.08793407f, 
    -0.09634332f, 0.00695145f, -0.07847607f, -0.11094473f, -0.08001716f, 0.07933499f, 0.03962977f, 0.03099772f, 
    -0.09021439f, -0.07844004f, -0.02852583f, 0.05345374f, -0.26100713f, -0.09355078f, -0.11932234f, 0.04991628f, 
    -0.17424451f, 0.04291761f, -0.17419256f, -0.12003783f, 0.03568675f, -0.03815239f, 0.03972473f, -0.05701370f, 
    -0.25628397f, 0.11219262f, -0.05817136f, -0.18264665f, 0.11871687f, -0.00922935f, 0.07701620f, -0.08994897f, 
    -0.01163965f, 0.13546306f, -0.02618146f, -0.00201679f, -0.33645457f, 0.13500324f, 0.09482677f, 0.04197723f, 
    0.10485762f, -0.01094462f, 0.06203648f, -0.02648067f, -0.02908060f, -0.04039669f, -0.07391516f, 0.03673697f, 
    0.10299525f, 0.00120908f, 0.13573442f, 0.08017392f, -0.22372581f, -0.03810470f, -0.01485419f, 0.02042771f, 
    -0.00623823f, -0.08155628f, -0.11096371f, 0.02498234f, -0.13376287f, -0.10599153f, 0.04941473f, 0.08346979f, 
    0.02574476f, -0.04729354f, 0.01872612f, -0.06982656f, 0.00658575f, 0.00486823f, -0.01727580f, 0.03143685f, 
    0.37736246f, -0.05200374f, -0.23536630f, 0.06919788f, 0.02958216f, -0.04520787f, 0.05550909f, -0.06753314f, 
    -0.13217092f, -0.04348261f, -0.03040409f, 0.04367964f, 0.28411698f, -0.06856371f, -0.08965415f, -0.02131447f, 
    -0.03634080f, -0.07980374f, 0.04703719f, -0.00130161f, 0.09170642f, -0.05865365f, 0.00384038f, 0.01538323f, 
    0.08170539f, -0.14179595f, -0.02197393f, -0.08187110f, 0.07995082f, 0.02818551f, 0.05061749f, 0.01199353f, 
    0.06550574f, 0.00055892f, 0.01303574f, -0.03636744f, 0.41724354f, -0.00172453f, 0.00087219f, 0.14202982f, 
    -0.05006376f, 0.05333825f, 0.01002884f, 0.03224347f, -0.00575045f, -0.02720722f, 0.07783774f, 0.01423447f, 
    0.09920152f, -0.07338371f, 0.03336842f, 0.04567738f, 0.15274835f, 0.06043578f, -0.01339292f, 0.03249654f, 
    0.01424884f, -0.00268492f, 0.04684924f, -0.02413864f, 0.21176240f, -0.05213373f, 0.01593680f, -0.03627601f, 
    -0.04229185f, 0.02888307f, 0.05394027f, 0.01982333f, -0.02032922f, 0.11723211f, 0.03389336f, 0.01625290f, 
    -0.34235996f, -0.24471922f, -0.06699634f, -0.11498410f, 0.03192475f, -0.08745114f, 0.03319343f, -0.06996171f, 
    -0.03082021f, -0.02010809f, 0.03237850f, -0.08582854f, -0.15679953f, 0.05879430f, 0.05214101f, -0.00861713f, 
    0.03528384f, 0.03574505f, -0.00928366f, -0.01330185f, -0.06038889f, -0.00783200f, 0.04483772f, -0.02363846f, 
    -0.23472609f, -0.00031655f, 0.13025677f, -0.18038431f, 0.03466511f, 0.00811004f, 0.05350412f, -0.02670258f, 
    -0.04660101f, -0.05490123f, 0.05100533f, -0.00164126f, -0.06826586f, 0.11920678f, 0.04271908f, -0.14808579f, 
    0.03177269f, 0.00925624f, 0.01596412f, -0.02677161f, -0.01194700f, 0.05434237f, 0.00828609f, -0.03731450f, 
    0.08788720f, 0.00607676f, 0.00289635f, -0.05509924f, 0.01058371f, -0.06035162f, 0.03415236f, 0.02517875f, 
    -0.01049911f, -0.00367661f, -0.01066461f, 0.03726228f, 0.06882762f, -0.06100708f, -0.00160581f, -0.05706819f, 
    0.07222346f, 0.01152364f, 0.01152697f, -0.01902600f, 0.04541687f, 0.01211714f, 0.01884839f, 0.00398333f, 
    0.05574790f, 0.08738565f, -0.12095112f, 0.11214020f, 0.00665904f, 0.02799892f, -0.02252455f, -0.03593854f, 
    -0.05822627f, 0.04331007f, -0.05902174f, 0.04591971f, -0.06836408f, 0.00557319f, 0.09439585f, -0.00884148f, 
    0.07114494f, -0.03990779f, 0.07112654f, 0.02184195f, -0.08115576f, -0.09212779f, -0.02398315f, -0.00996450f, 
    -0.00728230f, 0.05010492f, -0.15307735f, -0.34518790f, 0.01042374f, -0.02890245f, -0.01363527f, 0.00365299f, 
    -0.04155913f, -0.05536289f, -0.08275001f, -0.06520838f, -0.37820709f, -0.18661049f, -0.03407850f, -0.27486956f, 
    -0.06260330f, -0.01028605f, -0.11115489f, -0.09638151f, -0.04985857f, -0.05073181f, 0.01590015f, -0.01008003f, 
    0.19056478f, 0.00448109f, -0.23240082f, -0.11792825f, 0.02709312f, 0.09898388f, -0.01479168f, -0.14788380f, 
    -0.05094307f, -0.03798850f, 0.07136476f, -0.08832099f, 0.15000735f, -0.02166262f, 0.07837320f, 0.17114119f, 
    -0.00898264f, -0.00721461f, 0.07028754f, 0.09917159f, -0.03437197f, -0.00717042f, 0.05751149f, -0.05701787f, 
    0.00269551f, 0.08159247f, 0.02093476f, -0.01347963f, -0.06372826f, 0.08370181f, -0.03515803f, 0.06284330f, 
    0.00602598f, 0.07404614f, -0.10704107f, 0.04045919f, 0.12525611f, 0.00494475f, 0.08010571f, -0.13242850f, 
    -0.01169425f, -0.02326688f, 0.07327580f, 0.02593688f, 0.03220103f, -0.05821308f, 0.03007762f, -0.04238337f, 
    0.59499341f, -0.03092103f, 0.13724919f, 0.08420295f, 0.02597276f, -0.08743697f, -0.05068055f, 0.12102646f, 
    0.01113764f, 0.03451053f, -0.11131537f, -0.04209198f, 0.01667536f, -0.06963409f, -0.01749356f, 0.02075068f, 
    -0.18530937f, 0.04628869f, -0.04240349f, -0.02595691f, -0.01538374f, 0.01251527f, -0.05519021f, -0.04320079f, 
    0.17394011f, 0.09790275f, -0.15274443f, -0.01993493f, 0.04816793f, -0.00461648f, 0.09284756f, 0.08968484f, 
    -0.00067297f, 0.10248379f, 0.15349400f, -0.00685902f, 0.16705760f, -0.29796341f, -0.13217145f, 0.22069913f, 
    -0.04249756f, -0.09773401f, -0.00784725f, 0.09609345f, 0.01993394f, -0.00418219f, -0.11571188f, 0.11495243f, 
    0.23895210f, 0.07082366f, 0.05053218f, 0.17646618f, 0.07498852f, 0.05170771f, -0.07076608f, 0.14588808f, 
    -0.03455231f, -0.09653987f, -0.00478423f, 0.00093964f, 0.06792735f, 0.04168537f, -0.11768673f, -0.05404482f, 
    -0.02512652f, -0.01511479f, 0.03396970f, -0.08068670f, -0.02178041f, 0.05366134f, 0.07279851f, 0.14560813f, 
    -0.29882681f, 0.04814819f, -0.19263768f, 0.16357547f, 0.00905242f, -0.03289421f, 0.02791581f, -0.00956871f, 
    -0.09333538f, 0.01302974f, 0.04687874f, -0.00691758f, -0.24476378f, 0.31459260f, 0.12988567f, -0.28067091f, 
    -0.03955138f, -0.17783336f, -0.01791111f, 0.06928379f, 0.01678200f, -0.05620079f, 0.02250577f, 0.05511565f, 
    -0.11183229f, -0.35737571f, -0.06083855f, 0.14565934f, -0.07305100f, 0.02049032f, 0.08190259f, -0.03597895f, 
    -0.07422107f, -0.06731619f, -0.00724818f, -0.05726131f, 0.04321622f, -0.27844721f, -0.01891297f, -0.15428120f, 
    -0.09516852f, -0.00340004f, -0.04112067f, 0.01337065f, -0.00182237f, -0.09810159f, 0.00296123f, 0.02139569f, 
    -0.07100639f, -0.01576084f, -0.02876326f, -0.04185915f, -0.00724986f, -0.03154507f, -0.00969812f, 0.10024007f, 
    0.00309590f, 0.03175145f, 0.01771771f, -0.06234217f, -0.08252663f, 0.13792922f, 0.16198185f, 0.09614677f, 
    0.05269147f, 0.18356436f, 0.05586916f, 0.02086657f, -0.03587782f, -0.02598189f, -0.01651806f, 0.05403307f, 
    0.11929575f, -0.01825674f, 0.14310861f, 0.03185884f, -0.00636316f, -0.17153311f, -0.09739564f, 0.01166355f, 
    -0.05965680f, -0.02415375f, 0.03322939f, -0.11846497f, -0.08108024f, -0.36273900f, 0.15749267f, 0.07425649f, 
    -0.03098833f, 0.05986745f, 0.04696330f, 0.03861003f, 0.02389896f, -0.15554650f, 0.02048390f, 0.04753123f, 
    0.11318288f, -0.04439604f, -0.02115593f, -0.02795152f, -0.02374777f, 0.01978005f, -0.01074785f, 0.00187445f, 
    -0.10994865f, -0.06027099f, 0.00271647f, 0.03171806f, -0.30483910f, -0.30057618f, -0.17417753f, 0.19202077f, 
    -0.05121609f, -0.05520971f, -0.02227204f, 0.02683514f, -0.00718192f, -0.00357598f, 0.01218760f, -0.09564010f, 
    -0.30933362f, -0.25474277f, -0.22844511f, -0.12578827f, -0.12866773f, -0.10785215f, -0.01501479f, 0.06463683f, 
    -0.00332400f, -0.02444526f, 0.06210873f, 0.00808487f, 0.07384293f, -0.08723872f, 0.19731230f, 0.03237132f, 
    0.07501583f, 0.09484542f, 0.11126179f, -0.03065333f, -0.04456453f, 0.03020620f, 0.04880213f, 0.00371517f, 
    0.00198560f, 0.15649237f, -0.03088362f, -0.16683452f, -0.02254550f, -0.00800783f, 0.02056651f, 0.05599712f, 
    0.07252704f, -0.05277081f, 0.01309210f, 0.09786879f, 0.04082943f, -0.06896807f, 0.04839256f, 0.03312221f, 
    0.01424265f, -0.17127940f, 0.05150833f, -0.03169776f, 0.02192075f, -0.02382756f, -0.08894498f, 0.00166169f, 
    -0.23733430f, 0.10962737f, 0.10170432f, 0.22724955f, 0.03521495f, -0.09911514f, -0.06843346f, 0.06235441f, 
    -0.00911958f, 0.02711521f, -0.06071385f, 0.05631008f, -0.23512466f, -0.01991082f, 0.02711365f, 0.01410344f, 
    0.01266988f, -0.01325853f, 0.03619107f, 0.01412340f, -0.03814851f, -0.03787433f, -0.12356011f, -0.09315582f, 
    0.06980028f, -0.10416948f, 0.04276469f, -0.12054189f, 0.03379741f, -0.02693703f, 0.00259680f, 0.05184868f, 
    -0.07333571f, 0.02777063f, 0.00551610f, -0.07746761f, 0.20891823f, -0.02652981f, 0.07627662f, -0.06769571f, 
    0.02144586f, 0.01653655f, 0.04720240f, -0.05733221f, -0.05027387f, 0.03612704f, -0.00272516f, 0.05091663f, 
    0.14152880f, -0.11967073f, 0.01136322f, -0.07820129f, -0.01644603f, 0.01159863f, 0.00260590f, 0.04564399f, 
    0.04223811f, -0.02520924f, -0.00953715f, 0.03077378f, 0.05203045f, 0.20860207f, 0.03333118f, 0.08467007f, 
    -0.09980337f, -0.01169595f, 0.01372881f, 0.00523978f, -0.12121503f, 0.14750561f, -0.04802632f, 0.01131638f, 
    -0.34193635f, 0.00318063f, 0.13489814f, -0.28409287f, -0.04009239f, 0.02454942f, -0.00115856f, -0.00397355f, 
    0.01876931f, -0.01137081f, -0.06552068f, -0.01866487f, 0.00856598f, -0.20755528f, 0.03389201f, 0.20893197f, 
    -0.01210872f, 0.10354370f, 0.04319100f, 0.00430234f, -0.00789179f, -0.07350167f, -0.03243052f, -0.18832362f, 
    0.08190583f, -0.04970825f, 0.00944640f, -0.00103185f, -0.10794172f, 0.03821226f, 0.00540664f, 0.05131491f, 
    -0.01201444f, 0.13806401f, -0.07670654f, 0.06764365f, -0.29751971f, 0.17389034f, 0.10907932f, -0.01144314f, 
    0.00422004f, -0.00868350f, 0.08972222f, 0.10490223f, 0.08334894f, 0.13868672f, -0.04529822f, 0.02736146f, 
    -0.03988429f, 0.06761012f, -0.07438825f, -0.07678412f, 0.04759415f, 0.00422133f, -0.00299487f, -0.08954092f, 
    0.00608050f, -0.06667793f, -0.01700137f, 0.05976741f, 0.08873246f, -0.08477372f, -0.08548032f, -0.07178756f, 
    -0.09838753f, -0.02695363f, -0.03136432f, -0.04623084f, -0.12030751f, -0.01333508f, -0.03872112f, -0.01323479f, 
    -0.26711056f, 0.03522588f, -0.18345955f, -0.05626996f, 0.01946642f, 0.00237320f, 0.06588487f, 0.07482095f, 
    0.00588507f, 0.06782301f, -0.08880743f, 0.05342608f, -0.40973702f, -0.12245890f, -0.01643500f, -0.12666073f, 
    0.02175403f, -0.03728085f, -0.03007237f, -0.03596534f, 0.10112935f, 0.00996255f, 0.06236517f, -0.03368507f, 
    0.00955853f, 0.09571876f, -0.11217558f, -0.12122624f, -0.04100563f, -0.15400594f, -0.03427600f, 0.03128927f, 
    -0.04687830f, -0.01896048f, -0.02006928f, 0.02600349f, 0.13902144f, 0.01777427f, 0.02170404f, 0.08482900f, 
    0.02888940f, 0.05896123f, 0.05615398f, 0.03433384f, -0.01772744f, 0.02226581f, -0.01095420f, -0.07357498f, 
    -0.16844109f, 0.29735833f, 0.07304823f, 0.02340741f, -0.00382191f, 0.06789096f, -0.00345850f, -0.04716204f, 
    0.00218796f, -0.03031783f, 0.02049106f, 0.01746185f, 0.07029606f, -0.20619853f, 0.01126480f, 0.19003336f, 
    -0.04242701f, 0.03281243f, 0.00094925f, 0.05752200f, -0.00510771f, 0.03841747f, -0.00820229f, -0.04533825f, 
    0.35476586f, 0.06312788f, 0.04901662f, -0.01830081f, 0.06347751f, -0.00646206f, 0.08803815f, 0.17487571f, 
    -0.03003235f, 0.05254959f, -0.01031068f, -0.10076699f, 0.03981698f, 0.00955643f, 0.15046149f, 0.11505342f, 
    0.01407637f, -0.02493545f, 0.02096790f, 0.04084093f, -0.01424766f, -0.03995221f, 0.14422531f, -0.09347098f, 
    0.17318276f, -0.20336112f, -0.18078256f, 0.11005957f, 0.02497667f, -0.00007680f, -0.08710134f, 0.01681381f, 
    0.05167153f, 0.10196111f, -0.07656643f, 0.02790146f, -0.17175651f, 0.02929829f, -0.17791799f, 0.11758899f, 
    -0.00584562f, 0.07255720f, -0.02395292f, -0.01824478f, -0.10353976f, 0.03843318f, 0.09602693f, 0.04058918f, 
    -0.12937346f, -0.10333858f, -0.02464745f, -0.09081229f, -0.17225979f, 0.00148054f, -0.00354786f, 0.00801006f, 
    -0.00731910f, 0.00074907f, -0.03595510f, 0.02904336f, 0.07156628f, 0.00752125f, 0.01062500f, -0.03627244f, 
    -0.00211817f, -0.00583574f, 0.03498727f, -0.04786194f, 0.01417420f, -0.00197881f, 0.00882098f, -0.00613041f, 
    -0.22659370f, 0.11461636f, 0.18787563f, 0.14870523f, 0.01522171f, -0.00808412f, 0.09238844f, -0.13866112f, 
    -0.06690886f, -0.08852679f, -0.08863740f, -0.11309301f, 0.14161101f, 0.15101053f, 0.04309542f, -0.00817475f, 
    -0.07455979f, -0.08298214f, -0.01384099f, -0.04940470f, 0.01603704f, 0.03133004f, 0.07742087f, 0.11830764f, 
    -0.20651554f, 0.03724486f, 0.05841941f, 0.07745706f, 0.01327155f, -0.05654435f, 0.03227950f, 0.04840790f, 
    -0.00499057f, -0.06242963f, -0.04656614f, -0.00820858f, -0.04074792f, -0.01584998f, 0.12209400f, 0.15203463f, 
    -0.08571092f, 0.01359176f, 0.15540394f, -0.06063933f, -0.16494901f, 0.15738028f, -0.12884429f, 0.03924006f, 
    -0.23598619f, -0.32298839f, -0.28447735f, 0.08836524f, -0.02015371f, -0.02737482f, -0.04119750f, -0.05124940f, 
    -0.04925918f, -0.11289474f, 0.01488813f, -0.00891757f, -0.30129018f, -0.18975103f, -0.04953492f, -0.17217070f, 
    -0.02318763f, -0.06615444f, 0.04879554f, 0.01323575f, 0.04780811f, -0.01212212f, -0.05800251f, -0.02903457f, 
    0.11810944f, 0.05574149f, 0.11314402f, 0.09884939f, -0.03026309f, 0.01045010f, 0.04294684f, -0.01336008f, 
    0.06578381f, 0.06464637f, -0.05666416f, -0.06804694f, 0.29102618f, -0.16168272f, 0.04841562f, -0.01160290f, 
    0.03580047f, 0.12981035f, 0.04318923f, -0.09545824f, 0.00819098f, -0.07614507f, -0.08115398f, 0.06194343f, 
    -0.04272095f, -0.00487818f, 0.02428259f, 0.08033696f, -0.15542929f, 0.07233441f, -0.00214337f, -0.12017968f, 
    -0.05088640f, -0.04667598f, 0.02532711f, 0.07167459f, 0.04788498f, -0.27224669f, -0.19017078f, -0.03975409f, 
    0.03344439f, 0.07849945f, -0.01572683f, -0.06031941f, 0.08681399f, 0.00195627f, -0.02692231f, -0.08874300f, 
    0.04263785f, -0.01884338f, -0.10662235f, -0.23813868f, 0.00250244f, -0.00813562f, 0.02343432f, -0.06245287f, 
    0.00010477f, -0.00132399f, 0.01711451f, -0.05604453f, -0.48399326f, -0.41114673f, -0.14815894f, 0.07702358f, 
    -0.10512540f, -0.04981524f, -0.07066573f, -0.08942100f, 0.00460338f, -0.14866449f, 0.06178041f, -0.02995242f, 
    -0.27605769f, -0.06123349f, -0.00474600f, 0.19223918f, -0.07260357f, 0.06316447f, 0.00812547f, 0.01085485f, 
    -0.03859311f, 0.02060529f, -0.05629761f, 0.03253583f, -0.25664443f, 0.02989340f, -0.17769739f, 0.03394863f, 
    -0.08771762f, 0.07958800f, -0.04993354f, -0.06362297f, 0.03778281f, -0.08369181f, 0.04438248f, 0.00223038f, 
    0.47450301f, 0.19232883f, -0.12544620f, 0.18088137f, -0.01140405f, -0.00847882f, -0.03575563f, 0.09124556f, 
    0.02235717f, -0.08709528f, -0.00523359f, 0.03414723f, 0.08337233f, -0.03016708f, -0.04783279f, -0.15753312f, 
    -0.02933789f, 0.01797942f, 0.01283379f, -0.02530648f, 0.03583719f, 0.03655718f, -0.01388153f, -0.01529460f, 
    0.00889438f, 0.14358470f, 0.19062576f, -0.01920537f, 0.03591423f, 0.05685952f, -0.00874436f, -0.02312599f, 
    -0.02830767f, 0.06131574f, 0.01808026f, -0.07019769f, -0.23508385f, 0.09389895f, -0.07555432f, -0.22096732f, 
    -0.05087625f, 0.07360566f, 0.02574593f, 0.04009190f, -0.00759495f, -0.02361388f, 0.05407761f, 0.02290655f, 
    0.15771212f, 0.04848684f, -0.00758583f, -0.00181159f, -0.03390347f, -0.04348816f, 0.05308176f, 0.00608040f, 
    0.03934346f, -0.05744778f, 0.06195310f, 0.07383165f, -0.07892745f, 0.06165695f, -0.05939800f, -0.10793594f, 
    0.09578321f, 0.00926855f, -0.01450956f, -0.03159660f, -0.13001786f, -0.03457295f, 0.03659251f, 0.03098795f, 
    0.31333905f, 0.30156979f, -0.17115033f, -0.24441539f, -0.04673102f, -0.01903534f, 0.01807898f, 0.10303317f, 
    0.01096167f, 0.03060224f, -0.06603098f, 0.01394092f, 0.03206542f, -0.14280288f, -0.02357521f, 0.05475659f, 
    0.03430244f, 0.05946574f, 0.03607158f, 0.01647136f, -0.06736738f, 0.09310863f, 0.06196105f, -0.01090736f, 
    -0.11800338f, 0.11660660f, -0.12532988f, -0.21494237f, -0.04215586f, -0.04146829f, 0.08310384f, -0.05546367f, 
    0.11926544f, -0.05489121f, 0.00484705f, 0.08877877f, -0.14913025f, 0.04165524f, -0.05046073f, -0.04467142f, 
    0.04082353f, 0.09480508f, 0.10130434f, 0.13336116f, -0.05600027f, -0.13433516f, 0.02373026f, -0.04238268f, 
    -0.00701196f, -0.03229853f, 0.08892560f, -0.07085925f, -0.21172021f, 0.08848129f, -0.04370526f, -0.03765016f, 
    -0.07873807f, -0.03016896f, -0.00518756f, -0.00688072f, 0.14736979f, 0.04863968f, 0.00078370f, -0.03035976f, 
    0.04744129f, 0.14601892f, 0.12692758f, -0.04565393f, 0.01493788f, -0.06634461f, -0.02446894f, 0.06471676f, 
    0.08302459f, 0.04255686f, -0.05907952f, 0.08065243f, 0.08358935f, 0.10506243f, -0.07113165f, -0.02976000f, 
    0.06474456f, 0.22415349f, 0.06553892f, 0.00872437f, 0.33017045f, -0.01616555f, -0.07265546f, -0.27222171f, 
    0.00821835f, -0.04430066f, 0.06189576f, 0.01017284f, 0.02799213f, -0.11720729f, -0.17322239f, -0.04517160f, 
    -0.26390210f, -0.30707049f, 0.16071461f, 0.07509911f, -0.11061460f, -0.04714422f, 0.03333296f, -0.03077528f, 
    0.11531107f, 0.00464424f, -0.10004707f, -0.14313927f, 0.29539347f, -0.09556600f, -0.01864428f, 0.06071522f, 
    -0.05239196f, -0.03961185f, -0.03214195f, -0.04191919f, 0.04447613f, 0.08344985f, -0.01438088f, -0.08520217f, 
    -0.03796507f, -0.25986794f, 0.26064664f, -0.17801335f, -0.06281115f, -0.07129890f, -0.02059548f, -0.01000946f, 
    0.06529367f, 0.00983107f, -0.03297531f, -0.11914056f, -0.18586229f, -0.07367717f, -0.02821890f, 0.02350408f, 
    0.02725725f, -0.13542189f, 0.04013986f, 0.05075490f, 0.14622544f, -0.07247769f, -0.00968823f, -0.02178728f, 
    -0.12761804f, -0.02878802f, 0.00473892f, 0.03674697f, 0.03190364f, -0.06870047f, 0.03504619f, 0.14442651f, 
    -0.01863244f, 0.02058219f, -0.07534502f, 0.01024448f, 0.00928706f, 0.27647090f, -0.02651743f, -0.28647867f, 
    0.11548796f, -0.05501778f, 0.11486126f, 0.13420552f, 0.00593309f, 0.04913440f, 0.07114215f, -0.07789502f, 
    -0.74594104f, 0.13459258f, 0.11355091f, 0.08628837f, 0.06401367f, 0.09803464f, -0.01959460f, 0.05225576f, 
    -0.04848003f, -0.07401467f, 0.06628720f, 0.03104097f, -0.23265296f, 0.04083766f, 0.16071369f, -0.11969769f, 
    -0.10608271f, -0.00336014f, -0.00205008f, 0.05945545f, 0.11368387f, -0.08974691f, -0.08882250f, -0.03755919f, 
    -0.21880238f, 0.09897064f, -0.01467810f, -0.07598817f, 0.02278884f, -0.02100646f, -0.05894857f, 0.07253379f, 
    0.00183317f, -0.01520654f, 0.05306673f, 0.06518625f, -0.10656398f, 0.17905745f, 0.00543633f, -0.09871411f, 
    -0.03083572f, 0.01160073f, -0.09270862f, -0.02091916f, -0.09527572f, -0.08038486f, -0.02456573f, 0.00254954f, 
    0.16507281f, -0.11131494f, 0.10703247f, 0.08724143f, 0.06331615f, 0.08165245f, -0.03083345f, 0.09748722f, 
    0.00162654f, 0.04735295f, 0.02877938f, 0.03839937f, -0.40209183f, 0.04162161f, -0.07963301f, -0.02764932f, 
    0.12350265f, 0.03092296f, 0.03570203f, 0.05243263f, -0.04792008f, -0.03244809f, -0.01940442f, 0.03430630f, 
    -0.53009278f, -0.00426045f, -0.03432626f, -0.23569635f, 0.00027335f, -0.05890828f, -0.01579399f, -0.01043033f, 
    -0.04453874f, -0.05009766f, 0.07114359f, -0.14709955f, -0.18855716f, -0.20744655f, 0.11106147f, -0.17052944f, 
    -0.00011296f, 0.02110058f, -0.05223229f, 0.02612828f, -0.00550770f, 0.01468874f, 0.01908610f, 0.02664137f, 
    0.06198568f, -0.11482953f, 0.08143521f, -0.27287990f, 0.07783338f, -0.00418513f, -0.09754096f, 0.00985071f, 
    0.04212921f, 0.05249265f, -0.10186739f, 0.04837189f, -0.02428533f, 0.08765941f, -0.03535235f, 0.04712202f, 
    0.04614365f, -0.01785843f, 0.04390514f, 0.06344971f, -0.12698959f, -0.06917445f, -0.05842351f, -0.03617253f, 
    -0.20362453f, -0.05728061f, 0.05649933f, 0.09775038f, -0.03267460f, 0.10507084f, 0.06744368f, 0.04559577f, 
    -0.06597095f, -0.03028300f, 0.07971580f, 0.11743530f, 0.20291957f, -0.02240814f, 0.01749457f, -0.19465731f, 
    -0.07673869f, -0.07705124f, 0.06252915f, 0.09876411f, 0.03555910f, -0.06124656f, -0.08631004f, 0.05146692f, 
    0.20525698f, 0.10688702f, -0.20055734f, 0.15188316f, -0.09119878f, -0.09774701f, 0.12098698f, -0.06139123f, 
    0.03608490f, -0.04902560f, -0.03500208f, -0.02312491f, -0.23867406f, -0.22335891f, 0.19397828f, 0.15387817f, 
    0.03085416f, -0.10864794f, -0.25146574f, -0.07111279f, -0.01353975f, -0.00207864f, -0.09069800f, 0.01631474f, 
    -0.11359827f, -0.03247155f, 0.15038888f, 0.12195309f, -0.02690153f, -0.01661616f, 0.01268598f, 0.09300014f, 
    -0.04598837f, 0.12940341f, 0.10798072f, -0.01914911f, 0.13231854f, 0.09002067f, 0.07134926f, 0.03527541f, 
    -0.03058714f, 0.00206149f, 0.06859223f, -0.03368948f, -0.04690442f, -0.03624276f, -0.07666310f, -0.01781850f, 
    0.02651077f, 0.16715403f, -0.00612701f, -0.01911165f, 0.03651964f, 0.02474408f, 0.11840325f, -0.04526006f, 
    0.12002239f, 0.01975642f, 0.03472199f, 0.00512633f, -0.38433754f, 0.04823241f, 0.00539064f, 0.15257367f, 
    0.03976648f, -0.05244265f, 0.04484997f, 0.07622873f, -0.09666426f, 0.03754994f, 0.06943287f, -0.03323306f, 
    -0.14840485f, -0.16626810f, -0.03920710f, -0.07621107f, -0.04574159f, 0.04138049f, 0.02031337f, -0.01319477f, 
    -0.03299078f, 0.07708263f, 0.06630014f, 0.05923684f, -0.11764886f, 0.25334013f, -0.12184457f, -0.04917115f, 
    0.05978163f, -0.00232707f, -0.06099674f, 0.22689125f, -0.03127414f, 0.02684667f, -0.02670206f, 0.05942099f, 
    -0.00107205f, -0.21304397f, -0.00005079f, 0.26051953f, 0.00766146f, -0.03099137f, -0.02383254f, -0.05232114f, 
    -0.02761535f, -0.06117702f, -0.01395235f, -0.04766864f, -0.10126790f, -0.02066844f, 0.02955931f, 0.01471911f, 
    0.02455560f, 0.03459891f, -0.04500623f, -0.05570326f, -0.07162327f, -0.14438090f, -0.03972448f, -0.03330286f, 
    -0.00959542f, 0.07622546f, 0.13385880f, 0.02030592f, 0.03731048f, -0.06246118f, 0.04484586f, -0.11982228f, 
    0.02309554f, -0.03430927f, -0.05752443f, 0.10256201f, 0.01860994f, 0.19161017f, 0.02583900f, -0.10848153f, 
    0.05635080f, -0.04163210f, -0.03191080f, 0.10434542f, 0.02775994f, -0.00385074f, 0.01208289f, -0.06327620f, 
    0.13289821f, 0.08041015f, -0.01925741f, -0.27471936f, 0.11289708f, 0.01475540f, 0.06860839f, -0.12130899f, 
    -0.07037280f, 0.05200792f, 0.05082587f, -0.01012151f, -0.00181573f, 0.00461153f, -0.03893295f, -0.13419196f, 
    0.00844829f, 0.12029794f, 0.04092981f, 0.01132661f, 0.02997962f, -0.07064052f, 0.03581817f, -0.03362648f, 
    -0.11739785f, -0.02051393f, 0.16932361f, 0.08251974f, -0.16768663f, 0.10925996f, -0.01188546f, 0.06589382f, 
    0.02381443f, -0.04803885f, 0.00850369f, 0.08670902f, -0.43353066f, -0.01915355f, -0.11787074f, 0.03680807f, 
    0.03240968f, -0.05849931f, -0.00266494f, -0.26770672f, 0.00679863f, -0.11002328f, 0.03850629f, -0.07989596f, 
    -0.30795586f, 0.25178337f, 0.02157871f, 0.03849260f, 0.03856090f, -0.06844656f, 0.12055678f, 0.01179832f, 
    0.03782891f, 0.16917373f, 0.02833592f, -0.05802726f, -0.10558443f, -0.04451919f, 0.01470422f, 0.23684718f, 
    0.01544914f, -0.02142773f, 0.07614896f, 0.03012146f, -0.06224952f, -0.00649493f, 0.05605033f, 0.00689080f, 
    -0.23711775f, 0.07770276f, 0.11895208f, 0.07329455f, 0.10022531f, -0.10097399f, -0.02909006f, 0.03413729f, 
    0.08157413f, 0.03941240f, -0.01965231f, -0.12740023f, 0.06223221f, 0.00087208f, 0.04093417f, -0.07589881f, 
    0.08014777f, 0.07113103f, -0.01454173f, 0.13387227f, -0.04252567f, 0.02907937f, 0.03668388f, -0.05834454f, 
    -0.35581258f, 0.10193735f, -0.02014058f, -0.05858926f, -0.07216032f, 0.05711185f, 0.08923706f, 0.07873677f, 
    -0.00535964f, 0.10123298f, -0.10751922f, 0.00941901f, -0.17781314f, -0.01439105f, -0.01193765f, -0.11523817f, 
    -0.09981415f, 0.01442462f, 0.04571259f, -0.00711103f, -0.12505330f, -0.05028874f, 0.04278510f, 0.05739364f, 
    0.07430357f, 0.09243384f, 0.02239120f, 0.05595252f, -0.11297565f, 0.00257639f, 0.04326364f, 0.08928955f, 
    -0.00447211f, -0.01151545f, -0.03832400f, -0.01413557f, -0.05164177f, 0.14563590f, -0.09044960f, 0.09343116f, 
    0.07524581f, -0.08547418f, 0.05452833f, 0.15098675f, -0.00608225f, 0.05417974f, -0.03413403f, -0.04138217f, 
    0.06356908f, -0.06141598f, -0.17866954f, 0.04403417f, -0.09919301f, -0.10370084f, 0.07402559f, -0.00704431f, 
    -0.04326271f, -0.07188357f, 0.04861300f, 0.02383841f, 0.05569613f, -0.09358351f, 0.04855800f, 0.12027656f, 
    -0.04342227f, -0.00423829f, -0.00075852f, -0.03635200f, 0.14133626f, 0.02130687f, -0.01719843f, -0.11675851f, 
    -0.10037895f, -0.19303618f, -0.10255085f, 0.00076712f, 0.05043711f, -0.01020398f, -0.04310871f, 0.03307960f, 
    0.02267162f, -0.02658351f, -0.03631074f, -0.05508685f, -0.27475908f, -0.25599462f, -0.01714597f, 0.15743715f, 
    -0.11317074f, -0.06195996f, -0.11466120f, -0.19290109f, 0.01843092f, -0.01329241f, -0.08329966f, -0.02737741f, 
    0.38926297f, -0.18242434f, -0.14829543f, 0.07366487f, -0.00305726f, -0.03215957f, 0.01747368f, -0.06672038f, 
    -0.05862231f, -0.09530006f, 0.07677388f, -0.04057667f, 0.19604336f, 0.03771186f, -0.05863986f, 0.08344847f, 
    -0.00792944f, 0.00413414f, 0.07484680f, 0.01837112f, 0.00991086f, -0.04923378f, 0.05048079f, -0.00508581f, 
    -0.29313281f, -0.04152839f, 0.14797154f, 0.07732900f, -0.02575885f, 0.10980976f, -0.03648786f, -0.02628638f, 
    0.09784433f, -0.05305224f, -0.00909419f, 0.00702559f, -0.07506616f, -0.24643335f, -0.43602446f, 0.09851366f, 
    0.06606171f, 0.04143120f, 0.13332796f, -0.08736742f, -0.07289324f, 0.03601211f, -0.01346737f, 0.00135697f, 
    0.09771924f, 0.05193597f, -0.01888575f, -0.20056747f, 0.03410148f, 0.09342737f, 0.03409431f, 0.04548721f, 
    0.01969512f, -0.10336144f, 0.06113797f, 0.09025169f, 0.21164252f, 0.07005196f, 0.17797002f, 0.15298858f, 
    0.04345980f, 0.04957518f, 0.11587580f, 0.01212183f, 0.00364672f, 0.06813105f, 0.04448450f, 0.00909768f, 
    -0.10052194f, 0.10539030f, 0.13279597f, 0.13587013f, -0.06773409f, -0.06495167f, -0.07321279f, -0.18130690f, 
    -0.13230062f, -0.00726166f, 0.08582868f, -0.03505462f, -0.20972425f, 0.02377551f, 0.15968919f, 0.29382885f, 
    -0.05568949f, -0.04353232f, 0.01311103f, 0.10156527f, -0.03697276f, 0.08321551f, 0.14388877f, 0.05565607f, 
    0.01352097f, -0.02234817f, 0.04018002f, 0.16780958f, 0.19615775f, -0.06282438f, 0.04666638f, 0.10190973f, 
    -0.05698509f, -0.05502044f, -0.19427183f, -0.07226563f, -0.31960338f, -0.10465848f, 0.05945725f, 0.10639507f, 
    0.02467932f, -0.01358783f, 0.10873588f, 0.12470751f, 0.06165751f, 0.18709518f, -0.05235017f, 0.04356962f, 
    -0.27094463f, -0.14557829f, 0.22096564f, 0.23214342f, -0.03956234f, 0.06794128f, 0.04947031f, -0.06225424f, 
    -0.08398798f, -0.11386144f, 0.02402404f, -0.00213204f, 0.03316549f, -0.01419838f, -0.02783976f, -0.15987347f, 
    0.02994817f, -0.00064798f, -0.08106536f, -0.11163477f, -0.05863746f, 0.13994320f, -0.09295773f, -0.00623220f, 
    -0.36416757f, 0.05674251f, 0.09000073f, -0.40916449f, -0.05173513f, 0.07860997f, 0.14015573f, -0.06333482f, 
    -0.08900998f, -0.00051719f, -0.07417504f, -0.08293612f, 0.07972168f, -0.02491068f, 0.24026075f, -0.14259507f, 
    0.00115296f, 0.04267464f, 0.04000112f, -0.02241198f, -0.04068987f, 0.03017922f, -0.03684503f, -0.04642890f, 
    0.00609269f, -0.07038485f, 0.14315996f, 0.16602167f, 0.01179029f, 0.00935157f, 0.07433686f, -0.13300094f, 
    -0.05065556f, 0.01595759f, -0.07823440f, 0.16224085f, -0.47042274f, -0.12791729f, -0.04258544f, -0.08029847f, 
    0.01755529f, 0.06743208f, -0.09348494f, 0.17044109f, 0.07666572f, 0.14114362f, 0.10120619f, 0.01369035f, 
    0.00011679f, 0.02794274f, 0.17496876f, 0.09591585f, -0.00345800f, 0.01926175f, 0.04878333f, 0.05950429f, 
    0.07532462f, 0.02593095f, 0.03836457f, -0.04982650f, -0.25601387f, -0.30287993f, 0.10965811f, 0.05106959f, 
    -0.00005431f, -0.07042850f, 0.04999739f, 0.00275303f, 0.05686392f, 0.08301184f, 0.02198149f, -0.06601354f, 
    0.16559419f, 0.06826694f, -0.06005319f, 0.03368572f, -0.07778266f, 0.08479181f, -0.01698290f, 0.08662920f, 
    -0.07849555f, -0.07611968f, 0.10730493f, 0.07285981f, 0.07393706f, 0.03623830f, 0.05727047f, -0.22258280f, 
    0.12606935f, 0.03398888f, -0.04675290f, -0.12123507f, -0.01434277f, -0.03267885f, 0.05004529f, 0.02092885f, 
    0.08109353f, -0.05822982f, -0.01236973f, 0.13321932f, -0.04880831f, 0.04421492f, 0.05258613f, -0.02096253f, 
    -0.00250256f, 0.14363554f, -0.02249218f, -0.02762696f, 0.14473031f, -0.03620084f, -0.03670420f, 0.04017995f, 
    -0.08899367f, -0.09034953f, 0.04896348f, 0.00744097f, -0.02560453f, 0.04375792f, 0.12123493f, 0.21030068f, 
    -0.07550934f, -0.16858990f, 0.15282463f, 0.11936699f, -0.00848620f, -0.00710305f, 0.08290964f, -0.02481261f, 
    0.08572641f, -0.03755021f, -0.03116458f, 0.23481849f, -0.14085713f, 0.13076191f, 0.04767625f, 0.15234214f, 
    -0.03955363f, 0.06200787f, -0.11356624f, -0.14674053f, -0.04094216f, 0.03201362f, 0.01773730f, 0.07750395f, 
    -0.30656782f, -0.07418875f, -0.21435857f, -0.03357805f, 0.14687310f, 0.01034309f, -0.03542123f, 0.05999096f, 
    0.00690727f, 0.01453766f, -0.00589977f, -0.01057108f, -0.05189160f, -0.06063385f, -0.01723122f, 0.14084227f, 
    0.08906120f, -0.07562897f, -0.09510071f, 0.02129418f, 0.10607021f, -0.00879061f, 0.05822998f, -0.04935989f, 
    0.00016906f, 0.00241411f, -0.03366691f, 0.01615996f, -0.11526366f, -0.02340470f, 0.09412023f, -0.06481396f, 
    0.01094277f, -0.00023670f, 0.04577040f, -0.07553788f, -0.14450139f, 0.04601186f, -0.06917179f, -0.18035896f, 
    -0.04831151f, -0.00653137f, -0.06430721f, 0.04254693f, -0.04676711f, -0.15393700f, -0.01338557f, -0.26237780f, 
    -0.24755412f, -0.07101351f, -0.06119066f, 0.04306797f, 0.08356794f, -0.08339160f, -0.07706346f, -0.21706992f, 
    -0.09342426f, -0.03950252f, 0.08361113f, 0.03009747f, -0.58976656f, -0.03710762f, -0.10560101f, -0.19456486f, 
    0.20609559f, 0.03529473f, -0.08908828f, 0.00769371f, 0.01501095f, 0.01506921f, -0.05777124f, 0.09233940f, 
    -0.20473918f, 0.08329096f, 0.03567134f, 0.00860523f, 0.00836819f, 0.06709027f, 0.10093867f, 0.02343608f, 
    -0.00267135f, -0.05140495f, -0.16587615f, 0.00135266f, 0.02551309f, 0.10077062f, 0.05664928f, 0.08279004f, 
    0.04828751f, 0.01371575f, -0.08351603f, 0.10568756f, 0.05567843f, 0.06148965f, 0.09494250f, -0.01558880f, 
    -0.06503912f, 0.07450626f, -0.07645383f, 0.09352551f, 0.07911258f, -0.12478697f, -0.00714285f, -0.01112504f, 
    0.15785454f, -0.10518418f, -0.02973581f, 0.00634672f, -0.07462961f, -0.08649541f, -0.19536798f, -0.07147247f, 
    0.02155865f, 0.05007192f, -0.07060859f, 0.00787350f, 0.08379870f, 0.04956827f, 0.00218364f, 0.03938743f, 
    -0.00907353f, -0.06572305f, -0.39653364f, -0.10832538f, 0.09672840f, 0.04088847f, 0.01385817f, -0.03667876f, 
    -0.05019243f, -0.00346846f, -0.09057512f, -0.17366017f, 0.02816037f, 0.08646236f, 0.09165028f, 0.29006982f, 
    0.09808083f, 0.09752852f, 0.12432250f, 0.04330974f, 0.18837856f, -0.02228012f, -0.06337652f, -0.14965057f, 
    -0.04008513f, -0.14184880f, 0.08848631f, 0.02458508f, -0.15934198f, 0.01403299f, -0.00140723f, -0.01653991f, 
    0.13285981f, 0.08935941f, 0.05708124f, 0.10410751f, 0.10705968f, 0.12947574f, 0.11690086f, 0.17189863f, 
    -0.02182027f, -0.01942799f, 0.01174213f, 0.00665535f, -0.10177084f, -0.12452658f, -0.01137405f, 0.16790386f, 
    -0.05656090f, -0.10952888f, -0.12437131f, -0.08754136f, 0.08458109f, 0.13339244f, -0.14462841f, -0.07873806f, 
    0.04787413f, -0.07569952f, -0.10035537f, 0.13948773f, 0.12859407f, -0.13595600f, 0.07236467f, 0.21068454f, 
    -0.12466477f, 0.04517921f, -0.04266369f, -0.19294277f, -0.00187704f, 0.04034230f, 0.01733072f, 0.05675093f, 
    -0.26109120f, -0.09538616f, -0.08779743f, 0.01403963f, -0.10298868f, -0.08359971f, 0.05741480f, -0.07514050f, 
    -0.04348850f, -0.23179831f, 0.05391514f, -0.10778490f, -0.38535348f, 0.12717943f, -0.14190744f, -0.11006521f, 
    0.01144113f, 0.10351318f, 0.08329693f, 0.04501007f, 0.06462269f, 0.03237147f, -0.14729422f, 0.02915598f, 
    0.14796136f, 0.04173607f, -0.03282246f, -0.01458913f, -0.02353554f, -0.17429139f, -0.07391451f, -0.19397609f, 
    0.13362280f, -0.04888615f, -0.15248068f, 0.02621526f, 0.03402032f, 0.00176168f, 0.04114675f, -0.01752783f, 
    0.00673972f, -0.16882339f, 0.12675846f, -0.06538491f, 0.10032910f, -0.10597372f, -0.03346860f, -0.12625276f, 
    -0.48304957f, 0.09203061f, -0.09234759f, -0.07652583f, 0.15414937f, 0.16588621f, -0.07978989f, -0.15011899f, 
    0.04338934f, 0.03048497f, 0.00679302f, -0.13387547f, -0.17431957f, 0.01861393f, 0.12346318f, 0.21966396f, 
    -0.15742972f, -0.09188774f, -0.04810753f, 0.10202144f, 0.17370266f, -0.02461613f, 0.02903141f, 0.01793506f, 
    0.09441860f, -0.09237154f, 0.00220448f, 0.06946082f, 0.02121604f, -0.01350806f, 0.00244229f, 0.14305352f, 
    0.05787066f, 0.11602248f, 0.06493607f, 0.03589873f, -0.01162925f, -0.01754765f, -0.03357798f, 0.15185511f, 
    -0.10634509f, 0.00508047f, 0.01217129f, -0.16576774f, 0.05101894f, 0.00710202f, 0.06508906f, 0.07149840f, 
    -0.14702648f, -0.22045496f, 0.20691799f, 0.19476964f, 0.01410097f, -0.11316778f, -0.17081693f, 0.02454006f, 
    -0.06821637f, 0.05818753f, 0.03901876f, 0.01352148f, -0.16943060f, -0.03627022f, 0.00020100f, -0.33752093f, 
    0.09621896f, -0.01376967f, 0.13921016f, -0.10891343f, 0.00032360f, 0.18495846f, -0.12029158f, 0.05864031f, 
    -0.03094683f, 0.02006599f, -0.00221883f, 0.22636376f, 0.03971118f, -0.12801823f, 0.05068204f, -0.00709286f, 
    0.00469651f, -0.08273853f, -0.03713867f, -0.19948696f, -0.05865790f, -0.07859602f, 0.02524874f, -0.04628520f, 
    -0.00149197f, -0.09040606f, -0.03340801f, 0.03733080f, 0.17917286f, -0.09472879f, -0.09779342f, -0.07588664f, 
    -0.19897211f, -0.02255587f, -0.23534536f, -0.05134721f, 0.03868199f, -0.00200163f, -0.16482039f, -0.16584654f, 
    0.07652795f, -0.03858971f, 0.02349442f, -0.00500181f, 0.13935505f, -0.04016042f, -0.14431210f, 0.08825990f, 
    0.02709638f, 0.09518785f, -0.08598793f, 0.10813940f, 0.13009594f, -0.05626976f, 0.06364997f, -0.06180241f, 
    0.11876696f, -0.09558478f, -0.13114040f, -0.04956230f, -0.01716471f, 0.02256776f, 0.08063199f, -0.04606656f, 
    -0.02895192f, 0.10851679f, 0.18878040f, 0.19392383f, -0.26140630f, -0.14641277f, -0.12478840f, 0.14882460f, 
    0.06688093f, -0.09169497f, 0.02539281f, 0.03740086f, 0.02204995f, 0.14833547f, 0.07373929f, 0.00490622f, 
    -0.26444608f, 0.00424621f, 0.22424732f, -0.06527720f, 0.05047054f, -0.05779007f, -0.03365827f, -0.03402118f, 
    -0.00121447f, -0.08193436f, 0.01958667f, -0.03502641f, -0.39970747f, 0.07672717f, -0.05507244f, -0.18588170f, 
    0.07960971f, -0.05156174f, -0.04947205f, 0.17342888f, -0.05383452f, 0.08537603f, -0.06461415f, -0.22090425f, 
    -0.06099444f, -0.00967297f, 0.07785330f, -0.01596993f, 0.12518753f, 0.04070948f, 0.00625438f, -0.03069094f, 
    0.00151938f, 0.01555959f, -0.06432603f, 0.20212479f, -0.16527684f, 0.01551055f, 0.21278694f, 0.00497225f, 
    0.14770971f, -0.01325557f, -0.00770240f, -0.07197580f, 0.03644255f, -0.05733069f, -0.06075685f, -0.14916891f, 
    -0.12023102f, -0.06325956f, 0.11478932f, 0.23717828f, 0.00898356f, -0.07451984f, -0.05595860f, 0.08987711f, 
    0.00114957f, -0.01821254f, -0.09083011f, 0.22218700f, 0.08775321f, 0.02092796f, 0.05104041f, -0.10545658f, 
    -0.03023737f, -0.17821249f, 0.01529974f, -0.05669339f, -0.11664581f, -0.01819641f, 0.09421023f, 0.17085117f, 
    0.03190777f, 0.04595525f, 0.05581209f, -0.07131583f, 0.06614276f, 0.05758083f, 0.08824991f, 0.00297267f, 
    0.00923516f, -0.03181797f, 0.01451309f, -0.05659015f, 0.17523243f, 0.13179812f, 0.14315943f, 0.05136254f, 
    -0.10837918f, -0.06983278f, 0.06658258f, 0.01145768f, 0.00540973f, 0.01798882f, 0.03258085f, -0.01439932f, 
    -0.00717759f, 0.17598270f, 0.20643513f, -0.31126475f, -0.03507256f, -0.05093416f, 0.01740805f, -0.05003031f, 
    0.16433734f, -0.08216631f, 0.00175419f, -0.05542462f, 0.04504498f, 0.09272448f, 0.18196833f, -0.22045472f, 
    -0.03782042f, -0.02351390f, 0.05004013f, -0.02092887f, 0.08564778f, 0.04630462f, -0.01234600f, -0.00491557f, 
    0.01483438f, -0.03132823f, 0.06309582f, 0.02950550f, 0.06889495f, -0.06463724f, -0.01372366f, -0.00493773f, 
    -0.07870112f, 0.01318041f, 0.10546413f, 0.08704769f, -0.03573392f, 0.15904135f, 0.17497464f, -0.09265287f, 
    0.00873278f, -0.13810880f, -0.11713306f, 0.08152532f, -0.02761449f, -0.13626820f, 0.05089402f, 0.03316551f, 
    -0.29026577f, -0.04692092f, 0.17341904f, 0.06149350f, -0.06084043f, 0.13179904f, 0.04162309f, 0.02624483f, 
    -0.04229444f, 0.05618006f, 0.07863155f, -0.07495324f, -0.23260704f, -0.15681480f, -0.13101864f, 0.06908054f, 
    0.07867421f, -0.10660124f, -0.04278275f, -0.07869837f, 0.12272386f, 0.00462437f, 0.12209668f, 0.07974111f, 
    0.00330205f, -0.04588614f, 0.21748969f, 0.12498886f, -0.08804649f, -0.20116150f, 0.01545095f, 0.12743166f, 
    0.01658723f, 0.01617941f, -0.11907943f, 0.09896050f, 0.35511360f, 0.14678544f, -0.25795951f, -0.10229006f, 
    0.02653083f, 0.01852554f, -0.16888666f, -0.18423860f, -0.01706977f, 0.02764669f, -0.07306307f, -0.09000792f, 
    -0.23968752f, -0.05985838f, -0.20727928f, 0.07188427f, -0.01213650f, -0.02040121f, -0.04419058f, -0.10419042f, 
    0.00414205f, 0.01589607f, 0.10889274f, 0.02822015f, 0.08753522f, -0.09239891f, -0.18658952f, 0.07818797f, 
    -0.04586672f, 0.12302260f, -0.07899319f, -0.03133083f, -0.01954860f, -0.06039570f, -0.01699029f, 0.00957669f, 
    0.10719069f, -0.12936211f, 0.01534867f, 0.03952639f, -0.03476271f, -0.05091704f, -0.02315811f, 0.04955902f, 
    -0.03209589f, 0.13053834f, -0.06482181f, 0.02572066f, 0.14157937f, 0.04202136f, -0.08252109f, 0.03393259f, 
    -0.17073271f, 0.13462062f, -0.04024070f, -0.08919179f, -0.05447411f, 0.09690146f, 0.02302730f, 0.01083015f, 
    0.18611547f, -0.22038950f, 0.13702703f, 0.09578442f, -0.09034289f, -0.00560225f, -0.07327002f, 0.06066312f, 
    0.11766081f, -0.01643758f, 0.08847643f, 0.06748179f, -0.08377440f, 0.23541172f, 0.08186135f, -0.06090353f, 
    -0.18066360f, -0.04636370f, -0.01031531f, 0.09472204f, 0.04211282f, -0.09490697f, 0.02797686f, -0.05692056f, 
    0.07034638f, 0.12488174f, -0.00942997f, -0.00956161f, -0.05693861f, 0.12224627f, 0.14442746f, 0.08966813f, 
    0.12611048f, 0.02428096f, 0.14355296f, 0.04088397f, -0.05886558f, 0.01435117f, 0.14988418f, 0.18837404f, 
    -0.07406019f, 0.00226875f, 0.13050961f, -0.04147971f, -0.04839472f, -0.04890828f, 0.13438022f, 0.02621121f, 
    0.08119246f, 0.26896790f, 0.03177542f, -0.34940922f, 0.04225071f, -0.02226531f, 0.03767205f, 0.01007740f, 
    -0.07079390f, 0.01587267f, -0.01330941f, -0.18747056f, 0.46610534f, -0.29905552f, 0.06752948f, 0.12408997f, 
    -0.01552680f, -0.01759934f, -0.04869230f, 0.01379080f, -0.05530808f, 0.02708778f, -0.06293469f, -0.11420487f, 
    -0.06242731f, 0.05061889f, 0.11971061f, -0.05782921f, 0.03457767f, -0.18444258f, -0.05885210f, 0.02856007f, 
    -0.00280360f, 0.03506292f, -0.13410638f, 0.06918834f, -0.41620287f, 0.19265634f, 0.17991042f, -0.09459063f, 
    0.00480604f, 0.02894997f, -0.02759067f, 0.06721655f, -0.01756378f, 0.04728568f, 0.03353413f, -0.07833963f, 
    -0.15076680f, -0.06891723f, -0.24118066f, 0.31073844f, 0.02253047f, 0.07947638f, 0.00254037f, 0.04142091f, 
    0.05169449f, -0.12558673f, -0.06662896f, -0.07853172f, -0.02163073f, -0.05300269f, 0.10672978f, 0.09194670f, 
    0.04265265f, 0.09697524f, -0.08884627f, -0.10446589f, -0.08984470f, -0.27705008f, -0.10540704f, -0.13693076f, 
    0.04786003f, -0.12735392f, -0.01665170f, -0.18114203f, -0.01150827f, -0.01933867f, 0.02789561f, -0.08118696f, 
    0.03359751f, -0.10106015f, 0.03106427f, -0.20187154f, 0.09090164f, -0.10227444f, 0.06319599f, 0.06969800f, 
    -0.05736155f, 0.02974027f, -0.00041855f, 0.06623055f, -0.00003686f, -0.07175622f, -0.08179126f, -0.07138060f, 
    0.14290115f, -0.20226437f, 0.01929309f, -0.19774920f, -0.10389917f, 0.02218423f, 0.04962159f, -0.20685862f, 
    -0.00196175f, -0.09265624f, 0.15950620f, 0.12972580f, 0.04666209f, 0.07658873f, 0.11924394f, -0.07306665f, 
    -0.00755111f, -0.07812716f, 0.06838195f, 0.02085122f, 0.03899556f, 0.03179890f, 0.12867206f, 0.10218996f, 
    -0.25442669f, 0.17539494f, 0.07752710f, 0.18237634f, 0.01812522f, -0.04284955f, 0.04452818f, 0.02624669f, 
    -0.06697492f, -0.00082008f, 0.01395342f, -0.06838425f, 0.24147327f, -0.26046520f, 0.23500483f, -0.15687469f, 
    0.04885855f, -0.01684515f, 0.00879801f, -0.02204082f, 0.05770679f, 0.00881046f, 0.07265138f, 0.17624940f, 
    0.18096809f, 0.01575019f, -0.13206907f, 0.22627041f, -0.12206193f, -0.06259395f, 0.10265823f, 0.05593605f, 
    0.04482423f, -0.01315680f, -0.04720668f, -0.16488397f, 0.08018814f, -0.03504686f, -0.00387696f, -0.03985033f, 
    -0.04580499f, -0.01017775f, 0.09985436f, -0.00259071f, -0.00394846f, -0.01707730f, 0.16931798f, -0.07520076f, 
    0.26764190f, 0.01821214f, -0.02386644f, -0.00592239f, 0.01708337f, -0.01814260f, 0.05362250f, 0.11933003f, 
    -0.01877717f, 0.00971954f, 0.09555588f, -0.04062679f, 0.07295597f, -0.18571262f, 0.19143204f, -0.18422130f, 
    0.08439416f, -0.04528416f, 0.09203364f, -0.01754815f, 0.01166866f, 0.03734187f, -0.07523856f, -0.12683882f, 
    -0.15749954f, -0.12441100f, -0.05203466f, 0.00901283f, -0.00861170f, 0.04963934f, -0.05522771f, -0.02562389f, 
    -0.11133417f, 0.03554504f, 0.07451600f, -0.16224986f, 0.01948069f, 0.03184462f, -0.01595968f, -0.11634485f, 
    0.00840593f, 0.08499514f, 0.09233297f, -0.06357408f, -0.13589306f, 0.11214185f, 0.04562573f, -0.09441318f, 
    -0.16462287f, -0.29777989f, -0.06047939f, -0.08151446f, 0.03627798f, 0.02184098f, -0.00826256f, -0.15275820f, 
    -0.00518480f, -0.03523275f, 0.12754232f, 0.12551922f, 0.13822241f, -0.18219440f, -0.11831620f, -0.10989850f, 
    -0.00170072f, -0.12856069f, -0.03724772f, -0.10947125f, -0.11875896f, 0.10191310f, -0.14492275f, -0.05923186f, 
    -0.35639334f, -0.01481229f, 0.06563900f, 0.22786471f, 0.07226361f, -0.12118704f, -0.05772680f, -0.03668560f, 
    -0.15375224f, -0.15706836f, -0.10765712f, -0.11007236f, 0.12196680f, 0.10707608f, -0.02133706f, -0.26807112f, 
    -0.14365342f, 0.00602526f, 0.07116754f, 0.07360959f, 0.04470537f, 0.04854903f, 0.00966457f, 0.03052723f, 
    -0.16927984f, -0.19414398f, -0.04519483f, 0.08087718f, 0.13010409f, -0.05351611f, 0.04839168f, -0.04715522f, 
    -0.01852234f, -0.05733038f, 0.05506169f, -0.03856887f, -0.13334008f, 0.03486219f, -0.07371281f, 0.01725668f, 
    0.05110729f, -0.09144698f, 0.07733712f, -0.00326601f, 0.07300536f, -0.05844847f, -0.00795231f, 0.00546867f, 
    0.24472044f, -0.09239085f, 0.12322758f, 0.00702125f, -0.04807607f, 0.06915904f, -0.13684903f, 0.05991903f, 
    -0.02605906f, 0.10267556f, -0.05852078f, 0.18402582f, -0.15000083f, -0.28191882f, 0.01607347f, -0.33011696f, 
    0.13205603f, 0.03175563f, -0.00781767f, -0.12341422f, -0.01653983f, -0.04765663f, 0.03726016f, -0.02960055f, 
    -0.59710276f, 0.24729732f, 0.04658476f, 0.27440357f, -0.08936879f, 0.13996699f, 0.08059361f, 0.06446738f, 
    0.04447101f, 0.08278324f, 0.03919948f, 0.01068404f, 0.18529528f, -0.33714816f, -0.00598640f, 0.16317357f, 
    -0.00087384f, 0.01229145f, 0.10416294f, 0.04422695f, -0.03467390f, -0.04643898f, 0.08644973f, 0.21277429f, 
    -0.08977371f, -0.10577524f, -0.06301298f, -0.19078726f, -0.11283198f, 0.04889426f, -0.06733189f, 0.02305239f, 
    -0.03056452f, 0.06010718f, -0.04945780f, 0.07091121f, 0.01540885f, -0.15376630f, -0.28767154f, 0.03993234f, 
    0.07356861f, 0.09759717f, 0.04832952f, -0.08788906f, -0.04731107f, -0.04779242f, -0.05563223f, -0.06870842f, 
    0.22318089f, -0.13241796f, -0.02565123f, -0.11734238f, -0.03323844f, -0.02885659f, 0.07036179f, 0.00722823f, 
    -0.12161821f, 0.01695661f, -0.02779005f, -0.10528391f, 0.00236020f, 0.10735223f, 0.07298865f, -0.12904963f, 
    -0.06506909f, 0.00084742f, 0.04414485f, -0.00603299f, -0.02245888f, 0.09221327f, 0.00644764f, -0.00022974f, 
    0.14129266f, -0.12898292f, -0.05320082f, 0.17939685f, -0.02275930f, 0.03862530f, -0.08340061f, 0.07529192f, 
    0.07654246f, -0.03530486f, 0.02510397f, -0.02390754f, 0.19504388f, -0.17206471f, 0.06112746f, -0.14231777f, 
    0.09486860f, 0.01527438f, 0.00737830f, -0.09790616f, -0.01469678f, -0.15964666f, -0.03900127f, 0.01401258f, 
    -0.23862128f, 0.10248453f, -0.11998436f, -0.00404467f, 0.10364626f, 0.14800659f, 0.02060487f, -0.00232922f, 
    -0.01148896f, 0.07954105f, 0.00271343f, 0.10064309f, -0.03523495f, -0.18498069f, -0.16455695f, 0.06815116f, 
    -0.02043268f, -0.12067814f, 0.09351673f, 0.02039022f, -0.08356910f, 0.07499747f, -0.00801346f, 0.06984949f, 
    -0.04750237f, -0.31182587f, -0.12178034f, -0.07071313f, -0.01909543f, 0.03676815f, 0.04838720f, 0.12028067f, 
    0.02653163f, 0.03404161f, -0.09301905f, -0.00525397f, -0.10213818f, 0.00963961f, -0.13672620f, -0.08670152f, 
    -0.00611006f, -0.05126507f, -0.05079655f, -0.11965881f, -0.01870565f, 0.02146716f, 0.06361446f, 0.01352668f, 
    0.27573961f, 0.08666048f, -0.02153721f, 0.05128966f, -0.14050426f, 0.10525864f, 0.06771982f, 0.02400853f, 
    0.02797017f, -0.12410903f, -0.16766974f, -0.09845045f, -0.28431478f, 0.10239515f, -0.08611245f, -0.13027301f, 
    -0.09200022f, -0.02465572f, 0.04001730f, -0.04196019f, 0.03347011f, -0.08832622f, -0.04006701f, 0.08808245f, 
    0.36725846f, -0.08319233f, 0.05364612f, -0.05008574f, 0.02865452f, -0.07040438f, 0.10827511f, 0.04672533f, 
    0.03238053f, 0.06947641f, 0.03158614f, -0.01005331f, 0.19206066f, -0.06564119f, 0.09937298f, -0.08724393f, 
    0.14285433f, 0.06924517f, 0.27315834f, -0.12062409f, 0.00327706f, 0.01306773f, 0.06306161f, -0.00811035f, 
    -0.00629596f, 0.23319794f, 0.09634156f, -0.34855026f, -0.10918182f, -0.04691887f, 0.04141145f, 0.03129535f, 
    0.11037016f, -0.01807881f, 0.03367439f, -0.10890315f, 0.18018460f, -0.29378748f, -0.01482794f, 0.12393560f, 
    -0.22077923f, -0.00417395f, 0.04137606f, 0.07237724f, 0.00062863f, 0.13134305f, -0.08510981f, 0.24489637f, 
    -0.10364895f, -0.13385968f, -0.12697241f, 0.10837104f, 0.09486479f, 0.07540175f, 0.06967393f, -0.17037900f, 
    0.00824022f, -0.01232787f, 0.02073761f, -0.05707148f, -0.07350755f, 0.13553277f, 0.01770943f, 0.02010819f, 
    -0.02181195f, 0.14115787f, -0.03339253f, 0.03182241f, 0.08947079f, -0.18565448f, -0.08398206f, -0.13803510f, 
    0.05700913f, 0.00679332f, 0.15444811f, 0.02169626f, -0.09543978f, -0.04364771f, -0.03087975f, -0.00686984f, 
    0.10277944f, -0.04310149f, -0.03222946f, 0.05013934f, -0.28858316f, 0.07348609f, 0.01756745f, -0.06536380f, 
    0.05346976f, 0.08894742f, 0.01378498f, 0.00940579f, -0.05223165f, -0.08369235f, 0.00643089f, 0.02887451f, 
    -0.17773564f, -0.00703983f, 0.10035436f, 0.07806376f, 0.00999751f, 0.00437155f, 0.04046137f, 0.02688069f, 
    -0.03009092f, -0.07694992f, 0.01131343f, -0.04809607f, -0.11783265f, 0.12549472f, 0.18250252f, -0.30481443f, 
    -0.07601195f, -0.01329389f, -0.06598862f, 0.07531153f, -0.01299737f, -0.05250894f, -0.06895536f, 0.09366208f, 
    0.15568393f, 0.19789964f, 0.05497021f, -0.32993415f, -0.02969486f, 0.01707159f, 0.04129506f, -0.05695217f, 
    -0.04147535f, -0.03560977f, 0.01931494f, -0.00197992f, -0.09343027f, -0.19907139f, 0.06786284f, 0.03867337f, 
    -0.04122395f, 0.02745163f, 0.10804188f, 0.03109802f, 0.08496916f, 0.03813802f, -0.01525120f, 0.06282775f, 
    0.30891764f, 0.09649669f, 0.15973546f, 0.32705626f, -0.07186148f, 0.05014336f, -0.09266027f, 0.05283809f, 
    -0.04599153f, 0.01038020f, -0.01297454f, 0.12260613f, -0.08959223f, 0.09117763f, -0.13877206f, -0.11132748f, 
    -0.10866725f, -0.00014384f, -0.14335872f, -0.00532233f, -0.08505414f, -0.01376742f, -0.08214931f, -0.07656881f, 
    -0.06069485f, -0.04631208f, -0.12201091f, 0.01070195f, 0.02579542f, 0.15863824f, 0.00587525f, 0.03344268f, 
    0.05653288f, 0.01217815f, -0.04730614f, 0.13271351f, -0.28739026f, -0.20202880f, -0.32923988f, 0.08138877f, 
    -0.05826312f, -0.02822577f, -0.01403462f, -0.04865837f, 0.03566881f, -0.04903394f, 0.07392081f, 0.05681849f, 
    0.08072606f, 0.14588739f, 0.01946457f, 0.15197547f, 0.09178759f, -0.01214466f, -0.02305054f, -0.08143360f, 
    -0.04144904f, -0.06415540f, -0.00040085f, -0.14813761f, 0.03933474f, -0.02395933f, -0.03057889f, 0.07657395f, 
    -0.05005161f, 0.00929662f, -0.00782140f, -0.03677054f, 0.03705839f, -0.00756292f, -0.05207881f, -0.01318757f, 
    -0.13571620f, 0.10440326f, -0.07340022f, -0.00209262f, 0.00200726f, 0.00499561f, -0.05533975f, -0.10056686f, 
    -0.04276954f, 0.05160268f, 0.04545223f, -0.06239614f, 0.19451399f, 0.21436429f, -0.08116271f, 0.18297645f, 
    0.06085167f, 0.01285253f, 0.07028535f, 0.10893481f, 0.08884321f, 0.01106567f, 0.01150965f, -0.02645052f, 
    -0.12026037f, 0.00597744f, 0.06574592f, -0.05936123f, 0.00873629f, -0.00783642f, -0.10872594f, 0.02633321f, 
    -0.11797447f, 0.04724415f, -0.00478792f, -0.04270758f, -0.26994866f, 0.16014770f, 0.05564891f, -0.14298253f, 
    -0.03499642f, -0.00327374f, 0.00694227f, -0.00389459f, -0.08811126f, -0.05751668f, -0.02453464f, -0.07786668f, 
    -0.06337380f, -0.00533169f, -0.01426726f, 0.10382281f, 0.00101801f, -0.12001672f, -0.07707803f, -0.06751920f, 
    -0.04587592f, -0.00160269f, 0.00593372f, -0.08162721f, -0.08675956f, 0.06781708f, 0.00685442f, 0.03488749f, 
    -0.04735773f, -0.09512146f, 0.07902326f, -0.08445461f, -0.01945378f, -0.01102099f, -0.00954359f, 0.06124295f, 
    -0.15552957f, -0.07871154f, 0.07790099f, -0.14843537f, 0.04024811f, 0.05933568f, -0.09154832f, -0.00529008f, 
    -0.03200407f, 0.04734112f, -0.00320833f, 0.05937425f, 0.33482325f, -0.14698106f, -0.03444759f, 0.10546409f, 
    0.22315086f, -0.05928508f, 0.04199333f, -0.05964917f, -0.00177216f, -0.00516771f, -0.02808392f, -0.06729841f, 
    -0.00329307f, -0.07367747f, -0.10304809f, -0.15428410f, -0.00654075f, -0.05921119f, 0.02439605f, -0.07784561f, 
    -0.00525069f, -0.01106783f, 0.02712670f, -0.09906577f, -0.16423029f, 0.04331299f, -0.09678004f, -0.17899661f, 
    0.01703016f, 0.02287612f, -0.07433446f, -0.00776230f, -0.07184508f, -0.05594006f, -0.02138531f, -0.04424914f, 
    -0.09764023f, -0.15658745f, 0.00970843f, 0.00678194f, -0.01276507f, -0.02897162f, -0.07843123f, -0.01347135f, 
    -0.00227871f, -0.08135285f, -0.03575001f, -0.09278634f, 0.00475817f, -0.06608410f, -0.02895682f, 0.06331420f, 
    -0.04124472f, 0.03201685f, -0.14372027f, -0.10639130f, 0.04451336f, -0.03834932f, -0.00599993f, -0.03287280f, 
    0.14934102f, -0.02336167f, 0.04081053f, 0.11369070f, -0.11089188f, -0.01987145f, -0.05013785f, -0.02883498f, 
    -0.03739326f, 0.05522771f, -0.05613082f, 0.03263319f, 0.02768588f, -0.02836163f, -0.04508105f, -0.05446124f, 
    -0.08917184f, -0.00770941f, 0.05081780f, -0.03414593f, 0.01197914f, -0.04774775f, -0.09307081f, -0.04233063f, 
    0.12855873f, 0.09667352f, 0.24379858f, 0.05416396f, 0.04036317f, 0.00793915f, 0.06700986f, -0.02843187f, 
    0.00857875f, 0.06834138f, 0.02354267f, 0.01817981f, -0.15705071f, -0.19248740f, -0.15630123f, -0.13284379f, 
    -0.04948822f, -0.03410919f, -0.06270030f, -0.04849415f, -0.08300264f, 0.03031412f, -0.05951281f, 0.03530803f, 
    -0.07283869f, -0.05528275f, -0.20002267f, -0.07478025f, -0.07762285f, 0.02717098f, -0.06157432f, -0.04921823f, 
    -0.04022361f, -0.06086802f, 0.00192321f, -0.01784716f, 0.10179203f, 0.14179163f, 0.07289138f, -0.17497580f, 
    -0.14394189f, -0.04275645f, -0.02693699f, -0.12559725f, 0.00397351f, 0.01804681f, -0.08382399f, 0.00253221f, 
    0.18673278f, 0.09471580f, 0.00817837f, 0.18193892f, 0.13835509f, 0.01437316f, 0.00812186f, 0.02179985f, 
    -0.03427246f, -0.01060144f, -0.03189383f, -0.07757426f, 0.15651204f, -0.05203793f, 0.17206196f, -0.03248943f, 
    -0.09594674f, 0.06421533f, -0.11033923f, -0.02133454f, 0.04818652f, 0.01761540f, -0.06323168f, 0.03510703f, 
    0.12751332f, 0.12069143f, 0.12924123f, -0.02302870f, -0.07525446f, 0.03812654f, 0.00666881f, 0.03310578f, 
    -0.00658783f, 0.08310234f, 0.02709346f, 0.01248552f, 0.24254800f, -0.04655663f, 0.11414943f, -0.02258903f, 
    -0.01313266f, -0.00413651f, 0.04318235f, -0.04636144f, -0.06722049f, 0.01339598f, -0.02616782f, -0.15923300f, 
    0.12098955f, 0.01544220f, 0.02227288f, 0.07849021f, 0.12727134f, 0.00928720f, -0.01119293f, -0.02123582f, 
    -0.05443946f, -0.00969663f, 0.05257661f, -0.07872470f, -0.01641645f, 0.13772956f, -0.00083132f, -0.03344665f, 
    -0.12491146f, 0.00576917f, -0.00391993f, -0.07435078f, -0.08585075f, -0.04245919f, -0.00630474f, -0.07633459f, 
    0.03887658f, 0.12668157f, 0.06972805f, 0.19820082f, 0.06627769f, 0.04564135f, 0.06183433f, 0.05841729f, 
    -0.02315401f, 0.00176819f, 0.01481992f, -0.04976797f, -0.06130679f, -0.00968326f, 0.17166810f, 0.14382291f, 
    0.07815438f, 0.03959543f, -0.00050927f, 0.05386835f, -0.11063609f, 0.04157376f, 0.10201892f, 0.03659602f, 
    0.09788293f, -0.08771118f, 0.09637485f, 0.13348946f, 0.12498140f, -0.01139428f, -0.02770426f, 0.02260122f, 
    -0.03536965f, -0.11536939f, 0.01315226f, -0.05460930f, -0.22883676f, -0.09236536f, -0.17949989f, 0.08045310f, 
    -0.01898717f, -0.07029843f, 0.00644802f, -0.02497486f, -0.12719716f, 0.03084100f, 0.00560635f, -0.00434965f, 
    0.12551926f, 0.16538350f, 0.12879880f, -0.01180734f, 0.02232547f, 0.02816390f, 0.07107827f, -0.01508302f, 
    -0.01346237f, 0.03966905f, -0.01038211f, -0.05235738f, 0.19144344f, -0.32936618f, 0.11995253f, 0.21836478f, 
    -0.02830117f, -0.10426043f, -0.07123137f, -0.04172058f, -0.02734536f, -0.08581291f, -0.11185878f, -0.05462482f, 
    -0.04064286f, 0.08084475f, -0.01704947f, 0.07496374f, -0.02650337f, -0.01530360f, 0.04782880f, -0.01969148f, 
    -0.04166148f, 0.00847750f, 0.03410881f, -0.01201335f, 0.06125108f, -0.02615852f, 0.23814800f, 0.09537289f, 
    0.06269982f, 0.04753470f, 0.09163708f, 0.01337103f, -0.07902612f, 0.13831334f, 0.06886169f, -0.07932945f, 
    0.02131358f, -0.06640760f, -0.23411459f, -0.03354138f, -0.11962119f, -0.03986014f, -0.11087730f, -0.04925324f, 
    0.00191661f, 0.08672017f, 0.01816100f, -0.14609352f, -0.00650673f, -0.09521500f, -0.03295786f, -0.13897569f, 
    0.03946944f, -0.10097320f, -0.07955379f, -0.00872687f, -0.01253152f, 0.00092817f, -0.02572597f, 0.02755923f, 
    -0.08516452f, 0.08990179f, 0.04965916f, 0.16218174f, 0.14023268f, 0.05139989f, 0.09584376f, 0.05130243f, 
    0.04343653f, -0.04835754f, 0.06239283f, 0.00785248f, -0.04807825f, 0.09866482f, -0.08606544f, 0.11771820f, 
    -0.09523361f, -0.02115562f, -0.06435839f, 0.01561871f, -0.07935954f, -0.04460908f, -0.06400076f, -0.02026744f, 
    0.26478228f, -0.16690047f, 0.07076650f, 0.07921041f, 0.08230144f, -0.01037096f, -0.01386197f, -0.06000551f, 
    -0.04750321f, -0.05278429f, -0.02082704f, -0.03111507f, -0.02562447f, 0.06468382f, -0.07269367f, -0.03656359f, 
    -0.14955552f, -0.00743504f, -0.07303630f, -0.03769666f, -0.04242963f, -0.03067382f, -0.00444934f, -0.05534910f, 
    0.01701781f, 0.03435513f, -0.03367787f, 0.18147981f, 0.04335100f, 0.00572709f, 0.01395327f, 0.08960536f, 
    -0.07364810f, -0.03899296f, -0.09713311f, -0.10348822f, 0.13529666f, -0.16130982f, 0.03777814f, 0.01251243f, 
    0.00339016f, 0.03076022f, -0.03974603f, -0.05788952f, 0.01629089f, 0.05850133f, 0.13865265f, -0.14615165f, 
    -0.00204197f, -0.13624646f, 0.02917753f, 0.15011063f, -0.00508340f, -0.09354015f, -0.04961156f, -0.03137083f, 
    -0.07860518f, 0.00205163f, 0.10547896f, 0.03249777f, 0.05666036f, -0.06415915f, -0.10357241f, -0.04297942f, 
    -0.09288821f, 0.01478064f, -0.09178784f, -0.01508036f, 0.09931305f, 0.08829784f, -0.04559670f, -0.04288517f, 
    -0.00887731f, 0.05781103f, 0.12288292f, -0.00076758f, 0.10489289f, 0.06823419f, 0.02924757f, -0.09420759f, 
    -0.05753670f, 0.07062315f, 0.00180342f, -0.04952150f, 0.02338853f, 0.08636044f, 0.03963561f, 0.12793693f, 
    0.05385548f, 0.02608017f, -0.01655040f, -0.05318688f, -0.01715044f, 0.02402014f, -0.06324533f, 0.00064550f, 
    0.07612895f, -0.14693204f, 0.13736933f, 0.09985504f, -0.05515225f, -0.05222534f, 0.02087249f, -0.02974359f, 
    0.04053005f, 0.02063553f, -0.08984493f, -0.09062231f, 0.14534073f, 0.08178829f, 0.17567350f, 0.10306372f, 
    -0.01287832f, -0.08027469f, 0.03649944f, -0.11398717f, -0.02150520f, 0.07725722f, -0.00435504f, 0.02124920f, 
    -0.00601905f, -0.08047497f, 0.03895601f, 0.04079537f, 0.03744042f, -0.07725669f, -0.00823967f, -0.02667190f, 
    0.00514808f, 0.06386853f, 0.03643379f, 0.05629431f, 0.26133054f, 0.01871547f, 0.24330911f, -0.12955032f, 
    -0.10808931f, 0.01179529f, -0.02550799f, 0.01198860f, 0.05794041f, 0.13808118f, 0.01836195f, -0.01465559f, 
    -0.30569857f, 0.12593740f, -0.11623451f, -0.12695180f, -0.00609322f, -0.02001684f, 0.01647319f, -0.09239818f, 
    -0.03520959f, 0.00896736f, 0.01106788f, -0.07681321f, -0.06660262f, -0.11596761f, -0.02918795f, -0.08031585f, 
    -0.02627902f, -0.07339643f, -0.02335615f, -0.04691010f, -0.00167433f, -0.01571480f, -0.04280288f, -0.00043514f, 
    0.06344355f, 0.02948139f, -0.02413825f, 0.11640366f, 0.07802150f, -0.10151774f, -0.09179684f, -0.00446737f, 
    0.03601182f, -0.04137500f, -0.00456497f, -0.04918308f, -0.18784885f, 0.07752334f, 0.07407327f, -0.05925738f, 
    0.01567196f, -0.10018519f, -0.14169186f, 0.01978960f, -0.07107329f, -0.02407059f, 0.01055188f, -0.05042276f, 
    -0.17915310f, -0.06811911f, -0.32956111f, 0.03017323f, -0.03924377f, 0.00777159f, -0.00178116f, -0.05501778f, 
    -0.01474285f, -0.05770256f, 0.00673678f, -0.02695548f, -0.12245221f, 0.11151785f, -0.08446492f, -0.02329130f, 
    -0.04363164f, -0.04460115f, -0.05444083f, -0.01195984f, -0.04177026f, -0.06909675f, 0.06865540f, -0.04171739f, 
    -0.14165623f, 0.03995734f, -0.00852035f, -0.10623424f, -0.02258782f, -0.04722231f, -0.00028999f, -0.08335284f, 
    -0.02107475f, -0.04781993f, -0.01187797f, -0.06486078f, -0.06636221f, 0.07449777f, -0.07918096f, -0.10763904f, 
    -0.10111379f, -0.01080426f, -0.01469256f, -0.11192571f, -0.00688526f, -0.02810169f, -0.03809299f, -0.04580809f, 
    -0.03963199f, -0.24115434f, -0.03458733f, -0.07915673f, -0.00711310f, -0.01741371f, -0.01583557f, -0.06790899f, 
    -0.06395254f, -0.02091429f, -0.03162150f, -0.01929449f, 0.03403480f, 0.00243630f, -0.08285833f, -0.01119247f, 
    -0.09256618f, 0.00037770f, 0.00321458f, -0.14048682f, -0.12589291f, -0.02647111f, 0.00784716f, -0.05846515f, 
    -0.10705483f, 0.15076612f, -0.02501970f, 0.19420455f, -0.06019277f, -0.10638235f, 0.02561359f, 0.01169841f, 
    -0.08508835f, 0.07034378f, -0.03217817f, 0.01881449f, 0.07811406f, 0.10127396f, 0.05334245f, 0.23542526f, 
    0.03995677f, -0.04031212f, -0.06460094f, -0.07373774f, 0.06322823f, -0.02328771f, -0.03285751f, -0.06422678f, 
    0.04889157f, -0.16766191f, 0.04458343f, 0.10709970f, 0.02255872f, -0.10289408f, -0.12048614f, -0.07178694f, 
    -0.08487590f, -0.07610700f, -0.01732983f, -0.07223766f, -0.02848825f, 0.14797668f, -0.05506520f, 0.03037672f, 
    0.07586650f, -0.02398129f, 0.05169619f, -0.01261438f, 0.11069479f, 0.00643896f, -0.02144087f, -0.04109845f, 
    -0.11217041f, 0.06573151f, -0.12168703f, -0.23060866f, 0.05456841f, -0.05151652f, 0.05902342f, 0.02023763f, 
    0.02335355f, -0.04399965f, -0.15175891f, 0.00054293f, 0.07449749f, 0.14843671f, -0.10870635f, -0.03943820f, 
    0.01828087f, -0.00587003f, 0.13850367f, -0.09709291f, 0.01380823f, 0.03712141f, 0.02985761f, 0.02893591f, 
    -0.06826830f, -0.07386943f, -0.13671069f, -0.02262098f, 0.08066130f, -0.00084035f, -0.05479918f, -0.00835297f, 
    0.11373215f, -0.01028338f, -0.02109636f, -0.01174055f, -0.15217997f, 0.08321123f, 0.02077127f, -0.08188351f, 
    -0.00135985f, -0.00798252f, -0.09058399f, 0.00502821f, 0.03936032f, -0.07049082f, -0.01714395f, 0.04513543f, 
    -0.07759859f, -0.20240262f, 0.26460025f, 0.02931657f, 0.01489812f, -0.05600242f, 0.02046230f, -0.12822726f, 
    -0.04413451f, -0.06059473f, -0.20616424f, -0.04291545f, 0.16727313f, -0.00733867f, -0.05855538f, 0.15059456f, 
    0.11058541f, -0.10590958f, -0.14148264f, -0.07444681f, 0.05359058f, 0.10261051f, 0.01434946f, 0.00437964f, 
    -0.08346757f, -0.07850528f, -0.17175089f, -0.08738735f, 0.07521499f, -0.16931710f, 0.00479241f, -0.02266299f, 
    0.02916032f, 0.04135951f, -0.06226867f, -0.00617185f, 0.12064785f, 0.04627611f, -0.01991756f, -0.01922373f, 
    0.02284431f, -0.03538648f, -0.07383127f, 0.03851186f, -0.06489903f, 0.06617665f, -0.02429644f, -0.03138774f, 
    -0.14398836f, -0.11195492f, 0.07685902f, 0.11673876f, 0.12650059f, -0.20451443f, 0.02388038f, 0.05693268f, 
    0.10009583f, 0.09637673f, -0.11670353f, -0.00862950f, 0.01935114f, -0.15583880f, 0.08884694f, -0.12271017f, 
    -0.02894284f, -0.04998790f, 0.01143404f, -0.07862574f, -0.01524841f, 0.06363475f, 0.08218070f, -0.07071458f, 
    0.13074066f, -0.09978036f, -0.08112480f, 0.00971926f, 0.14514180f, 0.00235462f, 0.02860943f, -0.00497229f, 
    0.05246188f, -0.10306451f, 0.13205101f, 0.07569423f, 0.06577033f, -0.04562465f, -0.03768780f, 0.05020327f, 
    0.06516322f, -0.04912085f, 0.03004914f, 0.00778013f, 0.00560425f, 0.01549021f, -0.01667640f, 0.03155482f, 
    0.22410509f, 0.28636318f, -0.28932810f, -0.03395387f, 0.05517777f, 0.03899692f, -0.05515721f, -0.09330429f, 
    0.10594114f, 0.08448779f, -0.11857478f, 0.04491166f, -0.02125411f, 0.15509781f, -0.10924483f, -0.14043389f, 
    -0.11457648f, -0.04250400f, 0.04498192f, 0.05002063f, -0.10810950f, -0.00059241f, 0.08450158f, 0.03861101f, 
    -0.06207418f, -0.04497442f, -0.00457063f, -0.22211161f, -0.07440951f, -0.07085190f, 0.11666191f, -0.12871659f, 
    -0.05529112f, 0.01225842f, -0.02787491f, 0.13327084f, 0.03612418f, 0.11019149f, 0.03571147f, 0.17924966f, 
    0.02444245f, -0.02112815f, -0.05058203f, -0.09322425f, 0.02459389f, 0.08163746f, 0.14503494f, -0.05483334f, 
    -0.03325947f, -0.03760686f, 0.13726531f, 0.00016559f, -0.00449274f, 0.04506400f, 0.00597160f, 0.12075524f, 
    0.04125593f, -0.06358293f, -0.07862681f, -0.03466672f, 0.09496005f, -0.14195874f, -0.08836091f, 0.10756305f, 
    0.11499486f, 0.04164995f, -0.00697943f, -0.04692959f, 0.04431868f, -0.06332114f, 0.06925693f, 0.07327588f, 
    0.23186797f, -0.04622658f, -0.12164602f, 0.10039410f, 0.05648610f, 0.00523525f, -0.00413323f, -0.09013442f, 
    -0.00943007f, 0.04741904f, 0.06449176f, 0.02623934f, -0.10649581f, 0.10068410f, -0.09355027f, -0.22062658f, 
    -0.07628541f, -0.02712435f, 0.01814834f, 0.11865290f, 0.11540852f, -0.02824009f, 0.00342713f, -0.06618864f, 
    0.05060556f, -0.00681344f, 0.03235459f, -0.16255774f, 0.03230911f, -0.01937031f, -0.15940475f, -0.07541503f, 
    -0.10206471f, 0.01504560f, 0.06175948f, 0.03307854f, -0.14374350f, -0.03527949f, 0.09489257f, -0.12695204f, 
    0.02055446f, -0.01004275f, 0.00022974f, -0.02584244f, -0.02220028f, 0.00132961f, -0.01309548f, 0.08039754f, 
    -0.04570275f, -0.01682614f, -0.17069501f, -0.07672948f, 0.05436826f, -0.09757978f, 0.10142148f, -0.24733387f, 
    -0.04354107f, 0.01786061f, -0.05952987f, 0.16370195f, 0.09197541f, -0.20826247f, 0.06540782f, -0.11765172f, 
    0.00482849f, -0.07485119f, -0.01653651f, 0.06538742f, -0.02249932f, 0.01426297f, 0.05325814f, 0.11095519f, 
    0.02614369f, -0.15650588f, 0.06794382f, -0.12499088f, 0.00680709f, -0.04993568f, 0.03446084f, -0.01244462f, 
    -0.04847307f, -0.01229260f, 0.00313280f, 0.09235191f, -0.07792202f, -0.03471539f, 0.14185625f, -0.02123913f, 
    -0.12361285f, -0.02084333f, -0.16843893f, 0.12331460f, -0.03785409f, -0.07542032f, 0.04070282f, 0.01401004f, 
    -0.18290895f, 0.06410452f, 0.07446875f, -0.07751564f, 0.01957382f, -0.05725958f, -0.07522907f, -0.05196158f, 
    -0.01117007f, 0.03806911f, -0.09987350f, -0.18782134f, -0.07953847f, -0.07477999f, -0.02449903f, -0.22626279f, 
    -0.07656843f, 0.07825249f, 0.01917047f, -0.17606670f, -0.06316269f, -0.03929874f, -0.03973907f, 0.06378647f, 
    0.18815298f, 0.26774532f, -0.08404426f, 0.20631054f, 0.04169621f, -0.01722778f, -0.00906746f, -0.00105049f, 
    -0.09825080f, 0.03361293f, -0.04505831f, -0.00179198f, -0.06112838f, -0.13923757f, -0.16817474f, -0.00758864f, 
    0.04014263f, 0.00072529f, 0.00501275f, -0.01371985f, 0.08531877f, 0.13790479f, 0.03651212f, 0.00695633f, 
    -0.20290448f, 0.23800828f, -0.02416151f, -0.04770832f, -0.01732300f, 0.06865039f, -0.20012057f, -0.00755129f, 
    0.09027635f, -0.01548155f, -0.04680331f, 0.06587074f, 0.07676914f, -0.00919553f, 0.03031438f, 0.06280897f, 
    -0.04261847f, 0.01097864f, -0.16156319f, -0.07483467f, -0.12013299f, 0.01458370f, 0.04006357f, 0.01128456f, 
    0.05734547f, -0.07495669f, 0.06384883f, -0.02706418f, -0.06218638f, -0.05086785f, -0.04219772f, 0.07932525f, 
    -0.00653906f, -0.05815292f, 0.11349266f, -0.06499397f, -0.13685942f, 0.06159483f, 0.17549354f, 0.15590337f, 
    -0.17057504f, 0.01207164f, 0.02450893f, -0.04480253f, 0.02675513f, 0.04025061f, -0.17999670f, 0.00700536f, 
    0.06255771f, -0.02914430f, 0.00975256f, -0.00066193f, -0.04120365f, -0.03935353f, -0.02836460f, -0.00948976f, 
    0.03231786f, 0.01122174f, -0.08254675f, 0.13859844f, 0.14264445f, -0.04570320f, 0.00773636f, 0.10564612f, 
    0.07248969f, -0.01502192f, 0.00586079f, -0.11427150f, -0.00186118f, -0.03714195f, -0.07734068f, -0.03155340f, 
    -0.24314247f, 0.05701463f, 0.11356190f, -0.03788370f, -0.04435006f, -0.03842985f, 0.04181504f, -0.05779129f, 
    -0.01293505f, -0.01875831f, -0.03176322f, -0.03305745f, 0.10316066f, 0.26924276f, -0.13563170f, -0.08819621f, 
    0.02657491f, 0.07232879f, 0.08220413f, 0.00953781f, 0.13527672f, 0.04148125f, 0.03424657f, 0.09149026f, 
    0.00257745f, -0.18032803f, -0.06632428f, -0.12565920f, 0.00737103f, -0.03613913f, -0.00852627f, 0.00655831f, 
    0.00408075f, 0.08795007f, 0.07350076f, 0.05349314f, -0.09546871f, -0.00258890f, 0.10802831f, 0.14159739f, 
    0.07471894f, -0.02015744f, -0.03785676f, -0.09861279f, -0.05349934f, 0.04189070f, 0.03815656f, 0.03937216f, 
    0.11595267f, 0.04592217f, -0.06258795f, -0.25451419f, 0.13706152f, -0.12981929f, -0.09047745f, 0.01819570f, 
    0.07704987f, 0.04010882f, -0.01832559f, -0.00109467f, -0.21583046f, -0.10418142f, 0.10052824f, 0.09070943f, 
    -0.02445867f, -0.11592607f, 0.05122052f, 0.02781142f, -0.04530038f, 0.08661038f, -0.03976438f, 0.13285317f, 
    -0.13538696f, -0.05481668f, 0.04307306f, -0.05291672f, 0.08060322f, -0.05423732f, 0.00662478f, -0.00313298f, 
    0.07422842f, 0.01382207f, -0.08536982f, -0.22156222f, 0.00564551f, 0.25804421f, -0.04728705f, 0.06061761f, 
    -0.14259668f, 0.00044529f, -0.01629245f, -0.03159854f, 0.05437742f, 0.02442680f, -0.12357906f, -0.00647698f, 
    -0.20614851f, -0.10355137f, 0.16118298f, 0.02416325f, -0.19998762f, -0.02842106f, 0.02521197f, -0.06684456f, 
    0.01076964f, -0.12575972f, 0.07226694f, 0.04767653f, -0.18726006f, 0.06209314f, 0.14333540f, 0.01616638f, 
    -0.05536641f, 0.13805030f, -0.11847153f, 0.03652844f, 0.01758951f, -0.07572088f, 0.00568760f, -0.14822288f, 
    -0.18257295f, -0.22416079f, -0.12290341f, -0.05770278f, -0.08363974f, 0.04067552f, -0.06984335f, -0.03830672f, 
    0.02772323f, 0.07318415f, 0.12894948f, 0.03770411f, -0.11027268f, -0.01495236f, 0.12027760f, -0.16047455f, 
    0.11556248f, 0.04802676f, -0.14867288f, 0.06169994f, 0.01606276f, -0.00234579f, 0.02136235f, 0.06165981f, 
    0.11084241f, 0.01198176f, -0.05739633f, 0.05198144f, -0.04934742f, -0.08014067f, -0.02180899f, -0.02248002f, 
    -0.00382750f, 0.01916208f, 0.00133718f, -0.02731636f, -0.15520523f, 0.12800199f, -0.06247352f, -0.15375625f, 
    0.07136825f, -0.11868651f, -0.01629120f, 0.13312763f, -0.01479623f, 0.04073815f, -0.11119504f, -0.10417736f, 
    0.06405605f, -0.03481367f, 0.13309802f, 0.16241220f, 0.07105304f, -0.01041741f, -0.01105182f, -0.01973967f, 
    -0.02889270f, -0.03990313f, 0.08695805f, 0.06117434f, 0.22064088f, -0.02847198f, 0.01990314f, 0.04247406f, 
    -0.06382781f, 0.00987685f, -0.00167348f, -0.06300153f, -0.02980221f, -0.07087829f, 0.03321968f, -0.08012207f, 
    -0.09718706f, 0.19154328f, -0.14030340f, -0.22433309f, 0.06920216f, -0.00301540f, -0.11855385f, 0.07473700f, 
    -0.04315071f, 0.02315364f, 0.02524276f, 0.00115137f, -0.17749740f, -0.09303473f, -0.20923333f, -0.09396160f, 
    0.04420220f, -0.05946591f, -0.06877920f, -0.03459990f, 0.11543437f, 0.06125829f, 0.07741252f, 0.00129715f, 
    -0.06387420f, 0.12566590f, -0.16363604f, 0.00123831f, -0.04830639f, 0.00607225f, 0.01840433f, -0.04350845f, 
    -0.05798437f, -0.00459768f, 0.03783320f, 0.02287746f, 0.07104180f, -0.11715462f, -0.13105892f, -0.02294795f, 
    0.03723819f, -0.05131932f, 0.07032517f, -0.01332527f, 0.07498969f, 0.11614875f, -0.05027409f, -0.03596619f, 
    0.19185624f, -0.15146765f, 0.03882154f, 0.03469341f, -0.03912000f, -0.00245077f, 0.01627997f, -0.00924434f, 
    -0.00264361f, -0.02171649f, 0.04638085f, -0.04119199f, 0.20960999f, -0.01185240f, 0.04478792f, 0.11904825f, 
    0.07946426f, -0.03956373f, 0.02669696f, -0.09543324f, 0.04024136f, 0.04782567f, -0.00812032f, -0.06444681f, 
    -0.03094840f, -0.18766181f, -0.10778595f, 0.16063941f, 0.10980731f, 0.01118406f, -0.07292608f, 0.00735940f, 
    0.04786695f, -0.02603417f, 0.08682662f, -0.02172979f, 0.00304341f, 0.08296649f, 0.01303189f, 0.09697143f, 
    -0.10471176f, -0.03587670f, -0.11102504f, -0.02381125f, -0.00006002f, 0.01990282f, 0.01262061f, -0.14994475f, 
    -0.05559690f, -0.03477630f, -0.12545215f, -0.22956085f, 0.00126561f, -0.16420077f, -0.20283127f, -0.10852341f, 
    0.12674738f, -0.01655694f, -0.00059206f, -0.13442937f, -0.09658965f, 0.02667172f, 0.08748509f, -0.18973339f, 
    -0.10913769f, -0.08793431f, 0.01702250f, -0.08402042f, 0.01363473f, -0.02025365f, -0.04663210f, 0.07324914f, 
    -0.22181033f, -0.00360804f, -0.01907808f, -0.03804111f, 0.03757776f, 0.05542573f, 0.00327378f, 0.07696611f, 
    0.09423932f, 0.02236696f, -0.02141923f, 0.02914925f, 0.03618222f, 0.10893882f, -0.02717229f, 0.16906935f, 
    -0.03804199f, 0.06572177f, -0.08415113f, 0.00104028f, -0.12809910f, -0.05465874f, -0.06542899f, 0.09734444f, 
    0.07325883f, -0.20503499f, 0.12613913f, 0.02131761f, -0.12499873f, 0.04690832f, -0.02808553f, 0.02881601f, 
    -0.17407018f, 0.04379195f, 0.00454729f, -0.04338508f, 0.07264806f, 0.05598439f, 0.09481707f, 0.07700727f, 
    0.07034548f, -0.04465266f, -0.16184352f, 0.04125255f, 0.05593323f, -0.06055900f, 0.06602126f, -0.00116514f, 
    -0.32908422f, 0.09076092f, -0.07172994f, -0.19991033f, 0.03238767f, -0.01224253f, -0.05173595f, 0.01886033f, 
    0.03790286f, -0.07374047f, 0.16869184f, 0.02167880f, -0.59772182f, 0.06015638f, 0.23038527f, 0.06693701f, 
    0.01585474f, -0.05309923f, 0.02375984f, 0.19620085f, 0.09877539f, -0.10751543f, -0.02167666f, 0.02191103f, 
    -0.25132209f, 0.05740278f, -0.02652084f, 0.28355366f, 0.04209768f, -0.02899796f, -0.07341709f, 0.01612428f, 
    -0.02085919f, 0.10364480f, 0.05135910f, 0.07992551f, -0.06493360f, 0.10657186f, -0.05308426f, -0.07165862f, 
    -0.02384273f, 0.03584993f, -0.04041569f, 0.05999188f, 0.08401828f, 0.11789911f, -0.09258558f, 0.11109368f, 
    -0.06198262f, -0.08095802f, 0.00459364f, -0.13747589f, 0.01094956f, 0.03174269f, -0.21688342f, 0.05217731f, 
    0.03352999f, -0.01554654f, -0.11949993f, 0.01022461f, -0.06977773f, -0.38744497f, -0.01399410f, 0.05740078f, 
    0.12999883f, -0.08230022f, -0.10382352f, -0.19963369f, 0.00868353f, 0.10073699f, -0.08600787f, 0.01899355f, 
    0.07679703f, -0.28585759f, 0.06541320f, -0.18405217f, 0.06777497f, 0.04868319f, 0.08230968f, 0.03292611f, 
    0.01597934f, -0.04673034f, 0.16275163f, -0.01803910f, 0.08575823f, 0.06343883f, -0.04798440f, 0.03371479f, 
    0.16851929f, 0.02421428f, 0.03683077f, -0.08074655f, 0.01171569f, -0.06043108f, -0.01628860f, 0.19458775f, 
    0.00645852f, -0.03670197f, 0.10545698f, -0.06906553f, 0.10021376f, 0.05277795f, -0.02946985f, -0.11959066f, 
    -0.18361807f, -0.07653270f, -0.08789288f, -0.13748226f, -0.22302379f, 0.02333817f, -0.05410302f, 0.05800062f, 
    0.01781235f, 0.10383002f, -0.00981645f, -0.00694913f, 0.05067621f, -0.09074320f, 0.04217296f, 0.06113756f, 
    0.06966122f, -0.02575209f, 0.09743854f, 0.17069420f, 0.05930674f, 0.06099537f, -0.05582983f, -0.05943598f, 
    -0.06352883f, -0.09726437f, 0.07782363f, 0.03957043f, -0.08534192f, 0.03526524f, 0.06575662f, -0.16876876f, 
    0.01770286f, -0.02144522f, -0.01305356f, -0.06991921f, -0.07849941f, 0.21708797f, -0.05038904f, -0.10708439f, 
    0.14400111f, 0.17833963f, -0.06365540f, 0.11898887f, 0.02267111f, 0.04569230f, -0.02495724f, 0.13523516f, 
    -0.12641886f, -0.00006337f, 0.02701215f, -0.03844524f, 0.41082430f, 0.04250592f, -0.30846468f, -0.16097558f, 
    0.05157699f, -0.01727237f, 0.11777778f, 0.05318641f, 0.08903873f, 0.00334338f, -0.11266167f, 0.14385146f, 
    0.05130991f, -0.12312180f, -0.07157376f, 0.04807392f, 0.01755633f, -0.00275909f, -0.02225529f, -0.02818305f, 
    -0.17030360f, 0.12970890f, -0.00620861f, -0.00334731f, -0.08624871f, 0.07689552f, 0.05643077f, -0.20015499f, 
    0.10691472f, 0.06268613f, -0.14437158f, -0.09555615f, -0.12664899f, 0.09447575f, -0.03367141f, -0.06408817f, 
    0.07255097f, 0.09901315f, 0.06107091f, -0.07152697f, 0.03077090f, 0.08516365f, 0.04248196f, -0.03643290f, 
    0.06342407f, -0.04716764f, -0.11486300f, 0.03191949f, -0.46086597f, -0.04396006f, -0.29833004f, 0.11160751f, 
    0.09344446f, 0.03745419f, 0.11085196f, 0.01584364f, -0.09642995f, 0.10435335f, 0.04160722f, 0.08896887f, 
    -0.14504121f, -0.02470182f, 0.13840061f, -0.23511277f, 0.00846041f, -0.04640214f, 0.00763687f, -0.03190565f, 
    0.10003008f, -0.06624300f, -0.04805759f, 0.08355182f, 0.10438319f, -0.24126205f, -0.13309726f, 0.09720686f, 
    -0.06980579f, 0.00657012f, 0.00921596f, 0.00822691f, 0.05631926f, 0.08412290f, 0.10295901f, -0.10619334f, 
    -0.06135482f, -0.12007105f, -0.03092162f, 0.14174712f, 0.03423347f, 0.02142983f, -0.07424055f, -0.04649572f, 
    -0.03096181f, 0.06660723f, 0.03546564f, -0.06275599f, 0.13833788f, 0.21209708f, -0.16812891f, 0.01319411f, 
    -0.01605110f, 0.04520116f, -0.08228992f, -0.04794915f, -0.01536243f, -0.01695557f, -0.11113448f, -0.07684919f, 
    0.31471518f, 0.09228828f, -0.03454536f, -0.15573053f, -0.03693696f, -0.05872681f, 0.11107228f, -0.07444999f, 
    -0.07045906f, 0.06662655f, 0.09398149f, -0.09168391f, -0.16543245f, 0.09143811f, 0.02802043f, 0.03399954f, 
    0.02948465f, -0.05664114f, -0.06076451f, -0.10604109f, 0.10461739f, 0.02100804f, -0.07134346f, 0.11110102f, 
    0.24488676f, 0.16182756f, 0.01526619f, 0.02508761f, -0.01472097f, -0.02738417f, -0.01439180f, 0.07338214f, 
    0.08119024f, -0.01912871f, -0.00541412f, 0.02787435f, -0.05519228f, -0.18002769f, -0.04133456f, 0.26687658f, 
    0.03752442f, -0.01423556f, -0.16589703f, 0.01782511f, -0.17384872f, 0.00117843f, 0.12477416f, 0.14954931f, 
    0.26458251f, -0.51353431f, 0.04303702f, -0.14969940f, 0.11552061f, -0.02119400f, -0.07327265f, 0.05139750f, 
    -0.15935357f, 0.06349165f, 0.11469512f, 0.01014911f, -0.01447281f, 0.10896926f, -0.20762113f, -0.43383807f, 
    0.06482335f, 0.02608386f, 0.06055060f, -0.01622278f, 0.02295834f, -0.10706460f, 0.14629079f, 0.01781921f, 
    -0.14512600f, -0.02423993f, -0.09133990f, 0.08834670f, -0.02791140f, -0.02267360f, -0.02790462f, 0.09215390f, 
    -0.01851270f, 0.10255617f, 0.03021698f, -0.00933448f, 0.22819372f, -0.39796269f, -0.04108223f, 0.03533579f, 
    -0.05700016f, 0.00488684f, 0.05247661f, 0.09680042f, 0.05471655f, 0.13748172f, 0.05553402f, -0.04374596f, 
    -0.28166237f, -0.10326902f, 0.01497697f, 0.09309848f, 0.06653678f, -0.06203590f, 0.01591812f, -0.04061449f, 
    0.05804807f, 0.09947730f, -0.01060994f, -0.00412540f, -0.15984386f, -0.29621986f, -0.16836816f, 0.02900405f, 
    -0.04502751f, -0.00580456f, -0.01515310f, -0.00010377f, 0.00484037f, 0.02034076f, -0.01570344f, -0.06300190f, 
    0.21326700f, 0.19383964f, 0.06696706f, -0.08826039f, 0.03474335f, -0.00629353f, -0.05138296f, 0.05405043f, 
    -0.02855433f, -0.02634739f, -0.01492836f, -0.14995292f, 0.01329267f, 0.05230759f, -0.00110254f, -0.10110741f, 
    0.06273010f, -0.03851475f, -0.06702561f, -0.06947125f, 0.10626478f, 0.07495305f, -0.07651193f, 0.02517429f, 
    -0.04241262f, -0.37187061f, 0.07284942f, -0.07001372f, -0.00125359f, -0.00244180f, 0.12843315f, 0.16629465f, 
    -0.02204417f, -0.05484367f, 0.10370017f, 0.10860442f, 0.06238828f, 0.14353229f, 0.00076423f, 0.04363966f, 
    0.03410869f, -0.06810158f, 0.00866753f, 0.02790261f, 0.00821422f, 0.03839647f, 0.12062520f, -0.00453245f, 
    0.15161872f, -0.20606442f, 0.03602189f, 0.08887104f, -0.12270168f, 0.02681828f, 0.05829803f, -0.00724047f, 
    0.01686967f, -0.01869770f, 0.03447202f, -0.04770505f, 0.25284988f, -0.07102025f, -0.04338389f, -0.25476429f, 
    -0.03834756f, -0.07193411f, 0.05165254f, 0.02813869f, 0.09016424f, 0.01699758f, -0.02059981f, -0.01602894f, 
    -0.07482166f, 0.04376094f, -0.00538568f, -0.04942684f, -0.07203172f, -0.06910504f, 0.04906428f, 0.01270348f, 
    0.02177430f, -0.03520792f, 0.15710652f, 0.05941639f, 0.28259894f, 0.15809999f, -0.11910717f, 0.11578564f, 
    0.00132544f, -0.11489707f, -0.05820350f, 0.08485095f, 0.00785638f, -0.01183123f, 0.02764454f, -0.02347821f, 
    -0.01470887f, -0.18445966f, 0.08285507f, -0.16551380f, -0.02182082f, 0.07337637f, -0.07230823f, -0.00976028f, 
    -0.04216331f, 0.06337132f, 0.06252827f, 0.04151180f, 0.17770390f, 0.39856386f, -0.05709297f, 0.30690110f, 
    0.05556252f, 0.05381295f, 0.03635667f, 0.13103202f, 0.05413835f, 0.08734293f, 0.07527848f, 0.02268846f, 
    0.17452563f, -0.24785499f, 0.01861132f, 0.21476735f, 0.07859834f, 0.06327384f, -0.07030827f, -0.05928224f, 
    -0.07335719f, -0.05333989f, -0.01339789f, -0.07379144f, -0.26409608f, 0.00423994f, 0.15522896f, -0.05648843f, 
    0.06417359f, 0.04635699f, 0.00160119f, 0.00242034f, -0.03102110f, 0.03648330f, -0.03970079f, 0.18821082f, 
    -0.00626383f, -0.05832805f, -0.13444185f, -0.16611223f, -0.02843143f, -0.10445235f, 0.05792296f, -0.00983327f, 
    0.06082322f, 0.02698302f, 0.03999898f, -0.06813926f, 0.01392237f, -0.29158568f, -0.00123564f, 0.02106514f, 
    -0.00492877f, 0.03315612f, 0.06967445f, -0.13629353f, -0.04944424f, 0.02971727f, -0.08153013f, -0.02488870f, 
    0.24433368f, 0.01378953f, 0.10318654f, -0.12572797f, 0.02723329f, 0.12234078f, 0.06319586f, 0.06536394f, 
    0.02711991f, 0.01119954f, -0.17908715f, 0.13646883f, -0.11857406f, -0.11720227f, -0.10339530f, 0.09095418f, 
    -0.00561271f, 0.02697185f, -0.11943861f, -0.00966441f, -0.01673395f, -0.07232174f, 0.10863827f, -0.04879003f, 
    -0.23541754f, 0.17139640f, -0.08311857f, -0.29091367f, 0.06255108f, -0.05405066f, -0.03671235f, -0.06377493f, 
    -0.07693247f, -0.06846197f, -0.00031590f, -0.16038500f, 0.14748637f, -0.02631125f, -0.01849734f, -0.09876087f, 
    0.10534818f, 0.08736786f, -0.13327311f, 0.00048067f, 0.01488413f, 0.05796739f, 0.02397237f, 0.18129206f, 
    0.08763534f, -0.20811696f, 0.10711695f, -0.05486351f, -0.13457429f, 0.02930449f, -0.05260932f, 0.11523876f, 
    -0.00665308f, 0.06791122f, -0.04203296f, 0.03154162f, -0.18107454f, -0.08516833f, 0.05499504f, -0.12208847f, 
    -0.03861139f, -0.03330590f, 0.10753867f, 0.02607862f, -0.08532595f, 0.03728210f, -0.03472225f, -0.07238025f, 
    -0.07134342f, 0.45595792f, -0.16470778f, 0.12145814f, -0.06199023f, -0.02643802f, -0.02047316f, -0.11117785f, 
    -0.03700959f, 0.07305595f, 0.09226944f, -0.05889232f, -0.06095251f, 0.17561068f, 0.12789936f, -0.15665591f, 
    0.01453993f, 0.02362630f, 0.01122129f, -0.13016313f, -0.01485989f, -0.22554499f, -0.06461152f, -0.02706184f, 
    -0.31024268f, 0.11515910f, -0.08334481f, -0.12207600f, 0.11981262f, 0.00000039f, -0.03247829f, -0.03964416f, 
    -0.02249884f, -0.01776760f, 0.03272622f, 0.10764080f, -0.24858767f, 0.11223523f, -0.25077572f, 0.05148366f, 
    0.02331392f, 0.00685425f, -0.02193323f, -0.07039065f, -0.02574975f, -0.04567631f, 0.03862870f, -0.09300477f, 
    -0.20005246f, 0.01282069f, 0.01742817f, -0.30161321f, 0.01356155f, -0.15046254f, -0.02933920f, 0.04031664f, 
    -0.05991699f, 0.05413035f, -0.05440396f, 0.03979831f, -0.09756713f, 0.37031242f, -0.22358949f, 0.08587405f, 
    -0.02923711f, 0.12015887f, 0.00636455f, -0.07821995f, 0.03603041f, 0.05567751f, 0.06964637f, -0.01229569f, 
    -0.49645838f, -0.05434357f, 0.16530719f, 0.03267906f, 0.06087847f, -0.03641605f, -0.01464181f, 0.02348535f, 
    -0.12375828f, -0.03002377f, 0.01157189f, -0.00515522f, 0.10713860f, -0.07641291f, -0.14748010f, -0.18767010f, 
    0.11835830f, 0.06251334f, -0.04481724f, 0.04353944f, -0.12437284f, -0.12268831f, -0.11330906f, -0.02649108f, 
    0.19165738f, -0.35322690f, -0.19768405f, -0.13522609f, -0.03901064f, -0.00073416f, 0.00593565f, 0.05887187f, 
    0.04880456f, -0.01094272f, 0.12000535f, -0.03378375f, -0.18412179f, -0.06484742f, 0.15153453f, -0.01190595f, 
    0.01945350f, 0.01159012f, 0.07058240f, 0.17490320f, 0.08140792f, -0.00574029f, 0.04011349f, -0.07151852f, 
    0.04281147f, 0.07657737f, 0.11046696f, 0.02282866f, 0.07186642f, 0.03012883f, 0.06769230f, -0.03426792f, 
    0.01759604f, 0.07958651f, -0.01375257f, -0.10491191f, 0.02984333f, 0.00957017f, -0.00175588f, 0.00882430f, 
    -0.05629155f, -0.00803779f, 0.00281682f, -0.03148613f, 0.04024900f, 0.03867225f, -0.11723283f, -0.01892766f, 
    -0.19811484f, 0.15983872f, -0.19834025f, -0.12974213f, 0.24328670f, 0.03965079f, 0.02472839f, -0.08365571f, 
    0.00705279f, -0.02790153f, 0.12467358f, 0.00150517f, -0.03395280f, 0.04030623f, 0.00128494f, -0.02612094f, 
    -0.00365926f, -0.07657627f, 0.08745971f, -0.05599668f, 0.02900155f, -0.13032643f, 0.02122065f, 0.02593330f, 
    0.33215922f, 0.05838996f, 0.06657059f, 0.13689762f, -0.04345145f, -0.19687292f, -0.09297240f, 0.03994422f, 
    0.05321369f, -0.17604363f, -0.31251022f, -0.13510585f, -0.49825698f, -0.15366027f, -0.22077918f, -0.12699181f, 
    0.07861912f, -0.03857812f, -0.08313466f, -0.11819096f, 0.08134967f, 0.02551924f, 0.08647536f, -0.09911926f, 
    -0.01171522f, 0.01565026f, -0.10484005f, 0.02628540f, 0.00107995f, -0.03393177f, 0.09812395f, -0.00139360f, 
    0.09118346f, 0.12917785f, 0.02420232f, -0.00648220f, 0.17738815f, 0.01805579f, -0.03424913f, -0.01012512f, 
    -0.09525980f, -0.09289724f, -0.04036838f, 0.06149144f, 0.05025866f, -0.02155963f, -0.06993236f, -0.03521927f, 
    -0.55506480f, -0.05933630f, -0.07455070f, -0.15412921f, 0.06358471f, -0.13483782f, -0.09292802f, 0.03414714f, 
    0.06863134f, -0.01090852f, 0.03539496f, 0.13647948f, -0.34729996f, -0.06325373f, -0.21517988f, 0.08712040f, 
    -0.06437985f, 0.06604506f, 0.02696548f, -0.07856821f, -0.04966675f, 0.06051234f, 0.07316564f, 0.03495237f, 
    -0.39004305f, 0.12882675f, -0.01710138f, -0.04445003f, 0.08014979f, 0.04175398f, -0.03212233f, 0.04106360f, 
    0.08753268f, 0.05186535f, 0.00714722f, 0.11333415f, -0.43214431f, -0.37197894f, -0.10846602f, 0.02356169f, 
    0.03528025f, 0.04899553f, 0.07720713f, -0.01982616f, 0.04749858f, 0.03628191f, 0.01787782f, 0.10376361f, 
    -0.21722734f, -0.12293648f, 0.17541865f, 0.02691708f, -0.04652184f, 0.01256292f, 0.00269298f, 0.01503663f, 
    0.03552026f, 0.01859415f, -0.04593201f, 0.08510087f, 0.30551013f, 0.05362724f, -0.09301076f, -0.08377691f, 
    0.01569042f, -0.05398981f, -0.12399692f, 0.09244148f, 0.00142606f, 0.08388504f, 0.06918261f, 0.05850796f, 
    0.16586350f, 0.14835170f, 0.00372897f, -0.08769961f, 0.00118105f, 0.09673874f, 0.14367212f, -0.07032812f, 
    0.06731819f, 0.02348538f, -0.00345880f, 0.08549576f, -0.35148558f, -0.05375694f, 0.02994677f, -0.00293644f, 
    -0.06104779f, -0.02733987f, -0.10432689f, -0.06939022f, -0.11470885f, 0.13090234f, -0.01220684f, -0.08258960f, 
    0.31342581f, -0.03173441f, -0.09251298f, -0.05405152f, -0.18702550f, -0.07370038f, 0.04368361f, -0.02661024f, 
    0.10923589f, 0.07063550f, -0.05853092f, -0.05565137f, -0.44943559f, -0.00457112f, -0.04146371f, -0.21044426f, 
    0.02267334f, 0.05918866f, 0.00824418f, 0.00693740f, -0.00027669f, 0.00913671f, 0.02139431f, 0.11599177f, 
    -0.44696438f, -0.40209702f, 0.00513500f, 0.07249364f, 0.11492863f, 0.02547419f, 0.08078174f, -0.07453184f, 
    0.08882471f, 0.15909296f, -0.10725012f, 0.03334312f, -0.07365838f, -0.11721790f, -0.05462575f, 0.12384476f, 
    -0.05800296f, 0.05290819f, -0.02155913f, 0.07803253f, 0.08059859f, -0.07755885f, -0.11348461f, 0.06309576f, 
    -0.12923680f, -0.00522866f, -0.11300143f, 0.12149128f, 0.04346543f, -0.02464761f, 0.03151451f, -0.01674267f, 
    -0.08065937f, -0.00497251f, -0.02176786f, -0.00318137f, 0.14996907f, 0.04350862f, 0.05213995f, -0.04136483f, 
    0.01771276f, 0.04936225f, -0.06296133f, 0.04259630f, 0.00241135f, 0.02643543f, -0.08718713f, 0.05767903f, 
    0.09716092f, 0.03748719f, -0.09558641f, 0.06354447f, -0.00530730f, 0.05719307f, 0.00626586f, -0.01933648f, 
    0.07740507f, 0.03961441f, -0.04836735f, 0.04416578f, -0.01823757f, 0.13731045f, -0.08293676f, 0.01437522f, 
    0.03856450f, 0.03377004f, 0.10967270f, -0.01382933f, -0.02566670f, 0.05775703f, 0.14204860f, 0.16702506f, 
    -0.03621778f, 0.05154635f, 0.01375069f, 0.23518464f, 0.05425076f, 0.01050413f, 0.02865648f, -0.06476384f, 
    -0.05172006f, -0.00319323f, 0.07137433f, 0.13269569f, -0.00332495f, 0.03404902f, 0.01053136f, 0.10279558f, 
    0.06820150f, 0.04878746f, -0.01451300f, 0.14400077f, 0.05461948f, -0.02112628f, 0.07726902f, 0.01956874f, 
    0.14755931f, -0.06524577f, 0.03929599f, -0.08680104f, -0.08095885f, -0.03536353f, 0.08471142f, -0.06365933f, 
    0.00668565f, 0.05103478f, -0.14992155f, -0.00844124f, 0.13206051f, -0.01034098f, 0.01558760f, -0.00596080f, 
    -0.01932808f, 0.06607477f, 0.04832426f, -0.06070660f, 0.16142520f, -0.02102506f, 0.06468782f, -0.02278044f, 
    -0.27408358f, 0.06822946f, -0.08600017f, 0.02983372f, 0.02672553f, 0.15521795f, -0.00768553f, 0.00810281f, 
    0.02047039f, 0.06156320f, 0.00487227f, 0.06395990f, 0.02497412f, 0.13830826f, 0.01232061f, -0.22377367f, 
    0.07600765f, -0.00179049f, 0.01255829f, 0.07680449f, 0.00778962f, 0.06196167f, 0.02010215f, 0.07960895f, 
    -0.11699964f, -0.12124227f, 0.11710020f, -0.14028600f, -0.02810860f, 0.00058616f, 0.03781541f, -0.12980497f, 
    -0.00521475f, -0.18347073f, 0.02086473f, -0.02615858f, -0.07064008f, 0.15579267f, 0.00818578f, -0.15648165f, 
    0.00542302f, 0.08404116f, -0.16661498f, -0.05143880f, -0.02169440f, -0.06810334f, -0.08558843f, 0.02761549f, 
    0.18975230f, 0.06854968f, -0.02679545f, -0.01057485f, -0.12651640f, -0.04455257f, 0.04574861f, 0.07015198f, 
    0.01710577f, -0.03150699f, -0.02651840f, -0.14486776f, 0.18557046f, 0.00919220f, -0.03454249f, -0.03953588f, 
    -0.06383858f, -0.04996876f, -0.03175454f, 0.08660693f, 0.02575226f, 0.07402623f, 0.03964730f, 0.07527303f, 
    -0.57844532f, -0.39601257f, 0.03055042f, 0.14544450f, 0.01850495f, 0.03246030f, -0.03573449f, -0.11770210f, 
    0.06809349f, -0.17535070f, -0.06009147f, 0.09863555f, -0.02696364f, 0.12997308f, -0.09587139f, 0.03252861f, 
    -0.01871155f, 0.05386575f, -0.11253243f, -0.01338864f, -0.01897884f, -0.16538607f, -0.08168793f, -0.09458411f, 
    0.09055419f, 0.02431866f, -0.06146445f, -0.00890580f, -0.05884284f, 0.00579641f, 0.04751567f, -0.07597196f, 
    0.04493005f, 0.02002340f, -0.05728777f, -0.00999941f, 0.13943371f, -0.01808593f, 0.02733106f, -0.01245376f, 
    0.09273931f, 0.03941724f, 0.02369857f, 0.02052275f, 0.09042396f, 0.09729687f, 0.09418076f, 0.03802825f, 
    -0.23530512f, 0.00829867f, -0.02657099f, -0.01843478f, 0.03370138f, -0.02900854f, 0.05014237f, 0.06131247f, 
    -0.04740602f, -0.02865741f, 0.03019036f, 0.04911201f, -0.46252087f, -0.10742373f, 0.13398410f, -0.21413253f, 
    0.06001576f, -0.06507725f, -0.01998596f, 0.01619804f, -0.05802086f, 0.07002815f, -0.00809227f, 0.02097604f, 
    -0.13670811f, -0.06298214f, -0.07658408f, -0.04129572f, 0.06710992f, 0.01526242f, -0.12658304f, 0.03119503f, 
    0.06578110f, 0.04052296f, -0.07119653f, -0.05343082f, 0.00064666f, 0.04685467f, -0.03187973f, -0.12873064f, 
    -0.00337449f, -0.18947567f, 0.01407560f, 0.09093315f, -0.04837361f, 0.06032486f, -0.08306991f, 0.12360889f, 
    -0.19468081f, 0.06655997f, 0.17150398f, -0.20159239f, 0.09618478f, 0.00357587f, 0.01639241f, -0.00807898f, 
    -0.04273348f, -0.16031839f, -0.12137762f, -0.09508972f, -0.10885480f, -0.10620674f, 0.10015031f, -0.07827587f, 
    -0.12383438f, -0.04468586f, 0.05289515f, 0.05277356f, 0.04673970f, -0.07470351f, -0.05078176f, -0.10277834f, 
    0.23753870f, 0.09425727f, 0.01960750f, -0.05246807f, -0.04679874f, -0.08645760f, -0.01071423f, 0.00926613f, 
    -0.06470526f, -0.06008933f, 0.06701755f, -0.02604924f, 0.02199278f, -0.06643037f, -0.09165661f, 0.09294768f, 
    -0.01520055f, 0.04729673f, -0.02182942f, 0.00399489f, 0.07769077f, 0.04557238f, -0.02843096f, 0.00315907f, 
    0.28064108f, 0.12641479f, -0.04327493f, -0.11260283f, -0.00769420f, 0.08620615f, -0.02974292f, 0.14551890f, 
    0.06153345f, 0.08287988f, 0.11312669f, 0.09145454f, 0.20003346f, 0.09095314f, -0.03100171f, -0.11428789f, 
    0.07072153f, 0.10356538f, 0.02149689f, 0.03938555f, -0.02113608f, 0.00607409f, -0.00597168f, -0.02387298f, 
    -0.22771436f, 0.04465761f, -0.20579927f, -0.00893728f, 0.02570588f, -0.02607269f, -0.20043199f, -0.02615049f, 
    -0.04599964f, -0.03169851f, 0.07394181f, -0.03093810f, 0.17308897f, -0.13824816f, -0.14102679f, 0.07394087f, 
    -0.08040465f, -0.00553853f, -0.10177190f, 0.01143177f, -0.02510431f, 0.04447240f, 0.01542115f, 0.03471636f, 
    -0.47393546f, -0.34132969f, -0.09898546f, -0.15458798f, 0.05305660f, 0.00967229f, -0.00753334f, 0.03021225f, 
    0.09625231f, 0.09114839f, 0.08683000f, 0.10334664f, -0.26249471f, 0.15661196f, -0.05066445f, -0.12778696f, 
    -0.00775244f, -0.00773119f, -0.08287530f, -0.08251195f, 0.03415443f, -0.12778910f, 0.02570443f, -0.13283271f, 
    0.00542232f, 0.09882510f, 0.09533873f, -0.00422658f, 0.06559649f, 0.05220441f, 0.02048133f, 0.07096255f, 
    -0.02636697f, 0.02430424f, -0.04936987f, -0.01547449f, -0.22920325f, -0.15550391f, 0.01462592f, 0.01339744f, 
    0.03305192f, -0.05474816f, -0.05886850f, 0.04070019f, -0.02007938f, 0.15495872f, 0.06956697f, 0.05413423f, 
    -0.14665973f, -0.21837097f, 0.02579578f, 0.04106902f, 0.12300150f, 0.03446116f, 0.06313155f, 0.01403585f, 
    0.07414165f, 0.12125207f, -0.02798476f, 0.02000010f, -0.15958892f, -0.16440122f, 0.13663547f, 0.01618592f, 
    0.13684323f, 0.01769579f, -0.04936326f, 0.09566060f, 0.10501778f, 0.19745930f, 0.05096262f, 0.17185412f, 
    -0.06319267f, -0.21097203f, -0.16565700f, -0.00238378f, -0.11486667f, 0.00692132f, 0.02832699f, 0.07136615f, 
    0.03286254f, 0.06247886f, 0.04628721f, 0.09819732f, -0.25110129f, -0.07599211f, -0.13690732f, -0.21485585f, 
    0.02592452f, 0.03643822f, -0.02327984f, 0.04457802f, -0.06213713f, 0.03300877f, 0.00476461f, 0.03823553f, 
    -0.03911300f, 0.07694537f, 0.01770489f, -0.11859361f, 0.02802236f, -0.02309890f, -0.04160322f, 0.03342168f, 
    0.01727252f, 0.07919625f, 0.08913055f, -0.03546615f, -0.11121517f, -0.05413081f, 0.04974701f, 0.00191727f, 
    0.01244330f, -0.04048660f, 0.00891567f, 0.07721877f, 0.03793588f, -0.00864015f, -0.06665556f, 0.01853267f, 
    -0.12392084f, -0.11519934f, 0.02810371f, 0.08024695f, 0.09796833f, -0.01957736f, 0.00478373f, 0.00442078f, 
    0.04744494f, 0.07682776f, -0.03165077f, -0.07294190f, 0.11141863f, 0.13413173f, -0.01268633f, 0.05018118f, 
    0.06996132f, -0.00885248f, 0.03441118f, -0.01213990f, 0.00301395f, -0.03976530f, 0.04496744f, 0.00331894f, 
    0.15187261f, 0.16881859f, -0.08219288f, -0.06369708f, 0.10325913f, 0.05427764f, 0.05105125f, 0.04481082f, 
    0.05978770f, 0.02270223f, -0.08680546f, 0.14110595f, 0.12344781f, -0.16823538f, -0.04049657f, -0.12515998f, 
    -0.03112393f, -0.03440491f, 0.00082021f, -0.07335635f, 0.00034379f, -0.17149842f, -0.23278938f, -0.01913989f, 
    0.14492951f, 0.14380269f, 0.04622130f, -0.09344542f, -0.07670663f, 0.08462012f, -0.13589483f, -0.14131516f, 
    0.03480941f, 0.03930045f, 0.06324016f, -0.00428844f, -0.07743630f, -0.14062698f, 0.10080347f, 0.07275251f, 
    0.05690286f, 0.00167600f, -0.01784424f, 0.00321755f, -0.03993277f, 0.04493619f, 0.11735518f, -0.03910821f, 
    -0.06789289f, -0.13398387f, 0.12566939f, 0.44737616f, -0.06916882f, 0.13969366f, -0.00125739f, 0.03064975f, 
    0.03834339f, -0.04890224f, 0.02761473f, 0.07856563f, 0.18896957f, -0.05361398f, -0.19376546f, 0.04833535f, 
    0.05152762f, 0.11211517f, 0.03968428f, 0.06833436f, -0.12568174f, -0.11468363f, -0.03683898f, -0.05155028f, 
    0.15152054f, -0.11861863f, 0.04626461f, -0.22178206f, 0.01936291f, -0.01307078f, 0.08997016f, 0.00091374f, 
    0.09362172f, 0.08371083f, 0.07135601f, 0.12712011f, 0.06128887f, -0.09807221f, -0.04754114f, -0.04165680f, 
    -0.00985514f, -0.03137242f, 0.08698679f, 0.00575174f, 0.00389376f, -0.04031999f, 0.08029826f, 0.09330815f, 
    0.01053106f, -0.06393643f, -0.07016444f, 0.13713254f, 0.02351433f, -0.00082073f, -0.07304909f, 0.04333787f, 
    0.00312452f, -0.11716108f, -0.09883407f, -0.00464391f, -0.01233166f, 0.21629058f, 0.00189542f, -0.00557466f, 
    -0.04321581f, 0.10916623f, 0.06225180f, -0.11996378f, 0.02314104f, -0.05392489f, 0.03749784f, 0.04434793f, 
    0.01608946f, -0.08760117f, -0.05371177f, 0.00943456f, -0.17707972f, 0.08480459f, -0.01982298f, 0.09761849f, 
    0.02340553f, -0.12515786f, -0.09492535f, 0.00184001f, -0.44467989f, 0.03680931f, 0.07542808f, 0.04294429f, 
    -0.16249651f, 0.11247158f, -0.17696489f, 0.04948072f, -0.00683748f, -0.00553718f, 0.07626979f, 0.11936664f, 
    0.34956703f, 0.13819960f, -0.12016284f, -0.08002530f, 0.00838625f, -0.00892615f, -0.03996217f, 0.02861860f, 
    0.04119421f, 0.01856123f, 0.00617724f, -0.03675625f, -0.23563759f, 0.21975011f, -0.02916498f, -0.02512492f, 
    0.08635966f, 0.06898699f, 0.00703757f, 0.07164774f, 0.04365594f, -0.02792783f, -0.08170452f, -0.05153798f, 
    0.30443376f, -0.07754354f, -0.03524134f, 0.16285475f, 0.04301263f, -0.02041565f, -0.03174705f, 0.02254965f, 
    0.04381731f, -0.02045749f, 0.02966325f, -0.00688310f, 0.15513651f, 0.01370791f, -0.23903595f, 0.17473239f, 
    -0.02473772f, -0.01967528f, 0.04968436f, 0.16713955f, 0.03352437f, -0.03270429f, -0.02838988f, -0.07456591f, 
    -0.20453873f, -0.01197312f, -0.00499261f, 0.02875889f, 0.05009610f, -0.02646573f, -0.04015364f, 0.03387026f, 
    0.00299349f, -0.00255026f, 0.10362373f, -0.03275082f, -0.24503015f, -0.36417949f, 0.03779132f, -0.10955519f, 
    0.03334479f, -0.06616855f, -0.03091594f, 0.00145886f, -0.00132592f, 0.00803884f, 0.01170710f, 0.07569922f, 
    -0.20489432f, 0.21407609f, -0.03583362f, 0.01939804f, 0.01803216f, -0.04890347f, -0.02827681f, 0.05403709f, 
    0.01602383f, 0.03729644f, 0.01817869f, -0.13763033f, 0.48097959f, -0.10213013f, -0.17234050f, -0.11404209f, 
    0.01082052f, -0.09493714f, -0.00346652f, -0.07181630f, 0.01333994f, -0.00895459f, -0.00884313f, -0.00490752f, 
    0.31623098f, -0.07609121f, 0.04831428f, -0.04004391f, 0.00896876f, 0.04806849f, -0.06256412f, 0.00798346f, 
    0.05771306f, -0.05939369f, 0.05696999f, 0.01513727f, -0.41690701f, 0.16633251f, 0.02184239f, 0.15551725f, 
    0.24483523f, -0.19552489f, 0.09195388f, 0.03051611f, 0.12313484f, -0.00185298f, 0.02628060f, 0.06576680f, 
    0.11545547f, -0.14620820f, -0.03297537f, 0.12051484f, -0.18978779f, 0.12336354f, -0.08863467f, -0.01714439f, 
    0.07546963f, 0.03295339f, 0.01949915f, 0.04418637f, -0.17887394f, 0.20306064f, 0.00138717f, -0.04337635f, 
    -0.01322333f, 0.02195613f, 0.05008135f, -0.04777620f, -0.04480496f, -0.07791755f, 0.08829920f, -0.08041905f, 
    0.20207307f, 0.05864680f, -0.01385758f, 0.13952614f, -0.02477146f, 0.00198804f, 0.05729018f, -0.04429663f, 
    -0.18099654f, -0.03440501f, 0.08858367f, -0.04847972f, -0.07787974f, 0.08848655f, 0.10863259f, -0.00538837f, 
    0.01107203f, 0.02716451f, -0.06984148f, -0.04933184f, 0.04623773f, -0.06562961f, 0.04131287f, -0.07816631f, 
    -0.10687175f, 0.02183196f, 0.13649754f, 0.02771451f, -0.17192923f, 0.08419145f, 0.01686942f, -0.01435323f, 
    0.00036415f, 0.03353819f, -0.00142882f, 0.02072304f, 0.17569371f, 0.02829317f, -0.03541315f, 0.01411405f, 
    -0.10029688f, -0.07030316f, -0.02490948f, 0.00931046f, 0.01707542f, -0.03936533f, -0.02271431f, -0.10065520f, 
    -0.12377395f, -0.08272550f, 0.02438225f, -0.01074785f, 0.05997132f, -0.04396035f, -0.00027345f, -0.01544127f, 
    0.03125700f, -0.01832174f, 0.18061997f, 0.04330856f, -0.12456183f, 0.04312780f, 0.05246273f, 0.04717953f, 
    -0.04923249f, -0.17922884f, -0.07286652f, -0.01419803f, -0.12371100f, 0.09444363f, 0.16704966f, -0.03418672f, 
    -0.11850420f, -0.01970467f, -0.03043838f, 0.07304587f, 0.04770833f, 0.05433457f, 0.03240845f, 0.09862120f, 
    -0.07750034f, 0.03927376f, 0.06740953f, -0.13809419f, 0.22199827f, -0.14958158f, -0.14783365f, 0.17915542f, 
    -0.00988513f, -0.02812674f, 0.04815733f, 0.02294899f, 0.09373821f, 0.01808333f, 0.02228145f, -0.02723822f, 
    0.01524244f, 0.24263740f, 0.03852718f, -0.07326353f, 0.02943854f, -0.09895958f, 0.10722756f, -0.21313822f, 
    -0.07616922f, 0.05174864f, 0.01800219f, -0.06155232f, -0.38691399f, 0.11538876f, -0.02396365f, 0.01146853f, 
    0.02150925f, 0.05177939f, 0.05582280f, 0.11496598f, 0.01250821f, 0.05415493f, 0.06292002f, -0.02753079f, 
    0.00357079f, -0.27251166f, 0.03648026f, -0.07500020f, -0.01306908f, 0.07285667f, -0.02257524f, 0.02758514f, 
    0.02328217f, 0.01350298f, 0.01501331f, 0.08793963f, -0.02987938f, 0.17148530f, 0.00889557f, 0.06125538f, 
    -0.09732509f, -0.11762503f, -0.00766771f, -0.08507190f, -0.00880614f, -0.00751185f, 0.06119912f, -0.11487400f, 
    0.22206995f, 0.08177860f, -0.06684139f, -0.09439328f, 0.05068308f, -0.02070544f, -0.02908476f, 0.07226467f, 
    0.00131397f, -0.10324448f, 0.07847103f, -0.01474885f, -0.24419202f, -0.16047759f, -0.14207320f, -0.16618492f, 
    0.01617627f, -0.01490641f, 0.06410414f, -0.01945340f, -0.06452531f, 0.08030825f, 0.01463863f, 0.07307610f, 
    0.14841904f, -0.10091905f, -0.05258311f, -0.01000665f, -0.18492407f, 0.01570906f, -0.02626993f, -0.00476574f, 
    -0.06110842f, -0.01742313f, 0.01846842f, -0.02982669f, 0.07088495f, -0.16569996f, -0.06796627f, 0.09046146f, 
    0.07492580f, -0.09918494f, -0.02946105f, 0.10194739f, -0.08007445f, 0.02165605f, -0.01231355f, 0.00635293f, 
    -0.01000141f, 0.03595368f, 0.05531368f, 0.09727645f, -0.07581173f, -0.02404896f, -0.11819196f, -0.03418840f, 
    0.01213208f, -0.10698281f, -0.02048925f, 0.02472521f, 0.06271781f, -0.19170074f, -0.06443316f, -0.04083790f, 
    0.10173340f, -0.09987082f, -0.10728292f, 0.04042671f, -0.04858391f, -0.08464827f, 0.05789645f, -0.04197166f, 
    -0.09000765f, -0.12202764f, -0.00153941f, 0.16276947f, -0.04985695f, 0.07132825f, -0.14303845f, 0.02701367f, 
    0.01440850f, -0.01256335f, -0.04505992f, 0.02728628f, -0.00367849f, -0.00561188f, 0.10015233f, -0.19596942f, 
    0.04072024f, 0.00516923f, -0.08778626f, -0.00895399f, -0.01442656f, -0.03420928f, -0.01459133f, -0.12347534f, 
    0.40860161f, 0.24828452f, -0.17750975f, -0.08676013f, -0.01306396f, -0.06797238f, -0.04985376f, -0.08695127f, 
    0.09550032f, 0.07519805f, 0.10854685f, 0.07276695f, -0.38194221f, -0.35421839f, -0.11432087f, -0.08232979f, 
    0.07895869f, -0.04409220f, 0.07633135f, 0.03207669f, -0.11305293f, 0.03622544f, -0.03393413f, -0.07097363f, 
    0.02828199f, 0.06184288f, 0.07156742f, 0.03627175f, -0.09060075f, 0.02606663f, 0.04694059f, -0.12815727f, 
    -0.00745846f, 0.00611567f, -0.06222471f, -0.06278274f, 0.18210194f, 0.02655436f, -0.10861569f, 0.05695733f, 
    -0.10627694f, -0.13391604f, -0.01045943f, -0.07354191f, 0.07708010f, 0.02643885f, -0.01631589f, 0.03297828f, 
    -0.26207164f, 0.06824882f, 0.01756809f, 0.05024018f, 0.04137878f, -0.02658606f, -0.04481285f, 0.10079455f, 
    -0.06698976f, -0.07831769f, -0.10580306f, 0.01080241f, -0.18973678f, 0.11616299f, -0.05200756f, -0.11036197f, 
    -0.07037154f, 0.08141771f, -0.03838556f, -0.12753721f, -0.03392215f, 0.01089702f, -0.04426354f, -0.07442543f, 
    -0.12978490f, -0.03105542f, -0.12421552f, -0.06286633f, -0.14594150f, 0.06724409f, -0.04766292f, -0.02149040f, 
    -0.02572918f, -0.00316070f, -0.05503339f, 0.09465569f, -0.30057713f, 0.05436284f, 0.07444863f, -0.06075550f, 
    0.08153616f, -0.07685725f, 0.02745875f, -0.25937638f, -0.08211020f, -0.09501652f, 0.10621738f, -0.06347774f, 
    0.20193960f, -0.15898067f, -0.09990907f, -0.14371592f, 0.01263921f, 0.03175602f, 0.02716720f, 0.02183709f, 
    -0.10521095f, -0.01489981f, -0.04162261f, -0.04331066f, -0.24630116f, -0.25589004f, -0.02802517f, -0.26567554f, 
    -0.03997716f, -0.03863941f, -0.07719069f, 0.06038935f, -0.00510373f, -0.02472078f, -0.02386459f, 0.05375906f, 
    0.14414252f, 0.03020949f, -0.07153580f, 0.23070055f, 0.12282870f, 0.09204887f, 0.00275052f, -0.05875211f, 
    0.04684767f, 0.04288091f, -0.03494630f, 0.00700557f, -0.04504265f, 0.19158825f, -0.17941482f, 0.15614103f, 
    0.11437264f, -0.05017938f, -0.05011125f, -0.05984200f, 0.04021568f, -0.05451058f, -0.13254780f, -0.06200479f, 
    0.03855481f, 0.01552512f, -0.16244838f, 0.36423296f, -0.03992774f, -0.02337937f, 0.04468356f, 0.02089771f, 
    0.08323115f, 0.03980533f, -0.01289793f, -0.04592440f, 0.29641044f, 0.19605917f, -0.01153332f, -0.05410949f, 
    0.07364151f, 0.00915437f, -0.13607411f, 0.12483609f, -0.00950594f, -0.04659885f, 0.01033794f, -0.08153581f, 
    -0.23189075f, -0.34796250f, 0.08657016f, 0.00488559f, 0.12088496f, -0.03438399f, 0.05800043f, 0.01784718f, 
    0.04855735f, 0.01012545f, -0.00442175f, -0.06480145f, -0.02358603f, -0.11953818f, -0.15653434f, -0.19620059f, 
    0.11408766f, -0.02791606f, 0.02134457f, 0.05877974f, -0.05921928f, 0.01787806f, -0.04422180f, -0.02043863f, 
    0.24678741f, 0.08092515f, -0.27019045f, -0.14766029f, 0.09771894f, -0.00651634f, 0.00012923f, 0.02231325f, 
    0.03197969f, 0.01324116f, 0.04677519f, 0.06696265f, -0.10085448f, -0.15726370f, -0.10465150f, 0.16605802f, 
    0.03224641f, -0.06887652f, 0.09778292f, -0.08971635f, -0.01544629f, 0.03493353f, -0.01203486f, -0.04308141f, 
    -0.00048380f, -0.32499155f, -0.06934694f, -0.02320300f, 0.01351136f, 0.06403456f, -0.02504471f, -0.25281921f, 
    0.05911636f, 0.05876166f, 0.08850354f, 0.08880951f, 0.14540800f, -0.10709234f, -0.12198262f, 0.06238786f, 
    -0.12672061f, -0.08565421f, -0.08645411f, 0.00603841f, 0.00095305f, -0.03544182f, -0.01670422f, -0.10832260f, 
    0.05249889f, -0.01326299f, -0.01859570f, 0.23676938f, -0.03385183f, 0.01777494f, 0.02893540f, 0.11497686f, 
    0.02695430f, -0.00984802f, 0.02592308f, -0.13406922f, -0.06897540f, -0.22671860f, -0.04034853f, -0.02349101f, 
    -0.04616499f, 0.01773875f, 0.09134585f, 0.01575194f, 0.02974045f, 0.02242587f, 0.00532321f, -0.05625514f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05211263f, -0.00116993f, -0.04124991f, -0.04225039f, 0.01129031f, 0.04504646f, -0.02728371f, -0.03604684f, 
    0.01425063f, 0.00797201f, 0.04734141f, -0.00178462f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
