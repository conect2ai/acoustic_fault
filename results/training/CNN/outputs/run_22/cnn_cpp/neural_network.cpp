#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.30858970f, -0.02024688f, 1.29935634f, 0.16340320f, 0.67107457f, 1.20580292f, 0.57648551f, -0.01876796f, 
    -0.28564110f, -0.18388213f, 0.30690426f, 0.58546942f, -0.27159381f, -0.01034365f, -0.35403183f, 0.39308196f, 
    0.12407951f, -0.00670415f, -0.22203955f, -0.23912518f, -0.16583121f, -0.22120926f, -0.04072818f, -0.28853652f, 
    0.07545535f, -1.92076027f, 0.28163487f, -1.08109069f, -0.13247298f, -0.26640722f, -0.45432219f, -0.39456424f, 
    0.04625236f, 1.00673890f, -0.32999989f, 0.00640297f, 0.03307006f, 0.08750914f, -0.14652638f, -0.22754703f, 
    -0.07346951f, 0.31492117f, 0.22585379f, -0.57811284f, -0.65089375f, 0.12296855f, 0.16241536f, 0.19586141f, 
    0.04194809f, -0.00071760f, -0.97692806f, -0.45572194f, -1.17549753f, -1.20594370f, -0.50902063f, 1.22724020f, 
    0.25307432f, -0.03126532f, 0.54132104f, 0.72238815f, -0.43478224f, -0.45003650f, 0.21253940f, -0.04700891f, 
    0.48768282f, -0.24431692f, 0.19121201f, 0.11228960f, 0.30786735f, 0.05133851f, 0.10028349f, 0.04622136f, 
    0.15167785f, 0.21423358f, 0.33685485f, -1.06101823f, -2.08216238f, -0.58483523f, 0.43544865f, 0.20117310f, 
    -0.05240793f, 1.42883360f, 0.95427191f, -0.35368499f, -0.18563737f, -0.20109707f, 0.16903397f, 0.10840972f, 
    -0.04041779f, 0.31823930f, -0.32878491f, 0.39721441f, 0.03735847f, 0.08715710f, 0.01665374f, -0.00722573f, 
    -0.25151610f, -0.12451375f, -0.40259826f, -0.13251774f, -0.65327084f, 1.21120846f, 0.24106880f, -1.08521068f, 
    0.69119966f, 1.21734798f, -0.30730358f, -0.50895298f, -0.50643635f, -1.05753517f, 0.46888149f, 0.28657579f, 
    0.63857919f, 0.46514818f, -0.36860338f, 0.07515310f, 0.45279586f, 0.50892234f, 0.12286358f, 0.35762483f, 
    0.37025821f, -0.01006969f, 0.00587732f, -0.03879927f, 0.24854280f, -0.40408385f, -0.58680874f, -0.48376751f, 
    -0.70584112f, -0.35433415f, 0.56329781f, -0.51186365f, 0.82500386f, 0.20854034f, -0.58560556f, 0.36356527f, 
    -0.59966969f, -0.71133798f, -0.51980042f, -0.36578983f, 0.57537609f, 0.32926038f, -0.15822333f, -0.36305350f, 
    0.32251918f, -0.36690307f, -0.17082457f, 0.51129979f, 0.06458090f, -0.44151124f, -1.59792197f, -0.40886787f, 
    -0.03462113f, -0.62733644f, 0.09436584f, -1.35678470f, -0.65774262f, -0.06306335f, -0.88595974f, -0.23007390f, 
    -0.07165005f, 0.94510657f, 0.28980866f, 0.19081368f, 0.05769247f, -0.36669514f, -0.27633426f, -0.05956589f, 
    0.08446699f, -0.01577354f, 0.25340253f, -0.60535753f, -0.11378566f, -0.19819644f, -0.19554575f, 1.09717989f, 
    1.02156925f, 0.44548765f, 0.76346129f, 1.55249453f, 0.09248168f, -0.24563518f, -0.96292615f, 0.56424904f, 
    -0.13685511f, 0.10996268f, 0.13734323f, -0.01642538f, 0.30732372f, 0.09700963f, 0.22757578f, 0.18775131f, 
    0.74362332f, 0.08436659f, 0.16345024f, 0.34828770f, 0.03275628f, 0.07554499f, -0.01526990f, 0.24621393f, 
    1.47365820f, 1.42275810f, 0.35172141f, -1.25231671f, -1.24827135f, -0.15086669f, -0.68408269f, -0.64742368f, 
    -0.40230784f, -0.16685799f, 0.38342440f, -0.03323146f, -0.15105429f, -0.02279671f, -0.18642870f, -0.05968446f, 
    -0.11820197f, 0.13973904f, -0.22859521f, -0.09202241f, -0.25847417f, 0.39609876f, -0.28765473f, -0.08153538f, 
    0.18713474f, 0.25317001f, 0.26700136f, 1.09715211f, 0.59019548f, 0.55518848f, -1.73169386f, 0.63459110f, 
    -0.62420660f, -1.54005361f, 0.02206998f, 0.56084007f, 0.52354556f, -0.15235732f, 0.41378373f, 0.05237091f, 
    0.23459083f, -0.29761890f, -0.16559948f, 0.06208437f, -0.00110397f, -0.16968741f, 0.14220481f, 0.24202947f, 
    0.13267991f, -0.00215758f, 1.49517274f, -1.50423121f, -0.15482917f, -0.85499215f, 0.63060057f, 1.03818631f, 
    -0.10668619f, 0.67649978f, 0.05266757f, -0.16234058f, -0.06325141f, 0.51090676f, -0.66424507f, 0.30888319f, 
    0.02773273f, 0.00394858f, -0.25753614f, -0.15320820f, 0.22167666f, 0.19794217f, -0.00016862f, 0.04575155f, 
    -0.13082464f, 0.06151288f, 0.05374806f, -1.64884639f, -0.40612963f, 0.98902923f, 0.78217256f, 0.41055232f, 
    1.00268972f, 1.20973885f, 0.36258402f, 0.80974048f, 0.46480265f, -0.10722162f, -0.33531186f, -0.06303040f, 
    -0.17446266f, -0.57799655f, -0.20675978f, -0.11427952f, -0.04589524f, -0.25066683f, -0.34533048f, -0.23691092f, 
    -0.18091442f, 0.02135688f, 0.20277999f, -0.48042265f, 1.19174123f, 0.11644876f, 1.12597978f, 0.89495015f, 
    0.41633084f, 0.09267501f, -1.09133160f, -0.35109016f, -0.39186132f, -0.40258998f, 0.30467701f, 0.04626416f, 
    0.01191809f, -0.10820952f, 0.35295174f, -0.25255463f, -0.00467606f, -0.22515835f, -0.06549685f, 0.44644371f, 
    0.70276320f, 0.35375443f, 0.05141205f, 0.43156689f, 0.73119754f, 1.21535206f, 0.20163524f, -1.10793626f, 
    0.05699865f, -0.38609451f, 1.22193539f, 1.15591908f, 0.08795876f, 0.92330170f, 0.70554507f, -0.07782008f, 
    -0.04678305f, -0.37967005f, -0.22278771f, -0.34778696f, -0.10227144f, -0.09023076f, -0.35420796f, 0.02770123f, 
    -0.23491099f, -0.31574738f, -0.09659024f, -0.20387560f, -0.20560446f, 0.05694626f, 1.15112185f, 0.07132610f, 
    0.18415903f, 1.65129197f, 0.86382258f, 0.33673897f, 0.73855394f, 0.46070188f, 0.63207442f, 0.71959025f, 
    -0.55588257f, -0.11839411f, -0.44659513f, 0.25191814f, 0.17188349f, -0.15595128f, -0.52690005f, -0.34640935f, 
    -0.19660531f, 0.04317231f, 0.19388606f, 0.15480459f, 0.19084154f, 0.11445378f, -0.05001149f, 1.52801955f, 
    0.47798494f, -0.18750127f, 1.26659858f, -0.84902996f, -0.22141171f, -0.50192797f, 0.29530680f, 0.45584252f, 
    0.58448136f, 0.44353780f, -0.13934432f, -0.08091605f, 0.11380340f, -0.40819150f, 0.51052934f, 0.02001694f, 
    0.05882333f, -0.14065045f, 0.61132389f, 0.08402018f, 0.03073910f, 0.10728907f, -0.03206874f, -0.45670149f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28869662f, 0.36997339f, 0.33259535f, 0.69130874f, 0.67660874f, 0.21473034f, 0.49174652f, 0.13539720f, 
    0.31805193f, 0.24774617f, 0.16399005f, 0.20553420f, 0.22530900f, 0.27367607f, 0.26134264f, 0.11455871f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03745651f, -0.18873611f, 0.21062034f, 0.04230692f, -0.40124753f, -0.07072689f, 0.08739257f, 0.11880655f, 
    0.05806107f, 0.10355221f, -0.03988511f, -0.12923887f, 0.45220119f, 0.25432903f, -0.57891548f, 0.07608030f, 
    0.11383094f, -0.19079952f, 0.00163871f, -0.16415916f, -0.05187234f, -0.00503597f, -0.12294357f, -0.14326149f, 
    0.55073005f, -0.26668799f, -0.06117983f, -0.56855482f, 0.16027820f, 0.00789123f, -0.06136646f, 0.16994461f, 
    0.19223672f, 0.02940357f, -0.11830685f, 0.13921331f, -0.68002486f, 0.19635187f, -0.13060559f, -0.04665575f, 
    0.07342872f, -0.02814168f, 0.01335246f, 0.07301930f, 0.20002326f, -0.06044469f, -0.04601682f, 0.11290016f, 
    -0.52221352f, -0.03485016f, 0.19786683f, -0.38383970f, -0.13095562f, 0.11647952f, 0.16255744f, -0.30003867f, 
    0.06303982f, -0.00480595f, 0.04847652f, 0.12790179f, 0.01870380f, -0.21074772f, 0.13599928f, -0.43209997f, 
    -0.11235396f, 0.39396539f, -0.02756400f, -0.00919498f, -0.11954298f, -0.12299943f, -0.07825420f, -0.31603718f, 
    -1.12932944f, -0.23564067f, -0.03942557f, 0.18626559f, 0.01066088f, 0.06015263f, 0.18824948f, 0.13054685f, 
    0.08853994f, -0.01524917f, 0.08002408f, -0.14713411f, 0.03625721f, 0.09947384f, 0.06067728f, -0.05302674f, 
    -0.34312192f, -0.19690298f, 0.13996324f, 0.01920447f, 0.01028431f, 0.08959327f, -0.07757241f, -0.12479436f, 
    -0.26618537f, 0.17369846f, 0.39788038f, -0.59382880f, -0.27149445f, 0.04474113f, 0.03575870f, 0.18710691f, 
    0.00618548f, -0.24180412f, -0.13904171f, -0.05519424f, 0.17462125f, 0.19777356f, -0.12580673f, 0.42474917f, 
    -0.28212824f, -0.11612698f, -0.17377408f, -0.03568809f, 0.07012241f, 0.03947823f, -0.02292511f, -0.04338625f, 
    0.24362795f, -0.06426141f, 0.15448084f, -0.50113761f, 0.00871451f, 0.13179435f, -0.04506149f, -0.09583756f, 
    0.00194152f, -0.06784789f, 0.17787445f, -0.10637322f, 0.15487297f, 0.08921421f, 0.17678355f, 0.30313012f, 
    -0.00919805f, 0.15672743f, 0.13868000f, -0.08502858f, -0.07377674f, -0.08484656f, -0.14271557f, -0.04740552f, 
    0.46691719f, -0.19626682f, 0.00681811f, 0.14997017f, 0.09023238f, -0.22460991f, 0.01268741f, -0.05592450f, 
    0.04130660f, -0.05393755f, -0.23925553f, 0.05913172f, 0.18242830f, 0.20045696f, 0.18222280f, -0.14153160f, 
    -0.05028695f, -0.01700764f, -0.09848170f, 0.19751714f, -0.03708870f, 0.16655764f, 0.02643040f, 0.06991801f, 
    0.06739467f, -0.04461188f, -0.24967107f, 0.52683240f, -0.18715595f, 0.09446765f, -0.22895488f, -0.07715289f, 
    -0.16136563f, 0.07945292f, 0.17210463f, -0.06763241f, 0.10867125f, -0.18371734f, -0.45174581f, 0.51398599f, 
    -0.18117082f, 0.22454844f, -0.23412970f, 0.14315897f, -0.02805503f, -0.19864202f, -0.04952355f, -0.02047431f, 
    0.38152668f, 0.00389732f, 0.25479919f, -0.00992437f, -0.13549256f, 0.06410085f, -0.16446435f, 0.03037108f, 
    0.01226534f, -0.27304280f, -0.09661950f, -0.05134875f, -0.39036605f, 0.00093488f, -0.15453283f, -0.26037958f, 
    0.18474002f, 0.01505580f, 0.00513826f, 0.08189832f, 0.12699543f, -0.40514067f, -0.06135388f, -0.02532023f, 
    -0.26541299f, 0.00840854f, -0.07325055f, -0.27833310f, 0.02551273f, -0.18196984f, -0.07041419f, 0.05062575f, 
    0.09099756f, -0.07438409f, 0.05000267f, 0.03518002f, 0.47947255f, -0.02493065f, -0.39558426f, 0.08299506f, 
    -0.00249193f, -0.06192379f, -0.26443827f, -0.05892849f, -0.01293541f, -0.10571911f, 0.15034525f, -0.01503623f, 
    -0.22676274f, -0.20008695f, -0.06901251f, -0.30003494f, -0.16885762f, 0.10010121f, -0.02027897f, -0.20493099f, 
    0.03061230f, 0.18419579f, 0.10344584f, -0.10921942f, -0.16761878f, 0.09700785f, -0.09041803f, -0.28944370f, 
    0.05640441f, 0.01210861f, 0.11927660f, 0.02432463f, 0.18451114f, 0.17473683f, -0.12808356f, 0.19360030f, 
    0.28530639f, -0.25440621f, 0.14500049f, -0.21210767f, -0.08919677f, -0.35661861f, -0.24421062f, -0.00547666f, 
    -0.20380518f, 0.07812580f, -0.01815961f, -0.16659160f, 0.32715532f, -0.21847115f, 0.12770543f, 0.36904532f, 
    -0.18246114f, -0.13016398f, -0.07974590f, 0.05415531f, -0.02307796f, -0.09887952f, 0.09314361f, -0.09596781f, 
    0.17013207f, 0.02744017f, -0.14706352f, -0.37466365f, -0.00322459f, -0.12997040f, 0.12413056f, 0.03598144f, 
    -0.22442098f, -0.05685385f, 0.03259199f, 0.10668124f, -0.51264125f, 0.10129882f, -0.12372608f, -0.10892509f, 
    -0.04453122f, 0.08483055f, 0.15036733f, 0.03279118f, 0.10911904f, 0.08640473f, -0.10299536f, 0.00813998f, 
    0.47260207f, -0.73794168f, 0.47647187f, -0.28233859f, 0.10417501f, 0.07171689f, -0.14011142f, -0.04469507f, 
    -0.13446586f, 0.19838911f, -0.02711551f, 0.00136253f, -0.05049722f, 0.13448596f, -0.19586219f, 0.11102135f, 
    0.12762940f, 0.11944941f, -0.10935421f, -0.16604146f, -0.01064657f, 0.07767104f, -0.09026971f, -0.07042816f, 
    -0.30474293f, 0.20139614f, 0.15844765f, 0.21629792f, -0.15313317f, 0.19070610f, 0.16926710f, 0.02191574f, 
    -0.08466817f, 0.13092643f, 0.08886320f, -0.06491411f, 0.49668440f, -0.40662429f, 0.10616794f, -0.15775740f, 
    0.24558654f, 0.02511687f, -0.30473787f, 0.01129167f, -0.04361345f, -0.10208353f, -0.13259062f, -0.00198928f, 
    0.59227723f, 0.14795902f, 0.22722687f, 0.25699630f, -0.32415128f, 0.11106960f, 0.04533526f, 0.09990382f, 
    0.27157310f, 0.27706304f, -0.16833152f, 0.12597807f, 0.23376638f, 0.04473942f, 0.09335295f, 0.17707174f, 
    -0.16196685f, -0.38863915f, 0.02718913f, 0.03194400f, 0.02992731f, 0.06056493f, -0.23257895f, 0.26044241f, 
    -0.11738813f, -0.26960102f, -0.05611949f, -0.25243175f, 0.16240539f, -0.07535908f, 0.11890897f, 0.06918537f, 
    0.06683843f, 0.01866357f, -0.04566786f, -0.14589122f, -0.30723745f, -0.36905798f, -0.48433623f, 0.09074247f, 
    -0.30837825f, -0.17069995f, -0.28138724f, -0.09782586f, -0.15198806f, 0.12851492f, -0.13320526f, 0.14420840f, 
    0.33025905f, 0.49417749f, 0.34534377f, 0.53491837f, -0.24837829f, -0.36737707f, -0.08078260f, -0.00710863f, 
    -0.11182451f, -0.04080519f, -0.03228451f, 0.02332480f, 0.66875410f, -0.09451233f, -0.05245856f, 0.17494477f, 
    -0.33533955f, 0.01550314f, 0.03533068f, 0.23981436f, 0.24536376f, -0.08459997f, 0.00826359f, -0.01483249f, 
    -0.11519925f, 0.30689198f, -0.04401127f, 0.01630522f, 0.09078266f, -0.15672387f, 0.04048011f, -0.01416053f, 
    -0.38523591f, -0.04487749f, -0.27398199f, -0.12329490f, -0.54288435f, 0.01893071f, 0.08990031f, 0.19673833f, 
    -0.17836684f, 0.11176480f, -0.08867909f, 0.16945672f, 0.08299007f, -0.01426400f, -0.04053936f, -0.05039472f, 
    0.43860981f, -0.24074434f, -0.17822307f, -0.36304176f, 0.01631474f, -0.19949114f, 0.02661427f, 0.04041707f, 
    -0.23231496f, 0.02960173f, -0.04790777f, -0.14148468f, 0.28133291f, -0.28629076f, 0.09622443f, 0.10996757f, 
    0.26124534f, 0.07170229f, 0.09600956f, -0.13774075f, -0.07905677f, -0.07182658f, -0.14185843f, 0.02799447f, 
    -0.80394650f, -0.09035002f, -0.03971183f, -0.58152097f, 0.14087217f, -0.11786050f, 0.12529331f, -0.26204070f, 
    0.00107214f, -0.07916529f, 0.02424041f, -0.14659914f, 0.63858962f, 0.00712368f, -0.34492415f, -0.15590318f, 
    0.18714908f, 0.38091370f, -0.02461457f, -0.11915255f, -0.05990974f, 0.09318266f, -0.09630187f, -0.36050454f, 
    -0.87638462f, 0.43159020f, 0.16014318f, -0.34792301f, 0.12430388f, -0.00155684f, 0.03849305f, -0.11456115f, 
    0.01216891f, -0.20087737f, 0.00021199f, -0.07682835f, 0.65168196f, -0.34909332f, 0.14880922f, 0.21702102f, 
    -0.38694745f, 0.06099030f, -0.09217069f, -0.06984411f, 0.02001734f, 0.15073891f, 0.10138226f, 0.00194844f, 
    -0.34841546f, 0.19620413f, -0.26177856f, 0.06589355f, -0.02664216f, 0.20270221f, -0.03717252f, -0.13912854f, 
    0.16561066f, 0.00741795f, 0.14220503f, -0.18469417f, 0.44244251f, -0.14389564f, 0.18500014f, 0.21091354f, 
    0.17470779f, -0.19673632f, 0.11689563f, 0.22392394f, 0.02813008f, 0.15899423f, 0.13629793f, 0.07841519f, 
    -0.00554358f, 0.01883261f, -0.11847541f, -0.22241490f, 0.04394938f, -0.08335532f, 0.12234226f, 0.01353967f, 
    -0.13135582f, 0.09366141f, 0.13839637f, -0.22037511f, 0.09457465f, 0.01383928f, -0.04806146f, -0.08590465f, 
    -0.10990743f, 0.08065575f, -0.02963734f, 0.18913488f, -0.25006184f, -0.01455851f, -0.02778083f, -0.24891657f, 
    -1.13834989f, -0.74399310f, -0.25635815f, 0.23285078f, -0.39761618f, -0.09645025f, -0.07405867f, 0.16611071f, 
    -0.11953931f, -0.02447712f, -0.02253623f, -0.04509718f, 0.23769668f, 0.40860149f, -0.01656631f, -0.05590008f, 
    -0.11536776f, 0.05754643f, -0.09068842f, -0.00892446f, -0.03623223f, 0.16351616f, -0.01179316f, 0.00767278f, 
    -0.01121293f, 0.23602793f, -0.10061765f, -0.29498786f, -0.18503815f, -0.29928714f, 0.02445933f, -0.14732803f, 
    0.07267622f, -0.16183794f, -0.02798506f, 0.01632018f, 0.02083745f, -0.07153625f, 0.14608122f, 0.03007345f, 
    -0.11971220f, -0.03147626f, 0.29644191f, -0.05032594f, -0.07462107f, 0.07369173f, -0.01437464f, 0.03249567f, 
    0.77451670f, 0.07719284f, 0.49117592f, 0.03683771f, 0.15780383f, -0.06529742f, 0.00162104f, 0.19685251f, 
    -0.09806466f, -0.09453519f, -0.22603455f, -0.01551849f, 0.03342024f, -0.14863224f, 0.12106999f, -0.06710508f, 
    0.09525863f, 0.05193780f, -0.17194982f, -0.05392346f, 0.07933604f, 0.09882776f, 0.10243770f, -0.19480513f, 
    -0.02559361f, 0.49016479f, 0.10841652f, 0.21174030f, 0.10760278f, -0.04686321f, 0.08933726f, -0.17835672f, 
    0.04119931f, 0.12810279f, -0.07362039f, 0.18185051f, 0.35814568f, -0.22116733f, -0.35480356f, 0.02811131f, 
    -0.10764734f, 0.02484402f, -0.11535744f, -0.22135544f, -0.12058201f, -0.06799902f, -0.06327596f, 0.14035827f, 
    -0.20534363f, -0.05207080f, -0.18111406f, 0.05525548f, 0.04388649f, 0.20360504f, -0.14139365f, 0.26451257f, 
    -0.03596071f, 0.18983932f, -0.06419367f, -0.05506912f, -0.89690667f, 0.13852520f, 0.42106476f, 0.42499873f, 
    0.18817139f, 0.11364567f, -0.02666772f, 0.13944723f, -0.08785120f, 0.01236181f, 0.04170178f, -0.20742486f, 
    -0.21208549f, 0.04424957f, -0.15070519f, 0.23542362f, 0.05288926f, 0.22628371f, 0.02157841f, 0.21196705f, 
    -0.08777372f, 0.07063674f, 0.21970905f, 0.19908078f, -0.24977864f, 0.29619181f, -0.04660517f, -0.12090380f, 
    0.03324008f, -0.28738230f, -0.00745454f, 0.20872785f, 0.13270827f, -0.16148593f, 0.20145896f, -0.22962484f, 
    0.07095379f, -0.52887982f, -0.23945631f, 0.42580089f, -0.09747403f, -0.08782925f, 0.07060742f, -0.03563588f, 
    -0.12644880f, -0.15570024f, 0.06215315f, -0.40344661f, 0.08042774f, -0.04943234f, -0.03051820f, 0.02432593f, 
    -0.08197080f, -0.08738272f, -0.03869338f, -0.12975985f, -0.18726251f, -0.00541517f, -0.00925052f, -0.00941627f, 
    -0.75502551f, -0.29686806f, -0.35488778f, -0.28442988f, -0.06380089f, -0.22798172f, 0.00965590f, -0.34109229f, 
    0.17360783f, -0.07016753f, 0.23421840f, -0.03805548f, 0.36778671f, -0.75162309f, -0.74230039f, 0.05209330f, 
    -0.15293887f, 0.17902762f, 0.08404753f, 0.24906640f, 0.07320157f, -0.03496409f, -0.03174860f, -0.10308091f, 
    0.04389925f, 0.25280485f, -0.24474059f, -0.59458405f, 0.20709939f, 0.13832143f, 0.00144799f, 0.31981957f, 
    0.02517527f, -0.02110589f, -0.09962870f, -0.03058992f, 0.52267247f, 0.08133699f, 0.35015658f, -0.16938183f, 
    0.09371124f, 0.12565894f, 0.16141146f, 0.25069460f, 0.24132496f, -0.01665448f, 0.05819866f, 0.15380962f, 
    -0.03576138f, -0.51647913f, -0.12166686f, 0.49667647f, 0.11204175f, -0.14671883f, 0.07754425f, 0.03191684f, 
    -0.14744046f, -0.11693482f, 0.01880676f, 0.15478283f, -1.24877954f, 0.47417530f, 0.01317416f, 0.03601335f, 
    -0.11627930f, 0.02557900f, 0.02688254f, -0.04219434f, -0.04912021f, 0.18159378f, -0.03620314f, 0.03284310f, 
    0.00188436f, 0.36827508f, -0.16944402f, -0.17927960f, 0.16794939f, -0.07076413f, -0.03289502f, 0.20011158f, 
    -0.16290690f, -0.00694465f, -0.01912962f, -0.11074132f, 0.12600951f, 0.03899688f, -0.21292263f, 0.29285118f, 
    0.06265584f, -0.16019513f, -0.08178298f, 0.07653399f, -0.04439518f, -0.02749876f, 0.23372342f, 0.08262345f, 
    0.01604467f, 0.00500725f, 0.26910093f, 0.18924601f, 0.04931681f, 0.13287540f, -0.00339337f, 0.08563707f, 
    0.01306785f, -0.03137849f, -0.14126030f, 0.08147977f, 0.10773940f, -0.10353521f, 0.05204873f, 0.08428486f, 
    -0.31357536f, 0.11197059f, 0.09442706f, -0.00552903f, 0.07606055f, -0.14698720f, -0.22877187f, -0.02721529f, 
    -0.16547425f, -0.45149761f, 0.36436433f, -0.05553297f, -0.17574801f, 0.01957480f, 0.23293449f, 0.02364397f, 
    0.05551117f, -0.00240521f, 0.14540455f, 0.05635805f, -1.10457182f, -0.25678405f, 0.45605475f, 0.07818316f, 
    -0.13249476f, -0.23451203f, -0.14328520f, -0.11637881f, 0.00843409f, -0.01248839f, 0.09263914f, -0.00326230f, 
    -0.64047915f, 0.17379765f, -0.32549143f, -0.00823561f, 0.11382591f, 0.01083292f, -0.16109340f, -0.35194090f, 
    0.12204947f, -0.12442474f, 0.00037421f, -0.08813036f, -0.12990156f, 0.45686427f, -0.27960762f, -0.14282854f, 
    -0.00940835f, -0.09403262f, 0.12327496f, 0.10463161f, 0.01006949f, 0.09678413f, -0.02037144f, -0.18205053f, 
    -0.20466982f, 0.17449068f, 0.44240263f, 0.16419168f, -0.08678039f, -0.04804170f, -0.05631166f, -0.15167370f, 
    0.10519026f, -0.15062748f, -0.04088619f, -0.06771122f, -0.59270447f, -0.14388540f, -0.03818312f, 0.30413514f, 
    -0.17458026f, 0.10717899f, 0.23224331f, -0.01486027f, -0.17144483f, -0.02111335f, 0.09563159f, 0.06349633f, 
    0.22371437f, 0.17157789f, 0.00346175f, 0.16299470f, 0.05525735f, 0.04119131f, 0.16456673f, 0.07545222f, 
    -0.08665383f, 0.06483229f, 0.04965410f, 0.27455971f, -0.05493280f, -0.33385903f, -0.01240616f, -0.32064819f, 
    -0.12982652f, 0.24443820f, -0.01049213f, -0.32513636f, -0.04614524f, -0.12959161f, -0.03511219f, -0.22907133f, 
    -0.13145821f, 0.07535034f, 0.35535809f, 0.73293310f, 0.13146336f, 0.11161466f, 0.02222255f, -0.08605073f, 
    0.06827260f, -0.02346254f, -0.15298566f, 0.14322844f, -0.63420272f, -0.37794974f, 0.05160964f, 0.33337522f, 
    -0.01219966f, 0.25568131f, -0.04616783f, 0.15971409f, 0.06584474f, 0.11806239f, -0.04383702f, 0.09355132f, 
    -0.56169111f, -0.08338741f, -0.33398205f, -0.11080711f, 0.17940475f, 0.36786324f, 0.04176332f, -0.18205905f, 
    0.05259879f, 0.10039127f, 0.17503393f, -0.14352189f, -0.85865116f, 0.28094801f, -0.42843452f, -0.24787179f, 
    0.26886985f, 0.11909498f, -0.11459033f, -0.07441860f, -0.02051738f, 0.01827358f, 0.05024775f, -0.15528792f, 
    -0.41882801f, -0.42089230f, 0.31882501f, 0.24151717f, -0.08151023f, 0.05592796f, 0.02757633f, -0.08938304f, 
    0.17896664f, 0.05305717f, -0.05291935f, 0.18572398f, 0.03727760f, -0.11481050f, -0.15403466f, 0.13988584f, 
    0.32103971f, -0.14400937f, 0.21441643f, -0.05884597f, 0.14249410f, 0.17634790f, -0.30946946f, -0.07969918f, 
    -0.07634889f, -0.26104969f, -0.32802147f, 0.17283414f, 0.05440611f, -0.21560651f, -0.08745946f, 0.13995585f, 
    -0.07928441f, 0.11500938f, 0.22864743f, 0.39825997f, 0.12728147f, -0.08609297f, 0.07800172f, -0.28904960f, 
    0.15370652f, 0.04537039f, 0.00849674f, 0.02765921f, 0.12259053f, 0.07180494f, 0.22922611f, 0.38418543f, 
    0.05884799f, 0.20233253f, -0.23491268f, 0.16583702f, -0.00951804f, -0.00126090f, -0.01546492f, -0.04581328f, 
    0.01690134f, -0.15068597f, 0.10889636f, -0.16827972f, 0.32067329f, 0.01994434f, 0.29594171f, -0.14311986f, 
    -0.14916143f, -0.17995152f, 0.03710417f, -0.00045554f, -0.09381073f, -0.28578141f, -0.04538811f, 0.18457210f, 
    -0.35620764f, 0.06446902f, -0.04781947f, 0.09228250f, -0.09713984f, -0.08907643f, -0.28719267f, -0.02168587f, 
    0.00943156f, -0.01159396f, -0.08765979f, 0.09760123f, -0.44798499f, 0.15962891f, 0.23260197f, -0.12035164f, 
    0.00056246f, -0.16553919f, 0.13129194f, -0.19359106f, 0.12088949f, -0.07432284f, -0.08289595f, -0.08462601f, 
    0.17633833f, 0.00592250f, 0.06129457f, 0.24888727f, -0.28891796f, 0.06663495f, -0.13440037f, 0.21798719f, 
    -0.04784594f, 0.11026789f, -0.05122670f, 0.12278987f, 0.37326676f, 0.25895819f, -0.34787661f, -0.44320416f, 
    -0.18998781f, 0.07160077f, -0.12441678f, -0.31923971f, -0.13040790f, -0.14343455f, -0.10710500f, -0.06371263f, 
    -0.27433825f, -0.04944631f, 0.32079408f, -0.48217368f, 0.10129011f, -0.14764071f, -0.02149614f, -0.01628569f, 
    0.11491456f, -0.02224150f, -0.10132956f, -0.19239753f, 0.17125984f, 0.16267461f, 0.07403042f, -0.12111715f, 
    0.04173866f, -0.12183286f, -0.00064931f, 0.04257833f, -0.04582927f, 0.04392089f, 0.14104097f, -0.00945921f, 
    -0.06486668f, -0.08152204f, -0.13253453f, 0.03758931f, -0.06325141f, -0.04576905f, 0.14946173f, 0.19538476f, 
    -0.02838828f, 0.08055750f, 0.27092117f, 0.09274671f, -0.04030742f, -0.06303623f, 0.14125758f, -0.17022878f, 
    0.06040611f, -0.04540979f, -0.02029634f, -0.20591845f, -0.24441108f, 0.27356672f, 0.12806080f, 0.14961238f, 
    0.33693513f, -0.06861217f, -0.38192785f, -0.24041846f, -0.36422154f, 0.06633177f, 0.04210518f, -0.01562697f, 
    -0.25825822f, 0.18871237f, -0.15575311f, 0.04552232f, 0.19581337f, -0.85674852f, 0.17308529f, -0.20430686f, 
    -0.10412790f, 0.10961635f, 0.19217332f, 0.15574411f, 0.13926427f, 0.18184729f, 0.00046129f, 0.09212269f, 
    0.23605025f, -0.34548810f, -0.17141983f, 0.27706993f, -0.09979685f, 0.12484518f, -0.08074129f, -0.00529903f, 
    -0.04290537f, -0.30380368f, -0.31611258f, -0.19706410f, -0.33628559f, -0.11799665f, -0.35431683f, -0.12460333f, 
    -0.20532297f, 0.15621509f, -0.17393368f, -0.07604280f, -0.04169116f, 0.03250678f, 0.27128682f, 0.24248759f, 
    -0.19809347f, -0.12447300f, -0.18162386f, -0.26412764f, -0.04702404f, 0.26244947f, 0.00811227f, -0.12014975f, 
    0.10812739f, -0.26820716f, 0.12577687f, 0.15146942f, -0.21536228f, 0.53323817f, 0.14914607f, -0.40318781f, 
    -0.09633331f, 0.01619834f, 0.04560525f, 0.07725997f, 0.08062002f, -0.03893057f, -0.20759308f, 0.02314747f, 
    -0.29146791f, 0.09378199f, -0.44842276f, 0.67980248f, 0.10906380f, 0.04119693f, -0.14357810f, 0.09121519f, 
    -0.03138151f, 0.05225314f, -0.13630846f, -0.14468734f, 0.27145168f, 0.10625704f, -0.08502553f, -0.24606931f, 
    0.23421498f, -0.01932444f, 0.04301997f, 0.09657852f, -0.12700580f, 0.01020255f, -0.03595067f, -0.12532637f, 
    0.31571132f, -0.31245607f, -0.18148364f, 0.20655081f, 0.03141684f, -0.11400750f, 0.21022190f, 0.07882772f, 
    -0.12075750f, 0.01642463f, -0.15880604f, 0.07427082f, 0.62556452f, -1.15226483f, 0.07062598f, -0.13894790f, 
    -0.14832908f, 0.10608008f, 0.04101348f, 0.12177610f, -0.06167147f, 0.18085940f, 0.08234387f, 0.38123888f, 
    0.06620615f, 0.14372897f, 0.20327887f, -0.74926275f, 0.11165878f, 0.04546823f, -0.11931671f, 0.07126086f, 
    0.17516024f, -0.08958972f, 0.19596373f, -0.00281532f, -0.44281515f, -0.29151541f, 0.04431806f, 0.25057623f, 
    -0.12890667f, 0.00830305f, -0.09521484f, -0.02475854f, 0.21179861f, 0.00255282f, -0.03636806f, 0.23268580f, 
    -0.23492658f, 0.07481447f, 0.37929460f, -0.27282038f, -0.17678858f, -0.13204795f, -0.13291524f, 0.08990978f, 
    -0.07851094f, -0.13341388f, -0.05987018f, 0.03286790f, -0.28888556f, 0.47585228f, 0.35954162f, 0.13384439f, 
    0.01513359f, 0.30156943f, -0.06229941f, -0.01606480f, 0.08149192f, -0.03976623f, -0.02634447f, -0.20957372f, 
    0.04394273f, -0.00037666f, -0.27632919f, -0.10651601f, -0.09729271f, -0.11514022f, -0.12362769f, -0.17966115f, 
    -0.18580970f, -0.04757778f, -0.08205824f, -0.02221305f, -0.06615727f, 0.19836067f, 0.21701437f, 0.21125613f, 
    0.23472025f, 0.03075404f, 0.13321348f, -0.07180311f, -0.20742449f, -0.04175825f, 0.21313897f, -0.10802434f, 
    0.10309031f, 0.42438602f, 0.16221264f, 0.49917433f, 0.14577813f, 0.13829438f, 0.20421885f, 0.07593003f, 
    -0.09261822f, -0.05275080f, 0.11575405f, 0.06935243f, 0.52673703f, -0.14738953f, 0.47832069f, -0.15853050f, 
    0.00089310f, 0.08628909f, -0.09319219f, -0.15859424f, -0.23104692f, 0.18134078f, -0.21116796f, -0.18091597f, 
    -0.12432720f, 0.38837883f, -0.01034195f, 0.14766532f, 0.20593816f, -0.07657423f, 0.00414960f, 0.20669885f, 
    -0.04228830f, -0.02293265f, -0.09518618f, -0.20247178f, 0.16164312f, 0.47904158f, 0.25170010f, 0.41485026f, 
    0.13892186f, 0.06314863f, 0.09515054f, 0.00433403f, -0.26643670f, -0.06099707f, 0.05702125f, -0.17628866f, 
    0.50464314f, -0.20417218f, 0.32205310f, 0.25612211f, -0.06709159f, -0.24554253f, -0.11783578f, -0.28743407f, 
    0.00412625f, -0.04996403f, -0.16479555f, -0.18376584f, -1.08349633f, 0.34257320f, -0.13699497f, -0.22775315f, 
    0.30529568f, -0.09781563f, 0.08024153f, -0.11591571f, -0.17040518f, 0.15661585f, 0.09074763f, -0.19784278f, 
    -0.11927155f, -0.16071241f, -0.26931682f, 0.38694888f, 0.05631565f, -0.15870000f, -0.05557330f, -0.00364353f, 
    -0.09691831f, -0.07152122f, 0.10614909f, -0.16637111f, 0.47110501f, -0.68024355f, -0.04780873f, 0.11687040f, 
    -0.18805256f, 0.02954698f, -0.07444067f, 0.11399250f, -0.08867203f, -0.00006792f, -0.02066512f, 0.02897792f, 
    0.00759375f, 0.07303855f, -0.35649997f, -0.01294506f, -0.15021521f, 0.10912124f, -0.13422248f, 0.11033466f, 
    0.08380045f, -0.10981308f, -0.29652783f, -0.04514136f, -0.46719304f, 0.07413120f, 0.16463991f, -0.23684716f, 
    0.14682363f, -0.04195693f, -0.15487795f, -0.21023327f, -0.09889507f, 0.09716845f, 0.11678998f, 0.11694679f, 
    -0.05464837f, -0.09723782f, -0.29309571f, -0.09046225f, -0.13654785f, -0.03800189f, -0.01453960f, -0.12032886f, 
    -0.28015137f, -0.05507867f, 0.11889637f, 0.16924845f, -0.46693891f, 0.16008548f, -0.16251424f, -0.20387644f, 
    -0.35955542f, 0.06045833f, -0.10975918f, 0.02498688f, 0.03621231f, 0.14272510f, -0.11257676f, 0.01970499f, 
    -0.09056390f, 0.11983942f, -0.17774805f, -0.29128104f, 0.06387166f, 0.09581185f, -0.08279001f, -0.19839875f, 
    0.04981988f, -0.12661846f, -0.16564292f, -0.14545572f, -0.24511343f, 0.46884775f, -0.21768625f, -0.41801938f, 
    -0.38842517f, 0.20368268f, -0.14807454f, -0.06643265f, 0.02074366f, -0.24050151f, 0.20948310f, -0.35190350f, 
    0.23737094f, 0.40765724f, 0.08575379f, 0.23200104f, 0.11294910f, -0.01925574f, -0.07504860f, -0.29868165f, 
    -0.07230214f, -0.00712622f, -0.06633306f, 0.02966734f, -0.40520900f, -0.42871037f, 0.17036335f, -0.32339641f, 
    -0.20247018f, -0.20588188f, -0.35769325f, -0.07220355f, -0.02354869f, 0.09517024f, 0.06258679f, -0.13273560f, 
    -0.39146426f, 0.13853066f, 0.32020503f, -0.02486537f, -0.19405264f, 0.07284104f, 0.13772917f, -0.04038078f, 
    -0.05792433f, -0.07701986f, -0.11360544f, -0.22203717f, -0.23251928f, -0.34630293f, 0.28520322f, 0.06364615f, 
    -0.28415784f, -0.13522239f, -0.01742647f, 0.00630023f, 0.06057613f, -0.06943582f, -0.04103421f, 0.00980556f, 
    0.22228144f, 0.28378016f, -0.26382115f, -0.24655272f, -0.11916421f, -0.27488142f, -0.22510266f, -0.00444585f, 
    0.17421880f, 0.01671869f, 0.28619424f, 0.14867149f, -0.33415577f, 0.48985821f, 0.12709452f, -0.29779449f, 
    -0.05383888f, -0.41508955f, -0.05709287f, -0.10901459f, -0.01881585f, -0.13524039f, -0.08746471f, 0.29198226f, 
    -0.22104679f, -0.09875021f, 0.00060856f, -0.44376692f, 0.03325514f, 0.19219485f, -0.25555834f, -0.26971412f, 
    0.08150605f, -0.11921968f, -0.08249579f, 0.14980565f, -0.09226821f, -0.38481900f, 0.13582364f, 0.28277063f, 
    0.33105767f, 0.18795007f, -0.12724370f, -0.09528648f, 0.03833230f, -0.00481396f, 0.36434633f, 0.10721027f, 
    0.21128711f, 0.45609680f, -1.11379874f, -0.32756108f, 0.08794592f, -0.13772283f, -0.31985423f, -0.05577476f, 
    0.12108020f, -0.11925239f, 0.03632076f, 0.09188301f, 0.28600049f, -0.36429110f, -0.63577843f, 0.05899826f, 
    0.05326073f, -0.04215918f, 0.21709776f, -0.02927068f, 0.13512248f, 0.05322621f, 0.10893295f, 0.05006925f, 
    -0.20741643f, 0.40829501f, -0.06539753f, -0.07257825f, -0.42144492f, -0.02466905f, -0.05675312f, -0.13317458f, 
    0.04071580f, -0.05432248f, 0.06321475f, 0.20114538f, 0.29302979f, -0.28083417f, 0.24274012f, 0.20555386f, 
    -0.24174613f, -0.09959894f, -0.00115499f, -0.22814907f, -0.05253386f, -0.21746306f, -0.29808229f, -0.06596004f, 
    -0.24447492f, -0.27694049f, 0.02455233f, 0.42806908f, 0.05619768f, 0.10702550f, 0.04446319f, -0.05321322f, 
    0.27330664f, 0.11227811f, -0.15140760f, -0.03576524f, 0.40509659f, 0.25150391f, -0.03852942f, 0.21156314f, 
    -0.10844928f, -0.07910696f, 0.03754385f, -0.16473195f, -0.14001869f, -0.27227935f, 0.06078068f, -0.03893824f, 
    0.45576188f, -0.06589889f, 0.10632943f, 0.20590439f, 0.19637847f, -0.13302512f, -0.01528324f, -0.17958787f, 
    0.02150668f, 0.04226149f, -0.01644406f, -0.39462739f, 0.07787657f, -0.31480667f, -0.09533379f, 0.13565524f, 
    0.16178080f, -0.25171432f, 0.02684445f, -0.06260725f, 0.15582034f, 0.29881319f, -0.00994014f, 0.14974844f, 
    0.07813612f, 0.43007383f, -0.32334492f, -0.48907676f, 0.24649654f, -0.13302459f, 0.15805334f, -0.07371210f, 
    0.00321800f, 0.18265033f, 0.16394441f, -0.03950566f, -0.13023929f, -0.72077155f, -0.34266475f, 0.62968028f, 
    -0.06824229f, -0.01478062f, 0.15354128f, 0.29105696f, -0.13687061f, -0.09104216f, -0.02166811f, -0.06981592f, 
    -0.48336560f, -0.26226431f, 0.22906266f, -0.10390254f, 0.10593656f, -0.18915406f, -0.10263035f, 0.10818242f, 
    0.18770118f, -0.13569754f, 0.13337755f, 0.20775594f, 0.26583096f, -0.16563453f, -0.23817211f, 0.15385962f, 
    0.16001658f, 0.00495127f, 0.03545624f, -0.16237685f, -0.12851965f, -0.11419052f, -0.16788456f, -0.00467598f, 
    -0.11150359f, 0.07938193f, -0.22023134f, -0.45132670f, -0.06577872f, -0.02771378f, -0.09919286f, 0.21459126f, 
    0.00574086f, -0.01983476f, -0.04887196f, -0.18348610f, 0.55152506f, -0.31555539f, -0.17108288f, 0.08983640f, 
    -0.12144215f, 0.15344393f, -0.03361684f, 0.30975416f, -0.03644033f, -0.28962418f, 0.19146718f, -0.10581175f, 
    0.02198422f, -0.58927751f, -0.42054847f, 0.12662594f, 0.02820703f, 0.07097882f, 0.13443597f, -0.12543073f, 
    0.00631685f, 0.01282046f, -0.07505208f, -0.12664837f, -0.54167241f, 0.39896786f, 0.04174678f, -0.39462921f, 
    -0.05196472f, -0.00338850f, -0.19168667f, -0.11702725f, -0.08613756f, -0.05701667f, -0.08496489f, -0.35680100f, 
    0.43663612f, 0.05540534f, 0.35172248f, -0.12203529f, -0.03410693f, 0.22595440f, -0.08082019f, -0.24604145f, 
    -0.07669052f, 0.16781795f, -0.04198414f, -0.07500404f, -0.21218818f, -0.05238194f, 0.14405333f, -0.40199825f, 
    -0.08595540f, 0.09126024f, -0.28381863f, 0.12831730f, 0.04819104f, 0.11936987f, 0.15060389f, 0.07366151f, 
    0.75859600f, 0.44319040f, -0.48916692f, 0.34343418f, -0.08626842f, -0.06289218f, 0.27741835f, 0.19443159f, 
    -0.06820098f, 0.15302977f, 0.15679368f, 0.11456762f, -0.17177527f, -0.03716092f, 0.09333209f, 0.05006638f, 
    0.18757464f, 0.18979083f, -0.13421768f, 0.07173252f, -0.08355209f, -0.00485602f, 0.26973072f, 0.18842264f, 
    -0.13647148f, 0.01284745f, -0.41300741f, -0.48629022f, 0.07255168f, -0.03982590f, -0.06005279f, -0.24370654f, 
    -0.45472592f, -0.15815389f, -0.11012735f, 0.01278165f, -0.95995116f, 0.71167326f, 0.20104733f, 0.06869154f, 
    0.20784038f, -0.02476068f, 0.04505770f, 0.19087300f, 0.32239562f, 0.17501953f, 0.08666617f, 0.06141853f, 
    -0.69333357f, 0.41575605f, -0.25516412f, -0.36506426f, 0.14110860f, 0.24622767f, 0.10675789f, -0.08430914f, 
    0.06631685f, -0.10285450f, 0.13706250f, 0.14279898f, -0.25124341f, 0.39746928f, 0.28776166f, -0.11215504f, 
    -0.03263058f, -0.00240784f, 0.36397502f, -0.10278576f, 0.00783542f, -0.24238323f, 0.00262813f, -0.07389243f, 
    -0.96489412f, -0.49455622f, -0.30142418f, -0.33794609f, 0.02568354f, 0.21372053f, -0.17732452f, -0.30455765f, 
    0.00477557f, -0.11699756f, 0.07090743f, 0.13881223f, 0.05910837f, -0.04495038f, 0.23434149f, -0.08413367f, 
    -0.12281223f, -0.02332955f, 0.05041979f, -0.15509358f, 0.02951184f, -0.07630299f, 0.17434658f, -0.09332905f, 
    0.31299439f, 0.07310425f, -0.16752824f, -0.05742705f, -0.16876401f, -0.07947262f, -0.01523478f, -0.16362230f, 
    0.00262838f, 0.33672172f, -0.07914632f, -0.15505065f, 0.59527290f, 0.05962690f, -0.11285938f, 0.19620784f, 
    -0.39284027f, -0.18282266f, -0.20533323f, 0.07583819f, -0.06440459f, -0.08441861f, 0.02750799f, -0.14622974f, 
    0.09852257f, 0.04029866f, -0.33305943f, -0.16008842f, 0.11252430f, 0.07004803f, -0.07009359f, 0.20686686f, 
    0.16659567f, 0.16013555f, 0.41244081f, 0.30730444f, 0.00845974f, -0.18242146f, 0.49927819f, -0.10743929f, 
    0.02262499f, -0.14058127f, 0.21726038f, -0.17934586f, -0.30881253f, 0.05196133f, -0.18366410f, 0.05811791f, 
    0.45141414f, 0.45168355f, -0.12879305f, -0.24215816f, -0.01930831f, 0.33636987f, 0.19795932f, 0.00683065f, 
    -0.10061692f, -0.05886812f, 0.15841843f, -0.07160646f, -0.87254596f, -0.61758012f, -0.24269892f, -0.29674700f, 
    0.02781936f, -0.10094030f, 0.05745006f, 0.26639858f, 0.01993737f, 0.14302291f, 0.21404636f, 0.09884659f, 
    -0.80215293f, -0.09403975f, 0.44529051f, 0.07120291f, 0.31824002f, -0.16734466f, -0.05812687f, -0.07485396f, 
    0.08554258f, 0.03762745f, -0.18911013f, 0.16037220f, -0.24150881f, 0.24246466f, -0.03518958f, -0.03491606f, 
    -0.00072386f, 0.14147794f, 0.00078166f, 0.16873020f, -0.07373407f, -0.09673427f, -0.08075470f, -0.00259593f, 
    -0.04245205f, -0.29690456f, 0.40929249f, 0.24648955f, 0.12022179f, -0.07329796f, 0.00338375f, 0.00804009f, 
    0.07054523f, 0.07530869f, 0.16794905f, -0.05359243f, 0.18030876f, 0.28551689f, -0.30207291f, -0.00550741f, 
    -0.04898166f, -0.14203425f, -0.18609679f, 0.00489904f, 0.06588137f, -0.10696738f, -0.10935768f, 0.00390362f, 
    -0.33350548f, 0.09506501f, 0.09458334f, -0.47949103f, 0.11337324f, 0.03004805f, 0.06954515f, 0.27722958f, 
    -0.03050974f, 0.39938936f, -0.02817125f, 0.25501293f, -0.32816082f, -0.25313839f, -0.32478777f, -0.24397370f, 
    0.09936471f, 0.11262660f, 0.17826790f, 0.06290990f, 0.19367629f, -0.34704861f, -0.03545158f, -0.04475612f, 
    -0.43376371f, -0.38092512f, -0.17457499f, -0.13201408f, 0.18652621f, 0.06345472f, 0.12095918f, 0.04267789f, 
    0.17140509f, 0.10213041f, -0.13083427f, -0.03764752f, -1.13298452f, -0.61960727f, 0.35557607f, 0.16542564f, 
    0.23646905f, -0.26562116f, -0.05259890f, -0.26878175f, 0.07777142f, -0.05990839f, 0.07969929f, 0.41455826f, 
    0.37312615f, -0.67729431f, -0.28904891f, -0.04519854f, -0.11192013f, -0.11577996f, 0.10859518f, -0.02896296f, 
    -0.12562647f, 0.25613591f, -0.04452089f, -0.01693252f, 0.09793978f, 0.23307258f, -0.04819168f, -0.28489873f, 
    -0.20739549f, -0.05205060f, 0.27994534f, -0.21236664f, -0.00790440f, 0.18958297f, 0.12061927f, -0.12583582f, 
    0.26291007f, -0.30749100f, 0.11322131f, 0.13071151f, -0.25009540f, 0.09071305f, -0.17978114f, 0.04013192f, 
    -0.02531817f, -0.12109572f, 0.05949243f, -0.09940258f, -0.24486789f, 0.15373079f, 0.26852506f, 0.13698283f, 
    0.10021211f, -0.04160367f, 0.04082378f, -0.19588622f, 0.03814811f, -0.07693374f, 0.11156754f, -0.02925673f, 
    -0.09405454f, -0.28888187f, 0.26436314f, 0.72855741f, -0.06163990f, 0.20306557f, 0.09776772f, 0.09523731f, 
    -0.13772614f, -0.12885009f, -0.06671408f, -0.03274557f, 0.00795666f, -0.07072994f, 0.17966884f, -0.08843365f, 
    -0.05311104f, -0.30957806f, -0.21710315f, 0.12859675f, -0.18424650f, -0.08862405f, 0.15997601f, -0.16656210f, 
    -0.57504064f, 0.37244564f, -0.43184614f, -0.17431092f, -0.13698696f, -0.02120312f, 0.05153627f, 0.26310968f, 
    0.14893550f, -0.15381116f, -0.06420948f, -0.13686766f, 0.29882032f, 0.08700046f, -0.41154787f, 0.56898499f, 
    0.14290774f, -0.04812808f, -0.01092759f, -0.01843956f, -0.08361851f, 0.03917030f, -0.13369799f, -0.24866802f, 
    0.97017753f, -0.01685390f, -0.12293493f, 0.16040239f, -0.13946192f, -0.13842340f, 0.11104646f, -0.13844340f, 
    0.38044375f, 0.28096572f, 0.07500733f, 0.21420735f, 0.50562006f, 0.04676733f, -0.49590147f, 0.22252326f, 
    0.09669141f, -0.03110297f, -0.00996942f, 0.15268865f, -0.05343916f, 0.08927671f, 0.01482039f, 0.01762656f, 
    -0.41505435f, -0.31647885f, 0.18403125f, 0.20554371f, 0.00107914f, -0.09560989f, -0.01760741f, -0.02582178f, 
    -0.14597845f, 0.11553324f, -0.13209723f, -0.14396216f, -0.63050717f, -0.05377408f, -0.12954436f, -0.45173103f, 
    0.05944684f, -0.04759365f, -0.05354481f, 0.10083558f, -0.17895527f, -0.03892160f, -0.02109877f, 0.19341430f, 
    0.34088951f, 0.03648578f, -0.14101602f, -0.22057436f, 0.20526394f, -0.43482774f, 0.02175358f, 0.05143145f, 
    0.15468475f, -0.11563345f, -0.06969839f, -0.11730967f, -0.45353377f, -0.27928975f, 0.24230722f, -0.18168390f, 
    0.04978513f, -0.02188624f, 0.32534793f, 0.00463042f, 0.03220859f, 0.10996470f, -0.06554364f, -0.11857110f, 
    -0.13949724f, -0.26206771f, -0.16675010f, -0.27827621f, 0.02685178f, -0.02899995f, -0.08178740f, 0.06931896f, 
    -0.09396943f, -0.17208049f, -0.03758657f, 0.07376152f, 0.24926998f, -0.00974706f, -0.07439623f, -0.31609964f, 
    0.27735189f, -0.03173385f, -0.05049378f, -0.00727217f, -0.12164862f, 0.05392078f, 0.08551442f, -0.02947469f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08759250f, 0.02535462f, -0.06839377f, 0.10473217f, 0.03235527f, 0.01935951f, -0.03139797f, -0.11034705f, 
    -0.08241990f, 0.04325312f, 0.29977864f, 0.08594117f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
