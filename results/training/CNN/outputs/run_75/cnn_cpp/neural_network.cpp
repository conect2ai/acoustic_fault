#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.63655442f, 1.04584742f, 0.78690726f, -0.09559815f, 0.42071486f, 0.19926974f, -0.40770486f, -0.23813580f, 
    -0.26779932f, -1.09364367f, -0.11524838f, 0.96267021f, 0.58562899f, 0.42171687f, 0.42489463f, -0.42830375f, 
    -0.09783103f, 0.07392900f, -0.38512442f, -0.82974428f, -0.53815097f, -0.53815043f, -0.50401574f, 0.57851106f, 
    -0.47359475f, -0.47897297f, -0.09526554f, -0.75315791f, 0.16652317f, 0.35369039f, 0.81310111f, 0.15588772f, 
    0.50515258f, -0.42630944f, -0.06012001f, -0.64316404f, 0.36570758f, -0.88048184f, 0.47464377f, 0.79142141f, 
    0.65555161f, 0.66983551f, -0.26105797f, 0.03909768f, -0.09552427f, 0.43512535f, 0.86979848f, 0.73799324f, 
    0.66615313f, 0.27091193f, -0.37415919f, 0.14193104f, 0.01373890f, -0.34689608f, 0.93798494f, 0.51559061f, 
    0.78160882f, -0.21240236f, -0.78042740f, 0.33650967f, -0.56967497f, -0.47912508f, 0.06762755f, 0.75360024f, 
    -0.78865999f, -0.69018525f, -0.55114633f, 0.84040773f, 0.46581846f, 0.24469079f, -0.04760404f, 0.16996598f, 
    -0.29723498f, 0.83855695f, -0.92624450f, -0.54683316f, -0.79776800f, 0.46407539f, -0.34988451f, 0.08631763f, 
    0.28237206f, -1.04323208f, 0.62078714f, -0.38672858f, 0.61939615f, -0.27548334f, -0.51135010f, -0.19599356f, 
    0.18006609f, -0.49666834f, 0.90874499f, 0.62842447f, -1.03607953f, 0.29332799f, -0.58696115f, 0.22569495f, 
    0.38993052f, 0.01013308f, -0.44011536f, 0.85925502f, -0.10772393f, 1.00573623f, 0.71778190f, -0.19927113f, 
    -0.58431506f, 0.45855445f, 0.02184871f, -0.30523983f, 0.99544704f, 0.32746717f, 0.32810053f, -0.60789973f, 
    0.24298014f, -0.57856321f, -0.13007137f, -0.40374202f, -0.39670846f, 1.01887810f, 0.99614853f, -0.43318132f, 
    0.14887708f, 0.45065033f, -0.12173624f, 0.19610544f, 0.02957238f, 0.32305804f, 0.13927966f, 0.36787236f, 
    -0.82698750f, 0.81654799f, -0.81065518f, 0.19440812f, -0.03403708f, -0.21431054f, 0.05442648f, -0.57333231f, 
    -0.98761904f, 0.02556019f, -0.39500961f, 0.85289526f, 0.75585955f, -0.21652928f, -0.01645996f, -0.25763181f, 
    -1.20675969f, 0.88722813f, -0.17737687f, -0.08072747f, 0.74187976f, -0.61432743f, -0.26228592f, -0.22007085f, 
    0.39947125f, -0.78585672f, -0.56236863f, 0.53137338f, 0.40844548f, -0.31812221f, -0.80266345f, 0.33781886f, 
    0.34841183f, 0.45203286f, -0.52968532f, 0.61333030f, -0.46415597f, 0.81402278f, 0.63725460f, 0.78274286f, 
    0.22444128f, -0.08324740f, -0.59409356f, 0.25291753f, 0.06228193f, 0.37933657f, -0.35149658f, -0.94799119f, 
    0.63423342f, -0.04432509f, 0.12065974f, -0.67619348f, -0.15115485f, 1.06352997f, 0.57862091f, -0.81291837f, 
    0.44628143f, 0.25045392f, 0.31434181f, 0.18860772f, -0.19244409f, 0.90419334f, 0.85899270f, 0.81156385f, 
    -0.65761054f, 0.45094240f, -0.58898377f, -0.22221857f, 0.59737742f, -0.25106907f, 0.55759293f, 1.12796187f, 
    0.69861501f, -0.43536848f, -0.05593592f, 0.48096898f, 0.01747441f, 0.37767601f, -0.30831292f, -0.73182797f, 
    -0.49522772f, -0.13259299f, 0.65203828f, 0.41803557f, 0.50499284f, -0.18788235f, -0.52071035f, 0.50308007f, 
    -0.72068369f, 0.42730460f, 0.75305790f, 0.55113024f, 0.62206954f, 0.18312117f, 0.32176158f, -0.32335234f, 
    0.15524781f, -0.78525472f, -0.23016207f, 0.57647973f, -0.98902375f, -0.34669241f, -0.66513723f, 0.09022655f, 
    -0.04685346f, -0.13798194f, 0.53764379f, -0.29876861f, 1.05953145f, -0.59937531f, -0.97415149f, -0.47356170f, 
    0.47039375f, 0.10374447f, -0.28609428f, -0.95415097f, 0.80550647f, -0.35886988f, -0.50307655f, 0.62257546f, 
    -0.37629804f, -0.04556239f, 0.32864210f, -0.14692877f, -0.70744812f, -0.67437625f, -0.86464107f, 0.07279789f, 
    0.70800281f, -0.63846481f, -0.03670261f, -0.24799640f, 0.26570025f, 0.03740083f, 0.80836868f, 0.01915856f, 
    -0.84242088f, -0.76245266f, -0.93199182f, 0.41902387f, -0.26942626f, 0.42487246f, 0.69900042f, 0.42412031f, 
    -0.35900801f, 0.37575737f, 0.45651591f, -0.53990257f, 0.20325032f, 0.41835660f, 0.43183240f, -0.74135345f, 
    0.79565364f, 0.28821462f, 0.78720301f, -0.65751678f, 0.58025801f, -0.39854568f, -0.43621600f, -0.21295507f, 
    -0.70927507f, -0.58117032f, -0.68504614f, -0.36728880f, 0.74660051f, 0.04955175f, -0.33283338f, 0.36151785f, 
    0.45017684f, 0.18467462f, -0.80568177f, 0.15560006f, -0.70564377f, -0.73465693f, -0.63910329f, 0.01846306f, 
    -0.49652931f, 0.10206535f, -0.61172730f, -0.12996070f, -0.94067359f, 0.02009809f, -0.61402327f, -0.67937499f, 
    0.36275679f, 0.11066946f, 0.09234826f, 0.29927561f, 0.10092089f, 0.41503248f, -0.84174693f, -0.73980790f, 
    0.40562192f, 0.29012334f, 0.37047970f, 0.50839549f, -0.25746307f, -1.25207615f, -0.42772740f, 0.56669474f, 
    0.51990068f, 0.36370915f, -0.41020620f, -0.03943599f, -0.45444655f, -0.38394248f, -0.87716317f, -0.12430582f, 
    -0.17006883f, 0.24277624f, 0.56694698f, 0.40119597f, -0.02364642f, 0.15869027f, 0.77881265f, 0.21834479f, 
    0.27090460f, -0.51369572f, 0.55199766f, 0.36609307f, 0.28959337f, 0.15468112f, -0.38326222f, -0.61596662f, 
    -0.97211653f, 0.58993793f, -0.24019101f, -0.66687661f, -0.54465544f, 0.13261518f, 0.63108498f, -0.43651426f, 
    1.19665074f, -0.08487547f, -0.74981081f, 0.06539018f, -0.00931211f, -0.63505816f, -0.05046897f, -0.44142827f, 
    0.58368295f, 0.07365294f, -0.72701919f, -0.85790193f, 0.88387311f, -0.08745483f, -0.29914841f, -0.61022508f, 
    0.01565722f, 0.10341489f, 0.15089612f, 1.12894213f, -0.73510325f, 0.25883600f, 0.36323971f, -0.55079347f, 
    -0.21687897f, 0.16191399f, -0.41031820f, -0.63493681f, -0.95747340f, 0.12988134f, 0.48669699f, 0.73815906f, 
    -0.31709534f, -0.29260972f, 0.36385331f, -0.36794847f, 0.71654361f, 0.05093397f, -0.50346023f, -0.76354545f, 
    -0.50336879f, -0.72590429f, 0.53462660f, 0.30782193f, -0.17826061f, 0.88543576f, 0.59248900f, -0.24926107f, 
    -0.08237176f, 0.39239272f, -0.15055174f, 0.19613932f, 0.49091014f, 0.33791792f, -0.50721437f, 1.00246060f, 
    0.17266214f, -0.43797657f, 0.21369663f, -0.81844330f, -0.08236571f, 0.32665229f, 0.02925657f, -0.34499949f, 
    -0.53603655f, -0.76347303f, -0.68682104f, 0.83468473f, 0.55836648f, 0.13662456f, -0.18197599f, -0.32112041f, 
    0.44859388f, 0.98938447f, 0.28664362f, -0.86956292f, 0.19125915f, 0.52012670f, -0.18193434f, -0.27237442f, 
    -0.22134313f, 0.87010801f, -0.54733169f, -0.85630542f, 0.14153063f, 0.19928369f, -0.04478196f, -0.71903789f, 
    -0.24025641f, -0.37312788f, 0.74029040f, -0.53330553f, -0.07068523f, 0.44777805f, -0.19646159f, -0.05824022f, 
    0.23020156f, 0.68588758f, -0.34411833f, -1.22357810f, 0.76886463f, -0.07103518f, 0.58176231f, 0.34808031f, 
    -0.76555794f, -0.02866869f, 0.00420159f, 0.32296005f, -1.11943865f, -0.73037839f, 0.47680503f, 0.29242784f, 
    -0.39711061f, 0.58851439f, 0.43527856f, 0.17139047f, 0.16093913f, -0.71643114f, -0.85777593f, 0.00193894f, 
    -0.17015894f, -0.34633252f, 0.51303196f, -0.37273255f, -0.52309728f, -0.39118969f, 1.07310939f, -1.12739980f, 
    0.32148871f, 0.81073505f, 0.01900481f, -0.02508604f, -0.25927952f, -0.22758012f, -0.34716943f, -0.24086230f, 
    -0.35680380f, -0.35021615f, -0.60677904f, 0.14707032f, -0.88423848f, -0.49059948f, -0.24258997f, -0.60282242f, 
    -0.09200257f, -1.13010144f, -0.16759101f, -0.85154963f, -0.38778278f, 0.49851838f, 0.21110509f, 0.19883044f, 
    0.21319199f, -0.63255852f, 1.16584551f, -0.59556538f, 0.07535236f, -0.32239416f, 0.30888927f, 0.17582422f, 
    -0.63699299f, 0.53553063f, -0.74666870f, -0.75489604f, -0.62723821f, 0.23883237f, 0.12790284f, -0.33203605f, 
    0.29877561f, 0.24682663f, 0.43390366f, -0.40080088f, -1.00101304f, -0.84202212f, -0.53175193f, 0.52241886f, 
    0.26319504f, 0.21133947f, 0.22944580f, -0.28774634f, 0.05097362f, -0.48279035f, 1.06906152f, -1.00838876f, 
    0.65081602f, -0.47920731f, 0.40888584f, 0.40866074f, 0.24992543f, -0.78115159f, -0.17373139f, -0.69540602f, 
    0.82833457f, 0.37285450f, -0.49968690f, -0.12186915f, -0.31827274f, 0.04274754f, 0.86543369f, 0.46286473f, 
    0.33184692f, 0.24565960f, 0.59947670f, 0.69061804f, -0.56061965f, -0.33860677f, -0.22805245f, -0.75105506f, 
    0.48279446f, 0.76228350f, 0.32545677f, 0.59663826f, 0.49137324f, 0.13493192f, 0.48817551f, 0.53388256f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05035409f, 0.23844400f, -0.11835990f, 0.03176687f, 0.16528429f, 0.41161743f, 0.05192068f, 0.07122333f, 
    0.07528349f, 0.15470067f, 0.11140491f, 0.07310446f, 0.05288285f, 0.38111869f, 0.11370353f, 0.05206785f, 
    -0.23227832f, 0.27315336f, -0.02173147f, 0.19333382f, 0.31797105f, 0.02980539f, 0.12363103f, 0.16914657f, 
    0.23856618f, 0.07510729f, 0.18966489f, 0.24318740f, 0.04029006f, 0.08717588f, 0.30174783f, -0.14162536f, 
    0.09497450f, 0.40265253f, 0.36571100f, 0.08026458f, 0.15738332f, 0.31034312f, 0.17629702f, 0.16104782f, 
    0.19170952f, 0.03627647f, 0.11747989f, 0.07101327f, 0.06807672f, 0.32862863f, -0.06963465f, 0.03054159f, 
    -0.03776094f, -0.10713288f, -0.09406337f, -0.15917379f, 0.09389409f, 0.21352126f, -0.10860021f, -0.30502605f, 
    0.08275320f, -0.04791948f, 0.12588352f, 0.24460450f, -0.00007619f, -0.03661021f, 0.05315326f, 0.27671760f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05272036f, 0.05328875f, 0.18195662f, 0.07951661f, 0.23804878f, -0.10393219f, -0.06728493f, 0.03557518f, 
    0.03489173f, -0.00018490f, 0.06930866f, -0.05077705f, -0.04274174f, -0.00813130f, -0.02168077f, 0.12452902f, 
    0.05486375f, -0.04172404f, 0.05483461f, 0.02062430f, -0.09529994f, 0.07281847f, 0.16578035f, 0.10380879f, 
    -0.09152162f, -0.01078331f, 0.03081760f, 0.08173963f, 0.03671188f, -0.07862455f, -0.02124649f, -0.04724161f, 
    -0.04764040f, -0.06751387f, -0.02139425f, 0.09460502f, -0.00676556f, -0.01796973f, 0.02015953f, 0.00993886f, 
    -0.07986242f, -0.07973649f, -0.06253676f, 0.13362753f, -0.23379487f, -0.03004997f, 0.02591538f, -0.08613738f, 
    0.02709498f, 0.00173906f, 0.06676784f, -0.06822167f, -0.01554274f, 0.03072079f, -0.01699897f, 0.04201944f, 
    -0.01038501f, 0.05536576f, 0.02751284f, -0.04853135f, 0.00375226f, 0.12016567f, 0.16579500f, 0.07549579f, 
    -0.10751630f, 0.00794648f, 0.00466897f, 0.04647549f, 0.00155968f, -0.01471447f, -0.03630547f, -0.00771428f, 
    0.01841022f, -0.03793797f, -0.06627566f, 0.07422543f, -0.04032771f, -0.10438823f, 0.04692074f, 0.00849581f, 
    0.14785168f, 0.23336330f, 0.08248622f, -0.05833931f, -0.11403476f, 0.03358614f, 0.04568393f, 0.04280056f, 
    -0.01252945f, -0.10048270f, 0.01897043f, -0.00111769f, -0.06483768f, -0.04191041f, -0.00148352f, 0.07027335f, 
    0.05383741f, -0.01242449f, -0.04706721f, 0.06274261f, -0.03756138f, 0.08465161f, 0.04845476f, -0.06867047f, 
    0.08273810f, -0.12712096f, -0.10553700f, 0.06627927f, 0.03775012f, -0.02051102f, 0.03915676f, 0.00736304f, 
    -0.03461948f, -0.00168451f, -0.04050664f, 0.00231852f, 0.02816142f, 0.02623621f, -0.06454383f, -0.04649182f, 
    0.13655372f, 0.03384048f, 0.00109537f, -0.02422957f, -0.01131681f, -0.05962724f, -0.11906099f, -0.11202050f, 
    0.05165956f, -0.01090609f, -0.04199360f, 0.05701663f, -0.03428306f, 0.03604683f, 0.02060236f, 0.13864139f, 
    0.05508789f, -0.04855365f, 0.03586055f, 0.11756469f, -0.21794866f, 0.10701932f, -0.01057146f, 0.04136715f, 
    -0.08840146f, -0.01652812f, -0.07000875f, 0.00469968f, -0.07416102f, 0.05406254f, -0.00265137f, -0.01740135f, 
    0.01723621f, -0.01409226f, 0.02975461f, 0.01103319f, -0.00738602f, -0.03163598f, -0.02573315f, 0.04844404f, 
    -0.05180898f, -0.04493267f, 0.04528608f, 0.00087647f, 0.02982173f, -0.00632308f, -0.07547148f, -0.05590092f, 
    -0.06612229f, 0.00447711f, -0.12640198f, -0.00261930f, 0.04724217f, 0.01008275f, 0.03206320f, 0.00653077f, 
    0.02416198f, 0.04182523f, -0.04135589f, 0.05206925f, 0.09624070f, -0.00574147f, 0.06006266f, 0.05358655f, 
    -0.07199637f, 0.03473231f, -0.08467550f, 0.06004960f, -0.00833735f, 0.03807845f, -0.00609952f, 0.03549103f, 
    -0.08288562f, 0.00185174f, -0.05133903f, -0.06210029f, 0.02666851f, 0.02169557f, 0.00563299f, -0.11210532f, 
    0.17909637f, -0.16118738f, 0.16563934f, -0.08705991f, 0.22105996f, -0.13584928f, 0.05190830f, -0.02987562f, 
    0.05709280f, -0.00135651f, -0.02211774f, -0.06965743f, -0.03749177f, -0.06240245f, -0.00750128f, 0.01305190f, 
    -0.00616483f, 0.07943936f, 0.00467706f, -0.02904405f, 0.13407457f, -0.07999834f, 0.03485390f, -0.02959017f, 
    -0.12545142f, -0.15645744f, -0.11314253f, 0.05142953f, 0.02953929f, -0.07200637f, 0.01803238f, 0.00226744f, 
    -0.07579975f, 0.03718244f, -0.04501865f, 0.04795922f, -0.10623478f, 0.13134451f, -0.02075844f, 0.02704744f, 
    0.09059234f, 0.07076692f, -0.00089443f, 0.05298179f, 0.03450977f, -0.11013684f, -0.08361997f, -0.13205723f, 
    0.04128288f, 0.02981926f, 0.00238382f, 0.02189749f, -0.03147196f, -0.08157749f, 0.02215631f, 0.03692679f, 
    0.01995178f, -0.00328076f, 0.00834142f, 0.02016695f, -0.04139852f, 0.09035765f, 0.01051032f, -0.22047395f, 
    0.21505778f, -0.11834596f, 0.01781188f, -0.00299115f, 0.07492133f, -0.00959358f, 0.02991795f, -0.03559869f, 
    -0.00292779f, 0.01746475f, -0.01842760f, 0.03503428f, -0.07545624f, 0.05449016f, -0.02899493f, 0.02357285f, 
    0.17053993f, -0.27465126f, 0.09066360f, 0.01478405f, -0.06277211f, -0.06428466f, 0.06283575f, -0.00434786f, 
    -0.04489648f, -0.01617230f, -0.03197972f, 0.05371645f, -0.07788619f, 0.04110021f, -0.05481370f, 0.07377786f, 
    0.00358303f, 0.04787965f, -0.09037886f, -0.01098110f, -0.21634097f, 0.12836201f, -0.00385457f, -0.04880653f, 
    -0.20245169f, -0.02053529f, 0.05147826f, 0.04174681f, 0.10494508f, -0.04519543f, 0.04184314f, -0.02196716f, 
    0.00486884f, 0.01429688f, -0.03791969f, 0.00524545f, -0.04602624f, -0.00222607f, 0.03371623f, 0.05138478f, 
    0.48999283f, 0.02975976f, 0.11175574f, -0.16827010f, 0.04387607f, -0.02898819f, -0.03176428f, 0.00974162f, 
    -0.00886484f, 0.00491373f, 0.06095446f, -0.03663066f, -0.02097512f, 0.08861647f, 0.02512335f, -0.04846916f, 
    -0.13654178f, 0.07513633f, -0.04675204f, 0.00946200f, -0.34966588f, -0.26155406f, 0.00587447f, 0.07026533f, 
    0.00978489f, -0.04189067f, -0.06748804f, -0.06716442f, 0.00535506f, -0.01379142f, -0.06114449f, 0.01275034f, 
    0.05231052f, -0.07131138f, 0.02891680f, -0.02786390f, 0.00512567f, -0.01289181f, -0.02464936f, -0.03670807f, 
    0.24815969f, 0.09945559f, 0.14542504f, -0.10656901f, -0.04556197f, 0.06219878f, 0.00878756f, 0.10622895f, 
    -0.02937726f, -0.12260277f, -0.10226242f, -0.06337727f, -0.08717236f, -0.00662534f, 0.06269720f, -0.01179131f, 
    0.06762908f, -0.03786564f, 0.07285333f, -0.01777737f, 0.00946350f, 0.05360020f, 0.03849644f, 0.08902267f, 
    -0.00627926f, -0.10080097f, -0.03960619f, -0.12147250f, -0.00344892f, 0.02766753f, -0.07797626f, -0.05614871f, 
    0.10809767f, 0.00841636f, -0.02047969f, 0.01702262f, 0.02082306f, -0.16149844f, 0.04135298f, 0.03012338f, 
    -0.13071251f, 0.04224002f, 0.02700536f, -0.06827298f, 0.23350869f, -0.01652499f, -0.09476154f, 0.02074253f, 
    -0.04142904f, -0.03413946f, -0.03899500f, -0.06963796f, 0.01295500f, -0.03870741f, -0.00565420f, -0.04776986f, 
    -0.03014070f, -0.03133782f, -0.01566032f, -0.08868757f, 0.12137233f, 0.11577445f, -0.06999236f, -0.21338135f, 
    0.08647130f, -0.08112133f, -0.11494397f, -0.15503357f, 0.04736504f, 0.03432931f, -0.02203150f, 0.05237740f, 
    0.00128728f, -0.00505432f, 0.06147536f, -0.04800384f, 0.06021953f, -0.02787153f, 0.02673024f, -0.05364867f, 
    0.04707601f, 0.15363501f, -0.01685732f, -0.06146859f, 0.22913893f, -0.05104426f, -0.11608495f, -0.05160277f, 
    0.00649166f, -0.02522733f, -0.00586377f, -0.05911606f, 0.00151170f, 0.03497354f, 0.00046001f, 0.03632097f, 
    -0.00457671f, -0.03888584f, -0.00128454f, 0.03024421f, 0.11234137f, 0.06272715f, 0.06396113f, -0.06710672f, 
    -0.20547894f, 0.03093813f, 0.13070120f, -0.07743887f, 0.07029678f, -0.08955903f, -0.02217353f, -0.02783332f, 
    -0.06592365f, -0.03031423f, 0.01039439f, 0.01480626f, 0.00591597f, 0.02820518f, 0.04589825f, 0.03639102f, 
    0.17255834f, -0.05722001f, 0.15102001f, -0.02764303f, 0.04514541f, -0.11317102f, 0.00311542f, 0.04955854f, 
    -0.01195964f, -0.04021169f, 0.00104488f, -0.08241661f, 0.07642114f, 0.03611358f, -0.00268186f, -0.00777655f, 
    -0.01905689f, -0.06170020f, 0.02627580f, -0.00995536f, -0.16125193f, -0.26210296f, -0.24226880f, 0.07279877f, 
    -0.06445272f, -0.07382764f, -0.04496733f, 0.01342344f, 0.02416975f, 0.02341152f, 0.05240020f, 0.04343076f, 
    -0.11745500f, -0.02081578f, -0.05003624f, 0.05290212f, 0.01081787f, -0.00683847f, 0.04255109f, -0.01608258f, 
    0.19862056f, -0.01199191f, -0.16154057f, 0.00735979f, -0.14161810f, -0.10091408f, -0.03770659f, -0.03336233f, 
    -0.02907582f, -0.00540181f, 0.00014291f, -0.05335863f, 0.01168489f, -0.04240493f, -0.03440089f, -0.09308593f, 
    -0.06137516f, 0.14692385f, 0.11041459f, 0.04409739f, 0.18298976f, -0.02638523f, 0.07395174f, 0.00290098f, 
    0.00154441f, 0.01714208f, 0.02869930f, 0.00758681f, -0.03594636f, 0.05578056f, -0.01701686f, 0.01798960f, 
    -0.09516108f, -0.09486657f, 0.05083058f, -0.07763115f, -0.02044711f, 0.04683080f, 0.05598108f, -0.16111222f, 
    0.15540709f, 0.05309132f, 0.01053642f, -0.13538170f, -0.24497412f, 0.01246235f, -0.02567562f, -0.02145869f, 
    0.02059834f, -0.08994836f, -0.04274429f, -0.00090627f, 0.00896671f, 0.02516810f, 0.01074102f, -0.00347394f, 
    -0.05289594f, 0.01262720f, -0.02158387f, -0.00521484f, -0.01181317f, 0.05038286f, 0.09776413f, -0.05636698f, 
    0.04415834f, -0.07725909f, -0.03351086f, -0.04137607f, 0.02132050f, 0.02256407f, 0.05776481f, -0.03178686f, 
    -0.00015038f, 0.00214759f, -0.02450404f, 0.02866575f, -0.03865626f, 0.07514469f, 0.01819109f, -0.11397041f, 
    -0.12763734f, -0.02177626f, -0.02770494f, -0.14891499f, 0.13019240f, -0.06870893f, -0.04523446f, -0.05489958f, 
    0.05542241f, 0.01271294f, 0.02824609f, 0.09111692f, 0.02184574f, -0.01439047f, -0.01547954f, 0.01912824f, 
    -0.03238278f, 0.03811396f, -0.01172221f, -0.01074661f, -0.01929914f, -0.00144376f, 0.24708883f, 0.09898858f, 
    -0.06159974f, -0.11574926f, -0.01203537f, 0.09013943f, -0.02462738f, 0.04432536f, -0.01879790f, 0.06274108f, 
    0.00219147f, 0.03165205f, 0.03688254f, 0.02153674f, -0.04525022f, -0.01715815f, -0.09061230f, -0.01933650f, 
    -0.02990720f, 0.09370227f, -0.09532615f, -0.11481413f, -0.17870106f, 0.07533070f, -0.01964949f, 0.02665033f, 
    -0.00719632f, 0.00083699f, 0.01689394f, 0.02527623f, -0.02404097f, -0.01083075f, 0.05795629f, -0.05919275f, 
    -0.05313371f, 0.07241561f, 0.01949734f, 0.04697524f, 0.11011011f, -0.23732212f, 0.17157555f, 0.08877381f, 
    -0.05738376f, -0.00673199f, -0.03275050f, -0.02865559f, 0.03654678f, 0.01507149f, -0.04836296f, -0.05232410f, 
    -0.11861745f, -0.00744006f, -0.02402514f, 0.01457336f, -0.03997934f, 0.02146041f, 0.04412194f, -0.08493895f, 
    0.01405149f, -0.40003508f, -0.03521634f, 0.04868788f, -0.03250870f, -0.03637425f, -0.05985094f, -0.02666110f, 
    -0.01789609f, 0.01578785f, 0.01488719f, -0.05096489f, -0.03626271f, -0.01943453f, 0.00800922f, 0.06813206f, 
    0.01184612f, 0.11116437f, -0.01056681f, -0.07858030f, 0.08136669f, -0.06447033f, -0.06723361f, -0.04638564f, 
    -0.00625278f, 0.05568842f, 0.00374823f, -0.16685174f, 0.00885512f, -0.08464839f, 0.00230217f, 0.01988668f, 
    0.06891330f, -0.03800955f, 0.04920878f, -0.02351353f, 0.00946043f, 0.00263748f, -0.01007562f, 0.03494084f, 
    0.03431525f, 0.12340134f, 0.00318385f, -0.12367624f, -0.31286678f, 0.08298709f, 0.07074143f, 0.04710609f, 
    -0.01049195f, -0.06100260f, 0.05546549f, -0.02574661f, 0.08570050f, -0.00167851f, -0.04960085f, 0.03486639f, 
    0.05723951f, -0.00114735f, -0.05111867f, 0.05786498f, -0.16400599f, -0.00456864f, -0.14446495f, 0.00460395f, 
    -0.24832018f, 0.00876141f, -0.00716657f, -0.03588613f, -0.03499546f, 0.00681876f, 0.02749773f, -0.04826258f, 
    -0.06854199f, 0.01907003f, -0.02890544f, -0.00535596f, -0.02631970f, -0.01825718f, 0.03370780f, -0.04214164f, 
    0.05421240f, 0.06513456f, -0.06603248f, -0.09245013f, 0.07326011f, -0.21148527f, -0.06841003f, -0.10656856f, 
    -0.01539884f, -0.00437147f, 0.00285673f, 0.00813501f, 0.02035943f, -0.02238285f, 0.04478677f, -0.12258574f, 
    -0.05298803f, -0.03877080f, -0.01636198f, -0.02550821f, -0.30840054f, -0.35581347f, -0.05521233f, 0.08264828f, 
    -0.24961686f, -0.10938323f, -0.09505924f, 0.05110037f, 0.03004786f, -0.00240590f, -0.02527805f, 0.10553194f, 
    0.02021173f, -0.07035623f, -0.07618987f, -0.01001777f, -0.01985758f, -0.04168588f, -0.05054841f, -0.02489008f, 
    -0.05964797f, -0.10667308f, 0.18432294f, 0.04502746f, 0.16075167f, -0.09573268f, 0.03785220f, 0.04608803f, 
    0.08756986f, 0.03106945f, -0.01814243f, -0.03246644f, 0.07414451f, -0.00258891f, -0.09640788f, 0.11893962f, 
    -0.09106521f, -0.04989528f, -0.03757322f, -0.09490144f, 0.13518441f, -0.15896124f, 0.02520978f, 0.04095181f, 
    -0.06175708f, 0.07462083f, -0.03245391f, 0.05752374f, -0.06921430f, -0.06256673f, 0.04363816f, -0.00957603f, 
    0.02831731f, 0.04571285f, 0.04267626f, 0.02641938f, 0.00359318f, 0.02328236f, -0.13818017f, 0.02697140f, 
    0.12753703f, 0.04571686f, 0.10385390f, -0.08123686f, 0.24903503f, -0.06002674f, 0.01835022f, 0.06046134f, 
    0.02460160f, -0.04646635f, 0.00808255f, 0.04518315f, -0.07772017f, -0.01827555f, 0.00849167f, -0.05435514f, 
    -0.00318780f, 0.05263481f, -0.00232521f, -0.06695644f, -0.31007126f, 0.08950824f, 0.11836444f, -0.07262766f, 
    -0.32200861f, 0.05421295f, 0.04280143f, 0.03130687f, 0.11793741f, 0.05707756f, -0.00872088f, 0.01514744f, 
    0.00000698f, -0.00433026f, -0.05156535f, -0.01236848f, 0.01881974f, 0.01714193f, -0.01694799f, -0.05056836f, 
    -0.09002207f, -0.07806201f, 0.19931339f, 0.16285749f, 0.12248819f, -0.07894470f, -0.02067002f, 0.01771348f, 
    -0.01201419f, -0.00242789f, 0.04959089f, -0.06507816f, -0.00671688f, 0.01901438f, 0.02178035f, 0.00952456f, 
    -0.00297498f, 0.01784042f, 0.14473228f, -0.02045528f, -0.08955915f, -0.02710726f, -0.00060016f, -0.11699674f, 
    0.13259077f, -0.05436188f, -0.02879757f, -0.08576974f, 0.07911815f, 0.04591294f, 0.03633270f, 0.05979796f, 
    0.00440355f, 0.01156020f, -0.00804603f, -0.01375058f, -0.04616147f, 0.00910965f, 0.00415580f, -0.00037782f, 
    -0.22599603f, -0.03229204f, 0.10974421f, -0.19183950f, 0.10163460f, 0.04708678f, 0.00992150f, 0.02304606f, 
    -0.09490716f, 0.07329278f, -0.03988859f, 0.09244147f, -0.14145552f, -0.03357194f, 0.03036402f, -0.10337123f, 
    0.00718241f, 0.08736993f, 0.06756664f, -0.06392432f, -0.32910985f, 0.27590424f, -0.03508279f, -0.16189411f, 
    -0.12663832f, -0.02535645f, 0.03450237f, -0.02953017f, -0.00674539f, 0.01186429f, 0.01368945f, -0.00956191f, 
    0.00625127f, 0.04085092f, 0.00019112f, -0.08631059f, 0.02110548f, 0.00456683f, -0.00319159f, -0.03644700f, 
    0.05742647f, 0.12252138f, -0.04068791f, -0.06278944f, 0.32375699f, -0.09003577f, -0.11273963f, -0.07419236f, 
    0.04266029f, -0.04042660f, 0.02606821f, 0.00677926f, 0.08942635f, -0.09120387f, 0.04880585f, 0.03804279f, 
    0.13417509f, -0.07062168f, 0.03360970f, 0.07784113f, 0.12813786f, -0.21369931f, 0.11910453f, 0.07533691f, 
    0.09842252f, 0.04660889f, -0.02065115f, -0.03106459f, -0.02382186f, -0.01824591f, -0.14406601f, 0.03465213f, 
    0.13974473f, -0.02226434f, -0.02076497f, 0.02560661f, 0.11510766f, 0.00839035f, -0.02399018f, 0.02323336f, 
    0.15790030f, -0.24825600f, 0.09777277f, -0.04863191f, -0.05141829f, -0.06875331f, 0.06616780f, 0.02223701f, 
    0.00208909f, 0.01153166f, -0.08128624f, 0.07411129f, 0.09353668f, -0.00999904f, 0.07317200f, 0.04022585f, 
    -0.05653746f, -0.08516771f, 0.01458926f, -0.01721291f, 0.43856147f, -0.06123385f, 0.16224113f, -0.07603811f, 
    0.02162758f, 0.02452072f, -0.13905855f, 0.05467063f, -0.13194741f, -0.01958099f, 0.01868249f, 0.03257576f, 
    0.01855708f, 0.11263397f, 0.02731362f, -0.04528137f, -0.07275946f, 0.10433339f, -0.07995804f, 0.01204993f, 
    -0.26378372f, -0.07388851f, 0.03641890f, 0.04688896f, -0.08851918f, 0.01128283f, 0.07452402f, -0.05645134f, 
    -0.03244971f, 0.05524701f, 0.01187079f, -0.02528818f, 0.01786226f, -0.04806161f, 0.01036522f, -0.01229989f, 
    0.00384283f, -0.03777576f, 0.05905614f, -0.00778310f, -0.06630754f, 0.02480960f, -0.03688967f, 0.04454766f, 
    -0.20357744f, -0.01171279f, 0.03808141f, -0.05826871f, 0.06187973f, 0.02239212f, 0.02003189f, -0.04442785f, 
    -0.02494400f, 0.02394356f, -0.03637592f, 0.00597770f, -0.08164278f, -0.00912021f, 0.03402491f, 0.03126102f, 
    0.18339138f, -0.13821477f, 0.18002334f, 0.07986737f, -0.12285829f, 0.10335421f, 0.00948857f, -0.00746560f, 
    0.04087360f, -0.01480085f, -0.16569507f, 0.07910638f, -0.04364811f, -0.02139176f, 0.07917348f, 0.02417086f, 
    0.02731485f, 0.03028580f, -0.02671353f, 0.06947264f, -0.06729896f, -0.38285476f, 0.08550797f, 0.04190003f, 
    -0.05645855f, 0.14202231f, -0.00900068f, 0.03188422f, -0.07666885f, 0.00588637f, 0.02462914f, 0.08734597f, 
    -0.08692823f, 0.01024316f, -0.02657481f, 0.03730240f, -0.12665083f, 0.03204529f, -0.06653643f, 0.03616713f, 
    -0.14336322f, -0.29536179f, -0.07865451f, 0.08476508f, -0.25409892f, -0.02651138f, -0.03815701f, -0.01575112f, 
    0.04923407f, 0.05328523f, 0.02060338f, -0.03499638f, -0.01298809f, -0.07250033f, 0.05489406f, 0.03813100f, 
    -0.03226150f, 0.00736974f, 0.00460488f, 0.02090450f, 0.29290459f, 0.04276026f, 0.05164979f, -0.14337917f, 
    0.05760019f, -0.12682545f, 0.01039662f, -0.03184959f, -0.00742466f, -0.07332086f, 0.06527565f, 0.01680376f, 
    0.05205633f, -0.01027078f, 0.10778333f, 0.02382439f, -0.14336015f, 0.08802211f, -0.16014943f, -0.03658421f, 
    -0.01326115f, -0.13346425f, -0.07628374f, -0.01747151f, -0.13008374f, -0.04394235f, -0.02011625f, -0.02812437f, 
    0.02592059f, 0.02609128f, -0.01178831f, 0.02206256f, 0.01773721f, -0.03646460f, 0.05068896f, 0.05824623f, 
    0.03819167f, -0.00390176f, -0.00364531f, -0.02270675f, -0.23375483f, 0.03266883f, -0.12006227f, -0.03066788f, 
    -0.22057116f, -0.01629029f, -0.01527063f, -0.00066574f, 0.04813416f, 0.00314811f, 0.01251641f, -0.01276608f, 
    -0.05365677f, 0.00014461f, -0.01848857f, -0.00125960f, -0.03496268f, -0.01482282f, -0.00841369f, 0.03450549f, 
    0.10155902f, -0.20295602f, -0.05100371f, 0.17131801f, -0.25597608f, -0.06577902f, -0.02378701f, 0.04541654f, 
    0.03057314f, -0.03460451f, 0.04875835f, 0.06501454f, -0.00289304f, 0.03360222f, -0.04527634f, -0.02403733f, 
    -0.00328491f, -0.01648538f, -0.01262205f, -0.01213734f, 0.40461999f, -0.07605585f, 0.04094438f, -0.04550533f, 
    -0.17269266f, 0.06340821f, 0.00654021f, -0.04834775f, -0.04501409f, -0.05244333f, 0.04775460f, -0.04168630f, 
    -0.03589777f, 0.06586450f, 0.00140449f, 0.04310455f, 0.06002342f, -0.02671732f, -0.02141903f, -0.01443461f, 
    0.09970657f, 0.06219387f, -0.07740659f, -0.05149204f, 0.14564057f, -0.09759633f, -0.07035636f, -0.08093190f, 
    0.05688829f, -0.03778318f, 0.02880651f, -0.01330421f, 0.04117525f, -0.07183528f, -0.01798494f, 0.03021833f, 
    0.12330505f, -0.04964431f, -0.02084989f, 0.06618146f, -0.16452378f, -0.00126285f, 0.08098720f, 0.01492611f, 
    0.03639098f, 0.08338960f, -0.08959030f, 0.04507453f, -0.00200764f, -0.06981281f, 0.04111052f, -0.01709899f, 
    0.00818220f, 0.04450573f, 0.02391462f, 0.00045231f, -0.01565891f, -0.04538789f, -0.02275434f, -0.00168894f, 
    -0.03945140f, 0.17734814f, -0.13877086f, -0.05121949f, 0.11397034f, 0.05011997f, 0.12154796f, 0.02001630f, 
    -0.01002204f, 0.01263940f, -0.02097563f, -0.02484055f, 0.14458574f, -0.02597287f, -0.03068985f, 0.03124608f, 
    -0.06826811f, 0.03265866f, -0.08608039f, -0.07189149f, -0.11748231f, 0.07530614f, -0.11661904f, -0.01119569f, 
    -0.07841703f, 0.01668870f, 0.02462342f, -0.03417227f, -0.11286500f, 0.06024478f, -0.01317942f, 0.13992596f, 
    0.00889869f, -0.01619451f, -0.05640515f, -0.03186598f, -0.09009919f, 0.04929201f, -0.00397959f, 0.01318185f, 
    -0.11147046f, -0.04602801f, -0.03825095f, -0.14983085f, -0.09924421f, -0.17150939f, -0.08293296f, -0.00648200f, 
    0.01199840f, 0.06224609f, -0.03244511f, 0.00189535f, 0.03593735f, 0.04565705f, -0.04506844f, -0.12362566f, 
    -0.03563249f, -0.11587806f, -0.00052655f, -0.10971584f, -0.08837907f, 0.02390766f, -0.08874810f, 0.01039623f, 
    -0.00475254f, 0.01343376f, -0.04547154f, -0.06151374f, -0.11441801f, 0.07711834f, 0.09687252f, 0.16888171f, 
    -0.05916949f, -0.00350903f, 0.04986262f, 0.00401982f, 0.00268458f, 0.10551371f, -0.01675119f, 0.04424394f, 
    0.16997541f, -0.06586716f, -0.00688746f, 0.06160915f, -0.02952401f, 0.00260237f, 0.09964591f, 0.00047331f, 
    0.03060837f, 0.12902796f, 0.09380876f, 0.00608097f, -0.02171453f, 0.01890322f, -0.02507344f, -0.01921619f, 
    0.04015698f, -0.01949281f, 0.01015089f, 0.02888971f, 0.06987443f, 0.02575807f, 0.14116313f, 0.00697112f, 
    0.21536826f, -0.07312129f, 0.03370802f, 0.04746183f, 0.02410714f, -0.01544063f, -0.10647528f, -0.04985757f, 
    0.03081244f, -0.04759093f, 0.00448538f, -0.03415833f, 0.00859925f, -0.03730319f, 0.02918945f, 0.04499955f, 
    0.13018741f, 0.08413556f, -0.03587651f, 0.04384758f, 0.03333630f, -0.05867137f, -0.03486378f, 0.05825209f, 
    0.01783846f, 0.01338976f, -0.01348181f, -0.08351596f, -0.04551922f, 0.03621981f, -0.03768582f, 0.06968696f, 
    -0.05921442f, -0.00170532f, -0.00058583f, -0.03969415f, 0.25551516f, -0.44437703f, 0.02774191f, -0.05150134f, 
    0.01834876f, -0.10565513f, 0.05435689f, -0.02618774f, 0.02753820f, -0.00858367f, 0.03333492f, 0.02094564f, 
    -0.02829484f, 0.01384330f, -0.03651758f, 0.05838625f, -0.03180667f, -0.02391353f, 0.00980240f, -0.00032160f, 
    -0.02032142f, -0.12883455f, -0.03305464f, -0.38877058f, 0.10363813f, 0.01642370f, -0.05758876f, 0.00489388f, 
    0.06957123f, -0.09322059f, 0.02118636f, -0.00600380f, -0.01565610f, -0.00485691f, -0.03195931f, -0.15194397f, 
    -0.00182343f, 0.07692766f, 0.03707680f, -0.14021075f, -0.25797859f, -0.06040740f, -0.23637526f, -0.11723576f, 
    0.13081715f, 0.09212730f, -0.05488914f, -0.05035415f, -0.04018099f, 0.01623214f, 0.04190478f, 0.10289520f, 
    -0.01401843f, -0.04488836f, 0.01207856f, 0.01176232f, -0.02813566f, -0.03352670f, -0.08480430f, 0.01625013f, 
    0.05943690f, -0.19504407f, 0.11670679f, -0.07493669f, 0.03570514f, -0.03499733f, -0.05910273f, 0.05867103f, 
    -0.05429719f, 0.00594912f, 0.02927832f, -0.02294933f, -0.00007479f, 0.04383988f, -0.03730366f, -0.05712957f, 
    -0.05200929f, -0.05896664f, 0.03079984f, -0.06381189f, -0.07172000f, 0.03532821f, 0.18410136f, -0.06760001f, 
    0.01010349f, -0.01508129f, -0.04025266f, 0.02211046f, 0.02528816f, -0.01010685f, -0.04274968f, -0.06751983f, 
    0.05845782f, -0.07694892f, 0.01495202f, -0.07190113f, 0.00696188f, -0.00997870f, 0.01415077f, 0.11092592f, 
    0.26933530f, -0.04965376f, -0.05563129f, 0.05057461f, 0.12550329f, 0.02621196f, -0.08539689f, 0.06666002f, 
    -0.00690387f, -0.03290081f, 0.02308328f, -0.02401441f, -0.05713820f, 0.06790067f, -0.06415825f, -0.07352208f, 
    0.00379622f, -0.02788757f, -0.00807065f, -0.00323747f, 0.25973916f, -0.00184073f, 0.13512935f, -0.00039381f, 
    0.03399989f, -0.04392147f, -0.11958348f, -0.04289242f, 0.02329312f, -0.02704176f, -0.04860372f, -0.00847006f, 
    0.00360005f, 0.05578893f, 0.04546257f, -0.06862912f, 0.02197866f, -0.03180779f, 0.00256967f, 0.00268316f, 
    -0.20920917f, -0.07350735f, 0.03402119f, -0.15233815f, 0.21049365f, -0.01701465f, -0.10629421f, 0.07293000f, 
    -0.05634201f, -0.03527360f, 0.08307900f, -0.04801943f, 0.00915867f, 0.00173586f, -0.06685837f, -0.04704779f, 
    0.03923793f, -0.02153846f, 0.06690852f, -0.00947161f, 0.05961244f, 0.02889766f, -0.06678908f, -0.02559839f, 
    -0.14568235f, 0.00455296f, -0.04844173f, -0.05906576f, -0.03569469f, 0.00394927f, -0.00732448f, 0.01677850f, 
    -0.02433052f, -0.02137110f, -0.00660135f, 0.01661601f, -0.04420001f, -0.00048340f, -0.06788411f, 0.01631701f, 
    -0.52705276f, -0.10652725f, -0.04847072f, -0.10412906f, 0.10206871f, -0.02519951f, 0.07603470f, -0.00238913f, 
    0.04393252f, 0.01826546f, 0.00078793f, -0.00132907f, 0.05504742f, -0.06105557f, -0.00242464f, -0.02062402f, 
    0.00018748f, -0.03912827f, 0.00429825f, -0.17904031f, -0.12506083f, -0.01069024f, -0.01615243f, 0.01487491f, 
    -0.10702433f, -0.00668393f, -0.01314873f, 0.04376207f, -0.00681055f, -0.04418771f, 0.00859563f, -0.03227576f, 
    -0.04527770f, -0.01278535f, -0.00151487f, -0.02046421f, 0.03146818f, -0.04515267f, 0.01915944f, -0.02464527f, 
    -0.18380316f, -0.02668568f, -0.05700124f, -0.02793712f, 0.04516511f, -0.12266677f, 0.03617413f, -0.14853655f, 
    -0.06231577f, 0.02961076f, 0.15643384f, 0.01169062f, -0.10711603f, -0.04170999f, 0.06428947f, -0.01708450f, 
    0.02883750f, 0.01998084f, -0.02455512f, 0.07169599f, -0.08889066f, 0.11297169f, 0.01827094f, 0.04921188f, 
    0.03656154f, -0.00145854f, -0.01125861f, 0.02244642f, 0.01146546f, 0.07467013f, -0.00087484f, 0.05307942f, 
    -0.04056590f, 0.01937722f, -0.06879998f, 0.04655849f, 0.01999275f, 0.01234413f, 0.05025690f, 0.00891046f, 
    -0.04262042f, 0.15900286f, -0.09905829f, -0.05156345f, 0.06022809f, -0.00457629f, 0.03281015f, 0.01776849f, 
    0.03626329f, 0.03336727f, 0.09039194f, 0.01483415f, 0.05959949f, 0.06408835f, -0.02794695f, -0.01926211f, 
    0.02038659f, 0.04976755f, -0.07577121f, 0.04664685f, 0.18940210f, 0.13614719f, 0.08986060f, 0.17171633f, 
    0.18929000f, -0.00589747f, -0.06988767f, 0.07322395f, 0.01166559f, 0.01918082f, 0.03953461f, -0.06623542f, 
    -0.02346767f, 0.03896000f, -0.04827645f, 0.01289192f, 0.09119864f, 0.03046381f, -0.01871844f, 0.04517866f, 
    0.03097243f, 0.15124004f, -0.00558068f, 0.12957616f, 0.08015202f, 0.04162065f, -0.03917391f, 0.02788991f, 
    0.01907418f, 0.00628958f, -0.04231458f, 0.03745800f, -0.05267106f, 0.07484993f, -0.06014506f, 0.03667175f, 
    0.02058387f, 0.02111911f, -0.04489952f, -0.03620867f, -0.04289378f, 0.16542058f, -0.03704745f, 0.07115012f, 
    -0.11304121f, 0.02911161f, 0.01948662f, 0.02593124f, -0.17706370f, 0.04148097f, 0.02935370f, 0.08096862f, 
    -0.04707298f, 0.04402464f, 0.09214979f, 0.06180963f, 0.03262972f, 0.00750568f, 0.01027403f, 0.06036107f, 
    -0.18200189f, 0.12742031f, 0.04715125f, 0.01800619f, 0.09457275f, -0.08042403f, 0.08672122f, 0.00920624f, 
    -0.02464281f, 0.01237109f, -0.03664791f, 0.04279923f, 0.03794165f, -0.08332932f, -0.04949525f, 0.12170289f, 
    -0.06291845f, 0.00488231f, 0.04736798f, 0.04635682f, -0.17516539f, -0.04421342f, 0.03920707f, -0.02959499f, 
    -0.30720270f, 0.08003961f, 0.00014975f, -0.02190956f, 0.02571828f, 0.05467162f, -0.02313873f, -0.00799945f, 
    0.03377500f, 0.02450193f, -0.02707602f, -0.02050695f, -0.01540147f, -0.11189257f, -0.19301033f, -0.15567285f, 
    -0.34628007f, 0.07343614f, 0.02806243f, -0.01351153f, -0.18876877f, -0.00109657f, 0.00748621f, 0.00029547f, 
    -0.00498063f, -0.01028013f, 0.05351015f, 0.05134882f, 0.05028922f, 0.02893789f, 0.03210697f, 0.04335841f, 
    -0.00848846f, -0.14165238f, -0.11136056f, 0.03935293f, -0.24710837f, 0.08327308f, -0.26049697f, -0.18476768f, 
    0.05876397f, -0.02613406f, 0.03068190f, -0.02096449f, -0.01815239f, 0.07866383f, 0.04172443f, -0.05750716f, 
    0.04271522f, 0.03763365f, 0.02100710f, -0.01154624f, 0.02990721f, 0.07397366f, -0.09083892f, 0.05172531f, 
    0.13810214f, 0.00590038f, -0.15577033f, 0.08006859f, -0.04526342f, 0.04901303f, 0.02282107f, 0.07381243f, 
    0.08565412f, 0.10677704f, -0.05011087f, 0.06001285f, -0.07844356f, -0.00644407f, 0.03470393f, 0.03427359f, 
    0.03626009f, -0.06176321f, -0.02457356f, -0.10889480f, -0.06439182f, -0.10340846f, -0.13044423f, -0.15208158f, 
    0.00097196f, 0.07246622f, -0.05584578f, 0.14016874f, -0.03273703f, 0.01704107f, -0.11428803f, -0.01623782f, 
    0.05530894f, 0.05470831f, 0.08127686f, -0.09729464f, 0.04841565f, -0.11840795f, -0.09614749f, 0.08174200f, 
    0.19919609f, 0.00289821f, 0.10934924f, -0.04662193f, 0.02036532f, 0.00570665f, -0.05965024f, -0.02250056f, 
    -0.01554428f, -0.00315882f, -0.01912870f, 0.01463197f, -0.02290304f, 0.00288941f, 0.08261582f, -0.02406100f, 
    -0.00563583f, 0.00673172f, 0.05789440f, -0.01680049f, 0.08653749f, 0.07354019f, -0.11845514f, -0.04257642f, 
    0.21047148f, 0.03581885f, -0.04923307f, 0.01563133f, -0.14313532f, -0.09038924f, 0.04705411f, 0.06012772f, 
    0.04046088f, 0.02895822f, 0.05604518f, 0.04488987f, -0.07587294f, 0.09688125f, 0.08468658f, 0.02122196f, 
    0.04446777f, -0.08139567f, -0.05525017f, -0.03657805f, -0.01359004f, 0.02620884f, 0.01776299f, -0.03346579f, 
    0.04912720f, 0.13476694f, -0.01791913f, -0.03065791f, 0.04244135f, -0.01285416f, 0.05207218f, 0.09468436f, 
    0.06134115f, -0.01036695f, -0.12350332f, 0.02862591f, -0.08063815f, -0.02737075f, -0.02527001f, -0.11377469f, 
    -0.12748958f, 0.09556747f, 0.04235028f, 0.07334885f, 0.02278589f, -0.01826182f, 0.00573745f, 0.03552151f, 
    0.08674773f, 0.01097708f, 0.05290116f, -0.08881002f, 0.01225149f, -0.10071176f, -0.00976315f, -0.08586168f, 
    0.00130123f, 0.13062534f, -0.15037388f, -0.02549990f, 0.00287280f, 0.12818636f, 0.01936846f, 0.06782901f, 
    0.01831637f, 0.08333035f, 0.01027160f, -0.07447821f, 0.03113581f, 0.01729396f, 0.00178544f, -0.00577276f, 
    0.02554811f, -0.17924131f, -0.07006892f, -0.06152711f, -0.31132782f, -0.02567130f, 0.01208530f, 0.01160903f, 
    -0.04885493f, 0.04891391f, -0.06272345f, 0.00551043f, 0.06209852f, -0.00163071f, -0.08582533f, 0.00537147f, 
    -0.04292849f, 0.01283807f, -0.00580407f, 0.05468647f, -0.05723151f, 0.00977676f, 0.07802821f, -0.07066038f, 
    0.20510022f, -0.13328552f, -0.11081704f, 0.00959761f, -0.21046096f, -0.04397558f, 0.04410097f, -0.03484228f, 
    -0.00912559f, 0.02755564f, 0.07924242f, 0.07094653f, -0.01105905f, 0.00257434f, -0.03156659f, 0.04718613f, 
    0.05264077f, -0.03052974f, -0.02191640f, -0.00382852f, 0.10440663f, 0.07097209f, -0.07504652f, 0.04869361f, 
    -0.05762946f, -0.05911242f, 0.04435200f, 0.05916457f, 0.01277515f, 0.01776573f, 0.02185109f, -0.07141870f, 
    -0.02083961f, -0.01260748f, -0.01150436f, 0.07854397f, 0.06722863f, 0.00236238f, -0.01741575f, 0.03464631f, 
    0.21270345f, 0.09328491f, 0.05740933f, 0.11407060f, 0.16128884f, -0.02069970f, -0.07133864f, 0.02310762f, 
    0.04758902f, -0.00574853f, 0.00803259f, 0.00747984f, -0.09994659f, 0.11304110f, -0.10090086f, 0.03229159f, 
    -0.02078616f, 0.03101549f, 0.01111625f, 0.01643208f, -0.13132915f, 0.11149734f, -0.09515536f, 0.00819838f, 
    -0.26618493f, -0.06632476f, 0.00876136f, 0.04045667f, 0.04957656f, -0.01444781f, -0.09335878f, -0.10977147f, 
    0.02157806f, 0.04614712f, 0.04286410f, -0.11883987f, 0.11329734f, -0.05571018f, -0.12514263f, 0.07525948f, 
    0.19766483f, -0.30392706f, 0.01266880f, -0.16413754f, -0.02946403f, 0.04954885f, -0.07429364f, -0.01428542f, 
    -0.01439818f, -0.03250513f, 0.00350189f, 0.04562701f, -0.04431512f, -0.03680478f, 0.05883211f, -0.14005329f, 
    0.00112782f, -0.13167129f, -0.00052570f, -0.08882532f, 0.11771151f, -0.13263488f, -0.01046718f, -0.13996632f, 
    -0.10847979f, -0.03776981f, -0.00971721f, -0.02614719f, -0.03538936f, 0.02922032f, -0.01738461f, -0.03474028f, 
    0.01329610f, -0.05201618f, -0.04570414f, 0.02884020f, -0.00293457f, -0.09916163f, 0.00242526f, -0.02740809f, 
    -0.12762438f, -0.12961313f, 0.00382540f, -0.15846440f, 0.11687105f, -0.01087058f, -0.05618192f, -0.05348757f, 
    -0.02809043f, 0.01940831f, 0.08731169f, 0.05324463f, 0.07445981f, 0.02864567f, 0.12953648f, -0.05139471f, 
    0.00932628f, -0.03514638f, 0.06387752f, 0.00551810f, 0.25722766f, -0.05741979f, -0.21254532f, 0.00650758f, 
    -0.16373941f, -0.00938936f, 0.02711032f, -0.00164990f, -0.06687652f, 0.05764633f, 0.00131990f, -0.02625006f, 
    -0.01904087f, 0.05215717f, -0.02155133f, -0.01657581f, 0.06441532f, 0.01982240f, -0.04704575f, 0.13235973f, 
    0.20095026f, -0.20785493f, -0.13239650f, -0.03785745f, -0.15068845f, -0.01855833f, -0.04498449f, -0.00312445f, 
    0.05276565f, -0.04418617f, -0.01480127f, 0.09555960f, 0.03508092f, 0.04894948f, -0.00101292f, 0.01469642f, 
    -0.11562946f, -0.13339944f, -0.07845358f, -0.03063538f, 0.24986079f, 0.04726826f, 0.15713437f, 0.00651259f, 
    -0.03157973f, -0.04121814f, -0.07386719f, 0.00607009f, 0.01769066f, -0.00095692f, 0.03126583f, 0.01783414f, 
    0.00247474f, 0.02302234f, 0.05731263f, 0.03903726f, -0.00959129f, -0.00808695f, -0.04539569f, -0.00160299f, 
    -0.10411468f, 0.04935229f, -0.24668959f, -0.20874685f, 0.02474738f, -0.12452664f, 0.03143181f, 0.02357020f, 
    -0.13013045f, 0.14947705f, 0.06199379f, -0.02415084f, 0.16456096f, -0.00173791f, 0.05534367f, -0.08551551f, 
    0.03193640f, -0.03676599f, -0.20808290f, 0.10381582f, 0.29223365f, -0.18872537f, -0.10136254f, 0.03440079f, 
    -0.04524065f, -0.10934471f, 0.03886482f, -0.02479070f, 0.02754719f, 0.02483928f, 0.02070628f, 0.00558868f, 
    0.01102337f, -0.02283208f, 0.08670658f, 0.04037100f, -0.05058071f, 0.02296166f, -0.07341850f, 0.07820000f, 
    0.06828187f, 0.23835833f, -0.05972418f, 0.11181259f, 0.02028017f, 0.00771422f, 0.01673731f, 0.02815380f, 
    0.02322344f, 0.00875990f, -0.05603011f, -0.02176378f, -0.09486155f, 0.19019729f, -0.07192767f, 0.03852041f, 
    -0.06939830f, 0.07361692f, -0.02085465f, -0.07259964f, 0.18136545f, -0.34623328f, 0.13344477f, -0.31750974f, 
    -0.04375777f, -0.03044490f, 0.06008310f, -0.06889483f, -0.03832875f, -0.00589150f, -0.05139374f, 0.02822003f, 
    -0.06403724f, 0.04966605f, -0.16894528f, -0.06291158f, -0.00668691f, -0.10899227f, 0.08651321f, 0.01243029f, 
    0.23757942f, -0.14943323f, 0.09814438f, -0.02621336f, -0.04664437f, 0.02830487f, -0.01198000f, -0.13311194f, 
    0.03249708f, -0.04733513f, -0.06289399f, -0.06188884f, -0.06135835f, -0.01715207f, -0.10457414f, -0.00362195f, 
    0.11874040f, 0.01079636f, 0.05297054f, 0.06238401f, -0.59583336f, -0.20852950f, 0.04320802f, -0.00449940f, 
    0.18381420f, -0.03371402f, -0.01092068f, 0.01417519f, -0.04429626f, -0.02499629f, 0.02437077f, 0.05044735f, 
    0.01476760f, -0.04937644f, -0.01131385f, 0.10360643f, -0.09548931f, -0.09525862f, 0.04262778f, -0.11788111f, 
    -0.01248975f, 0.19043215f, -0.06762755f, 0.06956599f, -0.29498646f, 0.00082203f, -0.09752143f, -0.00932890f, 
    0.10838771f, 0.02347322f, 0.00232800f, -0.03815220f, -0.09299613f, 0.02908311f, -0.06073574f, 0.06582759f, 
    0.13314407f, 0.03053939f, 0.02222924f, 0.08091059f, -0.03595413f, 0.08730137f, -0.05878118f, 0.02315752f, 
    -0.19784474f, 0.01621373f, -0.04924302f, -0.01246968f, 0.00009026f, -0.01418753f, 0.03839941f, 0.08739749f, 
    -0.02933539f, 0.04856314f, -0.00169603f, 0.00105891f, 0.01080867f, -0.06239478f, 0.00767214f, -0.05155807f, 
    0.29817677f, -0.31396940f, 0.03411578f, -0.09549364f, -0.17840634f, 0.01299864f, 0.13115013f, -0.05649113f, 
    -0.06725428f, 0.01040912f, 0.16170239f, 0.01634660f, 0.04893370f, -0.05171623f, -0.04686722f, -0.02522092f, 
    -0.01643712f, -0.10258264f, 0.09404591f, 0.04709627f, 0.09498539f, -0.06440753f, -0.39099103f, -0.13562457f, 
    -0.11181739f, 0.02140465f, -0.13199940f, 0.08730254f, 0.07695535f, 0.10229145f, -0.05453366f, -0.13916288f, 
    0.06906370f, -0.02539390f, 0.02743164f, -0.16749090f, 0.00132837f, 0.01999952f, -0.03441310f, 0.13821837f, 
    -0.08766713f, -0.03270803f, 0.07249018f, 0.01139499f, -0.01362870f, -0.01778662f, 0.00640874f, 0.05367217f, 
    0.07859637f, -0.03920131f, -0.04758557f, -0.04645251f, 0.06864595f, 0.04696422f, -0.06812289f, 0.00373745f, 
    -0.08837187f, -0.00705629f, -0.03845027f, -0.08608156f, -0.03668351f, 0.04042951f, -0.03733185f, -0.05954230f, 
    0.26708889f, 0.10093337f, -0.00520535f, 0.03355129f, -0.01759247f, -0.01799919f, 0.01533313f, -0.03449523f, 
    -0.04388015f, -0.00664417f, 0.07440291f, -0.02110779f, 0.11923782f, -0.01660156f, 0.12942915f, 0.02643177f, 
    0.06112700f, 0.10837864f, -0.10319457f, 0.02132131f, -0.05916399f, 0.09347304f, -0.01565291f, 0.02466255f, 
    -0.01230437f, 0.06932713f, -0.05214113f, -0.07391713f, 0.02460793f, 0.02330893f, -0.02284828f, 0.12813185f, 
    0.07875422f, -0.06011329f, 0.10803184f, -0.08881900f, 0.21991910f, -0.15199646f, -0.13111423f, 0.07017402f, 
    -0.08966488f, -0.04525221f, 0.01614483f, 0.08195235f, 0.00178668f, 0.07452039f, 0.00240975f, -0.03780089f, 
    0.03518847f, 0.05292848f, 0.01694992f, 0.09653097f, 0.02175111f, 0.02849396f, -0.09406541f, 0.02311219f, 
    -0.33930653f, -0.03744677f, -0.05209366f, 0.00043740f, 0.08759128f, -0.04251370f, -0.01117530f, -0.06926453f, 
    -0.04476657f, 0.02668119f, 0.08691823f, -0.01439858f, -0.01140072f, -0.06828204f, -0.02457595f, -0.07869840f, 
    0.01237692f, -0.02413864f, -0.02765350f, 0.00906377f, -0.37232232f, 0.02581896f, -0.13696137f, -0.02939350f, 
    -0.09594817f, 0.09039368f, -0.07615335f, 0.01454357f, 0.03135303f, -0.00260736f, 0.02965361f, 0.03443557f, 
    0.01752343f, -0.04559566f, 0.04710280f, -0.01562402f, -0.01710653f, -0.14323419f, 0.00460484f, -0.11251477f, 
    0.28273520f, 0.18216583f, 0.12606068f, 0.12235755f, 0.07821208f, -0.03915779f, -0.06124292f, -0.01866664f, 
    0.03912883f, 0.02636014f, -0.00717149f, 0.05801950f, 0.02118892f, 0.00859602f, -0.06067663f, -0.01397003f, 
    0.03994370f, 0.10041806f, 0.04151105f, 0.03106153f, -0.20776947f, 0.16445865f, -0.02368201f, -0.03524893f, 
    0.03319125f, -0.15144743f, -0.00535235f, -0.01638427f, -0.00483740f, 0.07305625f, -0.02928221f, 0.01791330f, 
    0.00005104f, -0.10218463f, -0.00883970f, 0.02348044f, -0.02022844f, 0.07632028f, 0.02827992f, 0.06925602f, 
    0.16538845f, -0.01535735f, -0.20113906f, -0.05946317f, -0.03564562f, 0.02308016f, 0.00683469f, 0.04402802f, 
    -0.00488247f, 0.05770736f, -0.04515915f, 0.05035179f, -0.00890320f, -0.02346933f, -0.00661880f, -0.01774227f, 
    0.03248846f, -0.02793534f, -0.04947536f, 0.00025089f, 0.20352818f, -0.01679427f, -0.07823123f, -0.02448067f, 
    0.04541050f, -0.10149357f, -0.02673207f, 0.03658606f, 0.01898043f, -0.02109858f, 0.04061886f, 0.02642450f, 
    0.02170650f, -0.08227254f, 0.06511067f, -0.06024740f, 0.00114390f, -0.03379878f, 0.02376356f, -0.01957172f, 
    0.28787458f, -0.15206961f, -0.14788456f, 0.18018307f, -0.30555448f, -0.08942544f, 0.04884392f, -0.01118538f, 
    0.03947975f, 0.02339913f, 0.02142315f, 0.02990109f, 0.05061615f, 0.00592499f, -0.05864855f, 0.00361434f, 
    -0.07256488f, 0.03115319f, -0.01097201f, 0.00046891f, 0.17602679f, 0.00892278f, 0.04767815f, 0.04135774f, 
    0.10781997f, -0.06006670f, -0.04300146f, -0.07197630f, 0.07604185f, 0.06367026f, -0.04662646f, -0.00868220f, 
    0.00955008f, -0.00881285f, 0.05213238f, -0.06596640f, -0.01014404f, -0.14401107f, -0.01215993f, 0.00317564f, 
    -0.05752065f, 0.07066401f, 0.15119793f, -0.01656958f, 0.12518148f, -0.01705840f, -0.01562442f, 0.00691481f, 
    -0.00418543f, 0.02144651f, -0.02243488f, -0.03575115f, 0.00799187f, -0.09377185f, 0.04667100f, -0.05433579f, 
    -0.03931518f, -0.06117460f, -0.00142496f, 0.04396107f, 0.05686538f, -0.11363627f, 0.00069825f, -0.00211455f, 
    0.04178349f, 0.02468203f, 0.04461285f, 0.05298009f, -0.00847034f, 0.00360842f, -0.00436266f, 0.00817596f, 
    -0.00560153f, -0.05682003f, -0.02254524f, 0.03281666f, -0.04054708f, -0.03310309f, -0.11825963f, -0.02760915f, 
    -0.29188132f, 0.10663947f, -0.09791597f, -0.07980289f, 0.06902336f, 0.03245687f, 0.05339617f, 0.01280860f, 
    0.03195775f, -0.05546647f, -0.02477386f, -0.00350872f, 0.03079460f, -0.05631636f, -0.01511014f, -0.09317259f, 
    0.00109172f, 0.02817735f, -0.04590544f, 0.01218393f, 0.21549502f, 0.02438785f, 0.06637727f, 0.01941077f, 
    -0.07297230f, -0.04688682f, -0.06675132f, 0.05705598f, 0.03144793f, 0.05520327f, -0.00013008f, -0.06188858f, 
    0.00934943f, 0.02550435f, 0.02183092f, -0.02732001f, 0.00031920f, 0.00503929f, 0.00724728f, -0.01327676f, 
    -0.33008236f, 0.00220318f, -0.09159472f, -0.02691151f, -0.29144460f, 0.07866050f, 0.01693601f, -0.01618898f, 
    -0.00666518f, 0.06889316f, -0.00162650f, -0.00000732f, -0.09065352f, -0.02144355f, 0.02964394f, 0.03994336f, 
    -0.02686634f, 0.06977121f, 0.04799902f, -0.00170531f, 0.09911713f, -0.11763628f, -0.03780600f, -0.07173382f, 
    -0.01828110f, -0.03392351f, -0.01822635f, 0.02732395f, -0.04604828f, 0.02067298f, -0.03779515f, 0.03384000f, 
    0.01310362f, -0.00675669f, -0.02797311f, -0.00548054f, 0.02257325f, 0.02005480f, 0.05713128f, -0.00454068f, 
    0.11382111f, -0.21152049f, -0.00201827f, -0.08279908f, -0.07485961f, 0.00779541f, -0.05924682f, 0.07516357f, 
    0.03910178f, 0.05399171f, -0.01630346f, 0.04335645f, 0.04822382f, -0.10425600f, 0.00713835f, 0.03975264f, 
    -0.00579729f, 0.02199288f, -0.02737229f, -0.05208930f, -0.02337236f, -0.03053774f, 0.03155175f, -0.00716567f, 
    0.11057325f, 0.06168709f, 0.07836453f, 0.02147874f, 0.02536273f, -0.07745864f, 0.00264019f, -0.02178966f, 
    -0.06954508f, 0.04385478f, -0.02729481f, 0.13431489f, -0.02292238f, 0.00095148f, -0.07806938f, 0.01365968f, 
    -0.06299483f, 0.07085222f, -0.01383797f, -0.15474498f, 0.01683369f, 0.06201532f, -0.01460693f, 0.01298480f, 
    0.03956944f, -0.02837642f, -0.12143363f, 0.02076334f, -0.02155470f, -0.01893194f, -0.00910113f, 0.03573300f, 
    0.06952312f, -0.00157384f, -0.02299371f, -0.05249307f, 0.18596523f, -0.01126219f, 0.03647244f, -0.12996267f, 
    0.00319954f, 0.03939577f, -0.09852507f, 0.11187141f, -0.03578978f, -0.00355545f, -0.01611969f, 0.03457548f, 
    0.01849893f, -0.02515651f, -0.00162643f, -0.02970931f, -0.03076048f, 0.07042918f, 0.00752781f, -0.03980579f, 
    -0.09377382f, 0.05161947f, -0.02470310f, 0.02131906f, -0.06607317f, 0.04695224f, -0.05710455f, -0.01429506f, 
    -0.03278163f, 0.03217519f, -0.06945515f, -0.08072909f, -0.04479272f, -0.04034499f, 0.02550041f, 0.06724096f, 
    0.04600893f, 0.02465420f, -0.06698626f, 0.00484484f, 0.17550384f, 0.06426439f, -0.00271301f, 0.09635806f, 
    0.13049634f, -0.09670580f, -0.04191191f, -0.00554597f, 0.08205392f, 0.03336358f, 0.01500736f, 0.01372425f, 
    -0.00525589f, -0.00795300f, -0.04353743f, -0.00653872f, -0.02341088f, -0.04031714f, -0.00713778f, -0.02279322f, 
    0.12345939f, -0.05641934f, -0.20426852f, -0.19041005f, -0.13683435f, 0.09991064f, 0.01092547f, 0.00098840f, 
    -0.04104909f, 0.04249763f, 0.03907790f, 0.06835715f, 0.07579732f, -0.01162123f, 0.07212730f, -0.00932832f, 
    -0.01989639f, -0.03929174f, -0.02297233f, -0.03750668f, 0.18241639f, -0.10961790f, 0.00969923f, -0.02935203f, 
    -0.13436083f, -0.09076940f, -0.01720954f, -0.06187152f, -0.00010814f, 0.01732607f, 0.01025211f, -0.02489847f, 
    0.01619916f, -0.06777927f, 0.03618549f, 0.02039544f, 0.00365065f, 0.03841001f, 0.05453193f, -0.01533657f, 
    0.17519356f, 0.16642426f, 0.11965500f, 0.05961486f, 0.09042091f, -0.01072303f, -0.10275248f, -0.00773186f, 
    0.03095239f, 0.08980517f, 0.04215744f, -0.10069288f, 0.03850933f, 0.01933544f, -0.10497643f, 0.02151434f, 
    -0.03998867f, -0.03354875f, -0.04786770f, -0.07110564f, -0.21577898f, 0.03046853f, -0.03008966f, -0.02912565f, 
    0.00883459f, -0.04956021f, 0.02021572f, -0.01394407f, 0.06246075f, -0.06137971f, -0.01312852f, -0.00048153f, 
    0.02083753f, 0.02328077f, 0.00574513f, -0.02860616f, -0.02708242f, -0.03085824f, -0.03570033f, -0.06459036f, 
    0.09027493f, 0.02939058f, -0.13126200f, -0.02807217f, -0.07258554f, 0.01372467f, 0.09522517f, 0.01069986f, 
    -0.04241775f, -0.04605530f, -0.06422830f, -0.02769762f, 0.04648579f, 0.00831749f, 0.02061327f, 0.00842533f, 
    -0.02721018f, -0.04356553f, -0.04217569f, -0.00360078f, 0.03920603f, 0.17709790f, -0.03115473f, -0.18777558f, 
    0.09109502f, 0.01517703f, 0.09370668f, 0.04959036f, -0.04940723f, -0.04810715f, -0.02398999f, -0.00300314f, 
    0.01165668f, -0.07181346f, 0.05073996f, 0.00246650f, 0.03187811f, -0.06999230f, -0.04089529f, -0.01272393f, 
    -0.02906404f, 0.06278677f, -0.06295944f, -0.09078652f, 0.03650248f, 0.00289102f, 0.06874202f, 0.06729116f, 
    -0.03359772f, -0.05037285f, 0.00512858f, 0.01706578f, 0.07618982f, 0.00095416f, -0.01683350f, -0.01314024f, 
    -0.02579247f, -0.02009130f, -0.05213410f, -0.04042123f, 0.09509870f, 0.04709904f, 0.08358837f, 0.08683335f, 
    0.19377385f, -0.06821326f, -0.12762822f, -0.13294920f, 0.01469670f, 0.05530571f, 0.06739227f, -0.03026776f, 
    0.04499010f, -0.02508972f, 0.00929518f, -0.08762243f, -0.03666415f, -0.08480830f, -0.00796297f, -0.02325418f, 
    0.19945683f, 0.01542281f, 0.01319274f, -0.04415055f, 0.02224879f, 0.00656117f, -0.03407246f, 0.04612823f, 
    0.00445971f, -0.04668705f, -0.00552443f, 0.03831839f, -0.03709073f, 0.00690220f, 0.03094310f, 0.01237698f, 
    -0.07665464f, -0.02877594f, -0.07650591f, -0.06780838f, 0.29675943f, -0.12134942f, -0.22588380f, -0.01188472f, 
    -0.30622858f, 0.00789191f, -0.00487657f, -0.03489121f, 0.04848331f, -0.03638901f, -0.05788504f, -0.05278041f, 
    -0.00831543f, 0.02741721f, -0.06055548f, 0.02782370f, 0.02553356f, -0.01952820f, 0.10590885f, -0.03481983f, 
    -0.11817780f, 0.07094532f, -0.11930575f, 0.01766135f, 0.05334524f, -0.01038440f, 0.11178014f, 0.00579636f, 
    -0.00855450f, -0.11626343f, 0.00815303f, -0.00474563f, -0.02267546f, -0.00686376f, 0.01417268f, 0.00679562f, 
    -0.00703809f, 0.01010954f, 0.01509169f, -0.03510547f, 0.08507477f, -0.03500347f, -0.11141681f, -0.16918153f, 
    -0.10730299f, -0.02699131f, -0.01494251f, -0.03693796f, -0.06890742f, -0.01635745f, -0.01980196f, -0.07559353f, 
    0.00332979f, -0.07445573f, -0.02653717f, -0.01067705f, 0.01541159f, -0.02969152f, -0.01161018f, 0.01188788f, 
    0.18628037f, -0.22338030f, 0.08339401f, -0.04418348f, 0.02460059f, 0.00372065f, -0.10111249f, -0.09054152f, 
    0.02746880f, 0.03498431f, 0.05931801f, -0.05898234f, 0.03877316f, 0.04584283f, 0.01780055f, 0.02953423f, 
    -0.02257811f, 0.06146396f, 0.01636246f, -0.03952370f, -0.04806280f, 0.06165288f, -0.05069002f, -0.07100882f, 
    -0.05227568f, 0.07066348f, 0.06356719f, 0.01161360f, -0.04442048f, -0.01608004f, -0.00690053f, 0.05160992f, 
    -0.00254054f, -0.04553176f, -0.01439684f, 0.02548641f, 0.02550697f, 0.08256093f, -0.01261297f, -0.03521668f, 
    0.10335659f, 0.02384391f, 0.07598976f, -0.11116779f, -0.03443433f, -0.02104239f, -0.05265986f, 0.02770116f, 
    0.00631860f, 0.00206299f, -0.02573779f, 0.01069100f, 0.01462948f, -0.03791451f, 0.03508116f, -0.01774919f, 
    -0.07989587f, 0.02894021f, -0.00640376f, 0.00831309f, 0.09519339f, 0.10111432f, 0.05454757f, -0.01025112f, 
    0.08913901f, 0.03682014f, 0.02899093f, 0.01208296f, 0.00223333f, 0.08372069f, -0.09634737f, 0.00615815f, 
    -0.03026716f, 0.07497446f, -0.01543884f, -0.03924803f, 0.10602573f, -0.02339085f, -0.05811995f, -0.01859064f, 
    0.26674685f, -0.01253597f, -0.00791586f, 0.00000151f, 0.04634307f, -0.13732651f, 0.04719929f, -0.11377773f, 
    -0.00671367f, -0.03456140f, 0.07557400f, -0.02554931f, -0.00961603f, -0.01162668f, -0.04446039f, -0.02772968f, 
    0.06598473f, 0.03756162f, -0.04662346f, 0.03004427f, -0.05331087f, -0.12823136f, -0.11105340f, -0.07127289f, 
    -0.16850758f, -0.02470242f, 0.05584668f, -0.08914123f, -0.01723602f, -0.06074589f, 0.00119028f, 0.00096598f, 
    -0.01177995f, -0.03700671f, -0.05584431f, -0.02161264f, 0.05825777f, 0.04330939f, 0.03015756f, -0.05904509f, 
    -0.23143426f, -0.23328649f, -0.02221910f, -0.06787224f, -0.09827398f, 0.08341234f, -0.14363597f, -0.09021496f, 
    -0.01745990f, -0.01385454f, -0.07217690f, 0.00703401f, -0.01887087f, -0.04906931f, -0.02143304f, -0.03360061f, 
    -0.07891545f, 0.08146188f, 0.02921094f, 0.05050346f, 0.02296280f, 0.06906800f, -0.06077670f, -0.00556332f, 
    -0.12423709f, 0.00099604f, 0.05864704f, 0.05136669f, -0.04926943f, 0.01597243f, -0.01364900f, 0.02900308f, 
    0.02802761f, -0.11716747f, -0.06932535f, -0.00115540f, -0.03473778f, -0.01062643f, -0.00987704f, -0.07978879f, 
    0.06579720f, -0.01399996f, 0.15425684f, 0.10360830f, 0.19205777f, -0.16056602f, -0.07138411f, -0.09528649f, 
    -0.01822084f, -0.00369559f, 0.06003869f, -0.02684905f, -0.02429590f, 0.01638498f, 0.06178299f, -0.07511357f, 
    -0.03400093f, -0.04569642f, -0.02297918f, 0.03859865f, 0.12976724f, -0.04490554f, 0.05361577f, 0.05771748f, 
    0.01106690f, -0.06858289f, 0.00900396f, -0.02702733f, -0.03316472f, 0.02089626f, -0.02083683f, 0.01706444f, 
    0.02533142f, -0.02075625f, -0.01183106f, 0.06156419f, -0.02947189f, -0.01827389f, 0.02266024f, -0.00661551f, 
    0.06456164f, 0.07058705f, 0.04264753f, -0.05254375f, 0.08742718f, 0.04254934f, -0.02725516f, 0.05246655f, 
    0.03521209f, -0.03308740f, -0.02570640f, -0.04444325f, 0.00771780f, 0.02482189f, 0.02506863f, 0.01794945f, 
    -0.01291167f, -0.04300726f, 0.00166431f, -0.05019666f, 0.12064235f, -0.38852316f, -0.00875934f, -0.04427786f, 
    -0.18722492f, -0.06972881f, -0.01594389f, -0.03389816f, 0.03885186f, 0.00986320f, 0.02992076f, -0.06471519f, 
    0.08800517f, -0.05370583f, 0.01671609f, 0.03267754f, -0.02297655f, 0.00819193f, 0.05381896f, -0.01987613f, 
    -0.13097836f, -0.17968307f, 0.01213451f, -0.15011415f, -0.17419893f, 0.00102612f, -0.10705927f, 0.04857807f, 
    -0.02284806f, 0.01028555f, -0.12594764f, 0.01888038f, 0.01924620f, -0.00541711f, -0.05306565f, -0.00941541f, 
    -0.05227013f, 0.02044370f, -0.00136023f, 0.01916953f, -0.19401172f, -0.21956900f, 0.15484048f, 0.08162377f, 
    0.04576947f, -0.12059209f, -0.09420726f, -0.07447813f, 0.01659667f, 0.06668129f, -0.01723392f, 0.00879704f, 
    -0.11781415f, 0.04079361f, 0.04528509f, -0.02123347f, -0.02290703f, -0.05933558f, -0.03223797f, -0.00282562f, 
    0.20496991f, -0.22151843f, -0.04406158f, -0.13280596f, -0.05052406f, -0.02064892f, -0.05354793f, 0.05760502f, 
    -0.07625590f, 0.06033113f, -0.01963667f, -0.05274723f, 0.04637651f, -0.03735328f, -0.02972751f, 0.00577339f, 
    -0.01031315f, 0.06085423f, -0.05361339f, -0.00875912f, 0.20389482f, -0.19719070f, 0.11695856f, -0.05629671f, 
    0.10365859f, -0.08113887f, -0.01852884f, -0.01732339f, 0.00886780f, 0.02620404f, 0.03588656f, -0.01841349f, 
    0.01090314f, -0.01981088f, 0.04473876f, -0.00193006f, -0.00336464f, -0.00995163f, 0.00934659f, -0.03414084f, 
    0.02758049f, 0.01729744f, 0.07223547f, -0.12393139f, -0.10602479f, 0.01728822f, 0.04581803f, 0.04754300f, 
    -0.06311832f, -0.00281945f, -0.02296339f, 0.06206064f, 0.03684586f, -0.07898311f, -0.05463230f, 0.07743136f, 
    -0.00652237f, 0.02181458f, 0.04475746f, -0.02008326f, 0.09105716f, 0.05018735f, 0.05595554f, -0.12907298f, 
    -0.04973400f, -0.01967770f, -0.03021845f, 0.04746205f, -0.06728113f, -0.03754487f, -0.03586219f, 0.00412067f, 
    0.07733472f, -0.05179791f, -0.02218103f, 0.00478069f, -0.09941627f, 0.04113528f, 0.00453128f, -0.02071946f, 
    0.10865882f, 0.06789421f, -0.27941161f, -0.17996477f, -0.13781440f, 0.00619579f, 0.02987130f, 0.03119436f, 
    -0.13064277f, -0.01592946f, -0.05461346f, -0.06329919f, -0.01884894f, -0.04687689f, 0.00439915f, -0.04532797f, 
    -0.00855190f, 0.02833371f, -0.04838123f, -0.01481919f, 0.26655650f, 0.02801866f, 0.00841090f, 0.17053829f, 
    -0.02777891f, -0.01920760f, 0.03219248f, -0.01140521f, -0.02632326f, 0.04490590f, -0.04989538f, 0.05082397f, 
    0.06995048f, 0.03337827f, -0.01782363f, 0.03363459f, -0.09107739f, -0.06869194f, 0.03143600f, 0.01143183f, 
    -0.08222294f, 0.01355858f, -0.10651255f, -0.10096561f, -0.03769340f, 0.08036599f, -0.00305893f, 0.10695124f, 
    0.04244788f, -0.01643454f, -0.03646366f, 0.01920384f, 0.00049654f, -0.02704289f, 0.00140486f, -0.00886454f, 
    0.05091721f, -0.00577737f, -0.07111810f, -0.03971885f, -0.02902516f, -0.22662313f, -0.13372752f, 0.04752530f, 
    -0.17236124f, -0.02740340f, -0.10172396f, 0.02480606f, 0.05605377f, 0.04782388f, 0.06628482f, 0.06631097f, 
    -0.08705167f, 0.02809284f, 0.00555085f, -0.04607861f, -0.04091787f, 0.04238451f, -0.02221938f, -0.08551069f, 
    -0.34150895f, -0.06847278f, 0.11759946f, -0.22440861f, 0.03437656f, -0.00681055f, 0.06454517f, 0.02165255f, 
    0.04377783f, 0.00398013f, 0.04618717f, 0.01029295f, 0.11422010f, -0.09161525f, 0.01767810f, 0.11239869f, 
    -0.00627614f, -0.10842603f, 0.06380151f, -0.06808519f, 0.15506026f, 0.04265270f, -0.04398460f, -0.13628668f, 
    -0.08096173f, 0.08303443f, 0.06576246f, -0.01264895f, 0.06017660f, 0.03141853f, -0.05222338f, 0.05701752f, 
    0.01202859f, 0.01209786f, -0.00741230f, -0.06881256f, -0.01165155f, 0.03334464f, 0.03113179f, -0.03445417f, 
    0.05352293f, 0.01793492f, 0.00915959f, 0.00076757f, 0.02959365f, -0.08678148f, -0.09669563f, -0.02130190f, 
    -0.03337097f, -0.05855735f, -0.00162373f, -0.05626079f, 0.01306996f, -0.13179520f, 0.02535653f, 0.03540202f, 
    -0.02217073f, -0.00065825f, -0.02097311f, 0.03146087f, 0.00620703f, -0.07092450f, -0.06042910f, 0.06849662f, 
    -0.03269292f, -0.09714976f, 0.01942447f, -0.05537571f, 0.00190177f, 0.01988381f, 0.02920334f, -0.00489670f, 
    0.00676417f, -0.01378374f, 0.03899327f, -0.03425618f, -0.02650988f, -0.01223186f, -0.02733853f, 0.00912691f, 
    -0.55088735f, 0.05584042f, 0.04416837f, -0.10634672f, 0.00974010f, 0.01752568f, 0.02905501f, -0.03462296f, 
    0.06471774f, 0.08710007f, -0.02833744f, -0.06907365f, 0.00657806f, -0.10076169f, 0.02426052f, -0.00085213f, 
    0.06168759f, -0.06451608f, 0.03348110f, 0.07342791f, -0.17689057f, -0.07366124f, -0.23370330f, -0.15573403f, 
    -0.21673019f, -0.00739446f, -0.01738191f, -0.09484172f, -0.00124034f, -0.09991411f, -0.00611255f, 0.00382762f, 
    0.03929651f, 0.08534998f, 0.01734014f, 0.01460358f, -0.03258022f, 0.03756053f, -0.03218545f, -0.04800197f, 
    0.39617541f, -0.20119172f, -0.14749238f, 0.10018529f, -0.31185639f, -0.07946284f, 0.00209390f, 0.02064071f, 
    -0.07267258f, -0.00792693f, 0.00312748f, -0.00816770f, 0.01377513f, -0.10012581f, -0.04116568f, 0.01698999f, 
    -0.03076911f, 0.00666994f, 0.10189260f, 0.02289617f, -0.04449482f, 0.19050917f, -0.04598242f, -0.04909169f, 
    -0.03881570f, 0.02989513f, 0.01638849f, 0.05785537f, -0.09798105f, 0.00755839f, -0.00540418f, 0.06471664f, 
    0.02624564f, 0.08454594f, 0.04997339f, -0.02703567f, -0.11128150f, 0.06688277f, -0.02764387f, 0.00238867f, 
    0.17160578f, -0.11827279f, 0.13300765f, -0.04758956f, 0.04407514f, -0.05114788f, -0.06063543f, -0.15090126f, 
    0.08560850f, 0.01303527f, 0.02426312f, -0.05630494f, -0.00376101f, -0.03414209f, 0.00946170f, -0.00625250f, 
    -0.00520047f, 0.04109265f, -0.00847675f, -0.01367214f, 0.22695056f, -0.09012135f, 0.02185310f, 0.05806287f, 
    0.02191362f, -0.09404054f, 0.01772363f, -0.00842297f, -0.04681035f, 0.02674274f, 0.03300503f, -0.03541050f, 
    0.08205640f, 0.00151027f, -0.03474252f, 0.00552334f, -0.05230089f, -0.01632394f, 0.01417606f, 0.01708805f, 
    0.21158275f, 0.17915252f, -0.05933058f, 0.00219375f, -0.15334055f, -0.04713298f, 0.12055416f, -0.00215485f, 
    -0.01011889f, -0.02536774f, 0.01290443f, -0.08924335f, -0.01727867f, -0.03861065f, -0.01073594f, 0.02672009f, 
    0.03698775f, 0.00921064f, 0.11030963f, -0.05011071f, 0.30733854f, 0.00440300f, 0.15765832f, 0.03978412f, 
    0.18950987f, 0.04255750f, -0.04339695f, -0.13255617f, 0.06057455f, 0.10540348f, -0.00008368f, -0.03084267f, 
    -0.01604340f, 0.04279547f, 0.04780387f, 0.02221004f, -0.08647622f, 0.01913856f, 0.00411514f, -0.01380970f, 
    -0.09653858f, -0.00171354f, 0.07995601f, -0.11046111f, -0.03290430f, 0.10700759f, -0.07976464f, 0.05688519f, 
    0.07759755f, 0.01761657f, -0.06831156f, -0.00400421f, 0.03666161f, 0.04373858f, 0.00927581f, -0.13270441f, 
    -0.07889950f, -0.01004670f, -0.05562036f, -0.02667588f, 0.20065358f, 0.02132182f, -0.09055580f, 0.05713696f, 
    -0.01157513f, -0.11849504f, -0.01427467f, 0.04468475f, 0.00346830f, -0.07417521f, 0.00538534f, 0.02612652f, 
    -0.01357814f, 0.02033657f, -0.00611599f, -0.01319542f, -0.08150765f, -0.11515966f, 0.06345772f, 0.01180494f, 
    -0.10406968f, 0.01729389f, -0.04023835f, -0.00733929f, 0.02452770f, -0.03782184f, -0.04132648f, -0.00783916f, 
    0.06189162f, 0.00283369f, -0.00990668f, -0.03142686f, 0.05423879f, -0.02728692f, -0.03906574f, -0.00416846f, 
    0.06482966f, -0.06613556f, 0.03128761f, 0.04185402f, -0.17205268f, -0.12884013f, 0.01737014f, -0.04837194f, 
    -0.10067494f, -0.00616347f, -0.09618208f, -0.03118601f, 0.05352602f, -0.03753953f, 0.02188988f, -0.02868330f, 
    0.01103045f, -0.03053213f, -0.02922013f, -0.01719822f, 0.03879874f, 0.00079381f, 0.00660627f, -0.00149707f, 
    0.10779504f, -0.03649897f, 0.09047253f, 0.09798849f, 0.01352251f, -0.06338245f, 0.01233268f, 0.06112587f, 
    -0.06126284f, -0.03315748f, -0.15227060f, -0.04072978f, -0.06324346f, -0.03390451f, 0.05560916f, -0.02987498f, 
    0.05393761f, 0.08306605f, 0.02820734f, 0.04442171f, -0.24241784f, -0.06570931f, -0.01448556f, -0.01919973f, 
    -0.07624330f, -0.06881970f, -0.06079127f, -0.04282271f, 0.00946564f, -0.05096938f, -0.03686651f, -0.08836902f, 
    0.03101657f, 0.00428485f, -0.01598507f, -0.02199421f, 0.06957631f, 0.01166336f, 0.02586284f, 0.05005164f, 
    -0.12220024f, -0.17309883f, -0.17092857f, -0.12357963f, -0.21557926f, 0.02477712f, -0.03686031f, -0.04722205f, 
    -0.08826850f, -0.04338949f, -0.04288962f, -0.01817082f, 0.03451046f, -0.00247898f, 0.00709443f, 0.06541257f, 
    -0.00871210f, 0.00276026f, -0.04577333f, 0.02448880f, 0.06063398f, -0.26591650f, -0.16414493f, 0.05079759f, 
    -0.02197109f, -0.10640465f, -0.06128730f, -0.04412226f, 0.06460127f, -0.03753714f, -0.02068084f, -0.02695027f, 
    0.05440104f, -0.00724065f, 0.02302261f, -0.04822045f, 0.02105820f, 0.02321123f, -0.02783123f, 0.02597378f, 
    0.04798241f, -0.51437795f, -0.23705339f, 0.09941898f, 0.14713816f, 0.00998432f, 0.02104979f, 0.03213615f, 
    -0.06342564f, -0.06216976f, -0.00317932f, 0.01883374f, -0.03651890f, 0.07327631f, -0.01170917f, -0.03069448f, 
    0.03368366f, 0.05162061f, 0.01629724f, -0.01335466f, -0.01627719f, -0.08210001f, -0.00719599f, 0.06737860f, 
    -0.13741988f, -0.00656889f, -0.03813982f, -0.03363447f, -0.00595237f, 0.03667686f, -0.00359424f, 0.06811089f, 
    -0.01674738f, 0.01769198f, 0.01023662f, -0.01184233f, 0.01424635f, 0.00672427f, -0.03134867f, 0.01598995f, 
    0.11009219f, 0.07332095f, -0.04691225f, 0.11979462f, 0.01384517f, -0.12382533f, 0.04936502f, -0.00492138f, 
    0.02423375f, 0.04823162f, 0.05195150f, 0.06126726f, -0.04494503f, -0.01453142f, 0.00661756f, -0.03620876f, 
    0.01605541f, 0.10986413f, 0.04807221f, 0.03491871f, 0.29375845f, 0.14716980f, -0.05082653f, 0.00949838f, 
    0.06816924f, -0.01751721f, 0.02295511f, -0.05336795f, 0.09228105f, 0.03158733f, -0.03411099f, -0.03943089f, 
    -0.00706388f, -0.00223782f, -0.00743254f, -0.03376797f, -0.02677374f, 0.01328334f, 0.00576196f, -0.00053604f, 
    0.06229285f, 0.03366997f, -0.05430403f, 0.08901669f, 0.13591589f, -0.03355147f, 0.09546535f, 0.00370653f, 
    0.01575932f, 0.00022353f, 0.05806281f, -0.00708597f, -0.02965964f, -0.02532444f, 0.05637784f, -0.03942397f, 
    0.02021420f, -0.00843823f, -0.03715429f, -0.02420543f, -0.18366760f, -0.27702641f, -0.26153731f, 0.14500602f, 
    0.00394300f, -0.09009653f, 0.01151062f, -0.03623893f, 0.01651090f, -0.03809175f, 0.03511960f, 0.04651592f, 
    -0.01377833f, -0.04004382f, -0.00170466f, -0.05837275f, 0.05786396f, 0.08077637f, -0.03789344f, -0.08734055f, 
    -0.18156190f, -0.03326855f, -0.10671544f, -0.03268680f, 0.11671717f, 0.00283673f, 0.09045453f, 0.01555656f, 
    -0.00855628f, 0.08997586f, 0.00386654f, -0.03747516f, 0.04722844f, 0.03758267f, -0.04884195f, 0.00625429f, 
    -0.00200842f, 0.01445020f, 0.02771019f, 0.06924018f, -0.00130686f, -0.29730365f, -0.25751105f, -0.07198317f, 
    -0.00448601f, -0.09399924f, -0.08995968f, 0.00831849f, 0.02628148f, 0.04327448f, -0.00357093f, 0.04303275f, 
    -0.02091027f, 0.01419334f, -0.00731670f, -0.07126725f, 0.00331500f, -0.01301453f, 0.00452486f, 0.03493749f, 
    0.11546741f, 0.11882469f, -0.14149845f, 0.14804792f, -0.02852890f, -0.00433529f, 0.08078948f, 0.01383457f, 
    0.03326342f, 0.01359500f, 0.05908710f, -0.03712720f, -0.08278452f, 0.03350036f, 0.00179564f, -0.05726354f, 
    0.01068870f, 0.03051752f, -0.05875154f, -0.03341461f, 0.01198279f, -0.02362612f, 0.08346065f, 0.01460747f, 
    -0.07289241f, -0.01970285f, -0.13056363f, -0.03265423f, -0.01820120f, -0.05272302f, -0.04138694f, 0.04314844f, 
    -0.05570857f, 0.00538174f, 0.04128218f, 0.00289137f, 0.02039496f, 0.05250941f, 0.07417707f, 0.07525348f, 
    0.22387931f, 0.30739254f, -0.00287581f, 0.06246760f, -0.07972361f, 0.07313071f, -0.02153382f, -0.05428144f, 
    0.03371270f, -0.00120510f, -0.04520307f, -0.05134334f, -0.08116841f, 0.01444133f, -0.08388736f, 0.00108897f, 
    -0.01466277f, -0.02107148f, 0.12057812f, 0.03021243f, -0.02654151f, 0.03522164f, 0.12911887f, 0.01091081f, 
    -0.00529874f, 0.06015372f, -0.01636870f, 0.02128707f, 0.01556656f, 0.02067089f, -0.01995886f, 0.04440608f, 
    -0.06331003f, -0.06072685f, -0.06263523f, -0.05322218f, -0.00203002f, -0.00314405f, -0.05363730f, -0.03360100f, 
    -0.35314381f, 0.02049847f, 0.03398928f, -0.11090686f, -0.17540400f, -0.06802965f, -0.09404247f, 0.03146883f, 
    -0.02431985f, -0.02801926f, -0.09549616f, -0.11015043f, -0.02785284f, 0.00941483f, 0.02578456f, 0.03623604f, 
    0.02178470f, -0.02082243f, 0.07004695f, 0.00255449f, -0.00312321f, -0.16117606f, 0.01405335f, 0.12875655f, 
    0.09984294f, 0.02436635f, 0.08481093f, -0.00347377f, -0.03705291f, 0.00006488f, -0.00565682f, -0.00801659f, 
    -0.00181801f, 0.04544610f, -0.00373165f, -0.06916519f, -0.04233350f, -0.01270786f, 0.00384877f, -0.03215320f, 
    -0.36818847f, 0.06772153f, 0.00685796f, -0.04791473f, 0.09685232f, 0.00727099f, 0.06992346f, 0.00336076f, 
    0.05432636f, -0.06695860f, -0.01319459f, 0.00799343f, -0.03790547f, -0.03993061f, 0.00016968f, -0.03220990f, 
    0.01106651f, -0.12580755f, 0.04020891f, -0.05220721f, -0.36938769f, 0.07874446f, -0.34813112f, 0.06040030f, 
    0.17250185f, -0.03069108f, 0.02419385f, 0.00080666f, 0.01376798f, 0.03472035f, -0.02096735f, -0.01602386f, 
    0.00309051f, -0.06028258f, -0.01399002f, -0.00910653f, -0.03592499f, -0.02708738f, -0.00152499f, 0.02900984f, 
    -0.27408519f, -0.36076441f, -0.12293013f, 0.03688102f, 0.11764995f, -0.02780241f, 0.04229712f, 0.05604995f, 
    -0.01499396f, -0.04969941f, -0.00037517f, 0.02797578f, -0.04286655f, -0.01980593f, 0.05799309f, -0.04365530f, 
    0.00956358f, -0.04848697f, 0.05075793f, 0.00140326f, 0.00505217f, -0.12130795f, -0.02465319f, -0.09570283f, 
    -0.09639541f, -0.02841258f, -0.06539850f, -0.03918134f, 0.00341015f, -0.00827860f, -0.12457091f, -0.01873678f, 
    -0.02828143f, -0.01949832f, 0.00316396f, -0.00633831f, 0.01087708f, 0.04581724f, -0.06488324f, 0.03173000f, 
    -0.27937874f, -0.02320482f, 0.00231444f, -0.01537126f, -0.12628992f, -0.01270134f, -0.05798437f, -0.05478843f, 
    0.00187120f, -0.02445148f, 0.03394931f, -0.05428923f, 0.00469945f, 0.01021695f, -0.03085827f, 0.00461472f, 
    0.01643730f, -0.00650338f, -0.04473146f, -0.00933508f, -0.27380607f, 0.26717120f, 0.11308374f, 0.10882860f, 
    0.02538766f, 0.03029823f, 0.02190867f, 0.02829804f, 0.02485186f, -0.01382764f, -0.05733044f, -0.06352720f, 
    0.01312029f, -0.03609095f, -0.08305028f, -0.05625497f, 0.04322892f, 0.04984606f, 0.07897720f, 0.05090525f, 
    -0.06623050f, 0.04232571f, -0.09634466f, 0.22548503f, 0.08961683f, 0.07972115f, 0.07358685f, 0.05274532f, 
    0.00806194f, 0.01718598f, -0.03069111f, 0.03675897f, -0.01150444f, -0.17074849f, -0.00595133f, -0.01563541f, 
    0.00501313f, 0.06359436f, 0.05425287f, -0.06777485f, 0.06546734f, 0.23882776f, 0.08259079f, -0.03817016f, 
    -0.02020438f, -0.00276763f, 0.04694963f, 0.00696331f, 0.02974842f, -0.02506815f, -0.02688769f, -0.02261188f, 
    -0.02068913f, 0.02314468f, -0.06201196f, -0.05646554f, 0.01315741f, -0.04281820f, 0.09120666f, 0.00716180f, 
    0.02694704f, 0.06315863f, -0.05672758f, 0.00544031f, -0.04780561f, -0.05044229f, -0.12802611f, 0.09121311f, 
    0.00833791f, 0.02683380f, -0.01254862f, 0.00436668f, -0.08480628f, 0.02215642f, -0.01120489f, -0.00802065f, 
    -0.03564493f, 0.07111915f, 0.03228727f, -0.04273602f, 0.08137770f, 0.09146326f, -0.06750540f, 0.10674248f, 
    0.06633043f, 0.05473862f, 0.05319622f, 0.05580468f, 0.01036058f, 0.00147034f, 0.01166118f, -0.02942618f, 
    -0.01882208f, -0.09357093f, -0.05017279f, 0.07439277f, -0.00527650f, 0.05917376f, 0.00536521f, 0.03161818f, 
    0.02353309f, -0.10742731f, -0.08145446f, 0.01685501f, -0.06660057f, -0.03587381f, -0.09228581f, -0.00184719f, 
    0.01350748f, -0.01654190f, -0.08383882f, 0.01905886f, -0.00256520f, 0.05225707f, 0.02034958f, -0.01617472f, 
    -0.00118053f, 0.00400633f, -0.01676127f, -0.04992481f, -0.07216503f, 0.03420764f, -0.18583943f, 0.16638042f, 
    0.05043494f, -0.04006754f, -0.00749428f, -0.00937951f, 0.07150273f, 0.01919518f, 0.05639352f, 0.02086906f, 
    -0.01486854f, 0.10264130f, -0.01849080f, 0.03414372f, 0.03949914f, -0.05194853f, 0.04223768f, -0.01036819f, 
    -0.10665188f, 0.09476566f, -0.02721600f, 0.00061240f, -0.04594792f, -0.04637900f, -0.09385027f, -0.01746329f, 
    -0.02731995f, 0.04737347f, -0.01570852f, 0.03060580f, -0.06050164f, 0.05581320f, 0.02740986f, 0.08626778f, 
    -0.00276137f, 0.03106783f, 0.04231407f, -0.03924670f, 0.01853368f, 0.12231825f, 0.06330588f, 0.09943398f, 
    0.04093708f, -0.00484626f, 0.04192862f, -0.01365452f, -0.02501965f, 0.02699836f, -0.03226317f, 0.01156311f, 
    -0.07515959f, -0.01605801f, -0.01736232f, 0.02344574f, 0.02283331f, 0.06742232f, 0.04590822f, 0.05540428f, 
    0.15829121f, 0.18302520f, -0.09371106f, 0.01655198f, 0.02828337f, -0.01757512f, -0.03817941f, -0.01791276f, 
    -0.01317726f, -0.03041604f, -0.02167367f, -0.01028357f, -0.03648112f, -0.05626327f, 0.02483598f, -0.02734213f, 
    -0.00758923f, 0.09153575f, -0.06342098f, -0.02254673f, 0.13220665f, -0.11858288f, 0.03510775f, 0.21984473f, 
    0.12538259f, -0.00915443f, 0.03471023f, 0.03783599f, -0.07677843f, 0.04152757f, 0.06550048f, 0.05205887f, 
    -0.00848483f, -0.07307392f, -0.02603534f, 0.04109583f, 0.03665958f, 0.02166414f, -0.03181634f, -0.03997902f, 
    0.05118613f, -0.08469406f, -0.15246804f, -0.07418250f, -0.10442715f, 0.02473649f, -0.08052722f, 0.05018837f, 
    -0.04572995f, 0.01636190f, 0.00500354f, 0.00561704f, 0.09698545f, -0.07286849f, 0.04476853f, -0.01542718f, 
    -0.00382244f, 0.05340461f, -0.00746166f, 0.05353921f, 0.11751105f, -0.09349237f, 0.04319475f, -0.00009261f, 
    -0.04143364f, -0.01968770f, -0.00323794f, -0.05627097f, -0.01186863f, -0.00594802f, -0.01657512f, -0.01629561f, 
    0.03800201f, -0.00502707f, -0.00696917f, -0.00021187f, 0.03405295f, 0.02085117f, -0.03260352f, -0.00923101f, 
    -0.28792036f, -0.08764882f, -0.12146109f, -0.12092364f, 0.03079954f, -0.02655559f, 0.05149144f, -0.01825671f, 
    0.07157017f, -0.04201626f, -0.02003285f, 0.01465400f, 0.02505632f, -0.02959498f, 0.01883510f, -0.01712755f, 
    -0.05356635f, -0.08625608f, 0.00467711f, -0.01863863f, -0.05632399f, 0.13049577f, 0.07293508f, 0.04811653f, 
    0.01900623f, -0.05492955f, 0.01041030f, 0.00768051f, -0.04070570f, 0.02318820f, 0.01681631f, 0.01416401f, 
    0.02526598f, 0.01542094f, -0.04457068f, -0.06636321f, -0.05204377f, 0.03444106f, 0.11291019f, -0.06088030f, 
    0.14856397f, 0.00952955f, 0.12264368f, -0.00791841f, -0.02902297f, -0.03100789f, 0.06281552f, 0.00001000f, 
    0.01749111f, 0.00174570f, 0.01242075f, -0.00034105f, -0.02261203f, 0.00409566f, -0.01044215f, 0.00201458f, 
    0.04679688f, -0.01312493f, -0.07894515f, 0.01979013f, 0.07147906f, 0.09826790f, -0.13375103f, 0.05230991f, 
    -0.09418689f, 0.03823085f, 0.01980851f, 0.01903842f, -0.02288853f, -0.01844922f, -0.04439154f, 0.01237795f, 
    0.03991498f, -0.02209078f, 0.01360758f, 0.06298532f, -0.03644341f, 0.02600697f, -0.04489223f, -0.02920078f, 
    0.30641150f, 0.08921912f, -0.09350383f, -0.05418007f, 0.09771347f, -0.10188661f, 0.00234151f, -0.02206469f, 
    0.05780604f, 0.07176336f, -0.07053017f, -0.01754016f, -0.00971742f, 0.03415108f, 0.01630651f, -0.04895791f, 
    0.03580782f, 0.00991751f, 0.04316616f, 0.06989049f, -0.00651529f, 0.02608686f, -0.03316589f, -0.00911209f, 
    -0.03129783f, -0.06314959f, -0.08042364f, -0.07327708f, 0.01773283f, -0.00749550f, 0.02391688f, -0.03661531f, 
    0.09934066f, 0.00764146f, 0.01319937f, -0.03024018f, -0.02355972f, 0.00865946f, 0.07827758f, 0.05811602f, 
    0.07906953f, 0.01630968f, 0.02527111f, 0.07060734f, 0.14291357f, 0.00289501f, 0.09472566f, 0.02612071f, 
    0.02152806f, 0.03568641f, 0.01777465f, 0.00028004f, -0.02686827f, -0.16319796f, -0.02614323f, -0.03163850f, 
    0.01318935f, 0.02229067f, -0.00757164f, -0.05159495f, 0.01420963f, -0.22744569f, -0.16340894f, -0.01409407f, 
    -0.02071251f, -0.09713152f, -0.04793366f, -0.00493634f, 0.05415448f, -0.00942321f, -0.01679059f, 0.02671602f, 
    -0.00620162f, -0.03383305f, 0.05187400f, -0.06637780f, -0.00145574f, -0.01592384f, -0.01642211f, -0.02729405f, 
    0.28310019f, 0.14452480f, 0.01703246f, 0.03530424f, 0.10564440f, 0.02732574f, 0.07974646f, 0.05385871f, 
    0.12337852f, 0.01918088f, -0.06849217f, 0.04569839f, -0.07910609f, -0.02261525f, -0.13818744f, -0.03162131f, 
    0.03629974f, -0.01803442f, 0.11292734f, 0.04004654f, -0.07161786f, -0.05334606f, 0.01274859f, -0.01326714f, 
    -0.00868984f, -0.04748413f, -0.04813187f, 0.09291610f, -0.03779329f, -0.01453613f, -0.02025593f, 0.04539528f, 
    -0.10073389f, 0.01047063f, 0.06078875f, 0.02804005f, 0.05214210f, 0.04030398f, 0.06383869f, -0.03805361f, 
    -0.27851003f, -0.24753724f, -0.09533511f, -0.08493691f, 0.13945480f, -0.04477271f, 0.09225161f, -0.01693662f, 
    -0.02289214f, 0.00095989f, -0.04505326f, 0.05328858f, -0.00750413f, 0.00617352f, -0.02608593f, -0.06054780f, 
    0.05136232f, -0.04404424f, 0.04108407f, -0.00638915f, 0.06463291f, -0.02118072f, 0.10656230f, 0.06632557f, 
    -0.12381906f, -0.02811887f, 0.10455748f, 0.00996275f, -0.04000962f, 0.07195942f, -0.00514293f, 0.01469180f, 
    -0.01408031f, 0.01370652f, 0.02281101f, 0.06183251f, -0.01567926f, -0.01029426f, 0.00661023f, 0.05951059f, 
    0.03158610f, -0.02908715f, -0.20671867f, 0.21061279f, 0.00027170f, -0.08386008f, -0.00874685f, -0.00187662f, 
    0.07309021f, -0.02408682f, -0.01046180f, -0.05209846f, -0.00082629f, -0.03739471f, 0.04734191f, 0.03583398f, 
    -0.04986173f, 0.06687462f, -0.09325833f, -0.02091015f, 0.43160251f, 0.26484305f, 0.00928354f, 0.07032467f, 
    -0.00953105f, 0.09953221f, -0.06689833f, -0.15100579f, 0.08719213f, -0.02258869f, 0.00553377f, 0.03284449f, 
    -0.10431131f, 0.01632598f, -0.05085559f, -0.08258200f, -0.00636338f, -0.08197969f, 0.01407954f, 0.03684547f, 
    0.20531797f, -0.02734243f, 0.14663453f, -0.09889299f, 0.01126260f, -0.03061204f, -0.05113724f, -0.05235552f, 
    -0.04644852f, -0.02245842f, 0.00742282f, -0.03259590f, 0.06923756f, 0.06448615f, -0.07169255f, -0.05074159f, 
    -0.00399425f, -0.09015386f, 0.02996146f, -0.04461509f, 0.05205761f, -0.07381580f, 0.06643756f, 0.02719229f, 
    -0.01810602f, -0.05584547f, -0.02415598f, -0.02937420f, -0.01479844f, -0.02704559f, -0.01172505f, -0.02578152f, 
    0.02118852f, 0.00475011f, 0.01422642f, -0.05777462f, 0.04883261f, 0.07663357f, 0.02042012f, -0.00029751f, 
    -0.09624795f, 0.01710985f, -0.09973936f, 0.06358548f, -0.07268513f, -0.14990057f, 0.10418014f, -0.08166052f, 
    -0.01932287f, -0.05601706f, 0.02657009f, 0.01837131f, -0.06003026f, 0.03617791f, -0.02414729f, -0.02899761f, 
    -0.00075119f, -0.02905024f, 0.02756976f, -0.00392411f, -0.02642106f, 0.17135093f, 0.12756833f, 0.07407456f, 
    -0.02051122f, -0.03792380f, -0.06846505f, 0.02343028f, -0.09137569f, 0.07904837f, -0.02672694f, -0.04454111f, 
    0.04369388f, 0.00705804f, 0.04601052f, 0.13398823f, 0.05650857f, 0.08979027f, -0.00041988f, -0.00942655f, 
    0.04197992f, 0.06206526f, 0.10472568f, 0.07731771f, 0.02121328f, -0.01881179f, -0.02992214f, -0.08483070f, 
    -0.04816159f, -0.04967697f, -0.03951498f, 0.00621929f, -0.01111144f, -0.05352625f, 0.01752315f, 0.00282108f, 
    0.09169935f, 0.00842919f, -0.00255021f, 0.02281003f, 0.25918698f, 0.25280225f, -0.17128141f, -0.13403127f, 
    -0.16877651f, -0.06669451f, 0.02661723f, 0.01498637f, 0.03910486f, 0.01340386f, 0.06088567f, -0.07119378f, 
    -0.07338258f, 0.06501564f, -0.06531664f, 0.02754781f, -0.05837297f, 0.04250770f, -0.01016545f, -0.01127468f, 
    0.06328125f, 0.05368040f, -0.04800268f, -0.05904065f, -0.04312438f, -0.04540221f, -0.12583064f, -0.05355119f, 
    0.01310709f, -0.01510530f, -0.03035937f, 0.00565348f, 0.03929849f, 0.02225205f, 0.00174625f, -0.01779725f, 
    -0.02168133f, 0.05687085f, -0.05722936f, 0.01422145f, -0.02082723f, 0.01744269f, -0.01165701f, 0.03966701f, 
    -0.00525873f, -0.05826579f, -0.12067167f, 0.03950145f, -0.04132228f, -0.03450117f, 0.02509832f, 0.01104833f, 
    -0.02688046f, -0.02899312f, 0.04007656f, 0.00136654f, 0.05104439f, -0.01076956f, 0.03854082f, 0.01557746f, 
    -0.42536899f, 0.30457145f, 0.00252826f, 0.13490184f, 0.08965936f, -0.01956102f, 0.00843740f, 0.03610519f, 
    0.02029376f, -0.05111606f, -0.01270503f, -0.08955399f, -0.04966268f, 0.00334118f, -0.05842889f, 0.00475952f, 
    -0.01384827f, -0.07832942f, -0.00700699f, -0.00284017f, 0.16714939f, 0.05680143f, -0.20842785f, 0.00147235f, 
    0.01214998f, -0.02902877f, -0.05685449f, -0.02112525f, 0.07081410f, -0.08103099f, 0.00500321f, -0.03874741f, 
    -0.07444160f, 0.02589074f, 0.06066654f, -0.08482485f, -0.04957334f, 0.04009809f, -0.03480319f, 0.00848981f, 
    -0.24676527f, -0.44688964f, -0.09724405f, -0.09133040f, -0.26222610f, -0.06934383f, -0.07984982f, -0.00713326f, 
    0.00714133f, -0.02602802f, -0.10567724f, -0.01679707f, 0.12406503f, -0.00803119f, 0.01152849f, 0.06107702f, 
    -0.08056094f, -0.00407717f, -0.05228527f, 0.07470360f, -0.21901038f, -0.05087588f, 0.04058185f, -0.10745643f, 
    -0.09492026f, 0.00491620f, -0.06595052f, -0.00826822f, -0.05038319f, -0.07326724f, 0.05536437f, -0.01085466f, 
    -0.01763247f, -0.03842108f, -0.04087545f, 0.01047662f, -0.01845932f, -0.05661856f, -0.03406489f, -0.04349155f, 
    0.11470559f, 0.27564895f, -0.08402026f, -0.01866430f, -0.03309620f, -0.02644571f, -0.08195741f, 0.10525139f, 
    0.02336877f, 0.05473945f, 0.01945468f, 0.00884452f, -0.03260794f, 0.09135208f, 0.03683543f, -0.06621855f, 
    0.00333581f, 0.05029031f, -0.05903362f, 0.01830689f, 0.20897824f, 0.15961167f, -0.25175226f, -0.12759817f, 
    0.05446335f, -0.02970890f, -0.03117039f, 0.03784728f, 0.11080349f, -0.06890850f, 0.01019872f, -0.05259322f, 
    -0.02542580f, 0.05418193f, 0.05730719f, 0.04427016f, -0.00170966f, 0.00231376f, -0.01138773f, -0.04634856f, 
    -0.06752080f, 0.00171801f, -0.03556073f, 0.11705706f, 0.15887521f, 0.06869214f, -0.00947355f, -0.07049432f, 
    0.08108114f, -0.00701630f, -0.01070220f, 0.00771814f, -0.07829221f, 0.01147486f, 0.06091343f, -0.00070445f, 
    0.05606656f, 0.03613066f, 0.04333490f, -0.05270036f, 0.27064371f, -0.01392508f, -0.21825343f, -0.02929158f, 
    0.12889479f, 0.08499240f, 0.03055988f, 0.07435690f, 0.08822866f, -0.06797545f, 0.01274980f, -0.05421958f, 
    0.05398858f, 0.06851856f, 0.08702113f, -0.02536504f, 0.02668146f, -0.02163647f, -0.02190239f, -0.01498614f, 
    -0.51264942f, 0.03312903f, -0.02945624f, 0.02719977f, 0.03037811f, 0.02778605f, -0.01393110f, 0.01790560f, 
    0.04542850f, 0.00867959f, 0.00829341f, 0.01045726f, 0.04711334f, 0.04973133f, 0.03553965f, 0.05836210f, 
    0.03008265f, -0.02531132f, -0.01926625f, -0.07967734f, -0.14764838f, 0.12986533f, -0.00054221f, -0.05047940f, 
    0.06742094f, 0.02823312f, -0.00198064f, -0.01727937f, 0.07687049f, 0.05302502f, -0.01222282f, 0.00365895f, 
    0.01678339f, 0.04154329f, -0.01177419f, -0.01235455f, 0.09615596f, 0.01175720f, 0.01188855f, 0.02716594f, 
    0.05563747f, -0.11471587f, 0.16187105f, 0.06536564f, -0.02289266f, -0.07108717f, 0.04318752f, -0.02731404f, 
    -0.01901689f, 0.02698601f, 0.08316988f, 0.13166931f, 0.03280736f, -0.03662664f, -0.06879187f, -0.09682094f, 
    0.13190016f, 0.04392790f, 0.01444820f, 0.07382172f, -0.02786726f, 0.18446805f, 0.03545613f, -0.14844432f, 
    -0.12569915f, -0.07434446f, 0.03651872f, -0.03345852f, -0.06128498f, -0.06245587f, -0.01731632f, -0.06828713f, 
    0.06912018f, 0.02459317f, -0.04668883f, 0.01543421f, -0.04374029f, 0.07658208f, 0.03330256f, -0.13893735f, 
    0.16846567f, -0.28334850f, -0.02494168f, 0.01620291f, -0.16110085f, 0.01922940f, 0.03257727f, 0.09947089f, 
    -0.03562655f, -0.03584248f, 0.04895255f, -0.02120769f, 0.07487211f, -0.04064555f, 0.07273831f, -0.03026492f, 
    -0.06933101f, -0.03358565f, -0.04437253f, 0.02988619f, 0.28833652f, 0.02989841f, 0.00030250f, -0.19763111f, 
    -0.13665882f, -0.02707733f, 0.02807936f, -0.02799371f, 0.02107606f, 0.01521857f, 0.04743367f, -0.03980501f, 
    0.05466149f, 0.03209024f, 0.04061171f, -0.07321125f, 0.03149575f, 0.01484539f, 0.03888397f, 0.00866332f, 
    -0.05237167f, -0.00284282f, -0.13306661f, 0.05428441f, -0.27534869f, -0.12744194f, -0.03541558f, 0.00376026f, 
    -0.07381520f, 0.02059093f, -0.03321341f, -0.07324567f, -0.00523799f, 0.00875522f, -0.03689178f, 0.07470186f, 
    -0.00132548f, 0.08653615f, -0.11596110f, 0.01129876f, -0.10456433f, 0.15819125f, 0.19908679f, -0.16461584f, 
    -0.01373636f, 0.06082716f, 0.05686906f, -0.04725544f, 0.03039237f, 0.09294682f, 0.03272619f, -0.08724152f, 
    -0.13043164f, 0.01918530f, 0.01682279f, -0.05815187f, -0.06589222f, -0.07778034f, -0.06047143f, -0.00158493f, 
    0.06030115f, 0.07789898f, 0.19344790f, 0.06523310f, -0.04046694f, -0.05432577f, 0.01112751f, 0.00014836f, 
    -0.02218924f, 0.05087469f, 0.08983056f, -0.03396994f, 0.05123482f, -0.04955349f, 0.07173346f, 0.02511399f, 
    0.02748082f, -0.00604764f, -0.01021132f, 0.05405645f, 0.13170020f, -0.24200851f, -0.00462162f, -0.01570024f, 
    -0.12034725f, -0.06991336f, -0.05008975f, -0.05321501f, 0.04843388f, 0.01690409f, -0.02755633f, -0.00887430f, 
    -0.01234470f, -0.05335373f, 0.03944083f, -0.00707693f, 0.05995788f, -0.06925876f, 0.02031652f, -0.03611479f, 
    -0.02480783f, -0.17811725f, -0.13329071f, 0.24612255f, -0.07210550f, 0.03361133f, -0.07332729f, -0.04026674f, 
    -0.04703676f, -0.05742499f, -0.04695166f, -0.06103709f, 0.04431967f, -0.04800006f, 0.01332531f, -0.04084698f, 
    -0.00789802f, 0.01881256f, -0.03261929f, 0.05588599f, -0.58120984f, 0.02703510f, 0.08088714f, 0.07849471f, 
    0.17743406f, 0.05022261f, 0.02531602f, -0.04187762f, 0.00493316f, 0.17127180f, -0.06330748f, -0.06899402f, 
    0.06213402f, 0.06330413f, -0.01265573f, -0.00653800f, 0.14528033f, -0.00729211f, 0.03027189f, -0.14700484f, 
    -0.19245458f, 0.16775383f, 0.07049893f, -0.17755565f, -0.25120398f, 0.10720989f, 0.02056920f, 0.07493909f, 
    -0.12478537f, -0.06498124f, 0.07289514f, 0.05288974f, -0.05814637f, -0.04256213f, -0.02453116f, -0.01862837f, 
    0.12085756f, -0.07908496f, -0.03002438f, 0.01604026f, -0.03162803f, 0.14085130f, -0.05855546f, -0.11861417f, 
    -0.02152387f, 0.00022997f, -0.01360278f, -0.07063260f, -0.02723929f, -0.01394816f, 0.06068589f, -0.07299440f, 
    -0.08347885f, 0.08476982f, 0.00966200f, 0.00576323f, -0.04409883f, -0.04006334f, -0.06265763f, 0.02536146f, 
    0.06693046f, -0.19661592f, -0.12386627f, 0.17751549f, 0.10626005f, 0.09529330f, 0.06393128f, 0.09775203f, 
    -0.00686063f, -0.05060522f, -0.01625737f, -0.06447021f, 0.14234774f, 0.10211699f, -0.00113440f, 0.01320186f, 
    0.00540673f, -0.10423553f, 0.07491919f, -0.09648870f, 0.06378290f, -0.24441312f, -0.04655419f, -0.04921331f, 
    0.06465882f, -0.07007595f, -0.03117387f, 0.08571541f, -0.06951770f, -0.08317216f, 0.13910024f, 0.07126763f, 
    -0.00439019f, -0.04618265f, -0.03249855f, 0.02724841f, -0.05450939f, -0.04466067f, -0.01618628f, 0.07401251f, 
    -0.14045487f, 0.00361156f, 0.02793117f, 0.13222742f, 0.02422396f, -0.01300265f, -0.05136224f, 0.12089577f, 
    -0.04074313f, -0.02165383f, 0.02190654f, -0.01493089f, -0.08981428f, -0.04502058f, -0.01076231f, 0.03447957f, 
    -0.03452166f, -0.03818861f, -0.02090110f, -0.02224923f, -0.27786866f, -0.05886122f, 0.18062375f, 0.12188023f, 
    0.06511520f, -0.03513461f, -0.11382355f, 0.00102787f, 0.03923590f, -0.00176946f, 0.14723967f, -0.00395560f, 
    0.02123583f, -0.10852583f, 0.00407215f, 0.05340303f, -0.09824416f, -0.04817381f, -0.00598225f, 0.01514680f, 
    -0.03679732f, -0.20928958f, 0.14018039f, 0.03505970f, 0.05293580f, -0.08913129f, -0.12794884f, 0.04916116f, 
    -0.01921748f, 0.03438408f, 0.04860668f, -0.03861573f, 0.06670388f, -0.04975846f, -0.07511856f, 0.03961467f, 
    -0.06462874f, 0.01470428f, -0.01464951f, 0.00575545f, -0.26885855f, -0.03151507f, -0.16150597f, 0.05893229f, 
    0.11871815f, 0.02022520f, -0.06936207f, 0.00771505f, -0.00192308f, 0.00817959f, 0.02833970f, 0.03820722f, 
    0.01974639f, 0.02613025f, -0.02526991f, -0.03594503f, 0.02715732f, 0.00787321f, 0.08074997f, -0.04308457f, 
    -0.01206696f, 0.28535467f, -0.27096498f, -0.02181190f, 0.00960646f, 0.05478086f, -0.01877333f, 0.06475753f, 
    0.05214346f, 0.01666323f, -0.03642040f, -0.00920757f, -0.00667230f, -0.01900894f, -0.00487249f, -0.01665833f, 
    0.05008563f, -0.09352010f, 0.02708567f, -0.02072610f, -0.08887023f, -0.04160549f, 0.06727807f, -0.00419127f, 
    -0.06969324f, -0.00957744f, 0.03892953f, 0.04646794f, -0.05290498f, 0.00722694f, 0.07334694f, -0.01505701f, 
    0.02734816f, -0.00229499f, 0.03366530f, -0.02386307f, -0.02217065f, 0.03254938f, 0.08173864f, 0.00165688f, 
    -0.14776406f, -0.27755505f, 0.18329696f, 0.14491224f, 0.00891144f, 0.03374498f, -0.02485704f, -0.02574212f, 
    -0.10372292f, 0.02571741f, 0.01167622f, 0.05677720f, -0.07177606f, -0.08524390f, 0.01288619f, 0.03321389f, 
    -0.11719835f, 0.04538012f, 0.02005051f, 0.03308612f, 0.03181177f, 0.06553025f, 0.14277725f, -0.03728531f, 
    -0.07282092f, 0.04961903f, 0.03252673f, 0.00819626f, -0.06108066f, -0.04115453f, -0.01230805f, 0.03310106f, 
    -0.01520335f, 0.02608874f, -0.00124270f, 0.01945651f, -0.03928157f, 0.00738572f, -0.01547349f, -0.04535765f, 
    -0.30771413f, -0.07116526f, 0.04328873f, 0.07336503f, -0.03891290f, 0.07387659f, 0.03570108f, -0.03128194f, 
    0.13299385f, -0.02228501f, -0.00994174f, -0.06115787f, 0.04731337f, 0.00168533f, -0.06958505f, 0.02599042f, 
    -0.10154810f, 0.07707947f, 0.06866191f, 0.04496833f, -0.14915091f, -0.20088592f, 0.10509020f, 0.17408890f, 
    -0.04578127f, -0.07762038f, 0.03693199f, -0.07066068f, -0.08040686f, -0.07219901f, 0.06231454f, 0.06633250f, 
    -0.01508184f, -0.01276781f, 0.07255481f, -0.09396423f, -0.03272408f, -0.00267070f, 0.01464648f, 0.05181134f, 
    -0.03064104f, -0.14628397f, -0.02790421f, 0.01098993f, -0.02236499f, -0.03254557f, 0.03050311f, -0.00922491f, 
    0.00142239f, -0.08761381f, -0.04261502f, -0.03362117f, 0.00285429f, 0.01988889f, 0.06457004f, -0.07474261f, 
    0.05472733f, -0.02214566f, -0.04263669f, 0.00081759f, 0.42864901f, -0.00277890f, -0.09131642f, 0.00213280f, 
    0.09654264f, 0.04728345f, -0.06526478f, 0.01329772f, 0.05915212f, 0.05579752f, -0.10074970f, -0.02870782f, 
    0.03820693f, -0.07002589f, -0.02044185f, -0.00279491f, 0.01028491f, -0.09455638f, -0.05853385f, 0.07043535f, 
    -0.23148504f, 0.13765918f, 0.11966394f, 0.05351464f, 0.04760044f, 0.09405451f, -0.05495556f, -0.01624835f, 
    0.07392816f, 0.06209129f, -0.02662794f, 0.01968824f, -0.02124037f, 0.03078995f, 0.01532872f, 0.03951900f, 
    -0.05619420f, 0.02041283f, -0.00748926f, -0.11957116f, -0.01763045f, -0.03172200f, 0.02931734f, 0.12090427f, 
    -0.00075803f, 0.01973074f, 0.01181658f, 0.01036295f, -0.06984460f, 0.01760839f, 0.07264125f, 0.02131210f, 
    -0.05738642f, -0.04854325f, 0.05060422f, 0.02442470f, -0.01584706f, 0.10986441f, 0.04645375f, 0.05965402f, 
    0.09754450f, 0.04586937f, 0.10799076f, -0.06126121f, 0.00176337f, -0.00234962f, 0.07351799f, -0.01437837f, 
    0.06605025f, -0.03681234f, 0.07514040f, 0.00551860f, 0.09749683f, 0.03371235f, 0.07415834f, -0.00075040f, 
    -0.00457511f, 0.05991083f, -0.04747921f, 0.08044069f, -0.10254513f, -0.43777582f, -0.05222925f, 0.15710227f, 
    0.05723612f, -0.15673612f, -0.03685191f, -0.03619109f, -0.17348923f, -0.07920708f, 0.03599869f, 0.07071799f, 
    -0.02489851f, 0.02716754f, 0.05881746f, -0.14118232f, -0.07552329f, -0.02597023f, -0.03714328f, -0.03694898f, 
    -0.61830527f, 0.04803724f, 0.03245924f, 0.20816861f, 0.14192264f, 0.07753535f, -0.08142406f, 0.05692644f, 
    0.03846243f, 0.10345989f, 0.00182032f, 0.02981732f, 0.00360828f, 0.01676160f, 0.04362369f, 0.00814655f, 
    0.02145157f, 0.05105311f, 0.10065002f, 0.01753350f, -0.25259972f, 0.12284233f, -0.01972385f, -0.04837671f, 
    0.05730418f, 0.04094501f, 0.02336855f, 0.00331146f, 0.04272384f, 0.07155158f, 0.01705603f, 0.03949715f, 
    0.01184086f, 0.06310111f, -0.07105897f, 0.00037913f, 0.02101186f, -0.00679006f, -0.03089089f, -0.05661982f, 
    -0.08999007f, -0.12505096f, 0.15710934f, -0.19054972f, -0.05870144f, -0.05213324f, 0.06059486f, -0.03196108f, 
    -0.01074891f, 0.08840937f, 0.04972182f, -0.01353804f, -0.01168341f, -0.09198260f, 0.06967908f, 0.05257556f, 
    -0.01800115f, -0.07330417f, -0.00610073f, -0.00257482f, 0.06262758f, 0.01977983f, 0.07034505f, -0.09061822f, 
    0.01516106f, -0.01671899f, 0.05682679f, -0.14716534f, 0.02918088f, -0.00526090f, 0.05397049f, 0.01453187f, 
    -0.06757583f, 0.04227398f, -0.06081719f, -0.07139596f, -0.00471881f, 0.01546843f, 0.06805855f, -0.00732061f, 
    0.15462598f, 0.10809472f, -0.09291366f, 0.04510243f, -0.27027935f, -0.06475163f, 0.02627534f, 0.06217311f, 
    -0.00706529f, -0.08919873f, -0.01345042f, -0.07660012f, 0.03668487f, 0.04322416f, -0.03423807f, -0.11091002f, 
    0.01711871f, 0.11470618f, 0.00982421f, 0.07302494f, -0.32192379f, 0.00174480f, -0.12396366f, 0.16060583f, 
    -0.04185089f, -0.03569337f, -0.01641448f, 0.07980160f, 0.01518592f, -0.02733946f, 0.03782098f, -0.01168223f, 
    -0.01752811f, -0.00790372f, 0.09595596f, 0.02302880f, -0.06875108f, 0.04106605f, 0.07334489f, 0.13445078f, 
    -0.04501636f, 0.00781393f, 0.04330437f, -0.03247278f, -0.16447437f, 0.03640565f, -0.03504050f, 0.08514985f, 
    -0.00612935f, 0.02512207f, -0.02274164f, -0.02868091f, -0.04176835f, -0.02284022f, 0.01713548f, -0.03667919f, 
    0.09251431f, 0.01070923f, -0.00655827f, 0.01114474f, -0.25471133f, 0.06985618f, -0.01858852f, -0.02328684f, 
    0.03956861f, -0.01356296f, -0.07733820f, -0.08627594f, 0.00744392f, -0.02569456f, -0.03463423f, 0.04209909f, 
    -0.10788155f, 0.01075510f, 0.02522599f, -0.03765206f, 0.02063183f, 0.04187786f, 0.03749950f, -0.03470500f, 
    -0.18187675f, -0.12929530f, 0.03036970f, 0.12238808f, -0.01989671f, -0.07502926f, 0.01009755f, 0.04170278f, 
    -0.09619259f, -0.04289109f, 0.01304989f, -0.00786482f, 0.02580119f, -0.03046403f, 0.05824421f, -0.08456164f, 
    -0.02809916f, 0.14823319f, -0.05806696f, 0.01828757f, 0.00295287f, -0.23266527f, 0.03568894f, 0.01617691f, 
    -0.00415568f, -0.05907101f, 0.01840530f, -0.01231697f, -0.04453925f, -0.04637135f, 0.01733430f, -0.02336675f, 
    -0.06903838f, -0.01520632f, 0.01387441f, -0.04204036f, 0.08470561f, -0.01550305f, -0.02995855f, -0.06255035f, 
    -0.19593868f, 0.09270072f, 0.18404657f, 0.05624640f, -0.07592975f, -0.05166158f, 0.03921051f, 0.03415873f, 
    -0.05500156f, -0.11723808f, 0.05041783f, 0.00767004f, -0.04012228f, 0.08644437f, 0.04191016f, -0.04434194f, 
    0.01697493f, 0.10159724f, -0.05554473f, 0.00304427f, -0.24806513f, -0.02544159f, 0.00878135f, 0.00831441f, 
    0.17798299f, -0.00676545f, 0.02626426f, -0.00452185f, -0.00636717f, 0.08514631f, 0.01105491f, -0.07398520f, 
    0.03754940f, 0.02279148f, -0.05400594f, -0.09171692f, 0.13237058f, 0.06546637f, 0.10813400f, -0.14561234f, 
    0.09393988f, -0.18328229f, 0.14745447f, 0.05391302f, -0.02874278f, -0.04626985f, -0.12908317f, 0.11038513f, 
    -0.06065371f, 0.02923814f, 0.05235812f, -0.03582411f, -0.04139427f, -0.07047068f, 0.02604412f, 0.02666023f, 
    -0.03663755f, 0.01016129f, 0.04664226f, -0.02238057f, -0.03386634f, 0.07633021f, -0.13573866f, 0.10547475f, 
    -0.17858428f, 0.08553016f, -0.13459916f, -0.01445298f, 0.00400197f, -0.00957995f, -0.07639948f, -0.04149645f, 
    0.05034120f, 0.02520905f, 0.06680650f, 0.06531739f, 0.04181198f, -0.01600139f, -0.03970259f, -0.04900545f, 
    -0.15233029f, 0.08951057f, -0.04037286f, 0.02540367f, -0.18363096f, -0.05872783f, -0.03043181f, -0.12205262f, 
    -0.19334647f, -0.00856953f, 0.07429867f, -0.00665576f, -0.04890033f, 0.07277521f, 0.01317785f, -0.00845341f, 
    -0.05919259f, -0.00692932f, -0.15349618f, -0.05404178f, -0.03829180f, 0.20345616f, 0.01237608f, -0.34875506f, 
    -0.18840857f, 0.05132454f, 0.14365034f, 0.00673182f, 0.01979262f, -0.02185913f, 0.02624341f, 0.03663799f, 
    -0.03207211f, 0.03764482f, 0.03786347f, -0.05348899f, 0.11254966f, -0.04444395f, 0.00896064f, 0.04391939f, 
    0.15595303f, 0.17448649f, -0.10587261f, -0.22225666f, 0.20170677f, 0.03617117f, -0.01188395f, -0.04143211f, 
    0.04294174f, -0.07053827f, -0.03733245f, 0.00139508f, -0.03255220f, -0.02440510f, -0.05153804f, -0.05526956f, 
    -0.05878578f, -0.19378974f, 0.03319231f, 0.01388685f, -0.03534704f, -0.09987492f, -0.03912245f, -0.00710732f, 
    0.17601457f, 0.00908822f, 0.05265743f, -0.01261658f, 0.04651241f, -0.03555166f, 0.02107947f, 0.00562830f, 
    0.01293101f, 0.02407532f, 0.03898573f, -0.04746788f, 0.03902167f, -0.00902247f, 0.03644198f, -0.00133119f, 
    -0.32732865f, 0.20093778f, 0.01791864f, -0.06945701f, -0.23467582f, 0.10051179f, -0.08693203f, -0.04349754f, 
    -0.03196900f, -0.09995245f, -0.01977616f, -0.06602742f, -0.05828417f, 0.05002628f, -0.01922841f, -0.08843236f, 
    -0.03886517f, -0.00568310f, -0.12443323f, 0.04446337f, 0.03179971f, 0.02796547f, 0.05396277f, 0.01900971f, 
    -0.08343943f, -0.05572227f, -0.04980398f, -0.08116844f, 0.06290250f, -0.08127787f, 0.07689004f, 0.01523003f, 
    0.05759037f, 0.10445482f, 0.12051953f, -0.01906893f, 0.06435002f, 0.01002068f, 0.00993760f, -0.04257977f, 
    -0.18667500f, 0.03469069f, -0.11413775f, 0.06529290f, 0.07301996f, 0.06484202f, -0.06044575f, 0.00491901f, 
    0.03525122f, 0.06192718f, -0.03917735f, 0.06535014f, -0.00019038f, -0.02010220f, -0.02774063f, -0.02734866f, 
    -0.03058753f, -0.01622960f, 0.00231399f, -0.12687641f, 0.15464017f, -0.12074323f, -0.03906587f, 0.00727527f, 
    -0.02943857f, 0.06141322f, -0.02705426f, 0.02063172f, -0.02436974f, -0.05188138f, -0.07821466f, 0.04536158f, 
    0.05213733f, -0.06338125f, -0.12407500f, -0.07309241f, -0.03901633f, -0.13408555f, 0.01426374f, 0.03659363f, 
    -0.15912707f, 0.08450814f, 0.02346363f, 0.03614331f, 0.05629172f, 0.07974001f, 0.07360376f, 0.02260693f, 
    0.02351501f, -0.01491172f, 0.01516823f, 0.01077847f, 0.06067966f, 0.01623240f, 0.00147471f, 0.00709053f, 
    -0.10259543f, 0.00406586f, 0.01610256f, 0.03982708f, -0.24224633f, 0.14744021f, 0.01294142f, 0.09066091f, 
    0.09180987f, 0.04667053f, 0.02890873f, 0.04585176f, 0.07878538f, 0.09706580f, -0.04143930f, 0.03798588f, 
    0.01531640f, -0.00598729f, -0.03467014f, -0.05951698f, 0.02493604f, 0.06353230f, 0.03827484f, -0.04797518f, 
    -0.46117741f, -0.14337690f, -0.03849784f, -0.14972109f, 0.08663519f, -0.01212555f, -0.04066237f, 0.02658896f, 
    -0.01930646f, 0.01955048f, -0.06890927f, -0.03668633f, -0.02333002f, 0.00034745f, 0.02515486f, -0.00054387f, 
    0.02851507f, -0.01990662f, 0.02712720f, -0.07129108f, -0.24156344f, -0.11458519f, 0.00105803f, -0.05337508f, 
    -0.00863952f, -0.01471240f, 0.04674588f, 0.02953312f, -0.02942504f, 0.03022506f, 0.01108382f, -0.00127072f, 
    0.04070003f, 0.01240933f, 0.02458717f, 0.02229034f, 0.00885935f, 0.03658437f, 0.10860534f, 0.09573486f, 
    0.12844267f, 0.00873663f, 0.12986650f, 0.00233434f, -0.04210476f, 0.02494367f, 0.01362548f, -0.02888038f, 
    0.04144905f, 0.07091131f, -0.01005860f, -0.03618418f, 0.02693259f, 0.00452111f, 0.04644643f, -0.00060012f, 
    0.04784876f, -0.00527549f, -0.00137311f, -0.10425226f, 0.04121997f, 0.20598677f, -0.10066226f, -0.04119345f, 
    0.08274352f, 0.04740446f, -0.05663520f, 0.06567762f, 0.08935653f, 0.00226527f, -0.06264961f, 0.06777328f, 
    0.02547748f, 0.03958889f, -0.01347371f, 0.09492885f, 0.00571594f, -0.10167696f, 0.01416416f, -0.06367251f, 
    -0.07599269f, -0.04939623f, 0.13383299f, 0.14387438f, -0.33636311f, -0.02947032f, -0.02148669f, -0.07033166f, 
    -0.03706752f, -0.00664841f, 0.02326050f, 0.03341099f, 0.02751050f, -0.07390876f, 0.03207595f, -0.06037637f, 
    -0.07213113f, 0.00400483f, 0.06574460f, -0.11557904f, -0.20273378f, 0.07173768f, 0.10366370f, 0.03961704f, 
    -0.16899186f, 0.08301621f, 0.00020898f, -0.03464493f, -0.12532218f, 0.04464359f, -0.00472690f, -0.10187717f, 
    -0.04018429f, -0.00158039f, -0.05311293f, -0.02825182f, -0.00776397f, 0.03573361f, 0.09091435f, 0.01851193f, 
    -0.18967809f, 0.01685331f, -0.15482718f, -0.16731110f, 0.05615888f, 0.14452733f, 0.13062608f, 0.00702614f, 
    0.00391851f, 0.11822587f, -0.00455961f, 0.01955556f, -0.00246466f, -0.02743042f, -0.01873237f, -0.04642429f, 
    0.02882343f, 0.02183678f, -0.08393434f, 0.07693733f, -0.06334411f, 0.05344715f, 0.21742241f, -0.02188402f, 
    -0.16833030f, 0.04425384f, 0.00991547f, 0.07268883f, -0.09422752f, -0.08647277f, 0.05172042f, -0.06162542f, 
    -0.09717292f, -0.07648558f, -0.08427221f, -0.02198486f, 0.02554648f, 0.07224020f, 0.03563416f, -0.04010130f, 
    -0.15017037f, 0.15264741f, 0.10861118f, 0.00639781f, -0.05551936f, -0.06894711f, -0.02019968f, -0.01439442f, 
    -0.03286225f, -0.09059626f, -0.03881305f, 0.03862555f, 0.00325744f, 0.03533936f, -0.00751705f, 0.02784354f, 
    -0.01363454f, 0.04324947f, 0.07634582f, 0.06291686f, 0.06910066f, -0.04969871f, 0.07844022f, 0.10607318f, 
    -0.08432665f, 0.08367251f, 0.06048829f, -0.00415627f, -0.02635804f, -0.03386935f, -0.03930280f, 0.06198420f, 
    0.02068954f, -0.03520920f, 0.09865472f, -0.00914313f, -0.06184000f, 0.07322866f, 0.04239857f, -0.03417902f, 
    0.06058424f, 0.03810811f, 0.02697208f, 0.08586937f, 0.09265914f, 0.00431493f, -0.08204263f, -0.03204465f, 
    -0.01559324f, 0.02327508f, -0.01596452f, -0.05892053f, 0.07353269f, 0.05002954f, 0.04680081f, 0.04173936f, 
    -0.18643394f, 0.07712487f, -0.00991736f, -0.02603919f, -0.26113307f, -0.01430324f, -0.06975691f, 0.00334153f, 
    0.04847852f, 0.00630921f, -0.07748556f, -0.03607861f, 0.05464470f, -0.06441612f, 0.02897794f, 0.04684403f, 
    0.00363677f, -0.01148141f, 0.02373928f, -0.05913400f, 0.03504511f, -0.02901064f, -0.00611165f, 0.04796465f, 
    -0.11022568f, -0.02885696f, 0.02909674f, 0.22276692f, -0.00219803f, 0.01691562f, 0.13078329f, -0.02657472f, 
    -0.03093615f, 0.11844280f, -0.04333416f, -0.14172803f, -0.07614569f, 0.12991934f, -0.10880587f, 0.07544005f, 
    0.02419398f, -0.10532153f, -0.07497514f, 0.00418645f, -0.06890168f, 0.00344849f, 0.13867117f, -0.00731124f, 
    -0.13821065f, 0.04941640f, 0.03493147f, 0.02840997f, -0.01388002f, -0.03869870f, -0.07962419f, -0.01597309f, 
    0.03790852f, -0.05298317f, -0.02672798f, -0.06088334f, 0.01028564f, -0.00037751f, 0.03593859f, 0.00254640f, 
    -0.04626683f, 0.12369958f, -0.01247069f, -0.04875540f, -0.09749745f, 0.05316851f, -0.04318659f, -0.14399013f, 
    -0.01204584f, -0.04726179f, -0.15383896f, 0.00618686f, -0.02336116f, -0.00047838f, -0.01022024f, 0.07360346f, 
    0.00371462f, -0.04992751f, 0.06732550f, -0.02965302f, 0.06149941f, -0.11367488f, 0.01500952f, 0.30687329f, 
    0.09663482f, -0.02795076f, 0.10252181f, 0.02861731f, -0.00736697f, 0.02385581f, -0.03031557f, 0.07023242f, 
    0.02187280f, 0.03051192f, 0.07098595f, -0.06340760f, 0.11706655f, -0.08830148f, -0.00112726f, -0.04605427f, 
    -0.01758706f, -0.08388086f, -0.03661844f, 0.02513899f, 0.15034841f, -0.05254356f, 0.11067089f, -0.01416673f, 
    0.01012464f, -0.01424196f, -0.10405286f, 0.01547424f, 0.10121647f, 0.03215655f, 0.07714522f, -0.11549488f, 
    -0.01358630f, 0.01058440f, 0.00723573f, -0.00928456f, -0.00436196f, 0.03849076f, 0.03841911f, 0.07655853f, 
    0.09729189f, 0.03856772f, -0.02007563f, 0.05230056f, -0.08467028f, 0.10579791f, -0.03877371f, -0.07511851f, 
    -0.00246250f, 0.00986725f, 0.02978213f, 0.07833272f, 0.05180635f, -0.02247473f, 0.10418154f, 0.05408740f, 
    0.07893047f, 0.08171058f, 0.01946343f, -0.18422344f, -0.16533890f, 0.04822642f, -0.01055673f, -0.00246200f, 
    0.05386136f, 0.09219039f, -0.01444327f, 0.08434888f, -0.03330181f, -0.07003788f, -0.12730357f, 0.06337600f, 
    0.00049890f, -0.08515292f, 0.11273558f, -0.00923917f, -0.06211014f, 0.18500413f, -0.24776545f, -0.13001123f, 
    -0.13313833f, 0.07907739f, 0.06250118f, 0.07941496f, 0.00097047f, -0.12342497f, 0.00151871f, 0.00848782f, 
    -0.09005764f, -0.08981308f, -0.06418400f, 0.03865157f, -0.07958364f, 0.04600855f, 0.09070066f, 0.00133498f, 
    -0.32426795f, -0.07426412f, 0.08500710f, 0.14352596f, -0.31957588f, -0.08308931f, -0.04095983f, 0.02735802f, 
    -0.04852359f, 0.03801616f, 0.00633712f, 0.04504172f, 0.11967400f, 0.01145379f, -0.03602424f, -0.07309521f, 
    -0.08562860f, -0.11231028f, 0.01775273f, 0.07163948f, -0.02572678f, -0.11280435f, -0.04516497f, 0.05175539f, 
    0.04953678f, -0.04866223f, 0.02258973f, -0.00120951f, 0.00226710f, 0.08597608f, -0.01751990f, 0.10955568f, 
    0.10308391f, 0.03272995f, 0.14603014f, 0.02792486f, 0.05884649f, -0.01523215f, 0.03591470f, -0.09098370f, 
    -0.00630297f, 0.30862308f, 0.06449220f, -0.10032329f, -0.07458818f, 0.13995424f, -0.00175462f, 0.05178976f, 
    -0.04984333f, -0.01697299f, 0.15184863f, -0.00076657f, -0.11865722f, -0.02493100f, -0.03306133f, 0.12762837f, 
    0.00175240f, 0.12739620f, -0.02668608f, 0.07437193f, 0.02324109f, 0.04582712f, -0.06388900f, 0.05528837f, 
    0.01062288f, -0.02379496f, 0.03015626f, -0.11244036f, 0.03887609f, 0.04429650f, 0.00935587f, -0.04633937f, 
    -0.00692573f, 0.05625788f, 0.04982213f, -0.10769846f, -0.03222198f, 0.09760761f, -0.04467482f, -0.09369513f, 
    0.10315081f, -0.05159377f, -0.05794973f, 0.17681289f, -0.24726714f, -0.10558526f, -0.00567803f, -0.09122901f, 
    0.04531252f, 0.00224071f, 0.02722129f, 0.05875714f, 0.00133257f, 0.10640445f, 0.05719578f, -0.07959048f, 
    0.01210451f, 0.05266936f, 0.08369850f, -0.05801072f, -0.01723543f, -0.06159866f, 0.01428449f, 0.08388142f, 
    -0.05698082f, 0.01947913f, 0.07577724f, 0.02722465f, 0.02146731f, -0.01795176f, -0.10962768f, -0.04466002f, 
    0.02858166f, 0.04870810f, 0.05256098f, -0.11326007f, -0.13334526f, 0.07599082f, 0.02944596f, 0.00889594f, 
    0.10552933f, 0.09129862f, 0.01326668f, 0.03893098f, -0.18109080f, -0.14545318f, 0.08841471f, -0.07023599f, 
    0.02539891f, 0.00642556f, -0.02558425f, -0.01060314f, 0.04415918f, 0.01925059f, 0.06699775f, -0.02697681f, 
    -0.04538338f, 0.08554018f, 0.06313545f, 0.00404430f, -0.21945401f, -0.00741471f, -0.05353690f, -0.05126264f, 
    -0.07920098f, 0.06187808f, 0.06967484f, 0.02124773f, 0.03432417f, -0.14439274f, 0.06689909f, -0.05501413f, 
    0.02457766f, -0.05121302f, -0.03829722f, 0.14027733f, 0.04369626f, 0.03262222f, -0.03130770f, 0.02983740f, 
    -0.19266054f, 0.03731379f, 0.11421271f, 0.03109521f, -0.23142402f, 0.00934067f, -0.02975368f, 0.03754304f, 
    -0.01235165f, 0.01363591f, 0.05722772f, -0.04431818f, -0.01905484f, -0.00878642f, -0.04617595f, -0.06524169f, 
    0.03145049f, 0.15064652f, -0.01008976f, -0.00588126f, 0.13393600f, 0.08059247f, -0.02314835f, 0.00294242f, 
    0.11189350f, 0.00565796f, -0.00403290f, -0.04087097f, 0.07045068f, -0.06509937f, -0.03150313f, 0.00080549f, 
    0.08868213f, 0.12253219f, 0.13236454f, -0.07630280f, -0.02495554f, 0.03161310f, -0.24610561f, 0.03448699f, 
    0.05153969f, 0.02083951f, -0.05688378f, 0.16165277f, 0.20650756f, -0.06630878f, 0.02739967f, -0.00712211f, 
    0.11930370f, -0.00514996f, 0.02345697f, -0.11094870f, 0.03235380f, 0.11011334f, 0.10503411f, 0.00232182f, 
    0.13033596f, -0.08794034f, -0.07810993f, -0.04427912f, -0.13848282f, -0.09407096f, 0.10665760f, 0.03794846f, 
    -0.03677547f, 0.00364701f, -0.02750961f, 0.02063861f, 0.04735489f, -0.02657043f, 0.06552320f, 0.04034250f, 
    -0.01639804f, 0.06530258f, -0.00081402f, -0.04267682f, -0.07874407f, -0.03575896f, -0.05103662f, 0.02796634f, 
    -0.54445285f, -0.04411786f, -0.17349108f, -0.11974183f, 0.02073340f, 0.00521465f, 0.06846114f, 0.01760378f, 
    -0.00954174f, -0.04357186f, 0.04919231f, -0.09085826f, 0.08116570f, -0.08937512f, 0.07800396f, -0.11491857f, 
    0.08073485f, -0.20336141f, -0.04476145f, 0.02898569f, 0.06114633f, 0.04120245f, 0.05615532f, 0.19493118f, 
    0.05085780f, -0.06114221f, -0.09179451f, -0.00088450f, 0.02807220f, 0.05878463f, -0.02544789f, -0.07681241f, 
    -0.00050789f, 0.16351761f, 0.08771603f, 0.01204429f, 0.06408971f, -0.11458979f, -0.01094539f, 0.02939089f, 
    -0.02145301f, 0.00978773f, 0.06853691f, 0.06696203f, 0.09605870f, -0.00542487f, 0.01855198f, 0.10327964f, 
    -0.00297960f, 0.14210783f, 0.07044404f, -0.07032056f, -0.00573045f, -0.01317838f, -0.05914071f, -0.00188144f, 
    0.09474303f, -0.11734316f, 0.09258064f, -0.02481532f, -0.17402919f, 0.01220558f, 0.30954379f, -0.02195559f, 
    -0.26045546f, 0.10706466f, 0.02900891f, -0.01574673f, 0.02032317f, -0.01741778f, 0.09130868f, -0.06020570f, 
    -0.08164935f, -0.13875239f, -0.15292130f, -0.07419372f, 0.06892808f, 0.10489144f, 0.04643292f, -0.01146352f, 
    -0.49558976f, -0.11638965f, -0.21015713f, -0.10727440f, -0.01407360f, 0.05050440f, 0.08114847f, -0.01159720f, 
    0.02112344f, -0.09743471f, 0.07074924f, 0.04502713f, 0.07691297f, 0.01911552f, -0.02518515f, -0.01595552f, 
    -0.03231949f, -0.09574917f, 0.00673991f, -0.00161301f, -0.00165285f, 0.01238297f, -0.06608257f, 0.07589307f, 
    0.12513542f, 0.01181510f, -0.07514157f, -0.03195586f, 0.02834640f, -0.00156139f, -0.01945923f, 0.05025376f, 
    0.15792492f, 0.09566016f, 0.02981405f, 0.04657932f, -0.04402799f, -0.05330415f, -0.16479176f, 0.00142018f, 
    -0.14876871f, -0.06660452f, 0.02832623f, 0.10053516f, 0.04214992f, -0.07154191f, -0.02678119f, -0.06335361f, 
    -0.01085961f, 0.04330391f, -0.01536493f, 0.17185807f, 0.06435935f, 0.04500630f, -0.03972122f, -0.01542728f, 
    0.04293561f, -0.18552619f, -0.06861819f, -0.02393711f, 0.16837426f, 0.10582905f, -0.00449940f, 0.07384393f, 
    -0.07485723f, -0.11811561f, -0.07142075f, -0.02219958f, 0.00874622f, 0.08553974f, -0.00319499f, -0.17300232f, 
    -0.02848191f, 0.14710622f, -0.00501313f, 0.04916507f, -0.00554496f, -0.02150044f, -0.06930885f, 0.10350432f, 
    -0.13307688f, 0.16798006f, -0.28035301f, -0.12435815f, 0.00076104f, 0.04332082f, 0.05092268f, 0.01059856f, 
    -0.08910514f, -0.09104103f, -0.05492679f, 0.00260516f, -0.01720784f, -0.09071296f, 0.00756333f, -0.03464536f, 
    0.04473566f, -0.00487750f, 0.05393137f, -0.04727350f, -0.35385171f, -0.18096702f, -0.13453743f, -0.11901913f, 
    -0.04399446f, 0.07042489f, -0.06277402f, 0.02680030f, 0.01546765f, -0.13890921f, -0.00900643f, 0.05741917f, 
    -0.01923351f, 0.00612259f, -0.02639101f, 0.05980276f, -0.02468357f, 0.00911667f, -0.05983566f, 0.02074875f, 
    -0.00113307f, 0.04009916f, -0.02227448f, 0.03298904f, 0.01054633f, -0.05511022f, 0.01737997f, 0.00255610f, 
    -0.02246882f, 0.00873520f, 0.01627355f, 0.04847559f, 0.01096215f, -0.08460733f, -0.00604149f, 0.03286633f, 
    0.06937622f, 0.11224448f, 0.04808034f, 0.06185293f, 0.01654298f, 0.04867326f, -0.13483411f, 0.07017521f, 
    0.23299421f, 0.07214209f, -0.07407895f, 0.02392355f, 0.04593218f, 0.00031296f, 0.07324265f, 0.06463617f, 
    0.01359016f, 0.05118641f, 0.15879464f, 0.01131760f, -0.00617316f, -0.07591679f, -0.12806743f, -0.03152273f, 
    0.00879320f, -0.02727483f, -0.07972757f, 0.08577015f, 0.21997246f, -0.06139873f, -0.14088035f, 0.02148563f, 
    -0.02149396f, 0.07395758f, 0.05708128f, -0.01871447f, 0.00537272f, 0.02400545f, -0.05131854f, 0.05098933f, 
    -0.01717697f, -0.16188982f, -0.00140020f, 0.06389451f, -0.17989029f, 0.03258577f, -0.12814182f, -0.22804950f, 
    -0.02637394f, 0.06506578f, 0.06701323f, -0.08350165f, 0.03784655f, 0.06259716f, 0.06839707f, 0.02279616f, 
    0.10277944f, -0.10870194f, -0.08315503f, -0.01811142f, 0.06144938f, -0.08864930f, 0.14059944f, -0.04116841f, 
    0.10402168f, -0.16443466f, 0.03691442f, 0.04600635f, -0.04545784f, -0.05683451f, 0.06545283f, -0.00703444f, 
    0.00922212f, 0.00560259f, -0.07048660f, -0.04381945f, -0.02569515f, -0.05450386f, -0.02930842f, 0.01469501f, 
    -0.07717252f, -0.12205502f, 0.00173915f, 0.01392310f, -0.35293889f, 0.13736676f, -0.19282745f, -0.05155368f, 
    0.04547992f, 0.12068751f, 0.03416288f, 0.02522301f, -0.05759093f, -0.12052109f, -0.06617472f, -0.05416630f, 
    0.01398344f, -0.07285994f, -0.01866109f, 0.05702781f, -0.00228265f, -0.07399967f, 0.01547830f, -0.02603726f, 
    0.03361842f, -0.08910420f, 0.08400417f, 0.05721103f, 0.19375175f, -0.09970699f, -0.10120989f, 0.00300790f, 
    0.06559596f, 0.01307789f, -0.10245065f, -0.09020597f, -0.01586542f, 0.07347294f, 0.13765737f, 0.06249016f, 
    0.14660335f, -0.12256638f, -0.07827512f, -0.06481373f, -0.01759549f, 0.05011445f, 0.00803731f, 0.10283387f, 
    0.10155871f, -0.01741489f, 0.03160765f, 0.11763319f, -0.04693384f, 0.06943528f, 0.04317785f, -0.13706008f, 
    -0.00310964f, 0.00498570f, -0.01581696f, 0.03152936f, 0.06501810f, -0.06163178f, 0.05270945f, 0.02559971f, 
    -0.00176187f, -0.05386623f, 0.06130907f, 0.25709528f, -0.18705054f, -0.01175512f, -0.02171038f, -0.06717783f, 
    0.12720445f, -0.06581198f, -0.05152209f, 0.00472350f, 0.01820871f, 0.06877426f, 0.11133014f, -0.01107820f, 
    -0.07680640f, -0.07927784f, -0.00581602f, -0.11621995f, -0.21312037f, 0.00329319f, -0.13294485f, -0.15047179f, 
    0.06228016f, 0.11284310f, -0.03584697f, -0.00493144f, 0.01185732f, -0.08982790f, 0.07660561f, 0.05598792f, 
    -0.12570795f, 0.01244015f, -0.07226176f, 0.06117566f, -0.04002899f, -0.02644438f, -0.04818676f, -0.00306465f, 
    0.14962642f, 0.03924216f, 0.04762970f, 0.06467520f, -0.03317047f, -0.10485788f, -0.02798387f, -0.09775010f, 
    0.01489060f, 0.07706849f, 0.01864099f, 0.02533405f, 0.11925294f, 0.02508421f, -0.02634858f, -0.01687647f, 
    -0.09426248f, 0.03887640f, 0.12101635f, 0.01512369f, -0.00934664f, 0.04831320f, -0.03925866f, -0.06887944f, 
    0.04529874f, -0.01143832f, 0.10755764f, -0.07242771f, -0.03677221f, -0.01690743f, 0.09254036f, 0.06578948f, 
    -0.03956620f, -0.03960239f, 0.03990591f, -0.14546871f, -0.05134017f, 0.15271738f, -0.06040684f, -0.07531093f, 
    -0.17019753f, 0.03222157f, -0.01424574f, 0.17209138f, 0.09415062f, 0.00330026f, -0.06939129f, 0.06619366f, 
    0.01213628f, 0.12139282f, 0.12546656f, -0.01865410f, -0.02346843f, -0.08958664f, 0.03996037f, 0.01529505f, 
    0.03247711f, -0.02726665f, -0.01894685f, -0.09657714f, -0.33883044f, -0.19930181f, 0.16332528f, 0.06240848f, 
    -0.22227436f, -0.14461154f, -0.03846767f, 0.10075600f, -0.08008204f, 0.00357350f, -0.07293789f, -0.00107296f, 
    0.02354146f, -0.14824609f, -0.00835730f, -0.08790478f, 0.00073761f, -0.03087474f, 0.03690845f, 0.06030411f, 
    -0.26719081f, -0.41154164f, -0.08597441f, 0.08039251f, -0.07281089f, 0.03254280f, 0.01023662f, 0.05583896f, 
    -0.05227885f, 0.08073769f, 0.05614549f, 0.04700491f, 0.01964389f, 0.11011613f, -0.08053714f, 0.03907103f, 
    -0.02904183f, 0.01742731f, -0.05869210f, -0.04173119f, -0.02053722f, 0.10788423f, -0.12236603f, 0.00650132f, 
    -0.00057312f, 0.08722886f, 0.03936607f, 0.06808354f, -0.11020953f, 0.10322590f, -0.03711601f, -0.01875181f, 
    -0.02165232f, -0.07601209f, -0.06209137f, -0.03560468f, -0.02009239f, 0.04741213f, -0.04172987f, -0.04747890f, 
    -0.12129386f, 0.11940413f, -0.02337054f, 0.09436868f, 0.11927687f, -0.07702996f, 0.01317096f, 0.01155725f, 
    -0.02622701f, -0.02278348f, 0.06399238f, 0.04937651f, -0.03826822f, 0.05141511f, -0.01552419f, 0.05472110f, 
    -0.07093657f, 0.02420644f, 0.07344732f, -0.14315955f, 0.07019510f, 0.17414114f, 0.06785226f, 0.18460749f, 
    0.22403286f, 0.04080855f, 0.06236306f, 0.06246235f, 0.09891617f, 0.02743646f, 0.02740069f, 0.09919451f, 
    0.05422042f, -0.02951445f, -0.02180363f, -0.14611977f, 0.13220023f, -0.01523215f, -0.08080804f, -0.04146687f, 
    -0.29739362f, -0.29644737f, -0.09333270f, -0.03897855f, -0.07242255f, 0.08213215f, 0.00330252f, -0.03131294f, 
    0.02652379f, -0.01914611f, 0.04427181f, 0.01490749f, -0.06499472f, 0.04990841f, 0.01340459f, -0.07183343f, 
    0.02545165f, -0.00932570f, -0.10843058f, 0.12594311f, -0.26081777f, 0.00642108f, 0.12752435f, 0.22148672f, 
    -0.15213516f, -0.01004137f, -0.13171846f, -0.02771562f, -0.12139555f, 0.17676713f, 0.05511450f, -0.02294379f, 
    -0.06226127f, -0.01927570f, -0.15926245f, 0.02541005f, -0.00842632f, -0.09901738f, -0.00225715f, 0.09543713f, 
    -0.44178003f, -0.16181882f, -0.12412234f, -0.12126259f, 0.03425037f, -0.03892661f, 0.03950313f, 0.00753054f, 
    -0.03228807f, -0.01808405f, 0.00160104f, 0.06385696f, 0.05642589f, 0.00566631f, 0.05293303f, -0.01288324f, 
    0.04345967f, -0.09306206f, -0.03609580f, -0.00878115f, -0.31773978f, -0.06451020f, -0.10472668f, -0.12808934f, 
    -0.00522982f, 0.10612614f, -0.04871349f, -0.05380243f, 0.01189430f, -0.07178332f, -0.02535344f, -0.00506479f, 
    -0.08864245f, 0.05676872f, -0.00844259f, 0.04595719f, -0.01681869f, -0.01668943f, -0.06022368f, 0.01396960f, 
    0.05445917f, -0.04062108f, -0.00272284f, -0.06973664f, -0.15487391f, -0.01095540f, -0.10195175f, 0.01560901f, 
    0.06070824f, 0.05006021f, -0.03636954f, -0.00786185f, 0.00332026f, 0.01972697f, 0.05851830f, 0.03129856f, 
    -0.03896595f, -0.02194931f, -0.13175774f, 0.03391466f, -0.22079082f, 0.05027074f, -0.05955903f, -0.16079001f, 
    -0.03756675f, -0.03548972f, 0.06051498f, 0.10596913f, -0.07772993f, -0.06108399f, -0.02593221f, 0.00105292f, 
    0.02909194f, -0.18071483f, -0.03083728f, 0.04575717f, 0.05617203f, -0.11096781f, -0.05744739f, 0.03970651f, 
    0.23387726f, 0.04698007f, 0.08038477f, -0.01820911f, 0.04545907f, -0.06264693f, 0.09077161f, -0.00825843f, 
    -0.07167240f, 0.02672962f, 0.03539295f, 0.05671080f, -0.00897464f, 0.06118657f, 0.02119214f, 0.05565128f, 
    -0.04769659f, 0.09183615f, 0.03440290f, 0.01767544f, -0.19908693f, -0.12406955f, 0.06571829f, -0.00982617f, 
    -0.09799606f, 0.07306664f, 0.02270922f, 0.00904674f, 0.06291321f, -0.03430748f, 0.02867847f, -0.01370731f, 
    -0.01008352f, 0.05962004f, -0.04401088f, -0.05780561f, 0.11400363f, 0.07755959f, 0.03860290f, 0.04654822f, 
    0.13998251f, 0.00042368f, 0.05523990f, -0.02022037f, -0.08870593f, 0.00649565f, -0.03726517f, 0.10260563f, 
    -0.02351415f, 0.04556259f, -0.03452902f, -0.04278826f, -0.08293942f, -0.05931299f, -0.05809821f, -0.03402011f, 
    -0.02989592f, 0.04052748f, 0.07430840f, 0.02841068f, 0.17728643f, -0.34070486f, -0.09560809f, 0.11086537f, 
    0.00900382f, 0.01212608f, 0.08339712f, -0.02836184f, 0.01657296f, 0.06503428f, -0.00253470f, 0.02531713f, 
    -0.03547788f, 0.00519672f, 0.07974067f, 0.05336665f, 0.02359585f, -0.03084405f, -0.05693891f, -0.02342087f, 
    -0.18508704f, -0.17165208f, -0.01261734f, -0.36004528f, 0.07096819f, 0.01399050f, -0.10427941f, 0.11392706f, 
    -0.00462124f, -0.01782466f, 0.00568328f, -0.03415297f, -0.01530862f, 0.00341085f, -0.06515581f, 0.00765463f, 
    0.00542239f, -0.03035291f, 0.14269136f, -0.02885881f, 0.04714318f, -0.16731071f, -0.12934832f, 0.02161247f, 
    -0.07814850f, -0.06489809f, 0.01603583f, 0.00478558f, 0.02650950f, 0.02555754f, -0.05104642f, -0.01550477f, 
    -0.00918942f, 0.06117806f, 0.09892149f, 0.16751882f, -0.02862791f, -0.05481732f, -0.10831863f, -0.01942801f, 
    0.01307784f, -0.32303572f, -0.00093394f, 0.03874216f, 0.18643828f, 0.03081296f, 0.02564602f, -0.00667653f, 
    0.04927118f, 0.01665955f, -0.04768002f, -0.04769656f, 0.08215793f, 0.09038315f, 0.10040732f, -0.03852946f, 
    -0.01200106f, -0.11331224f, -0.15112075f, -0.08589835f, -0.03558003f, 0.16684499f, 0.01629592f, 0.16158170f, 
    -0.19003125f, -0.02189033f, -0.03428068f, 0.02123562f, 0.03256388f, 0.00423579f, 0.03533939f, 0.00097170f, 
    0.01700797f, 0.02784672f, -0.02607695f, -0.04722643f, -0.02710152f, -0.06752557f, -0.07273896f, 0.04603397f, 
    -0.22854917f, 0.26024494f, 0.08805812f, 0.00764681f, -0.12777863f, 0.00286713f, 0.04947675f, 0.02116790f, 
    0.07513213f, 0.05286252f, -0.05503729f, 0.03019939f, -0.03119178f, -0.07389574f, 0.03323709f, 0.01447241f, 
    0.02382489f, -0.08679495f, 0.06663735f, -0.09838209f, 0.14060900f, -0.17242765f, 0.07924706f, -0.01275927f, 
    0.18625568f, 0.08696453f, -0.04784489f, 0.00847874f, 0.07365275f, -0.01379813f, 0.02325076f, -0.04917839f, 
    0.09003672f, -0.01084302f, -0.05966159f, 0.04589820f, 0.03475287f, -0.00695719f, 0.00950203f, 0.06944478f, 
    -0.10653935f, 0.18446925f, 0.09595052f, -0.06435147f, 0.01436799f, -0.06695683f, -0.15782692f, 0.05780674f, 
    -0.01214941f, 0.09294499f, 0.02533019f, 0.04671646f, 0.01230097f, -0.03573601f, -0.04238637f, -0.01772477f, 
    -0.07627140f, 0.02410656f, 0.01901367f, 0.01063447f, 0.05388855f, -0.03322788f, 0.05070582f, 0.04020220f, 
    0.15796834f, -0.10805473f, 0.05929121f, -0.02655404f, 0.06106146f, -0.03638099f, 0.06788348f, 0.05038766f, 
    0.03091381f, 0.02107684f, 0.01437573f, 0.08387165f, 0.00227613f, 0.10322344f, -0.06986748f, 0.02154646f, 
    0.02222342f, -0.05432592f, -0.15255210f, 0.16705747f, 0.00929925f, 0.00311834f, 0.01315943f, 0.01652320f, 
    -0.01299409f, 0.02798304f, 0.04194552f, 0.04328871f, -0.00100165f, -0.00048586f, -0.00950906f, -0.02273248f, 
    0.01627378f, 0.07185643f, -0.02062097f, 0.07452599f, -0.13901715f, 0.16285658f, -0.09446484f, 0.01180550f, 
    0.10053680f, -0.14085321f, -0.07415392f, 0.01576217f, 0.00751493f, -0.01691355f, 0.01508861f, 0.06368392f, 
    0.02024203f, -0.02290207f, 0.01127494f, -0.02075244f, -0.09136019f, 0.05776582f, -0.04802368f, 0.06717587f, 
    -0.11364470f, 0.19150946f, 0.11416055f, 0.05383909f, -0.23107880f, 0.07046469f, 0.02127901f, 0.03575221f, 
    0.06925421f, -0.03941962f, -0.05475667f, -0.00151120f, -0.01415446f, 0.03876962f, 0.01314625f, 0.02924944f, 
    -0.04218594f, -0.09019011f, 0.00666130f, 0.02752098f, -0.28445855f, 0.21634834f, -0.12325886f, 0.20774141f, 
    -0.23648565f, 0.01739938f, 0.07445107f, -0.02465246f, 0.04134830f, 0.02889255f, 0.02850397f, 0.07846086f, 
    -0.00583902f, -0.03837689f, -0.10559910f, -0.01644203f, -0.11110102f, -0.01656611f, -0.02930408f, -0.04466969f, 
    0.07480509f, 0.01500652f, -0.14022738f, 0.07441900f, -0.00319189f, -0.10115562f, 0.09337614f, -0.03402412f, 
    -0.03906736f, -0.04472012f, 0.02124191f, 0.00476361f, 0.03385541f, 0.00035730f, -0.00628263f, -0.08305291f, 
    -0.02760295f, 0.08653470f, 0.01439275f, -0.03362286f, 0.16051495f, -0.37749809f, -0.02716467f, -0.19624844f, 
    -0.01276918f, -0.00582310f, 0.02586694f, -0.00419622f, -0.08428816f, -0.02879816f, -0.03953182f, -0.02442014f, 
    0.11766826f, 0.02714015f, 0.04775330f, -0.00949356f, -0.00073515f, -0.04995899f, -0.03870831f, -0.01722688f, 
    0.13973579f, -0.05639475f, 0.09738099f, 0.19473818f, 0.31076640f, 0.07765370f, 0.09870028f, 0.03833646f, 
    0.06397305f, -0.07474072f, -0.08773555f, -0.00020368f, -0.13714626f, -0.06771328f, -0.00843081f, 0.01001566f, 
    0.11675992f, 0.11989386f, 0.06497306f, 0.08529942f, 0.11381601f, -0.13215937f, -0.08442678f, -0.00844508f, 
    0.05072255f, 0.08314323f, 0.01809506f, -0.02540179f, -0.07099898f, -0.08264827f, 0.05131341f, -0.01981011f, 
    -0.05174604f, -0.04359116f, -0.10075656f, -0.04164320f, -0.08225273f, 0.01858734f, -0.01951486f, 0.11478994f, 
    -0.00611595f, -0.24357007f, -0.11243585f, 0.12692030f, -0.11811741f, -0.13640568f, -0.03205264f, -0.06357127f, 
    0.05389643f, 0.07723209f, -0.01175620f, 0.00860503f, 0.14943087f, -0.04217938f, 0.07924175f, 0.03568588f, 
    -0.05545137f, -0.06663820f, -0.08554517f, -0.16791895f, -0.05441394f, 0.09953777f, 0.05579336f, -0.07125848f, 
    -0.06740683f, 0.02976516f, 0.01175816f, 0.10280070f, 0.00358948f, -0.06973630f, -0.04727803f, -0.03365672f, 
    -0.00613070f, -0.03280926f, -0.02103765f, 0.08454383f, 0.02126489f, -0.05907725f, 0.03608485f, 0.03281701f, 
    -0.02634661f, 0.10875504f, 0.13431078f, -0.03456510f, -0.09991153f, 0.09199373f, -0.05164999f, 0.08641107f, 
    -0.03242391f, -0.05258736f, -0.01751376f, -0.00554556f, 0.00997500f, -0.01053365f, -0.06487358f, 0.01300934f, 
    -0.02660228f, 0.00208179f, -0.00177812f, -0.07016772f, -0.19055657f, 0.17227221f, 0.11935487f, 0.03983025f, 
    -0.40723920f, -0.02579387f, -0.01533010f, 0.02938608f, -0.00334286f, 0.08627909f, -0.01066709f, -0.01402113f, 
    0.02047409f, 0.03681467f, -0.07609989f, 0.05637775f, 0.04411710f, -0.03040075f, -0.02937943f, -0.04219785f, 
    -0.24616247f, 0.22785448f, 0.04279007f, 0.08299094f, -0.16547240f, 0.03849116f, -0.04748318f, 0.02213438f, 
    0.03223190f, 0.03866845f, 0.06241010f, 0.05638631f, 0.01375585f, -0.00289655f, -0.03619558f, -0.00268000f, 
    0.06469845f, -0.06983051f, -0.00693692f, -0.00392394f, 0.13627887f, -0.37348422f, -0.06356900f, -0.10105923f, 
    0.00558691f, -0.09099907f, 0.05709468f, -0.05505922f, -0.08736086f, 0.04833725f, -0.06770890f, 0.00680325f, 
    0.02346231f, 0.12089521f, 0.01130415f, -0.07252768f, 0.01162071f, -0.06652012f, -0.02217140f, -0.06838015f, 
    0.21167260f, -0.30599308f, -0.05356548f, 0.12886088f, -0.05401796f, -0.03577380f, -0.01417106f, -0.00955863f, 
    0.04776223f, 0.04109982f, 0.00952094f, -0.00913639f, -0.01499872f, -0.02873841f, 0.07087273f, -0.04692280f, 
    -0.02100842f, -0.03131947f, -0.02574394f, -0.00681907f, 0.19582771f, -0.14599279f, -0.17136042f, -0.22195818f, 
    0.03937134f, -0.00815697f, -0.02484750f, -0.00955463f, -0.07139715f, 0.04115828f, -0.01529790f, 0.02712770f, 
    -0.10451955f, -0.10139680f, -0.03502198f, 0.03658970f, 0.04457944f, 0.01394035f, 0.10293791f, 0.01894442f, 
    0.02227782f, 0.11117707f, 0.05884138f, -0.11225398f, -0.12648648f, -0.02828182f, 0.00774252f, 0.05537253f, 
    -0.04458128f, 0.00603554f, -0.05908391f, 0.03116124f, -0.13459146f, -0.03830378f, -0.04340163f, 0.05511039f, 
    -0.09438354f, 0.07138861f, 0.06861559f, 0.02235913f, -0.05306086f, -0.09730390f, 0.03088320f, 0.13405025f, 
    0.08190338f, 0.08618512f, 0.01598778f, 0.06206309f, 0.01059108f, -0.01368516f, -0.07759085f, 0.01131566f, 
    0.01949889f, 0.02973416f, 0.00130112f, -0.01179959f, 0.02776104f, 0.11189988f, 0.07754437f, -0.00156568f, 
    -0.09155305f, 0.10337841f, -0.02348407f, -0.18950231f, 0.10619606f, -0.07380464f, 0.00042525f, -0.05408312f, 
    -0.11291210f, -0.09865762f, 0.00199598f, 0.00030407f, 0.02098820f, 0.04510443f, 0.05507247f, 0.06062214f, 
    -0.04724091f, 0.03984073f, -0.00994471f, 0.08301564f, 0.05841083f, 0.13107331f, 0.00316632f, -0.10497060f, 
    -0.06689147f, 0.02379987f, 0.00180912f, 0.00051020f, 0.05039563f, 0.02013585f, -0.07997520f, 0.02226436f, 
    -0.05877820f, -0.00274430f, -0.11998253f, 0.08185646f, -0.03819818f, 0.07784652f, 0.07120319f, -0.03880128f, 
    -0.13882130f, 0.02347286f, -0.06605499f, 0.10817698f, -0.04561762f, -0.04518629f, 0.05949214f, 0.00520160f, 
    0.00385815f, 0.02237949f, -0.09291069f, 0.03800652f, -0.00145197f, -0.00476301f, -0.04713413f, 0.02242235f, 
    -0.04637346f, 0.01854930f, -0.12958585f, -0.03460914f, 0.03733084f, 0.04666005f, -0.13286787f, 0.04286180f, 
    -0.19432154f, -0.16458921f, 0.03133681f, 0.04904260f, -0.02330983f, 0.04284522f, -0.04314610f, -0.06756165f, 
    0.06885547f, -0.00881407f, 0.10958190f, 0.09884197f, -0.07535868f, -0.08369647f, 0.02247584f, -0.00380431f, 
    -0.14669807f, -0.14192267f, -0.01486189f, -0.12160674f, 0.10856956f, -0.01041269f, 0.08385456f, 0.05291114f, 
    -0.13569151f, -0.10113582f, -0.00848533f, -0.09359343f, -0.02165863f, 0.05404621f, -0.03060175f, 0.05447391f, 
    -0.01028474f, -0.00020997f, 0.05466973f, 0.04516717f, 0.03648459f, 0.06082762f, -0.09726514f, -0.15840657f, 
    -0.06088546f, -0.05056818f, 0.02717797f, 0.06028965f, 0.00717712f, 0.06650180f, -0.00209335f, -0.11762916f, 
    -0.09831720f, -0.00295881f, -0.01143273f, 0.01428106f, 0.00300617f, 0.06992368f, 0.07720201f, 0.04202102f, 
    0.02022659f, -0.04518527f, -0.03328678f, 0.01306103f, 0.06828768f, -0.01250328f, 0.00925873f, -0.04749570f, 
    -0.06252106f, -0.02678718f, -0.01525546f, -0.10668749f, -0.09587576f, -0.01847135f, 0.05109749f, -0.04681431f, 
    -0.03919511f, 0.05107158f, 0.02852837f, 0.08932611f, -0.07138437f, -0.01027561f, 0.09011363f, -0.04815766f, 
    -0.02976244f, 0.07098462f, 0.11113773f, -0.00049107f, 0.08366895f, 0.00986245f, 0.05734414f, -0.02382357f, 
    0.03682168f, -0.04613878f, 0.03436700f, -0.03493885f, -0.03403097f, -0.01874823f, 0.02555207f, -0.17735778f, 
    0.00930678f, -0.31922302f, -0.00876956f, -0.27517170f, 0.06733809f, -0.07419586f, -0.00113149f, -0.03445454f, 
    0.09962915f, -0.03752188f, -0.02114425f, 0.07357834f, -0.03215815f, 0.03710868f, 0.02428855f, 0.02490934f, 
    0.01439450f, -0.05502355f, -0.10364538f, 0.01044043f, 0.08657955f, -0.13712937f, 0.05050365f, -0.03193087f, 
    0.02464376f, -0.00033737f, 0.01262534f, 0.02170789f, -0.06077735f, 0.08056405f, 0.00434164f, -0.05394284f, 
    0.00277877f, 0.01602788f, 0.07870318f, -0.06458977f, 0.01854047f, 0.00449433f, -0.00993607f, -0.02446534f, 
    0.05692704f, 0.14912200f, 0.10844999f, 0.11865623f, 0.04379449f, 0.08038918f, -0.08197518f, -0.00086711f, 
    0.07094627f, -0.04865011f, -0.08323843f, -0.00834546f, 0.08626784f, 0.06390963f, -0.01609994f, -0.04306368f, 
    0.10445190f, -0.11885516f, -0.03476970f, -0.13774684f, 0.01480091f, 0.01730669f, -0.14952503f, -0.09563719f, 
    -0.02800185f, 0.09578092f, 0.02778104f, 0.00080271f, -0.08626999f, -0.09942506f, 0.01770005f, 0.08600316f, 
    0.05494302f, -0.04250637f, -0.15338014f, 0.04896955f, -0.21097808f, 0.10551645f, -0.00854997f, 0.05006393f, 
    -0.09062430f, -0.01933858f, -0.14901277f, 0.05503728f, 0.04892587f, 0.01731953f, 0.13064481f, -0.03991027f, 
    -0.05963462f, 0.06312191f, -0.00083313f, 0.02927357f, 0.06668227f, 0.04245703f, -0.11454640f, 0.09223923f, 
    0.02013386f, 0.09987406f, 0.04370122f, 0.04048352f, -0.07807714f, -0.24987955f, -0.09683983f, -0.30895036f, 
    0.17756072f, -0.13485374f, -0.03292478f, -0.04785858f, -0.01484625f, -0.11395513f, -0.06454786f, 0.00004966f, 
    -0.06818720f, -0.00356644f, -0.00527464f, -0.07741683f, 0.08110325f, 0.05905352f, -0.00369746f, -0.02761344f, 
    -0.13566159f, 0.05360195f, -0.12174698f, 0.19267428f, -0.18371387f, -0.02074775f, 0.03964625f, 0.04443702f, 
    0.03550675f, 0.01678758f, -0.00760921f, -0.00882172f, 0.00236320f, 0.05996167f, 0.02311895f, 0.04507875f, 
    -0.11690118f, 0.11798417f, -0.02879961f, -0.00065500f, 0.18661006f, -0.29510933f, -0.05554076f, 0.00786518f, 
    -0.02910689f, -0.00031916f, 0.11546856f, -0.01091967f, -0.00192477f, -0.07771607f, 0.06370638f, 0.03130737f, 
    0.04043538f, 0.00802681f, 0.01674999f, 0.07745178f, -0.05751444f, -0.03705376f, -0.03450428f, 0.06813776f, 
    -0.07124012f, 0.16294461f, -0.19147269f, -0.02025274f, -0.08599713f, 0.10218038f, 0.11173341f, -0.04457611f, 
    -0.01900529f, 0.08062451f, -0.01474272f, -0.00126725f, -0.01659474f, 0.03793324f, -0.10381331f, -0.00489999f, 
    0.09269297f, 0.16857465f, 0.05171639f, 0.09889191f, -0.20873201f, 0.10395162f, -0.02367457f, 0.07581639f, 
    -0.07331707f, -0.02754123f, 0.05751878f, -0.05470961f, 0.07247058f, -0.00217991f, -0.05096311f, 0.02766115f, 
    0.01690991f, -0.00078517f, -0.12553705f, -0.02549705f, -0.03968220f, 0.01336460f, -0.07088553f, -0.09137411f, 
    0.04246685f, 0.00213717f, 0.05461884f, -0.05521582f, 0.11777220f, 0.19559906f, 0.05040907f, 0.07575588f, 
    0.01639205f, -0.06577544f, -0.01712928f, 0.06158995f, -0.05982227f, -0.01108930f, -0.15992658f, 0.03438513f, 
    -0.01350539f, 0.09843045f, 0.09078340f, 0.03481182f, -0.04947477f, -0.14514033f, -0.06740334f, -0.17559138f, 
    0.05810540f, 0.04657784f, 0.02954997f, 0.09590878f, 0.00933002f, -0.03812254f, -0.09081289f, -0.05158665f, 
    0.08158877f, 0.04010414f, 0.00147620f, 0.06140829f, 0.00542768f, -0.03697081f, -0.02854975f, 0.16428281f, 
    -0.42477867f, 0.27732357f, 0.11937781f, 0.06128310f, -0.28924054f, 0.09150520f, -0.05072786f, 0.04527070f, 
    0.02632308f, -0.07378950f, 0.00757980f, 0.02208770f, -0.15291779f, -0.00482023f, 0.03531850f, 0.02038729f, 
    -0.02913259f, -0.11168299f, -0.00660907f, 0.00883856f, -0.08936674f, -0.19019638f, -0.14310832f, -0.15049356f, 
    0.26480585f, -0.02285542f, 0.00238611f, 0.05107953f, 0.06678390f, -0.14785145f, -0.03832448f, -0.02440862f, 
    -0.08612324f, 0.04990546f, -0.13046294f, 0.09049159f, -0.03250302f, 0.01139614f, 0.11670747f, 0.09755716f, 
    0.07874064f, -0.12372655f, -0.01802700f, -0.07661510f, 0.20128073f, 0.01287214f, -0.02296214f, -0.02768772f, 
    -0.01418185f, -0.03512372f, -0.08148646f, -0.10651393f, -0.08031767f, -0.08709377f, -0.00164571f, -0.06570107f, 
    -0.09421517f, 0.16973169f, -0.13415436f, 0.08665696f, 0.15586849f, -0.09732538f, 0.00986743f, 0.23154226f, 
    0.16941637f, 0.00206721f, 0.09564254f, -0.00585185f, 0.08042940f, -0.07679167f, -0.00011718f, 0.03076457f, 
    -0.06138985f, 0.02642139f, -0.08747530f, 0.08623177f, 0.09350986f, 0.03960087f, -0.03696849f, 0.05231423f, 
    -0.09424590f, -0.26939878f, -0.08937174f, -0.01080159f, -0.14222439f, -0.00983246f, 0.03298205f, 0.00706917f, 
    -0.03295644f, -0.06376678f, -0.01034562f, 0.05364742f, -0.14374109f, -0.03425419f, 0.07046773f, -0.00678372f, 
    -0.00787956f, 0.07249025f, 0.04204758f, -0.00171735f, -0.09962261f, -0.19606048f, 0.01062504f, -0.23084632f, 
    0.01059845f, 0.02556065f, -0.03736278f, 0.00434002f, -0.06081891f, -0.01467210f, -0.03249068f, -0.02995272f, 
    -0.03588469f, 0.02388818f, 0.00069111f, 0.01501329f, 0.04409806f, -0.00369020f, 0.09151870f, -0.00854528f, 
    0.07365882f, -0.19548117f, -0.12842616f, -0.15355261f, 0.50553602f, -0.05988245f, -0.03859854f, 0.01208100f, 
    0.06950714f, 0.01042626f, -0.12053235f, -0.08162067f, 0.05181493f, 0.02002638f, 0.12452058f, -0.00135480f, 
    -0.01713211f, 0.09336746f, -0.05799294f, 0.18520541f, -0.17726466f, -0.15392610f, -0.25613081f, -0.23583660f, 
    -0.06017730f, 0.01383935f, 0.16915101f, -0.00457493f, -0.01323204f, -0.06472649f, -0.15238625f, 0.05621907f, 
    -0.12184985f, -0.10700121f, 0.09349182f, 0.11515057f, -0.09426031f, 0.04871723f, 0.03086311f, 0.05742436f, 
    0.03864071f, 0.08483642f, -0.00727262f, -0.18724066f, 0.06078105f, 0.01328047f, 0.01000327f, 0.06933592f, 
    -0.06047018f, 0.05818319f, 0.09823824f, -0.03554242f, 0.00335519f, -0.01801987f, 0.07461836f, -0.11243276f, 
    -0.02650721f, -0.02398171f, 0.08444376f, -0.09783869f, -0.09934898f, 0.10455585f, 0.11304974f, 0.13125649f, 
    -0.08225325f, -0.00491609f, -0.10798924f, -0.01992760f, -0.06072494f, 0.02458767f, -0.13654906f, -0.01300852f, 
    -0.05134976f, 0.12200022f, -0.04481507f, -0.00926719f, -0.02547456f, 0.02028170f, 0.04226433f, -0.05732521f, 
    0.04614197f, 0.00069052f, -0.06950539f, -0.10394315f, 0.06685093f, -0.02582889f, -0.02104178f, -0.04835825f, 
    -0.09622322f, -0.02836149f, 0.02891420f, -0.02389584f, -0.07428464f, 0.02955349f, 0.03862103f, -0.07619251f, 
    -0.00261114f, -0.02157948f, -0.01742196f, 0.08416159f, 0.10972182f, 0.05961987f, -0.03961493f, -0.22912936f, 
    0.10584345f, 0.02055072f, 0.02769591f, 0.01580954f, -0.04686119f, -0.05642723f, -0.02572680f, -0.06903320f, 
    0.05885859f, -0.06622326f, 0.00115007f, -0.04778321f, 0.00088657f, -0.01265630f, -0.00373716f, 0.09614427f, 
    0.31729284f, -0.02686430f, 0.09902993f, 0.08712969f, -0.02076690f, 0.07164304f, 0.05873446f, -0.02518956f, 
    -0.05730033f, -0.06638244f, 0.06294909f, 0.01717103f, 0.04653498f, 0.00992301f, 0.03295823f, 0.02106758f, 
    -0.01073985f, 0.04631111f, -0.06429005f, -0.01624662f, 0.14937264f, -0.05651468f, 0.09149428f, -0.03721150f, 
    0.07948329f, -0.12190377f, 0.14485982f, -0.07188354f, -0.00598898f, 0.00598942f, -0.04364821f, 0.13281122f, 
    0.01127121f, 0.04200227f, 0.10763929f, 0.00373781f, 0.03874586f, 0.06397616f, -0.14556576f, 0.08253352f, 
    -0.33050534f, 0.02451878f, 0.02512983f, 0.14343899f, 0.01480542f, -0.04716181f, -0.01762992f, -0.00723046f, 
    -0.04046436f, -0.01676154f, -0.16174348f, -0.09906677f, -0.02201474f, 0.00570826f, 0.06757056f, 0.02152733f, 
    0.00618603f, -0.15842129f, -0.07470309f, -0.07856192f, 0.21987490f, -0.29308698f, -0.10217345f, 0.15380475f, 
    -0.02989813f, -0.04682586f, -0.02001676f, 0.02789202f, 0.01141866f, 0.08321192f, 0.08328018f, -0.00855072f, 
    -0.07412875f, 0.01501956f, 0.01112611f, -0.04421483f, -0.02952962f, 0.00481896f, -0.07683856f, -0.15292540f, 
    0.00084995f, -0.21789722f, 0.05896197f, -0.03363696f, -0.11150313f, 0.00727823f, -0.02307002f, -0.04039631f, 
    -0.03340087f, -0.01443169f, -0.00812762f, -0.00851254f, -0.11960717f, 0.03242173f, -0.06231927f, 0.04364837f, 
    0.03191050f, -0.00768900f, -0.01637275f, -0.02192177f, 0.02500826f, -0.11658304f, -0.01502417f, 0.01295081f, 
    0.07048325f, 0.05909968f, 0.00911977f, -0.05445454f, -0.02391497f, -0.05898278f, -0.02563568f, -0.03514739f, 
    0.00707734f, 0.01035583f, -0.05659790f, -0.01053446f, 0.00086735f, -0.04712331f, -0.03775088f, -0.01549795f, 
    0.08567461f, 0.08469459f, 0.13558482f, 0.11443815f, 0.13575135f, 0.07242295f, 0.07528927f, -0.00149574f, 
    -0.02048405f, -0.01769165f, 0.01164013f, 0.03597146f, -0.02309493f, -0.00029263f, -0.03577431f, -0.02196231f, 
    0.03900069f, 0.03718988f, 0.06021041f, -0.00856168f, 0.07560954f, 0.05806528f, 0.02042990f, 0.04093179f, 
    -0.04194694f, 0.02871208f, 0.02927443f, 0.02076151f, -0.03826400f, -0.03172029f, 0.04934879f, 0.00579177f, 
    0.02244477f, -0.02268195f, -0.01939942f, -0.00180722f, -0.03774300f, -0.00796715f, -0.01919917f, 0.03181176f, 
    -0.09106550f, -0.13279268f, -0.04256505f, -0.07576705f, -0.04069692f, -0.10932674f, -0.04097220f, -0.07133338f, 
    -0.01752733f, -0.07504828f, 0.06252972f, -0.01554655f, -0.03947744f, -0.02847700f, -0.01842748f, -0.02017858f, 
    -0.00601311f, 0.00872196f, -0.01725982f, -0.00946555f, -0.05307015f, -0.04216276f, -0.10452653f, -0.05261452f, 
    -0.10706537f, -0.01062221f, -0.05337882f, 0.00282011f, -0.07030024f, -0.10425679f, -0.02172210f, -0.01843135f, 
    -0.06309245f, 0.04760272f, -0.00914890f, -0.00169778f, -0.02015951f, -0.03194295f, -0.02990756f, 0.00009232f, 
    -0.02367617f, -0.00745228f, -0.19465895f, -0.12748200f, -0.03204390f, -0.07196622f, -0.07528497f, -0.05387962f, 
    -0.02953878f, -0.03755825f, -0.08416443f, 0.04133059f, 0.02049810f, -0.00989614f, -0.04854973f, 0.02252079f, 
    -0.04075279f, -0.06369070f, -0.01252660f, 0.04048340f, 0.06634784f, 0.09865721f, 0.08202862f, -0.10713033f, 
    0.03123971f, -0.06368693f, 0.07292242f, -0.01849188f, -0.03442553f, 0.04247501f, -0.00815540f, 0.06154411f, 
    -0.08611678f, 0.00253502f, -0.02390345f, -0.01712269f, 0.03442968f, 0.02225134f, -0.04335583f, -0.02775768f, 
    0.09627543f, 0.15485710f, 0.07053983f, -0.00290221f, 0.09066312f, 0.05814730f, -0.05901820f, -0.08260313f, 
    -0.00170077f, 0.03079988f, 0.00289905f, 0.00887995f, 0.01347105f, 0.00311399f, -0.05026178f, -0.03326866f, 
    0.00221438f, 0.02317538f, -0.06139398f, 0.01421401f, -0.10927429f, 0.09072295f, 0.01875694f, 0.05717681f, 
    0.01850340f, 0.00898421f, -0.01504645f, 0.02313345f, 0.02878120f, -0.01554249f, -0.01139515f, -0.01030026f, 
    0.01423738f, -0.01614682f, -0.01417797f, -0.01197444f, 0.00752394f, 0.01386818f, 0.02468837f, 0.00385734f, 
    -0.12920165f, 0.08272070f, -0.11919438f, -0.03492719f, 0.01169587f, 0.00814802f, 0.01314822f, -0.13515840f, 
    -0.02524349f, -0.04707395f, -0.01293692f, 0.05685854f, -0.00393785f, -0.04747175f, -0.02119786f, 0.05952226f, 
    -0.04997205f, -0.00113207f, -0.02040230f, -0.00687731f, -0.13011234f, 0.03008894f, -0.24801545f, -0.04508360f, 
    0.09904629f, -0.08169999f, -0.02452644f, -0.01190025f, -0.06747633f, -0.02826687f, -0.07292338f, 0.06333925f, 
    -0.05525412f, 0.01233211f, -0.00861385f, -0.02300317f, -0.08959136f, -0.01396911f, -0.01528757f, 0.00969189f, 
    -0.07694729f, -0.13980316f, -0.13676916f, -0.02587358f, 0.00887366f, -0.05400743f, -0.04088517f, 0.01132508f, 
    0.00722302f, -0.05488993f, -0.00236554f, 0.02653731f, -0.01544783f, -0.03886072f, -0.01349206f, -0.00407182f, 
    -0.09196407f, -0.02596619f, 0.00012159f, -0.03356684f, -0.30322164f, 0.14524874f, 0.08912872f, -0.08183511f, 
    -0.14259464f, 0.02749920f, 0.04604080f, -0.04904120f, -0.00473829f, -0.08688336f, 0.00370942f, -0.00034301f, 
    -0.02096237f, -0.04430847f, -0.02754682f, -0.02169869f, 0.02854645f, 0.00087406f, -0.03977585f, -0.02188524f, 
    0.16360094f, 0.12175822f, -0.01903110f, 0.03570475f, 0.02178023f, -0.03529396f, -0.02210681f, -0.04676677f, 
    0.06621739f, -0.00650519f, -0.09553709f, 0.04898500f, -0.03001510f, 0.00266403f, 0.01440209f, 0.01076431f, 
    -0.07094715f, 0.00155231f, -0.02842309f, -0.03182442f, 0.11079022f, -0.04741378f, 0.10801009f, 0.04897274f, 
    0.11333560f, 0.05894652f, 0.06996456f, -0.00413628f, -0.02302145f, -0.00240917f, 0.01752006f, 0.06614508f, 
    0.00611827f, 0.00247454f, -0.03626684f, -0.04178489f, 0.00284329f, 0.01153439f, -0.00672862f, -0.03890826f, 
    0.07737317f, -0.07756661f, 0.02039465f, 0.13103117f, -0.06393977f, 0.10205207f, -0.05992244f, -0.04835072f, 
    0.06752068f, 0.01278515f, -0.04482586f, 0.07172776f, 0.03949532f, 0.01160130f, -0.07734489f, 0.09491435f, 
    0.05835969f, 0.06759647f, -0.12384615f, 0.06801969f, 0.04777985f, 0.02164298f, 0.07466976f, 0.06515651f, 
    0.06727374f, -0.03040401f, -0.00249077f, 0.00294712f, -0.00646179f, 0.00621519f, -0.00792749f, -0.00152183f, 
    -0.01671763f, -0.03276091f, 0.03138838f, -0.01339848f, -0.04597495f, 0.00645202f, 0.01888334f, -0.01871756f, 
    -0.00860628f, -0.01998767f, 0.01661289f, -0.03341028f, -0.03751874f, -0.00597313f, -0.05733060f, 0.00125074f, 
    -0.05525704f, -0.04862284f, 0.06179153f, 0.00115573f, 0.01596977f, 0.00271964f, -0.08479133f, 0.00693393f, 
    -0.00101685f, -0.00398033f, 0.00057369f, -0.02330908f, 0.05270559f, 0.06309786f, -0.15416257f, -0.02980258f, 
    -0.00794152f, -0.01456673f, -0.07858498f, -0.03889575f, -0.01249932f, -0.01658310f, -0.03775235f, 0.03578535f, 
    -0.02698575f, -0.06171539f, -0.06009631f, -0.00120960f, -0.00905766f, -0.03398515f, -0.01920769f, 0.04369487f, 
    0.08601154f, -0.26034325f, 0.06371643f, -0.08438092f, -0.17754456f, 0.05129338f, -0.00917238f, -0.02992256f, 
    -0.04654245f, -0.03875907f, -0.04093745f, -0.03413784f, -0.10295678f, -0.01676768f, -0.10807100f, -0.06723793f, 
    0.08095489f, -0.03228872f, -0.01506048f, -0.00473854f, -0.08248538f, -0.35396659f, -0.13632445f, -0.08291625f, 
    -0.12692583f, 0.00916889f, -0.02561546f, 0.01847097f, -0.01271335f, -0.11669460f, -0.03224976f, -0.03858814f, 
    -0.00692483f, -0.03280686f, 0.02655177f, -0.01515315f, 0.04151944f, -0.03064655f, 0.02575358f, -0.03687554f, 
    -0.08759298f, -0.17352504f, -0.06870930f, -0.15692133f, -0.16334128f, 0.05737152f, -0.06791030f, -0.02141114f, 
    -0.06179659f, -0.08455990f, -0.01851512f, -0.05841057f, -0.02068809f, -0.03008156f, -0.09457394f, -0.02428347f, 
    0.08108625f, 0.00046416f, 0.02480820f, 0.05682701f, -0.05313530f, 0.01245084f, 0.01418030f, 0.04756761f, 
    0.03920523f, 0.00274089f, 0.02281846f, 0.00471176f, 0.01685109f, -0.05856198f, 0.00469289f, -0.01718031f, 
    0.02087748f, -0.00239678f, -0.02076093f, -0.04374938f, -0.02543305f, 0.02885879f, 0.03236999f, -0.00133836f, 
    0.07750045f, 0.01563923f, -0.00284799f, -0.03876636f, -0.02239970f, -0.00328193f, -0.05244736f, -0.00537794f, 
    -0.01858622f, -0.01267308f, -0.04121123f, -0.00662645f, -0.00946199f, -0.02654473f, 0.03945915f, 0.01054074f, 
    -0.03962613f, -0.00555172f, 0.03398880f, -0.04829080f, 0.14289570f, -0.06825504f, 0.07662503f, 0.04440124f, 
    0.08498170f, 0.05757088f, -0.02505933f, -0.03457291f, -0.01331871f, -0.01605359f, -0.02702080f, 0.01054140f, 
    -0.02026594f, -0.03897091f, 0.03275406f, -0.00681451f, -0.00344085f, 0.00890375f, 0.06049095f, 0.03815806f, 
    0.00854051f, -0.04998299f, -0.12352999f, 0.01705110f, 0.19138162f, -0.09015815f, -0.07954614f, -0.00911409f, 
    0.00005437f, -0.02834170f, -0.07344876f, 0.04188778f, -0.05400852f, -0.04018203f, -0.06416140f, -0.07509311f, 
    -0.02901744f, -0.02494353f, 0.00034551f, 0.06615836f, -0.03922226f, -0.04016842f, 0.10046252f, 0.04985259f, 
    -0.07836283f, 0.08344798f, -0.08932206f, -0.03576063f, 0.00175590f, -0.01686954f, -0.02552622f, 0.00060590f, 
    -0.01268267f, -0.00655671f, -0.02122768f, 0.00572123f, 0.00492237f, -0.00611808f, -0.00828088f, -0.04171615f, 
    -0.11401513f, 0.12885958f, 0.17911319f, 0.00962732f, 0.09216978f, 0.08036485f, 0.04923417f, -0.02857266f, 
    0.01649043f, -0.02508250f, -0.06440604f, 0.03904211f, 0.04489059f, -0.02576130f, -0.05302600f, -0.01312433f, 
    0.00738446f, 0.01494832f, 0.03115544f, -0.03002077f, -0.15347236f, -0.05809385f, -0.04120096f, 0.05221263f, 
    0.02807023f, -0.03267408f, -0.06392505f, -0.10951262f, 0.04854585f, -0.05524560f, -0.01712029f, -0.02301485f, 
    0.04155616f, -0.05903896f, -0.04819638f, -0.02751080f, -0.01419050f, 0.00178871f, 0.00574109f, 0.02694383f, 
    -0.18745123f, 0.06776277f, -0.01243937f, -0.08340234f, -0.04583393f, -0.05777011f, 0.00293643f, -0.06903090f, 
    -0.01491587f, -0.08523037f, -0.01986121f, -0.00967547f, -0.01065970f, 0.00295692f, -0.01618293f, -0.04207790f, 
    -0.00999186f, 0.00695098f, -0.02334917f, -0.04685092f, 0.13827612f, 0.16197497f, -0.07858658f, 0.06530818f, 
    -0.12718114f, -0.01071162f, -0.06563833f, 0.02665538f, 0.03189985f, -0.02005404f, 0.02659841f, 0.08834174f, 
    0.00817084f, 0.05595479f, -0.06083466f, 0.02626990f, -0.08038647f, -0.00602091f, -0.06433094f, 0.02265601f, 
    0.11948283f, -0.01219374f, 0.14909725f, -0.01694929f, 0.03928909f, 0.03181718f, 0.04466489f, 0.00429636f, 
    0.00112730f, -0.00024075f, -0.06149604f, 0.10305138f, -0.01866104f, 0.04977982f, -0.02561602f, -0.10865836f, 
    0.01335757f, 0.01617789f, 0.02901165f, 0.01213623f, 0.08268788f, 0.04528707f, -0.00586567f, 0.02196598f, 
    0.13832049f, -0.05804990f, -0.09252542f, -0.00366048f, -0.04611424f, -0.05907024f, -0.00910496f, -0.00329721f, 
    -0.06554785f, -0.03230301f, -0.05629655f, -0.01391572f, 0.03245499f, 0.01901737f, -0.03195923f, -0.03098945f, 
    -0.16346171f, 0.05890822f, 0.03025802f, 0.04035666f, 0.10296991f, -0.02464983f, -0.07173651f, -0.01904447f, 
    0.00984948f, -0.01150979f, 0.03701816f, -0.01749613f, -0.00286549f, -0.06391241f, -0.03307823f, 0.00560701f, 
    -0.03397945f, 0.05120767f, 0.00596820f, -0.03820318f, 0.07490185f, 0.09982304f, -0.13680519f, -0.08185156f, 
    -0.00855306f, -0.01863252f, -0.02983686f, -0.05716677f, -0.04688362f, -0.02155933f, -0.01627320f, -0.03077663f, 
    0.03391667f, 0.00805538f, -0.05832617f, -0.10873399f, 0.03521076f, -0.01330392f, 0.01376264f, 0.08941881f, 
    0.05192681f, 0.04071898f, 0.18347274f, 0.07989682f, 0.12256827f, -0.03311036f, 0.09289922f, -0.00788627f, 
    0.01956305f, -0.02700442f, -0.00392888f, 0.04981552f, -0.01495418f, 0.00483280f, -0.03286355f, -0.01036469f, 
    0.00722154f, 0.00281934f, -0.00858468f, -0.02750622f, 0.05385610f, 0.00805380f, 0.08185225f, 0.00302429f, 
    0.10258312f, -0.06194122f, -0.00937484f, -0.08432225f, -0.03604117f, -0.03760474f, -0.00825083f, 0.01906072f, 
    -0.03610948f, -0.00277315f, -0.02597827f, -0.01711008f, -0.02270964f, -0.00651076f, 0.04858115f, -0.05086973f, 
    0.01182209f, -0.15448003f, -0.04145814f, -0.07548387f, -0.14827451f, -0.05369067f, -0.01174625f, 0.02451892f, 
    -0.02856502f, -0.04159036f, -0.02293370f, -0.01184112f, -0.00217109f, 0.02034944f, -0.02203260f, -0.02062329f, 
    0.05034688f, -0.00676040f, 0.00624580f, -0.00777947f, 0.08736108f, -0.04209669f, 0.06302595f, 0.07081939f, 
    0.14268106f, 0.05414937f, 0.05189607f, 0.02470388f, -0.00105878f, 0.01408408f, -0.07349148f, 0.01357839f, 
    -0.06209386f, -0.10216556f, 0.04462321f, -0.02171986f, -0.07028999f, 0.02888039f, -0.01206300f, 0.02070975f, 
    -0.05951487f, 0.11483657f, -0.08289421f, -0.03492426f, 0.03211964f, -0.04501171f, 0.07790499f, -0.07962141f, 
    -0.03209303f, -0.04719060f, -0.05002157f, -0.03796997f, -0.02087514f, -0.06167307f, -0.07254626f, -0.00621637f, 
    -0.02203884f, 0.04336398f, 0.00505521f, -0.01766821f, 0.08465403f, 0.15188277f, 0.11293866f, 0.09328471f, 
    0.17963621f, -0.04800425f, 0.07308990f, -0.00148934f, -0.02753255f, 0.01537112f, -0.01125328f, 0.01943091f, 
    -0.09776029f, -0.02091094f, -0.01414049f, 0.02634487f, 0.02433439f, 0.03372298f, -0.01796522f, -0.02285387f, 
    -0.18922000f, 0.11233902f, 0.04951736f, -0.00809119f, 0.01892792f, -0.06554535f, -0.05742632f, -0.02727119f, 
    0.00161144f, -0.07602786f, 0.02108323f, -0.02759741f, 0.02078651f, 0.03750662f, -0.05099952f, 0.03620349f, 
    0.01561826f, -0.01710677f, -0.03042813f, -0.03299968f, 0.00361317f, 0.09467469f, 0.18899089f, 0.05435846f, 
    0.09827010f, 0.00073461f, 0.12872699f, 0.02142977f, 0.05274414f, -0.04398466f, 0.00486043f, -0.03531618f, 
    0.02485149f, 0.01209528f, -0.03910027f, -0.03902700f, -0.00138635f, 0.00285900f, -0.00840636f, -0.02922926f, 
    -0.06033165f, 0.06012070f, -0.23362006f, -0.02131648f, 0.08473501f, -0.04802325f, -0.02573314f, -0.08478343f, 
    0.00134334f, -0.05375256f, 0.01134011f, 0.03323681f, -0.00374154f, -0.00997922f, -0.05506281f, -0.03496524f, 
    -0.03427155f, 0.06384478f, -0.03245553f, 0.01630846f, -0.19225785f, 0.02197736f, -0.01975719f, -0.05830184f, 
    -0.05020853f, 0.00007505f, -0.02787819f, -0.09228092f, -0.00903003f, -0.05604102f, -0.01147583f, 0.04127326f, 
    -0.01867967f, -0.04288471f, 0.00191961f, -0.01040393f, -0.01397972f, 0.00280484f, -0.05341651f, -0.00251005f, 
    -0.01870220f, -0.16513704f, 0.07296944f, 0.12179567f, -0.02695069f, 0.06702239f, -0.10988244f, -0.00482198f, 
    0.06766939f, 0.01684622f, -0.05486041f, -0.00496599f, -0.00563042f, -0.04135843f, -0.04033879f, 0.02076330f, 
    0.01172240f, 0.00949550f, 0.03898440f, -0.00862952f, 0.21142536f, 0.04184539f, 0.18729442f, -0.05593977f, 
    0.07011196f, -0.00944192f, 0.06487843f, -0.04121161f, 0.00259145f, 0.02043241f, -0.00051237f, 0.00348489f, 
    0.00971241f, -0.03091168f, -0.05342472f, 0.00219202f, -0.01352639f, 0.01714188f, 0.07052977f, -0.03134712f, 
    0.12197895f, -0.28068930f, -0.05500200f, -0.16609676f, -0.12986369f, 0.02394898f, -0.05894880f, -0.03928581f, 
    -0.06138352f, -0.04408368f, -0.02135520f, 0.00988660f, -0.01456579f, -0.06962823f, -0.04902602f, -0.02011172f, 
    0.10247923f, -0.01095299f, -0.03288417f, 0.02827059f, -0.00384036f, 0.11716291f, 0.13904293f, 0.01866641f, 
    0.15399799f, -0.07387977f, 0.09928226f, 0.06306934f, 0.03943567f, 0.08697134f, -0.04233336f, 0.04545391f, 
    -0.05362013f, -0.07129942f, 0.00952454f, 0.00829050f, 0.02270634f, 0.02836309f, -0.01777326f, -0.00449725f, 
    -0.14420564f, 0.13525711f, -0.16775161f, 0.04317084f, 0.01354108f, -0.04512860f, 0.03724577f, -0.09283981f, 
    0.04786142f, -0.01017510f, -0.05241181f, 0.06679939f, -0.03452766f, 0.00426865f, -0.01276364f, -0.07210332f, 
    -0.07789715f, 0.01380479f, -0.08650450f, -0.04856673f, -0.12098621f, 0.01411410f, -0.05770693f, 0.09531976f, 
    -0.09894707f, 0.10324490f, -0.12405451f, 0.02621026f, 0.05866234f, 0.02256095f, -0.06047672f, 0.08099369f, 
    0.04798011f, -0.06521443f, -0.03148004f, 0.05201472f, 0.05558123f, 0.08366997f, -0.01317799f, 0.03380913f, 
    0.14821088f, -0.11466748f, 0.07941190f, 0.13212965f, 0.14879571f, 0.12518956f, -0.01673329f, -0.02770528f, 
    -0.01076679f, -0.01682096f, -0.04587916f, 0.05251480f, -0.05760918f, -0.09230111f, 0.00710559f, 0.02126786f, 
    -0.04431639f, -0.00550394f, 0.04900830f, -0.07086875f, 0.04539597f, 0.06968253f, 0.07077446f, 0.10830888f, 
    0.10101160f, 0.08881330f, 0.01885774f, -0.02132155f, 0.00034195f, -0.04727175f, -0.03101468f, 0.03617685f, 
    -0.03522312f, -0.00863432f, -0.08475632f, -0.04849820f, -0.01058342f, -0.03593311f, -0.03076867f, -0.00761929f, 
    -0.10899128f, 0.01452155f, -0.15800461f, 0.00354659f, 0.09225154f, -0.07904048f, 0.03139468f, -0.03730062f, 
    0.01399422f, -0.01018320f, -0.10641989f, 0.06865771f, -0.11939020f, -0.03370154f, -0.03742630f, 0.03266712f, 
    -0.03329175f, 0.01052879f, -0.05568701f, -0.00619716f, 0.03927060f, 0.09145691f, 0.12409355f, 0.05743700f, 
    0.17875281f, 0.01184379f, 0.00103968f, -0.03721386f, 0.06006341f, 0.03353938f, 0.02723877f, -0.02504942f, 
    -0.04176596f, -0.02462452f, -0.11308172f, 0.00988986f, -0.12810500f, 0.00087646f, 0.00148541f, 0.02893336f, 
    0.18435161f, 0.11600031f, 0.12420063f, 0.00445821f, 0.14836602f, -0.10427761f, 0.02528647f, -0.04521927f, 
    -0.02609096f, -0.03203282f, -0.02550715f, 0.02419156f, -0.05922624f, -0.00082835f, -0.00168753f, 0.00836519f, 
    -0.01470427f, 0.04316043f, 0.03616638f, -0.06123486f, -0.27580705f, 0.03888993f, 0.13142495f, 0.09201966f, 
    -0.17630805f, 0.14142285f, -0.00405951f, -0.09464522f, 0.05477774f, 0.08995311f, -0.05439722f, -0.04642640f, 
    -0.00400354f, -0.00612447f, 0.00131692f, -0.00782243f, -0.07923745f, -0.00084150f, -0.05626851f, 0.00224678f, 
    0.00597969f, 0.08371549f, 0.12314238f, 0.06607815f, 0.04810836f, 0.02951778f, 0.00546415f, 0.00402192f, 
    -0.01158790f, 0.00209199f, -0.01940602f, 0.07265393f, 0.00531526f, -0.04761167f, 0.01717636f, -0.03263449f, 
    0.00216991f, 0.02723074f, 0.00536519f, -0.06845088f, 0.13284987f, 0.05192139f, 0.19278623f, -0.00563053f, 
    0.07510896f, -0.00237021f, 0.03942820f, -0.02066113f, -0.00420325f, -0.02651463f, -0.03280381f, 0.03532048f, 
    -0.00390864f, 0.01344955f, -0.04299900f, -0.00722951f, -0.04610191f, 0.00395487f, 0.03157255f, -0.06435563f, 
    0.23689884f, -0.21871294f, 0.06391732f, -0.03595507f, 0.09308361f, -0.04740397f, 0.03324454f, 0.00203732f, 
    0.00402568f, -0.02620377f, -0.07046599f, -0.04760597f, -0.04811559f, 0.06821440f, 0.01960257f, -0.04531924f, 
    0.04400397f, 0.03111668f, 0.00921673f, -0.03918753f, -0.21594551f, 0.11947018f, 0.14147896f, 0.06342307f, 
    0.07812326f, 0.01791005f, 0.05244681f, 0.03031158f, 0.01969901f, 0.01333976f, -0.06844314f, -0.01759026f, 
    0.04802758f, 0.02724295f, -0.05682816f, 0.05922794f, 0.03238610f, 0.02959126f, 0.00031405f, -0.00722685f, 
    -0.10653678f, -0.18848516f, -0.04545833f, -0.10975480f, -0.10457036f, -0.07397494f, 0.00568057f, 0.06874727f, 
    -0.04670164f, -0.07830326f, 0.03910751f, -0.00385673f, -0.04567178f, 0.00401958f, 0.00315668f, 0.05339874f, 
    -0.03535732f, -0.03265642f, -0.00975775f, -0.03450480f, 0.12591626f, -0.09481665f, 0.04594487f, -0.04230442f, 
    -0.07791150f, 0.04068035f, -0.02456952f, 0.01653485f, -0.09840364f, -0.05454530f, -0.02103420f, -0.01969962f, 
    -0.02936577f, -0.00578219f, -0.02780285f, -0.00651919f, 0.02448483f, 0.01126446f, 0.01145220f, -0.04660439f, 
    0.01411173f, 0.01873454f, 0.00424813f, 0.07913563f, 0.11435810f, 0.00554744f, -0.02135698f, -0.05241261f, 
    -0.02522377f, -0.01724096f, -0.02547182f, 0.01223031f, -0.00557168f, -0.04938878f, 0.01624108f, -0.00232830f, 
    -0.00368393f, 0.01897288f, 0.08110394f, -0.02411627f, 0.02746965f, -0.05996224f, 0.07021874f, 0.02051896f, 
    0.09457272f, -0.02521642f, -0.01629899f, -0.02995414f, -0.01521401f, -0.04876053f, -0.04622522f, -0.00956730f, 
    0.02381882f, -0.08007534f, 0.00629349f, 0.03584457f, -0.04228333f, 0.09299886f, 0.06713505f, 0.01808193f, 
    -0.17468512f, -0.05836400f, 0.13049810f, -0.26159403f, -0.15959492f, 0.04354580f, 0.07588343f, 0.02142951f, 
    0.00475952f, -0.01284265f, -0.01193342f, -0.02973860f, -0.01552106f, -0.02182948f, 0.03167390f, -0.07270424f, 
    0.07956344f, 0.08126902f, -0.16232799f, -0.02577142f, 0.01070830f, -0.02375330f, 0.03432113f, -0.02978638f, 
    0.06206900f, -0.01308373f, 0.01217458f, 0.00987502f, 0.00949494f, -0.02183940f, -0.02057151f, -0.01862850f, 
    -0.00746184f, -0.03243025f, -0.05500329f, -0.01530240f, -0.00228374f, 0.03830323f, 0.04628175f, -0.01750738f, 
    0.12613833f, 0.13459425f, 0.01737227f, 0.03562457f, 0.11068176f, -0.09776638f, -0.06270260f, -0.04567951f, 
    -0.03590523f, -0.08020086f, 0.03489882f, -0.01971520f, -0.03471673f, -0.04614847f, -0.00199571f, -0.01836768f, 
    -0.02451877f, 0.03741103f, 0.06649874f, -0.03754151f, 0.09818527f, 0.06839205f, -0.09543108f, 0.08151429f, 
    0.10006148f, 0.06758145f, 0.01169716f, -0.04171027f, -0.00960847f, -0.03769501f, 0.01708029f, -0.01101874f, 
    0.02831217f, -0.02271799f, -0.02649437f, -0.01549229f, 0.01231255f, 0.00820923f, 0.04848298f, -0.02951733f, 
    -0.08451590f, -0.04527483f, 0.00179613f, -0.03064126f, 0.08408564f, 0.01092908f, 0.06911636f, -0.11616185f, 
    -0.00814795f, -0.00274785f, 0.01793490f, 0.04488742f, 0.03247381f, 0.05623077f, 0.04101570f, -0.11111332f, 
    0.05643062f, 0.05859723f, 0.01097195f, -0.01929870f, -0.02957929f, 0.17078784f, -0.01502120f, -0.03679303f, 
    -0.01037170f, -0.03852872f, -0.04446107f, -0.00764698f, -0.01271354f, -0.01338363f, 0.05948151f, -0.00236927f, 
    -0.00031471f, -0.01139588f, 0.04340357f, -0.03136630f, 0.00508282f, 0.03663843f, 0.05201272f, 0.04028408f, 
    -0.19975480f, 0.11150069f, -0.10171644f, -0.03739015f, -0.20483060f, 0.04694426f, -0.06132997f, -0.08562802f, 
    0.02469048f, -0.04525154f, -0.00664537f, 0.01826451f, 0.03070470f, -0.04147201f, -0.04998064f, 0.02799150f, 
    0.08877442f, -0.13272224f, 0.01607120f, 0.01206572f, -0.14654532f, -0.12910424f, -0.10259890f, -0.06089296f, 
    -0.14877051f, 0.04270878f, -0.00577789f, -0.05842222f, -0.02017545f, 0.02214524f, 0.07374993f, -0.06143050f, 
    -0.01977927f, 0.00452178f, 0.04934329f, -0.05459228f, -0.00847946f, -0.07500114f, -0.03744639f, 0.03282895f, 
    -0.16384245f, 0.13160057f, -0.07930353f, -0.05135595f, -0.06778754f, 0.00563170f, 0.03847872f, -0.04384929f, 
    0.03342685f, -0.04682840f, 0.02983463f, -0.04349629f, -0.02929831f, 0.01058589f, 0.06898758f, -0.07139797f, 
    -0.02350155f, -0.03453498f, 0.06155174f, -0.02958839f, -0.01887319f, 0.12895663f, 0.01200146f, 0.08788010f, 
    0.00899756f, 0.07768712f, 0.03591345f, -0.03968611f, -0.07639297f, 0.02536940f, 0.00717356f, -0.03486980f, 
    0.00749483f, 0.05842482f, -0.07929486f, -0.02612162f, 0.05812835f, 0.02840210f, 0.01302132f, -0.13239942f, 
    -0.02028684f, -0.11723450f, -0.10731605f, 0.08808026f, 0.06827177f, 0.04803359f, 0.05314296f, 0.00800873f, 
    -0.05725960f, -0.06238582f, 0.02260470f, 0.02930360f, 0.05499546f, -0.02953013f, 0.04406979f, -0.07064715f, 
    -0.01361632f, -0.00253324f, 0.04221275f, -0.11762824f, 0.05040637f, 0.05705777f, -0.15290435f, 0.08167794f, 
    0.03251301f, 0.04965568f, 0.04316781f, -0.04501232f, -0.03196105f, -0.03950917f, 0.00271229f, 0.01496251f, 
    0.03063267f, -0.03693538f, -0.01266588f, -0.00635206f, -0.01237348f, 0.01388102f, 0.07718902f, -0.01964202f, 
    -0.13355611f, 0.13186376f, -0.02486609f, -0.06082338f, -0.19362520f, -0.03911676f, -0.00450826f, -0.05668856f, 
    0.02973509f, -0.08272434f, 0.06906423f, 0.03336688f, 0.01053196f, -0.05944513f, 0.09566633f, -0.03319159f, 
    0.00638924f, -0.07995239f, 0.06266464f, -0.07047039f, -0.06459952f, -0.11727613f, 0.11266362f, 0.08686660f, 
    0.14523104f, -0.05984004f, -0.02375630f, 0.07296586f, -0.09879694f, 0.05586624f, 0.02582097f, -0.01007029f, 
    -0.03530942f, -0.02186497f, 0.06094561f, -0.00574237f, -0.00805513f, 0.03369617f, 0.03495071f, -0.00927835f, 
    -0.14629449f, 0.04688314f, -0.11674951f, 0.01728781f, -0.12100127f, 0.01731788f, -0.05051309f, -0.07272450f, 
    -0.09591962f, 0.11325836f, -0.00582342f, 0.00988025f, 0.01582702f, -0.05358567f, 0.02154340f, -0.01367488f, 
    0.00519436f, -0.08592822f, 0.12488271f, -0.07723001f, 0.00190149f, -0.16764180f, 0.06163063f, -0.13037035f, 
    -0.11497545f, -0.02865438f, -0.02745331f, 0.06468678f, -0.02699177f, -0.01469924f, -0.00109116f, 0.04016960f, 
    0.02273184f, 0.01797318f, -0.03455535f, 0.00860141f, -0.05056024f, -0.04212946f, -0.02827629f, 0.01807340f, 
    0.07365346f, 0.10711063f, -0.02223503f, 0.09877803f, 0.13024953f, -0.10562336f, -0.06878220f, -0.09740055f, 
    -0.15880866f, 0.01757140f, -0.15328105f, -0.06569029f, 0.01767874f, -0.01002396f, 0.08855028f, 0.09943801f, 
    0.04316774f, 0.05134282f, 0.05603731f, 0.01101176f, -0.13293880f, -0.05968059f, 0.01667212f, -0.12837650f, 
    0.05695739f, 0.01383480f, 0.05584957f, -0.05210251f, -0.02624394f, -0.02352574f, 0.02644847f, 0.00046068f, 
    -0.04074275f, 0.01671578f, -0.00974964f, -0.04829172f, -0.00003568f, 0.01740477f, -0.07506873f, -0.00453331f, 
    0.06083909f, 0.05840904f, -0.05348298f, 0.03689580f, 0.05324553f, 0.08699080f, -0.03816116f, -0.05825598f, 
    -0.03545394f, 0.00294848f, 0.00112178f, 0.01625638f, 0.04920140f, 0.00158916f, -0.03418978f, 0.04760063f, 
    -0.01035808f, 0.00883530f, 0.04175432f, 0.00046981f, 0.11493371f, -0.10430808f, -0.19670400f, 0.06131934f, 
    0.16725774f, 0.04777510f, 0.04126751f, 0.00043743f, -0.07097273f, 0.00573262f, -0.03464983f, -0.02615756f, 
    0.01693790f, 0.05757529f, 0.03582861f, -0.02706360f, -0.03180907f, 0.07017088f, 0.07593276f, -0.02347727f, 
    0.08068025f, -0.06458166f, -0.02138199f, 0.06390867f, 0.14303182f, 0.07860979f, 0.06852818f, -0.03665530f, 
    -0.01597347f, 0.01291313f, 0.02145721f, 0.08036166f, -0.04578112f, 0.07117947f, 0.00743482f, 0.00920420f, 
    0.00476165f, 0.02730220f, 0.04045423f, 0.00990883f, 0.02528058f, -0.06434570f, 0.13018025f, -0.00861417f, 
    0.11170916f, -0.06701092f, -0.02298773f, 0.05274196f, -0.04448748f, 0.02653030f, -0.01620380f, -0.09866256f, 
    -0.01097178f, -0.10473566f, -0.04811741f, 0.01626808f, -0.01535550f, 0.04461943f, 0.00510929f, 0.03344899f, 
    0.05638102f, 0.03549800f, -0.05839399f, 0.03571962f, 0.08215276f, 0.03737357f, -0.02241519f, -0.04161814f, 
    -0.01924337f, -0.00598407f, -0.01686724f, 0.03671021f, -0.03844729f, 0.01139796f, -0.00713303f, 0.03939865f, 
    0.00772867f, 0.00777610f, 0.03211156f, 0.04895961f, -0.19059351f, -0.15359947f, -0.05713513f, -0.23415570f, 
    -0.16411421f, -0.02674240f, -0.02687081f, -0.01336483f, -0.01554696f, -0.08902476f, 0.05002933f, 0.05080840f, 
    0.00680230f, 0.06356314f, 0.00851304f, -0.05581095f, 0.00622759f, -0.02218802f, -0.16945836f, -0.05056465f, 
    -0.10017561f, -0.14438348f, -0.04396968f, -0.18595432f, 0.03947387f, 0.11817758f, 0.00350786f, -0.04002909f, 
    -0.04362962f, -0.07337971f, 0.02599150f, 0.00084893f, 0.01096336f, 0.00885121f, -0.09412953f, 0.00687181f, 
    0.08496634f, 0.06277647f, -0.12449425f, -0.08407401f, -0.01661708f, 0.07109211f, -0.18724582f, 0.04903983f, 
    -0.03812889f, -0.02099782f, -0.01446496f, -0.10500921f, -0.02058185f, -0.03373373f, 0.03226601f, -0.04250708f, 
    -0.02568116f, 0.03321771f, -0.01584178f, 0.01713648f, -0.02970397f, -0.06915841f, 0.02670704f, 0.02065802f, 
    -0.06283774f, -0.01047380f, 0.11113697f, -0.02926146f, -0.11386796f, -0.05356495f, -0.01602542f, 0.02693966f, 
    -0.10617831f, 0.03481340f, 0.01386920f, -0.02222924f, 0.00672189f, 0.00669069f, 0.00780342f, 0.03594225f, 
    -0.00385631f, -0.09740826f, -0.00399266f, -0.00221754f, -0.08137780f, -0.04418296f, -0.18557140f, -0.15030241f, 
    -0.03099256f, 0.04360294f, -0.03678631f, 0.01847284f, 0.00037619f, -0.05485785f, 0.10398574f, 0.07724022f, 
    0.04071316f, 0.00821507f, 0.00848461f, 0.02522713f, 0.03287470f, -0.05279065f, -0.01311108f, -0.02838839f, 
    0.07872974f, 0.08947834f, -0.11912117f, 0.04204371f, 0.01306849f, -0.01495553f, 0.03553963f, 0.00054082f, 
    -0.05643447f, 0.02585355f, -0.00515234f, 0.02916830f, 0.03754383f, 0.03027144f, 0.02405936f, -0.00668166f, 
    -0.02240090f, -0.00208645f, 0.04482201f, 0.05263647f, 0.01175762f, 0.06759440f, 0.02132990f, -0.15779838f, 
    0.03029767f, 0.01804232f, -0.03777445f, -0.10914603f, 0.02985406f, -0.13993011f, 0.06911917f, -0.02525652f, 
    0.05094339f, -0.14096127f, -0.01980272f, -0.07410242f, 0.01682762f, -0.01867065f, -0.02415625f, -0.03130094f, 
    -0.11320346f, 0.00313292f, 0.10157132f, 0.06790996f, -0.03836926f, -0.04888558f, 0.08450805f, 0.00737736f, 
    -0.04600906f, -0.02382102f, 0.01334199f, -0.05922359f, -0.00994558f, 0.05117743f, -0.03001390f, 0.05925518f, 
    -0.07919642f, -0.06087157f, -0.00006228f, -0.02440809f, -0.18377794f, -0.11748024f, -0.03971873f, -0.22714050f, 
    -0.09257694f, -0.02784998f, -0.03429347f, -0.04687070f, -0.03063907f, -0.05672846f, -0.00771006f, 0.01120535f, 
    0.01037642f, 0.00821484f, -0.00765641f, -0.04111704f, 0.04596243f, -0.02420461f, -0.05170641f, -0.02918636f, 
    -0.14930426f, 0.03832939f, 0.09650858f, -0.09931765f, -0.20720932f, -0.00485941f, 0.00922773f, -0.06208086f, 
    0.03499119f, -0.03909085f, -0.00921759f, 0.04681442f, 0.00843143f, 0.05732388f, -0.00392526f, -0.01681481f, 
    -0.03970887f, -0.08309674f, -0.00539304f, 0.01159884f, 0.07623091f, -0.03364570f, 0.03190435f, -0.16349310f, 
    -0.04311941f, 0.08601606f, -0.01711469f, 0.01493110f, 0.03085979f, -0.07859749f, 0.05650660f, 0.04642129f, 
    0.03834304f, 0.07997634f, -0.07054739f, 0.05815878f, 0.08011121f, 0.02150821f, -0.02454293f, 0.06540659f, 
    -0.11864706f, 0.01383985f, 0.19928329f, -0.00337275f, 0.10258223f, -0.09677526f, -0.05609417f, 0.00083109f, 
    0.01739593f, -0.00241089f, -0.03145522f, 0.01489769f, -0.09090354f, -0.04715724f, 0.08427333f, -0.00032766f, 
    0.03218408f, -0.00865507f, 0.05709617f, -0.04332895f, -0.05874157f, -0.04977369f, 0.12924282f, -0.01152332f, 
    0.10882211f, 0.01913378f, 0.01299771f, 0.04106247f, -0.02693086f, -0.07659468f, 0.04233181f, 0.00131721f, 
    0.06749690f, 0.01678050f, 0.05134023f, 0.02968976f, 0.01521461f, 0.02436937f, -0.07491142f, 0.03678088f, 
    0.07467238f, 0.01793542f, -0.09704261f, 0.04828015f, 0.07332663f, 0.13569765f, 0.04326097f, 0.02635685f, 
    -0.03159186f, -0.02743054f, -0.00078527f, 0.06098274f, -0.04293923f, -0.00803745f, -0.02901112f, -0.02247059f, 
    -0.05302458f, 0.00555712f, 0.04850486f, -0.02264877f, -0.18917091f, -0.20728938f, 0.06957915f, -0.15181494f, 
    -0.09872490f, -0.07820020f, 0.03739363f, 0.01689969f, -0.05284202f, 0.01959027f, 0.00460117f, -0.00322718f, 
    -0.00099667f, 0.07162087f, -0.06121914f, -0.00900770f, -0.02984074f, -0.02384600f, -0.25787079f, -0.01243813f, 
    -0.12484940f, 0.05036991f, -0.09663095f, 0.02459351f, -0.14629008f, -0.06370348f, -0.01312011f, 0.00616964f, 
    -0.05745503f, -0.00923002f, 0.09433125f, 0.00871869f, -0.03658723f, -0.04783020f, 0.01171764f, -0.07842281f, 
    0.00429220f, -0.11919770f, 0.03532657f, -0.00195793f, -0.09842727f, 0.10075025f, 0.12517212f, -0.10486476f, 
    -0.12485303f, -0.05937152f, 0.03229671f, 0.01951210f, 0.02097355f, 0.01546386f, -0.00926695f, -0.00198735f, 
    -0.05441628f, -0.02413690f, -0.00184425f, -0.05476290f, -0.02733013f, -0.10695152f, 0.10528072f, -0.03242685f, 
    0.12934165f, 0.10225461f, -0.16458268f, 0.08496599f, 0.02971915f, 0.01881263f, 0.01789041f, -0.18602450f, 
    -0.09694519f, 0.00734157f, 0.03899685f, -0.01803890f, 0.03324656f, -0.02070688f, -0.00110657f, 0.01700959f, 
    0.00070822f, -0.07406034f, 0.08941171f, -0.03765064f, -0.05023024f, -0.16156839f, 0.03649077f, -0.00272398f, 
    0.00848168f, -0.11269017f, -0.03036618f, 0.04661638f, -0.03459919f, 0.02019606f, 0.02180691f, 0.01125068f, 
    -0.02130856f, -0.00687207f, 0.05942582f, 0.02578021f, -0.03285291f, -0.06760521f, 0.05858885f, 0.03910938f, 
    -0.02574513f, 0.11300509f, -0.12239083f, -0.14460222f, -0.05682006f, 0.02000372f, 0.03571074f, -0.02018949f, 
    0.03453024f, 0.00438026f, 0.00091755f, -0.01240909f, 0.01211921f, 0.04448186f, 0.04249608f, 0.04778201f, 
    0.01740886f, -0.03637273f, -0.03294802f, 0.07105370f, 0.09943437f, 0.05017197f, -0.12077770f, 0.06261448f, 
    0.01816145f, -0.01351878f, -0.00516459f, -0.01396713f, -0.05445840f, 0.02602617f, 0.00474306f, -0.00292543f, 
    0.01192507f, 0.04261492f, 0.01685173f, 0.01340307f, 0.01251633f, -0.02776526f, 0.03211158f, 0.06348600f, 
    -0.01694866f, 0.11133888f, -0.26492581f, -0.03729614f, 0.02859153f, 0.03586411f, -0.01468809f, -0.04969636f, 
    -0.01272358f, -0.06446846f, 0.10732553f, -0.01520545f, 0.03617037f, -0.00574774f, 0.07228065f, 0.02752134f, 
    -0.04136823f, -0.05365828f, 0.07806337f, 0.04442750f, -0.14282331f, 0.08231547f, 0.05148416f, -0.02797321f, 
    0.02596871f, -0.04712141f, -0.09648015f, 0.04794102f, -0.06726253f, 0.04546667f, 0.02364802f, -0.00994930f, 
    -0.14028955f, 0.04692687f, 0.11393525f, 0.00489542f, -0.05516715f, 0.02705942f, -0.04419225f, 0.02237659f, 
    -0.03140882f, -0.16975409f, -0.01721318f, 0.08113614f, 0.08159542f, 0.06654462f, 0.07039326f, -0.04525623f, 
    -0.02019608f, 0.00413892f, -0.01911842f, 0.06102223f, -0.00906904f, 0.00763395f, -0.00033419f, -0.03629528f, 
    -0.08270810f, 0.04424001f, 0.03983545f, -0.05459587f, -0.07405041f, 0.21950786f, 0.05034290f, -0.12651518f, 
    -0.13186869f, -0.02645950f, -0.00491328f, 0.02911085f, -0.01565254f, -0.04652790f, 0.05866360f, 0.02211187f, 
    0.00262443f, -0.02165105f, 0.08365297f, -0.05772309f, 0.02482845f, -0.03829334f, 0.04903013f, -0.06511412f, 
    0.10717290f, 0.20093165f, 0.02520485f, -0.09233643f, -0.04072695f, -0.14662489f, 0.09282149f, 0.01233608f, 
    -0.10975006f, -0.01877819f, 0.06309572f, 0.01340058f, -0.02831606f, 0.11325707f, -0.04131180f, -0.02595032f, 
    0.07179186f, -0.08234809f, 0.07785679f, -0.00575194f, -0.11554042f, -0.02647988f, -0.16308908f, -0.00718511f, 
    -0.17941399f, 0.03516834f, -0.06530443f, -0.13693389f, -0.02489915f, 0.07925830f, 0.10812976f, -0.04860848f, 
    0.07155990f, -0.04081043f, 0.04816384f, -0.00642549f, -0.00817752f, -0.11571105f, 0.05778418f, 0.04805175f, 
    -0.07728586f, -0.10560466f, 0.11577081f, 0.06081829f, 0.09544712f, -0.06968784f, -0.04590984f, 0.04844308f, 
    -0.07214557f, -0.01679052f, -0.00329166f, -0.02543084f, 0.03027428f, 0.04339898f, -0.00715686f, 0.01963618f, 
    -0.00230046f, 0.03232229f, -0.10827014f, 0.07210188f, -0.08361614f, -0.07491709f, 0.12176111f, -0.06072392f, 
    -0.01729238f, 0.02416132f, 0.02534132f, -0.00596356f, -0.00858373f, -0.00326366f, -0.02596429f, -0.00987517f, 
    -0.01375362f, -0.05542897f, -0.01126781f, -0.01824205f, 0.01815664f, 0.04396312f, -0.08586462f, -0.01713797f, 
    -0.02146334f, 0.17799783f, 0.20816268f, 0.00037894f, -0.06718217f, -0.02922081f, -0.05655540f, -0.01075259f, 
    -0.10738026f, -0.13405567f, 0.09650463f, -0.00974876f, 0.03600868f, -0.01038284f, -0.10371172f, -0.13085479f, 
    0.01536955f, -0.13268422f, 0.04251037f, -0.13609718f, 0.02016175f, 0.04999891f, -0.14585999f, -0.16862741f, 
    -0.17910323f, 0.01054672f, 0.03116058f, 0.00319903f, -0.10988296f, 0.05102638f, 0.07841034f, 0.03108463f, 
    0.09320576f, 0.03206908f, 0.00548057f, -0.09423459f, -0.05297609f, 0.00454147f, -0.08871731f, -0.16568495f, 
    -0.25388038f, -0.01008377f, 0.10639793f, -0.08955073f, -0.00516406f, 0.04255481f, 0.01071638f, 0.00833726f, 
    0.01766463f, -0.13940002f, 0.01814457f, -0.07065484f, 0.04259111f, 0.08874265f, 0.07044152f, -0.01228452f, 
    0.04844770f, 0.03358555f, -0.15001154f, 0.05096387f, -0.02325319f, 0.09715246f, -0.06665919f, -0.08257519f, 
    -0.01012670f, 0.02413549f, -0.04593860f, -0.15441650f, 0.03640750f, 0.01984560f, -0.01081982f, 0.04662456f, 
    0.08128252f, -0.12594560f, 0.04084878f, -0.06453063f, 0.00420342f, -0.04551788f, 0.07651870f, -0.08753501f, 
    -0.13347107f, -0.03640904f, 0.09149786f, -0.01690995f, -0.06420492f, -0.03970285f, 0.05003077f, 0.03714894f, 
    0.01298617f, -0.03273534f, 0.01078830f, 0.02307846f, -0.01213770f, 0.05699715f, 0.00467072f, 0.00684239f, 
    0.01561086f, -0.06093631f, -0.00894773f, -0.00955871f, -0.16925597f, 0.06631250f, 0.13533114f, 0.02150055f, 
    -0.01014991f, -0.02999434f, 0.01234909f, -0.05617930f, -0.02686396f, -0.03091003f, -0.00135604f, 0.00964741f, 
    -0.01377885f, 0.03194772f, 0.04064854f, -0.01449258f, 0.00936273f, 0.00698703f, -0.06159614f, 0.03573583f, 
    0.08032045f, -0.17435808f, -0.06488891f, -0.08222417f, -0.07957360f, -0.01001760f, 0.03315485f, -0.03243766f, 
    -0.08388060f, -0.05416275f, -0.04662246f, 0.03369379f, 0.04252539f, 0.06684313f, 0.00586374f, 0.06714793f, 
    0.05101297f, 0.02570846f, -0.02052045f, 0.05870518f, -0.06675864f, -0.18743508f, 0.07181706f, -0.03601055f, 
    -0.11283973f, -0.04165065f, -0.10725213f, -0.01541818f, -0.00604915f, 0.07878384f, 0.01531823f, -0.00973437f, 
    -0.01261675f, -0.06346465f, 0.05158431f, -0.00767529f, 0.01222283f, -0.06207548f, 0.07056496f, -0.03768296f, 
    0.20468073f, 0.11687489f, -0.08239786f, 0.08483636f, 0.14367704f, 0.01131486f, 0.03386667f, -0.05046853f, 
    -0.01594843f, -0.02459748f, 0.04886855f, 0.09318997f, -0.04363374f, -0.05389288f, 0.02459455f, -0.12224130f, 
    -0.03825859f, 0.03284256f, 0.05536170f, -0.03596303f, 0.13224797f, -0.00141160f, 0.05547403f, 0.06813572f, 
    0.11653551f, 0.04320994f, -0.00063363f, -0.02266182f, -0.04668865f, -0.02296671f, -0.02607816f, -0.01218731f, 
    0.00232459f, 0.03100480f, -0.03866931f, 0.06529976f, -0.01714964f, -0.00242146f, 0.03125362f, 0.08164498f, 
    0.12422505f, -0.35230887f, 0.08477682f, -0.07952587f, 0.03070490f, 0.04291744f, 0.01516358f, -0.03128213f, 
    0.00970780f, -0.14709696f, -0.01346153f, 0.03198865f, -0.02895636f, 0.04096948f, -0.02062685f, 0.02642133f, 
    0.11490092f, -0.08903543f, -0.05810623f, 0.01633568f, 0.08928422f, 0.02612929f, 0.13262710f, -0.09732903f, 
    0.04656116f, 0.09767580f, -0.01917308f, -0.00720538f, -0.07175515f, 0.04144800f, 0.02095201f, 0.02646963f, 
    0.08267504f, 0.11729303f, -0.01412063f, -0.00126715f, -0.00653332f, -0.12726626f, -0.02052864f, -0.10319880f, 
    0.19627157f, 0.07218192f, -0.13790165f, 0.05078832f, -0.05194215f, -0.12156618f, 0.01141157f, 0.04462339f, 
    -0.00933330f, -0.07780173f, -0.05502687f, 0.02421708f, 0.12060767f, 0.03264825f, 0.11523006f, 0.14983401f, 
    -0.07533876f, 0.06432368f, -0.09777369f, 0.10022843f, -0.08977211f, -0.03301479f, -0.10563617f, 0.03880902f, 
    0.04979938f, 0.04440002f, 0.02327386f, -0.05203403f, -0.03409216f, 0.05326278f, -0.02466515f, -0.02991802f, 
    0.07050457f, 0.06405634f, -0.02945916f, -0.08518162f, 0.02834136f, -0.08356775f, 0.09510367f, 0.01575951f, 
    0.30380628f, 0.05938981f, -0.17001560f, -0.02068117f, 0.01408507f, 0.10737948f, -0.01809846f, 0.04488399f, 
    -0.09014013f, 0.02111054f, -0.08122457f, 0.09634398f, -0.01479561f, 0.05210146f, -0.05999812f, -0.02252305f, 
    -0.02867193f, -0.07602271f, 0.01143406f, 0.03115647f, -0.09987205f, 0.02247346f, 0.08292189f, -0.21122792f, 
    0.03712698f, 0.06113534f, 0.03045201f, -0.05786864f, -0.00001758f, -0.00834486f, -0.01741145f, -0.01930956f, 
    0.00025136f, -0.03783875f, 0.00929414f, 0.02798572f, 0.01755840f, 0.01543675f, 0.02422542f, -0.01514351f, 
    0.10761387f, -0.12737235f, -0.05674003f, -0.05367890f, -0.19713360f, -0.00018123f, 0.12077232f, 0.02043606f, 
    -0.01159303f, -0.08898807f, 0.06186267f, -0.04507300f, -0.04052235f, -0.05370508f, -0.07793103f, 0.01130461f, 
    0.03462182f, -0.12265753f, -0.03852445f, -0.02773051f, -0.22937198f, 0.07393190f, -0.12219594f, 0.16188294f, 
    -0.15145199f, 0.05198642f, 0.07274862f, -0.02431502f, 0.01113028f, 0.04286003f, -0.08241449f, 0.02232732f, 
    -0.00212817f, 0.04556972f, 0.05314962f, 0.00346781f, -0.05742674f, -0.06590477f, -0.06877534f, -0.04769569f, 
    0.08579510f, -0.50219691f, -0.04219793f, 0.02528765f, -0.11067513f, -0.06602980f, 0.01774681f, -0.04680013f, 
    0.10196027f, -0.04942337f, -0.05587399f, 0.03272589f, 0.06242935f, 0.00288290f, 0.02921156f, 0.07209180f, 
    -0.02488086f, 0.08064371f, 0.07650205f, 0.00169654f, -0.36050722f, -0.17992957f, -0.00886873f, 0.13181993f, 
    0.07274310f, -0.03550527f, 0.02941022f, 0.01426600f, -0.01373619f, 0.05056047f, -0.13018970f, -0.09413779f, 
    -0.01163109f, -0.01526155f, 0.00213040f, 0.08138501f, 0.01954112f, -0.06965294f, 0.00551347f, -0.00751740f, 
    -0.12443241f, 0.12164739f, 0.23118621f, -0.15615043f, -0.02285645f, -0.00085968f, 0.02402176f, 0.04044928f, 
    0.05512303f, 0.00714832f, 0.03552773f, 0.03505010f, 0.07428374f, 0.01418874f, 0.08650360f, -0.05900968f, 
    0.03968041f, 0.04199331f, -0.06201960f, -0.04018042f, 0.21395668f, 0.09488960f, -0.12077536f, -0.27198169f, 
    -0.14397518f, 0.08090599f, -0.00724901f, 0.01180508f, 0.01647070f, -0.00430285f, -0.13071844f, -0.04900233f, 
    0.08294152f, 0.00288002f, -0.04401457f, 0.09711263f, 0.09495080f, 0.02294722f, -0.01901815f, -0.02952350f, 
    -0.23547879f, -0.05859316f, -0.03054988f, -0.05030094f, -0.20592839f, -0.02961624f, -0.03332226f, -0.06116478f, 
    -0.02912416f, 0.03175339f, -0.00799006f, -0.00458702f, -0.03167571f, -0.01269615f, -0.05657779f, 0.03553494f, 
    0.03408126f, 0.04545014f, 0.00514403f, -0.01465425f, -0.23799260f, 0.04212150f, 0.17451271f, -0.06037815f, 
    -0.06137891f, 0.01771808f, 0.01372449f, 0.02201569f, -0.07873526f, -0.06130325f, 0.07202128f, -0.00377288f, 
    0.03166180f, -0.02978114f, -0.01930059f, 0.07033583f, 0.02962801f, 0.06917406f, -0.17513818f, 0.00021719f, 
    -0.26204029f, 0.04595628f, 0.19899948f, -0.19556580f, 0.05899802f, 0.00845646f, 0.07755891f, 0.00098971f, 
    0.07579885f, -0.00288165f, -0.02455650f, -0.02867093f, 0.04926477f, 0.08048637f, 0.15425952f, -0.05170757f, 
    0.05594048f, -0.03335606f, -0.00271820f, 0.06529834f, 0.16788837f, -0.22113718f, -0.05378222f, 0.01854409f, 
    -0.02364506f, -0.00350948f, -0.00910058f, 0.01415771f, -0.04132711f, 0.09715757f, 0.00205676f, 0.00930316f, 
    0.03515072f, 0.00227051f, 0.00151120f, 0.01247337f, 0.01741720f, -0.06138065f, 0.01549262f, 0.04932536f, 
    0.37148538f, -0.38936505f, 0.01554485f, -0.08966689f, 0.21509968f, -0.12008046f, -0.01485407f, 0.03870985f, 
    0.08329343f, -0.14868566f, 0.02228167f, -0.05101488f, -0.04100600f, 0.08998565f, 0.01660461f, 0.02173349f, 
    -0.01148995f, 0.07643894f, -0.08833828f, 0.03951929f, -0.04903123f, 0.13217384f, -0.07143770f, 0.03784841f, 
    0.12274078f, 0.01764864f, -0.09432299f, 0.00208995f, 0.01204312f, 0.07968285f, -0.07136482f, 0.03272651f, 
    0.03751641f, -0.01027254f, -0.02361414f, 0.03189632f, -0.01240646f, 0.03387152f, -0.04974513f, 0.01308260f, 
    -0.22070737f, -0.15582341f, -0.01383208f, -0.05413189f, -0.01647600f, 0.06758857f, 0.11723836f, -0.02983019f, 
    0.09064300f, 0.00708921f, -0.18953821f, 0.05835033f, -0.05058919f, -0.10792795f, -0.06598338f, -0.10763148f, 
    0.00091431f, -0.06424481f, -0.00208374f, 0.09990720f, 0.27093259f, -0.02447234f, 0.11127282f, -0.03178171f, 
    -0.23355450f, -0.01947208f, -0.03701675f, 0.04257764f, 0.05893500f, 0.04313044f, -0.00322812f, 0.06721225f, 
    0.04736822f, -0.05186474f, 0.00307840f, 0.03566040f, 0.04216626f, 0.00901681f, -0.02479216f, 0.00361610f, 
    0.19136351f, -0.26936385f, 0.18658480f, -0.09822078f, -0.01331644f, 0.01766949f, -0.00484358f, -0.13026275f, 
    0.00788605f, 0.06257330f, 0.01673363f, -0.02528440f, 0.06486005f, -0.07544895f, 0.04330610f, 0.04209942f, 
    -0.01179692f, -0.05159769f, 0.03379054f, 0.03405349f, -0.03454844f, -0.08879881f, 0.12395819f, -0.19019641f, 
    -0.18388420f, 0.03089708f, 0.04570043f, -0.09563203f, -0.01319277f, -0.07403456f, -0.07676446f, 0.06595533f, 
    -0.06971792f, 0.02545418f, -0.03641235f, -0.09831230f, 0.03464325f, 0.08486547f, 0.10989578f, 0.01107140f, 
    0.18761331f, -0.22876018f, 0.21571986f, -0.04232258f, -0.22822367f, 0.00785227f, 0.06294744f, -0.01869125f, 
    -0.10795385f, -0.01222491f, -0.06636854f, 0.01108063f, 0.02596653f, -0.07929902f, 0.01059250f, -0.03230840f, 
    0.02365509f, -0.05067100f, -0.00925952f, -0.02922905f, 0.14630112f, 0.06702986f, 0.01226308f, 0.01201947f, 
    -0.05830118f, 0.09722441f, -0.11423641f, -0.00170871f, 0.05814827f, 0.09905393f, -0.04654093f, 0.01601240f, 
    0.01142056f, 0.05357651f, -0.00713120f, 0.03447597f, -0.10475668f, -0.02216532f, -0.06834567f, -0.03216327f, 
    -0.03723889f, -0.03349067f, -0.00481639f, -0.09166653f, 0.01309892f, 0.04538412f, 0.03434154f, -0.01620674f, 
    -0.07053398f, 0.00716312f, 0.05435098f, -0.00403030f, -0.05465068f, 0.08067466f, 0.00412130f, -0.01374680f, 
    0.00843236f, -0.05968060f, -0.04547691f, -0.04678268f, -0.10193999f, -0.09953907f, -0.00600517f, -0.02786177f, 
    0.11180849f, -0.15376750f, 0.04671790f, 0.04173511f, -0.06818208f, 0.06291315f, 0.05251622f, 0.03000588f, 
    0.05090257f, -0.05950317f, -0.08368465f, -0.01141094f, -0.01911975f, 0.01637694f, 0.04576108f, 0.03256633f, 
    0.17061000f, 0.00051045f, 0.02261613f, -0.34198195f, -0.30104092f, -0.01588376f, 0.02599803f, 0.02929201f, 
    -0.04006384f, 0.01361274f, 0.00352517f, -0.00380194f, 0.07662132f, -0.03276747f, -0.08022090f, -0.04569639f, 
    0.06244491f, -0.03067503f, 0.05438005f, 0.05503863f, 0.19188562f, -0.29447421f, 0.02988689f, 0.04129050f, 
    0.10871765f, -0.06746223f, -0.02920093f, 0.00716500f, 0.01502686f, -0.03620076f, 0.00026083f, -0.03241768f, 
    -0.01523814f, -0.02212777f, -0.04965960f, 0.02104068f, 0.08414304f, -0.09087928f, 0.06314602f, 0.11297570f, 
    -0.05527502f, -0.25195268f, -0.04459434f, 0.16956039f, 0.11679453f, -0.01825821f, -0.04446112f, -0.10820745f, 
    -0.05075913f, 0.08350272f, -0.06480491f, 0.12165330f, -0.12029207f, 0.02140790f, -0.05429533f, -0.06353278f, 
    0.00928155f, 0.06133304f, -0.00544125f, -0.00328399f, -0.09243179f, 0.02815015f, 0.08144395f, -0.18259208f, 
    -0.15667121f, -0.14486180f, 0.05306385f, -0.01968733f, 0.01870226f, 0.06850517f, 0.02041333f, -0.07232244f, 
    0.04591754f, -0.14695582f, -0.01162734f, -0.03121491f, 0.00066911f, 0.08741751f, 0.04107866f, 0.01682311f, 
    -0.14410242f, 0.23520805f, 0.05730532f, -0.03445647f, 0.02992113f, 0.04087215f, 0.00995967f, 0.00273847f, 
    0.01025642f, -0.04352609f, 0.02228885f, 0.03292065f, 0.03160056f, -0.01791294f, -0.01006630f, 0.05849313f, 
    -0.03669802f, 0.11750711f, -0.05641558f, 0.03998832f, -0.24735570f, -0.20520747f, -0.14400600f, -0.10644869f, 
    -0.10050365f, -0.05333348f, 0.04332495f, -0.09979232f, 0.02146770f, -0.00786357f, -0.03667942f, -0.02730266f, 
    -0.01205841f, 0.13106869f, -0.03290400f, 0.06343153f, 0.08727525f, -0.08020817f, -0.03794201f, -0.17572628f, 
    0.15061259f, -0.26526442f, -0.00204178f, 0.12847207f, 0.01854646f, -0.08317854f, -0.05873171f, -0.02445503f, 
    0.07392637f, 0.05158385f, -0.03826216f, 0.01775335f, -0.12235495f, -0.05430133f, -0.02493462f, -0.06439231f, 
    -0.03882742f, 0.02300547f, 0.00214299f, 0.04878514f, -0.03661020f, -0.03899853f, -0.00933206f, -0.10092079f, 
    -0.08092381f, -0.03003782f, 0.05768850f, -0.04100497f, -0.01709921f, -0.03246809f, -0.07583159f, 0.01424162f, 
    0.06323041f, -0.00284325f, 0.01153371f, 0.00156575f, 0.06153201f, 0.00498815f, -0.00335242f, 0.08337007f, 
    -0.26464567f, -0.14678100f, 0.04280081f, 0.05074618f, 0.02009268f, -0.02471991f, 0.09245056f, 0.06324958f, 
    0.01353049f, -0.07051092f, -0.03789536f, 0.03527460f, -0.03538672f, -0.02979628f, -0.09423820f, -0.03740108f, 
    0.04412873f, -0.01541368f, 0.07796258f, 0.03599817f, 0.05001356f, 0.00170800f, 0.07134128f, -0.08183268f, 
    -0.23583940f, 0.03244035f, 0.02171526f, 0.07945442f, -0.00161040f, 0.11413871f, -0.05012247f, -0.00932363f, 
    -0.00626919f, -0.07611846f, -0.03968985f, 0.03578980f, -0.00165049f, -0.03320116f, 0.11149356f, 0.05854061f, 
    0.18427378f, -0.03394616f, -0.04662907f, 0.03437142f, -0.00765418f, 0.06396744f, -0.01835311f, 0.00759375f, 
    -0.04339389f, 0.11072506f, -0.07298698f, -0.08007186f, 0.00311741f, 0.07040934f, 0.02452852f, 0.05217582f, 
    -0.11206341f, 0.02494342f, 0.00369316f, -0.05074095f, 0.20455994f, 0.02345095f, -0.10399844f, 0.05041999f, 
    0.03951622f, -0.01536777f, 0.00486890f, -0.01248232f, 0.03647291f, -0.00070438f, -0.06660502f, 0.05471583f, 
    0.03370751f, -0.01938844f, 0.02071556f, -0.01707431f, -0.02507827f, -0.07633772f, 0.07982554f, 0.01005328f, 
    -0.13468470f, -0.01303652f, 0.03702248f, 0.06003502f, -0.29227692f, 0.06790779f, 0.02649250f, 0.01190924f, 
    -0.05418651f, 0.00699649f, 0.02586151f, -0.10077003f, -0.02998669f, 0.01661798f, 0.01330100f, 0.02308361f, 
    -0.02946312f, -0.02078696f, 0.01550601f, 0.01561501f, 0.11825530f, -0.13016608f, -0.05735641f, 0.02082224f, 
    0.08463065f, 0.03124034f, 0.01566206f, 0.11304852f, -0.08269382f, -0.01072080f, 0.02013673f, -0.04866823f, 
    -0.07089754f, -0.07458185f, -0.00708291f, 0.05337436f, 0.04122193f, -0.03200722f, 0.09586435f, 0.02249225f, 
    -0.37136948f, 0.18204938f, 0.07341099f, -0.04075912f, -0.05276179f, 0.05720084f, 0.02440907f, -0.03145178f, 
    0.02888256f, 0.02403475f, -0.03628525f, -0.00653499f, -0.03211537f, -0.03807319f, 0.12895685f, 0.07199495f, 
    0.02814857f, 0.04708888f, -0.08302563f, 0.01432792f, -0.25548810f, 0.08239251f, 0.13917640f, 0.13576175f, 
    0.02658099f, 0.17199752f, 0.01257057f, -0.00547420f, -0.02744444f, 0.11051883f, -0.04439127f, -0.00167144f, 
    -0.02901689f, 0.05603204f, 0.03155400f, 0.06820530f, -0.12088180f, 0.09618171f, -0.08998460f, 0.02002881f, 
    -0.19830255f, 0.03660857f, 0.17245400f, -0.08803345f, 0.12223575f, 0.06001772f, 0.02017693f, -0.04766120f, 
    -0.01289762f, -0.06838740f, -0.00610927f, -0.01363218f, 0.00261716f, 0.03967191f, -0.06346020f, 0.06936243f, 
    -0.01371698f, 0.02882045f, -0.10220337f, 0.10906278f, -0.10341267f, -0.10465342f, -0.04214695f, 0.04412693f, 
    0.14159423f, 0.09650368f, -0.06009617f, 0.03606800f, -0.02805760f, 0.13761154f, 0.01529506f, -0.04097207f, 
    0.03695497f, 0.01675748f, -0.03901741f, 0.02134431f, 0.02923890f, -0.04171691f, 0.05305961f, -0.05260292f, 
    -0.09216791f, 0.13114575f, 0.13274263f, -0.21934351f, -0.26232883f, -0.03845980f, 0.00504125f, 0.01432750f, 
    -0.04834185f, 0.04224214f, 0.04182407f, 0.01996083f, -0.02844067f, -0.06002831f, -0.03663773f, -0.05220512f, 
    0.01069469f, -0.03627415f, 0.01288681f, -0.05023170f, -0.14748365f, 0.13366380f, 0.03885209f, -0.10216784f, 
    -0.12602152f, 0.08301563f, 0.02759166f, 0.06352728f, -0.08529688f, -0.03984676f, -0.03803939f, -0.01267945f, 
    -0.00192608f, -0.05038407f, -0.01947779f, 0.01999664f, -0.03434149f, 0.04451719f, -0.01331340f, 0.03683884f, 
    0.05905054f, -0.23724949f, 0.12974091f, -0.21515033f, 0.12185229f, -0.14210734f, 0.01083383f, -0.02327060f, 
    0.08564069f, 0.02797159f, -0.00086845f, -0.07216352f, -0.06975453f, -0.00128986f, -0.06017195f, 0.10061332f, 
    -0.01323630f, -0.03276709f, 0.01943579f, 0.05424273f, -0.10547778f, -0.07770741f, 0.00656758f, 0.11074096f, 
    -0.15452942f, -0.07448056f, 0.07247961f, -0.10282604f, 0.02053228f, 0.06951864f, -0.03639023f, 0.04600058f, 
    0.03562161f, -0.03243667f, 0.02786413f, -0.02649773f, 0.03939503f, -0.02984364f, 0.00437576f, -0.05413241f, 
    0.24808711f, -0.35405472f, 0.12128855f, 0.03722228f, -0.16512252f, 0.00208821f, 0.06440000f, 0.01694247f, 
    -0.03978009f, 0.03028742f, -0.04089203f, -0.00375882f, 0.08341691f, -0.11702051f, -0.03282585f, 0.02365445f, 
    0.02124558f, -0.01545521f, -0.10458198f, -0.00529303f, -0.20754066f, 0.33304417f, -0.07363290f, 0.14044265f, 
    -0.11504855f, -0.02234803f, -0.02707762f, -0.06252082f, 0.09002316f, 0.15663427f, 0.03122098f, -0.05754121f, 
    0.11979081f, 0.08428860f, 0.13223597f, 0.14043362f, 0.01074348f, 0.10375260f, -0.12508860f, 0.05131211f, 
    0.17404591f, 0.18306737f, -0.10263692f, 0.03156605f, -0.20534229f, -0.01358843f, 0.08356340f, 0.16773766f, 
    0.02710831f, -0.02024917f, -0.10717171f, 0.08103969f, 0.08266456f, 0.07697303f, 0.05146287f, 0.02857086f, 
    0.06724495f, -0.00181537f, 0.09752847f, 0.02303514f, 0.04611023f, -0.20517129f, -0.03733218f, -0.06867164f, 
    0.18137662f, -0.07752462f, -0.02556361f, 0.05861630f, 0.00080622f, 0.04091546f, 0.05241332f, -0.07363824f, 
    -0.08428124f, 0.05181624f, -0.02280594f, 0.01247453f, -0.08028610f, 0.08383512f, -0.09051479f, -0.02624317f, 
    0.18795572f, -0.00452940f, -0.10863604f, 0.00426822f, 0.08942144f, 0.02110619f, -0.03224097f, -0.02187637f, 
    -0.07270153f, 0.05179149f, -0.03688854f, 0.00580331f, 0.10024677f, 0.00986381f, 0.06390908f, 0.04690800f, 
    0.01121119f, -0.06535056f, 0.02117081f, -0.02273167f, 0.20474669f, 0.01971550f, -0.13973710f, -0.00489056f, 
    0.00990974f, -0.00199053f, -0.03474572f, 0.05729520f, -0.03957035f, -0.02627562f, 0.00176008f, -0.03703584f, 
    0.07640864f, 0.05107118f, 0.06874418f, 0.13460164f, 0.00827461f, 0.03358138f, 0.02310182f, 0.04863156f, 
    0.42741084f, 0.09088930f, -0.22910625f, 0.12580442f, -0.19378425f, 0.00192041f, 0.05208982f, 0.06662630f, 
    0.06708474f, 0.08474758f, -0.10386554f, -0.01876116f, 0.09883576f, 0.01875753f, -0.06186463f, 0.10155623f, 
    0.02606544f, 0.02777021f, -0.06582724f, -0.04542885f, -0.00039661f, -0.00090451f, -0.01240388f, -0.01264679f, 
    -0.00830435f, -0.10485794f, 0.02643362f, -0.03434065f, -0.09917056f, 0.00638487f, 0.02769981f, -0.05722352f, 
    0.05048792f, 0.05842767f, -0.05469015f, 0.08215881f, 0.13703315f, -0.04090238f, 0.04464623f, 0.04200106f, 
    0.12603346f, -0.00662113f, -0.11750200f, 0.08465789f, 0.03355434f, -0.08226177f, 0.14186300f, -0.01421841f, 
    -0.00592578f, -0.00586426f, -0.06153221f, -0.02402800f, -0.04452902f, -0.03985836f, 0.01439625f, 0.08293638f, 
    -0.00087899f, -0.00897470f, 0.04683759f, 0.15325265f, 0.09736696f, -0.31526089f, -0.02299652f, -0.23481877f, 
    -0.23032726f, -0.16812854f, 0.01832919f, 0.09397332f, 0.16617011f, -0.15854338f, 0.00813991f, -0.00321958f, 
    0.07329159f, -0.02384638f, 0.09553863f, 0.05510380f, 0.06436470f, 0.20449099f, -0.10801623f, -0.01031142f, 
    -0.10217041f, -0.21178186f, -0.09885217f, 0.20554961f, 0.06846354f, -0.05398249f, 0.00489848f, -0.01901546f, 
    -0.02418236f, 0.07234784f, -0.02951225f, 0.09268665f, -0.12819307f, -0.05591056f, -0.02649279f, -0.08325748f, 
    -0.05678940f, 0.03307080f, -0.00872540f, 0.03270045f, -0.19639540f, -0.20890719f, -0.01980576f, 0.08233171f, 
    -0.04198814f, -0.04897898f, 0.07045392f, -0.05559481f, 0.00359665f, -0.01013710f, 0.01725776f, 0.02710191f, 
    -0.01655113f, -0.01276072f, 0.04882556f, -0.10577036f, -0.03728379f, -0.06993104f, 0.04151324f, -0.03008663f, 
    -0.10161830f, -0.12002651f, 0.16784751f, -0.22415461f, -0.04722188f, 0.03080040f, 0.00766663f, -0.00120541f, 
    -0.00453302f, 0.00134482f, -0.03535585f, -0.00362186f, -0.04378732f, 0.05871233f, 0.01024632f, -0.10070869f, 
    -0.02432852f, 0.03979305f, 0.03456934f, 0.06759877f, -0.30142012f, -0.17250225f, -0.01772317f, 0.10991107f, 
    0.08373150f, 0.06546392f, -0.06275479f, -0.01007048f, -0.06498532f, 0.15415439f, -0.04590949f, 0.01503962f, 
    -0.05910477f, 0.03060068f, -0.07928395f, 0.00309280f, -0.03787133f, 0.07779063f, 0.05792352f, -0.01712850f, 
    -0.21537961f, 0.02456571f, -0.18128628f, 0.12325284f, -0.06890719f, 0.07578722f, 0.06504215f, 0.06722364f, 
    0.00683352f, -0.18381104f, 0.05993029f, 0.04657888f, -0.06334089f, -0.05072022f, -0.04759097f, 0.06513386f, 
    -0.06961815f, -0.03217087f, -0.06657259f, 0.02444797f, 0.14119992f, -0.05373371f, 0.03576202f, -0.08613513f, 
    -0.07668974f, 0.05358203f, -0.01478389f, -0.05061155f, -0.10697354f, -0.03374382f, -0.06861634f, -0.00430389f, 
    0.00347693f, 0.04100733f, 0.01911149f, -0.01377566f, -0.06452105f, -0.07427035f, -0.06703036f, 0.01737723f, 
    -0.40706164f, -0.04961807f, -0.23546271f, -0.08305223f, -0.02715730f, 0.06147893f, 0.02552732f, -0.12197280f, 
    -0.02519241f, 0.00237472f, 0.06363206f, -0.04619649f, -0.07308119f, -0.09048592f, 0.08175427f, -0.00689558f, 
    -0.08597772f, 0.01720638f, -0.03706972f, -0.00902216f, 0.00022855f, 0.03033680f, -0.09061921f, 0.03936345f, 
    0.04970356f, -0.05694137f, 0.03922739f, -0.06826406f, 0.01095121f, -0.01387602f, 0.03414652f, 0.04612528f, 
    0.04812934f, -0.01155312f, 0.02271019f, -0.01478384f, -0.02228313f, 0.05532019f, -0.02598793f, 0.06599956f, 
    -0.02146304f, -0.08120047f, -0.02862791f, -0.08610699f, 0.01860121f, 0.04093127f, 0.00674843f, 0.01534289f, 
    -0.01332581f, -0.00072836f, 0.00061298f, 0.05132444f, -0.05722782f, -0.00410665f, -0.02314165f, -0.00976881f, 
    -0.08820254f, -0.17780921f, -0.18281078f, -0.02772147f, 0.04619051f, 0.01601317f, 0.04039374f, -0.05405758f, 
    -0.03561961f, 0.00319166f, 0.00728568f, -0.02509991f, -0.02187259f, 0.05320431f, 0.02780269f, 0.08289039f, 
    -0.07531284f, -0.06598990f, -0.03205463f, -0.03713404f, 0.00882574f, 0.12145903f, -0.00331881f, 0.00317315f, 
    0.10440333f, 0.06490310f, -0.00235856f, 0.01332948f, 0.00283777f, -0.05575967f, 0.01244410f, -0.00457152f, 
    0.06199137f, -0.04225598f, -0.00254213f, -0.01630022f, 0.03522666f, -0.05275262f, -0.00680371f, -0.05909178f, 
    0.02036532f, 0.10945008f, 0.05884916f, 0.04498368f, -0.40488920f, -0.17990164f, -0.17081298f, -0.16301718f, 
    -0.14779980f, 0.06413208f, 0.03315212f, -0.04161254f, -0.04579621f, 0.05283659f, 0.06726563f, 0.03620168f, 
    0.02253734f, 0.05453553f, -0.00247106f, 0.02057293f, -0.04069965f, -0.00040264f, 0.03597534f, 0.02425071f, 
    -0.44801348f, -0.14507149f, 0.09220645f, -0.05968952f, -0.23682575f, 0.07143157f, -0.01987608f, -0.04128557f, 
    -0.07067366f, 0.03029521f, 0.01584146f, -0.02405434f, -0.01164858f, 0.13738434f, 0.07110174f, -0.03456365f, 
    -0.10868592f, 0.00903661f, -0.01725085f, -0.05380484f, -0.00848071f, -0.07363283f, -0.04403169f, -0.03194614f, 
    0.12277445f, -0.09728118f, 0.02954386f, 0.02434139f, 0.01337491f, -0.02372671f, -0.01375918f, -0.04704277f, 
    -0.00614385f, -0.06848954f, 0.01674831f, -0.06704514f, 0.05425768f, 0.00456378f, 0.02638962f, 0.04559593f, 
    0.10972293f, 0.00871534f, 0.03463187f, 0.01654763f, 0.10888734f, 0.06334703f, 0.09164316f, -0.01964189f, 
    0.02053827f, -0.06691994f, -0.04643081f, 0.03677515f, -0.02286890f, -0.04834323f, 0.08553977f, -0.03958649f, 
    0.11776573f, -0.05243536f, -0.02649184f, 0.01269612f, -0.06651949f, 0.05458103f, -0.00973058f, 0.05987614f, 
    0.00998323f, 0.05974487f, 0.00126778f, 0.00473879f, -0.06169764f, 0.03209321f, 0.00303340f, 0.02310579f, 
    0.00288342f, -0.00098859f, 0.02060969f, 0.02242948f, -0.06395895f, -0.04344410f, -0.00764255f, 0.03167129f, 
    -0.22627212f, -0.27969617f, -0.05853014f, -0.00256389f, 0.12953907f, 0.07362970f, -0.03649886f, 0.03359459f, 
    -0.02677070f, -0.01962949f, 0.05011203f, -0.00134551f, -0.08526763f, 0.00017141f, -0.05417782f, 0.06209408f, 
    0.01172212f, -0.00271271f, 0.05996477f, 0.10756902f, -0.47813189f, -0.11997677f, -0.02010365f, -0.09856489f, 
    -0.27049458f, 0.10047495f, -0.00638908f, -0.03962874f, -0.05716429f, 0.06885383f, 0.02976781f, -0.02443973f, 
    0.03243035f, 0.02997407f, 0.02824990f, -0.03991964f, -0.01757803f, 0.00730361f, 0.02364549f, 0.04261695f, 
    -0.30841964f, -0.15951665f, 0.11292867f, -0.03433545f, -0.19190349f, -0.00511123f, 0.01882258f, 0.02692789f, 
    -0.02881957f, 0.02084019f, 0.00604270f, 0.02440159f, 0.00503670f, -0.06993724f, -0.02058623f, -0.03600278f, 
    -0.02083489f, -0.02856444f, -0.04119774f, -0.06371863f, -0.38430163f, -0.26137081f, -0.10750147f, -0.01857840f, 
    0.03529676f, 0.06358823f, 0.02866633f, -0.05469593f, -0.03458401f, -0.07220083f, 0.07622983f, 0.02055658f, 
    -0.00340682f, 0.05930637f, -0.00893218f, 0.01904122f, -0.03215208f, 0.03997018f, 0.01644666f, 0.00897190f, 
    -0.10119841f, -0.15597676f, -0.02786829f, -0.05421548f, 0.10079007f, 0.06168550f, 0.03020737f, 0.04908416f, 
    -0.01077978f, -0.00607454f, 0.01972955f, 0.03775673f, -0.01284786f, -0.01794660f, 0.06339294f, 0.04258616f, 
    -0.06480404f, -0.03687737f, 0.06070748f, 0.06138152f, 0.13893460f, 0.00053153f, -0.07055981f, -0.08326468f, 
    0.06436355f, -0.07812294f, -0.02926922f, -0.09875354f, 0.02495063f, -0.06983534f, 0.05458342f, 0.03598356f, 
    0.01292083f, -0.06914920f, -0.02507891f, -0.07768644f, -0.00277686f, -0.01516271f, -0.08860674f, 0.01429525f, 
    -0.34425506f, -0.02110226f, -0.28243700f, 0.06294665f, 0.19177331f, -0.04594363f, -0.03022441f, -0.08936620f, 
    -0.01324951f, 0.03290544f, 0.02275300f, -0.04770270f, 0.04365067f, -0.15007830f, 0.10710172f, -0.00175358f, 
    0.06601917f, 0.00908542f, -0.03554335f, -0.13995467f, 0.14013086f, 0.16242379f, -0.09508152f, 0.04240811f, 
    0.00599536f, -0.01073741f, -0.00042048f, 0.02665003f, 0.03418569f, 0.01934887f, 0.00065743f, -0.02573519f, 
    0.03397636f, -0.02832490f, 0.02136489f, 0.00767258f, 0.09967729f, -0.01477929f, 0.04532712f, 0.08033189f, 
    0.17738496f, -0.05701143f, -0.03226005f, -0.11638350f, -0.04815922f, -0.05649340f, 0.00298189f, -0.09566912f, 
    0.05569233f, -0.01850705f, -0.06223843f, 0.08760665f, -0.13156471f, -0.01533667f, 0.04271231f, -0.03495743f, 
    0.05454388f, 0.08650697f, 0.03099427f, 0.03250640f, -0.10249753f, 0.09437283f, 0.05936432f, -0.01770914f, 
    -0.04270429f, 0.09609114f, -0.01948869f, 0.00023310f, -0.01232092f, -0.01511905f, -0.03291863f, 0.06341043f, 
    0.00112501f, 0.03718320f, -0.00795828f, 0.00625532f, -0.03304370f, 0.04028575f, 0.00771055f, 0.05104842f, 
    -0.29007784f, 0.03480062f, -0.13940740f, -0.01428738f, -0.01490270f, 0.04210868f, 0.01480489f, -0.02871480f, 
    0.01469403f, 0.05910062f, 0.00212741f, 0.00845501f, -0.02094882f, 0.08225506f, 0.05150456f, 0.06543867f, 
    0.01612279f, 0.10190207f, -0.05031066f, 0.08260540f, -0.47056326f, -0.27474517f, -0.07074222f, -0.14150667f, 
    -0.27030429f, 0.02701514f, -0.00346927f, -0.05805262f, -0.01495430f, 0.10074843f, 0.01686839f, 0.03024326f, 
    0.00198937f, 0.06086256f, -0.04938338f, 0.06082449f, 0.00762753f, -0.00252396f, -0.03241357f, 0.00473141f, 
    -0.39582008f, -0.10824047f, -0.16682087f, -0.13042985f, -0.13475072f, 0.03877421f, -0.00478983f, -0.05958411f, 
    -0.05845388f, 0.01319651f, -0.02732419f, 0.00422554f, -0.07600223f, 0.12303207f, -0.00133497f, -0.02628761f, 
    0.01943216f, 0.04325105f, -0.04749723f, 0.02138498f, 0.14054380f, 0.11532071f, -0.04986740f, 0.03748186f, 
    0.01406810f, -0.08168387f, -0.08649439f, 0.06565306f, 0.01576704f, 0.00532662f, 0.03940046f, -0.02503486f, 
    0.03445522f, -0.02020018f, -0.02197532f, 0.05177094f, 0.01891513f, 0.08929091f, 0.04122594f, 0.02018297f, 
    -0.11016563f, -0.00891701f, -0.18030651f, -0.05800112f, -0.00874047f, 0.05703438f, 0.01225228f, -0.04976992f, 
    -0.00567895f, -0.00521162f, -0.01426696f, -0.01539675f, -0.02534980f, -0.00150307f, 0.00625277f, -0.07443866f, 
    -0.00346653f, 0.05491145f, 0.08082207f, 0.05685385f, 0.22245094f, 0.18616541f, 0.06914675f, 0.01734255f, 
    0.06223020f, -0.00628095f, 0.01070954f, 0.06534996f, 0.05630246f, 0.03431185f, -0.02029114f, 0.02162143f, 
    0.02225934f, 0.04266352f, -0.01148363f, 0.11460672f, -0.06406953f, -0.14175452f, -0.19638449f, -0.01937131f, 
    -0.02649163f, 0.20465568f, 0.16163129f, -0.09771734f, -0.15037474f, 0.05988843f, -0.03331641f, -0.03528417f, 
    0.04318371f, 0.02006168f, -0.01459390f, 0.02333350f, 0.06811378f, 0.05688887f, 0.01214435f, 0.01472797f, 
    0.05353616f, -0.09701265f, -0.08003578f, -0.02008477f, -0.08783966f, -0.00314793f, -0.05085291f, 0.11114478f, 
    0.04824992f, -0.03952929f, 0.02959767f, -0.00532453f, -0.00232851f, 0.08155813f, 0.01581447f, 0.08714844f, 
    -0.00258980f, 0.02556539f, 0.08033906f, 0.06271452f, 0.02275282f, -0.01169979f, -0.04093284f, 0.02561468f, 
    0.23220076f, 0.03373379f, -0.07030800f, 0.05913203f, -0.20040688f, -0.05293368f, 0.00191127f, 0.07529697f, 
    -0.01521717f, -0.05721972f, 0.02732196f, -0.02773808f, 0.00820213f, -0.07942550f, -0.02175966f, -0.05021384f, 
    0.09630697f, -0.13027047f, -0.08457918f, -0.05129451f, 0.11858511f, 0.11268177f, 0.10485582f, -0.02793925f, 
    0.03212057f, 0.09940551f, 0.02943303f, 0.02424163f, 0.03570452f, -0.00137077f, -0.03459649f, 0.02932281f, 
    0.04257447f, 0.06955484f, 0.01188948f, 0.01954763f, 0.02939509f, -0.09921484f, -0.09219697f, -0.00226244f, 
    -0.12512651f, -0.10974412f, -0.13773516f, -0.02686770f, 0.01139940f, 0.03894101f, 0.01668608f, -0.00826226f, 
    0.01197670f, 0.01285442f, 0.10606693f, -0.01468156f, 0.03226488f, -0.02565966f, -0.01361459f, 0.08055979f, 
    0.06869797f, 0.04870961f, 0.09224670f, 0.05639152f, -0.33610094f, -0.14556710f, -0.11168052f, -0.17994997f, 
    -0.04349952f, 0.09564109f, -0.00346637f, -0.02506036f, -0.10384693f, -0.03348267f, 0.00482552f, 0.05711721f, 
    -0.06496853f, -0.18084876f, 0.08896790f, -0.03416877f, -0.06552090f, 0.08769073f, -0.01495791f, 0.04891758f, 
    0.17928743f, 0.00896227f, -0.05505443f, 0.05210024f, -0.07850324f, -0.04091959f, 0.01472553f, 0.01702014f, 
    0.04471393f, 0.00360237f, -0.01395668f, 0.00365761f, 0.01042213f, -0.04839511f, -0.00561117f, -0.02356646f, 
    0.07835602f, -0.07522093f, -0.01732550f, -0.01455543f, 0.08593622f, 0.10053092f, 0.06935904f, -0.00778906f, 
    -0.03292932f, 0.05658229f, 0.02060345f, 0.05292271f, 0.00351063f, 0.05989197f, -0.00227085f, 0.02442680f, 
    0.01288039f, -0.01100290f, -0.00298756f, 0.03312707f, 0.02011069f, -0.12764262f, -0.07134940f, -0.00103830f, 
    0.17752291f, 0.05951460f, 0.04818430f, 0.04561778f, 0.00163525f, 0.06493971f, 0.00170372f, 0.10705546f, 
    0.03155922f, 0.00363396f, 0.01614198f, -0.01636126f, 0.02506817f, 0.04758072f, 0.00928464f, 0.00540233f, 
    0.06989376f, -0.16800362f, 0.02384394f, 0.05695792f, -0.06044505f, 0.10506655f, 0.05615206f, -0.09199157f, 
    0.00989056f, 0.07366979f, 0.05736211f, 0.02301607f, 0.06709752f, -0.03835544f, -0.05380571f, -0.00489718f, 
    0.01264962f, 0.11926285f, 0.03320386f, 0.14153858f, 0.08236483f, 0.04252753f, -0.03567855f, 0.07499404f, 
    0.18265627f, 0.08377955f, 0.05864120f, -0.02622190f, -0.05956275f, -0.13082568f, -0.08494907f, 0.01810043f, 
    0.03228096f, -0.02539534f, -0.02009826f, 0.00156149f, -0.02368162f, -0.06913690f, -0.08018250f, -0.02213011f, 
    -0.00512588f, 0.02877424f, -0.00167818f, -0.06686396f, 0.01751333f, 0.05849402f, 0.02536573f, -0.03444316f, 
    -0.00044027f, 0.02349848f, -0.01504002f, 0.05165477f, -0.00041425f, 0.03109702f, -0.02357956f, -0.00211530f, 
    -0.00292851f, 0.01110452f, 0.01311134f, 0.01186408f, 0.08169908f, 0.06098102f, 0.01040525f, 0.06774192f, 
    -0.22507386f, -0.21528926f, -0.11223022f, -0.03258302f, -0.08700040f, -0.01860695f, 0.06043236f, -0.01339988f, 
    -0.02808997f, -0.00419238f, 0.02277218f, 0.00692782f, -0.03637053f, 0.00276018f, 0.02400980f, 0.02859518f, 
    0.01826506f, 0.12272621f, 0.01492042f, 0.05864158f, 0.17945124f, 0.16946574f, 0.03203444f, -0.01634821f, 
    -0.16397974f, 0.08758083f, -0.02682672f, 0.03231810f, 0.02036391f, -0.02026059f, 0.00432497f, -0.02009384f, 
    0.02456340f, -0.00245425f, -0.04014048f, 0.02994950f, 0.12889057f, -0.02855390f, -0.11676069f, 0.06312431f, 
    -0.15140454f, -0.16422950f, 0.00526126f, 0.01397612f, -0.02347885f, 0.08200926f, 0.09451999f, 0.06001735f, 
    -0.02978867f, -0.00318455f, 0.09035645f, -0.00142147f, -0.02000270f, -0.00814444f, 0.06408198f, 0.01885043f, 
    -0.03326495f, -0.06331395f, 0.01821571f, -0.02142014f, 0.07107058f, 0.10439515f, -0.05183425f, 0.02618294f, 
    -0.01004018f, 0.02082133f, -0.08618843f, 0.03596375f, 0.01433082f, -0.05630040f, 0.02666415f, 0.00579478f, 
    0.01614787f, -0.04701238f, -0.04505602f, 0.02829362f, -0.00714664f, -0.04845844f, 0.04349136f, -0.06715821f, 
    -0.24704933f, -0.10268079f, -0.01274759f, 0.08068059f, -0.07669937f, 0.00394977f, 0.00793427f, -0.03544794f, 
    -0.00375029f, 0.00680534f, 0.04648332f, 0.04315216f, 0.04538299f, -0.04281352f, 0.00949012f, -0.01087164f, 
    0.00025689f, -0.05543983f, 0.09054365f, -0.02868072f, 0.17507906f, 0.08179612f, -0.05204699f, 0.05388236f, 
    -0.06405441f, -0.05745600f, -0.05164699f, 0.01251380f, 0.03015368f, -0.00967474f, 0.00085076f, 0.00768009f, 
    -0.02109362f, -0.03941701f, -0.06085547f, 0.02891806f, -0.01341889f, 0.03383641f, -0.04500430f, -0.00581049f, 
    0.05295883f, -0.05096231f, 0.13004918f, 0.01923339f, -0.05424052f, 0.12090298f, 0.00665689f, -0.01164750f, 
    0.06283543f, -0.00792463f, 0.00578293f, 0.00472229f, 0.02405197f, 0.02217155f, -0.02960117f, 0.02313299f, 
    0.06158200f, -0.03165073f, -0.03574337f, 0.00348122f, -0.25035375f, -0.24431722f, -0.07017602f, 0.00710712f, 
    0.04928929f, 0.05160540f, 0.02992685f, -0.07168701f, 0.01721118f, -0.02114357f, 0.05417953f, -0.00097737f, 
    -0.01033938f, 0.01489808f, -0.00340325f, 0.06929249f, 0.08804628f, 0.06872254f, 0.06738841f, 0.06818639f, 
    -0.16570508f, 0.02791868f, -0.08994075f, 0.07560743f, 0.09501528f, 0.02139606f, -0.03687258f, -0.05094948f, 
    -0.00009854f, 0.07940494f, 0.02974709f, 0.07310902f, 0.03802038f, -0.08475544f, 0.03310424f, 0.05769076f, 
    -0.09575375f, -0.08536883f, -0.11005776f, -0.02317024f, 0.17439012f, -0.10702185f, -0.03203736f, 0.06242641f, 
    0.04074223f, -0.06142135f, 0.02300103f, -0.10371262f, -0.01248095f, -0.07571864f, 0.03640618f, 0.05334259f, 
    -0.04474073f, -0.01640647f, -0.07610119f, -0.08098323f, 0.01370263f, 0.00509154f, -0.13826157f, 0.03259727f, 
    -0.38845494f, -0.09706677f, -0.07974641f, -0.00592726f, -0.11704027f, 0.06645697f, 0.03385187f, -0.04122603f, 
    -0.01619799f, -0.03792208f, -0.04402317f, -0.07290022f, -0.05072193f, 0.08390446f, 0.04488867f, -0.06515031f, 
    -0.01501246f, 0.04099251f, -0.05947118f, 0.06788308f, -0.15130982f, -0.13648473f, -0.01434084f, -0.00898823f, 
    0.09745090f, 0.01970767f, 0.03147994f, -0.01298084f, 0.03020171f, -0.04362819f, 0.03528223f, -0.13922915f, 
    0.03978027f, -0.12010147f, -0.03726292f, -0.07080747f, -0.07209910f, -0.17350222f, 0.05096724f, -0.03529243f, 
    -0.15507452f, -0.30105150f, -0.04209070f, -0.07650811f, 0.01093671f, 0.10468245f, -0.03328203f, -0.09753528f, 
    -0.05254285f, 0.04868899f, 0.07820416f, -0.05790115f, -0.00642120f, 0.06073415f, -0.04117095f, 0.06648490f, 
    0.07432345f, 0.04889204f, 0.17980003f, 0.12274125f, -0.20927082f, 0.00900106f, -0.36575064f, 0.10240778f, 
    0.16585575f, 0.00084026f, -0.06382725f, -0.06189234f, -0.06355140f, 0.06438956f, 0.00276269f, -0.05968596f, 
    0.11811852f, -0.06619525f, 0.08531570f, -0.02768697f, -0.06533123f, 0.03425419f, 0.01708545f, -0.04350087f, 
    -0.05123242f, 0.13213046f, -0.05370492f, 0.01719007f, -0.06352544f, -0.01010631f, 0.01457658f, 0.03232721f, 
    0.04299248f, 0.07286127f, -0.02919764f, 0.03990976f, 0.03600469f, 0.02330977f, 0.03402391f, -0.04138038f, 
    0.09079425f, 0.11503041f, 0.01334271f, 0.06452722f, 0.03064401f, -0.02662454f, -0.01886106f, -0.01688215f, 
    0.01156338f, -0.03246845f, -0.01245566f, -0.00091165f, 0.01507691f, 0.01284365f, 0.01129932f, 0.06573031f, 
    0.01797211f, -0.02957146f, -0.05024805f, 0.01555278f, -0.00907154f, -0.06030900f, -0.04326335f, 0.00438723f, 
    -0.31474736f, -0.11428236f, 0.14490917f, 0.09456712f, -0.10249135f, 0.06239165f, -0.03944211f, 0.04605855f, 
    -0.05407663f, 0.04239715f, 0.01733186f, 0.00453784f, 0.05818048f, -0.13346505f, -0.01573097f, -0.09432898f, 
    -0.14835641f, -0.04552856f, 0.06776753f, -0.02684230f, 0.04906471f, -0.10458279f, 0.04193930f, 0.12352560f, 
    0.03258734f, -0.04068483f, 0.00745962f, 0.05855342f, 0.00639493f, 0.05686359f, -0.00142222f, -0.08469433f, 
    -0.08605094f, -0.10294695f, -0.09571292f, -0.07447570f, -0.07088070f, -0.19119009f, -0.02129616f, -0.04334232f, 
    -0.02214949f, 0.11003542f, -0.00492501f, -0.14541392f, -0.07986377f, 0.10419844f, 0.04975530f, 0.05573742f, 
    -0.02482533f, 0.03699379f, -0.03571774f, 0.02134651f, -0.00746739f, 0.06045944f, -0.04054074f, 0.04116223f, 
    0.00866458f, -0.09985708f, -0.11626054f, 0.05755989f, -0.23648608f, -0.11743890f, -0.13057639f, 0.04465821f, 
    0.18541646f, 0.08857723f, 0.03631723f, -0.03063625f, -0.00153306f, -0.05274115f, 0.09322751f, 0.03580099f, 
    0.02060875f, 0.02641776f, 0.14856477f, 0.00247539f, 0.05124182f, 0.03268965f, 0.00991817f, 0.03944384f, 
    0.17200050f, 0.08462116f, -0.04663027f, 0.01452531f, -0.13025229f, -0.03490636f, -0.04943520f, 0.05253081f, 
    0.04458458f, 0.01222784f, 0.00182077f, -0.06975637f, 0.03474808f, -0.05374625f, -0.01963024f, 0.02586520f, 
    0.06891680f, 0.00144401f, 0.04018477f, 0.00091043f, 0.10748935f, -0.02513077f, 0.00077853f, 0.02101800f, 
    -0.03121914f, -0.01485711f, -0.01488603f, -0.01239100f, 0.04837490f, -0.01027401f, 0.00223184f, -0.01936445f, 
    -0.04586315f, 0.04274663f, -0.02622217f, -0.04439348f, -0.00710558f, -0.01453879f, -0.04826088f, 0.02036458f, 
    0.00777219f, 0.05904592f, 0.01694660f, -0.06839316f, -0.09056190f, 0.00430959f, 0.07087705f, -0.00230893f, 
    0.09178359f, 0.07523704f, -0.01541434f, 0.02787440f, -0.02154385f, -0.03862825f, -0.03847096f, 0.12314212f, 
    0.03182636f, 0.04399787f, 0.04212757f, 0.07882108f, 0.17157514f, 0.10106103f, -0.09006819f, 0.15557307f, 
    -0.03732459f, -0.05639565f, -0.10277448f, 0.07543179f, -0.04933752f, -0.02142049f, 0.06648821f, -0.00475154f, 
    0.05174744f, -0.03362607f, -0.03821766f, 0.00678329f, -0.09171017f, -0.00856730f, 0.00139150f, -0.08767232f, 
    -0.23363383f, -0.25113302f, -0.14109020f, -0.08415789f, -0.05404356f, -0.03999169f, 0.03790791f, -0.06246335f, 
    -0.05974283f, -0.10198245f, 0.00807594f, -0.12972806f, -0.01418122f, -0.07850315f, 0.03596892f, -0.08976318f, 
    -0.00511644f, 0.03442113f, 0.04483824f, 0.03626882f, -0.13850178f, -0.02802421f, -0.11323478f, -0.02892361f, 
    0.05121721f, -0.00992291f, 0.03722064f, -0.06765448f, 0.02327122f, 0.03800329f, 0.00554124f, -0.01729987f, 
    0.06379227f, 0.00421276f, 0.06604600f, 0.02117361f, 0.07951931f, 0.12335537f, 0.05569549f, 0.11801098f, 
    -0.16383567f, -0.09841283f, -0.05903654f, -0.03506159f, -0.16425158f, -0.05104212f, 0.02800407f, -0.03869692f, 
    0.04516344f, 0.00213791f, -0.03332522f, -0.02706310f, 0.04641537f, 0.03553705f, -0.01017223f, 0.01070209f, 
    0.03080421f, -0.13126267f, -0.05296504f, 0.04952785f, -0.35623568f, -0.04686335f, 0.11256722f, -0.05404247f, 
    0.10265339f, -0.06823152f, 0.05341291f, 0.01697086f, 0.03836031f, -0.04155988f, -0.03168721f, 0.01618630f, 
    0.04148601f, -0.00904312f, -0.02009540f, -0.02013599f, 0.01579283f, -0.03580387f, -0.07102051f, 0.04403308f, 
    0.06778115f, 0.16514179f, -0.03990928f, -0.10751104f, -0.07347941f, -0.08867116f, -0.15092914f, -0.00579841f, 
    -0.10858323f, -0.05965770f, 0.04367192f, -0.05109790f, 0.06680530f, -0.01067498f, 0.00710929f, 0.07178720f, 
    -0.00476051f, -0.06402677f, 0.02766036f, 0.05502158f, -0.21198282f, -0.07169597f, 0.05253175f, -0.11488181f, 
    0.00100756f, -0.06200160f, 0.05556084f, 0.01082683f, 0.03770552f, -0.05395731f, -0.11059394f, 0.02220788f, 
    0.00469159f, 0.02815622f, -0.07432910f, -0.06078175f, 0.02797302f, 0.01618058f, -0.03902630f, -0.01055513f, 
    -0.31096312f, -0.23194417f, -0.09234045f, -0.06910265f, -0.05598278f, 0.02333480f, 0.03034396f, 0.02013222f, 
    0.00328962f, 0.09596939f, -0.07467213f, -0.01464914f, -0.01136014f, -0.01238071f, 0.00735141f, 0.01099306f, 
    -0.08397155f, -0.00968502f, -0.14889476f, -0.04754989f, 0.27783000f, -0.09691275f, -0.18106458f, -0.02550701f, 
    -0.15954021f, 0.02865227f, 0.02043207f, 0.06412475f, -0.07022008f, 0.01970587f, 0.09472472f, -0.00914285f, 
    -0.04105614f, 0.00263246f, -0.04434127f, 0.04261981f, 0.00776629f, -0.04625810f, 0.02984395f, -0.00111266f, 
    0.11559973f, 0.14945906f, -0.09769933f, -0.28048784f, 0.00194719f, -0.05133763f, -0.03467183f, 0.01935900f, 
    0.05133974f, 0.03979547f, -0.00199303f, -0.01632114f, -0.00877293f, -0.02162234f, 0.03028095f, -0.01236622f, 
    0.01755253f, -0.02029621f, -0.01671842f, 0.03500291f, -0.30456135f, 0.11900680f, 0.02921787f, 0.04792486f, 
    -0.01606878f, 0.20547676f, 0.01779025f, 0.04343035f, 0.01321768f, 0.04931768f, -0.01198231f, 0.02482478f, 
    -0.03447656f, -0.02342293f, -0.00213642f, -0.02216193f, 0.06152202f, -0.03871827f, 0.00926205f, -0.00945417f, 
    -0.23369454f, 0.30009985f, -0.06455889f, 0.00404774f, 0.21513966f, 0.03670590f, 0.04847323f, -0.06522838f, 
    -0.05591540f, -0.03192841f, 0.02363426f, 0.09455951f, -0.00334916f, -0.01141446f, 0.00521511f, 0.06738147f, 
    0.06632876f, -0.04975232f, -0.07538787f, 0.00319318f, -0.09545325f, 0.00652006f, 0.00326981f, 0.04440834f, 
    -0.00185688f, -0.04417532f, 0.01678615f, -0.00071687f, -0.06058015f, -0.12116543f, 0.03525330f, -0.02638246f, 
    0.02555818f, 0.04398724f, 0.02858158f, 0.01391658f, -0.00997358f, 0.02269400f, -0.00078885f, -0.03950301f, 
    0.09958592f, 0.16891313f, -0.06110664f, 0.09905797f, 0.11230993f, 0.14085443f, 0.01668610f, 0.01278629f, 
    -0.03882245f, 0.00368538f, -0.00481303f, 0.06524252f, 0.05529060f, 0.03103510f, -0.05558197f, -0.02729605f, 
    0.02453036f, -0.09579171f, 0.01577827f, 0.08028647f, 0.35522309f, -0.11514132f, -0.15650591f, 0.01188678f, 
    0.06338331f, -0.00173134f, -0.07321332f, -0.00147042f, -0.06807135f, 0.01423326f, 0.11571007f, -0.00851023f, 
    0.04830733f, 0.08633953f, -0.07410432f, 0.12097032f, 0.04325474f, -0.06542788f, 0.01676413f, -0.05910436f, 
    0.25347817f, 0.10820104f, -0.11286455f, -0.13098438f, 0.02779916f, 0.04713679f, -0.06979368f, 0.01506265f, 
    -0.00898206f, -0.02268574f, 0.09155139f, 0.05403887f, -0.12239470f, 0.02188467f, -0.06746582f, -0.02381815f, 
    0.02877706f, 0.04586525f, 0.03219625f, -0.00579950f, 0.17508280f, -0.00567951f, -0.08482733f, 0.08655956f, 
    -0.14658803f, 0.07660269f, 0.07427324f, 0.02738838f, -0.01583710f, 0.00096099f, -0.01493188f, 0.03604379f, 
    0.00044230f, 0.04638077f, 0.06880700f, -0.03321087f, 0.01337615f, 0.02729256f, -0.03377076f, 0.03255067f, 
    0.13680235f, -0.02907824f, -0.00678845f, 0.05835145f, 0.07667037f, 0.05838385f, -0.03123815f, -0.05317999f, 
    0.01583257f, 0.03497679f, -0.00043397f, 0.01049623f, 0.03903074f, 0.03474946f, -0.04392696f, 0.03915786f, 
    0.01111917f, -0.02759770f, -0.03289077f, -0.02936881f, -0.30654684f, 0.18319711f, -0.00222763f, 0.03467171f, 
    0.02876521f, -0.00288782f, -0.09990866f, -0.02285214f, 0.06409656f, 0.03011416f, -0.00722372f, -0.01624511f, 
    0.08370052f, -0.02561355f, 0.03744311f, 0.03229687f, -0.03255796f, -0.01050908f, -0.08328020f, -0.02796202f, 
    -0.26063055f, 0.03398369f, -0.04972903f, 0.04611043f, -0.14132664f, -0.10792831f, 0.08081783f, -0.07938333f, 
    0.02846666f, -0.00685643f, -0.12004079f, -0.00403107f, 0.08566183f, 0.06556804f, 0.01595799f, 0.02935515f, 
    -0.02125406f, 0.00706884f, -0.02257922f, -0.05960400f, -0.01187058f, 0.02860687f, 0.06265486f, 0.10328276f, 
    0.06295346f, 0.01050261f, 0.04671999f, 0.06237142f, 0.07943610f, 0.00252171f, 0.07830434f, -0.10555921f, 
    -0.04920911f, 0.05468283f, 0.03255613f, 0.01704331f, -0.00406811f, 0.01206013f, 0.01250768f, -0.02375150f, 
    -0.22661826f, -0.21321903f, -0.08650319f, -0.08751021f, -0.11648498f, 0.05738004f, 0.05896480f, 0.04031848f, 
    -0.01073101f, 0.07528018f, -0.16940083f, 0.07940311f, 0.07908720f, -0.01600217f, -0.12280212f, -0.08392955f, 
    -0.08016682f, -0.00703749f, -0.18329301f, -0.06626676f, -0.01466712f, 0.02085501f, -0.04655011f, -0.20903088f, 
    -0.00907183f, 0.03000868f, -0.05356723f, -0.02405453f, 0.02546520f, 0.02891603f, 0.04948978f, -0.02737812f, 
    0.00659262f, 0.02272942f, 0.01795076f, 0.02618444f, -0.04254394f, 0.06666934f, 0.02540713f, 0.01503230f, 
    0.24681881f, -0.03848768f, -0.07820176f, 0.01488984f, -0.08869664f, -0.11171245f, 0.11495360f, -0.04113977f, 
    0.03167570f, -0.00907781f, 0.01088516f, -0.00762058f, 0.02810497f, -0.01767591f, 0.05719968f, 0.03381022f, 
    0.02005880f, 0.00579285f, 0.02182316f, -0.03499964f, 0.52579248f, 0.06469573f, -0.24645153f, -0.00261888f, 
    -0.06166387f, -0.07078618f, -0.07119836f, -0.01580556f, -0.02136055f, -0.00508562f, 0.08241129f, -0.01601313f, 
    -0.00229765f, 0.00184961f, -0.04347787f, 0.05090759f, -0.05020122f, -0.01092834f, -0.03647599f, 0.01953129f, 
    0.31918505f, 0.04328042f, -0.07350605f, -0.09356240f, -0.14308712f, 0.01425735f, 0.03493908f, -0.04773070f, 
    0.06863326f, 0.03825170f, 0.08391842f, -0.00549036f, -0.00673600f, -0.06146809f, 0.06571422f, 0.01142460f, 
    -0.08407801f, -0.05984616f, -0.00856135f, 0.08178813f, -0.05193269f, -0.13001645f, 0.09169623f, 0.00870004f, 
    0.05260293f, 0.00803008f, 0.03051470f, 0.05107127f, -0.02230755f, -0.04481466f, 0.01311418f, -0.07655393f, 
    0.03974051f, 0.00064032f, -0.01355282f, -0.15946791f, -0.05493405f, -0.01716587f, -0.07448328f, -0.04634536f, 
    -0.09825624f, -0.14370139f, 0.00298255f, 0.02659849f, 0.03261070f, -0.02378858f, 0.08173259f, -0.04394321f, 
    0.00639561f, 0.04886194f, -0.01188762f, 0.10630778f, 0.02995505f, 0.06124678f, 0.02015286f, 0.02390262f, 
    -0.02962058f, -0.03426192f, -0.08523686f, -0.04417086f, -0.09911519f, -0.02404702f, -0.00452873f, -0.04447240f, 
    0.19108592f, -0.01105953f, -0.10935630f, 0.02401716f, 0.06482112f, -0.09252417f, 0.03706127f, -0.08891112f, 
    -0.03449855f, 0.10551069f, 0.02843108f, 0.07065056f, 0.03869789f, -0.03862568f, 0.11723592f, 0.06767705f, 
    0.25974160f, -0.03863601f, -0.07338695f, -0.05636869f, 0.29919991f, 0.07295860f, -0.04276430f, -0.00904835f, 
    0.05529406f, -0.02804296f, 0.03631948f, -0.09189240f, 0.01720194f, 0.04304964f, 0.07037263f, 0.05970240f, 
    0.01964910f, 0.00929131f, 0.02549640f, 0.05266259f, -0.02149537f, 0.07989036f, -0.06015674f, 0.01211182f, 
    -0.12359535f, -0.04363738f, -0.03217506f, -0.02366965f, 0.00459919f, -0.02086432f, -0.07336450f, -0.01080255f, 
    0.10065880f, -0.04588838f, -0.02680944f, 0.03085377f, 0.00137677f, 0.00456646f, -0.02789089f, -0.09316529f, 
    0.27375278f, -0.04697297f, 0.01937364f, -0.00591927f, -0.07588410f, -0.00089385f, -0.01933159f, 0.03792487f, 
    -0.05966306f, -0.08933409f, -0.00432005f, -0.07068884f, 0.03456218f, -0.03669016f, -0.11248050f, -0.01102162f, 
    0.00507994f, 0.07830921f, -0.01017345f, 0.00908647f, 0.24221288f, -0.04582747f, -0.19650379f, 0.00881079f, 
    0.06988028f, -0.08345222f, 0.08703976f, -0.07245496f, 0.05855978f, -0.05574834f, 0.07351112f, 0.04094936f, 
    0.00036646f, 0.02826656f, -0.01743459f, 0.03836378f, -0.02231485f, 0.05796717f, 0.01006479f, 0.02712509f, 
    0.12181413f, -0.07054765f, -0.09389918f, 0.06395662f, -0.07536276f, 0.11355671f, 0.02237263f, -0.05815730f, 
    -0.03260377f, 0.01418913f, 0.01031977f, -0.02569995f, -0.01750145f, 0.03350513f, -0.02054241f, -0.02775218f, 
    -0.04158604f, 0.01278850f, -0.06689696f, 0.01436681f, -0.21376596f, -0.35460594f, 0.13503808f, -0.04761359f, 
    0.08313217f, -0.08823963f, 0.09761258f, 0.00836357f, -0.01165754f, -0.00437371f, 0.01900560f, -0.09453690f, 
    -0.04638865f, 0.07293394f, -0.02879059f, -0.07071899f, 0.03621763f, -0.01007426f, -0.04437200f, -0.01708858f, 
    -0.02984834f, 0.10384380f, -0.08140408f, -0.03667337f, -0.01137382f, 0.01799018f, -0.04095234f, 0.03119969f, 
    -0.05274330f, -0.06284252f, -0.06594083f, -0.00620247f, 0.06935985f, -0.08991680f, -0.00997550f, 0.03222713f, 
    0.00798156f, 0.03352170f, -0.03945130f, -0.08950262f, -0.06866497f, 0.07175124f, 0.01023471f, -0.09456074f, 
    0.23729962f, 0.05208372f, -0.05072390f, 0.00792199f, 0.01758592f, -0.03313567f, 0.04566579f, -0.01766386f, 
    0.01105453f, 0.01370395f, -0.01117568f, -0.06632447f, 0.04402663f, 0.03990501f, 0.06606785f, 0.06266847f, 
    0.11924836f, -0.03211259f, -0.03064130f, -0.09257773f, 0.00516927f, -0.12594539f, -0.03420200f, 0.04647223f, 
    -0.04225211f, -0.02533827f, 0.08232136f, -0.00585677f, -0.05214731f, -0.02031326f, -0.08279561f, 0.10326882f, 
    -0.06096560f, 0.05302250f, 0.08644855f, -0.08936493f, -0.12112059f, 0.17617720f, -0.06621788f, -0.16690469f, 
    0.13914314f, 0.05682409f, -0.04370544f, 0.04483234f, 0.10596180f, 0.01768225f, 0.02946332f, 0.09224337f, 
    -0.02769342f, -0.05972517f, -0.00978970f, -0.08087841f, -0.07788792f, 0.06710455f, 0.01524009f, -0.00654384f, 
    -0.00193475f, -0.07824285f, -0.00223963f, 0.02865038f, 0.02112190f, -0.02789675f, -0.03271372f, -0.00326240f, 
    -0.01742516f, -0.07689060f, -0.04464509f, -0.02742077f, 0.02707875f, 0.00749183f, -0.03661585f, -0.07015260f, 
    -0.09134794f, 0.00009428f, 0.00587020f, 0.03486977f, -0.22514534f, 0.15858717f, -0.01281897f, -0.02823147f, 
    0.03533179f, 0.01052608f, 0.02141861f, 0.01581825f, -0.03469558f, 0.03828305f, -0.01471628f, -0.00416820f, 
    0.00173610f, -0.05624079f, -0.00296489f, -0.04738430f, -0.04855880f, -0.07298166f, 0.02256195f, -0.03348519f, 
    0.01987494f, 0.08889106f, -0.14058827f, -0.01712718f, -0.02522142f, 0.08110201f, 0.01910248f, 0.02941837f, 
    -0.01037671f, 0.06829774f, 0.06438011f, 0.03379537f, -0.02666697f, -0.01302979f, 0.02831298f, 0.02716652f, 
    -0.06595241f, -0.02300492f, -0.06517433f, -0.01924186f, -0.16919281f, 0.10085332f, -0.05366362f, 0.06798966f, 
    0.16295904f, -0.03926694f, -0.03218377f, 0.00857393f, 0.06648247f, 0.06334011f, -0.08269486f, -0.07245946f, 
    -0.07835105f, -0.00592532f, 0.15467198f, 0.02800481f, 0.00083963f, -0.00784757f, 0.08318216f, -0.05768179f, 
    0.07440531f, 0.12629043f, -0.08156853f, 0.12544762f, 0.02695260f, 0.11610968f, -0.09978252f, -0.05868340f, 
    0.05446763f, 0.04003002f, 0.04758425f, 0.07323663f, -0.02563402f, 0.01128272f, 0.05509781f, -0.04429441f, 
    0.06838125f, 0.10728641f, -0.04497745f, 0.00544271f, 0.25240654f, -0.15813959f, 0.00358281f, 0.06683318f, 
    -0.02072126f, 0.02773619f, -0.01725250f, -0.02866069f, -0.01174048f, -0.06847457f, 0.05611948f, -0.04950425f, 
    0.01890890f, 0.06167961f, -0.07660890f, -0.04244661f, 0.01527063f, -0.01200442f, -0.07116242f, 0.00914085f, 
    -0.00796502f, 0.06005313f, -0.07443419f, 0.11482978f, -0.24094041f, 0.06375260f, 0.03972964f, 0.01684235f, 
    -0.01626763f, -0.06115271f, 0.01262044f, 0.00693283f, 0.03282088f, 0.02431682f, -0.04139421f, -0.00721414f, 
    0.08568878f, -0.01289617f, -0.11168668f, -0.04817319f, -0.01466293f, 0.08257695f, -0.00279801f, -0.00885581f, 
    0.10313442f, -0.11360151f, 0.01377486f, 0.02308561f, 0.00521155f, -0.04064257f, -0.07148407f, 0.04813631f, 
    -0.01759396f, 0.02756482f, 0.03050275f, -0.01687203f, -0.04028460f, 0.00638558f, -0.06371719f, -0.03110460f, 
    0.17715003f, 0.11972848f, -0.11270092f, -0.06416248f, 0.13541064f, 0.06243651f, -0.02043442f, -0.07577781f, 
    -0.03295407f, 0.03614471f, 0.03482727f, 0.08873960f, -0.00300941f, -0.04919744f, 0.01615151f, -0.03068885f, 
    -0.07521539f, -0.01468720f, 0.03423880f, 0.01920249f, 0.10155676f, 0.01809098f, -0.05666985f, 0.03249291f, 
    -0.03483118f, 0.11621290f, 0.01996601f, -0.04098590f, -0.01833213f, 0.00317169f, -0.00929740f, 0.01569265f, 
    -0.02300013f, -0.00009931f, 0.01956432f, -0.07005779f, 0.00030168f, 0.01979874f, -0.07222688f, 0.01626470f, 
    0.17153107f, -0.01396050f, -0.17608240f, 0.13896270f, -0.22912048f, -0.09911928f, -0.07314237f, 0.01655788f, 
    0.03530538f, -0.02397401f, 0.08543000f, -0.06739993f, 0.06839652f, 0.03087985f, -0.01105560f, 0.05353217f, 
    0.03047809f, -0.07650882f, 0.00627843f, -0.02578821f, -0.10879087f, 0.16670242f, 0.02399768f, 0.01081094f, 
    -0.13151069f, 0.09398876f, -0.11451305f, 0.00721136f, -0.02229137f, 0.01314898f, 0.00834681f, -0.05093821f, 
    0.03661684f, -0.09793650f, -0.03402354f, 0.01074073f, 0.01575065f, -0.02455346f, 0.09624744f, -0.00889877f, 
    0.03249041f, 0.19673942f, -0.16377936f, -0.09279995f, -0.17340791f, -0.03582103f, 0.01915541f, -0.00792422f, 
    0.06750478f, 0.00838413f, 0.02750096f, -0.01778355f, -0.10256664f, -0.04166644f, 0.10024531f, 0.02805868f, 
    -0.00792093f, -0.01300184f, -0.07559379f, 0.06531256f, -0.11950281f, 0.01330615f, -0.14169446f, 0.10819719f, 
    -0.08591122f, 0.05463701f, -0.02063957f, 0.08269513f, -0.07860985f, -0.02096499f, 0.04849748f, 0.04375491f, 
    -0.06599561f, 0.03290940f, 0.03287526f, -0.08295167f, 0.09207486f, -0.05813548f, 0.00471750f, 0.02810149f, 
    -0.12808751f, -0.14415774f, -0.02139157f, -0.06468960f, 0.06269209f, 0.19072479f, -0.08843262f, -0.01033555f, 
    0.02938825f, 0.01024797f, -0.07373215f, 0.07679344f, -0.05965336f, 0.01743174f, 0.10353097f, -0.03857235f, 
    0.04689449f, 0.04167443f, -0.06071997f, -0.07151966f, -0.16438530f, -0.02134051f, -0.03024012f, 0.09934690f, 
    -0.06653554f, -0.01473559f, 0.10551040f, -0.03707102f, 0.03575112f, -0.06592606f, 0.02218853f, -0.09327584f, 
    0.01276064f, 0.11103382f, 0.00748277f, 0.04138583f, -0.03925139f, -0.00717911f, -0.04373765f, -0.05099249f, 
    -0.24471112f, 0.17218739f, 0.04454613f, -0.07803114f, 0.06457487f, -0.09500507f, 0.05985053f, -0.00208280f, 
    0.03624379f, 0.00144873f, 0.02553836f, 0.04519622f, 0.01158238f, 0.01954870f, 0.06985357f, -0.00570416f, 
    -0.07865518f, 0.01396796f, -0.08819196f, -0.12118909f, -0.02787502f, 0.08483429f, 0.05224334f, -0.05884616f, 
    0.04684632f, -0.05542151f, -0.05516789f, -0.03034946f, 0.03442532f, -0.11465527f, 0.00295068f, -0.01685603f, 
    0.00159064f, 0.03980969f, 0.03119426f, 0.01279752f, -0.05644122f, -0.00175218f, -0.00684856f, 0.05863620f, 
    -0.17123711f, -0.29205078f, -0.02512670f, -0.06490234f, 0.05005235f, 0.03132042f, -0.13878581f, 0.07312807f, 
    0.00728278f, 0.05437569f, -0.09821080f, 0.02712098f, -0.06293106f, 0.04410107f, -0.00227214f, 0.01328310f, 
    0.11929504f, 0.00365660f, -0.07828075f, -0.08963946f, -0.01949720f, -0.07340338f, -0.11668306f, -0.16882776f, 
    0.00294322f, -0.03781299f, -0.13732937f, 0.10674316f, -0.05033039f, -0.14228807f, 0.02879759f, 0.01920923f, 
    -0.06120807f, -0.05989552f, -0.08158672f, 0.04353996f, -0.06298502f, -0.04402889f, 0.12095867f, -0.03692404f, 
    -0.26795581f, 0.21161810f, -0.06800638f, -0.14503264f, 0.09984104f, -0.00583587f, -0.09327348f, 0.07412332f, 
    -0.08003327f, 0.01357560f, 0.00546563f, 0.04703565f, 0.06316080f, -0.07926744f, 0.00621214f, 0.04285522f, 
    0.01446102f, -0.06177038f, 0.01255988f, -0.08247884f, -0.09457569f, -0.32469347f, 0.05478366f, 0.08212820f, 
    0.16649894f, -0.05449040f, 0.13179882f, -0.12382106f, 0.04989210f, -0.00677843f, -0.00398655f, -0.01895213f, 
    -0.07778440f, 0.03875032f, 0.01890828f, 0.00478853f, 0.07933373f, 0.03091708f, -0.07050454f, -0.00740079f, 
    0.10379358f, -0.01059525f, 0.04371475f, -0.06435920f, -0.06845693f, -0.00258021f, 0.04560677f, 0.07995552f, 
    -0.02878089f, -0.09564909f, 0.00123702f, -0.10565446f, -0.04226232f, 0.04032988f, -0.07448419f, -0.03192423f, 
    -0.02449221f, 0.05976296f, -0.01986597f, -0.01985758f, -0.01938495f, 0.10920991f, -0.05089182f, -0.04171326f, 
    -0.03902274f, -0.00728513f, -0.08477443f, 0.03562051f, -0.09628484f, -0.09809089f, 0.03205323f, -0.02011842f, 
    0.07938601f, -0.07892682f, -0.03571703f, 0.05173672f, -0.00735302f, -0.05868827f, 0.10103159f, -0.06617463f, 
    0.18253541f, 0.16872235f, -0.14977467f, 0.10579382f, 0.24586795f, 0.08054774f, -0.01240604f, -0.05156927f, 
    0.02063068f, 0.04689023f, -0.06903552f, 0.00435186f, -0.00921478f, 0.00481205f, -0.01227284f, 0.00279187f, 
    0.05829185f, 0.02433047f, 0.01933615f, -0.10226234f, 0.22365862f, -0.18831283f, 0.00534090f, 0.04059254f, 
    -0.03913920f, -0.04411718f, 0.12325008f, 0.04173703f, -0.02821455f, -0.05304172f, -0.08224102f, -0.09431445f, 
    0.00038648f, 0.13570595f, -0.11206120f, -0.05105409f, -0.08796955f, 0.01985862f, -0.07916305f, -0.01783368f, 
    -0.37322077f, -0.18549371f, -0.17756604f, -0.16557474f, -0.39580891f, 0.05174993f, 0.03219209f, 0.06607817f, 
    0.01972510f, 0.11365863f, 0.00985532f, 0.02055720f, -0.04210914f, -0.05902658f, 0.07348321f, -0.04132150f, 
    -0.03664354f, -0.10404810f, -0.05871605f, -0.04142786f, -0.18112633f, 0.01628870f, -0.01616116f, -0.03662980f, 
    0.07881894f, 0.01742954f, 0.07442947f, -0.02130726f, 0.05576244f, 0.04818295f, 0.02868685f, -0.02458018f, 
    -0.03890245f, 0.00458826f, -0.00683168f, -0.04026840f, -0.01967530f, -0.04078396f, -0.05360354f, -0.04307768f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04735146f, 0.04671435f, -0.05189699f, -0.01277059f, -0.00143842f, 0.00426781f, -0.01417309f, -0.05835419f, 
    -0.03128916f, -0.01541769f, 0.02331973f, 0.03043780f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
