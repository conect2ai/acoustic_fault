#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.16953957f, 0.73458344f, 0.11345360f, 0.86861086f, 0.58860421f, -0.65335262f, -0.06291619f, 0.19817263f, 
    -0.38333255f, 1.38583446f, 1.37876678f, 0.45444933f, -0.53626311f, -0.49515930f, 0.09624741f, 0.07534033f, 
    0.66175294f, 0.02022691f, 0.40990892f, 1.29548144f, 1.60533655f, 0.08470024f, 0.63004845f, -1.14342499f, 
    0.13592625f, 0.71752799f, 0.37652397f, 0.44177812f, -0.30889717f, -0.16416793f, -1.54561162f, -0.66978508f, 
    -0.61879241f, 0.23304230f, 0.47212175f, 0.48461387f, -1.08639205f, -0.45010254f, -0.92626768f, -0.20389403f, 
    1.34017956f, -0.04520196f, -0.21737975f, -0.24095376f, -0.34027773f, -0.91183376f, -1.22140539f, -0.68426841f, 
    -0.90094560f, 0.62410885f, 0.96854293f, 0.59123498f, -0.19431269f, 0.26270556f, 0.70446539f, 0.68575919f, 
    0.42982718f, 0.34544930f, -1.50328398f, 0.10396522f, 0.53668123f, -0.37492934f, 0.00909792f, 1.62244415f, 
    0.27462280f, 1.11938763f, -0.06249643f, -0.31711426f, 0.86770618f, -0.28235713f, -0.11611413f, 0.38319412f, 
    -1.23525131f, -0.81578958f, -0.26358825f, 0.78823268f, 0.88908571f, 0.67563838f, 0.06337865f, -0.57878929f, 
    -0.44234949f, 0.70619947f, 0.34525225f, 0.11646987f, 0.97571886f, 1.10869980f, 0.78166991f, 0.18926510f, 
    -0.72219938f, 0.41780940f, 0.04378472f, 1.14532602f, -0.63954747f, -0.73301739f, 0.50965291f, 0.44632736f, 
    -0.13676035f, 0.62324739f, 0.94433218f, -1.64793599f, 0.19972467f, 1.13013756f, 0.52382600f, 0.58828950f, 
    -0.90617096f, -0.01361863f, -0.24472514f, -0.55527973f, -0.73819870f, -1.37594569f, -1.18930805f, -0.37265399f, 
    -0.17445011f, 0.02528105f, -0.43027908f, 0.61457974f, 0.09260124f, -1.19385588f, -0.54444605f, -1.52231252f, 
    -0.14733994f, -0.72349983f, -0.70980644f, -0.01680202f, -0.23797487f, -0.18645895f, -0.01886852f, 0.91633606f, 
    -0.85936111f, -0.16331182f, -0.60407954f, 0.76904535f, 1.02012372f, 0.15708956f, -0.40013441f, 0.18832119f, 
    -0.31135118f, 0.65679324f, -1.26510930f, -0.96938473f, -0.92689186f, -0.42414495f, 0.42343086f, -0.58508664f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.61091101f, -0.22348304f, 0.08369716f, 0.39782426f, 0.26700607f, 0.33644542f, 0.09455683f, 0.34966195f, 
    0.25836042f, 0.27207425f, 0.07243193f, -0.25582576f, 0.18609424f, 0.68984216f, -0.40313974f, 0.73529023f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.24695764f, 0.04803842f, 0.00456608f, 0.10780931f, -0.00091573f, 0.16303575f, 0.04060612f, 0.29056829f, 
    -0.06455044f, 0.09493282f, 0.22443974f, 0.19809772f, -0.10696032f, -0.07960805f, 0.05965737f, 0.16526495f, 
    0.00468210f, -0.05358632f, 0.52438909f, 0.12974738f, 0.19768895f, -0.23066142f, -0.16647451f, 0.06950770f, 
    0.28419852f, 0.15016010f, 0.11724496f, 0.47621307f, 0.27989116f, -0.05015330f, -0.08606996f, 0.03910645f, 
    0.32932773f, 0.19138427f, -0.31678715f, 0.32123870f, -0.29027757f, -0.92418325f, -0.60570830f, 0.09724881f, 
    0.14074959f, 0.01097368f, -0.03556311f, -0.16848199f, -0.33672774f, -0.15850657f, -0.17150977f, -0.23733972f, 
    0.15467352f, -0.16212106f, 0.28306565f, 0.08843321f, -0.18192811f, -0.30493206f, 0.07743469f, 0.08063927f, 
    0.28730264f, 0.17298079f, -0.01530881f, 0.23182406f, -0.04201045f, 0.26282212f, 0.06003990f, -0.12455124f, 
    0.30200002f, 0.05861013f, -0.11413259f, 0.07565261f, 0.12692469f, 0.06068498f, -0.17857224f, 0.02789132f, 
    0.02108878f, -0.13339847f, -0.41551772f, 0.01315645f, 0.16157264f, -0.29843637f, -0.19374762f, -0.10738362f, 
    -0.22821938f, 0.17152025f, 0.54901868f, 0.43519104f, 0.25227028f, -0.12595029f, -0.13315102f, 0.14786038f, 
    -0.05629771f, -0.06442527f, 0.15669282f, 0.23623623f, 0.16123503f, -0.05024565f, -0.22998255f, -0.15140264f, 
    -0.21470013f, 0.09949463f, 0.35603341f, -0.63421595f, -0.56163043f, -0.50387698f, 0.10922089f, -0.01251798f, 
    -0.21330246f, 0.12846395f, -0.01352587f, 0.16713673f, -0.26410532f, 0.35947251f, -0.06699541f, 0.07654177f, 
    0.22312424f, -0.02897149f, 0.08633842f, 0.07858519f, -0.12532395f, -0.08538043f, 0.58570951f, -0.28060490f, 
    0.24033254f, 0.12125179f, 0.08650448f, 0.01080379f, 0.11419097f, -0.18771860f, -0.21251807f, -0.20773272f, 
    0.06087445f, -0.08890121f, 0.06707554f, -0.05179261f, 0.19535710f, -0.19384626f, 0.08426756f, -0.14780626f, 
    -0.05150111f, -0.17152140f, 0.04257806f, 0.05268953f, 0.64282507f, -0.11294775f, -0.00677794f, 0.06266204f, 
    -0.05425655f, 0.03692782f, -0.01121722f, 0.06431964f, 0.02149986f, 0.07181007f, -0.06069512f, 0.02861013f, 
    0.00998728f, 0.03017425f, 0.01178200f, 0.01885379f, 0.01754367f, 0.00598076f, 0.05141842f, 0.04343288f, 
    -0.01835406f, -0.05316575f, -0.08432661f, 0.04886466f, 0.00591987f, 0.02252345f, 0.02107218f, 0.04713154f, 
    -0.02092760f, 0.05578886f, -0.08143129f, 0.05824663f, 0.04568622f, 0.01064425f, 0.03512270f, -0.07939038f, 
    -0.00630946f, 0.02053633f, 0.01930705f, -0.06532410f, -0.07095794f, -0.01442485f, -0.06155365f, 0.03025722f, 
    -0.07948992f, -0.05441709f, -0.00422545f, -0.06092125f, 0.03701147f, -0.00943869f, -0.07447371f, -0.03696310f, 
    -0.07458531f, -0.06279662f, -0.06820124f, -0.05982675f, 0.05883758f, -0.03164681f, -0.03414784f, -0.07671130f, 
    -0.00828330f, -0.07074708f, -0.03950523f, -0.01846689f, -0.02484670f, 0.05512316f, -0.01891900f, -0.09473646f, 
    -0.06481416f, -0.06181471f, 0.04036263f, -0.07552676f, -0.00187169f, -0.05503862f, 0.03421809f, 0.04148015f, 
    -0.04648821f, -0.06230431f, -0.03414311f, 0.03501325f, -0.01704421f, -0.09961903f, -0.03857261f, -0.06629445f, 
    -0.02136672f, 0.00906589f, -0.03103509f, -0.08531076f, -0.05507864f, -0.07441767f, -0.05796147f, 0.06005238f, 
    -0.09200212f, 0.04123765f, -0.01761214f, -0.00962465f, 0.05775633f, -0.00779232f, -0.03186374f, 0.06963745f, 
    0.03062320f, 0.04236940f, 0.00924568f, 0.01871543f, -0.07198942f, 0.02517370f, -0.03616675f, -0.02968915f, 
    -0.00558975f, 0.07092085f, -0.02044810f, -0.00423980f, -0.08932411f, -0.04756620f, -0.00840649f, -0.04751829f, 
    -0.06873979f, 0.08042019f, 0.06385519f, -0.04509628f, 0.04489768f, -0.02392428f, -0.03101484f, 0.06290817f, 
    -0.04122147f, -0.03571202f, -0.07562151f, -0.06757361f, -0.02062334f, -0.03654766f, -0.03733512f, -0.01902994f, 
    -0.04877140f, -0.08370311f, 0.02645427f, 0.04270058f, 0.05677447f, 0.05971076f, -0.07268985f, -0.09233515f, 
    -0.03364781f, 0.03990873f, -0.02122529f, -0.04434760f, -0.00514548f, 0.06325404f, 0.05470705f, 0.04826957f, 
    -0.65212500f, -0.20973781f, -0.29977489f, -0.04316409f, 0.21138634f, 0.11526190f, 0.17344385f, 0.04043182f, 
    0.20090219f, -0.96018744f, -0.58684975f, -0.13775201f, 0.24105807f, -0.10434964f, -0.00221006f, 0.06747678f, 
    -0.11234081f, -0.29665029f, -0.32721490f, 0.02056445f, 0.01262631f, 0.09219395f, -0.00457303f, 0.10030618f, 
    -0.09358685f, 0.28450403f, 0.32849836f, 0.28712866f, 0.19346647f, 0.01938819f, -0.07661973f, -0.18981014f, 
    -0.09813994f, -0.07081693f, 0.11216778f, -0.00596952f, 0.32680634f, 0.09382723f, -0.26913586f, -0.10490207f, 
    -0.01285812f, -0.06803043f, 0.23334922f, 0.10448911f, -0.09698638f, 0.00761999f, 0.01548079f, 0.10358108f, 
    0.07633494f, -0.26206827f, -0.02672607f, 0.01693323f, 0.26315367f, -0.06933253f, -0.16060881f, 0.10506943f, 
    -0.12125802f, 0.28363386f, 0.27554864f, 0.05422279f, -0.24489506f, 0.12550864f, 0.03746581f, -1.01751101f, 
    -0.50054669f, 0.37148011f, 0.07107292f, 0.42183894f, 0.18958914f, 0.12685056f, -0.12372085f, 0.17211454f, 
    0.50822949f, 0.10301377f, -0.19910938f, -0.14728403f, 0.11833192f, -0.00379076f, 0.03934831f, 0.20758358f, 
    -0.28086179f, -0.12008136f, -0.03846838f, -0.35735440f, 0.05220145f, 0.00740229f, -0.08477303f, 0.00277195f, 
    0.32950646f, 0.06449451f, -0.12709227f, -0.09251580f, -0.24192590f, -0.20053525f, -0.00484192f, 0.05704882f, 
    0.16939585f, 0.30066660f, 0.26629463f, -0.09042323f, 0.03389363f, -0.21332774f, -0.18567865f, -0.00071111f, 
    0.06580606f, -0.09547593f, -0.27882558f, 0.01963045f, -0.31528729f, 0.35374287f, -0.00332899f, -0.03223192f, 
    -0.17448084f, -0.04715742f, -0.08269013f, 0.14840047f, 0.28993377f, 0.05142120f, -0.10322184f, 0.05593636f, 
    -0.00370511f, -0.10938446f, 0.28250930f, 0.04802942f, 0.01943821f, 0.01782297f, -0.34671673f, -0.34190738f, 
    -0.46959186f, -0.16933608f, -0.23509111f, -0.04677426f, -0.01874816f, -0.16131362f, -0.02711914f, 0.68835431f, 
    0.59122777f, 0.56621432f, 0.20706613f, 0.16208307f, 0.41970810f, -0.25415081f, 0.04261798f, 0.10075253f, 
    0.59200382f, 0.17248468f, 0.12131673f, -0.05616802f, 0.01838433f, 0.04920154f, 0.19368345f, 0.03355689f, 
    0.04953984f, 0.28287974f, 0.06474564f, 0.03176991f, 0.02318279f, -0.19072019f, -0.02927429f, -0.05924570f, 
    0.00873639f, -0.18650587f, 0.02751849f, 0.28383768f, -0.84663439f, 0.07498083f, -0.04282945f, 0.16783115f, 
    -0.16277036f, 0.05833174f, 0.23437820f, -0.12755418f, 0.27858081f, -0.34322894f, 0.19536886f, 0.12940943f, 
    -0.04204144f, 0.05156217f, -0.06179022f, 0.17809050f, -0.61241448f, -0.11091242f, -0.04403630f, -0.11128959f, 
    -0.04167518f, -0.26353213f, -0.09207040f, 0.06485500f, -0.07477263f, -0.41210783f, -0.41087529f, 0.30663061f, 
    0.04124388f, -0.10937894f, 0.18482871f, -0.17145891f, 0.10418960f, 0.16379452f, -0.16232900f, 0.49071172f, 
    -0.37490046f, -0.22236273f, 0.10466262f, 0.01462922f, 0.18922658f, 0.13001578f, 0.12996432f, -0.50926226f, 
    -0.20472126f, 0.16904472f, 0.25660810f, 0.20575963f, 0.11593574f, -0.08137080f, -0.00736725f, -0.05326857f, 
    0.40294379f, -0.21482423f, 0.33591709f, -0.00919943f, -0.12075420f, -0.19779812f, -0.12689751f, -0.13393559f, 
    -0.07131848f, 0.06193369f, -0.10353697f, -0.07314479f, 0.04999895f, 0.08658771f, -0.22017564f, 0.02866901f, 
    0.06091252f, 0.06728092f, -0.17654309f, 0.15156637f, -0.40688485f, -0.04967473f, -0.21137209f, 0.00344651f, 
    0.04063884f, 0.14499438f, 0.26521817f, -0.76872522f, 0.34791520f, -0.13803297f, 0.03875239f, -0.01828062f, 
    0.10831631f, 0.03404612f, -0.02489577f, 0.01833028f, -0.05763397f, -0.00233648f, 0.21334216f, -0.10461801f, 
    -0.13350278f, -0.15319474f, -0.10331953f, -0.29226160f, -0.14796928f, -0.13334635f, -0.22395967f, 0.24868703f, 
    0.36375841f, 0.02914827f, 0.02732093f, -0.01326069f, 0.20506087f, 0.08462815f, -0.38156706f, 0.21878868f, 
    -0.54502958f, -0.21224721f, 0.10522605f, 0.16078818f, -0.10768012f, 0.07974934f, -0.13754195f, -0.24198133f, 
    0.18097322f, -0.07743885f, 0.31198758f, 0.09279151f, 0.02885284f, 0.02505632f, 0.10046204f, 0.09308676f, 
    0.22383079f, 0.19128279f, 0.09310763f, 0.08296277f, -0.02682959f, 0.01141864f, 0.13269407f, 0.10514031f, 
    0.17408676f, -0.40749758f, -0.51577389f, -0.00310628f, 0.12484764f, 0.25996944f, -0.11450025f, -0.00714604f, 
    -0.12170952f, -0.04978991f, 0.05542878f, -0.34084281f, 0.50662011f, -0.07924975f, -0.03872836f, 0.32258296f, 
    -0.05786433f, -0.06045726f, -0.16548282f, -0.05612578f, -0.07998413f, 0.18845616f, -0.09334942f, -0.03764656f, 
    -0.30529961f, 0.18750805f, -0.09336735f, -0.09405915f, 0.17107998f, 0.47797310f, 0.16082448f, -0.03337348f, 
    -0.16013590f, -0.14345662f, -0.19883898f, 0.19299744f, 0.27901709f, -0.12850370f, -0.10718662f, -0.02941746f, 
    -0.02444866f, -0.00496553f, -0.05706929f, -0.07775408f, 0.00281893f, -0.11499766f, -0.00883600f, -0.20122750f, 
    0.12844311f, -0.13055901f, 0.09136625f, -0.06793419f, -0.20709424f, 0.11805774f, -0.07924214f, -0.02396236f, 
    -0.16763338f, -0.28740242f, -0.08716428f, 0.32527643f, 0.18664335f, -0.02336614f, -0.20824243f, -0.29561904f, 
    -0.02882949f, -0.03771838f, -0.10605164f, 0.01809211f, 0.05911221f, -0.04851874f, -0.07129848f, -0.09841648f, 
    0.05718369f, -0.48100588f, -0.13590118f, -0.11997446f, 0.14160152f, -0.07379074f, 0.09687458f, 0.09829383f, 
    0.09261057f, -0.19819590f, -0.04205004f, -0.25991294f, 0.26888824f, 0.03850713f, 0.20396726f, -0.22942008f, 
    -0.00785389f, -0.09304453f, -0.25243914f, 0.55006838f, 0.02764093f, 0.66449803f, -0.04163728f, -0.24447392f, 
    0.21484843f, 0.09276872f, 0.07144094f, 0.14828144f, 0.05137420f, -0.36839569f, 0.12243473f, 0.17612211f, 
    0.07677998f, -0.20208408f, 0.09691946f, -0.21606113f, -0.10016432f, 0.18660153f, -0.23734327f, 0.06915281f, 
    -0.26874119f, 0.00199962f, -0.07759307f, 0.08881071f, 0.13382724f, 0.45219019f, 0.10187013f, 0.00013777f, 
    -0.10555848f, -0.17522655f, 0.24711226f, 0.05805546f, -0.37185922f, 0.12939025f, -0.18217970f, 0.23336214f, 
    -0.00959202f, 0.16726027f, -0.07773608f, -0.05715370f, -0.15572760f, 0.23033887f, -0.12795626f, 0.32954162f, 
    0.21371055f, 0.09662469f, 0.17628559f, -0.42238581f, -0.04506026f, 0.16209453f, 0.19826239f, 0.18312560f, 
    0.06422160f, 0.61020029f, 0.23878810f, 0.00076833f, -0.30043116f, -0.37683299f, 0.14039679f, 0.05661764f, 
    -0.01134270f, 0.11234006f, -0.16648844f, 0.30819702f, 0.03094756f, -0.23487507f, -0.05414645f, -0.01791515f, 
    -0.00509252f, 0.02314111f, 0.27984819f, 0.02734291f, -0.40065604f, 0.21096677f, 0.32302725f, 0.25262460f, 
    -0.01585190f, 0.02482460f, 0.08850074f, 0.06928360f, 0.64132786f, -0.27192217f, -0.53463763f, 0.17446019f, 
    0.05441585f, -0.02049622f, -0.04927765f, 0.06277412f, -0.32844993f, 0.26571667f, 0.26881507f, -0.04117882f, 
    -0.09391508f, -0.14502947f, 0.11041126f, 0.02525119f, -0.14895926f, -0.12562416f, -0.08304834f, 0.19434424f, 
    0.12801512f, -0.00926149f, -0.35465622f, 0.16782443f, -0.06688300f, -0.03507544f, 0.17337529f, 0.12989731f, 
    -0.11232781f, -0.22485027f, -0.03194414f, -0.27244741f, 0.05216639f, 0.10949792f, 0.12293878f, -0.03385336f, 
    0.31776673f, 0.62741584f, -0.19309412f, 0.15441073f, -0.02831708f, -0.07238841f, -0.01726036f, 0.04892868f, 
    -0.05186274f, 0.07944576f, 0.07254181f, 0.38874599f, 0.06014487f, 0.06902848f, -0.23847541f, 0.31754482f, 
    0.01769702f, 0.01656760f, -0.11583438f, 0.42901325f, -0.64878416f, 0.30272961f, -0.22510256f, -0.06973927f, 
    -0.28385249f, 0.00536355f, 0.23622824f, -0.92268258f, 0.02677527f, -0.12653327f, -0.14314672f, 0.11923140f, 
    -0.15991372f, -0.02711090f, 0.02162260f, -0.08966309f, -0.26471451f, -0.20726661f, 0.13112131f, -0.14826667f, 
    0.05547419f, 0.11558770f, 0.00952294f, -0.18109210f, 0.14708151f, 0.22671244f, 0.01086422f, -0.37378845f, 
    0.26541311f, 0.27002430f, 0.35450879f, 0.34490398f, -0.12773459f, -0.01756148f, -0.21115056f, -0.40422824f, 
    -0.36172196f, -0.24188954f, -0.14603654f, 0.23651704f, -0.13160662f, 0.13587758f, -0.02045546f, -0.27701494f, 
    -0.14654216f, -0.31279165f, 0.05137823f, 0.04441423f, -0.07516447f, 0.13486005f, 0.23875144f, 0.13889973f, 
    0.35294175f, -0.04790908f, 0.15870185f, 0.19867720f, 0.06908761f, 0.18781242f, -0.00938575f, 0.27430144f, 
    0.02462690f, 0.73379391f, 0.24720263f, 0.19437264f, 0.31679699f, -0.19649439f, -0.36688131f, 0.29276139f, 
    -0.12865347f, -0.00391413f, 0.54902375f, -0.04205616f, -0.28851745f, -0.02641513f, -0.12704268f, -0.01883267f, 
    -0.00618045f, -0.07319776f, -0.04721796f, 0.17931339f, 0.14710146f, -0.44806799f, 0.30423820f, -0.08186820f, 
    -0.09135786f, 0.25356618f, 0.15221795f, -0.15644558f, -0.42609254f, -0.34536678f, 0.31445453f, -0.20376657f, 
    0.05862466f, 0.03949215f, -0.28785712f, -0.05604752f, 0.25126880f, -0.64536190f, 0.14097753f, -0.10259274f, 
    -0.05988360f, 0.13040072f, 0.01246841f, -0.12453704f, 0.13097478f, 0.07079117f, 0.35253668f, 0.03127384f, 
    -0.11039145f, 0.12034993f, 0.01796600f, 0.41517651f, -0.22194694f, -0.02774527f, -0.17234209f, 0.10299425f, 
    0.15583682f, 0.13387033f, 0.00227836f, -0.12564151f, -0.03526568f, 0.35820562f, 0.09629983f, -0.01653270f, 
    -0.46787298f, -0.00082429f, 0.19315034f, -0.07533666f, 0.00729352f, 0.30474505f, -0.01706176f, 0.20082180f, 
    0.14749917f, -0.30290660f, -0.82795519f, -0.00350326f, 0.17434859f, 0.16828014f, 0.20084770f, -0.09667179f, 
    -0.10694927f, -0.19222850f, -0.58114594f, 0.24300370f, 0.09701169f, -0.06774396f, 0.12477399f, 0.00856936f, 
    0.02814202f, -0.16297224f, -0.13621280f, -0.51903480f, -0.20139939f, -0.36511862f, 0.01397008f, -0.18664180f, 
    -0.02210716f, -0.13798307f, -0.05157125f, -0.03285496f, 0.33117601f, 0.02143878f, -0.16684677f, 0.08674106f, 
    0.14007798f, -0.16388068f, 0.17383306f, -0.14060436f, -0.34181711f, 0.27526554f, -0.04781983f, 0.09946367f, 
    -0.10385581f, 0.04847486f, -0.16075528f, 0.02253967f, -0.10928486f, 0.27342954f, -0.21480450f, 0.11569992f, 
    0.00999695f, 0.03010773f, 0.09639722f, 0.08423190f, 0.07872675f, 0.18497796f, -0.17157227f, 0.24374345f, 
    0.03462400f, -0.31988648f, 0.07856490f, 0.11054252f, -0.24592708f, 0.11062868f, 0.10943345f, 0.10502474f, 
    -0.24648115f, 0.11037640f, 0.05770828f, 0.03422831f, 0.12162420f, 0.11701443f, 0.20823443f, -0.05207495f, 
    0.07345155f, -0.29079366f, 0.24114470f, 0.25591692f, -0.43637484f, -0.06057832f, -0.08940814f, -0.08915348f, 
    -0.04932258f, 0.08285733f, -0.50345320f, 0.20065509f, 0.29291901f, 0.38757840f, 0.29767486f, -0.00151794f, 
    0.14043267f, 0.06511441f, 0.09429668f, 0.00327149f, -0.15365975f, 0.09167132f, -0.11995811f, -0.29550061f, 
    -0.10480101f, -0.18229198f, 0.30580139f, 0.24478562f, -0.26087493f, 0.27479199f, -0.10985104f, 0.05631454f, 
    0.12211012f, 0.25894365f, 0.00679727f, -0.36989000f, -0.03137721f, -0.90442902f, 0.21810025f, -0.56838530f, 
    0.38093799f, 0.04690378f, 0.05038916f, -0.02417545f, -0.25308520f, 0.03395012f, -0.47361454f, 0.02171849f, 
    -0.05357167f, -0.28431937f, 0.24295557f, -0.04075544f, -0.05393484f, -0.12688988f, 0.10091039f, 0.09724557f, 
    0.00244655f, -0.01109083f, -0.01145975f, 0.31279439f, -0.07629265f, 0.19778180f, -0.08883681f, -0.26639798f, 
    0.11452323f, 0.49533647f, -0.05262736f, 0.13797505f, -0.23689263f, 0.20785455f, 0.18610695f, 0.00366330f, 
    0.20217027f, -0.04159152f, 0.23647512f, -0.00725300f, 0.08279797f, -0.12895191f, -0.09654674f, 0.16584207f, 
    -0.00057575f, 0.11925785f, -0.46429017f, -0.26928613f, 0.05662207f, 0.00115559f, -0.06962321f, 0.10046131f, 
    -0.08653131f, -0.00969791f, -0.18571275f, 0.43765494f, -0.02041455f, -0.04637440f, 0.09335261f, -0.10220931f, 
    0.06244542f, 0.06215842f, 0.00275013f, 0.10655276f, -0.57469034f, 0.59087539f, 0.10353542f, 0.35116586f, 
    0.20786439f, 0.22457950f, 0.35968751f, -0.07716013f, -0.08156128f, -0.50024557f, -0.05666743f, -0.01498532f, 
    0.34564510f, 0.27951804f, 0.06701922f, 0.20217831f, 0.06765094f, 0.41110396f, -0.47437567f, -0.38280675f, 
    -0.30867487f, -0.43086687f, 0.21096896f, -0.20130986f, -0.11314917f, 0.14851440f, -0.07992440f, 0.39096797f, 
    -0.16788468f, 0.13616717f, -0.15691397f, -0.17472471f, -0.09276689f, -0.04737680f, 0.22204903f, 0.00547093f, 
    -0.01515179f, 0.02462328f, 0.03071558f, -0.05187292f, 0.01633269f, 0.01773480f, 0.05588692f, -0.04867095f, 
    -0.06382180f, -0.00235298f, -0.07598244f, -0.07980918f, -0.00133256f, 0.05284682f, 0.03538408f, -0.02320528f, 
    0.03202154f, -0.08068376f, -0.02008775f, -0.07273018f, -0.08016153f, -0.04573983f, 0.00803633f, 0.00817992f, 
    0.02047198f, -0.02266082f, 0.04328429f, -0.06082735f, -0.06953721f, 0.05708551f, -0.06745761f, 0.07786242f, 
    0.02941284f, 0.03033771f, -0.02560044f, 0.04078005f, -0.08343413f, -0.00409497f, -0.06596368f, -0.00479749f, 
    0.00067932f, 0.06246912f, 0.02366840f, -0.09452942f, -0.03007052f, 0.01917917f, -0.09000216f, -0.03214662f, 
    0.06128981f, 0.05902481f, -0.05284752f, -0.03929830f, 0.00421008f, -0.06196715f, -0.04878186f, 0.05405108f, 
    0.03620483f, -0.00366205f, 0.03786182f, -0.05299829f, -0.07439543f, -0.05621671f, 0.00759239f, -0.04795730f, 
    0.04397437f, -0.05233289f, 0.02894416f, 0.04874128f, -0.01834824f, -0.06098003f, 0.02075030f, 0.02863851f, 
    -0.01863753f, 0.01690095f, -0.04480577f, -0.05925504f, 0.01258659f, -0.05075403f, -0.01586016f, 0.02304824f, 
    -0.03023739f, -0.05678809f, -0.01968850f, 0.00091102f, 0.05429704f, 0.08075917f, -0.04284560f, -0.06545525f, 
    -0.02040838f, -0.07420246f, -0.06191246f, -0.00714512f, -0.00248486f, 0.06075735f, -0.01931567f, -0.04698002f, 
    0.07168014f, -0.06464905f, 0.05404938f, 0.05038049f, 0.05670083f, -0.03718026f, -0.02776821f, 0.02885144f, 
    -0.01453919f, -0.04282476f, 0.06631570f, -0.01825920f, 0.02774163f, -0.04505859f, 0.06440879f, -0.06223696f, 
    -0.08505413f, -0.02290987f, 0.02742327f, 0.03653069f, 0.00781786f, -0.09176141f, -0.01333058f, -0.04754828f, 
    -0.01816265f, 0.00810477f, 0.01858664f, 0.06805414f, 0.01491751f, -0.01607990f, -0.08548684f, -0.05716681f, 
    0.00042889f, -0.03236455f, 0.05108927f, -0.02193412f, -0.06622690f, -0.09052885f, -0.08965141f, -0.07734787f, 
    -0.07311507f, -0.04569284f, -0.04898970f, 0.06357517f, -0.04334025f, -0.07105918f, 0.06611577f, 0.04828496f, 
    -0.01901902f, -0.17664915f, 0.06307995f, -0.01191839f, 0.08404189f, 0.04916424f, -0.25243333f, 0.05058068f, 
    0.04490285f, -0.07724527f, 0.30059907f, 0.09199116f, 0.11691291f, -0.01475760f, 0.17774759f, -0.14939114f, 
    0.13088025f, 0.03193400f, 0.16660340f, 0.20601137f, 0.08343841f, 0.00177887f, 0.09967487f, 0.00551079f, 
    0.00973342f, -0.11979595f, -0.04962932f, 0.58107263f, 0.35113469f, -0.22806533f, 0.28040159f, 0.14066073f, 
    -0.19433950f, -0.37725294f, 0.25879908f, -0.02940136f, 0.03074642f, -0.31730422f, -0.41440624f, 0.02562466f, 
    0.02311557f, 0.06416946f, -0.00741949f, -0.02796671f, -0.05706671f, 0.72642082f, -0.05605191f, 0.15425204f, 
    -0.26144359f, 0.05557995f, 0.19844419f, -0.24147186f, 0.01355633f, 0.23594049f, -0.37288535f, 0.27293462f, 
    0.07872410f, -0.18204254f, 0.27789488f, 0.25710794f, -0.06701410f, 0.12748337f, 0.13910335f, -0.76381958f, 
    0.34478390f, 0.15427725f, 0.08830516f, 0.09310665f, 0.12569420f, -0.01707263f, 0.17304192f, 0.15144035f, 
    0.26245698f, 0.03632959f, -0.00469646f, -0.21008886f, -0.33807200f, -0.25075674f, 0.12254585f, 0.10835788f, 
    -0.07607052f, -0.14970988f, -0.03075682f, 0.12283956f, -0.05276159f, -0.38469139f, -0.20539345f, 0.10161918f, 
    -0.13933188f, 0.09278607f, -0.22719501f, 0.21113388f, -0.52534425f, -0.13584711f, 0.09850500f, 0.11992660f, 
    0.10889795f, -0.15226832f, -0.10322512f, 0.80814213f, -0.79197395f, -0.27426118f, -0.39428687f, -0.01196270f, 
    0.10666793f, -0.13355584f, 0.17063138f, 0.09831563f, 0.31874031f, 0.08862849f, 0.03033586f, -0.36333504f, 
    0.20028892f, 0.16730313f, -0.04022359f, -0.25357315f, 0.17137897f, -0.79103959f, 0.01114537f, 0.02531401f, 
    0.01791932f, 0.22179852f, -0.06990863f, 0.14463651f, 0.15507829f, -0.00645980f, -0.42938709f, -0.29023001f, 
    -0.41371551f, -0.07809179f, 0.04641410f, 0.02700709f, -0.04998673f, 0.01850104f, 0.18808576f, -0.04127111f, 
    -0.09666641f, -0.27388713f, 0.02972086f, 0.02394650f, -0.11343785f, -0.07562092f, -0.02667697f, -0.07171992f, 
    -0.03729891f, 0.05017500f, 0.02516101f, -0.04723096f, -0.02103974f, 0.03500538f, -0.04979501f, 0.01834416f, 
    -0.04176772f, -0.08363310f, 0.00423918f, -0.07101502f, -0.00359812f, 0.03831525f, -0.05018988f, 0.05117348f, 
    -0.06977357f, -0.03154167f, -0.05566749f, 0.00893583f, -0.02182076f, 0.06670463f, -0.06652672f, -0.03200887f, 
    0.06201066f, -0.01169068f, 0.01655437f, -0.00079090f, -0.01955619f, -0.06296190f, -0.06561359f, 0.07426862f, 
    0.03531918f, -0.02606303f, 0.03539413f, -0.08355948f, -0.02257202f, -0.06349146f, -0.03249219f, -0.00989284f, 
    -0.04341813f, -0.03804407f, -0.02746215f, 0.04251534f, -0.07998845f, 0.03615148f, 0.01113480f, -0.02529218f, 
    0.03164764f, -0.04424634f, 0.00484734f, -0.04054018f, -0.03040256f, 0.02575851f, 0.05066046f, 0.04203677f, 
    0.01467296f, -0.05720740f, 0.04108690f, -0.08829798f, -0.06496809f, -0.06550654f, -0.01631089f, -0.01613129f, 
    -0.02456783f, -0.01521856f, -0.08216335f, -0.08218341f, -0.07459312f, -0.06599575f, -0.02685328f, -0.07707771f, 
    0.01237158f, -0.07148986f, -0.06894191f, -0.09310350f, 0.05495563f, 0.04706899f, 0.00512437f, -0.06996155f, 
    -0.08999871f, -0.07822470f, 0.03360109f, 0.01764133f, 0.05441961f, -0.02280211f, 0.00148528f, -0.07024250f, 
    0.04058436f, 0.02358953f, 0.02953213f, -0.08676483f, 0.05418112f, 0.03535716f, 0.04094430f, 0.03866026f, 
    -0.03242936f, -0.07931321f, 0.02519905f, -0.07584732f, 0.05194256f, 0.05414642f, -0.04071758f, -0.06600264f, 
    -0.06298649f, -0.04749723f, -0.02053977f, 0.06332120f, -0.07459566f, 0.01257615f, 0.02097297f, -0.06719734f, 
    -0.06567939f, 0.05554558f, 0.00404337f, 0.04706645f, 0.03034342f, -0.08287510f, 0.05060149f, 0.05514108f, 
    -0.04227225f, 0.04898953f, 0.05385750f, -0.03033572f, 0.04910018f, 0.03954669f, -0.02704848f, -0.07816942f, 
    -0.06042327f, -0.08026311f, 0.00609813f, -0.05711361f, -0.05856112f, 0.02777524f, 0.00543399f, -0.08756647f, 
    -0.08613167f, 0.02974826f, 0.05363956f, 0.06747753f, 0.06752551f, 0.01140853f, -0.08589485f, -0.00303813f, 
    0.25101942f, -0.12023392f, 0.06924438f, 0.13149580f, 0.05571068f, 0.01777595f, -0.05852268f, 0.31965253f, 
    -0.05836247f, -0.07254291f, -0.19616942f, 0.43755966f, 0.12881041f, 0.27591249f, 0.01076512f, 0.10160029f, 
    -0.21262844f, -0.12853055f, -0.03282752f, -0.17197494f, -0.11362571f, -0.00925376f, 0.21500640f, 0.03572545f, 
    0.06349923f, -0.09671504f, 0.06742311f, 0.36742482f, 0.27360189f, -0.30775586f, 0.00542515f, -0.10664585f, 
    0.05465908f, 0.08295996f, -0.17147544f, -0.12417611f, -0.11408880f, 0.02198000f, 0.25960225f, -0.06785171f, 
    -0.28062502f, 0.09485207f, 0.06348892f, -0.07610298f, -0.00023715f, -0.13566579f, 0.18820573f, 0.10551467f, 
    0.09509195f, 0.02931209f, 0.05730253f, -0.04936055f, 0.12689705f, 0.24275011f, -0.33466366f, -0.09131914f, 
    0.14260143f, 0.09071740f, -0.17983913f, -0.09687760f, -0.07541272f, -0.10713320f, 0.00372926f, -0.20638949f, 
    0.04283085f, -0.29789391f, 0.30818406f, 0.14139234f, 0.03694325f, 0.09936991f, 0.04751515f, -0.14505377f, 
    0.47909263f, 0.15924031f, 0.55077583f, -0.39958468f, -0.20778777f, 0.08430738f, -0.02076183f, -0.02782251f, 
    0.11863524f, 0.25502485f, 0.07167972f, -0.01032896f, 0.00786977f, -0.05631805f, 0.25885326f, 0.06926904f, 
    -0.07994140f, -0.16197792f, -0.20462428f, 0.11158936f, 0.11469203f, -0.09184850f, 0.29076624f, 0.00677038f, 
    -0.15372412f, -0.12458886f, 0.16161971f, 0.25576499f, -0.18281722f, -0.94777030f, -0.07095900f, -0.34301868f, 
    0.07169173f, 0.00335801f, -0.05466266f, 0.08963080f, 0.18823051f, -0.15590428f, 0.28400147f, -0.24019027f, 
    -0.13380948f, -0.28604734f, -0.12447385f, 0.08650695f, -0.06537607f, -0.60071057f, -0.47245243f, 0.21607812f, 
    0.07546704f, -0.01531518f, -0.03686927f, 0.15267217f, 0.07677353f, -0.11636657f, 0.06170553f, -0.41325226f, 
    0.03817724f, -0.01858506f, -0.10430405f, -0.27486733f, 0.18049611f, 0.01361929f, 0.04674084f, -0.17903504f, 
    0.33806887f, 0.08421327f, 0.02807960f, 0.08095773f, -0.13282637f, -0.05579254f, 0.07462233f, 0.05494588f, 
    0.51305020f, 0.47490683f, -0.26553950f, -0.23199922f, -0.15614419f, -0.04662612f, -0.14982587f, 0.19742446f, 
    0.00216608f, -0.44349307f, 0.28337741f, 0.39565939f, 0.10996429f, -0.10583577f, -0.16828135f, 0.20907386f, 
    -0.10180207f, -0.11613341f, -0.19227704f, -0.06950498f, -0.59174609f, 0.13788068f, 0.17136733f, 0.15488562f, 
    0.01095999f, -0.08957128f, -0.15672873f, 0.63939017f, 0.14946559f, -0.58815378f, -0.13421279f, 0.13479160f, 
    -0.15581796f, -0.24609216f, -0.08326861f, 0.07978147f, -0.09416386f, -0.03606921f, 0.54615331f, 0.03643700f, 
    0.19189498f, 0.03471880f, -0.12827928f, 0.01011259f, 0.06943884f, 0.05396809f, -0.19447617f, 0.13640557f, 
    -0.11028130f, -0.09799153f, 0.00352674f, -0.07880779f, 0.02164810f, 0.12395563f, -0.16288191f, -0.22175176f, 
    -0.15832797f, -0.06531248f, 0.15130433f, -0.28202370f, -0.17649147f, 0.15380958f, -0.11066204f, 0.20312017f, 
    0.27537614f, -0.08444798f, -0.03869465f, -0.05490932f, -0.05069412f, -0.25836951f, -0.04285412f, 0.06925993f, 
    -0.25710031f, -0.06583469f, 0.13477357f, 0.25169981f, 0.05124277f, 0.08475051f, -0.02959424f, 0.16568717f, 
    0.15807128f, -0.07707159f, -0.14696871f, 0.48161140f, -0.06712067f, -0.05971617f, 0.16756180f, 0.08117134f, 
    -0.17308152f, 0.09490716f, -0.33161914f, 0.03577384f, 0.11495695f, -0.06005089f, -0.01299053f, -0.09044922f, 
    -0.05411780f, -0.09264993f, -0.13402541f, 0.25209519f, 0.23481053f, -0.35739619f, 0.07406087f, 0.02918532f, 
    -0.03780692f, -0.10261021f, 0.04117246f, 0.10290585f, 0.39581999f, -0.18849806f, 0.67268562f, -0.03691155f, 
    -0.02992978f, 0.02820568f, -0.04425542f, -0.15739997f, -0.04733578f, -0.62028730f, 0.15750027f, 0.44660032f, 
    0.10305384f, 0.01004272f, 0.13524057f, 0.05320029f, -0.15696499f, 0.15862739f, -0.36258337f, -0.12459593f, 
    -0.35395455f, 0.20159960f, -0.07826835f, 0.11723167f, 0.33512998f, 0.03697379f, -0.03971060f, 0.03935919f, 
    0.01447788f, -0.40076724f, -0.05320202f, -0.18061198f, -0.10718519f, 0.08136094f, -0.05009424f, -0.10503855f, 
    0.03957804f, 0.04156837f, 0.05456180f, -0.08647174f, -0.07493348f, 0.01307935f, -0.00627263f, -0.05768229f, 
    -0.00263723f, 0.02131091f, -0.04735682f, -0.06307769f, 0.07733421f, -0.03206593f, 0.01246980f, 0.06354527f, 
    -0.01540135f, -0.08694743f, -0.02804515f, -0.00431164f, 0.03710390f, -0.08005746f, -0.08531646f, 0.05570818f, 
    0.07019912f, -0.04392391f, -0.04243933f, -0.02127251f, 0.01942165f, 0.02250533f, -0.01038759f, -0.05944319f, 
    0.07430945f, -0.08930310f, -0.00395010f, 0.02133001f, -0.07579787f, -0.07938009f, -0.00138935f, -0.03575991f, 
    -0.02381358f, -0.06651577f, -0.06974255f, -0.05077807f, -0.01745440f, -0.01902498f, -0.03104034f, -0.08934651f, 
    0.01501283f, 0.01858162f, -0.03427768f, 0.00270939f, 0.06556585f, -0.06479453f, -0.06808151f, -0.08489210f, 
    -0.00248317f, -0.08985311f, -0.04749851f, 0.06999324f, 0.01628720f, -0.05449619f, 0.06024262f, -0.06760348f, 
    -0.02269408f, 0.03882231f, -0.07895599f, -0.01500691f, 0.03326956f, 0.03367692f, -0.07029373f, 0.03089777f, 
    -0.00769766f, 0.05325881f, 0.02041452f, 0.03581886f, -0.08253604f, -0.00859929f, -0.00647224f, 0.01849377f, 
    -0.04590190f, -0.00274641f, -0.02920652f, 0.00322254f, -0.01269152f, -0.00190804f, -0.05601499f, 0.07548174f, 
    0.01566002f, -0.08751144f, -0.03717719f, 0.04821868f, -0.02178762f, -0.01196335f, -0.01776149f, -0.04682037f, 
    -0.04607286f, 0.03603351f, 0.07098576f, 0.02438070f, -0.05438099f, 0.02800490f, 0.02449250f, 0.00295518f, 
    0.00773353f, 0.04463671f, -0.03040670f, -0.04076650f, 0.02084472f, 0.01522478f, -0.06632689f, -0.08049373f, 
    -0.07792166f, -0.07767764f, -0.03438776f, -0.06560233f, -0.04084995f, -0.03867053f, 0.02645328f, -0.07747733f, 
    -0.01730973f, -0.00715435f, -0.00691186f, 0.00055556f, 0.01958624f, -0.07970116f, -0.08744307f, 0.02702977f, 
    -0.01134886f, 0.04414801f, 0.06752630f, 0.05016703f, -0.01992059f, 0.00529129f, 0.00252467f, -0.03152198f, 
    0.03268293f, 0.03978002f, 0.05359019f, 0.05712251f, -0.03721282f, 0.07167257f, 0.00491286f, 0.02979377f, 
    0.12940015f, -0.27343640f, -0.49897379f, -0.04061238f, 0.00247249f, -0.05599838f, 0.00558089f, -0.12658726f, 
    0.08701466f, 0.13130298f, -0.47646877f, 0.36506265f, -0.04142545f, 0.06537826f, 0.01209613f, 0.27037427f, 
    -0.09755286f, -0.04170094f, 0.91984153f, -0.39571273f, 0.02847192f, -0.06048429f, -0.02229624f, 0.16641304f, 
    0.15486565f, 0.09841122f, 0.20393400f, 0.41042152f, -0.00463169f, -0.29898319f, -0.09331071f, -0.20187175f, 
    -0.16743036f, 0.09663940f, -0.08947601f, 0.02868868f, -0.20513771f, 0.55236566f, 0.18495369f, -0.06950364f, 
    0.25117677f, 0.10210489f, -0.26150739f, 0.03435333f, -0.18353570f, -0.14592329f, 0.20375252f, -0.31535664f, 
    -0.05446863f, 0.04576807f, -0.10971950f, -0.04888336f, -0.01649982f, -0.05821357f, 0.52976012f, -0.67547548f, 
    -0.36629805f, 0.24333797f, 0.03984348f, 0.07649288f, 0.07225612f, -0.00899782f, 0.07775715f, -0.44651797f, 
    -0.40321973f, 0.00151555f, 0.05030509f, -0.03310290f, 0.39633194f, -0.08182210f, 0.19423938f, 0.20602578f, 
    -0.19415221f, 0.18365860f, 0.21466041f, -0.01726450f, -0.00103460f, -0.22205979f, -0.00083947f, 0.25533864f, 
    0.36518458f, -0.53313720f, 0.00391439f, -0.25129214f, -0.17961536f, 0.19827835f, -0.12848826f, -0.05939557f, 
    0.18677977f, -0.01075906f, 0.06577113f, 0.06854754f, -0.12453075f, -0.16306861f, -0.10937852f, 0.10693441f, 
    0.17805178f, -0.16330205f, -0.00708718f, 0.13865986f, 0.18344516f, 0.06277349f, 0.03483902f, -0.03333249f, 
    -0.23998080f, -0.27157372f, -0.10140568f, 0.02932690f, 0.06011051f, 0.42016268f, -0.37107059f, 0.14049534f, 
    -0.37415192f, -0.33118293f, 0.13204834f, 0.26199299f, 0.22381754f, 0.04059198f, 0.12726471f, -0.08190086f, 
    -0.32797772f, 0.17790209f, 0.12980224f, 0.02305593f, 0.13371032f, 0.02098775f, -0.13055968f, -0.15602720f, 
    -0.13227926f, -0.18218793f, -0.04980757f, -0.10767499f, -0.11739272f, 0.21336204f, -0.26147673f, -0.13896219f, 
    0.27457717f, 0.28270963f, 0.21789370f, -0.03081151f, 0.14941798f, -0.08192623f, -0.16818409f, -0.15747610f, 
    -0.17046358f, 0.03912991f, 0.33950385f, 0.09999694f, -0.03898208f, -0.13521507f, -0.14065462f, -0.05946093f, 
    0.07631538f, -0.15371488f, -0.36428350f, 0.28161001f, 0.04942749f, -0.38012558f, 0.03719257f, -0.05526688f, 
    -0.00691932f, 0.15585746f, -0.43639135f, -0.22618890f, 0.24068363f, 0.12189674f, 0.06123477f, -0.08109637f, 
    -0.02296937f, 0.07053716f, 0.06008770f, -0.32558635f, -0.73251337f, -0.46467459f, 0.06493809f, -0.19857983f, 
    0.19381417f, 0.08389683f, 0.15112218f, 0.17312630f, 0.04419116f, 0.17291172f, 0.11225885f, 0.02234698f, 
    0.11098026f, -0.08397529f, -0.10205366f, -0.30343464f, -0.10621086f, -0.44381914f, 0.58280832f, -0.28519747f, 
    -0.02149983f, 0.03399774f, 0.00269156f, 0.14437957f, -0.09963050f, -0.04086435f, 0.24030754f, -0.16161551f, 
    0.07750262f, -0.10134968f, -0.13920118f, 0.11490656f, -0.00953536f, 0.03345254f, 0.07694934f, -0.21795675f, 
    -0.38682386f, -0.01196095f, 0.31518281f, 0.13917892f, 0.09014100f, 0.14183673f, 0.14682068f, 0.16911319f, 
    0.10813291f, 0.36089996f, 0.01027109f, 0.12729198f, 0.18021633f, -0.25661400f, 0.15766862f, 0.03283908f, 
    -0.12862509f, 0.46432573f, -0.36753324f, 0.02818938f, 0.08206915f, 0.16230683f, -0.34768021f, 0.34320125f, 
    0.10231566f, -0.15961967f, 0.24153937f, -0.12076686f, 0.21310912f, -0.28482714f, -0.40610033f, -0.21164738f, 
    -0.12421674f, 0.13446739f, -0.02710862f, -0.16376682f, 0.12745549f, -0.15974443f, -0.01821101f, 0.27020356f, 
    -0.28866982f, -0.19128254f, 0.12640396f, 0.00298016f, 0.21445122f, 0.38810921f, 0.07102490f, 0.18343163f, 
    -0.05157185f, 0.16250969f, 0.33677074f, 0.19887695f, 0.00771043f, 0.12638558f, 0.58221102f, -0.12549876f, 
    0.19787736f, -0.06424402f, 0.18247873f, 0.02038304f, -0.01512677f, -0.16902117f, 0.31112632f, 0.06403928f, 
    -0.28735071f, 0.03164522f, -0.27466571f, 0.00919492f, 0.07612680f, 0.05901654f, 0.16763867f, -0.64570820f, 
    -0.37664530f, -0.26901057f, 0.15360627f, 0.26571605f, 0.06411802f, -0.32371241f, -0.08224831f, -0.12591481f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.22044565f, -0.09247495f, 0.48778668f, 0.38390788f, -0.06757633f, 0.10999309f, 0.04035978f, 0.21692176f, 
    -0.07471501f, -0.24081174f, 0.01802012f, 0.16757441f, -0.25026846f, -0.05005720f, -0.28223935f, 0.01363088f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.49289489f, 0.15922937f, -0.02332307f, 0.15371066f, 0.18794587f, 0.75109977f, -0.37205523f, 0.49233505f, 
    -0.21453184f, -0.32593602f, -0.00522748f, -0.13921826f, -0.54417431f, 0.23379020f, -0.55227572f, -0.19425081f, 
    0.47152075f, -0.24105501f, -0.12149592f, -0.01526692f, -0.46265447f, 0.60704869f, -0.63862759f, -0.17085245f, 
    0.01419189f, 0.12007134f, -0.19442208f, -0.48753291f, 0.09887055f, -0.08691813f, -0.33961079f, 0.23423934f, 
    -0.12780654f, 0.19810577f, -0.31633908f, -0.03594093f, -0.37594214f, -0.12483636f, 0.02356173f, -0.27889460f, 
    0.08585893f, 1.17485380f, -0.16208604f, 0.57491422f, 0.09030681f, -0.25251612f, -0.20092551f, -1.31514466f, 
    -0.42816150f, -0.01525161f, 0.48107916f, -0.30279735f, 0.47356477f, -0.51733708f, -0.05879869f, -0.36285761f, 
    -0.09545512f, 0.01862174f, 0.21994889f, -0.06261884f, -0.69661999f, -0.23617013f, 0.97306055f, -0.42482501f, 
    -0.24798143f, 0.15745641f, 0.11392824f, -0.03121160f, 0.11512796f, -0.36489362f, -0.03869463f, 0.58361638f, 
    -0.17823942f, -0.36861253f, -0.15061301f, 0.51694703f, 0.36746204f, -0.21195118f, -0.51688898f, -0.16373517f, 
    0.65681893f, -0.20064765f, -0.11795051f, -0.08930963f, -0.52279496f, 0.00420774f, -0.50648999f, 0.53057897f, 
    0.07901453f, -0.29389513f, -0.23013858f, -0.52728838f, -0.95768023f, -0.16013138f, 0.02260626f, -0.01209572f, 
    0.55620754f, -0.10514200f, 0.01083578f, -0.44975159f, 0.40879688f, -0.29607603f, 0.46741259f, -0.01658153f, 
    -0.23138435f, 0.30322877f, -0.14005654f, -0.75382054f, -0.53160077f, 0.14872271f, -0.38362038f, -0.38394770f, 
    -0.40315294f, -0.02667953f, 0.04107581f, -1.17916071f, 0.24269216f, -0.46714124f, -0.81619072f, 0.02090521f, 
    0.11849785f, -0.41010958f, 0.04664187f, 0.24084732f, 1.35020232f, -0.00987785f, 0.30397338f, 0.34870854f, 
    0.12466438f, 0.02635976f, -0.32616246f, 1.04668427f, -0.75289327f, -0.00451596f, -0.32510185f, -0.45632109f, 
    -0.23333199f, -0.11568091f, 0.20139912f, 0.25932410f, -0.53133315f, -0.22717762f, 0.16130738f, 0.90917641f, 
    0.17115535f, -0.01899493f, -0.17426227f, 0.80384946f, 0.26386574f, -0.08385731f, 0.19748922f, 0.04276090f, 
    0.16405563f, -0.41395816f, -0.20422719f, -0.15999320f, 0.68455762f, -0.25296286f, -0.34253708f, -0.55313545f, 
    -0.15676473f, 0.21145737f, 1.10401976f, 0.03792659f, -0.62627977f, -0.52532274f, -0.19810553f, -0.46017402f, 
    0.12654944f, 0.02531611f, -0.01324740f, 0.41721350f, -0.51679206f, 0.14552438f, -0.36102119f, -0.00291664f, 
    -0.13753714f, -0.07418825f, -0.23594858f, -0.45758882f, 0.41349822f, -0.04602101f, 0.87159371f, -0.50973201f, 
    -0.10205644f, -0.23725308f, -0.24670035f, 0.01048705f, -0.66224563f, -0.00751475f, 0.85553777f, -0.28954217f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07810006f, 0.29543689f, -0.17312182f, 0.04233490f, 0.45856744f, 0.40198606f, -0.09105627f, -0.36656064f, 
    -0.55551201f, -0.16144997f, 0.17408805f, 0.03998431f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
