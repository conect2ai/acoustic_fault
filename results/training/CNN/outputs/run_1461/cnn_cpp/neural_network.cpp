#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.20904520f, -0.74314988f, -1.02372217f, -0.59961993f, -0.04848946f, 1.01912415f, 0.12705690f, 0.02212825f, 
    -0.19648513f, 0.47931641f, -0.51360893f, -0.42695892f, -0.10348676f, 0.14985903f, -0.31030411f, -0.20671882f, 
    -0.45731476f, 0.28607997f, -0.16249110f, -0.62587398f, 0.20357282f, -0.23142315f, -0.37516227f, -0.00287917f, 
    0.12656753f, -1.20127869f, 0.00837133f, 0.44651482f, -0.78572547f, -0.44162914f, 0.06089995f, -0.34865996f, 
    0.59078723f, 0.37267891f, 0.18218669f, 0.00097952f, -0.00562452f, 0.03363601f, 0.12125204f, 0.09062398f, 
    0.07956155f, -0.23412912f, 0.13153376f, 0.27314299f, -0.20553869f, -0.00092849f, -0.01814580f, 0.35664755f, 
    -0.57075995f, -0.35920197f, 0.20918930f, 0.29650748f, 0.49597266f, -0.50505149f, -0.27130884f, 0.26379648f, 
    -0.21825115f, -0.18659730f, -0.30185926f, -0.31482762f, -0.28912339f, 0.33430165f, -0.32692206f, -0.12380785f, 
    -0.05543819f, 0.46827483f, 0.02629429f, 0.08869430f, -0.24028225f, -0.37586075f, -0.27953544f, 0.23916119f, 
    0.10038374f, 0.24513742f, 0.39620873f, -1.09395540f, -0.33436465f, -0.41035956f, -0.83180219f, -1.08980227f, 
    0.36343035f, 0.16214071f, -0.07387140f, 0.09828469f, 0.58781689f, -0.14820157f, -0.15554979f, 0.17007729f, 
    0.14330640f, 0.10952191f, 0.06555391f, -0.07834042f, -0.31855217f, -0.05460043f, 0.22409147f, -0.23453005f, 
    -0.17299770f, -0.05514208f, -0.37875861f, -0.25025818f, -1.02891946f, -0.72030193f, -0.65762126f, -0.27438536f, 
    -0.23600321f, 0.42770010f, 0.56066591f, 0.31568819f, 0.48867133f, 0.51556629f, 0.09725379f, 0.42346036f, 
    -0.22424722f, 0.02677454f, -0.41810924f, -0.29213202f, -0.26030338f, -0.06014061f, -0.10491057f, 0.20248216f, 
    0.05662904f, 0.08101533f, 0.17838758f, 0.17246355f, -0.02075673f, 1.14986742f, -0.40081078f, -0.41555631f, 
    0.17572536f, -0.36497945f, -0.24587922f, -0.14682046f, 0.32387996f, 0.51590872f, 0.46967119f, -0.28119400f, 
    0.41788399f, -0.30367666f, -0.21162723f, 0.09744476f, -0.04167444f, -0.16446766f, 0.10844226f, -0.03882828f, 
    -0.14621326f, -0.00278417f, -0.15249871f, -0.05091072f, 0.13633464f, 0.14580764f, -0.54404455f, 0.32474554f, 
    -0.75883311f, -0.15748693f, -0.75595784f, -0.87726986f, -0.39659408f, -0.56712097f, -0.22711885f, 0.17251192f, 
    0.53277773f, 0.15833585f, 0.04061901f, -0.17243080f, 0.01519784f, 0.15256344f, 0.02049105f, 0.23259445f, 
    0.21306346f, -0.24067266f, -0.14222787f, -0.25643328f, -0.13893506f, -0.15683311f, 0.45183519f, -1.02412081f, 
    -0.90713376f, 0.27668086f, 0.65895253f, 0.79600018f, 0.13463154f, -0.35714963f, 0.47917554f, -0.10047483f, 
    -0.28678963f, -0.01794240f, -0.16565855f, 0.38424107f, -0.56634748f, 0.10561049f, -0.22992425f, 0.19196120f, 
    0.03450435f, -0.39466387f, 0.28354821f, -0.40243119f, 0.09756459f, -0.41045776f, 0.13542627f, 0.45980617f, 
    -0.72179580f, -0.42912245f, -0.70939875f, -0.27236190f, -0.28670114f, -0.75586480f, -0.86430937f, -0.00714028f, 
    0.03564905f, -0.68398875f, 0.19145751f, 0.12282268f, 0.38059345f, -0.05181194f, 0.03556658f, 0.23557100f, 
    -0.21695670f, 0.05944035f, 0.26096782f, -0.17768387f, 0.24756654f, 0.51171529f, -0.19134040f, -0.05982758f, 
    0.26265711f, -0.07626530f, -0.09727608f, -0.05640327f, -0.12125968f, 0.18812782f, 0.02103865f, -0.05520048f, 
    0.21260613f, -0.10134330f, 0.50541896f, 0.03364274f, 0.33976388f, -0.31083807f, -0.59072489f, -0.31120211f, 
    0.04173657f, 0.16476570f, -0.39604199f, 0.05170264f, -0.21918571f, -0.76872432f, -0.61209524f, -0.23066717f, 
    -0.23104787f, -0.41371411f, 0.11952298f, -0.75364691f, 0.13677925f, 0.73450756f, -0.14520404f, -0.68435907f, 
    -0.80279195f, -0.67792571f, -0.13852000f, -0.61262524f, 0.46375924f, 0.53760141f, 0.28541189f, 0.37476385f, 
    -0.08514657f, -0.02342150f, 0.06551103f, -0.31794038f, -0.05828769f, -0.53386468f, 0.04022108f, -0.02237563f, 
    0.03078744f, 0.13500416f, 0.12005269f, -0.59715664f, -0.42887866f, -0.38149837f, -1.09275031f, -0.99185324f, 
    0.67751163f, 0.43845841f, -0.49674016f, -0.66120839f, 0.29542652f, -0.20363972f, 0.25505912f, -0.57130605f, 
    -0.60457748f, -0.07084829f, -0.32355154f, -0.17665012f, -0.02200408f, -0.35035783f, -0.64049959f, -0.24713460f, 
    0.34161556f, -0.03354245f, 0.20903163f, 0.22431530f, 0.09534113f, 0.35561022f, 0.32972348f, -0.17471161f, 
    -0.33852735f, -0.23942529f, -0.04091277f, -0.35011458f, 0.30274662f, -0.14519404f, -0.02856338f, -0.30630893f, 
    0.09746213f, 0.20882381f, 0.26815090f, 0.02336861f, -0.13669904f, -0.49080324f, -0.01588150f, 0.37327737f, 
    -0.31828088f, 0.13252211f, 0.07198472f, -0.08262480f, 0.18092099f, 0.85428768f, 0.05423592f, -0.91596353f, 
    -0.91218454f, -1.06826723f, 0.00991813f, -0.27271152f, 0.01210056f, 0.30136073f, 0.22224353f, 0.46661317f, 
    0.32276553f, 0.43706307f, -0.08960680f, -0.04318037f, 0.01405392f, -0.13989305f, 0.10183222f, -0.37838984f, 
    -0.27178586f, -0.28749642f, -0.23464790f, 0.11756141f, -0.24499328f, -0.24715456f, -1.67618072f, -0.52076530f, 
    -0.60937333f, -0.00116902f, 0.07570124f, 0.16313514f, 0.74191821f, -0.75167531f, -0.93337321f, -0.08946629f, 
    0.50244576f, -0.42611325f, 0.09801184f, -0.70230877f, -0.33544669f, -0.06965347f, -0.08787926f, -0.15009703f, 
    -0.21586862f, -0.11728581f, 0.36914825f, -0.61396021f, -0.32941315f, -0.16795768f, -0.25334346f, -0.79025906f, 
    0.00111013f, 0.27639979f, -0.15877382f, -0.39851099f, 0.25486472f, 0.57916337f, 0.24291842f, 0.33612904f, 
    0.16860215f, 0.00279975f, 0.01097821f, -0.02668712f, 0.15537070f, -0.19930987f, -0.37068692f, -0.30451748f, 
    -0.40767357f, 0.14258434f, -0.08245601f, -0.05607048f, 0.29647517f, 0.08471119f, 0.13225625f, 0.47094113f, 
    0.27288601f, 0.67667955f, 0.37331074f, 0.27024785f, 0.43744984f, -0.32307863f, -0.39818165f, -0.04587577f, 
    0.20315173f, -0.02876817f, 0.24992476f, -0.39228329f, 0.46284923f, -0.30528069f, -0.13188113f, 0.18476182f, 
    -0.16126481f, 0.06460829f, 0.00127853f, 0.16210562f, 0.02834077f, 0.21223779f, -0.04529768f, 0.07327174f, 
    0.04709533f, 1.12566829f, -0.36234188f, -0.72640622f, -0.81026995f, -1.05477452f, 0.47353289f, -0.12904614f, 
    -0.45537618f, -0.64427286f, -0.90979052f, -0.29628327f, 0.00863153f, -0.08504450f, -0.12204728f, -0.56417489f, 
    0.02856839f, -0.45223650f, -0.12722331f, -0.22474457f, -0.07883369f, -0.31046411f, -0.06598257f, 0.12827064f, 
    -0.00100495f, -0.11059348f, -0.35099164f, -0.17789018f, -0.24866459f, -0.03357304f, 0.69425958f, 0.30660051f, 
    0.40706998f, -0.44126764f, -0.58628231f, 0.01040738f, -0.03224868f, 0.35187402f, -0.31933045f, 0.38558990f, 
    0.18390051f, 0.16913134f, -0.40199709f, -0.38000926f, 0.23010671f, -0.73693550f, 0.36657327f, 0.44450381f, 
    0.36794254f, 0.03272901f, -0.25769368f, 0.01420541f, -0.26275808f, -0.72821575f, -0.68681586f, -0.40810081f, 
    0.16820307f, 0.43473104f, 0.22556511f, -0.24351928f, 0.12672660f, 0.35373223f, 0.27586195f, 0.30941185f, 
    -0.06559531f, -0.06250323f, -0.01032823f, 0.10153404f, -0.15590525f, 0.22869843f, 0.10832781f, 0.05867334f, 
    0.17820275f, 0.15448582f, 0.27114874f, 0.07368506f, 0.48600778f, 0.58522850f, 0.40088162f, 0.19342719f, 
    -0.55804855f, -0.41204786f, 0.02568196f, 0.02223731f, -0.16828588f, 0.02619323f, -0.04515331f, 0.01165847f, 
    0.23767017f, -0.14825922f, -0.18260044f, -0.08635661f, 0.00880748f, 0.10453692f, -0.08135460f, 0.03010749f, 
    0.43820524f, -0.13176093f, 0.14836942f, -0.25113207f, -0.27788579f, 0.06959867f, -0.63489795f, -0.41409472f, 
    -0.20403160f, -0.61987984f, -1.14774084f, -0.86952859f, -0.31737679f, -0.78027034f, -0.88595039f, -0.07337653f, 
    -0.50533229f, -0.18602735f, -0.01322989f, 0.33637837f, -0.07900777f, -0.10877820f, -0.12392079f, -0.56561202f, 
    -0.39674979f, 0.13090406f, -0.14208966f, -0.04634772f, 0.24403323f, -0.21795385f, 0.63689560f, 1.35034084f, 
    0.65220034f, -1.00356686f, -1.16473544f, -0.53683460f, -0.00498477f, 0.17730059f, -0.09813350f, -0.36824623f, 
    0.18237364f, 0.45558840f, 0.40688974f, 0.05639238f, -0.03378395f, -0.26187900f, -0.20553418f, 0.29379588f, 
    0.04170605f, -0.49783611f, 0.12387198f, 0.02789789f, -0.42591861f, -0.30964476f, 0.40370277f, 0.67737150f, 
    -1.07545984f, -0.31024033f, 0.49561262f, 0.17462707f, 0.61988389f, 0.51644367f, 0.23540813f, -0.22429752f, 
    0.05957965f, -0.17368625f, -0.38906074f, -0.15777533f, -0.06594583f, 0.40256706f, 0.22475114f, -0.12235916f, 
    -0.20596141f, 0.05462531f, -0.25190949f, 0.21963306f, -0.29884815f, -0.22009693f, 0.01353006f, -0.19906087f, 
    -0.70984119f, -0.80791163f, 0.02753744f, 0.24726126f, 0.57463181f, 1.34901929f, -0.44587147f, -0.61547655f, 
    -0.28190219f, -0.07578482f, -0.36787763f, 0.04660129f, 0.09111603f, -0.48645192f, -0.26522785f, -0.27607739f, 
    -0.07995804f, 0.29182446f, 0.34170660f, 0.26507363f, 0.24250409f, 0.11253700f, -0.20866358f, 0.10743640f, 
    -0.19564331f, 0.32103938f, -0.31409308f, -0.48491186f, 0.08080217f, -0.29389393f, 0.02653661f, -0.23994641f, 
    0.22904080f, -0.33286896f, -0.43659917f, -0.36221156f, 0.19813064f, -0.32649609f, 0.30603781f, -0.33465028f, 
    0.07938338f, 0.46615136f, 0.42500567f, 0.04630277f, 0.38091215f, -0.34596503f, -0.25292096f, -0.19058378f, 
    -0.12720983f, 0.11924278f, 0.21473274f, 0.70360202f, 0.53407764f, 0.46221405f, 0.02477892f, -0.00352036f, 
    0.12115689f, -0.23929796f, -0.42092803f, -0.34364972f, -0.39983338f, 0.16651684f, -0.14720976f, 0.07586207f, 
    -0.23837231f, -0.18607382f, 0.20539185f, 0.16716465f, -0.19130492f, 0.14852357f, -0.19645378f, 0.01152954f, 
    -0.09934212f, -0.29575437f, -0.56316817f, -0.18544254f, -0.16837558f, 0.01911805f, 0.86650836f, 0.22242665f, 
    -0.06653062f, -0.61552936f, -0.60861814f, 0.26246449f, -0.28184840f, 0.26615122f, 0.24344499f, -0.10243940f, 
    -0.20728341f, -0.40037614f, 0.15981497f, 0.07029358f, 0.22992164f, -0.21977106f, 0.06745381f, 0.04519564f, 
    -0.02104168f, 0.07778604f, 0.09383216f, 0.26638082f, 1.12899542f, -0.74059838f, -0.70871985f, -0.03067055f, 
    -0.62240368f, 1.25008249f, -0.17646407f, 0.06431296f, -0.42498294f, 0.11683986f, 0.32156518f, 0.54028648f, 
    -0.07758477f, 0.09682707f, -0.39877799f, -0.04810749f, -0.16589250f, 0.14719909f, -0.36514813f, 0.13350706f, 
    -0.24330853f, 0.26179147f, 0.07427748f, 0.37199527f, -0.24130692f, -1.16323459f, -0.12224881f, 0.10167756f, 
    0.22051312f, 0.43571019f, -0.18941185f, -0.32348651f, -0.31420493f, 0.59890056f, 0.58799350f, 0.31752661f, 
    0.10535145f, -0.34105405f, 0.11823799f, 0.10388204f, -0.11099605f, 0.54963398f, 0.36428362f, -0.32161009f, 
    -0.39178881f, 0.39120567f, 0.04699973f, -0.16788091f, 0.06216889f, -0.21300513f, -0.39215118f, -0.66654205f, 
    0.09163299f, 0.51601768f, 0.46053502f, -0.16212013f, 0.29221612f, 0.13562141f, 0.37447333f, 0.31120297f, 
    -0.06755392f, -0.27587482f, 0.10691204f, 0.02468507f, 0.00641513f, -0.06644590f, -0.37989911f, -0.09782810f, 
    0.26364326f, -0.34211162f, 0.25596985f, -0.00349224f, 0.39015782f, 0.07656392f, -0.29012951f, -0.89037454f, 
    -0.05327849f, -0.57807279f, 0.13432389f, -0.27393743f, 0.30997729f, -0.03190308f, -0.11536201f, 0.41604036f, 
    0.72868890f, 0.19189426f, -0.03652985f, -0.03338889f, 0.18391685f, 0.09481573f, 0.17688030f, 0.29448077f, 
    -0.13359307f, -0.14530690f, -0.38259038f, -0.16863416f, 0.45339173f, 0.06468787f, -0.02711212f, -0.24648292f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24692227f, 0.13364884f, 0.42260221f, -0.25556353f, 0.13614087f, 0.56895137f, 0.05323559f, 0.53005999f, 
    -0.02044978f, -0.00814660f, 0.24591333f, -0.01489296f, 0.43454486f, 0.12032817f, 0.22573583f, 0.24458414f, 
    -0.10687537f, -0.40330788f, 0.13807929f, 0.06524216f, 0.38114974f, -0.62548900f, 0.54076165f, 0.49938786f, 
    0.37788615f, 0.02071585f, 0.01919233f, 0.09933700f, 0.33851758f, 0.18823113f, 0.06036388f, -0.01941538f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13363059f, 0.04736967f, -0.15829763f, -0.07544197f, 0.02369911f, 0.03631591f, -0.09575179f, -0.38960341f, 
    -0.01150694f, 0.14747207f, 0.03243539f, -0.08813827f, 0.10506381f, -0.02123264f, 0.15846023f, -0.02420207f, 
    -0.03237905f, 0.11210352f, 0.00030550f, 0.00350257f, 0.14190453f, 0.05515352f, -0.05352401f, 0.06961265f, 
    0.02512705f, 0.01181150f, -0.14289112f, 0.05216075f, -0.24194273f, -0.07878308f, -0.05121652f, 0.02455989f, 
    -0.10304550f, -0.02019214f, 0.01165698f, -0.04691916f, 0.17757174f, -0.03992609f, 0.01239695f, -0.11685330f, 
    0.13162535f, 0.31610295f, -0.20860589f, 0.05756009f, -0.02157410f, 0.04798913f, 0.10919960f, -0.04774106f, 
    0.06386198f, 0.02096442f, -0.12629816f, -0.02169144f, 0.17741303f, 0.13874508f, 0.11211953f, -0.02379253f, 
    -0.19127600f, 0.11385059f, -0.09649303f, -0.05174781f, -1.04977942f, -0.22148596f, -0.18083236f, -0.07592306f, 
    -0.06941184f, 0.09275567f, -0.00112798f, -0.04710398f, -0.32959908f, -0.20772095f, -0.27220920f, 0.00464996f, 
    0.42801383f, 0.28536093f, -0.02951428f, -0.33251905f, 0.17279384f, 0.03925882f, -0.06117047f, 0.08980235f, 
    0.05453173f, 0.04871565f, 0.07159408f, 0.05948874f, 0.35089684f, -0.07549903f, 0.22981553f, -0.47831732f, 
    -0.27623746f, -0.09934501f, 0.14341278f, -0.23158053f, -0.12358636f, -0.24475995f, -0.05776837f, -0.27649629f, 
    0.38681477f, 0.32050058f, -0.07223967f, -0.21681349f, 0.03855193f, 0.04781962f, -0.09173924f, -0.06418025f, 
    0.03508979f, -0.00545606f, 0.02759934f, 0.09165790f, -0.38912928f, -0.07960600f, -0.03427052f, 0.11443136f, 
    -0.03493800f, 0.01402100f, 0.04822535f, 0.11124261f, 0.00506850f, -0.11269642f, 0.08050061f, 0.17929094f, 
    0.23839542f, 0.34774292f, -0.13218783f, -0.25431907f, -0.03546828f, 0.01464205f, 0.15305592f, -0.10315410f, 
    -0.00323191f, 0.02204708f, -0.06508049f, -0.02739618f, 0.27022803f, 0.07726295f, -0.21318127f, -0.17719051f, 
    0.15765975f, 0.30796599f, -0.16062602f, -0.05057138f, -0.07280679f, -0.04514137f, -0.08278593f, 0.01311244f, 
    -0.16295293f, -0.16154492f, -0.16683488f, -0.18579830f, -0.13906972f, -0.06005118f, -0.10043215f, -0.07825353f, 
    -0.00060188f, -0.05343071f, -0.06487780f, -0.24184406f, 0.21171786f, -0.08812774f, -0.27848715f, 0.11257488f, 
    0.10278344f, -0.01051168f, -0.07277621f, -0.04178268f, -0.07801401f, 0.05701216f, -0.04268938f, 0.09116608f, 
    0.65853101f, 0.32136771f, -0.20668739f, -0.13711543f, 0.15529452f, 0.08388700f, 0.22208263f, 0.09578854f, 
    -0.09104869f, -0.13838059f, -0.08943298f, -0.07138091f, -0.04398681f, -0.21554682f, 0.10534453f, -0.05084450f, 
    0.07739646f, 0.01364743f, 0.06430238f, 0.04947130f, -0.10658590f, -0.27169156f, -0.48660815f, -0.44348565f, 
    0.05166366f, -0.00630842f, 0.03808348f, 0.11307444f, 0.08993574f, 0.01633211f, 0.00839777f, 0.08085979f, 
    -0.00483300f, 0.04747498f, 0.02564774f, 0.06691936f, 0.23304492f, -0.05859364f, -0.30728865f, 0.00357643f, 
    0.29599458f, 0.05215897f, 0.01233264f, 0.06119361f, -0.09845182f, -0.06939214f, -0.15585390f, -0.00345899f, 
    -0.05572175f, 0.28069767f, -0.18927245f, 0.08774069f, 0.01596272f, 0.17430751f, 0.18064329f, -0.27969196f, 
    -0.18776254f, -0.09855066f, -0.23448145f, -0.06049063f, 0.11968837f, 0.14621787f, -0.02317838f, 0.13510390f, 
    0.16523147f, 0.01497597f, -0.28293714f, -0.15252888f, 0.01399077f, 0.00574788f, 0.02377131f, 0.00320423f, 
    -0.52021289f, -0.58946705f, 0.16708930f, 0.02058352f, 0.02247075f, 0.06627426f, -0.10398116f, -0.02766529f, 
    -0.03181497f, -0.02909079f, -0.04498271f, 0.04548865f, 0.34622470f, 0.17380707f, -0.06085483f, -0.32020330f, 
    0.21370752f, 0.21886396f, 0.01292566f, 0.08299399f, -0.04250666f, -0.05757371f, -0.00656093f, -0.05520416f, 
    0.04207128f, -0.76554865f, -0.30347446f, 0.24025843f, 0.03218144f, -0.07873064f, -0.16890647f, -0.01834171f, 
    -0.02049890f, 0.06051296f, -0.03186626f, -0.25162831f, -0.26032767f, -0.66952240f, -0.17112181f, 0.03646812f, 
    -0.01451829f, 0.02248785f, 0.01909233f, -0.06655095f, 0.01854926f, -0.02483861f, -0.00105074f, 0.16983944f, 
    0.55949813f, 0.18897721f, -0.38240433f, -0.16145238f, -0.29662174f, -0.24745673f, 0.04413323f, -0.11729748f, 
    -0.03339656f, -0.06300623f, -0.01329309f, -0.03734779f, 0.41867152f, 0.09252296f, -0.04367309f, -0.22760421f, 
    0.16087733f, 0.05643575f, 0.15788887f, 0.18721883f, 0.01386069f, 0.07481994f, 0.09489386f, -0.00714945f, 
    -0.63494569f, -0.57663411f, -0.30069500f, 0.02978643f, 0.06882447f, 0.03590932f, -0.01892213f, 0.03767659f, 
    -0.01662735f, 0.03702734f, 0.05361997f, 0.10453238f, 0.21892285f, 0.36115959f, -0.03419348f, -0.30940989f, 
    0.26457384f, -0.14603536f, -0.30268797f, -0.08821709f, 0.06265815f, -0.00067150f, 0.01924675f, 0.05286670f, 
    0.14761487f, -0.06935381f, -0.34464616f, 0.07608221f, -0.08470822f, -0.06306276f, -0.13121268f, -0.15544342f, 
    0.09902315f, 0.13043244f, -0.13067682f, -0.01440473f, -0.06208795f, 0.28225732f, 0.27750197f, -0.04468974f, 
    -0.07160860f, 0.15448084f, -0.02894913f, 0.20676388f, -0.09225908f, -0.02882699f, -0.05309335f, -0.31947574f, 
    -0.08640376f, 0.02907402f, 0.05004365f, -0.08414932f, 0.10727423f, -0.03341324f, 0.12531576f, 0.03788722f, 
    0.04545498f, -0.06975741f, -0.13368259f, 0.00904865f, 0.06753398f, 0.04328149f, 0.04998388f, 0.06355298f, 
    -0.02096125f, 0.05972826f, 0.07184949f, 0.00246928f, 0.02589701f, 0.22677638f, -0.06265318f, -0.08741283f, 
    0.44922313f, 0.02796838f, -0.15702015f, -0.07726802f, 0.00243443f, 0.06871768f, -0.03504715f, -0.03304088f, 
    0.03604326f, -0.17620359f, -0.13740262f, -0.37026733f, -0.53808469f, 0.08008978f, -0.04925953f, -0.21724801f, 
    0.01275919f, 0.11557169f, -0.10755555f, 0.13721776f, -0.12023024f, 0.13594773f, -0.11277577f, -0.18062523f, 
    0.20344868f, -0.11367291f, -0.01603171f, 0.06695562f, -0.02881380f, -0.04882479f, -0.00905475f, 0.02778001f, 
    -0.05753156f, 0.15340881f, -0.03348050f, 0.03385605f, 0.10863049f, 0.22384916f, 0.16321498f, 0.16948248f, 
    0.09850463f, 0.16803764f, -0.22735284f, -0.43973136f, -0.06600063f, -0.03959076f, 0.03878415f, -0.28477004f, 
    0.15689759f, -0.09474465f, -0.40295303f, -0.20276041f, -0.14004135f, 0.04633718f, 0.07259461f, 0.06976011f, 
    -0.02259960f, -0.00481438f, -0.12458747f, -0.12644979f, 0.81040871f, 0.25592706f, 0.32434952f, -0.14848629f, 
    0.00487806f, 0.03594569f, -0.04242487f, -0.07871608f, 0.09153520f, -0.00945320f, 0.12682401f, 0.12887380f, 
    -0.14164531f, 0.04414645f, 0.23973879f, -0.26991558f, -0.15124573f, 0.04280068f, -0.37920976f, -0.22938259f, 
    -0.03128192f, -0.03904356f, -0.08887196f, 0.08509705f, -0.31519341f, -0.05086938f, -0.32792082f, -0.03569260f, 
    0.14610453f, 0.09950730f, 0.11103404f, -0.10701451f, 0.39051783f, 0.19128592f, -0.11712865f, 0.14416654f, 
    -0.24564245f, 0.28789499f, 0.13325459f, 0.14577390f, -0.18327753f, 0.21207738f, -0.07184716f, -0.16850504f, 
    -0.06679408f, 0.00201855f, 0.00635748f, -0.06949563f, 0.05666327f, 0.04699121f, 0.13223659f, 0.00864830f, 
    -0.03474278f, 0.04533335f, -0.10001004f, -0.04485532f, -0.46780589f, -0.46559742f, -0.22329547f, -0.21091159f, 
    -0.74525493f, -0.00292137f, -0.39979061f, -0.08548880f, -0.01150179f, 0.11468817f, 0.10006953f, 0.06798886f, 
    -0.10998251f, -0.09103401f, 0.07182910f, 0.10062541f, 0.27250275f, 0.17571628f, 0.16860372f, 0.04869130f, 
    0.02884939f, 0.07972182f, -0.02440365f, 0.24116053f, -0.01413129f, 0.09819952f, -0.26734096f, -0.01597474f, 
    0.28529277f, 0.01175061f, -0.03720513f, -0.01870253f, -0.00595031f, -0.01628159f, 0.03094422f, -0.05123347f, 
    -0.14385885f, 0.07315725f, 0.06794871f, -0.01711054f, -0.00131982f, -0.24789764f, 0.00868936f, -0.32728767f, 
    0.04642792f, 0.01995819f, -0.04373718f, 0.07865303f, 0.21464404f, -0.15316442f, -0.07701343f, 0.01952677f, 
    0.15923192f, -0.46141464f, 0.05403046f, -0.05517779f, 0.03160538f, -0.04157216f, 0.03611285f, -0.26239976f, 
    0.09643909f, -0.02240598f, -0.20875293f, 0.02587656f, -0.03317855f, 0.02648936f, 0.11140656f, -0.03559599f, 
    -0.03417970f, -0.02769322f, 0.01910030f, -0.00580331f, -0.00044841f, 0.12805535f, 0.00441094f, 0.06012245f, 
    0.08478302f, 0.10009623f, 0.02609545f, 0.14478706f, -0.03600085f, 0.00790528f, -0.05097283f, -0.04235223f, 
    -0.13495860f, 0.07424621f, 0.03478761f, 0.05930648f, 0.50389075f, 0.08946113f, 0.00258270f, 0.03715913f, 
    -0.19490191f, -0.14089096f, 0.07940009f, -0.02433942f, 0.06059331f, -0.07012612f, -0.02070107f, -0.00194993f, 
    0.09902532f, -0.38484323f, 0.06672615f, 0.05258235f, -0.24654540f, 0.11772282f, -0.00050384f, 0.21729702f, 
    -0.03935143f, -0.14245984f, 0.08042444f, 0.11293998f, 0.01848739f, -0.14080095f, -0.13904765f, -0.10843191f, 
    0.13070132f, 0.12651846f, -0.04381339f, 0.15897478f, -0.10915456f, -0.08534709f, -0.05401045f, 0.01638479f, 
    0.26881567f, 0.20836329f, 0.09610670f, -0.10052552f, 0.00382947f, -0.00664833f, -0.11459660f, -0.00035102f, 
    -0.10485141f, -0.00260967f, 0.13459331f, -0.01907707f, -0.15887921f, 0.21402439f, 0.38213599f, -0.11073314f, 
    -0.24227829f, 0.02120925f, 0.05779123f, -0.05663165f, 0.01775402f, -0.02162482f, 0.10546374f, 0.09727009f, 
    0.25768644f, -0.57634091f, 0.36574817f, -0.62060535f, 0.03234542f, 0.12202480f, -0.14279231f, 0.11784514f, 
    0.05215729f, -0.07135382f, 0.01033439f, 0.16947024f, 0.54151374f, -0.03083937f, 0.09082538f, 0.30347934f, 
    0.02392239f, -0.02852393f, -0.11853167f, -0.10240178f, 0.06721792f, -0.18915975f, 0.14830391f, -0.18422350f, 
    -0.01762107f, 0.03788354f, -0.43767467f, -0.02883420f, 0.11023691f, 0.08105628f, 0.03315738f, 0.15295383f, 
    0.09102067f, -0.06105648f, -0.04404918f, 0.10473729f, 0.19677180f, 0.06665382f, -0.03533150f, -0.15984656f, 
    0.12717590f, 0.10411701f, -0.10343798f, -0.29879779f, 0.03472150f, -0.12524712f, -0.10042434f, 0.07346413f, 
    0.16649219f, 0.10934856f, 0.10445695f, 0.04886920f, -0.04633825f, 0.03892634f, -0.03786506f, 0.06791078f, 
    -0.03128779f, 0.01730386f, 0.00002663f, 0.05321944f, -0.25757226f, 0.20532402f, -0.43542510f, 0.12266500f, 
    0.16971745f, -0.15893370f, 0.07434957f, 0.04684127f, -0.08372796f, 0.02839727f, -0.10434390f, 0.13467841f, 
    0.67754227f, -0.12017702f, -0.26099786f, -0.23774882f, -0.01020805f, -0.06376231f, 0.12622453f, 0.05172063f, 
    0.10251036f, 0.27775809f, -0.12907538f, 0.04206912f, -0.22750737f, 0.13579717f, 0.12391311f, -0.09912603f, 
    0.00858588f, -0.10415582f, -0.00137254f, 0.12880833f, -0.24343908f, -0.35248542f, -0.08797584f, 0.06120248f, 
    0.03119179f, 0.04867178f, 0.09977942f, 0.05868547f, -0.01113280f, 0.07167958f, 0.00668366f, 0.03374528f, 
    -0.15427400f, -0.01889745f, 0.00864829f, 0.10566339f, -0.26476222f, 0.10123587f, -0.01325491f, -0.07499184f, 
    -0.01215399f, 0.02853529f, -0.03687155f, 0.01964921f, -0.13835372f, -0.08482878f, 0.06618499f, -0.06627881f, 
    -0.14189798f, 0.35638279f, 0.82343245f, 0.29052117f, -0.08508595f, 0.00777541f, -0.04510370f, -0.00368288f, 
    0.08580390f, -0.03597631f, 0.18968649f, -0.06490368f, 0.26302427f, 0.26965764f, -0.08849438f, 0.14465886f, 
    0.00303203f, -0.11356634f, 0.09501555f, -0.08992345f, -0.07119326f, -0.01755756f, 0.14329229f, 0.00137997f, 
    -0.06124789f, -0.08909936f, 0.09444138f, -0.16829492f, -0.19086865f, -0.08099344f, -0.03626982f, 0.09277778f, 
    -0.01756800f, -0.01094011f, -0.03245049f, 0.03643667f, 0.45761454f, 0.26738024f, 0.23640837f, 0.51594502f, 
    -0.12790497f, -0.01899370f, 0.04576053f, 0.05298284f, 0.04734960f, 0.09638803f, 0.00529485f, 0.11348675f, 
    -0.11380175f, 0.40538600f, 0.38014430f, 0.26823699f, 0.00204064f, -0.09474148f, 0.12921321f, -0.02416128f, 
    0.11978573f, -0.15658219f, -0.20825796f, -0.19316034f, -0.70823687f, 0.50739801f, 0.00052797f, 0.04109470f, 
    -0.14308874f, 0.09373017f, 0.00907285f, -0.07151483f, 0.09191845f, 0.14504993f, -0.11946494f, 0.07998829f, 
    0.05095659f, -0.32534838f, -0.35619891f, -0.40917173f, 0.17982455f, 0.24102686f, -0.23791824f, -0.22359703f, 
    0.00583833f, -0.01331278f, 0.04183495f, 0.00993613f, 0.15125076f, 0.22133888f, -0.58601099f, 0.18074027f, 
    -0.13813247f, 0.04962508f, -0.02358843f, 0.11933997f, -0.01714344f, 0.03774273f, -0.04448410f, -0.07420967f, 
    -0.51206750f, 0.01242000f, -0.34221178f, 0.16527593f, 0.05413095f, -0.10051090f, -0.00903300f, -0.01654627f, 
    -0.00629768f, -0.03585545f, 0.05695711f, -0.00264323f, 0.08757833f, -0.15817150f, -0.02938749f, 0.05311802f, 
    -0.03325378f, 0.02433284f, 0.00997166f, -0.10859572f, 0.06191482f, 0.09942885f, 0.07532740f, 0.26175508f, 
    -0.57385272f, -0.19974412f, -0.34841043f, 0.01437009f, 0.02317734f, 0.01441967f, -0.11600383f, -0.11317874f, 
    0.08282544f, -0.06236056f, -0.04343428f, -0.03685973f, -0.06382182f, 0.15465905f, 0.68146306f, 0.25816101f, 
    -0.05702905f, 0.11340508f, -0.23535787f, 0.07268844f, -0.07146733f, -0.00811003f, -0.08748505f, 0.08838210f, 
    -0.27258372f, -0.17480832f, 0.02921283f, -0.05950189f, 0.08335420f, -0.04069493f, -0.01370602f, -0.02622003f, 
    -0.03061060f, 0.04886758f, -0.05004672f, 0.13518165f, -0.09436513f, 0.28289029f, 0.07929230f, -0.05518927f, 
    -0.04414868f, -0.01909322f, 0.13132444f, -0.31407964f, 0.06569405f, 0.18597564f, -0.00219247f, 0.12932631f, 
    0.12691164f, -0.26852730f, 0.46555018f, 0.16183598f, 0.23344594f, -0.13476898f, -0.06847858f, 0.26529029f, 
    0.01245209f, 0.03812147f, 0.01278753f, -0.00677199f, -0.05388422f, 0.00057716f, -0.18172690f, -0.03658117f, 
    0.01485214f, 0.03945007f, -0.13878970f, 0.07416091f, -0.20730631f, -0.15952404f, 0.07001074f, -0.11078276f, 
    -0.29211074f, -0.09871822f, 0.01824459f, -0.13196915f, -0.11824620f, -0.04438900f, 0.04349849f, 0.09363908f, 
    -0.04479430f, -0.03164434f, 0.03827289f, -0.00144848f, -0.98413539f, 0.45717221f, 0.01126919f, -0.65877116f, 
    -0.03993578f, 0.03155733f, -0.00215737f, -0.27958736f, -0.05859117f, -0.02789813f, -0.01933576f, -0.05301690f, 
    0.07212178f, -0.18992716f, -0.12361098f, -0.00825713f, 0.16593733f, -0.23604015f, 0.16311717f, 0.01124598f, 
    -0.02312212f, -0.16774423f, -0.11250610f, -0.13287339f, 0.08350892f, 0.05381782f, 0.15237266f, 0.01550025f, 
    -0.15682013f, -0.19360001f, 0.09554866f, -0.11511770f, 0.06230023f, -0.05841687f, 0.02499180f, -0.03854525f, 
    -0.17430939f, 0.02628368f, 0.31979841f, -0.22450531f, 0.05028525f, -0.08286262f, -0.06401344f, 0.08689684f, 
    0.01838299f, -0.03847507f, 0.09144777f, 0.09506397f, -1.19785607f, -0.89853698f, -0.26426324f, -0.24196570f, 
    -0.20799316f, -0.20320950f, 0.01399082f, -0.33592421f, -0.04833801f, -0.05646798f, -0.06386448f, -0.01289253f, 
    -0.04709552f, -0.18797684f, 0.35846758f, -0.48404822f, 0.16632861f, -0.04663372f, -0.50987816f, -0.10661862f, 
    0.13809957f, -0.23296297f, 0.10896406f, 0.00577444f, 0.08511055f, -0.08163441f, 0.25981092f, 0.04017598f, 
    0.02711832f, 0.10762568f, 0.04428750f, 0.02684818f, 0.17281464f, 0.12986176f, 0.14355859f, 0.01115604f, 
    -0.03009978f, 0.26190239f, -0.12986371f, 0.01891758f, 0.02487178f, -0.21735673f, -0.14526467f, 0.24673213f, 
    0.09662636f, 0.11173201f, 0.14047392f, -0.23369557f, -0.35479876f, -0.07577742f, 0.28355452f, -0.02969718f, 
    0.04673537f, 0.06967142f, 0.17576778f, -0.17007025f, 0.01485419f, 0.06425509f, -0.03194310f, 0.04544830f, 
    -0.17483851f, 0.25347576f, -0.16843736f, -0.49268931f, 0.00455932f, -0.08357893f, 0.03201690f, 0.03365418f, 
    -0.03025218f, -0.04860101f, 0.02330575f, 0.03426598f, -0.27208656f, -0.00144307f, -0.06243082f, -0.22424334f, 
    -0.15036404f, -0.15519474f, -0.13972428f, 0.14400686f, -0.09247108f, 0.05270930f, 0.05047834f, -0.00178355f, 
    -0.19276367f, 0.18431616f, -0.00692070f, -0.05636696f, 0.05341410f, -0.16994733f, -0.00426946f, -0.02835818f, 
    -0.04638300f, -0.18569593f, -0.02863190f, 0.03410102f, 0.10577967f, -0.17380483f, -0.12765339f, 0.16307218f, 
    0.13271324f, 0.13916825f, -0.06567012f, 0.06616117f, 0.15935898f, 0.01223732f, -0.25047070f, 0.42457908f, 
    -0.06214438f, -0.05505142f, -0.31705898f, 0.20270054f, -0.03873673f, 0.05043444f, 0.12351214f, -0.00641735f, 
    -0.15804328f, -0.01956978f, 0.24513103f, -0.22025269f, 0.15165973f, -0.03725594f, 0.11943258f, 0.12938675f, 
    0.04100759f, 0.08636606f, 0.07931251f, -0.08123123f, -0.14257742f, -0.23664270f, 0.01817383f, 0.33567470f, 
    0.10192763f, 0.00544850f, -0.01874649f, 0.19060636f, 0.37285873f, -0.07465170f, -0.01513634f, 0.00439357f, 
    -0.06838780f, -0.03609809f, 0.06789096f, 0.06941471f, 0.74558800f, 0.01778302f, -0.02088935f, 0.24186067f, 
    0.26243028f, 0.17125778f, 0.01490030f, -0.05273079f, -0.03462209f, -0.06352714f, 0.12705211f, -0.01701916f, 
    0.08080973f, -0.04439073f, 0.36348584f, -0.00520359f, -0.19189091f, -0.32808059f, -0.28097221f, -0.06124928f, 
    -0.26067162f, -0.11979100f, -0.04503753f, 0.08319718f, 0.27087989f, -0.24069026f, 0.10325717f, 0.36873788f, 
    0.15441039f, -0.01883962f, -0.01791091f, -0.25925061f, -0.03072276f, 0.00594920f, 0.02580513f, 0.10364071f, 
    0.15135671f, -0.06978221f, -0.06441826f, -0.06626622f, 0.27672258f, 0.13554828f, -0.05142803f, 0.02204423f, 
    -0.13123687f, 0.04843787f, -0.03785973f, 0.04268297f, -0.97562712f, 0.18813004f, 0.07589859f, -0.07251608f, 
    -0.11674790f, -0.04806400f, 0.16455722f, -0.21747705f, -0.21016103f, 0.16248873f, 0.06609026f, -0.21452805f, 
    0.22425528f, -0.17232685f, -0.15013722f, 0.09419531f, 0.09161693f, 0.14652877f, -0.03337862f, -0.09482518f, 
    -0.00927645f, -0.12612878f, 0.05228135f, -0.11041477f, -0.58419967f, 0.77305591f, -0.39562839f, -0.69937307f, 
    -0.05153381f, 0.01395353f, -0.27188462f, 0.32145599f, -0.41406631f, -0.02534169f, -0.14179821f, -0.00261463f, 
    0.15036033f, -0.29676825f, -0.22906859f, -0.02007292f, 0.04343200f, 0.02389220f, 0.03209724f, 0.08202599f, 
    0.06185601f, -0.01049311f, 0.11789248f, -0.11247138f, -0.08992750f, -0.07655602f, -0.39046490f, -0.22136375f, 
    -0.01340305f, -0.02777830f, 0.08663502f, -0.00677840f, -0.01236401f, 0.16089249f, 0.01593436f, 0.03729034f, 
    0.13961998f, -0.05965851f, -0.16202427f, 0.39927757f, 0.16251999f, -0.16801633f, 0.18971354f, 0.28927559f, 
    -0.08579351f, -0.08844203f, 0.19522744f, 0.00786175f, 0.00541739f, -0.11057334f, 0.05695529f, 0.33174586f, 
    0.13588318f, -0.25877765f, 0.03844001f, -0.03169692f, 0.01989726f, 0.08229920f, -0.10986485f, 0.16884233f, 
    0.14144473f, -0.18164015f, 0.26332533f, -0.26133469f, -0.05921933f, 0.11353520f, -0.27955309f, 0.08629908f, 
    -0.18923874f, -0.23876034f, 0.00825971f, -0.31882170f, -0.31406605f, -0.02850871f, -0.10429827f, 0.37150523f, 
    -0.07575917f, 0.05277278f, 0.01617559f, -0.02531831f, -0.01294856f, 0.08430194f, 0.04834451f, 0.22501388f, 
    -0.16434123f, -0.00300010f, -0.20656787f, -0.09491354f, 0.29798344f, 0.01179493f, 0.01155398f, -0.02782631f, 
    -0.04084529f, 0.11767695f, 0.06158874f, 0.13650011f, 0.62894732f, 0.17960589f, 0.13011852f, -0.02784073f, 
    0.30683440f, 0.21759787f, -0.04482157f, 0.13592039f, -0.09592741f, 0.10870110f, 0.21615116f, -0.09378881f, 
    -0.44555190f, -0.55898374f, -0.10616890f, -0.35392562f, -0.35904315f, -0.20038332f, -0.37981999f, -0.17677274f, 
    0.17095467f, 0.16049488f, 0.22311431f, -0.26103914f, -0.36019665f, -0.13550410f, 0.09870148f, 0.46392742f, 
    -0.06529290f, 0.13122669f, 0.04275291f, -0.07224313f, -0.05442537f, -0.05740187f, 0.06814902f, 0.00338917f, 
    0.07477511f, 0.35658222f, -0.31412649f, 0.00365959f, -0.05173335f, -0.13902141f, -0.17710327f, 0.03048231f, 
    -0.06870063f, -0.35067424f, 0.20353636f, 0.07149472f, -0.10822822f, -0.18145776f, 0.01053488f, 0.40357301f, 
    0.08530552f, 0.03968782f, 0.09733076f, -0.04505785f, 0.04923579f, -0.02331172f, -0.05010780f, 0.07272380f, 
    -0.35598451f, -0.20368475f, 0.04255645f, -0.08243787f, -0.05124846f, -0.08637597f, 0.03297040f, -0.22151022f, 
    0.08040426f, 0.18570621f, -0.04391908f, 0.06562056f, -0.01952607f, -0.17278069f, -0.00245437f, 0.26658255f, 
    0.00297911f, 0.04496170f, 0.20148510f, 0.27068973f, -0.12909694f, 0.04273590f, -0.16223945f, -0.20462380f, 
    -0.16136181f, 0.18107700f, 0.44380927f, 0.00003824f, -0.14587444f, 0.06390302f, -0.31220594f, -0.02086924f, 
    -0.10120934f, -0.07834205f, -0.04967017f, -0.23959662f, -0.75231630f, 1.29611003f, -0.43709561f, -0.06136528f, 
    0.25635850f, 0.21105953f, 0.12685086f, -0.14347284f, -0.21339306f, -0.00155318f, -0.05611695f, -0.05654572f, 
    -0.53965539f, 0.60077822f, -0.24821264f, -0.43035445f, 0.15988129f, 0.19146051f, -0.09476703f, -0.08158094f, 
    -0.29348508f, -0.04291705f, -0.08874254f, 0.04195636f, 0.08577395f, -0.22070949f, -0.07896771f, 0.19118311f, 
    -0.13687700f, -0.02646850f, -0.01677504f, -0.01470146f, 0.10127982f, -0.06567155f, -0.06096345f, 0.02006231f, 
    -0.30590066f, 0.58572292f, 0.41811910f, 0.18336074f, -0.22955197f, -0.11600310f, -0.08153952f, 0.16266710f, 
    0.18510790f, 0.02736989f, -0.05292866f, 0.17860974f, 0.12839891f, 0.06224030f, 0.06793243f, 0.30038375f, 
    -0.19039772f, -0.13378823f, 0.06551075f, -0.00805177f, 0.11645410f, 0.13859105f, -0.00125955f, 0.08504088f, 
    -0.97172570f, -0.33523235f, 0.43773749f, -0.15493712f, -0.11080084f, 0.17901133f, -0.00352482f, -0.11069344f, 
    -0.06438185f, 0.12591825f, 0.22680230f, -0.03916733f, 0.75299931f, -0.03195418f, 0.14874956f, -0.69174272f, 
    0.04248349f, 0.15289286f, -0.10316961f, -0.00672434f, -0.30081832f, 0.23350063f, -0.30374420f, 0.03367390f, 
    -0.44682324f, 0.46365249f, 0.12309916f, -0.74470371f, 0.08023872f, 0.13052851f, 0.01785173f, -0.13044482f, 
    0.07117184f, -0.06374838f, 0.10362355f, -0.10941002f, 0.24090362f, -0.34023732f, 0.01401842f, -0.14790185f, 
    0.04510387f, 0.08705588f, 0.04903795f, -0.06168870f, -0.11431818f, -0.20227362f, 0.05855921f, -0.01224399f, 
    -0.33370718f, -0.00222580f, -0.01272523f, 0.11289895f, -0.15233794f, 0.03408462f, -0.15037899f, -0.01140483f, 
    -0.02023455f, 0.00918378f, -0.04599356f, 0.13444458f, -0.20906740f, -0.11369749f, 0.07711403f, 0.09128375f, 
    0.01901593f, -0.12425058f, -0.16083546f, -0.25130454f, -0.17028008f, -0.10907380f, 0.03604844f, 0.12086691f, 
    -0.00284118f, 0.07654425f, -0.11075555f, 0.11836433f, 0.22174543f, 0.11134138f, 0.10512724f, -0.01044221f, 
    -0.05313117f, -0.00509254f, -0.17539081f, -0.19193219f, -0.09055536f, 0.21486625f, 0.07328076f, 0.04964553f, 
    -0.18133184f, -0.20104021f, 0.15714526f, -0.08845080f, 0.08314472f, 0.00907115f, 0.00111403f, 0.14391027f, 
    0.15225743f, 0.27808565f, 0.05742367f, 0.02343584f, -0.01341279f, -0.09488706f, -0.00454388f, -0.01665830f, 
    0.11605913f, -0.04723088f, -0.25033757f, -0.04797485f, -0.34585992f, -0.15987051f, -0.19973448f, -0.22591443f, 
    0.08193234f, -0.10962638f, -0.01957099f, 0.08566227f, -0.09409830f, 0.08658396f, -0.31591034f, -0.13207120f, 
    0.00008690f, 0.11646310f, 0.29973099f, 0.30923340f, -0.25322559f, 0.07146809f, 0.03607657f, 0.08135127f, 
    0.03012584f, 0.05955650f, 0.02964737f, -0.05260849f, 0.18647866f, -0.55492347f, 0.07360928f, 0.11083353f, 
    -0.12220622f, -0.07800801f, -0.00604891f, -0.07633561f, -0.38788503f, 0.00633770f, -0.20627570f, -0.33065984f, 
    0.00357653f, 0.06186631f, 0.23755290f, 0.08848792f, -0.29365295f, -0.23359269f, -0.15729795f, 0.11946805f, 
    0.12234688f, 0.04631662f, 0.00156630f, 0.04739868f, -0.04649036f, -0.09277198f, -0.18583393f, -0.03378844f, 
    0.02819359f, -0.02316984f, 0.03681466f, 0.08846000f, 0.02167445f, 0.32036844f, 0.22612089f, 0.16781035f, 
    0.21601334f, 0.10772918f, 0.64456654f, 0.14742061f, -0.13956366f, 0.03037349f, -0.13691270f, 0.19672620f, 
    -0.05120555f, -0.01683995f, -0.10900552f, -0.00474246f, -0.12560906f, 0.07519202f, 0.07922930f, 0.21681194f, 
    -0.01965703f, -0.10143247f, -0.00521424f, -0.17012861f, -0.07930718f, -0.02482998f, 0.16033511f, -0.15093151f, 
    -0.37272489f, -0.08102171f, -0.09228118f, 0.23819441f, -0.13249922f, 0.07191262f, -0.02378160f, -0.01912008f, 
    0.00828369f, -0.07354105f, -0.11962408f, -0.00916190f, -0.10943001f, -0.03637226f, 0.20748644f, 0.11714347f, 
    0.10299142f, 0.03301136f, -0.17289385f, -0.30405623f, 0.16328345f, -0.06973223f, 0.08360412f, -0.09886064f, 
    -0.10111992f, -0.08602784f, 0.00344977f, 0.21901272f, -0.12087645f, -0.09832404f, -0.15774582f, -0.21117409f, 
    -0.17181219f, 0.07425036f, 0.02348401f, 0.21364053f, 0.24143182f, 0.06434853f, -0.02512709f, 0.03373775f, 
    -0.04231491f, -0.00591714f, 0.00395991f, -0.01595821f, -0.21844342f, -0.41762862f, -0.15730600f, -0.04996388f, 
    0.08840410f, 0.08186263f, 0.17584428f, 0.17251907f, 0.11430779f, 0.10865566f, 0.09334834f, 0.09327571f, 
    0.06605608f, -0.07218587f, 0.06527158f, 0.02437587f, -0.07401897f, 0.08941611f, 0.17990865f, 0.08098645f, 
    0.16521864f, -0.14552873f, -0.10481063f, 0.11831363f, 0.03540500f, -0.00159077f, 0.13175012f, -0.02037931f, 
    0.13995342f, -0.12124820f, -0.20127554f, 0.16215721f, 0.06639679f, -0.08504678f, -0.04670621f, 0.07061070f, 
    0.12065531f, -0.04632764f, -0.11340070f, -0.06228233f, 0.12047855f, 0.08581907f, 0.03329928f, -0.00572722f, 
    0.05608700f, -0.10122050f, -0.12329043f, -0.18194550f, 0.13209328f, -0.00317949f, 0.04309233f, -0.01221532f, 
    -0.01888876f, -0.05324925f, -0.13457482f, 0.17397019f, 0.06343547f, -0.13651060f, 0.04863252f, 0.03450850f, 
    0.14271599f, -0.04771026f, -0.06288719f, -0.00686859f, 0.05529689f, 0.19198073f, 0.13029586f, 0.22620171f, 
    0.02340350f, 0.11879676f, 0.20900714f, 0.21441263f, -0.01468225f, -0.02874799f, 0.04278761f, 0.11505231f, 
    -0.01045387f, 0.12759618f, -0.21796331f, 0.20958598f, 0.11709094f, -0.04625087f, 0.04048730f, -0.25327224f, 
    0.13555507f, -0.00126862f, -0.04650770f, -0.33288163f, -0.03682312f, -0.35248068f, -0.24052389f, -0.15801123f, 
    -0.03706857f, 0.04784506f, 0.03862502f, -0.01097752f, 0.06545427f, -0.03819343f, -0.17567879f, 0.26179051f, 
    0.05645955f, -0.63597322f, 0.37104571f, -0.03453007f, 0.01272941f, -0.04984655f, 0.02933560f, -0.17525932f, 
    -0.10898393f, -0.08049607f, -0.12722595f, -0.02314028f, -0.16740546f, 0.04915987f, 0.21920224f, 0.10507457f, 
    -0.03103091f, -0.03287777f, 0.05891486f, -0.02341602f, -0.02737422f, 0.00989497f, -0.05178010f, -0.03969877f, 
    0.54216021f, -0.33649507f, -0.05030081f, 0.43211377f, 0.03735832f, 0.03367859f, 0.09944183f, -0.12993059f, 
    0.05535754f, 0.08898721f, 0.04386257f, 0.10685281f, 0.14040373f, -0.16290802f, 0.47973186f, 0.05387635f, 
    -0.12642713f, 0.00384535f, -0.00414947f, 0.24595879f, -0.05077130f, -0.01489581f, -0.02237593f, -0.10537947f, 
    0.09856771f, 0.04623631f, -0.09762149f, 0.05410232f, 0.10714756f, 0.00242473f, -0.05426399f, -0.14265010f, 
    -0.01989361f, -0.32805356f, -0.04318708f, -0.00615600f, -0.13451135f, -0.11466432f, -0.20366289f, 0.21911788f, 
    -0.02776381f, -0.07962330f, -0.05738568f, -0.21966498f, 0.00654530f, -0.04006180f, 0.15768902f, 0.05872274f, 
    0.12413191f, 0.03157113f, 0.09229480f, 0.01625248f, 0.12268500f, -0.05398838f, -0.00997826f, 0.08024074f, 
    0.03190232f, -0.12395815f, -0.18452424f, -0.18161660f, 0.14772318f, 0.06662647f, -0.14112070f, 0.06144312f, 
    -0.01331975f, 0.02854582f, 0.08026184f, -0.00828559f, 0.14200626f, -0.05686548f, -0.13349432f, -0.09123010f, 
    -0.33180985f, 0.07586191f, 0.12216663f, -0.50424880f, -0.02006236f, 0.05028038f, 0.08089065f, 0.12202374f, 
    0.10308386f, -0.24188510f, -0.10408565f, -0.00891154f, -0.17803018f, -0.11116660f, -0.00079129f, -0.14422061f, 
    -0.03242876f, -0.14384870f, 0.12792528f, 0.11280252f, 0.16255108f, -0.03088855f, -0.08546641f, -0.18559499f, 
    -0.01324194f, 0.16960201f, -0.22097537f, -0.35295838f, 0.24578045f, -0.04839732f, -0.07178210f, 0.00722245f, 
    0.14980519f, -0.09207057f, 0.20757979f, 0.21223076f, -0.52246732f, -0.27468240f, -0.38664040f, -0.43059880f, 
    0.08466174f, -0.07930385f, 0.01774653f, 0.21531963f, -0.11623678f, -0.05756650f, -0.14168611f, 0.00995681f, 
    -0.68412596f, -0.47989818f, 0.01002625f, 0.04209413f, 0.01534087f, -0.06021697f, -0.13188627f, -0.10873710f, 
    0.09818970f, -0.00117331f, 0.22186199f, 0.03706679f, 0.15909848f, -0.28822267f, -0.15859956f, 0.16242537f, 
    0.01660340f, -0.01179993f, -0.06952826f, 0.08026142f, 0.24340186f, -0.12071744f, -0.09292842f, -0.06964261f, 
    -0.01733254f, 0.16718030f, 0.15342137f, 0.13065390f, 0.25418183f, -0.06306975f, 0.05694187f, 0.14201753f, 
    -0.08033360f, -0.08910711f, 0.05714381f, 0.04619923f, 0.34712544f, -0.24037980f, 0.44702920f, 0.31775045f, 
    0.09067884f, -0.09049215f, 0.02239496f, 0.18174855f, -0.03779366f, -0.15400463f, 0.15061419f, 0.29611236f, 
    0.03290841f, -0.02090975f, -0.05430178f, -0.04750905f, 0.31186435f, 0.22070481f, 0.23212615f, 0.06166827f, 
    0.00385440f, 0.08095870f, 0.03566230f, 0.09994731f, 0.02162659f, -0.08826634f, -0.10520488f, 0.06715351f, 
    0.03354821f, 0.01106980f, 0.02497158f, 0.02225856f, 0.02330688f, -0.56881452f, -0.25014812f, -0.18885648f, 
    0.41775677f, 0.06883068f, 0.10040896f, -0.18262698f, 0.09682700f, 0.09121422f, -0.08980415f, -0.30304050f, 
    -0.00226523f, -0.00776548f, -0.05390142f, 0.05970995f, 0.01432252f, 0.18309328f, -0.01676366f, -0.49526295f, 
    -0.07964370f, 0.05206417f, 0.11957001f, 0.01434984f, 0.12040464f, -0.09333973f, 0.19143125f, -0.04435551f, 
    -0.30220395f, -0.04570847f, -0.13863435f, 0.20554587f, 0.12431082f, -0.01958134f, 0.06306851f, 0.01394085f, 
    0.16921239f, 0.02023094f, 0.01006330f, 0.11947994f, 0.31954783f, 0.07750646f, -0.15130661f, -0.26184258f, 
    -0.09006654f, 0.03060585f, -0.03571783f, -0.06745946f, -0.23117624f, -0.22458015f, -0.03013917f, -0.20540495f, 
    -0.30646896f, 0.62023312f, 0.17200479f, -0.07146958f, -0.15274893f, -0.07244885f, -0.03141107f, 0.16898125f, 
    0.11601309f, -0.03413919f, 0.00294825f, 0.01602440f, -0.34416488f, -0.31203669f, -0.12237644f, 0.13359624f, 
    -0.05784634f, -0.00337490f, -0.05233781f, -0.10853613f, 0.21464337f, 0.17180522f, -0.08768141f, 0.24750568f, 
    -0.37867990f, -0.12946062f, -0.00183338f, 0.11075870f, 0.07676905f, -0.01256425f, -0.03834359f, 0.08413455f, 
    0.08688363f, -0.01413371f, -0.05332302f, 0.15662819f, 0.10956474f, 0.17917314f, 0.00688615f, -0.34593219f, 
    -0.02560863f, 0.11347260f, -0.13553667f, -0.12039683f, 0.02022739f, 0.04685319f, 0.02571873f, -0.06917235f, 
    -0.15824300f, 0.24022889f, 0.13755587f, -0.26972121f, 0.13386834f, -0.30060583f, 0.18026438f, -0.04099426f, 
    0.06475583f, 0.22359794f, 0.04534550f, -0.07700517f, -0.10969809f, -0.07866528f, -0.09990040f, -0.09823110f, 
    -0.07238146f, 0.07900459f, 0.15395410f, -0.03886686f, 0.14946462f, 0.17124069f, -0.01415718f, -0.02137000f, 
    0.08848774f, -0.41228622f, -0.34693030f, 0.17849848f, 0.01264928f, 0.08412802f, 0.10090249f, 0.10842179f, 
    0.01134778f, -0.03924050f, -0.03168243f, -0.13166329f, 0.28893533f, 0.11160019f, 0.03499997f, 0.07015114f, 
    0.31953734f, -0.12300198f, -0.44727314f, -0.00483832f, 0.08675321f, 0.04167561f, -0.00803944f, 0.01904256f, 
    -0.04887949f, 0.16237278f, -0.83060771f, 0.74932712f, -0.01853835f, 0.04238782f, 0.00531525f, -0.01069679f, 
    -0.08727235f, -0.11373550f, -0.00324584f, 0.09555241f, -0.29092929f, -0.04448538f, 0.22052558f, -0.23201686f, 
    -0.01637767f, -0.16500805f, -0.00285137f, 0.09735427f, -0.05750221f, 0.13731191f, -0.31758249f, -0.24651036f, 
    -0.18869987f, 0.06248918f, 0.34575009f, 0.01801736f, -0.10785219f, 0.05616425f, -0.08735592f, -0.02128496f, 
    0.14504853f, 0.30057478f, -0.09272467f, -0.10899793f, -0.02981654f, 0.13089943f, -0.04463739f, 0.08162978f, 
    -0.00579982f, -0.01802806f, -0.04539026f, 0.25030875f, -0.09336154f, 0.12196812f, 0.11151101f, 0.08850152f, 
    -0.15492067f, -0.43876016f, -0.07934956f, 0.17257787f, 0.08633133f, 0.08758868f, 0.06760396f, 0.05618953f, 
    -0.00516929f, -0.11159322f, 0.00536265f, -0.32425618f, 0.15003392f, -0.18292376f, 0.24461702f, -0.22349653f, 
    0.16297792f, 0.27921295f, 0.09857277f, -0.12135657f, 0.23341918f, -0.05963792f, 0.08093805f, 0.07284807f, 
    -0.24894731f, -0.09518136f, 0.08334935f, -0.17192440f, 0.06227451f, 0.26599017f, -0.02704485f, -0.04228057f, 
    0.14317426f, -0.21002381f, 0.21780966f, -0.15068623f, -0.06815547f, -0.18455002f, 0.08453616f, 0.13538030f, 
    -0.10114689f, -0.17214403f, -0.02192740f, 0.13138519f, 0.09628046f, -0.07212003f, 0.31722870f, 0.05947452f, 
    -0.12656929f, -0.22328423f, 0.22251174f, 0.18493877f, -0.06538738f, -0.15435120f, -0.04002649f, -0.04836718f, 
    -0.02895534f, 0.05848534f, 0.08917821f, 0.00749447f, -0.32474521f, -0.53542393f, -0.01948003f, -0.11657683f, 
    0.05773742f, -0.08709519f, 0.02246752f, 0.12637600f, 0.04981123f, 0.01520505f, 0.11796255f, 0.09400345f, 
    -0.27847853f, 0.11804098f, 0.13802217f, -0.13989237f, -0.07842222f, -0.18754180f, 0.11882670f, 0.17183012f, 
    0.09608696f, 0.35534039f, 0.05285007f, 0.32049322f, -0.10075850f, 0.06416204f, 0.08095302f, 0.12548752f, 
    -0.08826452f, 0.23140436f, -0.14932984f, -0.17975673f, 0.03685197f, 0.17433594f, 0.00758445f, 0.15137823f, 
    0.04460255f, -0.14260022f, -0.01643453f, -0.29208887f, -0.20030898f, 0.15539555f, 0.09461501f, 0.00547993f, 
    -0.03550750f, 0.01042203f, -0.11141834f, -0.04337272f, -0.40385449f, -0.00986728f, 0.20832549f, 0.12411699f, 
    -0.00936748f, 0.02376337f, 0.22501241f, 0.20204875f, -0.01396923f, -0.02055278f, 0.06418386f, 0.15745525f, 
    -0.45272893f, 0.20242392f, 0.49662304f, 0.51476264f, -0.04414403f, -0.01444017f, -0.18927187f, 0.00588341f, 
    -0.00576656f, 0.08162308f, -0.06543882f, 0.08694114f, 0.38940755f, 0.18814690f, -0.49914938f, 0.27764228f, 
    0.01893060f, -0.11480196f, 0.23147681f, 0.09817950f, -0.02172556f, 0.12100304f, -0.00976929f, 0.07499396f, 
    -0.80436122f, -0.81687003f, -0.41034940f, -0.55656797f, -0.40612739f, -0.09880447f, 0.21580584f, 0.03692355f, 
    0.02261331f, -0.03189110f, -0.01894529f, -0.05717423f, -0.31514606f, -0.09902828f, 0.45672929f, 0.36512202f, 
    0.05025705f, -0.15179998f, 0.02362688f, 0.15635200f, -0.19260500f, -0.22578940f, 0.07473561f, 0.06602505f, 
    -0.91182411f, -0.62143242f, -0.20416661f, -0.47879422f, -0.33816999f, -0.17807984f, -0.03932003f, -0.61071104f, 
    -0.05582880f, 0.03872883f, -0.07299479f, -0.04294023f, 0.03864729f, 0.16101189f, 0.02342471f, 0.01402673f, 
    -0.00490236f, -0.05913319f, 0.08215695f, 0.17848869f, 0.13041762f, 0.27980408f, 0.32110667f, 0.06866043f, 
    -0.47205099f, -0.70884699f, -0.18623815f, -0.22382784f, -0.05622137f, -0.01459728f, -0.40197718f, -0.43947542f, 
    0.05558878f, 0.02182510f, -0.13649119f, -0.06988455f, -0.78824568f, -0.82652849f, 0.29422405f, 0.17457178f, 
    0.08567333f, -0.26971126f, 0.22309746f, -0.18078382f, -0.11106264f, -0.00536855f, 0.08889263f, -0.10525964f, 
    0.22030498f, 0.19089544f, 0.02463937f, 0.38685900f, 0.11923166f, 0.10861291f, 0.10453388f, 0.06356894f, 
    0.04308594f, -0.10332884f, 0.09147398f, -0.05939184f, 0.49377006f, 0.42984769f, -0.18590924f, -0.05601034f, 
    -0.01859940f, -0.01598543f, -0.15260114f, 0.07425371f, 0.16094682f, 0.14368169f, -0.12004150f, -0.00246519f, 
    -0.53873515f, -0.70691353f, 0.59605324f, 0.05096138f, -0.29653513f, -0.11203195f, 0.32452515f, -0.34114745f, 
    -0.04493330f, 0.14645061f, 0.05462211f, -0.11086470f, -0.19080855f, 0.00934428f, 0.21119200f, 0.13673605f, 
    -0.03400015f, -0.17324406f, -0.06735782f, -0.04510600f, 0.04473764f, 0.01359377f, 0.15105672f, 0.09593275f, 
    -0.07745856f, -0.15974928f, -0.31622359f, -0.05519502f, 0.03037786f, 0.11457907f, 0.14801471f, -0.09969241f, 
    -0.11842355f, -0.07437921f, -0.12233344f, -0.04827100f, -0.45605299f, -0.61448365f, 0.29892758f, 0.12576725f, 
    0.12653688f, -0.05395407f, 0.00596333f, -0.33713257f, 0.04820825f, 0.00121601f, -0.05527901f, 0.09298374f, 
    -0.24985318f, -0.16002780f, 0.25119913f, 0.14462960f, 0.26250663f, -0.04761198f, -0.06009828f, 0.00511998f, 
    -0.06108996f, 0.26431289f, 0.04798586f, -0.00425630f, -0.00352682f, 0.24175313f, 0.07489873f, 0.00218046f, 
    -0.07061114f, -0.14206693f, -0.08387041f, 0.31856319f, 0.02178611f, -0.03683503f, -0.09372862f, -0.06918218f, 
    0.25625449f, -0.12916635f, -0.18695898f, -0.29251260f, -0.06011656f, 0.07488027f, 0.24572060f, -0.09938055f, 
    0.01659287f, 0.12284781f, -0.07450331f, -0.02164150f, -0.40144345f, -0.51074529f, -0.68086517f, -0.34667084f, 
    -0.28512385f, -0.11669791f, -0.20798206f, -0.52026761f, 0.01077882f, -0.08786963f, 0.03899133f, 0.02766620f, 
    0.55582440f, -0.14975411f, -0.05789733f, -0.66369653f, 0.00940041f, -0.09944981f, 0.37322268f, 0.07429216f, 
    0.04256340f, 0.32173184f, -0.22814204f, -0.04318234f, 0.09042779f, 0.18510918f, -0.11103573f, 0.08584599f, 
    0.02974527f, 0.00716663f, 0.09762371f, 0.03966703f, 0.33778805f, -0.06115269f, 0.32793134f, 0.01163457f, 
    -0.21905780f, -0.12442861f, 0.32764414f, 0.38650873f, 0.36382359f, 0.10963952f, -0.14545079f, -0.16339135f, 
    0.03536225f, 0.15417658f, 0.14784580f, 0.10033638f, -0.40154612f, -0.39141035f, -0.42682037f, 0.14255911f, 
    -0.21468256f, -0.17759706f, 0.03749052f, -0.17482761f, 0.06471259f, 0.02207738f, -0.05314133f, 0.01601430f, 
    -0.31857678f, -0.23245715f, -0.05729098f, 0.06208475f, 0.07967543f, 0.16740711f, 0.01347813f, -0.02977433f, 
    0.03153590f, -0.01661601f, -0.03144888f, 0.05399085f, -0.15416677f, -0.55450231f, -0.53661495f, -0.19761804f, 
    -0.05639356f, 0.19523153f, 0.01065620f, -0.09711075f, 0.08407146f, 0.06968487f, -0.08381796f, -0.03609701f, 
    -0.12671590f, 0.42363238f, 0.20476818f, 0.14330189f, 0.03301846f, -0.09556391f, -0.11414183f, -0.21201017f, 
    -0.06121101f, -0.17338736f, -0.08772683f, 0.03410700f, 0.09572270f, -0.11318106f, -0.10459716f, 0.07740413f, 
    -0.02412027f, 0.05546867f, -0.07048239f, 0.14006466f, 0.03161870f, 0.18942223f, -0.07108975f, -0.39593267f, 
    0.12714218f, -0.04723612f, -0.23613337f, -0.12253889f, -0.08467641f, 0.01369097f, -0.12082046f, 0.06974922f, 
    -0.06840647f, -0.01923292f, -0.17368579f, 0.04986007f, -0.05383923f, 0.09947797f, 0.09623776f, -0.05944782f, 
    -0.05920500f, 0.04873653f, -0.10924396f, 0.20333470f, -0.01022005f, 0.07930353f, 0.08018204f, -0.05889475f, 
    0.05723482f, -0.84245110f, 0.28887096f, -0.17820346f, -0.03694591f, -0.03810128f, 0.08318198f, 0.06857127f, 
    0.13804777f, 0.23435636f, -0.22255993f, 0.02476390f, 0.32052970f, -0.18563244f, -0.19831504f, -0.04421585f, 
    -0.02710953f, -0.02623419f, -0.05912594f, -0.09549849f, 0.17945924f, -0.16774505f, 0.08209398f, 0.05119622f, 
    -0.09684766f, 0.22856483f, 0.03554066f, 0.04845692f, -0.01645037f, -0.00167157f, -0.04172775f, 0.05542552f, 
    0.00078904f, -0.06112887f, 0.06850179f, 0.02647086f, 0.54151076f, -0.67888629f, -0.33111900f, -0.36363709f, 
    0.05295865f, -0.09546872f, 0.02664812f, 0.26360196f, 0.23890820f, 0.00671389f, -0.02025801f, 0.03839243f, 
    0.61018580f, 0.02968929f, -0.37861624f, -0.32149798f, 0.02829432f, -0.12824465f, -0.03703088f, -0.01361154f, 
    -0.04065563f, -0.06625313f, 0.02478934f, -0.04397342f, -0.11423323f, -0.51255834f, 0.11527991f, -0.23577110f, 
    -0.01809726f, 0.10856263f, -0.00115330f, -0.14737357f, -0.00855441f, -0.10588428f, -0.03049699f, -0.10822954f, 
    -0.34622559f, -0.57603663f, -0.75486386f, 0.48872796f, 0.05579422f, 0.04797401f, -0.13878772f, 0.09646408f, 
    0.11599251f, 0.04917670f, 0.00241565f, 0.00957934f, 0.40710190f, 0.05082633f, -0.08441064f, -0.35443771f, 
    -0.14913426f, -0.07743081f, -0.04343618f, -0.09909318f, -0.21834193f, 0.04031253f, -0.18505090f, -0.14435428f, 
    -0.50517863f, -0.50864291f, -0.34558025f, 0.12125435f, 0.23694313f, -0.01318204f, -0.13968574f, -0.00369679f, 
    0.10100367f, -0.01006137f, 0.02053614f, 0.04666994f, 0.01737545f, 0.10868803f, 0.09433389f, 0.02810669f, 
    -0.04699729f, -0.05959641f, -0.00405658f, 0.00539237f, 0.19591644f, 0.01591353f, -0.05764491f, -0.06784273f, 
    -0.65120274f, -0.57801771f, 0.65377945f, 0.43876326f, -0.03615999f, -0.10895374f, 0.16096579f, 0.04016378f, 
    0.02594404f, -0.00532171f, 0.06973530f, 0.01660041f, -0.23842348f, -0.72630793f, 0.07171255f, -0.39864066f, 
    0.01986207f, -0.00743022f, 0.00151585f, 0.01924030f, 0.02883876f, -0.02647994f, 0.04534701f, -0.03532464f, 
    0.01648200f, 0.15834880f, 0.00240388f, -0.07923286f, -0.08008662f, 0.05322919f, -0.10040842f, 0.05865614f, 
    0.04990989f, -0.00826903f, -0.01004294f, -0.19735652f, -0.30800495f, -0.35568726f, -0.22223389f, -0.05812687f, 
    -0.08823615f, -0.02123368f, 0.07864917f, 0.19217074f, -0.09346276f, 0.08381344f, 0.13610515f, 0.04613959f, 
    0.41946417f, -0.97012800f, 0.37849388f, -0.64271885f, -0.02339990f, -0.06993528f, 0.05688028f, 0.28343067f, 
    -0.03074762f, -0.07922243f, 0.03420046f, -0.03291684f, 0.30227268f, 0.21745686f, -0.17260718f, -0.26288798f, 
    0.00669497f, 0.13598883f, 0.09932245f, 0.01310506f, -0.22496009f, -0.01681887f, 0.02675426f, -0.05840806f, 
    0.04638178f, 0.01122553f, -0.01096477f, -0.11231297f, 0.03415319f, -0.05576894f, -0.03733901f, -0.04611612f, 
    0.04483847f, 0.06690582f, 0.02285702f, -0.02595455f, -0.35004425f, 0.59259343f, 0.50278324f, -0.03894759f, 
    0.02687912f, -0.11912651f, 0.30395105f, 0.08914760f, -0.14640477f, -0.01069820f, -0.07898431f, -0.04649846f, 
    0.16907124f, 0.19967642f, 0.23387881f, -0.06004594f, -0.14957663f, -0.01383945f, 0.07606598f, 0.11138871f, 
    0.09282383f, 0.02871803f, 0.07700490f, -0.06882974f, 0.02572777f, -0.01759263f, 0.01322717f, 0.01715486f, 
    -0.15795468f, -0.23397438f, 0.12555654f, -0.10880829f, 0.01655598f, -0.00315316f, 0.06024158f, 0.05750096f, 
    -0.05998273f, 0.16482295f, -0.06820001f, 0.01138941f, 0.02759324f, 0.01085452f, -0.11052164f, 0.04158843f, 
    0.07447349f, 0.07196484f, 0.06278712f, 0.02327937f, -0.30166426f, -0.25346899f, -0.35153300f, 0.55208689f, 
    0.29828650f, 0.17112084f, 0.17678230f, 0.06202395f, 0.06171753f, -0.00455828f, -0.07170623f, -0.09843095f, 
    -0.31411213f, 0.36536327f, -0.56062555f, 0.25418183f, -0.01401871f, 0.04303570f, 0.12783983f, 0.03949994f, 
    0.05219052f, 0.01201742f, 0.13588583f, -0.09398980f, 0.06771711f, -0.28326192f, 0.08599339f, -0.11887560f, 
    0.03742837f, 0.01604552f, 0.04096015f, -0.13609876f, -0.17205237f, 0.08152076f, -0.07495269f, -0.00752182f, 
    0.37498543f, -0.11241277f, 0.38373169f, -0.38822430f, -0.26852420f, 0.07336006f, -0.14768653f, 0.33539689f, 
    -0.04749826f, -0.09502173f, 0.02844184f, -0.24726638f, -0.34918281f, -0.16530570f, -0.00271797f, -0.12508255f, 
    -0.03895355f, 0.00104492f, 0.06091876f, 0.24037686f, 0.04417998f, 0.01116746f, -0.05709726f, -0.06279708f, 
    0.17383428f, 0.13776384f, -0.06244742f, 0.00443796f, 0.03086118f, -0.11126447f, -0.02148351f, -0.02937300f, 
    0.07363422f, 0.01652616f, 0.06942338f, 0.01543268f, -0.15220267f, -0.18636139f, 0.42833847f, 0.08545829f, 
    -0.11985712f, 0.08347765f, -0.11987748f, 0.02432063f, -0.00383008f, 0.01992155f, 0.02168373f, 0.02475451f, 
    -0.25244528f, -0.10450520f, 0.37920490f, -0.09145205f, -0.14040580f, 0.02537546f, 0.10611305f, 0.05094410f, 
    -0.09769969f, 0.02894709f, 0.04423892f, 0.09406910f, 0.41251323f, -0.04782385f, 0.05702383f, -0.18974386f, 
    0.01539143f, 0.15903443f, -0.01683738f, -0.10887273f, -0.05391555f, 0.00103039f, -0.22644143f, -0.26761639f, 
    0.28337169f, 0.00612643f, -0.03869767f, -0.17918579f, 0.05336756f, 0.05020779f, 0.01141823f, -0.00660885f, 
    0.07487874f, 0.03220776f, -0.07332005f, -0.18302581f, 0.52779233f, -0.19016308f, 0.00290539f, -0.26174003f, 
    -0.01685627f, -0.01465706f, -0.10627646f, -0.13625444f, -0.00635369f, -0.22029415f, 0.06692358f, -0.03134778f, 
    0.13526165f, -0.75214666f, -0.07315604f, 0.20491089f, 0.14881413f, 0.10664459f, 0.06222837f, -0.01842819f, 
    -0.02640405f, -0.12425042f, 0.08300737f, -0.13788494f, -0.05372601f, -0.25754559f, -0.00108225f, 0.05049723f, 
    0.22514515f, 0.07892133f, 0.03934570f, 0.21312390f, -0.23083715f, 0.11934765f, -0.06659553f, -0.12985766f, 
    -0.36274987f, 0.02839658f, 0.08393719f, 0.24136226f, 0.05527833f, -0.17206734f, -0.23683186f, 0.09051211f, 
    0.18822537f, 0.19286056f, 0.09388163f, 0.09121635f, -0.12464564f, -0.45929739f, -0.20159923f, 0.08689464f, 
    0.10320231f, 0.22861587f, 0.07213917f, 0.11558761f, -0.22611418f, -0.09320712f, -0.00590888f, -0.24742721f, 
    -0.11118109f, -0.35487014f, -0.05810302f, 0.01746837f, -0.04341770f, 0.05788169f, 0.11488874f, 0.03441465f, 
    0.15705997f, 0.09425766f, 0.17595451f, 0.04668995f, 0.18295975f, 0.16239433f, 0.00634153f, 0.01693386f, 
    0.21929373f, 0.04581649f, 0.01325217f, -0.04507031f, 0.07455844f, 0.13024658f, 0.13333522f, 0.37276182f, 
    -0.29062998f, -0.35002342f, -0.29403991f, -0.16209188f, 0.12760206f, -0.21127819f, 0.10988101f, 0.12322295f, 
    -0.07435848f, -0.02499971f, -0.01429323f, -0.06832362f, 0.37221783f, 0.22301380f, -0.56562001f, -0.33311102f, 
    0.04799801f, -0.08624372f, 0.09758606f, -0.12882678f, 0.26040497f, 0.05081113f, 0.14117372f, 0.29186711f, 
    0.05716440f, -0.65714204f, -0.36663207f, 0.15640703f, 0.15729380f, 0.13814594f, -0.09017693f, 0.29013011f, 
    -0.05510501f, 0.00959750f, -0.04091765f, 0.05812941f, -0.12934971f, -0.09111040f, -0.13312136f, -0.00902018f, 
    -0.03209413f, -0.02918146f, -0.04263083f, 0.02242260f, -0.14488922f, -0.03532203f, -0.19446133f, -0.47114888f, 
    0.81821436f, -0.43419698f, -0.17728277f, -0.13095662f, -0.06385458f, -0.06320495f, -0.14617516f, -0.13251635f, 
    0.19773568f, 0.24574146f, 0.09900635f, 0.09234584f, -0.41156515f, -0.87212670f, -0.20639041f, 0.52877325f, 
    0.15917708f, 0.20805682f, 0.09130546f, 0.19311987f, 0.08746808f, 0.06319989f, 0.08273729f, 0.16974743f, 
    -0.13916244f, 0.15679008f, 0.05380454f, -0.12485991f, 0.08639184f, -0.05205874f, -0.03468058f, 0.04571621f, 
    0.04298616f, 0.13871469f, 0.17634559f, 0.06225681f, -0.45092317f, -0.17175321f, -0.08001919f, 0.12323422f, 
    0.11044157f, 0.07248492f, -0.10124975f, 0.14284152f, -0.35388499f, 0.01558165f, -0.21913227f, -0.04034094f, 
    0.17660016f, 0.06861634f, -0.65421182f, -0.36658841f, -0.10708690f, 0.07539808f, 0.13592815f, -0.35298634f, 
    -0.11094163f, -0.02174003f, -0.04224873f, -0.14561021f, -0.21933927f, 0.05337857f, -0.12359945f, 0.02126822f, 
    -0.20154291f, 0.05962078f, -0.04150805f, 0.06627262f, 0.16532727f, 0.03257979f, 0.25840077f, 0.16305898f, 
    -0.05622820f, 0.11900494f, -0.01950597f, -0.08020864f, -0.02403467f, -0.08310509f, -0.07033977f, -0.11376517f, 
    -0.08124438f, 0.00423466f, -0.03188305f, 0.08230354f, -0.58597773f, -0.78984582f, -0.19727941f, -0.22613688f, 
    -0.26670820f, 0.30165124f, -0.07175226f, -0.42169034f, 0.01266018f, 0.07159715f, 0.07540429f, 0.17071125f, 
    -0.19666681f, -0.15990134f, -0.07149962f, -0.32660910f, -0.24776612f, 0.05667517f, -0.12569773f, 0.06022804f, 
    -0.10823863f, 0.24643348f, -0.04984532f, 0.21839656f, -0.16469154f, -0.26592705f, -0.14203937f, -0.01052898f, 
    -0.08476776f, 0.18272260f, 0.04786906f, 0.17050515f, 0.01657491f, 0.02891069f, 0.11058325f, 0.12083868f, 
    -0.39260098f, 0.27153802f, 0.07855716f, 0.19366086f, -0.05141106f, -0.04199081f, -0.11706092f, -0.12064084f, 
    -0.13563901f, 0.05546830f, -0.08408126f, 0.04896290f, -0.19698599f, -0.42405626f, -0.36448696f, -0.32557979f, 
    0.07988206f, -0.09252658f, 0.02925671f, -0.26594767f, 0.07560808f, 0.06140682f, 0.09849638f, 0.03990791f, 
    -0.62169802f, 0.20876464f, 0.03658740f, 0.32575929f, 0.12151768f, 0.02496201f, 0.09136666f, 0.23000875f, 
    -0.23529850f, -0.06817937f, 0.14174286f, 0.08906274f, -0.01556346f, -0.35955018f, -0.07557561f, -0.05607376f, 
    -0.09438336f, 0.04056465f, -0.00728596f, -0.11380623f, 0.00078981f, -0.05031778f, 0.08017933f, -0.18118279f, 
    0.36277726f, 0.43669555f, -0.30676496f, -0.22173779f, 0.03199893f, -0.43686873f, 0.16395327f, 0.00620479f, 
    0.08453951f, 0.05042152f, 0.16634506f, 0.17391632f, -0.09673972f, -0.29959166f, -0.16350988f, 0.25291035f, 
    -0.02646735f, 0.14744899f, 0.16667758f, -0.28313985f, 0.06373990f, -0.12559617f, -0.01613382f, 0.10025679f, 
    -0.53360516f, 0.28224000f, 0.01432962f, -0.06813828f, -0.07932874f, -0.07157971f, -0.23505832f, -0.27230978f, 
    -0.15821110f, -0.05085895f, -0.16777556f, -0.13491495f, 0.39575574f, 0.25620383f, -0.08263206f, -0.15829501f, 
    -0.12466467f, -0.34016863f, -0.11439145f, -0.25704172f, 0.13113241f, 0.21630956f, 0.04659449f, 0.04469028f, 
    -0.50878698f, -0.14679319f, 0.04184333f, 0.14823295f, -0.01050084f, -0.05545929f, -0.02130512f, 0.07707421f, 
    0.09173718f, 0.11154387f, -0.05855312f, 0.02884552f, 0.12825760f, -0.00528462f, -0.27836537f, -0.16743650f, 
    0.16763559f, 0.03525007f, 0.06812583f, -0.13558100f, 0.01073029f, 0.06524073f, 0.03653231f, 0.00230234f, 
    0.04540706f, -0.05949091f, -0.11905924f, -0.29833937f, -0.10119194f, -0.04335321f, -0.01553571f, -0.05637060f, 
    0.04709914f, 0.01273815f, 0.11335786f, 0.15962115f, -0.20701545f, -0.10048101f, -0.17161776f, -0.13737765f, 
    0.05403553f, 0.06099212f, 0.02516621f, -0.04466518f, 0.00557074f, 0.29080418f, -0.21621823f, 0.07624659f, 
    0.39514074f, -0.40071484f, -0.03767487f, -0.16344419f, -0.08532748f, 0.01684017f, -0.04070218f, -0.10663728f, 
    -0.21412390f, 0.05053796f, 0.04898753f, 0.03251707f, -0.06608787f, 0.20977871f, 0.06183544f, 0.09373865f, 
    -0.20483699f, -0.25923428f, -0.29313207f, -0.07663887f, 0.18637906f, -0.10758831f, 0.03890918f, 0.13025536f, 
    -0.33612320f, -0.12019583f, -0.05388169f, 0.00903085f, 0.02843599f, 0.01844595f, 0.05818186f, 0.09112836f, 
    0.13490435f, -0.18720609f, -0.24285278f, -0.22260059f, -0.32300386f, 0.27347326f, -0.05172000f, -0.51197803f, 
    -0.39818710f, -0.22436300f, -0.01240212f, -0.15347975f, 0.09692470f, 0.01982628f, 0.19709985f, 0.09613924f, 
    0.13615823f, 0.20228688f, 0.34870619f, 0.00321219f, 0.18381225f, -0.16848165f, -0.18392426f, -0.12036926f, 
    -0.21951693f, -0.12354308f, -0.00645344f, 0.19743118f, 0.01792902f, -0.35027471f, 0.39778903f, -0.52562416f, 
    -0.02781051f, -0.24309632f, -0.06926393f, -0.22574131f, -0.02050993f, -0.04517740f, 0.06476881f, -0.39831987f, 
    -0.53530741f, 0.33184257f, 0.35711989f, -0.05555122f, -0.03855399f, -0.60640085f, 0.26114589f, 0.17153449f, 
    -0.11119712f, 0.06552128f, 0.08732328f, 0.01775581f, -0.52565837f, 0.03373384f, -0.05426181f, 0.29401264f, 
    0.03369957f, -0.05967368f, -0.25229368f, -0.08767699f, 0.00698599f, -0.10961965f, -0.15539552f, -0.20512918f, 
    -0.39980182f, 0.00627361f, -0.02784590f, -0.03656243f, 0.01346159f, -0.32144547f, 0.01966257f, 0.19584247f, 
    0.03673825f, -0.04832624f, -0.04132016f, -0.05750493f, 0.07210048f, -0.09118004f, 0.17198309f, 0.06412356f, 
    0.07255221f, 0.18581872f, 0.04403132f, -0.05302660f, 0.09643392f, 0.32792234f, 0.18538626f, 0.11920725f, 
    0.30723420f, 0.20543216f, -0.25626063f, 0.06898108f, -0.03088674f, -0.14700630f, 0.00068940f, 0.18759035f, 
    0.01546651f, -0.03068200f, -0.09606544f, -0.13340452f, -0.04650056f, -0.05777651f, -0.08363280f, -0.70083565f, 
    -0.29715908f, -0.00933819f, -0.15777981f, -0.01731070f, 0.08518937f, 0.01633307f, -0.01093796f, -0.06318910f, 
    -0.00157509f, 0.17150694f, -0.27802426f, -0.31075048f, -0.07044189f, -0.07651561f, 0.02478880f, -0.01011071f, 
    0.01251016f, -0.09873565f, 0.02734978f, 0.01986464f, 0.03120131f, 0.39348987f, 0.68912190f, -0.60153770f, 
    -0.09370992f, -0.17836453f, 0.08164106f, 0.02207045f, -0.20786327f, 0.13839625f, 0.19277206f, -0.01261160f, 
    -0.39201424f, -0.07785192f, -0.05564361f, -0.04531395f, 0.05521257f, 0.04319622f, -0.11696012f, 0.13098155f, 
    0.19432148f, 0.02999165f, -0.02183866f, -0.04426836f, -0.07581279f, 0.09833085f, 0.09478355f, 0.04205428f, 
    0.11586891f, -0.03982318f, -0.17460318f, -0.00613876f, -0.06019017f, -0.09231505f, -0.09513209f, -0.22217922f, 
    -0.17407590f, -0.23169471f, -0.65015393f, 0.16840376f, 0.10464086f, 0.16883206f, 0.14650227f, 0.08362044f, 
    0.12991108f, -0.08817042f, -0.10648665f, 0.00131047f, 0.30502987f, 0.44586471f, 0.50018299f, -0.99823022f, 
    -0.20218420f, -0.02791188f, -0.04140207f, 0.21412992f, -0.00011307f, 0.12960297f, 0.05275227f, -0.16181834f, 
    0.14413480f, -0.11115344f, 0.08924771f, -0.13769612f, 0.11622774f, 0.04701254f, -0.32479653f, -0.00722837f, 
    0.02330006f, -0.21388407f, -0.16328022f, -0.22805449f, 0.02188190f, 0.22004560f, 0.27516317f, -0.24212350f, 
    0.00023540f, -0.08911768f, -0.02874135f, -0.13894644f, -0.02194702f, -0.00566995f, 0.05114743f, 0.03987578f, 
    -0.12409069f, 0.21289313f, -0.39226371f, 0.23173687f, 0.05630386f, 0.11515767f, 0.06486642f, 0.07880103f, 
    0.22365019f, 0.00105712f, -0.06742426f, 0.07707018f, -0.17198329f, -0.07072747f, -0.17946325f, -0.22051860f, 
    -0.09027235f, -0.06006517f, 0.23028620f, 0.24073775f, 0.07881907f, 0.11790501f, 0.09048752f, -0.00804555f, 
    -0.39218000f, 0.68884671f, -0.47940856f, 0.07918070f, -0.22898133f, -0.19379602f, 0.23030050f, 0.07678749f, 
    0.21151607f, 0.14266530f, -0.13280131f, 0.00856344f, 0.07825765f, -0.23555353f, 0.26964435f, 0.05598853f, 
    -0.02885029f, -0.04884500f, -0.01652780f, 0.05045465f, -0.25813040f, 0.15458216f, 0.16930394f, 0.25148013f, 
    -0.20684446f, -0.80138242f, 0.11854076f, -0.16587009f, -0.28957975f, 0.20959245f, -0.33271900f, 0.10338920f, 
    0.15512803f, -0.16344047f, -0.00923544f, 0.22256222f, -0.23631677f, 0.02300724f, 0.07921889f, 0.01840127f, 
    -0.12214906f, -0.03776485f, -0.02423729f, 0.02351198f, 0.06257037f, 0.02239250f, 0.06270717f, -0.02996664f, 
    -0.10548642f, -0.36939493f, -0.01966346f, -0.18204458f, 0.09542210f, 0.17021345f, 0.17905852f, 0.18250687f, 
    0.15949325f, -0.04685215f, 0.01835123f, 0.12038194f, 0.05190230f, -0.82424015f, -0.60519135f, 0.27981755f, 
    -0.16085109f, 0.07894960f, 0.00323158f, 0.13511610f, -0.12930070f, -0.10178421f, -0.03514503f, -0.11572500f, 
    0.39893466f, -0.25905040f, 0.41283539f, -0.64467174f, 0.05191646f, -0.02439455f, -0.32988709f, 0.17754480f, 
    -0.05931030f, 0.11120546f, 0.02626919f, 0.01787080f, -0.07802834f, 0.08414486f, 0.21214987f, 0.35886839f, 
    -0.03194305f, 0.04583390f, -0.01051548f, -0.45352611f, 0.21746591f, 0.05247427f, -0.12889968f, 0.16467786f, 
    -0.23962930f, -0.12657617f, 0.29401255f, 0.50564706f, 0.20064671f, 0.12371104f, -0.13129973f, 0.07505880f, 
    0.14328553f, -0.06818455f, -0.16374069f, 0.06089997f, 0.25987086f, 0.21197498f, 0.14949502f, 0.23960887f, 
    -0.12307072f, -0.11532451f, -0.15860069f, -0.32996109f, 0.28703451f, 0.01465238f, -0.09450004f, -0.05558443f, 
    -0.03818358f, 0.34760669f, -0.56269795f, 0.44960642f, 0.02300544f, 0.08571328f, 0.18303043f, -0.10926775f, 
    0.08759884f, 0.07696130f, -0.32413283f, -0.36409503f, 0.64203119f, -0.19302949f, 0.17919938f, 0.25817651f, 
    -0.05865120f, -0.42651847f, 0.21918625f, 0.41421521f, -0.45790640f, 0.02824136f, -0.29882789f, 0.01936217f, 
    0.14072725f, -0.33802202f, 0.24250121f, 0.28549102f, -0.01674849f, 0.12872617f, 0.38865209f, -0.17591909f, 
    0.07943124f, -0.00617079f, 0.21429686f, 0.26437122f, 0.10032231f, -0.07728116f, 0.13037513f, -0.15736520f, 
    0.10513371f, -0.17817296f, -0.00644313f, 0.09754073f, -0.27360466f, 0.15245651f, -0.22898915f, -0.38421100f, 
    -0.00049559f, 0.13074514f, 0.27870116f, -0.12494665f, 0.03862537f, -0.06095778f, -0.09239207f, 0.09248940f, 
    -0.05079334f, 0.02849031f, 0.04426745f, -0.14758605f, -0.78230995f, 0.34145027f, -0.02328132f, -0.03401237f, 
    -0.07851625f, 0.07117945f, -0.16148876f, 0.06040550f, 0.01203467f, -0.25306594f, 0.34526327f, -0.07086977f, 
    -0.14013067f, -0.30516455f, -0.21873607f, 0.20702107f, -0.02410324f, 0.11073705f, 0.43092197f, -0.09708357f, 
    -0.04029278f, -0.02933518f, 0.04678372f, 0.02005710f, -0.42093307f, -0.23593991f, 0.48519248f, 0.19656351f, 
    -0.39912346f, 0.13658035f, 0.15858676f, 0.19731623f, -0.00559163f, -0.00337886f, 0.24751964f, 0.09514099f, 
    -0.13482359f, 0.01804309f, 0.25104496f, 0.18764269f, -0.11407648f, 0.10176925f, 0.02176386f, -0.00572082f, 
    -0.04571500f, 0.14233294f, 0.09241985f, 0.13932942f, -0.28768891f, 0.31503037f, 0.22959842f, -0.35885155f, 
    0.02081455f, -0.13924003f, -0.18165568f, -0.01883069f, 0.03168627f, -0.35463822f, -0.20728043f, -0.55464727f, 
    -0.61291552f, 0.09775287f, -0.13682990f, 0.01773762f, 0.09183134f, 0.23648092f, -0.25079641f, -0.09355770f, 
    -0.06421800f, 0.33300471f, 0.11078244f, -0.00482331f, 0.08300803f, -0.02344113f, 0.02704721f, 0.04031593f, 
    -0.22048137f, 0.02960745f, 0.12248265f, -0.02068184f, 0.02380477f, 0.04016189f, 0.06569312f, 0.14697136f, 
    -0.11076604f, 0.09367593f, 0.24897756f, -0.20483924f, -0.07933806f, 0.02198204f, 0.11321098f, 0.06555567f, 
    0.02217720f, 0.27119893f, -0.00127709f, 0.00570259f, -0.17281920f, -0.10673799f, -0.29849505f, 0.20999694f, 
    0.03222485f, -0.22798671f, 0.02845034f, -0.05996311f, -0.20319495f, -0.51190639f, -0.27805433f, -0.16839693f, 
    -0.00549631f, -0.46350989f, -0.00371922f, 0.24215737f, -0.06325112f, 0.13256274f, -0.26217574f, -0.02893619f, 
    -0.06067039f, -0.00943483f, 0.08386552f, -0.28079844f, 0.62118971f, 0.34869626f, 0.38993567f, -0.30259848f, 
    -0.27578875f, -0.11648610f, 0.09451469f, -0.10989438f, 0.07112148f, 0.11201143f, 0.02288396f, 0.00955156f, 
    -0.37141395f, -0.26469001f, -0.20826805f, -0.16630229f, -0.33599818f, -0.18088327f, -0.02207898f, -0.07342346f, 
    -0.06925260f, 0.02893410f, 0.14136557f, 0.10165861f, -0.13916521f, -0.68431759f, -0.10673593f, 0.19289672f, 
    0.03734845f, -0.08752583f, -0.07100132f, 0.23555762f, 0.17560765f, -0.03531934f, -0.10323010f, -0.01896070f, 
    -0.15757819f, 0.17096545f, 0.15469854f, 0.23119165f, 0.10922908f, 0.19353028f, -0.07437847f, -0.11497254f, 
    0.19039679f, 0.36761042f, 0.20763534f, 0.38851890f, 0.19660042f, -0.05845519f, 0.26643896f, 0.22192863f, 
    -0.03656973f, 0.04936884f, -0.00002203f, 0.00044860f, 0.07142492f, 0.10657082f, 0.23841026f, 0.08808907f, 
    -0.19785765f, -0.11490714f, 0.06015953f, -0.05098032f, -0.16532770f, -0.00295690f, 0.11203610f, 0.17588192f, 
    -0.06764147f, -0.04555457f, 0.02490072f, -0.07481730f, -0.28954446f, -0.13248844f, -0.62138677f, 0.13485613f, 
    -0.18587075f, 0.01988182f, -0.35309616f, -0.06303054f, 0.00374788f, 0.10202993f, -0.00114914f, 0.12723871f, 
    0.31890175f, -0.63561821f, 0.28875968f, -0.01365043f, -0.23055883f, -0.23599382f, 0.24947812f, -0.10593145f, 
    -0.20429295f, -0.03959592f, -0.07802476f, -0.05455980f, -0.33786443f, 0.69765133f, 0.08780388f, -0.04433597f, 
    -0.01018573f, -0.00644020f, -0.29816326f, 0.18541732f, 0.11726651f, -0.15304579f, -0.27032730f, -0.26404798f, 
    -0.45747745f, -0.22679445f, -0.25193828f, 0.37969148f, 0.20087956f, 0.05995004f, 0.23049006f, -0.02038153f, 
    -0.20866705f, 0.12095588f, -0.02003194f, -0.05446325f, -0.14681810f, 0.19978265f, 0.13790427f, 0.28467584f, 
    0.14679389f, 0.22082946f, -0.22259466f, -0.23965824f, -0.21639431f, 0.20596164f, 0.00666343f, -0.05653611f, 
    -0.13362211f, -0.07346934f, 0.14984040f, -0.09263142f, -0.41528797f, -0.04398036f, 0.08981931f, -0.23706946f, 
    -0.05879887f, -0.20093685f, -0.28418148f, -0.19260757f, -0.42692712f, 0.30578449f, -0.14773238f, -0.12127897f, 
    0.08268971f, 0.17773356f, 0.02648825f, -0.09472080f, -0.15837076f, 0.03879916f, 0.10573194f, 0.16735160f, 
    0.06775783f, 0.33229521f, -0.13316236f, 0.58793390f, 0.29949158f, 0.22330020f, -0.01046652f, 0.01976890f, 
    -0.36233112f, 0.15347239f, 0.03290438f, 0.11247749f, -0.26454633f, 0.09972320f, -0.34638840f, -0.43477601f, 
    0.06698097f, -0.10441288f, 0.28304636f, 0.01576371f, -0.23153625f, -0.23890327f, 0.09633281f, -0.24239208f, 
    -0.69241601f, 0.02333907f, 0.04454108f, -0.34240419f, -0.32863313f, 0.00246043f, -0.16371760f, 0.02590890f, 
    0.00016121f, 0.16115975f, -0.15435632f, 0.33081371f, -0.26722383f, 0.23492962f, -0.23777886f, -0.09756765f, 
    0.16857432f, 0.00151885f, 0.05131968f, 0.00387766f, -0.32669440f, 0.15464538f, -0.09296238f, -0.08061808f, 
    -0.53643250f, 0.66760916f, -0.17541996f, 0.07410976f, 0.03285420f, -0.06503542f, 0.05596437f, 0.05870914f, 
    -0.09046575f, 0.06500233f, 0.23362012f, 0.16585793f, 0.14037046f, -0.26884532f, 0.15122734f, -0.10053391f, 
    0.03394908f, 0.15467687f, 0.11915451f, -0.09139007f, 0.04468719f, 0.01453834f, 0.02705042f, 0.05591954f, 
    0.03218810f, 0.17733695f, 0.13455257f, -0.05955270f, -0.08997057f, 0.07284118f, 0.07989009f, -0.19740191f, 
    -0.19769803f, 0.00368047f, -0.04816801f, -0.11770011f, -0.08085702f, 0.22059180f, -0.38610721f, -0.56055146f, 
    -0.12634909f, -0.16886599f, 0.06506082f, -0.02008354f, 0.09001026f, 0.01132274f, -0.00427612f, -0.06970534f, 
    -0.39542744f, -0.23703350f, -0.40821651f, -0.01857937f, 0.18579178f, 0.00550914f, -0.05624789f, -0.04290453f, 
    -0.15637986f, 0.04169330f, 0.02270652f, -0.04852782f, 0.09773511f, -0.43699917f, -0.04164714f, 0.77472305f, 
    0.13350081f, -0.06854214f, 0.12217035f, 0.48603120f, -0.30566230f, -0.15409112f, -0.08511803f, 0.02020931f, 
    -0.04883605f, -0.26621693f, -0.26772752f, -0.27471608f, 0.01780921f, -0.22317126f, -0.10430089f, -0.18672454f, 
    0.03502894f, -0.07186142f, -0.06039112f, -0.10352372f, -0.27633521f, -0.09611235f, 0.06871278f, -0.28075954f, 
    0.28789333f, 0.24327682f, -0.00125591f, -0.03979642f, -0.02687189f, 0.14664245f, 0.27713996f, -0.20961085f, 
    0.42174709f, -0.19802815f, 0.29567578f, -0.17345466f, 0.16771364f, -0.22079799f, -0.13110980f, -0.02290306f, 
    -0.01836147f, 0.02380630f, 0.03145166f, -0.17014840f, 0.04556500f, 0.18231058f, -0.14086865f, -0.11257115f, 
    -0.03450802f, 0.12683657f, -0.01843846f, -0.05840760f, 0.14469598f, 0.19953537f, 0.10175775f, 0.19413175f, 
    -0.05854143f, 0.01039906f, -0.08625705f, 0.27380157f, -0.00448639f, -0.19830292f, 0.16530700f, 0.01225311f, 
    0.07350072f, 0.06114933f, 0.08593362f, -0.00110097f, -0.33559293f, 0.58157164f, -0.52813596f, -0.20943601f, 
    -0.32004336f, 0.00156709f, 0.12655416f, -0.11685527f, -0.00200515f, 0.03220547f, -0.08065438f, -0.00185931f, 
    0.34295589f, -0.14678806f, 0.25225687f, -0.04823365f, 0.08614021f, 0.15375848f, -0.04008107f, -0.12656394f, 
    0.19436897f, 0.02938178f, -0.01263340f, 0.19345811f, -0.50187737f, -0.48618099f, 0.23054327f, 0.13756917f, 
    -0.07069649f, 0.11820593f, 0.09720312f, 0.04742657f, -0.06305928f, 0.23353489f, 0.05284511f, -0.06041544f, 
    -0.48305127f, -0.04143824f, -0.40654433f, 0.53431487f, -0.15110874f, 0.19487356f, 0.11676005f, 0.03044459f, 
    0.01606293f, 0.03974899f, 0.23184757f, 0.01378096f, -0.23822139f, -0.45443073f, -0.13857561f, 0.06591178f, 
    0.14151455f, 0.06187134f, 0.01450481f, -0.04786784f, -0.19631997f, -0.00061565f, -0.13418144f, -0.19767152f, 
    0.60492790f, 0.16818371f, 0.45442596f, -0.40058827f, -0.12766592f, -0.01432539f, -0.32823071f, 0.21674375f, 
    -0.13489486f, -0.11001218f, -0.13025072f, -0.12144125f, -0.72276783f, -0.50109124f, -0.29760265f, 0.02729100f, 
    -0.24807157f, 0.09054790f, -0.21533856f, 0.10483186f, 0.07845785f, 0.17012426f, 0.00989171f, 0.04983025f, 
    -0.47396281f, 0.34819904f, -0.55985069f, 0.20493262f, 0.02866460f, 0.12701221f, -0.04456905f, -0.05737734f, 
    0.01106978f, -0.21154211f, 0.11349916f, -0.04495037f, -0.27049309f, 0.09053735f, 0.13060725f, 0.17919433f, 
    -0.15271887f, 0.03944957f, -0.00873751f, -0.01367956f, -0.20764548f, -0.08899139f, -0.22776181f, -0.15080367f, 
    0.27693596f, 0.06270119f, 0.34267023f, -0.10582989f, 0.01903330f, -0.01952473f, 0.18100433f, -0.03327210f, 
    -0.19686124f, -0.02161874f, 0.07891496f, -0.02341469f, -0.13882551f, -0.24992160f, 0.00827750f, -0.36867598f, 
    -0.46508157f, -0.27749944f, -0.23160727f, -0.27347702f, -0.00766455f, -0.02324258f, 0.01284856f, -0.06276052f, 
    0.12051566f, -0.20141520f, 0.64163280f, -0.19631459f, 0.07273036f, 0.21430191f, -0.01541869f, 0.05541725f, 
    -0.20102499f, 0.09425884f, 0.21501878f, 0.12046460f, -0.44593135f, 0.18055569f, -0.34376392f, 0.14416908f, 
    0.04545184f, -0.09788670f, 0.23592970f, 0.23698552f, -0.05726333f, -0.02194818f, 0.03970434f, 0.17974479f, 
    -0.36226678f, 0.15794516f, -0.13739219f, 0.51865166f, 0.14672261f, 0.06503857f, 0.39591610f, -0.32834783f, 
    -0.10600997f, -0.19941303f, -0.06462147f, -0.00202671f, 0.08761353f, 0.04289829f, 0.19216391f, -0.10477895f, 
    0.01001574f, -0.28265977f, -0.18777895f, 0.07852138f, -0.00694871f, -0.04855258f, 0.07810592f, 0.00306704f, 
    0.37852222f, 0.30661404f, 0.00253808f, -0.29054502f, 0.03309360f, -0.03281124f, -0.05218968f, -0.06748312f, 
    0.03944831f, 0.09786761f, 0.13568228f, -0.09761721f, 0.04551827f, -0.00589795f, 0.24167953f, 0.37347546f, 
    -0.00459112f, -0.42833525f, 0.00720731f, -0.12692368f, 0.04888479f, -0.02723305f, -0.06421103f, -0.20837697f, 
    -0.58695751f, 0.00475628f, -0.18003815f, 0.45929098f, -0.31139788f, -0.13241425f, 0.35201019f, 0.47617733f, 
    -0.20007792f, 0.06536560f, 0.01310688f, -0.08737886f, -0.34267449f, -0.03185659f, -0.13570991f, 0.09994625f, 
    -0.08866753f, 0.00892271f, 0.14296997f, 0.08884696f, 0.17815641f, 0.19558881f, 0.23055430f, -0.08847534f, 
    -0.23710641f, -0.06219897f, -0.44840187f, 0.26297179f, 0.17330441f, -0.04943254f, 0.08426952f, -0.02262973f, 
    -0.06616116f, 0.03593451f, 0.10283310f, -0.09892035f, -0.34940851f, 0.26506725f, -0.12858669f, 0.24117041f, 
    -0.00514735f, -0.07185422f, -0.04560682f, 0.02351227f, 0.06186348f, 0.08673116f, 0.08238593f, -0.21436034f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.26014605f, 0.05790381f, 0.05684388f, -0.06699920f, -0.10455187f, 0.10356467f, -0.00527394f, -0.22125036f, 
    0.09660023f, 0.04122628f, 0.06323024f, -0.04068426f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
