#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.00835487f, -0.33392349f, -0.48537120f, -0.28359061f, 0.04829594f, 0.15524635f, -0.48050267f, -0.42760697f, 
    0.08939812f, -0.66344690f, 0.55443883f, -0.21997152f, 0.12944774f, 0.01977879f, -0.48440427f, -0.03260499f, 
    0.05743132f, 0.05360084f, -0.16629890f, 0.19432113f, 0.55927145f, 0.46362618f, -0.10140181f, 0.13868348f, 
    0.27674893f, 0.30107510f, 0.12690638f, 0.51901883f, -0.44376072f, -0.24194130f, 0.21067584f, -0.08751601f, 
    0.23839797f, 0.49085984f, 0.24721414f, 0.22945511f, 0.23573579f, -0.26413643f, 0.08485287f, -0.47741070f, 
    0.00571857f, -0.45406422f, -0.02910691f, 0.52473176f, -0.41551569f, -0.17629300f, 0.38482395f, 0.32887539f, 
    -0.62863004f, -0.32231632f, -0.29839122f, -0.16513692f, 0.13359275f, -0.15630180f, 0.81367326f, 0.05082049f, 
    0.69245231f, 0.08873519f, -0.29634553f, 0.32766497f, -0.04479905f, 0.02355929f, 0.05859672f, 0.57624137f, 
    0.61672926f, 0.41336960f, -0.30334637f, 0.23821473f, 0.05742543f, 0.33862329f, 0.30994070f, 0.18890405f, 
    -0.56985128f, -0.63124645f, -0.56330144f, -0.54127419f, -0.01367031f, 0.05111852f, 0.29388091f, 0.06807595f, 
    0.19999699f, -0.29523239f, -0.22674321f, -0.07511436f, 0.63323170f, 0.62807530f, 0.37437913f, 0.01014954f, 
    -0.18965583f, 0.05089486f, -0.55759448f, -0.37613282f, -0.61164504f, 0.19143900f, -0.47051316f, -0.27480569f, 
    -0.13806947f, 0.21877189f, 0.09736267f, 0.29106903f, 0.47414309f, -0.56155682f, 0.47016308f, 0.43985841f, 
    -0.14114636f, 0.28724027f, 0.20884500f, -0.11889434f, 0.54286623f, -0.50315022f, -0.06724755f, -0.24616276f, 
    -0.70178229f, -0.14042217f, -0.18096423f, 0.09783193f, 0.35040587f, -0.60074091f, -0.33423072f, -0.39826193f, 
    0.05646374f, 0.38982773f, 0.29964116f, -0.10944448f, 0.11014453f, -0.14107774f, 0.31240714f, -0.20669611f, 
    -0.50623822f, 0.40071401f, -0.33165669f, -0.13067767f, -0.03084924f, -0.21233948f, 0.17502189f, 0.21998198f, 
    0.09920876f, 0.16944636f, 0.30839008f, -0.58113557f, -0.26705346f, -0.18761703f, -0.16142771f, -0.37593281f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.44198844f, -0.13168262f, 0.17944181f, -0.42795938f, -0.41235992f, 0.16047268f, 0.14556219f, 0.12779884f, 
    -0.03273515f, -0.24012023f, -0.22812422f, -0.00987429f, -0.21860935f, 0.16784836f, -0.09688829f, -0.24255478f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.11382302f, -0.00181571f, 0.22973588f, -0.17258601f, 0.13339898f, -0.20639557f, 0.00233575f, 0.21670952f, 
    -0.14264968f, -0.00228790f, -0.09819718f, -0.13193071f, 0.08577984f, 0.12151005f, -0.12005921f, -0.02068854f, 
    -0.08549526f, 0.05164987f, -0.06576221f, -0.12226884f, -0.07041535f, 0.00830044f, -0.07207569f, 0.12883896f, 
    0.17686075f, 0.11584473f, -0.03596466f, -0.22726732f, 0.17075224f, -0.42682648f, -0.11649275f, 0.01899776f, 
    -0.04738042f, -0.00457234f, -0.04489763f, 0.09992351f, -0.27771711f, -0.30089074f, 0.29409662f, -0.02568844f, 
    -0.18401900f, -0.12756281f, -0.12954117f, -0.09566183f, -0.21403517f, -0.10593200f, -0.03669757f, 0.04497581f, 
    -0.07238274f, -0.04371044f, -0.13403325f, 0.09970502f, 0.02262199f, 0.01227018f, 0.05073673f, 0.03188396f, 
    0.09491886f, -0.08695439f, 0.13700449f, -0.13138118f, 0.03792904f, 0.02184356f, -0.09522453f, -0.15415524f, 
    -0.08016652f, -0.10792841f, -0.11372203f, -0.03680488f, -0.13767794f, -0.00946048f, 0.12427492f, 0.02813204f, 
    0.13685454f, -0.09687462f, 0.29055649f, 0.00665544f, 0.01039818f, 0.02943271f, 0.06840143f, -0.06273679f, 
    0.18302280f, 0.17418490f, 0.18671063f, -0.19845313f, -0.10948674f, 0.15653002f, -0.03998920f, 0.10238167f, 
    0.00900854f, 0.01630913f, 0.01880316f, 0.10316969f, 0.11753795f, -0.00079567f, -0.16011237f, 0.16635513f, 
    -0.12264043f, 0.10145973f, -0.14590438f, -0.29119447f, 0.20827119f, -0.16869348f, -0.17673266f, 0.06649660f, 
    -0.08065523f, 0.11237279f, 0.04426817f, 0.21735597f, -0.04641175f, 0.07626456f, -0.10452712f, -0.04908748f, 
    -0.01391914f, -0.08380935f, -0.10782506f, 0.04945683f, -0.09094380f, 0.18662068f, 0.15857933f, 0.10358165f, 
    0.13077180f, 0.04095447f, 0.23147473f, -0.04540347f, 0.01296132f, 0.04907730f, 0.04738563f, -0.01980124f, 
    -0.10951355f, 0.04266957f, 0.20975995f, 0.11919510f, 0.09866557f, 0.09676450f, -0.14891309f, 0.04961891f, 
    0.20268393f, 0.12795347f, -0.09242602f, -0.05093230f, -0.02205585f, 0.20771925f, -0.02434772f, 0.01877440f, 
    0.22380525f, 0.15493137f, 0.11160316f, -0.06129469f, 0.00879684f, 0.02947787f, 0.11444645f, 0.01942076f, 
    -0.02348275f, -0.47658026f, -0.13579506f, -0.12018685f, 0.01999539f, -0.01766936f, -0.04705000f, -0.01624978f, 
    0.07075870f, 0.05604403f, 0.05336434f, -0.17055693f, 0.04170758f, -0.19607252f, -0.02232021f, -0.06634507f, 
    0.07711059f, 0.00886726f, 0.07038572f, 0.22110690f, 0.25416416f, 0.28788996f, -0.02170399f, -0.11117796f, 
    -0.02690039f, 0.12352418f, 0.06200420f, -0.02298059f, 0.03608556f, -0.29443717f, -0.04748275f, 0.22403376f, 
    0.10133465f, -0.07989523f, 0.07599516f, -0.15876269f, -0.07681720f, -0.29199383f, -0.13876611f, -0.25326076f, 
    -0.12012263f, -0.05804856f, 0.03080247f, -0.09942736f, 0.01634054f, -0.05134194f, 0.15169275f, 0.18364374f, 
    0.04979188f, 0.16102670f, -0.13996662f, -0.11471032f, 0.04735267f, 0.11621501f, 0.10966044f, 0.10094988f, 
    -0.20189257f, 0.05711130f, 0.04176435f, -0.11644868f, -0.14414740f, 0.08566094f, 0.01191282f, 0.10368650f, 
    0.25444043f, 0.41436738f, -0.00745096f, -0.02322340f, 0.00056491f, -0.05082373f, -0.01922533f, -0.00054518f, 
    0.13681570f, 0.02183915f, -0.15649161f, 0.08946931f, -0.09370427f, -0.02530984f, 0.06261355f, 0.02216672f, 
    0.07872373f, -0.11549448f, 0.37174970f, 0.28939766f, -0.00282896f, -0.02886343f, -0.05496804f, 0.14823943f, 
    0.10549946f, -0.05256207f, 0.01284104f, 0.08212415f, -0.31309637f, 0.00850995f, 0.04534089f, -0.03882875f, 
    -0.07384284f, 0.13773824f, -0.02164416f, 0.10732293f, 0.03954592f, -0.14680707f, -0.23800066f, 0.07328442f, 
    0.06300297f, 0.21680889f, 0.04344712f, -0.00565192f, -0.08047409f, -0.02342941f, 0.26899183f, 0.13855191f, 
    0.07446217f, 0.06347665f, -0.05707399f, -0.03988313f, -0.11444388f, 0.06126421f, 0.15304096f, 0.14414433f, 
    -0.22695322f, -0.22594088f, 0.07189352f, -0.06394028f, -0.04936116f, -0.12466574f, -0.14202599f, -0.09719866f, 
    -0.11210743f, 0.13052244f, -0.12859005f, -0.06329761f, -0.04729164f, -0.17302717f, -0.06106462f, -0.13595676f, 
    0.17187515f, 0.02235779f, -0.17998371f, -0.23983818f, -0.05792134f, -0.03335334f, 0.18338887f, 0.02131469f, 
    -0.04157218f, -0.42737252f, -0.13090593f, -0.43805096f, 0.05538373f, -0.18754472f, -0.00690603f, 0.02134115f, 
    -0.00073492f, -0.03359130f, 0.25880727f, 0.21800083f, -0.10554652f, 0.11543517f, 0.09802411f, 0.01144468f, 
    -0.03753315f, -0.11557111f, 0.08643774f, -0.12760583f, -0.07007921f, 0.12358770f, -0.09798994f, 0.01096005f, 
    -0.02749048f, -0.06367364f, -0.02312806f, 0.16854708f, -0.14221977f, -0.01122144f, -0.14871150f, 0.17524008f, 
    0.03186261f, 0.07887911f, -0.13120730f, 0.01925558f, -0.18992972f, -0.15998869f, 0.27213702f, -0.23047726f, 
    0.14999677f, 0.05976792f, -0.05356161f, 0.08789106f, 0.18117857f, -0.03094640f, 0.00191831f, -0.10574563f, 
    -0.05552796f, 0.02929088f, 0.20322081f, 0.04344843f, 0.08324697f, 0.02720939f, 0.02995001f, 0.18699460f, 
    0.10340013f, -0.08931914f, 0.13227861f, -0.00145293f, -0.10718516f, 0.10222037f, 0.06711370f, -0.07269157f, 
    -0.52753592f, 0.15206462f, 0.18934003f, 0.04340516f, 0.13622203f, 0.07508042f, -0.07197290f, -0.01527515f, 
    -0.02845824f, 0.01355037f, -0.13151674f, 0.08100581f, -0.30742374f, -0.15773940f, -0.11421528f, -0.08818753f, 
    -0.06478481f, 0.02519271f, -0.10079425f, -0.18331219f, 0.21024965f, -0.21016780f, 0.08616759f, 0.14136793f, 
    0.03177040f, 0.00602051f, -0.02021006f, 0.25177905f, 0.26930186f, -0.24466018f, -0.05198476f, -0.14797626f, 
    -0.08468083f, 0.04825924f, 0.09614812f, 0.01888370f, -0.06114409f, -0.06795602f, -0.02025116f, 0.43265864f, 
    -0.04214977f, 0.08534950f, 0.02548563f, 0.03753936f, 0.01616903f, -0.28733215f, -0.24632205f, 0.29933050f, 
    -0.00048078f, -0.07567494f, 0.01583651f, -0.08719034f, 0.01485507f, -0.00517323f, 0.10349704f, 0.21585844f, 
    0.06913765f, -0.19654909f, 0.07673527f, -0.10278725f, 0.01404315f, -0.06955867f, 0.11204873f, 0.17217447f, 
    0.11127314f, -0.22726379f, 0.03548058f, -0.02014395f, -0.07451182f, 0.14432983f, 0.07101048f, 0.08412979f, 
    -0.07454883f, -0.34118238f, -0.03622466f, 0.06153039f, 0.06593580f, 0.03834038f, 0.11969313f, -0.16386068f, 
    -0.01065348f, 0.29585221f, 0.05516379f, 0.07367209f, 0.00049602f, -0.11479070f, -0.12491315f, -0.01070802f, 
    0.11046673f, 0.21700333f, 0.26370090f, 0.02986285f, -0.10265490f, 0.16410382f, -0.07869537f, 0.18783909f, 
    0.07893467f, 0.01232409f, -0.13300818f, 0.02507387f, -0.22198547f, 0.03915096f, -0.03787750f, -0.03480556f, 
    -0.11958724f, -0.07688347f, 0.06314693f, -0.03740180f, -0.02010630f, -0.02597883f, -0.12798132f, 0.19224569f, 
    -0.12725239f, -0.16204004f, 0.04893261f, -0.17177387f, 0.24160296f, 0.21460411f, -0.09361652f, 0.18106461f, 
    -0.08790253f, 0.11336354f, -0.18608849f, 0.00992585f, -0.02075051f, 0.14548038f, -0.18603960f, 0.03817170f, 
    -0.07192434f, 0.02286978f, 0.12941891f, 0.16640748f, -0.00110453f, 0.03124483f, -0.20286468f, -0.28154081f, 
    0.10583737f, 0.07885156f, 0.03627756f, 0.05824334f, -0.00415727f, -0.06198587f, -0.02045995f, -0.20352478f, 
    0.18686086f, -0.06836990f, 0.04042665f, 0.12210119f, -0.03359003f, 0.03984748f, -0.01159548f, 0.06099975f, 
    0.05403693f, 0.02258463f, -0.25709552f, -0.22851309f, 0.00337990f, 0.04030212f, -0.07264999f, -0.10300126f, 
    0.11384431f, -0.02193286f, 0.30099064f, -0.19697334f, -0.01183480f, -0.11253192f, 0.15123148f, 0.03307534f, 
    -0.02224970f, -0.05926347f, 0.01684377f, 0.04751556f, -0.08225783f, -0.07023199f, 0.00682866f, 0.04031963f, 
    0.06895196f, -0.18966912f, -0.03177956f, -0.02562825f, 0.10369605f, -0.10382704f, 0.12880825f, 0.04460618f, 
    0.08100300f, -0.07994187f, 0.12897271f, 0.11122108f, -0.07938048f, 0.07116377f, 0.13112590f, -0.01554587f, 
    -0.12822321f, 0.07561526f, 0.05575739f, -0.10560893f, 0.00423705f, 0.01033543f, -0.07441169f, 0.12779176f, 
    -0.15916790f, -0.00229130f, -0.11019405f, -0.04722586f, -0.15094887f, 0.03888321f, 0.08710976f, -0.00293414f, 
    0.34853223f, -0.14233379f, 0.17380561f, -0.08752531f, 0.00097087f, -0.01917435f, -0.05892016f, 0.00427602f, 
    -0.07380348f, -0.05492883f, -0.18444391f, 0.08030434f, -0.19878796f, 0.22419186f, 0.11783060f, -0.12163226f, 
    0.16284704f, -0.27692929f, -0.15989365f, -0.16784506f, 0.09340897f, -0.01782248f, -0.14965080f, -0.06977716f, 
    -0.08072052f, 0.12877318f, 0.14315645f, -0.09130858f, -0.04771578f, -0.10298406f, -0.09678916f, 0.09635776f, 
    -0.04356795f, 0.10275917f, 0.03150316f, 0.04088367f, -0.27172574f, -0.03123770f, -0.13861181f, -0.12904984f, 
    -0.00389137f, -0.06469336f, 0.06445139f, -0.02881756f, 0.02341644f, -0.14879107f, -0.12028418f, -0.08660936f, 
    0.15944302f, 0.07913326f, 0.13121398f, -0.05390011f, 0.04652106f, 0.04129594f, 0.11447716f, -0.09035172f, 
    0.07347463f, 0.09209979f, -0.08869518f, -0.02232392f, 0.10400505f, -0.06439365f, 0.31529284f, 0.14564705f, 
    0.17090908f, -0.22072768f, -0.07722806f, 0.02394525f, 0.05203417f, 0.10254906f, -0.03268565f, 0.19951329f, 
    0.30169439f, 0.02745833f, 0.06821249f, -0.08216916f, -0.10535108f, 0.12854341f, 0.02251702f, -0.09186742f, 
    0.07015677f, 0.02132426f, -0.03437832f, -0.01548528f, 0.09471864f, -0.13033025f, -0.13788509f, 0.06215224f, 
    -0.03319993f, -0.16181028f, -0.47340119f, -0.02465908f, 0.04115470f, 0.12432168f, -0.06737077f, -0.08889840f, 
    -0.09607456f, -0.04882098f, 0.09803782f, 0.26784202f, -0.03221121f, 0.16981792f, 0.03619306f, 0.03179720f, 
    -0.15169489f, -0.10672631f, -0.01813981f, 0.04906046f, -0.01832279f, 0.21148075f, -0.04321238f, 0.00019882f, 
    0.03877071f, 0.08042070f, -0.01471558f, 0.05859156f, -0.07164390f, 0.02730437f, -0.14985241f, 0.05123238f, 
    -0.01811896f, 0.10059439f, -0.01656593f, 0.03420260f, -0.00367058f, -0.23562759f, -0.04678367f, -0.05393001f, 
    0.11977242f, 0.09936234f, 0.06994195f, 0.02348814f, 0.03545758f, -0.05829566f, -0.21129605f, -0.05027813f, 
    -0.09133121f, 0.03831239f, 0.08874532f, -0.19842967f, -0.00199011f, -0.27300200f, 0.03633546f, 0.17064764f, 
    0.19536042f, -0.14222932f, 0.05344622f, -0.03697057f, 0.05479638f, -0.10846212f, -0.00831245f, 0.06147407f, 
    0.11933016f, -0.21707034f, -0.07957065f, 0.04753621f, -0.01517513f, 0.02876130f, 0.11621178f, -0.05955205f, 
    0.19890448f, 0.04685062f, -0.20711736f, -0.41830197f, 0.01120612f, -0.04398416f, 0.14112814f, -0.06370200f, 
    0.04365043f, 0.00059230f, 0.11743083f, 0.09161032f, -0.01944379f, -0.04267636f, 0.04801327f, -0.14852849f, 
    0.08794086f, 0.01140198f, -0.06357592f, -0.11765035f, -0.09356242f, 0.20723298f, -0.09419072f, 0.02515797f, 
    0.02352297f, 0.15224513f, -0.13580757f, 0.11764266f, 0.00577775f, 0.05691931f, -0.16769871f, 0.17958139f, 
    0.19360133f, -0.13845591f, 0.03916467f, -0.01067106f, -0.12422621f, 0.05722253f, 0.10368864f, -0.27184021f, 
    0.00166383f, 0.07557580f, 0.19753841f, -0.02297807f, 0.01437724f, 0.02421129f, -0.41889212f, 0.02254002f, 
    -0.08926532f, 0.02315831f, 0.05215174f, -0.00584643f, -0.11032143f, 0.01684898f, 0.13353501f, -0.00422141f, 
    0.06306152f, -0.00541714f, 0.00369619f, 0.10198786f, 0.10509593f, -0.07795411f, -0.04714160f, 0.08250935f, 
    0.54875344f, -0.01610303f, 0.04154450f, -0.12109867f, -0.06912526f, -0.01610612f, -0.06584458f, -0.02206968f, 
    -0.05314222f, 0.26686457f, 0.18643786f, 0.29258791f, -0.04475797f, -0.14761364f, -0.07026775f, 0.06870850f, 
    -0.00699368f, 0.12981102f, -0.13578302f, -0.08330117f, 0.12369257f, -0.02257996f, 0.01981345f, -0.02587624f, 
    -0.01637915f, 0.14627907f, 0.01218753f, 0.19517185f, -0.21864097f, 0.01968015f, -0.08576766f, -0.02211010f, 
    0.05728865f, -0.05295250f, -0.02233914f, 0.06308053f, -0.46796989f, 0.04913337f, -0.03434143f, 0.06301641f, 
    -0.07879226f, 0.03820442f, -0.09502784f, 0.08845306f, -0.10741547f, 0.24998242f, -0.02967356f, 0.06745557f, 
    -0.10825504f, 0.02034069f, 0.02075247f, 0.11825807f, -0.03223611f, 0.05203585f, -0.20159319f, -0.10313036f, 
    0.11961122f, -0.13240807f, 0.00421880f, -0.06564205f, -0.12457626f, 0.00279525f, -0.19258907f, -0.13119262f, 
    -0.14067414f, -0.00123545f, -0.10873031f, 0.14139068f, -0.04154655f, -0.15224636f, -0.04222925f, 0.10070876f, 
    0.00266930f, 0.02349214f, -0.02267630f, -0.06052519f, 0.00974897f, 0.02463521f, -0.08721696f, 0.06732663f, 
    0.04253438f, -0.00825197f, 0.04219631f, -0.04868989f, -0.03722762f, -0.02253465f, 0.00674805f, -0.07310753f, 
    0.02439855f, -0.01223439f, 0.04681600f, -0.07778564f, 0.04107935f, -0.04086518f, -0.02883836f, 0.06214020f, 
    -0.06363046f, 0.02065673f, -0.04372960f, 0.04889772f, -0.02911279f, 0.05136749f, -0.07943632f, 0.01795089f, 
    0.07123312f, -0.03535941f, 0.05741835f, -0.04258839f, 0.02538189f, -0.00127910f, -0.05963764f, -0.02913614f, 
    0.03147148f, -0.08013820f, 0.00020298f, -0.00041676f, -0.03110581f, 0.00978844f, -0.07216422f, -0.07342330f, 
    0.00940645f, -0.00826304f, 0.02126342f, -0.07991634f, -0.03961488f, -0.00352757f, -0.08430194f, -0.00536379f, 
    -0.06296654f, -0.02930804f, -0.05327199f, -0.04967526f, 0.04985293f, 0.01561029f, -0.01595563f, 0.01818758f, 
    0.02290285f, 0.04710791f, 0.04402743f, -0.07019345f, -0.07570206f, -0.06868058f, -0.00810703f, 0.06345537f, 
    0.05241792f, -0.04230317f, 0.07500743f, 0.08105326f, 0.01126006f, 0.00186918f, -0.02675391f, -0.08041717f, 
    0.02280219f, -0.07039821f, -0.01929082f, 0.06753113f, -0.07901170f, 0.03841580f, -0.04951346f, -0.08892616f, 
    -0.03236273f, -0.04031513f, -0.03785178f, -0.06935852f, 0.04363090f, -0.02137858f, -0.02953083f, 0.05258716f, 
    -0.03892941f, -0.02728122f, 0.02252911f, 0.07134294f, -0.06501780f, -0.04636526f, -0.04499663f, -0.06596852f, 
    0.03071010f, -0.03409152f, -0.00815140f, 0.06332842f, 0.01422092f, 0.01788280f, -0.00051290f, 0.05454110f, 
    -0.00492086f, 0.03490815f, 0.03417237f, -0.01031120f, 0.05838130f, 0.02036903f, 0.02401344f, -0.06724112f, 
    0.01696316f, -0.03710234f, -0.01984245f, -0.04477313f, -0.06412940f, -0.03542796f, -0.04493413f, -0.09128458f, 
    -0.06833766f, -0.04894938f, -0.00838257f, 0.05539922f, 0.03119757f, 0.02496586f, 0.02709867f, -0.07079741f, 
    0.07218380f, 0.08245546f, -0.06011309f, -0.05254000f, -0.04740302f, 0.02427994f, 0.03389981f, 0.05633786f, 
    -0.15352397f, 0.13888603f, -0.16718605f, 0.04729556f, 0.01446987f, -0.02796439f, -0.03564190f, -0.14981233f, 
    0.09108372f, 0.14485683f, -0.12655000f, -0.04897534f, 0.13272940f, -0.21236317f, 0.09718293f, 0.06117150f, 
    -0.03131980f, 0.14354940f, -0.27109218f, 0.09749662f, 0.01632501f, -0.02648558f, 0.11111359f, -0.07669698f, 
    0.04539286f, 0.17929128f, 0.05959785f, -0.14058010f, -0.12413523f, -0.22796030f, 0.17687178f, -0.05525733f, 
    -0.03929147f, 0.15158455f, 0.12534343f, -0.19674353f, 0.11918105f, 0.06163146f, -0.07827295f, 0.05404706f, 
    -0.07157142f, -0.11271930f, -0.01906742f, 0.04683947f, 0.07481771f, 0.13278602f, 0.11638317f, 0.00377893f, 
    0.08776436f, -0.01055775f, -0.07093292f, 0.03778704f, 0.15276173f, 0.27901754f, 0.20843524f, 0.01630442f, 
    0.10810427f, -0.11334006f, -0.02541739f, 0.02532347f, -0.02599002f, 0.02004793f, -0.07129460f, -0.29786918f, 
    0.13297524f, 0.12867247f, -0.11021690f, -0.09271409f, -0.04382806f, -0.03935121f, -0.01662540f, -0.15587848f, 
    -0.15748177f, -0.12948103f, -0.08629501f, 0.06911246f, 0.04702736f, 0.06961431f, 0.06787165f, -0.06454215f, 
    0.01363289f, 0.32571471f, 0.10834401f, -0.00992319f, -0.01857703f, -0.02388137f, 0.01150041f, 0.08375512f, 
    -0.00964515f, -0.09659164f, -0.51821035f, -0.14185086f, -0.16576953f, 0.10042426f, 0.16682403f, -0.15114754f, 
    -0.00598984f, -0.10580546f, -0.01321323f, -0.28394032f, 0.03980593f, -0.05048342f, 0.08238194f, 0.09869796f, 
    0.11002943f, -0.00838885f, 0.03405983f, 0.03546809f, -0.15106976f, -0.18858507f, 0.07566760f, -0.25987679f, 
    -0.03401528f, -0.20453240f, 0.02973914f, 0.02445127f, 0.03994125f, 0.14775236f, 0.07557654f, -0.34148899f, 
    0.19134535f, 0.10154391f, 0.18436787f, -0.04671777f, -0.04866716f, 0.07888149f, -0.14451389f, -0.11957482f, 
    -0.11056060f, 0.07776226f, -0.12742944f, 0.11356017f, 0.04207043f, -0.13173002f, 0.09441464f, 0.08235889f, 
    0.07167374f, 0.17256996f, 0.09231818f, -0.13083754f, -0.21409653f, 0.12518892f, 0.07829809f, 0.15948910f, 
    -0.08757668f, -0.31896219f, 0.21999680f, -0.20480312f, -0.05980890f, 0.03369344f, -0.10472248f, 0.05755467f, 
    -0.25290558f, 0.07004233f, 0.10420415f, 0.01889306f, -0.03699940f, 0.15503398f, -0.09298160f, 0.09797532f, 
    -0.03996124f, 0.04513337f, 0.11987652f, -0.18239853f, -0.10999928f, 0.12505645f, 0.05036008f, 0.04791650f, 
    -0.12474348f, -0.03361318f, -0.00129785f, 0.24547057f, 0.05491789f, -0.25059327f, -0.27674538f, -0.05766394f, 
    -0.01171273f, -0.07023991f, -0.08297747f, -0.13797691f, 0.02906621f, 0.11746060f, -0.05951119f, 0.03259161f, 
    -0.04464291f, -0.03678018f, -0.14848390f, -0.01493240f, -0.09426675f, -0.04818381f, 0.13314341f, 0.16339600f, 
    -0.05271456f, 0.13955916f, -0.03925268f, -0.01271879f, 0.06652856f, -0.02012566f, -0.16267735f, 0.28519183f, 
    0.30743811f, 0.11777204f, 0.08495010f, 0.00348341f, -0.03435569f, 0.04565033f, 0.16912670f, -0.04437492f, 
    0.24286555f, 0.31061587f, -0.14430554f, 0.03010048f, 0.12984703f, 0.09480567f, -0.07439765f, 0.05829849f, 
    -0.33308795f, 0.00871931f, 0.09330062f, 0.22038239f, 0.09143441f, 0.14193217f, 0.15271662f, -0.05463107f, 
    0.06420165f, 0.09745826f, -0.32404217f, -0.26613599f, 0.08367844f, -0.05359206f, 0.00002678f, 0.07871985f, 
    -0.02036833f, 0.02121155f, -0.28043360f, 0.08943757f, -0.00801476f, 0.00205996f, 0.09706566f, 0.02520333f, 
    -0.06456840f, -0.04174837f, 0.12707010f, -0.19913082f, -0.19070323f, 0.28187737f, -0.01922847f, -0.07206829f, 
    0.02386560f, -0.07145608f, 0.14504275f, -0.00074834f, -0.13127640f, -0.12167865f, 0.04611774f, -0.20584314f, 
    0.07497904f, -0.17288429f, 0.06462667f, -0.17391908f, -0.09110335f, -0.39506662f, -0.23987953f, 0.00148840f, 
    0.06921025f, 0.04608231f, 0.03861005f, -0.04682563f, -0.04759791f, 0.01689432f, -0.01244053f, -0.01701494f, 
    -0.35280505f, -0.12714492f, 0.02514574f, 0.00025586f, -0.02326865f, 0.05534722f, -0.06909834f, -0.21191074f, 
    -0.11143569f, 0.16765361f, -0.18361960f, 0.08037651f, 0.16676116f, -0.03599029f, 0.22881566f, 0.03715834f, 
    -0.02595457f, 0.21378908f, -0.28902417f, -0.08434709f, 0.00790015f, 0.14987645f, 0.04008610f, -0.03715616f, 
    0.01331456f, 0.47458738f, -0.05686815f, 0.05020431f, 0.07289775f, 0.05867682f, 0.03193137f, 0.10518255f, 
    -0.10336249f, -0.03000892f, -0.07135162f, -0.14301375f, -0.13784204f, 0.10157900f, -0.03623649f, -0.05139948f, 
    -0.07826879f, -0.01821349f, 0.06887189f, 0.08372478f, 0.09978328f, -0.00651962f, -0.14126584f, 0.00325892f, 
    0.06500284f, -0.01279209f, 0.06225418f, 0.10544177f, 0.05490595f, 0.33213082f, 0.14582652f, 0.05783750f, 
    0.11087392f, -0.12174629f, -0.00281842f, -0.04819022f, -0.10920802f, -0.19610603f, -0.05015355f, 0.09014066f, 
    0.11073555f, 0.13949494f, 0.18233360f, -0.14961854f, -0.11280629f, 0.09860487f, -0.29426062f, -0.59426814f, 
    0.03193394f, -0.01950508f, 0.02623285f, 0.06161569f, -0.01087215f, -0.07301999f, 0.01559534f, -0.13869594f, 
    -0.09356790f, -0.03330863f, -0.06038282f, 0.01024907f, 0.04322992f, -0.05745223f, -0.06270676f, -0.09801503f, 
    -0.06373276f, 0.01095334f, -0.02730026f, -0.05857046f, -0.14327468f, 0.02651452f, -0.01623036f, -0.11107194f, 
    -0.11367942f, 0.07037188f, -0.07571663f, 0.06898065f, -0.00628270f, 0.04298011f, -0.17765418f, 0.06215876f, 
    0.14257739f, 0.12024772f, -0.17858548f, 0.17961039f, -0.09187084f, -0.06893252f, 0.03260558f, 0.08795504f, 
    0.07596213f, 0.01886132f, 0.02999427f, 0.22427720f, -0.15300258f, -0.03643975f, -0.13643511f, -0.14144288f, 
    -0.09951333f, 0.04077425f, 0.05452891f, 0.00149150f, 0.36390096f, 0.01356527f, -0.04344893f, -0.02700662f, 
    -0.12316766f, -0.14060134f, -0.00789216f, -0.09302052f, 0.00704577f, 0.11248863f, 0.05759640f, 0.09009879f, 
    0.06624606f, 0.01838709f, -0.04492385f, 0.03806538f, -0.02565535f, 0.05447937f, 0.22056167f, 0.22926112f, 
    -0.15764835f, 0.00611456f, -0.04833694f, 0.12466076f, -0.01440752f, 0.04266086f, -0.13447319f, 0.15105636f, 
    -0.20271729f, -0.13499926f, -0.07152539f, -0.03960585f, 0.04441369f, -0.01375954f, -0.10684625f, 0.07176666f, 
    0.26543957f, -0.21509629f, 0.11030483f, -0.08164187f, 0.08873405f, -0.05034107f, 0.11473255f, 0.11712106f, 
    0.05298390f, -0.19178818f, -0.04370579f, 0.23641282f, 0.08472469f, -0.11200699f, -0.01368582f, 0.06644002f, 
    -0.08618262f, 0.08780524f, 0.06658779f, -0.00478000f, -0.14002101f, 0.06641717f, -0.00252727f, 0.01460913f, 
    -0.22235934f, -0.20174693f, -0.03920665f, 0.03619954f, -0.06784296f, -0.13093747f, 0.00058409f, 0.12631983f, 
    0.06977160f, -0.05479207f, 0.02720102f, -0.17068699f, 0.20175448f, -0.02963200f, -0.19132267f, 0.00101633f, 
    0.10213887f, -0.10685012f, -0.03154302f, -0.06350411f, -0.03883597f, -0.11423431f, 0.03278692f, 0.02820311f, 
    -0.10085604f, 0.00498185f, -0.16453011f, 0.11494870f, 0.06029860f, 0.15876698f, -0.03378756f, 0.11114715f, 
    -0.20155351f, -0.06247432f, 0.07479054f, -0.03264022f, 0.06582758f, 0.01960004f, -0.18019764f, -0.05113064f, 
    0.17530549f, 0.12083574f, -0.03829139f, 0.00276383f, 0.11194885f, -0.13037139f, -0.03961770f, 0.01469888f, 
    -0.18010886f, 0.02291954f, 0.08707725f, 0.31901267f, 0.11635289f, -0.06668845f, -0.10210844f, 0.05943155f, 
    -0.10086365f, -0.35612330f, 0.05533414f, -0.06891228f, 0.30841681f, -0.00287734f, 0.03808196f, -0.02216862f, 
    -0.01377368f, 0.05540854f, -0.18381837f, -0.04947102f, 0.14341275f, 0.07242920f, 0.16550143f, 0.09746857f, 
    0.05037414f, -0.04362378f, -0.00766868f, -0.04510173f, 0.23137990f, 0.05417244f, 0.19909489f, -0.13641433f, 
    -0.08721068f, -0.03636346f, -0.04334345f, -0.10753305f, 0.22766705f, -0.07079108f, -0.04026998f, -0.31999746f, 
    -0.11596188f, -0.19481146f, 0.05460022f, 0.04175460f, 0.08488980f, -0.09750448f, 0.02468789f, 0.14743620f, 
    0.19511047f, 0.08230019f, 0.00324947f, -0.03456192f, -0.08809518f, 0.10471378f, 0.12396360f, -0.05637689f, 
    -0.05415136f, -0.01020747f, -0.09861398f, 0.01198118f, -0.21166675f, 0.09826650f, 0.12242690f, 0.13511571f, 
    0.12547272f, -0.14422052f, -0.01914535f, -0.00753115f, 0.28848875f, 0.07835903f, -0.01024392f, 0.02318147f, 
    -0.01845913f, -0.07211233f, 0.06719812f, -0.04304625f, -0.02076215f, 0.03288860f, -0.07110365f, 0.00180461f, 
    -0.04489907f, 0.10106176f, -0.11329705f, -0.22249496f, -0.09324484f, 0.00581306f, -0.07774407f, 0.08603617f, 
    -0.17432831f, -0.03535748f, -0.30092338f, 0.03580449f, -0.22919619f, 0.10239495f, 0.00388100f, -0.16349711f, 
    0.15007304f, -0.01821386f, 0.08533128f, 0.02849352f, -0.15724051f, -0.01295245f, -0.17549023f, -0.06771299f, 
    0.02859801f, -0.06918536f, 0.13676986f, 0.12599210f, -0.01740996f, 0.07200595f, 0.12226979f, 0.20335405f, 
    -0.01417875f, -0.04350511f, -0.19558111f, 0.08407161f, -0.04697258f, 0.19449629f, 0.12790380f, -0.03129646f, 
    0.07244902f, 0.00370475f, 0.11293768f, -0.10632452f, 0.13970013f, -0.17314762f, -0.52237171f, -0.25431636f, 
    0.06651672f, 0.20684503f, 0.12505673f, -0.09085709f, -0.00598394f, 0.03534788f, 0.08568485f, -0.63535529f, 
    -0.18200843f, -0.05984662f, 0.08209670f, -0.10026558f, -0.11217833f, -0.10179171f, -0.02871153f, 0.12272356f, 
    -0.00738275f, 0.04700686f, 0.05629388f, 0.23709863f, -0.08731364f, 0.02779800f, -0.02995894f, 0.08073740f, 
    0.00494506f, 0.09601954f, 0.11845507f, -0.13860407f, 0.04979363f, 0.15183778f, -0.08782259f, 0.03331620f, 
    0.04837276f, -0.05088339f, 0.11108351f, 0.02592071f, -0.02069413f, -0.13113476f, -0.10967767f, -0.00471426f, 
    -0.01122012f, 0.12405771f, -0.06754814f, 0.03662332f, -0.04605475f, -0.13333252f, -0.05855580f, -0.00224186f, 
    -0.01251205f, 0.10490097f, -0.05157883f, 0.02683869f, 0.14458512f, 0.00612039f, -0.07750750f, -0.00340116f, 
    0.10797044f, 0.04048476f, -0.13773370f, -0.02103778f, 0.01579798f, -0.00623152f, 0.15828332f, 0.18739562f, 
    -0.11030314f, 0.14589949f, -0.13329168f, 0.08892674f, 0.10701363f, 0.01315954f, 0.02999430f, 0.16504943f, 
    -0.24005401f, 0.06797495f, -0.06591619f, 0.04659773f, 0.14363620f, -0.02378778f, -0.06008131f, -0.21466836f, 
    0.08614387f, 0.16739346f, 0.04350712f, 0.15170132f, 0.09622198f, -0.06852390f, -0.01529257f, -0.06872410f, 
    -0.20343928f, -0.01781279f, -0.07414774f, 0.24277143f, -0.09558985f, -0.03971040f, -0.04137785f, -0.18479016f, 
    0.25288969f, -0.10804305f, -0.19817165f, 0.00717520f, 0.05854674f, 0.15806846f, 0.14185272f, 0.10414226f, 
    -0.09581140f, -0.10198027f, -0.11971629f, 0.08327696f, 0.17900370f, 0.02563347f, 0.06129746f, -0.04173037f, 
    0.07295342f, 0.00534867f, -0.02956318f, -0.19851282f, -0.14924052f, 0.10457557f, -0.01657116f, -0.02015932f, 
    -0.05145569f, 0.04362687f, -0.07955977f, 0.06226876f, 0.06679414f, -0.04311858f, -0.16729875f, 0.08687494f, 
    -0.09066207f, 0.06876716f, -0.13315368f, -0.06801729f, 0.03171397f, 0.00115560f, -0.01991455f, -0.33363852f, 
    0.04106816f, 0.08164117f, 0.10525467f, 0.17120007f, -0.03480402f, -0.10072237f, 0.03087777f, 0.16200544f, 
    0.20405360f, 0.09969047f, -0.04961425f, -0.06731237f, -0.04029763f, -0.06697401f, 0.08433843f, 0.13264027f, 
    0.24794149f, -0.06888622f, -0.08787791f, 0.04172684f, -0.18695822f, -0.06164956f, -0.00331623f, 0.16968852f, 
    -0.08491620f, 0.25411412f, 0.06936792f, 0.13042639f, 0.09633676f, 0.02729350f, -0.01222073f, 0.14432172f, 
    -0.24471101f, 0.04802359f, 0.10122892f, -0.06742639f, -0.07759565f, -0.14663668f, -0.25919193f, 0.09308112f, 
    0.04826234f, -0.00124805f, -0.29726732f, 0.10627577f, -0.07570300f, -0.05726859f, -0.02066732f, 0.22748911f, 
    0.03075137f, 0.00524411f, 0.02523615f, 0.14246240f, -0.15845901f, -0.14195439f, -0.15821587f, -0.06493616f, 
    0.04418209f, -0.06693085f, -0.01555944f, 0.15110908f, -0.19324780f, 0.26865295f, -0.14463498f, 0.07563540f, 
    0.17379318f, 0.05367130f, -0.10787716f, -0.09931677f, 0.04888799f, 0.07618641f, 0.03930559f, -0.23076862f, 
    0.01807430f, 0.06684558f, -0.08120963f, 0.00431105f, 0.05654660f, -0.06298693f, -0.15083922f, -0.22366883f, 
    -0.02471262f, 0.08620964f, 0.04786369f, -0.12805019f, 0.04272052f, -0.05314818f, -0.16582592f, -0.19024362f, 
    -0.05556578f, 0.16875094f, -0.04996225f, 0.00876571f, 0.12766461f, -0.00157558f, 0.24782996f, -0.32942677f, 
    -0.12226694f, 0.09932505f, -0.06347297f, -0.33328128f, -0.01560614f, -0.16844557f, 0.00279219f, 0.12622930f, 
    -0.01878380f, -0.09802688f, -0.19850491f, 0.12176900f, -0.24847576f, -0.21676296f, -0.00757374f, -0.05757255f, 
    -0.13992523f, 0.05755034f, -0.29583707f, 0.00489503f, 0.05742738f, 0.08894996f, -0.01100974f, 0.02553859f, 
    0.09412717f, 0.13907194f, 0.03774661f, -0.36898503f, -0.11428556f, 0.04894450f, 0.06264281f, -0.22598320f, 
    -0.05892341f, -0.01797309f, -0.06442010f, 0.02940243f, 0.23031002f, -0.04677426f, -0.08431570f, 0.00297271f, 
    0.03555885f, 0.04331966f, 0.02404684f, -0.15774867f, -0.16662171f, 0.33372483f, 0.10620990f, 0.16166870f, 
    0.15596543f, -0.04134576f, 0.07834053f, 0.04026342f, -0.00457151f, 0.07456365f, -0.22634445f, -0.31269929f, 
    -0.06568783f, 0.06767141f, 0.09053063f, 0.08926161f, 0.07345963f, 0.05986364f, -0.00278281f, 0.13518119f, 
    0.03662668f, -0.07453165f, 0.07049089f, 0.05866294f, -0.02978423f, 0.14316292f, -0.05778906f, 0.02464275f, 
    -0.05786964f, 0.24704742f, -0.17941464f, -0.10464953f, 0.02484442f, -0.04628580f, 0.12924629f, 0.17505136f, 
    -0.11507517f, -0.01158808f, -0.02137723f, -0.10080392f, 0.04777235f, 0.03206497f, -0.00811232f, -0.11031010f, 
    0.10473360f, 0.05966147f, 0.27181807f, -0.01343663f, -0.16077195f, -0.11327002f, 0.14088076f, 0.10927600f, 
    -0.03464987f, 0.07153757f, -0.04265465f, -0.03385146f, -0.03815703f, 0.01928229f, -0.01508916f, 0.13406883f, 
    0.01057439f, 0.15271229f, 0.07038088f, -0.14720687f, 0.26290232f, 0.07596792f, -0.01467533f, -0.06457490f, 
    -0.09192629f, 0.09525735f, 0.14611997f, 0.03466437f, 0.07849438f, 0.05413776f, 0.20759545f, 0.04175614f, 
    -0.11770038f, -0.13742411f, -0.04166214f, -0.01689908f, 0.11206374f, 0.05258831f, 0.00394963f, 0.13553990f, 
    0.10245745f, -0.04772577f, 0.12365989f, -0.06411362f, -0.01362489f, -0.01081241f, 0.00792474f, -0.06663212f, 
    -0.40469947f, -0.28295404f, 0.16112085f, -0.03404417f, 0.09467210f, -0.14160286f, 0.05277483f, -0.08444188f, 
    -0.09883614f, 0.10193416f, 0.34864563f, -0.08750578f, -0.08310484f, 0.05383728f, 0.01237630f, -0.01369119f, 
    -0.15351917f, 0.12807420f, -0.12748913f, 0.06353585f, -0.01699960f, -0.33823371f, -0.11074277f, 0.01456253f, 
    0.11358591f, 0.15342820f, 0.05044898f, -0.04680809f, -0.06596825f, 0.16759555f, 0.10394769f, 0.14854668f, 
    -0.01071089f, -0.16619796f, -0.17842068f, 0.00449599f, -0.15521455f, 0.11362774f, 0.02890561f, -0.09580345f, 
    -0.03701667f, 0.07793888f, -0.05001635f, -0.13607047f, -0.04418459f, -0.06346268f, -0.01063747f, -0.00919729f, 
    -0.00835538f, -0.10745192f, 0.00622127f, -0.04528356f, -0.09599601f, -0.18528700f, -0.19923216f, -0.11042476f, 
    0.09735865f, -0.12075518f, -0.08805446f, 0.05127941f, -0.04827272f, -0.01586741f, -0.04420864f, -0.07071725f, 
    -0.27560258f, -0.01339563f, 0.05257444f, 0.16213094f, 0.03581084f, -0.00889079f, 0.09360463f, -0.01107231f, 
    -0.00793530f, 0.27533382f, -0.11121433f, -0.05458283f, 0.10350127f, -0.03634212f, 0.05047048f, 0.00938577f, 
    -0.03630210f, -0.04704860f, 0.30420527f, -0.15064906f, -0.00568972f, -0.00398251f, 0.01545569f, -0.12493153f, 
    0.18466653f, -0.12504792f, -0.03759378f, 0.07353182f, -0.10354441f, 0.09055660f, -0.11989047f, 0.02766930f, 
    0.06191992f, -0.00025716f, 0.06194601f, 0.07841191f, 0.20279129f, 0.03537354f, -0.04829934f, -0.02509120f, 
    0.01524798f, 0.08480171f, 0.11715369f, -0.20779009f, 0.09619939f, 0.04924540f, -0.03355482f, -0.08196024f, 
    0.04951597f, -0.05527347f, 0.01274506f, 0.08001390f, 0.32197919f, -0.02906654f, -0.11888769f, -0.22339186f, 
    -0.06990789f, -0.02280732f, -0.12155582f, 0.13440260f, 0.00230235f, 0.18987177f, -0.05397578f, 0.22747268f, 
    0.00634447f, -0.01036261f, -0.03416876f, -0.05203956f, 0.15656932f, 0.13876088f, 0.30000407f, 0.05752738f, 
    0.09013163f, -0.04436709f, 0.04514074f, -0.10262049f, -0.08166053f, 0.01526776f, -0.12602180f, -0.05203116f, 
    -0.11303648f, -0.08029569f, 0.11151272f, 0.04784388f, -0.06389629f, 0.09816274f, 0.01443464f, 0.14966191f, 
    -0.33689505f, -0.03076713f, 0.01678851f, -0.04254277f, -0.00963124f, 0.01562073f, -0.09710527f, 0.19042009f, 
    -0.14242354f, -0.25847822f, -0.35349816f, -0.02832703f, -0.01078915f, -0.18243569f, 0.04955034f, 0.05079911f, 
    -0.02670718f, 0.07654992f, 0.09110799f, -0.10534090f, 0.26342955f, 0.04756372f, 0.04434942f, -0.00208886f, 
    0.12635693f, -0.04230975f, 0.00944473f, -0.21226464f, -0.15472613f, -0.08865280f, -0.10556698f, -0.02790900f, 
    0.07860454f, 0.07587609f, -0.06265535f, 0.03617085f, -0.03705749f, 0.09533589f, -0.37071028f, 0.09745160f, 
    0.01011933f, 0.03161706f, 0.00609430f, 0.04568610f, -0.15297548f, 0.26633844f, 0.08049954f, -0.28465912f, 
    -0.05030357f, -0.03858205f, 0.09585013f, 0.11367215f, -0.00624744f, 0.09916549f, -0.25689504f, 0.25921926f, 
    -0.02803203f, 0.01555142f, -0.04681619f, 0.02049125f, 0.01606209f, -0.09319375f, 0.04768169f, 0.23505792f, 
    0.16478999f, -0.00670199f, 0.13060048f, 0.08851811f, 0.13443348f, 0.07335611f, -0.09142815f, 0.19509396f, 
    -0.17736880f, -0.27285081f, 0.07408644f, 0.10169151f, -0.08803304f, -0.01776334f, 0.15317333f, -0.11171379f, 
    0.09419764f, -0.29610860f, -0.01415125f, -0.11250624f, 0.03491677f, 0.02833255f, -0.16371119f, -0.09962806f, 
    0.03510607f, -0.08811767f, 0.06437916f, 0.13128625f, -0.28505895f, 0.09786271f, 0.21925148f, -0.01997769f, 
    -0.14800151f, 0.08589363f, 0.05036183f, 0.07609115f, -0.12950295f, 0.06668225f, -0.03494965f, 0.04163912f, 
    -0.07708893f, -0.15707161f, -0.12286893f, -0.02835188f, -0.13105695f, 0.03030323f, -0.23820224f, 0.04809557f, 
    -0.03270122f, -0.05518306f, -0.09081630f, -0.11518608f, 0.26316938f, -0.17375576f, -0.15256925f, -0.30246785f, 
    -0.05888183f, 0.05031865f, 0.06140440f, 0.20225604f, -0.06329559f, -0.18062791f, -0.25692853f, -0.07592401f, 
    -0.15126346f, 0.02246805f, 0.05591323f, -0.04397930f, 0.24447781f, 0.16706441f, 0.10650007f, -0.09930353f, 
    0.02271792f, 0.12991735f, -0.08308968f, 0.21177736f, -0.18081881f, 0.06931637f, 0.03096431f, 0.02044134f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02618858f, -0.03191815f, 0.27810007f, 0.02551935f, -0.04096618f, 0.00499544f, 0.04717796f, 0.09741065f, 
    0.10088112f, -0.05270586f, -0.07188858f, 0.04393274f, 0.02698357f, 0.10500056f, -0.11177531f, 0.05730224f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20956461f, -0.26807675f, -0.07301399f, -0.13487069f, 0.13864183f, -0.10724685f, -0.00547236f, -0.08291642f, 
    0.12897679f, -0.21256414f, 0.08995253f, 0.16055883f, -0.24028748f, 0.05139636f, -0.14389737f, -0.25845698f, 
    0.29296452f, -0.21419717f, -0.10210568f, 0.17101090f, -0.14692743f, 0.01602375f, 0.10552241f, 0.13767566f, 
    0.25689930f, -0.30573666f, 0.14693373f, -0.00891781f, -0.32701409f, 0.25298023f, -0.08542651f, -0.04329635f, 
    0.35080478f, -0.08735859f, 0.11192630f, 0.07475429f, -0.38024190f, -0.27627411f, -0.18307531f, 0.20359294f, 
    -0.44137794f, 0.43352142f, 0.29072556f, -0.11373935f, -0.08318742f, 0.04540773f, 0.26757246f, -0.36291844f, 
    0.41300523f, 0.16777809f, -0.28864169f, 0.34624106f, -0.03067030f, -0.18844050f, -0.01968567f, 0.25024328f, 
    0.36742923f, 0.24714546f, 0.05330382f, 0.25547132f, -0.22220489f, -0.10337216f, 0.37472796f, -0.40508321f, 
    0.14298829f, 0.22812605f, -0.42779404f, -0.03254448f, 0.00371691f, 0.39163461f, 0.12375808f, -0.42608681f, 
    0.12374510f, -0.06491989f, 0.04459100f, 0.00691841f, -0.31713751f, -0.07051153f, 0.38434231f, -0.75481594f, 
    0.11558089f, 0.27633077f, 0.24015082f, -0.32695201f, 0.06473839f, 0.15001433f, -0.12908015f, -0.10320097f, 
    -0.18571702f, -0.10008737f, 0.02309119f, -0.54841602f, -0.05896859f, 0.06466711f, -0.04171215f, 0.38460675f, 
    0.25691479f, 0.28788534f, -0.16108909f, -0.16304861f, -0.00345617f, 0.16027530f, -0.12178050f, 0.33293384f, 
    0.13853262f, 0.50450426f, -0.26706690f, 0.02129467f, 0.35282633f, -0.24289095f, -0.04995701f, 0.09523794f, 
    0.23999918f, 0.30758053f, -0.18852530f, -0.24412324f, -0.31342265f, 0.32666847f, -0.22731879f, 0.11872034f, 
    0.12325977f, 0.03350331f, 0.04262343f, 0.15422131f, 0.45025945f, -0.26799428f, -0.14567152f, 0.18235774f, 
    0.02286567f, 0.09173803f, -0.05839731f, 0.10540935f, 0.02458833f, -0.03282707f, 0.13255334f, 0.00368365f, 
    -0.30380356f, -0.22488040f, 0.07224990f, -0.23900142f, 0.08124615f, -0.00099214f, 0.35102087f, 0.18899286f, 
    0.15677834f, 0.19983038f, -0.07142416f, -0.07666539f, 0.19811001f, -0.45428923f, -0.11437898f, 0.27805629f, 
    -0.01035995f, -0.34123501f, 0.15345299f, -0.10749664f, 0.04034005f, 0.18497871f, -0.33657596f, 0.42072868f, 
    -0.42031130f, 0.32424957f, 0.12502234f, 0.25174972f, 0.09965320f, -0.11084227f, -0.05682652f, -0.27790505f, 
    -0.05116365f, -0.39775902f, 0.13881144f, -0.05613004f, 0.27146208f, -0.06091706f, 0.11404923f, 0.18865642f, 
    0.08580136f, -0.19136508f, -0.10220478f, -0.15603001f, 0.06288131f, 0.22648615f, -0.19033422f, -0.44007155f, 
    0.02513007f, 0.33964008f, -0.14406507f, 0.49101985f, 0.28143010f, 0.21361406f, 0.18997076f, 0.48321775f, 
    -0.35742271f, 0.18276671f, 0.02849050f, 0.01793678f, -0.24621880f, -0.18169993f, 0.15262324f, 0.23783632f, 
    0.17554931f, -0.08936250f, -0.30587754f, -0.17782795f, -0.11605535f, 0.38770431f, 0.04834284f, 0.10915444f, 
    0.09510451f, -0.02204948f, 0.21922447f, 0.13666090f, -0.31351545f, 0.49434471f, 0.16970436f, -0.01641598f, 
    -0.26835117f, 0.20086190f, -0.02032243f, 0.01057911f, 0.07428637f, 0.32363293f, -0.00060607f, 0.02353552f, 
    0.27227941f, 0.34980789f, 0.11498749f, -0.33378804f, -0.15287513f, -0.15358107f, 0.01185242f, 0.16623215f, 
    0.20447637f, -0.06100773f, -0.27979335f, 0.18446177f, 0.44286805f, -0.11811617f, -0.28421760f, 0.27915019f, 
    0.20089139f, -0.19365954f, -0.06259438f, 0.09363832f, 0.01264472f, -0.38464302f, 0.22654857f, 0.46425760f, 
    -0.13519941f, -0.16011736f, 0.05913505f, -0.11752485f, 0.27541530f, -0.06894010f, 0.16227765f, 0.09034941f, 
    0.36509392f, -0.06140811f, -0.19904901f, 0.13756901f, -0.01480130f, -0.33299103f, -0.16431394f, 0.23470482f, 
    0.21255110f, -0.26171896f, 0.26030040f, 0.13442045f, 0.15727527f, 0.24868277f, -0.39454803f, 0.36828503f, 
    0.17349632f, -0.27724338f, 0.14284706f, 0.12985717f, 0.13341251f, -0.27696264f, -0.08209381f, 0.34393904f, 
    0.37609604f, 0.01324087f, 0.34456009f, 0.08764984f, -0.21310724f, -0.30972451f, -0.13532853f, -0.42890754f, 
    -0.04041237f, -0.46078220f, -0.26855704f, -0.06834950f, 0.21380344f, -0.01293239f, 0.19041550f, 0.17041388f, 
    0.26272434f, 0.24860303f, -0.24326800f, 0.22266720f, 0.29710570f, 0.11251386f, 0.05761590f, 0.71776897f, 
    0.30684453f, -0.06286509f, -0.35254696f, 0.15300204f, 0.15700448f, -0.02523881f, -0.24933815f, 0.31322971f, 
    -0.02552658f, -0.23790094f, 0.23605911f, 0.31443557f, -0.19595958f, -0.16851270f, 0.06278025f, 0.04957199f, 
    0.09258325f, 0.08518034f, 0.22804227f, 0.33550462f, -0.29838932f, -0.13461445f, -0.11559661f, -0.04401040f, 
    -0.36489183f, 0.04820275f, 0.13931981f, 0.10716404f, -0.23580289f, 0.06413607f, 0.39938718f, -0.07741030f, 
    0.01880951f, -0.22014433f, 0.13030355f, 0.11406726f, 0.03397145f, 0.29892579f, 0.22817990f, -0.00801928f, 
    0.01130623f, 0.11844623f, -0.37644857f, 0.35074788f, 0.03554667f, 0.10304558f, -0.25711885f, 0.16823845f, 
    0.30583024f, -0.26713359f, 0.08161727f, 0.30051330f, -0.06503040f, -0.27428889f, 0.06845088f, 0.01643335f, 
    0.37008190f, 0.26310712f, -0.29109201f, 0.48629606f, -0.01879058f, 0.17956840f, -0.19252382f, -0.08472233f, 
    -0.38729396f, -0.00202893f, 0.09143310f, 0.12726867f, 0.20407455f, 0.32761773f, -0.14791866f, -0.02025907f, 
    -0.13033827f, 0.21495260f, -0.05701585f, 0.25412259f, 0.10972045f, 0.26525998f, -0.08196345f, 0.39960116f, 
    0.04379541f, -0.12339471f, 0.09523834f, 0.07949363f, 0.13749474f, 0.31644568f, -0.03974757f, 0.12077695f, 
    -0.00790176f, -0.15418337f, -0.27537885f, 0.13230926f, 0.35920003f, -0.04818687f, 0.04322561f, 0.29414216f, 
    -0.18112047f, 0.37163901f, -0.15601671f, 0.03431933f, 0.06463300f, 0.17094497f, 0.25683054f, 0.04599136f, 
    -0.32642061f, -0.22176342f, 0.36776543f, -0.15852460f, -0.15568323f, 0.22767894f, 0.38924104f, -0.12178393f, 
    -0.07201878f, 0.18002377f, 0.21486075f, 0.11960029f, 0.22757132f, 0.01947280f, -0.23274918f, 0.02151245f, 
    -0.25224459f, -0.51515514f, 0.14543572f, 0.20623988f, -0.20963547f, -0.16181353f, 0.02276463f, 0.18481232f, 
    0.00922372f, 0.20277466f, -0.09354626f, 0.15630543f, 0.34679648f, 0.16227680f, -0.11604919f, 0.32111713f, 
    0.08148033f, -0.22595644f, 0.32400358f, -0.14070176f, 0.12630439f, -0.37318149f, 0.04426428f, -0.29040152f, 
    0.33877170f, 0.15418854f, 0.02030818f, 0.19854513f, -0.44173521f, -0.13884237f, 0.06916294f, 0.37027135f, 
    -0.07702103f, 0.11752526f, -0.04928190f, 0.04539493f, 0.00308753f, -0.16163380f, 0.15118735f, -0.68628454f, 
    0.23778482f, 0.00212319f, 0.34550434f, -0.18788025f, 0.04314154f, -0.16031158f, -0.01789987f, 0.05372802f, 
    0.11876044f, -0.20740654f, -0.42740643f, 0.31535551f, 0.33721730f, 0.19284841f, -0.18468633f, -0.17788413f, 
    0.29000968f, 0.16557705f, 0.04754487f, -0.18435784f, -0.15805759f, -0.29447186f, 0.13278449f, 0.20933264f, 
    0.07764366f, 0.20113738f, 0.31234914f, -0.23163497f, -0.29863197f, 0.19255592f, 0.15311658f, -0.05335443f, 
    0.06785227f, -0.01692178f, 0.37462127f, 0.25126383f, -0.23519604f, -0.23818880f, -0.23761296f, 0.25472260f, 
    0.23153515f, 0.02086840f, -0.24013166f, 0.42543972f, -0.12239195f, 0.25415620f, -0.14670216f, -0.31786454f, 
    -0.27506891f, -0.01304376f, -0.27773952f, -0.08564337f, -0.21820143f, -0.10698204f, -0.23018152f, 0.08281320f, 
    -0.16112605f, 0.04463660f, -0.13904817f, -0.18163344f, -0.12954736f, 0.04856160f, 0.02773785f, 0.19608188f, 
    0.09836768f, 0.15074249f, 0.27704167f, 0.07301515f, 0.26214087f, 0.06127756f, -0.11910080f, 0.00487471f, 
    0.07942338f, -0.20025815f, -0.13025878f, -0.28720894f, 0.02514930f, -0.23145220f, -0.35361817f, 0.16407499f, 
    0.13819778f, -0.28002131f, 0.04109335f, 0.04759592f, -0.40152189f, -0.29138157f, 0.08426139f, 0.21181503f, 
    -0.15495329f, 0.44588491f, -0.25715941f, 0.35111988f, -0.42916012f, 0.13650721f, 0.34461874f, 0.12254310f, 
    -0.14190488f, -0.35668522f, 0.23612747f, 0.08359773f, 0.41697255f, -0.14387845f, -0.07015524f, 0.37551028f, 
    0.20152403f, 0.11299196f, 0.09957416f, -0.31749934f, -0.14498191f, -0.28892899f, 0.25209090f, 0.05764320f, 
    -0.00071274f, 0.19231983f, 0.21776161f, -0.19972540f, 0.38358715f, 0.27380437f, -0.06082618f, -0.13738583f, 
    -0.27405182f, 0.31514347f, -0.23115562f, 0.13296255f, 0.01837950f, 0.21415846f, -0.41011119f, 0.01379298f, 
    -0.07197394f, -0.04457748f, 0.34093615f, -0.28629693f, 0.36468381f, -0.25056940f, -0.23631462f, 0.11536566f, 
    -0.31171772f, -0.03718810f, 0.34658465f, -0.16278523f, 0.05798864f, 0.30419600f, -0.35432053f, -0.28115147f, 
    0.09097119f, -0.02091573f, 0.39393190f, -0.15195477f, 0.11119882f, -0.09012158f, 0.11192974f, 0.42367497f, 
    0.06025524f, 0.21345840f, -0.16462974f, 0.04099886f, 0.43051264f, -0.24515493f, -0.35003427f, 0.22190352f, 
    0.12576896f, -0.51565278f, 0.38755929f, -0.24853383f, -0.10836543f, -0.28158322f, 0.14202237f, 0.16257325f, 
    0.37882540f, 0.53346664f, 0.12248009f, 0.26995459f, -0.04488280f, -0.08590946f, -0.05217816f, -0.32260999f, 
    0.28038058f, -0.24444202f, 0.28644484f, 0.05800945f, -0.17139147f, 0.10503574f, -0.16583231f, -0.10210329f, 
    -0.18377483f, -0.17120090f, -0.50511050f, 0.44533637f, 0.35887560f, 0.16979614f, -0.01659103f, 0.18918848f, 
    0.10816171f, 0.25166613f, 0.07034124f, -0.10933623f, -0.20367517f, 0.00669760f, 0.19486892f, -0.30308020f, 
    -0.33842149f, 0.59626621f, 0.01324288f, -0.13041808f, -0.42957577f, -0.03316191f, 0.42652771f, 0.07655563f, 
    0.22404680f, -0.23825425f, -0.28669694f, 0.24965888f, -0.49674350f, 0.24987082f, 0.02112556f, 0.27303943f, 
    0.03427362f, 0.50119734f, 0.09764607f, 0.00972763f, -0.10408821f, 0.17992121f, -0.31021246f, 0.15363680f, 
    0.41668999f, 0.20471635f, -0.18911551f, 0.09713497f, -0.33978835f, -0.01537877f, 0.03076324f, 0.12599137f, 
    -0.29070908f, -0.02475906f, 0.15016539f, -0.23643734f, 0.08783054f, 0.15475138f, 0.01902097f, 0.17581889f, 
    0.04032741f, 0.01054810f, 0.10540227f, 0.42669657f, -0.10548830f, -0.42619696f, -0.03231739f, -0.24345736f, 
    0.00338005f, 0.32541391f, 0.24237478f, 0.15328556f, -0.25129235f, 0.04864239f, -0.39192295f, -0.03055198f, 
    -0.11199549f, 0.38158101f, 0.16407730f, 0.00431273f, 0.43068790f, -0.21286769f, 0.00533766f, -0.04314522f, 
    0.22006813f, -0.32021993f, 0.06738769f, -0.30569550f, -0.13000894f, 0.04379047f, -0.03236840f, -0.08220198f, 
    0.21489657f, 0.05837940f, -0.38742051f, 0.20661807f, 0.14595491f, -0.19338365f, -0.00320461f, 0.22200942f, 
    -0.05785841f, -0.00504239f, -0.09564979f, -0.05352852f, 0.24527134f, -0.11423074f, -0.36601880f, 0.93426371f, 
    0.43538794f, 0.06783329f, -0.15721855f, 0.20257129f, -0.17456540f, -0.38463271f, -0.06719158f, 0.41120750f, 
    -0.09290230f, 0.03849102f, 0.15065008f, -0.14831173f, 0.17141862f, -0.06842280f, -0.06633733f, 0.26716188f, 
    -0.03139749f, 0.11729255f, -0.23461296f, 0.19378284f, -0.42709163f, -0.06134070f, 0.16072543f, 0.40842056f, 
    -0.51249278f, 0.20277311f, 0.31453490f, -0.08116722f, 0.24777682f, 0.37018141f, -0.08720880f, -0.17951223f, 
    0.26298493f, 0.08031446f, 0.18362717f, -0.15548310f, -0.18164757f, 0.02351386f, -0.24368617f, 0.09752489f, 
    0.19261961f, -0.19172499f, -0.51451308f, 0.48901984f, -0.26253772f, -0.11937208f, 0.44043589f, 0.26976690f, 
    0.24434896f, 0.29355282f, -0.24318397f, 0.11766706f, -0.21427618f, 0.38447791f, 0.19383343f, -0.00507556f, 
    0.05115266f, -0.02266769f, -0.08785244f, -0.04701661f, -0.26916417f, 0.19331038f, 0.30449611f, -0.43619695f, 
    0.06833086f, 0.31384349f, 0.21838969f, -0.19562314f, 0.22900459f, -0.10846259f, 0.08381101f, -0.33382323f, 
    0.04905955f, -0.02626486f, -0.14843322f, 0.50866538f, -0.20821789f, 0.29212382f, -0.34668073f, 0.02069861f, 
    -0.05256671f, -0.19619133f, -0.05596406f, -0.28324705f, -0.19186690f, -0.13256051f, -0.08236080f, -0.21592684f, 
    0.01344203f, -0.01618013f, -0.05588090f, 0.08186685f, 0.09492276f, 0.01639350f, 0.10123899f, -0.05334187f, 
    0.39199331f, 0.00561887f, -0.10441841f, 0.23939987f, -0.17759354f, 0.36341304f, 0.03244745f, -0.05512914f, 
    0.05844113f, -0.27385899f, 0.29251197f, 0.15455815f, -0.27045050f, -0.24249876f, -0.03930225f, -0.64742738f, 
    -0.21046996f, -0.11305963f, -0.00903707f, -0.50096697f, -0.36059338f, -0.07305960f, 0.24684069f, 0.03599812f, 
    0.36157712f, -0.10298871f, 0.05798760f, -0.53183377f, 0.12180416f, 0.37603185f, 0.22965351f, 0.41388318f, 
    0.27934971f, 0.50104141f, 0.19148758f, -0.40463033f, -0.12895599f, -0.35720339f, 0.08906364f, 0.20479532f, 
    -0.21196941f, -0.28166643f, 0.29614529f, 0.11085402f, 0.14196467f, 0.39514688f, 0.08744605f, -0.21885513f, 
    -0.06185551f, 0.23612295f, -0.43351600f, 0.34602481f, 0.24475670f, 0.04992520f, -0.07226925f, -0.01500277f, 
    0.40310615f, -0.25653771f, 0.22109233f, -0.19412082f, -0.20294835f, 0.27375630f, 0.01501340f, -0.30175826f, 
    0.28721085f, -0.05825997f, -0.35329700f, -0.11246193f, -0.39629272f, 0.11474700f, 0.15590784f, -0.02316860f, 
    0.27434835f, -0.27807090f, 0.17828432f, 0.52929223f, -0.61333632f, 0.09483843f, 0.01983884f, 0.55274838f, 
    0.16295710f, 0.10348874f, -0.15279858f, -0.26269102f, -0.13618469f, 0.23345110f, -0.15446061f, 0.11536656f, 
    0.07796423f, -0.05304374f, -0.22957176f, 0.19450851f, -0.33964923f, 0.30290565f, 0.01579070f, 0.26777941f, 
    -0.17172410f, 0.55422676f, 0.00981683f, -0.29263538f, 0.25609043f, -0.19054930f, 0.13097160f, -0.09549863f, 
    0.03183651f, 0.26305088f, 0.41203791f, -0.25687480f, -0.03852915f, 0.44623822f, -0.04341271f, 0.24904366f, 
    0.07850932f, 0.16783075f, 0.17045632f, 0.29890433f, -0.20416568f, -0.18989579f, -0.13119771f, -0.07762064f, 
    -0.49673945f, 0.40843767f, 0.13593781f, 0.10194380f, -0.44541773f, -0.15764226f, 0.08851098f, 0.46282068f, 
    0.10112479f, -0.26764989f, -0.01813130f, -0.38805425f, -0.27039254f, 0.39759356f, -0.11878544f, 0.26737377f, 
    0.32961559f, -0.23783122f, -0.10835101f, -0.57369250f, 0.26406047f, 0.04855575f, 0.21741676f, -0.10993586f, 
    -0.12178785f, -0.07946397f, 0.01597847f, 0.24718340f, 0.19159567f, -0.01975033f, 0.20240170f, 0.00580145f, 
    -0.27587172f, 0.23585977f, -0.20670933f, 0.09860624f, -0.10075142f, 0.39951390f, 0.21803424f, 0.04904830f, 
    0.06749518f, 0.21841308f, 0.04788744f, 0.08761612f, -0.31186900f, 0.03155538f, -0.20307736f, -0.20272277f, 
    -0.46765697f, 0.12133754f, 0.03725426f, -0.12244110f, -0.16363038f, 0.45310864f, 0.09632350f, 0.49713019f, 
    -0.11483808f, 0.34848234f, 0.05305896f, 0.06386194f, 0.45996091f, -0.34137926f, 0.03487210f, -0.09993576f, 
    0.31251451f, -0.25798017f, 0.11090482f, 0.25181535f, -0.05288333f, 0.00199888f, -0.08365528f, 0.34557906f, 
    0.12021498f, 0.37259996f, 0.02938852f, -0.23032752f, 0.08506093f, 0.41577280f, 0.23429443f, 0.02892856f, 
    -0.23708877f, 0.19495754f, 0.00048547f, -0.07056674f, 0.30808088f, -0.31509250f, 0.12056293f, -0.10325760f, 
    -0.09220452f, 0.04075349f, 0.10700405f, 0.30605817f, -0.00993309f, -0.17591269f, 0.19043536f, -0.40596330f, 
    0.09134395f, -0.35077775f, -0.22442542f, -0.09649610f, 0.11467172f, 0.48402575f, 0.10737704f, -0.05225625f, 
    -0.19225790f, -0.00690103f, -0.18028760f, -0.10881142f, 0.10211062f, -0.02242178f, -0.20159659f, -0.09386890f, 
    0.00506251f, -0.09101787f, -0.22226444f, -0.22794993f, 0.06269074f, 0.15503982f, -0.17776644f, -0.18369837f, 
    0.04667416f, -0.34662753f, 0.12181084f, 0.33013609f, 0.39500836f, 0.02013221f, 0.01198448f, 0.25099307f, 
    -0.04758749f, -0.46733570f, 0.31108859f, -0.44186759f, -0.14339165f, 0.08621464f, 0.21381888f, -0.35667247f, 
    0.12131143f, 0.39451826f, 0.25213557f, 0.00153499f, -0.04787833f, 0.38143513f, 0.02857812f, 0.14361598f, 
    -0.38196379f, -0.04169022f, -0.07877529f, 0.31913599f, 0.09861244f, 0.04416376f, 0.20622164f, -0.10706318f, 
    0.45655796f, -0.28288645f, -0.13633156f, -0.04188738f, 0.41840637f, 0.15905879f, -0.18389910f, 0.11418775f, 
    -0.06572060f, 0.16172954f, 0.36240202f, -0.03034304f, -0.30989370f, -0.45368186f, -0.26021439f, -0.74656773f, 
    -0.15190575f, 0.42770961f, 0.02910133f, -0.00961121f, 0.33548033f, -0.23217803f, -0.08163080f, -0.27294588f, 
    0.24607567f, 0.25822324f, 0.02789056f, -0.04612846f, -0.03114260f, 0.49894959f, 0.06538367f, -0.14718810f, 
    0.05629160f, 0.27743188f, -0.29402515f, -0.14018527f, -0.11671285f, 0.23024029f, 0.11181216f, -0.39468905f, 
    0.15922558f, -0.02141709f, 0.23841870f, 0.22808784f, -0.28896460f, -0.23117831f, 0.49402776f, -0.11072937f, 
    0.34546521f, 0.10942938f, -0.22500660f, 0.19470899f, 0.43102336f, 0.14774631f, 0.15661806f, -0.28513137f, 
    -0.65019947f, -0.17665644f, 0.32197377f, -0.15998727f, -0.34096512f, -0.10075861f, 0.01655515f, -0.21117309f, 
    0.00817479f, -0.16671878f, -0.19972768f, 0.18881719f, -0.00908105f, 0.58540171f, -0.20508292f, 0.28760433f, 
    -0.07232553f, -0.20880936f, 0.16887030f, -0.60142833f, 0.03724917f, -0.32198328f, -0.19435471f, 0.24203281f, 
    0.40239263f, -0.19200477f, 0.04886248f, -0.11289899f, -0.17994143f, 0.05531289f, -0.17200518f, 0.37669641f, 
    -0.24938445f, -0.34611374f, -0.02247100f, -0.05616026f, 0.30349568f, 0.09543615f, -0.31748059f, -0.04492109f, 
    -0.33601135f, -0.21890913f, 0.32097647f, 0.15629549f, 0.26323083f, -0.24997036f, 0.18817721f, 0.21111773f, 
    0.07810676f, 0.26349121f, 0.26643577f, -0.34832466f, 0.27914131f, 0.34037438f, -0.36161384f, 0.40879110f, 
    0.04891651f, 0.09569883f, 0.22745003f, -0.18958616f, 0.07473626f, -0.10499267f, 0.03490993f, 0.02249160f, 
    0.10392510f, -0.08041769f, -0.19260149f, 0.21538770f, 0.40662026f, -0.12559637f, -0.21391250f, 0.39989731f, 
    -0.00969422f, -0.30598441f, 0.31808600f, 0.27325410f, -0.06895938f, -0.32457519f, 0.01839818f, -0.00121804f, 
    0.29375657f, 0.13638969f, 0.13469411f, -0.36420441f, -0.17731273f, 0.22141582f, -0.29259774f, 0.18943404f, 
    0.05655280f, -0.07299713f, 0.41241270f, 0.21390487f, 0.01196306f, 0.18055414f, -0.17033029f, -0.07702229f, 
    0.02785310f, 0.06948327f, 0.17814733f, -0.11502960f, 0.02072331f, -0.39115548f, -0.16341145f, -0.60151011f, 
    0.10611971f, -0.21584924f, 0.05505869f, 0.10418653f, -0.24131221f, -0.50486428f, 0.09534608f, -0.44104865f, 
    0.05904588f, -0.09927484f, 0.03681016f, -0.25454408f, 0.22381909f, 0.30969459f, -0.05768742f, 0.38639748f, 
    -0.08701017f, 0.23449300f, -0.06334062f, 0.15444294f, 0.06032373f, 0.21539265f, -0.23638858f, -0.13443296f, 
    -0.13273181f, -0.28318223f, -0.08110360f, 0.30074781f, 0.48616561f, -0.10313521f, -0.22745125f, 0.18215013f, 
    0.23440899f, -0.15577473f, -0.20381886f, 0.24539845f, -0.26199836f, -0.05997390f, -0.14583831f, 0.14281464f, 
    -0.14810760f, 0.35401770f, 0.06614254f, 0.33667961f, 0.22085406f, 0.25922540f, -0.17491150f, 0.33781832f, 
    -0.16078208f, 0.13842963f, -0.06946804f, 0.29554123f, 0.10784070f, 0.01039473f, -0.21777499f, 0.11401661f, 
    -0.34610799f, -0.05142605f, 0.17509618f, -0.05596441f, -0.29644391f, 0.28979343f, 0.32671574f, -0.23458551f, 
    -0.06616841f, -0.16885833f, 0.14463228f, 0.31484145f, -0.05320603f, 0.31517521f, -0.08557419f, -0.27775854f, 
    -0.58874398f, 0.08416522f, 0.06501741f, 0.00837744f, 0.10853499f, 0.33096474f, 0.05237682f, -0.40784287f, 
    0.37918940f, -0.18742430f, -0.33166599f, 0.28311583f, -0.29600582f, -0.25047582f, -0.16985691f, -0.22969107f, 
    0.08182808f, -0.14897272f, 0.26224747f, -0.00557939f, 0.26070520f, -0.03678898f, 0.30811521f, -0.18417074f, 
    -0.02707523f, 0.29661378f, 0.25837323f, -0.04868300f, -0.12664478f, 0.37630555f, 0.08402009f, 0.18238918f, 
    -0.00999876f, 0.23137252f, 0.18008529f, -0.02481324f, 0.01677015f, -0.36317796f, -0.35325250f, -0.05879496f, 
    0.23122339f, -0.25161320f, -0.19648948f, 0.07137254f, -0.24571098f, -0.09890174f, 0.12695843f, 0.21931095f, 
    0.13972776f, 0.37151739f, -0.12135545f, 0.37134263f, -0.54210061f, 0.08575459f, 0.34165627f, -0.09008874f, 
    -0.13083269f, -0.41076297f, 0.17832802f, 0.12152011f, -0.19311485f, -0.24856974f, -0.15738976f, 0.07827717f, 
    0.42322436f, -0.14174739f, 0.29943073f, 0.09574279f, -0.25906369f, -0.27591291f, 0.18747824f, 0.14669167f, 
    -0.26791611f, -0.07427145f, 0.31164068f, -0.46644312f, -0.13118419f, -0.18872972f, 0.17696071f, -0.16269645f, 
    0.32475862f, -0.11084794f, -0.24575819f, -0.65554106f, 0.06612708f, 0.29887575f, 0.24604407f, 0.38219497f, 
    0.29233465f, -0.14056738f, 0.18902910f, -0.22162922f, -0.13910815f, -0.22548613f, -0.02537762f, 0.44514665f, 
    -0.18283632f, 0.40232757f, 0.19108212f, 0.18019661f, -0.15593457f, -0.09645579f, 0.06687321f, -0.22528137f, 
    -0.03605635f, -0.18567364f, -0.06022540f, -0.23508430f, 0.16921766f, 0.47766802f, 0.16130978f, 0.23853619f, 
    0.01769364f, 0.19751054f, 0.08160178f, -0.04251446f, 0.16612592f, -0.07437338f, -0.60924435f, 0.21333632f, 
    -0.04652866f, -0.39884266f, 0.26090047f, -0.01054938f, -0.18191060f, -0.06852943f, -0.05133410f, -0.34340420f, 
    0.20537797f, -0.44313332f, 0.32779288f, 0.24410409f, 0.05022064f, 0.08341816f, 0.16322702f, 0.09888847f, 
    -0.12230591f, 0.11784939f, 0.20020543f, -0.27037042f, 0.29616532f, 0.37963611f, -0.16981618f, -0.19213602f, 
    -0.28338230f, 0.30090892f, 0.07048152f, 0.11360003f, 0.16530335f, -0.06435018f, -0.41122204f, 0.20694861f, 
    -0.10140385f, -0.26664987f, -0.14231625f, 0.20707996f, 0.09988743f, -0.40893748f, -0.20155707f, 0.18918578f, 
    0.19611780f, -0.04476163f, -0.05576994f, 0.09084252f, 0.38194650f, 0.15231577f, -0.27171704f, 0.77334815f, 
    0.13887416f, 0.21748404f, 0.21886078f, -0.25777528f, -0.04727219f, -0.15810615f, 0.00256214f, -0.39868546f, 
    0.17116466f, -0.27196983f, -0.06381480f, 0.29961091f, 0.18273942f, 0.26933706f, -0.31272736f, 0.00823675f, 
    0.30487329f, 0.23634990f, -0.12428403f, 0.23995109f, -0.23965611f, -0.10642955f, 0.06429404f, -0.25877753f, 
    0.00433229f, -0.03880951f, -0.16130833f, 0.35934412f, -0.14632341f, 0.38000306f, 0.31539381f, 0.19292857f, 
    0.20169687f, 0.07521590f, 0.21436934f, -0.28193471f, 0.05967082f, -0.52573758f, -0.17390814f, 0.18548611f, 
    0.12922598f, -0.00535317f, 0.26809677f, 0.03285501f, 0.24522440f, -0.01739873f, -0.12601960f, 0.33489177f, 
    0.08021826f, -0.08710068f, -0.19089618f, -0.00754693f, -0.00713250f, -0.14393166f, -0.13179719f, -0.08054587f, 
    -0.22227487f, -0.24469993f, 0.00785425f, -0.01081073f, 0.10267979f, -0.17375100f, -0.15404108f, -0.09141159f, 
    0.01564617f, 0.44540808f, 0.03872520f, -0.08072546f, 0.06222695f, 0.49446180f, 0.22606920f, 0.21221767f, 
    -0.33371133f, -0.16374029f, -0.00602604f, -0.05605178f, 0.13918053f, 0.15819967f, -0.21708702f, 0.17113100f, 
    -0.28478879f, -0.21427128f, 0.02152150f, 0.35268837f, 0.16519922f, 0.26408866f, -0.17569837f, -0.13444841f, 
    0.41419008f, 0.23662440f, -0.00586218f, -0.06998197f, 0.00808600f, 0.15849221f, 0.11486884f, -0.36504012f, 
    -0.06501022f, -0.33364618f, 0.00848994f, -0.11160984f, -0.32608429f, 0.09933330f, 0.04536054f, -0.19579667f, 
    0.07812782f, -0.18415838f, 0.09938469f, 0.19546802f, -0.00951180f, -0.21714868f, -0.18805380f, -0.19425133f, 
    -0.25458932f, 0.28372112f, -0.16065013f, 0.08683566f, -0.07844407f, 0.10484324f, -0.02267662f, -0.29343206f, 
    0.21635817f, 0.01662183f, -0.44074833f, 0.50001574f, 0.33992189f, -0.02366496f, 0.42774627f, -0.06129095f, 
    0.36154416f, -0.01368522f, -0.12952153f, -0.15351161f, 0.02803761f, 0.00534493f, -0.01354390f, -0.25254136f, 
    0.26381955f, 0.15068395f, 0.19215463f, 0.19658017f, -0.42871195f, -0.12542126f, 0.35024413f, -0.54947233f, 
    0.35979721f, -0.15422417f, -0.02432071f, 0.32563531f, 0.04558949f, -0.34688020f, -0.24280182f, 0.31341138f, 
    -0.30818531f, -0.16990045f, 0.34066013f, 0.04278364f, 0.03751855f, 0.14639314f, 0.36686158f, 0.24619095f, 
    -0.04362047f, -0.21081205f, -0.01491772f, 0.15450980f, -0.17752935f, 0.57335526f, 0.04545627f, 0.24278523f, 
    0.13289037f, 0.09060868f, -0.14220197f, 0.32524344f, -0.18359844f, -0.00262139f, -0.44865558f, 0.42036700f, 
    0.15594034f, 0.15355471f, 0.09356972f, 0.04772421f, 0.37728983f, -0.05978958f, -0.03899041f, 0.02235892f, 
    0.29406992f, -0.15139043f, -0.07342971f, 0.10445011f, 0.03282055f, -0.24891260f, -0.19502012f, -0.08134894f, 
    -0.60036695f, -0.43868598f, 0.14537077f, -0.41038805f, -0.30632445f, 0.20247026f, -0.24837914f, 0.14334206f, 
    -0.03195729f, -0.24596077f, 0.01688948f, -0.19363379f, -0.35748070f, 0.16798064f, -0.11726768f, 0.36551663f, 
    0.02356753f, -0.11459163f, 0.36525232f, -0.08703623f, 0.41913933f, -0.13041921f, 0.11316237f, 0.16334151f, 
    -0.47312716f, -0.31798056f, 0.00007462f, -0.27384937f, 0.05604463f, 0.20196114f, -0.07382689f, -0.34567362f, 
    0.16395341f, 0.24819465f, 0.30074674f, -0.11945446f, 0.18028568f, -0.02028532f, -0.21708429f, -0.10250995f, 
    -0.41772306f, -0.29492170f, 0.01339742f, 0.24593215f, 0.19265443f, 0.16484833f, 0.00300403f, 0.03686891f, 
    0.11024781f, -0.21169379f, 0.19491246f, 0.25862357f, 0.09605780f, -0.25268030f, -0.13924633f, 0.12425449f, 
    -0.40592140f, -0.15431245f, 0.02257036f, -0.18171169f, -0.25832644f, 0.33147407f, 0.22350447f, -0.04683783f, 
    0.02532567f, 0.38573176f, 0.39983532f, -0.01829000f, 0.30837008f, -0.25981182f, -0.22069190f, 0.11416383f, 
    0.07470820f, -0.17709036f, 0.11815735f, 0.38028696f, -0.23628502f, -0.26272970f, 0.13131174f, -0.12812373f, 
    0.18599480f, 0.00155943f, 0.06586347f, -0.02311864f, 0.20581250f, -0.23749714f, 0.02382691f, -0.53259557f, 
    0.31266108f, -0.57342404f, -0.00726771f, 0.35796595f, 0.25897112f, 0.05619775f, 0.14856298f, -0.30093861f, 
    -0.17205572f, 0.01155469f, -0.25729051f, -0.06520326f, 0.14701396f, -0.24801497f, -0.13247535f, -0.20884378f, 
    0.09945349f, -0.07575512f, -0.09508638f, -0.22365871f, -0.07623827f, 0.06382448f, -0.21152250f, 0.12231052f, 
    -0.14202346f, -0.05380001f, -0.43624121f, -0.06782480f, 0.27815425f, 0.16852991f, -0.13475499f, -0.10248725f, 
    -0.00347047f, -0.09039353f, -0.08169894f, -0.15655179f, 0.27904728f, 0.30333498f, -0.03800852f, 0.17978525f, 
    -0.19727115f, -0.09280264f, -0.18234268f, 0.37896633f, 0.29813865f, 0.05636904f, 0.16889876f, 0.26668364f, 
    0.16497919f, -0.30411854f, -0.25969794f, -0.11488708f, -0.19234684f, -0.23034857f, -0.15758657f, 0.30863518f, 
    0.31528100f, -0.10850680f, 0.11622665f, -0.04516470f, 0.05092321f, 0.01617746f, -0.03666205f, 0.33858117f, 
    -0.67122442f, -0.39200902f, -0.16225949f, -0.49475446f, 0.38935101f, -0.04014603f, 0.06008104f, -0.14624320f, 
    0.28098559f, -0.31652859f, -0.21304189f, 0.36699292f, 0.14028850f, 0.25243887f, 0.18291761f, 0.11376600f, 
    -0.04543744f, -0.33541477f, -0.08485246f, 0.34358314f, -0.07274704f, 0.22470474f, -0.14976239f, 0.20419788f, 
    -0.24061371f, 0.11327602f, -0.21509530f, 0.44939351f, 0.12060884f, 0.17899390f, -0.04152249f, -0.11882550f, 
    0.42068720f, 0.07599365f, 0.27992666f, -0.22386323f, -0.15864766f, 0.03383635f, -0.14050475f, 0.12754087f, 
    -0.09894267f, 0.02957985f, -0.17867005f, -0.06686044f, -0.05269679f, 0.07126278f, 0.03510523f, -0.24215114f, 
    0.02245027f, -0.21657649f, -0.00557554f, -0.05486345f, -0.09607938f, -0.16508466f, 0.01556408f, 0.07699373f, 
    -0.05546384f, 0.01398706f, -0.04375145f, 0.14413105f, -0.43676549f, 0.30843234f, 0.20597778f, -0.23746702f, 
    0.04890668f, 0.58722138f, -0.34937930f, -0.28280151f, -0.24690534f, -0.09233786f, 0.17731220f, 0.39329195f, 
    0.09316017f, -0.02351387f, 0.58902228f, -0.41087484f, 0.14721563f, 0.00712430f, 0.16928333f, -0.12630247f, 
    0.12231297f, 0.28127712f, -0.20480020f, -0.38418007f, 0.03130114f, -0.22195657f, -0.10569661f, 0.22330722f, 
    0.19848216f, 0.32514974f, -0.37167034f, -0.16615143f, -0.51811278f, -0.39347717f, 0.07767820f, -0.31876567f, 
    -0.01736232f, 0.30481470f, 0.08413157f, 0.16822168f, -0.03512347f, -0.14328778f, -0.10919485f, -0.18895639f, 
    -0.20985393f, -0.19916588f, -0.16217081f, -0.25057468f, -0.07047075f, -0.06344905f, 0.02778590f, 0.05218440f, 
    -0.05808222f, 0.06984480f, 0.15752578f, -0.24663791f, -0.08728847f, 0.05473082f, -0.13439414f, -0.23888057f, 
    0.25269431f, 0.15959927f, 0.21525285f, 0.26154029f, 0.26398936f, 0.37356013f, -0.14649156f, -0.11067094f, 
    -0.36062333f, -0.38773111f, -0.18826123f, 0.23939221f, -0.03672232f, 0.13178474f, -0.16248606f, -0.62340707f, 
    -0.21783638f, -0.11093634f, 0.01991342f, 0.34458071f, -0.11444059f, 0.40994784f, -0.10264066f, -0.24949183f, 
    -0.30381292f, -0.03954357f, 0.09117626f, 0.06475201f, 0.31528959f, 0.26700157f, -0.03281767f, -0.14472291f, 
    0.31864727f, -0.20530733f, 0.29191187f, 0.30377021f, -0.17242099f, 0.03302345f, 0.21479565f, 0.12456696f, 
    0.01300712f, 0.07325752f, -0.09500967f, -0.19381735f, -0.33893973f, -0.18133982f, 0.42481476f, -0.45332062f, 
    -0.10718680f, 0.01612432f, 0.38325670f, -0.17756326f, 0.26502508f, 0.11866876f, -0.20919530f, 0.03465984f, 
    -0.19898494f, -0.48695138f, 0.10629715f, -0.35338548f, 0.03930735f, 0.22261555f, 0.01150364f, -0.15409906f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25986117f, 0.39163348f, -0.11659439f, -0.06102714f, -0.01499660f, 0.29902059f, -0.00115809f, 0.06906306f, 
    -0.13138184f, 0.39850834f, 0.11727116f, -0.07291773f, 0.09706073f, -0.11412531f, 0.27863041f, 0.20587249f, 
    0.13766000f, 0.18309252f, -0.26676729f, -0.37813917f, 0.25525334f, 0.05094666f, 0.39649937f, -0.27239203f, 
    0.05806949f, -0.21671934f, 0.27956799f, 0.02215206f, 0.06472877f, -0.09201792f, 0.18096742f, 0.17561369f, 
    -0.14649528f, 0.44094229f, 0.03290170f, 0.19436307f, 0.01753544f, -0.01172038f, 0.04331053f, -0.13579844f, 
    -0.01404448f, -0.25679910f, -0.11812525f, -0.19042659f, 0.34830907f, 0.04435270f, 0.28651613f, 0.35329437f, 
    0.19233088f, -0.02446212f, 0.10391925f, 0.00166999f, -0.24360690f, 0.38726750f, 0.23678392f, -0.17641665f, 
    -0.07359726f, -0.04102960f, -0.20340605f, -0.12464051f, -0.24582799f, 0.28465164f, 0.17109925f, 0.12227872f, 
    0.39932749f, 0.07501935f, 0.00889263f, -0.11692704f, 0.33809856f, -0.31678677f, 0.20768932f, -0.14731720f, 
    -0.35178399f, 0.02917636f, 0.14651978f, 0.44436488f, 0.08259793f, 0.12929931f, 0.30302379f, 0.11753508f, 
    0.34302187f, 0.17984265f, 0.38618457f, 0.09624118f, 0.04950627f, -0.11997861f, -0.01080655f, -0.09588866f, 
    0.17446242f, 0.33051839f, 0.18562037f, 0.21543099f, 0.49798658f, 0.15688238f, -0.10628016f, 0.22309424f, 
    -0.00146911f, -0.21754718f, -0.13721931f, -0.08336540f, -0.20269775f, -0.34659705f, 0.25486168f, -0.22795795f, 
    -0.08305562f, 0.31605962f, 0.35561851f, 0.11272738f, 0.46566260f, -0.21867642f, 0.45895284f, -0.07602518f, 
    -0.10053000f, -0.13940191f, -0.31818026f, -0.08320270f, 0.32948911f, 0.40136021f, 0.12406997f, -0.09782347f, 
    0.43376407f, 0.42528191f, 0.26699489f, -0.18459553f, 0.17687716f, 0.18190953f, 0.33973497f, 0.44048217f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03710340f, -0.09262490f, 0.00551395f, 0.01346347f, -0.08957820f, 0.01312784f, 0.01190079f, 0.04505738f, 
    -0.00627146f, -0.00117010f, -0.03632483f, -0.05022583f, 0.07701486f, 0.01109318f, 0.02389845f, -0.06970796f, 
    -0.02411559f, -0.05958982f, -0.05882150f, 0.04818717f, 0.06963693f, 0.04513423f, -0.08688606f, -0.07813291f, 
    0.04766293f, -0.04609735f, 0.05779225f, 0.05827575f, -0.07855841f, -0.00132658f, -0.05277554f, -0.07475719f, 
    0.04451097f, 0.00780131f, 0.01094088f, -0.07392419f, 0.02100654f, -0.03449009f, -0.07731923f, -0.03247907f, 
    -0.06930778f, 0.03565208f, -0.03152989f, -0.05682931f, -0.01718676f, -0.01888775f, 0.03619560f, 0.07813370f, 
    -0.02415670f, -0.07726739f, -0.01869231f, 0.04340834f, -0.07865468f, -0.06955533f, -0.03736902f, 0.00511137f, 
    0.00019999f, -0.08690892f, -0.01117041f, -0.06032193f, 0.05011161f, -0.07454731f, 0.00102602f, 0.02306105f, 
    -0.08210669f, 0.05258409f, 0.06688488f, 0.04097050f, 0.01871961f, -0.02563780f, 0.05652791f, -0.05975282f, 
    0.03929728f, -0.00601721f, 0.06576972f, 0.00138853f, 0.06410506f, 0.00932545f, -0.07950201f, -0.02533289f, 
    -0.00232407f, -0.03281973f, -0.00944604f, -0.03272139f, 0.02638402f, 0.07549562f, 0.07644246f, -0.08022952f, 
    -0.05255122f, 0.02005178f, 0.06074261f, -0.02528616f, 0.05244810f, -0.08317005f, -0.05133940f, -0.08655778f, 
    -0.03210774f, -0.02521921f, -0.04117638f, -0.07007261f, -0.05989807f, 0.00616028f, 0.04100104f, 0.06930564f, 
    -0.01366075f, 0.00793044f, -0.08574265f, 0.08625787f, -0.05620972f, -0.01779419f, -0.07219587f, 0.04940166f, 
    -0.00157015f, -0.05113567f, -0.08220559f, 0.01776912f, 0.00642846f, 0.02772981f, -0.04780702f, 0.00878530f, 
    0.05726236f, -0.03955007f, -0.01465278f, -0.07011246f, -0.01548430f, -0.07454538f, -0.00332525f, -0.08564300f, 
    -0.06169750f, 0.19845688f, -0.32621419f, 0.03971991f, 0.07382044f, -0.14836685f, -0.20520771f, -0.00711633f, 
    -0.04433894f, 0.11685573f, 0.03356023f, 0.16194370f, 0.29650703f, -0.08413516f, 0.02226326f, -0.08910272f, 
    0.12768570f, 0.07996627f, -0.17011409f, -0.06621627f, -0.15634468f, 0.08133133f, 0.27808127f, 0.10325382f, 
    -0.07047904f, -0.34665731f, 0.13075311f, -0.15654649f, -0.35030705f, -0.04357001f, -0.01143566f, 0.22000174f, 
    -0.08505138f, -0.01338001f, -0.04935833f, -0.01467078f, 0.04457295f, -0.26718631f, -0.32300213f, -0.47945338f, 
    0.05603922f, 0.01279814f, 0.10088836f, -0.19916561f, 0.15140070f, 0.09218045f, 0.17967670f, 0.15367557f, 
    -0.09469292f, 0.09996895f, -0.00955442f, 0.43467295f, -0.01087602f, 0.02499940f, 0.08846340f, -0.13739087f, 
    0.15403175f, 0.32322770f, 0.08601233f, 0.03351795f, -0.01909190f, 0.07426833f, 0.17517944f, -0.07917127f, 
    0.20161842f, -0.15431203f, 0.46765262f, 0.08504693f, 0.07620903f, -0.07339939f, 0.12768167f, 0.23345779f, 
    -0.12899709f, -0.21306530f, -0.01241138f, -0.17359424f, 0.07463966f, -0.06441084f, 0.26166245f, -0.11735128f, 
    0.90113068f, 0.12276315f, 0.12959245f, 0.08172850f, 0.01470911f, 0.21006352f, -0.24976622f, 0.26473895f, 
    -0.00726310f, 0.02729305f, -0.13122807f, -0.17126317f, 0.11736979f, -0.04344095f, 0.12983781f, 0.64658535f, 
    0.17933719f, -0.03656707f, -0.04358149f, -0.14439833f, 0.19393803f, 0.01704843f, 0.27310041f, 0.14284030f, 
    0.10113631f, 0.12442197f, 0.08321648f, -0.13269913f, -0.18192226f, 0.02393343f, -0.05727292f, 0.09840491f, 
    0.27764624f, 0.05153758f, -0.04137409f, 0.12192804f, -0.23423825f, 0.05712563f, 0.18886149f, -0.03875799f, 
    -0.36178568f, -0.46597028f, -0.17305209f, -0.06987608f, 0.07598878f, 0.06911696f, -0.07082739f, 0.04902357f, 
    0.00002480f, -0.07338566f, -0.04313661f, 0.01915511f, 0.00476425f, -0.02740634f, 0.03475514f, -0.12027156f, 
    -0.03459959f, -0.00390259f, 0.01901543f, -0.01503741f, 0.03978203f, -0.07467728f, -0.04277397f, -0.02944939f, 
    -0.11844754f, -0.02302457f, 0.07946366f, 0.02711034f, -0.08597294f, -0.09973163f, -0.02771492f, -0.06864437f, 
    0.01919778f, 0.03817650f, 0.04940252f, 0.00534642f, -0.12282737f, -0.08956390f, 0.01102699f, 0.02544644f, 
    -0.01373316f, -0.08014157f, -0.03543821f, -0.06209113f, -0.02919568f, 0.03475169f, 0.00671772f, 0.06558965f, 
    -0.07456955f, -0.01988186f, -0.02393738f, -0.05732093f, 0.02713042f, -0.00397167f, -0.03236980f, -0.10109125f, 
    0.03363927f, -0.06559107f, -0.11350630f, 0.03413603f, -0.00064050f, 0.02189292f, -0.03168165f, -0.03986767f, 
    -0.01944081f, 0.07482550f, -0.03783025f, 0.00945461f, -0.05890940f, 0.04408032f, -0.10379528f, -0.04067322f, 
    0.01878055f, 0.05273579f, -0.05184752f, -0.09105476f, -0.10089844f, 0.00835231f, -0.06319059f, -0.07373577f, 
    -0.04886076f, -0.06354656f, 0.04183817f, 0.03023037f, 0.00050998f, -0.08926435f, 0.01104738f, -0.07506527f, 
    -0.01498078f, 0.01816909f, -0.11562372f, -0.05695966f, 0.03306489f, 0.02422651f, -0.04923567f, -0.08630515f, 
    -0.06148382f, -0.05158103f, 0.07013948f, -0.02685795f, -0.03951398f, 0.00656452f, -0.08731383f, 0.02218950f, 
    -0.02485991f, 0.04063255f, 0.04542536f, -0.08905365f, 0.04067464f, 0.06370926f, 0.01087689f, 0.01396235f, 
    -0.00777316f, -0.02748709f, 0.04244827f, 0.01360920f, -0.00992154f, 0.02062534f, -0.11650507f, -0.04379010f, 
    -0.07257016f, -0.04919521f, 0.07215922f, 0.07865714f, -0.00165255f, -0.10979666f, 0.01774991f, -0.07744152f, 
    0.09609634f, -0.03569330f, -0.07888365f, -0.04434717f, -0.01171130f, -0.04235138f, -0.09824337f, -0.04717629f, 
    0.04921268f, 0.03742543f, 0.06901021f, -0.06826650f, -0.06690429f, -0.06822045f, -0.09308233f, 0.02768272f, 
    -0.01696951f, -0.02571091f, -0.01934613f, -0.07845190f, 0.03336551f, -0.07643035f, -0.03860533f, 0.00586816f, 
    -0.00075979f, 0.04412841f, -0.08445545f, -0.02855592f, -0.04821686f, 0.00172427f, -0.08375917f, -0.05921445f, 
    -0.07497603f, -0.00239621f, 0.01387245f, -0.04419466f, -0.01777903f, -0.09745675f, -0.07123424f, -0.00338330f, 
    0.08086494f, -0.02060986f, -0.04953862f, -0.00705775f, -0.00271622f, 0.02140908f, 0.02595071f, 0.07901113f, 
    -0.05442649f, -0.02744449f, 0.07762203f, -0.06908445f, -0.02136188f, 0.00084244f, -0.06284437f, 0.07763509f, 
    0.02391886f, 0.01036544f, -0.06869145f, 0.04705510f, -0.05239952f, 0.02791060f, -0.08129483f, -0.03116214f, 
    -0.01885202f, 0.02366390f, -0.04806509f, -0.03562856f, 0.02518036f, 0.07758112f, -0.01165407f, -0.01085967f, 
    -0.02343367f, -0.03522200f, 0.05541293f, -0.08479866f, 0.00278503f, 0.04816544f, 0.06600098f, -0.02826293f, 
    0.05134317f, -0.01332820f, -0.02084154f, 0.04580503f, -0.08418392f, -0.08430707f, 0.06080008f, -0.01310316f, 
    -0.01449753f, -0.08175831f, 0.03606963f, 0.03723350f, 0.02384934f, 0.01186453f, -0.03231406f, 0.00621938f, 
    0.01219437f, 0.02024131f, 0.02421233f, -0.02825454f, -0.04453415f, -0.08699369f, -0.05884651f, -0.04252416f, 
    0.00486318f, -0.01628179f, 0.08657696f, 0.06418202f, -0.03507533f, -0.08074531f, -0.09797516f, -0.08457854f, 
    0.01793061f, -0.05774345f, -0.04935160f, 0.01737844f, 0.04363281f, -0.02867572f, -0.04420790f, 0.06899437f, 
    -0.06077592f, 0.03583038f, 0.08198217f, 0.02556641f, -0.08517688f, 0.00569735f, -0.07128370f, -0.06639889f, 
    0.06257108f, -0.03075410f, 0.04448676f, -0.00735948f, -0.08339901f, 0.01869719f, -0.02491743f, 0.00673820f, 
    0.09049245f, 0.05276927f, 0.16125000f, -0.14835870f, -0.22185427f, -0.03569083f, -0.01913026f, -0.06136877f, 
    0.06431842f, 0.01658402f, 0.10648371f, 0.21112001f, 0.14168538f, 0.13224506f, -0.14428246f, 0.02001142f, 
    -0.08839932f, -0.21670879f, 0.13969857f, -0.48946002f, 0.20172788f, 0.19507211f, 0.14697725f, 0.03418804f, 
    -0.01877989f, -0.00675771f, -0.05545789f, -0.12048120f, -0.08942597f, -0.06663273f, -0.12410133f, 0.06346513f, 
    -0.05120996f, 0.10526274f, 0.07693633f, -0.05166187f, 0.08956990f, 0.09912394f, -0.14670186f, -0.17781588f, 
    0.24767525f, -0.00520684f, -0.23985487f, 0.01004759f, 0.08539235f, -0.06254900f, 0.27665147f, 0.05264129f, 
    0.05182455f, 0.28150862f, -0.02157516f, 0.12069755f, 0.01456645f, 0.08940395f, -0.03114718f, -0.17884015f, 
    -0.19072664f, 0.11594813f, 0.04218684f, -0.10655154f, -0.15831932f, 0.06191069f, 0.32090035f, 0.34101081f, 
    -0.07262014f, -0.07395889f, 0.10461386f, 0.11286648f, 0.03617790f, -0.02232707f, 0.58058006f, -0.08509278f, 
    -0.14599140f, 0.22592011f, 0.11511994f, 0.07669569f, 0.05656935f, -0.08298136f, -0.03620463f, -0.01776769f, 
    -0.23891170f, 0.13581330f, 0.27960518f, 0.10879481f, 0.40613353f, -0.09005935f, -0.30228671f, -0.04654508f, 
    -0.15972301f, -0.34166420f, -0.13279639f, 0.06732886f, -0.03617774f, 0.12192363f, 0.05182820f, -0.08901476f, 
    0.17216621f, -0.29327586f, -0.08635874f, 0.12642395f, -0.20403233f, -0.02253243f, 0.27311936f, 0.04666888f, 
    0.13069622f, 0.11082598f, -0.12772080f, -0.53780264f, 0.28604946f, 0.11737303f, 0.41538703f, -0.11759172f, 
    -0.06351147f, -0.06136678f, 0.04496508f, 0.16217931f, 0.43636638f, 0.25932395f, -0.11784314f, 0.08079050f, 
    -0.26017570f, -0.18999714f, -0.08049177f, 0.07210390f, 0.13513939f, 0.18390527f, 0.13884701f, 0.03155871f, 
    0.01273275f, 0.19804069f, -0.07724140f, 0.16430545f, -0.01516184f, -0.13709652f, -0.12086189f, -0.04493481f, 
    0.10885923f, 0.14711845f, 0.08278859f, 0.19010815f, -0.25501823f, 0.00670617f, 0.03227324f, 0.22185440f, 
    0.32304895f, 0.21199748f, 0.30641267f, -0.32205510f, 0.07219481f, 0.27644056f, 0.59887785f, 0.03347041f, 
    -0.02358701f, -0.10968874f, -0.05858213f, -0.04611088f, 0.06707375f, -0.01957829f, -0.00267441f, 0.35292980f, 
    0.02204256f, 0.03029051f, 0.01432526f, 0.14779429f, -0.09756356f, 0.03907499f, 0.15909073f, 0.52622479f, 
    0.16289780f, -0.25971541f, -0.15462446f, 0.11173552f, 0.08733243f, -0.10904926f, -0.04463038f, 0.29866534f, 
    0.06508366f, -0.01682786f, -0.07707760f, 0.14331615f, 0.02994442f, 0.14484550f, -0.02573326f, -0.15719305f, 
    -0.09118535f, -0.19436736f, -0.00657118f, -0.25219679f, -0.25075200f, -0.35744533f, 0.31406254f, 0.09201393f, 
    0.04529140f, -0.19370082f, -0.13603260f, -0.00762779f, 0.07654364f, -0.14218438f, -0.19035286f, -0.15925509f, 
    -0.04893246f, -0.39564252f, -0.15704075f, 0.17808200f, 0.17070101f, 0.14270395f, 0.28851476f, 0.10114763f, 
    -0.21687676f, 0.05602441f, 0.38298959f, -0.05946249f, -0.04424929f, 0.09696060f, -0.01594839f, 0.01002125f, 
    0.38143581f, 0.19187620f, 0.14568882f, -0.08444174f, 0.17716093f, -0.05372622f, 0.24557033f, 0.01951343f, 
    0.16602091f, -0.00495547f, 0.03895183f, -0.22507368f, 0.05198435f, -0.08731689f, 0.06418087f, 0.02628232f, 
    0.18496560f, 0.16601722f, -0.05436675f, 0.08666576f, 0.04878406f, -0.05890053f, 0.27594921f, 0.09184249f, 
    0.08056225f, -0.04283357f, -0.15275788f, -0.26244381f, 0.01307290f, 0.22290207f, -0.02923568f, -0.07466362f, 
    -0.16060399f, -0.00813592f, -0.16889121f, -0.08318405f, -0.02118292f, -0.00796360f, 0.22121210f, -0.07827963f, 
    -0.03218980f, 0.11209147f, -0.07359851f, -0.39504051f, -0.45260319f, 0.43443984f, -0.03822295f, 0.04983059f, 
    0.03515261f, -0.02348791f, 0.01596966f, -0.10137880f, -0.03503523f, 0.12709294f, 0.18533483f, 0.06018472f, 
    -0.19416200f, -0.02887727f, -0.08883412f, -0.28890276f, 0.17863245f, 0.15263718f, -0.16785079f, 0.00105113f, 
    0.14273502f, -0.16658422f, 0.31184983f, 0.02394525f, 0.32268131f, 0.14690281f, 0.05006935f, 0.03274389f, 
    -0.05735867f, 0.22278100f, -0.04975934f, 0.22065894f, 0.19767098f, 0.25877905f, 0.24058010f, 0.34168988f, 
    0.16425486f, -0.08073049f, -0.21122006f, -0.02176249f, -0.48550299f, -0.04938025f, -0.28255558f, -0.06872279f, 
    -0.09419454f, 0.19083442f, -0.11090666f, -0.25339544f, -0.01288646f, 0.14694655f, 0.16371775f, -0.00833288f, 
    -0.40201119f, 0.00494515f, -0.04601629f, -0.19835660f, -0.13001511f, -0.02671032f, 0.11302283f, 0.03220355f, 
    -0.09404404f, 0.17844349f, -0.17491771f, 0.00188030f, 0.16168894f, 0.15158109f, -0.07770605f, -0.38919693f, 
    -0.30577201f, 0.11489578f, 0.23104458f, 0.32095531f, 0.09649062f, 0.14103670f, 0.08940279f, 0.19317327f, 
    -0.08901116f, 0.13262311f, -0.05174007f, -0.05417897f, 0.06315892f, -0.35871306f, 0.23401557f, -0.02190781f, 
    0.12307878f, 0.59273964f, 0.23731095f, 0.31612033f, 0.15485549f, 0.42408022f, -0.20108020f, -0.36207050f, 
    -0.16724199f, 0.04126275f, 0.03481172f, 0.17117290f, -0.30467752f, 0.18774165f, -0.24508695f, -0.51716113f, 
    -0.03246065f, 0.20197110f, 0.11456627f, 0.00952283f, 0.45677125f, 0.03259307f, 0.18116997f, -0.03098465f, 
    -0.22733270f, 0.03203616f, 0.06073143f, -0.15782890f, 0.11391595f, 0.11999800f, -0.35335386f, -0.07425538f, 
    0.31173670f, 0.61310720f, 0.07241880f, 0.05439661f, 0.12593032f, 0.15181725f, 0.25178781f, 0.35849303f, 
    -0.07955687f, 0.12756872f, 0.17891209f, 0.10623915f, 0.00726510f, -0.40749398f, -0.02044327f, 0.12644775f, 
    -0.01008148f, -0.11674028f, -0.19035205f, -0.02897735f, -0.00601260f, 0.19087049f, -0.19963920f, 0.02507701f, 
    0.29172930f, 0.21759969f, -0.21447857f, 0.36775666f, 0.05413898f, 0.20318994f, 0.05925229f, 0.11064269f, 
    0.03454201f, -0.05232095f, -0.41468105f, 0.16885006f, 0.14903948f, -0.15255263f, 0.03757169f, 0.13816069f, 
    0.04534653f, -0.16566646f, 0.16591594f, 0.15176697f, -0.15108657f, -0.40212548f, 0.05484214f, 0.11091705f, 
    -0.28865927f, -0.10126331f, 0.71938640f, 0.10179688f, -0.01024130f, -0.22143941f, -0.03111681f, 0.22406742f, 
    0.14755754f, -0.33883038f, 0.09435420f, -0.45631263f, -0.00458461f, 0.23612416f, -0.36965257f, -0.17440134f, 
    0.09000079f, 0.33853397f, 0.01634794f, 0.01606625f, 0.12653863f, -0.22972170f, -0.17378978f, -0.21413743f, 
    -0.22434388f, -0.03919950f, -0.14531507f, 0.00446723f, 0.08890440f, -0.08019631f, 0.19380873f, -0.07336822f, 
    0.07649765f, -0.13462877f, 0.37489158f, -0.11696938f, 0.02743720f, -0.07172909f, 0.03406164f, 0.21957910f, 
    -0.27669144f, -0.15283571f, 0.28372023f, 0.09390685f, 0.05316626f, 0.69376415f, 0.30060679f, 0.37653801f, 
    0.11964694f, -0.45688972f, 0.25398135f, 0.21895586f, -0.05305603f, 0.07605843f, 0.03940445f, -0.48798233f, 
    0.00822220f, -0.02470888f, -0.05385710f, -0.17628650f, 0.27999634f, -0.01000736f, -0.17549026f, 0.21717924f, 
    0.14789248f, 0.33300549f, -0.08806358f, -0.31085598f, -0.48865822f, -0.24779154f, -0.09643705f, -0.03330080f, 
    -0.05769526f, -0.10527040f, -0.29653448f, -0.51280051f, -0.37663496f, -0.01225592f, 0.25405896f, 0.03367826f, 
    -0.07377710f, -0.37774718f, -0.17150301f, 0.05662027f, -0.21723799f, 0.09329392f, 0.14716260f, -0.15899354f, 
    -0.00828128f, 0.09035264f, -0.06647462f, 0.03347267f, -0.10747218f, -0.12293720f, -0.04980680f, -0.08750113f, 
    0.15304448f, -0.15643655f, 0.03271590f, -0.05102932f, -0.12387697f, 0.02649028f, -0.16722505f, 0.04932724f, 
    -0.05601147f, 0.24478655f, -0.02761297f, 0.33623353f, 0.19726948f, -0.02025967f, 0.05114156f, -0.01286246f, 
    0.15639819f, 0.08950523f, 0.23663704f, 0.15970105f, 0.10724597f, 0.08673288f, -0.10609122f, 0.05440403f, 
    -0.03366095f, 0.11233432f, -0.12615420f, 0.18594350f, -0.07880164f, 0.11066648f, -0.14993617f, 0.17929858f, 
    -0.07211573f, -0.44499701f, -0.35133892f, -0.18066481f, 0.05195963f, 0.07324244f, -0.16599615f, -0.10570896f, 
    -0.06226280f, -0.02131874f, -0.02458777f, -0.02279202f, 0.00480607f, 0.17634892f, -0.06572219f, -0.08024582f, 
    0.13221480f, 0.00843134f, -0.02046785f, -0.20297348f, -0.39931741f, 0.09823740f, 0.16080271f, -0.13273844f, 
    -0.01991020f, 0.08391342f, 0.12134080f, -0.00436595f, 0.33820549f, 0.11583336f, -0.21700159f, -0.15479402f, 
    -0.20336439f, -0.20967832f, 0.20699999f, 0.02889237f, 0.00471217f, -0.14431451f, 0.00633294f, 0.24820164f, 
    -0.28368631f, 0.09048717f, -0.13768339f, 0.07454896f, 0.15246366f, -0.06088191f, 0.15010840f, 0.02715151f, 
    0.19684830f, -0.30946353f, 0.00777955f, 0.13493913f, 0.20700018f, -0.02188820f, -0.47063005f, -0.16247658f, 
    -0.08978772f, -0.16521108f, 0.01475896f, 0.08377199f, 0.16406378f, 0.06382354f, 0.04071631f, -0.22948119f, 
    0.21179982f, -0.06744321f, 0.17268722f, -0.34380248f, 0.22872464f, 0.04898405f, 0.31059980f, 0.15303597f, 
    0.22827554f, 0.05665087f, 0.12554288f, 0.31855533f, 0.26848939f, 0.09966228f, 0.12931329f, -0.04611304f, 
    -0.24312195f, 0.12005530f, -0.06487833f, 0.07529669f, 0.15637557f, 0.15786728f, 0.17711456f, 0.15998180f, 
    0.06410071f, -0.00083658f, 0.20658094f, -0.03297618f, 0.18485026f, 0.08340421f, -0.13867642f, -0.11122884f, 
    0.01856053f, 0.09142839f, 0.24039648f, -0.00386372f, 0.09690198f, 0.18811227f, -0.28854808f, -0.29399943f, 
    -0.00745724f, -0.14612389f, -0.05334881f, 0.01782581f, 0.29175282f, -0.07567459f, -0.05060849f, 0.11859167f, 
    -0.16187242f, 0.39589393f, 0.34130228f, -0.00990355f, 0.04334836f, -0.29877833f, 0.13620847f, 0.03256368f, 
    0.09637146f, -0.02594244f, 0.01453944f, -0.23924462f, -0.44712731f, -0.12770802f, -0.32701123f, -0.04952348f, 
    -0.16419579f, 0.30997282f, -0.03357777f, 0.27407050f, 0.18447174f, 0.04579171f, 0.14318874f, 0.00747044f, 
    0.32131189f, -0.14322536f, 0.06701849f, -0.53137636f, -0.04298320f, 0.18882141f, -0.20004739f, 0.07779909f, 
    0.00200609f, -0.20215446f, -0.20308915f, 0.20168191f, 0.36682305f, -0.53108871f, 0.12799221f, 0.30769101f, 
    0.14588989f, 0.05077778f, 0.07405373f, 0.00307426f, 0.02710084f, 0.15517353f, 0.21423616f, 0.06328928f, 
    0.13336004f, 0.84066576f, -0.11150333f, -0.14843123f, -0.05072192f, -0.49082765f, -0.05710390f, 0.02758329f, 
    -0.00321942f, 0.08826198f, 0.06031027f, 0.17365910f, 0.20318523f, 0.15880661f, 0.01673361f, -0.28009537f, 
    -0.19584459f, 0.01693222f, -0.14391278f, -0.30249512f, 0.04557569f, -0.38219732f, -0.38536993f, -0.56212598f, 
    0.31729195f, -0.12499740f, -0.01165603f, 0.14619923f, -0.02347922f, -0.00576734f, -0.24577041f, 0.13085100f, 
    0.14280944f, -0.16709179f, -0.18793505f, 0.00430709f, -0.08735177f, 0.18043175f, 0.02504751f, 0.07672448f, 
    -0.15391448f, -0.08261344f, -0.05461834f, -0.10835585f, -0.47024849f, 0.06562243f, 0.14481716f, 0.00314862f, 
    0.46165240f, -0.50842208f, 0.74282014f, 0.02554689f, 0.19817175f, 0.18548858f, 0.08621068f, -0.01067990f, 
    -0.03930977f, 0.25949442f, -0.42519224f, 0.20533372f, 0.23523101f, -0.26764211f, -0.10664628f, -0.07919939f, 
    -0.03510408f, 0.24425283f, -0.16143438f, -0.09857524f, 0.21317255f, -0.06395668f, 0.06121161f, 0.14184390f, 
    0.30033401f, 0.19503392f, -0.35911325f, 0.11545497f, -0.16560401f, -0.07701281f, 0.36846590f, -0.12921619f, 
    -0.07363354f, -0.06260044f, -0.01734349f, 0.05308140f, 0.04731089f, 0.05555789f, 0.13249096f, 0.32353380f, 
    0.11343246f, -0.02353158f, -0.44016746f, 0.08327041f, -0.07695101f, 0.02325046f, -0.08945800f, 0.05548196f, 
    -0.30363733f, -0.38261068f, 0.12386376f, -0.18080874f, 0.01320779f, 0.07191765f, -0.15915962f, 0.16937964f, 
    0.03526484f, -0.26775953f, 0.02663377f, 0.36170262f, -0.04051986f, 0.15670346f, 0.06899393f, 0.07370964f, 
    0.18931165f, 0.19355793f, -0.13763528f, 0.08778097f, -0.24476629f, 0.06870130f, -0.15844767f, -0.20830829f, 
    0.25438213f, -0.01615573f, 0.34121683f, 0.05149514f, 0.04876113f, -0.01292268f, -0.11960704f, 0.22816813f, 
    -0.03032749f, -0.42340425f, -0.21763608f, 0.03811911f, 0.12684461f, -0.10213649f, 0.25619373f, -0.11751828f, 
    0.59300649f, -0.11906223f, 0.15876602f, -0.05459827f, -0.26730856f, -0.12126643f, -0.13184731f, -0.07055550f, 
    0.25506213f, 0.15765716f, 0.06093731f, -0.09478948f, 0.13491298f, -0.27383208f, 0.03962551f, 0.45431748f, 
    0.10203411f, -0.08005322f, -0.00322178f, -0.13780461f, 0.23216015f, -0.04236014f, 0.02838572f, -0.05392246f, 
    0.06266799f, 0.00909253f, 0.10727426f, 0.05546810f, -0.09409005f, -0.06166169f, 0.07717133f, 0.02699017f, 
    0.44997290f, -0.00986995f, -0.11133476f, 0.00296051f, 0.02239920f, 0.04551441f, 0.09902362f, 0.08653975f, 
    -0.25902438f, -0.01484772f, -0.15761678f, 0.09140246f, -0.00647552f, 0.07728234f, 0.08598570f, 0.11715473f, 
    -0.00601216f, -0.01901644f, 0.02939330f, 0.03468755f, 0.04934183f, 0.05154400f, 0.04857700f, 0.03209880f, 
    0.00689459f, -0.08376420f, -0.09019816f, -0.05180448f, -0.02644265f, 0.05047419f, 0.03004565f, -0.07036573f, 
    0.01271554f, -0.02042185f, -0.06624414f, -0.00005103f, -0.08059447f, -0.04947051f, -0.10308627f, -0.00562031f, 
    -0.06008321f, -0.08791103f, -0.05071342f, -0.06994041f, 0.07113215f, 0.02675192f, -0.05740576f, 0.04381835f, 
    0.03622007f, -0.04980714f, 0.01347477f, -0.01793329f, -0.00889527f, 0.03071154f, -0.02140164f, -0.08044586f, 
    0.05313874f, -0.08381347f, 0.07455390f, -0.12117310f, -0.00732860f, -0.07346620f, 0.01817542f, -0.08076709f, 
    -0.02271736f, -0.00697913f, 0.06367253f, -0.00906396f, 0.04220307f, -0.05003520f, -0.05372580f, -0.01798993f, 
    -0.04634588f, 0.07189142f, -0.03092526f, 0.03077122f, -0.09329928f, -0.04252364f, -0.02664999f, -0.06577679f, 
    0.01484510f, 0.04940674f, -0.08750280f, 0.06208711f, -0.08839673f, -0.02038665f, -0.06080193f, 0.02789646f, 
    -0.04877190f, -0.03128036f, -0.11480878f, 0.03486624f, 0.01799254f, 0.06976621f, 0.02344231f, -0.00948377f, 
    -0.04994250f, 0.03219797f, -0.06664819f, -0.08237922f, -0.03361013f, -0.00180633f, -0.01192648f, -0.06165362f, 
    0.05733271f, -0.15356608f, 0.04994741f, -0.09336182f, -0.00651670f, -0.01520962f, -0.08357243f, 0.07117238f, 
    -0.12907040f, -0.00710433f, -0.02963617f, -0.01225631f, -0.06245983f, 0.04338795f, -0.06153896f, -0.03846632f, 
    -0.04940097f, -0.12153260f, -0.04539312f, 0.04306613f, 0.03587417f, -0.00366885f, -0.05078372f, 0.07836428f, 
    0.00851052f, 0.02209021f, -0.04001384f, 0.03355282f, -0.02151449f, -0.02951273f, 0.02066437f, 0.05963059f, 
    -0.03654381f, 0.04386588f, -0.04194776f, -0.01240256f, 0.01233479f, -0.09411138f, 0.01612744f, 0.00920986f, 
    -0.02757365f, -0.08259774f, -0.04731530f, -0.14185312f, -0.10612223f, -0.09441889f, -0.05470972f, -0.00115342f, 
    -0.08278031f, -0.12286902f, -0.08681509f, -0.05232174f, 0.00137725f, -0.03011857f, -0.05235381f, -0.10427397f, 
    -0.04321477f, -0.01695108f, -0.05244676f, 0.00533563f, -0.00596883f, 0.08890785f, 0.05516689f, 0.03620606f, 
    -0.06228978f, -0.12944131f, -0.05354040f, -0.01838558f, -0.04699043f, 0.03422311f, -0.00559420f, -0.10537836f, 
    0.07067116f, -0.09415010f, -0.00613653f, -0.08819278f, 0.09230324f, 0.07156407f, -0.06422669f, -0.01193255f, 
    0.06813429f, 0.00053261f, 0.07057312f, -0.12786303f, 0.03639569f, -0.09095277f, -0.08447468f, -0.13763595f, 
    -0.04455894f, -0.07526873f, -0.08664006f, -0.06588650f, 0.00821906f, -0.11300832f, -0.07823849f, 0.03336417f, 
    -0.09198121f, -0.08837316f, -0.07119528f, -0.06662230f, -0.02553477f, -0.04379001f, -0.03832803f, 0.00215887f, 
    -0.09031534f, -0.10809901f, -0.03435486f, -0.00147683f, -0.04657364f, -0.09782048f, -0.11341637f, -0.01879371f, 
    -0.11110345f, 0.03570373f, -0.02036566f, -0.04701811f, 0.07487819f, -0.00350995f, -0.03299285f, -0.02193863f, 
    0.07239076f, -0.04366488f, 0.03355537f, -0.00425134f, -0.05768435f, -0.13545263f, -0.06973732f, 0.00286015f, 
    -0.07791812f, 0.02851517f, -0.01504658f, -0.08804596f, -0.10545051f, 0.07318309f, -0.00390418f, 0.00939398f, 
    0.02261002f, 0.03396231f, 0.03119599f, 0.09099718f, 0.03441809f, -0.08801172f, -0.04807732f, -0.05107741f, 
    -0.02291759f, 0.08407116f, -0.10032598f, -0.02191474f, -0.04789309f, -0.11823037f, -0.00756446f, -0.07798330f, 
    0.04605377f, -0.08556737f, -0.05291793f, 0.04361182f, 0.01454106f, 0.04496558f, -0.02096534f, 0.05322945f, 
    0.03390719f, -0.00095121f, -0.08987851f, 0.03773642f, -0.09421336f, -0.04071824f, -0.02999926f, -0.02640414f, 
    0.04983535f, -0.19202778f, 0.17886969f, -0.16698864f, -0.26231620f, 0.07552690f, 0.09518561f, 0.12355426f, 
    0.15176006f, -0.05815660f, 0.09787086f, 0.25441316f, 0.11153758f, 0.14046106f, -0.03666309f, -0.02148962f, 
    -0.18779601f, -0.14626031f, 0.49057364f, -0.42583272f, 0.24769707f, 0.03491608f, -0.13913894f, 0.01431575f, 
    0.11343128f, 0.08031794f, 0.09757570f, 0.06091627f, 0.04542845f, -0.09689002f, -0.13207246f, -0.12237851f, 
    0.04980803f, 0.06916576f, 0.12584415f, -0.13836393f, 0.15632245f, 0.12025019f, -0.12280545f, -0.24448782f, 
    0.34637868f, 0.15348415f, -0.09384185f, 0.18110658f, 0.11025702f, 0.04234432f, 0.23353887f, -0.14057823f, 
    0.13294166f, 0.08529802f, 0.04402611f, 0.12839128f, 0.00750221f, -0.04170768f, 0.33859736f, 0.05855021f, 
    -0.07650863f, -0.28281417f, -0.00930499f, 0.16097659f, -0.13168588f, 0.31178692f, 0.38890237f, 0.23912072f, 
    -0.15956894f, 0.21057205f, 0.06474583f, -0.01948592f, -0.07333898f, 0.07710034f, 0.49433053f, 0.05003323f, 
    -0.19702736f, 0.09103017f, 0.20951378f, -0.01362692f, 0.10434704f, 0.00146803f, -0.18160814f, 0.06300785f, 
    -0.16321421f, 0.34654403f, -0.01591174f, 0.01313764f, 0.44157976f, -0.29301056f, -0.15809195f, -0.24303451f, 
    -0.34329015f, 0.08607886f, -0.22830355f, 0.04413542f, -0.13569616f, 0.20339380f, -0.02306476f, -0.30252504f, 
    0.07215850f, -0.07505029f, 0.08421583f, 0.19612451f, -0.04222501f, -0.08035393f, 0.36875689f, -0.09565401f, 
    0.04483761f, -0.11157324f, -0.03546986f, -0.52468157f, 0.19194208f, 0.10542778f, 0.26907557f, -0.06087038f, 
    -0.00026720f, -0.02494324f, 0.41048500f, 0.05441575f, 0.55151868f, 0.06297109f, 0.01705802f, -0.07228602f, 
    -0.16560639f, -0.29119101f, -0.31811765f, 0.01114758f, 0.11222588f, 0.20071347f, 0.05074797f, 0.06627461f, 
    0.01931899f, 0.05094107f, -0.00790284f, -0.09590978f, -0.02287832f, 0.05395009f, 0.00107020f, -0.09061458f, 
    -0.04052930f, 0.06409916f, 0.05406860f, -0.10072744f, 0.02305828f, -0.09736579f, -0.03793507f, -0.05338264f, 
    -0.06305860f, -0.10408510f, 0.03589430f, 0.05892734f, -0.13908580f, 0.03043442f, -0.10049311f, -0.04427190f, 
    -0.02817942f, 0.04207975f, 0.03822620f, 0.03244861f, 0.03328167f, -0.06680354f, 0.03320666f, -0.02457139f, 
    0.02089393f, 0.03484219f, -0.01393578f, 0.05783721f, -0.08071434f, 0.01309458f, -0.05739975f, 0.03434269f, 
    0.01839037f, -0.04685048f, -0.10750926f, -0.00736113f, -0.08813787f, 0.07081944f, -0.02918575f, -0.03601140f, 
    -0.10732264f, -0.00436154f, 0.00152745f, 0.03211523f, -0.06114960f, -0.09387659f, -0.04058831f, -0.05404567f, 
    0.05635110f, -0.00602990f, -0.09592714f, 0.02165009f, 0.05220277f, -0.01349822f, -0.13706887f, -0.11075627f, 
    0.01392008f, -0.07354983f, -0.13345467f, 0.08649763f, -0.06650115f, -0.10569951f, 0.03156851f, -0.00805474f, 
    0.09949595f, 0.05839325f, 0.03162291f, -0.00008191f, -0.05578022f, 0.02635557f, 0.00887835f, -0.03128721f, 
    0.00366352f, -0.01709198f, -0.04833949f, -0.07426909f, -0.01486231f, -0.02863597f, -0.07151425f, 0.04099385f, 
    0.02004768f, -0.01580510f, -0.02507523f, 0.03226568f, -0.01037586f, -0.10597946f, -0.01234758f, -0.05960640f, 
    0.04619817f, -0.05225889f, 0.02672803f, -0.08019935f, -0.03976307f, -0.02758612f, 0.06336253f, 0.01385740f, 
    0.03815072f, -0.03380796f, 0.03340350f, -0.01727410f, -0.13526647f, -0.06024585f, -0.14663303f, -0.04789926f, 
    -0.05501232f, 0.06231861f, -0.01714380f, -0.08661708f, 0.00827294f, -0.04892659f, 0.08755285f, 0.00180078f, 
    -0.05866792f, 0.02914651f, -0.03934753f, 0.06133248f, -0.03739937f, -0.02961376f, 0.00264645f, -0.12545329f, 
    0.07953564f, -0.16259582f, 0.30642980f, 0.23640962f, 0.19975507f, -0.01604777f, 0.08302169f, -0.04320829f, 
    0.16732727f, -0.43996257f, -0.02943291f, 0.11017337f, 0.08301907f, 0.04034039f, -0.05437827f, -0.23969948f, 
    -0.33642793f, -0.06153661f, 0.06388078f, -0.00143226f, 0.14901346f, 0.05032807f, -0.01217155f, -0.09062511f, 
    -0.03374764f, 0.13413213f, -0.10446181f, -0.04058946f, 0.17892380f, 0.08211809f, 0.14544834f, -0.20076969f, 
    0.04210119f, -0.05741008f, 0.17798001f, 0.11273540f, -0.26273569f, -0.09551489f, -0.16917923f, 0.02451470f, 
    0.05101796f, 0.41885495f, 0.28964058f, 0.11091478f, 0.11731301f, -0.00448385f, -0.40100688f, -0.00205014f, 
    0.11413298f, 0.20928225f, 0.12153957f, -0.21441001f, 0.06363620f, -0.03356536f, 0.01700937f, 0.16389407f, 
    0.00178533f, -0.09660218f, 0.07815709f, 0.02208313f, 0.28857195f, 0.03544897f, 0.11590543f, 0.05866999f, 
    -0.17257088f, 0.09083629f, -0.09060004f, 0.03257564f, -0.09809025f, 0.07003675f, 0.39610323f, 0.15113986f, 
    0.26984248f, 0.16678150f, -0.16449067f, -0.76501864f, -0.24203129f, -0.16628993f, -0.16577512f, -0.00360151f, 
    -0.04625391f, -0.30373150f, -0.02855326f, 0.09656879f, 0.13920772f, 0.47438371f, -0.04661469f, 0.23635271f, 
    -0.48050299f, -0.21614809f, 0.13903561f, -0.13569610f, -0.30782291f, -0.25537404f, -0.10074881f, -0.41466355f, 
    0.15251732f, -0.01284101f, 0.04693547f, -0.17104314f, 0.00025523f, -0.10570595f, 0.11033743f, 0.36031026f, 
    0.16394603f, -0.28939331f, -0.20062700f, 0.04859650f, -0.18389018f, 0.03125181f, -0.06573431f, 0.08181601f, 
    -0.15026148f, -0.01115127f, 0.31206769f, 0.16365835f, -0.29100055f, -0.32234207f, -0.11793870f, 0.04774242f, 
    0.05802596f, 0.02482558f, 0.22216198f, 0.06719796f, -0.11369403f, -0.03007946f, 0.16980489f, -0.23794346f, 
    -0.11125568f, 0.20103961f, 0.01750976f, 0.08356606f, 0.13201711f, 0.00565622f, -0.10884694f, 0.06017618f, 
    0.02222465f, 0.23815942f, -0.11964681f, -0.11916485f, 0.21552975f, -0.12547670f, -0.05886166f, 0.15306020f, 
    0.17011400f, 0.17828161f, -0.16174006f, 0.29289147f, -0.12214473f, -0.06664410f, 0.00151131f, -0.10425604f, 
    -0.12637953f, -0.01634190f, 0.01412767f, 0.17513265f, -0.00566775f, -0.05628631f, 0.22547397f, 0.00420891f, 
    -0.00767608f, -0.00647552f, -0.11747722f, 0.09105683f, -0.09030212f, -0.06021854f, 0.17353719f, -0.04814870f, 
    -0.50926262f, -0.15671663f, 0.34918997f, 0.08726901f, -0.13885039f, -0.03683909f, 0.03322294f, 0.28076705f, 
    0.08759711f, -0.21434817f, -0.08550735f, -0.07651294f, 0.05309806f, 0.16695325f, -0.03325574f, 0.02098057f, 
    0.04790604f, 0.24722996f, 0.07772519f, 0.08761326f, -0.12106372f, -0.08275269f, -0.23764101f, -0.20123608f, 
    0.10831218f, -0.05087102f, -0.22443675f, 0.05503346f, 0.18029474f, -0.16459456f, 0.11983772f, -0.04331628f, 
    0.26491141f, -0.02290837f, 0.05724337f, -0.02985595f, 0.09842423f, -0.02975417f, 0.05734932f, -0.03519049f, 
    0.20809433f, -0.28223661f, 0.07322334f, -0.06267642f, -0.22498609f, 0.45909160f, 0.07801347f, 0.17006341f, 
    0.15788117f, 0.14893031f, 0.16339913f, 0.00603214f, 0.04368208f, -0.18866032f, 0.02754246f, -0.11013066f, 
    0.06741658f, 0.12686242f, -0.01601799f, -0.20946498f, 0.06946822f, 0.02233923f, -0.17997891f, 0.24514261f, 
    0.17316690f, 0.04267669f, 0.10955879f, 0.56654984f, -0.13478279f, -0.15135384f, 0.00339172f, -0.00047983f, 
    0.17909941f, 0.03322321f, -0.37637541f, -0.01390235f, 0.00168926f, 0.06947818f, 0.12721863f, -0.02336177f, 
    0.10923754f, 0.19011064f, -0.08882118f, -0.02212584f, -0.16794868f, -0.06494580f, 0.08029351f, 0.01898461f, 
    0.01579935f, 0.03013047f, 0.34182081f, -0.00106539f, -0.24192694f, 0.29267055f, -0.15625751f, -0.18762632f, 
    0.07531841f, 0.04795684f, 0.10627684f, -0.09960007f, 0.09686068f, 0.09594523f, -0.05561677f, 0.07884608f, 
    -0.14589669f, 0.10163013f, -0.19367217f, -0.25141272f, 0.22854310f, -0.02826151f, -0.04470786f, 0.03200428f, 
    -0.08934234f, 0.19033022f, 0.18113090f, -0.02161989f, 0.11326635f, -0.08872471f, 0.15779209f, 0.05710853f, 
    0.04528269f, -0.00891175f, 0.37101480f, 0.02476517f, -0.08413514f, 0.19981220f, -0.13078453f, 0.37077475f, 
    -0.00746712f, 0.09819761f, 0.04449949f, 0.31577781f, 0.03930542f, -0.07973320f, -0.05927801f, 0.23314400f, 
    0.31176251f, -0.00975929f, 0.00578992f, -0.13953054f, 0.05364506f, -0.06322148f, 0.04045106f, 0.05674839f, 
    -0.12310782f, -0.61142713f, -0.13003838f, -0.01871554f, 0.08624658f, 0.09113339f, 0.34923661f, 0.22003675f, 
    -0.16987453f, 0.06240905f, -0.00890954f, 0.08104683f, 0.11259866f, 0.11295220f, 0.38002083f, -0.15214805f, 
    -0.28376684f, 0.89559448f, 0.04876522f, 0.21111628f, 0.12074991f, -0.07801452f, 0.14249286f, 0.07819444f, 
    -0.01830033f, -0.17970501f, 0.13964006f, 0.23498571f, 0.32501423f, -0.32742152f, -0.18158488f, 0.03197344f, 
    -0.16109888f, 0.47705597f, 0.35991573f, -0.13087447f, -0.01686351f, -0.06208242f, -0.21416877f, -0.46379930f, 
    0.07183154f, -0.04334431f, -0.04777589f, -0.07529248f, -0.54327297f, 0.04804783f, -0.24744584f, -0.28324774f, 
    0.19981253f, -0.22025545f, -0.09681260f, -0.06220377f, 0.32320455f, 0.10416625f, 0.31245172f, -0.05182693f, 
    -0.36340567f, -0.06884692f, -0.12942855f, -0.04148860f, 0.29487377f, -0.05107331f, -0.38245392f, -0.08279725f, 
    0.28307644f, 0.20652789f, -0.13891973f, -0.05020043f, 0.12831466f, 0.05982041f, 0.19353351f, 0.12767191f, 
    0.01985519f, -0.09106620f, 0.05948874f, 0.02036398f, -0.00189297f, -0.02212152f, 0.02468840f, 0.00783247f, 
    -0.02867121f, 0.03491515f, -0.08056647f, -0.04315975f, 0.07984133f, 0.02406231f, -0.01619545f, -0.03096224f, 
    0.02897912f, 0.02340999f, -0.05957276f, 0.07998917f, -0.04228799f, 0.07457215f, -0.07393816f, -0.09225727f, 
    0.02045259f, -0.09216323f, 0.03051396f, -0.04878950f, -0.05461978f, 0.03014722f, 0.00347781f, 0.01834152f, 
    -0.07209250f, -0.05948899f, -0.04736106f, 0.05172587f, 0.00318312f, -0.07149044f, -0.06050187f, -0.01281752f, 
    -0.07451580f, -0.03838015f, 0.01430131f, 0.05628292f, -0.01517441f, 0.05115905f, -0.06781170f, 0.00022788f, 
    0.00599193f, -0.03637793f, 0.03544412f, -0.03646397f, -0.05445347f, -0.05715602f, 0.01585767f, -0.02851814f, 
    0.04464275f, -0.03708314f, -0.04765501f, -0.10127115f, -0.07248133f, -0.02409722f, -0.07776839f, -0.02934370f, 
    0.00264024f, -0.07218613f, -0.02184585f, 0.07709655f, -0.00776271f, -0.07173967f, -0.07070453f, -0.08681057f, 
    0.02477414f, 0.02180591f, -0.08586922f, -0.01155695f, -0.09636028f, -0.02072915f, -0.02275684f, -0.03144749f, 
    -0.06913073f, 0.00594173f, -0.09876724f, -0.08098616f, -0.00173105f, 0.06639688f, 0.01446270f, 0.01882776f, 
    -0.04349891f, -0.03324309f, -0.00616969f, 0.04878554f, 0.01751769f, -0.05992323f, 0.01915113f, -0.07304817f, 
    0.03780704f, 0.06600149f, -0.07399311f, -0.03954522f, 0.03926399f, -0.06376971f, 0.02444980f, -0.06212940f, 
    0.02087714f, 0.02783286f, 0.01636243f, -0.03744249f, -0.06432512f, -0.09721724f, 0.04886550f, -0.04850360f, 
    0.02239599f, -0.03809350f, 0.06269938f, -0.03314709f, 0.04513397f, -0.08421939f, 0.01540837f, 0.05454478f, 
    -0.03156994f, 0.03728152f, 0.07556663f, 0.04917040f, -0.01219273f, 0.02364203f, -0.08559864f, -0.07795306f, 
    0.07788385f, -0.03588979f, -0.03673973f, -0.00887899f, 0.05127393f, 0.06097967f, 0.00006449f, -0.03414222f, 
    0.01569431f, 0.07465635f, 0.03328552f, 0.04856417f, -0.08673899f, -0.01064353f, -0.02475609f, -0.02924412f, 
    -0.01940056f, 0.06911180f, 0.04481476f, -0.00534347f, 0.02977449f, -0.05849226f, -0.03047481f, -0.08195400f, 
    -0.09722517f, -0.08111961f, 0.03318073f, -0.01325145f, -0.02658844f, 0.07187377f, 0.07931189f, -0.04086968f, 
    0.00648693f, 0.02077802f, 0.05222210f, -0.09896126f, -0.00410572f, -0.06272315f, 0.05144452f, -0.03239889f, 
    -0.04057980f, -0.07177658f, -0.00739833f, -0.02537175f, -0.02494075f, -0.00690985f, -0.09246579f, -0.06902750f, 
    -0.07670335f, 0.01501397f, 0.04265498f, 0.00872889f, 0.08642684f, -0.01284133f, 0.03727482f, -0.05449319f, 
    -0.06041251f, -0.10517371f, 0.07909069f, -0.07077048f, 0.01815182f, -0.00807116f, -0.06102909f, -0.03678152f, 
    0.02457510f, -0.06691775f, 0.01125431f, 0.08531225f, -0.06371285f, -0.04800632f, -0.02669006f, -0.09570769f, 
    -0.07325059f, 0.08368317f, -0.10372722f, -0.07397585f, -0.08418774f, -0.07129372f, -0.09033712f, -0.03753893f, 
    -0.09230257f, 0.05997218f, 0.04351087f, -0.04168177f, -0.05814543f, -0.03523699f, 0.02077567f, -0.06538273f, 
    0.03276659f, -0.10692640f, -0.06924209f, -0.01640582f, -0.02568527f, 0.03089999f, -0.03493035f, -0.01969834f, 
    -0.05662682f, 0.05775463f, 0.04655077f, 0.01336687f, 0.00190345f, 0.05681744f, 0.00714580f, -0.05444413f, 
    0.04502351f, -0.06559329f, 0.00838516f, -0.07294811f, 0.07294785f, 0.01068364f, -0.07268196f, -0.02307362f, 
    -0.08760349f, -0.06976599f, 0.00376167f, 0.04321245f, -0.07569435f, 0.06443958f, 0.00605043f, 0.03514553f, 
    -0.09414092f, -0.01842155f, -0.01951174f, 0.07058787f, 0.00578862f, -0.00793416f, 0.00264226f, 0.02015738f, 
    0.11124995f, -0.03127835f, 0.03799108f, 0.06874903f, 0.09110354f, 0.20758229f, 0.24319927f, 0.26568994f, 
    0.17163004f, 0.00476214f, 0.06053418f, 0.02740448f, -0.17269512f, 0.01829165f, 0.26644427f, 0.20194086f, 
    0.11824347f, -0.03584613f, -0.13180473f, 0.07673521f, 0.16263978f, 0.07037943f, 0.09877495f, -0.14091821f, 
    0.04667132f, -0.11533128f, 0.00402608f, 0.00764761f, 0.41989934f, 0.27435106f, -0.02855447f, 0.01770705f, 
    0.03205875f, 0.15328072f, 0.00997506f, -0.08316195f, 0.15540193f, -0.10993443f, 0.22980163f, -0.22730768f, 
    0.28805643f, 0.15343392f, -0.21756481f, 0.23295039f, -0.30569041f, -0.10641476f, -0.12044629f, 0.17987189f, 
    0.11322667f, 0.33984837f, 0.06036297f, 0.16088568f, 0.01464843f, 0.22551645f, -0.20327868f, 0.21350570f, 
    -0.09932261f, 0.29485652f, -0.08345388f, -0.27128729f, -0.27384865f, -0.17374891f, -0.13491075f, -0.07113359f, 
    -0.00237264f, 0.17873065f, -0.19347200f, -0.00979387f, -0.14216456f, 0.14213431f, -0.32037663f, -0.29852566f, 
    0.18893924f, -0.59194255f, -0.06577045f, 0.34337866f, -0.12503618f, 0.29380435f, -0.26053196f, 0.11950853f, 
    -0.38923386f, 0.24145538f, 0.07667948f, -0.09158666f, -0.12227851f, 0.25242054f, 0.01038421f, 0.09707742f, 
    -0.19571650f, -0.27148813f, 0.11460404f, 0.03952964f, -0.00378692f, 0.17437500f, 0.08062294f, 0.29653049f, 
    0.08637355f, 0.04024100f, -0.07826313f, 0.12108853f, -0.27952501f, -0.03913837f, 0.02955996f, 0.19007628f, 
    0.05626812f, -0.02675462f, 0.03407869f, -0.37105900f, 0.08963898f, 0.05761237f, -0.12530255f, 0.00586364f, 
    0.09898337f, -0.04333704f, -0.00236764f, -0.34306064f, 0.30373546f, 0.06178141f, -0.30363056f, 0.01829511f, 
    -0.34170347f, 0.11063389f, 0.00100568f, -0.03552121f, 0.18601578f, 0.01036003f, 0.08382097f, 0.06343459f, 
    -0.05876939f, 0.06420486f, 0.22573650f, 0.21778196f, 0.02636179f, -0.13873591f, 0.00099747f, -0.14115985f, 
    0.03927894f, 0.17329198f, -0.12897809f, -0.12687488f, 0.01946753f, -0.15222086f, -0.09580608f, 0.19971396f, 
    0.27025256f, 0.17723624f, -0.06956998f, 0.16747022f, 0.06551294f, -0.17029589f, 0.17858639f, -0.24608968f, 
    -0.07699693f, -0.11308402f, 0.11051085f, 0.09794605f, -0.03549008f, -0.10235966f, 0.25822034f, -0.02389575f, 
    0.07649466f, 0.14240143f, 0.17115535f, 0.27588814f, -0.27964070f, -0.11274010f, -0.01347231f, 0.02929837f, 
    -0.33864164f, 0.01491919f, -0.05606294f, 0.11172909f, 0.21958150f, 0.16314861f, 0.06726453f, 0.31562835f, 
    0.03305540f, -0.00686037f, 0.00281589f, 0.07921910f, 0.04138416f, 0.10167994f, -0.12349925f, 0.07317925f, 
    0.03912789f, 0.12046012f, -0.08951126f, -0.06596928f, 0.12807798f, 0.00863345f, -0.05735867f, -0.08040910f, 
    0.11950534f, -0.08021972f, -0.14540365f, 0.09756834f, 0.13623026f, -0.10017374f, 0.45323783f, -0.02499441f, 
    0.00185438f, 0.05615486f, 0.04538779f, -0.05523651f, -0.00804171f, -0.04924092f, 0.15719715f, -0.05080473f, 
    0.03163371f, -0.24924490f, 0.12104259f, 0.01523241f, -0.22012405f, 0.44601154f, -0.21171683f, 0.23100600f, 
    -0.04778203f, -0.23576780f, 0.17093939f, -0.16681941f, 0.00125434f, -0.42807290f, 0.17135015f, 0.04972818f, 
    0.07651576f, 0.04165217f, -0.06274082f, -0.15074232f, -0.09383857f, -0.05371006f, -0.08227532f, 0.17926207f, 
    0.21780093f, -0.02461173f, 0.04255767f, -0.21565405f, -0.10585862f, -0.00974086f, 0.14299092f, 0.10369445f, 
    0.13469066f, -0.02909662f, -0.05385305f, 0.25078595f, 0.10951833f, 0.07265902f, 0.10991764f, -0.02210636f, 
    -0.37681073f, -0.20356701f, 0.06670161f, -0.03796225f, 0.01299082f, -0.32783091f, 0.17212234f, 0.06777417f, 
    -0.00214915f, 0.03127459f, 0.01443723f, -0.06543730f, -0.07860216f, -0.03521711f, 0.10062256f, 0.06940509f, 
    -0.10180186f, 0.06428707f, -0.05237596f, -0.07782098f, -0.01160761f, -0.11750592f, 0.03403550f, 0.04235614f, 
    -0.01978229f, -0.01331164f, -0.07974806f, 0.02053213f, -0.05821200f, -0.04139602f, 0.05796931f, -0.11580434f, 
    -0.09256737f, -0.00182640f, -0.04676066f, 0.02921585f, -0.00198040f, -0.09793218f, -0.06776661f, -0.10534271f, 
    -0.07570814f, -0.05623434f, -0.09359083f, 0.00569990f, 0.07111763f, -0.07861342f, -0.00858079f, 0.05758523f, 
    -0.12730579f, -0.06707879f, 0.06336167f, -0.10694541f, 0.02357856f, -0.06691565f, -0.02943922f, -0.00013505f, 
    -0.05646036f, -0.08921485f, 0.00084738f, 0.00924686f, -0.02823190f, -0.04803536f, -0.03050904f, 0.02227607f, 
    -0.08274736f, -0.05489795f, -0.03102821f, 0.01209613f, -0.02968350f, 0.06521164f, -0.10932197f, -0.10365697f, 
    -0.06676872f, 0.02312957f, -0.10112950f, 0.03063774f, 0.07546061f, -0.11591892f, -0.01018849f, -0.08084971f, 
    0.02609454f, -0.04766678f, 0.04840388f, -0.06876816f, -0.09508546f, -0.08335551f, 0.03708576f, 0.07824174f, 
    -0.05176586f, 0.00357636f, -0.04057718f, 0.01331538f, -0.07394409f, -0.00901552f, 0.06755264f, 0.00638952f, 
    0.03288702f, 0.00476171f, -0.06783315f, -0.00711400f, -0.09928416f, 0.00398504f, -0.07165746f, 0.02015359f, 
    0.03563433f, -0.06501204f, -0.07692420f, -0.00217405f, -0.07335159f, -0.05227284f, 0.04132751f, -0.01750605f, 
    0.00775158f, -0.00459956f, -0.06860991f, -0.08804812f, 0.06077934f, -0.07165573f, 0.03541938f, -0.08403746f, 
    0.01918335f, -0.06708428f, -0.06334613f, -0.05530218f, -0.09591745f, 0.04306154f, 0.00717544f, 0.07049906f, 
    -0.04956995f, 0.08277550f, -0.08634158f, -0.08231257f, 0.05192524f, 0.04130539f, 0.05171423f, 0.03748020f, 
    -0.01787002f, -0.00828424f, -0.02887490f, 0.06178959f, -0.21415403f, 0.12063453f, 0.07174475f, -0.08012189f, 
    0.02193911f, 0.19758657f, 0.11157060f, -0.33468631f, 0.05154630f, -0.16977629f, 0.11215641f, 0.08901091f, 
    0.09750896f, 0.08328579f, -0.07298744f, 0.14101796f, -0.06249052f, 0.17185904f, -0.03653974f, 0.01642077f, 
    -0.00933564f, 0.13929296f, 0.25172967f, 0.09261034f, -0.09419495f, 0.25902081f, 0.16408420f, 0.17350069f, 
    -0.03565856f, 0.18978582f, -0.17608842f, 0.17100060f, -0.03363327f, 0.12965366f, 0.14776663f, 0.34923643f, 
    0.14251900f, -0.34216750f, -0.32241586f, -0.24992855f, -0.03048804f, 0.31179145f, -0.06062971f, 0.09788398f, 
    -0.01033843f, -0.07066192f, 0.02382168f, 0.18727142f, -0.00924355f, -0.06968503f, -0.30138475f, 0.22246569f, 
    -0.05774641f, -0.46573353f, -0.20768419f, 0.21877685f, -0.26781514f, -0.29520103f, 0.06027211f, -0.17852092f, 
    0.28331149f, 0.12190104f, -0.01940116f, 0.01596636f, 0.08818808f, 0.14025854f, -0.52927721f, 0.11900475f, 
    -0.27416718f, -0.24958467f, -0.45623153f, 0.00365563f, 0.11619019f, 0.04978570f, 0.12018306f, 0.06540912f, 
    -0.39395943f, -0.10581507f, -0.05071301f, 0.09600821f, -0.16025421f, -0.37230641f, 0.11564462f, -0.04393987f, 
    0.06963493f, -0.29310712f, 0.02437949f, -0.13747232f, 0.00459703f, -0.17600474f, 0.10587441f, 0.30261073f, 
    -0.01026968f, 0.29215854f, 0.03110261f, 0.02956539f, -0.19224152f, -0.04780600f, -0.25848982f, -0.27167448f, 
    0.01361391f, -0.18739781f, 0.19436455f, -0.30866838f, 0.08281302f, 0.19945505f, -0.00410815f, 0.30439678f, 
    0.16975555f, 0.11133521f, 0.11343641f, 0.38859281f, 0.01255572f, -0.03352673f, -0.14568114f, 0.08485526f, 
    -0.02135163f, 0.15077050f, 0.05311676f, 0.02966215f, 0.12511954f, -0.13795580f, 0.05398313f, 0.13649422f, 
    -0.03370722f, 0.01986633f, -0.04775412f, -0.02722991f, 0.05112832f, -0.05508352f, -0.08444864f, -0.07611550f, 
    -0.03178614f, -0.05580175f, -0.09771051f, 0.07534788f, 0.01403202f, -0.09944618f, 0.01930619f, 0.05297163f, 
    -0.03237988f, -0.03472031f, -0.06296896f, -0.03527129f, 0.07062091f, 0.07148242f, -0.05384099f, -0.07923715f, 
    -0.00477472f, -0.07124954f, 0.02048685f, 0.00782677f, -0.04374328f, -0.06537661f, 0.02084507f, -0.03324315f, 
    -0.06091720f, 0.05214161f, -0.08245999f, -0.02169960f, -0.04406612f, -0.06150639f, 0.00474021f, 0.03168129f, 
    -0.05533250f, -0.01003000f, -0.00639941f, 0.06918906f, 0.06467346f, 0.03730990f, 0.07080826f, 0.02000657f, 
    -0.04231275f, -0.00257909f, -0.03449426f, 0.04730906f, -0.03180983f, 0.06187511f, -0.02621200f, -0.05620833f, 
    0.06458987f, -0.01944892f, -0.01726029f, -0.07543950f, 0.03139079f, 0.01369153f, -0.06659740f, -0.07535951f, 
    0.03530913f, -0.07278849f, -0.10461199f, -0.01053872f, 0.03276997f, -0.06944545f, 0.01330318f, -0.06839459f, 
    -0.02150966f, -0.08800447f, -0.07290896f, -0.02276807f, 0.05754733f, -0.09956073f, -0.03555891f, 0.05222593f, 
    -0.06012145f, -0.01209612f, -0.03926953f, 0.03595066f, -0.07327999f, -0.02586258f, -0.04642368f, -0.05818398f, 
    0.02738016f, -0.01420949f, 0.02989148f, 0.02455689f, -0.00144307f, -0.03244542f, -0.03694374f, -0.05015539f, 
    -0.04551152f, -0.03659855f, 0.08714898f, -0.06096046f, -0.04365606f, 0.05371539f, 0.01566204f, -0.08608940f, 
    -0.08297411f, -0.07948341f, -0.09752438f, 0.05390727f, -0.00144915f, -0.10446725f, 0.01133875f, 0.00757257f, 
    0.04172494f, -0.05589665f, -0.01552956f, -0.00495367f, -0.09529343f, 0.03147898f, 0.01785006f, -0.03594625f, 
    0.05517029f, -0.06073001f, 0.04039801f, -0.01502057f, -0.11006811f, 0.00310453f, 0.04618965f, -0.06544913f, 
    -0.03980291f, 0.03719267f, -0.01474121f, 0.02772364f, 0.21608929f, 0.16309544f, -0.18705097f, -0.00009663f, 
    0.13157207f, 0.08542637f, 0.10096451f, -0.15587154f, 0.07859806f, -0.02824458f, -0.17503156f, -0.09176874f, 
    -0.05498488f, 0.00383989f, 0.00414053f, 0.29095221f, 0.11489175f, -0.22202189f, -0.19681858f, -0.03350879f, 
    0.02104840f, 0.26779434f, 0.23049860f, 0.17499000f, -0.09585366f, 0.04482645f, 0.14226338f, -0.04642475f, 
    0.08403059f, 0.07934344f, -0.13678010f, 0.27092311f, -0.09697087f, 0.06829932f, -0.00519918f, -0.10942931f, 
    -0.31416857f, -0.09220677f, -0.20921686f, 0.06223260f, -0.00502214f, 0.23142718f, -0.42501652f, -0.06738065f, 
    -0.09899309f, 0.12216759f, 0.02769708f, 0.10495888f, -0.11270022f, 0.19342306f, 0.01400035f, 0.17723647f, 
    0.19369075f, 0.52891833f, -0.05513345f, 0.12650895f, -0.01354760f, -0.01314560f, 0.01609740f, 0.01564280f, 
    0.23648286f, -0.00432926f, 0.12324724f, 0.00389141f, 0.19173937f, 0.14315484f, 0.04677371f, 0.09940816f, 
    0.29383063f, 0.02582863f, -0.04447045f, 0.05403882f, 0.09377317f, -0.14285828f, 0.01844713f, 0.01786183f, 
    -0.37927139f, -0.01406034f, -0.16933581f, 0.08479464f, -0.05732268f, 0.11334897f, 0.01653944f, 0.07364450f, 
    0.26530281f, 0.02991999f, -0.05076719f, -0.04612079f, 0.13041089f, -0.09010582f, -0.37237763f, 0.09132171f, 
    0.05855590f, -0.03326305f, 0.06241250f, 0.10300168f, 0.12983190f, 0.03406037f, 0.04513057f, 0.07530657f, 
    0.06605864f, -0.24357681f, 0.07484891f, -0.56810921f, 0.19652952f, 0.12765448f, 0.10125913f, 0.21258160f, 
    0.34538081f, -0.03686681f, 0.16948047f, 0.08617263f, 0.12490659f, 0.11627664f, -0.00767654f, -0.02801339f, 
    -0.30274978f, 0.08171129f, 0.16349071f, 0.01693105f, 0.08178456f, 0.00604662f, -0.00042597f, 0.20627564f, 
    -0.08181804f, 0.17506956f, 0.22151038f, 0.26345396f, -0.07085999f, -0.02645121f, 0.00245350f, 0.13136478f, 
    -0.04207056f, -0.16388366f, -0.11130913f, 0.27405122f, 0.13253342f, 0.17757767f, 0.02561626f, 0.07418452f, 
    0.00493457f, -0.01150071f, -0.33141190f, 0.18985656f, 0.13436270f, 0.19255006f, 0.32527599f, 0.03642591f, 
    -0.03134006f, -0.27744901f, -0.00367457f, 0.00276565f, 0.38082057f, -0.03588872f, -0.00041761f, 0.22870260f, 
    -0.00142408f, -0.00142609f, 0.58360541f, -0.13151795f, 0.13863750f, -0.16166660f, 0.01243394f, -0.07998750f, 
    0.08011239f, -0.20441070f, 0.34174699f, 0.07130296f, 0.00433244f, -0.23329841f, -0.44022137f, 0.16378532f, 
    0.19688655f, 0.41016713f, 0.10496876f, 0.07322513f, -0.04224488f, 0.37006474f, -0.12479450f, -0.00401401f, 
    -0.06243416f, 0.41043469f, 0.17473422f, -0.37199143f, -0.05302812f, 0.16964221f, 0.05403894f, -0.09668072f, 
    -0.34422100f, 0.04589618f, 0.02085835f, 0.01297138f, -0.05067258f, 0.08138558f, 0.52532828f, -0.19646701f, 
    0.12395828f, -0.02905961f, 0.21299641f, 0.13955921f, -0.15936324f, -0.08379316f, -0.02160662f, 0.14396088f, 
    -0.26540020f, -0.01629803f, 0.11937583f, 0.05514894f, 0.13145737f, 0.55054021f, -0.01576945f, 0.66747457f, 
    0.04856833f, 0.04561147f, 0.43612322f, 0.06509051f, -0.05063530f, 0.08291797f, -0.28922185f, -0.13415742f, 
    0.23296207f, -0.14491558f, 0.06350161f, -0.09648807f, 0.06640751f, -0.10621881f, 0.08952061f, 0.34343264f, 
    0.14167815f, 0.29852876f, 0.05645966f, -0.06526739f, -0.04594365f, -0.08797615f, 0.23379126f, -0.06029083f, 
    -0.02803176f, 0.04306084f, 0.02290053f, -0.04164127f, 0.21113621f, 0.13405077f, -0.01627766f, 0.07280242f, 
    0.25377062f, -0.05894573f, -0.00683618f, -0.06701379f, 0.12702781f, -0.02421371f, 0.27938056f, -0.14642449f, 
    -0.06329684f, -0.20048824f, 0.38208917f, 0.00856603f, -0.25881213f, 0.09483223f, 0.33979785f, 0.32577193f, 
    0.03199333f, -0.01158445f, -0.05281664f, 0.22259268f, 0.01806111f, 0.01399222f, 0.36292893f, 0.01435896f, 
    -0.07973460f, -0.05979818f, 0.34991559f, -0.13062501f, 0.09848460f, 0.26550683f, 0.03378855f, -0.00905722f, 
    0.10945092f, -0.17494175f, -0.16394952f, 0.03818299f, 0.41218430f, 0.16338524f, 0.06940148f, 0.02945146f, 
    0.04368876f, 0.08461872f, 0.50603795f, -0.14014485f, 0.30971289f, 0.02972368f, 0.21541937f, 0.11507149f, 
    0.41947737f, 0.27913317f, 0.08079180f, 0.12839299f, -0.19961378f, 0.07509034f, 0.05687036f, 0.17336403f, 
    0.03322049f, 0.33254245f, 0.00487112f, 0.10643382f, 0.07959608f, -0.06154831f, -0.04849017f, 0.24866098f, 
    -0.24023546f, -0.26799598f, 0.04074204f, -0.01269223f, -0.03286716f, 0.05598195f, -0.01661475f, 0.05389242f, 
    -0.06370649f, 0.24571854f, -0.31556329f, -0.01984250f, -0.17001180f, 0.12298197f, -0.23127872f, -0.09167389f, 
    -0.06113404f, -0.32222331f, 0.15262087f, 0.13818797f, -0.00002266f, 0.35300532f, -0.28863683f, 0.14013773f, 
    -0.38296166f, 0.19157988f, 0.00040538f, -0.15455015f, -0.09404474f, 0.16788028f, 0.15503313f, 0.21627408f, 
    -0.29744318f, -0.20552224f, 0.22786619f, 0.17118962f, -0.24469973f, 0.27965054f, 0.11138323f, 0.06506024f, 
    -0.07820044f, 0.27464947f, 0.08756936f, 0.13373449f, -0.16589579f, 0.01355099f, 0.13504165f, 0.16285199f, 
    0.04259879f, 0.02931392f, 0.03175433f, -0.46800098f, 0.11338706f, 0.11481337f, -0.19422144f, 0.08744017f, 
    -0.08062199f, -0.08764321f, 0.28262624f, -0.20783654f, 0.32441276f, -0.18267719f, -0.14081246f, 0.01136614f, 
    0.09419413f, 0.14499655f, -0.19697775f, 0.03345144f, 0.13059214f, -0.01167982f, 0.08656257f, -0.09182113f, 
    0.03076575f, 0.17363000f, -0.07919301f, 0.01477333f, -0.06354821f, -0.05724822f, -0.14009765f, -0.10475500f, 
    0.08081396f, -0.11884085f, 0.18878230f, -0.27517545f, -0.12192284f, 0.05456509f, -0.16062643f, 0.06628282f, 
    -0.09482124f, 0.25086170f, -0.35292882f, 0.18319342f, 0.16895708f, -0.12155131f, -0.07193034f, -0.06272404f, 
    0.02728462f, 0.19130647f, 0.18095398f, 0.15957408f, 0.08723232f, -0.07227299f, 0.08188947f, 0.02155951f, 
    -0.04179700f, 0.14199626f, -0.11887737f, 0.24555805f, -0.21655871f, -0.08510994f, 0.00838248f, 0.38975823f, 
    -0.26136994f, -0.39955926f, -0.30224982f, -0.05026716f, 0.15103184f, 0.14417134f, -0.42022690f, 0.04704253f, 
    0.01752816f, -0.16392407f, 0.02580624f, -0.09722464f, -0.00814686f, 0.22695002f, -0.20623453f, -0.08516412f, 
    0.17933223f, -0.04628543f, -0.04964417f, -0.15692112f, -0.28214040f, 0.11079357f, 0.05657689f, -0.09805068f, 
    0.07316283f, 0.09756986f, -0.00632975f, 0.04558720f, 0.24362634f, -0.06359731f, 0.10359636f, -0.06901377f, 
    -0.04920365f, 0.17441954f, 0.16398825f, -0.01203625f, -0.02174549f, -0.17073332f, 0.26104000f, 0.26555583f, 
    -0.11446923f, -0.12170453f, -0.00813657f, 0.18235151f, 0.01386216f, -0.09048758f, 0.08241110f, -0.16432673f, 
    0.58342820f, -0.22022754f, 0.18441436f, -0.09804281f, 0.11685484f, -0.08319951f, -0.35749277f, -0.06996924f, 
    -0.03347605f, -0.01568889f, 0.06006691f, -0.01357627f, 0.15921271f, -0.06815978f, -0.10767528f, -0.09829194f, 
    0.22147527f, 0.04082217f, -0.01239789f, -0.16190679f, 0.14105129f, -0.01341175f, 0.23363905f, 0.13522783f, 
    0.17387815f, 0.05222815f, -0.36602297f, 0.04902879f, -0.00550511f, -0.00043532f, 0.16070171f, -0.06269098f, 
    -0.03077952f, 0.02073252f, -0.26136503f, 0.09726709f, 0.08834417f, 0.06799645f, 0.27556711f, 0.18568315f, 
    -0.01844136f, 0.02644047f, 0.40655476f, 0.10915294f, -0.02735226f, 0.16553681f, 0.25024891f, 0.27642763f, 
    -0.05243152f, 0.00136927f, -0.16755159f, 0.13550843f, 0.02322170f, 0.09900203f, 0.14438224f, 0.19552775f, 
    0.14302354f, 0.00122220f, -0.02466023f, 0.01772170f, -0.03611630f, 0.08470957f, 0.10236715f, -0.08811348f, 
    -0.08228603f, -0.11812849f, -0.30666971f, -0.06581362f, 0.43842536f, -0.01268110f, 0.04117052f, -0.08902599f, 
    -0.10219676f, -0.10862874f, 0.54069555f, -0.12424589f, -0.05062569f, -0.00978989f, 0.16737029f, -0.02880418f, 
    0.10965449f, -0.03585528f, 0.45495284f, 0.36649132f, -0.26268610f, -0.28440309f, 0.03140942f, 0.39069834f, 
    0.32458326f, 0.10668343f, 0.02279444f, -0.26377451f, -0.04192445f, 0.13619435f, 0.21677981f, 0.21194132f, 
    -0.19197872f, -0.17855024f, 0.01762315f, -0.07511514f, 0.03024762f, 0.26027581f, -0.15543628f, -0.03259717f, 
    -0.28565407f, 0.08972412f, -0.32000041f, -0.13695973f, -0.21494344f, 0.01300757f, 0.36017650f, -0.09695394f, 
    0.04103601f, -0.17915349f, 0.18110496f, 0.17634830f, -0.01465128f, 0.18571869f, -0.06489974f, -0.06418537f, 
    -0.00170008f, -0.12064334f, 0.20923074f, -0.06985340f, 0.02952723f, 0.21902424f, 0.17228116f, 0.25248063f, 
    -0.13224955f, 0.56472826f, 0.42770007f, 0.08291012f, -0.11540325f, 0.14971477f, 0.11820699f, -0.26781225f, 
    0.04877407f, 0.13681561f, -0.02282289f, 0.02087650f, -0.11249136f, -0.04862694f, 0.03514681f, 0.04408119f, 
    0.04832143f, 0.12893006f, -0.08455904f, 0.54776311f, -0.01190509f, -0.11240195f, 0.00351541f, -0.16756766f, 
    -0.30268714f, 0.04835371f, -0.17190893f, -0.18810068f, 0.19558288f, -0.11073770f, -0.11061217f, 0.00829894f, 
    0.54897207f, 0.14513403f, -0.19442159f, 0.00793585f, -0.10489117f, 0.05107949f, 0.10940763f, -0.07382610f, 
    0.04968847f, 0.19938056f, 0.04222803f, -0.02673063f, 0.27032766f, 0.12608218f, -0.42060584f, -0.15893222f, 
    0.08853138f, -0.12524216f, 0.07907509f, 0.35734734f, 0.09942876f, 0.09094921f, -0.24804327f, -0.19381346f, 
    -0.06995593f, -0.25855368f, 0.12373070f, -0.16989110f, 0.03178104f, 0.07030627f, 0.06681719f, 0.19157024f, 
    0.19654293f, 0.25441429f, 0.35738185f, -0.11311163f, -0.21785694f, -0.10922207f, -0.05785832f, -0.09361546f, 
    -0.02949360f, -0.02982077f, 0.07296152f, -0.18905318f, -0.07800217f, 0.04075739f, -0.41012830f, -0.54653269f, 
    0.20670539f, -0.00810595f, -0.16036053f, 0.03702345f, 0.01623660f, -0.13057357f, 0.18641031f, -0.05665542f, 
    -0.06933793f, 0.42042333f, 0.12255118f, 0.08894446f, 0.04781622f, 0.06934359f, 0.30123076f, 0.02093277f, 
    -0.00698750f, 0.75768244f, 0.20673032f, -0.01488087f, 0.03149932f, 0.07845911f, 0.11964802f, 0.23097311f, 
    0.09653559f, -0.10302478f, 0.22312948f, 0.04421312f, 0.02774105f, 0.00476632f, 0.68044901f, 0.04525382f, 
    0.13311887f, 0.68633860f, -0.03232399f, -0.01143852f, 0.00171290f, -0.05726294f, -0.04646065f, -0.22142881f, 
    0.41280332f, 0.07921760f, 0.00899325f, 0.07351159f, 0.29462788f, 0.32157636f, -0.38789231f, 0.09337649f, 
    -0.09087387f, 0.30623516f, -0.29525915f, -0.09836651f, 0.24438573f, 0.04837668f, -0.03934429f, 0.01846175f, 
    0.17762089f, -0.21402435f, -0.00569159f, 0.06647222f, -0.01371018f, 0.08588270f, 0.14875966f, 0.23472112f, 
    0.02445157f, 0.06002273f, -0.18898304f, 0.47800702f, 0.06957625f, 0.16888788f, 0.11610087f, -0.01962908f, 
    0.04202503f, -0.00299583f, 0.25005803f, -0.38885820f, -0.10142854f, 0.22636326f, -0.05059841f, -0.05855370f, 
    0.08195137f, -0.33222204f, 0.43268463f, -0.02456982f, 0.12113267f, 0.14262526f, 0.03064395f, 0.18765882f, 
    -0.03510010f, -0.04332924f, 0.14259733f, -0.09946956f, 0.08129326f, 0.33138874f, 0.23160824f, 0.27094361f, 
    0.00356762f, -0.05590943f, -0.02677996f, -0.06980261f, 0.03077822f, 0.08748402f, 0.13881040f, 0.08214238f, 
    -0.01604838f, 0.04714644f, -0.06102570f, 0.13912724f, 0.00550615f, 0.03526969f, -0.22300330f, -0.08453108f, 
    0.08337852f, -0.09436929f, -0.00496062f, 0.19695854f, 0.27439380f, -0.05378585f, -0.03128511f, -0.15254879f, 
    -0.05845727f, 0.14926194f, 0.10803866f, 0.00143864f, 0.32560545f, -0.00651903f, 0.37960082f, -0.27922493f, 
    -0.08783278f, 0.02561349f, 0.13032991f, 0.28471741f, -0.26559719f, -0.14729136f, 0.01485475f, 0.06135565f, 
    0.05632333f, -0.09437659f, 0.04939135f, -0.24717847f, -0.00914634f, 0.35578445f, -0.10940877f, -0.08953547f, 
    -0.05132520f, -0.07076642f, 0.07349966f, -0.22131403f, -0.47760922f, 0.00909678f, -0.22220851f, -0.06817073f, 
    -0.35707694f, 0.17764989f, -0.39908087f, -0.05345276f, 0.12879714f, 0.09309038f, 0.04485352f, -0.36988455f, 
    0.06216783f, -0.15470995f, 0.43664846f, 0.26565507f, 0.07356831f, 0.20280661f, -0.07994344f, 0.38663402f, 
    -0.36030906f, 0.23610811f, -0.01443981f, -0.10178678f, -0.02134291f, 0.26822498f, 0.43339625f, 0.14228387f, 
    0.03534875f, 0.14855587f, 0.00249900f, 0.35976791f, -0.02021502f, 0.45439300f, -0.06128079f, -0.26631004f, 
    -0.29255489f, -0.11407736f, -0.00181673f, 0.17724726f, -0.15906788f, 0.01446462f, -0.03771476f, 0.01340105f, 
    0.02818919f, 0.28302428f, 0.03500537f, -0.23033154f, -0.02979071f, -0.07940077f, -0.12954645f, -0.18141091f, 
    -0.37072521f, -0.08475528f, 0.02199284f, 0.03766461f, 0.27977878f, 0.09154218f, 0.09615610f, -0.08135562f, 
    0.37771863f, 0.29797500f, -0.60626251f, -0.07819880f, 0.16096649f, 0.10589395f, 0.13287659f, -0.00352471f, 
    0.04023195f, 0.14939810f, -0.04598679f, 0.02615035f, -0.23324393f, -0.07564335f, -0.15978917f, -0.17154188f, 
    0.08002989f, -0.08268236f, -0.04697262f, 0.16097896f, 0.15518045f, 0.09355718f, -0.29019293f, 0.05487106f, 
    -0.06777897f, 0.08820851f, 0.02897332f, -0.22592564f, 0.20034754f, 0.28069636f, 0.26941025f, 0.06746523f, 
    0.14463291f, 0.05391521f, 0.07338971f, -0.04447369f, -0.03956604f, -0.03645710f, 0.06630377f, 0.21556433f, 
    0.00625921f, 0.02635626f, -0.09036120f, 0.18695517f, -0.03206753f, 0.05270228f, -0.16198748f, 0.31555128f, 
    0.21467158f, -0.29567873f, -0.26344651f, -0.02092098f, 0.25687897f, -0.14584735f, -0.15970857f, -0.14295758f, 
    0.18575278f, 0.10138708f, 0.07108772f, -0.05936817f, 0.05610029f, 0.18194786f, 0.05112529f, -0.24723908f, 
    0.15155272f, -0.23556492f, 0.07154458f, -0.22432680f, -0.12738992f, 0.08694892f, 0.45239669f, 0.17911273f, 
    0.00340739f, -0.08351988f, 0.21321468f, -0.04963226f, 0.25417444f, 0.00380792f, 0.15815799f, -0.00999493f, 
    -0.52800274f, 0.00090275f, 0.17013246f, 0.04725583f, 0.17020878f, -0.29997173f, 0.22475737f, 0.12667371f, 
    0.09577043f, 0.03009198f, 0.13581209f, 0.11469731f, 0.24298479f, -0.16911077f, -0.16994980f, -0.14306849f, 
    0.38831645f, -0.03285371f, 0.03028731f, -0.05257934f, 0.29090092f, 0.04071997f, -0.17141733f, -0.21864814f, 
    -0.01003356f, -0.33481324f, 0.01515847f, -0.04890336f, 0.15598956f, 0.08415207f, 0.19463807f, -0.32145742f, 
    0.05246348f, 0.23367141f, -0.02173244f, -0.35101497f, 0.08234012f, 0.05210034f, 0.50130838f, -0.01749835f, 
    0.08157906f, 0.02760028f, 0.13809074f, 0.32096750f, 0.09035488f, 0.34869587f, 0.19240654f, -0.07156218f, 
    0.02459446f, -0.20922661f, -0.30488247f, 0.06763911f, 0.15035456f, 0.19633622f, 0.24969697f, 0.06763471f, 
    0.03128040f, -0.06885261f, -0.08226314f, -0.07518657f, -0.02395705f, -0.07547037f, 0.00945253f, 0.03737786f, 
    0.02651871f, -0.00851878f, -0.02239734f, 0.00593976f, 0.02161468f, -0.07539438f, -0.04924200f, 0.00792903f, 
    -0.06669213f, -0.09160847f, 0.02061072f, -0.05166880f, 0.02957450f, 0.05748885f, -0.01157255f, -0.02994669f, 
    -0.10644806f, 0.03521093f, -0.06417480f, 0.04280805f, -0.04564316f, -0.05891186f, -0.10606510f, 0.08339556f, 
    -0.00208640f, 0.03778698f, 0.06626499f, -0.00339897f, -0.00295510f, -0.06035062f, 0.00950116f, 0.05364259f, 
    -0.00240823f, -0.01354038f, -0.05401437f, -0.04117770f, -0.05826609f, 0.03583210f, -0.05220148f, -0.02932747f, 
    -0.00736650f, 0.05591248f, -0.04340949f, -0.09459049f, 0.08099707f, 0.04096559f, -0.01206350f, 0.02530793f, 
    -0.11028850f, -0.05742099f, 0.03424807f, 0.00564872f, 0.05390773f, 0.00947829f, 0.06653251f, 0.04369248f, 
    -0.10020528f, 0.02351688f, -0.00068785f, 0.07052956f, -0.10618030f, -0.06650665f, 0.00363054f, -0.00414833f, 
    -0.02268461f, 0.06605685f, 0.02255904f, -0.04185992f, -0.01994567f, 0.01187593f, -0.11881006f, -0.06850229f, 
    -0.05741620f, -0.00265606f, -0.08084089f, -0.10189193f, 0.08272470f, -0.09746185f, -0.07470460f, -0.05464131f, 
    0.08613236f, -0.04649368f, -0.00253015f, 0.00845087f, -0.05442920f, 0.00939660f, -0.00591696f, -0.02022617f, 
    0.03329413f, -0.12980801f, 0.07360069f, -0.11396363f, -0.05179119f, -0.01243726f, -0.01878130f, -0.06796081f, 
    0.01465254f, -0.11197265f, 0.00678289f, -0.03584993f, -0.02819847f, 0.03580784f, 0.03996619f, -0.02819470f, 
    -0.04114189f, 0.03292967f, -0.00467013f, 0.02326980f, 0.00280610f, -0.08712283f, 0.04439554f, 0.01384637f, 
    0.02747702f, 0.02979529f, -0.05305215f, 0.02346180f, -0.05655663f, -0.00437263f, 0.05475293f, 0.00756438f, 
    0.04188898f, 0.16153693f, -0.11386496f, 0.04045101f, 0.45307344f, 0.17161208f, 0.13188812f, 0.06327453f, 
    -0.06445605f, 0.54209572f, 0.02031834f, -0.14515343f, -0.12418766f, 0.00220484f, 0.17257951f, 0.37965158f, 
    0.41970554f, 0.04476803f, -0.06239353f, 0.19751664f, -0.07275162f, -0.29050457f, -0.05236636f, -0.04483609f, 
    -0.04189391f, 0.35282367f, 0.12723230f, 0.11483981f, -0.09052581f, 0.01404292f, 0.23260252f, -0.01238152f, 
    -0.04626026f, 0.19445562f, -0.27540913f, -0.05371326f, -0.08994518f, 0.15258466f, 0.07302541f, -0.29092076f, 
    -0.33608517f, -0.08240797f, -0.06379161f, 0.16265671f, -0.04387267f, 0.21313411f, 0.74808270f, 0.32732883f, 
    0.26930749f, -0.34414074f, 0.12540708f, -0.03844561f, -0.01177453f, -0.08600890f, 0.25954476f, 0.33172908f, 
    0.19898319f, -0.22569759f, -0.00245689f, 0.39526469f, -0.15018491f, 0.18154791f, -0.07964017f, 0.15317512f, 
    0.28490222f, -0.02612423f, 0.06346832f, 0.08348787f, -0.02062912f, -0.01284551f, -0.52045816f, 0.20791054f, 
    0.18761002f, 0.08401098f, -0.21719365f, 0.13983350f, 0.12690772f, -0.09114625f, 0.05047071f, -0.17337587f, 
    0.18297936f, -0.07952309f, -0.04417522f, 0.11138835f, -0.12099703f, -0.25012326f, -0.08225650f, -0.24995513f, 
    -0.12758547f, 0.20807703f, -0.19441566f, -0.06771488f, -0.05598429f, -0.15966631f, 0.35334420f, 0.28617349f, 
    -0.07004764f, 0.25986010f, -0.04050948f, 0.04751152f, -0.14891461f, 0.09063890f, -0.09986430f, 0.08145653f, 
    0.10128587f, -0.29780450f, 0.12145237f, 0.49695414f, 0.01795449f, -0.07846764f, 0.09203685f, -0.07234601f, 
    0.15375854f, -0.05221279f, -0.21770933f, -0.07514691f, 0.08659422f, -0.03537117f, 0.12861031f, 0.06802509f, 
    0.09030315f, -0.02143572f, -0.07155473f, 0.06516366f, -0.09742763f, -0.05539522f, -0.20941846f, 0.09171467f, 
    0.04323027f, -0.13131286f, -0.07779199f, -0.06672385f, -0.29295892f, -0.00539221f, 0.00523517f, 0.00411262f, 
    0.10282347f, -0.07365361f, 0.29395372f, 0.19275710f, 0.25181344f, -0.03999067f, 0.10500028f, -0.16995527f, 
    -0.18500298f, -0.21970904f, 0.53495777f, -0.46485391f, 0.18594606f, 0.10383282f, 0.00930533f, 0.22751750f, 
    0.05681428f, -0.07195595f, -0.04051441f, -0.15215524f, -0.14711095f, 0.14814632f, -0.18643023f, 0.14802036f, 
    -0.01113006f, -0.02032428f, 0.05307429f, -0.06180863f, 0.52199847f, -0.04700566f, -0.05187182f, -0.76382655f, 
    0.24743444f, 0.28693134f, -0.35556126f, -0.16284643f, 0.10892180f, 0.16478206f, 0.14057146f, -0.21341553f, 
    -0.26549011f, 0.35514989f, 0.00313116f, 0.47305843f, 0.00755107f, -0.20558850f, 0.08714683f, 0.03870961f, 
    -0.02403655f, 0.19433109f, 0.10541093f, 0.10477187f, 0.09632506f, 0.05511145f, 0.27788347f, 0.13235155f, 
    0.19097489f, 0.10281759f, 0.49823147f, 0.06161093f, -0.17506768f, 0.10785973f, -0.08498146f, 0.26868936f, 
    -0.01933573f, -0.15413406f, 0.02610931f, -0.11910727f, 0.02527246f, 0.15369356f, -0.05630619f, 0.02553516f, 
    0.02959576f, 0.23591380f, 0.02637549f, 0.10629268f, 0.21833727f, 0.16763194f, -0.14240623f, -0.01567266f, 
    -0.22742136f, -0.18122780f, -0.24700363f, 0.12541944f, 0.03362201f, 0.22901352f, 0.04586984f, 0.27382863f, 
    0.15072893f, -0.08003784f, 0.06049067f, 0.24477161f, 0.09105460f, -0.06359184f, 0.51009911f, -0.04138200f, 
    -0.03554831f, 0.07751276f, 0.03196838f, -0.47441146f, 0.01781628f, 0.21680099f, 0.07315422f, 0.07977869f, 
    0.13778360f, 0.06835398f, 0.34204307f, 0.06212903f, 0.08666252f, -0.05358884f, 0.00092907f, -0.03545340f, 
    -0.34413081f, -0.19197629f, -0.19790415f, -0.09035867f, 0.09165776f, 0.11955913f, -0.08086304f, 0.05853976f, 
    0.05130272f, 0.06446041f, 0.03073413f, -0.17892998f, -0.27621514f, 0.17006053f, -0.08746639f, 0.02201098f, 
    -0.00354615f, -0.03065985f, -0.13240765f, -0.25886858f, 0.14061399f, 0.25627020f, 0.03426088f, 0.11406180f, 
    -0.27578932f, 0.25790268f, -0.55985445f, -0.23249489f, 0.11673293f, 0.15526797f, -0.01413532f, -0.00618145f, 
    0.08621534f, -0.12840620f, 0.10846604f, 0.11627100f, 0.46387503f, 0.09413562f, -0.03070598f, 0.10140353f, 
    -0.02609785f, 0.27313349f, -0.25507328f, 0.31983787f, 0.09035321f, 0.28242549f, 0.35732085f, 0.38091683f, 
    0.08846872f, -0.06703054f, 0.01862811f, -0.16214181f, -0.41122657f, 0.00263923f, -0.39232394f, -0.17840332f, 
    -0.07310473f, 0.22778946f, -0.09368359f, -0.20248504f, 0.05773479f, 0.20022392f, -0.29173392f, 0.07662923f, 
    -0.20088580f, 0.13704073f, -0.10722239f, -0.21893477f, -0.02279532f, 0.03351722f, -0.04108964f, -0.16314183f, 
    -0.16169113f, 0.14477539f, -0.11186127f, -0.03515861f, 0.21252082f, 0.16525944f, 0.17934133f, -0.24990769f, 
    -0.21575552f, 0.19836281f, 0.08094472f, 0.28520384f, 0.19472192f, 0.08993903f, 0.15062818f, 0.41323537f, 
    -0.22976921f, -0.11640997f, -0.10444868f, 0.00473240f, 0.08547499f, -0.10407405f, 0.36874822f, -0.21300562f, 
    0.24200734f, 0.14663298f, 0.42982304f, 0.29950625f, 0.22124836f, 0.39340982f, -0.36004177f, -0.35503131f, 
    -0.11442316f, 0.07494921f, -0.01415351f, 0.21260016f, -0.14807659f, -0.05409811f, -0.39449263f, -0.63156915f, 
    -0.05761662f, 0.15202330f, 0.07269956f, -0.31880695f, 0.41390240f, 0.08972821f, 0.21527283f, 0.10955184f, 
    -0.17455746f, -0.01850063f, 0.15498963f, 0.07610418f, 0.02232211f, 0.06377769f, -0.29126200f, 0.06906477f, 
    0.16080649f, 0.48761311f, -0.23109607f, -0.08280723f, 0.20185433f, 0.06309570f, 0.32365558f, 0.23893490f, 
    -0.03725670f, -0.09626082f, -0.47486380f, -0.21826060f, -0.17339717f, 0.05784944f, -0.06378211f, -0.01498712f, 
    -0.06046897f, 0.28020522f, 0.05408997f, 0.01438871f, -0.22343862f, -0.16338041f, 0.26054555f, 0.08640372f, 
    0.24653754f, 0.04615977f, 0.44469896f, -0.02525950f, -0.16374718f, 0.30931297f, 0.12126677f, -0.11451258f, 
    0.09103625f, -0.15735811f, 0.21147770f, 0.04773371f, -0.39195901f, 0.08087590f, -0.08661268f, 0.00886621f, 
    0.06609667f, 0.10631525f, -0.13225915f, 0.14248472f, -0.04696045f, 0.20596087f, 0.41737625f, 0.15516844f, 
    0.19391222f, 0.16645721f, -0.00394299f, -0.45746472f, -0.11243925f, 0.17067567f, 0.40916371f, 0.12353873f, 
    -0.29831645f, -0.26518178f, -0.41261753f, 0.12349412f, 0.00381039f, -0.33624935f, -0.18381491f, -0.05122517f, 
    -0.18600194f, -0.61521333f, -0.09334932f, 0.13493605f, 0.30815718f, -0.16211380f, -0.06124287f, -0.34792486f, 
    0.48705280f, -0.04163605f, -0.20471993f, 0.06784793f, 0.10499450f, -0.06622017f, -0.88157016f, 0.08027187f, 
    -0.36496305f, -0.70365858f, -0.24069893f, 0.12322821f, 0.26617295f, 0.39182267f, 0.19197346f, 0.07005498f, 
    0.26682258f, 0.20462453f, 0.01542601f, -0.20768575f, -0.22800952f, -0.54148263f, 0.03978804f, -0.24104206f, 
    0.17319712f, 0.25934234f, -0.07274463f, 0.12599619f, 0.24979661f, 0.10576932f, 0.61465281f, 0.39326942f, 
    -0.24335366f, 0.39508060f, 0.06029061f, -0.06758191f, -0.24981564f, -0.01915303f, -0.16735929f, -0.04625509f, 
    0.05430418f, -0.00733490f, 0.16928226f, 0.76987189f, 0.07719263f, 0.07961149f, -0.08268493f, 0.12640595f, 
    0.06140528f, 0.07018164f, -0.30757877f, -0.03968663f, -0.05057494f, 0.04208723f, 0.04106142f, -0.05589007f, 
    0.25379610f, 0.46487069f, -0.17364033f, -0.06120276f, -0.15244021f, -0.05770013f, -0.29730940f, 0.04254262f, 
    -0.02815385f, 0.04706203f, 0.03482008f, -0.00021404f, -0.03659214f, -0.02702186f, -0.02127968f, 0.02910447f, 
    -0.09945522f, -0.00980294f, 0.04635398f, -0.09619594f, 0.07412937f, 0.03607733f, -0.04075588f, 0.05271413f, 
    0.05749527f, -0.01917255f, -0.01420704f, 0.03624194f, 0.01148846f, -0.06737264f, -0.01616364f, -0.01859232f, 
    -0.03541627f, -0.05987223f, -0.08636975f, -0.00068964f, 0.05168634f, -0.08889953f, -0.01679667f, -0.02794654f, 
    0.01879061f, -0.05086661f, -0.00602782f, -0.02013956f, -0.04631908f, -0.04783614f, -0.02491314f, -0.04788278f, 
    0.00654354f, 0.06789105f, -0.01883260f, -0.00236627f, -0.05551301f, 0.02767160f, -0.04739841f, -0.04311828f, 
    -0.08021574f, -0.00228374f, -0.03169437f, -0.06252234f, -0.02789173f, 0.06132858f, -0.02314350f, 0.05025956f, 
    -0.03661096f, 0.05203737f, -0.05801853f, 0.03691620f, 0.00325730f, 0.00077961f, 0.06289998f, -0.03585487f, 
    -0.08075850f, -0.02990358f, 0.04620363f, 0.00346548f, -0.02175298f, -0.00171082f, 0.00080540f, -0.09996488f, 
    -0.00659635f, 0.02251662f, -0.08523247f, 0.02830987f, -0.01515328f, 0.00553955f, -0.10181133f, -0.10836671f, 
    -0.05281596f, -0.02995315f, -0.10782504f, -0.05919314f, -0.04008620f, -0.06068460f, -0.07946545f, 0.01266440f, 
    -0.03274526f, -0.06994697f, 0.00645610f, -0.02668838f, -0.02872581f, 0.00854287f, -0.08665853f, -0.06096352f, 
    0.06902776f, 0.01286283f, -0.04321679f, -0.00597852f, 0.08332410f, -0.07541704f, -0.10131082f, -0.03994989f, 
    0.02110966f, 0.00067397f, 0.01283376f, -0.07116013f, 0.06695150f, -0.08043645f, -0.04610519f, -0.04018722f, 
    0.06353427f, -0.04744308f, 0.06864540f, 0.02225456f, -0.06576356f, -0.00820308f, 0.07481977f, -0.01663001f, 
    -0.05255390f, 0.05255650f, -0.02530609f, 0.03933048f, -0.05279529f, -0.03641012f, -0.08602148f, -0.02278025f, 
    0.00577207f, -0.01670526f, -0.01339436f, -0.02692084f, 0.02474472f, -0.09538171f, 0.02401131f, -0.05789809f, 
    -0.05736490f, 0.04967515f, 0.03367775f, -0.04667715f, 0.04716362f, -0.03451435f, 0.01112239f, -0.06394463f, 
    0.00002217f, 0.01879223f, 0.01994612f, -0.07508337f, -0.08579067f, -0.10436361f, -0.08652090f, -0.10170100f, 
    0.01973239f, -0.02491669f, 0.03882864f, -0.01493595f, 0.07007317f, -0.07553211f, -0.07067538f, -0.04169657f, 
    0.04649513f, -0.04156319f, -0.07113492f, -0.03578991f, 0.03845286f, 0.06408438f, -0.01234672f, 0.00862036f, 
    -0.04066797f, -0.10017031f, 0.02381509f, -0.03214520f, 0.07136177f, 0.00875396f, -0.05869081f, 0.01200706f, 
    -0.03890826f, 0.06809941f, -0.01093569f, -0.06536390f, -0.05365911f, 0.02400925f, -0.03136038f, 0.00632962f, 
    -0.00468735f, -0.02680336f, 0.05804843f, 0.01838912f, 0.07094749f, 0.03155769f, -0.04273091f, 0.04709359f, 
    0.03389344f, -0.03576070f, 0.03909708f, -0.03738528f, -0.03452989f, -0.07886551f, -0.05730402f, 0.03304228f, 
    0.03566459f, 0.08190738f, -0.00444129f, -0.06205762f, -0.06463863f, -0.07655500f, -0.04020332f, -0.01558829f, 
    -0.03912429f, 0.06561930f, -0.03725147f, 0.01141140f, -0.01748021f, -0.08825263f, -0.09461039f, 0.00554425f, 
    0.08225564f, 0.03338248f, 0.04600547f, 0.04570444f, 0.00319157f, 0.00355092f, 0.01751604f, -0.01932764f, 
    -0.06127957f, 0.02092476f, -0.04295667f, -0.09823344f, -0.09654500f, -0.06141694f, -0.07388247f, -0.02980697f, 
    -0.02688411f, 0.02022361f, -0.03059634f, -0.04223590f, 0.02987003f, -0.07222670f, -0.05148631f, -0.02773685f, 
    -0.04622616f, 0.06348958f, -0.05862023f, 0.02841239f, 0.00386318f, 0.05272442f, -0.05830519f, -0.01668241f, 
    0.05710636f, 0.01361109f, 0.02059650f, -0.07642056f, 0.03091636f, 0.02079904f, 0.03962780f, -0.01055733f, 
    -0.05785889f, -0.04418884f, 0.15240677f, -0.18599245f, -0.18216455f, 0.09550108f, -0.27339926f, -0.09945101f, 
    0.00381723f, -0.12291201f, 0.12674130f, 0.25186083f, 0.08951119f, 0.26900786f, -0.20380719f, -0.13223769f, 
    -0.08301479f, -0.29649743f, 0.00490871f, -0.38373500f, 0.23462267f, 0.33639580f, -0.00196141f, 0.20078053f, 
    0.05847257f, 0.18888411f, 0.12063511f, -0.24565956f, -0.19340700f, -0.24649540f, 0.02200558f, -0.03184367f, 
    -0.01704483f, -0.12393257f, 0.23916405f, -0.22928970f, -0.02634461f, 0.11720151f, -0.23714788f, -0.03184740f, 
    0.44822794f, -0.01512658f, 0.12440707f, 0.15630397f, 0.15552378f, -0.29353151f, 0.32718092f, -0.05504112f, 
    0.31841365f, 0.12168203f, 0.02588836f, -0.08751410f, 0.07034674f, -0.06366429f, 0.48768333f, 0.08373742f, 
    -0.05371169f, -0.18813759f, 0.08302679f, 0.02859401f, 0.14874656f, 0.07298556f, 0.37543079f, 0.40390292f, 
    -0.19119476f, -0.03869646f, 0.21059631f, -0.05565532f, -0.05422260f, 0.00836713f, 0.18358123f, 0.05773427f, 
    -0.42159554f, 0.26903120f, -0.02688492f, 0.09972382f, 0.08010139f, -0.10004941f, 0.11156785f, -0.13643572f, 
    0.60194862f, 0.16599786f, 0.15234321f, 0.09251975f, 0.39958864f, -0.24579142f, -0.17545788f, -0.07996315f, 
    -0.13988797f, 0.50049388f, 0.04365291f, -0.01213285f, 0.17995669f, 0.11363464f, -0.11100202f, -0.03034641f, 
    0.19216920f, -0.18884835f, 0.04574354f, 0.15048449f, -0.03618197f, 0.04062202f, 0.16737610f, -0.34069601f, 
    0.06481034f, 0.13342638f, -0.29718626f, 0.54643804f, -0.08356991f, 0.03438215f, 0.21322447f, -0.29749480f, 
    -0.27863234f, -0.07720278f, 0.14766330f, -0.00068140f, -0.03023357f, 0.15988940f, -0.06048049f, -0.01349938f, 
    0.89273351f, -0.11175340f, 0.16525270f, 0.11404513f, 0.09400240f, 0.25366929f, -0.02402440f, 0.08248692f, 
    0.05679569f, -0.00344138f, 0.04027425f, -0.08724802f, -0.09220827f, -0.12178032f, 0.06331037f, -0.05614528f, 
    -0.12060616f, 0.04288634f, -0.09268758f, -0.08559155f, -0.05822642f, -0.11220308f, -0.01598310f, 0.06866621f, 
    -0.09293272f, -0.08292071f, 0.06838270f, 0.05487931f, -0.00210498f, -0.10723288f, -0.01870669f, -0.00590354f, 
    -0.02047482f, 0.01591777f, 0.03562650f, -0.07600012f, 0.01072847f, -0.00089671f, -0.05601934f, -0.07934748f, 
    0.01017336f, -0.11154686f, 0.01352402f, 0.06762355f, 0.01523446f, -0.02297266f, -0.09750529f, -0.03060991f, 
    0.03182703f, -0.03490309f, 0.11047766f, -0.09475232f, 0.03855623f, -0.08733194f, 0.03026655f, 0.01532213f, 
    -0.05151175f, -0.00322081f, -0.09741706f, -0.10638385f, -0.08402855f, -0.02107599f, 0.03466914f, -0.08539480f, 
    -0.08564343f, 0.07203092f, -0.04296573f, 0.00596684f, 0.01289170f, 0.05290414f, -0.08206660f, -0.01258481f, 
    -0.06108069f, -0.11379190f, -0.03957357f, 0.04118863f, -0.00123087f, 0.02011560f, -0.11343595f, -0.05189854f, 
    0.03112642f, 0.02705389f, -0.07294147f, -0.05857441f, 0.01879396f, -0.09322723f, 0.01483096f, 0.03152690f, 
    -0.04995042f, -0.02691364f, -0.07927159f, -0.07714772f, 0.00179383f, -0.06336723f, -0.04000076f, -0.04183541f, 
    0.07998774f, 0.03138236f, 0.01841978f, -0.04427393f, -0.09206649f, -0.02132186f, 0.03370726f, -0.12956566f, 
    0.01919172f, 0.04156559f, 0.06558879f, -0.07246494f, -0.08389603f, 0.03590433f, 0.00770833f, 0.07339119f, 
    -0.02783204f, 0.03161893f, -0.08035582f, -0.05022215f, -0.02532802f, -0.02860599f, 0.00097579f, -0.05511450f, 
    0.03721695f, 0.03009136f, -0.06353089f, -0.05807682f, -0.10559624f, -0.05970669f, -0.00896155f, 0.03740644f, 
    -0.00915061f, 0.03403344f, -0.02711268f, -0.08386559f, 0.01188672f, -0.03499270f, 0.02816109f, 0.01369308f, 
    -0.06988061f, -0.07166464f, 0.39862916f, -0.17540543f, -0.39758977f, 0.12933978f, -0.12092356f, -0.06564491f, 
    0.18791220f, -0.05974474f, 0.24945302f, 0.14382502f, 0.35565034f, 0.06785194f, 0.13304484f, -0.00041695f, 
    -0.10780086f, -0.17762096f, -0.05290489f, -0.43314803f, 0.29481602f, 0.00124638f, 0.09939941f, 0.07731939f, 
    -0.12153553f, 0.04015893f, 0.03329762f, -0.25580367f, 0.00733013f, 0.03583800f, 0.02901512f, 0.15562932f, 
    -0.04851167f, -0.06041599f, 0.31184390f, -0.32342899f, 0.07683309f, 0.08821801f, -0.30293646f, 0.10364593f, 
    0.47322017f, 0.16264263f, -0.13036746f, 0.26801428f, 0.20700963f, -0.09575202f, 0.32876217f, 0.13877101f, 
    0.17973648f, 0.35128021f, -0.00699809f, 0.08412711f, 0.13558255f, -0.07968677f, 0.54098690f, 0.20295718f, 
    -0.28914616f, -0.01240308f, -0.15851912f, 0.05238241f, 0.19883446f, 0.11725265f, 0.45577693f, 0.36251196f, 
    -0.23468447f, 0.07153723f, 0.18553174f, 0.08235027f, -0.08226353f, 0.09221221f, 0.63659078f, 0.04300691f, 
    -0.49247590f, 0.43336031f, -0.09197167f, 0.00849434f, -0.07891539f, 0.05716881f, 0.05129103f, -0.04157776f, 
    0.35617927f, 0.17615309f, 0.13934292f, 0.02802871f, 0.38984132f, 0.02599054f, -0.48576584f, 0.12834230f, 
    -0.12636822f, 0.19980530f, 0.20990354f, -0.44389072f, -0.06734373f, -0.04514088f, 0.00386230f, 0.12536533f, 
    0.26655212f, -0.02311780f, -0.00512272f, -0.04162929f, -0.39253944f, 0.07234947f, 0.17562227f, -0.17529063f, 
    0.06186039f, -0.25576285f, -0.22355142f, -0.60314119f, 0.07393263f, 0.13982549f, 0.09560080f, -0.02513448f, 
    -0.02424065f, -0.02883806f, 0.41359749f, 0.60890138f, 0.34138772f, -0.01637729f, -0.37263790f, 0.08726814f, 
    -0.16963814f, -0.25130078f, 0.25868204f, 0.09388006f, 0.07573906f, 0.20829317f, -0.00252481f, 0.07476545f, 
    0.04721268f, -0.07177676f, -0.00370733f, -0.01006775f, -0.07966784f, -0.05310177f, -0.10890824f, -0.11884212f, 
    0.00342900f, 0.02297696f, -0.08864163f, 0.03207994f, 0.05275667f, -0.05195555f, -0.02040541f, 0.03966461f, 
    -0.04197869f, 0.04536113f, -0.04102277f, 0.02993812f, 0.03820178f, 0.05542228f, 0.01163196f, -0.02556141f, 
    -0.01015160f, -0.02421111f, 0.06442339f, -0.04089106f, 0.05206511f, -0.07779739f, -0.07177459f, -0.07302141f, 
    0.03619672f, 0.00736093f, -0.05292288f, 0.04239705f, 0.01839742f, 0.04603352f, -0.09263628f, -0.07092005f, 
    -0.04198978f, -0.08077435f, -0.02436025f, -0.04648481f, 0.02625308f, 0.04377786f, -0.07076307f, -0.06144263f, 
    0.06016582f, -0.01705514f, -0.02783581f, -0.04021985f, -0.02329123f, -0.10397054f, 0.05160416f, -0.03949540f, 
    -0.06596169f, 0.01823710f, -0.12140858f, -0.06596249f, 0.02860229f, -0.02117006f, -0.05220236f, 0.06922786f, 
    -0.01635349f, -0.06050631f, -0.06268920f, 0.00572609f, -0.03916349f, 0.02209859f, 0.08686446f, -0.06011497f, 
    -0.02746622f, -0.01482375f, -0.01100216f, -0.03417480f, -0.05541912f, 0.01266906f, -0.10052888f, -0.03162210f, 
    0.01101192f, -0.00665950f, -0.00108507f, -0.09576561f, 0.04216820f, -0.00286276f, -0.01505883f, -0.04167815f, 
    -0.05335918f, -0.08344533f, -0.06561076f, 0.03413021f, -0.02529807f, -0.02486267f, -0.07914628f, -0.00921054f, 
    -0.09393435f, 0.00861520f, -0.05288281f, -0.03564324f, 0.05047354f, 0.03777960f, -0.09429496f, -0.09973440f, 
    -0.07941177f, -0.09573258f, -0.04713938f, 0.06423981f, -0.06579617f, 0.03495109f, 0.06220906f, -0.00409339f, 
    -0.06432046f, -0.01266424f, -0.04437130f, -0.09366442f, 0.00178788f, -0.07161371f, 0.04783698f, -0.08531873f, 
    -0.03996326f, -0.04517710f, -0.08552413f, -0.01389458f, 0.00672524f, -0.01450762f, -0.12228162f, -0.09409364f, 
    0.02211159f, 0.04211381f, 0.32965869f, 0.02755744f, 0.07336019f, -0.07745124f, 0.06514250f, 0.07846533f, 
    0.02325422f, 0.08752677f, -0.14029646f, 0.21670006f, 0.20933354f, 0.18083955f, -0.07609216f, -0.06905806f, 
    0.13938627f, -0.16768657f, 0.34283859f, -0.03400699f, 0.17467643f, -0.12002385f, 0.00666003f, 0.11200746f, 
    -0.05798426f, 0.30554190f, 0.00946096f, -0.11491325f, -0.00451383f, -0.07321234f, 0.16590989f, -0.02746535f, 
    0.04302220f, -0.24244416f, 0.20782737f, -0.09549043f, -0.36294141f, 0.10876530f, -0.19840127f, 0.25699368f, 
    -0.05627466f, 0.21579829f, 0.24215133f, 0.28073803f, 0.10427168f, -0.04971088f, 0.13922569f, 0.13588205f, 
    0.28557557f, -0.21256849f, 0.05295392f, -0.25794631f, -0.00241931f, -0.11739174f, 0.43255883f, 0.28704002f, 
    0.10857866f, -0.34151369f, 0.01813544f, 0.20565727f, 0.42012674f, 0.27161768f, 0.06457032f, 0.32137036f, 
    -0.19804351f, 0.03146996f, -0.07045971f, -0.09084284f, -0.09316570f, 0.04689594f, 0.40915570f, 0.11407032f, 
    0.00105857f, 0.99489123f, -0.01818686f, -0.03623747f, -0.01479908f, -0.09565824f, -0.13242230f, -0.04476263f, 
    0.21933472f, -0.02600300f, 0.19004929f, 0.10239977f, 0.27947915f, -0.13395840f, -0.24264134f, -0.16618174f, 
    -0.19669452f, 0.44857746f, 0.02645783f, -0.14251325f, -0.08609109f, -0.34236985f, -0.03366424f, -0.48405951f, 
    0.16783001f, -0.02080505f, 0.03558315f, 0.02003902f, 0.12584278f, 0.01055230f, -0.05959588f, 0.03517370f, 
    0.14977488f, -0.20277058f, -0.16216673f, 0.15073234f, 0.02973453f, 0.00319499f, 0.01621873f, -0.00271672f, 
    -0.09107323f, 0.01692867f, 0.18421952f, -0.38735744f, -0.16751830f, -0.01890710f, -0.02826892f, -0.03792788f, 
    0.00889123f, -0.19857305f, 0.57382303f, 0.03832205f, -0.03936436f, 0.19407374f, -0.06963501f, -0.08131154f, 
    0.07668894f, 0.02895366f, -0.03480573f, -0.00052008f, 0.00691910f, 0.03049569f, -0.05572748f, -0.04693071f, 
    0.01043691f, -0.00562152f, -0.09680007f, -0.04433667f, 0.08734269f, 0.00912634f, 0.02382026f, -0.05514286f, 
    -0.08265319f, -0.07438095f, 0.08407515f, 0.02545670f, 0.02363492f, 0.05518271f, -0.01911460f, -0.07092088f, 
    0.03580018f, 0.01627800f, -0.03392007f, -0.05984343f, -0.06180859f, -0.10063983f, -0.02588668f, -0.11793857f, 
    -0.03266563f, 0.02929195f, 0.03030126f, 0.01295912f, 0.02648166f, 0.07139746f, -0.06371817f, -0.06723069f, 
    -0.07723258f, -0.02138904f, 0.03403271f, -0.05989855f, 0.01779336f, -0.03258173f, -0.03808588f, -0.00419667f, 
    -0.08675265f, -0.06092603f, -0.05604729f, -0.03311367f, 0.08647402f, -0.04985480f, 0.03720639f, -0.05547208f, 
    -0.10959219f, -0.05221104f, -0.07901493f, 0.03622298f, 0.02146283f, -0.03934453f, -0.07708885f, 0.03573869f, 
    0.03281197f, -0.10042696f, -0.12645461f, -0.06442895f, -0.03799358f, -0.01523428f, 0.05667925f, -0.02460430f, 
    0.00286130f, -0.01373638f, -0.01897738f, 0.05803522f, -0.02896103f, -0.06479586f, -0.03111776f, 0.00186702f, 
    0.07230748f, -0.09882351f, 0.01103990f, 0.00045464f, 0.02469057f, 0.01684953f, 0.01582911f, -0.11826753f, 
    0.04633188f, -0.09055231f, -0.03924649f, -0.00720525f, -0.10598665f, -0.04292436f, -0.04825504f, -0.01949504f, 
    -0.03104365f, -0.01456861f, -0.08728699f, -0.03624012f, -0.04616531f, -0.07751001f, -0.11097781f, 0.00910719f, 
    -0.10930813f, -0.06156132f, -0.05192804f, 0.06756951f, -0.02890178f, 0.05203796f, 0.04608664f, -0.05453942f, 
    -0.08860533f, -0.05074198f, -0.08218867f, -0.04742734f, -0.09204308f, 0.05984523f, 0.03562886f, 0.06121068f, 
    0.04465393f, 0.03516220f, -0.05413395f, -0.04079814f, -0.09499530f, -0.03105927f, -0.00910200f, 0.00844971f, 
    -0.04616221f, 0.00682609f, -0.09902542f, 0.02509548f, 0.08422611f, 0.13437234f, 0.09837960f, 0.01263147f, 
    0.13939892f, 0.23541650f, 0.06872697f, -0.18234111f, -0.21923664f, -0.02738313f, 0.05332942f, 0.30718932f, 
    0.20614748f, 0.05398314f, 0.04690675f, 0.25597402f, 0.04751136f, -0.23176493f, -0.13120480f, -0.11911127f, 
    0.00717353f, 0.31599969f, 0.08837917f, 0.19477627f, -0.05180214f, -0.10395619f, 0.00899465f, -0.17160004f, 
    0.01498176f, 0.27038875f, -0.13936952f, -0.01518652f, 0.14720915f, 0.22086470f, 0.00490125f, 0.03934516f, 
    -0.04334272f, -0.14915989f, -0.12944373f, 0.18796264f, -0.08820541f, 0.20510228f, 0.51946890f, 0.07315206f, 
    0.19476242f, -0.09416824f, -0.00465579f, 0.05034956f, -0.03250703f, 0.04626415f, 0.12741099f, 0.15302899f, 
    0.05952983f, -0.06913511f, -0.03775924f, 0.24562603f, -0.21307646f, 0.12145653f, -0.00995453f, 0.16701631f, 
    0.03770393f, 0.11422677f, -0.14055137f, 0.02289293f, 0.13690232f, 0.07432136f, -0.13566968f, 0.15201196f, 
    0.06464832f, -0.01341533f, 0.01560024f, 0.31075233f, 0.11695430f, 0.01403853f, -0.03747033f, 0.02637576f, 
    -0.20303322f, 0.16998795f, -0.09991980f, -0.00306586f, 0.03723562f, -0.27719134f, 0.07618640f, -0.16361780f, 
    -0.15580091f, -0.17881165f, -0.22641218f, 0.06596964f, -0.09002152f, -0.07550290f, -0.05856884f, 0.06438056f, 
    -0.07679652f, 0.02379061f, 0.01643886f, 0.31997165f, -0.14821610f, 0.10856817f, -0.04943703f, -0.13436073f, 
    0.08589399f, -0.23900786f, 0.10747075f, -0.70635939f, 0.22341941f, 0.15064183f, 0.14745969f, -0.03087588f, 
    0.00069636f, 0.03213046f, 0.07035145f, 0.16157261f, 0.45880258f, -0.05357749f, 0.02344472f, -0.06089071f, 
    -0.07253154f, 0.06478760f, -0.39886314f, 0.00939492f, 0.19559239f, -0.02524618f, -0.03007267f, 0.16071965f, 
    -0.06197642f, -0.23719537f, 0.15927215f, 0.08179890f, 0.15835448f, 0.12065153f, 0.13712992f, 0.04760678f, 
    0.12215731f, -0.18988042f, 0.17988832f, -0.02095910f, -0.10447913f, 0.08625325f, -0.24068454f, -0.20548582f, 
    -0.51960617f, -0.17074051f, -0.06422478f, -0.11964635f, 0.35779554f, -0.26516345f, -0.15998524f, 0.01511587f, 
    -0.04115948f, 0.36354581f, 0.31349382f, 0.13492051f, 0.24304573f, -0.25521830f, 0.13853779f, -0.11390981f, 
    -0.04382955f, 0.15737541f, -0.04332362f, 0.08797412f, 0.01250201f, -0.05366264f, -0.17339069f, -0.01017856f, 
    -0.17565715f, 0.42551288f, -0.07422200f, 0.07282031f, 0.16138966f, 0.24061094f, -0.35491791f, -0.07037104f, 
    0.17221649f, -0.05525429f, 0.09943949f, -0.05139966f, 0.02512864f, 0.05111219f, -0.12640435f, -0.04388988f, 
    -0.00811108f, -0.34151912f, -0.05940549f, 0.21533093f, 0.38587481f, 0.01195802f, 0.09268653f, 0.18129005f, 
    0.00296794f, 0.19674365f, -0.00408983f, 0.08967803f, 0.05311093f, 0.03516442f, -0.08344352f, 0.20078734f, 
    0.21337229f, 0.03915061f, -0.03199409f, -0.45865011f, -0.06169853f, -0.20706312f, -0.14539647f, 0.30458662f, 
    -0.42062879f, 0.03988498f, -0.05415842f, 0.09936340f, 0.13212332f, 0.08542192f, 0.15852399f, -0.01314804f, 
    -0.32600102f, -0.35645336f, -0.12990658f, -0.01958479f, -0.34789762f, -0.00244501f, -0.39397994f, -0.24923998f, 
    -0.05136330f, -0.22311451f, 0.03003041f, 0.03805560f, 0.08900172f, -0.18048517f, 0.10013957f, 0.25645772f, 
    0.06791680f, -0.15528987f, -0.02851928f, -0.52829880f, 0.21114498f, 0.03619981f, 0.13680185f, 0.20258570f, 
    -0.15362918f, -0.05183928f, -0.06393278f, 0.12165641f, -0.08763191f, -0.36092073f, 0.10995521f, 0.08158717f, 
    0.38263920f, 0.13727675f, 0.12782608f, 0.00271347f, -0.05314804f, 0.06580798f, 0.13158324f, -0.03839325f, 
    -0.03655447f, 0.01763536f, 0.38949463f, 0.06602388f, -0.25773570f, 0.25585425f, 0.00573577f, -0.10786053f, 
    -0.11861424f, 0.22641124f, -0.00931975f, -0.25704765f, 0.35532349f, -0.00856140f, 0.27365106f, 0.08688676f, 
    0.08632260f, 0.19825682f, -0.13867635f, -0.03074716f, 0.09157670f, -0.06259667f, 0.16493316f, -0.10029725f, 
    -0.16481695f, -0.01485025f, 0.11448196f, -0.19859096f, 0.16828595f, 0.16584721f, 0.35883388f, 0.40715936f, 
    -0.02436570f, 0.12381815f, 0.42005512f, -0.09117833f, 0.01565830f, 0.25049293f, 0.18043444f, 0.38534948f, 
    0.09521985f, -0.04215654f, 0.22974186f, 0.15649749f, -0.14606185f, 0.06765644f, -0.18043262f, 0.30749583f, 
    0.24184901f, 0.02313959f, 0.04997916f, 0.12467880f, -0.06911676f, 0.01295578f, 0.32147631f, 0.56614763f, 
    -0.20012961f, -0.29856029f, -0.18331259f, 0.34591997f, 0.32758269f, 0.11696403f, -0.01028409f, 0.22279656f, 
    0.01670618f, -0.04190763f, 0.23981765f, 0.02706099f, -0.08754934f, 0.11278049f, 0.48678008f, 0.21693262f, 
    -0.50241721f, 0.67158771f, -0.34817278f, 0.17208478f, 0.03021681f, 0.14894901f, 0.19604214f, 0.04027382f, 
    0.25602269f, -0.11447734f, 0.05434538f, 0.00815268f, 0.12052081f, -0.15807559f, 0.13668500f, 0.09408379f, 
    -0.04218141f, 0.55768365f, 0.43510884f, -0.17452416f, -0.05274981f, -0.04655581f, 0.05238551f, 0.34382519f, 
    0.08298627f, 0.29629254f, 0.02592887f, 0.03464607f, -0.33707872f, -0.09390376f, -0.45861882f, -0.33856782f, 
    0.02350900f, -0.24442932f, 0.05801983f, 0.53878158f, 0.13206448f, 0.15218216f, 0.19020025f, 0.16025606f, 
    -0.09519682f, -0.05674853f, -0.17605242f, -0.15011162f, -0.00946579f, -0.12777176f, -0.39488378f, 0.08798276f, 
    0.14843956f, 0.31702456f, 0.24858545f, -0.05196897f, 0.06844715f, -0.07482351f, 0.08722705f, 0.10783985f, 
    0.04108674f, 0.04597893f, -0.08036195f, -0.06357348f, 0.04050339f, -0.00932979f, 0.03631364f, -0.05564500f, 
    0.00770624f, 0.00015110f, -0.10098406f, 0.01122500f, -0.01322589f, -0.05858440f, -0.07261151f, 0.02822529f, 
    -0.01302334f, 0.04185714f, 0.08594774f, -0.07408871f, -0.05346149f, -0.08700891f, -0.09994876f, 0.06513733f, 
    -0.00515946f, -0.09802239f, -0.09458484f, -0.00752676f, -0.09080528f, 0.05800838f, -0.05309998f, -0.04062922f, 
    0.00148844f, -0.04551503f, -0.07816643f, 0.07009219f, -0.03266691f, 0.05769019f, -0.00424659f, 0.00164696f, 
    0.00600550f, -0.00953506f, -0.04380524f, -0.00682784f, -0.07489766f, -0.00478080f, 0.02626332f, -0.03777444f, 
    0.04621354f, 0.02311401f, -0.05740846f, -0.01457880f, 0.06924324f, -0.05833844f, 0.04463507f, 0.05319203f, 
    0.00590548f, 0.03314514f, 0.07256208f, -0.02804337f, 0.01649412f, 0.03130176f, 0.05491680f, 0.01016875f, 
    -0.02262395f, -0.07125849f, 0.04364683f, -0.00008143f, -0.00239115f, 0.02770099f, 0.03327075f, -0.06206143f, 
    0.06394804f, 0.03588180f, -0.03496140f, -0.05813440f, -0.07912274f, -0.08987946f, -0.05320385f, 0.04021424f, 
    0.05010876f, -0.03461181f, -0.09549791f, -0.07110389f, -0.04568705f, -0.06349225f, -0.08368497f, 0.03249326f, 
    -0.06557143f, -0.00933208f, -0.08025373f, 0.01637750f, 0.03031906f, -0.04737919f, 0.06086065f, 0.05445354f, 
    -0.01335568f, 0.00827829f, 0.00116731f, 0.06387103f, -0.02759407f, -0.08785111f, -0.07573240f, -0.05785917f, 
    0.05086985f, -0.07293394f, 0.02801527f, 0.01743556f, -0.08290707f, -0.06503118f, 0.03147979f, -0.09087802f, 
    0.00789638f, -0.01926457f, 0.04040848f, -0.07221068f, -0.06058717f, -0.09869090f, -0.02566149f, -0.03635716f, 
    -0.02408423f, -0.01120518f, -0.07927196f, -0.00139297f, -0.05177681f, 0.06165650f, -0.08275304f, -0.00923602f, 
    0.00570272f, 0.18810354f, -0.06953177f, 0.05417177f, -0.27289844f, -0.35349709f, -0.00180218f, -0.17167056f, 
    -0.00274549f, 0.16152503f, 0.01444511f, 0.09772227f, 0.06064855f, -0.13375540f, -0.05864569f, 0.02808210f, 
    0.16301800f, 0.19286540f, -0.01844168f, -0.06068702f, -0.03420706f, 0.18493937f, 0.38081732f, -0.06537881f, 
    -0.09079394f, -0.25155923f, -0.20037287f, -0.15730584f, -0.16434456f, 0.00687912f, 0.15570258f, 0.14899564f, 
    0.04271235f, -0.03855398f, 0.05619982f, 0.00916251f, 0.12093155f, 0.05616608f, -0.18462043f, 0.19405252f, 
    0.06824012f, -0.02399493f, 0.06737291f, -0.17399031f, 0.29052433f, 0.07255173f, 0.19724922f, -0.00044779f, 
    0.02748258f, -0.17812102f, -0.07269633f, 0.26177463f, 0.10741918f, -0.09783202f, 0.11134278f, -0.05284661f, 
    0.10384805f, -0.27817291f, 0.03896417f, -0.00464752f, 0.02257055f, 0.10937408f, 0.29355457f, 0.03242476f, 
    0.19374613f, -0.24836469f, 0.34314325f, 0.01659151f, 0.03251020f, -0.21361612f, 0.14442548f, 0.25981465f, 
    -0.62471032f, -0.27246514f, -0.28670862f, -0.06307860f, 0.04447803f, -0.14713053f, 0.34939110f, 0.05535752f, 
    0.82090050f, -0.10690156f, 0.15360276f, 0.11024488f, 0.12849246f, -0.10654730f, -0.38356254f, -0.08166377f, 
    0.16219608f, 0.02082212f, -0.00059474f, -0.17801678f, 0.21991788f, -0.32039234f, 0.10251865f, 0.37230968f, 
    -0.00009376f, -0.09381586f, 0.02991902f, -0.22538768f, 0.19332662f, 0.01847482f, 0.07063565f, -0.07282026f, 
    0.07571305f, 0.03631986f, 0.11663125f, -0.22427088f, -0.14235173f, -0.08498318f, 0.03221714f, -0.09798838f, 
    0.26895010f, -0.04546519f, 0.09960929f, 0.11503987f, -0.17626667f, 0.17207009f, 0.30447215f, 0.01526240f, 
    -0.27292222f, -0.36443201f, -0.16043217f, -0.07622728f, -0.08498815f, -0.03241429f, 0.02956422f, 0.01800010f, 
    -0.09506787f, 0.11629708f, -0.10931525f, 0.12287620f, -0.29049116f, -0.31342095f, 0.04470026f, 0.09817208f, 
    0.01449523f, -0.09850531f, -0.15920371f, -0.00872620f, -0.23306285f, 0.12650751f, -0.14459413f, -0.03018365f, 
    0.14074349f, -0.00161090f, 0.37475207f, 0.41998792f, -0.01079492f, 0.31962267f, 0.06493982f, 0.36449108f, 
    0.00353684f, 0.11850379f, -0.11789511f, 0.07917704f, -0.04046540f, -0.02399294f, 0.01064759f, 0.00665958f, 
    -0.02601135f, -0.23486473f, 0.09219027f, 0.05743872f, -0.34186879f, -0.05901594f, -0.04232544f, 0.10310330f, 
    -0.01775745f, -0.12696521f, 0.19392683f, 0.12659593f, -0.26744527f, -0.09757593f, -0.04359133f, 0.15482463f, 
    0.18721108f, -0.70945507f, 0.09237718f, -0.32358834f, 0.07952470f, 0.05743236f, -0.20408286f, -0.00897681f, 
    0.18801105f, -0.57230628f, -0.15051322f, 0.18849519f, 0.18209384f, 0.01380793f, 0.02842314f, -0.09290511f, 
    -0.06092627f, 0.08402278f, -0.07275321f, -0.06727837f, 0.13129638f, 0.19305882f, -0.07309703f, 0.14435227f, 
    -0.48185664f, 0.11865976f, 0.26684120f, -0.02658341f, 0.16860020f, -0.22687796f, -0.12804255f, -0.10493383f, 
    0.10968491f, -0.02382728f, 0.08299679f, 0.09357600f, -0.11505705f, -0.17372048f, -0.01744080f, -0.16182561f, 
    -0.42317903f, -0.28999496f, 0.00445450f, 0.19256194f, -0.08924498f, -0.52973247f, 0.17378427f, -0.49890554f, 
    -0.01361929f, 0.00713853f, 0.06847883f, 0.09774415f, 0.19641377f, -0.06227619f, -0.35819256f, -0.37177774f, 
    0.13037819f, 0.10481566f, -0.12003569f, -0.06923286f, -0.38528082f, 0.03946495f, -0.23101777f, 0.09659898f, 
    -0.21223265f, 0.01047140f, 0.14971425f, 0.03513415f, -0.45969337f, 0.16332202f, 0.06762758f, -0.01969074f, 
    -0.36192802f, -0.64284617f, 0.15491931f, -0.09487914f, -0.04253649f, 0.11624990f, -0.06333779f, -0.04162581f, 
    0.02299562f, -0.02737547f, -0.22755612f, -0.11237187f, 0.13924950f, 0.26095709f, 0.06165519f, 0.07961658f, 
    0.10025471f, -0.07139798f, 0.22220571f, 0.03095169f, 0.21002798f, 0.05905507f, 0.12431750f, -0.04833794f, 
    -0.00427283f, 0.00551459f, -0.05932836f, 0.13460506f, 0.13004261f, -0.10448951f, -0.10889110f, 0.04278925f, 
    0.21213932f, 0.13815913f, 0.25445640f, 0.20755927f, 0.02006765f, -0.01853267f, -0.08362907f, -0.08652793f, 
    0.10133070f, 0.11651923f, -0.23318277f, 0.21774162f, 0.17710644f, 0.10300239f, 0.17496890f, -0.20685431f, 
    -0.12709910f, -0.00030599f, -0.19466864f, 0.13939789f, -0.18250841f, 0.09862360f, 0.06497072f, -0.12878300f, 
    -0.05100018f, -0.02450542f, 0.06150189f, 0.07292344f, 0.06026183f, 0.11529441f, -0.47051519f, 0.04424370f, 
    0.05886903f, 0.57334709f, 0.15054752f, 0.04828198f, -0.08474825f, -0.34122649f, -0.11915053f, -0.03630921f, 
    0.22564104f, 0.02073978f, -0.01773135f, -0.04819028f, 0.20407674f, 0.19684668f, -0.32878235f, -0.10903938f, 
    0.15379778f, -0.23496170f, 0.14722054f, 0.05124771f, 0.01023463f, 0.21472412f, -0.02365219f, 0.15778762f, 
    -0.56065738f, 0.30977288f, -0.06764765f, -0.00613364f, -0.04635032f, 0.20951661f, 0.26812500f, 0.08125611f, 
    0.13835920f, -0.11711330f, -0.20342563f, 0.18020172f, 0.17127079f, 0.28422749f, -0.05556423f, 0.09282327f, 
    0.01455118f, -0.00352208f, -0.07778673f, 0.20662555f, -0.16081704f, -0.07304925f, 0.06184378f, 0.10442571f, 
    -0.03039537f, 0.10736976f, 0.02850923f, -0.38281745f, 0.11901163f, 0.01559701f, -0.06994626f, 0.04798851f, 
    0.18006559f, 0.00207177f, -0.08199231f, 0.03309866f, 0.01944785f, 0.12887706f, 0.01366282f, 0.05261304f, 
    -0.10542946f, 0.18538602f, -0.12981871f, 0.10244418f, 0.24973512f, 0.15719999f, -0.01930032f, 0.17002918f, 
    -0.00753297f, 0.09533267f, 0.04863859f, -0.00981601f, -0.38884732f, -0.11114986f, 0.14342660f, 0.16532704f, 
    -0.01031831f, -0.29906920f, -0.02232116f, 0.23678163f, 0.18543011f, 0.18898499f, 0.01030564f, -0.04943132f, 
    -0.12533045f, -0.10144300f, 0.23593485f, -0.18209548f, 0.05270230f, 0.50600863f, 0.15300246f, 0.09804446f, 
    0.25806138f, -0.41762468f, -0.03180388f, -0.03041037f, 0.23759270f, 0.13650210f, -0.32218289f, 0.11494987f, 
    -0.08116206f, 0.08891091f, 0.18118206f, 0.10734119f, 0.27734074f, -0.31381509f, 0.06894969f, -0.22510645f, 
    0.36172673f, 0.04663889f, 0.03053998f, -0.12460469f, 0.18190219f, -0.20949861f, 0.04847272f, -0.08285288f, 
    -0.20216410f, 0.38338861f, 0.02299645f, 0.17962232f, -0.07063513f, 0.13171281f, -0.10460363f, -0.46202692f, 
    -0.06692477f, 0.16674232f, 0.10436975f, -0.31256953f, -0.17529744f, 0.09446578f, 0.30537313f, 0.02492308f, 
    -0.20287517f, 0.12030567f, -0.06851828f, 0.02167630f, -0.02612047f, 0.11663271f, 0.26314768f, -0.10293240f, 
    -0.21060158f, -0.26718873f, 0.44042405f, 0.03355452f, 0.01749200f, 0.09724396f, -0.11607310f, 0.25028533f, 
    -0.42962644f, 0.29197749f, 0.00624228f, 0.00416075f, 0.25200728f, 0.11151431f, 0.16688134f, 0.15913999f, 
    -0.13378827f, -0.47273174f, -0.20286930f, 0.15466735f, -0.10482994f, 0.19587079f, -0.11094493f, -0.22175254f, 
    0.05127511f, -0.36079708f, 0.07857658f, 0.13459669f, 0.28694066f, 0.18191868f, 0.36473152f, 0.03325809f, 
    0.04554389f, 0.39209798f, 0.15822737f, -0.53875583f, 0.00338348f, -0.00095764f, 0.08552198f, -0.16039312f, 
    -0.21437316f, -0.04283963f, 0.45506397f, 0.41496825f, 0.40943891f, 0.25198349f, 0.03715736f, 0.06651931f, 
    -0.04752399f, -0.04429536f, 0.52545005f, -0.06567699f, 0.27526531f, 0.15981574f, 0.27765864f, -0.01994660f, 
    -0.09375218f, 0.22245659f, -0.01334937f, 0.09488481f, 0.20817395f, 0.12160812f, -0.17500597f, -0.08241374f, 
    -0.13517289f, 0.38168415f, -0.05873702f, 0.20112862f, -0.04762873f, 0.03003464f, 0.04008062f, 0.06102898f, 
    0.32202911f, -0.10081424f, -0.18020745f, -0.01939172f, -0.14775407f, -0.06480239f, 0.15727501f, -0.05107747f, 
    -0.01627844f, 0.03774891f, 0.08274912f, -0.11682255f, -0.09017659f, -0.01968111f, 0.13439134f, 0.08394274f, 
    0.04973630f, -0.05358729f, -0.15971866f, -0.11159041f, -0.19090258f, -0.09345927f, -0.07563507f, -0.59875423f, 
    -0.08804552f, -0.04755522f, 0.13262975f, 0.14153913f, -0.13154849f, -0.00845503f, 0.43571725f, 0.19784500f, 
    0.16383271f, 0.02234591f, 0.12677929f, 0.15168734f, -0.10011511f, 0.07154732f, 0.34974712f, 0.25248075f, 
    -0.01053584f, 0.59637552f, -0.02711872f, 0.02506787f, -0.04186282f, 0.13713482f, -0.17587987f, 0.11242758f, 
    0.16313201f, -0.16404024f, 0.10283272f, -0.05199724f, 0.07633806f, -0.05732268f, 0.19629329f, 0.05518254f, 
    0.17915311f, 0.16633812f, -0.10440829f, 0.11523467f, 0.07222927f, 0.04001128f, -0.08705824f, -0.40613073f, 
    0.66463882f, 0.09598529f, 0.12063482f, -0.04486363f, -0.00614238f, 0.33544278f, -0.32925200f, 0.02977253f, 
    -0.18840382f, 0.31265843f, -0.03960951f, 0.01766361f, 0.14969778f, -0.02573836f, 0.21660800f, 0.38996801f, 
    0.19063951f, 0.09088281f, 0.03148628f, -0.08558793f, -0.20171583f, 0.00245848f, 0.13115658f, 0.35750675f, 
    0.08772658f, -0.06267924f, 0.05659337f, 0.63093907f, -0.01799103f, 0.05312371f, -0.05353928f, 0.00370710f, 
    0.23976806f, 0.07222261f, -0.18039232f, 0.00065140f, -0.01110537f, 0.15014115f, -0.15504797f, -0.02812696f, 
    -0.11065651f, -0.18161088f, 0.23881483f, -0.01170559f, -0.12159745f, 0.09029821f, -0.10561935f, -0.00487184f, 
    -0.04983257f, 0.13776630f, 0.15932213f, -0.00733941f, 0.22501490f, 0.41442117f, 0.18292522f, 0.29265469f, 
    0.12413529f, 0.23015395f, -0.16036126f, -0.02439734f, -0.15154272f, 0.06296084f, 0.14327241f, 0.18770048f, 
    0.19711331f, -0.05101306f, 0.05898908f, 0.18187957f, -0.10866388f, 0.10851988f, -0.17802447f, -0.15843561f, 
    0.09879127f, 0.21610759f, 0.02068656f, 0.11582429f, 0.15020303f, 0.03880711f, 0.15423098f, -0.35959211f, 
    0.05972015f, 0.11727639f, 0.16879688f, 0.03358029f, 0.06864429f, 0.02709399f, 0.28368607f, -0.20350327f, 
    0.00117836f, 0.10712595f, 0.03006709f, 0.36932859f, -0.53859496f, -0.16510548f, 0.42010021f, 0.28852513f, 
    0.04891573f, -0.03210435f, 0.04465345f, -0.40096396f, -0.01931946f, 0.18837415f, 0.19720517f, -0.00553375f, 
    -0.03471099f, -0.15074760f, -0.02390343f, -0.13037448f, -0.29117015f, 0.23423617f, -0.36300945f, -0.02468282f, 
    -0.29409775f, 0.14186388f, -0.49143538f, -0.00511444f, 0.11782258f, -0.07433177f, -0.29380944f, -0.42098442f, 
    0.19920218f, 0.28468996f, 0.39218733f, 0.25266510f, -0.08238956f, 0.23955281f, -0.20362061f, -0.08160254f, 
    -0.06244474f, 0.06891727f, 0.05452967f, -0.05151805f, 0.02450357f, 0.07638187f, 0.28435260f, -0.01629853f, 
    -0.23682499f, 0.27441889f, -0.04064436f, 0.25749448f, -0.19133173f, 0.09370624f, 0.09338120f, -0.11168588f, 
    -0.12096278f, 0.23178773f, -0.00239218f, 0.06690269f, -0.26640275f, -0.07589293f, -0.24383120f, 0.06355002f, 
    0.06505822f, 0.23929483f, 0.00593361f, 0.71865106f, 0.00226606f, 0.06658137f, -0.15823302f, -0.16993184f, 
    -0.21980081f, 0.01773663f, -0.09856035f, -0.04820503f, 0.26811185f, 0.01139203f, -0.07834727f, 0.05389116f, 
    0.75968820f, 0.48619556f, -0.04984630f, 0.04740142f, -0.04285470f, -0.12896235f, -0.04599283f, -0.00490254f, 
    0.07932821f, 0.20642383f, -0.48126525f, 0.03724200f, -0.06574138f, 0.20179182f, 0.01796743f, -0.00677008f, 
    0.04401869f, 0.10799026f, -0.04534157f, 0.17176302f, -0.10554434f, -0.00459936f, -0.10175376f, -0.05833023f, 
    0.17392664f, -0.01159041f, 0.06377669f, 0.32324192f, -0.65737003f, -0.02260791f, -0.05375773f, 0.09428028f, 
    0.10202105f, 0.14665386f, 0.07771635f, -0.00557424f, -0.41433099f, -0.08971216f, 0.01486619f, -0.21067540f, 
    0.04744119f, -0.06274309f, -0.19370717f, 0.19703056f, -0.10894803f, -0.01145068f, -0.10497727f, 0.04187081f, 
    0.09094187f, 0.00829065f, 0.22169361f, -0.23533951f, -0.42629513f, 0.05984374f, 0.16775674f, -0.13640547f, 
    -0.20883478f, 0.15714243f, 0.08540328f, -0.11728480f, 0.00263340f, 0.08081718f, 0.33269265f, -0.03424379f, 
    0.26838353f, -0.02926827f, 0.15637487f, 0.25229558f, -0.47649986f, 0.34870252f, -0.20530993f, -0.18715839f, 
    0.11558880f, -0.06501991f, 0.11663507f, -0.04106552f, 0.17892949f, -0.09916948f, -0.17814794f, 0.11246514f, 
    -0.02507642f, 0.29638901f, 0.19390099f, -0.06663498f, 0.14144021f, -0.04142632f, 0.05665562f, -0.37370524f, 
    0.73799878f, -0.18164514f, 0.04591630f, -0.07163899f, 0.29178548f, -0.36454877f, -0.05391506f, -0.03089788f, 
    0.13963255f, 0.45068386f, -0.15962683f, 0.14749107f, 0.17655583f, -0.04204037f, 0.07535650f, 0.24193271f, 
    -0.06605059f, 0.19543062f, 0.00493127f, 0.03240390f, 0.15647313f, 0.08536971f, -0.06500844f, -0.11786056f, 
    0.00156816f, 0.21842942f, 0.02521695f, 0.46850118f, -0.11661204f, -0.11537386f, -0.15454587f, -0.13291214f, 
    -0.04069594f, 0.09898340f, -0.04487518f, 0.13286105f, -0.29688773f, 0.15730460f, 0.22867338f, -0.00448049f, 
    0.43289387f, 0.36078098f, -0.36408284f, -0.08692499f, -0.14276218f, 0.05785113f, -0.15524916f, 0.08758298f, 
    -0.02436183f, 0.17283525f, -0.08337732f, 0.10811577f, -0.28917950f, -0.40329164f, -0.03093110f, -0.00254596f, 
    -0.00883137f, -0.26701802f, 0.01575860f, 0.14870025f, 0.23712021f, -0.00358943f, -0.11101062f, -0.17272618f, 
    -0.14936072f, 0.27351600f, -0.07963308f, -0.01690712f, 0.06529425f, 0.42283976f, 0.38645515f, 0.11941417f, 
    0.01803969f, -0.36083463f, -0.14280683f, 0.06811185f, 0.01650947f, 0.08301493f, -0.02503822f, 0.35374084f, 
    0.00646790f, 0.04176156f, 0.07256775f, 0.15006591f, 0.20362297f, -0.15874721f, -0.14318547f, 0.47499683f, 
    0.07386602f, -0.18748546f, 0.05199742f, -0.22611210f, 0.25664797f, 0.07476525f, -0.33345741f, -0.13450034f, 
    -0.14120382f, 0.13457483f, 0.04822596f, 0.21305698f, 0.00442641f, 0.06643509f, -0.18624784f, -0.24757519f, 
    0.08224732f, -0.00120791f, 0.05052552f, -0.17482938f, -0.07347886f, 0.05188764f, 0.34336430f, -0.02437694f, 
    -0.03666350f, 0.07656191f, 0.07314441f, -0.07915135f, 0.08409300f, -0.01091673f, 0.23928545f, -0.01231787f, 
    -0.20269689f, -0.43589324f, 0.04606676f, -0.13910037f, 0.00698773f, -0.17215988f, 0.23987952f, 0.34349993f, 
    0.24925151f, 0.05172909f, 0.11992991f, 0.00902129f, 0.13772249f, 0.01963529f, 0.13806081f, 0.18941464f, 
    0.44961590f, -0.19665311f, 0.14795531f, 0.11675286f, 0.16609065f, 0.03506412f, -0.21139501f, -0.03218811f, 
    0.13139164f, -0.09347732f, -0.02820485f, -0.16660324f, 0.41696990f, 0.12707110f, 0.16082829f, -0.05416522f, 
    -0.00175745f, 0.31723440f, 0.13054553f, -0.47188124f, -0.06346235f, -0.06932358f, 0.09749093f, -0.00590889f, 
    0.25936744f, -0.00152461f, 0.13625477f, 0.31407627f, -0.00674435f, 0.09829379f, 0.30999067f, 0.07097485f, 
    -0.26135650f, -0.20622954f, -0.14046705f, -0.11523922f, 0.00679842f, 0.14858244f, 0.16794486f, -0.01121857f, 
    -0.01129387f, -0.01599805f, 0.00069883f, -0.03793320f, -0.04297128f, -0.04169978f, -0.08691802f, 0.00608021f, 
    0.02792030f, 0.07366057f, -0.04083560f, 0.04579601f, -0.05523393f, 0.07078808f, 0.04542007f, 0.02912483f, 
    -0.03064560f, -0.01897532f, 0.04703665f, 0.03582308f, 0.03568088f, 0.02405272f, -0.03705224f, -0.08229022f, 
    -0.09060138f, 0.00729505f, -0.02247755f, -0.07512745f, 0.02272065f, -0.08292634f, 0.00422223f, -0.09177702f, 
    -0.03619876f, -0.03602706f, 0.00908650f, 0.07210256f, 0.00996244f, 0.07173000f, -0.01583618f, 0.05773278f, 
    -0.02292550f, -0.07588767f, 0.08817240f, 0.01068101f, 0.01994402f, -0.03790007f, 0.01600351f, 0.00270848f, 
    -0.04254464f, -0.07005426f, -0.05344854f, -0.06224365f, -0.04951873f, -0.07691539f, -0.03499696f, -0.01722285f, 
    0.04670303f, -0.02895331f, -0.06663596f, -0.02869252f, 0.04504323f, -0.01775675f, -0.02939326f, 0.07210978f, 
    0.01668240f, -0.08329576f, 0.05046914f, 0.06613334f, -0.00867990f, -0.04565601f, -0.07499247f, -0.05177072f, 
    -0.06587743f, -0.03292853f, -0.05585880f, 0.01584968f, -0.05386089f, 0.01941663f, -0.02329177f, -0.07195292f, 
    0.03475680f, 0.05639130f, -0.00557397f, -0.03293908f, 0.03399763f, 0.00299700f, 0.07693720f, -0.10323843f, 
    0.04694387f, -0.08052894f, 0.06879138f, -0.06574391f, -0.01282951f, 0.02424772f, 0.00422195f, -0.04320807f, 
    0.02474292f, -0.07278441f, -0.00518487f, 0.00949932f, 0.02404086f, -0.05356770f, -0.01119162f, -0.05362388f, 
    -0.06769193f, -0.08254379f, -0.02440161f, -0.03959444f, 0.06985646f, 0.00089941f, -0.04386381f, 0.06978290f, 
    0.00593797f, 0.02442303f, -0.06327999f, -0.02582309f, 0.00896546f, -0.04262717f, 0.05480513f, -0.07459656f, 
    -0.01882212f, 0.05734887f, -0.01536671f, -0.08631467f, -0.03819280f, 0.00655124f, 0.02935661f, 0.04033674f, 
    0.02601450f, 0.03504173f, 0.07387652f, -0.01822921f, -0.05000395f, 0.01743133f, -0.09636441f, 0.06751208f, 
    0.02960862f, -0.01104369f, -0.00680782f, -0.07290079f, -0.04397732f, -0.09964961f, -0.03829630f, 0.06635337f, 
    -0.08157768f, 0.00676565f, -0.08557374f, -0.08112834f, 0.08165289f, -0.05823695f, 0.07927179f, -0.08323276f, 
    0.05745053f, -0.08312705f, -0.03077015f, 0.02992681f, -0.10108534f, 0.05281944f, -0.05551980f, 0.07967786f, 
    -0.02946533f, -0.08790603f, -0.02804535f, -0.01986351f, -0.00032852f, -0.08503514f, 0.06238116f, -0.06348659f, 
    0.03909419f, 0.04760633f, -0.00155782f, -0.02574774f, -0.04021537f, -0.01563216f, 0.04181495f, 0.08605727f, 
    -0.07140280f, -0.02759398f, 0.01929043f, 0.04932639f, -0.08685152f, 0.07511938f, -0.05433868f, -0.08977719f, 
    -0.01869661f, 0.00692529f, 0.02250777f, -0.07885835f, -0.05671225f, -0.02202412f, -0.07694823f, -0.07346103f, 
    -0.00052134f, 0.03369980f, 0.02310364f, 0.08087224f, -0.09319377f, -0.07897996f, 0.02392093f, 0.03835889f, 
    -0.05982976f, -0.08489361f, -0.03359750f, -0.09778256f, -0.06993540f, -0.05561430f, 0.03490031f, 0.01437187f, 
    -0.01227035f, 0.04852310f, -0.04325924f, -0.06597897f, -0.06049442f, -0.00882323f, 0.04759379f, 0.01119597f, 
    -0.04107242f, -0.03823741f, -0.05006219f, -0.01542765f, -0.00530003f, -0.05392509f, 0.07935003f, 0.05311326f, 
    -0.01308340f, -0.07490589f, 0.00573831f, 0.02270633f, 0.04052390f, 0.06658860f, -0.07089943f, 0.04450137f, 
    -0.03258559f, -0.04875332f, 0.03483665f, -0.07899925f, -0.08037625f, -0.00134299f, 0.01626879f, -0.00920043f, 
    0.04904198f, 0.02629094f, 0.04256849f, -0.06814330f, -0.09119530f, -0.01920380f, -0.02216667f, -0.04267853f, 
    0.06888461f, -0.07090714f, 0.04094633f, 0.03197628f, -0.09903000f, -0.04276345f, -0.10046666f, -0.09999896f, 
    0.03338474f, 0.04846619f, -0.04853905f, -0.07902154f, -0.02814044f, 0.01677161f, -0.00175463f, -0.04609624f, 
    -0.04818011f, -0.08318581f, -0.01050708f, 0.01019613f, 0.06038442f, 0.04515280f, -0.08875804f, -0.03201484f, 
    -0.04586049f, -0.02789227f, 0.00824983f, -0.08263389f, 0.03132544f, 0.07925475f, -0.07298840f, -0.09475259f, 
    -0.02580325f, 0.05324377f, -0.03182767f, 0.06399792f, 0.02916038f, -0.01043906f, -0.06939115f, 0.00905867f, 
    0.04625395f, -0.04431238f, 0.06604987f, -0.01082736f, -0.03835577f, -0.00305452f, 0.02462276f, 0.08791915f, 
    0.04033836f, -0.04097856f, -0.02263073f, -0.08528594f, -0.00732723f, -0.02741469f, 0.01383493f, -0.00348708f, 
    0.04942712f, 0.07037095f, -0.09113151f, -0.09628043f, 0.07171723f, 0.01203469f, -0.00107953f, 0.05306999f, 
    -0.05893824f, -0.05830677f, -0.10129371f, -0.05100111f, -0.00731143f, 0.02585386f, -0.02029509f, -0.08205700f, 
    -0.08520647f, -0.06305440f, -0.01500590f, -0.06303890f, -0.09482528f, 0.02353340f, -0.05378288f, -0.07930858f, 
    0.00167057f, -0.08197640f, -0.01434637f, 0.04703876f, 0.06239534f, -0.07550018f, 0.02605287f, -0.01807597f, 
    0.07209819f, 0.04426022f, -0.01492216f, -0.03823781f, -0.06329799f, 0.02485936f, -0.02965094f, -0.05247921f, 
    -0.06066274f, 0.03670853f, 0.05841194f, 0.01445368f, -0.02212653f, 0.03500179f, 0.02573469f, 0.08078682f, 
    0.04531291f, -0.08814057f, -0.04960440f, 0.00020737f, 0.08427028f, 0.05970809f, -0.02390139f, 0.07676613f, 
    -0.05313281f, -0.04968742f, -0.02030385f, -0.05972364f, -0.00740070f, 0.02363258f, -0.07444360f, -0.08860803f, 
    -0.10103726f, -0.03093994f, 0.08198916f, -0.01455353f, -0.06584867f, -0.09766351f, -0.01310318f, -0.04102620f, 
    -0.05951722f, 0.01738688f, 0.06025267f, -0.07202452f, -0.03880111f, -0.08291113f, 0.06996816f, 0.00294909f, 
    0.11145713f, 0.01586577f, -0.24235575f, -0.00323458f, -0.06067539f, -0.04226818f, 0.01075406f, 0.24415821f, 
    -0.06648781f, 0.10272382f, 0.11723034f, -0.01337738f, 0.11474811f, -0.02595869f, 0.18059671f, -0.13230665f, 
    0.24050602f, -0.00032435f, -0.22780454f, 0.29271454f, -0.14692470f, -0.04838046f, 0.01962185f, -0.01848486f, 
    0.02053901f, -0.03659884f, 0.13103878f, 0.12264363f, 0.09622291f, 0.10222486f, -0.06281902f, 0.06573477f, 
    0.08422834f, 0.07934494f, -0.17818169f, -0.06443822f, 0.19922024f, -0.07073107f, 0.06895962f, -0.46785307f, 
    -0.08062583f, -0.02942045f, 0.10252756f, 0.06509954f, -0.05546208f, 0.11076163f, 0.19183592f, -0.16933012f, 
    -0.06260844f, -0.02937152f, 0.04569682f, 0.24964711f, 0.01799807f, 0.12084436f, -0.18428242f, 0.04317451f, 
    0.03774493f, 0.41484535f, 0.15445226f, 0.05583893f, -0.15602542f, -0.22866999f, -0.18168224f, -0.00846618f, 
    0.14041978f, 0.17006141f, 0.09438425f, 0.04998702f, -0.05035052f, 0.00524662f, -0.78150845f, 0.11830418f, 
    -0.06823857f, -0.30846080f, -0.01463728f, 0.17107779f, 0.08266173f, 0.05930842f, -0.01696967f, -0.08654439f, 
    0.20010477f, 0.30463463f, -0.04061244f, -0.01919023f, -0.13729824f, 0.09360020f, 0.16174130f, 0.06237874f, 
    -0.01314817f, -0.20342666f, -0.23763813f, 0.18752538f, 0.15736049f, 0.21897991f, -0.03046589f, 0.52027559f, 
    0.10357547f, -0.08892599f, -0.07564876f, 0.30307317f, -0.11366468f, 0.09565201f, 0.00186195f, -0.05099772f, 
    -0.10194720f, 0.04223104f, 0.05405668f, 0.47972584f, -0.07619626f, 0.01614114f, -0.31536889f, 0.13162604f, 
    0.14256577f, -0.01624247f, -0.00861133f, 0.36654511f, -0.04676538f, 0.16515240f, 0.09282257f, -0.08815505f, 
    -0.09340150f, 0.03839079f, 0.11527269f, 0.11165953f, 0.11720736f, 0.12817134f, -0.17876071f, 0.10156033f, 
    0.08644840f, -0.08599151f, 0.05938099f, -0.01597852f, -0.12199657f, 0.06471946f, 0.02909248f, -0.09023702f, 
    -0.05433375f, 0.06749636f, -0.01446608f, -0.02929941f, 0.02045931f, -0.03025522f, -0.03471408f, -0.03165741f, 
    0.07187343f, -0.00269989f, -0.04980534f, -0.03820558f, -0.06626222f, -0.01900203f, 0.03693852f, 0.07586194f, 
    -0.07915171f, -0.09118975f, 0.03666394f, -0.09984538f, 0.02801593f, -0.04509059f, 0.02852981f, 0.01561365f, 
    0.04198529f, -0.10599440f, 0.09974837f, 0.05110996f, 0.05684211f, -0.01483732f, 0.09862957f, 0.08711640f, 
    0.08038700f, -0.05221155f, 0.01571498f, -0.03072851f, -0.00762209f, -0.05307605f, -0.07062664f, -0.00577308f, 
    0.08076379f, -0.03613841f, -0.04641194f, -0.00600729f, 0.01151151f, -0.11548744f, 0.01907713f, 0.05372911f, 
    -0.11771350f, -0.03381809f, -0.03248138f, -0.03074944f, -0.10007441f, 0.00969562f, -0.00254255f, -0.09269026f, 
    -0.10634905f, 0.03054847f, 0.00727544f, -0.04627246f, -0.08202091f, -0.10240850f, -0.04837273f, -0.07812853f, 
    -0.03206601f, -0.01985165f, 0.01968793f, 0.05460232f, -0.08857313f, -0.02085008f, 0.05432178f, 0.03539005f, 
    0.02533687f, -0.02176408f, -0.06733862f, -0.01233670f, 0.01170956f, -0.04783111f, -0.06382066f, -0.05631017f, 
    -0.01596259f, 0.03864063f, -0.02171733f, 0.01153084f, -0.02031982f, 0.06924946f, -0.07306811f, -0.01395045f, 
    -0.06741348f, -0.01793330f, 0.07180272f, -0.06905570f, -0.04097975f, -0.07766409f, -0.11762130f, 0.00721302f, 
    0.07751072f, 0.07998311f, -0.00934272f, 0.00036789f, 0.02958071f, -0.10752708f, 0.05835622f, -0.01489159f, 
    -0.03858219f, 0.06336477f, 0.08074154f, -0.00733075f, 0.00981573f, -0.02965808f, 0.00183928f, -0.05429408f, 
    -0.13685124f, -0.07712756f, -0.04138159f, 0.02501086f, -0.01490806f, -0.11189218f, 0.02308479f, -0.01604149f, 
    0.00050520f, -0.02888025f, 0.10012309f, -0.06887061f, 0.03436010f, -0.03880184f, 0.04747332f, 0.05085352f, 
    0.04632645f, 0.01970328f, -0.08810268f, -0.02850183f, -0.07946273f, -0.02479200f, -0.09340821f, -0.08800250f, 
    -0.00245517f, 0.05308497f, -0.02698389f, -0.08385714f, 0.04553973f, -0.04443239f, 0.05782226f, -0.02167340f, 
    -0.05986375f, -0.10456000f, 0.04107525f, -0.02694953f, -0.09297010f, -0.09607598f, 0.03519127f, -0.04547010f, 
    -0.02938681f, -0.06462602f, 0.03666256f, 0.01040977f, 0.03290757f, -0.02529402f, -0.04196569f, -0.06259598f, 
    -0.05844742f, 0.01429439f, -0.03772569f, 0.00941801f, -0.04702718f, 0.01938759f, 0.03431253f, -0.02859868f, 
    -0.10758068f, -0.06539750f, -0.06332296f, 0.02877576f, 0.04909765f, -0.01341747f, 0.01652878f, -0.00914656f, 
    -0.06887226f, -0.02409015f, -0.00789393f, 0.01634693f, -0.03434392f, 0.08108213f, -0.03556546f, -0.08991791f, 
    -0.08934500f, -0.09828044f, -0.04066436f, -0.08625999f, -0.06274167f, 0.03131371f, 0.02643010f, -0.01154466f, 
    0.02319054f, 0.04767571f, 0.01262122f, -0.01863899f, -0.07144121f, 0.02534402f, 0.10495180f, -0.10894962f, 
    -0.05514126f, -0.08986014f, -0.05619650f, 0.04678592f, -0.00044606f, -0.03028657f, 0.01608202f, -0.05591378f, 
    0.03968032f, 0.08088832f, -0.04733854f, 0.02305398f, -0.04112956f, -0.06454922f, -0.08272231f, 0.08153156f, 
    -0.04295126f, 0.06580751f, 0.05652186f, -0.10868865f, 0.05549542f, 0.02701496f, 0.03017272f, 0.02145373f, 
    -0.09410588f, 0.00625112f, -0.10006506f, 0.06945361f, -0.05013859f, -0.10937972f, -0.08648564f, 0.05427831f, 
    -0.09592474f, -0.01117806f, -0.01989588f, 0.05675945f, 0.05091270f, -0.06174583f, 0.08209014f, 0.00866687f, 
    0.01182964f, 0.02929316f, 0.06695820f, 0.03509597f, 0.03035834f, -0.02861442f, 0.02930633f, -0.06715739f, 
    -0.06182327f, 0.21514842f, -0.06938062f, 0.02153308f, -0.15752685f, -0.14389321f, -0.22034931f, -0.25830022f, 
    0.03573642f, 0.11916862f, 0.19634926f, -0.24747406f, -0.23887819f, 0.06825083f, -0.10010108f, 0.24635123f, 
    0.11471044f, 0.10811946f, -0.18713300f, -0.04641003f, 0.04594064f, -0.04935233f, 0.26533028f, -0.18188190f, 
    -0.02885772f, -0.02086361f, 0.06217958f, -0.04970214f, 0.05519836f, 0.08531602f, 0.08953444f, 0.27932009f, 
    0.03497735f, 0.07814398f, -0.05238694f, 0.08790696f, -0.06583057f, 0.33272249f, -0.10930064f, 0.58287603f, 
    0.09743104f, -0.28852808f, -0.49377942f, -0.02217006f, 0.04392768f, -0.00977064f, -0.17685935f, 0.12855935f, 
    0.12437522f, -0.16991827f, -0.04872290f, 0.17591469f, -0.02128647f, 0.12190136f, -0.53546965f, 0.16604988f, 
    0.10420237f, 0.02134750f, -0.10478273f, -0.16030554f, -0.25671369f, -0.35821009f, 0.31310242f, -0.07852398f, 
    0.08942651f, -0.03410421f, 0.01744003f, 0.02993894f, 0.19021961f, 0.10749614f, -0.16136363f, -0.02200392f, 
    -0.41122162f, 0.02113909f, -0.18735705f, 0.22286314f, 0.03344438f, -0.19712494f, 0.28234920f, 0.17512237f, 
    -0.10804655f, -0.00016145f, 0.01223318f, 0.08513993f, 0.10842833f, -0.12539186f, -0.24197803f, 0.05980025f, 
    0.00733649f, -0.54448456f, 0.08249740f, -0.17687471f, 0.16013692f, -0.25018436f, -0.18106525f, 0.14026079f, 
    -0.07642040f, 0.09855610f, 0.03590288f, -0.12603833f, -0.23617956f, -0.05747160f, -0.24806575f, -0.30942255f, 
    0.15558288f, -0.23435789f, 0.09157844f, 0.14478298f, 0.22326580f, 0.17442247f, 0.32756865f, 0.08663116f, 
    -0.01374030f, -0.01909960f, -0.06655509f, -0.10334633f, 0.31573519f, 0.15657295f, -0.08198395f, -0.04046042f, 
    -0.02928105f, -0.20940083f, -0.21261430f, -0.04362950f, 0.22888210f, 0.00123775f, 0.27597007f, 0.24757852f, 
    0.05180203f, -0.09526442f, 0.01072239f, 0.00052416f, -0.06991508f, -0.09494888f, 0.11827081f, -0.07375834f, 
    0.16881269f, -0.00113741f, 0.16239923f, -0.08080842f, 0.46554312f, 0.10380545f, -0.02090061f, -0.08666596f, 
    -0.13931209f, -0.17747058f, 0.48871589f, -0.41468558f, 0.14615647f, 0.03385223f, 0.03508175f, 0.19198298f, 
    0.05897674f, -0.11181883f, 0.06231099f, -0.07188030f, -0.03733969f, 0.08687911f, 0.03207758f, 0.24258666f, 
    -0.10279761f, 0.01355869f, 0.12210024f, 0.07405623f, 0.26387495f, 0.05657282f, 0.03463552f, -0.27279484f, 
    0.08454734f, 0.35041124f, 0.07410681f, -0.10429420f, 0.39540935f, 0.12570220f, 0.12454528f, -0.04572589f, 
    -0.06588152f, 0.12076026f, -0.06373648f, 0.34653994f, 0.12864514f, -0.17368555f, -0.07673051f, -0.02790205f, 
    0.04454928f, 0.09716914f, 0.19754496f, 0.12055803f, 0.18733604f, -0.08425014f, 0.27662835f, 0.10922166f, 
    0.16817863f, 0.04869854f, 0.29250735f, 0.00083334f, -0.15612875f, 0.05466751f, 0.17718619f, 0.38864058f, 
    -0.13278994f, -0.34359816f, -0.02495602f, -0.21384087f, 0.10936584f, 0.03395756f, 0.09039025f, -0.05148214f, 
    -0.24451177f, 0.05496306f, 0.01401406f, 0.06368900f, -0.03394733f, 0.28611159f, -0.13792337f, 0.23822626f, 
    -0.29981413f, -0.49039912f, -0.02101513f, -0.05582308f, -0.17080772f, 0.05605272f, 0.18015344f, 0.11757528f, 
    0.10863776f, -0.04152175f, 0.06447675f, 0.13903680f, 0.09821459f, 0.06589404f, 0.36789596f, 0.12028204f, 
    -0.02976215f, -0.07054719f, 0.00907007f, -0.22366300f, -0.05032792f, 0.12978327f, 0.11088142f, 0.08218111f, 
    0.13383625f, -0.00011749f, 0.27864382f, 0.28123066f, 0.10977305f, -0.06659131f, 0.05534991f, -0.00107452f, 
    -0.34792435f, -0.42670643f, -0.23722419f, -0.08129239f, 0.00434683f, 0.01768748f, -0.02136128f, -0.04236396f, 
    0.05436333f, -0.05150123f, -0.08917170f, -0.02439570f, -0.06688529f, 0.02250838f, -0.12692121f, -0.08495380f, 
    -0.11310811f, -0.04071081f, 0.04563909f, -0.03463782f, 0.04293907f, 0.07539938f, 0.02551319f, -0.00113953f, 
    -0.12691078f, -0.07034823f, -0.03334946f, -0.06733023f, -0.00988849f, -0.05995111f, 0.02985591f, -0.01671758f, 
    -0.02117859f, -0.07961714f, -0.02549243f, -0.13994782f, 0.00312429f, -0.07044697f, -0.02593434f, 0.00687081f, 
    -0.06126059f, -0.12814730f, -0.13816360f, -0.07118122f, -0.11382631f, 0.01998381f, 0.02874800f, -0.02974165f, 
    -0.01441028f, 0.02791676f, -0.04348277f, -0.07408476f, -0.03785332f, -0.03584039f, 0.00483295f, 0.00860398f, 
    -0.01727273f, 0.00539846f, 0.02132750f, -0.11657062f, 0.07768112f, -0.02368641f, 0.08156905f, -0.08235367f, 
    -0.11416642f, -0.06998830f, -0.04802859f, -0.09436572f, -0.05625702f, 0.06119961f, -0.04957565f, 0.01337024f, 
    -0.06301058f, 0.00230881f, -0.06924460f, 0.07273664f, -0.11722683f, -0.11582892f, 0.05691544f, -0.03768188f, 
    -0.04417240f, -0.03642385f, -0.03220222f, -0.02329493f, 0.03850516f, -0.06022044f, -0.01692760f, -0.05762167f, 
    -0.01214260f, 0.00819178f, -0.01341254f, -0.00244674f, 0.02465791f, -0.00078070f, 0.04366861f, -0.11704306f, 
    -0.05362230f, 0.03784125f, -0.11721136f, -0.05520589f, 0.04513653f, -0.09710787f, -0.01425059f, 0.06244919f, 
    -0.04929145f, -0.09154878f, -0.03618162f, 0.01385428f, -0.06686563f, -0.06762737f, 0.04495627f, -0.03732853f, 
    -0.09286875f, -0.03162692f, -0.12905453f, 0.04995520f, -0.03312525f, -0.04746608f, -0.05320710f, -0.09894464f, 
    0.05237415f, 0.00004048f, -0.04058782f, 0.00086142f, 0.03946421f, 0.03076582f, -0.05225144f, 0.07972735f, 
    -0.01272270f, 0.10451619f, 0.03641170f, -0.08429261f, -0.09090332f, -0.08836117f, -0.01481466f, 0.04469324f, 
    -0.04820942f, 0.05130352f, -0.01527480f, 0.10713577f, 0.04175665f, 0.16781670f, -0.00829238f, 0.03488150f, 
    0.19776322f, 0.06932881f, 0.13150205f, -0.33337954f, 0.06838370f, -0.13312455f, -0.08664916f, 0.17478892f, 
    -0.05342679f, 0.08152667f, 0.02981592f, 0.20659527f, 0.14732626f, -0.04241366f, -0.17138121f, -0.16285703f, 
    0.13199441f, 0.19812672f, 0.35530570f, 0.25770366f, 0.01846872f, -0.00597474f, 0.15718652f, 0.09506655f, 
    0.05952489f, 0.23704126f, -0.19601086f, 0.35236171f, -0.00807576f, 0.19716646f, 0.14935148f, 0.22844321f, 
    -0.10789970f, -0.58155084f, -0.35213515f, -0.09316681f, -0.02272552f, 0.37069768f, -0.13634467f, 0.07491334f, 
    -0.06440084f, -0.12834534f, -0.05208445f, -0.01959153f, -0.02951924f, 0.07811327f, -0.09809030f, 0.15366086f, 
    0.15147518f, -0.00409287f, -0.11148109f, 0.08755971f, -0.33914614f, -0.02046145f, -0.01820759f, -0.09428849f, 
    0.21891588f, 0.15658014f, 0.00448431f, 0.04619056f, 0.33135927f, 0.15332206f, -0.10405846f, -0.05533650f, 
    0.09263626f, -0.01753998f, 0.06179643f, 0.16052657f, 0.10861616f, -0.03633974f, 0.15815398f, 0.39054224f, 
    -0.52126640f, -0.12052107f, -0.09272009f, 0.19331251f, -0.12145684f, -0.14519846f, 0.15545499f, -0.06260338f, 
    0.15632711f, -0.07020377f, 0.12922527f, -0.10257765f, -0.00362118f, -0.04528393f, -0.20566484f, -0.06066446f, 
    -0.18773727f, 0.19591565f, 0.03778479f, 0.16786975f, 0.06218618f, -0.05955681f, -0.16915593f, -0.25209442f, 
    0.12659423f, -0.11225474f, 0.23234262f, -0.70375276f, 0.24842592f, 0.07859742f, 0.28584886f, 0.19616918f, 
    0.01696120f, -0.05389304f, -0.00059514f, 0.20770375f, 0.25731146f, 0.00817663f, 0.01818893f, 0.04587857f, 
    -0.20897768f, 0.30650249f, -0.55802077f, 0.10092824f, 0.06231342f, -0.13092841f, 0.27250203f, 0.23211838f, 
    -0.00387640f, 0.06751446f, 0.02278855f, -0.05689393f, -0.00353669f, -0.07176244f, 0.05292279f, -0.05982382f, 
    -0.09466849f, -0.09451445f, 0.03096852f, -0.01799342f, -0.03380153f, -0.09512533f, -0.03955924f, 0.07490655f, 
    0.00906295f, -0.05880401f, -0.00808206f, 0.01256804f, 0.06660744f, 0.06075273f, 0.00841277f, -0.10173503f, 
    -0.01032438f, -0.08621445f, -0.00000074f, -0.06168913f, -0.05705066f, 0.06132793f, -0.05031503f, 0.01597536f, 
    -0.02052313f, 0.02373527f, -0.01189859f, -0.04925783f, -0.01127406f, 0.03665718f, 0.03531580f, 0.00954349f, 
    0.01553412f, 0.08715718f, 0.00740806f, 0.06146961f, -0.02339896f, -0.00755851f, 0.07475907f, -0.04552627f, 
    -0.07890786f, -0.01131709f, -0.01849261f, 0.00713653f, -0.05395962f, -0.08762696f, 0.07001540f, 0.04760968f, 
    -0.05714518f, -0.00526311f, -0.02467283f, 0.04093648f, -0.08578924f, -0.03278581f, -0.09443979f, 0.06222143f, 
    0.05434130f, -0.05335347f, 0.02114198f, 0.02061737f, -0.04957776f, -0.00060593f, -0.06525914f, 0.05932459f, 
    0.07469033f, 0.00371234f, -0.02973209f, 0.04695939f, -0.05921929f, -0.01770696f, 0.00603158f, 0.03405809f, 
    0.06918683f, -0.01348099f, -0.06766895f, -0.01855871f, 0.04223096f, -0.00710519f, -0.03163082f, -0.06910372f, 
    -0.01333759f, -0.05205901f, -0.03308938f, 0.02926467f, -0.02908841f, 0.00156071f, 0.04987211f, 0.03927876f, 
    -0.03551588f, -0.08595551f, 0.02412488f, -0.05109515f, -0.07068672f, 0.04758251f, -0.05476863f, 0.05521296f, 
    0.02286253f, -0.02770757f, 0.07458894f, 0.05391310f, -0.00845613f, 0.07115216f, -0.06616098f, -0.06602205f, 
    0.01681331f, -0.03420858f, -0.02354533f, -0.02628512f, 0.04950947f, -0.09899364f, 0.08769941f, 0.07006743f, 
    -0.07745469f, 0.04996511f, 0.03238780f, -0.00404102f, -0.08596300f, -0.02732674f, 0.01364553f, -0.05722205f, 
    0.01657255f, -0.01707212f, -0.04168871f, -0.08577224f, 0.02935698f, 0.03519811f, 0.03915362f, -0.04237655f, 
    0.01011955f, -0.08385619f, -0.11768009f, 0.01227747f, 0.05104075f, -0.05147532f, -0.11083397f, 0.00227201f, 
    0.01058173f, -0.11585861f, -0.02748209f, -0.01865779f, 0.07471576f, -0.07940596f, 0.03869702f, -0.06102774f, 
    -0.00519612f, -0.04002684f, -0.08655431f, -0.08968795f, -0.07916416f, -0.04956563f, -0.07709537f, -0.09211417f, 
    0.04358375f, -0.08178587f, -0.08721004f, 0.04414990f, 0.01891283f, -0.06077963f, -0.04417675f, -0.01547821f, 
    0.03202752f, -0.03948426f, -0.06915604f, -0.07200605f, 0.05408641f, 0.04526509f, -0.08437394f, -0.10703860f, 
    0.06214888f, -0.08442219f, 0.01355666f, 0.04469782f, -0.04980197f, -0.06545586f, -0.07841793f, -0.00873668f, 
    0.00026614f, -0.07498425f, -0.07695487f, 0.03564719f, -0.04820628f, -0.08764742f, 0.03965028f, -0.01500123f, 
    -0.01429969f, 0.00258708f, -0.04283128f, -0.04323923f, 0.03787432f, -0.04754326f, -0.09938921f, -0.06825122f, 
    -0.04046154f, 0.05839285f, 0.01279913f, 0.02220900f, -0.09216364f, -0.09910768f, -0.08055521f, -0.03517900f, 
    -0.04634398f, -0.06472991f, -0.08451807f, -0.11822318f, 0.01193938f, -0.08403429f, 0.01857205f, 0.04649557f, 
    -0.05445310f, 0.07987306f, 0.02796996f, -0.03943055f, -0.03766477f, -0.04120539f, 0.02759275f, -0.04451825f, 
    -0.08163172f, 0.05455379f, -0.01056846f, -0.06573059f, -0.11662737f, 0.08023958f, 0.04982956f, 0.05267386f, 
    -0.06111937f, -0.04455935f, 0.00843136f, -0.02452786f, 0.01236553f, -0.05869340f, -0.05187547f, 0.05158316f, 
    -0.09308972f, -0.04938418f, 0.03587471f, -0.07891304f, -0.00141721f, 0.05451334f, 0.02190305f, -0.04291785f, 
    -0.06771643f, -0.09998609f, -0.02221605f, -0.05566701f, -0.10493063f, -0.07272180f, -0.02817052f, -0.11835457f, 
    0.07421821f, -0.11637592f, 0.45238924f, -0.25122666f, -0.40634117f, 0.22453995f, -0.05382835f, -0.23813844f, 
    -0.11675459f, -0.09987648f, -0.11912160f, -0.01431035f, 0.03102950f, 0.07882161f, 0.13845800f, 0.08699720f, 
    -0.21282521f, 0.18418244f, 0.04387000f, -0.88231128f, 0.08157975f, 0.02575113f, -0.04768747f, -0.11585247f, 
    0.07315919f, -0.11313119f, 0.05789997f, -0.20397617f, 0.19308887f, 0.34149066f, 0.06821425f, 0.19168805f, 
    -0.08001901f, 0.05115446f, 0.19672473f, 0.29845399f, 0.08102040f, 0.22052848f, 0.38715667f, 0.74237716f, 
    0.20399794f, 0.42599046f, -0.46871936f, -0.46868387f, -0.17341530f, 0.02603233f, -0.57700491f, -0.28536600f, 
    -0.26788533f, 0.23123454f, -0.40606356f, 0.11201002f, 0.03276411f, -0.23392577f, 0.21014851f, 0.11759596f, 
    -0.42386463f, -0.55169213f, -0.19436494f, 0.01648551f, 0.93542874f, 0.19988021f, -0.00870823f, -0.10169561f, 
    0.11510808f, 0.01567746f, -0.01547073f, 0.06922247f, -0.01439974f, 0.05468100f, -0.19253443f, 0.06398501f, 
    -0.10604333f, -0.19630921f, -0.42449039f, 0.07214937f, 0.22675292f, 0.31380805f, 0.19992504f, 0.21254185f, 
    0.01105369f, -0.35669184f, -0.25652665f, -0.05977990f, -0.00974126f, -0.61885059f, 0.38228932f, -0.25456804f, 
    0.62345999f, 0.49484989f, 0.43454427f, 0.06598569f, 0.16128655f, 0.28067914f, -0.07680860f, 0.06192277f, 
    -0.09265825f, 0.27618989f, 0.08350339f, -0.12060134f, -0.22788452f, -0.06042656f, -0.39714965f, -0.43519694f, 
    -0.12078153f, -0.12221047f, 0.04479486f, 0.66784561f, 0.35532236f, 0.02457293f, 0.19906078f, 0.18414804f, 
    -0.07195079f, -0.04110580f, -0.37672690f, 0.08248907f, -0.07992171f, -0.28006506f, -0.48948413f, 0.02053310f, 
    0.53679878f, 0.81385285f, 0.31962568f, 0.08159418f, -0.07615388f, -0.25787154f, 0.18512870f, 0.22991544f, 
    0.02948694f, 0.09919728f, -0.21510106f, 0.09511764f, -0.16484809f, -0.06109338f, 0.12263117f, -0.08352420f, 
    0.06009758f, 0.18092048f, 0.07076521f, -0.16647518f, 0.06740966f, -0.15438513f, 0.26924288f, 0.13211624f, 
    0.14433369f, 0.24447215f, 0.36649740f, 0.17186724f, 0.02179131f, 0.27860114f, 0.22497843f, 0.04648417f, 
    0.03701419f, 0.00282619f, 0.11339491f, -0.02259120f, -0.16220060f, 0.20473659f, 0.08579388f, 0.35313803f, 
    0.01358221f, 0.03791099f, -0.19838998f, 0.27824172f, -0.11362949f, 0.21702600f, 0.39993075f, 0.24656339f, 
    0.09369885f, -0.13543740f, -0.02425699f, -0.17342766f, -0.00178951f, 0.17169753f, -0.01956537f, 0.12185338f, 
    -0.01750158f, -0.22967041f, -0.13917781f, -0.15703863f, -0.07763324f, -0.26361442f, -0.33770803f, 0.10531688f, 
    -0.13025820f, -0.32278225f, -0.03296136f, 0.04482708f, -0.03807358f, -0.37531105f, 0.06066123f, -0.14196078f, 
    0.30177873f, -0.02545441f, -0.00279296f, 0.00243831f, 0.05246179f, -0.06442546f, -0.94086260f, 0.12038624f, 
    -0.33476683f, -0.55940872f, -0.38014528f, 0.03932552f, 0.22201656f, 0.38417241f, 0.16795067f, -0.04963898f, 
    -0.05380822f, -0.15308861f, -0.00887263f, 0.04716577f, -0.38001212f, -0.14474471f, 0.08724754f, -0.05700281f, 
    0.20840086f, 0.04666323f, 0.19125290f, -0.06045640f, 0.18587670f, -0.13500722f, 0.64421713f, 0.23166701f, 
    -0.13958184f, 0.45735335f, -0.06410112f, -0.14837179f, -0.16618386f, 0.03551754f, -0.30946001f, -0.20622256f, 
    0.17700449f, -0.04624940f, 0.07520650f, 0.47183049f, 0.07959320f, 0.01052288f, -0.07244625f, 0.27298963f, 
    0.13719751f, 0.06944076f, 0.03406823f, 0.08660685f, -0.18779023f, -0.01685395f, -0.01210302f, -0.03330034f, 
    0.09472548f, 0.29015675f, -0.45881099f, -0.03740046f, -0.18477301f, -0.09060106f, -0.01551908f, 0.03446307f, 
    -0.01940802f, 0.12074360f, 0.18212970f, 0.06096154f, 0.04762729f, 0.13248916f, -0.26347938f, -0.10365982f, 
    0.03494772f, -0.01005760f, 0.12397704f, -0.18169533f, -0.04192615f, 0.07910500f, -0.31768396f, 0.09366210f, 
    -0.05567225f, 0.14507721f, -0.38487339f, 0.14703967f, 0.04011425f, -0.33300003f, -0.21304803f, -0.07429967f, 
    0.02454785f, 0.45322520f, 0.27022725f, 0.05111334f, -0.24531710f, -0.13556348f, 0.05923599f, -0.16661935f, 
    0.05588773f, 0.06889398f, 0.14626981f, 0.19424023f, -0.27567998f, 0.03922605f, -0.14136587f, 0.08574959f, 
    -0.23721296f, -0.05222468f, -0.14726929f, 0.08167946f, 0.19619754f, 0.10343180f, -0.23650813f, 0.07915100f, 
    0.19765258f, -0.11538725f, 0.11003546f, -0.17283136f, 0.02936742f, 0.15816003f, 0.17952013f, -0.02096865f, 
    0.09505865f, -0.17444612f, -0.04122251f, -0.07144205f, -0.04981622f, 0.20190862f, 0.17304134f, 0.09821980f, 
    -0.05554200f, -0.01821193f, 0.10553785f, 0.02175152f, 0.42316473f, -0.05156098f, 0.57599896f, -0.08004316f, 
    0.07470441f, 0.84582609f, 0.18847534f, -0.01181710f, 0.08107397f, -0.28479657f, 0.12741895f, -0.07379756f, 
    -0.00528780f, -0.20167851f, -0.04951842f, 0.33160985f, 0.23146243f, -0.11915322f, -0.04183086f, -0.10141650f, 
    0.22438259f, 0.23408306f, 0.09882893f, -0.04304209f, 0.19950335f, 0.01166807f, -0.39796200f, -0.28151563f, 
    0.13159399f, -0.02896686f, 0.01506068f, -0.04250051f, 0.08863000f, 0.02363112f, -0.03849120f, 0.03058325f, 
    0.19439109f, -0.12978481f, 0.04715548f, 0.00747222f, 0.16756618f, 0.04627147f, 0.42799670f, 0.03225547f, 
    -0.07091394f, 0.03501708f, -0.23290543f, -0.11308227f, 0.16532752f, 0.04750316f, 0.06793850f, -0.02991240f, 
    0.08265480f, 0.00429117f, -0.12972072f, -0.01037816f, 0.00070013f, 0.15823756f, 0.18487905f, 0.25035951f, 
    0.01628883f, -0.03261725f, -0.00644653f, 0.04311246f, 0.01058595f, 0.01595057f, 0.00507649f, 0.04208718f, 
    -0.04800949f, 0.00294324f, 0.00266094f, -0.06744967f, -0.06224299f, -0.10090994f, 0.00540088f, -0.06625292f, 
    -0.07649345f, -0.10516895f, 0.02382879f, -0.00031504f, 0.06037031f, -0.03015100f, 0.01555920f, -0.01772023f, 
    -0.12163054f, -0.07207330f, -0.06486075f, 0.00185244f, -0.12106484f, 0.04389735f, -0.05369633f, -0.07785230f, 
    0.01252677f, -0.01625153f, -0.00929474f, -0.04892894f, -0.04734065f, 0.05104715f, 0.07586377f, -0.01890757f, 
    -0.08232151f, -0.07662220f, -0.01956368f, 0.02772122f, -0.06159496f, -0.06648321f, 0.08105721f, -0.08290132f, 
    0.00880243f, -0.08899179f, -0.04648482f, 0.00296178f, 0.05816781f, 0.01129811f, -0.00526020f, -0.07568154f, 
    -0.00727095f, 0.08668352f, 0.03061915f, -0.10900231f, 0.07749809f, -0.01292407f, -0.01454909f, -0.08042022f, 
    -0.04471296f, 0.04004109f, -0.04425064f, -0.08324157f, 0.01124727f, -0.09416777f, 0.05139318f, -0.05953207f, 
    -0.07453258f, 0.05863373f, -0.00566202f, 0.01112363f, 0.03838654f, -0.08393615f, -0.03743859f, -0.08566592f, 
    -0.05083283f, 0.05261213f, -0.06918284f, 0.04866827f, 0.03269947f, -0.04211814f, 0.00798834f, -0.05078895f, 
    -0.01419712f, 0.04310745f, 0.03090749f, -0.03897747f, -0.04535170f, 0.02229448f, 0.07108189f, -0.04567201f, 
    -0.07162560f, -0.07226104f, -0.05551712f, -0.03776129f, 0.03426458f, 0.05138031f, -0.07477836f, -0.03769609f, 
    -0.04522150f, -0.01323210f, -0.07181834f, 0.02454315f, -0.02165057f, 0.02472381f, -0.07561383f, -0.01514403f, 
    -0.03734116f, 0.01344366f, 0.02577961f, -0.02022958f, -0.03916480f, 0.00615906f, -0.02068320f, 0.00114554f, 
    -0.00909838f, -0.01819212f, 0.02273169f, -0.00324514f, -0.06323498f, -0.10772390f, 0.04345057f, 0.00668349f, 
    -0.03326505f, -0.07695808f, 0.00190720f, -0.08700357f, -0.00226699f, 0.07867521f, -0.03593420f, -0.02411824f, 
    0.06520987f, 0.04498447f, -0.03680888f, -0.00450557f, 0.06472756f, 0.00089538f, 0.01918144f, -0.01255348f, 
    0.03023909f, 0.05462361f, -0.07197477f, -0.01318377f, -0.01048412f, -0.07279625f, 0.03115876f, -0.04767695f, 
    0.03401528f, 0.00739698f, 0.02148516f, 0.05120593f, 0.06695691f, -0.06506497f, -0.06161615f, -0.10804000f, 
    -0.03336303f, -0.05053758f, 0.03635715f, -0.01798357f, 0.00787029f, -0.04513918f, 0.03644426f, 0.05064233f, 
    -0.06394311f, -0.01333841f, -0.07659705f, -0.00958704f, -0.04884742f, -0.03143323f, 0.02342069f, 0.00028313f, 
    -0.04121983f, -0.00163436f, -0.02169499f, -0.05468863f, 0.07952323f, 0.04068611f, -0.03278564f, 0.04811085f, 
    -0.08778778f, 0.02146500f, -0.06546357f, 0.01432178f, 0.05437990f, -0.04490335f, -0.07522900f, 0.07442595f, 
    -0.07710375f, 0.07287729f, 0.05068734f, -0.07035448f, -0.05206215f, -0.08726946f, -0.02858794f, 0.02098844f, 
    -0.01626323f, 0.02134950f, 0.01531923f, -0.08789904f, -0.05909849f, -0.00590960f, -0.04317673f, -0.04042364f, 
    -0.07323451f, -0.01426625f, -0.04314400f, -0.06853609f, -0.07657790f, -0.10311219f, -0.04780766f, -0.01810219f, 
    0.01307510f, -0.04499238f, 0.01982334f, -0.09114149f, 0.05879896f, -0.04105594f, 0.03341170f, 0.04412350f, 
    0.01360281f, -0.07794023f, 0.08301739f, 0.00358511f, -0.02063522f, 0.04152698f, 0.02182707f, 0.06755555f, 
    0.03996344f, -0.09355482f, 0.00947220f, 0.04305226f, 0.06277542f, -0.08184748f, -0.10262010f, -0.08890890f, 
    -0.08043780f, -0.03930315f, -0.06829935f, 0.08684609f, -0.08220371f, 0.04014163f, 0.05056934f, 0.01469213f, 
    -0.08371950f, -0.07638687f, -0.07753186f, -0.05781302f, 0.03089545f, -0.02095027f, -0.06410054f, 0.00850763f, 
    -0.03808961f, 0.00076366f, 0.14657766f, 0.18861279f, 0.00359324f, -0.40011925f, 0.05728161f, -0.01271606f, 
    0.09250541f, -0.30359548f, 0.11382154f, 0.18999001f, -0.24655797f, 0.15421285f, -0.05836580f, -0.13341120f, 
    -0.03975966f, -0.06315180f, 0.25198972f, -0.07872424f, 0.31406763f, 0.45318419f, 0.20516285f, 0.20798278f, 
    -0.01088237f, 0.00631208f, 0.08789375f, -0.01488833f, 0.07536695f, 0.11750156f, 0.04546115f, 0.21319625f, 
    -0.10047103f, -0.37411180f, 0.33828276f, -0.03705502f, -0.16599013f, -0.26675725f, -0.02236161f, 0.21253398f, 
    0.44920155f, 0.23572864f, 0.25734034f, 0.21051104f, 0.18108945f, -0.20670407f, -0.20697114f, 0.16675600f, 
    0.18108472f, -0.00670022f, 0.01980266f, -0.32031089f, 0.02310525f, -0.03214688f, -0.02832881f, 0.14301600f, 
    -0.08531266f, -0.36827612f, -0.16013919f, -0.17886703f, 0.26446390f, -0.08777467f, 0.23384783f, 0.19001275f, 
    -0.05969350f, -0.05417228f, 0.16763107f, -0.02424710f, -0.09326958f, 0.15907596f, -0.10368037f, -0.04044223f, 
    0.10045604f, 0.19723605f, -0.24870333f, -0.14682598f, -0.08915305f, -0.01232987f, -0.13618350f, 0.09320832f, 
    -0.09243410f, 0.12580031f, 0.22535732f, 0.14716275f, 0.18599315f, 0.39472288f, -0.24104607f, 0.13215119f, 
    0.05346875f, -0.06296702f, 0.04347790f, -0.27896139f, 0.18674332f, -0.30099657f, 0.07702744f, -0.27470833f, 
    0.22001767f, 0.02455678f, -0.05791746f, -0.21765234f, 0.19212949f, 0.01234326f, 0.11094478f, 0.11736225f, 
    0.19580258f, -0.05259319f, -0.03785549f, 0.14076157f, -0.14746362f, 0.13287024f, -0.04870940f, 0.08388817f, 
    0.13090390f, 0.05328945f, -0.07852357f, -0.31611153f, -0.32968310f, -0.03496549f, -0.07003919f, 0.01049653f, 
    0.10873424f, -0.41294011f, 0.54878634f, -0.05010448f, 0.00649532f, 0.21231142f, 0.06452992f, -0.17475735f, 
    -0.00531030f, -0.07998612f, 0.08447537f, -0.03548313f, 0.00144677f, -0.05485000f, -0.09749854f, -0.04548123f, 
    -0.10504287f, 0.05187043f, -0.09474161f, 0.01147582f, 0.08346467f, -0.05429563f, -0.07436746f, -0.00194753f, 
    0.03682493f, -0.00389693f, -0.00919515f, -0.09029012f, -0.04383155f, -0.02217434f, -0.00623548f, -0.11268862f, 
    -0.00068838f, -0.00573228f, -0.07810310f, -0.05139559f, -0.05028331f, -0.09064590f, -0.05860176f, -0.11516985f, 
    -0.06291341f, -0.07006454f, -0.03527281f, -0.10864870f, 0.00683317f, -0.06669077f, -0.05035814f, 0.04208186f, 
    -0.06805451f, 0.06123894f, -0.03673352f, -0.00348803f, -0.10047322f, -0.01425492f, 0.02209177f, 0.05351477f, 
    -0.07778272f, -0.06929056f, -0.00827920f, 0.04102664f, 0.03154022f, -0.06677096f, -0.06645711f, -0.02382419f, 
    0.04858618f, 0.03280886f, -0.00106616f, -0.07196555f, -0.08212744f, -0.04112155f, -0.04185507f, -0.08328117f, 
    -0.10787168f, -0.03690480f, -0.05229411f, -0.05707800f, -0.04766048f, 0.01403065f, 0.01775718f, -0.09474280f, 
    0.05102113f, 0.04747544f, -0.02614463f, 0.00199190f, 0.00234230f, 0.03453245f, 0.00943832f, -0.02725868f, 
    0.05135918f, 0.03840193f, -0.04795547f, -0.05633746f, 0.08299827f, 0.03918476f, -0.01140820f, -0.07806987f, 
    0.02138948f, -0.00029729f, -0.09048700f, -0.06010757f, -0.07199861f, 0.01560906f, -0.00878879f, 0.01504192f, 
    -0.09821696f, -0.01622320f, -0.07323658f, 0.03426379f, -0.07855938f, 0.03508889f, -0.05457423f, 0.02131262f, 
    0.02615021f, -0.06297223f, -0.07547557f, 0.08415869f, -0.11466003f, -0.07320071f, -0.11268688f, -0.00356051f, 
    -0.00012823f, 0.04710411f, 0.06622174f, -0.07331673f, -0.02210103f, -0.03218858f, 0.01840031f, -0.03688075f, 
    -0.05602566f, 0.04675522f, 0.06214968f, 0.00123606f, 0.02630866f, -0.05449932f, -0.01838702f, 0.02471161f, 
    0.06369613f, 0.05302022f, -0.02779230f, -0.06056676f, 0.06689186f, -0.00438509f, 0.01055677f, 0.02543516f, 
    -0.09533630f, 0.04471342f, -0.04236595f, -0.00094049f, 0.02323392f, -0.03011757f, -0.00585061f, -0.05486961f, 
    0.02446664f, 0.00056475f, -0.07963821f, -0.02407487f, -0.03644540f, -0.07765166f, -0.02416482f, 0.02625798f, 
    0.02294132f, -0.07331916f, 0.05596726f, -0.10279869f, -0.03199685f, 0.01894799f, -0.00894178f, 0.01771468f, 
    -0.05959131f, -0.05724289f, 0.01826094f, -0.08165953f, -0.06596197f, 0.03872827f, 0.01257597f, -0.08659799f, 
    0.04895361f, 0.05028461f, 0.08726614f, 0.00184876f, -0.02612006f, -0.10615017f, 0.00735593f, -0.07914849f, 
    -0.02189892f, -0.00222028f, -0.01694390f, -0.07198662f, -0.07660805f, 0.04683670f, -0.08695374f, -0.01627926f, 
    -0.10274401f, -0.05040446f, -0.10518651f, 0.00326544f, -0.07318655f, -0.06720126f, -0.10879131f, -0.00205185f, 
    -0.07969140f, -0.03942393f, -0.06730627f, 0.04268497f, -0.07772189f, -0.04834288f, -0.03977198f, -0.06067577f, 
    -0.10047135f, 0.07726452f, 0.04146345f, -0.11747802f, 0.04474939f, 0.01208796f, 0.00564875f, -0.10410223f, 
    0.06152147f, -0.07957375f, -0.03027588f, -0.06569777f, -0.09304227f, 0.01223247f, -0.01048671f, -0.06414016f, 
    -0.09764542f, 0.08519293f, 0.04548854f, -0.02444048f, -0.10085365f, 0.03676610f, 0.06075124f, -0.06096436f, 
    -0.15571816f, -0.01257875f, -0.06459622f, 0.04104543f, 0.01086350f, -0.07286643f, -0.08932994f, -0.04550792f, 
    -0.11241136f, -0.01257443f, 0.04769252f, -0.04426013f, -0.11372776f, -0.01996391f, -0.05703948f, 0.00805482f, 
    -0.10408022f, 0.01516898f, -0.08601224f, -0.05019171f, 0.06027474f, 0.00692152f, -0.06323879f, -0.06442315f, 
    0.01681988f, -0.03310006f, -0.04677508f, 0.06090583f, -0.05896716f, -0.06205500f, 0.03951861f, -0.09337019f, 
    -0.10845015f, 0.16427675f, -0.40007186f, -0.03095047f, 0.12538482f, -0.03275754f, -0.18091723f, -0.26486656f, 
    0.07268105f, 0.17224818f, 0.32277489f, -0.12111948f, 0.02168190f, -0.08178078f, -0.10222700f, 0.14794809f, 
    0.13754682f, 0.03566665f, -0.02503354f, -0.20209461f, -0.00748577f, -0.28634185f, 0.04643037f, -0.12574558f, 
    0.00797746f, 0.16253945f, 0.24803405f, 0.01151191f, -0.46795970f, -0.15592362f, -0.00972256f, 0.00028354f, 
    0.07146540f, 0.25808004f, -0.50504678f, 0.28506604f, -0.46807894f, 0.01018052f, -0.07129029f, 0.10843370f, 
    -0.10918208f, -0.16336186f, -0.27819616f, -0.15896071f, 0.22051407f, 0.37244579f, 0.43799075f, -0.03852782f, 
    -0.07185026f, -0.40191790f, -0.08728774f, -0.01293924f, 0.02588895f, 0.02318487f, 0.01148231f, -0.18259399f, 
    0.14296597f, -0.38642418f, -0.20195180f, 0.19512518f, -0.14298749f, -0.06880873f, 0.28394216f, 0.20667106f, 
    0.38567293f, -0.31192568f, 0.30588129f, 0.02861916f, 0.34430313f, -0.23923288f, -0.32189956f, 0.11494358f, 
    -0.36870041f, 0.00582157f, -0.01779810f, -0.09161188f, 0.22637843f, -0.02148828f, 0.37712875f, 0.09382039f, 
    0.21657655f, -0.04794241f, 0.06077150f, 0.05072048f, 0.13326418f, -0.27823722f, -0.44741043f, -0.59488291f, 
    0.20818558f, -0.23277459f, -0.28225929f, -0.13658553f, 0.36196437f, -0.30818757f, 0.31962085f, 0.12188423f, 
    -0.01630174f, 0.09792389f, 0.02832658f, -0.14807525f, 0.08602432f, 0.07470614f, 0.14228883f, -0.10254953f, 
    0.11209622f, -0.11986078f, 0.15795408f, 0.06228454f, 0.10621208f, -0.04658565f, 0.29302716f, 0.08035739f, 
    0.11233353f, 0.06474720f, -0.27993730f, 0.28124690f, -0.24463350f, 0.12943316f, 0.32369977f, 0.06666387f, 
    -0.18436259f, -0.22642186f, -0.44080245f, -0.01058944f, -0.02197520f, 0.03255110f, 0.10410108f, 0.22632860f, 
    0.03661896f, -0.10195970f, -0.07991023f, -0.02995259f, 0.03927327f, -0.09782548f, -0.10474192f, -0.05419206f, 
    -0.10183278f, -0.01828372f, -0.06960776f, 0.01907589f, 0.03056940f, -0.02601627f, -0.06269612f, 0.07706208f, 
    -0.01186632f, 0.04541019f, -0.02296918f, 0.00623289f, 0.06347289f, 0.03114624f, -0.10739390f, 0.02473943f, 
    -0.01275078f, 0.02281008f, -0.03317582f, -0.11598999f, -0.09235033f, 0.02126387f, -0.00757393f, 0.03873527f, 
    0.05890745f, 0.03676001f, -0.05528964f, -0.00609019f, -0.02131800f, -0.04708772f, 0.01890234f, -0.03862595f, 
    -0.07828271f, 0.03410263f, -0.02273256f, 0.03265591f, -0.01852431f, 0.05355985f, 0.03586861f, -0.11132715f, 
    0.05945418f, -0.00471937f, -0.08850142f, -0.02556012f, -0.07968722f, -0.01398870f, -0.04744759f, 0.04371100f, 
    -0.01444787f, -0.04754107f, 0.03496528f, 0.01629784f, -0.05116335f, -0.10329501f, -0.10069561f, -0.02327882f, 
    -0.07740111f, 0.05289644f, -0.10419299f, 0.08724229f, 0.05138321f, -0.11513802f, -0.07264639f, -0.09805527f, 
    -0.03916186f, 0.08486199f, -0.04367540f, -0.04838036f, -0.12275975f, -0.09901674f, 0.03448607f, 0.04866645f, 
    0.04020988f, -0.01254407f, -0.01695853f, -0.00812898f, -0.03939393f, -0.08138408f, 0.04120389f, 0.05369668f, 
    0.04089211f, -0.04809415f, -0.07776920f, -0.08282570f, -0.02189591f, 0.02931120f, -0.04353493f, -0.08581556f, 
    0.05783462f, -0.09692768f, 0.04588991f, 0.05085348f, -0.09672641f, -0.03351784f, 0.00609327f, 0.03579010f, 
    -0.08469177f, -0.04900518f, -0.10965642f, -0.03038550f, -0.10693450f, -0.11245569f, -0.00088542f, -0.10502899f, 
    -0.05470548f, 0.05772632f, 0.04001412f, -0.08111127f, -0.00442170f, -0.04855400f, -0.00628748f, 0.06711861f, 
    -0.01149271f, 0.03262736f, -0.05451931f, 0.05916636f, -0.10934509f, -0.08997268f, -0.09451494f, 0.01864216f, 
    0.06121241f, 0.20028928f, -0.21476771f, 0.04687215f, 0.08418856f, -0.13575715f, 0.09290481f, 0.04141898f, 
    0.03636762f, 0.27202100f, -0.07529533f, 0.07118158f, -0.12029629f, -0.05788955f, 0.15432513f, 0.09466581f, 
    0.50117433f, 0.10084848f, 0.08054647f, 0.04005874f, -0.02855528f, 0.35664210f, 0.40189382f, -0.07907578f, 
    0.05000515f, -0.09536976f, -0.06362565f, 0.00738258f, 0.10405590f, 0.04676720f, -0.06645877f, 0.14674713f, 
    -0.04354808f, 0.02410054f, -0.11861304f, -0.12997717f, 0.00342207f, -0.04361628f, 0.05173195f, -0.07796918f, 
    0.29635948f, -0.09327561f, -0.03988783f, -0.03840615f, -0.02734502f, -0.12755662f, 0.75187695f, 0.30526760f, 
    0.09527967f, -0.05345437f, -0.03387140f, 0.02661736f, -0.01405520f, -0.01130476f, -0.22435848f, -0.09784849f, 
    0.18748794f, -0.02082828f, -0.02621044f, -0.10240810f, -0.24203700f, -0.45212182f, -0.02880253f, -0.05605109f, 
    0.31815895f, -0.09886545f, -0.19781771f, -0.02280310f, -0.07765885f, -0.11110584f, -0.44874385f, -0.15306821f, 
    -0.13696961f, -0.27090067f, -0.04017998f, 0.09683638f, 0.10575728f, -0.04499156f, 0.20297100f, -0.13456020f, 
    0.61946815f, 0.27416319f, 0.31374437f, -0.06061485f, -0.06353876f, -0.05285789f, -0.25286624f, -0.14457110f, 
    0.09621259f, -0.16805902f, -0.05918556f, 0.00328302f, 0.22030930f, -0.08571419f, 0.49187693f, 0.31911305f, 
    0.14849786f, 0.02892100f, -0.05868223f, 0.01826598f, -0.32648122f, -0.03886976f, 0.09920070f, -0.13719709f, 
    0.08971192f, 0.34991509f, 0.14579748f, 0.71564221f, -0.10365424f, -0.03311792f, 0.02502786f, -0.06813477f, 
    0.05241556f, 0.04322723f, 0.17938972f, 0.03418828f, -0.20417334f, 0.29062444f, 0.12260456f, -0.03740837f, 
    0.12174255f, -0.20031427f, -0.24693094f, -0.05199376f, 0.02481885f, 0.07093699f, -0.05098563f, -0.08508758f, 
    -0.02405918f, 0.05613659f, 0.07799385f, -0.07922002f, -0.02729998f, -0.06816737f, -0.08828781f, 0.06046042f, 
    -0.02246459f, -0.08097847f, 0.00993748f, 0.02902879f, -0.02343721f, -0.09298570f, 0.00861563f, 0.04211229f, 
    -0.05931037f, 0.00991141f, 0.00023450f, -0.07317765f, -0.01287016f, 0.00120960f, -0.00076914f, 0.06706865f, 
    -0.03201279f, -0.02794883f, -0.06470006f, -0.04831707f, 0.01054026f, -0.10245631f, -0.07937922f, 0.03290261f, 
    -0.05770026f, 0.07544172f, 0.02200910f, -0.04239767f, 0.01669443f, -0.01835703f, -0.03557340f, 0.00568116f, 
    0.05523057f, -0.05657746f, -0.05259940f, 0.07656529f, -0.00372796f, -0.04203462f, -0.10122465f, -0.03132664f, 
    0.00906224f, -0.07033870f, -0.05814549f, -0.03809467f, 0.05951662f, 0.08001041f, 0.04479799f, -0.01077375f, 
    0.06694330f, -0.03558586f, 0.06401450f, 0.01798022f, -0.02215270f, -0.01798309f, -0.07579698f, 0.03052775f, 
    0.02608254f, 0.04664570f, -0.01760206f, 0.06840404f, -0.07071368f, -0.02874316f, -0.08348680f, -0.07651559f, 
    -0.08016124f, 0.01803773f, -0.01508237f, -0.02383538f, -0.04172589f, 0.03359054f, 0.04727211f, 0.07023493f, 
    -0.06772089f, 0.03253767f, -0.02751664f, -0.07510117f, -0.06126590f, 0.08215691f, 0.00874563f, 0.06409902f, 
    -0.04936781f, -0.03519494f, 0.00467907f, -0.03230663f, -0.07563928f, 0.00158260f, 0.00336769f, 0.05761112f, 
    -0.07402076f, -0.04471115f, -0.08652279f, -0.05354400f, -0.07481885f, 0.07272385f, -0.00336617f, 0.04265843f, 
    -0.04417325f, -0.06902829f, 0.06371941f, 0.01600696f, 0.01132206f, 0.05648175f, 0.06347671f, 0.01148100f, 
    -0.08384355f, -0.07295483f, -0.02100527f, 0.01963083f, -0.00797884f, 0.07392017f, 0.03361752f, 0.04106306f, 
    0.02865507f, -0.03580333f, -0.05145175f, -0.07920631f, -0.06554145f, 0.01219765f, -0.01852277f, -0.05717479f, 
    0.04067605f, -0.09948503f, -0.05526287f, -0.09275317f, -0.04744508f, 0.02431324f, -0.02955386f, 0.00367698f, 
    -0.05337993f, -0.06404580f, 0.00303612f, -0.05829557f, 0.02376002f, -0.00406153f, 0.00482993f, -0.01954443f, 
    0.03608636f, -0.03336137f, -0.02542666f, -0.06581606f, -0.11162428f, 0.00057919f, 0.02246750f, -0.05875714f, 
    -0.09025385f, -0.05679824f, 0.05451937f, -0.01019540f, 0.00893212f, -0.03621352f, 0.00566295f, -0.04615375f, 
    -0.08626042f, 0.01712134f, -0.08688308f, -0.07331811f, -0.09850758f, -0.04930072f, 0.01344828f, -0.07197937f, 
    0.00265931f, -0.06500297f, 0.06334103f, 0.02407110f, -0.05200621f, 0.07282259f, -0.00841448f, -0.01414588f, 
    0.01053742f, -0.04900588f, 0.02043431f, -0.05166186f, -0.04769320f, -0.10835359f, -0.07758533f, -0.05037760f, 
    -0.03140059f, -0.05112410f, -0.09866102f, -0.00367940f, -0.06785499f, 0.07894222f, -0.13296011f, 0.03230362f, 
    0.00871878f, -0.01086267f, 0.05396664f, 0.05795233f, 0.00578285f, -0.11009450f, -0.05572705f, -0.05672391f, 
    -0.05901238f, -0.16230498f, 0.07703361f, 0.00076859f, 0.04745782f, 0.02293629f, -0.11637356f, -0.10879268f, 
    -0.02382184f, -0.05250858f, -0.04214788f, -0.11037167f, -0.08917695f, 0.00887566f, -0.01125992f, -0.04402987f, 
    0.01267426f, 0.00427305f, -0.04472013f, 0.03413441f, -0.07725514f, -0.11893797f, 0.06805760f, 0.05976120f, 
    -0.06018307f, -0.09929414f, -0.03137093f, -0.02202384f, 0.02258348f, -0.02889606f, -0.06088835f, -0.03364315f, 
    0.00522693f, 0.06325898f, 0.04696811f, 0.09545426f, -0.11591585f, 0.00009854f, -0.06280709f, -0.01309824f, 
    -0.10920127f, 0.00409984f, -0.00488285f, 0.08213935f, -0.06331079f, 0.01851357f, -0.07309318f, 0.01594711f, 
    0.09993482f, -0.09972741f, 0.03460379f, -0.00616472f, -0.04596530f, -0.05944389f, -0.05340658f, -0.05377135f, 
    -0.04949955f, -0.06014876f, 0.00893103f, -0.09850857f, -0.02100547f, 0.07554828f, 0.01847060f, -0.09165807f, 
    0.04710853f, -0.00038888f, 0.05745147f, 0.03422980f, 0.02307481f, 0.04807984f, 0.01936605f, -0.06855246f, 
    0.00954064f, -0.06126894f, -0.09758504f, 0.02547059f, 0.05009611f, 0.03211858f, 0.05011629f, -0.02943593f, 
    -0.08644991f, -0.06959347f, 0.08167278f, -0.05755740f, -0.02073357f, -0.02961531f, 0.07538546f, -0.07017504f, 
    -0.07721867f, -0.03960459f, -0.00139868f, -0.06470560f, 0.06277083f, -0.00913405f, 0.04981746f, -0.08650792f, 
    -0.00089170f, -0.08070077f, -0.02737923f, -0.11445366f, -0.06526302f, -0.01181129f, 0.04782421f, 0.03984344f, 
    0.03547487f, -0.05090914f, 0.04343418f, -0.02558659f, 0.03743643f, -0.07197209f, 0.05820697f, 0.00084265f, 
    0.07166241f, 0.07061128f, -0.08467016f, 0.05995914f, -0.08248114f, 0.01183729f, -0.01828149f, 0.06079257f, 
    0.03549312f, -0.09228206f, -0.11663733f, -0.01067039f, -0.00972181f, -0.08846658f, 0.07207943f, -0.09308034f, 
    -0.03858731f, 0.03811910f, 0.05530409f, 0.02461899f, -0.09239660f, 0.03190553f, -0.03197210f, 0.03730003f, 
    0.04362631f, 0.01822258f, -0.05984880f, -0.05176219f, -0.02251939f, -0.07466155f, -0.06067219f, 0.02409924f, 
    0.03608771f, -0.04286018f, 0.05415629f, -0.08087447f, 0.02148443f, -0.01883054f, -0.05764699f, 0.06929736f, 
    0.01883293f, -0.08268789f, 0.04870018f, -0.00159562f, 0.00884213f, -0.08817717f, 0.01141029f, 0.01839526f, 
    -0.06726874f, -0.08512898f, 0.06400023f, -0.07725732f, -0.08507398f, 0.03696857f, -0.00043549f, -0.07417792f, 
    -0.12212205f, 0.02856931f, 0.06892252f, 0.00761800f, -0.08278129f, 0.02987659f, 0.06352222f, 0.08235052f, 
    -0.08375597f, -0.04164293f, 0.02855499f, 0.03583452f, -0.08467114f, -0.00275284f, 0.03889022f, 0.01530399f, 
    0.05241994f, -0.05624545f, -0.17352153f, -0.10625382f, 0.01698774f, 0.22432628f, 0.00926422f, 0.11927304f, 
    0.09675266f, 0.14295919f, 0.23293616f, 0.11679180f, 0.03351830f, 0.02721390f, 0.27550873f, -0.17739654f, 
    0.06144246f, -0.18867941f, 0.07951006f, 0.01567267f, -0.05380050f, -0.05246207f, -0.10326485f, 0.05916353f, 
    0.07546025f, 0.08208394f, 0.06887097f, 0.04992909f, 0.03437297f, 0.15222484f, -0.02090741f, 0.01364649f, 
    0.10014621f, 0.15753438f, -0.04376066f, -0.15544128f, 0.21598864f, 0.02426951f, 0.15916450f, -0.56002641f, 
    0.03478394f, 0.26450428f, -0.04520587f, 0.06862804f, -0.12514518f, 0.04292669f, 0.16692418f, -0.02765150f, 
    -0.13606101f, 0.28996518f, 0.01349599f, 0.16335416f, -0.01600696f, 0.07327905f, -0.15634091f, 0.14006355f, 
    -0.15622962f, 0.66053963f, 0.18838917f, 0.13955994f, 0.07541865f, -0.22731426f, -0.01826480f, 0.01179689f, 
    0.11564207f, 0.13381466f, 0.04029464f, 0.02759066f, -0.03391038f, 0.11157928f, -0.25709161f, -0.05634750f, 
    0.07735778f, -0.03655478f, 0.11255376f, 0.02696374f, 0.10914529f, 0.33306342f, -0.13643642f, -0.12998579f, 
    -0.18789338f, 0.36913788f, -0.08097664f, -0.04479986f, 0.01686128f, 0.31675050f, 0.07541853f, 0.17686751f, 
    -0.14364493f, -0.01921381f, -0.21074164f, 0.12136649f, 0.19192237f, 0.48720169f, 0.15342884f, 0.26177776f, 
    0.17364527f, -0.02545616f, 0.03454191f, 0.22130121f, -0.29560953f, 0.01424713f, 0.15621783f, 0.12486979f, 
    -0.12211142f, 0.06703600f, 0.09283584f, -0.25261423f, 0.00819588f, 0.04961773f, -0.16036247f, 0.15326276f, 
    0.03811911f, 0.06096744f, 0.17789164f, -0.04516894f, 0.00843574f, -0.01213047f, -0.11502541f, 0.02349226f, 
    -0.08432122f, 0.09573777f, 0.24444349f, 0.08193565f, 0.05957527f, -0.03049123f, -0.05184681f, 0.14710552f, 
    -0.08189856f, 0.00067419f, 0.04812764f, 0.25391763f, 0.50606775f, -0.09153538f, 0.08830401f, 0.14375122f, 
    0.08889898f, -0.00056137f, 0.01901662f, -0.00513773f, 0.18624213f, 0.14235409f, -0.03104093f, -0.08461712f, 
    0.09831549f, -0.01533519f, -0.05800412f, 0.37597847f, 0.13685131f, -0.43639097f, -0.15344396f, -0.11945269f, 
    -0.26708779f, 0.39819041f, 0.02457831f, 0.04608101f, 0.18128929f, -0.10800576f, 0.20494847f, -0.10604907f, 
    0.03853248f, -0.09299906f, -0.13895722f, -0.29917064f, -0.22397377f, -0.32462031f, -0.17029743f, -0.22725479f, 
    -0.68353641f, 0.30873463f, 0.00517079f, 0.20779781f, 0.04423529f, 0.26004013f, 0.04482475f, 0.06324503f, 
    0.10791245f, 0.17051864f, 0.32656658f, -0.31806612f, 0.07056611f, 0.35202563f, -0.22680289f, 0.18056259f, 
    0.28029710f, 0.34319085f, 0.24915403f, 0.27526841f, 0.35435796f, -0.25413045f, -0.30736694f, 0.04574141f, 
    0.07253592f, 0.04672781f, -0.17390838f, -0.02677930f, -0.14848185f, 0.24184829f, 0.17038000f, 0.15603890f, 
    0.47968480f, 0.49213517f, -0.08323481f, -0.18278767f, -0.31658676f, -0.40431899f, -0.20751676f, -0.02941008f, 
    -0.71798193f, -0.07520219f, 0.02062127f, 0.10325214f, -0.11897883f, 0.43424064f, 0.13629064f, 0.13488443f, 
    -0.07484648f, 0.04011343f, -0.05206344f, -0.19834442f, 0.06280474f, -0.17348699f, -0.30858186f, -0.27304775f, 
    0.23613186f, -0.16236390f, -0.02322610f, 0.13898295f, -0.03946660f, -0.07415432f, 0.14111389f, 0.32744271f, 
    0.00548136f, -0.23046431f, -0.06488415f, 0.23625019f, -0.45941341f, -0.06008425f, -0.18209542f, 0.13732617f, 
    -0.00525694f, 0.03690139f, -0.27438217f, -0.14231658f, -0.61457914f, 0.00213354f, 0.11957563f, 0.01713945f, 
    0.33942100f, -0.29403684f, 0.25913110f, -0.09835020f, 0.10961833f, 0.09362466f, 0.15210995f, -0.14934243f, 
    0.07132437f, 0.20317246f, 0.06272734f, -0.10904485f, -0.05987477f, 0.02370490f, -0.14168397f, -0.10009668f, 
    0.10287564f, -0.07761563f, -0.02601047f, -0.03818204f, 0.39873689f, 0.10964096f, -0.20532916f, 0.10251938f, 
    -0.22515973f, 0.03636796f, -0.29509914f, -0.10907900f, 0.05088242f, -0.17315577f, -0.03929653f, 0.11229013f, 
    0.09650268f, 0.03649138f, -0.02931559f, 0.06030152f, -0.01803678f, -0.23844604f, 0.02235031f, -0.04255022f, 
    0.11582395f, -0.02779541f, 0.02986331f, 0.09995465f, -0.00237131f, 0.13238806f, -0.18920377f, -0.28552592f, 
    -0.18118680f, -0.12719382f, 0.07243408f, 0.00638109f, 0.10851416f, -0.10371290f, -0.12105582f, 0.00341812f, 
    0.19913259f, 0.07911924f, 0.08620919f, -0.14412220f, 0.10120258f, 0.26154774f, 0.14747520f, -0.19136985f, 
    0.05442066f, 0.05505914f, 0.03853905f, -0.06959103f, -0.09902729f, 0.29826489f, 0.27184233f, 0.07380130f, 
    -0.27479380f, 0.03921796f, 0.09384208f, -0.06935473f, 0.24947757f, -0.09868908f, 0.76517588f, -0.06027051f, 
    -0.02528757f, 0.16751422f, 0.26975554f, 0.20252760f, -0.02122751f, -0.23394364f, 0.13294695f, -0.01926735f, 
    -0.10083500f, -0.07801233f, 0.10495018f, 0.19080502f, 0.34064764f, -0.05006502f, -0.02245410f, 0.16324767f, 
    -0.00231680f, 0.24042587f, 0.08507326f, 0.13264586f, 0.06236002f, 0.11705122f, -0.32301763f, -0.37855595f, 
    0.00735002f, -0.40467852f, 0.03735837f, 0.01377026f, 0.14007910f, -0.08651964f, 0.18900976f, -0.04353386f, 
    0.14458336f, 0.04167118f, 0.03440943f, 0.04903295f, 0.19805488f, -0.09967627f, 0.30772507f, -0.15347391f, 
    0.01823423f, 0.05643289f, -0.19528376f, 0.20431599f, 0.27317473f, 0.16612592f, 0.18093003f, 0.01298405f, 
    0.11462507f, -0.22512764f, -0.39468968f, -0.03536905f, -0.02084588f, 0.25884411f, 0.17365220f, 0.06258196f, 
    0.01595909f, 0.14090990f, 0.14866818f, 0.02403411f, -0.26865897f, 0.02867472f, 0.27181634f, 0.17753582f, 
    -0.02787089f, -0.16221620f, -0.07556973f, 0.16239274f, 0.01158752f, 0.23354995f, 0.00808253f, -0.06498097f, 
    -0.09425379f, -0.07056598f, 0.05036900f, -0.14218949f, 0.07615579f, 0.50232309f, 0.12941664f, 0.11494578f, 
    0.04608033f, -0.39043683f, -0.07525124f, -0.00014501f, 0.17250735f, -0.12666442f, -0.03611882f, 0.03895578f, 
    0.05103840f, 0.01370667f, 0.27207360f, -0.02137419f, 0.40545112f, -0.12860879f, 0.05121520f, -0.16477433f, 
    0.12707184f, -0.06027065f, 0.42279318f, 0.04720055f, 0.12019756f, -0.26971814f, 0.48374298f, 0.11742255f, 
    0.16553743f, 0.15796620f, 0.01522125f, 0.04459438f, -0.08325546f, 0.09512587f, -0.04379258f, -0.33208707f, 
    -0.15987271f, -0.26348338f, 0.15263318f, -0.32790431f, -0.03426413f, 0.14028700f, 0.27113754f, 0.06028331f, 
    -0.28185645f, 0.07056190f, -0.26706868f, 0.10168937f, 0.01756906f, 0.07665613f, 0.20471151f, -0.32342628f, 
    -0.45492932f, -0.29868636f, 0.57369632f, 0.21079141f, -0.12295449f, -0.19576140f, 0.03987751f, 0.10481920f, 
    -0.20661141f, 0.18316364f, 0.22181529f, -0.05647350f, 0.14377300f, -0.29111826f, 0.24683735f, 0.09018809f, 
    -0.08209973f, -0.24726221f, 0.12825188f, 0.25878212f, -0.10494263f, 0.27745306f, -0.10625414f, -0.31049350f, 
    -0.07352911f, -0.25449568f, -0.06426950f, 0.21100447f, -0.08917249f, -0.03548370f, 0.09546185f, -0.24203463f, 
    0.01702947f, 0.51766181f, 0.07589352f, -0.29770368f, -0.07173993f, -0.07892913f, 0.14478859f, -0.11678317f, 
    -0.54784238f, 0.06804128f, 0.01660977f, 0.18459091f, 0.29980847f, 0.24021864f, 0.04035122f, 0.01229794f, 
    0.40261233f, -0.05036862f, -0.19970691f, -0.00430275f, 0.04446230f, 0.20361014f, 0.12887400f, -0.11792895f, 
    -0.04454524f, -0.05818082f, -0.03421894f, 0.08567470f, 0.02602860f, -0.02457666f, 0.06617448f, -0.07461072f, 
    0.07349399f, -0.04989067f, -0.06543694f, 0.03323216f, 0.05101601f, -0.00576459f, -0.07232344f, 0.00505498f, 
    0.02427981f, 0.00808142f, -0.07760604f, 0.08286978f, 0.04692825f, -0.04318816f, -0.06736224f, 0.08736485f, 
    -0.02627264f, -0.08490298f, -0.03903591f, 0.01987337f, -0.05826764f, 0.01456786f, -0.06988295f, 0.01637643f, 
    -0.05424136f, 0.07649475f, 0.02105862f, -0.03847218f, 0.01583259f, 0.03405077f, 0.00634884f, -0.05946939f, 
    -0.03620762f, -0.04620993f, 0.05625504f, -0.05332139f, 0.04337459f, -0.08018788f, 0.04210265f, -0.04994699f, 
    -0.08527488f, 0.08258233f, 0.03301559f, 0.08246522f, 0.05252770f, 0.01916191f, -0.08507618f, 0.08695139f, 
    -0.06706420f, -0.02467415f, 0.00971441f, -0.06919323f, -0.04549712f, -0.05315781f, -0.05532191f, 0.04858441f, 
    0.07750285f, -0.05862203f, -0.03899880f, -0.00455252f, 0.03873094f, -0.07092273f, 0.05159203f, 0.07978275f, 
    -0.04834531f, 0.03026173f, -0.01671469f, 0.05671504f, 0.00413381f, -0.05053727f, -0.02032246f, 0.08115691f, 
    -0.08660106f, 0.07349368f, -0.06228027f, -0.02277287f, -0.08562020f, 0.01704630f, 0.03290623f, -0.02954499f, 
    0.08501361f, 0.04681714f, -0.05750032f, 0.02984178f, 0.02105309f, -0.02726384f, -0.06189074f, -0.05299232f, 
    -0.07841983f, 0.07363067f, 0.03592494f, -0.05511874f, 0.02812653f, 0.06775653f, -0.04619768f, -0.00260892f, 
    -0.08176307f, -0.04810365f, -0.08122432f, 0.01895896f, -0.06837360f, 0.01591332f, -0.01337608f, -0.02177458f, 
    0.01041995f, -0.04258667f, 0.04134378f, 0.01074851f, -0.01170096f, 0.01526759f, -0.04226132f, 0.01832200f, 
    0.07675625f, -0.06622300f, -0.03108394f, -0.00988650f, 0.07329670f, 0.00262040f, -0.04638840f, -0.03517524f, 
    0.06439403f, 0.04476836f, 0.32657894f, -0.06907535f, 0.17834139f, 0.24372135f, 0.19234549f, 0.22583544f, 
    -0.02758868f, 0.07738445f, -0.05504133f, 0.19339493f, -0.17326112f, 0.02357578f, 0.17613196f, 0.19165887f, 
    0.20068739f, -0.02520194f, 0.05328372f, -0.18776122f, -0.08171945f, 0.20418778f, 0.04799230f, 0.04748048f, 
    -0.08962701f, 0.08464587f, -0.24369259f, -0.13261037f, 0.28363770f, 0.11207069f, 0.15275888f, 0.00867667f, 
    0.01586838f, 0.01585576f, 0.43182737f, -0.14225402f, -0.03063978f, 0.04865624f, 0.24462341f, 0.11206719f, 
    0.17804131f, 0.06876698f, 0.28681156f, 0.24390000f, -0.32320383f, -0.17474140f, 0.17413549f, 0.32993752f, 
    0.26573038f, -0.04690739f, 0.04520890f, -0.43056759f, -0.02602733f, -0.10159907f, 0.26260924f, 0.13293548f, 
    -0.11575679f, -0.35367280f, -0.00891436f, 0.09147888f, 0.04404080f, 0.12500975f, -0.19224659f, 0.10144600f, 
    -0.14584379f, 0.12343005f, -0.23428689f, -0.00201569f, -0.16568665f, -0.06079027f, -0.14012836f, -0.17619091f, 
    0.17948128f, 0.18442920f, 0.13079882f, 0.18616112f, -0.02171911f, 0.13444002f, -0.03260126f, -0.12745941f, 
    -0.01756336f, -0.03075865f, 0.10290240f, -0.18912315f, -0.06061630f, 0.05913247f, 0.06026985f, 0.10167683f, 
    -0.17595741f, 0.36755329f, 0.27238414f, 0.12265065f, 0.01755038f, 0.10193841f, 0.19650134f, -0.07697215f, 
    -0.01440991f, 0.20298113f, -0.07000346f, 0.05499210f, -0.18637101f, -0.07503278f, -0.02141545f, 0.14868435f, 
    0.08509248f, 0.04551561f, -0.11601849f, 0.66112655f, 0.04418626f, 0.06186982f, -0.25317067f, -0.06076270f, 
    -0.27588978f, -0.02359224f, -0.16015565f, -0.42753646f, 0.03412016f, -0.12541029f, -0.13943349f, -0.01499723f, 
    0.40151572f, 0.23334073f, 0.24392511f, -0.04482500f, -0.06340417f, 0.01095617f, 0.05759890f, -0.03335086f, 
    -0.04490808f, -0.08890057f, -0.23049137f, -0.24203452f, -0.15334061f, 0.18797092f, -0.02575925f, 0.07059316f, 
    -0.06472356f, -0.00501961f, 0.25059968f, 0.10000373f, 0.33477381f, 0.22941142f, 0.15025750f, -0.17398864f, 
    -0.04346937f, -0.09466737f, 0.25023389f, -0.46532932f, 0.01183792f, 0.06456567f, -0.00633547f, 0.25442713f, 
    0.01598287f, -0.09201127f, -0.13453737f, 0.00136272f, -0.10595851f, -0.06023698f, -0.11168704f, 0.04531243f, 
    -0.10562392f, 0.08221806f, 0.03008442f, -0.10320078f, 0.52202380f, 0.16669609f, -0.08714177f, -0.52119452f, 
    0.06214049f, 0.15041226f, 0.26898149f, 0.01824406f, 0.21485728f, 0.08839400f, 0.83543772f, -0.19357568f, 
    0.13020393f, -0.17546111f, 0.03301007f, 0.37590840f, 0.00729726f, -0.26307568f, 0.10682803f, 0.00739463f, 
    0.02266920f, -0.15412067f, 0.10185795f, 0.32064539f, 0.05618296f, -0.01945281f, 0.22705840f, 0.18738139f, 
    0.20780511f, -0.00310577f, 0.23716509f, -0.03688503f, -0.06290746f, -0.04000863f, -0.25752333f, 0.16653965f, 
    -0.29355311f, 0.01759078f, 0.02143450f, 0.08326873f, 0.18004760f, 0.07724872f, 0.18912959f, 0.00934370f, 
    0.68089890f, 0.30653685f, 0.16315334f, 0.13557041f, 0.31412542f, -0.25452301f, 0.01430766f, -0.15240155f, 
    -0.21403749f, -0.09917262f, -0.40867656f, 0.10921722f, 0.06714009f, 0.38909674f, 0.17694668f, 0.32588744f, 
    0.04881970f, -0.17803237f, -0.03531684f, 0.31276608f, 0.04923527f, 0.01906074f, 0.24457054f, -0.31098861f, 
    -0.14198427f, 0.17714326f, 0.02224327f, 0.13413593f, 0.14254691f, 0.09410290f, -0.01074476f, -0.15038249f, 
    -0.07830785f, 0.04121737f, -0.11867633f, 0.15780762f, 0.05350674f, 0.00313610f, 0.10152846f, -0.07022072f, 
    -0.00391820f, -0.12052865f, -0.13748902f, 0.10754725f, 0.00745628f, 0.25488773f, -0.21459505f, 0.16822135f, 
    -0.00828518f, -0.05653793f, -0.06032344f, -0.09655100f, 0.02679730f, -0.07011253f, 0.04094272f, -0.01259190f, 
    -0.09484708f, -0.01238864f, -0.09932079f, 0.05359014f, -0.02638240f, 0.00395592f, -0.06405413f, -0.08823991f, 
    0.03284250f, -0.07527537f, 0.03438221f, 0.06810200f, 0.00473511f, 0.05990216f, 0.00605461f, -0.10592796f, 
    0.05230833f, -0.01650979f, -0.05062047f, 0.01357499f, -0.06295091f, -0.04736940f, -0.00687798f, -0.09772632f, 
    0.00411992f, -0.03903322f, -0.02706958f, -0.02645167f, 0.03873286f, -0.03739444f, 0.02217937f, -0.00729749f, 
    0.00721506f, -0.03475587f, 0.05240717f, 0.03845946f, -0.06787730f, 0.04473001f, -0.01703462f, -0.01519979f, 
    0.00373225f, -0.02824351f, -0.10312782f, -0.02278387f, -0.05341835f, -0.09330162f, -0.08381159f, 0.01642387f, 
    -0.08701539f, 0.04841382f, -0.00294651f, 0.03986624f, -0.04788106f, -0.07929534f, -0.00546568f, -0.10677242f, 
    -0.02677565f, -0.10930748f, -0.11070352f, 0.01802387f, 0.00771406f, -0.06645621f, -0.07798431f, 0.02792492f, 
    -0.00562655f, 0.06384986f, -0.06221221f, 0.01802676f, -0.11407984f, -0.07677164f, -0.05185644f, -0.03229204f, 
    0.03767128f, -0.08630111f, -0.02854067f, -0.03039217f, -0.04616516f, 0.03577625f, -0.06830094f, -0.11303077f, 
    0.07478826f, 0.07429395f, 0.04184833f, 0.05684772f, -0.07634141f, -0.02144066f, 0.04070247f, -0.09719752f, 
    0.05165513f, 0.00308699f, 0.05704836f, -0.07664369f, 0.04471952f, -0.04202230f, -0.03393524f, -0.07187007f, 
    -0.04700519f, 0.01333005f, -0.09527180f, 0.06384766f, 0.02204425f, -0.07646130f, -0.00263858f, -0.08655166f, 
    -0.02753000f, 0.00158524f, 0.08631686f, 0.02605980f, 0.07888619f, -0.05664561f, -0.10944666f, 0.04297332f, 
    -0.01602462f, 0.07022946f, 0.02304518f, -0.06622898f, -0.05858285f, 0.05315008f, -0.06407052f, -0.10092396f, 
    0.04217665f, -0.01691412f, -0.00567739f, 0.18707088f, 0.22236763f, 0.15029463f, 0.15746360f, 0.00529225f, 
    -0.16348742f, -0.02527305f, -0.28233388f, -0.00136073f, 0.34346011f, 0.11775663f, 0.08683614f, -0.25514886f, 
    -0.10105383f, -0.11150696f, -0.22776565f, 0.21691635f, 0.15411432f, 0.01981863f, 0.04685723f, -0.00971556f, 
    -0.05039459f, 0.14418244f, -0.04840257f, -0.01619627f, 0.09600687f, 0.03274160f, 0.18640284f, 0.07632276f, 
    -0.08913320f, -0.13444957f, 0.17789362f, -0.16721258f, 0.21552332f, -0.15314189f, 0.06198931f, -0.27803558f, 
    -0.21330723f, 0.30352595f, 0.26163068f, 0.08779037f, 0.05379125f, 0.06124008f, -0.26627770f, 0.10484233f, 
    0.04959954f, 0.40830901f, 0.19619232f, 0.05125391f, -0.03201807f, 0.10564332f, -0.33350641f, 0.18467890f, 
    -0.06233408f, 0.45664766f, 0.39332956f, 0.16169028f, 0.34962004f, -0.25421929f, -0.00607874f, 0.03520334f, 
    0.06035218f, 0.14237170f, -0.04080833f, 0.00077844f, -0.28915620f, 0.20872410f, -0.11626847f, 0.05534839f, 
    0.36622867f, -0.13660049f, -0.25375614f, -0.25923535f, -0.31628790f, -0.01202954f, -0.03267495f, -0.28393376f, 
    -0.49005952f, -0.25516072f, -0.00279365f, 0.11231618f, -0.13845438f, 0.24407527f, 0.16921562f, 0.39177111f, 
    -0.20351167f, -0.33646411f, 0.13036615f, 0.07077790f, -0.19923012f, 0.25875151f, -0.34982860f, 0.13540147f, 
    0.16543916f, -0.03049294f, 0.08378960f, 0.25646323f, 0.02834430f, -0.10976022f, 0.06688537f, 0.30994514f, 
    0.01711937f, 0.17089508f, -0.08558208f, 0.31849867f, -0.32678005f, -0.05040590f, -0.13773437f, 0.16432182f, 
    -0.17658345f, 0.02188588f, -0.17433971f, -0.21115416f, -0.39282796f, -0.06205281f, -0.02834757f, 0.02350459f, 
    -0.06377827f, -0.07519093f, 0.11946533f, 0.00999944f, 0.01868365f, -0.19477516f, 0.04165008f, -0.08223464f, 
    0.05803654f, 0.10835973f, 0.11352880f, 0.20272328f, -0.17728762f, -0.08094401f, 0.17211688f, 0.15800539f, 
    0.07739120f, -0.31865597f, 0.09994824f, 0.27232549f, 0.12966101f, 0.20087482f, 0.04767615f, -0.11148240f, 
    -0.25980881f, 0.04355118f, 0.08093221f, -0.24515235f, 0.17748325f, 0.30673292f, 0.26187241f, 0.03941506f, 
    0.19595219f, -0.30576316f, -0.00103741f, -0.14539789f, 0.26540130f, 0.10215966f, -0.05417441f, 0.31486955f, 
    0.02582826f, 0.06284107f, 0.24948543f, -0.03016637f, 0.08272926f, -0.34987980f, 0.11118963f, -0.08504481f, 
    0.25340426f, 0.15992357f, 0.13992821f, 0.08662597f, 0.09269707f, -0.17393045f, -0.25249782f, -0.00859364f, 
    -0.15919583f, 0.49290127f, 0.07393917f, 0.01456880f, -0.01653345f, 0.12545773f, -0.14710434f, -0.09219472f, 
    -0.13198939f, 0.47203100f, 0.27060291f, -0.31103203f, 0.20136800f, 0.01765143f, 0.11436579f, -0.07293024f, 
    0.09341788f, -0.03669294f, 0.11848779f, -0.04008674f, -0.14851379f, 0.12955634f, 0.32846391f, -0.02199504f, 
    -0.08313198f, -0.25866625f, 0.10427932f, 0.10191946f, -0.03612403f, 0.11447461f, 0.06256001f, 0.19309901f, 
    -0.61526531f, 0.09112323f, 0.20410527f, -0.09058668f, -0.03542043f, 0.48536545f, 0.04718103f, 0.52192324f, 
    0.20237069f, -0.21733704f, 0.21613196f, 0.05751102f, 0.08527157f, 0.10236335f, -0.09097667f, -0.14863876f, 
    0.25242659f, -0.26020846f, -0.06130802f, -0.00255416f, 0.07473518f, 0.00642578f, 0.38630745f, 0.14143947f, 
    -0.04881483f, 0.24108103f, -0.03065621f, -0.33963758f, -0.11700937f, -0.15125446f, 0.05236221f, 0.06527613f, 
    -0.08862283f, -0.05766378f, 0.06162644f, 0.12791324f, 0.06988686f, -0.00291049f, -0.04671539f, 0.07525522f, 
    -0.15514095f, -0.16666682f, -0.17423888f, 0.02512671f, 0.06396321f, 0.09215867f, 0.32937282f, -0.01694089f, 
    -0.07356432f, 0.13974838f, 0.13313083f, 0.18505423f, -0.03924956f, -0.15692019f, 0.01568499f, 0.02719068f, 
    0.01846630f, -0.03240234f, -0.34846869f, 0.03854666f, 0.28827298f, 0.20783129f, -0.15421785f, 0.00737598f, 
    0.09575217f, -0.04164566f, 0.16326316f, 0.40267667f, 0.06380785f, 0.08176480f, 0.12994941f, 0.15097849f, 
    -0.09552723f, 0.17823866f, -0.00537732f, 0.05098704f, 0.10897072f, -0.01286407f, -0.00047776f, 0.18782325f, 
    -0.11275065f, -0.26163957f, 0.17130978f, -0.30134541f, -0.12478130f, -0.10209097f, -0.18574846f, -0.10775206f, 
    -0.11826579f, -0.21203791f, 0.39145496f, 0.22361232f, -0.12197848f, -0.06739543f, 0.02785453f, 0.13914493f, 
    0.40608338f, -0.26602238f, 0.19831158f, -0.19734290f, -0.00815917f, 0.23316661f, 0.04943505f, 0.15124542f, 
    0.12797143f, -0.09336637f, 0.15036421f, 0.06280480f, 0.37525022f, 0.17468840f, 0.10632219f, 0.13679160f, 
    -0.16195604f, -0.10362653f, 0.12609302f, 0.08121666f, -0.11526991f, 0.17187281f, 0.40411821f, 0.04264905f, 
    -0.15727596f, 0.79298723f, 0.03233117f, 0.08950652f, 0.00073747f, -0.19516908f, -0.20954734f, -0.00358434f, 
    -0.27542979f, 0.01616952f, 0.25334045f, 0.22422507f, 0.12829939f, -0.16792189f, -0.13809226f, 0.06596218f, 
    -0.49061480f, 0.12156904f, 0.21111713f, 0.00819140f, -0.13988878f, -0.32420176f, -0.17807938f, -0.44930854f, 
    0.31564441f, -0.00994589f, 0.08189275f, 0.09082688f, 0.00070531f, 0.13480949f, -0.19806720f, -0.04884155f, 
    0.13219854f, 0.10135718f, -0.05498227f, -0.27754232f, -0.31575695f, 0.04828798f, -0.12558848f, -0.07128955f, 
    -0.00772504f, -0.06988899f, 0.13460004f, -0.47100186f, -0.19478776f, 0.14902103f, -0.04057214f, -0.05415403f, 
    -0.09871881f, -0.80659616f, 0.28899619f, 0.02721117f, 0.20809363f, 0.30058366f, -0.12544514f, -0.10078731f, 
    0.02350090f, -0.09441098f, 0.02095864f, -0.06187701f, 0.01682697f, -0.09554529f, -0.11852205f, -0.10364130f, 
    0.00820602f, 0.02284649f, -0.06327968f, -0.00400111f, 0.07741346f, -0.05115770f, 0.01732272f, -0.09448419f, 
    0.08830076f, 0.02998850f, 0.01195906f, 0.03043222f, -0.07459056f, -0.01585164f, 0.04308657f, -0.01561107f, 
    -0.04765955f, 0.05410120f, -0.12314843f, -0.07347553f, 0.01194532f, 0.02473406f, -0.01229145f, 0.04080091f, 
    0.05218710f, -0.04850565f, -0.02302929f, 0.03826284f, -0.05213788f, -0.02617066f, 0.02064580f, -0.09714215f, 
    0.00788413f, -0.07549809f, -0.01405430f, 0.08990376f, -0.00769777f, 0.00904245f, 0.05354708f, 0.05761585f, 
    -0.00705540f, -0.00707280f, -0.03743060f, -0.05310611f, 0.04296935f, 0.04483686f, -0.02135086f, -0.00322801f, 
    -0.01145604f, 0.07542390f, 0.01392317f, -0.00011494f, 0.00412622f, -0.00173921f, 0.00802420f, -0.05024982f, 
    0.03788150f, -0.08058199f, 0.01376072f, -0.08762710f, -0.08562651f, -0.06485386f, -0.07247495f, 0.04272955f, 
    -0.11412565f, 0.03553347f, 0.02317003f, -0.01840991f, -0.02068109f, -0.09394804f, -0.02479353f, -0.01021963f, 
    -0.01160491f, -0.07172759f, -0.02882081f, -0.07260060f, -0.01234011f, 0.00991901f, 0.02388815f, -0.04700219f, 
    -0.02593959f, -0.01783769f, 0.02301749f, -0.11954057f, 0.02945899f, -0.01015498f, -0.09285673f, 0.04417791f, 
    0.07517544f, -0.04782414f, -0.03359328f, -0.06221576f, 0.04850944f, 0.03201676f, -0.03869145f, -0.07030617f, 
    0.05157631f, -0.10026882f, -0.11496610f, 0.00418251f, 0.03382989f, -0.06513585f, 0.00497362f, -0.05165865f, 
    0.07062752f, 0.01810772f, -0.02815583f, -0.04587869f, -0.13165005f, 0.00532109f, 0.03070811f, -0.05152133f, 
    -0.00416712f, -0.01613435f, -0.07590728f, 0.02619283f, -0.04069800f, -0.07932319f, -0.04769165f, -0.10940555f, 
    -0.05749969f, 0.05542434f, 0.10883908f, 0.27617377f, 0.12278866f, -0.47465250f, -0.17362988f, -0.10018448f, 
    -0.08009880f, -0.13357240f, -0.15408707f, 0.16471829f, -0.18535596f, -0.10231087f, -0.22774559f, -0.20613594f, 
    0.00881981f, 0.10457204f, -0.28171745f, 0.26160315f, 0.16422577f, -0.14127752f, 0.17515834f, -0.13236982f, 
    -0.32367992f, -0.13330725f, 0.07528923f, -0.03518321f, -0.00263105f, -0.18060368f, 0.13313937f, 0.03306747f, 
    -0.05894393f, -0.34756514f, 0.34482488f, -0.03985351f, -0.29061562f, -0.40023670f, -0.40120193f, 0.10401526f, 
    -0.03663012f, 0.09361780f, 0.20466709f, 0.02026265f, 0.15170875f, 0.05188276f, -0.27711299f, 0.00619759f, 
    -0.08141115f, 0.23999658f, 0.13310574f, -0.07870077f, -0.10108390f, 0.13236313f, -0.28678280f, 0.00639844f, 
    0.08790322f, 0.46793699f, 0.13186905f, 0.00825687f, 0.31391633f, -0.35330254f, -0.06749592f, 0.10564567f, 
    0.06674558f, -0.20666954f, -0.11896101f, -0.05416920f, -0.13923344f, -0.18197282f, 0.21175061f, 0.01589264f, 
    0.35033336f, -0.18746039f, -0.34565690f, -0.19055070f, -0.30848402f, -0.51122731f, 0.13880855f, 0.02945550f, 
    -0.01430224f, -0.47107339f, 0.04671319f, -0.01182078f, -0.05543709f, 0.31982020f, -0.21676406f, 0.46717376f, 
    0.38608983f, 0.11652596f, 0.26124409f, -0.06611424f, 0.09569792f, 0.05089684f, -0.25499660f, -0.12835550f, 
    0.20101820f, -0.12813793f, -0.04975920f, -0.30907834f, 0.14767557f, 0.05849165f, 0.01793232f, 0.50019425f, 
    0.10882517f, 0.08674870f, 0.04808064f, -0.27606094f, -0.51222074f, -0.02744521f, 0.00606990f, 0.13260305f, 
    0.00326946f, 0.05681456f, -0.28945872f, -0.22090468f, -0.66488135f, -0.00123941f, 0.22806387f, 0.08233433f, 
    -0.09130743f, -0.36959559f, -0.31111929f, -0.00576800f, -0.10489766f, -0.13081232f, 0.20748866f, -0.34672329f, 
    -0.03165789f, 0.14056504f, -0.14614461f, 0.06028638f, 0.34565648f, 0.12009495f, 0.07642177f, 0.23739380f, 
    0.03433545f, 0.23335357f, -0.17917639f, -0.03527948f, -0.09912653f, -0.09541472f, 0.10930499f, 0.26173544f, 
    0.35162428f, 0.09107443f, -0.33897290f, 0.35774577f, -0.29442561f, -0.11104248f, -0.02294213f, -0.11707137f, 
    -0.08547373f, -0.01733246f, -0.07357545f, 0.06977849f, 0.09249727f, -0.02253099f, 0.08530831f, -0.11776485f, 
    -0.06093816f, -0.09252216f, -0.05607710f, -0.11450850f, -0.01150261f, -0.10488389f, 0.02410289f, -0.55793053f, 
    -0.29205531f, -0.15131836f, 0.32371482f, 0.14619252f, -0.28352389f, -0.09656775f, 0.32476068f, 0.26211408f, 
    0.19520959f, -0.16583784f, 0.12951373f, 0.10252310f, -0.07300912f, 0.14472528f, 0.17989962f, 0.16555670f, 
    0.03127787f, 0.35494477f, 0.12655449f, 0.06261320f, -0.10514159f, 0.12312633f, -0.37835309f, -0.05360122f, 
    0.10711880f, -0.13410622f, -0.16478907f, -0.17477073f, -0.03929909f, -0.14577021f, -0.29405159f, -0.04641531f, 
    0.22175312f, -0.31472191f, 0.08784881f, 0.20412822f, -0.02231473f, -0.03432995f, -0.06432044f, -0.29000545f, 
    0.37924635f, 0.07229985f, 0.17421456f, 0.04434161f, -0.23144831f, 0.34841886f, -0.08210249f, 0.06099158f, 
    0.12728801f, 0.30725643f, -0.06916168f, 0.10696831f, 0.02547378f, 0.01515358f, 0.17873169f, 0.36709279f, 
    0.10777067f, 0.14068256f, 0.04598249f, 0.08371554f, -0.24594904f, 0.06814002f, -0.12709241f, 0.25459841f, 
    0.03598794f, 0.20030485f, 0.07988087f, 0.61343831f, -0.15915768f, -0.07036573f, -0.22535907f, 0.00218815f, 
    0.17450851f, -0.00939512f, -0.33393842f, -0.13458732f, -0.02921519f, 0.07018276f, 0.08050875f, -0.04503389f, 
    0.28865746f, -0.03372713f, -0.11191220f, 0.06372897f, -0.05410184f, 0.00691600f, -0.19986457f, -0.05053656f, 
    0.01251240f, -0.01468564f, -0.25171283f, -0.13393357f, -0.36090732f, 0.29377463f, 0.15507282f, 0.14767170f, 
    -0.03206345f, 0.04406519f, 0.22455485f, 0.11072644f, 0.18512179f, 0.08538109f, 0.26441163f, -0.23426914f, 
    -0.10600794f, -0.18665725f, 0.16048366f, -0.13596047f, -0.12913656f, 0.15658548f, -0.07113360f, 0.12754504f, 
    0.19009183f, -0.15025468f, 0.17017142f, 0.00915579f, -0.10966512f, 0.17101002f, -0.01907846f, 0.10060081f, 
    0.01394565f, 0.13616084f, -0.05481642f, -0.02355126f, 0.28811809f, 0.17157425f, 0.14169136f, -0.60307616f, 
    0.11032899f, 0.06467818f, -0.05264059f, -0.06903320f, -0.18757540f, 0.14872977f, -0.03495305f, -0.19053003f, 
    -0.27055603f, 0.30708939f, -0.08308568f, 0.28676113f, 0.03364735f, -0.06147867f, -0.17024596f, 0.12178800f, 
    -0.15426177f, 0.55719161f, 0.13988483f, 0.02086737f, -0.06210558f, -0.21917950f, -0.16686668f, -0.19769135f, 
    0.12168483f, 0.16352926f, -0.04970045f, -0.04258299f, -0.09770628f, 0.18908040f, -0.47759423f, -0.09717306f, 
    -0.20600578f, -0.53779322f, 0.17215443f, 0.09145752f, -0.00685888f, 0.41622454f, -0.02525970f, -0.08270986f, 
    -0.25201946f, 0.32136145f, -0.02978824f, -0.05482148f, -0.16693157f, 0.23268270f, 0.31171015f, 0.12155053f, 
    -0.05099896f, 0.01765281f, 0.00970358f, 0.29788461f, 0.01387291f, 0.41388753f, 0.11174674f, 0.35726911f, 
    0.06291459f, 0.17743306f, -0.05052948f, 0.33529374f, -0.17268033f, -0.15939531f, 0.06713079f, -0.31571615f, 
    -0.02517705f, 0.12969744f, 0.08156306f, -0.06399662f, 0.10728723f, 0.19195765f, -0.21261717f, 0.24784791f, 
    -0.03394939f, -0.03695432f, 0.26909679f, -0.18231589f, -0.11447400f, 0.00563415f, -0.08374404f, -0.06277978f, 
    -0.15720932f, 0.21320806f, -0.11511528f, 0.07923508f, 0.15400113f, 0.04850207f, -0.17635423f, 0.08862847f, 
    -0.04074539f, -0.01842062f, -0.01530633f, -0.01700193f, 0.00200865f, -0.14792196f, 0.00381313f, -0.04756456f, 
    -0.02703071f, -0.00251373f, -0.01556837f, 0.00374858f, 0.08212915f, -0.06976958f, 0.00585407f, -0.11591239f, 
    -0.03510832f, -0.06560922f, -0.00737391f, -0.02480272f, -0.09038541f, -0.11366946f, 0.02426047f, -0.02182540f, 
    -0.04561626f, -0.00340024f, -0.02475655f, -0.10638899f, 0.05794888f, -0.06738076f, -0.06475537f, 0.00071530f, 
    0.06014647f, -0.10909605f, 0.02410156f, -0.00557912f, -0.07581706f, -0.03604402f, 0.00302423f, -0.03585869f, 
    -0.11570049f, 0.07760028f, -0.00824060f, -0.01625337f, -0.09006968f, -0.06817189f, 0.00917049f, -0.06372232f, 
    -0.00214173f, -0.06126953f, 0.00161369f, -0.03031029f, -0.02116864f, -0.09824236f, 0.12708859f, -0.02173587f, 
    -0.11332045f, 0.03423407f, -0.05136955f, -0.05509419f, -0.10055842f, -0.09563117f, -0.05624042f, -0.00229570f, 
    -0.14737274f, -0.12674186f, -0.08457378f, 0.01907170f, -0.14685108f, -0.01584827f, -0.02889398f, -0.03217307f, 
    -0.06696460f, -0.00010765f, -0.00938790f, 0.00760758f, -0.03896011f, -0.01119543f, -0.13424486f, -0.09105342f, 
    0.15235430f, -0.07406327f, -0.00031224f, -0.04221566f, -0.00734930f, 0.02056508f, -0.13255991f, 0.11078507f, 
    -0.02609904f, 0.05159888f, -0.06291497f, -0.04601596f, -0.09234555f, -0.09761606f, -0.08059464f, -0.02013493f, 
    0.01175706f, -0.00617882f, 0.07369632f, -0.09299587f, -0.05333405f, -0.01226239f, -0.07666540f, 0.02640305f, 
    -0.09873127f, -0.05731057f, -0.01418045f, 0.11835416f, -0.07204881f, -0.07407555f, 0.00542558f, -0.13933113f, 
    -0.09740802f, 0.02577276f, 0.07137235f, 0.12498809f, 0.00979543f, -0.15921250f, 0.00427322f, 0.08735766f, 
    -0.02435455f, -0.11336578f, 0.03187238f, 0.04387483f, 0.04533448f, -0.00497321f, -0.07178634f, -0.05234821f, 
    0.00231549f, -0.13467166f, 0.05095136f, 0.21062955f, 0.24160439f, 0.08069516f, 0.10834309f, -0.02103070f, 
    0.09930624f, 0.10701979f, 0.12484784f, -0.21663354f, -0.37953755f, 0.09974171f, -0.18514447f, -0.20642124f, 
    -0.24104396f, -0.03421780f, -0.05772159f, 0.23479567f, 0.17186736f, -0.36219165f, -0.32887799f, 0.15142483f, 
    -0.11295574f, 0.43963200f, 0.22696312f, 0.26025429f, 0.11099982f, -0.30375701f, 0.11651356f, -0.15507677f, 
    -0.02269839f, 0.05284267f, -0.11404177f, -0.00452544f, -0.03284645f, 0.03566096f, -0.25086874f, 0.06712981f, 
    -0.41313547f, 0.29356030f, -0.36080313f, 0.26255536f, 0.03693953f, 0.20031734f, -0.14226110f, 0.03970389f, 
    0.07051103f, -0.24684830f, 0.10971834f, -0.15798786f, -0.04267989f, 0.00992172f, -0.27028507f, 0.25196883f, 
    0.13970606f, -0.52703691f, -0.03654336f, 0.45559770f, 0.35269800f, -0.21348922f, 0.10105271f, 0.11727000f, 
    0.05537477f, 0.23417197f, -0.05821067f, -0.05078762f, -0.01625261f, 0.31408170f, 0.04471439f, 0.22602098f, 
    0.26620838f, 0.35420072f, -0.00311015f, -0.35261205f, -0.08711942f, -0.28958216f, -0.07713251f, -0.03201321f, 
    -0.27660656f, -0.07557889f, -0.13778408f, 0.23070548f, -0.12160952f, 0.01726931f, 0.30002451f, -0.13020943f, 
    -0.04663710f, -0.36642948f, -0.00438287f, -0.23000123f, -0.15704183f, -0.01751566f, -0.19318959f, -0.53324717f, 
    0.01348365f, -0.00416212f, -0.04098340f, 0.18991336f, -0.10814223f, -0.09990189f, -0.09101162f, 0.13644320f, 
    0.14528191f, -0.28809404f, 0.08156842f, -0.08163614f, -0.07475300f, 0.06902117f, -0.05423954f, 0.28767383f, 
    -0.24500629f, 0.02590026f, -0.15404542f, -0.19845584f, -0.39765051f, -0.14951190f, 0.10033993f, -0.04553660f, 
    0.27974743f, -0.11710072f, 0.20973985f, -0.04722111f, 0.03993679f, -0.06810440f, 0.06888251f, -0.03297497f, 
    0.08430643f, -0.04759860f, 0.03198460f, 0.03997866f, -0.04637020f, -0.05719371f, -0.10455763f, -0.11521536f, 
    0.03819859f, 0.07033103f, -0.05096854f, -0.05028610f, -0.01576517f, -0.05983822f, 0.03421649f, 0.11441847f, 
    -0.03840913f, -0.05565529f, 0.05457097f, 0.03664220f, -0.08916762f, -0.08775382f, -0.05257298f, -0.11353396f, 
    -0.10460944f, 0.04700229f, 0.04555426f, -0.11359829f, -0.09475864f, -0.12069392f, -0.10613790f, -0.00428198f, 
    -0.03917762f, -0.10089250f, -0.07434006f, 0.01381842f, 0.04111848f, 0.01763541f, 0.00657349f, -0.00229015f, 
    -0.01333194f, 0.04665311f, 0.07655004f, -0.08279816f, -0.02207028f, -0.04152061f, -0.05782889f, -0.04638449f, 
    -0.08382002f, 0.03395491f, 0.01608560f, -0.03799169f, 0.02644391f, 0.01111149f, -0.04291610f, 0.03333124f, 
    -0.01062844f, 0.02969905f, -0.11130580f, -0.02871368f, -0.09558919f, -0.07882851f, 0.02346757f, -0.10769495f, 
    -0.07452410f, 0.03948261f, 0.05690150f, 0.05635518f, 0.06372800f, 0.01098054f, 0.02615804f, -0.06034731f, 
    0.01256167f, -0.04557671f, 0.02397294f, -0.07865775f, -0.08636248f, -0.05432172f, -0.05859645f, 0.02597731f, 
    0.02397084f, -0.11492401f, -0.03572071f, -0.07184882f, -0.01520482f, 0.08449733f, 0.00341737f, 0.03999695f, 
    0.03498558f, -0.01420797f, -0.04973402f, 0.04082782f, 0.06412581f, -0.07448674f, -0.05653443f, 0.00402704f, 
    0.05333086f, -0.01744337f, 0.02325499f, -0.07336085f, 0.05865100f, -0.03897875f, -0.03251685f, -0.05512371f, 
    0.05394200f, -0.06941854f, -0.09148113f, 0.00750840f, 0.03121744f, -0.01184417f, -0.00624229f, -0.12690867f, 
    -0.06120013f, -0.05840845f, 0.08383112f, 0.04604025f, 0.04339322f, -0.09583430f, 0.06229583f, 0.05414234f, 
    -0.03933352f, -0.02458916f, -0.07129180f, -0.07654681f, -0.09242353f, -0.05834562f, -0.09548388f, 0.02407208f, 
    -0.03576830f, -0.09799652f, 0.01536753f, -0.02732337f, -0.02021271f, -0.04227513f, -0.13625029f, 0.01298658f, 
    0.03321371f, -0.03833806f, 0.02310991f, -0.08521229f, -0.03806262f, -0.08533815f, -0.03812537f, 0.01204811f, 
    -0.12633732f, -0.10898259f, 0.03291203f, -0.03719315f, 0.05093622f, 0.07443112f, 0.05473949f, 0.01973299f, 
    0.05844969f, 0.00536685f, 0.03242085f, -0.06133145f, -0.08448875f, -0.01132554f, -0.10699692f, -0.00317379f, 
    -0.04509624f, -0.08606753f, -0.02852155f, -0.06265821f, 0.03539108f, -0.03407076f, -0.07432678f, 0.02000759f, 
    -0.02716505f, 0.02013993f, -0.03717464f, 0.06227367f, -0.07048517f, -0.01866071f, -0.09320810f, -0.01030968f, 
    0.01899909f, 0.01334797f, 0.00974286f, -0.04684893f, -0.03370911f, 0.02274129f, -0.00124150f, -0.08837859f, 
    -0.05854803f, 0.04461903f, -0.03378178f, -0.04343383f, -0.03792966f, 0.02681113f, 0.10080178f, -0.09792428f, 
    0.01684617f, 0.00579379f, -0.06003153f, -0.06942910f, -0.05904175f, -0.05701269f, -0.07944684f, 0.02474614f, 
    -0.03178155f, 0.05565829f, -0.03433058f, -0.00142669f, -0.01087919f, 0.06850371f, 0.02777843f, -0.04284101f, 
    0.06933717f, 0.02200132f, -0.03264909f, -0.04965473f, 0.09314715f, 0.00477060f, 0.04543599f, -0.05390312f, 
    0.05451144f, 0.08081920f, -0.07181317f, -0.10439771f, -0.04076964f, -0.00585374f, -0.03959174f, 0.01684717f, 
    0.03282319f, -0.02868569f, 0.05959055f, -0.03467964f, -0.07325001f, -0.04973496f, -0.03330272f, -0.08532403f, 
    0.02458590f, -0.11876463f, -0.11557731f, 0.01012978f, 0.07283013f, 0.00372570f, 0.08762006f, 0.01124487f, 
    -0.08667663f, 0.02068420f, -0.00631980f, 0.02646525f, -0.05217064f, 0.03535066f, -0.13269950f, -0.08641913f, 
    -0.05571314f, 0.00979820f, 0.03463874f, 0.05897200f, -0.04505842f, -0.09328306f, 0.00843546f, -0.09050983f, 
    -0.02971012f, 0.10580276f, -0.31744251f, 0.08193895f, 0.06538557f, 0.04415650f, 0.16342355f, 0.17884575f, 
    0.04166412f, -0.10853776f, 0.13493608f, 0.06279488f, -0.20357226f, 0.01120939f, 0.17401403f, -0.02316196f, 
    0.07880418f, 0.13750383f, -0.17643607f, 0.32615727f, -0.05338572f, 0.22104134f, -0.03327716f, 0.11242966f, 
    0.03478487f, -0.07281676f, 0.09859504f, 0.25169450f, 0.12224361f, 0.13566612f, -0.11428959f, 0.08626986f, 
    0.03892841f, 0.09817039f, -0.15169166f, 0.08198936f, 0.19930142f, -0.07924532f, 0.12174674f, -0.14376050f, 
    0.00256379f, -0.08045923f, -0.22206748f, -0.00583481f, -0.17762141f, -0.08111160f, -0.11826759f, -0.15753788f, 
    -0.02031228f, 0.00201829f, 0.03577431f, 0.10786998f, -0.07550975f, 0.30330095f, -0.70234352f, -0.10218844f, 
    0.07716159f, 0.19994396f, 0.01172473f, -0.12528972f, -0.07311364f, -0.30827838f, -0.03628353f, -0.09304513f, 
    0.21230531f, 0.09700729f, -0.20229021f, -0.07460211f, 0.00256820f, 0.05596746f, -0.90175158f, -0.25847185f, 
    0.01544122f, -0.58376217f, 0.21666723f, 0.15684855f, 0.04097986f, 0.16005625f, -0.05188813f, 0.23874740f, 
    -0.40039793f, 0.39593056f, 0.08850683f, 0.01717195f, -0.10362983f, 0.11325569f, 0.36247319f, 0.04009932f, 
    0.16428900f, -0.67750651f, -0.08930477f, 0.35421419f, 0.20123236f, 0.24678117f, -0.12792093f, 0.33506581f, 
    0.05646935f, -0.07442840f, -0.05260266f, 0.25289458f, -0.14892726f, 0.09125949f, 0.04999675f, 0.06042124f, 
    0.03307234f, 0.22673644f, 0.25001556f, -0.31472915f, -0.04196768f, 0.17181703f, -0.22764960f, 0.20937428f, 
    0.04440223f, 0.00747447f, 0.05572758f, 0.37806696f, -0.05275743f, 0.31049284f, 0.14769150f, 0.03265924f, 
    -0.13958713f, 0.28212279f, -0.20112219f, 0.06205136f, 0.20112336f, 0.04381029f, -0.00466998f, 0.08782465f, 
    -0.10906859f, 0.08899991f, -0.05089411f, 0.16263260f, 0.14154530f, -0.21895431f, 0.01345637f, 0.03635631f, 
    -0.09909320f, 0.20136097f, -0.08105942f, -0.05294712f, 0.16763926f, -0.06530412f, 0.15141982f, 0.06514004f, 
    0.27727422f, 0.29779303f, 0.09672052f, 0.18059257f, -0.15749176f, 0.20277959f, 0.25377628f, -0.03398402f, 
    -0.00934537f, -0.42903891f, -0.01661488f, -0.07170846f, -0.08235864f, 0.17078799f, 0.02414791f, 0.20814365f, 
    -0.08297744f, 0.10481521f, -0.08375248f, 0.15858112f, -0.32170990f, -0.05408715f, 0.34137732f, 0.16729240f, 
    0.03919088f, 0.09004470f, 0.32264796f, -0.09142661f, 0.08213405f, 0.06819326f, 0.36431941f, 0.18763220f, 
    -0.03506175f, -0.31414697f, -0.18807802f, -0.26091671f, -0.00387748f, -0.00538589f, -0.29725370f, -0.15673520f, 
    0.02211094f, -0.24409686f, -0.01980626f, 0.07021540f, 0.05605083f, -0.44761562f, -0.17420435f, -0.16495313f, 
    0.24697194f, -0.28414300f, 0.12682267f, -0.02588654f, -0.02778978f, -0.24928868f, -0.27025452f, 0.05037612f, 
    -0.26112172f, -0.47558445f, -0.18918747f, 0.03337893f, 0.26692161f, 0.29649854f, 0.36925599f, 0.02346148f, 
    0.51697075f, -0.02494977f, 0.18640795f, -0.14029738f, -0.20034969f, 0.52932161f, 0.10258742f, 0.13792776f, 
    0.28739166f, 0.12831135f, -0.03901634f, -0.06092773f, 0.22341630f, 0.00296237f, 0.48053440f, 0.10209063f, 
    0.00108478f, 0.34894797f, -0.05933123f, -0.26252913f, -0.06337357f, -0.04457750f, -0.22915275f, 0.05730702f, 
    0.13301049f, 0.08716161f, 0.05786732f, 0.52748471f, -0.24639301f, -0.23713934f, -0.15897542f, -0.01900609f, 
    0.02605508f, -0.02590225f, -0.22335841f, 0.05952667f, -0.40981674f, 0.02966191f, 0.12886056f, 0.07676031f, 
    0.25660700f, 0.18589820f, -0.03070191f, -0.04088234f, -0.30418402f, -0.09777585f, 0.00318134f, -0.15602744f, 
    0.03641751f, 0.01347355f, 0.02274421f, 0.09044981f, -0.22725771f, 0.05605870f, -0.00002837f, 0.04589196f, 
    -0.08749487f, 0.00659496f, -0.10849472f, 0.37688032f, -0.08961093f, 0.04667640f, 0.26029941f, -0.21597530f, 
    0.08055811f, -0.12431726f, 0.09443002f, -0.09989326f, 0.11357344f, 0.35543218f, 0.18212707f, 0.06787051f, 
    0.11705009f, -0.26222658f, 0.03457338f, -0.31786323f, 0.07383163f, 0.29469958f, -0.11749019f, 0.18354818f, 
    0.00341767f, -0.10193534f, 0.19530174f, -0.39031732f, 0.35514498f, -0.07567111f, -0.06141263f, -0.50392753f, 
    0.52179575f, 0.25049648f, 0.05927443f, 0.15009028f, 0.02923110f, -0.13852412f, 0.28764704f, -0.08284296f, 
    -0.15502499f, 0.52075958f, 0.03818790f, 0.41362962f, -0.05447189f, -0.10620987f, -0.13374616f, 0.07544646f, 
    -0.20794179f, 0.32245442f, 0.22014365f, -0.07985435f, 0.11673835f, -0.13052107f, 0.20092034f, 0.16913706f, 
    -0.00421171f, -0.02393556f, 0.18342973f, -0.05568830f, -0.31628373f, 0.14788751f, -0.30845150f, -0.00631019f, 
    -0.21748298f, -0.26678053f, -0.09458844f, 0.15045848f, -0.17988028f, 0.20770405f, -0.15925241f, -0.22590661f, 
    0.26937607f, 0.15368815f, 0.18446428f, 0.00975771f, 0.17744862f, 0.12512736f, -0.21108690f, 0.17876156f, 
    -0.24314603f, -0.09730044f, -0.06578334f, 0.02799122f, -0.02815239f, 0.26782948f, 0.12722066f, 0.47100624f, 
    0.28159919f, -0.14294603f, -0.08550458f, 0.01344678f, -0.20913190f, -0.05023188f, 0.27839139f, 0.04282577f, 
    -0.02486388f, 0.20830095f, 0.00363673f, 0.37295040f, -0.02516059f, 0.13374212f, -0.02997145f, 0.15452482f, 
    0.11224474f, 0.00461405f, 0.39181346f, 0.33559826f, 0.15191738f, 0.24499139f, -0.36557102f, -0.00786496f, 
    0.05036372f, 0.06878428f, 0.21658142f, -0.03647622f, 0.19696373f, 0.05767673f, -0.03567803f, -0.05128962f, 
    0.00509850f, -0.02681999f, -0.00697612f, -0.04694144f, -0.08643983f, -0.09118649f, -0.00454974f, -0.08801918f, 
    -0.09149348f, 0.05190987f, 0.04537156f, 0.01141374f, -0.01989720f, -0.09749262f, -0.02199119f, 0.00176450f, 
    -0.05324626f, -0.09123306f, -0.01170422f, -0.08671364f, 0.03967680f, -0.08193243f, -0.09911299f, -0.07351490f, 
    -0.08147851f, -0.06243169f, 0.03729556f, 0.02059463f, -0.04003935f, 0.00254859f, 0.03150745f, 0.03929729f, 
    -0.02242786f, 0.04768412f, -0.01767783f, 0.05534312f, -0.04826703f, 0.06764278f, 0.03185518f, -0.08350947f, 
    0.01723119f, -0.07318937f, 0.04053995f, -0.03577044f, 0.05049447f, -0.08097526f, 0.03362178f, -0.12640749f, 
    -0.04162780f, 0.04433552f, 0.03980087f, 0.03861961f, 0.01515281f, -0.05907398f, -0.09433980f, -0.03768555f, 
    -0.12057185f, 0.01807377f, -0.06438277f, 0.00947800f, -0.05965865f, -0.08673786f, -0.11428186f, -0.08589523f, 
    -0.05694360f, -0.01546632f, -0.01855926f, -0.08299351f, -0.02750987f, -0.04293763f, -0.03605951f, -0.03859829f, 
    0.02755985f, 0.09863369f, -0.01316320f, -0.01286227f, -0.07562705f, 0.00279325f, 0.03042957f, -0.08413573f, 
    -0.02477001f, -0.01485578f, -0.05965672f, -0.07783625f, -0.08506292f, 0.02407514f, -0.00650675f, -0.09756682f, 
    -0.08131609f, -0.02247103f, -0.00938034f, 0.06787653f, 0.05608811f, 0.02582598f, 0.04429485f, 0.00552884f, 
    0.00244481f, -0.03646513f, -0.06566147f, -0.07060344f, -0.09600897f, 0.01891840f, 0.00085733f, 0.02706868f, 
    0.00467964f, -0.07882048f, -0.04325498f, 0.04729994f, 0.04996657f, -0.03610487f, 0.04269588f, -0.04687063f, 
    0.06440970f, 0.00283132f, 0.07080490f, 0.01953470f, -0.08702309f, 0.03788860f, -0.00557712f, 0.07075992f, 
    -0.09500398f, -0.04082198f, -0.03056493f, -0.06341848f, -0.02327799f, -0.02653824f, -0.07614222f, -0.02283585f, 
    0.02395875f, 0.08664189f, -0.10361492f, -0.12671188f, -0.11769816f, 0.01188211f, 0.05427722f, 0.17208932f, 
    0.03148179f, -0.21355854f, 0.02102802f, 0.00816065f, 0.14165321f, 0.26233122f, 0.12029197f, -0.23681679f, 
    -0.15029114f, 0.06853947f, -0.07318050f, 0.09742781f, -0.00728700f, 0.13380700f, -0.03536634f, 0.03738247f, 
    0.03713797f, -0.13431361f, -0.06611770f, 0.14497709f, 0.10611255f, 0.00834058f, -0.01867113f, 0.07746305f, 
    -0.10469678f, 0.09912859f, -0.07317962f, 0.05063573f, 0.19794565f, 0.20387708f, 0.10644482f, 0.10793911f, 
    0.09117567f, -0.07216555f, 0.10338742f, 0.02783406f, -0.12829371f, -0.12839456f, -0.38678533f, -0.27081135f, 
    0.11246485f, 0.07906909f, 0.03525542f, 0.06694767f, 0.03095282f, 0.10226196f, -0.11355398f, 0.02821382f, 
    -0.05877252f, 0.22005856f, -0.01311851f, 0.01452578f, -0.08917347f, -0.11303122f, 0.06954432f, -0.06218351f, 
    0.02544137f, 0.15156771f, -0.02320192f, 0.07660813f, 0.04823151f, 0.10653821f, -0.04503106f, -0.01195133f, 
    -0.12961878f, -0.31279880f, 0.08377296f, 0.24025470f, 0.14770485f, 0.16037323f, 0.01481145f, 0.28803617f, 
    -0.18112728f, 0.19209039f, 0.03785727f, 0.08201166f, 0.16001308f, -0.10903125f, 0.31434032f, -0.02020535f, 
    0.18786328f, -0.04602462f, 0.00760388f, 0.26020145f, 0.09231364f, 0.36751807f, -0.49356452f, 0.08212004f, 
    0.11209758f, -0.22103348f, 0.03582568f, 0.27658671f, -0.07317704f, 0.00421130f, 0.08701025f, -0.33444661f, 
    -0.10042926f, 0.16612525f, 0.07038856f, -0.29942414f, 0.14348081f, 0.06421646f, -0.11883564f, 0.04819117f, 
    0.02763709f, -0.00106277f, 0.41216260f, 0.09650539f, 0.04060672f, 0.14659768f, 0.10871299f, -0.06039770f, 
    0.10357726f, 0.18238018f, -0.08998993f, 0.02094806f, 0.19250037f, 0.24569941f, 0.06545088f, -0.00906566f, 
    -0.08252766f, 0.09367002f, 0.39113364f, 0.12354399f, -0.00158158f, -0.05286545f, -0.02754116f, 0.00053391f, 
    0.09006960f, -0.03870625f, -0.15305230f, 0.23808253f, 0.14784716f, 0.13275538f, -0.03908495f, 0.08582671f, 
    -0.12338620f, -0.00656666f, 0.14865616f, -0.14515997f, 0.01933944f, -0.00376066f, 0.24236441f, -0.05032055f, 
    0.00226372f, -0.05098017f, -0.21274346f, -0.03319227f, 0.15496367f, 0.03629010f, 0.12176250f, -0.02987386f, 
    -0.02599152f, -0.18730667f, 0.46551412f, -0.26295030f, -0.22179537f, -0.12942858f, -0.18903832f, 0.02783105f, 
    0.19785379f, -0.08203258f, 0.13961446f, 0.21424060f, 0.09778423f, -0.05455829f, 0.12135696f, 0.30030030f, 
    0.15379824f, 0.18540995f, 0.16349356f, -0.07419829f, 0.09938104f, 0.05543834f, 0.42971855f, 0.17749031f, 
    0.07978458f, -0.07922029f, -0.00442837f, -0.00863973f, -0.00688634f, 0.37871915f, 0.11502017f, 0.11955490f, 
    -0.19450013f, 0.06470594f, 0.04775482f, -0.01178839f, -0.04953476f, -0.01037362f, 0.92598772f, 0.09373620f, 
    0.07715361f, 0.32938522f, 0.01563052f, 0.08899140f, -0.13411362f, -0.16446826f, -0.06007005f, -0.00498304f, 
    0.28295848f, -0.15140131f, 0.16422163f, 0.06907333f, 0.23082514f, 0.13040473f, -0.29314291f, 0.21969841f, 
    -0.18720955f, 0.34864038f, 0.27661899f, -0.14733459f, -0.12643544f, -0.18223350f, 0.03880801f, -0.17513461f, 
    0.04079964f, -0.13327721f, 0.01353753f, -0.16576411f, 0.07995632f, 0.05789018f, 0.12841401f, 0.12937690f, 
    0.15515256f, -0.06956641f, -0.04469940f, -0.50211090f, -0.00798392f, 0.02575778f, 0.25557429f, -0.21358474f, 
    0.08721372f, -0.08602106f, 0.21515235f, -0.38801366f, 0.35729483f, 0.01959617f, -0.04895725f, 0.07608604f, 
    -0.18605106f, -0.17822902f, 0.12483694f, -0.10503799f, 0.01185704f, 0.08394345f, 0.11370365f, 0.01499493f, 
    -0.04473042f, 0.04224318f, -0.10073764f, -0.03015817f, -0.13171369f, -0.08788396f, -0.11581189f, 0.01539149f, 
    0.06237379f, -0.04786054f, 0.20215093f, -0.08212556f, -0.37408245f, 0.15788074f, -0.03584900f, 0.10653402f, 
    -0.07640540f, 0.13317929f, -0.14001513f, 0.05138833f, 0.21193841f, 0.23161037f, 0.19215596f, -0.16566396f, 
    0.21583356f, -0.08646896f, 0.15855378f, -0.05883846f, 0.20152338f, 0.24153355f, -0.18134457f, 0.24042298f, 
    -0.08709064f, 0.14031129f, -0.10874416f, 0.04961636f, 0.11970476f, 0.05220886f, 0.15936656f, 0.33045372f, 
    0.14788336f, -0.41465271f, -0.36850795f, -0.09142692f, -0.01242286f, -0.14898923f, -0.43180758f, 0.06887568f, 
    0.10020486f, 0.29467785f, -0.08002756f, 0.08628905f, 0.02863297f, 0.30391833f, -0.42243493f, 0.15186812f, 
    -0.03799398f, 0.14518918f, -0.09265639f, -0.48002034f, -0.28176263f, -0.03182716f, 0.10247011f, -0.07218118f, 
    -0.08575268f, 0.10750421f, 0.03345633f, 0.03028720f, 0.29515314f, 0.12226243f, 0.09385092f, -0.23087144f, 
    -0.18449911f, -0.27486482f, -0.05130383f, 0.28635180f, 0.05757698f, -0.03796979f, 0.01040321f, 0.51129872f, 
    -0.64653456f, 0.11456606f, -0.06466553f, 0.03960259f, -0.00608418f, 0.00457636f, 0.11383831f, 0.04764006f, 
    0.22305174f, -0.31975448f, 0.15109544f, 0.09194017f, 0.12462566f, -0.00174010f, -0.37430245f, -0.04583462f, 
    0.03230445f, -0.02697892f, -0.08535113f, 0.12470111f, 0.00987068f, 0.03581016f, 0.06405489f, -0.14808862f, 
    0.06266569f, -0.08617018f, 0.04897080f, 0.00094365f, 0.35691169f, 0.09321225f, 0.30067402f, 0.11379812f, 
    0.19021915f, -0.04492602f, 0.22888148f, -0.31682453f, 0.33314595f, 0.12878387f, -0.32178348f, -0.03445766f, 
    -0.24924338f, 0.17243218f, -0.29550061f, 0.03350458f, 0.38467106f, 0.21793976f, 0.44376734f, 0.16712096f, 
    0.04450179f, -0.05352033f, -0.07393945f, 0.02017747f, 0.00186531f, 0.00194725f, -0.10094692f, -0.08684056f, 
    0.07288191f, -0.08283939f, 0.01459046f, -0.02465777f, 0.03307541f, -0.05710051f, -0.06193942f, -0.06342140f, 
    0.01380768f, 0.06677505f, 0.01878141f, -0.06087868f, -0.06761586f, -0.03321993f, -0.05424994f, 0.03627878f, 
    -0.05828189f, -0.04916316f, -0.00299769f, -0.07121304f, -0.05394264f, 0.01564224f, -0.02887540f, -0.01304836f, 
    -0.05559498f, 0.04115499f, -0.02390114f, -0.04794418f, 0.00002935f, -0.09378819f, 0.04550869f, 0.05779179f, 
    0.03578763f, -0.01238715f, 0.03392370f, -0.01570508f, -0.06428373f, 0.00403879f, -0.05036213f, 0.04793716f, 
    0.01659966f, -0.05294958f, 0.02510804f, 0.00761579f, -0.03508353f, 0.04015368f, -0.07670414f, -0.06613322f, 
    -0.04087948f, 0.06991988f, -0.06121657f, -0.02922107f, 0.05805452f, 0.05275246f, -0.10878032f, 0.03909964f, 
    0.08094489f, -0.00117943f, 0.04155836f, 0.00398677f, 0.02504999f, 0.00986113f, -0.03427605f, -0.03284999f, 
    0.02714404f, 0.05370536f, 0.02635895f, -0.02927814f, -0.09013520f, -0.07377195f, -0.08987208f, -0.06642155f, 
    -0.01448710f, 0.01686293f, 0.02554497f, -0.02762586f, 0.05963375f, 0.03238425f, -0.03487372f, 0.02566679f, 
    0.05962115f, 0.02608715f, -0.06214322f, 0.05588891f, 0.04571033f, 0.02658947f, 0.05823027f, -0.06908017f, 
    -0.02384242f, -0.02951973f, -0.07198569f, 0.02943662f, 0.02596710f, 0.07346430f, -0.04071919f, -0.01491142f, 
    -0.02407386f, -0.07628427f, -0.00318957f, 0.01597507f, 0.03074368f, -0.03545638f, 0.00717770f, -0.07130694f, 
    0.04423500f, -0.07347465f, 0.02488261f, -0.00158521f, -0.07615370f, -0.07142522f, -0.05380037f, 0.00297135f, 
    -0.03119474f, 0.01635034f, 0.05608325f, -0.02920465f, 0.04060625f, -0.03786987f, -0.06560140f, -0.01694807f, 
    -0.04954968f, 0.05827460f, -0.06251105f, -0.02270929f, 0.04819481f, 0.07336789f, -0.03189339f, 0.02883933f, 
    -0.08883690f, -0.04197038f, -0.03973885f, -0.06000428f, -0.07058804f, -0.08330888f, -0.02468164f, 0.00024087f, 
    -0.06685775f, -0.00495227f, -0.09678003f, -0.01241015f, -0.03787368f, 0.01653209f, -0.01624040f, -0.10271464f, 
    -0.04127740f, -0.08923479f, 0.05379509f, 0.01484073f, 0.05919785f, -0.06626444f, -0.01589454f, -0.02140533f, 
    -0.03897483f, -0.01312783f, -0.02311162f, -0.07008077f, -0.00588381f, -0.06618690f, -0.00974240f, -0.04066084f, 
    0.01703647f, 0.02317059f, 0.02456904f, -0.06614213f, -0.02574453f, -0.03143224f, -0.07862636f, -0.04076557f, 
    0.05060614f, 0.05667237f, -0.05761137f, -0.06856284f, -0.01162619f, 0.01990439f, -0.11816902f, -0.05958668f, 
    0.02152682f, -0.11174066f, 0.00682351f, -0.10859266f, -0.08257853f, 0.03609376f, 0.02545578f, -0.08493591f, 
    0.03857255f, -0.02258853f, 0.02359551f, -0.02042843f, 0.03114822f, 0.03253064f, -0.03660241f, -0.06861604f, 
    -0.01919344f, -0.04145920f, 0.03837161f, -0.07967486f, -0.02584855f, -0.08872300f, -0.06012100f, 0.06472728f, 
    0.02234120f, -0.08561043f, 0.03283511f, -0.00200228f, -0.04203795f, -0.08175766f, -0.07248703f, -0.00426656f, 
    0.04449688f, -0.04882089f, 0.01055535f, -0.03059545f, -0.05596175f, 0.04381347f, -0.00093427f, 0.07130235f, 
    0.01767049f, 0.03502741f, 0.06058867f, -0.09916944f, 0.00302267f, 0.00836437f, 0.04443933f, -0.06804547f, 
    -0.02000464f, -0.07449372f, -0.00768171f, -0.00771461f, -0.06087402f, -0.06035487f, -0.06243996f, -0.01910561f, 
    -0.05445944f, -0.05858479f, -0.01068699f, 0.05385020f, -0.03955728f, -0.09016081f, -0.01241622f, 0.01507713f, 
    -0.05202377f, -0.06340775f, -0.05095683f, -0.06810609f, 0.05465764f, -0.04154451f, -0.01079232f, 0.04134432f, 
    0.04375972f, 0.11281528f, -0.10736239f, 0.17653176f, 0.34493566f, -0.09865173f, 0.19310467f, 0.03859315f, 
    0.02160715f, 0.23877278f, 0.04896369f, -0.17519459f, -0.04405696f, -0.14137590f, 0.13728954f, 0.21560486f, 
    0.23730811f, 0.23295195f, -0.20452932f, 0.20388645f, -0.05354092f, 0.04334000f, 0.27856243f, -0.20012015f, 
    -0.05254523f, -0.02168716f, 0.00630940f, 0.05704289f, 0.09801181f, 0.14321378f, 0.19207229f, 0.28059062f, 
    -0.02470545f, 0.06011932f, -0.08779837f, 0.16261280f, -0.06909779f, -0.20535356f, 0.18157056f, -0.05618759f, 
    -0.25570160f, 0.06510715f, 0.12283649f, -0.02677555f, 0.05146693f, 0.22824118f, -0.02795349f, 0.17732318f, 
    -0.14775161f, -0.06619196f, -0.03080726f, 0.22172058f, -0.00262639f, 0.08138785f, -0.21137618f, 0.02629418f, 
    0.17033505f, 0.07344950f, -0.12090012f, 0.11664955f, 0.01271800f, -0.17194462f, -0.18902723f, -0.28425276f, 
    0.26029766f, -0.01082581f, 0.10413652f, -0.12000195f, -0.04203086f, -0.06567625f, -0.41282243f, 0.23843028f, 
    0.27837339f, -0.23275457f, -0.12383677f, -0.11815035f, 0.03941684f, 0.16282724f, 0.10926518f, 0.08574761f, 
    -0.09122842f, -0.15799239f, -0.00706492f, 0.05176974f, -0.31435165f, 0.42647350f, 0.11150952f, 0.15783790f, 
    0.13809583f, -0.25535703f, 0.13530335f, -0.06468353f, 0.04366563f, -0.11925408f, 0.31820381f, 0.51843357f, 
    -0.06409617f, 0.26830712f, -0.03004117f, -0.11097235f, 0.14788122f, -0.05745189f, 0.06923135f, 0.39626408f, 
    0.03135929f, -0.02212247f, 0.20674309f, 0.02256697f, -0.05406881f, -0.03278453f, -0.16177893f, 0.28130898f, 
    0.28538647f, -0.03042916f, -0.14824837f, 0.14652102f, -0.13348328f, -0.14075132f, 0.04075908f, -0.01360080f, 
    -0.17372875f, 0.18827936f, -0.00333456f, 0.04901967f, -0.04266438f, -0.13097663f, 0.10970888f, 0.03986341f, 
    -0.00532946f, 0.19851060f, 0.15257651f, 0.32570106f, 0.02791180f, -0.16697493f, -0.02466181f, 0.09074615f, 
    0.01161615f, 0.11624092f, -0.28242555f, 0.06115147f, 0.18852912f, -0.04307847f, 0.24090430f, 0.22951809f, 
    0.12300628f, 0.08379136f, -0.43389732f, 0.28919789f, 0.17218818f, -0.24621502f, 0.15362459f, -0.27898103f, 
    0.00295573f, -0.10838804f, -0.07623046f, -0.03113223f, 0.43733445f, 0.12740581f, 0.21793517f, 0.18124111f, 
    0.08589827f, -0.20555615f, 0.06160034f, -0.19960843f, -0.29705173f, -0.29453975f, -0.00633440f, -0.50408077f, 
    0.12596184f, -0.21835558f, 0.07774306f, 0.23459990f, -0.24155536f, -0.25777036f, -0.27419260f, 0.30991822f, 
    0.14367719f, 0.34222698f, 0.14094459f, 0.09364702f, -0.03500522f, 0.34076020f, -0.14230637f, 0.30339435f, 
    0.05566571f, 0.58939451f, 0.03226852f, -0.36669338f, -0.14794116f, 0.06743960f, -0.18365140f, 0.02725768f, 
    -0.19529268f, -0.04680715f, 0.00179382f, -0.04678020f, -0.03022711f, 0.02638950f, 0.43041575f, -0.34181333f, 
    0.27862844f, -0.01137511f, -0.04875971f, 0.25882003f, -0.33763582f, -0.18308829f, -0.20107050f, -0.00838183f, 
    -0.09396672f, 0.01288218f, 0.06690199f, 0.08259674f, -0.15514895f, 0.52739131f, -0.14408009f, 0.38820353f, 
    -0.06572050f, -0.31508315f, 0.29154640f, -0.23507164f, -0.11863434f, -0.37420374f, -0.22660711f, 0.05117895f, 
    0.20680282f, -0.08482129f, -0.03405356f, -0.03995734f, -0.24312596f, 0.01430222f, 0.06130256f, 0.48478293f, 
    0.14507939f, -0.08609844f, -0.02233308f, -0.16851825f, -0.06654651f, 0.05778317f, 0.06603824f, 0.02945533f, 
    0.05163640f, -0.01106515f, -0.01074904f, -0.40045202f, 0.40877220f, 0.17238241f, -0.17921416f, -0.00563225f, 
    -0.65333658f, -0.31272867f, 0.00073411f, 0.04278177f, 0.12039150f, -0.16527422f, 0.15522067f, -0.13019371f, 
    0.05735593f, 0.00770467f, 0.03418146f, -0.36823866f, -0.12246601f, 0.24276979f, -0.27453989f, -0.12483016f, 
    -0.09341979f, -0.07194813f, 0.21121302f, 0.11992566f, 0.58903003f, 0.28405523f, -0.24661429f, -0.46864989f, 
    -0.05508670f, -0.12991276f, -0.13804884f, -0.67657870f, -0.02483513f, -0.01505405f, -0.04261236f, 0.22000727f, 
    -0.06130948f, 0.00960667f, -0.03409099f, -0.30672070f, -0.23307106f, -0.14918306f, -0.01534418f, 0.02517821f, 
    0.02647844f, 0.09108672f, 0.04161832f, -0.08793158f, 0.20697168f, 0.29662398f, -0.09392274f, -0.29089886f, 
    -0.04910169f, -0.00386585f, 0.41812637f, -0.05277863f, 0.10441808f, 0.03409768f, 0.01568531f, -0.29441294f, 
    0.09171393f, -0.11069757f, -0.05602129f, 0.25774029f, 0.09671123f, -0.04859024f, 0.33305514f, -0.03981521f, 
    -0.00990001f, -0.07188054f, 0.08692139f, 0.35469478f, 0.14497824f, -0.05125828f, 0.21131824f, 0.27025366f, 
    -0.00098300f, 0.00007293f, 0.38163757f, 0.01331737f, -0.04561795f, 0.06291807f, -0.15288772f, 0.28162193f, 
    -0.24657172f, 0.12045406f, -0.09672689f, 0.03433058f, 0.27895480f, -0.12459137f, 0.35953799f, 0.10982701f, 
    0.48468101f, -0.02626269f, 0.02706645f, 0.08970036f, 0.33701324f, -0.25497237f, 0.16390687f, -0.00505707f, 
    -0.15512858f, 0.48171100f, -0.24070646f, 0.05174409f, 0.20747931f, 0.22214280f, -0.08644815f, 0.28744146f, 
    0.06678410f, -0.17713673f, 0.00999065f, 0.19142255f, 0.17136364f, -0.06526534f, -0.06954806f, -0.28477362f, 
    -0.23108542f, 0.12938713f, -0.20624426f, 0.50947493f, 0.01874329f, -0.03713918f, 0.02841961f, -0.16071253f, 
    -0.05817388f, -0.07068165f, -0.29156289f, -0.02743902f, -0.34325838f, -0.08063883f, 0.19280654f, -0.05057479f, 
    0.45103526f, 0.11228860f, 0.08861634f, -0.00890756f, 0.18309967f, 0.24939646f, -0.06541333f, 0.27658436f, 
    0.01046091f, 0.02743198f, -0.42461118f, 0.02943684f, 0.24269892f, 0.03569245f, 0.15557438f, 0.24679306f, 
    0.06568436f, 0.24002561f, 0.07044148f, 0.01149543f, 0.03556617f, -0.01864600f, 0.06424584f, 0.06622622f, 
    0.30390233f, -0.08866511f, -0.26198998f, 0.15338382f, -0.11734235f, -0.01211157f, 0.09812990f, -0.05997748f, 
    0.06419754f, -0.03659863f, 0.03129524f, 0.09928993f, 0.10333978f, 0.05162966f, -0.10519702f, -0.11435180f, 
    -0.03674586f, 0.11993516f, -0.33456361f, -0.04328456f, 0.22206162f, -0.01639633f, -0.06407230f, -0.74939716f, 
    -0.00203930f, -0.18368438f, -0.06516296f, 0.11527029f, -0.21757592f, 0.00712552f, 0.44937789f, 0.05098755f, 
    -0.01279947f, 0.04273423f, 0.10230878f, 0.27586108f, -0.00745729f, 0.13169594f, -0.48154232f, 0.02133113f, 
    0.17734885f, 0.42014128f, 0.06115396f, -0.18442699f, -0.35365847f, -0.32893530f, -0.05993490f, -0.05789284f, 
    0.22442359f, 0.10695978f, -0.01079178f, -0.02419803f, 0.16384441f, 0.08105590f, -0.40205693f, -0.06543692f, 
    0.17540327f, -0.56760597f, 0.16074055f, 0.21413226f, -0.11314489f, 0.05170164f, -0.02417731f, -0.06747032f, 
    -0.22237945f, 0.40665632f, 0.02844219f, 0.04301101f, -0.03196452f, -0.03418394f, -0.00511348f, -0.08375009f, 
    -0.03484078f, -0.36160752f, -0.27988157f, 0.05593310f, 0.15262680f, 0.25781345f, -0.01103996f, 0.44810516f, 
    0.05751467f, -0.28221756f, -0.02072790f, 0.26019311f, -0.13422574f, 0.03375162f, 0.27821022f, 0.09457612f, 
    0.05098416f, 0.20200625f, 0.14489861f, -0.37152040f, 0.00461808f, -0.04112659f, 0.05403293f, 0.04046397f, 
    0.21870662f, 0.02254777f, -0.01098506f, 0.20906256f, 0.11523224f, 0.17517956f, 0.05978484f, -0.03314750f, 
    -0.18091737f, -0.19404148f, -0.24094933f, 0.02140632f, 0.10947790f, 0.16542079f, 0.04730886f, 0.02573551f, 
    -0.02001300f, 0.05853556f, -0.10443790f, 0.00849061f, -0.12335272f, -0.00621478f, -0.15980345f, -0.04740718f, 
    -0.11077210f, -0.04620976f, 0.00332567f, -0.19640836f, 0.29825613f, 0.09356630f, 0.03446466f, -0.26876098f, 
    -0.08571259f, 0.27587834f, -0.22236028f, -0.11696976f, 0.03569087f, 0.07655956f, 0.22794224f, -0.12867644f, 
    -0.00883039f, -0.18984823f, 0.03871354f, -0.03236582f, 0.00668628f, 0.20213707f, 0.08708456f, 0.35159358f, 
    0.03495277f, 0.05192369f, -0.12052169f, 0.06784245f, 0.07492762f, 0.22506204f, -0.00583684f, 0.64431208f, 
    0.31951198f, -0.01673244f, -0.34441882f, -0.19245066f, 0.06403826f, 0.20852117f, -0.78306651f, -0.17532653f, 
    -0.04888761f, 0.09075112f, -0.13428244f, 0.21748877f, -0.01866748f, 0.09659413f, -0.16398743f, 0.14742233f, 
    -0.01584270f, 0.18012802f, -0.16188839f, 0.07874060f, 0.13006248f, -0.05706375f, -0.04725979f, 0.02501534f, 
    0.24262439f, -0.04131370f, 0.19967990f, -0.06936178f, 0.02782682f, 0.01460743f, 0.08133210f, 0.23890322f, 
    -0.35027102f, -0.01366200f, -0.43446144f, -0.09574690f, 0.00769498f, 0.03234813f, 0.20725319f, 0.18240167f, 
    0.04646199f, -0.04914198f, -0.07319340f, -0.07031918f, -0.06053609f, 0.00319792f, 0.28717119f, -0.02605392f, 
    0.52987421f, 0.31367230f, 0.25861388f, -0.08535748f, 0.28222251f, -0.02609933f, -0.29907474f, 0.35306671f, 
    0.14231898f, 0.13620253f, -0.07168848f, -0.07759333f, 0.03378160f, 0.01730129f, -0.11032915f, -0.12156516f, 
    0.01336120f, -0.17060234f, -0.00736372f, -0.16565396f, -0.02003804f, 0.13162880f, 0.02849306f, 0.21670879f, 
    0.26217753f, -0.08475231f, 0.20382784f, 0.01886606f, -0.23029409f, -0.06625692f, -0.11480032f, -0.05082730f, 
    -0.24765179f, 0.25871029f, -0.03072770f, 0.00634306f, 0.02301699f, -0.07378984f, 0.12400848f, 0.12469088f, 
    0.01382318f, 0.09609257f, 0.16120785f, 0.04352029f, -0.20283715f, 0.13080938f, -0.19754779f, -0.27752748f, 
    0.17635803f, 0.09405324f, 0.07600483f, -0.21913604f, -0.11627638f, 0.01765494f, -0.21585213f, 0.13651073f, 
    0.06910091f, 0.19301052f, -0.31222659f, -0.02147724f, 0.24131621f, -0.17670906f, 0.04271833f, -0.04934147f, 
    -0.16997467f, 0.17495759f, 0.16717996f, -0.02434312f, 0.04107599f, -0.06339584f, 0.16237828f, 0.25140998f, 
    0.00741760f, 0.05569128f, 0.04381290f, 0.09436223f, -0.10789969f, 0.33172250f, -0.12079474f, 0.38913143f, 
    -0.14525378f, -0.06547784f, -0.03448738f, 0.12449407f, 0.21064501f, -0.02760011f, -0.16863433f, 0.16736175f, 
    0.22919391f, -0.09000883f, -0.00446202f, 0.09132832f, -0.04048563f, 0.12946434f, -0.09710685f, 0.21772520f, 
    -0.05824357f, -0.18682954f, -0.14308745f, 0.16946279f, 0.05713284f, -0.22102356f, 0.20921859f, 0.23145309f, 
    -0.13177630f, -0.03728930f, 0.06057264f, 0.00010886f, 0.29419625f, -0.01603349f, 0.52996719f, 0.05164052f, 
    -0.14454071f, 0.26942497f, -0.38495263f, 0.15776893f, 0.12443206f, -0.40587562f, 0.32777861f, 0.15009257f, 
    -0.00764440f, -0.20886518f, 0.01285800f, 0.24709186f, 0.17321180f, -0.04617095f, -0.03826109f, 0.04081040f, 
    0.23733400f, -0.11924629f, 0.34309506f, -0.13422062f, -0.01419427f, -0.15790009f, -0.38378602f, -0.19541126f, 
    0.09422692f, 0.12303124f, 0.03844343f, 0.00203939f, -0.25695759f, 0.00806708f, -0.19816175f, -0.15065946f, 
    0.08034015f, -0.30702502f, -0.09004094f, -0.23137446f, 0.45351133f, 0.03961634f, 0.58474594f, 0.09889859f, 
    -0.19116765f, 0.02654263f, -0.24501926f, -0.15217914f, 0.26791692f, -0.00879379f, -0.24390478f, 0.06834165f, 
    -0.13418576f, -0.12141278f, -0.43834120f, -0.03447875f, 0.07899021f, 0.10127194f, 0.36329320f, 0.12323201f, 
    0.06594607f, -0.04331743f, -0.33112189f, -0.16962747f, -0.10969801f, 0.03606661f, 0.03759556f, 0.02487367f, 
    0.09821481f, 0.11224753f, 0.09191598f, -0.01074684f, -0.24191719f, -0.02867700f, 0.19256231f, -0.03757598f, 
    0.10390638f, -0.11263152f, 0.35483453f, -0.12665857f, -0.12443551f, 0.08725226f, -0.04099785f, 0.05561196f, 
    0.07342995f, 0.11630151f, 0.24611887f, 0.06940563f, -0.21539631f, 0.11056391f, -0.02206678f, 0.02517310f, 
    0.03047416f, 0.13738638f, -0.25239128f, 0.11061239f, 0.12171138f, 0.19037341f, 0.22759317f, -0.08266659f, 
    0.22619149f, 0.24151509f, -0.14378197f, -0.06700463f, -0.14684004f, 0.18669978f, 0.40775329f, -0.03856122f, 
    -0.09982547f, -0.04401713f, -0.19012445f, 0.11649731f, -0.02679672f, -0.16101457f, -0.18156080f, 0.00676603f, 
    -0.06109892f, -0.03237871f, 0.11219020f, 0.13518392f, -0.04853066f, -0.38135529f, -0.03062427f, -0.10528470f, 
    0.35023233f, 0.00973676f, -0.04452476f, 0.09782115f, -0.02796739f, 0.11918444f, -0.72697371f, 0.14389890f, 
    -0.13497232f, -0.49851131f, -0.03299061f, 0.11672438f, 0.20784485f, 0.26120263f, -0.05975036f, 0.00420300f, 
    -0.35963699f, 0.25739920f, -0.04758300f, 0.05905055f, -0.01080392f, -0.15453611f, 0.00191355f, -0.08583352f, 
    0.06416924f, -0.31718597f, -0.30248925f, 0.00462182f, -0.01423112f, 0.20457539f, 0.42154178f, 0.25238577f, 
    -0.09352545f, 0.21925819f, 0.03422360f, 0.19897790f, -0.26070955f, 0.13029788f, 0.09988073f, -0.16428758f, 
    0.01926150f, 0.02058599f, 0.08946810f, -0.17480353f, 0.00728293f, 0.11698424f, -0.16006105f, 0.14246964f, 
    -0.04554561f, -0.00888132f, -0.05684058f, 0.01639052f, -0.18072724f, 0.07861848f, -0.02926687f, -0.07860823f, 
    -0.19164892f, 0.08269983f, -0.09670157f, 0.07961569f, 0.02373296f, 0.00161011f, -0.13489483f, 0.05136958f, 
    -0.06377718f, 0.04572720f, 0.03058301f, 0.02272275f, -0.00421729f, -0.08495443f, -0.06063364f, 0.03793429f, 
    -0.05884308f, 0.05093556f, 0.05484521f, 0.00295204f, -0.03451082f, 0.04012028f, 0.01623956f, -0.08276410f, 
    0.02649401f, 0.04097667f, -0.00774406f, -0.01070022f, -0.06035566f, 0.05394328f, 0.03574695f, 0.03977436f, 
    -0.03894052f, -0.07704072f, -0.07023661f, -0.00727661f, 0.02578561f, 0.07225863f, 0.02293954f, 0.02094050f, 
    0.07974906f, -0.04583651f, 0.04289002f, -0.09513884f, -0.00509644f, -0.06758250f, -0.00272130f, -0.05347567f, 
    -0.08244509f, -0.00670407f, 0.02707096f, -0.08725477f, -0.00103382f, 0.00784414f, 0.02553729f, -0.00026258f, 
    -0.08355565f, -0.05627144f, -0.03181111f, 0.04292317f, -0.03734037f, -0.02406610f, 0.01710175f, -0.00341173f, 
    -0.07814857f, -0.08709761f, 0.01274850f, 0.07287329f, -0.06426865f, 0.04588939f, -0.05776910f, -0.09280046f, 
    -0.00579420f, -0.07116304f, 0.04720267f, -0.07770932f, 0.02572918f, -0.06965324f, -0.08149211f, -0.01965322f, 
    -0.03676640f, 0.06205263f, -0.03493665f, -0.04888771f, 0.01857392f, -0.06766863f, 0.04104307f, -0.08445370f, 
    -0.01883091f, -0.08986784f, -0.07447618f, -0.10561464f, 0.01204557f, -0.03361923f, -0.02135743f, -0.06980484f, 
    -0.10195740f, 0.02846080f, -0.08098426f, -0.09596065f, -0.04714328f, -0.05606919f, -0.00848030f, -0.06205631f, 
    -0.08837458f, 0.06740396f, 0.02731812f, -0.02350328f, 0.02024961f, 0.02329839f, -0.00843972f, -0.07353545f, 
    0.07315117f, -0.04083556f, -0.01747238f, -0.07518511f, -0.02026929f, -0.01295708f, 0.03091682f, 0.05814365f, 
    -0.05328426f, 0.00213752f, -0.05481033f, -0.03353097f, -0.00512355f, -0.01542685f, -0.03124455f, -0.02660354f, 
    0.06364410f, -0.08428168f, -0.00591917f, -0.01776771f, -0.06595004f, -0.03720130f, 0.02794432f, -0.08752988f, 
    0.02581349f, 0.26042381f, -0.16368033f, 0.15603295f, 0.46016625f, -0.01595403f, -0.18861219f, -0.27046087f, 
    0.08570915f, 0.36652207f, 0.08903453f, -0.28742343f, -0.01757931f, -0.16204213f, -0.15046278f, 0.26419324f, 
    0.40302414f, 0.22304653f, 0.16458330f, 0.17687595f, -0.06250519f, -0.16286373f, 0.12156633f, -0.04097623f, 
    -0.06624974f, 0.42704296f, 0.09650348f, 0.10242921f, -0.18358999f, -0.14740758f, 0.25281703f, 0.04846336f, 
    -0.02632521f, 0.01180492f, -0.26634118f, 0.29650360f, -0.33140388f, -0.07187127f, 0.15988095f, 0.15776777f, 
    -0.24258418f, -0.12101699f, -0.12914407f, 0.11902206f, -0.03353380f, 0.10463772f, 0.32766840f, 0.26265165f, 
    0.13234644f, -0.47399089f, -0.08985779f, -0.16617067f, 0.02478694f, -0.10424370f, -0.18694057f, -0.03139251f, 
    0.14454681f, -0.18322593f, -0.03630926f, 0.16290189f, -0.06484914f, -0.22646829f, 0.04016211f, -0.00209036f, 
    0.32071665f, -0.20656444f, 0.02028749f, 0.00109891f, 0.31842336f, -0.08968258f, -0.40247297f, 0.16325121f, 
    0.30424821f, 0.31710544f, -0.13855821f, 0.06469830f, 0.13576949f, -0.06234816f, 0.21212360f, -0.15964514f, 
    0.13229707f, -0.08751233f, 0.09703253f, 0.09424657f, -0.16726048f, -0.08270949f, -0.28517997f, -0.21606973f, 
    0.15897809f, -0.07389310f, -0.07555812f, -0.06523687f, 0.16286387f, -0.30494741f, 0.36951214f, -0.01527352f, 
    0.05008882f, 0.15225050f, 0.08139331f, -0.06132670f, -0.11588044f, 0.02575777f, -0.21892719f, 0.22133444f, 
    0.19972803f, -0.09240293f, 0.04941668f, 0.23516244f, -0.00621052f, -0.01915430f, 0.28310052f, 0.05936110f, 
    0.07238498f, -0.00817979f, -0.28560403f, 0.02952380f, -0.15864699f, 0.06611890f, 0.07093088f, -0.03315734f, 
    -0.27027640f, -0.02631352f, 0.18955882f, -0.02129235f, 0.00190189f, -0.05328683f, 0.07152446f, 0.12260981f, 
    0.05759203f, 0.22527313f, -0.28945932f, -0.09518943f, 0.18011524f, 0.12977457f, -0.02967065f, 0.15648472f, 
    -0.03517739f, 0.22963420f, 0.12626706f, -0.02589009f, 0.09451390f, 0.05278422f, 0.00490364f, 0.11766323f, 
    0.30052266f, 0.01936789f, -0.30730054f, 0.23674780f, -0.18243995f, -0.10923539f, -0.02579158f, -0.00525428f, 
    0.01970391f, 0.05416059f, 0.05796776f, 0.13839404f, -0.08570846f, -0.21519563f, 0.04669294f, -0.13554408f, 
    0.09248712f, 0.18343431f, -0.33788618f, -0.04960652f, 0.24982370f, -0.07097450f, -0.12837473f, -0.60472864f, 
    -0.32744852f, -0.17648855f, 0.01220790f, 0.10057922f, -0.10036808f, 0.13389304f, 0.68562245f, -0.04618031f, 
    0.14660092f, -0.24402320f, 0.14356159f, 0.14602567f, 0.01157329f, 0.14564744f, -0.09930042f, -0.08622606f, 
    0.23596443f, 0.30603710f, 0.00020057f, 0.14564076f, -0.18853661f, -0.09476338f, -0.12259521f, 0.11654329f, 
    0.13202463f, 0.00610508f, 0.13976777f, -0.00956194f, 0.16058187f, -0.07409532f, -0.53700835f, -0.02228314f, 
    -0.08249517f, -0.14257790f, 0.26441574f, 0.21859530f, 0.11866911f, -0.09078798f, 0.02137751f, -0.12725510f, 
    0.65883023f, 0.35833025f, 0.07069253f, 0.03670559f, 0.06507391f, -0.13646367f, -0.09292102f, -0.20627807f, 
    0.03696441f, -0.12163074f, -0.41060498f, 0.18825093f, 0.08355471f, 0.24316736f, 0.00684172f, 0.45687845f, 
    0.06329703f, -0.17842135f, 0.04394412f, 0.25545934f, -0.28386462f, 0.02475385f, 0.16052423f, -0.17307664f, 
    0.00168330f, 0.16333948f, 0.02324766f, 0.43879858f, 0.02648528f, -0.01003091f, -0.03154770f, -0.06281336f, 
    -0.03488272f, -0.04400619f, -0.19319360f, 0.36781603f, 0.06835260f, 0.30617458f, 0.23225664f, 0.02637844f, 
    0.09280736f, -0.13071023f, 0.04689731f, -0.01014461f, 0.00928882f, 0.17429236f, -0.27849561f, 0.06863487f, 
    -0.01536774f, -0.00016486f, 0.04461582f, 0.06754319f, -0.02091057f, 0.00229029f, -0.03966452f, -0.04832307f, 
    -0.07111293f, 0.06039393f, 0.03058340f, 0.04159022f, -0.05800552f, -0.05465868f, 0.00820966f, 0.00287371f, 
    -0.04657296f, 0.04300348f, -0.05667870f, 0.01325319f, -0.09287050f, -0.05024102f, -0.12238008f, -0.06268752f, 
    -0.09967025f, 0.07459955f, -0.03241666f, -0.00279807f, -0.06237148f, -0.03095603f, 0.02653613f, 0.01745368f, 
    -0.06089089f, -0.02640164f, -0.00701368f, -0.02182008f, -0.04882855f, -0.07008152f, -0.01517886f, -0.07803357f, 
    -0.03701308f, -0.09271564f, 0.04803691f, -0.10564189f, 0.02149564f, -0.11447405f, 0.05273544f, -0.07999370f, 
    0.01843771f, 0.03690994f, 0.03125120f, -0.05781907f, -0.05144225f, -0.09464660f, 0.02181704f, 0.01036246f, 
    -0.03215353f, -0.05710202f, -0.07844394f, -0.06876743f, 0.07140797f, 0.03322964f, 0.03068652f, 0.01406173f, 
    -0.06631529f, -0.00492838f, 0.01518415f, 0.03511596f, -0.09122790f, -0.03803168f, -0.08114972f, -0.09112705f, 
    0.05866341f, 0.00236961f, -0.03362862f, 0.02768135f, -0.02032841f, -0.00225286f, -0.04810075f, 0.02081301f, 
    0.06552657f, -0.06560893f, 0.02805471f, -0.05379740f, -0.03679239f, 0.06224596f, 0.04931098f, -0.07790700f, 
    -0.04724845f, 0.01686065f, -0.01851205f, -0.09965000f, -0.01484624f, 0.03489301f, -0.02074217f, 0.01028036f, 
    -0.08453409f, 0.02953807f, 0.00796807f, 0.05144802f, 0.02719692f, 0.01168865f, -0.08641431f, -0.01622024f, 
    0.00921008f, -0.00941537f, 0.03600336f, -0.01054242f, -0.01884712f, 0.07337562f, 0.05644841f, 0.04985294f, 
    0.00775926f, 0.02968054f, -0.00660273f, 0.02607106f, 0.00567699f, 0.01970034f, -0.01861949f, -0.03972054f, 
    0.03836627f, -0.02492866f, -0.01886082f, -0.04206277f, 0.05633225f, 0.00385609f, -0.07936957f, -0.09685749f, 
    0.05899040f, 0.18283336f, -0.07305124f, 0.24490680f, -0.03366132f, -0.15878345f, 0.08276712f, 0.04252303f, 
    0.03849449f, 0.05050080f, 0.01401429f, -0.17980638f, -0.35947120f, -0.06770055f, -0.08647488f, 0.19574921f, 
    0.04615794f, 0.32949379f, -0.06244214f, 0.23508476f, 0.07914376f, 0.46009773f, 0.31677821f, -0.01459541f, 
    0.04188018f, -0.09497861f, 0.06855649f, 0.18946569f, 0.16822240f, 0.05649422f, 0.00113018f, 0.10972082f, 
    -0.02878747f, -0.01116273f, -0.00104666f, 0.24112661f, 0.03605735f, -0.16017951f, -0.00034473f, 0.57650948f, 
    0.20807724f, -0.41836283f, -0.26073095f, -0.04762958f, 0.03601376f, -0.00404647f, -0.17277043f, 0.06437042f, 
    -0.05776029f, -0.00413696f, 0.16976121f, 0.10112929f, -0.01928137f, 0.15333842f, -0.29456198f, -0.10094959f, 
    0.07750265f, -0.33346093f, -0.02665073f, -0.18733348f, -0.25722384f, 0.08828022f, 0.15165022f, -0.06393037f, 
    0.05726829f, -0.02644387f, 0.08365026f, -0.06031023f, 0.10740321f, -0.05854485f, -0.43208531f, -0.25651264f, 
    -0.25486487f, -0.18974587f, 0.22723354f, 0.09177607f, 0.05719560f, -0.15522523f, 0.20860174f, 0.29538077f, 
    0.02160219f, 0.03934406f, 0.12111823f, 0.12606852f, 0.00012122f, -0.11734667f, 0.05007584f, -0.06360687f, 
    0.30266815f, -0.50078386f, 0.08644868f, 0.12644812f, 0.06568558f, -0.21384175f, -0.07581392f, 0.05945597f, 
    -0.04055518f, -0.04968535f, 0.02534314f, -0.15284243f, 0.11595122f, -0.01348383f, -0.08963310f, -0.08335679f, 
    0.14480653f, 0.31313926f, 0.13334171f, -0.43604928f, 0.08968699f, 0.05912259f, 0.15828532f, 0.00913643f, 
    0.19207947f, -0.05026445f, 0.21017087f, 0.27360821f, 0.10972137f, 0.25318921f, 0.05321173f, -0.01657099f, 
    -0.06851491f, -0.06559607f, -0.33776855f, -0.07832319f, 0.08874382f, 0.06454068f, 0.37592366f, -0.05045414f, 
    -0.00896994f, -0.01354570f, 0.09658479f, -0.02346128f, -0.47201893f, 0.03078084f, 0.16050817f, 0.00912966f, 
    -0.09197464f, 0.33455229f, -0.03096686f, 0.04240710f, -0.11070890f, -0.14669558f, 0.21909498f, 0.38136831f, 
    0.50464028f, 0.16471307f, 0.51403457f, 0.22965714f, -0.23229662f, 0.39738297f, 0.21710370f, 0.14659399f, 
    0.07496450f, 0.00036515f, 0.02990102f, -0.01909576f, -0.14257993f, 0.00202462f, 0.04062765f, 0.06185358f, 
    -0.04336820f, 0.06403154f, 0.41161457f, 0.02839541f, -0.07231195f, 0.08090758f, 0.30382797f, -0.01977723f, 
    0.17064513f, -0.43995467f, -0.00092951f, 0.07357632f, -0.14961100f, -0.30347073f, 0.68786955f, 0.38201192f, 
    0.08039524f, -0.13362141f, -0.32834148f, -0.14223030f, 0.00715762f, -0.31666854f, 0.01405037f, -0.02814667f, 
    -0.15630719f, -0.44649205f, -0.00561189f, -0.00691836f, -0.39619464f, -0.24938589f, 0.00250907f, -0.12033246f, 
    0.01594694f, -0.22980639f, -0.43938732f, -0.02531704f, -0.10123412f, -0.08866045f, -0.68595219f, -0.34377149f, 
    -0.56412947f, -0.55813956f, 0.07090735f, 0.22835162f, 0.17337921f, 0.16983165f, 0.04808481f, -0.20929970f, 
    -0.07299883f, -0.01230969f, 0.33254299f, -0.08290061f, -0.24066727f, -0.15694229f, -0.02146845f, 0.10902410f, 
    -0.02863528f, 0.21443664f, 0.12834993f, 0.17499171f, 0.04918458f, -0.01637985f, 0.56777936f, 0.00809888f, 
    -0.07831367f, 0.27224240f, -0.00521849f, -0.16742344f, -0.20725383f, 0.02908287f, -0.42832088f, -0.35970202f, 
    0.21761145f, 0.23145939f, -0.05740082f, 0.35081807f, -0.18267816f, 0.06206721f, -0.06856263f, -0.03741274f, 
    -0.33584321f, -0.03028202f, -0.18324223f, -0.21365562f, 0.04388195f, 0.19922751f, 0.01699180f, -0.03423208f, 
    -0.02057219f, 0.00461289f, -0.73596990f, 0.03631530f, -0.26089573f, -0.07664854f, -0.13149779f, -0.11136643f, 
    -0.01546629f, 0.24266584f, 0.00591834f, 0.20393398f, -0.10328101f, -0.16192450f, 0.01836355f, 0.10672385f, 
    0.02062717f, 0.00830196f, -0.01643055f, -0.03696888f, -0.13371520f, -0.07440732f, 0.06807455f, 0.19153713f, 
    0.10843435f, 0.24016397f, 0.08560886f, 0.03681377f, 0.00654157f, 0.39750776f, 0.32332781f, -0.01831205f, 
    -0.00311705f, -0.29519886f, -0.06466603f, 0.13361409f, 0.17423163f, 0.02682193f, 0.09656570f, 0.19776998f, 
    -0.01225213f, 0.06940024f, -0.07022654f, 0.11710357f, 0.02149268f, -0.13785365f, -0.12317573f, 0.45951501f, 
    0.21086331f, -0.36265349f, -0.10024942f, 0.01417559f, 0.10524812f, 0.03874141f, 0.15086322f, 0.26667345f, 
    0.00971614f, -0.10304842f, 0.05584336f, 0.09627707f, 0.04873637f, 0.16184577f, -0.12893999f, -0.17039035f, 
    0.12614956f, -0.37998611f, -0.07268018f, -0.25678465f, -0.42579219f, 0.05641471f, 0.19739902f, -0.12350291f, 
    0.03785685f, -0.03601367f, 0.11506190f, 0.05423372f, 0.17845538f, -0.13662225f, -0.24476489f, -0.11418667f, 
    -0.21178356f, -0.23841406f, 0.25321612f, 0.09793149f, 0.08069407f, -0.09412879f, 0.24636164f, 0.31357244f, 
    -0.08727667f, -0.02357149f, 0.10975213f, 0.11063050f, -0.00958367f, -0.05810996f, 0.03455580f, -0.02188586f, 
    0.24798916f, -0.51727694f, 0.10608660f, 0.00232332f, 0.13521162f, -0.06190762f, -0.01230664f, 0.09491679f, 
    -0.00537147f, -0.04524324f, 0.04723047f, -0.13046880f, 0.22981711f, -0.03853983f, 0.00814587f, -0.16278373f, 
    0.07729102f, 0.17956409f, 0.16888596f, -0.38204923f, 0.11995816f, -0.00388806f, 0.30013964f, 0.05696134f, 
    0.04212595f, 0.03049934f, -0.05668202f, 0.19327590f, 0.15760824f, 0.26270431f, 0.21565071f, -0.03353261f, 
    -0.01570040f, -0.07449579f, -0.34279263f, 0.01467947f, 0.18644698f, 0.08965734f, 0.23054296f, -0.05505959f, 
    -0.09884479f, -0.14594112f, 0.11738805f, 0.01902005f, 0.05425775f, 0.18195313f, 0.21222976f, -0.03515956f, 
    0.06464643f, 0.34462252f, 0.19137731f, -0.16333079f, 0.13559338f, -0.01272315f, 0.28978121f, 0.04128183f, 
    0.08408091f, -0.03540959f, 0.31809765f, -0.21542619f, 0.04529959f, -0.26088345f, 0.00330593f, 0.03186660f, 
    0.04350534f, 0.24857995f, 0.16909681f, 0.05922424f, -0.12906252f, 0.26810536f, 0.13002655f, 0.18120021f, 
    0.00229145f, 0.18731964f, -0.08704428f, 0.05152610f, -0.03145977f, 0.09638093f, 0.17552741f, 0.11679588f, 
    0.01870249f, 0.45624262f, -0.00906902f, 0.09051101f, 0.09514673f, 0.36063269f, 0.35144854f, 0.20178106f, 
    -0.05611633f, -0.06580018f, 0.04073283f, 0.04334375f, 0.01073296f, -0.42554227f, 0.18156484f, 0.45489693f, 
    0.05214035f, -0.53898072f, -0.09600502f, 0.40123335f, 0.45160633f, 0.10021679f, -0.07084174f, 0.09119470f, 
    0.30840400f, 0.04998754f, 0.09086721f, -0.00029566f, -0.12353140f, 0.09291895f, -0.32587582f, 0.44544476f, 
    -0.01296123f, 0.51346195f, -0.32137454f, -0.11031105f, 0.15526116f, 0.15574792f, 0.19375113f, 0.09767190f, 
    0.07202272f, -0.02632444f, -0.13777524f, -0.13214310f, -0.21013942f, -0.28309712f, 0.03959834f, -0.35273293f, 
    -0.21577771f, 0.26799816f, -0.04153702f, -0.13441874f, -0.07032083f, -0.11461295f, 0.57336771f, 0.33963355f, 
    -0.13374716f, 0.47726363f, 0.00458821f, 0.09363864f, -0.02917675f, 0.00361371f, -0.11867552f, -0.01072765f, 
    -0.03767139f, -0.28650945f, 0.18042433f, 0.29948968f, -0.06812305f, 0.14422145f, -0.15484244f, 0.12570889f, 
    0.03588347f, 0.08231898f, 0.10644531f, -0.20982213f, -0.26406705f, -0.26005232f, 0.07003265f, -0.04255410f, 
    -0.20636778f, 0.25538084f, 0.41603926f, -0.02316803f, -0.12366357f, -0.13594687f, -0.19013977f, 0.11313023f, 
    0.05958288f, -0.10024840f, -0.02684779f, -0.04213508f, -0.04419790f, 0.08255547f, -0.04469395f, -0.10865251f, 
    -0.01332425f, 0.05154530f, -0.07010539f, 0.04141628f, 0.02802284f, -0.02344195f, 0.02316816f, -0.01713065f, 
    0.05160497f, 0.06279472f, 0.04587030f, -0.03079496f, -0.08079115f, 0.08714747f, -0.02095355f, -0.02404364f, 
    -0.08147303f, -0.05790921f, 0.01864265f, -0.10789926f, -0.06122333f, 0.05008904f, 0.00330707f, -0.00720099f, 
    0.00796211f, 0.06941925f, 0.03256056f, -0.04160821f, -0.06383657f, -0.02392126f, -0.02172734f, 0.04053143f, 
    0.03982677f, -0.00625900f, 0.05450212f, 0.03033102f, -0.07389118f, -0.00588672f, -0.05276793f, 0.05445840f, 
    -0.02478342f, -0.10560644f, 0.01491686f, -0.02528932f, 0.02113962f, -0.03209217f, 0.04851510f, -0.09002558f, 
    0.02864394f, -0.06182462f, 0.01941308f, 0.03094921f, -0.07011420f, 0.00638362f, -0.01082152f, 0.02338555f, 
    -0.04132260f, -0.09169997f, -0.06627740f, 0.01283105f, -0.04255836f, -0.01031000f, -0.05836659f, 0.00015669f, 
    -0.05344808f, -0.07360917f, 0.04321512f, 0.05968356f, 0.02106070f, -0.08518198f, -0.09526549f, -0.04641097f, 
    0.03744153f, 0.01023939f, 0.02469454f, -0.02037803f, 0.00421126f, 0.05024870f, 0.05233515f, -0.04333404f, 
    -0.07715439f, -0.05579055f, -0.01205213f, -0.03590986f, 0.02987748f, 0.05433979f, 0.05144869f, 0.06150042f, 
    -0.05131776f, 0.01911930f, 0.08247308f, -0.03502284f, -0.01026682f, 0.05462530f, 0.04368311f, 0.01462144f, 
    0.01847306f, 0.01603076f, 0.02844563f, 0.02875302f, -0.09261920f, -0.04844691f, -0.04793357f, 0.01381231f, 
    0.06017724f, 0.00177972f, -0.03397628f, -0.01542751f, 0.05425189f, -0.10326679f, 0.00629822f, 0.01375894f, 
    -0.06482857f, -0.00878955f, -0.03094031f, -0.03264772f, -0.10629492f, -0.04632569f, 0.06774794f, -0.08175420f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.08520145f, 0.22055553f, 0.03301341f, -0.00755716f, 0.20940402f, 0.23853695f, 0.21160050f, 0.03122169f, 
    -0.01836217f, -0.04971357f, 0.22020808f, -0.06279182f, -0.01626742f, -0.03871214f, -0.09784820f, -0.24304645f, 
    0.12951559f, 0.16295791f, 0.05447635f, -0.04416487f, -0.01209261f, 0.09615433f, -0.01291074f, -0.01114293f, 
    -0.09005176f, -0.00609081f, 0.03944287f, -0.00680578f, 0.17147827f, 0.05550962f, 0.01858379f, 0.08072387f, 
    0.27818188f, -0.10094835f, 0.03225095f, -0.00428349f, 0.16222009f, 0.14918093f, -0.07385761f, 0.05640242f, 
    0.14569049f, -0.01416233f, 0.09593837f, -0.08957482f, -0.12085306f, -0.04609321f, 0.04033517f, -0.05158361f, 
    0.12202903f, 0.03727255f, 0.22978994f, -0.17453288f, 0.02418787f, 0.00457483f, 0.19207855f, -0.01890359f, 
    -0.02472374f, 0.19432247f, 0.06611382f, -0.10061860f, -0.00352599f, 0.11373347f, -0.10824038f, -0.08587547f, 
    0.12844917f, 0.06036982f, -0.05418031f, 0.11199218f, -0.08323204f, -0.08641641f, 0.07494438f, 0.09095933f, 
    0.23020014f, -0.10277571f, 0.04374684f, -0.11631843f, 0.00031533f, 0.06430939f, 0.24767189f, 0.00522754f, 
    0.18356146f, -0.04828125f, -0.10061987f, -0.01890923f, -0.03584587f, -0.12896593f, 0.08155943f, 0.23725863f, 
    -0.04826455f, -0.01033750f, 0.17006433f, -0.08132832f, 0.06160204f, 0.06553778f, -0.11273214f, -0.07971866f, 
    0.04128814f, 0.03661116f, 0.04858088f, -0.01221307f, -0.17038541f, 0.01229073f, 0.00506102f, 0.13189435f, 
    0.05079352f, 0.06085095f, -0.08993841f, -0.03455782f, 0.00872137f, 0.12702881f, 0.08214654f, 0.03303717f, 
    0.05711806f, -0.06319452f, 0.20946230f, 0.12203711f, 0.02408962f, 0.11537330f, 0.02685444f, 0.02426044f, 
    0.18289857f, 0.18815638f, -0.10062630f, 0.18096152f, -0.04843857f, 0.26391634f, -0.08023951f, -0.02178647f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.06760690f, -0.16555922f, -0.03316197f, -0.03569392f, 0.04766215f, 0.04735425f, 0.07833421f, 0.00091240f, 
    0.03142368f, -0.33226204f, -0.00852102f, 0.03369988f, -0.07144769f, 0.17256841f, -0.03251128f, -0.61441326f, 
    0.08775536f, 0.27094719f, 0.06521899f, 0.05497858f, 0.24305680f, 0.08020429f, 0.04455962f, -0.06818391f, 
    -0.06886456f, -0.08286384f, 0.25002390f, 0.18984854f, -0.01820813f, 0.33241624f, -0.38531098f, 0.19302171f, 
    -0.05227439f, 0.02539511f, 0.05398076f, -0.06995803f, -0.03175614f, -0.68228221f, 0.05407034f, 0.07217530f, 
    -0.09949262f, -0.03841234f, 0.19748071f, -0.00356261f, 0.00665978f, -0.02290246f, 0.04471004f, -0.07400838f, 
    0.16939563f, -0.03513473f, -0.15923539f, 0.01466864f, -0.15286361f, 0.03027410f, -0.03352549f, 0.33724737f, 
    0.04143684f, -0.03735024f, 0.07750716f, -0.01422280f, 0.01140156f, -0.17307793f, 0.02164347f, -0.03270920f, 
    0.09853387f, -0.22844855f, -0.06056468f, 0.05931308f, -0.08506853f, -0.06680783f, -0.41675633f, -0.17125648f, 
    0.03425470f, 0.04052364f, 0.01348355f, -0.05665981f, 0.00697074f, -0.02882988f, -1.00322437f, 0.06599414f, 
    -0.06942930f, -0.11032836f, -0.02462633f, -0.02642482f, -0.18785995f, -0.42670384f, 0.08678069f, 0.19095716f, 
    0.08017095f, 0.20343803f, -0.18453099f, -0.02433955f, -0.47667086f, -0.05769805f, 0.03229403f, -0.10732682f, 
    -0.21471885f, 0.15053834f, -0.29092002f, 0.04515505f, -0.36481285f, -0.05451920f, 0.09465156f, -0.10178006f, 
    -0.30896410f, 0.02144929f, -0.02701019f, -0.04836136f, 0.18687427f, 0.10976639f, -0.00514745f, -0.00085245f, 
    -0.03420769f, 0.33491498f, -0.22287686f, -0.02251533f, -0.13185975f, 0.13981082f, -0.37638596f, 0.06804010f, 
    -0.11226690f, -0.16206014f, 0.06954042f, 0.08665970f, 0.13827203f, 0.11570103f, -0.15099885f, -0.06497799f, 
    -0.04303203f, -0.34249485f, 0.02404634f, -0.03132746f, 0.11505277f, 0.10877516f, 0.06644452f, -0.46959308f, 
    -0.01770747f, 0.12449238f, -0.25653601f, 0.05537678f, 0.04628032f, 0.05116643f, 0.03374085f, 0.32462075f, 
    -0.16622764f, -0.18068171f, 0.02238498f, -0.04925122f, 0.27500495f, -0.25426227f, -0.00628627f, -0.02888479f, 
    -0.03423216f, -0.09977431f, -0.09890238f, 0.23050372f, -0.00519800f, 0.07189029f, -0.42896467f, 0.13610023f, 
    -0.03615618f, 0.02127489f, 0.03393772f, 0.07712359f, -0.11848357f, 0.08492617f, -0.09226315f, 0.06188444f, 
    -0.13679370f, 0.06327476f, -0.14392881f, -0.08877584f, -0.21488799f, -0.00384749f, 0.08185204f, 0.18669334f, 
    -0.25686020f, -0.05138163f, -0.49730459f, -0.54236847f, 0.15799139f, 0.12473464f, -0.13604096f, 0.20130339f, 
    -0.21761717f, -0.09997810f, -0.01861706f, 0.00093682f, -0.02037378f, 0.05151332f, 0.04247614f, -0.03779511f, 
    0.13166751f, 0.07921331f, 0.04831083f, 0.10073671f, 0.03115576f, 0.04728141f, -0.39646208f, 0.09446561f, 
    -0.24285115f, 0.03096727f, 0.02171820f, 0.22140713f, 0.02845142f, -0.05861288f, -0.09437511f, 0.01988731f, 
    0.13204308f, 0.04850144f, -0.03317081f, -0.05354781f, 0.15369454f, 0.06495769f, -0.33764032f, 0.25959998f, 
    0.07688998f, 0.11874180f, 0.10553841f, -0.04682303f, 0.13343826f, 0.10497342f, -0.54404944f, -0.00344158f, 
    -0.15449946f, 0.03060770f, 0.13693301f, -0.01981877f, 0.19944128f, -0.05633922f, -0.00996823f, 0.14899336f, 
    -0.00822488f, 0.08014610f, 0.03174921f, -0.01362680f, -0.22270556f, 0.09872288f, 0.04457078f, -0.00700265f, 
    0.00970250f, -0.23625763f, -0.28207919f, 0.20710911f, -0.29257271f, -0.10779654f, 0.18512627f, -0.06684165f, 
    -0.08865526f, 0.04820364f, -0.04521855f, 0.05156981f, 0.24163678f, 0.09537959f, 0.05164450f, 0.05267998f, 
    -0.04432551f, -0.15811317f, -0.05179469f, 0.05263953f, 0.10783935f, -0.33725068f, 0.38861305f, -0.16904539f, 
    0.29258844f, 0.16078378f, -0.45023075f, 0.02204231f, 0.03849372f, 0.15722494f, 0.04186491f, -0.05337159f, 
    -0.22161716f, 0.02073533f, -0.03449544f, -0.07757030f, -0.04894491f, -0.32753515f, 0.11574990f, -0.30217367f, 
    -0.03112616f, 0.04641068f, 0.09547679f, -0.08505971f, 0.29136872f, -0.12701568f, 0.11493342f, 0.20214014f, 
    0.24503513f, -0.07190427f, -0.52591336f, 0.05800244f, 0.37414983f, -0.23348001f, -0.04933668f, -0.01509978f, 
    0.12551554f, 0.02706248f, -0.22420737f, -0.01327942f, -0.52445090f, -0.07361013f, -0.01107573f, -0.34822008f, 
    -0.83201414f, 0.05904125f, -0.28027013f, -0.16455409f, 0.20564532f, 0.32822454f, -0.55460429f, 0.09904253f, 
    0.12156624f, 0.19124812f, -0.00641135f, 0.04420079f, -0.01808294f, 0.06321994f, -0.01046348f, -0.05768498f, 
    -0.09464072f, -0.29069844f, -0.01854462f, 0.11452760f, 0.05190815f, 0.02679646f, -0.03718054f, -0.47007367f, 
    0.30946261f, -0.01400629f, -0.08167563f, -0.36375895f, 0.03865429f, -0.00338168f, 0.15846133f, 0.04757709f, 
    -0.26864487f, 0.00021018f, -0.06488349f, 0.01256900f, 0.05475917f, -0.74430567f, 0.19754589f, 0.33539021f, 
    -0.01159918f, -0.32660744f, 0.08536510f, 0.02119442f, -0.62522465f, -0.00281334f, -0.34724259f, -0.04738326f, 
    -0.23526391f, -0.26204112f, 0.06827033f, 0.07282754f, -0.37216315f, -0.04407267f, -0.01020430f, 0.16104119f, 
    -0.69796956f, -0.03622832f, 0.03287598f, 0.22464576f, -0.28491482f, 0.16595751f, -0.02474848f, -0.07981358f, 
    -0.64207989f, -0.36993149f, 0.11234054f, 0.06728645f, -0.11583700f, -0.05077553f, -0.06980114f, -0.02243962f, 
    -0.32832047f, 0.09264237f, -0.05306995f, 0.10334273f, -0.42268923f, 0.01456750f, -0.66170233f, 0.04329349f, 
    -0.04462799f, 0.14730132f, -0.00644769f, -0.00785359f, 0.10844854f, 0.14399628f, -0.80783594f, 0.15124860f, 
    -0.46059272f, 0.05944632f, -0.10975782f, 0.01907356f, 0.01674154f, 0.13476261f, -0.11322606f, -0.09190435f, 
    -0.01764509f, 0.20315325f, 0.07440257f, -0.05387743f, -0.26615578f, 0.01725342f, 0.04915613f, -0.56411004f, 
    0.06562912f, -0.54602307f, 0.09671298f, 0.05597615f, -0.08085681f, 0.17170607f, 0.01104603f, -0.32085595f, 
    0.16457742f, 0.00455354f, -0.32544532f, 0.14163403f, -0.32667300f, -0.30468333f, 0.00332677f, -0.04470761f, 
    0.21238692f, -0.00043434f, 0.21103035f, -0.06704066f, 0.07620865f, -0.05277730f, -0.51738232f, -0.11280352f, 
    0.13469768f, 0.00837703f, 0.24910486f, -0.02244792f, -0.53281301f, 0.23054832f, -0.06228150f, -0.17721456f, 
    -0.00069158f, 0.24954361f, -0.05343987f, 0.05507204f, 0.00188238f, -0.28603205f, 0.10211109f, -0.06704558f, 
    -0.10942440f, 0.21495128f, 0.00211235f, -0.76709682f, 0.03377676f, -0.02671879f, -0.18702143f, -0.32654169f, 
    -0.01279002f, 0.04745672f, -0.06830302f, 0.15337503f, -0.07050995f, 0.01559169f, -0.02406920f, -0.07692995f, 
    -0.01816598f, -0.00531431f, 0.04295784f, 0.05536178f, -0.23088112f, -0.17197160f, 0.10679297f, 0.28811231f, 
    -0.02538358f, 0.11191989f, 0.22816727f, 0.00993867f, -0.05849370f, 0.19829701f, 0.10561442f, -0.00554132f, 
    0.18301526f, -0.30677861f, -0.17736787f, 0.05640204f, -0.03872357f, 0.01877682f, -0.05436030f, -0.47061735f, 
    0.32448456f, 0.03612857f, 0.00759682f, -0.08135182f, 0.18271379f, -0.29155669f, -0.06073406f, 0.03567003f, 
    -0.11594835f, -0.10952390f, 0.22464511f, -0.39384341f, 0.05281773f, 0.08518516f, -0.07925770f, 0.02436050f, 
    -0.12819265f, -0.38792172f, -0.00002115f, -0.06388498f, -0.28395328f, 0.05400588f, 0.13479899f, -0.01527005f, 
    -0.03436561f, 0.06888904f, -0.04841306f, 0.01624737f, -0.07784818f, 0.14645399f, 0.02952714f, 0.27227542f, 
    0.06563573f, -0.27181134f, 0.19165885f, 0.01126125f, -0.09052032f, -0.19041181f, -0.09973232f, -0.26805213f, 
    0.14944576f, -0.09866744f, -0.04967163f, 0.00465238f, -0.06229608f, 0.11171493f, 0.08217044f, -0.02873478f, 
    0.06519071f, 0.09081592f, 0.11943012f, -0.21137281f, 0.18035127f, -0.02396418f, -0.06357928f, 0.02197704f, 
    0.07708294f, -0.02135614f, -0.08460454f, -0.01557896f, 0.20122567f, -0.34155399f, 0.01907662f, 0.05973066f, 
    -0.63743603f, -0.08830839f, -0.38855401f, -0.03873011f, -0.25573245f, 0.03512510f, -0.08553589f, -0.14805786f, 
    0.00227018f, 0.00383646f, -0.05071844f, -0.24735056f, 0.07472923f, -0.12990418f, -0.01557723f, -0.35823652f, 
    -0.46930757f, 0.13941073f, 0.06427133f, -0.01838324f, 0.01296110f, 0.03229820f, -0.06439071f, 0.05746561f, 
    0.09585685f, 0.12585445f, -0.04390689f, 0.14176229f, 0.01233288f, -0.03525533f, 0.03984219f, 0.07866561f, 
    0.02173345f, 0.03374736f, 0.05027024f, -0.17181380f, -0.06631975f, 0.04201725f, -0.08221187f, -0.10171352f, 
    -0.11717805f, -0.04454597f, -0.05327003f, 0.07765143f, -0.01915408f, 0.18620311f, 0.11606976f, 0.01170284f, 
    0.06677754f, -0.27879685f, -0.12799314f, 0.02925203f, 0.23089792f, 0.11539662f, -0.10557483f, 0.02970466f, 
    0.56382197f, 0.06722210f, 0.08990994f, -0.05444591f, -0.07017928f, 0.03482530f, -0.03509020f, 0.00810076f, 
    0.08023486f, -0.31860304f, 0.01496098f, 0.02665536f, -0.00191716f, 0.17611334f, -0.06179849f, 0.07900487f, 
    0.16421588f, 0.21060686f, 0.15450923f, 0.13831565f, 0.12465058f, 0.16534653f, -0.19356737f, -0.01539319f, 
    0.06347267f, -0.04135780f, -0.08012390f, 0.06316417f, -0.25656241f, 0.09092734f, -0.19711442f, -0.04212517f, 
    -0.02309610f, 0.02115491f, -0.05999800f, -0.04618586f, -0.24352618f, 0.02717602f, -0.00307355f, 0.26104823f, 
    -0.25817832f, 0.01539171f, 0.10719847f, 0.03219651f, -0.08894663f, -0.27011874f, -0.01367689f, -0.40821719f, 
    0.13231140f, -0.28362179f, -0.06254564f, -0.02252701f, -0.01509306f, -0.04535386f, -0.01862470f, -0.09678429f, 
    -0.05345279f, -0.08422304f, 0.00857963f, -0.06901480f, -0.28284687f, 0.20724519f, 0.14199431f, -0.03385890f, 
    -0.27362758f, 0.01946015f, 0.17443840f, -0.13966410f, -0.18032590f, 0.22817968f, -0.00053287f, -0.06641976f, 
    0.28394744f, -0.04654124f, -0.34473607f, -0.10659849f, 0.11963244f, -0.06116576f, -0.02998207f, -0.24005808f, 
    0.06726325f, -0.06570291f, -0.15344551f, 0.23933209f, 0.00726139f, -0.45602727f, 0.15711397f, 0.20464209f, 
    0.18671449f, -0.46217316f, -0.01759512f, 0.05672418f, -0.05682615f, 0.08311222f, 0.03867303f, -0.01072590f, 
    -0.28904000f, -0.27858859f, 0.02657382f, -0.15240316f, 0.03226962f, 0.00884570f, 0.14444746f, 0.15485035f, 
    -0.17753574f, -0.03131310f, -0.00202014f, 0.14515752f, 0.00106256f, -0.00469983f, -0.00578664f, -0.05557654f, 
    0.15435790f, 0.00866097f, 0.00611385f, -0.03990470f, 0.05049844f, 0.22726974f, -0.07015538f, -0.00543401f, 
    0.00431989f, 0.22898360f, 0.08517759f, 0.02971250f, 0.14980191f, -0.17209227f, 0.35029113f, -0.02123990f, 
    -0.37735912f, 0.35701409f, 0.04099957f, 0.03048270f, -0.16090308f, -0.05329904f, -0.10549785f, -0.01147123f, 
    0.28233626f, 0.03895207f, -0.02063322f, -0.04163898f, -0.02364271f, -0.42356881f, -0.00618618f, 0.08169911f, 
    0.07088345f, 0.10946268f, 0.32804832f, 0.08516731f, -0.38696539f, -0.63222271f, 0.05687767f, -0.04873478f, 
    0.08709374f, 0.13668594f, -0.08366154f, -0.10918472f, 0.19828613f, -0.10932112f, 0.07978864f, -0.00190378f, 
    -0.09199164f, 0.25464341f, 0.02517782f, 0.00807479f, -0.15460861f, 0.01885504f, -0.78314036f, -0.12112523f, 
    0.10578648f, -0.54075861f, 0.24182974f, -0.05634413f, -0.04129039f, -0.27872980f, -0.00379701f, -0.29745218f, 
    0.08729515f, -0.41587287f, -0.07992879f, -0.07922924f, -0.31099394f, 0.12935764f, 0.04784494f, 0.13301219f, 
    0.04226749f, 0.02343968f, -0.51207292f, -0.27777922f, 0.18523552f, -0.30039218f, -0.38535139f, -0.23631352f, 
    0.04284886f, -0.01765258f, 0.17533332f, -0.15167183f, -0.66826814f, 0.16581441f, -0.00716121f, -0.03550402f, 
    -0.19231398f, -0.00246071f, -0.14749525f, -0.04573799f, -0.36991650f, 0.01125501f, 0.03175181f, 0.14864273f, 
    -0.22074008f, 0.02825754f, 0.34330657f, 0.26225266f, -0.05180549f, -0.01387822f, 0.03766583f, -0.07415630f, 
    0.14009316f, 0.12684456f, -0.05538112f, -0.02323778f, -0.09768919f, 0.07469480f, -0.12245581f, 0.06733198f, 
    0.04246908f, 0.08566114f, -0.11415410f, 0.08658964f, -0.04851740f, -0.00993973f, -0.70117891f, 0.19478795f, 
    0.13176328f, 0.01645345f, -0.07097913f, -0.61455899f, -0.00787018f, 0.04172907f, 0.32265183f, -0.06144137f, 
    0.09820226f, -0.03509339f, 0.02095940f, -0.03159736f, -0.17094962f, -0.63049108f, -0.05197938f, -0.00950065f, 
    0.00669919f, -0.25947961f, 0.04676256f, -0.00742753f, -0.34822080f, -0.41058174f, -0.39580750f, -0.01202051f, 
    -0.59213787f, 0.14348252f, -0.19956827f, -0.01125792f, 0.28453892f, -0.00282572f, -0.05219455f, 0.04359875f, 
    0.25507769f, 0.07856249f, 0.06435741f, -0.20022763f, -0.24784711f, -0.32610673f, 0.07120559f, 0.06964558f, 
    0.22648531f, -0.49677089f, 0.04544647f, 0.10545941f, 0.02593479f, -0.18226299f, 0.06562203f, 0.03626310f, 
    0.20316055f, 0.15915960f, -0.02612479f, 0.18155676f, 0.09766556f, 0.19203508f, 0.08021434f, -0.07794993f, 
    -0.00249544f, -0.05433422f, -0.02413979f, -0.00124841f, -0.02885684f, -0.08592807f, 0.38158327f, 0.22844975f, 
    -0.25048301f, 0.13841844f, -0.34726918f, -0.02488331f, 0.00712784f, -0.07519382f, -0.06073960f, 0.30137163f, 
    0.12458509f, 0.14978331f, -0.01735663f, 0.02708794f, -0.08476388f, 0.18361972f, -0.12958772f, 0.15682840f, 
    -0.02664967f, -0.01658542f, 0.10787980f, 0.02259961f, 0.00922769f, 0.08360492f, 0.11213672f, -0.14833824f, 
    -0.42394051f, -0.04161412f, -0.08152488f, 0.05970106f, 0.15312307f, 0.26188174f, 0.01961637f, 0.04625604f, 
    -0.12062526f, 0.05324284f, 0.12480415f, -0.03470489f, 0.11669277f, -0.02618629f, -0.11875139f, 0.03403376f, 
    0.18044339f, -0.07556259f, -0.37204772f, -0.04681753f, -0.10112508f, 0.12817276f, 0.13225698f, 0.13800830f, 
    0.31443462f, -0.16709128f, -0.01908486f, -0.02994245f, -0.03426796f, -0.32850122f, -0.04680906f, 0.01567584f, 
    -0.61145651f, 0.08627208f, 0.04218782f, 0.24980831f, 0.06038579f, 0.03813922f, -0.07748918f, 0.34101942f, 
    0.13385691f, -0.07781897f, 0.05575130f, 0.10970342f, 0.06893426f, 0.05084096f, 0.32345626f, 0.05870389f, 
    -0.61129510f, 0.04409736f, -0.10475212f, -0.03323181f, 0.03267171f, 0.13451582f, -0.01556327f, -0.38548902f, 
    -0.08401756f, 0.08907980f, -0.39831272f, -0.02659728f, 0.14070390f, 0.08507492f, 0.00760444f, 0.00306488f, 
    0.19753118f, -0.04070856f, 0.19515637f, -0.04580201f, 0.10044962f, -0.02975718f, -0.02490283f, -0.36660957f, 
    -0.43240234f, -0.00284321f, -0.05674154f, -0.40851060f, 0.13626596f, -0.59784985f, -0.05312035f, 0.00106221f, 
    0.07676990f, 0.07752228f, -0.53959602f, -0.34326032f, -0.16810711f, 0.06604616f, 0.10561967f, -0.08945854f, 
    0.06432540f, -0.42196447f, 0.00961935f, -0.79435784f, -0.23899205f, -0.86511642f, 0.15721782f, -0.02101887f, 
    -0.05522786f, -0.19461188f, 0.06587369f, -0.03318213f, -0.33954316f, -0.63458389f, -0.03859543f, -0.20365851f, 
    -0.01329458f, -0.21539722f, -0.15039055f, -0.01847717f, 0.05187637f, 0.08281019f, -0.15082359f, -0.16640367f, 
    -0.59866756f, -0.36892295f, -0.06739854f, 0.03257369f, 0.14474717f, -0.66889119f, 0.00678625f, 0.21110420f, 
    -0.00048688f, 0.12001876f, -0.48887661f, 0.27582449f, -0.36017159f, -0.08214078f, -0.24081901f, 0.06046465f, 
    -0.57556230f, -0.00362798f, 0.09188211f, 0.12040298f, 0.20249711f, 0.18353896f, 0.07346720f, -0.05322286f, 
    -0.03105350f, -0.00703869f, 0.23999366f, -0.06464371f, 0.14228797f, -0.03910076f, 0.16162466f, 0.03104157f, 
    0.29169694f, -0.04612911f, 0.01446169f, 0.03715825f, 0.11156944f, -0.12731603f, -0.26411372f, -0.09028868f, 
    -0.03975798f, -0.31044897f, 0.02105331f, 0.06543372f, 0.03930344f, 0.17804311f, -0.05690522f, -0.05116171f, 
    -0.01370141f, 0.19644505f, 0.01463180f, 0.09934026f, -0.04778197f, 0.08290295f, 0.30657038f, 0.04813501f, 
    -0.65555125f, -0.03827785f, 0.04955981f, -0.35939950f, 0.08046473f, -0.08384306f, -0.26973641f, -0.03965902f, 
    -0.36905438f, 0.08251759f, -0.13310720f, 0.04544507f, 0.20006542f, -0.20056340f, -0.58934772f, -0.35276812f, 
    -0.04979429f, -0.09361695f, 0.18924353f, -0.03264088f, -0.05446439f, -0.06169321f, -0.33440813f, 0.00593163f, 
    -0.29602516f, -0.20845059f, 0.25683209f, -0.02808423f, 0.02612838f, -0.01043477f, 0.04301149f, 0.01062430f, 
    -0.18765788f, 0.01009814f, -0.03911741f, 0.12265816f, -0.18982188f, 0.05006647f, 0.07226624f, -0.06686755f, 
    0.02879668f, -0.52235758f, 0.07476614f, -0.01872296f, 0.31413588f, -0.13576853f, 0.22434030f, 0.05511548f, 
    -0.51791072f, -0.09045495f, -0.08292037f, -0.42129442f, -0.49328682f, -0.60629493f, 0.41983861f, 0.04753846f, 
    -0.00687447f, -0.27189097f, 0.04934772f, -0.03590273f, -0.31963524f, 0.09807644f, 0.11886056f, -0.28973848f, 
    0.08007693f, 0.45003390f, 0.05426671f, -0.06631006f, -0.04442940f, -0.33179036f, -0.04637212f, -0.21801753f, 
    -0.01323675f, 0.10586520f, 0.08253047f, 0.05018199f, -0.12782118f, -0.02146005f, -0.08462998f, 0.18623650f, 
    -0.03724651f, 0.03862594f, -0.18913740f, -0.14712907f, 0.17945856f, -0.10738514f, -0.10787923f, -0.19600070f, 
    0.08330669f, -0.06339819f, -0.02404244f, -0.93373358f, 0.25237224f, 0.18558285f, 0.03486775f, -0.01242850f, 
    -0.21312287f, 0.02429557f, -0.25778934f, -0.00859061f, 0.18487687f, -0.03444817f, -0.03067260f, 0.18522282f, 
    0.18671367f, 0.07258137f, -0.04625944f, 0.44276673f, -0.02403904f, -0.55706364f, -0.14260967f, -0.13908474f, 
    -0.09860363f, -0.01422810f, -0.02187990f, 0.02172159f, -0.04062856f, -0.16172789f, -0.05081544f, -0.01179681f, 
    0.16326621f, -0.20820728f, -0.03704445f, 0.19321406f, 0.02697228f, -0.01340861f, 0.62581336f, 0.28594795f, 
    0.09393262f, 0.06802253f, 0.07165281f, 0.11930007f, -0.02137686f, 0.05971394f, -0.01545816f, -0.06189684f, 
    -0.08515163f, 0.07324573f, -0.14337616f, 0.06646927f, -0.31243232f, 0.40118197f, -0.16950449f, -0.49859992f, 
    0.07626107f, 0.00004281f, -0.42718065f, 0.07767475f, -0.20986412f, -0.28134042f, 0.34485459f, 0.00138754f, 
    -0.48572591f, -0.23206772f, -0.25668627f, 0.07718384f, 0.54507983f, -0.05893235f, -0.02628535f, -0.05524484f, 
    0.13608892f, -0.93633664f, 0.05955343f, -0.02819137f, -0.10356195f, 0.12475553f, 0.08106409f, -0.07413817f, 
    0.05792754f, -0.17876312f, -0.46097279f, -0.24635081f, 0.29166073f, 0.13521615f, -0.02804280f, -0.01683405f, 
    0.14237517f, -0.29360595f, -0.01924720f, 0.11573885f, 0.05418069f, 0.01771146f, 0.14209935f, 0.03623505f, 
    -0.01470071f, 0.20766604f, -0.01856521f, 0.00713272f, 0.16650726f, 0.12106943f, -0.32606393f, -0.05309292f, 
    -0.00997303f, -0.10370580f, 0.05618412f, 0.05070319f, -0.03226339f, 0.06752737f, -0.00873000f, -0.47832441f, 
    -0.20615633f, -0.15266547f, -0.03219869f, 0.00527421f, 0.31672439f, -0.01729386f, -0.08905304f, -0.20485480f, 
    0.07108937f, -0.12778033f, 0.15506943f, -0.01743453f, -0.41522273f, -0.07253073f, 0.23264198f, -0.36845461f, 
    0.08831180f, 0.01001164f, -0.38896379f, 0.19542228f, -0.37423536f, -0.05406059f, -0.06198467f, -0.06109999f, 
    0.08709214f, -0.06603383f, 0.10587128f, 0.01868357f, -0.15095612f, -0.00570952f, -0.27137810f, -0.72446108f, 
    -0.08944003f, -0.08309180f, 0.05234253f, -0.03470358f, 0.03580835f, 0.28933325f, 0.13872619f, -0.69645256f, 
    -0.04351686f, 0.20124088f, -0.07451449f, -0.00599651f, -0.08646192f, 0.11115192f, -0.00806463f, -0.03461836f, 
    0.03346794f, 0.13356803f, -0.00203157f, -0.62953597f, -0.07173430f, -0.07362664f, 0.26830211f, -0.51742262f, 
    -0.22538891f, 0.05920915f, 0.05254195f, 0.04423353f, -0.03515567f, -0.04226843f, -0.46337441f, 0.03502076f, 
    0.10142522f, -0.01679996f, -0.08135004f, -0.03839140f, 0.12470188f, -0.24341707f, -0.04989804f, 0.05151220f, 
    -0.08421155f, -0.13939025f, 0.09454682f, 0.03588033f, -0.03009455f, 0.22526564f, -0.06578802f, 0.06718325f, 
    0.00662305f, -0.02254352f, 0.25030202f, 0.06519105f, -0.52555758f, 0.02995394f, 0.01503669f, 0.16647707f, 
    -0.60307443f, 0.32585081f, 0.02467924f, 0.12931928f, 0.05640294f, 0.13888651f, -0.08090501f, -0.09135161f, 
    -0.09518867f, 0.25993404f, 0.00602909f, 0.19705337f, 0.17688130f, -0.25204119f, 0.06467488f, -0.04211682f, 
    -0.21691181f, 0.04554813f, -0.08253934f, 0.00433163f, -0.65371096f, -0.05154964f, -0.32723066f, -0.00109962f, 
    -0.06824356f, 0.00976493f, -0.00014046f, -0.03614493f, 0.25008774f, 0.04168145f, -0.15206480f, -0.81306148f, 
    0.04754540f, 0.16631639f, 0.02982966f, -0.04811154f, 0.02331691f, 0.27304927f, -0.05973213f, 0.08460510f, 
    -0.15374871f, 0.24373974f, -0.07665748f, 0.03294352f, -0.33534461f, 0.04674920f, -0.06949907f, -0.08864158f, 
    0.00253136f, 0.10776463f, -0.25779250f, -0.44274995f, 0.01998883f, -0.15764889f, 0.28597176f, -0.51379079f, 
    0.15220836f, 0.02828322f, 0.22675349f, 0.03863242f, -0.12611121f, -0.27571347f, 0.06097368f, 0.01808534f, 
    0.31821573f, -0.01528037f, 0.23603024f, 0.05232970f, 0.20778377f, -0.04032666f, 0.17227943f, -0.01936826f, 
    0.05722431f, -0.01681500f, 0.06134220f, -0.37378043f, -0.01156433f, -0.49822843f, 0.14149618f, -0.24489246f, 
    -0.01666846f, -0.24696775f, -0.01112197f, 0.03195233f, 0.04967213f, -0.10038575f, -0.03223670f, 0.05074459f, 
    0.12055943f, 0.06365777f, -0.00552502f, 0.05112777f, 0.04198593f, -0.09176108f, -0.43645400f, -0.21983427f, 
    0.26841304f, 0.04910075f, -0.01912668f, -0.13183920f, -0.08522533f, -0.07954950f, 0.39754596f, -0.05272532f, 
    0.03136231f, 0.02054256f, 0.04256384f, -0.03556457f, -0.05828774f, -0.08244120f, 0.17451055f, -0.26930878f, 
    -0.08179597f, -0.11805132f, 0.13860728f, -0.04356367f, -0.28019413f, -0.25648284f, 0.00260075f, -0.00616732f, 
    -0.28269944f, -0.14315709f, -0.43034893f, 0.00358522f, 0.03193755f, 0.04036771f, 0.04900016f, -0.29268625f, 
    -0.33981293f, -0.11407229f, -0.03534306f, -0.15294456f, 0.12892713f, -0.05828310f, -0.07366015f, 0.05608128f, 
    -0.23671493f, -0.23159716f, 0.18869171f, 0.01432662f, -0.08095887f, 0.25112200f, -0.04471326f, 0.06400635f, 
    0.18448897f, 0.09709330f, -0.08817632f, -0.14584617f, -0.03189014f, -0.08201963f, 0.09317153f, -0.00935858f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.01785806f, 0.06650873f, -0.01414337f, 0.01695773f, 0.05669618f, 0.10976206f, -0.01172374f, -0.17475896f, 
    -0.26884237f, -0.08088680f, -0.02514485f, 0.06244255f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
