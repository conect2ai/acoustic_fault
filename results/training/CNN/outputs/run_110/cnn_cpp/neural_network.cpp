#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.22826421f, -1.50056922f, -0.69243073f, -0.18910025f, -0.28277680f, -0.43241909f, 0.11160216f, 0.14804240f, 
    -0.04948758f, -1.00223768f, -0.77561855f, -1.09043932f, -0.00552905f, 0.79536361f, 0.82622164f, -0.27444908f, 
    -0.13078682f, -0.16749749f, -0.86918867f, -0.91418791f, -1.18964887f, 0.12834217f, -0.47666761f, 0.23201416f, 
    0.43318281f, 0.17806387f, -0.00738129f, -0.21310610f, -0.49930465f, -0.42966074f, 0.59670448f, -0.21576175f, 
    -0.27965143f, 0.38335666f, -0.34671348f, 0.98771501f, 0.81232071f, 0.52564085f, 0.44639242f, -0.46545684f, 
    -0.45223281f, -1.39865482f, -0.11177158f, 0.61798155f, 0.36877444f, -0.65111709f, -1.45105243f, -0.55618846f, 
    -0.12009790f, -0.66301548f, -0.08741031f, -0.11394728f, 0.15451743f, 0.37276095f, 1.15491319f, 1.00592768f, 
    1.05369127f, 0.21294710f, -0.32418585f, 0.36215594f, -0.54676712f, 0.04231427f, -0.05767619f, 0.59642613f, 
    0.58996642f, -0.36521330f, -0.41884381f, -1.49323702f, -0.71864754f, -0.04543585f, -0.20655952f, -0.03887379f, 
    -0.07166616f, -0.54885381f, 0.73912370f, -0.43255344f, 0.44028422f, -1.55558050f, -0.32018480f, -0.55867112f, 
    -0.48306346f, -0.11590180f, 0.57659060f, -0.41804567f, -1.24674082f, -0.60080236f, -1.06583858f, 0.35386145f, 
    -0.12726693f, 0.39850822f, 1.06710887f, 1.16742349f, 0.42075542f, -0.60599422f, -0.62556434f, 0.53466082f, 
    0.35967299f, 0.17005566f, 0.14779110f, -0.88794327f, -0.75131577f, -0.43269193f, 1.07989490f, 1.23654461f, 
    0.09245095f, 0.02856279f, -0.35416868f, -0.26040050f, -0.02852777f, -0.43511760f, 1.25254643f, 1.08731484f, 
    1.13172424f, 0.30149952f, -0.12209799f, 0.15689532f, 0.11777916f, 1.19985461f, 0.89422154f, 0.75883871f, 
    -0.87087363f, 0.82090420f, -0.63640147f, 0.36559916f, 0.00950170f, -0.13790670f, 0.28135741f, -0.34317490f, 
    0.57209903f, -0.91184688f, 0.26825863f, 1.12911570f, 0.23016693f, 0.43238607f, 0.98566115f, -1.25512660f, 
    0.92719156f, -0.98427874f, 0.13662811f, 0.20013951f, -0.85119051f, -0.24498501f, 0.31893027f, 0.04836232f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26116017f, 0.21227030f, 0.28596020f, -0.26679540f, 0.43929228f, 0.18607560f, 0.62833774f, 0.45004916f, 
    -0.05249052f, -0.00154246f, 0.21828645f, -0.29138443f, 0.17965651f, -0.18124422f, 0.43238464f, 0.40489772f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.03047840f, 0.04796415f, -0.00626702f, 0.06976338f, 0.01828445f, -0.00672740f, -0.01143345f, 0.06311816f, 
    -0.07526142f, -0.09036327f, 0.05669219f, -0.02706196f, -0.00815916f, 0.00895666f, -0.01247771f, -0.07590611f, 
    0.03827435f, 0.00713442f, -0.08138481f, -0.04500142f, 0.06530570f, -0.08701134f, -0.01757909f, 0.04192264f, 
    -0.08116803f, -0.06142639f, 0.02339457f, 0.06377001f, 0.02120038f, -0.08775673f, 0.04901294f, -0.04633363f, 
    0.05009316f, -0.01704215f, -0.08203793f, 0.07040739f, -0.02277307f, -0.05218606f, 0.04491215f, -0.00422434f, 
    -0.05936803f, -0.07390269f, 0.00510777f, -0.00649285f, -0.00946333f, -0.04447708f, 0.02439899f, 0.02668906f, 
    -0.07814226f, -0.03355252f, 0.00291508f, 0.00635950f, -0.03928522f, -0.03217037f, 0.05730486f, -0.00165323f, 
    0.07764640f, -0.02264523f, -0.01250607f, 0.03156489f, -0.05307106f, -0.02819153f, 0.02657770f, -0.05798359f, 
    0.04145391f, 0.03987671f, 0.04522137f, -0.05613213f, -0.02813961f, -0.08336712f, -0.03616646f, -0.03492016f, 
    -0.01726343f, 0.05442327f, -0.08900902f, 0.03491579f, -0.07738359f, 0.06914318f, -0.07033948f, -0.02572743f, 
    -0.01332219f, 0.04639530f, 0.01444431f, 0.04734971f, 0.05370411f, -0.06418324f, -0.07398594f, -0.09238819f, 
    -0.03834684f, 0.00322423f, -0.07739214f, -0.03189124f, 0.00823032f, -0.02597634f, -0.07566725f, 0.01375578f, 
    0.02516174f, -0.01992367f, -0.03602514f, -0.01517397f, 0.00842244f, 0.02389402f, -0.03344751f, -0.07051282f, 
    0.01192480f, 0.05333042f, -0.08353203f, 0.03857919f, 0.02847535f, -0.08773456f, -0.07410035f, -0.02048034f, 
    -0.05003342f, 0.07034276f, -0.04695863f, -0.04507153f, -0.07887650f, 0.01007861f, 0.04188530f, -0.07734480f, 
    0.04623628f, -0.00600433f, 0.03184228f, -0.09543402f, 0.00398423f, -0.00695811f, -0.02388020f, -0.01636075f, 
    -0.02851643f, 0.05063891f, 0.05719493f, -0.06724361f, 0.05844366f, 0.00603575f, 0.00811635f, 0.05475816f, 
    -0.06222814f, 0.06788708f, -0.06461557f, -0.02285426f, -0.03162308f, 0.04766769f, -0.05156783f, 0.05177723f, 
    0.47122577f, 0.11571518f, -0.20332728f, -0.08836143f, -0.15074749f, -0.07191683f, -0.00109049f, -0.04970495f, 
    -0.11739101f, 0.09613077f, 0.59968364f, 0.11381169f, 0.29164457f, 0.16567840f, -0.26869574f, 0.22371095f, 
    0.23196764f, -0.16204180f, -0.16472445f, 0.49795333f, 0.11826643f, -0.02566190f, -0.13815773f, 0.03738371f, 
    -0.06376772f, 0.29050377f, 0.06282741f, 0.10864733f, 0.06986931f, -0.01238528f, -0.20394787f, -0.08180033f, 
    0.13587660f, 0.12796998f, 0.01818452f, 0.04232086f, -0.14165951f, -0.44481260f, 0.18493712f, -0.26485434f, 
    -0.01881275f, 0.18870023f, -0.01986997f, -0.08505851f, 0.04190820f, 0.15475507f, 0.33256444f, -0.04582554f, 
    -0.09353215f, -0.22661571f, -0.12105124f, -0.29360262f, 0.23825163f, 0.00795702f, -0.18453798f, -0.43173045f, 
    0.16575082f, -0.04964935f, -0.00759086f, -0.03413003f, -0.00109702f, -0.01385618f, 0.05253789f, 0.44258630f, 
    -0.27307901f, -0.08158873f, 0.16726694f, -0.09465159f, -0.15432279f, -0.13119195f, -0.16973728f, -0.22540160f, 
    -0.03488329f, 0.54477900f, 0.39580038f, 0.13070530f, 0.02583410f, 0.22241199f, -0.11454909f, 0.09057167f, 
    -0.03885212f, 0.10401290f, -0.14955597f, -0.09662915f, -0.06349263f, -0.17623423f, 0.11367950f, -0.20468046f, 
    -0.12479845f, 0.07827470f, 0.01824633f, -0.35682508f, -0.17532341f, 0.17851785f, -0.23956427f, -0.04319955f, 
    0.02938191f, -0.03103600f, 0.06237992f, 0.26641938f, 0.58215839f, -0.05904165f, -0.00374341f, 0.10100528f, 
    -0.06414726f, 0.18437557f, 0.23843840f, -0.04540480f, 0.01964291f, -0.13684988f, -0.28109172f, -0.10959602f, 
    -0.07125223f, -0.15540799f, 0.20250574f, 0.00255380f, 0.24630150f, -0.76295757f, -0.66519761f, -0.15579987f, 
    0.29050758f, 0.15059696f, 0.02643742f, -0.24978463f, -0.10753790f, 0.16242558f, -0.31729525f, 0.16473445f, 
    0.00888669f, 0.08447099f, -0.05304869f, -0.10814942f, 0.01163423f, 0.17753933f, 0.22101541f, 0.29976574f, 
    -0.17117238f, 0.13810940f, 0.00633147f, 0.28609303f, -0.03118942f, -0.13011304f, 0.16760041f, -0.09147435f, 
    0.19849645f, -0.32155475f, 0.06634978f, 0.35024667f, -0.16886893f, -0.21080439f, -0.18275100f, -0.01336359f, 
    -0.08054329f, -0.61500204f, 0.00009409f, -0.03185591f, -0.34999377f, 0.10916352f, -0.12271620f, -0.21811289f, 
    -0.34434381f, -0.15522139f, 0.11973257f, 0.25031206f, 0.15482147f, -0.16021441f, 0.20716076f, -0.04740321f, 
    0.13305408f, 0.16265161f, -0.05114610f, 0.23256965f, 0.06558008f, 0.03146494f, -0.01324695f, 0.02840549f, 
    0.03328026f, 0.00858995f, 0.03078269f, -0.22472860f, 0.29407209f, 0.34322077f, -0.63858366f, 0.35192490f, 
    -0.05069866f, 0.04083021f, 0.25985706f, 0.08680443f, -0.09648475f, 0.41990876f, 0.06733683f, -0.35778773f, 
    -0.08711653f, 0.02788318f, 0.15406287f, 0.11427747f, -0.04597204f, -0.06251460f, 0.31793445f, 0.25798252f, 
    0.20021015f, -0.09968667f, -0.02100384f, 0.04568207f, 0.20784229f, 0.07000995f, 0.08869107f, 0.54628772f, 
    0.27478227f, -0.26335898f, 0.17130037f, -0.03210011f, -0.00301773f, 0.01623853f, 0.06159705f, -0.10726456f, 
    -0.36782137f, -0.02830288f, -0.17586403f, 0.06381029f, 0.24422675f, 0.15647177f, -0.05237280f, -0.00661541f, 
    0.27628779f, 0.06316888f, -0.27796483f, -0.32652369f, 0.38961247f, 0.05491433f, 0.25894496f, 0.08967082f, 
    0.07707611f, -0.11494612f, 0.62157011f, 0.27093992f, 0.05125666f, 0.26639381f, 0.09350218f, 0.05365553f, 
    0.26409015f, 0.06246762f, 0.09323897f, -0.37477478f, -0.58445114f, -0.23578575f, -0.22732350f, -0.05249308f, 
    -0.03654696f, -0.37348962f, -0.08756959f, -0.03248905f, -0.07562619f, -0.46472731f, 0.10679209f, 0.09783711f, 
    0.25354472f, 0.14727983f, 0.05240576f, 0.05379108f, -0.07728843f, 0.81976557f, 0.30079222f, -0.31897360f, 
    0.19822299f, 0.11986145f, 0.01607975f, -0.02538327f, -0.19883600f, 0.04447384f, -0.33326811f, -0.08335488f, 
    0.13329139f, -0.15628609f, 0.00653827f, 0.01248655f, 0.18573439f, 0.18631002f, -0.07130723f, -0.26583764f, 
    -0.18085097f, 0.09668233f, -0.37275493f, -0.06729791f, 0.03837921f, -0.19780566f, -0.02633916f, 0.02648917f, 
    0.30029836f, -0.15869711f, -0.07246452f, -0.00803905f, -0.11945505f, -0.21244434f, -0.02145616f, 0.37407428f, 
    0.23262557f, -0.43540293f, -0.02639526f, 0.24557510f, 0.05091390f, -0.03910766f, 0.20317374f, 0.17246042f, 
    -0.07958125f, -0.11502725f, -0.51154113f, 0.03151838f, -0.00232445f, -0.02296568f, -0.14448123f, 0.05441643f, 
    -0.13728820f, 0.10990158f, 0.02167769f, -0.03075119f, 0.13514526f, 0.15352531f, 0.08852135f, 0.46328533f, 
    0.02811665f, -0.08234829f, -0.46653840f, 0.25076795f, 0.15843834f, 0.27442151f, -0.00189372f, 0.07901903f, 
    -0.04605722f, -0.39377347f, 0.02540718f, -0.11639727f, 0.00029270f, -0.30925709f, -0.53791690f, -0.64484680f, 
    -0.19091605f, -0.01744749f, -0.26444864f, -0.11453158f, -0.07741017f, -0.05252767f, 0.58332556f, 0.33798820f, 
    0.17013675f, -0.24918512f, -0.11674025f, -0.15423784f, -0.12931266f, 0.17769870f, 0.00031051f, -0.11656447f, 
    -0.20441088f, -0.17494631f, -0.09314363f, -0.12265636f, -0.29097828f, 0.03100160f, 0.03551189f, 0.02031043f, 
    -0.02869582f, 0.20025265f, -0.00863792f, 0.16881108f, -0.15513216f, 0.17250861f, 0.01831585f, 0.12418969f, 
    -0.27821720f, 0.17026104f, -0.12386668f, -0.26305100f, -0.06228548f, 0.07932979f, -0.09550443f, -0.05107015f, 
    -0.08782456f, 0.05194062f, 0.35955471f, 0.13118185f, 0.26759270f, -0.15533046f, -0.04239302f, 0.01726347f, 
    -0.22136050f, 0.07184883f, 0.00825986f, -0.68723691f, 0.05626846f, -0.27156118f, 0.33986765f, 0.15680724f, 
    0.17480160f, 0.05073911f, 0.06524406f, 0.09344900f, -0.16575649f, -0.06275713f, -0.18151556f, -0.15382791f, 
    0.07154596f, -0.43105811f, -0.04044989f, -0.09851728f, -0.02377491f, 0.83510184f, 0.19805411f, 0.33878031f, 
    -0.20543966f, -0.09934067f, -0.26314864f, 0.00923468f, 0.19559436f, -0.05164471f, 0.22568731f, -0.03829248f, 
    0.16689101f, -0.35943481f, 0.11726952f, 0.06266616f, -0.20634967f, -0.04470998f, 0.14716578f, 0.04674805f, 
    -0.19375913f, -0.06244854f, 0.05186826f, -0.22102857f, -0.05339855f, -0.08042517f, 0.19345564f, 0.05088454f, 
    -0.01808797f, -0.02603796f, -0.04934641f, -0.07235995f, -0.00637766f, -0.08235359f, -0.07869016f, 0.00709604f, 
    -0.00081541f, 0.01069283f, -0.08567446f, -0.10109341f, -0.01040565f, 0.02855834f, -0.10015134f, 0.06293061f, 
    -0.03205914f, -0.03829502f, -0.05013769f, 0.06559857f, -0.01622782f, -0.02277702f, -0.00558750f, 0.01863457f, 
    0.01620885f, -0.01269430f, 0.06001285f, -0.09019256f, -0.08780956f, 0.02845466f, -0.03048274f, 0.03099636f, 
    -0.00778431f, -0.07366966f, -0.05217835f, 0.01830412f, 0.04722143f, 0.03085792f, 0.03207769f, 0.05480696f, 
    0.05495859f, -0.08770952f, -0.01237710f, -0.04026753f, -0.00975988f, 0.00383951f, -0.03992027f, -0.09165002f, 
    -0.04131154f, 0.04144897f, -0.00942146f, 0.05525380f, -0.01908604f, -0.04678845f, 0.01812349f, -0.07470372f, 
    -0.05691053f, -0.07196742f, -0.01851836f, -0.01344681f, -0.00099406f, 0.03907285f, -0.04172862f, -0.06479488f, 
    0.04910568f, -0.05424226f, -0.03388077f, 0.05519748f, 0.01883091f, -0.06953094f, 0.02527016f, -0.10879883f, 
    0.04512447f, 0.05593936f, -0.07554772f, 0.02065550f, -0.07085385f, 0.06536908f, 0.07535072f, -0.01241968f, 
    0.05097839f, -0.02992547f, -0.05971375f, -0.06643276f, -0.03717409f, -0.05274179f, 0.05556469f, 0.02302628f, 
    -0.02932698f, -0.10794188f, 0.00906972f, -0.01269323f, -0.01081311f, 0.00248776f, -0.03927894f, -0.01222134f, 
    0.04973055f, -0.02314834f, -0.08702612f, -0.03432005f, -0.08672525f, -0.05484980f, 0.04023458f, -0.09465691f, 
    -0.02036178f, 0.01066895f, 0.04952633f, -0.09390181f, 0.01774163f, -0.06871764f, 0.03056840f, -0.05760265f, 
    -0.00851333f, -0.02028544f, 0.00229242f, 0.02409528f, 0.05643215f, -0.00818157f, -0.06186438f, -0.02416544f, 
    -0.03948300f, 0.05864204f, 0.00822990f, 0.07426260f, 0.04373433f, -0.07337033f, -0.02902122f, 0.02492291f, 
    -0.07753659f, 0.02319202f, 0.04674620f, -0.00489666f, -0.09388953f, -0.09636647f, 0.04930603f, -0.04068262f, 
    -0.02912566f, 0.03594423f, 0.04695801f, -0.03561878f, -0.02916885f, -0.02183616f, -0.08565633f, -0.09680807f, 
    -0.03605382f, -0.00961734f, -0.00036414f, 0.02808047f, -0.03030339f, -0.10533887f, -0.01947121f, -0.08342057f, 
    0.01381623f, 0.02291022f, -0.10077701f, 0.03516294f, -0.11686647f, 0.04253474f, 0.02418235f, -0.10185651f, 
    -0.08426257f, -0.05225728f, 0.07822389f, -0.05336475f, 0.05047924f, -0.07893438f, -0.05850049f, -0.04055554f, 
    -0.05702160f, -0.10966618f, 0.02425773f, -0.00804932f, -0.10771533f, 0.00327609f, 0.02599709f, -0.00333339f, 
    -0.09538684f, -0.04457042f, -0.04362171f, -0.08637218f, -0.04513449f, -0.10494031f, 0.02578605f, 0.01802264f, 
    0.03015341f, -0.00428880f, -0.11958657f, 0.00704075f, -0.05186949f, 0.05489310f, -0.02326284f, -0.04957946f, 
    -0.03909012f, 0.03211842f, -0.10959805f, 0.04447443f, -0.01878784f, -0.04433247f, -0.11359942f, 0.00464119f, 
    -0.10006168f, -0.06196762f, -0.09370031f, -0.10925330f, -0.03716408f, -0.03177004f, 0.04587340f, -0.04922874f, 
    -0.09827066f, -0.10820941f, 0.03281191f, 0.05465681f, -0.01071535f, -0.06485132f, -0.08981477f, -0.00429542f, 
    -0.06429391f, -0.03351410f, -0.08325640f, 0.02499858f, 0.04449804f, -0.11833473f, -0.11129908f, -0.01949039f, 
    -0.04903983f, -0.00695925f, -0.04854919f, -0.07085745f, -0.08095883f, -0.11135999f, -0.05729722f, 0.02720320f, 
    0.02424172f, -0.07146817f, -0.04959938f, -0.05986393f, -0.09805926f, -0.00301609f, -0.10123713f, -0.00624505f, 
    -0.09940676f, -0.06094040f, -0.08351268f, -0.07837077f, 0.01165519f, -0.08854014f, -0.01705045f, -0.01957156f, 
    -0.06387778f, -0.04548271f, -0.03679416f, -0.00558881f, -0.00856610f, -0.00337715f, 0.02477565f, -0.02635586f, 
    -0.07336877f, -0.00317671f, -0.07206269f, -0.01779598f, -0.05789371f, -0.09306999f, 0.01860222f, -0.09656771f, 
    0.04582741f, -0.03268501f, -0.06469879f, 0.00696885f, 0.00029263f, -0.01554251f, -0.10249332f, -0.02513373f, 
    -0.06688488f, -0.07923246f, -0.04792939f, -0.07433043f, -0.02534722f, 0.02272735f, -0.10171451f, 0.02065885f, 
    0.04360543f, -0.00249947f, 0.02134792f, 0.03294893f, -0.00443455f, -0.06137436f, 0.02468562f, -0.08704687f, 
    -0.08474206f, 0.01354577f, 0.07127191f, -0.05757791f, -0.03489562f, 0.04622051f, 0.00500336f, 0.04244394f, 
    -0.03649122f, -0.02728963f, -0.07415479f, 0.04286420f, -0.02972363f, 0.04006713f, 0.01517572f, -0.04274265f, 
    -0.06856684f, 0.00170102f, 0.04951754f, -0.05764155f, -0.07120779f, -0.01257481f, 0.06994607f, -0.05522566f, 
    0.07217205f, -0.01652597f, 0.01682047f, -0.00673446f, -0.08819538f, -0.04892242f, 0.04744286f, 0.03912196f, 
    -0.06532316f, 0.06348906f, 0.02657196f, 0.06706906f, -0.00558141f, 0.01332521f, 0.06857365f, -0.04594922f, 
    0.05075980f, -0.04228989f, -0.02449103f, -0.04243643f, -0.03766600f, -0.00008591f, -0.01946902f, -0.07717847f, 
    -0.07363974f, -0.06847586f, -0.02573235f, 0.06854539f, 0.02506056f, -0.05253936f, 0.00486814f, -0.03055906f, 
    -0.02485311f, 0.02786832f, -0.06081010f, -0.02364353f, -0.01208353f, 0.05450286f, 0.03460073f, -0.08091557f, 
    -0.05972194f, 0.00304506f, -0.02698860f, 0.00348704f, -0.07342477f, -0.03914324f, -0.04778398f, -0.07288621f, 
    -0.00039239f, 0.00241657f, -0.01335865f, 0.07368924f, 0.01966091f, -0.06270835f, -0.05583922f, -0.04112206f, 
    0.03419138f, -0.08579564f, 0.03600179f, 0.02213233f, -0.04752324f, -0.00838002f, 0.05825363f, 0.06383739f, 
    -0.01104873f, -0.02294943f, -0.04644288f, -0.00754993f, 0.03536244f, -0.04110656f, -0.04902624f, 0.05234940f, 
    0.04807077f, -0.03598978f, -0.01653106f, -0.02281360f, 0.07475382f, -0.00372919f, -0.04181103f, -0.01266147f, 
    0.00351521f, -0.03181192f, -0.05235882f, -0.05464346f, -0.04115133f, 0.04100871f, -0.01949827f, 0.03908094f, 
    0.00864695f, -0.04370289f, -0.08769675f, 0.01904266f, -0.01503419f, -0.03903754f, 0.02938254f, 0.05957430f, 
    -0.06318036f, -0.00780412f, 0.03755709f, 0.03693525f, -0.06327526f, -0.04020358f, -0.03220074f, -0.03071902f, 
    -0.03603792f, -0.04332419f, 0.07051366f, -0.06989341f, -0.01930811f, 0.05304312f, -0.07905623f, -0.07730406f, 
    0.04615004f, 0.01405021f, -0.01710336f, -0.06538475f, 0.01100580f, -0.04146023f, 0.07007726f, 0.03939971f, 
    0.04001508f, -0.04183615f, 0.01904622f, -0.00022162f, 0.06739922f, -0.05810472f, -0.07863763f, 0.04754459f, 
    -0.01387261f, 0.02080709f, 0.05697521f, 0.00863243f, -0.05211413f, 0.00218998f, -0.03067133f, 0.05687210f, 
    -0.00779998f, -0.05170328f, 0.04355075f, -0.08128369f, 0.07118038f, -0.04808286f, 0.07408947f, 0.00724592f, 
    0.06063703f, -0.08882029f, -0.08251926f, -0.00988032f, -0.00178918f, 0.04560535f, 0.05497444f, -0.02603844f, 
    -0.02358272f, -0.00097310f, -0.01248174f, -0.00293560f, 0.04899874f, -0.04872815f, -0.00482000f, -0.06723342f, 
    -0.07220566f, 0.01114066f, -0.04396237f, 0.03851312f, -0.05015568f, -0.03934864f, -0.06839760f, -0.07522882f, 
    0.01735965f, -0.01278231f, -0.00217859f, -0.07568409f, 0.00246454f, -0.06391177f, -0.01859559f, 0.05310092f, 
    0.01532535f, -0.06105652f, 0.05839188f, -0.02562441f, 0.01676955f, -0.07055631f, -0.07293268f, -0.03593783f, 
    -0.07476818f, -0.05977335f, 0.05297351f, -0.02176827f, -0.00745559f, -0.01997379f, -0.03477778f, 0.02229955f, 
    -0.03414463f, -0.01847460f, 0.04189784f, 0.01810989f, 0.05926128f, -0.10132539f, -0.06985392f, -0.07985710f, 
    -0.00588805f, -0.00959436f, -0.06200354f, -0.04913547f, -0.03631119f, -0.09494155f, 0.01593114f, 0.03287831f, 
    0.00880878f, -0.02795821f, 0.01999275f, 0.01260708f, -0.03592841f, -0.07345709f, -0.08842058f, -0.04329100f, 
    0.02871792f, -0.06369454f, 0.02233603f, 0.02409372f, -0.04681794f, -0.00473619f, -0.08975700f, -0.00196087f, 
    0.01909570f, -0.05292800f, 0.02711686f, -0.00652118f, -0.01417949f, -0.05230501f, -0.09171021f, -0.06677487f, 
    -0.07241296f, -0.02217539f, -0.08489180f, 0.03299378f, 0.02286707f, 0.03886423f, -0.06622228f, 0.05998456f, 
    -0.01055995f, -0.00254823f, -0.04260031f, 0.05729271f, 0.00889825f, 0.04793422f, -0.07376274f, 0.03792623f, 
    -0.02130112f, 0.06880976f, -0.07275442f, 0.03839545f, 0.01316301f, 0.01270958f, -0.08334573f, 0.01334505f, 
    0.00180204f, -0.03809205f, -0.00340477f, -0.04760712f, -0.02136224f, 0.04423847f, -0.04209059f, 0.02240483f, 
    -0.17963609f, -0.16366324f, -0.20084125f, -0.03459806f, -0.07801847f, -0.05227451f, 0.02456257f, 0.15454486f, 
    -0.02882770f, 0.17116661f, 0.42719564f, 0.09258862f, -0.11503024f, -0.08089953f, 0.08949485f, -0.20246758f, 
    0.23924573f, 0.24084286f, 0.04603951f, -0.06694523f, 0.12592292f, -0.05912833f, 0.29444742f, -0.19111454f, 
    -0.08068974f, 0.01252776f, -0.06043296f, 0.43460065f, -0.28918147f, 0.22537734f, -0.07518785f, -0.32070908f, 
    0.11636490f, -0.22026774f, -0.33921796f, 0.06120430f, -0.27819115f, 0.00409608f, 0.34050876f, 0.11652523f, 
    -0.00100595f, 0.23417328f, 0.06124301f, -0.08548178f, 0.22316451f, 0.04244709f, -0.43226999f, -0.13270915f, 
    -0.17006651f, 0.04238615f, -0.01300193f, 0.06957041f, 0.01271251f, 0.12362958f, -1.03130734f, -0.08242692f, 
    -0.07492407f, 0.34720966f, 0.40308392f, 0.11109578f, 0.08773828f, 0.12793824f, -0.03548774f, 0.43654105f, 
    0.27224293f, 0.07860179f, -0.00499925f, -0.07860555f, -0.05349756f, 0.05969448f, 0.14924809f, 0.08842263f, 
    0.16216485f, 0.24512757f, 0.27465454f, 0.13902520f, -0.19657914f, 0.21268699f, 0.04275801f, 0.06222812f, 
    -0.00671493f, 0.72694576f, 0.12187631f, -0.04606446f, 0.23590446f, 0.10146576f, -0.27339655f, -0.12783495f, 
    -0.23383658f, 0.03228372f, -0.70611578f, -0.24109672f, -0.31598854f, -0.00596080f, 0.23164847f, -0.04372016f, 
    0.14677069f, 0.04053824f, -0.11855526f, 0.50195473f, 0.14317489f, 0.04738025f, -0.21721575f, -0.22447379f, 
    0.03231855f, 0.02182519f, 0.20119557f, 0.05019903f, -0.12501208f, -0.47740272f, -0.24305056f, -0.09475195f, 
    -0.16043663f, 0.20974793f, 0.11347056f, 0.20517693f, -0.10541832f, -0.37346593f, 0.02066026f, 0.39063925f, 
    0.13850728f, -0.01922682f, -0.03220499f, 0.04502279f, -0.26052850f, 0.09139105f, 0.43027359f, 0.13962908f, 
    -0.08587626f, -0.16888526f, 0.14996283f, 0.24039792f, 0.14341074f, 0.10656200f, -0.10257144f, 0.30859870f, 
    0.01266806f, -0.32033277f, -0.38064179f, -0.09372752f, -0.01688615f, -0.02014798f, 0.31646800f, 0.14236766f, 
    0.60876656f, 0.01864815f, 0.22401044f, -0.21498774f, -0.08216149f, -0.21085872f, -0.18313196f, 0.16787235f, 
    -0.12558128f, 0.09261445f, -0.51785624f, 0.74848980f, 0.17632890f, 0.08708300f, 0.19683164f, -0.05865751f, 
    0.06843403f, 0.34078202f, -0.24554479f, -0.29003569f, 0.37958774f, 0.02396883f, 0.14086558f, 0.15448305f, 
    0.00226203f, 0.06557021f, -0.06792615f, 0.01025251f, 0.06122904f, 0.02391615f, -0.10165555f, 0.05949975f, 
    0.08602248f, -0.09135085f, -0.37557682f, -0.04082749f, 0.13215563f, -0.20047860f, -0.75081944f, -0.09315680f, 
    0.01479361f, -0.26787165f, -0.02457773f, -0.20268461f, -0.32343456f, -0.02042686f, -0.11873803f, 0.26158610f, 
    0.15001027f, 0.06271419f, -0.23699306f, 0.15561527f, -0.11531929f, 0.02771165f, 0.38610226f, 0.07043982f, 
    -0.13520411f, 0.30394763f, 0.04358265f, 0.09294291f, 0.01393947f, 0.00165088f, -0.19767980f, 0.32615885f, 
    0.11634722f, -0.26984990f, -0.03868541f, -0.02816885f, -0.27576730f, 0.24037813f, 0.29567045f, 0.01759272f, 
    0.36461896f, -0.11981501f, 0.00454291f, -0.11031383f, -0.15557098f, 0.30326095f, -0.07663637f, 0.02718545f, 
    0.09588390f, -0.13622026f, 0.21616924f, -0.15299425f, 0.08476985f, 0.00837175f, -0.16296424f, 0.10168085f, 
    0.02385691f, 0.01701608f, -0.44229114f, 0.20239760f, 0.09840923f, 0.05413713f, 0.12982233f, -0.39636937f, 
    0.10428025f, -0.08958711f, -0.05761177f, -0.45491266f, 0.26360512f, 0.58291775f, 0.15696692f, -0.06318761f, 
    0.06906053f, -0.28143981f, 0.17245770f, 0.26491550f, 0.23340146f, -0.08800197f, -0.28941303f, 0.24936521f, 
    0.02589932f, 0.16031754f, 0.20499527f, -0.11545995f, 0.13270682f, 0.15966134f, -0.33166584f, 0.02338204f, 
    -0.16115610f, 0.05415232f, 0.15146104f, -0.07003644f, 0.02340160f, 0.14962007f, 0.12349181f, 0.11853319f, 
    -0.11313558f, -0.41772276f, 0.18804421f, 0.07537389f, 0.06093189f, -0.37592426f, -0.16841187f, -0.58501059f, 
    -0.02083165f, 0.37945065f, 0.00426026f, -0.19589785f, 0.14545728f, -0.08998303f, -0.10245809f, 0.10493731f, 
    0.22729012f, -0.38466138f, 0.18017884f, -0.12867211f, 0.33994484f, 0.08516920f, -0.20682107f, -0.23073690f, 
    -0.01014949f, 0.21431734f, -0.14864060f, -0.26968119f, 0.38333225f, 0.15877438f, 0.38080209f, 0.18492827f, 
    0.11612906f, 0.25980118f, 0.50090832f, 0.29154697f, -0.15354775f, 0.30313030f, 0.07487301f, 0.02616778f, 
    0.09979420f, -0.15823388f, 0.06828259f, -0.01464658f, 0.04590698f, -0.50933075f, 0.15248990f, 0.34546128f, 
    -0.09038662f, -0.41365996f, -0.16205716f, -0.18078800f, 0.05395283f, 0.02244076f, 0.07044336f, -0.07920232f, 
    -0.12383715f, -0.15818462f, -0.25931439f, -0.11689761f, 0.03211027f, -0.53763908f, -0.17163703f, 0.30168954f, 
    0.03040008f, -0.06071325f, -0.13222902f, 0.06940135f, -0.05855971f, 0.12910223f, 0.53081322f, 0.34971783f, 
    0.73245943f, -0.13441056f, -0.05858215f, -0.10916591f, 0.20902923f, 0.08218315f, -0.03764397f, -0.09901225f, 
    -0.04670649f, 0.25151348f, -0.22776279f, -0.07069490f, -0.21993461f, -0.18302722f, 0.31411546f, 0.21299833f, 
    -0.27384323f, -0.17140055f, -0.07305980f, 0.20374991f, -0.04611959f, -0.04919250f, 0.34464207f, 0.15789963f, 
    0.16895373f, -0.27586919f, -0.12535943f, -0.20568731f, 0.11883127f, -0.10927334f, 0.03504103f, 0.01819270f, 
    -0.04036326f, 0.19534749f, 0.04296188f, 0.01590886f, 0.25613442f, -0.30328056f, -0.41084498f, 0.19828267f, 
    -0.21131399f, -0.06206576f, -0.07079927f, 0.46813142f, -0.13309211f, 0.05775076f, 0.00228871f, 0.25977075f, 
    -0.13244489f, 0.20616490f, -0.02297793f, -0.15995014f, -0.32255626f, 0.48025891f, 0.12110610f, 0.07972046f, 
    0.26005232f, -0.05637210f, -0.19780804f, 0.13425632f, 0.02673818f, 0.44849530f, 0.19891547f, 0.35093454f, 
    -0.25988653f, -0.51413888f, 0.09027713f, -0.05481641f, 0.14031285f, -0.16918972f, -0.49026150f, -0.57307291f, 
    -0.90395701f, -0.04410028f, 0.24998730f, 0.11364006f, -0.09308093f, -0.24705610f, -0.05279483f, 0.37907237f, 
    -0.07653956f, -0.48453394f, 0.24551682f, 0.17035337f, 0.08652935f, 0.24846494f, 0.09483352f, 0.10124961f, 
    -0.03031432f, -0.05324881f, 0.05441392f, 0.04993668f, -0.08725785f, -0.05384561f, 0.04817376f, -0.00880185f, 
    -0.00436607f, -0.07711321f, -0.09450796f, 0.00783319f, -0.01002173f, 0.06145754f, 0.04335179f, -0.02195428f, 
    -0.08302263f, 0.04964489f, -0.05810582f, -0.01185688f, 0.07423640f, -0.01471604f, 0.01524688f, -0.08171556f, 
    -0.00679980f, 0.05126545f, -0.02913124f, -0.04724924f, 0.02731323f, 0.03883120f, -0.06079393f, 0.05263425f, 
    0.07024489f, -0.06854744f, -0.01045498f, 0.04724867f, -0.00573469f, -0.01198133f, 0.00073616f, -0.08086455f, 
    0.06464139f, 0.02303345f, -0.01345243f, 0.05012843f, 0.01435662f, -0.01522745f, -0.02266329f, 0.00115671f, 
    -0.03237909f, 0.05265914f, -0.07844344f, 0.05447913f, -0.00246901f, 0.00407965f, 0.05396316f, 0.04275870f, 
    -0.03317328f, 0.05345413f, 0.03149789f, -0.04123906f, 0.01064483f, -0.04127660f, -0.07722386f, -0.02385302f, 
    -0.04922931f, 0.00302515f, 0.04249081f, 0.00698533f, -0.07681765f, -0.05527504f, 0.00350042f, -0.01612595f, 
    -0.04297217f, -0.05116779f, -0.05837063f, 0.01903576f, -0.09347538f, -0.00139059f, -0.06965797f, -0.00514225f, 
    0.02859910f, 0.00136334f, 0.03027808f, -0.07497207f, 0.04722562f, -0.07643820f, 0.00011586f, 0.00229043f, 
    0.06144559f, -0.01785298f, 0.04079070f, -0.01541511f, 0.03226279f, -0.08648757f, -0.06656429f, 0.06489480f, 
    -0.08047899f, -0.04508561f, -0.02870562f, 0.01302016f, 0.07189593f, -0.06900911f, -0.04414124f, -0.02943483f, 
    -0.04290052f, -0.06381190f, -0.08254075f, 0.03716605f, 0.00625145f, 0.04416882f, 0.03360384f, -0.04789118f, 
    -0.04689218f, -0.04364459f, -0.02465548f, 0.04133465f, -0.08804949f, -0.00259914f, -0.00763312f, -0.02638323f, 
    -0.07529538f, 0.06042271f, -0.08979762f, -0.07157893f, 0.03383002f, 0.04870071f, -0.05500862f, -0.07588370f, 
    -0.03064434f, -0.00804998f, 0.03327720f, -0.04138767f, 0.00921605f, 0.00222009f, -0.07373817f, 0.00912111f, 
    0.02325828f, 0.00188058f, -0.06113296f, -0.09191849f, 0.05338551f, -0.02011143f, 0.06289675f, -0.05709805f, 
    0.08363422f, -0.56019801f, -0.10304846f, 0.00448764f, -0.15036853f, -0.09315159f, -0.10716703f, -0.19189070f, 
    -0.06738964f, -0.51912987f, -0.08105391f, 0.22460863f, 0.07618408f, 0.03012408f, 0.06322557f, -0.23829989f, 
    -0.02423301f, -0.05452144f, -0.57851511f, -0.16169657f, 0.41232640f, 0.21010141f, -0.04981098f, 0.14820965f, 
    0.01459039f, -0.03239710f, 0.00151004f, -0.11584006f, 0.17075843f, -0.13157770f, 0.20169210f, 0.02195887f, 
    0.00246189f, 0.14004008f, -0.29151079f, 0.04628301f, 0.44029209f, 0.12002306f, -0.08241849f, 0.04161114f, 
    -0.03208577f, -0.01846207f, 0.20619799f, 0.03486220f, -0.01990540f, -0.09610151f, -0.32349834f, 0.18480475f, 
    0.26420876f, -0.05229075f, 0.07162722f, -0.10468512f, 0.25221315f, -0.05848067f, 0.06250909f, 0.10636773f, 
    0.52035755f, 0.33355701f, 0.18191487f, -0.04521155f, 0.01283932f, 0.12528431f, 0.10973599f, -0.17128853f, 
    0.19093548f, -0.04181105f, -0.04849990f, 0.04373334f, 0.03394720f, -0.09652537f, 0.02280365f, 0.24519002f, 
    -0.36458850f, -0.21358339f, -0.54385054f, -0.11285491f, 0.40586236f, 0.12039693f, 0.22372569f, 0.02270720f, 
    0.29227659f, -0.14922829f, 0.19830005f, -0.04284366f, 0.17287314f, -0.14678289f, 0.16944402f, 0.23212135f, 
    -0.20088415f, -0.04072382f, -0.32112989f, 0.04078908f, -0.00172549f, 0.04871745f, -0.11577076f, -0.04101869f, 
    0.12096461f, 0.18929102f, -0.06985440f, -0.32608014f, -0.43628848f, -0.23230828f, -0.17319885f, -0.10295142f, 
    -0.00037031f, -0.10640842f, 0.13999137f, -0.08980555f, -0.05832830f, -0.56178004f, -0.36284605f, -0.18589035f, 
    -0.23370825f, -0.09511458f, 0.10519946f, -0.00036680f, 0.13022001f, -0.07064026f, 0.45013949f, 0.14366840f, 
    0.14731808f, 0.06058037f, -0.07443668f, -0.05646884f, -0.22378662f, 0.01841039f, -0.05182278f, 0.05922957f, 
    -0.00129664f, -0.11793787f, 0.02406115f, 0.00990541f, 0.12994657f, -0.00327834f, 0.22708271f, -0.80805260f, 
    0.00584034f, 0.54393983f, 0.37066606f, 0.18038441f, -0.01253372f, -0.11694783f, -0.11740486f, -0.08906388f, 
    0.03753888f, -0.05761492f, -0.01246643f, 0.07738490f, 0.06366698f, -0.01185357f, 0.05189017f, -0.02538766f, 
    0.04057624f, -0.07793625f, -0.11422326f, 0.02525385f, -0.03643024f, 0.05954966f, -0.05650846f, 0.01344120f, 
    0.00636796f, -0.00504624f, -0.00868906f, -0.06723706f, 0.02451934f, -0.01107442f, -0.10332385f, -0.06302300f, 
    0.02785892f, -0.01446239f, 0.00656865f, -0.08460256f, -0.06566136f, 0.03073123f, -0.04780479f, -0.06559080f, 
    0.06498363f, 0.01091121f, -0.00928353f, -0.02321096f, 0.01640820f, 0.03301610f, 0.00188247f, -0.04579978f, 
    -0.04595757f, 0.02434568f, 0.03898378f, 0.04280005f, 0.06065313f, -0.05932651f, -0.03979316f, -0.05599543f, 
    0.07197504f, -0.07402302f, 0.02316474f, -0.07018087f, 0.01280759f, -0.01753449f, -0.01610498f, -0.03954484f, 
    0.00950319f, 0.00047923f, 0.01306221f, 0.04594976f, 0.05355292f, 0.05790679f, 0.03792923f, -0.10913182f, 
    -0.07100064f, 0.04083667f, -0.04890782f, -0.00192861f, 0.01317012f, -0.04175562f, -0.07984233f, -0.04653245f, 
    0.02051734f, -0.06212222f, 0.01577655f, 0.00325671f, -0.09813312f, -0.07231335f, -0.01302931f, 0.01555821f, 
    0.08093863f, 0.05019050f, -0.09825112f, -0.08881211f, 0.01120834f, -0.00345155f, -0.06371920f, -0.01496984f, 
    -0.04388633f, -0.05347658f, -0.02593798f, -0.06262524f, -0.04137821f, -0.04528325f, 0.08072165f, 0.03956882f, 
    0.00277955f, 0.04514093f, -0.03237594f, -0.05521515f, 0.03225118f, -0.04356787f, -0.01948720f, -0.04093561f, 
    0.08363714f, -0.05135502f, -0.07588387f, -0.05062288f, 0.00027730f, -0.03557662f, -0.07658604f, -0.00313532f, 
    -0.01848730f, -0.01420890f, -0.07680675f, -0.00115696f, 0.02960107f, 0.03294064f, -0.04063988f, -0.03910860f, 
    0.01306600f, -0.04392008f, -0.09017277f, 0.03265130f, 0.01088900f, -0.06607454f, -0.08585799f, 0.05448033f, 
    0.04732912f, -0.02146656f, -0.02848840f, 0.00157803f, -0.04045042f, 0.01915564f, -0.01406998f, 0.05126404f, 
    0.02093359f, 0.03713389f, 0.05415261f, -0.03098973f, -0.05281865f, -0.04775499f, 0.00088590f, 0.02926751f, 
    -0.16858765f, 0.52099502f, -0.01513057f, 0.12576225f, -0.08928877f, -0.15729216f, 0.02115630f, -0.08178194f, 
    -0.22569415f, 0.04743528f, 0.08247001f, 0.39045718f, -0.05904613f, 0.06836372f, -0.13289848f, 0.00801130f, 
    -0.02150469f, -0.06009585f, 0.00958656f, 0.04046261f, 0.37193409f, 0.06948109f, -0.00448425f, 0.11921740f, 
    -0.07145413f, 0.06697449f, 0.06268021f, -0.39985749f, -0.07329901f, 0.06951794f, -0.05684070f, -0.13907099f, 
    0.20903337f, -0.10162088f, 0.06456649f, -0.00976333f, 0.33920228f, -0.05668259f, -0.09791149f, 0.15155879f, 
    0.22925866f, -0.06868240f, -0.14763454f, 0.07556089f, 0.16183227f, -0.01649049f, 0.40915754f, 0.26260573f, 
    -0.14234029f, -0.20373975f, -0.14166710f, -0.07482664f, 0.02447988f, 0.19653073f, -0.09910355f, -0.09028918f, 
    0.15604697f, 0.16721433f, 0.20817986f, -0.20358069f, 0.00667526f, 0.22897217f, 0.07186049f, -0.44914371f, 
    -0.12095862f, -0.21718286f, -0.09365300f, 0.20835111f, -0.07062113f, 0.01894935f, 0.26817989f, -0.25829241f, 
    -0.56023240f, -0.74331105f, -0.05115508f, 0.23763141f, -0.01934277f, 0.25330335f, 0.01820077f, -0.21651380f, 
    0.46252796f, -0.21808198f, -0.12816285f, -0.52911443f, 0.35827821f, 0.17672133f, -0.06878825f, 0.05289963f, 
    0.20839971f, -0.03534755f, 0.15024845f, 0.28679785f, 0.15618944f, -0.00053861f, 0.08632009f, -0.27572322f, 
    0.06980068f, 0.01954925f, 0.03668943f, 0.15856905f, -0.29659751f, 0.33627972f, -0.14200346f, -0.21496257f, 
    0.01718172f, 0.05613356f, -0.22329699f, 0.10874507f, 0.33940879f, 0.31180051f, -0.12875530f, -0.23918545f, 
    -0.13807988f, -0.04030275f, 0.10235216f, 0.35825944f, 0.01709605f, 0.15083270f, -0.14637096f, -0.68122494f, 
    0.12337816f, 0.21282622f, 0.09542427f, 0.00951266f, 0.00748492f, 0.12677653f, 0.25760114f, -0.35332721f, 
    0.04850044f, 0.05313891f, -0.02775732f, 0.19244485f, -0.29027659f, 0.21253046f, 0.26668441f, -0.27071789f, 
    -0.75915360f, -0.98326766f, 0.25785574f, 0.03648482f, 0.20820662f, -0.06557550f, -0.01363799f, -0.00670673f, 
    -0.72244823f, -0.38115069f, -0.28138956f, -0.13480212f, -0.20972721f, -0.05734676f, 0.29086012f, 0.02431262f, 
    -0.05028183f, 0.30566835f, 0.04426478f, -0.61674708f, 0.17969790f, -0.09528904f, -0.02944819f, -0.00664389f, 
    0.06569832f, -0.23266080f, -0.61851496f, 0.14637706f, -0.27958506f, 0.02595423f, 0.28815261f, 0.08287913f, 
    0.02448569f, 0.03637610f, -0.02734607f, -0.30995053f, -0.70374846f, -0.06590375f, -0.12372791f, -0.03526281f, 
    -0.26389489f, 0.21741875f, -0.17073269f, 0.27603194f, 0.19536656f, 0.05868132f, -0.20079696f, -0.00958457f, 
    0.19011024f, 0.15673617f, -0.11531565f, 0.02218606f, 0.43708724f, -0.68125552f, 0.03099552f, -0.20920575f, 
    -0.08094501f, 0.07227524f, -0.06809070f, 0.05293909f, 0.11244596f, 0.24217963f, -0.10245933f, 0.34067371f, 
    0.04533776f, 0.20032173f, 0.12684546f, 0.14538409f, 0.09853335f, 0.15165408f, -0.04253118f, 0.06447086f, 
    0.08208082f, 0.19177663f, -0.21889341f, 0.26934710f, -0.16526185f, 0.08296169f, 0.04864224f, 0.14124572f, 
    0.27999806f, -0.04612892f, -0.01573719f, 0.01324395f, -0.01829376f, -0.21531759f, -0.22657743f, 0.00863941f, 
    -0.10932894f, 0.35715058f, 0.01341736f, 0.09588440f, -0.18958254f, -0.03420561f, -0.21635157f, -0.11517983f, 
    -0.10236586f, 0.15565510f, 0.01212196f, 0.64043218f, 0.10131420f, 0.01457509f, -0.05309738f, 0.15988000f, 
    -0.23439400f, 0.21093172f, 0.09554672f, -0.22506942f, -0.37850267f, -0.46549270f, 0.04408549f, 0.09118472f, 
    0.02303052f, 0.09238619f, -0.10697420f, -0.18421055f, -0.06611677f, -0.15921001f, 0.41813901f, 0.25684279f, 
    -0.02840534f, -0.09644354f, 0.05393397f, 0.00253076f, -0.11673566f, -0.28572091f, 0.10602979f, 0.03834643f, 
    0.02488231f, 0.18749143f, 0.23277757f, -0.09363287f, -0.01470619f, -0.00968235f, -0.28057024f, 0.09180547f, 
    -0.16258000f, 0.17217179f, -0.12460813f, 0.01604768f, 0.06494608f, -0.25729156f, 0.31583264f, -0.15824804f, 
    -0.47172272f, -0.20082211f, 0.04585885f, 0.07104576f, 0.01823441f, 0.11169063f, -0.04076580f, 0.28122425f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03832792f, -0.13132849f, 0.05507387f, -0.68030047f, 0.04656039f, 0.02337513f, 0.03604381f, -0.01195576f, 
    0.17029057f, -0.08233188f, 0.36098176f, 0.02518792f, 0.62047017f, 0.04523741f, 0.04142192f, 0.16765967f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20668407f, -0.36610600f, -0.45475921f, -0.58294547f, -0.14037265f, 0.16441427f, -0.04240848f, 0.12377522f, 
    0.09429897f, -0.07754003f, 0.67804646f, -0.20758370f, -0.70346135f, 0.08010869f, 0.03667573f, -0.06681661f, 
    0.24227212f, 0.15554316f, -0.02966926f, -0.55935067f, 0.16150710f, 0.06454019f, -0.18309605f, 0.16961370f, 
    -0.43453333f, -0.62780190f, 0.50122923f, -0.13136229f, 0.01840346f, 0.04789799f, 0.23159215f, 0.29100427f, 
    0.16251963f, -1.55787325f, 0.09909285f, 0.61682236f, -0.15476321f, 0.03828966f, 0.14263041f, 0.11604407f, 
    0.34783921f, 0.26329327f, 0.07343486f, 0.11907690f, -0.56631964f, 0.24240354f, 0.33544448f, -0.52809030f, 
    0.19770053f, 0.47099179f, -0.10862537f, 0.24591376f, 0.09781686f, -0.23597203f, -0.18633068f, 0.15867753f, 
    0.45536569f, -0.31792033f, -0.39336058f, 0.15224315f, -0.62097806f, -0.03686009f, -0.44773290f, -0.38421938f, 
    -0.14759587f, -0.39622864f, -0.42312101f, -0.55342233f, -0.11495054f, 0.06653924f, 0.23929057f, 0.18683456f, 
    0.25241610f, 0.24330723f, 0.29363680f, 0.06243984f, 0.52573609f, 0.18153812f, -0.13343732f, -0.31769770f, 
    0.11364528f, 0.16022597f, -0.16326784f, -0.68747544f, 0.09382714f, 0.01241983f, -0.24920689f, 0.15379100f, 
    -0.21774176f, -0.33932093f, 0.18062679f, -0.03566948f, 0.24944852f, -0.14946817f, -0.42421588f, 0.90330887f, 
    -0.14357330f, -0.38612413f, 0.39872056f, 0.06017505f, -0.00553189f, 0.04081282f, 0.08232959f, 0.03602299f, 
    0.01498521f, -0.16608474f, 0.15631571f, -0.09219135f, 0.32397342f, -0.16355100f, -0.89723927f, 0.20140351f, 
    -0.12876707f, 0.48619083f, -1.07431304f, 0.70228344f, -0.08034728f, 0.00141704f, 0.03423417f, 0.11949113f, 
    -0.05232792f, 0.97879893f, -0.41557574f, 0.02195830f, -0.68083477f, -0.11273639f, 0.21648607f, -0.30307955f, 
    0.12904328f, 0.43656397f, 0.07490990f, 0.52633810f, 0.03614672f, -0.09481274f, 0.24055709f, 0.13683049f, 
    -0.70683193f, -0.42229551f, -0.23888047f, 0.16136067f, 0.18521044f, 0.02442202f, 1.03532672f, -0.56149304f, 
    -0.17594491f, -0.32306269f, 0.05977188f, -0.28986761f, 0.06076328f, 0.04973091f, -0.04789087f, 0.17921948f, 
    -0.28576347f, 0.59386200f, 0.04461587f, 0.03427320f, 0.78202671f, 0.19740836f, -0.22726040f, -0.08095728f, 
    -0.22077374f, 0.31161270f, 0.13550062f, 0.57132608f, -0.17170265f, 0.06131244f, -0.15130889f, -0.07578732f, 
    0.58228415f, -0.78830391f, -0.65197110f, -0.12493971f, -0.07648198f, 0.17651440f, -0.03363020f, -0.64520252f, 
    -0.10109897f, -0.17336719f, 0.73330313f, -0.41942737f, 0.20002955f, 0.14994496f, -0.07199239f, 0.23286189f, 
    0.11632770f, 0.17326590f, -0.14485034f, 0.10421472f, -0.75661319f, -0.22613460f, -0.26338831f, -0.33579332f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.37226981f, 0.02672708f, -0.37581483f, 0.48909789f, 0.41357952f, 0.36825997f, -0.00714057f, -1.15209687f, 
    -0.41308698f, 0.36392772f, 0.34492871f, -0.18848187f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
