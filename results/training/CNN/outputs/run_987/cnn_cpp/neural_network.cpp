#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.28564030f, -0.47601390f, 0.54791611f, -0.66588926f, -0.53671253f, 0.15649663f, -0.05121431f, 0.11095869f, 
    0.54546654f, -0.71287417f, 0.68114758f, 0.85294175f, -0.37956983f, -0.46407956f, -0.14200504f, 0.34743461f, 
    -0.34751645f, -0.13315959f, 0.57250071f, -0.20207836f, -0.80502349f, -0.07669576f, 0.25557289f, -0.33504868f, 
    0.25459102f, 0.17000525f, 0.37290698f, -1.01186109f, -0.81990123f, -0.52545917f, 0.68754184f, 0.54099864f, 
    0.22619629f, 0.07722370f, -0.19296035f, 0.21468560f, -0.91581386f, 0.32969454f, 0.50998092f, -0.27536952f, 
    -0.33171964f, 0.40245131f, 0.16090687f, 0.34637371f, 0.05165261f, -0.62307531f, -0.29421756f, -0.24835725f, 
    0.66727996f, -0.49737328f, -0.11855308f, -0.30783921f, -0.09384073f, -0.56275666f, 0.17799328f, 0.51732391f, 
    -0.15142052f, -0.22499028f, 0.59332567f, -0.42076516f, 0.08808791f, 0.35481679f, -0.35099095f, 0.68228477f, 
    -0.24177012f, -0.11217938f, 0.37021682f, 0.38226864f, 0.42725649f, -0.50840664f, -0.36530843f, 0.35879245f, 
    1.13077807f, -0.85929394f, -0.21056768f, 0.59709948f, -0.38681301f, 0.01370409f, 0.01717218f, 0.27405000f, 
    -0.38605356f, -0.50061804f, 0.74961847f, -0.08987304f, 0.12509504f, 0.13543585f, -0.42563903f, -0.09828586f, 
    -0.04441755f, 0.50448817f, -0.33363780f, 0.34223247f, -0.63488364f, 0.07146226f, -0.59451944f, -0.52236086f, 
    -0.23258190f, -0.32007918f, -0.22475848f, 0.07045789f, 0.55977893f, 0.20441782f, -0.63762271f, -0.15582700f, 
    0.06919312f, 0.06987657f, 0.09167255f, 0.38065273f, -0.43288678f, -0.53696477f, -0.48576358f, -0.48959500f, 
    -0.57565027f, -0.37922865f, 0.46850535f, 0.45238012f, 0.03649903f, 0.56579584f, 0.06709100f, 0.45741230f, 
    0.28174990f, 0.24011002f, 0.18734382f, 0.23450583f, 0.10890765f, -0.10697190f, 0.42839062f, 1.19676316f, 
    -0.61014599f, -0.52794206f, -0.23257394f, -0.13364023f, -0.15054201f, 0.05175138f, -0.08481649f, 0.19664051f, 
    -0.78428864f, 0.68817276f, -0.34590814f, -0.34067178f, -0.07424751f, 0.31744471f, -0.31281316f, -0.26864114f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00777562f, 0.08684949f, 0.17003186f, 0.24276744f, -0.21272980f, -0.19889379f, 0.26216021f, -0.27529973f, 
    0.13846864f, -0.02903058f, -0.30232245f, 0.02935547f, 0.13117105f, -0.39490369f, 0.02760408f, -0.02911370f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02549787f, 0.30087468f, 0.13333850f, 0.08489621f, 0.03215773f, -0.07371536f, 0.11814402f, 0.00196937f, 
    0.05958642f, 0.13853584f, -0.03062356f, 0.09550562f, 0.12815124f, 0.08214503f, 0.06414416f, -0.02808786f, 
    -0.04663899f, 0.04987990f, -0.27106628f, 0.04812455f, 0.01953970f, 0.18687801f, 0.17324488f, 0.08228412f, 
    0.00493070f, 0.20771113f, 0.06448803f, -0.06904814f, 0.16689134f, 0.04838940f, 0.13918924f, -0.03737335f, 
    0.05841396f, -0.02257020f, -0.05824444f, 0.00812064f, 0.07776067f, 0.00841948f, -0.08163420f, 0.17223069f, 
    0.14009659f, -0.12918313f, -0.16735125f, -0.12218654f, -0.24302143f, 0.01823026f, -0.01702175f, 0.04279110f, 
    -0.06329376f, -0.13396372f, 0.00916582f, -0.01535479f, 0.16431288f, 0.03995968f, 0.12597345f, -0.03562011f, 
    -0.06247349f, -0.17484728f, 0.02792509f, -0.09748214f, 0.09838832f, -0.06777029f, 0.44098830f, 0.29376754f, 
    0.24149071f, -0.09154958f, -0.04106844f, 0.11102247f, 0.09025355f, -0.20338859f, 0.08605351f, 0.11484611f, 
    0.04025159f, -0.04912108f, 0.15420607f, 0.12108161f, 0.00299333f, 0.02849267f, -0.10057423f, -0.07524730f, 
    -0.01028941f, 0.13794972f, -0.09110258f, 0.01051866f, -0.25937736f, -0.02253796f, 0.06342063f, -0.12118194f, 
    0.09344467f, 0.05211359f, -0.12619139f, -0.06302843f, 0.09386843f, 0.01880308f, -0.01229108f, 0.02044492f, 
    -0.19650948f, 0.05075237f, -0.17808247f, 0.06318568f, -0.20404467f, 0.06804667f, 0.45548105f, 0.22146262f, 
    0.02158207f, 0.09215789f, 0.15630016f, 0.10982093f, 0.07230360f, -0.18715565f, 0.13155833f, 0.07340401f, 
    -0.12306186f, 0.04059804f, 0.11821470f, 0.19056697f, 0.24484658f, -0.00195326f, -0.01757264f, 0.13520759f, 
    -0.00967666f, -0.14696771f, -0.10666350f, -0.15059337f, -0.14351527f, 0.14840233f, -0.22766876f, -0.16164804f, 
    -0.11303421f, 0.04878170f, 0.02748177f, -0.00077260f, 0.07842766f, 0.01405953f, -0.12635350f, 0.12471426f, 
    0.00086121f, -0.00941745f, 0.10823388f, 0.09634823f, 0.25301972f, -0.05988294f, -0.40998849f, -0.26832238f, 
    -0.30727768f, -0.16002074f, -0.12374889f, -0.03452801f, -0.12768723f, -0.07134624f, -0.00416188f, -0.02676191f, 
    0.12469629f, -0.11143465f, 0.00585669f, -0.05724275f, 0.16337800f, 0.05507181f, 0.00479265f, -0.07732063f, 
    -0.13256091f, 0.28965622f, -0.09046359f, -0.15281358f, -0.12989962f, -0.08448763f, 0.01634158f, -0.04281809f, 
    -0.02461400f, -0.11432387f, -0.01157849f, 0.02988859f, -0.09109309f, 0.11635534f, -0.04820627f, 0.20792706f, 
    -0.09874948f, -0.05850009f, 0.12963019f, 0.04546720f, 0.14353928f, -0.15532091f, -0.18592179f, -0.08150829f, 
    0.06495506f, 0.23739858f, -0.20834765f, -0.28669327f, -0.07524821f, -0.04145331f, 0.00655992f, 0.13966525f, 
    0.03535726f, 0.04826025f, 0.04605476f, -0.07110377f, -0.08137159f, -0.28435713f, -0.04412480f, -0.02474478f, 
    -0.07141065f, 0.07455584f, 0.32420635f, 0.32433581f, 0.09204932f, 0.01073515f, 0.08965290f, 0.04126536f, 
    0.07179651f, 0.09592751f, 0.03473486f, 0.17568189f, 0.00854642f, -0.00958668f, 0.07974403f, 0.10035374f, 
    0.11381352f, -0.13063827f, 0.00866868f, 0.11852735f, -0.23043428f, -0.26119477f, 0.16265321f, 0.01602523f, 
    -0.05736278f, 0.00376580f, 0.00040970f, -0.19015002f, -0.29658368f, 0.00761362f, 0.02857400f, -0.03595645f, 
    0.03510578f, 0.09068464f, 0.05462319f, -0.05397798f, -0.10275171f, -0.05067561f, -0.16345841f, 0.04975425f, 
    0.21997918f, 0.27907056f, 0.19871286f, 0.27096146f, 0.11617728f, 0.05478223f, 0.09472388f, 0.04395916f, 
    -0.00876832f, -0.05598914f, 0.08559529f, 0.10629978f, 0.05696085f, 0.11905235f, 0.05818810f, 0.07992687f, 
    0.03548153f, -0.19522418f, -0.17175794f, 0.07098825f, -0.33214301f, -0.43009791f, -0.54149085f, -0.16043481f, 
    0.14370133f, 0.00685539f, -0.09600902f, -0.21662773f, -0.21605211f, -0.12837622f, -0.01131057f, 0.00713100f, 
    0.14742257f, 0.08868364f, 0.11268234f, 0.05699406f, -0.05073084f, -0.10473734f, -0.07189681f, -0.12079350f, 
    -0.12279308f, -0.17520316f, 0.27806237f, 0.08606561f, -0.04620499f, 0.06453244f, 0.13166046f, -0.23258084f, 
    -0.07360195f, 0.09811810f, -0.04917887f, 0.00285686f, 0.01322751f, 0.01110637f, -0.07063671f, -0.05046068f, 
    0.01742838f, 0.00085925f, 0.04495819f, 0.15674900f, -0.35044757f, 0.16575086f, 0.15373462f, -0.18131977f, 
    -0.00824073f, 0.03301731f, -0.02983364f, -0.04729664f, 0.16110969f, 0.08093438f, 0.00931086f, 0.02796204f, 
    0.11314959f, 0.01453113f, -0.07541985f, 0.09619896f, 0.14044650f, 0.01195781f, -0.08971165f, 0.08413610f, 
    -0.05126201f, 0.24119686f, 0.26941448f, 0.08043157f, -0.10105085f, 0.02452903f, -0.02699181f, 0.09499729f, 
    0.02156822f, 0.01218627f, 0.03375658f, 0.05389699f, -0.00350319f, -0.02367504f, -0.07849289f, 0.02819898f, 
    -0.05153013f, 0.04109652f, -0.10715820f, 0.05154664f, -0.11336480f, 0.04063961f, 0.00768352f, 0.31690696f, 
    -0.24324596f, 0.01588651f, -0.06557581f, 0.09532107f, 0.11978006f, 0.23774134f, 0.11792856f, -0.02175539f, 
    -0.01364243f, -0.01234839f, -0.08634400f, -0.03434368f, 0.08907271f, 0.12965411f, 0.13681711f, 0.08955704f, 
    0.15595450f, -0.03575508f, 0.30331054f, -0.20082963f, -0.16257001f, -0.06265234f, -0.04006377f, 0.02294603f, 
    -0.03934101f, -0.01109985f, 0.05266950f, 0.04040715f, 0.07262769f, 0.03078970f, 0.08199524f, -0.05497229f, 
    0.05964037f, -0.08668233f, -0.16069944f, -0.09180313f, 0.05103439f, -0.02340786f, -0.18179846f, 0.14922990f, 
    -0.49939373f, 0.02747535f, 0.08966734f, -0.14823976f, -0.00036283f, -0.09150836f, 0.17163537f, -0.13609394f, 
    0.03631975f, 0.17308600f, 0.00402914f, 0.01264880f, -0.03436766f, 0.05828290f, -0.09167796f, 0.00527685f, 
    -0.50121433f, 0.13157874f, -0.02014352f, 0.14512791f, -0.02402297f, 0.01187789f, 0.05181222f, -0.13042420f, 
    -0.02381500f, -0.03880134f, 0.14428356f, 0.10907218f, -0.13280153f, 0.01959422f, -0.05030674f, 0.06433037f, 
    -0.10454323f, 0.02380542f, -0.23928575f, -0.19573137f, -0.02904978f, -0.04479504f, 0.30100548f, -0.00698919f, 
    -0.13748810f, -0.02196584f, -0.00880007f, -0.02147965f, 0.02313080f, 0.13105662f, 0.13524593f, -0.10671263f, 
    0.05234933f, 0.18934797f, 0.14475279f, 0.04541654f, -0.03012632f, -0.00357430f, 0.12493217f, 0.16519275f, 
    0.14179181f, 0.04079368f, -0.30187485f, -0.01043547f, 0.15557462f, -0.06562184f, 0.12103504f, 0.01508098f, 
    -0.01428125f, 0.04573913f, 0.00962990f, 0.08717659f, -0.18087699f, -0.00348825f, -0.02230808f, 0.04617898f, 
    0.15141383f, 0.09488039f, 0.01491356f, -0.00807183f, 0.17756341f, -0.11291791f, -0.15864627f, -0.00240132f, 
    0.06779802f, -0.01623637f, -0.00333089f, 0.04105475f, -0.10705873f, -0.11816331f, -0.05088447f, 0.06806768f, 
    0.13843971f, -0.09381282f, -0.06505977f, -0.07793988f, 0.04859047f, -0.01647799f, -0.06880140f, 0.04161331f, 
    0.23869964f, -0.51984394f, 0.08167521f, -0.20867474f, -0.05616063f, -0.09838991f, -0.01708315f, -0.07508766f, 
    0.05744963f, -0.13868695f, 0.05357980f, -0.02396866f, -0.01857999f, -0.05335871f, 0.01609043f, 0.11664875f, 
    -0.05896698f, 0.05742311f, 0.10593735f, -0.01089599f, -0.23626798f, 0.22395061f, -0.11775040f, 0.14590892f, 
    -0.09166595f, 0.02083607f, 0.09070268f, -0.23747946f, 0.04317932f, -0.02443978f, 0.01453354f, 0.07256634f, 
    -0.06023834f, -0.06083529f, 0.04909053f, 0.10622478f, -0.07450611f, -0.09871624f, -0.00936003f, -0.15752412f, 
    -0.04626591f, 0.13007094f, 0.35707685f, 0.17618288f, -0.05261778f, 0.03112198f, 0.04123554f, -0.10636391f, 
    0.07949920f, 0.26560786f, 0.05103233f, -0.02903925f, 0.02061305f, 0.06506070f, 0.07511239f, 0.04993759f, 
    0.07045544f, -0.01175827f, 0.11511828f, 0.03940645f, -0.15167269f, 0.26419955f, -0.10495710f, 0.00829570f, 
    -0.07663576f, 0.11011326f, 0.11537690f, 0.00355545f, 0.04691283f, 0.04894526f, 0.11558767f, 0.04096180f, 
    -0.03094674f, -0.04553830f, -0.03802731f, 0.01584622f, 0.04062580f, -0.14714663f, -0.19160561f, -0.02008962f, 
    0.26429465f, 0.20463340f, 0.40818241f, 0.16568448f, -0.13273934f, -0.00125690f, -0.10912575f, 0.13132943f, 
    -0.04772147f, 0.14702609f, 0.01396512f, 0.04643182f, -0.02405927f, 0.03405077f, -0.05047275f, 0.02744017f, 
    -0.05179234f, -0.00359883f, -0.01113194f, -0.13353078f, -0.01222429f, -0.00287164f, -0.07529838f, -0.07688185f, 
    0.15915048f, -0.01098995f, 0.05628550f, 0.06309936f, -0.07566861f, -0.05414272f, 0.04494680f, 0.04527016f, 
    0.08224279f, 0.04263876f, -0.08434521f, 0.02657021f, 0.09839631f, 0.00209691f, -0.07213675f, -0.09667224f, 
    0.38864994f, 0.50393039f, -0.46637309f, 0.08333972f, -0.02335141f, 0.10513500f, 0.02731418f, -0.03839239f, 
    0.16466691f, 0.31740034f, 0.03550991f, 0.06719837f, -0.02432421f, -0.04197071f, -0.13800997f, -0.01419690f, 
    0.10915284f, -0.11399926f, 0.17324482f, 0.19954582f, 0.08235621f, -0.16974737f, 0.12059806f, 0.22623527f, 
    -0.14529401f, -0.04111342f, -0.06725210f, 0.08078492f, 0.05000172f, 0.06915124f, 0.11747741f, 0.03451725f, 
    0.05521561f, -0.08797202f, -0.03226140f, -0.01800999f, 0.00810186f, -0.03252454f, 0.06027592f, 0.10826335f, 
    0.24961199f, 0.08544837f, -0.01577957f, 0.15427797f, -0.40907988f, 0.01411905f, -0.08750305f, -0.10440824f, 
    -0.07308525f, -0.06108725f, 0.19246083f, 0.06851696f, 0.02915582f, -0.07931366f, 0.03508554f, -0.08070706f, 
    -0.02248926f, 0.00317524f, -0.07810797f, 0.23109722f, -0.18624593f, 0.04375678f, 0.33947584f, -0.07535698f, 
    -0.23013005f, 0.13259879f, -0.09892919f, -0.10389267f, 0.25037614f, 0.17024967f, -0.03524442f, -0.02795658f, 
    0.05043060f, -0.03696601f, -0.04183146f, 0.03355180f, 0.04225559f, 0.09927226f, -0.00816216f, -0.10540535f, 
    0.01218126f, -0.11551688f, -0.02329390f, -0.16669556f, -0.04777735f, 0.05875962f, -0.00630387f, 0.13305265f, 
    0.03696063f, 0.15654504f, 0.02281809f, 0.04942204f, -0.00038913f, 0.07388375f, -0.03879376f, -0.00303338f, 
    0.19195163f, -0.03524299f, -0.05224579f, 0.18365644f, 0.22545305f, -0.21036212f, -0.44058919f, -0.15434441f, 
    -0.29489055f, -0.03689843f, -0.03477914f, 0.05219428f, 0.06491984f, -0.15729393f, 0.14960258f, -0.13613215f, 
    -0.08667196f, 0.00588000f, -0.00615612f, -0.00630175f, 0.05531182f, 0.08348479f, 0.02003368f, 0.00441985f, 
    0.11085001f, 0.01553289f, -0.08114578f, 0.22794458f, -0.15283942f, -0.00953945f, -0.03725182f, -0.08486070f, 
    0.08091658f, 0.10791864f, -0.02583373f, -0.12944470f, 0.10870237f, -0.01583635f, 0.00583758f, -0.06645019f, 
    0.10583127f, 0.04628289f, -0.02331498f, -0.06388368f, 0.00932686f, 0.19189428f, 0.18730833f, -0.29773420f, 
    -0.12857898f, 0.10016757f, 0.02073992f, 0.08102380f, 0.13849585f, -0.04580614f, 0.04185030f, -0.08695266f, 
    0.06782074f, -0.13609552f, 0.07892319f, 0.07837219f, -0.26093158f, -0.19256234f, -0.01323366f, 0.02460073f, 
    -0.10549387f, 0.15035971f, -0.14769961f, -0.05335121f, 0.22351362f, -0.06388500f, 0.13131228f, -0.05651279f, 
    0.10992920f, -0.00911077f, 0.09368556f, 0.16766554f, -0.08658432f, 0.14736730f, 0.04803654f, -0.05000227f, 
    0.03096991f, -0.00439030f, 0.10551158f, -0.08683364f, 0.23569769f, -0.08111642f, 0.05940231f, 0.19154024f, 
    0.13268849f, -0.00828013f, -0.00919570f, -0.01867244f, -0.21823733f, -0.03710160f, -0.02062235f, -0.01275819f, 
    -0.04259797f, -0.02827584f, -0.05356921f, 0.06156906f, -0.18094213f, 0.01074779f, 0.05720625f, 0.04650545f, 
    0.36874133f, -0.21781166f, 0.04816577f, -0.36633056f, 0.20661516f, -0.04399325f, 0.11237081f, -0.09904386f, 
    -0.03980008f, -0.01798365f, 0.19045055f, -0.04829260f, -0.02097425f, -0.05103881f, 0.01518779f, -0.00491423f, 
    -0.03148576f, 0.00111265f, 0.21589783f, -0.06614105f, 0.07547106f, 0.12698320f, -0.22935843f, 0.21286115f, 
    0.02311951f, -0.09921957f, -0.00383991f, -0.06934997f, 0.13876063f, -0.05423329f, -0.14492899f, 0.04644998f, 
    0.07886850f, 0.10901478f, -0.01571071f, 0.09029624f, 0.05131851f, -0.03441751f, 0.12693974f, 0.18799645f, 
    -0.11345230f, 0.22559173f, 0.31322202f, -0.07788748f, -0.33126932f, 0.15693413f, -0.04296947f, -0.02044393f, 
    -0.04590552f, 0.01082560f, 0.08598794f, -0.04166674f, 0.10516465f, -0.03645048f, -0.04125091f, 0.03906166f, 
    0.04762327f, -0.07303475f, -0.08073258f, -0.06884031f, -0.06611244f, 0.16333009f, -0.12959050f, 0.12136315f, 
    0.02234073f, 0.05223927f, -0.12069032f, -0.08063082f, 0.06475081f, 0.02591210f, -0.02408516f, 0.02960159f, 
    -0.05198795f, 0.08400820f, -0.08420260f, 0.00103012f, -0.00870595f, 0.12436077f, -0.13434336f, 0.06117269f, 
    0.26526645f, -0.06060194f, 0.00723498f, 0.03333041f, -0.15850395f, 0.03914756f, 0.00543883f, 0.02596412f, 
    0.08481339f, 0.02419439f, -0.06927972f, -0.05566907f, 0.03673108f, 0.06510840f, 0.05237974f, -0.04576283f, 
    0.06373563f, -0.05021503f, -0.10666322f, 0.14903218f, -0.03767667f, 0.13546510f, 0.05704806f, 0.09285086f, 
    0.08871210f, -0.05125462f, 0.02007763f, -0.11563287f, -0.09224300f, -0.11973462f, 0.14140624f, -0.04105586f, 
    0.04631702f, 0.06893215f, -0.00469757f, -0.04376134f, 0.09730826f, 0.01841236f, -0.02563921f, -0.06079783f, 
    -0.09061158f, 0.16819289f, -0.04557936f, -0.11540882f, -0.23300242f, 0.05608658f, 0.05791907f, -0.25260711f, 
    -0.10198782f, 0.01932733f, -0.05000320f, 0.05820546f, 0.07308914f, 0.02628874f, 0.05930282f, 0.02802134f, 
    0.03671846f, -0.20103832f, 0.01291594f, 0.11317495f, 0.38299879f, 0.03343603f, 0.22470643f, -0.02597276f, 
    -0.14334559f, 0.05203084f, 0.15652713f, -0.04029316f, 0.08929078f, 0.08622061f, 0.16869132f, -0.08043551f, 
    0.17284903f, -0.02775214f, -0.06070482f, -0.14604503f, 0.05945962f, 0.17086428f, -0.07647556f, -0.19233449f, 
    0.15085359f, -0.19091871f, 0.29054129f, 0.00807498f, -0.01850232f, 0.16330990f, 0.05753298f, -0.09304214f, 
    0.11745028f, -0.02070389f, 0.06328479f, 0.02431170f, -0.02708964f, 0.05708101f, 0.06742800f, 0.00715301f, 
    0.01915353f, -0.02106835f, 0.04545034f, 0.10424861f, 0.12621491f, 0.11113203f, 0.48058179f, -0.05090211f, 
    0.22413604f, 0.10915137f, -0.03822250f, -0.02008774f, 0.08145963f, -0.01682678f, -0.05434985f, 0.06926058f, 
    -0.08830959f, -0.01723214f, 0.05959551f, 0.06620158f, -0.09117191f, 0.10990828f, -0.04480315f, 0.07432815f, 
    0.07395121f, -0.01917811f, -0.31986904f, 0.19289789f, 0.24500440f, -0.00953679f, 0.02671650f, 0.01188511f, 
    -0.04369722f, 0.06721047f, -0.04525768f, -0.08735885f, 0.04313344f, 0.01879220f, -0.04451254f, 0.04734045f, 
    0.05670578f, 0.06909798f, 0.03786355f, 0.00498447f, -0.30296806f, 0.19881521f, 0.06695887f, -0.06669796f, 
    0.27007174f, 0.10366905f, 0.04552453f, 0.11574479f, -0.00837940f, 0.19279069f, -0.03644198f, 0.00376760f, 
    -0.03658893f, -0.03497044f, -0.09936764f, -0.10905784f, -0.01775363f, -0.00393248f, 0.00999139f, -0.02539456f, 
    0.09653336f, -0.01316248f, 0.07584842f, -0.05238103f, 0.01936697f, 0.02080786f, -0.07690124f, -0.10352565f, 
    0.01454282f, 0.05360230f, -0.09749668f, -0.00004455f, -0.00296689f, -0.05267125f, 0.15496130f, 0.01178819f, 
    -0.00710084f, 0.16001017f, -0.02572928f, -0.09367477f, -0.24148718f, 0.06047058f, 0.12667874f, 0.16500880f, 
    0.20493008f, 0.03313634f, 0.07702186f, 0.07684243f, -0.22877042f, -0.11646273f, -0.13328254f, 0.05878172f, 
    -0.08939070f, -0.04267649f, 0.03655069f, 0.08389004f, -0.05910639f, -0.04510140f, 0.04266200f, 0.04709731f, 
    -0.05561907f, 0.08015911f, 0.02729453f, 0.13187510f, 0.02981637f, 0.21391769f, -0.09052278f, 0.03484803f, 
    -0.02227578f, -0.00944015f, -0.07383706f, -0.16293892f, 0.12824102f, 0.01047252f, 0.09129866f, 0.19289237f, 
    -0.09875546f, 0.17406437f, 0.13710834f, -0.00372700f, -0.18061553f, -0.07682352f, -0.10251909f, -0.16182734f, 
    -0.03204450f, -0.02215453f, -0.04496579f, -0.15895151f, 0.03066241f, 0.04610385f, 0.09409478f, -0.09475791f, 
    0.03025547f, -0.03609706f, 0.10375970f, -0.07230058f, -0.18011472f, 0.01753711f, 0.18752572f, -0.08724590f, 
    -0.52169740f, 0.41220799f, -0.12505446f, 0.15976943f, 0.21948178f, -0.04470564f, 0.08044276f, -0.11346311f, 
    -0.00182117f, 0.08252623f, 0.01505825f, 0.01223241f, -0.00470283f, -0.04332807f, -0.03332387f, 0.17568736f, 
    0.03684549f, -0.04325502f, 0.24026456f, 0.11920232f, 0.00026478f, -0.08028366f, 0.17483123f, -0.08479670f, 
    0.09829497f, 0.05350057f, 0.00150579f, 0.01934828f, 0.15441653f, 0.08978418f, 0.00235598f, -0.08266477f, 
    0.17047317f, 0.02933703f, 0.09899626f, -0.14045987f, 0.01585462f, -0.00267893f, 0.23290297f, 0.07438990f, 
    0.06885172f, -0.08415104f, -0.01528944f, -0.06195301f, 0.15669844f, 0.02424836f, -0.07090080f, 0.13515176f, 
    -0.00623573f, -0.00781250f, 0.00071321f, 0.01739926f, 0.00596986f, -0.20807484f, 0.01427154f, 0.22722770f, 
    -0.02316385f, -0.03433055f, -0.04824088f, 0.04140433f, 0.04225678f, -0.17376469f, 0.25929964f, -0.01787603f, 
    0.04233006f, 0.05892324f, 0.05900999f, 0.05072302f, 0.04164977f, -0.00770055f, -0.12457802f, -0.01250718f, 
    0.05251800f, 0.09062526f, 0.06879549f, -0.09242628f, -0.00605113f, 0.23801108f, -0.11766951f, -0.01985961f, 
    0.05124926f, 0.07564540f, -0.02489886f, 0.08069854f, 0.07376704f, 0.02643152f, 0.13869517f, 0.01852519f, 
    -0.07555488f, -0.10488208f, 0.01116878f, -0.05157428f, -0.10534840f, -0.05332676f, 0.00144242f, -0.07729103f, 
    -0.10168612f, -0.01156254f, -0.09291376f, 0.13731566f, -0.17868641f, -0.23011073f, -0.22384422f, -0.03902361f, 
    -0.12911205f, 0.06496114f, -0.00694224f, -0.08619481f, 0.02678789f, -0.03823851f, -0.17148735f, -0.06092146f, 
    -0.04911867f, -0.01542993f, 0.10385113f, -0.02041060f, 0.02095579f, -0.02573139f, 0.10064258f, -0.04302298f, 
    0.45916262f, -0.33811921f, 0.47961995f, 0.05406980f, 0.25127560f, -0.02676699f, 0.08394224f, 0.04009512f, 
    0.08384094f, -0.11764899f, 0.00737529f, 0.02621564f, -0.06106743f, -0.02445657f, 0.05941235f, -0.00994884f, 
    -0.06056949f, 0.08955330f, 0.04981039f, -0.01250138f, 0.10152220f, 0.08023977f, 0.23889226f, 0.08231036f, 
    -0.15942529f, 0.11504363f, -0.06000571f, 0.16437115f, 0.03631866f, -0.05886973f, -0.09555362f, -0.00088937f, 
    -0.05133554f, -0.04705486f, -0.02433307f, 0.04912062f, -0.03171069f, 0.25238761f, 0.07159166f, -0.04920990f, 
    0.02222267f, -0.02715161f, 0.03997431f, -0.00248406f, -0.05741990f, -0.00727844f, 0.00061654f, 0.03368261f, 
    -0.03521337f, -0.02447111f, -0.03665384f, -0.03175214f, 0.04682429f, -0.05314470f, -0.05946720f, -0.02431040f, 
    0.04233096f, -0.03241494f, -0.03767333f, -0.04703548f, 0.02602147f, 0.02199973f, -0.03957226f, -0.03785019f, 
    -0.02109975f, -0.01638062f, -0.05731392f, -0.01380204f, -0.06069398f, -0.02438652f, -0.01271832f, 0.03322181f, 
    -0.05212464f, -0.04627449f, 0.03849499f, -0.04772608f, -0.02836229f, -0.03729927f, 0.00460069f, 0.04658596f, 
    -0.02273035f, -0.05647473f, 0.02012900f, 0.00874827f, 0.01036009f, -0.05711196f, -0.04951591f, 0.04034075f, 
    0.01092218f, 0.02736409f, -0.00389450f, -0.05165939f, 0.00256853f, -0.01896819f, -0.00738716f, 0.02434859f, 
    0.00606937f, -0.01192821f, 0.04893236f, 0.01182946f, -0.01550122f, 0.04589149f, -0.06066370f, -0.05800685f, 
    0.00706821f, 0.04452965f, -0.01828990f, -0.02915677f, 0.01367307f, 0.02744318f, -0.02696023f, 0.02423611f, 
    -0.00088399f, -0.00151018f, 0.02345731f, -0.04014063f, -0.06083477f, 0.04076735f, -0.03594470f, 0.04259986f, 
    -0.02165328f, -0.05643295f, -0.00598651f, 0.00172828f, 0.00395410f, -0.05792163f, -0.04650563f, -0.00427669f, 
    -0.03520408f, 0.00924393f, 0.02887107f, 0.01668196f, 0.03335054f, -0.03529784f, -0.00951410f, 0.00040248f, 
    -0.01241790f, 0.02443477f, 0.04365291f, -0.00769833f, -0.04229572f, -0.03751873f, -0.06033791f, 0.02220483f, 
    -0.02844480f, -0.02453673f, -0.03077931f, -0.00057504f, 0.02303306f, -0.04991207f, -0.02208000f, 0.04084340f, 
    0.03211087f, -0.00892434f, -0.02309462f, 0.01069291f, 0.03896182f, -0.05508980f, 0.00741935f, -0.05983028f, 
    -0.00447104f, 0.02879719f, -0.01751416f, -0.05612612f, 0.04960478f, 0.03844768f, 0.02605951f, -0.04639573f, 
    -0.00880456f, 0.02564301f, -0.05864109f, -0.05612118f, 0.04413647f, 0.03939760f, 0.04026933f, 0.03273453f, 
    -0.01359888f, 0.03800111f, -0.03723476f, -0.00489755f, -0.01757484f, -0.02068162f, -0.03950082f, 0.04358508f, 
    0.00585631f, 0.00132796f, -0.03415461f, 0.02890168f, -0.00802042f, -0.03717780f, 0.02180095f, -0.02518279f, 
    -0.03302693f, 0.02406800f, 0.03995821f, -0.03764450f, -0.00842076f, -0.01826152f, -0.01248493f, 0.02982891f, 
    0.00581950f, -0.04811954f, -0.06049942f, -0.02356166f, -0.00708961f, -0.02905308f, 0.03839872f, -0.01788212f, 
    0.03446056f, 0.00659401f, 0.03435409f, -0.00376585f, 0.02767102f, -0.04886632f, 0.03378801f, 0.04819949f, 
    -0.04652477f, -0.05883265f, 0.00714375f, -0.05011831f, -0.05082748f, 0.04854076f, -0.03049469f, -0.01014585f, 
    0.01133996f, -0.05464028f, 0.01033369f, 0.04282161f, -0.02710272f, -0.01516573f, -0.04259731f, -0.05936858f, 
    0.01254986f, -0.02249252f, -0.03219313f, 0.00626097f, -0.01261119f, 0.00486959f, -0.00073994f, -0.05831455f, 
    0.00277664f, 0.01159948f, 0.02294412f, 0.03350477f, 0.03286787f, -0.01905127f, 0.01908160f, 0.02373025f, 
    -0.03047806f, -0.05764782f, -0.05746620f, -0.02631942f, -0.01049485f, -0.01626766f, 0.01556497f, -0.01400848f, 
    -0.05240083f, 0.00117274f, 0.01125572f, -0.05407585f, 0.02074132f, -0.00871450f, -0.03341882f, -0.01448519f, 
    -0.03549637f, -0.02979206f, -0.00832899f, 0.01212375f, 0.03465795f, 0.00160622f, 0.04741719f, 0.01590887f, 
    -0.05969667f, 0.02125470f, -0.05138261f, 0.01745467f, -0.03478000f, 0.03452178f, 0.00125452f, -0.02871430f, 
    -0.04206711f, -0.00048632f, -0.01350798f, -0.05006677f, -0.00223018f, 0.04441921f, -0.00452223f, 0.02584976f, 
    0.00017146f, -0.01967376f, 0.00887562f, -0.01872667f, 0.03741937f, -0.01472806f, -0.00793291f, -0.05189518f, 
    -0.03482740f, 0.00194303f, 0.02935574f, -0.03334074f, -0.03034999f, 0.01782846f, -0.02121096f, 0.00120670f, 
    0.03913731f, -0.00491484f, -0.04746515f, -0.02251177f, -0.03574084f, 0.01536844f, 0.04259274f, 0.00087331f, 
    0.03807602f, -0.03554814f, 0.00420931f, -0.05593468f, -0.04753881f, -0.04583701f, -0.03601094f, 0.02394391f, 
    -0.02544586f, 0.02826172f, 0.04660292f, -0.06092327f, -0.00066803f, -0.04646035f, -0.04900419f, 0.03797588f, 
    0.04522965f, -0.00307520f, -0.01725779f, -0.01424944f, -0.03336170f, 0.02376814f, 0.02235446f, -0.02348295f, 
    0.04880624f, -0.04048620f, 0.01900279f, -0.05129915f, -0.00440579f, 0.04764848f, -0.03418825f, 0.04696602f, 
    -0.03197605f, -0.04463099f, -0.00879920f, -0.05178548f, -0.04960394f, 0.01533773f, 0.04322744f, -0.01390421f, 
    -0.01797863f, -0.03767948f, 0.00853099f, 0.01631928f, 0.01832297f, 0.04839585f, 0.03812974f, -0.03803574f, 
    -0.19818258f, -0.00945828f, 0.37731588f, 0.05591954f, 0.01223629f, -0.05290845f, -0.06175251f, 0.08388875f, 
    -0.10454571f, 0.00740879f, -0.02763996f, 0.02911652f, 0.03992438f, 0.07234301f, 0.05836736f, -0.04445443f, 
    0.02673626f, -0.09420603f, 0.10529240f, 0.04840619f, -0.14761138f, -0.04841625f, -0.17087668f, 0.21765240f, 
    -0.03022138f, -0.01783748f, -0.15170629f, 0.06830917f, 0.11380606f, 0.06974339f, -0.12162559f, 0.07329611f, 
    -0.01203054f, 0.07913432f, 0.02505686f, 0.19556551f, 0.08490536f, 0.10350008f, 0.00934191f, 0.12057274f, 
    0.05223021f, -0.17820735f, 0.05826835f, 0.11795113f, -0.10203271f, 0.00680860f, 0.04740383f, 0.01178962f, 
    0.03521635f, 0.01586780f, 0.05815589f, -0.04729482f, 0.00481352f, 0.14140663f, 0.01926787f, -0.07165380f, 
    0.01328299f, -0.06322058f, -0.04465592f, 0.10586113f, 0.28930846f, -0.21686636f, -0.23162526f, -0.09013480f, 
    -0.35603192f, -0.12274567f, -0.07944412f, -0.03475877f, 0.06384851f, 0.21028887f, 0.05165131f, -0.05034276f, 
    -0.08606795f, -0.05953315f, -0.14112175f, 0.07392949f, 0.00997703f, -0.02762430f, 0.03622540f, 0.11531214f, 
    -0.18627343f, -0.25847635f, 0.21046470f, 0.00888474f, -0.10957655f, -0.07096151f, -0.02397785f, 0.09722728f, 
    0.04813730f, 0.05714382f, -0.09815182f, 0.06816559f, 0.13617748f, -0.01592706f, -0.03405201f, -0.17703183f, 
    0.03654031f, 0.12727296f, -0.08827166f, -0.01911134f, -0.00541698f, 0.00963840f, 0.12854922f, 0.03436044f, 
    0.05209258f, -0.01223399f, 0.13202511f, -0.00552103f, 0.02338289f, 0.09170639f, -0.07446875f, -0.02988901f, 
    -0.03492221f, -0.13788228f, 0.01558577f, -0.02995271f, 0.07803546f, -0.14385009f, 0.04326705f, 0.07698603f, 
    0.21114434f, 0.12830441f, 0.09694859f, 0.18376333f, 0.00086960f, -0.02176861f, 0.06258556f, 0.05669216f, 
    0.00546546f, -0.07462194f, 0.02465484f, 0.08200816f, 0.08701044f, -0.03528041f, -0.02830583f, -0.07598103f, 
    -0.00440961f, 0.18351047f, -0.03257825f, -0.03420924f, 0.26484492f, 0.07789324f, 0.28052706f, 0.13994956f, 
    -0.00704492f, -0.06647462f, -0.10072205f, -0.08258692f, -0.05365594f, -0.00965620f, 0.08709188f, 0.13793251f, 
    -0.05709099f, 0.07736839f, 0.05986103f, -0.09705520f, -0.02917448f, -0.20517279f, 0.02501598f, -0.12987576f, 
    0.67872155f, -0.31998101f, -0.09295568f, 0.11331964f, 0.02240348f, 0.07872601f, -0.00490554f, 0.02306093f, 
    0.21785262f, 0.08367742f, 0.02174165f, 0.02132226f, -0.11249730f, -0.06197263f, 0.04707965f, -0.19386369f, 
    -0.04575333f, -0.12837882f, -0.03317101f, 0.08190048f, -0.06967524f, 0.02272006f, 0.03202069f, 0.24961559f, 
    -0.15419941f, -0.09359933f, 0.07435767f, 0.07868855f, 0.13233088f, -0.08748090f, 0.11364372f, -0.01446149f, 
    0.08652241f, -0.01067540f, -0.08483788f, -0.05305652f, 0.01869881f, 0.22432584f, -0.05195647f, -0.06870265f, 
    0.01583274f, 0.29067969f, 0.08800340f, 0.00078108f, -0.13277848f, 0.05384905f, 0.02147831f, 0.12765682f, 
    -0.02997823f, 0.03537959f, -0.08012769f, -0.06465580f, -0.01956874f, 0.03878653f, -0.01062873f, -0.04692377f, 
    0.08964795f, 0.08372770f, -0.04904842f, 0.05423463f, -0.01483040f, -0.09690688f, 0.06287130f, 0.08752845f, 
    -0.03988374f, -0.05402808f, 0.07557831f, 0.13641775f, 0.05308395f, -0.00090851f, -0.00938152f, 0.01037013f, 
    -0.04749891f, 0.05172148f, 0.03571783f, 0.06780114f, 0.00011435f, 0.04977293f, -0.01037157f, 0.05565304f, 
    0.04704745f, 0.15873276f, 0.10693530f, 0.13934784f, -0.01110572f, -0.05909762f, -0.07653717f, -0.02819012f, 
    -0.07167557f, 0.03373350f, -0.05036973f, -0.05381736f, -0.03207129f, 0.08089951f, 0.01518557f, 0.00348320f, 
    -0.00862165f, -0.11207166f, 0.04334542f, 0.02678525f, 0.23790993f, 0.15573573f, 0.06750327f, 0.05752202f, 
    -0.06240105f, -0.03684612f, 0.02267498f, -0.03668556f, -0.05083600f, -0.04108744f, 0.15850365f, 0.01899822f, 
    -0.06841468f, -0.05405167f, -0.08908567f, -0.10550023f, -0.08540518f, -0.04785739f, 0.03203893f, -0.02086704f, 
    0.13203850f, 0.47929952f, -0.35171205f, 0.08874084f, -0.28935000f, -0.13254644f, -0.14770681f, 0.15785217f, 
    0.01061740f, 0.02767956f, -0.02656037f, 0.05777004f, 0.05780590f, 0.06038111f, -0.04482866f, 0.06131825f, 
    0.06011377f, 0.12877578f, -0.05323670f, -0.01707463f, 0.11091699f, 0.00731830f, 0.03350718f, 0.11007904f, 
    0.10382862f, 0.04326811f, -0.08931856f, 0.27269727f, 0.08326530f, 0.10844833f, -0.13458416f, -0.01416778f, 
    -0.01608278f, -0.09887087f, -0.03832043f, 0.03699135f, -0.08481526f, -0.17878981f, 0.17381166f, 0.12159141f, 
    -0.04969323f, -0.05475099f, -0.04946550f, -0.05119307f, -0.03833474f, -0.02261907f, 0.03193557f, -0.03620894f, 
    0.03391864f, -0.05525812f, -0.02331789f, 0.00427978f, -0.02917347f, -0.03611995f, -0.00119773f, -0.05046069f, 
    0.02511338f, 0.02503617f, -0.05016313f, -0.02116875f, 0.02303245f, -0.04887941f, -0.06059253f, 0.03316791f, 
    -0.04881331f, 0.02484017f, -0.02087049f, 0.02056784f, -0.04480633f, 0.03630468f, 0.00572839f, 0.00512922f, 
    0.02398471f, -0.03962952f, -0.03907565f, -0.00260492f, 0.02473160f, -0.01921805f, 0.01294689f, -0.02942386f, 
    0.01556011f, -0.05155839f, -0.04933712f, 0.00976848f, 0.03321879f, -0.03823854f, -0.00615370f, -0.02919037f, 
    0.01171524f, 0.04233410f, -0.05574209f, 0.01772357f, -0.02645195f, -0.00185806f, -0.05493206f, -0.05538179f, 
    -0.05103945f, -0.04565272f, -0.03651364f, -0.02654515f, -0.01247396f, 0.00879035f, -0.03989488f, 0.01395533f, 
    0.02757516f, -0.05092441f, 0.04068568f, -0.00258886f, -0.04247189f, -0.01506953f, -0.03031429f, 0.01239367f, 
    0.01737342f, 0.01850277f, -0.01124151f, 0.04074616f, -0.00391482f, -0.00231119f, 0.02748167f, 0.02087430f, 
    -0.03493373f, -0.04284634f, 0.00037762f, -0.01368773f, -0.04814810f, 0.00754074f, -0.01491564f, 0.02957599f, 
    0.04464236f, -0.04008302f, -0.02874348f, -0.02064824f, -0.01483134f, -0.02476820f, 0.04041077f, -0.03270661f, 
    -0.03023019f, 0.02886362f, 0.03996640f, 0.04275235f, 0.00645258f, -0.04664853f, 0.04350318f, 0.02816793f, 
    0.03815733f, 0.04518564f, -0.05261192f, -0.05993612f, 0.04156324f, 0.03942680f, 0.04812783f, -0.04787134f, 
    -0.04773860f, 0.02207746f, 0.01373204f, -0.02737278f, -0.02885086f, -0.03993886f, -0.04354754f, -0.01551749f, 
    0.02628956f, 0.02190252f, -0.04030187f, 0.02426677f, 0.00264371f, 0.00675300f, -0.01481197f, -0.03899642f, 
    -0.03231452f, 0.02070812f, 0.02430395f, -0.01646779f, -0.01904917f, 0.04926131f, -0.00052189f, 0.03805607f, 
    0.02004582f, -0.01174734f, -0.00932427f, 0.02946160f, 0.04973445f, -0.04702530f, -0.03687019f, -0.02774335f, 
    0.00915120f, 0.03701106f, 0.00995189f, 0.02702910f, -0.00672995f, -0.00458037f, 0.02183230f, 0.01970819f, 
    0.01929216f, -0.00291950f, 0.04696924f, -0.02066043f, 0.04967241f, -0.02989089f, -0.04634262f, 0.03799836f, 
    -0.03058016f, -0.00596340f, -0.01804478f, -0.00331482f, -0.03695101f, 0.00960959f, 0.04334033f, -0.05048010f, 
    0.02191438f, 0.03664125f, -0.04793959f, -0.03114831f, -0.05075305f, -0.01117016f, -0.04001861f, -0.05214992f, 
    -0.05678222f, 0.04386906f, -0.03317492f, -0.04956022f, 0.03473330f, -0.05404727f, -0.05672887f, -0.00887456f, 
    -0.01977385f, -0.02658036f, 0.00784999f, 0.02095387f, -0.04209454f, 0.03240932f, -0.00457279f, -0.01395400f, 
    0.01964501f, -0.01022529f, 0.03436832f, 0.04066695f, -0.03157816f, -0.03040995f, 0.02527819f, 0.02743603f, 
    -0.05427489f, 0.03594803f, -0.03065406f, -0.04033799f, -0.03459809f, -0.02657430f, 0.03098634f, -0.00088036f, 
    0.01989419f, -0.03713916f, 0.00765898f, 0.02841488f, 0.02173574f, -0.00659111f, 0.01785163f, -0.04376772f, 
    -0.01592100f, -0.04857827f, -0.01431931f, 0.03036271f, 0.01602832f, -0.02343003f, 0.04482250f, -0.04590559f, 
    -0.04178289f, 0.02005066f, -0.00107697f, -0.01715375f, -0.00073057f, -0.05083252f, 0.01817827f, -0.03301581f, 
    0.01100395f, -0.04561177f, -0.02497035f, -0.03060182f, 0.02767340f, -0.05450572f, -0.03009944f, -0.00686251f, 
    -0.01936807f, -0.04308967f, -0.03021161f, -0.05976454f, -0.04479168f, 0.03416734f, 0.02511375f, -0.01598333f, 
    -0.03795861f, -0.06116450f, 0.04342698f, -0.00950874f, 0.02315355f, 0.02693253f, -0.06109686f, 0.02290120f, 
    -0.05508799f, -0.04318183f, -0.04085861f, -0.04484461f, 0.00835833f, -0.04108790f, -0.01532949f, 0.00859859f, 
    -0.03961693f, 0.01192387f, 0.04721921f, 0.04324424f, -0.05167985f, 0.02723580f, -0.00188009f, -0.04105604f, 
    -0.03486904f, -0.01813037f, -0.01847892f, -0.04140599f, 0.03164545f, -0.01551272f, 0.01313483f, 0.02631174f, 
    0.02609128f, 0.04486076f, -0.01724936f, 0.00715300f, -0.04653243f, -0.03065843f, 0.02304956f, 0.02849959f, 
    0.03745911f, 0.04309388f, 0.02912608f, -0.03495543f, 0.00509340f, -0.02713999f, 0.02616475f, -0.02821055f, 
    0.03059283f, 0.04684768f, -0.02507765f, -0.02501941f, 0.01306982f, 0.00751190f, 0.00449461f, -0.05676609f, 
    -0.04867044f, 0.02710424f, -0.02564634f, 0.04428962f, 0.01393859f, 0.03481510f, 0.02367882f, -0.00325386f, 
    0.02071078f, 0.02346969f, 0.04157933f, -0.05394202f, -0.04254735f, 0.01356606f, 0.01529201f, -0.04090585f, 
    -0.04077097f, -0.12831859f, -0.21933584f, 0.28606343f, 0.00105771f, 0.01771220f, 0.03419546f, 0.05876622f, 
    0.03013135f, 0.05395090f, 0.11707085f, -0.01471800f, -0.01082713f, -0.08637232f, -0.00901838f, -0.02184782f, 
    -0.08215390f, -0.01261475f, 0.01730436f, 0.03976170f, 0.02196051f, -0.06169791f, -0.51415658f, 0.28875041f, 
    -0.24167113f, 0.15856160f, 0.09256983f, 0.08082706f, -0.03196977f, 0.07411188f, 0.10883444f, -0.04841622f, 
    0.02724381f, 0.06270844f, -0.06588074f, 0.00301285f, -0.00799234f, -0.04474283f, 0.04584775f, 0.08637130f, 
    0.13970459f, 0.10462121f, 0.51579916f, -0.24207084f, 0.02571903f, -0.00590139f, -0.01526942f, -0.04758690f, 
    -0.05474229f, -0.01967235f, -0.02337990f, 0.01979866f, 0.08820879f, -0.08307631f, -0.05746334f, -0.08189890f, 
    -0.08706950f, -0.07873973f, -0.13722591f, -0.11200792f, 0.05903452f, -0.10232225f, 0.28601253f, 0.28124174f, 
    -0.01246661f, -0.10008155f, -0.06468343f, -0.23949730f, 0.05260510f, -0.04866586f, 0.12976755f, -0.03514781f, 
    0.00167849f, 0.18667772f, 0.02648885f, -0.05606186f, 0.00118337f, 0.05360202f, -0.02820535f, 0.00733508f, 
    -0.09889384f, 0.12223575f, -0.52065343f, 0.10936343f, -0.10940199f, 0.01789883f, 0.01677918f, -0.01350904f, 
    -0.17487136f, -0.01677877f, 0.14241092f, -0.02305566f, -0.06238665f, -0.07515196f, -0.11020736f, 0.04645126f, 
    -0.25199297f, -0.04846634f, -0.11804760f, -0.12319303f, -0.10249633f, -0.49359989f, -0.01615845f, 0.21940899f, 
    -0.17063813f, -0.02113009f, -0.01506805f, -0.02291798f, 0.04510002f, 0.00652426f, 0.07180966f, -0.15239382f, 
    0.03611067f, 0.19447018f, 0.05321689f, 0.14123978f, 0.20998949f, 0.10671126f, 0.12698252f, 0.15065973f, 
    0.21553977f, 0.02099961f, -0.08209153f, -0.11876427f, 0.08643404f, -0.02914029f, 0.16876860f, 0.15950003f, 
    -0.09496522f, 0.06180520f, -0.04898087f, 0.01131204f, -0.01119373f, 0.05484698f, 0.01929054f, 0.05809145f, 
    0.08573793f, -0.00082808f, -0.00318788f, -0.00823765f, -0.04635739f, 0.08272990f, -0.02021834f, -0.19102497f, 
    -0.03624694f, -0.20268422f, 0.00286642f, 0.18993941f, -0.17042191f, -0.00573537f, -0.12230194f, 0.13681842f, 
    0.11230846f, 0.10873912f, 0.06046309f, -0.10652137f, 0.08070718f, 0.17152272f, -0.08345535f, -0.00905216f, 
    0.10796952f, -0.17569849f, 0.25457892f, -0.13819279f, -0.19442166f, -0.08847085f, 0.03951428f, 0.06160586f, 
    0.06249971f, -0.19813138f, 0.08627100f, -0.01560566f, 0.06063187f, 0.08710229f, 0.11385323f, 0.11255872f, 
    -0.08985111f, 0.04316495f, 0.00308888f, -0.11615749f, 0.04871165f, 0.15739974f, -0.19382650f, 0.07460175f, 
    -0.06953908f, 0.00255392f, 0.10078072f, -0.03149245f, -0.14078818f, -0.07286996f, 0.02044035f, 0.00858322f, 
    0.08124122f, -0.16948357f, 0.10843050f, 0.20148054f, -0.13699770f, -0.14783145f, -0.08387561f, -0.14769225f, 
    -0.11504894f, -0.34432229f, 0.07915395f, 0.11086131f, 0.00103098f, -0.01077157f, -0.00002984f, 0.05553322f, 
    0.13026181f, 0.07209048f, -0.03538549f, -0.05971887f, 0.00945795f, 0.08161478f, -0.05805592f, 0.13796224f, 
    0.10775902f, -0.01749110f, 0.16222017f, 0.13267447f, -0.14293307f, 0.16376941f, -0.42462423f, 0.04866647f, 
    0.05218639f, 0.10794745f, 0.04794855f, 0.04468052f, -0.08132101f, -0.04397995f, 0.22186635f, -0.00009771f, 
    0.06543606f, -0.14757106f, 0.05892072f, -0.04060287f, -0.00014774f, -0.11651155f, 0.00552401f, -0.15455103f, 
    -0.01313034f, -0.06005712f, 0.26588133f, 0.18009846f, -0.07468183f, -0.09003617f, -0.06656578f, 0.10520678f, 
    0.03568433f, 0.16958135f, 0.05631262f, 0.05256047f, -0.00901800f, -0.11867585f, -0.13698949f, -0.00254973f, 
    0.11914700f, -0.07439031f, 0.11120638f, -0.09967330f, 0.08340429f, 0.05594724f, 0.06705905f, -0.18107867f, 
    0.10312654f, 0.11279815f, 0.06604254f, 0.16317655f, 0.14401425f, 0.03498875f, 0.20326030f, 0.14070460f, 
    0.11897166f, 0.13690853f, 0.10006562f, 0.05991542f, 0.03398272f, -0.07682345f, -0.13040790f, -0.14859165f, 
    0.19468346f, 0.27019367f, -0.36501175f, 0.01483674f, 0.18004128f, 0.15905474f, 0.11049495f, 0.14316306f, 
    0.02840985f, 0.07891428f, -0.09113868f, 0.02188654f, -0.01081745f, -0.15298943f, -0.10121232f, 0.09962753f, 
    0.08113610f, 0.05492095f, 0.01531536f, 0.03672197f, 0.03116202f, -0.24780093f, -0.27963379f, 0.32563373f, 
    -0.21838568f, 0.04402805f, 0.00376147f, 0.07675928f, -0.00041560f, -0.04080563f, 0.10690296f, -0.04696453f, 
    -0.06352382f, 0.10299741f, -0.02027117f, -0.01780160f, 0.14299349f, -0.10808882f, 0.03785141f, 0.16156280f, 
    -0.46999502f, -0.11280758f, 0.22714123f, -0.32157663f, 0.12609330f, 0.02347286f, -0.06158466f, 0.12750968f, 
    0.02952327f, -0.02325797f, -0.17741388f, 0.07515688f, 0.00006055f, 0.05674028f, 0.05572215f, 0.03171216f, 
    0.11275035f, -0.02651328f, 0.21947621f, -0.10058670f, 0.00320018f, -0.14091611f, -0.21913569f, -0.01483565f, 
    0.25639197f, -0.08211584f, -0.05588460f, 0.07183731f, -0.02414060f, -0.08006077f, 0.07054242f, 0.05904613f, 
    -0.02717569f, 0.02298837f, 0.11707388f, 0.12927455f, -0.00440493f, -0.02676780f, 0.05082254f, 0.07097752f, 
    0.13320701f, 0.05630977f, 0.03356359f, 0.16765967f, -0.03918018f, -0.15095894f, -0.03842067f, 0.00460756f, 
    -0.06655522f, -0.14896700f, -0.10338992f, 0.01537622f, -0.12959862f, -0.03982133f, 0.09965600f, 0.04140897f, 
    -0.14710668f, 0.10860431f, -0.09346689f, -0.02669268f, -0.49944997f, 0.27901489f, -0.03918878f, -0.23610698f, 
    -0.22881007f, -0.01494232f, -0.03129717f, -0.08123931f, -0.19790745f, 0.29976347f, -0.04613951f, 0.04578501f, 
    0.05539609f, -0.02867995f, -0.00728893f, 0.02599118f, -0.01751241f, -0.00574209f, -0.01321815f, 0.05633652f, 
    -0.52519947f, -0.13733630f, 0.11571068f, -0.07162239f, 0.06537877f, -0.08071110f, 0.00356867f, -0.05890589f, 
    -0.00069508f, -0.11561498f, 0.14355910f, 0.15357265f, 0.06204377f, -0.01595739f, 0.14289947f, 0.06242225f, 
    0.06838430f, -0.13898617f, 0.00694284f, -0.11084220f, 0.01631977f, -0.11006205f, -0.34292001f, 0.26614919f, 
    0.12319901f, -0.05563750f, -0.03423002f, 0.00968836f, -0.16968928f, 0.08693183f, -0.02426801f, 0.05206756f, 
    0.17705700f, -0.07481045f, -0.10719918f, 0.14073920f, 0.04530995f, 0.01856719f, 0.17732579f, 0.06527791f, 
    0.25398362f, 0.05693487f, 0.03694432f, 0.18507585f, 0.03024506f, -0.06949264f, 0.09742460f, 0.03574993f, 
    -0.03305383f, 0.02378015f, -0.00928436f, -0.03804329f, -0.02589425f, -0.06694888f, 0.12015389f, 0.02133366f, 
    0.05114595f, 0.06484745f, -0.07421485f, 0.06159600f, 0.06526718f, 0.10828072f, 0.14457959f, -0.04164650f, 
    0.09705321f, -0.07350855f, -0.03412971f, -0.02462563f, 0.02589885f, -0.05534997f, -0.03766115f, -0.06011474f, 
    -0.01751108f, -0.03358129f, 0.01673369f, 0.08087820f, -0.04706497f, -0.12616192f, -0.11824591f, -0.08089079f, 
    0.05800994f, -0.07067156f, -0.04455988f, 0.34253311f, 0.00338586f, 0.07925779f, -0.01037250f, 0.18540092f, 
    0.07643472f, 0.01373870f, -0.15360077f, 0.06042635f, 0.01287463f, -0.08147891f, 0.04396834f, -0.11050481f, 
    0.00989590f, 0.05415657f, -0.12269956f, 0.08467591f, -0.18285248f, -0.05653483f, 0.24518816f, 0.00129761f, 
    0.04234785f, -0.01061450f, 0.16125441f, 0.04141819f, 0.01170795f, 0.00619771f, 0.05001074f, -0.09464641f, 
    -0.28311294f, 0.14833327f, 0.04771905f, -0.14189503f, 0.06900402f, 0.09566879f, 0.02278620f, -0.09307538f, 
    -0.09160788f, 0.06716056f, -0.41739854f, -0.12986928f, 0.03758597f, -0.07624828f, -0.13628449f, -0.03159656f, 
    0.04550116f, -0.04695529f, 0.04386071f, 0.05415022f, 0.03775324f, 0.07335462f, 0.11759894f, 0.12113903f, 
    -0.03047867f, 0.16603605f, 0.04627141f, 0.01515731f, 0.29530141f, 0.01957139f, 0.15084700f, -0.17693034f, 
    0.06904517f, 0.00542432f, 0.10983865f, 0.04582699f, 0.16082422f, -0.04118975f, -0.07897836f, -0.00225363f, 
    0.01639478f, -0.01862838f, 0.05905674f, -0.14228773f, 0.13393714f, -0.06055913f, 0.05765382f, 0.00833979f, 
    -0.39900136f, -0.13901916f, 0.14413522f, 0.01407777f, -0.06966868f, -0.15152811f, -0.06556948f, 0.06778043f, 
    -0.05516355f, -0.07027707f, 0.02761761f, 0.11967761f, 0.00724403f, -0.06123242f, 0.08078019f, 0.04347645f, 
    0.01721951f, 0.04333565f, 0.12625696f, -0.08298240f, 0.14753315f, 0.01312598f, -0.04875050f, -0.04680126f, 
    -0.08290819f, 0.02008837f, 0.05123744f, -0.02512548f, 0.02426843f, -0.02763855f, -0.14491779f, -0.16126066f, 
    -0.11830264f, -0.20960939f, -0.25930873f, 0.01973512f, -0.05465115f, -0.05107566f, -0.04907810f, 0.00698654f, 
    0.59025162f, -0.07513471f, -0.19693610f, -0.00245792f, 0.02111593f, 0.04262223f, -0.04017718f, 0.19455056f, 
    0.21962649f, -0.03749464f, -0.06449208f, 0.10209313f, -0.08794050f, 0.05914532f, -0.07323935f, -0.01746862f, 
    -0.01473973f, 0.14283611f, 0.07836152f, 0.08557695f, 0.00869372f, -0.16632195f, -0.09262230f, 0.01867872f, 
    0.05367983f, 0.06395222f, -0.00228748f, 0.21644655f, -0.06287062f, -0.00693042f, -0.12986080f, 0.09586919f, 
    0.04122046f, 0.00828534f, 0.09978774f, 0.18911225f, -0.01659987f, -0.08369863f, 0.16018000f, -0.00933879f, 
    0.30791399f, -0.13432243f, 0.04944012f, -0.24569337f, 0.13477372f, 0.00007443f, 0.00297623f, 0.00032480f, 
    -0.04971478f, 0.02227832f, 0.02459013f, -0.02685018f, 0.12804292f, 0.00131372f, 0.00808449f, -0.02271002f, 
    -0.00030384f, 0.03947255f, -0.19028015f, -0.18323365f, 0.44614664f, 0.13110779f, 0.32624331f, -0.16063915f, 
    0.17595451f, 0.07076313f, -0.20014279f, -0.11119785f, -0.09910586f, -0.11055981f, 0.11312089f, -0.03640730f, 
    0.04988227f, -0.04249695f, -0.04289961f, -0.01688026f, 0.10085576f, 0.00789242f, -0.01623859f, 0.20159912f, 
    0.00936435f, -0.16292392f, -0.22476462f, 0.32868761f, 0.17401813f, 0.00892826f, 0.15395802f, 0.03848907f, 
    0.01896675f, -0.03353158f, -0.07110517f, 0.05532725f, 0.02746378f, -0.03588239f, 0.08017860f, -0.09220604f, 
    -0.03133556f, -0.08424925f, 0.05644828f, -0.11613567f, -0.23156209f, -0.34500092f, -0.03601933f, 0.12367431f, 
    0.28013441f, 0.05479501f, 0.05263029f, 0.32090065f, 0.01400843f, 0.02023862f, 0.03036014f, -0.14888981f, 
    0.08189544f, -0.08822177f, -0.07863266f, -0.01464713f, -0.01698253f, -0.01094611f, -0.04537160f, -0.02322388f, 
    0.14882363f, 0.04025723f, 0.19039600f, -0.08942346f, 0.15744300f, 0.21813811f, 0.21381083f, 0.16312364f, 
    0.05665720f, -0.01479241f, -0.04508590f, -0.05781014f, 0.08694005f, 0.03583167f, -0.03310276f, -0.17640035f, 
    -0.11591234f, 0.05508117f, -0.08114705f, 0.12846816f, 0.22548184f, 0.03906040f, 0.02234502f, 0.27007332f, 
    -0.06903850f, 0.07457931f, -0.15971868f, 0.13552503f, 0.03740533f, -0.03362788f, -0.04572215f, -0.01356451f, 
    -0.14432612f, -0.03138127f, 0.01739467f, 0.05819463f, 0.06807589f, 0.09573501f, 0.03795356f, 0.08437982f, 
    -0.06606986f, 0.05023361f, -0.02091103f, 0.09100112f, 0.01079154f, -0.12327403f, 0.08058272f, -0.00765044f, 
    0.05411031f, 0.12436079f, -0.05862610f, 0.05770905f, 0.08961800f, 0.09578138f, -0.00781096f, 0.09450305f, 
    0.04895694f, -0.11194062f, 0.06657445f, 0.08870997f, -0.13980541f, -0.15094408f, 0.17384392f, -0.02033988f, 
    0.01190597f, 0.10059882f, 0.16890478f, 0.09895433f, 0.12155426f, 0.11603398f, -0.03318227f, -0.04981520f, 
    0.02751784f, -0.12707819f, 0.18641949f, 0.09886357f, 0.07066939f, -0.00594583f, -0.07632175f, -0.14962795f, 
    -0.17416666f, 0.04246745f, -0.27727288f, 0.42480397f, -0.22466023f, -0.09487095f, -0.09653776f, 0.02821582f, 
    0.15280433f, -0.01571456f, -0.16517693f, 0.02177163f, -0.15808414f, 0.11798494f, -0.09466399f, -0.04939559f, 
    -0.08059026f, 0.07249725f, -0.14406058f, -0.16029304f, 0.17351222f, -0.02435700f, 0.21123008f, -0.12275102f, 
    0.07842084f, 0.20926702f, 0.01506775f, -0.06321443f, 0.02503362f, 0.19897795f, -0.02839594f, 0.28001407f, 
    0.04399000f, 0.07159168f, -0.00207168f, -0.20972537f, 0.01518794f, -0.07242892f, -0.07564570f, -0.08340439f, 
    0.05780392f, -0.04738700f, 0.00586830f, 0.00670139f, 0.03533575f, -0.02811470f, -0.09883205f, -0.10990987f, 
    0.01645402f, -0.08156075f, 0.00165555f, -0.05044939f, 0.02530541f, -0.19671832f, -0.12311751f, 0.10725620f, 
    0.01590713f, -0.02316100f, 0.09358596f, 0.19197156f, 0.34863040f, 0.04921404f, 0.50623435f, -0.12578346f, 
    0.02203493f, -0.11662990f, 0.00331972f, -0.29806072f, 0.00336731f, -0.02380889f, 0.01605605f, 0.06450134f, 
    0.15821368f, 0.10502348f, 0.00753550f, -0.12436409f, -0.01466617f, -0.04454387f, 0.02981962f, -0.03407599f, 
    0.29367715f, 0.06294716f, -0.21313147f, 0.06814289f, 0.21418113f, -0.03689634f, 0.07058699f, -0.10082670f, 
    -0.11001893f, -0.10476293f, 0.02546780f, 0.00505940f, -0.03881821f, -0.01110019f, 0.00224051f, 0.01793019f, 
    -0.01493403f, 0.05221732f, -0.12094227f, 0.04681538f, -0.05588879f, 0.14743952f, 0.07033046f, 0.00192929f, 
    -0.08160928f, 0.03792357f, 0.06278519f, 0.12862501f, 0.16465998f, 0.08978616f, -0.01654864f, 0.07577114f, 
    0.05507055f, 0.05555610f, 0.10374543f, -0.00144883f, 0.06007662f, 0.07249841f, -0.03982568f, 0.03268486f, 
    0.10868560f, -0.48838374f, 0.67108560f, 0.01117060f, 0.04247579f, -0.00853344f, -0.21152925f, -0.44993135f, 
    0.21231474f, -0.03280173f, -0.07824620f, 0.02065669f, 0.05191245f, 0.03213014f, -0.05278041f, 0.03071399f, 
    0.14956594f, -0.11224491f, 0.05006191f, 0.04327792f, 0.13290316f, 0.28429732f, 0.34371355f, 0.14038202f, 
    0.15058021f, -0.10625394f, -0.28392079f, 0.04489513f, -0.07517913f, -0.19781283f, 0.12512350f, -0.10100969f, 
    0.09056643f, 0.00951871f, -0.04241993f, 0.14184614f, -0.07266341f, 0.13478364f, 0.04285651f, 0.00757433f, 
    -0.58465344f, 0.29100960f, 0.13167128f, -0.66256946f, -0.24963169f, -0.01254545f, 0.04306663f, -0.25756702f, 
    -0.11002366f, 0.21223289f, -0.03278995f, 0.09816901f, 0.03246760f, 0.00788326f, -0.00597252f, -0.10254999f, 
    0.00480366f, -0.08495317f, -0.09824851f, 0.08468933f, 0.17199871f, 0.23895307f, 0.05095593f, -0.13918960f, 
    0.06553490f, -0.16668071f, -0.04537942f, 0.03966748f, -0.05965528f, 0.00967097f, -0.06690621f, -0.09652795f, 
    -0.00804989f, 0.01686508f, 0.09811956f, 0.21327476f, -0.00952706f, -0.00267452f, 0.15252377f, -0.00965510f, 
    0.09933572f, -0.11250210f, 0.03482526f, -0.15825316f, -0.12820429f, 0.07372244f, 0.06710231f, 0.04777319f, 
    -0.05537459f, 0.10840645f, 0.42704192f, 0.01115994f, 0.02383070f, -0.04074486f, -0.08246871f, 0.05510908f, 
    0.11265680f, -0.07771008f, 0.05532973f, 0.01086268f, -0.30644268f, -0.43317157f, -0.36881319f, -0.21535410f, 
    -0.20972964f, -0.05238983f, -0.00340893f, -0.04656255f, -0.10690250f, -0.07636427f, 0.01720056f, -0.10283439f, 
    -0.07580710f, 0.00382490f, -0.14098915f, -0.02770824f, -0.01494482f, 0.03417671f, 0.01971165f, 0.03515105f, 
    -0.20164882f, -0.04364840f, 0.13930233f, -0.02099078f, -0.07131553f, -0.05513287f, 0.01083657f, -0.11037644f, 
    0.08309668f, -0.01151783f, 0.06125254f, -0.06208597f, -0.37235615f, -0.04757188f, 0.02021218f, -0.10812869f, 
    -0.01944340f, -0.05285915f, 0.11766412f, 0.05110984f, -0.45902765f, -0.20827448f, -1.05311596f, -0.53034997f, 
    -0.03542910f, 0.11180361f, 0.02428643f, -0.08954174f, 0.03832035f, 0.10677087f, 0.03751291f, 0.01206407f, 
    0.05064679f, -0.11376259f, -0.04355320f, 0.08401845f, 0.16233623f, -0.15587041f, -0.04769027f, 0.16887140f, 
    0.23178916f, 0.12466086f, 0.09741824f, 0.05934613f, 0.13871358f, 0.04280807f, -0.02195151f, 0.03985509f, 
    0.00378684f, -0.07350221f, 0.05673879f, 0.04045962f, -0.10053296f, 0.03752764f, 0.11531816f, 0.02340706f, 
    0.14563228f, -0.13934809f, 0.13372479f, -0.02471274f, 0.25342098f, 0.12745990f, 0.27859861f, 0.13142271f, 
    0.11206600f, -0.07673071f, -0.10581717f, -0.08737326f, -0.01712329f, 0.03230787f, -0.07557803f, 0.07356548f, 
    -0.02567855f, -0.06683927f, -0.01781004f, 0.00350995f, 0.02522913f, -0.03712214f, -0.05360024f, -0.03449748f, 
    0.44690546f, 0.23944345f, -0.09543687f, 0.02352762f, 0.04216736f, 0.11301813f, -0.01289113f, -0.18673560f, 
    0.17885865f, 0.02906173f, 0.28286499f, 0.31856593f, -0.08656942f, 0.10144203f, -0.01673862f, 0.08023515f, 
    0.04835369f, 0.06129416f, -0.06757508f, 0.10870380f, -0.12725265f, 0.03668119f, 0.11048987f, 0.04428174f, 
    0.05684056f, 0.03758186f, -0.02755208f, -0.01638663f, 0.03777359f, -0.01816125f, -0.02733523f, -0.11578705f, 
    -0.00039725f, -0.00484501f, -0.10352059f, 0.10582126f, -0.04917522f, -0.13194758f, 0.02184782f, -0.14704221f, 
    -0.31207037f, -0.46677786f, -1.14272559f, -0.24680033f, 0.17006610f, 0.15472239f, 0.06793477f, -0.26703247f, 
    -0.16439974f, 0.06147798f, -0.04208591f, 0.10958977f, 0.16029134f, 0.03539924f, 0.07943959f, -0.03245563f, 
    0.02987169f, 0.01731716f, 0.03372969f, -0.01515615f, -0.01199158f, 0.10370337f, 0.20004281f, 0.08299869f, 
    0.11633102f, -0.15563646f, 0.05035653f, -0.00213382f, -0.08538053f, 0.08625166f, -0.02567222f, -0.14910866f, 
    -0.06684545f, 0.00483619f, -0.05336201f, 0.07988163f, 0.04163202f, -0.04956663f, -0.03671785f, -0.01540702f, 
    -0.63388735f, 0.00335487f, -0.22335443f, -0.44557121f, -0.38702077f, 0.26711249f, 0.18245344f, 0.02770284f, 
    0.14998601f, 0.11823792f, 0.01114814f, 0.02693368f, -0.10933797f, 0.01360342f, -0.03735447f, -0.02398099f, 
    -0.01788145f, 0.07486641f, -0.05520749f, 0.13733113f, 0.11498872f, 0.06126457f, 0.05115780f, 0.11899386f, 
    0.21142064f, -0.02483783f, 0.02947423f, -0.02672374f, -0.00818742f, -0.01540323f, 0.07790800f, 0.08088412f, 
    -0.04274455f, -0.01063487f, 0.07850835f, -0.04641873f, -0.07617413f, -0.07224665f, -0.06682754f, -0.00855266f, 
    0.55100918f, 0.50493068f, 0.22717625f, 0.06061242f, 0.16907047f, -0.18408147f, -0.14954065f, -0.04985286f, 
    -0.02095827f, -0.02058815f, -0.08858396f, -0.05844666f, -0.03720196f, 0.02770749f, -0.02457360f, 0.08407956f, 
    0.29601696f, -0.12167883f, 0.12669232f, 0.05584981f, 0.00646098f, 0.40965745f, -0.36217335f, -0.40486592f, 
    -0.07505937f, 0.05908985f, 0.07815333f, -0.16040012f, 0.01148205f, -0.06499078f, -0.11320851f, 0.07766623f, 
    -0.08735522f, -0.08872829f, 0.00092849f, 0.09615382f, -0.04914637f, 0.02636745f, -0.14035541f, 0.00293572f, 
    0.12707356f, -0.18808672f, 0.05730408f, 0.39697215f, -0.16806120f, -0.02922244f, -0.03494665f, -0.02195549f, 
    -0.04965660f, -0.05398607f, 0.13152149f, 0.21739146f, 0.04493604f, 0.05994406f, 0.08789200f, -0.02508082f, 
    0.03258191f, -0.09442635f, 0.20917404f, 0.23028816f, -0.13806099f, -0.06794953f, -0.01632063f, 0.12242445f, 
    -0.26924422f, 0.28283960f, -0.06690182f, -0.09500030f, 0.11285870f, 0.03798035f, -0.08287188f, 0.03831927f, 
    0.09440677f, -0.02989910f, 0.05140663f, 0.09281097f, -0.07606826f, -0.11132739f, 0.01938005f, -0.05895415f, 
    0.02200076f, -0.02849983f, 0.04183678f, -0.18052086f, 0.03782619f, -0.02709010f, 0.06720403f, 0.07000566f, 
    -0.04518530f, 0.00464900f, 0.02239936f, -0.04828785f, -0.07641851f, 0.12116502f, 0.14499342f, 0.07665132f, 
    0.06101048f, -0.02185677f, -0.01598790f, 0.22113706f, 0.03235379f, -0.24461111f, 0.03832803f, 0.03314661f, 
    -0.02087739f, -0.18226428f, -0.01541921f, 0.06376011f, 0.05644728f, 0.09643468f, 0.14708129f, 0.10235611f, 
    -0.15186352f, 0.03852389f, -0.07312843f, 0.06873740f, -0.04459361f, 0.03040055f, 0.05277332f, 0.09873202f, 
    0.27728477f, -0.21195529f, -0.08706253f, 0.22319554f, -0.02741387f, 0.04342192f, -0.08047429f, -0.00221792f, 
    0.09292901f, 0.13979334f, 0.03160791f, -0.02508227f, 0.19829735f, 0.00430482f, 0.04344146f, -0.16530329f, 
    0.00026751f, 0.04050252f, 0.12208405f, -0.09309254f, -0.24628924f, -0.10304454f, 0.18217359f, 0.03239613f, 
    -0.11050217f, -0.02099403f, -0.08344349f, 0.03570474f, -0.02753829f, -0.12836088f, 0.00390171f, -0.06597587f, 
    -0.00696575f, 0.00306165f, -0.06603938f, 0.06544391f, -0.06904938f, -0.24052690f, -0.10681659f, -0.12910742f, 
    -0.02448194f, 0.03151961f, 0.10067883f, -0.03521241f, 0.08879960f, 0.17159171f, 0.00304856f, 0.00122418f, 
    0.02123897f, -0.14518566f, 0.10535926f, 0.00079749f, -0.00505487f, 0.01868599f, 0.00942873f, 0.00818246f, 
    -0.12506527f, 0.10024483f, 0.07724768f, -0.03980731f, -0.03109857f, -0.05612414f, 0.01341978f, 0.06873731f, 
    0.18728612f, -0.20730206f, -0.04356124f, -0.04613655f, -0.25289392f, -0.00865757f, -0.06492233f, 0.11446074f, 
    0.00621842f, 0.22601643f, 0.09665744f, -0.00426781f, -0.05503188f, 0.19907470f, 0.08499859f, 0.15073423f, 
    0.51839375f, 0.02783217f, -0.05047562f, -0.36912507f, 0.00736843f, 0.06045647f, 0.06954724f, -0.06666681f, 
    -0.08761772f, 0.04632870f, 0.14833081f, -0.21168157f, -0.02953094f, 0.03516712f, 0.02328656f, -0.13067272f, 
    -0.03911268f, -0.11909966f, 0.18020415f, 0.04789758f, 0.13634671f, -0.02336500f, -0.22163804f, 0.19275452f, 
    0.03844395f, -0.14351240f, 0.01654980f, 0.05410293f, 0.24747078f, -0.16256632f, -0.07995515f, -0.12867504f, 
    0.07902323f, 0.06635672f, 0.05455066f, 0.05654329f, 0.01664385f, -0.06559682f, 0.10801148f, 0.23384890f, 
    -0.15237191f, 0.09510793f, 0.20409988f, -0.01777435f, -0.19241667f, 0.17487128f, -0.14438041f, 0.08743298f, 
    -0.01076373f, -0.13641788f, 0.13194320f, 0.07955588f, 0.05414965f, 0.09914039f, -0.02986732f, 0.03682490f, 
    0.02235969f, -0.09488099f, -0.10926546f, -0.01131739f, -0.17610140f, -0.09076133f, -0.38373649f, 0.20339949f, 
    0.06306063f, 0.02033737f, -0.12972979f, -0.04922664f, 0.03565355f, -0.05024797f, -0.12216638f, -0.08895410f, 
    -0.05717755f, 0.02166664f, -0.05322437f, 0.03898680f, -0.07466710f, 0.12298936f, -0.04055876f, 0.17877457f, 
    -0.03343156f, -0.05889394f, 0.15847470f, 0.20289704f, -0.07394604f, -0.11289694f, 0.07150038f, 0.09138917f, 
    0.00275869f, -0.06527556f, -0.06697350f, -0.04793565f, -0.04191442f, -0.03748364f, 0.09263129f, 0.00740707f, 
    0.08709886f, 0.05599080f, 0.08885827f, -0.03880069f, -0.03200850f, 0.09061936f, 0.01703471f, 0.04735762f, 
    0.03959228f, 0.01676488f, -0.09632685f, -0.19996643f, -0.07840221f, -0.07114401f, 0.09516682f, -0.25782818f, 
    -0.10805658f, 0.06295114f, 0.06471820f, -0.08954111f, 0.04629127f, 0.06464920f, 0.18942706f, 0.04038751f, 
    0.07425158f, -0.00225464f, -0.20922065f, -0.07275582f, -0.25340986f, 0.21488334f, 0.26431090f, 0.06512088f, 
    -0.18652764f, -0.21100372f, 0.02198529f, -0.00829170f, 0.03964845f, -0.06106734f, 0.00029906f, 0.02219313f, 
    -0.02264907f, -0.00559181f, -0.04572891f, -0.04154981f, 0.33242574f, 0.02468302f, -0.08940432f, 0.19918609f, 
    -0.15915062f, 0.10918495f, -0.00396657f, -0.04222639f, 0.10907976f, 0.04589026f, 0.00175414f, -0.04951518f, 
    0.01156933f, -0.02655639f, -0.00898743f, -0.06409843f, 0.01553205f, -0.00246349f, 0.06942479f, -0.05273338f, 
    -0.01342551f, 0.15389475f, 0.28669560f, 0.05246195f, -0.10350019f, -0.05459549f, 0.05458979f, -0.00541517f, 
    0.08926596f, 0.00789014f, 0.06179221f, 0.05729156f, 0.04546570f, 0.04961298f, -0.02328250f, -0.01247303f, 
    0.05304352f, -0.09555954f, -0.04236998f, 0.15087190f, -0.27678928f, 0.02892182f, 0.12510003f, 0.07914076f, 
    -0.19564331f, 0.11253045f, -0.00649134f, -0.01052305f, 0.12387171f, 0.05410026f, 0.05787811f, -0.01470412f, 
    -0.07365684f, -0.00571977f, 0.02500514f, 0.04518333f, -0.05316335f, 0.04493128f, -0.09572449f, 0.03104744f, 
    -0.02631039f, -0.12706934f, -0.01360699f, -0.14531323f, -0.21019050f, 0.01482831f, -0.02098691f, 0.03690793f, 
    0.00033663f, -0.02296900f, 0.00063517f, -0.09020094f, -0.00966356f, 0.02375859f, -0.07755928f, -0.01287899f, 
    -0.00225047f, -0.14891693f, -0.03888325f, 0.08526746f, 0.36198437f, -0.06113615f, -0.07980699f, -0.11813457f, 
    -0.23251621f, -0.01051721f, -0.02597880f, -0.05815815f, 0.03980968f, -0.03395281f, 0.15666790f, 0.09789288f, 
    -0.03643808f, -0.11619123f, -0.02003664f, -0.05351686f, -0.09911781f, 0.06072808f, -0.01769910f, -0.06005960f, 
    0.11979096f, 0.02225888f, 0.20802192f, -0.04484176f, -0.15975259f, -0.17229345f, -0.06058607f, -0.07268783f, 
    -0.03069951f, 0.00669593f, -0.04928615f, 0.09406636f, -0.04377510f, -0.03456707f, -0.06090266f, -0.04463826f, 
    -0.00012045f, 0.00633269f, -0.10820869f, 0.03633149f, -0.07608274f, 0.20382509f, 0.32273176f, -0.02586496f, 
    0.04611957f, -0.00750191f, 0.16622528f, 0.02742944f, -0.01757315f, -0.00515829f, 0.05215077f, 0.03333888f, 
    0.02062201f, -0.02729852f, 0.10962297f, 0.04281187f, -0.00554485f, -0.13272168f, -0.07043169f, -0.01259780f, 
    -0.11328046f, -0.10868421f, 0.07398504f, -0.11645018f, -0.04864077f, 0.06129475f, -0.11663792f, 0.00825044f, 
    0.02885730f, -0.12588985f, -0.09387809f, -0.04999567f, -0.07091754f, -0.00647363f, -0.17634948f, -0.00131840f, 
    -0.06093264f, 0.00867846f, -0.05683654f, -0.08127348f, 0.21928582f, -0.03265934f, -0.07317352f, 0.10853307f, 
    -0.16772076f, -0.08023907f, -0.06731444f, -0.09931549f, -0.08758315f, -0.10465346f, -0.00108317f, 0.03123414f, 
    0.01341669f, 0.01148237f, -0.00679129f, -0.03230796f, 0.04680623f, 0.05779815f, 0.13331717f, -0.00897650f, 
    0.12860629f, -0.05646147f, 0.02162418f, -0.04993112f, 0.10124521f, -0.02678956f, 0.02586253f, -0.15661146f, 
    0.08766044f, -0.02825147f, 0.02295064f, 0.01826184f, -0.07473431f, -0.16931129f, -0.05451889f, 0.02652691f, 
    -0.13957520f, -0.19334061f, 0.11050374f, 0.01276844f, 0.01192491f, 0.05372945f, -0.16492988f, 0.10677122f, 
    -0.12407687f, 0.00923624f, -0.16192764f, -0.00889891f, 0.01634906f, -0.13713801f, 0.08137067f, -0.02120865f, 
    0.07647772f, -0.04595683f, 0.00166587f, -0.02229104f, -0.01849632f, -0.04772539f, 0.04742467f, 0.03743014f, 
    -0.01664247f, 0.23132874f, 0.20534842f, 0.02302645f, -0.07797315f, 0.11387750f, 0.10008451f, 0.17785397f, 
    0.00361847f, 0.02896614f, -0.04167260f, -0.03080046f, -0.04973871f, 0.01089901f, -0.02009242f, -0.00777853f, 
    -0.00521436f, -0.10056724f, -0.07838520f, -0.03488935f, -0.36566237f, -0.09722151f, -0.06274946f, 0.16714093f, 
    -0.14227876f, 0.05404655f, 0.02402830f, 0.02306718f, -0.10273160f, 0.00496461f, -0.00502996f, 0.01892803f, 
    -0.06755979f, 0.08569396f, 0.04572831f, 0.08512304f, -0.01742910f, 0.05166312f, -0.11186650f, 0.10013998f, 
    0.15447141f, 0.22714789f, 0.12477461f, 0.03226137f, -0.02168689f, 0.04832106f, -0.01204948f, 0.02464055f, 
    0.02708235f, 0.10083062f, -0.01689184f, -0.01110489f, 0.01967052f, 0.06817503f, 0.04150560f, -0.01201452f, 
    -0.00792234f, -0.22180596f, -0.01598394f, 0.17045662f, -0.09383144f, -0.08101651f, -0.01974400f, 0.02259386f, 
    0.03881861f, -0.02759900f, -0.03221941f, -0.10938920f, -0.08308129f, -0.05628493f, -0.04589416f, -0.08937971f, 
    -0.03849592f, 0.04915689f, 0.12395369f, 0.03924349f, 0.07546198f, 0.06344984f, 0.02942663f, -0.04784033f, 
    -0.16862585f, 0.27156803f, -0.17844865f, 0.09148549f, -0.23507237f, 0.11404631f, 0.02096517f, 0.14798072f, 
    -0.13948730f, -0.01662089f, -0.05380151f, 0.04341879f, -0.05518639f, 0.00443338f, -0.05624629f, 0.03918716f, 
    -0.04203325f, 0.02514878f, 0.07475816f, 0.03670537f, -0.04148109f, 0.07920502f, 0.14888939f, -0.12887326f, 
    -0.02286789f, 0.12681772f, 0.03609643f, 0.13383430f, 0.14262189f, 0.09913795f, -0.01435144f, 0.05487765f, 
    -0.07150930f, 0.03242663f, -0.10202451f, -0.02966841f, -0.02148763f, 0.00701714f, 0.06465528f, 0.08801193f, 
    0.26931551f, -0.32857838f, -0.25886354f, 0.19324858f, 0.02420604f, 0.14669445f, 0.01538947f, -0.01012647f, 
    0.05845867f, 0.05447910f, 0.04396334f, 0.00607346f, -0.00373668f, -0.00737662f, 0.04548807f, -0.02587906f, 
    0.06392673f, -0.01960653f, 0.03881462f, 0.07628783f, 0.34329945f, 0.10012142f, 0.15422355f, 0.04528108f, 
    0.01156527f, 0.13754119f, 0.14282717f, 0.04832767f, 0.00210397f, 0.17829499f, 0.01215778f, -0.00565514f, 
    0.00931389f, 0.04270284f, -0.04328077f, 0.06652555f, 0.06727929f, -0.00945557f, 0.05600460f, 0.10155047f, 
    -0.19532670f, -0.17426650f, 0.06881237f, 0.00232754f, 0.23057151f, 0.04818341f, -0.02471092f, -0.01432387f, 
    0.10610311f, 0.08118870f, 0.07463742f, 0.09881366f, 0.07169029f, -0.07648766f, -0.04519664f, -0.01553402f, 
    0.06058470f, 0.10338519f, 0.04503198f, -0.07606836f, -0.06527470f, -0.08139069f, -0.13520074f, 0.04131555f, 
    0.14225052f, -0.02681358f, 0.00892349f, -0.01643899f, 0.03554060f, 0.06729771f, -0.00311598f, -0.00121246f, 
    0.00044333f, 0.07117267f, 0.05695766f, -0.11281955f, -0.00462882f, 0.08559832f, 0.02405904f, 0.01892670f, 
    0.48510531f, 0.07277625f, -0.33065882f, -0.09511506f, -0.05888935f, 0.13560292f, -0.02960476f, -0.15681823f, 
    -0.15628321f, -0.10224764f, -0.07623370f, -0.14794883f, 0.00011518f, 0.00625255f, -0.04743526f, -0.01269622f, 
    0.01832282f, -0.06550304f, 0.15561737f, -0.03584495f, -0.07496446f, -0.22461559f, -0.18389452f, 0.00813969f, 
    0.03359570f, 0.01202757f, -0.12828054f, 0.00539528f, 0.11469430f, 0.07865862f, -0.04806937f, 0.01715805f, 
    0.00787900f, 0.02642014f, 0.02795172f, 0.06836032f, 0.05995786f, 0.17491122f, 0.04089610f, 0.06010983f, 
    -0.12075080f, 0.14009051f, 0.12288342f, 0.04165733f, 0.10848185f, -0.09114197f, -0.00335287f, -0.00311281f, 
    -0.00950831f, 0.01414908f, -0.06112336f, -0.06464857f, -0.02956614f, -0.02682569f, 0.11221839f, 0.11740085f, 
    0.02864601f, 0.00149285f, 0.09178821f, 0.09253104f, -0.38186684f, -0.00248802f, 0.01192612f, 0.07787225f, 
    -0.13996989f, -0.11028267f, -0.12150778f, -0.07862488f, -0.11203922f, -0.01546151f, 0.05830996f, -0.01857146f, 
    -0.07869381f, 0.13507257f, 0.12575327f, 0.03338277f, -0.10569040f, 0.03096889f, -0.09049971f, 0.00249565f, 
    -0.19093044f, 0.00398374f, 0.25494152f, 0.00677837f, 0.00347886f, 0.04721445f, -0.04112521f, 0.00851284f, 
    -0.05142752f, 0.04772645f, 0.01057249f, 0.14121039f, 0.12531877f, 0.09925405f, 0.04033908f, 0.01773341f, 
    0.09641958f, 0.07913648f, 0.00665154f, -0.08095013f, 0.12275551f, 0.14079811f, 0.04063991f, -0.18199441f, 
    -0.13390011f, -0.12997741f, -0.09957531f, -0.07094922f, -0.02393699f, 0.04093783f, -0.01537763f, 0.00746042f, 
    0.06387447f, -0.05712492f, 0.01454660f, 0.00372861f, 0.08916929f, -0.06367098f, 0.11186457f, 0.06195594f, 
    0.02285050f, -0.33052787f, -0.03269443f, -0.12892477f, 0.09995618f, 0.01641590f, -0.00260641f, -0.00297054f, 
    0.00917574f, 0.06760575f, 0.10682169f, 0.00574498f, 0.06581887f, -0.06225453f, -0.01487715f, 0.01571662f, 
    0.03981280f, 0.01507230f, 0.18154836f, -0.01596027f, 0.00875240f, 0.13939558f, 0.02262790f, -0.05946275f, 
    -0.16947657f, 0.10503028f, 0.07037357f, -0.18255889f, -0.06617539f, -0.18051998f, -0.05492499f, -0.04441116f, 
    -0.06487939f, 0.02252808f, -0.07928718f, -0.07931886f, 0.03207935f, 0.06070933f, 0.12154225f, 0.03056731f, 
    0.09042464f, -0.29667228f, -0.24474387f, 0.05447846f, 0.00578377f, 0.02522299f, 0.05861847f, -0.01146594f, 
    0.05530448f, 0.10399937f, -0.02160136f, -0.02010567f, -0.00066792f, -0.06889877f, 0.06002349f, 0.05238649f, 
    0.00982208f, 0.05876991f, -0.00423703f, 0.06400909f, -0.20571320f, 0.00805177f, 0.08431493f, -0.12703979f, 
    -0.16472639f, -0.13010718f, -0.22409144f, -0.14230746f, -0.02646499f, -0.14816663f, -0.00527509f, -0.06955115f, 
    -0.17907481f, -0.04568188f, -0.02815627f, -0.08331987f, 0.03758230f, -0.02595885f, -0.06723732f, -0.02674546f, 
    0.11386975f, -0.03673832f, 0.49502826f, 0.13199756f, 0.47694716f, 0.12170173f, 0.08962610f, 0.03660845f, 
    0.17245963f, -0.00309209f, -0.00359414f, -0.08316052f, 0.00777221f, -0.06413871f, 0.05089663f, 0.13407674f, 
    0.11849582f, 0.01554857f, 0.03737570f, -0.00045633f, 0.30613294f, -0.00147476f, 0.13606657f, 0.39447674f, 
    -0.08773916f, 0.00808997f, 0.04741573f, -0.03377991f, -0.01195953f, 0.00482046f, 0.05609724f, -0.07858411f, 
    0.02355546f, 0.05652308f, -0.03829877f, -0.00145485f, 0.10174480f, 0.13971423f, -0.05739836f, -0.06057088f, 
    -0.03356894f, 0.33979955f, 0.06768306f, 0.05126546f, 0.13478570f, -0.14458889f, -0.03612438f, 0.12007689f, 
    0.05342718f, 0.00916673f, -0.01377511f, 0.07641533f, 0.13063712f, 0.07213371f, -0.03346241f, 0.06896033f, 
    -0.03931430f, 0.10737253f, -0.01999917f, -0.12553890f, -0.06183868f, 0.03061999f, -0.22245832f, 0.13150233f, 
    -0.05236707f, 0.15352488f, -0.03047649f, 0.05675265f, 0.00677063f, 0.04444664f, 0.07882410f, -0.08502877f, 
    0.01472896f, 0.09313802f, -0.12292827f, 0.01282667f, 0.18624018f, 0.04689017f, 0.12254006f, 0.09558390f, 
    0.16668554f, 0.00292839f, 0.08850167f, -0.06341407f, -0.29718068f, -0.13088694f, -0.07850147f, -0.09764761f, 
    -0.06435000f, -0.02547794f, -0.04328480f, 0.06212374f, 0.02870043f, 0.07201683f, 0.19049750f, -0.16325438f, 
    -0.07357720f, -0.19745684f, -0.04106351f, -0.08007096f, 0.35371009f, -0.06311484f, 0.13351288f, 0.21752708f, 
    -0.08327462f, -0.01158099f, 0.00009199f, 0.06247531f, 0.13786736f, -0.03037116f, 0.10137542f, -0.09285304f, 
    0.08049754f, -0.11500071f, 0.03292915f, 0.21756117f, 0.04555644f, -0.04656349f, 0.04027634f, -0.05524793f, 
    -0.29409343f, 0.01797395f, 0.11586411f, 0.01100579f, -0.04897719f, -0.11990644f, 0.01539198f, 0.09125871f, 
    0.10824125f, -0.03459224f, 0.05635640f, 0.14138439f, 0.04431760f, 0.09562805f, -0.13562581f, -0.01325490f, 
    -0.18555696f, -0.15216608f, -0.08240980f, -0.05089503f, 0.20434961f, 0.15657900f, 0.11839452f, 0.04900443f, 
    -0.14578287f, -0.06664182f, 0.03221587f, 0.07089516f, 0.14271219f, -0.02227241f, 0.03798855f, -0.08732847f, 
    -0.02906338f, 0.09642931f, 0.06785627f, 0.12697817f, 0.10951276f, -0.03469916f, 0.02361975f, 0.07487164f, 
    0.04782904f, -0.42530152f, -0.19961762f, -0.09829358f, -0.19445388f, -0.08661175f, 0.22675350f, -0.02993136f, 
    0.06106642f, 0.14302689f, -0.01376968f, 0.06481999f, -0.03998373f, -0.00339038f, -0.03327066f, -0.10365883f, 
    0.13634159f, -0.11992216f, -0.15665607f, 0.05013549f, 0.47429433f, -0.14447224f, -0.27352342f, -0.01719643f, 
    -0.09952995f, -0.01305175f, 0.01711580f, -0.00891365f, -0.04954734f, -0.28720421f, 0.00106482f, 0.05426367f, 
    0.11551297f, 0.00126683f, -0.09112045f, -0.01759413f, 0.25424990f, -0.11524491f, -0.23202246f, -0.11571515f, 
    0.43982065f, -0.41603059f, -0.05371889f, -0.15234827f, -0.16232735f, -0.19238995f, -0.09524524f, 0.08860790f, 
    -0.01038365f, 0.04366614f, -0.11125127f, 0.04933032f, -0.11705191f, 0.08353955f, -0.01502657f, -0.09940465f, 
    0.03556654f, 0.03533405f, -0.11053511f, 0.01918164f, 0.03556035f, -0.11988872f, -0.23227027f, 0.18410632f, 
    -0.01948616f, -0.00388064f, -0.04249753f, -0.23291530f, -0.04282735f, -0.12020179f, 0.06276194f, 0.09321950f, 
    -0.09245951f, 0.04077257f, 0.00631869f, 0.02691721f, -0.02625955f, -0.18007207f, -0.11867027f, -0.22257946f, 
    -0.02410320f, 0.26224896f, 0.06798032f, 0.14023800f, -0.09185103f, 0.00304399f, 0.01470996f, -0.06021618f, 
    0.02854631f, 0.08045084f, -0.05382248f, 0.02305131f, 0.02277347f, 0.15084806f, 0.12835017f, -0.06147796f, 
    0.10631069f, 0.09516908f, -0.05744205f, 0.07301680f, 0.02738259f, 0.01846855f, -0.03401329f, -0.09215163f, 
    -0.13952589f, 0.06556718f, 0.04214298f, -0.12129562f, 0.01653513f, -0.03151244f, 0.04126400f, -0.05227687f, 
    0.02234027f, -0.07394882f, 0.03579201f, -0.01115880f, -0.08284210f, -0.23191550f, 0.11289296f, 0.05873853f, 
    0.09891204f, 0.29124066f, 0.19071448f, 0.12264975f, 0.02154937f, -0.11056194f, -0.12723431f, -0.03956131f, 
    0.08537831f, 0.07417270f, 0.00517727f, 0.05020881f, 0.10853692f, 0.07839280f, -0.00154572f, 0.17696621f, 
    0.04528641f, -0.05889593f, 0.11111265f, -0.14670183f, -0.15107962f, -0.22555156f, -0.29237431f, -0.30042106f, 
    -0.04754445f, -0.21853685f, 0.18544580f, -0.01603455f, -0.08033088f, -0.01523253f, -0.15215965f, 0.06103580f, 
    0.10513728f, 0.03350374f, 0.02914148f, -0.05248518f, 0.06296848f, -0.13187844f, -0.05844447f, -0.05217370f, 
    -0.52022570f, -0.04189669f, -0.29565701f, -0.06110153f, -0.41141540f, 0.15834896f, 0.03548880f, -0.17088038f, 
    0.07833097f, 0.13884895f, -0.07322183f, -0.12308352f, 0.01118014f, -0.01388299f, 0.01515018f, 0.04754499f, 
    0.14036424f, 0.02089855f, 0.01466026f, 0.16521050f, -0.23371914f, 0.11714198f, 0.00870998f, -0.20455828f, 
    0.23637699f, -0.06464881f, -0.10131581f, -0.10264882f, 0.02313309f, -0.00702997f, 0.04358854f, 0.05485817f, 
    0.05606613f, -0.04614844f, -0.10724742f, 0.17459874f, 0.08802862f, -0.18498531f, 0.00009650f, 0.12181533f, 
    -0.08578358f, 0.26988983f, -0.20248657f, -0.17817344f, 0.21621044f, -0.08753875f, 0.04303008f, 0.10842390f, 
    -0.00249022f, 0.05239056f, -0.04650480f, -0.05380007f, -0.06487617f, -0.05021596f, -0.01293546f, -0.01943205f, 
    -0.03221688f, 0.05318137f, 0.01432054f, -0.09756864f, 0.01379021f, -0.00525499f, 0.03686069f, -0.22478004f, 
    0.37886572f, -0.10844571f, 0.05317658f, -0.10165292f, 0.05532606f, -0.14090668f, 0.01602707f, -0.01757082f, 
    -0.05364285f, 0.02277482f, 0.04762441f, -0.24103795f, 0.02742719f, 0.14883135f, 0.11482593f, -0.08498123f, 
    0.08828279f, 0.15714301f, -0.36130461f, 0.09802481f, -0.13845564f, -0.00731583f, 0.02504667f, 0.04283325f, 
    0.00266018f, -0.07619779f, 0.01359352f, 0.07765038f, -0.03809772f, 0.02064384f, -0.03941650f, 0.07391615f, 
    -0.12599635f, -0.00791664f, 0.03644697f, -0.03944786f, 0.10246879f, 0.38771468f, 0.25713134f, 0.00908340f, 
    0.35500652f, 0.19684367f, 0.11588013f, 0.18617105f, 0.05514596f, -0.05750536f, -0.04814607f, 0.01637463f, 
    0.10246762f, -0.04233954f, 0.09493154f, 0.03776312f, -0.01123865f, -0.09742168f, 0.00276799f, -0.05135720f, 
    -0.09228531f, -0.02357553f, -0.02610026f, -0.14292310f, -0.01047351f, -0.00377177f, 0.01161061f, 0.22225918f, 
    0.16395634f, 0.01297652f, -0.00178429f, 0.12952597f, -0.11984037f, 0.01721988f, -0.08495709f, -0.10561559f, 
    0.03154790f, -0.01636689f, 0.09158864f, 0.01676214f, 0.19790389f, 0.31786463f, -0.00643550f, -0.07040436f, 
    0.15400822f, 0.16656771f, 0.09431823f, 0.02158475f, 0.21863440f, -0.00964064f, -0.03299722f, 0.07705314f, 
    0.03282159f, -0.04550535f, -0.03188901f, -0.05165727f, 0.00399189f, 0.17376660f, 0.03104609f, -0.00032571f, 
    0.07314848f, -0.20209345f, 0.01361693f, 0.04926610f, -0.23307480f, -0.11437576f, 0.03760824f, -0.11606705f, 
    -0.01446656f, 0.00363898f, 0.01986747f, -0.03905624f, 0.09942506f, 0.02744578f, -0.03905765f, -0.07827535f, 
    0.03651736f, -0.17752714f, 0.00069433f, 0.10010400f, 0.32974991f, 0.05147089f, -0.05874737f, -0.01824941f, 
    0.00055967f, 0.09359901f, 0.08286673f, 0.01146285f, 0.03934086f, -0.02546616f, 0.06915861f, -0.04248139f, 
    0.05306126f, -0.00967919f, -0.10091837f, 0.06607002f, -0.02336768f, -0.20281988f, -0.08692329f, -0.02639692f, 
    -0.02531854f, 0.42067558f, -0.12398208f, -0.01794101f, -0.07318018f, -0.09615723f, -0.06748898f, 0.12123337f, 
    -0.10952747f, -0.04725447f, -0.13128276f, 0.01234278f, 0.09216888f, 0.23736614f, 0.03762412f, 0.02029564f, 
    0.08170263f, 0.09904842f, -0.08194876f, 0.12343951f, 0.04542742f, -0.21563581f, 0.00519649f, -0.20916967f, 
    0.13772117f, 0.14896891f, 0.08128014f, -0.03278161f, -0.14039212f, 0.03802344f, 0.01913982f, 0.15180555f, 
    -0.04614892f, 0.16210383f, -0.09937762f, -0.13715342f, 0.04080408f, -0.01655312f, -0.03096747f, -0.11112811f, 
    0.09684981f, 0.15376292f, -0.07097941f, 0.14891006f, 0.07823741f, 0.05566381f, 0.08756988f, -0.18899679f, 
    -0.04799198f, 0.01438869f, -0.01000083f, -0.01736587f, -0.06326911f, -0.03100608f, 0.03147052f, -0.06775966f, 
    -0.12732168f, 0.18541443f, -0.09017769f, 0.11371631f, 0.23376101f, -0.21266352f, 0.09443841f, -0.16328244f, 
    0.01465535f, -0.02939260f, 0.01228236f, -0.00411925f, -0.06133107f, 0.02722039f, 0.04961261f, 0.05941591f, 
    0.02767959f, -0.00350361f, 0.05421987f, -0.06077381f, -0.08994658f, -0.16270167f, 0.14871746f, -0.07612275f, 
    -0.09368429f, 0.18609878f, -0.07878824f, -0.08005690f, 0.11671060f, 0.00464528f, 0.10250134f, 0.04496974f, 
    0.13316737f, 0.02059781f, 0.04157120f, -0.02014344f, 0.02676271f, -0.05975588f, -0.03474688f, 0.04053314f, 
    -0.09768277f, 0.06848922f, -0.02909951f, 0.05329712f, 0.08122241f, -0.12725843f, -0.09354198f, -0.03100837f, 
    -0.01962905f, -0.08044460f, 0.02900936f, -0.09191665f, -0.06238779f, 0.02397247f, -0.19109897f, 0.06772184f, 
    0.03814837f, -0.02371207f, -0.03968930f, -0.01441160f, -0.10896846f, -0.10067705f, -0.04295254f, -0.08163770f, 
    -0.48695067f, -0.36066383f, 0.20345159f, -0.00602659f, -0.09730423f, -0.03417197f, 0.00119502f, -0.16966915f, 
    -0.09752587f, -0.02590727f, 0.03916935f, -0.00780046f, -0.03359712f, 0.11676216f, 0.05142063f, -0.09580348f, 
    -0.17504059f, 0.05732356f, 0.05944425f, 0.04219381f, -0.45004690f, 0.03569803f, -0.10151943f, -0.39005011f, 
    0.38419589f, -0.11494959f, 0.08707750f, -0.26103202f, 0.04528843f, -0.01349293f, -0.05743920f, 0.08847179f, 
    -0.00036214f, 0.03518876f, 0.05852275f, -0.00614749f, -0.00443241f, 0.01469032f, 0.03481935f, -0.17736398f, 
    -0.13794117f, 0.35030645f, 0.00201788f, 0.09208063f, -0.13050495f, -0.03873058f, 0.09332479f, -0.03687787f, 
    0.10095001f, 0.10930248f, 0.02339075f, 0.00024996f, 0.05847425f, 0.03871297f, -0.02742777f, 0.07391729f, 
    0.11107882f, 0.04130234f, -0.07430930f, 0.15838563f, -0.20062783f, 0.01411169f, -0.15859829f, -0.17162178f, 
    0.03153697f, 0.13072799f, 0.05958346f, -0.06045429f, 0.03097674f, 0.04165634f, -0.05268010f, -0.06183315f, 
    0.03227090f, 0.10307410f, 0.05899702f, 0.12335229f, -0.11095628f, -0.00674151f, 0.06572522f, -0.01086300f, 
    0.08693096f, 0.07852566f, -0.03820442f, -0.10708928f, -0.13642140f, 0.07875733f, -0.04287089f, -0.04428354f, 
    0.01398456f, -0.00553483f, 0.13261774f, -0.05548921f, 0.16787910f, 0.04070171f, -0.03160462f, 0.08509460f, 
    0.07494119f, 0.01824882f, 0.14525113f, 0.07430602f, 0.23938715f, 0.10733205f, 0.42798939f, 0.25672033f, 
    0.17099071f, 0.13123941f, 0.04821374f, 0.13532011f, 0.14811817f, -0.06204645f, 0.11208982f, -0.05428139f, 
    -0.04626384f, -0.09416468f, -0.00191111f, 0.06800723f, 0.02673265f, 0.08922882f, 0.03208390f, 0.00219657f, 
    0.06918256f, -0.03299435f, 0.14517108f, -0.01765348f, 0.03276753f, -0.24778067f, -0.02468537f, 0.04627758f, 
    0.10271112f, 0.05777496f, -0.09062659f, 0.03628107f, -0.29823005f, 0.05435901f, -0.09957671f, -0.06831796f, 
    0.06155122f, 0.09908132f, 0.15903628f, 0.05485926f, -0.10470780f, 0.19332981f, -0.05610475f, 0.06399456f, 
    -0.03599622f, 0.00690615f, 0.01454563f, 0.10428390f, 0.13784859f, -0.09722973f, 0.01185612f, -0.02534995f, 
    0.02278833f, -0.04610035f, -0.04718436f, 0.05790882f, -0.07056299f, -0.20161062f, -0.09465782f, 0.03400792f, 
    -0.04196974f, -0.24540780f, 0.23347932f, -0.23536946f, -0.00043652f, 0.08190490f, -0.06862325f, 0.05555905f, 
    -0.00419665f, 0.01802718f, 0.02475544f, 0.03141637f, 0.04721844f, 0.00536734f, 0.01541466f, -0.09644708f, 
    -0.03291077f, -0.12038072f, 0.14985195f, -0.02245216f, -0.04943160f, -0.18908522f, -0.07122006f, 0.02023480f, 
    0.03224280f, 0.01819606f, -0.17716049f, -0.05890859f, -0.03137874f, -0.04980515f, -0.09323494f, 0.11298583f, 
    0.05884584f, 0.10070031f, -0.05242536f, 0.09027907f, 0.13590807f, 0.18455304f, 0.26471987f, 0.02975141f, 
    0.10632848f, 0.38020459f, -0.16656502f, -0.08198560f, 0.04185957f, -0.05243804f, -0.14861979f, -0.17300011f, 
    0.10128173f, 0.17538813f, -0.01495341f, 0.03815942f, 0.04136387f, -0.01085299f, 0.05549688f, 0.03177776f, 
    -0.00370166f, -0.07490942f, 0.08741836f, 0.19900164f, -0.04709584f, -0.12295488f, 0.06167391f, 0.01465835f, 
    0.17318939f, 0.10450880f, -0.14898799f, 0.01411652f, -0.00636952f, 0.04920221f, 0.07427488f, -0.10753300f, 
    0.09541070f, -0.02795151f, -0.14052416f, -0.02119859f, 0.06755923f, -0.02045039f, -0.00629890f, 0.16236760f, 
    -0.23202062f, 0.06710854f, -0.27515882f, -0.02731729f, -0.36653259f, 0.09985477f, -0.07961322f, 0.11691556f, 
    -0.03432351f, 0.00015567f, -0.04326505f, 0.04137049f, 0.05141411f, -0.02925460f, 0.04160091f, -0.11766548f, 
    -0.13706045f, 0.04913924f, 0.07975457f, 0.01353495f, -0.21929103f, -0.03662001f, -0.01877487f, 0.10099616f, 
    0.07667613f, -0.13924640f, -0.09858884f, -0.01391871f, -0.10813239f, 0.04823200f, -0.08155944f, -0.08081672f, 
    -0.05341966f, 0.02878039f, -0.06279365f, 0.09829295f, -0.12442847f, 0.00448044f, 0.04492864f, -0.00175306f, 
    -0.23206754f, 0.08139112f, -0.21910593f, -0.04158115f, -0.08670528f, 0.06307084f, 0.07069758f, 0.05142361f, 
    0.15702684f, -0.02158523f, -0.09227934f, -0.08866169f, -0.00242953f, 0.10016206f, 0.00387243f, 0.00051963f, 
    0.07426355f, -0.03729378f, -0.07627851f, 0.23161791f, -0.16887853f, -0.22752015f, -0.14057252f, 0.08144008f, 
    0.15112476f, -0.07658453f, -0.07340074f, 0.01712387f, 0.07901268f, -0.02241887f, -0.08170016f, 0.01084249f, 
    -0.04499884f, 0.09136590f, -0.01831026f, -0.09929507f, -0.12414021f, 0.09740836f, 0.12703626f, -0.04248792f, 
    -0.47822163f, -0.18894422f, -0.03759898f, -0.15355217f, -0.21347670f, 0.05803593f, 0.07064938f, 0.15096830f, 
    -0.22719736f, 0.08279315f, -0.02134474f, -0.06699559f, -0.04557294f, 0.07405893f, 0.03030429f, -0.07430839f, 
    0.00547593f, -0.07310997f, -0.07778556f, -0.07993663f, -0.34349751f, 0.17425425f, -0.33413365f, -0.35605663f, 
    -0.07489693f, 0.07552676f, 0.08712432f, -0.06164411f, 0.20797122f, 0.26225764f, -0.01275760f, -0.03653949f, 
    -0.05298712f, 0.02373233f, -0.03210827f, -0.15267968f, 0.03384341f, 0.01523240f, 0.06523652f, 0.08586699f, 
    0.00352751f, 0.04626558f, 0.09499711f, 0.11463248f, -0.27290419f, 0.03676077f, 0.00591765f, -0.03586787f, 
    -0.01165317f, -0.07063069f, 0.06697051f, 0.01174743f, 0.01812290f, 0.02646966f, -0.02314294f, -0.00972723f, 
    0.08870089f, -0.01190469f, 0.09675045f, 0.19919497f, -0.36971650f, 0.01886981f, 0.08611261f, 0.20438553f, 
    -0.18806833f, 0.08085512f, -0.04387498f, -0.02028984f, 0.25908080f, 0.19065486f, -0.05568678f, 0.00534136f, 
    0.00763318f, -0.05013074f, 0.03689263f, 0.16341232f, 0.02218745f, 0.14917819f, -0.00515006f, -0.03805271f, 
    -0.02592050f, -0.01918814f, 0.07746845f, -0.16187295f, -0.08985553f, 0.03536051f, 0.02428708f, 0.11130765f, 
    0.05658817f, 0.06046687f, 0.06869991f, 0.03273766f, -0.08888227f, 0.07981458f, -0.00885169f, 0.03893699f, 
    0.03730041f, -0.02691058f, -0.12778679f, 0.12211841f, 0.17542164f, -0.17978474f, -0.42721155f, -0.25210646f, 
    -0.45884708f, -0.04940880f, -0.02060848f, -0.09825357f, -0.00427317f, 0.01381716f, 0.00719939f, -0.06403866f, 
    -0.05498634f, 0.00557825f, -0.10789724f, -0.00227346f, -0.03115820f, 0.01556965f, 0.11145867f, 0.10849223f, 
    -0.15008247f, -0.04740592f, 0.05771863f, 0.20708969f, -0.14192621f, -0.02181342f, -0.06119787f, -0.01264229f, 
    0.04716583f, 0.13878973f, 0.06539600f, -0.02436636f, 0.05372361f, 0.03465991f, -0.04836370f, -0.07478560f, 
    0.06596981f, 0.06345725f, -0.02070554f, -0.14104527f, -0.00055050f, 0.22466226f, 0.31183308f, -0.27465042f, 
    -0.11893222f, 0.06714052f, 0.10525677f, 0.01010429f, 0.14032623f, 0.11343010f, 0.06864987f, -0.10765907f, 
    0.02398241f, 0.00328423f, 0.07935828f, -0.08118429f, -0.12119808f, -0.05079605f, -0.01214987f, 0.02424451f, 
    0.13145308f, 0.18736739f, -0.06799217f, 0.07836214f, 0.21282072f, 0.03187362f, -0.02826373f, 0.02868095f, 
    -0.02640586f, -0.12526317f, 0.10868425f, 0.16415626f, -0.09357428f, 0.06615990f, -0.07001555f, -0.08714022f, 
    0.04550570f, 0.11396682f, -0.00204816f, -0.14524516f, 0.30638325f, 0.10648477f, 0.15285389f, 0.14666559f, 
    0.21665551f, -0.10411850f, -0.03383863f, -0.05460951f, -0.16534971f, -0.06427199f, 0.11782202f, 0.06325194f, 
    -0.00965521f, 0.05506884f, 0.01070549f, -0.00021943f, -0.08231189f, -0.03131763f, -0.03180373f, 0.07352893f, 
    0.58785880f, -0.28807250f, 0.02619665f, -0.24515943f, 0.10181087f, 0.10105658f, 0.13063395f, 0.00462050f, 
    -0.01833591f, 0.02180193f, 0.17970972f, 0.01090781f, 0.09124003f, -0.09298670f, 0.02444428f, -0.04569672f, 
    -0.03213349f, -0.00040087f, 0.17301093f, -0.08572581f, -0.04902135f, 0.12229577f, -0.19098811f, 0.23005538f, 
    -0.03944716f, -0.11935194f, 0.03503113f, 0.00229206f, 0.20348237f, -0.11045095f, -0.02794042f, -0.06611954f, 
    0.04742962f, 0.00020320f, -0.14870255f, 0.03424885f, -0.00305575f, 0.02639203f, 0.10062073f, -0.04967405f, 
    0.00493235f, 0.38421753f, 0.28416839f, 0.00585378f, -0.17239575f, 0.22145672f, 0.07709231f, 0.06803837f, 
    -0.00094620f, 0.09369561f, -0.07610095f, -0.07528412f, 0.01899684f, 0.08271721f, 0.04073067f, -0.12197244f, 
    0.07395910f, 0.09060840f, -0.09622934f, 0.02022697f, -0.10523572f, 0.13476321f, -0.18696399f, 0.21061094f, 
    -0.02230948f, 0.05338046f, -0.04274240f, 0.11630852f, 0.04493918f, 0.08622515f, -0.04814046f, 0.06253535f, 
    -0.05800807f, 0.06728450f, -0.06548879f, 0.14652073f, 0.00529126f, 0.05091373f, -0.05860902f, 0.03639949f, 
    0.14477567f, -0.01697634f, 0.14350392f, -0.01177309f, -0.21538267f, 0.05372601f, 0.07493502f, 0.08629772f, 
    -0.02689377f, 0.05586144f, -0.01342170f, -0.14593366f, -0.00780950f, 0.04134854f, -0.00686252f, -0.02475468f, 
    0.04990160f, -0.00690879f, 0.01787057f, -0.02414525f, 0.22612646f, 0.18180875f, 0.19337393f, 0.20163774f, 
    0.07751254f, 0.08163260f, -0.03525193f, 0.02095201f, -0.08762297f, -0.07851745f, 0.24462493f, -0.02662264f, 
    0.04067647f, -0.01812033f, -0.02290510f, -0.14133024f, -0.08508578f, 0.00144322f, 0.03738067f, -0.11105421f, 
    0.16940342f, 0.44736210f, -0.35652524f, -0.02843917f, -0.21236941f, 0.00961257f, -0.01787104f, 0.05796775f, 
    -0.13006622f, 0.08388481f, -0.04226248f, -0.05786465f, 0.02894888f, 0.01974192f, 0.01711102f, 0.01771239f, 
    0.07456224f, -0.08876848f, 0.05155764f, -0.01607068f, 0.22821015f, -0.03295422f, 0.12126004f, 0.01479651f, 
    0.06561033f, 0.08530486f, 0.21069059f, 0.07188630f, -0.00255812f, 0.12601735f, 0.01126263f, -0.08196269f, 
    0.00879800f, -0.02075604f, 0.00550182f, -0.12779392f, -0.07503979f, 0.06040206f, 0.08614757f, -0.01011852f, 
    0.07245247f, 0.04217298f, -0.09255846f, 0.10030666f, -0.11482798f, 0.02854274f, -0.05707921f, -0.12835443f, 
    -0.04888058f, 0.01986469f, 0.06166619f, 0.12641032f, -0.01892336f, -0.11877541f, 0.05144366f, 0.06010887f, 
    0.05418569f, 0.00585869f, -0.01682109f, 0.17753994f, -0.01696978f, -0.04178515f, -0.06660268f, -0.07147314f, 
    0.02014647f, 0.08215171f, -0.22497028f, -0.03735872f, 0.09970326f, 0.05548387f, 0.04759000f, 0.02261867f, 
    -0.04526500f, 0.04831128f, 0.08228271f, 0.15735368f, 0.07037165f, 0.09510377f, 0.01404273f, -0.09621514f, 
    0.02162335f, -0.12257281f, -0.01801830f, -0.07787304f, -0.10124284f, 0.05341339f, 0.07155225f, -0.11226895f, 
    0.06754547f, -0.00168313f, 0.07267811f, 0.04940669f, 0.03714234f, 0.10039693f, 0.05058909f, 0.03492759f, 
    0.07994112f, -0.05756370f, -0.02077266f, 0.09403760f, -0.26488313f, -0.01969431f, 0.00787526f, -0.03698434f, 
    -0.19883628f, 0.02999159f, 0.00114553f, 0.12096629f, -0.10224962f, 0.15442388f, 0.25343060f, -0.10322178f, 
    0.04367349f, 0.04623230f, -0.01815656f, 0.11346199f, -0.02019694f, -0.06731366f, -0.02649000f, -0.02256460f, 
    -0.41626006f, -0.14279100f, -0.17944092f, -0.05508531f, -0.10006369f, -0.02699555f, 0.07034035f, -0.03767651f, 
    0.01455044f, 0.10654285f, 0.14302264f, 0.04244716f, 0.03051288f, 0.11518328f, -0.05137538f, -0.11862657f, 
    0.03640075f, -0.05508808f, -0.03735212f, 0.04456773f, -0.07800369f, 0.16167217f, -0.00045084f, 0.06129190f, 
    -0.03149949f, 0.06664658f, -0.08711386f, 0.08028623f, 0.13971068f, -0.01980956f, 0.04892900f, -0.04169868f, 
    -0.03453497f, -0.03424441f, 0.03103374f, 0.09945249f, -0.11930715f, -0.26919007f, 0.00917737f, -0.03019656f, 
    0.18164212f, 0.01452200f, 0.01274311f, -0.03331765f, -0.02103470f, -0.06748886f, 0.09453027f, 0.04027364f, 
    -0.00081360f, -0.07724985f, 0.17941508f, 0.16549952f, -0.07218882f, 0.07597620f, 0.12457662f, -0.11570525f, 
    0.08627123f, 0.03874164f, 0.15200904f, 0.00785987f, 0.18785170f, -0.18001473f, 0.20160116f, -0.12360414f, 
    0.10869724f, -0.01251546f, -0.08626287f, -0.18457197f, -0.16235153f, -0.18079479f, -0.06294820f, 0.11458620f, 
    0.15704672f, -0.04004434f, 0.06567924f, 0.14400595f, -0.15997091f, -0.02753693f, -0.09770606f, -0.07769258f, 
    0.65798044f, 0.09858195f, -0.23219052f, -0.19428219f, -0.12889862f, 0.10440265f, 0.03218941f, -0.04181331f, 
    0.01327450f, 0.12185978f, -0.00341973f, 0.06884823f, 0.08152849f, 0.16633488f, 0.01176955f, -0.02329407f, 
    0.15197825f, 0.15078072f, 0.02456940f, 0.02273043f, -0.28447446f, -0.10849670f, -0.01557763f, 0.06826764f, 
    0.13486886f, -0.06601471f, 0.10700663f, -0.03906772f, -0.02493471f, -0.08641702f, 0.00119174f, 0.00261653f, 
    0.00715657f, 0.07108442f, -0.03706155f, 0.05700815f, 0.16616689f, 0.05098527f, -0.02306587f, 0.07894011f, 
    -0.19903368f, 0.13884744f, 0.00456518f, 0.06235897f, -0.20972027f, 0.13928412f, -0.26055244f, -0.16346742f, 
    -0.09901169f, -0.09341911f, 0.15868945f, 0.06343436f, 0.08978532f, 0.16773650f, 0.16503090f, -0.05354194f, 
    0.05855372f, 0.00913067f, -0.09422242f, -0.12459431f, 0.35598636f, 0.14545807f, -0.09392978f, -0.13627426f, 
    0.01756972f, -0.11641515f, -0.06894284f, -0.12910131f, -0.03887899f, -0.08130617f, -0.07358193f, 0.06662086f, 
    -0.04120039f, 0.04556535f, 0.01452564f, 0.04979770f, 0.00018731f, -0.10621794f, 0.03242795f, 0.10747779f, 
    -0.18326005f, -0.08138642f, 0.05499362f, 0.12790918f, 0.00948272f, -0.12850198f, 0.01711152f, 0.04090739f, 
    0.07432505f, 0.06609438f, -0.09503469f, -0.13505882f, -0.12636353f, 0.11158220f, -0.05472670f, 0.01543817f, 
    0.14525102f, 0.05674714f, 0.02754462f, 0.03937327f, -0.01667869f, 0.02257246f, -0.03847788f, -0.04576276f, 
    -0.04033906f, -0.12328160f, -0.05457703f, -0.10152941f, -0.19007796f, -0.06640884f, 0.10081516f, 0.06557218f, 
    -0.01383928f, 0.02393471f, -0.03092298f, -0.06381258f, 0.02028355f, 0.01154236f, 0.00637218f, -0.05712957f, 
    0.08952826f, 0.00184014f, -0.03543893f, -0.25510344f, -0.32291320f, -0.03999652f, -0.04378238f, -0.19375890f, 
    0.04303961f, -0.09475103f, -0.01943148f, -0.00586019f, -0.10440887f, -0.03416060f, 0.10672373f, -0.06785188f, 
    -0.03065110f, -0.10015959f, -0.05306340f, -0.02589430f, 0.31637606f, 0.17476943f, -0.24253631f, 0.14309953f, 
    0.03532381f, 0.00894968f, -0.00721494f, -0.13477539f, 0.10019420f, 0.05993821f, -0.02140454f, -0.04948983f, 
    0.09051393f, 0.00724821f, 0.04776076f, -0.06281824f, 0.05126213f, 0.01917883f, -0.06491376f, -0.17569618f, 
    -0.28527680f, -0.16910864f, 0.01954396f, 0.30022433f, -0.08670332f, 0.06461051f, 0.11859984f, -0.01889995f, 
    0.02797535f, 0.06342805f, -0.00360829f, 0.09252865f, -0.00103132f, 0.00491250f, 0.04143064f, 0.09598022f, 
    0.09423446f, 0.03512958f, -0.03287795f, 0.19179329f, -0.19041277f, -0.13910177f, -0.33709806f, 0.11944823f, 
    -0.16728871f, 0.12086616f, 0.05959164f, 0.07070389f, 0.09954806f, 0.06846505f, -0.01567545f, 0.08231816f, 
    -0.07456270f, 0.03183287f, 0.05841903f, 0.17975576f, -0.08960146f, -0.05990062f, -0.04165572f, -0.04876113f, 
    0.08095278f, 0.05282881f, 0.13934951f, -0.15300316f, -0.14997287f, 0.03115339f, 0.00887342f, -0.05483848f, 
    0.02253493f, 0.02236191f, 0.05014336f, -0.14894320f, 0.08604263f, 0.18726772f, -0.06013483f, 0.07673448f, 
    0.12159352f, -0.08760175f, 0.08529709f, 0.19407371f, -0.05067282f, 0.00355783f, 0.44327873f, 0.20504047f, 
    0.07005949f, -0.18135419f, -0.19190761f, -0.10120902f, 0.01033741f, 0.00284876f, 0.11690791f, 0.11666708f, 
    -0.08529770f, -0.07687482f, 0.05106220f, 0.10260688f, -0.06963851f, -0.01989230f, -0.03366863f, 0.06367908f, 
    -0.08361849f, -0.27001205f, -0.19311200f, 0.11702383f, -0.18519174f, -0.01067800f, -0.02852399f, -0.08261576f, 
    -0.01308497f, 0.02422497f, -0.11857329f, -0.06479979f, 0.06988925f, 0.00693085f, -0.01360402f, 0.08769239f, 
    -0.05507390f, 0.08972500f, 0.06807080f, -0.00078234f, -0.32539457f, -0.16747434f, 0.04678715f, 0.29145896f, 
    -0.07402161f, 0.03907393f, 0.02780978f, 0.03150280f, -0.04529739f, -0.10329457f, 0.02922046f, -0.08348768f, 
    0.00143743f, -0.03252065f, -0.05433520f, 0.05492049f, 0.08286799f, -0.21407115f, 0.02871340f, 0.03360505f, 
    0.20788269f, -0.08832774f, 0.23150031f, -0.16824596f, 0.08223487f, 0.13225387f, -0.11494821f, 0.09164942f, 
    0.02381073f, -0.13323174f, 0.10229386f, 0.03444562f, 0.11317093f, -0.04491666f, 0.04022836f, 0.00346870f, 
    0.02941529f, 0.07621274f, 0.13589625f, 0.02825235f, 0.07509283f, -0.03409799f, -0.09021461f, -0.14282680f, 
    -0.02619744f, -0.26810426f, -0.33404741f, -0.06713554f, -0.06038947f, -0.08271915f, 0.01305766f, 0.14783424f, 
    0.04563474f, 0.07051159f, 0.08583523f, 0.08386674f, 0.05396507f, 0.12104420f, 0.17763209f, 0.06351071f, 
    0.27585191f, 0.37239641f, 0.02010895f, -0.13420372f, 0.04016810f, 0.10738487f, 0.03056428f, -0.08984496f, 
    0.11492533f, 0.04951408f, 0.03598809f, 0.00150831f, 0.13481472f, -0.00256367f, -0.00882591f, 0.02392849f, 
    0.01458219f, -0.10313025f, 0.17011854f, 0.17667873f, -0.14046536f, -0.14110425f, -0.07729559f, 0.15138116f, 
    0.01546424f, -0.03970263f, -0.00989081f, 0.05529777f, -0.06122836f, -0.23977168f, 0.01582925f, -0.02606016f, 
    0.16883636f, 0.01231460f, 0.11612525f, 0.14728786f, 0.00468243f, 0.13567771f, -0.01876406f, 0.21527617f, 
    -0.20324396f, -0.09781672f, 0.04713807f, 0.14698514f, -0.15554157f, 0.06114402f, -0.11066320f, 0.10380482f, 
    -0.05342216f, -0.02680978f, 0.09921141f, 0.10191090f, 0.07449856f, 0.11796300f, 0.00833668f, 0.08113362f, 
    0.07026280f, -0.07992361f, -0.07867600f, -0.04566019f, -0.38400045f, -0.26011229f, -0.31475440f, 0.11532030f, 
    0.11585057f, -0.05877287f, -0.08695867f, 0.08714778f, -0.18267407f, -0.08981653f, -0.01707277f, -0.03153754f, 
    -0.07404637f, 0.01353369f, 0.00819429f, 0.05802927f, -0.00858177f, 0.08829043f, -0.00563966f, 0.11082096f, 
    -0.29144585f, -0.02555211f, 0.07513299f, 0.26356745f, 0.03239314f, -0.08951651f, 0.11020517f, 0.01186688f, 
    0.03347524f, 0.01725729f, -0.07837511f, -0.09708572f, -0.00972986f, -0.01567683f, 0.04384294f, 0.07740498f, 
    0.20332998f, -0.07510687f, -0.00956803f, 0.06150439f, -0.01033830f, -0.23005415f, -0.20412815f, -0.04315986f, 
    0.04964893f, -0.12313566f, -0.13187066f, -0.10563151f, -0.04079121f, -0.04951755f, 0.13438953f, -0.01643368f, 
    -0.01736630f, -0.08268074f, 0.03989615f, -0.01233852f, 0.02068997f, 0.01921100f, 0.28083831f, 0.07222331f, 
    0.07044970f, 0.00580823f, -0.23055153f, -0.11582065f, -0.04509941f, -0.03911791f, 0.07175386f, 0.20871668f, 
    -0.24684845f, -0.02160659f, 0.01444344f, 0.03724149f, -0.00533175f, -0.03951456f, 0.06829190f, -0.00206273f, 
    -0.07668048f, 0.01179848f, -0.10044158f, -0.00248745f, -0.05787535f, -0.01291805f, -0.40555355f, 0.07096590f, 
    -0.19311889f, 0.13587090f, 0.05194239f, 0.05459180f, 0.20176230f, 0.17385957f, -0.00568008f, -0.03337517f, 
    -0.00788845f, 0.00710102f, 0.00527029f, -0.07358143f, 0.11086366f, -0.07060533f, 0.12737176f, 0.05928742f, 
    0.01986124f, 0.09001628f, 0.26416448f, 0.09153507f, -0.05397616f, 0.07221513f, -0.00091779f, 0.16367489f, 
    0.10797846f, 0.02865217f, -0.02195406f, 0.01855014f, -0.08967412f, -0.03163828f, -0.00233821f, -0.05035928f, 
    -0.04940170f, -0.10636326f, 0.03694478f, -0.07840314f, -0.06631560f, 0.09762878f, -0.01336967f, 0.44338098f, 
    -0.26640636f, -0.04435427f, 0.06952736f, 0.08650954f, 0.06320081f, 0.10046089f, -0.05136169f, -0.06446747f, 
    -0.04270214f, 0.05722746f, -0.00079633f, 0.05829080f, 0.10264755f, 0.02358777f, 0.06790727f, 0.08865148f, 
    0.03056144f, 0.05190942f, 0.26936609f, -0.27906388f, -0.08983859f, -0.09280623f, -0.10817484f, 0.02592930f, 
    -0.08724167f, 0.04151891f, -0.03093778f, 0.02939133f, 0.03673579f, -0.13781038f, -0.01801100f, -0.09638554f, 
    -0.11905853f, -0.11331342f, -0.12856942f, -0.11959803f, 0.26200831f, 0.02267255f, -0.14304516f, 0.03834197f, 
    -0.15771475f, -0.04180846f, 0.01928500f, -0.19206542f, 0.06346046f, -0.06336266f, -0.05709421f, 0.01971949f, 
    -0.10641093f, 0.00863215f, 0.08304258f, -0.09673477f, 0.04387208f, 0.19723946f, -0.01596125f, 0.05626515f, 
    -0.03077316f, 0.19574416f, 0.07173412f, 0.16033246f, -0.20063135f, -0.12877677f, -0.12713765f, 0.00170810f, 
    -0.05253690f, -0.09173506f, 0.11593258f, -0.02421543f, -0.03436430f, -0.11952925f, -0.09698091f, 0.01786252f, 
    -0.08497082f, -0.02765669f, -0.15299991f, -0.07068442f, 0.02694620f, -0.16058949f, 0.20651819f, -0.11524267f, 
    0.02856546f, -0.05805112f, 0.13835973f, -0.08557118f, 0.00912092f, 0.09216967f, 0.05736591f, -0.05072249f, 
    0.13482875f, 0.16753855f, 0.11207729f, -0.01826082f, 0.07646884f, 0.09377947f, 0.15462232f, 0.08908559f, 
    -0.12009358f, 0.01755104f, -0.25016728f, -0.15469581f, 0.01820228f, 0.08688503f, -0.09256981f, 0.00906603f, 
    -0.07394015f, -0.00002293f, -0.04256214f, 0.00672663f, 0.01135801f, -0.02077451f, -0.06644753f, 0.18742356f, 
    -0.02810956f, 0.09811664f, -0.15550335f, -0.09057914f, 0.04101545f, 0.13964111f, -0.15194285f, 0.01758833f, 
    -0.17432827f, -0.19657105f, -0.17050780f, -0.13899229f, -0.23374219f, -0.01365380f, 0.07244782f, 0.11845464f, 
    -0.06048428f, 0.12699755f, 0.02682824f, -0.05037888f, 0.10792641f, 0.21146852f, -0.13996962f, 0.06783830f, 
    -0.10546519f, -0.58168799f, 0.23043133f, -0.26731935f, 0.12314954f, 0.00756314f, -0.00804696f, -0.10121217f, 
    -0.02389160f, -0.13548894f, 0.11192025f, -0.03359205f, 0.05247720f, -0.04258418f, 0.10801426f, 0.02119065f, 
    -0.09665089f, -0.04814274f, 0.01264825f, -0.03203432f, -0.05712664f, 0.12271760f, -0.38379714f, 0.20286737f, 
    -0.41423354f, -0.11612740f, -0.14163038f, -0.03003882f, -0.06676910f, -0.09459396f, 0.09675325f, -0.04591247f, 
    0.03324792f, -0.04366068f, 0.11160608f, 0.08780161f, -0.21582648f, -0.19461264f, -0.20643909f, -0.09355954f, 
    0.19488829f, 0.13556573f, 0.29589379f, 0.09436772f, 0.13142885f, -0.01779480f, 0.22803669f, 0.14121287f, 
    0.12636146f, 0.23088712f, -0.14558406f, -0.00539878f, -0.06090464f, 0.17123042f, 0.04771433f, 0.06723785f, 
    0.16062519f, 0.05736260f, 0.08158691f, -0.02156802f, -0.59541178f, 0.01652369f, -0.36472517f, 0.20258255f, 
    -0.10227948f, 0.02659602f, -0.03100401f, 0.00440154f, 0.02984941f, -0.02912724f, 0.00891925f, -0.02853796f, 
    0.01722703f, -0.02535864f, 0.07415574f, 0.04395258f, -0.04185382f, 0.00758173f, -0.20593685f, -0.19400461f, 
    0.36414185f, 0.18949908f, 0.34120330f, 0.06077078f, 0.00357347f, 0.15723699f, 0.02918506f, 0.05868862f, 
    -0.01362258f, 0.18890858f, -0.05236660f, 0.03111184f, -0.08369721f, -0.07386415f, 0.06010712f, -0.06427816f, 
    0.00361112f, -0.11841680f, 0.04875071f, -0.03777932f, -0.05769290f, 0.01123731f, -0.00580338f, 0.00820046f, 
    0.20194572f, 0.02973696f, -0.11378942f, -0.01549832f, -0.06364249f, -0.06339410f, 0.14753662f, 0.02166527f, 
    0.03588772f, 0.10961937f, 0.18491827f, 0.07196355f, 0.03574241f, -0.00852702f, -0.22704217f, -0.09922245f, 
    0.12021542f, 0.62478465f, -0.31139925f, 0.19047743f, 0.13951461f, 0.05291052f, -0.00861688f, 0.08713499f, 
    0.02513932f, 0.02919062f, -0.01048385f, -0.01517602f, 0.09012823f, -0.09376727f, -0.00991012f, 0.13409351f, 
    0.16118145f, 0.15353726f, 0.01718412f, 0.02805388f, 0.13496795f, -0.06787783f, 0.22561951f, 0.15647298f, 
    -0.07150646f, -0.02338954f, 0.01867548f, 0.14474024f, -0.02827962f, 0.03350870f, 0.04713973f, 0.04181392f, 
    -0.11538947f, 0.01770701f, -0.04921556f, -0.00116389f, 0.11339911f, -0.02200927f, 0.13360845f, 0.14755844f, 
    -0.01831396f, 0.02260624f, 0.02872374f, 0.02277404f, -0.03541082f, 0.04967956f, 0.02955203f, 0.02485333f, 
    0.04856401f, 0.01807291f, 0.00148034f, 0.00926396f, 0.04620775f, 0.02076758f, -0.02322512f, 0.02416491f, 
    -0.00013583f, -0.01453855f, 0.03807393f, -0.01048279f, 0.04285841f, 0.03260679f, 0.04696618f, 0.01406885f, 
    -0.03791810f, -0.05873609f, -0.00769038f, -0.05209041f, -0.02610539f, 0.01278010f, 0.04431333f, 0.01896393f, 
    -0.01616897f, -0.05690361f, -0.01897601f, 0.04985771f, -0.02008373f, -0.01376482f, 0.02327235f, 0.02589882f, 
    -0.01766006f, 0.00298042f, -0.01071922f, -0.01482513f, -0.01357786f, 0.02189146f, 0.01329244f, -0.05509215f, 
    -0.01070902f, -0.06032684f, -0.02597583f, -0.00683241f, 0.03297494f, 0.04512933f, 0.02855065f, -0.05965149f, 
    -0.01544308f, -0.03501396f, -0.03686859f, 0.03746556f, 0.04075299f, 0.04162661f, 0.00390692f, -0.04729689f, 
    -0.05112839f, 0.02861722f, 0.01326153f, -0.00989237f, 0.00213803f, -0.04038168f, 0.01180683f, -0.00724803f, 
    -0.00881033f, -0.01569295f, 0.01962565f, 0.00951115f, -0.02432577f, -0.02325931f, -0.04885136f, -0.05269155f, 
    0.02025557f, -0.02185731f, 0.03969157f, 0.00171579f, -0.05961106f, -0.00735395f, -0.05195007f, 0.04497444f, 
    0.02137413f, -0.05996745f, 0.04083867f, -0.00638917f, 0.00526077f, 0.01641381f, -0.01354393f, -0.01283658f, 
    -0.04612697f, 0.03116038f, -0.03231788f, -0.04006734f, -0.03517711f, -0.02549706f, 0.00463043f, -0.04113027f, 
    -0.05506658f, 0.04087821f, 0.03534098f, -0.05397333f, 0.00458773f, -0.00712745f, -0.00031043f, -0.05685029f, 
    0.04149675f, 0.03816873f, -0.04037089f, -0.02910859f, 0.04723277f, 0.00559443f, 0.01562317f, -0.05634090f, 
    -0.03418713f, 0.02289804f, -0.01723009f, -0.05110882f, -0.05895029f, -0.03852947f, -0.01897567f, 0.03343858f, 
    -0.03017832f, -0.05102056f, -0.04368725f, 0.00596900f, 0.00992077f, -0.03936393f, -0.00108065f, 0.01561378f, 
    -0.01455724f, 0.02498500f, 0.02429939f, 0.02581863f, 0.00164913f, 0.02729184f, -0.03103279f, 0.03200779f, 
    -0.06010632f, -0.02919049f, -0.03543267f, -0.04190775f, -0.02442088f, 0.01288289f, -0.04347479f, -0.01704421f, 
    -0.04554279f, 0.03729910f, -0.01604209f, 0.04862887f, -0.01952906f, -0.03507516f, -0.02451368f, 0.01115736f, 
    0.04328836f, 0.02135636f, -0.02464245f, -0.02964190f, 0.01046472f, -0.00920467f, 0.04978736f, 0.02655294f, 
    -0.02946483f, 0.04871937f, -0.03417300f, -0.05045653f, -0.05874581f, -0.01322581f, 0.00260598f, -0.04451302f, 
    0.03994994f, -0.00174028f, -0.01649560f, -0.02738743f, -0.04761661f, -0.04184825f, 0.04112786f, -0.05837309f, 
    -0.02824259f, -0.04269832f, -0.05330795f, -0.04156926f, -0.01692489f, -0.01039904f, -0.01720539f, 0.02494223f, 
    0.04359609f, 0.03003035f, -0.00498647f, 0.01010736f, 0.03340250f, 0.00721535f, -0.05596784f, 0.00045030f, 
    0.04250817f, -0.01849820f, 0.02735622f, 0.01348370f, -0.05015837f, -0.01741079f, 0.05382552f, -0.00447358f, 
    -0.00111935f, -0.01581044f, 0.03820689f, 0.01799932f, 0.05022545f, 0.00108504f, 0.01696211f, 0.02260166f, 
    -0.04461044f, 0.03486416f, 0.01583394f, -0.02326872f, 0.02088068f, -0.05399819f, -0.05188690f, -0.05778023f, 
    -0.05873677f, 0.02519745f, -0.05894865f, -0.00702047f, 0.04715851f, -0.04746383f, 0.02815817f, 0.01420945f, 
    0.01334227f, 0.03776686f, 0.01780753f, 0.00012054f, 0.02854188f, 0.03062651f, 0.01002673f, 0.04537597f, 
    -0.04740551f, -0.04350618f, 0.00403237f, -0.05295638f, -0.00202082f, -0.03331342f, -0.03773020f, -0.01256251f, 
    -0.03801784f, 0.01523741f, -0.02663735f, -0.02402147f, -0.05401643f, 0.01421158f, -0.02132691f, -0.05083216f, 
    -0.03128137f, -0.00379922f, -0.02275336f, 0.02021117f, -0.05965150f, 0.02743751f, 0.01970820f, 0.00147463f, 
    -0.01764805f, -0.02445353f, -0.03079596f, -0.05411399f, 0.01307147f, -0.00310916f, -0.05071305f, 0.01685797f, 
    -0.00324829f, -0.05498074f, -0.05585331f, -0.03369016f, 0.01763672f, 0.03384952f, -0.03538007f, -0.02273180f, 
    -0.05349785f, 0.04334244f, -0.05101278f, -0.03003801f, -0.04175434f, -0.00390102f, -0.04475283f, 0.02302644f, 
    0.00428419f, -0.00357685f, -0.04105044f, 0.00576813f, 0.00274805f, 0.00947944f, -0.04967905f, 0.04904729f, 
    -0.04586916f, -0.05393656f, -0.00896383f, 0.00902688f, 0.02604675f, -0.05931889f, 0.01707734f, -0.01468989f, 
    0.00604767f, -0.03118451f, -0.00891760f, -0.01036414f, -0.04797794f, -0.06145741f, 0.04576573f, -0.00076529f, 
    0.01759991f, -0.02129247f, -0.00363484f, -0.00596965f, 0.01084750f, 0.00921542f, -0.04400458f, 0.01348328f, 
    0.28963345f, 0.03439057f, -0.13331464f, -0.08912318f, 0.00010574f, 0.18458956f, 0.08099039f, 0.02416359f, 
    0.05617139f, -0.03265545f, 0.03071158f, -0.01230081f, -0.02819292f, 0.01012251f, -0.08866145f, 0.05051676f, 
    0.04401201f, -0.00331626f, -0.02475567f, 0.02088785f, 0.28129283f, 0.16565129f, 0.35498074f, -0.15889472f, 
    0.16800566f, -0.06981607f, 0.06280347f, 0.01557622f, 0.04829730f, -0.00185710f, 0.02500302f, 0.00077474f, 
    -0.00715474f, -0.06825762f, -0.03383562f, -0.12768711f, 0.01706992f, -0.02702451f, 0.03153217f, -0.06981985f, 
    -0.30587697f, -0.12556368f, -0.15848014f, 0.09617639f, 0.14091794f, 0.04163298f, 0.00971903f, 0.01799029f, 
    0.05750989f, 0.16851944f, 0.03517723f, 0.11876201f, -0.03571082f, -0.05280245f, -0.11610899f, 0.05825331f, 
    0.04165535f, 0.04211465f, 0.02675167f, -0.10097872f, 0.12554142f, 0.13161816f, -0.31969571f, -0.18665966f, 
    0.09118011f, 0.11228479f, 0.12929028f, 0.02044718f, 0.05707256f, -0.03378846f, -0.09427422f, 0.02944753f, 
    0.05268875f, 0.00837654f, 0.06582947f, -0.07768054f, 0.05483118f, -0.01531784f, 0.02865855f, -0.01755396f, 
    0.41472238f, 0.16011472f, -0.12672752f, -0.09453852f, -0.02169898f, 0.07480901f, -0.02609234f, 0.00858277f, 
    -0.08837681f, -0.17714882f, -0.00573793f, -0.01562997f, -0.02610488f, -0.09104829f, -0.00511491f, 0.08602977f, 
    0.20767124f, 0.03895536f, 0.04028229f, -0.00694691f, 0.11362459f, 0.18820053f, -0.12084853f, -0.22248061f, 
    0.13628329f, 0.10206527f, -0.03605573f, -0.00179794f, 0.06397544f, 0.11821795f, -0.03176913f, -0.00870572f, 
    0.04667568f, 0.08657875f, 0.14413473f, -0.03322361f, -0.01939692f, 0.16088405f, 0.05239058f, -0.01608222f, 
    -0.31688559f, 0.21096401f, -0.05753636f, 0.09844759f, -0.07565130f, -0.05746758f, -0.04239991f, -0.00594351f, 
    0.05899728f, -0.03726598f, -0.07227436f, -0.08268082f, -0.03067420f, -0.02624853f, 0.02780083f, -0.00828191f, 
    -0.00141763f, -0.05494307f, -0.00527285f, -0.02311450f, -0.22026095f, -0.10879835f, -0.12840764f, 0.04324466f, 
    -0.23335312f, 0.06529592f, 0.06914955f, 0.08877920f, -0.03135106f, 0.01797495f, 0.03893432f, -0.08179853f, 
    -0.01192837f, 0.07741805f, 0.00165788f, 0.01539033f, -0.12171443f, 0.00495867f, 0.00535836f, -0.01166871f, 
    -0.59120762f, 0.01486772f, 0.13173684f, 0.01478272f, 0.28374666f, -0.12567624f, 0.04230379f, 0.00238075f, 
    -0.10982898f, 0.10475845f, -0.01636013f, 0.06790890f, 0.10110640f, 0.02313654f, -0.00988190f, -0.02016558f, 
    0.08060283f, 0.10085770f, -0.02815014f, -0.00847520f, 0.12289018f, 0.09021832f, 0.06554419f, -0.22551183f, 
    -0.20191026f, -0.02289014f, 0.00690519f, 0.08463264f, -0.11519561f, 0.01224434f, -0.04955598f, 0.07897355f, 
    0.02738426f, 0.00346872f, -0.10384214f, -0.07266383f, 0.13092880f, 0.03537272f, 0.05990762f, 0.02682664f, 
    0.11033253f, -0.04943908f, -0.03986245f, -0.10654077f, 0.21874532f, -0.06459790f, 0.02688470f, -0.05636142f, 
    0.01000011f, 0.16057040f, 0.04028643f, -0.07696871f, -0.03585253f, -0.06610485f, 0.00215322f, 0.03292096f, 
    0.01693597f, 0.03890767f, -0.01120050f, -0.10536135f, 0.02929290f, 0.14880896f, 0.11847768f, -0.05974668f, 
    -0.20929283f, 0.11235218f, 0.04429486f, -0.01164559f, -0.06784159f, -0.08060480f, -0.07691306f, 0.07216926f, 
    0.00614921f, 0.02406435f, -0.07956795f, 0.01877888f, 0.01959476f, 0.06103852f, 0.07452618f, -0.06594165f, 
    0.09214883f, -0.19783516f, -0.30010816f, -0.07162621f, 0.06555863f, 0.18039775f, 0.12448203f, 0.09712102f, 
    0.08047463f, 0.10146614f, 0.03575464f, -0.00797226f, -0.01326406f, -0.03740767f, 0.03620990f, 0.01588936f, 
    -0.02619334f, 0.12011189f, -0.07496615f, 0.20044914f, -0.17692742f, 0.05719375f, 0.09605233f, 0.02893254f, 
    -0.13960883f, -0.06988709f, -0.05402846f, -0.00864422f, -0.05681562f, -0.12498945f, -0.00768146f, 0.08998629f, 
    0.05511771f, 0.04606554f, -0.00321710f, -0.00305101f, 0.12564047f, 0.06331312f, 0.01562160f, -0.06791721f, 
    -0.07414328f, -0.06318043f, 0.38674024f, 0.13466340f, 0.36941403f, -0.13615511f, -0.02028147f, -0.10387544f, 
    0.06972688f, -0.01125623f, 0.08840551f, -0.03692922f, 0.02771184f, -0.01054435f, 0.06934220f, -0.00428364f, 
    -0.04536360f, -0.11971556f, -0.01428124f, -0.09934382f, 0.05710258f, -0.00186645f, 0.25309628f, 0.03934802f, 
    0.12596798f, 0.05575302f, 0.12333453f, -0.03777720f, -0.11755835f, -0.09415263f, 0.07141656f, 0.03633489f, 
    0.05871150f, 0.06728706f, 0.05436162f, 0.03190296f, 0.02193688f, 0.19993880f, -0.17935066f, -0.16812612f, 
    0.16612270f, 0.01054224f, 0.47019568f, 0.12726229f, 0.17840104f, 0.01847053f, -0.02883291f, -0.02797230f, 
    0.10833953f, 0.00608857f, 0.07984427f, 0.10869595f, -0.02329524f, 0.00790525f, 0.05031051f, -0.05251918f, 
    -0.02563222f, -0.08843695f, 0.11243764f, 0.14307423f, -0.15841199f, 0.03255443f, 0.18205529f, 0.46214774f, 
    -0.22142293f, 0.00687964f, -0.00679621f, 0.06444842f, -0.07230049f, 0.14105715f, 0.06730948f, -0.00045277f, 
    -0.00067664f, -0.03545731f, 0.07103930f, 0.02713208f, -0.03703368f, 0.09196363f, -0.03663330f, -0.06739974f, 
    0.17261735f, -0.08687890f, 0.13896303f, -0.21842754f, 0.07098830f, 0.01964656f, -0.02449241f, 0.11222363f, 
    -0.13403192f, 0.04664598f, -0.13958471f, -0.14087273f, -0.00025938f, -0.04886261f, -0.06327526f, 0.01744494f, 
    -0.07118615f, -0.04967088f, -0.08252162f, 0.06508277f, -0.28037041f, 0.02792281f, -0.21748443f, -0.11061571f, 
    -0.16068770f, 0.01350588f, 0.06798477f, -0.04978807f, -0.07503391f, 0.05802815f, -0.04318926f, -0.05680897f, 
    -0.05657261f, 0.17688446f, -0.02451883f, -0.03562916f, -0.03352386f, 0.02292886f, -0.06108084f, 0.04097148f, 
    -0.07124837f, 0.12721762f, 0.10394975f, 0.12146943f, -0.11828879f, 0.02502940f, -0.05490640f, -0.23722138f, 
    -0.00775193f, 0.12494016f, 0.05245234f, -0.04225644f, -0.05840773f, -0.05215725f, 0.17201795f, 0.16604856f, 
    -0.13647528f, 0.04354971f, -0.07030597f, -0.16323163f, -0.22148693f, -0.14287370f, 0.31201020f, -0.05210720f, 
    0.11110140f, -0.03254065f, 0.11870877f, 0.04801285f, -0.18055744f, -0.01354556f, 0.10466850f, -0.02092561f, 
    -0.01721034f, 0.16531548f, 0.09575520f, 0.04556412f, 0.13682809f, 0.09606976f, 0.04108062f, -0.06452088f, 
    -0.17243871f, 0.03866726f, -0.43323874f, -0.12318447f, -0.00390322f, 0.24049726f, -0.13343371f, 0.07296656f, 
    -0.12858398f, -0.03791401f, -0.04363977f, -0.02393555f, -0.01179985f, -0.07715858f, -0.07095617f, 0.15825161f, 
    -0.12718748f, 0.17845386f, -0.11143496f, -0.12467242f, -0.10576085f, -0.08015953f, -0.32741827f, -0.27921262f, 
    -0.12129525f, 0.08920145f, 0.01140346f, -0.13632578f, -0.08849730f, 0.13631803f, -0.07285669f, 0.00755055f, 
    0.01337854f, 0.03316406f, 0.05446651f, -0.17157659f, -0.11584826f, 0.09893869f, -0.12172301f, 0.11439338f, 
    -0.13433567f, -0.51682436f, 0.19068131f, -0.31232843f, 0.09734461f, 0.01644690f, 0.14349876f, -0.00702281f, 
    -0.07944065f, -0.23936097f, 0.05431576f, -0.17924820f, -0.01152408f, -0.10233280f, 0.01421935f, 0.06215908f, 
    -0.12741193f, -0.11020485f, -0.03246675f, -0.03635416f, -0.21466203f, 0.19062418f, -0.37032595f, 0.17433065f, 
    -0.23329560f, -0.09607131f, 0.00718069f, -0.10529264f, 0.13761967f, -0.00209432f, 0.05679196f, -0.07377923f, 
    0.00521646f, -0.08859257f, 0.09039480f, 0.11542689f, -0.16503479f, -0.11355624f, 0.02589895f, 0.00275466f, 
    0.10260083f, -0.02434701f, 0.34641334f, 0.11710052f, 0.28350645f, -0.02070267f, 0.12373998f, 0.24402097f, 
    0.23001321f, 0.16810317f, 0.00903765f, 0.03274154f, 0.02596630f, 0.09162278f, 0.04345929f, 0.19184607f, 
    0.11230605f, 0.03283537f, -0.06011931f, 0.00986225f, -0.33740935f, 0.08135428f, -0.31405506f, 0.05962794f, 
    -0.00157748f, 0.08481377f, -0.03054913f, -0.05281474f, -0.06108293f, 0.07159496f, 0.04278534f, 0.00607944f, 
    -0.07168909f, -0.03535781f, 0.00788274f, -0.05934465f, -0.05620061f, 0.15679152f, -0.20992200f, -0.10601953f, 
    0.40013847f, 0.16727124f, 0.42254832f, 0.17877540f, 0.14153892f, 0.08390860f, 0.02616460f, 0.01607915f, 
    -0.02936492f, 0.07718460f, 0.02779039f, 0.00862840f, 0.02900648f, 0.03300007f, 0.06019017f, -0.08271274f, 
    0.00797124f, -0.15505488f, 0.03666544f, 0.00198093f, -0.14555605f, -0.20686874f, -0.24400316f, -0.03323318f, 
    0.05324898f, 0.30210489f, 0.15843780f, 0.08894563f, -0.13816978f, 0.07728297f, 0.06038390f, -0.08076531f, 
    0.00148533f, 0.10169200f, 0.16506299f, 0.09101564f, 0.13514033f, -0.01846279f, -0.13457701f, -0.03245410f, 
    0.39384907f, 0.30058312f, -0.38963977f, 0.24324468f, 0.37503859f, 0.07463999f, 0.10628705f, 0.14994898f, 
    0.01926786f, 0.13445053f, 0.12397301f, 0.09720951f, 0.00460320f, -0.06090504f, -0.08011320f, 0.03886643f, 
    0.02579806f, 0.19719808f, 0.10134449f, -0.04416005f, 0.24852027f, -0.10191037f, 0.35804421f, 0.27923551f, 
    -0.22615924f, -0.02926474f, -0.02345492f, 0.18022396f, -0.04505204f, 0.03776387f, 0.06606316f, 0.06229134f, 
    -0.06376934f, -0.10185598f, 0.03437085f, 0.05731626f, 0.02101268f, 0.05663152f, 0.03352471f, 0.02810332f, 
    -0.09451996f, 0.11679653f, 0.19926326f, -0.10951327f, -0.00009815f, 0.05238178f, 0.09355081f, -0.12943824f, 
    0.02262008f, -0.03642373f, 0.05111500f, 0.02980224f, 0.03807557f, -0.00591473f, -0.02120435f, -0.06664368f, 
    0.04495979f, 0.01082690f, -0.14682539f, 0.14807807f, -0.15588407f, 0.02079399f, 0.27952790f, -0.21228051f, 
    0.25657678f, 0.10894243f, -0.20217483f, -0.00783405f, 0.22695763f, -0.04254600f, 0.08053870f, -0.01951460f, 
    -0.02513969f, -0.06158094f, 0.05479765f, 0.01482371f, 0.06434972f, 0.19431755f, 0.00197634f, 0.12124448f, 
    0.11408200f, -0.03218540f, -0.38219556f, 0.07010477f, -0.17060743f, -0.06860589f, 0.10272501f, -0.03133205f, 
    0.10671268f, -0.11172868f, 0.08224283f, 0.09416746f, 0.02044786f, 0.01665276f, 0.06010011f, -0.05861235f, 
    0.04572747f, -0.00575820f, 0.06306165f, 0.06719475f, -0.26930133f, -0.04965340f, 0.17870508f, -0.08745584f, 
    -0.19623339f, 0.05064487f, -0.02901338f, 0.15346681f, -0.03353987f, 0.03528084f, 0.10718884f, -0.05846705f, 
    0.05617839f, -0.00601440f, -0.06409659f, 0.10449021f, -0.05336890f, -0.07660290f, -0.08649950f, -0.08594806f, 
    -0.52456522f, -0.22004256f, 0.22515048f, -0.08621992f, 0.10349876f, -0.01538668f, 0.11134116f, 0.00072885f, 
    0.08561174f, 0.08722173f, 0.11246496f, 0.12876569f, 0.05888065f, 0.22646882f, -0.08226165f, -0.24847516f, 
    -0.00517987f, 0.01977386f, -0.07385701f, 0.06269646f, -0.01657526f, 0.34221011f, 0.20509127f, 0.11301196f, 
    -0.01942383f, 0.20376526f, 0.00262954f, 0.06496251f, 0.09543966f, 0.01189459f, -0.07128783f, 0.01396875f, 
    -0.01940507f, -0.10909968f, 0.08558767f, 0.17778191f, -0.01079292f, -0.10251160f, 0.04784529f, 0.07542562f, 
    0.31391245f, -0.12201003f, 0.16521843f, 0.21012245f, 0.03740279f, -0.03776138f, 0.10617672f, -0.06327447f, 
    0.03490078f, 0.11052266f, 0.07587367f, 0.05908276f, 0.00475561f, 0.15789287f, 0.03426083f, 0.04716101f, 
    0.03417190f, 0.03033539f, 0.19391581f, -0.02288643f, 0.29860443f, -0.03356840f, 0.05640397f, 0.01416493f, 
    0.15068357f, -0.10033507f, -0.02800001f, -0.07603642f, 0.11475667f, -0.10116275f, -0.09432516f, -0.04024212f, 
    0.11217557f, -0.10612815f, 0.08256157f, 0.16042435f, -0.04796549f, -0.03472441f, -0.01426837f, -0.12160948f, 
    0.34253126f, 0.35267934f, -0.43743244f, 0.25829774f, -0.22056234f, -0.11049285f, -0.00466116f, 0.05183021f, 
    0.08143739f, 0.06472389f, -0.01076785f, 0.05398186f, -0.03534792f, 0.13369533f, 0.01325145f, 0.07878133f, 
    0.02998400f, 0.18364766f, 0.15342979f, 0.05575505f, -0.15827852f, -0.22159407f, 0.15167236f, 0.00232985f, 
    0.24933037f, 0.20874910f, -0.07965700f, -0.07679985f, 0.18588227f, 0.03255638f, -0.01382769f, 0.17256252f, 
    0.05696055f, 0.28604385f, -0.06625914f, -0.14703467f, 0.11249394f, 0.05712564f, 0.13890257f, 0.00436452f, 
    -0.17267099f, 0.28951257f, -0.09144375f, -0.01596409f, -0.30851310f, 0.05249936f, -0.18246099f, -0.11434056f, 
    -0.03120774f, -0.16259314f, -0.08419167f, 0.11672589f, 0.05191565f, -0.10934727f, 0.01291709f, 0.06313758f, 
    0.03005776f, -0.05434010f, -0.04629410f, 0.07609461f, 0.40035823f, -0.03064293f, 0.44009092f, -0.18068671f, 
    0.09671014f, 0.01381767f, 0.05629024f, -0.16711280f, 0.05555586f, -0.05105862f, -0.07717256f, 0.00372779f, 
    0.04757231f, 0.25318682f, 0.13005823f, 0.01223050f, 0.03274689f, -0.06177631f, 0.02067111f, 0.06577145f, 
    -0.16975412f, 0.10847990f, -0.09912808f, 0.04685911f, -0.05259082f, -0.05901157f, 0.04268715f, -0.05395634f, 
    -0.04320658f, -0.14035383f, -0.01932138f, -0.03119282f, -0.11541466f, -0.05169063f, -0.09931538f, -0.02679727f, 
    -0.01402016f, 0.00460849f, -0.22035697f, -0.01660132f, 0.16383991f, 0.00331856f, -0.08686838f, 0.03096068f, 
    0.03720752f, -0.20862977f, -0.01666111f, -0.03495951f, -0.06958809f, -0.01040681f, -0.21168102f, -0.00983652f, 
    0.00683477f, 0.05410079f, 0.00193321f, -0.06525347f, 0.00308381f, 0.01904545f, 0.02382651f, -0.15865491f, 
    0.24315651f, -0.50137639f, 0.39097959f, -0.17801434f, -0.42189649f, 0.00569789f, -0.05869569f, -0.25027278f, 
    0.11783236f, 0.02480787f, -0.09352493f, 0.01258119f, -0.15241455f, 0.09861118f, 0.01795670f, -0.06375024f, 
    -0.05158471f, -0.13082489f, 0.20182170f, 0.07149170f, -0.04134667f, 0.31056887f, 0.05033515f, -0.13241187f, 
    0.12263872f, -0.04326995f, -0.00905384f, 0.12010694f, 0.00026867f, 0.05509936f, -0.04317392f, -0.12345965f, 
    0.04923261f, -0.08467901f, -0.01666575f, -0.04102355f, -0.10989907f, 0.13331611f, 0.07249149f, -0.10888524f, 
    0.00848226f, 0.00371004f, 0.03046075f, 0.00761112f, 0.04982884f, -0.01664809f, 0.02439620f, 0.04712202f, 
    0.04419868f, -0.04483933f, 0.00554155f, -0.03644088f, -0.02905836f, -0.00214180f, -0.01261848f, -0.03482503f, 
    -0.02002777f, -0.01358951f, -0.06028629f, 0.00910054f, 0.01763049f, -0.01219380f, -0.04825750f, -0.01927191f, 
    -0.03558837f, -0.02336130f, -0.06136241f, 0.00495845f, 0.04592765f, 0.04787401f, 0.02417398f, -0.02328120f, 
    -0.02385593f, 0.01150225f, -0.00631399f, 0.00179014f, 0.02950616f, 0.04633802f, -0.03380558f, -0.03829992f, 
    0.02317849f, 0.04967803f, 0.04092070f, -0.05616309f, -0.04125108f, 0.03855956f, -0.02757294f, -0.04585125f, 
    -0.01986980f, -0.04132979f, 0.03756213f, 0.01434450f, 0.03948270f, -0.00249698f, -0.04670269f, 0.00496266f, 
    -0.00118992f, -0.01167722f, -0.03089638f, -0.01647586f, -0.01350193f, 0.04132911f, 0.02125881f, -0.01614637f, 
    0.04798273f, 0.02136018f, -0.02848001f, -0.00305912f, -0.01496918f, 0.00648582f, 0.00106143f, -0.04903642f, 
    0.01912302f, -0.05589950f, 0.01336785f, 0.00665043f, -0.05495361f, 0.01237118f, 0.03577705f, 0.03383214f, 
    -0.02640001f, -0.03026854f, 0.01818800f, -0.02434932f, 0.03922208f, -0.02929567f, 0.00951563f, -0.01485771f, 
    -0.00742622f, 0.01052123f, 0.02580382f, -0.02865782f, -0.00938888f, -0.05842417f, -0.05538011f, -0.00448900f, 
    -0.04203212f, -0.02198566f, -0.00958884f, -0.01066822f, 0.01961588f, -0.01713983f, 0.04574100f, 0.00274934f, 
    0.03788551f, -0.00308561f, 0.04839432f, 0.01452366f, 0.02606412f, -0.05195864f, -0.03485773f, 0.01730251f, 
    -0.02305071f, 0.03403648f, -0.04575675f, -0.03218923f, -0.03537288f, 0.00662686f, 0.03753722f, -0.05536046f, 
    0.02785462f, 0.02090577f, 0.03184067f, -0.02557890f, 0.00292832f, -0.00580600f, -0.02768160f, -0.02644196f, 
    0.00058004f, -0.01783455f, 0.00035372f, -0.02674972f, 0.03725255f, 0.03165963f, -0.00336849f, 0.02187387f, 
    0.00417552f, -0.05363787f, 0.03100855f, -0.05487216f, 0.02623449f, 0.05427888f, 0.04439515f, 0.02518705f, 
    -0.02155391f, 0.01643529f, -0.03250150f, 0.01835573f, 0.02667938f, -0.05806232f, -0.01473121f, 0.01166733f, 
    0.02527870f, -0.00302334f, 0.00198090f, -0.01397502f, -0.04235983f, -0.02188926f, 0.04334967f, -0.04488837f, 
    -0.04917353f, -0.03504046f, -0.04059249f, 0.02150073f, -0.01182325f, -0.04589729f, 0.04003742f, -0.04540134f, 
    -0.01667695f, 0.00762944f, 0.00633379f, 0.02243323f, -0.03276030f, 0.03064886f, -0.03458939f, -0.03903569f, 
    0.01687897f, 0.04850933f, 0.00223924f, 0.03247476f, -0.03418261f, -0.04141084f, 0.04598225f, -0.03222565f, 
    0.05354355f, 0.00987386f, -0.00286693f, -0.04005009f, -0.04733062f, 0.01350833f, -0.04495776f, 0.03870913f, 
    0.01605789f, 0.04351456f, 0.04706723f, 0.02409970f, -0.02995580f, 0.01706650f, 0.02899151f, -0.01789115f, 
    -0.04434771f, -0.04110829f, -0.04259029f, 0.02966963f, -0.05600386f, 0.01705188f, 0.03446248f, 0.04467212f, 
    0.04138453f, 0.02301137f, 0.04863901f, 0.02984114f, -0.00626231f, -0.02785850f, -0.00853960f, 0.00972417f, 
    -0.04334873f, 0.03936358f, 0.06159038f, -0.00912998f, 0.01269723f, -0.01838771f, -0.03614764f, -0.05345190f, 
    0.02498597f, 0.03319930f, -0.03183332f, 0.03849741f, 0.01437718f, -0.02454292f, -0.06068112f, -0.00330372f, 
    0.00177813f, -0.00373019f, -0.06346089f, -0.00416651f, -0.02526527f, 0.03632790f, 0.01753422f, -0.02300162f, 
    0.02122882f, -0.01865337f, 0.00630776f, -0.04576297f, -0.00456567f, -0.03152793f, 0.01622663f, -0.00164094f, 
    0.02377834f, -0.03954156f, -0.03659631f, -0.01947740f, -0.04299314f, 0.00925640f, -0.03576857f, 0.02319287f, 
    0.00015032f, -0.02178853f, -0.01932365f, -0.03139801f, -0.03080306f, -0.01743711f, 0.04817047f, -0.02821148f, 
    -0.03998110f, 0.01626365f, 0.03810162f, 0.04306254f, 0.00569974f, -0.02450415f, -0.06138581f, -0.04953199f, 
    0.03831302f, -0.00059213f, 0.02359445f, 0.03456881f, -0.04263383f, 0.00105644f, 0.02421692f, -0.06069958f, 
    -0.01843682f, -0.04312908f, -0.01140336f, 0.05012742f, -0.03448367f, -0.04065509f, -0.05588584f, -0.04277891f, 
    0.02915622f, -0.05582821f, -0.01885821f, -0.01273151f, -0.03333126f, -0.02345934f, -0.01834542f, -0.03117201f, 
    -0.05738512f, -0.00462966f, -0.05317661f, 0.01556031f, 0.02948064f, -0.02056561f, 0.04291987f, -0.01299089f, 
    -0.00027795f, -0.02191515f, 0.01720729f, 0.00745959f, -0.02213585f, 0.02780764f, -0.05277383f, -0.02519925f, 
    0.00269009f, -0.04514538f, 0.04143471f, 0.00348769f, -0.04692329f, 0.04617471f, 0.01413464f, -0.04409806f, 
    0.23900346f, 0.06970203f, 0.19320568f, 0.00122433f, 0.04110339f, 0.16478531f, 0.06684158f, 0.07961347f, 
    0.10062346f, 0.09886061f, 0.05878175f, -0.01164008f, -0.00853083f, 0.07963379f, -0.00495885f, 0.10343812f, 
    -0.04814793f, 0.00314185f, 0.05715410f, 0.05025114f, 0.45990828f, 0.17335351f, 0.22736245f, 0.08158566f, 
    0.14800106f, -0.08498326f, 0.07470063f, 0.07557346f, 0.01472824f, 0.11086322f, -0.03105233f, -0.01957559f, 
    0.01019934f, 0.03186158f, -0.06958508f, 0.03969284f, -0.00510739f, 0.00899421f, 0.02910786f, 0.16834605f, 
    -0.30960006f, -0.19531430f, -0.00533902f, 0.18037881f, 0.11159378f, -0.01922662f, -0.06662671f, -0.00735244f, 
    0.09623738f, 0.08410962f, -0.03886489f, 0.04625368f, 0.18645954f, -0.09186745f, -0.02281679f, -0.01948793f, 
    0.00779352f, 0.02933136f, 0.17437167f, -0.04790837f, 0.57386070f, -0.08918742f, -0.16496024f, 0.06428662f, 
    0.12825854f, 0.07345464f, 0.03603532f, 0.00384010f, 0.20686026f, -0.04217832f, -0.14646678f, 0.04025652f, 
    -0.04990443f, -0.02230841f, 0.15617341f, -0.08133107f, 0.07968719f, 0.06908714f, 0.12278115f, -0.07726671f, 
    0.52706629f, 0.13816376f, 0.02743880f, -0.09260868f, -0.13574299f, 0.02486452f, -0.00847807f, 0.02660586f, 
    -0.06600565f, -0.21615031f, -0.16330017f, -0.06364651f, -0.17922206f, -0.06699485f, -0.09926852f, 0.06123900f, 
    -0.06195368f, 0.03312851f, 0.06910695f, 0.14454424f, 0.23544714f, 0.01919443f, -0.01131408f, -0.00624481f, 
    0.11678433f, -0.00799908f, 0.05725533f, -0.03115193f, 0.02736429f, 0.17997243f, -0.06374531f, -0.00326041f, 
    -0.04524942f, 0.11107754f, 0.14803530f, 0.07086332f, 0.21143787f, 0.11507127f, 0.03761557f, 0.12666111f, 
    -0.30329990f, 0.02752377f, 0.17406049f, -0.04010926f, -0.14305620f, -0.03599707f, -0.09179194f, 0.01300123f, 
    0.00268587f, 0.00491295f, -0.03509407f, -0.07162800f, 0.09753124f, -0.04068498f, -0.00744519f, 0.03919756f, 
    0.02803761f, -0.03370767f, -0.12331301f, 0.11111154f, -0.27576643f, -0.09281220f, -0.12338474f, 0.12432969f, 
    -0.29438794f, 0.02458201f, -0.00696420f, 0.01755811f, 0.09387002f, 0.00436814f, 0.17744535f, -0.01365163f, 
    -0.05976797f, 0.08704887f, 0.04889762f, -0.10870407f, -0.00356314f, 0.03982303f, 0.03900839f, -0.16898847f, 
    -0.54930383f, -0.15308763f, 0.23488805f, 0.27676547f, 0.21591337f, -0.15146023f, -0.05472395f, -0.05051296f, 
    0.20755714f, 0.12174846f, -0.08643348f, 0.14354074f, -0.01041433f, 0.01127148f, 0.03552137f, 0.02951854f, 
    0.06670935f, -0.11041076f, 0.02253338f, 0.07192801f, 0.27683926f, 0.07769220f, 0.11825927f, -0.15308081f, 
    -0.28134066f, -0.05172853f, -0.03142040f, 0.04934197f, -0.10084059f, -0.04689028f, -0.02987152f, 0.06380666f, 
    0.11741328f, -0.17125900f, 0.04569538f, -0.11751284f, 0.04865409f, 0.06194523f, -0.03920320f, -0.05707406f, 
    0.22818659f, -0.15702774f, 0.00184894f, -0.03803162f, 0.28089681f, -0.11453027f, 0.12552904f, 0.15079564f, 
    -0.00443112f, 0.21254648f, 0.02081170f, -0.07048805f, 0.02882450f, 0.01507719f, 0.01754572f, 0.11622930f, 
    0.04371991f, -0.01006254f, 0.03552037f, 0.01248754f, -0.33787325f, -0.02319054f, 0.24096426f, 0.09347834f, 
    -0.22514234f, 0.07893799f, 0.01590418f, 0.00505175f, -0.05932635f, -0.09371015f, -0.06105836f, -0.06637534f, 
    0.00313194f, 0.01613430f, 0.03229316f, -0.00916016f, 0.06785455f, 0.03924518f, 0.02815032f, -0.09312526f, 
    0.35743731f, -0.02715605f, -0.25791046f, -0.01936854f, 0.22719286f, 0.23149459f, 0.05800379f, -0.07125168f, 
    0.09039624f, 0.16629378f, 0.01153421f, 0.01603180f, 0.05999631f, 0.03131932f, 0.03545914f, 0.10610539f, 
    -0.07118513f, -0.04323432f, 0.00200070f, 0.22192439f, -0.28193328f, -0.10083302f, 0.05201664f, -0.05043240f, 
    -0.12055182f, -0.12723289f, -0.14467220f, -0.04796857f, 0.02136891f, -0.06185075f, -0.02446853f, 0.10179865f, 
    -0.01699161f, -0.02872165f, -0.03941129f, -0.07053035f, -0.16197577f, -0.00235889f, -0.04560088f, -0.09682825f, 
    -0.39214179f, 0.13549501f, 0.36244577f, 0.31433454f, 0.38109583f, -0.08020502f, -0.11317451f, 0.13050854f, 
    0.11841580f, 0.21197529f, -0.01082058f, 0.03031520f, 0.02006372f, 0.00130134f, 0.05213238f, 0.09307460f, 
    0.02220296f, 0.00252492f, -0.08865265f, 0.01857506f, -0.01711773f, 0.02980476f, 0.32007319f, 0.17963660f, 
    0.06806397f, 0.06747381f, -0.07761840f, 0.04480790f, 0.08347164f, 0.07097095f, 0.11853120f, 0.07297488f, 
    -0.00484444f, 0.03743939f, -0.11707138f, 0.11379817f, 0.03312538f, 0.07416371f, -0.10920970f, 0.10546564f, 
    0.17771509f, -0.14587387f, -0.30855414f, -0.10092254f, -0.25474229f, 0.03773975f, -0.04053709f, 0.06457012f, 
    -0.06009847f, -0.25324640f, 0.10664650f, 0.02189189f, 0.03623730f, -0.04552240f, -0.00256699f, -0.02954432f, 
    0.04982710f, -0.04934839f, 0.27665982f, 0.00439516f, -0.21158935f, 0.12138010f, -0.04831445f, -0.26754677f, 
    -0.02205769f, 0.31312704f, 0.27941608f, 0.13182408f, 0.09437097f, 0.05151906f, -0.05165201f, -0.03016447f, 
    0.00807359f, 0.01469572f, -0.10077978f, 0.12549986f, 0.11637792f, 0.04400111f, 0.12911138f, 0.05776814f, 
    0.09165631f, 0.08787532f, 0.05820178f, -0.00715405f, 0.13447592f, -0.15858540f, -0.18132770f, -0.10984546f, 
    -0.05656968f, -0.12934044f, -0.08516850f, 0.17165491f, -0.17090665f, -0.00246657f, 0.02928589f, -0.08176363f, 
    -0.07829621f, 0.10908005f, -0.03289901f, -0.07246770f, -0.41343340f, 0.06015646f, -0.08116262f, -0.11796485f, 
    0.01141012f, -0.13275281f, -0.13284560f, 0.07233126f, 0.03503381f, 0.09653981f, 0.13896945f, 0.12058019f, 
    0.07094119f, 0.07701969f, -0.03006705f, -0.09258766f, -0.08154593f, 0.03062109f, 0.05778167f, -0.00896211f, 
    0.02683557f, 0.02428051f, -0.11376053f, 0.05086751f, 0.19280097f, -0.06934749f, -0.02271127f, -0.16877982f, 
    -0.13330944f, -0.14563762f, 0.33422586f, 0.12572071f, 0.08774971f, 0.04602483f, 0.00435945f, -0.01368505f, 
    -0.07681331f, -0.17524928f, 0.10107966f, -0.05056363f, -0.01243153f, -0.47564465f, -0.25131744f, -0.30406693f, 
    -0.23127078f, -0.03317256f, -0.17244847f, -0.02380717f, -0.01100688f, -0.12974818f, 0.02861549f, -0.04442168f, 
    0.07220607f, 0.09010599f, -0.02949589f, 0.11694777f, -0.05009779f, 0.20379904f, 0.02841952f, 0.05449619f, 
    0.11396801f, -0.01495659f, 0.04116151f, 0.14152482f, 0.19233528f, 0.06834301f, 0.02521048f, 0.04316712f, 
    0.01103678f, 0.00874816f, -0.02424262f, -0.01365151f, -0.09095153f, 0.01351209f, 0.03948573f, 0.17910798f, 
    -0.05463408f, 0.03506551f, 0.10059543f, 0.03337922f, -0.15136908f, 0.16099454f, 0.10659228f, -0.02116719f, 
    0.19135615f, -0.10267407f, -0.05305400f, -0.01591951f, -0.12810561f, -0.09353685f, 0.08640723f, 0.17348818f, 
    0.08240470f, 0.10876398f, 0.13545461f, 0.07284893f, -0.00629703f, 0.30992910f, -0.10362823f, 0.05356185f, 
    0.00603362f, -0.03451113f, 0.06314486f, 0.01958702f, -0.02165012f, 0.06818412f, 0.14014395f, 0.05391929f, 
    -0.00011824f, 0.05171304f, 0.13775545f, 0.14407717f, 0.17337018f, 0.07368287f, 0.30129814f, -0.00479563f, 
    0.07923248f, 0.17472322f, 0.02528783f, 0.04606437f, 0.00790816f, 0.02852191f, 0.01691087f, 0.07124864f, 
    0.16955739f, 0.04721723f, -0.16052279f, -0.00774133f, 0.04247227f, -0.09418906f, 0.17244807f, -0.11414851f, 
    -0.09523162f, 0.08923295f, 0.02023397f, 0.04116259f, 0.00065791f, -0.12419687f, 0.12638760f, 0.06504267f, 
    -0.10310280f, -0.26937956f, -0.14258072f, -0.47999734f, -0.39890283f, -0.08042045f, -0.12966189f, -0.07299744f, 
    0.01288269f, -0.33360991f, 0.03180320f, -0.10965759f, -0.00143583f, 0.16032897f, 0.15527014f, 0.16763446f, 
    -0.00507389f, 0.13052858f, 0.03733528f, 0.21936829f, 0.17872997f, 0.04783569f, -0.08242742f, -0.02440876f, 
    0.13329668f, 0.10472178f, 0.06998388f, 0.07861891f, 0.13289179f, -0.03265955f, -0.02275685f, -0.08353914f, 
    -0.09402283f, -0.02437487f, -0.11331583f, 0.02366551f, 0.00199478f, -0.02236026f, 0.05843785f, -0.01261827f, 
    -0.03268707f, -0.31638083f, 0.00884482f, -0.33555612f, -0.37317237f, -0.15004677f, -0.00293172f, 0.07478908f, 
    -0.04814640f, -0.30152065f, 0.02585482f, 0.08105642f, 0.01997499f, -0.03598674f, -0.02771575f, -0.00658673f, 
    -0.03837857f, 0.03735074f, 0.15266652f, -0.18938030f, 0.05144752f, 0.10601281f, 0.06427928f, 0.01120151f, 
    0.06434222f, -0.02312395f, -0.05313247f, -0.00020319f, -0.02075560f, -0.01648345f, -0.20950426f, -0.22132741f, 
    -0.11244526f, -0.04008395f, -0.14860409f, -0.02887713f, 0.03735166f, -0.01672987f, -0.12196115f, 0.00020065f, 
    0.31068799f, -0.38744503f, 0.09964913f, -0.14335905f, -0.00509416f, 0.25806618f, 0.26528507f, 0.17967989f, 
    0.20064355f, -0.04283915f, -0.08156089f, -0.02693129f, -0.10106514f, -0.09848671f, -0.01457347f, 0.23249860f, 
    0.11345103f, 0.00868737f, 0.17396961f, 0.16562405f, 0.54374808f, -0.09847441f, -0.00984075f, -0.17501464f, 
    -0.16638277f, 0.10288051f, 0.11616407f, 0.05618857f, -0.21342556f, -0.12272491f, -0.00888851f, 0.04621421f, 
    0.04799390f, 0.00059560f, 0.02382829f, 0.04855751f, 0.12068082f, 0.04117212f, 0.23694226f, -0.01834506f, 
    0.10439695f, -0.21593152f, -0.04269065f, -0.02115794f, -0.01690185f, 0.15491270f, -0.00240704f, 0.01689239f, 
    0.14990236f, -0.05401430f, 0.02479152f, 0.07634145f, -0.04380827f, -0.00310259f, 0.11737306f, -0.00510075f, 
    0.04684896f, -0.03823198f, 0.18116561f, 0.12653597f, 0.12138960f, 0.01254640f, 0.04965878f, 0.06030696f, 
    0.11318295f, 0.07992645f, 0.05210706f, 0.07269102f, -0.00563309f, 0.02954908f, 0.01235587f, 0.03479933f, 
    0.00863680f, 0.00542181f, 0.01506091f, 0.04950815f, -0.05107251f, -0.03084501f, 0.09017599f, 0.04619391f, 
    -0.02470111f, -0.06038480f, -0.03425995f, 0.02732885f, 0.18277378f, -0.08479709f, -0.01713599f, -0.05372068f, 
    0.07711033f, -0.02020099f, 0.01856938f, 0.00696258f, -0.07950363f, -0.00285187f, 0.02317031f, 0.08882818f, 
    0.02069551f, 0.18330882f, -0.07292075f, 0.02403972f, -0.50995362f, 0.18553595f, 0.04331470f, -0.05537610f, 
    -0.00928568f, -0.02007311f, -0.00763578f, -0.04803583f, -0.07328840f, 0.13033158f, -0.03449710f, 0.08806805f, 
    0.03442660f, 0.11475555f, 0.00387505f, -0.07046743f, 0.04131621f, 0.07820717f, 0.04284960f, 0.04197664f, 
    -0.14526165f, -0.05604826f, -0.19609842f, -0.15428659f, 0.04403981f, 0.01986132f, -0.16537857f, -0.17948647f, 
    -0.05250177f, -0.04264298f, 0.02701330f, 0.05706822f, 0.01319600f, 0.04430631f, 0.09905816f, 0.05607115f, 
    0.09293481f, -0.10435954f, -0.00428051f, -0.07595619f, -0.11630938f, -0.14927182f, -0.20489354f, 0.18849123f, 
    0.08666231f, 0.07373889f, -0.04125673f, 0.07349838f, -0.11602154f, 0.04988075f, -0.03239733f, 0.05469227f, 
    0.07163271f, 0.18294048f, 0.01797883f, 0.07297341f, -0.02798634f, 0.13392520f, 0.11110002f, 0.05780819f, 
    0.05873632f, 0.18999940f, 0.05360883f, 0.14560647f, 0.16027418f, 0.03723111f, 0.07543405f, 0.01857042f, 
    0.00428891f, 0.01312609f, -0.02437828f, -0.04944656f, -0.00185258f, 0.05611602f, 0.19824484f, 0.13450921f, 
    -0.01121902f, 0.06294393f, -0.03659071f, -0.03703112f, -0.23146366f, -0.01969552f, 0.09879494f, -0.07492296f, 
    0.07266560f, -0.10899737f, 0.00501653f, -0.09228505f, -0.04676257f, 0.03829015f, -0.11611053f, -0.11588369f, 
    0.01960367f, 0.00267387f, 0.11705353f, 0.04130602f, -0.11091505f, 0.08753124f, -0.02405310f, -0.00445557f, 
    -0.23876615f, 0.06902158f, 0.00340069f, 0.22692037f, -0.04390614f, -0.01314308f, 0.10779627f, -0.03532642f, 
    0.02739375f, 0.07270281f, -0.03464284f, -0.04617136f, 0.05773261f, -0.07013898f, 0.01239547f, 0.05015810f, 
    0.10783581f, 0.09366968f, 0.05460167f, 0.00830119f, -0.13959777f, -0.06254100f, 0.19047315f, -0.11189711f, 
    0.04401312f, -0.05222948f, 0.11057109f, 0.00688264f, -0.03181156f, 0.08294222f, 0.01006401f, -0.07380271f, 
    -0.06772159f, 0.02730979f, 0.03814644f, 0.01701681f, 0.07630380f, 0.06713112f, 0.16519779f, 0.12861578f, 
    -0.03844719f, -0.16049504f, -0.11228993f, -0.02083071f, 0.07735271f, -0.01516827f, -0.07712537f, 0.00431944f, 
    0.10304564f, -0.04363085f, 0.12621364f, 0.02192336f, 0.01083293f, 0.03595607f, 0.05260168f, 0.12020256f, 
    0.02947201f, 0.02906357f, 0.01134019f, 0.01495962f, 0.30618498f, 0.03683449f, 0.00888142f, -0.14285029f, 
    -0.00292818f, 0.07743802f, 0.09481094f, 0.01492346f, 0.04115331f, -0.12386291f, -0.17389010f, -0.06194333f, 
    0.00121424f, 0.00001593f, 0.10989595f, -0.12604141f, 0.10068206f, 0.08313978f, 0.06450476f, -0.01843920f, 
    -0.17027722f, -0.23689531f, -0.06458067f, 0.07025126f, 0.02578230f, -0.07676135f, -0.01060466f, 0.04735295f, 
    0.02158000f, -0.04953004f, 0.00940630f, 0.02863718f, -0.03871322f, -0.06195651f, 0.03759249f, 0.04318558f, 
    0.10100640f, 0.11034611f, 0.13420297f, -0.02290321f, -0.00705864f, -0.00309949f, -0.07161561f, -0.05676913f, 
    -0.13849410f, -0.04284380f, -0.08735128f, -0.08448593f, -0.05476575f, -0.02961564f, -0.15627061f, -0.17517976f, 
    -0.10721353f, -0.08705419f, -0.07772426f, 0.05173415f, 0.07304975f, -0.08388408f, -0.08556849f, 0.03714030f, 
    0.51586437f, -0.30715644f, 0.14911297f, 0.01168012f, 0.38482681f, 0.03479948f, 0.21919139f, 0.00239377f, 
    0.10405147f, -0.01992610f, -0.04626039f, 0.02038430f, -0.05997319f, -0.04993462f, 0.08072311f, 0.00142719f, 
    -0.00850945f, 0.08532572f, 0.10620996f, 0.12020723f, 0.15843932f, -0.10358589f, -0.05570905f, 0.37441394f, 
    -0.17109647f, 0.07717545f, 0.01412049f, 0.10476082f, 0.04454856f, -0.03017966f, -0.03435058f, 0.05195670f, 
    0.00578824f, 0.04820229f, 0.10784972f, 0.02846211f, -0.05494231f, 0.18787402f, 0.14632973f, 0.01639552f, 
    0.02038211f, 0.37082431f, 0.17762744f, 0.01239241f, -0.16388834f, 0.01022266f, 0.01745160f, 0.07619290f, 
    0.04372494f, 0.02320047f, 0.01356376f, -0.07876073f, 0.08239169f, -0.00445281f, -0.05957419f, 0.00505017f, 
    -0.04211293f, 0.05026981f, -0.02179705f, 0.04960329f, -0.18483256f, 0.03339346f, -0.03620112f, 0.21449155f, 
    -0.16373661f, -0.07275902f, -0.08228704f, -0.04713155f, 0.06715675f, 0.09104530f, 0.02540206f, 0.02681458f, 
    0.01744436f, -0.05294920f, 0.07793350f, -0.04774278f, 0.07107788f, 0.09884809f, 0.07565986f, -0.09127311f, 
    0.03610317f, 0.00031304f, 0.09728488f, -0.18050651f, -0.22291766f, 0.07499390f, 0.02082957f, 0.13162316f, 
    0.07963894f, 0.20429718f, 0.08168533f, 0.08809894f, 0.07498807f, 0.10839111f, -0.00358825f, -0.04179064f, 
    0.07003014f, -0.14549689f, -0.05151342f, 0.10919106f, 0.47177982f, 0.02231615f, -0.23825699f, 0.11976293f, 
    -0.37633035f, 0.13219206f, 0.08327105f, -0.13650750f, -0.04159668f, -0.09546407f, 0.01424699f, -0.14691857f, 
    0.00948614f, -0.04781230f, -0.00084119f, 0.08801989f, 0.09111671f, 0.07529032f, 0.04519062f, 0.03174395f, 
    -0.16518047f, -0.05248667f, 0.04117764f, 0.01842311f, -0.10653355f, -0.00383739f, 0.04895408f, 0.24697328f, 
    0.11379437f, 0.08864252f, -0.03815086f, 0.03180543f, -0.06353864f, 0.04132996f, -0.04952824f, -0.02337170f, 
    0.06768659f, 0.11369162f, -0.13025835f, -0.03765902f, 0.17131196f, 0.24353290f, 0.18701431f, -0.17890665f, 
    -0.08526126f, -0.03576137f, 0.02056544f, -0.07196193f, 0.14984678f, 0.07678717f, 0.04974255f, -0.13073370f, 
    0.05221847f, -0.08085570f, 0.06698553f, -0.00197341f, -0.08399400f, -0.07483364f, -0.00313026f, 0.07275285f, 
    -0.10008863f, 0.05695248f, -0.22157051f, -0.01756879f, 0.04527598f, -0.09898703f, 0.14477611f, -0.02450605f, 
    0.02816960f, -0.09010241f, 0.00191814f, 0.18431343f, -0.08713721f, 0.03362641f, -0.10477618f, -0.14530964f, 
    0.08218119f, 0.02451129f, -0.02353877f, -0.00914525f, 0.29094574f, -0.03140434f, 0.03057553f, 0.13498913f, 
    0.00833700f, -0.01059895f, -0.01966533f, 0.04033795f, -0.08822817f, -0.04191868f, 0.01000918f, 0.10798988f, 
    -0.03378296f, 0.01014577f, -0.25678337f, -0.06686799f, 0.00390730f, -0.25508377f, 0.06142487f, 0.01891389f, 
    0.37368733f, -0.38492164f, -0.02636707f, -0.21783023f, 0.08927307f, -0.10555575f, -0.03084284f, 0.00496916f, 
    0.02040674f, -0.06326661f, -0.02546609f, -0.06549664f, -0.04177287f, -0.01205393f, 0.05176593f, 0.02452840f, 
    -0.04650443f, 0.01484475f, 0.02245867f, 0.03972781f, -0.06069733f, 0.12856792f, -0.27410752f, 0.16713373f, 
    -0.10144634f, -0.04356984f, 0.15809271f, 0.00815343f, 0.01408133f, -0.07010238f, -0.09360402f, 0.05842908f, 
    -0.00066708f, -0.01681800f, -0.12451833f, -0.00347494f, -0.11654456f, 0.03730629f, -0.11165512f, -0.05993421f, 
    0.05416828f, 0.27714214f, 0.08262537f, 0.08222831f, -0.16390501f, 0.09468231f, 0.09570517f, 0.01866540f, 
    -0.08085709f, 0.13969983f, -0.01379229f, -0.06633288f, -0.04431951f, -0.04355461f, -0.07267123f, -0.07353110f, 
    0.05421689f, 0.06862939f, -0.02894044f, -0.04205431f, -0.09812254f, 0.12977919f, -0.08871546f, 0.03480421f, 
    -0.15826319f, 0.00712310f, 0.06377029f, 0.12119716f, -0.02875395f, 0.04006968f, 0.05504136f, 0.05792411f, 
    0.00176282f, 0.04357999f, -0.01843130f, 0.12504803f, 0.00944769f, -0.12043960f, 0.00514062f, -0.02377374f, 
    0.21533251f, 0.21719857f, 0.11066417f, -0.05426947f, -0.13301979f, 0.09470422f, -0.02781269f, 0.04448799f, 
    0.08348213f, 0.22770762f, -0.04238735f, -0.02732901f, 0.06994187f, 0.04497427f, 0.01419181f, -0.04156266f, 
    -0.00628835f, -0.07802778f, -0.16481428f, 0.03815942f, -0.02722899f, 0.03059269f, -0.01789173f, 0.09011772f, 
    0.11508773f, -0.00873464f, 0.02337310f, -0.01408286f, -0.02176344f, -0.02980447f, 0.08551594f, 0.05561517f, 
    0.07345366f, 0.05528372f, 0.07806577f, -0.09225502f, -0.07613891f, -0.00198055f, 0.05356009f, -0.10493921f, 
    -0.30223310f, 0.41742921f, -0.44827962f, -0.07330193f, -0.31216928f, -0.07569630f, -0.09572063f, -0.22987078f, 
    -0.12558651f, 0.12726881f, 0.01660795f, 0.02014499f, 0.03361588f, 0.10252653f, 0.06953261f, 0.00995763f, 
    0.10727782f, -0.05813185f, 0.03653866f, 0.07385331f, -0.10049815f, 0.03566840f, 0.10134946f, -0.18807431f, 
    0.15353993f, -0.02613246f, 0.04925347f, 0.02513988f, 0.02876306f, 0.05354245f, 0.14647925f, -0.00758149f, 
    -0.06784289f, 0.00002754f, 0.04880422f, -0.02703447f, -0.07362591f, -0.05326498f, -0.03917027f, -0.04559335f, 
    -0.16032578f, 0.18061389f, -0.19640242f, 0.01927421f, 0.03673847f, -0.16134407f, 0.03399849f, 0.04800663f, 
    -0.02612823f, 0.13916945f, 0.02364135f, -0.01982236f, -0.00758492f, -0.03828569f, 0.01682199f, -0.00845125f, 
    -0.08504284f, 0.00050233f, -0.00570818f, -0.01514234f, -0.10815112f, -0.03280496f, -0.28416762f, 0.01330874f, 
    0.04600836f, 0.09088756f, 0.08506973f, -0.01678206f, 0.07438386f, 0.04603580f, -0.05989414f, -0.06952669f, 
    -0.03265323f, 0.02452240f, 0.01701209f, 0.01098246f, 0.05634253f, 0.01394181f, 0.00842304f, 0.07974017f, 
    0.09407276f, 0.31454924f, 0.13847837f, -0.18485056f, -0.24673814f, -0.05913065f, -0.18192023f, -0.02505892f, 
    -0.14958958f, -0.06156469f, 0.08139649f, -0.09339862f, 0.09087700f, 0.09306946f, -0.02597496f, -0.03985843f, 
    -0.13158812f, -0.18379192f, 0.02092708f, 0.00413144f, 0.30316296f, 0.17306653f, 0.61319810f, 0.28641108f, 
    0.34281641f, -0.20082046f, -0.21080959f, -0.18922460f, 0.05852908f, -0.03117269f, 0.14359505f, 0.10131338f, 
    0.00803850f, -0.01173790f, 0.03794629f, 0.06770764f, 0.01808270f, 0.04537555f, -0.01524604f, 0.04989478f, 
    0.09227102f, 0.08214345f, -0.08110154f, 0.21905175f, -0.16568841f, -0.18628106f, -0.13098587f, -0.05926949f, 
    0.01374632f, 0.05842577f, 0.09862576f, 0.08031047f, -0.04777956f, -0.12261783f, -0.12477052f, -0.05416258f, 
    -0.06331889f, -0.01295679f, 0.02094530f, 0.04478567f, -0.02167456f, -0.13993257f, 0.14141028f, 0.04394897f, 
    -0.08497124f, -0.08741552f, 0.01517339f, 0.00448484f, 0.00036305f, -0.01251050f, 0.04807783f, -0.08741768f, 
    0.00059541f, 0.06429059f, 0.03431434f, 0.06248285f, 0.18173848f, 0.05008899f, -0.01961505f, 0.09891950f, 
    0.01829579f, -0.12840766f, -0.02726077f, -0.16409987f, -0.01976184f, 0.13359414f, -0.06090425f, -0.08241288f, 
    0.01869614f, 0.02670090f, 0.04630326f, -0.00087960f, -0.00987471f, 0.05378768f, -0.04160342f, 0.07197523f, 
    0.03146384f, 0.02958437f, 0.02775157f, 0.07910739f, 0.17724843f, 0.16707774f, -0.12080903f, -0.14463902f, 
    -0.00964680f, -0.09842342f, -0.22119126f, -0.09514557f, -0.03149493f, 0.01377002f, 0.08148943f, 0.11918433f, 
    0.15619618f, 0.15670756f, -0.02258175f, 0.04320527f, 0.26975805f, 0.14278594f, 0.14818981f, 0.02235747f, 
    -0.01090334f, 0.17934057f, 0.24818590f, -0.14926371f, -0.06976037f, -0.02662572f, -0.03828952f, 0.01031550f, 
    -0.04662750f, -0.00587728f, 0.12144138f, 0.03122209f, 0.11702226f, 0.12848361f, 0.05671223f, 0.07154493f, 
    -0.07993112f, -0.01992634f, 0.10442635f, 0.13887268f, 0.03917290f, -0.14774181f, -0.17709680f, 0.12567301f, 
    0.05318069f, 0.09043679f, -0.14784533f, -0.06781920f, -0.05196508f, -0.04274400f, 0.08471992f, 0.07392534f, 
    0.01876958f, 0.03019090f, 0.15382650f, 0.08120182f, -0.10125405f, -0.20519352f, -0.07252604f, -0.00925322f, 
    -0.12666941f, -0.06664942f, 0.03891896f, 0.11739744f, -0.08278340f, 0.03749874f, 0.05801557f, 0.03691170f, 
    -0.02694918f, 0.04020098f, 0.00981815f, 0.00859482f, -0.00835369f, 0.05950841f, 0.14177337f, 0.09783015f, 
    0.03300052f, 0.08412466f, -0.00425181f, 0.08575169f, -0.32989568f, -0.18479051f, -0.21808159f, 0.14740498f, 
    0.08292207f, -0.04451077f, -0.04548781f, -0.02627558f, -0.21491976f, 0.04426595f, 0.05885927f, -0.07697383f, 
    -0.04526845f, -0.09297792f, 0.08595441f, 0.03076012f, -0.10492148f, -0.07682617f, 0.01830099f, 0.03571508f, 
    -0.04939007f, 0.16678300f, 0.12907897f, 0.06369855f, -0.07264543f, -0.05555018f, -0.00837991f, -0.03675373f, 
    0.03463519f, 0.08798057f, -0.03470822f, 0.01940621f, 0.07819846f, -0.00870778f, -0.00088492f, 0.04151973f, 
    0.05722805f, -0.09649168f, 0.04625702f, 0.00113503f, -0.09436091f, -0.18276754f, -0.25920200f, -0.15003841f, 
    0.15532354f, -0.02808198f, -0.10826083f, -0.03437780f, -0.12639605f, 0.01015501f, -0.05934016f, -0.03327716f, 
    0.06448449f, 0.03647743f, 0.12232239f, 0.05199559f, -0.05547855f, -0.15796167f, -0.02109531f, -0.03957545f, 
    -0.42584813f, 0.13319148f, -0.12473052f, 0.05145366f, 0.00155016f, 0.08872176f, 0.09268858f, 0.08964882f, 
    -0.06993061f, 0.02711898f, 0.00204354f, -0.12848125f, -0.01369004f, -0.08425307f, 0.00883183f, 0.10310249f, 
    0.14261758f, 0.11934508f, -0.07892932f, 0.10142380f, -0.45953143f, -0.04129293f, -0.25769660f, -0.33822078f, 
    0.06456558f, -0.01577382f, 0.02888266f, -0.10925210f, 0.06134361f, 0.12649816f, -0.01986635f, -0.00443622f, 
    -0.09956588f, 0.04574032f, 0.00199328f, 0.12631108f, 0.24443814f, -0.01688446f, 0.08115832f, 0.13403757f, 
    -0.25499338f, 0.01465543f, -0.12378033f, -0.15406720f, 0.22005051f, 0.04767069f, -0.01112213f, 0.02481398f, 
    0.12675329f, 0.09385248f, -0.02570445f, -0.07888974f, 0.05507771f, 0.05790656f, -0.05194717f, 0.03142348f, 
    -0.11079749f, -0.05297065f, 0.05330152f, -0.10656961f, 0.20847088f, -0.14026141f, -0.44415471f, -0.07380690f, 
    0.26330340f, -0.11007792f, 0.07909524f, 0.13267635f, -0.13946047f, 0.02867865f, -0.01334380f, -0.00425229f, 
    -0.02906231f, 0.06642117f, 0.01645196f, -0.01521608f, -0.13651437f, 0.03119523f, 0.03420544f, 0.02200924f, 
    0.13725986f, 0.25112244f, 0.10104433f, 0.10863274f, 0.04640166f, -0.02863896f, 0.01864895f, -0.08441953f, 
    0.01530525f, -0.05190879f, 0.09479354f, -0.05904942f, 0.03768460f, -0.04498693f, -0.01018071f, 0.00773091f, 
    -0.09955241f, 0.07615707f, 0.01385410f, -0.16935121f, -0.22314939f, 0.26049760f, 0.62069929f, 0.26460245f, 
    0.16427502f, 0.03759007f, -0.05694391f, -0.19028786f, -0.15201707f, 0.10385162f, -0.10138019f, 0.05348004f, 
    0.11652008f, 0.03992622f, 0.01418739f, -0.03179970f, -0.10166346f, -0.08570731f, -0.01255598f, 0.00799978f, 
    -0.30318496f, -0.08772242f, -0.11404421f, -0.09759302f, 0.13078053f, 0.01764551f, -0.02108148f, -0.09756833f, 
    -0.05974256f, -0.01412641f, -0.01929305f, 0.05823918f, -0.10157099f, 0.02346358f, -0.10177618f, 0.06838324f, 
    -0.14321977f, -0.10180241f, -0.05956963f, -0.02695999f, -0.06591617f, -0.25945017f, -0.31782269f, 0.39522275f, 
    0.06182079f, -0.08777647f, -0.00564039f, 0.10969957f, -0.07824893f, 0.06644387f, -0.05304234f, 0.00480192f, 
    0.04167259f, 0.14443091f, 0.01937844f, 0.15468483f, 0.24072564f, 0.07849902f, 0.25400603f, 0.20252417f, 
    0.26422960f, -0.08385845f, 0.09686439f, 0.03653029f, 0.11244254f, -0.00425326f, 0.04631856f, 0.14435561f, 
    0.00845686f, 0.04913238f, 0.09758849f, 0.01147488f, 0.08746199f, -0.02976056f, 0.12461625f, -0.01382275f, 
    0.08000641f, 0.06436706f, 0.01931487f, 0.02499269f, -0.10827267f, 0.06497661f, -0.07941192f, -0.22352949f, 
    -0.02586842f, -0.05163597f, -0.09097709f, -0.03870459f, 0.10091383f, -0.02344659f, 0.00369815f, -0.01763866f, 
    0.12074982f, 0.02633539f, 0.02129775f, -0.01511003f, -0.00744999f, -0.08428388f, -0.05312843f, -0.11728802f, 
    -0.30163264f, 0.28647807f, 0.02197929f, 0.34918788f, -0.18875805f, 0.07624401f, -0.00580788f, 0.04206044f, 
    0.08043242f, 0.02142062f, -0.02562807f, 0.08922301f, 0.09981639f, 0.09557779f, 0.12700494f, 0.16329783f, 
    0.05464445f, -0.01387614f, 0.01913930f, 0.05540749f, -0.14361557f, -0.16612335f, 0.15131749f, -0.06979889f, 
    0.13551013f, 0.06031059f, 0.12273821f, 0.05214768f, -0.12943333f, 0.17257825f, 0.08824043f, -0.00270233f, 
    -0.02602687f, 0.03042561f, -0.04950177f, -0.01236738f, -0.00006269f, 0.04604145f, -0.08216177f, -0.19347265f, 
    -0.06922534f, -0.33975855f, -0.40136513f, 0.08987045f, 0.14204198f, -0.14955549f, 0.03552845f, -0.00331750f, 
    0.06829573f, -0.03229683f, -0.03496363f, -0.03597293f, -0.01887131f, 0.01048338f, 0.06913180f, 0.08069991f, 
    -0.01821474f, 0.12069222f, 0.15241662f, 0.12211545f, 0.15985829f, -0.02363423f, 0.05509318f, -0.14543851f, 
    0.11681508f, 0.10756839f, 0.19568568f, 0.15211327f, 0.00225756f, -0.01695186f, 0.05689514f, -0.02843868f, 
    -0.00078440f, -0.09392762f, 0.02178574f, -0.04150251f, -0.02488504f, -0.16153805f, -0.01127770f, -0.08458785f, 
    -0.43405148f, 0.01132393f, 0.08756668f, 0.06324909f, 0.04507538f, -0.02888932f, -0.05923223f, -0.03557132f, 
    0.04623971f, -0.03412234f, -0.03584304f, 0.09915026f, 0.06336346f, -0.01870495f, -0.12194073f, 0.07261148f, 
    -0.10283400f, -0.03334237f, 0.11197218f, -0.05126277f, 0.00973778f, -0.13393082f, -0.11890219f, -0.11220110f, 
    -0.05739768f, -0.03389860f, -0.03931976f, -0.00802290f, -0.03279663f, -0.03749500f, -0.11100488f, 0.11904152f, 
    0.06471240f, -0.08092285f, -0.07219777f, 0.03779413f, -0.01586892f, -0.04429160f, -0.08979806f, -0.09437086f, 
    0.16122103f, -0.26837489f, -0.01718052f, 0.01995598f, 0.14269194f, -0.05356150f, -0.02010278f, 0.19510663f, 
    0.03547660f, 0.10143065f, -0.02614009f, 0.00373204f, -0.08941057f, 0.03002100f, -0.06391886f, -0.08502908f, 
    0.05519682f, 0.13121369f, 0.05656220f, 0.08629387f, -0.43932071f, -0.12405381f, -0.41922522f, -0.04067025f, 
    -0.01949704f, -0.06338222f, -0.04949310f, 0.01723014f, 0.06988833f, 0.11663064f, -0.08470502f, 0.04378210f, 
    -0.04386644f, -0.06579184f, 0.03656349f, 0.13487744f, 0.03110933f, -0.02941898f, 0.01407487f, 0.12015791f, 
    -0.00261887f, -0.23360619f, -0.33563256f, 0.38978449f, -0.03147756f, 0.01981054f, 0.01750698f, -0.01873562f, 
    -0.04157941f, 0.05130549f, 0.06406422f, -0.04871747f, -0.06617205f, 0.02002202f, -0.01478598f, 0.00669926f, 
    -0.00005108f, 0.05592718f, -0.01199125f, 0.10173958f, 0.10619143f, -0.03623353f, 0.14086351f, 0.04078982f, 
    0.07271592f, -0.05199319f, 0.13388304f, -0.00557623f, 0.07003561f, 0.17461675f, -0.08147920f, 0.00460037f, 
    -0.03651037f, -0.00541438f, 0.04119159f, 0.00910320f, 0.00444957f, 0.02064096f, 0.08596707f, -0.04560940f, 
    -0.23147489f, -0.09702666f, -0.02442953f, -0.05537436f, 0.09810735f, 0.12049837f, 0.04931976f, -0.02270352f, 
    0.10072234f, 0.09222877f, 0.12497549f, 0.09236418f, 0.10395376f, 0.16282362f, -0.07159641f, 0.12476932f, 
    0.00866618f, 0.03539372f, -0.00721074f, 0.04050402f, 0.27937213f, 0.08763602f, 0.00588883f, -0.03611567f, 
    0.10004614f, 0.01085138f, -0.05134202f, 0.04474306f, 0.26010385f, -0.02546532f, 0.01509023f, 0.05307291f, 
    0.03586473f, -0.00709847f, 0.06329573f, -0.04495387f, 0.04796216f, -0.02031727f, 0.08407278f, 0.04183196f, 
    0.36194837f, -0.07772736f, -0.33401921f, 0.11293443f, -0.13207646f, 0.04749307f, -0.00624047f, 0.01368990f, 
    -0.07214537f, -0.03949887f, -0.01384505f, -0.06304207f, 0.04347740f, -0.01948499f, -0.11678000f, -0.13767648f, 
    0.03257462f, 0.02585202f, 0.13253395f, -0.11697902f, -0.06037602f, -0.01371741f, -0.05725050f, -0.22203037f, 
    0.07439845f, 0.09786329f, -0.00877078f, -0.06886054f, 0.33333305f, 0.11306714f, -0.03712434f, -0.01162557f, 
    0.00562429f, -0.09106734f, -0.00870823f, -0.10359774f, 0.03738618f, 0.15954350f, -0.03412443f, 0.01446522f, 
    -0.00634332f, 0.12043212f, 0.21451993f, 0.01394229f, -0.12263798f, -0.04995976f, -0.08094729f, -0.05896368f, 
    0.02031287f, -0.14674458f, 0.18043749f, -0.07110747f, 0.07968741f, -0.01291689f, 0.01207859f, 0.04962336f, 
    -0.03946171f, -0.01227317f, 0.22848944f, -0.05325406f, 0.00508770f, 0.10382679f, 0.03495269f, 0.14070982f, 
    0.03819305f, -0.02889358f, -0.11858144f, -0.03467244f, -0.20290504f, -0.15600112f, 0.05436691f, 0.05925253f, 
    0.02159431f, 0.12996285f, -0.00657708f, 0.05963269f, -0.18126148f, -0.07491254f, 0.04109872f, 0.02184072f, 
    0.19681928f, 0.37433544f, 0.29261991f, -0.30866623f, 0.10397757f, 0.16352555f, 0.00115593f, 0.08212128f, 
    -0.09176040f, -0.00713790f, 0.17419143f, 0.15665315f, 0.14750738f, 0.25317064f, 0.03518422f, 0.03157497f, 
    -0.01062809f, 0.09602956f, 0.06468965f, -0.00020303f, 0.11504996f, 0.13466567f, -0.05279623f, -0.05439782f, 
    -0.10227648f, -0.06700139f, -0.06863180f, 0.04057033f, -0.12189913f, -0.09648619f, -0.02509736f, -0.10067302f, 
    0.14461119f, 0.01231069f, -0.17860182f, 0.01622228f, 0.05655994f, -0.03422862f, 0.08027953f, 0.03648291f, 
    -0.12872733f, -0.18026850f, 0.00926373f, 0.01439854f, 0.01582407f, 0.14479513f, 0.03205698f, 0.02980181f, 
    -0.10127308f, 0.06985474f, 0.01464059f, -0.04346704f, -0.06572867f, 0.01127645f, 0.08748691f, -0.17878364f, 
    0.05438181f, 0.14371581f, 0.05397576f, -0.04853166f, -0.12548406f, -0.04772405f, -0.20980425f, 0.06055574f, 
    -0.05321017f, -0.06089466f, -0.05376900f, 0.04803598f, -0.14533044f, -0.06985536f, 0.12633273f, -0.05198703f, 
    -0.07119803f, -0.05460289f, -0.10796596f, 0.04250109f, -0.11096874f, -0.01763637f, 0.10876139f, -0.04834107f, 
    -0.10900381f, -0.24484418f, -0.31372222f, 0.05892374f, 0.08511876f, 0.06066363f, 0.15927829f, 0.05042149f, 
    0.22514334f, 0.17874070f, -0.04130737f, 0.00051286f, -0.00360023f, -0.00288888f, 0.00841549f, -0.03751973f, 
    0.00875926f, 0.09590802f, -0.05756082f, 0.00507420f, 0.06951988f, 0.02677390f, 0.06410158f, 0.03215938f, 
    -0.07624535f, -0.06046349f, -0.16561534f, -0.19170350f, -0.13938403f, -0.13229471f, 0.19687930f, 0.09870422f, 
    -0.11853769f, -0.05997099f, -0.14263801f, -0.08980709f, -0.14976884f, -0.07137369f, 0.08551069f, -0.02095664f, 
    -0.23337245f, 0.15783833f, 0.35033515f, 0.12635878f, 0.18893772f, -0.01382538f, -0.01623169f, 0.12740035f, 
    -0.02817781f, -0.09901110f, 0.12633978f, -0.05840329f, -0.06058132f, -0.02202196f, -0.01883100f, 0.10486566f, 
    -0.03355527f, -0.07208694f, -0.06241422f, -0.13191782f, -0.01989839f, -0.02582587f, 0.02709129f, 0.16577660f, 
    0.18972404f, 0.08725901f, 0.22413339f, -0.17973027f, 0.09688549f, 0.06351602f, 0.03119112f, -0.07009879f, 
    0.02314557f, -0.03840824f, 0.00501705f, -0.02676467f, 0.11855420f, 0.12150034f, -0.19318238f, -0.10690670f, 
    0.00489186f, -0.02208070f, 0.00012583f, 0.00660818f, -0.03358210f, 0.01328093f, -0.05164331f, -0.00905276f, 
    -0.02673285f, 0.02965683f, -0.05556483f, 0.01733814f, -0.04030633f, 0.00759844f, -0.02563570f, -0.02420041f, 
    -0.03535150f, 0.03416348f, -0.01699206f, -0.01539140f, -0.03944527f, -0.05207666f, 0.01346955f, -0.00872355f, 
    -0.00996830f, 0.01778992f, -0.05463521f, 0.00167215f, 0.01345232f, 0.02924941f, -0.04279596f, 0.01027644f, 
    0.01667009f, 0.04317451f, -0.03704194f, 0.01414719f, -0.05632646f, -0.02910370f, 0.04925389f, -0.05839685f, 
    -0.05625633f, -0.06984783f, -0.06883553f, -0.03732833f, 0.03102835f, 0.02376716f, -0.03955506f, 0.00486613f, 
    -0.02369058f, -0.00307248f, 0.04429289f, 0.01717553f, -0.06200039f, -0.06207644f, -0.04342752f, -0.04605742f, 
    -0.03120722f, -0.01864631f, 0.00178301f, -0.03188772f, 0.01511245f, -0.02682176f, 0.01715987f, -0.05064294f, 
    -0.06769688f, 0.02865407f, 0.02066673f, -0.00339999f, 0.02048615f, 0.01206159f, 0.01644830f, -0.04948645f, 
    -0.02892640f, 0.03933516f, -0.01109721f, -0.04336102f, -0.01643836f, -0.05643314f, -0.04717793f, -0.06493181f, 
    0.01988097f, 0.01568346f, -0.02025292f, -0.00062204f, 0.00503633f, -0.01958903f, -0.07076920f, -0.04429418f, 
    -0.01414324f, -0.03453740f, 0.00268027f, 0.04968891f, 0.00182534f, 0.02090180f, 0.00661979f, -0.05134658f, 
    -0.06462205f, -0.03390471f, 0.02032831f, 0.01011810f, -0.04621665f, -0.05950580f, 0.00341994f, 0.04938896f, 
    0.01755262f, -0.03765873f, -0.06569710f, -0.05261248f, 0.04803710f, -0.06703104f, -0.05630896f, -0.00389280f, 
    0.04271143f, -0.01042059f, -0.04827416f, -0.04086866f, 0.00373339f, 0.04721950f, 0.04986345f, 0.01083589f, 
    -0.06465162f, -0.03291107f, -0.01350394f, 0.03153013f, -0.01136735f, -0.06070776f, 0.02527432f, -0.02796664f, 
    -0.07671167f, -0.00113220f, -0.00690588f, -0.00972769f, 0.00484207f, 0.01051824f, -0.05675302f, -0.04909878f, 
    0.00460294f, 0.03295139f, -0.05302825f, 0.03102332f, -0.04007119f, 0.00966140f, 0.01583468f, -0.06675889f, 
    -0.02000916f, 0.01605744f, 0.00314055f, -0.00663322f, 0.02794190f, -0.05543602f, 0.02734016f, 0.02665102f, 
    0.02527503f, 0.02031649f, 0.02697418f, -0.06789470f, -0.06216805f, -0.02090758f, -0.05613571f, 0.01271007f, 
    -0.01238459f, -0.05229271f, -0.06185432f, -0.03657091f, -0.00015574f, -0.04019142f, -0.06221373f, -0.01843507f, 
    0.00424802f, -0.01899129f, -0.05121915f, 0.02787866f, -0.04693959f, -0.01702379f, -0.01902899f, 0.01330796f, 
    0.00832063f, -0.05184473f, 0.00910558f, -0.00382329f, -0.03433232f, 0.01659672f, -0.00116501f, -0.03850863f, 
    -0.00422596f, -0.07871988f, -0.06701969f, -0.05645596f, 0.00126944f, -0.06799848f, 0.02320276f, -0.01510679f, 
    -0.03369531f, 0.00825701f, -0.01680903f, -0.00726141f, -0.04796301f, 0.00640514f, -0.06198212f, -0.03917899f, 
    0.04386509f, -0.00090392f, -0.03572709f, -0.03766874f, -0.00645035f, -0.04553366f, -0.02870564f, -0.00991501f, 
    -0.00644100f, 0.03690550f, 0.05405519f, -0.01964986f, 0.02605419f, 0.02417402f, -0.02385093f, -0.03424638f, 
    -0.03620661f, -0.04621902f, 0.02039104f, 0.02540687f, 0.02734877f, -0.02542388f, 0.00591229f, -0.04971225f, 
    -0.03344565f, 0.02420493f, 0.02608321f, -0.02229300f, -0.00922582f, 0.02513852f, 0.00358592f, -0.06195020f, 
    -0.04928286f, 0.02060864f, 0.01853960f, 0.00452321f, -0.04685384f, 0.01846953f, 0.03426354f, -0.01672115f, 
    0.03128685f, -0.00720611f, 0.03751652f, 0.03746003f, -0.01150421f, -0.01299007f, 0.00429622f, -0.04434706f, 
    0.02310441f, 0.02028556f, 0.00108050f, 0.02336588f, -0.03631725f, -0.04921502f, -0.00134409f, -0.04885964f, 
    -0.00650127f, -0.07409972f, 0.03353642f, -0.04766750f, 0.03764898f, 0.03148347f, 0.02896449f, 0.02031550f, 
    -0.04797979f, 0.00775910f, 0.00862590f, -0.02837848f, -0.02472306f, 0.03349300f, -0.02588984f, -0.02332049f, 
    -0.00587491f, 0.02834062f, -0.02599575f, -0.04050704f, 0.01109478f, 0.01088496f, -0.03946183f, -0.02849402f, 
    -0.07225622f, -0.02202246f, -0.05876407f, 0.01266640f, -0.00387170f, -0.02986787f, 0.00318800f, 0.00422553f, 
    -0.03910725f, 0.01403665f, -0.04189880f, -0.02160804f, -0.02382281f, -0.06333184f, -0.07363554f, -0.06996094f, 
    -0.01239756f, -0.00486995f, 0.01183996f, 0.02124427f, -0.06790484f, 0.01242851f, 0.03421132f, 0.01130489f, 
    0.03975159f, -0.03919670f, -0.02704604f, -0.04122454f, -0.03241622f, -0.05330994f, -0.03057361f, -0.06216334f, 
    -0.06552323f, 0.03470174f, 0.00848788f, -0.02455238f, 0.04380343f, 0.01971540f, -0.05086453f, 0.02035157f, 
    -0.12695818f, -0.04126437f, 0.35359874f, -0.03355532f, -0.15472020f, 0.00246273f, 0.03460514f, -0.05392260f, 
    0.18189938f, 0.01114080f, 0.05965815f, 0.08868202f, 0.00692295f, -0.01911369f, 0.06484915f, -0.03311100f, 
    -0.05724513f, -0.09670322f, 0.32279885f, 0.13972527f, -0.32403138f, -0.03328345f, -0.02749531f, 0.16190407f, 
    -0.20174839f, 0.17339239f, -0.13840044f, -0.01525091f, 0.00054347f, 0.04780374f, 0.05292101f, 0.09344746f, 
    -0.06511474f, 0.00622981f, 0.10390329f, 0.08054629f, -0.03925300f, 0.00995290f, -0.08367913f, -0.08495840f, 
    0.30001059f, 0.02431587f, 0.03040070f, -0.07285725f, -0.10879416f, 0.01822816f, 0.07762584f, 0.10551445f, 
    -0.16622001f, -0.03030839f, -0.13659133f, -0.12895687f, -0.11513082f, -0.06322153f, 0.07653479f, 0.01232550f, 
    -0.00086318f, 0.04258233f, -0.07296678f, 0.25566134f, -0.66747314f, -0.13467330f, -0.16977248f, -0.22431834f, 
    -0.19154352f, -0.02513385f, 0.02522925f, -0.08217355f, -0.10121831f, 0.14384535f, -0.01775987f, 0.11444690f, 
    -0.06447779f, 0.03762104f, 0.01130176f, 0.03054563f, 0.00869040f, 0.00831696f, -0.04089795f, 0.01107082f, 
    -0.29309979f, -0.04705452f, 0.16212006f, 0.10630411f, 0.04119428f, -0.04020254f, -0.00528270f, -0.09446620f, 
    0.12339315f, 0.15056323f, 0.14203702f, 0.01934997f, -0.06275423f, -0.14559114f, 0.08211434f, 0.17762321f, 
    0.03178041f, -0.03061398f, -0.16131957f, 0.13064747f, -0.19859180f, -0.09988274f, 0.25696287f, 0.14619385f, 
    -0.05459015f, -0.06279682f, 0.05725399f, 0.12295133f, -0.25941122f, -0.20226671f, -0.07236861f, -0.02246434f, 
    0.10923209f, 0.06051923f, -0.02573189f, 0.05076981f, -0.25902870f, -0.12380783f, -0.02648815f, -0.06224789f, 
    0.10145178f, -0.01424047f, -0.25461686f, -0.05524356f, 0.23680024f, 0.10501972f, 0.05544714f, -0.03000896f, 
    -0.05205185f, 0.02181888f, -0.02501214f, 0.09575631f, -0.04406025f, -0.00173031f, 0.03455576f, 0.08806755f, 
    -0.05652736f, 0.25760552f, -0.16254848f, -0.19127643f, 0.10119034f, -0.06729373f, 0.05038241f, -0.18271190f, 
    0.24522680f, 0.00714599f, 0.08840526f, -0.08718403f, -0.01329222f, 0.07852188f, 0.06213147f, 0.03607517f, 
    -0.03782870f, 0.01587136f, -0.03766372f, -0.02210323f, -0.10603399f, -0.01280669f, -0.08277369f, 0.02987646f, 
    0.20809765f, -0.27726898f, -0.13427715f, -0.08865122f, 0.03031832f, -0.07382811f, 0.10929344f, -0.12055136f, 
    -0.14562450f, -0.14714007f, -0.07643927f, -0.09166516f, 0.03805446f, -0.35330200f, 0.00862972f, 0.03085051f, 
    -0.02549035f, -0.12829579f, -0.05347678f, 0.01066220f, -0.13760749f, -0.02798352f, -0.14109339f, 0.20569979f, 
    0.09162419f, -0.00478395f, 0.11198177f, -0.07206098f, 0.20186411f, -0.04867177f, 0.01158794f, -0.11343896f, 
    -0.21554282f, -0.01930839f, 0.17438960f, 0.05074814f, -0.09161133f, 0.04385763f, 0.06741411f, 0.05750144f, 
    -0.04764933f, 0.11064412f, 0.12824990f, 0.05167168f, -0.16282907f, 0.07433045f, 0.02949131f, 0.21178457f, 
    0.22274972f, -0.05051424f, 0.08402447f, 0.10655068f, 0.13250262f, 0.15862580f, -0.13525859f, 0.13151386f, 
    -0.05182388f, -0.03999112f, -0.02399320f, -0.00215302f, -0.03276277f, -0.01879676f, -0.11483744f, 0.08958971f, 
    0.21056993f, 0.10468786f, -0.12142839f, -0.02136065f, 0.02305810f, 0.05328423f, -0.08152848f, 0.04201182f, 
    -0.05022346f, -0.02296077f, 0.07831392f, 0.04444915f, 0.00520221f, 0.04209153f, -0.25299901f, 0.14419547f, 
    0.08737498f, 0.14706233f, 0.28363314f, 0.08452993f, -0.12971388f, -0.04753523f, -0.05502385f, 0.13700657f, 
    -0.04733375f, -0.09153324f, 0.09124941f, -0.00766138f, 0.00426299f, -0.05025263f, 0.00424576f, -0.00455605f, 
    0.03962722f, -0.01157826f, 0.28014964f, 0.10250731f, 0.04849209f, -0.06736626f, -0.12236694f, 0.13372861f, 
    0.08167850f, 0.19125019f, 0.16012374f, 0.00962706f, 0.02930138f, 0.07391525f, 0.06066832f, -0.16891125f, 
    0.03960939f, 0.01593335f, 0.00049874f, 0.06602814f, 0.12197825f, 0.00051534f, -0.08083079f, 0.04294875f, 
    0.60106790f, 0.11744590f, -0.48917782f, -0.06018874f, -0.07313576f, 0.21301205f, 0.02539900f, 0.03635350f, 
    -0.01468571f, 0.08638301f, -0.02130399f, 0.09119201f, 0.08878705f, 0.03872950f, -0.02694821f, 0.02983540f, 
    -0.06081693f, 0.12030472f, 0.05997793f, 0.11196149f, 0.23686762f, -0.11822531f, 0.11606221f, 0.10694679f, 
    -0.27991560f, 0.05493926f, 0.05483081f, 0.26746756f, 0.06374328f, 0.02457832f, -0.02911582f, 0.02185984f, 
    0.08241415f, -0.03217649f, -0.00600336f, -0.07531881f, -0.02220625f, -0.02333239f, 0.22085622f, 0.08089729f, 
    -0.01375469f, -0.16722411f, -0.45469782f, 0.10886323f, 0.02085038f, 0.00121127f, 0.06508703f, 0.00027012f, 
    -0.06510914f, 0.02315800f, 0.04042901f, -0.12079809f, -0.05207911f, 0.01632510f, 0.02646354f, -0.00925875f, 
    -0.05107499f, 0.02936542f, 0.08547879f, -0.03958990f, 0.01534512f, -0.02147669f, -0.28300646f, -0.19645876f, 
    0.08027890f, 0.06140661f, 0.14514448f, 0.06126373f, -0.03044211f, 0.11771460f, 0.01051510f, 0.05114246f, 
    -0.02172286f, -0.02368824f, 0.03036919f, 0.04425693f, -0.05041410f, -0.04273312f, 0.13436843f, -0.02678583f, 
    0.03589366f, 0.29977730f, 0.12074592f, -0.15468068f, 0.09737656f, 0.07087324f, -0.09320953f, -0.06560241f, 
    -0.12035525f, -0.12903063f, 0.03254873f, 0.09704015f, 0.05345373f, 0.03874822f, -0.07789146f, 0.11058832f, 
    -0.05607903f, 0.05585015f, -0.08920370f, -0.06971416f, -0.28574240f, 0.26290581f, 0.56914896f, 0.24490617f, 
    0.28924081f, 0.00900365f, -0.06348163f, -0.02866356f, -0.08537345f, 0.03453571f, -0.00846197f, 0.11101778f, 
    0.10809642f, 0.11985890f, 0.11988059f, 0.02598425f, -0.04693795f, 0.02207570f, 0.00346065f, 0.05905215f, 
    0.00845663f, -0.02435503f, -0.28291041f, 0.03259669f, 0.08496512f, 0.00499732f, 0.00817133f, -0.12524757f, 
    -0.08631479f, 0.02075414f, 0.07924207f, -0.12719022f, -0.07596159f, -0.03822055f, 0.03494842f, 0.04088234f, 
    -0.08016230f, -0.04986279f, 0.12824850f, -0.00692879f, -0.12346342f, -0.25803697f, -0.18803909f, 0.00873844f, 
    -0.12403633f, 0.04245023f, -0.08489116f, -0.03481873f, -0.01793393f, -0.04254213f, -0.02852868f, 0.01140716f, 
    0.01785993f, 0.08432861f, -0.13869843f, 0.01986078f, 0.03936914f, 0.16155623f, 0.04438386f, 0.03386946f, 
    0.18837194f, -0.02394440f, 0.04696508f, -0.08387830f, 0.09143076f, 0.08122574f, 0.07547326f, 0.09012156f, 
    -0.03476794f, 0.01793418f, 0.04984472f, -0.00671611f, 0.00135952f, -0.09635176f, -0.00087460f, -0.00395148f, 
    -0.04490039f, 0.00458710f, 0.10809214f, -0.02375773f, -0.23023334f, 0.13574916f, 0.00502938f, -0.07963673f, 
    0.22564933f, -0.00254158f, -0.05647017f, 0.04337585f, -0.11225868f, -0.00828076f, 0.04388047f, 0.06249322f, 
    0.06394364f, 0.07022887f, -0.00634735f, 0.03234299f, 0.01796287f, 0.09461374f, -0.03832332f, 0.12240716f, 
    -0.06082048f, 0.43704179f, 0.05423035f, -0.19499724f, -0.11303347f, 0.14172834f, 0.11456493f, 0.05469096f, 
    -0.11825196f, -0.02046947f, 0.13721718f, 0.12229239f, 0.21431668f, 0.13412601f, 0.06706497f, 0.17748915f, 
    0.01170330f, 0.08871590f, -0.03852291f, -0.03123443f, -0.04547743f, -0.04722163f, -0.03336581f, -0.04758067f, 
    0.16641322f, 0.02302597f, -0.08141410f, 0.02075976f, -0.07795619f, 0.04288336f, 0.10753985f, -0.08388531f, 
    -0.00303390f, 0.01168754f, -0.06229228f, 0.11254735f, -0.09569630f, -0.07052219f, 0.06495951f, 0.02437050f, 
    -0.00070044f, -0.26203039f, -0.13754234f, -0.09175522f, 0.01906142f, 0.02304948f, -0.01671959f, -0.08840399f, 
    -0.02345375f, -0.16481209f, 0.02855550f, -0.07306704f, -0.04522815f, 0.05084906f, -0.04314986f, -0.06350474f, 
    -0.04705266f, 0.10889248f, 0.12118873f, 0.09136658f, 0.12808812f, 0.03433524f, -0.26558682f, -0.02120541f, 
    0.18965663f, 0.01203472f, -0.03398947f, 0.01905652f, 0.01141889f, 0.05098414f, 0.12391186f, -0.11343568f, 
    -0.06085976f, -0.10135212f, -0.10906342f, -0.05764934f, -0.03198451f, -0.05683656f, 0.05780204f, -0.00042085f, 
    -0.33683026f, -0.21506460f, -0.01277311f, -0.03485953f, -0.07767181f, -0.00139967f, 0.11302496f, 0.08618946f, 
    0.00698124f, -0.11477417f, 0.01977271f, 0.00147115f, -0.02775731f, -0.03071144f, -0.03560798f, -0.00704804f, 
    -0.03395719f, 0.15170425f, 0.09762616f, -0.19768575f, 0.02668958f, -0.10856222f, -0.04635193f, -0.11806692f, 
    0.06386790f, 0.02409570f, -0.00364547f, -0.03825206f, 0.00740484f, 0.03109371f, -0.03477025f, -0.02393538f, 
    -0.03675730f, -0.15382993f, -0.09572674f, -0.07886323f, -0.12189216f, -0.04395887f, -0.01905480f, -0.00876457f, 
    0.08198884f, -0.25853127f, 0.12947650f, -0.11647395f, 0.16455933f, 0.02299643f, 0.05020851f, 0.17540225f, 
    0.07790846f, -0.00353978f, 0.12281581f, -0.01396291f, -0.05712475f, -0.04621769f, 0.05034588f, 0.05724768f, 
    -0.02151496f, 0.02144980f, -0.00518153f, -0.02328957f, -0.02715977f, -0.05752432f, -0.34093964f, -0.03131640f, 
    -0.14772095f, -0.01349052f, 0.15854192f, -0.08644629f, 0.00029875f, 0.02157551f, -0.03858180f, -0.06501342f, 
    0.05314702f, 0.01335226f, 0.05271964f, 0.04154491f, 0.08851396f, 0.01865085f, 0.04576088f, 0.06371883f, 
    -0.03343892f, -0.02861169f, -0.03133553f, 0.01875521f, -0.02230614f, 0.01573475f, -0.05303019f, 0.00765668f, 
    -0.05452774f, 0.01723465f, 0.03042679f, 0.01085854f, -0.04828586f, 0.01473496f, -0.05466600f, -0.00895909f, 
    0.01130355f, 0.02547304f, -0.00766266f, 0.00789119f, -0.03110074f, -0.02075735f, -0.03523098f, 0.01574299f, 
    -0.01222613f, 0.03614739f, -0.04758592f, 0.03045527f, -0.02892550f, -0.06263179f, 0.00677960f, 0.02670150f, 
    -0.02536178f, -0.02619979f, 0.02187552f, -0.02173417f, -0.05423892f, -0.06055338f, 0.02617976f, 0.03963258f, 
    -0.02796513f, -0.01702316f, -0.03509502f, -0.03276713f, -0.03737698f, -0.06137877f, -0.04948575f, 0.02412007f, 
    -0.04665330f, 0.02782186f, -0.04832002f, -0.03143295f, -0.00330958f, -0.02739989f, 0.02412405f, -0.00829266f, 
    0.03645384f, 0.01873839f, -0.03381489f, -0.03241337f, 0.04016327f, -0.04595992f, -0.01086789f, -0.00902041f, 
    -0.00391137f, -0.02797049f, -0.01503075f, 0.02330291f, -0.05088982f, 0.03938745f, -0.03858879f, 0.02382394f, 
    -0.03327652f, 0.01164554f, 0.00203552f, 0.02458834f, -0.02383742f, 0.03197970f, -0.05521028f, 0.01281001f, 
    -0.00704583f, 0.00963178f, 0.01139375f, -0.03282933f, 0.01194047f, -0.01546334f, 0.03867963f, -0.05416822f, 
    0.02042819f, 0.00900705f, 0.03752972f, -0.00766965f, -0.00889264f, -0.03247948f, 0.00252325f, 0.00284721f, 
    0.04132216f, -0.05481794f, -0.06036572f, -0.00155665f, -0.02159026f, -0.04635364f, 0.01082583f, 0.00037386f, 
    0.04149752f, 0.00843860f, -0.01501854f, 0.03388143f, 0.02489256f, -0.04234062f, 0.03660714f, 0.00044142f, 
    0.04386932f, -0.01405712f, -0.01534195f, 0.02109650f, 0.00665310f, -0.05112072f, -0.03855310f, -0.02049683f, 
    -0.05229227f, -0.01742910f, -0.00861315f, 0.03682590f, -0.02426806f, -0.00088599f, 0.02857688f, 0.00543214f, 
    -0.05820480f, -0.04089885f, 0.00869928f, 0.02308872f, 0.03741817f, 0.01042103f, -0.02822895f, -0.05738495f, 
    -0.04758130f, -0.01087817f, -0.00618148f, -0.00417143f, -0.00278546f, 0.02093759f, 0.04501158f, 0.02342038f, 
    -0.03653333f, 0.01383746f, -0.02930323f, 0.02111739f, 0.04511068f, 0.00551821f, -0.02917925f, 0.03079988f, 
    0.02485644f, 0.00541000f, -0.04733725f, -0.04216807f, -0.00789882f, 0.03871236f, -0.02557442f, -0.06132355f, 
    0.01903909f, -0.04179494f, -0.00232787f, -0.02333967f, -0.01172357f, -0.04117102f, 0.02627183f, -0.04033476f, 
    -0.02901791f, 0.04078709f, -0.03331754f, 0.04319072f, -0.03505104f, -0.03418341f, -0.03441713f, 0.03708021f, 
    -0.03376390f, 0.03031032f, -0.03782332f, 0.01990871f, -0.00214274f, 0.03401646f, -0.02574645f, -0.02333306f, 
    -0.00239345f, -0.06336715f, 0.01872982f, -0.00310717f, -0.01006854f, 0.02423893f, -0.02908053f, -0.04783815f, 
    0.02280402f, -0.01103291f, -0.03711031f, 0.01581085f, 0.01019445f, -0.01197318f, 0.01264196f, -0.02088359f, 
    0.04634915f, 0.00527650f, 0.01780032f, 0.00389015f, -0.05106986f, 0.01074801f, 0.04924586f, 0.03729958f, 
    -0.04528545f, 0.02658040f, -0.00554529f, -0.04529562f, 0.01533382f, -0.01747125f, -0.00854350f, 0.04266240f, 
    0.02225244f, 0.03838514f, 0.02967886f, 0.02515623f, -0.04244679f, -0.01194010f, 0.02988268f, 0.00492276f, 
    0.04547852f, -0.05951054f, -0.05959849f, -0.01207127f, -0.00840057f, -0.05023422f, -0.03692951f, -0.04520321f, 
    0.04182854f, -0.00104562f, -0.01697570f, -0.00268327f, 0.04056687f, -0.04587046f, -0.06296971f, 0.03878192f, 
    0.04493072f, -0.04243139f, 0.02849294f, -0.02248708f, -0.00786039f, -0.00517203f, -0.04841970f, -0.03544915f, 
    0.03477998f, -0.00145011f, 0.02982617f, -0.00149892f, -0.03493358f, 0.02695612f, -0.00609287f, -0.01368720f, 
    -0.03892227f, 0.01277552f, 0.01077556f, 0.00920628f, 0.02737238f, 0.02600368f, 0.01881705f, -0.04019630f, 
    -0.01207224f, -0.01887813f, 0.03940117f, -0.01350969f, 0.00637630f, -0.04244110f, -0.02155478f, 0.02215330f, 
    -0.02572662f, 0.00660620f, 0.05084601f, 0.02129759f, -0.00828486f, -0.04686473f, -0.06023521f, -0.00564504f, 
    0.01638904f, 0.00745357f, 0.04626089f, -0.03725379f, 0.04510184f, 0.01029821f, -0.04060298f, -0.00835543f, 
    0.02084998f, -0.06192521f, 0.01806092f, -0.00523261f, 0.03559316f, 0.04623450f, -0.04828240f, 0.02390116f, 
    0.02138327f, 0.03639530f, -0.06264237f, -0.00184040f, -0.04896183f, 0.04258216f, 0.00368725f, -0.00840050f, 
    0.03045343f, -0.02467830f, 0.02968211f, -0.02670410f, 0.01430515f, 0.01689470f, -0.06228631f, 0.00762633f, 
    -0.06244751f, -0.05698435f, -0.03805390f, -0.01049466f, 0.00769647f, -0.01834244f, 0.02029026f, -0.03952719f, 
    -0.01253121f, -0.23136450f, -0.20839761f, 0.08461717f, 0.26623884f, -0.07099176f, -0.01667395f, 0.01954130f, 
    -0.05295089f, 0.06818106f, -0.05531422f, -0.10731524f, -0.12477697f, 0.04962621f, -0.01844240f, -0.14899948f, 
    -0.07061123f, -0.04557939f, 0.14651883f, -0.15087251f, 0.17208946f, 0.06874309f, 0.09761775f, 0.00325996f, 
    0.13179944f, -0.02360272f, 0.13158338f, 0.09853268f, 0.12701897f, 0.13171794f, 0.00410624f, -0.11465390f, 
    -0.03229528f, 0.00805477f, -0.00753896f, -0.19715068f, 0.09981381f, 0.03095691f, 0.04728623f, 0.09878397f, 
    -0.11234473f, 0.04811285f, -0.03234332f, 0.12416330f, 0.25142097f, -0.10609685f, -0.03606835f, 0.07621174f, 
    -0.05060831f, -0.10054180f, 0.01290627f, 0.11298047f, -0.05485604f, -0.00530244f, -0.00556444f, 0.02701537f, 
    -0.15333869f, -0.03189799f, -0.14736512f, -0.16173211f, 0.08835858f, 0.00095269f, 0.07114299f, -0.13866551f, 
    0.00684129f, 0.05093906f, -0.00012418f, 0.07763307f, 0.15285091f, 0.09079647f, -0.02721319f, 0.00565498f, 
    0.03489541f, 0.01546369f, 0.13180992f, -0.07731635f, 0.02192478f, -0.10803746f, 0.02049579f, 0.03973532f, 
    0.14825213f, 0.06662922f, -0.19253863f, 0.01267785f, 0.18718037f, 0.25714803f, 0.08122262f, 0.12953286f, 
    -0.03362431f, -0.05733784f, 0.04148166f, 0.09085771f, 0.09566053f, -0.02653057f, -0.02379249f, -0.16332231f, 
    -0.12812485f, -0.12754570f, -0.16460870f, -0.09477367f, 0.05074058f, -0.26426426f, -0.02322571f, -0.05907073f, 
    -0.11613062f, -0.01811969f, -0.01333204f, -0.08833247f, 0.23773080f, 0.24498099f, -0.03545447f, -0.00260073f, 
    -0.06226993f, 0.09381105f, 0.01039531f, 0.04163273f, 0.24847449f, 0.28270489f, 0.11088642f, 0.15855031f, 
    0.28246027f, 0.10168020f, 0.02408301f, 0.23522553f, 0.00972253f, -0.06482767f, -0.04848373f, -0.13449273f, 
    0.02094316f, 0.09790310f, 0.00031258f, -0.06938288f, 0.04114577f, -0.02181526f, -0.06200396f, -0.00479522f, 
    -0.07808388f, -0.09778690f, -0.15307373f, -0.06365538f, 0.07437550f, 0.13943911f, 0.08540092f, 0.06057121f, 
    0.03838452f, -0.04004671f, 0.07464860f, 0.06795866f, 0.01612885f, -0.01136293f, 0.02799624f, 0.01059805f, 
    0.08145739f, -0.03365194f, 0.09429044f, -0.11082303f, -0.04395064f, -0.20367734f, -0.17875886f, -0.00037187f, 
    -0.06223049f, 0.10826024f, 0.25124085f, 0.02972690f, -0.16852586f, -0.05283199f, 0.08908825f, 0.36155459f, 
    -0.07348646f, -0.18376702f, 0.06502821f, 0.04345649f, 0.15497862f, 0.27309388f, -0.04399328f, 0.03500040f, 
    0.00359280f, 0.14087175f, -0.14065558f, -0.09313601f, 0.17579676f, 0.08865828f, 0.16451743f, -0.05999411f, 
    0.03494216f, 0.05732917f, 0.07272244f, -0.00450594f, -0.07892952f, 0.06537329f, -0.01681929f, 0.06579015f, 
    0.02051324f, -0.05543426f, -0.09159054f, -0.08009087f, -0.07336845f, -0.11054459f, -0.15028733f, -0.10430072f, 
    0.03385967f, -0.16956110f, 0.00550379f, -0.00651239f, 0.14375934f, -0.07353743f, 0.05934534f, -0.08266965f, 
    0.07274895f, 0.02752030f, -0.08002423f, -0.20227870f, -0.00777825f, -0.00896130f, -0.00260862f, -0.02661634f, 
    0.12592462f, 0.05861330f, 0.14098349f, 0.21026473f, 0.27900127f, -0.10812169f, 0.07307217f, -0.06931517f, 
    0.01081753f, 0.04060278f, 0.05709479f, -0.03110686f, 0.09249611f, 0.06887756f, 0.11296854f, -0.04761706f, 
    0.03579095f, -0.08752225f, -0.03980667f, -0.18378471f, -0.06421061f, -0.24205866f, 0.00607746f, -0.16629054f, 
    -0.03560222f, -0.08386329f, -0.01771799f, 0.00984482f, 0.03615994f, -0.01519816f, 0.05635273f, 0.03594338f, 
    -0.07993106f, -0.03266333f, 0.05077891f, 0.06119675f, -0.05230140f, -0.08968545f, -0.08702917f, -0.11174960f, 
    -0.04516632f, 0.05971686f, 0.03738204f, -0.16281317f, 0.23423278f, 0.16939045f, 0.23597024f, -0.01619261f, 
    -0.04692310f, -0.03274285f, -0.02398689f, 0.07719942f, 0.01168443f, -0.00043235f, -0.14997680f, -0.01720429f, 
    -0.02125194f, -0.15746422f, -0.17189163f, -0.16962788f, -0.13905580f, -0.22348145f, -0.25897759f, -0.15574086f, 
    0.25214797f, -0.01963119f, 0.37921205f, 0.07060543f, 0.16990814f, -0.03980229f, -0.11650658f, -0.08440574f, 
    0.25194839f, 0.10574631f, 0.09474408f, -0.03504059f, -0.07929263f, -0.13518488f, -0.07148897f, 0.01153936f, 
    0.01662812f, -0.00932212f, 0.07021655f, -0.00793540f, -0.24740104f, -0.05351074f, 0.25347629f, 0.15671718f, 
    0.28726557f, -0.06247829f, 0.11640058f, -0.00754008f, -0.14165513f, -0.04534012f, 0.05661336f, 0.00508921f, 
    -0.06594224f, -0.00263675f, 0.09252445f, 0.04245446f, 0.14630069f, 0.06879146f, -0.11616331f, 0.04991234f, 
    -0.05660393f, -0.14612103f, -0.24867757f, 0.16336682f, -0.23954591f, 0.09696738f, -0.15871345f, 0.01255363f, 
    -0.06017860f, -0.08486541f, 0.04071121f, -0.22624458f, -0.01040925f, -0.10892081f, -0.07512320f, 0.07274513f, 
    0.00251201f, 0.06621562f, -0.39395440f, -0.08705615f, -0.00230299f, -0.16630006f, -0.32536182f, 0.02338444f, 
    -0.23524591f, -0.08788244f, 0.15838203f, 0.19991171f, 0.12999713f, 0.05021260f, -0.05668282f, 0.00243997f, 
    -0.00173584f, -0.00176023f, -0.02925297f, 0.00485600f, 0.07186613f, 0.18012254f, 0.03917330f, -0.05985648f, 
    -0.06301802f, 0.03742502f, 0.32764214f, -0.07173445f, 0.10391171f, 0.00543890f, 0.01134181f, -0.12728304f, 
    0.18261543f, 0.11811281f, -0.11147564f, 0.09345305f, 0.16911744f, 0.11446391f, -0.01425603f, 0.04934776f, 
    0.01403524f, -0.07317476f, -0.07681867f, -0.10925636f, 0.39016140f, 0.04123671f, -0.06920470f, 0.19336405f, 
    -0.41753796f, -0.08939719f, -0.17040850f, -0.37382638f, -0.13901989f, -0.08622420f, 0.05944641f, -0.11160316f, 
    0.12195771f, 0.27539676f, 0.04101462f, 0.03750602f, 0.01032897f, -0.09820081f, 0.04962558f, 0.10270841f, 
    -0.00231292f, 0.05623526f, -0.20833103f, 0.08623982f, 0.02358810f, 0.01560404f, 0.02219608f, 0.03466079f, 
    -0.10897878f, -0.12632932f, 0.07347608f, 0.01070892f, 0.32326782f, 0.03427710f, 0.02877275f, 0.15615723f, 
    -0.01504441f, 0.03327161f, -0.08087504f, -0.14325795f, 0.10260620f, -0.40830532f, -0.10871784f, -0.24704236f, 
    -0.30329391f, -0.00639340f, -0.07481975f, -0.04865494f, 0.07688034f, 0.01203165f, 0.04484203f, -0.00426091f, 
    -0.02326383f, -0.09702699f, -0.01190054f, 0.03710093f, 0.16066846f, 0.00606358f, 0.13329428f, -0.03132484f, 
    0.07267801f, 0.18900532f, -0.10795532f, -0.03324217f, 0.18157271f, -0.12354129f, 0.14845420f, 0.04515623f, 
    0.03628971f, -0.00061115f, 0.03413345f, 0.03612487f, -0.08960099f, 0.01855689f, -0.07250311f, -0.04426948f, 
    0.04272336f, 0.17102510f, 0.09343407f, 0.06470119f, -0.00979051f, 0.07410099f, -0.08343887f, 0.06705374f, 
    0.00034387f, 0.11603362f, 0.04056041f, 0.07331713f, -0.01614442f, -0.01542023f, -0.00359963f, -0.12700211f, 
    0.15038712f, -0.05612350f, -0.02817190f, 0.12689339f, 0.00461066f, -0.12353006f, 0.05787962f, 0.02496949f, 
    -0.12035675f, -0.18191478f, 0.26160651f, -0.13160555f, 0.02828572f, 0.06462612f, 0.04778564f, 0.13156508f, 
    0.05219605f, 0.17180231f, 0.11342411f, 0.02322681f, 0.02550808f, 0.09638319f, 0.11752030f, 0.13040048f, 
    0.08820883f, 0.04332284f, 0.09694316f, -0.01772709f, 0.04040423f, 0.19804691f, -0.10887601f, 0.07800384f, 
    -0.12764697f, -0.15516590f, 0.11485309f, 0.06307495f, -0.02478666f, -0.03083649f, -0.13112061f, 0.03127696f, 
    0.13071141f, -0.03764894f, -0.01436805f, 0.15053208f, -0.00673757f, 0.14482298f, -0.05695250f, -0.16494255f, 
    -0.07273784f, -0.24158214f, -0.03496628f, -0.12338704f, -0.03163052f, -0.11075269f, 0.00571376f, -0.00336982f, 
    0.00477872f, 0.05394844f, 0.04950943f, -0.08394329f, -0.15648502f, -0.01977300f, -0.13814399f, -0.05746196f, 
    0.09028853f, -0.01572193f, 0.06588559f, -0.06937758f, -0.03237079f, 0.18478486f, -0.29583430f, -0.03252896f, 
    -0.17309260f, 0.09446406f, 0.14912681f, 0.27551228f, 0.04544781f, -0.05531039f, 0.15850037f, 0.03379234f, 
    -0.01037704f, -0.01774297f, -0.00266659f, 0.14221755f, 0.07573665f, 0.00888804f, 0.12763231f, 0.01381158f, 
    0.00078193f, -0.28681034f, -0.02296385f, -0.11344837f, -0.40563574f, -0.04787866f, -0.25738969f, -0.01578966f, 
    0.09516954f, 0.19804469f, -0.04195993f, -0.02513006f, 0.09794113f, 0.02167566f, -0.04080689f, 0.05520712f, 
    0.00187430f, -0.06953798f, -0.31748804f, -0.27470016f, 0.12429257f, 0.20541608f, 0.16231988f, -0.06134643f, 
    -0.01479724f, -0.03101680f, 0.05953649f, 0.15105045f, 0.09397572f, -0.08113001f, 0.05320866f, 0.04385585f, 
    0.14497356f, 0.05160638f, -0.07866435f, 0.06378262f, 0.03886507f, 0.07700580f, 0.13579206f, 0.02853294f, 
    -0.00617194f, 0.51573497f, -0.42590702f, -0.04301243f, -0.05320661f, 0.00862780f, 0.04080988f, 0.06355730f, 
    0.07224469f, -0.00842696f, 0.04838762f, -0.01600532f, -0.00905689f, -0.01154251f, -0.01776377f, 0.07411839f, 
    -0.00395539f, -0.13605630f, 0.05124363f, -0.00222855f, 0.06572846f, -0.44625878f, -0.05722471f, 0.18825911f, 
    -0.10031981f, 0.00091897f, 0.10029493f, 0.07285927f, -0.10307347f, -0.04439686f, 0.15769733f, 0.00368762f, 
    -0.02153606f, -0.06744216f, 0.06515491f, 0.01615295f, 0.15494324f, -0.06994219f, -0.05659430f, 0.02325927f, 
    -0.28980747f, 0.31578875f, 0.31786880f, -0.09541073f, 0.02070559f, -0.00732413f, 0.01221071f, 0.13637915f, 
    -0.00729667f, -0.01503002f, 0.05670603f, -0.04980003f, 0.02320117f, -0.00883967f, -0.01548933f, -0.07397271f, 
    0.01312987f, 0.01998865f, -0.02629795f, -0.13439001f, -0.10539185f, 0.03646688f, -0.16242683f, -0.06944191f, 
    0.05689577f, -0.06678958f, -0.04454301f, 0.09739318f, 0.00491176f, -0.03016359f, -0.02917016f, 0.00653098f, 
    -0.11609459f, 0.07123554f, 0.03720808f, 0.16051573f, -0.04144913f, -0.07747142f, -0.04610006f, 0.06648914f, 
    0.01290374f, -0.02056874f, -0.02018251f, 0.14080748f, -0.27033561f, 0.05464581f, 0.04057090f, 0.04259967f, 
    0.04324415f, -0.05167412f, 0.07159798f, 0.00749830f, 0.01487459f, 0.09041054f, 0.08189028f, -0.05428743f, 
    -0.00931214f, -0.13028941f, 0.14890690f, 0.10547020f, 0.38124460f, -0.09292875f, 0.07567824f, 0.03289998f, 
    -0.15063804f, 0.00723378f, 0.04064488f, 0.07752528f, 0.03896485f, -0.02461842f, -0.10032185f, 0.08316474f, 
    -0.01444643f, -0.17428482f, -0.02005665f, -0.04046448f, -0.00211283f, 0.00891689f, -0.06522133f, -0.16499454f, 
    -0.16593920f, -0.14697993f, 0.39068320f, -0.04281457f, -0.02435280f, -0.19065170f, 0.05716260f, 0.12423653f, 
    0.10554551f, -0.07910053f, -0.03711982f, -0.01515109f, 0.01165844f, 0.09851965f, 0.03550086f, -0.06402843f, 
    0.05123179f, 0.03909790f, 0.00285585f, 0.09762131f, 0.16454987f, 0.21214242f, 0.08107304f, 0.16209871f, 
    0.05311514f, -0.06989349f, 0.15381721f, 0.04485119f, 0.05803561f, 0.00671785f, -0.10197033f, 0.01501372f, 
    0.02759100f, -0.23842944f, 0.01156789f, 0.06329884f, 0.06659853f, -0.21831986f, -0.15092322f, -0.12325229f, 
    0.03213619f, -0.28393900f, 0.23217516f, 0.10403349f, -0.14438742f, -0.15389718f, -0.09181879f, 0.04533982f, 
    -0.01318411f, 0.03489294f, -0.01064728f, 0.02212836f, 0.04845955f, 0.05366864f, 0.05895121f, -0.15038775f, 
    0.10550229f, -0.05399635f, 0.01180242f, 0.07559421f, 0.28645170f, -0.13725905f, 0.09347121f, 0.13499710f, 
    -0.13058138f, -0.07587619f, -0.08146916f, -0.13293239f, 0.16300993f, 0.03529708f, 0.04825149f, 0.09254639f, 
    0.02435198f, 0.09751578f, -0.06145186f, -0.00763015f, 0.03874300f, -0.17335935f, 0.04427979f, -0.09462032f, 
    0.28556007f, -0.10785054f, -0.20314607f, 0.24026155f, 0.05629357f, -0.05635978f, -0.17757446f, -0.08324352f, 
    0.16935909f, 0.12696734f, -0.27091897f, 0.07032612f, -0.10670456f, -0.01109826f, -0.02022793f, -0.12322281f, 
    0.03258212f, -0.18998510f, 0.03037166f, 0.18003935f, -0.06908195f, -0.14860709f, 0.19259979f, 0.13543831f, 
    -0.14373960f, 0.06348329f, -0.06733287f, 0.02536247f, 0.08779503f, -0.06994725f, 0.01307070f, 0.02812375f, 
    -0.03368292f, 0.07907532f, -0.06583772f, -0.08523484f, 0.08093017f, 0.06861553f, -0.03588961f, 0.02647105f, 
    0.03380260f, 0.29466087f, -0.11546518f, 0.02466233f, -0.07848903f, -0.02169666f, 0.06239082f, 0.12637945f, 
    -0.05732848f, 0.01453603f, -0.12941925f, 0.01050882f, -0.06440955f, -0.05778155f, -0.12113630f, 0.08318765f, 
    0.02180745f, 0.08631994f, -0.13141637f, -0.01299895f, -0.18136522f, -0.16224383f, 0.26228088f, 0.00549812f, 
    -0.21346262f, -0.11628570f, 0.06566306f, 0.04481946f, -0.02619415f, -0.04307440f, -0.07373980f, 0.07102492f, 
    0.03853104f, 0.00079548f, 0.03796162f, -0.02644854f, 0.08706529f, -0.10346695f, 0.06139270f, 0.08498997f, 
    0.00296317f, 0.25209275f, -0.03101074f, 0.11910424f, 0.09304531f, 0.05846247f, 0.07115258f, -0.08870765f, 
    -0.05906142f, 0.10338048f, -0.00036415f, 0.01968112f, 0.01881525f, -0.01724453f, -0.07399017f, -0.02614563f, 
    -0.05888684f, -0.13457790f, 0.00087774f, 0.02494108f, 0.08390571f, -0.03932616f, -0.08244543f, 0.04639061f, 
    0.10169148f, -0.06992818f, 0.07161874f, 0.02176157f, 0.09544580f, -0.03341987f, -0.02362749f, 0.00910987f, 
    0.07118052f, -0.02389693f, 0.02792304f, -0.08082060f, -0.16221254f, 0.01795981f, 0.05989321f, 0.08787491f, 
    -0.35805899f, 0.10956522f, -0.11329440f, 0.04564224f, -0.38989541f, -0.00022402f, -0.08240659f, 0.15255238f, 
    -0.07179586f, 0.12428988f, -0.24952042f, 0.04811516f, -0.04879889f, 0.07006097f, -0.03705638f, -0.00184659f, 
    0.05653175f, 0.02894234f, 0.04044211f, 0.00962470f, -0.24630824f, 0.10923689f, -0.12872227f, -0.27288055f, 
    0.25854489f, -0.00270245f, -0.11458481f, 0.16196525f, 0.11915143f, 0.15831521f, -0.10368554f, 0.04696892f, 
    -0.10060973f, -0.06290550f, -0.14306141f, 0.15991154f, -0.17708997f, -0.13517141f, 0.01690468f, 0.18049705f, 
    0.04453686f, 0.10242591f, 0.04154219f, 0.12928456f, -0.18791941f, 0.03942662f, 0.03770747f, -0.06730304f, 
    0.05304960f, 0.02117745f, 0.02934065f, 0.11041913f, -0.00816938f, 0.00420346f, -0.01155434f, 0.08886935f, 
    0.03861313f, -0.02779461f, 0.01140574f, 0.13149825f, -0.08010710f, 0.01431555f, 0.19953072f, -0.01888831f, 
    -0.04783191f, -0.04572553f, 0.08601250f, 0.01144509f, 0.03209934f, 0.03121686f, -0.16530517f, 0.11930133f, 
    -0.06183355f, -0.13532624f, -0.06782372f, 0.16966461f, -0.11621109f, 0.04463476f, -0.06883964f, -0.02146546f, 
    -0.14619996f, -0.16777965f, -0.02029445f, -0.08546472f, -0.11941628f, 0.05327227f, -0.08681832f, 0.04074240f, 
    0.10551501f, 0.11468475f, 0.01301195f, -0.08844781f, 0.09335187f, -0.01641532f, 0.09974146f, 0.06142159f, 
    0.17097984f, 0.11646110f, 0.08508041f, 0.22069685f, 0.09661461f, 0.16169684f, -0.18095313f, -0.04408200f, 
    -0.10986079f, -0.03079336f, -0.09378132f, -0.04195058f, 0.01356541f, -0.11647326f, -0.02545707f, 0.08169629f, 
    0.00387855f, -0.14638232f, 0.02920922f, 0.05850575f, -0.03232918f, 0.01875849f, -0.00086076f, -0.05996598f, 
    0.26241237f, -0.01496968f, -0.11769141f, 0.03458639f, -0.13503024f, -0.11040929f, 0.02921502f, -0.14378463f, 
    -0.11450216f, -0.05870566f, -0.10537583f, 0.01559716f, -0.09428241f, 0.07783827f, 0.00055579f, 0.05994343f, 
    0.14195450f, 0.11900158f, 0.15587781f, 0.07107405f, -0.05507775f, 0.42580733f, 0.15203628f, -0.08237661f, 
    0.16168986f, 0.12360922f, 0.15106085f, 0.09863354f, 0.01432032f, 0.01198838f, 0.00969737f, -0.00981512f, 
    0.08895590f, -0.16991307f, 0.04240441f, -0.02324497f, -0.22444607f, -0.14442872f, -0.04782094f, -0.08696153f, 
    -0.22109245f, 0.04232171f, 0.22117759f, -0.11334807f, 0.01078322f, 0.03263535f, -0.09246761f, 0.04088182f, 
    -0.02146177f, -0.03450750f, 0.07080945f, -0.02119485f, 0.00749646f, 0.02103155f, 0.08541366f, 0.05852739f, 
    0.09319660f, 0.12093735f, 0.03742182f, 0.05627993f, -0.01055110f, -0.00843307f, -0.06873401f, 0.16183573f, 
    -0.05394185f, -0.05103787f, -0.10723972f, 0.05319637f, -0.15672202f, -0.21765882f, 0.07749718f, 0.02741833f, 
    0.03721011f, 0.12211237f, 0.06342433f, 0.17456859f, 0.05814242f, 0.21971515f, 0.21500508f, 0.03793588f, 
    -0.04635041f, 0.11252213f, 0.04745232f, -0.13386409f, 0.24869043f, 0.01570803f, -0.07019234f, -0.03733859f, 
    0.07089978f, 0.12680940f, -0.07833193f, 0.06563051f, -0.01057781f, -0.11965170f, -0.02191038f, 0.06554234f, 
    0.04196065f, -0.07779154f, 0.14449875f, 0.12302269f, 0.04235032f, 0.04322021f, 0.03357846f, -0.01683860f, 
    -0.07086122f, -0.04092228f, -0.01257531f, 0.04923667f, -0.00081019f, 0.00754339f, 0.02890795f, 0.00295252f, 
    0.06774263f, 0.02561965f, 0.15694170f, -0.04063345f, 0.22647473f, 0.05945285f, 0.18645963f, 0.22293217f, 
    -0.02819648f, 0.15360738f, 0.01887480f, 0.05058631f, 0.01131811f, 0.09826602f, 0.09315112f, 0.13701722f, 
    -0.05079994f, 0.07939257f, 0.13292691f, 0.09611129f, -0.00117078f, -0.18453664f, -0.08802156f, -0.12999693f, 
    -0.14122605f, -0.01607160f, -0.04486576f, -0.22854997f, -0.24282874f, 0.07298171f, 0.00757370f, 0.08023986f, 
    -0.16035911f, 0.00863758f, 0.01756565f, 0.06115212f, -0.12852748f, -0.04508799f, -0.00769028f, 0.03798207f, 
    -0.01232335f, -0.01534909f, -0.05374931f, 0.08152437f, 0.05766624f, 0.24357904f, -0.00406304f, 0.16693448f, 
    0.02830915f, -0.11271387f, -0.17039329f, 0.06169596f, 0.04763548f, 0.14478485f, 0.09009478f, 0.06325447f, 
    0.04723277f, 0.07363712f, -0.15260909f, -0.04735330f, -0.03030705f, -0.02394503f, 0.03101343f, 0.06793717f, 
    0.00693928f, 0.05211277f, -0.06487148f, 0.17853396f, -0.16572493f, 0.03298679f, -0.05672513f, -0.02615932f, 
    -0.03620356f, -0.07980108f, -0.08078561f, 0.00800043f, -0.05516925f, -0.17482989f, 0.04478773f, 0.07669549f, 
    0.09333497f, 0.06671759f, 0.06010357f, 0.14131525f, 0.13026325f, 0.17096080f, 0.18707028f, 0.14519891f, 
    -0.26275903f, -0.11961363f, 0.01004629f, 0.01227671f, 0.03040508f, -0.08209631f, -0.00500702f, 0.12091094f, 
    -0.28914860f, -0.11913452f, -0.07177849f, -0.04218996f, -0.06934363f, -0.03458406f, 0.03830917f, -0.05671167f, 
    -0.00869212f, -0.06467202f, -0.13995954f, -0.01481960f, 0.03424202f, 0.05211825f, -0.02957585f, -0.00165146f, 
    -0.04244857f, 0.22938368f, 0.13682185f, 0.01434171f, 0.07634591f, 0.17028764f, -0.06768695f, -0.00933273f, 
    -0.08683311f, -0.08116888f, -0.18830794f, -0.00762249f, -0.12116443f, 0.00261593f, -0.04791405f, -0.14075173f, 
    -0.02109743f, -0.03397613f, 0.00993275f, 0.03596162f, 0.02763759f, -0.02338758f, -0.01739099f, -0.03027996f, 
    0.02432389f, 0.03237740f, 0.00082186f, 0.01289820f, -0.00490584f, -0.02105767f, 0.00398725f, -0.02569711f, 
    -0.02406657f, -0.01086117f, -0.04969747f, -0.01002223f, -0.01554172f, -0.00798522f, -0.04399518f, -0.05665752f, 
    -0.06342073f, -0.03724267f, 0.02460830f, 0.00402863f, 0.03720903f, -0.00049832f, 0.01208642f, -0.04018841f, 
    0.02802431f, 0.00823354f, 0.03270626f, -0.05719117f, -0.03048863f, -0.04236969f, -0.00116359f, -0.04108502f, 
    0.00185759f, -0.05174427f, -0.05875144f, 0.03438465f, 0.04545578f, -0.04374177f, -0.04886267f, 0.04001474f, 
    -0.06243572f, -0.04176700f, -0.02324108f, 0.03972821f, -0.03416334f, 0.02584660f, -0.05477918f, 0.04348616f, 
    0.04805403f, -0.04603248f, 0.02703276f, 0.00650403f, 0.02864443f, -0.02528344f, -0.03822304f, -0.06000103f, 
    -0.02453934f, -0.04727471f, -0.04951566f, 0.01047082f, 0.03446189f, -0.03150891f, -0.03669315f, 0.00778972f, 
    0.03437440f, -0.00527397f, -0.00186066f, -0.03476929f, -0.00375516f, 0.02380489f, -0.00773055f, 0.02899236f, 
    0.01264074f, -0.01363416f, -0.00630996f, -0.02579600f, 0.01111423f, 0.03983019f, -0.00387370f, 0.00617364f, 
    -0.03916252f, -0.00559200f, 0.02944687f, 0.02214037f, -0.00699008f, -0.04248294f, 0.01990742f, 0.01068069f, 
    -0.04092405f, -0.00477000f, -0.05292542f, -0.01270293f, -0.02304067f, -0.01731799f, -0.02950912f, 0.04502715f, 
    -0.04350957f, 0.04257607f, 0.00528364f, -0.05531934f, 0.03306906f, -0.00606176f, -0.01597982f, -0.05484701f, 
    -0.00557411f, -0.00867761f, -0.02119205f, -0.02009566f, -0.01740166f, 0.02150844f, -0.00313699f, -0.00003598f, 
    -0.01327806f, -0.00492515f, -0.00384903f, -0.05941444f, 0.01021255f, -0.01554463f, -0.01768926f, -0.04676501f, 
    0.00285849f, 0.01561992f, -0.04323754f, -0.06019820f, 0.01446174f, -0.00418015f, 0.00510970f, 0.04273548f, 
    -0.01555437f, 0.02097136f, -0.01819199f, -0.03508113f, -0.04098011f, 0.02087395f, 0.00001746f, -0.04574577f, 
    0.03380451f, 0.05167842f, -0.00199056f, -0.04821096f, -0.03583444f, -0.03844934f, 0.03696354f, 0.02828266f, 
    0.00258122f, 0.01291621f, 0.00993800f, 0.04460996f, -0.05185596f, 0.04866161f, -0.03878080f, -0.00297843f, 
    -0.02517902f, -0.01303113f, 0.01514132f, -0.03397826f, 0.02436009f, 0.03934997f, -0.02688689f, -0.00693570f, 
    -0.01106835f, -0.02092927f, -0.04919723f, 0.02986481f, 0.01020302f, 0.03778261f, 0.03014558f, 0.00787230f, 
    -0.04445462f, -0.05928234f, 0.04696868f, -0.06364890f, 0.03959434f, 0.04031494f, -0.05161177f, -0.04539923f, 
    0.02183983f, 0.01309515f, -0.02461081f, -0.04953753f, 0.03428145f, 0.02120926f, -0.00537795f, -0.04272313f, 
    0.02543118f, 0.03334542f, -0.01900682f, -0.04789589f, 0.02370482f, -0.03375724f, -0.00189183f, 0.04637470f, 
    0.03675299f, 0.01288209f, 0.00989631f, -0.02004666f, -0.05126151f, -0.00523154f, -0.03837410f, 0.01299601f, 
    -0.04046766f, 0.03844684f, -0.00948957f, -0.02079895f, 0.04569761f, 0.03574204f, -0.01005223f, -0.05239804f, 
    -0.03136872f, -0.03619109f, -0.00402024f, -0.02637226f, 0.00899770f, 0.00801454f, 0.03832438f, -0.03611264f, 
    -0.03935946f, 0.03645021f, -0.02363678f, -0.03039740f, -0.03923193f, 0.00609030f, -0.01006970f, 0.02761297f, 
    -0.01772301f, -0.00921291f, -0.05001995f, -0.00315907f, 0.03175933f, -0.06063978f, -0.01056759f, 0.01925745f, 
    -0.06206125f, 0.01209985f, 0.00614209f, -0.03383849f, -0.05104970f, -0.01547727f, -0.01670447f, -0.04080043f, 
    0.00074689f, -0.05499078f, 0.02246375f, -0.00850892f, 0.01587594f, -0.02640914f, -0.05991035f, 0.00033221f, 
    -0.01718705f, -0.04559797f, 0.03422520f, -0.00345688f, -0.03814682f, -0.04984356f, -0.01041990f, -0.02849979f, 
    0.01468709f, 0.04776609f, -0.02075085f, -0.04803472f, -0.03029994f, -0.03731910f, 0.04469525f, -0.03706621f, 
    0.01619647f, -0.02538238f, -0.02346753f, -0.00300595f, -0.02169350f, 0.00929821f, -0.02616996f, 0.02385959f, 
    -0.01721639f, 0.00415807f, 0.03776556f, -0.01961843f, 0.00725338f, -0.04685408f, -0.01663443f, -0.01280891f, 
    -0.01308582f, -0.02745838f, -0.00030606f, 0.03853299f, -0.04995673f, 0.02116280f, 0.01708616f, 0.00977124f, 
    -0.01546256f, 0.03317897f, -0.03138911f, 0.04377341f, -0.03075679f, 0.03451579f, 0.04585114f, -0.02907837f, 
    0.01088431f, 0.04038425f, 0.01739138f, -0.00272785f, -0.00457805f, -0.00017770f, -0.05763854f, 0.04035120f, 
    0.02424283f, 0.03640933f, -0.02445519f, -0.00710551f, -0.02533719f, -0.00312577f, -0.04536313f, 0.03053223f, 
    -0.01033372f, -0.16346142f, -0.00696320f, 0.15698560f, -0.00100748f, 0.08335066f, 0.08900209f, -0.13340378f, 
    -0.03104759f, 0.04479472f, 0.03403940f, 0.04977230f, 0.00141044f, -0.00847608f, 0.11635777f, -0.03252075f, 
    -0.00677255f, -0.06299438f, -0.02176083f, 0.21765089f, 0.07912451f, -0.02299433f, 0.09693073f, -0.09057593f, 
    0.14980049f, 0.10425220f, -0.03935662f, 0.02386676f, 0.14691201f, 0.00454220f, -0.01218395f, 0.03751955f, 
    -0.01478879f, 0.01091171f, 0.07220643f, 0.07932025f, -0.01579234f, 0.04655173f, -0.00475436f, -0.07902865f, 
    0.00903801f, -0.10925439f, -0.17880078f, 0.16253100f, 0.17098776f, -0.03877049f, 0.07694566f, -0.07688736f, 
    0.00276414f, -0.07515196f, -0.05991993f, -0.03554000f, -0.01022114f, 0.12128958f, -0.05491542f, 0.05297333f, 
    0.05592871f, 0.04133785f, 0.02034162f, 0.11957624f, -0.38191414f, 0.16227788f, 0.17139110f, -0.05995408f, 
    0.15327249f, -0.02966109f, -0.03276452f, 0.15587996f, -0.07690734f, 0.13662431f, 0.03794866f, 0.07138178f, 
    0.06610989f, -0.00795320f, -0.06301859f, 0.00485054f, -0.12712909f, -0.05800467f, -0.07733309f, -0.06294364f, 
    -0.00623432f, -0.16227573f, -0.24156155f, -0.08071864f, 0.04836993f, 0.12861252f, 0.01323438f, -0.04966734f, 
    -0.07640918f, 0.05943582f, -0.04396484f, 0.01140208f, 0.04423999f, 0.09927157f, -0.00642446f, -0.02484078f, 
    -0.01353517f, -0.01003132f, -0.03582880f, -0.01321386f, -0.24619113f, 0.08842032f, -0.03411483f, 0.24831541f, 
    0.15829520f, 0.07063451f, -0.01496960f, 0.12202405f, -0.01720222f, -0.07297923f, -0.09713028f, -0.02899472f, 
    -0.07820376f, 0.06317466f, -0.01223955f, 0.06943295f, -0.10154658f, -0.10217205f, -0.00112804f, -0.00262053f, 
    0.02865444f, 0.01682181f, 0.18409382f, 0.09557083f, 0.05046964f, 0.05703694f, -0.03670024f, 0.04019240f, 
    0.00704510f, -0.03430684f, 0.03049236f, -0.05378361f, 0.02863108f, 0.01073454f, 0.11139731f, 0.10582542f, 
    0.02278538f, 0.12694602f, 0.19912149f, 0.00776203f, -0.08364207f, -0.09069935f, 0.02145557f, -0.12206867f, 
    0.05936550f, -0.19164157f, -0.05134444f, -0.09504712f, 0.00625286f, 0.00398528f, -0.10187709f, -0.01916365f, 
    0.01659832f, -0.05932563f, 0.09628279f, 0.12543161f, -0.09284931f, 0.03567445f, 0.13820197f, -0.02800114f, 
    -0.03475478f, 0.48937729f, -0.13488071f, 0.12835154f, 0.02469218f, 0.09230792f, 0.11643894f, 0.01029550f, 
    0.04023277f, 0.05601668f, -0.00281118f, -0.05573390f, 0.02548352f, 0.10607888f, -0.05683580f, 0.13934973f, 
    0.11772212f, 0.06524985f, 0.12067835f, 0.07717830f, -0.09788375f, -0.15798835f, 0.18436964f, -0.08681686f, 
    0.19179405f, 0.03020320f, 0.01408145f, 0.04937624f, 0.01616050f, -0.01036448f, -0.01170100f, 0.04460155f, 
    0.12059508f, 0.13611761f, 0.06009809f, -0.00164110f, 0.14627437f, 0.11466435f, 0.11328697f, 0.16426119f, 
    -0.13682143f, -0.15352590f, -0.07355192f, 0.06138690f, -0.08141040f, 0.02302365f, -0.26648164f, 0.04914012f, 
    0.03554543f, -0.13340485f, 0.08298969f, 0.03295611f, 0.00663804f, -0.15269011f, -0.00068429f, 0.05034754f, 
    -0.10093974f, -0.16279690f, -0.08401536f, -0.00077482f, 0.22552589f, -0.04655366f, 0.15497175f, -0.09778268f, 
    0.08613199f, -0.02559313f, 0.02107482f, -0.00496674f, 0.06500406f, -0.12675269f, -0.14890419f, -0.04232429f, 
    0.01346629f, 0.11185939f, 0.05465128f, -0.09606003f, 0.02215213f, 0.18824185f, -0.02983301f, 0.13795824f, 
    -0.21920377f, -0.19169958f, -0.07216501f, 0.14668134f, 0.15140077f, -0.02784675f, 0.10857528f, -0.03268325f, 
    -0.02726210f, -0.17050785f, -0.02710384f, -0.08376078f, -0.06752359f, 0.00961455f, -0.03246345f, -0.00178440f, 
    -0.00880904f, 0.06447732f, -0.13730656f, 0.13935117f, -0.15457946f, -0.08089951f, -0.15104879f, -0.13299033f, 
    -0.14934342f, -0.13369308f, -0.09478857f, -0.16661102f, -0.13172616f, -0.10829990f, -0.09583554f, -0.04999170f, 
    -0.02004218f, -0.05571285f, -0.07633405f, -0.07004256f, 0.08799670f, 0.05706155f, 0.08516649f, -0.09066636f, 
    0.37258098f, -0.48577783f, 0.26423737f, -0.03440230f, 0.04204197f, -0.02259234f, 0.09470762f, -0.12486047f, 
    0.01970156f, -0.06347518f, 0.00400544f, 0.07172926f, -0.04053326f, -0.00378886f, 0.02193751f, -0.12817328f, 
    -0.09914467f, -0.00158274f, -0.03661790f, 0.01120297f, 0.14207077f, 0.06595788f, -0.14439622f, 0.22063287f, 
    -0.11400557f, 0.08159266f, -0.04849831f, 0.02143738f, 0.10907960f, 0.10717754f, -0.04348821f, -0.04209357f, 
    0.12770683f, -0.06747094f, 0.05913406f, -0.04923930f, -0.12929784f, 0.12460320f, 0.00691571f, -0.14051588f, 
    -0.23547187f, -0.19634703f, -0.41929007f, -0.35777923f, 0.23847063f, 0.00148274f, -0.00055727f, 0.15121727f, 
    0.02419342f, -0.00029923f, -0.16021159f, 0.02710184f, -0.00348918f, 0.09244414f, 0.01368155f, 0.00595263f, 
    -0.04972947f, 0.01397916f, 0.13557900f, -0.21059386f, 0.02971725f, -0.07580976f, -0.05556556f, -0.16442207f, 
    0.12716889f, -0.04934752f, 0.19204059f, 0.01633755f, -0.06263192f, 0.00741466f, 0.01764009f, -0.07046404f, 
    0.04088637f, -0.03542801f, -0.03341440f, 0.00655987f, 0.11851171f, -0.08012406f, 0.08985045f, 0.07534220f, 
    -0.04173338f, 0.18250865f, -0.03250007f, 0.12634112f, 0.14176330f, -0.09980325f, -0.08351574f, -0.14881185f, 
    -0.06356563f, -0.14643505f, -0.06466917f, 0.07086831f, -0.08261254f, -0.03207024f, 0.06290438f, 0.01151995f, 
    -0.13541019f, 0.12815732f, -0.16986236f, -0.15941034f, -0.21577646f, 0.27989572f, 0.05490540f, -0.20762654f, 
    0.12025359f, -0.07281704f, -0.05670954f, 0.08795355f, 0.00874846f, 0.24612848f, 0.04582382f, 0.08418669f, 
    0.06379662f, 0.10537913f, 0.03374083f, 0.06875649f, 0.00896687f, -0.10345901f, 0.01607480f, 0.04259947f, 
    -0.11477417f, -0.05112941f, -0.01738581f, -0.04426978f, 0.17552826f, -0.02187833f, 0.09467691f, -0.11518060f, 
    -0.04190065f, -0.01577100f, 0.13050745f, 0.16640161f, 0.21356519f, 0.10924325f, 0.13397707f, 0.05112895f, 
    -0.04025330f, -0.11249661f, -0.00219679f, -0.08816260f, 0.37903744f, -0.21441342f, -0.37759867f, -0.02061525f, 
    -0.00302117f, 0.02921003f, -0.07977725f, -0.02558733f, 0.10639407f, 0.11802516f, -0.05148417f, 0.06239408f, 
    0.07542179f, -0.02219857f, -0.07583673f, 0.02916545f, 0.17034940f, 0.19696163f, 0.06992155f, 0.07906813f, 
    0.19971892f, -0.01346678f, 0.16098601f, 0.15969954f, 0.02783641f, -0.01701250f, 0.07134972f, 0.02676195f, 
    0.00330987f, 0.07032490f, 0.07057066f, -0.03025820f, 0.00524352f, -0.09113484f, 0.02459387f, 0.09329578f, 
    -0.03900035f, -0.03935051f, -0.02311251f, 0.03968199f, -0.01845902f, 0.16554202f, 0.08264966f, -0.03449200f, 
    0.18037912f, 0.04355450f, -0.02264656f, -0.01476895f, 0.02740702f, -0.00906516f, 0.01324962f, -0.04111345f, 
    -0.07649477f, 0.02220677f, 0.09124070f, 0.18109043f, -0.01356226f, -0.05191018f, -0.16676542f, -0.04542083f, 
    -0.03312353f, 0.10234983f, 0.02837141f, 0.14055337f, -0.13599618f, 0.09665396f, 0.15325373f, 0.20154175f, 
    -0.09400348f, 0.02503322f, 0.13015364f, 0.11063458f, 0.12391940f, 0.10696128f, 0.09224067f, -0.03989803f, 
    0.12559552f, 0.20406999f, -0.25066945f, -0.00024334f, -0.04149299f, -0.01796189f, 0.11725642f, 0.10189093f, 
    0.01789834f, 0.05272429f, -0.00371274f, 0.06923871f, 0.02365848f, -0.05912804f, 0.18108208f, -0.00552404f, 
    -0.14873701f, 0.14707622f, 0.06782755f, -0.05670044f, 0.06097444f, 0.00551671f, 0.03265959f, -0.17260559f, 
    0.06371147f, -0.23212679f, -0.29476106f, -0.15557709f, 0.01931207f, -0.13474019f, -0.03859927f, -0.12834723f, 
    -0.06481023f, -0.16680543f, 0.01650628f, -0.01583044f, 0.00973229f, 0.12057165f, 0.05918820f, 0.02793539f, 
    -0.00847990f, 0.26648167f, 0.13809130f, 0.14989027f, 0.25463334f, -0.02974975f, 0.01421421f, -0.19222139f, 
    0.08792698f, -0.02841655f, 0.00519126f, 0.10082864f, 0.13061665f, 0.01070390f, 0.03085666f, -0.00155979f, 
    -0.03647146f, -0.10228211f, 0.04655249f, -0.01478253f, 0.02975700f, -0.12662566f, 0.09083287f, 0.04486303f, 
    -0.55334097f, -0.37727901f, -0.16184497f, -0.30128554f, -0.17916250f, -0.08743663f, -0.00612904f, 0.01017922f, 
    -0.01887570f, -0.04148158f, 0.03753433f, 0.06531528f, -0.03868006f, 0.01484506f, 0.05015824f, 0.02976354f, 
    -0.05104919f, 0.13379952f, 0.16736014f, -0.23342712f, 0.22962622f, 0.08986363f, 0.10880640f, -0.03296677f, 
    -0.07100604f, 0.02216452f, 0.01552042f, 0.06530911f, 0.03932329f, 0.03873678f, -0.12713082f, -0.04316336f, 
    -0.13246560f, -0.22046959f, -0.15587324f, 0.06001582f, -0.01039211f, 0.00381759f, -0.04273535f, 0.05124328f, 
    0.21630330f, -0.30517551f, 0.13971607f, -0.04111142f, -0.02399398f, 0.00108849f, 0.04568396f, 0.15426913f, 
    0.21415429f, -0.11159276f, 0.02874338f, -0.03925886f, -0.06446030f, -0.08790016f, -0.04865424f, 0.08400632f, 
    0.00885902f, 0.10372739f, 0.12539583f, 0.07394166f, 0.04747052f, -0.08549505f, -0.09609985f, -0.05380189f, 
    0.24609916f, -0.04376289f, -0.01312603f, 0.02938465f, -0.13908902f, -0.04676425f, -0.10555896f, 0.05737609f, 
    0.09109987f, 0.01050718f, 0.09906696f, 0.11539656f, 0.05351558f, -0.14312920f, 0.16950034f, 0.07789216f, 
    0.06066649f, -0.21608990f, 0.23257081f, 0.16266292f, 0.02811580f, 0.19131941f, -0.00504175f, 0.00815280f, 
    0.10138223f, 0.00611487f, 0.06305572f, 0.05909659f, -0.11563616f, -0.03584675f, 0.06658806f, 0.03094401f, 
    0.06821609f, -0.07697897f, 0.09722929f, 0.17233203f, 0.07286959f, -0.08178169f, 0.04695904f, 0.15165719f, 
    -0.01974222f, 0.06211544f, -0.04944431f, 0.02317508f, 0.02602394f, 0.07490777f, -0.05315330f, 0.09493424f, 
    -0.01410960f, 0.04780994f, 0.05058223f, 0.11133783f, -0.14018711f, -0.05280787f, -0.05875880f, -0.07760729f, 
    0.00554893f, -0.19714092f, 0.14715505f, 0.07346307f, 0.30501291f, -0.03878961f, 0.03537847f, -0.00161592f, 
    0.08728871f, 0.01116436f, -0.03711613f, -0.00606113f, 0.03234725f, 0.00959017f, -0.16841926f, 0.03519754f, 
    0.14667477f, 0.19989668f, 0.04498124f, 0.09483918f, -0.27703178f, 0.13848826f, -0.08424933f, -0.01028223f, 
    -0.05658750f, -0.02078907f, -0.01150148f, -0.03924339f, -0.13304429f, 0.28079471f, -0.09343731f, 0.06459454f, 
    -0.02032585f, 0.08154616f, -0.08116600f, -0.07340045f, -0.01993280f, -0.09377673f, 0.03452608f, 0.00513241f, 
    0.01314880f, -0.18883020f, -0.21107128f, -0.16561045f, -0.03978363f, 0.08935576f, -0.13724589f, -0.06875333f, 
    -0.13986950f, -0.02667045f, -0.07082532f, -0.08667778f, -0.07293405f, -0.08180296f, 0.15743877f, 0.10221332f, 
    -0.01340550f, 0.06568211f, -0.03080176f, -0.14274177f, -0.23852415f, -0.11005470f, -0.00915345f, 0.22595295f, 
    0.09758157f, -0.03824925f, 0.01513069f, 0.08760843f, -0.14558467f, 0.05527883f, -0.12106748f, -0.00366960f, 
    0.03509374f, 0.06423312f, -0.03661321f, -0.01308449f, -0.09030039f, -0.14588334f, -0.00468761f, -0.05534992f, 
    -0.11045161f, 0.16750017f, -0.06093574f, 0.01897837f, 0.19900456f, 0.00813027f, 0.01363778f, 0.13814297f, 
    0.05176453f, -0.06558232f, -0.12836736f, -0.08404566f, 0.09545612f, -0.05862840f, 0.15272555f, 0.13347952f, 
    -0.07001258f, 0.17075698f, 0.01588865f, -0.09617799f, -0.49700746f, -0.18377370f, -0.04578468f, -0.25107408f, 
    -0.11876796f, -0.11384583f, -0.04404601f, -0.04440974f, -0.09897732f, 0.16582999f, 0.03918016f, -0.01147897f, 
    -0.01079789f, 0.02018995f, 0.10948295f, -0.04333021f, -0.17453094f, 0.02368892f, 0.16669396f, 0.05485040f, 
    -0.21813391f, -0.03938711f, 0.04913756f, 0.08869225f, 0.15942356f, 0.09700260f, 0.11918764f, -0.08013599f, 
    0.15642554f, -0.01451229f, -0.02709170f, -0.06755746f, 0.08539277f, -0.11253267f, -0.07004193f, 0.04146867f, 
    0.07407133f, -0.01256482f, 0.09622788f, 0.04900461f, -0.18728632f, 0.02731759f, 0.12430877f, -0.04263011f, 
    -0.15865897f, -0.13096985f, 0.09017957f, 0.08055871f, 0.08397809f, -0.03719115f, 0.03166240f, -0.10798944f, 
    0.15818010f, -0.04165211f, 0.09320448f, 0.02357670f, 0.09392106f, 0.12794353f, 0.16822478f, 0.18996006f, 
    0.01382064f, -0.09941169f, 0.02897966f, -0.04238099f, 0.05782718f, -0.00312116f, -0.17182556f, 0.09298029f, 
    0.04461335f, 0.05767344f, 0.07799128f, 0.03024691f, -0.03300071f, -0.05101786f, -0.04842885f, -0.02162756f, 
    -0.09120965f, -0.05456943f, -0.05344913f, -0.11221318f, -0.08138534f, 0.04803526f, -0.07333001f, 0.04751790f, 
    -0.02890156f, 0.03093665f, 0.02763374f, 0.12473487f, 0.09581905f, -0.11262952f, -0.10382951f, -0.05028259f, 
    0.03352207f, 0.00571607f, 0.02487543f, -0.05067565f, 0.07081550f, 0.21098566f, -0.04681093f, -0.00698087f, 
    -0.10189652f, -0.13414317f, 0.02671727f, 0.11619971f, 0.03180033f, -0.00893988f, -0.00791315f, 0.08306021f, 
    -0.10951740f, -0.06936806f, -0.01352893f, -0.02456995f, -0.17704757f, -0.11077456f, 0.03172907f, -0.02048470f, 
    0.05223501f, -0.01449182f, -0.00534825f, 0.05065400f, -0.22124690f, -0.06945343f, -0.16637446f, -0.13533743f, 
    -0.25600624f, 0.10013178f, -0.14936754f, -0.07147016f, 0.10421403f, -0.01512413f, 0.04693730f, -0.00041753f, 
    -0.09677367f, -0.10808728f, 0.01804363f, -0.03249329f, 0.04036849f, -0.01974497f, 0.06867442f, -0.06221873f, 
    0.48883158f, -0.05360655f, -0.00669879f, 0.04739109f, 0.37300369f, -0.00439437f, -0.02919402f, 0.12407679f, 
    -0.00869554f, -0.07593594f, -0.06674067f, 0.04893038f, 0.00051717f, -0.04712235f, 0.02253895f, 0.03254192f, 
    -0.05588518f, -0.02472109f, -0.09422307f, -0.03756512f, 0.29372945f, -0.06894003f, 0.08078420f, 0.48396772f, 
    -0.18101232f, 0.19238339f, -0.07674152f, 0.24946116f, 0.10443984f, 0.05695531f, -0.08719730f, -0.03371534f, 
    0.00518420f, -0.04309964f, 0.10815816f, 0.00815073f, -0.02911423f, 0.15208882f, 0.04669904f, 0.02828105f, 
    -0.00224101f, 0.02966401f, -0.02219933f, 0.03791714f, -0.02112981f, 0.00535465f, -0.04117288f, 0.03247051f, 
    0.01526120f, 0.00058840f, 0.02101082f, 0.00581388f, 0.02869504f, 0.04384883f, -0.02892088f, -0.05470779f, 
    -0.00505970f, -0.02517312f, -0.05103837f, 0.02223139f, -0.01111804f, -0.01991075f, -0.00125158f, -0.04720880f, 
    0.00511665f, 0.02449370f, 0.00892387f, 0.04498864f, -0.04356358f, -0.04085395f, 0.04619202f, 0.02858764f, 
    -0.04582705f, -0.03091544f, -0.02835059f, 0.01764499f, 0.00500711f, 0.04447373f, 0.05498303f, -0.04044349f, 
    -0.03770936f, -0.05175164f, 0.00697110f, -0.04636372f, -0.00312199f, -0.05711780f, 0.02607897f, 0.04724233f, 
    -0.04275965f, -0.02601624f, 0.00383407f, -0.00068298f, -0.00300725f, 0.00596335f, -0.05635748f, -0.04676452f, 
    0.00986388f, -0.03671737f, 0.02732521f, -0.01568297f, -0.03286077f, 0.04256824f, -0.00275571f, -0.02944271f, 
    0.04754971f, -0.00183126f, -0.04945998f, 0.02202063f, -0.04755976f, 0.04170576f, -0.03340286f, 0.04283858f, 
    0.02929057f, -0.01584217f, 0.05176188f, 0.03217570f, 0.01369186f, -0.00681538f, 0.01549930f, -0.04569677f, 
    0.04070732f, -0.00090159f, -0.00755257f, 0.02104726f, -0.01076497f, 0.01385992f, -0.00848606f, 0.03451659f, 
    -0.02230469f, -0.04210325f, 0.00591902f, 0.00004856f, -0.02510159f, -0.02163904f, 0.02260402f, 0.00163530f, 
    0.02123196f, -0.03791132f, -0.00546681f, 0.00680874f, 0.02677906f, -0.01252177f, 0.00847282f, 0.01811238f, 
    -0.05543566f, -0.05097323f, 0.03317136f, -0.04349693f, 0.02791745f, -0.02722218f, -0.01160747f, -0.00074178f, 
    -0.03348705f, 0.03614390f, -0.02009827f, -0.02438319f, -0.03569271f, -0.02152875f, -0.04967276f, -0.01128073f, 
    -0.01838501f, -0.02922364f, 0.01703511f, -0.03764158f, -0.02007743f, 0.03312176f, -0.02672148f, 0.04449490f, 
    -0.02627262f, -0.03546585f, -0.03905229f, 0.02992698f, -0.02156313f, -0.00914845f, -0.05845238f, -0.02670919f, 
    -0.02647091f, -0.02086207f, 0.03569317f, -0.03096445f, 0.03517821f, 0.01456903f, -0.00166995f, -0.01486543f, 
    0.01674391f, 0.04396618f, 0.03284299f, -0.03618484f, 0.00073410f, 0.03035272f, 0.00410244f, -0.03399841f, 
    0.04375560f, -0.02363767f, 0.00751001f, -0.00091952f, 0.04240284f, -0.00433037f, 0.01046282f, 0.04875002f, 
    -0.00198929f, 0.04514490f, -0.01576592f, -0.01042347f, -0.00698788f, -0.00384150f, 0.04744289f, -0.06230445f, 
    -0.05000261f, -0.04586581f, 0.03052390f, 0.02840656f, -0.05186238f, -0.06114437f, -0.02703133f, -0.04553727f, 
    0.00190809f, 0.00908245f, -0.03037449f, -0.01007896f, -0.05271108f, 0.04096849f, 0.00273237f, -0.00637553f, 
    -0.03293908f, 0.02180686f, 0.02593818f, -0.04790418f, 0.00188235f, -0.04584472f, 0.00094169f, -0.00462829f, 
    -0.01108818f, -0.02408888f, 0.02736690f, -0.02498407f, -0.02420205f, -0.02117285f, -0.00660946f, 0.00209803f, 
    0.02854827f, -0.06403504f, 0.00073566f, 0.05022123f, -0.02710960f, -0.03644001f, -0.00487139f, 0.01056693f, 
    0.01631043f, -0.01793584f, 0.01936444f, -0.00822505f, -0.03342132f, -0.03124712f, 0.03248671f, 0.04341369f, 
    -0.05425868f, -0.02686062f, -0.02359744f, -0.01986460f, -0.02828435f, 0.04858793f, -0.01794323f, -0.03594412f, 
    -0.04928347f, -0.03526249f, -0.02217711f, -0.02887235f, -0.06095595f, -0.05924657f, 0.00435343f, 0.00801338f, 
    0.03823806f, 0.02215899f, -0.04419666f, 0.04268619f, -0.03661235f, -0.04667315f, -0.03554393f, 0.02820062f, 
    0.04376430f, -0.05173680f, 0.04878303f, 0.04192299f, -0.05249834f, 0.01370103f, -0.04790390f, 0.01411723f, 
    -0.03731330f, -0.02368574f, 0.00183413f, 0.04110301f, 0.02905145f, -0.05188212f, 0.01802919f, 0.04695144f, 
    0.03085785f, -0.01050086f, -0.01907464f, 0.02652774f, -0.04779991f, -0.01417459f, 0.00732437f, -0.00000492f, 
    0.00965594f, -0.02554088f, -0.00594749f, -0.05668344f, 0.02450388f, -0.03807895f, -0.04129597f, -0.00722382f, 
    0.00083236f, 0.03119489f, -0.03695874f, -0.06162968f, 0.01744407f, -0.01501037f, -0.01847453f, -0.03269851f, 
    -0.05496542f, -0.04609560f, 0.01082639f, -0.00236528f, -0.04657768f, -0.04774701f, -0.01227079f, 0.02550220f, 
    -0.01473705f, 0.04123843f, 0.03189315f, -0.02520034f, -0.01436047f, 0.03687037f, 0.01031281f, -0.00318337f, 
    -0.03816525f, 0.03983589f, 0.02955863f, 0.02546805f, 0.04919029f, -0.04018696f, 0.03650121f, 0.04076768f, 
    0.02697719f, 0.05720362f, -0.03642471f, -0.00770890f, 0.04528735f, 0.03024108f, 0.01448587f, 0.03719085f, 
    -0.01796952f, -0.02189542f, -0.04588201f, 0.01150888f, -0.02854210f, -0.06256292f, 0.01081853f, -0.04630671f, 
    -0.03724143f, -0.01590820f, 0.02525066f, -0.02696567f, -0.02610420f, 0.03612993f, -0.03569796f, -0.06273983f, 
    -0.02541029f, -0.00124730f, 0.03890073f, 0.00376164f, 0.00494649f, 0.03987650f, 0.04534048f, -0.01583786f, 
    -0.04373515f, -0.04066071f, -0.03081026f, -0.02250633f, 0.01900115f, -0.02947985f, 0.03786952f, -0.00432970f, 
    0.03193636f, 0.04719666f, -0.05660241f, -0.00427364f, 0.03968912f, -0.00667595f, -0.03714053f, -0.00935547f, 
    -0.03852889f, -0.03363159f, -0.04678739f, -0.04203701f, -0.03656526f, 0.01043767f, -0.02956719f, -0.01907894f, 
    -0.06070101f, 0.02192740f, 0.02716321f, 0.01630493f, 0.00518559f, 0.00541510f, -0.02895001f, -0.00462452f, 
    0.02270603f, 0.01493574f, -0.02644239f, -0.03680393f, -0.06269962f, 0.00087741f, -0.01772492f, -0.04319105f, 
    -0.05879992f, 0.02468424f, 0.03960977f, -0.05532477f, -0.05918569f, -0.04794916f, -0.03165281f, 0.00524279f, 
    0.04329726f, -0.02480452f, -0.02568558f, -0.05001555f, -0.03815614f, 0.03418973f, -0.00535871f, 0.00016106f, 
    -0.01512490f, 0.02812825f, -0.00656179f, -0.03731373f, 0.03684473f, 0.00571550f, 0.04456792f, 0.01718331f, 
    0.00420340f, -0.03947172f, 0.03131429f, 0.01776155f, 0.01975849f, -0.01944278f, 0.01328551f, -0.05372664f, 
    -0.02511013f, 0.02077400f, 0.00755372f, -0.05765073f, -0.06230242f, 0.00158548f, 0.01540597f, 0.01606054f, 
    0.04162528f, -0.01426630f, -0.03948432f, -0.03706156f, -0.01768806f, 0.01072142f, 0.03960489f, -0.01271274f, 
    -0.00812739f, 0.03822956f, -0.01032285f, 0.02260249f, -0.03675345f, -0.02792824f, -0.01608719f, 0.02283145f, 
    0.03770992f, -0.05260657f, -0.01487113f, 0.03390513f, 0.04270933f, 0.02225643f, -0.00416934f, -0.00448469f, 
    0.04377417f, -0.05454092f, -0.01012067f, -0.01260408f, 0.02401980f, -0.05386055f, -0.06195848f, -0.01748716f, 
    0.01179898f, -0.01311489f, -0.02865539f, -0.04361286f, -0.04006543f, 0.02825506f, -0.02156051f, 0.02968063f, 
    0.02957669f, -0.03604163f, -0.01259107f, -0.02662586f, 0.00766721f, 0.01683613f, -0.04464287f, -0.05127098f, 
    -0.04687707f, 0.02687321f, -0.00209519f, 0.00167189f, -0.00644272f, 0.02434803f, -0.02164662f, 0.00618784f, 
    -0.02277825f, 0.02435192f, 0.00706038f, -0.00911492f, 0.01699901f, 0.00482889f, -0.02842588f, 0.04555800f, 
    -0.01791857f, -0.04595671f, 0.00682646f, -0.04622349f, -0.00832455f, -0.01842610f, -0.00763653f, -0.03960908f, 
    0.03124456f, -0.00559156f, -0.02961073f, -0.00652770f, -0.00343415f, -0.05862185f, 0.03188860f, -0.01039704f, 
    -0.01688091f, 0.01118597f, -0.06023615f, -0.04326837f, 0.04242709f, -0.03121657f, -0.04736658f, -0.01652806f, 
    -0.05255877f, -0.02550208f, 0.02337484f, 0.04085200f, -0.02021766f, -0.04341944f, -0.06087888f, 0.00420395f, 
    0.01644663f, -0.03421606f, -0.02884728f, 0.02293938f, -0.03923035f, -0.00129961f, 0.04270523f, 0.03011437f, 
    -0.01019718f, -0.04956892f, -0.01060826f, 0.01414340f, 0.05898886f, 0.01136192f, -0.00692632f, -0.02441207f, 
    0.00062498f, -0.01646952f, 0.01168160f, 0.01107543f, 0.02893625f, -0.04228814f, -0.02947024f, -0.05135942f, 
    -0.02281924f, 0.01830021f, -0.00856284f, -0.02522124f, -0.01470971f, -0.04730152f, 0.03970345f, -0.03496848f, 
    -0.01169677f, -0.00072412f, -0.01160743f, 0.01289449f, -0.02560060f, -0.01842416f, -0.03959884f, -0.03123060f, 
    0.02218049f, 0.04432009f, 0.01670757f, 0.00562171f, 0.03230792f, 0.02557219f, -0.00848297f, -0.06105949f, 
    -0.00624381f, 0.03123507f, -0.00121370f, -0.05943275f, -0.03765645f, 0.00206875f, -0.04028717f, 0.01930487f, 
    0.02996400f, -0.02305113f, 0.00077608f, 0.00876436f, -0.01213124f, -0.00772110f, 0.04432830f, -0.03908090f, 
    0.02083699f, 0.02496816f, 0.02726708f, -0.03566696f, 0.03900949f, 0.02816544f, -0.00876993f, -0.00678122f, 
    -0.03223194f, -0.01942644f, 0.01440414f, -0.00072899f, 0.01481880f, -0.00089773f, -0.04966129f, 0.03395679f, 
    -0.00927219f, -0.01701596f, -0.05087588f, -0.03748872f, -0.01626646f, -0.02295837f, 0.03550202f, -0.02974078f, 
    0.02837950f, -0.00447686f, -0.01742451f, 0.06060923f, -0.03258175f, 0.02079442f, -0.02944074f, -0.02065604f, 
    -0.01474394f, -0.05782156f, 0.00186579f, -0.05393857f, 0.02490075f, 0.03114310f, 0.03579217f, 0.02368858f, 
    -0.02758253f, -0.01603202f, -0.04919976f, 0.02070155f, -0.04059247f, 0.02643823f, 0.00233253f, 0.04813290f, 
    -0.05942559f, -0.05437535f, -0.05809902f, -0.02213901f, 0.02084792f, 0.04098530f, -0.03066112f, 0.03304550f, 
    0.04331936f, -0.04816160f, 0.00098319f, -0.05399001f, -0.01220585f, 0.01085502f, 0.04281171f, -0.04191029f, 
    -0.04017878f, -0.19393024f, -0.04458570f, 0.23556231f, 0.08951903f, -0.02724919f, 0.05439355f, -0.08718807f, 
    -0.01103027f, 0.04263676f, 0.06923871f, 0.05265501f, -0.03430950f, -0.07651994f, 0.07094754f, -0.01264969f, 
    -0.04605920f, -0.05765682f, 0.00383967f, 0.16067025f, 0.05795040f, -0.13714233f, -0.13541955f, -0.00407870f, 
    0.08070314f, 0.13824719f, -0.01796864f, -0.02035029f, -0.01360117f, -0.06731633f, -0.01695486f, 0.04023921f, 
    0.00039881f, 0.05200808f, 0.04641505f, 0.04743980f, -0.03115866f, 0.03403363f, 0.01622496f, -0.03920965f, 
    0.19632734f, -0.00072279f, -0.01215083f, 0.02480160f, 0.10826699f, 0.00153452f, 0.09306475f, 0.01232700f, 
    0.04505861f, -0.03761768f, 0.08011813f, 0.06191545f, -0.02302831f, 0.03035888f, -0.13140452f, 0.00337868f, 
    0.09655611f, 0.01904035f, 0.04068481f, 0.10162618f, -0.33580807f, 0.03623091f, 0.32916236f, 0.09293117f, 
    0.03972956f, -0.07402847f, -0.07360359f, 0.09269902f, -0.04461724f, 0.10453077f, 0.06540260f, 0.01650504f, 
    0.02749901f, 0.04685023f, 0.02180818f, 0.03968316f, 0.00035228f, -0.11201094f, -0.09298953f, -0.05196244f, 
    -0.13607648f, -0.08504308f, -0.32282761f, -0.05146777f, -0.07578816f, 0.05912988f, 0.03601319f, -0.13386200f, 
    -0.09804682f, 0.14638469f, -0.00843820f, -0.02080631f, 0.01295956f, -0.00873007f, -0.04433648f, 0.01191563f, 
    -0.15791588f, -0.02765502f, -0.04368097f, 0.02244769f, -0.22996160f, -0.13189001f, -0.01984003f, 0.29702631f, 
    0.05386525f, 0.08334257f, -0.02034596f, 0.08339852f, 0.00481859f, -0.07428478f, -0.14561023f, -0.04604558f, 
    -0.13021685f, 0.10256052f, -0.01121394f, 0.06717183f, 0.05033170f, -0.11467412f, 0.12274243f, -0.05342009f, 
    0.20523767f, 0.11985798f, 0.21223669f, 0.01608708f, 0.14593713f, 0.12032507f, 0.10334271f, 0.08882182f, 
    -0.01411869f, 0.03208977f, 0.10549740f, 0.05127088f, 0.11145397f, -0.04283032f, 0.18259527f, 0.02358457f, 
    -0.04158698f, 0.06407551f, 0.10371031f, 0.02656323f, 0.04985109f, -0.01525426f, 0.11147959f, -0.19213255f, 
    0.12232936f, -0.15906641f, -0.07724655f, -0.05775997f, -0.12795585f, 0.04995483f, -0.06749418f, -0.04750219f, 
    0.14187032f, -0.02591982f, 0.05645199f, 0.06410660f, -0.07056922f, -0.07049627f, -0.02496350f, -0.09061520f, 
    0.28447205f, 0.43723249f, -0.16222566f, 0.05376428f, -0.14282066f, 0.11824631f, 0.05654141f, 0.02105637f, 
    0.03919658f, 0.04422236f, 0.07381213f, -0.01557085f, 0.00391678f, 0.17913507f, -0.00870051f, 0.11799967f, 
    0.16946746f, 0.04549270f, 0.16790476f, 0.09231556f, -0.04751467f, -0.06286891f, 0.16556469f, -0.08094525f, 
    0.16340052f, 0.05724394f, 0.07828507f, 0.01528853f, -0.03728636f, 0.04094927f, -0.07285639f, 0.03652038f, 
    0.06112191f, -0.01267610f, 0.04040664f, 0.06856290f, 0.11230167f, 0.06595194f, 0.02362653f, 0.15472995f, 
    -0.05229931f, -0.19076182f, -0.02472474f, 0.10916693f, -0.09109224f, 0.03895856f, -0.17676304f, 0.03537475f, 
    -0.02525589f, -0.08059914f, 0.07388078f, 0.08745095f, 0.00385047f, 0.01213071f, -0.07276797f, 0.01191974f, 
    0.04822977f, -0.06975006f, -0.01728457f, -0.01542827f, 0.30450380f, 0.04982846f, -0.00614544f, -0.12854062f, 
    0.13234347f, -0.03934198f, 0.07801674f, 0.03876092f, -0.10251489f, -0.08247772f, 0.01295417f, -0.03155836f, 
    0.03019131f, 0.09953837f, 0.07511009f, -0.14105716f, 0.04814481f, 0.02670361f, 0.00123060f, 0.01570605f, 
    -0.25580129f, -0.06203663f, 0.02474124f, 0.18563217f, 0.08732773f, -0.09830107f, 0.05613516f, -0.02872349f, 
    -0.07453322f, -0.08235873f, 0.00523279f, -0.05013599f, -0.06254843f, -0.09458178f, -0.00706766f, 0.02406021f, 
    0.08662971f, -0.00192430f, -0.08743546f, -0.00125395f, 0.01229995f, -0.04270823f, -0.01839163f, -0.03000148f, 
    -0.04560732f, 0.01237442f, -0.05987180f, -0.15652600f, -0.05724736f, -0.01891512f, 0.00510161f, -0.03329288f, 
    0.01630721f, -0.09619177f, -0.00261320f, -0.13302070f, -0.01579041f, -0.15341063f, -0.08213902f, -0.11083585f, 
    0.36388192f, -0.30081719f, 0.08712844f, -0.09034156f, -0.00659800f, 0.11695608f, 0.16572917f, -0.02110981f, 
    0.04500615f, -0.05137572f, 0.04245580f, -0.03432663f, 0.08719499f, -0.00604602f, -0.00444452f, -0.05905909f, 
    -0.01884881f, -0.00862073f, -0.01739640f, 0.06298449f, 0.06003591f, 0.01456122f, -0.22078171f, 0.25693753f, 
    -0.11896110f, 0.03813694f, -0.04896205f, -0.01153972f, 0.18548380f, 0.04999471f, -0.10848714f, -0.00486087f, 
    0.05360874f, 0.00053841f, 0.05985849f, 0.02446922f, 0.08317302f, 0.07784505f, 0.00580536f, -0.09508879f, 
    -0.23875301f, -0.01151389f, 0.10553561f, 0.17330128f, 0.03188616f, -0.05524776f, -0.00838210f, 0.03413706f, 
    -0.00040563f, 0.06856334f, -0.10057601f, 0.04556851f, 0.06840353f, 0.11479428f, 0.02612059f, -0.03657823f, 
    0.04013497f, -0.01681588f, -0.01691018f, -0.02068093f, 0.00640586f, -0.06452843f, -0.26710364f, 0.12845905f, 
    -0.09039851f, 0.08675223f, -0.13322960f, -0.02990281f, 0.01716272f, -0.06137690f, -0.08407358f, 0.08075154f, 
    -0.06612609f, 0.08476270f, 0.09362972f, 0.12476468f, -0.02478081f, -0.04670761f, -0.06743294f, -0.06361010f, 
    0.11568967f, -0.05086406f, 0.11475805f, 0.04663495f, -0.16057086f, 0.01962273f, 0.07362429f, -0.05306094f, 
    -0.03380815f, -0.03177324f, 0.09865706f, -0.08529301f, 0.13450404f, 0.19007859f, 0.08007148f, -0.04278631f, 
    0.09031330f, -0.10821064f, 0.00424771f, 0.09133662f, -0.01095258f, -0.02434203f, 0.37822095f, 0.19788051f, 
    -0.07035813f, -0.07950076f, -0.00633985f, 0.01116268f, -0.01972263f, 0.10769229f, 0.10853545f, 0.06805623f, 
    0.01403872f, -0.09719631f, -0.09725605f, 0.12386936f, -0.05297972f, -0.03153814f, -0.04655346f, -0.00336505f, 
    -0.31316155f, -0.20395033f, 0.01482672f, -0.08101986f, -0.11061692f, -0.01518817f, -0.01189178f, -0.00862709f, 
    0.01207083f, 0.12023670f, -0.05865354f, -0.00679865f, 0.06149969f, 0.03067928f, 0.06979031f, -0.01179239f, 
    -0.02333124f, 0.03621690f, 0.00637496f, 0.04473301f, -0.13914628f, -0.01024907f, 0.06340889f, 0.38956213f, 
    0.01745962f, 0.03862945f, -0.02173056f, 0.11229281f, -0.04726635f, -0.15878867f, -0.06703097f, -0.08277021f, 
    -0.04545177f, -0.08015222f, -0.05401821f, 0.05343452f, 0.13461649f, -0.26857242f, 0.03142198f, -0.09760691f, 
    0.21044196f, -0.25600198f, 0.17671365f, -0.07467541f, -0.13701519f, -0.01806557f, 0.04599841f, 0.07775418f, 
    -0.04542621f, 0.03373835f, 0.09471565f, -0.03713096f, 0.04388335f, -0.05983884f, 0.01057836f, -0.02564688f, 
    0.01186832f, 0.04813150f, 0.11940157f, 0.04890126f, 0.10565060f, -0.13899671f, 0.08487529f, -0.08648036f, 
    0.07151903f, -0.16746651f, -0.14092013f, -0.08907230f, 0.00051854f, -0.05743939f, -0.02365429f, 0.06684483f, 
    -0.01857187f, 0.03258396f, 0.16148263f, -0.01204279f, 0.03908269f, -0.04511853f, 0.04133603f, -0.06622059f, 
    0.44861144f, 0.15208034f, -0.08546909f, 0.04949447f, -0.10965990f, 0.08698330f, -0.01654672f, 0.05640246f, 
    0.07613159f, 0.10334521f, -0.14225584f, -0.02870783f, -0.02016598f, 0.01101939f, -0.06673487f, 0.03580738f, 
    0.04992095f, -0.15077913f, -0.02658011f, 0.19854388f, -0.04552976f, -0.11917210f, 0.07213340f, 0.08769960f, 
    0.02807642f, 0.01338280f, 0.09201048f, -0.03528278f, 0.02159553f, -0.04441116f, 0.03223838f, -0.01452011f, 
    -0.00603043f, 0.04499503f, 0.07954931f, 0.02291116f, 0.06938916f, 0.06013503f, -0.08234274f, 0.00208157f, 
    -0.06699766f, 0.05532574f, 0.02302530f, 0.22661719f, -0.10906840f, 0.03321922f, -0.18762007f, 0.03840505f, 
    -0.03280637f, -0.12680289f, -0.00167500f, 0.09481719f, -0.05734636f, 0.08771185f, -0.01086459f, 0.00883789f, 
    -0.01776616f, -0.08247501f, -0.08385413f, 0.01709561f, 0.03941876f, -0.07254780f, -0.07483163f, -0.04537129f, 
    0.04519054f, -0.02768648f, 0.08205309f, -0.00364862f, -0.04686620f, -0.08086206f, -0.01760346f, -0.05136887f, 
    -0.04321326f, 0.07371628f, 0.00967018f, -0.06074470f, -0.02468470f, -0.05639260f, 0.06319779f, 0.19794503f, 
    -0.22425675f, 0.10268283f, 0.16946407f, 0.28025886f, 0.06443477f, -0.07940776f, -0.02222976f, -0.07133465f, 
    -0.04552738f, -0.02830636f, -0.10105553f, 0.00086482f, -0.00501414f, 0.03958296f, -0.00114536f, 0.01504379f, 
    0.03124435f, -0.06122917f, -0.02100987f, -0.02657772f, 0.05055509f, -0.18466601f, -0.19251120f, -0.05395722f, 
    -0.01676876f, -0.06789313f, -0.02406557f, -0.06018829f, -0.02862092f, -0.02272119f, 0.05716771f, -0.00441643f, 
    -0.04697270f, 0.00473645f, 0.05701504f, 0.01347528f, 0.01834042f, -0.06428989f, 0.11392809f, -0.00104723f, 
    -0.05653249f, -0.02725803f, -0.17734772f, -0.08172850f, -0.30399850f, -0.00762194f, 0.02245774f, 0.08314363f, 
    -0.13066350f, 0.01585802f, -0.08059021f, 0.04634840f, 0.03796556f, -0.00000117f, -0.04620481f, -0.05203613f, 
    -0.00580320f, 0.06525887f, -0.07105794f, -0.02934432f, 0.01290507f, 0.10647859f, -0.32082945f, 0.06082552f, 
    -0.00093607f, -0.04248657f, -0.17668353f, 0.00851623f, 0.17030072f, 0.12147918f, -0.11844799f, -0.03595446f, 
    0.02675864f, -0.06839914f, -0.04848538f, -0.02172481f, 0.00471783f, -0.04781274f, 0.12159830f, 0.04514470f, 
    0.12042661f, 0.09629413f, -0.25512791f, 0.09058325f, 0.15313901f, -0.13806532f, 0.18374091f, 0.07450902f, 
    0.02579473f, 0.13582382f, -0.10959356f, -0.03348163f, 0.03018900f, -0.05283096f, 0.03916331f, -0.10115431f, 
    -0.11961307f, 0.15320194f, -0.32366425f, -0.07686592f, 0.32595560f, 0.18287982f, 0.14222462f, 0.13691361f, 
    -0.01311424f, 0.13692237f, 0.02960837f, -0.04217623f, 0.14614320f, 0.02135251f, 0.07310116f, -0.13638975f, 
    0.02451961f, -0.01374518f, -0.21258874f, -0.14611776f, 0.23460108f, 0.04931813f, 0.03902569f, 0.24719280f, 
    -0.00621530f, -0.26959112f, -0.07548335f, -0.02685940f, -0.08382511f, -0.00488959f, -0.08786061f, 0.03297497f, 
    -0.03087308f, -0.07124463f, 0.09659470f, 0.17255715f, 0.19970831f, 0.00349500f, 0.00682066f, -0.03032802f, 
    -0.03578381f, -0.19917461f, -0.00941969f, -0.28855965f, 0.22197807f, -0.16166213f, 0.33982715f, 0.30468136f, 
    0.21444836f, -0.14957936f, 0.01240132f, 0.12676913f, 0.03757412f, -0.22799186f, 0.10129956f, -0.01927608f, 
    0.11746448f, -0.00175064f, 0.22018531f, 0.07770927f, 0.08273976f, 0.02180965f, -0.06357467f, -0.08695558f, 
    0.21032366f, 0.23728630f, -0.43719247f, -0.06290579f, -0.04800880f, 0.14173354f, 0.14022087f, -0.19346134f, 
    0.01165379f, -0.09376640f, -0.09864708f, 0.05950231f, 0.09976318f, 0.05639177f, -0.01410193f, 0.05574250f, 
    -0.14190733f, -0.09228222f, -0.09871192f, 0.13909869f, 0.00911191f, -0.13413300f, 0.30630454f, 0.16780256f, 
    -0.07306720f, 0.03085732f, -0.04580242f, -0.04643339f, 0.12266057f, -0.03398815f, 0.10879062f, 0.02002369f, 
    -0.13969216f, 0.04916777f, 0.00181234f, 0.08097772f, 0.23335871f, 0.11506176f, 0.08777933f, 0.08551588f, 
    -0.03384818f, -0.00499919f, -0.14173582f, -0.12496963f, -0.03060871f, -0.07159346f, -0.05998288f, -0.14575866f, 
    -0.01379590f, 0.13972779f, 0.06125079f, 0.04690519f, -0.00004904f, -0.00190866f, -0.02572021f, 0.09038425f, 
    0.08281489f, -0.21204215f, 0.16200608f, 0.19719177f, 0.22620116f, 0.09456518f, -0.22618461f, -0.01443454f, 
    -0.24508744f, -0.02130927f, 0.08485938f, 0.14079802f, 0.01863475f, -0.05798816f, -0.06939468f, -0.09207029f, 
    0.12339031f, -0.17796017f, 0.02569770f, -0.10113449f, 0.15240486f, -0.01599130f, -0.16130294f, -0.00027434f, 
    0.00202895f, 0.14165124f, 0.06778192f, -0.06648330f, -0.45506126f, -0.09620906f, -0.11298205f, -0.00259392f, 
    -0.03658832f, -0.28081316f, -0.00327937f, 0.13147035f, -0.11981220f, 0.27285001f, -0.04300182f, 0.21143955f, 
    -0.07517587f, 0.02035404f, 0.03305412f, -0.21830878f, 0.35309616f, 0.12457126f, -0.13836373f, -0.24212722f, 
    -0.04423495f, 0.09657139f, -0.07116769f, -0.34787995f, -0.06631362f, 0.00614936f, -0.03537859f, 0.25258562f, 
    0.05836596f, -0.01484960f, 0.17602313f, 0.08323048f, -0.06130103f, -0.35892457f, -0.16100796f, -0.13402636f, 
    -0.01082237f, -0.12542666f, 0.27536869f, 0.27126601f, 0.13805781f, -0.05019951f, -0.01112446f, -0.16379358f, 
    0.07385058f, 0.03671112f, -0.06847175f, -0.01980015f, 0.04942556f, -0.04734671f, -0.04600559f, 0.00720172f, 
    0.24035271f, -0.23721495f, 0.08393715f, 0.10578566f, -0.05427955f, 0.03518865f, 0.20825738f, -0.14357977f, 
    -0.10825195f, 0.03254015f, 0.11104216f, -0.24948011f, -0.12365346f, 0.00230825f, 0.15068178f, -0.08869410f, 
    0.14539541f, 0.10659145f, 0.08669019f, -0.05039287f, -0.02539874f, -0.17687355f, -0.05358529f, -0.04782475f, 
    0.21950357f, 0.14056158f, 0.10124109f, 0.20086583f, 0.18239118f, 0.06494914f, 0.06928676f, -0.02760469f, 
    0.04228928f, 0.05529530f, 0.01583420f, 0.05533384f, 0.10251489f, 0.04207136f, 0.02727349f, 0.05676297f, 
    -0.05733953f, -0.04662596f, -0.17594026f, -0.13423078f, -0.13808498f, 0.00096090f, 0.06876902f, -0.07324252f, 
    0.15548784f, -0.03769196f, -0.10753684f, -0.05803338f, -0.13553067f, -0.02059032f, 0.01783421f, 0.10510733f, 
    0.13269518f, 0.18628010f, 0.08573268f, 0.06592593f, -0.02788529f, -0.07486228f, -0.07359623f, 0.01961890f, 
    -0.13169970f, -0.15294576f, 0.54511905f, -0.01496988f, 0.11567617f, 0.14689076f, 0.06757867f, -0.42102242f, 
    0.16928004f, 0.25657058f, -0.03389956f, -0.07530547f, -0.00669419f, -0.05265626f, -0.07102972f, -0.01565087f, 
    0.26022419f, -0.08283830f, 0.11810024f, 0.21642834f, -0.27441266f, 0.13502587f, 0.08828513f, 0.13605314f, 
    0.09060577f, -0.12803546f, -0.07415281f, -0.19777207f, -0.05283833f, -0.09697619f, 0.06889548f, 0.01133946f, 
    0.04997150f, -0.12407780f, -0.16374382f, 0.08123618f, 0.24339566f, 0.03905725f, -0.08725037f, -0.02957730f, 
    -0.05379897f, -0.05242716f, -0.34396127f, -0.00583905f, 0.12876016f, -0.14400038f, -0.10145451f, 0.06276721f, 
    0.01453525f, 0.04686612f, -0.00841522f, -0.03761233f, 0.00892648f, -0.03644684f, -0.04757680f, -0.10181525f, 
    -0.09322620f, -0.04933020f, 0.09053794f, -0.21950036f, 0.12394189f, 0.10106335f, -0.32641679f, -0.05111788f, 
    0.11968946f, 0.12615784f, 0.17443554f, 0.13503085f, -0.08137671f, -0.03737354f, -0.00348873f, -0.01775922f, 
    -0.07129962f, 0.03921637f, 0.00771512f, -0.03408207f, 0.00333064f, -0.00540824f, 0.09834890f, 0.09491414f, 
    0.08178411f, 0.32216907f, 0.18994232f, 0.02279638f, 0.01948941f, -0.04917595f, -0.08734486f, -0.06790426f, 
    -0.11596614f, -0.05239599f, 0.00737810f, 0.06418350f, 0.06776245f, -0.09891157f, 0.01806282f, -0.01886727f, 
    -0.23536725f, -0.16051307f, -0.03855132f, -0.18640226f, 0.19799101f, 0.22212957f, 0.55471623f, 0.26873526f, 
    0.35007659f, -0.03248574f, -0.07104730f, -0.14596103f, 0.05191807f, -0.11327665f, -0.04242651f, -0.03159315f, 
    0.08711471f, 0.11716008f, 0.10823262f, -0.02398428f, -0.01769508f, -0.00057981f, -0.05625135f, -0.01644684f, 
    0.10161475f, -0.02439346f, -0.31115493f, 0.13281339f, -0.03174004f, -0.01079065f, -0.19917974f, 0.08068641f, 
    -0.06343120f, -0.09410417f, 0.04456601f, -0.04394469f, 0.07873700f, -0.07927901f, -0.17489557f, -0.02497620f, 
    -0.21527644f, -0.14227501f, 0.04480820f, -0.17203701f, 0.04352732f, -0.32586816f, -0.12530227f, 0.00005796f, 
    -0.03964297f, 0.03225157f, -0.09010838f, -0.02786468f, -0.00784711f, 0.05337548f, -0.00351971f, -0.06928287f, 
    -0.09558078f, 0.13519186f, -0.00976863f, 0.04951546f, 0.27246734f, 0.29073977f, 0.15887144f, 0.22061600f, 
    0.16083871f, 0.02135773f, 0.00696422f, 0.05509184f, 0.04361133f, 0.00878495f, 0.11363405f, -0.07145762f, 
    -0.07025083f, 0.05941204f, 0.12812603f, -0.10875682f, 0.06172844f, 0.08545411f, 0.03418576f, 0.12453685f, 
    0.07106651f, -0.03368936f, -0.02320651f, 0.01647629f, -0.24573129f, 0.08350370f, -0.07741257f, -0.12996791f, 
    -0.01187674f, -0.00219283f, -0.11453479f, -0.02524813f, -0.06773996f, -0.08244488f, 0.03650255f, 0.07989497f, 
    0.08654621f, 0.15182742f, 0.03453613f, -0.02150734f, 0.19544700f, -0.05174328f, -0.05793377f, -0.03705043f, 
    -0.23698437f, 0.11752632f, 0.24655443f, -0.01153716f, -0.14654540f, 0.08431682f, 0.01274822f, 0.08570915f, 
    -0.02176559f, -0.00077325f, 0.07571856f, 0.07724306f, 0.09570727f, 0.19340153f, 0.20723040f, 0.12399454f, 
    -0.00707876f, 0.18370317f, -0.02880048f, 0.06849480f, 0.09719899f, -0.07506743f, -0.06611853f, -0.09721841f, 
    0.01810753f, 0.06211012f, -0.06112201f, -0.03811086f, -0.17806956f, -0.10710509f, 0.02925748f, 0.06555961f, 
    -0.08761334f, -0.02337989f, 0.07256626f, 0.18261299f, -0.20340860f, -0.20184915f, -0.17351680f, -0.20837513f, 
    0.03471651f, -0.30015421f, -0.13433047f, -0.04562733f, 0.06216955f, -0.09186232f, 0.01990049f, -0.03391048f, 
    0.01629636f, 0.03002631f, -0.17914619f, -0.09416702f, -0.09550807f, -0.02119958f, 0.00658483f, 0.10474792f, 
    0.08788782f, 0.18541262f, 0.21736881f, 0.15663768f, 0.00128089f, -0.17656678f, -0.30747685f, 0.00517821f, 
    0.07817756f, 0.04482217f, -0.09934669f, 0.11300927f, -0.06896418f, 0.04294999f, 0.07899410f, -0.07897165f, 
    0.10958236f, -0.15750492f, -0.06230155f, -0.12962839f, -0.15554480f, -0.12300656f, 0.07882132f, -0.24637565f, 
    -0.08231115f, -0.03553799f, 0.11882555f, 0.00243786f, -0.04232967f, -0.02630619f, -0.07670996f, 0.03461593f, 
    0.07657256f, 0.06061219f, 0.05426822f, 0.06354716f, 0.09990154f, -0.11714909f, -0.00412205f, 0.00334135f, 
    0.00148124f, -0.04096257f, 0.08800042f, -0.08834708f, 0.00862869f, -0.09183516f, -0.08028903f, -0.26391378f, 
    -0.09709437f, -0.01268672f, -0.21568680f, -0.05332626f, -0.06079767f, -0.06501132f, -0.09208245f, -0.15399644f, 
    -0.02793474f, 0.05921353f, 0.01300374f, -0.05587989f, -0.22220677f, -0.31158283f, -0.17586334f, -0.18548591f, 
    -0.09938153f, 0.10563852f, 0.11655749f, 0.08619545f, 0.14870980f, 0.06985107f, 0.07091745f, 0.09394564f, 
    0.04449699f, 0.00840807f, 0.02375096f, -0.05248697f, -0.07582708f, -0.17640288f, 0.02193989f, 0.12303481f, 
    0.06166783f, 0.10102190f, 0.03078267f, 0.02731354f, -0.25260407f, -0.05786002f, -0.12503828f, -0.04877244f, 
    0.15033968f, -0.04311807f, 0.06373990f, -0.06070549f, 0.03935493f, 0.01963817f, -0.00091601f, 0.04111830f, 
    -0.10787526f, 0.02337877f, 0.10651472f, 0.02777126f, 0.18783024f, 0.02002066f, 0.04659033f, 0.21931086f, 
    0.11728510f, -0.29238164f, -0.02104188f, 0.07324727f, -0.08970127f, 0.15028498f, -0.07533093f, 0.01786406f, 
    0.05709400f, -0.07250103f, 0.06288594f, 0.02594510f, 0.02559152f, -0.07229010f, 0.04103681f, 0.07396509f, 
    0.02274848f, -0.04071091f, -0.03975898f, 0.14583451f, 0.21679348f, 0.00338832f, 0.28117961f, 0.00958313f, 
    -0.02444787f, -0.00780999f, -0.07838274f, 0.02273130f, 0.03975445f, 0.08458266f, -0.05216349f, 0.03596201f, 
    -0.00717136f, 0.00029167f, 0.02613797f, 0.00684454f, 0.01039120f, -0.04459798f, -0.09013880f, 0.03738599f, 
    -0.23757030f, -0.29720610f, -0.00194716f, 0.11043119f, 0.10064227f, -0.02908878f, 0.06504393f, 0.04552174f, 
    0.18366219f, 0.19822884f, 0.01430118f, 0.00232745f, -0.06500138f, 0.06482807f, -0.04355724f, -0.01508744f, 
    0.06780279f, 0.02302213f, -0.02908627f, 0.05977199f, 0.11316795f, -0.18806982f, -0.60636616f, -0.25339541f, 
    -0.21076453f, -0.08534896f, -0.05706895f, 0.07388299f, 0.07437548f, 0.06519906f, -0.02219506f, -0.06046614f, 
    -0.00980688f, -0.09838898f, -0.01541129f, -0.08303118f, -0.03132493f, 0.01087043f, -0.00877009f, 0.02834798f, 
    0.28163105f, 0.00845556f, -0.14902340f, -0.01056642f, -0.08859657f, 0.19925728f, -0.08054661f, -0.04158974f, 
    -0.07172662f, -0.08889857f, -0.05448590f, -0.02465454f, 0.15116896f, -0.01608465f, 0.01530400f, 0.00071777f, 
    0.15352938f, 0.01693221f, 0.01286437f, -0.02482071f, -0.05618519f, 0.07636600f, -0.11714096f, -0.07940793f, 
    0.03919314f, 0.11166332f, 0.02339002f, 0.02352480f, 0.09809411f, 0.13608588f, -0.06188301f, -0.01387874f, 
    0.00074675f, 0.02311219f, 0.12291264f, 0.01406948f, -0.07444702f, -0.07170279f, 0.03106013f, -0.08561446f, 
    -0.17676431f, 0.31954971f, 0.11635461f, 0.10934885f, -0.00147127f, -0.08946855f, 0.04260407f, -0.00094601f, 
    0.09606023f, -0.05759056f, 0.06525052f, -0.03522497f, 0.07126714f, 0.06660649f, 0.05346205f, 0.04082847f, 
    -0.00545817f, 0.07516192f, 0.10183439f, 0.00076344f, -0.07351301f, -0.08163342f, 0.04688128f, 0.11436016f, 
    -0.13611637f, -0.03867234f, 0.06068086f, 0.03441229f, -0.12390638f, -0.03529407f, 0.02628332f, -0.03700219f, 
    -0.05262683f, 0.05902020f, 0.12867706f, 0.15001434f, -0.14161871f, 0.05125924f, 0.06676891f, -0.06967910f, 
    -0.04895178f, -0.14918755f, 0.03986681f, 0.06394146f, 0.17760482f, 0.02177802f, 0.09890246f, 0.03223523f, 
    0.02843596f, 0.13110767f, 0.02808943f, 0.00268654f, 0.01816603f, 0.09527642f, -0.00975800f, -0.02756619f, 
    0.04831849f, 0.03405163f, 0.11763037f, -0.01508577f, 0.19653122f, 0.13974266f, 0.07608350f, -0.09264018f, 
    -0.17686506f, -0.19285391f, 0.07045584f, 0.04579060f, 0.02252983f, -0.08443437f, -0.06951119f, 0.07079437f, 
    0.15632217f, 0.11042271f, 0.01925288f, 0.01517819f, 0.14775455f, 0.15102786f, 0.06893820f, 0.10851850f, 
    -0.06888980f, -0.03476717f, -0.01062519f, -0.09849651f, 0.05553890f, -0.00628727f, -0.06243037f, 0.07490823f, 
    0.02200821f, 0.04397797f, 0.10755946f, -0.05391062f, 0.00334108f, -0.00324382f, 0.01046712f, 0.01776369f, 
    0.01267939f, -0.04472508f, -0.06877832f, -0.11558729f, 0.16912024f, 0.16151968f, 0.05694750f, 0.00021106f, 
    -0.17906915f, 0.04875874f, -0.02065988f, 0.08284348f, 0.01878918f, -0.05219063f, -0.11136178f, 0.00616472f, 
    0.05912126f, 0.08021353f, -0.06065475f, 0.07013941f, 0.09794421f, 0.18345682f, 0.04497015f, 0.11625257f, 
    0.02686570f, -0.27089822f, -0.28660649f, 0.07705964f, 0.08584462f, 0.03586540f, 0.05022183f, -0.04957779f, 
    0.05164734f, 0.02452423f, -0.07379030f, -0.11196259f, -0.02678898f, 0.01778427f, 0.02027546f, 0.06699241f, 
    0.08422458f, 0.04441965f, -0.14022924f, 0.07471847f, -0.01594939f, 0.23141429f, 0.11387874f, 0.09239800f, 
    -0.11229676f, -0.07555676f, -0.05357663f, -0.06578649f, -0.01714903f, -0.05848167f, 0.11531352f, 0.05583906f, 
    0.10656733f, 0.07500481f, 0.01476318f, 0.01703945f, 0.08260385f, 0.08023940f, 0.03006716f, -0.04905009f, 
    0.16408534f, -0.01041979f, 0.21715683f, 0.13250558f, 0.19880421f, -0.09192843f, 0.03526497f, -0.16606382f, 
    0.02239990f, -0.08689287f, -0.03325342f, 0.00558754f, -0.00747441f, -0.05571564f, 0.02574825f, -0.00424580f, 
    -0.01380074f, -0.12498976f, -0.12518872f, -0.04211725f, 0.38334045f, -0.07887552f, 0.21848072f, 0.39566338f, 
    0.00784186f, 0.07105241f, 0.04049107f, 0.05459043f, -0.00063910f, -0.00483412f, 0.07094551f, -0.06502935f, 
    -0.00578834f, -0.01586444f, 0.01590896f, 0.08429731f, -0.06431251f, 0.14930589f, -0.11234908f, -0.10265149f, 
    -0.26906505f, 0.16229233f, 0.14216986f, 0.10907786f, 0.17797831f, -0.10361574f, -0.07564783f, 0.10104284f, 
    0.07085469f, 0.12809885f, -0.00736749f, -0.09252375f, -0.00218069f, -0.01402358f, -0.02581757f, -0.04770606f, 
    -0.04378344f, 0.04770082f, -0.10425272f, -0.02594708f, -0.09869876f, -0.09534353f, -0.50951165f, 0.22458197f, 
    -0.04770165f, -0.12875582f, 0.09046285f, 0.07990894f, -0.14636937f, -0.00200644f, 0.10760124f, -0.03066520f, 
    -0.03419927f, 0.09697723f, 0.03607583f, 0.11142586f, -0.11895835f, -0.07044381f, -0.08665773f, -0.01635998f, 
    0.22143809f, 0.14418145f, 0.19927134f, -0.01131065f, -0.03889794f, 0.07012297f, -0.04245659f, -0.09893295f, 
    -0.05627914f, -0.09539848f, -0.08643730f, -0.09268901f, 0.16063793f, 0.07096363f, -0.03598036f, -0.05228195f, 
    -0.02427128f, -0.00891761f, 0.09881163f, -0.05321066f, 0.17945771f, 0.03445752f, 0.47517699f, 0.31523481f, 
    0.03532682f, -0.02875375f, 0.04888880f, -0.15046439f, -0.09342446f, -0.08295085f, 0.02890856f, 0.00325236f, 
    0.05929732f, 0.00687952f, 0.08420636f, 0.07793260f, 0.02122201f, -0.05582193f, -0.05308288f, -0.01403714f, 
    -0.17225365f, 0.07226473f, 0.03850770f, -0.06377373f, 0.05585027f, -0.01398595f, 0.02387073f, 0.05846020f, 
    0.01127383f, 0.06731351f, -0.02002336f, -0.04815651f, -0.06967425f, 0.05641638f, -0.04717370f, 0.19383448f, 
    -0.11018647f, 0.07643715f, -0.02246538f, 0.08279437f, -0.05180817f, -0.15616854f, 0.02968879f, 0.19793724f, 
    -0.04693871f, -0.10283137f, 0.03022228f, -0.00333992f, -0.14017460f, -0.13427269f, -0.07232049f, 0.01393684f, 
    -0.06804291f, 0.11628705f, -0.01471895f, -0.07180534f, 0.13362721f, -0.11227047f, 0.06533261f, -0.08445210f, 
    0.07022125f, -0.22440766f, -0.08056685f, -0.22275659f, 0.01979919f, 0.03889130f, 0.02086101f, 0.13652757f, 
    -0.05966809f, 0.17759115f, 0.03982741f, 0.07241208f, 0.10802466f, 0.01577481f, 0.05697394f, -0.00023887f, 
    -0.01299444f, 0.08874149f, -0.06942707f, 0.13806960f, -0.00003954f, 0.09824963f, -0.04233171f, -0.03167638f, 
    -0.07734646f, 0.05156615f, -0.07275726f, 0.00939129f, 0.12390126f, 0.11478624f, -0.00305789f, 0.04602271f, 
    0.03238977f, -0.03639553f, -0.09458908f, -0.16202216f, 0.22558835f, 0.03474820f, 0.14379576f, 0.02829704f, 
    0.01692157f, -0.15824704f, 0.09317467f, -0.00976472f, -0.14945613f, 0.04709840f, -0.05751501f, 0.04879256f, 
    0.15152964f, 0.03648901f, -0.12408990f, 0.09002113f, 0.03138340f, 0.02917792f, 0.01878197f, 0.04516139f, 
    -0.10219327f, -0.11781123f, -0.02744733f, -0.00450360f, -0.04986842f, -0.00928394f, -0.10574720f, 0.10667502f, 
    0.09890632f, 0.10498382f, 0.07297831f, -0.02992294f, -0.10490855f, 0.09334107f, 0.11551524f, -0.03771252f, 
    0.07934879f, -0.08056191f, 0.06096495f, 0.18509609f, -0.09448572f, 0.01358782f, -0.07944151f, -0.08441035f, 
    0.00181975f, 0.02308658f, -0.05350482f, 0.19864574f, -0.02942625f, -0.05854155f, 0.09681410f, 0.00882325f, 
    -0.03322648f, 0.02589279f, -0.10734569f, 0.03071000f, -0.14404514f, 0.00409765f, -0.05100609f, -0.07661733f, 
    -0.02370094f, 0.00830880f, 0.04019331f, 0.09363810f, -0.15533870f, -0.04045927f, -0.11064197f, 0.06687893f, 
    0.07363562f, 0.00261748f, 0.13912666f, 0.09713829f, -0.04526729f, 0.05664975f, 0.23588221f, -0.00475050f, 
    0.01111126f, -0.01094741f, 0.13018432f, -0.00198525f, 0.04388435f, -0.01870182f, -0.00874963f, -0.04274164f, 
    -0.02555826f, 0.19375730f, 0.20191190f, 0.13246930f, 0.05990854f, -0.03857335f, -0.14778015f, -0.06090285f, 
    -0.00922755f, 0.13527875f, -0.01310091f, -0.01816442f, 0.09188118f, 0.07558618f, -0.03025840f, 0.02058666f, 
    -0.04634994f, -0.12213568f, -0.02848973f, -0.11914065f, 0.00120344f, -0.11327710f, -0.09270282f, -0.08714057f, 
    0.09751888f, 0.07382709f, 0.13660887f, 0.14504716f, 0.11944551f, 0.13873208f, 0.14351156f, 0.12064970f, 
    0.12285044f, 0.06864084f, 0.03363790f, 0.12382754f, 0.01641710f, -0.00482290f, 0.04445671f, 0.12336601f, 
    -0.19223723f, 0.14466508f, -0.44594336f, 0.01127789f, 0.02291753f, 0.02736418f, -0.01842833f, 0.28468487f, 
    -0.03501340f, 0.19034566f, 0.09577042f, 0.06200100f, -0.00286067f, 0.06717046f, 0.03242144f, -0.03700659f, 
    0.09312423f, 0.05737551f, -0.03058049f, 0.05618868f, -0.35050023f, -0.10247933f, -0.36773527f, -0.06380837f, 
    -0.00496481f, -0.07872563f, -0.07561183f, -0.03968437f, 0.13550705f, 0.04256302f, -0.11829737f, -0.01025131f, 
    -0.03797101f, 0.00511773f, -0.04109053f, -0.03756187f, 0.04616325f, -0.25004300f, 0.05109155f, 0.17990489f, 
    0.00678564f, -0.02770679f, 0.11895603f, 0.10517713f, -0.15789106f, 0.18546259f, -0.33572835f, -0.14052045f, 
    -0.21104974f, -0.15855224f, -0.09245870f, -0.16495220f, -0.07652789f, 0.04271569f, -0.11263629f, -0.21182351f, 
    -0.11067423f, -0.17174613f, 0.27803257f, -0.16854379f, 0.16328940f, -0.14561892f, 0.23057166f, 0.02660248f, 
    -0.03655165f, -0.20613964f, -0.16712759f, -0.03499104f, 0.07899223f, -0.01843479f, -0.15375163f, -0.15351371f, 
    0.04184829f, -0.08152625f, 0.04237203f, 0.17639433f, -0.06130380f, -0.13637084f, 0.29450482f, 0.00478179f, 
    -0.00647724f, 0.05645942f, 0.01825936f, 0.12280647f, 0.13847461f, 0.05751161f, 0.03335401f, 0.08697522f, 
    -0.07281940f, 0.10903214f, 0.13095355f, 0.25868523f, 0.00527401f, -0.04365436f, -0.04387441f, -0.15924411f, 
    -0.04042152f, 0.03714175f, 0.01544516f, 0.04298003f, 0.04914018f, -0.08848903f, -0.12094013f, -0.16514117f, 
    0.01614550f, -0.02417474f, -0.00436479f, 0.07284784f, 0.08691131f, -0.04146737f, -0.05467148f, -0.18911161f, 
    -0.04845365f, 0.00099384f, -0.22386684f, -0.19026111f, -0.11674070f, -0.08365477f, -0.04918023f, -0.02714417f, 
    0.01704237f, -0.08126247f, 0.10293245f, 0.01607749f, 0.02424247f, 0.04443726f, 0.01498680f, 0.04482586f, 
    0.07031016f, -0.00624170f, 0.15859710f, -0.02558889f, -0.07474813f, 0.07129495f, -0.04199535f, -0.14605151f, 
    -0.10848451f, -0.16118065f, 0.03905588f, -0.05065136f, 0.20987336f, 0.15171710f, 0.00701771f, -0.16150045f, 
    -0.01058132f, 0.01936445f, 0.02285131f, -0.14362966f, 0.11600698f, -0.18219437f, -0.19739957f, -0.17937879f, 
    -0.13233891f, -0.30036396f, -0.36048087f, -0.20961998f, 0.21768539f, 0.09579604f, -0.32388586f, -0.18069512f, 
    0.03730751f, 0.08505690f, 0.10745033f, 0.07728280f, 0.09246946f, 0.03862100f, 0.07205898f, 0.03315169f, 
    0.07924069f, 0.07501939f, 0.14399174f, 0.06602903f, 0.06670057f, -0.02004359f, 0.06204483f, 0.02816956f, 
    0.14924040f, -0.02528037f, 0.02120030f, -0.03259544f, 0.06651984f, 0.04543617f, 0.13087739f, 0.16117483f, 
    0.12386207f, 0.08043597f, 0.02396263f, 0.01323528f, 0.03774020f, 0.06710471f, 0.15244161f, 0.22961426f, 
    0.20665744f, 0.18879965f, 0.10605523f, -0.11560131f, -0.01614302f, -0.04733121f, 0.02233927f, -0.02805596f, 
    0.24197246f, 0.00145316f, -0.01786564f, 0.01185592f, 0.14648634f, -0.07585783f, 0.20082298f, 0.09345368f, 
    0.00846507f, 0.12658870f, -0.20557457f, 0.30118665f, 0.12799108f, 0.08285455f, 0.02980630f, -0.25501615f, 
    0.01635468f, 0.15885974f, -0.13975793f, 0.10988318f, 0.04920105f, 0.05941959f, 0.11212520f, 0.10973538f, 
    -0.01580319f, 0.06493293f, 0.00803346f, 0.03409159f, 0.05979607f, 0.07393377f, 0.14926094f, 0.01034092f, 
    0.09960151f, 0.02535672f, -0.09529897f, 0.01497493f, -0.06098184f, -0.17637636f, 0.00510742f, 0.00594183f, 
    -0.11407537f, -0.04896333f, -0.14949131f, -0.00040256f, -0.15249942f, -0.01950960f, -0.25216720f, -0.17888436f, 
    -0.44303268f, -0.27470985f, -0.22839411f, -0.19709612f, -0.05512009f, -0.13857016f, -0.07149479f, -0.10265192f, 
    -0.10684216f, 0.08941530f, -0.32351172f, -0.38165054f, 0.01567498f, 0.09730985f, 0.08722063f, 0.07415588f, 
    0.00619329f, 0.08551554f, 0.08305765f, 0.04787971f, 0.03955776f, 0.01447180f, 0.06883046f, -0.05281589f, 
    0.06886981f, 0.00432200f, -0.01631482f, -0.02277464f, -0.06331768f, -0.05723281f, -0.11101617f, -0.13385463f, 
    -0.11379359f, -0.12517826f, -0.05094159f, -0.05311762f, 0.01053333f, 0.06968537f, -0.03317475f, -0.30227268f, 
    -0.13561496f, -0.21752842f, -0.34530002f, -0.24858141f, -0.11821064f, -0.05419600f, -0.15572466f, -0.19244526f, 
    -0.12895793f, -0.13359778f, -0.04265275f, 0.11155175f, 0.09330884f, 0.03646348f, 0.12402906f, 0.10560846f, 
    0.16065426f, 0.08734049f, 0.09696528f, 0.07869112f, 0.05472858f, 0.10597531f, 0.17332757f, 0.16508649f, 
    0.11737925f, 0.06645803f, 0.08765993f, -0.06697071f, -0.11525935f, -0.09887106f, -0.06035132f, -0.07724992f, 
    -0.09740175f, 0.19121692f, 0.07532075f, 0.31547350f, 0.02807834f, -0.30381462f, -0.22638558f, -0.07663376f, 
    0.02833565f, 0.18898623f, -0.05485423f, -0.03305977f, -0.00205006f, -0.00772255f, -0.08225452f, 0.13316074f, 
    0.02054049f, 0.24560052f, -0.05144920f, 0.15488189f, 0.13702108f, 0.23563488f, 0.01398175f, 0.00658556f, 
    -0.07899597f, -0.35059133f, -0.35397428f, -0.23005968f, 0.17114249f, -0.15557522f, -0.18537407f, -0.13380839f, 
    -0.13573804f, -0.05471158f, -0.11806705f, 0.00640033f, -0.06629591f, -0.00280016f, -0.14065206f, -0.02530426f, 
    0.22047654f, -0.21004722f, 0.01276404f, 0.08135258f, -0.07363169f, 0.21687648f, 0.06435344f, 0.00817051f, 
    0.09194484f, 0.01728150f, 0.03923612f, -0.01600897f, -0.02777170f, -0.01145010f, 0.04112341f, 0.04858030f, 
    0.11458423f, -0.02238896f, 0.06851602f, 0.20082334f, 0.27655956f, 0.09145489f, 0.25360754f, -0.09225377f, 
    0.06363054f, 0.03375097f, -0.01932664f, -0.01238134f, 0.09684376f, 0.06118116f, -0.04090798f, 0.02680563f, 
    -0.04625964f, -0.00379652f, -0.02024426f, 0.10290669f, -0.06063792f, -0.01622410f, 0.02810668f, -0.00305977f, 
    -0.11001384f, -0.21600133f, -0.07157717f, 0.20728000f, 0.18127483f, 0.04598538f, 0.04173323f, -0.02615020f, 
    0.17369476f, 0.03900560f, -0.03352138f, 0.08624403f, 0.01522511f, -0.04463026f, -0.07986467f, 0.06386518f, 
    0.04753621f, 0.13986763f, 0.09382526f, 0.05436644f, -0.16113217f, -0.00782605f, -0.02377195f, -0.06251334f, 
    0.10272046f, 0.03400362f, 0.06641884f, 0.03221325f, -0.02883315f, 0.07050145f, -0.08062948f, 0.01675768f, 
    0.00492629f, 0.03240607f, 0.00144922f, -0.03892518f, -0.05272131f, -0.03953232f, 0.01823189f, -0.00528361f, 
    0.38512018f, -0.06866340f, -0.21045716f, -0.17111619f, -0.07173413f, 0.14015877f, -0.03037235f, -0.11654976f, 
    -0.10124844f, -0.07032956f, -0.03489448f, -0.10652483f, -0.03167319f, 0.06364313f, -0.02088497f, -0.02978870f, 
    -0.01664538f, 0.02858992f, 0.05299558f, -0.01885147f, -0.18098105f, -0.09295947f, -0.19145226f, 0.12227622f, 
    0.02270905f, 0.00891996f, -0.06700752f, 0.04852509f, -0.06277888f, -0.02638258f, -0.11362057f, 0.04848544f, 
    -0.05916302f, -0.01018973f, 0.01114709f, 0.04229083f, -0.09589915f, -0.04175725f, 0.09510917f, -0.04818789f, 
    -0.16447595f, 0.15449031f, 0.23160975f, 0.04852744f, 0.10037334f, -0.06075335f, -0.05393627f, 0.08293643f, 
    0.00680808f, -0.02439001f, -0.04394784f, 0.01533614f, 0.04671400f, 0.08525555f, 0.10120020f, 0.08540717f, 
    -0.03067651f, 0.02682604f, 0.14941645f, 0.01858070f, -0.46891823f, -0.19509248f, 0.10816485f, -0.03699850f, 
    -0.10179125f, -0.11548914f, -0.03334148f, -0.14319918f, -0.06984487f, -0.00105521f, 0.04990736f, -0.03423894f, 
    0.04820496f, 0.01840942f, 0.17791785f, 0.06133942f, -0.19251160f, 0.05276128f, 0.09123133f, -0.07349650f, 
    -0.39349523f, 0.21072611f, 0.01583662f, 0.25270012f, 0.16670230f, -0.02958619f, -0.05572001f, -0.00540911f, 
    0.15597799f, 0.16038331f, -0.03440142f, 0.06982099f, 0.05115362f, 0.07991023f, 0.03422264f, 0.04577884f, 
    0.05279224f, -0.02102605f, 0.11171764f, 0.04487101f, 0.11526269f, -0.09429282f, 0.25498500f, -0.17490503f, 
    -0.09581377f, 0.01370562f, -0.00750807f, 0.15779904f, -0.02236930f, 0.04581909f, -0.11390980f, 0.02034345f, 
    0.05589264f, 0.03600878f, 0.00358108f, -0.00840900f, 0.16172206f, 0.06814592f, 0.09574814f, 0.12321772f, 
    -0.08880979f, -0.21172863f, -0.21643364f, -0.16516009f, -0.01636481f, 0.00481205f, -0.18303496f, 0.09944772f, 
    0.00936682f, -0.05604959f, 0.02106251f, 0.00053260f, -0.02270764f, -0.11701486f, 0.02549479f, 0.09350958f, 
    -0.08763080f, -0.06190317f, -0.01634111f, -0.11110327f, 0.12142913f, 0.00932197f, 0.21367887f, -0.10997672f, 
    -0.15036157f, 0.03015088f, 0.03720748f, -0.01716318f, 0.05099964f, -0.12367267f, -0.11998177f, -0.07383699f, 
    -0.04031484f, 0.08247622f, 0.01568378f, -0.02570312f, 0.07580481f, 0.18090631f, 0.04489389f, 0.07471643f, 
    -0.07619832f, -0.27593747f, -0.29699352f, 0.05735008f, 0.02116918f, 0.01408771f, 0.06127928f, -0.02083068f, 
    -0.00799111f, -0.02066521f, -0.06416134f, -0.01909538f, -0.07462958f, -0.00656580f, -0.06770648f, -0.03939136f, 
    0.00415853f, 0.08860692f, -0.05311574f, 0.14916570f, -0.30154485f, -0.10625148f, -0.00727354f, -0.12402584f, 
    -0.23895767f, -0.15996398f, -0.19805783f, -0.19566415f, -0.09464201f, -0.18693447f, -0.04942214f, 0.00548715f, 
    -0.09019375f, -0.02045101f, -0.04121313f, -0.03264798f, 0.04217240f, 0.01378285f, -0.02020866f, -0.04706295f, 
    0.22634941f, -0.34606886f, 0.49977863f, 0.06263675f, 0.30873868f, 0.04888953f, 0.07018031f, -0.08807316f, 
    0.10366886f, -0.00561431f, -0.01712190f, -0.01051293f, -0.05304888f, -0.04543858f, 0.03252873f, 0.03151631f, 
    -0.02581006f, -0.06473081f, 0.03585419f, -0.02607069f, 0.19834536f, 0.05891757f, 0.08168409f, 0.34870341f, 
    -0.16860864f, 0.10902711f, -0.02911324f, 0.06037015f, 0.09426177f, -0.00810723f, -0.01752917f, -0.02855667f, 
    0.00408780f, 0.05650173f, -0.00489369f, -0.03166927f, -0.01278113f, 0.20325264f, -0.06142554f, -0.04577620f, 
    -0.02359070f, 0.04109889f, 0.03527996f, -0.00175911f, -0.03159780f, -0.03569895f, 0.04318614f, -0.03458162f, 
    0.00684387f, 0.02015939f, -0.04976904f, -0.01852063f, -0.04830825f, -0.05983335f, 0.04992364f, 0.02087502f, 
    -0.04109091f, 0.04719733f, -0.04498567f, 0.00346892f, -0.03423619f, 0.01076438f, 0.01903269f, -0.04426899f, 
    0.02641157f, 0.00112085f, 0.02477111f, -0.01624955f, 0.04617731f, -0.00192694f, 0.02538489f, -0.04591847f, 
    -0.06013182f, -0.04841408f, 0.00256916f, 0.03124449f, -0.01013741f, -0.03105579f, -0.02357438f, -0.00038491f, 
    -0.02370082f, -0.03665040f, -0.04041309f, 0.04371505f, 0.03881546f, 0.01585005f, 0.04142673f, 0.02699409f, 
    -0.00907419f, -0.03878075f, -0.04104680f, 0.03218142f, -0.04250838f, 0.04269347f, 0.04847051f, 0.02066964f, 
    0.00797380f, 0.04730982f, -0.00134437f, -0.00784191f, 0.03779339f, -0.01138536f, -0.06099377f, 0.01322690f, 
    0.02287903f, 0.03187871f, -0.00583580f, -0.00745411f, -0.00733866f, -0.00563791f, -0.05808643f, 0.00964268f, 
    -0.05134125f, -0.00229817f, 0.02258077f, -0.02474512f, -0.03829307f, -0.04484072f, -0.01103872f, -0.03224679f, 
    -0.04621602f, 0.02206535f, 0.04408553f, -0.01991705f, -0.03910543f, 0.04950214f, 0.04377426f, -0.01701668f, 
    -0.04287530f, -0.01043701f, -0.05557934f, -0.02383460f, 0.00228353f, 0.01012293f, 0.00309996f, -0.05282625f, 
    -0.04555802f, -0.03924030f, 0.00424012f, 0.01155167f, -0.03494436f, -0.02368368f, -0.05651217f, 0.00705273f, 
    0.03999717f, -0.04646116f, 0.03657284f, -0.00751942f, 0.03364122f, 0.02389469f, 0.04652022f, -0.00233362f, 
    0.03341104f, -0.01895581f, -0.05384500f, 0.03231023f, -0.05504133f, -0.05698325f, -0.04338259f, -0.00398195f, 
    0.03796520f, -0.02546566f, 0.03609711f, -0.00450427f, -0.03053803f, 0.00286222f, -0.02648278f, -0.04832336f, 
    -0.05180166f, -0.05606325f, -0.02384296f, 0.03366591f, 0.02679677f, -0.04776188f, -0.01382833f, 0.01835830f, 
    -0.05169457f, -0.05070386f, -0.03560140f, -0.03978975f, -0.02654385f, 0.02759852f, 0.03532574f, -0.03955831f, 
    -0.02749909f, -0.03919126f, 0.04093542f, 0.04878678f, -0.03823437f, -0.02789961f, -0.00212123f, -0.04066215f, 
    0.00334519f, -0.01304185f, 0.02182773f, -0.03862246f, -0.03120891f, -0.00199238f, -0.04228367f, -0.01188206f, 
    0.00556536f, 0.03113361f, -0.04627297f, -0.03996311f, -0.05199540f, 0.02757989f, -0.02110068f, -0.00663705f, 
    0.00401778f, -0.00946052f, -0.00523846f, -0.01429078f, -0.03111451f, 0.02160436f, 0.03583302f, 0.00310446f, 
    0.03155118f, -0.00432901f, -0.04441446f, -0.02846539f, 0.03542068f, 0.05056755f, -0.02194058f, -0.02822874f, 
    -0.03151489f, 0.02291965f, -0.05391834f, -0.02784767f, 0.01155021f, -0.02326082f, 0.03489593f, -0.04850775f, 
    0.00227867f, -0.04332983f, -0.04474612f, -0.01919419f, -0.01177506f, -0.05670664f, 0.02452251f, 0.03666549f, 
    -0.00788988f, 0.04291878f, 0.04271490f, 0.04558136f, 0.04403698f, 0.01897695f, 0.02435581f, 0.00543801f, 
    0.03347598f, 0.01330921f, -0.05223064f, 0.00193855f, -0.01780387f, -0.01043221f, -0.05863710f, 0.02435315f, 
    -0.04923828f, -0.05406694f, -0.05108222f, 0.02201259f, -0.05071335f, -0.00234520f, -0.02255913f, 0.01509735f, 
    -0.01308873f, 0.04782354f, 0.05556457f, 0.01290788f, -0.00410299f, -0.00923650f, -0.05556405f, -0.00768112f, 
    0.02142281f, 0.01072725f, -0.01888596f, 0.02235842f, 0.02451877f, 0.00430773f, -0.03904556f, 0.03865583f, 
    -0.02961357f, -0.05240347f, -0.03030544f, 0.03568127f, 0.00388487f, -0.05198341f, -0.04667367f, -0.04036629f, 
    -0.02171773f, 0.00104715f, -0.00753490f, 0.04867882f, -0.00971793f, -0.05409405f, 0.01564717f, -0.03204340f, 
    0.04071254f, 0.00278565f, 0.02267999f, -0.04694014f, -0.05004914f, -0.04374091f, 0.00908602f, 0.03299357f, 
    0.00569165f, 0.02247139f, 0.04387115f, -0.03084591f, -0.03290932f, -0.01655977f, -0.04015456f, 0.03179604f, 
    0.00959001f, -0.05719572f, -0.01820309f, -0.00124050f, -0.01815541f, -0.02430858f, 0.00849437f, -0.05118611f, 
    0.01758398f, -0.00551058f, -0.04755829f, -0.03701298f, 0.04761987f, 0.04620534f, -0.04299829f, -0.01141022f, 
    -0.00315338f, 0.02059567f, 0.00403453f, -0.01530377f, 0.03846386f, 0.03504388f, -0.02829514f, -0.00466266f, 
    -0.05409401f, -0.00123695f, -0.00461414f, 0.02649679f, 0.02485482f, 0.02533277f, 0.00260250f, 0.02883174f, 
    0.00544311f, 0.01205912f, 0.01832264f, -0.00319804f, -0.05889573f, -0.00198043f, -0.06101744f, 0.04349742f, 
    0.04000335f, 0.02221632f, 0.01761322f, 0.04667610f, 0.00651057f, -0.03361694f, 0.00522554f, -0.05470104f, 
    -0.03042239f, 0.03369652f, 0.02479501f, -0.05508834f, -0.01302375f, -0.04103179f, -0.00966754f, 0.00009504f, 
    0.02302140f, 0.01305296f, -0.04661820f, -0.01166417f, -0.01834526f, -0.04484559f, 0.03047496f, -0.02131693f, 
    -0.01710851f, -0.02209070f, -0.02358563f, 0.01098166f, 0.02205694f, -0.00414852f, -0.05651530f, 0.02916468f, 
    0.02754590f, -0.06545208f, 0.04270529f, 0.01698054f, -0.03445212f, -0.01147799f, 0.01835661f, 0.02394062f, 
    0.01185189f, -0.02782662f, -0.03259434f, -0.03242926f, -0.01761115f, -0.05085470f, 0.03779641f, 0.03732298f, 
    -0.05411848f, -0.05623965f, -0.01043203f, -0.00541063f, 0.01356946f, -0.00691882f, -0.05560190f, -0.00945818f, 
    0.01648619f, 0.04466357f, -0.01443032f, 0.00484785f, 0.02042170f, 0.02529857f, 0.03895446f, 0.03046246f, 
    -0.06395894f, -0.04610453f, 0.02749500f, -0.03026633f, -0.03880998f, -0.02613681f, -0.06708623f, -0.03865701f, 
    -0.01164251f, 0.02566371f, 0.04458826f, -0.03627302f, -0.04801931f, -0.00604443f, -0.02122804f, -0.01134542f, 
    -0.00165323f, 0.04292665f, -0.03601439f, 0.02651127f, -0.00257741f, -0.04172071f, -0.00351113f, -0.04136571f, 
    0.03130562f, -0.03986744f, 0.00355737f, 0.02314467f, 0.02648008f, -0.00805814f, 0.01415903f, -0.01688839f, 
    0.00223585f, -0.05886481f, 0.02211070f, -0.05213665f, 0.04342806f, -0.01993968f, -0.02946186f, -0.03384198f, 
    0.04086161f, 0.01652082f, -0.04528579f, 0.03531013f, -0.04460003f, -0.04783098f, 0.00121933f, -0.00624937f, 
    -0.06227655f, 0.02305501f, 0.00992411f, 0.00264790f, -0.02349675f, -0.04578123f, -0.02313520f, -0.06382565f, 
    -0.00166179f, -0.02609712f, 0.03487939f, 0.03166853f, 0.01254547f, -0.04215937f, -0.03545186f, 0.00448393f, 
    -0.00656834f, 0.01528543f, -0.03412564f, 0.00966827f, -0.03426374f, -0.04014932f, 0.00187548f, 0.03127163f, 
    -0.01708054f, -0.02396849f, 0.04316664f, 0.02677473f, -0.00535562f, -0.02902645f, -0.00793647f, -0.05465243f, 
    -0.02227070f, 0.02807874f, -0.01056376f, -0.04998047f, 0.00838296f, -0.04736890f, 0.03425758f, -0.00688732f, 
    -0.05585252f, -0.03456469f, -0.01699646f, 0.04643514f, -0.06111785f, -0.01479796f, 0.03070425f, -0.05919798f, 
    0.04298620f, -0.05652968f, -0.01002759f, 0.02989501f, 0.04182820f, 0.01007008f, 0.01997054f, -0.00048809f, 
    -0.02216287f, 0.04205181f, 0.03489200f, -0.03839023f, -0.01926725f, 0.00467059f, -0.01829132f, 0.03382222f, 
    -0.01350476f, -0.01656902f, -0.03811993f, -0.00822535f, 0.02745944f, -0.01268435f, 0.00461107f, 0.01651125f, 
    0.03692328f, -0.06708784f, -0.05598797f, 0.01726966f, -0.05932270f, 0.02952272f, -0.06365215f, 0.04214124f, 
    0.00941818f, -0.00043099f, 0.03925948f, -0.05254308f, 0.00530061f, 0.04095332f, -0.05120488f, -0.02466012f, 
    0.01463081f, -0.05912206f, 0.00445594f, 0.00019386f, 0.02913566f, -0.03764703f, 0.00313671f, -0.06058777f, 
    0.01087927f, 0.02458436f, 0.01688588f, 0.00168616f, -0.03149508f, -0.06474976f, 0.02206192f, 0.01015037f, 
    -0.04010046f, -0.01203735f, -0.02702243f, 0.04085760f, 0.04226396f, 0.00942036f, 0.04182876f, 0.00569694f, 
    0.00121223f, 0.03712834f, -0.01762147f, -0.02651751f, 0.00330237f, 0.00835275f, -0.04563979f, 0.00748170f, 
    0.01984459f, -0.03152778f, -0.02099749f, 0.00568567f, 0.02326414f, -0.04930390f, 0.03685722f, 0.02474715f, 
    -0.05480021f, -0.01500177f, -0.05196935f, -0.06066434f, -0.03206957f, 0.00763692f, 0.00358462f, -0.01094031f, 
    0.00088364f, 0.03577115f, -0.00369796f, -0.05447796f, -0.01129512f, -0.04673428f, -0.00562712f, 0.00771711f, 
    -0.05150620f, 0.04497952f, -0.02957017f, 0.03074240f, -0.00230364f, -0.04548908f, 0.02903264f, -0.04085230f, 
    -0.00990189f, 0.02097529f, 0.03410034f, 0.02485873f, -0.03626132f, 0.02898155f, 0.00833942f, -0.03619704f, 
    -0.05683652f, -0.00840091f, -0.02958027f, 0.01697839f, -0.00126709f, -0.02443528f, -0.01838261f, 0.00521451f, 
    -0.02986272f, -0.04600325f, 0.03916725f, -0.03453824f, -0.03795872f, -0.02948454f, 0.01394156f, -0.01575268f, 
    -0.01808685f, 0.00509231f, 0.01735783f, -0.02895141f, -0.00441207f, 0.04074890f, 0.03520832f, -0.00505989f, 
    0.01856478f, 0.00565485f, -0.02486628f, -0.02078131f, -0.03283605f, -0.05267633f, -0.00825457f, -0.04301928f, 
    -0.04686443f, 0.02022641f, 0.03348583f, 0.03319529f, -0.01090557f, -0.02004955f, -0.03804115f, -0.06274153f, 
    0.04673731f, -0.01264753f, -0.05928366f, 0.00085667f, 0.03036353f, -0.00829603f, 0.02095721f, -0.01233095f, 
    0.01386655f, -0.05424517f, 0.01224550f, -0.05219443f, -0.03130135f, -0.03145659f, 0.03463620f, -0.04671901f, 
    0.20684394f, 0.33518431f, 0.23780954f, -0.08575096f, 0.08064315f, 0.16202591f, 0.11305106f, 0.00602645f, 
    0.07546490f, 0.04047032f, -0.07077190f, -0.11165524f, -0.11085759f, 0.04161445f, 0.01946447f, 0.05036001f, 
    -0.05601690f, 0.06161375f, 0.00777080f, 0.03870212f, -0.10371352f, 0.18418796f, 0.39289203f, -0.00313803f, 
    0.10187231f, -0.05687343f, 0.07646336f, -0.09062429f, 0.07013436f, 0.02345791f, 0.08324758f, -0.02959878f, 
    -0.04435659f, -0.05440244f, 0.03012479f, -0.09005731f, 0.04197867f, 0.07549484f, -0.02788596f, -0.10612594f, 
    0.03417012f, -0.02815560f, -0.26409498f, -0.06300986f, -0.11515752f, 0.06920678f, 0.01729788f, 0.16887151f, 
    -0.08935776f, 0.05646014f, -0.07258110f, -0.03053864f, 0.01353992f, -0.07894070f, 0.03750134f, 0.15731704f, 
    0.03873279f, 0.06882674f, 0.02876036f, 0.08210090f, 0.02232384f, 0.26519883f, -0.05864342f, -0.02412746f, 
    0.16636510f, 0.20995255f, 0.18390790f, 0.10749657f, 0.05465154f, -0.07981759f, -0.06408149f, 0.03084494f, 
    -0.04649881f, 0.07306007f, 0.06668381f, -0.00030323f, 0.04957761f, -0.04298528f, -0.04744736f, -0.06130180f, 
    -0.18895036f, 0.13401599f, 0.17510702f, 0.01117648f, -0.11049934f, -0.06199846f, 0.00008273f, -0.01674602f, 
    0.12744334f, 0.07677354f, 0.01970199f, 0.05427281f, -0.14760126f, 0.05049325f, 0.12599234f, 0.11982185f, 
    0.18037659f, 0.07710868f, 0.00362621f, 0.02621679f, 0.14674741f, 0.38636616f, 0.38302404f, -0.18730232f, 
    0.18156777f, 0.11815102f, 0.20428811f, 0.01575857f, -0.01989530f, 0.05492385f, 0.01595454f, 0.03226709f, 
    -0.00370781f, -0.02668316f, 0.06872687f, 0.06560485f, -0.10969803f, 0.17746770f, -0.11356002f, 0.10126823f, 
    -0.27758041f, -0.11961055f, -0.32324013f, 0.01576165f, -0.08136269f, 0.07690844f, -0.17239806f, -0.17160130f, 
    -0.00705444f, -0.03241631f, 0.04647185f, 0.03717548f, -0.04761746f, 0.02161161f, -0.08576293f, 0.09968136f, 
    -0.00239155f, -0.02839858f, 0.00674461f, 0.05110525f, 0.10483775f, -0.22908977f, -0.41985855f, -0.12703592f, 
    -0.10400368f, 0.14210655f, 0.08669533f, 0.00735860f, 0.01742759f, 0.06374098f, 0.10281355f, -0.01279096f, 
    0.10155594f, -0.10842548f, -0.05041909f, 0.00926615f, -0.02501114f, -0.06895683f, -0.07343685f, 0.02700062f, 
    -0.33979523f, -0.08811788f, -0.04774798f, -0.22508793f, 0.27155352f, -0.06583568f, 0.08744776f, 0.03626046f, 
    -0.22219673f, -0.14501892f, -0.03208304f, -0.03392919f, 0.02099057f, -0.11622103f, 0.01151782f, 0.16812097f, 
    -0.08148036f, 0.05185244f, -0.01398336f, 0.01831353f, -0.13119979f, -0.11213128f, -0.29544032f, -0.05473579f, 
    0.02362251f, 0.06391162f, -0.08033051f, -0.12693067f, 0.04299505f, -0.04187310f, -0.00724649f, 0.16528936f, 
    -0.06885151f, 0.16530323f, 0.01966369f, -0.00880647f, -0.03802970f, -0.04292708f, 0.18151629f, -0.00385642f, 
    0.14235377f, 0.28278857f, 0.17817989f, 0.08995523f, 0.18177377f, 0.07617213f, 0.19696514f, 0.06758375f, 
    0.06059454f, 0.12488945f, -0.04140917f, -0.07501468f, -0.04338960f, -0.10270701f, 0.02210522f, -0.01817588f, 
    -0.04974955f, -0.00883396f, -0.01414337f, 0.01886309f, -0.19444843f, -0.11267912f, 0.06381594f, 0.02514203f, 
    -0.12561280f, 0.02651169f, -0.08510779f, -0.07751424f, -0.01958993f, 0.08570089f, -0.01032934f, 0.10209217f, 
    -0.01783020f, 0.13809830f, 0.07685750f, 0.08146597f, 0.06302114f, 0.07943017f, -0.01275430f, -0.05477934f, 
    0.28449064f, 0.33726868f, 0.09544288f, -0.04956506f, 0.16544232f, 0.18033887f, 0.16129136f, 0.09487593f, 
    0.03877230f, 0.08612870f, 0.00472711f, -0.02228794f, -0.01634422f, 0.06420125f, -0.01475326f, -0.07855961f, 
    -0.08053743f, -0.07943051f, -0.14296873f, -0.00465302f, -0.32501626f, -0.36077067f, -0.36627665f, -0.07721706f, 
    0.05420098f, 0.07163262f, 0.12278705f, 0.04913864f, -0.17178307f, 0.01545392f, -0.05571905f, 0.04621829f, 
    0.03914820f, 0.05279477f, 0.09532535f, 0.10324115f, 0.13459563f, 0.10729937f, -0.06029909f, 0.00275253f, 
    -0.15373264f, 0.10758566f, 0.07234366f, 0.07495229f, -0.04640650f, -0.06459823f, -0.06582994f, -0.20316291f, 
    -0.08336383f, 0.01642693f, 0.01152135f, 0.02334343f, -0.04082871f, 0.04458066f, 0.07373266f, -0.03623953f, 
    0.00343393f, -0.00371812f, 0.07745881f, -0.00169542f, -0.05717734f, 0.16163073f, 0.46450180f, -0.38905653f, 
    0.15921922f, 0.10275590f, 0.11413611f, 0.08353361f, 0.00350080f, -0.02760888f, 0.03264611f, -0.01009281f, 
    -0.08255234f, -0.04860776f, -0.00440524f, -0.01177300f, -0.00137799f, 0.02031532f, -0.03057863f, -0.03589609f, 
    0.11607726f, 0.31139648f, 0.18176118f, -0.03308491f, -0.18229267f, 0.00343966f, 0.04762938f, -0.06382027f, 
    -0.02385828f, -0.02533061f, 0.07865852f, 0.02811423f, 0.06267583f, -0.00720065f, -0.01583711f, -0.06487757f, 
    0.10450155f, 0.10127260f, -0.01812458f, 0.15541564f, -0.35135138f, 0.09243535f, 0.24677309f, -0.18649916f, 
    0.01901736f, 0.07768072f, -0.08346083f, -0.06612574f, 0.11255815f, -0.01235759f, -0.03429397f, 0.02387803f, 
    -0.02243768f, -0.02592288f, 0.08458066f, -0.05337681f, -0.11163678f, 0.04788874f, -0.04760626f, -0.06224351f, 
    -0.00298516f, 0.01920781f, -0.17633256f, -0.05038306f, -0.13899599f, 0.01416171f, -0.04645136f, 0.07781373f, 
    0.06391852f, 0.04462302f, 0.02410774f, -0.07271793f, 0.02219467f, 0.00157132f, 0.04675720f, -0.04260698f, 
    0.07524084f, -0.03576750f, 0.09363972f, 0.19905704f, 0.16565874f, 0.08125173f, -0.10408562f, 0.08393864f, 
    0.02548412f, 0.11315215f, 0.09977382f, 0.16239142f, 0.06723171f, -0.07666111f, 0.10107867f, -0.06675635f, 
    -0.02910312f, -0.08560538f, -0.14775915f, 0.00878987f, 0.01459691f, 0.10901466f, 0.02189636f, -0.05145621f, 
    -0.00458096f, -0.05801240f, 0.30282667f, 0.08374885f, -0.03922233f, -0.12151524f, -0.02139682f, 0.18531542f, 
    0.15313463f, 0.03094916f, 0.02657161f, -0.00887684f, -0.16089414f, 0.04440785f, -0.04856303f, -0.17970604f, 
    0.13596208f, 0.09519403f, 0.08576243f, 0.06885808f, 0.12451930f, 0.46010193f, 0.21759504f, -0.10095358f, 
    0.00992480f, 0.08087514f, 0.07664885f, 0.06310453f, 0.15982024f, 0.05807637f, 0.09262268f, -0.05553928f, 
    0.00549322f, -0.19373628f, -0.05946657f, 0.06451130f, -0.15180957f, -0.05252366f, -0.21481942f, -0.09726989f, 
    -0.07339589f, -0.26729378f, 0.04264515f, -0.07458135f, -0.05630798f, -0.04645007f, -0.12973194f, -0.04428327f, 
    -0.06584845f, 0.01733425f, -0.05293399f, 0.09128595f, 0.06034189f, 0.06975114f, -0.06683897f, 0.01456704f, 
    -0.08266493f, 0.01396997f, 0.07025126f, -0.03151938f, 0.16881509f, -0.29250398f, -0.07552750f, 0.07165705f, 
    0.11946952f, -0.06437370f, -0.08129021f, 0.02426767f, 0.00873591f, -0.09418319f, -0.02639970f, 0.14803617f, 
    0.07412790f, 0.04284770f, -0.08588131f, -0.00558618f, 0.05469294f, 0.10851321f, 0.16292530f, 0.05889736f, 
    0.25685546f, 0.07766900f, -0.38244838f, -0.08285948f, 0.03741941f, -0.08412459f, -0.03433444f, -0.15503566f, 
    0.04504263f, 0.04876352f, -0.06285781f, -0.03101714f, -0.08826230f, -0.02883008f, -0.00884198f, 0.00651478f, 
    -0.15121228f, 0.02641364f, 0.17499457f, 0.08039547f, -0.01252929f, -0.12184827f, -0.00041699f, 0.03697079f, 
    0.08420709f, 0.07777460f, -0.16822298f, 0.04241780f, 0.06305164f, 0.04390797f, -0.01233662f, -0.02013000f, 
    0.03739397f, 0.07364117f, -0.17244263f, -0.10225318f, 0.09228654f, -0.02713579f, 0.09573776f, 0.14440218f, 
    -0.05412691f, 0.31471804f, 0.04503060f, -0.06933184f, -0.26181036f, 0.18376172f, -0.03198794f, 0.11455897f, 
    -0.01091775f, -0.02894864f, -0.07083166f, 0.01298606f, 0.04907213f, -0.18278696f, -0.09268358f, -0.12274721f, 
    -0.14484999f, -0.01557969f, -0.06935984f, 0.02009974f, -0.11933247f, -0.13446462f, 0.07985967f, 0.10666750f, 
    -0.00229166f, -0.05678075f, -0.10217996f, -0.09224421f, -0.07384892f, 0.02457019f, -0.07888737f, 0.07417616f, 
    -0.02783479f, 0.07160347f, -0.08825486f, 0.07460818f, 0.00431442f, 0.02560586f, -0.08075453f, 0.02664985f, 
    0.13167003f, 0.20742309f, -0.04044012f, -0.10332627f, -0.15885369f, -0.02723003f, 0.06774344f, 0.01393942f, 
    0.10577133f, -0.03082789f, 0.01090446f, -0.09647116f, -0.05164432f, 0.03802103f, -0.00419259f, -0.02442067f, 
    0.07107710f, 0.06098844f, -0.04840549f, 0.17791356f, -0.13652985f, -0.13563783f, -0.08743409f, 0.09721048f, 
    0.07285024f, -0.15235539f, 0.00632158f, -0.04255658f, -0.02288630f, 0.02489072f, -0.11463731f, -0.12487374f, 
    0.01918090f, 0.07074253f, 0.08648605f, -0.10624154f, -0.11977778f, 0.16528307f, 0.18120794f, 0.05620049f, 
    -0.29801697f, -0.13117023f, -0.07784630f, -0.10851548f, -0.43031123f, 0.14060935f, -0.08359035f, -0.08131465f, 
    -0.24943087f, -0.06554182f, -0.08860645f, 0.03527929f, -0.01826331f, 0.12744129f, 0.04229696f, -0.00461205f, 
    -0.11507908f, -0.08964406f, -0.04312815f, 0.02018403f, -0.02597138f, 0.23139259f, 0.12403786f, -0.35511753f, 
    0.08755491f, 0.04986453f, 0.13822633f, 0.01443669f, 0.09336001f, 0.11733337f, 0.03506489f, -0.03955467f, 
    -0.06349205f, 0.02873711f, -0.01365468f, -0.19303361f, -0.14394149f, 0.18987788f, 0.00236346f, 0.01023601f, 
    0.20010145f, -0.10606340f, 0.22739416f, 0.08974909f, 0.14155881f, 0.18454722f, 0.00863328f, 0.09442586f, 
    0.09689113f, 0.01068539f, 0.11619990f, -0.02970505f, -0.04703654f, -0.08142976f, -0.07115371f, -0.03782645f, 
    -0.06525814f, -0.05890171f, -0.02806609f, 0.01908245f, 0.09128968f, 0.06890844f, 0.15066923f, 0.22129326f, 
    -0.07393389f, 0.02926895f, 0.18815464f, 0.17705788f, 0.07181986f, 0.17784403f, 0.05959694f, -0.00149975f, 
    -0.01288495f, -0.01924474f, -0.02701246f, -0.00450523f, -0.11312076f, 0.09300374f, 0.10959622f, 0.10058967f, 
    0.08757371f, 0.11659612f, 0.27302241f, -0.01030084f, 0.23992360f, -0.06368832f, -0.08163046f, -0.01038269f, 
    0.00701348f, -0.03068955f, -0.07579847f, 0.00780419f, 0.07157694f, -0.08385899f, -0.08416001f, 0.01829600f, 
    -0.04352871f, -0.01553377f, -0.02511979f, -0.20044342f, -0.28353471f, 0.13004076f, -0.07582008f, 0.14244574f, 
    -0.05316632f, 0.07799444f, 0.11790637f, -0.17496589f, -0.10062370f, 0.03272992f, -0.10250577f, 0.01018108f, 
    0.05745487f, 0.17156635f, 0.08413162f, -0.16202331f, -0.04860489f, 0.11935414f, -0.04619926f, 0.09128512f, 
    -0.17410012f, 0.26591298f, -0.02199377f, 0.01449623f, 0.09288064f, 0.17585176f, -0.12501308f, -0.12941505f, 
    -0.12398186f, -0.10772107f, 0.15317975f, 0.05187364f, -0.06898536f, -0.00128423f, 0.06027733f, 0.24726929f, 
    -0.10955807f, -0.02997603f, -0.20127317f, -0.18745819f, -0.12713578f, -0.29562822f, 0.02740943f, 0.09079744f, 
    -0.03695420f, -0.08731782f, 0.02352646f, 0.05266809f, -0.17439741f, 0.08528954f, 0.03496669f, -0.06998318f, 
    0.11084883f, 0.22224456f, 0.01770235f, 0.06334619f, 0.13881420f, 0.21694253f, 0.19529195f, 0.14649920f, 
    -0.02418266f, 0.10288996f, -0.26851949f, -0.00453177f, 0.26912880f, 0.00722099f, 0.05816187f, 0.10678505f, 
    0.01492310f, 0.08828598f, -0.06518333f, -0.04792639f, -0.08672968f, 0.07229262f, 0.01077981f, 0.24511950f, 
    -0.03420506f, 0.09306004f, 0.00101113f, -0.00069964f, -0.31849420f, 0.02901182f, -0.17388493f, -0.08391526f, 
    -0.04026851f, 0.01387008f, 0.04542173f, 0.06975093f, 0.08682448f, 0.07389920f, -0.09498852f, -0.04133593f, 
    0.05350496f, -0.11539212f, 0.12590279f, -0.01824382f, 0.03280848f, 0.17116699f, 0.12045426f, 0.06296454f, 
    -0.62976575f, -0.23607770f, 0.21879706f, 0.08749375f, -0.02148536f, -0.03306215f, 0.05583856f, 0.02579026f, 
    0.05786730f, -0.17238854f, 0.03100013f, -0.02224687f, 0.05898554f, -0.07052100f, 0.08184345f, 0.14148273f, 
    -0.04786244f, 0.04598001f, 0.06144221f, -0.12505329f, -0.11782845f, 0.17353648f, 0.05895602f, -0.08168181f, 
    -0.10097829f, -0.00776106f, 0.09628263f, -0.12991083f, 0.03778297f, 0.12032971f, 0.05292871f, 0.02506520f, 
    0.10842964f, -0.02361517f, 0.14547664f, 0.10850261f, -0.14016058f, -0.15328968f, 0.08862393f, -0.08458200f, 
    0.12614304f, -0.22051476f, 0.14475800f, -0.00451627f, 0.26690635f, -0.15244110f, 0.06422551f, 0.13885942f, 
    0.21407840f, 0.25208887f, -0.00537211f, -0.03696662f, -0.04458052f, -0.05718967f, -0.06609137f, 0.10512131f, 
    0.02828764f, -0.03873517f, 0.15858923f, 0.10065043f, -0.05821536f, 0.10198954f, 0.01506790f, -0.03217442f, 
    0.00003635f, 0.20111075f, 0.11581932f, 0.00129000f, 0.03606319f, 0.04380846f, 0.07926540f, 0.04187020f, 
    0.07526843f, -0.08248462f, 0.03297388f, 0.04540917f, -0.02806747f, 0.06350452f, -0.16081785f, -0.16816041f, 
    0.16458863f, -0.01251804f, 0.26492900f, 0.01131569f, 0.01584855f, 0.07389547f, -0.05682907f, 0.07735252f, 
    -0.02066581f, 0.07951840f, 0.06145726f, 0.10832135f, -0.07359429f, -0.10989509f, -0.08316796f, -0.05785823f, 
    -0.04913964f, 0.06054786f, -0.01762985f, -0.06935487f, -0.03087165f, -0.02493641f, -0.00065097f, -0.01911737f, 
    -0.04716384f, 0.09167691f, 0.03049557f, 0.12898462f, 0.08281165f, 0.05105697f, -0.07118196f, -0.03715085f, 
    0.11163452f, 0.12873642f, 0.03789238f, 0.18231586f, 0.08757830f, 0.07844719f, -0.07619675f, -0.06414993f, 
    0.66470885f, 0.11489471f, 0.08090343f, 0.25534943f, 0.52875018f, 0.08693796f, 0.10928743f, 0.13468193f, 
    0.30410331f, 0.14045893f, 0.10676250f, 0.05360536f, -0.10069586f, -0.16502890f, -0.06198810f, 0.13032894f, 
    0.10437272f, 0.13097866f, 0.21601075f, 0.19489729f, 0.09818128f, -0.23322788f, 0.14984523f, 0.38733548f, 
    -0.23587240f, 0.07119075f, -0.00851207f, 0.26664817f, -0.05937332f, -0.02966009f, 0.07056987f, -0.03749684f, 
    -0.06497923f, -0.06585501f, 0.05155789f, 0.00868541f, -0.07947382f, 0.20198071f, 0.07203406f, 0.09821950f, 
    0.22439563f, 0.12623161f, -0.23987520f, -0.03885344f, -0.10126258f, -0.04781445f, 0.07407673f, -0.12527333f, 
    0.02679287f, 0.01152426f, 0.04330950f, 0.13181290f, -0.00069138f, -0.05498985f, 0.06733735f, 0.06283775f, 
    0.12735125f, 0.01801549f, 0.03781949f, 0.17433617f, 0.03809046f, 0.08495140f, 0.22220409f, -0.32574120f, 
    0.04011618f, 0.16413887f, -0.04786813f, -0.08435029f, 0.10874035f, 0.02302881f, 0.00546210f, 0.00499104f, 
    -0.08432932f, 0.02752182f, 0.06244507f, 0.00431659f, 0.10265289f, 0.07782798f, 0.04515582f, -0.01605690f, 
    -0.21640451f, -0.06868506f, -0.19622511f, -0.09048914f, -0.14379671f, 0.05198887f, -0.00475521f, -0.01554817f, 
    0.12126543f, 0.03528500f, 0.10296886f, 0.04337370f, 0.03286646f, 0.08847386f, 0.12060855f, 0.12142210f, 
    0.06374010f, 0.05873154f, 0.11545198f, 0.12342132f, -0.11377388f, -0.03011042f, -0.21327107f, -0.16960795f, 
    0.06381653f, 0.09424240f, 0.06713999f, 0.14621486f, 0.05362083f, 0.02966580f, 0.07818785f, 0.08991882f, 
    0.05268682f, 0.03373624f, 0.12774244f, 0.05930334f, 0.02140735f, 0.00424314f, -0.01325392f, -0.03445093f, 
    0.13724667f, -0.02050316f, -0.08446954f, -0.15456678f, -0.21224192f, -0.21295930f, -0.08085263f, -0.06542213f, 
    0.00423624f, 0.01514816f, 0.04425507f, 0.12738813f, -0.09876688f, 0.09832142f, 0.00787543f, -0.16863556f, 
    0.23602834f, -0.09844278f, 0.15190884f, 0.08182526f, 0.14964457f, 0.45548177f, 0.03608518f, -0.11480131f, 
    0.18225084f, 0.22356421f, -0.03869921f, 0.09537578f, 0.19537884f, -0.05800867f, 0.13226095f, -0.00449680f, 
    0.00790338f, -0.15473035f, 0.00411547f, 0.03955079f, -0.12316293f, -0.06079696f, -0.04337067f, -0.02811152f, 
    -0.27442375f, 0.00521511f, 0.12928779f, -0.10783760f, -0.25474501f, -0.06774385f, -0.11155537f, -0.05908635f, 
    0.01159382f, -0.05406070f, 0.03528252f, 0.02869710f, 0.02312097f, -0.04676060f, 0.05023538f, -0.02352929f, 
    0.03972614f, -0.07630397f, 0.17934914f, 0.03108821f, -0.00842688f, -0.17185612f, 0.22863285f, 0.06814329f, 
    -0.06928139f, -0.10688394f, -0.08617500f, -0.10281721f, -0.11753003f, -0.20930815f, 0.02512650f, 0.07393831f, 
    0.00947623f, 0.01907969f, -0.02771767f, 0.18969816f, 0.02307801f, 0.14722084f, -0.13618089f, 0.03657310f, 
    0.25749543f, 0.07233964f, -0.14531185f, -0.05836405f, 0.06053329f, -0.05598659f, -0.06707723f, -0.06225149f, 
    -0.05399821f, 0.14842470f, 0.12977657f, 0.02235155f, 0.07727682f, 0.08721658f, 0.01322580f, 0.01060741f, 
    0.00445985f, 0.05398924f, -0.01823756f, -0.04689560f, -0.06157522f, -0.10356760f, -0.05927176f, -0.18383074f, 
    -0.00545916f, -0.07091266f, -0.05741498f, -0.00712246f, -0.05817892f, -0.09148491f, -0.07036497f, 0.03171878f, 
    0.04673301f, 0.17128815f, -0.06041631f, -0.20382561f, 0.21216965f, 0.10582157f, 0.07172633f, 0.21770906f, 
    -0.00051335f, 0.20113510f, -0.06626492f, 0.06287371f, -0.10977374f, 0.20476508f, -0.06337150f, -0.02272116f, 
    -0.11563403f, -0.16307150f, 0.09222086f, 0.07948051f, 0.08548865f, 0.07157506f, 0.10561805f, -0.04895220f, 
    -0.09759524f, 0.13278270f, -0.19803755f, -0.23602410f, 0.18032229f, 0.07162031f, 0.07290842f, -0.16119869f, 
    -0.22431922f, -0.24345562f, -0.14672235f, -0.15879385f, -0.05367626f, -0.03045213f, -0.15155390f, 0.01718865f, 
    -0.10073391f, 0.13408157f, 0.07491536f, 0.07287109f, 0.13430728f, 0.03355391f, 0.10961791f, 0.20299363f, 
    -0.08249021f, -0.10067923f, -0.29147729f, -0.07093969f, 0.06957982f, 0.11147007f, 0.07583303f, 0.09213327f, 
    0.20672677f, 0.06775163f, -0.06738652f, -0.15524846f, -0.06649416f, 0.14662956f, 0.02964871f, 0.02856872f, 
    0.08825798f, 0.09315538f, -0.00329469f, 0.11650842f, -0.34896633f, -0.04905377f, 0.02135236f, -0.02818356f, 
    -0.10667581f, -0.35377678f, -0.11308858f, -0.17822930f, -0.24951771f, -0.22851042f, 0.01897942f, 0.00403108f, 
    0.07261156f, -0.02443985f, -0.05320719f, 0.03969355f, 0.11135549f, 0.06896067f, 0.04918053f, 0.01553096f, 
    -0.44775110f, -0.26540327f, 0.23511173f, -0.12967621f, -0.31242365f, -0.03158478f, 0.01789122f, -0.27602696f, 
    -0.15553862f, -0.11971125f, -0.10744400f, -0.06727447f, -0.04810528f, 0.10491107f, 0.15342931f, -0.03777301f, 
    -0.12129907f, -0.02767479f, -0.05003749f, -0.07148442f, 0.23712024f, 0.18921748f, 0.02388628f, -0.19753234f, 
    0.13455102f, 0.18320660f, 0.03765289f, -0.24694034f, 0.04192269f, 0.08120959f, 0.10189418f, 0.01705745f, 
    -0.01473202f, 0.00382377f, -0.05752990f, -0.03427531f, -0.01725857f, 0.08056455f, -0.05668894f, -0.33331412f, 
    0.29080135f, 0.06840111f, 0.13738827f, -0.07775696f, -0.00518332f, 0.13822125f, 0.03082522f, -0.07221532f, 
    0.08528453f, 0.01517021f, 0.10862805f, 0.05889597f, -0.17566392f, -0.00654358f, 0.01328302f, 0.07318030f, 
    -0.01855229f, -0.04002063f, 0.02292966f, 0.17217228f, 0.15149575f, 0.12508428f, 0.27750197f, 0.00316918f, 
    0.12399318f, 0.00898055f, 0.08700714f, 0.03095656f, -0.12447110f, -0.05030157f, 0.03184589f, -0.07312237f, 
    -0.06243800f, -0.05197794f, -0.03208563f, 0.00339420f, -0.00452966f, 0.07250965f, 0.03249122f, -0.09709284f, 
    0.01633053f, 0.04949312f, -0.11550242f, -0.04153464f, 0.11931974f, 0.04266451f, -0.02519356f, 0.01396220f, 
    0.02103459f, 0.14603995f, -0.02045076f, -0.02632248f, 0.00345799f, -0.14825287f, -0.16093095f, 0.03783416f, 
    0.12068456f, 0.11649885f, 0.03731815f, -0.02809050f, -0.33391619f, 0.30015561f, -0.23329225f, -0.06885564f, 
    0.12669994f, 0.10439242f, 0.13962513f, 0.05853643f, -0.00943815f, 0.08068442f, -0.03397773f, -0.07905580f, 
    -0.04863394f, 0.00275947f, 0.10448256f, -0.12442631f, -0.04287538f, 0.04582832f, 0.00144364f, -0.03448970f, 
    0.12714522f, 0.21038750f, -0.00277123f, -0.04113984f, -0.08424798f, 0.00879521f, -0.14417812f, -0.14595415f, 
    -0.13242878f, -0.08788270f, 0.04038340f, 0.01667833f, -0.24008627f, -0.05341309f, 0.11253402f, 0.23129083f, 
    0.15179461f, -0.00151380f, 0.07115810f, 0.00366237f, -0.03420776f, 0.11909192f, -0.00383430f, -0.10954709f, 
    0.19615158f, 0.06602781f, -0.00294307f, -0.02743549f, -0.16296145f, 0.06741556f, -0.03462374f, 0.05099737f, 
    0.04536475f, 0.08073615f, 0.01568620f, 0.04273016f, -0.16361099f, 0.05596383f, -0.10435364f, -0.03603055f, 
    -0.35184345f, 0.02670571f, -0.17897369f, -0.06372435f, 0.09446125f, -0.00247330f, -0.04121831f, 0.09522496f, 
    0.05562680f, -0.07031287f, -0.11461499f, -0.08111390f, -0.01923397f, 0.06544050f, -0.01257384f, 0.17437795f, 
    0.07997235f, 0.01855168f, 0.01515610f, -0.00080096f, -0.26936316f, -0.10726405f, -0.21684176f, -0.08674238f, 
    -0.00139046f, 0.07778975f, 0.08187878f, 0.01418150f, -0.07171947f, 0.02143711f, -0.02135122f, -0.09066533f, 
    0.03654131f, 0.02014181f, -0.01949768f, 0.04892890f, -0.00129244f, 0.13663238f, 0.03754283f, 0.04842228f, 
    -0.50299484f, 0.01555250f, -0.00230078f, -0.11326770f, 0.20083387f, -0.01605902f, 0.02186839f, -0.11633024f, 
    -0.17289633f, 0.03138635f, 0.01113029f, -0.06760097f, 0.14653960f, -0.06122570f, -0.09654341f, 0.09026945f, 
    0.00450301f, 0.06112904f, -0.01217636f, 0.08961590f, -0.05395165f, -0.04524977f, -0.08938992f, -0.20717667f, 
    -0.08562775f, -0.04851145f, -0.02580604f, 0.01353573f, -0.02786144f, 0.07641286f, 0.02889200f, -0.03178161f, 
    0.05591295f, -0.00856999f, 0.02569547f, 0.05912652f, 0.12382516f, -0.03141328f, 0.11278680f, 0.13296291f, 
    0.14652307f, -0.09519136f, 0.00744583f, -0.09878369f, 0.17069663f, -0.02365498f, 0.03188192f, 0.04383416f, 
    -0.01888570f, 0.05159413f, 0.05860331f, 0.03227693f, -0.02530895f, -0.10321480f, 0.01809237f, 0.15133466f, 
    -0.12468676f, -0.00456509f, -0.00419649f, -0.12308557f, -0.07813235f, 0.10932410f, 0.04413098f, -0.01359048f, 
    -0.00372974f, 0.06636255f, -0.01244350f, 0.08105942f, -0.10055680f, -0.09094802f, -0.01718836f, 0.06041281f, 
    0.01902325f, -0.01468739f, 0.01330648f, 0.07475827f, 0.13273124f, 0.16350564f, -0.05388013f, -0.02634461f, 
    0.16145283f, -0.03760789f, -0.03114951f, -0.07573211f, 0.06803840f, 0.09982644f, 0.05429817f, 0.07623179f, 
    0.07136869f, -0.04843461f, -0.00327392f, -0.10077398f, -0.09749725f, -0.02745611f, -0.04681871f, -0.04645199f, 
    -0.09217668f, -0.02371940f, 0.01201461f, 0.13196106f, -0.28147793f, -0.18674318f, -0.14776188f, -0.08124766f, 
    -0.02798538f, 0.05607223f, 0.10145726f, 0.06907046f, 0.01755490f, 0.00387407f, -0.00434397f, 0.03678406f, 
    0.03482045f, 0.09765176f, 0.10520286f, 0.10581312f, 0.13513759f, 0.06887583f, 0.00411604f, -0.04920238f, 
    0.16542330f, -0.10639341f, 0.15055637f, 0.13795111f, 0.50229824f, -0.06508137f, 0.06557340f, 0.01336352f, 
    0.04231475f, -0.12959574f, 0.00836310f, -0.03806204f, -0.05954889f, -0.01180383f, -0.05114664f, -0.02807929f, 
    0.01470900f, 0.03969638f, 0.01304063f, 0.00219473f, 0.14111133f, -0.09084958f, 0.18541707f, 0.04506005f, 
    -0.14091603f, 0.10499126f, 0.10635671f, 0.05992988f, -0.07696294f, -0.01865547f, -0.03985281f, -0.05501728f, 
    -0.06849275f, -0.04193855f, 0.06393211f, 0.04531927f, -0.04522849f, 0.20283493f, -0.02022297f, -0.14360259f, 
    -0.36474311f, 0.40696827f, -0.02175713f, -0.16806035f, 0.08602618f, 0.05163103f, -0.01165109f, 0.03778451f, 
    0.04573707f, 0.21154271f, -0.12803186f, -0.00390997f, 0.01281696f, -0.00536936f, -0.05234599f, 0.10881343f, 
    0.02463693f, 0.05217643f, 0.00010282f, -0.03007162f, 0.05787583f, -0.07135067f, -0.20032011f, -0.17416626f, 
    0.25633588f, -0.14166239f, -0.01510517f, 0.02975605f, -0.04665447f, 0.04747137f, -0.06110138f, -0.06283350f, 
    -0.09170102f, -0.02702489f, 0.13524888f, 0.02630383f, -0.07975962f, 0.03854293f, 0.08317612f, -0.03642827f, 
    0.03233911f, 0.08654959f, -0.11002667f, -0.00594597f, -0.30332726f, -0.01263655f, 0.05950272f, -0.07342523f, 
    0.10910575f, -0.07286097f, 0.13417801f, 0.07671410f, -0.01238321f, 0.07334337f, 0.02624276f, 0.06928848f, 
    0.11303614f, 0.02609712f, 0.11845279f, 0.06150977f, 0.00376306f, 0.28178492f, 0.18469246f, 0.05880767f, 
    -0.07344969f, 0.13982132f, 0.04829391f, -0.01721605f, -0.06929138f, 0.05535794f, 0.04057290f, -0.00543619f, 
    0.05741052f, -0.07603659f, 0.02761150f, 0.16567165f, 0.02216978f, -0.01951820f, 0.00994526f, -0.02497907f, 
    -0.52466238f, -0.16855495f, 0.09940264f, -0.26656151f, -0.03986417f, -0.15775332f, 0.05612266f, -0.01286666f, 
    0.03432388f, -0.03865465f, 0.09047399f, 0.12502980f, -0.18280132f, 0.05147598f, -0.03923587f, -0.05906263f, 
    0.11168829f, -0.05275723f, 0.13689086f, 0.00832201f, 0.20504989f, 0.34122267f, -0.26699775f, 0.20569350f, 
    0.14098024f, 0.13437122f, 0.04505442f, 0.09457187f, 0.12713680f, 0.11505889f, 0.01375730f, 0.03909807f, 
    0.11044183f, -0.09363049f, 0.01481782f, 0.04613657f, -0.00709124f, -0.02407935f, 0.11716675f, 0.01686978f, 
    0.15911879f, -0.06893529f, 0.18521351f, 0.01735204f, -0.08630177f, -0.22952479f, 0.06236445f, 0.00040005f, 
    0.10966319f, 0.01092248f, 0.12268458f, 0.03248990f, 0.00550089f, 0.00263644f, 0.05086864f, -0.09243423f, 
    0.16027282f, -0.10459814f, 0.14917864f, 0.09856901f, 0.23051180f, -0.11380436f, 0.07691767f, -0.00575919f, 
    -0.03859296f, -0.01275584f, -0.12152679f, -0.03103981f, 0.08040036f, -0.21009970f, 0.00333636f, 0.02888204f, 
    0.07557241f, -0.03882757f, -0.13139825f, 0.18950835f, 0.14673561f, -0.20391160f, 0.00541702f, -0.11261668f, 
    0.25195986f, 0.34403625f, -0.25077212f, 0.13225853f, -0.09496885f, 0.01872141f, -0.07932143f, -0.02254981f, 
    0.17181359f, 0.15216197f, -0.21827668f, 0.17399876f, 0.02570829f, 0.13792354f, 0.07203236f, -0.02031379f, 
    0.09468085f, 0.15509354f, -0.03403494f, 0.22921893f, -0.24672422f, -0.16503327f, 0.20607860f, -0.12402681f, 
    0.10044527f, 0.09780948f, 0.03522974f, -0.01185356f, -0.21913366f, 0.03677989f, 0.07208152f, 0.03644991f, 
    -0.09019429f, 0.14845324f, -0.15328884f, -0.00524089f, 0.11175812f, 0.08676292f, 0.03554381f, -0.11569200f, 
    -0.07461195f, 0.09397575f, -0.45849967f, 0.14444220f, 0.04147211f, 0.03534266f, 0.02736818f, -0.10691483f, 
    -0.14294007f, 0.08602281f, -0.08616596f, 0.08878394f, -0.02624568f, -0.02919026f, 0.08100277f, -0.05586530f, 
    -0.11001396f, 0.18891940f, 0.00095336f, -0.03215875f, 0.29965103f, 0.04013482f, 0.16410762f, -0.12408663f, 
    0.01935154f, 0.02117215f, 0.02442236f, 0.02096795f, -0.07203260f, -0.08207113f, 0.00821706f, 0.00751492f, 
    0.03235728f, 0.01266796f, 0.03562291f, 0.06127627f, 0.09228006f, -0.10102292f, 0.16629358f, -0.07733756f, 
    -0.43934879f, 0.00654318f, -0.12464117f, 0.02678979f, 0.11643904f, 0.02491699f, -0.03884831f, 0.00347164f, 
    0.09628087f, 0.10346606f, -0.03695569f, -0.05952730f, -0.01495466f, 0.09263745f, 0.00380465f, 0.06797849f, 
    0.02384788f, -0.00640111f, -0.02604303f, 0.18979806f, 0.07588808f, -0.17440048f, -0.13230899f, -0.06387357f, 
    0.00053986f, -0.15895958f, -0.00280748f, -0.02396466f, -0.16371973f, -0.13033640f, -0.06941801f, 0.18566854f, 
    -0.01242201f, -0.07125508f, -0.07426831f, 0.12618104f, 0.05275797f, 0.07744107f, -0.02363397f, 0.01368495f, 
    -0.23321754f, -0.05335094f, 0.01354656f, -0.08897967f, -0.04927643f, -0.10805679f, -0.02985581f, 0.00429921f, 
    -0.07644078f, 0.05986349f, -0.07751960f, -0.05824193f, -0.16675015f, 0.13685088f, 0.00539721f, -0.09583013f, 
    0.02993471f, -0.03948112f, -0.04698171f, 0.05039808f, -0.42878899f, 0.06656175f, -0.36337325f, -0.29591912f, 
    0.21897206f, 0.02894000f, -0.00485950f, -0.02813092f, 0.13906370f, 0.11240938f, -0.19127700f, -0.04049402f, 
    -0.01192047f, -0.02514392f, 0.00300859f, 0.02549766f, -0.10412198f, 0.01267648f, -0.05737561f, -0.05643915f, 
    -0.01169427f, -0.05909914f, 0.03544736f, 0.03812813f, 0.01154141f, 0.01135025f, 0.01566992f, 0.00537242f, 
    -0.01678739f, -0.00989297f, 0.04428135f, -0.02750624f, -0.06726275f, 0.04338104f, -0.00787318f, -0.03491818f, 
    -0.03941727f, -0.02648163f, 0.02280427f, -0.00126501f, 0.02399702f, 0.03519766f, 0.00201215f, -0.02442059f, 
    -0.02653634f, -0.05806860f, -0.02098280f, -0.05923304f, -0.04860580f, 0.00383731f, 0.03227759f, 0.03120673f, 
    0.02895774f, 0.02150458f, 0.03483426f, -0.02513633f, 0.00601646f, 0.02181286f, -0.04516309f, 0.02504549f, 
    -0.05165372f, -0.04779466f, 0.01153275f, -0.06158923f, -0.03134762f, -0.05205002f, -0.03197807f, 0.00517340f, 
    -0.03648398f, 0.01697544f, -0.01599716f, 0.02929793f, -0.01353217f, -0.03655568f, 0.04101076f, -0.01808146f, 
    0.02644809f, -0.01519360f, -0.03540374f, -0.00696240f, 0.01599159f, -0.04749038f, 0.02011100f, -0.04198729f, 
    -0.02252477f, -0.00433144f, 0.00312929f, -0.01801040f, 0.01650935f, -0.04508654f, -0.03909525f, -0.05671490f, 
    0.00168114f, 0.02755060f, -0.04000189f, -0.00014904f, 0.00961784f, 0.00092096f, 0.04262593f, 0.00745815f, 
    0.01539520f, -0.02223806f, -0.04897162f, -0.05346563f, 0.02778894f, 0.01338531f, -0.05005039f, 0.04478384f, 
    -0.00779800f, -0.03110659f, 0.04017339f, 0.03817575f, 0.02758304f, 0.01856360f, 0.02858604f, -0.04427643f, 
    -0.03408921f, 0.02480652f, 0.00016174f, 0.01527691f, 0.02235419f, -0.04055678f, -0.02561753f, 0.03968032f, 
    -0.02613299f, 0.03028261f, -0.01333062f, -0.01102445f, 0.05325704f, -0.04921064f, 0.01079829f, 0.03513065f, 
    -0.04312087f, 0.04259649f, -0.05302187f, -0.02084932f, -0.04444930f, -0.04543338f, -0.05565476f, 0.04501249f, 
    -0.04662703f, -0.03141207f, -0.00833623f, -0.00631255f, 0.03910889f, -0.05669063f, -0.02839058f, 0.04006250f, 
    0.01569394f, -0.00860093f, -0.02959660f, -0.04533391f, -0.03566076f, -0.02991551f, -0.04710251f, -0.04975266f, 
    0.02141641f, -0.03955723f, -0.00301967f, -0.04877779f, 0.00129228f, 0.01087032f, -0.02705940f, 0.00936732f, 
    0.04304271f, -0.03862607f, -0.04190127f, 0.01529342f, -0.03764730f, -0.01101689f, -0.01137117f, -0.03789392f, 
    -0.00162362f, -0.01017970f, 0.03503213f, -0.05108134f, -0.05566346f, 0.03612905f, -0.05622083f, -0.05653812f, 
    0.03693859f, 0.04150033f, 0.01796206f, -0.01690008f, 0.02516541f, -0.02545124f, 0.02708496f, -0.05657557f, 
    0.02790738f, -0.00341179f, 0.02990458f, -0.05452785f, 0.03940232f, 0.03871164f, 0.02083346f, -0.02074675f, 
    0.01039523f, 0.02727693f, 0.04106259f, 0.00835043f, -0.05973470f, -0.04761182f, 0.03056523f, 0.02496139f, 
    -0.06249722f, -0.04214022f, 0.00016369f, -0.01377846f, 0.04155992f, 0.02374095f, -0.04877495f, 0.04610467f, 
    -0.02688468f, -0.03454092f, -0.04499253f, 0.03482519f, 0.03689265f, -0.03979093f, -0.02712129f, 0.00512597f, 
    -0.05190111f, -0.04648616f, -0.02850476f, 0.02542186f, -0.02099835f, -0.04397255f, -0.03520722f, 0.00139423f, 
    -0.00874850f, 0.04228729f, -0.02616810f, 0.03410487f, -0.00782017f, -0.02241564f, 0.04986366f, 0.01026838f, 
    0.03934054f, 0.02981264f, -0.00212509f, 0.01782294f, -0.04152502f, -0.04180801f, 0.02133242f, -0.02090554f, 
    -0.05104052f, 0.02696245f, -0.05498017f, -0.05953185f, -0.01740341f, -0.02877416f, 0.02636741f, 0.04426880f, 
    0.03009118f, 0.00312451f, -0.02633930f, 0.03481915f, -0.01076637f, -0.06586923f, 0.03329894f, -0.04649606f, 
    -0.00704666f, 0.01799197f, 0.01492918f, 0.01469867f, -0.03583784f, -0.03460331f, -0.01715596f, 0.02792991f, 
    0.04119192f, 0.02196254f, -0.02731252f, -0.03987934f, 0.02583012f, -0.03792811f, 0.00246491f, -0.01818600f, 
    0.04019300f, -0.05797269f, -0.01705507f, 0.01991895f, 0.02478107f, -0.05831663f, -0.03061592f, 0.00755123f, 
    -0.04793919f, -0.06273522f, -0.04915889f, 0.02332023f, -0.04628867f, -0.02437039f, -0.04441807f, 0.00735801f, 
    0.02501866f, -0.04995339f, 0.01929505f, 0.03460208f, -0.02398810f, -0.00194387f, 0.03334463f, 0.02831412f, 
    -0.01164012f, 0.04347871f, 0.03474715f, 0.04741332f, -0.01367861f, 0.00772834f, 0.02951777f, -0.02183402f, 
    -0.03533980f, -0.02524409f, 0.00078915f, 0.04026120f, -0.01937401f, 0.00566616f, 0.00387327f, 0.02077369f, 
    -0.00922771f, 0.03684875f, 0.02987549f, 0.01095576f, -0.04566534f, 0.04681025f, 0.00929234f, 0.06018956f, 
    -0.04883293f, -0.03452304f, 0.00930745f, -0.05210688f, 0.01545560f, -0.03179053f, 0.02268849f, -0.00830317f, 
    -0.04032962f, 0.02852982f, 0.03043833f, -0.06045017f, -0.06534146f, -0.06218781f, -0.02229384f, 0.04727323f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04149279f, 0.01435520f, 0.03883854f, 0.08401867f, 0.00002955f, 0.02416143f, -0.02122740f, 0.06158359f, 
    0.02923584f, -0.13031666f, 0.18265997f, 0.16762887f, 0.02768011f, 0.08036424f, -0.02581502f, -0.01109192f, 
    0.09800369f, 0.04913846f, 0.15180872f, 0.14580078f, -0.08239859f, -0.04609082f, -0.01361279f, -0.00834369f, 
    0.17088348f, -0.01382222f, -0.06055883f, 0.13570990f, 0.07268538f, -0.06447455f, 0.01909414f, 0.07378524f, 
    0.17820138f, 0.01777449f, 0.00779496f, 0.09228663f, -0.01250771f, 0.05179477f, 0.01621018f, 0.01255801f, 
    -0.00094969f, 0.02319466f, 0.15221803f, -0.00772262f, 0.07607418f, 0.00719027f, 0.03757349f, 0.13361079f, 
    0.15340106f, -0.04802079f, -0.01087700f, -0.01248130f, 0.02769736f, 0.17251064f, 0.03264542f, -0.05473710f, 
    -0.04991102f, -0.02453860f, 0.01940554f, 0.02631775f, 0.13498868f, -0.01296674f, 0.14694980f, -0.06276353f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02385283f, 0.08085891f, -0.05078042f, -0.10416385f, -0.11651306f, -0.12015247f, 0.05080883f, -0.15418316f, 
    -0.04439292f, -0.12897441f, -0.15932228f, 0.06300595f, -0.01374393f, -0.17246568f, -0.12708709f, 0.00323430f, 
    0.04388946f, -0.14016601f, -0.16091377f, -0.11059949f, 0.09379059f, -0.00375733f, 0.04918994f, 0.04177434f, 
    -0.06685352f, -0.08415489f, 0.03890883f, 0.05375960f, 0.11180949f, -0.09304143f, -0.17161423f, 0.03326586f, 
    0.00926375f, -0.10214783f, -0.11243170f, -0.03199902f, 0.05284504f, -0.03859426f, 0.06419118f, -0.01916797f, 
    0.05355033f, -0.00019899f, -0.00538766f, -0.03879312f, 0.04977455f, 0.01821487f, 0.09392279f, 0.05415208f, 
    -0.18608677f, -0.13488875f, -0.15993819f, -0.08098067f, 0.00217243f, 0.01553748f, -0.18474786f, 0.00803229f, 
    0.11391777f, -0.01763157f, -0.06584124f, -0.02968626f, -0.08690932f, 0.05468529f, -0.01909062f, 0.03579278f, 
    -0.13023877f, -0.05420259f, 0.03968024f, 0.11429996f, -0.06072603f, 0.05868527f, 0.05524637f, -0.09178971f, 
    -0.06944949f, 0.15175876f, -0.19285192f, -0.07085521f, -0.14377128f, 0.31235266f, -0.27885756f, 0.10929342f, 
    -0.10740781f, -0.07164559f, -0.14326912f, -0.26811427f, -0.07488099f, -0.09439788f, 0.33224633f, 0.12088797f, 
    -0.11042966f, 0.01837156f, 0.31587437f, 0.15412562f, 0.13738467f, 0.00551114f, -0.23106389f, -0.15484872f, 
    0.06021092f, 0.01604325f, -0.11941922f, -0.15076740f, 0.10446563f, 0.08542909f, -0.07320013f, -0.27826536f, 
    -0.08019329f, -0.07274274f, -0.07426543f, -0.10051200f, -0.00662519f, 0.10815787f, 0.01693400f, 0.11092576f, 
    -0.16030443f, 0.09049730f, -0.19814886f, 0.18395016f, -0.24368924f, -0.33019459f, 0.28933990f, 0.10235587f, 
    0.07222863f, 0.12847349f, -0.19016166f, 0.09908872f, 0.20128162f, 0.13384511f, -0.14944586f, -0.11092081f, 
    0.14363542f, 0.23508374f, -0.26669362f, 0.15242890f, -0.08417595f, 0.13595939f, 0.11346124f, -0.34822947f, 
    0.15434317f, -0.23112273f, 0.21356262f, -0.29644650f, 0.28200164f, -0.25897348f, 0.35025874f, 0.22058754f, 
    -0.07013821f, 0.07150026f, -0.02055519f, -0.10136510f, -0.00565944f, -0.06833869f, 0.09124406f, 0.22626166f, 
    0.21362524f, 0.10112246f, -0.00397929f, -0.34709075f, 0.00557999f, 0.13593091f, -0.02628914f, 0.16212481f, 
    0.04487585f, -0.03793442f, -0.08892203f, -0.29343385f, 0.09703609f, 0.08410688f, -0.12422734f, 0.24665472f, 
    0.22019851f, 0.05748332f, 0.12150013f, -0.10721371f, 0.08629327f, -0.10431612f, 0.01214841f, -0.05903152f, 
    -0.04051446f, -0.05109145f, -0.07846460f, 0.00266249f, 0.14602801f, -0.04520877f, -0.12859203f, -0.06362595f, 
    -0.11185103f, 0.26236904f, 0.14610766f, 0.12565173f, 0.16318096f, 0.18501137f, 0.30761078f, 0.08933297f, 
    0.20457438f, 0.19668974f, 0.15868334f, -0.07341143f, -0.12196416f, 0.13577649f, -0.06501533f, -0.04069664f, 
    -0.04758480f, -0.03769688f, 0.15936348f, 0.11502825f, 0.21037343f, 0.07408567f, 0.10650884f, -0.05246501f, 
    -0.08985410f, 0.20995076f, 0.08743146f, 0.18421875f, -0.10223553f, -0.09976634f, -0.17343749f, -0.05432465f, 
    0.19278315f, -0.02722119f, -0.12987253f, -0.07080282f, 0.06093311f, -0.10448318f, 0.17189525f, -0.27524626f, 
    0.24707845f, 0.11080028f, -0.02138886f, -0.06352300f, 0.02946703f, -0.09027576f, -0.11611554f, 0.08872889f, 
    0.02654371f, -0.00514562f, 0.05498850f, -0.17980625f, -0.10867561f, -0.09277110f, -0.01942441f, 0.20056951f, 
    0.06136082f, 0.19533879f, -0.30987066f, 0.03970627f, -0.29132059f, 0.16549051f, -0.12323207f, 0.11720706f, 
    0.04389010f, 0.16575852f, 0.09536857f, 0.00939810f, 0.28587127f, -0.00197205f, -0.01144636f, -0.05532663f, 
    0.11591453f, 0.25608987f, 0.10828397f, 0.20918427f, -0.08753270f, -0.01897417f, 0.08316021f, -0.23479375f, 
    0.09182215f, 0.05643060f, 0.26808473f, -0.15039669f, 0.11812402f, -0.04508564f, 0.13177356f, -0.04356634f, 
    -0.23504926f, -0.03233928f, 0.13100728f, 0.01585432f, -0.02653491f, 0.05190594f, 0.00318063f, 0.19588600f, 
    0.44493735f, -0.05499824f, -0.08225788f, 0.00874193f, 0.09967332f, -0.02222039f, -0.16174518f, -0.12539549f, 
    -0.15520440f, -0.12220497f, -0.07793382f, -0.00803045f, -0.01784780f, -0.02495383f, -0.16171616f, -0.00571421f, 
    0.02139473f, -0.08505827f, 0.05769640f, -0.03412481f, -0.05693953f, 0.02776846f, -0.12258843f, 0.10567950f, 
    -0.03577303f, 0.21553181f, -0.39001840f, -0.02164693f, -0.18057655f, 0.03630460f, 0.19645630f, 0.09213194f, 
    0.02655142f, 0.09090814f, 0.02837660f, 0.06832542f, 0.17232388f, 0.17689134f, 0.19943723f, -0.12791301f, 
    -0.21598189f, 0.14680028f, 0.08056602f, -0.28852549f, -0.00927381f, 0.18064320f, -0.10022110f, 0.20903346f, 
    0.13626263f, -0.28289825f, 0.35290918f, 0.08543990f, -0.15685780f, 0.07263422f, 0.15282822f, -0.09590936f, 
    -0.20605278f, 0.23137611f, 0.16350150f, 0.12886044f, 0.13695793f, -0.03661136f, -0.19662504f, -0.11635189f, 
    -0.05776453f, -0.04423606f, -0.07037192f, 0.13312691f, 0.20151216f, 0.13377169f, -0.01804685f, 0.26155794f, 
    0.17813767f, -0.11286772f, -0.09777347f, 0.18422705f, -0.00764533f, -0.00255372f, 0.04999322f, -0.10363476f, 
    -0.19306342f, 0.06099587f, -0.23477075f, 0.05874651f, 0.10611039f, -0.06712766f, 0.00177766f, -0.02528254f, 
    -0.07640138f, -0.20059042f, 0.12089311f, 0.01534965f, -0.07877126f, 0.30623659f, -0.13169540f, -0.09966122f, 
    0.04263144f, -0.21397428f, -0.05249983f, 0.16508794f, -0.18022047f, -0.07363711f, 0.27899715f, -0.11268302f, 
    0.05498585f, 0.05470416f, -0.35188174f, 0.11834557f, -0.05445838f, -0.05515916f, 0.01723829f, 0.06740605f, 
    0.12033674f, 0.15896668f, 0.17609580f, -0.36112857f, 0.16092980f, 0.16987295f, 0.09922794f, -0.03409230f, 
    -0.29054260f, -0.20918117f, -0.38785034f, -0.31787029f, 0.38056540f, 0.05820511f, 0.20271374f, 0.28561446f, 
    -0.05875199f, 0.10222526f, 0.28827167f, -0.00576073f, 0.00845790f, 0.15820985f, 0.04280619f, 0.27480516f, 
    -0.10759612f, 0.00715211f, -0.18616097f, -0.18137419f, 0.01583152f, 0.10059907f, 0.03532422f, 0.15861404f, 
    -0.09316087f, -0.11574060f, -0.25393853f, -0.02437428f, -0.07564184f, -0.06408060f, 0.07325436f, -0.26298279f, 
    -0.19510110f, 0.19253884f, 0.20429730f, 0.07059650f, -0.02254971f, -0.16656445f, -0.11314664f, 0.08142048f, 
    -0.11869811f, 0.21167488f, -0.08300789f, 0.27978757f, -0.27408099f, 0.03780131f, 0.03817180f, 0.01731556f, 
    -0.02524254f, 0.02717838f, 0.10915177f, 0.18017410f, -0.06635861f, 0.14614828f, 0.05054019f, 0.02510018f, 
    -0.19455327f, -0.20207736f, -0.06183936f, 0.12268800f, 0.22152445f, 0.15208420f, -0.38610590f, -0.15100931f, 
    -0.16386618f, 0.24492376f, 0.01166062f, 0.13093215f, 0.24734883f, -0.02717540f, -0.02430550f, 0.33424249f, 
    0.06748305f, -0.13175443f, 0.06209047f, 0.08859681f, 0.03289532f, -0.10421433f, -0.15545185f, -0.31264800f, 
    0.19599830f, 0.00785653f, -0.01645806f, -0.16319552f, 0.05715759f, -0.11904638f, 0.00318655f, -0.08336154f, 
    0.23085943f, -0.04760336f, 0.08712973f, -0.17496553f, 0.22851862f, 0.08821445f, -0.09700251f, -0.01414914f, 
    -0.15666020f, 0.05144824f, -0.30417022f, 0.18716392f, -0.31565848f, -0.13500260f, 0.15634660f, 0.09013242f, 
    0.10058378f, -0.02881622f, 0.08691815f, 0.11348579f, -0.03869063f, 0.05082963f, -0.25202474f, -0.02020123f, 
    0.29753032f, -0.03295387f, -0.15908769f, -0.07345968f, 0.03454047f, -0.10473234f, -0.04058321f, -0.19279543f, 
    -0.07801869f, 0.01711445f, -0.39933467f, 0.05340489f, 0.10992368f, -0.11858511f, 0.57421094f, 0.18628952f, 
    0.03847009f, -0.28972450f, -0.04955643f, -0.00720559f, 0.12218624f, 0.03444146f, -0.06584780f, 0.20485121f, 
    0.10559565f, 0.09809089f, 0.09418038f, -0.20020299f, -0.19722095f, 0.03734617f, 0.17531526f, -0.03201498f, 
    -0.04054184f, 0.10461899f, -0.10368600f, -0.22548611f, -0.10184335f, -0.04765186f, -0.34335047f, 0.20387158f, 
    0.07437248f, -0.11311177f, -0.11254610f, -0.18268420f, -0.14220712f, -0.05369782f, 0.00586198f, -0.14397661f, 
    0.13856634f, 0.21353129f, -0.02341357f, -0.24283443f, 0.12389050f, 0.01154694f, -0.24885863f, -0.02545115f, 
    0.05102377f, 0.06552205f, 0.06394300f, -0.02036886f, 0.07125465f, 0.02532176f, -0.01140703f, -0.01834134f, 
    -0.02690487f, 0.05568086f, -0.08212621f, 0.06536421f, 0.03944109f, 0.32962179f, -0.00237715f, -0.29263243f, 
    0.15970659f, -0.18144897f, 0.10331634f, -0.09153416f, 0.12097872f, -0.00257091f, -0.12208522f, -0.09922668f, 
    -0.08697766f, 0.31873313f, 0.01515669f, 0.01181483f, 0.00393035f, -0.05153935f, 0.10263739f, 0.03524707f, 
    0.33880669f, 0.06174652f, -0.04532008f, 0.05151772f, 0.15011473f, 0.08424006f, -0.23994592f, -0.07836366f, 
    0.12138391f, -0.00778585f, 0.00926543f, -0.22213204f, 0.09242529f, -0.04130668f, -0.03048100f, 0.30580848f, 
    0.15967843f, -0.04041797f, 0.08522238f, -0.12434920f, 0.12577307f, -0.05604950f, 0.00721176f, 0.00489252f, 
    0.07976300f, -0.13114519f, -0.43680260f, 0.29097858f, -0.21079157f, -0.20769446f, 0.15299946f, -0.06991029f, 
    0.08588426f, 0.11843576f, 0.21121557f, 0.12340594f, 0.18445404f, -0.10964452f, 0.19376671f, -0.04723432f, 
    0.31773043f, 0.29527265f, 0.00389715f, 0.13765226f, -0.08164231f, -0.42799535f, -0.07210223f, 0.05904427f, 
    -0.17558767f, -0.08101595f, 0.04860401f, -0.09459349f, 0.01798212f, -0.03738767f, 0.15298794f, 0.15839453f, 
    0.00389237f, -0.02037742f, 0.11028672f, 0.02544849f, 0.30627498f, -0.02306639f, 0.22013506f, 0.43942344f, 
    -0.11776657f, 0.12925476f, -0.01017075f, -0.12191854f, 0.01987302f, 0.10529674f, 0.18132415f, 0.01183071f, 
    -0.01714243f, -0.10815968f, 0.04526573f, -0.01100041f, 0.08883023f, 0.04418626f, -0.02054431f, -0.47010401f, 
    0.08332834f, 0.00294800f, -0.03442273f, -0.26888871f, 0.09314511f, 0.01947902f, 0.10003566f, 0.01182754f, 
    -0.13496935f, 0.20483899f, -0.00930888f, -0.02911281f, 0.13198587f, -0.00417615f, -0.13179524f, -0.08541861f, 
    0.10457923f, 0.27076742f, 0.03712792f, 0.04871111f, 0.02681166f, 0.25706348f, -0.05144546f, 0.12011226f, 
    0.23291205f, -0.07685179f, -0.05069259f, -0.02149123f, -0.10761937f, 0.06580066f, 0.11172037f, -0.16276559f, 
    -0.03179249f, 0.02608577f, 0.15908819f, -0.13979912f, -0.12577730f, -0.02407627f, 0.04168177f, -0.28897250f, 
    -0.16451798f, -0.05516902f, -0.01495302f, 0.07063837f, -0.10864872f, 0.00685509f, -0.10399733f, 0.07455203f, 
    0.08839878f, -0.00644096f, -0.13795109f, -0.12608314f, -0.17212132f, 0.03226976f, 0.21618171f, -0.00620978f, 
    -0.01671760f, 0.03177567f, 0.02409522f, -0.18790267f, 0.10611971f, 0.20684476f, -0.03165362f, -0.01164136f, 
    -0.15395066f, -0.04900575f, -0.09230272f, 0.05562844f, -0.05276388f, 0.00171554f, -0.05061862f, 0.08936942f, 
    0.05429313f, -0.07799589f, -0.02161363f, -0.04932023f, -0.04929084f, 0.21026194f, 0.03508788f, 0.05875364f, 
    0.01913122f, -0.03329520f, -0.14686868f, -0.27229771f, 0.13666795f, -0.22224046f, 0.14456625f, 0.11581056f, 
    0.01152146f, -0.06108202f, 0.07274798f, 0.11385563f, -0.07021186f, -0.01996823f, -0.04691917f, -0.31956968f, 
    -0.12751675f, 0.00193739f, 0.33760953f, -0.13041359f, 0.01521242f, 0.13147540f, 0.28315410f, 0.22020502f, 
    -0.07604758f, 0.13325422f, 0.21745980f, -0.18236510f, -0.22279626f, 0.08520131f, 0.13387822f, -0.25398594f, 
    0.11492070f, -0.09218374f, 0.14644602f, -0.08229918f, -0.09684890f, 0.06552241f, -0.01054954f, -0.18935598f, 
    0.21603075f, 0.05752526f, -0.19095814f, 0.02176122f, 0.02208048f, 0.17390689f, -0.11221062f, 0.07368630f, 
    0.13701408f, -0.00244062f, -0.03708018f, 0.04249155f, -0.02241514f, 0.01936123f, -0.03234203f, -0.07280778f, 
    -0.10833649f, 0.02800378f, -0.14885353f, 0.13378356f, -0.27787435f, 0.44784838f, -0.04597895f, 0.00000566f, 
    -0.09796081f, 0.15487033f, 0.15112402f, -0.14086105f, 0.38509575f, 0.04136116f, 0.26159313f, -0.04648451f, 
    0.22123644f, 0.04558076f, 0.05047685f, 0.00193924f, 0.06932329f, 0.08741385f, -0.08686943f, 0.01605363f, 
    -0.02537002f, 0.09515304f, 0.42921329f, 0.02359150f, 0.08874130f, -0.02187726f, 0.18533818f, 0.14208619f, 
    -0.02332437f, -0.07519216f, 0.19674030f, 0.13845474f, -0.40419212f, 0.05278415f, -0.15764275f, -0.29341838f, 
    0.35630453f, 0.00402164f, -0.00660191f, -0.14518400f, -0.04437577f, -0.16874255f, -0.04596024f, 0.10422917f, 
    0.02331235f, -0.06911720f, -0.19033134f, -0.07796618f, 0.09405504f, 0.25515735f, -0.16460991f, 0.05458843f, 
    -0.04267098f, 0.04705836f, 0.16505787f, 0.09222056f, -0.20848168f, -0.12043045f, -0.09921716f, 0.14263655f, 
    0.14805493f, 0.21256667f, -0.08220220f, -0.00488702f, -0.06761601f, 0.05844264f, -0.07049490f, 0.02769111f, 
    0.04268846f, 0.05071091f, -0.10673446f, -0.13633035f, 0.06827113f, -0.26984918f, 0.25596458f, 0.05997046f, 
    -0.34870359f, 0.16752321f, -0.10348877f, -0.12814198f, 0.05697450f, 0.15335222f, 0.01043059f, 0.11339351f, 
    0.12300721f, -0.39961946f, -0.06034972f, 0.14287004f, -0.10719484f, -0.04418521f, 0.03650953f, 0.10330208f, 
    0.02625902f, 0.20431168f, 0.09346868f, 0.20664661f, 0.23219289f, 0.02149515f, -0.12977847f, -0.02272257f, 
    -0.32593238f, 0.06353460f, 0.03947958f, 0.12687458f, 0.01973549f, -0.01174674f, 0.19393414f, 0.03568452f, 
    0.27365854f, -0.01344520f, -0.09451072f, 0.14765154f, -0.04711894f, 0.04907024f, 0.31734690f, -0.23585047f, 
    -0.13595194f, 0.03600289f, -0.17441618f, 0.09572638f, -0.08878459f, -0.09196316f, -0.00995491f, 0.02583326f, 
    -0.00304520f, -0.25446352f, 0.27059895f, -0.05539663f, 0.04183484f, 0.19968231f, -0.17069755f, 0.03385802f, 
    -0.03972786f, -0.20536473f, -0.03214673f, 0.09839299f, -0.09763681f, 0.07308713f, 0.19838662f, 0.08624680f, 
    0.03645432f, 0.02281016f, -0.01524489f, 0.00901295f, 0.08370928f, 0.19928862f, -0.01018967f, -0.04300371f, 
    0.15132698f, 0.02494384f, 0.02940604f, 0.34296116f, -0.00174522f, 0.14423411f, -0.00992694f, -0.05569350f, 
    -0.07434090f, 0.09256922f, 0.24899264f, -0.10602005f, -0.10614499f, -0.05342291f, -0.16438864f, 0.09696088f, 
    0.22005557f, -0.04339148f, -0.06203815f, 0.17581053f, -0.03846066f, -0.01014732f, 0.07104973f, -0.11921237f, 
    -0.00775254f, -0.08200463f, 0.14945729f, -0.00770445f, 0.09769348f, 0.17681183f, -0.24494369f, -0.07043339f, 
    0.03287882f, 0.02368572f, 0.18037134f, 0.16755970f, -0.09203097f, 0.00165899f, -0.10663899f, 0.17895035f, 
    0.15841019f, -0.06257369f, -0.02672003f, 0.16972813f, -0.15349633f, 0.27045101f, 0.05819872f, 0.09052400f, 
    0.08207021f, -0.05208434f, 0.16434833f, -0.11556885f, 0.14481652f, -0.15010716f, -0.05675171f, -0.06669181f, 
    0.07342841f, 0.33258620f, 0.28520244f, -0.15460794f, 0.00291614f, -0.12081652f, 0.10360771f, 0.11720344f, 
    -0.21575506f, -0.16840667f, 0.21771887f, -0.07513998f, 0.12986752f, 0.11822075f, 0.38518682f, -0.07633077f, 
    -0.08583233f, 0.09401986f, -0.05292632f, -0.02958856f, 0.45053783f, 0.02399108f, 0.20333776f, 0.45935917f, 
    -0.16497061f, 0.07686262f, 0.18147634f, -0.09176853f, -0.08539177f, 0.27501908f, 0.15202725f, -0.21981844f, 
    0.04912364f, 0.00865769f, -0.01150418f, -0.00124075f, -0.06209147f, 0.10495602f, 0.01434805f, -0.20766591f, 
    0.09981948f, -0.06147150f, -0.11605968f, -0.08698136f, -0.14607494f, 0.01438427f, -0.03602093f, -0.12855288f, 
    -0.22825089f, 0.25661212f, 0.05635772f, 0.09538484f, 0.05559587f, -0.12817864f, 0.06462126f, 0.03604434f, 
    0.02421381f, 0.29199511f, -0.18477899f, 0.16636953f, -0.02105103f, 0.17750816f, 0.01657137f, -0.04152811f, 
    -0.10212587f, -0.13419779f, 0.08214319f, -0.03328949f, -0.00914221f, 0.12411007f, 0.08003302f, -0.12000010f, 
    -0.12241911f, -0.13198580f, -0.13462946f, -0.00313595f, -0.09422275f, -0.10819951f, -0.11918498f, -0.10322929f, 
    0.00217781f, -0.02552381f, -0.10005244f, -0.01545239f, 0.05284986f, -0.05187361f, -0.09943272f, -0.00387994f, 
    -0.04749580f, -0.02539337f, -0.06299634f, -0.10994533f, 0.00222856f, -0.11937101f, 0.06409144f, 0.07719976f, 
    -0.06773502f, -0.02022977f, -0.01264460f, -0.13442235f, 0.07402025f, 0.10935940f, -0.00663902f, 0.00876129f, 
    0.02710953f, -0.04891679f, 0.09981629f, -0.11412838f, -0.06495213f, -0.08380173f, -0.10737841f, -0.05990827f, 
    0.06170142f, -0.06692845f, 0.09812168f, -0.10617573f, -0.02254622f, 0.06843741f, -0.05287235f, 0.09579504f, 
    0.10497422f, 0.05542175f, -0.02152452f, -0.12640361f, -0.07758607f, 0.05254536f, -0.03333154f, 0.00045058f, 
    0.17906760f, 0.05816033f, -0.03812672f, -0.00688118f, 0.02885323f, -0.23234154f, 0.02362088f, 0.27996150f, 
    -0.28647649f, -0.25553992f, -0.18201908f, 0.00006296f, 0.07299136f, 0.18670094f, -0.02446299f, -0.11934189f, 
    -0.00481975f, 0.09822918f, -0.26946196f, 0.09604695f, 0.33548236f, 0.12488597f, -0.08975815f, 0.02656887f, 
    -0.27934772f, 0.11249866f, 0.20234556f, 0.10937715f, -0.07950810f, -0.14686653f, 0.22051592f, -0.13580178f, 
    0.28883108f, 0.11639293f, -0.34745160f, 0.06037738f, 0.03265645f, 0.18942744f, -0.02325139f, -0.18690261f, 
    -0.10534268f, 0.01867601f, -0.12640546f, -0.05295132f, -0.18112402f, 0.08136880f, 0.12570634f, -0.11381346f, 
    -0.12762384f, 0.19369029f, 0.37521636f, -0.12661122f, 0.03523056f, 0.12421995f, -0.11242823f, 0.02468121f, 
    0.01197590f, -0.01177282f, -0.09763100f, 0.10674451f, -0.16425943f, -0.02553413f, -0.19157934f, 0.09025518f, 
    0.18757713f, 0.09990748f, -0.17009954f, 0.07748630f, 0.08492103f, 0.15182814f, -0.01566318f, -0.05861399f, 
    -0.14164215f, 0.21165203f, -0.11158172f, -0.13754356f, 0.09534448f, -0.15014000f, 0.38802403f, 0.03121577f, 
    0.03274361f, -0.07510392f, -0.15405299f, 0.00497691f, 0.17269032f, -0.08169419f, -0.11893085f, -0.01649201f, 
    0.20624959f, -0.06284431f, 0.20175481f, -0.23466511f, -0.10528083f, 0.06670400f, 0.05381905f, 0.05895063f, 
    -0.20319566f, -0.07824143f, 0.14293225f, -0.12446457f, -0.05832953f, -0.01407473f, -0.11749739f, 0.28223264f, 
    -0.06072712f, -0.00474791f, 0.02342557f, -0.17293948f, -0.05406980f, -0.01616031f, -0.11476948f, -0.01151485f, 
    0.10706379f, 0.07641916f, 0.04117604f, -0.16088380f, 0.25245851f, 0.00923788f, 0.03083548f, 0.04054505f, 
    0.04618941f, 0.06501345f, 0.17399845f, 0.14802322f, -0.27842551f, 0.05129226f, 0.00337870f, 0.07408120f, 
    0.22797601f, 0.23583592f, 0.01815357f, 0.14478806f, -0.04835227f, -0.16264725f, 0.05217664f, 0.14495961f, 
    0.06070663f, -0.13474199f, 0.19239949f, 0.00529327f, -0.12423282f, -0.09439851f, -0.08562516f, 0.09121752f, 
    -0.00189199f, 0.12855034f, 0.14504541f, 0.13147193f, 0.05979344f, -0.11660123f, -0.18650280f, 0.23126724f, 
    0.39599538f, 0.00734825f, -0.32546169f, 0.29279169f, 0.15257466f, -0.05356137f, 0.07228599f, 0.23491620f, 
    -0.08889523f, -0.09868062f, 0.22731508f, 0.22057112f, -0.11980630f, -0.07903121f, -0.08218765f, -0.32486755f, 
    -0.02938544f, 0.06839713f, 0.08959772f, 0.06912761f, 0.05268525f, 0.09191008f, -0.10989457f, 0.15938810f, 
    -0.00744826f, 0.09195427f, 0.02656223f, -0.20861216f, -0.02375308f, 0.07962696f, -0.17747834f, 0.01442166f, 
    0.00336019f, 0.14635038f, 0.02340498f, 0.25740206f, -0.15420824f, 0.04002072f, 0.08454702f, 0.04282382f, 
    -0.12766971f, 0.11758816f, 0.00061967f, -0.18900426f, -0.06893310f, 0.09829184f, -0.12478553f, 0.17015800f, 
    0.02145945f, -0.31381756f, -0.09822030f, 0.02244438f, -0.01345884f, 0.20891270f, 0.07930123f, -0.10172731f, 
    0.12029730f, 0.24058767f, -0.05274432f, 0.20441921f, 0.09218507f, 0.06259125f, 0.15483896f, -0.20127091f, 
    -0.22725357f, 0.06203358f, -0.00952547f, 0.04209712f, 0.03740894f, 0.16342297f, 0.01270170f, 0.06229055f, 
    0.27803496f, -0.10559329f, -0.12482849f, 0.21210028f, -0.10824709f, 0.15105708f, 0.10887638f, -0.23296081f, 
    -0.03893624f, 0.11125377f, -0.29226500f, 0.02057834f, -0.10130224f, -0.12137090f, -0.05562721f, -0.08126123f, 
    -0.08608580f, 0.08360381f, 0.09035532f, 0.13903585f, -0.12337682f, 0.19685404f, 0.00932317f, 0.04405111f, 
    0.10696961f, -0.10201601f, -0.10335043f, 0.01457568f, -0.07511285f, -0.23922393f, 0.08912471f, 0.03794241f, 
    0.10960244f, -0.15890238f, -0.06294227f, 0.10440942f, 0.07248755f, -0.27022725f, 0.03407189f, -0.05201582f, 
    0.00072047f, -0.05840498f, 0.12794602f, -0.20251289f, -0.11627425f, 0.13143526f, -0.18950379f, 0.17089379f, 
    0.03225821f, -0.04979765f, 0.07938503f, -0.17402990f, -0.17301686f, -0.12160499f, 0.23114456f, -0.04290312f, 
    0.13957873f, -0.11306130f, -0.05007261f, 0.15966113f, 0.15500470f, -0.12731561f, -0.07934677f, 0.22722119f, 
    0.22256495f, -0.00079583f, -0.09122492f, 0.26268384f, -0.09735263f, -0.00481914f, 0.00120433f, -0.23664555f, 
    -0.05845806f, -0.11001805f, 0.19799146f, 0.21340376f, -0.06056327f, 0.00409170f, 0.05203053f, 0.16581145f, 
    -0.06807419f, 0.03730514f, -0.00019706f, 0.22311656f, -0.23914546f, -0.04715468f, 0.21967867f, -0.11910174f, 
    -0.04873108f, 0.01680338f, -0.11478700f, 0.11812682f, 0.16162816f, 0.09921753f, 0.18082222f, 0.10144162f, 
    -0.26408342f, 0.03632095f, 0.19874151f, -0.33051106f, 0.06947493f, 0.08240592f, 0.05847895f, 0.19549891f, 
    -0.21153076f, -0.10882835f, -0.06297072f, 0.07096261f, 0.10815853f, 0.12906726f, 0.20005085f, -0.10517240f, 
    -0.05390771f, 0.24525379f, 0.17261647f, 0.22845927f, 0.25392351f, -0.02299732f, 0.03698563f, -0.02666070f, 
    -0.26412642f, -0.01466673f, 0.11630058f, -0.06260151f, -0.17336641f, 0.24813648f, -0.03492625f, -0.00669981f, 
    0.24268986f, 0.01556908f, -0.13064073f, 0.01909669f, 0.01451329f, 0.00979515f, 0.35696945f, 0.10713426f, 
    0.22172588f, 0.04089863f, -0.23353608f, -0.09027341f, 0.05327311f, 0.02457973f, 0.12012763f, -0.03536132f, 
    0.01438577f, 0.06126606f, 0.02288304f, 0.17663865f, -0.00631215f, -0.06072788f, 0.05269291f, -0.01511428f, 
    0.03169280f, -0.27337202f, -0.08216229f, -0.06534346f, -0.02466923f, -0.20672436f, -0.09239602f, -0.04809190f, 
    -0.22390662f, -0.00626857f, -0.18204723f, 0.06115483f, 0.08685188f, 0.01459859f, -0.05872527f, -0.02992142f, 
    0.21784717f, 0.09276851f, -0.04610107f, -0.11018284f, -0.23498324f, -0.02544554f, -0.21530825f, 0.10865451f, 
    -0.29290864f, -0.03501668f, -0.02061374f, -0.02366629f, -0.16656034f, -0.10529450f, -0.13287729f, -0.24904640f, 
    0.44104049f, 0.08672132f, -0.17738394f, 0.17753339f, 0.25221866f, -0.31688955f, -0.08675648f, 0.22264540f, 
    -0.03641709f, 0.12338739f, -0.06265533f, 0.25001958f, -0.12813532f, 0.26895997f, 0.05995497f, -0.11665146f, 
    -0.36995119f, -0.09866671f, 0.13376884f, 0.19675428f, 0.12041125f, 0.02628292f, -0.04418760f, 0.30372369f, 
    -0.14104052f, 0.07705471f, 0.19492616f, -0.12033928f, -0.22862847f, -0.17912358f, 0.05465417f, 0.10913119f, 
    -0.12105025f, -0.28157917f, -0.16782492f, 0.12375344f, -0.35216722f, -0.04859973f, 0.05935770f, 0.00203949f, 
    0.21061236f, -0.04207128f, -0.21985404f, 0.10349691f, -0.00422157f, -0.09813028f, -0.03404902f, 0.02498840f, 
    -0.21514788f, 0.09639370f, -0.13041759f, -0.08702122f, 0.08167712f, 0.11042111f, -0.16886793f, 0.25126410f, 
    -0.24475381f, -0.12140781f, -0.34586087f, -0.09567050f, 0.21533716f, 0.11792269f, 0.23798741f, 0.12026445f, 
    -0.00575237f, -0.03030785f, 0.12477274f, 0.14516789f, -0.14316423f, -0.21161455f, 0.14286402f, -0.07048770f, 
    0.24225831f, -0.07592862f, -0.31938604f, 0.00591169f, 0.03166673f, 0.35325179f, 0.06266227f, -0.14822514f, 
    -0.07578997f, 0.00901563f, -0.09943189f, 0.26440051f, -0.08594071f, -0.02255822f, -0.03015582f, -0.13345478f, 
    -0.39352629f, 0.20957690f, 0.31994894f, -0.03162423f, -0.17467843f, -0.12132677f, -0.08057489f, 0.09289851f, 
    -0.10320538f, 0.19245252f, -0.00595391f, 0.11642705f, -0.19142091f, 0.02075727f, -0.15732783f, -0.03572734f, 
    0.04458344f, -0.28355426f, -0.00416882f, 0.00307438f, 0.04000177f, -0.16107759f, 0.06460194f, -0.15574959f, 
    -0.20596458f, -0.00818485f, 0.02878216f, 0.08861006f, -0.03739919f, 0.10002717f, -0.05069666f, 0.25982180f, 
    0.16015156f, -0.08506118f, 0.04054404f, 0.15603295f, -0.38620001f, -0.10121255f, 0.06682030f, -0.45157921f, 
    0.10976639f, -0.12128034f, 0.03092115f, 0.00975887f, 0.07124852f, -0.19029447f, 0.20848092f, 0.14660299f, 
    0.14019082f, 0.05129766f, -0.10875689f, 0.04152757f, -0.08407182f, -0.00962456f, -0.34001523f, -0.14603755f, 
    0.04495308f, -0.03577638f, 0.13781135f, -0.03273837f, -0.16955313f, -0.07487909f, -0.10047313f, 0.14440764f, 
    -0.08829324f, 0.12660311f, 0.25313684f, 0.11975862f, -0.16790976f, -0.01962044f, 0.09063119f, -0.07096747f, 
    -0.11835869f, -0.12777750f, 0.12710720f, -0.02684317f, 0.36802736f, -0.15067063f, 0.10424111f, -0.06019228f, 
    0.30409420f, 0.30856839f, 0.17021111f, -0.16709433f, -0.00626225f, -0.21856883f, -0.01685113f, 0.00908663f, 
    -0.21653545f, -0.30459517f, 0.20092027f, -0.04219432f, 0.14715485f, 0.09935392f, 0.24472030f, -0.08015767f, 
    0.19971417f, -0.02554907f, -0.14907372f, 0.03961313f, 0.11679801f, 0.02925823f, 0.03868379f, -0.13069567f, 
    -0.02292668f, -0.04207136f, 0.16903296f, -0.06884404f, -0.03024194f, 0.08803736f, 0.24044645f, 0.01127056f, 
    -0.08068698f, 0.06158851f, 0.01257314f, 0.02672674f, -0.06223845f, -0.21392278f, -0.02530043f, -0.01209440f, 
    0.23386738f, -0.08542230f, 0.08332568f, -0.24860023f, -0.15769377f, 0.07721016f, -0.02137137f, 0.03886998f, 
    -0.04680860f, 0.11108595f, 0.05196996f, -0.06221453f, 0.06118021f, -0.03366077f, 0.05702793f, -0.08048996f, 
    0.01506319f, 0.17996456f, 0.16486213f, 0.11715721f, 0.16323499f, 0.13531832f, 0.18367387f, -0.09754226f, 
    -0.10009872f, 0.07668304f, -0.01834720f, -0.03100386f, 0.06775783f, 0.13945089f, 0.02128778f, 0.36013135f, 
    0.05274799f, -0.24401829f, -0.00800859f, -0.09462000f, 0.09694292f, -0.15085216f, 0.29238075f, 0.01542853f, 
    0.13267080f, 0.23217790f, 0.06894646f, 0.22947252f, 0.03916290f, -0.11896721f, -0.14084192f, -0.06222386f, 
    -0.16553196f, 0.07215022f, -0.21266395f, 0.05131736f, -0.06837441f, 0.06024658f, 0.23652682f, 0.17603986f, 
    -0.01238684f, 0.13268712f, -0.09346893f, 0.08085164f, 0.10461192f, 0.03317562f, 0.28549764f, -0.17270745f, 
    -0.19951719f, 0.07980001f, -0.16375858f, 0.07063989f, -0.13442746f, 0.10659925f, -0.09852627f, -0.01425509f, 
    0.09184142f, 0.06337997f, 0.33360690f, -0.34150365f, 0.24409463f, -0.20279995f, -0.22664571f, 0.01942932f, 
    -0.11380694f, 0.03783911f, -0.00561223f, 0.09753907f, 0.03014837f, -0.20654403f, 0.04972273f, 0.02205865f, 
    -0.19448362f, 0.24244237f, 0.00645937f, -0.25770161f, -0.00517124f, 0.21916460f, 0.02256179f, 0.20127271f, 
    -0.03058166f, -0.18408747f, 0.19288020f, 0.07879544f, -0.05530042f, 0.19514368f, 0.19207829f, -0.06660590f, 
    -0.08362790f, 0.14547105f, 0.22980581f, 0.07987341f, 0.31746078f, 0.12173323f, -0.08088510f, 0.15432072f, 
    -0.24695104f, -0.04947555f, -0.01052276f, -0.14550164f, 0.10380253f, 0.08880369f, -0.05670451f, 0.13678063f, 
    0.13804612f, 0.03844616f, 0.05439506f, -0.04534849f, 0.04532284f, -0.04484137f, -0.02135696f, 0.00298604f, 
    0.02289227f, 0.09750189f, -0.09640352f, -0.14863271f, 0.06630884f, -0.00427356f, 0.04050097f, 0.08165844f, 
    -0.01406265f, -0.02141769f, -0.06594583f, 0.05520117f, 0.02053715f, 0.25861681f, -0.13297318f, 0.03700668f, 
    -0.06985887f, -0.12524474f, -0.24796452f, 0.06456356f, 0.01364983f, -0.13038488f, 0.15221970f, -0.10621537f, 
    0.00562374f, 0.05439078f, -0.03289870f, -0.09822752f, 0.11228831f, 0.01722112f, 0.10334555f, 0.07015690f, 
    -0.19569080f, 0.01304386f, -0.00113962f, 0.16764985f, -0.02832406f, 0.14184321f, 0.18349500f, -0.02469375f, 
    0.24565721f, -0.06406698f, 0.22554050f, 0.29528907f, -0.16290058f, 0.04944262f, -0.13783510f, -0.35902891f, 
    0.20433663f, -0.11291221f, 0.00265581f, -0.03419651f, -0.05250871f, 0.11165179f, 0.06891633f, -0.13129170f, 
    0.08578348f, -0.10944879f, -0.17480156f, 0.06143693f, 0.02003207f, -0.03761774f, -0.00539918f, 0.35766423f, 
    0.19145927f, 0.05142220f, -0.13571715f, -0.22739884f, -0.09681803f, -0.01116976f, 0.08526237f, 0.11879352f, 
    0.10745998f, 0.11231795f, -0.05814278f, -0.04719213f, 0.19426769f, 0.17962268f, 0.10805219f, 0.04033083f, 
    -0.05839432f, -0.26778695f, 0.24077219f, -0.22528765f, 0.13809755f, -0.13934128f, 0.13345823f, 0.01757697f, 
    -0.07303970f, 0.30838105f, 0.16829555f, 0.08927365f, -0.06372336f, 0.00043598f, 0.11732315f, 0.23032801f, 
    0.21548259f, -0.03646880f, -0.05623604f, 0.24661280f, -0.12217142f, 0.04949116f, 0.10374441f, -0.13983820f, 
    -0.01719843f, 0.22547528f, 0.26334277f, 0.00037417f, -0.03079529f, 0.00248602f, -0.24394062f, -0.01463190f, 
    0.39162716f, 0.02516666f, -0.21188848f, 0.25206673f, 0.18393725f, 0.02728466f, -0.13459665f, -0.00701778f, 
    0.05687537f, 0.07186040f, 0.08066302f, -0.03179468f, -0.07096992f, 0.13078587f, -0.13067321f, -0.07636154f, 
    -0.11568880f, -0.06171993f, 0.12266469f, -0.04204823f, -0.07982195f, 0.08846673f, 0.06745613f, 0.19923146f, 
    0.13293426f, 0.12909362f, -0.10997126f, 0.04516281f, -0.16951105f, -0.09213106f, -0.06239488f, 0.11730900f, 
    0.01215286f, 0.06373336f, 0.13422880f, 0.18010326f, 0.06243492f, -0.17133455f, -0.15442158f, -0.01554711f, 
    0.22615325f, -0.12314038f, -0.14529204f, 0.03831042f, -0.06771664f, -0.06073989f, -0.04308556f, 0.21901157f, 
    0.00233738f, -0.17286611f, 0.41304734f, -0.10867970f, 0.07613394f, -0.03832967f, 0.11326528f, 0.05378220f, 
    0.21311148f, -0.20242421f, 0.00717074f, 0.39419204f, -0.25399041f, -0.02054288f, -0.24477866f, -0.24490531f, 
    0.03391154f, -0.07122498f, 0.09266100f, -0.18222620f, 0.00858000f, -0.13953684f, 0.20716698f, 0.36845791f, 
    0.18230444f, -0.08499260f, -0.34407121f, 0.13985363f, -0.07359245f, 0.01576271f, -0.20487574f, 0.27498928f, 
    0.11713352f, 0.04505577f, 0.12592517f, 0.00511307f, -0.06842146f, -0.11524764f, 0.04306813f, 0.21929242f, 
    0.12698832f, 0.16308516f, 0.22091348f, -0.13404918f, 0.18094465f, 0.15433984f, 0.05383270f, -0.03045207f, 
    0.02544904f, -0.17109641f, -0.12576133f, -0.09126417f, -0.06954299f, -0.08103865f, 0.27393472f, 0.02329654f, 
    -0.04474528f, -0.02722320f, -0.22262773f, 0.17474349f, -0.06450197f, -0.06815226f, -0.03565495f, 0.02754103f, 
    0.08596874f, -0.04156051f, -0.28653693f, -0.06010890f, -0.19227113f, 0.27323049f, -0.13778128f, -0.11700822f, 
    0.03829176f, -0.23582897f, -0.07984191f, 0.04753236f, -0.30465004f, 0.00083677f, 0.11222295f, -0.14074396f, 
    0.13938971f, -0.06022860f, 0.08286705f, 0.24225931f, 0.08874644f, -0.16668472f, -0.05403027f, 0.25749782f, 
    -0.02123372f, -0.08767637f, -0.12749955f, 0.25709769f, -0.09024169f, 0.22999245f, 0.07350342f, 0.08621504f, 
    -0.06686294f, -0.11583281f, 0.13649839f, 0.21849883f, 0.21603152f, -0.12049884f, 0.09462398f, 0.01981863f, 
    0.05337314f, -0.01044852f, 0.38719088f, -0.13774088f, 0.23121099f, -0.08812146f, 0.20665282f, -0.03290177f, 
    -0.09527550f, -0.19032626f, -0.10695508f, 0.08669012f, 0.20582351f, 0.13243496f, 0.09949037f, 0.11562171f, 
    0.03588178f, 0.13661318f, 0.15497217f, 0.02126695f, 0.11913814f, -0.31228665f, 0.04587087f, 0.16295435f, 
    0.04340563f, 0.16774397f, -0.07503071f, -0.27461612f, -0.00304461f, 0.20138954f, -0.12111602f, -0.00364834f, 
    -0.06534849f, -0.11800635f, 0.08119690f, -0.09559976f, -0.19508603f, 0.02917982f, 0.23338211f, -0.13899681f, 
    0.14200476f, 0.04596755f, 0.05451572f, 0.02062457f, 0.04691370f, -0.26048595f, -0.15476137f, 0.20197338f, 
    0.01393646f, 0.01585340f, -0.14719728f, 0.07066832f, 0.09938520f, 0.02344270f, 0.09195473f, -0.10196409f, 
    0.10633973f, 0.05633134f, 0.17006034f, -0.12915574f, 0.07356167f, 0.00933933f, -0.02839780f, 0.06193189f, 
    -0.21892966f, -0.01695894f, 0.10931662f, 0.08327156f, -0.15460984f, 0.15157032f, 0.31006134f, -0.11685258f, 
    -0.00566674f, -0.02940378f, 0.02924587f, 0.13905761f, -0.04519718f, 0.12019730f, 0.05319970f, 0.07887979f, 
    -0.05044524f, 0.08251168f, -0.15868197f, 0.14878175f, -0.11777771f, -0.00131168f, -0.08936453f, -0.24653968f, 
    0.24648601f, -0.07797978f, 0.03716079f, -0.35707423f, -0.11804310f, -0.16625489f, -0.03306870f, 0.26144469f, 
    -0.04036218f, -0.22468008f, -0.02298152f, -0.02638306f, -0.24485311f, 0.03858636f, 0.19455297f, -0.11913957f, 
    0.24712299f, 0.06827840f, 0.17382801f, -0.28381446f, 0.14618216f, -0.08169106f, -0.03058943f, 0.33097047f, 
    -0.06342604f, 0.05309264f, -0.15430112f, -0.13355926f, -0.03243544f, 0.13651092f, -0.18971482f, 0.28757864f, 
    0.04488215f, 0.04684382f, 0.10142644f, 0.13497116f, 0.15246962f, 0.04433534f, -0.00583238f, 0.03663230f, 
    -0.04451220f, -0.05108394f, 0.04797426f, 0.06040950f, 0.03804920f, -0.02160643f, 0.11360354f, 0.06699226f, 
    -0.08348686f, 0.12639377f, -0.14994769f, 0.07159805f, -0.11269302f, 0.02264909f, 0.37794447f, 0.08154427f, 
    -0.10594682f, 0.05297113f, -0.11829168f, 0.10162588f, 0.04126263f, 0.02597412f, -0.10972579f, 0.05901809f, 
    0.18175013f, -0.06228346f, 0.23333326f, 0.04638410f, -0.11415557f, 0.01997504f, 0.02598605f, -0.04581559f, 
    -0.03399555f, -0.25833562f, 0.24844255f, 0.12925540f, -0.30664060f, -0.07907787f, -0.03571127f, -0.05910252f, 
    0.10958923f, -0.08322772f, 0.17370901f, 0.05885690f, 0.26385278f, 0.00518382f, -0.01697524f, 0.26370597f, 
    -0.03332396f, 0.07914320f, -0.10202909f, -0.06355593f, -0.09239910f, -0.22716929f, 0.09012397f, 0.14758368f, 
    0.14690541f, 0.08777057f, 0.19389172f, -0.04847730f, 0.17754681f, -0.05522238f, -0.01040666f, 0.14524721f, 
    0.18367204f, -0.02608173f, -0.26720130f, 0.07054830f, -0.00529097f, 0.30351993f, 0.31289345f, 0.04205006f, 
    0.09991005f, -0.08638708f, -0.07889800f, -0.00502912f, 0.00125027f, 0.06619237f, 0.33089542f, -0.02714841f, 
    -0.12659021f, -0.07685956f, -0.14710233f, -0.04971815f, 0.08431227f, -0.11147194f, -0.07672825f, -0.07147830f, 
    -0.02655531f, -0.04598650f, -0.04473731f, 0.08106616f, -0.08003526f, 0.04151174f, 0.08446328f, -0.07851483f, 
    -0.09644221f, -0.02729881f, 0.06331855f, -0.07468205f, 0.03294854f, -0.09160692f, -0.17605233f, 0.02799893f, 
    0.05212264f, -0.02063731f, 0.06233633f, 0.01037726f, 0.08226010f, -0.03866291f, 0.07755671f, -0.04918090f, 
    0.05018031f, -0.02074310f, -0.12248972f, -0.13250171f, -0.02573354f, -0.08124565f, 0.01939167f, -0.05436956f, 
    -0.04835400f, 0.11733475f, -0.12014517f, -0.05974968f, -0.02756022f, -0.08169001f, 0.11617932f, 0.08107197f, 
    0.07990804f, -0.11496594f, -0.06854805f, 0.00368206f, -0.08290651f, 0.02541266f, -0.09823521f, -0.03669660f, 
    0.06456695f, -0.00442339f, -0.07491900f, 0.00114810f, -0.02015088f, 0.07126047f, -0.12819995f, 0.09963246f, 
    -0.10071748f, -0.09804103f, -0.17982936f, -0.09075277f, -0.04133078f, -0.18342620f, 0.12361602f, -0.11641404f, 
    0.04994703f, -0.13835776f, -0.10188531f, 0.02759411f, 0.08610733f, 0.03323863f, 0.03828610f, -0.00112929f, 
    -0.07797838f, 0.01059591f, 0.01903074f, 0.07570530f, 0.10799006f, -0.09682643f, 0.04727977f, -0.05873318f, 
    -0.12437309f, 0.07686478f, -0.11687064f, -0.03036555f, -0.10052172f, -0.05097500f, -0.14044437f, -0.11346021f, 
    -0.16678847f, 0.00527279f, 0.03322436f, -0.04753494f, -0.06415756f, 0.03164329f, 0.02033312f, -0.07402045f, 
    -0.05748104f, -0.06549183f, 0.04204335f, 0.05234766f, 0.10404464f, 0.07532144f, -0.02274841f, 0.00263029f, 
    -0.06202021f, -0.08186834f, 0.07704660f, -0.06853237f, -0.03484473f, -0.02961520f, -0.12206341f, 0.12279321f, 
    -0.00025532f, -0.01089238f, 0.02308326f, -0.04240019f, 0.00042408f, -0.15321434f, 0.02385158f, 0.07943868f, 
    0.04175153f, 0.04047710f, -0.15754983f, 0.10866920f, -0.03825508f, 0.07430462f, 0.00938460f, -0.02306360f, 
    -0.08944611f, 0.04051324f, -0.11013705f, -0.07015844f, 0.05417096f, 0.03948103f, -0.03454216f, -0.04561607f, 
    -0.09951063f, 0.07369585f, -0.05298183f, -0.04414550f, 0.04602758f, 0.09658822f, -0.12369015f, -0.09107178f, 
    0.07287898f, -0.05311009f, -0.11821117f, -0.10955382f, 0.09503875f, 0.02624621f, -0.09017743f, -0.04566100f, 
    0.04700753f, 0.09607393f, -0.05581817f, -0.03259074f, -0.01488662f, 0.00115923f, -0.11823441f, 0.02484677f, 
    0.10316321f, -0.01319184f, -0.12408607f, -0.08826199f, 0.08290765f, 0.04019426f, 0.03567687f, -0.02262980f, 
    -0.14541109f, -0.08383894f, 0.02884757f, 0.02424737f, -0.04993869f, -0.02565460f, -0.10824435f, -0.05961536f, 
    -0.09125548f, 0.03449887f, 0.00513375f, -0.07419330f, -0.10759017f, 0.00282170f, -0.09823698f, 0.12143592f, 
    -0.26543441f, 0.11062899f, -0.06122416f, -0.00141620f, -0.12189835f, 0.15039176f, 0.05172072f, 0.27124310f, 
    0.21158776f, -0.26707909f, 0.02834040f, 0.10009955f, 0.00052332f, 0.09982260f, -0.31412715f, -0.04508239f, 
    -0.12885924f, 0.18206370f, 0.14589079f, 0.11211012f, 0.01971238f, -0.06944954f, -0.22462934f, 0.21857509f, 
    0.02955692f, 0.06924564f, -0.12363598f, 0.20960526f, 0.22466776f, -0.15487501f, -0.11207137f, 0.11563192f, 
    -0.02520384f, -0.07620526f, 0.22544931f, 0.04775257f, -0.04495913f, -0.11022075f, -0.02217788f, -0.19945848f, 
    0.12424764f, -0.05250205f, 0.11550481f, 0.17067248f, 0.26366472f, -0.04645454f, 0.01311816f, 0.16680188f, 
    0.05670682f, -0.14865181f, -0.05451272f, 0.04201428f, 0.05891071f, 0.17585869f, -0.00686998f, 0.05781472f, 
    -0.04972913f, -0.04659030f, -0.13059263f, 0.09758260f, 0.03026920f, 0.11194595f, 0.06967680f, -0.06733453f, 
    0.06462710f, -0.09153424f, -0.05140089f, -0.02397207f, -0.09281022f, -0.06734867f, -0.06469239f, 0.05044927f, 
    -0.09979644f, -0.11469321f, 0.13655263f, -0.07178251f, -0.17152841f, 0.06692118f, -0.02201001f, -0.18025775f, 
    0.08832379f, 0.05845825f, 0.13121217f, 0.12120546f, -0.11602435f, -0.07927252f, -0.06847977f, -0.02718329f, 
    0.06624773f, -0.09660503f, -0.03031725f, -0.10375427f, 0.12961549f, -0.00545077f, -0.12082499f, -0.03725074f, 
    -0.05246509f, -0.09221835f, -0.12881705f, -0.06302514f, -0.00319356f, -0.10481037f, 0.07039333f, -0.15836370f, 
    0.04534497f, -0.04218560f, -0.06776250f, 0.00247567f, -0.17323592f, 0.07333559f, 0.02619472f, 0.10945275f, 
    0.04200154f, 0.03938031f, -0.07215092f, 0.05748414f, -0.01360409f, 0.08291704f, -0.07207643f, 0.04716286f, 
    -0.10280923f, -0.02284907f, 0.04767395f, -0.14644150f, -0.04030638f, -0.02794825f, 0.12828979f, 0.02000686f, 
    -0.05233008f, -0.11208845f, 0.18878777f, 0.06484232f, -0.03972665f, -0.15410234f, -0.02511275f, -0.27842394f, 
    0.10378847f, -0.08659550f, -0.06127780f, 0.07350028f, 0.01722312f, 0.16337770f, -0.25511453f, 0.15901521f, 
    0.18124767f, -0.08591507f, 0.04193253f, 0.00878630f, -0.12907968f, -0.07237495f, 0.37940222f, -0.17369083f, 
    0.14808552f, -0.10323876f, 0.22604807f, 0.05265599f, 0.14739670f, 0.05850058f, 0.13898793f, 0.07202431f, 
    0.15322356f, -0.02124358f, -0.18736017f, 0.12471551f, -0.06134902f, 0.10445512f, -0.20646109f, -0.10835019f, 
    0.15888612f, -0.08700009f, 0.09607554f, -0.04139286f, 0.03492980f, 0.03978725f, 0.04530641f, -0.05171197f, 
    -0.19122179f, 0.00202003f, -0.05870000f, 0.08363352f, -0.26033041f, -0.09384314f, 0.25780874f, -0.05864906f, 
    0.10791157f, 0.14290693f, 0.15618117f, -0.04666226f, 0.34322193f, 0.10331963f, 0.00348016f, 0.07731222f, 
    -0.09646629f, -0.19264489f, 0.11399698f, 0.17418271f, -0.00773232f, 0.09660129f, -0.07686007f, -0.12685005f, 
    0.06332518f, -0.17596911f, 0.04994297f, 0.07791329f, 0.19120461f, 0.06895970f, -0.41732568f, -0.06807087f, 
    0.10458820f, 0.16752052f, 0.12811629f, 0.17865500f, 0.02071865f, -0.02008518f, 0.25587934f, 0.21529314f, 
    -0.16264021f, -0.07700976f, 0.07715105f, 0.01560426f, 0.06856205f, -0.14458266f, 0.05324985f, -0.20894994f, 
    0.11759311f, -0.05249783f, 0.03334390f, -0.17495766f, 0.09449722f, -0.09500513f, -0.09910107f, 0.18483698f, 
    0.25662890f, 0.05362839f, -0.01862083f, -0.14294912f, 0.25312340f, -0.00668608f, 0.06119060f, 0.03486039f, 
    -0.12429678f, -0.15341225f, -0.29445270f, 0.35382751f, -0.22015060f, 0.19822092f, 0.15065822f, 0.05426328f, 
    0.06103786f, 0.05037868f, -0.03070869f, 0.05124088f, 0.35507318f, 0.16099502f, 0.12567967f, -0.09481818f, 
    -0.10070278f, -0.04087614f, -0.08493134f, -0.10966837f, -0.12107792f, -0.12499741f, -0.02700962f, -0.07689719f, 
    -0.09686019f, -0.04220142f, 0.12006707f, -0.10077564f, 0.00342780f, 0.06331204f, -0.02240364f, 0.05997389f, 
    -0.10089541f, -0.06380731f, 0.10900187f, -0.08979498f, -0.00381762f, -0.05561462f, -0.11402154f, -0.00186847f, 
    -0.07812267f, 0.11436474f, -0.01313602f, -0.07355578f, -0.10129248f, 0.06225671f, -0.06226417f, -0.02100101f, 
    0.04030384f, 0.02430307f, 0.07487320f, -0.00609260f, 0.03706622f, 0.02269379f, -0.08630975f, -0.06899132f, 
    0.12922993f, -0.07867870f, -0.11819427f, -0.08114409f, 0.01005795f, -0.01705226f, -0.02949511f, -0.06521659f, 
    -0.08684051f, -0.06435984f, -0.08087287f, -0.07402816f, 0.04436198f, -0.05807804f, 0.09834972f, 0.07059203f, 
    0.12254629f, -0.00348087f, -0.07346937f, -0.00226802f, 0.07495546f, -0.05777768f, -0.03850474f, -0.08637138f, 
    0.12591469f, -0.18347278f, -0.07957191f, 0.24265374f, -0.02112208f, -0.11142484f, -0.06057367f, -0.22096862f, 
    -0.00723451f, -0.03441887f, -0.05383234f, 0.06152336f, 0.10370294f, 0.07336722f, -0.39507622f, -0.01366119f, 
    0.12928626f, -0.21894111f, -0.14240713f, 0.24175960f, -0.14463674f, 0.06028070f, 0.24842559f, -0.07450898f, 
    -0.07114524f, -0.09531024f, 0.21098427f, 0.09899768f, -0.04429423f, -0.16584799f, 0.08799442f, 0.04466255f, 
    0.17868905f, -0.07686846f, -0.21270320f, -0.03359772f, -0.09978592f, -0.15745240f, -0.20706791f, 0.11976970f, 
    0.14052770f, -0.07661584f, 0.11358613f, -0.23711085f, 0.24440517f, 0.09684850f, -0.11160935f, 0.00201954f, 
    -0.00729505f, 0.13318223f, -0.17458521f, 0.11317281f, -0.15097985f, 0.05839607f, 0.31315386f, -0.08315831f, 
    -0.03769461f, 0.10806307f, 0.07765338f, -0.01136202f, 0.26750305f, 0.20944926f, 0.15496710f, 0.11113822f, 
    -0.11566965f, -0.13508977f, -0.07048967f, 0.06026848f, -0.06018509f, -0.02723502f, -0.00217357f, -0.05944414f, 
    -0.10129136f, -0.14143342f, -0.01973034f, 0.08124778f, 0.07955626f, 0.00392212f, -0.06409225f, -0.13521765f, 
    -0.07734956f, 0.03627097f, -0.06494505f, -0.01674627f, 0.01433996f, 0.01307893f, -0.04829393f, 0.04245356f, 
    0.02632613f, -0.01640718f, -0.08331749f, -0.11629415f, 0.07454719f, -0.06497916f, -0.08869350f, 0.04552665f, 
    -0.06988939f, -0.11907572f, -0.05724222f, 0.02316627f, -0.04180437f, 0.01626012f, 0.04933683f, 0.00202372f, 
    -0.08749700f, -0.03213882f, 0.03379938f, 0.03397707f, -0.08517701f, 0.09259133f, 0.09239406f, -0.03825985f, 
    0.08529490f, -0.01113102f, 0.09393314f, -0.03624216f, -0.07610651f, 0.10590236f, -0.00632727f, -0.02650866f, 
    -0.00938726f, 0.06444266f, -0.03210389f, 0.07776696f, -0.04957908f, -0.07703883f, -0.03653567f, -0.01590885f, 
    -0.02587963f, 0.01590013f, -0.33823332f, 0.01947546f, 0.09850617f, -0.07395264f, 0.04284129f, 0.14352706f, 
    -0.01802453f, 0.08817123f, -0.23234949f, -0.26672298f, -0.09032118f, 0.23217043f, 0.04402347f, 0.21001866f, 
    -0.40153071f, -0.22189415f, -0.25733086f, -0.06497500f, 0.17247091f, -0.05352983f, 0.25619406f, 0.07795078f, 
    -0.20099683f, 0.03713563f, 0.21328200f, -0.02470240f, 0.12558582f, -0.27087313f, 0.04127692f, 0.05643672f, 
    0.23324041f, 0.09040681f, -0.34603611f, 0.18218791f, -0.10151685f, 0.32488400f, 0.11449356f, -0.10934989f, 
    -0.11518130f, -0.01319407f, -0.01737289f, 0.20545335f, 0.11214355f, 0.06169330f, -0.00689905f, 0.16177356f, 
    -0.22244446f, 0.13899453f, 0.32840008f, 0.03324910f, 0.02896553f, 0.30291536f, 0.11355787f, -0.10647953f, 
    0.07375868f, -0.02389700f, -0.21116291f, 0.19876607f, -0.17876016f, 0.01123062f, 0.06879907f, 0.06998953f, 
    -0.00570619f, 0.04778765f, -0.02615178f, -0.06050620f, -0.02896789f, -0.03951149f, 0.07382676f, -0.19448480f, 
    -0.13263218f, -0.14705153f, 0.12209806f, -0.07942815f, 0.10201754f, -0.05101434f, 0.14247467f, -0.10434133f, 
    0.00498668f, 0.05325314f, 0.12527610f, 0.02906889f, -0.08213808f, 0.00596465f, -0.12394532f, 0.06270778f, 
    0.00475441f, 0.01009835f, -0.01680571f, -0.10927691f, -0.09959914f, -0.05546128f, -0.05218030f, 0.04318654f, 
    -0.05280934f, 0.12413747f, -0.08646745f, -0.07124641f, 0.06971209f, -0.02119152f, -0.02724382f, 0.00481583f, 
    0.04315345f, -0.08986890f, 0.03104533f, -0.17066851f, 0.08249319f, -0.10835315f, -0.03567800f, -0.10549482f, 
    -0.01108731f, -0.06905015f, -0.04638368f, 0.08369864f, -0.01740182f, 0.24122134f, -0.12060622f, -0.05287994f, 
    0.05957993f, -0.03893135f, 0.02623513f, -0.21293871f, 0.04671526f, 0.01555422f, 0.04763249f, 0.09691099f, 
    0.15101157f, -0.01666584f, -0.21934441f, 0.16314253f, 0.04860372f, 0.23644480f, 0.07500088f, 0.41540611f, 
    -0.02061977f, -0.35470343f, -0.17754823f, 0.06883791f, 0.19451585f, 0.14328520f, -0.04468354f, -0.21010707f, 
    0.10770619f, -0.10483523f, -0.17139645f, 0.38399106f, 0.31986848f, -0.09318716f, -0.18811029f, 0.27283990f, 
    -0.09889560f, 0.01161806f, 0.22984359f, -0.04065362f, 0.09100260f, -0.26213744f, 0.20075263f, 0.29765829f, 
    0.06890909f, 0.10969137f, 0.06512094f, 0.15497123f, 0.09226993f, 0.08056295f, -0.01576698f, 0.04984747f, 
    0.05217990f, -0.02622043f, -0.05571674f, -0.21163464f, 0.12354553f, -0.06621975f, -0.08786655f, 0.09357417f, 
    0.18315946f, -0.09537157f, 0.21534324f, -0.07761774f, 0.25005132f, -0.02940368f, 0.02319083f, 0.10883805f, 
    -0.02475271f, 0.02987576f, -0.05550211f, 0.19614615f, -0.32921156f, -0.04317430f, -0.01735228f, 0.06329717f, 
    -0.02287324f, 0.04895883f, 0.00370202f, 0.13752908f, -0.06779790f, 0.17501408f, -0.11632531f, -0.07112062f, 
    0.05118503f, 0.08733178f, -0.15663838f, -0.10378832f, -0.08282334f, 0.20590688f, -0.26450831f, -0.09908652f, 
    -0.32444960f, 0.00989141f, -0.14449894f, -0.21060522f, 0.10092414f, -0.05777355f, 0.15862009f, 0.08433020f, 
    -0.07821071f, -0.10460358f, 0.30154765f, -0.05707228f, 0.09449551f, -0.16244009f, -0.33745784f, -0.00470811f, 
    -0.11766443f, 0.05142984f, 0.01269097f, -0.23159948f, 0.06168294f, 0.04540986f, 0.11594983f, 0.12425090f, 
    0.08483353f, -0.10980093f, 0.02216197f, 0.09956779f, 0.15288638f, 0.00093586f, 0.09147490f, -0.03105169f, 
    -0.00417122f, 0.05335619f, -0.21964398f, 0.34636492f, -0.14165290f, -0.12925513f, 0.09402851f, 0.04854130f, 
    -0.04956665f, -0.05850571f, -0.06994566f, 0.19470933f, -0.20487696f, 0.13621517f, -0.21587005f, 0.10091852f, 
    -0.03579777f, 0.07729479f, 0.14660408f, 0.11677005f, -0.02939602f, -0.09526812f, 0.06135523f, 0.04720630f, 
    -0.09342144f, 0.01578092f, -0.32190704f, 0.15967590f, -0.01265600f, 0.26238731f, -0.39745873f, -0.20222206f, 
    -0.30859846f, 0.10542573f, 0.04933720f, 0.09240180f, 0.11885679f, 0.00941940f, 0.15419744f, 0.32192749f, 
    -0.15276805f, -0.01615642f, 0.11536820f, -0.03759487f, 0.17830311f, -0.20329683f, -0.13910678f, -0.23570094f, 
    0.13906649f, 0.04405168f, 0.13275003f, 0.05428939f, 0.00398249f, -0.06342959f, -0.00800199f, -0.36750922f, 
    0.05290464f, 0.10899380f, 0.12502445f, -0.07997319f, 0.30761111f, 0.10737994f, -0.09416200f, 0.03142937f, 
    -0.19746481f, 0.10407601f, -0.17297201f, 0.19972473f, -0.15011424f, -0.17809276f, 0.24444997f, -0.07516468f, 
    -0.05479882f, -0.03142683f, -0.10571306f, 0.22935060f, 0.02934202f, 0.14828891f, -0.14112943f, -0.03467593f, 
    0.14949144f, 0.14640291f, 0.11677986f, 0.11208653f, -0.11623316f, 0.05936125f, -0.01896299f, -0.61825317f, 
    -0.16982885f, -0.03210494f, 0.00949730f, -0.27212498f, 0.10176983f, -0.12119071f, 0.01729529f, -0.02406679f, 
    -0.02550435f, 0.26759914f, -0.32255179f, -0.22937836f, 0.10936964f, -0.11001645f, 0.02180907f, 0.02818412f, 
    0.20398721f, -0.10684437f, 0.17940275f, 0.26309291f, -0.33783585f, 0.11007179f, 0.05755528f, -0.22821058f, 
    -0.04598558f, -0.00079829f, 0.05377225f, -0.32778719f, 0.11954138f, -0.08962628f, -0.23477231f, 0.22652714f, 
    0.06934253f, 0.10306095f, -0.27553236f, -0.03293653f, -0.32240823f, -0.02396828f, 0.10458723f, -0.46222427f, 
    -0.37322980f, 0.08997874f, -0.00585651f, -0.13731007f, -0.18117037f, -0.36725980f, -0.27906427f, 0.00254525f, 
    -0.09566294f, 0.11806103f, 0.08621354f, 0.09013274f, 0.00267144f, 0.07936381f, 0.02413850f, 0.01441136f, 
    0.10387440f, -0.10385682f, 0.02934626f, -0.09980728f, 0.06999132f, -0.14798489f, 0.08752298f, 0.02214803f, 
    0.06892805f, 0.06900235f, 0.04878044f, -0.16568069f, -0.00825288f, 0.04509687f, -0.04084270f, 0.06685295f, 
    0.09003159f, -0.09586201f, 0.06352542f, -0.00420457f, 0.02390434f, -0.06905349f, -0.02017222f, -0.15584220f, 
    0.03256961f, 0.05198477f, 0.06890685f, -0.12144878f, -0.08643161f, -0.12868175f, -0.11812960f, -0.11707044f, 
    -0.16196291f, -0.09118310f, 0.04394927f, 0.03674204f, 0.10574365f, -0.04667687f, 0.11997098f, -0.06431078f, 
    0.04778327f, -0.06594741f, 0.01657989f, 0.05029986f, -0.04800816f, 0.07750951f, 0.11521801f, -0.07854806f, 
    -0.09846882f, -0.12023934f, 0.08867580f, 0.02769872f, 0.01514192f, -0.02307884f, 0.07329196f, 0.03282727f, 
    -0.10508389f, 0.07895088f, -0.14722565f, 0.14749385f, 0.06452461f, -0.19579610f, -0.11364317f, 0.00898834f, 
    0.18951012f, 0.13043894f, 0.15961838f, 0.18378085f, 0.07698794f, 0.26432300f, -0.04961087f, -0.11276340f, 
    -0.02209810f, 0.00057778f, 0.16137306f, 0.19584587f, 0.23436998f, -0.25449991f, 0.03332977f, 0.05267921f, 
    -0.02595444f, 0.37033227f, -0.07520312f, 0.24297141f, 0.30754659f, -0.01797149f, -0.18643762f, 0.32211643f, 
    -0.10773572f, 0.01789461f, 0.00540127f, -0.04609034f, -0.16327134f, 0.15528750f, 0.09477691f, -0.10331809f, 
    -0.01231439f, -0.06134294f, 0.26069275f, -0.06199570f, 0.09901609f, 0.04496357f, -0.11764108f, 0.08165127f, 
    -0.07146120f, -0.01939031f, 0.07469665f, -0.09710144f, 0.19261786f, -0.09251649f, -0.10824186f, -0.05366102f, 
    0.11579638f, -0.14300804f, -0.35093114f, -0.08266937f, 0.04444023f, -0.00940760f, -0.15862338f, 0.06346300f, 
    -0.01431392f, 0.08232470f, 0.07617462f, -0.08332448f, -0.06347024f, -0.08163842f, -0.10212522f, -0.05949043f, 
    0.10045240f, 0.19378471f, -0.05232864f, -0.06647709f, -0.06721383f, 0.33077863f, -0.02112284f, 0.24497627f, 
    0.22431616f, -0.05545721f, 0.11591638f, -0.04386114f, -0.03832794f, 0.04104469f, 0.23799747f, -0.13280961f, 
    -0.21149951f, 0.18743397f, 0.15333858f, -0.12440632f, 0.14391820f, -0.05888790f, -0.18725339f, 0.04537902f, 
    -0.02796531f, 0.04263914f, -0.01632810f, 0.06345937f, 0.10352979f, 0.05740887f, 0.00469148f, 0.04610234f, 
    -0.12248476f, 0.06727240f, 0.07766249f, -0.07003715f, -0.05340443f, 0.11016166f, 0.12889788f, -0.00385144f, 
    -0.08399012f, 0.06679934f, -0.06566764f, 0.08692759f, 0.15386240f, 0.03362486f, 0.01130889f, -0.01379757f, 
    0.06630000f, 0.13401477f, -0.03290189f, 0.11977465f, 0.07195606f, -0.22049533f, 0.00122130f, -0.04374510f, 
    -0.05074653f, 0.05898177f, -0.31335434f, -0.04302455f, -0.27245891f, -0.15645212f, -0.10615259f, 0.12023760f, 
    -0.04300316f, 0.14224246f, 0.07694187f, -0.02660314f, 0.09938167f, 0.10223705f, -0.10834228f, 0.00714445f, 
    0.19008683f, 0.00816664f, 0.39483565f, -0.05643506f, -0.19955991f, 0.17019978f, -0.10559784f, -0.12802280f, 
    -0.05017385f, 0.16246872f, 0.01852630f, -0.16234511f, -0.44281423f, 0.07412930f, -0.07787051f, -0.17420435f, 
    0.18930043f, -0.06971373f, -0.06543355f, 0.18251660f, 0.25704417f, -0.10103754f, -0.48859525f, -0.00612356f, 
    -0.00513648f, -0.05399210f, 0.03698790f, -0.09809924f, 0.07864689f, 0.05258607f, -0.00912954f, 0.14997850f, 
    -0.21708800f, -0.09289526f, -0.02784268f, 0.00772228f, -0.08264273f, -0.04217606f, -0.09719440f, 0.22901189f, 
    -0.14252415f, 0.08081459f, -0.22514163f, 0.16507620f, -0.27792215f, 0.36454231f, 0.08103473f, 0.05866270f, 
    0.01168447f, -0.14999622f, -0.08684853f, 0.22209391f, -0.10092404f, -0.04997981f, 0.05084861f, 0.01151495f, 
    0.05626799f, 0.27063030f, 0.19920877f, -0.01974490f, 0.09545691f, 0.01491947f, 0.01158459f, 0.27802721f, 
    -0.16961955f, 0.06996408f, -0.27084142f, 0.06661136f, 0.11714453f, 0.14113173f, -0.07536647f, -0.33239675f, 
    -0.18534830f, 0.17368539f, 0.01401832f, 0.15886560f, 0.09690893f, -0.05419869f, -0.13349400f, 0.22062415f, 
    0.08978267f, 0.07863153f, 0.08523539f, 0.00082425f, -0.01049617f, 0.05560465f, -0.06193684f, -0.14711314f, 
    0.18164715f, 0.03408529f, -0.13776843f, -0.16194458f, 0.00962284f, -0.01565335f, 0.20601013f, -0.22129288f, 
    0.11973924f, 0.12159975f, 0.12499317f, -0.15935132f, 0.15580910f, 0.06816255f, 0.02562790f, 0.00691081f, 
    0.13664512f, 0.03288225f, -0.15921050f, 0.22774680f, -0.11303044f, -0.25687045f, 0.22365183f, 0.08118032f, 
    -0.01975646f, -0.14054911f, -0.19321986f, 0.18878399f, -0.28590655f, -0.11505493f, -0.26172400f, -0.12109560f, 
    -0.02955426f, -0.12595360f, 0.05226072f, -0.05087258f, 0.07882126f, 0.00536535f, -0.07759151f, -0.02918866f, 
    -0.01073648f, -0.16925834f, 0.07675290f, 0.09619457f, -0.05797600f, -0.03254557f, 0.06700075f, -0.06734388f, 
    -0.12159935f, -0.01661271f, -0.11024038f, -0.04114962f, -0.08172854f, -0.01596884f, 0.09570433f, 0.02316853f, 
    -0.12115180f, 0.08711492f, 0.05104971f, -0.01057447f, -0.12793368f, -0.09450324f, -0.04630645f, -0.03105505f, 
    -0.16709852f, 0.04530885f, 0.03238271f, 0.02598038f, 0.10106132f, -0.00139253f, -0.14941698f, 0.05770477f, 
    -0.05974888f, -0.04221442f, -0.10162382f, -0.13218226f, -0.11670315f, 0.12166404f, 0.05822352f, 0.01947645f, 
    0.07960495f, 0.08837105f, -0.07188407f, 0.06248267f, -0.03686666f, 0.02914463f, -0.05307882f, -0.06704769f, 
    0.05299797f, -0.11574058f, 0.10049480f, -0.00070017f, -0.12878385f, 0.07822740f, -0.07481179f, 0.04905290f, 
    -0.20825948f, -0.14287473f, -0.09773760f, 0.06901963f, 0.00137576f, 0.04999812f, -0.07999378f, 0.00010250f, 
    -0.02098910f, -0.12682918f, 0.09164464f, -0.10657225f, 0.04771196f, 0.05450546f, -0.03184299f, -0.10395180f, 
    -0.12413839f, -0.00385879f, -0.04649666f, 0.02335695f, -0.10000914f, 0.12405564f, -0.17294779f, 0.04810348f, 
    0.01648978f, 0.05115834f, -0.07520624f, 0.02205921f, -0.06678239f, -0.20425709f, 0.01671466f, 0.09518658f, 
    -0.04697177f, -0.07638728f, -0.04271356f, -0.01198039f, -0.03185634f, -0.05116706f, 0.04507448f, -0.06830431f, 
    -0.02259647f, -0.05037535f, -0.06205229f, -0.04266436f, 0.07148160f, -0.09667274f, -0.04071157f, 0.06812429f, 
    -0.10288603f, -0.19615114f, 0.11024248f, -0.18556027f, -0.13950887f, -0.10746534f, -0.11082096f, 0.06948608f, 
    -0.05154578f, -0.11146450f, -0.05201310f, -0.09804513f, -0.06431346f, -0.15692095f, 0.05530644f, 0.01682876f, 
    0.19532403f, -0.10713997f, -0.45325804f, 0.24347746f, -0.10694724f, -0.16775915f, -0.05285104f, 0.12516879f, 
    0.03972460f, 0.01210816f, -0.22044909f, -0.00653618f, -0.11819679f, 0.23618887f, -0.17438479f, -0.04823358f, 
    -0.05972315f, -0.38311750f, -0.13764529f, 0.15942092f, -0.13241799f, 0.05948856f, -0.13918193f, 0.01282402f, 
    -0.08658130f, -0.05465649f, 0.01148313f, -0.12996064f, 0.27167931f, -0.34755298f, 0.15268157f, 0.25520593f, 
    0.10322823f, 0.00434277f, 0.00246562f, 0.30827665f, 0.02805158f, -0.02788118f, -0.29805771f, -0.02321795f, 
    -0.08589858f, -0.02932707f, 0.23168667f, 0.03585275f, 0.26268899f, -0.10511165f, 0.12621838f, 0.31680664f, 
    0.10367459f, 0.20827664f, 0.15754928f, -0.10336188f, 0.17093921f, -0.04340261f, 0.32144591f, 0.05826769f, 
    0.09892574f, -0.07725704f, -0.25325164f, 0.17673503f, -0.26746419f, 0.08192246f, -0.00548104f, -0.01650934f, 
    -0.16442534f, 0.01487667f, 0.11798375f, -0.00856902f, 0.01042439f, 0.28527740f, -0.04682897f, 0.03221127f, 
    -0.06319204f, 0.09234069f, 0.24819048f, -0.06682886f, 0.05144195f, 0.00944394f, 0.03752121f, -0.18832089f, 
    -0.14266501f, 0.33096722f, 0.19432501f, -0.03983489f, -0.19888626f, -0.05953376f, 0.03481332f, -0.03559926f, 
    0.05891510f, 0.07179821f, -0.01012692f, -0.06760206f, -0.04664495f, -0.02823760f, -0.42162716f, -0.20538668f, 
    0.10497792f, 0.07968351f, -0.13264999f, 0.01642495f, 0.08322130f, 0.21559325f, 0.07862052f, 0.16843756f, 
    -0.10758591f, -0.10419984f, 0.05659167f, -0.00597077f, 0.08923791f, -0.12305483f, 0.00429788f, 0.07532761f, 
    -0.03785597f, -0.02336017f, -0.39170668f, 0.29219559f, -0.04400302f, 0.44815588f, -0.06294674f, -0.04454397f, 
    -0.02073626f, -0.25634414f, -0.01899886f, -0.09704948f, 0.04773413f, -0.01179210f, -0.07480153f, -0.06260563f, 
    0.04731729f, -0.12270264f, 0.09192611f, -0.02234145f, 0.11238474f, 0.08771998f, -0.02159440f, -0.09558962f, 
    0.11484514f, -0.10857107f, 0.13720307f, -0.11308522f, -0.20029084f, 0.00287139f, 0.11220170f, -0.02425567f, 
    -0.02089122f, 0.06984741f, -0.15476739f, -0.24864690f, -0.03312367f, -0.03949720f, 0.10770179f, -0.03671840f, 
    -0.00938288f, -0.02958155f, -0.03996915f, -0.07144333f, 0.00789864f, 0.02201548f, -0.13006288f, -0.03922198f, 
    0.02894237f, 0.10908128f, 0.09439784f, 0.13328061f, 0.07296392f, -0.08625887f, -0.07806704f, -0.20409851f, 
    -0.10952070f, -0.05435163f, -0.19011596f, -0.04185466f, -0.00910497f, -0.04379274f, -0.07377525f, 0.04019897f, 
    0.13069390f, -0.05059179f, 0.04717347f, 0.03260578f, -0.01547776f, 0.00627934f, -0.08037731f, 0.02023171f, 
    -0.06775329f, -0.14715046f, 0.07878342f, -0.25520775f, -0.02226583f, -0.18186671f, 0.06197213f, -0.08935563f, 
    0.03162542f, -0.11401191f, -0.01226998f, -0.06117526f, 0.00650783f, 0.05227584f, -0.01494838f, -0.10422037f, 
    -0.13923533f, -0.00944500f, 0.05152687f, -0.13193540f, -0.10160778f, 0.07250425f, 0.01502002f, 0.07847680f, 
    -0.11533865f, -0.04275891f, 0.03174151f, 0.01797650f, -0.02813764f, 0.09736334f, -0.06161794f, -0.11197934f, 
    0.05018019f, -0.10533957f, -0.08088234f, -0.17065908f, -0.09643564f, -0.14950725f, -0.12212548f, 0.05582474f, 
    -0.09403702f, -0.03797422f, 0.02874179f, -0.11197531f, 0.00375322f, 0.02180418f, -0.22493677f, 0.07153735f, 
    0.01602539f, -0.07396969f, 0.07905809f, 0.04630160f, 0.00071546f, 0.11844924f, -0.03479968f, -0.02469661f, 
    0.03878960f, -0.06844451f, -0.02025072f, -0.00497059f, -0.12112604f, -0.01834026f, -0.12874071f, -0.07010944f, 
    -0.09947804f, 0.03279492f, 0.10482378f, -0.09666547f, -0.06315222f, 0.02399352f, -0.06616081f, 0.08736087f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12425270f, -0.03370780f, 0.01919321f, 0.08222532f, 0.06218262f, 0.04779075f, -0.07135536f, -0.04815910f, 
    -0.17415479f, -0.05457390f, 0.04056375f, -0.00006339f, 0.04513706f, 0.19855136f, 0.03275119f, 0.05616631f, 
    0.12079813f, 0.07321645f, 0.11366271f, -0.04131258f, 0.15359350f, -0.01021012f, 0.00341763f, 0.07022009f, 
    0.16680598f, 0.06156917f, 0.14090784f, 0.18224494f, -0.07816875f, 0.01609283f, 0.09385145f, 0.27324376f, 
    0.03129273f, 0.21892181f, 0.04966948f, -0.12274458f, 0.22283787f, -0.03019213f, -0.09689166f, 0.08968306f, 
    0.05925664f, 0.10183597f, 0.14868473f, 0.11700521f, -0.00742896f, 0.21487351f, -0.14581707f, 0.08150292f, 
    -0.09247742f, 0.02703272f, -0.24030814f, -0.02827267f, -0.07531955f, -0.00695069f, -0.10866255f, -0.10015225f, 
    0.24794301f, 0.15559241f, -0.11033995f, -0.09332397f, 0.09265746f, 0.26790237f, 0.03551859f, -0.09787314f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.02124273f, 0.03168999f, 0.14508083f, 0.01565439f, 0.06259971f, 0.14747572f, 0.17914709f, -0.02805934f, 
    0.14024846f, 0.02419455f, 0.04459310f, -0.04331934f, 0.18429603f, -0.20808312f, 0.41379279f, -0.15759405f, 
    0.12518765f, 0.00894369f, 0.06105811f, 0.26374277f, -0.08924131f, -0.04548600f, -0.37023485f, -0.37819684f, 
    0.02341871f, 0.15548553f, -0.26445159f, 0.10570226f, 0.08460563f, -0.32025751f, 0.02709386f, -0.20252161f, 
    -0.22904330f, -0.32233357f, -0.26618877f, -0.01945106f, -0.26803020f, -0.01438886f, -0.06186232f, -0.12512831f, 
    -0.37932938f, -0.11598383f, 0.01799357f, -0.00471367f, -0.09660534f, -0.07023768f, 0.06204322f, -0.21316038f, 
    0.02421399f, -0.09390330f, 0.05847172f, -0.31698513f, 0.44746113f, -0.01560655f, 0.20513581f, -0.07228449f, 
    -0.25662288f, -0.25795025f, -0.03733109f, 0.07312042f, -0.63689470f, -0.78347683f, -0.13017912f, 0.00874642f, 
    -0.08650612f, -0.17180066f, 0.18764074f, 0.25262567f, 0.18108645f, 0.12329523f, -0.59926373f, -0.05814753f, 
    0.24185954f, 0.05969671f, -0.04936816f, 0.04056539f, 0.33146089f, 0.45057428f, -0.00867957f, 0.12084720f, 
    0.00937904f, 0.03632165f, -0.28326923f, 0.05290524f, 0.08701430f, 0.03953330f, 0.00870845f, 0.03766628f, 
    0.01046066f, -0.50580305f, 0.11592177f, 0.11232001f, 0.03021772f, 0.10506587f, 0.19899382f, 0.09798271f, 
    0.17231172f, -0.22485374f, -0.14484294f, -0.00519799f, 0.02811297f, -0.00501807f, -0.06930228f, -0.05508165f, 
    -0.03818608f, -0.00921202f, -0.04410272f, 0.04514127f, 0.06014224f, -0.03358371f, -0.09481303f, -0.46963376f, 
    0.03115313f, -0.30117112f, -0.21392293f, -0.33432764f, -0.53742510f, -0.16120523f, 0.12357441f, -0.08463246f, 
    0.17601259f, -0.05847210f, -0.08919420f, 0.04098324f, -0.16831881f, 0.06310605f, -0.03665572f, -0.09159878f, 
    -0.05987225f, -0.13139012f, -0.69019991f, 0.01103053f, -0.08801147f, -0.23203047f, -0.23381935f, -0.17957850f, 
    -0.41066417f, -0.33983770f, -0.09420845f, -0.00455161f, -0.08494024f, 0.22670187f, -0.34266552f, -0.06687599f, 
    -0.02745203f, -0.01609212f, 0.29110518f, 0.06747755f, 0.09142921f, -0.01201586f, 0.03396569f, -0.15861896f, 
    0.02827017f, 0.25570232f, 0.30069530f, 0.20450827f, 0.10906597f, -0.48856145f, 0.21513118f, 0.05436286f, 
    0.23322552f, 0.18125527f, 0.20619340f, -0.23671019f, -0.10322137f, 0.02823214f, -0.09282885f, 0.10725047f, 
    -0.19543679f, -0.15562280f, 0.23416676f, -0.33400056f, -0.09257062f, 0.11721884f, 0.01954959f, 0.03003751f, 
    -0.07153055f, 0.14460948f, -0.23844901f, -0.14809649f, -0.31592807f, 0.10881121f, -0.14005402f, -0.27845183f, 
    -0.40521079f, 0.08448201f, -0.09758497f, -0.23147525f, 0.23241991f, -0.25782585f, -0.02512219f, 0.03740570f, 
    0.04319721f, 0.22705282f, 0.09453339f, -0.14780226f, 0.00660256f, -0.23137572f, 0.12883040f, -0.12812234f, 
    -0.02382887f, -0.14786838f, 0.16052841f, -0.19867951f, 0.10148438f, -0.14297120f, -0.14558011f, -0.29455280f, 
    0.14846034f, -0.03397033f, 0.07995739f, -0.14427464f, 0.03814352f, -0.02956956f, 0.18973739f, -0.25039437f, 
    -0.49279711f, 0.22557712f, 0.04193237f, 0.08872093f, -0.14448069f, -0.23488539f, -0.30378091f, -0.26737660f, 
    -0.09226564f, 0.00584486f, 0.15753889f, 0.16505651f, -0.06465966f, 0.01090510f, -0.04481621f, 0.00277824f, 
    -0.23639634f, 0.08899222f, 0.22452103f, 0.03885090f, -0.05373049f, 0.12670428f, 0.06688809f, 0.25608397f, 
    -0.10318866f, -0.16203755f, 0.11257031f, 0.05943752f, -0.13808452f, -0.04982299f, -0.17374367f, -0.28877729f, 
    -0.49063993f, -0.17974769f, 0.05120046f, 0.05795310f, 0.05393127f, -0.56283760f, 0.03460624f, -0.10655523f, 
    -0.04021602f, -0.03766675f, 0.02611361f, -0.02714062f, -0.00183322f, -0.48907682f, 0.11580997f, -0.07058593f, 
    0.22725719f, -0.32272819f, 0.11347646f, 0.04270608f, -0.53622842f, -0.09777704f, -0.29074961f, 0.05488504f, 
    0.14739341f, -0.08097523f, 0.13549209f, 0.05937694f, 0.05062396f, -0.61739254f, -0.37845954f, -0.00923972f, 
    -0.12046020f, 0.03933068f, -0.23899128f, 0.00946580f, 0.10919218f, -0.02901620f, -0.18314911f, 0.00455975f, 
    0.03651960f, -0.12398570f, -0.22901404f, -0.08825746f, -0.10733560f, 0.09819021f, -0.17814144f, -0.00826056f, 
    -0.02498590f, -0.04753895f, -0.50445300f, -0.13966881f, 0.06297825f, -0.08943071f, -0.13405016f, 0.05360430f, 
    -0.13373467f, 0.22050704f, 0.11784261f, 0.03315356f, -0.45535865f, -0.06884818f, 0.15576419f, 0.24733968f, 
    0.06342594f, 0.02285156f, 0.07819477f, 0.01506358f, 0.18064445f, 0.04901630f, 0.04080771f, 0.09979012f, 
    -0.05365602f, -0.04347936f, 0.01294618f, 0.14050280f, 0.13857566f, -0.05625691f, -0.26189426f, 0.29022324f, 
    -0.16743287f, 0.09503292f, 0.13496111f, -0.14637141f, -0.23983611f, -0.25642484f, -0.21009496f, 0.14222455f, 
    0.11082756f, 0.07260398f, -0.04096521f, -0.11895845f, 0.24023530f, -0.24323684f, -0.00968518f, -0.14749575f, 
    -0.26069105f, -0.23019402f, -0.22283830f, 0.12313727f, -0.03518417f, -0.02810347f, -0.17085169f, 0.15837742f, 
    -0.25667056f, -0.13991410f, 0.01767506f, -0.26941365f, 0.01649492f, 0.06113406f, -0.10259662f, 0.06229981f, 
    0.18038179f, -0.07715922f, -0.00191842f, 0.21523774f, -0.13084446f, 0.08263441f, -0.06058691f, -0.60196090f, 
    -0.14629744f, 0.07155435f, -0.07428321f, 0.23390575f, -0.15675120f, -0.12021891f, 0.21294761f, -0.07414474f, 
    -0.03888430f, 0.15211280f, 0.04248790f, -0.00316528f, -0.05019985f, -0.50293958f, -0.06030579f, -0.05268361f, 
    -0.00976813f, -0.48189506f, -0.40906972f, -0.38029885f, -0.33491597f, 0.17447078f, -0.31992620f, -0.41948995f, 
    -0.12167624f, -0.33592919f, -0.59685594f, -0.06917527f, -0.25934175f, -0.06391174f, 0.27512234f, 0.09632998f, 
    -0.61494064f, 0.10520281f, -0.03580783f, -0.42647529f, 0.23521104f, -0.01237902f, 0.21688749f, -0.18232585f, 
    0.32909343f, 0.04115114f, 0.18718673f, -0.53067625f, 0.24796684f, -0.18033956f, -0.08930589f, 0.10018239f, 
    0.05006453f, 0.23824270f, -0.07320757f, 0.08021399f, -0.03072505f, -0.08856579f, 0.08498768f, 0.00900478f, 
    0.20384292f, -0.09632244f, 0.04287545f, -0.14937764f, 0.06809269f, -0.32258746f, -0.06953309f, 0.14044876f, 
    0.03979405f, -0.00479405f, -0.38574818f, -0.17815651f, -0.16040589f, 0.00940351f, -0.04082885f, -0.02314194f, 
    -0.22966293f, -0.21403849f, -0.02584286f, 0.07118949f, 0.19523446f, -0.07365246f, 0.02174193f, -0.09514206f, 
    -0.04392107f, 0.08300153f, -0.30941340f, 0.06594513f, -0.43762907f, 0.03678710f, 0.06541763f, 0.28078502f, 
    -0.35699776f, 0.06470535f, -0.24207997f, -0.03716048f, -0.06482603f, -0.27418530f, 0.14130008f, 0.01258100f, 
    0.23041810f, -0.02590409f, 0.24373452f, -0.21839753f, -0.49307659f, 0.21738417f, -0.20332840f, 0.36869362f, 
    -0.15282148f, 0.26144016f, -0.17114110f, -0.30499747f, 0.10065705f, 0.13595001f, 0.02982109f, 0.00663685f, 
    -0.54210651f, -0.13556528f, -0.14622846f, -0.22184300f, -0.23137310f, -0.05954305f, -0.00217699f, 0.08581302f, 
    -0.08437827f, 0.03147817f, 0.01564934f, 0.09792370f, -0.07032412f, -0.21340112f, -0.10607652f, 0.14200003f, 
    0.01434864f, 0.01794073f, 0.16253670f, 0.23815002f, -0.24916847f, 0.03320436f, 0.01508814f, 0.02818902f, 
    -0.23284276f, 0.28817734f, 0.08361352f, -0.06939357f, -0.42524007f, -0.03052552f, -0.00848030f, 0.10954619f, 
    -0.05718177f, 0.38302889f, -0.55611432f, 0.08269430f, 0.01898543f, -0.10418936f, -0.54222685f, 0.10848323f, 
    -0.20518367f, -0.10544401f, -0.29670265f, -0.35027343f, 0.29284197f, -0.12997466f, -0.09638809f, 0.23041409f, 
    -0.05395585f, 0.06421671f, -0.18246834f, -0.28623948f, -0.41977075f, -0.06523877f, 0.06888487f, 0.06026609f, 
    -0.28141862f, -0.05432891f, 0.28141785f, -0.02454895f, -0.15005051f, 0.02174698f, 0.14520437f, 0.01610779f, 
    -0.36405814f, 0.14550458f, 0.10209447f, -0.40311265f, 0.18835600f, 0.08476035f, 0.01740362f, 0.03667036f, 
    0.14213715f, -0.03642622f, 0.30928111f, 0.25656727f, 0.07519535f, 0.14742592f, -0.00703027f, 0.00067490f, 
    -0.13450190f, -0.55045348f, 0.20191227f, 0.23865275f, -0.27919140f, -0.18678935f, -0.16532543f, -0.36850670f, 
    0.02432998f, 0.01122921f, -0.00271632f, -0.07160155f, -0.06810465f, 0.11473697f, -0.10240192f, 0.01222689f, 
    0.12277022f, -0.40772283f, -0.05012114f, -0.21705243f, -0.19677782f, 0.24945734f, 0.12909947f, -0.38174489f, 
    -0.37525573f, -0.22498153f, 0.06199904f, -0.20108259f, -0.18551293f, -0.27661437f, 0.27883196f, -0.25040174f, 
    0.20930430f, -0.10880373f, 0.10129642f, -0.26575077f, 0.12139135f, 0.14885156f, -0.12201625f, 0.16088474f, 
    -0.12941478f, -0.18899469f, -0.36723703f, 0.26109385f, 0.25247112f, 0.21214029f, 0.10952536f, 0.03814455f, 
    0.07082281f, 0.05943802f, 0.07440640f, -0.11830051f, 0.16602309f, -0.01630170f, 0.04663080f, 0.03042300f, 
    0.12195202f, 0.15802152f, -0.39973924f, -0.33485398f, -0.04912879f, -0.48130694f, -0.06617998f, 0.05347494f, 
    0.09286985f, 0.10813341f, -0.26978263f, -0.21780978f, -0.50807273f, -0.08958557f, -0.26299709f, 0.10636106f, 
    -0.20391192f, 0.00430390f, 0.01892206f, -0.00482790f, -0.09252495f, -0.57945526f, -0.24804242f, 0.09629589f, 
    -0.12396917f, -0.08710478f, 0.16853334f, -0.11294279f, -0.04704612f, -0.09211938f, -0.16833414f, -0.06152074f, 
    -0.26841766f, 0.20911939f, -0.52714741f, -0.05197943f, -0.08607130f, -0.03023604f, -0.07091251f, -0.13605498f, 
    -0.47590402f, -0.01885354f, -0.33532554f, 0.04290378f, -0.36580402f, -0.12055837f, -0.06951073f, -0.25294456f, 
    -0.25545955f, -0.53321737f, 0.11263132f, 0.00438402f, -0.15534985f, -0.17407535f, 0.01361514f, -0.28983837f, 
    0.30634084f, 0.07362769f, -0.07121556f, 0.32342732f, 0.25221622f, -0.11210501f, -0.12315460f, 0.09225975f, 
    0.05387626f, 0.01405796f, 0.12681003f, 0.26965490f, -0.15104705f, 0.28373092f, 0.03179576f, -0.23150921f, 
    -0.00201884f, 0.29197013f, 0.13869928f, -0.11798047f, -0.21125717f, -0.21746087f, 0.04858012f, -0.24386732f, 
    -0.45945105f, -0.16029307f, 0.00113384f, -0.00496533f, 0.22135647f, -0.60945112f, -0.11765391f, 0.01781116f, 
    0.00971922f, 0.13222578f, 0.10170832f, -0.15041031f, 0.27930266f, -0.01055443f, 0.18618931f, -0.08537133f, 
    -0.17230855f, 0.11416846f, -0.19964074f, -0.29004720f, -0.16789590f, 0.14160469f, -0.28349233f, 0.02244626f, 
    -0.22072355f, 0.11077911f, -0.36273408f, 0.10667431f, 0.09720878f, -0.21592809f, 0.08115409f, -0.35154378f, 
    0.29633012f, -0.09425665f, -0.24454074f, -0.22517385f, -0.17881288f, -0.27532399f, -0.12942579f, 0.20306773f, 
    -0.34246609f, 0.12867193f, 0.25461578f, 0.32061785f, 0.14907491f, -0.01436730f, 0.01579669f, 0.04979378f, 
    0.03633486f, -0.07501438f, -0.08769770f, -0.26545125f, -0.07466589f, -0.19743827f, 0.05094119f, -0.02467105f, 
    -0.08310631f, -0.26768717f, 0.35417560f, 0.12384511f, 0.04781801f, -0.01976189f, -0.58940375f, 0.22373351f, 
    0.15669052f, 0.14920940f, 0.04747072f, 0.02072034f, 0.11965173f, -0.17418112f, -0.23790385f, -0.08975282f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.10203002f, 0.12218394f, 0.22416550f, -0.20174013f, -0.00608750f, 0.09601185f, -0.06263033f, 0.09618197f, 
    0.09981114f, 0.12014584f, -0.04374671f, -0.12435199f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
