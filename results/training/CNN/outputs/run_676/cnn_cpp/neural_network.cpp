#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.56962270f, 0.58072555f, 0.29804602f, 0.85392028f, 0.61550742f, -0.11449561f, 0.36597314f, -0.20498383f, 
    -0.20793718f, 0.42037508f, -0.08702430f, -0.09447464f, 0.21177395f, -0.16627006f, -0.02158852f, -0.18929432f, 
    0.08695900f, 0.18316333f, -0.18429208f, -0.26031533f, -0.04169583f, -0.06101965f, -0.16674334f, 0.00038391f, 
    -0.13224496f, 0.05833322f, -0.36492312f, 0.08746272f, 0.87794226f, 0.56826931f, 0.68340069f, 0.20262159f, 
    0.05716148f, -0.12983958f, -0.13517576f, 0.13984059f, 0.11341047f, 0.02241630f, 0.33394584f, 0.24343649f, 
    0.21296017f, 0.18980305f, 0.27834061f, 0.27550119f, 0.14968191f, -0.28358841f, 0.14850253f, -0.41705567f, 
    0.04552318f, -0.30605912f, 0.74932426f, 0.34358448f, 0.81993359f, 0.72329003f, 0.40021783f, -0.23314150f, 
    0.14157812f, -0.40156391f, -0.64109641f, -0.25812361f, 0.06904347f, 0.12748523f, -0.18465981f, 0.16192533f, 
    0.02553438f, -0.04522558f, 0.11753868f, -0.00960909f, 0.10978709f, 0.24713372f, 0.07115294f, 0.20628758f, 
    0.40457472f, 0.03971636f, 0.15304013f, 0.23613816f, -0.74727941f, 0.21776949f, 0.40738565f, -0.21659964f, 
    0.34332660f, -0.96259540f, 0.36594850f, 0.43119115f, -0.00333426f, 0.01631231f, -0.30857652f, -0.21170264f, 
    0.33363989f, -0.32162830f, 0.10718402f, 0.06566824f, -0.03722801f, -0.19857195f, -0.09797055f, -0.01263103f, 
    0.09229831f, 0.27542287f, 0.02365086f, 0.06569520f, 0.78674495f, 0.41652998f, -0.65687257f, -0.81781662f, 
    -0.06185244f, 0.42349571f, -0.66937590f, -0.04877158f, -0.44500425f, -0.34946588f, 0.24007060f, -0.28427571f, 
    0.01255712f, 0.14470398f, -0.33712265f, -0.04381822f, 0.05733746f, -0.18080007f, 0.30971339f, 0.10244231f, 
    0.22245745f, -0.05005999f, 0.00003976f, -0.21469712f, 0.03544497f, -0.87551665f, -0.32737941f, -0.16541457f, 
    -0.27841932f, -0.51670325f, -0.33203456f, -0.06724280f, -0.34805822f, -0.06418394f, -0.28658137f, 0.08484086f, 
    0.44601741f, -0.04130275f, 0.12976038f, -0.15085289f, 0.33095360f, -0.26501462f, 0.07829409f, 0.18763717f, 
    -0.20786697f, -0.02596498f, 0.12428294f, 0.27485704f, -0.07818919f, 0.38094097f, -0.74745011f, -0.23261227f, 
    -0.69330657f, -0.27727062f, 0.37541634f, -0.03539265f, 0.90124691f, 0.31797260f, 0.12961689f, 0.14259839f, 
    -0.08673745f, -0.05390392f, 0.28991368f, -0.27414572f, -0.08867721f, 0.28925309f, -0.01504482f, 0.16780199f, 
    0.22489786f, -0.34489673f, 0.25127345f, 0.06982887f, -0.07677350f, 0.09434230f, 0.26583958f, 0.38474968f, 
    -0.31901848f, -0.37067139f, -0.04604689f, 0.33744645f, -0.50601631f, -0.81168610f, -0.58300596f, -0.56252974f, 
    -0.17493285f, -0.19206123f, -0.06346406f, 0.00775222f, -0.19770931f, 0.00772270f, 0.21054560f, -0.17919125f, 
    -0.13846867f, -0.25724542f, 0.12336640f, -0.17445542f, 0.28825957f, 0.33590615f, -0.48840269f, -0.02008520f, 
    -0.03876172f, -0.66657668f, -0.50935137f, -0.26418862f, -0.62686610f, -0.32533962f, 0.61225688f, 0.19637184f, 
    -0.21902213f, 0.50927389f, -0.08812866f, -0.02491543f, -0.15066142f, -0.20450477f, 0.26243719f, -0.09041602f, 
    0.17124251f, -0.02440246f, 0.25057796f, 0.40372559f, 0.19451313f, 0.28250813f, -0.11854914f, 0.02348911f, 
    -0.11665332f, -0.73800236f, 0.57484317f, -0.53792202f, -0.60193080f, 0.31797826f, -0.35367861f, 0.50504428f, 
    0.34885535f, 0.42935681f, 0.56167579f, -0.11119574f, 0.00883500f, -0.04991576f, -0.34644607f, 0.10831393f, 
    0.06544156f, 0.23461884f, 0.13577469f, 0.22027104f, 0.09419136f, -0.35560712f, -0.12435021f, -0.36226213f, 
    -0.08774382f, -0.00757074f, 0.81496972f, 0.75385869f, -0.49195004f, -0.18197376f, -0.72264314f, 0.10369627f, 
    0.49338445f, -0.28636912f, 0.12488969f, 0.42429763f, 0.30738446f, 0.19251506f, 0.26849556f, -0.03351430f, 
    -0.14032207f, 0.02030148f, -0.06356638f, 0.25043520f, 0.14992602f, -0.04191522f, 0.03127191f, 0.00747844f, 
    0.09761542f, 0.10905481f, -0.04535091f, 0.87949193f, 0.61848825f, -0.42118314f, 0.15567641f, -0.48419338f, 
    0.24037337f, -0.32478932f, 0.08574646f, -0.13791171f, 0.16061889f, -0.04965029f, 0.35313612f, -0.21983933f, 
    0.09059382f, -0.18953995f, -0.03356398f, 0.14479887f, -0.38309389f, -0.22795200f, -0.17287427f, -0.21282461f, 
    -0.06196529f, -0.12222706f, -0.28413004f, -0.04436857f, -0.36140296f, -0.87528586f, -0.90982664f, -0.44726524f, 
    0.09841562f, -0.04962289f, 0.50594002f, 0.25473270f, -0.09330878f, 0.24357279f, 0.10479075f, 0.06157058f, 
    -0.12474316f, -0.18208551f, -0.10669009f, -0.15094823f, 0.02366027f, 0.00063708f, -0.26162425f, -0.24421455f, 
    -0.20628718f, -0.37553984f, 0.14757167f, -0.03880186f, -0.02983496f, -1.04431391f, 0.57124907f, -0.20059757f, 
    -0.56083649f, -0.51602441f, 0.25691956f, -0.01799195f, 0.22019172f, 0.33110926f, -0.08608303f, -0.26178387f, 
    -0.14311981f, -0.29617608f, 0.08330677f, -0.04369976f, -0.11055517f, 0.04391157f, -0.15754198f, -0.17284487f, 
    -0.16736725f, 0.18418147f, 0.19776441f, 0.19558147f, 0.23457088f, -0.01856226f, -0.67919654f, 0.21691500f, 
    0.58254951f, 0.82824057f, 0.13094436f, -0.97066647f, -0.15725943f, -0.45363510f, -0.21385972f, 0.06749132f, 
    0.37981164f, 0.21699832f, 0.02361881f, 0.02711542f, 0.08784378f, -0.09881347f, 0.09124053f, 0.12914386f, 
    0.16324167f, 0.10989383f, -0.25127575f, -0.04749143f, -0.06928375f, 0.16260235f, 0.05257697f, 0.17364565f, 
    -1.06052935f, -0.20832168f, 0.39484861f, -0.32021943f, -0.88009059f, 0.50589317f, 0.35755932f, 0.10207665f, 
    -0.21512353f, 0.46776319f, 0.17453815f, 0.23808813f, 0.07334790f, 0.37903413f, 0.04176753f, 0.07434657f, 
    -0.15786088f, -0.12577936f, -0.14822903f, 0.14566806f, 0.15430973f, -0.17060556f, 0.07358578f, -0.06632996f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05759442f, 0.08990811f, -0.15489189f, -0.05988470f, 0.21128462f, 0.14288671f, 0.25483072f, 0.17641070f, 
    0.18046919f, 0.36416754f, 0.04194109f, 0.08488712f, 0.22234355f, 0.13183324f, 0.24056298f, 0.06078436f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.10451140f, 0.01904065f, 0.13820538f, 0.27707475f, -0.07154418f, 0.04329668f, -0.01671698f, 0.00632126f, 
    -0.01429359f, -0.07599331f, 0.13957663f, -0.04381754f, -0.09523701f, 0.15090168f, 0.04915496f, 0.06991871f, 
    -0.02121877f, 0.04628472f, -0.16244376f, 0.06388412f, -0.02858235f, 0.03350456f, 0.05990890f, 0.14167745f, 
    -0.21489251f, 0.04976101f, 0.25381315f, 0.08385796f, -0.12840985f, 0.05198039f, 0.06332961f, 0.15259634f, 
    0.11025872f, 0.12699835f, 0.01263405f, 0.19048752f, -0.27019677f, -0.11902477f, 0.01143481f, 0.18648370f, 
    -0.00130583f, 0.00007509f, 0.13703161f, -0.07356723f, 0.18078940f, 0.04430361f, 0.01057377f, -0.05891737f, 
    -0.14375401f, -0.14639072f, 0.28484708f, -0.21708117f, 0.04801072f, -0.12790540f, 0.06357913f, 0.10022299f, 
    0.04573425f, -0.00403700f, 0.03545995f, 0.03346660f, 0.13055217f, -0.01024813f, -0.13235566f, -0.09305404f, 
    0.12784347f, 0.01814917f, 0.08067393f, 0.12829028f, -0.05102375f, -0.04781203f, 0.12632021f, 0.15403204f, 
    -0.03039383f, 0.27091277f, -0.07579086f, -0.18162791f, -0.02738160f, 0.09540030f, 0.01255468f, -0.10159162f, 
    0.16740519f, -0.06171136f, 0.01983092f, 0.05713705f, 0.22188090f, -0.07531531f, 0.12992060f, 0.11842350f, 
    -0.01210882f, -0.03348080f, 0.06715523f, -0.03032739f, -0.10206991f, 0.06573738f, 0.02686069f, -0.03287497f, 
    0.02436843f, 0.02827098f, -0.06099410f, 0.07426073f, 0.06846038f, -0.04325710f, -0.02502842f, 0.04923159f, 
    0.01809179f, 0.05639740f, 0.00694636f, -0.01041930f, 0.15620664f, 0.16068469f, 0.15193698f, -0.06837566f, 
    -0.00813178f, 0.02282342f, -0.09083144f, -0.20441361f, 0.07459453f, 0.01934129f, 0.03748325f, 0.09354663f, 
    0.03707374f, -0.08436294f, -0.03929596f, -0.10899293f, 0.02922277f, -0.11614103f, 0.11151091f, -0.05599836f, 
    0.10718182f, -0.10726102f, -0.01764305f, 0.06565856f, -0.09314862f, -0.17689854f, -0.02277301f, -0.06614173f, 
    0.00843645f, 0.09450369f, -0.03580869f, -0.04442378f, -0.02596857f, -0.11836225f, -0.19997893f, -0.09507558f, 
    0.00072478f, 0.07967392f, 0.01067578f, -0.02046262f, -0.07100723f, 0.01594155f, 0.11730413f, -0.11449587f, 
    -0.02768000f, -0.14272092f, -0.03653265f, 0.00911180f, 0.26682588f, -0.04314332f, -0.09806154f, -0.12413502f, 
    0.09380839f, 0.03128477f, 0.02320101f, 0.01835376f, 0.12953800f, 0.07287162f, -0.14977635f, -0.05830663f, 
    -0.13371746f, 0.02572381f, -0.06425855f, 0.09816377f, -0.08389899f, 0.02475738f, 0.09184512f, 0.00718341f, 
    -0.10176530f, 0.00277520f, 0.11074695f, 0.11937163f, -0.04693353f, -0.12601256f, 0.03286687f, 0.07362391f, 
    0.03366238f, 0.03318688f, -0.07278515f, 0.05671004f, -0.11677154f, 0.05286952f, -0.04383961f, 0.06705677f, 
    -0.00665727f, 0.00166260f, -0.23034516f, 0.05478733f, 0.05564435f, -0.07074142f, 0.00838641f, -0.02569509f, 
    -0.00426787f, 0.20311490f, 0.08088432f, 0.07348426f, 0.17407656f, -0.06987084f, -0.19485526f, 0.10498101f, 
    -0.00715667f, -0.13537042f, 0.00242509f, 0.06246008f, 0.02414051f, -0.00303890f, 0.05571845f, -0.02365643f, 
    0.03313448f, 0.22699179f, -0.23673938f, -0.22592363f, 0.00168949f, -0.01967104f, 0.02367106f, 0.01127346f, 
    -0.07371972f, 0.03854399f, -0.05704772f, 0.00054207f, 0.20270801f, -0.18820630f, 0.28682533f, 0.04154741f, 
    0.05153104f, -0.02475884f, -0.00717291f, 0.11286251f, -0.04148537f, 0.08979072f, 0.01292262f, 0.04112131f, 
    -0.18564050f, 0.01903494f, 0.07152836f, -0.22623253f, 0.04292583f, 0.08951483f, 0.09179913f, 0.00054397f, 
    -0.04350084f, -0.06236808f, 0.13473925f, 0.11621226f, 0.05794558f, -0.22076896f, -0.05829403f, -0.24547914f, 
    -0.04085298f, 0.06371625f, 0.06466179f, 0.12979092f, 0.05951936f, 0.01847959f, -0.07976804f, -0.10519463f, 
    0.28946844f, 0.09877560f, 0.07790613f, -0.03839235f, 0.05665651f, -0.14608392f, 0.01259817f, 0.16127644f, 
    -0.02927868f, 0.11936786f, -0.00401675f, 0.10247540f, -0.08810558f, -0.05139747f, -0.11158521f, -0.07780931f, 
    0.06049859f, -0.03875373f, 0.00740163f, 0.14897539f, -0.01674892f, 0.02919495f, -0.10970741f, 0.07435779f, 
    -0.03328851f, 0.03897297f, 0.09401714f, -0.12019750f, -0.11005646f, 0.03900272f, 0.12515703f, -0.19363800f, 
    0.06322119f, 0.06889880f, 0.00802478f, 0.05712986f, 0.25612301f, -0.03262573f, 0.01401939f, 0.06629154f, 
    -0.03578527f, 0.04279005f, 0.14283749f, 0.06240658f, -0.02495256f, -0.06275222f, 0.00658187f, -0.04549196f, 
    -0.20427509f, 0.13704908f, 0.10068516f, -0.11607501f, 0.14657038f, 0.00890712f, 0.01624944f, -0.02839668f, 
    0.00288853f, 0.06235145f, 0.11550342f, 0.10222822f, -0.11194030f, -0.15971854f, 0.08996325f, -0.15763585f, 
    0.04084925f, -0.14959975f, -0.05558738f, -0.04119419f, 0.14033298f, 0.00860483f, 0.00612666f, 0.10005377f, 
    -0.16955678f, 0.08000601f, 0.10507422f, -0.03956517f, -0.07260293f, -0.13194899f, -0.12419839f, 0.07374021f, 
    0.01412878f, 0.06640525f, 0.03248528f, -0.04479977f, 0.34755582f, -0.05589025f, 0.00559187f, -0.06235831f, 
    -0.07685024f, -0.05618103f, -0.05271286f, -0.05772807f, -0.02773314f, -0.07710670f, 0.05507397f, 0.03904799f, 
    -0.06007769f, 0.14523046f, 0.04393239f, 0.05550056f, -0.00224697f, 0.05156443f, -0.06994847f, 0.02788420f, 
    0.15640400f, 0.10246539f, -0.07623697f, 0.10489217f, -0.02727777f, 0.05961063f, -0.08592793f, 0.06082227f, 
    0.00558339f, 0.00563415f, 0.05707353f, -0.12977010f, -0.00702854f, -0.05761129f, 0.07699145f, 0.06182622f, 
    -0.42608187f, -0.33099300f, -0.14907001f, 0.02767580f, 0.15850629f, -0.10863744f, -0.09295710f, -0.00369097f, 
    0.08614535f, -0.01172440f, 0.13950358f, 0.00731813f, -0.09763390f, 0.12518133f, 0.02645935f, 0.15723175f, 
    0.09336366f, -0.08871354f, -0.08247550f, 0.05634387f, 0.06120713f, 0.08806727f, 0.12161718f, 0.14701810f, 
    -0.53693086f, -0.17236063f, 0.03759262f, -0.08308758f, 0.11223998f, -0.08123077f, -0.05921190f, 0.01922871f, 
    0.01541650f, 0.00024138f, 0.01826768f, -0.00039775f, 0.28975773f, -0.06982058f, 0.00457671f, -0.04208305f, 
    0.01878507f, -0.07980590f, 0.09431981f, 0.07378170f, 0.23166656f, -0.03457918f, 0.17192353f, 0.05210036f, 
    -0.06520146f, 0.14097929f, 0.23923320f, 0.00250752f, 0.03979361f, 0.06711748f, 0.07362497f, -0.00992817f, 
    0.09657205f, -0.00034718f, -0.03529138f, -0.05097502f, 0.10058606f, 0.12544562f, 0.00673059f, -0.00231371f, 
    -0.00461421f, 0.00502169f, -0.03890941f, 0.01251708f, -0.05056524f, 0.06720775f, -0.00394047f, 0.16477877f, 
    0.30577993f, 0.00363201f, 0.05444845f, 0.16285610f, -0.00533061f, 0.01660532f, 0.06986487f, 0.10607313f, 
    -0.05862689f, 0.09101903f, 0.01234560f, -0.01654600f, 0.25597435f, 0.15687901f, 0.28078276f, 0.14311554f, 
    0.04446576f, 0.16983330f, 0.23081364f, 0.06973143f, -0.07542481f, -0.08109895f, -0.04872518f, 0.02981702f, 
    0.12623633f, -0.09362541f, -0.10123354f, -0.04087707f, 0.09180272f, -0.02164863f, 0.04897169f, -0.01190710f, 
    0.08570338f, 0.13249823f, -0.06395599f, 0.13856332f, 0.12736480f, -0.08677743f, 0.04449570f, 0.00879806f, 
    -0.01708847f, -0.03339022f, -0.01534063f, 0.03323231f, -0.00061148f, 0.13623701f, -0.10880005f, -0.01432764f, 
    -0.05810374f, -0.02195952f, -0.06490059f, -0.09344238f, -0.03783369f, 0.02970432f, 0.10567854f, 0.02925761f, 
    -0.07027542f, -0.04724360f, 0.13092989f, 0.05677434f, -0.18054764f, -0.10112748f, -0.05629392f, -0.00597707f, 
    0.18972114f, -0.01611199f, 0.17558363f, -0.20548183f, 0.11193824f, 0.01694416f, 0.00709840f, 0.00468362f, 
    0.02924328f, -0.03092441f, -0.12651096f, 0.07862333f, -0.01591353f, -0.07064525f, 0.09507012f, 0.04394504f, 
    -0.01160574f, -0.05312854f, -0.10614309f, -0.15187892f, -0.34351903f, -0.06046803f, 0.12469389f, -0.06279869f, 
    0.04211312f, 0.01579753f, -0.00003813f, 0.02918541f, 0.08102416f, 0.03863121f, -0.05061344f, -0.03537319f, 
    -0.22026198f, 0.36568987f, 0.22458673f, -0.03717972f, 0.10973483f, 0.09540198f, -0.00201352f, 0.11640941f, 
    -0.01805063f, -0.04245539f, 0.10769609f, 0.07779948f, -0.14781626f, -0.05958063f, -0.07808074f, -0.11017793f, 
    -0.04185815f, -0.05347335f, -0.03317609f, -0.03560618f, -0.00399217f, 0.01000268f, -0.09331312f, -0.05973367f, 
    0.37065282f, 0.08793074f, 0.17262974f, 0.16239499f, -0.19098011f, -0.01797107f, 0.05469029f, 0.08052985f, 
    0.12569727f, 0.05307433f, 0.03624034f, 0.07155564f, -0.10418381f, 0.04886034f, -0.06708149f, 0.09500621f, 
    0.08890387f, 0.14548519f, 0.14261860f, 0.03950350f, 0.07520614f, -0.10490628f, -0.01547445f, 0.06835908f, 
    0.29273847f, 0.07067377f, 0.10870718f, 0.30381146f, 0.08619870f, 0.05653092f, 0.08903276f, 0.06672894f, 
    0.02498337f, -0.03732326f, -0.06744727f, -0.10336222f, 0.16355155f, 0.01521362f, -0.07270870f, 0.06445400f, 
    0.04160674f, 0.07762574f, -0.08470476f, 0.06984866f, -0.05677925f, -0.06353652f, 0.03499061f, 0.10207834f, 
    0.17116809f, 0.00581844f, 0.12823735f, -0.15523376f, -0.01094762f, -0.02530123f, 0.12598541f, 0.04544232f, 
    0.03124898f, -0.03783341f, 0.13002518f, 0.07813127f, -0.18824838f, 0.00952641f, -0.01232662f, -0.11875219f, 
    -0.15474094f, 0.05446147f, -0.04063839f, 0.20413502f, 0.06581229f, -0.02478489f, -0.09113791f, -0.03898262f, 
    -0.25168160f, 0.20186003f, -0.16674018f, -0.15208696f, 0.02200743f, 0.02419167f, 0.06446791f, 0.00496116f, 
    -0.03895397f, 0.03660935f, -0.00043575f, -0.06875335f, 0.06192691f, -0.02823301f, 0.13297936f, -0.00314667f, 
    -0.13391380f, -0.05792765f, -0.02750874f, 0.11033442f, 0.15603550f, -0.13010974f, 0.05093882f, 0.06995042f, 
    -0.28897986f, -0.06386369f, -0.07154884f, 0.01890545f, -0.14316510f, 0.15137567f, -0.05710884f, 0.02811059f, 
    -0.00129184f, -0.08873708f, 0.12567961f, -0.04372995f, -0.04745081f, 0.18395047f, 0.09805554f, -0.18035474f, 
    -0.14792258f, 0.01898415f, 0.04818115f, 0.09900717f, 0.06638088f, 0.02263964f, -0.01550957f, 0.11409742f, 
    0.18434089f, -0.09715288f, 0.00769013f, 0.01989677f, 0.00581001f, 0.03407456f, -0.03763016f, 0.07067920f, 
    -0.01524781f, -0.00154483f, -0.04207441f, 0.07478182f, 0.36887449f, -0.02967115f, -0.00162455f, 0.00866016f, 
    0.01312276f, 0.06845898f, 0.06520295f, 0.04094855f, -0.01299994f, 0.08284544f, 0.00133029f, 0.00923539f, 
    -0.21445875f, -0.07653476f, -0.17061199f, 0.00649236f, 0.04539268f, 0.01123463f, 0.02051572f, 0.07634214f, 
    0.06875231f, 0.13279878f, 0.08216184f, 0.11627945f, 0.14974661f, -0.03852371f, 0.08049187f, -0.18975592f, 
    -0.03772284f, -0.04316810f, -0.03042439f, 0.11220791f, 0.06695750f, 0.09391592f, 0.01507441f, 0.05264361f, 
    -0.33592305f, -0.15534447f, -0.06974921f, 0.15330487f, -0.02350780f, -0.07682148f, 0.15489675f, 0.08765682f, 
    0.09716763f, 0.07518650f, -0.03489142f, -0.01540639f, -0.33127025f, -0.01893018f, -0.13998745f, 0.12508070f, 
    0.10932789f, -0.05598205f, -0.08709190f, 0.04357444f, 0.09542349f, -0.01264599f, -0.02047160f, -0.01319388f, 
    -0.05243502f, 0.05815047f, -0.06764489f, -0.02707456f, -0.01713631f, 0.03897087f, 0.03226473f, 0.00695870f, 
    0.02835644f, 0.01049023f, 0.03111877f, -0.03866541f, -0.00296278f, 0.04672429f, -0.07356647f, 0.05597508f, 
    -0.02431401f, 0.05988082f, 0.04354018f, 0.05499814f, 0.00685770f, 0.04677509f, 0.03616528f, -0.01864958f, 
    -0.00944083f, 0.04026632f, -0.05200493f, -0.04875481f, -0.07949513f, 0.02194000f, -0.02907771f, 0.01437753f, 
    -0.04060613f, 0.00289201f, 0.00562664f, -0.03449687f, 0.04528667f, -0.03774362f, 0.05400980f, -0.03179469f, 
    -0.06972346f, 0.03236090f, -0.04365900f, -0.00726051f, 0.02999497f, -0.05968328f, -0.06845124f, 0.01180349f, 
    -0.08154567f, -0.00033648f, -0.02269560f, -0.01440587f, 0.00232773f, -0.05857873f, -0.02810054f, 0.01857522f, 
    -0.08222923f, -0.00684063f, -0.05530653f, -0.06881338f, -0.03635374f, -0.01972168f, -0.07730751f, -0.03999252f, 
    -0.07310247f, -0.01030200f, -0.06585161f, -0.04505192f, 0.04550437f, 0.02201710f, -0.01644278f, -0.00910064f, 
    0.06154068f, 0.04822884f, 0.02904080f, -0.08267635f, 0.02743254f, -0.02865265f, -0.00362166f, 0.04402765f, 
    0.02124050f, -0.08081753f, 0.01029649f, -0.03657503f, 0.04675294f, -0.00489739f, 0.03528862f, 0.01707486f, 
    -0.04138578f, 0.02922903f, -0.02263400f, -0.07515625f, -0.07855915f, 0.03915167f, -0.02421711f, -0.07839330f, 
    0.04416781f, 0.04993702f, -0.03541705f, -0.00635687f, -0.05236888f, -0.07065405f, 0.01776655f, 0.02276662f, 
    0.04665245f, -0.04405273f, -0.00359270f, -0.07853447f, -0.05127005f, 0.00909716f, 0.03716101f, -0.01755143f, 
    0.02619111f, 0.03256857f, 0.01441893f, -0.02824559f, 0.02558893f, -0.07955451f, 0.02901770f, 0.01189620f, 
    0.01397435f, 0.01975098f, 0.01557464f, 0.04056850f, -0.04513193f, 0.04183224f, -0.02530819f, 0.03506348f, 
    -0.05645892f, 0.05298670f, -0.02021147f, -0.02143485f, 0.00758660f, 0.01542312f, -0.05191128f, -0.02955545f, 
    -0.00813437f, 0.00812745f, -0.07430932f, -0.02445428f, -0.02226815f, -0.00412104f, -0.00846235f, 0.05708550f, 
    -0.07828225f, 0.03970720f, -0.05797319f, 0.03057699f, -0.03002666f, 0.04854418f, -0.00135904f, 0.04523257f, 
    -0.00774632f, 0.05620449f, -0.00090193f, -0.07627646f, -0.01083830f, -0.04314537f, 0.05083934f, -0.03162836f, 
    0.06557855f, 0.03047023f, -0.06314234f, -0.02795059f, -0.01609041f, 0.02242692f, 0.01084020f, 0.02581408f, 
    0.04684801f, 0.02390725f, -0.04939230f, 0.01209363f, -0.00116519f, -0.05355491f, -0.04130435f, -0.00506090f, 
    -0.03718947f, -0.04257577f, 0.03334695f, -0.00651819f, 0.02178504f, 0.01812092f, 0.01256510f, 0.00682377f, 
    0.00439760f, -0.03937946f, -0.09366433f, 0.00243823f, -0.03581659f, -0.01196687f, -0.01669962f, 0.01772875f, 
    -0.02269325f, -0.11304716f, -0.18172821f, 0.07469453f, -0.09375189f, -0.01438068f, -0.01965203f, -0.05675883f, 
    0.00976072f, 0.04441760f, 0.05275061f, 0.18117854f, -0.12762646f, -0.29753128f, 0.04507083f, 0.16084506f, 
    -0.13967723f, 0.10274851f, 0.12679087f, -0.06288221f, -0.02018443f, -0.12713051f, 0.04158713f, -0.03948540f, 
    0.27795929f, -0.14477170f, -0.06202837f, 0.11377057f, -0.00752828f, -0.02632665f, 0.01552824f, -0.04164450f, 
    -0.05141003f, -0.00498121f, 0.10456283f, -0.08067184f, -0.03327037f, -0.17854270f, -0.10239772f, 0.14649825f, 
    0.08228431f, 0.09235457f, -0.11133453f, 0.12035863f, -0.11178564f, 0.05660350f, 0.03194454f, 0.12028404f, 
    0.20303304f, 0.01519506f, -0.02747333f, 0.02421784f, 0.13002558f, 0.00336568f, 0.13012287f, 0.06826257f, 
    0.05102529f, 0.05600042f, 0.03181455f, 0.14748290f, -0.02602156f, 0.36652645f, 0.08374112f, -0.09479425f, 
    -0.06438091f, -0.03517938f, -0.06998273f, -0.01502515f, 0.19376181f, 0.08183238f, 0.01478567f, -0.14385968f, 
    -0.13874564f, 0.20072882f, 0.00181505f, -0.13405021f, -0.01084125f, -0.06095666f, 0.04514236f, 0.10098340f, 
    -0.14063923f, 0.08554211f, 0.04215074f, 0.06292675f, 0.28564158f, -0.11062109f, 0.09891788f, 0.19290362f, 
    0.03354610f, -0.10442197f, -0.12245760f, -0.03602483f, 0.09904394f, -0.00959057f, -0.05121593f, -0.06487210f, 
    -0.07047229f, -0.02526528f, 0.23390636f, -0.09368817f, -0.18205267f, 0.08280759f, 0.06759307f, 0.10582411f, 
    0.15503183f, -0.06192113f, 0.07857726f, 0.07803310f, -0.34493694f, 0.40485212f, 0.00748608f, 0.05157721f, 
    0.09058055f, -0.00255338f, 0.09882877f, 0.10500631f, 0.05929162f, 0.04664235f, -0.15034494f, 0.02287339f, 
    -0.36442626f, -0.27330875f, -0.09002613f, -0.04827805f, 0.13681775f, 0.14374028f, 0.03615299f, 0.04453170f, 
    -0.09368052f, 0.12408108f, -0.07453816f, 0.15655483f, -0.02860981f, -0.23754117f, 0.00859827f, 0.01525740f, 
    -0.03824012f, 0.04410626f, 0.04787286f, 0.14070891f, 0.06572557f, 0.02783943f, -0.02126022f, 0.10932747f, 
    0.07223249f, 0.12602133f, 0.11029774f, -0.03353765f, -0.05086073f, -0.12852575f, 0.12402680f, 0.08970591f, 
    -0.00809507f, 0.16593789f, -0.00841170f, 0.09102262f, 0.23793948f, 0.09112801f, -0.04684504f, -0.10389506f, 
    -0.19420403f, 0.05496976f, 0.15483487f, -0.12717433f, -0.01202758f, 0.15264754f, -0.00875407f, -0.03575228f, 
    -0.19820616f, 0.04052569f, -0.15521728f, 0.17536359f, 0.13336237f, -0.12365567f, 0.08887646f, -0.04305296f, 
    0.02748059f, 0.07680140f, -0.16619676f, 0.07313508f, -0.12196762f, 0.08231142f, 0.04281588f, 0.01039387f, 
    0.18516779f, 0.00073008f, 0.12847042f, -0.10270857f, 0.04706686f, -0.11001014f, 0.16332336f, -0.06287997f, 
    -0.03731915f, 0.01292715f, 0.00361027f, -0.01627536f, -0.05588566f, -0.02562270f, 0.00479224f, 0.05537413f, 
    0.05649085f, 0.04296981f, -0.00146287f, -0.01213175f, -0.00471815f, 0.04258671f, -0.00127810f, 0.00434881f, 
    -0.05407850f, 0.00416724f, -0.05410216f, 0.05310773f, 0.00020866f, 0.02222897f, -0.06088927f, -0.06069497f, 
    0.01186369f, -0.04215837f, -0.04282035f, -0.05276104f, -0.05299280f, -0.02752507f, -0.05625632f, -0.06977491f, 
    0.06206160f, 0.01111920f, 0.05777849f, 0.05548494f, -0.02495935f, -0.05958531f, 0.06291955f, -0.04509464f, 
    -0.04753470f, 0.06239709f, 0.02046871f, 0.02658990f, -0.06755880f, -0.04931924f, 0.02569154f, 0.06683597f, 
    -0.01842056f, 0.04483026f, -0.02366703f, 0.01883133f, 0.03746949f, 0.00726579f, -0.02691960f, -0.04300227f, 
    -0.07123467f, -0.00836353f, 0.05378429f, 0.05426100f, 0.01404238f, -0.00791038f, 0.03819643f, -0.06172485f, 
    -0.07264650f, 0.04461417f, -0.06329106f, -0.00112925f, 0.06077449f, -0.01578116f, -0.06237819f, 0.05872060f, 
    0.06447668f, -0.02937892f, -0.04702955f, 0.06385704f, 0.05624289f, -0.03382752f, -0.04107490f, -0.05932767f, 
    -0.00453720f, -0.03368217f, -0.03244577f, -0.01933420f, -0.02292561f, -0.06343158f, 0.00848084f, 0.02409977f, 
    0.05992375f, -0.01614553f, 0.00308121f, 0.03463175f, -0.03857481f, -0.02455130f, -0.07418372f, -0.00280663f, 
    -0.00499649f, -0.02026325f, 0.03334817f, -0.04277980f, 0.05617114f, -0.04990703f, -0.04931895f, -0.01965439f, 
    0.06102785f, -0.03902262f, 0.00944550f, 0.01433983f, 0.02994836f, -0.02318029f, -0.07058135f, 0.01030648f, 
    -0.04597802f, -0.03078643f, 0.05439772f, 0.01692942f, 0.02532411f, -0.05591832f, -0.06963591f, -0.06553377f, 
    -0.04743558f, 0.00858103f, 0.04923179f, 0.00924506f, -0.03765301f, -0.05478282f, 0.02725567f, -0.04408382f, 
    0.03009463f, 0.01612803f, 0.00304088f, 0.00385602f, 0.00766231f, -0.03100850f, 0.04616060f, -0.00430346f, 
    -0.06801821f, -0.04647498f, -0.04395794f, 0.03541648f, -0.00642985f, 0.04199496f, -0.05273105f, 0.01393819f, 
    -0.01536210f, 0.02403273f, 0.06276006f, 0.06357127f, -0.05175841f, 0.01294371f, -0.07441156f, -0.04630404f, 
    -0.00733707f, -0.06637520f, -0.06995615f, -0.02085311f, -0.04959248f, 0.05554978f, 0.06297977f, 0.00548092f, 
    -0.06072162f, 0.05479388f, -0.06774527f, -0.07680307f, 0.01142541f, -0.03765865f, 0.02995752f, -0.00437179f, 
    -0.01021954f, 0.03796213f, -0.00344248f, -0.06632679f, 0.00760510f, 0.02271446f, 0.06448831f, 0.04082925f, 
    0.03643250f, -0.06942444f, 0.00810462f, -0.06517535f, 0.02057873f, -0.03117092f, 0.02270447f, 0.05355861f, 
    -0.04066089f, -0.07522300f, -0.07853095f, -0.01817114f, -0.01317254f, -0.05933706f, -0.04243197f, -0.06766289f, 
    -0.06160998f, -0.21168360f, 0.08580869f, 0.23756045f, -0.11334679f, -0.09102054f, 0.03142268f, 0.04982485f, 
    -0.01761872f, -0.05577874f, 0.09291803f, -0.10003498f, -0.01022644f, -0.00842416f, -0.11616414f, 0.12816145f, 
    0.00835379f, 0.00158582f, -0.07451263f, 0.01977471f, -0.00774631f, 0.04753496f, 0.07107339f, 0.12118661f, 
    -0.24639143f, -0.12868240f, -0.03591321f, 0.12325510f, -0.24001245f, 0.04075634f, 0.09109177f, 0.07278999f, 
    0.01480289f, 0.10591991f, 0.09658211f, 0.17141916f, -0.04649320f, -0.08627713f, 0.04572072f, 0.31841457f, 
    -0.00573394f, 0.11310660f, 0.09640144f, -0.00389293f, 0.08312038f, 0.12691328f, -0.03573860f, 0.02602758f, 
    -0.15465346f, 0.01908408f, 0.33956718f, -0.26763663f, 0.08764864f, -0.01841620f, 0.09433676f, 0.09390776f, 
    -0.09422043f, -0.01619587f, 0.04685260f, 0.11956055f, 0.17200316f, 0.09932443f, 0.07345693f, -0.03969554f, 
    0.13376394f, 0.08722795f, 0.02368622f, 0.15551555f, -0.00802413f, -0.02133660f, 0.04111198f, 0.04071597f, 
    0.16657679f, 0.19233237f, 0.10569604f, -0.14406368f, 0.01483470f, 0.13056086f, -0.01065811f, 0.08577116f, 
    0.03703180f, 0.05857802f, 0.03686532f, 0.04216921f, 0.28304619f, -0.16232261f, 0.21998726f, 0.12161978f, 
    -0.00362343f, -0.03254168f, -0.03447179f, 0.00707652f, -0.05330378f, -0.01835722f, -0.02679731f, 0.02060264f, 
    0.25028479f, -0.10197242f, 0.03357582f, -0.06224020f, 0.08200759f, -0.03308986f, 0.07310538f, -0.01290407f, 
    0.09473324f, 0.11074887f, -0.07718049f, 0.03490050f, 0.11846563f, 0.19352631f, 0.14324862f, -0.22366856f, 
    -0.00471555f, 0.05542975f, -0.06704513f, -0.14183995f, 0.09355447f, 0.01300637f, -0.06384046f, 0.06205022f, 
    -0.20598774f, -0.13818210f, 0.01966213f, -0.23766011f, -0.01974900f, -0.01307647f, 0.11846415f, -0.02721161f, 
    -0.04188192f, 0.02178613f, 0.10053078f, 0.11432849f, -0.19892137f, -0.18429656f, -0.07617349f, -0.21004501f, 
    -0.17184255f, -0.17192374f, 0.04775554f, -0.08134520f, -0.03435736f, -0.15483518f, -0.15086477f, -0.15304315f, 
    0.21035282f, 0.17371742f, 0.20758197f, -0.06611075f, -0.03329102f, 0.05803982f, 0.00278677f, 0.05962858f, 
    -0.00800311f, -0.07738187f, -0.07614221f, -0.07050053f, 0.21305774f, 0.05500328f, 0.01106793f, -0.08218534f, 
    0.02737642f, 0.04313498f, 0.03997241f, 0.01991117f, 0.08101950f, 0.09219296f, -0.07800536f, -0.15314202f, 
    -0.08504781f, 0.06268118f, -0.05069029f, 0.21883936f, -0.01458061f, 0.03460320f, -0.07608406f, -0.06107017f, 
    -0.09395085f, 0.03790803f, -0.03471224f, 0.11402414f, 0.18503259f, -0.07651093f, 0.05340886f, 0.06419231f, 
    -0.12424899f, 0.06271784f, -0.03993497f, -0.05638817f, -0.06137168f, 0.08903693f, 0.00916264f, 0.10272231f, 
    0.39288163f, 0.26519534f, -0.00428640f, 0.15876326f, -0.00732940f, 0.06050780f, 0.03124847f, 0.09890760f, 
    0.10556171f, 0.09016184f, 0.08011570f, 0.09500910f, 0.25529423f, -0.09610122f, -0.03573845f, 0.05275502f, 
    0.04894815f, 0.07717924f, -0.01672144f, 0.08919934f, 0.02461245f, 0.01725526f, -0.05137637f, -0.06510045f, 
    0.43386284f, 0.27769187f, 0.08363037f, 0.07067861f, 0.08738140f, 0.08104695f, -0.09298094f, 0.00615976f, 
    -0.09925718f, 0.04618725f, -0.02214556f, -0.05446305f, -0.27959618f, 0.06883360f, 0.12895249f, -0.03127594f, 
    0.02854534f, -0.01330104f, -0.13569275f, -0.02866122f, -0.04068756f, -0.03615168f, 0.00620301f, -0.01203848f, 
    0.02409787f, -0.13157918f, -0.24000779f, -0.10472807f, -0.08015142f, 0.05891454f, 0.14674370f, -0.11950605f, 
    -0.03003863f, -0.07717476f, 0.00457608f, 0.13347207f, -0.24094661f, -0.17714858f, -0.06281148f, -0.18522531f, 
    -0.13387220f, 0.03735808f, 0.01739897f, 0.07375659f, 0.01535412f, -0.00280192f, -0.08980884f, -0.10982979f, 
    -0.13632315f, -0.08305129f, -0.03847941f, -0.06066598f, 0.04559962f, -0.06377439f, 0.01566119f, 0.04329829f, 
    -0.05648429f, -0.10973860f, 0.04901658f, 0.04918826f, -0.23094413f, 0.04675189f, -0.14239752f, -0.24922135f, 
    0.01470357f, -0.11414011f, -0.07374816f, 0.06190493f, 0.13497153f, 0.10408361f, 0.03534544f, 0.16602996f, 
    -0.12331785f, -0.08915336f, 0.03782843f, 0.12621002f, -0.02336449f, 0.10263773f, 0.05132470f, -0.01454548f, 
    0.01180713f, -0.09359676f, 0.14318590f, -0.13549873f, -0.10401392f, -0.08486865f, -0.10193085f, 0.08416109f, 
    0.06841355f, 0.14813434f, 0.19766535f, 0.13603488f, 0.07082053f, 0.01989647f, 0.10698804f, 0.02441920f, 
    0.11754410f, 0.11913467f, 0.12516792f, 0.09361064f, 0.11560797f, 0.00765890f, 0.07204456f, -0.02201966f, 
    -0.07453601f, 0.03731533f, -0.02856582f, -0.04429928f, 0.06306881f, 0.01777288f, 0.12306521f, -0.02218247f, 
    -0.04858480f, 0.01736548f, -0.06356445f, 0.16972841f, 0.08717230f, 0.13716869f, 0.16386344f, 0.05942877f, 
    -0.14814262f, -0.22017843f, 0.01344860f, -0.01261254f, 0.09843365f, -0.04825602f, -0.03876074f, 0.03357408f, 
    -0.10768622f, 0.09847049f, 0.14316094f, 0.02299016f, 0.17476261f, -0.03705463f, -0.10358635f, -0.03137482f, 
    -0.04319099f, -0.02934955f, 0.00301379f, -0.13095619f, -0.06801715f, -0.06201690f, 0.04190113f, 0.01898987f, 
    0.09341415f, -0.14735729f, -0.09096041f, 0.09964552f, 0.03241001f, 0.14500885f, -0.01632212f, 0.00711275f, 
    0.09197048f, 0.14808930f, -0.03943614f, -0.02524097f, 0.21786125f, -0.09715957f, -0.03311654f, 0.07008282f, 
    0.10709628f, 0.04583133f, 0.18539828f, 0.04040990f, 0.07939908f, 0.02310400f, 0.02719216f, -0.07290702f, 
    -0.04939517f, -0.06504820f, -0.01273848f, -0.05233033f, -0.03190776f, 0.01416496f, -0.02520662f, -0.00057594f, 
    -0.05405694f, -0.04623293f, 0.02647888f, -0.05774819f, -0.05308224f, -0.07043162f, -0.01141186f, 0.06264832f, 
    0.00413188f, 0.04653550f, 0.04936175f, 0.05052995f, -0.01065535f, -0.06790856f, -0.01053406f, -0.07072178f, 
    -0.07325977f, -0.01883087f, 0.01448627f, 0.03461734f, -0.01748708f, -0.04694406f, -0.00931362f, -0.01041090f, 
    -0.05217812f, -0.00716496f, -0.01479504f, 0.01803365f, 0.01942686f, -0.03588763f, 0.06052769f, 0.02322800f, 
    0.02296771f, 0.01186108f, -0.01672889f, 0.04624068f, -0.02728849f, -0.03759893f, -0.06817696f, -0.02713456f, 
    -0.07145122f, 0.01218624f, -0.06399063f, -0.01359277f, -0.06500388f, -0.04040400f, -0.03003800f, 0.00770097f, 
    0.00165742f, -0.02103864f, -0.05943727f, -0.05925675f, -0.04023043f, 0.05711224f, 0.03479258f, -0.03417198f, 
    0.05801808f, -0.03087749f, -0.04351427f, 0.01441114f, 0.02004641f, 0.01343802f, 0.06248781f, -0.03625138f, 
    0.05105378f, -0.02166980f, 0.00826597f, -0.03130771f, 0.02466480f, -0.04979246f, -0.00952090f, 0.02319961f, 
    0.02136148f, 0.03947701f, 0.01079062f, -0.01097155f, 0.03867168f, 0.01808306f, -0.06851516f, 0.03437196f, 
    -0.00255457f, -0.03691704f, 0.02372600f, -0.01221806f, 0.04234732f, -0.02412753f, -0.03838406f, 0.06190026f, 
    0.05513147f, -0.04025925f, -0.04214706f, 0.06243350f, 0.03600524f, -0.00083603f, 0.04376284f, 0.05720326f, 
    -0.03971359f, 0.04942778f, -0.05667980f, 0.01396717f, 0.01498169f, 0.06147013f, -0.05806050f, 0.05722468f, 
    0.03906728f, 0.05342289f, -0.01725061f, 0.02679605f, -0.05279436f, -0.06036082f, 0.05274457f, -0.01632023f, 
    -0.02266739f, -0.00793672f, -0.00447632f, 0.05162083f, -0.05866056f, -0.03629863f, -0.03474950f, 0.04328603f, 
    -0.02216375f, -0.07904547f, -0.04390018f, 0.05887233f, -0.04740307f, -0.01042953f, -0.06528113f, -0.02632427f, 
    -0.06935735f, 0.01580592f, 0.06844280f, 0.05378002f, -0.04106457f, -0.00037375f, 0.00223133f, -0.00007420f, 
    -0.00405432f, -0.05875893f, -0.03563895f, -0.03707249f, -0.07434498f, -0.02469879f, -0.06815525f, -0.06058127f, 
    -0.03393684f, -0.06988807f, -0.04830030f, 0.04399053f, 0.06148657f, 0.04298579f, 0.00855124f, 0.04588726f, 
    -0.05349656f, -0.00548756f, -0.02387966f, 0.06611975f, 0.00231600f, 0.06787239f, -0.03553022f, -0.03658406f, 
    0.01239985f, 0.03649090f, -0.05775509f, 0.03487283f, -0.03788458f, -0.07044341f, -0.03986058f, 0.06389479f, 
    -0.00426979f, 0.00583750f, 0.06712385f, -0.04547408f, 0.02251530f, -0.01838366f, -0.00925855f, -0.03917591f, 
    0.04971310f, 0.02796028f, -0.06579656f, -0.02516917f, -0.04197677f, -0.05358997f, 0.00327607f, -0.01147786f, 
    -0.29553246f, 0.02162094f, -0.14817785f, -0.27919343f, 0.12736358f, 0.04776652f, -0.03182437f, 0.00319839f, 
    0.07886502f, 0.06556551f, -0.10342652f, 0.11360066f, -0.16699229f, 0.06163352f, 0.23888600f, -0.12228473f, 
    0.04449993f, -0.09945922f, 0.02090006f, 0.03035929f, -0.01389312f, 0.08600517f, -0.06084112f, 0.02095683f, 
    0.12804478f, -0.06071768f, 0.02765655f, -0.25867581f, 0.11743835f, 0.01406473f, -0.15585038f, -0.07989508f, 
    0.01933390f, 0.00078412f, 0.08932553f, -0.04464768f, -0.05678836f, -0.01043369f, -0.12346547f, -0.25516748f, 
    0.01367992f, -0.03480331f, -0.06700543f, -0.01953411f, 0.08023727f, 0.00864254f, -0.06508749f, 0.01197150f, 
    0.06801291f, 0.11791192f, -0.33173713f, 0.49637467f, 0.10657304f, -0.12891766f, -0.11167368f, -0.06465130f, 
    0.12522103f, 0.04392130f, -0.03017558f, -0.13415782f, 0.30023476f, 0.15776250f, -0.07503583f, 0.07549715f, 
    -0.00647755f, 0.03983863f, -0.10342222f, -0.22397858f, 0.09158123f, 0.04597294f, 0.02126320f, 0.05866559f, 
    -0.04392825f, -0.08360763f, -0.02592574f, 0.18617029f, -0.08351010f, -0.12422778f, 0.03303456f, -0.03803203f, 
    0.04599057f, 0.05069974f, 0.12466649f, -0.12441394f, -0.05280178f, 0.20386778f, -0.12907398f, 0.30513144f, 
    -0.02457915f, -0.06925551f, 0.01078463f, -0.04107129f, 0.15983717f, -0.05737783f, -0.05414173f, 0.08244596f, 
    -0.04090296f, 0.13534975f, 0.04263701f, 0.27934799f, -0.10566328f, -0.04220920f, -0.03841661f, 0.04391657f, 
    0.01762424f, 0.14573410f, -0.05074390f, -0.03688862f, -0.09627256f, -0.01091655f, 0.02329260f, 0.34565815f, 
    -0.04482370f, -0.08343347f, 0.08181153f, 0.10778002f, 0.04074895f, 0.03358643f, 0.01578387f, 0.05636551f, 
    -0.13169052f, -0.05108199f, -0.11889799f, 0.16405562f, 0.05760345f, 0.07433177f, 0.04767758f, -0.02640564f, 
    0.10211442f, -0.06648132f, -0.01283070f, -0.00508237f, -0.19529879f, 0.02584793f, -0.00325895f, 0.13288027f, 
    0.17211843f, 0.17796808f, 0.09518113f, 0.02735054f, 0.10526329f, 0.12445930f, 0.15646508f, 0.09205859f, 
    -0.06455874f, 0.08810193f, 0.00635400f, 0.11931854f, -0.00811569f, -0.05074619f, 0.09735020f, -0.03606533f, 
    -0.01535557f, -0.09485404f, 0.12932391f, 0.04223199f, -0.13298789f, -0.01582277f, 0.07089782f, 0.07780573f, 
    0.00464605f, 0.12482483f, 0.12238497f, 0.00140853f, -0.00994348f, -0.04442576f, 0.08321895f, 0.03596947f, 
    0.13709496f, 0.18285213f, 0.10594043f, -0.09688219f, 0.02664229f, 0.09149487f, 0.05064457f, 0.15487783f, 
    0.05851362f, -0.04353173f, -0.08759114f, 0.06599264f, -0.24619955f, 0.32527566f, 0.02220016f, -0.23381148f, 
    0.19605707f, 0.06330869f, -0.06823719f, 0.08199905f, -0.05376609f, 0.01610027f, -0.05085022f, 0.02750256f, 
    0.01408483f, -0.12323190f, -0.06250221f, 0.34183291f, 0.14914243f, 0.02676048f, 0.02762000f, -0.06342967f, 
    0.11887256f, -0.03282470f, 0.07050272f, 0.06895780f, -0.26420876f, -0.11890739f, 0.37898126f, 0.18526125f, 
    0.04129083f, -0.03800267f, 0.03260790f, 0.11946195f, -0.08291874f, 0.03131262f, 0.11648076f, 0.15327388f, 
    0.06312881f, -0.22417650f, 0.07071649f, 0.32870027f, 0.00441106f, -0.05821199f, -0.07012159f, 0.05771973f, 
    0.07204559f, 0.11811370f, 0.13550578f, 0.16446450f, -0.27230209f, -0.19125505f, -0.08105528f, 0.07006776f, 
    0.05588556f, -0.06363770f, 0.00151079f, 0.03793925f, 0.14922321f, -0.01645484f, -0.08361793f, -0.01509239f, 
    -0.00320903f, 0.10897194f, 0.01009159f, 0.09385308f, 0.03750052f, -0.12070762f, 0.13400613f, 0.10247608f, 
    0.04339539f, 0.15249446f, 0.08623479f, -0.01867771f, 0.05113547f, 0.27715087f, -0.09753645f, -0.14479816f, 
    0.00437839f, -0.03636691f, -0.11793475f, 0.01211392f, 0.16496053f, -0.05560048f, 0.19783017f, 0.21095705f, 
    -0.16019894f, 0.31623957f, -0.06275846f, 0.02814653f, -0.15365955f, -0.08362740f, 0.11536004f, -0.10550702f, 
    0.09388988f, -0.02426961f, 0.08167097f, -0.16154262f, 0.25406352f, 0.00918105f, 0.02633902f, 0.16836114f, 
    -0.00035250f, -0.00814075f, -0.00626118f, -0.05441663f, 0.10248686f, -0.06264969f, -0.09042034f, -0.01045147f, 
    -0.17497002f, 0.10979962f, 0.06033523f, 0.33712783f, -0.03668679f, -0.10994142f, -0.05941401f, 0.18790340f, 
    0.05204546f, 0.18179196f, -0.12079962f, -0.01842536f, -0.00181800f, 0.46468198f, 0.04021659f, 0.06600522f, 
    -0.12335006f, -0.05894871f, -0.01124021f, -0.05008824f, -0.02746887f, 0.02025096f, -0.02431164f, 0.02700000f, 
    0.05766883f, -0.20877683f, -0.22295710f, -0.10468973f, 0.12366415f, -0.08264843f, 0.06632593f, -0.06052585f, 
    -0.00646511f, -0.08010675f, 0.09209406f, 0.05452052f, 0.05143802f, -0.25243080f, -0.03453836f, -0.09513871f, 
    0.01855411f, -0.03051547f, 0.12319900f, -0.09155187f, 0.08244887f, -0.02978143f, -0.04680013f, -0.02522855f, 
    -0.14759454f, -0.07314106f, 0.05708243f, 0.16443914f, -0.10309742f, -0.08861921f, 0.12027123f, -0.07375658f, 
    -0.04253222f, -0.04752091f, -0.02814859f, 0.01509188f, -0.05427874f, 0.03021304f, -0.15123785f, -0.16431804f, 
    -0.16916093f, 0.07514372f, 0.01901339f, 0.02281392f, 0.11506747f, 0.04088792f, -0.12730570f, 0.01297971f, 
    -0.20198488f, 0.06679301f, -0.13564458f, 0.14846860f, 0.12595804f, 0.04785340f, 0.00985545f, 0.14800140f, 
    0.00305031f, -0.06888241f, -0.01748763f, 0.17457649f, -0.28726050f, 0.14890565f, 0.05794476f, -0.04576527f, 
    0.23263429f, 0.07506929f, -0.07115877f, 0.10001225f, 0.01843841f, -0.00943962f, -0.09062003f, 0.01322835f, 
    -0.15420428f, -0.18782789f, -0.27228642f, -0.22337621f, 0.20802423f, -0.28717315f, -0.04811237f, -0.12180641f, 
    -0.02672590f, 0.03523825f, -0.03294050f, 0.09370852f, -0.05702791f, -0.06110888f, -0.06377994f, -0.20271564f, 
    -0.00532225f, -0.18404292f, 0.05279804f, -0.11350051f, -0.06078720f, 0.02156201f, -0.07301549f, -0.05490579f, 
    0.08016953f, -0.17755039f, -0.28725088f, -0.07326715f, -0.05434678f, -0.20475978f, -0.09974222f, -0.14899954f, 
    0.00036245f, 0.01164973f, 0.17542757f, -0.00440309f, 0.34773526f, 0.03357788f, -0.11273865f, 0.05460019f, 
    -0.10992423f, 0.11243653f, -0.10423281f, 0.04114102f, -0.16469252f, 0.13729607f, 0.24560301f, -0.06245705f, 
    -0.11597838f, 0.19040534f, 0.05639628f, 0.14287002f, 0.07506756f, 0.03537683f, -0.09457961f, -0.03649541f, 
    -0.01118209f, -0.04580932f, 0.04585770f, 0.03667489f, 0.27457532f, 0.05691111f, 0.08059369f, 0.06953116f, 
    0.06225179f, 0.11307576f, 0.05662931f, 0.01593621f, 0.04072963f, -0.08514523f, -0.04686495f, -0.05585134f, 
    0.25553831f, -0.11590973f, 0.10510040f, 0.20577604f, 0.05591157f, -0.02146395f, 0.08974861f, 0.15637110f, 
    -0.18329923f, 0.10780074f, 0.04582059f, -0.04386874f, 0.12562396f, 0.03828186f, 0.10212220f, 0.16144744f, 
    0.08665210f, -0.05424069f, -0.08478042f, -0.07394254f, 0.00336171f, 0.12852390f, -0.01255076f, 0.00638816f, 
    0.25784796f, 0.08491223f, 0.20309155f, 0.03503700f, 0.04017249f, 0.07151944f, 0.03418356f, 0.03578841f, 
    0.03967830f, -0.01429264f, -0.13990548f, 0.14299724f, 0.16842447f, -0.01115667f, -0.00241162f, 0.11209015f, 
    0.03955152f, 0.08368771f, 0.09629538f, 0.19208221f, -0.10227594f, -0.00331038f, -0.05344885f, 0.02426087f, 
    -0.20842628f, 0.13701312f, 0.07185973f, -0.24750839f, 0.00763649f, -0.11976352f, -0.04120646f, -0.01618869f, 
    0.11504908f, 0.01677950f, -0.00688010f, 0.10097019f, -0.17572787f, -0.06984865f, -0.11731417f, -0.09088220f, 
    0.01925232f, -0.16796085f, 0.01595427f, -0.15399437f, -0.04046308f, 0.07293680f, 0.06706278f, -0.08050502f, 
    0.24897324f, 0.10550848f, 0.11142371f, 0.23636827f, 0.10505866f, 0.05864756f, 0.08080069f, 0.07764287f, 
    -0.09581390f, 0.12590216f, -0.09535319f, -0.02642396f, -0.08624561f, 0.10542478f, 0.20078205f, 0.22228761f, 
    0.11486781f, 0.15634367f, -0.03316273f, 0.02493974f, -0.13311943f, -0.08981898f, 0.08934817f, -0.02147089f, 
    0.12063881f, -0.03135430f, -0.01092333f, -0.19144040f, 0.06924713f, -0.11836434f, -0.18957961f, -0.02133649f, 
    -0.03719747f, 0.04263413f, 0.13733689f, -0.15660475f, 0.29328406f, 0.00253396f, -0.05701556f, -0.17970769f, 
    -0.06258359f, 0.04707690f, 0.02561378f, -0.06628270f, -0.09836787f, -0.00074150f, -0.03631816f, -0.00609880f, 
    0.18861125f, -0.00466674f, -0.11119332f, 0.27956781f, 0.03139383f, 0.05539040f, 0.00306395f, 0.14978011f, 
    0.06300359f, -0.09504130f, 0.03936632f, -0.02389713f, -0.02109617f, 0.04001075f, 0.03435316f, 0.12488353f, 
    0.03911797f, -0.09573310f, -0.13198464f, -0.01145718f, 0.00367626f, 0.19084735f, 0.08499550f, 0.12678544f, 
    0.19130802f, -0.00138706f, 0.12414521f, 0.20174403f, -0.08728225f, 0.02677346f, 0.12729934f, 0.02182926f, 
    0.15969279f, 0.03369621f, 0.01256381f, 0.06944143f, -0.14339547f, -0.00632876f, 0.01273333f, -0.04112694f, 
    0.03050054f, -0.16921979f, 0.00083672f, 0.00980807f, 0.13523535f, -0.15771763f, 0.05184656f, -0.03960580f, 
    0.23201513f, -0.19927643f, -0.00630964f, 0.02946153f, 0.01256808f, 0.03231242f, 0.10599838f, -0.01553407f, 
    -0.01878746f, 0.12081974f, 0.02134721f, -0.08182255f, 0.04163717f, 0.17404902f, -0.19643627f, -0.10463002f, 
    0.12715210f, 0.07020010f, 0.11917946f, 0.13452156f, 0.08704717f, -0.02273855f, 0.03687551f, 0.14874719f, 
    0.14545794f, 0.02865191f, -0.09807380f, -0.05054091f, 0.04163043f, 0.09581590f, -0.01862615f, -0.04809812f, 
    0.20844966f, 0.03132528f, 0.21823350f, -0.08390938f, 0.00833413f, -0.04032376f, 0.13905765f, 0.05116108f, 
    0.12552446f, -0.16347642f, 0.06838643f, -0.04632833f, -0.01034055f, -0.00896847f, -0.00557316f, 0.06090265f, 
    0.07799014f, 0.04059882f, -0.02673480f, 0.30602831f, -0.01503307f, -0.03262901f, 0.04107963f, 0.11419131f, 
    0.09846442f, 0.15537874f, -0.13887109f, 0.07293265f, 0.10976125f, 0.27357230f, 0.11361131f, -0.08467462f, 
    -0.02871196f, 0.03882624f, -0.07911924f, -0.03436487f, 0.02193949f, -0.07474903f, 0.10532952f, -0.03029450f, 
    0.29584295f, -0.29344285f, -0.15712167f, -0.24015668f, 0.06997471f, -0.16522472f, -0.02079894f, -0.11901996f, 
    0.02149600f, 0.06792179f, -0.00514731f, 0.01466749f, -0.00871044f, -0.23538734f, 0.05126994f, -0.09660952f, 
    0.17138165f, -0.21057139f, -0.08105992f, -0.25320858f, -0.00125079f, -0.11230043f, 0.05194949f, -0.02149159f, 
    0.18575253f, -0.06515367f, 0.09254352f, 0.07311009f, 0.10834130f, -0.04189067f, 0.20406345f, -0.01555247f, 
    -0.11049668f, -0.24122521f, -0.00130271f, 0.00640530f, -0.35152110f, -0.08923990f, -0.12400330f, -0.25257766f, 
    0.06458584f, 0.08790121f, -0.05173886f, -0.02708135f, 0.10727660f, 0.10124745f, -0.02103576f, -0.10942435f, 
    -0.18662851f, -0.11260153f, -0.06701344f, 0.02204679f, 0.00272303f, -0.08946170f, 0.01857715f, 0.02149070f, 
    -0.04757567f, -0.00072259f, -0.03246568f, 0.00970992f, -0.33521986f, -0.05638162f, -0.03900107f, 0.08049735f, 
    0.08460782f, 0.12679632f, 0.00905046f, -0.02456276f, -0.08383599f, 0.04307131f, -0.10487154f, 0.01150173f, 
    0.05405357f, -0.06256837f, 0.02205322f, -0.06085516f, -0.07108139f, 0.01093347f, 0.05143570f, 0.00750573f, 
    -0.00467156f, -0.06778446f, -0.00744663f, -0.03730126f, 0.04276516f, 0.01095698f, 0.04059019f, 0.05261768f, 
    0.01321760f, -0.02424996f, 0.02159310f, -0.03616714f, -0.04405186f, -0.06805262f, -0.02717457f, -0.02809015f, 
    0.01947522f, -0.00949983f, 0.03034731f, -0.06266969f, 0.03545834f, 0.02980670f, 0.01579408f, 0.02682329f, 
    0.01098242f, 0.05763192f, 0.02966312f, -0.02768228f, -0.00959963f, -0.05121043f, -0.02213441f, -0.06163723f, 
    -0.05815762f, -0.03758369f, -0.08131424f, -0.04202412f, 0.07488759f, -0.00601368f, -0.00291177f, 0.01165746f, 
    0.00983655f, 0.05620696f, 0.00880447f, 0.03188410f, -0.05071829f, -0.05355544f, -0.00885354f, 0.04309214f, 
    -0.02453840f, -0.07310878f, -0.05405257f, -0.06070569f, 0.04773410f, 0.03445410f, 0.01002227f, -0.08125343f, 
    -0.02305789f, -0.07059709f, 0.02003315f, 0.04528036f, 0.02189215f, -0.01285389f, -0.02407813f, -0.05111327f, 
    -0.03839498f, 0.01932012f, -0.02741514f, -0.06148540f, 0.02037408f, 0.04824916f, 0.04259003f, -0.01035541f, 
    -0.03479280f, -0.00654054f, -0.05006509f, -0.04571733f, 0.03975312f, -0.04619650f, -0.07808214f, -0.06379127f, 
    0.01785585f, 0.00621833f, -0.06835110f, -0.07474504f, -0.04802097f, -0.07457452f, -0.03384236f, 0.02708902f, 
    -0.01487408f, 0.03639794f, -0.03160353f, 0.04120874f, -0.06584100f, 0.01368396f, -0.00486276f, -0.04104232f, 
    -0.03417600f, -0.00995485f, -0.03312993f, 0.06670749f, -0.06606156f, 0.00762917f, 0.02813428f, -0.07047828f, 
    -0.04583435f, -0.01143644f, -0.03501554f, -0.02264024f, 0.00299630f, -0.01162772f, -0.03477606f, -0.04361390f, 
    -0.01236954f, -0.05059064f, -0.01307036f, -0.03583799f, 0.01104918f, 0.02350754f, -0.07484351f, 0.00138798f, 
    0.05202635f, 0.04940188f, -0.06038110f, -0.06713364f, -0.02463404f, 0.02378852f, -0.05385191f, 0.01677550f, 
    -0.01326173f, 0.00032158f, -0.04519048f, 0.02152522f, -0.00562266f, 0.04527044f, -0.00133712f, -0.03966075f, 
    -0.02426333f, -0.05060460f, 0.05695593f, -0.05069746f, -0.00433429f, 0.05215057f, -0.02338938f, -0.01987195f, 
    -0.05277403f, 0.05558401f, 0.04457736f, 0.04857823f, 0.05828163f, -0.01321200f, 0.03514696f, 0.03249896f, 
    -0.02285133f, 0.01190210f, 0.02631130f, -0.01300472f, 0.01974200f, 0.03314195f, 0.01529537f, 0.00573306f, 
    -0.03058507f, 0.06457346f, 0.01893328f, -0.03072920f, 0.04560618f, 0.01897047f, -0.04961135f, 0.01259457f, 
    0.01255360f, -0.03213852f, 0.04745507f, 0.01649791f, -0.02605669f, -0.03152387f, 0.00357501f, -0.06344090f, 
    0.04282799f, 0.02421840f, -0.05259512f, -0.05075040f, -0.02106226f, -0.03114693f, -0.05393694f, -0.06808548f, 
    0.06040016f, -0.02075441f, -0.06186302f, -0.06015639f, -0.05289043f, 0.00082100f, -0.04685865f, -0.04131506f, 
    -0.04152533f, -0.03117936f, 0.03513114f, -0.06795356f, -0.04578971f, -0.05961883f, -0.04635638f, -0.00947745f, 
    -0.02109957f, -0.05265978f, 0.03406855f, 0.04129324f, 0.01630387f, -0.00800075f, -0.06842311f, -0.01264672f, 
    -0.05963435f, -0.04602229f, 0.03805031f, -0.02225197f, -0.00227617f, 0.07271217f, 0.05493045f, -0.01335149f, 
    -0.00414974f, -0.00221237f, -0.07560115f, -0.04042073f, -0.01347553f, 0.00804426f, 0.00729660f, -0.04238411f, 
    -0.08252670f, -0.04127286f, -0.07376292f, -0.02242691f, 0.04120855f, 0.03826164f, -0.05454930f, 0.01983855f, 
    0.03068765f, -0.00439961f, 0.02282011f, -0.06503323f, -0.03482163f, -0.04604947f, 0.01945605f, 0.00259845f, 
    0.04100120f, -0.05630592f, 0.02801425f, -0.06505454f, -0.07612894f, -0.07217731f, -0.05603128f, -0.02877872f, 
    -0.05129770f, -0.04548169f, 0.01509784f, -0.07554669f, 0.00589955f, 0.01524846f, 0.02476419f, -0.06373114f, 
    -0.06403586f, -0.05525713f, -0.02014547f, 0.03643456f, 0.03717758f, -0.00222341f, 0.05181966f, 0.05450692f, 
    0.04059369f, 0.01897774f, -0.04079165f, -0.05036328f, 0.06618864f, -0.01475515f, 0.05290294f, 0.05278968f, 
    -0.03107913f, 0.06158835f, -0.04940218f, -0.00558919f, -0.00359108f, -0.04293941f, 0.02428182f, -0.05136517f, 
    -0.06027280f, -0.04610683f, 0.01991123f, 0.04263193f, -0.05981172f, -0.05698516f, -0.00446386f, -0.00862580f, 
    0.04738075f, -0.05153427f, 0.05039436f, -0.04593853f, -0.01007169f, 0.02333676f, -0.03969051f, -0.03262703f, 
    -0.02019439f, 0.03919931f, -0.03260460f, -0.05520160f, -0.02905211f, -0.00083428f, 0.05785601f, 0.02578069f, 
    0.00325068f, -0.06087209f, -0.04627971f, -0.05853822f, -0.04253537f, 0.01910528f, 0.03031976f, -0.06229988f, 
    -0.05533063f, -0.04993655f, 0.03835808f, 0.01295728f, 0.03062796f, 0.01264426f, 0.03835824f, 0.02332922f, 
    -0.02806333f, -0.04244835f, 0.01899198f, -0.03044140f, -0.00246421f, 0.06196200f, 0.04749965f, 0.02595307f, 
    -0.07479334f, -0.02866210f, -0.05855654f, -0.06948747f, 0.04126160f, 0.01040062f, 0.03710186f, -0.01170130f, 
    0.04592089f, 0.01307778f, -0.02480876f, -0.04578243f, -0.03466782f, 0.02160213f, -0.01367603f, -0.01837473f, 
    -0.03881330f, 0.01533509f, -0.01788869f, -0.03083314f, -0.05180075f, -0.07787545f, -0.05263210f, -0.00014289f, 
    0.04702894f, -0.00394069f, -0.04908288f, 0.02590461f, -0.04133873f, -0.03385248f, -0.08480473f, -0.00365635f, 
    -0.06185697f, 0.01602082f, -0.03089963f, 0.05665452f, 0.02766263f, -0.05094010f, -0.02107903f, -0.05991496f, 
    0.03772185f, -0.00893190f, 0.01500354f, -0.00246857f, 0.01535225f, -0.03982731f, 0.01850213f, 0.03485283f, 
    0.29804310f, 0.08292595f, 0.07998997f, 0.41154978f, -0.05387065f, -0.00311254f, -0.03956221f, -0.01374150f, 
    0.02416565f, -0.01409438f, 0.06539856f, -0.15065853f, -0.00962510f, -0.09906729f, 0.02016492f, 0.13941702f, 
    0.01129831f, 0.01310451f, 0.07896069f, 0.09012044f, 0.01646953f, 0.03145996f, -0.02121257f, 0.09801465f, 
    0.21787840f, -0.04306028f, 0.07698716f, 0.50095457f, -0.10080077f, 0.00339563f, 0.11585525f, 0.06109693f, 
    0.08362447f, 0.13585952f, 0.01365145f, 0.08021579f, -0.03933072f, 0.09922548f, 0.16472907f, 0.06338248f, 
    -0.07732767f, -0.00326552f, 0.07738291f, 0.10968427f, 0.05892624f, -0.06958148f, 0.07076854f, 0.00082330f, 
    0.11751159f, 0.12538202f, 0.08037461f, -0.27288282f, -0.09927911f, -0.00947214f, -0.00708144f, 0.03018827f, 
    0.11616138f, 0.08863254f, 0.10616641f, 0.06722879f, -0.11293116f, 0.09370191f, 0.10549350f, -0.18940064f, 
    0.02615952f, 0.04626051f, 0.06558333f, 0.18215607f, -0.00293791f, -0.07432144f, 0.04397743f, -0.02554863f, 
    -0.01707123f, 0.17867148f, -0.06477818f, -0.06139665f, -0.02781617f, 0.14201792f, -0.02758925f, 0.03372172f, 
    0.04176290f, 0.02368283f, 0.11317486f, -0.07892932f, -0.04418318f, -0.06483442f, 0.09699716f, -0.14473824f, 
    -0.02911483f, -0.08458199f, -0.01832966f, -0.08812097f, 0.03646138f, 0.13128927f, 0.05037979f, -0.02442026f, 
    0.02291248f, 0.01108144f, 0.01850594f, 0.04093471f, -0.01863920f, -0.03723320f, 0.00392696f, 0.11268868f, 
    0.14091016f, 0.06883456f, -0.10873834f, -0.08709148f, -0.00625526f, 0.36614892f, -0.04959542f, -0.04254454f, 
    -0.05107218f, -0.00618082f, -0.17994963f, 0.05195038f, 0.14375694f, -0.05793868f, 0.04639715f, 0.03327920f, 
    0.22069052f, 0.05695714f, -0.08577551f, -0.13968168f, 0.07372816f, 0.00231573f, -0.03560472f, -0.09119740f, 
    -0.00534893f, 0.02755120f, 0.02725226f, 0.08764687f, 0.18413852f, -0.00163849f, -0.00315715f, -0.21683916f, 
    -0.04015714f, -0.08954296f, -0.11303441f, 0.01907434f, -0.04859012f, -0.05359548f, -0.12757833f, -0.03187383f, 
    0.00892652f, 0.03209579f, 0.06675997f, 0.00892909f, 0.03235697f, 0.09867728f, 0.07235084f, -0.09671277f, 
    -0.10380827f, -0.02282571f, -0.02123229f, 0.03419157f, -0.27322325f, 0.04372033f, -0.03265612f, -0.20885956f, 
    -0.02706295f, -0.04214189f, 0.01889102f, -0.00174996f, 0.09589302f, 0.05537618f, -0.15061109f, -0.02369597f, 
    -0.22838134f, -0.28613734f, -0.14164309f, -0.04684969f, 0.03869678f, -0.07847221f, 0.00993204f, -0.12817441f, 
    -0.00388304f, 0.07341896f, 0.04465295f, 0.10432253f, 0.00944600f, -0.11904917f, 0.09588411f, 0.05288089f, 
    0.08107422f, -0.04087416f, 0.01107251f, -0.03927569f, 0.01555030f, 0.10265810f, -0.07503366f, 0.00298699f, 
    -0.04550527f, 0.04119225f, -0.05558749f, 0.01934323f, -0.00691375f, 0.06026971f, 0.02513993f, -0.02658293f, 
    0.05563747f, -0.01815524f, 0.00513900f, 0.01426821f, -0.00477134f, -0.06014683f, -0.03221659f, 0.05064346f, 
    0.05912669f, -0.06891279f, 0.02390526f, 0.06036653f, -0.02193866f, -0.05678488f, 0.04447684f, 0.00148454f, 
    0.03088813f, -0.02872736f, 0.06316601f, -0.06470483f, 0.06789604f, -0.07515623f, 0.04187294f, -0.00684633f, 
    0.05163800f, -0.00197530f, 0.05916435f, -0.01642508f, -0.00978633f, -0.02328416f, 0.05593326f, -0.06813607f, 
    0.05151544f, 0.00915649f, 0.00421552f, 0.03816402f, -0.03161121f, -0.00656822f, 0.03956080f, -0.00405822f, 
    -0.04031475f, 0.06305546f, -0.04673255f, -0.01299936f, 0.00571649f, 0.00035608f, -0.01651954f, 0.03520218f, 
    -0.06970277f, 0.03225213f, -0.02649121f, -0.04567652f, -0.01724832f, -0.07736021f, -0.02283509f, -0.00760320f, 
    -0.04516378f, 0.00335071f, -0.07406999f, -0.06718466f, -0.07270525f, -0.03384098f, 0.03265067f, -0.04360114f, 
    0.05401878f, -0.01054113f, -0.03305641f, -0.07354321f, -0.07555687f, -0.01120678f, -0.07395681f, 0.03031749f, 
    0.04303082f, -0.02470582f, -0.05245087f, -0.00744208f, -0.05697479f, 0.02576733f, 0.02447098f, 0.01371909f, 
    -0.04455432f, 0.04242777f, -0.01598136f, -0.04261568f, -0.04754329f, 0.01399702f, -0.05770462f, -0.07706449f, 
    -0.07936518f, -0.02303602f, 0.03900592f, -0.01155793f, 0.02527573f, -0.01223766f, -0.06007268f, -0.05818255f, 
    0.06564564f, -0.01065343f, 0.06444962f, -0.01033785f, 0.01284723f, 0.01479561f, 0.02632580f, -0.04176792f, 
    -0.03742921f, -0.05710052f, 0.00206652f, -0.00874858f, 0.01247971f, 0.03864439f, -0.05150861f, -0.01750796f, 
    -0.03898792f, -0.05918100f, -0.00343653f, 0.05304899f, -0.06366575f, -0.03106130f, -0.02260210f, -0.06646354f, 
    0.05770807f, 0.04531740f, -0.00679736f, 0.01765856f, -0.03993051f, -0.07247319f, -0.00999200f, -0.03118189f, 
    -0.00859043f, -0.03756980f, 0.02685350f, -0.07269057f, -0.02354216f, -0.04326535f, -0.00818727f, 0.04308586f, 
    0.02351610f, 0.00153970f, -0.02466454f, -0.02795837f, 0.01254038f, 0.02509499f, 0.05239457f, -0.06184179f, 
    0.01028743f, 0.02306541f, -0.06494719f, 0.02872859f, 0.00898593f, -0.07269499f, -0.00954651f, 0.03208793f, 
    -0.00004593f, -0.07366749f, -0.06010595f, -0.04577869f, 0.04546677f, 0.04793301f, 0.02843735f, -0.04716866f, 
    -0.02452002f, -0.05397119f, -0.06123668f, -0.08300072f, 0.03393248f, -0.03203193f, -0.05162561f, 0.03968246f, 
    0.04862227f, 0.01130828f, -0.00185982f, 0.04629952f, 0.01176528f, 0.04215907f, 0.01857498f, -0.07092322f, 
    -0.00711620f, 0.06304161f, -0.03755027f, 0.05583045f, -0.06720696f, 0.04346599f, -0.01148349f, -0.02542236f, 
    0.27786073f, -0.10347895f, 0.20467536f, 0.31932366f, -0.08680123f, 0.11404350f, 0.03214261f, 0.05509017f, 
    0.07965333f, 0.09655447f, 0.04017752f, -0.03443366f, 0.11542393f, 0.12370133f, -0.24952906f, 0.13082480f, 
    0.12821788f, 0.06459270f, 0.06053748f, 0.17002566f, 0.06606473f, 0.00883021f, -0.02068594f, -0.02423622f, 
    -0.39770764f, 0.23361857f, 0.28138208f, 0.24499661f, 0.01169924f, 0.10093801f, 0.03572864f, 0.00157123f, 
    0.08245679f, -0.04038097f, -0.01171395f, 0.08080568f, 0.15354531f, 0.24307060f, 0.14766473f, 0.19450958f, 
    -0.07846410f, 0.06090453f, -0.06594613f, 0.01922729f, 0.03608906f, -0.00383783f, -0.08851533f, -0.04172323f, 
    -0.13509791f, 0.20420337f, 0.15570082f, -0.30222869f, -0.10777992f, 0.09515820f, 0.03757312f, 0.05368522f, 
    -0.04698317f, -0.05885176f, 0.08071948f, 0.00817971f, -0.09107050f, -0.06496735f, 0.02641121f, -0.18723631f, 
    -0.04839585f, -0.07852818f, -0.06605746f, 0.13841420f, -0.09513784f, -0.00357907f, -0.04260691f, 0.10049111f, 
    -0.10714087f, 0.10154341f, -0.11350725f, -0.02871645f, 0.07090519f, 0.04958794f, 0.06607071f, -0.09919251f, 
    0.04475786f, 0.02837835f, -0.11258069f, 0.05502852f, 0.08823285f, 0.01355700f, 0.13293783f, -0.15821803f, 
    -0.01590363f, 0.16445847f, 0.02983708f, 0.00603658f, 0.14354004f, 0.09626398f, 0.00643086f, -0.04042234f, 
    0.03925408f, -0.15133812f, -0.09421784f, -0.06398211f, -0.03730205f, 0.02101269f, -0.07056078f, -0.02420720f, 
    -0.01063213f, -0.09130121f, 0.00878341f, -0.04573643f, 0.07339619f, 0.07315922f, 0.08719101f, -0.16871603f, 
    -0.06325169f, 0.00556678f, -0.08834361f, -0.00070362f, 0.11007842f, -0.03420065f, 0.05306054f, 0.07881649f, 
    0.26123691f, 0.02801156f, 0.06175136f, -0.02157616f, -0.15303192f, -0.03092293f, -0.02342772f, -0.05856882f, 
    -0.00872832f, -0.08428137f, -0.00804326f, 0.00733616f, 0.24364747f, -0.09732345f, -0.09311948f, 0.00707998f, 
    -0.02357301f, 0.06639187f, 0.02629662f, -0.00194681f, 0.00255132f, 0.07450172f, -0.14295241f, 0.01117686f, 
    -0.01437794f, -0.09408250f, 0.02229501f, 0.20253673f, -0.03695379f, 0.10289027f, -0.00060426f, 0.06514457f, 
    0.05878093f, -0.06528226f, 0.07341761f, 0.10525577f, 0.11817080f, 0.01996732f, 0.00433533f, -0.21561639f, 
    0.07290653f, -0.13533509f, 0.04223211f, 0.20336080f, 0.01703586f, -0.00631861f, -0.05409811f, 0.02160576f, 
    -0.39607158f, -0.18448377f, -0.04298060f, 0.18856654f, -0.02235887f, 0.10827660f, 0.03497340f, -0.03692629f, 
    0.02133624f, -0.04847693f, -0.05112610f, -0.05318139f, 0.30211112f, -0.21952410f, -0.12642851f, 0.18261163f, 
    -0.21129544f, 0.01334874f, -0.12735575f, 0.01396191f, -0.02524382f, 0.04588062f, -0.03994754f, 0.05510846f, 
    0.07345828f, 0.37430513f, 0.30876231f, 0.04300226f, -0.08053872f, 0.03380802f, -0.06540839f, -0.11490460f, 
    -0.04942816f, -0.02042482f, -0.03118135f, -0.03866229f, 0.14861214f, 0.21020930f, 0.05958481f, -0.02213446f, 
    0.02831480f, -0.11892201f, -0.11358504f, 0.08211504f, -0.00077453f, 0.22166641f, -0.12808189f, -0.01094246f, 
    -0.25134906f, 0.18507881f, 0.41956395f, 0.14294559f, 0.06207160f, 0.01727970f, -0.05216900f, 0.02950167f, 
    0.09450706f, 0.11587176f, -0.04737874f, 0.00738252f, -0.21536826f, 0.24491805f, 0.22539620f, -0.24137315f, 
    -0.08829492f, 0.20996268f, 0.13253853f, -0.00728953f, -0.08258155f, -0.10969408f, -0.03118259f, 0.15073267f, 
    -0.29622027f, 0.02911629f, -0.19612844f, 0.00043777f, 0.07981692f, 0.14344344f, -0.10390710f, 0.07073161f, 
    0.08098622f, -0.01113858f, -0.00535098f, -0.07812583f, -0.34840366f, -0.37920853f, -0.24205019f, -0.09118770f, 
    0.11277399f, 0.21853806f, 0.22537512f, -0.07887100f, -0.21454290f, 0.13047585f, 0.00049353f, 0.11821212f, 
    -0.06809907f, -0.36665216f, -0.07786027f, 0.09059916f, 0.05881415f, -0.00248091f, -0.02201247f, -0.00275012f, 
    0.08439546f, -0.04564341f, 0.02266708f, 0.05493627f, -0.19125974f, 0.19396269f, -0.08676095f, -0.37429720f, 
    -0.07484707f, 0.09888726f, 0.16297716f, 0.07327383f, 0.05470433f, -0.07687391f, 0.07405900f, 0.04596170f, 
    -0.07639766f, -0.17121477f, -0.31471723f, -0.10267515f, 0.18235569f, 0.06564683f, 0.14270815f, 0.00604141f, 
    0.00801577f, 0.05579276f, -0.00070469f, -0.00631215f, -0.17763713f, -0.34502396f, -0.06931246f, 0.15860835f, 
    0.07921472f, -0.00779500f, 0.07369913f, 0.10398502f, 0.02601051f, 0.02907981f, 0.21115020f, -0.08987938f, 
    -0.00627299f, 0.26200610f, 0.10768331f, 0.27103338f, 0.07340765f, 0.04066522f, -0.02572686f, 0.08617227f, 
    0.02926385f, -0.02623213f, -0.04896817f, -0.13530332f, -0.23700529f, 0.15029345f, 0.08042470f, 0.26853696f, 
    0.09951781f, 0.08684173f, -0.07455274f, -0.07136253f, 0.31712601f, -0.03870216f, 0.05897933f, -0.04747158f, 
    -0.13555945f, -0.25190035f, -0.03946536f, -0.08938494f, 0.06883043f, 0.02256208f, -0.02561315f, -0.03782238f, 
    -0.03651861f, -0.07582901f, 0.04910975f, 0.13105744f, -0.34200546f, -0.12134808f, -0.04130869f, -0.05661396f, 
    0.00734672f, -0.11818381f, 0.10461118f, 0.04181594f, -0.03049070f, 0.01418089f, 0.01616396f, 0.22859852f, 
    0.04956877f, 0.06524514f, 0.19050168f, -0.06101778f, 0.03659525f, -0.01763779f, 0.01255989f, -0.06759273f, 
    0.01267533f, -0.01249610f, 0.15592548f, -0.07205508f, 0.15557469f, -0.18732649f, -0.13434459f, -0.24698624f, 
    -0.00080096f, 0.14334641f, -0.00858056f, 0.20361918f, 0.01995710f, 0.08705917f, 0.17114480f, 0.09431103f, 
    -0.02405494f, 0.01229416f, 0.00874220f, -0.01986249f, -0.00086269f, 0.00997993f, -0.05443346f, 0.03327231f, 
    0.05321926f, -0.04047451f, -0.07478916f, 0.04002434f, -0.00671411f, -0.05158594f, -0.02430532f, -0.06806290f, 
    -0.04461884f, -0.03843659f, 0.02282359f, 0.05044460f, 0.06230087f, -0.03486180f, -0.07482426f, 0.02322896f, 
    0.04005007f, 0.00552756f, -0.07225379f, -0.07315333f, -0.03695560f, 0.02317982f, 0.02842287f, -0.06242431f, 
    0.04648901f, -0.03093020f, -0.02823255f, -0.05305098f, -0.06614285f, -0.03207049f, 0.02020600f, -0.03593266f, 
    0.01589184f, 0.03839342f, 0.02529103f, 0.04147314f, -0.03343260f, 0.04528987f, 0.03626968f, 0.00127316f, 
    -0.04581778f, -0.00839526f, -0.02052503f, 0.02294295f, 0.02296607f, -0.06564344f, 0.04076288f, 0.04243984f, 
    -0.06449184f, -0.07189206f, 0.03840734f, -0.01442793f, 0.01683190f, 0.00199117f, -0.00058197f, 0.02614361f, 
    0.04611890f, 0.05269105f, -0.02257685f, -0.01671223f, -0.01917148f, -0.03576428f, -0.00998344f, -0.00308528f, 
    -0.07933746f, 0.02328520f, -0.07152545f, -0.04953150f, 0.06360701f, -0.06621961f, -0.02920594f, -0.07330659f, 
    -0.03781823f, -0.01229274f, -0.04426720f, -0.07885785f, -0.03692226f, 0.01733991f, 0.00617376f, -0.02104005f, 
    0.04437262f, -0.05062572f, 0.04306154f, 0.02609090f, -0.02554696f, 0.02212174f, -0.04080227f, 0.05139472f, 
    -0.06305496f, -0.00956314f, -0.08017927f, -0.04788691f, -0.04234163f, 0.03753152f, 0.00446293f, -0.03268791f, 
    0.02916886f, 0.05152772f, 0.03402797f, -0.07617511f, -0.00054063f, 0.03213682f, 0.00801327f, -0.03792940f, 
    0.00579102f, 0.03480844f, -0.07599735f, -0.00202412f, -0.04244201f, 0.01959263f, -0.03984773f, 0.05605647f, 
    0.05917988f, 0.04600988f, -0.02725154f, 0.06852224f, 0.01144115f, -0.05465369f, 0.00579491f, 0.02603035f, 
    -0.06781180f, -0.06334350f, -0.02176030f, 0.01651690f, 0.05296727f, -0.05435273f, 0.03409815f, -0.05398322f, 
    -0.05845990f, 0.05276615f, -0.00215914f, -0.05542754f, 0.03858706f, -0.06434371f, -0.04204302f, 0.00659767f, 
    -0.03137705f, -0.02499825f, 0.06386874f, -0.03358219f, -0.05826771f, -0.05685165f, -0.07265268f, -0.02964820f, 
    -0.01587394f, 0.03116205f, 0.04610788f, 0.05437776f, -0.01588906f, -0.02024721f, -0.02759248f, -0.02123691f, 
    0.01241604f, 0.04534126f, -0.01370243f, -0.01187553f, -0.04930657f, -0.02513774f, 0.06182146f, 0.05143178f, 
    0.04908835f, -0.04974390f, 0.04484171f, -0.05467575f, 0.03390256f, -0.07731888f, 0.05055403f, -0.05707219f, 
    -0.01289344f, -0.06142222f, -0.00422710f, 0.02689851f, -0.06751271f, 0.06416200f, -0.05569058f, -0.00096691f, 
    0.00954075f, 0.05445661f, 0.02331622f, 0.03204596f, -0.06219853f, -0.03314103f, 0.04063987f, -0.01273673f, 
    -0.02713698f, -0.07915970f, 0.04771896f, 0.08121631f, -0.08500089f, -0.12316085f, 0.03922574f, -0.10327809f, 
    0.17065197f, 0.02643789f, 0.01976801f, 0.00418267f, -0.09817885f, 0.21610925f, 0.14474811f, 0.03093868f, 
    0.06928875f, 0.00060917f, 0.18080425f, -0.03107361f, 0.04457999f, 0.05505724f, 0.10999751f, 0.06785809f, 
    0.11642713f, -0.07196264f, -0.00320656f, 0.27818215f, 0.06527562f, 0.01374487f, -0.03484858f, -0.00474025f, 
    0.06549427f, -0.04535307f, -0.02386167f, 0.04984718f, 0.23493682f, 0.03585997f, -0.12604772f, -0.00416971f, 
    0.10654923f, 0.02177048f, 0.03493578f, 0.08975915f, 0.05344380f, 0.00278703f, 0.08043069f, 0.01552744f, 
    0.09929965f, 0.21707004f, 0.12759338f, 0.17612770f, 0.02919054f, -0.08565094f, -0.08592587f, 0.08625001f, 
    0.14928761f, 0.02671165f, -0.01059709f, 0.01916447f, -0.05599976f, -0.10658243f, 0.07806625f, 0.10770392f, 
    0.06769636f, 0.04924655f, -0.03402641f, 0.01913236f, 0.04994209f, -0.09604134f, -0.03613555f, 0.14743069f, 
    -0.22063462f, 0.27418271f, -0.00567465f, -0.12945569f, -0.00400224f, 0.07036441f, 0.04969001f, -0.01008426f, 
    -0.05644656f, -0.04892702f, -0.06216971f, 0.01202189f, 0.08057780f, 0.03901011f, -0.01024681f, 0.39626929f, 
    -0.13507858f, -0.06789554f, 0.03282946f, -0.04587658f, 0.05678017f, -0.18089752f, 0.02218424f, 0.04120973f, 
    -0.41470686f, 0.11998402f, -0.11628444f, -0.02711044f, -0.04867659f, 0.01638012f, -0.07665996f, 0.11313315f, 
    0.01361507f, -0.14974093f, -0.00666290f, -0.04008000f, 0.17712000f, 0.10589661f, 0.08821949f, -0.08435227f, 
    -0.13273916f, -0.04853115f, -0.07074106f, -0.06920889f, 0.00912837f, 0.07219262f, 0.03034695f, 0.06335099f, 
    -0.02072722f, 0.03015680f, -0.12565266f, -0.03690463f, 0.00303146f, 0.08743540f, 0.03429969f, 0.03641582f, 
    0.13802476f, -0.00061759f, 0.03168734f, 0.03855280f, 0.20520863f, 0.07090895f, 0.07983940f, 0.05835252f, 
    -0.02498144f, 0.16246194f, 0.05188270f, 0.01033508f, -0.01326357f, -0.02172566f, -0.06126826f, 0.00715748f, 
    -0.39824110f, 0.04121092f, -0.20677789f, 0.01728606f, 0.14686835f, 0.01554045f, 0.09601992f, -0.00005574f, 
    0.10498782f, 0.15037055f, -0.00546687f, -0.00258022f, -0.05693807f, -0.18109116f, 0.16012771f, 0.04346900f, 
    0.11990446f, 0.09683654f, 0.05244206f, 0.19078662f, 0.11409040f, 0.08843692f, -0.00942406f, 0.01638596f, 
    -0.17969081f, 0.00859895f, 0.02074538f, -0.07676670f, -0.01914842f, -0.01979045f, -0.00372403f, 0.13519765f, 
    0.04667501f, 0.07463022f, -0.05908311f, 0.02635740f, -0.52367043f, 0.14853430f, -0.03622312f, -0.02655057f, 
    0.13726570f, -0.11510669f, -0.16460073f, 0.05056309f, -0.00632987f, 0.01844947f, -0.11077693f, 0.10899881f, 
    -0.03705554f, 0.17526563f, 0.05632482f, -0.19744709f, 0.00416062f, -0.05575843f, 0.02559655f, 0.03933376f, 
    -0.06838299f, -0.00184387f, -0.04302789f, -0.06748059f, -0.08482000f, 0.27493086f, 0.09148403f, -0.18235472f, 
    -0.09851173f, -0.05306032f, -0.00057837f, -0.00172831f, -0.04728383f, -0.02843799f, -0.01609854f, -0.07673111f, 
    0.25451827f, 0.09978690f, -0.12670124f, -0.16264014f, 0.02621630f, -0.08210613f, -0.03612814f, -0.05318217f, 
    0.03001548f, 0.05283941f, -0.12476850f, 0.06801560f, -0.07639553f, 0.09437829f, -0.07206991f, -0.12186951f, 
    0.10265791f, 0.05944542f, 0.01242425f, -0.08575449f, -0.05760214f, 0.08019403f, 0.00344077f, -0.05027350f, 
    0.07586596f, 0.06377010f, -0.14524706f, 0.20237274f, -0.05845422f, -0.05388952f, -0.22312176f, 0.07416024f, 
    0.09398408f, -0.07908572f, -0.03767338f, -0.05171986f, 0.10314966f, -0.12688310f, 0.01737858f, 0.19464344f, 
    0.14250556f, 0.18259171f, 0.05086646f, -0.05222498f, -0.03191765f, -0.02905227f, 0.03409293f, 0.06456973f, 
    -0.04146580f, -0.13870580f, 0.18688230f, 0.08721865f, 0.05928486f, 0.08782898f, -0.02411539f, 0.02820416f, 
    0.00977961f, -0.12235618f, -0.00385891f, -0.01135566f, -0.21831293f, 0.04542825f, -0.24319036f, 0.19826454f, 
    -0.09910887f, -0.08521955f, -0.03062150f, 0.02683562f, 0.05485455f, -0.00862646f, -0.00460351f, 0.02300325f, 
    -0.20216112f, 0.23059209f, 0.04373960f, 0.07651678f, 0.05719442f, -0.00386390f, -0.03239339f, -0.08076833f, 
    -0.06396382f, -0.03881079f, 0.12327099f, -0.02423823f, 0.19143507f, -0.24184366f, 0.08978549f, 0.24413571f, 
    -0.05653922f, -0.06667865f, 0.09717125f, -0.14450683f, -0.02875226f, 0.04848527f, 0.04779508f, 0.02638940f, 
    -0.12955841f, 0.16256942f, 0.00147203f, 0.07673284f, -0.00488045f, -0.05835065f, 0.03657990f, 0.01761517f, 
    0.11421708f, -0.10181558f, -0.00796572f, -0.01342901f, -0.11382738f, 0.21461511f, 0.06316096f, 0.04352871f, 
    0.03765597f, 0.14638460f, -0.03472501f, -0.11520175f, -0.04135213f, -0.06465454f, 0.12069574f, 0.05964843f, 
    -0.20369853f, 0.16141801f, 0.08589279f, 0.02397611f, 0.18191357f, 0.05832130f, 0.09296666f, -0.15208916f, 
    0.12715502f, 0.05306410f, -0.13116728f, 0.05043514f, 0.25823104f, -0.07728819f, 0.08752110f, 0.26025027f, 
    0.25254861f, 0.06097689f, 0.11764418f, 0.12623937f, -0.00278920f, -0.08421231f, 0.06008243f, 0.05542573f, 
    0.26574153f, -0.08239964f, 0.13080058f, -0.20755464f, -0.10421202f, -0.00750337f, 0.01621499f, 0.07790504f, 
    0.11175723f, -0.00402090f, 0.00877219f, -0.05490569f, -0.08968098f, 0.23080629f, 0.07682826f, -0.07072046f, 
    0.00298327f, -0.02179758f, 0.00547839f, 0.08367979f, -0.03526262f, 0.12456870f, -0.02272664f, 0.05733338f, 
    -0.00563976f, 0.06803379f, 0.14761490f, -0.13459389f, 0.04605243f, 0.12545580f, 0.03149348f, -0.03992005f, 
    0.00608399f, -0.11945841f, 0.00559218f, 0.15539163f, 0.16822213f, -0.21715355f, 0.20235516f, 0.05450978f, 
    0.03039989f, 0.04745213f, -0.17993128f, -0.03611018f, -0.02386508f, 0.06068359f, 0.06746869f, -0.02989886f, 
    0.20005299f, -0.02655873f, 0.04483445f, 0.07980701f, -0.00475796f, -0.02544121f, 0.03466434f, 0.01489808f, 
    -0.01913415f, 0.01875529f, 0.07254535f, 0.07938541f, -0.31161359f, -0.16183759f, -0.08783934f, -0.09161275f, 
    -0.05909002f, -0.07243107f, 0.01301546f, 0.01921910f, 0.03719715f, -0.04496131f, 0.04403245f, 0.05528478f, 
    0.06667551f, -0.32309836f, 0.01342888f, -0.00317801f, 0.11017494f, -0.01283278f, 0.16183087f, -0.07204221f, 
    -0.01398514f, 0.05348909f, -0.11862241f, 0.05883787f, -0.05698406f, 0.11428773f, -0.18837658f, -0.01574884f, 
    -0.14584079f, -0.07267164f, 0.01827463f, 0.08414567f, -0.04734729f, 0.06845764f, 0.04790734f, 0.06159310f, 
    0.10470483f, -0.01854986f, -0.17889304f, -0.00863225f, -0.07829857f, 0.07488873f, -0.03329986f, 0.08069609f, 
    0.11793681f, 0.05603924f, -0.01635539f, 0.05009264f, 0.01706013f, 0.12949008f, -0.03428737f, -0.24017763f, 
    0.07767181f, -0.00620325f, -0.00866678f, 0.01869199f, -0.12891383f, 0.05294794f, 0.08773123f, 0.04550941f, 
    0.14737943f, -0.03807760f, -0.15934893f, 0.13815202f, 0.07418706f, -0.06375175f, -0.01161577f, 0.07132221f, 
    0.04044985f, -0.01046272f, 0.05824691f, 0.00477288f, -0.08618031f, 0.02699058f, -0.05100931f, -0.04102565f, 
    0.14183323f, 0.09035777f, 0.06588369f, -0.02781668f, 0.09418774f, 0.10674352f, 0.08133898f, 0.04230064f, 
    0.13051338f, -0.08180656f, 0.04082682f, 0.02586508f, 0.04373258f, -0.07492171f, 0.05866417f, 0.04875107f, 
    -0.05633460f, -0.02332792f, 0.12848374f, 0.06834041f, 0.10825498f, 0.10806660f, 0.08197965f, 0.02801777f, 
    0.12807593f, -0.09944683f, -0.03630590f, -0.06673750f, -0.01882426f, 0.09080679f, 0.01203650f, -0.05293430f, 
    0.31258926f, -0.11686122f, -0.11107700f, -0.12741104f, 0.07460432f, -0.07898679f, 0.00653763f, -0.04974934f, 
    -0.03912444f, -0.02435504f, -0.06011304f, 0.07319816f, -0.19395860f, -0.04611721f, -0.10524736f, 0.02661939f, 
    -0.17259027f, 0.04857380f, -0.19489780f, -0.07874581f, 0.04426116f, 0.01676706f, 0.04072229f, 0.02028324f, 
    0.47277388f, 0.16393465f, -0.03494142f, 0.03909342f, 0.00954834f, -0.03454184f, 0.04396880f, 0.06475082f, 
    -0.06373092f, -0.02824978f, 0.11144282f, 0.02369273f, 0.00302213f, 0.00262538f, 0.09621161f, 0.05130665f, 
    0.05499297f, 0.02862442f, 0.07663015f, 0.00356975f, 0.01113202f, -0.03093165f, 0.05780671f, 0.02217502f, 
    -0.11054625f, 0.09285285f, 0.00932047f, -0.23736435f, 0.14017057f, -0.01604604f, -0.02033507f, -0.07877747f, 
    -0.04664576f, 0.02697454f, -0.10233448f, 0.07557924f, -0.03996911f, -0.01672954f, 0.19706480f, -0.17623124f, 
    -0.05910961f, -0.03130849f, 0.12410723f, 0.08760136f, -0.02162251f, -0.05774239f, -0.08745735f, -0.14234266f, 
    -0.13691579f, 0.10079371f, -0.01561424f, -0.23956728f, 0.14285806f, 0.06517652f, -0.11337227f, -0.03424701f, 
    0.00891564f, -0.05032077f, -0.05123768f, -0.02414664f, 0.05371651f, 0.08302312f, -0.00381893f, -0.06567205f, 
    0.09030118f, 0.06830668f, 0.00365082f, -0.09553718f, -0.03906627f, 0.09717505f, -0.13364244f, 0.05925617f, 
    -0.15593602f, 0.07835501f, -0.29095298f, 0.32231295f, 0.05384509f, -0.04086620f, -0.14691842f, 0.02552069f, 
    -0.01232237f, -0.02924076f, 0.02728913f, -0.00338420f, 0.16886652f, -0.18108998f, 0.11853293f, 0.07067060f, 
    -0.09789885f, -0.05147421f, -0.05678099f, -0.18882026f, -0.01572387f, 0.03921756f, -0.02130893f, -0.03497711f, 
    -0.24476327f, -0.23596287f, 0.10315282f, 0.27252042f, -0.11517058f, -0.12959383f, 0.03862407f, -0.15896100f, 
    -0.03555514f, 0.00223152f, -0.01603167f, -0.01563168f, -0.12722790f, 0.14556246f, -0.17208396f, 0.02733707f, 
    -0.02061689f, 0.11190797f, -0.10647360f, -0.01822444f, 0.11966130f, -0.02432950f, -0.01235674f, -0.00011895f, 
    -0.09271865f, 0.05339996f, 0.03600644f, 0.06776005f, 0.02348397f, 0.17000256f, -0.01296738f, -0.02670193f, 
    -0.03299936f, -0.02620239f, 0.07393958f, 0.01431401f, -0.12441149f, -0.23508096f, -0.00680230f, 0.36407241f, 
    0.03400718f, -0.05389696f, 0.15979721f, 0.08335551f, -0.07153819f, 0.02261694f, 0.04408123f, 0.02907488f, 
    -0.18093821f, 0.16680272f, -0.02830876f, 0.29645690f, -0.01412428f, 0.08543146f, 0.00361629f, 0.08175918f, 
    -0.00716878f, -0.00916436f, -0.02120091f, -0.09365355f, -0.04003962f, 0.18726172f, 0.03148549f, 0.28935549f, 
    0.03793231f, 0.16144976f, 0.04188189f, 0.09987989f, 0.12340618f, 0.19039083f, 0.23629014f, 0.10243797f, 
    -0.09899080f, -0.02309267f, -0.02381030f, -0.00121791f, -0.01768203f, 0.01495317f, -0.01127317f, 0.02761687f, 
    0.11817847f, 0.01636271f, -0.03857483f, 0.10030079f, 0.20039432f, -0.01105997f, 0.15447824f, 0.28252324f, 
    -0.05784266f, -0.00111381f, 0.02142876f, -0.00026760f, -0.17441233f, -0.09340274f, 0.03075125f, 0.20277119f, 
    0.21933870f, 0.04824179f, 0.21260485f, -0.10044120f, 0.00616556f, 0.14829209f, 0.06359386f, 0.06931893f, 
    0.06586127f, -0.00686298f, -0.14305204f, -0.01281819f, 0.19890089f, 0.23191430f, 0.07336506f, -0.18250257f, 
    -0.00126259f, 0.07362825f, 0.05913274f, 0.12555748f, 0.10900672f, 0.01746030f, 0.13903405f, -0.05067036f, 
    -0.12518510f, -0.17838323f, -0.12826543f, 0.08608497f, 0.23506306f, -0.12457945f, -0.08425327f, -0.02250748f, 
    0.06512083f, 0.08349654f, -0.00650043f, 0.08202903f, -0.12932974f, 0.08302842f, 0.26421574f, 0.09978769f, 
    0.17314047f, -0.11579303f, 0.15444864f, 0.06761016f, 0.11918609f, -0.13746609f, -0.04314188f, -0.02060125f, 
    -0.00647114f, 0.03661079f, -0.05497413f, 0.07462671f, 0.09408781f, -0.01778376f, -0.12136066f, -0.09976195f, 
    -0.06285185f, -0.06979083f, 0.07256492f, 0.08197951f, -0.09060681f, -0.28826493f, -0.23000427f, 0.07103321f, 
    0.09845402f, 0.03014414f, -0.03037548f, 0.00273924f, 0.05993117f, 0.12243678f, -0.07171157f, -0.07995984f, 
    -0.17491449f, 0.08825829f, 0.19691831f, 0.15370493f, 0.02301555f, -0.04416804f, 0.08515377f, -0.01564705f, 
    0.13102603f, -0.01889666f, 0.05727424f, -0.07653704f, 0.22805536f, -0.03230746f, 0.04430569f, -0.13962913f, 
    0.08932510f, -0.13123859f, -0.31765461f, -0.05257302f, 0.03676982f, -0.00934655f, 0.04872048f, -0.00853999f, 
    0.14293537f, 0.37665904f, 0.13023287f, 0.11689299f, -0.06830083f, -0.19759120f, 0.14243872f, 0.01473706f, 
    0.01905625f, -0.01001385f, 0.08249686f, 0.03619894f, 0.12338240f, -0.10981213f, 0.14178726f, 0.32442483f, 
    -0.11012449f, 0.01662205f, -0.04308856f, -0.03384198f, -0.02770158f, 0.04395930f, -0.05291067f, -0.01321528f, 
    -0.23608015f, 0.09160036f, 0.17956036f, 0.26540527f, -0.11546911f, 0.13440143f, -0.11791910f, 0.02489546f, 
    -0.16182622f, -0.16677248f, 0.08162142f, 0.09980785f, 0.32963553f, 0.20683649f, 0.04207467f, 0.19767977f, 
    -0.19823854f, -0.14541598f, 0.06093622f, -0.04442658f, -0.02839876f, 0.05853933f, -0.08134471f, 0.05294358f, 
    -0.25188473f, -0.21875158f, 0.00467068f, -0.04903945f, 0.10688490f, 0.08140551f, 0.03748205f, 0.03030453f, 
    0.09646569f, 0.02158165f, 0.06667522f, -0.02830514f, -0.07547791f, -0.24891700f, -0.08657686f, -0.22957096f, 
    0.03435631f, 0.06517085f, 0.08620949f, -0.03321433f, 0.02882402f, 0.02953516f, -0.00107608f, 0.07146725f, 
    -0.31896010f, 0.13461784f, -0.03483927f, 0.08649162f, -0.12620315f, -0.00486656f, 0.18069379f, 0.00034701f, 
    0.03170762f, 0.15510979f, 0.10644467f, -0.02367309f, 0.50945687f, -0.07158349f, -0.14235230f, 0.08373867f, 
    -0.07448814f, 0.17390531f, -0.02654682f, 0.06126543f, -0.09369447f, -0.08828598f, -0.01907835f, 0.01123280f, 
    -0.10283590f, 0.29024246f, -0.01579733f, 0.21453778f, -0.03154542f, 0.08584502f, 0.05575898f, 0.09005896f, 
    -0.10935802f, 0.00110687f, -0.13836116f, -0.03798576f, 0.01386047f, 0.33823895f, -0.08622111f, -0.14891468f, 
    0.17548847f, -0.00102211f, -0.03289550f, -0.05770937f, -0.05294147f, 0.09449682f, -0.14249195f, -0.06743036f, 
    -0.06403189f, -0.18422377f, -0.22853915f, -0.06733010f, 0.13633727f, 0.00653257f, 0.00989337f, 0.03820383f, 
    0.06414998f, -0.12032974f, 0.13356408f, 0.06684494f, 0.07505412f, 0.04329651f, -0.14672603f, -0.04786520f, 
    0.11491414f, -0.01962722f, -0.21043852f, 0.15506984f, -0.00646775f, 0.05914141f, -0.00858492f, 0.01026517f, 
    -0.40678194f, 0.13013542f, -0.16459213f, -0.23807298f, -0.00393895f, 0.05975894f, 0.04087723f, -0.05004307f, 
    -0.06227341f, -0.00771745f, 0.01520738f, 0.18687694f, -0.35622814f, -0.14408554f, -0.01362188f, 0.14268290f, 
    0.03993811f, -0.10727612f, 0.04469141f, 0.03192509f, 0.21258411f, -0.00625172f, 0.11249933f, 0.11893839f, 
    -0.37756285f, -0.04272988f, 0.20000975f, -0.20457208f, 0.15452640f, -0.08262249f, -0.07297841f, 0.17628275f, 
    -0.00825407f, 0.10620917f, -0.06136029f, 0.07716772f, 0.01312433f, -0.20582734f, -0.13578090f, -0.03256020f, 
    -0.13594514f, -0.10579935f, 0.00029314f, -0.04886745f, -0.01413451f, -0.05607815f, 0.08765662f, -0.00412211f, 
    0.26696995f, 0.12426015f, 0.10413998f, 0.08723477f, -0.04050401f, 0.04729943f, 0.06049655f, 0.14225776f, 
    0.02149503f, -0.14474726f, 0.10922872f, -0.00613407f, -0.18024871f, -0.17034650f, -0.07804081f, -0.08295255f, 
    0.09274408f, 0.12668014f, 0.07578576f, -0.03896007f, -0.04378174f, -0.00409737f, -0.10940083f, 0.06005495f, 
    0.27387127f, 0.01230090f, -0.00685303f, -0.01448443f, -0.03572265f, -0.10523439f, -0.05167115f, -0.01578655f, 
    0.04117516f, 0.14115365f, 0.01401142f, 0.06120773f, 0.30375153f, 0.05037299f, 0.07426675f, 0.12072530f, 
    0.10133629f, 0.00619374f, -0.04595592f, 0.00059733f, 0.04143623f, 0.04942887f, 0.02279209f, -0.00314189f, 
    0.08287586f, 0.12896380f, 0.19527149f, -0.22628042f, 0.11047193f, -0.05195579f, 0.25006810f, -0.05615946f, 
    0.05275629f, -0.16332228f, 0.07997119f, 0.01804443f, -0.20827620f, -0.01743764f, -0.03678635f, -0.32656643f, 
    0.13734208f, 0.01303764f, 0.04419677f, -0.05699597f, 0.03246336f, 0.10578293f, -0.05514031f, 0.06594635f, 
    0.21663539f, 0.15682177f, 0.07056498f, 0.05250790f, -0.16564018f, -0.09181051f, 0.03141250f, -0.03844898f, 
    0.07744874f, -0.04603966f, -0.04167065f, -0.13393159f, -0.02915712f, -0.04101686f, 0.02732479f, 0.04956263f, 
    -0.06513606f, -0.19435957f, 0.06683572f, 0.11956839f, 0.14649053f, -0.07156149f, -0.03682775f, -0.03188325f, 
    0.08996164f, 0.10868515f, -0.10767065f, -0.03617882f, 0.07238102f, 0.22349948f, -0.13808094f, -0.01233246f, 
    -0.01531517f, -0.09041043f, 0.00772077f, 0.11314273f, 0.19857554f, 0.05138096f, -0.07451528f, -0.04662518f, 
    -0.14397818f, 0.06037326f, 0.10823534f, 0.04375195f, 0.00560200f, 0.08711089f, 0.06333623f, -0.07700276f, 
    0.04149159f, 0.26162857f, 0.09442886f, -0.02350662f, -0.21164209f, -0.02708064f, -0.09013644f, 0.02982131f, 
    -0.01908066f, 0.00684739f, 0.06352490f, -0.02289377f, 0.25006208f, 0.15597345f, -0.31998053f, -0.01309833f, 
    0.02321704f, -0.00029080f, -0.08536772f, 0.13060638f, 0.17942044f, -0.05643492f, 0.06141990f, 0.07142781f, 
    -0.06581300f, 0.46996203f, 0.11055530f, -0.17537558f, 0.02481141f, -0.04157672f, 0.03656083f, 0.05661306f, 
    -0.02801202f, 0.05243506f, -0.05122445f, 0.09917059f, -0.07953144f, -0.18235283f, 0.19514699f, 0.06541529f, 
    0.07507061f, -0.07106365f, 0.18987617f, -0.05768400f, 0.00311964f, 0.04296536f, 0.04206444f, 0.05415588f, 
    -0.17977895f, -0.20548877f, 0.09133737f, -0.14064008f, -0.05626565f, 0.04636394f, 0.08017659f, -0.02989767f, 
    -0.03334774f, -0.12118039f, 0.03311482f, 0.03376254f, -0.23557159f, -0.30335921f, -0.09912619f, -0.04120727f, 
    -0.04939553f, 0.14808869f, 0.06810477f, 0.06190659f, 0.00611167f, 0.09720748f, -0.16560428f, -0.11289082f, 
    -0.06874541f, 0.03006206f, 0.06981900f, -0.14374569f, 0.12604855f, 0.06592531f, 0.07008477f, 0.14368343f, 
    0.07832061f, -0.06924612f, 0.06675113f, 0.03568402f, 0.00716306f, 0.01348584f, 0.11925547f, 0.03123746f, 
    0.01557065f, 0.05663642f, 0.01752419f, 0.18379501f, 0.00124948f, 0.04825656f, 0.05562807f, 0.09870651f, 
    -0.26910746f, -0.16518256f, -0.08280910f, -0.12790343f, -0.01025401f, 0.11084016f, 0.14509310f, -0.05550975f, 
    0.03874708f, -0.03341714f, 0.06447302f, 0.05260861f, 0.07269133f, -0.18706645f, 0.10687305f, 0.05751725f, 
    0.08209431f, 0.10924159f, 0.18223083f, -0.13219751f, -0.06336276f, -0.02318432f, 0.05335168f, -0.03394517f, 
    -0.10317699f, 0.17575593f, 0.12382194f, 0.04052229f, 0.09984583f, 0.05355346f, 0.20193677f, -0.04416971f, 
    -0.00152142f, -0.00077428f, 0.02067738f, -0.07399338f, -0.11445405f, -0.05000122f, 0.23807669f, -0.00354249f, 
    0.03531250f, 0.17887789f, -0.08656140f, 0.00424460f, 0.08374882f, -0.08157354f, -0.09658454f, -0.05144920f, 
    -0.23183532f, 0.01142143f, -0.02688801f, -0.30036020f, 0.04271667f, -0.03137638f, -0.09508517f, 0.06617741f, 
    0.01081731f, 0.04496052f, -0.01884825f, 0.04281952f, 0.44343004f, -0.03865753f, -0.08329047f, -0.01861428f, 
    -0.03033464f, -0.14405738f, 0.09218028f, -0.02990215f, 0.04293206f, -0.02095705f, 0.12283396f, -0.01080841f, 
    0.02559798f, 0.10038970f, 0.10085283f, 0.19555441f, -0.02310170f, 0.16492204f, 0.03499339f, -0.06434590f, 
    0.14824547f, 0.22542252f, -0.01153864f, 0.07724499f, -0.18558457f, -0.11815263f, -0.08276911f, 0.10968223f, 
    0.06483502f, 0.09389877f, 0.13424391f, 0.07339361f, 0.08658987f, 0.02475619f, 0.02983565f, 0.01778659f, 
    -0.01777243f, 0.06424028f, -0.01175772f, -0.03681923f, -0.05755962f, -0.00276088f, 0.02197163f, -0.07517620f, 
    -0.00196917f, 0.06976680f, -0.02080819f, 0.01654857f, -0.07264758f, -0.02376387f, -0.02458327f, 0.06255381f, 
    -0.00568884f, -0.05390940f, -0.09235714f, -0.08005676f, -0.05206950f, -0.02752883f, -0.00088905f, -0.00001618f, 
    0.02949052f, 0.00829201f, 0.01958372f, -0.00116260f, -0.02093232f, -0.00041024f, -0.08807701f, -0.07745548f, 
    0.00094480f, -0.04617833f, 0.03310012f, 0.04012398f, -0.03783122f, -0.05033146f, -0.02909835f, 0.01204156f, 
    -0.06392886f, 0.04169306f, -0.05693592f, 0.04158633f, 0.07317299f, 0.00760571f, 0.04761142f, -0.00110004f, 
    -0.06444725f, 0.04801763f, 0.08121609f, -0.03162059f, -0.01132922f, -0.01861207f, -0.04738063f, 0.04108592f, 
    -0.04927545f, 0.02593563f, 0.02795804f, -0.05628999f, 0.06344365f, -0.05149277f, 0.07312902f, -0.07639834f, 
    0.00880206f, -0.01792789f, -0.01165328f, 0.02049598f, -0.04512358f, 0.03967552f, -0.03600898f, 0.04492017f, 
    -0.08464885f, -0.02394551f, -0.00834038f, -0.03526434f, 0.03553282f, -0.00272159f, 0.01000938f, -0.04705248f, 
    0.03566600f, 0.01237402f, 0.06068330f, -0.04522852f, 0.06004240f, -0.01118149f, 0.06505166f, -0.02250703f, 
    0.04271923f, -0.05454933f, -0.06226495f, 0.05256454f, -0.02193099f, -0.00780717f, 0.02372805f, -0.02491550f, 
    -0.08463663f, -0.01341200f, 0.00718692f, 0.05180755f, -0.04708818f, -0.05393991f, 0.00411589f, -0.00886460f, 
    0.06636276f, -0.05964564f, 0.00687838f, 0.04868830f, -0.04563569f, -0.05369416f, -0.05207244f, 0.01018558f, 
    -0.06202202f, 0.01323707f, -0.06200280f, -0.05712255f, 0.06167302f, 0.03958138f, -0.05327789f, -0.06344769f, 
    -0.05586417f, -0.02711127f, 0.06477544f, -0.02006533f, -0.01647537f, -0.01873234f, -0.06223826f, 0.05702314f, 
    -0.00264662f, 0.04431494f, -0.07016107f, 0.02685354f, 0.05986716f, -0.06307246f, -0.01244630f, 0.01951647f, 
    -0.04272461f, 0.05545599f, 0.01860029f, -0.04721488f, -0.00732299f, -0.07041139f, 0.05602762f, 0.02155239f, 
    -0.03801095f, -0.07918002f, -0.07749486f, 0.04656810f, -0.02756069f, -0.04070627f, 0.06706905f, 0.02059854f, 
    -0.07066722f, -0.07532728f, -0.01510277f, -0.06001578f, -0.01670973f, 0.04031905f, 0.06876182f, 0.02241328f, 
    0.05805047f, -0.03784189f, 0.00058843f, -0.07542969f, 0.03668365f, 0.03104280f, -0.04753653f, 0.01223923f, 
    -0.04950941f, -0.07706308f, -0.02081631f, 0.04362134f, -0.04312248f, -0.05142818f, 0.05089642f, -0.03417306f, 
    -0.06475706f, 0.01551355f, 0.02914463f, -0.03664814f, -0.07585908f, -0.05394609f, -0.00234562f, 0.05614269f, 
    0.05904166f, -0.06377162f, -0.04818650f, 0.02371440f, -0.05461466f, 0.01622252f, 0.03845094f, 0.01547876f, 
    -0.23872936f, -0.09249777f, 0.18208168f, -0.05656249f, -0.05964199f, 0.01721673f, -0.07091708f, -0.13479142f, 
    -0.02490516f, -0.00897065f, -0.05176682f, -0.03279580f, -0.03718268f, -0.11904211f, 0.24809557f, 0.19192013f, 
    -0.05964952f, 0.01424632f, -0.09514935f, -0.09973329f, -0.04462643f, 0.10526529f, 0.10005204f, 0.12454895f, 
    -0.19330157f, -0.12309045f, 0.26577166f, 0.07852236f, -0.07605650f, -0.01386856f, -0.07462199f, -0.10090599f, 
    -0.06289944f, 0.07564216f, 0.11438086f, 0.20079340f, -0.05190614f, -0.05095713f, 0.00767183f, 0.01276424f, 
    0.03335717f, -0.06558500f, 0.17282574f, 0.00973966f, 0.01198483f, 0.02538454f, 0.06288345f, 0.05631867f, 
    0.10252547f, -0.09669804f, 0.05675453f, -0.07751093f, 0.03886026f, 0.18356809f, -0.04030410f, 0.07095696f, 
    0.04515937f, 0.08740167f, -0.13833092f, 0.13124683f, -0.22052534f, 0.13038583f, -0.09386988f, -0.00133609f, 
    -0.14696331f, -0.15749124f, -0.03287525f, -0.03760181f, -0.06921866f, 0.09864465f, 0.09016083f, 0.04780678f, 
    0.08539864f, 0.12034617f, -0.17355035f, -0.19556764f, -0.02677070f, 0.18099695f, -0.00972635f, 0.14561276f, 
    0.05584745f, 0.00992950f, -0.07751574f, 0.07809679f, 0.20472929f, 0.17118111f, 0.11432089f, -0.06377675f, 
    0.09016461f, 0.12221190f, -0.02698247f, -0.01644770f, -0.08370197f, -0.01344976f, 0.06113410f, 0.03900040f, 
    0.25261232f, -0.10617279f, -0.33482227f, -0.27477008f, 0.12596005f, -0.03236069f, -0.00643331f, 0.08615123f, 
    -0.04019490f, 0.00670874f, -0.01636716f, 0.09681936f, -0.23432395f, 0.12479860f, -0.00747651f, -0.10879020f, 
    0.18310615f, 0.01166027f, -0.09029569f, -0.08185283f, 0.11534820f, 0.15038627f, -0.05473171f, 0.00492891f, 
    0.09917875f, 0.01250513f, -0.08857065f, 0.17671090f, -0.03316060f, 0.08776650f, 0.04989559f, 0.10429487f, 
    0.07786290f, 0.01287814f, 0.07316501f, 0.03911269f, 0.02399366f, 0.20041449f, -0.02703486f, 0.23221801f, 
    0.04183286f, 0.06399383f, -0.06354437f, 0.03592925f, 0.03920488f, -0.02099195f, -0.08267598f, 0.05094742f, 
    0.19662353f, -0.09431236f, -0.24726038f, -0.36743411f, 0.02668247f, -0.03501488f, -0.07412291f, -0.12430014f, 
    0.05046043f, 0.02241098f, 0.02215199f, -0.01966648f, -0.12165278f, 0.04651761f, -0.08232278f, -0.02248009f, 
    -0.12982079f, -0.11291929f, 0.03355499f, -0.06368527f, 0.06826025f, 0.19550902f, 0.09831344f, -0.03872973f, 
    0.19045354f, 0.19664641f, 0.02939384f, 0.10112327f, 0.10000657f, -0.10561465f, 0.15840903f, 0.00971762f, 
    0.00083433f, 0.06365276f, 0.08620808f, 0.12409577f, -0.03865978f, -0.16018769f, 0.02788010f, 0.03103146f, 
    0.00718286f, -0.02779836f, 0.14820531f, 0.00402747f, 0.12214063f, -0.10705259f, 0.10928039f, 0.00177333f, 
    0.25475749f, 0.00391632f, 0.07093202f, 0.05666280f, 0.15596339f, 0.15073708f, -0.05799946f, -0.11679964f, 
    0.15488890f, -0.06179791f, 0.14219430f, 0.01020908f, 0.03367054f, 0.05687413f, -0.04064782f, -0.07369199f, 
    0.13270335f, 0.07217279f, -0.10832340f, -0.00901757f, -0.09140394f, 0.08275110f, -0.02948474f, 0.06867935f, 
    0.06474476f, -0.06586977f, -0.09941376f, 0.19662522f, 0.06014666f, 0.11522487f, 0.10932516f, 0.03725470f, 
    0.00594671f, 0.07125715f, -0.07896158f, 0.14503631f, -0.25991607f, 0.02089069f, 0.01329959f, 0.18280786f, 
    -0.17017499f, -0.18059209f, 0.08924370f, 0.05741631f, 0.10388424f, -0.12221898f, 0.14904237f, 0.04544572f, 
    -0.10156862f, 0.16980724f, 0.18010788f, -0.16140266f, 0.11362959f, -0.05069560f, -0.03058719f, 0.10166270f, 
    0.02001943f, 0.05710363f, -0.16101773f, -0.03510004f, -0.11934316f, -0.10627568f, 0.12165278f, 0.11748263f, 
    -0.07941219f, -0.08384053f, 0.07435849f, 0.05503360f, -0.17550379f, -0.03691492f, 0.00960356f, 0.00037824f, 
    0.17460193f, -0.01672228f, -0.05902678f, 0.08209471f, 0.04562169f, -0.00215434f, -0.00437819f, 0.03910469f, 
    0.08205207f, -0.13963056f, -0.14332692f, 0.03483128f, -0.40693340f, -0.17044319f, -0.11116347f, -0.27163371f, 
    0.08880003f, 0.06136626f, -0.02140009f, -0.11076806f, 0.00446264f, 0.18866487f, 0.01896366f, -0.00921855f, 
    0.34340036f, 0.07159450f, 0.02451426f, 0.19288324f, 0.00759247f, -0.09274929f, 0.00589005f, 0.15188009f, 
    0.05567233f, -0.02621163f, -0.08671117f, 0.01523888f, -0.00270682f, -0.01432747f, 0.09802797f, 0.03184251f, 
    0.08617777f, 0.08337789f, -0.14740251f, 0.00633911f, 0.02548515f, -0.06512988f, 0.09590889f, 0.02877502f, 
    0.44743288f, 0.27291870f, 0.17612964f, -0.35271180f, -0.01382752f, -0.17266986f, 0.16451000f, 0.06529370f, 
    0.10630435f, -0.02777373f, 0.05909302f, 0.03629643f, 0.10888360f, 0.17674173f, -0.00781556f, -0.20939082f, 
    0.10764752f, -0.13233568f, -0.00188262f, 0.00337281f, -0.04051211f, 0.08171631f, -0.12054434f, 0.05842298f, 
    0.10571863f, 0.05887112f, 0.21165220f, 0.16858742f, -0.02143869f, -0.00768378f, -0.03137079f, 0.03790957f, 
    0.02272922f, -0.06794027f, -0.01542491f, 0.00556193f, -0.41036937f, 0.10463136f, -0.02836104f, -0.00340025f, 
    0.02073430f, -0.13168783f, -0.09642150f, 0.07980986f, 0.06607164f, -0.09591466f, -0.06041472f, -0.09841301f, 
    0.07354926f, -0.31085417f, -0.32140273f, -0.15196356f, -0.07450948f, 0.12504749f, -0.08635509f, -0.07501804f, 
    -0.05356329f, -0.11085560f, 0.16544269f, -0.19988604f, 0.34350875f, -0.09942283f, -0.05925783f, 0.06034078f, 
    -0.11572907f, 0.01011960f, -0.00191242f, 0.11201799f, 0.02255464f, 0.14493386f, -0.09870977f, -0.00892820f, 
    0.06748749f, 0.20300283f, 0.21911778f, -0.09760611f, -0.03881573f, 0.19794470f, 0.11511581f, 0.20845352f, 
    0.05800999f, -0.09755427f, 0.07102783f, 0.12236203f, 0.07997940f, 0.27937341f, 0.05536722f, -0.22847305f, 
    0.18823288f, 0.07440173f, 0.00050468f, 0.15224285f, 0.01611625f, 0.04930165f, -0.10593331f, 0.07468484f, 
    0.00292847f, 0.32293919f, 0.33822033f, -0.13093162f, 0.12420432f, -0.05228768f, -0.08097363f, 0.06993393f, 
    0.02256217f, -0.06425903f, 0.03911328f, -0.13315682f, 0.03883537f, 0.09539937f, -0.14067970f, -0.20659782f, 
    0.00889978f, -0.03124727f, 0.07279236f, -0.10029405f, -0.08713167f, -0.11033819f, 0.06850418f, 0.09069034f, 
    -0.05179422f, -0.18774505f, -0.23173682f, 0.31827569f, -0.06273452f, -0.01794980f, -0.02929702f, -0.01953305f, 
    0.03742881f, 0.00077083f, 0.04306288f, -0.13614161f, -0.02024715f, -0.13760406f, -0.18458812f, 0.10189534f, 
    0.15545377f, -0.05183301f, 0.02415650f, -0.16725804f, -0.11461316f, 0.08604307f, -0.16697975f, 0.13191770f, 
    -0.25164199f, -0.23437345f, -0.09021827f, 0.09911195f, 0.08991685f, 0.03033322f, 0.05626287f, 0.01881889f, 
    0.00053338f, -0.17996371f, 0.05651179f, -0.16324517f, -0.17443863f, 0.07471533f, 0.03694504f, 0.01761349f, 
    -0.04740016f, -0.09293328f, 0.21543252f, -0.15156898f, 0.04314503f, 0.05592808f, 0.07035512f, 0.14140180f, 
    -0.26402107f, -0.01866979f, -0.01143838f, 0.10722744f, -0.04008749f, 0.02466733f, 0.07598538f, -0.01775034f, 
    -0.14339691f, 0.07909530f, 0.04809823f, -0.04511205f, -0.03918943f, -0.19943747f, 0.08398208f, 0.28643832f, 
    0.00718378f, -0.08343645f, 0.19764546f, 0.29793060f, -0.06645989f, -0.04639181f, 0.18540584f, -0.13370159f, 
    -0.07742398f, -0.22037484f, 0.01768592f, 0.12828773f, 0.05165163f, 0.07389445f, 0.08007003f, -0.02342999f, 
    0.20875543f, -0.06793986f, -0.08983687f, -0.11030284f, -0.18674283f, -0.03242521f, 0.10736036f, 0.22130291f, 
    0.19203722f, 0.07607458f, 0.16148447f, -0.08104751f, 0.33312514f, 0.11851756f, 0.17198570f, 0.09810086f, 
    -0.26448268f, -0.18921217f, -0.16396919f, 0.08480944f, 0.20687707f, -0.08074416f, -0.00196613f, 0.13070635f, 
    -0.07007437f, -0.10125589f, 0.10457820f, 0.00019595f, -0.12020312f, -0.22284622f, -0.19114555f, -0.04474074f, 
    0.12350616f, -0.09480608f, 0.08874189f, 0.04642075f, -0.03994873f, -0.05955127f, 0.00849399f, 0.13412492f, 
    -0.00992596f, -0.04155081f, 0.27399114f, -0.02960176f, -0.07439841f, 0.13866073f, 0.04617188f, 0.04321052f, 
    0.00267301f, -0.03649098f, 0.03853912f, -0.03250086f, -0.26761955f, -0.01113207f, -0.13917102f, -0.09266002f, 
    0.10802216f, 0.10293864f, 0.01098755f, 0.11491656f, -0.11901233f, 0.15884654f, -0.07428617f, -0.06369528f, 
    0.12890047f, -0.28420076f, -0.03088682f, 0.21744946f, 0.23310944f, -0.02690938f, -0.00312520f, -0.13728036f, 
    0.18834203f, -0.04298466f, 0.04846179f, -0.02647541f, -0.14256446f, 0.02760242f, 0.15017165f, 0.16079147f, 
    0.21339804f, -0.04620035f, -0.07202051f, -0.01700493f, 0.09878701f, 0.08368094f, 0.08026162f, 0.14461042f, 
    -0.11604853f, -0.26672474f, 0.13879277f, 0.49568114f, 0.02393476f, 0.07533160f, 0.08743053f, -0.04804133f, 
    0.16737232f, -0.03312584f, 0.10086642f, 0.04593647f, 0.16825108f, -0.05006998f, 0.02611635f, 0.02684322f, 
    -0.06912174f, -0.13891476f, -0.07128368f, 0.10446680f, 0.21507114f, 0.00621579f, 0.14471282f, 0.05442540f, 
    0.09003492f, 0.32029161f, 0.08863448f, 0.07761651f, 0.04146571f, 0.02676693f, 0.00361495f, -0.02525661f, 
    0.09902053f, 0.13985543f, 0.05099636f, 0.06874420f, -0.09861614f, 0.11953652f, 0.06309038f, -0.14559872f, 
    0.05197798f, -0.19300908f, -0.05390714f, 0.08950900f, -0.00603217f, -0.01756337f, 0.19151035f, 0.19037504f, 
    0.08386393f, 0.21260415f, -0.20882244f, 0.19359419f, 0.01958155f, -0.03289692f, 0.07606223f, -0.03745057f, 
    0.02451080f, -0.00723190f, -0.05056166f, -0.07145290f, 0.02743385f, 0.03119224f, 0.21209608f, -0.01630015f, 
    0.03004155f, 0.03393336f, 0.00631100f, -0.05949823f, 0.16228645f, -0.00979156f, 0.01995756f, -0.05522396f, 
    0.06816127f, -0.02575875f, -0.05120360f, 0.25503692f, 0.06520889f, -0.02195348f, -0.07343722f, 0.18415573f, 
    0.09736960f, 0.03142601f, -0.13856588f, 0.07923845f, 0.01340604f, 0.17777717f, -0.06155793f, -0.16606833f, 
    -0.18157306f, 0.00805382f, -0.08730737f, 0.02009038f, 0.03380775f, -0.00381569f, -0.07094134f, 0.02364449f, 
    0.48857418f, 0.02037990f, -0.08857675f, -0.10541524f, -0.01413436f, 0.00889469f, -0.10436159f, 0.07330044f, 
    0.00619474f, 0.07396699f, 0.00195579f, 0.08017090f, 0.24203074f, -0.08267234f, -0.13829261f, -0.11466595f, 
    0.06674815f, -0.07635147f, 0.04187472f, -0.04038607f, 0.01056902f, 0.08132138f, 0.01497900f, -0.00820590f, 
    0.09183291f, -0.11837140f, -0.00480904f, 0.19468156f, 0.03412373f, 0.00190091f, 0.09634718f, 0.02204107f, 
    -0.05899678f, -0.00494914f, -0.02304385f, 0.02623058f, -0.46663383f, -0.07718219f, 0.13102584f, -0.15634355f, 
    0.07076047f, 0.04546513f, -0.10961537f, 0.05211566f, 0.06256393f, 0.01586778f, 0.01284465f, -0.01258347f, 
    -0.18174329f, 0.07170178f, -0.00473739f, 0.01220737f, 0.10357748f, -0.07540908f, -0.02896370f, -0.03713957f, 
    -0.10759425f, -0.09126583f, 0.06101940f, -0.06935967f, -0.11174265f, -0.09488155f, -0.12392700f, -0.00676890f, 
    -0.01894801f, -0.01764251f, -0.13575731f, -0.01412752f, -0.04577592f, 0.03785652f, -0.12284885f, -0.07279536f, 
    0.28587812f, 0.05398166f, 0.16927226f, 0.45356268f, -0.02260286f, -0.01175285f, 0.10979128f, -0.00183908f, 
    -0.09909468f, -0.02126630f, 0.00816937f, -0.03745015f, 0.13247153f, -0.19945171f, -0.02437462f, 0.21710223f, 
    0.04700667f, -0.02564495f, -0.08930466f, 0.05278664f, 0.01179803f, -0.00784571f, 0.00073414f, -0.16423069f, 
    0.09237904f, 0.23077692f, 0.09276270f, 0.28543609f, -0.09536819f, 0.06679915f, 0.08805652f, 0.00247818f, 
    0.04033381f, 0.00741538f, 0.10677619f, -0.03788837f, -0.21990596f, 0.11381020f, -0.05376547f, 0.21539155f, 
    -0.01819182f, 0.11172271f, -0.14836298f, -0.01419580f, -0.18891619f, 0.02233041f, -0.07731913f, 0.03044835f, 
    -0.26231083f, -0.25560644f, 0.07562315f, -0.41399196f, 0.00255332f, -0.09478277f, 0.30218178f, 0.06692345f, 
    -0.06675948f, 0.07110721f, 0.09857318f, 0.06186862f, -0.11131147f, -0.13050401f, -0.23477262f, -0.43389243f, 
    0.00558236f, 0.03358530f, -0.09880638f, 0.24651682f, 0.11152648f, -0.09731332f, -0.04526673f, 0.02848169f, 
    0.25118366f, 0.06757002f, 0.00379148f, -0.01840887f, -0.07744750f, -0.10070237f, -0.01500776f, -0.02042943f, 
    0.10654210f, 0.06163188f, -0.03670369f, 0.12241344f, 0.12762672f, -0.32739940f, 0.02287453f, -0.25835127f, 
    0.06218751f, -0.07437226f, -0.04170412f, -0.03896825f, -0.04450260f, 0.12736385f, -0.01019330f, 0.04123149f, 
    0.17456056f, -0.18448302f, 0.15235005f, 0.10451069f, -0.06806292f, -0.09091214f, -0.00136161f, -0.08803418f, 
    0.08612040f, -0.07568429f, -0.01088408f, 0.05094080f, 0.26920950f, 0.20791118f, -0.08830506f, 0.03622925f, 
    -0.04548202f, 0.01547673f, 0.17838217f, 0.06614573f, 0.01899076f, -0.03859075f, -0.08315405f, -0.02977698f, 
    0.10240386f, -0.12148927f, 0.03855678f, -0.18744563f, -0.07084791f, -0.06201586f, 0.02898765f, -0.08227910f, 
    -0.04219515f, 0.05632393f, -0.11816041f, -0.00717813f, -0.01744395f, -0.28165373f, 0.03828534f, -0.18123990f, 
    -0.01050666f, -0.17761910f, 0.10184548f, 0.01731542f, -0.02432632f, -0.11838108f, 0.18506177f, -0.06085731f, 
    0.32868028f, -0.18444581f, 0.19725001f, 0.14967003f, -0.07860970f, 0.04270914f, 0.00923177f, 0.12462011f, 
    -0.07523076f, 0.01251621f, 0.03372768f, -0.03710633f, 0.17799538f, 0.30644399f, -0.15362771f, -0.13589185f, 
    0.05542905f, 0.08107729f, -0.11074992f, -0.02422632f, 0.00766021f, 0.02028156f, -0.05611519f, 0.08745696f, 
    0.03351704f, -0.14355382f, -0.28097281f, 0.26377496f, -0.03505994f, 0.12337705f, 0.01882325f, -0.07837785f, 
    -0.10456644f, 0.08937609f, 0.01971777f, -0.11180240f, 0.49500927f, -0.28125930f, -0.11029176f, 0.06565319f, 
    -0.03799502f, 0.20889083f, 0.09958000f, -0.09201892f, -0.01900326f, -0.10020193f, -0.06511945f, -0.01325290f, 
    -0.04040704f, 0.06382713f, -0.03193329f, 0.02846326f, 0.01957064f, -0.00317098f, -0.07569361f, -0.05352302f, 
    -0.05475736f, 0.05141158f, 0.02734324f, -0.02466925f, 0.03754890f, -0.07921845f, 0.03719620f, -0.08170869f, 
    0.01648251f, -0.06246000f, 0.00112275f, 0.02549871f, 0.05237484f, 0.01023185f, 0.04390119f, -0.01806884f, 
    0.04985113f, 0.03843450f, -0.01219118f, -0.06173399f, -0.06180974f, -0.01650091f, -0.08612755f, 0.02233869f, 
    -0.02620149f, -0.04742413f, -0.03003937f, -0.01197098f, -0.05538431f, 0.05331745f, 0.02786333f, -0.05397622f, 
    0.05374268f, -0.08539540f, -0.00930613f, 0.05253092f, 0.02955953f, -0.07761835f, -0.02177240f, -0.05048724f, 
    -0.03194682f, -0.04971866f, 0.02125748f, 0.03742328f, -0.05828631f, -0.04195409f, 0.02157521f, -0.07283822f, 
    -0.03056380f, -0.06800636f, -0.00239568f, -0.04823427f, -0.04356503f, -0.07601330f, -0.07009199f, 0.03014543f, 
    -0.00122185f, -0.00531729f, 0.01399083f, 0.05651743f, 0.00555337f, -0.06069750f, 0.02344993f, -0.02301108f, 
    -0.04377643f, -0.00279747f, -0.05922776f, 0.05689360f, -0.02020122f, 0.01345456f, -0.03755579f, 0.04299754f, 
    0.05082152f, 0.01649038f, -0.06037204f, -0.06112202f, -0.00202195f, -0.06418244f, 0.01599346f, -0.05900763f, 
    -0.07078708f, -0.00929193f, 0.04931602f, -0.04777941f, 0.01789817f, 0.02052082f, -0.08044440f, -0.03071628f, 
    0.04695326f, -0.01651334f, 0.02034074f, 0.04128469f, 0.03595612f, -0.05683832f, -0.05628002f, -0.03800787f, 
    0.01584914f, -0.02156436f, 0.02629643f, -0.06910516f, 0.02998981f, -0.00597219f, 0.05086413f, -0.09518079f, 
    -0.01662216f, 0.00773135f, -0.03363451f, -0.03271190f, -0.07368650f, 0.01955159f, 0.02301306f, 0.00729957f, 
    -0.06580779f, -0.08830103f, 0.05858617f, -0.03618663f, 0.05638827f, 0.04212058f, 0.01324317f, -0.06478740f, 
    -0.08639559f, -0.04530181f, -0.01585712f, -0.04137932f, 0.00001987f, -0.06235191f, -0.00030618f, -0.01604269f, 
    -0.04396276f, -0.06241095f, -0.06829296f, 0.00868945f, 0.00662472f, 0.02056151f, -0.08242976f, 0.00882113f, 
    0.01989405f, 0.00910413f, -0.07906218f, -0.03899315f, -0.05471290f, -0.03143800f, -0.04827605f, 0.05970636f, 
    -0.03607757f, -0.00676123f, 0.00685778f, -0.03603014f, 0.02240919f, -0.02397109f, -0.07936587f, -0.05157331f, 
    0.04900680f, -0.07039799f, -0.05432673f, 0.00515893f, 0.02581228f, -0.03837087f, -0.03441302f, 0.02469152f, 
    0.01610356f, 0.04390663f, -0.01490530f, -0.02696890f, -0.01245572f, -0.04010508f, 0.03386955f, 0.02191235f, 
    -0.06770395f, -0.04988095f, 0.05070896f, -0.03147883f, 0.01524560f, 0.05640889f, 0.05839277f, -0.01058828f, 
    0.06513600f, 0.02378585f, -0.02619864f, -0.01384042f, -0.02668811f, -0.00861736f, -0.06758707f, -0.07524955f, 
    0.24964646f, -0.04063073f, 0.13456596f, 0.28829405f, 0.07708263f, 0.09641047f, 0.13964039f, 0.10143065f, 
    -0.14356191f, -0.12480050f, 0.00815410f, 0.03161240f, 0.14135730f, -0.04074884f, -0.04884980f, 0.15992811f, 
    0.03116686f, -0.00413604f, -0.00406750f, -0.03422561f, -0.10567815f, -0.06136887f, -0.08643983f, -0.18260291f, 
    0.06806594f, -0.01017628f, 0.02638490f, 0.24015196f, 0.00977265f, 0.08510554f, 0.13666622f, -0.03936560f, 
    0.05859254f, -0.05630245f, 0.06978615f, -0.07558151f, -0.01024892f, 0.23517492f, -0.10194069f, 0.13017569f, 
    0.00284578f, 0.04438840f, -0.04731963f, 0.09850669f, 0.07282875f, -0.01375677f, 0.04775762f, -0.05180994f, 
    0.11419205f, -0.19771080f, 0.12882988f, -0.19017342f, 0.01403544f, 0.02069146f, 0.20704386f, 0.03266655f, 
    -0.06886621f, -0.00058717f, 0.04082178f, 0.04465843f, -0.05065875f, -0.04067095f, -0.04741739f, -0.17206810f, 
    -0.04103310f, -0.11593136f, -0.17482939f, 0.07848036f, 0.00742612f, 0.00830526f, -0.00784002f, 0.05058873f, 
    0.24731793f, -0.00898341f, 0.03160132f, -0.03609055f, 0.00704191f, -0.11031284f, -0.00836879f, 0.01889699f, 
    0.05354828f, -0.06640096f, 0.03634996f, 0.04078054f, 0.00426178f, -0.15308420f, 0.08048932f, -0.15628600f, 
    0.00101840f, -0.06243120f, 0.11980938f, 0.06067290f, 0.03433919f, -0.06418668f, 0.04050673f, 0.00537659f, 
    0.18477003f, -0.10498432f, 0.25837260f, 0.14907762f, -0.06800497f, 0.08519518f, 0.00016579f, 0.02456606f, 
    0.11654376f, -0.08528864f, 0.10245778f, -0.02839518f, 0.16816667f, 0.16314647f, -0.04790102f, -0.05142598f, 
    -0.16807078f, 0.05073472f, 0.07730025f, 0.02147724f, -0.05723687f, -0.04522102f, -0.03514624f, -0.03863325f, 
    0.15534465f, -0.21483952f, 0.19102831f, -0.19415292f, -0.06312782f, -0.10287776f, 0.00978320f, -0.04264052f, 
    0.03480127f, 0.01092682f, -0.02762678f, -0.04224662f, 0.03292510f, -0.19137242f, 0.05939685f, -0.09743229f, 
    -0.00633670f, -0.18195167f, 0.15384774f, 0.01012248f, 0.01789313f, -0.00813849f, 0.04391237f, -0.12142452f, 
    0.20008953f, -0.04046588f, 0.17513348f, 0.26937267f, -0.09533191f, -0.00222185f, -0.01066572f, 0.24152870f, 
    -0.18530485f, -0.07878417f, 0.13740180f, -0.05267704f, -0.04981007f, 0.01177387f, -0.14223161f, -0.19742154f, 
    0.00675775f, 0.09409439f, -0.19099739f, 0.11667389f, -0.14006491f, 0.05592885f, -0.10820629f, 0.05783531f, 
    -0.08494673f, -0.12233810f, -0.25177222f, 0.17640842f, -0.05896519f, 0.12799813f, -0.01957353f, -0.10645960f, 
    -0.11136067f, 0.03404929f, -0.00010103f, -0.15817295f, 0.41062579f, -0.08250710f, -0.05850524f, 0.09060223f, 
    -0.04006156f, -0.05579958f, -0.03590968f, -0.12799241f, 0.03444295f, 0.06093672f, -0.16595045f, 0.00628071f, 
    0.02719937f, -0.02751412f, -0.03757276f, 0.04806688f, -0.03238142f, -0.02604262f, -0.04706408f, -0.07883551f, 
    -0.00825208f, 0.05751712f, -0.07212950f, 0.04532540f, -0.07647660f, 0.03050428f, -0.00423987f, -0.07892936f, 
    0.04466932f, -0.06474134f, 0.04779945f, 0.06092814f, -0.05336851f, -0.03292782f, 0.01119474f, -0.04191815f, 
    0.01151651f, 0.00244967f, 0.00524774f, 0.01368901f, -0.06466192f, 0.04737217f, 0.06373097f, -0.02591807f, 
    0.01863793f, 0.02737719f, 0.03983727f, 0.00699931f, 0.00087961f, -0.02191954f, -0.03224147f, 0.04652644f, 
    -0.03201804f, -0.02345440f, -0.04116076f, -0.02829036f, 0.05571318f, 0.02814058f, -0.06202507f, -0.04138712f, 
    -0.00152501f, 0.06518549f, -0.00765811f, 0.02542018f, 0.00288152f, 0.03733433f, -0.01586715f, 0.03010482f, 
    -0.00910071f, 0.05068870f, -0.02314922f, 0.02708305f, -0.02801990f, -0.03131083f, -0.04742047f, -0.04982464f, 
    -0.04847349f, 0.04420312f, 0.03294722f, -0.04998418f, -0.05118580f, 0.03987465f, 0.04029125f, 0.05087937f, 
    0.05767100f, -0.05317723f, 0.05751037f, 0.01885025f, 0.04076226f, -0.04898607f, -0.01464981f, 0.03681520f, 
    0.04636714f, 0.03462140f, -0.00053771f, -0.00982612f, 0.01673084f, -0.04720193f, 0.01142498f, -0.00873578f, 
    0.00486490f, 0.06643809f, 0.02481730f, -0.03130974f, -0.02763159f, 0.01897736f, -0.01029955f, -0.08048775f, 
    -0.01545552f, -0.03323071f, 0.04177870f, 0.03164064f, -0.06148459f, 0.02736195f, -0.07598136f, -0.04242614f, 
    -0.06974499f, -0.05049197f, 0.01781676f, 0.04531476f, -0.01572334f, 0.01238155f, 0.07568107f, 0.06758179f, 
    -0.00218054f, -0.07498402f, -0.01744494f, 0.03577390f, -0.06107618f, 0.03015938f, 0.05607653f, -0.02082757f, 
    0.00917623f, -0.07352288f, -0.01424797f, -0.01155726f, -0.02909096f, -0.00686448f, -0.06420419f, -0.05139916f, 
    -0.02740564f, -0.02826433f, -0.05805763f, 0.02589204f, -0.04083046f, 0.01541114f, -0.06989400f, -0.05841081f, 
    0.02777871f, 0.05872779f, 0.00455564f, -0.00679046f, 0.00534026f, -0.05023808f, -0.05964933f, -0.01051538f, 
    -0.03231261f, -0.03888077f, -0.00992191f, 0.06565989f, -0.03752521f, -0.00326163f, 0.01983077f, 0.03019170f, 
    -0.07344215f, -0.06368584f, -0.04457910f, -0.07622289f, -0.03625438f, -0.01450619f, -0.04154284f, -0.00775498f, 
    -0.04395467f, -0.04376811f, 0.00811463f, -0.03578543f, 0.01996047f, 0.06426384f, 0.01016692f, 0.03452685f, 
    -0.07415133f, 0.01335599f, -0.05576833f, 0.03349201f, -0.01788777f, 0.00130005f, -0.04021720f, 0.01013617f, 
    -0.02567139f, -0.06999464f, -0.03279404f, -0.06010620f, 0.01720151f, 0.06322853f, 0.02690809f, 0.05453900f, 
    -0.05720123f, -0.06569388f, 0.04837970f, -0.00526606f, 0.03358249f, 0.01908744f, 0.00346417f, -0.06094937f, 
    0.02294924f, -0.19660448f, -0.37238592f, 0.21828277f, 0.26766118f, -0.23921546f, -0.13985948f, -0.00091327f, 
    0.04675271f, 0.09325666f, 0.16834871f, 0.11321425f, 0.12660676f, -0.02186355f, -0.05592140f, 0.18060091f, 
    0.03359188f, -0.24108760f, 0.16311380f, 0.07010848f, 0.00444105f, -0.04450924f, 0.04137883f, 0.11646342f, 
    -0.11506643f, 0.11501624f, -0.19588335f, -0.04346929f, 0.05103083f, -0.13159491f, 0.02274220f, -0.16355100f, 
    -0.07952406f, -0.01145548f, -0.06145374f, 0.08845474f, 0.32767302f, -0.20082274f, 0.26765242f, -0.06975435f, 
    -0.00814014f, -0.02600769f, 0.10996505f, 0.23323181f, -0.02991795f, 0.01553039f, 0.15825032f, 0.06306107f, 
    -0.15414447f, 0.13622099f, 0.13183746f, -0.05345312f, -0.02458930f, 0.18812974f, 0.01503176f, -0.06330440f, 
    -0.03068911f, -0.06750080f, 0.12847516f, 0.02222028f, 0.07177958f, -0.03279848f, 0.02034388f, -0.24542834f, 
    -0.03760158f, -0.05461010f, -0.11188309f, 0.06785922f, 0.07102173f, 0.03385673f, 0.05179160f, -0.08730981f, 
    0.26249057f, 0.06704813f, 0.14739189f, 0.17613843f, 0.04822135f, -0.20236304f, 0.00854860f, 0.09559965f, 
    -0.22688571f, 0.08093630f, 0.06287529f, 0.05860565f, -0.00726722f, 0.13091330f, -0.03668838f, 0.03609621f, 
    0.07624413f, 0.09108652f, 0.09571435f, 0.06131487f, 0.02384292f, 0.08037623f, 0.06012439f, -0.05558326f, 
    0.03435427f, -0.09899323f, -0.01097225f, -0.01792951f, -0.13290769f, 0.06490668f, 0.09548776f, -0.06203647f, 
    0.16663113f, 0.01502780f, -0.06657425f, 0.13039473f, 0.12452971f, 0.00518756f, -0.09543494f, 0.09859740f, 
    -0.01923227f, 0.08873112f, -0.05215605f, 0.17360783f, -0.01280763f, 0.05714226f, -0.02874780f, -0.05045816f, 
    -0.09298563f, -0.00415319f, -0.04413768f, -0.08830270f, 0.14040011f, 0.13886976f, 0.03816067f, -0.01138779f, 
    -0.02834289f, 0.13394013f, 0.01627827f, 0.03731341f, -0.00637389f, -0.13551868f, 0.02050046f, -0.07417042f, 
    0.15962699f, -0.04402372f, -0.02894972f, -0.06620238f, 0.07928236f, 0.14551392f, 0.09650122f, 0.11097449f, 
    -0.07431977f, 0.03751049f, -0.00146540f, 0.05325368f, -0.11059493f, -0.04862447f, 0.03773472f, 0.13090551f, 
    -0.01949317f, 0.00802253f, -0.03634174f, -0.13113208f, -0.09091820f, -0.09891693f, 0.00746065f, -0.19166490f, 
    -0.10427329f, 0.08667468f, 0.00030707f, 0.07266831f, 0.01211814f, 0.01725805f, -0.03384257f, -0.05034532f, 
    -0.10258882f, 0.30503124f, -0.08597928f, 0.03814588f, 0.10550955f, 0.04432054f, -0.14379141f, 0.02778647f, 
    0.05242904f, -0.02203017f, -0.02259971f, 0.06178150f, -0.13505812f, 0.06499550f, -0.15268578f, -0.04064190f, 
    0.09998497f, -0.03739304f, 0.08282634f, 0.01152560f, 0.03861542f, -0.04346960f, 0.04615049f, -0.04952838f, 
    -0.11259219f, -0.04263002f, 0.02272738f, 0.04385782f, 0.01359123f, 0.10373055f, -0.03604173f, 0.04772495f, 
    0.00448223f, -0.19716354f, 0.03521632f, 0.02500735f, 0.05343468f, -0.18937615f, 0.15747488f, 0.08825271f, 
    -0.17486812f, 0.03143169f, -0.06583672f, -0.01467127f, 0.05667692f, 0.13844900f, 0.07412097f, -0.05752433f, 
    0.03441390f, -0.06942704f, 0.04283282f, 0.07381534f, -0.10079946f, -0.00388145f, -0.02713533f, -0.08679878f, 
    0.09482295f, 0.22140889f, 0.08864456f, 0.13407131f, -0.30476379f, -0.07527144f, 0.11588685f, -0.01681862f, 
    -0.12331612f, 0.01328447f, 0.12405690f, 0.05626322f, 0.01697283f, 0.06220311f, -0.04930073f, 0.05996934f, 
    0.00550854f, -0.18034118f, -0.10460347f, -0.05075667f, 0.09858387f, 0.09860467f, -0.00337527f, 0.03586905f, 
    -0.05888004f, 0.05603094f, -0.03590100f, 0.06993653f, 0.05218747f, 0.35259593f, 0.00787021f, 0.04688814f, 
    -0.07807710f, -0.12376331f, -0.01018046f, -0.06084673f, -0.06848908f, 0.08048347f, 0.04098851f, -0.06796449f, 
    0.15213282f, 0.03263734f, 0.02974973f, -0.03529238f, -0.01432091f, 0.11017232f, -0.04372244f, 0.03845060f, 
    0.05535721f, -0.03337269f, 0.08582307f, 0.09164704f, 0.14938734f, 0.01938030f, 0.00500939f, -0.10414612f, 
    0.03850858f, -0.00440682f, -0.11827698f, 0.01838748f, -0.09043556f, 0.09497200f, 0.05645207f, -0.01873559f, 
    0.44501039f, 0.09243068f, -0.02784822f, 0.04000745f, 0.08343727f, -0.04084443f, 0.06243694f, 0.12441104f, 
    0.13102871f, 0.12375998f, -0.08970765f, 0.00971111f, -0.23631793f, 0.21096425f, -0.06430668f, 0.12536407f, 
    0.09720665f, -0.04440739f, -0.01074895f, -0.08494199f, 0.06288865f, 0.03166072f, -0.03374622f, 0.08217010f, 
    -0.03274535f, 0.01225862f, -0.01205860f, 0.14716794f, 0.01880164f, -0.01099888f, 0.10627446f, 0.09601226f, 
    -0.00905021f, 0.07764697f, 0.09420698f, 0.04301013f, -0.13278694f, 0.06573503f, -0.05713990f, 0.14973255f, 
    0.00007785f, -0.03435319f, -0.07853291f, -0.01710247f, 0.08422931f, 0.01520841f, -0.05379708f, -0.09470387f, 
    0.50645167f, 0.04216399f, 0.09774192f, -0.06356607f, 0.02611711f, -0.00357358f, 0.08036859f, -0.09220189f, 
    0.02903627f, -0.02578307f, -0.07299748f, 0.01316752f, -0.06615114f, 0.24916318f, -0.06707290f, 0.13617457f, 
    -0.03415571f, 0.01918210f, -0.06127907f, -0.17590503f, -0.03675176f, 0.13258576f, 0.00766094f, -0.09910410f, 
    0.28040054f, 0.01615496f, -0.03640645f, 0.06264263f, 0.12696020f, -0.04597126f, 0.05706230f, -0.04905634f, 
    -0.08268894f, 0.02706543f, 0.07889913f, 0.01178226f, 0.46115348f, -0.07182842f, 0.20101933f, -0.03843606f, 
    -0.07477098f, -0.00740186f, 0.10702058f, -0.02824237f, 0.07112181f, -0.09089096f, 0.13172814f, -0.05790181f, 
    0.47242329f, 0.16063626f, 0.20181571f, 0.30729678f, 0.14729604f, -0.01607871f, -0.03342729f, -0.09009264f, 
    0.15554479f, 0.01917141f, 0.00192125f, -0.02931976f, 0.02438260f, 0.01962654f, 0.24190915f, 0.08915663f, 
    0.08799578f, 0.07360592f, -0.05165201f, -0.04204699f, 0.02072268f, -0.00567334f, 0.07148163f, -0.02772742f, 
    0.55136490f, 0.01259349f, -0.13879126f, 0.45830622f, 0.00478693f, -0.03794958f, -0.04673630f, -0.08213618f, 
    -0.07317852f, 0.02465193f, -0.10110252f, 0.08595270f, -0.24152541f, 0.01625556f, -0.18625842f, -0.02502600f, 
    0.03459881f, 0.05539347f, -0.20821995f, 0.06633219f, -0.00990632f, -0.01841573f, 0.10743378f, -0.05510955f, 
    0.06366424f, 0.08435167f, -0.14708224f, 0.00150346f, 0.20659038f, -0.16889070f, -0.00572451f, -0.03457022f, 
    -0.03436058f, 0.04834685f, 0.11023675f, 0.08135911f, -0.12762178f, -0.14174451f, -0.05104715f, -0.22058842f, 
    0.09832288f, -0.03591270f, -0.10480072f, -0.04362455f, 0.09078712f, -0.15311044f, 0.05699457f, 0.13431570f, 
    -0.10709667f, 0.18828170f, -0.01907926f, -0.01366243f, -0.02009369f, 0.00060373f, -0.10378641f, -0.04991500f, 
    -0.05715984f, -0.03446718f, 0.13903154f, -0.02012594f, -0.33581692f, -0.14249071f, -0.21139339f, -0.09158240f, 
    -0.03371570f, -0.21605974f, -0.09204435f, -0.06715898f, 0.15753686f, -0.09718229f, -0.00796921f, 0.08835818f, 
    -0.19899070f, 0.20702790f, 0.20215167f, 0.25718197f, -0.05096800f, -0.00215222f, 0.06633371f, 0.07444341f, 
    0.06700301f, 0.08232877f, 0.02826884f, -0.08078772f, 0.13603047f, 0.09908454f, -0.02638122f, 0.10980912f, 
    -0.16824192f, 0.12641513f, 0.02341750f, -0.01089417f, -0.07407041f, -0.03420223f, -0.08586567f, 0.02498071f, 
    0.24667035f, 0.13637321f, 0.03889982f, -0.22732620f, 0.06793465f, -0.02025474f, -0.03131366f, 0.00705282f, 
    -0.01457515f, -0.03472167f, 0.11425381f, 0.05269269f, 0.14817443f, 0.18950482f, 0.10180877f, -0.19059749f, 
    -0.04017849f, -0.13313638f, -0.08341849f, -0.02632766f, -0.06724215f, 0.07659206f, 0.07587675f, -0.06492808f, 
    -0.10415287f, 0.08907924f, 0.20171344f, 0.03416114f, -0.01919869f, 0.02025737f, 0.09608897f, -0.04357621f, 
    0.02181552f, 0.17654049f, -0.04667243f, 0.05146061f, -0.10419253f, -0.06687306f, -0.05779695f, 0.01326513f, 
    0.05446812f, 0.12337219f, -0.02265142f, -0.03227707f, 0.01428276f, -0.04501253f, 0.01535619f, -0.00376914f, 
    0.25681806f, -0.02250081f, -0.28683013f, -0.10112203f, -0.02605652f, -0.00094129f, -0.00891909f, 0.06435295f, 
    0.01646570f, 0.03190276f, -0.01295332f, 0.02127668f, -0.07356512f, 0.16168545f, -0.01523938f, -0.09150192f, 
    0.11874279f, 0.02676562f, 0.02703435f, 0.04330687f, 0.14701118f, 0.02845372f, -0.05355936f, -0.05341475f, 
    0.09950855f, 0.19830425f, 0.27458116f, 0.20486009f, -0.12888286f, 0.06748620f, 0.00428881f, 0.17373721f, 
    0.00209607f, -0.09365159f, -0.04465520f, -0.09898951f, 0.04936979f, 0.11024834f, -0.03002269f, -0.11429764f, 
    0.00767006f, 0.06909063f, 0.04433259f, 0.12729764f, -0.00491985f, -0.04640180f, 0.03260911f, -0.13114055f, 
    -0.26022804f, 0.11485989f, 0.23064162f, 0.03397666f, -0.06156141f, 0.08518904f, 0.01816408f, 0.00386653f, 
    0.05122770f, 0.11873124f, 0.09583294f, -0.04220856f, -0.41842797f, 0.16537412f, -0.04010435f, 0.07878390f, 
    -0.08951814f, 0.10478804f, -0.04317028f, -0.10824560f, 0.03288801f, -0.01616290f, -0.06318793f, -0.17859544f, 
    -0.10106520f, 0.00590766f, -0.15766287f, 0.07158042f, -0.08516403f, -0.09374401f, -0.10680303f, 0.13828532f, 
    0.03599488f, 0.00144159f, 0.02076406f, -0.11483064f, 0.22456940f, -0.12081557f, 0.00526337f, -0.02505820f, 
    0.11177491f, 0.13656329f, 0.01590661f, -0.04316528f, -0.04465600f, -0.02229154f, -0.01587495f, 0.16914870f, 
    -0.25503191f, -0.11063804f, -0.13228336f, -0.05018510f, -0.00485229f, 0.04740983f, -0.01533172f, -0.15726703f, 
    0.18335873f, -0.11217456f, -0.06794466f, -0.00376497f, -0.05645203f, -0.00265894f, -0.07491995f, -0.02302661f, 
    -0.11011592f, 0.13802096f, -0.06763431f, -0.01322653f, 0.08853527f, 0.01023287f, -0.11489306f, -0.03109149f, 
    -0.16495228f, 0.05656627f, 0.13236095f, 0.22577162f, -0.06262637f, 0.08728576f, 0.01797031f, 0.14211130f, 
    -0.05886580f, 0.02424568f, 0.08805384f, 0.04100755f, -0.03558200f, 0.06467082f, 0.08270295f, 0.12831275f, 
    0.01642054f, -0.00464745f, 0.01244489f, -0.00711108f, 0.06323353f, -0.09077971f, 0.17567091f, 0.16552366f, 
    0.09407008f, -0.12183268f, -0.06423335f, 0.11190462f, -0.09498082f, 0.04277480f, -0.02087326f, -0.04845409f, 
    0.08308804f, -0.10259018f, 0.00564136f, -0.05559525f, 0.12691009f, -0.10145903f, -0.06618490f, 0.18359812f, 
    -0.09134994f, 0.14671752f, -0.07297051f, 0.01494005f, -0.03434724f, -0.08863087f, -0.04989992f, -0.13216415f, 
    -0.05332815f, -0.06194279f, 0.07852942f, 0.13442667f, 0.06234548f, 0.14445940f, -0.01030910f, 0.02652465f, 
    0.06494804f, 0.00763791f, -0.01508476f, 0.19159992f, 0.34703946f, 0.02974883f, -0.07751357f, 0.10218424f, 
    0.17297025f, -0.00648069f, 0.08768408f, 0.12666973f, 0.10879936f, -0.13093376f, -0.10637836f, 0.05355350f, 
    -0.08972663f, -0.27035010f, 0.04505505f, 0.06701221f, -0.13313428f, 0.07568280f, 0.02055418f, 0.03047387f, 
    0.09469416f, 0.00384135f, -0.07715121f, -0.10065679f, 0.35386258f, 0.05710259f, 0.07490736f, 0.04537264f, 
    -0.03023589f, 0.07473826f, -0.11511528f, 0.05764653f, -0.03568577f, 0.12805440f, -0.11263157f, -0.02551950f, 
    0.04697343f, -0.19568260f, -0.04755497f, -0.12157262f, -0.02744492f, -0.02638060f, 0.01668954f, -0.03116571f, 
    0.12130784f, -0.00635789f, 0.06154269f, -0.02110781f, 0.04141723f, -0.04094369f, -0.04247278f, 0.03367238f, 
    -0.01948161f, 0.06360515f, -0.01763207f, 0.10839248f, 0.03859467f, -0.00974004f, 0.08551971f, 0.06624837f, 
    -0.18065116f, -0.17340820f, -0.23008932f, 0.06073936f, 0.08095781f, 0.09972084f, 0.11240422f, 0.08221546f, 
    0.04749434f, 0.00745020f, 0.01792983f, 0.07287905f, 0.14228532f, -0.00240361f, 0.19096133f, 0.26416522f, 
    -0.07271656f, 0.16368926f, 0.05729353f, 0.11824226f, -0.09794340f, 0.11394332f, -0.18101916f, 0.14561923f, 
    -0.41558313f, 0.38613826f, 0.09325610f, -0.24251953f, 0.08090859f, -0.17721979f, -0.09036213f, 0.07414918f, 
    0.15693738f, -0.07213712f, 0.00545689f, -0.06868190f, -0.00197616f, -0.16684271f, 0.21469966f, -0.00948179f, 
    -0.07093576f, 0.08478471f, -0.08091332f, -0.00717917f, -0.06074775f, -0.03624925f, 0.01225665f, 0.13883920f, 
    -0.29973963f, 0.02548146f, 0.07333819f, 0.18250057f, -0.12200416f, -0.04906595f, -0.01346115f, -0.09430731f, 
    -0.11400901f, -0.13299724f, -0.02582145f, 0.08421379f, -0.29477865f, -0.12912194f, -0.13897829f, -0.23262618f, 
    -0.01768570f, 0.06912795f, -0.13376994f, 0.04689320f, 0.14057857f, 0.03564984f, -0.09213535f, -0.10006563f, 
    -0.26433638f, -0.02215750f, 0.01447324f, -0.01041364f, -0.04850116f, -0.08043463f, 0.06315383f, 0.13925406f, 
    -0.11986639f, -0.08602206f, 0.01522155f, 0.04058760f, 0.02650833f, -0.02269870f, 0.12225390f, 0.25280046f, 
    0.00561052f, 0.02777131f, -0.10359354f, -0.05741578f, 0.03206326f, -0.07066971f, 0.02871632f, -0.02605410f, 
    0.15845656f, 0.37965572f, -0.05812780f, -0.03828632f, 0.05946087f, 0.03934849f, 0.14277491f, 0.00349044f, 
    0.06657549f, -0.06372082f, 0.21161139f, 0.02704610f, 0.10297609f, 0.44766027f, 0.00730841f, -0.28085449f, 
    0.02835805f, -0.05822797f, 0.13718925f, 0.21759410f, 0.00836277f, 0.01366613f, -0.07141185f, 0.03795636f, 
    -0.40197480f, 0.03839138f, 0.03653078f, -0.16163942f, -0.11071878f, -0.00419497f, -0.03056163f, -0.09995724f, 
    0.04708102f, 0.15089762f, -0.14837065f, -0.03840698f, 0.08047294f, 0.19512789f, 0.17708252f, 0.19589457f, 
    -0.06385434f, 0.04095616f, 0.07867140f, 0.13340442f, 0.07177237f, -0.11304164f, -0.01453728f, -0.01928630f, 
    0.00215763f, -0.27165484f, -0.09255261f, 0.15008344f, -0.03888745f, 0.13338494f, -0.00598551f, 0.03885682f, 
    -0.04286196f, 0.03505269f, -0.09285433f, 0.04412624f, 0.15795073f, 0.05666778f, 0.02303728f, -0.02995910f, 
    0.13025762f, -0.08840910f, 0.02848835f, 0.05748924f, 0.12102363f, 0.09716106f, 0.08736926f, 0.02924814f, 
    0.18215953f, 0.10023919f, 0.19945785f, 0.13452347f, -0.08977399f, 0.11122941f, -0.17382246f, -0.14357921f, 
    0.14057223f, -0.09695035f, 0.15410037f, -0.01391105f, 0.04429950f, -0.09752303f, 0.13034664f, 0.01410921f, 
    -0.13688955f, 0.06142984f, -0.22557066f, -0.14270328f, 0.03064812f, 0.16119675f, 0.13128464f, 0.04188044f, 
    0.01858588f, 0.09826963f, 0.11920634f, 0.27785730f, -0.18946269f, 0.01923824f, -0.06845963f, -0.06761287f, 
    0.16287954f, 0.10743927f, 0.06080900f, 0.14440909f, -0.67337787f, -0.23174627f, -0.19880505f, 0.09609825f, 
    0.15288086f, -0.00207421f, 0.09482671f, -0.14012963f, 0.18053602f, -0.07529155f, -0.09545773f, 0.05206924f, 
    -0.29833713f, -0.09248930f, 0.19742139f, 0.01655185f, 0.08895733f, -0.17142481f, 0.17204989f, 0.08441459f, 
    0.04805599f, 0.15150663f, -0.00187610f, 0.08741682f, -0.12447809f, -0.11157560f, -0.21507345f, -0.10329378f, 
    0.29193518f, 0.18007125f, 0.11411862f, 0.02683424f, -0.04788622f, -0.05409583f, 0.05134964f, 0.20210755f, 
    -0.34421828f, 0.09453541f, -0.20876403f, -0.26445752f, 0.12112018f, 0.09638657f, 0.05157338f, 0.06229552f, 
    0.22629741f, 0.05059590f, 0.09171382f, 0.05775348f, 0.09837448f, -0.19256641f, 0.04832056f, 0.13917433f, 
    -0.04724061f, 0.01602201f, 0.11125432f, 0.09219155f, 0.07260400f, 0.04311944f, -0.09177108f, 0.00434560f, 
    -0.06829746f, -0.15983835f, 0.05171966f, 0.31180045f, 0.01882806f, -0.08691224f, 0.14352283f, 0.18763235f, 
    0.14097106f, 0.06816007f, -0.02023564f, 0.05970553f, -0.16341217f, 0.21708545f, -0.09274242f, -0.16103460f, 
    -0.01038097f, 0.04505270f, 0.04935614f, -0.03142002f, 0.06108021f, 0.03183840f, -0.10863453f, 0.08879444f, 
    -0.11193968f, -0.25633377f, -0.08704440f, -0.26147959f, -0.13332087f, 0.00727293f, 0.12022310f, -0.03242632f, 
    0.02886928f, -0.09236308f, 0.08413713f, 0.07646738f, -0.26910663f, -0.13405450f, 0.12160791f, -0.12494404f, 
    -0.06939955f, 0.09149039f, -0.07180446f, -0.03873349f, 0.02912763f, 0.00892663f, 0.05412406f, -0.04636769f, 
    -0.19145690f, -0.00433101f, 0.01220329f, -0.07851124f, 0.20504910f, 0.06792477f, -0.00369592f, 0.06292123f, 
    0.09055918f, -0.06845263f, 0.01429112f, 0.01964455f, -0.15466392f, 0.07608566f, -0.31060475f, -0.15094806f, 
    0.12156044f, 0.04852308f, 0.09456020f, 0.04299311f, 0.10897753f, 0.08969314f, -0.07694307f, -0.07560950f, 
    0.22617158f, 0.06796365f, -0.20085740f, 0.08333837f, -0.18532848f, -0.07082292f, 0.04032449f, -0.09999893f, 
    -0.04022443f, 0.15458028f, 0.07001707f, 0.18097232f, -0.32674694f, -0.09818358f, -0.06797780f, -0.04145552f, 
    0.04053057f, 0.08714822f, 0.02181207f, 0.15650691f, -0.08863018f, -0.01025191f, -0.09801611f, 0.00315427f, 
    -0.01027994f, 0.18820906f, -0.05433314f, -0.33968586f, -0.05669533f, 0.03160609f, 0.11548118f, 0.23409645f, 
    -0.09900635f, 0.08914290f, -0.02431496f, 0.19414744f, 0.19170980f, 0.14798027f, -0.18885756f, -0.13370597f, 
    0.12417497f, 0.08358503f, 0.01883053f, 0.14952239f, 0.04016081f, -0.03090478f, 0.00882239f, -0.00890605f, 
    0.04606465f, 0.29022303f, -0.04322682f, -0.42724755f, 0.19148642f, 0.07363842f, 0.03979042f, 0.11268365f, 
    0.00554267f, -0.09228818f, -0.10062464f, -0.05079953f, 0.07183220f, -0.00673498f, -0.09294561f, -0.14216229f, 
    0.11698980f, -0.03967131f, 0.05873207f, -0.10435957f, -0.06608700f, 0.06125851f, 0.01479207f, 0.05972430f, 
    0.11638092f, -0.25588432f, -0.12659423f, 0.14149076f, -0.02022669f, 0.10690108f, 0.12145844f, 0.02574421f, 
    -0.06634863f, -0.05215254f, 0.01569702f, 0.07477804f, -0.02509592f, -0.16048200f, -0.17095722f, 0.06982882f, 
    -0.10478245f, 0.02514178f, 0.07224137f, 0.02759220f, 0.07080854f, 0.08753598f, -0.06528170f, -0.10241912f, 
    -0.00284953f, -0.16364215f, -0.01976685f, 0.07827525f, 0.02628767f, -0.17528820f, 0.13703358f, -0.00650323f, 
    -0.06980972f, 0.05025389f, -0.05856615f, 0.08259085f, -0.13339978f, -0.06025741f, -0.06220146f, 0.02283807f, 
    0.08830703f, 0.03352418f, 0.11795241f, 0.15584230f, 0.05555472f, 0.00055061f, 0.07319108f, 0.14695439f, 
    -0.27589306f, -0.09410534f, 0.10513376f, 0.02838354f, -0.09619626f, 0.11930323f, 0.08066134f, -0.16849078f, 
    -0.08857347f, 0.00116546f, 0.11555028f, 0.08882995f, 0.08611710f, -0.31470084f, -0.04244158f, 0.14000012f, 
    0.00426240f, -0.06125489f, 0.25951242f, 0.18701284f, 0.01084974f, 0.08744931f, 0.05324896f, -0.04019023f, 
    -0.26078269f, -0.04499109f, 0.16416061f, 0.05621997f, 0.12419421f, 0.01056464f, 0.08917762f, -0.06362629f, 
    0.02849077f, -0.00218366f, -0.03055643f, -0.12104996f, -0.04375107f, -0.05504140f, 0.10196275f, 0.02752678f, 
    0.11866137f, 0.03782231f, 0.08125250f, 0.01542869f, 0.07430333f, 0.02544719f, 0.13957939f, 0.06290305f, 
    -0.23528919f, -0.07119934f, -0.06713221f, 0.07811366f, 0.02931608f, -0.01213444f, -0.04040267f, 0.18176225f, 
    0.14243573f, 0.12380666f, 0.11873657f, 0.01311946f, 0.34630427f, -0.07716184f, -0.02488788f, -0.03316467f, 
    -0.15389256f, -0.04371779f, -0.04155548f, 0.01534253f, -0.05103734f, -0.05600266f, 0.06217750f, 0.16136400f, 
    0.03733013f, 0.10752063f, 0.18447676f, 0.14417326f, -0.04464185f, 0.13109022f, 0.04048942f, 0.09278736f, 
    0.08518435f, -0.04341906f, -0.13135047f, 0.02828570f, -0.18599284f, 0.08312837f, -0.15196082f, 0.01949367f, 
    0.01704026f, 0.12400278f, 0.07930160f, 0.00258636f, 0.03305389f, -0.04063100f, 0.08552793f, 0.04356286f, 
    0.24367718f, -0.03523108f, -0.00519178f, 0.35768995f, -0.04760956f, -0.07143091f, -0.02292861f, -0.07789074f, 
    0.03454649f, 0.04264949f, 0.01296323f, -0.13616771f, -0.07895742f, -0.15197206f, 0.20329553f, 0.16336015f, 
    0.01893457f, 0.11574756f, 0.01923832f, -0.18511887f, 0.03987526f, -0.07680684f, 0.03658326f, -0.00557832f, 
    0.37194335f, -0.18925050f, -0.07273492f, 0.43679616f, -0.07740153f, -0.03833396f, 0.10293659f, -0.03767676f, 
    -0.04442854f, -0.02246415f, -0.06207473f, -0.04931308f, 0.21219929f, 0.09358639f, 0.02011144f, 0.16426122f, 
    -0.05688497f, 0.14524408f, -0.05439986f, 0.17222632f, 0.04974429f, -0.01571421f, 0.02632934f, -0.04036916f, 
    -0.00675269f, 0.22959061f, 0.10072860f, -0.13672061f, 0.14534914f, -0.01684526f, -0.01592869f, 0.03797005f, 
    -0.00875002f, 0.12243912f, 0.07992169f, 0.13007405f, -0.12471870f, -0.03405618f, 0.22002789f, -0.05568716f, 
    -0.01424787f, -0.00072481f, -0.07191750f, 0.02835230f, 0.01238475f, -0.17386922f, 0.05042339f, 0.05123411f, 
    -0.14601728f, 0.23281515f, -0.00111988f, -0.09978553f, 0.08582626f, -0.07394995f, -0.02773174f, 0.00021897f, 
    -0.09150314f, 0.04984463f, 0.01345336f, -0.00911596f, 0.04189254f, -0.05392613f, 0.02002537f, -0.04203859f, 
    -0.06532507f, -0.10746288f, -0.18319377f, -0.03638105f, 0.04501437f, -0.01330544f, -0.02359379f, -0.03810536f, 
    -0.00174510f, 0.08010169f, 0.12885150f, 0.08141016f, -0.07092228f, -0.05267689f, -0.00030277f, 0.12201159f, 
    0.08282503f, -0.13392051f, 0.04986805f, 0.04025150f, 0.07385493f, 0.24503940f, 0.02827194f, -0.09806968f, 
    0.03727574f, 0.07632717f, -0.03269942f, -0.05402530f, -0.03950526f, -0.02612670f, -0.12601635f, 0.08561514f, 
    0.25540558f, 0.04831978f, -0.12091334f, -0.17099567f, 0.00648761f, -0.02876707f, 0.00611142f, 0.09180021f, 
    -0.12428498f, 0.05931578f, 0.10622014f, 0.10500512f, 0.30439016f, 0.00839183f, -0.03342196f, -0.18131246f, 
    -0.10790743f, -0.19746542f, 0.01186894f, 0.18380368f, -0.11437015f, 0.09461560f, -0.13443442f, 0.01125859f, 
    0.05357897f, 0.04086164f, 0.09357414f, -0.00790607f, 0.04922099f, 0.10145991f, 0.04410965f, -0.06751394f, 
    -0.10525040f, 0.11630274f, -0.00252035f, 0.04536479f, -0.10100693f, 0.11283994f, 0.08821636f, -0.00147869f, 
    0.06022148f, 0.14586283f, -0.08449057f, 0.06952409f, -0.01523553f, -0.01367339f, -0.03196998f, 0.01631927f, 
    0.00002484f, -0.17083676f, -0.27982628f, 0.06186821f, 0.06637210f, -0.01078285f, -0.10017579f, -0.02639614f, 
    -0.04211027f, 0.05198722f, -0.06882008f, -0.11145823f, 0.18139379f, -0.07361449f, -0.00427267f, 0.07681796f, 
    0.04647145f, -0.09328001f, -0.11671794f, -0.07947407f, 0.12040656f, 0.10292003f, -0.02320633f, 0.01182284f, 
    -0.01901872f, 0.01074980f, -0.18375920f, 0.05587770f, 0.26097035f, 0.01203918f, -0.06246172f, 0.04102596f, 
    0.03634575f, 0.14316447f, -0.01654280f, 0.06576584f, 0.03161798f, -0.09110615f, 0.00076672f, -0.12953022f, 
    -0.02457519f, 0.01055951f, 0.16195776f, 0.06096243f, -0.09659272f, -0.09907032f, 0.01895296f, -0.04371360f, 
    -0.44460037f, -0.05759621f, 0.05661362f, -0.11572770f, 0.22828236f, 0.05208432f, -0.13692735f, -0.01850599f, 
    -0.00584524f, -0.13588235f, -0.01777276f, -0.03260348f, -0.04610898f, 0.07601847f, 0.03892251f, 0.06505613f, 
    -0.09635746f, 0.20100342f, 0.00425736f, -0.04215143f, 0.01886374f, 0.09089839f, -0.01301102f, -0.02114156f, 
    -0.07612625f, 0.21498956f, -0.10229184f, 0.12460809f, -0.01018469f, -0.02263312f, 0.13744494f, 0.01727070f, 
    0.04099771f, -0.03796484f, 0.06566487f, -0.06042377f, 0.21800391f, 0.07456426f, 0.08480125f, -0.10211792f, 
    -0.07762937f, -0.05577752f, -0.16889867f, -0.14525196f, -0.04593751f, 0.00139957f, 0.08380523f, -0.04294180f, 
    -0.09333084f, 0.02629061f, -0.04956938f, 0.25128925f, -0.05356249f, -0.20912683f, -0.03207166f, -0.07960955f, 
    0.00288718f, -0.00850750f, -0.10379879f, -0.00227374f, 0.12797254f, 0.05267138f, 0.03460228f, 0.09917261f, 
    0.13125353f, 0.08155195f, 0.03782053f, -0.10093988f, 0.13835287f, 0.01924997f, -0.01415191f, -0.04621071f, 
    0.01898349f, -0.03695527f, 0.15080945f, 0.03183717f, -0.23227376f, 0.17140962f, 0.02163464f, 0.01832808f, 
    0.02688701f, 0.12284293f, -0.04122091f, -0.03946972f, -0.36479354f, 0.20617631f, -0.01831484f, 0.22787043f, 
    -0.06350201f, -0.05920311f, 0.14240605f, 0.19407985f, 0.05789183f, -0.06727070f, -0.00756570f, 0.13589889f, 
    -0.10581972f, -0.19076781f, -0.14323395f, 0.07722543f, -0.03574162f, 0.11935187f, -0.01125106f, -0.01764319f, 
    -0.16901697f, 0.14981642f, -0.09152162f, -0.08944192f, -0.05546738f, -0.31017432f, -0.11940720f, 0.18711849f, 
    -0.05328560f, 0.04616248f, 0.12211551f, 0.13010730f, 0.15673152f, 0.12413980f, 0.13464391f, 0.03831151f, 
    -0.05108589f, -0.09134568f, 0.12371182f, 0.25242051f, -0.06009659f, -0.00557752f, 0.03395302f, 0.27023175f, 
    -0.08139756f, 0.10054453f, 0.11887760f, 0.16339703f, 0.11149206f, 0.16808824f, 0.07488926f, -0.06653026f, 
    -0.13618435f, 0.06736591f, 0.13205726f, 0.07891093f, -0.15467532f, 0.01572725f, -0.04754228f, 0.21954192f, 
    -0.19713452f, 0.02291522f, 0.09125634f, 0.03313081f, 0.09324063f, 0.08241933f, 0.05269848f, -0.09250239f, 
    0.05435150f, -0.16865587f, -0.15310462f, -0.05212372f, 0.37042883f, 0.09790595f, -0.03256464f, -0.15219559f, 
    0.00127105f, 0.03273462f, -0.04918019f, 0.16274476f, 0.04897122f, -0.03084689f, -0.02490805f, -0.02655458f, 
    0.18442020f, 0.21427676f, -0.00240924f, 0.21427825f, 0.02717332f, -0.09850254f, -0.02146203f, 0.11397033f, 
    0.14002430f, -0.13311066f, 0.01470100f, -0.05735227f, -0.00839496f, 0.00528055f, 0.06700876f, 0.05929137f, 
    -0.02570246f, -0.05494123f, -0.06603181f, -0.00471222f, 0.04361750f, 0.10792522f, 0.05572550f, 0.14805879f, 
    0.36511809f, -0.09104130f, 0.02246740f, 0.31210786f, 0.11199778f, -0.06638774f, 0.03537040f, 0.09781875f, 
    0.02764721f, 0.05081521f, -0.09965454f, 0.20466700f, -0.26788697f, -0.00854104f, 0.00690030f, -0.01643623f, 
    0.01505592f, -0.01011537f, -0.03357013f, 0.08129645f, 0.01002913f, -0.03951593f, -0.01542620f, -0.06973527f, 
    0.18402967f, 0.04840250f, -0.19445105f, -0.11608927f, 0.02235002f, -0.03116989f, -0.12106165f, -0.02003448f, 
    0.18010959f, -0.01393316f, 0.13463396f, -0.10998310f, -0.09914824f, -0.10637133f, 0.00310716f, -0.04549770f, 
    0.13211019f, 0.06471793f, 0.07498028f, -0.11626671f, -0.03367859f, -0.07974973f, 0.13423251f, 0.17804825f, 
    -0.02790502f, 0.24462561f, -0.06058669f, -0.17802417f, -0.14951836f, 0.14314865f, 0.07177661f, 0.01522728f, 
    0.06719168f, -0.07740719f, 0.10347030f, -0.08087602f, -0.14657950f, -0.11818169f, -0.21029569f, -0.08209874f, 
    -0.10595367f, -0.21164034f, -0.00872850f, 0.07557932f, 0.12049115f, 0.01991700f, 0.08961938f, 0.05833984f, 
    -0.24911523f, 0.28487340f, 0.01998134f, 0.10150786f, 0.06142392f, 0.04184605f, 0.01118191f, 0.16669571f, 
    0.09268818f, 0.02730775f, -0.13594435f, -0.02309710f, 0.02926479f, 0.13828820f, 0.05198702f, 0.17814870f, 
    -0.02686838f, -0.00810552f, -0.05521190f, -0.19039418f, -0.04574398f, -0.03266108f, 0.08740331f, 0.02223237f, 
    0.20434898f, 0.18000382f, -0.15753740f, 0.10900397f, 0.14557235f, -0.08736233f, -0.05472040f, -0.02808998f, 
    0.12504418f, -0.03384026f, 0.14759420f, 0.06845908f, 0.16566837f, 0.19216140f, -0.06028133f, -0.15408266f, 
    0.14898731f, 0.04692176f, -0.15371662f, -0.07063612f, 0.01155757f, -0.08781917f, -0.06289150f, -0.13537928f, 
    -0.25589886f, 0.21067634f, -0.06160447f, -0.22496587f, 0.17032273f, -0.06492779f, 0.11339550f, -0.15797673f, 
    0.01934391f, -0.11321156f, -0.13497660f, 0.01139589f, 0.06696869f, -0.14153139f, -0.10873786f, -0.00732477f, 
    -0.01365271f, -0.02652867f, 0.08029255f, -0.03855310f, 0.07882719f, 0.02048095f, -0.07955409f, -0.18989930f, 
    0.05244453f, -0.23846859f, -0.06804691f, -0.17710586f, 0.04595727f, -0.12937799f, 0.14004903f, 0.06563071f, 
    0.00760886f, 0.06226832f, -0.03998313f, 0.18421468f, -0.31547984f, 0.14653003f, 0.13129811f, 0.03154143f, 
    0.25760490f, 0.05051840f, -0.12889315f, 0.06087717f, -0.01588971f, 0.18991834f, -0.13607727f, 0.09423231f, 
    0.07494144f, 0.06821179f, -0.16814883f, -0.06460587f, 0.10600460f, -0.13637215f, -0.09165261f, -0.11248206f, 
    0.00136104f, -0.14503445f, -0.08278219f, 0.02429201f, 0.13606945f, -0.28553459f, 0.06379254f, 0.11260767f, 
    -0.11675536f, -0.10072705f, -0.14746909f, -0.22765908f, 0.00507194f, 0.02987028f, 0.09661452f, -0.06143880f, 
    0.33910924f, -0.21293366f, -0.31980193f, 0.10141014f, -0.04651897f, 0.00215853f, -0.07518794f, -0.09306800f, 
    0.01167471f, 0.06468010f, -0.02163452f, -0.00659309f, -0.07612082f, -0.05222838f, -0.00192330f, 0.02548806f, 
    0.01426381f, -0.02456647f, -0.00078096f, -0.03438571f, -0.04321639f, -0.01808019f, 0.05089360f, 0.05367279f, 
    0.02698092f, -0.11736649f, 0.00970662f, -0.10820884f, 0.13777979f, 0.05950503f, -0.03863802f, -0.11002196f, 
    0.03254249f, 0.08350451f, -0.04139316f, 0.13672996f, -0.07131619f, -0.02638410f, -0.03621023f, 0.10835035f, 
    -0.06187253f, -0.00950755f, 0.01689172f, -0.00402554f, -0.03569901f, 0.02851894f, 0.07757554f, -0.12566416f, 
    0.19358547f, 0.10022634f, 0.14215364f, -0.05896576f, 0.04650718f, 0.05523647f, -0.05911495f, 0.21303478f, 
    -0.06603199f, 0.10339710f, 0.01754967f, 0.02812091f, -0.07083920f, -0.05377924f, -0.16310382f, -0.14956224f, 
    0.14030533f, -0.06131300f, -0.12766416f, -0.04687212f, -0.03841521f, 0.04161520f, 0.06824674f, -0.04683139f, 
    0.38326573f, 0.06475066f, 0.10650351f, 0.05402306f, 0.12763749f, -0.00319402f, 0.14410374f, 0.08004119f, 
    0.07137910f, 0.10963745f, 0.01414036f, 0.06085101f, 0.00340458f, 0.11177154f, -0.02568056f, 0.03336083f, 
    0.09353129f, 0.01401808f, -0.07116101f, -0.01857587f, -0.06708584f, -0.00393370f, -0.08545139f, -0.07170285f, 
    0.04864041f, 0.18850842f, 0.15208788f, -0.11481430f, 0.06830300f, -0.05497152f, 0.06442484f, 0.01243538f, 
    0.00023294f, 0.04035265f, 0.11970320f, 0.00865254f, -0.02937746f, 0.11729685f, 0.00877135f, -0.21846367f, 
    -0.00624544f, -0.12345870f, -0.14366928f, 0.01639973f, -0.07683378f, 0.07480845f, -0.10452766f, 0.00314823f, 
    0.36921510f, 0.18685709f, 0.19816203f, -0.15535027f, -0.04035275f, -0.02400276f, 0.02529345f, -0.12187520f, 
    -0.03978068f, 0.05776042f, -0.05901913f, 0.03811551f, -0.05946999f, 0.19541092f, 0.11648528f, 0.19116107f, 
    -0.01745177f, 0.11487441f, -0.01321390f, -0.17290635f, -0.02370425f, 0.08815677f, 0.14204440f, -0.04577612f, 
    0.50009125f, 0.00650261f, -0.21455029f, -0.04712501f, 0.11585052f, -0.04422902f, 0.03242034f, -0.04121444f, 
    -0.03385909f, 0.13212045f, 0.08980653f, 0.07112883f, 0.32147905f, 0.09187021f, 0.13362277f, -0.09297253f, 
    0.04299254f, -0.04427424f, 0.12268154f, -0.08969309f, 0.09277916f, -0.00940178f, 0.06747036f, 0.00801945f, 
    0.08793627f, 0.02393041f, -0.11976011f, 0.22266306f, 0.03711563f, -0.08003531f, -0.16061784f, -0.15991002f, 
    0.08233193f, 0.11321011f, 0.03725256f, 0.16548979f, -0.04017616f, -0.03501873f, -0.11388566f, -0.01069965f, 
    -0.00760589f, -0.01890964f, 0.30682063f, 0.02727865f, 0.00625660f, -0.20392001f, -0.05778148f, -0.12600228f, 
    0.02344838f, 0.05765987f, -0.01155136f, 0.15089589f, 0.10863758f, 0.03449522f, -0.17750075f, -0.12296474f, 
    -0.05779856f, -0.15014499f, 0.00879399f, -0.01138908f, 0.06361230f, -0.25609353f, -0.13473256f, 0.17041245f, 
    0.03401897f, 0.15961018f, -0.02162577f, 0.03878659f, 0.02430005f, 0.00943709f, 0.01560805f, 0.06041763f, 
    -0.12005387f, 0.21463907f, 0.07537109f, 0.08404545f, -0.08532491f, -0.00286260f, 0.10467948f, -0.06397928f, 
    0.05937525f, -0.06553210f, 0.07391861f, 0.00516925f, 0.12240905f, -0.10011559f, 0.34063950f, -0.03772980f, 
    0.07747991f, -0.06124598f, -0.12016997f, 0.04047313f, 0.13895303f, -0.03838542f, 0.07056887f, -0.11634010f, 
    -0.12742990f, 0.23313124f, 0.02482588f, -0.11912335f, 0.06794826f, -0.21009479f, 0.14511117f, -0.00990208f, 
    -0.03183588f, -0.01365889f, 0.05127220f, 0.04183283f, 0.10480799f, -0.13295078f, 0.09924661f, 0.13672926f, 
    -0.05626389f, 0.02690136f, -0.15238604f, 0.02086666f, 0.14564763f, 0.08155134f, 0.13560745f, -0.10759158f, 
    -0.14531428f, -0.01242853f, 0.23712949f, -0.00007775f, -0.16362476f, 0.12305782f, -0.01157415f, 0.00311242f, 
    -0.04091377f, -0.12556000f, -0.03507848f, 0.02730985f, -0.02361947f, 0.29617104f, 0.03195420f, 0.05283297f, 
    -0.08107077f, -0.00623927f, 0.02517866f, 0.08750542f, 0.00285364f, 0.01777475f, -0.15629724f, 0.02580792f, 
    -0.28168303f, -0.14537741f, -0.08744083f, -0.12776011f, 0.03639184f, 0.10195695f, -0.06355588f, -0.05248016f, 
    0.07817411f, 0.18366130f, 0.00876545f, 0.01281284f, 0.04678910f, -0.16581343f, 0.05283653f, -0.06760609f, 
    -0.05191045f, 0.17331587f, 0.09812596f, 0.14421514f, 0.06841484f, 0.00397136f, -0.07042729f, -0.01667913f, 
    -0.35556230f, 0.18410662f, 0.15166928f, 0.09152131f, -0.11931875f, 0.11188755f, 0.08425264f, 0.08511351f, 
    0.02688758f, 0.23685303f, 0.12490373f, 0.13952692f, 0.61840808f, 0.03072308f, -0.08243869f, -0.06632264f, 
    0.02689959f, 0.03140597f, 0.12429177f, 0.04262563f, -0.04068878f, -0.13240476f, 0.07185394f, 0.06354656f, 
    -0.28578797f, -0.10757311f, -0.11862611f, 0.13689516f, 0.07428411f, 0.03080737f, 0.00181287f, -0.03865022f, 
    0.08463280f, 0.08739086f, -0.12406042f, -0.01289777f, 0.09471213f, 0.04157217f, -0.19271794f, -0.10305795f, 
    -0.04898388f, -0.03236267f, -0.05791081f, 0.08170231f, -0.08175769f, 0.00064144f, -0.06722337f, -0.05388490f, 
    -0.04055662f, 0.03734660f, -0.02956285f, 0.03819581f, -0.05075561f, 0.05675064f, -0.02838504f, -0.04997506f, 
    -0.07255480f, -0.04428865f, -0.02926500f, -0.05295082f, -0.04956710f, 0.04675082f, 0.01389764f, -0.03139132f, 
    0.04451162f, 0.02260718f, -0.03614059f, 0.00837106f, -0.00500850f, 0.03267469f, 0.02989500f, 0.03254766f, 
    -0.07176936f, 0.04426212f, 0.05359266f, -0.07690167f, -0.03846694f, -0.04711367f, -0.01515638f, 0.02294872f, 
    0.03577578f, -0.07710711f, -0.00131188f, -0.02187656f, -0.03074597f, 0.00457476f, -0.04691371f, 0.02692661f, 
    -0.03174119f, -0.00343952f, -0.01093133f, 0.00071228f, -0.07372320f, -0.01843756f, -0.04632669f, 0.00962665f, 
    0.02697651f, -0.01426944f, -0.01850589f, -0.05087687f, -0.02768857f, -0.04540017f, 0.02299207f, -0.00655878f, 
    0.03343046f, -0.02772657f, -0.01329158f, 0.03755835f, 0.02830107f, 0.05400367f, -0.02405693f, -0.02013118f, 
    -0.01589619f, 0.00182471f, 0.01776923f, 0.06018798f, 0.02751805f, -0.05181415f, 0.04919922f, 0.04723534f, 
    0.03481094f, 0.03841345f, -0.05067669f, -0.02862884f, 0.06060887f, -0.02779672f, 0.05369175f, -0.04705307f, 
    -0.04149854f, 0.03737634f, -0.06370720f, 0.04870075f, -0.01377323f, -0.07047010f, -0.07196588f, 0.01873741f, 
    -0.05351096f, 0.02066921f, 0.02422647f, -0.00069740f, 0.06582847f, 0.01854920f, 0.05745043f, -0.01379660f, 
    0.02794250f, 0.06245524f, -0.07693723f, -0.04371780f, -0.06968680f, -0.06850764f, -0.02061591f, -0.01105042f, 
    0.06002725f, -0.04588645f, -0.07110310f, 0.01992770f, -0.04673202f, 0.00321158f, 0.03134090f, -0.07161561f, 
    -0.00566833f, -0.07346576f, 0.00641283f, 0.01615068f, 0.00839996f, -0.01587283f, -0.06675835f, 0.00639221f, 
    -0.04968229f, 0.00876002f, 0.01260962f, 0.01280362f, -0.06866655f, 0.04369008f, -0.01482888f, -0.00133446f, 
    -0.01244208f, -0.05789667f, 0.05289539f, -0.02373905f, -0.02645547f, -0.03384371f, 0.00853360f, -0.06077493f, 
    -0.04184626f, -0.07359080f, -0.00183696f, 0.03453375f, 0.00141754f, 0.02080271f, -0.03403886f, 0.05559123f, 
    0.01685080f, 0.01237138f, -0.04494666f, 0.04229642f, -0.03573654f, 0.00861177f, -0.05038280f, -0.04930003f, 
    -0.05198317f, 0.03244396f, -0.05554435f, -0.04957430f, 0.05828460f, -0.02721301f, 0.06015700f, 0.01691099f, 
    0.00751006f, -0.07498650f, -0.02027625f, -0.06068636f, -0.00612458f, 0.05948852f, 0.03489621f, -0.06214724f, 
    0.01898813f, -0.05521700f, 0.05916367f, -0.00486848f, 0.05865248f, -0.06367844f, 0.05009836f, -0.07059590f, 
    -0.03714179f, -0.06728087f, 0.00196647f, -0.03048539f, 0.07047690f, 0.00136568f, -0.07018624f, -0.04524659f, 
    0.06292522f, 0.04570629f, -0.07796318f, -0.07194415f, -0.01541968f, -0.02190308f, 0.00897188f, -0.02169285f, 
    0.01480198f, -0.00994694f, -0.03009500f, -0.06882883f, -0.06070744f, -0.04436314f, -0.05715567f, -0.04702361f, 
    0.04372769f, -0.07130954f, 0.02530568f, -0.04501649f, -0.00275044f, 0.03552679f, 0.06178297f, -0.03772585f, 
    -0.02857836f, 0.04478185f, -0.07154834f, -0.05043588f, 0.02954312f, -0.06270496f, 0.01633007f, -0.04767579f, 
    -0.02253087f, -0.07195546f, 0.04366767f, -0.05381227f, -0.02834181f, -0.01149142f, 0.03134134f, -0.02562140f, 
    -0.02649409f, -0.02724464f, -0.05484778f, 0.02474034f, 0.01907357f, 0.02204971f, -0.07675039f, 0.02058164f, 
    0.06586523f, 0.00509539f, 0.03064804f, -0.00550624f, 0.00277281f, 0.05252320f, -0.03921220f, 0.04498873f, 
    -0.04213687f, -0.05943174f, -0.02891245f, -0.04738601f, -0.00194511f, 0.01106249f, -0.00492152f, 0.05938694f, 
    -0.05648267f, 0.04643894f, 0.01020036f, 0.00764398f, 0.01524143f, 0.00089451f, -0.04645794f, 0.00735968f, 
    -0.05826240f, -0.04706445f, -0.06596091f, -0.05991870f, -0.05074036f, -0.04601042f, -0.02424518f, -0.06293337f, 
    -0.06339262f, -0.03827951f, -0.02484209f, -0.04410097f, -0.05104297f, 0.05276690f, 0.02678564f, 0.00277969f, 
    0.04182852f, 0.03329935f, 0.04174057f, -0.07470416f, -0.04254441f, -0.06240183f, 0.00670539f, -0.01597754f, 
    -0.00360565f, 0.01514433f, 0.04749818f, -0.05351928f, -0.02059168f, -0.02928251f, -0.06312551f, 0.02323292f, 
    -0.03713082f, 0.02357799f, -0.01282542f, 0.06603825f, -0.07217830f, -0.01555601f, 0.03996036f, -0.05601410f, 
    0.04322723f, 0.06374332f, 0.01464706f, -0.02534897f, -0.06577379f, 0.00673186f, 0.00057364f, -0.07070289f, 
    0.03484731f, 0.02419681f, -0.02773617f, -0.05998567f, -0.03689651f, -0.07743918f, -0.00726104f, -0.01065177f, 
    -0.04112166f, 0.01700059f, -0.00489586f, -0.00027220f, -0.03530792f, 0.00008287f, -0.00934175f, 0.00249984f, 
    -0.01066264f, 0.05735883f, -0.02620569f, 0.01075529f, 0.06119477f, -0.04972573f, 0.02011240f, 0.06024462f, 
    0.06342366f, 0.04803555f, -0.07814592f, -0.00538307f, 0.02745859f, 0.04514223f, -0.01807174f, -0.05609716f, 
    0.01389260f, -0.03249049f, -0.07116318f, 0.03161309f, -0.07277060f, -0.01858087f, 0.06096015f, -0.03286739f, 
    -0.05268949f, 0.00616073f, 0.03936275f, -0.07679916f, -0.01997408f, -0.07306447f, 0.04528442f, -0.02678796f, 
    -0.00004282f, 0.02193065f, -0.02576922f, -0.02131787f, 0.06478383f, 0.02220166f, 0.05090072f, 0.05047392f, 
    -0.05530142f, -0.05715499f, -0.06823692f, 0.04610230f, -0.02403293f, -0.04958990f, -0.01910520f, 0.00544913f, 
    -0.07037474f, 0.03259609f, -0.07664370f, 0.02042228f, 0.02763181f, -0.00301481f, -0.05625716f, -0.07021437f, 
    0.04363386f, -0.01399915f, -0.04118049f, 0.00913771f, 0.02850956f, 0.00544954f, 0.06175875f, 0.04828966f, 
    -0.05660506f, -0.01625198f, -0.06221317f, -0.06758741f, 0.05772806f, -0.07497614f, 0.04047344f, -0.07832804f, 
    0.06057169f, 0.02752456f, 0.02015538f, -0.01031660f, 0.05262905f, 0.05119304f, -0.04836538f, 0.05499757f, 
    0.01239548f, 0.00667392f, 0.04669670f, -0.01394453f, -0.03326787f, 0.00557649f, 0.04942761f, 0.00496849f, 
    -0.03627341f, -0.02760459f, -0.03124094f, 0.00067720f, 0.06256144f, -0.06845638f, 0.01391357f, 0.01195554f, 
    0.03464485f, 0.04127496f, 0.00692422f, 0.02507315f, 0.03412738f, -0.00379450f, -0.06057460f, -0.01013161f, 
    0.01246546f, -0.07849070f, -0.06207826f, -0.07121635f, -0.07077331f, -0.02216340f, 0.04728521f, -0.06706854f, 
    -0.07951141f, -0.01277239f, -0.02885987f, -0.02061066f, 0.01333105f, 0.03195711f, -0.01253386f, -0.06415546f, 
    -0.02434126f, -0.02277228f, -0.02487608f, 0.02933269f, -0.03744546f, 0.01740261f, 0.00531748f, 0.01221185f, 
    0.02895533f, 0.05727591f, -0.03557647f, -0.06408130f, -0.02467597f, -0.05291515f, 0.01578679f, 0.05938911f, 
    0.02912356f, -0.00743270f, 0.04071885f, 0.03877198f, -0.02912205f, 0.02890564f, 0.01342937f, -0.04852236f, 
    0.04841856f, 0.03419264f, 0.01927239f, 0.03343922f, -0.05039817f, 0.00379587f, 0.00953402f, -0.05686522f, 
    -0.06026334f, -0.00779634f, -0.02970347f, 0.01655148f, 0.07007979f, 0.03779380f, -0.01489781f, 0.02342548f, 
    -0.01696757f, -0.04628675f, -0.05584859f, -0.07809926f, -0.05853770f, 0.03355085f, -0.02343057f, 0.01955937f, 
    -0.06970017f, 0.03080667f, 0.04477124f, 0.04894396f, -0.04197704f, -0.03107337f, 0.01625771f, -0.07465120f, 
    -0.01116885f, -0.06208810f, -0.02885833f, 0.01955568f, 0.04596071f, -0.03409008f, -0.05577433f, -0.05331748f, 
    -0.01817795f, -0.06122418f, 0.05779014f, 0.04432153f, -0.06797077f, 0.02067527f, -0.05135033f, 0.00407437f, 
    -0.06929535f, -0.04224466f, 0.05574418f, 0.01807957f, -0.02959899f, -0.00332080f, 0.01582774f, -0.04596009f, 
    -0.05593058f, 0.01665252f, -0.01670825f, -0.03464384f, -0.06229892f, -0.03205734f, -0.00625775f, -0.07811205f, 
    0.01851249f, 0.04695235f, 0.04463233f, -0.04101778f, -0.03329569f, -0.02590510f, -0.01758532f, -0.02274822f, 
    -0.01971005f, 0.02586753f, 0.03072471f, -0.03090520f, -0.07245217f, -0.05327286f, -0.04110542f, -0.04130864f, 
    -0.07171787f, -0.05492382f, -0.05252830f, -0.06071008f, 0.05485276f, 0.02565992f, -0.05130269f, -0.00134196f, 
    -0.07158950f, -0.00289492f, 0.04368737f, 0.05333715f, -0.02481951f, 0.05916528f, -0.01380641f, -0.02704120f, 
    0.06232847f, -0.00233100f, 0.00334682f, -0.03876455f, -0.06986320f, 0.02717844f, 0.03525085f, -0.01432001f, 
    0.00014216f, -0.06156659f, 0.06378979f, -0.04261398f, 0.06162119f, -0.00200987f, -0.05085489f, -0.01192135f, 
    -0.02875259f, -0.03170332f, 0.00562140f, -0.04003968f, -0.05700925f, -0.00382266f, 0.01696927f, -0.03489379f, 
    -0.05326258f, 0.06158610f, 0.02800820f, 0.04662710f, -0.00379671f, 0.01896738f, 0.04314793f, 0.01552901f, 
    -0.05556259f, -0.01079058f, 0.05076770f, 0.02449433f, -0.03209669f, 0.06015172f, -0.04905272f, -0.00711014f, 
    -0.02704834f, -0.04466715f, 0.02868336f, 0.00633779f, -0.02457960f, -0.03717917f, 0.05245547f, -0.04003759f, 
    -0.07490170f, -0.07100122f, -0.01784926f, 0.00332603f, 0.03922532f, 0.05839483f, -0.02723386f, -0.02826723f, 
    -0.01150287f, -0.00075286f, -0.07404341f, 0.01852306f, -0.04867788f, 0.06732690f, 0.06581240f, -0.07458183f, 
    0.00966396f, -0.00674413f, 0.00965892f, 0.01252612f, -0.08368888f, -0.05846111f, -0.00835103f, 0.00080917f, 
    -0.05066996f, 0.04488695f, -0.03592493f, -0.01398800f, 0.04580653f, 0.01884653f, 0.03017777f, -0.04242036f, 
    0.05601055f, 0.02210934f, -0.05188965f, -0.00816265f, 0.00277452f, 0.00701432f, 0.04395221f, -0.04590937f, 
    0.04798273f, -0.01693511f, -0.03467716f, -0.02170706f, -0.05836901f, -0.03606636f, -0.05171805f, -0.05091026f, 
    -0.00475542f, 0.01946699f, -0.02215978f, -0.04711916f, 0.06634523f, -0.01302215f, -0.04634675f, -0.07359041f, 
    -0.03255297f, -0.06865035f, -0.00766134f, 0.04460179f, -0.05721622f, 0.02448997f, 0.03899463f, 0.01593691f, 
    -0.03751041f, -0.02587996f, 0.00026117f, -0.01428182f, -0.07220078f, 0.03131897f, -0.06430376f, 0.06001491f, 
    -0.03072378f, 0.02676049f, -0.04675841f, -0.03063328f, -0.02575432f, -0.04588931f, -0.01582510f, -0.04644841f, 
    -0.03991292f, 0.04819668f, 0.04245703f, -0.03897179f, -0.00945345f, -0.06351042f, 0.03549207f, -0.01064659f, 
    0.00014740f, -0.02960370f, 0.05868387f, 0.00931211f, 0.00659977f, 0.05356844f, -0.02030374f, -0.05361872f, 
    -0.01351269f, -0.07616474f, 0.05496374f, 0.02105384f, 0.05201641f, 0.05158940f, -0.07056075f, 0.05791660f, 
    -0.06945719f, -0.07610150f, 0.05742015f, 0.05980676f, 0.05970131f, 0.03756675f, 0.01625382f, -0.03111941f, 
    -0.06649448f, -0.04756040f, 0.02778970f, -0.05736069f, -0.06649782f, -0.06005770f, 0.02100089f, 0.04970697f, 
    0.02780003f, -0.07906773f, -0.00842765f, -0.05919309f, -0.00880449f, -0.07785404f, -0.02415094f, 0.03705838f, 
    0.01122992f, 0.02106337f, 0.01171867f, 0.05352879f, -0.02071736f, -0.02439367f, 0.03463005f, -0.05388980f, 
    -0.05217090f, -0.01956046f, 0.00880455f, 0.03773620f, -0.02951214f, -0.07580744f, -0.07977629f, 0.03701104f, 
    0.05113888f, -0.00499362f, -0.07338377f, 0.06097290f, -0.00677537f, -0.06718950f, -0.06521718f, -0.00532007f, 
    -0.04740489f, -0.01718730f, 0.05031049f, -0.07697683f, 0.05522751f, -0.01804046f, -0.04450232f, 0.01066373f, 
    0.02650708f, 0.15987779f, 0.09105562f, 0.23948045f, 0.01088668f, -0.06703345f, -0.06301078f, -0.20866150f, 
    -0.10037877f, -0.01877222f, -0.02875958f, 0.09415901f, -0.20172739f, 0.08372928f, -0.01578952f, -0.13317637f, 
    -0.14320774f, -0.08836398f, 0.06300748f, -0.03232671f, 0.05357556f, -0.07055448f, -0.04336622f, -0.17278081f, 
    0.29796088f, -0.09886181f, -0.01124962f, 0.22074014f, -0.09194180f, 0.08055478f, -0.20014374f, -0.12364897f, 
    -0.09223210f, -0.08914274f, -0.21285334f, -0.04769232f, -0.11894874f, -0.19563621f, -0.31807348f, 0.16693388f, 
    0.16300893f, 0.09785610f, -0.17136364f, -0.01983264f, 0.07621688f, -0.13000476f, 0.01944317f, -0.06033305f, 
    0.03653673f, 0.31007540f, 0.05160608f, 0.26605684f, -0.00718688f, -0.06155819f, 0.16788474f, -0.08152409f, 
    -0.01923580f, 0.05285437f, -0.03570388f, -0.05943204f, 0.14161398f, 0.08134431f, 0.17501910f, -0.04384533f, 
    0.21274583f, -0.06349666f, 0.03182682f, 0.03414119f, 0.17754745f, -0.00406932f, 0.08016911f, 0.05949586f, 
    -0.31343794f, 0.33096805f, 0.01260960f, -0.32981893f, 0.10483013f, 0.02235723f, 0.03046525f, -0.02925003f, 
    0.13212664f, 0.03924776f, 0.02172014f, -0.03619584f, 0.11552323f, -0.11754799f, 0.04600224f, 0.38543105f, 
    -0.15043405f, -0.04646454f, 0.00560868f, -0.03857528f, 0.12573707f, 0.13612801f, 0.06351240f, 0.02065761f, 
    -0.14841703f, 0.24040781f, 0.05886127f, 0.20573796f, 0.04440366f, 0.04851679f, 0.00586506f, 0.02437642f, 
    -0.13069738f, -0.01463334f, 0.06517645f, 0.05180323f, -0.13642450f, 0.33117911f, 0.07230503f, -0.04630394f, 
    -0.09529363f, -0.09395017f, -0.01702179f, -0.09893204f, 0.00496055f, -0.02882902f, -0.13377032f, 0.06914097f, 
    -0.31961524f, -0.19313608f, -0.21762349f, -0.09053319f, -0.03725271f, 0.04840860f, -0.03171919f, -0.10004856f, 
    -0.06484891f, 0.03134619f, -0.17830311f, -0.07206052f, 0.05072759f, -0.03113329f, 0.08313656f, -0.03434427f, 
    -0.03941571f, 0.21088462f, 0.03393264f, -0.03132910f, 0.02969370f, -0.01300010f, -0.02462840f, -0.00563145f, 
    -0.14408655f, 0.26917732f, 0.07661573f, 0.02437186f, 0.14011844f, 0.05748739f, 0.21325456f, 0.10886259f, 
    0.05577096f, 0.17551364f, 0.06455266f, 0.04162914f, 0.31176987f, 0.01591957f, -0.18840647f, 0.00696767f, 
    0.19536561f, 0.23219424f, 0.10131516f, -0.06087890f, 0.10443782f, 0.00960933f, 0.02103917f, 0.16092277f, 
    -0.16945010f, -0.15938458f, -0.00455352f, 0.04656482f, 0.02380277f, -0.08253497f, 0.10405428f, -0.10120118f, 
    -0.01944705f, 0.04865218f, -0.07309510f, -0.06530204f, -0.10452323f, 0.21176781f, 0.09453861f, -0.17524031f, 
    0.13278931f, 0.00967199f, -0.03798248f, 0.02735612f, -0.06389971f, 0.00931979f, -0.13697003f, -0.20240788f, 
    -0.04847378f, 0.05475412f, -0.03727388f, -0.02763703f, -0.00541337f, -0.06577490f, -0.05146296f, -0.02136900f, 
    -0.06651968f, -0.04420248f, 0.00868323f, -0.07562459f, -0.05558855f, -0.02318165f, -0.02963309f, 0.03366413f, 
    -0.04278433f, 0.05927810f, 0.03507622f, 0.05577280f, 0.04487494f, -0.03011305f, -0.06369246f, 0.03932120f, 
    -0.05138354f, -0.00003257f, -0.02012698f, -0.04574810f, 0.02436321f, -0.04594640f, 0.05785481f, -0.06750246f, 
    -0.02242435f, -0.00092968f, -0.02398260f, 0.02550651f, 0.01798497f, -0.04169218f, 0.00369849f, -0.04979172f, 
    0.03210433f, 0.05108609f, 0.05888552f, 0.02701203f, -0.02625936f, -0.06677359f, 0.04469848f, -0.05028263f, 
    -0.01780767f, 0.04410827f, 0.03232911f, -0.00239371f, -0.08088146f, 0.04803003f, -0.02522322f, -0.05214850f, 
    0.02742207f, 0.05014696f, 0.01773666f, -0.02750371f, -0.05162933f, 0.04227876f, -0.06257491f, -0.05062030f, 
    0.06290323f, -0.04640483f, 0.02393979f, -0.00231964f, -0.04977504f, -0.02465692f, -0.07479746f, 0.03720337f, 
    0.05188461f, 0.06177848f, 0.02357161f, -0.00522690f, 0.05231140f, 0.00451790f, -0.02404455f, 0.04117172f, 
    0.06622992f, -0.00365554f, -0.05290099f, -0.04167530f, 0.04695162f, 0.03255218f, -0.02812673f, 0.05832555f, 
    -0.02167142f, -0.05150229f, 0.00402529f, -0.05425965f, 0.01328733f, 0.02685557f, 0.00120679f, -0.05507271f, 
    -0.03153860f, 0.06287556f, -0.01173658f, -0.02616051f, -0.03265544f, -0.01624720f, -0.01911725f, -0.05113876f, 
    -0.02044898f, 0.02046111f, 0.01628493f, -0.00064730f, -0.07472645f, -0.03281906f, 0.03198352f, 0.04376256f, 
    -0.00883976f, -0.00493444f, 0.00781543f, 0.04672547f, -0.07176927f, 0.04897127f, -0.06848279f, 0.04332716f, 
    -0.04683148f, -0.02595554f, 0.03887326f, -0.02897885f, -0.08063325f, -0.00061094f, 0.04707260f, -0.02301103f, 
    -0.07134214f, -0.07360642f, 0.01896605f, 0.05751036f, -0.05240331f, 0.05606210f, -0.06961645f, -0.02124427f, 
    -0.00213468f, 0.05956538f, -0.04503833f, -0.03763500f, 0.03573809f, -0.00759570f, -0.02801467f, -0.07649557f, 
    -0.03841058f, -0.00438294f, -0.04193183f, 0.00209308f, 0.05270071f, -0.05017532f, -0.01125490f, 0.04194114f, 
    -0.03727369f, 0.04281452f, 0.00806076f, -0.00132476f, 0.02754336f, -0.03956494f, -0.00926281f, -0.01064789f, 
    0.00734080f, -0.02341815f, -0.06158378f, -0.02243912f, -0.07029793f, -0.02307226f, -0.01073531f, -0.05863214f, 
    0.01809354f, 0.01570025f, 0.03735790f, -0.00124533f, 0.02391310f, 0.00625833f, 0.06267348f, -0.05995544f, 
    0.02140003f, -0.06624145f, -0.06579199f, 0.05648240f, -0.06324995f, -0.00044209f, -0.02396197f, 0.05376669f, 
    0.04940469f, -0.02780299f, -0.03728644f, -0.07894155f, -0.00177591f, 0.05684963f, 0.01069603f, 0.06292910f, 
    -0.36468881f, -0.14854984f, -0.04435575f, -0.34738812f, 0.10042387f, 0.05616161f, -0.08827836f, -0.07931103f, 
    -0.04347113f, 0.15389274f, 0.03540076f, 0.18090189f, 0.09911915f, 0.03452617f, 0.12675647f, -0.06967212f, 
    0.06042786f, 0.05066927f, 0.15146813f, 0.08219425f, 0.04855672f, -0.12689091f, 0.04967805f, -0.08979946f, 
    -0.32393965f, 0.02686176f, 0.04651555f, -0.44231889f, 0.17623179f, -0.05234424f, -0.13454139f, -0.04456906f, 
    -0.04478985f, -0.03165331f, -0.02478261f, -0.17871749f, 0.20128044f, -0.02133816f, 0.00702803f, -0.14101978f, 
    0.13130486f, 0.11315001f, -0.00161782f, -0.03091085f, 0.02367358f, 0.11532243f, -0.00081125f, 0.14299157f, 
    -0.00827461f, -0.07087498f, -0.03068240f, 0.24490069f, 0.10783860f, 0.14843041f, 0.04517435f, 0.00234806f, 
    0.07578923f, -0.01923811f, 0.02912514f, 0.06280492f, 0.04494433f, 0.10162452f, 0.03136076f, 0.07334331f, 
    -0.21764125f, -0.08509455f, -0.01735770f, -0.23937236f, 0.04042117f, 0.10812183f, 0.01393072f, -0.07914145f, 
    -0.06994789f, -0.06724984f, 0.08717190f, 0.18128403f, -0.03007588f, -0.15883648f, 0.05669269f, 0.07932898f, 
    -0.14981769f, 0.10552141f, -0.04307955f, 0.00892705f, 0.10494715f, 0.22617123f, -0.05203875f, 0.08640125f, 
    0.11321398f, 0.21601187f, -0.05060679f, 0.14955139f, -0.00549398f, -0.11006532f, 0.04133873f, -0.00132254f, 
    -0.08538274f, -0.09276227f, -0.11751132f, -0.21941805f, -0.03950566f, 0.02465810f, -0.02691293f, -0.07099181f, 
    -0.12926367f, -0.00245170f, 0.04734656f, 0.00694038f, -0.24004704f, -0.24718919f, -0.03038513f, 0.13425691f, 
    0.01238357f, -0.06934218f, 0.21357737f, 0.13263217f, -0.05821404f, 0.09339456f, -0.05979560f, 0.15004042f, 
    -0.31700259f, 0.00000381f, -0.01275240f, 0.33760026f, -0.01976980f, 0.22708826f, 0.03396997f, 0.14404370f, 
    -0.06049576f, 0.09330193f, 0.06799166f, -0.03376216f, -0.06787771f, 0.17761700f, 0.01778238f, 0.31277385f, 
    -0.07687368f, 0.12121308f, 0.08602917f, 0.20931675f, 0.20214103f, 0.13140334f, 0.17856848f, 0.20876959f, 
    -0.10733328f, -0.08951827f, -0.08101109f, -0.03721292f, -0.12106754f, -0.06932878f, 0.00172151f, 0.10116074f, 
    0.09388977f, 0.08393510f, 0.02147369f, 0.08567608f, 0.17105722f, 0.00364459f, 0.04702504f, 0.15638000f, 
    -0.15785612f, 0.05278085f, 0.07714225f, 0.02625878f, -0.11712407f, 0.08097328f, 0.09942864f, 0.19757584f, 
    0.12535694f, 0.39799589f, 0.26430878f, 0.12404954f, 0.08178559f, 0.09257998f, 0.14167786f, 0.16276628f, 
    -0.02375733f, -0.05346582f, -0.10322200f, -0.01261871f, -0.01546189f, 0.06410199f, -0.04498566f, -0.20255771f, 
    0.06843060f, -0.06424749f, 0.11799145f, -0.05651896f, 0.08335507f, -0.02963076f, 0.16756293f, -0.04794956f, 
    -0.04229020f, -0.03572822f, -0.03292945f, 0.00877788f, -0.05846905f, 0.02398094f, -0.05012408f, -0.05921569f, 
    0.03599068f, 0.01987982f, -0.05649342f, -0.03623937f, 0.03786162f, 0.00768043f, -0.04115570f, 0.06831058f, 
    -0.07322061f, 0.00462173f, -0.01885578f, -0.03494318f, 0.00879011f, -0.03389320f, 0.05054695f, 0.02805007f, 
    0.01273087f, 0.04841724f, -0.00327887f, -0.02322000f, -0.07788905f, -0.07429277f, 0.04322414f, -0.05319470f, 
    -0.03650363f, 0.02468976f, -0.07397827f, 0.03019018f, -0.06433360f, -0.03007745f, -0.06450452f, 0.07098280f, 
    -0.02575654f, -0.07521640f, 0.04467440f, 0.02771243f, 0.01692810f, -0.05657217f, 0.03375018f, 0.00578936f, 
    0.03542530f, -0.06774738f, -0.01213365f, 0.00992046f, -0.03749141f, -0.07640531f, 0.05613375f, 0.00774316f, 
    0.03268207f, 0.03942291f, 0.04100602f, -0.00911496f, 0.01073521f, -0.03476951f, -0.02115219f, 0.00737620f, 
    -0.08403507f, -0.00632714f, -0.05001324f, -0.07136464f, -0.02331549f, -0.04971545f, -0.08572931f, -0.00556857f, 
    -0.03689518f, 0.01897611f, 0.01177860f, -0.05868538f, 0.02814150f, 0.01340632f, 0.01112599f, -0.04206296f, 
    -0.03897965f, 0.03964061f, 0.01278750f, -0.01198955f, -0.03945060f, -0.00295257f, -0.05173811f, -0.01538630f, 
    -0.07871695f, -0.07647264f, -0.06989792f, -0.02110450f, 0.00953607f, 0.05665800f, 0.01691198f, -0.05982045f, 
    0.00678945f, -0.07153865f, 0.04943072f, 0.03355082f, -0.02679689f, -0.03742457f, -0.06779565f, 0.05659353f, 
    -0.02466540f, 0.06359815f, -0.02606809f, 0.03284269f, 0.05424704f, -0.07054804f, 0.00503637f, -0.03550120f, 
    0.04676940f, 0.05610932f, -0.04655405f, -0.06032782f, -0.02918884f, 0.00910138f, -0.02849745f, -0.01341985f, 
    -0.05881554f, 0.07098591f, 0.02570174f, 0.00784624f, -0.05127526f, -0.06989557f, 0.05578781f, 0.03798840f, 
    -0.03001136f, -0.02518380f, -0.08000430f, -0.00499343f, 0.00594762f, -0.04357940f, -0.06876229f, -0.00366652f, 
    -0.08037990f, -0.01043440f, 0.05011579f, -0.07677409f, 0.05104509f, 0.00710857f, 0.05368027f, -0.01491977f, 
    0.00179601f, -0.06263327f, 0.08241951f, -0.03747991f, 0.01930787f, -0.08119503f, -0.00121775f, 0.00184254f, 
    -0.00355710f, 0.04273666f, 0.03073276f, 0.04130870f, 0.05746980f, -0.04138104f, 0.04344027f, -0.07058819f, 
    -0.06903949f, 0.05128384f, 0.04091674f, -0.06801757f, 0.03330230f, -0.02889124f, 0.02824146f, 0.01698178f, 
    0.02317312f, -0.01846950f, 0.00582092f, 0.05645464f, -0.04929566f, 0.03092886f, 0.03393626f, -0.06587850f, 
    -0.00448860f, 0.03468300f, -0.05389138f, -0.03998288f, -0.00021060f, 0.02622402f, 0.05922435f, 0.00398178f, 
    0.02696106f, -0.04554817f, -0.02994511f, -0.00045069f, -0.00609361f, -0.02333236f, 0.03150474f, -0.00162276f, 
    -0.14346610f, 0.18143865f, 0.10474662f, -0.39469945f, -0.03194726f, 0.03572169f, 0.04279106f, -0.01075852f, 
    -0.01114482f, -0.00073183f, -0.08551390f, 0.19504721f, -0.04225971f, 0.05760697f, 0.24667253f, -0.12322042f, 
    0.01642841f, 0.07911093f, 0.09758215f, 0.00784594f, -0.09477128f, -0.04363102f, -0.06564164f, -0.11776522f, 
    0.20177613f, -0.01721380f, 0.10864980f, -0.17824213f, 0.01280257f, 0.05286785f, -0.02031781f, 0.04877704f, 
    -0.09967483f, 0.02830124f, -0.01992697f, -0.01314557f, -0.01241366f, 0.11485878f, -0.19423942f, -0.13660534f, 
    -0.01293932f, 0.13975403f, -0.02872515f, -0.08021840f, -0.04961567f, 0.07228114f, -0.11430418f, 0.02210256f, 
    0.14859885f, 0.01680101f, -0.23029763f, 0.30715907f, 0.08850230f, -0.08821502f, -0.05032479f, -0.04951633f, 
    0.05553643f, -0.01958858f, -0.11538468f, -0.12749892f, 0.04668867f, 0.17055631f, 0.01332481f, 0.15649408f, 
    -0.08258678f, -0.07859410f, 0.04230731f, -0.12433030f, -0.01116003f, 0.06333328f, 0.01867642f, -0.08384277f, 
    -0.28462246f, -0.10031113f, -0.01849456f, 0.12570535f, -0.05113868f, -0.01712473f, 0.10356910f, -0.00064912f, 
    -0.05754649f, 0.01215785f, -0.03857072f, -0.00863935f, 0.03045783f, 0.08118869f, -0.01200948f, 0.09026113f, 
    -0.04879490f, -0.01316094f, -0.14545305f, -0.07922535f, -0.03196074f, -0.00455020f, -0.02161421f, 0.12617365f, 
    -0.08934943f, 0.06046114f, 0.01712388f, 0.03384757f, -0.03267130f, 0.07947533f, -0.02430508f, -0.01791892f, 
    -0.14041601f, -0.04547001f, 0.07295877f, -0.09214728f, -0.29836866f, -0.15331298f, 0.01310075f, 0.16908421f, 
    0.03702066f, -0.06613893f, 0.20577323f, 0.06131743f, 0.07984829f, 0.05809291f, 0.00561951f, 0.14351249f, 
    -0.26517951f, -0.01144835f, -0.04070856f, 0.29672796f, -0.04250877f, 0.06786326f, -0.03971118f, 0.19879742f, 
    0.01043498f, -0.05212877f, -0.15104429f, -0.12686870f, 0.07107248f, 0.13129881f, 0.02609985f, 0.23679066f, 
    -0.02076878f, 0.24048109f, 0.13351227f, 0.14581189f, 0.03666787f, 0.03987142f, 0.21252646f, 0.04759104f, 
    0.03472264f, 0.11336915f, -0.08787774f, 0.07100265f, 0.07012881f, -0.01512969f, 0.01738262f, -0.00223016f, 
    0.07749571f, 0.13405123f, 0.14322476f, 0.04925391f, 0.21645820f, 0.01344715f, 0.01135716f, 0.25470898f, 
    0.08793140f, 0.00341461f, 0.07485490f, 0.03720018f, -0.02810567f, 0.03689084f, 0.00757051f, 0.05434415f, 
    0.18042988f, -0.07370054f, 0.20176578f, 0.01607546f, 0.02352377f, 0.07160327f, 0.01225175f, -0.00238116f, 
    -0.02092359f, -0.04789420f, -0.03109898f, 0.00350613f, 0.10020863f, 0.13956381f, 0.06159925f, -0.08756554f, 
    0.04322338f, -0.03496055f, 0.04524393f, 0.04250979f, -0.01863911f, 0.01915168f, -0.03961809f, -0.04026783f, 
    -0.27736655f, -0.00673570f, -0.08959413f, 0.03628855f, -0.01842134f, -0.07691354f, -0.15136112f, 0.04667435f, 
    -0.08134078f, -0.02103558f, 0.12851512f, -0.04020849f, -0.23527646f, 0.24919765f, -0.22342563f, -0.20971982f, 
    -0.03281834f, -0.18917824f, -0.05476658f, 0.01760929f, 0.01627106f, 0.14028206f, 0.09316388f, -0.07891421f, 
    -0.31822258f, 0.02129487f, 0.04774167f, -0.00531466f, 0.07992188f, -0.11078997f, 0.06322312f, -0.03877211f, 
    0.03401615f, 0.07249705f, 0.01786344f, 0.03668537f, 0.04810943f, 0.08313017f, 0.00175677f, 0.13487253f, 
    0.17026269f, -0.07177411f, 0.05594993f, -0.04940571f, 0.15667145f, -0.06004787f, 0.04783711f, -0.12151038f, 
    -0.19603424f, 0.23463324f, 0.14370070f, -0.01979618f, -0.01371511f, 0.04069952f, -0.07466415f, 0.09195979f, 
    -0.00633764f, -0.02167487f, -0.00375753f, 0.00365224f, 0.24371788f, -0.14641686f, 0.14639333f, 0.15819104f, 
    0.23065823f, 0.24269949f, 0.15308928f, 0.03994503f, 0.01873950f, -0.01268620f, -0.05810749f, 0.03701561f, 
    0.12183933f, -0.07679480f, 0.20506731f, 0.04529138f, 0.14311354f, 0.01477875f, -0.00868527f, 0.01718293f, 
    0.07221267f, -0.00252835f, 0.06023908f, 0.03104043f, -0.06769829f, -0.06886989f, 0.20383465f, 0.40101486f, 
    0.05578277f, 0.06286530f, 0.10726546f, 0.00810630f, -0.05401167f, -0.00180372f, -0.05947167f, 0.11619551f, 
    -0.12066375f, -0.04212314f, 0.01813757f, -0.01785841f, 0.02356684f, -0.00370776f, -0.10082398f, -0.00191904f, 
    0.03875144f, 0.09989896f, 0.01037487f, 0.05234588f, 0.23690051f, -0.12227809f, 0.08300685f, 0.09353548f, 
    0.05199412f, -0.05097966f, -0.08070652f, -0.02204108f, -0.01483595f, 0.04581727f, 0.07691342f, -0.03471177f, 
    -0.26831508f, 0.07887772f, -0.09591071f, -0.06341440f, -0.02981307f, 0.01575347f, 0.00355575f, -0.11226457f, 
    0.09461699f, -0.19042628f, -0.00838695f, -0.03266015f, -0.35910800f, -0.01699692f, -0.07757151f, -0.03855217f, 
    0.05322216f, 0.11345768f, -0.04464862f, -0.15316428f, 0.04855356f, -0.22976691f, 0.00999483f, 0.07947920f, 
    -0.24132387f, 0.07720272f, 0.12813267f, 0.08006651f, 0.09808701f, 0.16606611f, 0.14507161f, 0.07956723f, 
    0.14330800f, -0.03244945f, -0.10144619f, -0.00639818f, 0.07752000f, -0.06624682f, 0.15383761f, 0.04148556f, 
    0.27262524f, -0.02749355f, 0.09419721f, 0.19029304f, 0.08498558f, 0.04144207f, -0.04077845f, 0.00493013f, 
    -0.19884402f, -0.01310202f, 0.25797430f, -0.07882433f, -0.02992938f, 0.04140981f, -0.19905777f, 0.00121776f, 
    -0.00717954f, -0.05012551f, 0.04914710f, 0.00852749f, -0.28600428f, 0.03472754f, -0.01610738f, -0.11213005f, 
    -0.05684322f, 0.03970464f, -0.08286969f, 0.09168165f, -0.05131209f, 0.00229023f, -0.07428437f, 0.15692854f, 
    0.23072396f, 0.12473049f, 0.10311686f, 0.03050643f, -0.03984588f, -0.06391348f, -0.14975539f, -0.10313082f, 
    -0.09163272f, 0.15688497f, -0.06447574f, 0.11757202f, -0.00914529f, 0.14162675f, -0.12718529f, -0.22123493f, 
    0.12240402f, -0.01129383f, 0.23509765f, 0.08327145f, 0.17226626f, -0.23017275f, 0.00628205f, -0.13872160f, 
    -0.02174724f, 0.12480092f, 0.08990292f, 0.00185633f, 0.08889926f, -0.06769633f, -0.26383477f, -0.13050951f, 
    -0.03203312f, -0.14342152f, 0.06643059f, -0.04916007f, 0.13883460f, -0.01321942f, -0.21316063f, 0.12989499f, 
    0.03577171f, 0.15555382f, -0.10354386f, -0.08504535f, -0.07384886f, 0.06869689f, -0.02309779f, 0.00812311f, 
    -0.16727138f, 0.10224822f, -0.02094086f, 0.07241183f, -0.02427922f, -0.03164182f, 0.14772965f, -0.04479235f, 
    0.01147718f, 0.06155274f, 0.00515454f, -0.08863670f, 0.27523011f, -0.15927890f, 0.28059456f, -0.02908423f, 
    0.07747597f, -0.10168909f, -0.15035500f, 0.00253892f, -0.01117517f, 0.02111920f, -0.08549801f, -0.15663284f, 
    -0.02878762f, 0.04953361f, 0.08174876f, 0.03619640f, 0.13797750f, -0.27295026f, 0.04833915f, -0.05281662f, 
    -0.04820053f, 0.07971161f, -0.02081538f, -0.03520697f, 0.05336178f, -0.06216298f, -0.10688141f, 0.15128872f, 
    -0.18508410f, 0.07657977f, -0.17137593f, -0.14089331f, 0.08745952f, 0.07012922f, 0.09691938f, 0.04876046f, 
    -0.08135083f, 0.00255530f, 0.23301370f, 0.08872195f, -0.20430286f, 0.23511422f, 0.04276340f, -0.09083528f, 
    -0.22373004f, -0.25963590f, 0.07975972f, -0.04954555f, 0.00667797f, 0.04911508f, -0.09747983f, 0.06912889f, 
    -0.00068656f, -0.04874208f, 0.12958601f, 0.17558311f, -0.05216689f, -0.05781747f, -0.13342991f, 0.06483235f, 
    -0.16642126f, -0.16132833f, 0.11786818f, -0.09124511f, -0.03723257f, 0.19297196f, 0.00819001f, -0.04853441f, 
    0.05103341f, 0.07281166f, -0.13562547f, 0.00860740f, 0.02964071f, -0.08033896f, -0.00808403f, 0.00279746f, 
    -0.23181537f, 0.13099657f, 0.04988175f, 0.09568821f, 0.00675856f, 0.15643661f, 0.11197566f, 0.02886384f, 
    -0.13340889f, 0.10581437f, 0.11895169f, 0.09707823f, -0.02379044f, 0.15340813f, 0.07701910f, 0.07692024f, 
    -0.02226856f, 0.26970702f, 0.14867835f, 0.05107195f, 0.70151758f, 0.10004964f, -0.10333364f, 0.20132887f, 
    0.04950250f, 0.05861694f, 0.12195840f, -0.04717768f, -0.09402908f, -0.01085347f, 0.06237885f, 0.20187959f, 
    -0.06481834f, -0.17449984f, -0.04038432f, 0.01919213f, 0.01881460f, 0.07397547f, -0.03237423f, 0.00416012f, 
    0.09462773f, 0.08933074f, -0.05055654f, -0.14802344f, 0.44074944f, 0.09933349f, -0.26619187f, -0.15394557f, 
    -0.02417616f, -0.05068893f, 0.00916528f, -0.04498781f, -0.03826976f, 0.03509013f, -0.02777367f, -0.07463747f, 
    -0.01645485f, -0.13416767f, -0.19131345f, -0.06347749f, -0.07627241f, -0.04301684f, -0.06388332f, 0.04259398f, 
    -0.01178031f, 0.01268221f, 0.02458626f, 0.05196645f, 0.06998458f, -0.14841944f, -0.13688843f, 0.09745108f, 
    0.06319315f, 0.05817248f, 0.16498169f, -0.06026887f, -0.02682745f, 0.02854380f, -0.02051986f, -0.04329360f, 
    0.02397407f, -0.12055461f, -0.18455052f, -0.11206318f, 0.02410681f, -0.11312109f, 0.00295098f, -0.03210004f, 
    -0.00327452f, -0.04239852f, 0.06175759f, -0.04773375f, 0.52358097f, 0.10654704f, 0.03215830f, -0.04330721f, 
    -0.01367944f, 0.10049340f, 0.10469186f, 0.13459255f, -0.08650777f, 0.05370328f, 0.11045776f, 0.09772177f, 
    0.14911115f, 0.08747817f, 0.17424306f, -0.03528633f, 0.03390120f, 0.14707315f, 0.06350555f, -0.00338859f, 
    -0.07927744f, -0.01472450f, -0.00646719f, 0.10214064f, 0.10097457f, 0.26691607f, 0.11156251f, 0.16809672f, 
    -0.07813737f, -0.06116033f, -0.05183255f, 0.08026870f, 0.00553646f, 0.11162490f, 0.01227130f, -0.16328804f, 
    0.23931073f, 0.05168665f, 0.05645090f, 0.13469596f, 0.09204610f, -0.00038476f, -0.03715774f, 0.26726010f, 
    -0.06924818f, 0.06783029f, -0.02100097f, 0.00616032f, 0.25316098f, 0.14062612f, 0.24204369f, 0.03682972f, 
    0.04858384f, 0.04246094f, 0.02722335f, -0.05360864f, -0.09161044f, 0.06706189f, 0.14829008f, 0.00298448f, 
    0.33737379f, -0.07136069f, 0.09990281f, -0.28025952f, 0.01691705f, 0.05616821f, 0.06188561f, 0.02750702f, 
    0.07957385f, 0.01234571f, -0.04027468f, 0.00728318f, -0.06020441f, 0.17827432f, 0.01733929f, -0.15049061f, 
    0.13209479f, 0.06717411f, 0.03899262f, 0.20675606f, 0.05136443f, 0.01130238f, -0.00515294f, -0.05665015f, 
    -0.16050744f, -0.10566144f, 0.08420885f, -0.08664057f, -0.05500529f, 0.02625449f, -0.00669878f, 0.07328127f, 
    -0.01370653f, 0.21811755f, -0.09519190f, 0.11131321f, -0.00806698f, -0.04461728f, 0.05099367f, 0.06391930f, 
    0.03835153f, -0.05857875f, 0.08374123f, -0.01437925f, 0.02333223f, 0.03261421f, 0.07221636f, 0.03446590f, 
    0.37122425f, -0.06109009f, 0.05119745f, 0.05369797f, -0.06844551f, 0.00287804f, -0.00098182f, 0.21696113f, 
    0.00692048f, 0.06830519f, 0.01923862f, -0.06757261f, -0.17695171f, 0.03143758f, 0.06261460f, -0.08004268f, 
    -0.02617113f, 0.02756993f, 0.09021023f, -0.01820087f, -0.02733313f, 0.03673299f, -0.01518469f, 0.05934817f, 
    -0.20209698f, 0.07084936f, 0.04586219f, 0.05244064f, 0.26165715f, -0.12148941f, -0.08262935f, -0.08399421f, 
    0.02545550f, 0.00705676f, 0.06563223f, 0.04108002f, 0.16364077f, -0.13922200f, 0.06949721f, 0.09058181f, 
    -0.10296508f, 0.02425487f, 0.04915366f, -0.16562176f, -0.03463970f, -0.05253816f, 0.12629999f, 0.09222496f, 
    0.11148743f, 0.05740932f, 0.09305234f, -0.04116882f, 0.22197719f, 0.07386328f, -0.09801528f, -0.14183265f, 
    0.00978350f, 0.04039022f, 0.00164219f, 0.02766021f, 0.12834875f, -0.00079521f, 0.09933198f, 0.05520580f, 
    0.10632108f, -0.00986274f, -0.17076451f, 0.05656934f, -0.02543630f, 0.10220270f, -0.06586710f, 0.01991632f, 
    -0.02039943f, 0.08646650f, 0.14989008f, 0.20383352f, 0.14156958f, 0.08667626f, -0.03604472f, -0.11364327f, 
    -0.04006496f, 0.07564986f, -0.04631573f, 0.03829204f, -0.25932300f, -0.03156418f, 0.03316341f, -0.16185391f, 
    -0.00257963f, 0.09440724f, -0.00627362f, 0.01596301f, 0.04631647f, -0.08871378f, -0.00049562f, 0.05525713f, 
    -0.25041130f, 0.10182070f, -0.23220059f, 0.15836416f, -0.03924019f, -0.01149714f, 0.07724117f, -0.03175218f, 
    -0.01412736f, 0.05552098f, 0.03316569f, -0.05852806f, -0.18966351f, -0.28798518f, -0.03511379f, -0.19304295f, 
    0.05033692f, -0.09425017f, -0.04222377f, -0.25367481f, 0.01665555f, -0.09367252f, 0.16339460f, 0.07039745f, 
    -0.05883255f, -0.27571529f, -0.08757099f, 0.23593006f, 0.01288990f, 0.00432551f, -0.12561235f, -0.05023871f, 
    0.12118926f, -0.09590455f, 0.10413946f, 0.01292375f, -0.29046330f, 0.24258836f, -0.11956770f, -0.19074920f, 
    0.09312412f, 0.18033388f, 0.05874043f, -0.10888564f, 0.14116283f, -0.02553306f, -0.00800815f, 0.07298013f, 
    -0.06249309f, 0.11362710f, -0.00483041f, 0.24946639f, 0.13428220f, -0.05289854f, 0.00111319f, -0.00314136f, 
    -0.08970372f, 0.15914825f, -0.01954644f, -0.06962570f, -0.16296959f, -0.17216970f, -0.15135978f, 0.23150994f, 
    -0.01279999f, 0.04050054f, -0.03640442f, 0.07794940f, 0.04054651f, -0.06671349f, 0.16429661f, -0.01031630f, 
    0.37859505f, 0.15882893f, -0.04768087f, -0.00048152f, -0.04950656f, -0.00799568f, 0.03354875f, 0.06184698f, 
    -0.13869627f, -0.04750360f, 0.00178476f, -0.01590007f, 0.05077741f, 0.15018286f, -0.03981907f, -0.04918786f, 
    0.18546993f, -0.08343557f, 0.07872190f, -0.02189644f, 0.17238088f, 0.18899499f, 0.24912976f, -0.02030107f, 
    -0.00813344f, -0.25624603f, -0.01604401f, 0.20239829f, 0.01801806f, -0.05288303f, -0.01473555f, -0.05237684f, 
    0.03004299f, 0.04145737f, 0.10774511f, 0.03621180f, -0.43889266f, -0.11896959f, 0.10379542f, -0.04063959f, 
    0.05731575f, 0.01082795f, -0.05235697f, 0.02399580f, -0.04110654f, -0.01960803f, 0.01041158f, 0.12318218f, 
    0.29736620f, -0.02455638f, -0.05791656f, -0.03838669f, 0.10268587f, 0.10679828f, 0.00557809f, 0.00330347f, 
    0.09244740f, -0.03882919f, 0.08218540f, -0.15031372f, 0.32475263f, -0.07759656f, -0.06569509f, -0.11718810f, 
    -0.02020141f, -0.00000613f, 0.04990409f, 0.21085039f, 0.07414652f, 0.18870749f, -0.05068034f, -0.04414119f, 
    -0.05760143f, 0.03747616f, 0.21212761f, 0.10409161f, -0.10330403f, 0.03260019f, -0.02129018f, -0.09898406f, 
    0.04278237f, 0.01958837f, 0.09757505f, -0.05947693f, 0.09406237f, -0.11880807f, 0.12155881f, 0.17448382f, 
    -0.03501064f, 0.09525158f, -0.16037013f, -0.05403962f, 0.02090609f, -0.01246583f, 0.00049922f, 0.11615717f, 
    -0.12042999f, -0.09792293f, 0.12682979f, 0.08947699f, -0.06878132f, -0.00724591f, -0.06168906f, -0.02418764f, 
    -0.00532814f, 0.21856356f, 0.04170571f, 0.18835205f, -0.20964459f, -0.12540197f, 0.12867811f, 0.02137144f, 
    -0.03379411f, 0.04939949f, 0.12858239f, -0.04813965f, 0.08039860f, 0.02711998f, -0.06105481f, 0.03766211f, 
    -0.03991419f, 0.03410606f, 0.07107093f, -0.25345135f, 0.00251452f, 0.13325152f, 0.13957341f, 0.03576431f, 
    0.09174325f, 0.08873678f, 0.00977548f, 0.12454811f, -0.14259970f, 0.03190957f, -0.06500313f, -0.05223933f, 
    -0.15784298f, -0.10828245f, 0.04011162f, 0.05317746f, -0.10177183f, 0.11061939f, 0.03568159f, 0.10701856f, 
    -0.11149268f, 0.13261408f, -0.18369052f, -0.12492657f, -0.09541312f, 0.18115838f, -0.01835920f, 0.00574394f, 
    0.04322364f, 0.06300239f, -0.05048303f, -0.00385453f, 0.19051832f, 0.19137938f, 0.10620366f, -0.26781526f, 
    0.02480978f, 0.15129742f, -0.07999695f, 0.06871706f, -0.03586722f, -0.03127655f, 0.16176762f, 0.02387050f, 
    0.07573765f, -0.02552703f, -0.26382145f, -0.16884579f, 0.08106670f, 0.08531975f, -0.00364017f, 0.08331480f, 
    -0.07733304f, -0.04180535f, 0.01490309f, 0.02359393f, -0.22748601f, 0.19091177f, 0.03810731f, -0.11664055f, 
    0.06909660f, -0.01057315f, -0.01511303f, -0.18823150f, 0.07346132f, 0.06050717f, 0.01573422f, 0.03906732f, 
    0.20259349f, 0.18465745f, -0.08545440f, 0.23795851f, 0.04713404f, 0.08726273f, 0.09597947f, 0.04889789f, 
    0.05814233f, -0.04936244f, 0.06055361f, 0.08616333f, 0.23922879f, 0.20478553f, 0.03565537f, 0.14750324f, 
    -0.01010469f, 0.10370775f, -0.16378181f, 0.11915856f, -0.05014008f, 0.09528158f, -0.20281073f, -0.03265245f, 
    0.07948307f, -0.07388932f, -0.13296436f, -0.37835580f, -0.01375112f, 0.03777077f, -0.02766866f, -0.12841247f, 
    0.03410883f, -0.07529056f, -0.06793693f, 0.09723043f, -0.03692012f, 0.07618233f, 0.06346808f, -0.03059549f, 
    -0.09369683f, -0.01513497f, 0.03499773f, -0.09590001f, 0.09861434f, 0.08298007f, 0.09790219f, 0.03535574f, 
    0.18359682f, 0.11572026f, -0.06689839f, 0.04011302f, -0.00452395f, -0.04986036f, 0.20828882f, 0.00794358f, 
    -0.05431367f, 0.08804558f, 0.08114497f, 0.05219259f, -0.04560491f, -0.20872368f, 0.05740526f, 0.02633791f, 
    0.07837670f, -0.09788053f, 0.04464547f, 0.02698453f, 0.18473274f, -0.07509290f, 0.06785539f, 0.04380737f, 
    0.05341239f, -0.04461266f, 0.03719671f, 0.07214309f, -0.05186230f, -0.00523685f, 0.08198506f, 0.00635548f, 
    -0.03766951f, -0.02986783f, -0.02921111f, -0.04206804f, -0.05728681f, 0.03829746f, -0.04581512f, 0.04059115f, 
    0.00734073f, 0.02662922f, 0.05795285f, 0.01060564f, -0.03573614f, -0.01378009f, -0.08856513f, -0.04082590f, 
    0.02704797f, -0.07213550f, -0.05486525f, -0.09025011f, -0.08103602f, 0.06230978f, 0.01817217f, -0.02500456f, 
    -0.01289184f, -0.03179661f, -0.02665515f, 0.02545629f, -0.00443089f, -0.03592324f, 0.02077827f, -0.03895967f, 
    0.04086951f, 0.01747368f, -0.01389424f, -0.04602350f, -0.03390783f, -0.04745180f, -0.06679074f, 0.04643638f, 
    -0.04493579f, -0.01197021f, -0.07982986f, -0.05964899f, -0.05848945f, 0.00928556f, -0.03465199f, -0.00751349f, 
    -0.01313343f, 0.00901110f, -0.04990526f, 0.04902255f, -0.04883412f, -0.06800787f, -0.01429107f, 0.02549783f, 
    -0.07119395f, -0.05062032f, -0.04490893f, 0.01467915f, 0.01138997f, -0.02079954f, -0.06466801f, 0.00686684f, 
    -0.01608502f, -0.03696155f, -0.06986004f, 0.03665562f, -0.05956113f, -0.08625336f, -0.04268610f, 0.03966100f, 
    -0.00630152f, -0.00827580f, 0.04287246f, 0.02347879f, 0.03569211f, 0.02538116f, -0.04508698f, -0.05132108f, 
    0.01039686f, -0.04433474f, 0.02258791f, -0.08162078f, 0.00095766f, 0.01425735f, -0.01163363f, -0.07001834f, 
    0.04693857f, -0.00938268f, -0.01025933f, -0.01100097f, -0.06622788f, 0.04784258f, 0.03832080f, 0.01227108f, 
    0.01900156f, -0.06660505f, -0.01596194f, -0.06269223f, 0.02805636f, 0.03531902f, -0.01617339f, 0.02510342f, 
    -0.08326948f, -0.08579498f, -0.03384861f, -0.08914827f, 0.00464353f, -0.00173568f, -0.03682360f, 0.02635464f, 
    -0.07813136f, 0.06367210f, 0.01361196f, -0.02748400f, -0.02624261f, 0.00499510f, 0.07766549f, -0.00826176f, 
    0.02128894f, -0.02177817f, -0.07392906f, 0.04974208f, -0.06314258f, -0.02703846f, -0.04033353f, 0.03538238f, 
    -0.07065546f, 0.05217674f, 0.00677723f, -0.02791366f, -0.01215017f, -0.07384682f, 0.02417351f, 0.01980244f, 
    0.05613239f, -0.07247801f, -0.03312469f, 0.06600387f, -0.08977188f, -0.03577847f, -0.05025697f, -0.07437035f, 
    0.00846175f, -0.01172322f, -0.03824496f, -0.07493231f, -0.02526912f, 0.06105214f, -0.04318419f, 0.03031925f, 
    -0.02464017f, 0.05420385f, -0.04988566f, -0.00791514f, -0.06199551f, -0.03710994f, -0.02851181f, -0.06198887f, 
    0.03584004f, 0.04416839f, -0.06156935f, -0.03436665f, -0.03113801f, -0.06254666f, 0.05242654f, -0.04581441f, 
    -0.00360400f, 0.04738050f, -0.00704626f, 0.01648612f, 0.07863352f, -0.00835143f, -0.02223345f, 0.02150720f, 
    0.05025001f, 0.02862125f, 0.01034140f, 0.02306646f, -0.03012588f, -0.06524454f, -0.00032791f, -0.03963964f, 
    -0.01820011f, 0.03214070f, -0.09707755f, -0.07455514f, -0.14467151f, 0.02006573f, 0.09856029f, 0.00686016f, 
    0.04312231f, 0.01940016f, 0.01390943f, 0.06667905f, -0.08721294f, 0.31890938f, 0.11668537f, -0.10478010f, 
    0.17857541f, -0.02798578f, 0.12052517f, 0.04921554f, -0.01335922f, -0.03781170f, 0.02465295f, 0.01688119f, 
    0.31801942f, -0.05847822f, 0.08532993f, 0.02535126f, 0.00767630f, -0.02505068f, -0.02538094f, 0.04145702f, 
    0.05019782f, -0.10622937f, 0.04224120f, -0.00097733f, 0.37473992f, 0.06684315f, -0.31206092f, -0.06686187f, 
    0.12073728f, -0.01464812f, -0.03981817f, 0.02151231f, 0.05661825f, -0.04710817f, 0.15298486f, -0.03270621f, 
    0.22185126f, 0.15427604f, 0.09366797f, 0.29891860f, 0.03411402f, -0.08257039f, -0.04069156f, 0.08854314f, 
    0.04400920f, -0.07710189f, -0.05590783f, -0.03266292f, 0.05379814f, 0.16189641f, 0.03183142f, 0.19639745f, 
    0.15276550f, 0.11994445f, -0.05703356f, 0.03375445f, 0.03079561f, -0.01581406f, -0.02124134f, 0.05459650f, 
    -0.04905885f, 0.05674116f, -0.02862677f, 0.00016100f, 0.02726621f, -0.10353409f, 0.10806400f, 0.00052920f, 
    0.02070065f, 0.07271315f, -0.04349516f, -0.07593857f, 0.02037704f, -0.11651129f, 0.18809469f, 0.46311545f, 
    -0.06771202f, -0.09506988f, 0.08296558f, -0.08657195f, 0.03881280f, -0.05207983f, -0.01542766f, -0.00302282f, 
    -0.25456730f, 0.10042865f, 0.00638446f, 0.09834403f, -0.08418714f, 0.08461506f, -0.07546562f, 0.01673823f, 
    0.04743947f, -0.03972464f, 0.06167595f, 0.03986205f, 0.12742946f, -0.01705279f, 0.08036818f, -0.02664861f, 
    -0.10129733f, -0.06072066f, 0.14469637f, 0.03808828f, -0.01409062f, 0.08047086f, -0.07238338f, -0.00272349f, 
    -0.07747539f, -0.15532880f, -0.04450634f, -0.01566120f, 0.06289253f, -0.00949208f, -0.04010343f, 0.07349453f, 
    0.12334228f, 0.02310668f, -0.01382425f, -0.06767992f, 0.00816740f, -0.06432714f, 0.00996752f, 0.00783149f, 
    0.01454758f, 0.02675504f, 0.08313054f, -0.08069956f, -0.06804650f, -0.11688416f, 0.02624830f, 0.04906964f, 
    -0.23159666f, 0.06351655f, -0.15220042f, 0.09310131f, 0.06839554f, 0.01774886f, 0.16289696f, 0.04343319f, 
    0.08872540f, 0.12966056f, 0.14992289f, 0.00873367f, 0.01885817f, -0.18034260f, 0.11048513f, 0.07671127f, 
    0.07941025f, 0.14057907f, -0.00248415f, 0.05042613f, 0.02766846f, 0.06290365f, 0.04347007f, 0.02241092f, 
    -0.25219232f, -0.14430471f, 0.18325989f, -0.05571442f, -0.00252307f, -0.05353773f, -0.07952177f, 0.11734767f, 
    0.03662276f, 0.02981792f, 0.01022870f, 0.04872534f, -0.41545454f, 0.13062900f, -0.11902136f, -0.04188598f, 
    -0.01533899f, -0.02307729f, -0.05704542f, -0.00758372f, -0.10349580f, -0.00934661f, -0.12826146f, -0.01452632f, 
    0.02009204f, -0.05860576f, 0.04544721f, 0.00803657f, -0.01216536f, -0.02764604f, -0.02288596f, -0.02453860f, 
    -0.03907978f, -0.07195394f, -0.00222387f, 0.04132767f, 0.03937187f, -0.05528642f, -0.04513451f, 0.03968605f, 
    -0.02914606f, 0.06404783f, 0.01499033f, 0.02046710f, 0.01194189f, -0.07125304f, 0.01038958f, -0.06285093f, 
    -0.00576657f, 0.05415127f, -0.03107049f, -0.05469313f, 0.02276961f, 0.01253863f, -0.03929946f, -0.01806492f, 
    0.02937559f, 0.02032099f, -0.01362432f, -0.01741399f, 0.02530936f, -0.03996849f, -0.05220186f, 0.05910218f, 
    -0.01545204f, 0.02063309f, 0.00004022f, -0.07438464f, -0.05136025f, 0.06186654f, -0.00661793f, 0.02629166f, 
    0.04731358f, 0.02909545f, -0.01827323f, -0.01397701f, -0.04683047f, -0.05774736f, -0.03685144f, 0.06496415f, 
    0.04127803f, -0.05023435f, -0.00480259f, -0.06516419f, -0.07241592f, 0.04709311f, -0.03692673f, 0.02198323f, 
    -0.04469730f, -0.05456383f, 0.03030975f, -0.05305083f, -0.00253725f, -0.01759486f, 0.01442464f, 0.04238532f, 
    -0.04873846f, -0.01816643f, -0.05158317f, -0.03888986f, -0.05258552f, -0.05758657f, 0.02663929f, -0.03455872f, 
    -0.06390228f, -0.02255103f, -0.06891632f, -0.05127854f, -0.00640883f, 0.00400170f, 0.02123779f, -0.01616443f, 
    0.06019416f, -0.02652767f, -0.03818427f, -0.05118944f, -0.02796444f, 0.03754042f, 0.00528038f, -0.03689324f, 
    -0.04626528f, -0.06905624f, -0.01836901f, -0.00042992f, -0.07168445f, 0.00699346f, -0.04337264f, -0.06602568f, 
    0.01221121f, 0.05388846f, -0.02871801f, -0.00320074f, 0.00385960f, -0.07722779f, -0.06363727f, -0.04058185f, 
    -0.02508093f, 0.03974760f, 0.04814323f, 0.03204412f, 0.02924551f, -0.00830338f, 0.06439045f, -0.04757858f, 
    -0.04505589f, -0.05491731f, -0.03011122f, -0.00543168f, 0.02064334f, -0.06272419f, -0.05679610f, -0.01125779f, 
    -0.02514928f, 0.01352112f, 0.00596936f, 0.02706754f, -0.02415444f, -0.05445154f, 0.05480645f, 0.02985704f, 
    0.00887598f, 0.03354344f, -0.03932014f, 0.05494805f, -0.05056148f, 0.00963299f, -0.00513940f, 0.02876800f, 
    -0.01876971f, -0.01137035f, -0.04673409f, 0.04473087f, 0.01319097f, 0.06208849f, -0.01433442f, -0.00434239f, 
    -0.02570662f, -0.07282698f, -0.01870930f, -0.01330523f, 0.05966133f, -0.03561403f, -0.01510871f, 0.03466929f, 
    0.01560436f, 0.02490174f, 0.03053831f, 0.02019098f, 0.00666754f, -0.01892849f, 0.02977328f, -0.00240624f, 
    0.00346138f, -0.06940965f, -0.02215229f, -0.03224079f, 0.01259911f, -0.05298633f, 0.00537532f, 0.00881492f, 
    0.05200750f, 0.03260118f, -0.00419350f, -0.04975491f, -0.01971734f, 0.03707976f, -0.04093933f, -0.01560443f, 
    -0.04653885f, 0.04599555f, 0.06633413f, -0.01608374f, 0.04041673f, 0.05892268f, -0.07048275f, 0.01144862f, 
    0.06146506f, 0.04389387f, -0.00511627f, -0.06031799f, -0.17241320f, -0.03408121f, 0.00900301f, 0.00046529f, 
    0.06395125f, 0.04909525f, 0.01777945f, 0.05764789f, 0.15446283f, 0.26899344f, -0.01318678f, 0.11602470f, 
    0.19205751f, 0.01731959f, -0.03643383f, -0.04129270f, 0.07807710f, 0.03885344f, 0.13947660f, 0.12814577f, 
    0.31266958f, 0.09391698f, 0.07203018f, 0.23540555f, -0.12287752f, -0.10264273f, 0.10279289f, -0.12291786f, 
    0.19293222f, 0.11979767f, 0.03574852f, 0.00311892f, 0.35516202f, 0.11456859f, -0.17490013f, -0.03881861f, 
    0.13489117f, -0.13776509f, -0.03361919f, 0.19565035f, 0.05380340f, 0.04206995f, 0.10549528f, 0.13238782f, 
    0.17760383f, -0.13713272f, 0.26517826f, -0.01818157f, 0.03138203f, -0.11636350f, -0.06034154f, -0.07028571f, 
    -0.00222072f, -0.03090375f, 0.05095363f, 0.15815170f, -0.24736744f, -0.15873735f, -0.07245367f, 0.18701781f, 
    0.09466946f, 0.18749703f, 0.07354044f, 0.08530182f, -0.08011433f, -0.16866654f, -0.07291468f, 0.02072309f, 
    0.09352897f, -0.17337354f, -0.20999324f, -0.05716515f, 0.27394521f, 0.07747414f, 0.10932116f, 0.17515545f, 
    -0.00329442f, -0.03400139f, -0.00418328f, -0.01726643f, -0.12396529f, -0.03693039f, 0.13410790f, 0.04303430f, 
    -0.01822605f, -0.13340585f, 0.06776728f, -0.06503045f, 0.10676734f, 0.05283335f, -0.03711183f, 0.09909832f, 
    -0.05777148f, -0.18854494f, -0.17457542f, -0.10479196f, 0.18216527f, -0.05156454f, 0.09769238f, -0.07725690f, 
    0.04004481f, -0.04006623f, -0.13375387f, -0.08703807f, 0.22064583f, -0.32762924f, 0.00415316f, -0.12200177f, 
    -0.05633619f, 0.16417840f, 0.15324925f, 0.18564874f, 0.04130859f, -0.06889721f, 0.00915918f, -0.15334229f, 
    0.10189425f, -0.03486905f, 0.22334433f, -0.14881796f, -0.04093025f, -0.07565425f, 0.12768196f, 0.04873072f, 
    -0.01410211f, 0.05377552f, 0.05305463f, 0.07491195f, -0.13022913f, 0.07748198f, 0.14867298f, -0.03556719f, 
    0.09053234f, -0.19250402f, 0.05478912f, -0.07534941f, -0.06733100f, -0.04527777f, 0.03027938f, 0.06575306f, 
    -0.04461759f, -0.25983527f, -0.26987037f, -0.04866629f, 0.28092095f, -0.02800623f, 0.03189453f, 0.15715940f, 
    -0.06159461f, -0.08620223f, -0.00936309f, -0.07263624f, -0.52619064f, -0.24535590f, -0.03461579f, -0.09485827f, 
    0.10938022f, 0.19196941f, -0.00847174f, 0.18168159f, -0.02841801f, 0.06043963f, 0.11598963f, -0.02996444f, 
    0.16332765f, 0.06157586f, 0.12816735f, 0.01297647f, -0.09358533f, 0.00081928f, -0.17143236f, 0.09880181f, 
    0.05913884f, 0.08720704f, 0.17957576f, 0.02907067f, -0.29656678f, -0.19556785f, -0.20590678f, 0.02746896f, 
    0.06909409f, 0.06535310f, 0.05803462f, 0.06925455f, -0.01445092f, 0.03490416f, -0.09938259f, -0.01351183f, 
    -0.02150889f, 0.02358284f, 0.04766859f, -0.02697869f, -0.05028414f, -0.00921991f, -0.06151229f, -0.00639420f, 
    0.00727503f, -0.01574364f, -0.01135690f, -0.05530116f, -0.02187844f, -0.00568514f, -0.00395402f, -0.06393858f, 
    -0.01607940f, -0.05187476f, 0.00034417f, -0.02611891f, -0.03048698f, 0.02709513f, 0.00150335f, 0.03659463f, 
    -0.09252732f, -0.04738479f, 0.00844891f, 0.01746036f, 0.05334532f, -0.02194482f, -0.06427011f, 0.01928832f, 
    -0.03979778f, 0.02529713f, -0.07627813f, 0.00671727f, 0.05186592f, 0.03107094f, 0.03791321f, -0.05545982f, 
    0.02190449f, 0.02768745f, -0.05821914f, -0.03641942f, 0.02628783f, -0.07642580f, -0.01512183f, 0.06583315f, 
    -0.07105417f, -0.04633256f, -0.05449765f, -0.03641926f, -0.04592359f, -0.02510138f, -0.06319515f, 0.04379145f, 
    -0.02328834f, 0.00938904f, 0.01124073f, 0.00797907f, 0.05252012f, -0.06126843f, -0.01952465f, -0.00381687f, 
    0.01952931f, -0.06769614f, -0.00180165f, -0.06481484f, -0.00738953f, -0.03194584f, -0.06310962f, 0.02489387f, 
    -0.03188530f, -0.01735989f, -0.00766803f, -0.09045654f, 0.03518904f, -0.05382029f, 0.03390902f, 0.03936771f, 
    -0.02747207f, 0.01658884f, 0.03022232f, 0.00875549f, 0.01793043f, -0.02743961f, -0.03991739f, 0.01096748f, 
    -0.07557444f, 0.03681517f, 0.02022856f, -0.08741928f, -0.00988190f, 0.00652012f, -0.09130348f, 0.05924394f, 
    0.00817810f, -0.05239114f, -0.01362232f, 0.00875965f, 0.01929394f, 0.04445461f, -0.08017940f, -0.08044518f, 
    -0.05726182f, -0.08608115f, 0.00010007f, 0.05135483f, 0.03887248f, -0.07236313f, 0.01199185f, 0.02124037f, 
    -0.02257988f, 0.01134166f, 0.00763143f, 0.00664785f, -0.01903518f, 0.02256532f, -0.00080825f, -0.06823879f, 
    -0.06178168f, 0.03108279f, -0.01213608f, 0.00042620f, -0.06053211f, -0.03023779f, -0.03106030f, -0.06703074f, 
    -0.04890167f, 0.01567404f, 0.02969358f, -0.06051827f, -0.06322201f, -0.06209473f, 0.03714256f, -0.05362608f, 
    -0.07810458f, -0.01679790f, 0.03796159f, -0.05733798f, 0.03365584f, -0.03164740f, -0.04179825f, -0.08020666f, 
    -0.03206981f, -0.00952210f, -0.06041452f, -0.07485342f, 0.04323897f, 0.01713893f, -0.00143855f, -0.01023438f, 
    -0.02355131f, -0.02742938f, -0.06300504f, -0.04860644f, 0.00807170f, -0.04064438f, 0.02834464f, -0.01049428f, 
    -0.08850343f, 0.02692639f, -0.02793466f, 0.03597188f, -0.00891633f, 0.04185353f, -0.05840395f, -0.05093313f, 
    -0.06480975f, -0.06901010f, 0.03680877f, 0.03722554f, 0.05602809f, -0.02425705f, -0.00318918f, -0.05009057f, 
    0.04988397f, 0.03103058f, -0.06012478f, -0.04359818f, -0.05754990f, -0.07070273f, 0.00580268f, 0.01303283f, 
    -0.06734800f, -0.03915683f, 0.03371304f, 0.04131889f, -0.02734851f, 0.02010077f, -0.08103601f, 0.01801538f, 
    -0.04158819f, 0.06313496f, -0.05560049f, 0.00098538f, -0.05851044f, -0.05694188f, 0.00472393f, -0.00584850f, 
    -0.01670128f, -0.05133823f, -0.01879568f, -0.02042978f, -0.05093850f, -0.03887711f, 0.05514509f, -0.06307417f, 
    -0.01257735f, -0.07209205f, -0.01804398f, -0.06831478f, 0.02128414f, -0.02867427f, 0.07129701f, -0.00532258f, 
    -0.00604203f, -0.04000638f, 0.06130116f, -0.04430949f, 0.01991487f, -0.05963999f, -0.04570303f, 0.04232902f, 
    -0.03370283f, -0.06946163f, -0.06239010f, -0.01522517f, 0.05337252f, 0.05537568f, -0.04225370f, 0.02058331f, 
    -0.02276352f, -0.07010534f, -0.01110949f, 0.00398630f, -0.04571382f, 0.00464987f, -0.00354087f, 0.03221032f, 
    -0.00980599f, -0.04072640f, -0.00436368f, -0.00186140f, -0.01929313f, -0.03233546f, 0.01568059f, 0.00425807f, 
    -0.04892980f, -0.04545077f, -0.07167033f, -0.04643629f, 0.06690875f, 0.00747449f, -0.06941978f, 0.01326486f, 
    -0.06025679f, 0.05918914f, 0.06704426f, -0.02583730f, -0.03046318f, 0.06978638f, -0.00784059f, -0.01637961f, 
    -0.03825908f, 0.05054920f, -0.06807584f, 0.03461144f, -0.01047968f, -0.00310257f, 0.05990556f, 0.06852514f, 
    -0.03308924f, -0.05895886f, 0.00285820f, 0.06657156f, 0.03948041f, 0.05959848f, 0.01678945f, -0.01715759f, 
    -0.03728694f, -0.00872763f, 0.03417679f, 0.02510126f, -0.02218349f, 0.04735760f, -0.03918347f, -0.05885566f, 
    -0.03791489f, -0.04544776f, 0.04313573f, -0.03131275f, 0.02738754f, 0.06821707f, 0.02684983f, 0.03055980f, 
    0.03194239f, -0.04572605f, -0.05622925f, 0.03543257f, 0.02985526f, -0.03729959f, -0.05632097f, 0.05594889f, 
    0.01519667f, 0.00496235f, -0.01419393f, -0.03441593f, 0.02206328f, -0.04243055f, -0.02368113f, 0.00438299f, 
    0.03301230f, 0.04993909f, -0.01867837f, 0.06898113f, -0.03517615f, 0.06102407f, -0.03878180f, 0.01259178f, 
    -0.05836643f, -0.00714233f, 0.01198405f, 0.00344417f, 0.00483283f, -0.05989173f, -0.00715372f, -0.01922606f, 
    -0.02217139f, -0.00470856f, 0.04645184f, 0.06313725f, -0.02179482f, 0.03973926f, -0.04133267f, -0.05656516f, 
    -0.01523685f, -0.07111354f, -0.05282597f, -0.01703086f, 0.05773798f, -0.01269787f, -0.02038687f, 0.00476296f, 
    0.05484901f, 0.05969305f, 0.01390755f, -0.02935837f, 0.00898705f, -0.06623068f, -0.05741133f, -0.06946294f, 
    -0.00637600f, -0.02240955f, 0.02880058f, -0.02036463f, -0.02658575f, 0.03856996f, -0.04341066f, -0.04830583f, 
    0.02822054f, -0.04869763f, -0.05866652f, -0.04932181f, -0.01069803f, -0.00609511f, -0.02293565f, -0.04416100f, 
    -0.00513759f, -0.05550827f, -0.00212969f, 0.00397575f, 0.03268292f, -0.06818862f, -0.05358230f, -0.04957064f, 
    -0.02654215f, -0.04880592f, 0.02708362f, -0.00614078f, 0.02954765f, -0.01391323f, 0.03285179f, -0.04698537f, 
    0.15717144f, 0.02488280f, 0.13228007f, 0.02646531f, -0.01065175f, 0.01436005f, 0.07232971f, -0.00966990f, 
    0.00351244f, -0.03032300f, 0.04405901f, 0.01226422f, -0.13400002f, -0.10590807f, 0.26694012f, 0.15317604f, 
    -0.01103315f, -0.08379665f, -0.11766723f, -0.12461229f, -0.04224307f, 0.07756854f, 0.07720707f, 0.13396530f, 
    0.41526279f, -0.05335392f, 0.09058966f, 0.34936047f, -0.14015499f, -0.00714141f, -0.04281907f, -0.06150102f, 
    0.03242148f, 0.10332499f, 0.00142891f, 0.08333183f, -0.36361185f, -0.23650865f, -0.23680963f, 0.04336308f, 
    0.09638425f, -0.10321714f, -0.01498201f, 0.01484313f, 0.17475036f, -0.09008562f, 0.04426746f, 0.01626232f, 
    0.18015932f, -0.16900875f, 0.06941424f, -0.18164173f, 0.11446353f, -0.11618061f, 0.15343970f, -0.05858313f, 
    0.07736037f, 0.12149029f, -0.03043708f, 0.05044917f, -0.20104229f, 0.16799864f, -0.18014047f, -0.00013831f, 
    0.07754386f, 0.04214018f, 0.05680622f, 0.20354342f, 0.07120516f, -0.02361201f, 0.01379931f, 0.06221353f, 
    0.00710349f, 0.29704949f, -0.14715597f, -0.16439664f, -0.03508303f, 0.12367725f, -0.06356579f, 0.14957145f, 
    -0.00034379f, -0.02330508f, -0.00891768f, -0.03227714f, 0.20741957f, -0.06833944f, 0.04098120f, 0.08226602f, 
    0.11747468f, -0.09562166f, 0.05830946f, -0.01280976f, -0.03248058f, -0.06107514f, 0.07765613f, -0.00287966f, 
    0.08296055f, -0.00037733f, -0.14614128f, 0.16423872f, 0.03249996f, -0.03364280f, -0.02673168f, 0.08501086f, 
    0.09107854f, 0.09054488f, -0.09753840f, 0.04750397f, 0.06595819f, 0.25239938f, -0.04633036f, -0.11829646f, 
    -0.03487426f, 0.09781825f, -0.07894873f, -0.11129967f, -0.02864618f, 0.04871246f, -0.09003473f, 0.05412728f, 
    0.25208414f, -0.13838974f, -0.09142184f, -0.12078133f, 0.03986521f, -0.13383290f, 0.04491148f, 0.05954932f, 
    -0.04694200f, -0.04417547f, 0.08305001f, 0.06565826f, 0.11261011f, 0.07091147f, 0.01999247f, -0.16862707f, 
    0.04962521f, -0.13908072f, 0.01101559f, -0.15013233f, -0.09946168f, 0.01526542f, -0.05137380f, -0.03174007f, 
    0.23622610f, 0.07725153f, -0.03542196f, -0.08943909f, 0.07556734f, -0.03641586f, 0.12637673f, -0.06072081f, 
    -0.03551486f, 0.00273483f, -0.03593536f, -0.02799482f, -0.19665517f, 0.00940121f, -0.15414031f, -0.04232248f, 
    0.03570992f, 0.14293356f, -0.11551501f, -0.02682932f, -0.01808802f, 0.08765106f, -0.06896936f, -0.13210671f, 
    0.31626546f, 0.18269373f, -0.23964742f, 0.05453795f, 0.03235381f, -0.03988976f, 0.04084573f, 0.00498322f, 
    -0.03495729f, 0.07690838f, 0.10784150f, 0.21337257f, -0.28074551f, -0.12077620f, 0.02440917f, 0.01395535f, 
    0.20825918f, 0.00576694f, 0.07194119f, 0.00576193f, 0.04163362f, -0.00617333f, -0.01600401f, -0.05026552f, 
    -0.14479394f, -0.12889297f, 0.11530150f, -0.11419777f, -0.12320214f, 0.02297107f, 0.02734241f, -0.03719794f, 
    -0.08538388f, -0.00342981f, -0.06215745f, -0.07436146f, -0.06084623f, 0.36799151f, -0.06064702f, -0.02318518f, 
    0.05772232f, 0.07151964f, 0.00577174f, -0.03891375f, 0.02053169f, 0.06435512f, -0.04017060f, -0.02797643f, 
    -0.17374830f, -0.06281054f, -0.00354946f, 0.01256658f, -0.15962012f, 0.08522732f, 0.09085960f, 0.10869744f, 
    0.08696981f, 0.00956113f, 0.01570088f, 0.12708552f, 0.33405796f, 0.16515194f, -0.08314036f, 0.14095268f, 
    0.08477096f, -0.07380879f, 0.07443234f, 0.01697953f, -0.02360744f, 0.09900131f, 0.06719909f, -0.03324872f, 
    0.08938780f, 0.02966937f, 0.30611736f, 0.02631159f, -0.08070175f, 0.06894964f, -0.00872781f, 0.16385926f, 
    -0.00852435f, -0.04941626f, -0.11431511f, 0.00608595f, 0.06982296f, -0.09216256f, -0.00924446f, 0.38495663f, 
    0.21312693f, 0.08230249f, 0.12712951f, 0.03554320f, -0.08888435f, -0.01188702f, -0.03509406f, 0.01622827f, 
    0.08154143f, 0.03180282f, 0.06168091f, -0.09261965f, 0.20151775f, 0.13069279f, 0.01603777f, 0.04366744f, 
    0.05292270f, 0.00855084f, 0.05536763f, 0.07152500f, 0.12835430f, -0.03829740f, 0.12767933f, 0.20710322f, 
    -0.00669599f, 0.09885343f, 0.14634342f, 0.05691894f, -0.23176134f, -0.04231159f, 0.09610314f, 0.02449141f, 
    0.13291262f, -0.06802556f, -0.13968557f, -0.16371590f, 0.07479132f, -0.05392482f, -0.00169255f, -0.08174513f, 
    -0.04388314f, 0.04525881f, 0.03140648f, -0.02935389f, 0.22911415f, -0.15939023f, 0.19915776f, -0.28897569f, 
    0.02823605f, 0.05478200f, -0.17077382f, 0.01013537f, -0.01806941f, 0.07512693f, 0.04392837f, -0.08371979f, 
    -0.12156881f, -0.01335238f, 0.20486708f, 0.01302876f, -0.04408577f, -0.09317499f, 0.10641861f, 0.13318828f, 
    0.07303590f, -0.13218212f, -0.14353320f, -0.08123289f, -0.19622131f, 0.11260432f, -0.01291963f, 0.03028153f, 
    0.06478761f, 0.10627171f, 0.03708456f, -0.07192560f, -0.10917516f, -0.15163922f, -0.11234153f, -0.03902723f, 
    0.05020427f, 0.13998424f, -0.01397273f, 0.00756215f, 0.07719635f, 0.12823543f, -0.02842822f, 0.01851055f, 
    0.04085264f, -0.04561000f, -0.05541629f, -0.07434279f, -0.01417211f, -0.05800793f, 0.16184588f, 0.17920712f, 
    0.26514065f, 0.01547762f, -0.01293832f, 0.08446742f, 0.05371590f, 0.05865745f, -0.03685906f, -0.03399306f, 
    -0.03518116f, 0.02192196f, 0.14465185f, -0.19999315f, -0.02563709f, -0.01463063f, -0.05860037f, 0.05554036f, 
    -0.04091277f, -0.10340200f, 0.08494448f, -0.06530771f, -0.16088900f, -0.04260359f, 0.07849609f, 0.09661703f, 
    -0.22893894f, -0.07442597f, -0.12196798f, -0.06558073f, -0.09693812f, -0.04178130f, 0.01258092f, 0.06276523f, 
    0.23451155f, 0.17394748f, -0.10281003f, 0.09406933f, -0.13929254f, -0.03276226f, -0.01960568f, 0.01484923f, 
    0.00572764f, 0.03189936f, -0.04179242f, -0.04740041f, 0.09167650f, 0.16052713f, -0.24089833f, -0.01271542f, 
    0.07051712f, -0.00525967f, 0.06834837f, -0.05372386f, 0.02453532f, -0.04927614f, 0.04040645f, 0.03790212f, 
    0.38698792f, 0.06987415f, -0.19448067f, 0.09104817f, 0.07687366f, -0.09790001f, 0.09754980f, -0.00827314f, 
    0.06430221f, -0.03372312f, 0.01022125f, -0.03769184f, 0.49848801f, 0.19151388f, 0.07393447f, -0.05504159f, 
    0.00993101f, -0.06042363f, -0.03371719f, 0.12043830f, -0.08134556f, 0.04017634f, 0.14772137f, 0.03469046f, 
    0.21823932f, 0.11725822f, 0.04221915f, -0.02453576f, -0.11080251f, 0.05800482f, -0.04375107f, 0.00681885f, 
    -0.04738265f, -0.00571982f, 0.09940477f, 0.06986105f, -0.22579844f, -0.03154337f, 0.09292461f, 0.09031270f, 
    0.05189613f, 0.03706647f, 0.14083166f, 0.13281643f, 0.01574258f, 0.03817622f, -0.08377792f, -0.03595106f, 
    0.03451007f, -0.07998906f, -0.05718312f, -0.04542818f, 0.18994942f, -0.06737168f, -0.02103982f, 0.12663926f, 
    -0.00314995f, -0.01822706f, 0.04169817f, 0.00490086f, -0.25014174f, 0.01269624f, -0.09504671f, -0.12777767f, 
    -0.08624208f, -0.11579087f, 0.01163450f, 0.06217116f, 0.08749662f, 0.03905226f, 0.02892523f, -0.00061656f, 
    -0.01429836f, 0.04077834f, -0.01937547f, -0.10212071f, 0.08582583f, 0.00863134f, 0.03152173f, 0.03201772f, 
    0.00073026f, -0.07788403f, -0.01007469f, -0.05432445f, 0.08208091f, -0.13232388f, 0.04974713f, -0.11002290f, 
    0.09145850f, 0.06612793f, -0.06321207f, 0.19402067f, 0.03284029f, 0.06208574f, 0.05895224f, -0.05303450f, 
    0.33200991f, 0.17193453f, 0.01306425f, 0.00156473f, -0.00354661f, 0.00165370f, -0.07010918f, -0.03637112f, 
    -0.03710268f, 0.15503559f, -0.05906841f, 0.07070608f, 0.20979314f, 0.19020656f, 0.09419245f, -0.04836216f, 
    0.11425423f, -0.18936121f, -0.10156758f, -0.05520994f, -0.00789256f, 0.10680831f, 0.06706077f, 0.07301109f, 
    -0.00344130f, 0.00566611f, 0.10538886f, 0.09688471f, 0.09923925f, -0.02964019f, -0.07454238f, 0.08136791f, 
    0.00039513f, 0.16832489f, 0.09513107f, 0.02741128f, -0.25502467f, 0.03001987f, 0.11093298f, -0.12658110f, 
    0.08414474f, -0.08421755f, -0.08548798f, 0.02292817f, 0.02927449f, 0.03753175f, 0.06472237f, 0.02115983f, 
    -0.06506644f, -0.26409671f, -0.05312523f, -0.28941175f, 0.08482511f, -0.13669823f, -0.01599400f, -0.05689717f, 
    0.14026383f, -0.01314597f, 0.03522473f, -0.12471635f, -0.12407888f, -0.05983353f, -0.05229862f, 0.15848096f, 
    -0.11992565f, -0.04997423f, -0.06137090f, 0.00823397f, -0.00971146f, 0.00388924f, -0.10251871f, -0.07162511f, 
    0.01450637f, -0.05919746f, -0.03465369f, -0.05280660f, 0.05929574f, -0.01645007f, -0.04136374f, -0.01858613f, 
    -0.01156662f, -0.07663021f, 0.05779072f, 0.05824785f, 0.05255249f, -0.02877913f, 0.03177851f, -0.04732968f, 
    -0.06761536f, 0.03186670f, -0.03286370f, 0.03286349f, 0.03171871f, -0.05080689f, 0.05086394f, -0.05939659f, 
    -0.02282064f, 0.06419569f, 0.04984757f, -0.05063461f, -0.04747155f, -0.03344221f, 0.01078105f, -0.00337367f, 
    -0.05313040f, 0.02115200f, -0.01501110f, 0.06127365f, -0.03298962f, 0.06498847f, -0.00843276f, -0.05466580f, 
    0.06315919f, 0.01687964f, -0.06414694f, 0.05955196f, 0.00064255f, 0.04606865f, -0.00911912f, -0.05268028f, 
    0.04736121f, 0.05981015f, 0.04958342f, -0.02623799f, 0.04178013f, -0.03500361f, -0.00544406f, -0.06056814f, 
    -0.04272527f, 0.00465462f, -0.06389191f, -0.03019926f, 0.02375981f, -0.00949001f, 0.00480351f, -0.04343868f, 
    0.06594296f, -0.05568482f, 0.00014848f, 0.04187219f, 0.04441379f, 0.04475339f, -0.01818754f, -0.04239077f, 
    -0.00451416f, -0.01418120f, -0.00126238f, -0.03386481f, -0.03731722f, 0.02725106f, 0.06194828f, -0.00005795f, 
    -0.01530628f, 0.05904788f, 0.01976978f, 0.04668683f, -0.04522351f, -0.06818508f, -0.03137276f, -0.05170229f, 
    -0.01034557f, -0.06098672f, -0.05344633f, -0.00475606f, 0.05073477f, 0.01049805f, 0.03279590f, -0.07292998f, 
    -0.02694280f, 0.00872167f, -0.06833757f, 0.04012086f, 0.03309453f, 0.05335020f, 0.01027161f, -0.07368453f, 
    -0.05001007f, -0.07382532f, 0.06309967f, 0.00128306f, -0.02255538f, 0.00952681f, -0.03701090f, -0.01811834f, 
    -0.07408322f, 0.05486677f, -0.04595913f, -0.06156716f, -0.04570965f, 0.06576893f, 0.00791025f, -0.06373432f, 
    0.00679605f, -0.00686769f, -0.02957974f, -0.05425313f, -0.06246541f, -0.05527347f, -0.03144441f, 0.03982929f, 
    0.00450512f, -0.06692658f, 0.03368652f, 0.01808224f, -0.00682774f, -0.06472162f, 0.02532883f, -0.03371587f, 
    0.04962483f, -0.06156151f, 0.05492788f, 0.02501595f, 0.01803806f, 0.00886516f, -0.03185951f, -0.05934130f, 
    -0.01784728f, -0.03701617f, -0.02538643f, -0.02224523f, 0.00413139f, 0.01072636f, -0.05835744f, -0.01694843f, 
    -0.05633538f, -0.05151949f, 0.03859679f, -0.04492694f, -0.02816804f, -0.04967153f, -0.01700292f, -0.06484117f, 
    0.03136045f, 0.04357915f, -0.00948874f, -0.02053944f, -0.00808441f, 0.00965863f, -0.01738757f, -0.04672759f, 
    -0.07070580f, 0.02523699f, 0.03846541f, -0.06740713f, -0.01379099f, -0.07766180f, 0.03488253f, -0.01822302f, 
    0.01606071f, 0.01193107f, -0.06717046f, -0.00188751f, -0.02256918f, -0.07746276f, 0.00575384f, 0.04374962f, 
    -0.04586052f, -0.00135648f, -0.03306314f, 0.03539649f, 0.02435733f, -0.02733054f, -0.00041464f, 0.04724494f, 
    -0.01020729f, -0.01743870f, 0.20026508f, 0.13875620f, -0.05453831f, 0.01282946f, 0.00091713f, -0.18223986f, 
    0.05735236f, -0.08232503f, -0.03243836f, -0.02099523f, -0.10611065f, 0.11667995f, 0.04971081f, -0.04283709f, 
    0.07531877f, 0.09653769f, 0.03269048f, -0.05402896f, 0.01899113f, 0.09176052f, -0.09284551f, 0.00280835f, 
    -0.04744416f, -0.17695166f, 0.12524249f, 0.22070606f, 0.03774608f, 0.09250819f, -0.03029155f, 0.05064034f, 
    0.01975076f, -0.10632784f, 0.02785212f, 0.00598528f, 0.37618157f, 0.26643756f, 0.10568518f, -0.01715380f, 
    -0.12245193f, -0.01165216f, 0.03528236f, 0.01780831f, 0.03554903f, 0.02622650f, -0.02893251f, 0.06305372f, 
    0.21923767f, 0.34624639f, 0.10899866f, -0.04995766f, -0.06459937f, 0.05036546f, -0.01016021f, 0.12236422f, 
    0.11658108f, -0.05406353f, -0.05452094f, -0.06828667f, -0.22591951f, -0.00177011f, 0.09801663f, 0.15183644f, 
    0.08305493f, -0.03763349f, 0.06685626f, -0.00473255f, -0.21623105f, 0.05069852f, 0.05781667f, 0.22443685f, 
    -0.17031208f, -0.09424998f, -0.24019626f, 0.02555387f, 0.18376383f, 0.18367016f, -0.01499381f, 0.04463842f, 
    0.06689359f, -0.11954371f, -0.14838661f, -0.06818723f, -0.06384633f, 0.14809503f, -0.04331592f, -0.13199067f, 
    -0.07598104f, 0.06065648f, 0.03243927f, 0.08625948f, 0.06684883f, -0.12240306f, 0.20694543f, -0.04431862f, 
    0.03831330f, -0.02975967f, -0.29418251f, -0.19056991f, 0.13893028f, -0.05145089f, 0.02819760f, 0.14683948f, 
    -0.06697850f, -0.09826470f, -0.05036337f, -0.04314425f, -0.05053587f, -0.08272438f, -0.07592415f, -0.13164902f, 
    0.11191191f, -0.04802644f, -0.08948217f, 0.13429223f, 0.19410709f, -0.01505006f, 0.04838653f, 0.00606038f, 
    0.28556404f, 0.13206038f, -0.08311225f, 0.15212409f, -0.15408598f, -0.04026169f, -0.10384057f, 0.06835540f, 
    -0.03792081f, -0.03595561f, -0.05365968f, 0.00866580f, 0.37309417f, 0.39105725f, -0.05669147f, 0.25615546f, 
    -0.05803214f, -0.03072623f, 0.06233699f, -0.01500158f, -0.09867461f, 0.09101819f, 0.01306830f, 0.10333809f, 
    0.00945330f, -0.09542646f, -0.21948075f, -0.01791775f, 0.15217955f, 0.14743428f, 0.09093042f, 0.05041669f, 
    -0.01320810f, 0.09493160f, 0.01263874f, 0.10322194f, -0.41474235f, 0.07598590f, 0.09914283f, 0.05630289f, 
    0.14603119f, -0.04141603f, -0.09037703f, 0.14570241f, 0.09595527f, 0.06513566f, 0.07101432f, 0.16860412f, 
    -0.09462330f, -0.11377964f, 0.17206533f, -0.21547848f, 0.03760409f, -0.11051643f, 0.03895299f, 0.07393475f, 
    -0.05367953f, -0.07187598f, 0.07878563f, -0.17193213f, 0.00236469f, -0.16579793f, 0.02479559f, 0.05530101f, 
    -0.10742854f, -0.05717522f, -0.03960256f, -0.02559598f, 0.07362900f, 0.09910159f, -0.05087165f, -0.10048928f, 
    -0.05315977f, -0.03373820f, 0.20441175f, 0.03322760f, -0.01823616f, -0.02389647f, -0.01758878f, -0.02199029f, 
    0.03655444f, -0.07730600f, 0.08754772f, -0.11142582f, 0.07198373f, 0.06873957f, -0.00076413f, 0.04694881f, 
    0.20820113f, -0.01095435f, -0.19724809f, -0.00883053f, 0.10165165f, 0.10096928f, -0.00743226f, 0.06705316f, 
    -0.09763879f, 0.08898965f, 0.12277918f, 0.10963987f, -0.12958579f, 0.11522608f, 0.13163687f, 0.01445576f, 
    0.00131260f, 0.01744580f, 0.03727180f, 0.09970442f, -0.05039381f, -0.03363292f, -0.10609519f, 0.09171287f, 
    0.05305852f, -0.15473874f, -0.03903874f, 0.03027368f, 0.22406982f, -0.07732399f, 0.03298545f, 0.04882168f, 
    -0.00212588f, -0.19402936f, 0.31934139f, -0.11610031f, -0.00281586f, -0.02153999f, 0.05898713f, -0.00225524f, 
    -0.03637092f, -0.01001460f, 0.07109387f, 0.07446368f, -0.19834174f, -0.10157460f, -0.21281289f, 0.11182407f, 
    0.13051811f, -0.06676506f, -0.03588649f, 0.13541478f, -0.11114471f, 0.03459058f, 0.04914014f, 0.11636903f, 
    0.18913934f, -0.02091433f, -0.07284155f, -0.06177407f, 0.07556140f, 0.16980816f, -0.02579799f, 0.07888036f, 
    0.12348638f, -0.03503256f, 0.02308507f, 0.10285072f, 0.08058839f, 0.06357639f, 0.10028003f, -0.11469349f, 
    0.06100820f, 0.13678454f, 0.17110458f, 0.01172260f, -0.07440296f, 0.02492462f, 0.07813839f, 0.06179242f, 
    0.08524641f, -0.11151670f, -0.06492894f, 0.02181710f, 0.11552411f, -0.03740785f, 0.02302509f, -0.00456430f, 
    -0.06989951f, -0.06717855f, 0.01406298f, 0.01394251f, 0.28533244f, -0.18534192f, 0.01329035f, -0.14532621f, 
    0.06002181f, 0.04219092f, -0.08515101f, -0.13741876f, -0.06353620f, 0.00282774f, 0.05192873f, 0.01009741f, 
    0.31988814f, -0.02742564f, 0.07487905f, -0.17096657f, -0.05442881f, -0.13484123f, 0.10410364f, -0.03146163f, 
    0.04582037f, -0.14027800f, 0.05120210f, -0.03478062f, 0.05849749f, 0.02091948f, 0.02493135f, -0.18235143f, 
    0.08548236f, -0.14697956f, -0.04329662f, -0.12736408f, -0.16420376f, -0.06886195f, -0.05110264f, -0.04028626f, 
    0.18755190f, -0.11529265f, -0.07640220f, -0.02202351f, 0.04694693f, 0.13702296f, -0.01918945f, -0.01351075f, 
    0.04812287f, -0.05612190f, -0.00855430f, -0.08527041f, -0.17511852f, 0.01680181f, 0.08794143f, 0.02320773f, 
    0.10524544f, 0.09191597f, -0.12700081f, 0.08992959f, 0.13049635f, 0.01723287f, 0.00339106f, -0.05251579f, 
    0.15398541f, 0.17315410f, -0.12267777f, -0.01548965f, -0.15206851f, 0.07244535f, -0.03332578f, 0.01242359f, 
    -0.02801371f, -0.09574021f, 0.16663189f, 0.00609386f, -0.00810225f, -0.13334730f, -0.10882794f, 0.20103274f, 
    -0.04359490f, 0.00540900f, -0.01847180f, -0.05535153f, 0.07100069f, 0.06720765f, -0.04131134f, 0.00034439f, 
    -0.05660238f, 0.00688862f, -0.09199328f, -0.02990109f, -0.01713170f, -0.07153784f, -0.04003940f, -0.02441331f, 
    -0.06548892f, -0.05151295f, -0.06538024f, -0.02132086f, -0.09491678f, 0.00471374f, -0.06727894f, 0.05162346f, 
    0.02417905f, -0.09248278f, 0.00446453f, 0.03160399f, 0.04682944f, -0.05824977f, -0.07343871f, -0.05844777f, 
    -0.03107567f, -0.06787314f, 0.03248505f, 0.02528678f, 0.02654928f, 0.00659932f, -0.06138322f, -0.04910632f, 
    0.01758308f, 0.04208523f, -0.06292049f, -0.03721653f, -0.03005604f, -0.01836074f, 0.02879114f, -0.02192989f, 
    -0.01166816f, -0.03657872f, -0.05081448f, -0.08449588f, -0.06962054f, 0.03000701f, 0.02640351f, 0.01908596f, 
    -0.04607847f, -0.03685826f, -0.01309788f, 0.00715031f, 0.05106803f, 0.02489631f, 0.04120348f, 0.01552043f, 
    0.02016603f, -0.08057720f, -0.03565397f, 0.04457302f, 0.06022713f, 0.04602760f, 0.03908477f, 0.03107556f, 
    0.01989696f, -0.03058726f, 0.02733187f, -0.00578038f, -0.05243547f, 0.04520419f, -0.02969490f, -0.00400859f, 
    -0.01091708f, 0.02630017f, -0.06794298f, -0.03095640f, 0.02029089f, -0.01417157f, -0.01070399f, -0.01034763f, 
    -0.07899404f, -0.07312275f, 0.00298732f, 0.04674648f, 0.04347558f, -0.01376564f, 0.04952074f, -0.00057036f, 
    -0.06372541f, -0.01104485f, 0.02355910f, -0.00726994f, 0.04247283f, -0.00421761f, -0.05965814f, 0.03372661f, 
    0.02387970f, -0.03678839f, 0.00401951f, -0.04865309f, 0.01909865f, -0.05929074f, -0.04247532f, -0.02337394f, 
    -0.06008529f, 0.03763050f, -0.00339662f, -0.06133602f, -0.04261510f, 0.02825586f, 0.03247698f, 0.01750895f, 
    -0.06914673f, -0.03273276f, 0.03341559f, -0.00242208f, -0.01544448f, 0.00491023f, -0.06013551f, -0.08825249f, 
    0.03217252f, 0.01225705f, 0.02783337f, 0.01263927f, -0.04435489f, -0.03384790f, 0.04848107f, -0.06652258f, 
    -0.03649237f, -0.01336149f, -0.01322338f, -0.07236537f, -0.01186944f, 0.02753864f, -0.02344279f, -0.06787515f, 
    -0.05344634f, -0.06704599f, -0.01962866f, -0.07450620f, -0.06132090f, -0.06365469f, -0.05712925f, 0.02284716f, 
    -0.03432572f, -0.02175663f, -0.02628806f, -0.03554890f, 0.00836158f, -0.04657241f, 0.00630971f, -0.01793520f, 
    -0.05112628f, 0.01351392f, -0.03727667f, -0.05258641f, -0.03426694f, 0.02972858f, 0.01750033f, 0.02907151f, 
    0.06486314f, 0.05292973f, -0.03248373f, -0.02973918f, -0.08807368f, 0.00764716f, -0.01934762f, -0.02330593f, 
    0.03574210f, -0.09143525f, 0.02608284f, -0.05274121f, 0.00378431f, 0.00850449f, -0.07042913f, 0.03636931f, 
    -0.05929807f, -0.02755192f, -0.05005584f, 0.05107123f, -0.03539740f, 0.03023045f, 0.04807414f, -0.06454847f, 
    0.03155111f, -0.06690242f, -0.00232495f, 0.02608421f, 0.04684683f, 0.03590546f, -0.07058761f, -0.00618647f, 
    -0.25356197f, 0.01888341f, -0.06165632f, -0.15182088f, 0.10801075f, -0.02082334f, -0.07033911f, -0.10636488f, 
    0.15702786f, -0.04650473f, 0.05946333f, 0.12219271f, -0.18619189f, -0.17218447f, 0.38596129f, 0.10434900f, 
    -0.01993069f, 0.02566877f, -0.09748935f, -0.01574137f, 0.07486594f, 0.15945150f, 0.08760074f, 0.05111006f, 
    0.10617758f, -0.09446436f, 0.05310793f, 0.02702934f, 0.05003491f, -0.08684744f, -0.05020371f, 0.02433973f, 
    0.07706910f, 0.11696652f, 0.05477802f, 0.05072748f, -0.45513603f, -0.26394477f, -0.19022752f, -0.17017242f, 
    0.05026384f, -0.08790094f, 0.04355583f, 0.06673960f, 0.05159169f, 0.05978657f, 0.00216762f, -0.07390727f, 
    0.13009566f, 0.01650074f, -0.10521739f, 0.30229363f, 0.20653315f, -0.02109810f, -0.01740459f, 0.05350035f, 
    0.12003658f, 0.03852562f, -0.03003707f, 0.01411572f, 0.07604004f, 0.26413921f, -0.21593963f, -0.03732321f, 
    -0.04281404f, 0.00857431f, -0.00976818f, -0.18305735f, 0.02213326f, 0.03262230f, 0.13904476f, 0.03577443f, 
    -0.24681382f, 0.22499327f, -0.09601504f, -0.16502678f, -0.09886821f, 0.12648495f, 0.00267551f, 0.01970966f, 
    0.09641545f, 0.03886010f, 0.10113806f, -0.09658771f, 0.23275270f, 0.16398568f, -0.05169516f, 0.20859793f, 
    -0.01240858f, -0.05394787f, -0.00554452f, -0.03435028f, 0.01316438f, -0.04008391f, -0.05105600f, -0.00304036f, 
    -0.15773705f, 0.12940332f, -0.03166926f, 0.05744112f, -0.03531252f, -0.02280410f, -0.04995298f, 0.14304894f, 
    0.09312632f, 0.03262555f, -0.09953490f, 0.02815311f, -0.28384501f, 0.20899397f, -0.09340204f, 0.17950469f, 
    -0.06230728f, -0.08166790f, 0.06148527f, -0.07742866f, -0.02672339f, 0.00196676f, 0.04791401f, 0.13270077f, 
    -0.01447252f, -0.06363972f, -0.18198213f, 0.14276148f, 0.11808959f, 0.03797040f, 0.07394859f, 0.02979240f, 
    0.02080914f, -0.02952859f, 0.18573256f, 0.03847880f, -0.07970957f, -0.00343325f, -0.07758535f, 0.11797265f, 
    0.10724291f, 0.01372943f, 0.05172352f, 0.03712824f, 0.10599516f, 0.03785006f, -0.02720895f, 0.11875516f, 
    -0.15094237f, 0.00297116f, -0.10083304f, -0.19094311f, 0.00632207f, -0.13107961f, 0.05135093f, -0.06133712f, 
    -0.07638454f, 0.02379907f, -0.13043833f, 0.06460284f, -0.18091929f, -0.10256216f, -0.06441922f, -0.00338118f, 
    -0.08617309f, 0.03072887f, 0.05483468f, -0.05080662f, -0.03373889f, 0.08677609f, -0.06281570f, -0.05989280f, 
    0.22907361f, 0.20638368f, -0.07137901f, -0.06844498f, 0.00229504f, -0.10789768f, 0.13240463f, 0.13764925f, 
    -0.01320977f, 0.07275003f, 0.03734924f, 0.13917369f, -0.37565917f, 0.13542940f, 0.11385975f, -0.22232082f, 
    0.29623964f, 0.04632789f, 0.05071667f, 0.09202468f, 0.07896166f, 0.03505575f, 0.06626074f, 0.02252814f, 
    -0.07568816f, 0.01114518f, 0.06475112f, 0.06662294f, 0.05823381f, -0.06367666f, 0.02189714f, -0.06477838f, 
    -0.02565948f, -0.06830022f, -0.00568916f, -0.02895780f, 0.05093431f, 0.06373952f, 0.00617031f, -0.03028564f, 
    -0.01680731f, 0.05525427f, 0.02144568f, 0.04320135f, -0.02557528f, -0.02438014f, -0.02365857f, 0.04590019f, 
    0.00988764f, 0.04581621f, 0.04788876f, 0.04736780f, 0.01331759f, -0.00328422f, 0.04626531f, 0.06325954f, 
    -0.03317555f, -0.03134795f, -0.06926550f, -0.07720152f, -0.02341817f, -0.04611487f, -0.05621563f, 0.02938098f, 
    0.04252749f, -0.01464852f, -0.04522049f, -0.02939692f, -0.05400098f, 0.05039096f, -0.00952010f, 0.04351742f, 
    0.00553655f, -0.06735143f, -0.02437275f, -0.00345923f, -0.05055248f, -0.01313252f, -0.03837026f, 0.01262922f, 
    0.04636771f, -0.07052594f, -0.03061703f, 0.00173069f, 0.03833307f, 0.00036655f, -0.05175809f, 0.03701488f, 
    -0.04610614f, 0.05294744f, -0.04881835f, 0.01098906f, -0.04183373f, 0.00717855f, 0.02289524f, -0.05250070f, 
    0.04186552f, 0.00956581f, -0.06867030f, -0.07019126f, -0.02377082f, -0.06673916f, -0.01608583f, 0.02965907f, 
    -0.02404431f, -0.01372698f, 0.01525971f, -0.03693935f, 0.01549591f, 0.01146736f, -0.07798906f, 0.04243628f, 
    0.00483047f, -0.02965872f, 0.05479153f, 0.02251190f, 0.03103100f, -0.06573740f, 0.00815703f, -0.01681350f, 
    -0.00025805f, -0.00652590f, 0.06403898f, 0.03899512f, -0.04906361f, 0.02454919f, -0.07194499f, 0.03223422f, 
    0.03577257f, 0.01236754f, 0.04061765f, -0.06821214f, 0.04698556f, 0.04922286f, -0.05961387f, -0.05273348f, 
    -0.02189399f, -0.03204340f, 0.02362750f, -0.04085517f, 0.02917366f, -0.05716617f, -0.06616084f, -0.07278166f, 
    0.04862983f, -0.02630669f, -0.04825283f, -0.00259660f, 0.04078194f, -0.06116622f, -0.02768188f, -0.05468205f, 
    -0.03208578f, -0.07796642f, -0.04716780f, -0.01939537f, 0.00138893f, 0.01387078f, 0.04596384f, 0.04840428f, 
    -0.03112353f, -0.07047275f, 0.05050254f, 0.03762485f, 0.00902752f, 0.03982008f, 0.01365159f, -0.06415547f, 
    -0.00511516f, 0.04654996f, -0.01136502f, 0.03915969f, -0.01438548f, 0.02555355f, 0.03989027f, -0.02396809f, 
    0.01666222f, -0.07715525f, 0.01211517f, -0.01890768f, 0.03107527f, -0.07513795f, -0.05161330f, 0.05754356f, 
    0.04093232f, 0.04908605f, -0.04067288f, -0.02688760f, -0.07180420f, -0.07214794f, -0.01576045f, -0.03697086f, 
    0.03524883f, -0.05274097f, 0.01522264f, -0.08284388f, 0.00539786f, -0.05547081f, 0.06515220f, -0.00174328f, 
    0.04257559f, -0.04323082f, -0.03421929f, -0.04332681f, 0.04622720f, -0.08586971f, -0.06925002f, -0.01310050f, 
    0.03677845f, -0.05824996f, 0.05765511f, -0.06488263f, -0.00304566f, -0.04415614f, 0.02766263f, -0.02945966f, 
    0.28853977f, 0.35697308f, 0.34927148f, -0.14958934f, -0.31100413f, 0.18236239f, -0.03171457f, 0.04950976f, 
    0.00654466f, -0.03713682f, 0.06741574f, 0.03895284f, 0.33789155f, 0.10076714f, -0.09905027f, -0.02858566f, 
    0.05954852f, 0.11970609f, 0.03882729f, 0.19680417f, 0.02238579f, 0.02665895f, 0.00281127f, -0.11035334f, 
    0.09410643f, 0.47351608f, 0.32613340f, 0.01829578f, -0.11645682f, 0.00357708f, -0.06206816f, -0.11434649f, 
    0.05756709f, 0.06430037f, 0.07941159f, -0.02281142f, -0.11807341f, 0.13718784f, -0.07805769f, 0.01479884f, 
    0.08546041f, 0.08950963f, 0.13339682f, -0.12993515f, -0.04362572f, 0.03449269f, 0.01312326f, 0.08410209f, 
    -0.17973834f, -0.17483392f, 0.10573279f, -0.09023552f, -0.03279126f, -0.07287302f, 0.04062422f, 0.04755585f, 
    0.02213464f, -0.02177863f, 0.00492877f, 0.06368876f, -0.26925167f, -0.20999293f, -0.23279220f, 0.05057752f, 
    0.08470127f, -0.00338808f, -0.01118205f, -0.02444607f, -0.14457525f, 0.07937211f, -0.15473025f, -0.00592028f, 
    -0.09495175f, -0.28282884f, -0.10402677f, -0.04096022f, 0.19518003f, 0.00517121f, -0.00775225f, 0.05235862f, 
    0.10060734f, -0.03959617f, -0.14190674f, -0.01328762f, -0.24692746f, -0.10349460f, 0.08774397f, -0.11081593f, 
    0.08067200f, -0.03266665f, 0.03285823f, -0.07899389f, 0.08658412f, -0.01343601f, 0.10685467f, 0.00561340f, 
    -0.06805363f, -0.27199110f, -0.04056434f, 0.11068387f, 0.08809489f, -0.01591062f, 0.14081094f, -0.03290828f, 
    -0.01816605f, -0.06903031f, -0.04821791f, -0.14169368f, -0.06508027f, -0.25299034f, -0.10629997f, 0.02076836f, 
    0.13013646f, 0.04305631f, 0.18551014f, 0.17915334f, 0.08327796f, 0.08061206f, 0.02935700f, -0.06433936f, 
    0.01167944f, -0.02893611f, 0.20249635f, 0.05997963f, -0.06287627f, 0.05298095f, 0.12407217f, 0.09196311f, 
    0.01825603f, -0.02357168f, -0.00274232f, -0.03806626f, -0.08985819f, -0.00154978f, 0.23702554f, 0.14281720f, 
    0.04101550f, -0.03740032f, 0.14603682f, 0.10183320f, 0.08981845f, -0.05285710f, 0.14025067f, 0.00446809f, 
    0.00782196f, -0.30468428f, -0.21643186f, -0.11101431f, 0.10135306f, 0.06603305f, -0.03348308f, 0.22864996f, 
    0.04498484f, -0.09084021f, 0.02810841f, -0.00086750f, 0.00389061f, -0.04837988f, -0.19412293f, -0.00484558f, 
    0.10554184f, -0.06330306f, -0.02648794f, 0.07047212f, -0.00289211f, -0.06237315f, 0.00033358f, 0.06118130f, 
    0.20222627f, -0.10502078f, 0.10128732f, 0.19608513f, -0.11143437f, 0.08978547f, 0.03095456f, -0.03706595f, 
    0.04656174f, 0.04419356f, 0.11559600f, 0.01313752f, 0.10888976f, -0.33075961f, -0.14329241f, 0.07183628f, 
    -0.04642857f, 0.17644504f, 0.11991032f, 0.05226405f, 0.08384708f, 0.09311180f, 0.05643253f, 0.01624043f, 
    0.13945401f, 0.06861400f, 0.08958088f, 0.21789773f, -0.08106131f, 0.00569017f, 0.09687177f, 0.00115957f, 
    -0.01267951f, 0.04853907f, -0.02853161f, 0.00337972f, 0.05994071f, 0.32846466f, -0.15710460f, 0.03271135f, 
    0.11833487f, 0.02586045f, 0.06212124f, -0.07776420f, 0.07968530f, -0.08552308f, -0.00774616f, 0.07456599f, 
    0.06257298f, 0.11277308f, -0.08864614f, 0.22338581f, -0.04958785f, 0.06431144f, 0.15136273f, 0.03689327f, 
    -0.03412841f, -0.18076509f, -0.10583428f, -0.09824379f, 0.50610441f, 0.15375416f, -0.10140768f, 0.17320432f, 
    0.09681747f, -0.00222187f, -0.04191820f, 0.05652380f, -0.03860468f, 0.02612133f, 0.13138142f, 0.05357650f, 
    0.13748428f, -0.06151461f, 0.31324825f, -0.08385687f, -0.00591573f, -0.00291878f, 0.02789554f, 0.00838728f, 
    -0.00094858f, 0.02931931f, 0.08439364f, -0.01056380f, -0.17198551f, -0.25005573f, -0.05657616f, 0.12323885f, 
    -0.03698972f, -0.00871182f, 0.10781506f, 0.19594215f, -0.12958211f, 0.03170967f, 0.00807565f, 0.07909498f, 
    0.08070766f, 0.11089444f, 0.02956965f, -0.01048412f, 0.15916535f, -0.05777400f, -0.08407191f, 0.06693283f, 
    0.05901861f, 0.06936496f, 0.01347468f, 0.00671512f, -0.10109968f, -0.12941721f, 0.10180931f, 0.08179544f, 
    0.04381702f, -0.04988705f, 0.08335478f, -0.03917522f, 0.00146435f, -0.04435455f, 0.14860192f, 0.04178328f, 
    -0.06491552f, -0.13857192f, 0.01484660f, -0.19930479f, 0.09231248f, -0.07073023f, 0.04644952f, -0.04797960f, 
    0.03604599f, -0.09673308f, 0.07143570f, -0.00983420f, 0.27815115f, -0.24986348f, 0.09960636f, -0.27355766f, 
    0.02864289f, 0.13543098f, 0.02642764f, 0.07150086f, 0.07371264f, -0.02885354f, -0.03352853f, -0.06179597f, 
    0.16637632f, 0.01300233f, 0.26389349f, -0.24335106f, -0.06843315f, -0.08359315f, -0.05680449f, -0.00755394f, 
    0.02455561f, 0.03227276f, 0.03590494f, -0.03612496f, 0.19315867f, 0.07351203f, 0.06062895f, -0.12925035f, 
    -0.03417005f, -0.19078679f, 0.05443290f, 0.02627542f, -0.14213176f, 0.00623615f, 0.04351185f, -0.01724358f, 
    -0.07833867f, -0.00033096f, -0.03641365f, 0.16144069f, 0.04644284f, 0.01448342f, -0.02298339f, 0.06085404f, 
    0.03642810f, 0.10922032f, 0.07377384f, -0.11951005f, -0.16549921f, -0.16945751f, 0.06340142f, -0.03749341f, 
    0.09031458f, -0.07515785f, 0.00684727f, 0.12853573f, 0.04373138f, -0.00033929f, 0.03939555f, -0.00631884f, 
    -0.19447355f, -0.06480739f, -0.06621005f, -0.08558459f, -0.04516569f, -0.05724026f, -0.12260606f, -0.08483699f, 
    -0.04426572f, -0.00900092f, 0.16231206f, -0.04489605f, -0.13950796f, -0.08119509f, -0.19628006f, 0.21529602f, 
    -0.14706373f, -0.11000216f, -0.07553937f, -0.14870344f, 0.08260065f, 0.07531380f, -0.11136952f, 0.06101800f, 
    0.19029893f, 0.09593110f, 0.03963363f, 0.13148384f, -0.14254497f, -0.00401601f, 0.03745304f, 0.04302653f, 
    0.08560759f, -0.04421335f, 0.10424805f, -0.00590587f, -0.02354472f, -0.07076414f, 0.17435718f, 0.03411459f, 
    0.02446702f, 0.04229179f, 0.00275777f, 0.09733772f, 0.04109658f, 0.06445594f, 0.01700121f, 0.06806607f, 
    0.37943244f, -0.01730848f, 0.24416304f, 0.13803861f, -0.04170681f, 0.02661626f, 0.03215468f, 0.05142413f, 
    0.01674101f, 0.06213935f, 0.01961794f, 0.10486963f, -0.20618923f, -0.14167389f, -0.03224533f, -0.13398711f, 
    -0.04639816f, -0.11703002f, 0.07525409f, 0.10390451f, 0.01800953f, -0.05114879f, 0.03251340f, 0.07383065f, 
    0.25883132f, -0.05916356f, -0.18158239f, -0.00072860f, 0.04216111f, -0.03318511f, 0.03134394f, 0.04647948f, 
    0.02983918f, 0.04170319f, 0.09792184f, -0.03549922f, -0.12544498f, 0.23147973f, -0.15657574f, -0.10514195f, 
    0.02372234f, -0.02609954f, 0.02319047f, 0.07780293f, 0.04025572f, 0.07055759f, 0.08245204f, 0.03563204f, 
    -0.14924312f, 0.11356477f, -0.20650013f, -0.10377040f, -0.05280269f, 0.06195642f, 0.06729227f, -0.05294590f, 
    0.06190689f, -0.02437684f, 0.15896277f, -0.11178119f, -0.00783930f, -0.02231493f, 0.01074739f, 0.00058225f, 
    0.02465825f, -0.11639237f, 0.00617013f, 0.00948723f, 0.01871930f, -0.04244552f, 0.01644803f, 0.02873050f, 
    -0.11025795f, 0.07492194f, -0.03153557f, 0.19001563f, 0.05067100f, -0.05366430f, -0.00245420f, 0.18362035f, 
    0.02265960f, 0.06066661f, -0.03547096f, 0.02548703f, -0.14998059f, 0.33496869f, -0.01921920f, 0.05316191f, 
    -0.13070197f, 0.02353242f, -0.07134473f, -0.06797390f, 0.13311543f, 0.00430358f, 0.10713369f, 0.10036491f, 
    0.24171123f, -0.11598630f, -0.27005559f, 0.06331195f, 0.10190216f, 0.00167634f, 0.02308968f, -0.01931999f, 
    0.01977443f, 0.06414419f, 0.03080593f, 0.09666245f, 0.22301693f, -0.01298701f, 0.06651918f, 0.03574815f, 
    0.17832743f, 0.03294688f, -0.08781292f, -0.03886133f, 0.01327868f, 0.00945679f, -0.06400287f, 0.09730332f, 
    -0.03667496f, -0.05659620f, -0.06187432f, -0.07038531f, 0.06742118f, -0.08220653f, 0.03985531f, -0.08136526f, 
    -0.05226898f, -0.08697180f, -0.00117040f, 0.04530116f, -0.07696569f, -0.03332193f, -0.11450571f, -0.24075851f, 
    -0.11474176f, -0.03587670f, -0.00489000f, -0.10720083f, 0.08025890f, 0.05590581f, 0.00844815f, -0.07724919f, 
    -0.07300584f, -0.09511451f, -0.02284645f, -0.02627739f, 0.04650824f, -0.02483406f, 0.14243945f, 0.09649096f, 
    0.02596891f, 0.10529108f, 0.02492551f, 0.14453778f, -0.30059525f, -0.04508501f, 0.06803963f, -0.00215864f, 
    0.28720388f, -0.00038262f, -0.07880501f, 0.15763143f, -0.00238351f, -0.01633717f, -0.06577171f, -0.04794540f, 
    0.06826011f, 0.10321120f, -0.18899122f, -0.04267593f, 0.07980458f, -0.14104329f, -0.04011210f, -0.02768318f, 
    0.04924849f, 0.11366461f, -0.02153216f, 0.02318054f, 0.08687799f, -0.13261732f, 0.09073106f, 0.01858002f, 
    -0.19239298f, -0.03120954f, 0.08383390f, 0.08749433f, 0.04318758f, -0.01498433f, 0.03510971f, -0.02083137f, 
    0.10622526f, 0.02344052f, -0.23387861f, -0.26227775f, 0.23671584f, -0.14273676f, -0.05661959f, -0.06683934f, 
    -0.02453096f, 0.06995533f, -0.04829985f, -0.07506628f, 0.05353401f, 0.05257154f, 0.27314577f, -0.28168008f, 
    0.01392631f, 0.11398017f, 0.01393786f, 0.10944410f, -0.20059223f, 0.03504053f, -0.07833106f, 0.07045151f, 
    0.00497430f, 0.14868379f, -0.31526801f, 0.03533557f, 0.03181461f, 0.07126746f, -0.01888330f, -0.05400242f, 
    0.08361269f, -0.12391583f, 0.01256185f, 0.02222882f, 0.05639569f, 0.03561168f, 0.07802329f, -0.04195789f, 
    -0.12996261f, 0.03733377f, -0.02942240f, -0.17779741f, 0.15767346f, 0.10367656f, -0.03791891f, -0.15949608f, 
    0.02664217f, -0.12066420f, 0.10317851f, 0.11553999f, 0.02782260f, -0.18874884f, 0.05463224f, 0.03479918f, 
    -0.13450891f, 0.02877144f, 0.06193996f, -0.01684361f, -0.18086791f, 0.15579680f, -0.30862379f, -0.08433262f, 
    0.09107387f, -0.04745081f, -0.04706043f, 0.02165487f, 0.08408116f, 0.06808512f, -0.06916516f, 0.01878149f, 
    0.07858509f, 0.07282645f, 0.09944400f, -0.14378496f, -0.04933414f, 0.13994566f, 0.16832523f, 0.00748535f, 
    0.05741475f, -0.02121163f, 0.04219818f, 0.00668910f, -0.21882662f, 0.06185670f, -0.13497265f, 0.25434324f, 
    0.14248757f, -0.01294182f, 0.11560141f, 0.14490299f, -0.01622836f, 0.00861235f, -0.02047944f, -0.06993245f, 
    -0.17486338f, 0.09692739f, -0.09994613f, 0.26036620f, 0.17574149f, 0.17547487f, -0.05289522f, -0.01838308f, 
    0.01784371f, 0.17851974f, 0.00434515f, -0.00260077f, -0.10452996f, 0.07195558f, -0.00134820f, 0.09750266f, 
    -0.01394494f, 0.04477916f, -0.12638921f, 0.10083881f, 0.26367769f, 0.10590881f, 0.08733232f, 0.22952618f, 
    -0.00838474f, 0.01127293f, 0.11600330f, -0.14827590f, -0.06425573f, -0.10508766f, -0.07930660f, -0.00134678f, 
    -0.01409581f, 0.07303707f, 0.01989555f, 0.07823013f, 0.01888843f, -0.01075910f, 0.06806928f, 0.06470892f, 
    -0.22495838f, 0.04210732f, 0.12111362f, -0.19257738f, -0.12200271f, 0.10895450f, 0.03035664f, 0.08275420f, 
    0.17324229f, -0.02792822f, 0.05338009f, -0.08600797f, 0.17247024f, 0.02615750f, -0.03425218f, -0.06802097f, 
    0.06923003f, 0.01576395f, 0.00231178f, -0.02253023f, 0.08816263f, 0.21201834f, 0.03734739f, -0.18828414f, 
    0.03724497f, -0.04878794f, 0.15356383f, -0.03227571f, 0.05684855f, -0.05754222f, 0.15964831f, -0.01109324f, 
    -0.03899633f, -0.03556945f, 0.01298241f, -0.07282224f, -0.01728384f, -0.03527074f, 0.01484075f, -0.02639502f, 
    0.05194012f, -0.00251191f, 0.04751513f, 0.06173037f, -0.02547101f, -0.01069081f, -0.05001608f, -0.02174227f, 
    0.06305679f, -0.01958473f, 0.00882730f, 0.01067306f, -0.00918347f, 0.04193109f, -0.04213448f, 0.05000167f, 
    0.03846594f, -0.06823182f, 0.04571743f, 0.00374740f, -0.00237563f, -0.07056005f, -0.05192581f, -0.05313518f, 
    -0.01236990f, -0.01878001f, 0.03180483f, -0.00490759f, -0.05916910f, 0.04296282f, -0.04509146f, -0.05536755f, 
    0.05995116f, -0.02477462f, -0.04151069f, 0.04396869f, -0.01901602f, 0.01170504f, 0.00961725f, -0.05461787f, 
    0.02895454f, -0.00546283f, -0.08222096f, -0.05994577f, 0.01050500f, 0.01631540f, -0.05371529f, -0.03205032f, 
    -0.04687572f, -0.01749291f, 0.04255974f, 0.04933882f, 0.03470823f, -0.01576617f, 0.05274432f, -0.02643250f, 
    -0.00970898f, -0.07194506f, -0.01105151f, -0.02309517f, -0.01421123f, 0.00135860f, -0.03954512f, -0.03233710f, 
    0.00491970f, 0.01824455f, 0.00082680f, 0.04043002f, 0.03232331f, -0.04608096f, 0.06669842f, 0.03704975f, 
    -0.01338982f, -0.02803328f, -0.05920336f, 0.02286773f, -0.06357785f, -0.03055771f, -0.01781054f, -0.01440001f, 
    0.01488891f, -0.02512515f, 0.04861464f, -0.07149172f, -0.05541691f, -0.03167808f, -0.00854088f, -0.00482118f, 
    0.05199393f, -0.04950999f, -0.00815531f, 0.02316857f, 0.02138756f, -0.04888378f, 0.02577585f, -0.00278489f, 
    -0.05402652f, -0.04644526f, 0.05976678f, -0.05190143f, 0.06091491f, -0.07725111f, 0.06104176f, -0.08343793f, 
    0.02740431f, -0.05937059f, -0.04779905f, 0.02705112f, 0.03938325f, 0.01619335f, -0.04797031f, 0.04971339f, 
    -0.03536557f, 0.02433514f, 0.04249618f, 0.02190329f, -0.05812968f, -0.00082092f, -0.00884219f, 0.00605700f, 
    -0.07514704f, 0.05655760f, -0.05040732f, -0.06346361f, 0.01099890f, -0.06618895f, 0.04159995f, 0.04107741f, 
    0.02740191f, -0.05186045f, 0.02356907f, -0.01465070f, -0.06978245f, 0.05241579f, 0.04009370f, -0.08474968f, 
    0.05181225f, 0.03688326f, -0.04762898f, -0.03625600f, -0.06978466f, 0.01671243f, 0.00601810f, -0.01236363f, 
    -0.04539363f, -0.02722517f, 0.01467503f, -0.00805511f, -0.03105783f, 0.01218130f, -0.02582018f, -0.01878301f, 
    -0.07471135f, 0.02205239f, 0.02045023f, -0.01614272f, 0.05243131f, -0.03399302f, 0.01230053f, 0.02968434f, 
    0.01365664f, 0.00019924f, 0.02733005f, 0.03502098f, -0.03214137f, -0.04112237f, -0.07449749f, -0.00752465f, 
    -0.06856597f, 0.04357694f, 0.02573295f, 0.04236247f, -0.06256416f, -0.06967647f, 0.02632221f, 0.05029465f, 
    -0.06678797f, -0.06597475f, 0.06225444f, 0.03387023f, -0.01916651f, 0.03995913f, 0.01701731f, -0.04662975f, 
    0.01095766f, 0.05913260f, -0.01645820f, 0.02105620f, 0.02912968f, -0.06819893f, -0.05329864f, -0.02274536f, 
    -0.02061538f, -0.00812361f, -0.06663118f, 0.00742117f, 0.02799885f, -0.00827329f, 0.06554919f, 0.06470505f, 
    -0.02442456f, -0.02962517f, 0.01811082f, 0.03438565f, 0.01590675f, 0.04340233f, -0.06266329f, -0.03621482f, 
    -0.02879584f, 0.02794739f, -0.07110079f, -0.07289245f, 0.06909793f, -0.05950974f, 0.01963017f, 0.06396052f, 
    0.02236575f, 0.04263163f, 0.02250961f, -0.00166300f, -0.02018889f, -0.05829126f, -0.02345419f, -0.03308819f, 
    0.01181371f, -0.00303269f, -0.02714179f, -0.06721736f, -0.02911636f, -0.00413757f, -0.00766021f, -0.05147171f, 
    0.01764647f, 0.01639420f, -0.04426998f, -0.07303995f, 0.03157016f, -0.07655258f, -0.05579497f, -0.06388012f, 
    0.03216060f, -0.02463244f, -0.03441612f, 0.02594321f, 0.00260193f, 0.03142447f, -0.06244007f, -0.04563211f, 
    -0.07556467f, 0.04797557f, 0.02181689f, 0.03547804f, 0.04131050f, -0.02302672f, -0.03622984f, -0.05674479f, 
    -0.06820828f, 0.00605151f, -0.00221965f, 0.00776757f, 0.03971574f, -0.01831244f, 0.03396055f, 0.05337067f, 
    0.03604528f, 0.03401870f, -0.06790652f, -0.05290035f, -0.02810282f, 0.05437678f, 0.03940463f, 0.01175543f, 
    -0.01117218f, 0.02820408f, -0.01200192f, -0.02279147f, 0.03120842f, -0.07479411f, 0.02295011f, 0.05952685f, 
    -0.04490898f, -0.02342796f, -0.02222904f, -0.00208317f, -0.05515746f, -0.01278897f, 0.05549949f, -0.07300952f, 
    0.03062445f, -0.05505767f, -0.05036232f, -0.03373528f, -0.02438608f, -0.01132121f, 0.05408269f, 0.02961014f, 
    -0.05583359f, 0.02580503f, -0.04147031f, 0.00496607f, -0.04928967f, -0.02095831f, -0.04121524f, -0.00596155f, 
    -0.03997272f, -0.02448013f, -0.00344128f, 0.01375352f, -0.01460987f, 0.03877372f, -0.05476719f, -0.03756008f, 
    -0.07570294f, 0.00172627f, -0.04589181f, 0.01422361f, 0.02901091f, -0.07320085f, 0.01734521f, -0.02390492f, 
    -0.00348833f, 0.05306559f, -0.07366487f, -0.05832188f, 0.05646320f, 0.00480967f, -0.06550609f, 0.04058786f, 
    -0.05968126f, 0.00725671f, 0.02311482f, 0.00263557f, 0.04781703f, -0.06355669f, 0.02509549f, 0.05821572f, 
    0.05221823f, -0.04640860f, -0.04099576f, -0.00506226f, -0.01140037f, 0.01352099f, -0.01613666f, -0.03492691f, 
    0.01983030f, -0.01733644f, -0.04608459f, -0.01792886f, 0.03751034f, -0.05523542f, -0.05351502f, 0.01779437f, 
    0.00178718f, -0.04421797f, -0.05558558f, -0.01316314f, -0.06063652f, -0.00725709f, 0.00811623f, 0.01478848f, 
    -0.06299081f, 0.02040886f, -0.06017070f, -0.03339951f, 0.03032782f, 0.02090110f, 0.04413174f, -0.01983067f, 
    0.04999590f, -0.02477831f, -0.04967825f, 0.06802197f, -0.05435769f, -0.04828202f, 0.04227758f, 0.00700301f, 
    -0.08016462f, -0.06134259f, 0.02173909f, -0.04855661f, 0.01753408f, -0.04715211f, 0.01256520f, 0.00330889f, 
    -0.01563475f, -0.00880696f, 0.05460873f, -0.01449464f, 0.03189553f, -0.03265434f, 0.01375021f, 0.05689628f, 
    -0.07581589f, -0.04228051f, 0.04206003f, -0.05139777f, 0.01609778f, 0.05233615f, 0.05644852f, -0.00557564f, 
    0.05630959f, -0.06311037f, 0.00542653f, -0.04500788f, -0.06665308f, -0.02148570f, 0.03678042f, 0.02903238f, 
    0.00610941f, -0.00171352f, -0.06434032f, -0.02188006f, -0.04043199f, -0.04840240f, 0.04599614f, -0.05007761f, 
    -0.07228930f, -0.04970450f, 0.03402961f, -0.00678861f, 0.00186847f, 0.02133266f, 0.03491125f, -0.02485858f, 
    0.00286687f, 0.05719539f, -0.06369598f, 0.05492031f, -0.02976526f, -0.07136504f, 0.02417381f, 0.00469633f, 
    -0.06976991f, -0.03376094f, -0.04224473f, -0.01752760f, -0.07018837f, -0.02333378f, -0.06198043f, -0.07440395f, 
    -0.04856922f, 0.02051602f, -0.03787624f, 0.05382423f, 0.00707525f, 0.02854672f, -0.02367028f, 0.02410196f, 
    0.00361096f, -0.02405737f, 0.01522801f, 0.02704940f, -0.02120528f, -0.04705054f, 0.03066368f, -0.07916151f, 
    -0.03135097f, 0.06099339f, 0.00770384f, -0.00633147f, 0.02352435f, -0.06170567f, -0.04965883f, 0.01632696f, 
    -0.05609437f, -0.03344966f, 0.03275172f, -0.00283686f, -0.04777700f, -0.02515516f, 0.04848831f, -0.07043467f, 
    -0.03607685f, -0.04707287f, -0.01712517f, 0.05041046f, 0.00881360f, -0.04829732f, 0.02198686f, -0.05807091f, 
    0.05657483f, -0.03259351f, 0.02588884f, -0.01563618f, -0.01689680f, -0.04916067f, 0.04182959f, -0.00461260f, 
    0.05629087f, -0.05656211f, 0.05729844f, -0.04714299f, -0.05944735f, 0.02023256f, -0.02398248f, -0.01651595f, 
    -0.05994796f, -0.06530588f, -0.07618240f, -0.01659687f, -0.07753199f, 0.04020922f, -0.06472165f, -0.04806207f, 
    -0.07505638f, -0.00738974f, -0.00866829f, -0.02283253f, -0.05113797f, -0.08205940f, -0.04812160f, 0.02538925f, 
    0.02262752f, 0.05378349f, 0.00855797f, -0.04358903f, -0.05117165f, -0.04809269f, -0.02714868f, 0.02426236f, 
    0.02204694f, -0.07179628f, -0.04566295f, -0.03552705f, -0.04729502f, 0.00471514f, -0.06102157f, -0.01166567f, 
    0.03315772f, 0.00494744f, 0.06116486f, -0.06407490f, -0.01672608f, 0.01059703f, 0.05868021f, -0.06144103f, 
    0.05562931f, 0.06041728f, 0.03228581f, -0.05740892f, 0.05257889f, -0.03770901f, 0.01644651f, -0.03218503f, 
    -0.04934319f, 0.01700035f, 0.00893182f, 0.01814469f, 0.04518107f, -0.01606832f, 0.00241874f, -0.06660787f, 
    -0.06116009f, -0.02684166f, -0.03129707f, 0.01662969f, 0.05966476f, 0.00775670f, -0.05117734f, -0.07805252f, 
    -0.01822881f, 0.03946072f, -0.07606012f, 0.01867025f, -0.05513000f, 0.03218523f, -0.00247985f, 0.00736412f, 
    0.03192857f, 0.18375424f, 0.03545012f, 0.01966279f, -0.04938314f, -0.12648043f, 0.00868227f, -0.02748279f, 
    0.01708001f, 0.10463067f, 0.07974678f, -0.06336799f, 0.16757816f, 0.10414605f, -0.08411393f, 0.00187210f, 
    -0.00036146f, -0.02284660f, -0.03746345f, 0.09231611f, 0.11386924f, -0.01281590f, 0.00207185f, 0.17360044f, 
    0.21204342f, 0.22117741f, 0.04326570f, 0.11106740f, 0.08535465f, -0.02176710f, -0.02624999f, 0.06779017f, 
    0.07373767f, 0.06676626f, -0.14166437f, 0.20199063f, 0.05637771f, -0.07522029f, 0.10203082f, -0.12871951f, 
    0.08583315f, -0.04378626f, 0.16148669f, 0.06229779f, -0.09878942f, 0.03291146f, 0.05992676f, 0.04499723f, 
    0.07642675f, -0.07624666f, -0.05421964f, -0.06202822f, -0.05877550f, 0.07651197f, -0.12959245f, 0.00205122f, 
    0.18447460f, -0.04353452f, 0.10159846f, 0.04701080f, -0.22869760f, -0.28369710f, -0.11095556f, 0.07609633f, 
    0.01180435f, 0.09076685f, 0.04190902f, -0.03386896f, 0.02044841f, -0.01125939f, 0.04386412f, -0.10472979f, 
    0.02357712f, 0.02507237f, 0.05263952f, -0.07715647f, 0.13367704f, 0.03183307f, -0.01751992f, 0.15581815f, 
    -0.05415933f, -0.05970448f, 0.02321536f, 0.04586086f, -0.20111458f, -0.01769747f, -0.08778216f, -0.07591413f, 
    -0.07621388f, -0.09692415f, -0.04275026f, 0.09546940f, -0.06878409f, 0.06766981f, 0.04550269f, 0.08117127f, 
    -0.30349785f, 0.05908347f, -0.13341920f, -0.13127671f, -0.02300685f, -0.05633286f, 0.02357320f, -0.13297103f, 
    0.06409161f, 0.00187288f, 0.09503429f, -0.01239657f, 0.13352229f, -0.21078958f, 0.05823380f, 0.09513586f, 
    0.07269093f, 0.09405736f, -0.03517732f, -0.14775306f, -0.01060680f, 0.10072976f, 0.04858240f, -0.12278333f, 
    0.09258994f, 0.27160472f, -0.04101446f, 0.11524390f, 0.13766445f, 0.08617830f, 0.15121157f, -0.03113907f, 
    0.14168817f, 0.02670421f, 0.12059477f, 0.00253432f, 0.06179572f, 0.25921053f, 0.18201731f, 0.02571247f, 
    0.13469024f, 0.07659943f, -0.11783830f, -0.08433216f, 0.07973113f, 0.01195824f, -0.05772535f, -0.04053840f, 
    -0.39288133f, 0.08611946f, -0.11061261f, -0.28255576f, 0.10890913f, -0.00276109f, -0.09262753f, -0.15863036f, 
    0.10245208f, 0.10713473f, -0.07677508f, -0.01890399f, 0.13738133f, -0.17683369f, 0.02121455f, 0.02615700f, 
    0.06161062f, -0.02398144f, 0.03943531f, 0.00847667f, -0.00109394f, -0.00020435f, 0.17217991f, -0.10517249f, 
    0.05971018f, 0.05535159f, 0.10292511f, -0.11465038f, -0.06706557f, -0.05217182f, 0.03030920f, 0.03831318f, 
    0.12480301f, 0.19947605f, 0.01390948f, 0.09871361f, -0.34888679f, 0.06033585f, 0.05630498f, 0.03074166f, 
    0.03771615f, 0.00286384f, 0.05133847f, -0.04409892f, 0.14367661f, 0.04376695f, -0.01148564f, -0.02265628f, 
    -0.01441606f, -0.03568671f, -0.02024062f, -0.06022056f, 0.01734123f, -0.06853593f, -0.06371113f, -0.04596962f, 
    -0.03400391f, -0.03388288f, -0.05243930f, -0.02759042f, 0.00065395f, -0.07758411f, 0.06181732f, -0.02878769f, 
    -0.06393372f, 0.06216598f, -0.05647736f, -0.02442301f, 0.05809017f, -0.04468629f, -0.00369417f, -0.06450820f, 
    0.06131357f, -0.07096704f, -0.03424078f, -0.01791877f, -0.03914068f, 0.03114404f, -0.05055916f, -0.03336334f, 
    -0.00036980f, 0.00556861f, -0.07200035f, -0.01252835f, -0.06665437f, 0.03521850f, -0.03018156f, -0.02743946f, 
    0.05615831f, 0.01497788f, -0.05253394f, -0.02146577f, 0.03369067f, -0.02909885f, -0.01301358f, -0.01727590f, 
    -0.02536839f, -0.05796084f, -0.00515904f, 0.05781433f, -0.01652577f, 0.06084464f, 0.00909745f, -0.01501946f, 
    -0.01337218f, -0.04185608f, 0.06588569f, -0.00504221f, -0.06084413f, -0.03492847f, -0.00531255f, 0.06926586f, 
    0.02444012f, -0.06614940f, 0.02308742f, -0.07369667f, -0.07588726f, 0.02976041f, -0.04595046f, -0.00487337f, 
    -0.05029586f, 0.02568443f, -0.01626137f, -0.02502966f, -0.07995404f, -0.02725041f, -0.03748910f, 0.03084279f, 
    -0.03980196f, -0.05467842f, 0.05071457f, 0.01339872f, 0.00932854f, 0.03183926f, -0.07320455f, -0.03052392f, 
    0.01805506f, -0.05430584f, -0.04952814f, 0.03605911f, -0.04447016f, 0.03767306f, 0.02566945f, -0.06059567f, 
    -0.06302398f, -0.03235064f, 0.03503180f, -0.06969949f, 0.06127432f, 0.05537198f, -0.06563487f, -0.07064401f, 
    -0.00737216f, 0.00010936f, -0.01371870f, 0.06050308f, 0.04929893f, 0.03664029f, -0.04030690f, -0.04305586f, 
    0.05811287f, -0.06192191f, -0.04534584f, -0.04529789f, 0.00996792f, 0.03378206f, -0.03619834f, 0.05988683f, 
    0.07662042f, 0.01745010f, -0.00561003f, 0.05472321f, 0.02271710f, 0.04474585f, 0.02900157f, 0.02226862f, 
    -0.06137449f, -0.04857703f, -0.03100345f, 0.02494020f, -0.03472947f, 0.06006682f, -0.06604917f, 0.05552032f, 
    0.06728604f, 0.00527980f, 0.00400531f, -0.03571767f, 0.05262820f, -0.06468122f, -0.00468830f, 0.05649717f, 
    -0.03725432f, -0.05445149f, -0.03061041f, -0.04374577f, 0.01924908f, 0.01602946f, -0.00550864f, 0.02949498f, 
    0.04488374f, 0.06900720f, 0.05862866f, -0.01132432f, -0.06408370f, -0.06803906f, 0.05599391f, -0.06795855f, 
    0.00140960f, 0.00679244f, 0.05097957f, -0.01000233f, -0.02048051f, -0.00170078f, 0.03303193f, -0.03167670f, 
    -0.02734704f, -0.01806187f, 0.02292530f, 0.00575734f, -0.05217742f, -0.01015512f, 0.06328213f, 0.00939716f, 
    -0.05945544f, 0.03819067f, 0.01369024f, 0.03393696f, -0.04680120f, 0.06436985f, 0.01324878f, -0.05922449f, 
    -0.07506708f, -0.07367630f, 0.05137611f, -0.05650901f, -0.03847482f, -0.08112387f, 0.02234240f, -0.01390063f, 
    0.15483055f, -0.06818767f, -0.06303147f, 0.25762150f, 0.20577027f, 0.05354540f, -0.06802005f, -0.00037941f, 
    -0.04486881f, -0.00875089f, 0.03032211f, -0.07235829f, 0.09995781f, -0.18921296f, -0.03040412f, 0.22409879f, 
    0.03026457f, -0.04717774f, -0.06099980f, 0.03397256f, 0.07255819f, -0.03528232f, 0.00190316f, -0.08000286f, 
    -0.21107566f, 0.02041308f, -0.17782927f, 0.12240380f, 0.02463219f, 0.02463088f, 0.11964715f, -0.06580108f, 
    0.06217686f, -0.00294758f, 0.03446877f, -0.00275119f, 0.14001250f, 0.01371481f, 0.13996491f, 0.07150382f, 
    -0.14084861f, 0.11676426f, -0.15047799f, 0.15761583f, 0.03038519f, 0.01673642f, -0.02830283f, -0.04613735f, 
    -0.12890232f, 0.11489411f, 0.06446030f, -0.22110374f, 0.02669537f, 0.12920836f, 0.17208500f, -0.05964517f, 
    -0.08858479f, 0.06943031f, 0.09273592f, 0.12116770f, 0.08611992f, -0.04133163f, -0.03600916f, -0.28200510f, 
    -0.01838190f, -0.03144484f, -0.12934569f, 0.10595575f, 0.05284379f, 0.07505549f, 0.08462113f, 0.00490091f, 
    0.29482111f, -0.06138106f, 0.01759372f, 0.12942879f, 0.10133294f, -0.12841555f, -0.03487994f, 0.01994785f, 
    -0.01256807f, 0.09709220f, 0.04947684f, 0.06230374f, 0.10042050f, 0.03886348f, 0.10504659f, -0.34182161f, 
    0.12579232f, 0.15208337f, -0.03895737f, -0.00976206f, 0.09577943f, 0.20468180f, 0.08167303f, -0.04629662f, 
    0.38245854f, -0.18486165f, 0.11561112f, -0.00070517f, -0.01844328f, -0.08053977f, 0.02299439f, -0.03610372f, 
    0.17055286f, 0.11643988f, -0.08244568f, 0.12640898f, 0.08341540f, 0.13366479f, -0.16533495f, -0.09384510f, 
    -0.01260818f, 0.01062919f, 0.05746062f, 0.08629557f, 0.05919208f, 0.02822157f, -0.01272478f, -0.00841224f, 
    0.09930685f, -0.02218008f, 0.05912269f, -0.10224427f, -0.03167370f, -0.00056881f, -0.11791418f, -0.07472737f, 
    -0.05118678f, 0.10691334f, 0.09685057f, -0.00273767f, -0.00102192f, -0.22376509f, 0.00598862f, -0.10566621f, 
    0.02980932f, -0.28250375f, 0.00648499f, 0.04242034f, 0.04797808f, 0.10071798f, 0.02986616f, -0.06665840f, 
    0.30380595f, -0.08449917f, 0.25530314f, 0.15504669f, -0.00455198f, -0.09228592f, -0.07527714f, 0.11429524f, 
    -0.04830521f, -0.05815849f, -0.01193185f, 0.02491434f, -0.27349406f, 0.15011242f, -0.00782580f, -0.24825993f, 
    -0.08169355f, 0.05544222f, -0.11396592f, -0.01936688f, -0.11123218f, -0.04561366f, -0.05029848f, 0.05066876f, 
    0.02322641f, 0.00466654f, -0.21265669f, 0.13001731f, 0.09680501f, 0.05792948f, -0.06605714f, -0.10936958f, 
    -0.06514750f, 0.01803193f, 0.08977742f, -0.07228363f, 0.41301265f, -0.20530804f, -0.09888850f, -0.01870387f, 
    -0.11460418f, 0.04506970f, 0.02518596f, -0.06129582f, -0.03537187f, 0.01857265f, -0.05312141f, 0.10059739f, 
    -0.06943045f, -0.05220781f, -0.06852699f, -0.04369897f, 0.02166951f, -0.03884974f, 0.00598849f, -0.05464983f, 
    0.06260096f, -0.03844793f, 0.01743467f, 0.01973566f, 0.02045586f, -0.01089319f, -0.01818067f, -0.06140219f, 
    0.05774003f, -0.00743434f, -0.03990406f, 0.02841515f, 0.01586499f, 0.05700428f, 0.03690743f, -0.05579880f, 
    0.01991220f, 0.01290090f, -0.03296636f, 0.06767396f, -0.00601575f, -0.03317054f, -0.00878284f, 0.01023114f, 
    0.03507924f, 0.02707304f, 0.02800000f, 0.01134235f, -0.05935376f, -0.05345839f, -0.03823473f, 0.04045769f, 
    -0.04455808f, 0.03330114f, -0.00599493f, -0.01969434f, -0.05038005f, -0.05565488f, -0.06119459f, 0.04892666f, 
    0.01310392f, 0.06462078f, -0.04695015f, -0.04523597f, -0.07583886f, 0.04717312f, 0.05199745f, 0.02887361f, 
    -0.05816799f, 0.06695284f, -0.04000499f, -0.06405650f, -0.01155812f, 0.01717327f, -0.04474300f, -0.03927784f, 
    0.04615301f, 0.02145785f, 0.02202234f, -0.03157745f, -0.00955724f, -0.04286363f, 0.02399030f, 0.04431897f, 
    -0.05089096f, -0.07612895f, 0.02101177f, -0.02653401f, 0.06580351f, -0.00191527f, 0.03296378f, 0.03486876f, 
    -0.06774129f, 0.03974532f, -0.06288328f, -0.07374092f, -0.02335134f, -0.04004762f, -0.07270330f, -0.07510731f, 
    -0.06527474f, 0.06647914f, -0.02797946f, -0.01388096f, -0.02002939f, -0.07178241f, -0.03536763f, 0.00492718f, 
    -0.05213709f, -0.01126795f, 0.06325315f, -0.07373948f, 0.01012780f, -0.05713382f, 0.03572682f, -0.05644176f, 
    0.00536193f, 0.04984159f, 0.06546687f, -0.02612615f, -0.02358144f, 0.02264372f, 0.05817284f, -0.03762497f, 
    -0.02578032f, 0.00326954f, -0.04046008f, -0.01470745f, -0.02122963f, 0.02050882f, -0.06207808f, 0.00586321f, 
    -0.06148824f, 0.06748995f, -0.06552371f, 0.04544217f, -0.07765846f, -0.00261122f, 0.04498008f, -0.07590549f, 
    -0.02225569f, 0.01867316f, 0.00370067f, -0.01004188f, -0.04433711f, 0.03326931f, -0.04603778f, 0.06175818f, 
    -0.05826953f, -0.01964869f, 0.04174787f, 0.00992323f, 0.02127184f, -0.05111710f, 0.00560337f, 0.00028460f, 
    -0.00588330f, -0.07395841f, 0.02470140f, -0.02217469f, -0.06635135f, -0.06651253f, 0.03275080f, 0.05579207f, 
    -0.05718285f, 0.00372909f, -0.06415251f, -0.05510579f, 0.01970854f, 0.00912799f, 0.05538454f, -0.04194466f, 
    -0.06868865f, -0.01601363f, -0.04359993f, 0.05522135f, -0.01685048f, -0.05272587f, 0.02760191f, -0.04527766f, 
    -0.00974381f, 0.02569007f, 0.04823580f, 0.04389424f, 0.00118432f, 0.03744597f, 0.00368542f, -0.02709582f, 
    -0.04486695f, -0.06089357f, -0.00494872f, 0.02953782f, -0.03529868f, 0.06752856f, -0.07633947f, -0.01169126f, 
    0.00690266f, 0.03483381f, 0.04588063f, -0.00137598f, 0.00815841f, 0.02372741f, -0.07735912f, -0.05285445f, 
    0.42078096f, 0.24667867f, 0.10174993f, 0.11571471f, 0.00591495f, 0.01067466f, -0.00162964f, -0.09090111f, 
    0.07517903f, -0.05049611f, 0.03159958f, -0.04173754f, 0.04143203f, -0.05790857f, 0.16665140f, 0.03519071f, 
    -0.03595586f, 0.00866268f, -0.13375042f, -0.03727043f, 0.08726420f, -0.00239015f, 0.10664625f, 0.02918422f, 
    0.49946415f, 0.05171021f, -0.04515551f, 0.30334067f, 0.08801676f, 0.06856939f, 0.04665480f, 0.04999333f, 
    -0.02701870f, -0.00710413f, -0.10078141f, -0.03022755f, -0.09854839f, -0.10485965f, 0.11631767f, -0.03420291f, 
    0.05635064f, 0.01845473f, -0.01898283f, 0.04574566f, 0.00350252f, -0.12972936f, -0.03621722f, 0.00936031f, 
    0.06470896f, 0.00117381f, -0.16029005f, -0.21077195f, 0.04968749f, 0.04379165f, 0.01417702f, -0.10243130f, 
    0.01272797f, 0.03078444f, 0.08057562f, 0.15318520f, -0.32070747f, -0.05957505f, 0.01947209f, -0.03275927f, 
    -0.10669383f, -0.05604582f, 0.04940315f, 0.02305599f, -0.02916270f, 0.01775894f, 0.09435950f, 0.08454981f, 
    -0.14825362f, 0.07719839f, -0.01990183f, -0.01008634f, 0.06863811f, 0.11321454f, -0.08316743f, 0.08611925f, 
    -0.04610030f, -0.11648231f, -0.03723199f, -0.02459862f, -0.17230499f, 0.05883382f, -0.23784959f, -0.29041767f, 
    0.06250802f, 0.04752030f, -0.03278087f, 0.08540017f, 0.06443558f, 0.00491920f, 0.01531745f, 0.13215622f, 
    -0.21163368f, 0.05779335f, -0.07748711f, 0.09441714f, 0.00484854f, -0.01732801f, 0.03995875f, 0.12805332f, 
    -0.06448357f, -0.00887107f, 0.03235282f, -0.01126312f, -0.02139440f, -0.05735252f, -0.10945596f, 0.06389009f, 
    0.05016749f, 0.09326960f, 0.02770732f, -0.11398194f, 0.01597599f, 0.09317757f, 0.08988063f, 0.01151994f, 
    0.42145050f, 0.21102521f, -0.02129358f, 0.08087076f, 0.04910157f, 0.06010641f, -0.07549710f, 0.05875786f, 
    -0.02633436f, -0.03010982f, 0.07539175f, 0.10334980f, 0.38724416f, 0.34469074f, 0.04800498f, -0.05065611f, 
    0.05690300f, -0.11658765f, -0.11108885f, 0.10040588f, 0.00131903f, 0.15751544f, -0.03371635f, 0.04759533f, 
    -0.14491034f, -0.03946388f, -0.03560223f, -0.18860376f, 0.16518396f, 0.03682484f, 0.03896310f, -0.04990392f, 
    0.05939939f, 0.06171739f, 0.01645708f, 0.05471876f, -0.13114776f, 0.04762260f, 0.03734057f, 0.07633618f, 
    -0.10521530f, 0.04275946f, -0.10894389f, -0.09810550f, 0.01509049f, 0.04657266f, 0.09179269f, 0.00655892f, 
    0.27407163f, -0.04813935f, -0.16709296f, -0.02621630f, -0.00068543f, -0.03469700f, 0.05678074f, 0.05494099f, 
    -0.00590036f, 0.18321276f, -0.00930060f, 0.04488956f, -0.02631376f, -0.04577066f, 0.05039359f, 0.06087866f, 
    0.19712298f, -0.03802573f, 0.02243691f, 0.01877031f, 0.13658552f, 0.02036383f, -0.01241223f, 0.01877526f, 
    -0.14856865f, -0.16804639f, -0.09526123f, 0.00724557f, 0.04855751f, -0.07034933f, -0.06544114f, 0.06867624f, 
    0.00746022f, 0.05224771f, 0.00364661f, -0.02343876f, -0.14645180f, 0.00519480f, -0.10144228f, -0.04911401f, 
    -0.08077619f, -0.10420953f, -0.04142336f, 0.01271255f, 0.03792971f, 0.03623651f, 0.01536319f, 0.07145311f, 
    -0.12546942f, -0.07144202f, -0.14343080f, -0.19038917f, -0.17340039f, -0.01237896f, 0.02992878f, 0.08088997f, 
    -0.04787750f, -0.04799428f, 0.02481524f, 0.09998848f, 0.02434553f, -0.11724914f, -0.08501142f, 0.29055870f, 
    0.07283311f, 0.09374496f, -0.00094542f, -0.06142185f, 0.01670625f, 0.12630969f, 0.01375880f, 0.00782286f, 
    -0.19785945f, -0.00271071f, 0.15547387f, 0.04456738f, 0.05142430f, -0.07617982f, 0.04670944f, 0.00431156f, 
    -0.00598352f, -0.02491771f, 0.13067558f, -0.07882047f, 0.28469700f, -0.07166734f, 0.14529835f, -0.04283480f, 
    0.22403066f, 0.15488422f, 0.02750562f, 0.09499139f, 0.13834295f, -0.02846910f, 0.05093594f, -0.08013423f, 
    0.13495894f, 0.22889937f, 0.18189420f, -0.08562437f, 0.02553445f, 0.02841040f, 0.11711325f, 0.06162243f, 
    -0.04660369f, 0.08661750f, 0.07646048f, 0.06542775f, 0.22337560f, -0.07860396f, 0.13462810f, 0.40361539f, 
    0.00026900f, -0.08955531f, 0.03314318f, -0.07743412f, 0.01407096f, -0.05564044f, -0.14003210f, 0.02440272f, 
    0.09604262f, 0.01417614f, 0.12782370f, 0.11231274f, 0.01639914f, -0.00875061f, 0.03799835f, 0.04906844f, 
    0.16214292f, 0.08853366f, 0.01617472f, 0.14484839f, 0.30399182f, 0.04805939f, 0.14361063f, -0.05640803f, 
    -0.06007127f, 0.03974255f, 0.01173959f, -0.12934496f, -0.06300776f, -0.03349861f, -0.12402807f, 0.03807211f, 
    -0.33350304f, -0.16224235f, -0.00102752f, -0.20312166f, -0.03599570f, -0.01241554f, 0.09209776f, -0.08562970f, 
    0.00500634f, -0.05225683f, 0.11388271f, -0.07532231f, -0.36686483f, -0.32674417f, -0.08589660f, -0.30752313f, 
    -0.05213301f, -0.12398935f, 0.03590458f, -0.13893411f, -0.05905442f, 0.00213187f, 0.07250089f, -0.12569709f, 
    0.02420345f, 0.14531828f, 0.19921771f, 0.13124803f, -0.09482650f, -0.01112466f, 0.13160479f, 0.11435717f, 
    0.01827900f, 0.00665586f, 0.03079090f, -0.11694364f, 0.35535547f, -0.03403517f, 0.03896338f, 0.02727140f, 
    0.12174151f, 0.12562571f, 0.19984268f, 0.00882248f, 0.04412217f, -0.00953278f, -0.10878828f, -0.06507419f, 
    -0.19450067f, 0.10540275f, -0.06306268f, 0.05637305f, -0.02900717f, 0.09751718f, -0.09817372f, -0.06806683f, 
    0.02901567f, 0.08661001f, -0.00569048f, 0.03649602f, -0.11083075f, 0.14483468f, -0.01729919f, -0.00072613f, 
    0.05609877f, 0.07133883f, 0.00470876f, 0.05566226f, 0.03276942f, 0.13547732f, -0.05961077f, 0.03220883f, 
    -0.05186665f, -0.01235742f, 0.05392762f, -0.02071355f, 0.03821056f, 0.02814754f, 0.01203372f, -0.02635705f, 
    -0.07447901f, -0.04455814f, 0.05539745f, -0.00724062f, -0.04911686f, -0.02996423f, -0.00757122f, -0.04942664f, 
    -0.01963974f, -0.01911099f, -0.04826783f, -0.03006963f, 0.00243004f, -0.06883971f, -0.03134201f, -0.02384076f, 
    -0.05324683f, 0.04318900f, 0.00798093f, 0.04572084f, -0.07020305f, -0.05581080f, -0.06023414f, -0.00463749f, 
    0.03877760f, -0.00355293f, -0.00225587f, 0.03024689f, 0.04494572f, 0.01715696f, 0.01398566f, 0.03915753f, 
    0.00195558f, -0.07282488f, 0.04047660f, -0.04054910f, 0.05451330f, -0.06552822f, -0.07404764f, 0.06291167f, 
    -0.02902603f, -0.01432032f, 0.05734863f, 0.03354961f, 0.02444532f, -0.03935356f, -0.05232389f, 0.04948385f, 
    0.00673155f, 0.00526570f, -0.08018038f, 0.01223621f, 0.01243972f, 0.02841813f, -0.00696612f, -0.07992004f, 
    0.02063854f, 0.02669937f, -0.03478507f, -0.01255416f, -0.04589802f, -0.03129143f, -0.05250262f, 0.02853560f, 
    0.00601099f, -0.00983202f, 0.00338676f, 0.04796072f, 0.03281228f, -0.04425372f, -0.01687230f, -0.00526094f, 
    0.03806055f, -0.01826387f, -0.05626502f, 0.06033151f, -0.06380627f, 0.04843659f, -0.01974237f, -0.04122712f, 
    0.02968039f, -0.03614856f, 0.05149852f, 0.06649200f, 0.07188454f, 0.00340477f, -0.02394656f, -0.03962907f, 
    0.01211365f, 0.02608579f, 0.02567915f, -0.07204349f, -0.02991783f, 0.04520493f, -0.01912976f, -0.07500301f, 
    0.02730663f, -0.07899228f, -0.03179558f, 0.03510606f, -0.04270991f, -0.03401471f, 0.05955897f, -0.00369431f, 
    -0.03254575f, -0.06990866f, 0.02270741f, 0.05315036f, -0.00033776f, -0.00537568f, 0.03485171f, -0.08340706f, 
    -0.00583766f, -0.03644462f, -0.05931432f, -0.02070821f, -0.02534291f, 0.03815122f, -0.05565118f, 0.06359161f, 
    -0.02479951f, 0.04487323f, 0.02354418f, -0.01386461f, 0.02169701f, -0.03647855f, 0.04478348f, -0.01066237f, 
    0.02672020f, -0.06057279f, 0.00218352f, 0.01862353f, 0.06059245f, -0.03043894f, 0.06291971f, 0.05275245f, 
    -0.06180146f, -0.03915031f, -0.01281293f, -0.05788000f, -0.02868809f, -0.07041900f, -0.00349745f, 0.01961662f, 
    -0.00600648f, -0.00748808f, -0.05887206f, 0.06256340f, 0.02222663f, -0.00585561f, 0.01774877f, 0.04695284f, 
    -0.02393098f, 0.01747424f, -0.07372379f, -0.05443820f, -0.06811383f, 0.04523480f, 0.03383264f, 0.00099294f, 
    -0.01544882f, -0.01181792f, -0.04573721f, -0.06635166f, -0.05592161f, -0.01724478f, -0.02564616f, 0.01672487f, 
    0.02013074f, 0.05354682f, -0.02620634f, 0.03697273f, 0.01980227f, -0.01506429f, 0.03181711f, 0.00016746f, 
    -0.00880244f, 0.03015353f, -0.01813931f, 0.03153516f, 0.04535697f, 0.00095296f, 0.01265034f, 0.00498814f, 
    -0.04304354f, 0.10266843f, 0.22688241f, 0.19044049f, -0.18082663f, 0.02298078f, 0.00816968f, -0.02637975f, 
    0.02426273f, -0.07340193f, -0.02240105f, -0.05317911f, -0.21595635f, 0.07461656f, -0.00410141f, -0.10238411f, 
    -0.08290949f, 0.01232919f, 0.09982558f, -0.02020692f, 0.03767606f, -0.02859757f, 0.07601222f, -0.00215538f, 
    -0.21215659f, -0.13825400f, 0.15399408f, 0.17801298f, 0.02309740f, -0.02976951f, -0.08517224f, -0.05081560f, 
    0.06654190f, -0.05916195f, 0.08292642f, -0.01915716f, -0.15804672f, -0.04534981f, -0.05079823f, 0.03739291f, 
    -0.00155502f, 0.05709382f, 0.02712628f, -0.01992257f, 0.05473359f, 0.00351591f, -0.00718899f, 0.04047140f, 
    -0.01815250f, 0.23959397f, -0.06590275f, 0.11233312f, 0.04370083f, -0.03025080f, 0.03435031f, 0.08525242f, 
    0.04698771f, 0.12472985f, -0.05579991f, -0.04265293f, 0.19783774f, 0.21756911f, 0.07163930f, 0.05501274f, 
    0.07466150f, 0.07413901f, 0.00424015f, 0.04749138f, 0.00186330f, 0.01238577f, 0.05149866f, 0.04421179f, 
    -0.28907335f, 0.11857709f, -0.08350987f, -0.05774184f, -0.04797871f, 0.04436666f, -0.03129688f, -0.07068260f, 
    0.14577037f, -0.04132488f, 0.07847269f, 0.05497206f, 0.17136335f, -0.03708521f, 0.06334473f, 0.25305662f, 
    -0.02992711f, -0.02486945f, 0.00638585f, 0.01593802f, 0.05483231f, -0.00296405f, 0.04873950f, 0.01849342f, 
    -0.08333438f, 0.04372510f, -0.00917731f, 0.12701784f, -0.09510900f, -0.01271426f, 0.05482554f, 0.10200534f, 
    0.08610611f, 0.03571960f, 0.04685715f, 0.02197205f, -0.39168587f, 0.30588931f, 0.05396042f, -0.04240802f, 
    0.02845512f, -0.06071270f, -0.05372545f, 0.08041990f, -0.01020277f, -0.09139854f, 0.09368605f, 0.09184362f, 
    -0.20610079f, -0.15364695f, -0.15734205f, 0.01186060f, -0.10536123f, 0.07574022f, -0.00445469f, -0.01698202f, 
    0.07508937f, -0.05564031f, -0.11801879f, 0.01391379f, 0.04443090f, -0.07103105f, 0.01262208f, 0.16230395f, 
    -0.05882714f, 0.18778442f, -0.04844733f, 0.02762664f, 0.04355153f, -0.08301383f, -0.02087364f, 0.01771881f, 
    -0.13236515f, 0.12343519f, 0.08895096f, 0.03197996f, -0.00774623f, 0.06774696f, 0.03217088f, -0.01668763f, 
    0.05455140f, -0.08345440f, 0.10587662f, 0.11197296f, 0.10599652f, 0.06445435f, 0.01030550f, 0.08468600f, 
    0.11815545f, -0.04649897f, 0.23598976f, 0.06839915f, 0.13040300f, -0.05193882f, -0.05796779f, 0.00795646f, 
    -0.32663378f, -0.24881119f, 0.01929254f, 0.06035115f, 0.01664045f, -0.03749773f, 0.11914025f, -0.08450936f, 
    0.01742494f, -0.03941874f, -0.05629225f, -0.02932713f, -0.01430834f, -0.00391512f, -0.02706541f, -0.08765995f, 
    0.03344771f, -0.11396062f, -0.02232504f, 0.18747222f, 0.02049507f, -0.06109150f, 0.05620501f, 0.03545770f, 
    -0.00775099f, 0.04379322f, -0.02069952f, -0.04999716f, -0.03761417f, -0.01121090f, 0.03357653f, -0.04111581f, 
    -0.04142623f, -0.05334977f, -0.02901064f, 0.01518358f, 0.04554202f, 0.01230314f, 0.01641457f, -0.02216025f, 
    -0.01159119f, -0.05980898f, -0.04249750f, -0.03867376f, -0.06929585f, 0.03600693f, -0.07165054f, 0.05651794f, 
    0.05313117f, -0.04666940f, 0.04363110f, 0.00495590f, -0.07116343f, -0.05267509f, -0.05000665f, -0.03605121f, 
    -0.02995398f, -0.04640899f, -0.00781807f, 0.03706676f, -0.00397819f, 0.02645078f, -0.04413605f, 0.00780583f, 
    -0.06888819f, 0.06249233f, 0.02376049f, -0.02203339f, -0.03859590f, 0.02882338f, -0.05504654f, -0.07176319f, 
    -0.01026262f, 0.02653462f, 0.02189346f, -0.06921170f, -0.06506597f, -0.02109556f, 0.02402003f, 0.06019053f, 
    -0.03505224f, -0.02671212f, -0.07638011f, -0.00530864f, -0.04638075f, 0.00254422f, -0.03556972f, 0.05059995f, 
    0.03466583f, -0.06775067f, 0.05137818f, 0.04208994f, -0.00123236f, -0.02090759f, -0.03517236f, -0.06966224f, 
    0.02649957f, -0.02026389f, -0.02945589f, 0.02448808f, -0.01497415f, -0.01006833f, -0.03168787f, 0.02620102f, 
    -0.04198105f, 0.00691606f, -0.05958604f, 0.00461342f, -0.00020165f, 0.00290129f, 0.03091582f, 0.01502798f, 
    0.05325225f, -0.05985647f, 0.01501878f, 0.01966137f, -0.03121603f, 0.04881074f, -0.02824745f, 0.04870588f, 
    0.00716371f, -0.00610138f, -0.07366877f, -0.07381634f, -0.00239300f, -0.07136110f, 0.06340164f, -0.00638300f, 
    0.03636397f, 0.04533986f, -0.04785470f, -0.04606327f, 0.04510139f, 0.04018100f, 0.04074631f, -0.06842428f, 
    0.04652927f, -0.00315735f, -0.04815418f, 0.02576708f, 0.04253326f, -0.02371227f, -0.05545803f, -0.06540362f, 
    0.00122722f, 0.01023938f, 0.03931781f, 0.00789811f, 0.00552097f, 0.04380044f, 0.03880298f, -0.02556011f, 
    -0.03536708f, 0.06040777f, 0.05634788f, 0.03605450f, -0.03524448f, -0.06236716f, -0.00403079f, 0.03063081f, 
    -0.03536438f, 0.02938321f, 0.00298753f, 0.03102928f, 0.01896189f, -0.07683622f, -0.02999139f, -0.01297570f, 
    0.01553833f, 0.06398879f, -0.02356409f, -0.00898722f, -0.04068785f, -0.02695918f, 0.05561197f, -0.07020570f, 
    -0.06772283f, -0.05620201f, 0.00700239f, -0.07448789f, -0.05570303f, -0.00500331f, 0.03198009f, -0.07707800f, 
    0.04923039f, -0.02384421f, 0.05752600f, -0.08082015f, 0.01506978f, -0.01909386f, 0.04788423f, -0.02041000f, 
    -0.04734831f, -0.02512977f, -0.05828653f, -0.01856606f, 0.02647834f, -0.02572252f, 0.01494818f, -0.01058543f, 
    0.04298548f, -0.00877497f, -0.06967010f, -0.04648102f, -0.05262393f, 0.04456655f, 0.01915051f, -0.04847249f, 
    -0.02318756f, 0.03777384f, -0.06582537f, 0.03451470f, -0.04662677f, 0.01147399f, -0.06657008f, 0.03307611f, 
    0.02364430f, -0.06136973f, -0.04774489f, 0.01570365f, 0.06592263f, -0.06867452f, -0.05454046f, -0.07477473f, 
    0.04423965f, -0.04358802f, 0.06285005f, -0.01486729f, -0.04885258f, -0.05855811f, 0.06508868f, -0.01545236f, 
    0.04018157f, -0.05596041f, -0.02747762f, -0.05139130f, -0.00328384f, -0.02154508f, -0.03416283f, -0.01944218f, 
    -0.00502903f, 0.04321002f, 0.04719188f, -0.05488414f, 0.03937921f, -0.02569332f, -0.07577883f, 0.02884539f, 
    -0.05254326f, 0.06488700f, 0.02040366f, 0.02639748f, -0.04622564f, 0.05368847f, 0.04486597f, -0.03440585f, 
    0.04857611f, 0.04126895f, -0.07808729f, -0.06802408f, -0.06613503f, -0.00526366f, 0.01796771f, -0.04484637f, 
    0.01555345f, -0.05704667f, 0.04046825f, 0.01821058f, 0.01747674f, -0.03506357f, 0.03401816f, -0.07223803f, 
    -0.04588559f, -0.06973544f, -0.03949402f, -0.03506995f, -0.06345608f, 0.01509531f, -0.04950947f, -0.05569777f, 
    -0.01475377f, -0.01769317f, -0.03660204f, -0.07344543f, 0.03520684f, 0.04050212f, -0.00021677f, 0.00979303f, 
    -0.00518851f, 0.07066108f, -0.04311704f, 0.00595616f, 0.04128053f, -0.01438519f, -0.06652424f, 0.06760328f, 
    -0.01413131f, 0.06044735f, -0.01263066f, 0.01592224f, -0.06949595f, -0.06318996f, -0.03328244f, 0.05349310f, 
    0.02191829f, -0.03060084f, -0.04390082f, -0.06990636f, 0.04591814f, 0.04791278f, -0.00931720f, -0.03511423f, 
    -0.07643678f, 0.03032334f, 0.02321002f, -0.02449358f, 0.05081230f, -0.02047145f, -0.04980370f, -0.03094114f, 
    0.04595511f, -0.01547787f, 0.06697450f, -0.07208934f, -0.03006952f, -0.02664223f, -0.05257387f, -0.00013436f, 
    -0.06714498f, 0.02538422f, -0.04708356f, 0.05219581f, -0.01912093f, -0.00794757f, 0.02096896f, 0.04120222f, 
    0.05425105f, 0.01699563f, -0.02595133f, 0.01817155f, -0.02202840f, -0.01330943f, -0.07963814f, 0.04299658f, 
    -0.06706101f, -0.02667161f, -0.05121092f, 0.02546533f, -0.02948333f, -0.03984112f, 0.04335590f, -0.06798352f, 
    -0.02727699f, 0.01366272f, 0.05538576f, 0.02839505f, -0.06182123f, -0.03129971f, -0.03177217f, -0.06073130f, 
    -0.00749545f, -0.05349586f, -0.05151846f, -0.07105549f, -0.00378781f, -0.03329841f, 0.04867049f, 0.00727049f, 
    -0.01299469f, 0.00101158f, -0.00341276f, 0.05206446f, -0.05777065f, 0.00871827f, 0.04878012f, 0.06340627f, 
    0.00825480f, -0.02570983f, -0.05860889f, 0.03543083f, -0.07927813f, 0.05332683f, -0.01668513f, 0.02662498f, 
    0.01263551f, 0.02859467f, 0.04332527f, -0.02323687f, 0.03184512f, 0.04002203f, 0.05953075f, -0.01541299f, 
    -0.06789104f, 0.04022845f, -0.05996122f, -0.06750487f, -0.06123192f, -0.02437210f, 0.01976577f, -0.01625427f, 
    0.03934360f, 0.02297951f, 0.04563161f, 0.02263499f, -0.02410252f, 0.05892074f, 0.06844277f, 0.05248693f, 
    -0.05771566f, 0.02608838f, -0.02570402f, 0.07272434f, 0.00960374f, 0.05931542f, -0.04989244f, -0.04549854f, 
    0.07910040f, 0.01713207f, 0.00995724f, -0.02334295f, 0.00096667f, -0.04798314f, -0.02975314f, -0.06540897f, 
    -0.03607915f, -0.07145046f, -0.06822616f, -0.02572181f, -0.05710892f, -0.01222250f, 0.01401244f, -0.07079283f, 
    0.04490888f, 0.03829315f, 0.02223809f, 0.05169236f, -0.10956044f, 0.07328330f, -0.02979489f, 0.03580617f, 
    0.05762520f, 0.04182193f, 0.01786140f, 0.00850327f, -0.03366169f, -0.03956898f, -0.05592457f, -0.07116654f, 
    -0.02300094f, -0.00408625f, -0.07978118f, 0.01063652f, -0.08075211f, 0.03120179f, -0.00510602f, 0.06351133f, 
    0.01092051f, 0.01466090f, -0.08235347f, 0.02020626f, -0.05485966f, 0.04912210f, 0.02085115f, -0.02305840f, 
    -0.00080813f, -0.05191673f, 0.04396227f, 0.07291774f, 0.07294897f, -0.06812739f, -0.04716506f, -0.11076744f, 
    -0.04286566f, -0.08814516f, -0.06503620f, 0.04727441f, 0.06154564f, 0.03945555f, -0.00935758f, -0.07039648f, 
    -0.08156348f, -0.00477070f, -0.07334680f, 0.00089419f, 0.03374726f, -0.07484651f, 0.00105408f, -0.04295775f, 
    -0.00949065f, 0.02766726f, -0.06731156f, -0.01669488f, -0.00175888f, -0.07557754f, 0.01750327f, 0.03296791f, 
    0.04470746f, -0.03388838f, 0.01594047f, -0.04425222f, 0.04688514f, -0.03638859f, -0.05128322f, -0.04394153f, 
    -0.02534073f, 0.08238002f, -0.01982479f, -0.01882404f, 0.02918550f, 0.00320526f, -0.06611195f, -0.03125915f, 
    -0.03424473f, -0.05120634f, -0.04420735f, 0.05103378f, 0.01904198f, 0.03730193f, 0.00557783f, -0.02985816f, 
    0.03434194f, 0.03650867f, 0.03330861f, 0.05379409f, -0.02805213f, 0.02945672f, 0.05178731f, 0.06494174f, 
    0.02210731f, -0.01233816f, -0.04539244f, 0.02990966f, -0.04954950f, -0.08492841f, -0.00634424f, -0.08348879f, 
    -0.09461857f, -0.06676014f, -0.03684330f, -0.01081790f, -0.07441790f, -0.00224220f, -0.01930520f, 0.02926555f, 
    -0.03979842f, -0.05044575f, -0.07855140f, -0.04162328f, -0.05166180f, -0.07294978f, 0.02116326f, -0.06785015f, 
    -0.01717288f, 0.03579743f, -0.04431042f, -0.06829478f, 0.03315644f, -0.08585005f, 0.05057632f, -0.04061282f, 
    -0.05644812f, -0.07243846f, 0.04312190f, 0.04453984f, 0.04302322f, -0.04140794f, -0.04666749f, -0.05746593f, 
    0.04078228f, -0.04032759f, -0.05689165f, -0.02816043f, -0.09202790f, -0.03369190f, 0.00677526f, 0.00352180f, 
    -0.10590553f, -0.00626783f, 0.03863606f, -0.01642625f, -0.05786932f, 0.06873728f, -0.05527145f, 0.01685573f, 
    -0.00549947f, -0.02424427f, -0.09129016f, -0.07775834f, 0.05505247f, -0.00824864f, -0.01964368f, 0.04503207f, 
    -0.06932402f, -0.01163808f, -0.00073686f, -0.02532065f, 0.03366723f, 0.06479924f, -0.07135776f, -0.04065506f, 
    -0.26734242f, -0.10161425f, 0.09275987f, 0.22170405f, 0.08352092f, -0.13621193f, -0.07533036f, -0.10203040f, 
    -0.09260655f, -0.03767359f, 0.08813305f, -0.07411265f, -0.20356452f, 0.12734807f, -0.06875036f, -0.15026714f, 
    -0.07792113f, -0.01876236f, -0.08278622f, 0.03877348f, -0.00685528f, 0.06356783f, -0.02177771f, 0.10251987f, 
    -0.29808056f, -0.00863340f, 0.17214969f, 0.05706732f, -0.08660926f, 0.03082328f, -0.02396600f, 0.03912531f, 
    0.06558218f, -0.03892008f, 0.07021792f, 0.11127029f, -0.08784517f, -0.13417579f, -0.00643042f, 0.20265007f, 
    0.05615833f, 0.05987185f, 0.02273881f, -0.13102345f, 0.18195833f, -0.11985114f, 0.08970018f, -0.05586432f, 
    -0.27561620f, 0.16647469f, 0.21617515f, 0.13954106f, -0.03713953f, -0.06286831f, 0.06124801f, 0.12498826f, 
    0.13595136f, 0.07707787f, 0.02878900f, -0.01664664f, 0.20151709f, -0.13287517f, 0.09798553f, -0.01343322f, 
    0.32495758f, 0.12732033f, 0.13332394f, 0.07054241f, 0.07896083f, -0.05790451f, 0.17753293f, 0.18967021f, 
    -0.11711194f, 0.05182606f, 0.05864434f, -0.01715977f, 0.04870509f, 0.08347573f, -0.01800945f, -0.13263756f, 
    0.07682709f, -0.05001928f, 0.09483207f, 0.11604440f, 0.06063330f, -0.02766362f, 0.10400987f, 0.34993228f, 
    -0.04446026f, 0.08776425f, 0.10276588f, -0.04795980f, 0.08190753f, 0.08118334f, -0.02296403f, -0.00104208f, 
    -0.24456488f, 0.00008999f, 0.06117011f, 0.05538563f, -0.01373282f, 0.04013040f, -0.01469815f, 0.09325403f, 
    -0.01521398f, 0.07906047f, 0.09243732f, 0.11429228f, 0.13962743f, -0.10445741f, 0.13275170f, -0.07433306f, 
    -0.15856372f, -0.04792664f, -0.12601610f, -0.13736488f, -0.01109972f, 0.03868524f, 0.01145359f, 0.11257725f, 
    -0.29372439f, -0.14979289f, -0.14832869f, -0.16711874f, -0.07175136f, 0.05578494f, 0.01617546f, -0.11848403f, 
    0.02025040f, -0.23900215f, 0.10688186f, -0.01263892f, -0.15328522f, -0.12515631f, -0.07902063f, -0.02683177f, 
    -0.03691788f, 0.22056854f, 0.08460388f, -0.04931393f, 0.04662852f, -0.08314557f, -0.02766089f, -0.08697043f, 
    -0.41130808f, 0.05075192f, -0.05951977f, 0.16818443f, 0.09640647f, 0.05971025f, 0.05169091f, -0.07549691f, 
    0.02964446f, 0.00681431f, 0.01402859f, 0.02956742f, 0.25869820f, -0.11879951f, 0.00399255f, 0.02280132f, 
    0.24281275f, 0.03667849f, 0.21298309f, 0.20673622f, 0.14114407f, 0.01002176f, -0.01041299f, 0.10104861f, 
    -0.30965057f, -0.06487357f, 0.14080073f, 0.07638378f, -0.10045797f, 0.06356696f, 0.03615601f, -0.08736597f, 
    -0.06800679f, -0.07606734f, -0.01133691f, -0.01215366f, -0.33047798f, 0.08449530f, -0.11337778f, -0.04138437f, 
    0.07150414f, 0.14591764f, -0.08861803f, 0.18425453f, -0.06820554f, 0.10525538f, -0.04976497f, 0.03666575f, 
    -0.27842569f, -0.31855354f, -0.21799800f, -0.12895305f, 0.34218851f, 0.00179377f, -0.10139050f, 0.03868831f, 
    0.11645002f, -0.00607993f, 0.03970696f, 0.07364406f, 0.04146352f, 0.07772456f, 0.02376868f, -0.08128872f, 
    0.18081458f, -0.12877968f, -0.02477982f, 0.09170502f, -0.06610006f, 0.01772257f, 0.10236496f, 0.12682323f, 
    -0.27045846f, 0.05570351f, -0.10064008f, -0.16688986f, 0.13566625f, 0.01495073f, -0.07158638f, 0.01631829f, 
    0.06775206f, -0.05239455f, 0.02381321f, -0.01401660f, 0.13007100f, -0.04687335f, -0.04396684f, -0.17819025f, 
    0.04299806f, -0.09200165f, -0.00125513f, 0.04241538f, 0.07653671f, 0.01947304f, 0.07627629f, -0.11414190f, 
    -0.08731205f, -0.00975893f, -0.00985212f, 0.25812626f, -0.00677795f, 0.00161022f, -0.01732577f, -0.05510255f, 
    -0.05467565f, -0.00583798f, 0.06653821f, -0.03285737f, 0.23239218f, 0.05693271f, -0.06674775f, -0.00483215f, 
    0.03115248f, 0.05031029f, -0.06787500f, -0.12393224f, 0.06012041f, 0.04687763f, 0.07250298f, 0.10817698f, 
    0.19324046f, -0.10345005f, 0.12454315f, 0.34283832f, -0.00269793f, -0.09615016f, 0.00688703f, 0.01993744f, 
    0.03209236f, -0.02261890f, -0.05089175f, -0.01601104f, 0.00043749f, 0.16615255f, 0.14022766f, 0.08470203f, 
    0.10386358f, 0.05637455f, 0.23527929f, -0.05125685f, 0.13987087f, 0.01461902f, -0.05618488f, 0.09792240f, 
    0.05944224f, 0.11810129f, 0.10128259f, 0.09868485f, 0.00108097f, -0.14152694f, 0.00223985f, -0.04896047f, 
    -0.01840619f, 0.13497151f, -0.01184193f, 0.10036451f, 0.17883535f, -0.28159142f, -0.02381188f, 0.11076891f, 
    -0.11276659f, -0.00514288f, 0.09886501f, 0.07595365f, 0.00197622f, 0.08439428f, 0.01198593f, -0.04833689f, 
    0.05932225f, -0.02834394f, 0.10202801f, -0.13219552f, 0.08516084f, -0.05484495f, -0.01841399f, -0.00613549f, 
    0.07478724f, -0.01021670f, 0.07911479f, -0.01082270f, -0.18144280f, -0.10793080f, -0.05506196f, -0.15058552f, 
    0.14836659f, -0.09426131f, 0.16915438f, -0.19453633f, 0.14270380f, 0.13353269f, 0.09106767f, 0.02271896f, 
    0.06946810f, -0.09065045f, 0.05015086f, 0.25423744f, 0.05467966f, -0.13274089f, 0.04646660f, 0.04743626f, 
    0.02614979f, -0.04551904f, 0.04493260f, -0.05340625f, -0.34457952f, -0.10719933f, 0.02126930f, -0.07405209f, 
    -0.05671563f, 0.15393038f, 0.00557304f, 0.18820299f, 0.02869287f, 0.01335325f, 0.09947252f, 0.09521662f, 
    0.17595084f, 0.33729637f, 0.08507174f, 0.01536392f, 0.00521718f, 0.08860241f, -0.05104507f, 0.12492490f, 
    0.00151617f, -0.07031829f, 0.05088660f, 0.00439577f, -0.07713441f, 0.16632131f, -0.10424739f, -0.13851205f, 
    0.03209724f, 0.05541022f, -0.04022034f, 0.05622057f, -0.04858699f, 0.10289829f, -0.08304720f, -0.08008148f, 
    0.39908174f, 0.08542362f, 0.25332963f, 0.35827780f, -0.22380088f, 0.11176753f, 0.13985483f, 0.18143991f, 
    0.03189669f, 0.05141653f, -0.01511474f, -0.00925440f, 0.15809655f, 0.09092573f, -0.25534800f, 0.02461888f, 
    0.04679596f, 0.17487629f, 0.01931169f, 0.07275382f, -0.00424513f, 0.00498918f, -0.03179466f, 0.05399985f, 
    0.06347269f, 0.21524546f, 0.14496359f, 0.27612990f, -0.08696784f, 0.08589154f, 0.11551724f, 0.11015528f, 
    0.05304251f, -0.03807189f, 0.03837938f, -0.03239469f, -0.05521813f, 0.22220367f, 0.03165754f, 0.25175455f, 
    -0.09142292f, 0.05256432f, -0.08549960f, -0.01928151f, -0.04451082f, -0.03022641f, 0.01631775f, -0.05587278f, 
    0.07281294f, -0.13653241f, 0.05773005f, -0.29857135f, -0.16945525f, -0.02231503f, 0.16132857f, 0.04472119f, 
    -0.10244078f, 0.01554300f, 0.18432248f, -0.05158591f, -0.07266133f, -0.01431235f, 0.06552284f, -0.01193343f, 
    0.05288006f, -0.13312230f, 0.04840845f, 0.26060024f, 0.10075239f, 0.07935470f, -0.10935406f, 0.05233896f, 
    -0.07524331f, 0.06246938f, -0.08357956f, -0.06625745f, 0.00445356f, 0.03541952f, 0.00827455f, -0.16960040f, 
    0.11755963f, 0.01981637f, -0.00654528f, 0.00591961f, -0.05569243f, -0.24870582f, 0.12711084f, -0.16628703f, 
    -0.15356775f, -0.06443119f, 0.07013774f, -0.05954152f, 0.01217224f, 0.03710174f, -0.04546799f, 0.04112821f, 
    -0.10344421f, -0.00907218f, 0.05054894f, 0.03866203f, -0.06501275f, -0.05276879f, -0.08620471f, 0.08380605f, 
    0.00629899f, 0.02359404f, 0.04759353f, -0.09337623f, 0.11459338f, 0.24831039f, 0.05583295f, -0.11860491f, 
    -0.11217111f, 0.09314445f, 0.03889715f, 0.01679828f, 0.04383468f, -0.02053130f, 0.02379419f, 0.12960991f, 
    0.17356239f, -0.13206485f, 0.05037393f, -0.11676792f, -0.01049344f, -0.10792442f, -0.01727433f, -0.12295803f, 
    -0.00337190f, -0.06715087f, -0.17851207f, 0.05252417f, 0.19872504f, -0.18373367f, 0.04658183f, -0.18915543f, 
    -0.16101500f, 0.02079752f, 0.06201674f, -0.00461247f, -0.08344108f, -0.09748074f, -0.02481131f, -0.11807326f, 
    0.13342856f, 0.09771918f, -0.00905784f, 0.13331874f, -0.01533395f, 0.11465723f, -0.04416188f, 0.06844479f, 
    -0.06925103f, -0.08167993f, 0.07793467f, 0.02594495f, 0.26574340f, 0.03035290f, -0.04756109f, -0.14117570f, 
    0.09292704f, -0.11159908f, -0.04532402f, 0.03419482f, 0.13618380f, -0.01065089f, -0.07170335f, 0.02699929f, 
    -0.45166966f, -0.38664356f, -0.04799079f, 0.20924596f, -0.12752706f, -0.02949504f, 0.03130743f, -0.06328738f, 
    0.01961070f, 0.00025565f, -0.03863392f, -0.10290988f, 0.29214564f, -0.03532760f, 0.01547840f, 0.21652789f, 
    -0.05261128f, 0.01977870f, -0.09082083f, 0.07547693f, 0.01255333f, -0.07674829f, -0.04825864f, 0.07853971f, 
    -0.04794804f, -0.01023415f, -0.27722397f, -0.13579719f, 0.23230951f, -0.11026625f, -0.02228822f, 0.04956244f, 
    -0.02487459f, 0.02096299f, 0.02918246f, 0.03515457f, 0.03861003f, 0.10083816f, -0.20991400f, -0.03526343f, 
    0.10096265f, -0.10196306f, -0.02090768f, 0.10553161f, -0.06624950f, 0.10670815f, -0.04562034f, 0.06747905f, 
    -0.09985376f, 0.12793817f, -0.11545741f, -0.31418064f, 0.16913266f, -0.01518804f, 0.08852834f, -0.03868509f, 
    0.08719092f, -0.05216705f, -0.06062006f, 0.06195051f, 0.10737547f, -0.07324211f, 0.10916517f, -0.32111382f, 
    -0.04378473f, -0.20247933f, -0.03056159f, 0.04309756f, -0.00324610f, -0.05744560f, -0.03015193f, -0.01265848f, 
    0.00055349f, -0.00482747f, -0.15078056f, 0.16668884f, 0.06242321f, 0.07421187f, -0.03568468f, -0.00667091f, 
    -0.02847457f, -0.00963253f, -0.01498062f, -0.03082609f, 0.12224922f, 0.02779711f, -0.14261012f, -0.10287974f, 
    0.01670360f, 0.02661672f, 0.03332380f, 0.00047229f, 0.10405949f, 0.00478714f, 0.11054560f, 0.04034398f, 
    0.25661477f, -0.25240245f, 0.07322760f, 0.27585402f, -0.01707548f, -0.06307206f, -0.02646507f, 0.06971065f, 
    0.13133521f, -0.03718300f, 0.06443097f, -0.08017774f, -0.25673947f, 0.22523730f, -0.14138804f, -0.10650393f, 
    0.07071217f, 0.07705822f, 0.10448406f, 0.06779749f, 0.10365409f, 0.04525745f, 0.03603961f, 0.10753626f, 
    0.07658613f, 0.01969496f, 0.04573121f, 0.13511078f, 0.00482547f, -0.04934727f, 0.11085809f, -0.16134079f, 
    0.04433875f, 0.12653817f, 0.01634548f, 0.04925662f, 0.07843886f, -0.31645468f, -0.01327964f, 0.18488428f, 
    -0.02975471f, 0.05073536f, 0.07982323f, 0.04981529f, 0.06995395f, 0.06753668f, 0.11398327f, -0.05404687f, 
    0.11339258f, 0.12886794f, -0.01693133f, -0.00351959f, 0.17864668f, -0.09182726f, 0.06589101f, -0.15589699f, 
    0.06743567f, 0.03963333f, 0.10414515f, -0.06058538f, -0.10345370f, -0.06056629f, 0.09943139f, -0.09634876f, 
    0.28420821f, -0.10779544f, 0.08675578f, -0.11602946f, 0.15668927f, 0.00011874f, 0.14871249f, 0.15324421f, 
    0.07885501f, -0.04583756f, 0.00776831f, 0.10714084f, 0.05417741f, -0.14700136f, -0.05705426f, -0.04810093f, 
    -0.00491471f, -0.11534521f, 0.09712743f, -0.09014636f, -0.24044155f, -0.20921831f, -0.01086725f, -0.14227466f, 
    0.04843382f, 0.03785983f, -0.03105410f, 0.06136360f, 0.01830940f, -0.06258719f, 0.11337485f, 0.03786095f, 
    0.11225948f, 0.14838500f, 0.15992504f, -0.18173240f, -0.01036225f, 0.12308083f, -0.12375173f, 0.05273398f, 
    0.11333972f, -0.05905684f, 0.08390442f, 0.04645340f, -0.06061879f, 0.07050371f, 0.01756610f, -0.05686183f, 
    0.04462883f, 0.08783549f, 0.02904224f, 0.11840706f, -0.08276752f, 0.04815279f, -0.02520686f, -0.05187164f, 
    -0.03429384f, -0.01526820f, -0.02865485f, -0.05498486f, -0.01716120f, 0.00521714f, -0.01333876f, 0.00049867f, 
    -0.05232405f, 0.05211130f, -0.00121853f, 0.01353694f, -0.03123042f, -0.00422118f, -0.04161207f, 0.00860085f, 
    -0.04611972f, -0.01994590f, -0.04476209f, -0.06018798f, -0.08297209f, 0.01486368f, -0.01652981f, -0.04133444f, 
    -0.06504217f, -0.06983530f, -0.00910783f, 0.02247855f, 0.03469364f, -0.04459180f, 0.05753480f, 0.05504022f, 
    -0.05756541f, 0.05837972f, -0.00352733f, -0.04820153f, 0.02682885f, 0.05714511f, -0.04826511f, 0.01788239f, 
    -0.04852505f, -0.04476807f, 0.04393156f, 0.00860421f, 0.01353336f, 0.05503586f, 0.06151359f, -0.04801113f, 
    0.01500758f, -0.04881072f, -0.04609842f, -0.06381749f, -0.01272289f, -0.00415922f, -0.05185141f, 0.00862345f, 
    -0.02790971f, 0.03290666f, -0.00321461f, 0.01671142f, -0.00702833f, -0.01194962f, -0.06010442f, 0.03784413f, 
    0.02445121f, -0.06788583f, 0.01936650f, -0.06069662f, 0.05178313f, 0.01163177f, -0.00135574f, -0.04113297f, 
    -0.04083083f, 0.03936408f, -0.07940378f, 0.05149336f, 0.03464121f, -0.05223064f, 0.05022317f, -0.07142163f, 
    0.01643940f, -0.04096266f, -0.07455382f, 0.00319144f, -0.00721102f, 0.08192264f, -0.06518257f, 0.05471118f, 
    -0.03378504f, -0.04163642f, 0.02877192f, -0.03931255f, -0.04649430f, -0.04432194f, 0.08083010f, -0.02031791f, 
    0.07635496f, 0.01868947f, 0.03199947f, 0.00895918f, -0.00628308f, -0.02184133f, -0.03784807f, -0.04167722f, 
    -0.04250193f, -0.07378870f, -0.03706156f, -0.03800276f, 0.04468829f, -0.01919885f, -0.03548849f, 0.01166797f, 
    0.00046476f, -0.07223014f, -0.04713697f, 0.03885895f, 0.03489745f, -0.01819734f, 0.01872251f, 0.05748918f, 
    0.01538439f, -0.07091340f, -0.07930583f, -0.01898717f, -0.05858016f, 0.02050478f, -0.07180955f, -0.00616422f, 
    -0.07678390f, 0.05650927f, -0.03090590f, -0.02702978f, 0.07896763f, 0.05242183f, 0.04200489f, 0.04774361f, 
    -0.01340291f, -0.01715877f, 0.01204981f, 0.03519232f, 0.04440833f, -0.06118402f, -0.05167481f, -0.03478278f, 
    0.04116814f, 0.01495584f, -0.00127361f, 0.00207155f, 0.06186756f, -0.03865990f, 0.03189208f, -0.03904689f, 
    -0.03109984f, -0.01140121f, -0.05153263f, -0.04149873f, -0.01250906f, 0.01804424f, 0.02483180f, -0.04309255f, 
    -0.03598739f, -0.00277059f, 0.05139057f, 0.00437273f, -0.07007235f, -0.00785178f, 0.01844933f, 0.02707013f, 
    0.01957377f, 0.04435676f, -0.01643032f, -0.07711107f, -0.05379833f, -0.02646381f, 0.05554169f, -0.00435038f, 
    0.01467600f, -0.01372294f, 0.01223178f, -0.03755973f, 0.01823066f, -0.00281683f, -0.06335413f, 0.04335177f, 
    -0.00503791f, -0.06639848f, -0.00536010f, -0.05783848f, 0.04553570f, -0.03865666f, 0.03746833f, -0.06782328f, 
    0.06632417f, 0.01822255f, -0.24801646f, 0.02413007f, 0.09847195f, 0.04221100f, -0.04233487f, 0.04039718f, 
    0.02017025f, 0.07184022f, 0.00298954f, -0.01453619f, 0.12787785f, -0.29716045f, -0.09802548f, -0.05691437f, 
    0.05388122f, -0.08815932f, 0.12505426f, 0.10458916f, -0.09303091f, -0.04152092f, -0.09755830f, -0.11661804f, 
    -0.05944189f, -0.04909820f, -0.18206124f, -0.21567558f, 0.10041325f, -0.08569238f, 0.00346396f, -0.06094484f, 
    -0.01373917f, -0.10842357f, -0.09693956f, -0.09573480f, -0.12501313f, 0.04813592f, 0.15124394f, -0.20081438f, 
    -0.03745518f, 0.07424231f, -0.12495214f, 0.00973272f, -0.05982627f, 0.00635322f, -0.09191611f, 0.04138738f, 
    0.04886012f, 0.06695451f, -0.31249669f, 0.08734105f, -0.05935721f, 0.05924039f, 0.08104306f, 0.02808249f, 
    -0.04406751f, -0.04721608f, 0.04806039f, -0.05068221f, 0.28310022f, 0.21783866f, 0.16414544f, -0.07184964f, 
    0.00683052f, 0.00447254f, -0.03648239f, -0.03564434f, 0.07334039f, 0.10914298f, -0.07468336f, -0.16115214f, 
    0.01187029f, -0.17848401f, 0.10430730f, 0.31459841f, -0.05097651f, -0.12288508f, -0.06722543f, 0.03052707f, 
    -0.01037142f, 0.09483117f, 0.00481831f, -0.00839952f, 0.01982270f, 0.14942582f, -0.04632365f, -0.08801850f, 
    0.17118083f, 0.06178797f, -0.02412673f, -0.08759329f, 0.10900545f, 0.21323763f, 0.06971303f, -0.00563544f, 
    0.23229520f, 0.08916332f, 0.30313694f, 0.07986462f, -0.02958475f, 0.12911133f, 0.12828986f, -0.03077145f, 
    0.05905877f, 0.07886910f, -0.07295595f, -0.05058773f, -0.31631100f, 0.04034786f, -0.12360767f, 0.34266785f, 
    0.07755866f, -0.05498162f, 0.06863140f, 0.22407179f, -0.00123573f, -0.05148333f, 0.08297848f, -0.08820015f, 
    -0.14007421f, -0.05750125f, -0.04158632f, 0.16549182f, 0.04928724f, 0.10494202f, 0.00929714f, -0.03665831f, 
    -0.10040436f, 0.09540150f, -0.14590742f, -0.07435566f, -0.04944623f, -0.13807689f, 0.03041006f, 0.11209286f, 
    0.01146550f, -0.09567300f, -0.01654636f, 0.06235868f, 0.27457330f, 0.10104256f, 0.14752702f, 0.03882231f, 
    0.19495775f, 0.04563430f, 0.21977434f, 0.27594227f, 0.05253870f, -0.10429443f, -0.03843567f, 0.05971696f, 
    0.04547806f, 0.07420516f, 0.18364617f, 0.02017078f, 0.02175599f, 0.11340792f, 0.00084121f, 0.02744388f, 
    0.02068930f, 0.08433036f, -0.04742900f, -0.10651258f, -0.16476569f, -0.02378923f, 0.12971970f, 0.04021759f, 
    0.10380471f, -0.05569417f, -0.02050926f, -0.05138395f, 0.16113386f, 0.08596610f, -0.07701324f, 0.02480084f, 
    0.02735738f, -0.04841967f, -0.11505254f, -0.10879664f, 0.42802855f, 0.17730407f, 0.01295671f, -0.05931226f, 
    -0.06447914f, 0.08742263f, 0.14178266f, 0.02832844f, 0.03401194f, -0.04638473f, 0.15555052f, -0.03872613f, 
    -0.08795376f, -0.07082049f, -0.01618625f, 0.01095329f, -0.03862485f, 0.06077940f, 0.06435607f, 0.02848732f, 
    -0.01820377f, -0.08270781f, -0.06647295f, -0.05143594f, 0.04585818f, -0.00395193f, 0.02348409f, -0.00091419f, 
    -0.05199914f, 0.00092349f, -0.02328177f, -0.01356363f, 0.00853684f, 0.04684378f, -0.00046823f, 0.03204732f, 
    0.01030886f, -0.05347663f, 0.08906285f, 0.00006906f, 0.05220219f, -0.07125308f, -0.01247808f, -0.05597871f, 
    -0.01568561f, 0.04659596f, -0.01617564f, -0.07911983f, -0.02938710f, -0.01028162f, 0.04421970f, -0.08074924f, 
    0.01345082f, 0.00642999f, 0.04470025f, -0.02364560f, -0.05285475f, 0.02623899f, -0.04521225f, -0.05786656f, 
    0.01793111f, -0.09898674f, -0.08570538f, 0.01864956f, 0.03601434f, -0.07349842f, -0.00535488f, 0.01952121f, 
    -0.00806250f, 0.02021607f, -0.07357483f, -0.05741223f, 0.00097483f, -0.07368232f, -0.01424060f, -0.06387156f, 
    -0.04875094f, 0.01775467f, 0.02310796f, -0.02229822f, -0.05936310f, -0.08693112f, -0.01797703f, -0.07815774f, 
    0.03373850f, -0.09153435f, 0.03934290f, 0.00033270f, 0.00229454f, 0.04462291f, 0.03637253f, -0.00110406f, 
    -0.02412461f, -0.02431460f, -0.04628775f, -0.09040309f, -0.05179678f, 0.00405232f, -0.04653912f, -0.02820427f, 
    0.01353576f, -0.08719279f, 0.03217968f, -0.06880346f, -0.00908715f, 0.01872992f, -0.09194560f, -0.05155603f, 
    0.00002296f, -0.02946465f, 0.03013260f, -0.05734149f, -0.00424243f, -0.09209586f, -0.03724487f, -0.09945101f, 
    -0.07693842f, 0.03250757f, -0.05175371f, -0.03513795f, -0.04716684f, 0.02073061f, 0.03009944f, -0.05951729f, 
    -0.07161440f, -0.07667810f, -0.05808250f, -0.00740165f, 0.03274406f, 0.01767132f, 0.01517426f, -0.04821092f, 
    -0.04882297f, 0.00339292f, -0.01164573f, -0.04717349f, 0.02033835f, -0.00318143f, -0.03449042f, -0.06619890f, 
    -0.06293478f, -0.02065979f, 0.02992059f, -0.03679282f, -0.00710452f, -0.10026669f, -0.00245452f, -0.01213249f, 
    0.02025373f, -0.04261822f, 0.02276208f, -0.02117936f, -0.04979773f, -0.02980946f, -0.00057142f, -0.06459437f, 
    -0.08188209f, -0.04309246f, 0.04005279f, -0.07798478f, -0.08737907f, -0.05323795f, 0.04573004f, -0.00719068f, 
    -0.07699630f, -0.04570250f, 0.01751315f, -0.06196189f, -0.06978019f, -0.08836051f, -0.00795883f, 0.01482996f, 
    -0.00938061f, -0.07652476f, 0.02728141f, -0.04708605f, -0.03042843f, -0.01227218f, 0.03079313f, -0.00696435f, 
    0.01443347f, -0.04515978f, 0.04105708f, -0.02660330f, -0.03514950f, -0.01642278f, 0.04539274f, -0.08337431f, 
    0.02038081f, 0.02253847f, 0.03800489f, -0.03374764f, -0.01140151f, 0.00240441f, 0.05639005f, 0.04027700f, 
    -0.01728794f, -0.01488252f, 0.00913091f, -0.09036524f, -0.06667180f, 0.03495890f, 0.02262117f, 0.01618770f, 
    -0.16811116f, 0.06288002f, -0.01307716f, -0.21234864f, -0.15603682f, 0.02257339f, -0.02670522f, 0.06338994f, 
    -0.02449729f, -0.01865141f, 0.05117219f, 0.10963202f, -0.14230715f, 0.13931733f, 0.03846653f, -0.13547947f, 
    0.00128407f, 0.12674256f, 0.04796368f, 0.15809441f, -0.06221336f, -0.00579030f, 0.06372460f, -0.03747055f, 
    -0.06385984f, 0.02573192f, 0.22812474f, -0.21096145f, -0.05493455f, 0.02565651f, -0.06671251f, 0.01432963f, 
    0.01888118f, -0.00123656f, 0.11503558f, -0.01223223f, -0.09075821f, 0.13087283f, -0.16323943f, -0.10734437f, 
    0.02464162f, 0.05485456f, 0.04218999f, -0.06462193f, 0.03582632f, 0.06772567f, -0.01825459f, 0.05666112f, 
    0.03641200f, -0.10669412f, -0.03420650f, 0.23039052f, 0.03010551f, -0.17710944f, -0.05487047f, 0.04935608f, 
    -0.03230748f, 0.00857864f, 0.05417291f, -0.13591616f, 0.26737246f, 0.17870000f, 0.01931890f, 0.13498256f, 
    0.06975174f, 0.11312433f, 0.03579494f, -0.09202022f, 0.01519094f, -0.03010286f, -0.09226011f, -0.12185527f, 
    -0.24126473f, -0.05624440f, 0.00240238f, 0.01275194f, -0.05545805f, 0.08057600f, 0.16791683f, -0.02704141f, 
    -0.00499367f, 0.05821582f, 0.08056898f, -0.06410746f, 0.04141876f, -0.02600014f, 0.06100737f, 0.29009241f, 
    -0.01244903f, -0.02200387f, -0.04284433f, 0.00702273f, -0.05987053f, -0.11548265f, -0.04778086f, 0.00481946f, 
    -0.11730774f, 0.06538691f, 0.09669567f, 0.11362292f, -0.02827300f, -0.00625381f, -0.10772715f, 0.01972886f, 
    -0.07496697f, 0.03684586f, 0.06148675f, 0.04479175f, -0.01381399f, 0.02457329f, 0.05916778f, 0.09566826f, 
    0.04767160f, -0.00436699f, 0.14813256f, 0.01869334f, 0.03509802f, 0.03693312f, 0.11450056f, 0.05440180f, 
    -0.39885461f, -0.12569965f, -0.03754565f, 0.15806329f, 0.06662147f, 0.04626070f, 0.04553430f, 0.09817656f, 
    0.08344468f, -0.06113689f, -0.12320255f, -0.00490495f, -0.23315677f, -0.12354086f, 0.06755221f, 0.14090036f, 
    -0.08359453f, 0.28937948f, 0.04559944f, -0.01034461f, -0.00495580f, -0.05915638f, 0.04082935f, 0.02105092f, 
    -0.19276804f, 0.01780912f, 0.00754029f, 0.05211615f, 0.09325206f, 0.04956356f, 0.13171190f, 0.06113079f, 
    -0.00328287f, -0.03046996f, 0.09097679f, 0.09797430f, 0.29732874f, -0.05640742f, -0.09159224f, 0.16976707f, 
    0.08573543f, 0.01848074f, 0.15419243f, 0.01040464f, 0.01526523f, -0.00169662f, -0.06165477f, -0.02459364f, 
    -0.11714486f, -0.00973923f, 0.17758714f, 0.00932517f, -0.09958903f, 0.10749716f, 0.00909610f, 0.15490848f, 
    0.09353203f, -0.06986802f, -0.13990921f, 0.04084875f, -0.18571898f, 0.13121948f, 0.03530149f, 0.00344795f, 
    0.02849131f, 0.00582305f, -0.05725755f, 0.02903765f, -0.07427896f, -0.02697943f, 0.04447656f, -0.03183871f, 
    0.05265201f, -0.04953555f, -0.06526104f, -0.05980966f, 0.24568224f, -0.02869744f, -0.07650639f, -0.03659701f, 
    0.15105778f, -0.05328721f, 0.06278668f, -0.01447209f, -0.04489534f, 0.14124216f, -0.10749920f, -0.08969316f, 
    0.07738673f, -0.03501393f, -0.12531492f, 0.01481075f, 0.02857172f, 0.13368136f, 0.12685686f, -0.01977999f, 
    -0.29883754f, 0.08226319f, 0.00285216f, -0.02279841f, 0.25441924f, 0.02761904f, 0.08010293f, -0.01068766f, 
    0.16037978f, 0.11464357f, 0.06245929f, 0.05057178f, -0.25030664f, -0.14305612f, -0.13898677f, 0.14033954f, 
    0.01824895f, -0.19336495f, 0.14238028f, -0.03246737f, 0.23151857f, -0.04140854f, 0.06592988f, 0.09821516f, 
    -0.41153041f, 0.02634544f, 0.22221597f, 0.05513590f, -0.08994406f, -0.09810815f, 0.04789897f, 0.23563829f, 
    0.01971364f, 0.15797134f, 0.06739902f, 0.06326570f, -0.01706086f, -0.26336834f, -0.11524618f, 0.08695789f, 
    -0.08609271f, -0.16704068f, -0.00534982f, 0.11315972f, 0.00917188f, 0.07183996f, 0.07301852f, 0.32256013f, 
    0.27468196f, -0.04908512f, -0.07743535f, 0.13137263f, -0.05256930f, -0.05288508f, -0.16496617f, -0.01082764f, 
    0.19617237f, -0.14110032f, -0.02232146f, -0.01527468f, -0.38400325f, -0.12220539f, 0.01976440f, -0.04463542f, 
    0.08370101f, 0.21427068f, 0.14387485f, -0.02798115f, 0.04989048f, 0.04425939f, 0.02860315f, 0.03494242f, 
    0.17429315f, -0.15858558f, -0.07416521f, -0.00478048f, -0.00908717f, -0.17276622f, -0.14266710f, 0.17131473f, 
    0.01532640f, -0.00762976f, -0.03126328f, -0.03691396f, 0.04822426f, -0.03710954f, 0.01346018f, -0.09064281f, 
    0.08442757f, -0.08084214f, -0.28699234f, 0.05570119f, 0.04995440f, 0.00198691f, 0.06454053f, -0.06299506f, 
    0.35134661f, 0.17803515f, 0.10788339f, -0.18420157f, -0.13662751f, -0.07301760f, 0.24641794f, 0.05245687f, 
    0.10828751f, -0.15902607f, 0.18898305f, 0.03697674f, -0.03586014f, 0.08566932f, -0.06992942f, -0.11958025f, 
    0.23977064f, 0.06166708f, 0.04381137f, -0.11399062f, 0.00014799f, -0.03965129f, -0.01174212f, 0.06268544f, 
    -0.07707243f, -0.07118538f, 0.06738454f, 0.21959840f, 0.03757863f, -0.04242539f, -0.03022890f, -0.03719734f, 
    0.16095138f, -0.14047122f, -0.09355748f, -0.00518734f, -0.46057734f, -0.06300201f, 0.09765217f, -0.03070142f, 
    0.08531194f, -0.07488078f, 0.01792337f, 0.15252700f, 0.17758200f, 0.02598241f, -0.08874343f, 0.11242650f, 
    0.02920100f, 0.00383373f, -0.14578727f, -0.29048836f, 0.05505939f, 0.05275764f, -0.11772161f, -0.05327597f, 
    -0.02059775f, 0.02912032f, 0.18625656f, 0.06300224f, 0.11344860f, -0.05755026f, -0.21642007f, -0.01783776f, 
    -0.12904674f, 0.01749525f, 0.04812129f, 0.11552414f, 0.08915069f, 0.06581708f, 0.02339990f, -0.02618330f, 
    0.12906936f, 0.05337557f, 0.18433279f, -0.02147256f, -0.16263694f, 0.07714251f, 0.05408861f, -0.06345924f, 
    -0.06809665f, 0.11879121f, 0.05893217f, 0.11400147f, 0.33432910f, 0.21548700f, -0.19649626f, -0.17277345f, 
    0.26021558f, 0.12991847f, 0.05811764f, 0.04410057f, 0.13151175f, -0.02834959f, 0.02006612f, -0.00034707f, 
    -0.02283327f, 0.27719316f, 0.07761279f, -0.10688413f, -0.11559185f, 0.04172346f, 0.13847090f, -0.02139235f, 
    -0.00141566f, -0.10413349f, -0.05273528f, 0.03581338f, 0.27630344f, 0.10811351f, 0.00317715f, 0.14394015f, 
    0.08134505f, -0.05945772f, 0.08349922f, -0.03345502f, -0.01945072f, 0.03156475f, 0.13976148f, 0.02620086f, 
    -0.20563599f, -0.12747134f, 0.35339633f, -0.22967152f, 0.05261002f, 0.02346738f, 0.08387773f, -0.04412128f, 
    0.06576908f, -0.00656978f, -0.10905249f, 0.13371238f, -0.31752634f, -0.39979169f, -0.07485345f, 0.03339146f, 
    0.00006149f, 0.00906784f, 0.04289577f, 0.04528683f, -0.03674048f, -0.07150727f, -0.10594098f, 0.02144769f, 
    0.03516666f, -0.15675358f, -0.02675785f, -0.01053579f, 0.11904737f, -0.06345673f, -0.01673661f, 0.10148119f, 
    0.07337673f, -0.01122074f, -0.04333019f, 0.01451165f, -0.16481042f, 0.07526179f, 0.06269354f, -0.10977598f, 
    -0.02545150f, 0.12213759f, 0.05814403f, 0.07015226f, -0.04671577f, 0.05244098f, 0.08874840f, 0.03025807f, 
    -0.01603053f, -0.28187943f, -0.20225959f, -0.21613936f, 0.05921486f, 0.05053857f, 0.07092667f, -0.02572019f, 
    -0.05206955f, -0.16932842f, 0.11972727f, -0.07576123f, 0.20104368f, -0.34524316f, -0.12369974f, -0.15536276f, 
    0.06159381f, 0.06696369f, 0.09466771f, 0.16267103f, 0.02584063f, 0.02921098f, 0.09553076f, -0.07200161f, 
    0.14707053f, -0.00805253f, 0.39495158f, -0.04328199f, -0.12718420f, 0.01809062f, 0.06164390f, 0.09306105f, 
    0.00677775f, -0.03005629f, -0.03034649f, 0.03916321f, 0.00720369f, 0.07554223f, 0.18638067f, -0.12918258f, 
    0.02232275f, -0.06556414f, 0.08440752f, 0.13639183f, -0.05375067f, 0.03688397f, 0.07562530f, 0.00402890f, 
    -0.11368522f, -0.23186208f, -0.20918599f, -0.11290747f, 0.07803771f, 0.13727279f, -0.06566099f, 0.23642090f, 
    0.16332425f, 0.10803398f, 0.16661409f, -0.03234721f, -0.00131331f, -0.01466743f, -0.05938951f, 0.04695072f, 
    0.08387261f, -0.04092032f, -0.06594981f, 0.06102955f, 0.04574703f, 0.01693176f, 0.04293717f, 0.10865100f, 
    0.09330306f, -0.00784731f, 0.01295944f, 0.07945585f, -0.09403080f, 0.11975123f, 0.00525390f, -0.01015475f, 
    0.06191090f, 0.01172545f, 0.11355581f, -0.15176819f, 0.01356713f, -0.19600841f, -0.22781956f, 0.15512590f, 
    -0.19333883f, -0.00960533f, 0.10845320f, -0.02151131f, 0.07102138f, -0.04640732f, 0.05685770f, 0.00301445f, 
    0.16458042f, 0.21621333f, 0.11147396f, 0.10022691f, 0.08460853f, -0.01987844f, -0.11336168f, -0.06294440f, 
    -0.09984867f, 0.15389132f, -0.01346404f, -0.03628143f, 0.22729588f, -0.12554283f, 0.04983331f, 0.06513140f, 
    -0.04078738f, 0.01229202f, 0.01439516f, 0.13468939f, 0.04819530f, -0.05906861f, -0.02727797f, -0.10743149f, 
    -0.04344602f, 0.30342439f, 0.01237272f, -0.05674635f, 0.23806296f, 0.02616072f, -0.16631764f, 0.02120623f, 
    -0.05198260f, 0.05802273f, -0.01970799f, -0.18290994f, -0.23181894f, 0.06143318f, 0.18648595f, -0.09493352f, 
    0.03296177f, 0.12661587f, -0.07489501f, -0.04527893f, -0.09374131f, 0.09286856f, -0.16026030f, 0.02089395f, 
    -0.22584407f, 0.06447080f, -0.15408896f, -0.13991770f, 0.04370319f, 0.02382328f, 0.12291948f, -0.04394764f, 
    -0.09835504f, -0.08935697f, 0.06744495f, 0.05400337f, -0.20735343f, -0.22323656f, -0.19051102f, -0.32523870f, 
    -0.22039804f, 0.00062806f, -0.05700672f, -0.06841561f, -0.04768872f, 0.16709726f, -0.00718961f, -0.12594138f, 
    0.02213498f, -0.15650728f, 0.02542385f, 0.15028101f, -0.00907701f, -0.11620634f, 0.03505567f, -0.03744331f, 
    -0.08281307f, 0.06070782f, -0.01436587f, 0.06280746f, -0.32368046f, 0.06176449f, -0.27282393f, -0.52255917f, 
    -0.00519792f, 0.08284724f, -0.03690332f, 0.05195591f, 0.11245410f, 0.06240277f, 0.05004907f, 0.02463588f, 
    -0.05832056f, -0.09002532f, 0.12912734f, 0.05168643f, 0.02203000f, 0.10751519f, 0.17102088f, -0.11005300f, 
    -0.10094848f, -0.01483740f, 0.07691599f, -0.01910350f, -0.08969688f, -0.19231604f, -0.13004541f, 0.24620108f, 
    0.12932748f, 0.00641975f, 0.17586814f, 0.07648547f, 0.05325995f, -0.10997371f, 0.03640628f, 0.08701610f, 
    0.11878593f, 0.27659127f, 0.19403878f, 0.16281475f, 0.05120652f, 0.08096845f, 0.04715184f, -0.12565002f, 
    -0.03690547f, 0.04480753f, 0.00798996f, 0.01522103f, 0.17504112f, 0.10366338f, 0.12456392f, -0.01684876f, 
    0.02561184f, 0.00701728f, -0.09434411f, 0.13640183f, 0.13814700f, 0.12225071f, 0.12007636f, 0.00360536f, 
    0.08503435f, -0.11849609f, 0.09628751f, -0.08486263f, -0.10323159f, 0.02624806f, -0.17042421f, 0.12134922f, 
    -0.04938637f, 0.09205888f, 0.03115838f, 0.14429830f, 0.22624171f, 0.14133123f, -0.04756137f, 0.00359587f, 
    -0.16974162f, -0.01167253f, -0.03706520f, -0.03708351f, -0.07817893f, -0.02495867f, 0.09339637f, 0.07729665f, 
    0.07813966f, -0.06488037f, 0.01992609f, 0.08017596f, 0.00102412f, 0.15896638f, -0.06927291f, -0.04340953f, 
    0.05579420f, -0.01006306f, -0.11406310f, -0.15265961f, 0.43026507f, -0.02923301f, -0.08948702f, -0.05260544f, 
    -0.10791156f, 0.10264584f, 0.19805646f, 0.05990120f, 0.18600217f, 0.04668055f, 0.12826940f, -0.00393007f, 
    -0.24186812f, -0.02307139f, 0.00682897f, -0.39027271f, -0.00303823f, 0.00551806f, -0.01100547f, -0.09345251f, 
    -0.08952800f, 0.02270845f, -0.06177237f, 0.05714200f, -0.19115894f, 0.18498753f, 0.17730199f, -0.26520309f, 
    -0.10841788f, 0.02207563f, 0.03705271f, -0.05356045f, 0.00535103f, 0.03565321f, -0.01190087f, 0.02104855f, 
    -0.18619713f, -0.15447170f, -0.00800989f, -0.12434663f, 0.11247501f, -0.00595523f, -0.05796642f, -0.03424226f, 
    -0.01820701f, -0.00946233f, -0.02883450f, 0.05673458f, 0.07452013f, 0.01402773f, -0.13032620f, -0.04263829f, 
    0.12432031f, 0.13123392f, 0.10853199f, -0.01659527f, 0.07549195f, 0.01020707f, 0.07765175f, -0.08300596f, 
    -0.06382272f, 0.17532131f, -0.13133383f, 0.27618372f, 0.06725060f, -0.06078131f, -0.23941861f, 0.05872544f, 
    0.14238015f, -0.03417853f, -0.02780763f, -0.02004729f, 0.03728566f, -0.09904165f, 0.02893886f, 0.17419048f, 
    0.09082577f, 0.06908035f, 0.05488390f, -0.19666435f, -0.08702498f, -0.02116986f, -0.00399823f, -0.03778839f, 
    -0.08160689f, -0.10903528f, 0.16438006f, 0.14755347f, -0.00097182f, 0.06230342f, -0.02136550f, 0.04031578f, 
    -0.04492640f, -0.07808851f, -0.08691866f, 0.06840976f, 0.02416885f, 0.14584720f, -0.05461525f, 0.26153576f, 
    -0.00811417f, 0.00915350f, -0.08593647f, -0.05483456f, -0.03148685f, -0.07426982f, -0.05814018f, 0.05522175f, 
    -0.07238702f, 0.14546691f, 0.00879302f, -0.03651475f, 0.09209588f, 0.10510558f, -0.01694825f, -0.00368799f, 
    -0.05047185f, 0.01209418f, 0.01963613f, 0.06633143f, -0.02049967f, -0.24201147f, 0.03825866f, 0.13391086f, 
    0.02820580f, -0.09080782f, -0.03705777f, -0.01205048f, -0.07461230f, 0.04287191f, 0.04782474f, 0.05836295f, 
    -0.20553201f, 0.16982126f, -0.04455980f, 0.15992466f, 0.02086885f, 0.09668350f, -0.03637696f, 0.17234491f, 
    0.04483339f, -0.03069707f, -0.09071113f, -0.10889722f, -0.18150532f, 0.22565864f, 0.00971140f, 0.17043692f, 
    0.01254518f, 0.26653582f, 0.09284469f, 0.02880246f, 0.01263286f, -0.04573506f, -0.04098730f, 0.13777803f, 
    -0.22856346f, 0.06730325f, -0.07842337f, 0.01257551f, 0.04414981f, 0.15347821f, -0.00711078f, -0.03850374f, 
    0.12872122f, 0.04869860f, -0.10167365f, -0.04813846f, 0.03218155f, -0.04130468f, 0.13548678f, 0.37749693f, 
    0.21344981f, 0.09093729f, 0.02125336f, 0.01016260f, 0.00425417f, 0.02725460f, 0.04857409f, 0.09186773f, 
    0.07077831f, 0.08093340f, 0.23262011f, -0.17107446f, -0.07941966f, 0.00476030f, 0.07833701f, 0.08750495f, 
    0.01738528f, 0.00882144f, -0.02079237f, -0.02574238f, -0.13221060f, 0.15000303f, 0.11108256f, -0.16481766f, 
    0.04467654f, -0.04614145f, -0.02054434f, 0.11636502f, 0.08873408f, 0.03673537f, 0.05720253f, 0.09110283f, 
    0.04429609f, -0.02871244f, -0.01545952f, 0.05747613f, 0.00881672f, -0.02165189f, 0.02426828f, 0.05794849f, 
    -0.00796080f, 0.03953048f, -0.05332860f, 0.05257519f, -0.04474179f, -0.03720072f, -0.03817194f, 0.04653065f, 
    0.07202174f, -0.01466538f, 0.00111172f, 0.06069491f, -0.07415132f, 0.04040754f, -0.04674364f, -0.02048856f, 
    0.04744921f, -0.03423090f, -0.04038813f, -0.07184270f, -0.03007674f, -0.01357356f, 0.04424153f, -0.03345368f, 
    -0.06052778f, 0.05303699f, 0.02280537f, -0.02142736f, -0.00367394f, -0.02814901f, -0.06804966f, -0.00372626f, 
    0.05836044f, -0.00898637f, -0.07579589f, -0.01637741f, -0.05709799f, -0.05205141f, -0.05117926f, -0.04283088f, 
    -0.01130725f, 0.02088746f, -0.05384901f, 0.01281922f, 0.04186597f, 0.02644938f, -0.04789294f, 0.04554577f, 
    0.06584082f, -0.02318381f, -0.06320490f, 0.01886862f, 0.00722547f, -0.04720454f, -0.04234788f, -0.00839328f, 
    0.00273718f, -0.03585161f, 0.01440357f, -0.03413256f, -0.02892523f, -0.06819677f, -0.01995312f, -0.04738259f, 
    0.04190936f, 0.03972536f, -0.02407041f, -0.07431436f, 0.04119944f, 0.01845806f, 0.03398493f, 0.04833624f, 
    -0.00681391f, -0.03295987f, -0.03879292f, -0.02739090f, -0.06390701f, -0.00930040f, 0.00064371f, -0.06943889f, 
    0.03278142f, -0.00152516f, -0.01349814f, 0.04983817f, -0.00233267f, 0.05239546f, 0.03879385f, -0.03256039f, 
    0.02255788f, -0.03699220f, -0.07787739f, 0.03788548f, -0.03014592f, -0.05873735f, -0.01311831f, -0.07020522f, 
    -0.00522640f, -0.05112291f, 0.02474680f, -0.06732587f, 0.07196265f, 0.02269245f, 0.02672460f, -0.03438833f, 
    -0.00783976f, -0.07556595f, 0.06298109f, 0.02905937f, 0.04077838f, -0.00396355f, 0.02396107f, 0.02908259f, 
    -0.03753423f, 0.01442740f, -0.04067331f, 0.03268914f, -0.07594192f, 0.00017182f, -0.01797300f, 0.01884255f, 
    -0.06763240f, -0.02942959f, 0.03249007f, -0.02213146f, -0.03411488f, -0.00352258f, 0.02997535f, 0.04231542f, 
    -0.07276934f, 0.00171104f, -0.00968828f, -0.01990045f, 0.02780616f, -0.01404916f, -0.04642601f, 0.02709694f, 
    0.01018781f, 0.04789353f, 0.03230016f, 0.05474343f, 0.05153606f, -0.08336330f, 0.05873577f, -0.02358039f, 
    0.03933442f, -0.00535775f, 0.05453466f, -0.07006505f, -0.03888071f, -0.01064599f, -0.01002465f, -0.01536194f, 
    0.05527680f, 0.05077562f, -0.02430008f, -0.06106625f, -0.02667085f, 0.05504265f, 0.05916844f, -0.06186479f, 
    -0.07734712f, -0.03917999f, -0.00062255f, 0.01572700f, 0.03191349f, -0.05368230f, -0.03563577f, -0.04670567f, 
    -0.06362779f, -0.05398881f, -0.00798484f, 0.01607819f, 0.03652567f, 0.02126508f, -0.06793961f, -0.06739088f, 
    -0.06125673f, -0.04889778f, -0.02506292f, -0.04646016f, -0.01389065f, 0.02927242f, -0.06954551f, -0.06262664f, 
    -0.01601283f, -0.08282022f, 0.17966816f, 0.06547017f, -0.24769962f, -0.01222198f, -0.00815097f, 0.03241616f, 
    -0.05204083f, 0.06396402f, -0.00070742f, 0.07556048f, 0.04691596f, 0.04868918f, -0.20001462f, 0.03550510f, 
    0.08254028f, 0.12418009f, 0.12656033f, -0.04947663f, 0.13015261f, -0.01788091f, -0.04448388f, -0.02364610f, 
    -0.18217543f, -0.02540989f, 0.15828110f, 0.09439488f, -0.04075856f, 0.01350667f, -0.00488519f, 0.06132200f, 
    -0.06921180f, -0.03141406f, 0.04908761f, -0.08260074f, 0.50807577f, 0.07043393f, -0.02746518f, 0.24456149f, 
    -0.01284435f, 0.00038464f, 0.06629132f, -0.03399207f, -0.09292346f, 0.06829253f, -0.02870462f, 0.16521497f, 
    0.09618957f, 0.01410053f, 0.30551118f, -0.26135108f, -0.02201197f, 0.14861363f, 0.10109867f, 0.15690419f, 
    -0.00505632f, -0.03952026f, 0.01962055f, -0.02773244f, -0.23295256f, 0.02203252f, -0.00526214f, 0.21946864f, 
    -0.05881232f, 0.05595252f, 0.01897760f, 0.06572576f, -0.05801235f, 0.10127340f, -0.06842899f, -0.09342833f, 
    0.00843574f, 0.17010252f, -0.06269319f, -0.12415638f, 0.04981315f, 0.03723774f, -0.00820667f, 0.15649858f, 
    -0.05160512f, 0.08198789f, -0.06872745f, 0.11136833f, 0.21714322f, -0.06247074f, 0.21072190f, 0.12640931f, 
    -0.00579810f, 0.10425181f, -0.03275901f, -0.01570957f, -0.14926961f, 0.00593375f, 0.13049261f, 0.02079526f, 
    -0.06560973f, -0.24966027f, -0.08191304f, -0.38507646f, 0.06604307f, 0.04189036f, 0.04438908f, 0.00756916f, 
    -0.02920680f, -0.17592508f, 0.13110514f, 0.06405492f, 0.04382638f, 0.05140586f, 0.16175826f, -0.38049662f, 
    0.05323609f, 0.05246646f, 0.03757981f, 0.10914393f, 0.07891693f, 0.04679362f, -0.07143525f, 0.08239373f, 
    -0.09521274f, -0.10210692f, 0.06382476f, 0.06971151f, -0.08989540f, 0.04822932f, 0.05435561f, 0.09998629f, 
    -0.00471990f, 0.09127433f, -0.03208335f, -0.04812579f, 0.00461977f, -0.00238288f, 0.10033200f, 0.16100638f, 
    -0.10745957f, 0.10716738f, 0.01858758f, 0.12821138f, -0.07091638f, -0.02975623f, -0.05865173f, -0.00648441f, 
    -0.05577092f, -0.07036795f, -0.12296601f, -0.11086338f, -0.01919935f, 0.05210227f, 0.03409918f, 0.16025029f, 
    0.03134029f, 0.10802357f, 0.06734090f, -0.04045134f, 0.07133043f, 0.03319651f, 0.12628292f, -0.02812741f, 
    0.00414513f, -0.05122915f, -0.03455522f, 0.12472641f, 0.07135698f, 0.03060381f, 0.01767346f, -0.00173538f, 
    -0.40999281f, 0.05275866f, 0.14583805f, 0.18643749f, 0.04694256f, -0.06939840f, 0.05236851f, -0.01397689f, 
    0.03824129f, 0.07834710f, -0.02940042f, -0.01734881f, -0.19871582f, -0.22157522f, -0.17257109f, 0.20690361f, 
    -0.10850614f, -0.04988817f, -0.00960399f, -0.09421265f, 0.03023775f, -0.01876687f, 0.05277345f, 0.08366069f, 
    0.02304934f, 0.02025597f, -0.10534675f, 0.02630421f, 0.12628935f, 0.05274916f, -0.05509088f, 0.18669078f, 
    -0.13402557f, -0.14121588f, 0.04143625f, 0.04378575f, 0.08794674f, 0.06421208f, -0.23269336f, -0.11049529f, 
    -0.15840995f, -0.10831922f, 0.04105185f, 0.23780948f, -0.06071424f, 0.03954317f, -0.03676201f, -0.00263764f, 
    -0.48347929f, 0.00916571f, 0.14386551f, -0.31906623f, 0.10629292f, 0.03171785f, -0.01188032f, 0.03910306f, 
    0.02341620f, -0.00918235f, -0.10454527f, 0.06058836f, -0.12362543f, 0.02010214f, 0.20490623f, -0.11576618f, 
    0.00062002f, -0.06820976f, 0.13190828f, -0.08543675f, 0.10485011f, 0.07722112f, 0.02137014f, -0.08061834f, 
    0.05160908f, 0.06495080f, -0.02690402f, -0.07559776f, -0.12384798f, 0.08085243f, -0.06129438f, 0.06086114f, 
    0.02624121f, -0.00751012f, -0.07353283f, -0.11128091f, 0.29631379f, 0.17377114f, 0.02651724f, 0.06784058f, 
    0.09652179f, 0.13767241f, 0.05825215f, -0.09643379f, 0.02304405f, 0.12421799f, 0.01988604f, -0.00701888f, 
    0.03088797f, -0.09531856f, -0.03268939f, 0.11009289f, -0.11474596f, 0.03649694f, -0.02653220f, 0.07748504f, 
    0.05146342f, 0.01490176f, 0.04056480f, 0.06318063f, -0.16514379f, 0.14662091f, 0.04068215f, 0.00953492f, 
    0.11737559f, 0.06174269f, 0.04873018f, 0.13095087f, -0.01438258f, 0.00152811f, -0.17496516f, 0.06593267f, 
    0.16505358f, 0.06597933f, -0.01070319f, 0.03422018f, -0.05551142f, 0.09284236f, 0.05901390f, 0.05239224f, 
    0.06591594f, 0.11754720f, -0.04618008f, 0.06197508f, -0.14011021f, -0.06777336f, 0.11469801f, 0.12458033f, 
    0.05939180f, 0.00785605f, -0.00003459f, 0.05568675f, -0.05831302f, 0.01830100f, 0.10110606f, 0.00056611f, 
    0.04235204f, 0.06868821f, -0.10190754f, 0.13074380f, 0.06636136f, 0.09609221f, -0.04112262f, -0.06678126f, 
    -0.03240081f, 0.05371261f, -0.06147953f, -0.05511118f, -0.10386340f, -0.13097104f, -0.03159890f, 0.22547877f, 
    0.17387329f, 0.23225012f, -0.04774678f, -0.14481908f, 0.21533023f, -0.06514055f, -0.07293743f, 0.11546260f, 
    0.07125674f, 0.07898988f, 0.06457491f, 0.08528409f, -0.01654947f, -0.00498560f, 0.04497316f, 0.09952898f, 
    0.05731296f, -0.15533315f, -0.01785334f, 0.04215745f, 0.06975695f, 0.08492058f, 0.02767618f, -0.08628996f, 
    -0.06828102f, -0.09604821f, 0.10909543f, 0.00991508f, 0.09633107f, 0.00197646f, -0.04443972f, 0.01094273f, 
    -0.37132600f, -0.08996199f, 0.28356302f, -0.14245215f, 0.01908530f, 0.04735730f, -0.08201050f, -0.02335813f, 
    0.03640791f, -0.04155795f, -0.04092117f, 0.01124190f, -0.00632550f, -0.00045428f, 0.12821464f, 0.03854910f, 
    -0.08133309f, 0.00729234f, -0.09721734f, 0.09770782f, -0.12487806f, 0.09541736f, -0.03842201f, 0.01593545f, 
    0.21141574f, 0.30146766f, -0.00373106f, -0.14301544f, -0.20056333f, 0.06356413f, 0.04406286f, 0.10948507f, 
    -0.07127655f, -0.06013530f, -0.11401656f, 0.00663865f, 0.10488689f, 0.11348861f, -0.29010880f, -0.13127311f, 
    -0.00011536f, 0.01824580f, 0.01214543f, 0.02604727f, -0.07030353f, 0.00376559f, -0.04242516f, -0.11087621f, 
    0.34230727f, 0.16349949f, -0.02257705f, -0.21611054f, -0.02325904f, -0.02011396f, 0.10458700f, 0.07397690f, 
    -0.00379025f, -0.07772290f, -0.05735590f, -0.06859297f, 0.21408850f, 0.11869682f, 0.01107653f, -0.23173584f, 
    0.03983477f, -0.09810401f, -0.02099037f, -0.07230992f, -0.21467002f, -0.00485092f, 0.03241582f, 0.12327966f, 
    0.26812300f, -0.13049664f, -0.01929344f, 0.03969317f, -0.11078402f, 0.06146970f, 0.03297339f, 0.02384964f, 
    -0.07533453f, 0.05135980f, -0.01991824f, 0.09511148f, -0.13824625f, 0.13430429f, -0.06258840f, 0.14557897f, 
    -0.11756784f, 0.05607679f, 0.08523761f, 0.07170290f, -0.05541854f, 0.14388561f, -0.10425087f, -0.14519121f, 
    0.16046192f, -0.20685607f, -0.06216482f, -0.11179252f, 0.14554544f, 0.02212844f, -0.06597713f, 0.08315045f, 
    -0.03865916f, -0.05332230f, 0.13492468f, -0.05575400f, -0.13359168f, 0.01743216f, -0.00548332f, -0.09335749f, 
    0.05550609f, -0.03872125f, 0.06698012f, 0.06130921f, -0.11656228f, 0.08049637f, 0.13384373f, 0.14923061f, 
    0.08458868f, 0.01448393f, 0.02339873f, -0.05743814f, -0.01068271f, 0.10372720f, 0.10860194f, -0.04397586f, 
    0.01572690f, 0.01808754f, 0.12556247f, -0.10438346f, -0.07231363f, -0.06205130f, -0.00839010f, -0.05017329f, 
    0.17581554f, 0.04556012f, 0.02158779f, 0.20729081f, 0.01932040f, 0.04826238f, 0.07369354f, -0.04173942f, 
    -0.10190232f, 0.01872789f, 0.17936316f, 0.06056106f, 0.09183175f, 0.00262221f, -0.06433349f, 0.11169204f, 
    -0.03573416f, 0.05402068f, -0.16640046f, -0.05931910f, 0.05132844f, 0.10472190f, 0.19126996f, 0.16156405f, 
    0.03090695f, 0.00702848f, -0.06847525f, 0.00660253f, 0.09124956f, -0.05014383f, 0.14768812f, 0.11283270f, 
    0.11786712f, 0.02687712f, 0.04810854f, 0.03381659f, 0.16523260f, -0.05054480f, 0.02305247f, 0.05554365f, 
    -0.03281006f, 0.04501547f, 0.09322146f, -0.03379906f, -0.15368435f, -0.05211002f, 0.05055005f, 0.04995202f, 
    0.00845657f, -0.04938141f, 0.03053900f, -0.09466061f, -0.09752660f, 0.01187864f, 0.13735327f, -0.02433234f, 
    0.04907967f, -0.17767838f, -0.01084314f, -0.06700063f, 0.07358146f, -0.00689170f, 0.04157442f, -0.02265829f, 
    0.10822027f, 0.04454708f, 0.03970071f, -0.11194237f, -0.05729631f, 0.01224176f, -0.03488612f, 0.13592134f, 
    -0.14050159f, -0.01939719f, 0.01297204f, -0.07932917f, -0.02310663f, -0.01576376f, 0.08052237f, -0.03671122f, 
    -0.23493852f, -0.13193053f, 0.05660477f, -0.15714373f, 0.11717981f, -0.06603404f, -0.03741578f, -0.08930500f, 
    0.01248624f, 0.08227269f, -0.00984845f, -0.04489145f, 0.03471157f, 0.16208954f, 0.21312410f, 0.02307534f, 
    0.10609255f, 0.04873368f, -0.08513416f, -0.26758012f, 0.04225343f, -0.07924195f, 0.10365131f, -0.06944783f, 
    0.08440702f, -0.16384199f, -0.15267761f, 0.09180466f, -0.14052269f, -0.02281428f, 0.00396058f, -0.00393677f, 
    0.02373257f, -0.04855093f, 0.00381814f, 0.05657229f, 0.24954559f, -0.04006918f, -0.25066626f, 0.11521270f, 
    0.05813776f, 0.03993570f, -0.06622078f, -0.06548832f, 0.04020720f, 0.06469525f, 0.13948342f, 0.07275004f, 
    -0.01481774f, 0.04243511f, 0.14174928f, 0.18987761f, 0.18119647f, -0.00308865f, -0.03466113f, -0.05451891f, 
    0.00870357f, -0.02525349f, -0.12526344f, 0.02409919f, -0.01911812f, -0.07705429f, 0.02079849f, 0.27211747f, 
    0.02451137f, 0.01947308f, -0.03016689f, 0.00191243f, -0.13186158f, 0.03462567f, 0.07164981f, 0.07675306f, 
    0.13703415f, 0.19913262f, 0.20915967f, -0.03278136f, 0.08236274f, 0.02057790f, -0.01176185f, 0.09763179f, 
    -0.15187383f, 0.01750696f, -0.03290575f, 0.07810851f, 0.17104073f, 0.10295630f, -0.03329815f, 0.06518178f, 
    0.05011991f, 0.03577273f, 0.03360765f, 0.07093985f, -0.08826895f, -0.12688729f, 0.00954276f, -0.04421286f, 
    0.12833467f, -0.04150835f, -0.07280825f, -0.21109121f, 0.08365030f, -0.01833150f, -0.07138196f, -0.07108475f, 
    -0.00593427f, -0.07626623f, -0.04768647f, 0.07720055f, 0.23890904f, -0.28750068f, 0.07561333f, -0.08941233f, 
    0.09114194f, 0.11321282f, 0.03578499f, -0.04085537f, -0.08115907f, 0.05187076f, -0.11509053f, 0.09165323f, 
    -0.05633871f, 0.08198965f, 0.19692533f, -0.11977353f, -0.11979847f, -0.06062458f, -0.01278038f, 0.20282425f, 
    0.01855661f, -0.08155587f, 0.09197193f, -0.04513466f, -0.12244452f, 0.21311538f, 0.06949265f, 0.00550917f, 
    -0.01925522f, -0.10749548f, -0.01412720f, 0.06373118f, -0.16575997f, 0.08358021f, -0.10096586f, -0.05874299f, 
    0.08556748f, 0.03368795f, -0.01140673f, -0.00566693f, -0.02629134f, 0.06990428f, 0.07569737f, -0.03090020f, 
    0.10616119f, 0.09731317f, -0.15833354f, -0.10275751f, -0.14531679f, 0.10337097f, 0.19052152f, 0.24031481f, 
    0.11334793f, 0.12798092f, -0.14219338f, 0.08448479f, -0.01020257f, -0.04829820f, 0.12502730f, 0.06863399f, 
    0.31964913f, 0.32545197f, -0.03259278f, -0.13379464f, -0.04298006f, -0.04180738f, -0.02561798f, 0.01452346f, 
    -0.15427533f, 0.04582123f, 0.06989805f, 0.01915788f, 0.10919680f, 0.01186722f, 0.01217974f, 0.03164695f, 
    -0.17935149f, -0.07009222f, -0.01998482f, -0.06219888f, 0.11825563f, 0.00331624f, -0.02614873f, -0.03435563f, 
    -0.04234640f, -0.06383736f, -0.04089483f, -0.00052539f, 0.05735091f, 0.04310151f, 0.06666979f, 0.04168782f, 
    0.01324305f, -0.03886276f, 0.06325523f, 0.00425988f, 0.06108988f, 0.05336460f, -0.07159290f, 0.00120750f, 
    0.05030056f, -0.07367550f, -0.05115023f, -0.03219661f, -0.02607277f, 0.03853002f, -0.00826487f, -0.05572843f, 
    -0.05266651f, -0.04399578f, 0.02931814f, -0.00587169f, -0.07659435f, -0.05545126f, 0.04117092f, 0.01851908f, 
    -0.00302767f, 0.05425171f, -0.01274268f, -0.05882990f, 0.05147972f, -0.02205214f, -0.03774384f, -0.05693214f, 
    0.05809571f, -0.07602728f, -0.01208660f, -0.05834875f, 0.00130995f, 0.03734089f, 0.00909519f, -0.07799499f, 
    0.04854157f, 0.03171130f, 0.04480449f, -0.06667086f, 0.05668063f, 0.00167085f, -0.04551533f, 0.05422532f, 
    0.05387008f, -0.03750835f, 0.00144563f, 0.01479020f, 0.04093128f, -0.06159141f, -0.06587264f, -0.06606068f, 
    -0.07019095f, 0.02683738f, -0.03528754f, -0.05086381f, 0.02482676f, 0.01523498f, -0.01177177f, -0.03098129f, 
    -0.02339912f, -0.00982787f, -0.03795779f, -0.04210141f, -0.01768453f, 0.00683003f, 0.00747790f, -0.06185280f, 
    0.03506750f, -0.00238442f, 0.04241269f, -0.00391934f, -0.04033391f, -0.05518942f, -0.05540520f, -0.04342340f, 
    -0.06855397f, -0.04372434f, -0.00639518f, -0.08355792f, -0.07345914f, 0.05051075f, 0.01549082f, -0.07151482f, 
    0.06831296f, 0.04206799f, 0.06155337f, 0.00682534f, 0.04228919f, -0.07925621f, 0.05476218f, -0.02302330f, 
    0.05955413f, -0.01704480f, 0.00883370f, 0.04178470f, -0.06467336f, -0.04888798f, 0.00795107f, -0.03196384f, 
    -0.03827912f, -0.04629015f, 0.02146376f, 0.06257248f, -0.07658476f, -0.02186916f, -0.04368768f, -0.04879002f, 
    -0.02832533f, 0.06546168f, 0.05619096f, 0.00801526f, 0.06513277f, -0.00518571f, -0.07224849f, -0.00161240f, 
    -0.07545545f, -0.01796470f, -0.03114975f, -0.02824531f, 0.04271248f, 0.05210314f, 0.00851050f, -0.00821673f, 
    0.02520528f, -0.05857619f, -0.06619577f, -0.03006976f, -0.05076015f, 0.04858941f, -0.02856031f, 0.02726834f, 
    0.01594710f, -0.00355247f, -0.06820869f, -0.07699205f, 0.05344462f, -0.05252985f, -0.04065991f, 0.04126703f, 
    -0.00725185f, 0.05663022f, -0.06533520f, -0.00533352f, -0.01770268f, -0.03508772f, -0.00937158f, -0.07396549f, 
    0.04248051f, -0.05402221f, 0.06002957f, -0.04593237f, -0.02993266f, 0.05510422f, -0.04645963f, -0.01481099f, 
    0.02922744f, -0.07614511f, 0.04545048f, 0.01998223f, -0.04497831f, 0.03379555f, 0.01141932f, -0.07283685f, 
    -0.05197370f, -0.07734445f, 0.03228208f, 0.01683643f, -0.06530350f, -0.07325599f, -0.02585709f, 0.04828931f, 
    -0.02193545f, -0.07557528f, 0.03480838f, -0.04855462f, -0.07805034f, 0.04676342f, -0.04521304f, -0.03137639f, 
    -0.12802230f, -0.05225559f, -0.12821588f, -0.24912056f, 0.32837039f, -0.04464707f, -0.07731584f, -0.01813907f, 
    0.02033611f, -0.07149747f, 0.10464734f, 0.01561692f, 0.04721501f, 0.09063873f, 0.23369658f, 0.06354762f, 
    0.07728863f, -0.08906246f, -0.20910937f, -0.01238934f, 0.01720096f, 0.09016784f, 0.10705927f, 0.18821996f, 
    0.12610824f, -0.15512131f, -0.06427431f, -0.09159439f, -0.02621674f, -0.05362518f, 0.05098251f, -0.03970404f, 
    0.02248771f, 0.07246687f, 0.01350416f, 0.14225507f, -0.19617517f, -0.26323867f, -0.06883117f, -0.10361133f, 
    0.10074590f, -0.12127672f, 0.03190068f, 0.09222917f, 0.13021977f, -0.06938900f, 0.08749002f, -0.06849680f, 
    -0.02031678f, 0.01118927f, -0.02694553f, 0.22593512f, 0.11469325f, 0.00391551f, -0.03075945f, -0.01182372f, 
    0.05791714f, 0.03892003f, -0.05404259f, 0.11571474f, -0.06144317f, -0.07818181f, -0.17689459f, 0.06072858f, 
    -0.02413711f, -0.06262515f, 0.00453390f, -0.08625818f, 0.04838501f, 0.01554639f, 0.10510510f, 0.05202987f, 
    0.22288145f, -0.03550040f, 0.04632234f, 0.01773803f, -0.02732250f, 0.08406886f, -0.01077385f, 0.07376757f, 
    0.04311079f, 0.03037805f, 0.04897767f, -0.04109059f, -0.09263725f, 0.15268576f, -0.11839351f, -0.02100734f, 
    0.07735019f, -0.08351347f, 0.08691462f, 0.08193704f, -0.06578661f, 0.05365391f, 0.09080710f, 0.07092122f, 
    0.10359438f, 0.01575524f, -0.11776868f, 0.03110657f, 0.16522217f, -0.11502103f, -0.02193660f, 0.07906502f, 
    0.01466405f, 0.14350061f, -0.04828630f, 0.01723909f, 0.02839140f, -0.09946272f, -0.04343371f, 0.05098499f, 
    0.09129485f, -0.03405850f, -0.08352549f, -0.14516705f, -0.04310605f, 0.02960756f, 0.08892854f, -0.09466698f, 
    0.27861875f, 0.17079020f, -0.09829482f, 0.08163734f, 0.11938187f, -0.09944778f, 0.05179788f, -0.03257098f, 
    0.15190946f, -0.07550521f, 0.23422068f, -0.01143260f, 0.00082015f, 0.21140677f, -0.04529879f, -0.06633289f, 
    0.10762180f, -0.05618954f, 0.02808514f, -0.14434899f, 0.06017548f, 0.02002165f, -0.08402097f, 0.00253151f, 
    0.02442756f, -0.03610637f, -0.01245073f, -0.16961831f, 0.06724273f, -0.04290339f, 0.02593820f, -0.14973135f, 
    0.07608587f, -0.07658927f, -0.16654140f, -0.07662814f, -0.34182155f, -0.12655586f, -0.01539986f, 0.01662299f, 
    0.07644147f, 0.00989916f, -0.04247328f, 0.06350747f, 0.04105707f, 0.08265156f, 0.01103254f, -0.05992621f, 
    0.39314249f, 0.14841938f, -0.01218307f, -0.17054889f, -0.01528681f, 0.05076620f, -0.04352609f, 0.11421216f, 
    -0.02070595f, -0.02002579f, 0.12019566f, 0.11659254f, -0.20919853f, 0.06741163f, 0.09240180f, -0.14784735f, 
    0.10294423f, 0.13674712f, 0.06568682f, 0.13455863f, -0.02485443f, 0.04456917f, 0.01970798f, -0.02017340f, 
    0.05710869f, -0.06452960f, -0.03347131f, 0.00077913f, 0.06227309f, -0.20665631f, 0.03933472f, -0.04117387f, 
    -0.03578575f, 0.20654027f, 0.09154175f, 0.04408145f, 0.12461316f, 0.25326291f, -0.12843817f, -0.19519570f, 
    0.24547817f, -0.05679736f, 0.21036336f, -0.03824381f, 0.07693633f, -0.15209559f, -0.05465954f, -0.15746383f, 
    0.05022977f, 0.15144709f, -0.14059676f, -0.06967051f, 0.08362231f, -0.03840752f, -0.01652928f, -0.08878544f, 
    -0.04109858f, -0.20029752f, -0.10731623f, 0.02226240f, 0.44962078f, -0.13046782f, -0.17645407f, 0.15165646f, 
    0.10962342f, -0.13003120f, -0.00464849f, 0.00384129f, 0.06873372f, 0.08494247f, -0.01703788f, 0.08315144f, 
    0.08017399f, 0.02842821f, 0.30774558f, 0.03775756f, -0.06535827f, 0.02209247f, 0.01655565f, -0.12505504f, 
    0.14527194f, -0.06741923f, 0.12513451f, 0.02930108f, -0.01302277f, -0.32133448f, 0.14785784f, 0.20915163f, 
    0.04805495f, -0.05124637f, -0.22432806f, 0.07367156f, 0.01250502f, 0.05712924f, -0.12692058f, 0.00426810f, 
    0.09154693f, 0.16717732f, 0.12811802f, 0.07742024f, 0.19129881f, -0.11003841f, 0.00769205f, 0.06461252f, 
    -0.00337317f, 0.00737178f, -0.09081087f, 0.12040409f, -0.17508566f, -0.05586215f, 0.08016882f, 0.18476701f, 
    -0.08008509f, 0.01840159f, 0.03152466f, -0.00674469f, -0.07512237f, -0.07945495f, 0.06852110f, 0.10533085f, 
    -0.21385342f, -0.08080048f, -0.03715434f, -0.14906143f, -0.06662192f, 0.10142026f, -0.01740870f, -0.12732314f, 
    -0.11446920f, -0.31932813f, 0.03287624f, 0.10321788f, 0.34129819f, -0.23710746f, 0.09542211f, -0.03443155f, 
    0.05226530f, -0.07402863f, 0.07254104f, 0.04374018f, -0.05697580f, -0.06522346f, -0.09784283f, -0.00695670f, 
    -0.23438501f, 0.04967423f, 0.15766849f, -0.18330088f, 0.06376967f, 0.10241841f, -0.02325629f, 0.03549047f, 
    0.07462405f, 0.12822641f, -0.00662899f, 0.01313804f, -0.05434506f, -0.05243197f, 0.02852111f, -0.00455369f, 
    -0.01315937f, 0.15777777f, 0.13293095f, -0.07713525f, -0.02612387f, 0.05853980f, -0.04259786f, 0.09224103f, 
    -0.35426217f, 0.08398218f, -0.14801738f, 0.03905405f, 0.10935330f, 0.12818074f, -0.02584178f, 0.11091954f, 
    0.11325578f, 0.24085581f, 0.13719204f, 0.00365924f, 0.51602900f, -0.13735877f, 0.10574685f, 0.05842824f, 
    0.18507558f, -0.03008275f, -0.00647297f, 0.08874179f, -0.02230541f, -0.03515123f, 0.17559566f, 0.13410076f, 
    -0.18169531f, -0.02607889f, 0.14176902f, 0.00504343f, -0.09630117f, -0.03713315f, -0.04095904f, 0.14347492f, 
    0.03906727f, 0.09816240f, -0.06705270f, -0.07702064f, -0.11608323f, 0.18247823f, -0.16066371f, 0.10793319f, 
    -0.08079021f, -0.09011799f, -0.00907863f, -0.11014225f, 0.01151091f, -0.03968281f, -0.12945662f, -0.06291005f, 
    -0.03488675f, -0.02066409f, 0.00446238f, -0.04084344f, -0.03282601f, 0.00774682f, 0.02071232f, 0.04948008f, 
    0.00972965f, 0.04588556f, -0.03628377f, -0.04148021f, 0.03410568f, 0.05859758f, 0.04195021f, 0.05699439f, 
    0.05111858f, -0.04250059f, 0.01718622f, -0.08315631f, 0.00928339f, -0.05307265f, 0.02941827f, -0.08019331f, 
    0.01607509f, 0.04875434f, 0.04587139f, -0.03773977f, -0.06317089f, 0.03583369f, -0.02450999f, -0.05140204f, 
    -0.04277033f, -0.01487732f, 0.02349334f, 0.02864121f, -0.06479327f, -0.07297067f, -0.00989252f, -0.08344785f, 
    -0.02317949f, -0.04763437f, 0.05353402f, 0.05402560f, -0.01976854f, -0.01172564f, -0.00662353f, 0.01649269f, 
    0.00175213f, -0.03224839f, -0.06330133f, -0.04148947f, -0.03135174f, -0.00698428f, -0.01167825f, 0.00364915f, 
    -0.04946512f, -0.02621615f, 0.00833325f, -0.04229208f, -0.06540586f, 0.01132540f, -0.01668535f, 0.02079086f, 
    -0.00997895f, 0.02899786f, -0.03084786f, 0.01204811f, -0.03545703f, -0.03612722f, -0.02286476f, 0.03074343f, 
    -0.04927235f, 0.05094928f, -0.03030424f, -0.02440329f, 0.03856162f, 0.04699330f, -0.04930826f, -0.04916326f, 
    0.02670475f, -0.07249584f, 0.03497429f, -0.05503786f, -0.04322895f, -0.00416136f, -0.03267911f, 0.04199675f, 
    -0.06393730f, -0.03332423f, 0.00853923f, -0.06105197f, 0.06406591f, -0.00889782f, -0.03975853f, -0.07148095f, 
    0.01749897f, 0.02855468f, -0.03406041f, 0.01023595f, 0.01404012f, -0.00597595f, 0.00105546f, -0.04161696f, 
    -0.04765300f, -0.02654880f, 0.00925147f, 0.03600574f, -0.07140873f, -0.07020322f, 0.05573710f, 0.02436986f, 
    -0.04609126f, 0.05109357f, -0.06048179f, 0.01789514f, -0.08110636f, -0.02423729f, 0.03362129f, -0.05790170f, 
    -0.02129516f, 0.04778507f, 0.01183952f, -0.03169702f, 0.00431131f, 0.00452555f, -0.04419556f, 0.03363058f, 
    -0.03180346f, -0.04984283f, -0.03787378f, -0.00197060f, -0.02197895f, -0.04135188f, -0.02359445f, -0.05740526f, 
    -0.07172615f, -0.02379509f, -0.07165523f, 0.01465993f, -0.06690828f, -0.00604545f, 0.06245641f, -0.03521117f, 
    0.01276822f, 0.01533756f, -0.00915255f, -0.06050932f, -0.05233639f, -0.06512076f, -0.06694862f, -0.05171565f, 
    -0.01398390f, -0.01107071f, 0.02926640f, 0.03315527f, -0.00439514f, 0.04175833f, -0.06878548f, 0.01880880f, 
    -0.00210068f, 0.05979301f, -0.01636310f, 0.01610792f, -0.03306675f, -0.00340348f, 0.05695572f, -0.01708935f, 
    0.00674127f, -0.06975298f, 0.03486199f, -0.02498767f, -0.00397986f, -0.01524839f, -0.06105373f, 0.03300482f, 
    0.05133718f, -0.07953747f, -0.06014762f, -0.00227793f, 0.02999664f, 0.05436813f, -0.02505886f, 0.04826931f, 
    -0.03001917f, -0.00871386f, -0.04700600f, 0.05125370f, -0.05823802f, -0.00397096f, -0.05246763f, -0.04254635f, 
    0.03356379f, 0.16470416f, 0.17634536f, 0.21498603f, 0.02873034f, -0.17882776f, 0.00283529f, -0.02813838f, 
    -0.03313210f, -0.14486893f, -0.00939489f, -0.25072041f, 0.02102767f, 0.13103619f, 0.06934698f, -0.01212345f, 
    -0.05419012f, -0.24636346f, -0.23386088f, 0.00158966f, 0.01251519f, 0.19389239f, 0.03881734f, 0.07447809f, 
    -0.21129492f, -0.04455536f, 0.09728833f, 0.10178806f, -0.03652116f, -0.03148640f, 0.04261483f, 0.00140101f, 
    0.05630659f, 0.14318195f, 0.06006466f, 0.23387069f, -0.36354390f, -0.00348255f, 0.12283105f, 0.02266357f, 
    -0.09082775f, -0.10081390f, 0.13469188f, 0.01387015f, 0.07355145f, 0.01605906f, 0.13036968f, -0.01525421f, 
    -0.11009359f, 0.05953876f, 0.02662153f, 0.02347586f, -0.05536574f, -0.04793156f, -0.05961931f, 0.00527241f, 
    0.10914975f, 0.09750350f, -0.04561844f, 0.02430464f, 0.15049660f, -0.07696205f, -0.08079354f, -0.08341949f, 
    0.32280323f, 0.12483205f, 0.18739641f, 0.01224111f, -0.11128417f, 0.05871953f, 0.08587813f, 0.10190865f, 
    0.13464490f, 0.04414872f, 0.00252405f, -0.05233664f, -0.02554443f, 0.18858658f, -0.05251230f, 0.02102177f, 
    0.13873029f, -0.01673287f, 0.16565795f, 0.02061673f, -0.11065322f, -0.04123289f, -0.06605431f, -0.09935659f, 
    -0.03674843f, -0.07423804f, 0.05172275f, -0.03155587f, -0.09894446f, 0.01872918f, -0.06413711f, 0.08580451f, 
    0.08451062f, 0.08082847f, 0.01179358f, 0.02321048f, 0.06894576f, -0.00344413f, -0.02562208f, 0.09431028f, 
    0.05346226f, 0.15792949f, 0.00072148f, -0.02884654f, 0.14061409f, -0.00489101f, 0.14689459f, 0.11952157f, 
    0.11965521f, 0.00492647f, -0.20643143f, -0.11810756f, -0.01220456f, 0.02389458f, 0.15683497f, -0.11836246f, 
    0.08771961f, 0.09934343f, -0.11512407f, 0.03892076f, 0.14146692f, -0.12942126f, 0.06223352f, -0.08910109f, 
    0.06191912f, -0.06265137f, 0.05330774f, -0.00241289f, -0.22928703f, 0.05377714f, -0.09224704f, -0.05902807f, 
    0.23050874f, 0.13283105f, -0.08476080f, -0.15000200f, 0.00542440f, -0.20539437f, -0.19395286f, -0.02580372f, 
    0.03029634f, 0.13358431f, 0.03612491f, -0.11182520f, 0.09165614f, 0.00211543f, 0.09662338f, -0.19777380f, 
    -0.06662725f, -0.22391403f, -0.13300709f, -0.00529507f, -0.09323425f, -0.01079020f, -0.02671749f, -0.08416001f, 
    0.19263828f, -0.04998969f, 0.08818641f, 0.05077389f, 0.13230358f, 0.06435119f, -0.05482428f, -0.14872093f, 
    -0.01483687f, -0.10821126f, 0.08201022f, -0.27297488f, -0.05343845f, -0.06444734f, 0.06638856f, -0.10988659f, 
    -0.01390896f, 0.04583359f, 0.22770941f, -0.00760841f, -0.09658845f, 0.02251362f, 0.14346585f, -0.10740135f, 
    -0.00237460f, 0.17827196f, -0.09741867f, 0.07716999f, -0.06558483f, 0.08876263f, 0.00476242f, -0.03206648f, 
    0.03608980f, -0.06927086f, -0.04104961f, 0.02435788f, 0.00552455f, -0.03073290f, -0.03750174f, -0.06148520f, 
    -0.02688388f, -0.05311205f, -0.00712328f, 0.01603677f, -0.03604120f, -0.03081479f, -0.06138266f, -0.07489627f, 
    -0.07031461f, 0.05352980f, -0.01986122f, -0.06505562f, -0.05531537f, -0.07299612f, -0.06266405f, 0.01489701f, 
    0.00537907f, 0.01652376f, 0.03667414f, -0.00873333f, -0.05548627f, -0.00434080f, -0.05000492f, -0.07617190f, 
    0.00220898f, 0.01703562f, -0.05134453f, -0.04800812f, -0.00216314f, -0.01086435f, -0.06535607f, 0.04317375f, 
    -0.03894604f, -0.03299319f, -0.01300808f, 0.00409420f, -0.00735304f, 0.02447151f, -0.02832671f, 0.03193873f, 
    -0.05731023f, 0.03935850f, 0.03497932f, -0.04403615f, 0.03325923f, -0.07757798f, 0.01933207f, -0.05018665f, 
    -0.01710204f, -0.03239841f, -0.00851388f, -0.03169848f, -0.06142040f, -0.02871010f, 0.02321058f, 0.05425897f, 
    0.03025249f, -0.07970040f, 0.02724669f, -0.05592302f, -0.03348351f, -0.06036055f, 0.03219103f, -0.07010239f, 
    0.02531491f, -0.06475351f, 0.04897528f, -0.04487261f, -0.06978584f, 0.02761038f, -0.02670657f, -0.02122701f, 
    0.03289364f, 0.03133541f, 0.00332284f, 0.05497086f, -0.00205935f, -0.00636316f, 0.04387764f, -0.04626719f, 
    -0.07000984f, -0.01288663f, -0.00582573f, 0.06030412f, 0.05376971f, -0.05781237f, 0.04694434f, 0.00565046f, 
    -0.00559366f, -0.04096614f, -0.05856935f, 0.02125875f, -0.03697382f, -0.03035870f, 0.05411178f, -0.00241264f, 
    -0.06028093f, 0.01357427f, 0.05875026f, 0.04527329f, 0.00186703f, 0.04411805f, -0.02893059f, -0.00114517f, 
    -0.01309264f, 0.00291824f, -0.03520748f, -0.02732109f, 0.00278216f, -0.04469937f, -0.07952014f, 0.04311353f, 
    0.00144923f, -0.00200944f, -0.06846390f, -0.03075933f, 0.06031484f, 0.04259782f, -0.08095808f, -0.03542435f, 
    -0.01585537f, -0.04701106f, 0.04546057f, 0.06228885f, -0.02756420f, 0.05011212f, 0.00487331f, 0.00885494f, 
    -0.06619798f, 0.00523245f, -0.00057293f, -0.01200571f, -0.02899534f, -0.03135095f, -0.00382934f, 0.04512947f, 
    0.02557166f, -0.03001687f, 0.04726942f, -0.06190474f, 0.00790104f, -0.00141937f, -0.04604753f, -0.02602744f, 
    -0.02150437f, -0.03324855f, 0.01429318f, 0.02791173f, 0.05577318f, -0.01434559f, 0.01778888f, 0.01909780f, 
    -0.08207312f, 0.04166768f, 0.04405692f, 0.04050907f, -0.06261463f, 0.05979231f, 0.04553974f, -0.06251232f, 
    -0.03377969f, 0.04577401f, -0.01164498f, 0.00177911f, -0.00484875f, -0.03473037f, -0.04356464f, -0.04920709f, 
    0.03019719f, -0.04598200f, 0.03526934f, 0.02882917f, -0.02341113f, 0.01237949f, 0.02446228f, 0.00102457f, 
    -0.00295719f, 0.06034836f, -0.01996283f, 0.00123114f, -0.04162588f, -0.06203439f, 0.03302496f, 0.06016878f, 
    -0.03444804f, 0.10187381f, -0.13047071f, 0.07941584f, 0.20918600f, -0.06909823f, -0.09778305f, 0.05258490f, 
    -0.02417414f, 0.01280075f, 0.03592756f, 0.00345408f, 0.05808747f, -0.03458289f, -0.15807527f, -0.04780308f, 
    -0.07061334f, -0.12992673f, 0.13092183f, 0.15495305f, 0.01739419f, 0.02251684f, 0.03339271f, -0.04391412f, 
    -0.34566557f, 0.18707143f, -0.11262151f, -0.28726259f, 0.08612879f, -0.01048298f, -0.07579446f, 0.03489373f, 
    0.08786677f, -0.05297816f, -0.03524249f, -0.05181922f, 0.03371779f, 0.04349080f, 0.25999570f, -0.07538246f, 
    -0.02298542f, 0.14261281f, -0.00565970f, -0.00509692f, -0.08922746f, 0.07742827f, -0.05122290f, 0.00056684f, 
    -0.35412753f, 0.11928453f, -0.13276476f, -0.01283477f, -0.01058115f, 0.05578303f, -0.00302100f, 0.00329105f, 
    -0.09355408f, -0.06770355f, 0.02718841f, -0.00581426f, 0.23573689f, -0.14977151f, 0.07276534f, -0.06929602f, 
    0.14203924f, 0.07036779f, 0.07826636f, -0.07953425f, 0.05900545f, 0.05337508f, 0.01308650f, -0.01344718f, 
    0.18091407f, -0.27540365f, 0.06806331f, 0.25937855f, -0.07556897f, -0.05346691f, -0.05050870f, -0.10388757f, 
    0.08721889f, 0.09111965f, 0.08616678f, 0.06175252f, -0.12780720f, -0.01225851f, -0.01779117f, -0.05224678f, 
    -0.02200311f, 0.03203484f, 0.01697389f, -0.06998187f, 0.07394314f, 0.03042502f, -0.18234684f, 0.01876436f, 
    0.07422794f, 0.06924734f, 0.15947451f, 0.09337693f, 0.03862576f, 0.03955097f, 0.01937369f, -0.03488203f, 
    0.09185059f, 0.06527678f, 0.02459876f, 0.06774017f, 0.12111925f, -0.09589826f, -0.04005342f, 0.20398594f, 
    -0.00663411f, 0.02044517f, 0.08652518f, 0.06637876f, -0.07025424f, -0.10785665f, 0.10042768f, -0.00354928f, 
    -0.22727840f, 0.00595210f, 0.06518697f, 0.04680070f, 0.05052048f, 0.03874883f, 0.00939462f, -0.16251662f, 
    -0.00563400f, 0.10300833f, -0.04642332f, 0.02505206f, -0.38748050f, -0.13945548f, -0.01723751f, -0.06621129f, 
    -0.00174379f, 0.14509510f, -0.02608506f, 0.04993899f, 0.15507819f, 0.02209681f, 0.11271052f, 0.03427546f, 
    -0.03180404f, 0.03874995f, 0.19466719f, 0.10312454f, -0.07083192f, -0.00120247f, -0.01583078f, 0.06841633f, 
    -0.03912683f, -0.12568909f, 0.06548713f, 0.00970065f, 0.27308699f, -0.03303250f, 0.04201792f, -0.03047790f, 
    -0.00712308f, 0.04730849f, 0.14441423f, 0.04335248f, -0.10143105f, -0.04569863f, 0.03647888f, 0.07254560f, 
    -0.01721100f, -0.06287567f, 0.15001771f, -0.05840484f, -0.02470170f, 0.15668823f, -0.05896527f, -0.07249190f, 
    0.13137308f, -0.03655112f, -0.09167464f, -0.08496341f, 0.27535978f, 0.10181172f, 0.07306156f, -0.16275217f, 
    -0.10283649f, 0.12333488f, 0.06061405f, 0.10079300f, -0.03673133f, 0.04242456f, 0.00752483f, 0.04348298f, 
    0.13790846f, 0.05565164f, 0.01398906f, -0.24495693f, -0.09439118f, 0.09171603f, 0.06773935f, 0.04637737f, 
    0.02194438f, 0.04461963f, 0.04855028f, 0.14925089f, 0.11181543f, -0.15772997f, -0.06272659f, 0.02282447f, 
    0.19946766f, 0.07204849f, 0.05607869f, 0.01000884f, 0.00004376f, -0.04231019f, -0.04708337f, -0.03686445f, 
    0.12306453f, 0.15808146f, 0.13636996f, -0.03653004f, 0.10828903f, 0.02102360f, -0.06219176f, -0.00875907f, 
    -0.06891466f, -0.08064613f, -0.05905150f, -0.17682554f, 0.04345248f, -0.05885359f, -0.07605866f, -0.10620327f, 
    0.02517654f, -0.04757725f, -0.01105565f, 0.09430945f, -0.09451285f, -0.02575215f, -0.06747639f, 0.08786441f, 
    0.23515393f, -0.19189215f, -0.05670200f, -0.04515850f, 0.01967656f, 0.15795633f, 0.21482337f, -0.01072895f, 
    0.05644459f, 0.07392763f, 0.07519548f, 0.16647457f, -0.10420618f, 0.12155599f, -0.09285057f, -0.10567901f, 
    -0.21981558f, -0.17380126f, -0.10673872f, 0.02115789f, 0.04759577f, 0.17411952f, -0.01735910f, -0.06135971f, 
    -0.11356309f, -0.02100514f, -0.22518960f, 0.01002994f, 0.01194922f, -0.11999213f, 0.04260071f, 0.07667343f, 
    0.06436051f, 0.09951617f, -0.11033264f, 0.01459489f, 0.21325526f, 0.06784862f, 0.12104063f, -0.01729706f, 
    0.10805567f, 0.15267971f, 0.00009056f, 0.01890995f, 0.00222710f, -0.05270295f, 0.13252744f, 0.11736596f, 
    -0.01917819f, -0.24693851f, -0.11439385f, -0.10818063f, -0.13307117f, 0.10034990f, -0.00886313f, -0.03424795f, 
    -0.06008054f, -0.14298902f, 0.07618448f, -0.03597046f, -0.25033641f, 0.06745515f, -0.03876975f, -0.12890592f, 
    0.02994937f, 0.02018333f, 0.17342943f, 0.17682368f, 0.04431809f, 0.06499854f, -0.00897750f, 0.11942592f, 
    0.03285081f, -0.23419105f, 0.14979036f, 0.16599382f, 0.05943736f, 0.09017339f, 0.05474280f, 0.03489791f, 
    -0.05666245f, 0.02787173f, -0.10528377f, 0.02931039f, 0.29360041f, -0.12393584f, 0.11157980f, 0.22182247f, 
    0.07011414f, -0.04515557f, 0.09568946f, 0.13248055f, 0.13597240f, 0.18710595f, 0.16727002f, 0.19249164f, 
    0.10930304f, -0.21519028f, -0.18811259f, 0.05359237f, -0.08636431f, -0.02078184f, -0.03673937f, 0.18773235f, 
    0.07069578f, 0.13481370f, 0.20925227f, 0.13450229f, 0.01226919f, -0.02640063f, 0.00852184f, -0.08025517f, 
    -0.18984161f, 0.02247577f, -0.07499673f, -0.06983974f, -0.10440569f, 0.05401100f, 0.12574622f, 0.09538724f, 
    0.02622781f, 0.19517238f, -0.00959276f, 0.22099178f, 0.07197388f, 0.04453570f, 0.13774353f, 0.00646376f, 
    -0.02116220f, -0.04362987f, 0.02276712f, -0.03586975f, -0.06037194f, -0.04649368f, -0.14713389f, 0.16754493f, 
    0.10422660f, 0.01705905f, 0.05464754f, 0.01895656f, 0.08889756f, 0.00244281f, 0.02521518f, -0.01327999f, 
    -0.10255144f, -0.09733305f, -0.17067744f, 0.15365745f, -0.04290020f, 0.15616074f, 0.06201494f, -0.05258336f, 
    0.12138816f, 0.18152489f, -0.00301936f, 0.04617523f, 0.22941971f, 0.10260957f, 0.03667166f, 0.11656590f, 
    0.04285602f, 0.04682201f, -0.00890490f, 0.16808024f, -0.03232180f, 0.08057079f, -0.02702457f, 0.00940568f, 
    -0.11608493f, -0.02494439f, -0.00499020f, 0.05299539f, -0.00919169f, 0.03592823f, -0.01763884f, 0.00642545f, 
    0.32795316f, 0.21258987f, 0.10693738f, 0.14561267f, -0.03368150f, -0.07178839f, -0.07356881f, 0.02564798f, 
    0.10701858f, -0.16219065f, 0.15876399f, -0.03975520f, 0.22942916f, -0.01532552f, 0.07888274f, 0.06546204f, 
    0.00491891f, -0.00462340f, 0.03158511f, -0.02558797f, -0.09246065f, -0.35298109f, -0.04915626f, 0.14299954f, 
    0.07841358f, -0.11463851f, 0.08784251f, 0.07459933f, -0.21985930f, 0.10351395f, -0.08282829f, -0.01596470f, 
    0.10061821f, -0.16390347f, -0.01794410f, -0.03948274f, -0.02455089f, 0.02381846f, -0.07148385f, -0.14014447f, 
    0.01578350f, 0.11964226f, -0.12297064f, -0.09940458f, -0.17908823f, -0.02548654f, 0.16733341f, 0.00236301f, 
    0.03190602f, 0.10504635f, -0.09513275f, -0.02397314f, -0.37172687f, -0.23057657f, 0.15786774f, -0.00866089f, 
    0.02451042f, -0.39298785f, -0.02840544f, -0.14960444f, 0.22564848f, -0.02852578f, -0.05448264f, 0.14374627f, 
    0.09455110f, 0.09723575f, 0.03663760f, -0.15858632f, -0.14494060f, -0.17972320f, 0.08901419f, 0.12046548f, 
    0.09767847f, -0.04627953f, -0.03218646f, -0.03423207f, 0.01707621f, -0.11536206f, -0.03100139f, -0.07454357f, 
    -0.07678634f, -0.01547770f, 0.24552298f, 0.11867946f, 0.00459443f, -0.10546676f, -0.03612562f, -0.04732539f, 
    0.11872756f, -0.00853321f, -0.02475219f, 0.05515139f, 0.01379300f, 0.23837806f, 0.13166736f, 0.02770946f, 
    -0.11138670f, 0.11473540f, -0.15222552f, 0.09694765f, -0.07165099f, -0.04607731f, -0.22527827f, 0.09274274f, 
    0.08664669f, 0.06438857f, 0.09751331f, 0.01729111f, 0.07679763f, 0.03186555f, -0.10505925f, 0.07767115f, 
    0.07107164f, -0.00146651f, -0.13022989f, -0.24765480f, 0.08543872f, -0.09758413f, 0.03616380f, 0.20835921f, 
    -0.03616576f, -0.34588167f, -0.08428919f, -0.00269741f, -0.03272806f, -0.20734572f, -0.23632711f, -0.35979360f, 
    -0.14575723f, 0.03483272f, 0.16732843f, 0.13520043f, 0.07886412f, -0.16130331f, -0.22037701f, -0.02395042f, 
    -0.26829380f, -0.10350735f, 0.02722220f, 0.15500966f, 0.22072572f, -0.00594006f, -0.10073519f, -0.06127148f, 
    0.03677898f, -0.02121399f, 0.24016154f, -0.04673409f, -0.16999799f, -0.04111433f, -0.04741733f, 0.03660991f, 
    -0.01133470f, 0.05523942f, 0.07975946f, 0.11210692f, -0.05499902f, -0.13661726f, -0.02177276f, 0.04594176f, 
    -0.07183166f, 0.05825320f, -0.06834610f, 0.00072171f, -0.07721536f, 0.00276933f, -0.03969581f, -0.04927934f, 
    0.04779812f, -0.00171797f, -0.04405425f, 0.01450810f, -0.03496470f, 0.00857409f, -0.00362530f, -0.00659928f, 
    0.03596388f, -0.05511358f, 0.03682953f, -0.02359314f, -0.01607142f, 0.00486611f, 0.05624970f, -0.04114026f, 
    0.06613174f, 0.02713447f, -0.05220936f, -0.04347315f, 0.02273122f, -0.02517824f, -0.02900791f, -0.01405285f, 
    0.00770467f, 0.03900473f, -0.06040902f, -0.04907968f, -0.07133759f, -0.05889739f, -0.02681911f, 0.06491659f, 
    -0.00457960f, 0.02231769f, 0.03007728f, -0.02282645f, -0.05933857f, -0.03347617f, -0.07566293f, -0.02427550f, 
    -0.07063495f, -0.03719278f, 0.05596221f, -0.05824620f, -0.02236217f, 0.02766020f, -0.04345228f, 0.02285578f, 
    0.03282603f, -0.06833765f, 0.00751958f, -0.07292119f, 0.03753715f, 0.00564003f, -0.01162509f, -0.07678485f, 
    -0.05336237f, 0.02503345f, 0.03364636f, 0.02749362f, -0.07411152f, -0.02536764f, -0.06403827f, 0.05850165f, 
    -0.05321633f, -0.00789348f, -0.05209346f, -0.04702718f, -0.03273858f, 0.06138817f, -0.01545157f, -0.02995894f, 
    0.01523622f, -0.00178900f, -0.06253593f, 0.00059442f, 0.00775052f, -0.03537453f, -0.04664130f, -0.02158300f, 
    0.01576340f, 0.05137900f, -0.03116191f, 0.04752619f, 0.01552460f, -0.01198415f, 0.00225922f, 0.02090000f, 
    -0.05049357f, -0.02843376f, -0.00175187f, 0.03196963f, 0.06183865f, 0.06039687f, 0.02543501f, -0.07282323f, 
    -0.07551295f, 0.06447493f, -0.04669443f, 0.03470571f, -0.04147477f, -0.00732717f, 0.01111919f, 0.01515023f, 
    0.06403362f, -0.01648679f, 0.02371805f, -0.06899323f, -0.07400104f, -0.06700338f, -0.01302175f, -0.05271664f, 
    -0.05172993f, -0.04348123f, -0.05554659f, -0.03344487f, 0.05697744f, 0.04791170f, 0.02376712f, -0.03299057f, 
    -0.06263200f, -0.00133086f, -0.04946155f, 0.05368805f, -0.00060730f, -0.06148699f, 0.01592399f, 0.04683619f, 
    -0.00603805f, -0.07333706f, 0.00682415f, 0.02179285f, -0.02110106f, 0.04167136f, -0.04744812f, 0.01493043f, 
    -0.02175289f, -0.04715743f, 0.02405809f, -0.04619503f, 0.00200587f, 0.00651580f, 0.01382324f, -0.01226749f, 
    -0.02450277f, -0.04605588f, -0.06275189f, -0.03820240f, 0.06015363f, -0.01967882f, -0.05300931f, -0.06800637f, 
    -0.01228837f, 0.05296630f, 0.00819026f, -0.00688062f, 0.05741191f, -0.02050054f, -0.03835469f, 0.00883093f, 
    -0.07521942f, -0.05909864f, -0.01036546f, 0.04567748f, 0.05000830f, 0.01222854f, -0.03609044f, -0.00880797f, 
    0.04254850f, 0.01940041f, 0.04211948f, -0.01973035f, -0.01534019f, 0.04073828f, 0.00657385f, 0.03719097f, 
    -0.00480677f, -0.05161054f, 0.04746567f, -0.03026012f, 0.06636295f, -0.04022017f, 0.00705567f, -0.04803999f, 
    0.03197061f, -0.02843129f, -0.00145819f, -0.03938268f, 0.01152327f, -0.07437792f, 0.05927035f, -0.03486340f, 
    0.00042014f, 0.00436672f, -0.00564779f, 0.04904171f, -0.01459216f, -0.08453819f, -0.07853039f, 0.02221534f, 
    0.04333228f, -0.00655400f, -0.01239238f, -0.02872029f, 0.02592817f, 0.06321451f, -0.05756424f, 0.00666233f, 
    0.00074429f, 0.06159409f, -0.04436775f, -0.02101097f, 0.01848185f, -0.03939232f, -0.02489953f, 0.01410147f, 
    -0.04297782f, -0.05552610f, 0.03094347f, 0.02830691f, -0.02483137f, 0.03015061f, 0.04149334f, 0.06239444f, 
    -0.01593131f, -0.03844178f, -0.00104884f, 0.00864419f, -0.03243477f, -0.02966283f, -0.02189527f, -0.07616697f, 
    -0.04813293f, -0.03730507f, 0.03311080f, 0.02217235f, -0.03186374f, -0.01732456f, 0.01495574f, 0.06262328f, 
    -0.06120608f, -0.00343979f, 0.03467429f, 0.00023635f, 0.02235212f, -0.04655553f, 0.02559743f, -0.06817403f, 
    -0.06801675f, 0.00817050f, -0.02495449f, 0.01231774f, -0.01903606f, 0.03894470f, -0.05413479f, -0.04738467f, 
    0.02993686f, 0.04537506f, 0.03465078f, 0.00309120f, 0.03194192f, 0.02774786f, -0.01374105f, -0.03208674f, 
    0.04273048f, 0.01145617f, -0.03628798f, -0.03982626f, 0.00741649f, 0.02287307f, 0.04493837f, -0.07335159f, 
    -0.06275073f, 0.06003480f, -0.07650825f, -0.08175714f, -0.06098599f, 0.02071507f, -0.05230520f, 0.04753946f, 
    -0.00819382f, 0.06202680f, 0.05101373f, -0.06776039f, 0.02994649f, -0.00644198f, -0.06719157f, 0.05669624f, 
    0.04006818f, -0.00373627f, -0.06846627f, -0.03291500f, 0.05898389f, -0.01202421f, -0.07160136f, -0.03058609f, 
    0.03560309f, 0.05594949f, -0.01522001f, -0.00170963f, -0.04333741f, 0.03690192f, -0.07592788f, 0.04068099f, 
    0.05586912f, -0.00156290f, 0.02755982f, -0.06295634f, -0.01598960f, -0.06127494f, 0.01890095f, -0.05597151f, 
    -0.01903700f, -0.05993249f, 0.01608256f, -0.05936907f, -0.02924269f, 0.00711164f, 0.03589231f, 0.05537508f, 
    -0.01677304f, 0.01534086f, 0.03356466f, 0.02937729f, -0.03803742f, 0.00593016f, 0.06442662f, 0.04535402f, 
    0.04894513f, 0.03496876f, -0.05363475f, 0.05615608f, -0.02717618f, -0.06373835f, -0.07959414f, -0.07830173f, 
    -0.03233517f, -0.05333884f, -0.08124640f, -0.06705052f, -0.03591410f, 0.00429589f, 0.02961635f, -0.01205975f, 
    0.03217340f, -0.05768830f, 0.02715375f, -0.01554710f, -0.07009497f, -0.06669933f, 0.04892137f, -0.02053298f, 
    -0.06376284f, -0.04049595f, -0.02134830f, 0.02123419f, -0.01595815f, -0.02924099f, 0.06278796f, -0.01275766f, 
    -0.04416256f, -0.03137553f, -0.06280866f, 0.00783354f, -0.02446185f, 0.01835222f, -0.01468050f, -0.01543595f, 
    -0.01787127f, -0.07296216f, 0.03318534f, -0.02217323f, -0.01540138f, 0.04717168f, -0.02032909f, -0.05615972f, 
    0.14820534f, 0.35974824f, 0.32285121f, 0.09984067f, -0.11370734f, -0.01804018f, -0.07793022f, -0.18111157f, 
    -0.06026803f, 0.05668873f, 0.03390357f, 0.00676042f, 0.07942095f, -0.12797303f, 0.04771360f, 0.00288640f, 
    -0.08905102f, 0.10903454f, -0.20031162f, 0.04992193f, 0.13361223f, -0.01989084f, -0.02052409f, -0.04931078f, 
    0.02821425f, 0.22665226f, 0.20732406f, 0.11537621f, -0.00244335f, 0.12423235f, -0.16945085f, -0.11618399f, 
    0.14520563f, 0.14483529f, 0.05020924f, 0.00661376f, -0.54993433f, -0.10052057f, 0.07973665f, 0.06891830f, 
    -0.07083101f, 0.10472196f, 0.05822391f, -0.25068477f, 0.03600139f, -0.10556249f, -0.21363285f, 0.12135769f, 
    -0.23115420f, -0.12945494f, -0.05188480f, -0.12439268f, -0.03863878f, 0.11300732f, 0.11667740f, 0.11460058f, 
    0.00244273f, -0.05775744f, -0.01762787f, 0.11347048f, -0.17224787f, -0.21262032f, -0.15210797f, -0.08108773f, 
    0.00393828f, 0.06654242f, 0.01139218f, 0.03230794f, -0.01998056f, 0.10288714f, -0.06030228f, -0.04247394f, 
    -0.21872130f, -0.01347129f, -0.07736107f, -0.26447922f, 0.03979551f, 0.11075529f, 0.04246658f, 0.10287089f, 
    0.10753848f, -0.07187801f, -0.01293566f, 0.13023971f, 0.02715675f, -0.08937228f, -0.11916960f, -0.16218242f, 
    0.01451111f, 0.00035569f, -0.00938464f, 0.09731373f, -0.03165279f, 0.01508155f, -0.05620682f, 0.05919539f, 
    -0.16039020f, -0.14234224f, -0.01693753f, 0.08314213f, 0.06617583f, 0.03690641f, 0.15469433f, 0.09316541f, 
    0.04014017f, -0.06228886f, 0.16872807f, 0.06307427f, -0.28805768f, -0.03002160f, 0.02622677f, 0.04238471f, 
    0.07642240f, 0.03307449f, 0.13849583f, 0.01600917f, 0.11897210f, -0.00709617f, 0.13674578f, -0.00532056f, 
    -0.10217654f, 0.07697681f, -0.03562357f, 0.05382681f, -0.01162956f, 0.04814341f, 0.15358149f, -0.00217927f, 
    0.09111187f, -0.03683324f, -0.00702008f, -0.07611050f, -0.13457246f, 0.06878118f, 0.12525512f, 0.10790472f, 
    -0.01169728f, 0.26947922f, -0.09931212f, 0.07910664f, 0.03252516f, -0.07387597f, -0.08520822f, -0.05010076f, 
    -0.23442335f, 0.01698935f, -0.05148727f, -0.37861392f, 0.04540933f, 0.00846370f, 0.00787310f, -0.02096950f, 
    0.00191004f, 0.01987183f, -0.07438885f, 0.13282992f, 0.49881256f, 0.06226771f, -0.24155192f, 0.10235108f, 
    0.03074016f, -0.04002561f, -0.00680706f, -0.14396097f, 0.12251683f, 0.03887139f, 0.00407388f, 0.13938506f, 
    0.08955722f, -0.10390343f, -0.04445097f, 0.19336201f, 0.00306191f, 0.01118276f, 0.04744143f, -0.12466590f, 
    0.15944473f, 0.08234920f, -0.02511143f, -0.00863655f, 0.23733784f, -0.00294249f, 0.10106576f, -0.08557867f, 
    0.00863382f, 0.05358244f, 0.20002143f, 0.10487616f, 0.07748386f, -0.02172436f, 0.07634313f, -0.07876831f, 
    0.00572794f, -0.03309103f, 0.03868772f, -0.00960349f, 0.00045219f, -0.06868569f, -0.02653421f, 0.00555151f, 
    -0.00468926f, 0.02882003f, -0.03192697f, 0.00680656f, -0.08137878f, -0.00336885f, -0.01449141f, 0.02558038f, 
    0.00577106f, -0.04451878f, -0.07109352f, 0.04814055f, -0.04287723f, -0.06679065f, 0.00304346f, 0.04169407f, 
    0.03054898f, -0.07363249f, -0.05773189f, 0.03370514f, 0.02529413f, 0.01038461f, -0.03320979f, 0.00736818f, 
    0.03506271f, -0.00680899f, -0.06869339f, -0.02365351f, -0.06459455f, -0.06652530f, -0.02721030f, 0.02182062f, 
    -0.07189120f, -0.03069453f, 0.05468880f, -0.03672459f, 0.03855599f, 0.02796321f, -0.03509359f, -0.01835448f, 
    -0.07427605f, -0.05781508f, 0.01622066f, -0.05147832f, 0.05678878f, 0.05292938f, -0.02578917f, 0.04655692f, 
    0.05017966f, -0.04983559f, 0.02377211f, -0.05161069f, -0.06209553f, -0.00855725f, -0.07254139f, 0.05414840f, 
    -0.07364119f, 0.03072022f, -0.02897220f, 0.01836013f, -0.00272776f, -0.04014774f, 0.04540302f, -0.06287831f, 
    -0.07900047f, 0.04951790f, 0.02395647f, 0.04471852f, 0.04384353f, 0.05685968f, -0.02728046f, -0.07703960f, 
    0.05328260f, -0.01445160f, -0.06186392f, 0.04052982f, -0.01489141f, -0.05208645f, 0.06839143f, -0.03783489f, 
    -0.04517982f, 0.01845621f, 0.00485586f, -0.04130416f, -0.00731645f, -0.04360218f, -0.04986269f, -0.00550412f, 
    -0.04698816f, -0.04747569f, -0.05169649f, 0.04495542f, 0.02918517f, -0.03697696f, -0.04034475f, 0.03459552f, 
    -0.06569091f, -0.01816068f, -0.00543867f, 0.00474932f, -0.02334522f, 0.03021891f, 0.01656730f, -0.06212242f, 
    0.01023281f, -0.01055130f, -0.03710697f, -0.04122240f, 0.03012323f, -0.01075765f, -0.00703116f, 0.03849073f, 
    0.01834967f, -0.02654972f, 0.00145640f, -0.00320128f, -0.02322142f, 0.03651785f, -0.04976738f, 0.00163881f, 
    0.01404442f, -0.05978737f, -0.06683867f, -0.05453369f, -0.02025695f, -0.02638296f, -0.03282265f, -0.04786160f, 
    0.05129359f, -0.02627239f, -0.05433272f, 0.05417034f, -0.05125750f, 0.03667716f, -0.03136292f, -0.07227439f, 
    -0.01103826f, 0.03996056f, -0.00299669f, -0.07015943f, -0.04900507f, 0.03602130f, 0.03731143f, -0.03211921f, 
    -0.05651279f, 0.04260209f, -0.04516944f, 0.04716344f, 0.03551879f, 0.02808353f, 0.01980470f, 0.00875599f, 
    -0.03934396f, -0.06539741f, -0.01999488f, 0.00856847f, 0.00270709f, -0.02666989f, 0.01601077f, -0.03329739f, 
    -0.05578213f, -0.03975132f, -0.05632285f, 0.02103997f, 0.01475960f, 0.02873456f, 0.03321659f, 0.00173579f, 
    0.04657069f, 0.00895009f, 0.04590914f, 0.05306897f, 0.03674970f, -0.05732899f, 0.06244188f, 0.01296646f, 
    0.06114347f, 0.04066917f, -0.05425911f, 0.04864120f, -0.04494622f, -0.07773376f, -0.07048506f, -0.04481417f, 
    -0.16219264f, -0.07810596f, -0.21530825f, -0.25709984f, 0.14328036f, 0.04228511f, -0.03886744f, -0.03466686f, 
    0.05456857f, 0.20727593f, -0.09395948f, 0.12966779f, 0.07625070f, -0.09691645f, 0.03517159f, -0.04106798f, 
    0.12320999f, 0.11211850f, 0.12868673f, 0.06286049f, 0.01846870f, -0.05764101f, 0.01087071f, -0.03061846f, 
    -0.08353361f, -0.06482010f, -0.15716080f, -0.35642385f, 0.11156809f, -0.07653094f, -0.04097782f, -0.00647863f, 
    -0.00847574f, -0.09614524f, -0.01770611f, -0.18224920f, 0.27930495f, 0.09038600f, 0.02235902f, -0.13627885f, 
    0.06116823f, 0.06293981f, -0.04008001f, 0.07326552f, -0.10029148f, 0.10299594f, -0.01068669f, 0.00728850f, 
    0.04020847f, 0.04421651f, -0.06119411f, 0.29547393f, -0.02062824f, 0.10731819f, 0.06676728f, 0.02124912f, 
    -0.03487278f, -0.07278107f, -0.01730445f, -0.04355147f, 0.13567829f, 0.19464904f, 0.11708198f, 0.08808838f, 
    -0.12135729f, -0.00731966f, -0.14289840f, -0.19301082f, 0.09384175f, 0.07726337f, -0.04540307f, -0.19901103f, 
    -0.00317259f, -0.22876342f, 0.06507132f, 0.26110521f, -0.03515073f, -0.12505046f, 0.06668999f, 0.01943153f, 
    -0.16324955f, 0.13591802f, -0.08700654f, -0.07911566f, 0.11521371f, 0.23767775f, 0.06969625f, 0.08315870f, 
    0.07130758f, 0.07958765f, -0.07139736f, -0.02993907f, 0.08649660f, -0.04181742f, 0.07238813f, 0.09254313f, 
    0.05776456f, -0.13383330f, 0.12378630f, -0.00150456f, -0.13929375f, 0.13292980f, 0.01658057f, -0.04480534f, 
    0.03566638f, -0.06138887f, 0.10439640f, 0.00596234f, -0.17878701f, -0.06966808f, -0.02311324f, 0.16508697f, 
    -0.03959420f, -0.10897419f, 0.15491600f, 0.32230556f, 0.04788744f, 0.03221377f, 0.04783737f, 0.00403640f, 
    -0.29664195f, -0.20346648f, 0.11260298f, 0.12645911f, -0.02158402f, 0.20302701f, 0.03641371f, 0.03712672f, 
    -0.06337542f, 0.15504204f, -0.14922692f, -0.09010010f, -0.04127343f, -0.09104145f, -0.00312285f, 0.10442622f, 
    -0.02823276f, 0.09968745f, 0.16472524f, 0.16814552f, 0.11414914f, 0.07628392f, 0.29051641f, 0.14038372f, 
    0.03124292f, -0.13724603f, 0.07121141f, 0.19533342f, -0.11623811f, -0.03428302f, -0.01026630f, 0.13645011f, 
    0.06688591f, 0.17294273f, 0.17943405f, 0.06781951f, -0.04664402f, 0.12573047f, 0.13849740f, 0.02477901f, 
    -0.21944824f, 0.09763272f, 0.01977544f, 0.00851320f, -0.12783383f, 0.05144108f, 0.08973372f, 0.08454828f, 
    0.09003019f, 0.16665195f, 0.11153680f, 0.07781602f, 0.05431091f, 0.02280879f, -0.00147050f, -0.02697015f, 
    -0.01573841f, -0.12502280f, -0.10756703f, -0.05405282f, 0.20003313f, 0.08433710f, -0.12767576f, -0.17301866f, 
    -0.00167532f, 0.03800674f, 0.17854628f, -0.05420514f, -0.06016818f, -0.07981693f, 0.08434849f, -0.04960692f, 
    -0.29941204f, -0.02403492f, 0.06329483f, -0.37236601f, 0.04377130f, 0.04338123f, 0.05496311f, 0.00108739f, 
    -0.06608602f, 0.00607593f, -0.05850348f, -0.00174737f, -0.15131484f, 0.12107273f, 0.27216965f, -0.18771435f, 
    0.05690869f, -0.01603663f, 0.01975279f, -0.08414871f, 0.00700704f, -0.02533877f, 0.05503351f, -0.01759446f, 
    0.22078723f, -0.09976698f, -0.01323132f, -0.10722477f, -0.01897690f, 0.03304575f, -0.03909570f, -0.03146119f, 
    -0.03951099f, -0.06259843f, 0.03810554f, 0.07663098f, -0.16809152f, 0.03125095f, -0.30293250f, 0.02415679f, 
    0.12208389f, 0.01525603f, -0.04191248f, 0.02058646f, -0.01848435f, 0.07941942f, -0.03200687f, -0.11642139f, 
    -0.02206136f, -0.11897968f, -0.08590703f, 0.41165641f, 0.08061104f, -0.13563047f, 0.00796393f, 0.04622897f, 
    0.05193232f, 0.09820763f, -0.12224443f, -0.10226551f, 0.23339804f, 0.04906961f, -0.00342821f, 0.15881930f, 
    0.15549657f, -0.01634903f, 0.02125149f, -0.15802597f, 0.04938217f, -0.05567437f, 0.06245234f, 0.07273512f, 
    -0.07893202f, -0.02833174f, 0.08574909f, 0.06618384f, 0.02339455f, 0.09354168f, 0.04137661f, -0.05414244f, 
    -0.02248762f, -0.02614095f, 0.03062752f, 0.01279886f, -0.04930683f, -0.07415543f, -0.02850875f, 0.27794734f, 
    -0.02110418f, -0.08237067f, -0.00152352f, -0.00335237f, -0.06690917f, -0.11206207f, 0.01648175f, 0.09782297f, 
    0.00165351f, 0.13475427f, 0.10159224f, 0.19029264f, 0.05845769f, -0.04046437f, -0.07381094f, 0.05995880f, 
    -0.01578843f, 0.05127501f, 0.09131345f, 0.03046011f, 0.07211019f, -0.19127224f, -0.00674921f, 0.24058552f, 
    0.03266924f, -0.05474424f, 0.14784428f, -0.06652502f, -0.00600147f, 0.01164053f, -0.03633478f, -0.00674325f, 
    -0.22931539f, -0.07692279f, 0.02710094f, -0.04008089f, 0.07380738f, -0.01809214f, 0.07081181f, 0.04077942f, 
    0.04108020f, -0.11042485f, 0.09601922f, -0.07561582f, -0.12705700f, 0.12000173f, -0.00967463f, -0.05651870f, 
    -0.08443376f, 0.11803433f, 0.12281164f, 0.02609305f, -0.04634069f, -0.02074581f, 0.03152039f, 0.00438966f, 
    0.10704305f, 0.14870672f, 0.03611644f, 0.01826198f, 0.04493055f, 0.05653735f, 0.05443867f, -0.01788268f, 
    0.04976467f, -0.02316412f, 0.01783474f, -0.09146202f, 0.21463589f, -0.03468434f, -0.02085106f, 0.32342193f, 
    0.17092861f, 0.08474249f, -0.00440493f, -0.00229237f, -0.00212482f, 0.01437985f, -0.00006789f, 0.01418818f, 
    0.40186509f, 0.00760406f, 0.06679580f, -0.00617698f, -0.10862957f, -0.00772347f, 0.00662137f, 0.12396165f, 
    -0.07050078f, -0.02491706f, -0.01124519f, 0.00765476f, -0.04022834f, 0.28039131f, 0.09026109f, -0.13099372f, 
    0.00557457f, 0.12562081f, -0.01372511f, 0.11487124f, -0.00343602f, 0.00276436f, -0.01803424f, -0.05710141f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04006712f, 0.07078990f, 0.06227703f, -0.05391053f, -0.04920341f, -0.06270971f, -0.03844884f, -0.08049082f, 
    -0.01877135f, 0.02779979f, 0.11659817f, 0.05705567f, -0.08793572f, 0.11582972f, 0.02462965f, 0.06088624f, 
    -0.07187494f, 0.00739620f, 0.05234511f, 0.08285034f, -0.02593159f, 0.04026742f, 0.03961581f, 0.00502314f, 
    0.01977864f, 0.08478455f, 0.08989663f, 0.09745452f, -0.04714744f, 0.13581066f, -0.04596982f, 0.06131450f, 
    -0.00144806f, -0.01691112f, 0.03138050f, -0.00681141f, 0.01978199f, 0.13152066f, 0.04223084f, -0.01925927f, 
    -0.03722190f, 0.05936060f, 0.04656615f, 0.06407043f, -0.14689836f, -0.00724646f, 0.05027364f, -0.10210273f, 
    0.00469663f, -0.06409809f, 0.03543309f, 0.02997894f, 0.02992378f, -0.07779828f, -0.07727439f, 0.15046491f, 
    -0.03658792f, 0.05441835f, -0.00053131f, 0.03700716f, 0.05883528f, -0.00832828f, 0.09799761f, 0.05215129f, 
    0.09648732f, -0.00096926f, -0.01599612f, -0.06069423f, 0.04643815f, 0.03009203f, 0.02163197f, -0.02318114f, 
    0.05444955f, -0.00184264f, 0.02058264f, -0.04466148f, 0.11869822f, -0.03757509f, -0.02733133f, 0.00522238f, 
    0.12318709f, -0.02427716f, 0.01333980f, 0.02218526f, 0.03180553f, 0.03208536f, -0.06649193f, -0.00844978f, 
    0.02116385f, 0.02002318f, 0.08846982f, 0.02083172f, -0.03406317f, 0.06212571f, 0.01500638f, -0.06606927f, 
    0.07427927f, 0.14812590f, -0.10325914f, 0.10362882f, -0.03254906f, -0.00200932f, 0.01036177f, -0.00461312f, 
    0.17425938f, -0.02941683f, 0.02079948f, 0.01271322f, -0.00590601f, -0.01045727f, 0.03128683f, -0.01751620f, 
    -0.00682503f, 0.05399019f, 0.06913193f, 0.02354446f, -0.08474316f, 0.01323322f, -0.02862439f, -0.01792053f, 
    0.12010340f, 0.05295333f, 0.05339409f, -0.05125062f, 0.03574403f, -0.07799051f, 0.03251297f, 0.00997245f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13006300f, 0.24649231f, -0.20573604f, 0.24609756f, 0.00228119f, 0.19000384f, 0.04795492f, 0.16328993f, 
    0.06992292f, 0.06906184f, -0.48741752f, -0.04404134f, -0.04908678f, -0.03947796f, -0.05732013f, 0.04974237f, 
    0.14767613f, -0.06282304f, 0.11750652f, -0.62184715f, -0.06158520f, 0.13303283f, -0.09417456f, -0.09080819f, 
    -0.42688245f, 0.21280625f, -0.14462136f, 0.21592864f, 0.11118317f, -0.06223769f, -0.14353839f, -0.31967118f, 
    -0.16002935f, 0.21589360f, 0.06425365f, 0.10535344f, 0.01480836f, 0.08678944f, -0.12191635f, 0.09346398f, 
    -0.13186991f, 0.11381863f, -0.02313218f, 0.00622495f, 0.25310248f, -0.33911410f, 0.06351501f, 0.06807656f, 
    0.29215220f, -0.03369027f, 0.06327587f, 0.06208992f, -0.07878318f, 0.16389848f, 0.00609982f, -0.25557780f, 
    -0.00631033f, -0.24503228f, -0.02602617f, 0.24055074f, 0.03138587f, -0.56108570f, 0.04521770f, -0.05971618f, 
    0.04256235f, -0.03128776f, 0.10835300f, 0.05028675f, -0.03291706f, 0.10073241f, 0.04093245f, 0.12891048f, 
    0.00321260f, -0.15417525f, 0.06287866f, 0.01163098f, -0.26806703f, -0.00970282f, -0.00025837f, 0.25186133f, 
    0.01099245f, -0.14068286f, -0.01035424f, 0.05389832f, -0.09827789f, 0.15575916f, -0.01695300f, -0.05542469f, 
    -0.06897987f, 0.07882785f, 0.18502751f, 0.04827715f, -0.00804533f, -0.03554466f, -0.03933665f, 0.01454589f, 
    0.05900788f, -0.38432178f, 0.22478651f, -0.37266234f, -0.11101815f, -0.30739748f, -0.10293084f, -0.06596134f, 
    -0.52702934f, 0.16829795f, -0.14997914f, -0.27360177f, 0.07297118f, 0.25149566f, -0.35222301f, 0.04979536f, 
    0.05947380f, 0.05995170f, -0.31014359f, 0.34619752f, 0.06328306f, -0.13144258f, -0.02910572f, -0.26447967f, 
    0.03369306f, -0.34129545f, 0.07803697f, 0.05199768f, 0.10697685f, 0.00137869f, -0.23001730f, -0.15725067f, 
    0.13185531f, -0.16118497f, -0.06008859f, 0.05217160f, 0.04827748f, -0.10870827f, -0.00927068f, 0.05772630f, 
    0.04618481f, -0.03753623f, -0.22119364f, 0.00387776f, -0.11892712f, 0.35102031f, -0.03351521f, -0.06219159f, 
    0.21958286f, 0.07460633f, 0.21649526f, 0.17740645f, -0.01325839f, -0.12751377f, -0.20635980f, 0.12373058f, 
    -0.45696568f, -0.66058135f, -0.03064514f, 0.01038803f, 0.03215433f, 0.11662693f, 0.23564717f, 0.05614479f, 
    0.21389644f, 0.24853373f, 0.01429441f, 0.24844715f, 0.03574760f, -0.20755698f, 0.10750169f, 0.02136461f, 
    0.01663380f, -0.33142966f, 0.24622954f, -0.17488036f, 0.06343032f, -0.06224721f, -0.00114844f, 0.01902605f, 
    -0.47116062f, -0.04655852f, 0.06389736f, -0.00724918f, -0.02382200f, -0.38908446f, -0.02147945f, -0.53807485f, 
    0.04466124f, -0.24844988f, -0.12602241f, -0.40392178f, 0.06921732f, 0.09595418f, 0.09361175f, 0.01574456f, 
    -0.08272970f, 0.01377081f, 0.27602321f, 0.00913537f, 0.02094569f, 0.17109697f, 0.06112732f, 0.17845783f, 
    0.03385627f, 0.18312432f, 0.20376982f, 0.04938278f, -0.15650746f, -0.00972753f, 0.22244217f, 0.13936467f, 
    0.15936226f, -0.39831153f, 0.04888706f, 0.04443284f, 0.06356488f, -0.05660099f, 0.04032698f, 0.15352130f, 
    -0.02236801f, 0.02801790f, -0.17156638f, -0.06312122f, 0.01214461f, 0.06784505f, -0.02259596f, -0.07200032f, 
    -0.18566252f, -0.10580315f, 0.20820810f, -0.02245664f, 0.05860483f, -0.02555561f, -0.00248865f, -0.15765595f, 
    0.13675894f, 0.12472901f, -0.16186622f, -0.41446403f, 0.00080535f, 0.05200783f, 0.10825841f, 0.14581941f, 
    -0.12036315f, -0.03206090f, -0.02960915f, -0.42775372f, 0.00198189f, 0.13919938f, -0.06103398f, -0.18840608f, 
    0.05105416f, 0.40356091f, 0.07930290f, 0.00765079f, 0.06108679f, -0.04195000f, -0.23547626f, -0.20527290f, 
    -0.05277514f, 0.08520886f, -0.19701630f, -0.19685732f, 0.03898478f, -0.17711110f, -0.08453032f, 0.01522109f, 
    0.18339854f, 0.07967012f, -0.11203277f, -0.04205965f, 0.07815420f, -0.18368208f, 0.00795677f, -0.05383898f, 
    -0.14512108f, 0.01051110f, 0.11410744f, -0.01606692f, 0.07535859f, -0.59459883f, -0.11746635f, 0.16738841f, 
    0.10791497f, 0.14510518f, 0.17321791f, -0.05525161f, -0.01041248f, -0.16415355f, 0.21934837f, -0.18659280f, 
    -0.01034115f, 0.43129346f, -0.07651025f, 0.26434198f, -0.05796810f, -0.02352131f, 0.10969601f, 0.19049561f, 
    0.12123775f, 0.02799517f, -0.10742246f, -0.01782413f, 0.14096390f, 0.14398380f, -0.26986679f, 0.19402793f, 
    -0.02306520f, 0.03358982f, 0.05287609f, -0.00595663f, 0.07303242f, -0.23892510f, 0.07480486f, -0.04870398f, 
    0.08281966f, -0.09004717f, -0.49568003f, 0.27592987f, -0.12819037f, 0.32932314f, -0.03028866f, 0.06774218f, 
    -0.52648479f, 0.00104996f, -0.16787779f, -0.03111705f, 0.01757617f, 0.01309958f, -0.30853993f, -0.20489974f, 
    0.01947290f, -0.22094515f, 0.16997480f, 0.00559998f, -0.22339056f, -0.00188159f, 0.09625609f, -0.06306001f, 
    -0.20606630f, -0.08700071f, 0.03207489f, -0.09019908f, -0.07096817f, -0.22774844f, -0.05941037f, 0.26181680f, 
    -0.09054331f, 0.09729405f, 0.00553432f, 0.05075534f, -0.38787392f, 0.00591693f, -0.07817052f, -0.04423939f, 
    -0.26263392f, 0.12115799f, 0.01838490f, 0.00781091f, -0.05314598f, 0.19855832f, 0.00402842f, -0.29742831f, 
    0.10375313f, 0.10797316f, 0.37611967f, -0.29988083f, 0.04170851f, -0.36325076f, -0.29157478f, -0.18086597f, 
    0.11034556f, -0.00502363f, -0.01309981f, -0.18561688f, -0.00848899f, -0.21777095f, -0.08215861f, 0.15134436f, 
    0.07196554f, -0.23731540f, -0.04805718f, -0.02433048f, 0.06074807f, -0.06079387f, 0.03937466f, 0.05716944f, 
    0.02181642f, -0.25049946f, 0.18847536f, 0.17996433f, -0.04292971f, 0.21805054f, 0.02526277f, 0.04274910f, 
    -0.34623298f, -0.02350108f, 0.04237682f, 0.23880747f, -0.10960343f, -0.14530732f, -0.00297716f, -0.03634607f, 
    0.04346000f, -0.03699958f, 0.29752335f, -0.53656811f, 0.07836521f, 0.18933813f, -0.39312875f, -0.06949648f, 
    0.05525004f, 0.16830452f, -0.42016611f, -0.42997682f, -0.01443974f, 0.23862383f, -0.25586265f, -0.47032842f, 
    0.29572085f, -0.06949031f, 0.00200989f, 0.04422857f, 0.02484610f, 0.09695674f, 0.04635711f, -0.56868887f, 
    -0.05961035f, 0.29368478f, -0.37452596f, -0.25232261f, 0.17404836f, 0.32218468f, -0.43779534f, -0.20839570f, 
    0.22498415f, -0.04866189f, -0.03888773f, -0.00913873f, 0.01528872f, 0.10541248f, 0.07072692f, 0.26732713f, 
    0.00074327f, 0.02819898f, -0.12319477f, 0.08439900f, 0.17548415f, -0.30689269f, 0.21038757f, -0.00813092f, 
    0.06192218f, -0.07415041f, -0.58488244f, 0.04935053f, 0.08593926f, -0.07231763f, -0.03095528f, -0.16160910f, 
    0.02633303f, 0.29477814f, -0.15336694f, -0.04729202f, 0.09729635f, 0.04700783f, -0.55073768f, -0.06191356f, 
    0.01556401f, -0.03433165f, 0.00523817f, -0.05204114f, 0.00521721f, -0.51681691f, 0.05873203f, 0.09380507f, 
    -0.05968866f, -0.20465623f, -0.08074530f, 0.08191202f, 0.21310245f, -0.03565213f, -0.02925225f, -0.07745922f, 
    0.02435634f, -0.01011936f, -0.04635611f, -0.29195020f, 0.02759510f, -0.00260214f, 0.04145778f, 0.00675263f, 
    -0.10925848f, -0.03090673f, -0.47428903f, 0.01304194f, 0.04037121f, 0.26711762f, -0.03467907f, -0.25723681f, 
    0.03661770f, -0.04641892f, -0.37313354f, -0.11259001f, 0.01845907f, -0.47976404f, -0.01465641f, -0.15048218f, 
    0.24592628f, -0.46865577f, -0.04185390f, 0.00744235f, -0.39315990f, 0.00731933f, 0.21824805f, -0.14898308f, 
    0.09709888f, 0.03773845f, -0.14216085f, 0.09255524f, 0.04867588f, -0.00622344f, -0.05176201f, -0.10397136f, 
    0.01070421f, 0.00145231f, 0.15380366f, 0.14528766f, -0.26258254f, 0.03797309f, 0.07716074f, 0.00190407f, 
    -0.12266383f, 0.04700270f, 0.10949983f, -0.11583547f, -0.03692804f, 0.09717008f, 0.11553150f, -0.24010000f, 
    0.10243503f, 0.31814769f, -0.12489929f, 0.06301964f, 0.02309025f, -0.43189919f, -0.28285021f, 0.21515854f, 
    -0.18729727f, 0.13911888f, -0.02126241f, 0.08457980f, 0.01605943f, -0.08978933f, -0.24081054f, -0.04078941f, 
    0.30861259f, -0.07259776f, 0.12681842f, 0.18058600f, -0.25193292f, 0.18948025f, 0.04075767f, -0.47401488f, 
    0.31811324f, 0.02823652f, -0.08010949f, -0.08403424f, -0.06052248f, 0.38896877f, -0.00891308f, -0.05641092f, 
    0.04399578f, 0.04903669f, 0.18245390f, 0.27030548f, -0.16109274f, -0.09138110f, -0.31567004f, 0.06821653f, 
    0.15716605f, 0.02187020f, -0.09376657f, 0.00444285f, 0.05527997f, -0.26344752f, -0.05543160f, -0.10252228f, 
    -0.00720657f, -0.21572475f, -0.16546875f, 0.04189951f, -0.02862940f, 0.04739283f, 0.07073236f, -0.04855484f, 
    0.06318269f, -0.11667290f, -0.06688399f, -0.05440279f, -0.05853279f, -0.04284604f, 0.06754264f, -0.22606729f, 
    -0.06054376f, -0.15348667f, 0.15720399f, -0.07835987f, 0.21618958f, -0.06492323f, 0.06544676f, 0.02327744f, 
    0.33663040f, 0.02395696f, 0.21247095f, 0.03754104f, 0.02173269f, 0.00790453f, 0.04010259f, 0.22532625f, 
    -0.28276902f, -0.05603826f, -0.01429363f, 0.03371016f, 0.04699326f, -0.07044078f, 0.21929519f, -0.01479250f, 
    -0.30638516f, 0.02599496f, -0.29831874f, 0.14185362f, -0.03011914f, -0.02141485f, -0.07537889f, 0.20107515f, 
    -0.00562388f, 0.26160407f, -0.03527744f, 0.03284961f, 0.07068832f, -0.01659885f, 0.01897299f, 0.08239329f, 
    0.15535112f, -0.25537801f, -0.00495755f, 0.01701462f, 0.06135561f, -0.18426396f, 0.00461012f, -0.04826723f, 
    -0.10277713f, -0.00308401f, 0.04431783f, 0.05131226f, -0.27883950f, -0.05227602f, 0.01557876f, -0.07473782f, 
    -0.10062573f, -0.02670692f, -0.08785330f, 0.13458537f, 0.06957301f, 0.21697974f, 0.14945534f, 0.10707931f, 
    -0.00508401f, 0.05915967f, 0.21790677f, 0.03826300f, -0.02616067f, 0.18565640f, 0.24643871f, 0.08840402f, 
    -0.01298024f, -0.47345892f, 0.04923093f, -0.34630701f, -0.10217921f, -0.33606178f, -0.00537308f, 0.06626284f, 
    0.03487116f, 0.29377362f, 0.21542852f, -0.07832251f, -0.03827833f, -0.60874420f, 0.13597898f, 0.02037088f, 
    -0.28176469f, -0.08953147f, -0.06341343f, 0.05267117f, 0.03391391f, 0.27408004f, -0.04225215f, -0.04586958f, 
    -0.03127686f, 0.02862998f, 0.09425357f, -0.29542848f, -0.20666306f, 0.05206219f, 0.19803204f, -0.05917468f, 
    0.06523310f, -0.05028845f, 0.03980974f, 0.03875045f, 0.02676100f, 0.16452713f, 0.12903020f, -0.09785624f, 
    -0.02791700f, 0.17123368f, 0.18912348f, -0.02958536f, 0.23574430f, -0.00125791f, 0.01780239f, 0.03404485f, 
    0.08527134f, -0.35681590f, 0.02501335f, -0.07349820f, -0.01526268f, 0.11856274f, 0.01199506f, -0.46244344f, 
    -0.03911312f, 0.08760120f, -0.08218049f, 0.03407989f, 0.02855545f, -0.04838953f, -0.05463501f, -0.08317686f, 
    0.20124796f, -0.06559604f, -0.14378341f, -0.12573338f, -0.06662086f, -0.53503233f, -0.00909597f, 0.04340662f, 
    0.37037170f, 0.05061008f, -0.30088046f, 0.17415965f, -0.02760410f, 0.01173066f, -0.21747676f, -0.09535449f, 
    0.22944924f, -0.08252902f, 0.18916547f, -0.01627284f, -0.00551719f, 0.16354905f, 0.03917972f, -0.36687851f, 
    -0.03869693f, -0.15197362f, 0.02671603f, 0.06745169f, 0.11135456f, 0.00564495f, -0.27847275f, 0.17703751f, 
    -0.20077753f, 0.00856115f, -0.31854495f, 0.00687232f, 0.02352540f, 0.05721007f, -0.00595534f, -0.31703478f, 
    0.19914292f, -0.05569795f, 0.03419033f, -0.37248203f, -0.54018039f, -0.34816784f, -0.07469261f, -0.05727404f, 
    -0.19759119f, -0.00780104f, -0.11593097f, 0.28393623f, 0.03976787f, -0.18748064f, 0.05227163f, 0.15355185f, 
    0.27503568f, -0.40597254f, -0.65342283f, 0.20752484f, -0.04405215f, 0.21375112f, -0.53140336f, 0.12653549f, 
    -0.57509905f, -0.06091359f, 0.04634532f, -0.38492844f, -0.07505880f, -0.22559299f, 0.17871885f, -0.19363187f, 
    0.05575521f, -0.06622130f, -0.14839633f, 0.19992961f, -0.26947626f, 0.10850248f, -0.04498594f, 0.11419641f, 
    -0.18272606f, -0.04484334f, -0.08641203f, 0.04117623f, -0.03551120f, -0.39674968f, 0.00212714f, 0.27763876f, 
    -0.02348918f, 0.21433277f, -0.26511326f, 0.07385001f, 0.00190622f, 0.03101001f, 0.24987713f, -0.01411021f, 
    -0.16695306f, 0.04843032f, -0.05003825f, 0.06779916f, -0.08048208f, -0.12174363f, -0.11303698f, 0.00169296f, 
    0.02881826f, 0.04422385f, -0.15744488f, -0.07371597f, 0.06255589f, -0.07643721f, 0.26760525f, -0.21948425f, 
    0.08187802f, 0.30299923f, 0.02600047f, -0.07479947f, -0.02213749f, 0.14635201f, 0.08449413f, -0.17507716f, 
    0.03499003f, 0.11543085f, -0.60606492f, 0.02721313f, -0.01332299f, 0.06804771f, -0.07556416f, -0.01757139f, 
    -0.55879408f, -0.23680495f, -0.09663455f, -0.02247788f, -0.04512253f, 0.19773299f, 0.02607642f, 0.07113940f, 
    -0.65508783f, 0.07788903f, 0.32647005f, 0.03967004f, 0.01941527f, 0.04334473f, 0.15989210f, 0.22141975f, 
    -0.11492641f, 0.02150275f, -0.09146938f, -0.11903881f, -0.04661803f, -0.15223573f, 0.06354251f, 0.01564002f, 
    0.22721317f, -0.09844089f, -0.06295291f, -0.05158185f, 0.38555163f, 0.05590221f, 0.14604004f, -0.01851340f, 
    -0.09708919f, -0.14226149f, -0.17188521f, -0.42418396f, 0.03592836f, 0.08800788f, 0.01130858f, 0.11358836f, 
    -0.23532373f, 0.02391498f, 0.10584101f, -0.23528452f, 0.35163927f, -0.24972452f, -0.05132971f, -0.05144000f, 
    -0.06172889f, -0.04816406f, -0.23974591f, 0.07055019f, 0.02466096f, -0.14016752f, 0.23957904f, -0.22434035f, 
    0.19260792f, -0.08997835f, 0.11876992f, -0.53829825f, -0.00380290f, -0.23966789f, 0.17550090f, -0.34481403f, 
    -0.28265408f, 0.11927702f, 0.07458294f, -0.01873275f, 0.04828102f, -0.26916048f, 0.20381260f, 0.12864770f, 
    0.09202169f, -0.08790883f, -0.22830771f, -0.30723098f, 0.12059183f, 0.03773282f, -0.07725766f, 0.29362997f, 
    0.09931706f, -0.07945067f, 0.00638285f, 0.02793608f, 0.01692832f, 0.29695404f, 0.03320186f, -0.10678852f, 
    0.04711915f, 0.16319250f, 0.12446824f, 0.36424023f, 0.13765465f, -0.09612489f, -0.33538190f, -0.01572208f, 
    0.03661905f, 0.06721059f, -0.13190094f, 0.00022234f, -0.06880073f, -0.29669026f, 0.14839199f, 0.02042530f, 
    -0.02309152f, 0.00235364f, -0.32905033f, -0.00535123f, -0.18839970f, -0.07593518f, -0.22830683f, -0.00374597f, 
    -0.34801406f, 0.10731160f, -0.06215139f, 0.04026382f, -0.04731016f, -0.24406837f, 0.07226990f, -0.02034238f, 
    -0.07788081f, -0.25795013f, 0.16636440f, -0.02284873f, 0.15274239f, 0.07621925f, -0.09121476f, -0.02807228f, 
    -0.03018977f, -0.12766251f, -0.10402951f, -0.15211597f, 0.03856371f, 0.19735916f, 0.04874015f, 0.12874962f, 
    -0.10992252f, -0.29190186f, 0.08122446f, 0.22799486f, -0.00528260f, -0.11016811f, 0.02049423f, 0.06828225f, 
    0.21602054f, -0.00762131f, -0.15193418f, -0.01595804f, -0.01899607f, 0.17121631f, -0.07377691f, 0.23167636f, 
    -0.41116303f, -0.04465117f, -0.09007854f, -0.03331120f, 0.01617465f, 0.04869330f, 0.06243351f, 0.27446556f, 
    -0.00217932f, 0.12443122f, -0.03296655f, -0.04776084f, 0.02214161f, -0.14255790f, -0.09141042f, -0.08692664f, 
    0.05331539f, -0.03277171f, -0.02737514f, 0.16073775f, -0.15118054f, 0.01524505f, -0.10810953f, 0.03787574f, 
    0.29263493f, 0.04364381f, 0.08664187f, 0.33273995f, 0.00619662f, 0.07350114f, 0.04662036f, -0.17829819f, 
    0.05025896f, -0.08979400f, 0.06397213f, 0.03934932f, -0.06384990f, -0.07016035f, 0.14808734f, -0.28990155f, 
    0.16669871f, -0.13953283f, -0.00831213f, -0.21346134f, -0.00640100f, 0.28674126f, -0.02092676f, 0.25924021f, 
    0.04143110f, 0.31983671f, -0.04090060f, -0.39689922f, 0.19851142f, 0.04587473f, 0.29424873f, 0.07561195f, 
    0.11234392f, -0.04639585f, 0.01444321f, 0.03354482f, 0.07470283f, -0.13712913f, -0.01531547f, -0.29915890f, 
    0.04418423f, -0.44925669f, 0.11406235f, -0.16602418f, -0.17820574f, 0.22761425f, 0.16878425f, -0.07319289f, 
    -0.36268535f, -0.01265088f, -0.49033713f, -0.06697834f, 0.08823083f, -0.08568157f, -0.29627115f, 0.11824815f, 
    0.00575483f, 0.06080558f, -0.16991268f, -0.02401763f, 0.07354338f, 0.02105528f, -0.37154612f, -0.22920981f, 
    0.12429079f, 0.24740793f, -0.04725064f, 0.05455832f, -0.03305964f, 0.22506097f, -0.01167581f, 0.09612452f, 
    -0.09107252f, 0.21364832f, -0.16132315f, 0.01601303f, -0.00750774f, 0.04958019f, -0.00613190f, 0.05573238f, 
    0.19917753f, -0.06018947f, -0.12723778f, 0.08845114f, -0.06023290f, 0.04125028f, -0.01279746f, -0.39743939f, 
    0.15704757f, -0.42176071f, 0.17548625f, -0.04686432f, -0.01784123f, -0.42846149f, 0.17731223f, -0.30266353f, 
    -0.33068317f, 0.01366168f, 0.09477216f, -0.35434267f, -0.06577652f, 0.28463036f, 0.00627697f, 0.14962311f, 
    -0.33851773f, -0.27076340f, -0.06668083f, -0.02080207f, 0.18038671f, -0.05224022f, -0.34298450f, -0.40496618f, 
    -0.23711626f, 0.15230022f, 0.17724495f, -0.06388657f, 0.00114787f, -0.37631312f, 0.01797613f, -0.19764699f, 
    -0.05699446f, 0.03510185f, -0.00841449f, -0.56794912f, 0.16973704f, -0.27711827f, -0.00738721f, -0.01230768f, 
    -0.32902992f, -0.01598327f, 0.05715551f, 0.18828477f, 0.02518372f, 0.05128358f, 0.10074971f, -0.15031356f, 
    0.11588800f, -0.15046924f, 0.04764287f, 0.08195512f, -0.00744342f, -0.12797925f, 0.11552121f, 0.14368993f, 
    -0.04328264f, -0.45567292f, 0.03646707f, -0.09764231f, -0.05180019f, 0.18637232f, -0.30205479f, -0.22617669f, 
    -0.21960248f, -0.03620272f, -0.73144430f, 0.17836663f, -0.22566283f, -0.08127420f, -0.39507288f, -0.18431859f, 
    -0.16334136f, -0.04713261f, -0.09129839f, -0.04598404f, -0.06648270f, -0.53730017f, -0.08098333f, 0.16018802f, 
    0.03207104f, -0.07212483f, 0.23298934f, 0.01240983f, 0.09158628f, 0.07399627f, -0.20353393f, -0.02677286f, 
    0.07068096f, 0.04275351f, 0.26459947f, 0.02804338f, -0.03263092f, -0.42502239f, 0.18316761f, 0.25502419f, 
    0.02056711f, 0.20092684f, 0.11323185f, 0.00613766f, -0.45697850f, 0.01758156f, 0.08630369f, 0.29607823f, 
    -0.29430404f, 0.01554710f, 0.01157774f, -0.00194698f, 0.00048092f, 0.12752682f, -0.05969733f, 0.01793835f, 
    0.03896824f, -0.07144424f, -0.06417775f, -0.00012517f, -0.29122403f, 0.00667206f, 0.01180595f, 0.03542451f, 
    0.05085639f, 0.23614436f, -0.23091029f, 0.23143739f, -0.06697109f, -0.03014122f, -0.06300909f, -0.05490400f, 
    0.27551758f, 0.26590076f, 0.03334799f, 0.14124213f, 0.09081419f, 0.13664968f, 0.07149457f, 0.14553775f, 
    0.19160420f, -0.06522843f, 0.04241659f, 0.31363505f, 0.05193002f, -0.09777813f, -0.01540740f, 0.09982180f, 
    0.03412207f, 0.01453652f, -0.02446440f, -0.02293302f, -0.33666617f, -0.08661661f, 0.13509801f, -0.05378873f, 
    0.20664296f, 0.24589746f, 0.30787855f, -0.39292768f, -0.01044055f, 0.09931058f, 0.02473482f, 0.20795108f, 
    -0.31505516f, 0.06875994f, 0.13200240f, 0.12748019f, 0.09672874f, 0.13376805f, 0.00835322f, -0.02908739f, 
    -0.26896983f, -0.06931236f, -0.30395153f, -0.14142998f, 0.06010478f, -0.18257089f, -0.13672440f, 0.08344251f, 
    -0.09250941f, 0.19223683f, 0.43510208f, 0.08281409f, -0.08793736f, 0.15466240f, -0.34455463f, -0.13238482f, 
    -0.14702614f, -0.00732146f, -0.03102405f, -0.12335975f, -0.07294224f, 0.27984577f, 0.17862859f, -0.57937384f, 
    -0.36359623f, -0.40551811f, 0.01241983f, 0.04987514f, -0.38747954f, -0.00491215f, -0.08330730f, 0.12009570f, 
    -0.16516697f, -0.03040578f, 0.04497636f, -0.04079105f, 0.06136974f, -0.23053494f, -0.03910259f, 0.15962934f, 
    0.05299991f, -0.17023626f, 0.25168651f, -0.43415806f, 0.11313629f, -0.28929335f, 0.02615735f, 0.08728460f, 
    -0.08420687f, 0.02486650f, -0.23108673f, 0.05721348f, 0.04107249f, 0.06150606f, 0.04449484f, -0.53464723f, 
    0.07095719f, -0.60980719f, 0.03230122f, -0.04847563f, 0.19287443f, -0.03795428f, -0.40444154f, -0.38738453f, 
    -0.04751247f, 0.04273668f, -0.06340862f, -0.02822711f, -0.07940283f, -0.02844720f, 0.07161238f, 0.07334778f, 
    -0.06710991f, -0.36486921f, 0.31875026f, -0.06701956f, -0.07036478f, -0.06667603f, -0.08802488f, 0.01975684f, 
    0.20636241f, 0.25489992f, -0.45254320f, 0.16668317f, -0.02923597f, 0.06350932f, -0.00542618f, 0.06201788f, 
    0.14252308f, -0.42122373f, -0.24847263f, -0.00335187f, -0.08433712f, -0.01843129f, 0.20299476f, -0.10459633f, 
    0.07745282f, -0.03805818f, 0.22464941f, -0.17202233f, 0.01945234f, 0.23775610f, 0.03201464f, 0.18032938f, 
    -0.01688290f, 0.40041897f, -0.05617690f, 0.07522301f, -0.19777063f, 0.01160121f, 0.08424111f, 0.08039763f, 
    -0.32327196f, -0.03951599f, -0.08316202f, 0.07134933f, 0.02680104f, 0.16671191f, 0.04289722f, -0.28813106f, 
    0.06510237f, -0.04675204f, 0.30168676f, 0.20091602f, 0.09069447f, 0.22701429f, -0.00084557f, -0.07910882f, 
    0.00685782f, 0.00245995f, -0.56106043f, -0.55748147f, -0.07932536f, 0.16523342f, 0.06843711f, 0.14351538f, 
    0.01253917f, 0.09784109f, -0.36820993f, -0.26395762f, 0.03521834f, -0.08715039f, -0.26294792f, 0.02448043f, 
    0.12206920f, -0.27739176f, 0.05058625f, 0.01438363f, -0.02838076f, 0.09380929f, -0.00896197f, 0.34625405f, 
    -0.39579991f, -0.44885460f, -0.30827656f, 0.03095638f, 0.16358609f, -0.04550958f, 0.14143187f, 0.19362634f, 
    -0.10314807f, -0.05722557f, -0.05304324f, -0.04201787f, 0.06144486f, 0.06168802f, -0.04795121f, 0.01172162f, 
    -0.04380491f, 0.06757098f, -0.33101004f, -0.15621336f, 0.03890233f, 0.10095423f, -0.15928586f, -0.01030090f, 
    0.20417427f, 0.07535002f, 0.18947537f, 0.00943574f, 0.08429535f, 0.22766680f, -0.21463741f, 0.17382035f, 
    0.05108471f, -0.06887766f, -0.12569909f, 0.02646741f, 0.29044995f, -0.03470116f, -0.28164572f, -0.01032469f, 
    0.23699977f, 0.17666264f, 0.00428188f, -0.00491013f, 0.04682420f, 0.02017036f, 0.05468765f, -0.07377417f, 
    -0.01696305f, 0.16950721f, -0.12987356f, -0.01542227f, -0.17335902f, 0.08998062f, 0.04868309f, -0.07959825f, 
    -0.51071703f, 0.15385188f, -0.35142753f, 0.12964258f, 0.03196283f, 0.11654608f, -0.03743062f, -0.01780237f, 
    -0.37557518f, -0.31597212f, -0.33736083f, -0.02923113f, -0.01927892f, -0.23247431f, -0.25767606f, 0.14885063f, 
    0.07471239f, -0.05037147f, 0.20337352f, -0.12132497f, -0.00806587f, -0.24770215f, -0.09350265f, -0.27726725f, 
    0.13414383f, 0.02200477f, -0.05784165f, 0.05123854f, -0.59707272f, 0.03583916f, 0.13371147f, 0.15131280f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11622398f, 0.10098835f, -0.04828351f, 0.05342522f, -0.03705541f, 0.05907202f, 0.03554262f, -0.08015352f, 
    -0.07712783f, -0.01158529f, 0.08729403f, 0.05650284f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
