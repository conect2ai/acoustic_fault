#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.05790582f, -0.58555138f, -0.38925895f, 0.14914949f, 0.07094412f, 0.57414311f, 0.74705684f, -0.38804621f, 
    0.43437028f, 0.46924981f, -0.00476775f, -0.16544524f, -0.13782054f, 0.41766596f, -0.25503537f, -0.07927919f, 
    0.19004217f, -0.12128462f, 0.14832135f, 0.06716939f, 0.15385312f, -0.05596720f, -0.32528985f, -0.17516086f, 
    0.18770194f, 0.74901313f, 0.02264021f, -0.24004485f, 0.42923430f, 0.42949617f, 0.23796062f, 0.30519766f, 
    -0.26898542f, 0.32487464f, 0.01950442f, 0.19711457f, 0.09167663f, -0.13343360f, 0.14140579f, -0.08912792f, 
    -0.03211913f, -0.35041645f, 0.22067058f, -0.10148808f, -0.06925739f, -0.03267466f, 0.51701105f, 0.28749689f, 
    0.01046539f, 0.20433591f, 0.06993105f, -0.21201645f, -0.67927474f, -0.32790074f, -0.56154996f, 0.14820892f, 
    0.34085447f, 0.10068011f, -0.00498698f, 0.02048928f, -0.20167014f, 0.48843718f, 0.18982878f, 0.16304867f, 
    0.04863064f, -0.16478655f, -0.37846103f, 0.19968559f, 0.27241781f, -0.36282572f, -0.25294921f, 0.23519066f, 
    0.05821000f, -0.32852751f, 0.13575366f, 0.91640157f, 0.31504187f, 0.00027469f, 0.85394537f, 0.25647777f, 
    0.39886755f, -0.34049779f, -0.00930568f, -0.47160739f, -0.46316704f, -0.16472965f, -0.08101384f, -0.05443892f, 
    -0.04908432f, -0.10066863f, 0.23430704f, -0.03979273f, -0.09898213f, 0.03829582f, 0.02907444f, 0.01913767f, 
    0.01932695f, 0.13080132f, -0.25640845f, 0.14370957f, 0.77469444f, 0.50976008f, 0.53529400f, 0.51198572f, 
    0.44375890f, 0.07876044f, 0.00373709f, -0.31326151f, -0.15946990f, 0.39821890f, -0.29187155f, 0.31697652f, 
    0.17593470f, -0.28783324f, 0.10014351f, -0.24081092f, 0.14863622f, -0.04941450f, -0.26200643f, -0.03242066f, 
    0.05427684f, 0.18537487f, 0.07512111f, 0.09999551f, 0.15127884f, -0.45606467f, 0.02428951f, -0.69199067f, 
    -0.65813595f, -0.36886925f, 0.30693254f, -0.41033578f, 0.18792075f, 0.05561030f, 0.28902301f, -0.27682114f, 
    0.01435100f, 0.01748054f, -0.07646360f, -0.13481829f, -0.13637376f, 0.27222967f, -0.14113835f, 0.11213569f, 
    0.18725178f, 0.19190122f, -0.11706103f, -0.05289793f, 0.08970370f, 0.32275313f, -0.61158431f, -0.14831507f, 
    -0.20949693f, -0.63904309f, 0.07297402f, -0.33409479f, -0.59775078f, 0.03603004f, 0.41912147f, -0.05682683f, 
    0.36325410f, -0.20266809f, -0.08663953f, -0.09934278f, -0.17765479f, 0.18051441f, -0.10581283f, 0.17195539f, 
    0.10905969f, 0.03373728f, 0.02872857f, -0.21057303f, 0.20659767f, 0.07140519f, 0.06367309f, 0.46947774f, 
    0.97405761f, -0.27972731f, -0.29848322f, -0.31522158f, -0.31934360f, -0.31148842f, 0.04217424f, -0.04171323f, 
    0.07385267f, 0.12302850f, -0.09737422f, 0.05578708f, 0.18794282f, -0.09965135f, 0.00208423f, -0.32944220f, 
    -0.01473856f, 0.07748361f, 0.14125507f, 0.03759436f, 0.28396466f, -0.32249105f, -0.00432207f, 0.07626384f, 
    -0.51135004f, -0.55055171f, -0.42226940f, -0.10346888f, -0.21969804f, 0.36204070f, 0.89830738f, -0.36273953f, 
    -0.22342433f, -0.01319885f, 0.03353028f, 0.05467486f, 0.14945242f, 0.32884911f, 0.32786560f, -0.21848039f, 
    -0.20910953f, -0.06440336f, -0.01015374f, -0.37544549f, -0.03305799f, -0.10777777f, 0.20652047f, -0.04260468f, 
    -0.17344384f, 0.47521397f, 0.61345452f, 0.60069609f, -0.38160735f, 0.08239654f, 0.22802152f, 0.17221749f, 
    0.24129073f, -0.13997859f, -0.15010473f, 0.12875146f, 0.01140711f, 0.14725518f, 0.02596361f, 0.24820463f, 
    -0.05051478f, 0.21132289f, 0.34187564f, 0.17221911f, -0.34814391f, 0.06979894f, 0.08589876f, 0.19225729f, 
    0.12154604f, 0.15696767f, 0.12761971f, 0.57565975f, -0.24076934f, -0.02640539f, 0.59843111f, -0.57707059f, 
    -0.75706172f, -0.35311705f, -0.71911120f, -0.14763147f, 0.23978382f, -0.11129406f, 0.02357266f, -0.07169968f, 
    -0.13545175f, 0.23843709f, -0.20424204f, 0.10890956f, -0.09327714f, -0.06814309f, 0.03022056f, -0.15186740f, 
    -0.01413569f, -0.04120412f, -0.09329717f, 0.33634067f, 0.16539811f, 0.19238193f, 0.12995005f, -0.06890107f, 
    -0.56019413f, -0.64635938f, 0.22123456f, 0.23758696f, -0.30149546f, 0.01505250f, -0.32815427f, -0.16348381f, 
    -0.03995239f, 0.00973104f, 0.13109884f, -0.29652840f, -0.03896444f, -0.01806230f, 0.42570421f, 0.27616939f, 
    0.02715989f, -0.20302622f, 0.07983385f, -0.20651609f, 0.60045719f, 0.31952134f, 0.25932893f, -0.50785446f, 
    -0.29808587f, -0.22037737f, 0.14494082f, -0.30426857f, -0.06790375f, -0.30393806f, -0.11668914f, -0.08091090f, 
    -0.45103928f, -0.16451883f, -0.07689711f, -0.27667743f, 0.16809446f, -0.29677194f, -0.31342471f, -0.12591678f, 
    0.13038899f, -0.03562236f, 0.25199223f, 0.23904653f, -0.33910048f, 0.40362486f, 0.51569378f, 0.51003420f, 
    0.41593024f, -0.14905563f, -0.13023072f, -0.11915386f, -0.70065957f, -0.51643974f, 0.17147386f, 0.39694983f, 
    0.35656571f, 0.27130395f, 0.03484514f, -0.24877715f, 0.22406931f, -0.12220683f, 0.25013801f, 0.21740049f, 
    0.04429355f, -0.09647129f, 0.30234575f, 0.08717790f, 0.14231998f, 0.20415451f, 0.75759083f, 0.29880369f, 
    0.61999196f, 0.20559630f, -0.72482014f, -0.30679864f, -0.65136540f, 0.08159566f, 0.15823822f, 0.04185501f, 
    0.23257703f, -0.19854629f, 0.08186952f, 0.07578283f, -0.27589485f, -0.28975198f, -0.06985907f, 0.02565329f, 
    -0.14117394f, 0.17036161f, 0.05866610f, 0.03460803f, 0.22051021f, 0.16928253f, 0.11516079f, -0.23615527f, 
    -0.18569726f, 0.26359406f, 0.17820819f, -0.59909368f, 0.08627249f, 0.04945324f, -0.46903384f, -0.47760880f, 
    -0.24014875f, -0.12986058f, -0.09911061f, -0.39520109f, 0.00367466f, 0.14318986f, -0.35362908f, 0.15275061f, 
    -0.38399881f, -0.03502339f, 0.35484126f, -0.08453020f, 0.35028633f, 0.35116264f, 0.16567042f, -0.04786178f, 
    0.05319278f, 0.36755770f, -0.52283412f, -0.60264826f, 0.00750596f, 0.01218134f, 0.40333065f, -0.02690652f, 
    -0.00202199f, -0.49847174f, -0.15644902f, 0.02193854f, -0.37832588f, -0.42694789f, -0.41833842f, 0.11707390f, 
    0.11048817f, 0.19881515f, 0.20611227f, -0.37828380f, 0.16175041f, -0.31403816f, 0.03021989f, -0.15708064f, 
    0.29048073f, -0.50841188f, -1.02836132f, -0.45835847f, -0.27902660f, -0.30656466f, -0.56999642f, -0.24929507f, 
    -0.16003606f, -0.00919626f, 0.33689663f, 0.36386010f, 0.27137229f, 0.14030176f, -0.00700532f, 0.23101999f, 
    0.00706518f, 0.12973531f, -0.07539577f, 0.11428383f, 0.19397859f, 0.01868303f, -0.26272663f, -0.04825215f, 
    0.15593016f, -0.10527784f, -0.66700691f, 0.20049560f, -0.42868745f, -0.10921553f, -0.10866907f, -0.21800862f, 
    -0.19756211f, -0.16266227f, 0.15882035f, -0.02418014f, -0.09441183f, 0.09641430f, 0.34892160f, 0.16303681f, 
    -0.16367023f, 0.29141849f, 0.14054386f, 0.29622126f, -0.30003035f, -0.57354802f, -0.27166653f, -0.05462513f, 
    0.09220348f, 0.20452605f, 0.40291360f, 0.23435776f, 0.25611183f, 0.51575279f, -0.38385674f, 0.30103800f, 
    -1.01009190f, 0.56062180f, -0.15214272f, -0.55049658f, -0.54584801f, -0.10141885f, -0.00901537f, -0.03282883f, 
    0.41111887f, -0.16770056f, -0.20636827f, -0.05164563f, 0.08608928f, -0.14936525f, 0.00934310f, -0.05977713f, 
    -0.00873883f, 0.12974305f, -0.11886517f, -0.14484328f, -0.31439227f, -0.41758975f, -0.50791025f, -0.55673933f, 
    -0.55117702f, 0.43395007f, 0.00419861f, 0.30105042f, 0.15441610f, 0.01666791f, 0.26114562f, -0.03938549f, 
    -0.15882324f, 0.25528663f, 0.17533080f, 0.16845621f, 0.13686667f, -0.06018027f, -0.13175219f, 0.08601749f, 
    -0.01738565f, -0.12497283f, 0.30957183f, -0.19850175f, 0.16181380f, 0.84245437f, 0.38345423f, 0.48646694f, 
    -0.39972788f, 0.05476701f, 0.31292149f, -0.56791002f, 0.47424924f, 0.11878183f, 0.47196120f, 0.32382947f, 
    -0.03741105f, -0.36758628f, -0.02590756f, -0.17691235f, 0.31679577f, -0.05445601f, -0.28966224f, -0.00736096f, 
    -0.03350096f, 0.17423704f, -0.06339914f, 0.03903592f, 0.11675975f, -0.07187035f, -0.08194876f, -0.33235243f, 
    -0.69434077f, 0.15185741f, 0.48002136f, -0.34958699f, -0.71640742f, 0.01863075f, 0.25922117f, 0.05970365f, 
    -0.53643441f, -0.24902546f, 0.19282532f, 0.01466702f, -0.35065213f, 0.09572528f, 0.07351068f, -0.04672016f, 
    0.23322177f, 0.01462249f, -0.16592503f, 0.04690250f, 0.05141873f, 0.08721776f, -0.23431312f, -1.07003129f, 
    0.97977483f, 0.17629564f, -0.48531693f, -0.05941601f, 0.48820823f, 0.46017849f, 0.22953047f, 0.34159052f, 
    0.36530739f, -0.18922976f, -0.19527051f, -0.02345681f, -0.11003336f, 0.29820403f, -0.05964777f, 0.08713325f, 
    0.08817284f, 0.08713613f, -0.00826496f, 0.02788069f, 0.32889548f, -0.04176354f, 0.19053671f, 0.12812316f, 
    0.20927489f, -0.77903408f, 0.12579139f, -0.47843274f, -0.36475617f, 0.16416906f, -0.15849230f, 0.41666079f, 
    0.31768981f, 0.53005946f, 0.12736057f, -0.11504152f, -0.12142961f, 0.22556187f, -0.37227222f, 0.07743520f, 
    0.10236600f, 0.24415088f, 0.23070192f, 0.19826362f, -0.21025659f, 0.19921719f, 0.11589786f, -0.18499659f, 
    -0.02053177f, -0.18129957f, 0.45242077f, -0.41213244f, -0.42622465f, -0.38385835f, 0.10535800f, 0.16303298f, 
    -0.19847494f, 0.34348291f, -0.00659733f, -0.03258433f, -0.07573199f, -0.40940335f, 0.21006241f, -0.13206080f, 
    -0.05219549f, 0.12847352f, 0.00174368f, 0.00194402f, 0.00164150f, -0.33860570f, 0.05685610f, -0.17247674f, 
    -0.22727561f, -0.36625618f, 0.78880066f, 0.04816593f, 0.69250625f, 0.41548082f, 0.60795712f, 0.44099149f, 
    -0.16093893f, -0.37048224f, 0.43845102f, -0.20202994f, -0.08790064f, 0.03900736f, 0.01358057f, 0.24426001f, 
    0.09149703f, 0.18028936f, 0.11441909f, -0.01613753f, 0.08444005f, 0.00655771f, 0.24605180f, 0.11979325f, 
    0.00096943f, -0.11298984f, 0.07433647f, 0.01032377f, 0.13748252f, -0.61044931f, -0.82950187f, 0.01501833f, 
    -0.20988174f, 0.73753577f, 0.48250672f, -0.24669698f, 0.25397313f, -0.04236786f, -0.25957504f, -0.33853441f, 
    -0.35735971f, -0.00413877f, -0.09919307f, 0.14924616f, 0.02976395f, 0.16287942f, 0.16530590f, -0.05988180f, 
    -0.11369224f, 0.15411443f, -0.49518442f, -0.05275562f, 0.41445804f, -0.47159460f, -0.19263408f, -0.17867255f, 
    0.07060429f, 0.40841895f, 0.62185729f, 0.26651537f, 0.39947218f, 0.43648925f, -0.45028111f, -0.00112381f, 
    -0.17986530f, 0.01921619f, 0.03833229f, -0.12903523f, -0.12685269f, -0.37164655f, -0.15371282f, -0.08916442f, 
    -0.05334526f, -0.08879874f, 0.29697642f, 0.05947826f, -0.17757697f, 0.68038583f, 0.56213492f, 0.26662818f, 
    0.46673641f, -0.24209653f, 0.07719191f, 0.13179871f, 0.29773933f, 0.49146861f, 0.19918701f, -0.30535910f, 
    -0.04834704f, 0.06024778f, -0.26054385f, 0.05804722f, 0.18559825f, 0.28348863f, -0.13310985f, 0.17366743f, 
    -0.17165008f, -0.12347192f, -0.35873967f, 0.09943283f, -0.10641967f, -0.07561713f, 0.92922342f, 0.42604077f, 
    -0.55735797f, -0.43378183f, -0.28601027f, 0.23998187f, -0.06930567f, 0.18694203f, 0.39107391f, 0.33296534f, 
    -0.09439439f, 0.57552731f, -0.12738837f, 0.18636407f, 0.15608124f, -0.23313463f, -0.07150134f, -0.07634275f, 
    0.13523322f, 0.12722947f, -0.32981262f, -0.10668918f, -0.05832789f, -0.10540445f, 0.26566067f, -0.52630579f, 
    -1.06678832f, -0.13410868f, 0.48947105f, 0.38538671f, -0.70239854f, 0.79914230f, 0.40708268f, -0.39268592f, 
    -0.15162741f, 0.25473875f, -0.12949824f, 0.11520228f, -0.02916548f, 0.05717624f, -0.08830693f, 0.12469880f, 
    0.02695045f, 0.02723856f, -0.09862996f, 0.02394495f, 0.04276809f, -0.12243046f, -0.15531237f, -0.12089715f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22044966f, 0.05097583f, 0.12730297f, -0.00696622f, 0.30595329f, 0.17699216f, -0.01535819f, 0.27943277f, 
    0.03854162f, 0.10519533f, 0.27248290f, 0.14570059f, 0.05148288f, 0.25888097f, 0.20915702f, 0.16277848f, 
    0.07858433f, 0.23317409f, 0.21443444f, 0.18482174f, 0.13180056f, 0.25969842f, 0.10880030f, -0.10232851f, 
    0.11568314f, -0.01929117f, 0.13397016f, -0.03907957f, 0.10712162f, 0.07279161f, 0.02999022f, 0.03947100f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.47144714f, 0.22479965f, 0.11246064f, 0.09978651f, -0.11923885f, -0.08870036f, 0.01468544f, -0.10168206f, 
    0.02884340f, -0.02873180f, 0.05723473f, -0.00783591f, -0.05594514f, 0.26208088f, 0.02308759f, -0.07776222f, 
    -0.09048208f, 0.06576093f, -0.02962447f, -0.05752312f, -0.11757553f, -0.12212305f, -0.10574070f, -0.08018182f, 
    -0.08822668f, 0.08160321f, -0.03628042f, 0.10335129f, -0.05737224f, 0.09177648f, -0.01457114f, 0.07129139f, 
    0.08615641f, 0.14675248f, -0.02965921f, 0.03166994f, 0.20737916f, 0.37869003f, 0.16463640f, 0.20449330f, 
    -0.01139065f, 0.06465945f, 0.05575241f, -0.02262787f, -0.01779591f, -0.05291092f, 0.07467379f, 0.09300689f, 
    -0.11097541f, -0.05494404f, 0.15872310f, 0.03971690f, -0.00349126f, -0.10840873f, -0.10512269f, 0.00340937f, 
    -0.05057736f, 0.05031744f, -0.10307047f, 0.12050218f, 0.20721875f, 0.04871356f, 0.02534734f, 0.27981967f, 
    0.20539336f, 0.03493965f, 0.00319669f, -0.00952093f, -0.08187274f, -0.06907323f, 0.05226510f, 0.02997433f, 
    0.04834064f, 0.15728560f, -0.00561984f, 0.35044217f, 0.07658767f, -0.03762175f, 0.01442367f, -0.03056725f, 
    0.11573225f, -0.08343160f, 0.11557044f, 0.01357532f, -0.04683436f, 0.09580670f, -0.12053290f, -0.05138484f, 
    0.02441939f, -0.08383979f, -0.00854785f, -0.11294528f, -0.11182702f, -0.05461649f, 0.11972107f, -0.09325650f, 
    -0.37756479f, 0.18092881f, 0.10699882f, -0.07862667f, 0.03743716f, 0.06329851f, 0.06499061f, 0.16731288f, 
    0.00103691f, 0.10719082f, -0.00104701f, 0.07781101f, 0.15064478f, -0.00117972f, 0.07225353f, 0.01514020f, 
    0.14669977f, 0.04011068f, 0.03813979f, -0.08296562f, -0.05236333f, -0.01784240f, -0.00315996f, -0.00237183f, 
    -0.29986241f, -0.15014790f, 0.05689357f, 0.27139744f, -0.04103830f, -0.09492837f, -0.07099687f, -0.03768059f, 
    -0.01766342f, -0.09216213f, 0.01591015f, -0.11309584f, 0.24965873f, -0.16870463f, -0.09577855f, -0.01508779f, 
    -0.07948612f, -0.00985336f, -0.01427507f, -0.21108367f, 0.02169167f, 0.07650148f, 0.08563130f, -0.18194702f, 
    -0.02393263f, -0.10256918f, 0.04869884f, -0.02547942f, -0.03572223f, -0.04559169f, -0.10324725f, 0.02903946f, 
    0.05961539f, 0.05848835f, -0.04959845f, 0.04147717f, -0.23457620f, -0.03664619f, -0.00107357f, 0.17857386f, 
    -0.09324826f, -0.08209893f, -0.11151080f, 0.02702408f, 0.07753439f, -0.12827227f, -0.03175022f, 0.04442394f, 
    0.03538216f, -0.13231473f, -0.04113658f, -0.10523421f, -0.14422064f, 0.14801063f, -0.02921873f, -0.12234579f, 
    0.01789710f, 0.02226430f, 0.01770998f, -0.03353891f, 0.01070815f, 0.00013935f, 0.00496277f, -0.05422096f, 
    0.03033699f, 0.03965525f, -0.10223935f, 0.03308366f, -0.07955516f, -0.23576841f, 0.00724848f, 0.03913480f, 
    0.20135218f, 0.15062597f, 0.10734629f, -0.06053428f, 0.05190406f, -0.00080785f, -0.02279702f, 0.04398098f, 
    0.02083441f, 0.19553217f, 0.01609432f, -0.01066414f, -0.00124722f, -0.02446765f, -0.02496639f, 0.14657237f, 
    -0.01999013f, 0.05489927f, -0.00789980f, 0.09309813f, 0.08617742f, 0.07277788f, -0.00748670f, -0.01537931f, 
    0.06459183f, -0.03969101f, 0.19172853f, 0.03363226f, 0.11917830f, 0.09550384f, -0.00374490f, 0.14890273f, 
    -0.02171090f, 0.10156082f, -0.03692541f, 0.09494934f, 0.02513257f, -0.18524714f, 0.19778968f, 0.08057618f, 
    -0.07193449f, 0.07980226f, 0.01681561f, -0.08386286f, -0.02285660f, 0.01127877f, 0.05800332f, -0.00972976f, 
    0.05594632f, 0.11258280f, 0.04058660f, 0.21120141f, 0.09607132f, 0.11186028f, 0.04901164f, 0.07797468f, 
    -0.01985920f, -0.04978565f, -0.02552625f, 0.06209509f, 0.00142118f, -0.11987060f, -0.22697879f, -0.14652759f, 
    -0.00304303f, 0.05279743f, -0.09738655f, -0.04461001f, 0.13118780f, -0.03707395f, -0.12500146f, 0.02597092f, 
    0.25872770f, 0.04660879f, 0.10598879f, 0.24603291f, 0.06983835f, 0.08644158f, -0.17598201f, -0.01960559f, 
    -0.02005848f, 0.06442241f, 0.08815093f, -0.03699607f, 0.39895380f, 0.18615107f, 0.13462259f, 0.08345752f, 
    0.17981866f, -0.09750541f, -0.01728707f, -0.01910827f, 0.01285108f, -0.07849523f, -0.07105908f, -0.02623910f, 
    -0.03384027f, 0.13074958f, 0.04094778f, 0.01811470f, -0.11789515f, 0.11057174f, -0.07714383f, 0.05588389f, 
    0.05430018f, -0.00103840f, -0.04056551f, 0.06486322f, 0.22555988f, 0.32608598f, -0.03954245f, 0.04441464f, 
    0.01779205f, 0.08189365f, 0.00758287f, 0.09336322f, 0.00408950f, 0.00615862f, 0.04678737f, 0.15087348f, 
    0.18748111f, 0.11686109f, -0.03516004f, 0.07674089f, 0.12138059f, 0.05680200f, 0.08753463f, -0.05448011f, 
    -0.03686044f, -0.03112995f, -0.12333194f, 0.01041904f, -0.15831824f, 0.11678511f, 0.16868043f, 0.32629490f, 
    -0.00828512f, 0.09647830f, 0.06282345f, -0.11726407f, 0.00155242f, -0.01397587f, 0.05612574f, 0.07321083f, 
    -0.13373400f, 0.18203099f, -0.10099231f, 0.05826006f, -0.04889388f, 0.00251604f, -0.01958716f, 0.01590483f, 
    -0.00923488f, -0.04110050f, -0.03487720f, -0.08253780f, 0.17805772f, 0.08094870f, 0.08872588f, -0.01598598f, 
    -0.10268383f, -0.02530214f, 0.02291801f, 0.01574161f, -0.10053444f, 0.17913337f, 0.02732481f, 0.17148234f, 
    0.05613735f, 0.14463127f, -0.09322131f, -0.08602194f, -0.06419660f, 0.05309870f, 0.07592094f, 0.04532634f, 
    -0.04327575f, -0.04031862f, -0.00462391f, -0.08391728f, -0.29606915f, -0.09437976f, 0.11376561f, -0.19130406f, 
    0.08481956f, -0.01023761f, 0.08565386f, 0.03967297f, -0.08727204f, 0.02139373f, -0.06632947f, -0.00506785f, 
    -0.00726057f, -0.12598978f, 0.05406823f, -0.04439580f, 0.19627582f, -0.00105594f, -0.05267565f, 0.12776946f, 
    0.01224882f, 0.16893806f, -0.02406471f, -0.04317204f, 0.10095119f, 0.20691153f, 0.01242371f, 0.15641677f, 
    0.00939034f, -0.07898222f, 0.08366088f, -0.02306596f, -0.09897973f, 0.01459325f, -0.12485957f, -0.00835444f, 
    -0.31294611f, -0.00091483f, 0.08783037f, -0.24343747f, 0.00248073f, -0.01389515f, 0.15445803f, -0.05654812f, 
    0.01662658f, -0.01847342f, -0.19114062f, 0.08145266f, 0.03296158f, 0.10673042f, 0.04643869f, 0.08771002f, 
    -0.01291008f, 0.07042746f, -0.17702998f, 0.03406225f, -0.07066461f, 0.03311738f, -0.00715756f, 0.04948948f, 
    0.31464383f, 0.29510772f, 0.23134120f, 0.21973108f, -0.13891889f, -0.02767426f, 0.05702857f, 0.03084264f, 
    -0.06043463f, 0.03661681f, 0.00100067f, 0.07411473f, 0.00981293f, -0.28556836f, -0.06138978f, -0.28321257f, 
    0.09185428f, -0.11316742f, 0.05027278f, 0.06325745f, 0.03257038f, 0.05861698f, 0.03627713f, -0.07457423f, 
    -0.09934874f, -0.32098126f, -0.22401425f, 0.08263964f, 0.03821095f, 0.00751338f, -0.15164675f, 0.11547428f, 
    0.20809734f, -0.01445537f, -0.01954024f, -0.07334772f, -0.09875095f, -0.06450218f, 0.31605914f, -0.19865470f, 
    -0.07241777f, -0.03298149f, 0.20373969f, -0.17203276f, -0.06365000f, 0.01169727f, -0.04795344f, 0.03560824f, 
    -0.13912193f, -0.13442035f, -0.02902534f, -0.25809190f, 0.11545000f, 0.07084370f, -0.10198376f, -0.00260603f, 
    0.16123706f, 0.05897237f, -0.05584453f, -0.04405694f, -0.01840268f, 0.24387586f, 0.16147888f, -0.14693920f, 
    -0.09495476f, -0.01609890f, 0.01914693f, -0.06273173f, -0.06248942f, -0.03114881f, -0.06155432f, 0.02623663f, 
    0.09568664f, 0.03432305f, 0.37076750f, -0.06904717f, -0.18868306f, -0.08398010f, 0.10551961f, -0.11519346f, 
    0.10905886f, 0.09263055f, 0.06046829f, 0.02828745f, 0.01696028f, 0.08546458f, 0.10208695f, 0.18640774f, 
    -0.06154990f, -0.00032187f, -0.03925434f, 0.06507361f, -0.02584181f, -0.08278697f, 0.00698013f, 0.00761267f, 
    -0.09650379f, 0.13567966f, 0.01763204f, -0.02954754f, -0.09831389f, 0.02498538f, 0.04928116f, -0.15860993f, 
    0.01304180f, -0.05038182f, 0.16646808f, 0.02206853f, 0.00514483f, 0.32478121f, 0.28470024f, 0.05682841f, 
    -0.20151946f, 0.01019811f, -0.00060318f, 0.06930258f, 0.03665618f, 0.14883952f, -0.11152664f, -0.02509110f, 
    0.04519182f, 0.24593423f, 0.14914483f, 0.23164032f, -0.10676015f, -0.06725138f, 0.02669228f, 0.01752711f, 
    -0.05307733f, 0.01935641f, -0.03581229f, 0.05532337f, -0.37291738f, -0.02798628f, -0.02500493f, -0.01106722f, 
    -0.02846023f, 0.07387007f, -0.13629313f, -0.21463688f, -0.00796357f, -0.01081701f, 0.09031876f, 0.04479156f, 
    -0.08859654f, 0.03535587f, 0.12727688f, -0.05538326f, 0.10676593f, -0.04326789f, 0.04265319f, -0.04358157f, 
    -0.03142009f, 0.02294608f, -0.08679018f, 0.09278718f, -0.08600209f, -0.54562443f, -0.07481847f, -0.02507327f, 
    -0.04039135f, -0.01134163f, 0.01318309f, 0.01201562f, 0.04718604f, 0.06467391f, -0.01453485f, -0.08235254f, 
    -0.10223033f, -0.17699914f, -0.10524951f, -0.10592601f, 0.00727900f, 0.00069588f, 0.00362285f, 0.09116477f, 
    0.05439665f, 0.06815912f, -0.18198800f, -0.06646772f, 0.11661505f, 0.36181593f, -0.05491308f, -0.06325615f, 
    -0.11728366f, -0.05962079f, -0.13201906f, -0.11712227f, 0.11939447f, 0.02529558f, 0.02318512f, 0.02687817f, 
    -0.07707875f, -0.22225775f, -0.14281493f, -0.26600218f, 0.01614621f, 0.09547529f, 0.11628084f, 0.18064973f, 
    0.13054970f, -0.07281727f, 0.01106569f, -0.14483310f, 0.36315128f, -0.00502837f, 0.30393249f, -0.17682551f, 
    0.04618895f, -0.11816501f, 0.10265204f, 0.03402680f, 0.08369734f, 0.00322683f, 0.20333380f, -0.06989030f, 
    -0.21458095f, -0.23621987f, 0.05600385f, 0.11240990f, -0.01027613f, 0.01027942f, 0.11227935f, 0.00923050f, 
    0.08052940f, 0.12605309f, -0.02937913f, 0.04641959f, 0.52668577f, -0.17874725f, 0.06181496f, -0.15147310f, 
    -0.05760393f, 0.09145975f, 0.23458508f, -0.01618078f, -0.02919633f, -0.01831066f, -0.05061984f, 0.07447508f, 
    0.05267623f, -0.11106230f, 0.04802471f, -0.11606012f, 0.19128086f, 0.03351046f, 0.03761150f, 0.01823270f, 
    0.00045013f, 0.03669016f, -0.02239941f, -0.01437899f, -0.08031972f, -0.14391625f, -0.00368912f, -0.20273151f, 
    0.01525705f, 0.10402390f, 0.19735138f, 0.08594336f, 0.03039982f, 0.04405754f, 0.00868638f, -0.10617734f, 
    0.37892845f, 0.24000232f, 0.07408226f, 0.10613701f, 0.01348781f, -0.06429438f, -0.12329800f, 0.00341916f, 
    0.07359567f, 0.02663617f, -0.12799437f, 0.10945871f, -0.12373377f, -0.14584091f, 0.04005294f, -0.24949184f, 
    0.07851132f, -0.03303431f, 0.04228899f, 0.22231548f, -0.09066889f, -0.04171348f, 0.15737529f, 0.05151101f, 
    0.05775836f, 0.07974099f, 0.10258642f, 0.02717252f, 0.19505364f, 0.06223132f, 0.03482795f, 0.11273178f, 
    -0.00178810f, 0.01268570f, 0.13688529f, 0.11469070f, -0.01617603f, 0.13788083f, -0.07388815f, 0.25899523f, 
    -0.05743597f, 0.05586835f, 0.07641619f, 0.14009844f, 0.10510278f, -0.00811128f, 0.14226599f, -0.03277955f, 
    0.26092547f, -0.03922062f, 0.30359286f, -0.23107511f, -0.02780719f, -0.06941479f, 0.20924923f, 0.08271765f, 
    -0.06857094f, 0.02164382f, 0.14584480f, -0.01048823f, 0.17175411f, 0.09529375f, -0.23108651f, 0.14402908f, 
    0.01916471f, 0.10509936f, -0.08899992f, 0.00870573f, 0.09054308f, -0.06149807f, 0.00842503f, 0.00445060f, 
    -0.03831631f, 0.02995013f, -0.03158765f, -0.05239281f, -0.02792005f, 0.03170085f, -0.04381063f, -0.00407760f, 
    -0.02416594f, -0.05585418f, -0.01667076f, -0.04929348f, -0.03968995f, -0.01550559f, -0.01068141f, -0.00613778f, 
    -0.03324566f, 0.00059426f, -0.00202075f, 0.02760616f, -0.00960791f, -0.00221302f, -0.04679313f, 0.02583392f, 
    -0.02192840f, -0.00566765f, -0.02231806f, -0.04619602f, -0.02886814f, 0.01488475f, 0.03286598f, -0.02556052f, 
    -0.00515827f, 0.03435973f, 0.03348728f, -0.00366293f, -0.03470119f, -0.02744584f, -0.03006167f, -0.01290075f, 
    -0.02484430f, 0.04176285f, 0.04114578f, -0.03204408f, 0.03727695f, -0.02289146f, 0.00199419f, -0.00587049f, 
    -0.01822277f, -0.04126389f, 0.04035845f, -0.02434298f, 0.01140990f, 0.04439749f, 0.00652251f, -0.02282717f, 
    0.03211777f, -0.01707934f, -0.02002407f, -0.03197371f, 0.01696624f, -0.02512380f, -0.00173394f, -0.01488991f, 
    -0.04201054f, -0.03723567f, -0.02376535f, 0.01815599f, -0.04321336f, -0.02601066f, 0.01552242f, -0.03173335f, 
    0.00906693f, 0.02306833f, -0.00854764f, -0.00426449f, -0.04684197f, 0.01030265f, 0.00179240f, 0.01295766f, 
    0.02403004f, -0.00045974f, -0.02519096f, 0.01159501f, 0.03775530f, -0.02797569f, -0.01074048f, 0.01661848f, 
    0.03419814f, 0.01917354f, -0.01546276f, -0.01172843f, 0.02703575f, -0.04563158f, 0.01391462f, -0.02131342f, 
    -0.03488914f, -0.03748491f, -0.00310074f, 0.03757493f, 0.03073575f, 0.03460431f, 0.00227079f, 0.00312815f, 
    0.03102781f, -0.00707940f, 0.02158918f, 0.04414207f, -0.03568534f, -0.01326862f, 0.01925049f, -0.02433510f, 
    -0.02551397f, -0.02487113f, -0.03383526f, -0.05229543f, 0.02769820f, 0.01337083f, 0.03628276f, 0.02092621f, 
    0.02315632f, -0.00551881f, -0.04569123f, -0.03971792f, -0.01855137f, 0.02656371f, 0.01107030f, 0.04292282f, 
    -0.02233857f, -0.00348730f, 0.02114983f, -0.03116537f, -0.01056404f, -0.04027230f, -0.00662033f, -0.02497909f, 
    -0.05248445f, 0.04227322f, 0.02983587f, -0.05405914f, -0.01883498f, -0.03709778f, 0.03031466f, -0.00246588f, 
    0.03087983f, -0.03896964f, -0.03785133f, -0.00965169f, -0.01031025f, 0.03370065f, 0.01809343f, -0.01608311f, 
    -0.02658945f, -0.03635486f, 0.00310547f, 0.00806801f, -0.00760086f, 0.01594049f, 0.01210732f, -0.00532147f, 
    0.02350738f, -0.00928970f, 0.01947238f, 0.02941853f, -0.03318281f, -0.00136414f, 0.02337764f, -0.00311401f, 
    -0.01654385f, 0.04528533f, 0.01919213f, 0.01690586f, -0.01923801f, -0.03278138f, 0.00480621f, 0.01085139f, 
    0.04329829f, -0.02009022f, -0.03317030f, -0.01938664f, -0.01223437f, 0.00545720f, 0.01568394f, 0.02846244f, 
    -0.04888239f, 0.03788492f, -0.00367878f, -0.02786629f, -0.02113710f, 0.03509326f, -0.00630085f, 0.03352709f, 
    0.02489298f, -0.05164985f, -0.01241364f, -0.00933840f, -0.02105584f, -0.01568887f, 0.02729071f, -0.04211180f, 
    -0.02835755f, 0.03527826f, 0.00752161f, 0.00706715f, 0.02869083f, 0.03755810f, 0.01017827f, -0.03461091f, 
    -0.01560290f, -0.03140256f, -0.02403133f, -0.05123046f, -0.01555681f, -0.03568671f, -0.02982604f, -0.01182933f, 
    -0.00448621f, -0.04393888f, 0.00535963f, 0.02255637f, 0.04093685f, -0.00313027f, -0.01634288f, -0.01547674f, 
    0.03143671f, 0.04235268f, -0.05452802f, -0.04464456f, -0.03595655f, 0.03170233f, -0.04779890f, -0.03624105f, 
    0.04449323f, 0.01925582f, 0.03114386f, -0.04519921f, -0.04196690f, -0.04824868f, -0.03535332f, -0.03270893f, 
    -0.03688653f, 0.01235092f, 0.03085327f, -0.03611667f, -0.02773289f, -0.01564161f, 0.03198509f, -0.04234825f, 
    -0.05629673f, 0.03502929f, 0.00785029f, 0.01620430f, -0.00158248f, -0.02692710f, -0.04663861f, 0.01915127f, 
    0.01321867f, 0.00976303f, -0.03308250f, 0.01081799f, -0.04879599f, 0.00690204f, 0.01713989f, 0.01326305f, 
    -0.05329122f, -0.05543785f, -0.04920755f, -0.03927286f, 0.04574337f, 0.02422234f, 0.03305300f, -0.04766151f, 
    0.01618038f, -0.02152507f, 0.02654791f, -0.01728117f, 0.03483181f, -0.00580115f, 0.04214136f, 0.03441233f, 
    -0.04323367f, -0.05064463f, -0.04141086f, 0.00072243f, 0.04592695f, -0.04862978f, -0.04180240f, -0.01818720f, 
    -0.05706825f, 0.03233065f, -0.02250384f, -0.04906898f, -0.00446197f, -0.02264014f, -0.04559943f, 0.02670266f, 
    0.00636076f, 0.02372678f, 0.00579698f, 0.02558242f, 0.02178777f, -0.02296885f, 0.03612729f, -0.00385863f, 
    -0.03181303f, 0.03103042f, -0.05440321f, 0.01850419f, -0.02237991f, -0.01807025f, 0.01951250f, 0.04519395f, 
    -0.02471270f, 0.01001275f, 0.03259083f, 0.03039717f, -0.03509534f, -0.00073474f, -0.05151236f, -0.02555471f, 
    -0.04710333f, 0.00751634f, -0.00662164f, -0.03063817f, -0.02484512f, 0.02894490f, 0.02466667f, -0.05255749f, 
    0.00244596f, -0.00866963f, 0.03206792f, 0.04254030f, 0.01037015f, -0.03287396f, -0.03955938f, -0.01463901f, 
    0.04338622f, -0.02293400f, 0.04077501f, -0.05159145f, -0.02964859f, 0.00890824f, 0.02738889f, 0.02775328f, 
    -0.01293747f, 0.02043676f, 0.03677890f, 0.02824060f, 0.00036188f, 0.03302797f, -0.01433682f, -0.01878453f, 
    0.00020962f, -0.00806414f, 0.02506614f, -0.01602973f, -0.02361268f, 0.00398125f, -0.01041489f, 0.04335350f, 
    0.02905720f, -0.03004983f, -0.05466772f, 0.01765704f, -0.02350571f, 0.01974582f, 0.03192473f, -0.00245723f, 
    0.03611061f, -0.04591503f, -0.04395694f, -0.03417210f, -0.04188824f, -0.00854656f, 0.04620686f, -0.05574999f, 
    -0.03985985f, -0.01375800f, 0.01768288f, -0.01652583f, 0.03386869f, -0.01442226f, 0.02305974f, 0.01530295f, 
    0.03017157f, -0.03208273f, 0.01191378f, -0.00540653f, 0.03670347f, 0.03616406f, -0.00023524f, -0.01914923f, 
    -0.03562103f, -0.04222010f, -0.02032395f, -0.03583280f, 0.00047833f, 0.01551238f, -0.04794008f, -0.04133929f, 
    -0.01165980f, -0.01156932f, -0.03142857f, -0.05093222f, 0.00022329f, 0.03707470f, 0.01634686f, 0.02064817f, 
    -0.02922966f, -0.01150103f, 0.01905530f, 0.03640220f, -0.02300706f, -0.03092494f, -0.05624704f, 0.00559217f, 
    -0.02224284f, 0.00595441f, -0.01701524f, 0.02366070f, 0.01915678f, -0.06165481f, -0.02323054f, 0.03824276f, 
    -0.02466046f, 0.02895615f, -0.02688585f, -0.05844430f, -0.04275685f, -0.03324239f, 0.03179247f, 0.02037152f, 
    0.02069359f, 0.00000303f, -0.01226149f, -0.04339586f, -0.02492537f, 0.01418634f, 0.02091331f, 0.01033324f, 
    0.03502110f, -0.01195708f, 0.03803890f, -0.05463257f, -0.02628969f, 0.01726958f, -0.01039127f, -0.05537795f, 
    0.03928633f, -0.02771951f, -0.04752403f, -0.00380850f, 0.02442148f, 0.01547332f, -0.03235713f, -0.03410936f, 
    0.04152372f, -0.03423419f, 0.02662256f, 0.02619382f, -0.02389780f, 0.03498254f, 0.03815102f, -0.02080071f, 
    0.04123458f, -0.01706869f, -0.02700323f, -0.05176402f, 0.02759775f, -0.04765338f, 0.02754505f, -0.05452321f, 
    -0.02214945f, 0.02171100f, 0.01744085f, -0.04220128f, -0.03352094f, 0.04270959f, 0.02349878f, 0.04096485f, 
    -0.03265711f, -0.00757005f, -0.00481178f, -0.03551454f, 0.01986695f, -0.00719633f, 0.04258034f, 0.02479596f, 
    0.04379618f, 0.00015048f, -0.00294255f, -0.01817053f, -0.02971911f, 0.04781569f, 0.04019687f, 0.03439215f, 
    -0.00684769f, 0.00953493f, 0.02468322f, 0.01569195f, 0.00751901f, -0.05366994f, -0.02405775f, -0.05331471f, 
    -0.04030664f, -0.01665871f, 0.02553119f, -0.05503683f, -0.04259772f, -0.04382872f, -0.01403339f, -0.02181502f, 
    0.00259097f, 0.04341788f, -0.03392082f, 0.00476983f, -0.00713615f, 0.02780504f, -0.01771519f, -0.00588673f, 
    -0.01252224f, 0.01326493f, 0.01798018f, 0.01966317f, 0.01053889f, -0.04485289f, 0.02720150f, 0.00548362f, 
    0.02371384f, 0.00290345f, -0.04375711f, -0.05966484f, 0.04232573f, -0.01079547f, 0.00934225f, -0.03639235f, 
    -0.04353206f, -0.03066998f, -0.00347865f, -0.02370166f, -0.01636037f, -0.04757532f, -0.03907560f, 0.03936708f, 
    0.02454618f, -0.04960049f, 0.01431998f, -0.03720863f, -0.02566459f, 0.02611086f, 0.02843451f, 0.02919066f, 
    0.00523833f, 0.01251303f, -0.04183695f, -0.02080260f, -0.03478558f, -0.01604222f, -0.00078091f, -0.01144986f, 
    -0.02392556f, -0.04068545f, 0.01979460f, 0.04361549f, 0.01120972f, -0.02210660f, -0.01486877f, 0.00083407f, 
    0.02452254f, -0.03112408f, 0.03939037f, -0.02263627f, -0.05651567f, -0.02347897f, 0.01666088f, -0.01131348f, 
    0.00065543f, -0.03127391f, -0.04640497f, 0.02327879f, 0.02070636f, -0.02260155f, -0.00374824f, 0.03663237f, 
    -0.04431176f, 0.00561597f, 0.00439735f, -0.00518112f, -0.01162529f, 0.01675021f, -0.04111536f, -0.05815219f, 
    -0.04756051f, -0.05510103f, 0.03848554f, -0.00448453f, -0.05550322f, 0.01879559f, -0.02066523f, -0.00562983f, 
    -0.01292521f, -0.03088102f, -0.02536567f, -0.05385383f, 0.02320912f, 0.04705654f, 0.02721029f, -0.03121292f, 
    -0.00045826f, -0.04335436f, -0.02080823f, 0.00046622f, 0.02746910f, -0.05392409f, 0.02811078f, 0.03645271f, 
    -0.00580694f, 0.02675528f, 0.00217472f, 0.04161150f, -0.04094608f, -0.04581030f, 0.02524015f, -0.03675247f, 
    0.03821692f, -0.00238675f, -0.04978652f, 0.03563966f, 0.00387154f, -0.01631584f, 0.01431316f, 0.01167529f, 
    -0.01084842f, 0.01802225f, 0.03535852f, -0.00943238f, -0.01220674f, 0.03806473f, -0.00013965f, 0.00614403f, 
    0.01648756f, 0.02532055f, 0.01030008f, -0.02419104f, -0.03805963f, -0.00505239f, -0.05388118f, -0.03609245f, 
    0.00562700f, -0.04661853f, -0.03069238f, 0.03806828f, 0.03029096f, 0.00256191f, 0.02533416f, 0.02273970f, 
    -0.00210845f, -0.01326890f, -0.01912887f, 0.03905331f, 0.02380678f, -0.02684817f, 0.00600013f, 0.01068789f, 
    0.01221650f, -0.05407768f, -0.05092733f, 0.01919848f, -0.01431596f, 0.02163864f, -0.02820213f, 0.04082818f, 
    -0.05644924f, 0.02816405f, -0.05967204f, -0.03063262f, -0.00043955f, -0.01886851f, 0.00944226f, -0.04325406f, 
    -0.02378114f, -0.03673187f, -0.04801951f, 0.00477696f, 0.00179601f, -0.01236424f, -0.04243287f, -0.00992652f, 
    0.03248138f, -0.02846041f, -0.02717590f, 0.01981763f, 0.01608158f, -0.01467081f, -0.00617361f, 0.01836877f, 
    0.00404244f, -0.01847711f, -0.00599146f, -0.01278944f, 0.01585157f, -0.00348060f, 0.05031686f, -0.04447583f, 
    -0.03823198f, 0.00398308f, -0.01164181f, -0.00463337f, 0.01091274f, -0.04986117f, -0.00976079f, 0.01022916f, 
    0.04280165f, 0.03614343f, -0.03256956f, -0.03165383f, 0.01919805f, 0.04267628f, 0.04525396f, -0.04904466f, 
    0.02400915f, -0.02560391f, 0.01891598f, -0.00163119f, 0.04247508f, -0.00837817f, -0.02050066f, 0.00003608f, 
    0.02990136f, 0.04556524f, 0.00305887f, -0.05262382f, 0.01814587f, -0.00081595f, 0.01219830f, 0.01597318f, 
    0.03043180f, 0.00558793f, 0.00845729f, -0.04371696f, 0.00776957f, -0.03381232f, 0.01901354f, -0.02966316f, 
    -0.04787499f, 0.02078016f, -0.03519656f, 0.02113606f, 0.04226466f, 0.01916148f, -0.03323746f, 0.01082055f, 
    0.02671215f, -0.05111790f, 0.04608013f, -0.04867347f, 0.03373514f, 0.04689140f, 0.01350614f, -0.04927121f, 
    0.00951119f, -0.00610284f, 0.02659992f, 0.03294070f, 0.00609709f, -0.01655642f, 0.00253768f, 0.01706834f, 
    -0.04396955f, -0.03681058f, -0.00513807f, -0.02050279f, 0.00311161f, -0.03252995f, 0.01078487f, -0.00845060f, 
    -0.02805014f, 0.00017824f, 0.01281766f, -0.03669115f, 0.02152038f, 0.00996662f, 0.02485149f, -0.02358303f, 
    -0.01872138f, -0.05480063f, -0.01365983f, 0.01682289f, 0.01903625f, 0.01552450f, 0.02001371f, 0.03950927f, 
    -0.02211438f, -0.05376617f, -0.05084673f, 0.04054134f, -0.01849399f, -0.04933003f, -0.05691425f, -0.05068805f, 
    -0.02193462f, 0.01134234f, -0.00588587f, -0.00118605f, 0.02687510f, -0.04410302f, 0.01883517f, 0.01919815f, 
    -0.02036975f, -0.03073734f, 0.01401089f, -0.03976236f, 0.02787888f, 0.01635432f, -0.03648857f, -0.01812512f, 
    -0.04790570f, -0.05342658f, 0.00017292f, -0.03402140f, -0.00466465f, -0.00293075f, 0.04381378f, -0.01899101f, 
    0.00071767f, -0.00253718f, -0.04333043f, 0.02317213f, 0.00578227f, -0.03100142f, 0.01576515f, -0.03639027f, 
    -0.02161823f, 0.01959219f, -0.03869275f, -0.01684779f, 0.00824998f, -0.03995910f, -0.03949164f, 0.03014081f, 
    0.01634860f, -0.02684748f, -0.03450405f, -0.04767819f, -0.03108133f, 0.02233064f, -0.02088465f, 0.02245479f, 
    -0.05534187f, -0.00541898f, -0.00773069f, 0.03780035f, -0.00862608f, 0.01209357f, -0.02010402f, -0.02969741f, 
    0.04421264f, 0.01486848f, -0.04109650f, -0.03586687f, -0.03639784f, 0.03281813f, -0.00051892f, -0.00684999f, 
    -0.01664156f, -0.01778781f, -0.03448815f, -0.04817659f, -0.02714399f, 0.01180563f, 0.00151401f, -0.00679237f, 
    0.02186442f, -0.04885584f, 0.02609654f, 0.02772683f, 0.01628286f, -0.01362683f, 0.01867367f, 0.01481593f, 
    -0.01162849f, -0.04067503f, 0.03078958f, -0.00096014f, 0.00754149f, -0.00893058f, -0.02622497f, -0.01847536f, 
    -0.02403008f, 0.02556515f, -0.01365482f, -0.03022694f, -0.00228683f, -0.01218151f, 0.01862100f, -0.05174159f, 
    -0.01500259f, 0.03597714f, -0.03484448f, -0.02146760f, 0.02406636f, -0.01924913f, 0.04218245f, -0.02429782f, 
    -0.02854533f, -0.02052158f, 0.03903425f, -0.04094397f, -0.01716289f, 0.01315059f, -0.05639702f, -0.02528022f, 
    -0.03604126f, -0.00519551f, 0.01702953f, 0.03940108f, 0.03917859f, 0.03652969f, 0.04449641f, 0.03637180f, 
    -0.01493618f, -0.01288777f, 0.04330210f, 0.00659368f, 0.02476023f, -0.02318283f, 0.02081435f, -0.00460978f, 
    0.01587687f, 0.02209517f, 0.04071973f, -0.05053636f, 0.02745330f, 0.00855250f, -0.00132893f, 0.03893592f, 
    -0.04341252f, 0.02265763f, -0.02454194f, -0.01642299f, 0.03016802f, -0.02568533f, 0.04433938f, 0.02799198f, 
    0.02112108f, 0.01423120f, 0.00559641f, 0.00050202f, 0.01257106f, -0.05046548f, -0.00946406f, 0.04013325f, 
    -0.00435566f, 0.03887980f, 0.01532693f, -0.03530395f, -0.04906389f, -0.05349344f, 0.01841226f, -0.02787942f, 
    0.02251838f, -0.04160142f, -0.05375539f, -0.04801487f, -0.01680762f, 0.03292120f, -0.00639092f, 0.01315764f, 
    0.02005174f, -0.03054880f, -0.04763519f, -0.01954899f, 0.00276264f, -0.05549442f, -0.01165798f, 0.03249807f, 
    -0.00411886f, 0.00106428f, -0.00214682f, -0.04622140f, 0.02769439f, -0.05555316f, -0.03850909f, -0.03000793f, 
    -0.04342833f, 0.03937485f, 0.03851543f, 0.03500486f, 0.03507088f, -0.01923530f, -0.02520356f, 0.02525813f, 
    0.04170598f, -0.01323041f, -0.03312362f, 0.01988723f, -0.05510548f, -0.05154446f, 0.02430656f, -0.02629320f, 
    0.00421588f, 0.01211664f, 0.00278361f, 0.00029606f, -0.05689912f, 0.01812724f, -0.02649761f, -0.01143020f, 
    0.02720488f, 0.02988209f, -0.02751539f, 0.03166085f, 0.03856600f, 0.03498634f, -0.04884216f, 0.03933135f, 
    0.00240004f, -0.02572552f, -0.05414776f, -0.05571630f, -0.05484812f, 0.02592748f, -0.01674306f, 0.02096583f, 
    -0.05156994f, -0.01372465f, 0.01542991f, -0.00083763f, -0.05560804f, -0.04411134f, -0.01075698f, 0.01603010f, 
    -0.00287002f, -0.05543972f, 0.02596064f, 0.02804078f, 0.03803866f, -0.01706897f, -0.04565237f, 0.03812371f, 
    -0.04608978f, 0.02247946f, -0.05496041f, -0.03295149f, -0.04650000f, 0.02086607f, -0.00090333f, 0.03480244f, 
    0.00682679f, -0.00048616f, -0.01975687f, 0.02923960f, 0.01067598f, -0.01143297f, 0.01021906f, 0.01829311f, 
    -0.01738760f, -0.02884369f, 0.00690674f, 0.00262881f, -0.04307487f, 0.03147868f, -0.05602985f, 0.00621089f, 
    0.01787088f, -0.05268992f, -0.01554888f, -0.02610321f, -0.02839425f, 0.04300623f, -0.04195116f, -0.00218501f, 
    0.02304165f, -0.03544756f, 0.01407278f, -0.00141949f, -0.05176899f, -0.02194659f, 0.02247724f, 0.04276053f, 
    0.01475040f, -0.05065833f, 0.04293722f, 0.04201192f, -0.00364927f, 0.01015776f, 0.01223609f, -0.02225885f, 
    -0.04956385f, -0.00685852f, 0.00789092f, -0.04676799f, -0.04161643f, 0.03141132f, -0.02474133f, 0.02180340f, 
    0.00291081f, -0.05454830f, 0.03256319f, -0.02293949f, -0.01848872f, 0.00424404f, -0.04785483f, 0.01005183f, 
    -0.05306828f, -0.01846048f, -0.01416731f, -0.05533056f, -0.04276636f, 0.01762993f, 0.01827870f, 0.01983997f, 
    0.01888135f, -0.00459264f, -0.02991314f, -0.04450520f, -0.03959712f, -0.00064293f, -0.00235804f, 0.03445695f, 
    0.00552020f, -0.04709538f, -0.00222304f, -0.00895552f, -0.04649013f, -0.01384374f, -0.02721811f, 0.00572975f, 
    -0.01911553f, 0.03150923f, -0.03211283f, 0.02313505f, -0.00037885f, 0.03195871f, -0.01888077f, 0.02690045f, 
    -0.04975637f, -0.03741295f, -0.05163074f, -0.00738681f, 0.01105048f, 0.02254147f, 0.03876416f, -0.01039424f, 
    0.02295235f, 0.03512646f, -0.00086547f, 0.00447339f, -0.02825163f, -0.00667284f, -0.02687417f, 0.00093388f, 
    -0.03621519f, -0.05483579f, -0.01002881f, -0.00050991f, -0.05206719f, 0.03748913f, -0.04326198f, -0.01159932f, 
    -0.02997507f, -0.04296721f, -0.04222674f, -0.02316365f, 0.02764778f, 0.00090815f, 0.03651435f, 0.01420152f, 
    -0.03680936f, -0.01220414f, 0.01076562f, -0.04584261f, -0.00206079f, 0.03514755f, -0.04367423f, 0.02218811f, 
    0.03810024f, -0.04566601f, 0.02493549f, -0.03012449f, 0.01588561f, 0.04216536f, -0.04178827f, 0.02271167f, 
    -0.03230619f, -0.04119997f, 0.02144741f, -0.04629049f, 0.04010892f, -0.00611235f, 0.04419809f, -0.00710583f, 
    -0.04942315f, 0.02161238f, 0.00977744f, -0.01252331f, -0.02980578f, 0.04389379f, 0.02712047f, -0.05561240f, 
    -0.01225874f, -0.05085479f, -0.05113484f, -0.05437488f, -0.03642079f, 0.00208803f, -0.03414177f, -0.00392437f, 
    -0.01207448f, 0.04474476f, -0.04949193f, -0.00728808f, -0.03914982f, -0.05292265f, 0.02920484f, -0.03855525f, 
    0.00981942f, -0.04850355f, 0.01718220f, -0.02983655f, -0.03646244f, 0.00668392f, 0.04533182f, 0.00514071f, 
    -0.01026577f, -0.05492480f, 0.03184289f, -0.00750132f, -0.03338679f, 0.03504018f, -0.05002333f, -0.05015106f, 
    -0.03253619f, 0.02673879f, -0.02715613f, -0.04776733f, -0.05643659f, -0.03181523f, 0.01282440f, -0.04277663f, 
    -0.04534519f, 0.02337176f, -0.02468311f, -0.01504841f, -0.03870320f, 0.00983906f, -0.00998419f, -0.02615764f, 
    -0.01021058f, -0.00066493f, -0.03005067f, -0.03170562f, 0.01291107f, -0.01032053f, -0.02173279f, -0.00735993f, 
    -0.03392599f, 0.01338937f, -0.01393611f, 0.00815564f, -0.05366552f, 0.03791327f, 0.02300285f, -0.01236218f, 
    0.02734187f, 0.04331322f, -0.05070936f, 0.02785512f, 0.03902674f, 0.04578424f, -0.02963223f, 0.00778424f, 
    -0.03850264f, -0.05234307f, -0.03579512f, -0.01579251f, -0.03166931f, 0.01080465f, -0.04809988f, 0.01435862f, 
    0.02671798f, 0.03169633f, 0.00248410f, 0.00286282f, 0.02550097f, -0.01740116f, -0.01469498f, 0.01091784f, 
    0.02277149f, -0.04413163f, -0.04160694f, -0.01369827f, -0.00596270f, -0.05077828f, -0.01658655f, 0.01570388f, 
    -0.02302609f, 0.00594745f, 0.01946718f, -0.04424163f, -0.02182375f, -0.00546096f, -0.01392656f, -0.04479389f, 
    0.00027829f, -0.00007742f, -0.03411433f, -0.04832176f, -0.05293053f, 0.01768450f, 0.01309798f, -0.00527953f, 
    0.00278901f, 0.03333735f, -0.03649682f, -0.00573183f, 0.02554680f, 0.03616298f, 0.05423401f, -0.02303983f, 
    0.00622281f, -0.05484040f, -0.05171478f, 0.03242897f, -0.02570304f, 0.03843452f, 0.04267292f, 0.00552978f, 
    0.01639293f, -0.03347389f, -0.00634612f, -0.05441718f, -0.02202374f, -0.01941952f, -0.00105808f, -0.01951395f, 
    0.04123094f, 0.00388055f, 0.03361106f, 0.01253215f, -0.00295081f, -0.03422705f, 0.01348276f, 0.03229858f, 
    0.02009348f, -0.01923680f, 0.01042921f, 0.00601069f, -0.02322435f, 0.03003096f, 0.00120865f, -0.03118827f, 
    0.01272524f, -0.04485425f, -0.01702300f, -0.00664146f, -0.01940896f, -0.04903479f, 0.03074488f, -0.03074446f, 
    0.04391855f, -0.00185744f, -0.03736817f, -0.04712777f, 0.03255162f, -0.04850361f, 0.02149377f, 0.00938546f, 
    -0.02628785f, -0.04408586f, 0.01393753f, 0.03498332f, -0.04630295f, 0.01198278f, -0.01793055f, 0.04289661f, 
    -0.01304570f, -0.04741646f, -0.02345988f, -0.03891863f, 0.02455034f, 0.02311942f, 0.00604877f, 0.02505828f, 
    0.02631904f, -0.02384336f, 0.02153494f, -0.02814634f, -0.00103634f, -0.02039119f, 0.03542242f, -0.00019656f, 
    -0.05258536f, 0.04725834f, 0.00125282f, 0.03293162f, -0.05588320f, 0.03216938f, -0.01803647f, -0.00025248f, 
    0.02848118f, 0.02804453f, -0.01851869f, 0.01985295f, -0.04851602f, -0.01039982f, 0.01618147f, -0.05054348f, 
    0.04114273f, -0.00439282f, 0.02165547f, -0.04542053f, 0.03584123f, 0.01851241f, 0.01879307f, 0.02378130f, 
    -0.01645168f, -0.03233670f, -0.02163322f, -0.04818893f, 0.02450215f, 0.03731662f, -0.04987597f, 0.02219038f, 
    0.03746689f, 0.00116742f, 0.01378065f, 0.03251458f, 0.02054594f, 0.03662080f, -0.03076482f, 0.00404140f, 
    0.03806276f, -0.03075400f, 0.02377505f, -0.04126733f, -0.01241543f, 0.02313204f, -0.00945565f, 0.04572767f, 
    -0.01910226f, 0.02258701f, -0.04579775f, -0.05511732f, -0.05053884f, 0.03621962f, 0.02560674f, -0.04547304f, 
    -0.00540663f, 0.01873947f, -0.01456559f, 0.03892631f, 0.03374725f, -0.04194916f, 0.04024538f, 0.04181756f, 
    0.00198776f, -0.02679537f, 0.01627498f, 0.04052278f, -0.00505197f, -0.03231314f, -0.05679761f, -0.00183752f, 
    -0.01332661f, -0.05113180f, -0.03252938f, -0.00813690f, -0.02949679f, -0.01237782f, 0.02742873f, -0.03012750f, 
    -0.04018456f, -0.04486383f, -0.04352441f, -0.02188942f, 0.03455818f, -0.04014808f, -0.03648885f, 0.04234531f, 
    0.02804741f, -0.00238462f, -0.01494949f, -0.01426062f, 0.00408906f, -0.02233644f, -0.01554033f, 0.03173332f, 
    -0.02556642f, -0.05107774f, -0.00616233f, -0.03065924f, -0.04976283f, -0.04508046f, 0.00322776f, 0.01940420f, 
    -0.05063410f, 0.03383551f, -0.03053284f, 0.03572846f, 0.03484318f, -0.04353316f, 0.01263165f, -0.03806340f, 
    0.03598251f, -0.01724405f, -0.02125003f, -0.01970308f, 0.01021267f, 0.03450122f, -0.02730073f, 0.04484262f, 
    -0.02032170f, 0.01972115f, 0.03524179f, -0.04445988f, -0.04052234f, -0.01939571f, 0.00991467f, 0.04663161f, 
    -0.01688098f, 0.04222930f, 0.04440178f, -0.04543844f, -0.04338560f, 0.01925952f, -0.03296918f, -0.04585826f, 
    -0.04475717f, 0.02908055f, 0.00379767f, -0.02375652f, 0.01949155f, -0.04004904f, 0.01045643f, -0.01876589f, 
    -0.12729554f, -0.01235508f, -0.08437203f, -0.09005371f, 0.16533509f, -0.01091527f, -0.07009982f, 0.03310704f, 
    0.13634455f, 0.17968392f, 0.11883077f, -0.00636319f, -0.14400265f, 0.17121987f, 0.04090688f, 0.05743086f, 
    -0.21045296f, -0.02127583f, 0.05948973f, 0.11600657f, -0.01175581f, 0.12469377f, -0.07776720f, 0.06241917f, 
    -0.12638657f, -0.10920411f, 0.22037525f, -0.08244243f, 0.01857197f, 0.02851364f, 0.16638528f, -0.02732298f, 
    -0.08589185f, 0.00651397f, -0.00890539f, 0.00983129f, 0.18527980f, 0.04905509f, -0.11123251f, -0.04642567f, 
    -0.11955428f, 0.16991739f, -0.06685455f, 0.11965234f, -0.02329056f, 0.02566015f, -0.00623743f, -0.03274534f, 
    -0.08212920f, 0.12819056f, 0.19602261f, 0.09734442f, -0.25253615f, -0.00649436f, -0.01398695f, 0.12469497f, 
    -0.01248069f, -0.00556764f, -0.01397905f, -0.01999959f, 0.02180402f, -0.12876973f, 0.01907095f, -0.40564945f, 
    0.13900833f, -0.03871550f, -0.02528318f, 0.08968214f, 0.09689935f, 0.11360908f, 0.06726270f, 0.03122450f, 
    -0.09245148f, -0.08449539f, -0.20515534f, -0.22898230f, 0.10131054f, -0.01072519f, -0.10688566f, 0.04531210f, 
    -0.03074468f, 0.01341669f, 0.04776450f, 0.04344165f, -0.11057959f, -0.21381292f, 0.22665729f, -0.00203154f, 
    -0.07838725f, 0.01598404f, 0.17681347f, -0.05429489f, -0.05407035f, -0.01897484f, -0.01318744f, -0.10218013f, 
    -0.05558810f, 0.10480922f, -0.15942626f, -0.07857568f, -0.00838601f, 0.00934769f, -0.16202506f, -0.12416997f, 
    0.14451386f, 0.15880172f, 0.03449031f, -0.04755341f, -0.24145418f, -0.06010361f, 0.20575067f, 0.14713368f, 
    -0.12210575f, -0.09547593f, 0.01140504f, 0.12922461f, -0.02333574f, 0.12773596f, -0.07213911f, 0.00695914f, 
    0.11504491f, -0.01555853f, 0.33106980f, -0.23436001f, -0.17601837f, 0.03053691f, 0.07999018f, -0.03022821f, 
    0.01001906f, -0.05836194f, 0.05436862f, 0.05204314f, -0.06359286f, -0.02162382f, 0.18880256f, 0.17310724f, 
    -0.01265037f, -0.07983328f, 0.01449823f, 0.00542537f, -0.09414240f, -0.09329030f, -0.02300948f, 0.05393495f, 
    -0.20162745f, 0.04143794f, -0.14182740f, 0.16188027f, 0.03895921f, 0.08061028f, 0.03794236f, 0.09638352f, 
    -0.06770127f, 0.09203491f, 0.07203784f, -0.03499155f, -0.16564590f, 0.18752210f, 0.11665561f, -0.14122780f, 
    -0.18016160f, 0.18013179f, -0.04155866f, 0.09336554f, 0.04290343f, 0.12365374f, -0.02481072f, -0.07690888f, 
    -0.25410756f, -0.11290218f, 0.07680471f, 0.22799702f, -0.09351382f, -0.11271133f, 0.11396011f, -0.02979842f, 
    0.01045405f, 0.03433302f, -0.16751200f, 0.04521217f, -0.12197752f, 0.19060899f, -0.05144012f, -0.01432021f, 
    0.05770839f, 0.05786003f, -0.03406211f, 0.00154243f, -0.05666152f, 0.00809079f, 0.23056954f, 0.05504428f, 
    0.06827658f, -0.14321610f, 0.05393460f, -0.05093159f, 0.12106898f, 0.02423133f, 0.14625508f, 0.21577561f, 
    0.13672197f, 0.03668120f, 0.00529236f, 0.06783240f, -0.08192762f, -0.28063002f, -0.18355465f, 0.05343943f, 
    0.07708076f, 0.01942256f, 0.09549567f, 0.06448553f, 0.00952571f, -0.04713641f, 0.09484054f, 0.04549748f, 
    0.09216769f, -0.01209571f, 0.08626215f, -0.07890745f, 0.06101593f, 0.00125489f, -0.00555306f, 0.01470712f, 
    0.01014192f, 0.06211625f, -0.07077178f, -0.03733089f, 0.02294790f, 0.20312791f, 0.17727095f, -0.11120872f, 
    -0.00329766f, 0.02594925f, -0.00208743f, 0.03737262f, -0.06946615f, 0.00705629f, 0.16368014f, 0.02293574f, 
    0.01432902f, -0.11636867f, -0.20214142f, -0.13023449f, 0.06396583f, 0.18429601f, 0.13280649f, -0.00543558f, 
    0.03166701f, 0.05496188f, 0.01084127f, 0.07199929f, -0.14800826f, 0.11611667f, 0.22008809f, 0.25805053f, 
    -0.05760612f, 0.00491173f, 0.12535492f, 0.09077884f, -0.04010138f, 0.04610882f, 0.12773959f, -0.08230942f, 
    -0.21974434f, -0.16548571f, 0.13552240f, -0.10456489f, -0.09186468f, 0.32650876f, 0.21490490f, 0.02765515f, 
    0.03080388f, 0.00081388f, -0.04413593f, 0.01235905f, 0.19922993f, -0.22782166f, 0.06204215f, -0.03696853f, 
    0.02951606f, -0.01508392f, 0.16515335f, -0.20636314f, 0.07675428f, 0.07152598f, -0.06056867f, 0.04639396f, 
    0.09412578f, -0.11316013f, -0.02739942f, -0.06251176f, 0.15921469f, 0.13318980f, 0.13365996f, 0.01790540f, 
    0.02887532f, 0.11900934f, 0.04885693f, 0.15767725f, -0.07908611f, -0.12398817f, 0.11108228f, -0.03100435f, 
    0.07520615f, 0.06559273f, 0.10689219f, 0.13663368f, -0.05191929f, 0.12825027f, 0.00974040f, -0.05291724f, 
    0.00884301f, 0.25364763f, 0.11963147f, -0.17251539f, -0.03462519f, -0.09877673f, 0.04537862f, 0.07854547f, 
    0.05309192f, 0.14693162f, -0.02014503f, 0.08310640f, 0.03640467f, -0.24965660f, -0.10863810f, -0.25508416f, 
    0.03056317f, 0.03554096f, -0.03156839f, 0.19659249f, 0.07605901f, -0.06023715f, 0.14389539f, 0.11191183f, 
    0.09160340f, -0.05392427f, 0.09311355f, 0.02653093f, -0.02226499f, 0.15876548f, -0.11753731f, -0.09309359f, 
    0.07512860f, -0.03476336f, 0.10848330f, 0.10961219f, -0.11064857f, 0.14849979f, 0.07939291f, 0.37265980f, 
    -0.02486882f, -0.00187143f, 0.10686322f, 0.10917912f, 0.24442381f, 0.07757329f, 0.06851399f, -0.10237932f, 
    0.11375213f, -0.12136921f, 0.17354427f, -0.06162946f, -0.06757370f, 0.04340316f, -0.00511817f, 0.17819564f, 
    -0.07427501f, -0.00541112f, 0.03550626f, -0.04349311f, 0.33375227f, -0.03032642f, -0.08549149f, 0.13515671f, 
    -0.10378806f, 0.04209520f, -0.01659425f, 0.02737277f, 0.12349784f, -0.03861500f, 0.06188732f, 0.08496400f, 
    -0.02838765f, -0.04340626f, 0.03647980f, 0.00836020f, 0.00664355f, 0.01316096f, -0.00905053f, -0.03078073f, 
    -0.03683810f, 0.01151769f, 0.02671400f, 0.04333469f, 0.01831592f, 0.03004937f, 0.03866339f, -0.03746626f, 
    0.04147768f, 0.01285440f, 0.00836398f, -0.02020592f, 0.04137636f, -0.04305570f, -0.04301984f, 0.02427079f, 
    -0.02747055f, 0.00575678f, -0.02467188f, 0.01670350f, -0.03392262f, -0.05045990f, -0.01333386f, -0.03863298f, 
    0.03775207f, -0.02360016f, 0.01713800f, 0.02973591f, 0.03098390f, -0.03447467f, 0.01293006f, -0.02718068f, 
    -0.03776493f, 0.01567132f, 0.03651415f, 0.00554631f, -0.03782903f, 0.04070475f, -0.01624069f, -0.04294409f, 
    -0.03644159f, -0.04860442f, -0.01747064f, -0.05139016f, 0.03537888f, 0.01361788f, -0.04688351f, -0.04871943f, 
    -0.02117022f, -0.04848236f, -0.02490205f, -0.01931748f, -0.00935742f, -0.01877597f, -0.01993263f, 0.03998252f, 
    0.01351866f, -0.05528932f, 0.02315277f, -0.01636784f, -0.03556045f, -0.02321740f, 0.00175279f, -0.01853553f, 
    0.00337649f, 0.04319846f, 0.02673987f, 0.01195170f, -0.03483031f, -0.02522824f, -0.00994895f, 0.00403970f, 
    0.04242141f, 0.00515177f, 0.03931033f, 0.01843329f, -0.04252433f, -0.03815289f, 0.00462080f, 0.03372899f, 
    -0.03064330f, 0.03455992f, -0.01917057f, 0.02624023f, -0.01679892f, -0.00249108f, 0.03759455f, 0.03964176f, 
    -0.00790841f, -0.00716147f, -0.03617296f, 0.02996215f, -0.03445036f, 0.03034229f, 0.04238300f, -0.00613702f, 
    -0.04024130f, 0.02009118f, -0.03593656f, -0.00315551f, -0.01366152f, -0.04562365f, 0.02765085f, 0.01959395f, 
    -0.04423424f, -0.02425484f, 0.02086663f, 0.01654348f, 0.00750572f, -0.03655221f, -0.02938208f, -0.03453788f, 
    -0.01130969f, -0.01221860f, 0.00560095f, -0.04315346f, 0.03714635f, -0.04454972f, -0.00722601f, -0.04955041f, 
    0.04066374f, -0.02635976f, -0.05168626f, -0.04099066f, -0.01698305f, -0.01241053f, 0.01634661f, 0.03738721f, 
    -0.04168112f, 0.02034851f, 0.00800595f, -0.04183226f, -0.00907351f, -0.00948447f, -0.05231752f, -0.01595116f, 
    0.03840014f, 0.03362099f, 0.02802871f, 0.00926132f, 0.04264650f, 0.03339431f, -0.00629959f, 0.00780590f, 
    -0.05378802f, -0.00209343f, 0.03214577f, 0.00400669f, -0.01037733f, -0.02438568f, -0.01907193f, 0.02109590f, 
    0.00151985f, -0.01135107f, 0.03129636f, -0.03491540f, -0.03097410f, 0.01693769f, 0.04297716f, -0.04195599f, 
    0.00161821f, -0.04312502f, -0.00349177f, -0.03857157f, -0.02555484f, 0.03477225f, -0.01126052f, -0.01488805f, 
    -0.04179786f, -0.02124524f, 0.00499472f, -0.02749792f, -0.03740827f, -0.03976953f, -0.03342110f, 0.00063737f, 
    -0.03240475f, -0.03471414f, -0.05485620f, -0.04603215f, -0.01816603f, 0.03423470f, -0.05205665f, -0.04523707f, 
    -0.03984432f, 0.00692637f, -0.02100784f, -0.01365058f, -0.00521084f, 0.01339153f, 0.00354765f, 0.01258367f, 
    -0.03647155f, -0.00804244f, 0.01064655f, 0.03786335f, -0.01663435f, -0.04292082f, -0.03831131f, -0.03390169f, 
    -0.03051265f, 0.03889380f, -0.00892234f, 0.03025186f, -0.00769576f, 0.00348349f, -0.02409322f, -0.03306790f, 
    0.02453695f, 0.00602663f, -0.04664390f, -0.03288825f, -0.04648355f, -0.05020672f, -0.01690091f, -0.00226940f, 
    -0.03670927f, -0.02282527f, 0.00616582f, 0.00786965f, 0.00008770f, -0.04697513f, -0.01374954f, -0.05060460f, 
    -0.02583190f, 0.03421946f, 0.00506499f, -0.01131909f, -0.01188969f, 0.01813127f, 0.04147387f, -0.02441742f, 
    0.03543017f, -0.04705535f, 0.00345239f, -0.04444687f, -0.02164107f, -0.01637984f, 0.03450251f, -0.03604115f, 
    0.00909417f, 0.00060357f, -0.04342375f, -0.00466336f, 0.00949431f, -0.04141925f, -0.00442457f, -0.05233156f, 
    -0.01882637f, 0.02932753f, 0.03572926f, -0.01229680f, -0.04043882f, 0.02721716f, -0.01637642f, 0.03051370f, 
    0.04027928f, 0.00070752f, -0.00160301f, 0.00542520f, -0.05336796f, 0.02365521f, 0.00790176f, 0.02773245f, 
    0.02629254f, -0.05003449f, -0.00352993f, -0.01871175f, -0.04384855f, 0.01522777f, -0.01507232f, -0.04034922f, 
    -0.05010830f, -0.02054063f, -0.04466518f, 0.02262741f, 0.03046703f, -0.01069602f, 0.03842577f, -0.04401410f, 
    0.01767967f, -0.03556482f, 0.00355361f, 0.02976201f, 0.01355315f, -0.05494132f, -0.00776048f, -0.01915460f, 
    0.01270328f, -0.02441256f, 0.02100773f, 0.03156393f, 0.03679562f, 0.04287865f, 0.03577137f, -0.01060089f, 
    -0.01291512f, -0.05169648f, -0.03570369f, 0.03163949f, -0.04689302f, 0.00638310f, 0.04184964f, -0.04350729f, 
    -0.00250946f, -0.00755421f, -0.04583607f, -0.01938537f, -0.03455928f, -0.04460191f, -0.02986279f, -0.01375340f, 
    0.04000755f, -0.03343819f, 0.01856928f, 0.04273654f, -0.02206749f, 0.02670058f, -0.05234119f, -0.01514529f, 
    -0.05381913f, 0.01579834f, -0.00745893f, -0.03628930f, -0.03738018f, -0.00447851f, -0.02237341f, 0.00532875f, 
    0.04440403f, 0.01076948f, 0.00655303f, -0.01235707f, -0.05080931f, -0.01658030f, -0.02186356f, -0.00532132f, 
    0.01084445f, -0.02892549f, 0.02924980f, -0.05443263f, -0.05321246f, -0.02318933f, -0.00571251f, -0.02613262f, 
    0.00456746f, -0.03014412f, -0.05264239f, 0.02719384f, -0.03267161f, -0.01806036f, -0.03070320f, -0.01625728f, 
    -0.01265202f, -0.04876289f, 0.02833222f, 0.02195307f, 0.02586242f, 0.03444553f, 0.02948183f, -0.04519909f, 
    -0.02498261f, -0.03606697f, -0.03886861f, 0.04291923f, 0.00652379f, 0.00745118f, 0.03287150f, 0.02323593f, 
    0.01415590f, -0.01518808f, 0.01262227f, -0.04010091f, -0.03627449f, 0.01502817f, -0.05657423f, 0.00324141f, 
    -0.05712911f, -0.13380305f, 0.04453762f, -0.11088983f, -0.00016528f, 0.06131298f, 0.02542475f, -0.02694931f, 
    0.03148576f, -0.01785132f, -0.02594618f, -0.00926044f, -0.17262851f, 0.00597343f, 0.10010285f, -0.08292898f, 
    0.06509622f, -0.06230393f, 0.03199211f, -0.00237618f, -0.03354984f, -0.04724350f, -0.03755328f, -0.06662133f, 
    -0.15281168f, -0.06201593f, -0.15118118f, 0.03479823f, 0.14555018f, 0.01595872f, -0.08371868f, -0.00530153f, 
    0.13739602f, -0.01114552f, 0.11093679f, -0.09680817f, -0.03868566f, 0.06851874f, 0.15576963f, 0.08640079f, 
    -0.02426569f, -0.02187474f, 0.11528627f, -0.17614259f, -0.08650433f, 0.00092348f, 0.00825441f, 0.03141629f, 
    0.22494672f, 0.16057262f, 0.02644352f, -0.09694180f, 0.13401154f, 0.00143065f, 0.06570328f, 0.03840590f, 
    0.03695168f, -0.09113348f, -0.01776299f, -0.03333135f, 0.08097986f, -0.08456104f, -0.09438308f, -0.05189953f, 
    -0.06988963f, 0.12684323f, 0.03674456f, 0.03126350f, -0.05144678f, -0.04857432f, 0.00637270f, 0.08446989f, 
    0.15855232f, -0.11236974f, -0.05618047f, 0.04518657f, -0.02757811f, -0.02149784f, 0.10929112f, 0.00602636f, 
    0.01761645f, -0.09658757f, -0.03513479f, 0.12540859f, 0.26942745f, 0.26699251f, 0.00383133f, 0.14079724f, 
    0.08762170f, -0.07474785f, -0.04491967f, 0.10518448f, 0.01104627f, -0.01737045f, 0.11615656f, 0.04512119f, 
    -0.37723976f, -0.23794311f, -0.00714430f, -0.03258657f, 0.10481986f, 0.19915535f, 0.12332579f, -0.01727993f, 
    -0.06346627f, 0.02991951f, 0.11892589f, 0.09932889f, 0.51911467f, 0.09581876f, -0.09745902f, 0.24799767f, 
    0.10533722f, 0.12092467f, 0.00683140f, -0.02422197f, 0.17910400f, -0.08016074f, 0.06067101f, 0.00817778f, 
    -0.11410533f, 0.01468676f, -0.04505286f, 0.22002281f, -0.04593475f, -0.10231552f, 0.07220844f, 0.12891628f, 
    -0.03739285f, 0.02242752f, -0.02429346f, 0.10782356f, 0.08250875f, 0.14557430f, 0.06504469f, -0.00664041f, 
    -0.01174855f, 0.01036069f, 0.05006574f, 0.02581862f, 0.12532955f, 0.02820863f, 0.00738261f, -0.08832335f, 
    0.42564222f, 0.06276613f, -0.01654700f, 0.26463538f, 0.02922612f, 0.05591190f, -0.05927029f, 0.01913937f, 
    0.01113707f, 0.03746397f, -0.01353406f, -0.11398941f, 0.38810268f, -0.02533029f, -0.02725745f, 0.03974022f, 
    0.04438415f, -0.08677690f, 0.09354342f, -0.07235826f, -0.03509914f, -0.00669175f, 0.09235418f, 0.25921524f, 
    0.39511782f, 0.30739895f, 0.03961824f, -0.04600584f, 0.13095893f, -0.07730330f, -0.02442903f, 0.10749570f, 
    0.03314451f, -0.11040600f, 0.15320221f, -0.03930506f, 0.12019701f, -0.05820168f, 0.03901302f, 0.19987500f, 
    -0.02820326f, 0.02521552f, 0.05012318f, -0.00672477f, -0.03621660f, 0.09935634f, -0.07086703f, -0.09347533f, 
    0.06976975f, -0.10735188f, -0.07170596f, 0.15674427f, 0.02301211f, 0.13311131f, 0.01089190f, -0.22932853f, 
    0.06882712f, -0.08826074f, -0.09757147f, -0.02162890f, -0.33622810f, 0.22081541f, -0.08655159f, -0.06791605f, 
    0.11355228f, 0.01501292f, -0.04968407f, -0.02462471f, -0.01145568f, 0.07115855f, -0.09702969f, 0.01834927f, 
    -0.11534236f, 0.02400667f, 0.01463947f, 0.02476051f, 0.00859960f, -0.01326233f, 0.09616699f, -0.01259360f, 
    0.03280720f, 0.01515686f, 0.08292092f, 0.12417796f, 0.21908887f, -0.21882927f, -0.08813176f, 0.19662076f, 
    -0.05081879f, 0.04665985f, 0.01746351f, 0.05049921f, 0.03640840f, 0.09129509f, 0.13184658f, 0.04545256f, 
    -0.25113088f, -0.11309591f, -0.13257793f, -0.10677896f, 0.16841787f, -0.04130584f, -0.00821821f, -0.03704439f, 
    0.09055454f, 0.03335605f, -0.02826118f, 0.08803035f, 0.33457115f, 0.01284478f, 0.01491765f, -0.02919284f, 
    0.05362618f, -0.02257949f, -0.04997096f, 0.04116523f, 0.11546233f, 0.08973441f, -0.02479094f, 0.08507300f, 
    0.04197228f, 0.18006971f, -0.11515797f, -0.12798634f, 0.10100703f, -0.19157039f, -0.09445089f, -0.03678980f, 
    0.07106668f, 0.06042007f, 0.04550857f, -0.01290818f, -0.37205902f, -0.36475930f, 0.03469200f, 0.13478348f, 
    -0.00308996f, 0.07272136f, -0.05358869f, 0.07543703f, -0.02380114f, 0.02220669f, 0.09088947f, -0.07786094f, 
    -0.02819305f, 0.02118871f, -0.11652821f, 0.03401949f, -0.00283965f, -0.13212939f, -0.08568983f, 0.00265598f, 
    0.05155879f, -0.19210862f, -0.03782582f, -0.04003416f, 0.05111222f, -0.28046516f, 0.01778311f, -0.02116378f, 
    0.02076368f, 0.02187874f, -0.00766765f, -0.08494273f, 0.08616502f, 0.00798106f, -0.04716113f, 0.11123089f, 
    0.27220184f, 0.10448576f, -0.01995376f, 0.06747438f, -0.07428631f, 0.05852368f, 0.08849116f, 0.07295523f, 
    -0.06391101f, 0.00462316f, 0.07817406f, 0.09798940f, -0.17498077f, 0.04484890f, -0.23978068f, 0.09140983f, 
    0.01910751f, -0.03554544f, -0.06733885f, -0.07035709f, 0.02869130f, 0.12619247f, -0.04749839f, -0.03349562f, 
    -0.13723470f, -0.13294759f, -0.07848826f, -0.22095162f, 0.08618980f, -0.13348243f, 0.05862640f, 0.10826862f, 
    0.07153780f, 0.05601309f, -0.08553357f, -0.03036691f, 0.05827207f, 0.11430819f, 0.19420637f, -0.06988113f, 
    0.13585083f, 0.13341449f, -0.03966968f, -0.03945304f, -0.09706292f, 0.08564808f, 0.03850515f, 0.01958764f, 
    0.03577892f, 0.18603347f, -0.01005267f, 0.15728670f, 0.07780036f, -0.00731569f, -0.05540857f, -0.09255257f, 
    0.08034444f, -0.00446553f, -0.04884003f, 0.08575359f, -0.77591151f, 0.18479460f, -0.17448616f, -0.20068848f, 
    0.21932051f, -0.11968905f, -0.01671739f, -0.01229508f, 0.05114367f, -0.07201149f, 0.22290267f, -0.04627024f, 
    0.01008584f, -0.01268923f, -0.05599904f, -0.00610384f, -0.04613336f, -0.00037021f, -0.01624642f, -0.00244469f, 
    -0.05233037f, -0.02449890f, 0.01960530f, -0.02764654f, 0.01631462f, -0.01605923f, 0.03144868f, -0.04386844f, 
    -0.04172151f, -0.03375891f, 0.03802238f, 0.03277677f, -0.02995135f, -0.01361989f, -0.04908873f, 0.04623141f, 
    -0.01504190f, -0.00761832f, -0.04822689f, -0.03780769f, 0.02818869f, 0.00647304f, -0.04713330f, 0.02946566f, 
    0.01107956f, 0.04140484f, -0.03937084f, -0.03373582f, -0.00665896f, -0.00609641f, 0.02535528f, -0.00672813f, 
    -0.01096546f, 0.00050785f, -0.03023441f, 0.01956829f, -0.02442071f, -0.00796582f, 0.01375107f, 0.01726588f, 
    -0.02431575f, 0.04366435f, -0.00513737f, -0.00974660f, -0.02962853f, -0.05311428f, 0.03761703f, -0.04469630f, 
    -0.02605598f, 0.03630536f, 0.04027555f, -0.05421888f, 0.02494016f, -0.05183643f, -0.02874110f, 0.00052355f, 
    0.03419855f, 0.00471376f, -0.00462281f, -0.02946642f, -0.00279963f, -0.01109033f, 0.00302776f, 0.04323348f, 
    0.01565422f, -0.05247625f, -0.03696548f, -0.02030165f, 0.03297541f, 0.03143179f, -0.01588340f, 0.03649241f, 
    0.01051690f, 0.00451481f, 0.03427625f, -0.04962124f, -0.00784526f, 0.02476362f, -0.04403603f, -0.02214985f, 
    0.04295530f, -0.01901431f, -0.01885643f, 0.02795384f, -0.00515051f, 0.00830792f, -0.05087634f, 0.00386554f, 
    -0.04750432f, -0.00685556f, 0.01303070f, 0.01415336f, -0.03034951f, -0.04136289f, -0.03023880f, -0.03489601f, 
    0.01082571f, 0.03999333f, 0.01518686f, -0.04226080f, 0.02761613f, 0.01703358f, -0.02079659f, 0.00114763f, 
    -0.05496513f, -0.02024397f, -0.02673939f, -0.00018775f, -0.01398914f, 0.01873014f, 0.01683570f, -0.00185434f, 
    0.01649210f, -0.01358958f, -0.04969566f, -0.01642200f, 0.02273476f, 0.00076433f, 0.00188828f, -0.01993911f, 
    0.01293739f, -0.03782612f, 0.00475588f, 0.02715568f, 0.01957402f, -0.01420573f, 0.04778871f, -0.03253804f, 
    0.04576571f, 0.03160436f, -0.04745013f, -0.00873186f, -0.02746564f, 0.00507503f, -0.02669490f, -0.02788449f, 
    0.02879279f, 0.02882321f, -0.04569495f, 0.01601762f, -0.04609336f, -0.04468117f, -0.03088417f, -0.05052058f, 
    -0.03680861f, 0.01812550f, -0.05380689f, -0.02319416f, -0.05802670f, 0.02898696f, -0.04316601f, -0.03855148f, 
    0.03618945f, 0.02613847f, 0.02139016f, 0.02040474f, 0.03711699f, 0.02739509f, -0.04578149f, 0.02878033f, 
    0.02412875f, -0.05671862f, -0.03637474f, 0.04292249f, 0.03055935f, -0.04050746f, -0.02168177f, 0.03933880f, 
    0.01142698f, -0.01067411f, -0.00288861f, 0.01161814f, -0.05132709f, -0.04226564f, -0.04314958f, 0.00462967f, 
    0.00089775f, -0.04859128f, 0.02648524f, 0.03638703f, 0.02342596f, -0.01605235f, -0.02509109f, 0.00166624f, 
    0.00173908f, 0.02417767f, -0.04034342f, 0.03138295f, -0.01309669f, 0.04095702f, 0.00608695f, -0.01081164f, 
    0.00125902f, 0.03540518f, -0.03206808f, 0.03233180f, 0.02375881f, -0.00481372f, -0.04973563f, -0.00971684f, 
    0.02244089f, -0.00508175f, -0.01429565f, 0.00920191f, -0.00051665f, -0.02214938f, -0.03347640f, -0.04161362f, 
    0.00128947f, -0.02016086f, -0.03661067f, 0.02383754f, -0.02049255f, -0.00683715f, 0.04001632f, -0.01077611f, 
    -0.05723908f, 0.00394460f, -0.02534209f, -0.04762977f, 0.00682687f, -0.01055721f, 0.01697675f, 0.02766292f, 
    -0.02017428f, 0.03950533f, 0.00295071f, -0.00594711f, -0.02711879f, -0.05315319f, -0.01199588f, -0.02673794f, 
    -0.01025423f, -0.02370902f, -0.03100513f, 0.00022501f, -0.00001894f, -0.03313190f, -0.00080140f, 0.03231406f, 
    0.01674279f, -0.02398342f, 0.04407248f, 0.00349280f, 0.04106085f, -0.02546626f, -0.04606201f, -0.03073576f, 
    -0.02989201f, 0.01894520f, 0.03612938f, 0.04114729f, -0.04221148f, -0.00493008f, -0.00036356f, -0.00270019f, 
    -0.04674457f, 0.01701100f, -0.05459204f, 0.04114512f, 0.03881067f, 0.02737557f, 0.02144244f, -0.01036561f, 
    0.02888217f, -0.02252610f, 0.01222966f, 0.01746128f, -0.05249951f, 0.02243040f, -0.03094889f, 0.03617914f, 
    0.01111955f, -0.02238095f, 0.03800462f, -0.00319280f, 0.01730187f, 0.04677072f, -0.03331535f, -0.02526765f, 
    -0.02798379f, -0.03236162f, -0.03347000f, 0.02812997f, -0.00248148f, -0.04842529f, -0.05776819f, 0.01478676f, 
    0.01944198f, -0.01470009f, -0.05061194f, -0.02554559f, 0.00919733f, -0.01714047f, 0.01764735f, 0.03386886f, 
    0.03515507f, 0.03476787f, -0.05023322f, 0.03934138f, 0.01180638f, 0.01255235f, 0.03396937f, -0.02288665f, 
    -0.01520512f, 0.02410539f, -0.04863319f, -0.02240113f, -0.02732173f, -0.00300918f, -0.01596098f, 0.02959093f, 
    0.03969509f, 0.00254995f, 0.04054284f, -0.05234900f, -0.02306578f, 0.01492736f, -0.02204799f, -0.03089312f, 
    -0.05150816f, -0.03888606f, -0.04841199f, -0.05079842f, 0.03040033f, 0.03495708f, -0.01100333f, -0.01390085f, 
    0.03292136f, -0.00773325f, 0.00520648f, -0.03121317f, -0.00316100f, -0.03637883f, 0.03339719f, -0.05131855f, 
    0.00342079f, -0.05171149f, 0.01200569f, -0.00327330f, -0.01361002f, 0.00456624f, 0.04191415f, -0.02187757f, 
    -0.05043701f, 0.00888455f, 0.01660392f, 0.00403664f, -0.01985766f, 0.01447616f, -0.01397778f, 0.04300339f, 
    0.00062530f, 0.04835868f, -0.02256894f, -0.00469679f, -0.00386796f, 0.02202397f, -0.01454946f, 0.00586183f, 
    0.04045749f, 0.01391796f, 0.02575246f, 0.01405935f, 0.01416374f, 0.00270298f, -0.00499881f, -0.05903271f, 
    0.03424292f, 0.00125469f, -0.05175120f, -0.04672812f, 0.03615767f, 0.00323769f, -0.04163025f, -0.00678989f, 
    -0.40558019f, 0.12176097f, 0.17433949f, 0.04398552f, 0.09524703f, 0.08903915f, -0.14208184f, -0.03974921f, 
    -0.05554125f, 0.00923815f, 0.01589937f, -0.01241258f, -0.14190130f, 0.51517147f, 0.01544895f, -0.00282709f, 
    -0.02596530f, -0.04131779f, -0.03949118f, -0.18382223f, -0.08233031f, -0.06569272f, -0.25707784f, 0.05911009f, 
    -0.15858614f, 0.18330298f, 0.24056670f, 0.15157275f, -0.00294764f, 0.06272268f, 0.08385856f, 0.04368420f, 
    0.02182877f, 0.06421302f, -0.12727655f, 0.04024895f, -0.18050808f, 0.41044483f, 0.03415065f, 0.05027512f, 
    0.08333207f, 0.09742006f, 0.15499182f, 0.06965090f, -0.13802329f, 0.10473807f, 0.09517574f, -0.05509153f, 
    -0.03100363f, 0.15315211f, 0.21918198f, 0.09264044f, 0.05672638f, 0.05166943f, -0.02963085f, 0.00399377f, 
    -0.11795621f, 0.03816150f, -0.04122789f, -0.09181080f, 0.03032088f, -0.04641913f, 0.31010064f, -0.00459390f, 
    0.14291804f, -0.07961723f, -0.02681500f, 0.09611270f, -0.06522039f, -0.03953892f, 0.12683025f, 0.16408391f, 
    0.03016192f, -0.14543074f, -0.17352742f, 0.17787158f, 0.04468311f, 0.01717031f, 0.01462100f, 0.14673653f, 
    0.01904119f, -0.06790804f, 0.09408675f, 0.01838607f, 0.16439942f, 0.00374101f, 0.08806086f, -0.11553380f, 
    -0.08954944f, -0.10231123f, 0.13205600f, -0.06399757f, -0.15561980f, -0.10756779f, 0.08237835f, -0.07698697f, 
    -0.27312118f, -0.01061288f, 0.01927423f, -0.11426245f, 0.03382944f, 0.12528212f, -0.17323554f, 0.01549855f, 
    0.10836767f, 0.01919389f, 0.05490967f, 0.03901003f, 0.45527944f, 0.08295552f, -0.02841546f, 0.17104158f, 
    0.28841615f, 0.13230982f, 0.02199329f, 0.00711811f, 0.02505057f, -0.05639284f, -0.05297385f, -0.07942772f, 
    -0.39481187f, -0.22475572f, -0.03508645f, 0.02259216f, -0.20304666f, -0.06905901f, 0.06436735f, -0.05416751f, 
    -0.04172222f, -0.07209262f, 0.00479037f, -0.02874190f, 0.15893276f, -0.17856325f, -0.01002960f, -0.02017444f, 
    -0.11992316f, -0.12649043f, 0.06696552f, -0.09109514f, 0.11688836f, 0.01230090f, 0.06789267f, -0.15369792f, 
    0.21548338f, -0.15396751f, -0.11034656f, 0.17688145f, 0.04014198f, 0.05700734f, -0.05309555f, 0.13299400f, 
    -0.05496605f, 0.02218641f, 0.11594127f, 0.02911408f, -0.22171125f, 0.06864542f, 0.03808014f, -0.16300155f, 
    -0.05684852f, -0.00741122f, -0.03961581f, 0.09561407f, 0.02024856f, -0.06959766f, -0.04078598f, -0.10090145f, 
    0.16964471f, 0.14165160f, -0.00421343f, -0.07551327f, -0.15279312f, 0.08013618f, 0.05776794f, 0.06013598f, 
    0.00783103f, -0.06696645f, 0.06205228f, -0.06483731f, -0.20442493f, -0.02153899f, 0.01399360f, -0.17893359f, 
    -0.07080697f, 0.05277956f, -0.05464035f, 0.07724203f, -0.09077016f, -0.20718998f, 0.02060706f, 0.05644781f, 
    0.17265689f, -0.15044858f, -0.03882054f, 0.08390754f, 0.19289522f, -0.02975593f, 0.05471867f, 0.00383986f, 
    0.11320066f, 0.15754880f, 0.03771204f, 0.04090572f, -0.10203382f, -0.19214211f, 0.10936614f, 0.19004004f, 
    0.04951309f, 0.09619522f, 0.05003417f, 0.08127386f, -0.06147454f, 0.11295278f, 0.01078350f, -0.01608623f, 
    -0.05652865f, -0.20484032f, 0.23126455f, -0.03003565f, 0.04427216f, 0.01904139f, -0.10240856f, 0.18477865f, 
    -0.05776661f, -0.00532112f, 0.03469411f, 0.08878711f, 0.20497406f, -0.41213790f, -0.10917833f, -0.04801582f, 
    0.00804167f, 0.02126836f, 0.01900301f, -0.03784264f, 0.06152985f, 0.02592762f, 0.06231334f, 0.12214636f, 
    -0.09038994f, 0.10594878f, 0.14194176f, 0.30543628f, 0.18325518f, 0.06330495f, 0.05993585f, 0.22212712f, 
    0.10879093f, -0.05643118f, 0.06374069f, 0.09599926f, 0.44469365f, 0.09976410f, -0.03976199f, -0.02025369f, 
    -0.09251276f, 0.02238143f, 0.00731667f, -0.00652972f, 0.06647719f, -0.04890412f, 0.05764404f, -0.08673502f, 
    -0.12682992f, -0.10529437f, -0.04327628f, 0.07069775f, -0.03945493f, 0.20410964f, 0.00294032f, -0.07402521f, 
    -0.04645091f, 0.13681418f, -0.00840664f, 0.10148621f, 0.22495875f, -0.37534606f, 0.10256815f, 0.10530082f, 
    0.17449503f, -0.00440241f, 0.11596032f, -0.22008418f, 0.07068387f, -0.14184661f, -0.04809097f, 0.01676628f, 
    0.18254223f, -0.02073334f, 0.14165236f, 0.13565032f, -0.03726118f, -0.01875711f, -0.01545841f, 0.12109911f, 
    0.00506029f, -0.03754840f, -0.09120414f, 0.09085585f, -0.09453572f, 0.09686941f, 0.08736291f, 0.09593946f, 
    0.08373190f, -0.02131622f, 0.12831874f, 0.16222841f, -0.00942886f, -0.10024507f, 0.16072279f, 0.07402291f, 
    0.33173656f, 0.41079342f, -0.01709424f, 0.02697675f, 0.08774570f, 0.07878194f, -0.03427196f, -0.05667735f, 
    -0.16664454f, 0.06406544f, -0.06246606f, -0.00557920f, 0.00082108f, -0.04072090f, -0.00114632f, 0.20628123f, 
    0.04483746f, 0.06176870f, -0.12690972f, 0.08630629f, -0.03503577f, -0.00333506f, 0.18190575f, 0.07681347f, 
    -0.11743440f, 0.12447689f, 0.09540040f, 0.10495666f, 0.13336942f, -0.03493873f, -0.15815260f, 0.00773794f, 
    0.13029400f, 0.00147531f, -0.05638520f, 0.05714029f, 0.32979146f, 0.15109342f, 0.13649516f, 0.25756627f, 
    0.04444963f, -0.03447872f, 0.08292510f, -0.03909159f, 0.05524168f, 0.12381772f, 0.02011922f, 0.04184446f, 
    0.35462767f, 0.41143996f, 0.12528002f, -0.00296523f, 0.05593662f, -0.05628037f, 0.08700392f, 0.02875241f, 
    -0.07633763f, -0.00099577f, -0.04449012f, -0.06410435f, -0.06351931f, -0.09081230f, -0.06180317f, -0.11300435f, 
    -0.00537375f, 0.06151074f, -0.06114228f, 0.00058081f, 0.01580747f, 0.04607093f, 0.09784809f, 0.08180328f, 
    -0.02343564f, 0.04361692f, 0.01349635f, -0.04282958f, 0.04360403f, -0.02281941f, -0.03328053f, -0.00549622f, 
    0.04241893f, -0.01777723f, -0.00470243f, 0.02561561f, -0.02632033f, -0.05018998f, -0.05607563f, 0.01437946f, 
    0.01314463f, -0.00563342f, -0.04715682f, 0.02611672f, -0.05392665f, -0.05645765f, 0.00964591f, -0.01237685f, 
    0.02103142f, -0.01099296f, -0.00049364f, 0.03203439f, 0.01011514f, -0.00453621f, 0.01396861f, 0.04106658f, 
    -0.00261826f, -0.01827504f, -0.04286910f, -0.00516094f, -0.00237446f, -0.03129650f, -0.01722218f, -0.04182821f, 
    -0.00279537f, -0.01620492f, 0.03814033f, -0.02821181f, 0.00120641f, 0.00047249f, -0.00182742f, -0.01602275f, 
    -0.03010470f, -0.01454929f, 0.03664964f, 0.01263234f, -0.03852746f, 0.03919237f, 0.03945453f, -0.04485454f, 
    0.01651216f, 0.00589955f, -0.00133760f, -0.04641242f, -0.00803562f, -0.05000958f, -0.03532349f, -0.05643446f, 
    -0.01797169f, -0.04229898f, 0.03992428f, 0.03159045f, -0.00348372f, -0.00184409f, -0.03576769f, -0.00094443f, 
    0.04665096f, 0.01832201f, 0.00258352f, 0.01251030f, 0.02661477f, -0.04846309f, 0.01792787f, -0.00395638f, 
    0.03197667f, -0.04431058f, -0.03867095f, -0.03344184f, -0.05247040f, 0.01027354f, 0.03589970f, -0.00688537f, 
    0.01800545f, -0.02466423f, 0.00974650f, 0.02114350f, -0.00643760f, 0.04245863f, 0.00184059f, 0.03422444f, 
    0.01060975f, -0.03575075f, -0.04202599f, -0.04331435f, -0.05528214f, 0.01829170f, -0.02892550f, 0.00362140f, 
    0.00735647f, 0.03049847f, -0.00319187f, -0.05092686f, -0.02140756f, -0.00260342f, -0.00623112f, 0.02174572f, 
    -0.05315978f, -0.01432420f, -0.03753113f, -0.02543051f, -0.02447388f, 0.01411230f, -0.00250755f, -0.00118071f, 
    -0.02933588f, -0.04098479f, -0.01758739f, 0.00241594f, -0.03409177f, 0.01914638f, -0.00346335f, -0.03562900f, 
    -0.00393895f, 0.00675133f, -0.04227675f, -0.04616385f, -0.04670020f, 0.00616356f, -0.02137850f, -0.05531039f, 
    0.02465286f, 0.04117962f, -0.01153776f, -0.01374447f, -0.05593130f, 0.01479431f, -0.03082465f, -0.02025407f, 
    0.01840015f, -0.00083120f, -0.04980257f, 0.03165322f, -0.04387235f, -0.05400477f, 0.02768152f, -0.05317163f, 
    -0.04435480f, 0.00055452f, -0.02538420f, -0.01454352f, -0.04007803f, -0.03650267f, -0.03318650f, 0.03997142f, 
    -0.02297200f, -0.02889588f, 0.01188644f, 0.02439871f, 0.02733175f, -0.02286847f, -0.02108262f, -0.02631088f, 
    -0.00770023f, -0.03919967f, -0.05111174f, 0.04460739f, -0.02111883f, 0.02124236f, -0.00375665f, -0.01730878f, 
    0.04076988f, 0.01587897f, -0.00192374f, -0.01809668f, -0.04391769f, -0.05424391f, 0.03420650f, -0.01454599f, 
    -0.03933356f, 0.01291034f, 0.03488024f, 0.02855766f, -0.04703984f, 0.03089082f, -0.03785428f, 0.00261714f, 
    -0.04786767f, -0.03225808f, -0.04412566f, 0.01390129f, 0.03212417f, -0.01659487f, 0.03254514f, -0.05044129f, 
    0.02382989f, -0.03677342f, -0.01872279f, 0.03618617f, -0.04496009f, 0.01653025f, -0.03477052f, -0.04090974f, 
    -0.00766670f, -0.03468543f, -0.03294433f, -0.03904227f, -0.04674999f, -0.01514640f, 0.00172977f, 0.00991373f, 
    -0.00346415f, -0.03995162f, -0.01085861f, -0.01477893f, 0.02969830f, -0.03840679f, 0.00623158f, -0.04875560f, 
    0.02677534f, 0.00473966f, -0.03518848f, -0.00544703f, -0.02845654f, -0.00824741f, -0.00480099f, -0.01119552f, 
    0.02905323f, -0.05518213f, 0.03164597f, 0.00248948f, 0.02255064f, 0.02885984f, -0.04165633f, 0.02811264f, 
    0.02145444f, 0.03245002f, 0.02772796f, -0.02797759f, 0.02544903f, 0.02836024f, 0.02111817f, -0.02330918f, 
    -0.01638595f, 0.00332224f, -0.02669671f, -0.03508976f, -0.03193284f, 0.02845749f, -0.04886012f, -0.05405980f, 
    -0.05180941f, -0.02002895f, -0.00828947f, 0.00454132f, 0.02865431f, 0.01928081f, -0.02678119f, 0.00594276f, 
    -0.02973807f, 0.02622510f, 0.01799509f, -0.01988541f, -0.01618460f, -0.04562216f, 0.03834687f, -0.04213829f, 
    0.04278307f, -0.03931045f, 0.02460144f, -0.02605866f, -0.04011312f, -0.00529139f, -0.02979224f, -0.01477555f, 
    0.01755443f, -0.01302523f, 0.04371059f, -0.00123829f, -0.01010656f, -0.01438515f, 0.00406154f, 0.04064209f, 
    -0.02246704f, 0.00549562f, -0.00252251f, -0.00872803f, -0.00174979f, 0.03791018f, 0.04184742f, -0.02034711f, 
    0.04380945f, -0.03484964f, 0.01490822f, -0.02739103f, -0.00039683f, 0.02055745f, 0.04327174f, -0.00174013f, 
    -0.05224031f, -0.03257310f, -0.04273761f, -0.03473444f, -0.04297289f, -0.02905664f, 0.00545821f, 0.00842370f, 
    -0.00680486f, 0.03942164f, -0.01578427f, 0.00742743f, -0.04852851f, -0.04013840f, 0.01671457f, 0.02879909f, 
    -0.05456288f, 0.03704619f, -0.00426725f, -0.00526659f, 0.04445489f, 0.01176196f, -0.03240426f, -0.03700861f, 
    0.02027716f, -0.03812374f, -0.04597976f, -0.01585853f, -0.00471588f, -0.04043747f, 0.02793137f, -0.01890144f, 
    -0.03413924f, -0.05665239f, 0.02805385f, -0.01338792f, -0.02201463f, -0.00564350f, -0.05508688f, 0.04056948f, 
    -0.02522083f, -0.04729525f, -0.03868469f, 0.03250287f, 0.02545043f, -0.01476269f, -0.04959379f, -0.03768766f, 
    0.03159414f, -0.00218346f, 0.02956000f, -0.04182466f, 0.00798835f, -0.03916136f, 0.02141720f, -0.04252667f, 
    -0.03673200f, -0.00161373f, -0.03725898f, -0.00052160f, 0.03296390f, -0.02764014f, 0.03348324f, 0.00257100f, 
    0.04946684f, 0.03326455f, 0.02964505f, -0.00445793f, 0.04353578f, 0.02891144f, 0.02615700f, 0.00353149f, 
    0.01123008f, -0.02473892f, -0.01606020f, -0.01161136f, -0.02776421f, -0.00926888f, -0.05054883f, -0.03237227f, 
    -0.14667007f, 0.21484141f, -0.04190617f, 0.09629105f, -0.02791904f, -0.06725102f, 0.07415446f, -0.07240604f, 
    -0.00121008f, 0.08001899f, 0.01062632f, 0.03857139f, 0.01781878f, 0.16492356f, -0.01950792f, -0.00837423f, 
    -0.09192959f, 0.14014319f, -0.09796451f, -0.02698932f, -0.03075443f, -0.00086060f, 0.01151454f, -0.07790952f, 
    -0.02235933f, -0.06507961f, -0.05963186f, 0.10304290f, -0.01601432f, -0.00908940f, -0.06657790f, -0.03679805f, 
    0.10733818f, 0.10616794f, -0.03748107f, 0.11960799f, 0.31730849f, -0.14028104f, -0.17842992f, 0.16410498f, 
    0.03841864f, 0.05370302f, 0.05357407f, 0.16005774f, -0.12615149f, -0.02739716f, -0.07976346f, 0.07214203f, 
    0.02897810f, -0.22504732f, -0.10741349f, 0.20924006f, -0.00167722f, -0.02651328f, 0.06903108f, 0.07064051f, 
    0.03949751f, -0.03738339f, -0.02369316f, 0.08843230f, 0.02286218f, -0.22680841f, 0.05473921f, -0.14167625f, 
    0.07801913f, 0.01564164f, -0.00113283f, 0.07344002f, 0.03264462f, -0.02812380f, -0.06379868f, -0.00534488f, 
    0.13387375f, 0.15246080f, -0.10776416f, 0.13246049f, -0.10327230f, -0.05992758f, 0.11958292f, 0.16969550f, 
    0.01988842f, 0.00096966f, -0.00364703f, -0.02699181f, 0.23844735f, -0.16870670f, 0.11730059f, -0.17198764f, 
    -0.07454326f, 0.03483640f, 0.04589099f, 0.02166903f, -0.08270612f, 0.02713698f, -0.02729988f, 0.05522509f, 
    -0.11458133f, 0.07835492f, -0.06670058f, 0.18198882f, -0.03613650f, -0.01593760f, -0.15600128f, 0.08484862f, 
    0.01123287f, -0.04582199f, -0.01508229f, 0.06175745f, 0.03709228f, -0.24088942f, 0.15004256f, -0.17744273f, 
    -0.01672807f, 0.04882835f, 0.05089255f, 0.00149343f, -0.01485407f, -0.04917435f, -0.01228314f, -0.03308591f, 
    -0.01911192f, -0.14644897f, 0.28828362f, 0.11080765f, 0.01056765f, 0.09647422f, 0.03798976f, -0.01068786f, 
    0.07332064f, 0.00293747f, 0.07283469f, -0.08733185f, 0.32781321f, -0.11553428f, 0.08099326f, 0.10781083f, 
    0.02331052f, 0.08873439f, 0.01125789f, -0.12099862f, 0.01521176f, 0.01322674f, 0.09589348f, -0.01171879f, 
    -0.00667070f, 0.02188441f, 0.01178290f, -0.06592172f, -0.03061656f, 0.00305682f, -0.09431292f, 0.08019874f, 
    -0.03612427f, 0.04570080f, 0.05936228f, 0.06464565f, -0.04403003f, -0.05112191f, 0.03827535f, 0.18953866f, 
    0.02697632f, 0.03233123f, -0.02637478f, 0.13020146f, 0.00492537f, -0.04054536f, -0.04689255f, -0.02898281f, 
    0.31294358f, -0.19821376f, -0.14150557f, 0.01485931f, 0.00224815f, 0.10988923f, -0.08404113f, -0.01585091f, 
    0.02313737f, -0.04095025f, 0.06772457f, 0.08222479f, -0.09401392f, -0.01221495f, 0.05165153f, 0.02430851f, 
    0.02414910f, 0.09354386f, -0.14910209f, 0.08883882f, 0.01652689f, -0.05964402f, 0.04447707f, 0.14474416f, 
    -0.02054429f, 0.09002524f, 0.28052881f, -0.02988571f, -0.06519873f, 0.03990305f, -0.02796838f, 0.14697950f, 
    -0.10146214f, 0.08899873f, 0.05413192f, -0.01602451f, 0.12655228f, -0.01577086f, -0.17977755f, 0.17446907f, 
    -0.07239573f, -0.00335092f, -0.07258842f, -0.04379143f, -0.03238782f, 0.01790757f, -0.00320686f, 0.06842956f, 
    0.21992695f, 0.00565389f, 0.09337037f, -0.02264270f, -0.05220041f, 0.01718176f, 0.02345909f, 0.09065447f, 
    0.02274715f, 0.08431196f, -0.03677354f, 0.00699915f, -0.42719078f, 0.20209552f, 0.16598190f, 0.02019310f, 
    0.01028434f, 0.03638537f, -0.03360538f, -0.00160063f, 0.10182216f, -0.04658091f, -0.00819428f, -0.07365505f, 
    0.18223780f, -0.23050459f, -0.04639221f, -0.09192326f, -0.05663651f, -0.04305699f, 0.05337986f, 0.11051486f, 
    0.06341492f, 0.01713401f, -0.01889903f, -0.01762295f, 0.23236485f, -0.34894803f, -0.05586971f, -0.06211538f, 
    -0.09019729f, 0.09790261f, -0.04171079f, -0.00967559f, 0.03053509f, 0.10285755f, -0.02292985f, -0.01064480f, 
    0.31597307f, 0.00838649f, -0.04146375f, 0.21708792f, -0.12613815f, 0.05956722f, -0.02996686f, -0.10719339f, 
    -0.06246399f, 0.00114513f, 0.02713288f, 0.08815764f, 0.02206185f, -0.07419688f, 0.30796355f, -0.12423934f, 
    0.00375784f, -0.06757337f, -0.03399718f, -0.00223141f, 0.19417839f, -0.03636878f, 0.02364984f, 0.05145597f, 
    0.20985764f, -0.09396257f, 0.01652762f, -0.18763958f, -0.00350877f, 0.06596365f, -0.12040134f, -0.06177995f, 
    0.06919370f, 0.11837960f, -0.02069450f, 0.00709118f, 0.11696841f, 0.07383383f, 0.12733667f, -0.11303549f, 
    -0.10171703f, -0.00162477f, 0.06684132f, 0.10360044f, 0.06258132f, 0.02076343f, -0.10747933f, 0.10821156f, 
    0.27476618f, -0.13001959f, -0.06061543f, 0.03430229f, 0.06938398f, 0.03748072f, 0.13257173f, 0.00859960f, 
    0.00760877f, -0.07098192f, -0.12579639f, 0.04445266f, -0.17639056f, -0.02303739f, 0.10334825f, 0.00383714f, 
    0.10832514f, 0.05654905f, 0.04028920f, -0.09169772f, -0.02504482f, 0.03093633f, 0.02788681f, -0.01134904f, 
    -0.13495980f, 0.15862076f, -0.12035580f, -0.03231345f, 0.13988481f, 0.09375931f, -0.04005124f, 0.06273128f, 
    0.03138537f, 0.13426270f, 0.06748395f, -0.04905439f, 0.07805622f, -0.21384795f, 0.00786383f, 0.02920100f, 
    -0.07736241f, -0.03367537f, 0.07840487f, 0.08827038f, 0.02125595f, -0.04579490f, 0.07741387f, 0.09361479f, 
    0.21400343f, -0.27055147f, 0.31457239f, -0.00075332f, -0.10898430f, 0.00318559f, 0.13117808f, 0.09879567f, 
    -0.01915738f, 0.08739196f, -0.01536700f, 0.07611240f, -0.56231821f, 0.20105815f, -0.07403570f, 0.22447708f, 
    0.02849044f, 0.01397424f, 0.07271356f, 0.00425134f, -0.10785692f, 0.05594050f, -0.02738493f, 0.06801432f, 
    -0.19407429f, 0.12263873f, 0.08828153f, 0.02896351f, -0.03151348f, -0.04139791f, 0.12732558f, 0.02347721f, 
    0.04363028f, -0.06134235f, 0.03240379f, 0.04931349f, -0.23067856f, 0.09819924f, -0.02472582f, -0.22950473f, 
    0.06722120f, 0.01814969f, 0.19664364f, 0.00398179f, 0.02212071f, -0.02393832f, -0.01249291f, 0.11010031f, 
    -0.06416322f, 0.03178971f, 0.05432416f, 0.10013064f, 0.02769491f, 0.08042692f, -0.00013817f, 0.02490218f, 
    0.02158215f, 0.10842367f, 0.03059427f, 0.00792798f, 0.03084117f, 0.24293420f, 0.06911213f, -0.26738930f, 
    0.06580786f, 0.04013678f, 0.06320679f, 0.02271292f, 0.14996482f, -0.12050045f, 0.17905699f, 0.00509963f, 
    -0.33316487f, 0.06179143f, 0.01133244f, -0.22524217f, -0.02329873f, -0.08203002f, -0.14776734f, -0.06070002f, 
    0.04345855f, 0.07556774f, 0.03522311f, 0.18679450f, -0.02930713f, 0.02219998f, -0.11883813f, 0.28906721f, 
    0.01279629f, -0.02272847f, -0.01409471f, 0.02370733f, -0.06513651f, 0.02197994f, 0.00940069f, 0.02033692f, 
    -0.01351830f, 0.17186505f, -0.11677688f, 0.15486979f, 0.05677454f, -0.04836355f, -0.05190961f, -0.16511820f, 
    0.02158056f, -0.01220964f, -0.04142001f, -0.07229053f, -0.19111939f, -0.01871008f, -0.00893972f, 0.28477451f, 
    0.02994606f, 0.00830153f, -0.03499179f, -0.08966909f, 0.07635640f, -0.00875151f, -0.04441182f, -0.03540085f, 
    -0.00351993f, 0.06213159f, 0.08393731f, -0.08704364f, 0.10690864f, -0.02197777f, 0.02394503f, 0.05011872f, 
    -0.01535734f, 0.11259877f, -0.02143472f, 0.07866333f, -0.24206793f, -0.01650990f, -0.05385299f, 0.19652937f, 
    0.12049886f, 0.00408230f, -0.11201077f, 0.06909765f, -0.00522515f, 0.08981161f, -0.06822331f, -0.05670687f, 
    -0.02767664f, 0.02516215f, 0.01081520f, 0.23636110f, 0.12469379f, 0.00133683f, 0.03611607f, -0.00768172f, 
    -0.00343054f, -0.02591546f, 0.01333114f, -0.11179647f, 0.01821528f, 0.00372064f, 0.04368624f, -0.02554764f, 
    -0.03640493f, 0.03396641f, -0.02849551f, -0.07548328f, 0.00050425f, -0.06815746f, 0.08645497f, -0.05823557f, 
    -0.21120805f, 0.00151588f, 0.21886727f, 0.07233798f, 0.07145460f, -0.01937137f, -0.02512855f, -0.07502883f, 
    0.09704339f, 0.09987719f, 0.10266105f, 0.14637104f, -0.27842158f, -0.00063671f, -0.02984638f, -0.01668015f, 
    0.01741077f, 0.08417482f, -0.13335329f, 0.00227946f, 0.08555643f, -0.02526634f, -0.12204354f, -0.03384635f, 
    -0.33644101f, -0.13542999f, 0.21701068f, -0.01269730f, 0.07388205f, 0.05871171f, 0.01539783f, -0.01401129f, 
    0.11951639f, 0.09776967f, -0.08105098f, 0.04402972f, 0.23563553f, 0.04691311f, 0.15871093f, -0.08393081f, 
    0.05750721f, 0.07279311f, 0.02988024f, -0.01444953f, 0.08867025f, -0.10070606f, 0.05238928f, 0.03913450f, 
    0.02473529f, -0.08560574f, 0.00870167f, 0.20399326f, -0.05317053f, -0.13683847f, 0.12051302f, -0.04463810f, 
    0.09503351f, 0.14127389f, 0.02744533f, 0.05265986f, 0.01858477f, 0.07375524f, -0.02457260f, -0.02395308f, 
    0.00718547f, 0.10444215f, 0.05737786f, -0.01140139f, 0.20684671f, -0.03339987f, -0.02659972f, -0.14316912f, 
    0.30067486f, -0.07566962f, 0.04391000f, 0.11708640f, 0.01689614f, 0.02151796f, 0.05683952f, -0.08650439f, 
    -0.01550766f, 0.19290605f, -0.11899021f, -0.00229525f, -0.03959749f, -0.01435896f, 0.28685483f, 0.01230591f, 
    0.01627200f, 0.11305505f, 0.00489939f, -0.01925379f, -0.06563576f, 0.02628736f, 0.02201447f, 0.01005092f, 
    0.03065748f, 0.10482275f, -0.07420995f, 0.17475967f, -0.12197568f, 0.02899943f, -0.00270834f, -0.02589360f, 
    -0.14638408f, -0.11131019f, 0.01035500f, -0.02398981f, -0.50150251f, 0.01696199f, -0.10565364f, 0.09311563f, 
    0.03483448f, 0.16704291f, 0.09577686f, 0.02148178f, 0.04025679f, 0.03992510f, 0.02315976f, -0.00271126f, 
    0.12768574f, 0.04649663f, 0.05492748f, 0.27068526f, 0.11542764f, 0.05480690f, 0.01091262f, 0.03871182f, 
    0.11217785f, 0.10599881f, 0.11594469f, -0.02091692f, 0.37428468f, 0.15431489f, -0.09520240f, 0.08037986f, 
    0.04722523f, 0.00104935f, -0.04190690f, 0.08174852f, -0.09843381f, 0.00448141f, -0.03726270f, -0.04882962f, 
    -0.15904126f, 0.01753697f, 0.06105492f, 0.08275802f, -0.11768059f, 0.20047371f, 0.02387711f, 0.05299192f, 
    0.04626459f, 0.09008592f, -0.01144092f, 0.07683967f, 0.01629051f, 0.20731543f, 0.06675945f, 0.21227355f, 
    -0.11323611f, 0.09249565f, 0.10340663f, 0.04735274f, -0.00725659f, 0.06715323f, 0.13345957f, 0.16974391f, 
    -0.32309648f, 0.14212069f, -0.13910674f, -0.18150528f, 0.07217342f, 0.12905604f, 0.02934740f, -0.05450985f, 
    0.02091588f, 0.04250129f, -0.01728992f, -0.10564869f, -0.16994265f, -0.14506732f, 0.01137874f, 0.44553295f, 
    -0.01507245f, 0.00797726f, 0.24854910f, 0.01955502f, 0.02312099f, -0.12862368f, 0.06562854f, 0.07271669f, 
    -0.34223950f, 0.01715801f, -0.11074682f, -0.00646707f, -0.07888359f, 0.03922259f, 0.10399987f, 0.13669150f, 
    -0.00021087f, -0.09500169f, 0.10665809f, 0.09392092f, -0.27187902f, 0.02146313f, 0.06503236f, -0.12030383f, 
    0.02280750f, 0.08872297f, 0.13043869f, 0.01369914f, 0.05190860f, 0.09192083f, 0.09964494f, 0.13626978f, 
    -0.45749447f, 0.06696609f, -0.27054349f, 0.18899521f, 0.02301320f, 0.14078811f, 0.12488761f, 0.05024849f, 
    0.10231878f, -0.11899409f, -0.00389748f, -0.03897249f, 0.26291582f, -0.10767706f, 0.01177277f, -0.15859480f, 
    0.08117631f, 0.04629513f, 0.14743145f, 0.07744367f, 0.04923256f, 0.00415383f, -0.06202854f, 0.15103105f, 
    0.03019948f, 0.03994408f, -0.00162284f, -0.01987685f, 0.00528168f, -0.03565842f, -0.00014917f, -0.05642505f, 
    -0.01193086f, -0.01600074f, -0.04891885f, 0.02129138f, -0.04206125f, 0.00467206f, -0.02330786f, 0.02339119f, 
    0.02583730f, -0.05035124f, 0.00886794f, 0.02061527f, 0.01364130f, -0.04272629f, -0.04667092f, 0.02479799f, 
    0.01438075f, 0.00271719f, -0.00684214f, 0.01751777f, 0.03004579f, -0.04523806f, -0.00972818f, -0.00598090f, 
    -0.01164637f, 0.01206024f, 0.03708816f, -0.03164922f, 0.04001882f, 0.00678437f, -0.05797961f, 0.02160186f, 
    -0.04804254f, 0.03065951f, -0.01256111f, 0.02057820f, -0.01660847f, 0.01950298f, 0.00103231f, -0.04283565f, 
    -0.01444032f, -0.04597060f, -0.04033437f, -0.04515642f, -0.04536110f, 0.03140158f, -0.04891357f, -0.03237348f, 
    -0.01136338f, 0.02878862f, -0.01238626f, -0.02742077f, -0.04708384f, 0.03387837f, -0.06071615f, -0.03637045f, 
    -0.02951131f, 0.04039448f, -0.00396650f, -0.02379852f, -0.03658988f, 0.02462089f, -0.03085603f, -0.02420284f, 
    -0.00426379f, 0.03747523f, -0.06072413f, 0.01912152f, -0.03958118f, 0.02942573f, 0.03501243f, -0.04141642f, 
    -0.03354971f, 0.00930640f, -0.04435499f, -0.02494081f, 0.02402750f, -0.04775579f, 0.01371940f, 0.00379044f, 
    -0.02943163f, -0.04903735f, 0.03323671f, 0.01671361f, -0.03742866f, -0.05504894f, 0.02794001f, 0.03823148f, 
    -0.00743164f, -0.03618094f, 0.02656835f, -0.02572629f, -0.05171205f, 0.01787264f, 0.01955335f, 0.03417546f, 
    0.01914372f, -0.00316002f, -0.01076085f, 0.02159906f, -0.04826281f, -0.04342280f, 0.01545864f, -0.04768818f, 
    0.03265610f, -0.00507322f, -0.03028469f, 0.03277925f, -0.03258094f, 0.03458155f, -0.04207406f, 0.03139420f, 
    -0.02929671f, 0.02755165f, 0.01114023f, 0.00185304f, -0.04893024f, -0.00616850f, 0.02229672f, -0.04456657f, 
    0.02012815f, -0.01011489f, -0.01937366f, 0.02976105f, 0.02877158f, 0.02833324f, 0.02370589f, -0.01659203f, 
    0.01601064f, -0.01669623f, -0.02375706f, 0.02328109f, -0.04277633f, -0.01856071f, -0.00726488f, -0.04321120f, 
    0.02107522f, -0.04863710f, -0.04314575f, 0.00010743f, -0.04848634f, -0.03878844f, 0.01579566f, 0.04783421f, 
    -0.04417466f, -0.02941587f, 0.00906275f, -0.01819639f, -0.02312290f, 0.03390218f, -0.03249878f, -0.04322868f, 
    -0.00163515f, -0.04005698f, 0.00336536f, -0.01671218f, -0.05236821f, -0.01277894f, -0.02813393f, -0.00377831f, 
    -0.03545797f, -0.05068814f, 0.02240056f, -0.00990492f, -0.03166763f, 0.03125098f, 0.03972076f, 0.00600332f, 
    -0.00830316f, -0.00731795f, -0.03005546f, -0.01237470f, 0.03084765f, -0.02428151f, 0.01588297f, 0.01145444f, 
    -0.03726554f, 0.00815759f, 0.03080005f, 0.03040971f, 0.01573955f, -0.00082010f, -0.04363703f, -0.02237810f, 
    0.00513940f, -0.00288786f, -0.00142748f, -0.02702004f, -0.00131614f, -0.04226457f, 0.04002704f, 0.03112528f, 
    -0.05416986f, -0.05411175f, 0.01185946f, -0.03734176f, -0.01297004f, -0.00387554f, -0.03274551f, 0.01626969f, 
    0.03196407f, 0.02483147f, 0.04182756f, 0.04776442f, -0.05742930f, -0.03905065f, 0.01318470f, -0.04851041f, 
    -0.04474188f, -0.02446639f, -0.02531554f, 0.01816128f, 0.04808357f, -0.02209052f, -0.03136389f, 0.00686983f, 
    0.01399343f, -0.01884902f, -0.04363406f, 0.01593524f, -0.03163074f, -0.02778327f, -0.00364412f, -0.01086075f, 
    0.03848278f, -0.03661776f, 0.02629734f, 0.02961767f, 0.01112228f, 0.03776287f, 0.03785723f, -0.04484179f, 
    -0.02120274f, 0.03825968f, 0.03129478f, -0.02381187f, -0.01331628f, 0.00309865f, -0.00818135f, -0.01641838f, 
    -0.00430790f, 0.02064417f, 0.04346548f, -0.01424501f, 0.03244191f, 0.01781199f, -0.04199600f, -0.01766345f, 
    0.00266035f, 0.01574672f, 0.00361361f, -0.00915769f, -0.04352143f, -0.03919184f, 0.02818612f, -0.03013716f, 
    -0.04105862f, -0.02851305f, 0.00577056f, 0.00885340f, 0.03298965f, -0.04936463f, -0.03703480f, -0.00719846f, 
    0.03001671f, 0.00409145f, 0.03083600f, -0.03979624f, -0.05124749f, 0.00758064f, -0.04196143f, -0.03683806f, 
    0.00551962f, -0.04346609f, -0.05044792f, -0.03247212f, -0.03935171f, 0.03519316f, 0.03248648f, -0.03550124f, 
    -0.02595638f, 0.01635627f, 0.03327343f, -0.00408222f, -0.00270982f, -0.00602246f, -0.03343188f, 0.04108093f, 
    -0.03700406f, -0.01269503f, -0.03745282f, 0.00568597f, 0.03126850f, -0.03517675f, -0.02642329f, 0.01383483f, 
    -0.02430573f, -0.00017075f, -0.06181151f, 0.00379171f, -0.04742733f, 0.01140088f, -0.00450205f, -0.01652618f, 
    0.00825487f, 0.03024639f, 0.00403804f, -0.05567730f, 0.01757731f, 0.02611442f, -0.02120644f, -0.02905831f, 
    -0.00469336f, 0.04241442f, 0.00642776f, 0.00963286f, -0.04089886f, -0.02114837f, 0.04715436f, -0.00109508f, 
    -0.01207207f, 0.01985715f, 0.01497961f, -0.00251853f, 0.03057810f, -0.02853270f, 0.04292306f, -0.02943363f, 
    -0.04689464f, 0.03966420f, -0.04222167f, -0.04069480f, 0.03221163f, 0.03789788f, 0.02902352f, 0.03187002f, 
    -0.04245965f, 0.02501688f, 0.00265248f, 0.01559071f, 0.01332719f, 0.01998992f, -0.05043999f, -0.04700926f, 
    -0.03846608f, 0.00259384f, -0.04068459f, -0.03366608f, -0.03258609f, -0.04760472f, 0.04397155f, -0.01625723f, 
    -0.02419451f, 0.00981454f, -0.00721997f, -0.03686108f, 0.00128992f, 0.03418937f, -0.03096788f, -0.04254213f, 
    0.02462683f, -0.03064127f, 0.01893466f, -0.00959751f, 0.04333093f, -0.00716193f, -0.03522256f, 0.01411852f, 
    0.03034150f, -0.05464070f, 0.00919636f, 0.00560653f, 0.02385993f, -0.01205937f, -0.00857292f, 0.00937970f, 
    0.03623757f, 0.00638463f, -0.03331945f, 0.01804167f, 0.02442496f, 0.00691418f, -0.04088041f, -0.03859039f, 
    0.01624368f, 0.03809513f, -0.04363281f, -0.04180081f, 0.00392454f, -0.02564306f, -0.04120345f, 0.02512413f, 
    -0.01113853f, -0.02972956f, -0.03903261f, -0.04658413f, -0.05224552f, -0.04538758f, -0.00565170f, -0.02028756f, 
    -0.03835347f, 0.02747530f, 0.01134539f, 0.03179294f, -0.04257737f, 0.00977326f, -0.05353467f, 0.04491995f, 
    -0.02965785f, 0.00206447f, -0.02733957f, -0.03469172f, -0.05339434f, 0.04013690f, -0.01519431f, -0.02466640f, 
    -0.03405005f, -0.05635908f, -0.02597618f, 0.02900710f, 0.02927264f, -0.01627382f, 0.02596489f, 0.01207445f, 
    0.01857837f, -0.05019120f, 0.00954413f, 0.03911134f, -0.00573594f, -0.02107375f, -0.01571475f, -0.05231564f, 
    0.01588448f, 0.03723305f, 0.00196330f, -0.04803594f, -0.01795241f, 0.01495506f, 0.04312256f, -0.00674541f, 
    -0.03956538f, -0.03052952f, -0.05651708f, -0.02605306f, -0.01712748f, -0.00339750f, -0.02951907f, 0.03385023f, 
    -0.02035301f, -0.03574124f, -0.01734603f, 0.02579280f, -0.04990368f, -0.05596063f, -0.03023534f, -0.02072260f, 
    -0.03461925f, 0.00059277f, -0.04491914f, -0.03436913f, -0.04119099f, -0.03982248f, 0.04230988f, -0.05633539f, 
    0.00732443f, -0.01708787f, 0.00021637f, 0.01835020f, -0.04831692f, -0.01416647f, 0.01004591f, -0.03148554f, 
    0.05320725f, -0.03554423f, 0.00811568f, 0.01619665f, -0.04502540f, -0.02540289f, 0.03883290f, -0.05090250f, 
    -0.04829746f, -0.00467608f, 0.04192749f, 0.01330091f, -0.04066869f, -0.02877409f, 0.00332448f, -0.04059059f, 
    0.02472869f, 0.01648603f, 0.03913390f, 0.00872596f, 0.02847756f, 0.02035764f, 0.02325662f, -0.03006952f, 
    -0.01711778f, 0.00742497f, -0.04759931f, 0.00599199f, 0.02600704f, 0.01529563f, -0.02571047f, 0.00204390f, 
    0.03391081f, -0.01658229f, -0.02771189f, 0.00958133f, 0.00625919f, -0.04034498f, -0.02887652f, 0.03123964f, 
    0.01493592f, -0.03805319f, -0.00361788f, -0.03521373f, -0.04577955f, -0.00015312f, 0.01595544f, 0.04072019f, 
    0.02160255f, 0.01754875f, 0.02133078f, 0.01846668f, -0.00246749f, -0.01418029f, -0.03658720f, 0.02792653f, 
    0.01426657f, -0.05364432f, -0.04152791f, -0.03703690f, -0.00324231f, -0.01261384f, -0.00444798f, -0.04087929f, 
    0.01723152f, 0.02095970f, -0.03115574f, -0.05084966f, 0.01758113f, -0.03360572f, 0.01649721f, -0.00743106f, 
    -0.01092676f, -0.03770685f, -0.03577206f, -0.02190991f, -0.03628138f, 0.04367603f, 0.00127137f, -0.03790037f, 
    -0.01223962f, 0.03831080f, 0.02653496f, -0.01444379f, -0.01023875f, -0.00095636f, -0.02614934f, -0.01937862f, 
    -0.02993985f, -0.01121216f, 0.03286724f, -0.04637763f, -0.05553792f, -0.01446572f, -0.00082603f, -0.01590754f, 
    -0.03992302f, -0.01147611f, -0.00063189f, -0.05530401f, 0.01404808f, 0.02780372f, -0.02656337f, 0.04022631f, 
    -0.01166264f, -0.02806108f, -0.03281784f, 0.03596566f, 0.00676526f, 0.03715098f, -0.01406031f, 0.00532045f, 
    -0.00435169f, 0.00546622f, 0.05521043f, 0.02280411f, -0.01591678f, -0.02558786f, -0.03115784f, 0.03303231f, 
    -0.05292552f, 0.02057579f, -0.02531923f, -0.03711826f, 0.00397065f, -0.01983115f, -0.03789811f, 0.01131404f, 
    -0.01055783f, -0.03449956f, -0.00318302f, 0.04364458f, 0.03186361f, 0.00597479f, 0.00732169f, 0.03405181f, 
    0.01816849f, -0.05588808f, 0.01614726f, -0.02725123f, -0.03763060f, 0.00632428f, -0.02581394f, -0.04098506f, 
    0.02497457f, -0.02848991f, 0.04311325f, -0.05288195f, -0.04017331f, -0.04991533f, -0.01230404f, -0.01388348f, 
    -0.00009916f, 0.03920752f, 0.03353125f, -0.00227207f, 0.01754615f, -0.05318439f, 0.02264014f, 0.04404356f, 
    -0.03140479f, -0.04050609f, 0.03452688f, -0.03246059f, 0.03401206f, 0.04325598f, 0.00221516f, -0.02948713f, 
    0.02899669f, -0.01750289f, 0.00089160f, -0.02533169f, -0.05288729f, 0.01234859f, 0.01930168f, 0.02773475f, 
    -0.05568190f, 0.04437771f, 0.01195740f, -0.04761538f, 0.01792820f, -0.04027317f, -0.00685643f, 0.03474667f, 
    -0.01703298f, 0.03095583f, -0.01428558f, -0.02280304f, 0.01794836f, -0.00920085f, 0.03705056f, -0.02548479f, 
    0.00590005f, -0.02863439f, 0.03288262f, 0.04117750f, 0.02926877f, 0.01261512f, 0.02575268f, -0.03778952f, 
    0.03732084f, -0.04560714f, 0.02919378f, 0.02572267f, -0.04352567f, -0.03781837f, 0.03284182f, -0.00021754f, 
    0.00213746f, 0.03299365f, -0.03079925f, -0.04190238f, -0.03864708f, 0.00410266f, -0.01365411f, -0.02455970f, 
    0.03476543f, -0.03290860f, 0.03834609f, -0.03350967f, -0.05475906f, 0.03140868f, 0.03786300f, -0.04802682f, 
    0.02740198f, -0.03766798f, -0.04015677f, -0.01515277f, -0.05207989f, -0.00588099f, 0.02133781f, 0.04130656f, 
    -0.04774981f, -0.00102985f, -0.00379762f, 0.02535827f, 0.01192022f, -0.00247032f, -0.04998075f, -0.02086788f, 
    -0.00936404f, -0.05440997f, -0.00975038f, 0.00792133f, 0.04443126f, -0.01604307f, -0.05280921f, -0.05496268f, 
    -0.04021391f, -0.02369398f, -0.04822674f, -0.00151545f, 0.00033334f, -0.01888348f, -0.04408458f, 0.01582078f, 
    -0.03587841f, -0.03694232f, -0.01140101f, 0.03394498f, 0.03584418f, -0.02001497f, 0.02638024f, -0.01972597f, 
    0.02918419f, -0.03284559f, 0.04004429f, 0.05319903f, -0.01271657f, 0.00283611f, -0.02864701f, -0.00957797f, 
    0.01862778f, 0.03377596f, 0.02236868f, -0.05251318f, 0.03108588f, 0.03227217f, 0.03883146f, -0.05540882f, 
    -0.03290445f, -0.00077894f, 0.01441849f, -0.05253750f, 0.00293559f, 0.02258619f, 0.00676231f, -0.03951588f, 
    0.17785104f, 0.07149576f, 0.02064074f, -0.16012096f, 0.19465153f, 0.12834093f, -0.02813883f, 0.02719492f, 
    -0.04697214f, 0.09381109f, -0.09040893f, 0.13736492f, -0.52849233f, 0.14889118f, -0.12159446f, -0.05128602f, 
    -0.03153094f, -0.15963884f, 0.12008162f, -0.00246175f, 0.09733149f, 0.00274451f, 0.08237207f, 0.02048243f, 
    -0.00442265f, 0.11325048f, 0.13066941f, 0.04115207f, -0.15156664f, 0.04846076f, 0.03393128f, 0.05807111f, 
    0.13304208f, -0.10793649f, 0.02470019f, -0.02698702f, -0.50080025f, -0.10332756f, -0.15536492f, -0.30104017f, 
    -0.02695632f, -0.03304688f, 0.00226228f, -0.02702127f, -0.09757459f, 0.11823487f, -0.09514526f, 0.03160661f, 
    -0.16199782f, -0.03329973f, -0.21909684f, -0.40007252f, -0.02594060f, 0.06674611f, 0.00994729f, -0.02599471f, 
    -0.00127186f, 0.07188287f, 0.06762465f, -0.03031869f, 0.23519658f, 0.27485830f, 0.19234958f, -0.00443451f, 
    0.10955366f, 0.19090791f, 0.04249173f, 0.01342360f, -0.04619280f, 0.10417166f, 0.06515398f, 0.02591612f, 
    0.15033914f, -0.12408513f, 0.06915825f, 0.07684567f, 0.06100258f, 0.09142786f, -0.01964823f, -0.08045675f, 
    0.09902805f, 0.06814469f, 0.04731116f, -0.10857145f, -0.06304490f, 0.13643000f, 0.39503551f, 0.08141034f, 
    0.13987772f, 0.07708003f, 0.05204299f, -0.10146924f, -0.00153129f, -0.03697027f, 0.04734467f, 0.03701171f, 
    0.28155366f, 0.07252840f, 0.04081459f, 0.09251066f, -0.10895413f, -0.00932436f, 0.12830880f, -0.02088445f, 
    0.10687593f, 0.10118219f, 0.06831753f, -0.11996728f, -0.21105489f, -0.18235461f, 0.17123327f, -0.03594590f, 
    0.05234478f, 0.08940749f, 0.15449810f, 0.03239183f, -0.07010157f, 0.09815265f, 0.05805294f, 0.13309091f, 
    0.13163455f, 0.03052187f, 0.01734337f, -0.04373852f, -0.03713211f, 0.00370231f, -0.01190474f, -0.01112475f, 
    -0.02807872f, -0.07804225f, 0.08065867f, 0.09549214f, 0.04810988f, 0.10173166f, 0.07142418f, -0.02568832f, 
    -0.11202087f, 0.04820294f, 0.02634110f, 0.06000401f, -0.12793219f, 0.01521588f, 0.01943704f, 0.09669272f, 
    -0.04933687f, 0.03438189f, -0.04037178f, 0.15734048f, -0.12904467f, 0.12173351f, -0.00842449f, 0.07833414f, 
    -0.09179386f, -0.09628873f, -0.01265647f, -0.17079912f, 0.14096820f, 0.17754339f, -0.11818627f, -0.24309359f, 
    -0.05788277f, 0.01486161f, 0.07954741f, 0.06339538f, -0.07667622f, 0.15918323f, 0.09858119f, 0.10834720f, 
    0.17443232f, 0.46483752f, 0.06155622f, -0.12517181f, -0.08021457f, 0.04928453f, -0.00187885f, 0.05012554f, 
    -0.10736844f, 0.03361916f, -0.03049933f, 0.06967676f, -0.01076350f, 0.23142849f, 0.02789430f, 0.47600347f, 
    0.07545052f, 0.01955826f, -0.08544028f, -0.00514799f, 0.08855877f, 0.13737324f, -0.06096062f, -0.02236561f, 
    0.10119137f, 0.02022663f, 0.09571720f, 0.35093227f, 0.09425061f, 0.08013099f, -0.05195840f, -0.07437901f, 
    -0.01468693f, 0.00583025f, 0.00565832f, 0.06321561f, 0.28494045f, -0.05154983f, 0.13184120f, -0.00935688f, 
    0.09032371f, 0.01380299f, 0.03976296f, -0.13271843f, -0.10882563f, -0.04719597f, -0.00204412f, 0.01994993f, 
    -0.10045583f, -0.06707088f, 0.15901844f, 0.21069503f, 0.11765262f, -0.04436610f, 0.02654933f, -0.12802967f, 
    -0.08265396f, -0.02734694f, 0.09231383f, 0.00644947f, 0.50837618f, -0.31391609f, -0.03467593f, 0.00368951f, 
    -0.09608480f, -0.02580881f, 0.09405693f, 0.06065025f, -0.12745197f, 0.11873816f, -0.08441052f, -0.08337139f, 
    0.10407843f, 0.14288357f, 0.14370845f, 0.12039254f, 0.07290297f, -0.02319121f, 0.10344302f, -0.07181523f, 
    0.20111936f, 0.07242058f, 0.03698535f, 0.02541414f, 0.23714514f, -0.05166598f, 0.18082386f, -0.01106225f, 
    0.11470285f, -0.17513135f, 0.14490399f, 0.04604777f, -0.08386050f, -0.03162802f, -0.01571532f, 0.06976363f, 
    0.15812667f, -0.01014692f, 0.15106018f, 0.00123846f, 0.08283783f, 0.07163827f, 0.04309068f, -0.01577509f, 
    -0.03841254f, 0.18465130f, -0.01669876f, -0.11547575f, -0.25420371f, -0.24580868f, 0.12079650f, 0.06662722f, 
    0.18952982f, 0.19478276f, 0.10333203f, -0.08106340f, 0.09530739f, -0.00371597f, 0.04254783f, 0.21116792f, 
    0.36596435f, 0.13968240f, -0.04613101f, 0.07484015f, 0.02155521f, -0.13615781f, 0.06937618f, 0.01284616f, 
    -0.09491244f, -0.00816319f, 0.02512123f, -0.03946600f, 0.01712971f, -0.11220140f, 0.07740927f, 0.00691489f, 
    0.13177316f, 0.04462332f, 0.08129901f, 0.00601155f, -0.16094233f, -0.13448590f, -0.04514698f, -0.15400656f, 
    -0.19798145f, 0.11248550f, -0.25369316f, -0.16584672f, 0.11426490f, 0.02532889f, 0.03571348f, 0.02730550f, 
    -0.08779057f, 0.13653857f, 0.15257840f, 0.10961805f, 0.60222256f, 0.02402271f, 0.07361548f, -0.09642872f, 
    0.01917216f, 0.05929646f, -0.19240308f, 0.09564076f, -0.17527321f, 0.06629320f, -0.13669232f, -0.08097161f, 
    0.19869520f, 0.04484290f, -0.01418662f, -0.06346997f, -0.07364709f, 0.05081362f, -0.03534548f, -0.09694785f, 
    -0.01083144f, -0.05804986f, 0.02732384f, -0.04660503f, -0.14790766f, 0.05112596f, -0.07216501f, -0.07028008f, 
    0.04790236f, 0.03296096f, -0.02234382f, -0.14260803f, -0.00927293f, -0.04589965f, 0.03962776f, 0.05638745f, 
    0.08418516f, 0.08421136f, 0.13444731f, -0.07974392f, -0.02517012f, -0.08685350f, 0.01420002f, 0.04599254f, 
    0.04702365f, 0.16709760f, 0.03848106f, -0.02606016f, 0.66937101f, 0.10529329f, 0.00975667f, -0.02151023f, 
    -0.00613693f, -0.01661394f, -0.13247861f, -0.01381918f, -0.03466542f, -0.01350533f, -0.08150489f, -0.04620922f, 
    -0.01407245f, -0.04627217f, 0.02293482f, 0.04144078f, -0.02050807f, 0.03678109f, 0.00125861f, 0.03982317f, 
    0.03852714f, 0.00093014f, -0.04394616f, 0.00903266f, 0.03107997f, -0.04630588f, 0.02523897f, -0.01295205f, 
    -0.03218134f, -0.01046539f, -0.01369006f, -0.05677651f, 0.00103719f, -0.02193757f, -0.05103388f, -0.04642322f, 
    0.03245169f, 0.02038385f, 0.02977497f, 0.03736043f, 0.03894238f, -0.05124095f, -0.01741320f, -0.04404686f, 
    -0.02808419f, -0.01937806f, 0.04175046f, -0.03028329f, -0.01120980f, -0.00082999f, -0.02022585f, -0.01449486f, 
    -0.00598003f, -0.03472984f, -0.05398893f, -0.04974534f, 0.02145135f, 0.02772793f, -0.03737176f, -0.01273861f, 
    0.00301517f, 0.00567297f, 0.02523498f, -0.03364752f, -0.03824230f, -0.04831828f, -0.00023857f, -0.04660750f, 
    0.01668929f, -0.05065118f, -0.01096834f, -0.01200998f, 0.04244293f, -0.00779208f, -0.00000179f, -0.03831117f, 
    -0.04496488f, -0.01373315f, -0.00352355f, -0.02258574f, -0.00225489f, 0.03487087f, 0.01273652f, 0.01751428f, 
    0.02186657f, 0.01919896f, 0.03870946f, -0.05473468f, -0.00224466f, -0.02135153f, 0.03059850f, 0.01255503f, 
    0.00356185f, -0.02545948f, 0.03086886f, -0.00174341f, 0.02555212f, 0.02661681f, -0.00326585f, -0.05272066f, 
    -0.03536599f, 0.03081048f, -0.03547334f, -0.02930384f, -0.04444357f, -0.04366949f, 0.02652915f, -0.01261804f, 
    -0.04112150f, 0.02534866f, 0.02378496f, -0.01910055f, -0.04504642f, 0.01629446f, -0.03305319f, 0.00793937f, 
    0.01991034f, -0.02033527f, 0.01484221f, -0.05325684f, -0.04401877f, -0.01713762f, 0.03210514f, 0.03892487f, 
    0.00380621f, -0.02394794f, -0.04493237f, -0.01455652f, -0.04780757f, 0.02693848f, -0.03060659f, -0.02914804f, 
    0.01273390f, -0.00667600f, 0.04430551f, -0.04598415f, -0.00557797f, 0.01180963f, -0.01246987f, -0.02505093f, 
    -0.01552984f, 0.00583842f, -0.01057945f, 0.02619770f, -0.04990220f, 0.01271431f, -0.04052072f, 0.03295736f, 
    -0.00665318f, -0.05659011f, -0.03455453f, 0.00359497f, -0.02731680f, 0.03893652f, -0.01336706f, -0.04327635f, 
    -0.03038584f, -0.01004946f, -0.02147803f, -0.03065077f, 0.00684336f, 0.05678216f, 0.02967889f, -0.04921005f, 
    -0.04921977f, 0.03883810f, -0.02518784f, 0.01700709f, 0.02495778f, 0.04459736f, 0.04325125f, -0.03520568f, 
    -0.01936206f, 0.02030557f, -0.04519386f, -0.02560912f, -0.02007776f, -0.02439873f, 0.00293007f, -0.02784702f, 
    0.03864758f, 0.03737360f, 0.02596184f, 0.03013429f, -0.04798148f, -0.02463193f, -0.02770547f, 0.02190561f, 
    0.01213123f, 0.00546944f, 0.02310079f, -0.02563451f, 0.01483398f, -0.03612638f, -0.04897340f, -0.01696403f, 
    0.04312468f, 0.03963440f, 0.01878067f, -0.00196394f, 0.03470748f, 0.00026203f, -0.02233664f, 0.01003120f, 
    -0.00593427f, 0.02545171f, -0.02022961f, -0.02093526f, -0.04633009f, -0.02100776f, 0.02057715f, 0.03517332f, 
    0.02118838f, -0.02908246f, 0.00355586f, -0.04035521f, -0.03460839f, 0.04368066f, -0.01871628f, -0.02209220f, 
    0.02773999f, -0.03540614f, -0.04737931f, 0.03475853f, 0.00701356f, -0.01355520f, 0.05296990f, -0.02281591f, 
    -0.00378407f, -0.05580154f, 0.01654702f, 0.04335583f, -0.03658359f, -0.02116580f, -0.04208127f, -0.03653903f, 
    -0.02185780f, -0.05350919f, 0.00985870f, 0.03307472f, 0.03785373f, -0.05069962f, -0.01534673f, -0.00312766f, 
    -0.00649522f, -0.03833819f, 0.01946703f, -0.04671464f, -0.00830954f, -0.02222177f, 0.00692986f, -0.01261581f, 
    -0.05606633f, 0.05210493f, -0.00883230f, -0.05115408f, 0.00785150f, 0.04176531f, -0.00268478f, -0.02259246f, 
    -0.02271832f, -0.03309005f, -0.05624544f, -0.01237284f, 0.01750197f, 0.03989884f, 0.01469978f, 0.02449785f, 
    0.01000291f, 0.00065710f, -0.03409069f, 0.00088716f, 0.00473626f, 0.03899121f, 0.02325743f, 0.04475105f, 
    -0.03136913f, -0.05679503f, -0.04585834f, -0.03478521f, -0.00207702f, -0.00472660f, -0.02645815f, -0.02926953f, 
    0.04203068f, -0.05068883f, -0.01574743f, -0.04595876f, -0.03538530f, 0.00832385f, -0.00927278f, -0.01704775f, 
    0.04238313f, 0.01012673f, 0.00293706f, -0.00458010f, 0.02538234f, 0.04155679f, -0.00931448f, -0.04823735f, 
    -0.05279528f, -0.03505658f, -0.00443074f, -0.04763563f, -0.03676223f, -0.05450353f, -0.02447832f, 0.03954476f, 
    -0.04703200f, -0.00907890f, -0.01254864f, 0.01975412f, -0.00853508f, 0.04771834f, -0.02090788f, -0.04010775f, 
    0.02873003f, -0.01151841f, -0.04926151f, -0.02326987f, -0.01338387f, 0.00320456f, -0.03875694f, 0.01027588f, 
    -0.03306547f, -0.05058834f, -0.01193046f, -0.05076938f, 0.01668472f, -0.01143466f, -0.02798959f, -0.03511506f, 
    -0.01275542f, -0.02262345f, -0.02054609f, -0.00400197f, -0.04274328f, 0.02088842f, -0.01596100f, -0.04636990f, 
    -0.04857659f, 0.03806512f, 0.01234639f, -0.03929051f, 0.00445901f, 0.00913597f, 0.01222720f, -0.01098574f, 
    0.04737759f, 0.02339039f, 0.02465873f, 0.00837235f, 0.04236012f, 0.02580660f, -0.05500681f, -0.03154378f, 
    -0.04817292f, -0.01908392f, -0.05380928f, 0.03518404f, -0.04058699f, -0.00308852f, -0.05624676f, -0.04060042f, 
    0.04049772f, 0.04302396f, -0.04099871f, -0.05191319f, 0.04045339f, -0.04920779f, 0.03504165f, -0.04121658f, 
    0.03580967f, -0.02049542f, -0.05196337f, -0.01648981f, 0.03526738f, 0.01607130f, -0.00315028f, -0.05072487f, 
    0.04253203f, -0.03463129f, -0.00521571f, 0.04200715f, -0.05092031f, -0.04847167f, 0.03887502f, -0.03690802f, 
    0.03898695f, 0.02605595f, 0.03271310f, -0.02770608f, -0.00771057f, -0.04251907f, -0.01802226f, 0.03316906f, 
    0.52228922f, -0.27744630f, -0.03950100f, 0.04336783f, -0.00513188f, 0.13593906f, -0.01227899f, 0.19030923f, 
    -0.00645444f, 0.10703034f, -0.04681809f, 0.01744193f, 0.30517411f, -0.17105348f, 0.11989806f, 0.16909094f, 
    0.19827898f, 0.02966997f, -0.05213607f, 0.08530525f, 0.07871590f, 0.06630373f, 0.09027427f, -0.01251663f, 
    0.12445606f, 0.04617235f, -0.00228834f, -0.11958835f, 0.06968397f, -0.08084209f, 0.02684859f, 0.01015487f, 
    -0.05984992f, -0.05109094f, 0.02484804f, -0.01828882f, -0.07972624f, -0.19470927f, 0.01241906f, 0.09714656f, 
    0.01195802f, 0.02674500f, -0.04309190f, -0.02126895f, 0.05687333f, 0.09035148f, 0.00226783f, -0.03740574f, 
    0.32155675f, 0.15328594f, 0.04185893f, 0.14228258f, 0.11610056f, 0.08061498f, 0.14333455f, 0.03206648f, 
    0.01845672f, 0.05499857f, 0.08906618f, -0.01737694f, -0.17806561f, 0.06763382f, 0.02542776f, -0.17469491f, 
    -0.17511126f, -0.11026471f, 0.05093153f, 0.00988786f, 0.13090500f, 0.04748989f, -0.05530910f, 0.00227597f, 
    -0.11783258f, -0.21435328f, 0.12051810f, -0.20693685f, -0.07845233f, 0.03041568f, 0.02143463f, -0.02666144f, 
    0.02571984f, 0.12719288f, 0.01803654f, 0.08624498f, 0.08955736f, 0.06913545f, -0.04685495f, -0.02282805f, 
    0.06241143f, 0.14252406f, 0.04208465f, 0.17415315f, 0.21312156f, 0.04002361f, 0.02201012f, 0.03943774f, 
    0.39569438f, -0.15270177f, -0.06253068f, 0.01292454f, 0.02107200f, 0.04538867f, -0.04931149f, -0.08774549f, 
    0.01403159f, -0.03599310f, 0.01068826f, 0.02012103f, 0.19332325f, 0.23034316f, -0.04782219f, -0.04943139f, 
    -0.11053208f, -0.02082763f, 0.11410444f, -0.01282479f, 0.02568155f, 0.01006458f, 0.00984819f, 0.04821057f, 
    0.21701202f, 0.17745315f, -0.14179772f, -0.25040382f, 0.10749026f, 0.10810427f, 0.06206762f, 0.03251328f, 
    0.02802969f, 0.12587671f, -0.01403302f, 0.08914063f, -0.15823026f, 0.23880012f, 0.02640745f, 0.01907860f, 
    0.13701510f, 0.02481430f, 0.06691273f, 0.24272271f, -0.01107654f, 0.01243044f, -0.06836209f, 0.13921221f, 
    0.10161373f, 0.16229399f, -0.09557939f, -0.09747159f, 0.08583206f, 0.05611103f, 0.11231341f, 0.04964708f, 
    0.01680397f, 0.01663524f, 0.03107383f, 0.05101458f, 0.37828180f, 0.14427860f, 0.06285214f, 0.01502882f, 
    0.13894776f, -0.01644492f, 0.15084715f, -0.05388997f, -0.00008335f, 0.12762819f, -0.01610212f, 0.02499594f, 
    0.12567542f, 0.25301930f, 0.03098367f, 0.08015751f, 0.13393350f, -0.05134988f, 0.05636047f, 0.11277892f, 
    -0.05290158f, 0.02330651f, 0.05861459f, -0.02764151f, -0.01638044f, -0.12329640f, -0.06318524f, 0.03875362f, 
    -0.03709514f, -0.02257925f, 0.08785272f, -0.05660281f, 0.01229810f, 0.16438475f, 0.07295843f, 0.01318499f, 
    -0.11857554f, -0.04194376f, -0.11134847f, -0.03396313f, 0.03853133f, -0.02734890f, -0.01055771f, 0.03284641f, 
    -0.00872470f, -0.16878745f, -0.01862174f, 0.08679733f, 0.02658591f, 0.00260378f, 0.05309111f, -0.09778367f, 
    0.03437054f, -0.00438134f, -0.01134081f, -0.05453893f, -0.03647213f, 0.01331034f, 0.02558716f, 0.09377421f, 
    -0.23772115f, 0.10296877f, -0.22376253f, -0.11290345f, -0.05820257f, -0.13325730f, -0.01892622f, 0.01238419f, 
    0.05422576f, -0.06166116f, 0.03077111f, -0.03270268f, 0.11667445f, 0.19644247f, -0.26528725f, -0.03295983f, 
    0.12599313f, -0.03880150f, 0.07848084f, 0.11103312f, 0.12685625f, 0.04176552f, -0.03511333f, 0.07212233f, 
    -0.05676135f, 0.01090202f, 0.04133542f, -0.18651544f, -0.03983915f, -0.01958157f, -0.00047190f, -0.03646719f, 
    0.06811396f, 0.04725527f, 0.09704983f, 0.00789273f, 0.23387708f, 0.27534518f, 0.12550384f, 0.11364300f, 
    0.15924983f, -0.00716534f, 0.09103319f, 0.13351946f, -0.04158662f, 0.01243242f, 0.10498015f, 0.10732500f, 
    -0.31978518f, -0.00988620f, -0.05588745f, -0.19085410f, 0.01290706f, -0.15640050f, 0.16871655f, 0.09862321f, 
    0.03499218f, -0.01412949f, -0.05778117f, 0.13411492f, -0.12864432f, -0.06816261f, -0.05734224f, 0.01585711f, 
    -0.15965067f, 0.12729815f, 0.09337961f, 0.13755490f, -0.05469171f, 0.06661462f, 0.04425762f, -0.01811413f, 
    -0.00544944f, -0.03290097f, 0.04392390f, 0.02081783f, 0.11025135f, -0.02281373f, 0.07379041f, 0.07778002f, 
    -0.07832901f, -0.02318228f, 0.10569794f, -0.13539654f, -0.16379987f, -0.27136916f, -0.00903979f, -0.07020698f, 
    0.00060688f, -0.01985561f, -0.04468277f, -0.10718907f, -0.00160215f, 0.03800293f, 0.04408899f, -0.06652600f, 
    0.13654269f, -0.01756255f, 0.18854383f, 0.14599399f, -0.01781058f, 0.02496788f, -0.04818806f, 0.05047261f, 
    0.08905822f, -0.02689029f, 0.15728325f, -0.00895265f, 0.11528914f, 0.10690906f, -0.06882803f, -0.25122517f, 
    0.02219955f, -0.06511480f, -0.00861355f, 0.17860927f, 0.08249067f, 0.06183530f, 0.01714923f, 0.05998552f, 
    0.31289509f, -0.04595556f, 0.15941042f, 0.08762725f, 0.04661988f, 0.01232984f, 0.15014163f, 0.02250977f, 
    0.04743128f, 0.07070700f, -0.00639837f, 0.04201780f, 0.06327828f, 0.12227639f, -0.10573082f, 0.02402296f, 
    0.09559747f, -0.02070186f, 0.01927293f, 0.07305129f, 0.10197712f, -0.11962686f, -0.00098076f, -0.10707406f, 
    0.14588073f, 0.11592011f, 0.04607870f, -0.01956613f, 0.10962138f, -0.05287493f, -0.01303975f, 0.06439156f, 
    0.05698408f, 0.13261311f, 0.11777540f, 0.14629576f, 0.32903993f, 0.05105069f, 0.01804841f, 0.12313132f, 
    -0.01344398f, -0.01092228f, -0.00561481f, 0.02789488f, 0.09661783f, 0.02025944f, 0.14549258f, -0.05634734f, 
    -0.17185953f, 0.09811818f, 0.00023257f, 0.10818442f, -0.18580361f, -0.05098429f, 0.09367044f, -0.07134669f, 
    0.12047461f, -0.05471299f, 0.07571445f, -0.04772985f, 0.09607203f, -0.14290506f, 0.15792692f, 0.01787539f, 
    -0.11720273f, -0.00163506f, 0.08697188f, 0.18651359f, -0.06538725f, -0.02463971f, 0.06704496f, -0.08667054f, 
    -0.02262007f, -0.10225157f, -0.23080146f, 0.10370646f, 0.10239069f, 0.01303517f, -0.07406299f, -0.06931251f, 
    0.01403934f, 0.11745045f, 0.10361814f, -0.04535256f, 0.60224378f, -0.03872240f, 0.20105077f, 0.11805537f, 
    -0.09409008f, -0.00930313f, 0.10688198f, 0.05940233f, 0.07336328f, -0.09614686f, -0.02361998f, 0.05109288f, 
    0.20308621f, -0.00669577f, 0.10898653f, 0.08473514f, -0.03831588f, -0.03870311f, 0.03335407f, 0.17790025f, 
    0.04732812f, 0.02448300f, -0.00015336f, 0.13651578f, 0.26442656f, -0.18620941f, -0.36634198f, 0.08490582f, 
    -0.03453796f, 0.08264332f, -0.06666924f, -0.03104610f, -0.04637136f, -0.00609852f, 0.01939432f, -0.13989173f, 
    0.13701566f, 0.34262601f, -0.08010496f, 0.00239920f, 0.02465408f, -0.11392514f, 0.01127066f, -0.08609280f, 
    0.02634787f, -0.07875284f, -0.04283242f, 0.09527158f, 0.14546138f, 0.15637276f, -0.12544762f, 0.05323925f, 
    0.03093443f, 0.00458270f, -0.02588077f, 0.00101963f, 0.01440010f, -0.07923148f, -0.02292755f, 0.01461635f, 
    -0.36309171f, 0.04653516f, 0.04269379f, -0.05133654f, 0.08016781f, -0.00371219f, 0.08539286f, 0.01312896f, 
    -0.04048640f, 0.04631052f, 0.06303944f, 0.15415677f, 0.08594820f, -0.01826660f, -0.03023938f, 0.18906413f, 
    -0.00471550f, -0.02879369f, 0.11050666f, 0.04408311f, 0.16557048f, 0.04520252f, 0.07500649f, -0.07756374f, 
    0.10333363f, 0.01406357f, 0.15710260f, 0.33151522f, -0.01979084f, -0.01664430f, 0.01190993f, 0.09151188f, 
    -0.08317447f, -0.00931311f, -0.03204197f, 0.07210163f, 0.11022547f, 0.11219519f, 0.05083371f, 0.01225880f, 
    0.02698014f, 0.03517184f, -0.05469538f, -0.14775927f, 0.05060834f, 0.09826852f, 0.07455544f, -0.06621161f, 
    0.06042114f, 0.07591895f, 0.12273363f, -0.07395984f, 0.00765815f, -0.03368813f, 0.02340000f, 0.02571951f, 
    0.09604324f, 0.07957106f, -0.11344681f, -0.09680988f, 0.12250322f, -0.07197469f, 0.07435332f, 0.32578430f, 
    -0.03280555f, 0.00421022f, 0.00227529f, 0.04500423f, -0.00254777f, -0.13343176f, -0.00781530f, 0.22972417f, 
    0.10423620f, -0.10343321f, 0.01929917f, 0.13401450f, 0.17016199f, -0.05666106f, -0.08071753f, 0.05635095f, 
    0.02133125f, -0.10703243f, 0.01063965f, 0.08195601f, 0.08984067f, -0.00002230f, 0.11027709f, -0.08982264f, 
    0.06370845f, -0.03233317f, 0.11141838f, -0.00937697f, -0.02833966f, -0.00206362f, 0.01361457f, -0.05560349f, 
    0.08947605f, 0.05915223f, 0.06976276f, -0.12904240f, -0.05559485f, 0.02710089f, 0.00181440f, -0.12676446f, 
    0.03255322f, -0.04346367f, -0.01787207f, -0.05185198f, -0.25636211f, 0.18053739f, -0.22238611f, 0.22442405f, 
    0.10825399f, 0.01704627f, -0.09284377f, 0.09273324f, 0.16700032f, 0.04281821f, -0.02362254f, 0.03743633f, 
    0.22602771f, 0.14365520f, -0.02652851f, 0.00468776f, 0.02389835f, 0.07569993f, 0.15396737f, -0.01895739f, 
    0.18108468f, 0.03943634f, -0.09697332f, 0.12620357f, -0.19786480f, 0.19030450f, 0.26763609f, 0.24224889f, 
    -0.07105386f, 0.05524609f, -0.01310982f, 0.01107460f, 0.02901649f, -0.01976957f, 0.10930266f, -0.05886903f, 
    -0.01193117f, -0.14482549f, -0.25492993f, -0.08919786f, 0.02722969f, 0.07590077f, 0.01914581f, -0.09419724f, 
    -0.06983702f, 0.07876719f, -0.04545457f, 0.05853086f, -0.22835842f, -0.15704328f, -0.07386407f, 0.04625224f, 
    -0.00245350f, -0.00816241f, -0.09448076f, 0.10652913f, 0.09038260f, 0.04511782f, -0.06902878f, -0.01732382f, 
    0.32149115f, 0.23496476f, -0.12560484f, 0.05886641f, 0.04620827f, -0.03478053f, -0.18297657f, -0.09555193f, 
    0.08897951f, -0.02161285f, 0.07137589f, 0.00414019f, 0.00971385f, 0.17213264f, 0.11885349f, 0.14133638f, 
    -0.06236599f, -0.05463488f, -0.00197853f, 0.00851855f, 0.03730614f, 0.07818561f, 0.00175423f, -0.05496310f, 
    -0.23956463f, 0.09843265f, -0.04362556f, -0.09969937f, -0.03328980f, 0.00056129f, -0.08153900f, -0.11248641f, 
    0.06847861f, -0.00261824f, -0.05138220f, -0.01754200f, 0.34944132f, 0.02564395f, -0.01380022f, -0.01427904f, 
    -0.03666240f, 0.04389895f, -0.18065073f, -0.15857473f, 0.06129400f, 0.04967593f, -0.08962183f, 0.12988088f, 
    0.16950959f, -0.17001058f, 0.06321432f, 0.12919250f, -0.03655843f, 0.01016819f, 0.20270894f, 0.12960038f, 
    0.06883900f, 0.00343428f, 0.04892428f, -0.00408943f, -0.41370896f, 0.19234581f, 0.05710450f, 0.02974861f, 
    0.00395185f, -0.02946770f, 0.05987474f, -0.20516999f, 0.13826099f, 0.03873917f, -0.01763723f, 0.09399220f, 
    -0.14156188f, -0.08744362f, -0.06081303f, -0.11486408f, 0.07143445f, -0.01399493f, 0.17486455f, 0.13486421f, 
    -0.06661508f, 0.06247910f, -0.06702058f, -0.02273402f, -0.04487383f, 0.11424164f, 0.21663183f, -0.12332950f, 
    0.03392157f, 0.09446944f, 0.10923086f, 0.07868578f, -0.14471522f, 0.08326615f, 0.04390701f, 0.09504845f, 
    -0.10471680f, -0.19535527f, -0.14428100f, 0.12596004f, -0.03472989f, 0.02569981f, 0.03625095f, -0.02736728f, 
    -0.07596282f, -0.04011226f, 0.01476046f, 0.04813004f, -0.76102293f, 0.21107867f, -0.02233129f, -0.05846639f, 
    0.24042556f, 0.02115481f, 0.15412900f, 0.00343843f, 0.07683650f, -0.11232151f, 0.04869070f, -0.00586764f, 
    0.04249243f, -0.01431527f, 0.00839477f, -0.03777575f, -0.02880111f, -0.03512466f, -0.00649952f, -0.02326838f, 
    -0.04061984f, 0.03652105f, 0.00746523f, -0.05441835f, -0.01691140f, -0.00906868f, 0.00058706f, 0.00642954f, 
    -0.02955430f, -0.02560023f, -0.02751315f, -0.04077585f, 0.03934850f, -0.03307647f, -0.01511213f, -0.00135066f, 
    0.01770647f, -0.03033943f, 0.05088852f, -0.04298177f, -0.01209062f, 0.03357111f, -0.00061497f, -0.00006590f, 
    -0.04785854f, 0.03758439f, 0.03999807f, 0.04420769f, 0.00956725f, 0.02743483f, -0.03122508f, -0.05403340f, 
    -0.02304441f, -0.04947725f, 0.03798940f, 0.01156557f, 0.00409779f, 0.03593671f, 0.00319071f, 0.02312323f, 
    -0.05058796f, 0.04446507f, -0.03632782f, -0.03874212f, -0.04220068f, 0.01658828f, -0.04188411f, 0.01666956f, 
    0.01811289f, -0.01976062f, -0.04775829f, -0.00458388f, 0.03240592f, -0.01405272f, 0.01081120f, -0.01416677f, 
    0.03296358f, -0.05491586f, -0.05169981f, -0.05531617f, 0.01481325f, -0.00511986f, 0.00276771f, 0.00828479f, 
    -0.03609942f, 0.02603504f, 0.03892593f, 0.00913242f, 0.02644701f, -0.03536488f, -0.04294402f, -0.04396753f, 
    -0.00290267f, 0.00289549f, 0.00924879f, -0.03873695f, 0.03131190f, -0.01644405f, 0.02132212f, -0.03603736f, 
    0.01151988f, -0.04459220f, 0.01726314f, 0.01591466f, -0.04447303f, -0.04609319f, -0.03529039f, 0.00314393f, 
    -0.02680060f, -0.04592374f, 0.00086474f, -0.04821720f, 0.02038293f, -0.04838995f, -0.02238227f, 0.02903417f, 
    0.00625151f, -0.01448776f, 0.02097413f, 0.01587863f, 0.03138811f, -0.02292692f, 0.02238460f, -0.04846310f, 
    -0.03060612f, 0.00560536f, 0.00844659f, -0.03209776f, 0.04125008f, -0.00727875f, -0.03558687f, -0.05644304f, 
    -0.01925614f, -0.02894866f, 0.01946431f, 0.00467901f, 0.03784356f, 0.01273324f, -0.01978521f, -0.02620967f, 
    -0.00407003f, 0.01661767f, 0.03799070f, -0.01786319f, 0.04333803f, 0.00242383f, -0.04180327f, 0.03620667f, 
    0.00370758f, -0.00382717f, -0.03221345f, -0.05128702f, -0.00189945f, -0.01680500f, -0.02197472f, 0.02162339f, 
    -0.04908950f, -0.02853517f, 0.03327236f, 0.01173751f, 0.03770413f, -0.00275853f, 0.00353731f, -0.04100904f, 
    -0.00157972f, 0.00618339f, -0.02050755f, -0.04706265f, 0.00169259f, 0.03449351f, 0.03284088f, 0.02764473f, 
    -0.04332630f, 0.03866356f, 0.00751371f, -0.03626296f, 0.00328531f, 0.01653708f, 0.00572984f, 0.02217070f, 
    -0.00445093f, -0.05176269f, 0.02590149f, 0.02045967f, -0.02671409f, 0.02586108f, -0.01248290f, -0.00567173f, 
    -0.03538847f, 0.00865704f, 0.01425208f, -0.00401536f, -0.04878271f, 0.02043548f, -0.03368210f, -0.04096104f, 
    0.03440442f, -0.01765195f, 0.03032293f, 0.01669560f, -0.02625201f, -0.05507553f, -0.02847879f, -0.02498478f, 
    -0.03794776f, 0.00890048f, 0.03920882f, 0.02586933f, -0.01937427f, 0.02341200f, -0.05443567f, 0.01165077f, 
    -0.04885825f, -0.01478397f, -0.00208194f, 0.00493012f, -0.01136847f, -0.00387705f, -0.04692358f, -0.02291295f, 
    -0.05598582f, 0.04464133f, -0.02128740f, -0.01569840f, 0.01419512f, 0.03735662f, -0.03667197f, 0.00301208f, 
    -0.00498849f, -0.02317949f, 0.01202806f, -0.03174814f, -0.02664400f, 0.02793046f, -0.00550711f, 0.01742545f, 
    -0.05144169f, -0.01253097f, -0.02229657f, 0.01371524f, -0.04830517f, -0.02432068f, -0.02361304f, -0.05575368f, 
    -0.04071930f, 0.01611524f, 0.01079234f, 0.02450461f, -0.00000664f, -0.00559127f, -0.04003087f, -0.05436020f, 
    0.03810172f, 0.01572538f, 0.03605158f, -0.04534155f, -0.00544436f, -0.03744179f, -0.00142287f, -0.04433436f, 
    0.03937535f, -0.00625721f, -0.01902872f, -0.04708616f, 0.01069270f, 0.03846999f, -0.01966723f, 0.04069598f, 
    0.02451036f, 0.01794687f, -0.05585950f, -0.00179374f, -0.00074301f, 0.01843181f, 0.02733650f, -0.03924904f, 
    -0.01648601f, 0.00394024f, -0.04520384f, 0.02382960f, 0.03653472f, -0.04571623f, 0.03220268f, -0.03815832f, 
    0.00892196f, 0.03823552f, -0.01408992f, -0.01241306f, 0.00235984f, -0.00829312f, -0.03637910f, -0.04284171f, 
    -0.01780264f, -0.00900324f, -0.04526237f, -0.01223639f, -0.03644056f, -0.02148305f, 0.04746699f, 0.03888972f, 
    0.03618722f, 0.02789574f, 0.02738562f, 0.04353634f, 0.00616959f, -0.05675164f, 0.01767896f, 0.04083909f, 
    0.03946841f, -0.04993263f, 0.00069063f, 0.01039924f, -0.05024521f, 0.01093890f, 0.04068058f, 0.04383501f, 
    -0.04469138f, -0.01487533f, 0.03140973f, -0.03131476f, -0.01023213f, -0.01971862f, 0.01028928f, -0.01701906f, 
    -0.04477016f, -0.02859687f, -0.00283126f, -0.04079076f, 0.01147879f, 0.00516326f, -0.04574762f, 0.02332415f, 
    -0.05066836f, -0.05287636f, -0.03413309f, -0.02446215f, -0.00908626f, 0.01327829f, 0.03495715f, 0.04247896f, 
    -0.03287026f, 0.00752271f, -0.03570756f, 0.00860678f, -0.03618162f, 0.00246779f, 0.03180730f, -0.00154826f, 
    -0.03803356f, -0.02299042f, -0.02252507f, -0.03002467f, -0.01165509f, -0.01424939f, 0.04105399f, 0.03536376f, 
    -0.01745600f, -0.02017821f, 0.00445100f, -0.02869353f, -0.04841747f, -0.04319982f, 0.02620901f, -0.00248106f, 
    -0.01987237f, -0.04207386f, 0.01797144f, 0.03803432f, 0.00447679f, -0.01530477f, -0.03697115f, -0.02505166f, 
    -0.02777680f, -0.04477523f, 0.00931509f, 0.04395795f, -0.04662486f, -0.01440715f, -0.01222306f, 0.00652128f, 
    -0.02282535f, 0.00069064f, -0.01292320f, 0.02893038f, -0.02329115f, 0.01239081f, 0.01160066f, -0.01133733f, 
    -0.02758322f, -0.03845834f, -0.03993707f, -0.03212972f, 0.00530328f, -0.03176127f, 0.03153174f, -0.02750087f, 
    0.02108858f, 0.03075554f, -0.01677968f, -0.02087001f, 0.02547197f, -0.01437391f, 0.00121450f, -0.00420593f, 
    -0.05373441f, -0.03519401f, -0.03200259f, -0.02154212f, 0.01736168f, 0.00000172f, 0.02479311f, 0.03985905f, 
    0.04294396f, 0.01384292f, -0.00486499f, 0.00140485f, 0.01828019f, -0.00004339f, 0.00704066f, -0.01184505f, 
    -0.04721773f, -0.04375128f, -0.00111408f, 0.01170334f, -0.04024771f, 0.02777997f, 0.04027133f, -0.00634681f, 
    0.01814219f, -0.02855421f, 0.01577119f, -0.03496791f, 0.04130791f, -0.04543024f, -0.01533770f, -0.03172757f, 
    0.00247678f, -0.02112006f, -0.04369555f, -0.03964904f, 0.04449250f, 0.02730267f, -0.00009653f, -0.04607218f, 
    -0.04505355f, 0.00051890f, 0.02674904f, -0.00652766f, 0.00195797f, -0.05493903f, -0.02781583f, -0.01128716f, 
    -0.00279121f, -0.03315514f, -0.05433566f, -0.03846367f, 0.02581110f, 0.04110687f, -0.05230862f, 0.00073005f, 
    -0.00183904f, -0.01977314f, -0.01056378f, -0.00805727f, 0.02058009f, 0.00188398f, -0.01547569f, 0.01576396f, 
    -0.04945468f, 0.04128834f, 0.03069816f, -0.03804194f, -0.01125954f, 0.03164743f, 0.00439211f, -0.04911233f, 
    0.02882600f, -0.03145253f, 0.00974302f, 0.04444979f, 0.04091383f, -0.02581464f, 0.00675264f, 0.00452263f, 
    0.00083128f, -0.01321967f, 0.02946295f, 0.03740280f, -0.02701735f, 0.01444500f, -0.04302651f, 0.04377051f, 
    0.00453174f, -0.00912405f, -0.03997952f, 0.02521233f, -0.03816697f, -0.03079273f, -0.05622318f, 0.00107081f, 
    -0.00152050f, -0.03738014f, -0.02976867f, -0.02561731f, 0.03538764f, -0.03811005f, 0.04447470f, -0.04923239f, 
    -0.04153436f, -0.03695387f, 0.04337145f, 0.03756732f, -0.05462410f, 0.01500907f, 0.02686489f, 0.02169992f, 
    0.02375492f, -0.01657650f, 0.00563327f, -0.05521984f, -0.00681344f, 0.02164626f, -0.05547861f, 0.03054462f, 
    -0.02194194f, -0.03299423f, 0.01658466f, 0.03016302f, -0.03357355f, 0.02708060f, 0.03306961f, 0.01380942f, 
    0.00609382f, -0.00578812f, -0.03125253f, -0.00158081f, 0.03951396f, 0.03134305f, -0.04538111f, 0.01498327f, 
    -0.00125319f, -0.02816389f, 0.02224861f, -0.01337961f, -0.02755782f, 0.00391849f, -0.02399235f, -0.00573779f, 
    0.03517304f, -0.01797108f, 0.01404606f, -0.00318650f, 0.01077824f, -0.02061644f, -0.05037113f, -0.02205586f, 
    0.01801964f, -0.01395330f, 0.03890653f, -0.03551842f, 0.03645734f, 0.04167851f, 0.03835320f, -0.02170485f, 
    0.02286831f, -0.02967748f, -0.03407355f, 0.00444654f, -0.02853580f, -0.00477248f, 0.02849226f, 0.01511997f, 
    -0.05264789f, 0.03498454f, 0.04321355f, -0.00758047f, -0.02494634f, -0.05139911f, -0.03062056f, -0.01569024f, 
    0.03495549f, -0.03244160f, -0.05182794f, -0.05631766f, -0.00779910f, -0.02091506f, 0.00626305f, 0.01260842f, 
    0.04093207f, -0.00977233f, -0.03100726f, 0.04487905f, -0.00202224f, -0.03239254f, -0.00883071f, -0.03548745f, 
    -0.04280645f, 0.00618214f, 0.04498532f, -0.03876098f, 0.00723096f, -0.00521675f, -0.02937656f, -0.02720804f, 
    0.00978912f, 0.02491936f, -0.03411327f, -0.00893494f, -0.03282804f, 0.02843839f, 0.01065069f, 0.03315387f, 
    0.01662524f, -0.03474273f, 0.00780004f, -0.03629379f, -0.00372757f, -0.04592905f, 0.03644728f, -0.04637550f, 
    0.01184812f, 0.00831514f, -0.02978731f, 0.03218680f, 0.02826000f, -0.03787969f, -0.05606754f, 0.03249090f, 
    -0.05621502f, -0.02925605f, -0.05069513f, -0.04688542f, -0.03366084f, -0.05470430f, -0.05002065f, -0.03993744f, 
    -0.05547100f, -0.05039715f, 0.02671812f, 0.01339177f, 0.04005573f, 0.02669816f, 0.02209019f, 0.01879041f, 
    0.01954836f, -0.02011628f, -0.05044992f, -0.03064205f, 0.00798735f, -0.01011121f, 0.03888427f, -0.05177300f, 
    0.00759051f, -0.03134219f, -0.00855101f, -0.01947511f, -0.03487100f, 0.01201869f, -0.02249870f, 0.00779767f, 
    -0.04758840f, -0.01519504f, -0.00746312f, 0.01249909f, -0.01954640f, 0.00393817f, -0.03548912f, -0.01187604f, 
    0.01106775f, -0.04649123f, 0.04151014f, -0.03522551f, 0.03541616f, -0.00302058f, 0.03171009f, -0.01265005f, 
    -0.01796634f, -0.01774411f, 0.02390939f, 0.03381480f, 0.01825332f, -0.05663658f, -0.00492498f, 0.04310532f, 
    0.01518464f, -0.04013111f, -0.05240805f, -0.04123376f, 0.01144346f, 0.03491005f, 0.03740026f, -0.03974165f, 
    -0.03059182f, -0.01220143f, 0.01495112f, 0.01809937f, 0.03476823f, -0.01055077f, 0.03179030f, -0.00682243f, 
    -0.04231007f, 0.03076975f, -0.03411846f, 0.03966210f, 0.02416066f, -0.02929278f, 0.00586652f, -0.00389604f, 
    0.00456553f, -0.01905430f, -0.00897892f, 0.00952197f, 0.01570102f, -0.00755460f, -0.02531976f, -0.03343457f, 
    0.03244881f, 0.03100451f, -0.00443993f, 0.03506557f, 0.02270573f, -0.05336828f, -0.00800957f, 0.04247113f, 
    0.03108468f, -0.04017499f, 0.04174144f, 0.01984376f, -0.03321894f, -0.03722448f, -0.05544118f, 0.04442991f, 
    -0.04203199f, -0.01241160f, -0.01478186f, -0.03263315f, 0.02655443f, 0.03955892f, 0.02443685f, -0.01959878f, 
    -0.01177892f, -0.05218516f, -0.02753043f, -0.04104758f, 0.04458446f, -0.03179168f, -0.05348254f, -0.00879742f, 
    -0.04928653f, 0.00394864f, 0.00412987f, -0.04219801f, 0.04495098f, -0.03999956f, 0.03512250f, -0.03841941f, 
    -0.03718097f, -0.02250674f, 0.02015785f, -0.03470743f, 0.00416581f, -0.03117547f, -0.00809107f, -0.02991357f, 
    0.01574696f, 0.00300013f, 0.03482132f, -0.00338963f, -0.05693864f, -0.04415387f, 0.04455490f, -0.00895272f, 
    0.01766995f, -0.01962359f, 0.01779673f, -0.04518194f, -0.03322262f, -0.03290943f, -0.00656743f, -0.03816399f, 
    0.02342844f, -0.04131190f, -0.04152022f, 0.02072122f, -0.01813643f, 0.04626561f, -0.03564395f, 0.01073541f, 
    -0.01931437f, 0.02954153f, 0.04096579f, 0.01260002f, -0.05408873f, -0.03371946f, 0.00965435f, 0.00330315f, 
    -0.02496397f, 0.01573415f, 0.00954400f, 0.04367127f, -0.03417153f, -0.00386269f, -0.03843511f, 0.01680476f, 
    0.03327604f, -0.04044860f, -0.00797934f, -0.03360555f, 0.04631698f, 0.00291861f, 0.04438761f, -0.02416051f, 
    0.00097201f, -0.05395989f, 0.04209835f, -0.00085137f, -0.02487089f, 0.02572216f, 0.01779415f, -0.03976903f, 
    -0.00271045f, -0.00549657f, 0.03983142f, -0.03686884f, 0.03178334f, -0.01831806f, 0.03973275f, 0.00844045f, 
    -0.00183461f, -0.03608959f, -0.02793126f, 0.00876582f, -0.03571602f, 0.03655266f, -0.05631622f, 0.02337113f, 
    -0.04917751f, 0.02743116f, -0.05004325f, -0.04941390f, -0.05136731f, -0.02777551f, 0.01730376f, -0.00048304f, 
    -0.01848584f, -0.00368223f, 0.02331825f, 0.01864015f, 0.04123472f, -0.01257752f, -0.02279705f, -0.05150705f, 
    -0.00412674f, 0.04202835f, 0.01779429f, -0.03334719f, -0.04744123f, -0.04968691f, -0.00041302f, -0.01267856f, 
    0.01529746f, -0.02634282f, -0.04686848f, 0.00381202f, 0.03579319f, -0.00364321f, -0.03032370f, 0.03144984f, 
    -0.01362056f, -0.00690725f, -0.00811289f, -0.02226629f, -0.00433694f, 0.00093075f, 0.01789595f, -0.01560247f, 
    -0.01122308f, -0.01739281f, -0.04929816f, -0.00182193f, 0.01860255f, 0.00835479f, -0.05107917f, -0.05281412f, 
    -0.01118948f, 0.02273766f, -0.03722507f, -0.04578788f, -0.00663064f, -0.03927729f, 0.01979131f, 0.03535479f, 
    0.01449156f, 0.03195398f, 0.00333776f, 0.04683283f, -0.03635018f, -0.02608246f, -0.04891203f, 0.03678394f, 
    -0.03991752f, -0.00039730f, 0.03245489f, 0.03439677f, 0.02567007f, 0.00520825f, -0.03503455f, -0.04489292f, 
    -0.02349455f, 0.04307665f, -0.03996369f, -0.01774834f, 0.02909335f, 0.03853790f, -0.05175604f, -0.03553598f, 
    0.03312184f, 0.00685069f, -0.05464721f, -0.03847737f, 0.03297783f, -0.02276405f, -0.01280769f, 0.00296907f, 
    -0.00073803f, 0.00244576f, 0.02442423f, 0.01520184f, -0.04988928f, -0.00841280f, 0.03258678f, 0.02288042f, 
    0.02934325f, -0.02805349f, -0.00883031f, -0.04773466f, -0.03096697f, 0.04500912f, -0.01648090f, -0.02169113f, 
    -0.03425369f, 0.01234699f, 0.03954569f, -0.03241799f, 0.00910407f, 0.01763907f, 0.01886155f, -0.00531109f, 
    0.04227143f, 0.03479003f, -0.02351321f, -0.01949883f, 0.01672953f, -0.03045570f, -0.04880258f, 0.02694998f, 
    0.01667657f, -0.05029302f, 0.03173396f, -0.04031245f, -0.03649638f, 0.03098233f, -0.05400546f, 0.04250997f, 
    0.01581982f, 0.01196986f, -0.03623256f, -0.03980071f, -0.02156745f, -0.03414847f, 0.00601021f, 0.01426116f, 
    -0.01292347f, -0.04947871f, -0.05264335f, 0.03318391f, -0.00975308f, 0.00807434f, -0.04873345f, 0.03845014f, 
    -0.00193126f, 0.02469056f, -0.03812721f, -0.05636354f, -0.01580391f, 0.03240971f, -0.01502649f, 0.02275677f, 
    -0.02507129f, 0.02070825f, -0.02870293f, 0.03986499f, -0.05259037f, -0.03837198f, 0.02477122f, 0.02569030f, 
    -0.05592119f, -0.03120063f, -0.01020261f, 0.00433486f, -0.02217218f, 0.03932223f, 0.00699517f, 0.03297947f, 
    -0.01691605f, 0.00068193f, -0.02042253f, -0.02731755f, 0.01453647f, -0.01747093f, 0.03687188f, -0.01582149f, 
    0.03272590f, -0.02929392f, -0.04061472f, -0.05485445f, -0.05318164f, 0.03278235f, 0.00215479f, -0.04923896f, 
    -0.03299396f, 0.03380489f, 0.00699675f, 0.03353721f, -0.01493935f, 0.01704813f, 0.03874947f, 0.01855655f, 
    0.00860338f, 0.00342127f, -0.05115050f, 0.03415601f, 0.03544660f, 0.00962539f, 0.00425805f, -0.00165947f, 
    0.00056680f, 0.02951673f, 0.00463511f, -0.04639699f, -0.00780551f, -0.03944930f, 0.00059487f, -0.05012336f, 
    0.00299960f, -0.01460954f, 0.03469769f, 0.00847444f, -0.04178991f, -0.04306737f, 0.02123751f, 0.01643450f, 
    0.01254447f, 0.00390833f, -0.01656487f, -0.00877766f, 0.02868718f, 0.02349665f, -0.05367027f, -0.05916215f, 
    -0.04603618f, -0.02263550f, 0.00609502f, -0.03949377f, 0.04154589f, 0.03419694f, 0.03173453f, -0.00848934f, 
    0.02165059f, 0.02771768f, 0.03887103f, -0.01700391f, -0.00704828f, 0.01522823f, -0.01328332f, -0.00910432f, 
    -0.05070942f, 0.02090006f, -0.05096873f, 0.02854514f, -0.04633148f, -0.03708522f, 0.00208814f, -0.03344728f, 
    -0.01391570f, -0.00474879f, 0.00762027f, 0.02599715f, -0.05088627f, -0.03792430f, -0.01271557f, 0.04123081f, 
    0.00212868f, 0.01668785f, -0.04051942f, -0.02194679f, 0.00344133f, -0.04393676f, -0.00470279f, -0.01534541f, 
    0.02284504f, 0.00042587f, 0.00722923f, -0.03504159f, 0.03102231f, 0.04049098f, -0.02201833f, 0.03077544f, 
    -0.00809266f, 0.04091115f, 0.04356278f, 0.02904594f, -0.03605834f, 0.01251670f, 0.02982161f, 0.01534779f, 
    -0.01604442f, 0.01739307f, -0.02035199f, -0.05817373f, -0.02651720f, 0.03132407f, -0.04951304f, -0.01005942f, 
    -0.01347284f, 0.01974754f, -0.01853770f, 0.00574426f, 0.01871903f, -0.05104900f, -0.03708939f, -0.03963611f, 
    0.02499654f, 0.02868308f, -0.00209957f, 0.04110628f, 0.02164570f, 0.01170168f, 0.02149616f, -0.05622870f, 
    -0.01555871f, -0.03279386f, 0.02550641f, -0.01841883f, 0.00717625f, -0.03614444f, 0.01769607f, -0.02570680f, 
    -0.04762251f, -0.02223037f, 0.02877940f, 0.02475776f, -0.04278481f, 0.01771950f, 0.00767633f, -0.02264625f, 
    0.01999557f, -0.02011275f, 0.01887430f, -0.04523381f, 0.03618557f, -0.04797266f, -0.00911579f, -0.02202108f, 
    -0.05632922f, -0.01455716f, -0.10109928f, -0.09670338f, -0.01048967f, 0.05776260f, -0.09626683f, -0.09438846f, 
    0.01906634f, -0.07939905f, 0.07565828f, -0.09212401f, -0.14303170f, -0.03767871f, 0.06166359f, -0.12651534f, 
    -0.12768948f, -0.06461077f, 0.09930924f, -0.01870033f, 0.06814425f, -0.06433386f, 0.14225955f, 0.07905025f, 
    -0.17246406f, -0.23669316f, -0.19107834f, 0.06228564f, -0.04284607f, 0.08525818f, -0.02309552f, 0.12339305f, 
    0.11371595f, -0.03673648f, 0.14979038f, 0.06597976f, -0.13545325f, 0.03122023f, 0.12952918f, 0.19342342f, 
    -0.02386521f, -0.02662375f, 0.10642177f, -0.18654177f, 0.05618197f, 0.05197529f, -0.02933500f, 0.04358236f, 
    -0.00022607f, -0.01324161f, 0.13647442f, 0.05730447f, 0.08224670f, 0.11336811f, 0.11468507f, -0.02936233f, 
    0.05269133f, -0.08344650f, -0.00633822f, -0.07967743f, -0.05875429f, -0.11933520f, 0.07488615f, 0.10154033f, 
    0.08513990f, 0.19930977f, 0.02704176f, 0.02351992f, 0.00132614f, -0.04337616f, 0.09402787f, -0.02818323f, 
    -0.00875652f, -0.22077250f, 0.18901400f, -0.00874452f, 0.18763341f, -0.01023730f, 0.01432905f, -0.13395286f, 
    -0.04389056f, -0.10907880f, -0.02053910f, 0.17815484f, -0.01811685f, 0.11414465f, 0.06850459f, 0.20673099f, 
    -0.06637845f, 0.05416204f, 0.05371746f, 0.08368005f, -0.02580096f, -0.07407617f, 0.19863695f, -0.04835068f, 
    -0.62827331f, -0.10017451f, -0.20414935f, -0.08421780f, 0.03187029f, -0.00102741f, 0.13975708f, 0.11168732f, 
    -0.12510681f, -0.08236065f, 0.12840268f, -0.09312147f, 0.06384265f, -0.06017096f, 0.10766884f, 0.31520468f, 
    0.19015166f, 0.08810865f, 0.06531589f, 0.02524247f, 0.11737226f, -0.09688313f, 0.10010937f, 0.04627869f, 
    -0.08788520f, -0.00371581f, 0.10477848f, 0.26544920f, 0.01125658f, 0.04652498f, 0.01598709f, 0.03123357f, 
    -0.06135545f, -0.05067575f, -0.06193656f, 0.25907579f, -0.00381411f, -0.03640285f, 0.07656122f, 0.16913623f, 
    -0.07570874f, -0.07307496f, 0.10266471f, 0.00780127f, 0.08629660f, 0.16208762f, -0.01412485f, 0.14223742f, 
    -0.02500040f, -0.04694832f, 0.00559938f, 0.18058009f, 0.11074504f, 0.04172217f, 0.09494812f, 0.10475795f, 
    0.03410781f, 0.05328056f, -0.17914625f, -0.18132736f, 0.06371531f, -0.04394391f, 0.04621279f, 0.13585927f, 
    -0.04908068f, 0.05534187f, 0.13595058f, -0.05054776f, -0.03478328f, -0.12625371f, 0.28292558f, 0.26695853f, 
    -0.06908613f, 0.07529335f, 0.02276232f, 0.10618381f, 0.05169249f, 0.06582226f, 0.14932840f, 0.14301403f, 
    0.04655814f, -0.20895134f, 0.14476909f, -0.04953441f, -0.14039287f, 0.17569436f, 0.05833193f, 0.01252866f, 
    -0.01838027f, -0.01737743f, 0.15484551f, 0.04390750f, 0.00749008f, 0.24468572f, -0.02689987f, -0.03978773f, 
    0.20391315f, -0.13306479f, 0.10128750f, 0.14174494f, 0.00164217f, 0.27194229f, -0.15485220f, -0.11043718f, 
    0.25904635f, -0.09541463f, -0.09525622f, 0.01228399f, -0.42378521f, -0.01065217f, -0.15765683f, 0.03107499f, 
    0.09853702f, -0.11869904f, 0.04903496f, -0.04702712f, 0.06321780f, 0.13833836f, -0.05847725f, 0.24381457f, 
    -0.15122117f, 0.06088071f, -0.03116043f, 0.10885739f, 0.02229938f, 0.10045899f, -0.02612840f, -0.02945442f, 
    0.15206487f, -0.18703799f, 0.15900989f, 0.14320931f, 0.06549636f, -0.07243282f, 0.09715382f, 0.20886353f, 
    0.02177920f, 0.06987098f, 0.14415112f, 0.04916050f, -0.03383563f, -0.00956869f, 0.11079001f, 0.12669259f, 
    -0.39700228f, -0.20541607f, -0.15794538f, -0.06022572f, 0.19162749f, 0.02582824f, 0.02380201f, -0.14528635f, 
    0.18629634f, 0.14045824f, 0.01727330f, 0.23491898f, -0.02888666f, 0.06188607f, 0.05425300f, 0.14715414f, 
    0.07114084f, 0.00326161f, -0.08062140f, -0.06777086f, -0.00475831f, -0.04803522f, -0.16969162f, 0.08086666f, 
    0.04293115f, -0.04288742f, -0.05501201f, -0.20849864f, -0.00109372f, 0.04889384f, -0.06714787f, -0.05616547f, 
    0.05977410f, -0.01203659f, 0.07964809f, 0.00380923f, -0.39171472f, -0.01359897f, 0.05049162f, -0.01992151f, 
    0.01536720f, -0.15086265f, -0.08899142f, -0.04023403f, 0.09539387f, 0.04540375f, 0.15361661f, -0.01320113f, 
    -0.28994846f, -0.00359276f, -0.24368010f, 0.06320263f, -0.10102397f, -0.18189801f, 0.01456105f, 0.09333623f, 
    0.07294530f, -0.19284768f, 0.06663043f, 0.07489198f, 0.15413035f, -0.35742700f, -0.00820137f, 0.08070508f, 
    0.05723996f, -0.03176818f, -0.00354066f, -0.03981415f, -0.07139216f, -0.15435931f, -0.08988967f, -0.03309797f, 
    0.11421410f, 0.05847384f, 0.18325287f, 0.15383151f, 0.04217847f, 0.05850064f, 0.11473792f, 0.04228183f, 
    0.00995722f, 0.08471251f, 0.08710492f, 0.12954596f, 0.10225664f, 0.03816992f, -0.19235362f, -0.12516707f, 
    -0.09532096f, -0.01056506f, -0.19261780f, -0.14889090f, 0.03866005f, 0.17364597f, -0.13517082f, -0.03350037f, 
    0.07246682f, -0.01783829f, -0.11548975f, -0.25514501f, -0.06673536f, -0.01441389f, 0.14314610f, -0.07887507f, 
    0.12552400f, -0.03797463f, -0.28500745f, -0.13564153f, 0.27025509f, 0.03648806f, 0.16400991f, 0.00672291f, 
    0.11528443f, 0.13420393f, -0.09413005f, -0.17427333f, -0.20272852f, 0.07592843f, -0.06096551f, 0.06122387f, 
    -0.11487249f, 0.03279972f, -0.07010385f, -0.03565064f, -0.05980469f, -0.00643593f, 0.00264419f, -0.06823151f, 
    -0.15393074f, -0.10820299f, -0.05486800f, 0.02080729f, -0.34027532f, -0.00078676f, -0.17050304f, -0.28379920f, 
    0.14533156f, -0.08526420f, -0.04019324f, -0.01079479f, 0.05488066f, -0.00723827f, 0.05952975f, -0.13561368f, 
    0.33361465f, -0.16275959f, 0.11351345f, 0.12914243f, -0.01624500f, -0.01986331f, 0.03538433f, 0.14348751f, 
    0.02239921f, -0.06522138f, 0.05866690f, -0.02221680f, 0.35926434f, -0.21186049f, 0.09898479f, 0.15770815f, 
    0.21610071f, 0.12019533f, -0.05646191f, 0.00245988f, 0.09534296f, 0.05951653f, 0.18840785f, 0.10958181f, 
    0.30370563f, 0.06415686f, -0.11699981f, 0.04252067f, 0.09979577f, 0.00161473f, -0.02081266f, 0.09560060f, 
    0.03909383f, -0.01386954f, 0.13531512f, -0.00612556f, -0.11460760f, -0.03010539f, 0.29723704f, 0.19927503f, 
    0.03289027f, -0.02518564f, -0.02953487f, -0.09310355f, 0.20711365f, 0.09181788f, 0.11037853f, 0.04424094f, 
    0.04691377f, -0.01518788f, 0.07855763f, 0.15398438f, 0.08023433f, 0.10178894f, 0.00734925f, -0.03157496f, 
    0.12304851f, 0.03137850f, 0.08137436f, -0.01256514f, -0.09166438f, 0.27697060f, 0.12729968f, 0.41235006f, 
    -0.03986305f, 0.01830928f, 0.01150439f, -0.03915644f, 0.05655152f, -0.04451649f, -0.07302972f, -0.00359355f, 
    -0.11880928f, 0.04088264f, 0.28968498f, -0.15385878f, 0.09277197f, 0.13010213f, -0.03886592f, -0.06283643f, 
    -0.04812232f, 0.09552266f, 0.06364307f, 0.08104958f, -0.03745470f, 0.21060219f, -0.30800578f, 0.10150549f, 
    0.10297509f, 0.05472806f, -0.11360804f, 0.11971360f, 0.15216148f, 0.11486789f, 0.02129936f, 0.08787972f, 
    0.20032483f, -0.07385954f, 0.08969226f, -0.01368584f, -0.02217295f, -0.06954653f, 0.12586835f, 0.04059510f, 
    -0.05208046f, -0.11019909f, 0.00280261f, 0.00707583f, 0.04125485f, 0.20421369f, -0.12496637f, 0.01449414f, 
    0.07859372f, -0.05403896f, -0.00127850f, -0.02855545f, 0.04509513f, 0.03419188f, 0.06498761f, 0.09350647f, 
    0.00709549f, 0.19599475f, -0.37419838f, 0.00891026f, 0.20019016f, 0.05002161f, -0.01149577f, 0.04389683f, 
    0.03508035f, 0.12503780f, -0.07086555f, 0.06096804f, -0.24443497f, -0.00153584f, -0.14481948f, -0.04264497f, 
    0.08446705f, -0.07063166f, 0.01480113f, 0.06424911f, 0.00863287f, 0.11565100f, -0.02974678f, 0.09323621f, 
    0.10725790f, 0.02724272f, 0.07821511f, -0.21441266f, 0.12716985f, 0.00224231f, 0.18966013f, 0.01266823f, 
    0.11739832f, 0.03809984f, -0.03121175f, 0.05812928f, 0.08434991f, -0.12575762f, -0.01906979f, 0.09761231f, 
    0.17941774f, -0.01933591f, 0.10660247f, -0.12185452f, 0.10375527f, 0.04219116f, 0.12053430f, 0.06604403f, 
    -0.25552794f, -0.06815175f, 0.02821080f, 0.01519084f, 0.09492258f, 0.00008764f, 0.00432739f, 0.07292762f, 
    0.06782461f, 0.07381367f, 0.15795620f, -0.05023193f, 0.12036324f, -0.11850355f, -0.03575148f, -0.25464275f, 
    0.01880559f, -0.07500055f, 0.13637267f, -0.00147217f, 0.08430602f, 0.06341375f, -0.07476965f, -0.04595227f, 
    -0.08315270f, 0.09910281f, -0.23008128f, -0.02684381f, -0.06340498f, 0.03649609f, -0.12896585f, 0.02785582f, 
    0.02486288f, -0.02907597f, 0.07832564f, 0.05007503f, 0.08537536f, 0.35255912f, 0.30103680f, -0.05058333f, 
    0.10981377f, 0.07832769f, 0.08945605f, 0.08723110f, 0.01640687f, 0.06368927f, 0.01626345f, 0.08099438f, 
    -0.17014360f, 0.30447561f, -0.22009975f, -0.08561163f, -0.01973300f, 0.01433076f, -0.00925505f, 0.05919402f, 
    0.09031345f, -0.06542376f, 0.17314832f, 0.07634097f, -0.01918162f, -0.00169100f, -0.11099192f, 0.04688430f, 
    0.07908066f, -0.05968678f, 0.05778433f, 0.05896982f, -0.00081490f, 0.06250361f, -0.05476776f, 0.06343871f, 
    0.01900901f, 0.22823524f, 0.30356446f, 0.05615195f, 0.00702926f, -0.04797744f, -0.01545679f, -0.04327612f, 
    -0.07119276f, 0.02317729f, 0.02646338f, 0.05109685f, -0.11476026f, 0.26573166f, -0.08704304f, 0.01623848f, 
    0.09287366f, 0.02834919f, 0.00194847f, -0.00467539f, 0.08895072f, 0.02782443f, 0.00061675f, 0.10967128f, 
    -0.23153676f, 0.09936350f, -0.05854311f, -0.06284712f, 0.06292937f, -0.13073438f, 0.00543458f, 0.12119078f, 
    0.07652798f, -0.13547425f, -0.01033687f, -0.00657852f, -0.05464821f, 0.35353869f, -0.19366865f, 0.10741425f, 
    -0.02011503f, -0.02107870f, 0.00471061f, 0.16183501f, -0.05050385f, 0.12707648f, 0.00661960f, -0.05543861f, 
    -0.17522706f, 0.10586599f, 0.14828715f, 0.24867548f, -0.08699446f, 0.05559305f, 0.08768775f, 0.05227436f, 
    0.08314715f, -0.04458518f, 0.12462484f, -0.04616344f, 0.05984301f, 0.10882751f, -0.13357615f, 0.04821218f, 
    0.02990516f, -0.06031018f, -0.05523629f, -0.11118012f, 0.04915519f, 0.01076181f, 0.04462483f, -0.03906127f, 
    -0.16103548f, -0.14042430f, 0.23153110f, 0.25975043f, -0.07956449f, 0.05286327f, -0.02124120f, -0.04701184f, 
    0.07347549f, -0.02705989f, 0.18278028f, -0.05318739f, 0.05952925f, 0.23237865f, 0.04147533f, 0.19064055f, 
    -0.07272004f, -0.08347991f, 0.04566690f, -0.01571298f, 0.07650799f, 0.06490057f, -0.06693418f, 0.08046246f, 
    0.31681684f, 0.02580320f, 0.17393588f, 0.14389871f, -0.09105208f, -0.09090640f, 0.12892312f, -0.01623943f, 
    0.03087650f, 0.03750503f, -0.04650639f, 0.00532491f, 0.21433771f, -0.01225948f, -0.02960745f, -0.10826704f, 
    0.05502619f, -0.04972954f, -0.07241833f, -0.04988566f, -0.04361560f, 0.00501794f, -0.03438773f, 0.00768180f, 
    -0.08539305f, 0.16908464f, -0.26269236f, 0.10064603f, 0.17235900f, 0.01950593f, -0.07107938f, -0.16766453f, 
    0.06665449f, 0.01298575f, 0.03232167f, 0.04038057f, 0.38400391f, -0.13472436f, 0.12351147f, -0.01543793f, 
    -0.02261896f, 0.01320328f, 0.08257003f, 0.05090175f, 0.02449452f, 0.12566240f, 0.03126449f, -0.04313356f, 
    -0.02334095f, 0.02676528f, -0.01804967f, -0.02877506f, -0.04458386f, 0.00079671f, 0.01362752f, 0.03175011f, 
    0.02278300f, -0.00540889f, -0.01262482f, -0.02677873f, 0.00098983f, 0.00004869f, -0.03871454f, -0.04235299f, 
    0.02021568f, -0.02177254f, 0.01072131f, -0.03684451f, -0.03785831f, 0.03417110f, 0.04579232f, -0.02833724f, 
    0.01104505f, 0.03393386f, 0.04891036f, 0.03660417f, -0.02801888f, 0.01019170f, -0.02787093f, -0.00427554f, 
    -0.04734113f, -0.04482760f, -0.05547310f, 0.02222633f, 0.01973953f, -0.04644882f, -0.03068986f, 0.00395235f, 
    0.00858214f, 0.00368046f, 0.00396178f, 0.00756830f, 0.03443471f, 0.00158059f, 0.04248049f, 0.03533003f, 
    -0.00656481f, 0.01963689f, 0.02772488f, -0.03893570f, -0.02787355f, 0.05045835f, -0.04800643f, -0.02233995f, 
    -0.01435464f, 0.02556890f, -0.01506877f, -0.00340503f, -0.00291595f, 0.03628678f, 0.04297958f, -0.01301352f, 
    -0.02614153f, -0.00454952f, 0.03649785f, -0.04738963f, 0.04506708f, -0.01780502f, -0.00965340f, -0.01331971f, 
    0.02825505f, 0.01450488f, -0.02174055f, -0.03237877f, 0.04102984f, -0.04701378f, -0.00724705f, -0.01045774f, 
    -0.04673075f, -0.04878732f, -0.01959871f, -0.03268517f, -0.02477776f, 0.00767828f, -0.00786718f, -0.04563727f, 
    -0.05849145f, 0.02991311f, -0.00957208f, 0.02557455f, 0.01896987f, 0.01374223f, -0.05711182f, -0.04033493f, 
    -0.02431443f, -0.04138870f, 0.03245805f, -0.03681907f, 0.01131320f, 0.00401451f, 0.03976550f, 0.01067311f, 
    -0.03997597f, -0.03646949f, 0.00545491f, -0.04505111f, 0.04563907f, 0.03077305f, -0.05307055f, -0.02002155f, 
    -0.04496049f, 0.01271837f, -0.04618583f, -0.03957578f, 0.00840550f, 0.02222888f, -0.04600595f, -0.04247949f, 
    -0.05419152f, -0.02330031f, -0.04810849f, -0.03021393f, -0.00781991f, -0.00558990f, 0.03038765f, -0.00769190f, 
    -0.01747084f, 0.01103371f, 0.00586672f, 0.01232221f, 0.00321521f, -0.05782826f, -0.01622104f, -0.04594242f, 
    -0.02104151f, 0.00854218f, 0.00662960f, -0.01845232f, 0.04108404f, 0.02241304f, 0.00306770f, 0.04810375f, 
    -0.06059435f, 0.01917753f, -0.05775163f, 0.02190836f, -0.01204975f, 0.01610167f, -0.03599176f, -0.04896946f, 
    -0.04142001f, -0.01414311f, 0.03512404f, -0.02109673f, 0.00255021f, -0.01486517f, 0.02851045f, -0.00683842f, 
    -0.03706280f, -0.01760758f, -0.05216309f, -0.04674570f, -0.00045207f, 0.02465974f, -0.03458570f, 0.04743055f, 
    -0.01327934f, -0.05455560f, 0.04224604f, -0.00827921f, -0.00791135f, -0.02259969f, 0.00747588f, 0.04894461f, 
    -0.02978997f, -0.02875460f, 0.03938533f, -0.04049012f, 0.03815881f, 0.02149483f, -0.04498370f, 0.02634569f, 
    -0.02370417f, -0.00559737f, -0.05087042f, -0.04940961f, 0.03053121f, 0.01416437f, -0.04341512f, 0.03556385f, 
    -0.05634440f, -0.01020135f, 0.01469497f, -0.04198086f, -0.00062676f, 0.02437781f, -0.00006807f, -0.03002864f, 
    0.03446846f, 0.04002556f, -0.00132946f, 0.02991044f, 0.04022830f, 0.00480840f, 0.03149880f, -0.03985308f, 
    -0.01538648f, -0.04574924f, 0.00784931f, -0.03894641f, 0.04014914f, 0.04200942f, -0.01272196f, 0.00085395f, 
    -0.02546714f, -0.02492351f, -0.04196867f, 0.05264789f, -0.00086057f, -0.05373271f, 0.01168164f, 0.03218014f, 
    -0.02926274f, -0.02430186f, 0.00172104f, 0.04771113f, -0.04101618f, 0.03515743f, -0.03636821f, 0.03770435f, 
    -0.05016914f, -0.03471959f, -0.00234786f, -0.00338489f, -0.03779837f, 0.02057655f, 0.02717439f, -0.00896732f, 
    0.03502018f, 0.04866841f, -0.04077515f, -0.04446473f, 0.04365540f, -0.01376247f, 0.03466427f, 0.01677552f, 
    0.03857467f, -0.00492378f, -0.01422598f, 0.05228858f, 0.00297817f, -0.04006453f, -0.01639548f, 0.01369576f, 
    -0.04519436f, -0.01327377f, 0.02590341f, -0.01309599f, 0.01928906f, -0.02987158f, -0.01709094f, 0.01792226f, 
    -0.04897859f, -0.04300497f, -0.04634411f, -0.04927106f, -0.01919276f, -0.05640138f, 0.00503648f, -0.00951299f, 
    -0.00622309f, 0.02030014f, 0.03917488f, -0.01428411f, -0.00346627f, -0.00764147f, 0.03406959f, -0.04532328f, 
    0.00864509f, -0.03189758f, -0.04158146f, 0.03198352f, -0.01445008f, 0.01323597f, 0.04475568f, 0.02674026f, 
    0.01494029f, -0.03985439f, -0.01655039f, -0.02749220f, 0.04743998f, -0.01195748f, 0.04320644f, -0.02185701f, 
    0.02115873f, 0.02511262f, -0.03115512f, 0.02491686f, -0.04481148f, 0.02395361f, -0.05958622f, -0.00815040f, 
    0.03806082f, 0.03095283f, -0.00560360f, 0.03490680f, 0.00794518f, 0.03635571f, -0.00148594f, -0.02359025f, 
    -0.02174005f, 0.02900628f, 0.01515452f, 0.03412854f, 0.03438848f, -0.02772961f, -0.04307716f, -0.01689800f, 
    0.05224662f, -0.01488755f, -0.03448552f, -0.01906038f, 0.03289454f, -0.04094645f, -0.04530256f, -0.03626688f, 
    -0.01871839f, 0.00980960f, -0.03297419f, 0.03739250f, 0.00603934f, 0.00379790f, -0.04981993f, -0.00570069f, 
    -0.03325709f, 0.02048803f, -0.05587570f, 0.04403615f, -0.00594438f, -0.03444425f, 0.01588152f, 0.02516919f, 
    0.00325132f, -0.02456492f, 0.01353861f, 0.03111162f, 0.04559958f, -0.01021902f, 0.02397817f, 0.01361524f, 
    -0.04174007f, 0.03634775f, 0.00343810f, 0.03882303f, 0.00384287f, -0.01806610f, 0.02945252f, 0.04173869f, 
    -0.02121554f, -0.01911923f, -0.02469501f, -0.02848709f, -0.00359065f, 0.00244733f, 0.02324630f, -0.03110859f, 
    0.04205535f, 0.00555693f, 0.00819250f, -0.04298780f, -0.03752890f, -0.02962841f, -0.00836843f, -0.02917740f, 
    0.02464312f, 0.01278814f, -0.00437176f, 0.04695186f, 0.03064913f, -0.03868755f, 0.00036592f, -0.04872281f, 
    0.09254315f, -0.17373976f, -0.07900304f, -0.01478937f, 0.13857040f, 0.04155216f, -0.12344611f, 0.08668063f, 
    0.06021635f, 0.01100436f, 0.16039979f, -0.03062389f, 0.12700331f, -0.10430865f, 0.05813204f, -0.02042842f, 
    -0.05132869f, -0.06904965f, 0.09464732f, 0.01450273f, 0.10161006f, 0.10576125f, 0.10323560f, 0.20783234f, 
    -0.01877496f, -0.03575347f, 0.05368017f, -0.05742320f, 0.01415025f, -0.03079032f, 0.02579155f, 0.08573227f, 
    -0.05214707f, 0.01262824f, 0.13994221f, 0.00030039f, -0.05269859f, 0.03308889f, 0.06675771f, 0.04755595f, 
    -0.09125672f, 0.09873458f, -0.11107360f, 0.00155209f, 0.14712104f, 0.03077554f, 0.02912819f, -0.01397131f, 
    -0.10376251f, 0.12822717f, 0.21570551f, 0.03913437f, -0.10229193f, 0.05746260f, 0.03798955f, 0.03982796f, 
    0.03540210f, 0.03246915f, 0.11368137f, -0.07847714f, -0.12682575f, 0.05251697f, 0.02610891f, -0.01799751f, 
    0.10503951f, -0.06712392f, 0.01815284f, 0.01920748f, 0.07726682f, 0.06621628f, 0.08262935f, -0.01649845f, 
    -0.10287761f, -0.13791689f, 0.04029820f, -0.23523511f, 0.21240656f, 0.07941172f, -0.15254091f, -0.14480735f, 
    -0.09508412f, 0.06495581f, 0.06578249f, 0.05925518f, -0.19004063f, -0.07692417f, 0.00700796f, 0.21112533f, 
    0.07819783f, -0.00691643f, 0.06967423f, -0.00883053f, 0.04167021f, 0.03588156f, -0.07248981f, -0.03873391f, 
    -0.06471594f, -0.04786641f, -0.10366290f, -0.16584063f, 0.04516394f, -0.05489989f, 0.07438174f, -0.06223562f, 
    -0.01092142f, -0.00890986f, 0.06631932f, -0.12179150f, -0.22495715f, 0.09502363f, 0.09382460f, 0.21110836f, 
    -0.03563628f, -0.13267797f, -0.06153556f, 0.12520227f, -0.01420687f, 0.03441725f, -0.01090748f, 0.05552152f, 
    0.08779772f, 0.07988223f, -0.00057868f, -0.11234333f, 0.00946708f, 0.02246751f, 0.00864699f, -0.04911669f, 
    -0.07413205f, -0.03940463f, -0.07449061f, 0.12609191f, -0.19782162f, 0.02128448f, 0.03958228f, 0.11682189f, 
    0.04047047f, -0.12713973f, 0.09828965f, 0.05744660f, -0.08394769f, 0.02105283f, -0.02407863f, 0.05737107f, 
    -0.19015172f, -0.02986076f, 0.04507683f, 0.06446662f, 0.14637311f, -0.03352111f, 0.11446992f, 0.00757584f, 
    0.01344039f, 0.01248947f, 0.03567015f, 0.00925306f, -0.10323163f, 0.06828766f, 0.11671168f, -0.07845856f, 
    -0.03848758f, 0.11919811f, 0.06250956f, -0.01507927f, 0.09879768f, 0.04866134f, 0.01075707f, -0.07091001f, 
    -0.49893305f, 0.00016644f, 0.17295426f, 0.16601267f, -0.03447922f, -0.03106720f, 0.17082378f, 0.06748605f, 
    0.01555771f, -0.02495542f, -0.05353326f, 0.00597393f, -0.04202551f, 0.12660339f, -0.09045033f, -0.23256645f, 
    -0.00333804f, 0.00005402f, 0.16898479f, 0.05746882f, -0.07342873f, 0.06731502f, 0.03873019f, -0.06230809f, 
    0.08026492f, -0.22524458f, -0.17662604f, 0.01810627f, 0.11551062f, -0.04072346f, 0.00720978f, 0.06045735f, 
    0.20463298f, -0.00763310f, -0.00709274f, 0.10125443f, -0.10788886f, -0.14097831f, 0.02343303f, 0.01899097f, 
    0.12135859f, 0.04087473f, 0.04813958f, 0.11209310f, 0.05770655f, 0.00532506f, 0.07564969f, 0.10479335f, 
    -0.08774656f, 0.04124204f, -0.08868707f, -0.03224242f, 0.02271805f, 0.11328083f, -0.02796504f, -0.00503746f, 
    0.03549520f, -0.03267220f, 0.06327482f, 0.06142987f, 0.07593860f, 0.11230799f, 0.07943382f, 0.01997644f, 
    0.12510978f, 0.02713067f, 0.04072849f, 0.01402625f, -0.12307221f, -0.00287955f, 0.07263391f, 0.05610924f, 
    -0.11586270f, 0.01316826f, -0.09383253f, 0.01895384f, 0.04262109f, 0.10225378f, 0.05252819f, -0.13662463f, 
    0.02646549f, 0.09693842f, 0.05903375f, 0.14820617f, -0.26363477f, 0.27584663f, 0.16762450f, 0.25578183f, 
    0.06027601f, 0.02497071f, 0.07505279f, -0.01510099f, 0.00062318f, -0.06610501f, 0.01934877f, 0.02364178f, 
    -0.27500132f, -0.15093914f, -0.00896414f, -0.16274808f, 0.03441245f, 0.06613784f, 0.17300366f, 0.04552471f, 
    0.11875914f, -0.08864462f, -0.02471612f, -0.05225428f, 0.08910582f, 0.09307329f, -0.15808073f, 0.00377552f, 
    0.04574424f, -0.06908739f, 0.00509743f, -0.08567944f, -0.08022560f, 0.09921490f, 0.01721155f, -0.00842522f, 
    -0.12631598f, -0.06856686f, -0.02210721f, 0.18179823f, 0.03019508f, 0.02761755f, 0.14031257f, 0.11940625f, 
    0.08793817f, 0.01072743f, 0.07412435f, 0.12279436f, -0.06514960f, -0.18577582f, -0.03284973f, 0.14788578f, 
    0.01897667f, 0.01645616f, -0.00827439f, -0.04484954f, -0.04147912f, -0.00528483f, 0.02473710f, -0.01485338f, 
    -0.21785921f, 0.21713440f, 0.23241396f, -0.00711226f, -0.06203244f, 0.01184829f, 0.02008107f, 0.04522015f, 
    0.08322416f, 0.11792938f, 0.08329557f, -0.01548758f, 0.12990056f, -0.02480573f, -0.15749164f, -0.10552759f, 
    -0.04472541f, -0.00766837f, 0.04187754f, 0.17331858f, 0.12444296f, -0.06818362f, -0.02515623f, 0.04775514f, 
    0.25182667f, -0.11206983f, 0.13528669f, 0.00781278f, -0.07626299f, 0.01653025f, -0.01591529f, -0.06275598f, 
    0.12345863f, -0.08028608f, -0.02964003f, 0.05411538f, 0.13686822f, 0.21370010f, 0.08394164f, 0.22372022f, 
    0.05129280f, 0.07910635f, -0.07054304f, 0.00724583f, 0.08777639f, 0.07215552f, 0.05931779f, -0.01095883f, 
    -0.09889688f, 0.02853149f, -0.03391434f, -0.06842609f, 0.03365337f, -0.01459561f, -0.00121344f, -0.03106591f, 
    -0.10520416f, -0.08023801f, -0.03775611f, 0.01821240f, 0.51475579f, -0.07868786f, -0.04256806f, -0.08603402f, 
    -0.02950156f, 0.02363949f, -0.01069976f, 0.01157088f, 0.10932084f, 0.06268391f, 0.03370946f, 0.01415032f, 
    0.23336522f, 0.06010270f, -0.02023991f, 0.24693923f, 0.22644718f, -0.06308210f, 0.09631217f, 0.22078235f, 
    0.08716957f, 0.02673890f, 0.01701420f, 0.06755046f, 0.01122232f, -0.15941274f, -0.10615662f, -0.09037380f, 
    0.21130617f, -0.04977037f, 0.03310012f, -0.03197546f, 0.17304635f, -0.02620661f, 0.03291384f, 0.03810741f, 
    -0.05942848f, 0.09169850f, 0.00724077f, 0.11636501f, 0.05080281f, 0.17183699f, 0.01703405f, -0.05657258f, 
    0.21902706f, 0.03934640f, -0.00755482f, 0.01288707f, -0.00288365f, -0.20742159f, -0.06513742f, -0.05325183f, 
    0.12194233f, -0.12547863f, 0.12497140f, -0.02416475f, 0.11966227f, -0.01119420f, 0.03274567f, 0.14885803f, 
    0.07316677f, -0.17971838f, 0.03664443f, 0.03934767f, 0.16877449f, 0.10383055f, 0.00399839f, 0.03707600f, 
    0.23065343f, -0.00282991f, 0.04365933f, 0.15950711f, -0.10220673f, -0.10756609f, 0.25292781f, 0.03610122f, 
    -0.02289717f, 0.15731274f, 0.01988806f, 0.20005740f, 0.11328836f, 0.08487084f, 0.05506616f, 0.04803775f, 
    0.42325899f, 0.16203475f, -0.03507726f, 0.07137027f, 0.15564395f, 0.01340271f, 0.21689963f, 0.33778328f, 
    -0.05063218f, -0.00278336f, -0.07278237f, 0.15119492f, 0.14310776f, -0.20584431f, 0.23959452f, -0.04454132f, 
    -0.00766292f, 0.04198208f, 0.06193836f, -0.03050335f, 0.02059513f, 0.12901570f, 0.02850639f, 0.17142901f, 
    0.04846741f, -0.05968471f, -0.26164421f, 0.22101125f, 0.02968769f, -0.09506603f, 0.03867931f, 0.21028079f, 
    0.01501486f, -0.10852531f, 0.07127675f, -0.03271098f, -0.09135260f, -0.26899070f, 0.10619201f, -0.23559342f, 
    -0.12560311f, 0.21145613f, -0.05119993f, 0.01198147f, 0.10366823f, 0.06921178f, 0.15285742f, 0.09838789f, 
    0.03965717f, 0.02231265f, 0.28092679f, 0.23402941f, 0.13897605f, 0.10731171f, 0.09257054f, -0.02826341f, 
    0.17534477f, 0.13434824f, 0.08465718f, -0.00225082f, 0.01665339f, -0.09631234f, 0.22783084f, 0.18440311f, 
    0.13429783f, 0.12183604f, 0.03387288f, -0.03998846f, 0.07472309f, 0.05098609f, 0.01162607f, 0.18802448f, 
    0.13550293f, 0.24854442f, 0.29750356f, 0.01277028f, -0.09176110f, 0.05386394f, 0.09957872f, -0.05217726f, 
    0.02199608f, 0.07444149f, -0.00149301f, -0.00987746f, -0.02557653f, -0.10904328f, 0.26044258f, -0.04737486f, 
    0.10605950f, 0.04190324f, -0.03125003f, 0.01757863f, 0.12794638f, 0.06518644f, 0.19805644f, 0.13639885f, 
    0.18125185f, -0.01510176f, 0.22835408f, 0.00287335f, 0.06915894f, 0.12737395f, -0.01361724f, -0.01356659f, 
    0.11855799f, 0.14603414f, 0.04060867f, 0.16187948f, -0.07167421f, 0.09456053f, 0.26089585f, 0.16421308f, 
    0.17423540f, 0.20083444f, 0.00813376f, -0.11586250f, 0.21547827f, 0.10466202f, -0.04812557f, 0.15412937f, 
    -0.09932828f, 0.07236620f, 0.37047267f, 0.01179575f, -0.21723539f, 0.20157494f, -0.07511441f, 0.03349056f, 
    -0.08711637f, 0.07877691f, 0.18450052f, -0.03969358f, 0.34657708f, 0.05653089f, -0.03365383f, 0.00926544f, 
    0.11965072f, 0.06849134f, 0.15953836f, -0.01252242f, -0.11449651f, 0.10883638f, 0.01062646f, 0.13989276f, 
    0.26826894f, 0.01382881f, 0.01857213f, 0.09990912f, 0.03727383f, 0.27852541f, 0.20639104f, 0.08865522f, 
    -0.06668303f, 0.08961073f, 0.13469811f, 0.09285606f, -0.43943211f, 0.17431858f, 0.05505969f, 0.12878045f, 
    0.04360384f, 0.10782921f, 0.07812404f, 0.04649384f, 0.16295800f, 0.03900824f, 0.03446567f, -0.00240187f, 
    0.13260919f, -0.19793625f, 0.19259752f, 0.01402758f, -0.03158686f, -0.06550200f, 0.11887743f, 0.13122983f, 
    0.03870995f, 0.11768451f, 0.00870287f, 0.02328206f, 0.22126764f, -0.36983940f, 0.15708151f, -0.09745553f, 
    0.01049349f, 0.07986460f, -0.01355440f, -0.15565056f, 0.09702635f, 0.12165162f, -0.08824831f, 0.04501378f, 
    0.28508258f, -0.10165186f, -0.18180904f, 0.43540442f, 0.03398454f, -0.14738119f, 0.04531442f, 0.10889281f, 
    0.10662504f, 0.06271917f, 0.06794406f, 0.02660733f, -0.22152354f, -0.01288537f, -0.00164421f, -0.22188400f, 
    0.02667476f, 0.08758298f, -0.07502870f, 0.19884616f, 0.11780644f, 0.15632129f, -0.02094880f, 0.02908497f, 
    0.12500559f, -0.06478456f, 0.14894895f, 0.08952059f, -0.00340194f, -0.05467174f, -0.02956028f, 0.13698146f, 
    0.20063293f, 0.01972246f, 0.11015879f, -0.02526197f, -0.04462877f, 0.02248352f, 0.28190815f, -0.08272660f, 
    -0.20623663f, -0.05477265f, 0.20944764f, 0.11119509f, -0.01352645f, 0.02047192f, -0.00050165f, -0.04286973f, 
    -0.05907291f, -0.25602910f, 0.05814461f, -0.09980539f, 0.16615842f, 0.02845194f, 0.06418955f, 0.10647551f, 
    0.20376998f, -0.05244058f, 0.07597638f, 0.19886436f, 0.17176333f, -0.10847888f, 0.09610344f, 0.26868093f, 
    -0.08196917f, 0.01247022f, -0.03545760f, -0.10195042f, -0.05402842f, 0.10425600f, 0.02134261f, -0.06553850f, 
    -0.15646183f, -0.00496398f, 0.00712777f, 0.13400109f, 0.24822891f, 0.05734821f, 0.12609440f, 0.11137570f, 
    0.06839889f, 0.04813254f, 0.06492426f, -0.05174224f, 0.04831322f, -0.27344853f, -0.06425515f, -0.17604984f, 
    -0.07966768f, 0.01032915f, -0.07267577f, -0.04675193f, 0.03292360f, -0.03283151f, 0.03425573f, 0.12829916f, 
    -0.09179901f, -0.38692513f, 0.24101166f, 0.05081750f, -0.12860072f, 0.00981879f, 0.10355905f, -0.17513084f, 
    0.16476886f, -0.00310237f, -0.04229331f, 0.04064460f, -0.41681921f, 0.21190885f, -0.25146866f, 0.22840662f, 
    -0.00745614f, -0.01494719f, -0.07639668f, 0.12036712f, -0.15315714f, 0.07809811f, -0.01367097f, 0.07194430f, 
    0.01741382f, -0.05031533f, -0.00459555f, -0.02649579f, 0.00766107f, -0.00573624f, -0.01618462f, -0.04149266f, 
    -0.00571849f, -0.01967114f, -0.04685187f, 0.04483204f, 0.04267352f, 0.02968481f, -0.00299870f, -0.04721527f, 
    0.03512813f, -0.02606780f, -0.05228537f, 0.00801123f, 0.04245325f, 0.04401280f, -0.04554088f, 0.03068324f, 
    -0.02522822f, 0.04518479f, -0.04146374f, 0.03615438f, 0.04308428f, -0.04413500f, -0.03418766f, -0.00694822f, 
    0.02335710f, 0.02387795f, 0.01574581f, -0.00204965f, -0.00863294f, -0.02191690f, -0.05130922f, -0.04469963f, 
    -0.04031096f, 0.00953243f, -0.00928789f, 0.02041415f, -0.01452703f, -0.03440543f, -0.03365782f, -0.03592796f, 
    -0.02611092f, 0.02014293f, 0.02355792f, -0.02783976f, -0.03881412f, -0.04782639f, 0.03545111f, 0.03748620f, 
    -0.01794942f, -0.03265878f, -0.05053050f, -0.01495553f, 0.02458525f, 0.04102409f, -0.02814466f, 0.03068014f, 
    0.02290149f, -0.04976143f, -0.02632264f, -0.02644102f, -0.04394254f, -0.05594946f, -0.02423609f, 0.03180256f, 
    0.01626864f, -0.02029484f, -0.03416119f, -0.02671919f, -0.05282327f, 0.03347606f, -0.03319732f, 0.00074028f, 
    -0.02278155f, -0.04006123f, -0.03106339f, 0.01029882f, 0.03446309f, -0.00106000f, -0.03004495f, 0.00135602f, 
    -0.02159544f, -0.00828505f, -0.01902122f, 0.01893429f, 0.01166141f, 0.04703113f, -0.01758982f, 0.00825786f, 
    -0.02669496f, 0.01244452f, -0.02728595f, -0.05386991f, -0.03364689f, -0.02587317f, -0.03311709f, 0.04287239f, 
    -0.02342512f, 0.02159263f, 0.02113429f, -0.04684974f, -0.04426936f, 0.00235273f, 0.01892581f, -0.01098041f, 
    0.02480529f, 0.03759130f, -0.01591369f, 0.01157995f, -0.03347095f, 0.03492435f, -0.02861411f, 0.00786091f, 
    -0.00815196f, 0.00129631f, 0.00893800f, -0.04121510f, 0.03791963f, -0.03550202f, -0.05439468f, -0.03735179f, 
    0.02674662f, 0.03986355f, -0.04602037f, -0.02653792f, -0.04114966f, 0.03708998f, 0.00754943f, 0.04135580f, 
    -0.01636646f, -0.01249465f, -0.04582470f, -0.00642137f, -0.04055793f, 0.01827136f, -0.05481954f, -0.03782063f, 
    0.00368729f, -0.04686265f, 0.04245543f, -0.03157616f, -0.04276612f, -0.01533648f, 0.01044700f, 0.02538937f, 
    0.04504963f, -0.01938635f, -0.02333928f, -0.03422876f, -0.01407282f, -0.01018778f, 0.01555029f, -0.01485227f, 
    -0.01217119f, -0.03274337f, 0.03906276f, -0.03074070f, -0.04625975f, -0.05076615f, 0.03851243f, 0.04226479f, 
    -0.04608965f, 0.02045075f, -0.01125498f, 0.01882418f, 0.03933254f, 0.01971098f, -0.04775539f, 0.01478037f, 
    0.02977462f, -0.03457514f, 0.04121244f, 0.00431309f, -0.01137454f, -0.01211639f, 0.01349107f, 0.00102407f, 
    0.01428298f, -0.00808999f, -0.05047724f, -0.02170954f, -0.03751414f, 0.04461780f, 0.04365717f, -0.04435058f, 
    -0.04255478f, -0.02406366f, -0.00566719f, -0.05081704f, 0.03272623f, -0.02722112f, -0.01729096f, 0.01327863f, 
    -0.00363995f, 0.04607730f, 0.03677516f, -0.05392977f, -0.04970176f, -0.03601430f, -0.05329781f, 0.01558268f, 
    -0.04498655f, -0.02518710f, 0.03957138f, -0.02436285f, 0.00633994f, 0.02446063f, 0.02138459f, -0.01228517f, 
    0.02058685f, -0.02420734f, -0.00080464f, 0.04434655f, -0.04204752f, -0.05045049f, -0.04598187f, -0.04501873f, 
    -0.00182121f, 0.02809407f, -0.04746846f, -0.02620385f, 0.03649373f, 0.01834410f, 0.00183257f, 0.01127178f, 
    -0.00508189f, 0.00759851f, -0.00254483f, -0.04822894f, 0.04529401f, 0.04232170f, -0.02857112f, 0.00965926f, 
    -0.00054588f, 0.01854062f, -0.02949169f, -0.04502633f, -0.00109463f, 0.02207656f, -0.02883000f, -0.01681006f, 
    0.02061853f, -0.02012084f, 0.01839701f, 0.01100864f, 0.00230574f, -0.04665856f, -0.01700684f, 0.04315840f, 
    0.03854533f, -0.00694392f, -0.03269142f, 0.01485783f, 0.03137186f, 0.01536373f, -0.00989340f, -0.02921863f, 
    0.02358999f, -0.04786000f, -0.02815491f, -0.04856990f, 0.03533430f, 0.03523882f, -0.04677795f, -0.01970333f, 
    -0.05445248f, 0.01248326f, 0.01338696f, -0.05332420f, 0.04112511f, 0.00681584f, -0.05525963f, -0.03015104f, 
    -0.02963468f, 0.01998723f, -0.05206500f, 0.03570417f, -0.02146179f, 0.00346835f, -0.00001933f, 0.00005631f, 
    -0.05214379f, -0.01579937f, -0.04000713f, -0.05377851f, 0.00245088f, -0.05004620f, -0.00762754f, 0.01656948f, 
    -0.02481783f, 0.04518984f, 0.03759161f, 0.02343315f, -0.04127787f, -0.02790370f, -0.01782902f, 0.02065128f, 
    0.00257378f, -0.01413351f, 0.00976768f, -0.01980305f, -0.02667321f, 0.01454990f, 0.00351270f, 0.02829704f, 
    -0.03283466f, -0.04777414f, 0.03038169f, -0.05244059f, -0.03123971f, -0.04206862f, 0.02606965f, 0.00091978f, 
    -0.01972276f, -0.03522844f, -0.04123417f, -0.05366872f, 0.03336935f, 0.01521470f, 0.01380083f, -0.04587924f, 
    0.03860635f, -0.01848134f, -0.02266501f, -0.04012452f, -0.01726201f, 0.00752799f, -0.00535240f, 0.03824095f, 
    -0.03018888f, 0.00044569f, -0.03570614f, -0.04194834f, -0.01340777f, -0.04627462f, -0.02976612f, 0.00176077f, 
    0.03734306f, 0.00039502f, -0.00822886f, 0.02796695f, 0.03521609f, -0.00465650f, 0.01013193f, 0.00580741f, 
    -0.00836427f, -0.01959376f, 0.00269829f, 0.02614343f, -0.00564521f, -0.02750913f, 0.03544580f, 0.02785343f, 
    -0.01757080f, 0.04256931f, 0.03249090f, 0.03731137f, -0.00946098f, 0.02457276f, 0.00612584f, -0.02261438f, 
    -0.03305078f, 0.02801091f, -0.00618177f, -0.03512484f, -0.02889833f, -0.03148117f, -0.05052986f, 0.01550847f, 
    -0.03844297f, -0.02455655f, 0.03157810f, -0.01707688f, 0.01306966f, -0.05237217f, -0.04115633f, 0.00938974f, 
    -0.23470721f, 0.15644264f, 0.06517375f, -0.13906240f, -0.01171230f, 0.01447626f, 0.15855157f, 0.00431390f, 
    0.04317514f, 0.06784499f, -0.05424844f, 0.11189207f, -0.33699912f, 0.22493076f, -0.08845439f, -0.15750732f, 
    0.01448837f, -0.05040605f, 0.06786592f, -0.01422702f, -0.09654240f, -0.06071673f, -0.08096964f, -0.12086414f, 
    -0.04997461f, -0.03684546f, 0.06020359f, 0.07572327f, 0.07121775f, 0.01958959f, 0.04346123f, -0.01995981f, 
    0.01689991f, 0.18418233f, -0.10551968f, -0.02816758f, 0.23170398f, 0.10545678f, -0.09477436f, -0.28501362f, 
    0.01899856f, 0.04178123f, 0.03159212f, 0.03991148f, -0.09558772f, -0.03315621f, 0.07058141f, -0.04057541f, 
    -0.10803150f, 0.11384853f, -0.22818287f, -0.25046769f, -0.07265992f, -0.12803973f, -0.12388949f, 0.05909818f, 
    -0.03908084f, 0.14336607f, -0.03402319f, 0.17689252f, 0.20195970f, -0.05000653f, -0.21719240f, -0.10414027f, 
    -0.06281511f, -0.04646416f, -0.01223382f, 0.02531116f, -0.03300327f, 0.02833613f, -0.04777950f, 0.00404157f, 
    0.07854056f, 0.26914105f, -0.21313216f, 0.07865253f, -0.16470160f, -0.08986681f, 0.06742817f, -0.03798776f, 
    0.06840675f, 0.03629033f, 0.02842758f, -0.11266177f, 0.06422651f, -0.03895803f, 0.12208624f, 0.21362658f, 
    0.02348450f, 0.04933232f, -0.08399452f, -0.02700773f, 0.00829102f, 0.01778401f, -0.05483403f, 0.03542984f, 
    0.12563974f, 0.10851896f, 0.07750157f, 0.08680413f, 0.09524726f, 0.15569386f, -0.06153449f, -0.10181793f, 
    0.10191231f, 0.14814642f, -0.04984542f, 0.19886284f, 0.02272646f, -0.09653527f, 0.02520829f, 0.11945705f, 
    -0.00302931f, -0.00727658f, -0.06262569f, 0.01860194f, -0.04804618f, 0.06731485f, -0.16355400f, -0.07783023f, 
    0.16746804f, 0.04052439f, 0.09790429f, 0.11228713f, -0.01642993f, 0.08134055f, -0.03980842f, 0.11395948f, 
    -0.04809674f, -0.02103838f, 0.15757273f, -0.11415734f, 0.28843659f, 0.27495265f, 0.16189587f, -0.12719807f, 
    -0.00899360f, 0.15670811f, 0.09788722f, -0.14553826f, 0.02157163f, -0.12105679f, 0.16272692f, -0.13278005f, 
    -0.03005591f, 0.09210822f, 0.05680101f, 0.23028383f, -0.02863740f, 0.03657952f, -0.22184458f, -0.01220320f, 
    -0.04399944f, 0.06015381f, 0.17360726f, 0.15205635f, 0.07339858f, 0.02152671f, -0.06053009f, 0.02416676f, 
    0.05243035f, -0.00296987f, -0.13830854f, 0.12714483f, -0.02745084f, 0.06860851f, -0.16425128f, -0.09592856f, 
    0.31762463f, 0.06392001f, 0.03504167f, -0.04290481f, 0.09525211f, 0.04797560f, -0.07630148f, -0.06347471f, 
    -0.04803272f, 0.10024255f, -0.14550158f, 0.10288508f, 0.33938992f, 0.03241259f, 0.08569969f, 0.23690473f, 
    0.04451561f, 0.09990234f, -0.16173805f, 0.05966353f, 0.02994337f, -0.11030906f, 0.18419790f, 0.10902125f, 
    0.05015535f, 0.02774376f, -0.00211861f, 0.34488606f, 0.05041825f, -0.01747483f, 0.20109692f, 0.07775245f, 
    -0.01865422f, 0.17051636f, 0.08927065f, 0.04176812f, 0.03125348f, 0.00972819f, -0.20993060f, -0.07285132f, 
    -0.04239072f, 0.07242697f, 0.04350087f, -0.07770762f, 0.06881344f, -0.02153671f, 0.00737481f, -0.22861759f, 
    0.29067180f, -0.06490082f, 0.13005447f, 0.10518157f, -0.02591857f, -0.09377073f, 0.06071473f, -0.05531954f, 
    -0.09537667f, 0.26751822f, -0.12250139f, -0.05739517f, 0.07892521f, -0.00698007f, 0.22254391f, 0.04527976f, 
    -0.03725312f, 0.04299407f, -0.03983506f, -0.03210130f, -0.07653458f, -0.00654058f, 0.01229003f, -0.02060008f, 
    0.18257125f, -0.04861848f, -0.09127509f, 0.09754235f, -0.07867631f, 0.04863315f, -0.01101176f, 0.03059104f, 
    -0.07588851f, -0.08483499f, 0.01408698f, -0.13010733f, -0.10214735f, -0.07853472f, -0.15475416f, 0.08148048f, 
    -0.04434143f, 0.07933956f, 0.10126597f, 0.10409572f, -0.00188453f, 0.14230844f, 0.12729588f, -0.02852091f, 
    0.20965387f, 0.23257408f, 0.13991597f, 0.15785836f, 0.02254651f, 0.13935472f, 0.03032161f, -0.12108512f, 
    0.06660436f, 0.19625778f, 0.05579685f, -0.00024884f, 0.16843250f, -0.09967124f, 0.08720418f, 0.11225309f, 
    0.00176663f, 0.16331905f, -0.02882766f, 0.10655233f, -0.13144210f, -0.05869986f, -0.05129528f, 0.01950959f, 
    0.14459944f, -0.03208453f, -0.07917556f, -0.09409179f, 0.11986617f, 0.10311040f, 0.03225655f, -0.02517461f, 
    -0.06662848f, 0.11752202f, -0.15358442f, 0.01363418f, 0.03053145f, 0.13983421f, 0.11161812f, 0.23396806f, 
    -0.06852774f, 0.19984680f, 0.01009625f, 0.14062002f, 0.09327605f, 0.18303046f, 0.21089040f, 0.24641600f, 
    -0.03089819f, 0.17128563f, -0.18221685f, -0.33536166f, 0.04421781f, -0.00063563f, 0.05910617f, -0.05539137f, 
    -0.06537378f, 0.02050477f, -0.05376277f, -0.11997596f, -0.27248371f, -0.16302621f, -0.07527119f, 0.20227650f, 
    0.11696748f, 0.15488049f, 0.10843336f, 0.10236391f, 0.00998229f, -0.10444798f, 0.22291590f, 0.03851785f, 
    -0.42447215f, -0.03166316f, -0.11124084f, -0.05151767f, 0.12379596f, 0.04616726f, -0.03799462f, 0.18617809f, 
    0.05618388f, -0.01283990f, 0.16291493f, 0.09031942f, -0.43522641f, 0.00529678f, 0.05408154f, -0.04468395f, 
    -0.08359266f, 0.02520132f, 0.21787061f, 0.07189883f, 0.15114212f, 0.04275747f, 0.07364011f, 0.02550690f, 
    -0.20108229f, 0.04625969f, 0.01181895f, 0.25164562f, -0.00570094f, 0.06914864f, 0.01121466f, 0.21169417f, 
    0.26420122f, 0.05383603f, -0.03842714f, -0.07651836f, -0.04502006f, 0.08136013f, 0.08228740f, 0.05952527f, 
    0.09997074f, 0.02212943f, 0.15623842f, 0.03954210f, -0.06052238f, 0.02308603f, 0.02005853f, 0.12015992f, 
    0.02811040f, 0.03497381f, -0.04383198f, 0.03126048f, -0.02672671f, 0.01429673f, -0.00105395f, -0.04664779f, 
    0.00727127f, -0.01994712f, 0.02065337f, -0.03224320f, -0.02213630f, -0.03812997f, -0.00838249f, -0.02365304f, 
    0.05145812f, 0.03327617f, -0.01406116f, -0.04906454f, -0.00900182f, 0.00567571f, -0.01545505f, 0.03359666f, 
    0.03159610f, -0.04755291f, 0.01110562f, 0.02725833f, 0.01850523f, 0.02363398f, -0.01078598f, -0.03875122f, 
    0.01322169f, -0.00067603f, -0.03301256f, 0.00570687f, -0.00633257f, 0.03368245f, -0.00643268f, -0.06009322f, 
    0.01373045f, 0.01032496f, -0.00288589f, -0.05304794f, -0.05542300f, -0.05807889f, -0.04024333f, 0.02925545f, 
    -0.03929695f, -0.04035965f, -0.03892310f, 0.02602830f, 0.03901633f, 0.04206077f, 0.01849874f, -0.00538632f, 
    -0.04090863f, -0.00876239f, -0.04000844f, -0.05798645f, -0.04888286f, 0.03092324f, -0.05851658f, -0.02178320f, 
    -0.01912917f, 0.02276229f, -0.04251081f, -0.01081708f, -0.02708679f, 0.02674022f, 0.01663106f, 0.03593833f, 
    0.03281746f, 0.03337102f, 0.03995319f, 0.02230096f, -0.03740146f, -0.03003325f, -0.03647213f, -0.00834036f, 
    0.01655999f, 0.00111559f, 0.03646623f, 0.02157290f, -0.02781926f, -0.03795584f, 0.03135677f, 0.01296232f, 
    -0.02039635f, -0.02436462f, -0.04643397f, -0.02318788f, 0.02367461f, -0.02874608f, -0.04743471f, -0.05985895f, 
    0.04096457f, 0.01337752f, -0.04277489f, -0.00787719f, -0.04963793f, -0.04247388f, -0.03357482f, -0.00940633f, 
    0.01521848f, 0.03425811f, 0.03509828f, 0.00931240f, -0.04102563f, 0.03856618f, 0.01422486f, -0.02537386f, 
    -0.00717796f, 0.02424929f, -0.02704513f, -0.01220074f, 0.02197506f, -0.03625674f, 0.02290854f, 0.03106258f, 
    -0.01141069f, 0.01792862f, -0.04185181f, 0.02983347f, -0.01827364f, -0.01058892f, -0.04284111f, -0.03782700f, 
    -0.05286270f, 0.02276988f, -0.00161228f, 0.03893480f, 0.04508631f, 0.00712502f, -0.06276132f, 0.00557225f, 
    -0.00878775f, -0.02703907f, -0.00745954f, -0.04879933f, 0.00912395f, 0.03505072f, 0.01804158f, 0.03117212f, 
    -0.03132819f, 0.02430843f, -0.01060660f, 0.03016762f, 0.01945971f, 0.03075484f, -0.02028895f, -0.02117876f, 
    -0.02848003f, 0.04262443f, 0.03617087f, -0.02416542f, -0.04029156f, 0.01199372f, 0.02833734f, 0.03707212f, 
    -0.04428401f, -0.05387014f, 0.05377708f, -0.02434497f, 0.00730952f, -0.02481234f, -0.04905809f, -0.02205035f, 
    -0.01230071f, -0.03443684f, -0.05238575f, -0.02206803f, -0.03085143f, -0.00464132f, 0.00443302f, 0.00530508f, 
    0.01976832f, 0.03517874f, 0.03478124f, -0.02575724f, 0.00883025f, 0.02797453f, 0.03490177f, 0.03174778f, 
    -0.00814953f, 0.03441944f, -0.04213089f, -0.03392991f, -0.04078225f, -0.04601603f, -0.04204010f, 0.02312273f, 
    -0.01115343f, -0.03409657f, 0.00021360f, -0.00218700f, -0.01719615f, -0.04148441f, 0.03025058f, -0.01844160f, 
    0.01102365f, -0.00016599f, 0.02206899f, 0.00346132f, -0.03871463f, -0.02554464f, -0.02995711f, 0.03335712f, 
    -0.02349389f, 0.02485755f, 0.02790295f, 0.04195547f, -0.02928331f, 0.04263954f, -0.04576268f, 0.03841279f, 
    0.02777091f, 0.04564099f, -0.00502143f, -0.05214200f, -0.01412364f, 0.02633462f, -0.05880598f, -0.03336905f, 
    0.02640533f, -0.06146805f, 0.03248839f, -0.01403249f, -0.05305231f, -0.06063338f, -0.00845756f, 0.02308793f, 
    0.03061302f, 0.01686903f, -0.03380068f, -0.04980318f, -0.03346311f, -0.01715595f, -0.02031506f, -0.03893007f, 
    0.03731453f, -0.02400392f, -0.01961017f, 0.01316014f, -0.02277207f, 0.00056759f, -0.04265840f, 0.00438278f, 
    0.01372739f, 0.03519750f, -0.01859010f, -0.05420134f, -0.01726254f, 0.03516889f, -0.05670807f, -0.01341149f, 
    0.04781495f, -0.01328892f, -0.01163225f, -0.03732050f, -0.00020225f, 0.00609486f, 0.01443550f, 0.01675237f, 
    0.02620865f, 0.01002371f, 0.04456433f, 0.03094679f, 0.01135812f, -0.01961177f, -0.04003192f, -0.03378682f, 
    -0.05061182f, 0.00941370f, -0.04208471f, 0.02887196f, 0.00866566f, -0.01799620f, -0.01241773f, 0.05085966f, 
    -0.00960322f, 0.03517253f, 0.02758454f, -0.00827130f, -0.03081396f, 0.00079499f, -0.05814333f, -0.05738326f, 
    -0.00584849f, 0.04216175f, 0.01332270f, 0.03989178f, 0.00188494f, 0.04243918f, 0.03537209f, 0.02991303f, 
    -0.05558807f, -0.00919641f, 0.03392866f, 0.02164192f, 0.01544655f, 0.00442201f, 0.00026363f, 0.03292521f, 
    -0.04474095f, -0.05270058f, 0.03271849f, -0.04453596f, -0.01065864f, -0.03851146f, 0.03327705f, -0.03925489f, 
    -0.03775350f, -0.05562331f, -0.02639783f, 0.04710766f, -0.01184683f, -0.01498271f, 0.02669189f, 0.04564788f, 
    -0.05162098f, 0.01564214f, -0.01428513f, -0.02864829f, 0.03964859f, 0.01578338f, 0.04073408f, -0.05195932f, 
    -0.01950199f, 0.02099131f, -0.05619698f, 0.03116297f, 0.02983095f, -0.04730633f, -0.03274142f, 0.02559025f, 
    -0.01949667f, 0.01627207f, 0.03597719f, 0.01459440f, -0.03232039f, -0.04325442f, -0.01049503f, 0.03477870f, 
    0.01746000f, -0.00716422f, -0.02566925f, -0.04747352f, -0.02190360f, 0.03485143f, -0.01274047f, 0.02112977f, 
    -0.00879910f, -0.01344054f, 0.01280310f, 0.01665553f, -0.05325092f, -0.05127232f, 0.00079653f, -0.02925140f, 
    -0.03369274f, -0.03563683f, -0.01641584f, 0.01571423f, -0.04483827f, 0.02228756f, 0.03900781f, -0.00419080f, 
    0.03738294f, -0.03362960f, -0.03378315f, -0.02547271f, 0.00703597f, 0.03422127f, -0.04617198f, -0.03605996f, 
    0.01778451f, 0.01974750f, 0.03864456f, 0.02894354f, -0.01298783f, -0.03465902f, 0.00048146f, -0.04925362f, 
    0.11456788f, 0.04818162f, -0.11194005f, 0.00726201f, -0.03999939f, 0.01913252f, 0.06499047f, -0.06698439f, 
    0.01601585f, 0.05204817f, 0.02165654f, -0.00092313f, 0.35129991f, -0.23664565f, 0.04066126f, 0.25605127f, 
    -0.12916049f, 0.18880743f, -0.22859983f, 0.02098626f, -0.03442753f, 0.09606110f, 0.08130729f, -0.14344499f, 
    0.29514679f, -0.23044811f, -0.21905901f, -0.11489476f, -0.02638073f, -0.06334866f, -0.01082979f, 0.01929791f, 
    -0.09609389f, -0.05913665f, 0.08206840f, 0.16319972f, 0.46645069f, -0.23758593f, 0.13487580f, 0.37677768f, 
    -0.23016009f, 0.07178473f, -0.09549253f, 0.11847067f, -0.05850615f, -0.05026794f, -0.03468704f, 0.13651727f, 
    0.13932601f, -0.17107306f, -0.04157703f, 0.27900234f, -0.14799002f, -0.04267271f, 0.00554534f, 0.05701268f, 
    0.01972588f, -0.04920335f, -0.05711521f, 0.02320477f, 0.19056576f, 0.04687134f, -0.08400014f, -0.05308256f, 
    0.09096913f, 0.00931620f, 0.21333796f, -0.03090805f, 0.07240985f, 0.04292054f, -0.03233775f, -0.07849941f, 
    -0.11516905f, 0.19845010f, 0.23688456f, 0.02232108f, 0.01737029f, 0.00541912f, 0.09894443f, -0.01326176f, 
    0.05791463f, 0.08858947f, -0.02560003f, -0.01734566f, -0.01328305f, 0.02926710f, -0.18291037f, -0.22996441f, 
    -0.04791458f, 0.04413567f, 0.00029000f, 0.16499175f, 0.04742722f, 0.07753328f, 0.03339719f, 0.05878213f, 
    0.09842924f, 0.20445329f, 0.10740199f, -0.02252624f, -0.02457004f, -0.00257066f, -0.03245492f, 0.14304523f, 
    -0.01953173f, 0.02828942f, 0.02101184f, 0.10165600f, -0.25866869f, 0.05423489f, 0.17378448f, -0.30692753f, 
    -0.15277161f, -0.12081667f, 0.07883956f, -0.00968613f, -0.03631470f, 0.02747998f, 0.08735178f, 0.00179695f, 
    0.20427828f, -0.01004067f, 0.11608737f, 0.06777833f, 0.03264594f, 0.05009284f, -0.05535301f, 0.08608652f, 
    0.00986859f, 0.01740945f, -0.02083635f, -0.00578795f, 0.21960162f, 0.01086425f, -0.13747945f, 0.14061181f, 
    0.09186960f, 0.04749058f, -0.08008450f, 0.04422165f, -0.03488969f, 0.07363665f, -0.00182585f, 0.13500759f, 
    -0.11560698f, 0.06967098f, -0.01687489f, -0.10879054f, -0.11095728f, -0.07837398f, 0.10869934f, 0.10427605f, 
    0.06156733f, 0.08304709f, -0.12118594f, -0.00413578f, 0.03252931f, -0.08551860f, 0.02872471f, 0.28102434f, 
    0.01401732f, -0.02302060f, 0.00056597f, 0.00575191f, -0.07857423f, -0.02030835f, 0.04496788f, -0.03040338f, 
    0.14411511f, -0.17357935f, -0.34390265f, 0.14048691f, -0.06544777f, -0.07256671f, -0.02917780f, 0.03972945f, 
    -0.07548869f, 0.04683349f, 0.05639708f, 0.08534367f, 0.04967687f, 0.00950578f, -0.00049218f, 0.13760723f, 
    0.08560904f, -0.06522339f, 0.04157514f, 0.16362907f, -0.04072157f, 0.02576818f, 0.10377117f, 0.03292378f, 
    0.08024018f, 0.28930944f, 0.16921663f, -0.18068202f, -0.05445738f, 0.09105436f, -0.02736453f, 0.09475425f, 
    -0.03972942f, -0.00965970f, 0.04007360f, 0.04848763f, 0.11805759f, 0.04027336f, -0.05808449f, 0.07413000f, 
    -0.05843547f, -0.09199473f, -0.06073246f, 0.08539210f, -0.01159721f, -0.02347472f, 0.03868448f, 0.21655910f, 
    -0.02231869f, 0.29521966f, -0.10307930f, -0.09985548f, 0.08621137f, -0.02392057f, -0.01110950f, 0.04480930f, 
    0.09070886f, 0.09554514f, 0.00849538f, -0.04509300f, -0.12294275f, 0.32993105f, 0.14867736f, 0.14286552f, 
    -0.06176523f, 0.03867266f, -0.01203888f, 0.07772699f, -0.04083685f, -0.07066059f, -0.01664869f, -0.02275921f, 
    0.16677271f, -0.04218702f, -0.15519488f, -0.17591231f, 0.02901054f, 0.08711533f, 0.04302942f, 0.00240552f, 
    0.01170415f, 0.14285345f, 0.03989979f, 0.05095159f, -0.21433739f, -0.04636509f, -0.02054907f, 0.02286026f, 
    -0.06375671f, -0.07079004f, 0.03482827f, 0.00291529f, -0.08277489f, 0.02350825f, 0.01560629f, 0.05210149f, 
    0.27879286f, 0.12399062f, 0.17669123f, -0.09633587f, 0.01959490f, -0.00844653f, -0.00501223f, -0.02141487f, 
    -0.07690880f, -0.20025714f, 0.00063938f, -0.00129444f, -0.03736241f, 0.46589038f, 0.17310603f, -0.19186559f, 
    -0.03577950f, -0.02951229f, 0.01370854f, -0.02025209f, 0.08138780f, 0.03013881f, 0.02664701f, 0.02363260f, 
    -0.10061527f, 0.10388073f, -0.05863416f, -0.27390742f, 0.07564152f, 0.03821031f, 0.06847100f, -0.07864325f, 
    -0.01277944f, 0.10986872f, 0.04571070f, 0.03346726f, 0.21544556f, 0.16541474f, -0.22703592f, -0.07736973f, 
    0.01512372f, 0.04911307f, -0.08097900f, -0.04757330f, 0.01214824f, 0.07067307f, -0.10942256f, 0.02590265f, 
    0.14141494f, -0.29898235f, 0.11982578f, 0.27712822f, -0.15968689f, -0.10438967f, 0.01133921f, -0.07648959f, 
    0.05996899f, -0.05722032f, -0.02384095f, 0.01592641f, -0.05912818f, 0.19100067f, 0.23714504f, -0.42695391f, 
    -0.07042705f, 0.05697557f, 0.08245157f, -0.08304348f, 0.04706130f, 0.03587931f, -0.05932515f, 0.01141573f, 
    0.41551441f, -0.00244809f, -0.04552444f, -0.12851779f, -0.06354763f, 0.11125524f, 0.06125092f, -0.10340146f, 
    -0.08650710f, 0.09604628f, 0.03678269f, -0.05133064f, 0.21077177f, -0.10288230f, -0.04571367f, 0.06035039f, 
    -0.14479078f, -0.04471837f, -0.02489851f, 0.06151494f, -0.06435978f, -0.09183213f, -0.01344161f, 0.01023743f, 
    0.24995908f, -0.42228463f, 0.02694470f, -0.13008472f, -0.05792661f, -0.00288686f, -0.04084797f, 0.17143048f, 
    -0.03125658f, 0.09043851f, 0.09381533f, 0.11096823f, -0.17262536f, 0.02184338f, 0.29821643f, 0.13546970f, 
    -0.00858720f, 0.08136965f, 0.08841787f, 0.05793393f, -0.01109715f, 0.00624021f, -0.11384246f, -0.05571255f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02388119f, -0.02524097f, 0.01217178f, -0.01199397f, -0.03224427f, 0.03231001f, -0.02173236f, -0.00682314f, 
    0.04529790f, -0.02747670f, -0.00968601f, -0.04963982f, 0.03794462f, 0.02081659f, -0.05679960f, -0.00710460f, 
    0.01079418f, 0.02481671f, 0.05943907f, 0.06475271f, -0.05607555f, -0.02910527f, 0.02859478f, 0.00089492f, 
    0.09144627f, 0.02799203f, 0.05648814f, 0.15477501f, 0.01256592f, 0.07505644f, -0.01212788f, -0.06760260f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.11846355f, 0.01026143f, -0.11124840f, 0.13136069f, 0.10348789f, 0.06903875f, -0.26105466f, 0.07729182f, 
    0.22487825f, 0.06938426f, -0.13817132f, -0.02450909f, 0.29767695f, -0.42510104f, -0.14605606f, -0.13530613f, 
    0.05332171f, 0.11052288f, 0.15785830f, 0.26369217f, 0.15123214f, 0.00106703f, 0.08520987f, 0.36892292f, 
    -0.09677635f, -0.14908239f, -0.22229932f, 0.16534144f, -0.09120462f, 0.10246418f, 0.04224113f, 0.25780693f, 
    0.38603973f, 0.11295305f, -0.14023444f, 0.09793110f, 0.16272989f, -0.02460312f, 0.08987156f, -0.01035285f, 
    -0.33152497f, 0.16167827f, -0.03380606f, -0.16386475f, -0.02087473f, -0.09341539f, -0.08666755f, 0.11776868f, 
    0.19908746f, -0.01818889f, -0.11426340f, 0.26706982f, -0.15505540f, -0.06295277f, 0.04883101f, 0.30850205f, 
    0.14574341f, 0.11149678f, 0.22079732f, -0.05930355f, 0.09270646f, -0.32367861f, 0.05671123f, 0.56805557f, 
    -0.09275951f, -0.08104120f, -0.16295131f, 0.15262571f, 0.15442988f, 0.16261426f, 0.06059287f, 0.15947786f, 
    -0.17092852f, -0.07837514f, -0.12815753f, -0.09732784f, -0.00073818f, -0.00629825f, -0.05083445f, -0.16529189f, 
    -0.00458189f, 0.17026816f, -0.14118558f, -0.17132773f, 0.12515618f, 0.04133962f, -0.03948405f, 0.11589205f, 
    -0.09705172f, 0.06892768f, 0.04850619f, -0.13427374f, 0.16568200f, -0.07427078f, 0.00453913f, 0.12094482f, 
    0.07052583f, 0.03172647f, -0.03560220f, 0.07701030f, 0.09542171f, 0.02846625f, 0.10961848f, 0.15344623f, 
    -0.32134005f, -0.10583956f, 0.04797311f, 0.03605754f, 0.15688808f, 0.59700692f, 0.11601320f, 0.07671820f, 
    0.01457705f, -0.10740119f, -0.15756893f, -0.17631166f, -0.02352316f, -0.09535054f, 0.06939095f, 0.14702612f, 
    0.00649034f, 0.09430549f, 0.24165325f, 0.22475253f, -0.01470398f, 0.23058467f, -0.04187585f, -0.53078628f, 
    0.21771900f, -0.32710671f, -0.10882555f, 0.11781705f, 0.05446342f, -0.13119052f, -0.42720908f, 0.06198939f, 
    -0.11888094f, -0.01879057f, 0.03120998f, 0.06576155f, -0.28599116f, 0.13774477f, -0.12598692f, 0.00764357f, 
    0.34543473f, 0.02069010f, 0.10445534f, -0.35584199f, 0.00080608f, 0.04387442f, -0.02918682f, -0.08167730f, 
    0.47693211f, 0.14893124f, -0.05980881f, 0.28189039f, 0.10373574f, -0.27077767f, 0.17775349f, -0.10862640f, 
    -0.02076445f, -0.45315850f, -0.15711890f, -0.06603238f, -0.06210342f, 0.15815149f, -0.23628226f, 0.01374040f, 
    0.28586316f, 0.08099367f, -0.19045261f, 0.10971992f, 0.38590768f, -0.18165758f, -0.06585198f, 0.09681367f, 
    -0.19890597f, 0.13041012f, 0.05890049f, 0.27990153f, -0.01602216f, 0.14281298f, 0.03332930f, 0.39166903f, 
    0.28416869f, -0.12988526f, -0.11231966f, 0.23052236f, -0.08743810f, -0.15565802f, -0.10994361f, 0.54592234f, 
    0.11019599f, 0.35983896f, -0.01202319f, 0.01081256f, -0.09029865f, -0.05601898f, 0.35538009f, 0.14429562f, 
    -0.23042361f, 0.14074905f, 0.10992949f, -0.14325696f, 0.42265183f, -0.27396187f, -0.11058700f, 0.03502403f, 
    0.18603665f, 0.01518026f, -0.09404419f, -0.02488757f, 0.15222803f, -0.16538522f, -0.17160937f, 0.11831746f, 
    -0.21458022f, 0.07238860f, -0.03420711f, 0.18811582f, -0.08881386f, -0.06887943f, -0.07344866f, 0.03703896f, 
    -0.05278879f, 0.23873028f, 0.11227737f, 0.05509053f, -0.06667427f, -0.05818726f, 0.15791067f, 0.00617034f, 
    -0.52304620f, -0.11719926f, 0.06095008f, -0.00175729f, -0.12730479f, 0.02761292f, -0.16305372f, 0.06199578f, 
    -0.06677585f, 0.09629644f, 0.07058116f, -0.25620407f, -0.03016547f, 0.00026279f, -0.10755627f, -0.42560527f, 
    0.16986647f, -0.05890273f, 0.10681354f, 0.23868792f, -0.09185784f, -0.04095528f, -0.06640855f, 0.26019931f, 
    -0.10534061f, 0.00170130f, -0.16840267f, -0.10127313f, 0.01648121f, 0.02966526f, 0.12036978f, -0.10710409f, 
    -0.17205611f, 0.00244968f, -0.08771269f, 0.10611371f, -0.05192193f, -0.18877904f, -0.12894908f, -0.14835592f, 
    -0.04551451f, -0.04181095f, -0.17433509f, 0.13504894f, -0.13422480f, -0.12573870f, 0.01424177f, 0.11042807f, 
    0.10842042f, -0.09502233f, -0.01699960f, -0.06300599f, 0.09714775f, -0.11780548f, -0.14703999f, 0.13369069f, 
    0.17915617f, -0.21907775f, -0.11539950f, 0.02646302f, 0.01523448f, -0.02459833f, 0.02082939f, -0.15783364f, 
    -0.27207094f, 0.16388720f, -0.01431572f, -0.16732016f, 0.11530654f, 0.11719647f, 0.06851031f, -0.17749506f, 
    -0.43725312f, -0.11238308f, 0.02521652f, 0.28127426f, 0.06298945f, 0.10921554f, 0.15029250f, -0.07342131f, 
    0.30000731f, 0.12408361f, 0.16388781f, 0.18327898f, 0.07977254f, -0.18296176f, 0.05323256f, -0.07991638f, 
    -0.15166397f, -0.02769046f, -0.07861513f, 0.16724792f, 0.06404789f, -0.13105772f, 0.10488886f, 0.06980117f, 
    -0.12092103f, -0.16447759f, -0.22616342f, 0.13472699f, -0.16901633f, -0.08997791f, -0.11872271f, -0.12550786f, 
    -0.03754139f, 0.00355319f, 0.06666160f, -0.00056247f, 0.00638318f, 0.09177324f, 0.12666196f, 0.07004449f, 
    -0.05617057f, -0.00242389f, -0.05207623f, -0.08137783f, 0.15003376f, 0.08794033f, -0.02394128f, -0.00663852f, 
    0.07337116f, 0.10041582f, -0.03584016f, 0.12729181f, 0.06117103f, -0.10697051f, 0.05600052f, 0.04731972f, 
    0.39174694f, 0.03261937f, -0.09249547f, 0.14345141f, -0.46042603f, 0.02074803f, 0.06240313f, 0.10032705f, 
    -0.28892124f, 0.06741515f, 0.06091844f, 0.22308940f, 0.05477617f, -0.11428537f, -0.09313399f, 0.40576848f, 
    0.14093609f, -0.15406315f, 0.22834237f, -0.06282666f, -0.05816543f, -0.27083421f, -0.06446604f, 0.17368159f, 
    0.26191545f, -0.21054155f, 0.11461099f, -0.10912692f, 0.03019195f, 0.08540384f, 0.02829956f, 0.11093247f, 
    0.10759224f, 0.05831334f, 0.18599567f, -0.07636133f, -0.38551697f, 0.63239980f, -0.17145024f, -0.11158186f, 
    0.04149223f, -0.14720048f, -0.16401964f, 0.18134786f, -0.13910848f, 0.09595069f, -0.08692204f, 0.20148927f, 
    0.08270497f, 0.14438854f, 0.12386964f, 0.04396148f, -0.09349905f, 0.40308771f, -0.02128559f, -0.45696953f, 
    -0.46674365f, 0.32829598f, 0.03838593f, 0.05893774f, 0.00191397f, 0.10732533f, 0.27577153f, -0.04216206f, 
    -0.27697811f, -0.07212701f, -0.22102056f, -0.10115869f, -0.13204138f, 0.01043028f, -0.00633458f, 0.04697668f, 
    0.28110680f, 0.01829683f, 0.29134965f, -0.13290995f, -0.04213675f, -0.06115251f, -0.10284303f, -0.53119397f, 
    0.00340368f, -0.09572414f, 0.14012702f, 0.15759794f, 0.15728946f, 0.24678788f, -0.02395506f, 0.14333102f, 
    -0.00820868f, -0.06695228f, -0.06793270f, -0.09419797f, -0.12249116f, 0.02816383f, 0.09111324f, 0.13563694f, 
    -0.40373772f, 0.09767710f, -0.31666014f, -0.03108856f, 0.13947839f, 0.25573871f, -0.11004434f, 0.03003210f, 
    -0.13644914f, -0.04535450f, 0.22946118f, 0.28367412f, -0.13889252f, 0.03554329f, 0.08089107f, -0.22214468f, 
    0.14180969f, 0.11886562f, -0.02497690f, -0.05699872f, -0.14620057f, 0.17254075f, -0.01973287f, 0.44011492f, 
    -0.01809752f, -0.01308381f, -0.17274486f, -0.03916354f, 0.07843097f, -0.00857724f, -0.05467181f, 0.00540015f, 
    0.02865100f, -0.15210986f, -0.06027900f, 0.04331330f, -0.06046618f, -0.04126185f, -0.10530832f, 0.04613836f, 
    -0.09391233f, 0.04971519f, -0.17631988f, 0.02177057f, 0.17577139f, 0.08399374f, 0.11660329f, -0.14864203f, 
    -0.16558748f, -0.02615177f, 0.02249962f, 0.16219620f, 0.06387858f, -0.12612820f, -0.12509510f, 0.13650271f, 
    0.52678138f, -0.39769167f, -0.04430805f, -0.11298408f, -0.07002136f, 0.10973933f, -0.08165228f, -0.03592842f, 
    -0.19052099f, -0.02422934f, 0.39142042f, -0.12719905f, 0.28744581f, -0.21766752f, 0.12509552f, 0.01601458f, 
    -0.10025588f, -0.03975084f, -0.10696995f, 0.04109576f, -0.12274007f, -0.12725796f, -0.08922487f, -0.05043083f, 
    0.21661772f, -0.04733674f, -0.05685905f, -0.14840360f, 0.08267646f, 0.05732159f, -0.12322009f, 0.31012151f, 
    0.21175343f, 0.21317773f, -0.14803429f, 0.10144712f, 0.14593160f, -0.11071677f, 0.02087770f, 0.02685672f, 
    0.14395885f, 0.13615406f, 0.17605728f, -0.11200211f, 0.45562637f, -0.00271132f, -0.09490055f, -0.10237416f, 
    -0.31901449f, -0.16975974f, -0.12803298f, 0.26431462f, -0.10289934f, -0.12214994f, -0.16916382f, -0.11140374f, 
    -0.08413385f, 0.12694557f, -0.37913355f, 0.10422364f, -0.02426137f, 0.08939143f, -0.09878105f, 0.35745779f, 
    -0.26706228f, -0.37430701f, 0.02077627f, -0.02934320f, 0.07583539f, -0.10611817f, 0.11002049f, -0.14938687f, 
    0.13637750f, -0.04180890f, -0.38237301f, 0.14039437f, -0.05511892f, 0.40186080f, 0.05552796f, 0.13088897f, 
    -0.14848076f, -0.03578200f, -0.05857772f, 0.35027510f, -0.07590715f, -0.07812163f, -0.16537112f, 0.04871811f, 
    0.19026680f, 0.18081994f, 0.28250158f, 0.13452625f, -0.08318350f, 0.23091590f, -0.13605505f, 0.06643019f, 
    0.23064019f, -0.07845483f, 0.06516731f, 0.03364700f, -0.01492387f, -0.09984389f, -0.05358790f, 0.02045931f, 
    0.32523045f, 0.12081394f, 0.14941783f, 0.08012322f, 0.05777154f, 0.39050600f, -0.02641537f, 0.02606070f, 
    0.32496616f, 0.03907402f, 0.02837988f, 0.08139917f, 0.12797000f, 0.01800708f, -0.05339547f, -0.36915356f, 
    -0.11342813f, 0.02836911f, -0.23946111f, 0.07228135f, 0.05292675f, 0.48662034f, 0.08137229f, -0.27959642f, 
    0.21769923f, -0.13468587f, 0.10375959f, 0.00594984f, 0.16996929f, -0.10631456f, 0.26527101f, 0.04495659f, 
    0.27054650f, 0.08321293f, 0.14517684f, -0.14651975f, 0.09982430f, 0.04586539f, 0.06958895f, 0.00792539f, 
    0.33344465f, 0.01447655f, -0.31900063f, 0.37422791f, -0.03533961f, 0.09999611f, 0.15092699f, 0.49187604f, 
    -0.32455477f, -0.03555798f, 0.12079868f, 0.07530209f, 0.16547680f, 0.17212968f, -0.06708904f, 0.05292406f, 
    -0.33042657f, -0.01126212f, 0.03835819f, 0.17036675f, 0.04031914f, 0.15754743f, 0.06099839f, 0.03721183f, 
    0.38585946f, 0.04293668f, -0.04513312f, 0.00090671f, 0.20426974f, -0.46306878f, 0.11580237f, 0.00092290f, 
    0.10111230f, -0.12710486f, 0.24120636f, 0.14499208f, 0.03279779f, 0.06582611f, -0.01181519f, 0.62159854f, 
    0.02764013f, 0.04211653f, -0.05049962f, 0.30991367f, -0.15972699f, -0.15189216f, 0.02594482f, -0.14589563f, 
    0.19632782f, 0.58214903f, 0.15630442f, -0.08593675f, -0.12704721f, -0.05046225f, 0.40491641f, -0.16335052f, 
    0.21471222f, 0.09874578f, 0.51946479f, 0.01736070f, -0.19506046f, 0.05740847f, -0.15249306f, -0.09817770f, 
    -0.24967431f, -0.12034460f, 0.00781704f, -0.04266612f, 0.15751651f, -0.05895059f, -0.14347328f, 0.23573139f, 
    -0.01905060f, 0.04401306f, 0.41578874f, -0.03567213f, -0.13304809f, -0.12242375f, -0.13182664f, -0.34110853f, 
    -0.08983070f, 0.11639798f, -0.01100922f, 0.12490260f, 0.09182519f, 0.10527863f, -0.11421797f, -0.09811725f, 
    0.08583069f, -0.04176066f, -0.10848183f, 0.10649046f, -0.06479032f, 0.01725833f, -0.06963966f, 0.15588532f, 
    -0.05761632f, 0.02415139f, -0.10679442f, 0.15305537f, 0.06945954f, 0.14866675f, 0.06833053f, -0.00558560f, 
    -0.01897852f, 0.06550872f, -0.08662882f, -0.14865783f, 0.16406955f, 0.04484526f, -0.05216785f, -0.03460525f, 
    -0.05774640f, 0.28333420f, 0.07606690f, 0.13649273f, -0.06063705f, 0.04125569f, -0.27365813f, 0.12607266f, 
    0.60286039f, 0.08880276f, 0.44129810f, -0.17191187f, -0.15812992f, -0.30347562f, -0.17704271f, 0.00006309f, 
    0.11217865f, -0.15323043f, 0.34028938f, 0.20539121f, 0.05978583f, -0.04500797f, -0.16940600f, 0.26710939f, 
    0.22713952f, 0.06481391f, -0.10574509f, 0.06566458f, 0.08767954f, -0.16966538f, -0.12494899f, -0.37641248f, 
    -0.17087562f, 0.42241019f, -0.10111164f, 0.16658816f, 0.03204117f, -0.13798161f, 0.38972393f, -0.01508895f, 
    -0.15354629f, -0.01074043f, 0.28650281f, -0.04770528f, 0.37422156f, -0.18872412f, -0.04935449f, -0.08504485f, 
    0.06102850f, 0.14991263f, 0.26509389f, -0.37811375f, 0.17040171f, -0.16808979f, 0.00052303f, -0.06965478f, 
    -0.17295904f, -0.03634646f, 0.19079310f, 0.09123185f, 0.06382096f, 0.08115271f, 0.00801512f, -0.04481317f, 
    0.39675766f, -0.19382289f, -0.04114448f, 0.10569638f, 0.01979492f, 0.02646741f, -0.16689825f, 0.12526812f, 
    0.15606843f, -0.06575517f, 0.24327044f, -0.17338912f, 0.21145298f, 0.01231995f, 0.11373642f, 0.09456112f, 
    0.27700022f, 0.04631903f, -0.29631770f, -0.27045223f, -0.16802298f, -0.07230122f, -0.14820686f, 0.13095523f, 
    -0.09088340f, -0.14521122f, -0.29711971f, 0.20178451f, -0.00732858f, 0.22085822f, 0.16895144f, -0.04556590f, 
    -0.19756977f, 0.18298762f, -0.16969112f, -0.11780867f, 0.14682774f, 0.03270021f, 0.10944431f, 0.14589314f, 
    0.10115967f, -0.03934053f, -0.02664606f, 0.13762017f, -0.48869866f, -0.26684701f, 0.15862456f, 0.14393488f, 
    0.05174904f, -0.08763286f, 0.44442540f, -0.08252867f, 0.14090796f, -0.14004087f, -0.02879581f, -0.09885113f, 
    0.35194063f, -0.03792507f, 0.24523881f, -0.19382331f, -0.08455020f, 0.06752197f, 0.04740821f, 0.14936827f, 
    0.35375586f, 0.24935320f, 0.11265077f, -0.10632468f, -0.03793136f, 0.15453336f, -0.17960323f, 0.01803025f, 
    0.09169857f, -0.15420422f, -0.13000846f, -0.07539106f, 0.48770458f, 0.19634356f, -0.00738318f, -0.06008379f, 
    -0.34304336f, 0.12785481f, -0.19085358f, 0.43446523f, 0.14357728f, -0.15479970f, 0.09693153f, -0.37055030f, 
    -0.15426096f, -0.14323221f, -0.17222326f, 0.13395081f, 0.10576629f, 0.23071520f, -0.04740672f, 0.19733740f, 
    0.27879423f, 0.25504339f, -0.10889363f, 0.10283050f, 0.08727273f, -0.16704790f, 0.08755487f, -0.02327760f, 
    0.23006423f, -0.10397003f, 0.16481084f, 0.09197902f, 0.38879317f, 0.04591302f, 0.07443137f, -0.10693739f, 
    -0.28261486f, 0.15643285f, -0.13339023f, 0.25811797f, -0.11454467f, -0.06974017f, -0.13776758f, -0.50489813f, 
    -0.19146895f, -0.17873882f, -0.25269428f, 0.12747891f, 0.03087579f, 0.30108958f, 0.03760485f, -0.12469316f, 
    0.04376759f, -0.07255680f, 0.08618858f, 0.05840214f, -0.10615908f, 0.02281904f, 0.14906226f, -0.04543860f, 
    0.08079638f, -0.08379591f, -0.02638796f, 0.06806520f, 0.08130352f, 0.11787664f, 0.14654376f, 0.08469114f, 
    -0.07506528f, 0.17581154f, -0.16231588f, 0.10839186f, -0.03144243f, 0.00673575f, -0.17139307f, 0.03067531f, 
    -0.12807710f, 0.08167882f, -0.06760343f, -0.12910587f, 0.00717534f, -0.08201751f, -0.12950011f, 0.03874338f, 
    0.29891977f, -0.25879070f, -0.14148596f, -0.08554491f, 0.15944102f, -0.16745365f, 0.09765968f, 0.03125165f, 
    0.14971890f, -0.16616148f, 0.13466784f, -0.00902014f, -0.00896879f, 0.08059765f, 0.08567552f, 0.13708092f, 
    0.16628298f, -0.11690440f, -0.05568245f, 0.11940391f, 0.06768687f, -0.02603733f, -0.10117629f, 0.35578465f, 
    -0.11638113f, 0.17247063f, -0.08346614f, -0.10399151f, 0.00226529f, 0.30873516f, 0.03029802f, 0.12474021f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09743960f, -0.03923630f, 0.09484262f, 0.22858386f, 0.21227635f, -0.03230121f, -0.06898089f, -0.09081415f, 
    0.10674518f, 0.25385383f, -0.19318023f, -0.10408956f, 0.15603186f, 0.20912471f, 0.04983413f, -0.02832149f, 
    -0.25666231f, 0.02320389f, 0.06333861f, 0.11840183f, -0.03013171f, 0.10065643f, 0.15863264f, -0.14787237f, 
    -0.11643685f, 0.15272577f, 0.11819167f, 0.04212562f, -0.13869116f, 0.11455188f, -0.18070808f, -0.17205113f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.02659445f, 0.27812442f, 0.08616371f, -0.34442934f, -0.68171930f, -0.16405965f, 0.29801673f, 0.11324737f, 
    0.03647018f, -0.25710264f, 0.07187048f, -0.28112116f, -0.64162862f, 0.27121189f, 0.24684195f, -0.12685096f, 
    0.07532811f, 0.24172755f, -0.40785760f, 0.03977676f, -0.12729108f, -0.06316654f, 0.01045350f, -0.08738011f, 
    -0.15716045f, 0.05777605f, -0.64931142f, 0.13668545f, 0.29630658f, 0.27026156f, -0.13208507f, -0.06532563f, 
    -0.00736514f, 0.07211539f, -0.12423923f, -0.23580553f, -0.12738349f, 0.12369621f, 0.06242579f, 0.22267768f, 
    0.01727646f, 0.03723450f, -0.00921727f, 0.38378856f, -0.72828376f, 0.09745803f, -0.11629119f, 0.06167968f, 
    0.25692222f, -0.09171381f, -0.14535731f, -0.47591528f, -0.25472248f, 0.28840306f, 0.11845504f, -0.10007615f, 
    0.09974584f, 0.24992563f, 0.13138595f, 0.15059882f, -0.47226796f, -0.43782985f, 0.12976140f, -0.19009818f, 
    -0.81820005f, 0.19133113f, 0.05671464f, 0.10604531f, 0.38409263f, -0.53384876f, -0.02086815f, 0.49190781f, 
    -0.06751955f, -0.00355148f, -0.06407582f, -0.32963836f, 0.00418052f, 0.22666028f, 0.15752459f, -0.10221768f, 
    -0.41632640f, -0.39561036f, -0.36878175f, -0.10439918f, -0.61525190f, -0.37052110f, 0.15416005f, -0.14278883f, 
    0.15380409f, 0.22610433f, -0.50835687f, 0.24565515f, -0.34967551f, -0.43868035f, 0.17409855f, -0.43141180f, 
    0.11596741f, 0.08800478f, -0.15445605f, -0.03483520f, -0.20750920f, 0.37788102f, -0.11733257f, -0.00245354f, 
    -0.02221203f, 0.22490901f, 0.10437731f, -0.64127743f, -0.18431260f, -0.12062656f, 0.44901848f, -0.11304043f, 
    0.18484595f, 0.23846303f, 0.13169350f, -0.13458653f, -0.13846780f, -0.25396249f, -0.72492552f, 0.08909206f, 
    -0.60126406f, 0.03009529f, -0.10775881f, -0.47710323f, 0.39878064f, 0.01133328f, 0.14752489f, 0.06458382f, 
    -0.32564518f, -0.07412429f, -0.16776405f, 0.12934606f, -0.25119311f, -0.16173008f, -0.00466947f, -0.01044801f, 
    0.09697585f, 0.38810378f, -0.15833676f, -0.04210166f, 0.08449704f, -0.38390717f, -0.07640407f, -0.06081417f, 
    0.01721554f, 0.17305160f, -0.04505154f, -0.04905289f, 0.01525420f, -0.17451671f, 0.20971590f, -0.15598425f, 
    0.01757012f, -0.16213141f, -0.02345268f, -0.56161982f, 0.43586847f, 0.27140936f, -0.13337545f, 0.01779727f, 
    0.11076458f, 0.25003153f, 0.14798617f, -0.09060843f, -0.08422985f, 0.14795287f, 0.17871404f, -0.66213191f, 
    0.13476521f, -0.31556541f, 0.01713300f, 0.25152451f, 0.06381702f, -0.43249771f, -0.37654516f, -0.14444895f, 
    -0.17885895f, -0.13744751f, -0.16396467f, -0.17182751f, 0.27466536f, 0.26714793f, 0.18175584f, 0.14133042f, 
    0.14127499f, -0.01188547f, -0.13135725f, -0.16597769f, -0.25923136f, -0.31636816f, -0.13200249f, 0.20796077f, 
    -0.57660419f, -0.33615050f, -0.04462480f, 0.07166330f, -0.47408554f, -0.41261902f, -0.43585828f, -0.13338293f, 
    -0.10119051f, -0.05798414f, -0.12303138f, 0.13527218f, 0.42033911f, 0.19863841f, 0.14787742f, 0.01478249f, 
    -0.11427005f, -0.17910807f, 0.29316160f, 0.08232692f, -0.11001220f, -0.18377692f, 0.21421820f, 0.14413147f, 
    -0.01346689f, 0.02795509f, -0.67539680f, 0.34210387f, -0.31180030f, -0.13309903f, 0.13356875f, 0.12213174f, 
    -0.32562992f, 0.19895369f, 0.06524914f, -0.05945386f, 0.23323724f, -0.05379988f, -0.35777688f, -0.10894299f, 
    -0.09521642f, -0.35928825f, -0.18591391f, 0.10235266f, 0.24000026f, -0.32428718f, -0.07459456f, -0.01906607f, 
    0.35356382f, -0.06022660f, -0.12557319f, 0.22665530f, 0.10364314f, -0.60720783f, -0.32312062f, -0.18236685f, 
    -0.25602832f, -0.41208139f, 0.33609477f, -0.00362944f, -0.06551055f, -0.13101597f, 0.07595330f, 0.38253918f, 
    -0.10147256f, 0.07674796f, 0.01936078f, -0.23651117f, 0.44517973f, 0.32207695f, -0.81781733f, -0.05926051f, 
    -0.09818860f, 0.26161572f, 0.02061666f, 0.44451612f, -0.15539859f, -0.41317672f, -0.11207396f, -0.11800418f, 
    0.26433891f, -0.14989190f, -0.20823246f, -0.22884132f, -0.50264645f, 0.15609944f, 0.11459567f, -0.15267198f, 
    0.28221717f, -0.26291856f, -0.12860781f, 0.26907682f, -0.56229001f, -0.46789068f, 0.06144890f, -0.20723160f, 
    -0.27239272f, -0.73584980f, -0.10810766f, 0.16217899f, -0.14373048f, -0.56814510f, 0.25969529f, -0.03495679f, 
    -0.19855358f, -0.39136440f, -0.13426664f, -0.66712421f, 0.02722987f, 0.05385161f, -0.65169716f, -0.01401157f, 
    -0.28604564f, -0.01027536f, -0.43540594f, 0.21946894f, -0.05756562f, 0.11924077f, 0.23449598f, -0.03425993f, 
    0.04472558f, 0.32739729f, 0.23050614f, -0.22148144f, -0.24484679f, 0.17146330f, 0.07931149f, 0.06929114f, 
    -0.18130508f, -0.01116333f, -0.12360386f, 0.16923507f, 0.39325818f, 0.10301237f, -0.11224025f, 0.17254527f, 
    -0.09446849f, 0.10660435f, 0.02156555f, -0.50271821f, -0.00467447f, 0.33142450f, 0.16868071f, -0.04037596f, 
    -0.76270252f, -0.40428632f, 0.33016750f, 0.07452898f, -0.05273457f, 0.20875551f, -0.54944241f, 0.03272996f, 
    -0.40592855f, -0.23810193f, -0.17921601f, -0.24792069f, -0.28431809f, -0.52082413f, 0.02364850f, -0.21070096f, 
    0.42529550f, -0.69998169f, 0.14249496f, -0.28497329f, 0.00920131f, 0.20558581f, -0.39320126f, -0.47957084f, 
    -0.04217660f, -0.14032339f, -0.09057072f, -0.18779351f, -0.10684537f, -0.05204928f, -0.06816165f, -0.03090410f, 
    -0.43550813f, 0.12394514f, 0.03020343f, 0.22983481f, -0.19566458f, 0.23623084f, -0.41679463f, -0.03558262f, 
    0.33374944f, -0.21540099f, -0.07271577f, 0.08313492f, 0.25766379f, 0.16604838f, -0.07508583f, -0.00511115f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.00566387f, -0.03015717f, -0.09900612f, -0.13521804f, -0.12228094f, -0.13595246f, 0.01120547f, 0.09299551f, 
    0.01914063f, 0.08579921f, -0.04672631f, 0.16833715f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
