#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.94290859f, -0.89211375f, 0.35637730f, 0.39020801f, 0.55687785f, 0.42345977f, -0.31238458f, 0.13084252f, 
    -0.05024301f, 0.11850426f, 0.55676031f, -0.53301519f, 0.40552619f, -0.72920883f, 0.08774548f, -0.04761767f, 
    -0.39608040f, -0.10514165f, 0.19081986f, 0.27028033f, -0.20133971f, 0.07393374f, -0.10650403f, -0.26349264f, 
    0.52565980f, 0.06804767f, 0.02756142f, -0.36694151f, -0.28151006f, -0.27210769f, 0.74957681f, -0.07912216f, 
    -0.00558827f, 0.11186351f, 0.31448168f, -0.17563103f, 0.82634616f, -0.46892411f, -0.23610590f, -0.15344779f, 
    -0.55820960f, 0.08962619f, 0.02691584f, 0.04050589f, -0.45331588f, 0.25291497f, 0.49341515f, 0.41203988f, 
    0.44143713f, 0.63482803f, 0.90247011f, 0.20358914f, -1.08770132f, -0.76526815f, 0.23522192f, -0.54606396f, 
    -0.25743440f, 0.44138134f, -0.12181528f, 0.61173493f, -0.40061957f, 0.05438280f, 0.45380294f, -0.40165150f, 
    -0.32478973f, 0.00344922f, -0.11632659f, 0.27129862f, 0.31837198f, -0.09548867f, -0.14502588f, -0.05616825f, 
    0.09514385f, 0.06218067f, 0.31606215f, -0.44536275f, -0.35012123f, 0.44361326f, 0.90751106f, 0.31266004f, 
    -0.23362482f, 0.90523022f, -0.27681425f, -0.07126599f, -0.55711305f, -0.44239554f, 0.17933099f, 0.26105735f, 
    0.21102077f, 0.42525470f, 0.01164956f, -0.69235307f, -0.25788966f, 0.36716723f, 0.21385667f, 0.38128540f, 
    -0.39488712f, 0.11561953f, 0.14922222f, -0.18037267f, 0.27062663f, 0.50915164f, -0.90570337f, -0.79225814f, 
    -0.44954625f, -0.61533850f, -0.91135222f, -0.53123170f, -1.13258266f, -1.26741302f, -0.58290112f, 0.04878271f, 
    0.11669097f, -0.24122204f, -0.32464701f, 0.00155115f, -0.29655486f, -0.17597860f, -0.20126498f, -0.37254709f, 
    -0.27161694f, 0.14776626f, 0.04513346f, -0.03301790f, -0.10250465f, -1.11656535f, -1.06114745f, -1.14983940f, 
    -0.89827311f, -0.71003461f, 0.88029099f, 0.42864376f, 0.33085930f, 0.36298949f, 0.85886157f, 0.35914916f, 
    0.43130654f, 0.13145933f, 0.18587196f, -0.47847840f, -0.22701792f, -0.10066888f, -0.26802471f, 0.16925442f, 
    0.41975302f, -0.02960113f, 0.08361936f, 0.27450567f, 0.01575857f, -0.02594805f, -0.83235437f, -0.52838683f, 
    0.52059811f, 0.85090750f, -0.05945103f, 1.07585812f, 0.28311095f, -0.02107807f, 0.12022414f, 0.02262428f, 
    -0.00038409f, -0.52197683f, -0.31360888f, 0.45989379f, -0.32635322f, 0.15621065f, 0.02629417f, -0.52446806f, 
    -0.17634884f, -0.53323334f, -0.24487086f, -0.21469599f, -0.15889956f, -0.26821861f, -0.46918136f, -0.47788569f, 
    0.01424689f, 0.25315258f, 0.30710822f, 0.50037897f, -0.06539181f, 0.48439476f, 0.46607837f, 0.42989564f, 
    0.51767695f, 0.05843528f, 0.74252599f, 0.44681752f, -0.75388885f, -0.30772707f, -0.27651140f, 0.26507378f, 
    0.05246623f, -0.27803549f, -0.13644125f, -0.00813502f, 0.30296460f, 0.31078923f, -0.25102577f, -0.04334053f, 
    0.06380340f, 0.67598778f, 0.50819057f, -0.37233672f, -0.47602037f, 0.03531905f, 0.45261320f, 0.18509316f, 
    -0.22596221f, -0.27850762f, -0.51620442f, -0.22209039f, -0.03707113f, -0.04486170f, -0.14822306f, 0.32904986f, 
    -0.59746498f, -0.62134808f, 0.11165042f, -0.34832263f, -0.19330379f, -0.04344773f, 0.32262492f, 0.42333087f, 
    0.55739170f, -0.66258359f, -0.26245984f, -0.41750020f, 1.00584400f, -0.03088491f, 0.25533485f, 0.61152095f, 
    -1.29017913f, -1.01092863f, 1.40019262f, 0.59772384f, -0.03549204f, -0.19976513f, -0.24351223f, 0.48183739f, 
    -0.05265235f, 0.02426150f, -0.13126071f, -0.33413237f, -0.29619420f, 0.47657236f, -0.06598366f, 0.03844733f, 
    0.16040309f, 0.15823375f, 0.09269513f, 1.23773301f, 0.88424730f, 0.07534135f, 0.51970869f, -0.47634441f, 
    -0.15973333f, -0.09858877f, 0.38562948f, -0.29349536f, 0.14424875f, -0.24290937f, -0.13879134f, -0.07316346f, 
    -0.40305018f, -0.15417661f, -0.21147870f, -0.25840575f, -0.12865166f, -0.05757525f, -0.04696619f, 0.37467560f, 
    -0.01220363f, -0.29343823f, -0.53524834f, 0.66511452f, 0.39139694f, 0.60115236f, 0.83830863f, -0.20831311f, 
    -0.79886359f, -0.99549234f, -0.40865016f, -0.45271182f, -0.84851974f, 0.50158715f, -0.16906805f, -0.10122852f, 
    0.35844404f, 0.43614903f, 0.13016225f, 0.22589968f, 0.13431509f, -0.19548799f, -0.03476118f, -0.34506527f, 
    0.23958702f, -0.34002617f, 0.21241261f, -0.17314428f, -1.83517289f, 0.84690970f, -0.33032084f, -1.58375716f, 
    -1.11414623f, 0.05415611f, 0.40925285f, 0.46959800f, 0.26203853f, 0.18352997f, 0.09551520f, -0.27237189f, 
    -0.12567140f, -0.28431493f, 0.29706246f, 0.17771201f, 0.14288577f, -0.21753182f, -0.14851184f, -0.26894102f, 
    -0.04930391f, -0.01408313f, 0.00965464f, -0.34330964f, -0.06584229f, -0.77629709f, -1.05983388f, -1.19661975f, 
    -1.00971878f, -0.33145297f, 0.29196474f, -0.19476826f, -0.39741853f, 0.08622548f, 0.87867248f, -0.92452699f, 
    -0.79480135f, -0.79176694f, -0.01977419f, 0.52027339f, -0.20958617f, -0.16443931f, -0.27363485f, 0.17106234f, 
    -0.25052202f, -0.27495521f, -0.71554828f, -0.24469161f, -0.28948569f, -0.76338643f, -1.31634748f, -0.39722610f, 
    -0.93157941f, -1.06829965f, -0.10738671f, 0.77096158f, 0.08296726f, -1.34343624f, -1.51434255f, -0.35263062f, 
    -0.07745852f, -0.19094291f, 0.25046766f, -0.22516780f, -0.34124598f, -0.36631650f, -0.22937037f, -0.52183801f, 
    -0.65471387f, -0.43142119f, 0.10789748f, -0.20853898f, -0.53332669f, 0.09821214f, -0.12783690f, -0.97295576f, 
    -0.91599208f, -0.34047624f, -0.31648082f, -0.41058278f, -0.77977419f, -0.94722557f, -0.76854229f, -0.60505533f, 
    -1.07432425f, 0.41594887f, 0.76944077f, -0.03377273f, -0.32439315f, -0.05290629f, 0.52528179f, 0.06807701f, 
    0.06117846f, 0.41217095f, -0.00471830f, -0.05470122f, 0.45041624f, -0.16651839f, -0.18755677f, 0.17115447f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.41648114f, 0.09755093f, 0.63459182f, 0.71219558f, 0.02218933f, 0.34657180f, 0.36780292f, 0.25230706f, 
    0.47371489f, 0.52930790f, 0.33603311f, 0.23205623f, 0.31819710f, 0.05229763f, 0.29496613f, -0.10294814f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.66437930f, 0.13249186f, -0.02022814f, -0.47506133f, -0.19678186f, -0.15705772f, 0.18240824f, -0.26516256f, 
    0.12782460f, -0.45857930f, -0.47784191f, -0.36515719f, -0.05601589f, 0.01197255f, -0.03689821f, -0.02267051f, 
    -0.07843620f, 0.18125238f, -0.01229401f, -0.02725306f, -0.27775899f, -0.16965470f, -0.05488927f, -0.26670891f, 
    -0.46697897f, 0.33240530f, -0.43102822f, -0.02819080f, -0.08242069f, -0.19072720f, -0.17639987f, -0.14456233f, 
    -0.08916645f, -0.34904391f, 0.01416683f, 0.09264438f, -0.06008159f, -0.05262354f, 0.11789887f, -0.13352217f, 
    0.01893055f, -0.17039713f, 0.11488714f, -0.04182086f, -0.15537329f, 0.01746177f, -0.08149616f, -0.16701730f, 
    0.37974599f, 0.27110511f, -0.21281037f, -0.07512279f, 0.17341645f, 0.13039352f, 0.00702720f, 0.07816918f, 
    -0.07822964f, -0.10843095f, -0.00044247f, -0.05149894f, 0.37262645f, 0.03541942f, -0.11797506f, 0.00468010f, 
    0.29705232f, 0.23330344f, -0.08630124f, -0.19379516f, -0.06050095f, 0.00593820f, 0.09466238f, 0.02760683f, 
    0.16940269f, -0.69162208f, 0.03226814f, -0.48484376f, -0.03942252f, 0.03185309f, 0.07236549f, 0.02967026f, 
    0.16511337f, -0.06558250f, 0.09181371f, 0.08534011f, -0.24064417f, -0.13601255f, -0.00362306f, 0.01989342f, 
    0.07707973f, 0.02832612f, 0.02509653f, 0.05976562f, -0.21362272f, -0.16376115f, -0.02112953f, -0.37662750f, 
    -0.47774771f, -0.45756620f, -0.07838654f, 0.17739168f, 0.02094276f, -0.07199208f, 0.02262472f, 0.05299242f, 
    -0.07247981f, -0.04326806f, -0.06307136f, 0.02350307f, 0.05799967f, 0.29356331f, 0.02200662f, -0.20629942f, 
    -0.29553121f, 0.06334759f, 0.11335496f, -0.24341990f, -0.31214574f, -0.24238539f, -0.15683156f, -0.15273258f, 
    -1.05010557f, -0.36523318f, 0.19483197f, 0.13810737f, -0.00954153f, 0.08171944f, 0.09936371f, 0.09895437f, 
    0.04051058f, 0.07779177f, -0.09478130f, 0.03387352f, 0.12550974f, -0.02227679f, 0.09531579f, -0.45223898f, 
    -0.21274270f, 0.07608160f, -0.16508189f, -0.02922172f, 0.04221440f, 0.06646319f, 0.02369161f, 0.01841433f, 
    -0.16945215f, -0.32517061f, -0.04166127f, -0.31520495f, 0.11258654f, 0.41177836f, -0.19658850f, -0.01533286f, 
    -0.05011738f, 0.03997971f, 0.06651045f, -0.09876963f, 0.44392461f, 0.32753485f, 0.04222285f, -0.18268220f, 
    0.11131586f, 0.19814700f, 0.02660455f, -0.11540181f, -0.09559095f, -0.01844623f, -0.06207977f, 0.13750234f, 
    0.58580691f, 0.29816052f, -0.59662503f, -0.18605343f, 0.09827140f, 0.19428805f, 0.03546200f, -0.10551388f, 
    -0.14074677f, -0.27918038f, -0.19482751f, -0.12099770f, 0.62912977f, 0.39711377f, -0.23838814f, -0.36670503f, 
    0.23981924f, 0.06638739f, 0.11683858f, 0.21771997f, 0.07471219f, 0.01923920f, 0.03747976f, -0.00857243f, 
    -0.28932983f, 0.28168350f, -0.66242176f, 0.09103104f, -0.02107199f, 0.15412311f, 0.03760242f, 0.04797891f, 
    0.24237739f, 0.20069836f, 0.08297779f, 0.15978806f, 0.19037372f, 0.05094509f, 0.03930713f, -0.09625847f, 
    0.22444028f, 0.11192352f, 0.07205288f, 0.08793446f, -0.06300170f, 0.07593911f, -0.15238923f, -0.10838250f, 
    0.22604267f, -0.12375400f, 0.01567337f, 0.15991540f, 0.04353971f, 0.17716105f, -0.00741500f, -0.16572560f, 
    -0.05691358f, -0.02495437f, -0.10850152f, -0.03124535f, 0.07544357f, -0.10738332f, 0.07500218f, 0.18544669f, 
    -0.18474212f, -0.02058427f, -0.13843942f, 0.08566786f, 0.07389610f, 0.09247550f, 0.25740007f, -0.17081006f, 
    0.01315988f, 0.02734216f, -0.10240887f, 0.06592353f, -0.16320412f, -0.07218128f, -0.21482289f, -0.18044375f, 
    -0.14587940f, 0.06435213f, 0.04359870f, 0.21372978f, 0.30668607f, 0.01593800f, -0.48475334f, -0.18785302f, 
    -0.12028463f, 0.05946844f, 0.17975904f, -0.14078875f, -0.07889830f, -0.07049882f, -0.01552412f, -0.11190607f, 
    0.40528706f, -0.08456884f, 0.09064367f, 0.30118269f, -0.04802800f, -0.11191880f, -0.04942707f, 0.03364071f, 
    -0.25478345f, -0.33698893f, -0.21123053f, -0.42549515f, 0.06653818f, -0.07998283f, 0.34099251f, 0.24515934f, 
    -0.04929020f, -0.00634511f, -0.05579270f, -0.04288423f, 0.01405857f, 0.10441611f, -0.29337159f, 0.31281838f, 
    0.64254379f, -0.23890686f, 0.41286084f, 0.14291316f, -0.13296123f, -0.00616294f, 0.17227842f, -0.16287942f, 
    -0.00905647f, -0.03896159f, 0.01770934f, -0.08439261f, -0.13236479f, 0.08503909f, -0.09108448f, -0.20353547f, 
    0.05779262f, 0.12553447f, -0.07309267f, 0.25198960f, 0.12326540f, -0.14164445f, 0.05862636f, 0.16473292f, 
    0.56658202f, 0.28282952f, 0.27433908f, 0.28508344f, -0.05968498f, -0.17070116f, -0.17677106f, 0.04503053f, 
    -0.03461963f, 0.03797165f, 0.00170987f, 0.03367824f, -0.23285426f, 0.09175797f, -0.19806038f, -0.30325419f, 
    -0.19765960f, -0.23147649f, -0.04464993f, -0.05782146f, -0.10115931f, 0.00104807f, -0.03755560f, 0.20016830f, 
    -0.62566274f, 0.08278225f, 0.16080575f, -0.41743913f, 0.22478160f, 0.18553782f, -0.35078374f, -0.36043036f, 
    -0.10995188f, -0.00948111f, -0.19467352f, -0.12146726f, 0.12770391f, 0.26883417f, 0.09210075f, -0.05944760f, 
    -0.04285602f, 0.12324625f, -0.39699197f, -0.21145487f, 0.13887583f, 0.01605688f, -0.02060099f, -0.60319382f, 
    0.23437424f, -0.19637534f, 0.31771028f, 0.39245251f, 0.03949443f, 0.05301157f, 0.26560605f, -0.00833329f, 
    0.07612318f, -0.00122303f, -0.07188512f, -0.04464740f, -0.19732331f, 0.32293463f, 0.03379772f, 0.15784431f, 
    -0.41797531f, 0.23774296f, -0.35046026f, 0.00841306f, -0.04687284f, -0.03046308f, -0.07548684f, 0.10140035f, 
    0.04606131f, 0.07633342f, -0.52900410f, -0.12293064f, 0.12502526f, 0.25848138f, -0.12819605f, 0.18606885f, 
    0.11021070f, 0.03928187f, 0.20615479f, -0.19545841f, -0.10425971f, -0.15194865f, -0.11343060f, -0.08858628f, 
    0.12280410f, -0.06993661f, -0.16717245f, 0.08871868f, 0.04202405f, -0.19939350f, 0.01962899f, 0.00111096f, 
    -0.17163195f, 0.17812203f, 0.22762737f, 0.14900544f, -0.04620586f, -0.06856873f, 0.13426298f, 0.04551715f, 
    0.06775477f, 0.07839350f, 0.04662324f, -0.26456198f, 0.04307024f, 0.27891564f, -0.27930373f, 0.15401608f, 
    -0.07053445f, -0.04523332f, 0.11669146f, 0.13382162f, -0.32479402f, 0.11141931f, 0.11464278f, -0.08854168f, 
    -1.04280210f, -0.63067311f, -0.01209662f, -0.65735203f, -0.13796769f, -0.01686915f, 0.00287266f, -0.29194096f, 
    -0.08069553f, -0.07834932f, -0.03367573f, -0.08578537f, -0.03288177f, 0.49217394f, 0.31944600f, 0.35464093f, 
    -0.15238371f, 0.00161505f, 0.22001360f, 0.15035611f, 0.12294082f, 0.00492052f, 0.11224546f, -0.02168355f, 
    -0.28284395f, -0.29476216f, -0.12212153f, 0.11960335f, -0.01980690f, -0.03679761f, -0.00389437f, 0.02099167f, 
    0.16128185f, 0.09165794f, 0.23408964f, 0.02851387f, -0.05589126f, -0.23826461f, -0.17490414f, 0.05579804f, 
    -0.03584855f, 0.08979069f, 0.05051663f, 0.01409153f, 0.02212910f, -0.13004616f, -0.08894312f, -0.10212882f, 
    0.00611981f, -0.14646295f, -0.07800822f, -0.36746716f, -0.00764863f, 0.04549536f, 0.04233027f, -0.05717190f, 
    -0.04491445f, -0.05097877f, 0.03542464f, -0.19241419f, -0.01937187f, -0.65634757f, 0.24542311f, 0.15791632f, 
    0.30836084f, 0.04040506f, -0.21243006f, -0.00026725f, -0.11623411f, -0.01116191f, -0.34615165f, 0.09411544f, 
    0.06533256f, 0.09162585f, 0.19134100f, -0.20665911f, -0.02278213f, -0.03035919f, 0.00297996f, 0.03446362f, 
    -0.00604648f, -0.04907263f, 0.04189644f, 0.06550166f, -0.77573556f, 0.00769176f, 0.07723797f, -0.04959382f, 
    -0.10599232f, -0.29848772f, -0.31263831f, -0.33470067f, 0.07024176f, -0.07772046f, -0.01544921f, 0.02828120f, 
    0.90481627f, 0.95723552f, 0.24296738f, 0.40179363f, -0.06873610f, 0.28314900f, 0.05451355f, -0.19005112f, 
    0.02923828f, -0.05396998f, -0.14056884f, 0.31745896f, -0.26374406f, -0.13029484f, 0.88921821f, 0.45059970f, 
    -0.10480694f, -0.03063791f, 0.16322897f, -0.12068594f, -0.12089632f, 0.03564431f, -0.01054680f, -0.20159633f, 
    0.14732230f, -0.57205194f, 0.33548674f, 0.36715791f, -0.00851120f, -0.10809035f, -0.13213044f, 0.01079663f, 
    0.04825406f, 0.02683581f, 0.06858675f, -0.07681376f, -1.26681149f, -0.82573539f, -0.54391539f, -0.65560901f, 
    0.01059239f, -0.05537681f, -0.19216152f, 0.22512951f, 0.03652417f, -0.05404588f, 0.00430827f, -0.01296309f, 
    -0.72666770f, 0.40230376f, -0.15984416f, -1.09245980f, 0.11577640f, 0.01388075f, -0.29119542f, -0.07655756f, 
    -0.10929991f, -0.10909466f, -0.03373656f, -0.14037232f, 0.05428629f, -0.01484475f, 0.00416456f, 0.31491923f, 
    0.18219164f, -0.19868834f, 0.21232891f, -0.46801651f, 0.05903199f, 0.41833931f, 0.19180028f, -0.02697130f, 
    0.06363440f, 0.08340212f, -0.53048092f, 0.27799976f, -0.20001747f, -0.22321595f, -0.23856831f, -0.33753324f, 
    0.09525844f, -0.25754029f, -0.00832308f, -0.04499109f, -0.58446747f, 0.94398761f, -0.68354779f, -0.45802566f, 
    0.13024315f, 0.04170954f, -0.00042712f, -0.26579615f, -0.17293502f, -0.50730956f, -0.07456975f, -0.01981568f, 
    0.00433649f, -0.38615039f, 0.18305925f, 0.31402445f, -0.09053376f, 0.19435060f, 0.04783143f, 0.13988353f, 
    -0.13852617f, -0.06515089f, -0.15409309f, -0.13606130f, -0.10691493f, -0.46914855f, -0.08155721f, 0.24652678f, 
    0.26173064f, 0.09330288f, -0.09695274f, -0.03189255f, -0.05019134f, -0.07138610f, 0.04998896f, 0.03805905f, 
    -0.33734557f, 0.88697517f, -0.00363085f, -0.38996172f, 0.14330733f, 0.24426457f, 0.17457734f, 0.00483465f, 
    -0.37901282f, -0.30666190f, 0.18376741f, -0.28109854f, -0.19667564f, -0.13313216f, 0.22343561f, -0.45030358f, 
    0.23794225f, 0.16121121f, 0.32973444f, 0.02556893f, -0.13652058f, 0.10778779f, -0.50342470f, 0.00624092f, 
    0.30928341f, 0.27219275f, 0.33615020f, 0.30310062f, -0.22981577f, 0.22045954f, -0.34860206f, -0.20265344f, 
    -0.29867348f, -0.48680755f, 0.26157948f, 0.00018509f, 0.42106858f, 0.06177206f, -0.22983533f, -0.14507793f, 
    -0.09123774f, 0.17756504f, -0.04063211f, -0.51601303f, -0.01482892f, -0.18876050f, -0.09841880f, 0.21410310f, 
    -0.41126582f, -0.18330961f, 0.52593964f, -0.53203666f, -0.55296183f, 0.03994977f, -0.53015786f, 0.21971777f, 
    0.11350475f, -0.00203760f, 0.02738228f, -0.07748862f, 0.16336806f, -0.50941300f, 0.37488031f, 0.34900671f, 
    -0.12898557f, 0.06005447f, 0.16026025f, 0.42725363f, 0.22964826f, 0.06474100f, -0.05402708f, 0.19996187f, 
    1.10161519f, -0.30491605f, 0.28180319f, 0.45122814f, 0.18775111f, -0.10763317f, -0.03556146f, -0.14971504f, 
    -0.14844236f, -0.02449868f, 0.06956509f, 0.16032107f, 0.09992225f, -0.35430959f, -0.19326738f, 0.14667225f, 
    0.11487630f, -0.04754480f, 0.13047665f, -0.16089837f, 0.04568576f, 0.04422541f, 0.12067185f, 0.13264856f, 
    -0.11017698f, -0.12754264f, -0.12477637f, 0.27242631f, 0.12051269f, -0.03260880f, 0.00373636f, 0.04740530f, 
    -0.09758165f, 0.12580404f, 0.02502050f, 0.12546286f, -0.00956491f, -0.31766510f, -0.24938148f, 0.25054768f, 
    0.24178192f, -0.04405183f, 0.06008203f, 0.02969712f, -0.03454267f, 0.04353170f, 0.00623788f, -0.07145811f, 
    0.15234774f, -0.34257594f, -0.05063716f, 0.16719350f, -0.11326468f, -0.21677722f, -0.05234615f, -0.23155887f, 
    -0.44449058f, -0.06040686f, -0.14271714f, -0.31194395f, 0.26339397f, 0.20080233f, -0.02101104f, 0.12955001f, 
    0.13114870f, -0.01431653f, 0.09792610f, 0.00070770f, -0.02050055f, -0.18474554f, -0.11707245f, -0.02845250f, 
    -0.54373097f, -0.41406378f, -0.02572837f, -0.36541122f, -0.04011773f, -0.00875885f, -0.14988784f, -0.07907166f, 
    0.06288370f, 0.06215428f, -0.07091040f, -0.37336650f, 0.07585780f, -0.31871954f, 0.17777638f, 0.09856854f, 
    0.15866633f, 0.03805310f, -0.15730396f, 0.18849583f, 0.09060479f, 0.07601475f, -0.28415024f, 0.19720897f, 
    -0.11504865f, 0.27389494f, 0.14611344f, 0.13523136f, 0.12345428f, 0.13534164f, 0.12027534f, 0.13276726f, 
    -0.06019926f, -0.17686696f, 0.09387375f, -0.24881102f, 0.10703639f, 0.19199315f, 0.15945108f, 0.03928467f, 
    -0.04713552f, -0.14877348f, 0.02610099f, -0.12986360f, 0.17949125f, -0.10379871f, -0.10477218f, 0.18447670f, 
    0.06313638f, -0.62133521f, -0.14730828f, -0.21396399f, -0.04484345f, 0.01528817f, -0.02447488f, -0.03470409f, 
    0.20469987f, 0.32086590f, -0.15858167f, 0.26614413f, 0.24169600f, 0.05621800f, -0.25421968f, -0.19068322f, 
    0.09786474f, -0.03477859f, 0.07106017f, 0.08746799f, -0.18371740f, -0.17864476f, 0.04806378f, -0.46786824f, 
    -0.19114910f, -0.20563425f, -0.28914627f, 0.08984162f, 0.30625913f, -0.03621290f, -0.02928874f, 0.03589348f, 
    -0.07298248f, -0.11065373f, -0.19820608f, -0.15726231f, 0.22374347f, 0.26218921f, -0.27644819f, 0.25621441f, 
    0.12615883f, -0.22544812f, -0.09939348f, -0.31226307f, -0.18474384f, -0.11022307f, 0.01653082f, -0.18161523f, 
    0.26217487f, -0.66291338f, -0.44819966f, 0.21714436f, -0.03719025f, -0.02925515f, 0.09042311f, -0.13881990f, 
    0.10592225f, -0.11146362f, 0.06687985f, 0.09113363f, -0.03729377f, 0.55717123f, 0.17464070f, 0.43302482f, 
    0.17761655f, -0.00499686f, -0.11679015f, 0.23918991f, 0.01621534f, -0.08658071f, -0.06025605f, -0.15790720f, 
    -0.14909498f, -0.09619365f, -0.05696459f, 0.09771325f, -0.15511456f, -0.49166614f, -0.02546137f, -0.09190127f, 
    -0.03166317f, -0.05579945f, -0.01906627f, -0.04860228f, -0.43471825f, 0.07374366f, -0.09829903f, 0.05563474f, 
    -0.15597123f, 0.17203301f, 0.15363914f, 0.02031629f, -0.00913559f, 0.05448303f, -0.00759485f, 0.34608406f, 
    0.08944345f, 0.11220971f, 0.11544525f, 0.01762874f, 0.00844745f, -0.01134686f, -0.08228109f, -0.15441303f, 
    0.06708927f, 0.01515397f, 0.03078389f, 0.07733747f, 0.15871523f, 0.11103294f, 0.53943235f, 0.18418372f, 
    -0.09282252f, -0.24982353f, 0.09130741f, 0.04753696f, 0.16143189f, -0.04405145f, 0.12614769f, -0.04565355f, 
    -0.07069289f, -0.02237600f, 0.56281811f, 0.28574029f, 0.09943275f, -0.20959283f, 0.22662939f, 0.16524751f, 
    -0.00723130f, -0.02563023f, -0.26298639f, 0.44982147f, -0.40946656f, -0.26894403f, -0.00612250f, -0.25038189f, 
    -0.39163154f, 0.01694753f, -0.21753959f, -0.12151757f, 0.34807172f, -0.17448810f, 0.03668972f, 0.11316676f, 
    0.46302113f, -0.14267808f, 0.16130055f, 0.00380476f, 0.14013308f, 0.12666355f, -0.24553080f, 0.11365342f, 
    0.12473102f, 0.07194596f, -0.08357587f, 0.14320207f, 0.04427734f, -0.15686715f, 0.12611240f, 0.07248951f, 
    0.12691465f, -0.19788836f, 0.21147564f, 0.07468711f, 0.06460784f, -0.12460898f, -0.15746459f, 0.00768737f, 
    0.17350799f, 0.47337830f, 0.13452072f, -0.15252157f, 0.24631700f, -0.00113423f, 0.12915789f, -0.07612252f, 
    0.11096495f, 0.02922434f, 0.00081151f, -0.04806200f, -0.70565104f, -0.59695405f, -0.13796233f, -0.23665459f, 
    0.04600892f, 0.11069950f, -0.03066130f, 0.00017132f, 0.06696143f, 0.19324912f, 0.07642990f, -0.00014628f, 
    -0.40635741f, -0.23984084f, 0.06052342f, -0.07721902f, 0.01550260f, 0.06378485f, -0.03654772f, -0.10931370f, 
    -0.08534136f, -0.10147189f, -0.37064818f, -0.35452035f, -0.10615566f, -0.07031944f, -0.31830657f, 0.18348359f, 
    0.00558169f, -0.23159198f, -0.17090166f, -0.08745803f, 0.07137891f, -0.11477711f, 0.61200708f, 0.12533826f, 
    -0.10292877f, 0.04897862f, -0.53753287f, -0.02577092f, 0.18063179f, -0.15313706f, -0.16313134f, 0.07166315f, 
    0.17556266f, 0.02798771f, -0.09919608f, 0.33388293f, 0.05036470f, 0.00994225f, 0.29199544f, -0.10366777f, 
    0.09387711f, -0.24287228f, -0.01916335f, 0.37511042f, 0.20154873f, 0.18272881f, -0.11219817f, -0.04461506f, 
    -0.94762105f, -0.46589863f, 0.02344448f, 0.33475220f, 0.08600630f, 0.02972639f, 0.03280279f, -0.02886965f, 
    -0.03548091f, -0.11089555f, -0.01168145f, 0.06088040f, 0.10004739f, -0.28372106f, 0.11277624f, 0.13337339f, 
    0.16127804f, 0.13861626f, -0.04941833f, -0.39140138f, 0.00176938f, -0.04464234f, 0.14103350f, -0.05182100f, 
    -0.69924456f, 0.25551891f, -0.53183335f, -0.15466990f, -0.02737474f, -0.15539940f, 0.04051632f, 0.16248192f, 
    0.17341287f, -0.22883503f, -0.19776732f, -0.05257216f, -0.13486402f, -0.10638694f, 0.23585886f, -0.24215445f, 
    0.11116544f, -0.23038578f, -0.17699412f, 0.18566893f, 0.09847851f, -0.19275369f, -0.11741401f, -0.11176074f, 
    -0.29592845f, 0.55190468f, 0.09518404f, -0.44277322f, -0.09202646f, 0.12619720f, -0.31744501f, -0.01412293f, 
    0.09594882f, 0.00555368f, 0.00242659f, -0.02129494f, 0.10356985f, 0.23927219f, 0.23248674f, -0.17423719f, 
    0.36969799f, 0.12967296f, 0.23806842f, -0.09725283f, 0.01027901f, -0.07597845f, 0.03909957f, 0.13989131f, 
    -0.05664812f, 0.03610937f, 1.24223769f, 0.43275836f, 0.06447079f, -0.19332898f, -0.13560000f, 0.13008069f, 
    -0.01988930f, -0.05940690f, 0.13511004f, -0.22338425f, -0.22919682f, -0.13189454f, -0.05048604f, 0.16105793f, 
    -0.07853637f, -0.35619012f, 0.02926259f, -0.05668785f, -0.04101567f, 0.03352529f, -0.23241431f, -0.14241105f, 
    0.17889182f, 0.01304202f, -0.89510089f, -0.01326730f, -0.25083691f, -0.04169743f, 0.04723047f, 0.54874301f, 
    0.16491969f, 0.07791866f, -0.24800247f, 0.04087816f, -0.42175886f, -0.07582649f, -0.02809964f, 0.26136073f, 
    -0.05708847f, 0.24639589f, 0.01802649f, -0.15855975f, 0.14272089f, -0.21682438f, -0.08557143f, 0.11008780f, 
    -0.89981282f, -1.47266006f, -0.09245509f, -0.31667188f, 0.17243083f, -0.22091214f, -0.01860852f, -0.25521126f, 
    0.00484519f, -0.06235300f, -0.09399492f, -0.00794999f, -0.89680952f, 0.70814031f, 0.70339394f, 0.07260272f, 
    -0.27609202f, 0.00108914f, -0.38315588f, 0.18366256f, -0.05788606f, 0.04585841f, -0.08939580f, 0.09941710f, 
    -0.05289561f, 0.08046434f, 0.05052552f, -0.26024526f, 0.03415642f, 0.13705154f, -0.01378105f, -0.01582387f, 
    0.20936012f, 0.37299499f, 0.47871831f, 0.29841852f, 0.07193063f, -0.06194513f, 0.15508838f, -0.05336086f, 
    0.09571736f, -0.05055778f, -0.14638235f, 0.12319184f, -0.14738508f, 0.20544851f, -0.07547336f, 0.03319403f, 
    -0.05510347f, -0.01349368f, 0.15051919f, -0.48089123f, -0.01292914f, -0.04523120f, -0.01801866f, 0.07779719f, 
    -0.09590733f, 0.25570205f, 0.00887592f, 0.05648561f, -0.20325799f, -0.55096215f, 0.19542205f, 0.35017276f, 
    0.15581848f, -0.02979151f, 0.15989605f, 0.19350378f, 0.04364609f, 0.20602222f, 0.03444405f, -0.36267975f, 
    0.13109145f, -0.04367710f, -0.30251902f, -0.31006318f, 0.05477785f, 0.10710104f, -0.00338455f, 0.02903948f, 
    -0.09246056f, 0.05878709f, 0.05268065f, -0.18068342f, 0.34556130f, -0.75264674f, -0.39665368f, -0.16679452f, 
    0.12481912f, 0.20500830f, 0.49140432f, -0.29274321f, 0.04901955f, -0.11571684f, 0.01614795f, 0.01643711f, 
    0.07185975f, -0.03309936f, 0.42390957f, 0.58226287f, -0.15826762f, -0.14282243f, 0.36432967f, 0.12634653f, 
    0.14342986f, 0.13490577f, 0.19980802f, -0.09677839f, -0.50964826f, -0.31277412f, -0.67695868f, 0.13644512f, 
    -0.38986090f, 0.12913173f, 0.20682980f, 0.25069615f, 0.09860926f, -0.02565720f, 0.19288495f, 0.16256991f, 
    -1.56365156f, -0.65311486f, 0.18541974f, -0.22103126f, -0.01994714f, -0.45292255f, 0.09586620f, -0.50773561f, 
    -0.17539978f, 0.08760720f, -0.01538534f, 0.10152696f, -1.28228438f, -1.04501152f, -0.78692776f, -0.38310301f, 
    -0.29626739f, -0.23022398f, -0.12591588f, -0.63555998f, 0.00325378f, -0.03090707f, 0.04093529f, -0.04860691f, 
    0.49319112f, -0.10939059f, -0.34160453f, -0.86387008f, 0.06112386f, 0.06188238f, -0.05615820f, -0.19167726f, 
    -0.30169576f, -0.18679312f, -0.20997116f, -0.47253346f, 0.14803228f, -0.00030527f, 0.15580028f, -0.21758898f, 
    -0.19213995f, 0.23930985f, 0.16189265f, 0.08776888f, 0.00895533f, -0.22698709f, 0.02557141f, -0.08175413f, 
    -0.82532251f, -0.34180513f, -0.04056535f, -0.12257712f, -0.27386838f, 0.00327295f, 0.34407628f, -0.18595716f, 
    -0.04499915f, 0.05641237f, 0.08782200f, 0.09647341f, 0.16639541f, 0.08923627f, -0.27972806f, -0.22875990f, 
    0.01300211f, 0.11153607f, 0.03912438f, -0.13193144f, -0.19691044f, 0.10667000f, -0.06152905f, -0.09679766f, 
    -0.77747506f, 0.84035498f, 0.13734891f, 0.72130930f, -0.08952298f, -0.28063437f, 0.19023083f, -0.03742841f, 
    -0.03577702f, -0.09720378f, -0.16516095f, -0.12032409f, 1.23659754f, -0.98047805f, -0.24013948f, -0.20499764f, 
    -0.06218214f, -0.15924338f, -0.10921516f, 0.19400038f, 0.11534463f, -0.07640358f, 0.10017490f, 0.10441380f, 
    0.24327190f, -0.04057029f, 0.01112945f, -0.31925300f, 0.02403415f, -0.02347949f, -0.04743454f, -0.01524352f, 
    0.16975680f, 0.32288748f, 0.00327176f, 0.28997397f, 0.33773881f, 0.19098227f, -0.04895963f, -0.21675573f, 
    0.09946425f, -0.03155391f, 0.06671907f, 0.02363547f, -0.11430798f, -0.17377859f, -0.35192204f, -0.59097463f, 
    -0.13395227f, 0.88891131f, -0.54178745f, 0.15063740f, 0.03758096f, 0.21333040f, 0.08315081f, 0.02467246f, 
    0.01093185f, 0.01448789f, -0.07878958f, -0.13951978f, 0.47088224f, -0.24101099f, 0.59919304f, -0.15473536f, 
    0.02020344f, -0.07861721f, -0.16896607f, -0.15297806f, 0.10568266f, 0.20637183f, -0.04466756f, -0.00414880f, 
    0.10378955f, 0.02869710f, -0.24232699f, -0.29433569f, -0.01141256f, -0.05516464f, -0.04273581f, -0.06046957f, 
    0.06388824f, 0.01106740f, -0.00045436f, -0.12192667f, -0.17852814f, 0.09342348f, 0.11117645f, 0.21294051f, 
    -0.30913404f, -0.01204035f, -0.13699187f, 0.23720686f, -0.00752895f, -0.00847098f, 0.01030881f, -0.07744502f, 
    0.23701572f, -1.03691387f, -0.99213034f, -0.32393339f, 0.04684166f, -0.08521354f, 0.07354066f, -0.27475524f, 
    0.14404605f, -0.01699786f, -0.02435430f, 0.21066883f, 0.16058007f, -1.14976823f, -0.11766786f, -1.01823127f, 
    0.14274555f, 0.14504124f, 0.23123214f, 0.23459753f, 0.11252121f, -0.10262835f, -0.20225611f, -0.00413456f, 
    -0.32004112f, -0.86236310f, 0.91128451f, -0.31603459f, -0.03964403f, -0.11958648f, -0.02513888f, 0.15450169f, 
    -0.09515448f, -0.02309002f, 0.00213527f, -0.05431606f, -0.68481958f, -0.97812319f, -0.56974965f, 0.30751893f, 
    0.23807983f, -0.13100737f, 0.04699100f, 0.08723330f, 0.07705694f, -0.05057406f, -0.09484251f, 0.01395175f, 
    0.51522785f, 0.03989675f, -0.49231088f, -0.39535871f, -0.05874338f, -0.34805226f, 0.12394878f, 0.04829367f, 
    0.15970628f, 0.15249848f, 0.06040357f, 0.14290278f, -0.43850034f, -0.25315613f, -0.10265648f, 0.20788412f, 
    -0.09440228f, -0.03621421f, -0.01810716f, 0.09023944f, 0.06539824f, 0.10683795f, 0.03801727f, 0.30945796f, 
    -0.09379186f, -0.64850825f, -0.04655232f, 0.14882031f, 0.26908851f, 0.18713221f, 0.32430437f, -0.10646775f, 
    -0.09768117f, -0.13876384f, 0.26351714f, 0.42492062f, 0.21374503f, 0.05846088f, 0.05050709f, -0.18252502f, 
    -0.29285347f, 0.18784162f, 0.07022222f, -0.21219130f, 0.24181552f, 0.00481514f, 0.11668423f, 0.14122637f, 
    -0.78557682f, -0.81735319f, -0.11197314f, 0.12113517f, -0.12673286f, 0.04689270f, -0.37467426f, -0.26896569f, 
    -0.00227518f, 0.03404788f, 0.24151631f, 0.16235365f, 0.09364266f, -0.77444893f, -0.42457312f, 0.27616709f, 
    -0.21781783f, 0.39348012f, 0.18177703f, 0.25479451f, 0.02475723f, -0.08223255f, 0.01553051f, -0.05369661f, 
    -0.28636745f, 0.05247807f, 0.07807386f, -0.29684934f, -0.07821593f, -0.09449917f, -0.09596766f, -0.07173019f, 
    0.26765731f, 0.06252527f, 0.03926136f, -0.34821671f, -0.08048987f, 0.22215042f, -0.17238769f, -0.27465290f, 
    -0.25605831f, -0.12425240f, 0.00235154f, -0.06655141f, 0.25857538f, 0.04424540f, -0.07139530f, 0.17788245f, 
    -0.60146129f, 0.14285430f, 0.20053145f, 0.22248200f, -0.18419012f, -0.06435807f, -0.11464681f, 0.02985581f, 
    0.21871394f, 0.14884929f, 0.42491516f, 0.15945075f, -0.07981057f, -0.48409176f, 0.00950572f, -0.15658420f, 
    0.00497649f, 0.01190374f, 0.37541938f, 0.00846753f, 0.16127063f, 0.19597341f, 0.15832464f, 0.20727819f, 
    -0.00707414f, 0.44526863f, 0.10279264f, -0.44327527f, -0.13523838f, -0.15222830f, -0.12750633f, -0.13914473f, 
    -0.39627790f, -0.00392036f, -0.09901865f, 0.09228904f, -0.36123222f, 0.09271329f, 0.11116073f, -0.13168883f, 
    -0.12770784f, -0.33070239f, -0.06351562f, -0.37388459f, 0.12432154f, -0.07981534f, 0.18172327f, 0.02505101f, 
    -0.15027133f, -0.81890345f, -0.32824442f, 0.72841811f, 0.09795186f, 0.45660567f, 0.06544156f, 0.40119660f, 
    -0.37069324f, 0.21179482f, 0.08345772f, -0.27315533f, 0.76451010f, -0.17782566f, -0.03345076f, 0.19563451f, 
    0.31142312f, 0.04890046f, 0.20491733f, -0.22550559f, -0.02795590f, -0.30386752f, -0.12479760f, -0.78828710f, 
    0.02316434f, -0.85476047f, -0.84114093f, -0.36300865f, -0.33653989f, 0.27305305f, 0.30717126f, -0.10421852f, 
    -0.08084857f, -0.00878227f, 0.07582696f, -0.07837606f, 0.20451121f, -0.60483706f, -0.87647682f, 0.37363392f, 
    -0.08142319f, 0.10473284f, -0.34144723f, 0.07609631f, -0.01554936f, 0.02826193f, -0.01762738f, -0.02562142f, 
    -0.55744755f, -0.34982711f, -0.02927289f, 0.33565003f, -0.08135310f, 0.10881474f, -0.26222858f, 0.02520646f, 
    0.20510764f, 0.05083391f, 0.08434904f, -0.07433667f, 0.42669609f, -0.01547770f, 0.12223028f, -0.25686634f, 
    0.22287029f, -0.20252350f, 0.16832304f, -0.04062801f, 0.04092279f, 0.30632958f, -0.35231802f, -0.11979458f, 
    0.01255572f, 0.25279546f, 0.89116055f, -0.75987315f, 0.27864888f, -0.54647899f, 0.22704646f, -0.28670946f, 
    -0.33362693f, 0.11218684f, -0.02833345f, -0.05793199f, -0.00883956f, -0.34845418f, 0.22792058f, -0.38519934f, 
    0.24500540f, 0.06795070f, -0.37361598f, 0.21835358f, 0.04011609f, -0.07012962f, -0.06300829f, 0.22487189f, 
    -0.29567334f, 0.44812447f, 0.06228510f, -0.44938141f, -0.32316306f, -0.06476978f, 0.07242838f, 0.36633703f, 
    -0.03136496f, 0.20507433f, 0.08228384f, -0.15015714f, 0.26037318f, 0.39876965f, 0.77547950f, -0.30570954f, 
    -0.01504653f, -0.27979356f, -0.29660106f, -0.18453118f, -0.01048291f, -0.23844175f, 0.10110676f, 0.17057522f, 
    0.01954855f, 0.14990921f, -0.31545150f, 0.65678602f, -0.04931107f, -0.08312608f, -0.04662164f, 0.10238667f, 
    -0.03629113f, 0.17319913f, 0.22712713f, 0.15340884f, -0.50215507f, 0.07250462f, 0.19068819f, 0.43270597f, 
    0.19774014f, 0.02572654f, -0.05458734f, -0.16055578f, 0.15796338f, 0.07756545f, -0.08740718f, 0.08722366f, 
    -0.80161673f, 0.24622777f, 0.13448921f, 0.02238262f, -0.03835143f, -0.02635131f, 0.07038891f, -0.04198689f, 
    -0.11003106f, -0.15091456f, 0.03543238f, -0.36613998f, 0.40410975f, -0.93091756f, 0.26043451f, -0.13140021f, 
    -0.20699465f, 0.15483628f, -0.52142912f, -0.47762156f, -0.10384328f, -0.06488155f, 0.00032684f, -0.11331242f, 
    -0.43452254f, -0.22828722f, -0.75471038f, 0.38973060f, 0.19956337f, 0.26915243f, 0.17022082f, -0.01485548f, 
    0.11315070f, -0.11003206f, 0.15264827f, 0.01887455f, 0.34582096f, -0.11240239f, -0.92311460f, -0.08498973f, 
    0.27326894f, 0.31292400f, 0.14803483f, 0.23432811f, -0.04788488f, -0.15799803f, -0.10677303f, -0.27372479f, 
    -0.69246477f, 0.30921537f, -0.19022252f, -0.34884471f, -0.26642179f, -0.55384058f, 0.00012467f, -0.19090073f, 
    0.12507580f, 0.14407983f, 0.11920021f, -0.05083139f, 0.38970995f, -0.32969528f, 0.30171663f, 0.26952004f, 
    -0.12340628f, -0.07623447f, -0.13132261f, -0.09773444f, 0.14087997f, -0.04491791f, 0.21944191f, 0.16974078f, 
    -0.43859649f, 0.34850156f, -0.03517279f, -0.54992723f, -0.30491668f, 0.14578231f, -0.05973536f, 0.41928542f, 
    0.12447424f, 0.09195317f, 0.00010675f, -0.03995690f, -0.86725813f, -0.12269744f, 0.25146174f, -0.08810802f, 
    -0.08750979f, -0.21287900f, 0.25495169f, 0.01571021f, -0.02843382f, -0.02870817f, -0.01288100f, -0.07966018f, 
    -0.13696562f, -0.63937402f, 0.68300903f, 0.46903810f, -0.10734744f, -0.03363756f, 0.27118823f, 0.01210542f, 
    -0.04798789f, -0.22455499f, 0.12531327f, 0.12864462f, 0.20400102f, 0.18831241f, 0.41752398f, 0.25605983f, 
    -0.18764099f, -0.08924307f, -0.00938497f, -0.09699082f, 0.08088791f, 0.14098032f, 0.33712861f, 0.21632753f, 
    -0.17308447f, 0.75061256f, 0.11449256f, 0.08349771f, -0.27422640f, -0.10156245f, 0.21900252f, 0.22027697f, 
    0.04014873f, 0.10101665f, 0.29299590f, 0.23041061f, -0.51893580f, 0.02124652f, 0.48832700f, -0.23819971f, 
    -0.18076529f, 0.19304658f, -0.48064098f, 0.19756559f, 0.14632554f, 0.01230026f, 0.02085235f, -0.16858405f, 
    -0.00618691f, -0.79268837f, -0.13174318f, 0.11097646f, 0.02779351f, 0.05328887f, 0.01530332f, -0.03140151f, 
    0.11371976f, 0.02260056f, -0.07697922f, 0.12770014f, -0.41230229f, 0.20763351f, 0.12773259f, 0.07285994f, 
    0.09446922f, -0.26796338f, 0.06402184f, -0.05445985f, -0.10565271f, 0.17587082f, -0.23634245f, -0.19368650f, 
    0.12128666f, 0.47230312f, -0.17290625f, -0.14409414f, -0.06731739f, 0.22988173f, 0.03613746f, -0.08443826f, 
    -0.36644647f, -0.26902017f, -0.43083504f, -0.55064988f, -0.30272177f, -0.43834651f, 0.36348560f, -0.53533131f, 
    -0.51559472f, -0.05751538f, 0.08505986f, -0.17230992f, -0.02693669f, -0.36050767f, 0.04831859f, 0.14981373f, 
    0.34032184f, -0.52324367f, 0.27329409f, -0.36271498f, -0.45367092f, 0.09982029f, 0.04601757f, 0.07865411f, 
    0.23087254f, -0.07322086f, -0.07708161f, 0.37047091f, -0.60179430f, 0.47257629f, 0.21121526f, 0.06246246f, 
    -0.05840860f, 0.31704363f, 0.10927859f, 0.09881598f, 0.03262879f, 0.18850172f, 0.18594673f, 0.25300324f, 
    -0.24126472f, 0.03935466f, -0.33360621f, -0.12262528f, -0.70814401f, -0.26878259f, 0.26343039f, -0.34161517f, 
    -0.31497341f, 0.19101439f, -0.23807831f, 0.06377739f, -0.42628938f, -0.04499092f, -0.43731749f, -0.13527843f, 
    -0.04343380f, -0.03390574f, -0.05561397f, -0.13383043f, -0.30184910f, 0.19228141f, 0.01580501f, -0.15159550f, 
    1.05638325f, -0.91459537f, 0.36748150f, -0.06275714f, -0.23220398f, -0.03780673f, 0.11754832f, 0.36778924f, 
    -0.18528335f, 0.10025191f, 0.00257473f, -0.06546041f, -0.37723169f, 0.48777407f, -0.44329235f, 0.06211087f, 
    -0.13070253f, -0.16924047f, 0.04987549f, -0.21812579f, 0.10692590f, 0.09594060f, -0.38416576f, -0.59735644f, 
    0.14188860f, -0.60449231f, -0.03635778f, 0.41445559f, 0.12752800f, -0.03253612f, -0.10865653f, 0.01078355f, 
    0.03414925f, 0.08859606f, 0.04785039f, -0.19070773f, -0.12682012f, -0.55503470f, -0.21701948f, 0.11825243f, 
    -0.18999884f, 0.17294320f, -0.07337210f, 0.12858765f, -0.00565414f, 0.17566064f, 0.03479110f, 0.15765421f, 
    -0.19574589f, -0.21565880f, -0.33152467f, 0.07951763f, 0.19638501f, 0.11785814f, -0.04593643f, -0.18474792f, 
    0.05372507f, 0.04239348f, 0.50918293f, -0.16928598f, -0.32789698f, 0.13489161f, -0.33859059f, 0.14518331f, 
    0.00330728f, 0.08144070f, -0.07247357f, 0.08309419f, -0.51113170f, -0.00946257f, -0.36976543f, -0.42550969f, 
    0.33844557f, 0.09547997f, 0.97791857f, 0.13850324f, -0.21074343f, 0.38381749f, -0.20674098f, 0.46559286f, 
    -0.34262371f, 0.06276362f, -0.11066870f, -0.18517967f, -0.09449629f, 0.38105491f, -0.52604210f, 0.01255619f, 
    0.10471606f, -0.00797937f, 0.15240782f, -0.05800892f, 0.13912156f, 0.15867302f, -0.00072157f, 0.24990524f, 
    0.01823079f, -0.60771072f, 0.37432358f, -0.10902307f, -0.35900527f, -0.18412766f, -0.25767013f, -0.05803651f, 
    -0.00928568f, 0.14349082f, -0.04320962f, 0.04967561f, -0.51995605f, -0.04160492f, -0.30896211f, -0.01250669f, 
    0.03012377f, -0.15515393f, 0.11165798f, 0.02915058f, -0.11343819f, 0.02726258f, -0.32379678f, -0.24279007f, 
    -0.32456034f, -0.19183132f, -0.07413031f, 0.33709714f, 0.15492813f, -0.15211670f, 0.03711293f, -0.13164310f, 
    -0.00413618f, -0.02828721f, 0.30145332f, 0.40312704f, -0.08410711f, 0.09690720f, -0.18451141f, -0.14387953f, 
    -0.05364392f, 0.27345654f, -0.02926669f, 0.08078392f, 0.05632820f, 0.28406575f, 0.38162276f, -0.32214159f, 
    0.24368228f, -0.08667965f, -0.04157552f, -0.34606817f, -0.13410296f, 0.05955144f, -0.18612850f, -0.14415361f, 
    -0.05101364f, 0.12985244f, -0.17371856f, -0.01213657f, -1.41149521f, 0.94049901f, -1.03143084f, 0.56484115f, 
    0.17218143f, -0.67924207f, 0.62044907f, -0.04103511f, 0.04625115f, -0.06353263f, -0.01296537f, -0.02349854f, 
    0.50462133f, 0.23796299f, 0.25071511f, -0.26348475f, 0.00153468f, 0.19074227f, -0.19123007f, 0.06965738f, 
    -0.13220832f, -0.10323613f, 0.03531642f, -0.21775635f, 0.69669545f, 0.22948946f, 0.48830011f, 0.10200775f, 
    0.26822442f, 0.01606634f, 0.01385663f, 0.04718488f, -0.05380918f, -0.06945002f, 0.10443375f, 0.06096914f, 
    -0.30554983f, 0.16699870f, 0.25476769f, -1.28190649f, -0.17962408f, -0.16641584f, -0.04951583f, 0.17929704f, 
    0.02237280f, -0.05843952f, 0.10017943f, -0.02285351f, 0.06227529f, 0.36616436f, -0.27902734f, -0.31092331f, 
    0.01404153f, -0.12243399f, 0.33038005f, 0.34926844f, -0.00929635f, 0.23795564f, 0.14259937f, 0.20023528f, 
    -1.15122926f, -0.51660508f, 0.09995522f, 0.55571020f, -0.39471200f, -0.30009332f, 0.01826869f, -0.19283730f, 
    -0.02687745f, 0.05061437f, -0.05425527f, 0.00152062f, 0.35656920f, -0.51806939f, 0.19782774f, -0.19220428f, 
    -0.22607341f, -0.05307617f, -0.04114219f, -0.30934644f, 0.05355662f, -0.10322249f, -0.11139712f, -0.08320533f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.35774145f, 0.10872613f, 0.04933303f, -0.15184942f, -0.03864589f, 0.06183371f, 0.02483070f, -0.30584890f, 
    0.16969058f, 0.03325188f, -0.02687137f, 0.03769226f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
