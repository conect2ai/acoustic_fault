#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.59657973f, 0.90766597f, 0.92734921f, -1.05425429f, -0.23815662f, -0.66559434f, -0.12987433f, 0.78423482f, 
    -0.02681996f, 0.36371812f, -0.19792573f, 0.11427404f, -0.10898130f, 0.28990293f, -0.38051033f, 0.02093830f, 
    -0.27436695f, -0.36411506f, 0.26291525f, 0.37698871f, -0.05417829f, 0.22391897f, -0.08308465f, 0.03132590f, 
    -0.05744172f, -0.06511547f, -0.60746098f, -0.21643950f, 0.20529750f, 0.56071043f, 0.40028203f, -0.33503130f, 
    -0.39377981f, 0.15597872f, 0.89261532f, -0.03020756f, 0.45948181f, -0.25702265f, -0.22335835f, 0.82386154f, 
    -0.51493323f, -0.12340788f, 0.02810509f, -0.26612625f, 0.03049793f, 0.22400558f, 0.06955479f, 0.30605400f, 
    0.00512192f, 0.05756310f, 0.60935223f, 0.39604115f, 0.21635798f, 0.68648642f, 0.30480078f, -0.01149619f, 
    0.06958844f, 0.15105103f, 0.02093708f, 0.19953625f, -0.06157916f, -0.25565517f, -0.08189974f, -0.33973306f, 
    0.22742365f, 0.08992658f, 0.17744909f, -0.25696981f, 0.31155196f, -0.21395233f, -0.04777711f, -0.56152546f, 
    -0.30450073f, -0.23961012f, -0.44279745f, 0.70883095f, 0.44881046f, 0.20990771f, 0.28226981f, 0.25708967f, 
    0.31579828f, 0.13355233f, -0.25873351f, 0.12792401f, 0.15944609f, 0.10896877f, 0.52932096f, 0.00242823f, 
    -0.35861206f, -0.16591404f, -0.01629298f, -0.39835182f, 0.02981502f, -0.08428374f, -0.28177488f, 0.08124534f, 
    0.36823961f, 0.50912666f, -0.25145954f, -0.57221240f, 1.22725284f, 0.69891143f, 0.40236840f, -0.28733209f, 
    -0.27759367f, -0.38450456f, -0.15308067f, 0.21644279f, -0.58394104f, -0.87652248f, -0.36989895f, 0.49702838f, 
    -0.16929211f, -0.31884974f, 0.34737578f, 0.27737689f, 0.10255794f, 0.08878624f, 0.07650884f, -0.11290310f, 
    -0.12810361f, -0.13131350f, 0.00116375f, 0.09619917f, 0.33952513f, -0.02514685f, 0.15547037f, -0.02916382f, 
    0.89269823f, -0.74231416f, -0.93105417f, -0.77842009f, -0.19752024f, 0.51344746f, 0.57782131f, 0.22408226f, 
    -0.53421324f, -0.05474540f, 0.68258780f, 0.10184722f, 0.02568695f, 0.25802314f, 0.26349258f, -0.13222860f, 
    -0.70954913f, -0.03754387f, -0.07901762f, 0.00313855f, -0.21699381f, -0.08816598f, 0.00388621f, 0.30997416f, 
    1.16277468f, -0.51234221f, -0.93437606f, 0.66139001f, -0.46885896f, -0.58010304f, -0.23619613f, -0.46380514f, 
    0.30223289f, -0.33898208f, -0.29170516f, 0.03722469f, 0.14570823f, 0.16602699f, -0.18602237f, 0.28720960f, 
    0.15743569f, -0.33348346f, -0.11303452f, 0.20236526f, 0.33097315f, -0.12182111f, 0.15598805f, -0.74344677f, 
    -0.54304606f, -0.95309192f, -0.60227424f, -0.58653146f, -0.01732236f, -0.15513706f, -0.61826199f, -0.78857666f, 
    0.50416958f, -0.09559417f, -0.47360843f, -0.65221298f, -0.07964920f, 0.31797501f, -0.20635138f, -0.29119307f, 
    -0.38466915f, -0.26560381f, -0.81419486f, -0.20961031f, -0.29869354f, 0.00984120f, 0.18030925f, -0.11742397f, 
    1.04616535f, 0.40309936f, -0.08531617f, -0.78312540f, -1.09428108f, 0.01260301f, -0.14401303f, 0.21507435f, 
    0.05684116f, 0.35735005f, 0.16098894f, 0.09277279f, -0.09203161f, 0.22003597f, -0.50694048f, -0.00855794f, 
    -0.12884630f, 0.10489378f, -0.36271244f, -0.12853304f, -0.24818112f, -0.30000925f, -0.45540994f, -0.49774829f, 
    -0.48209411f, -0.36802235f, 0.06934021f, 0.37893292f, 0.61586976f, 0.70534450f, 0.43823224f, 0.04541486f, 
    -0.03558090f, -0.14138764f, -0.10954008f, -0.00982277f, 0.34180626f, 0.38770932f, -0.30099884f, -0.06178140f, 
    -0.39915752f, -0.27924138f, 0.09883360f, -0.02691897f, -0.35463405f, 0.10863948f, 0.25082436f, 0.01013699f, 
    0.21619421f, 0.46705467f, 0.44253239f, -0.37804902f, -0.06442040f, 0.04171839f, -0.32513866f, 0.01137937f, 
    0.36931619f, 0.44258252f, 0.18631214f, 0.53826505f, 0.34055778f, -0.44314325f, -0.14564332f, 0.16553017f, 
    0.10010310f, -0.30434504f, -0.04543626f, -0.35273138f, 0.49580303f, -0.27636790f, 0.20270380f, -0.05603712f, 
    0.31532311f, -0.02019253f, 0.50828820f, -0.08209515f, 0.30765790f, 0.24790257f, -0.85559833f, 0.61405045f, 
    -0.16568044f, -0.43680167f, -0.65150726f, -0.78670049f, -0.83780038f, 0.27824035f, 0.95333385f, -0.31593582f, 
    0.13497546f, -0.26591575f, 0.10516083f, -0.41156849f, 0.01222414f, -0.31315687f, -0.27099073f, -0.14150466f, 
    -0.08962306f, -0.25346372f, 0.15577768f, -0.20120068f, -0.80278373f, -0.47242209f, -0.22081605f, 1.00416672f, 
    0.30088612f, 0.43609026f, 0.35539421f, 0.25141856f, 0.40187028f, 0.42493328f, 0.19556224f, 0.13284907f, 
    -0.64852667f, -0.29999971f, -0.18863145f, -0.16553351f, 0.27795395f, 0.02561392f, -0.12087131f, -0.30091661f, 
    -0.29979137f, -0.03257709f, -0.19474022f, -0.22925806f, -0.21838568f, -0.66653264f, -0.24143414f, -0.27457079f, 
    0.00815387f, 0.93619871f, -0.96250439f, -1.03351438f, 0.33259526f, -0.08542210f, -0.66622025f, -0.26494873f, 
    -0.22377835f, -0.07235222f, 0.80639005f, -0.62263322f, 0.45081565f, -0.23452809f, -0.11986907f, 0.03688906f, 
    0.28169504f, -0.20026840f, 0.12833762f, 0.34098229f, -0.07894219f, 0.38663280f, -1.38153839f, -0.68168616f, 
    -0.56894082f, -0.21022139f, -0.13759437f, 0.35900879f, 0.67695165f, -0.75026095f, -0.42725950f, 0.21336637f, 
    -0.08437575f, -0.45807093f, -0.40975407f, -0.66260463f, -0.36507544f, 0.15198593f, 0.37318477f, 0.07998658f, 
    0.07614378f, 0.14836469f, 0.17860942f, -0.07263418f, -0.03266311f, 0.06205615f, -0.14265612f, -0.70497483f, 
    -0.33867201f, 0.35349709f, -1.12078738f, -1.36629903f, 0.55159491f, 0.50711429f, -0.01055316f, -0.08260100f, 
    0.36320814f, 0.03019354f, -0.04003664f, 0.26897824f, 0.26497823f, 0.18968165f, -0.21877243f, 0.29995891f, 
    0.04497835f, 0.06256569f, -0.16272295f, 0.00368965f, -0.03545505f, -0.13977750f, -0.22645918f, -0.25897366f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35646123f, 0.22679967f, 0.04720299f, 0.15552072f, 0.45659015f, 0.42802384f, 0.51630396f, 0.28611559f, 
    0.23059107f, 0.34666783f, 0.42371807f, 0.17426649f, 0.41612884f, 0.37224284f, -0.31345358f, 0.31421855f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.51347196f, 0.35007432f, -0.55378550f, 0.01844761f, -0.09357426f, 0.06135866f, 0.28132269f, -0.14421390f, 
    0.07410209f, 0.04034999f, 0.10565770f, 0.04736581f, 0.15762766f, -0.23810148f, 0.37730646f, -0.05577290f, 
    0.04609091f, -0.05058797f, -0.08326669f, -0.15184967f, 0.14295383f, -0.03260349f, 0.27376425f, 0.16563022f, 
    0.02259003f, -0.05575002f, -0.16347444f, -0.03776802f, 0.03130480f, 0.09002855f, 0.04456284f, -0.07571092f, 
    -0.10761575f, -0.07698441f, 0.13401806f, 0.05625898f, 0.06249527f, -0.18477374f, 0.03181637f, 0.05799421f, 
    0.10883747f, 0.13360083f, -0.04114157f, -0.07691448f, 0.09475211f, 0.03616146f, -0.11160512f, -0.21549197f, 
    0.15622409f, 0.03508876f, -0.05767470f, -0.21871817f, 0.20555066f, 0.25780720f, 0.55814201f, 0.15189894f, 
    -0.01545186f, -0.04759109f, -0.08145013f, -0.02539593f, 0.67440999f, 0.20441070f, -0.46733555f, -0.07666364f, 
    -0.14502604f, 0.04180249f, 0.33338815f, 0.05571931f, 0.11633518f, 0.11104002f, -0.00521567f, 0.06892189f, 
    0.34899375f, -0.12353591f, -0.15129168f, -0.01090426f, -0.23172903f, 0.07302991f, 0.05556395f, -0.14736120f, 
    0.09394354f, -0.11523303f, -0.07486636f, -0.01070953f, -0.13283929f, 0.02826108f, -0.13358863f, -0.18064325f, 
    -0.12794767f, -0.08547022f, -0.01813935f, 0.18935421f, 0.04014928f, -0.06721182f, 0.08024033f, 0.01021545f, 
    0.33048049f, 0.24084675f, 0.16911684f, -0.00539192f, -0.04465605f, -0.12121864f, 0.11943366f, 0.13966538f, 
    0.10816339f, 0.17160152f, 0.13026457f, -0.00338242f, -0.09005652f, -0.20900054f, 0.25260133f, 0.01467977f, 
    0.02302869f, 0.02329097f, -0.14019196f, -0.18389465f, 0.04917485f, -0.07701229f, -0.11343090f, -0.04638659f, 
    0.16742976f, -0.03149775f, 0.01126868f, 0.04852656f, 0.02282180f, -0.18538493f, 0.07521874f, -0.12499924f, 
    0.05286750f, 0.14935987f, 0.18859753f, -0.06486086f, -0.50304538f, -0.38335752f, -0.03460281f, 0.26371855f, 
    0.19698906f, 0.00386436f, 0.13076973f, 0.04109200f, -0.02375226f, -0.06239290f, 0.03312337f, -0.11128457f, 
    0.14092602f, 0.16094790f, 0.41703165f, 0.14044291f, -0.01818680f, -0.03496615f, -0.07616344f, -0.13272123f, 
    0.20792231f, 0.30262271f, 0.37134174f, -0.13727415f, -0.67586607f, -0.19720119f, -0.36699837f, 0.00716711f, 
    0.32035559f, -0.30359429f, 0.09279982f, 0.06704299f, 0.00225253f, -0.06797811f, -0.03620617f, -0.01123072f, 
    -0.26327094f, -0.35563704f, -0.33692187f, -0.23493886f, -0.02519485f, 0.12626787f, -0.07977737f, 0.15706095f, 
    0.10757834f, -0.05473397f, -0.04059078f, 0.02497338f, -0.14652708f, 0.19147438f, -0.24269184f, -0.24605493f, 
    -0.17970774f, 0.07629969f, -0.05067608f, -0.03249916f, 0.19013560f, 0.12991732f, 0.03910182f, 0.19810371f, 
    -0.08839929f, 0.06109255f, 0.14296448f, -0.11958772f, 0.00510457f, -0.06197624f, 0.23869959f, -0.18989952f, 
    0.26209292f, 0.02090744f, 0.19824383f, -0.03092019f, 0.13314532f, 0.38091201f, -0.01077202f, -0.00803649f, 
    -0.17037480f, -0.11525203f, -0.07873591f, 0.00142146f, 0.01353759f, -0.11814743f, -0.01329994f, -0.11325944f, 
    0.21155442f, 0.19964410f, 0.24327654f, 0.16035962f, -0.08789843f, -0.08924109f, 0.02256472f, 0.03133993f, 
    0.20909618f, 0.14392401f, -0.00359145f, 0.10093882f, 0.44592288f, 0.22268282f, 0.28258556f, 0.22411111f, 
    -0.07549919f, -0.10751803f, -0.01558848f, -0.07186238f, 0.06533570f, 0.01582764f, 0.07937161f, 0.07486317f, 
    0.32993853f, 0.13218032f, -0.03271096f, 0.02038553f, -0.03400482f, -0.04855302f, -0.02581742f, 0.03028744f, 
    -0.05177952f, -0.04651356f, -0.10342041f, -0.12303600f, -0.21900824f, 0.06083858f, 0.39681986f, 0.10733830f, 
    0.19503832f, 0.40355527f, -0.27853271f, 0.06203821f, -0.09610731f, -0.01824972f, 0.12734874f, -0.11027336f, 
    0.17676260f, 0.14820530f, -0.04659688f, 0.08556602f, -0.03134272f, 0.22435154f, 0.23228341f, 0.19481732f, 
    -0.06106557f, -0.02246795f, 0.04743016f, -0.08019479f, -0.29752615f, -0.35332471f, -0.54166287f, 0.02835956f, 
    -0.03234180f, -0.06394035f, 0.03831686f, 0.04134789f, -0.07436108f, 0.01427031f, -0.17128314f, 0.05836901f, 
    -0.05217976f, -0.26863304f, -0.02126723f, -0.15558079f, -0.07969987f, -0.00701194f, -0.05765529f, 0.07453845f, 
    0.12637873f, -0.24945165f, -0.01096986f, -0.11046059f, 0.24111405f, 0.23313443f, 0.12202874f, 0.19877878f, 
    -0.13008399f, 0.05241763f, -0.09760669f, -0.06730159f, -0.07406512f, -0.07009456f, -0.07498649f, -0.00564773f, 
    0.07445987f, 0.06774137f, 0.06807189f, -0.02517771f, -0.01784476f, -0.04772168f, -0.04617272f, -0.10008930f, 
    0.11525728f, -0.01481864f, -0.13884021f, -0.03109017f, 0.12779422f, 0.47137666f, 0.31547123f, 0.38315654f, 
    -0.04239245f, 0.02479740f, 0.22145982f, 0.08641794f, 0.05908130f, -0.18981180f, -0.06904505f, 0.29224864f, 
    0.36183727f, 0.09320650f, 0.15665598f, -0.12517260f, -0.08124658f, 0.10507262f, -0.03806212f, 0.02880082f, 
    -0.02390333f, -0.12927990f, -0.02666952f, 0.29237950f, -0.45870817f, 0.18483989f, 0.02936177f, -0.20879784f, 
    0.17501540f, 0.15562108f, 0.16245085f, 0.17653897f, -0.02686757f, -0.00218940f, -0.03077782f, -0.15509973f, 
    -0.10911919f, 0.13457672f, -0.47069806f, -0.44352177f, 0.02982057f, 0.00687701f, 0.00303502f, 0.19341840f, 
    -0.02462217f, 0.01262837f, 0.08852587f, 0.03579435f, -0.48128542f, -0.31033680f, -0.49983045f, -0.46280584f, 
    0.01924578f, -0.07940609f, -0.00499602f, 0.12776811f, 0.08753384f, -0.18434280f, 0.01635524f, -0.28586859f, 
    -0.91776437f, -0.57139009f, 0.16047065f, -0.53384387f, 0.02970179f, 0.23894423f, -0.07161848f, -0.06998703f, 
    0.13114408f, -0.26518404f, 0.07043552f, 0.03977419f, 0.17991313f, -0.19271825f, -0.16269922f, -0.20773152f, 
    0.06102246f, 0.03651120f, -0.01970154f, -0.02236023f, -0.16276605f, -0.27578735f, 0.25759619f, -0.20537987f, 
    -0.08675288f, -0.57944912f, -0.11437542f, -0.24573009f, 0.11836886f, -0.07795841f, -0.27369669f, -0.20056312f, 
    -0.14607874f, -0.17813331f, 0.02501088f, 0.07456116f, -0.22067675f, -0.63403982f, -0.47932956f, -0.24937624f, 
    0.10915507f, -0.08940480f, 0.09799258f, 0.03900454f, -0.10237543f, 0.01016680f, 0.06270644f, -0.04558548f, 
    0.33665985f, 0.33922657f, -0.78430521f, -0.41494006f, 0.30487487f, 0.36127728f, 0.36999255f, 0.04306996f, 
    0.01938320f, 0.10154241f, -0.00878870f, -0.11744386f, -0.16508515f, -0.05118668f, 0.06578599f, 0.17594509f, 
    0.25705066f, 0.10728685f, -0.00999793f, -0.12884676f, -0.10634731f, 0.17532352f, -0.03738803f, 0.14358968f, 
    -0.07727351f, 0.28825575f, -0.51782608f, 0.18359762f, -0.03518058f, -0.03498493f, 0.02910248f, 0.21313523f, 
    -0.01418326f, -0.06259768f, -0.12066310f, 0.01442749f, 0.36370823f, 0.42161083f, 0.25652626f, 0.10177325f, 
    -0.00225164f, 0.04708332f, 0.08259035f, 0.11303221f, -0.02773161f, 0.06917168f, 0.03419679f, 0.03396248f, 
    0.06506051f, -0.26575994f, -0.03646331f, 0.11083097f, 0.17227367f, -0.10429796f, 0.09114181f, -0.11963359f, 
    0.10182050f, -0.07093699f, -0.00400627f, 0.23062740f, -0.34126320f, -0.34757239f, -0.08042654f, 0.10642811f, 
    0.17918514f, 0.16476430f, 0.20972842f, 0.06242372f, 0.04010332f, 0.17139855f, 0.03720069f, 0.09980521f, 
    0.13985665f, -0.43981910f, -0.18500920f, -0.05109542f, -0.06911655f, -0.02203855f, 0.20180485f, 0.03817248f, 
    -0.00705913f, -0.10513755f, -0.10155451f, -0.11649750f, 0.37506080f, 0.48740011f, 0.01055420f, 0.53389627f, 
    -0.04170003f, -0.04895315f, 0.07366567f, -0.01293707f, -0.05212685f, 0.11092231f, 0.10511660f, -0.00118191f, 
    0.24305028f, -0.31802735f, -0.07568780f, 0.09178367f, -0.10451029f, -0.17200208f, 0.02201778f, 0.02129238f, 
    0.17341447f, -0.05944759f, 0.10331947f, -0.01433564f, 0.12526746f, 0.43881378f, 0.53922731f, 0.18768007f, 
    0.15350120f, 0.04486961f, 0.07240982f, 0.02127662f, -0.00494718f, 0.06868587f, -0.06732578f, -0.08719549f, 
    0.41325477f, 0.21643823f, 0.15683845f, 0.14492339f, -0.00323965f, 0.11582037f, 0.18317662f, 0.02346491f, 
    0.09695324f, 0.08283048f, 0.06272599f, 0.00617350f, -0.23084518f, 0.31138334f, -0.06711143f, -0.10318235f, 
    -0.00883808f, 0.03321002f, 0.00717774f, 0.01364292f, -0.01712652f, 0.02106028f, 0.07893792f, 0.02366134f, 
    0.02433979f, -0.05745268f, 0.01667696f, 0.02353271f, 0.05333442f, -0.06695754f, -0.05706299f, -0.01994752f, 
    0.04747935f, -0.03081109f, -0.04766702f, 0.04766240f, 0.05780539f, -0.02914812f, -0.04478042f, -0.06258377f, 
    -0.00237616f, -0.05601247f, 0.00779947f, -0.04898469f, 0.01827961f, 0.04618882f, -0.07632777f, -0.07633039f, 
    0.00450213f, 0.01503400f, -0.03238578f, -0.01276283f, 0.00120039f, -0.06034588f, -0.02359827f, -0.03263345f, 
    -0.06620058f, -0.07426877f, -0.01057766f, 0.04984828f, -0.03150336f, 0.04464079f, -0.07174085f, -0.00134646f, 
    0.02450204f, -0.06381048f, -0.01427951f, -0.04149906f, -0.03462584f, 0.03423973f, -0.01281080f, -0.02313345f, 
    -0.03729191f, 0.01650597f, 0.03005755f, -0.07529205f, -0.07763226f, 0.04202722f, 0.06118173f, 0.04013450f, 
    0.02869524f, 0.01562002f, -0.04694558f, 0.00881736f, 0.03637902f, -0.07464147f, -0.02893106f, 0.05293360f, 
    -0.00988529f, 0.05888965f, -0.05733117f, 0.00536505f, -0.06098972f, -0.03253832f, 0.03006343f, -0.05554396f, 
    0.02996888f, 0.03664996f, 0.03966827f, -0.04518913f, -0.01464024f, -0.06306866f, -0.07719503f, 0.01682393f, 
    -0.03505904f, -0.07778713f, -0.07416524f, -0.02084982f, -0.04791295f, -0.03151112f, 0.02242928f, 0.05638640f, 
    0.06062237f, 0.02292869f, -0.07448766f, -0.06646015f, 0.05328407f, -0.03175194f, -0.06612578f, 0.05768667f, 
    -0.03104738f, -0.03664862f, 0.02281770f, 0.06475703f, -0.02509379f, 0.01572079f, -0.03091598f, -0.04969569f, 
    0.01084794f, 0.00180048f, -0.01310025f, -0.02783583f, -0.03738815f, 0.02610374f, 0.01384189f, -0.02189556f, 
    -0.03204460f, -0.00831235f, -0.00901414f, 0.03509575f, -0.02595707f, 0.05508812f, -0.04013019f, -0.06625199f, 
    -0.05578049f, -0.00524855f, 0.00214589f, 0.02897683f, -0.01576965f, -0.03293060f, -0.01136436f, 0.05228388f, 
    0.01631367f, 0.02921101f, 0.02053053f, 0.04475935f, 0.02305994f, 0.02143788f, -0.03077260f, -0.05961015f, 
    0.03840397f, 0.04950278f, 0.02580557f, 0.03341216f, -0.03899873f, 0.05040786f, 0.01810175f, 0.04692614f, 
    0.01384779f, -0.07161843f, 0.03581109f, 0.04437964f, -0.06910445f, -0.02573017f, -0.05271954f, -0.04760722f, 
    0.01403513f, 0.02848170f, -0.00118939f, 0.02730653f, -0.05847804f, 0.00656494f, -0.01438102f, -0.06130925f, 
    -0.06828213f, 0.02913809f, 0.02670426f, -0.04130375f, -0.01583255f, -0.07512412f, -0.06758912f, 0.00360280f, 
    -0.03568936f, 0.01042080f, -0.03020040f, 0.01139164f, 0.06237865f, -0.00563337f, 0.06330395f, 0.05390530f, 
    -0.04306983f, -0.04219323f, 0.01197600f, -0.07677385f, -0.01569469f, -0.03504986f, -0.02758103f, -0.05413778f, 
    0.02946128f, -0.07012940f, -0.00524412f, -0.06725815f, 0.00243711f, 0.05942014f, -0.00414080f, -0.01030104f, 
    -0.76998329f, 0.35769993f, -0.34970343f, 0.40878642f, -0.07135101f, -0.15120535f, 0.04359369f, -0.04727115f, 
    0.05902017f, 0.09903497f, -0.04019018f, 0.20042318f, 0.05438342f, -0.45307112f, 0.41884935f, -0.35846081f, 
    -0.06807438f, -0.05490023f, -0.07296789f, -0.26012716f, 0.21225809f, 0.27131239f, 0.12677421f, 0.12324496f, 
    -0.14353527f, 0.04271936f, 0.26118988f, 0.08572206f, -0.09888119f, 0.01823335f, -0.02738172f, -0.14109291f, 
    -0.26577449f, -0.16213380f, -0.09385746f, -0.22687876f, 0.01609615f, 0.05903991f, 0.35162130f, 0.04416791f, 
    -0.08874607f, 0.12292862f, -0.12393799f, -0.12892704f, 0.08438727f, 0.13144469f, -0.02881694f, -0.01195830f, 
    -0.44636840f, -0.31455344f, 0.01897281f, 0.16604316f, 0.04343503f, -0.00594580f, -0.17819676f, 0.22808616f, 
    0.24670842f, 0.08394839f, 0.05521868f, 0.05496741f, 0.10087653f, 0.14701164f, 0.57523119f, 0.02447126f, 
    0.05429836f, -0.03912521f, -0.20113666f, -0.03648502f, -0.05665435f, -0.15873392f, 0.15462208f, -0.11714804f, 
    0.12779708f, 0.21572338f, 0.08246657f, -0.13729618f, -0.15720780f, 0.03683715f, -0.04688621f, 0.19228822f, 
    0.19598375f, 0.14310521f, 0.08136386f, 0.08122522f, 0.17574809f, 0.01594252f, 0.04486772f, -0.07232025f, 
    0.41233152f, 0.13746950f, 0.10182947f, 0.13241634f, -0.00113568f, -0.15117432f, -0.00487213f, 0.05521531f, 
    -0.35910940f, -0.03766911f, 0.07924115f, 0.12738818f, -0.13286945f, 0.00534792f, 0.09352537f, -0.00718005f, 
    -0.10594259f, -0.13449170f, -0.02883146f, -0.21066615f, 0.15361814f, -0.10483637f, 0.14036804f, -0.01196855f, 
    -0.13716160f, 0.17402515f, -0.02777650f, 0.02234638f, 0.05667982f, -0.03415753f, 0.17001025f, 0.18047231f, 
    0.08306517f, -0.18782187f, 0.07738434f, -0.37186113f, -0.07617537f, 0.03381636f, -0.31196126f, -0.24250458f, 
    0.14010860f, 0.25610858f, 0.17653029f, 0.19755818f, 0.12619235f, 0.48665777f, -0.19512407f, -0.19298621f, 
    0.06514236f, 0.06930690f, -0.24489699f, 0.30133733f, 0.03779937f, 0.03325630f, -0.01279392f, -0.04546960f, 
    0.25585181f, 0.00172775f, 0.12668385f, -0.16118455f, -0.16464576f, -0.05556555f, -0.09366687f, -0.14811613f, 
    0.02261942f, -0.09967920f, -0.04384573f, 0.00055789f, 0.16761965f, 0.15419041f, -0.26118723f, -0.09546167f, 
    0.34138539f, -0.01775851f, 0.30713007f, 0.01999460f, 0.13109317f, -0.10906197f, -0.09222364f, 0.00568499f, 
    0.36707085f, 0.51669538f, 0.09203931f, -0.34096199f, 0.22283238f, 0.09483861f, -0.03944342f, 0.28586560f, 
    0.05743070f, -0.13188361f, -0.09795142f, 0.12555707f, -0.03956145f, -0.16570680f, -0.25080740f, -0.09536809f, 
    0.09598205f, 0.11714231f, -0.05136200f, 0.08827767f, 0.13647750f, 0.13916892f, 0.07918462f, -0.07784227f, 
    0.46655029f, 0.44368210f, -0.52355236f, -0.14728780f, 0.06768463f, -0.03768983f, 0.19769381f, -0.36756650f, 
    -0.11577351f, -0.09494013f, 0.12540406f, 0.15580156f, 0.12400638f, -0.08786415f, 0.42528293f, -0.27862573f, 
    0.19124907f, -0.33999619f, -0.11427911f, -0.30163306f, -0.13503554f, -0.21824142f, -0.02491426f, 0.02793571f, 
    -0.15249443f, -0.07521017f, -0.22763048f, -0.23962674f, -0.03070433f, 0.09749798f, -0.02487690f, 0.20348381f, 
    0.33574283f, 0.30373055f, 0.16126284f, 0.22490585f, 0.07972100f, -0.27075547f, 0.13384487f, -0.13850334f, 
    0.11218476f, 0.11087897f, -0.12789892f, 0.00266966f, 0.02360695f, -0.14136279f, -0.21113974f, 0.23323467f, 
    -0.16230819f, 0.32499319f, 0.13848846f, -0.13893060f, 0.07276217f, -0.22888739f, 0.14935887f, 0.37754452f, 
    -0.10885625f, -0.15078105f, -0.28925192f, -0.02870340f, -0.10547896f, 0.27292022f, -0.18038113f, 0.13408475f, 
    -0.16262764f, -0.13642608f, 0.01014156f, 0.02754742f, 0.25323209f, -0.05661085f, -0.01323984f, -0.05717895f, 
    0.29368624f, -0.01062524f, 0.02647368f, 0.30305734f, -0.14024590f, -0.00863641f, 0.16971134f, 0.19266385f, 
    -0.11088008f, 0.07367150f, -0.31928840f, -0.12881671f, -0.03639537f, -0.25456810f, 0.08190551f, 0.37468043f, 
    -0.09890740f, -0.06089642f, 0.13774155f, 0.15593217f, 0.10609942f, 0.14378025f, 0.02400680f, -0.10399897f, 
    -0.09927983f, 0.23948374f, 0.31842104f, -0.08980946f, 0.11618032f, -0.13896358f, 0.11085383f, -0.00914522f, 
    0.05893417f, 0.27361032f, 0.14532247f, 0.19661492f, -0.10158487f, -0.24736449f, 0.07307598f, -0.13804798f, 
    0.03271430f, -0.05480034f, -0.17691180f, -0.01748269f, -0.17298912f, -0.06110629f, 0.09549829f, -0.14844297f, 
    0.15412652f, 0.05374394f, 0.14542064f, -0.30865777f, 0.04390716f, 0.10638191f, -0.00421992f, -0.42202875f, 
    -0.14707756f, -0.04425354f, -0.07062161f, -0.23693551f, -0.01854061f, -0.02769845f, 0.27375197f, 0.27577576f, 
    0.15511900f, -0.08186474f, 0.28433821f, 0.13779737f, 0.09125701f, -0.06185209f, -0.01991906f, 0.01279703f, 
    0.14443126f, 0.19807613f, 0.29985726f, 0.17775895f, -0.06251127f, 0.11817525f, -0.16634019f, 0.06064511f, 
    0.11693358f, 0.05863868f, 0.00630503f, -0.01921768f, -0.32620510f, -0.17335595f, -0.40906030f, 0.16088898f, 
    -0.05770551f, -0.12255509f, -0.07406891f, 0.15908962f, -0.04961858f, 0.09848721f, 0.15313417f, -0.08760194f, 
    -0.12954572f, -0.43065974f, -0.04336194f, 0.05575256f, 0.04644113f, -0.02893074f, -0.18457074f, 0.07183316f, 
    0.11979439f, 0.01869825f, 0.01105116f, 0.07358068f, 0.16345260f, 0.23844068f, 0.32479754f, 0.23858467f, 
    -0.06791256f, -0.11179758f, -0.11442199f, -0.22640090f, 0.09689703f, 0.11439690f, -0.03067138f, 0.16906525f, 
    0.83902496f, -0.28102365f, 0.28236198f, -0.51935911f, 0.12714864f, 0.13922894f, -0.23814227f, 0.14194329f, 
    0.29481050f, -0.18817210f, -0.08951336f, -0.08576919f, -0.03870511f, 0.24223909f, -0.34636551f, 0.14712127f, 
    0.03868656f, 0.10064986f, 0.04378406f, 0.00922767f, -0.07639101f, -0.24368776f, -0.21318321f, -0.01708323f, 
    -0.17712538f, -0.08576566f, -0.25427952f, -0.16012546f, 0.00493831f, -0.01372850f, 0.10406692f, -0.00059032f, 
    0.19249171f, 0.05064922f, -0.11284711f, 0.19517842f, -0.11373969f, 0.01016745f, -0.30525896f, -0.07404831f, 
    -0.01094059f, 0.03925427f, 0.03550455f, -0.03994645f, -0.07099802f, -0.05136350f, 0.00860608f, 0.05297814f, 
    -0.01618408f, 0.09054233f, -0.10153262f, 0.01188520f, 0.12477157f, 0.27513587f, 0.10762155f, 0.15525362f, 
    -0.03751064f, 0.03212170f, -0.14795990f, -0.09222913f, -0.14693147f, 0.20605837f, -0.25843078f, 0.03780675f, 
    0.04543772f, -0.04050417f, -0.01880079f, -0.19425550f, -0.06478076f, 0.15209752f, -0.08183388f, 0.14649832f, 
    0.04938720f, -0.05591821f, -0.29014230f, 0.16387956f, 0.19259708f, -0.00454007f, -0.06057777f, -0.06867304f, 
    -0.08174958f, 0.01234674f, -0.08664852f, -0.11853166f, 0.13356604f, 0.02577161f, -0.05759303f, 0.14508732f, 
    -0.07652811f, 0.22202590f, -0.03771804f, -0.06574839f, -0.16886483f, 0.03520431f, 0.10804513f, 0.12162828f, 
    -0.14644745f, 0.10999183f, 0.03756196f, 0.02850794f, 0.12611762f, 0.01493120f, 0.06181956f, -0.01630486f, 
    0.01309589f, 0.26853693f, 0.14799854f, 0.50555986f, -0.00528235f, -0.04416598f, -0.13516098f, 0.01309892f, 
    0.12242280f, -0.05316442f, 0.06211334f, -0.00238492f, -0.02572378f, -0.04195377f, 0.01191875f, -0.23222215f, 
    0.01663174f, 0.04591481f, -0.11053076f, 0.12723680f, -0.07288402f, 0.05835203f, -0.04470676f, 0.09355963f, 
    -0.09547082f, -0.21647005f, -0.23827527f, -0.06120938f, 0.23188582f, -0.04190863f, -0.00620022f, 0.26481405f, 
    -0.01438460f, 0.05184397f, 0.18326257f, 0.01026020f, -0.02723908f, 0.08378784f, 0.17740062f, 0.03888551f, 
    -0.10548061f, 0.08979296f, -0.09169517f, 0.22811949f, 0.05102195f, -0.04325175f, -0.01171302f, 0.00177142f, 
    0.14697163f, 0.22895648f, -0.05552991f, 0.26838574f, 0.13327643f, -0.06538808f, 0.21125689f, 0.06901078f, 
    -0.35602304f, 0.01762186f, -0.28251258f, 0.04207531f, -0.06623866f, 0.01035798f, 0.09993339f, -0.15025154f, 
    0.13071391f, -0.14436425f, -0.00202770f, 0.32148311f, -0.12046200f, -0.00265714f, 0.13110189f, -0.22531243f, 
    -0.03637617f, 0.00882529f, 0.12933406f, 0.13120121f, 0.22453529f, 0.25645328f, 0.27750483f, 0.28947541f, 
    -0.12483902f, -0.17254043f, 0.14800492f, -0.16880271f, -0.04779667f, 0.09996665f, 0.12546967f, 0.17911811f, 
    -0.25887898f, 0.45566934f, -0.24902759f, 0.25294322f, -0.09141069f, -0.07640883f, -0.02377506f, -0.18306409f, 
    0.26917297f, -0.16095389f, -0.01719052f, 0.00574709f, 0.13825795f, -0.21025029f, 0.37015432f, -0.49863994f, 
    -0.03242851f, -0.00721849f, -0.25441223f, -0.71302712f, 0.25916478f, 0.00876394f, -0.10557419f, -0.15836182f, 
    -0.16566485f, 0.01315339f, 0.11764490f, 0.01737554f, -0.09322048f, 0.10681256f, 0.20464934f, 0.02242719f, 
    -0.13681938f, 0.17054377f, -0.08807139f, 0.36654195f, -0.05955905f, 0.14164250f, 0.19330394f, 0.03377578f, 
    0.22856490f, 0.13214986f, -0.05823878f, -0.01924187f, -0.01367242f, -0.46130487f, 0.27215722f, 0.10799742f, 
    -0.96852565f, 0.30313030f, 0.55702239f, 0.48909721f, 0.13147512f, -0.07920890f, -0.02400108f, 0.11365825f, 
    -0.06672590f, 0.04153956f, -0.19947329f, -0.46363923f, 0.37496358f, 0.06663977f, 0.50195271f, 0.08965708f, 
    -0.29840940f, 0.06363006f, -0.20777416f, -0.14201716f, -0.09273551f, -0.01836378f, 0.17055331f, 0.27174950f, 
    0.13816577f, 0.29904488f, -0.05237000f, 0.11592220f, -0.09566884f, 0.23239662f, -0.00182403f, -0.05599317f, 
    0.02680065f, -0.25909796f, -0.13357712f, -0.11681117f, 0.19347553f, 0.22580613f, -0.15901239f, 0.10868435f, 
    0.08990423f, 0.10212862f, 0.14874792f, -0.16545063f, 0.04377576f, 0.08722743f, 0.04319295f, 0.09623644f, 
    -0.60797006f, 0.03401305f, 0.05141354f, 0.36217812f, -0.14877068f, -0.05697887f, -0.21869437f, -0.30810830f, 
    0.07067383f, 0.25399700f, 0.30196428f, 0.37445986f, 0.03205518f, 0.25989375f, 0.08092908f, -0.33608666f, 
    0.23203078f, 0.01639242f, -0.01756999f, -0.17067432f, -0.49385321f, -0.31315827f, -0.22024915f, -0.66928834f, 
    -0.11424477f, 0.06170885f, -0.03651204f, -0.20117030f, -0.15454130f, -0.16572404f, -0.33515126f, -0.63789165f, 
    -0.34907988f, -0.00251486f, -0.17498764f, -0.25928548f, 0.19904466f, 0.59109581f, -0.21361536f, 0.32652521f, 
    0.14996751f, -0.05417753f, 0.13575211f, 0.10153332f, 0.21185729f, 0.18644473f, 0.23750670f, 0.04091226f, 
    0.23076895f, 0.01088296f, 0.12609549f, -0.10999560f, -0.15595569f, -0.01002145f, 0.03238653f, -0.12175877f, 
    0.04348807f, 0.21067867f, 0.26741582f, 0.15723674f, 0.41712183f, 0.22036454f, 0.14289366f, -0.29185945f, 
    0.25285071f, 0.26766753f, -0.14543776f, 0.29501778f, -0.02775544f, -0.22558537f, 0.10778641f, -0.31015411f, 
    0.39404711f, 0.28902870f, -0.22099735f, -0.17974627f, 0.29899493f, 0.17828947f, 0.16768768f, 0.01784742f, 
    0.01566208f, 0.02764918f, 0.11247261f, 0.26082528f, 0.22011448f, 0.06630249f, -0.00378309f, 0.20516942f, 
    0.04157583f, -0.07565717f, 0.08586745f, 0.02988224f, 0.15277970f, 0.00707427f, 0.02378988f, 0.16138060f, 
    0.74135250f, -0.24848971f, 0.69147724f, -0.37763506f, 0.12254503f, 0.01222643f, 0.17373440f, 0.20817426f, 
    0.19648711f, 0.00264609f, -0.02760926f, 0.25057933f, -0.01811011f, 0.56443596f, -0.36617827f, 0.20759495f, 
    -0.04200249f, -0.03116243f, 0.01682208f, -0.16690141f, -0.03523669f, -0.15563500f, -0.28307509f, 0.01022151f, 
    0.11076186f, 0.25052959f, 0.10555687f, 0.05173673f, -0.15872931f, -0.10636980f, -0.33590525f, -0.27664796f, 
    0.04087152f, -0.13121946f, -0.01206153f, -0.11144222f, 0.35802892f, 0.23777241f, 0.10688992f, 0.12104089f, 
    -0.28820124f, -0.21663985f, -0.04492481f, 0.00927881f, -0.23611671f, 0.06610443f, -0.16179626f, 0.06127959f, 
    0.32232708f, 0.02958354f, 0.35445631f, -0.03525342f, -0.32599297f, 0.09334826f, -0.03809075f, 0.11362543f, 
    -0.21295238f, 0.14790718f, -0.15142606f, -0.04277496f, -0.71189326f, 0.21014598f, 0.44647586f, -0.04093722f, 
    0.28631288f, -0.25256005f, 0.00072013f, -0.02380676f, 0.07265781f, -0.22968115f, 0.06458911f, 0.10669412f, 
    -0.17173067f, -0.15277022f, 0.28190565f, -0.01164710f, -0.03160065f, 0.34397978f, 0.22256657f, 0.28937891f, 
    -0.17708386f, 0.13640298f, 0.09843460f, -0.00981265f, 0.30224317f, -0.06237562f, 0.02762585f, 0.15927346f, 
    -0.01714591f, 0.18490641f, -0.00400384f, -0.05249447f, 0.01758080f, 0.22794069f, -0.10624801f, -0.14666399f, 
    -0.11613403f, 0.15360869f, 0.29701722f, -0.30480567f, 0.05451838f, -0.10722482f, -0.26814047f, 0.03117629f, 
    0.05813219f, -0.20294090f, -0.15764034f, 0.05672876f, 0.13720393f, 0.33498672f, -0.27880287f, 0.10460386f, 
    -0.03398236f, -0.25314242f, 0.02822407f, 0.17643470f, 0.02420449f, 0.09180641f, 0.06124019f, -0.19671845f, 
    -0.12708083f, 0.03759184f, -0.07879918f, 0.08576563f, -0.06058144f, 0.28731379f, 0.28228018f, -0.03357002f, 
    -0.00657744f, -0.08499742f, -0.08095108f, 0.09251210f, 0.30394679f, -0.29156229f, 0.18604667f, -0.00633151f, 
    -0.41131133f, 0.07218172f, 0.04802699f, 0.36087778f, 0.01558625f, 0.13122205f, -0.05131555f, 0.11669937f, 
    -0.16844128f, 0.17218700f, -0.07651249f, 0.08711743f, -0.11383872f, -0.14952470f, -0.21438316f, -0.22818893f, 
    -0.08084054f, -0.18934631f, -0.16918221f, 0.21485269f, 0.17110351f, 0.07131740f, 0.08119413f, 0.13010347f, 
    -0.25815034f, 0.10261109f, -0.13076551f, 0.10139718f, -0.13557997f, 0.25699756f, -0.08572785f, -0.16625071f, 
    0.61926347f, 0.10305145f, 0.02313535f, 0.15263014f, 0.06487614f, 0.07643747f, -0.01024194f, 0.03016442f, 
    0.12503764f, 0.05778047f, -0.07742129f, -0.15794973f, 0.37579015f, -0.10292642f, 0.08419587f, 0.16194850f, 
    -0.03776906f, 0.00764353f, -0.01077304f, -0.05036318f, -0.03868265f, 0.18756182f, 0.09338605f, -0.06332890f, 
    -0.01402740f, 0.01606740f, -0.04089967f, -0.03880715f, -0.02396010f, 0.04600598f, -0.01227105f, -0.01292699f, 
    -0.06692991f, -0.07653841f, 0.04504048f, -0.06352419f, 0.01772243f, 0.04016268f, -0.04086534f, 0.02980807f, 
    -0.01786497f, 0.00487864f, 0.00678380f, -0.03795640f, -0.07119491f, -0.05457437f, 0.00746271f, 0.05871110f, 
    0.04985421f, -0.07640648f, 0.02161913f, -0.04634862f, -0.03689108f, -0.05358619f, 0.01944357f, -0.01815499f, 
    -0.04521831f, -0.00418240f, -0.03249454f, -0.04478824f, 0.01658833f, 0.01313071f, 0.00520187f, -0.02457402f, 
    -0.04329907f, 0.06289589f, -0.01061349f, 0.02663944f, -0.03818663f, 0.04615147f, 0.05983528f, 0.02327536f, 
    -0.02538796f, 0.02906454f, 0.02042834f, -0.05335325f, -0.04706450f, 0.05593359f, -0.06298891f, 0.01332100f, 
    0.00234616f, 0.04849316f, 0.01902596f, -0.00576168f, -0.06773639f, 0.05958990f, -0.06832529f, -0.00016527f, 
    -0.07458143f, -0.00293875f, 0.05246253f, -0.03818297f, -0.05759911f, 0.03072302f, -0.00350472f, -0.06231054f, 
    0.02713318f, -0.05768552f, 0.06231040f, 0.02307216f, -0.05634267f, -0.06626561f, -0.04711134f, -0.00603327f, 
    0.05834530f, 0.03340256f, -0.00878030f, 0.05985056f, -0.07314151f, -0.04683026f, 0.05763791f, -0.04660789f, 
    -0.02651668f, -0.05069130f, -0.07961752f, -0.03754655f, 0.04291080f, 0.03993416f, 0.05949125f, 0.00450011f, 
    -0.03110828f, 0.01781641f, 0.03965238f, -0.07735381f, -0.05178018f, -0.05357293f, -0.07822330f, 0.02638195f, 
    -0.00826439f, -0.05963706f, -0.01532850f, -0.04686028f, 0.04664231f, -0.03898640f, 0.06070767f, 0.03466714f, 
    0.05228330f, 0.04398387f, -0.02585705f, 0.02035825f, 0.02146084f, 0.02767972f, -0.06326032f, -0.02631053f, 
    -0.00881260f, 0.04071339f, -0.05084109f, 0.03796934f, -0.04565354f, -0.07325911f, -0.04985672f, -0.04242746f, 
    0.03354147f, -0.03339884f, -0.03832133f, 0.01477753f, 0.05481620f, 0.01771923f, -0.07672020f, -0.00457719f, 
    0.04560762f, 0.01771155f, -0.02891510f, -0.00856850f, 0.00492029f, 0.02718348f, -0.04788602f, 0.00010929f, 
    0.02415334f, 0.04790927f, -0.00894668f, 0.04179652f, -0.07566655f, -0.05160023f, -0.06110616f, -0.00434089f, 
    -0.04850378f, -0.04016302f, 0.05435478f, 0.01530565f, 0.03935814f, 0.02197085f, 0.06738529f, 0.06109289f, 
    0.03711139f, 0.01244830f, -0.01925184f, -0.06270245f, -0.04593083f, -0.07183503f, -0.01314152f, -0.04209258f, 
    0.00570308f, -0.04127377f, 0.03289275f, 0.03223093f, -0.04288686f, -0.02653511f, 0.03125545f, -0.04008124f, 
    0.05310386f, 0.00697451f, 0.01115643f, -0.02668783f, -0.03913767f, -0.00626410f, -0.07012068f, -0.07192644f, 
    0.04839789f, 0.03726269f, 0.02422703f, 0.01382893f, -0.02284143f, -0.02023568f, 0.01408245f, -0.01292925f, 
    -0.40403056f, -0.17630319f, 0.14710523f, -0.18926357f, 0.18225063f, -0.25006112f, 0.13113828f, -0.10810036f, 
    0.10893613f, -0.09977378f, -0.09808903f, -0.00087370f, 0.06298563f, 0.07032406f, 0.18520199f, -0.17809014f, 
    -0.14034049f, -0.00919387f, -0.09218053f, -0.04004414f, 0.07833061f, 0.01265936f, -0.11037172f, 0.06746181f, 
    -0.11891416f, -0.32469147f, -0.23026222f, -0.03648219f, -0.05775796f, -0.00326849f, -0.05627894f, -0.07732273f, 
    0.21305825f, 0.27859980f, 0.24039169f, 0.03470759f, 0.07524978f, -0.46414196f, -0.21875440f, 0.17115836f, 
    -0.11223879f, 0.10016962f, -0.16048051f, -0.04005182f, 0.02243852f, 0.12727895f, -0.00080575f, 0.14272077f, 
    0.48239902f, -0.11490122f, -0.25439990f, -0.11355668f, 0.08835964f, 0.06573465f, 0.05707284f, 0.09133730f, 
    -0.02075920f, 0.07668035f, -0.00203101f, -0.06354449f, -0.06936172f, -0.12119704f, 0.39503366f, -0.00751367f, 
    -0.13743787f, -0.10537924f, -0.05892447f, 0.09946320f, 0.00648279f, 0.08118282f, 0.14047945f, 0.02006590f, 
    0.44085196f, 0.12308587f, 0.11117210f, 0.13143946f, -0.47275913f, 0.29188961f, 0.07161598f, 0.15601747f, 
    0.07563881f, -0.09945765f, 0.00905242f, -0.13770561f, 0.38351572f, 0.20388952f, 0.20422621f, 0.12905200f, 
    0.06140744f, -0.07311130f, -0.12511462f, 0.16073242f, -0.00647456f, 0.02673325f, 0.04372834f, 0.08959575f, 
    -0.03435143f, -0.21567230f, 0.18943012f, -0.19685955f, -0.12229995f, -0.03381019f, 0.01061298f, 0.03030691f, 
    0.01609263f, 0.02367810f, -0.08752638f, 0.10907283f, -0.22046873f, -0.08177318f, 0.04631542f, 0.17360656f, 
    0.06286341f, 0.14646746f, 0.06879755f, -0.02295990f, 0.00923632f, -0.02685020f, -0.06858775f, 0.15281691f, 
    -0.11856704f, -0.35333097f, -0.08054654f, -0.07891451f, 0.05762069f, 0.08693139f, 0.12462473f, -0.07510217f, 
    0.05495135f, 0.08993479f, 0.11725957f, -0.01680982f, 0.51001126f, 0.32346985f, -0.00666489f, 0.12297207f, 
    -0.04471938f, 0.07884192f, 0.24862947f, 0.19376719f, -0.08117472f, -0.01547424f, 0.16459218f, 0.16908680f, 
    -0.34140801f, -0.23836659f, -0.15268324f, 0.06393734f, 0.00047523f, 0.12498367f, -0.06958622f, 0.00639954f, 
    -0.20997667f, -0.04436525f, -0.02097656f, 0.14283904f, 0.15589018f, 0.28085682f, 0.55266762f, 0.15539086f, 
    0.06311864f, -0.13871792f, 0.10390648f, -0.13192779f, -0.05371187f, -0.03358287f, -0.01036797f, -0.17795572f, 
    0.15802614f, 0.62253565f, 0.05089898f, -0.11269385f, 0.09622896f, 0.11676818f, 0.12858278f, 0.04266866f, 
    0.12531407f, 0.05939238f, 0.03910041f, 0.16331108f, -0.14421560f, 0.27900562f, -0.12439541f, -0.00889586f, 
    -0.02668429f, 0.04176391f, -0.21604328f, -0.08161376f, -0.03374062f, 0.03178702f, 0.15091565f, 0.02580640f, 
    -0.04668999f, 0.28332797f, -0.09055530f, 0.25205636f, 0.02300504f, 0.08239497f, -0.04698835f, 0.09463374f, 
    -0.05847650f, 0.18213518f, 0.21649976f, 0.25088063f, 0.12468039f, -0.35239121f, 0.08986447f, -0.13867678f, 
    0.06207389f, 0.03731855f, -0.00565043f, -0.07312591f, 0.29247800f, 0.18542509f, 0.01646719f, 0.01721241f, 
    -0.24654081f, 0.06359398f, 0.00054948f, -0.05377645f, -0.03421478f, 0.04660431f, 0.10915802f, -0.21280298f, 
    -0.19875883f, -0.19645193f, -0.06802510f, -0.06549817f, 0.12404103f, 0.23968738f, 0.42428559f, -0.16256106f, 
    -0.10777039f, 0.04860651f, 0.09735983f, 0.04548537f, -0.08354864f, 0.05465065f, -0.10728292f, -0.05811661f, 
    -0.21625477f, -0.12152849f, 0.16965824f, -0.05067487f, -0.23398767f, -0.14476916f, -0.09801587f, -0.08672137f, 
    0.04418462f, -0.09312567f, -0.09837109f, 0.15092945f, 0.19839334f, 0.05574209f, 0.19633089f, -0.32725650f, 
    0.31198236f, 0.03080456f, 0.23212373f, 0.00462192f, 0.27067208f, 0.00130917f, 0.24646439f, -0.06003971f, 
    -0.12577266f, 0.04071852f, 0.17993064f, -0.17403550f, -0.15243235f, 0.16991478f, -0.06243503f, 0.17926046f, 
    -0.06352611f, 0.06673688f, 0.16246019f, 0.05556183f, 0.00713796f, -0.22070311f, 0.06273738f, -0.15632564f, 
    0.17105485f, 0.06971263f, 0.06442325f, 0.03580381f, 0.07199518f, -0.05937301f, 0.12890436f, 0.00380927f, 
    -0.30523598f, 0.09409992f, 0.14794430f, 0.10221203f, 0.01093985f, 0.03127063f, -0.04823815f, 0.16857474f, 
    -0.21102975f, 0.10657141f, 0.05953323f, -0.16240324f, 0.09888874f, 0.03871465f, -0.12176424f, -0.13079081f, 
    -0.07594448f, -0.03018083f, -0.07107164f, -0.03392097f, 0.00283886f, 0.15804136f, 0.02351739f, -0.07514767f, 
    -0.14533795f, 0.09010511f, 0.01654308f, -0.11662581f, 0.06132907f, 0.20693459f, -0.00168777f, -0.09643739f, 
    0.11821831f, 0.19946475f, 0.29857251f, 0.11584608f, -0.03335579f, -0.18285726f, -0.24435507f, -0.19421214f, 
    -0.09415340f, 0.03748237f, -0.15852453f, 0.31409332f, 0.08272298f, 0.10380928f, -0.06186903f, -0.04372236f, 
    -0.08993485f, 0.24505918f, -0.02230460f, -0.21394785f, -0.10280567f, -0.15006112f, -0.09146348f, -0.16890563f, 
    0.11482116f, 0.10841299f, 0.02922622f, 0.12858902f, 0.30964211f, -0.22902329f, -0.30325937f, 0.07411090f, 
    0.13659582f, -0.38893119f, 0.09650469f, -0.14848676f, -0.01346786f, -0.01982360f, 0.05862322f, 0.10408028f, 
    0.55907226f, 0.27161455f, 0.05511075f, -0.16436563f, 0.05579033f, 0.02645412f, -0.09276868f, 0.13629048f, 
    0.01811979f, -0.04634571f, -0.13442081f, -0.08794393f, 0.06383801f, -0.27076912f, -0.05327451f, 0.07779829f, 
    -0.04514237f, 0.29360667f, 0.14716707f, 0.08456697f, 0.07798924f, -0.00612027f, -0.00587491f, -0.10053121f, 
    0.02813620f, 0.04167622f, -0.00846970f, -0.06670972f, 0.00653846f, -0.05825499f, -0.02012732f, 0.06608809f, 
    0.03102972f, -0.02448774f, 0.00478297f, -0.04330466f, -0.01526633f, 0.05212183f, -0.01460602f, 0.04578933f, 
    0.06178551f, -0.04911955f, -0.03438127f, -0.01516100f, 0.01412195f, -0.01993609f, 0.04064220f, 0.03365453f, 
    -0.00335119f, -0.04772353f, 0.00592942f, -0.00867054f, 0.05497673f, 0.01602674f, -0.06681863f, -0.00538366f, 
    0.02723894f, -0.02720874f, 0.03762652f, -0.00449072f, -0.06945185f, 0.05471411f, 0.02916345f, -0.00765969f, 
    -0.06626005f, -0.01163965f, -0.01126706f, 0.05507756f, -0.07345565f, 0.00840372f, 0.03406528f, -0.04580889f, 
    -0.04084325f, -0.01827266f, 0.03484314f, 0.00782935f, 0.04009834f, -0.06589579f, 0.03495644f, 0.03665461f, 
    -0.02232197f, 0.00218360f, -0.06137188f, -0.01113281f, 0.03344449f, -0.00133416f, -0.05203053f, -0.03536854f, 
    -0.02465206f, -0.05870881f, 0.04857961f, 0.05848982f, -0.04293678f, 0.00568182f, -0.05498791f, -0.00795194f, 
    0.00070570f, -0.06547897f, -0.07764243f, -0.05077601f, 0.06038318f, -0.03730079f, 0.05300874f, 0.02247041f, 
    0.02200900f, -0.07180820f, -0.05213617f, 0.00714353f, -0.03182172f, -0.00295094f, 0.05250292f, -0.01909773f, 
    -0.03482647f, 0.01231102f, 0.04762944f, -0.01914934f, 0.02201346f, -0.07081894f, 0.05228768f, -0.01340593f, 
    0.05855099f, 0.00209229f, -0.07261373f, 0.03824890f, -0.07386934f, -0.02805741f, -0.07553172f, -0.01537845f, 
    0.05403694f, 0.04446597f, -0.00471784f, -0.03713545f, -0.00342226f, 0.01666915f, -0.00671075f, 0.01354752f, 
    -0.04192125f, -0.03525984f, 0.04586241f, 0.00812342f, -0.00713672f, -0.02447752f, -0.02420782f, 0.03141372f, 
    -0.02877903f, -0.02435852f, 0.00789489f, -0.06639875f, 0.01753254f, -0.00086675f, -0.04964608f, -0.02830100f, 
    -0.05225363f, 0.03344882f, 0.05567462f, 0.01931472f, -0.06132994f, -0.06610589f, -0.02021393f, -0.03717490f, 
    -0.03035014f, 0.00309970f, -0.03371102f, -0.01397487f, 0.02720327f, 0.03613650f, -0.00938341f, 0.04960600f, 
    -0.03140005f, 0.04824030f, -0.04275778f, -0.04861019f, -0.04101997f, 0.06548466f, -0.04311661f, -0.01956649f, 
    -0.01111065f, -0.04836657f, 0.02959770f, -0.01085525f, 0.00715216f, 0.03549039f, -0.01372032f, -0.01734786f, 
    -0.03354837f, -0.04377160f, -0.04874796f, -0.06217955f, -0.01266470f, 0.02351782f, 0.03010695f, 0.03745815f, 
    0.04854674f, -0.02288762f, -0.04805793f, 0.03850396f, 0.03664956f, -0.01467094f, -0.03330500f, 0.04086157f, 
    -0.02589957f, 0.05898081f, -0.05322281f, -0.06974042f, 0.02964578f, -0.06770379f, 0.04138089f, 0.02042536f, 
    -0.04936408f, -0.00123835f, -0.01006917f, -0.01434621f, -0.06519084f, -0.03626063f, -0.06662994f, 0.06386708f, 
    -0.61224169f, 0.25148642f, 0.10787204f, 0.23744063f, -0.20602767f, -0.21835333f, -0.07220176f, -0.00983301f, 
    0.13633153f, 0.05168270f, 0.12992407f, -0.02411250f, -0.17883264f, 0.20336853f, -0.03777510f, -0.03524250f, 
    -0.11553246f, -0.13954535f, -0.03329741f, -0.18309982f, -0.07860256f, 0.16474742f, 0.15312165f, 0.30026594f, 
    -0.29994538f, -0.19888628f, -0.03744093f, 0.11748917f, 0.06234924f, -0.00199368f, -0.27000597f, -0.06986368f, 
    -0.08228248f, -0.18152393f, -0.00802755f, -0.28452951f, -0.13783355f, -0.22593811f, -0.13980402f, 0.01984245f, 
    0.00326532f, -0.13104782f, -0.07722060f, -0.13695794f, -0.03247419f, 0.15589902f, -0.04372878f, 0.19521864f, 
    -0.24941646f, -0.41087642f, 0.04970630f, -0.06606393f, 0.21186365f, 0.14055508f, -0.12370501f, -0.02466650f, 
    -0.08395561f, -0.13181812f, 0.18840745f, -0.01389123f, -0.33872369f, 0.37931678f, -0.08153548f, -0.04029621f, 
    -0.08139430f, -0.30572075f, -0.03030766f, 0.17628747f, 0.09389357f, 0.01937594f, -0.19169547f, -0.06662641f, 
    0.43343645f, -0.25093997f, -0.48229113f, -0.05980757f, 0.26955158f, 0.23809372f, 0.05941046f, 0.24881089f, 
    -0.00636940f, 0.20003821f, 0.08514710f, 0.21772757f, 0.12498821f, 0.31320232f, -0.26252273f, -0.03027021f, 
    0.15908664f, 0.17172520f, 0.21347538f, 0.23501290f, 0.14877622f, -0.03403444f, 0.04846884f, -0.05570070f, 
    0.22150736f, 0.14926448f, 0.02723410f, 0.20933208f, 0.07042720f, 0.09044826f, 0.08223098f, 0.06660217f, 
    -0.01864841f, -0.09916018f, -0.31737202f, -0.20627777f, -0.22915797f, -0.46811661f, 0.16342896f, 0.17199157f, 
    -0.05809371f, 0.02904878f, -0.10476787f, -0.11259559f, 0.26058811f, 0.05652898f, 0.18326044f, 0.43447292f, 
    0.00419193f, 0.05486371f, 0.23560351f, 0.10635043f, -0.11212108f, -0.03216498f, -0.13041586f, 0.03371996f, 
    0.45603558f, 0.21514580f, 0.06834906f, 0.10991920f, 0.32451272f, -0.03678020f, 0.29041919f, -0.35219115f, 
    -0.17297815f, -0.03780235f, 0.25899038f, 0.21835952f, 0.10957912f, -0.07851173f, -0.06431273f, 0.17398094f, 
    -0.10983051f, 0.05312607f, 0.23883839f, 0.33820188f, -0.06544389f, 0.08665938f, -0.16895600f, -0.00163550f, 
    -0.05495646f, 0.00053693f, 0.04444043f, 0.00600310f, -0.36753190f, 0.58255732f, -0.31123137f, 0.00660571f, 
    0.07412596f, 0.10125842f, 0.54933441f, 0.25922802f, 0.08164376f, 0.19029567f, 0.12866460f, 0.18522157f, 
    0.03034475f, 0.21423976f, 0.02368943f, -0.31579655f, 0.20232114f, 0.08683711f, -0.17680477f, 0.04632854f, 
    0.02943597f, -0.01382560f, 0.08278622f, 0.17068787f, 0.26061022f, 0.01122114f, -0.05307353f, -0.08140405f, 
    0.17415778f, 0.08947897f, -0.03456947f, 0.09180582f, -0.06366807f, 0.00542378f, 0.13248570f, -0.04829727f, 
    0.18853506f, 0.11361574f, -0.19892536f, 0.10986125f, 0.20174427f, 0.08463705f, -0.09851410f, 0.06030689f, 
    0.20532444f, -0.02187306f, 0.15737629f, 0.16947407f, 0.21764323f, -0.17438090f, 0.00824965f, 0.17132035f, 
    -0.13050039f, -0.07877626f, -0.01526776f, 0.16435739f, 0.05364889f, 0.03475679f, -0.18801408f, -0.03082492f, 
    0.01500726f, 0.01699633f, 0.08938014f, 0.18970394f, -0.09319719f, -0.06089050f, -0.03011991f, -0.06341526f, 
    0.18154663f, 0.03510983f, 0.24101235f, 0.16971298f, 0.37813058f, -0.06931453f, 0.19286712f, 0.08795734f, 
    -0.04103842f, -0.09900755f, -0.00507509f, 0.06121669f, -0.04358024f, -0.06602158f, -0.03142852f, 0.07594965f, 
    0.35165405f, 0.00293631f, -0.06312676f, -0.23498251f, -0.05968332f, -0.16264486f, -0.02226625f, -0.23157768f, 
    -0.08082286f, -0.09607587f, -0.11530981f, -0.08796530f, -0.88861930f, -0.05122804f, 0.03758460f, -0.11606260f, 
    0.16378975f, 0.24353361f, -0.06758813f, -0.15967037f, 0.33068264f, 0.07837956f, 0.11527127f, 0.18812715f, 
    0.02913442f, -0.09486544f, -0.19169231f, -0.34057981f, 0.12783776f, 0.01623470f, -0.16874811f, 0.29451174f, 
    -0.06127859f, 0.05512457f, 0.15371761f, -0.05541165f, 0.33467287f, -0.06293806f, 0.63812810f, 0.27730939f, 
    0.09087455f, 0.14388627f, 0.09044798f, 0.16008377f, -0.00023086f, 0.00653171f, 0.12333450f, -0.14350301f, 
    0.44408590f, 0.30227521f, 0.18768170f, -0.17136037f, 0.04274916f, 0.06080182f, -0.03216670f, 0.06286816f, 
    0.34435141f, -0.06617103f, 0.05205067f, 0.09657388f, 0.10645878f, -0.04099043f, -0.03241655f, 0.28962094f, 
    0.10303777f, -0.15891048f, -0.08122439f, 0.06894413f, -0.03332576f, -0.07602113f, -0.03252067f, -0.10584112f, 
    0.10555111f, 0.07834312f, 0.21273038f, -0.04672112f, -0.03348015f, 0.21831852f, 0.07206895f, 0.04404227f, 
    0.04796244f, -0.06259224f, 0.11330589f, -0.14867304f, -0.07511847f, -0.40103790f, -0.31294248f, 0.00112731f, 
    -0.09968843f, -0.28631732f, -0.35785356f, 0.10857882f, -0.08276619f, -0.15145944f, -0.08465645f, 0.18622129f, 
    0.20975928f, -0.14064348f, 0.25565845f, 0.10417239f, -0.14933261f, -0.09333830f, -0.06541191f, -0.03901302f, 
    0.30117819f, -0.20775010f, -0.21493007f, 0.26865903f, -0.53318018f, -0.18963802f, -0.58162147f, 0.13530004f, 
    -0.15110156f, -0.03558210f, 0.34647736f, -0.04838074f, -0.27311346f, -0.03071977f, -0.04735535f, -0.08455553f, 
    0.28064331f, 0.06761670f, 0.55023479f, -0.04059592f, -0.03461578f, -0.19005637f, -0.12264128f, 0.07870906f, 
    -0.02927077f, -0.07626672f, -0.19668327f, 0.04468795f, 0.21246873f, -0.06891758f, 0.24651411f, -0.10538224f, 
    0.05848422f, 0.23737830f, -0.00807116f, -0.02739078f, 0.04019432f, 0.04553997f, 0.15744586f, 0.00697717f, 
    -0.01491344f, -0.03253672f, -0.04886749f, 0.03269482f, -0.03188111f, -0.01509850f, -0.00205279f, -0.01993077f, 
    -0.06904473f, 0.05963562f, -0.01268501f, -0.04601120f, -0.02772948f, -0.01669761f, -0.00148613f, -0.02387300f, 
    -0.03473682f, -0.02521296f, 0.02240353f, -0.03502301f, -0.06683381f, -0.04353607f, 0.03224724f, -0.03728445f, 
    -0.03967402f, 0.00533239f, -0.01327424f, 0.02974587f, -0.01860040f, -0.03317377f, -0.02968534f, -0.05776119f, 
    0.04617362f, 0.06022799f, -0.06625909f, 0.00123071f, -0.05282078f, -0.04701634f, -0.00256936f, -0.06052724f, 
    0.04259813f, -0.04723285f, -0.01776642f, 0.01789202f, -0.05183164f, 0.00202906f, 0.03100584f, -0.07185350f, 
    0.02607463f, -0.06245440f, 0.03551276f, 0.00127777f, -0.02939394f, -0.00020235f, -0.05724088f, 0.05318414f, 
    -0.01715892f, -0.01342404f, 0.01368700f, -0.06778666f, 0.00685224f, -0.03343847f, -0.03636301f, 0.03412417f, 
    0.03116921f, -0.03246733f, -0.04971953f, 0.05859369f, 0.02199695f, -0.06584792f, 0.04668130f, 0.02402349f, 
    0.04545121f, 0.05513579f, 0.06384974f, -0.06685828f, -0.04440897f, 0.03696104f, 0.00100984f, -0.05368983f, 
    -0.06182325f, -0.06554513f, 0.00293703f, 0.02648412f, -0.06809717f, -0.04212446f, 0.04316521f, -0.07075898f, 
    -0.05552040f, 0.00656256f, -0.05460755f, -0.05366803f, 0.03050325f, 0.00700900f, -0.02937788f, -0.01497275f, 
    -0.00486446f, -0.02924942f, -0.03959106f, 0.05680379f, 0.05134333f, 0.01122944f, 0.06252174f, 0.05771172f, 
    -0.00981468f, -0.06344623f, -0.05251844f, 0.03638030f, 0.06151614f, -0.03082150f, -0.01153609f, -0.03779841f, 
    0.04161804f, 0.04152999f, 0.03874798f, -0.01018515f, -0.05192170f, 0.00677090f, 0.00886642f, -0.00754587f, 
    -0.02639759f, -0.00607609f, 0.04223423f, 0.01348960f, -0.07255457f, 0.00924482f, -0.03188028f, -0.04077461f, 
    -0.05283380f, 0.03229297f, 0.00474159f, 0.03841934f, 0.01033226f, 0.04679445f, -0.03534437f, -0.07198630f, 
    -0.05302092f, -0.06801717f, -0.02006380f, -0.04648314f, -0.00505957f, -0.01214047f, -0.03253810f, 0.01704237f, 
    -0.01582380f, 0.03801867f, -0.03687342f, -0.06061285f, 0.06190289f, -0.05623751f, 0.05294954f, -0.04695031f, 
    -0.00153152f, 0.06027601f, -0.07028913f, -0.02469059f, -0.03799507f, -0.06577243f, -0.06840345f, -0.04766219f, 
    -0.06667034f, 0.00477163f, -0.04705266f, 0.02567570f, 0.03863899f, -0.04270503f, -0.05256763f, 0.00264812f, 
    0.02744287f, -0.06080254f, 0.00641613f, 0.05590172f, -0.04572327f, -0.06940755f, 0.02028878f, -0.00064119f, 
    0.00786192f, -0.03239320f, -0.04972718f, 0.01536371f, 0.00613106f, 0.01512224f, 0.03228806f, -0.05237297f, 
    -0.00224178f, -0.01671879f, 0.03471922f, -0.02375450f, 0.05322738f, 0.02784631f, 0.05682044f, -0.04173506f, 
    0.00011988f, -0.03236437f, -0.05765967f, 0.05445840f, 0.06636477f, -0.00738904f, -0.04872489f, -0.01247173f, 
    -0.00658912f, -0.05884075f, -0.02287926f, 0.00553782f, -0.03566796f, 0.05796508f, 0.05260477f, 0.02668491f, 
    -0.01285044f, 0.02511583f, -0.01122755f, -0.06428273f, -0.03883768f, -0.00976047f, -0.00453362f, -0.01944718f, 
    -0.03506161f, 0.04612995f, -0.01941475f, 0.05595376f, -0.00537068f, 0.00500352f, -0.01380646f, -0.07121379f, 
    -0.04615340f, 0.00173927f, 0.02795466f, -0.03757335f, 0.04674531f, 0.00389726f, 0.03245195f, 0.02755309f, 
    -0.00519750f, -0.01603225f, 0.01080207f, 0.01093958f, 0.01221561f, -0.02630013f, -0.03470469f, 0.01943718f, 
    -0.04495902f, 0.01551712f, -0.06450811f, -0.05113399f, -0.02192261f, -0.06538098f, -0.03765487f, -0.07769033f, 
    0.01393462f, -0.07256272f, 0.04025428f, -0.01252331f, 0.05555676f, 0.04503612f, -0.07344936f, 0.04337143f, 
    -0.04075548f, 0.01388064f, -0.06128408f, -0.00989351f, -0.02846092f, 0.01508440f, -0.01712934f, -0.00863870f, 
    0.01348733f, 0.00474224f, -0.06694904f, -0.04538527f, -0.02231044f, -0.03847830f, -0.00664088f, -0.06409575f, 
    -0.03769692f, -0.03716464f, -0.04184285f, -0.02333266f, 0.02870218f, 0.04290473f, -0.03526825f, -0.00892686f, 
    -0.03019564f, -0.03297745f, 0.05245495f, 0.02552410f, -0.02782265f, -0.07304046f, -0.00972499f, -0.03800429f, 
    -0.05423602f, 0.01119443f, 0.06714095f, -0.01653544f, -0.06640354f, -0.04074788f, -0.05563180f, 0.03178816f, 
    0.03506069f, -0.05807895f, 0.04468779f, 0.02492327f, -0.01479404f, 0.00222388f, 0.03031017f, -0.01064875f, 
    -0.01700827f, -0.02633408f, -0.00319619f, -0.07557326f, 0.01301560f, 0.03857395f, -0.00306998f, -0.04729836f, 
    -0.03261767f, -0.00520438f, 0.01642108f, 0.03653332f, 0.03331013f, -0.02379991f, 0.05513965f, -0.02333367f, 
    -0.00235420f, -0.04225395f, -0.04452163f, 0.05234752f, -0.07058883f, -0.04590045f, -0.03200946f, -0.06994458f, 
    0.06579186f, 0.01788811f, -0.03145872f, 0.05314914f, -0.01207175f, 0.05342538f, 0.03118703f, -0.06716262f, 
    -0.06208885f, -0.03916799f, 0.00510071f, 0.03047008f, -0.04567449f, 0.05404026f, -0.01965363f, -0.03708015f, 
    0.04380469f, -0.01068428f, -0.02737836f, -0.07646430f, -0.03762299f, 0.05607083f, -0.05134642f, 0.00737020f, 
    -0.00418435f, -0.06820650f, -0.07113010f, 0.05754739f, 0.03531382f, 0.02947967f, 0.02633443f, -0.05170169f, 
    -0.05101827f, 0.02795464f, -0.03269448f, 0.04320496f, -0.07329449f, 0.03736858f, 0.03629098f, -0.02790990f, 
    -0.05530838f, -0.04257239f, 0.03897209f, 0.00653472f, 0.01200480f, 0.05044780f, -0.04210998f, -0.03278790f, 
    -0.01815512f, 0.05297308f, 0.01650595f, -0.04088119f, -0.02383934f, 0.00142405f, 0.05010431f, -0.02090952f, 
    0.02634640f, -0.31830761f, 0.72352046f, -0.17272143f, 0.01432588f, 0.24388488f, 0.37769702f, 0.20219555f, 
    0.04825023f, 0.37186348f, -0.02504629f, 0.09342656f, -0.13669524f, 0.50746906f, -0.41026020f, 0.38882822f, 
    -0.12753348f, 0.00881361f, 0.04130528f, 0.22726284f, -0.04997736f, 0.02216146f, 0.34301576f, -0.12882845f, 
    0.35483426f, 0.19452518f, -0.26251131f, -0.26636124f, -0.12174101f, -0.32695794f, -0.13071479f, 0.02783082f, 
    -0.23569639f, -0.15888114f, -0.15879525f, -0.25216794f, 0.20761049f, 0.12380260f, -0.19186194f, 0.07325052f, 
    -0.36947751f, -0.18993986f, 0.18100853f, 0.24267362f, 0.00851691f, 0.00996896f, 0.01048077f, -0.20880002f, 
    0.49541089f, -0.03259848f, -0.18737133f, -0.33501619f, -0.13286383f, -0.10697479f, 0.17854764f, 0.01676187f, 
    -0.03196494f, 0.07414863f, 0.04881729f, 0.12306811f, 0.14772333f, -0.00347305f, -0.10509543f, 0.24345043f, 
    0.20075788f, 0.19237866f, 0.34843573f, 0.14323559f, -0.09605590f, 0.01368102f, 0.18790226f, -0.02124833f, 
    -0.20103869f, -0.06442375f, 0.26059541f, 0.18322453f, -0.03567062f, 0.00620552f, 0.45412946f, 0.04742160f, 
    0.16735081f, -0.10292953f, -0.04144384f, 0.29845190f, -0.22490305f, 0.20789483f, -0.00888044f, -0.12052694f, 
    -0.09975550f, 0.00267294f, 0.04418931f, 0.25164723f, 0.11181030f, 0.10273308f, -0.12715074f, -0.07199033f, 
    0.56144887f, 0.04926299f, 0.02565423f, -0.04482497f, -0.09143380f, -0.17622650f, 0.04806294f, 0.06192767f, 
    0.02594544f, -0.23933737f, -0.13741282f, -0.24207623f, -0.09722403f, 0.04524379f, -0.23596799f, -0.01472554f, 
    -0.16548726f, 0.08038191f, 0.05101708f, 0.11394879f, 0.45768750f, -0.02597792f, -0.11320285f, 0.01623971f, 
    -0.19567658f, -0.18383253f, -0.17099670f, 0.17791483f, -0.31861165f, -0.13361217f, 0.23585910f, -0.02432764f, 
    0.12686439f, 0.13560507f, 0.12102159f, 0.05330267f, -0.31912675f, -0.51596069f, 0.43651065f, 0.15302715f, 
    -0.10400257f, 0.29316264f, 0.19022875f, -0.06937706f, -0.01961615f, -0.01310107f, 0.07607759f, 0.17118931f, 
    -0.17026238f, -0.11021198f, 0.04063431f, -0.04159876f, -0.05158903f, -0.05775855f, -0.21257733f, -0.25147712f, 
    0.15600443f, -0.27898541f, 0.17268120f, 0.01064859f, -0.14764500f, 0.30034387f, 0.22501101f, 0.22810932f, 
    0.07755218f, 0.25965211f, 0.17686592f, 0.04757241f, -0.17413996f, 0.16141914f, -0.15421261f, 0.17242105f, 
    -0.42937142f, -0.24472511f, -0.06016773f, 0.23679014f, -0.10415556f, 0.02181169f, 0.03523995f, 0.10923114f, 
    -0.03666722f, 0.02960113f, -0.00394312f, -0.23098408f, -0.03199691f, 0.06682862f, -0.19067861f, -0.32446817f, 
    0.08467707f, -0.08289047f, 0.17282574f, 0.27058959f, -0.09912957f, 0.00557203f, -0.09989266f, -0.17264877f, 
    0.66299188f, 0.01493684f, 0.05379364f, 0.40077198f, 0.17425039f, -0.06987345f, 0.09718299f, -0.07275777f, 
    -0.02538676f, 0.37678170f, -0.18446465f, 0.00914553f, -0.14292747f, 0.01347267f, -0.16963202f, -0.25481302f, 
    -0.05736267f, 0.02101311f, -0.02339020f, 0.18956129f, 0.12924203f, 0.22967696f, -0.18445294f, -0.00704472f, 
    0.04577853f, 0.16347349f, -0.02640802f, 0.09114283f, -0.20882462f, -0.18188141f, -0.10501300f, 0.04433035f, 
    0.01325594f, 0.20446035f, 0.08527051f, -0.04451834f, 0.11067057f, 0.20548615f, 0.04821184f, -0.13051984f, 
    -0.15397583f, -0.13218971f, -0.25954321f, 0.03657541f, 0.04606020f, -0.06095314f, 0.07463363f, 0.05404699f, 
    -0.07009465f, 0.07884492f, 0.14638191f, 0.23521289f, 0.08800876f, -0.10354593f, -0.18029623f, 0.05539946f, 
    0.04659622f, 0.07684913f, 0.09292476f, 0.06847885f, -0.09403782f, -0.37149993f, 0.37305397f, 0.15246065f, 
    -0.09832182f, 0.07284463f, -0.14728734f, -0.04503951f, -0.14640747f, 0.04578245f, 0.05761731f, -0.05067366f, 
    -0.09151129f, 0.14198975f, 0.81867200f, 0.15138508f, 0.24059756f, -0.03576092f, 0.15889072f, 0.11104679f, 
    0.11270405f, -0.02498664f, -0.02296624f, -0.14779148f, -0.23721038f, -0.24183443f, 0.13420458f, 0.16770248f, 
    0.09181543f, -0.02211648f, 0.07432137f, -0.03330380f, 0.14409386f, 0.13413388f, -0.04711443f, 0.02876353f, 
    0.08938274f, -0.12899642f, -0.14331360f, 0.07867973f, -0.06000314f, -0.00736887f, -0.10536446f, -0.06364369f, 
    0.13669606f, -0.18583317f, 0.16158096f, -0.06213456f, 0.17153628f, 0.36823413f, -0.20884375f, -0.26130518f, 
    -0.15063488f, -0.15204027f, 0.09839699f, 0.08944201f, -0.01275991f, -0.22168635f, -0.07605807f, 0.05559595f, 
    -0.28982431f, -0.23347522f, -0.25142747f, -0.18247494f, -0.08473466f, 0.17385446f, -0.10117396f, -0.12844242f, 
    0.04929884f, 0.22156928f, 0.16891466f, 0.24865723f, -0.05080744f, 0.24957857f, 0.41071010f, 0.05866694f, 
    0.10246415f, -0.03083150f, 0.03987622f, -0.01429225f, 0.05141788f, -0.17145061f, 0.24033347f, 0.23422247f, 
    0.17098315f, 0.01293035f, -0.27674705f, -0.44865641f, -0.05372333f, -0.01857305f, 0.07420205f, -0.06900629f, 
    -0.14318389f, -0.19847167f, -0.04298079f, -0.02877925f, -0.01464817f, -0.15894996f, 0.07692139f, 0.20088288f, 
    0.09691126f, 0.28002152f, 0.08119667f, -0.00328880f, 0.03289052f, -0.02285468f, -0.10875891f, 0.15000390f, 
    -0.31360710f, 0.03801111f, 0.22182678f, 0.09355047f, 0.07949176f, -0.07909183f, 0.12266731f, 0.14426057f, 
    -0.06819829f, 0.08855736f, -0.07609333f, 0.05489933f, 0.13674228f, -0.15482250f, 0.10684016f, 0.13204086f, 
    0.26826227f, -0.11317798f, 0.02789997f, 0.13844721f, 0.04163097f, 0.04597360f, 0.10255512f, -0.21087784f, 
    0.30204314f, 0.31508341f, -0.14574939f, -0.00009872f, 0.03047676f, 0.07390506f, 0.18336591f, -0.16720425f, 
    0.08183146f, 0.06428660f, -0.03253554f, -0.03828287f, 0.17532036f, 0.32809287f, 0.11543477f, 0.18611299f, 
    -0.08757874f, -0.23947324f, -0.15065242f, -0.10295514f, -0.02989058f, 0.01182542f, 0.02664858f, 0.16320734f, 
    -0.06808755f, -0.09371556f, -0.30977941f, -0.03578827f, -0.09258873f, 0.02746401f, 0.15126611f, 0.14620072f, 
    0.29932696f, 0.29807520f, 0.09372037f, 0.35020399f, 0.05488328f, -0.05856638f, -0.18160677f, 0.05190951f, 
    0.05668605f, 0.33147720f, -0.30774888f, -0.05789633f, -0.07840531f, -0.09046999f, 0.00740083f, 0.14672913f, 
    -0.29521191f, 0.03145538f, 0.19847144f, 0.12178352f, 0.22673959f, 0.11020821f, -0.03027628f, 0.30657122f, 
    -0.14223073f, -0.06690150f, -0.00187915f, -0.17304055f, 0.44992882f, -0.03635179f, -0.20567958f, 0.22507200f, 
    -0.20282041f, 0.14624880f, 0.02181637f, 0.14269117f, 0.01708201f, 0.20519650f, 0.18276976f, 0.16460398f, 
    0.38885817f, 0.07103458f, 0.22252516f, 0.06451755f, -0.10368919f, 0.15332846f, 0.10649779f, -0.21657199f, 
    -0.03327344f, -0.17177968f, -0.27393511f, -0.09578540f, -0.16725197f, -0.01727656f, -0.05229612f, 0.19746380f, 
    -0.13405554f, -0.10770012f, -0.06154982f, -0.09235682f, 0.01863297f, 0.03943461f, 0.07928837f, 0.21605209f, 
    -0.17296843f, 0.17100734f, 0.00492693f, -0.01466252f, -0.18520290f, 0.06595913f, 0.12234148f, -0.15242401f, 
    0.01432311f, 0.41820183f, 0.36872041f, 0.38036415f, -0.19724247f, -0.03250751f, -0.07044022f, -0.12355051f, 
    0.25823575f, 0.07979209f, -0.07444913f, -0.16086879f, -0.25072467f, -0.19040109f, -0.22078219f, -0.26789403f, 
    0.10252769f, 0.03986429f, -0.01396253f, 0.22721975f, 0.05555807f, -0.33308518f, -0.03809495f, -0.25202635f, 
    -0.04326649f, -0.00280045f, 0.03792654f, -0.03611891f, -0.02083590f, -0.01739045f, 0.21123362f, 0.06023728f, 
    0.23503533f, 0.27716488f, 0.21478088f, -0.08591724f, 0.09000435f, -0.02649078f, 0.12196855f, 0.06567684f, 
    -0.13860716f, 0.18849219f, -0.08150596f, 0.21461520f, 0.15313685f, 0.03536773f, -0.02464794f, 0.06849689f, 
    0.00875369f, 0.34602693f, 0.29519480f, 0.16180199f, -0.02341281f, -0.11854946f, 0.28118452f, -0.17726506f, 
    -0.01869309f, 0.12636253f, -0.19268134f, 0.21025038f, 0.02609069f, -0.03270930f, 0.08953105f, -0.15273085f, 
    -0.50451595f, -0.14140348f, -0.09574799f, 0.24261065f, -0.05466675f, 0.05632432f, -0.02056355f, -0.03873522f, 
    -0.25922796f, 0.06171477f, 0.12835321f, 0.13467139f, 0.30524763f, 0.41778797f, 0.30112118f, 0.28209704f, 
    -0.06829587f, -0.03760961f, -0.03351459f, 0.06834760f, 0.17194107f, 0.01554790f, -0.07895757f, 0.18355539f, 
    -0.44770050f, -0.14534090f, -0.20944421f, 0.16322352f, -0.01037922f, -0.08230066f, -0.15161392f, -0.07310949f, 
    -0.04090582f, 0.04752409f, 0.01488762f, 0.06513093f, -0.26443368f, -0.30493879f, -0.21483037f, -0.24844505f, 
    -0.17071162f, 0.00377706f, -0.09125645f, 0.08598182f, -0.16470392f, 0.08845967f, 0.31175715f, 0.24011873f, 
    -0.43166530f, -0.48418629f, -0.05018485f, -0.09699678f, 0.05712895f, -0.09729365f, -0.03259306f, 0.03190688f, 
    0.09733909f, -0.09665677f, -0.15149470f, -0.06658620f, -0.56745547f, 0.03766361f, -0.19138078f, -0.23264049f, 
    -0.01211265f, -0.04506996f, -0.19704205f, -0.04125588f, 0.20690870f, -0.09167469f, 0.10275806f, -0.00918039f, 
    -0.27020416f, 0.22917424f, -0.39920464f, 0.29921949f, 0.37875080f, 0.22845356f, -0.04943033f, 0.31079021f, 
    0.17106840f, -0.07887161f, 0.04666378f, -0.00711844f, 0.24055424f, -0.04127298f, -0.05127560f, 0.45236480f, 
    -0.00588904f, 0.05343122f, -0.18604861f, -0.00338474f, -0.06428107f, 0.21471430f, 0.13600244f, 0.09305514f, 
    0.14268054f, 0.52245849f, -0.08915293f, 0.10936783f, 0.42868349f, -0.22854255f, 0.11444174f, 0.10070343f, 
    0.10184074f, -0.04361642f, -0.03435613f, -0.04804796f, -0.14102997f, 0.23773864f, 0.10693460f, 0.02414389f, 
    0.02528175f, -0.00314752f, 0.16705595f, 0.11050230f, 0.12154411f, -0.04090809f, -0.03546432f, 0.05990624f, 
    -0.13460927f, -0.23547485f, -0.28501576f, -0.01186340f, 0.19192366f, 0.04005710f, 0.10457915f, -0.10664546f, 
    -0.08144756f, -0.11117164f, 0.13247626f, -0.01034911f, -0.10743961f, -0.27157387f, -0.11184455f, -0.32454512f, 
    -0.07356418f, 0.00490064f, 0.02995765f, -0.05483862f, 0.14095651f, -0.01350030f, 0.01162075f, 0.26995328f, 
    -0.01649774f, -0.22349632f, 0.04794555f, -0.01659908f, -0.10438484f, -0.24467799f, -0.26461965f, 0.15631522f, 
    0.18096025f, 0.11499314f, 0.01906217f, 0.23545155f, 0.30703330f, 0.74641234f, 0.31814381f, -0.01210173f, 
    0.24472538f, 0.08415115f, 0.03045211f, -0.24499330f, 0.05190184f, -0.03951119f, 0.00461810f, 0.06420186f, 
    0.11922418f, -0.40002820f, -0.25558180f, -0.07438658f, 0.06157254f, 0.10665257f, 0.16837339f, 0.06228520f, 
    0.00952385f, -0.08913546f, -0.01955145f, -0.18335013f, 0.31047899f, 0.18157177f, 0.55163199f, 0.20715496f, 
    0.14274657f, 0.26310146f, 0.06013529f, 0.12343071f, 0.12248088f, -0.07727046f, -0.00795157f, 0.11925040f, 
    -0.35830063f, 0.15088919f, 0.16968724f, 0.26717532f, -0.05302550f, 0.05720730f, 0.09584717f, -0.03485480f, 
    -0.11848404f, -0.02895588f, 0.02078010f, 0.08387963f, -0.27160904f, 0.32774982f, 0.12358622f, 0.07430222f, 
    0.08706105f, -0.22378463f, 0.09748894f, 0.22558224f, 0.04046813f, -0.00850126f, -0.06005561f, -0.07974539f, 
    -0.05114582f, -0.01695016f, -0.06820539f, -0.04635366f, -0.00506222f, 0.01312167f, 0.00744073f, 0.04558538f, 
    0.04673596f, 0.03581564f, 0.03697861f, 0.00662635f, 0.03810316f, -0.00893706f, 0.02593878f, 0.02975914f, 
    0.04532302f, -0.01521999f, -0.06223833f, 0.03361467f, -0.07620282f, 0.04663844f, 0.04948829f, -0.05812619f, 
    -0.02882016f, 0.08158991f, -0.05876060f, -0.06295993f, -0.00340285f, 0.03577984f, 0.05771140f, 0.02131725f, 
    0.02549655f, -0.00545004f, 0.05889403f, -0.01771503f, 0.03785421f, 0.04749965f, -0.01968748f, -0.06350317f, 
    -0.07016310f, 0.01335770f, 0.01487154f, -0.04489846f, -0.02009284f, -0.06012902f, -0.01863345f, -0.05996393f, 
    0.01902695f, 0.06291621f, -0.00795469f, 0.02320845f, 0.00393380f, -0.06671237f, 0.03214871f, -0.07649397f, 
    0.02233269f, 0.05347211f, -0.02871534f, -0.01502231f, -0.03955885f, 0.04213536f, -0.05352505f, 0.01623435f, 
    0.01619564f, -0.01035136f, 0.02089590f, 0.03907845f, -0.01706028f, 0.06441634f, -0.05329401f, -0.02125014f, 
    -0.01667710f, -0.02468211f, 0.00263998f, -0.05133522f, -0.06516130f, -0.07324602f, 0.00990368f, 0.04111366f, 
    0.06381444f, -0.04602022f, -0.03005529f, 0.03328150f, 0.05880323f, -0.03385196f, 0.00453748f, -0.01346086f, 
    0.06428466f, -0.04343238f, -0.06153852f, 0.03497391f, 0.04974911f, -0.03707185f, 0.00203754f, -0.05414188f, 
    -0.04575041f, 0.04100310f, -0.02209406f, 0.02720305f, -0.07546713f, 0.03598781f, -0.02990138f, -0.02618856f, 
    -0.00855340f, 0.01670469f, 0.04783276f, -0.03328374f, 0.05961340f, -0.06633488f, 0.00409026f, 0.04420887f, 
    0.02180480f, -0.04767058f, -0.07385414f, -0.01046016f, 0.00443269f, -0.06885411f, -0.07129937f, -0.04184553f, 
    -0.00716842f, -0.05845223f, -0.01990785f, 0.03072149f, 0.03979401f, -0.06639394f, -0.02911840f, 0.02681437f, 
    0.02578721f, -0.05966526f, 0.05543135f, 0.01387452f, 0.04654197f, -0.04437640f, -0.00882280f, 0.03914032f, 
    0.02947641f, -0.06341147f, 0.00954126f, 0.02122667f, 0.05979210f, 0.00137334f, -0.02557572f, 0.05112877f, 
    0.02648284f, 0.01960105f, -0.02445901f, -0.03966094f, 0.02189037f, -0.02453837f, -0.05937026f, -0.04141219f, 
    0.05379866f, -0.00419411f, 0.02202054f, -0.05334127f, 0.05559211f, -0.04407790f, -0.00431044f, -0.01866111f, 
    -0.01252724f, -0.01095414f, 0.00643768f, 0.00095867f, -0.04259753f, -0.03864116f, -0.07218617f, -0.05563332f, 
    -0.00909295f, -0.04622640f, 0.01367381f, -0.02254770f, -0.05274944f, -0.06278152f, -0.03702237f, -0.02279959f, 
    -0.01174679f, 0.00933420f, -0.05190055f, -0.04496131f, -0.05104051f, -0.03594507f, -0.00225542f, -0.01554628f, 
    0.05184861f, 0.02058657f, 0.00952401f, 0.00250523f, -0.07017425f, -0.06659508f, -0.00673241f, -0.07625705f, 
    -0.93886906f, 0.27435100f, -0.19346459f, 0.29290783f, -0.19319128f, -0.24781719f, -0.05680586f, 0.13872573f, 
    -0.06900103f, 0.14829364f, -0.21679248f, 0.17674637f, 0.03581080f, -0.09649805f, 0.36968097f, -0.17807646f, 
    -0.06193082f, 0.00061015f, 0.09125723f, -0.11730855f, -0.22364935f, 0.21365556f, 0.08698542f, 0.09025250f, 
    -0.07671639f, -0.09157681f, 0.08005214f, 0.10581162f, 0.08589418f, 0.02174767f, -0.12762879f, -0.04928546f, 
    0.04389498f, 0.06613538f, 0.06146432f, -0.06028739f, -0.16727997f, -0.04248235f, 0.04277183f, 0.03912319f, 
    0.05024810f, -0.08765069f, 0.00748479f, -0.07519160f, 0.17124058f, -0.03032690f, 0.06668853f, 0.15476216f, 
    -0.47875312f, 0.13778192f, -0.10541816f, -0.06396341f, 0.05599761f, 0.11264961f, -0.33509985f, 0.33941516f, 
    0.05717474f, 0.11226903f, 0.16902442f, -0.00925148f, -0.25815138f, 0.10080593f, 0.20063592f, 0.25436899f, 
    0.18800014f, -0.14185800f, -0.00275077f, -0.10451248f, -0.05231344f, -0.21715303f, -0.07881348f, 0.25287545f, 
    -0.01323311f, 0.40773350f, -0.36260292f, -0.04496988f, 0.00209757f, -0.08853918f, 0.18275748f, 0.13765757f, 
    0.06818222f, 0.05450403f, -0.02850647f, 0.23650593f, 0.05098163f, 0.27523482f, 0.15647429f, -0.23885933f, 
    0.15632159f, 0.00667890f, 0.12018468f, 0.24658979f, 0.05180332f, -0.10244525f, -0.21363831f, -0.09830219f, 
    -0.24643570f, 0.20242912f, -0.08140603f, 0.05363645f, 0.07387605f, -0.04187337f, 0.19562426f, -0.13564718f, 
    -0.02483868f, -0.19440377f, 0.03544518f, -0.15145871f, 0.07856311f, -0.08762616f, 0.10296280f, -0.05576367f, 
    -0.03781385f, 0.09660482f, 0.05493850f, -0.04515384f, 0.11752991f, 0.01053866f, 0.09855860f, 0.00805501f, 
    0.12910266f, -0.07308871f, 0.12931859f, -0.06760588f, -0.01662324f, 0.08260018f, -0.10006469f, -0.00755851f, 
    -0.11210743f, 0.08469114f, -0.09485643f, 0.15709500f, 0.22174720f, 0.35848707f, 0.13338131f, -0.27516991f, 
    0.02767359f, 0.03873262f, 0.04213616f, 0.07682487f, 0.03123701f, -0.12262374f, -0.00037831f, -0.16739272f, 
    0.25331682f, -0.18545413f, 0.22925565f, -0.01322122f, 0.03343653f, -0.04356268f, 0.02339006f, -0.08105564f, 
    0.13500993f, -0.06445706f, -0.06175696f, -0.24533330f, -0.08368115f, 0.48746857f, 0.03381302f, 0.11667021f, 
    0.23699988f, 0.29494351f, 0.30508739f, 0.17134759f, 0.04257411f, 0.12538984f, -0.19429170f, 0.09832183f, 
    -0.37620673f, -0.03420009f, 0.20455927f, -0.11234521f, 0.01123370f, -0.08340504f, -0.15637554f, 0.36070046f, 
    -0.02366056f, -0.05871726f, -0.02142143f, 0.19699103f, 0.07909454f, 0.19907986f, -0.04661669f, -0.22184965f, 
    -0.10068385f, -0.07362264f, 0.14226830f, 0.27333465f, 0.06249650f, 0.14684443f, 0.09105352f, -0.24551220f, 
    -0.34452239f, -0.28071806f, 0.50357145f, -0.29693094f, 0.31383517f, 0.03102186f, -0.00376099f, 0.06525583f, 
    0.06458499f, -0.23636591f, 0.05938902f, -0.03150340f, -0.00880202f, 0.16050135f, -0.24352078f, 0.20542826f, 
    0.01318380f, 0.15815029f, 0.05277617f, 0.09574588f, -0.08250226f, 0.04486839f, -0.09007675f, -0.05072518f, 
    -0.05689418f, -0.08608040f, 0.00890016f, -0.00651741f, 0.02405203f, 0.05417877f, 0.13602637f, -0.04865593f, 
    -0.01948361f, -0.16108519f, -0.00838543f, -0.00882239f, 0.16871758f, 0.23468795f, -0.06773480f, 0.08371471f, 
    -0.05226365f, 0.01663152f, 0.08574069f, -0.05073627f, -0.09739708f, 0.11245336f, 0.08714627f, -0.06075064f, 
    0.19547048f, 0.15742835f, -0.10305949f, 0.06725229f, 0.03248044f, 0.05350732f, -0.18008469f, -0.09484589f, 
    0.05175791f, -0.03564303f, -0.19423030f, -0.02811524f, -0.39401588f, 0.19715497f, 0.31140658f, 0.22315815f, 
    0.28493717f, -0.08424670f, 0.00957157f, -0.11388472f, 0.34326157f, 0.11551810f, 0.15023135f, 0.02298040f, 
    -0.23839790f, 0.35426399f, -0.35186961f, 0.02046745f, 0.01647486f, 0.05476638f, -0.08097934f, 0.04989088f, 
    -0.06908702f, 0.07334563f, 0.12415642f, -0.14039628f, 0.25722089f, 0.24162994f, 0.23939592f, -0.10083438f, 
    0.05061969f, 0.11714752f, 0.03139013f, 0.00433930f, 0.08549673f, 0.09071103f, -0.02041251f, 0.14074685f, 
    -0.11900181f, -0.10339109f, 0.13350584f, -0.16508618f, 0.16733710f, 0.05470368f, -0.04905304f, -0.06956111f, 
    0.03152682f, 0.00740787f, 0.01710583f, 0.16547027f, 0.10892341f, 0.06463359f, -0.18073565f, 0.08091518f, 
    0.00791047f, 0.12273200f, 0.05401111f, 0.02988900f, -0.01836948f, 0.05272251f, 0.13157193f, -0.02078288f, 
    -0.01831738f, 0.00029277f, 0.09475612f, 0.06549982f, -0.04706632f, -0.00095185f, 0.01356085f, 0.04654463f, 
    0.06790455f, -0.02110044f, -0.03675422f, 0.20462006f, 0.53184134f, 0.21724117f, -0.36735287f, -0.00193236f, 
    -0.19671242f, -0.02688610f, -0.07457057f, 0.06680147f, -0.07566994f, 0.03576873f, -0.05157916f, 0.04069642f, 
    -0.02572186f, -0.44059473f, -0.17936893f, 0.17780708f, -0.15447786f, -0.02084156f, 0.02761251f, -0.04314717f, 
    0.12988260f, -0.01117648f, -0.02464903f, 0.24018912f, 0.27945137f, 0.02526128f, 0.40479228f, 0.05176581f, 
    -0.07478437f, -0.12555017f, 0.08614545f, -0.13810889f, 0.06427447f, -0.25282261f, 0.05222901f, -0.16231595f, 
    0.31181762f, 0.07577623f, 0.03833137f, 0.18081389f, -0.05915937f, 0.03360009f, 0.13419923f, -0.03589093f, 
    0.10234553f, 0.00316064f, -0.02504556f, -0.01968451f, -0.19582263f, 0.37513271f, -0.01782530f, 0.03354918f, 
    -0.05995415f, -0.02636269f, -0.08527919f, -0.07264456f, 0.12784319f, -0.06072140f, -0.08235078f, -0.01431879f, 
    1.04474044f, -0.10376763f, 0.22291425f, 0.10454077f, -0.15626805f, 0.29049855f, -0.09543195f, 0.21900792f, 
    0.20716290f, 0.09483604f, 0.23791762f, 0.00056092f, -0.19471483f, 0.04485677f, -0.21608615f, 0.16580668f, 
    -0.01829939f, -0.07047632f, 0.00379531f, 0.03495704f, 0.17544287f, -0.03310718f, 0.15760924f, -0.18394223f, 
    -0.03244747f, 0.05919354f, 0.10873806f, 0.07884667f, -0.08880454f, 0.01024399f, -0.11949689f, -0.10202643f, 
    0.00782917f, 0.04621140f, -0.02131620f, 0.07257303f, -0.02686642f, -0.07569100f, 0.13253063f, -0.10075120f, 
    0.00347385f, -0.18380244f, 0.03179574f, 0.08982243f, -0.06126871f, -0.02027600f, -0.03742899f, 0.05175191f, 
    0.29173502f, -0.10249446f, 0.17223021f, -0.05784157f, -0.27222472f, -0.06408492f, 0.26110896f, -0.41902009f, 
    0.03060482f, 0.08156312f, 0.04982812f, 0.03311364f, -0.25621381f, 0.01028607f, 0.09815594f, -0.45300788f, 
    -0.09628706f, 0.24153030f, -0.07620750f, 0.11658036f, -0.11278606f, 0.06138406f, 0.07234994f, -0.17400204f, 
    0.01379704f, -0.48407957f, 0.31287000f, 0.06178166f, 0.26824933f, 0.10785096f, -0.08312069f, 0.10826367f, 
    -0.12925035f, 0.10187053f, 0.08865204f, 0.01631761f, 0.13478346f, -0.16508882f, -0.04151995f, 0.23953474f, 
    0.25601655f, 0.29092580f, 0.04280380f, -0.15947090f, -0.13970698f, -0.06740720f, 0.01877814f, -0.11244225f, 
    0.14518492f, -0.14251918f, -0.05475973f, 0.10854388f, 0.04078919f, 0.07281882f, -0.27942047f, 0.19062105f, 
    0.23615257f, 0.04974714f, -0.09776661f, 0.09595571f, -0.06918212f, -0.03171008f, 0.00496867f, 0.00991215f, 
    -0.08198956f, -0.13765632f, -0.01526917f, 0.03250960f, 0.07059607f, 0.03237313f, 0.04070069f, 0.06132124f, 
    -0.02120092f, 0.24063565f, -0.07217822f, 0.04902273f, -0.01888706f, 0.17235962f, 0.02417826f, 0.09964407f, 
    0.26410708f, 0.02080429f, 0.07496750f, -0.19031243f, -0.24828146f, -0.44146359f, -0.06726337f, 0.15819381f, 
    0.19900446f, 0.03823847f, -0.00254375f, 0.18375757f, -0.06072718f, 0.00807013f, 0.01903395f, 0.17581241f, 
    0.00630595f, 0.23719332f, 0.11004555f, -0.16120622f, -0.00721474f, -0.00758970f, -0.06911192f, 0.10720981f, 
    -0.03060012f, 0.01198450f, -0.05670708f, 0.08502801f, 0.00446817f, 0.10470168f, -0.49063501f, -0.12127106f, 
    -0.15978396f, 0.14447191f, -0.00491977f, -0.03808769f, -0.03836593f, 0.07659283f, 0.01475289f, -0.05158167f, 
    0.79531544f, 0.19029148f, 0.11179160f, -0.16434436f, 0.24934874f, 0.00171920f, 0.01067423f, -0.08233756f, 
    -0.13170750f, 0.01040781f, -0.13935606f, -0.16368127f, 0.31598791f, -0.54125488f, 0.24204285f, 0.21439402f, 
    0.26624164f, 0.34176600f, 0.04852455f, 0.15106337f, -0.04906796f, 0.03630967f, 0.08921743f, 0.09012189f, 
    0.02978162f, -0.28885686f, 0.24858673f, -0.18914457f, 0.30361709f, 0.17469802f, 0.16311881f, -0.10178486f, 
    -0.11512367f, 0.06139182f, 0.08804369f, -0.05281176f, 0.28156084f, 0.07596619f, -0.09729505f, -0.04348309f, 
    0.12562314f, -0.01402908f, 0.00216634f, -0.01344523f, 0.12345543f, -0.07614325f, -0.01050066f, 0.14726906f, 
    0.26564157f, 0.21544984f, 0.16412736f, -0.00087730f, -0.08271805f, -0.04622401f, 0.07578953f, -0.08056375f, 
    0.10187259f, 0.17415452f, 0.05512049f, -0.06204850f, 0.23107411f, 0.40836897f, 0.27055120f, 0.06546568f, 
    -0.03875851f, -0.04760300f, 0.00896523f, -0.06247451f, -0.00595108f, 0.03423344f, -0.07967368f, -0.06054493f, 
    0.12005001f, 0.17262585f, 0.12236247f, 0.17419195f, -0.00692332f, 0.10012463f, 0.04878445f, -0.07482496f, 
    0.02508134f, -0.01680753f, -0.01883770f, 0.00047697f, 0.35119748f, -0.22583506f, 0.26194531f, -0.05167769f, 
    0.18002456f, -0.16051859f, 0.28334770f, 0.07602365f, -0.00403397f, 0.08057951f, 0.01745713f, -0.14817356f, 
    -0.49140969f, 0.01936172f, 0.20568968f, 0.19432682f, -0.04870258f, 0.08322950f, 0.01113948f, -0.17287245f, 
    -0.03587799f, 0.00548461f, 0.07816067f, 0.03397358f, -0.44155601f, -0.33163607f, -0.65993190f, -0.21518749f, 
    -0.13160929f, -0.03617794f, -0.07396919f, -0.14174202f, 0.12763795f, 0.08871736f, 0.03842776f, 0.17055532f, 
    -0.07655193f, -0.17071126f, -0.00714841f, 0.09697728f, -0.06870195f, 0.08453591f, 0.04207472f, 0.27312818f, 
    -0.17991637f, -0.06552444f, 0.22087273f, -0.08492720f, 0.34472701f, 0.34763914f, 0.10635502f, -0.13375726f, 
    -0.05486093f, -0.00312083f, -0.03961137f, -0.05609920f, -0.00308632f, 0.11105600f, -0.17438693f, 0.02264053f, 
    0.00077938f, -0.02828970f, 0.07196476f, -0.10633388f, -0.03875440f, -0.03112505f, 0.07551163f, 0.01555238f, 
    0.10103040f, 0.11154895f, 0.10449408f, 0.16932000f, 0.25027004f, 0.40679225f, -0.00988964f, 0.38638049f, 
    -0.11983766f, 0.07717144f, -0.00828682f, 0.00360658f, -0.03844393f, 0.19191499f, 0.00886055f, 0.07075609f, 
    -0.04084101f, 0.25280994f, -0.04291543f, -0.22049956f, -0.05629824f, 0.01380968f, -0.08445811f, -0.14786018f, 
    0.17676553f, 0.20079909f, 0.18998627f, 0.19219096f, 0.54180223f, -0.09611870f, 0.36944094f, -0.02470804f, 
    0.13586071f, -0.16896798f, -0.17590678f, -0.00477086f, 0.13849844f, -0.06089495f, -0.02839827f, -0.07215068f, 
    0.28030068f, 0.27360374f, -0.72193944f, -0.06614004f, 0.02622100f, 0.13958573f, 0.27796894f, 0.01696675f, 
    0.04174554f, 0.00118417f, 0.02423525f, -0.10632918f, -0.47989908f, -0.27886629f, -0.44598418f, -0.18820861f, 
    0.02093883f, 0.07941215f, 0.25025621f, 0.20874973f, -0.09769820f, -0.08805678f, 0.04864074f, -0.02560302f, 
    -0.49484506f, -0.27391645f, -0.16542122f, -0.01019629f, 0.14584091f, 0.20684522f, 0.02876043f, -0.01786368f, 
    -0.05283221f, 0.03012561f, -0.13707753f, 0.09430852f, 0.19652823f, -0.31353757f, 0.15941516f, 0.49802253f, 
    0.02969265f, -0.05999292f, -0.04639190f, 0.26258853f, -0.14406444f, 0.03871799f, 0.00058391f, -0.06649645f, 
    0.18306026f, -0.19634631f, -0.16502333f, 0.11712167f, 0.10240754f, 0.02646590f, 0.03531194f, 0.12501337f, 
    -0.14243914f, -0.22922434f, -0.00411063f, 0.08871212f, 0.28770125f, -0.17731278f, -0.21953972f, 0.17306173f, 
    0.16233824f, 0.08924311f, 0.10560336f, 0.04582761f, 0.06786527f, -0.21878207f, 0.03452997f, -0.10730146f, 
    0.32761317f, 0.23409893f, -0.34790435f, -0.12906188f, 0.19146840f, 0.14707389f, 0.26189733f, 0.08128753f, 
    0.13687962f, -0.08141836f, -0.13672252f, 0.06796686f, 0.28771001f, -0.19489761f, -0.15317033f, 0.51501566f, 
    0.18697889f, 0.19255243f, 0.03659124f, -0.01465957f, 0.17174381f, 0.14678800f, 0.02709495f, 0.25367522f, 
    -0.00471870f, 0.33381960f, -0.36426729f, -0.30974048f, 0.04799290f, 0.01224729f, 0.17171916f, 0.01688799f, 
    0.03456592f, -0.07724895f, -0.00599218f, 0.02677717f, -0.00273843f, 0.31832147f, 0.51048672f, -0.20774651f, 
    -0.16109942f, -0.14589755f, 0.01788852f, 0.19849920f, -0.02576344f, 0.05987415f, 0.09628411f, -0.00392139f, 
    0.49797338f, 0.29418504f, -0.08659313f, -0.16904110f, -0.05991895f, 0.04655124f, 0.14229544f, -0.15990335f, 
    0.30688080f, 0.27130002f, 0.38965487f, 0.34182394f, -0.12464075f, 0.01604791f, -0.12615345f, 0.21391656f, 
    0.23086442f, 0.14268918f, 0.00803274f, 0.10005151f, -0.02792432f, -0.06685509f, -0.08058503f, -0.19764102f, 
    0.07427419f, -0.16908467f, 0.02120904f, 0.13530385f, 0.05789964f, -0.06314590f, -0.00004232f, 0.03523904f, 
    -0.14698434f, -0.10907651f, -0.14247842f, -0.04592755f, -0.14223291f, -0.08825911f, -0.28530294f, -0.09113058f, 
    0.10661301f, 0.02472262f, -0.24658892f, -0.20097616f, -0.04437140f, -0.03985773f, 0.00393000f, -0.14049521f, 
    0.13860814f, -0.48547369f, 0.33268169f, 0.49917361f, -0.06503928f, -0.06418691f, 0.03691637f, 0.00211036f, 
    0.44938755f, 0.23244259f, 0.23683847f, 0.32156053f, -0.48022497f, -0.15712766f, 0.08859357f, 0.08484794f, 
    0.17723124f, 0.01928586f, 0.24585137f, 0.02430004f, -0.08014847f, -0.03073164f, 0.08652315f, -0.07878128f, 
    -0.51859784f, -0.12714562f, 0.39578149f, 0.15470903f, -0.20244038f, -0.15174103f, 0.13261044f, 0.05322823f, 
    0.01020915f, 0.05174256f, 0.02184404f, -0.01231759f, -0.21882589f, 0.54164058f, 0.06650528f, -0.31203726f, 
    -0.12449385f, -0.03994657f, 0.02531020f, -0.07267383f, 0.33383927f, 0.03224013f, 0.02211860f, 0.17085627f, 
    0.00014366f, -0.03617327f, -0.00282888f, -0.01751356f, -0.03707310f, 0.01100732f, 0.04039603f, -0.05299791f, 
    -0.07160914f, -0.04326362f, 0.06028626f, 0.01528651f, 0.05311475f, -0.01208378f, 0.03471621f, -0.01040904f, 
    -0.05670970f, 0.00614604f, -0.02031456f, -0.04523151f, 0.02491401f, -0.00559196f, -0.04916322f, -0.04757753f, 
    0.01516035f, -0.02809742f, -0.04587432f, 0.01198309f, -0.00941138f, -0.06111010f, -0.06975421f, 0.06066451f, 
    -0.01763055f, -0.07072844f, 0.03311487f, 0.02201043f, 0.00166260f, -0.01559106f, -0.01275224f, 0.06018961f, 
    0.04170391f, -0.00166060f, 0.05152626f, 0.02155543f, -0.02754031f, 0.06404825f, -0.02318400f, 0.01734178f, 
    -0.03190934f, -0.03771684f, -0.00534453f, 0.03653144f, 0.03487369f, 0.06229336f, -0.04649690f, 0.01333556f, 
    -0.03323744f, -0.04808686f, -0.05010827f, 0.02232226f, 0.05694380f, -0.07623828f, -0.07847982f, -0.01772160f, 
    -0.02252220f, -0.01597694f, -0.02872416f, -0.00893368f, -0.07466703f, -0.04972420f, 0.04008100f, -0.06183786f, 
    0.01264552f, -0.05849539f, -0.06977964f, 0.02587572f, 0.01513791f, -0.05656233f, 0.00409545f, -0.06629648f, 
    -0.05336461f, -0.01153922f, -0.07618146f, 0.02220603f, -0.07674953f, -0.05434920f, -0.01104438f, 0.03878795f, 
    -0.07282727f, -0.03326716f, -0.05853322f, -0.00771729f, -0.01847272f, -0.01057862f, 0.02621040f, 0.05651478f, 
    -0.05771409f, -0.05352983f, -0.06083522f, -0.00045908f, 0.01955293f, 0.04301477f, -0.07019363f, 0.00386457f, 
    0.03434676f, 0.06336698f, -0.04967406f, 0.00975150f, 0.03002025f, -0.05405877f, -0.07694494f, -0.00418760f, 
    -0.01089510f, -0.05369923f, 0.05200950f, -0.01472700f, -0.05816971f, 0.03131880f, -0.02486919f, -0.02462567f, 
    -0.00102687f, 0.02217763f, -0.02229109f, -0.02997589f, -0.06420601f, 0.04514493f, -0.00102415f, 0.02811349f, 
    0.02477141f, -0.02040210f, -0.07291320f, -0.01093989f, 0.00383508f, -0.05727284f, 0.02785886f, -0.00964340f, 
    -0.02368336f, -0.03417804f, 0.04876957f, 0.03886998f, 0.01722353f, 0.01446644f, -0.01156449f, -0.06068104f, 
    0.01580559f, 0.05686447f, 0.02653751f, 0.06302147f, 0.05415154f, -0.02566755f, -0.07392586f, -0.07153139f, 
    -0.00625317f, 0.05050496f, -0.05576228f, 0.00034283f, -0.07227109f, 0.03584660f, -0.06171414f, 0.05249864f, 
    -0.01300920f, 0.06480744f, -0.03718156f, 0.06121892f, -0.00681145f, -0.03394509f, 0.02830712f, -0.00585785f, 
    -0.02883822f, 0.01346685f, 0.05569949f, -0.03356839f, 0.04761146f, -0.03960329f, 0.00632786f, -0.07227457f, 
    0.05235459f, 0.05416954f, -0.02812151f, -0.00743349f, -0.02435243f, -0.00830356f, -0.00352716f, -0.03677459f, 
    0.00636710f, -0.01379406f, 0.05990975f, 0.05498244f, -0.07215762f, -0.01189629f, 0.01465003f, -0.02742960f, 
    1.15729535f, 0.27990508f, 0.09615635f, 0.17785175f, -0.02288885f, 0.03322737f, 0.00550395f, 0.25566658f, 
    0.11744361f, -0.01419052f, 0.18693091f, -0.11300835f, -0.29184127f, 0.19807549f, -0.10468335f, 0.05408915f, 
    -0.03009894f, 0.00530950f, 0.04573676f, -0.01367460f, -0.09024800f, 0.04857922f, 0.26346782f, 0.41171950f, 
    -0.27508327f, 0.02102545f, -0.10278810f, -0.20676693f, -0.18195745f, -0.06368397f, -0.07747249f, -0.02302505f, 
    0.12378073f, 0.06208397f, -0.00410911f, -0.04443649f, -0.32512745f, 0.19227269f, -0.00508993f, -0.09660134f, 
    -0.16851702f, -0.08411672f, -0.00299318f, -0.15233186f, 0.03784265f, -0.06211978f, -0.06657521f, 0.24591465f, 
    -0.50380963f, -0.08716651f, 0.21563001f, 0.10146719f, 0.23444986f, 0.18842568f, 0.16016293f, 0.27331093f, 
    -0.00394233f, -0.05079643f, 0.19780374f, -0.01175251f, 0.14681414f, 0.23057564f, -0.52497661f, -0.04500635f, 
    -0.19628669f, -0.14533110f, 0.07780279f, -0.01768081f, 0.15967301f, 0.13110468f, 0.01656331f, 0.14687255f, 
    -0.01580930f, -0.19289744f, 0.38351390f, 0.17361479f, 0.49160597f, -0.18610738f, 0.09570643f, 0.10245740f, 
    -0.04061043f, -0.00674690f, -0.05615769f, -0.02525562f, -0.30100912f, -0.16195878f, -0.25746658f, 0.05721467f, 
    -0.12041170f, 0.03861328f, 0.20765677f, 0.03466359f, 0.06654338f, 0.01474959f, 0.03286148f, -0.03445403f, 
    0.09834468f, 0.24604124f, -0.09389155f, 0.07402379f, 0.10346126f, -0.09274709f, -0.19540973f, -0.10348182f, 
    -0.04419434f, 0.02933349f, -0.06785605f, 0.07008390f, -0.05501793f, -0.12033883f, -0.14658506f, -0.12742996f, 
    0.00798949f, -0.09431312f, 0.10912503f, -0.05007108f, 0.03333176f, 0.10274987f, 0.03823271f, 0.08879427f, 
    -0.12111390f, 0.32882601f, 0.08334038f, 0.20385544f, 0.01705763f, 0.10344729f, -0.09806622f, 0.08968490f, 
    0.19343854f, 0.08239324f, 0.29037729f, 0.31046686f, -0.12059112f, -0.34720951f, 0.43230072f, -0.10034325f, 
    0.08395181f, -0.03116665f, 0.40521142f, 0.03108370f, -0.01584727f, 0.04146473f, 0.01097009f, 0.18206300f, 
    -0.22870380f, 0.31503114f, -0.13346012f, 0.01073905f, 0.00778627f, -0.16709882f, 0.05124116f, 0.01668249f, 
    0.06824203f, 0.18364492f, 0.02707713f, 0.02901986f, 0.07449108f, 0.03037191f, 0.00749730f, 0.16680774f, 
    -0.16516443f, 0.18740694f, -0.03948009f, 0.16546021f, 0.06549625f, 0.07342838f, 0.02719616f, 0.11909270f, 
    -0.55102062f, -0.38612896f, -0.08594585f, 0.23401234f, -0.08312058f, 0.06388598f, -0.11900343f, -0.15380226f, 
    -0.25295767f, -0.07829618f, -0.11503071f, -0.01293539f, 0.18670961f, -0.03616217f, 0.39265481f, 0.53574640f, 
    0.06868874f, -0.17313677f, 0.24977367f, 0.24001867f, -0.05400620f, -0.07500406f, -0.08978532f, -0.08994843f, 
    0.19619983f, 0.24301039f, -0.04605918f, 0.12850738f, -0.14160585f, -0.12371942f, -0.04229897f, 0.00909976f, 
    0.17650069f, -0.09441048f, 0.02015173f, -0.01260892f, -0.07950514f, -0.03761373f, -0.10076673f, -0.24853180f, 
    -0.00434380f, -0.05229344f, -0.10194822f, 0.09537659f, 0.10787788f, 0.04264537f, -0.23097560f, -0.05267837f, 
    -0.34045807f, -0.09884041f, -0.04167399f, -0.04994095f, -0.05548140f, -0.01204632f, -0.08384439f, -0.03834682f, 
    0.17399929f, 0.23030917f, 0.26809770f, 0.16834696f, -0.30551079f, -0.62737334f, -0.07894491f, -0.25647634f, 
    0.06741431f, 0.02086079f, -0.05782880f, 0.04060846f, -0.01218652f, 0.09340769f, 0.04243815f, 0.09187709f, 
    -0.13215837f, -0.39337489f, 0.15031634f, 0.18277131f, -0.20859422f, 0.01826190f, 0.08340245f, -0.37438235f, 
    -0.03470357f, 0.17894997f, 0.09867383f, 0.06170463f, -0.34495801f, 0.02955078f, 0.45250314f, -0.37497017f, 
    -0.09974752f, -0.09876315f, -0.16402702f, 0.12400096f, -0.04967830f, -0.06319626f, -0.02466324f, -0.15909825f, 
    0.21352287f, -0.28492883f, 0.27443731f, 0.07755478f, -0.28638262f, 0.42575249f, 0.10740438f, 0.03420790f, 
    0.00613396f, 0.12023269f, 0.08373668f, -0.03451705f, 0.27813250f, -0.12407090f, -0.05234553f, 0.27530545f, 
    0.28301516f, 0.05276915f, -0.01407952f, -0.21339756f, -0.14829436f, -0.10397415f, -0.08804784f, 0.00126047f, 
    -0.37163308f, -0.34417772f, -0.04662532f, 0.02626037f, -0.10692381f, 0.00696150f, -0.21176542f, 0.02248701f, 
    0.12584992f, 0.02859113f, -0.06740518f, 0.02636215f, -0.20502250f, 0.00360467f, 0.07475735f, -0.19833983f, 
    0.09539381f, 0.00036695f, 0.10346230f, 0.06003166f, 0.02145455f, 0.14193435f, 0.05270024f, 0.22234946f, 
    -0.05482458f, -0.09036118f, -0.20521024f, -0.20746416f, 0.03239718f, 0.08479628f, 0.13933335f, 0.00380865f, 
    0.10780268f, 0.20130681f, 0.08047956f, -0.02496077f, 0.13988930f, 0.14881316f, 0.04972846f, 0.11222041f, 
    0.10984008f, 0.08671322f, -0.04242212f, 0.29965711f, -0.04392555f, -0.02802415f, 0.09123178f, 0.01220484f, 
    -0.16873723f, 0.20501746f, -0.32761794f, -0.28509203f, 0.03008321f, 0.07292023f, 0.07708281f, 0.11408193f, 
    -0.23846215f, 0.10065805f, -0.00773394f, 0.10277779f, 0.15365116f, 0.03985208f, -0.06810336f, -0.05250869f, 
    -0.06294566f, -0.01785214f, -0.06149714f, 0.09157348f, -0.02441893f, -0.00370991f, 0.08373311f, -0.03324883f, 
    0.52948660f, 0.32326972f, 0.23693739f, -0.13858278f, 0.30079564f, 0.25427410f, 0.07853463f, -0.01021742f, 
    0.07469556f, 0.00721819f, -0.14689335f, -0.01209388f, 0.31669843f, -0.19969049f, 0.14386919f, 0.21387917f, 
    0.24935295f, 0.24787150f, -0.11348259f, -0.12100182f, -0.14013766f, -0.06598128f, -0.05891097f, -0.00449613f, 
    1.04400289f, 0.33667260f, -0.21883087f, 0.25998330f, 0.23699701f, 0.07215413f, -0.03660998f, 0.10235704f, 
    -0.07465186f, 0.16330580f, 0.05493122f, 0.04202761f, -0.05263788f, -0.49084494f, 0.03541283f, -0.14100501f, 
    -0.03702525f, -0.04287009f, -0.06373475f, 0.11047332f, 0.20679210f, 0.07435191f, -0.05540021f, 0.24409913f, 
    -0.15114178f, 0.03698462f, -0.06742129f, -0.04871501f, -0.11126374f, -0.08701199f, -0.04330589f, -0.12554444f, 
    -0.00082130f, -0.01569872f, -0.11274997f, 0.02305826f, -0.08484595f, 0.31188348f, 0.22452542f, -0.20073214f, 
    -0.12869446f, 0.02080137f, -0.12629950f, -0.07558795f, -0.04871234f, -0.02844168f, -0.06160429f, -0.11433436f, 
    -0.37488809f, -0.10754258f, 0.30416906f, 0.15579583f, 0.06304118f, -0.07207934f, -0.21317531f, -0.02476189f, 
    0.02752393f, -0.15437314f, -0.01581904f, 0.10883111f, 0.52923131f, -0.11067710f, 0.07031042f, 0.13509816f, 
    -0.00056826f, 0.03092395f, 0.15063308f, 0.07773670f, 0.17967913f, 0.20849271f, 0.32288352f, 0.02934980f, 
    -0.09953383f, 0.08659923f, 0.73042196f, 0.08224352f, 0.30179536f, 0.06825374f, -0.00180363f, 0.00404640f, 
    0.11451878f, 0.09054087f, 0.06567897f, -0.05910078f, -0.34470603f, -0.38528064f, 0.08841618f, 0.10266510f, 
    -0.00843073f, -0.05551748f, 0.09192480f, -0.12428311f, 0.11219524f, -0.03988598f, 0.15256362f, 0.04467250f, 
    -0.04494453f, 0.01600921f, 0.05988226f, 0.05605117f, -0.04408270f, 0.08665466f, -0.07480395f, 0.01519029f, 
    0.05862484f, 0.17444897f, 0.18679382f, 0.11827228f, 0.02638663f, 0.14623256f, -0.37700167f, -0.44314811f, 
    -0.13324577f, -0.16614543f, -0.00111321f, -0.12141641f, -0.16336866f, 0.05972846f, -0.03055009f, -0.08168249f, 
    -0.29681268f, 0.07640816f, -0.10173976f, 0.02592420f, 0.07676814f, 0.01164235f, -0.16154483f, -0.09968896f, 
    0.13014637f, 0.11780483f, 0.40086320f, 0.19377086f, -0.25350207f, -0.16624844f, 0.04245033f, -0.02415787f, 
    0.09279515f, -0.04332387f, 0.02940764f, 0.11476965f, 0.04933044f, 0.11206824f, -0.00076395f, 0.04244591f, 
    0.03622361f, 0.20915985f, -0.24020986f, -0.28192636f, -0.02880156f, -0.07422349f, 0.06826972f, 0.02591766f, 
    0.11817871f, 0.25113711f, 0.18733597f, 0.07788242f, 0.16313949f, -0.53449905f, -0.25920931f, 0.12919672f, 
    0.08543336f, 0.01130714f, -0.13997422f, 0.04789004f, 0.12551890f, 0.00976945f, 0.09413124f, 0.08966153f, 
    -0.38343704f, -0.06177303f, 0.08310529f, 0.08564113f, -0.05773952f, 0.02482042f, 0.18229480f, -0.05252382f, 
    0.01772105f, 0.10565253f, -0.00394273f, 0.07133975f, 0.03000700f, -0.19834937f, 0.17502992f, 0.32078034f, 
    0.09406862f, 0.09470499f, 0.09979624f, 0.08364778f, 0.09929153f, -0.08666136f, -0.01722554f, 0.14733581f, 
    0.21926199f, -0.05540055f, 0.38693890f, 0.34953263f, 0.10158167f, 0.01168514f, 0.25462738f, 0.31431377f, 
    0.04319909f, 0.35482705f, 0.03101187f, 0.01304170f, -0.30746531f, 0.21471271f, -0.22421326f, 0.28135231f, 
    -0.04910303f, -0.14759730f, -0.05485590f, 0.12828696f, -0.03883732f, 0.14192483f, 0.03816262f, 0.22667582f, 
    0.19341435f, 0.19549692f, 0.10328391f, 0.16288272f, -0.05138930f, -0.10687332f, -0.18494701f, -0.12076287f, 
    -0.20435798f, -0.22823986f, -0.16389190f, -0.41185942f, 0.32480255f, 0.25125191f, 0.05007711f, 0.40156773f, 
    -0.15372552f, -0.01987145f, -0.19805761f, -0.14779851f, -0.08521356f, 0.13298447f, -0.14541750f, -0.26116976f, 
    0.23786035f, -0.50298202f, 0.11121032f, -0.01053810f, 0.02747177f, 0.20676082f, -0.06647553f, 0.06085122f, 
    0.01629666f, -0.06863433f, 0.11747850f, 0.05672183f, 0.40868858f, 0.15325202f, 0.07259076f, -0.02867694f, 
    0.07743483f, -0.09881891f, 0.12772924f, 0.20829861f, 0.02054563f, 0.21705234f, 0.21822381f, -0.18183416f, 
    0.02226599f, -0.23880288f, 0.42384756f, -0.02452233f, 0.19691008f, 0.12214814f, 0.26398885f, 0.17711858f, 
    0.17134985f, 0.08863303f, -0.02108940f, 0.15179747f, -0.23083124f, -0.12764467f, -0.06983618f, -0.15490028f, 
    0.31118950f, -0.01539424f, 0.08740302f, 0.21560128f, 0.15823500f, 0.06587224f, 0.16134036f, 0.19345756f, 
    0.40962479f, -0.04092802f, 0.04600856f, -0.10065113f, -0.20315564f, 0.06848234f, -0.08313890f, 0.07897735f, 
    -0.19211656f, -0.10421041f, -0.21153292f, -0.36548463f, -0.18519442f, -0.18990724f, -0.06314163f, 0.11343519f, 
    -0.21389520f, 0.01666599f, -0.15048586f, -0.16821492f, 0.15424222f, -0.10498293f, -0.16312416f, 0.18976627f, 
    -0.22410664f, -0.09086348f, -0.11163860f, 0.24640644f, -0.08917008f, -0.19984166f, -0.18051815f, -0.15941322f, 
    0.24909696f, 0.33205724f, 0.38544551f, 0.22984193f, -0.16564085f, -0.34559125f, 0.33750117f, -0.40930787f, 
    -0.00348592f, 0.25817370f, -0.00274373f, 0.16873942f, -0.09422329f, -0.08453359f, -0.03749932f, 0.16776536f, 
    -0.39281970f, 0.18862614f, -0.25046843f, 0.01989338f, 0.07146424f, -0.00561866f, -0.08196635f, -0.11611459f, 
    -0.11812162f, -0.10569854f, 0.13549583f, 0.07160436f, 0.09978094f, -0.19151939f, 0.08394314f, 0.00146229f, 
    0.20149937f, 0.02479316f, 0.16660099f, 0.00322346f, 0.01745241f, 0.02592874f, -0.05716293f, 0.09466077f, 
    -0.29696715f, 0.19323768f, 0.01970546f, -0.02245260f, 0.24894446f, 0.12323611f, 0.12251274f, 0.01699825f, 
    -0.07590998f, 0.03952690f, -0.01022479f, -0.03309208f, -0.12136751f, -0.21945503f, -0.11638649f, -0.04181509f, 
    0.19148071f, 0.12409842f, 0.11837886f, 0.30383074f, -0.09569205f, 0.10035198f, 0.10194504f, -0.08043680f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10028700f, -0.01226074f, -0.09332351f, 0.01099267f, 0.09763659f, -0.03740117f, -0.11593384f, -0.26292333f, 
    0.06197165f, -0.05122759f, -0.05919044f, 0.16523510f, 0.01076586f, 0.19977358f, 0.33080885f, 0.05508839f, 
    -0.01209174f, 0.23317809f, -0.07193207f, 0.01346739f, 0.10944622f, 0.06171548f, 0.16560400f, 0.05525100f, 
    -0.03984882f, -0.06028752f, 0.26183933f, -0.03207111f, 0.23663366f, -0.08448058f, 0.14953487f, 0.21992499f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.36666203f, -0.85753238f, 0.29231060f, -0.09142891f, 0.40430245f, -0.91216815f, 0.04331385f, 0.55744207f, 
    0.09053548f, -0.17282991f, 0.13044310f, 0.18729143f, -0.14810340f, 0.16620049f, -0.18047071f, 0.12302135f, 
    -0.08303349f, -0.48404631f, -0.77438331f, -0.05466580f, -0.19193441f, 0.16255173f, 0.08188841f, 0.22223401f, 
    0.21045403f, -0.38456550f, -0.16267963f, 0.16302270f, -0.63448066f, 0.30011436f, -0.84904063f, -0.38989463f, 
    -0.11173289f, 0.47227427f, 0.24611259f, 0.11930802f, 0.06554452f, -0.00149072f, -0.06718149f, -1.07951295f, 
    0.49477002f, -0.00649431f, 0.21138498f, 0.04848602f, -0.07059950f, 0.19994198f, 0.60001326f, -0.04552488f, 
    0.07464352f, 0.03624690f, -0.01332387f, -0.72025883f, -0.34864700f, 0.14566222f, -0.16388828f, 0.10055241f, 
    0.26345289f, -0.04373767f, 0.02207275f, 0.03987105f, -0.36603960f, 0.17803589f, -0.28304160f, 0.12279521f, 
    -0.47609234f, -0.87459266f, -0.74461788f, 0.07318960f, -0.15607098f, 0.10548096f, 0.10930853f, -0.17489192f, 
    0.28470442f, 0.08960269f, -0.42763394f, 0.04742070f, 0.12269842f, 0.03830831f, 0.55947471f, 0.09485447f, 
    0.02200868f, -0.09274597f, 0.18919945f, 0.09743011f, -0.12127379f, -0.01311466f, 0.14686392f, 0.14573519f, 
    0.06592718f, -0.71077055f, 0.27150020f, -0.05064117f, 0.16430797f, -0.08480453f, 0.18725996f, -0.18933372f, 
    -0.44806197f, -0.06501138f, -0.20932752f, -0.03757859f, 0.09042235f, 0.26775661f, 0.04592570f, 0.25180015f, 
    0.01489927f, -0.00143727f, 0.12624876f, -0.12204657f, 0.01309799f, 0.03759810f, -0.33364260f, -0.13308245f, 
    -0.17314699f, -0.62016112f, 0.32239187f, 0.30911693f, -0.05236570f, 0.15006912f, -0.36694187f, -0.28230613f, 
    0.25953084f, -0.24004436f, -0.69629306f, -0.15310714f, 0.15973791f, 0.38814175f, 0.21199559f, -0.00133810f, 
    -0.57882470f, 0.22149064f, 0.38321590f, -0.00504843f, -0.49718004f, 0.09094748f, 0.26041138f, 0.11889484f, 
    -0.20831063f, 0.16226690f, 0.08343640f, -0.81020826f, 0.02534548f, -0.06704964f, -0.20384136f, -0.07110601f, 
    0.07993890f, -0.26408675f, -0.12917395f, 0.12626706f, 0.40164879f, -0.04972211f, 0.00757555f, 0.23778689f, 
    -0.14111818f, 0.11063104f, 0.11547779f, 0.07237339f, 0.08466916f, -0.08398816f, -0.21677855f, -0.56581450f, 
    -0.12681232f, 0.01448322f, 0.13268667f, -0.15731008f, 0.37301004f, -0.81313056f, -0.35613909f, -0.25024080f, 
    -0.47351825f, -0.14085534f, 0.16363698f, -0.24327682f, 0.01737681f, 0.15548119f, -0.22895133f, -0.15228550f, 
    -0.07020973f, 0.12575842f, 0.20465909f, -0.11451730f, 0.39689592f, -0.09959961f, 0.30401146f, -0.01502102f, 
    -0.32738170f, -0.06757231f, 0.15982570f, -0.09155829f, -0.22643860f, -0.08221688f, -0.19748007f, 0.36200872f, 
    0.49780023f, -0.51341683f, -0.59494138f, 0.06557844f, -0.92762899f, -0.04883923f, -0.02174388f, -0.63345766f, 
    -0.78904384f, -0.01897518f, -0.59670895f, 0.02933777f, -0.13780123f, -0.04445882f, 0.07569583f, 0.03048967f, 
    0.09533131f, 0.18593431f, -0.46404386f, 0.27672288f, -0.75613314f, 0.01422665f, -0.60547137f, -0.39304429f, 
    0.29693517f, -0.06972369f, 0.38830400f, 0.02586569f, 0.20296992f, -0.92245692f, 0.19052997f, 0.23967551f, 
    0.09850926f, 0.19467890f, -0.12589483f, -0.16449255f, 0.35000297f, 0.16283964f, -0.53414166f, 0.42466739f, 
    -0.41300800f, -0.04613652f, -0.60896081f, 0.22134139f, 0.14281493f, -0.67546421f, -0.13060935f, -0.08046702f, 
    0.11739062f, 0.05897606f, 0.34963542f, -0.20741095f, -0.20512146f, 0.06681813f, 0.27390990f, -0.18659341f, 
    0.14517583f, 0.18155162f, 0.05075393f, -0.08777069f, -0.52148771f, -0.21040396f, 0.03318320f, -0.51773190f, 
    -0.19502501f, -0.24302669f, -0.67829275f, -0.11799783f, 0.39493272f, -0.62713122f, -0.23353052f, -0.33489114f, 
    -0.00154105f, 0.12238005f, -0.87514728f, 0.59405088f, -0.14918441f, 0.19076277f, -0.42119521f, -0.12613097f, 
    -0.09878507f, -0.20670114f, -0.13511361f, -0.57537645f, 0.23609474f, 0.16414538f, -0.05893377f, 0.14088772f, 
    0.06468613f, 0.31689733f, -0.56663942f, 0.14522289f, 0.37236598f, -0.13363497f, 0.44124109f, 0.23221740f, 
    0.43296891f, -0.07588848f, -0.00826064f, -0.05199026f, 0.07485346f, 0.65449321f, -0.11056803f, -0.13253520f, 
    -0.46650347f, -0.02970464f, 0.28815815f, -0.00359776f, 0.03276351f, 0.20838290f, 0.07580607f, 0.00577810f, 
    -0.12448225f, -0.24479319f, -0.83579195f, 0.30809927f, -0.07293393f, 0.10536147f, 0.20465143f, 0.02826544f, 
    -0.85806960f, -0.33049607f, 0.25107172f, -0.13876969f, -0.18887082f, -0.29500413f, -0.16637276f, -0.24458358f, 
    -0.11240884f, -0.35140350f, -0.14184973f, -0.11803138f, -0.47421116f, -0.04150842f, 0.02595414f, -0.63556516f, 
    0.36895126f, 0.05396192f, -0.15499155f, -0.57851404f, 0.12009793f, 0.47709435f, -0.52851802f, -0.11780137f, 
    -0.09369766f, 0.55500537f, 0.02669528f, 0.09885434f, 0.00779688f, -0.14282012f, 0.27472782f, -0.47392508f, 
    0.24561507f, -0.43058357f, -0.49773243f, 0.15311523f, 0.54566044f, -0.06823299f, -0.41037521f, 0.18391560f, 
    -0.16660039f, 0.01057074f, -0.05895228f, 0.09301260f, -0.63585460f, -0.41767842f, 0.10608792f, -0.31724724f, 
    0.58568466f, 0.08227454f, 0.41738600f, -0.05746742f, -0.10339157f, -0.64706200f, -0.59245551f, 0.11314992f, 
    0.05576267f, 0.40415180f, 0.13385205f, 0.17627999f, -0.32788676f, 0.11991768f, -0.61086398f, 0.26469275f, 
    -0.40566772f, 0.34612080f, 0.17661753f, 0.13428541f, -0.10354541f, -0.24674594f, 0.14883028f, 0.24414460f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.19246893f, 0.17272833f, -0.03859915f, -0.19138199f, 0.08819813f, 0.20674661f, 0.18588814f, -0.02872714f, 
    -0.03133092f, -0.04036754f, 0.01423431f, -0.11958760f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
