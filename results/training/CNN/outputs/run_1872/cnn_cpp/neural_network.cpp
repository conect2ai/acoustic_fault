#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.73369712f, -1.50121868f, 0.62878925f, -0.48965508f, -0.43530545f, -0.99680972f, -0.19789888f, -0.26168761f, 
    -0.64557862f, -1.45737231f, 0.64204031f, 0.23928961f, 0.72464585f, -1.08084857f, -0.76417994f, -0.35300466f, 
    -0.40548733f, -0.34880358f, -0.93649906f, -0.71124804f, -1.11537337f, -0.48380950f, -0.87882096f, 1.08019674f, 
    0.14699923f, -0.07915273f, -0.16876389f, 0.48554245f, 0.72431511f, 0.07517315f, -0.52402556f, 0.55714351f, 
    -1.01472771f, -0.22007363f, 0.38098642f, 0.94915301f, -0.74168408f, -0.08131285f, 0.15003572f, -0.89235747f, 
    -0.49180672f, 0.48212075f, -0.35814849f, -0.68097031f, -0.60738677f, -1.20087349f, 0.04688821f, 1.04379976f, 
    -0.74185163f, -1.04112983f, -0.49479181f, 0.35331154f, 0.80740350f, -0.22522345f, -1.06091535f, -0.77134120f, 
    -0.55667824f, 0.33615863f, 0.25213298f, 0.25479314f, -0.07378032f, -0.40384760f, -0.85572499f, -0.47116122f, 
    0.15564920f, 0.55871922f, 0.46236694f, 0.79107690f, -0.89839023f, -0.54212695f, 1.15454805f, -0.85272497f, 
    -0.80625093f, 1.38946068f, -0.53690082f, 0.18348563f, -0.16352309f, 0.22447352f, 0.54318500f, 0.49063733f, 
    0.28975204f, 0.68074942f, 0.74081522f, -0.00507446f, 0.40636083f, 0.33999819f, 0.07241116f, -0.07172994f, 
    0.58749521f, 0.30458319f, -1.13152766f, 0.15530534f, -0.80688894f, -0.00512232f, 1.18979609f, 0.60799968f, 
    0.28628916f, 0.14555945f, 0.42702946f, 0.67995214f, -0.58149683f, 0.67261523f, -0.05615029f, -0.52125221f, 
    0.85921860f, 0.97351891f, -0.53278488f, -0.34588850f, -0.48456770f, -0.29723674f, -0.04008697f, 0.13435331f, 
    -0.85957569f, 0.08386394f, 0.12325333f, 0.80904478f, 0.46341273f, -0.35406312f, 0.01333930f, 0.44585952f, 
    0.57400984f, 0.61134058f, 0.11271456f, -0.39571881f, -0.41876033f, -0.59486949f, -0.73417842f, -0.69336504f, 
    1.04719305f, 0.47131309f, 0.45198509f, 0.58027083f, -0.34478071f, -0.17613882f, 0.13562147f, -1.58426607f, 
    1.35940492f, -0.02889828f, -0.59862381f, -0.65388423f, -0.55992478f, -0.35988346f, -0.10792489f, 0.32111883f, 
    0.55626476f, -0.09631446f, -0.54646391f, 0.43202558f, 0.32119194f, 0.35323867f, -0.54907286f, 1.20705307f, 
    -0.85739625f, 0.26028574f, 0.87594223f, -1.25741041f, 0.38219675f, 0.57169390f, -0.83795464f, -0.25313956f, 
    -0.19554321f, -0.21192740f, 0.44647437f, 0.49008727f, 1.20546210f, -0.99996418f, -0.65940422f, 0.43266883f, 
    0.08899423f, -0.03859364f, -0.27021235f, -0.49109581f, 1.03613579f, -0.31221244f, -0.17420787f, -0.17282164f, 
    0.71652019f, 0.47895396f, -0.63960385f, -0.69542515f, -1.18985665f, -1.07699072f, -0.66866666f, 0.37663019f, 
    0.42297691f, -0.29050255f, 0.06187719f, 0.39364395f, 0.23259166f, -0.70959401f, -0.11750107f, 0.30748922f, 
    -0.32058245f, 0.61061281f, 0.94042969f, 0.49543214f, -0.69501668f, -0.43375754f, 0.14448294f, 0.18541197f, 
    0.32508692f, -0.66007030f, -0.08524908f, -0.27447271f, 0.20761409f, -0.57617408f, -0.63934606f, -1.18165433f, 
    -0.52001733f, 0.53789872f, 0.07877913f, -0.16880624f, 0.08292307f, 0.74416822f, 0.35007381f, 0.70085394f, 
    -0.41563430f, -0.92347246f, 0.30752748f, 1.23912358f, -0.38939771f, -1.50086880f, -0.00797206f, -0.53183746f, 
    -0.35362443f, -0.78717357f, -0.68581778f, -0.74455005f, 0.87738007f, 0.28949568f, -0.05794587f, -0.55120355f, 
    -0.82436013f, -0.60730511f, 0.11743488f, -1.05880713f, -1.10036314f, 0.52757221f, 0.96837562f, 0.56961805f, 
    -0.35843182f, 0.20205039f, -0.23380719f, 1.00868714f, 0.20263360f, 0.92662752f, -0.65566593f, -0.52452672f, 
    -0.73335081f, 0.24720258f, 0.10351820f, 1.02952969f, 0.72894746f, 0.77387977f, -0.41249666f, 0.52231026f, 
    -0.11286020f, 0.14986315f, 0.40392131f, 0.38088715f, -0.50501198f, 0.34135473f, -0.11333651f, 0.55884951f, 
    0.55808216f, 0.30245405f, 0.42034894f, -0.14816752f, -0.74775457f, -0.27606934f, 0.50566989f, 0.97024435f, 
    0.34096220f, -0.04712221f, 0.77359772f, 0.29998663f, -0.38272527f, -0.55692536f, 0.18865018f, 0.16795057f, 
    -1.34825075f, 1.13003802f, -0.06854025f, -0.55655193f, 0.64352542f, -0.00820631f, 0.01476099f, -0.00954513f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18780437f, 0.02667129f, 0.01073254f, 0.11428000f, 0.14738882f, 0.35255396f, 0.53985232f, 0.54452056f, 
    0.21534476f, 0.78126663f, 0.21683787f, 0.43175173f, 0.33866122f, -0.19031084f, 0.45378238f, 0.44993651f, 
    0.65569139f, 0.26009500f, 0.10678881f, -0.03359521f, 0.25460076f, 0.34258866f, 0.50540215f, 0.08676981f, 
    0.27526712f, 0.31699479f, 0.17471068f, 0.36355627f, 0.82120073f, 0.62102729f, -0.28601426f, -0.07204009f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.03547178f, -0.04500013f, -0.00036392f, 0.02825266f, -0.03060967f, 0.02737027f, 0.02515805f, 0.04629382f, 
    -0.02841611f, 0.05203717f, -0.04856408f, -0.04295349f, -0.04410443f, 0.00359114f, -0.06321461f, -0.05931631f, 
    0.02890835f, -0.03077406f, -0.00864428f, -0.00655718f, -0.02748655f, -0.00988807f, 0.04298213f, -0.05431403f, 
    0.00022836f, -0.02197005f, 0.03269584f, -0.06052728f, -0.05071327f, 0.04639466f, -0.03614632f, 0.04207150f, 
    -0.00186245f, -0.02388419f, 0.04346886f, -0.04970381f, 0.00498368f, -0.00231077f, 0.05290327f, -0.05922115f, 
    0.02264823f, -0.02314723f, 0.03160585f, 0.04376017f, 0.02576754f, 0.00202205f, 0.05138771f, -0.00692321f, 
    -0.06333561f, 0.00979252f, -0.05509327f, 0.01493603f, -0.00408213f, -0.01180737f, 0.04460499f, 0.00251071f, 
    -0.05983847f, 0.04919668f, 0.01350268f, -0.06327581f, -0.05634613f, -0.04828198f, -0.06176406f, 0.01770994f, 
    -0.02720823f, 0.03081624f, -0.00939660f, -0.00521649f, 0.00547001f, 0.01657405f, -0.05622501f, -0.00864313f, 
    -0.01029735f, -0.03361075f, 0.01048656f, -0.03202944f, -0.01310424f, -0.00355640f, 0.02008023f, 0.02105273f, 
    -0.06109364f, -0.03727192f, -0.05991031f, -0.05866396f, -0.04400069f, -0.06073701f, -0.05364789f, 0.01233596f, 
    0.03995725f, -0.02123252f, 0.03570317f, 0.03211814f, 0.01285881f, 0.02440809f, -0.05185709f, 0.01345867f, 
    -0.03974808f, -0.03926459f, 0.03556722f, -0.02767263f, 0.00610180f, 0.03798053f, -0.03926313f, 0.01132236f, 
    0.03941922f, 0.02194998f, 0.04736930f, -0.01111547f, -0.02097269f, -0.00090825f, -0.03604794f, 0.01159790f, 
    -0.02982450f, -0.04504930f, 0.02762411f, 0.02048007f, 0.04026548f, 0.06047617f, -0.02053956f, 0.04290698f, 
    -0.05653790f, 0.03069051f, -0.03502507f, -0.04767725f, -0.00789586f, -0.00698506f, 0.04415885f, 0.01727863f, 
    0.03165053f, -0.06084365f, 0.04423185f, -0.04536353f, -0.01255754f, -0.00093164f, -0.02369464f, 0.01591936f, 
    0.03930672f, 0.00305771f, -0.04584583f, 0.03700937f, 0.02285504f, -0.00499059f, 0.02399193f, -0.00097858f, 
    -0.03442470f, 0.02621772f, -0.03894655f, 0.04891581f, 0.03124993f, -0.02403119f, -0.02617777f, -0.04334512f, 
    -0.01644599f, -0.00583643f, -0.01914381f, 0.04957646f, 0.05245242f, 0.03427363f, -0.05580358f, -0.01716358f, 
    -0.02975238f, 0.04237864f, -0.02741713f, 0.02177135f, -0.02609047f, 0.03349506f, 0.03038161f, -0.01837896f, 
    0.03145473f, -0.04200575f, -0.03563082f, 0.01019517f, -0.00027655f, -0.01169536f, 0.00691936f, 0.04348028f, 
    -0.05346228f, -0.01766419f, -0.03501559f, -0.02253264f, -0.06036434f, -0.00932768f, -0.02122768f, -0.02287196f, 
    -0.00764927f, 0.00396654f, 0.00710045f, -0.06336233f, 0.03119336f, -0.05210266f, 0.00221957f, -0.04202069f, 
    -0.01989323f, 0.03453639f, 0.04989866f, 0.04327025f, 0.04005180f, -0.00454502f, -0.03743787f, -0.05846706f, 
    -0.02644598f, -0.00568308f, -0.01227880f, 0.01842517f, -0.02375178f, -0.05037847f, -0.00595972f, 0.05091701f, 
    0.04237982f, -0.05521470f, 0.02344718f, 0.01022417f, -0.03186397f, -0.01666738f, -0.00815234f, 0.04813796f, 
    -0.02409839f, 0.01474134f, -0.02005086f, -0.02672284f, 0.00946925f, -0.06127334f, -0.06342602f, -0.01869096f, 
    -0.01204224f, 0.02347737f, -0.00087370f, 0.00043107f, -0.03298489f, 0.00635723f, 0.04867958f, -0.04217305f, 
    -0.02562506f, -0.03449223f, -0.06361357f, 0.01130279f, -0.03663453f, 0.02491696f, 0.00400964f, -0.06060693f, 
    -0.03366501f, -0.01352342f, 0.02065506f, -0.03873385f, -0.03458365f, -0.03136142f, 0.01997555f, 0.05036593f, 
    0.03930342f, -0.05555930f, 0.03788850f, 0.02833848f, -0.04831456f, -0.05600419f, 0.03020843f, -0.05699477f, 
    -0.02170050f, -0.05745006f, -0.04626144f, -0.05027322f, 0.01425989f, 0.05175936f, -0.00906643f, -0.04428805f, 
    -0.04498025f, -0.06327254f, 0.02629937f, -0.01245543f, -0.04733286f, 0.03873599f, 0.02469644f, 0.01240568f, 
    -0.03831836f, -0.02431013f, 0.02659627f, -0.06362125f, -0.02024824f, -0.01320237f, -0.06268039f, 0.00447055f, 
    -0.01794206f, 0.00685290f, 0.03663833f, -0.00977128f, -0.02935002f, 0.02917493f, -0.03081142f, 0.01094012f, 
    0.42079499f, 0.27516934f, -0.05044927f, 0.21372630f, 0.09663272f, 0.11686456f, 0.17796466f, -0.18243457f, 
    -0.03979817f, -0.19292878f, 0.11942803f, -0.13257414f, -0.01961589f, -0.06856475f, 0.10397097f, -0.13848116f, 
    0.00387914f, -0.07738061f, 0.13808949f, -0.15364020f, 0.20829149f, -0.07599087f, -0.01057137f, -0.07832912f, 
    0.07137217f, 0.08551124f, 0.10808562f, 0.09832110f, 0.05674007f, 0.24874541f, -0.01710059f, -0.05260658f, 
    0.02727095f, 0.10198662f, 0.19093338f, 0.06876705f, 0.02927583f, 0.21089435f, 0.05898169f, -0.01152203f, 
    0.05927270f, 0.03041185f, 0.13848650f, 0.06195602f, -0.02760788f, 0.04293681f, -0.01252415f, 0.30125314f, 
    0.06527291f, 0.13937220f, 0.22873957f, 0.05079139f, 0.21139386f, -0.05539401f, 0.14311323f, -0.08916700f, 
    -0.37807739f, -0.04788594f, 0.02078301f, 0.04969248f, -0.03865562f, -0.18737406f, 0.07122912f, -0.11221687f, 
    -0.05516240f, 0.31500658f, 0.00980480f, 0.11615080f, -0.16846696f, -0.17734478f, 0.18423921f, 0.02553404f, 
    0.06802014f, -0.05436774f, -0.04957293f, -0.07851578f, 0.06691623f, 0.08907333f, 0.14277239f, 0.30182463f, 
    0.09339213f, -0.02420119f, 0.06289381f, 0.13406701f, -0.08475868f, -0.02128256f, 0.02916178f, -0.08037474f, 
    0.05241356f, -0.06579355f, 0.14231759f, -0.32505190f, -0.23053525f, -0.08250549f, -0.01492895f, 0.16776390f, 
    0.11622357f, 0.15295973f, 0.11698157f, 0.08992557f, -0.01645172f, 0.19340521f, -0.23975082f, -0.11142213f, 
    -0.00832719f, -0.25241703f, -0.05170009f, -0.06492130f, 0.18043524f, 0.06782779f, 0.14248787f, 0.03452685f, 
    0.09290435f, -0.15219173f, 0.12008768f, 0.26701963f, 0.11432923f, -0.18683825f, -0.00679867f, -0.02601019f, 
    0.10200165f, 0.03515445f, 0.11749188f, 0.01870113f, -0.49805284f, -0.34065658f, -0.08546147f, -0.12013155f, 
    -0.17531613f, -0.19536720f, 0.10470750f, 0.09149891f, -0.05914615f, -0.16553496f, -0.06748965f, -0.15960586f, 
    0.08209919f, 0.09177195f, 0.10034580f, 0.15215535f, 0.25877020f, -0.04859677f, 0.15555052f, -0.06239095f, 
    -0.01060606f, -0.07228480f, 0.39191091f, 0.21323265f, -0.02151782f, 0.08969387f, -0.29947829f, 0.02556878f, 
    -0.08562893f, 0.09070138f, 0.25605360f, -0.17020668f, 0.24952786f, -0.20782851f, 0.33341557f, 0.09534973f, 
    0.06407038f, -0.24520320f, -0.08703881f, -0.03011038f, -0.03273589f, -0.11802840f, -0.01007705f, -0.01962113f, 
    -0.14273356f, 0.15099587f, 0.07580623f, 0.00636244f, 0.11038373f, 0.01404409f, 0.16636831f, -0.15758774f, 
    -0.01291470f, -0.13392907f, -0.15876611f, 0.03362136f, 0.23760289f, -0.00705574f, -0.18370250f, -0.05887885f, 
    0.04105465f, -0.24449207f, 0.02712275f, 0.10907051f, 0.09425502f, -0.02629824f, 0.06951212f, -0.03305844f, 
    -0.14862286f, -0.19620094f, -0.10824659f, 0.04681742f, -0.20802200f, -0.07401883f, -0.04480873f, 0.14976238f, 
    -0.08149172f, 0.07244266f, -0.01841449f, 0.00270833f, -0.22037429f, 0.08122479f, -0.03749630f, 0.15747133f, 
    -0.08781852f, -0.06240458f, 0.12272982f, -0.04137346f, -0.15936019f, 0.12085397f, 0.24640025f, 0.09492981f, 
    0.09859949f, -0.00750088f, -0.15557277f, 0.06364189f, -0.06450301f, 0.06493817f, 0.15630530f, -0.01756263f, 
    0.14090651f, -0.07747857f, -0.07445816f, -0.36976364f, -0.05936201f, 0.04863620f, 0.01721795f, -0.06591160f, 
    -0.19578126f, -0.00792583f, -0.13629919f, -0.41589293f, -0.46621716f, -0.08110018f, -0.11797877f, 0.11762594f, 
    -0.12700637f, 0.04335057f, -0.08345398f, 0.11577703f, 0.06769058f, 0.24762550f, -0.06067931f, -0.00634505f, 
    0.05201748f, 0.06900309f, 0.09627484f, -0.08764920f, 0.10449094f, 0.10210801f, 0.18338616f, -0.03872102f, 
    0.04561219f, 0.18522395f, -0.13521959f, 0.05290068f, -0.00407072f, -0.14355280f, 0.01207536f, -0.02798519f, 
    -0.02249955f, 0.03410092f, 0.09675498f, 0.03542127f, -0.34790245f, -0.52220237f, 0.00988650f, 0.15649436f, 
    0.04409735f, -0.01871490f, -0.23386131f, 0.06182013f, 0.04676505f, 0.04354013f, -0.42078063f, 0.16145749f, 
    -0.04815287f, 0.11033879f, 0.01673051f, -0.00997093f, 0.30780718f, -0.19447260f, -0.10984891f, 0.03700020f, 
    0.05220344f, 0.00333439f, -0.01894235f, -0.00238840f, -0.02246050f, -0.01450262f, -0.05913191f, -0.03961857f, 
    -0.03197682f, 0.03648299f, 0.04071133f, -0.04470231f, 0.04215675f, 0.02949302f, 0.00408757f, 0.04163425f, 
    -0.02710017f, -0.02674316f, 0.04792152f, 0.04522806f, -0.04806252f, -0.04342749f, -0.00798458f, -0.00636093f, 
    -0.03176897f, -0.00244340f, -0.00690636f, -0.05154332f, 0.00482450f, -0.02279813f, 0.02252018f, 0.04912503f, 
    -0.05344969f, -0.06227185f, -0.03549583f, 0.00287776f, -0.00035873f, 0.00063178f, -0.05159125f, -0.00730097f, 
    -0.05122485f, 0.01414030f, 0.00755746f, -0.01236842f, -0.05066333f, -0.04685496f, 0.03896121f, -0.02939899f, 
    0.03662833f, 0.04213975f, 0.01808999f, -0.01543271f, 0.03096009f, 0.01049532f, -0.03739574f, 0.01810076f, 
    -0.01676397f, 0.03648727f, 0.03069850f, -0.03344472f, -0.06039405f, 0.01704807f, 0.04831136f, 0.04141207f, 
    0.05083824f, -0.04750261f, -0.06265078f, 0.04733684f, -0.05281355f, 0.03626096f, -0.01248983f, 0.05139879f, 
    -0.00509949f, -0.01023676f, 0.03985670f, -0.00724852f, -0.04789240f, -0.05966269f, -0.05518612f, 0.01380700f, 
    -0.03011366f, 0.03656930f, -0.02584880f, 0.05549771f, -0.05256354f, -0.04140174f, -0.00847027f, 0.04052868f, 
    -0.00663176f, 0.04829514f, -0.02840924f, 0.02212012f, -0.00908226f, -0.03474626f, 0.04522893f, 0.05106617f, 
    0.00236103f, 0.02265034f, 0.00712335f, 0.00167267f, -0.03437735f, 0.01802799f, -0.00826255f, -0.00773509f, 
    -0.00516961f, -0.05076755f, -0.00254881f, -0.04221582f, -0.04497423f, 0.04632515f, 0.00956419f, 0.00443798f, 
    -0.02498034f, -0.01765825f, -0.01986462f, -0.05299127f, 0.04312421f, 0.04670662f, 0.01712402f, 0.02760663f, 
    0.00979505f, -0.03944380f, 0.02695278f, 0.03582035f, 0.00654850f, -0.04990594f, -0.05021312f, -0.01428078f, 
    -0.04538304f, -0.02004591f, -0.04917526f, -0.01564056f, -0.05057761f, -0.03041936f, -0.02310050f, -0.04698830f, 
    0.03290705f, 0.04359046f, -0.06186737f, -0.04867123f, -0.04909267f, 0.01903078f, -0.02994977f, 0.02487376f, 
    -0.05088276f, -0.04583154f, -0.06193586f, 0.03877854f, -0.02072528f, -0.03917040f, -0.04109950f, -0.00028808f, 
    0.03808053f, -0.04457376f, 0.02953470f, 0.01056874f, 0.04248863f, -0.03348345f, 0.04958561f, 0.01292491f, 
    -0.02862098f, 0.05144337f, 0.02831688f, 0.03312358f, 0.03031434f, -0.02285170f, -0.06279371f, 0.01052666f, 
    0.03274724f, 0.05133096f, 0.04353829f, 0.00776503f, 0.02259272f, 0.04223168f, -0.02213192f, -0.04331417f, 
    0.02856469f, 0.03722640f, 0.00348760f, -0.04514528f, -0.05626519f, -0.06150924f, -0.03849581f, -0.05785408f, 
    0.03551090f, 0.00741524f, -0.00725653f, 0.04561204f, -0.02725677f, -0.05506993f, -0.02204824f, -0.06113680f, 
    0.01109101f, -0.00830449f, 0.02934848f, -0.03326087f, -0.05215883f, 0.00297534f, -0.04880346f, -0.03823956f, 
    0.00267874f, 0.01032707f, -0.05397386f, 0.03898196f, -0.02324826f, 0.04280785f, -0.03024642f, -0.06038444f, 
    0.01109024f, -0.01544825f, 0.02310995f, 0.02739653f, 0.02058705f, -0.06263398f, -0.05258819f, -0.00225951f, 
    -0.02312119f, 0.01318325f, -0.00834621f, 0.00820397f, -0.06271844f, -0.04119555f, -0.01177285f, 0.02895657f, 
    -0.04226112f, -0.02541871f, -0.01623446f, -0.05725745f, -0.05808570f, -0.01163126f, 0.03850894f, -0.04270786f, 
    0.04529865f, 0.03048260f, 0.01016534f, -0.02169636f, -0.04309211f, -0.02553522f, -0.05062461f, -0.00196621f, 
    0.02562441f, -0.01319862f, 0.01486966f, -0.04832364f, -0.03003218f, -0.04581121f, -0.03487811f, 0.00443754f, 
    0.03993868f, 0.03658016f, -0.00407689f, 0.01085748f, 0.02379900f, 0.03267288f, 0.05520478f, -0.02015352f, 
    -0.05170003f, -0.02175997f, 0.05245857f, -0.03834347f, -0.05348448f, -0.05393471f, 0.05068207f, 0.04104425f, 
    -0.03698962f, 0.03183903f, -0.02882681f, -0.01517934f, -0.01747633f, -0.03723636f, -0.00268735f, -0.02944192f, 
    0.01861950f, 0.02133117f, 0.00822945f, -0.04053966f, 0.03833579f, -0.03738206f, 0.03899856f, -0.02658955f, 
    -0.04496573f, 0.04024078f, 0.00610872f, -0.03972372f, -0.02635239f, -0.01993443f, -0.05672551f, -0.02615680f, 
    -0.00785481f, 0.17079136f, 0.22048414f, -0.03536495f, 0.11255060f, -0.11297651f, -0.08163404f, -0.18981762f, 
    -0.04870528f, 0.25923425f, -0.23844999f, 0.12619427f, -0.04525137f, 0.10174131f, 0.14799872f, 0.10392102f, 
    -0.01062803f, -0.03498954f, -0.28385797f, 0.16844799f, 0.24564408f, -0.10958534f, 0.17782877f, -0.22538370f, 
    0.02381520f, 0.17765640f, -0.07942268f, -0.27341515f, -0.58237809f, -0.28206700f, 0.09396726f, 0.16008306f, 
    -0.24954452f, 0.02224588f, -0.03943919f, 0.17069229f, -0.26228860f, 0.00780125f, 0.07881058f, -0.10184184f, 
    0.05807221f, -0.15128005f, 0.12862052f, 0.06278262f, 0.01228646f, 0.01854219f, 0.07246917f, 0.50704044f, 
    -0.03330239f, 0.07913740f, 0.16842568f, -0.02944071f, -0.05747910f, 0.24220408f, 0.22462337f, 0.14068869f, 
    0.34651953f, -0.03863997f, 0.05160682f, 0.06619276f, 0.20716986f, 0.06577234f, -0.14176911f, -0.20280144f, 
    -0.57552940f, 0.60464555f, 0.11813074f, -0.16283004f, -0.00549488f, 0.06868481f, -0.07632181f, 0.05855371f, 
    0.04288403f, -0.13177732f, -0.18077146f, -0.17366202f, 0.17917459f, 0.26681858f, 0.06449048f, 0.27244458f, 
    0.03832004f, -0.46003065f, -0.32701498f, -0.14084888f, -0.03499975f, -0.11166231f, 0.01911235f, 0.01734294f, 
    0.19294418f, 0.06129041f, 0.05904718f, -0.29939023f, 0.26933917f, -0.32730907f, -0.01718961f, 0.23054844f, 
    -0.01407153f, 0.12905359f, -0.00524876f, -0.75014114f, -0.73563111f, -0.16134124f, -0.09051782f, -0.16973178f, 
    0.16390508f, 0.09678476f, 0.01379582f, 0.02770157f, 0.14164683f, 0.19364668f, 0.24217962f, 0.06611232f, 
    0.18076850f, 0.13588180f, -0.00232855f, 0.19680960f, 0.09904548f, -0.15488364f, -0.20462354f, 0.20744175f, 
    -0.09740205f, -0.02305313f, 0.00591310f, 0.13000262f, -0.13156050f, 0.06336942f, 0.18194997f, -0.35678887f, 
    0.24620135f, -0.19003995f, -0.14168966f, -0.00441939f, 0.04590560f, 0.10255520f, -0.03875815f, 0.24512266f, 
    -0.16242889f, 0.21084289f, 0.12269041f, 0.02374711f, 0.29853576f, 0.03389059f, 0.06583837f, 0.00407333f, 
    0.05038371f, -0.02044859f, 0.43033296f, 0.04879740f, 0.03768606f, -0.22339329f, 0.05019291f, -0.18355091f, 
    0.30012599f, -0.24089324f, 0.07275904f, 0.14913395f, 0.07561608f, -0.01783597f, 0.05721171f, 0.13831322f, 
    -0.04952560f, -0.15850291f, -0.33212909f, -0.95530516f, -0.55884862f, -0.08782090f, -0.18247023f, -0.00422165f, 
    -0.00941432f, 0.07797199f, 0.16341268f, -0.25502753f, -0.35854715f, -0.00696891f, -0.04224019f, 0.07736089f, 
    0.11084660f, 0.17688675f, -0.33003902f, 0.06244396f, 0.23831706f, -0.04443236f, 0.50061119f, -0.08028243f, 
    0.14909738f, -0.10026740f, -0.06116952f, 0.16959718f, 0.12771164f, -0.30262721f, -0.41970956f, 0.19207793f, 
    -0.22126079f, -0.25848430f, -0.15314430f, 0.04177802f, 0.02734781f, -0.00568524f, 0.07625753f, -0.10718805f, 
    -0.09313717f, 0.03878323f, 0.09775693f, 0.17253482f, 0.14978343f, 0.01491953f, -0.08540857f, 0.29321429f, 
    0.00996876f, 0.14215142f, -0.07334449f, 0.18354063f, 0.08768488f, 0.04794825f, 0.21848360f, 0.23426820f, 
    0.01253126f, -0.07257397f, 0.28229281f, -0.01160730f, 0.03946219f, -0.06730640f, 0.19678585f, -0.01859514f, 
    0.06604652f, 0.14191923f, 0.19814324f, 0.15895523f, 0.00017806f, 0.15695551f, 0.02124275f, 0.26709026f, 
    0.04988909f, -0.17647937f, -0.04694090f, -0.16484115f, 0.35521165f, 0.11225650f, 0.10901558f, -0.13882323f, 
    0.07036583f, 0.05861247f, 0.04159414f, -0.17625648f, -0.37530664f, -0.20256893f, -0.12734412f, 0.17600669f, 
    -0.04613268f, -0.15538415f, -0.05991169f, 0.13235825f, -0.37690023f, -0.36868602f, -0.10468809f, -0.13244617f, 
    0.05277542f, 0.08021550f, -0.19911593f, 0.02251888f, 0.07630702f, -0.18546940f, -0.21543348f, -0.11428849f, 
    0.06392884f, -0.07358497f, 0.04989046f, 0.27834955f, -0.02964364f, 0.09989950f, -0.34328184f, -0.65729719f, 
    0.15173854f, -0.02886721f, -0.01122533f, 0.01926731f, 0.15722467f, -0.18578734f, -0.03976173f, -0.89826912f, 
    -0.63904166f, -0.26849964f, 0.08328926f, -0.12236429f, -0.08450969f, 0.05752343f, 0.07514907f, 0.03729350f, 
    -0.00699850f, 0.10844144f, 0.05565074f, 0.20804638f, -0.05358777f, 0.05493155f, 0.05362860f, -0.10860672f, 
    -0.22836685f, -0.20617418f, 0.01144672f, 0.33635694f, 0.13919242f, 0.07506718f, -0.03971034f, 0.12653975f, 
    -0.19658624f, -0.17003727f, 0.19509242f, 0.10453246f, 0.11909088f, -0.08513910f, -0.16747858f, -0.14143230f, 
    0.13893504f, 0.15025464f, 0.05435271f, 0.20149870f, -0.10557555f, -0.04832676f, -0.14873183f, 0.00916024f, 
    -0.00431637f, 0.26253474f, 0.08709380f, 0.23244330f, -0.10034841f, -0.20249738f, 0.08735632f, 0.08761179f, 
    0.03085061f, 0.02148331f, -0.07654704f, 0.01374854f, 0.08465832f, -0.09139463f, -0.32558331f, 0.36636871f, 
    0.01550238f, 0.16602297f, 0.32934198f, 0.09749100f, -0.08093939f, 0.19468814f, -0.01240353f, -0.13548696f, 
    -0.08041499f, -0.05440952f, -0.15093218f, -0.17415990f, -0.05924494f, -0.15339670f, -0.08204666f, 0.03502085f, 
    0.14521386f, -0.05630595f, 0.21508268f, 0.01043930f, 0.28419822f, 0.19418898f, 0.33085006f, -0.42322427f, 
    0.13762660f, 0.00967600f, -0.05826423f, 0.16097014f, -0.01611672f, -0.12194185f, 0.01976405f, 0.29781079f, 
    0.13599184f, 0.19842027f, 0.13043360f, 0.03254367f, -0.00776804f, 0.00036919f, -0.02271041f, 0.14471303f, 
    0.08927975f, 0.01464990f, 0.24910887f, -0.21073805f, -0.19211529f, 0.18353862f, -0.02585460f, 0.03887496f, 
    0.04913305f, -0.05803196f, 0.06304040f, 0.06537114f, -0.11383530f, 0.11546542f, -0.09741686f, 0.13346027f, 
    0.06041183f, 0.06809889f, -0.18012540f, 0.24999292f, -0.07619954f, -0.03767781f, -0.08321691f, 0.02528778f, 
    0.02161554f, 0.15053412f, 0.17085883f, 0.13643180f, 0.07470945f, -0.10720068f, -0.00756853f, -0.01471555f, 
    -0.04643739f, 0.09038372f, 0.20061728f, -0.12013208f, -0.15332676f, -0.49687642f, -0.04824745f, -0.05122908f, 
    0.11256541f, 0.17398751f, -0.01447117f, 0.11538289f, -0.00913395f, -0.17099753f, -0.11993342f, -0.17889392f, 
    -0.33942848f, 0.29788646f, 0.16970010f, 0.19116715f, 0.18464974f, 0.03255788f, -0.25542930f, 0.10464095f, 
    0.34678110f, 0.06859342f, -0.05183195f, -0.10891604f, 0.12961683f, 0.16515997f, -0.20806204f, -0.05373581f, 
    -0.23204544f, -0.10130131f, 0.11106142f, -0.15460013f, -0.12248682f, 0.18058482f, 0.07498977f, -0.23669314f, 
    -0.25909188f, -0.35914493f, -0.15740615f, 0.01248431f, 0.21621516f, -0.03796464f, -0.05161148f, 0.10137133f, 
    -0.02456578f, -0.03025266f, 0.00224580f, -0.01573975f, 0.00601710f, -0.02318949f, 0.12486496f, 0.29856819f, 
    -0.03426033f, -0.18454409f, -0.39163560f, 0.15061238f, 0.05976033f, -0.02204724f, -0.02267039f, 0.06597017f, 
    -0.15639731f, -0.09495407f, 0.04100877f, -0.00003202f, -0.01503744f, 0.01843582f, 0.02796368f, 0.00408134f, 
    -0.02654984f, 0.19372833f, -0.06019102f, -0.00356932f, -0.17292964f, -0.20069095f, -0.06094985f, 0.04417665f, 
    0.17437762f, 0.09673811f, 0.11698379f, 0.05408755f, -0.22236414f, 0.04364894f, -0.03715957f, 0.13485314f, 
    -0.18239371f, -0.03608920f, 0.19116727f, -0.08227280f, -0.00387635f, 0.06077507f, 0.19581750f, 0.21584477f, 
    -0.12152899f, 0.12756711f, 0.19205606f, 0.01984213f, 0.07029938f, -0.01478195f, -0.02449962f, -0.05455206f, 
    -0.12010355f, -0.11548954f, -0.04882048f, -0.16171885f, -0.10681408f, -0.11303214f, -0.03327061f, -0.16990641f, 
    -0.34209102f, -0.30454645f, 0.26076940f, -0.24466854f, -0.31101081f, 0.02813597f, -0.09784757f, 0.21337406f, 
    -0.16762702f, -0.29492652f, -0.06994887f, -0.00716255f, 0.15901195f, -0.19955277f, -0.06831016f, 0.00314244f, 
    -0.06736048f, 0.38627911f, 0.15117948f, 0.00457183f, 0.13010985f, 0.08049974f, 0.08371451f, 0.02161367f, 
    0.11893218f, -0.03616441f, 0.07512131f, 0.05767572f, 0.10314402f, 0.01040483f, 0.00956076f, 0.14074744f, 
    -0.14176372f, 0.10616667f, 0.10563738f, 0.04106950f, -0.13453363f, -0.26352501f, 0.12104946f, -0.01919307f, 
    0.03457860f, -0.16872166f, -0.05345542f, -0.00216195f, 0.06052044f, -0.17603649f, -0.02166745f, 0.16570804f, 
    0.00205318f, 0.05364640f, 0.30024320f, -0.29485720f, -0.02477721f, 0.04908611f, -0.26473594f, 0.14363313f, 
    0.02916120f, -0.28540182f, -0.24258237f, 0.00474461f, 0.22926715f, 0.16814758f, 0.05841185f, -0.11324915f, 
    -0.00511922f, -0.08520570f, 0.18129680f, -0.17410085f, 0.23745659f, -0.16577007f, -0.00107761f, 0.13805638f, 
    0.00096529f, 0.06834757f, -0.01374803f, -0.03710380f, 0.02823900f, 0.04528026f, 0.08712124f, 0.06847324f, 
    0.05684069f, -0.07888010f, -0.11866375f, 0.15948147f, 0.20701905f, 0.10870340f, 0.13138896f, 0.08779298f, 
    -0.09692314f, -0.19565147f, -0.10648175f, -0.09782062f, 0.08632495f, -0.13898315f, -0.12094875f, 0.14504117f, 
    0.22845255f, 0.24531503f, 0.03707112f, 0.06073884f, 0.06953453f, -0.29194725f, -0.28310239f, -0.04920750f, 
    0.00280257f, -0.04410151f, 0.11914682f, 0.00009420f, -0.10853443f, -0.25638112f, -0.02991781f, -0.11011356f, 
    -0.13491386f, 0.10056262f, 0.01620718f, 0.03074838f, 0.06994172f, 0.01936680f, 0.05208597f, 0.07229897f, 
    0.11589245f, -0.41335484f, -0.07942722f, 0.13734417f, -0.03494341f, 0.22775732f, -0.00563763f, -0.13397656f, 
    0.11357073f, -0.06637953f, -0.11929497f, 0.05615595f, 0.09305873f, 0.00168013f, 0.06718901f, -0.25079957f, 
    -0.14411174f, 0.19877075f, 0.36267477f, 0.24247873f, 0.10241861f, 0.01996491f, 0.04575362f, 0.21499288f, 
    0.09319871f, -0.06323034f, -0.03246629f, -0.32582512f, -0.28552714f, -0.01505018f, 0.09156883f, -0.20341218f, 
    0.17279269f, -0.12501015f, -0.04651323f, 0.25226766f, 0.23413740f, 0.08089318f, -0.12455183f, 0.19016406f, 
    0.13740593f, 0.07253338f, 0.09413095f, 0.07381280f, -0.30631158f, -0.33456433f, -0.08342928f, 0.01127631f, 
    -0.04670808f, 0.08715826f, -0.13694982f, -0.13571180f, -0.20647566f, -0.14544599f, -0.06122747f, -0.17725648f, 
    -0.16109873f, 0.00611754f, -0.13182676f, 0.12311222f, -0.01585451f, 0.01278008f, 0.02508700f, -0.18001851f, 
    -0.25853300f, 0.22922100f, 0.09030909f, 0.04438056f, 0.11155695f, -0.09637444f, 0.05872316f, 0.23776087f, 
    -0.36722660f, -0.22219448f, 0.15659538f, -0.12025935f, -0.01979979f, 0.09726646f, -0.04919013f, 0.16372056f, 
    0.11085228f, 0.14395455f, 0.00614844f, 0.15593222f, -0.06530230f, 0.16335063f, 0.12013216f, -0.06977072f, 
    -0.19396265f, -0.11786216f, -0.57277960f, 0.05924238f, -0.14821421f, 0.27750465f, 0.00257905f, -0.13646765f, 
    0.11503617f, -0.00338808f, 0.59153360f, 0.48583055f, 0.32664394f, -0.14037426f, -0.11859798f, 0.05837796f, 
    0.06764183f, 0.16190220f, -0.00587724f, -0.04307935f, 0.23953541f, 0.12460889f, -0.23488325f, 0.10699010f, 
    -0.12150610f, -0.01745613f, -0.02633210f, 0.08463678f, 0.06964939f, -0.02799357f, -0.25656524f, -0.20809790f, 
    -0.07550113f, -0.06546956f, 0.08972898f, -0.17643252f, -0.07004235f, 0.01073561f, -0.05575025f, -0.11341128f, 
    -0.05010176f, 0.30182120f, 0.00385575f, -0.00416918f, -0.15562963f, 0.06124242f, 0.22817434f, 0.40600899f, 
    0.18568438f, -0.08170798f, 0.02330987f, -0.05466587f, 0.14099619f, 0.01752845f, 0.06596587f, -0.08239781f, 
    -0.27970332f, -0.08264165f, 0.11217707f, 0.09931406f, 0.13998736f, -0.04118393f, 0.03949413f, -0.12709728f, 
    -0.10667460f, 0.09182373f, 0.12818372f, 0.05947275f, -0.08217750f, 0.32223698f, 0.08708425f, 0.02282231f, 
    0.09484747f, 0.01082265f, -0.12009041f, 0.09282767f, 0.04305361f, 0.10844827f, 0.17754751f, 0.14548433f, 
    0.01361945f, 0.11066310f, -0.06919966f, -0.31922823f, 0.12048978f, -0.39867827f, -0.05221525f, -0.00693175f, 
    0.10202664f, -0.11298540f, -0.02651936f, 0.20245567f, 0.24373557f, 0.05455892f, 0.03750288f, -0.00031711f, 
    -0.13035083f, -0.16368653f, 0.01596268f, -0.07328696f, 0.03928981f, 0.20555994f, 0.33500150f, -0.03730577f, 
    0.14738134f, 0.00781558f, 0.18270840f, 0.11477657f, 0.11714725f, -0.09107474f, 0.09872725f, 0.01174583f, 
    0.03622260f, -0.00120732f, -0.01795635f, -0.09641245f, -0.01094185f, 0.23727891f, 0.13098341f, 0.12838192f, 
    0.23233677f, -0.05100446f, -0.02014761f, -0.09654692f, 0.09034717f, -0.13772471f, 0.08413749f, 0.28849339f, 
    -0.23358838f, -0.52273571f, -0.00390438f, 0.25656670f, 0.19690627f, -0.14727905f, 0.29342160f, -0.21645051f, 
    -0.14685816f, -0.06510366f, 0.02169584f, -0.36823258f, -0.14050300f, 0.17031309f, 0.23304065f, 0.06863885f, 
    0.06311271f, 0.26954773f, 0.09422398f, 0.14617468f, -0.10364199f, -0.03740803f, -0.10040731f, 0.11501718f, 
    0.05214649f, 0.06286179f, -0.19087486f, -0.15616119f, 0.02542743f, -0.01822584f, -0.25124633f, 0.04651489f, 
    -0.10881380f, -0.05157898f, 0.12033295f, -0.20613505f, -0.23998161f, 0.19708093f, -0.06711792f, -0.19165005f, 
    0.01280190f, 0.30506414f, 0.36152634f, 0.05023098f, 0.39925134f, -0.04393638f, -0.00069434f, -0.08882101f, 
    -0.11962368f, 0.03639111f, 0.17449231f, 0.07167123f, -0.00040958f, 0.36719149f, 0.08214819f, -0.41862106f, 
    -0.04888213f, -0.18905175f, 0.02802498f, 0.20233633f, -0.20102972f, 0.06578145f, 0.11887341f, -0.04168164f, 
    0.03696708f, -0.05582445f, 0.07234488f, 0.07168124f, 0.02200256f, -0.10445225f, 0.21364123f, 0.01075389f, 
    0.31270611f, -0.05669687f, -0.11594722f, -0.11681730f, -0.13579009f, 0.27728704f, -0.04835845f, 0.32810286f, 
    -0.35348696f, -0.17115031f, -0.30454975f, 0.05877548f, -0.06575704f, -0.01381957f, 0.42408788f, 0.12051149f, 
    0.15879220f, 0.05478635f, 0.22112577f, 0.10660784f, 0.02952566f, 0.06583534f, 0.00290710f, 0.34491923f, 
    0.20522611f, 0.05239072f, -0.29216605f, -0.34384748f, 0.14042461f, 0.20606150f, -0.16436125f, 0.20274436f, 
    0.11054869f, -0.06347069f, 0.19131835f, -0.24206552f, 0.00880251f, 0.05797733f, -0.17689162f, 0.20967188f, 
    0.04703807f, 0.04024067f, 0.07819283f, 0.00923329f, -0.20338798f, -0.60078287f, -0.14533679f, -0.03541689f, 
    0.05631864f, -0.07478324f, 0.14540482f, 0.14339644f, -0.05044900f, -0.25763053f, -0.17417060f, -0.24358222f, 
    -0.28410247f, -0.08578131f, 0.00850782f, -0.06883726f, -0.27109572f, 0.09524331f, -0.14323124f, -0.19426213f, 
    0.00079238f, 0.03862727f, 0.03513728f, 0.01915490f, -0.13164434f, 0.06491783f, 0.06693183f, 0.31150365f, 
    0.07057978f, -0.17761602f, -0.31876811f, -0.15359966f, 0.06600032f, 0.11517359f, 0.12342497f, -0.03645145f, 
    0.07038305f, 0.04533967f, 0.59475893f, 0.01819746f, 0.11121589f, -0.09594042f, 0.14619479f, 0.15503471f, 
    0.26763555f, -0.01703582f, -0.38587201f, -0.00503044f, -0.12332071f, 0.22469586f, -0.05235374f, 0.06490745f, 
    0.05267859f, 0.07094418f, -0.07073355f, -0.27536240f, -0.00782005f, -0.02460792f, 0.08202192f, -0.11333337f, 
    -0.19146901f, -0.14312142f, 0.04840418f, 0.02451169f, -0.19442363f, -0.35271060f, -0.16945927f, -0.13320081f, 
    0.16549037f, 0.12688518f, -0.03022692f, 0.19656029f, -0.34588057f, -0.34463701f, 0.03619441f, 0.00238719f, 
    0.04127689f, -0.01552163f, -0.33503681f, 0.04522472f, -0.02756158f, 0.00864229f, -0.00692255f, 0.14201517f, 
    0.03554595f, 0.05087323f, 0.01290184f, 0.04991672f, -0.06927218f, 0.10374548f, 0.10211685f, 0.00531389f, 
    0.15479895f, -0.16312896f, 0.20021445f, -0.05265116f, -0.03834434f, 0.10306255f, 0.19870444f, -0.16999160f, 
    -0.58616108f, -0.13096140f, -0.17984147f, -0.05531763f, -0.09426671f, -0.01619040f, 0.20252261f, 0.01800423f, 
    -0.18264261f, 0.22049560f, 0.20291726f, -0.27351362f, -0.02769713f, 0.14453134f, 0.00792222f, 0.04607187f, 
    0.03248324f, 0.13855751f, -0.05684702f, -0.03242465f, -0.01809538f, 0.07383212f, 0.16789210f, -0.07865328f, 
    -0.06150375f, 0.02649424f, -0.19693613f, 0.08058477f, 0.26380289f, 0.03066829f, -0.13133898f, 0.02743218f, 
    -0.45383468f, -0.02834453f, -0.05066707f, 0.12710337f, -0.26690161f, 0.19104421f, -0.06707037f, -0.02296575f, 
    -0.08414998f, 0.05141402f, 0.14879690f, 0.13067068f, -0.28714097f, 0.13103810f, 0.23740126f, 0.03137553f, 
    0.21724685f, -0.03023071f, 0.16596761f, 0.16548045f, 0.12432031f, -0.21801703f, 0.12626664f, 0.02799184f, 
    -0.20661804f, 0.05440998f, 0.04116131f, 0.03166026f, 0.00987556f, 0.19437551f, 0.02090678f, 0.13172023f, 
    -0.07549880f, -0.09223350f, -0.22546151f, -0.12637788f, -0.00604408f, -0.05867206f, 0.09165822f, -0.42317969f, 
    -0.52545249f, -0.50470299f, -0.07051334f, 0.02067593f, 0.10224864f, -0.11204477f, 0.22325617f, -0.07125075f, 
    -0.01559587f, 0.04996692f, 0.03523583f, -0.02577137f, 0.03191599f, -0.02227294f, -0.01873239f, -0.06121512f, 
    -0.02429304f, 0.04547251f, 0.05372949f, 0.00695365f, 0.01160790f, -0.01298864f, -0.00122586f, -0.04504417f, 
    0.03519180f, 0.01211810f, 0.01887392f, -0.02844052f, -0.03698680f, -0.01725976f, 0.01320453f, 0.02198587f, 
    0.01158511f, -0.05886099f, -0.01847106f, -0.05196463f, -0.02318617f, -0.05849291f, 0.03050620f, -0.03730338f, 
    0.04917046f, -0.04167324f, -0.02959770f, -0.01198554f, 0.03736938f, -0.06079983f, 0.01031653f, -0.05394604f, 
    -0.01710483f, -0.03071669f, 0.04256466f, 0.04669651f, -0.04087491f, 0.04097690f, 0.03544017f, -0.01814562f, 
    -0.00043325f, -0.03262556f, -0.04054292f, -0.02478736f, -0.04945561f, -0.00169520f, -0.05977916f, -0.03717669f, 
    0.01140042f, -0.01026274f, -0.01630941f, -0.02726963f, 0.02482575f, -0.02310616f, 0.00765203f, -0.02428816f, 
    -0.04775455f, 0.01170612f, -0.01979869f, -0.05766073f, -0.02814831f, -0.04701081f, 0.00960516f, 0.05121072f, 
    0.03048163f, -0.02920223f, 0.02587036f, 0.01110143f, -0.00955097f, -0.01615373f, -0.02779225f, -0.05652105f, 
    0.04898320f, -0.00337225f, -0.02831082f, -0.04727949f, -0.01802854f, 0.05133728f, 0.05065103f, 0.00805263f, 
    0.04462030f, -0.02388514f, 0.02887423f, -0.01695022f, 0.02528940f, -0.03583469f, -0.02811109f, -0.06480712f, 
    -0.05841658f, 0.00754239f, -0.04308549f, 0.01223467f, 0.00688464f, -0.04728251f, -0.05149804f, -0.01358353f, 
    -0.02398736f, 0.00762227f, -0.03924908f, 0.00592140f, 0.00693086f, -0.03174510f, -0.03492576f, 0.03161898f, 
    0.01999487f, -0.00107670f, -0.05452910f, -0.06566568f, 0.00498244f, 0.04791016f, 0.01535963f, -0.00198533f, 
    -0.03267763f, 0.03651264f, 0.04150498f, -0.04275312f, -0.03289711f, -0.01752301f, -0.03118207f, -0.01774530f, 
    0.01546473f, 0.05111342f, -0.01532587f, 0.00592118f, -0.03713362f, 0.00341748f, -0.06410475f, -0.04486412f, 
    -0.04363942f, 0.01242332f, -0.05474599f, -0.03298468f, -0.01218687f, 0.00499368f, -0.05305388f, 0.02361961f, 
    -0.00094094f, -0.02405613f, -0.01352479f, -0.02587288f, -0.04002350f, -0.00674891f, 0.02293898f, -0.00606279f, 
    -0.02500926f, -0.03262027f, 0.02550996f, 0.02720194f, -0.06283659f, 0.04752845f, -0.05847244f, -0.05894582f, 
    0.05018867f, -0.04745739f, -0.01940272f, 0.00793676f, -0.03921201f, -0.05485176f, -0.03141322f, -0.02465506f, 
    -0.00830625f, 0.02748690f, 0.02801698f, -0.01597640f, 0.00148530f, 0.02247047f, -0.05789457f, 0.05019166f, 
    0.02221328f, 0.00643707f, 0.04068630f, -0.01180190f, -0.02808673f, -0.02514990f, 0.03242258f, -0.03026707f, 
    0.02581686f, 0.00198054f, -0.03291791f, 0.00775792f, -0.02504312f, 0.00747714f, -0.00005198f, -0.02318145f, 
    -0.03703018f, -0.02623829f, 0.04570778f, -0.04906450f, 0.01036607f, -0.05344691f, -0.04544082f, -0.00618810f, 
    -0.00147309f, -0.05976521f, -0.00222465f, -0.05591323f, 0.04682972f, 0.00432780f, -0.01758421f, -0.06309066f, 
    -0.01424858f, 0.01053480f, 0.05150594f, 0.00257659f, 0.03046114f, 0.04168568f, -0.00754696f, 0.04142519f, 
    0.03352096f, -0.02839189f, -0.01842886f, -0.03164798f, 0.00587113f, 0.02098085f, -0.05027832f, 0.03355981f, 
    0.02190408f, 0.02487090f, 0.02582538f, -0.03115662f, 0.04252476f, 0.00058299f, -0.00010740f, -0.00506231f, 
    -0.00572410f, -0.05341367f, -0.01168220f, -0.02316629f, 0.04939291f, -0.05816981f, -0.03849868f, 0.00834497f, 
    0.05041940f, 0.02078116f, -0.01258390f, 0.01639640f, 0.01887298f, -0.04400194f, -0.00420906f, 0.04522191f, 
    -0.04740790f, -0.04966635f, 0.04137646f, -0.06308162f, 0.02927671f, 0.03160015f, -0.03122827f, 0.04966547f, 
    0.01472615f, -0.03915929f, 0.05413831f, 0.01671498f, -0.03876628f, -0.01986639f, 0.02243941f, 0.01962754f, 
    -0.03368112f, 0.01351744f, -0.05403569f, 0.03956629f, -0.05939348f, -0.03771720f, 0.01084609f, 0.05449292f, 
    -0.02949203f, -0.01663398f, -0.02767478f, -0.06576487f, -0.02098322f, -0.01824735f, 0.03499628f, 0.00726488f, 
    0.02712572f, 0.00966139f, -0.01906079f, 0.01530806f, 0.05543563f, 0.03970727f, 0.00053087f, -0.04632122f, 
    0.55401498f, 0.11005177f, 0.28926703f, 0.16523542f, 0.22425823f, 0.25326717f, 0.04778813f, -0.01014897f, 
    -0.04182243f, 0.10046034f, 0.11409640f, -0.20692703f, -0.08994789f, 0.13603090f, -0.07332339f, 0.26625627f, 
    0.00213732f, -0.04607816f, 0.33167616f, -0.08340596f, 0.39894095f, 0.05642813f, 0.11714915f, 0.11865040f, 
    -0.19313884f, 0.19700937f, -0.04531195f, -0.33400664f, -0.61645913f, 0.00533196f, 0.17594279f, 0.10946297f, 
    -0.07981202f, 0.06111076f, 0.24112374f, -0.31731305f, -0.05905723f, 0.01958383f, 0.24668755f, 0.04488372f, 
    0.18425561f, -0.02642740f, 0.07332750f, 0.05737313f, 0.31790030f, 0.32789078f, 0.29921615f, 0.41753066f, 
    -0.01535981f, 0.11864128f, -0.30109581f, -0.17384969f, 0.04975405f, 0.14735413f, -0.02970246f, -0.41549686f, 
    0.07067346f, -0.11011651f, 0.14298081f, 0.08475132f, -0.02112860f, 0.14886199f, 0.01258663f, -0.20747505f, 
    -0.50253940f, 0.17879042f, 0.26567808f, -0.15901761f, 0.07857307f, -0.15258907f, 0.06796616f, 0.07441691f, 
    0.28932121f, 0.02306448f, -0.86155379f, -0.17779458f, 0.17962639f, 0.12414512f, 0.28659317f, 0.19799356f, 
    -0.20084694f, -0.14145745f, -0.39013860f, -0.12248994f, 0.14244987f, 0.00785642f, -0.11972296f, -0.02016123f, 
    0.11361877f, 0.10759021f, 0.32132286f, -0.53646481f, 0.17258698f, -0.24329583f, -0.09046124f, -0.24823636f, 
    0.13247076f, -0.25288600f, 0.10715932f, -0.81899297f, -0.67411840f, -0.37901381f, -0.23665048f, -0.13636243f, 
    -0.18669544f, 0.10292067f, -0.09932505f, 0.03985211f, 0.59463328f, 0.58973539f, 0.38884494f, -0.11717556f, 
    -0.04257087f, -0.00125358f, 0.26632017f, -0.02827937f, -0.05868958f, -0.11978657f, -0.90679312f, -0.58160001f, 
    -0.27351737f, -0.21815902f, 0.06106096f, 0.17598334f, 0.01082915f, 0.10074490f, 0.14353240f, -1.00366342f, 
    -0.36786965f, -0.18204339f, -0.17752373f, 0.16317284f, -0.02822361f, -0.11861251f, -0.01715610f, 0.20693727f, 
    0.19668937f, -0.05617732f, -0.02377010f, 0.26456699f, 0.00658307f, 0.19138183f, 0.10582925f, -0.06478579f, 
    -0.48742473f, -0.49158341f, -0.11159510f, -0.07723009f, -0.02666623f, 0.04409089f, 0.05790053f, 0.21049757f, 
    0.02672804f, -0.42548007f, -0.07929033f, -0.44107836f, 0.15367056f, -0.27054119f, 0.03748586f, -0.03627215f, 
    0.13297491f, 0.09943865f, 0.30314118f, 0.38840866f, -0.02695780f, 0.00427819f, -0.23519365f, -0.28614908f, 
    -0.06939489f, -0.17485102f, -0.01915954f, -0.21702427f, -0.27175301f, -0.01582027f, 0.05551657f, 0.09818627f, 
    -0.00285271f, -0.09984469f, -0.12959103f, 0.37825346f, 0.50332963f, 0.07444097f, 0.16658744f, -0.06608046f, 
    -0.03871122f, -0.05255791f, 0.09908289f, -0.14134231f, 0.14410636f, -0.24337499f, -0.93446207f, -0.01435557f, 
    -0.33058283f, -0.06564295f, -0.10788044f, -0.08049520f, 0.03216140f, 0.39576760f, 0.02375522f, 0.26441351f, 
    -0.01537510f, -0.08510251f, 0.05950299f, -0.06030848f, 0.30402341f, 0.05368260f, 0.00514029f, 0.51639223f, 
    0.61557591f, 0.03855937f, 0.01925639f, -0.08707325f, 0.07432567f, 0.36185056f, 0.11530420f, -0.05169143f, 
    0.18630822f, -0.10761485f, -0.18886708f, 0.02513357f, 0.09841843f, 0.00232504f, 0.00374196f, -0.02300620f, 
    -0.15327296f, -0.14625825f, -0.44425699f, -0.09317447f, -0.09022421f, 0.03720328f, -0.02869395f, -0.04613112f, 
    0.02931904f, 0.20501925f, -0.24758476f, -1.18282461f, -0.24364679f, 0.02391502f, -0.03482209f, -0.09194022f, 
    0.13065621f, -0.03725486f, 0.12675726f, -0.77836281f, -0.41256669f, 0.41296798f, -0.01943775f, 0.17229511f, 
    -0.06477980f, -0.02592704f, 0.03556458f, -0.25561056f, -0.26205868f, -0.52144718f, -0.82429683f, 0.11111898f, 
    -0.07173558f, -0.00000978f, -0.01042530f, -0.03213374f, 0.21266276f, 0.17918067f, -0.35893607f, -0.58490652f, 
    -0.03566893f, -0.28406516f, -0.08481225f, 0.19683489f, -0.02004560f, -0.21223341f, 0.13692608f, -0.35791680f, 
    0.15593509f, 0.56169266f, -0.45864874f, -0.14523821f, 0.32536262f, -0.16463569f, 0.03643193f, 0.19209719f, 
    -0.74469382f, 0.22360024f, 0.06879659f, -0.39224467f, -0.00700857f, 0.35949981f, -0.04027027f, 0.02928426f, 
    0.05390918f, 0.00075525f, 0.05387496f, -0.03916897f, -0.02769146f, -0.04412810f, -0.00349551f, -0.00331842f, 
    -0.01020248f, 0.00166360f, 0.00391333f, 0.01550558f, 0.00572215f, -0.00140599f, -0.01905214f, -0.02738727f, 
    0.00539745f, 0.02942020f, -0.03406707f, -0.02116250f, -0.02760559f, -0.05901306f, -0.02828253f, -0.04015158f, 
    0.00331168f, -0.03136304f, -0.01880755f, -0.03753027f, 0.03998390f, -0.05551162f, -0.00399490f, -0.05117947f, 
    -0.00246814f, -0.02174335f, 0.05226921f, -0.06188693f, 0.00399707f, -0.04033116f, -0.04187357f, -0.00033179f, 
    -0.05353126f, -0.03110188f, -0.02996329f, 0.01047744f, -0.05125663f, 0.05029400f, 0.01452042f, 0.00652058f, 
    0.03353758f, -0.03242665f, 0.01848974f, -0.04773455f, -0.02434762f, 0.01603502f, 0.01383120f, 0.05590973f, 
    0.04127732f, -0.02866845f, -0.01043794f, -0.03817786f, 0.03279809f, -0.00457689f, 0.02674664f, 0.00185961f, 
    -0.00441297f, -0.02239878f, 0.04756083f, -0.00596432f, -0.03598391f, -0.04577575f, 0.02128702f, 0.01578657f, 
    -0.00078291f, 0.01020407f, 0.04378093f, 0.00781480f, 0.01646774f, 0.00492565f, -0.05030300f, 0.00428298f, 
    0.02008320f, -0.04121517f, -0.03707897f, 0.03586701f, -0.00762096f, -0.03797716f, -0.04484165f, 0.03959784f, 
    -0.01177897f, -0.04630727f, -0.04382131f, -0.02640906f, 0.03517579f, -0.00547369f, -0.04270582f, 0.04779725f, 
    0.03651492f, -0.00721776f, 0.02309040f, 0.00651657f, 0.02375373f, 0.04192026f, 0.05875571f, -0.02274644f, 
    0.00468985f, -0.03461273f, 0.02502899f, -0.03646071f, 0.02378994f, -0.03192748f, 0.03302709f, 0.03447052f, 
    -0.01632890f, 0.00804034f, -0.04201651f, 0.02460248f, -0.05634313f, 0.04460647f, -0.00019561f, 0.04702537f, 
    -0.00380173f, -0.01192269f, 0.01928145f, 0.01965889f, -0.00958663f, -0.04665424f, -0.04292290f, 0.00577049f, 
    -0.04335838f, 0.01138851f, 0.04998421f, -0.04484408f, 0.04343536f, 0.04172916f, 0.05455061f, 0.01325491f, 
    -0.01160863f, -0.02642799f, 0.03666313f, 0.01054277f, -0.03313417f, -0.00105080f, -0.03657187f, -0.00919193f, 
    0.00363319f, 0.00506406f, -0.02036637f, -0.05270789f, -0.05047731f, -0.04790918f, 0.01911719f, -0.04846257f, 
    0.01225701f, -0.01986646f, 0.02521783f, 0.02607404f, -0.05712445f, -0.05807251f, -0.01910023f, -0.04599632f, 
    -0.04747900f, -0.03679006f, 0.00093999f, 0.04474297f, 0.00690251f, -0.03729198f, 0.00924843f, -0.00700917f, 
    0.02016659f, 0.04076766f, -0.02383917f, 0.05645325f, -0.05481251f, 0.02488554f, 0.02215495f, -0.02778368f, 
    -0.03850154f, 0.01298381f, 0.00261801f, -0.03101095f, -0.03152623f, 0.02727427f, 0.01913611f, 0.04651388f, 
    -0.04172376f, -0.01691050f, -0.04524104f, -0.00897349f, 0.00566578f, -0.02870457f, -0.05450663f, -0.02679214f, 
    0.01141786f, 0.05655130f, -0.01453769f, 0.00083689f, 0.05121069f, 0.00545145f, -0.01794194f, 0.00535240f, 
    0.01301411f, -0.02895980f, -0.01912116f, -0.00036007f, -0.03297855f, 0.05094981f, 0.01457158f, 0.04096270f, 
    -0.01830412f, -0.02071192f, 0.03322408f, -0.00643454f, 0.02470709f, 0.03743955f, 0.03638407f, 0.01607261f, 
    -0.06021767f, -0.01209334f, 0.02054193f, 0.00001314f, -0.01208777f, 0.04653427f, 0.04833714f, -0.01545216f, 
    0.02574679f, 0.01296561f, -0.00911069f, 0.02395356f, -0.01738179f, 0.05459425f, 0.03075971f, 0.02815633f, 
    0.02151309f, -0.00559953f, -0.05188114f, -0.02181130f, -0.01553269f, 0.02845664f, -0.05424229f, -0.01547977f, 
    -0.03783954f, -0.02514633f, -0.03705108f, 0.05958648f, 0.00290595f, 0.05400431f, -0.04019617f, -0.03193057f, 
    -0.00836858f, 0.03319232f, -0.05060093f, -0.05018438f, -0.02125719f, -0.03098479f, -0.00624323f, -0.01555642f, 
    0.01378529f, -0.01837605f, 0.04752831f, -0.04240848f, 0.00958212f, -0.05488693f, 0.02498592f, -0.04279226f, 
    0.02221321f, 0.02797708f, -0.01308375f, 0.03966622f, -0.02450131f, -0.03767431f, -0.01723688f, -0.04241714f, 
    -0.02651852f, 0.04277164f, 0.02733987f, 0.01007561f, -0.05526228f, -0.01848543f, 0.00134153f, -0.02961495f, 
    0.01129153f, 0.02995710f, 0.04027121f, -0.05367011f, -0.01098545f, 0.00829275f, -0.04464847f, -0.02101362f, 
    -0.00592930f, -0.01143058f, 0.03693095f, -0.03919019f, 0.04388706f, -0.04783229f, -0.03594258f, 0.03395017f, 
    -0.02279978f, -0.03157149f, -0.00579690f, 0.02430387f, -0.06353210f, 0.04296845f, -0.06043762f, 0.04412930f, 
    -0.02401210f, -0.00587467f, 0.04801663f, -0.04742286f, -0.04453743f, -0.06445602f, -0.00143116f, -0.00912195f, 
    0.04067049f, -0.02223227f, 0.04645618f, 0.03952537f, -0.05018792f, -0.00965925f, 0.03000140f, -0.03295393f, 
    -0.02557725f, -0.01541498f, 0.03620315f, 0.02100956f, -0.01733902f, 0.03116250f, -0.04800868f, -0.03031147f, 
    0.00205073f, 0.04775306f, -0.02908113f, -0.03159959f, -0.02698508f, -0.01693556f, 0.01671505f, -0.03405214f, 
    0.03190682f, 0.00530823f, -0.00688232f, 0.03598285f, 0.00569748f, -0.03676487f, 0.00603243f, 0.04037549f, 
    0.05156792f, -0.01087801f, -0.05543389f, -0.03947166f, 0.03876304f, -0.02172871f, 0.01977153f, -0.02789046f, 
    -0.01425541f, 0.01075121f, 0.03606128f, -0.00188510f, -0.06169129f, 0.04462854f, 0.02260833f, 0.00004701f, 
    -0.05559079f, -0.05008060f, 0.01220384f, 0.05134059f, -0.02268583f, 0.04923683f, -0.02435831f, -0.01827727f, 
    -0.00336796f, -0.01250359f, -0.05730520f, 0.00581905f, -0.00789592f, 0.03753100f, -0.05418253f, -0.05074491f, 
    0.03581402f, 0.00286195f, -0.02418344f, -0.06080547f, 0.05083703f, -0.04552457f, -0.06286088f, -0.02547309f, 
    -0.05622667f, -0.04996536f, -0.02055759f, -0.04933079f, 0.04586444f, -0.03211011f, 0.01230547f, -0.06257360f, 
    0.02821210f, 0.04859383f, -0.01485459f, 0.03001700f, -0.06438074f, 0.02905328f, -0.04991207f, 0.01339278f, 
    -0.04858800f, -0.02358859f, -0.03993432f, 0.00296219f, -0.03795296f, 0.00720697f, 0.03655835f, 0.00839015f, 
    0.02059956f, 0.03073937f, -0.05272197f, -0.02059097f, -0.03021576f, -0.01455899f, 0.02862697f, 0.01455895f, 
    -0.04313951f, 0.04466467f, 0.03322947f, -0.01498276f, -0.01297242f, 0.04740700f, 0.01818838f, -0.05829244f, 
    -0.03165628f, -0.03983183f, -0.02807304f, -0.05987188f, -0.06152160f, -0.06247706f, -0.05409112f, -0.04944259f, 
    -0.02160129f, -0.05624323f, -0.02509918f, 0.04209369f, 0.02079668f, -0.02320392f, -0.02051705f, -0.03755596f, 
    0.03692867f, 0.02190775f, -0.00420025f, 0.03606520f, -0.00380087f, 0.02091437f, 0.01948299f, 0.03251864f, 
    0.04198539f, -0.04040326f, -0.03683711f, 0.02466423f, 0.00638350f, -0.00224538f, 0.01731584f, 0.00577046f, 
    -0.05406177f, -0.05610700f, -0.03139705f, 0.04926674f, 0.01583930f, -0.05722018f, -0.04709244f, 0.04409286f, 
    0.04247372f, 0.05291576f, -0.05956904f, -0.00006910f, -0.03413784f, -0.04600390f, 0.04618285f, -0.02933715f, 
    0.04557644f, 0.05126585f, -0.03383705f, 0.02668586f, -0.03537459f, 0.01169215f, -0.03707170f, -0.01902377f, 
    -0.00798845f, 0.00721981f, -0.04863171f, -0.03021323f, -0.00530083f, 0.02229694f, -0.00650781f, 0.01568219f, 
    -0.04450959f, 0.02543665f, -0.01947297f, 0.00167274f, -0.01329261f, -0.04938006f, 0.02719796f, -0.05800864f, 
    -0.00694277f, -0.03116638f, -0.06025157f, -0.02031953f, -0.04151088f, -0.00145880f, -0.02277200f, 0.02141030f, 
    -0.01029839f, -0.03593612f, -0.04057668f, 0.01228244f, -0.02938616f, -0.00363160f, -0.03327239f, -0.01282317f, 
    0.00962649f, -0.01855613f, 0.03437750f, 0.01635245f, -0.04201495f, -0.00578513f, 0.02145911f, 0.03352890f, 
    0.04426783f, -0.01204112f, -0.06301200f, 0.02107815f, -0.01246903f, -0.05439279f, -0.02024227f, 0.00760815f, 
    0.02909174f, 0.05267535f, -0.01727409f, 0.02812401f, 0.03600678f, -0.06329302f, 0.01410533f, 0.00801330f, 
    0.01271310f, 0.04058427f, -0.01590920f, -0.05980594f, 0.00100389f, -0.00696441f, 0.01409327f, -0.06327405f, 
    0.03804102f, -0.02239779f, 0.00131997f, -0.04007355f, 0.03692017f, 0.03709874f, -0.05890024f, -0.05552051f, 
    -0.05993178f, 0.01682949f, -0.00397316f, -0.05025018f, -0.04950095f, -0.04207418f, -0.02902081f, 0.04607469f, 
    0.00626160f, -0.04073368f, 0.04446042f, -0.06180938f, -0.00298803f, -0.04172701f, 0.05187139f, 0.03923399f, 
    0.03525403f, -0.04788604f, 0.01876698f, -0.04777742f, 0.04066187f, -0.05939083f, -0.03020222f, -0.00504059f, 
    0.37538812f, 0.07941080f, 0.16359721f, 0.05296279f, -0.04050202f, 0.03361852f, 0.09666518f, -0.22431043f, 
    0.25023764f, -0.40775061f, 0.37852892f, 0.00504531f, -0.17931345f, 0.12053173f, -0.02653791f, 0.23668292f, 
    0.00439901f, 0.16516617f, 0.42973733f, 0.34218308f, 0.41514671f, 0.06745765f, 0.21571739f, 0.15861824f, 
    0.14967433f, 0.00470263f, 0.00508140f, 0.21070077f, -0.04763144f, 0.02098471f, -0.18859789f, -0.22582681f, 
    -0.06149102f, 0.18953671f, 0.15383382f, -0.20718339f, -0.05001653f, 0.30367821f, 0.44336525f, -0.02808770f, 
    0.08566242f, -0.00584967f, 0.04916942f, 0.00334992f, -0.07116616f, -0.03696645f, 0.27367455f, 0.06710846f, 
    -0.22511381f, 0.06461949f, -0.27188495f, 0.05472917f, 0.00631975f, 0.08919988f, 0.46297860f, 0.10216479f, 
    0.35954165f, 0.07959449f, 0.01666079f, 0.10779962f, 0.01217776f, -0.15420972f, -0.00245803f, -0.17292200f, 
    -0.30254909f, 0.00592217f, -0.04182160f, -0.03043056f, 0.06329990f, -0.05063240f, 0.12611896f, -0.11376625f, 
    -0.40399787f, 0.01481321f, -0.51307130f, 0.25459406f, -0.22329353f, 0.07289424f, 0.12222009f, 0.22034772f, 
    0.13733941f, 0.13833682f, -0.05539307f, -0.15865588f, 0.04807982f, -0.01079766f, 0.05948692f, 0.15996383f, 
    0.17467371f, -0.05287732f, -0.45890549f, -0.36119747f, -0.22561514f, 0.00805348f, -0.12893054f, -0.10080802f, 
    0.05232960f, 0.09897356f, 0.13951021f, -0.43179247f, -0.41458336f, -0.12921290f, -0.19082627f, 0.15392417f, 
    -0.07113945f, 0.01502137f, -0.21827771f, -0.02663063f, 0.07843494f, 0.23032208f, 0.26432562f, -0.03810742f, 
    0.09156488f, -0.20074631f, 0.10696985f, 0.17391479f, 0.20230535f, -0.11062562f, -0.47845078f, -0.34314176f, 
    -0.11678562f, -0.31089014f, -0.05495160f, 0.09992021f, -0.08303012f, -0.05269486f, 0.01482650f, -0.39711201f, 
    -0.12848583f, -0.04849040f, -0.19618280f, 0.08155781f, 0.04561609f, 0.02953299f, 0.04493657f, -0.35095173f, 
    0.23949887f, -0.09571324f, -0.17104033f, -0.08458842f, -0.17921820f, 0.11447301f, 0.05036549f, 0.17343117f, 
    0.12024555f, -0.35822409f, -0.18725598f, -0.08650961f, -0.12556626f, -0.00492340f, -0.13484137f, 0.03397686f, 
    -0.01373075f, 0.02802793f, 0.02887600f, -0.29313561f, 0.01064558f, -0.08679223f, 0.09063306f, 0.01988512f, 
    0.00468461f, -0.09512950f, -0.03206713f, 0.00466538f, -0.26915428f, -0.06588596f, -0.20554760f, -0.30764413f, 
    -0.05210846f, 0.03965702f, -0.12579763f, -0.65500653f, -0.38874996f, 0.15552777f, 0.08111975f, 0.07540337f, 
    -0.22060624f, -0.07939360f, -0.02480644f, -0.15132898f, 0.48716632f, 0.27084488f, 0.07330783f, 0.38934228f, 
    -0.10604110f, 0.18891585f, -0.07880561f, 0.05669651f, 0.04723025f, -0.31437182f, -0.59882224f, 0.20599332f, 
    -0.12405418f, -0.10818260f, -0.34596735f, -0.05965593f, -0.01902684f, -0.07543398f, -0.04432271f, 0.06045466f, 
    0.18037146f, 0.07525918f, 0.02738343f, -0.23164260f, -0.11317541f, -0.13847527f, 0.01037908f, -0.22224288f, 
    0.15087190f, 0.18653420f, 0.12368646f, 0.12068795f, 0.10342344f, -0.02102332f, 0.21239784f, 0.02109538f, 
    0.30759633f, 0.07130276f, -0.06432626f, -0.00038129f, 0.04810177f, 0.17876701f, 0.26850781f, -0.09706689f, 
    0.17858759f, 0.36873505f, 0.05213009f, 0.26412043f, -0.03071685f, -0.10139952f, 0.09064252f, 0.00082971f, 
    0.00810927f, 0.05111879f, 0.52351564f, -0.75893390f, -0.44257045f, -0.07631031f, -0.13026668f, 0.26676175f, 
    0.11799892f, 0.07958615f, 0.02311691f, 0.10522813f, -0.23659059f, -0.33816078f, -0.20305967f, -0.16973509f, 
    -0.27721709f, 0.06255728f, -0.09912133f, 0.03055535f, 0.03268114f, -0.21714625f, -0.01070709f, 0.22506596f, 
    -0.10714235f, 0.04391188f, -0.03974840f, 0.19004089f, -0.04482369f, 0.14278385f, -0.35216430f, -0.17111008f, 
    -0.09251082f, -0.15076998f, -0.07296268f, 0.18096468f, -0.11074752f, -0.13556692f, 0.35052201f, 0.12077694f, 
    -0.10889153f, 0.01640953f, 0.11350799f, 0.06298549f, 0.11804693f, -0.00690816f, 0.12017682f, 0.01388173f, 
    -0.40574008f, -0.05955899f, -0.03743687f, 0.16096666f, 0.22020397f, 0.17912152f, -0.07223881f, -0.21872261f, 
    0.03281218f, -0.18785192f, -0.21459642f, 0.02853144f, 0.01353416f, -0.15020128f, -0.07756556f, -0.00901930f, 
    0.05773417f, -0.09511511f, -0.04898673f, -0.05267210f, -0.15635014f, -0.02289654f, -0.22549494f, 0.27291936f, 
    -0.00388931f, 0.09573370f, -0.19923140f, -0.01027523f, -0.08414640f, -0.04414664f, 0.10153557f, 0.04354469f, 
    -0.17620763f, -0.11943125f, -0.11906166f, 0.09408813f, -0.10826555f, 0.15548298f, 0.06517500f, 0.11070202f, 
    -0.27144361f, 0.03092719f, 0.00684583f, 0.01609240f, -0.11955900f, -0.16438848f, -0.04366609f, 0.04448317f, 
    0.00450561f, 0.09113076f, 0.18011354f, -0.09153337f, 0.04602710f, -0.12880261f, -0.72707283f, 0.07976092f, 
    -0.01228765f, 0.01710407f, -0.25841954f, 0.21209733f, 0.04780897f, 0.05884830f, -0.34532008f, 0.10040132f, 
    -0.02796004f, 0.00886861f, 0.22499211f, 0.05851600f, -0.11352451f, -0.08329254f, 0.22522859f, 0.18150543f, 
    -0.21671043f, -0.02084525f, 0.12603690f, -0.00982435f, 0.00761231f, 0.02638049f, 0.09422561f, 0.19856565f, 
    0.24093191f, -0.23876739f, -0.24182497f, -0.06656506f, -0.31157890f, 0.06217935f, 0.06546701f, 0.12698376f, 
    0.00478354f, 0.19224048f, 0.09736408f, 0.03245348f, -0.09650908f, 0.00777316f, 0.03342354f, -0.06743097f, 
    0.21317147f, 0.05610536f, -0.01317584f, 0.19515054f, 0.21362092f, -0.28972539f, -0.03891044f, 0.04588025f, 
    0.09761181f, 0.14023119f, 0.09486149f, 0.07717206f, 0.08763150f, 0.01839101f, -0.01191197f, 0.09569195f, 
    -0.04398832f, 0.18558879f, -0.04264853f, 0.16080306f, -0.09617565f, -0.21481264f, 0.01796711f, -0.08036109f, 
    -0.02724747f, -0.20367923f, 0.12572029f, 0.09157332f, -0.10139752f, 0.04923121f, 0.10046740f, -0.09107242f, 
    -0.31394920f, -0.56614792f, -0.03829360f, -0.11888795f, 0.00470642f, -0.02518050f, 0.14517142f, -0.00543597f, 
    -0.17213340f, 0.31216484f, 0.14866896f, 0.16177349f, -0.11645895f, 0.10213222f, 0.05117702f, -0.03481740f, 
    -0.35513178f, 0.11784224f, -0.01367556f, -0.03986851f, -0.11654384f, 0.26830062f, -0.16811617f, 0.14108315f, 
    -0.03475703f, -0.08471920f, 0.14390327f, -0.08077995f, 0.00088528f, 0.19788425f, 0.04643778f, -0.07262060f, 
    0.37994656f, 0.48315492f, -0.19092563f, 0.00474357f, -0.06029217f, 0.02117404f, -0.21306361f, 0.02640554f, 
    -0.03436303f, 0.22828530f, -0.12170019f, -0.04898041f, 0.03328385f, 0.05217014f, -0.01399388f, -0.16271499f, 
    -0.10625190f, -0.01611288f, -0.02317230f, 0.20483349f, -0.04483383f, -0.11235881f, 0.01886766f, -0.25783655f, 
    0.03847579f, 0.13622028f, 0.19083805f, 0.19344586f, -0.58510721f, 0.22416982f, 0.40302601f, 0.04303981f, 
    0.04999524f, -0.10942908f, 0.01700751f, -0.12370595f, -0.07245037f, 0.17525898f, 0.07532903f, -0.10367425f, 
    0.03233059f, 0.15825634f, -0.08130163f, 0.09527740f, 0.05612035f, 0.07393327f, -0.08349428f, -0.01184402f, 
    0.00964366f, 0.01253150f, 0.03343250f, 0.03497111f, 0.11290953f, -0.05259178f, 0.24366772f, 0.06819389f, 
    -0.12369554f, -0.12650135f, 0.08453728f, -0.33423534f, -0.12683918f, -0.01669530f, 0.18388481f, 0.00835006f, 
    -0.22741483f, 0.09775352f, 0.09639253f, 0.02181722f, 0.01284275f, -0.16830643f, 0.10102824f, 0.15228146f, 
    0.18812418f, -0.30483824f, 0.17685425f, 0.18745878f, -0.00762437f, 0.12767416f, 0.02316892f, -0.11227525f, 
    -0.07104416f, 0.14805230f, -0.26261625f, 0.05080719f, 0.48130512f, -0.11067449f, 0.19192968f, 0.18959311f, 
    -0.01476975f, 0.03342436f, 0.22004028f, -0.03083833f, -0.12074725f, -0.12793113f, -0.01795721f, 0.11715380f, 
    -0.25312522f, 0.16345197f, -0.05848896f, 0.05818286f, 0.27533790f, -0.00079779f, -0.13953936f, -0.07495584f, 
    -0.15515538f, -0.01545195f, 0.08349340f, 0.10650034f, 0.19243179f, 0.05697633f, 0.01567660f, -0.02345991f, 
    -0.04462187f, -0.08590399f, -0.11641265f, 0.12975964f, -0.00492489f, -0.08289216f, 0.08097035f, -0.08826976f, 
    -0.04836214f, -0.01745244f, -0.09033696f, -0.06126991f, -0.37292552f, 0.10992097f, -0.11698029f, 0.87181687f, 
    -0.45996279f, -0.11841011f, 0.04183396f, 0.07840452f, 0.10149107f, -0.18638158f, 0.03321367f, -0.18897885f, 
    0.03024954f, 0.14920649f, 0.29994091f, -0.01284717f, 0.14770927f, -0.03103524f, 0.00725685f, 0.08191984f, 
    -0.01949152f, -0.25050360f, -0.15654762f, 0.40863824f, -0.02874983f, -0.08967800f, -0.04071080f, 0.09418400f, 
    0.01104899f, -0.17133684f, -0.46542278f, -0.27634564f, 0.28407070f, 0.07802078f, -0.08566511f, -0.12570888f, 
    -0.13897222f, 0.01945034f, -0.05713138f, -0.17551051f, -0.55373317f, 0.09076106f, -0.36500466f, -0.08779840f, 
    -0.21987014f, -0.17686145f, 0.01924592f, -0.10788319f, -0.11373422f, -0.13751502f, -0.11167213f, 0.04300911f, 
    0.02913434f, 0.02709755f, 0.24288493f, 0.24295138f, 0.14287128f, 0.14053281f, -0.21105672f, 0.16166528f, 
    0.02779143f, -0.16773228f, -0.01352026f, -0.02894696f, -0.02842881f, 0.03652270f, -0.46706113f, 0.16651657f, 
    0.11684396f, 0.00599040f, 0.04132086f, 0.08770492f, 0.10400065f, 0.14611034f, 0.07070021f, -0.29725489f, 
    -0.08669560f, 0.10435400f, 0.17794003f, -0.08277526f, 0.24356647f, 0.16688703f, 0.00777573f, 0.15264985f, 
    0.17660137f, -0.16026765f, -0.44699904f, 0.09383212f, -0.03029422f, -0.15054142f, -0.01005328f, 0.04193257f, 
    0.28773370f, -0.09698336f, -0.14119732f, -0.15420194f, -0.30748022f, 0.07356296f, 0.04464456f, 0.15626402f, 
    0.33186352f, 0.23827744f, 0.09061451f, 0.27872851f, 0.31114358f, -0.36994717f, -0.03316162f, 0.00754687f, 
    0.06813595f, 0.05495926f, 0.12346534f, 0.10082237f, -0.11483546f, -0.27645794f, 0.16709277f, -0.01825812f, 
    -0.12288498f, 0.21564193f, -0.19114408f, 0.46152970f, -0.00978967f, -0.10129297f, -0.09960584f, -0.07157853f, 
    0.06226431f, -0.11921445f, 0.00661257f, 0.09399886f, 0.10619841f, -0.16963290f, 0.04850139f, 0.03313470f, 
    -0.14158040f, 0.04245501f, -0.13493118f, 0.02531525f, -0.46102425f, -0.37668788f, -0.07525576f, 0.09119640f, 
    -0.07550633f, 0.20129839f, 0.09738542f, 0.04606640f, 0.09496071f, -0.02973155f, -0.02001629f, 0.22040604f, 
    0.04445972f, 0.42593524f, 0.16833948f, -0.01039533f, 0.01720693f, 0.02014248f, -0.02830208f, -0.08891235f, 
    -0.30010343f, 0.23799746f, 0.22705896f, 0.12166403f, 0.25624195f, 0.25721213f, 0.10770980f, -0.14863931f, 
    0.38073841f, 0.77509087f, -0.04028080f, 0.12464746f, -0.19672452f, -0.16991445f, 0.21404377f, 0.15236126f, 
    0.07927003f, -0.14379774f, -0.05824295f, -0.42300731f, -0.19163308f, -0.15591499f, -0.03763396f, -0.08570483f, 
    -0.15697272f, -0.02020842f, -0.13215475f, 0.28385893f, -0.08481506f, -0.36264366f, -0.01726901f, -0.07006254f, 
    -0.42873415f, 0.15512691f, -0.12906639f, 0.07654490f, -0.41611284f, 0.00066094f, 0.55309147f, 0.02651571f, 
    0.03957055f, 0.08351587f, 0.03747533f, 0.12758875f, -0.07864962f, 0.03286931f, 0.12542157f, -0.13500705f, 
    0.23902379f, -0.08506710f, -0.36070985f, 0.12271846f, -0.05391911f, -0.11225385f, 0.18501304f, 0.05738385f, 
    0.25879335f, 0.14456293f, 0.13900872f, 0.04721574f, 0.16275090f, -0.06780070f, 0.16802977f, 0.25378811f, 
    -0.32863855f, -0.16174950f, 0.11282197f, -0.16188329f, -0.10273832f, 0.03988633f, 0.00025239f, 0.08194081f, 
    -0.55504882f, 0.13191240f, 0.25380719f, -0.11807033f, 0.16237755f, -0.02001249f, 0.16325201f, 0.04821547f, 
    -0.31420630f, -0.51352584f, 0.11720981f, 0.11646361f, 0.05781077f, 0.00713001f, 0.05393224f, 0.17714120f, 
    0.09933181f, -0.02036107f, -0.50447154f, 0.24114627f, 0.59249490f, -0.11927228f, 0.05969602f, -0.09065442f, 
    -0.03679777f, 0.17286795f, -0.01187363f, -0.43177548f, -0.49224639f, -0.01734083f, 0.02600625f, -0.07750247f, 
    -0.03606052f, 0.10785887f, -0.14102511f, 0.08667561f, 0.32205224f, -0.02747839f, -0.43265405f, 0.02182677f, 
    0.00680120f, -0.13202485f, 0.25911883f, 0.05651257f, 0.36887375f, 0.01805851f, -0.02172251f, -0.05610750f, 
    -0.06859713f, 0.15331542f, -0.07709546f, 0.18299380f, -0.14862874f, 0.01877389f, -0.06470881f, -0.17321317f, 
    0.03324511f, -0.39153141f, -0.25039858f, -0.23178379f, -0.15680951f, -0.01241428f, -0.15392447f, 0.73281831f, 
    -0.38059413f, -0.52770126f, -0.07382458f, -0.24689910f, -0.10493222f, -0.17826670f, -0.04183123f, 0.08461175f, 
    -0.00664808f, -0.05205705f, 0.01011870f, -0.02637019f, -0.01227893f, -0.02250059f, 0.02780626f, -0.03681104f, 
    0.02261658f, 0.05090757f, -0.01156014f, -0.02586457f, 0.02933113f, -0.05679084f, -0.06153722f, -0.04009356f, 
    0.01716150f, -0.02862953f, -0.00149992f, -0.03096041f, -0.05470360f, 0.01931468f, -0.03081194f, -0.02003941f, 
    0.00138651f, -0.05611046f, -0.00180018f, -0.02124636f, -0.02670483f, 0.01006314f, -0.03393737f, 0.04036620f, 
    0.02430161f, 0.01017098f, -0.04109361f, 0.02373763f, -0.04510660f, 0.03969227f, 0.00239637f, -0.04806050f, 
    -0.06002861f, 0.02835628f, 0.02116690f, 0.02770591f, -0.02579315f, 0.03548435f, -0.01211433f, -0.02286875f, 
    0.04457294f, -0.01376498f, -0.03530021f, 0.00339583f, -0.03497402f, 0.00092058f, -0.03912649f, 0.03212198f, 
    -0.03178132f, -0.03677231f, 0.02662721f, -0.03962271f, -0.03887269f, 0.02501559f, -0.04322815f, 0.03153169f, 
    -0.00659782f, 0.01071127f, -0.01234447f, 0.04676669f, -0.05285224f, -0.05170794f, -0.03697104f, 0.01183261f, 
    0.02403259f, -0.02995498f, -0.04186445f, -0.00707276f, -0.02969451f, -0.02652238f, -0.02475487f, -0.05659466f, 
    0.02324636f, -0.04562394f, 0.02963856f, 0.02891321f, -0.01097327f, 0.01073022f, 0.01373278f, 0.03035073f, 
    -0.05614808f, 0.00397846f, 0.05059105f, -0.02116519f, -0.05451448f, -0.01732292f, 0.05268916f, 0.04711953f, 
    0.03061528f, 0.03791343f, 0.02329788f, -0.06428301f, -0.00229782f, -0.05632753f, -0.02184761f, -0.05993815f, 
    0.01673525f, 0.02220490f, -0.05507314f, 0.03841873f, -0.02167091f, -0.01059934f, 0.04214215f, 0.05273981f, 
    -0.02213190f, -0.01674300f, 0.04003420f, 0.02346767f, -0.01076243f, 0.00721865f, 0.03433522f, -0.04584141f, 
    0.00661021f, 0.03966415f, 0.01044077f, -0.05287370f, 0.03983638f, 0.04523733f, -0.06362236f, -0.04309769f, 
    -0.04941088f, 0.00917493f, 0.01434963f, -0.04383934f, -0.02826772f, -0.05361547f, 0.03167313f, -0.04681152f, 
    -0.02220892f, 0.02972043f, -0.00624290f, -0.01191909f, -0.01014191f, -0.00396696f, -0.00410423f, -0.01925885f, 
    0.02427573f, 0.00389989f, 0.02788761f, 0.03783245f, -0.06447332f, -0.03056169f, 0.03722470f, -0.04124793f, 
    0.00793975f, 0.00942264f, -0.02522253f, -0.00158770f, -0.00337068f, -0.00029012f, -0.02359785f, -0.03675037f, 
    0.01474708f, -0.00368067f, -0.04662017f, -0.06042495f, -0.04950288f, -0.05848153f, -0.02545246f, -0.04853746f, 
    -0.05599422f, -0.01749881f, -0.00055375f, -0.04342153f, -0.01879633f, 0.00501405f, 0.03096445f, -0.01762846f, 
    0.04374035f, 0.03142877f, -0.02894719f, 0.03214814f, 0.04828240f, 0.01908026f, -0.01456897f, 0.00823779f, 
    -0.01688069f, -0.04944889f, -0.03291963f, -0.01555234f, 0.00579568f, 0.04213924f, -0.01768558f, 0.03084166f, 
    -0.03127330f, 0.03156548f, -0.02504572f, 0.03174178f, 0.05076642f, -0.04942601f, -0.01330752f, -0.01859996f, 
    -0.05480748f, 0.03648009f, 0.00846016f, -0.04207247f, 0.04343076f, -0.05418659f, -0.06400063f, 0.05121878f, 
    -0.00557983f, -0.04138771f, 0.01299581f, -0.05744075f, -0.02727240f, -0.04201065f, -0.05542510f, 0.02447774f, 
    -0.04580967f, -0.01523933f, 0.01360515f, -0.02497708f, -0.04184670f, -0.01059823f, -0.00126112f, 0.02420473f, 
    -0.01407018f, -0.05477608f, 0.05791816f, -0.00455184f, -0.01090191f, 0.01214678f, -0.01341973f, 0.02490304f, 
    0.02956216f, -0.01175309f, 0.03150916f, -0.03441556f, 0.00720882f, 0.00566567f, 0.04879555f, 0.01864329f, 
    -0.06094779f, -0.02047231f, -0.01648500f, -0.04056214f, -0.02346912f, -0.03028658f, 0.00516770f, 0.02476988f, 
    -0.00081982f, 0.04365788f, 0.01601947f, -0.05400301f, -0.01088574f, 0.02147716f, 0.04198956f, -0.01266595f, 
    0.01256653f, -0.00807914f, 0.04864168f, -0.03634081f, 0.02428704f, 0.02392621f, 0.01666378f, 0.00139067f, 
    -0.03151476f, 0.01243819f, -0.01935997f, -0.03441269f, -0.01317092f, -0.00473882f, 0.00103100f, 0.01266591f, 
    -0.03217862f, 0.02163158f, -0.04434924f, -0.05765330f, 0.04838981f, -0.03702840f, -0.04691416f, 0.00121841f, 
    0.01215991f, -0.04398986f, 0.00425596f, -0.00797405f, -0.05740046f, -0.00298095f, -0.03607170f, 0.03393382f, 
    -0.37152055f, 0.23312201f, -0.13619839f, -0.28319678f, -0.10389134f, 0.07562705f, -0.12225141f, 0.15576431f, 
    0.16888005f, 0.37625518f, 0.37401077f, 0.34285849f, -0.13543183f, -0.29829633f, 0.01977926f, 0.04519667f, 
    -0.05290692f, 0.01285815f, 0.39566398f, -0.24541874f, 0.07543492f, 0.25625113f, 0.30932987f, -0.13146022f, 
    0.09366935f, 0.08534539f, 0.20375222f, -0.46213973f, -0.26845855f, 0.31016368f, -0.02991963f, 0.02246082f, 
    0.31678537f, 0.04408131f, 0.07848213f, -0.19778782f, 0.35709521f, -0.11254647f, 0.00014340f, 0.02914285f, 
    -0.00218573f, -0.16377562f, 0.02725547f, -0.09790170f, 0.05319388f, 0.58181858f, 0.40805691f, -0.21517166f, 
    -0.11839035f, -0.19193979f, 0.04175667f, 0.01295944f, 0.09208494f, 0.05953036f, -0.00514234f, -0.00467213f, 
    -0.05726895f, 0.11025228f, 0.14648806f, 0.00789422f, 0.09904902f, 0.11635652f, 0.03415155f, 0.32864773f, 
    0.07789741f, -0.20217040f, -0.16388233f, -0.00508023f, -0.05762629f, -0.24233617f, -0.26305676f, -0.08689414f, 
    0.04859630f, 0.38358539f, -0.23411866f, 0.12435627f, 0.00243816f, -0.19369347f, -0.06302652f, -0.03572397f, 
    0.06257593f, -0.43073702f, -0.33928537f, -0.15391377f, 0.00832404f, 0.10362311f, -0.32119325f, 0.05565852f, 
    0.06504085f, 0.05321990f, -0.03800613f, -0.24223846f, 0.09221181f, 0.15993290f, 0.14593130f, 0.09374725f, 
    -0.00423213f, 0.04552704f, -0.07014561f, -0.33458304f, -0.56905466f, -0.20230456f, 0.21542637f, 0.05047118f, 
    -0.16288415f, 0.21118657f, 0.18039858f, -0.04740362f, 0.17016245f, -0.01974451f, -0.35298765f, 0.11214127f, 
    0.05871518f, 0.23033696f, -0.09295290f, 0.17120080f, -0.04389090f, 0.37512729f, 0.11071228f, -0.09131438f, 
    0.05317719f, 0.16050804f, 0.31060556f, 0.08225282f, -0.07170276f, 0.05513236f, -0.15198722f, 0.21427906f, 
    -0.21208204f, -0.04686258f, 0.09735842f, -0.00323577f, -0.08598763f, 0.13564859f, -0.17089008f, 0.52374423f, 
    0.41901192f, 0.18826598f, 0.03463400f, -0.22952329f, -0.01779241f, -0.03263668f, -0.03276676f, -0.07509435f, 
    0.18893185f, -0.36478242f, -0.17812955f, -0.18603063f, -0.19811067f, 0.03042362f, 0.10813927f, -0.06724796f, 
    0.25450432f, 0.36955118f, -0.30694902f, -0.51952881f, -0.04379740f, 0.02447432f, -0.08603465f, 0.10423777f, 
    -0.05302659f, -0.02761112f, -0.50468522f, -0.35246071f, 0.55005717f, -0.12216640f, -0.24417345f, -0.15520044f, 
    0.15867902f, 0.04320606f, -0.05760387f, 0.23855470f, -0.33404395f, -0.14551955f, -0.04030717f, -0.32457969f, 
    0.32221356f, -0.00557755f, -0.34113720f, 0.06945162f, -0.04027289f, -0.08291594f, 0.10660158f, 0.13130637f, 
    0.05671140f, 0.07502054f, 0.01550324f, -0.01005016f, -0.03048232f, 0.34003586f, -0.23444395f, -0.18635689f, 
    0.00298446f, 0.16788143f, 0.13921550f, -0.15599853f, 0.27961951f, 0.18608004f, -0.23750821f, -0.28484151f, 
    0.07266768f, -0.08043079f, -0.03653529f, -0.00712377f, 0.01279662f, -0.11007445f, -0.05203480f, 0.32252473f, 
    0.04552973f, -0.20364256f, 0.01801391f, 0.34388739f, -0.17134352f, 0.18058901f, 0.29658771f, 0.07213744f, 
    0.03294055f, 0.38186914f, -0.04573559f, -0.06522544f, -0.05980443f, 0.12566672f, -0.11130586f, 0.12497732f, 
    -0.04793910f, 0.15909043f, 0.26770836f, -0.05880502f, 0.17257200f, 0.00730556f, 0.07799973f, 0.12019043f, 
    -0.03268327f, -0.05636206f, 0.33927688f, 0.33984485f, 0.08476717f, -0.02618053f, -0.09481750f, 0.07738908f, 
    -0.12378597f, -0.05408378f, -0.07825727f, -0.07630283f, -0.16845652f, 0.31896043f, -0.23429771f, -0.19723086f, 
    0.25432020f, 0.08049800f, 0.25917017f, -0.01503689f, -0.63642657f, 0.04079927f, -0.08326185f, -0.16305403f, 
    0.05508773f, -0.00177314f, -0.07049876f, -0.03912006f, 0.24936669f, 0.19489366f, -0.00071265f, -0.27219829f, 
    0.05756467f, 0.03923823f, 0.14792715f, -0.05748531f, -0.12125915f, 0.05029957f, -0.27228650f, -0.47842371f, 
    -0.45987159f, 0.12442706f, 0.02655960f, -0.21752839f, 0.01270804f, 0.08344485f, -0.00750268f, -0.27078518f, 
    -0.08588177f, -0.67497355f, 0.01626863f, -0.03650330f, -0.24484612f, 0.16430224f, 0.16376290f, 0.01883575f, 
    -0.00793833f, -0.19169931f, -0.05548506f, -0.14759718f, 0.00334867f, -0.10883012f, 0.15085055f, -0.34366482f, 
    0.08664433f, -0.29110309f, 0.28510845f, 0.07062082f, -0.05847027f, -0.09616846f, 0.18976559f, -0.00359154f, 
    0.05620285f, 0.18407503f, 0.21804607f, 0.12217177f, -0.07229138f, 0.11861778f, 0.28413832f, 0.03233542f, 
    0.06700623f, -0.06124707f, 0.03189234f, -0.02224737f, -0.39836365f, -0.22499067f, -0.20747235f, -0.12471326f, 
    0.23376189f, -0.21746506f, -0.29538342f, -0.16478722f, 0.07150420f, 0.20313506f, 0.05887660f, 0.03845274f, 
    -0.19729866f, -0.04723905f, 0.02217709f, 0.00166486f, 0.01411079f, 0.00186036f, -0.05290183f, -0.16467005f, 
    0.04556220f, -0.11788393f, -0.27386251f, -0.09776961f, -0.10704109f, -0.00444067f, -0.02777832f, 0.16688673f, 
    0.32480806f, 0.22280674f, -0.02582555f, 0.03057085f, 0.13393411f, -0.07353981f, 0.05153295f, -0.37728640f, 
    -0.32162690f, 0.09004366f, -0.11801569f, 0.04944169f, 0.11453473f, 0.12685394f, -0.14692724f, 0.08580934f, 
    0.25771785f, -0.07332247f, -0.41089436f, 0.04575839f, 0.01104443f, -0.02408846f, -0.18776302f, -0.11279453f, 
    -0.22927262f, 0.23125099f, -0.24452746f, -0.14316005f, 0.09956644f, 0.15031202f, 0.12316960f, 0.09448548f, 
    -0.01886186f, -0.03596229f, -0.77348870f, -0.36836448f, -0.43969274f, 0.05266365f, 0.20233479f, 0.14485414f, 
    0.03128202f, 0.19421352f, 0.11755523f, 0.14582600f, -0.25953868f, -0.26695427f, 0.14684348f, 0.30596521f, 
    -0.07038300f, 0.04046772f, 0.10399985f, 0.02071572f, -0.04911047f, 0.14041409f, 0.08464075f, 0.05573850f, 
    0.10511135f, 0.09863199f, -0.16040808f, -0.12028237f, 0.01622384f, -0.29126573f, -0.03910613f, -0.05044692f, 
    0.07826480f, -0.13748688f, -0.26542273f, -0.07115535f, -0.03933264f, 0.11091207f, -0.11150200f, -0.23265369f, 
    0.03627510f, 0.07798566f, -0.04839021f, -0.20320867f, 0.24790262f, 0.24858621f, 0.27257863f, -0.17597318f, 
    0.00552090f, -0.04761231f, -0.03029841f, -0.03948753f, -0.29797566f, -0.07070217f, -0.09905484f, 0.03098361f, 
    0.11909129f, -0.34221855f, -0.30651307f, 0.08982599f, -0.12688462f, -0.20540565f, 0.07014368f, -0.05068724f, 
    0.19975731f, 0.43776643f, -0.10498002f, -0.45271504f, -0.01913126f, -0.10014268f, -0.06484038f, 0.01935372f, 
    -0.13152036f, -0.21088448f, 0.06089221f, -0.54166377f, -0.05745691f, 0.05008544f, 0.01909361f, -0.24314584f, 
    -0.12656941f, 0.16534165f, 0.12996826f, -0.54799283f, 0.08588856f, -0.64075893f, 0.02132571f, 0.03266464f, 
    -0.10768332f, 0.05248630f, 0.07204969f, 0.09529439f, -0.04946304f, 0.00856713f, 0.11929024f, 0.12366821f, 
    0.23591331f, 0.39182809f, 0.28903484f, 0.05173277f, 0.07162268f, -0.36157829f, -0.44655016f, 0.09089316f, 
    0.17401831f, -0.03699724f, -0.18469350f, 0.27575594f, 0.13213956f, 0.14424369f, 0.24031979f, -0.00433542f, 
    0.05714346f, 0.16793743f, 0.06856127f, -0.14714690f, -0.08291648f, 0.01405089f, 0.19011630f, 0.09213938f, 
    0.21422099f, 0.11261411f, 0.11002810f, -0.13720264f, 0.13611358f, -0.12305357f, 0.09538067f, -0.11185049f, 
    0.32697731f, 0.03455628f, 0.13539582f, 0.11121661f, -0.11111800f, 0.29058257f, 0.06144363f, 0.01292906f, 
    0.05379692f, 0.00344118f, 0.28703353f, 0.46398899f, 0.18865572f, -0.03761281f, 0.03858959f, 0.10344879f, 
    0.05670088f, -0.03444391f, 0.24373323f, -0.31478378f, -0.10785796f, 0.08796109f, 0.11705802f, -0.06704587f, 
    0.15558290f, 0.10521248f, 0.17660302f, 0.08785058f, -0.09952096f, -0.46658739f, -0.27333218f, -0.01523653f, 
    -0.10256460f, -0.24888971f, -0.24003971f, 0.06609595f, 0.39127576f, -0.07302108f, -0.22359189f, 0.21525569f, 
    0.02466208f, 0.10774730f, 0.13830134f, 0.18163031f, 0.12734434f, 0.26400128f, 0.10324007f, 0.10809677f, 
    0.14268787f, 0.03371705f, -0.07704636f, 0.12992938f, 0.09919488f, 0.13361207f, 0.13846262f, -0.31088543f, 
    -0.20219056f, 0.24995427f, 0.10922313f, -0.00923786f, -0.05520955f, -0.06941252f, -0.03720536f, 0.39749154f, 
    -0.22431634f, -0.61338776f, 0.01792406f, 0.18586451f, -0.05941974f, 0.07382337f, -0.04983371f, -0.28959581f, 
    0.23748034f, -0.16433060f, 0.07240859f, -0.17696230f, 0.05564260f, -0.11233322f, -0.02223817f, -0.04180906f, 
    0.02552761f, -0.52900952f, -0.15977564f, 0.47175008f, -0.03179296f, -0.09841071f, -0.04566042f, 0.02335596f, 
    0.13286889f, 0.05401023f, -0.35177204f, 0.92060894f, -0.67601299f, -0.27153650f, -0.20024601f, -0.10258567f, 
    0.09031945f, 0.21271308f, 0.18190891f, 0.11242624f, 0.17587717f, 0.05309734f, 0.04698699f, -0.08168243f, 
    -0.17088439f, 0.27336931f, -0.11642255f, -0.14333241f, -0.26223171f, 0.50496429f, 0.12174566f, -0.21697143f, 
    -0.12283151f, -0.15880455f, -0.02267000f, -0.09181107f, 0.05805851f, -0.49598601f, -0.15529117f, 0.25399619f, 
    -0.03879621f, -0.02512248f, -0.21406813f, 0.06848205f, 0.06041085f, 0.02577809f, -0.35612407f, -0.00070493f, 
    -0.21491952f, 0.18100818f, 0.10163608f, 0.00414603f, -0.08104859f, 0.09256724f, 0.10365180f, -0.11638148f, 
    -0.10394060f, 0.18304020f, 0.22562326f, -0.12760642f, -0.20613675f, 0.02535246f, 0.27836654f, 0.20920514f, 
    -0.04425259f, -0.13041140f, -0.34023288f, 0.04273459f, -0.01751076f, 0.34878397f, -0.07853724f, 0.11132210f, 
    -0.15760592f, 0.22418034f, 0.03162785f, 0.19536287f, 0.00868837f, 0.17839316f, -0.10593037f, 0.10547588f, 
    0.07660132f, -0.01937431f, -0.23534320f, -0.18944544f, 0.31370461f, -0.07530364f, 0.04254129f, -0.03145482f, 
    0.06004017f, 0.15987626f, 0.05878167f, -0.09637895f, 0.26779404f, 0.75214708f, -0.02995721f, -0.03849846f, 
    0.04726626f, -0.27711675f, -0.05993103f, 0.01562430f, -0.06637220f, 0.16260195f, 0.13513322f, 0.10570581f, 
    -0.13888018f, -0.06812806f, 0.07683520f, 0.03061441f, -0.05503714f, -0.24820438f, -0.29722443f, -0.07179374f, 
    0.03199483f, -0.03452179f, -0.29087535f, -0.06811611f, 0.12716100f, 0.07778682f, -0.35965148f, 0.02138286f, 
    -0.09091108f, 0.03941822f, 0.22811389f, -0.19523016f, -0.01449571f, 0.09657821f, 0.16858508f, -0.56308508f, 
    -0.20516269f, 0.14057811f, -0.06539217f, -0.10869013f, 0.10735457f, 0.11434562f, 0.02909070f, 0.07252487f, 
    0.02272582f, -0.32418156f, 0.64424354f, -0.04567572f, -0.18637460f, 0.13133228f, -0.24388124f, 0.08607629f, 
    0.36087939f, 0.56514955f, -0.15348406f, -0.07623006f, 0.00507052f, -0.20533839f, 0.20476460f, 0.20943737f, 
    -0.07713707f, -0.08116728f, -0.20186968f, 0.33841997f, 0.06354027f, -0.20061837f, -0.24851161f, -0.24775569f, 
    0.21320873f, 0.07876816f, -0.14015211f, -0.02574064f, 0.02921567f, -0.02247860f, -0.09654565f, -0.42425844f, 
    0.30269566f, -0.08114448f, 0.17207050f, 0.04921497f, -0.26111096f, 0.17566976f, 0.11582142f, -0.08306900f, 
    -0.15709579f, -0.08075856f, -0.06459653f, -0.04897817f, 0.01347563f, -0.07510220f, 0.13736193f, 0.11277408f, 
    0.05446508f, 0.04439177f, -0.15232398f, -0.16998856f, 0.08490197f, 0.19542211f, -0.16464864f, 0.22731405f, 
    0.47882712f, -0.14696333f, -0.04838164f, -0.12379254f, -0.01587837f, 0.17546073f, 0.13302971f, -0.01591963f, 
    -0.07217075f, 0.05595086f, 0.08482238f, 0.22327524f, -0.08476795f, -0.12072584f, 0.12977248f, -0.04826153f, 
    -0.23545812f, 0.25981367f, 0.53994673f, 0.17722213f, 0.01133366f, -0.20572214f, -0.08993032f, 0.27169195f, 
    0.10027816f, -0.32293150f, -0.12094216f, -0.21911697f, 0.07374807f, 0.18057925f, -0.00248494f, -0.20373964f, 
    0.09642611f, 0.01412349f, -0.03774925f, -0.43424234f, -0.08980601f, -0.16690803f, -0.02551743f, -0.01735096f, 
    -0.08086409f, -0.06937481f, 0.27803481f, 0.15752622f, 0.38078758f, -0.15964054f, -0.03314030f, 0.00364274f, 
    -0.10725746f, 0.12197132f, 0.02685626f, -0.04559598f, 0.30804038f, -0.19038329f, 0.16664708f, 0.11227997f, 
    0.09556427f, -0.02357003f, -0.06639612f, 0.08292765f, 0.08437995f, -0.00499875f, -0.14154910f, 0.10531449f, 
    -0.01346764f, 0.04580403f, -0.19453387f, 0.11271932f, 0.05749672f, 0.01025715f, -0.03900860f, 0.14420031f, 
    0.02350412f, -0.06495432f, -0.12811475f, -0.23095380f, 0.20798416f, 0.10443614f, -0.00821832f, -0.18372001f, 
    0.25278452f, 0.38632053f, -0.06575678f, 0.45864573f, 0.22351921f, -0.22029391f, -0.12406602f, -0.06503905f, 
    -0.05934907f, 0.03159598f, 0.02458774f, -0.04777202f, -0.02885060f, 0.00487739f, 0.00998921f, -0.05557244f, 
    0.02985638f, 0.03451702f, 0.03067898f, -0.01389957f, -0.00993699f, -0.00590322f, -0.07354014f, 0.01714098f, 
    0.00169725f, -0.03085890f, 0.03949207f, -0.03633328f, 0.01179553f, -0.05478707f, -0.06231340f, -0.04251102f, 
    -0.01025170f, -0.01769525f, -0.06304390f, -0.05102366f, -0.06388980f, -0.02153129f, -0.06504354f, -0.02907129f, 
    -0.02079379f, -0.01138867f, 0.02047184f, -0.06641954f, 0.00689721f, -0.02024495f, -0.00119393f, -0.04906599f, 
    -0.01054229f, -0.02556778f, -0.06839616f, 0.02699724f, 0.03521365f, 0.00706994f, 0.01076154f, 0.04682721f, 
    0.03722977f, 0.00263896f, -0.00263581f, -0.06787855f, -0.00741224f, -0.04355598f, 0.03593482f, -0.00760352f, 
    -0.01822561f, 0.02851101f, -0.03098598f, 0.03847893f, 0.01527248f, 0.01321229f, 0.01072330f, 0.04005015f, 
    -0.00452852f, -0.03411400f, 0.03494509f, -0.04588963f, 0.01522917f, 0.02231653f, -0.05719000f, -0.00011555f, 
    -0.03195917f, -0.02712879f, -0.01034005f, 0.01119167f, 0.00841032f, -0.06196981f, -0.00115628f, 0.03866876f, 
    0.02397758f, -0.04094819f, 0.02897301f, 0.04449208f, -0.03745949f, -0.03928876f, -0.04349871f, -0.00933219f, 
    -0.05639764f, 0.03345132f, 0.01795442f, 0.03172502f, -0.01364429f, -0.06788664f, 0.01104373f, 0.04159580f, 
    -0.01466406f, 0.03191271f, -0.04854220f, -0.05887171f, -0.06023192f, -0.03967743f, 0.02582357f, -0.03512838f, 
    -0.05256702f, -0.07298297f, -0.06067166f, 0.02557858f, -0.04492964f, -0.04072104f, -0.01036920f, -0.02362628f, 
    -0.04776227f, 0.01006597f, 0.02277253f, 0.02587885f, -0.02882351f, -0.05936221f, -0.03314060f, -0.04145090f, 
    0.04012492f, -0.01024818f, 0.00868832f, -0.02695592f, -0.00460921f, -0.04772897f, -0.03860059f, -0.03412794f, 
    -0.01088057f, 0.02561306f, -0.04034016f, -0.06241843f, -0.03326027f, -0.06918633f, 0.04550983f, 0.00028555f, 
    -0.03902424f, 0.01729914f, -0.01518149f, 0.04470757f, -0.04959980f, -0.00328715f, -0.00398536f, 0.03256077f, 
    -0.06709310f, 0.02483311f, -0.03761047f, -0.01130286f, -0.03116199f, -0.04348887f, -0.02064574f, 0.01195176f, 
    -0.04393009f, -0.02601722f, 0.02624889f, -0.00116357f, -0.06063781f, -0.03790768f, 0.01817491f, 0.00388523f, 
    0.03600632f, 0.03078465f, 0.03611287f, 0.03710441f, -0.02771924f, -0.03449753f, -0.03015705f, 0.00003426f, 
    0.01220591f, 0.01272392f, 0.01576583f, 0.00879379f, 0.02787175f, -0.07024355f, -0.00623864f, -0.04875889f, 
    -0.05496935f, -0.06728752f, -0.00139500f, -0.04177761f, -0.06502818f, 0.03507449f, 0.04674461f, -0.01172045f, 
    -0.00977397f, 0.03381393f, 0.03700100f, 0.01061399f, 0.03543541f, -0.04713158f, -0.00294211f, -0.00320923f, 
    0.01312576f, -0.00506588f, -0.05732745f, -0.05480508f, -0.06437203f, 0.04523002f, -0.00446731f, 0.01473348f, 
    0.02488308f, 0.01923551f, 0.02952442f, 0.03085922f, 0.03561665f, -0.02486243f, 0.01708206f, -0.04449502f, 
    0.02744766f, -0.05827603f, -0.04326519f, 0.02151525f, -0.01625587f, -0.06684765f, -0.00336567f, -0.05603725f, 
    -0.03247714f, 0.03732880f, -0.01493734f, -0.06341290f, 0.00029022f, 0.01412983f, -0.00710530f, 0.01409048f, 
    0.03517308f, 0.03598801f, -0.01384030f, -0.01834784f, 0.03523164f, -0.02581992f, -0.01401602f, -0.03347421f, 
    -0.02955094f, -0.05933933f, -0.05768597f, 0.03757712f, 0.02301504f, -0.04776403f, 0.03126597f, -0.02978726f, 
    0.01808348f, -0.03063015f, 0.02268550f, -0.00090619f, 0.03914234f, -0.02790437f, 0.02273061f, 0.01039318f, 
    0.00687192f, 0.01195608f, -0.01031484f, 0.01384867f, -0.00084221f, -0.04766871f, -0.02571737f, -0.01799962f, 
    -0.00572571f, -0.00789084f, -0.00285605f, -0.01240326f, -0.02033595f, -0.01256444f, 0.02669232f, 0.00817853f, 
    -0.02943636f, -0.00409622f, 0.02734536f, -0.02769257f, -0.00199957f, -0.05480589f, 0.03168595f, 0.00721305f, 
    0.04577008f, -0.05921159f, 0.02963012f, 0.00342101f, 0.01257277f, -0.00981817f, -0.00787222f, 0.01298212f, 
    0.03805199f, 0.03256988f, -0.03845054f, -0.03255922f, 0.03091636f, 0.03656777f, -0.03039991f, -0.05545867f, 
    0.01230626f, -0.71055806f, -0.70366150f, 0.07138749f, -0.34496188f, 0.00019180f, 0.07893984f, 0.08530083f, 
    0.13213155f, -0.88273650f, -0.71839237f, -0.77673018f, -0.44573638f, 0.19002584f, -0.05172890f, 0.17031717f, 
    0.07398865f, 0.09488287f, -0.87768233f, -0.68742794f, 0.59454310f, 0.23027465f, -0.32936731f, -0.31669387f, 
    0.10499763f, -0.05952411f, -0.07686790f, -0.06247064f, -0.20187533f, -0.26554635f, 0.31573588f, 0.09680684f, 
    0.09796174f, 0.01834904f, -0.32043964f, -0.30881068f, -0.52313161f, 0.03923101f, -0.56365973f, -0.11079100f, 
    -0.15289618f, 0.03041307f, 0.21668398f, 0.12987143f, 0.12708034f, -0.10287326f, 0.31723261f, -0.61860907f, 
    -0.37972927f, -0.19097872f, -0.18544750f, -0.13693558f, -0.20146120f, -0.11497333f, 0.05957959f, 0.57698053f, 
    0.71919966f, 0.17203304f, 0.05743552f, -0.22186270f, 0.04670881f, 0.03950240f, 0.23708130f, 0.04358462f, 
    0.00161536f, 0.44502011f, -0.17833669f, 0.29327941f, 0.07147383f, 0.22801505f, 0.21631740f, 0.11667040f, 
    -0.23054598f, 0.09515880f, 0.04810419f, 0.06287213f, 0.06485375f, 0.07109335f, 0.18411179f, 0.01152785f, 
    -0.28108078f, 0.06963822f, -0.13767760f, -0.03122303f, 0.25157660f, 0.18628274f, 0.15456764f, 0.16139799f, 
    0.13326128f, -0.03201041f, -0.44433102f, 0.27299970f, 0.47738817f, 0.08636607f, -0.08765876f, -0.23823735f, 
    -0.02956336f, 0.12140126f, -0.06336663f, -0.19360858f, -0.21492787f, 0.08031207f, 0.12277658f, 0.16487463f, 
    0.21268708f, 0.02823926f, 0.15136796f, 0.01562492f, 0.09140234f, 0.15546891f, 0.29758379f, 0.00665242f, 
    -0.12868281f, -0.09609898f, 0.12737399f, -0.11158628f, -0.08284159f, 0.12789960f, 0.11904985f, -0.02655294f, 
    -0.06092646f, -0.13038118f, -0.13074310f, -0.00872258f, 0.07060905f, 0.32522389f, -0.26751745f, 0.36723360f, 
    0.25686327f, -0.12650408f, 0.02004594f, -0.09130178f, 0.07368442f, 0.03095208f, 0.07915837f, -1.07497799f, 
    0.28044349f, -1.18419051f, -0.13106595f, 0.12138060f, -0.06060052f, 0.22549540f, -0.15825585f, -0.04365723f, 
    0.51086366f, 0.12784910f, 0.42262515f, 0.16443746f, -0.08928715f, -0.07317548f, 0.27051282f, 0.24160565f, 
    0.16975316f, 0.53299707f, -0.33224899f, 0.02843462f, 0.02946106f, 0.04634659f, 0.35101703f, 0.03299837f, 
    0.25345469f, -0.00887566f, -0.36678395f, -0.15289274f, -0.69610888f, 0.14304191f, 0.13431197f, 0.08298283f, 
    -0.00501127f, 0.10168315f, 0.09119748f, -0.20975369f, -0.08258969f, 0.05077453f, 0.00256823f, -0.01056419f, 
    0.00174201f, -0.00957774f, 0.18335202f, 0.36719003f, -0.67032856f, 0.15620211f, 0.62594992f, 0.04320119f, 
    -0.11082534f, -0.34776247f, 0.06159167f, 0.11656893f, 0.02288111f, -0.10077710f, 0.22186187f, 0.25101307f, 
    0.03463040f, 0.00242854f, -0.19674389f, 0.15897231f, 0.17237790f, 0.34016785f, 0.05898445f, -0.15702921f, 
    -0.45651892f, 0.25241911f, 0.19449231f, 0.02599998f, 0.20487684f, 0.14001197f, 0.18941890f, -0.15613943f, 
    0.20342024f, 0.39485237f, -0.16915601f, -0.09476188f, -0.07648317f, -0.02167394f, -0.09916130f, -0.27944750f, 
    -0.27713567f, -0.61032152f, -0.39575458f, -0.24609561f, 0.01190843f, -0.28530917f, 0.11247335f, 0.07885241f, 
    0.04085311f, 0.35375503f, 0.48566058f, 0.01119523f, 0.01015034f, -0.06690945f, -0.15817338f, 0.05680167f, 
    0.13821496f, 0.28521299f, 0.67005336f, 0.39130586f, 0.28586504f, -0.03762566f, -0.36804023f, -0.39779583f, 
    0.06161880f, 0.17381999f, 0.17458771f, 0.18816176f, 0.00670510f, -0.32546401f, 0.22444229f, 0.07425333f, 
    0.36298165f, -0.01962787f, -0.07380807f, -0.18807860f, 0.15394162f, -0.13128950f, 0.04569652f, 0.25781614f, 
    0.11675853f, 0.09562667f, 0.15966465f, 0.11151432f, -0.00088987f, 0.16175583f, 0.13067541f, 0.06510220f, 
    0.04954143f, 0.03602969f, -0.04486599f, 0.14318201f, 0.05584810f, 0.36404389f, -0.25769344f, -0.20576712f, 
    0.03352651f, 0.03307907f, -0.03123339f, 0.04105484f, 0.12511575f, -0.03754934f, -0.02257702f, -0.52124131f, 
    -0.08237376f, 0.00012221f, 0.01577199f, -0.02766073f, 0.57876456f, -0.10156567f, -0.16841917f, -0.35115859f, 
    0.04671616f, -0.01295131f, 0.05524022f, 0.02849583f, 0.01729055f, 0.04230886f, -0.01826475f, -0.05358506f, 
    -0.02107135f, -0.02810542f, -0.06143389f, -0.06137815f, 0.03266972f, -0.00651137f, 0.01415725f, 0.02903978f, 
    -0.03206412f, -0.01965260f, -0.05815789f, -0.04768909f, -0.06499735f, 0.02080632f, -0.06293507f, -0.06132997f, 
    -0.05071990f, -0.05483131f, 0.04747268f, -0.02039404f, -0.00843333f, 0.02889461f, -0.05631915f, -0.00799929f, 
    -0.02588394f, -0.03042085f, -0.00780383f, 0.00245667f, 0.01194143f, -0.04441259f, 0.04011695f, 0.02560301f, 
    -0.06772954f, -0.01438116f, 0.02654898f, -0.01518749f, -0.05623973f, -0.03861883f, -0.02316915f, 0.04122392f, 
    0.03372082f, -0.05884550f, -0.03395001f, -0.02514295f, -0.00316852f, -0.00490840f, -0.01479222f, -0.01597385f, 
    -0.02851509f, -0.06484985f, 0.00743792f, 0.03253752f, 0.04885133f, -0.00128049f, -0.06247287f, -0.04778723f, 
    -0.00637864f, 0.01448850f, -0.03405618f, -0.04632149f, -0.05878019f, 0.04182555f, -0.05053000f, 0.01594547f, 
    0.04641943f, -0.04682729f, -0.05819678f, -0.06267148f, 0.01041965f, 0.00788265f, -0.04268866f, 0.04248917f, 
    0.01197238f, -0.02445821f, 0.03198646f, 0.00979235f, 0.05070079f, 0.00889168f, -0.03326524f, 0.05306470f, 
    -0.04614455f, 0.01929411f, 0.03468594f, -0.04598628f, 0.04587310f, -0.05415531f, -0.01529214f, 0.01491217f, 
    -0.01228503f, -0.03924103f, 0.01560186f, 0.00041060f, -0.00082637f, 0.00761119f, -0.06087608f, -0.06833412f, 
    -0.00129619f, -0.01959010f, -0.03886865f, -0.02504394f, 0.04487115f, 0.00275172f, 0.01332601f, 0.04817388f, 
    -0.01306311f, -0.03070247f, 0.03554521f, 0.00994401f, -0.04711469f, 0.00786838f, 0.04461723f, -0.04283068f, 
    -0.05509955f, 0.05323794f, 0.00532125f, 0.03738585f, -0.04096201f, 0.05654841f, 0.00573404f, 0.03150455f, 
    -0.02172033f, -0.04404652f, -0.01873189f, 0.04979855f, 0.04391884f, 0.04076621f, -0.05689370f, -0.00957364f, 
    -0.06293022f, -0.02225402f, 0.03697721f, 0.01051631f, -0.00157521f, 0.02953912f, 0.04510953f, 0.02974624f, 
    -0.01909538f, -0.06677977f, 0.02510801f, 0.02712044f, -0.01645666f, -0.01892818f, -0.03479160f, -0.03801823f, 
    -0.00103840f, -0.03401313f, 0.00463894f, -0.03033771f, 0.03138278f, 0.00550717f, -0.01529896f, -0.03251415f, 
    -0.05134834f, -0.04495874f, 0.00050317f, -0.05454992f, 0.04810499f, 0.00193843f, -0.02860116f, -0.04316596f, 
    0.03988562f, -0.00884509f, -0.00522482f, -0.01319642f, -0.01294865f, -0.03702250f, 0.03069797f, -0.03783967f, 
    -0.03514995f, -0.04200524f, 0.04199924f, 0.04907661f, -0.00366719f, 0.02245031f, -0.03510499f, -0.01647704f, 
    0.05074381f, -0.01819571f, 0.03969719f, -0.00121398f, 0.03475433f, -0.01253338f, 0.04390514f, -0.00661471f, 
    -0.06416722f, -0.03190356f, 0.01287731f, 0.04852409f, 0.05057690f, -0.04613179f, 0.02771407f, 0.04432270f, 
    0.01535258f, 0.02421946f, 0.00937594f, -0.04378467f, -0.01286800f, 0.03943602f, 0.04621580f, -0.04872224f, 
    -0.01083495f, 0.00222103f, -0.04914708f, 0.00211528f, -0.04157034f, -0.04492546f, -0.04052428f, -0.04936559f, 
    0.01169635f, -0.05012935f, -0.04190749f, 0.02983413f, -0.02196664f, -0.00755695f, -0.03210523f, -0.02996176f, 
    -0.02873440f, 0.01486470f, -0.01738271f, -0.04897699f, -0.05143847f, 0.03579098f, -0.01369025f, -0.00082166f, 
    -0.01361549f, -0.06321834f, 0.04840524f, 0.02179546f, 0.00407721f, 0.01838786f, 0.02112695f, 0.02888588f, 
    -0.02316047f, -0.03874329f, -0.04735817f, -0.02252972f, -0.03397521f, 0.02637467f, -0.00740242f, 0.04089700f, 
    -0.06320906f, -0.06646294f, -0.03709459f, -0.01391105f, -0.02656978f, 0.02951321f, 0.04317698f, -0.06228350f, 
    -0.05366288f, -0.02250220f, -0.03982039f, -0.00043633f, -0.02471533f, -0.00318908f, -0.06184549f, -0.05229205f, 
    0.01063122f, 0.04550907f, -0.00144640f, 0.00412329f, -0.02286566f, 0.04138709f, -0.01972537f, -0.02955227f, 
    -0.00169758f, -0.03923654f, 0.01968425f, 0.04944145f, -0.02686282f, -0.04958442f, 0.02722581f, -0.02291617f, 
    -0.06344929f, 0.01918277f, -0.02952573f, -0.04845065f, 0.03320251f, -0.01524519f, -0.02201547f, -0.04992809f, 
    0.04338776f, 0.32167110f, 0.40572509f, 0.31701595f, 0.19925228f, 0.13081625f, 0.04071598f, 0.09781239f, 
    0.09863541f, 0.45399413f, 0.22348253f, 0.17561534f, -0.09094510f, 0.00717028f, 0.14177912f, 0.03426857f, 
    -0.04378172f, 0.09298155f, -0.04937405f, -0.55919170f, 0.14592826f, 0.09655400f, -0.01456580f, 0.11926132f, 
    -0.06493839f, 0.08890163f, 0.01247478f, -0.15558510f, -0.01221626f, -0.01742181f, -0.03644717f, 0.06412271f, 
    -0.21802884f, 0.05568796f, -0.08084423f, -0.19440264f, 0.23431495f, 0.01897075f, 0.18198623f, -0.20393772f, 
    0.14408584f, 0.12700875f, 0.06059628f, 0.05694409f, 0.07218061f, 0.39420807f, 0.25728643f, -0.31362996f, 
    0.27296656f, 0.04902831f, 0.14193188f, -0.34304360f, -0.10127856f, -0.08094727f, -0.01595064f, -0.29718053f, 
    -0.02873996f, 0.02003888f, 0.01715124f, 0.18105550f, 0.10044131f, 0.10772251f, 0.16722092f, -0.02955301f, 
    0.19632964f, -0.13707897f, 0.01553135f, 0.33214566f, 0.01200149f, -0.12914141f, 0.14501275f, -0.01114034f, 
    -0.09416679f, -0.07869641f, -0.07491563f, 0.00701487f, 0.12411383f, 0.04730398f, -0.08013643f, -0.17911479f, 
    -0.16106148f, -0.12298580f, -0.00870882f, -0.05379401f, 0.00833567f, -0.00961147f, 0.08745326f, 0.04457600f, 
    0.02531650f, 0.03017899f, 0.20784374f, 0.08454413f, -0.01442038f, 0.19669114f, 0.35693595f, 0.02286556f, 
    -0.20971699f, -0.29525954f, 0.05240012f, 0.09391709f, -0.18516910f, -0.21512485f, 0.04977570f, -0.05807755f, 
    0.11381394f, 0.28474617f, 0.25528508f, -0.03305370f, 0.02470119f, -0.01203281f, -0.07264861f, 0.42561576f, 
    -0.12515430f, 0.06722367f, 0.02830896f, -0.29589257f, -0.29359028f, -0.08394998f, -0.06330746f, -0.24265873f, 
    0.04881349f, 0.10432109f, -0.07084309f, 0.03124072f, -0.24292426f, -0.21278946f, 0.23704319f, -0.06510029f, 
    -0.21498464f, 0.05270216f, 0.09211899f, 0.05419018f, -0.02593262f, 0.01242249f, -0.14862542f, 0.42531389f, 
    0.44371623f, 0.21978603f, 0.01476261f, -0.04722071f, -0.01792972f, -0.01576298f, -0.08057778f, 0.10360575f, 
    -0.31182292f, 0.18366295f, 0.08401596f, 0.18858181f, 0.09760299f, 0.16342869f, -0.13229904f, -0.06405098f, 
    -0.07245720f, 0.09425411f, 0.33067593f, 0.61731946f, -0.08155090f, 0.03698218f, 0.17382187f, 0.08586442f, 
    0.16698962f, 0.17620248f, 0.35329250f, 0.14425242f, -0.44478598f, -0.03605382f, 0.10723844f, -0.01745940f, 
    -0.05749552f, 0.12709691f, 0.02401126f, 0.13223590f, 0.15891013f, -0.02473077f, -0.05779684f, 0.11326733f, 
    0.01192541f, 0.32726547f, 0.07445753f, 0.03854647f, -0.00649339f, -0.42187607f, 0.16417831f, 0.16296899f, 
    0.09172361f, 0.13473609f, -0.03487296f, -0.01468162f, 0.04416778f, 0.12747042f, -0.14597884f, -0.19964814f, 
    0.04386500f, 0.05679566f, -0.08109006f, 0.11327145f, -0.21951593f, -0.05149046f, 0.31799901f, 0.36090872f, 
    0.10803072f, 0.10578236f, 0.12467796f, 0.16864662f, 0.13457172f, 0.11122738f, 0.04265967f, 0.13996111f, 
    -0.17356387f, -0.00332613f, 0.19251831f, 0.08893387f, -0.04584788f, 0.22907150f, -0.34081432f, -0.35564053f, 
    -0.05822054f, 0.00340398f, 0.14203416f, 0.00491966f, -0.12208363f, 0.21131328f, -0.01121708f, -0.00891943f, 
    0.12184712f, -0.08799578f, -0.21462120f, -0.17715630f, 0.18383463f, -0.03117656f, 0.26872227f, -0.03458023f, 
    0.19243068f, 0.24635540f, -0.38433877f, 0.05598188f, 0.26522249f, 0.13988639f, 0.29641858f, 0.24392717f, 
    -0.21968669f, 0.09070659f, 0.11486764f, 0.09604339f, 0.07845609f, 0.15432595f, 0.03687498f, 0.07272509f, 
    -0.13291590f, 0.13248140f, 0.06343282f, -0.17741720f, -0.11681359f, -0.03718980f, -0.09968533f, 0.03898771f, 
    -0.01339492f, 0.09996626f, 0.09665701f, 0.05323051f, 0.08975703f, -0.16404116f, -0.01077731f, -0.09406626f, 
    0.12488783f, 0.16365646f, 0.09003559f, 0.02915679f, 0.10759731f, -0.11831966f, -0.43081421f, -0.01237917f, 
    -0.24110951f, 0.05226620f, 0.13378169f, -0.01367776f, 0.10272989f, 0.00995326f, 0.13813439f, 0.24575673f, 
    0.05554477f, -0.21149960f, -0.36351100f, -0.04824549f, -0.11772351f, 0.01636175f, 0.35093591f, -0.14374582f, 
    0.31897202f, 0.44296581f, 0.13247409f, 0.15685950f, 0.09137852f, 0.00160016f, -0.21208175f, -0.22234368f, 
    -0.49866009f, 0.06791071f, 0.12573817f, 0.07771420f, 0.03191339f, -0.06054277f, 0.09095404f, -0.15025733f, 
    -0.01823200f, -0.09792582f, 0.09640871f, -0.07765605f, 0.32452407f, 0.08916168f, -0.20227411f, -0.05136617f, 
    0.01819651f, 0.10985313f, 0.18028036f, -0.10784068f, -0.17455411f, 0.08364680f, 0.12285332f, 0.14009775f, 
    -0.07934744f, 0.19477309f, 0.23459972f, 0.46437570f, 0.03470195f, 0.06030663f, 0.36757770f, 0.10913514f, 
    -0.00544952f, 0.10674063f, -0.07035781f, -0.11202370f, -0.32075515f, -0.26952094f, 0.39586657f, 0.08795672f, 
    0.06749063f, 0.10505511f, 0.07569506f, -0.02729589f, 0.21055031f, -0.00501251f, 0.11839323f, -0.09759859f, 
    -0.01364210f, 0.06529173f, -0.00682607f, -0.14484465f, -0.25560859f, -0.00672335f, 0.01564548f, -0.32725951f, 
    -0.08041482f, 0.21981868f, 0.09092717f, 0.32923552f, 0.18662266f, 0.10153563f, 0.12408194f, 0.05153012f, 
    0.00873752f, 0.35266042f, 0.11537769f, -0.12602061f, -0.26745117f, -0.08839468f, -0.05359323f, 0.30731562f, 
    0.04844128f, -0.02212575f, -0.16645148f, -0.08633256f, -0.01986121f, 0.21314949f, 0.15771089f, -0.09733053f, 
    -0.02760640f, 0.05809843f, -0.04490678f, 0.00591123f, 0.02112765f, -0.03270291f, -0.06782124f, -0.00179244f, 
    0.02376689f, 0.04001436f, -0.00053114f, 0.04039956f, 0.05797546f, 0.05415767f, -0.07990886f, -0.02727516f, 
    0.25005341f, -0.29808095f, -0.05039742f, -0.13915400f, 0.18986534f, 0.15693986f, 0.22122037f, 0.04077499f, 
    0.06216878f, -0.11867979f, 0.21176845f, -0.01903411f, 0.22156475f, -0.12333960f, -0.12022248f, -0.14155850f, 
    0.35333791f, 0.05275002f, 0.13871893f, -0.20359109f, -0.03521953f, -0.18284227f, -0.15478465f, 0.03227821f, 
    0.09556726f, 0.28943336f, -0.13951285f, -0.03851483f, -0.07843269f, 0.05744760f, -0.02262875f, -0.04638709f, 
    0.28595707f, 0.38346949f, 0.05580825f, 0.05949458f, 0.15295964f, -0.09014557f, -0.10399728f, -0.03003345f, 
    0.01275334f, -0.06552056f, -0.08505328f, 0.33466035f, 0.40495214f, 0.06139491f, -0.12968062f, -0.00301663f, 
    -0.09638330f, 0.11445740f, 0.54009837f, -0.34273389f, 0.08817158f, 0.04397976f, -0.05491497f, 0.06500126f, 
    0.26456222f, -0.15049753f, -0.26070699f, -0.11502799f, -0.28567550f, 0.06080042f, -0.07573011f, -0.01846002f, 
    -0.33192229f, 0.12517411f, -0.21469155f, -0.04216299f, 0.13013956f, -0.00274544f, 0.08448306f, -0.24164061f, 
    0.11771745f, -0.13196802f, -0.02619553f, -0.16989376f, 0.25154004f, 0.16973278f, -0.08008676f, 0.01848970f, 
    0.06693898f, -0.04435564f, -0.01322067f, -0.07677523f, 0.11557295f, -0.13360226f, -0.32864267f, -0.00465136f, 
    0.09754946f, -0.26581243f, 0.17158465f, -0.07220519f, 0.19633287f, -0.20333289f, -0.08225679f, -0.11163091f, 
    -0.00631195f, -0.00209429f, -0.09316180f, 0.00899074f, -0.27152100f, -0.15524547f, -0.28630406f, 0.10211770f, 
    0.25332892f, 0.14740190f, -0.02563361f, -0.41484407f, -0.15352201f, 0.04848421f, 0.13073137f, -0.05970470f, 
    0.39094493f, 0.00423654f, -0.35224569f, -0.02483861f, -0.02699684f, 0.07370288f, -0.09873801f, -0.35721692f, 
    0.02942223f, 0.03391734f, 0.20697248f, -0.06844338f, 0.10399996f, -0.07004831f, -0.19552477f, -0.26326990f, 
    -0.15755716f, -0.10490913f, 0.07124787f, -0.13630082f, -0.58206993f, 0.19710754f, 0.03521277f, 0.13195518f, 
    -0.08667266f, -0.03172332f, -0.18028960f, -0.14929788f, 0.10327351f, 0.22750285f, 0.02076843f, 0.13193044f, 
    0.04087953f, 0.07287487f, 0.08660427f, 0.26140898f, 0.17087245f, -0.00890370f, -0.04942451f, 0.07081895f, 
    0.19169348f, 0.02613557f, -0.13240767f, 0.09653056f, -0.09182883f, -0.11140249f, -0.05661552f, -0.09881657f, 
    0.04088443f, -0.11260500f, -0.02433920f, -0.20364708f, -0.15203287f, -0.19636388f, -0.00131491f, -0.04638025f, 
    -0.11051776f, -0.11483096f, -0.04163456f, -0.02261544f, -0.02339080f, -0.04005677f, -0.20858929f, 0.06960802f, 
    0.46566087f, 0.50130051f, 0.12107582f, -0.17616555f, 0.16991447f, -0.09939332f, 0.14500943f, 0.15715913f, 
    0.20665771f, 0.02143184f, -0.81306809f, -0.02405734f, -0.24913496f, 0.07455070f, 0.02328282f, 0.12617326f, 
    -0.03939153f, 0.58386612f, 0.21450150f, -0.25090471f, 0.05788209f, -0.12041381f, -0.08037518f, -0.02055373f, 
    0.07182360f, 0.04669927f, 0.28686523f, 0.22386657f, -0.30034551f, -0.02933042f, 0.10533892f, -0.29105157f, 
    -0.12303700f, 0.15325491f, -0.26166281f, -0.52585793f, -0.19306497f, 0.02108615f, -0.13673939f, -0.05933698f, 
    0.04650103f, 0.00965376f, 0.07719339f, 0.17886625f, 0.05968501f, 0.18002553f, -0.12306121f, -0.00184554f, 
    0.02738885f, -0.11352547f, -0.05455144f, 0.04067406f, -0.14185931f, 0.13065477f, 0.08827674f, -0.25484329f, 
    0.13254255f, -0.16838256f, 0.25903761f, -0.13643302f, 0.08467682f, 0.18023160f, 0.04512650f, 0.20832255f, 
    -0.10064077f, -0.11060202f, 0.06210271f, 0.03378384f, -0.01713513f, -0.03502455f, -0.35623217f, 0.02352714f, 
    0.01881972f, 0.40109417f, -0.20996033f, 0.07836287f, -0.00453535f, 0.01510245f, 0.22505789f, 0.04966203f, 
    0.10815711f, 0.05955826f, 0.04922790f, -0.06778481f, -0.15476415f, 0.15715304f, -0.12040078f, -0.05758752f, 
    0.17421937f, 0.02220592f, 0.10290270f, 0.13218801f, -0.08898140f, -0.00781604f, -0.02843714f, -0.05277506f, 
    -0.11638214f, 0.04834862f, -0.07598265f, -0.09300522f, 0.10261565f, -0.31205797f, 0.05836902f, -0.09967560f, 
    0.00197376f, -0.02336334f, 0.05591745f, 0.08127195f, 0.11163261f, 0.24036303f, 0.15608872f, -0.14400852f, 
    0.03822737f, -0.02756925f, 0.13090138f, 0.12223870f, -0.15338646f, 0.03938439f, -0.31969097f, 0.04417665f, 
    -0.00258473f, 0.12217513f, -0.04343439f, -0.02102103f, 0.23405671f, 0.03782006f, 0.09756683f, 0.22727765f, 
    -0.04536492f, 0.18290310f, -0.14588077f, 0.21681778f, -0.08315012f, -0.43050608f, 0.02995532f, -0.03484254f, 
    0.12619562f, -0.09706140f, 0.09786733f, 0.18695477f, 0.12055149f, -0.08591793f, -0.08796315f, 0.35411501f, 
    0.09854421f, 0.13080293f, 0.04524298f, -0.14331502f, 0.16575801f, 0.07446984f, 0.09525212f, 0.16179793f, 
    -0.11301367f, 0.11645882f, 0.26652449f, 0.17142686f, 0.05681990f, -0.00267687f, -0.04878278f, -0.18347071f, 
    0.19396369f, -0.16664349f, -0.48602408f, 0.08872206f, -0.05050762f, 0.09474357f, -0.12595637f, 0.07598891f, 
    0.03257956f, -0.12647845f, -0.18926740f, -0.03949704f, 0.31244540f, -0.03530790f, -0.12564279f, -0.04284035f, 
    -0.04477209f, -0.09648712f, 0.06557532f, -0.04812101f, 0.12400185f, 0.24631883f, 0.02812720f, -0.13117468f, 
    -0.06807102f, -0.04645458f, -0.12828018f, -0.16980460f, 0.22654127f, 0.20076033f, -0.02538337f, -0.10558848f, 
    0.16981034f, -0.02097308f, 0.01324449f, -0.10506839f, 0.12437218f, -0.17518710f, -0.05524834f, 0.19204068f, 
    0.01651299f, 0.23607314f, -0.01358146f, 0.07994135f, -0.01914837f, -0.12557341f, -0.23721310f, 0.09053373f, 
    0.11329879f, -0.01785357f, -0.15603007f, 0.02411523f, 0.02639042f, 0.05762073f, 0.03819743f, 0.00361411f, 
    -0.02252211f, -0.17095317f, 0.02043586f, 0.07685289f, 0.04713906f, -0.12705193f, 0.04748447f, 0.22156966f, 
    0.39767268f, 0.21546586f, -0.31436762f, 0.03705959f, -0.10911951f, -0.02559613f, -0.01606457f, -0.11273393f, 
    0.16316158f, -0.00296363f, 0.34366572f, -0.00816203f, -0.06100645f, 0.03224590f, -0.08300589f, 0.15479027f, 
    -0.13112631f, -0.44588101f, 0.01948593f, -0.17633776f, -0.25691009f, -0.29736814f, 0.15779814f, -0.22764651f, 
    0.08364137f, -0.31604135f, -0.14169493f, -0.54751480f, -0.21014611f, -0.24454112f, -0.00123759f, -0.02183796f, 
    0.02856878f, 0.03759609f, 0.07682769f, 0.25666055f, 0.08572630f, 0.20621705f, 0.31833440f, -0.02879534f, 
    0.01350799f, 0.06220216f, -0.08969370f, -0.07456130f, 0.03412498f, 0.04573017f, 0.05872004f, 0.19902401f, 
    0.10793886f, 0.03884257f, -0.08187199f, 0.10203353f, 0.07290787f, -0.03544870f, 0.07474761f, 0.10166524f, 
    0.22874898f, -0.09743086f, 0.00082653f, -0.12143020f, 0.00973605f, -0.14136589f, -0.06883358f, 0.16060862f, 
    -0.11056822f, -0.11891571f, 0.06392816f, -0.11023789f, 0.19113387f, -0.05510271f, 0.10146976f, 0.04056373f, 
    0.20581673f, 0.10198330f, -0.27059457f, 0.04365762f, 0.00818233f, 0.15942734f, 0.15842502f, 0.01128214f, 
    -0.03628327f, -0.01747462f, 0.48960906f, -0.01826124f, -0.04000679f, -0.08580208f, 0.14978939f, 0.03689772f, 
    0.04108708f, 0.07647442f, 0.23571007f, -0.29317597f, -0.05431892f, 0.18879886f, 0.01499530f, -0.28802770f, 
    -0.02111217f, -0.13241547f, -0.15536983f, -0.31992549f, -0.02560149f, 0.11920325f, -0.07718609f, -0.07177328f, 
    0.14861596f, -0.05042730f, 0.13527401f, 0.03244285f, 0.22977597f, 0.15488498f, 0.14574651f, 0.10025781f, 
    0.05749434f, 0.07619290f, 0.11111188f, 0.13655961f, -0.05639983f, 0.44270289f, -0.06134137f, 0.29684019f, 
    0.14347841f, -0.13086334f, -0.07752561f, 0.06488566f, 0.01972784f, 0.07875413f, 0.15767744f, -0.13006400f, 
    -0.35138139f, 0.04539648f, 0.09844921f, 0.09169421f, -0.00837818f, -0.01326524f, 0.04661354f, -0.39914376f, 
    0.46855879f, -0.12521330f, 0.18771611f, -0.04627440f, -0.18977037f, 0.25605363f, 0.10437330f, -0.05195052f, 
    0.18203557f, -0.17566034f, -0.29836512f, 0.06166565f, -0.14188859f, 0.05690271f, 0.26422060f, 0.17845240f, 
    0.07857227f, -0.15450703f, 0.13917145f, 0.21318328f, 0.07576164f, -0.02469146f, 0.02107862f, -0.07818527f, 
    0.05419463f, 0.00790696f, 0.36115611f, -0.55624807f, -0.35223252f, -0.10142491f, -0.05567470f, 0.05161639f, 
    0.07695911f, -0.01370937f, 0.09573959f, -0.22055767f, 0.09551882f, -0.07692770f, 0.05574270f, 0.02331670f, 
    -0.18758169f, 0.08414971f, -0.15693219f, -0.01310389f, 0.07395240f, -0.05579140f, -0.11430360f, -0.01659878f, 
    0.00260710f, -0.09284607f, 0.00506545f, 0.01073048f, 0.00311132f, -0.17104982f, -0.10737601f, 0.18708856f, 
    -0.06255925f, -0.05982183f, 0.05529201f, 0.06682492f, 0.05101862f, -0.09530513f, 0.02760770f, -0.30226022f, 
    -0.25098315f, 0.06068731f, -0.10276140f, 0.11536726f, 0.13346741f, 0.06253152f, -0.09184359f, 0.25782242f, 
    0.03743012f, 0.06501436f, -0.15074885f, -0.02395240f, 0.10208949f, 0.02072648f, 0.10954543f, 0.01579235f, 
    -0.23892327f, -0.06830985f, -0.01946308f, -0.00011424f, 0.01836963f, -0.14040729f, -0.05599124f, 0.08707239f, 
    0.21965195f, -0.32516369f, -0.11735022f, -0.40304369f, -0.01457513f, 0.07212278f, 0.04868122f, 0.16528778f, 
    -0.20045082f, -0.10493529f, -0.37762651f, 0.06986725f, 0.49676108f, 0.04970036f, -0.07764143f, -0.12229666f, 
    0.16259356f, 0.02911764f, 0.12257363f, -0.17953837f, 0.01488087f, -0.06947122f, -0.06299219f, 0.18656491f, 
    -0.26715013f, -0.04902072f, -0.08788143f, 0.17210154f, -0.08004122f, -0.09518417f, -0.69540876f, 0.00652365f, 
    0.03816377f, 0.23055808f, 0.05199662f, 0.00669845f, 0.03812265f, 0.26199147f, -0.00698893f, 0.12665430f, 
    -0.12881148f, -0.04456183f, -0.09686549f, -0.06032482f, -0.12570648f, -0.16791801f, -0.09681897f, 0.22999287f, 
    0.15283790f, -0.04584661f, 0.06758846f, -0.09027367f, -0.00004339f, 0.04155746f, 0.25612116f, 0.19557078f, 
    -0.33933023f, -0.09648829f, -0.06383270f, -0.15076414f, 0.02277305f, 0.10993806f, 0.02741945f, 0.01290777f, 
    -0.23383197f, 0.24249983f, -0.49987915f, 0.15270999f, -0.25396773f, 0.24501330f, -0.00874002f, 0.07570646f, 
    0.04290976f, 0.08349471f, -0.19000772f, -0.50803894f, 0.03384416f, 0.02890718f, 0.16271217f, 0.10803536f, 
    -0.01198860f, 0.00701585f, 0.05072074f, -0.65248424f, -0.52833170f, -0.18906902f, 0.24310575f, 0.08926435f, 
    0.03124153f, -0.05076287f, 0.05383254f, -0.09694242f, -0.16223328f, 0.12652279f, 0.05233666f, 0.07567879f, 
    -0.01265307f, 0.20508403f, 0.12954795f, -0.01650155f, -0.48980248f, 0.13336487f, 0.08788918f, 0.20802251f, 
    -0.06574754f, 0.09943494f, 0.19485332f, 0.03650347f, 0.01401595f, -0.26522437f, -0.00022364f, 0.20554614f, 
    0.00276385f, -0.11564844f, -0.04171948f, 0.00324412f, -0.07341037f, 0.03236801f, -0.16605642f, 0.10653712f, 
    0.19477648f, 0.05129881f, 0.03544547f, -0.18900855f, -0.06551890f, -0.14533305f, 0.26745737f, 0.48900688f, 
    -0.45649129f, -0.51958579f, 0.30264756f, 0.07833049f, -0.09402523f, 0.09222799f, 0.02470657f, -0.19023935f, 
    0.02321154f, 0.00081734f, -0.02088960f, 0.03123599f, -0.01405142f, -0.02433025f, -0.01585517f, 0.04569897f, 
    -0.02448291f, -0.02789905f, 0.02055481f, -0.04907333f, 0.03839603f, -0.00065434f, -0.04714522f, 0.00152759f, 
    -0.00167219f, 0.02884545f, 0.01396828f, -0.01723647f, -0.06713212f, 0.02269560f, 0.01279510f, -0.05786247f, 
    0.00633433f, -0.00968583f, 0.00281520f, -0.04462747f, 0.03971795f, -0.05605330f, -0.04962249f, 0.03456193f, 
    0.04612370f, -0.01718258f, 0.03112417f, -0.02460515f, -0.04202852f, -0.04681796f, -0.00401417f, 0.03647900f, 
    0.00191785f, 0.03857616f, 0.00287264f, 0.02826546f, 0.02860357f, 0.01327859f, 0.04672888f, -0.06640270f, 
    0.04707093f, -0.01736544f, -0.00671945f, -0.02874272f, -0.00531509f, -0.06021862f, -0.04209005f, 0.00864186f, 
    -0.04446601f, -0.05690389f, -0.06022403f, -0.03549960f, 0.01976500f, 0.02847046f, 0.01134856f, -0.02767688f, 
    -0.06381971f, -0.03313529f, 0.03045746f, -0.01832067f, -0.02361662f, 0.03056314f, 0.04896327f, 0.03095257f, 
    -0.01549052f, -0.05040911f, -0.04567983f, -0.00168784f, -0.03217139f, 0.00902719f, 0.05119308f, 0.01280361f, 
    -0.01917788f, 0.03886429f, 0.00292199f, -0.02087056f, 0.02954247f, 0.01278387f, 0.04589510f, 0.04492914f, 
    0.01651446f, -0.05161072f, -0.05602885f, -0.03135113f, -0.04967070f, 0.04541348f, -0.02232968f, 0.04138093f, 
    0.02853834f, -0.05412656f, 0.00881786f, -0.02378771f, -0.04582143f, -0.06435019f, -0.06001169f, -0.05692623f, 
    0.00511806f, -0.06119934f, -0.04158211f, -0.02121536f, 0.02906954f, 0.00401328f, -0.04535054f, -0.05004241f, 
    0.01287196f, -0.05851895f, -0.01005395f, -0.04045864f, 0.01385145f, 0.03548894f, 0.04218572f, -0.04989519f, 
    -0.06135196f, -0.05828370f, -0.02240337f, -0.00171060f, -0.03931417f, 0.01885405f, -0.03765481f, -0.05556223f, 
    -0.04937287f, 0.04219845f, 0.03172642f, 0.00660403f, 0.00656412f, -0.00617863f, -0.05858846f, -0.00847783f, 
    -0.01915802f, -0.04551764f, -0.06155954f, -0.03022292f, -0.01076619f, -0.04384571f, -0.01597862f, -0.05436577f, 
    -0.05283456f, 0.00189177f, 0.01780424f, 0.04357140f, 0.00487021f, -0.06386015f, -0.01240170f, 0.00971734f, 
    -0.05905510f, -0.03002240f, -0.06837730f, -0.04126386f, -0.00467387f, 0.02597681f, -0.04632863f, 0.05487764f, 
    0.04158044f, 0.04676582f, 0.03932251f, -0.01988713f, -0.02520569f, -0.04975357f, 0.00482897f, -0.03695510f, 
    0.04149057f, 0.01992665f, 0.00921809f, -0.04648330f, -0.03575175f, 0.02876381f, -0.00807306f, 0.04101775f, 
    0.01544810f, -0.04456267f, 0.00882200f, 0.00086784f, -0.00395020f, 0.01809395f, -0.03607279f, -0.04835399f, 
    0.01540487f, 0.04647523f, -0.02225529f, 0.00125624f, -0.01877883f, 0.04699862f, 0.02291468f, -0.02519908f, 
    -0.03817738f, -0.03232100f, -0.01155565f, 0.01253097f, -0.05752105f, -0.01689787f, -0.01879569f, -0.05377397f, 
    -0.03646835f, -0.05650965f, 0.02396345f, 0.02854102f, 0.02052758f, -0.00752055f, 0.04227863f, 0.04304525f, 
    -0.00607863f, -0.02087178f, 0.05827854f, -0.05405344f, -0.00698467f, 0.01287889f, -0.06272043f, 0.01426873f, 
    -0.03489197f, -0.03094748f, 0.01067307f, 0.04812784f, -0.01215609f, -0.04736213f, -0.02002726f, -0.03300697f, 
    -0.04929675f, -0.01276967f, 0.02976426f, -0.03308763f, 0.03589690f, 0.03297868f, 0.01982386f, -0.06353287f, 
    0.02127592f, 0.01346269f, 0.05194219f, 0.04468647f, -0.05907288f, 0.00912882f, 0.00866586f, -0.05247179f, 
    -0.00854247f, -0.05981792f, -0.04042458f, 0.02545309f, 0.02976191f, -0.00929125f, 0.04312303f, 0.03386494f, 
    -0.02966765f, 0.01646108f, -0.04451228f, -0.06412356f, 0.00651964f, 0.03065112f, -0.00310015f, -0.03202311f, 
    0.02351787f, 0.01191557f, -0.01082050f, -0.00421533f, 0.01939741f, 0.03242467f, 0.04006031f, -0.05548894f, 
    -0.05639696f, 0.00593890f, -0.03610194f, -0.02200826f, 0.03692653f, -0.05605968f, 0.01899465f, -0.06531757f, 
    -0.05131689f, -0.00359421f, 0.03371642f, 0.00476103f, 0.00344043f, 0.01368564f, 0.05780784f, -0.05116575f, 
    0.01483547f, -0.05681457f, 0.03604700f, 0.01589134f, 0.05918260f, 0.00114181f, -0.02103884f, 0.02988445f, 
    0.04996887f, 0.02152629f, -0.06237161f, -0.02254566f, 0.03099424f, -0.02736581f, 0.03228404f, 0.04714519f, 
    -0.06591635f, 0.03302186f, -0.03144723f, 0.02145417f, 0.04148353f, -0.04214748f, 0.02485312f, -0.06752985f, 
    -0.06068741f, -0.01154309f, 0.01040885f, -0.00422942f, -0.03400381f, -0.01103922f, 0.00901825f, -0.01156185f, 
    -0.06051708f, 0.04807468f, -0.03963004f, -0.01492137f, 0.03381386f, 0.03646692f, 0.02186080f, 0.02468041f, 
    0.04693861f, -0.01478285f, -0.02346357f, 0.03874174f, 0.00482635f, 0.01729896f, -0.04406086f, 0.01454354f, 
    -0.06584533f, -0.01576123f, -0.03633531f, -0.03245458f, -0.04742737f, -0.03848284f, -0.03083856f, 0.02328464f, 
    0.03507061f, 0.00437143f, 0.00887369f, -0.05691722f, -0.06592620f, 0.04755529f, 0.02661434f, -0.00974963f, 
    -0.02780286f, 0.00328307f, 0.04193173f, -0.05002790f, 0.02101551f, -0.06201077f, 0.00270309f, -0.00101888f, 
    0.04976005f, 0.00268787f, -0.00490165f, -0.04029536f, 0.02639209f, 0.05085607f, 0.00429915f, 0.01422390f, 
    -0.00856126f, -0.03739654f, 0.03275483f, -0.00211308f, -0.00525205f, -0.06501083f, -0.06156949f, -0.02712992f, 
    -0.02682989f, -0.02165406f, -0.06255933f, -0.00446770f, 0.01242218f, 0.04819516f, 0.01725676f, -0.00909477f, 
    0.02387221f, -0.02764747f, 0.02847105f, -0.02084021f, 0.05045534f, -0.03758059f, 0.00733401f, 0.02532523f, 
    -0.02592370f, 0.00099362f, -0.00167237f, -0.00547151f, 0.04212040f, 0.01766727f, -0.06261697f, -0.02699850f, 
    0.02188361f, -0.01943691f, -0.06034898f, 0.01837094f, -0.06718254f, 0.00139428f, 0.04585697f, -0.04021902f, 
    -0.00374298f, -0.05959384f, -0.00522885f, 0.01529436f, 0.02736152f, -0.04110831f, -0.00083794f, 0.03314580f, 
    -0.03451343f, 0.04517627f, 0.01136704f, -0.03397393f, 0.04750893f, 0.05199791f, 0.04882950f, -0.02351190f, 
    0.00505614f, -0.05251402f, -0.03318341f, -0.04679462f, 0.04644363f, -0.04951793f, 0.03367896f, -0.05887911f, 
    -0.05791178f, -0.03521893f, -0.01726213f, -0.05894379f, 0.03015136f, 0.03967685f, -0.03780931f, -0.05775835f, 
    -0.06110779f, 0.00506181f, -0.01001912f, 0.01329221f, -0.03534307f, 0.01934263f, -0.06131843f, -0.00543593f, 
    0.00820085f, -0.01121738f, 0.04001775f, 0.02666478f, 0.00790593f, 0.01092581f, -0.05007441f, -0.03231196f, 
    -0.06180791f, -0.04311344f, -0.02919396f, -0.06092968f, 0.02074878f, -0.00137812f, -0.03562738f, -0.02417497f, 
    0.01580271f, 0.04751839f, -0.02975224f, 0.00590754f, -0.00352285f, -0.01977150f, -0.02288532f, -0.00223456f, 
    -0.05088624f, 0.00645716f, -0.05189442f, -0.01265576f, 0.03776556f, -0.02531657f, 0.00250970f, -0.03167003f, 
    -0.04079068f, -0.02231646f, -0.06681831f, 0.03111093f, 0.02451070f, -0.02259052f, -0.00732979f, 0.04066413f, 
    0.04593686f, -0.03540403f, 0.00019867f, 0.02771166f, 0.04470626f, 0.03887346f, -0.02932528f, -0.03812263f, 
    0.04340961f, 0.03705413f, -0.05180560f, 0.03965898f, -0.06485176f, 0.00745540f, -0.00982101f, 0.04284342f, 
    -0.02293593f, -0.02334405f, 0.04469283f, 0.01681891f, 0.03697772f, -0.03551621f, -0.05536655f, -0.00681447f, 
    0.04818457f, 0.01763368f, 0.04707305f, -0.01639056f, 0.03238091f, 0.01998757f, 0.00448952f, -0.05371786f, 
    -0.04725798f, -0.00762076f, -0.02133475f, -0.04367362f, -0.06520846f, -0.04092306f, -0.05213381f, 0.01418294f, 
    0.03952914f, 0.03087904f, 0.01428863f, -0.00042421f, -0.04636730f, 0.00990003f, -0.04803504f, -0.06622442f, 
    -0.04178388f, -0.00895286f, -0.04807198f, -0.03695148f, -0.06483579f, -0.00344384f, -0.05897585f, -0.03772318f, 
    -0.00001357f, -0.02699045f, 0.02519882f, -0.03907176f, -0.00170045f, 0.01757474f, 0.01465282f, 0.02541047f, 
    0.02308344f, -0.01185927f, -0.03424578f, 0.00190971f, -0.06560598f, 0.00958458f, -0.04801360f, 0.02433069f, 
    -0.03245993f, 0.00826906f, -0.02688200f, -0.02850719f, -0.04912658f, -0.03343587f, -0.03626024f, 0.04557644f, 
    -0.01474815f, -0.01296448f, 0.02267768f, 0.01124176f, -0.00407203f, -0.05075385f, -0.05681179f, -0.03146823f, 
    0.01959610f, -0.01304826f, 0.04081006f, 0.01440033f, -0.01092306f, 0.00966037f, 0.04686675f, -0.03739384f, 
    -0.30460441f, -0.56604838f, -0.05565177f, -0.05643924f, 0.12328982f, 0.07152630f, 0.23966558f, -0.02717167f, 
    -0.08986751f, -0.83596140f, -0.03815733f, 0.38041016f, -0.08858497f, -0.04792850f, 0.01471954f, 0.05100152f, 
    0.03869998f, 0.03163796f, 0.36361635f, -0.02431315f, -0.06548993f, 0.03474003f, -0.07086546f, -0.01114396f, 
    -0.01775821f, 0.20094705f, -0.08678378f, 0.43699574f, 0.35477933f, 0.10787528f, 0.00302894f, 0.03519583f, 
    0.01173220f, 0.04569366f, 0.01529302f, -0.06791462f, 0.19798939f, -0.06822571f, 0.02900283f, -0.04331825f, 
    0.00280912f, -0.05345974f, 0.02065156f, 0.04752780f, 0.02892296f, -0.58720773f, 0.10156162f, 0.04657016f, 
    -0.03786011f, 0.11856764f, -0.27682236f, 0.04086208f, -0.03315663f, 0.00719529f, 0.20885044f, -0.27195349f, 
    -0.21272843f, 0.02765881f, -0.06849221f, 0.06650681f, -0.05436449f, 0.03660683f, 0.20879318f, -0.08565354f, 
    -0.01299151f, 0.25358394f, 0.02024370f, 0.11148154f, -0.33420116f, 0.04997968f, 0.25713229f, -0.00482062f, 
    -0.05303643f, 0.07148054f, -0.08369040f, -0.18331774f, 0.05027233f, 0.00500698f, -0.03833420f, 0.09696437f, 
    -0.18692140f, 0.08664344f, 0.04073865f, -0.01541266f, -0.11215363f, 0.15315846f, 0.03303864f, 0.04852508f, 
    0.16194199f, -0.12818113f, -0.12857161f, -0.01408548f, -0.27201396f, 0.06717958f, -0.40021345f, 0.10227971f, 
    0.08932247f, 0.07048148f, -0.03185257f, -0.10008962f, -0.02280857f, 0.21290915f, -0.06239324f, 0.06134705f, 
    -0.16044074f, -0.16495447f, -0.16430387f, 0.17327060f, 0.00383841f, 0.42127949f, 0.29173398f, -0.11412313f, 
    -0.00159886f, -0.13922770f, 0.03466195f, 0.00159791f, -0.19395779f, 0.07450478f, 0.02642609f, -0.10233865f, 
    -0.30077794f, -0.01828881f, -0.27201504f, -0.13444401f, -0.09534805f, 0.36697328f, -0.04329736f, 0.21702339f, 
    -0.16499682f, 0.04656463f, -0.01969041f, -0.15795542f, 0.12968111f, -0.05793673f, 0.08251651f, -0.81359202f, 
    -0.17347498f, -0.42015073f, -0.02647678f, -0.05289999f, 0.06507449f, 0.13860533f, 0.06039700f, -0.12360293f, 
    0.08097546f, -0.03572775f, 0.28229493f, 0.00303268f, 0.07579349f, 0.08542789f, -0.08807103f, 0.06600217f, 
    0.06040058f, 0.20332728f, 0.27798256f, 0.46510744f, -0.03721644f, -0.04844321f, 0.24436572f, 0.09126369f, 
    0.19848037f, 0.05114784f, -0.22841188f, -0.11850370f, -0.18949537f, 0.01306017f, 0.09199286f, -0.04443586f, 
    0.05080115f, -0.13219276f, 0.23353943f, -0.03139959f, 0.13823919f, 0.14235315f, -0.15281424f, -0.07021695f, 
    0.03583482f, -0.13228087f, 0.18886241f, 0.14222266f, 0.12159952f, -0.25679761f, -0.22370645f, 0.15349385f, 
    0.02375271f, -0.06876276f, 0.00353105f, 0.09559913f, 0.04980049f, 0.20445625f, 0.34978488f, 0.17486812f, 
    -0.27124038f, 0.12365475f, 0.03461444f, 0.06451937f, -0.07093924f, 0.27384499f, -0.23642787f, -0.13644785f, 
    0.16496147f, -0.01840722f, 0.03531912f, -0.04973930f, -0.05491148f, 0.09657024f, 0.10953604f, -0.23314372f, 
    0.07760829f, -0.03233235f, -0.03276666f, -0.00201357f, -0.07313350f, -0.00307830f, 0.04214647f, -0.04996636f, 
    -0.37474039f, -0.51045519f, 0.39861614f, -0.06565637f, 0.00433658f, -0.10815559f, 0.05128486f, 0.06242791f, 
    0.18373717f, 0.19035572f, -0.27969429f, -0.43628126f, -0.03491462f, -0.05721907f, 0.07117319f, -0.05240358f, 
    0.05368419f, 0.26152271f, 0.03964467f, -0.14415522f, -0.18782608f, 0.04648759f, -0.23297457f, 0.35554749f, 
    -0.01096930f, 0.05981256f, 0.14930601f, 0.34455854f, 0.15501338f, -0.18268234f, -0.00481030f, 0.02420892f, 
    0.01425955f, 0.04508058f, -0.14602028f, -0.17099655f, 0.17311005f, -0.09793006f, 0.05949438f, 0.03711061f, 
    -0.00602470f, 0.00918364f, -0.08892996f, 0.11100291f, 0.00605598f, 0.04472474f, 0.06504995f, -0.04948919f, 
    -0.20432310f, -0.06379265f, -0.17507444f, -0.05248555f, -0.20698734f, 0.17016760f, -0.07287849f, -0.00436609f, 
    -0.14449297f, -0.16102709f, -0.17403319f, -0.10666646f, 0.04815266f, 0.17968863f, 0.01153199f, -0.30118331f, 
    0.18680112f, 0.22852419f, -0.10492007f, 0.29072481f, -0.15853681f, 0.13559417f, -0.06186710f, -0.02508490f, 
    0.01921931f, -0.02474745f, 0.01222480f, -0.05910001f, 0.02336846f, -0.03237624f, -0.04367733f, -0.02273272f, 
    0.04228495f, -0.02306658f, -0.04666954f, -0.01521806f, -0.03606109f, -0.05830105f, -0.00393392f, -0.00860688f, 
    0.00408179f, 0.00364147f, 0.02523235f, -0.00299791f, -0.01266017f, -0.01504327f, 0.04285835f, 0.04513699f, 
    -0.00953155f, -0.03464736f, 0.02599282f, 0.00097570f, -0.06071174f, -0.04602440f, -0.00847268f, 0.04422894f, 
    0.04434391f, 0.02891508f, -0.05632716f, -0.01409356f, 0.01584380f, -0.02339865f, 0.03325483f, -0.00480955f, 
    -0.03831550f, 0.04129476f, -0.06412184f, 0.02583476f, -0.03978801f, 0.04771519f, 0.04432625f, 0.05359166f, 
    -0.01493599f, -0.01791823f, -0.02307374f, -0.01570597f, 0.03967361f, 0.03453921f, -0.04652531f, -0.02664296f, 
    -0.04445676f, 0.00735633f, 0.03692038f, -0.05983392f, -0.04187884f, -0.03952201f, 0.04697695f, 0.02273990f, 
    -0.01181412f, -0.04302992f, 0.04776108f, -0.02477503f, -0.00375247f, -0.00365170f, 0.00893482f, -0.04952555f, 
    0.03662790f, -0.05712888f, 0.01638464f, -0.01172361f, 0.01468045f, 0.03794831f, -0.00367233f, -0.03847677f, 
    -0.01035916f, 0.02807987f, -0.05682940f, -0.03353653f, -0.04855500f, -0.01910867f, -0.01751331f, -0.01135342f, 
    0.01701368f, -0.03475764f, -0.00100361f, 0.03672611f, -0.02617251f, -0.05909881f, -0.04211600f, 0.01876738f, 
    0.01714898f, 0.01620415f, 0.01500787f, -0.02604551f, -0.01376761f, -0.03586698f, 0.01993193f, 0.04085152f, 
    -0.02647175f, -0.02119998f, 0.03028540f, 0.02573348f, 0.02537493f, 0.02603203f, 0.03691392f, 0.02663929f, 
    0.03457043f, -0.00045081f, -0.04475906f, 0.01106773f, 0.00739215f, 0.03917284f, -0.04658761f, -0.04510050f, 
    0.00589566f, -0.04515702f, 0.02323712f, -0.05970667f, 0.05449193f, -0.03432953f, -0.06335904f, -0.01227353f, 
    0.03351323f, 0.01433024f, 0.03206954f, 0.00412625f, -0.02834847f, 0.01928519f, -0.02108251f, 0.04460973f, 
    0.02180823f, -0.03143846f, -0.02043866f, 0.02728258f, -0.01774256f, 0.02662654f, -0.02300936f, -0.03952906f, 
    0.02480898f, -0.01460297f, -0.02363832f, 0.02155112f, 0.01784037f, -0.05845549f, -0.02505674f, 0.04069817f, 
    -0.04403748f, 0.03784483f, -0.01478051f, 0.02665571f, -0.06267660f, 0.01118548f, -0.00713473f, -0.00097522f, 
    -0.06068855f, -0.06399089f, 0.00587946f, -0.00401395f, -0.01372329f, 0.00400669f, -0.03049414f, 0.01895749f, 
    0.04148421f, -0.04746787f, 0.04429901f, 0.00882125f, -0.03077324f, 0.04917053f, -0.03730222f, -0.00015921f, 
    -0.02775425f, -0.01187404f, -0.03823278f, -0.04565055f, -0.03929653f, 0.00503347f, 0.04590396f, -0.05211265f, 
    0.04786600f, -0.01816216f, -0.00996939f, 0.02643703f, -0.05518228f, -0.02140573f, 0.01254828f, -0.03075913f, 
    0.02035336f, 0.00041528f, -0.01474239f, 0.03557213f, -0.01428309f, 0.02007258f, -0.01412352f, -0.03641183f, 
    -0.03908546f, -0.06670555f, 0.05017321f, 0.03988254f, -0.01986855f, 0.02109280f, 0.01082839f, 0.02041807f, 
    -0.06237547f, 0.05243229f, 0.01136645f, -0.00762243f, -0.04965001f, -0.01600906f, -0.04431307f, 0.05403212f, 
    0.05422583f, -0.05749341f, 0.02593671f, -0.03126207f, 0.02799483f, -0.05926383f, 0.00224446f, -0.01858246f, 
    -0.04156535f, -0.02209678f, -0.03400320f, -0.01603608f, -0.06758519f, 0.00673721f, -0.01672338f, -0.03878598f, 
    -0.00367921f, 0.02117684f, 0.00535722f, 0.00348624f, -0.06195166f, 0.00613657f, 0.03950024f, 0.03268599f, 
    -0.05473426f, -0.05214251f, 0.03567757f, 0.00796429f, -0.01727090f, 0.00025521f, -0.05113900f, 0.03567171f, 
    0.01970249f, 0.05024651f, 0.01438822f, 0.04357531f, -0.04134632f, -0.01108234f, -0.04986200f, -0.01926981f, 
    0.04997803f, -0.01594300f, 0.01329671f, -0.04467589f, -0.03269385f, 0.02940543f, -0.01703045f, -0.00013083f, 
    -0.00765765f, 0.01800076f, 0.03595499f, -0.05976252f, -0.04217552f, 0.01830235f, 0.01549993f, -0.00909303f, 
    -0.02491340f, -0.06051131f, -0.06289480f, 0.03016501f, -0.04523704f, 0.02131829f, 0.05020885f, -0.05851851f, 
    0.00733893f, 0.03334708f, -0.04126057f, -0.06336068f, 0.00328484f, 0.02277018f, -0.04264518f, 0.05069492f, 
    -1.14727533f, -0.80952054f, -0.25012454f, -0.05959980f, 0.08578037f, 0.13679931f, -0.03786775f, -0.24729227f, 
    -0.01936547f, 0.05518719f, -0.12263963f, 0.32438836f, -0.21203274f, 0.01643965f, -0.09861168f, -0.03280577f, 
    -0.18928316f, 0.01828141f, 0.89398563f, -0.11667533f, -1.62749517f, -0.10280757f, -0.07583693f, -0.12247914f, 
    -0.08203933f, 0.09858485f, -0.20265190f, 0.00015650f, 0.12907213f, 0.22451557f, -0.00534769f, 0.20046161f, 
    0.10010849f, 0.09008234f, -0.02543061f, 0.08642187f, -0.32986382f, -0.51142687f, -0.00214322f, -0.02264246f, 
    0.01804771f, -0.07727968f, -0.31571296f, 0.43577445f, 0.05840211f, -1.05422533f, -0.46972352f, 0.43157345f, 
    0.31813914f, 0.02305167f, 0.06685515f, 0.05565077f, 0.01058449f, 0.07577655f, 0.57588542f, -0.21596254f, 
    -0.64409631f, -0.06925342f, -0.00664294f, -0.02859135f, 0.07887013f, 0.25862807f, 0.03894066f, 0.04288690f, 
    0.12681063f, 0.39614975f, 0.16838124f, 0.04610259f, -0.11444506f, 0.14844573f, -0.23530990f, 0.27414364f, 
    0.23199591f, 0.11948626f, -0.08739703f, -0.20228182f, 0.01410097f, 0.00606517f, 0.04962949f, -0.11341351f, 
    -0.02547626f, 0.12001155f, 0.13335375f, 0.06844448f, 0.03199524f, -0.07988299f, -0.04598406f, 0.16876152f, 
    -0.11862373f, 0.10651039f, 0.18381713f, 0.24642013f, -0.66631913f, -0.20652969f, -0.23619068f, -0.23414783f, 
    0.18573180f, -0.08769315f, -0.09325735f, 0.20297317f, 0.00707745f, 0.07717437f, -0.01221393f, 0.08133864f, 
    0.00106169f, -0.08114814f, 0.42075726f, 0.01226767f, 0.08942227f, 0.12600121f, 0.10881077f, -0.00514749f, 
    0.10282557f, -0.08514725f, 0.12739819f, -0.26254848f, 0.17960362f, 0.14486834f, 0.00845736f, 0.14700271f, 
    -0.17901164f, 0.04588627f, -0.19988635f, -0.19670397f, -0.36614361f, 0.27994311f, 0.40967676f, 0.17546028f, 
    -0.16272739f, -0.23248860f, -0.11354174f, -0.39535853f, 0.04180600f, -0.05085208f, 0.10310593f, -0.76593262f, 
    -0.27611312f, -0.15590674f, 0.00185796f, 0.10719934f, -0.17716551f, -0.16522725f, -0.17681357f, 0.06140335f, 
    0.23819678f, 0.17592841f, 0.16733760f, 0.12931460f, 0.02291652f, 0.03104497f, 0.15891767f, 0.02835964f, 
    0.24953319f, 0.18198197f, -0.08706607f, 0.16083190f, -0.05174143f, -0.20124812f, 0.34079450f, -0.18269715f, 
    0.11274010f, 0.12820272f, -0.25808963f, -0.36262682f, -0.23458688f, -0.02237566f, 0.05984224f, -0.04089499f, 
    0.07453119f, -0.00646130f, 0.15351531f, -0.03183675f, 0.12839119f, 0.21241999f, -0.02221565f, -0.03629503f, 
    0.07924449f, 0.27304125f, 0.21450177f, -0.07134499f, 1.15449369f, 0.47733629f, -0.67787760f, -0.19031473f, 
    0.03756960f, -0.15493359f, 0.08445248f, 0.04557788f, -0.10048014f, 0.15833752f, 0.21222509f, 0.08865475f, 
    -0.06474124f, -0.11276211f, -0.08251512f, 0.11857119f, 0.09638896f, 0.15547170f, -0.04290880f, -0.13450561f, 
    0.06185157f, 0.01530987f, 0.05748649f, 0.09468517f, -0.03843537f, 0.25895438f, 0.20429580f, 0.23455231f, 
    0.30157167f, -0.25582832f, -0.08849239f, -0.12997830f, -0.02643397f, 0.15149917f, 0.00071973f, -0.00079035f, 
    -0.19472037f, -0.48709092f, -0.39739406f, -0.11238616f, -0.01083221f, -0.17126471f, 0.05607230f, 0.03148942f, 
    0.02504583f, -0.04633874f, -0.55921698f, -0.39812830f, -0.10838771f, -0.06113014f, 0.05963570f, -0.07175913f, 
    0.20952660f, 0.11304176f, 0.26136437f, -0.30770069f, -0.35738331f, -0.13156715f, -0.07189872f, 0.21071379f, 
    -0.04106175f, 0.07566747f, 0.13995978f, -0.07105424f, -0.19136849f, 0.22014605f, 0.05271624f, 0.13531192f, 
    0.14005299f, 0.09025224f, -0.05674354f, 0.03233220f, 0.24668539f, -0.00022790f, -0.01147072f, 0.08642934f, 
    -0.20638566f, 0.00069558f, 0.13946559f, -0.04548045f, 0.06036126f, 0.14570408f, 0.01117896f, 0.04119757f, 
    0.02446469f, 0.08524071f, -0.08858363f, -0.15521021f, -0.03323767f, 0.18039995f, 0.03212497f, 0.06699621f, 
    -0.12056271f, -0.12078571f, -0.05514368f, -0.10334454f, 0.13197285f, -0.14277606f, -0.14677818f, 0.09246112f, 
    0.04035810f, -0.43406817f, -0.23668753f, -0.20713821f, -0.13478756f, -0.26984772f, 0.07314493f, -0.05653020f, 
    -0.25423247f, -0.52619159f, -0.89653951f, 0.05876676f, -0.02435309f, 0.03040560f, 0.21032909f, -0.29750824f, 
    0.13628612f, -0.08454125f, -0.25902951f, -0.56108665f, -0.01641103f, 0.06245449f, -0.12267148f, 0.07438090f, 
    0.02329253f, -0.06524009f, -0.39502847f, -0.12809725f, -0.11641503f, -0.33421049f, 0.04238794f, -0.17054811f, 
    0.05412362f, 0.02518807f, -0.04828994f, 0.07038195f, -0.80067211f, -0.24590553f, -0.14701234f, -0.09008695f, 
    0.00304142f, -0.00357597f, 0.04690759f, -0.17074943f, 0.04451692f, -0.24483602f, -0.38729593f, -0.11373971f, 
    0.13876677f, 0.28410184f, 0.12165116f, 0.06578408f, 0.17573939f, -0.48332775f, -0.55477816f, -0.15978371f, 
    -0.00534812f, 0.16797806f, 0.07640689f, 0.08194829f, 0.04664370f, 0.12601557f, 0.26534250f, 0.10977332f, 
    0.25346887f, 0.01980911f, 0.01111395f, 0.19706957f, 0.10243034f, 0.20483427f, 0.04937544f, -0.17835246f, 
    0.03978572f, 0.46290100f, 0.18540476f, 0.05870610f, 0.01065578f, 0.20716919f, -0.03719166f, 0.22459050f, 
    -0.05504071f, -0.35171545f, -0.06658278f, -0.00366566f, 0.04566041f, 0.09138243f, 0.02677413f, 0.10188201f, 
    -0.03121866f, 0.17320277f, -0.07676118f, 0.11355644f, -0.00085293f, 0.00732369f, 0.22480972f, 0.01093937f, 
    0.13322012f, 0.10812080f, -0.55340141f, -0.17714514f, -0.03885359f, 0.15645471f, 0.07417763f, 0.23216559f, 
    0.14963208f, 0.01762699f, 0.05112367f, 0.26004353f, 0.12066149f, -0.13990667f, 0.00523665f, 0.18717319f, 
    -0.04473804f, 0.04062534f, 0.07202824f, 0.04461441f, -0.62204736f, 0.03465115f, -0.12168534f, -0.08863359f, 
    -0.01668319f, -0.20222186f, 0.06372321f, 0.02138946f, 0.23962192f, -0.25181177f, -0.07844849f, 0.09779178f, 
    -0.15279484f, -0.06972435f, -0.12510616f, -0.02185570f, -0.29824179f, 0.09476791f, -0.17734665f, -0.05888534f, 
    0.17404802f, 0.08567365f, -0.02264872f, 0.09396593f, 0.24793439f, 0.12921591f, 0.25165075f, -0.35071546f, 
    -0.32230550f, -0.40943068f, 0.17682782f, 0.17669252f, -0.10441417f, 0.01097222f, 0.01469009f, -0.02467832f, 
    0.31958869f, 0.30353692f, 0.04021995f, 0.12205202f, 0.11387135f, -0.09104596f, 0.06417400f, 0.13737458f, 
    0.20203973f, -0.08866380f, -0.29011261f, 0.13277528f, 0.18325552f, 0.23074588f, 0.11924921f, 0.05795451f, 
    -0.01410185f, 0.24848856f, 0.14398560f, -0.37195253f, -0.34449741f, -0.12464475f, -0.04291041f, -0.12606145f, 
    -0.12369414f, 0.01923286f, -0.07797099f, -0.15283151f, 0.02124641f, 0.00306076f, 0.03833256f, -0.11462448f, 
    -0.34486255f, 0.11912940f, -0.09740220f, 0.03741901f, -0.53502733f, 0.49718657f, 0.59332323f, 0.11789063f, 
    -0.02475664f, -0.01355891f, -0.09978414f, -0.01412854f, 0.01358866f, -0.17787714f, 0.04594545f, 0.07264916f, 
    0.14717250f, 0.05070682f, 0.23389032f, 0.13895734f, 0.10679492f, 0.26398399f, 0.14633837f, 0.08328201f, 
    -0.35563418f, 0.13589463f, 0.12390635f, -0.09731207f, 0.25229502f, 0.19682838f, 0.32424438f, -0.56819862f, 
    0.03209148f, 0.11830911f, -0.17837703f, 0.01016991f, 0.02841059f, -0.02250067f, -0.11736988f, 0.07710424f, 
    0.10877854f, -0.22297256f, -0.30434307f, 0.11809237f, -0.05158141f, 0.13264142f, 0.08326072f, 0.08216944f, 
    -0.03851428f, 0.09447248f, -0.05425798f, 0.28788662f, 0.09922646f, -0.01006087f, 0.09861138f, 0.10846333f, 
    -0.03495259f, 0.01835614f, -0.30413973f, 0.07807955f, 0.21086945f, -0.17573951f, -0.05880091f, 0.01835171f, 
    0.15010220f, 0.05382558f, -0.07341959f, 0.56269789f, -0.79002661f, -0.51394868f, -0.04414109f, -0.10909177f, 
    -0.08981270f, 0.11897060f, 0.15562028f, 0.05479300f, 0.29828089f, 0.09986236f, 0.13556461f, 0.11046964f, 
    -0.09763277f, 0.09043970f, 0.07566217f, 0.08303393f, 0.13621163f, -0.10066134f, 0.16178420f, 0.07739751f, 
    0.04806558f, -0.00637762f, -0.12510988f, 0.12186901f, -0.12996456f, 0.35882056f, -0.21840256f, -0.04081606f, 
    -0.05722653f, -0.31878453f, -0.05350376f, -0.18443671f, 0.16029808f, -0.26487294f, -0.19040447f, -0.00955497f, 
    -0.33960092f, -0.51200271f, -0.10470188f, -0.18452406f, -0.10080867f, -0.12271404f, -0.18527125f, 0.03736534f, 
    0.03557998f, -0.02851478f, -0.00693605f, -0.02170661f, 0.03258318f, -0.03486226f, -0.00210938f, -0.03429150f, 
    -0.05579261f, 0.00055239f, 0.00518725f, -0.00209875f, -0.06471620f, -0.05832121f, -0.06453395f, -0.01633597f, 
    -0.04314385f, -0.00642392f, 0.02739869f, -0.05264999f, -0.00850455f, 0.03544701f, 0.04151357f, -0.06284922f, 
    0.04461299f, 0.02274299f, -0.05551095f, 0.04072500f, -0.05038028f, 0.01327155f, -0.01265131f, -0.03777212f, 
    0.02075833f, -0.00938408f, -0.01608092f, -0.02250127f, 0.02456007f, -0.01091196f, 0.04194000f, 0.01451185f, 
    0.02557279f, -0.00778299f, 0.04301327f, -0.00514054f, -0.05628932f, -0.03285073f, -0.04032291f, -0.02842481f, 
    0.03823102f, -0.01509427f, -0.01773898f, 0.00816486f, -0.04390171f, -0.02384717f, -0.02684438f, -0.06422121f, 
    -0.02221046f, -0.01363694f, -0.04509016f, -0.05625963f, -0.00921861f, 0.00654550f, 0.02890636f, 0.02179489f, 
    -0.04822080f, -0.01799341f, -0.07079247f, 0.02631111f, -0.06901909f, 0.00130996f, -0.04319087f, -0.01600932f, 
    -0.04911213f, -0.04433770f, 0.02505745f, -0.05284202f, -0.01744499f, 0.00951616f, 0.00331319f, -0.01526874f, 
    -0.00512155f, -0.00928201f, -0.03271714f, 0.02554037f, -0.04276282f, -0.03149276f, -0.05821886f, -0.06739034f, 
    -0.00246672f, 0.00134205f, 0.02964449f, 0.00766620f, 0.03034835f, 0.02726476f, 0.01079064f, -0.05784475f, 
    0.03401266f, -0.06202633f, 0.00890406f, -0.02792162f, 0.03733426f, -0.04877816f, 0.02686699f, 0.04447421f, 
    -0.02105467f, -0.03378759f, -0.00107877f, 0.01506866f, -0.04542020f, -0.05157564f, 0.03050145f, -0.03158789f, 
    -0.04635830f, -0.03071679f, -0.03723606f, -0.04272045f, 0.01130216f, -0.02943541f, 0.03178472f, 0.04522197f, 
    -0.01687931f, -0.05589984f, 0.02787648f, -0.02321867f, -0.03635759f, -0.02755000f, 0.00200259f, 0.03741872f, 
    0.04086548f, -0.00612273f, 0.04075797f, -0.05048680f, 0.04553025f, 0.03915538f, 0.00191754f, 0.03553683f, 
    0.03605668f, 0.03908484f, -0.05269343f, -0.03336722f, -0.00833976f, -0.00716597f, 0.01263340f, 0.02030153f, 
    -0.00752013f, -0.05006145f, -0.03676645f, -0.01800124f, -0.01314954f, -0.03282092f, -0.04100388f, 0.03896022f, 
    -0.01680294f, 0.01876988f, 0.00988637f, -0.05750655f, -0.06845911f, 0.00629709f, -0.04563535f, 0.03774748f, 
    -0.00622431f, -0.01468916f, -0.03795232f, 0.00048774f, -0.04446080f, -0.03611527f, -0.01213999f, 0.04845108f, 
    0.03108320f, -0.04429552f, -0.00646669f, -0.04335527f, -0.04538786f, -0.01464754f, -0.00898689f, -0.06582575f, 
    -0.06395884f, 0.03692814f, -0.03102162f, -0.05374404f, -0.04028339f, 0.03880819f, 0.02154055f, -0.04923756f, 
    -0.01375575f, -0.02711120f, -0.00328032f, -0.06365225f, -0.06670144f, 0.00588673f, 0.03918447f, -0.06632444f, 
    0.01506641f, 0.04379978f, -0.05271360f, -0.00491253f, -0.02044566f, -0.05489485f, 0.02969726f, 0.02728386f, 
    -0.00702839f, 0.01015230f, -0.05585122f, -0.04051787f, 0.01512686f, 0.04254147f, -0.00687857f, -0.05667439f, 
    -0.01722590f, 0.04674375f, -0.05230269f, 0.03373090f, 0.02301906f, -0.03159265f, -0.01324812f, -0.00189724f, 
    0.02490024f, 0.02210373f, 0.03204685f, -0.01041491f, -0.01543128f, 0.03064601f, 0.02786305f, 0.03452815f, 
    -0.02076599f, -0.02536943f, -0.01728931f, 0.04137325f, -0.02297005f, 0.03354014f, -0.06213325f, -0.00139948f, 
    -0.04267053f, 0.00700832f, -0.00829562f, -0.00686352f, -0.05864142f, -0.01628409f, 0.02083258f, 0.01430515f, 
    0.03667096f, -0.05193210f, -0.04245889f, -0.06694152f, -0.03521964f, -0.02446302f, -0.01982198f, -0.04138479f, 
    -0.01122278f, -0.04260061f, -0.05969134f, 0.01855379f, 0.04440907f, -0.04454766f, -0.04518488f, -0.02093060f, 
    0.02573602f, -0.06005137f, 0.04750197f, -0.05626192f, -0.01019475f, 0.00978766f, 0.02389114f, -0.05491903f, 
    -0.04515875f, 0.01915403f, 0.03653831f, -0.00839884f, 0.02789192f, 0.00085058f, 0.02247065f, -0.03254193f, 
    0.05692225f, 0.03462534f, -0.01645136f, -0.05094932f, -0.00873202f, -0.05324529f, -0.03792361f, -0.05760024f, 
    -0.01835227f, 0.02450409f, 0.00638667f, -0.01760511f, -0.02332222f, -0.02813082f, -0.02514030f, -0.03206620f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04553604f, 0.06865261f, -0.02738023f, 0.05913611f, 0.26369429f, 0.16394506f, 0.23346525f, -0.01871974f, 
    -0.03771273f, -0.04590257f, -0.05890941f, 0.04883835f, 0.10985837f, 0.33214128f, 0.00972265f, -0.16092801f, 
    0.11135801f, 0.08664812f, 0.01041977f, 0.32054272f, 0.02152698f, 0.01027738f, 0.05739571f, 0.17164664f, 
    0.09066506f, 0.02251952f, -0.06316461f, 0.07042264f, -0.03555570f, 0.19997589f, 0.36499086f, 0.03730119f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15613723f, 0.06667667f, -0.13760364f, -0.09485948f, -0.03742905f, -0.16886166f, -0.50968206f, 0.10002062f, 
    0.52505952f, -0.11024629f, 0.02726238f, 0.58047295f, -0.36553803f, -1.18875241f, 0.10150946f, 0.14964484f, 
    0.12603028f, -0.09046494f, 0.00860105f, -0.05035381f, -0.09733088f, -0.29096556f, 0.23266724f, 0.46942854f, 
    0.22016640f, 0.09305536f, 0.11211263f, 0.14548627f, 0.02675358f, 0.22044180f, -0.16199447f, -0.06911560f, 
    0.06949408f, -0.02853225f, 0.08863082f, 0.24964158f, 0.24464162f, 0.32377556f, 0.06887395f, 0.04354663f, 
    -0.96098965f, 0.12577252f, -0.14117759f, 0.39002118f, -0.48900181f, -0.37753350f, -0.08057822f, -0.05810793f, 
    0.60812932f, -0.05424923f, 0.13999836f, -0.16088124f, 0.09491827f, -0.42105845f, 0.07057098f, 0.26307732f, 
    -0.19870323f, -0.05229726f, -0.02129069f, 0.01312158f, 0.06995112f, 0.20794271f, 0.37512216f, 0.09944601f, 
    0.03811063f, -0.48387912f, -0.11352411f, 0.12175519f, -0.20074511f, 0.01941611f, -0.13071102f, -0.07989684f, 
    -0.50656372f, 0.01917380f, 0.05449377f, -1.01445210f, 0.57018763f, 0.62026995f, -0.11012957f, -0.15157619f, 
    0.26392305f, -0.06205065f, 0.00578240f, -0.00060742f, -0.05037936f, 0.27035806f, -0.48539314f, 0.29334012f, 
    -0.69502699f, -0.01788926f, 0.09083899f, -0.78207481f, -0.13838944f, -0.27176556f, 0.13218078f, -0.11087076f, 
    0.00637021f, -0.19181806f, -0.03231628f, -0.27739266f, -0.55082142f, 0.05240425f, 0.54266459f, -0.15191486f, 
    -0.23345378f, 0.10286700f, 0.10724334f, -0.28134355f, -0.20060956f, -0.00007940f, 0.16698356f, 0.90495032f, 
    -0.08832745f, -0.61852169f, -0.11997911f, -0.17578411f, 0.12353665f, 0.37367347f, -0.22940207f, 0.05136711f, 
    0.28507972f, 0.13890636f, -0.09676365f, -0.35922623f, 0.04015864f, -0.04323384f, -1.05329394f, -0.08802375f, 
    0.02307024f, -0.06468431f, -0.05937059f, 0.49618298f, -0.08047601f, 0.30893326f, -0.43898797f, 0.01947279f, 
    0.58928603f, -0.13692521f, -0.06248644f, -0.04493436f, -0.03222098f, 0.23190159f, -0.04766012f, 0.03961990f, 
    -0.27089378f, 0.01310424f, 0.15599909f, 0.13190778f, -0.14226882f, 0.03660300f, -0.09879130f, -0.43854120f, 
    -0.53094888f, 0.11354508f, 0.05560968f, -0.00911405f, -0.12501588f, -0.00674809f, -0.75541270f, -0.11942210f, 
    -0.13843091f, 0.31020403f, -0.06328106f, -0.16889787f, 0.42203909f, -0.55163413f, -0.20238590f, 0.16059271f, 
    -0.06607582f, 0.11293979f, 0.16384457f, 0.03089793f, 0.36367396f, 0.49432278f, -0.14813469f, -0.31176078f, 
    0.38867062f, 0.06280929f, -0.06027723f, -0.13589679f, -0.01990142f, -0.07721464f, 0.39915514f, -0.24672790f, 
    0.52624261f, -0.06946678f, -0.08776861f, 0.03739648f, 0.13005652f, -0.19651160f, -0.39663798f, 0.06329245f, 
    0.07941387f, -0.41393554f, -0.03127139f, -1.00631595f, -0.61597139f, -0.14639136f, -0.35569647f, -0.03343706f, 
    -0.68898439f, -0.07092164f, 0.17899707f, 0.14343040f, 0.43241650f, 0.25358161f, -0.16858096f, -0.33796293f, 
    -0.71868646f, -0.06591567f, 0.07334222f, 0.23153144f, -0.02711458f, 0.09767111f, -0.35240451f, -0.39509884f, 
    -0.53874093f, 0.14432259f, -0.09773092f, 0.36508816f, 0.03245536f, 0.20420314f, 0.83607453f, 0.09503970f, 
    0.03224412f, 0.06692319f, -0.07858476f, -0.20465934f, 0.15619676f, 0.19451079f, -0.49721897f, 0.10217932f, 
    -0.05534702f, 0.16631532f, 0.01418417f, -0.09367943f, 0.23490283f, 0.06198651f, 0.05497130f, 0.16705775f, 
    -0.12736905f, -0.06982676f, -0.02305420f, -0.61219984f, -0.10376044f, -0.12091568f, -0.03529600f, -0.31246060f, 
    0.64475662f, 0.04685604f, -0.07058561f, 0.38231176f, -0.15141447f, 0.49530387f, -0.45676666f, 0.08034700f, 
    0.02009081f, 0.18818355f, 0.08264355f, -0.31283000f, 0.28406850f, 0.33592668f, 0.49759987f, -0.16550831f, 
    -0.54291660f, 0.08372759f, 0.11657757f, -0.59330088f, 0.04104039f, -0.08566186f, -0.10091902f, -0.31951472f, 
    -0.73030829f, -0.56540692f, -0.04464645f, -0.28461862f, -0.00232005f, -0.01953567f, 0.23677550f, 0.03088145f, 
    1.02774453f, 0.08407328f, 0.05641113f, -0.34916240f, 0.05737361f, -0.54130185f, 0.30407310f, 0.00351384f, 
    0.02776737f, -0.65604222f, -0.00761241f, 0.31186590f, 0.09248070f, 0.32960510f, 0.06508563f, -0.17977953f, 
    -0.54717737f, -0.10684566f, -0.11779959f, 0.43296784f, -0.43041644f, -0.11241387f, 0.04792357f, -0.94061393f, 
    0.05602058f, -0.50683016f, 0.14004754f, 0.52231401f, 0.05329610f, 0.31344840f, -0.66952318f, -0.62781972f, 
    0.10626019f, 0.06452950f, 0.12361597f, 0.17626724f, -0.04240176f, -0.39101380f, -0.05571346f, 0.04515100f, 
    0.00840336f, 0.28104854f, 0.08898643f, 0.50597018f, 0.08728731f, -0.53686684f, 0.04124861f, 0.08080941f, 
    -1.04006827f, -0.15091546f, 0.12539625f, -0.43130085f, -0.54166389f, 0.06967426f, 0.14147148f, -0.40113685f, 
    -1.19795549f, -0.17791909f, -0.02435675f, -0.02129546f, -0.06892947f, 0.08332143f, 0.94991666f, 0.21353412f, 
    -0.44877377f, 0.16085707f, 0.03025749f, 0.17630400f, 0.05416308f, -0.30054280f, 0.03787655f, 0.14324632f, 
    -0.01202487f, 0.00116514f, -0.18068419f, -0.70620769f, -0.33533889f, 0.33251825f, 0.35077292f, -0.13767000f, 
    -0.44541234f, -0.12510963f, -0.17124826f, 0.19068632f, 0.21074212f, -0.22354363f, -0.10020104f, -0.02643614f, 
    -0.23140667f, 0.98486030f, -0.11832494f, -0.07908408f, -0.01516270f, -0.12702151f, -0.21279198f, -0.45461279f, 
    -0.24735980f, 0.11514936f, -0.04236886f, 0.39112619f, 0.07176746f, -0.74575615f, -0.26727349f, 0.05430460f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33113074f, 0.27156505f, 0.29238024f, 0.14884642f, -0.04242237f, 0.03426864f, -0.24068655f, -0.53470689f, 
    -0.30315545f, 0.02321137f, 0.31341559f, 0.08517941f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
