#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.26403776f, -0.60212886f, 0.04775545f, -0.14567044f, -0.65713286f, -1.06141317f, -0.98333007f, -1.33708632f, 
    -0.83735061f, -0.00765172f, 0.68083173f, -0.01909071f, -0.01730955f, -0.00536469f, 0.62760872f, -0.11017312f, 
    0.34640524f, 0.04497486f, 0.15724860f, -0.07326603f, 0.01205630f, 0.25373310f, -0.12734576f, -0.10480054f, 
    -0.38812408f, 0.38484827f, -1.99439692f, -1.01238537f, -0.28765213f, 0.78214467f, 0.14934707f, 0.71207714f, 
    0.01638781f, -0.08222567f, 0.00179194f, 0.05551628f, 0.03411587f, 0.29272193f, -0.62855005f, 0.55002701f, 
    -0.12122645f, -0.21022783f, 0.33732721f, 0.01741318f, -0.02450620f, -0.31773299f, -0.43345958f, -0.35795358f, 
    0.06439249f, 0.52504236f, -1.53189850f, -0.26051977f, -0.07085496f, -1.01801240f, -0.79457122f, 0.87161702f, 
    0.21410243f, 0.61540264f, 0.87798625f, 0.82932234f, -0.09403422f, -0.09832015f, -0.03914770f, -0.03408482f, 
    -0.31046027f, -0.29537880f, -0.25139099f, -0.07428093f, -0.21743801f, 0.19572237f, 0.11590110f, 0.11168242f, 
    0.57247394f, -0.03577722f, -0.10125679f, 1.53518331f, -0.28495151f, -0.24897775f, -0.65187931f, -0.93993241f, 
    0.34662575f, 0.49212340f, 0.01624917f, -0.15015697f, 0.16365582f, 0.02996772f, -0.14663804f, -0.35944691f, 
    -0.54495215f, 0.42362809f, -0.21492215f, -0.06968560f, 0.19601612f, -0.28994334f, -0.39454910f, -0.64295083f, 
    -0.40450633f, 0.10119994f, -0.61036283f, -0.72075999f, 0.69439250f, 0.43122649f, 0.36450556f, -0.65363401f, 
    0.66329229f, -0.14139862f, 0.78801996f, -0.01110012f, -0.54037315f, -0.57185411f, -0.00794467f, 0.50452852f, 
    -0.23432080f, -0.15015531f, 0.11853380f, -0.29432380f, -0.33165973f, -0.20012888f, -0.03774710f, 0.10929041f, 
    0.44483262f, 0.04902884f, -0.27022383f, 0.08473643f, -0.30261251f, 0.78559285f, 1.66206539f, 1.11266649f, 
    -0.85029060f, -0.61432552f, -1.12672925f, -0.32732323f, -0.33534729f, -0.32362580f, -0.39915085f, 0.66194093f, 
    0.05186810f, 0.08614016f, 0.10275599f, -0.24735916f, 0.21228546f, -0.23376544f, 0.18925181f, 0.29545072f, 
    -0.19215882f, 0.05619055f, 0.20731628f, -0.05746503f, -0.37610561f, 0.09190129f, -1.33768725f, -0.00528303f, 
    -0.47594571f, -0.75384569f, -0.64705265f, -0.32933649f, 0.44720215f, 0.75718164f, 0.80498505f, -0.12101065f, 
    0.42415032f, 0.24169774f, 0.28687763f, -0.23034799f, -0.39394042f, -0.19775435f, -0.12033207f, -0.46476740f, 
    -0.14899461f, -0.13689336f, -0.02606564f, -0.13358006f, -0.32643577f, -0.35520056f, -0.58391851f, 0.51738936f, 
    0.81495804f, 0.61228281f, -1.00933242f, -0.80772769f, 0.65443003f, -0.07556807f, -0.34447682f, -0.39371267f, 
    -0.51060981f, 0.06326595f, 0.81584615f, -0.33370024f, -0.24496068f, 0.26474658f, 0.41871634f, 0.49317133f, 
    0.02745974f, -0.08769400f, -0.98895729f, -0.28520173f, 0.23059340f, 0.25992468f, -0.17419849f, 0.35924155f, 
    -1.11481500f, -0.94469565f, -0.53409076f, -0.28078318f, -0.58527964f, -0.69880682f, -0.25502476f, -0.79369515f, 
    -1.07264543f, -1.06496966f, -0.25935251f, -0.36130902f, -0.34665924f, -0.43637416f, -0.78248143f, -0.08945534f, 
    0.06840538f, -0.24653511f, -0.32123157f, -0.11320724f, 0.03891090f, -0.03831789f, 0.26529360f, 0.32565409f, 
    0.38628921f, 0.45192528f, 0.57207912f, 0.69646382f, 0.51507849f, 0.41611600f, -0.66676664f, -0.74408299f, 
    -0.34112486f, 0.03741442f, -0.34331638f, -0.19494109f, -0.69946176f, -0.13973793f, -0.07318832f, -0.13304362f, 
    -0.03251461f, 0.08813323f, 0.24591622f, 0.12419097f, -0.07205079f, 0.11573725f, 0.00212265f, -0.15824439f, 
    0.29142094f, 0.24803056f, 0.33243254f, 0.30493182f, -0.13503848f, -0.48087376f, -0.90072411f, -0.07261996f, 
    0.38895246f, 0.10957268f, -0.04781118f, 0.01116033f, -0.07337897f, -0.09377372f, 0.66503531f, 0.08937866f, 
    0.12138020f, -0.41113123f, -0.58607811f, -0.04864126f, 0.58555293f, -0.21819690f, -0.29996029f, -0.25001317f, 
    -0.00597185f, 0.36692339f, 0.74367678f, 0.65706235f, 0.42709622f, 0.57510597f, 0.43574682f, 0.11249222f, 
    -0.31490797f, -0.22269359f, 0.16121881f, 0.49574301f, 0.40932372f, 0.23999548f, 0.10859039f, 0.18808401f, 
    -0.16343765f, 0.23682897f, -0.10713861f, 0.33941382f, -0.09033450f, -0.20958240f, -0.07556611f, 0.18206562f, 
    -0.13807012f, -0.09172595f, 0.42382798f, -0.28098416f, -0.58168972f, -0.75705695f, -0.47891724f, 0.36256722f, 
    0.05705695f, -0.35805050f, 0.54810101f, 0.29350954f, 0.27763221f, -0.16019303f, 0.14776847f, 0.40033129f, 
    -0.36889747f, 0.43136013f, -0.11647765f, -0.20586361f, -0.02670530f, 0.18600036f, 0.23238151f, 0.39821824f, 
    -0.16815415f, -0.13165769f, 0.30730739f, 0.31310618f, 0.04581148f, -0.37952650f, -1.03422308f, -1.02853096f, 
    -0.91736889f, -1.41285789f, 0.44878188f, 0.24439867f, 0.02528553f, -0.38129538f, 0.09569266f, -0.12422835f, 
    -0.40918970f, -0.02079913f, 0.10576085f, 0.01486394f, 0.06292613f, 0.08942328f, -0.17203249f, -0.01232856f, 
    -0.10157212f, -0.53113502f, -0.19493917f, 0.11111345f, -0.27948233f, -0.26975256f, 1.07943988f, 0.19717152f, 
    0.23408782f, 0.09291888f, -0.36026657f, 0.48980340f, -0.34209213f, 0.21628818f, 0.19981441f, 0.01439571f, 
    0.00182427f, -0.01903851f, -0.08080401f, -0.18818378f, -0.35619196f, -0.18806456f, -0.26723707f, -0.14709060f, 
    0.23007762f, -0.12869824f, -0.27530420f, -0.11973396f, -0.29615372f, -0.43278477f, -0.53801435f, 0.12479239f, 
    -0.91876984f, -0.41446584f, 0.16594806f, 0.81534082f, -1.23249388f, -1.07005215f, -0.51881713f, -0.22601976f, 
    0.63633835f, 0.18295492f, 0.57625592f, -0.40621135f, 0.21380793f, 0.16557615f, 0.41938862f, -0.30548739f, 
    -0.38260326f, 0.27586788f, -0.71083146f, -0.24250847f, 0.36179221f, -0.35524887f, 0.23435341f, 0.14442800f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10838264f, 0.87416005f, 0.28232595f, 0.27445120f, 0.33043668f, 0.32735485f, -0.13281229f, 0.81023735f, 
    -0.21548910f, 0.28977865f, 0.52174115f, -0.05214014f, 0.68544984f, -0.19361588f, 0.44446620f, 0.52886939f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.54271108f, 0.47152865f, -0.06431089f, -0.62727147f, 0.15197253f, -0.10632987f, -0.16948095f, 0.22879341f, 
    0.10156080f, 0.05787455f, 0.00230027f, 0.03336406f, 0.43570030f, -0.05216755f, -0.51340377f, -0.00817399f, 
    -0.01804123f, -0.06440734f, 0.13856371f, -0.41602772f, 0.00854082f, -0.16078995f, -0.15821737f, -0.05142874f, 
    -0.15000312f, -0.53155321f, 0.30910933f, -0.14783224f, -0.00167017f, 0.25127679f, -0.12229805f, 0.03149636f, 
    0.09455526f, -0.02648380f, -0.01889983f, -0.08471844f, -0.32147509f, -0.26982769f, -0.12394053f, 0.25105986f, 
    0.10712666f, -0.02985617f, -0.17112797f, -0.02241279f, 0.10653931f, -0.15028511f, -0.08492871f, 0.18731163f, 
    -0.44174823f, -0.14502864f, -0.72524673f, 0.38678870f, -0.04579412f, 0.07217565f, -0.10298749f, -0.07208682f, 
    -0.02212247f, 0.07432042f, 0.10459259f, -0.04515680f, -0.08825971f, -0.36155775f, -0.49806258f, -0.10598727f, 
    -0.09187049f, 0.26433596f, 0.07727540f, -0.20911767f, -0.05826187f, 0.05135962f, 0.05324656f, -0.04841144f, 
    0.16899638f, -0.09735690f, 0.02241079f, -0.10698393f, 0.06925474f, 0.02540488f, -0.03710348f, 0.16795525f, 
    -0.08361910f, -0.09549938f, 0.02360534f, 0.25998896f, 0.40182990f, -0.53511935f, -0.61016810f, 0.10215174f, 
    -0.29798651f, 0.01264124f, -0.39872500f, -0.22009963f, -0.12028323f, -0.15077290f, 0.09964311f, -0.31002721f, 
    0.69900680f, 0.42462361f, -0.19071275f, -0.38912103f, 0.28650561f, 0.18977146f, 0.14610402f, 0.09874029f, 
    -0.11651755f, -0.02706666f, 0.03136877f, -0.14517908f, -0.17113423f, 0.31305873f, 0.29245076f, -0.15248014f, 
    0.07156965f, 0.01961922f, -0.13422704f, 0.12500727f, 0.04309507f, 0.04957392f, 0.05207086f, 0.06423905f, 
    0.15536192f, -0.37069809f, 0.11384996f, 0.06060209f, 0.15037006f, -0.15075801f, -0.22972611f, -0.36298066f, 
    -0.11502121f, -0.23647566f, -0.15399946f, -0.05326639f, -0.23407105f, -0.03668609f, -0.05264879f, 0.09947023f, 
    0.09335613f, 0.13483343f, -0.01014228f, -0.02342463f, -0.04797127f, -0.10553364f, -0.03965703f, 0.02722522f, 
    0.14752629f, -0.00398240f, -0.05694686f, -0.05583381f, 0.17119832f, -0.19561477f, -0.22475316f, -0.34895489f, 
    -0.04904494f, 0.06583754f, -0.04091362f, 0.03472667f, 0.58674091f, 0.11807186f, -0.22461967f, -0.18471159f, 
    0.15120061f, 0.23458631f, 0.00983340f, -0.03652882f, -0.06988722f, 0.13764581f, 0.05475469f, 0.08491922f, 
    -1.02177525f, -0.66681784f, -0.42180154f, 0.02131517f, 0.10548218f, 0.00646408f, -0.02160770f, -0.01271365f, 
    -0.19881640f, -0.14713047f, -0.07903955f, 0.12776101f, 0.35026306f, 0.52767152f, 0.03427402f, -0.44476211f, 
    0.07063636f, 0.05254542f, -0.17364578f, -0.55569941f, -0.24672300f, -0.08825139f, -0.18305606f, -0.01628372f, 
    -0.10122539f, 0.28581947f, 0.08938282f, -0.18884319f, -0.26110572f, -0.16477440f, -0.17835589f, 0.12365723f, 
    -0.08696255f, -0.06754851f, 0.08155920f, 0.07317212f, 0.32795367f, 0.02936796f, -0.26251942f, 0.04900251f, 
    0.08118834f, 0.29479158f, 0.17483296f, -0.42311689f, 0.40158543f, -0.02202890f, -0.00487485f, 0.05047921f, 
    -0.14978693f, 0.55269557f, -0.29944932f, -0.32249948f, -0.14888582f, 0.01872933f, -0.06856574f, 0.07639926f, 
    -0.19915299f, 0.03483486f, 0.02164192f, -0.10312318f, 0.55665249f, -0.15818922f, 0.18771830f, -0.08890475f, 
    -0.04949503f, -0.01691736f, -0.27236992f, 0.07920138f, -0.29456705f, -0.14569910f, -0.20193146f, -0.52413255f, 
    0.57056892f, 0.17794184f, 0.21184310f, 0.18937130f, 0.03141106f, -0.14925753f, -0.22364075f, 0.00483603f, 
    -0.01731932f, 0.00055375f, 0.12103415f, 0.04402215f, 0.25204456f, -0.61562371f, 0.16424529f, -0.56406653f, 
    -0.03742545f, -0.11313989f, -0.21629561f, 0.15364644f, -0.02952296f, -0.15433109f, -0.04152885f, 0.10481856f, 
    -0.23648882f, -0.56392920f, -0.17220894f, -0.13830397f, -0.05343391f, 0.02963572f, 0.04248017f, 0.01345445f, 
    -0.20970550f, -0.21779750f, -0.32577437f, -0.15761466f, 0.40345308f, -0.47798708f, 0.01222613f, -0.42264163f, 
    0.12661700f, 0.24030147f, 0.30254731f, 0.10462209f, -0.06811753f, 0.39275986f, -0.26323301f, 0.23204973f, 
    0.19916265f, 0.03964452f, 0.32187334f, -0.08959854f, -0.05848757f, 0.09269908f, 0.07410111f, -0.04572586f, 
    -0.03112195f, 0.10051192f, -0.01110241f, 0.02965274f, 0.00233467f, 0.27009296f, -0.23028810f, -0.17893426f, 
    -0.10030396f, -0.05490725f, -0.05311632f, -0.10628628f, -0.02792878f, 0.03588832f, -0.01933099f, 0.06270556f, 
    0.22768456f, -0.10638566f, 0.16301973f, -0.33018726f, 0.02536071f, 0.35659787f, 0.17303644f, 0.03722593f, 
    0.23557910f, 0.22135369f, 0.04401853f, 0.03984193f, 0.11917033f, 0.21688639f, 0.27074766f, 0.17369156f, 
    -0.01518556f, -0.05721970f, -0.08315247f, -0.04796328f, 0.08451479f, -0.00545118f, 0.05377052f, 0.07657976f, 
    -0.25867936f, -0.06021026f, -0.10096281f, -0.10356884f, 0.03804599f, 0.03075309f, 0.17104070f, 0.02202549f, 
    -0.16958964f, -0.08694002f, 0.05176796f, -0.01141006f, 0.34936449f, 0.04827086f, 0.35005131f, 0.00996678f, 
    0.01923615f, 0.05296643f, -0.11132977f, -0.39507359f, -0.05620537f, -0.06112105f, -0.06758328f, -0.26122317f, 
    0.35230756f, 0.27649060f, 0.08630179f, -0.05511052f, -0.06605203f, -0.01123846f, -0.07281215f, 0.02223290f, 
    -0.00118675f, -0.00031503f, 0.33071637f, -0.00368985f, -0.57620430f, -0.15481782f, -0.44363064f, -0.15236375f, 
    -0.05563200f, 0.14887513f, -0.14635392f, 0.02666430f, 0.07888621f, 0.04125584f, 0.01437269f, -0.07137121f, 
    -0.64362729f, -0.65238166f, -0.29451033f, -0.23074023f, -0.13734847f, 0.15297513f, -0.24676049f, 0.00193248f, 
    0.10182679f, 0.01575573f, -0.00375793f, 0.07790782f, 0.14593749f, 0.06899326f, 0.38045028f, 0.00204882f, 
    -0.04398061f, 0.18699250f, -0.08538843f, 0.27040836f, -0.08092826f, 0.17052886f, 0.00569105f, 0.01488013f, 
    -0.10259094f, 0.72331059f, 0.16155837f, 0.64588183f, 0.04326164f, 0.08728201f, 0.18903664f, -0.07501782f, 
    0.05186226f, -0.17465703f, -0.09519330f, -0.10202722f, -0.27907982f, 0.34230381f, 0.23500052f, -0.08963229f, 
    0.05196123f, 0.01239761f, 0.15313146f, -0.27660248f, 0.28391653f, 0.43932080f, 0.04989973f, 0.31431308f, 
    0.36769143f, -0.25926480f, -0.19870915f, -0.62717402f, -0.01685333f, -0.03140286f, 0.03209577f, 0.09417303f, 
    0.02731635f, 0.06252581f, -0.16293053f, 0.02398097f, -0.42676255f, -0.47276986f, 0.85309625f, -0.79633081f, 
    -0.06082739f, -0.12443753f, -0.68544060f, -0.22287320f, 0.06753457f, -0.06786269f, 0.02171305f, 0.03514197f, 
    0.28114864f, 0.68695432f, -0.05885158f, 0.34626874f, -0.11154749f, -0.02669378f, 0.11364020f, -0.15826781f, 
    -0.04114400f, -0.07316533f, -0.00906612f, 0.20484771f, 0.05921922f, -0.24984436f, 0.13828328f, -0.28489992f, 
    -0.02094717f, 0.00270129f, -0.16594462f, 0.00204193f, 0.15422286f, 0.00691595f, -0.08562198f, 0.21970251f, 
    -1.07195771f, -0.36210769f, 0.06195921f, -0.33253554f, -0.36734736f, -0.17826056f, 0.07579767f, -0.19980083f, 
    0.02418894f, -0.06885446f, -0.14859645f, -0.04148915f, -0.33900219f, 0.04242871f, 0.17326440f, -0.12355933f, 
    0.04142002f, 0.05612223f, 0.11890662f, 0.23106420f, -0.04706534f, -0.00433123f, -0.04990152f, -0.01504235f, 
    -0.18911791f, 0.07337361f, -0.20077981f, -0.02996050f, -0.09976088f, 0.02995708f, -0.24651526f, -0.22516884f, 
    -0.39129305f, -0.18799429f, -0.03839019f, -0.08178779f, -0.35253480f, -0.19587192f, 0.06562224f, -0.02025856f, 
    0.03143474f, -0.06722105f, 0.00314163f, 0.02295922f, -0.01811998f, -0.09017520f, -0.08620194f, 0.09727053f, 
    0.06574772f, 0.24971573f, 0.19774257f, 0.02954857f, 0.15151280f, 0.08594711f, 0.07329667f, 0.17702422f, 
    -0.02589810f, 0.11454421f, -0.05855546f, -0.00273283f, -0.55810428f, 0.36212805f, 0.98570836f, 0.39490059f, 
    -0.05182766f, -0.16700290f, 0.20756301f, -0.07646498f, 0.01534750f, -0.12317385f, 0.00140518f, 0.10269797f, 
    -0.37784839f, 0.17264500f, -0.17493056f, -0.22137307f, -0.00948104f, -0.03942465f, -0.09024459f, -0.07563683f, 
    -0.02172955f, -0.27151147f, 0.01252251f, -0.00502483f, -0.67041171f, -0.53560281f, -0.68482280f, 0.48907113f, 
    0.10839501f, 0.10266490f, -0.17800102f, 0.08965790f, 0.07794640f, -0.03729895f, -0.03041524f, 0.10546201f, 
    0.19762245f, -0.28173220f, -0.09253873f, 0.34205163f, -0.07943490f, 0.16236866f, 0.21936366f, 0.07234076f, 
    0.19103318f, -0.13550429f, -0.00303450f, 0.09285382f, -0.57641864f, 0.78488803f, -0.32334593f, -0.15873304f, 
    0.22233011f, -0.22387086f, -0.17243023f, -0.19774540f, -0.05399221f, 0.00452246f, -0.15141910f, -0.24423356f, 
    1.20293927f, -0.48592496f, 0.13806568f, 0.18547620f, 0.48636305f, 0.26032051f, -0.01714924f, 0.14324625f, 
    -0.12834151f, 0.20080309f, -0.10133887f, 0.16126300f, -0.66049200f, -0.32626387f, -0.40544692f, 0.13785873f, 
    -0.27958712f, 0.09510057f, 0.03965972f, 0.06757036f, -0.03900025f, 0.08286265f, -0.02185853f, 0.16828321f, 
    -0.29453757f, 0.21749128f, 0.43475953f, 0.19443546f, -0.10392255f, -0.46446860f, -0.01942686f, -0.28450599f, 
    -0.03032180f, -0.36092496f, -0.07510488f, 0.14128792f, -0.15271010f, 0.12697981f, 1.03950870f, 0.10901146f, 
    0.05676717f, 0.23765610f, -0.33498058f, -0.05716389f, -0.12478204f, -0.01094732f, 0.29257736f, -0.05884534f, 
    0.69929433f, -0.52894449f, 0.24772838f, 0.28471887f, 0.41221195f, 0.00398230f, 0.03656337f, -0.02739789f, 
    -0.12006114f, 0.17428879f, 0.07959852f, 0.03609396f, -0.12586880f, -0.30371672f, 0.23335575f, 0.19069640f, 
    -0.18252045f, -0.24295272f, -0.50310725f, -0.08942234f, -0.00133937f, 0.05449345f, -0.23405425f, -0.30208826f, 
    -0.10687650f, -0.13250570f, -0.09859706f, 0.32260638f, -0.01794074f, 0.04632933f, 0.11074172f, -0.09278858f, 
    -0.12548424f, 0.12096453f, -0.17376211f, 0.06540424f, -0.30993015f, -0.47192708f, 0.50705391f, 0.01953389f, 
    -0.61262548f, -0.18202868f, -0.07787292f, -0.15828788f, 0.03484280f, 0.10133503f, 0.11301330f, 0.11186132f, 
    -0.34637827f, 0.29636845f, -0.11397466f, 0.54831302f, 0.01391461f, -0.06885447f, -0.08200986f, -0.23998937f, 
    0.02562705f, -0.14628223f, 0.24274975f, -0.31750053f, -0.40306151f, -0.46638224f, 0.00621148f, -0.40594462f, 
    -0.61400712f, -0.14383706f, -0.15150993f, -0.35097438f, 0.23098534f, 0.42056552f, -0.13594012f, 0.15426065f, 
    -0.26672825f, -0.00656215f, -0.26470593f, -0.41392764f, 0.02794271f, 0.01034908f, -0.13019896f, -0.33830699f, 
    -0.14981882f, -0.12966976f, 0.01302150f, -0.15106899f, -0.20730160f, -0.32992581f, -0.04341661f, 0.62299943f, 
    0.14968173f, 0.00347956f, 0.01998063f, -0.16658647f, 0.15884830f, 0.20311977f, 0.05074329f, 0.26779449f, 
    -0.81883448f, -0.06623237f, 0.16303460f, -0.03280880f, -0.31314459f, 0.18495025f, -0.03240963f, 0.10723060f, 
    0.09443162f, -0.00855308f, -0.14268832f, -0.10083642f, 0.25336978f, -0.03277686f, -0.38172573f, 0.12684913f, 
    -0.05912866f, -0.15882596f, 0.09332906f, 0.01386297f, -0.07171513f, -0.19922741f, 0.07868463f, -0.04089371f, 
    -0.06603520f, 0.27687651f, 0.34344018f, 0.53123331f, -0.05462449f, 0.02115872f, 0.08290624f, -0.02360359f, 
    0.06255364f, 0.07750099f, 0.01031826f, 0.07290232f, -0.17714246f, -0.56958461f, -0.05688057f, 0.02009518f, 
    -0.23168254f, -0.00646818f, -0.45750931f, -0.16759586f, -0.36845723f, -0.05621342f, -0.29350623f, -0.01532882f, 
    0.11685462f, 0.34780934f, 0.03317807f, 0.07943644f, -0.10532176f, -0.15940090f, -0.05532166f, -0.02764941f, 
    0.00419972f, -0.29936349f, -0.18904501f, 0.04885836f, -0.26280376f, 0.19198287f, -0.23862395f, -0.10990886f, 
    0.18104732f, -0.18052541f, 0.05524112f, -0.04253912f, 0.14142278f, -0.07627066f, -0.05158295f, 0.36752325f, 
    -0.10902081f, -0.29860052f, -0.61345226f, 0.07952967f, 0.14840096f, 0.12166485f, 0.17738591f, -0.14335844f, 
    0.04545953f, 0.03748189f, -0.03414549f, 0.00396406f, 0.07656363f, 0.36734393f, -0.53921950f, 0.43270120f, 
    0.14164975f, 0.28470799f, 0.01100130f, -0.12019664f, 0.21000890f, -0.08934582f, -0.00603626f, -0.04902986f, 
    0.14591640f, 0.13657285f, 0.00060564f, -0.11480271f, -0.11466356f, -0.03048033f, 0.10044885f, 0.04346881f, 
    0.34770247f, 0.05214332f, 0.01848641f, 0.19322565f, -0.09538173f, 0.19224013f, -0.53973651f, 0.36251765f, 
    -0.00317710f, -0.29292542f, 0.19649576f, -0.30228972f, -0.19508353f, -0.24079879f, 0.04250939f, -0.44914126f, 
    -0.12456658f, -0.02059739f, 0.12069996f, 0.30688518f, -0.04540011f, -0.03075123f, -0.07249826f, -0.02235161f, 
    -0.05414289f, -0.04225899f, 0.02680410f, -0.04493405f, 0.37442759f, -0.07995593f, 0.11220459f, 0.52537555f, 
    0.04505798f, 0.11177994f, 0.13290001f, 0.22164953f, 0.08758687f, -0.00034090f, -0.05609569f, -0.10011991f, 
    -0.07693078f, 0.19568200f, -0.13433941f, 0.10440937f, -0.10099006f, -0.23063824f, -0.24963686f, 0.08812001f, 
    -0.48197296f, -0.20322998f, -0.03742263f, -0.19484310f, -0.03619373f, -0.09301426f, -0.08313503f, -0.05589260f, 
    0.08969971f, 0.12445245f, 0.11924825f, 0.11372833f, 0.11534324f, -0.03559033f, 0.01763095f, 0.11600431f, 
    0.00339902f, -0.12715787f, 0.02267958f, -0.07514028f, -0.31569570f, -0.19745803f, -0.24446289f, -0.26579252f, 
    0.15740913f, 0.05839621f, -0.22071195f, -0.09435812f, -0.16380475f, 0.29715294f, 0.29312256f, 0.21020134f, 
    -0.04697321f, -0.20157687f, -0.02349575f, 0.01060442f, -0.07533326f, -0.01333117f, 0.12799512f, 0.21997716f, 
    0.41130203f, -0.23115934f, -0.23575886f, -0.10677187f, 0.14570841f, -0.06670373f, 0.03814802f, -0.02698975f, 
    0.04144036f, 0.09298826f, -0.03581503f, 0.23787963f, 0.01177485f, 0.08474029f, 0.47583920f, 0.25469521f, 
    -0.46661216f, -0.14862940f, -0.03918486f, 0.07715888f, 0.00565290f, -0.03513535f, -0.01984640f, -0.13479523f, 
    0.07938620f, -0.04269680f, 0.28845692f, -0.05490004f, 0.25248531f, 0.05996213f, -0.04806188f, 0.12794127f, 
    -0.08917823f, -0.04202646f, 0.07358599f, -0.11662304f, 0.21600974f, -0.19690710f, 0.13782261f, -0.15048830f, 
    0.04556438f, -0.09544734f, 0.08513613f, 0.12395234f, 0.00726178f, -0.04393145f, 0.11798743f, 0.31550977f, 
    -0.99277854f, -0.67539924f, -0.36748362f, -0.11419877f, -0.04825240f, -0.16596939f, 0.00071158f, -0.11392237f, 
    0.21978150f, 0.11902599f, 0.08596028f, 0.03876809f, 0.16638742f, -0.13043600f, -0.45000911f, -0.15352629f, 
    -0.09287974f, 0.07241419f, 0.15646681f, 0.07511411f, -0.03906066f, -0.18483509f, -0.17096490f, -0.56585735f, 
    -0.31050724f, -0.14037699f, -0.44194621f, 0.07733335f, 0.07888170f, 0.00371042f, -0.00656546f, 0.06324850f, 
    0.01508370f, 0.01030075f, 0.00723524f, 0.01384897f, -0.29074749f, 0.24108104f, -0.97625828f, 0.42296764f, 
    0.20677073f, -0.23014492f, 0.15657552f, -0.12090576f, 0.03277523f, 0.17659721f, -0.25303817f, -0.00437748f, 
    -0.77253783f, 0.11141398f, -0.45757630f, 0.00093945f, -0.02897754f, -0.03380812f, 0.00213681f, 0.05581185f, 
    -0.18405022f, -0.27724358f, 0.01875797f, -0.19120161f, 0.04714912f, 0.60702747f, -0.38034058f, -0.26284668f, 
    0.14563009f, 0.10652725f, -0.01523480f, 0.07711120f, 0.17038867f, -0.26977280f, 0.36223453f, 0.15716957f, 
    0.02781386f, 0.32688701f, 0.15104765f, -0.02153457f, 0.13084838f, 0.07904223f, 0.15492558f, 0.15447083f, 
    0.13933201f, -0.00203866f, 0.16619100f, 0.19388817f, -0.08561142f, -0.44471571f, 0.13676243f, 0.23852380f, 
    0.26953244f, 0.06916405f, -0.05814627f, -0.00342357f, -0.04340724f, 0.02894862f, -0.03369198f, 0.09535546f, 
    0.04421972f, -0.12197267f, -0.31509840f, 0.06718878f, 0.00413026f, 0.07950889f, -0.25862917f, -0.16745862f, 
    0.16681786f, 0.12106583f, -0.02619982f, 0.05240152f, -0.16763745f, -0.34445235f, -0.10465565f, 0.07709919f, 
    0.04704330f, -0.09634307f, -0.18584217f, 0.04530413f, -0.05988077f, -0.04529308f, 0.21368757f, -0.18893749f, 
    0.16752139f, -0.23730604f, -0.04215105f, 0.21356218f, -0.12643516f, 0.16170001f, 0.26103836f, -0.02446176f, 
    -0.01957671f, 0.10265671f, 0.00778130f, 0.11298697f, 0.05040453f, 0.07096786f, -0.30869570f, -0.52014887f, 
    0.08102098f, 0.10311397f, -0.18464786f, -0.02310452f, -0.00963990f, -0.20915167f, -0.14100908f, -0.23602720f, 
    0.20787668f, -0.17610548f, -0.23268537f, 0.06877962f, 0.07256264f, 0.03181682f, 0.00131711f, 0.03769570f, 
    -0.06694417f, -0.35618138f, 0.00125063f, -0.37532312f, 0.20660616f, 0.02155027f, 0.58066738f, -0.10852358f, 
    0.33290139f, 0.13733050f, 0.19429573f, -0.00940471f, -0.03954290f, -0.19216502f, -0.07592042f, 0.20280196f, 
    -1.02449441f, -1.88164282f, -0.93607026f, 0.04719069f, -0.35847583f, 0.04519181f, -0.21567996f, -0.67872661f, 
    0.04731400f, -0.03430274f, 0.06970240f, -0.00910189f, -0.71008861f, 0.85997361f, 0.50405622f, 0.12296391f, 
    -0.19068877f, -0.14764352f, 0.14117627f, 0.40174910f, 0.09655643f, -0.05518084f, 0.20833562f, 0.08011308f, 
    -0.33883375f, 0.14277215f, 0.00898405f, 0.50411975f, -0.05440406f, 0.02227115f, -0.35720441f, 0.19522692f, 
    -0.15578371f, 0.03178350f, 0.02080313f, 0.10468858f, 0.29955113f, 0.16456875f, -0.09366470f, 0.20669267f, 
    0.03005254f, 0.08810764f, 0.08216190f, 0.01487465f, 0.30929974f, 0.04641796f, 0.43258604f, 0.35132927f, 
    -0.14954394f, -0.04559343f, 0.15662548f, 0.13261692f, 0.14260760f, 0.09291018f, 0.20220795f, -0.05751992f, 
    -0.12290395f, -0.11550320f, -0.01280639f, 0.02910032f, 0.52352041f, -0.49440461f, -0.75031167f, -0.86552322f, 
    0.04004966f, 0.15365134f, 0.35304672f, 0.01914994f, 0.02660051f, 0.07778331f, 0.00336903f, -0.09454405f, 
    -0.41083729f, 0.21960188f, 0.29843983f, -0.00184437f, -0.06634249f, 0.10607202f, -0.00408713f, -0.01161324f, 
    0.06506817f, 0.35151145f, 0.21903194f, -0.09825842f, 0.40180588f, 0.04513065f, 0.54328436f, -0.42541230f, 
    0.00289190f, -0.03677147f, 0.12723586f, -0.13149273f, 0.12754050f, -0.00267711f, 0.03658307f, -0.15892664f, 
    -0.91487747f, -1.58883691f, -0.63067663f, 0.09799280f, -0.23782453f, -0.44001198f, -0.39607912f, -0.65610176f, 
    -0.11657989f, 0.01700592f, -0.08496106f, -0.13972858f, -0.40473437f, -0.02877584f, -0.49766803f, -0.13094695f, 
    0.16297005f, 0.25630498f, 0.13805099f, -0.20678057f, -0.01415468f, -0.04728897f, -0.00601145f, 0.07347718f, 
    0.35502404f, 0.07672594f, 0.03495416f, 0.13165171f, -0.17327023f, -0.52035397f, 0.39406025f, -0.09323913f, 
    -0.10505855f, -0.17289302f, -0.31047964f, -0.00062534f, 0.26140147f, -0.08678077f, -0.24876784f, -0.13090073f, 
    -0.02645845f, 0.04581531f, 0.19344825f, 0.10804502f, -0.08920183f, -0.11627378f, -0.24844012f, -0.24839233f, 
    -0.22951482f, 0.20878826f, 0.34492844f, 0.14888391f, -0.17060308f, 0.19794488f, -0.43625420f, 0.26842162f, 
    -0.01220130f, -0.14387116f, -0.01274014f, -0.07780896f, -0.77517581f, 0.10082190f, -0.05007104f, -0.37534329f, 
    -0.07095259f, 0.18780489f, 0.12708953f, 0.08164437f, 0.04996359f, -0.06925261f, 0.02971917f, 0.13953491f, 
    0.19223917f, 0.13718428f, 0.06901761f, -0.17473064f, 0.02059317f, 0.07680137f, 0.01531727f, 0.02761053f, 
    -0.04868480f, -0.02646637f, 0.04459279f, 0.02449322f, 0.19564731f, -1.19875360f, -0.89624780f, -0.12285253f, 
    -0.07676688f, -0.26067108f, -0.06811984f, 0.32854891f, 0.03707897f, 0.05919741f, 0.01810694f, -0.08975748f, 
    -0.69670945f, -0.96615374f, -0.22009645f, 0.78663152f, 0.10075260f, 0.21434706f, 0.20529459f, -0.08731595f, 
    0.08241159f, 0.02248296f, -0.04753288f, 0.04157845f, -0.11563390f, -1.03889418f, 0.04838882f, -0.32980257f, 
    -0.18219183f, -0.16173153f, 0.26004156f, 0.01814946f, -0.17502037f, 0.14868289f, -0.05918164f, -0.17001739f, 
    1.04086804f, -0.45462635f, -0.76588035f, -1.02517569f, -0.06939383f, 0.12127119f, -0.09271068f, 0.12310310f, 
    -0.10637569f, -0.19576932f, -0.01102506f, -0.07581925f, 0.09918699f, -0.10871583f, 0.42164704f, 0.14469256f, 
    0.01497605f, 0.10392503f, 0.00220420f, -0.04258559f, -0.12201718f, -0.17463757f, 0.21265198f, -0.10818413f, 
    -0.25565395f, 0.24702646f, 0.08929649f, 0.08807877f, -0.03226708f, -0.17772676f, 0.07298020f, 0.01345843f, 
    0.12445623f, 0.00853682f, 0.06626947f, -0.10356170f, -0.46801409f, 0.36151886f, -0.35204238f, 0.16362552f, 
    -0.21967976f, 0.10760038f, -0.00055132f, 0.36141467f, 0.14056633f, 0.01733532f, 0.13653329f, 0.11104964f, 
    0.78689289f, -0.00651727f, -0.38600948f, 0.18971896f, -0.05938012f, -0.12613441f, 0.02052033f, -0.08462607f, 
    0.25336429f, 0.19090953f, -0.15356939f, -0.05323236f, -0.85026652f, 0.75187898f, 0.14233372f, 0.14201368f, 
    -0.14813723f, -0.04895432f, 0.02355227f, 0.24916197f, -0.07644895f, -0.08073308f, 0.01249206f, -0.20920128f, 
    -0.51837873f, -0.44945705f, -0.03231389f, 0.27309763f, 0.25562403f, -0.38209262f, -0.06779929f, 0.39944053f, 
    0.05015605f, -0.04927581f, -0.15388654f, -0.15066612f, -0.07102028f, -0.04804512f, -0.09077310f, -0.15204398f, 
    -0.00433075f, -0.10883728f, -0.19076043f, -0.11149117f, 0.08287698f, 0.10802277f, 0.02109771f, 0.03745271f, 
    -0.20648375f, 0.21535273f, 0.03134051f, 0.03364300f, -0.07891288f, 0.02553287f, -0.03817755f, 0.12626399f, 
    -0.25658074f, 0.07611123f, 0.03411848f, -0.02479453f, 0.01521107f, -0.05112626f, 0.06758727f, -0.11788155f, 
    0.05632886f, -0.07411536f, 0.00303706f, -0.05826166f, 0.11286793f, -0.09855360f, -0.04306357f, -0.07986529f, 
    0.28476983f, 0.00855857f, -0.37069079f, -0.18554300f, -0.08994091f, -0.51054627f, -0.12523635f, -0.10003342f, 
    0.02106949f, 0.10584869f, 0.01097555f, 0.01407011f, -1.12643766f, -0.82622361f, -0.49691018f, -0.92319703f, 
    -0.08124406f, 0.05832608f, 0.26204595f, 0.31701875f, 0.03010094f, -0.03016132f, -0.09623103f, -0.08344711f, 
    0.06454208f, 0.20411815f, 0.16785587f, -0.12289615f, 0.00979855f, -0.09304628f, -0.07617848f, -0.04797788f, 
    0.13734742f, 0.07208974f, 0.13058268f, -0.01426789f, -0.62038195f, -1.41944849f, 0.58042330f, 0.55608767f, 
    -0.26184568f, 0.23027611f, -0.06030568f, -0.42122111f, 0.01957602f, 0.06632783f, -0.02154044f, -0.12312712f, 
    -0.01615133f, -0.34196505f, -0.20302387f, -0.06296509f, 0.06186172f, 0.09279170f, 0.00148573f, 0.19355342f, 
    -0.22448683f, -0.03914163f, -0.06910642f, -0.09257130f, 0.66669959f, -0.43900561f, -0.48921427f, 0.05211443f, 
    -0.10216334f, 0.24726431f, 0.13833965f, 0.08160572f, 0.24744433f, -0.32117233f, 0.07917461f, 0.21220404f, 
    -0.45890844f, -0.68076545f, -0.33624753f, 0.05115337f, -0.05526794f, 0.12704229f, 0.12377581f, 0.06322828f, 
    0.21221916f, 0.29443428f, 0.13643631f, -0.03513074f, -0.42366588f, -0.11720248f, 0.23126234f, 0.19136725f, 
    0.10537276f, 0.04093741f, 0.00062227f, 0.19425489f, -0.04398456f, 0.02418697f, -0.10707030f, -0.34395888f, 
    -0.31555644f, 0.00546890f, 0.35232419f, -0.30480003f, -0.31364706f, -0.15535416f, -0.07361765f, 0.02968104f, 
    -0.22472149f, -0.00898062f, 0.00471602f, -0.06979224f, -0.62556189f, 0.30535915f, 0.16188338f, 0.11838373f, 
    -0.01546053f, -0.36020291f, -0.36568272f, -0.03181414f, -0.25727192f, 0.00180732f, 0.10461067f, -0.11842805f, 
    -0.32577926f, -0.12579030f, 0.01700616f, 0.06554866f, -0.03381460f, 0.13741434f, 0.06591572f, 0.24540780f, 
    -0.08119481f, -0.07135837f, -0.27108043f, -0.57903361f, -1.08202899f, 0.02463292f, 0.41535726f, 0.47320962f, 
    0.07696944f, -0.03071154f, -0.23143797f, 0.23379689f, 0.22912921f, 0.28408608f, -0.00312162f, 0.15666741f, 
    -0.35488212f, -0.60351479f, -0.45727637f, -0.11435302f, 0.01255216f, -0.11185041f, -0.03669941f, -0.42491525f, 
    0.11098695f, 0.04770141f, 0.09290642f, 0.19043602f, -0.03518091f, 0.33147439f, 0.34004939f, 0.15021244f, 
    0.11607949f, -0.41435564f, -0.20411435f, -0.23069371f, -0.04568984f, 0.03683259f, 0.03876128f, -0.07287908f, 
    -0.31752002f, -0.28508818f, -0.05148228f, 0.08167523f, 0.12405314f, 0.05512080f, 0.09602899f, 0.12104952f, 
    0.33333495f, -0.02914388f, 0.26113632f, 0.28062662f, -0.10763781f, 0.17232589f, 0.07478596f, -0.17630488f, 
    -0.01245310f, -0.07758336f, -0.05356874f, -0.02513331f, -0.10911945f, -0.09878272f, 0.00324699f, 0.00129585f, 
    0.04949647f, -0.07837337f, -0.05049027f, -0.02421835f, -0.03643904f, 0.18199834f, 0.26181832f, 0.28279185f, 
    0.10249389f, -0.06408518f, 0.18839386f, -0.05304614f, -0.01478385f, -1.08564067f, -1.00918317f, -0.11575261f, 
    0.01399169f, 0.45991969f, 0.05005622f, 0.00110469f, -0.11455852f, -0.36852786f, -0.16677205f, -0.23755439f, 
    -0.51011878f, 0.15088394f, -0.06904835f, 0.09241521f, -0.00962736f, -0.16030839f, -0.21229225f, -0.13745728f, 
    -0.23483112f, -0.02072724f, -0.52360904f, -0.24568833f, 1.31662536f, -0.38721505f, -0.37314653f, -0.40113431f, 
    -0.00810085f, -0.12617059f, -0.05560345f, 0.08749536f, 0.13413189f, 0.39460385f, 0.32077256f, 0.05301082f, 
    0.53397483f, -0.13778354f, -0.28773302f, -0.21408524f, 0.00590638f, -0.11928590f, 0.21802810f, 0.09495752f, 
    0.09682491f, 0.05285727f, 0.00092815f, -0.02479585f, 0.35947642f, -0.67505443f, 0.56911206f, -0.15472732f, 
    0.30213529f, -0.31624761f, -0.08212125f, -0.02516434f, -0.23071100f, -0.02350273f, -0.24468789f, 0.11490504f, 
    -0.04107917f, 0.44868693f, 0.27822047f, -0.20781940f, -0.16128485f, -0.28628820f, -0.15662390f, -0.42746398f, 
    -0.01902797f, -0.25680518f, -0.03710114f, 0.16110723f, 0.46611425f, -0.30970454f, 0.35374987f, -0.48964587f, 
    0.00665721f, -0.09659738f, 0.08329383f, -0.04116413f, 0.04026493f, -0.17111169f, 0.20616134f, 0.22584639f, 
    -0.25941950f, -0.26883030f, 0.26575202f, -0.53451622f, 0.03796068f, 0.12324502f, -0.04398476f, -0.01967852f, 
    0.22828142f, 0.04397040f, -0.08882661f, -0.09654082f, -0.12353746f, 1.05324340f, -1.06172287f, 0.06745733f, 
    -0.11362535f, 0.10070294f, 0.51397401f, 0.05238288f, 0.10278553f, -0.02097975f, -0.10403306f, -0.01078999f, 
    -0.39283860f, 0.51625806f, 0.28087857f, -0.04042435f, 0.03499281f, -0.34792483f, -0.21466745f, -0.24544837f, 
    0.01873739f, 0.09995850f, 0.06893381f, -0.00072489f, -0.24581014f, 0.09818939f, -0.37027821f, -0.40430132f, 
    -0.11171742f, -0.21734723f, -0.03789297f, 0.28827888f, 0.03938048f, 0.00310054f, -0.24460140f, -0.33380228f, 
    -0.95114601f, -0.03962613f, 0.24394451f, -0.45021039f, -0.22556993f, -0.13181435f, -0.02272271f, 0.41421103f, 
    0.01938089f, -0.01052379f, 0.20828107f, -0.06341142f, -0.20665440f, -0.43086958f, -0.72254926f, 0.34761125f, 
    0.14492813f, 0.14238042f, 0.27088514f, 0.01079950f, -0.05491190f, -0.09951653f, -0.03346835f, -0.09361362f, 
    -0.01112568f, 0.76797473f, 0.03422247f, -0.77865702f, 0.06707809f, -0.45370242f, -0.02520550f, 0.14279516f, 
    -0.13739902f, -0.13758232f, 0.00418997f, 0.15709792f, -0.10687686f, 0.05738178f, -0.45044321f, 0.33333957f, 
    0.13017642f, 0.23033023f, 0.17106600f, -0.15291379f, 0.23891351f, -0.18412371f, -0.01273955f, 0.02566084f, 
    -0.06903182f, -0.19221574f, 0.24858649f, 0.09744371f, 0.34026116f, -0.27992243f, -0.47448251f, 0.25396964f, 
    -0.06655792f, -0.18591876f, 0.08524374f, 0.04613024f, 0.01721483f, 0.13426408f, -0.02423919f, -0.42021585f, 
    -0.25359333f, -0.07345823f, 0.08879116f, 0.24085915f, 0.07981218f, 0.16339616f, 0.13363998f, 0.09787887f, 
    0.06237247f, -0.18276970f, 0.17261858f, -0.00754349f, 0.00190234f, 0.19942217f, 0.32185152f, 0.00822430f, 
    -0.02024880f, 0.05092912f, 0.07033961f, 0.34564772f, -0.15908764f, -0.38902140f, 0.32191032f, 0.18395557f, 
    0.02144961f, -0.45571265f, 0.16369787f, -0.05866426f, 0.01030782f, 0.03456211f, -0.15716539f, -0.07474884f, 
    -0.59109050f, -0.08908489f, -0.04173556f, 0.12412430f, 0.12613776f, -0.19775562f, 0.25938177f, -0.03721967f, 
    -0.40833670f, -0.02096220f, -0.06828491f, 0.04317138f, -0.48918495f, 0.73479706f, -0.09646265f, 0.40077183f, 
    0.29943728f, 0.23705640f, -0.12593368f, 0.39003047f, 0.14891931f, -0.12011588f, 0.34425002f, 0.12360916f, 
    0.47425517f, 0.05043510f, 0.19819571f, 0.04784389f, -0.03227807f, -0.34287575f, 0.19010602f, 0.05018638f, 
    -0.14719972f, 0.26581043f, -0.10842162f, -0.02966184f, -0.43041083f, 0.50225633f, -0.04301849f, 0.19757181f, 
    0.08705175f, -0.27069536f, -0.07341730f, 0.11188756f, -0.47929981f, -0.18366045f, -0.31572178f, -0.58277148f, 
    -0.10026731f, -0.51768905f, 0.78271770f, -0.44852939f, -0.35595593f, 0.25049731f, 0.59854698f, 0.05580760f, 
    -0.00785954f, -0.15377542f, 0.07565295f, -0.18234715f, 0.07062298f, -0.71204323f, -0.23977903f, 0.08927456f, 
    -0.06370962f, -0.33176091f, 0.43121225f, -0.14811972f, -0.11640903f, 0.13749442f, -0.44146374f, 0.08153007f, 
    0.65966302f, -0.06395288f, 0.03557248f, -0.32222545f, -0.04474583f, -0.09088891f, -0.36891904f, 0.00514976f, 
    -0.18518615f, -0.44017094f, -0.45563257f, -0.58771783f, 0.30557391f, -0.64271790f, 0.38739139f, 0.19242775f, 
    0.32175645f, 0.07349115f, 0.32735935f, -0.08290208f, -0.22096995f, -0.01360025f, 0.12967096f, 0.32029912f, 
    -0.22804551f, -0.25584212f, -0.32862592f, 0.38341394f, -0.05548331f, 0.16367988f, -0.24422680f, 0.18338385f, 
    0.14314547f, 0.13572818f, 0.15783933f, 0.12340681f, -0.37601605f, -0.02059007f, -0.62705159f, -0.29860878f, 
    -0.33123204f, 0.02613216f, -0.13194285f, -0.16455339f, 0.00758505f, 0.26056960f, 0.06222441f, 0.08834066f, 
    0.05731129f, -0.26196608f, 0.57246143f, -0.15586588f, -0.35999653f, 0.10697319f, -0.12183209f, -0.06388807f, 
    0.19960351f, -0.00386115f, 0.41473851f, 0.07551002f, -0.43045446f, -0.24625599f, -0.99698150f, -0.83319032f, 
    -0.28279135f, -0.00449385f, -0.28743953f, -0.01044346f, -0.23519810f, 0.13277054f, 0.28034058f, 0.05360794f, 
    -0.29047510f, 0.25459272f, 0.42714071f, 0.12523343f, 0.03964549f, 0.05075325f, -0.22012046f, 0.26443109f, 
    0.03923051f, 0.24247058f, 0.21024969f, 0.07924416f, -0.26149186f, -0.51905125f, -0.37889129f, -0.00629990f, 
    0.15447418f, -0.12177049f, -0.20999444f, -0.00167825f, -0.16077654f, 0.16371737f, -0.31584123f, -0.59028232f, 
    0.00627512f, 0.36123607f, -0.23389816f, 0.53349483f, -0.00091387f, -0.18802769f, -0.21661861f, -0.11075903f, 
    -0.05161366f, 0.04620022f, -0.56261051f, -0.21752918f, -1.15153503f, 0.45262563f, 0.04798691f, -0.08663072f, 
    -0.02251869f, 0.03602263f, 0.21433166f, 0.02919862f, -0.15398289f, 0.24304071f, 0.01754625f, -0.12148359f, 
    -0.52625698f, 0.15337639f, -0.81420249f, -0.06445993f, -0.21157080f, -0.54680496f, 0.18455732f, -0.35949144f, 
    0.12942667f, 0.03503892f, -0.22882175f, -0.13329343f, -1.16035962f, 0.19816983f, 0.00353825f, 0.53572482f, 
    0.06231524f, 0.09430197f, -0.14368214f, 0.27773282f, -0.12395675f, 0.02818048f, 0.20193170f, -0.16729918f, 
    -0.41661799f, -0.37102452f, 0.26750815f, -0.20329228f, 0.09182711f, -0.01975445f, 0.24737200f, -0.03048872f, 
    -0.15479812f, -0.01708021f, -0.12400606f, -0.07075696f, -0.53229499f, 0.23031391f, -0.45410383f, 0.20623794f, 
    0.02566852f, 0.04884702f, 0.12138893f, 0.13096841f, -0.29914090f, 0.31727526f, 0.12262701f, 0.17089011f, 
    0.20945764f, 0.23263133f, -0.39897996f, 0.04402782f, -0.42949131f, 0.42149493f, -0.10067855f, 0.00138519f, 
    -0.04451276f, -0.18891189f, -0.29262233f, 0.20046708f, 0.60558146f, -0.19822817f, 1.12287915f, -0.16037571f, 
    -0.15522432f, -0.05411005f, -0.36388817f, 0.13547494f, -0.33754718f, -0.07357914f, 0.16298087f, 0.05421270f, 
    0.17781520f, -0.60853136f, 0.07271203f, -0.60251248f, 0.11836159f, 0.01564356f, 0.06068128f, -0.10169986f, 
    0.01912992f, 0.05148688f, 0.41279712f, 0.06157203f, -0.49363786f, -0.09350710f, 0.07446346f, 0.08948135f, 
    -0.18682484f, 0.22990495f, 0.09870293f, -0.24740808f, -0.21552025f, -0.05851208f, 0.12476653f, 0.15108788f, 
    0.11077867f, -0.22436485f, 0.04658013f, -0.03862400f, -0.19955796f, -0.00483855f, -0.10165150f, -0.27641112f, 
    0.03273131f, 0.03899306f, -0.08914809f, -0.29623261f, 0.67130309f, -0.06085007f, 0.21904799f, -0.39962327f, 
    -0.04766975f, -0.18708955f, -0.06463172f, 0.12608163f, -0.08932539f, -0.02455624f, -0.10282454f, -0.25531721f, 
    0.20310612f, -0.24470332f, 0.45643988f, -0.05191693f, 0.22855730f, 0.07646715f, 0.23379140f, 0.38856220f, 
    -0.45110989f, -0.07871936f, -0.46513769f, -0.11042710f, 0.42378750f, 0.05257411f, 0.12299853f, -0.26715606f, 
    0.01423096f, -0.08512904f, 0.01863157f, 0.05389212f, -0.24178335f, 0.00227898f, -0.18379292f, -0.06153490f, 
    -0.22445849f, 0.07637591f, -0.05897116f, 0.56692499f, 0.21419258f, 0.25302184f, -0.04987924f, -0.12655096f, 
    0.15313005f, -0.08788259f, -0.21886212f, -0.04942069f, -0.21306254f, 0.19323750f, -0.26168147f, -0.49433836f, 
    -0.25017658f, -0.22252291f, -0.00705661f, 0.22582613f, 0.19312181f, 0.14517806f, 0.11348440f, 0.20083486f, 
    0.16453248f, -0.17575535f, 0.16019514f, 0.14372718f, -0.08007693f, 0.09654328f, 0.03556107f, 0.15146594f, 
    -0.10950186f, 0.22430219f, 0.21171241f, 0.15481526f, 0.38761359f, 0.03828986f, -0.38350195f, 0.33325273f, 
    0.20583209f, 0.15504438f, -0.09977511f, 0.24466771f, 0.04401838f, 0.00112631f, 0.25876400f, 0.09699092f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.23887230f, 0.21268941f, 0.15126477f, -0.20408674f, -0.18739966f, 0.13635463f, 0.12018374f, -0.21981683f, 
    0.16427831f, 0.01724262f, 0.09879667f, -0.05294318f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
