#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.07316625f, 1.33362544f, 0.67112941f, -1.01659250f, 0.72937727f, 0.01545807f, 0.29298127f, 0.23210035f, 
    -0.51417702f, -0.59868777f, -0.02428368f, -0.00669919f, -0.03935302f, 0.09919363f, -0.15698721f, 0.13572007f, 
    0.08619263f, -0.18653278f, 0.01116615f, 0.06215918f, 0.02990142f, -0.10175099f, 0.01533332f, 0.07036051f, 
    0.21600462f, -0.04857181f, -0.16355038f, 0.63722378f, 0.02399935f, -0.63989908f, -0.10960464f, 0.14105228f, 
    -0.58432531f, -0.48971710f, -0.26551470f, -0.31524861f, 0.29127568f, -0.48016948f, -0.54389757f, 0.02750505f, 
    -0.51992595f, -0.32381636f, -0.28987297f, -0.18311687f, -0.25532147f, 0.24308679f, 0.14474632f, -0.04686640f, 
    -0.22858316f, 0.23545748f, 0.87547219f, 1.01685178f, 0.30760187f, -0.16927651f, -0.01622834f, -0.21836464f, 
    -0.76282674f, -0.29387069f, -0.06189094f, 0.55457741f, 0.21871252f, -0.06451096f, 0.06383029f, 0.08883943f, 
    0.19761983f, -0.08718865f, -0.13762572f, 0.11108385f, -0.10025629f, -0.01286707f, -0.14665630f, 0.35547635f, 
    0.22126606f, -0.35491982f, -0.12262664f, -0.22462358f, 0.62588674f, 0.26901138f, -0.62183774f, -0.26876980f, 
    -0.57780421f, -0.23345533f, 0.39545557f, 0.28497416f, -0.33917376f, -0.04191098f, 0.32320973f, -0.23996665f, 
    -0.08165589f, 0.05117295f, 0.23771398f, 0.27905580f, -0.14552443f, -0.21810102f, -0.02498748f, 0.24115428f, 
    -0.23562005f, -0.01613525f, 0.20911807f, 0.39652097f, -1.23450482f, 0.00205871f, 0.02342840f, 0.04844608f, 
    -0.33837241f, 0.26717043f, 0.61000121f, 0.06712852f, 0.24952915f, -0.34912887f, 0.03139246f, -0.21511562f, 
    -0.02346258f, -0.12494422f, -0.01121023f, 0.03409059f, -0.28407359f, 0.09166860f, -0.45442742f, -0.29557523f, 
    0.27462718f, 0.42995667f, 0.20982744f, 0.22073562f, 0.30064452f, -0.26329100f, -0.62843281f, 0.06253635f, 
    0.38542309f, -0.21711750f, 0.06123343f, -0.80209696f, 0.30523238f, -0.17049070f, -0.36589620f, 0.36366662f, 
    0.12478638f, -0.03616958f, 0.00139705f, -0.07047568f, 0.11602751f, 0.52280736f, 0.30605388f, -0.15009256f, 
    0.22914299f, 0.25221211f, -0.16199534f, 0.02475745f, -0.43753162f, 0.20610815f, 0.14832161f, -0.46805900f, 
    -0.53841370f, -0.35995325f, -0.33667526f, 0.25123319f, 0.83768731f, -0.45707408f, 0.21263319f, 0.60638458f, 
    0.07426046f, -0.04962787f, -0.27642578f, 0.14973015f, 0.08411781f, -0.07972266f, 0.28845629f, 0.11660957f, 
    0.08475122f, -0.03074982f, -0.07468196f, 0.08738522f, -0.04913618f, -0.24774671f, 0.30849046f, -0.74230057f, 
    -0.77136552f, -0.05701744f, -0.14747499f, 0.15842223f, 0.38252002f, 0.47596440f, 0.62876624f, 0.06195637f, 
    0.46080711f, -0.01210107f, 0.14985684f, 0.33341959f, 0.36498955f, 0.23474598f, 0.13316508f, 0.20991658f, 
    -0.15823215f, 0.02877336f, 0.18923710f, -0.20966424f, -0.21192728f, -0.07463138f, -0.39426693f, -0.26860553f, 
    -0.78168333f, 0.54542345f, 0.58341843f, -0.00287267f, -0.02964076f, -0.18796247f, 0.14424044f, -0.57235420f, 
    0.05679630f, -0.54897040f, -0.49574330f, -0.07277057f, -0.15861599f, 0.30470830f, -0.10810392f, -0.17918766f, 
    -0.10284117f, 0.02827251f, -0.23120962f, -0.15428747f, -0.14069664f, -0.03783659f, -0.34555617f, -0.25594234f, 
    0.03675958f, -0.60629916f, -0.28483269f, -0.56638384f, 0.15458059f, -0.16134065f, 0.37352076f, -0.01746403f, 
    0.15437527f, -0.29970753f, -0.88789344f, -0.09941529f, -0.09546077f, -0.46692684f, 0.15215342f, 0.33244994f, 
    0.06763138f, 0.20736508f, -0.29833937f, 0.08941273f, 0.32453245f, 0.16996376f, -0.10706160f, 0.28497207f, 
    0.33883926f, -0.22918391f, -0.62250239f, 0.25892484f, -0.43489525f, -0.88169676f, -0.66530174f, 0.60320860f, 
    0.13630970f, 0.07398717f, 0.52207303f, 0.06666274f, -0.45156091f, -0.14357738f, -0.48611313f, -0.13803616f, 
    -0.17260499f, -0.00220274f, 0.05817781f, 0.08381562f, 0.23211792f, 0.37388197f, -0.05655235f, -0.42941082f, 
    0.00750045f, -0.22760645f, 0.39457405f, 0.02175389f, -0.92862153f, -0.63527906f, -0.56985152f, 0.17230116f, 
    -0.54901081f, 0.12690066f, -0.10536022f, -0.68488568f, 0.21084668f, 0.19577153f, 0.37545413f, 0.50927150f, 
    -0.11606736f, 0.23571232f, -0.06651065f, -0.02464522f, -0.35932216f, -0.02626374f, -0.27421272f, -0.13788392f, 
    -0.12538177f, 0.09780370f, 0.04939941f, 0.09865464f, -0.41777691f, -0.71532488f, -0.44480672f, 0.89805049f, 
    0.82675272f, 0.44154018f, 0.29875949f, -0.08356877f, -0.10070142f, -0.07112819f, 0.25483805f, 0.13099727f, 
    -0.12118421f, 0.28212038f, 0.10125110f, -0.15809688f, -0.02741808f, 0.06046277f, 0.05657706f, -0.17475103f, 
    -0.00823239f, 0.24156944f, -0.30602837f, 0.33545628f, -0.38492784f, 0.99717003f, 0.32369888f, 0.18960017f, 
    -0.45479757f, 0.49406928f, -0.06991421f, 0.25422743f, 0.08212068f, 0.40490472f, 0.43392700f, -0.63193870f, 
    0.22686988f, -0.43230888f, 0.11620037f, -0.22549181f, -0.28582898f, -0.05140429f, -0.15942569f, 0.23489499f, 
    0.00170590f, -0.08435158f, 0.21083745f, 0.31403366f, -0.08967028f, -0.00019237f, 0.48584899f, -0.49107426f, 
    0.56803286f, 0.00941239f, -0.33067539f, 0.18402195f, 0.01896183f, -0.56961775f, -0.11557350f, -0.31113070f, 
    0.27635694f, -0.22141992f, -0.42424104f, -0.14301164f, 0.31666237f, 0.17923316f, -0.37585849f, -0.24916273f, 
    -0.46652696f, -0.26629540f, -0.07718655f, 0.22688141f, 0.43935314f, 0.29320055f, -0.25342879f, 0.96990550f, 
    -0.65706891f, 0.71733510f, -0.62455654f, 0.16406609f, 0.58257025f, -0.27985612f, 0.34533256f, -0.32840577f, 
    0.13639566f, 0.00164368f, 0.25753897f, -0.22900376f, 0.32140976f, -0.08402132f, 0.21233036f, 0.27127364f, 
    0.35874072f, 0.23037210f, 0.35625857f, -0.28168139f, -0.12809505f, -0.08010568f, -0.31535614f, -0.11977160f, 
    -0.37330729f, -1.08118129f, -0.46539423f, 0.31027538f, -0.37566304f, 0.15626894f, 1.15516186f, 0.58226115f, 
    -0.63761967f, 0.38561088f, -0.24750265f, -0.12676999f, -0.34481555f, -0.28020445f, -0.07922453f, -0.20922646f, 
    -0.08296777f, -0.22798793f, -0.01872997f, -0.27327290f, -0.00041385f, -0.22911513f, 0.01317883f, 0.02644173f, 
    0.04889089f, 0.33827424f, 0.68269378f, 0.35004389f, -0.10651050f, 0.71608579f, -0.23715347f, -1.01158690f, 
    -0.76350415f, -0.30006388f, -0.44604081f, 0.25967023f, 0.42820251f, 0.20680916f, -0.01847728f, -0.31196347f, 
    0.13189512f, -0.09898515f, -0.01296143f, -0.45455718f, 0.09521020f, -0.05966764f, 0.01235279f, 0.22039865f, 
    0.20721170f, -0.12865549f, -0.41259220f, -0.12439318f, 0.48484957f, 0.35326070f, 0.78959817f, 0.06771418f, 
    -0.64126045f, -0.85887414f, -0.50250387f, -0.29577410f, 0.23195800f, 0.39458638f, -0.08923309f, 0.22319806f, 
    0.27281055f, -0.25596008f, -0.34006929f, 0.14168040f, 0.14524312f, 0.63408232f, -0.07374501f, -0.00142090f, 
    -0.29916486f, 0.30522633f, 0.00418743f, -1.50290823f, 0.64868265f, 0.83880860f, -0.50593519f, -0.67034405f, 
    0.57498181f, 0.44635594f, -0.05684618f, 0.65125471f, 0.66110587f, 0.12543122f, -0.23601195f, 0.11457788f, 
    -0.14107068f, 0.16495700f, 0.19141775f, -0.15435381f, -0.16439635f, -0.22104952f, 0.16865020f, 0.19531994f, 
    0.22256362f, 0.28354752f, 0.10494079f, 0.27421579f, 0.67115343f, 0.69869107f, 0.74774867f, 0.71620351f, 
    0.74392116f, 0.58545721f, 0.01032234f, 0.02374554f, -0.66070604f, -0.18029496f, -0.11844378f, 0.27249357f, 
    0.00888508f, 0.04236031f, -0.25679848f, -0.12726495f, -0.16384481f, 0.23567608f, 0.03235001f, -0.01751622f, 
    0.09682032f, 0.42641950f, -0.07392584f, -0.01918925f, 0.34857690f, -0.09238617f, 0.72864956f, 0.32311553f, 
    0.06089297f, -0.60087198f, 0.33619398f, -0.11769532f, -0.80482733f, -0.45999452f, 0.04285800f, -0.08836679f, 
    0.05555104f, -0.31116590f, 0.44403887f, -0.26067606f, -0.14190020f, 0.38052443f, 0.06506754f, -0.05549281f, 
    -0.17746986f, -0.45770398f, 0.20466647f, 0.21331018f, -0.04516053f, -0.31312516f, 0.21020691f, -0.05943783f, 
    0.30738676f, 0.47983128f, -0.29260516f, -0.44830245f, 0.26608968f, 0.60761803f, 0.14323114f, 0.35215893f, 
    0.05656718f, 0.28147990f, -0.29600522f, -0.43521446f, -0.24385066f, -0.26632494f, -0.15902263f, 0.33428907f, 
    0.03932513f, -0.30368686f, -0.27412194f, -0.20767495f, -0.07749943f, -0.49386904f, -0.04123138f, 1.10448122f, 
    0.56418228f, 0.03518394f, 0.42975578f, -0.45932126f, -0.19730134f, -0.53094655f, 0.32976401f, 0.35514903f, 
    0.25877529f, -0.13075468f, -0.13788944f, 0.00360470f, -0.38470876f, 0.28571072f, 0.08153072f, -0.13510133f, 
    -0.44352302f, -0.41212544f, 0.21948943f, -0.20820612f, -0.08953081f, -0.25381884f, -0.34953371f, 0.05523438f, 
    -0.11681701f, -0.75922716f, -0.52920264f, -0.50934654f, -0.18453977f, 0.58974189f, -0.20751579f, -0.12401886f, 
    -0.31908765f, -0.01845723f, 0.16526361f, -0.33179891f, -0.30470207f, -0.35977975f, 0.11957958f, 0.01173296f, 
    0.25287923f, -0.04795698f, 0.22946738f, 0.16249725f, 0.15428782f, 0.35406259f, 0.06586032f, 0.09944162f, 
    -0.09052070f, 0.90975875f, 0.60718524f, 0.14791203f, 0.47400892f, 0.10769444f, -0.34891668f, 0.24328171f, 
    0.47373700f, 0.10010277f, 0.39112589f, -0.56027627f, -0.38296992f, 0.43542093f, -0.09589285f, 0.06784959f, 
    0.00021901f, 0.13878624f, -0.14156874f, -0.29941586f, -0.01757620f, 0.24346921f, -0.20179468f, -0.07994570f, 
    0.52515984f, 0.00922923f, -0.68400866f, 0.98633569f, -0.48602635f, -0.76187956f, 0.58578968f, -0.05236828f, 
    0.34528938f, -0.16381696f, 0.44718751f, 0.38976026f, -0.19655038f, -0.18877177f, -0.57572651f, 0.12260554f, 
    -0.19629045f, 0.15161175f, -0.04091426f, 0.04507648f, 0.09427736f, -0.19952394f, -0.45259410f, 0.04848186f, 
    0.07694161f, 0.02067912f, -0.20435588f, -0.66900063f, -0.53274989f, -0.58677071f, -0.25815141f, 0.10324367f, 
    0.00826989f, 0.28959656f, 0.09082509f, 0.56011009f, 0.59221143f, 0.10938544f, 0.30975631f, 0.43541721f, 
    -0.19740175f, 0.01188832f, -0.20732097f, 0.10320800f, 0.17654820f, 0.22531238f, -0.00811788f, -0.05409764f, 
    -0.06279812f, -0.14465284f, 0.44830492f, -0.09709770f, -0.75236994f, -0.33286831f, -0.15225683f, -0.34542206f, 
    -0.05570312f, -0.19053541f, -0.57088250f, 0.44582722f, 0.27634391f, -0.41085058f, -0.15213916f, -0.02718063f, 
    0.18838345f, 0.40334547f, -0.13270903f, 0.37744465f, 0.25524810f, 0.25557706f, 0.01861701f, -0.23103306f, 
    -0.22782598f, -0.34898967f, 0.07969600f, -0.02515314f, -0.28794983f, 0.86405063f, 0.22557180f, 0.78406101f, 
    0.05903965f, -0.33216059f, 0.42693648f, 0.28857002f, -0.60723186f, -0.27360249f, -0.26846460f, 0.36221632f, 
    0.45820060f, -0.04655192f, 0.24672039f, -0.06770475f, 0.26493448f, -0.21809304f, 0.05534694f, -0.14895833f, 
    0.08093910f, 0.13717757f, 0.53800237f, 0.19674848f, -0.14034379f, 0.22396438f, -0.34119281f, -0.97782010f, 
    -0.78609216f, -0.27394599f, -0.19590962f, -0.50667149f, 0.09839003f, 0.48370978f, 0.00896254f, 0.42486295f, 
    0.22898060f, 0.27150828f, -0.17394318f, 0.01082052f, -0.27245039f, 0.14791001f, 0.08510045f, 0.19006836f, 
    -0.07454743f, 0.11985722f, 0.11816292f, 0.17864628f, -0.18378139f, 0.18959691f, 0.00768535f, 0.11798789f, 
    -0.81834775f, 1.02896130f, 0.43490177f, -0.45909134f, 0.57135522f, -0.59630561f, 0.70372933f, -0.21560712f, 
    -0.25514653f, -0.05009787f, -0.31979132f, 0.21022604f, 0.23222254f, -0.25027600f, 0.23404355f, 0.01867715f, 
    -0.14605223f, 0.03730972f, -0.08528761f, -0.01159873f, -0.10461480f, 0.15159921f, -0.25719678f, 0.14157118f, 
    -0.28898329f, 0.33819669f, 0.34669265f, 0.27232265f, 0.39989793f, -0.95542550f, -0.03751384f, -0.34394878f, 
    -0.57912260f, -0.13064410f, 0.34338197f, 0.56668687f, -0.29428157f, 0.23225658f, -0.35711807f, 0.37741914f, 
    -0.00338356f, 0.28638032f, -0.00363388f, 0.44915000f, -0.21900596f, 0.02955426f, 0.00387216f, 0.18676263f, 
    -0.04872670f, 0.78998715f, -0.35745737f, -1.02811730f, -0.28735602f, -0.57933295f, -0.55870336f, 0.61796647f, 
    0.18831629f, 0.45943969f, -0.08700921f, -0.27563378f, 0.11860757f, 0.32076159f, 0.01878707f, 0.19921754f, 
    0.04046925f, -0.33951730f, -0.07430473f, 0.22226222f, 0.05452037f, 0.12797068f, 0.40483019f, 0.17072752f, 
    0.13927376f, 0.21413165f, -0.78471363f, -0.62626636f, -0.27511474f, 0.19488615f, 0.48953262f, -0.79204500f, 
    0.46593174f, 0.53011751f, -0.51463801f, -0.26326668f, 0.46081519f, -0.04669246f, 0.14193605f, 0.08345241f, 
    0.24870728f, -0.34562606f, 0.15877438f, 0.07567035f, -0.30877435f, 0.07094758f, -0.20076245f, -0.15735742f, 
    -0.24659081f, 0.06666996f, -0.15358974f, 0.59204113f, 0.59575039f, -0.23892148f, 0.55872613f, -0.82224464f, 
    0.07959668f, -0.70060593f, 0.25770628f, -0.21718349f, -0.27877271f, -0.17173316f, 0.17666833f, 0.24592598f, 
    0.18354985f, -0.23715672f, 0.06892880f, 0.15759121f, 0.17476131f, -0.01744861f, 0.04206255f, 0.10583560f, 
    -0.24548453f, -0.07618680f, 0.09912606f, -0.05316768f, 0.12185813f, -0.15777159f, 0.19895859f, 0.12712154f, 
    -0.74299347f, -0.41101840f, -0.12717663f, 0.71511638f, -0.00920908f, 0.16043691f, -0.34745821f, -0.50414300f, 
    -0.31099367f, -0.20325896f, -0.17981593f, -0.27288371f, -0.20035040f, -0.40904957f, -0.31279412f, 0.18657787f, 
    -0.29978728f, -0.12090953f, 0.55612510f, 0.20461182f, -0.22621180f, -0.41337004f, -1.02146959f, 0.51442611f, 
    0.58361250f, -0.02130982f, 0.80065948f, 0.77602828f, 0.36729002f, 0.05944510f, -0.47908202f, -0.10260122f, 
    0.04006458f, -0.01806891f, -0.06766466f, -0.00908855f, -0.07402288f, 0.12702794f, 0.12374092f, -0.17573370f, 
    -0.22028303f, -0.07549340f, -0.19192730f, -0.06371406f, -0.03284907f, -0.01395204f, 0.38738543f, -0.16455501f, 
    0.55298489f, 0.83360684f, 0.22983617f, 0.44994649f, 0.01715832f, -0.51653302f, -0.30317771f, 0.36892727f, 
    0.39188376f, 0.14925510f, 0.15545164f, -0.19748145f, 0.23356117f, -0.32415944f, 0.20818877f, 0.41200700f, 
    -0.34837234f, -0.03097659f, -0.33700919f, -0.35375586f, 0.21405378f, 0.12430853f, 0.06940284f, -0.79562575f, 
    -0.54271221f, -0.76265454f, -0.48179066f, -0.00366695f, -0.27935684f, -0.33684802f, 0.11744579f, 0.24486896f, 
    0.13124569f, 0.34180096f, -0.01060358f, -0.09690391f, -0.03928653f, 0.10333939f, 0.32692510f, 0.10065562f, 
    0.45094794f, -0.15943037f, -0.15248527f, -0.40415969f, 0.03555143f, 0.12208022f, -0.24279016f, 0.12590249f, 
    -0.34799436f, 0.25756320f, -0.66160065f, -0.46822178f, -0.41145051f, 0.25571030f, 0.23152152f, 0.03599048f, 
    0.36555010f, 0.10759815f, -0.04521061f, -0.05530756f, -0.16203687f, 0.24816342f, 0.24148832f, 0.03552083f, 
    -0.15480417f, -0.13062258f, 0.10789015f, 0.35100195f, 0.20670742f, -0.49196818f, 0.25903106f, -0.07710725f, 
    -0.32849824f, -0.30925378f, -0.51672727f, -0.58352929f, 0.49650425f, -0.25043648f, -0.39791977f, 0.21191867f, 
    -0.09750111f, 0.49007210f, -0.46737334f, 0.49582857f, -0.07505323f, -0.20730871f, 0.06054811f, -0.02638358f, 
    -0.44779763f, 0.00173809f, 0.01113620f, -0.06021288f, -0.26873398f, 0.10663311f, 0.27806163f, -0.12806231f, 
    0.21980320f, 0.28483286f, -0.35600013f, 0.24240811f, -0.34894270f, 0.55338651f, -0.13982183f, -0.22401841f, 
    -0.72122294f, -0.30493009f, -0.03989035f, 0.18609118f, -0.08222135f, 0.23650114f, -0.44237569f, -0.07751732f, 
    -0.10390666f, -0.18750462f, 0.03016034f, 0.23954231f, 0.36781046f, 0.13464065f, 0.14046426f, -0.06784049f, 
    0.11776767f, -0.47926566f, -0.16709365f, 0.83539879f, 0.65644103f, 0.32298887f, -0.61995101f, 0.70993227f, 
    0.17525858f, -0.26443556f, 0.51230711f, 0.23196907f, 0.37436581f, 0.05541571f, 0.16826208f, -0.06012537f, 
    0.06689361f, 0.00977906f, 0.40971825f, 0.04716095f, -0.23979950f, 0.00978043f, -0.11390398f, 0.16838999f, 
    0.22507365f, -0.12516090f, 0.33401850f, -0.02010575f, -0.63427311f, -0.26503098f, 0.44501016f, 0.01857745f, 
    -0.25989932f, -0.22675408f, 0.31862149f, -0.68720102f, 0.14444791f, -0.52448124f, 0.02052912f, 0.53316259f, 
    -0.41654760f, 0.27487436f, 0.06937788f, 0.21278405f, 0.23717579f, -0.33408064f, 0.00846252f, 0.25341800f, 
    -0.38054678f, -0.16123606f, 0.40292442f, -0.20908397f, 0.28771827f, 0.05656276f, -0.56501365f, -0.35833380f, 
    -0.13502371f, 0.20706096f, -0.29581311f, -0.94125974f, -0.30164826f, 0.06957903f, -0.57756084f, 0.11029865f, 
    0.30028802f, 0.03532226f, -0.06069075f, 0.04543190f, 0.07302194f, -0.32451120f, -0.08987363f, 0.38606322f, 
    0.47649008f, 0.31132638f, 0.45559475f, -0.02541723f, -0.12299738f, 0.39227274f, -0.36071441f, -0.30760881f, 
    -0.55683988f, -0.34835732f, -0.35992229f, 0.23890585f, 0.13184687f, -0.00200074f, -0.10044390f, 0.31360939f, 
    0.29014999f, -0.57396930f, 0.28525269f, -0.24059546f, -0.32540432f, -0.46292463f, -0.31469190f, -0.07886615f, 
    -0.40540370f, -0.33293176f, -0.24118784f, -0.08671477f, 0.08980967f, -0.24494970f, -0.20242974f, 0.47824410f, 
    -1.36196721f, -0.13812648f, -0.16596530f, 0.57383263f, 0.06946114f, 0.14426172f, 0.56704390f, 0.20283712f, 
    0.36080143f, -0.09857576f, 0.16456304f, -0.34471515f, 0.34830144f, -0.08971794f, -0.05836502f, -0.18158476f, 
    -0.02604062f, 0.01871516f, -0.14081965f, -0.02460722f, 0.02641524f, 0.04173291f, -0.02348900f, 0.01970235f, 
    1.07581055f, 0.36751977f, 0.50449717f, 0.87408268f, 1.00911605f, -0.12492107f, -0.18767300f, -0.13670868f, 
    0.38430259f, -0.55398375f, -0.03488704f, 0.16197860f, -0.07237051f, -0.33924219f, -0.03028342f, 0.21497072f, 
    0.21252702f, 0.05255403f, 0.06739659f, 0.20188999f, 0.14735128f, 0.18630347f, -0.04712923f, -0.08281068f, 
    -0.02756643f, 0.83993763f, 0.36094844f, 0.21597360f, 0.73459786f, 0.30099514f, 0.60958004f, 0.53307909f, 
    0.18687609f, 0.48046821f, 0.24169430f, -0.37981918f, 0.39898315f, -0.01552062f, -0.08468398f, 0.30949375f, 
    -0.13916218f, -0.28426239f, 0.14760433f, 0.05869476f, 0.21375918f, -0.01581759f, 0.07626127f, -0.01353883f, 
    -0.09661116f, 0.28490081f, -0.61381280f, -0.32202214f, 0.63997334f, 0.69244671f, -0.56147367f, -0.69566965f, 
    -0.24495183f, 0.70278382f, -0.27026945f, -0.33165264f, 0.05908664f, 0.36463290f, -0.25035074f, 0.15258837f, 
    0.21527648f, -0.05969643f, 0.41627952f, 0.38855332f, -0.00153915f, -0.39236394f, 0.18750674f, -0.10273778f, 
    -0.24774848f, 0.25240999f, -0.05840698f, 1.04994237f, -0.47646418f, 0.33240649f, 1.17278826f, 0.61199319f, 
    -0.57695627f, 0.41773269f, -0.10223005f, 0.32118437f, 0.12876509f, -0.10140690f, -0.17661020f, -0.23477314f, 
    0.04588273f, -0.10430598f, -0.19490130f, 0.01138383f, 0.04714412f, 0.13464670f, -0.05552994f, -0.09646276f, 
    0.15048847f, -0.11742989f, -0.17175664f, 0.02467094f, -0.59266287f, -0.44792831f, 0.25651741f, -0.44079101f, 
    -0.59169388f, 0.00424829f, 0.45742938f, 0.24960108f, -0.19210140f, 0.27861774f, -0.44540924f, 0.16523926f, 
    -0.19307475f, -0.21603331f, -0.44025105f, -0.26569322f, 0.23933613f, -0.12084974f, 0.11511322f, 0.03309719f, 
    0.02745100f, 0.12341393f, -0.00924770f, -0.16994333f, 0.08095151f, 0.52427304f, 0.41354868f, 0.73947531f, 
    -0.21291384f, 0.18559872f, -0.65677541f, -0.29762366f, -0.03234921f, -0.09765268f, -0.52462262f, -0.07259252f, 
    0.04168531f, 0.34887263f, 0.43573686f, 0.37910333f, -0.25542545f, 0.07094784f, -0.02416397f, 0.27694187f, 
    0.41686651f, 0.06851835f, 0.28016162f, 0.04539892f, 0.22363141f, -0.06800151f, -0.69338530f, -0.50246024f, 
    0.34097490f, 0.01899524f, -0.00079879f, 0.60026997f, 0.66483408f, 0.28260738f, 0.36777043f, -0.16262306f, 
    -0.34937897f, -0.49465480f, -0.21990117f, -0.14972059f, -0.09701456f, 0.32584003f, 0.14354347f, -0.02893232f, 
    -0.08371445f, 0.10747230f, -0.14920205f, -0.00148612f, 0.29601121f, -0.25252587f, 0.23572540f, 0.09492945f, 
    -0.44781244f, 0.55079615f, 0.19061042f, -0.14507899f, -0.47029373f, -0.42476746f, 0.02804560f, 0.40837443f, 
    -0.30618468f, -0.03149530f, -0.27595377f, 0.34705117f, -0.30457580f, -0.26948848f, -0.44450697f, 0.09259551f, 
    -0.28460011f, -0.17246884f, 0.13010348f, -0.14593302f, -0.26476187f, -0.21075490f, -0.08046610f, -0.05764320f, 
    0.44007462f, 0.59383345f, 0.71857107f, 0.86024868f, 0.20709451f, 0.30663002f, -0.05774922f, -0.15683030f, 
    0.44783559f, 0.12876558f, -0.48603725f, -0.07918172f, -0.19391942f, 0.24029076f, -0.36771157f, -0.09779625f, 
    0.17522469f, 0.07212649f, -0.05869117f, -0.19310252f, -0.03121506f, -0.16752626f, -0.35329410f, 0.18260126f, 
    0.11249650f, -0.69209999f, 0.56003243f, 1.00282431f, -0.91913897f, 0.00508303f, 0.25659934f, -0.12547389f, 
    0.39333993f, -0.13021868f, -0.46796304f, 0.04025950f, -0.09086150f, 0.37814748f, -0.18096446f, 0.09766465f, 
    -0.31341550f, -0.07243375f, 0.03792669f, -0.31887352f, -0.20743404f, -0.15630740f, 0.14423367f, -0.22879559f, 
    -0.03616704f, 0.07267615f, 0.61754251f, -0.28613988f, -0.45934981f, -0.57135546f, 0.50581777f, 0.76478845f, 
    -0.03751882f, -0.05061641f, 0.29289526f, 0.35909805f, -0.26009953f, 0.31786951f, -0.13956158f, -0.15960081f, 
    -0.16293076f, -0.18688473f, 0.15003431f, -0.00582164f, -0.38497287f, -0.22454701f, 0.00097800f, -0.15639828f, 
    0.26591766f, -0.09058211f, -0.24019276f, -0.01377875f, -0.09979908f, 0.19604954f, 0.57727802f, 0.40908566f, 
    0.27339807f, 0.31088662f, 0.31075153f, 0.32980585f, 0.30456191f, 0.11418521f, -0.31878543f, -0.12626234f, 
    -0.09929202f, 0.20425002f, 0.20491163f, -0.54104531f, -0.13180377f, -0.27677119f, 0.17932650f, 0.42073154f, 
    0.50199348f, 0.41103303f, 0.29361445f, 0.02414161f, -0.65845793f, -0.32387570f, -0.74069625f, 0.18326209f, 
    0.29922253f, -0.75022912f, 0.79225767f, 0.65456086f, -0.43638521f, 0.20401737f, 0.13850190f, -0.15841880f, 
    -0.03686295f, -0.13800989f, 0.40261298f, 0.00286321f, 0.16114372f, -0.25687242f, -0.08854871f, -0.30904603f, 
    0.00552935f, -0.04038625f, 0.01353473f, -0.08328979f, 0.01950466f, -0.60349357f, 0.29644394f, -0.31085101f, 
    0.76765174f, 0.07447308f, 0.16444264f, -0.13935992f, 0.55169231f, 0.44025689f, -0.33053532f, -0.29637805f, 
    -0.41040289f, -0.45745355f, -0.27534181f, -0.17725031f, -0.04268509f, -0.13784294f, -0.25317994f, 0.12637378f, 
    0.04606612f, -0.07139815f, -0.01748157f, -0.16686232f, -0.25205836f, -0.45156738f, -0.49606717f, -0.26392862f, 
    -0.32372484f, -0.30292791f, -0.55202764f, -0.36458120f, 0.65413910f, 0.33401021f, -0.12508236f, 0.06473500f, 
    -0.33928302f, -0.08250648f, 0.17649852f, -0.29570302f, -0.21183990f, -0.33705214f, 0.15143311f, -0.16293208f, 
    -0.28192383f, -0.31766528f, 0.18182354f, 0.45645288f, -0.13151799f, 0.21061879f, 0.22029650f, -0.56751877f, 
    -0.27996418f, 0.17270523f, -0.33094710f, -0.29292586f, -0.10969506f, -0.40122929f, -0.08089028f, -0.57251608f, 
    -0.36831039f, -0.02033435f, -0.25321355f, 0.36291054f, 0.39803270f, -0.23976992f, 0.02305849f, -0.00952470f, 
    -0.29296413f, 0.08093323f, 0.49980387f, 0.08327737f, 0.09079267f, 0.29054314f, 0.11492838f, -0.55236608f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10424786f, 0.05632266f, 0.24433956f, 0.14870486f, 0.19585755f, 0.35973552f, 0.26451996f, 0.04821314f, 
    -0.01149792f, 0.17949289f, 0.04618061f, 0.32266068f, 0.20956355f, 0.32827038f, 0.07165670f, 0.19710824f, 
    0.21846935f, 0.31051221f, 0.01915832f, -0.07842726f, 0.13744512f, 0.04987222f, 0.19212498f, 0.21890527f, 
    0.10027807f, 0.14759329f, 0.11988382f, 0.22580244f, 0.06934783f, 0.09006771f, 0.29582447f, -0.05232163f, 
    0.13292967f, 0.09467312f, 0.12040031f, -0.03367875f, -0.10987828f, 0.09023860f, 0.27721956f, 0.09640575f, 
    0.22579311f, 0.18142571f, 0.14409667f, 0.25143915f, 0.33539698f, 0.30807808f, 0.01602205f, 0.10988203f, 
    -0.10604891f, 0.09221741f, 0.15755567f, 0.20952535f, -0.00493394f, -0.01759596f, -0.07449012f, 0.11037769f, 
    0.29595262f, 0.27581799f, -0.12563238f, 0.23745155f, 0.13699117f, 0.04204499f, 0.07823759f, 0.18466571f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.58539551f, 0.10810821f, 0.21044649f, -0.36196658f, 0.01075092f, 0.01125435f, 0.05353162f, 0.01909429f, 
    0.00229438f, -0.11751182f, 0.06835541f, 0.04124009f, -0.14256433f, 0.01655832f, 0.15042259f, 0.11567383f, 
    -0.01025548f, 0.02275095f, 0.03767030f, -0.09040444f, -0.11818204f, 0.17502569f, 0.03999130f, 0.06058671f, 
    0.10037888f, 0.04641394f, 0.02366297f, -0.17912103f, -0.11339662f, -0.05155242f, 0.05188952f, 0.04276815f, 
    0.01896062f, 0.01059587f, -0.01544189f, -0.03114658f, -0.27229896f, 0.23684373f, 0.01810026f, -0.11677408f, 
    -0.01340888f, -0.06982432f, -0.02442365f, -0.02305469f, -0.04180265f, 0.03208413f, 0.01288719f, -0.11159851f, 
    0.31449550f, 0.08413775f, 0.07957548f, -0.07490662f, -0.02661876f, -0.01488165f, -0.01781204f, 0.00859177f, 
    -0.04733175f, -0.06704433f, -0.03443001f, -0.08478156f, -0.07630531f, -0.16838019f, -0.09353627f, 0.06826845f, 
    0.03695050f, 0.05460461f, -0.03624305f, 0.06467554f, -0.10113954f, -0.01062091f, -0.03862228f, -0.11097892f, 
    0.01838151f, -0.08594636f, 0.08487049f, -0.21158817f, -0.05730388f, 0.08577560f, 0.01370985f, -0.10166577f, 
    0.04861538f, 0.04003549f, -0.03274507f, 0.13776298f, -0.07093780f, 0.02727432f, -0.00972859f, -0.05931810f, 
    0.01372010f, 0.08607025f, -0.11850040f, -0.00438872f, 0.06519505f, -0.04994866f, -0.03051933f, -0.01054483f, 
    -0.26934847f, 0.07937276f, 0.03912815f, 0.01634546f, 0.00996808f, -0.05020642f, 0.08671505f, 0.05271749f, 
    -0.03558034f, -0.01907566f, -0.06452639f, -0.00368980f, -0.23016870f, 0.00949756f, 0.02454354f, 0.09421198f, 
    0.06730712f, 0.02655226f, -0.04550545f, 0.08139541f, 0.09448802f, -0.00387122f, 0.10531624f, -0.14967829f, 
    0.28419626f, 0.10097554f, -0.13705280f, -0.30242786f, 0.04774785f, 0.01694883f, -0.03210657f, 0.05140325f, 
    0.00247056f, 0.03899751f, -0.06489755f, 0.07140010f, -0.39617184f, -0.21876593f, 0.09877409f, -0.03499817f, 
    -0.02394712f, -0.09938477f, -0.00428020f, 0.02482465f, -0.12614602f, 0.06684757f, 0.00696228f, -0.00026667f, 
    -0.11434103f, -0.03728801f, -0.03979043f, 0.16557626f, 0.06040698f, -0.04211242f, -0.09543439f, -0.02975173f, 
    -0.02209512f, -0.14941579f, 0.01596486f, 0.00055248f, 0.14103508f, -0.11037699f, -0.01325295f, -0.23137487f, 
    -0.08462679f, 0.03771799f, -0.16261837f, 0.05569314f, -0.11157745f, -0.02521103f, 0.02048098f, 0.00333962f, 
    0.08687449f, -0.08043835f, -0.02721981f, -0.00605003f, 0.05481194f, 0.07142241f, -0.07924093f, -0.00808906f, 
    0.01944469f, -0.00353431f, 0.04171479f, -0.04256443f, 0.13781551f, 0.09551298f, 0.09886407f, -0.27025709f, 
    -0.12673736f, -0.03828488f, 0.06132369f, -0.01146686f, -0.00699825f, 0.00756342f, -0.04022805f, 0.06722228f, 
    -0.09975155f, 0.16140184f, 0.06922195f, -0.14877404f, -0.00091355f, 0.03818170f, -0.04483180f, 0.06981927f, 
    0.10785215f, 0.08685718f, 0.03718846f, 0.00929629f, 0.12529542f, -0.04319744f, 0.16745909f, -0.15703739f, 
    -0.06465929f, -0.09298264f, -0.06705660f, 0.03316740f, 0.10287089f, -0.13531773f, -0.03688747f, -0.02566451f, 
    -0.12131321f, 0.01448935f, 0.05806429f, 0.02742075f, -0.07373418f, -0.03203517f, 0.09342171f, -0.07008280f, 
    0.04526481f, -0.07484809f, -0.03907311f, 0.05814778f, 0.66818720f, -0.04843676f, 0.06862759f, 0.10524753f, 
    -0.08791389f, 0.00900004f, 0.07367161f, -0.13557857f, 0.04010972f, -0.00243896f, 0.10472968f, 0.03493675f, 
    0.18059091f, 0.03525859f, -0.00885514f, -0.00795718f, -0.22248998f, -0.08779699f, -0.00360328f, 0.06307574f, 
    -0.08977657f, 0.01843682f, -0.07709246f, 0.00829500f, -0.03753040f, 0.21989223f, -0.10264889f, -0.09820355f, 
    0.00196072f, -0.08040119f, -0.01042834f, -0.03934390f, -0.04468842f, 0.08958307f, -0.02423969f, -0.02986169f, 
    -0.03767065f, -0.05630390f, -0.16260251f, 0.13181934f, -0.07818467f, -0.02024942f, 0.04569588f, -0.14798464f, 
    0.07991728f, 0.00338491f, 0.00814995f, 0.02037192f, 0.07037887f, -0.12204139f, -0.12858020f, 0.04935368f, 
    -0.02568422f, -0.16119234f, -0.04583051f, 0.11219373f, 0.02278828f, -0.02242488f, 0.04996361f, 0.06888678f, 
    -0.16102038f, -0.16444609f, 0.16163658f, -0.24465212f, 0.00404449f, 0.05889034f, 0.04055785f, 0.01412254f, 
    0.01410176f, -0.07503830f, 0.15793361f, 0.07055006f, 0.02884997f, -0.09249048f, -0.17857395f, 0.12868071f, 
    0.00837032f, -0.01309200f, -0.03911886f, -0.02342593f, -0.04767356f, -0.01216841f, 0.13408379f, 0.03137375f, 
    0.24572812f, 0.07054301f, 0.19799609f, -0.21923582f, 0.05235309f, 0.04146445f, 0.14133890f, -0.10950351f, 
    -0.03827062f, -0.13163045f, -0.04667235f, -0.07330056f, 0.08781987f, 0.12136633f, -0.21197122f, -0.08095619f, 
    0.03739974f, 0.07149332f, 0.00338303f, 0.05778500f, -0.03552196f, -0.04974991f, -0.08800717f, -0.00689801f, 
    0.00212407f, -0.03345439f, -0.03652139f, 0.00485624f, 0.07662489f, 0.02798336f, -0.01753830f, -0.04329824f, 
    0.09175089f, 0.14118409f, -0.08262534f, 0.02875983f, -0.03481033f, 0.13425411f, 0.04367359f, -0.06761453f, 
    -0.20768824f, 0.00713605f, -0.11810675f, 0.00883366f, -0.05857363f, 0.02552176f, -0.03556614f, 0.04432017f, 
    -0.06529470f, -0.03485246f, -0.14629175f, -0.16164732f, -0.10548704f, 0.00881865f, 0.00226165f, 0.04874109f, 
    -0.01183585f, 0.00254410f, 0.02331687f, -0.03797948f, -0.16978024f, -0.01580678f, 0.04400321f, 0.26585016f, 
    0.02118006f, -0.01266359f, 0.07912701f, -0.02810905f, -0.06504945f, 0.11214558f, -0.08207972f, -0.04832458f, 
    -0.03965532f, -0.15448424f, -0.07010750f, 0.00676330f, -0.00033478f, 0.00046592f, -0.05586986f, 0.11500889f, 
    0.11112176f, -0.05929792f, 0.01646567f, -0.03111663f, -0.27483198f, -0.03761517f, -0.06818657f, -0.22010867f, 
    0.02944847f, 0.01956335f, 0.15470186f, -0.10056138f, 0.00341819f, -0.02189187f, 0.11751531f, 0.05636126f, 
    -0.28270620f, 0.14698601f, -0.17560640f, 0.10877551f, -0.00312620f, -0.09528473f, -0.08899796f, -0.08780723f, 
    0.01864819f, -0.09956022f, 0.00966737f, 0.06683937f, 0.15643169f, -0.01751517f, 0.06687758f, 0.04838744f, 
    -0.00022462f, -0.07281291f, -0.00868384f, -0.02964846f, -0.20156561f, -0.02435921f, -0.16872731f, 0.01368430f, 
    -0.25033167f, -0.06672575f, -0.04895749f, 0.18096431f, -0.20808028f, 0.09122986f, -0.07819859f, -0.19081748f, 
    -0.00355050f, 0.06836159f, 0.07601964f, 0.03804351f, -0.24838699f, 0.18555719f, 0.13557765f, 0.11772897f, 
    0.03611895f, 0.04405703f, 0.14940828f, -0.00308244f, -0.04778551f, 0.05685756f, -0.04983883f, 0.03071741f, 
    0.02661535f, -0.14596194f, -0.17166023f, 0.20011815f, -0.17631547f, -0.14237933f, 0.08988737f, 0.02769894f, 
    -0.06547192f, 0.12798822f, -0.03776853f, 0.01690234f, 0.03891773f, -0.07007458f, -0.14040966f, -0.08025571f, 
    0.02053633f, -0.07759553f, -0.02155392f, -0.00738999f, -0.00567527f, -0.01076322f, -0.06849448f, -0.10155209f, 
    0.22328620f, 0.09870674f, -0.09477244f, -0.23981042f, -0.07227948f, 0.02986532f, 0.01511948f, -0.09983624f, 
    -0.07684983f, -0.07736266f, -0.05297481f, 0.03275834f, -0.20794000f, 0.06556873f, -0.27158114f, 0.12808993f, 
    0.05487330f, -0.07586306f, 0.02355522f, -0.04626822f, 0.05283990f, -0.16490611f, -0.06073018f, 0.10187937f, 
    0.03594458f, 0.01447011f, 0.09174929f, 0.09226220f, 0.04068797f, 0.01239857f, 0.04214394f, -0.03914304f, 
    -0.01854515f, 0.03357176f, -0.04691337f, 0.02135110f, 0.15240946f, -0.08918733f, 0.15291744f, -0.25885767f, 
    -0.08436488f, 0.00511784f, 0.03092393f, 0.03179274f, -0.03317519f, 0.05357651f, 0.02486861f, -0.04846852f, 
    -0.38427371f, -0.13106567f, 0.05933567f, 0.06649943f, 0.03985912f, 0.04994170f, -0.00253560f, 0.01381962f, 
    0.04209029f, 0.03475511f, 0.04728729f, -0.15318380f, 0.02668264f, -0.20068249f, 0.05400222f, -0.02762664f, 
    -0.01117421f, 0.04669729f, 0.06253783f, 0.05180768f, 0.12809701f, -0.05652104f, 0.08172465f, -0.08037158f, 
    0.06641463f, -0.09308117f, 0.00003623f, -0.21711612f, -0.04349333f, 0.07736237f, -0.01683608f, 0.03879052f, 
    -0.03066020f, 0.01524994f, 0.01885758f, -0.00726538f, 0.14578907f, 0.06912355f, -0.05130250f, -0.06289165f, 
    0.04994926f, 0.07841029f, -0.10355311f, -0.05348069f, -0.07520141f, 0.02160796f, -0.03028691f, -0.11512633f, 
    0.25412259f, 0.03256620f, -0.10206538f, 0.07419112f, -0.09649085f, -0.00493907f, 0.00729704f, 0.06504593f, 
    0.07699867f, -0.13063960f, -0.10623378f, -0.05940419f, 0.10279063f, 0.00356330f, -0.16140431f, 0.15361355f, 
    -0.13299170f, -0.09125519f, -0.00049039f, -0.00715892f, -0.00631486f, 0.02697590f, 0.05978573f, 0.03170506f, 
    -0.23343186f, 0.12521583f, -0.18692997f, 0.31135318f, -0.02500436f, 0.00395346f, 0.15630138f, -0.01882554f, 
    0.05368090f, 0.09991769f, -0.00968765f, -0.03683530f, 0.25894949f, -0.06149890f, -0.16721687f, 0.38259193f, 
    -0.20430875f, -0.08329847f, 0.06960392f, 0.00814568f, -0.02604548f, -0.01057792f, -0.07694495f, -0.07235450f, 
    0.03552062f, 0.09946796f, 0.09922963f, -0.11501738f, 0.03832070f, -0.00396962f, -0.02332159f, 0.02780924f, 
    0.01668480f, -0.06815275f, -0.05865411f, -0.08297954f, 0.11031613f, 0.24272902f, -0.05523340f, -0.01635688f, 
    -0.04794721f, 0.01531206f, -0.01784588f, 0.02402989f, -0.04511592f, -0.15095529f, -0.05375069f, -0.03964035f, 
    0.07532588f, 0.09912596f, 0.19725809f, 0.03158997f, 0.01974668f, 0.05140417f, 0.06565426f, 0.06359921f, 
    -0.00445321f, 0.02211169f, -0.03859992f, 0.03390361f, 0.24282342f, -0.05435789f, -0.12173535f, 0.15090181f, 
    -0.00912386f, -0.03250619f, 0.09467870f, -0.10657030f, 0.01386256f, -0.02666244f, -0.00984985f, 0.01680176f, 
    0.04523237f, -0.00186710f, -0.12084391f, 0.25883374f, -0.01628615f, -0.10457474f, -0.02319775f, -0.03697164f, 
    -0.07164408f, 0.00690234f, -0.07559946f, 0.03827868f, -0.27728200f, 0.20259653f, 0.14726543f, -0.02639567f, 
    -0.03169829f, -0.11675891f, -0.02209330f, -0.05304020f, 0.00485580f, -0.07566182f, 0.00283728f, -0.04317469f, 
    0.10553223f, 0.03925264f, 0.10757314f, -0.08259743f, 0.01921459f, 0.10582818f, 0.09313186f, 0.04919709f, 
    -0.17554897f, 0.04785306f, 0.04683606f, -0.02056835f, -0.06597473f, 0.08379643f, -0.04985256f, 0.06034756f, 
    -0.09001763f, 0.05241433f, -0.07194477f, -0.00675426f, 0.01522906f, -0.02644341f, 0.07504906f, 0.00800054f, 
    -0.25994682f, 0.21511054f, 0.05595808f, 0.05454376f, 0.01507709f, -0.01469612f, -0.07769602f, -0.07207762f, 
    0.03966661f, 0.10437222f, -0.00452350f, 0.07856666f, 0.06362025f, 0.01676999f, 0.05332119f, 0.17087516f, 
    -0.06009844f, 0.04897191f, 0.02915990f, -0.05340435f, 0.01845097f, -0.02837634f, 0.04888989f, -0.08475008f, 
    0.00505656f, 0.11577069f, -0.00952889f, -0.12703612f, 0.03044363f, 0.06662758f, -0.00226851f, -0.00956077f, 
    0.04266841f, -0.05718307f, -0.11451145f, 0.02605721f, -0.34360558f, -0.03803144f, -0.03487679f, 0.08083343f, 
    0.04109467f, 0.02145088f, -0.10877156f, -0.03412623f, 0.03278366f, -0.15620010f, -0.03771159f, -0.07964311f, 
    0.03262042f, 0.20593520f, -0.28615475f, -0.35989723f, -0.05699613f, 0.15202647f, -0.01095663f, -0.09156319f, 
    0.00120817f, 0.19054496f, -0.04206420f, 0.11455768f, -0.18731038f, -0.06681997f, -0.34946245f, -0.02635969f, 
    -0.06586739f, 0.03420882f, 0.10303372f, 0.02945680f, 0.00179550f, -0.16949068f, -0.06036498f, -0.17112780f, 
    0.11411930f, -0.08362027f, 0.05128102f, -0.01858266f, 0.00171423f, -0.10150032f, 0.05632981f, -0.02420279f, 
    -0.11595950f, -0.02292008f, 0.02854856f, 0.02432481f, -0.28248966f, 0.05004277f, -0.09130675f, -0.21895596f, 
    0.03843731f, -0.07381929f, -0.01545081f, 0.05112223f, 0.00970701f, -0.04596499f, -0.03285628f, -0.01580324f, 
    -0.27806067f, 0.03127024f, -0.13337578f, 0.00452820f, -0.01597328f, 0.08761986f, -0.04725384f, -0.00438561f, 
    0.01710934f, -0.05816444f, -0.06360474f, 0.06172170f, -0.27962834f, 0.29983076f, -0.03245889f, 0.03878205f, 
    -0.00626991f, 0.01010243f, 0.02809513f, 0.05952653f, 0.09772175f, -0.04623743f, 0.07898315f, 0.04070184f, 
    0.17364708f, -0.08205810f, -0.12433893f, -0.12569003f, 0.00282128f, -0.10762741f, 0.06563740f, 0.07399224f, 
    -0.08056541f, 0.02588394f, -0.00531440f, -0.08272124f, 0.10562038f, 0.10708102f, -0.04928023f, 0.04188646f, 
    -0.01658228f, -0.03289966f, 0.08794877f, 0.02006666f, -0.15177855f, 0.06051767f, 0.02016943f, 0.03083734f, 
    -0.06427742f, -0.03561994f, -0.18574531f, -0.08818656f, -0.16338161f, 0.07699323f, 0.05465497f, 0.00044925f, 
    -0.04893965f, -0.07098522f, 0.08163707f, -0.03892784f, -0.01174842f, 0.10805606f, -0.13340077f, 0.02197473f, 
    0.02796259f, 0.04914170f, 0.03783916f, -0.05473777f, 0.06329908f, 0.10498172f, -0.17693093f, 0.10842515f, 
    -0.36093560f, -0.03262423f, 0.06533629f, -0.23951054f, -0.03212419f, -0.01773013f, 0.07031236f, 0.07250775f, 
    0.06004426f, 0.09190893f, -0.01674988f, 0.05821014f, 0.19331062f, -0.06048233f, 0.08332433f, -0.06675217f, 
    -0.00478714f, 0.00162289f, 0.02182078f, 0.07791954f, -0.04491543f, -0.10784568f, -0.01683983f, -0.09971888f, 
    0.18482590f, -0.00284772f, -0.24698441f, 0.03656318f, 0.12303483f, 0.05680316f, -0.10922805f, 0.08821286f, 
    -0.04947926f, 0.00798081f, 0.01460272f, 0.05804820f, 0.30868205f, 0.03651875f, 0.09806081f, 0.15687014f, 
    0.07219684f, -0.09264630f, 0.10185968f, -0.00410936f, -0.05350072f, -0.10324728f, -0.09170926f, -0.09843439f, 
    -0.01817031f, -0.09061158f, 0.01694533f, -0.02419724f, -0.00530862f, -0.15656389f, 0.02007684f, 0.00038662f, 
    0.01181335f, -0.08924121f, -0.17694646f, 0.06180914f, 0.22733431f, -0.03330802f, -0.03437316f, -0.01614032f, 
    0.07852967f, 0.01928752f, -0.07390968f, 0.01928334f, 0.00932265f, -0.02819038f, 0.08832093f, -0.00128730f, 
    0.14631495f, -0.03289046f, -0.07548968f, 0.10833961f, -0.03730495f, 0.06104601f, -0.00600353f, -0.10849988f, 
    -0.04024158f, -0.02219798f, -0.05517741f, 0.06656612f, 0.04291962f, -0.13225298f, 0.03332225f, -0.04383243f, 
    0.02546422f, 0.01177207f, 0.10440479f, -0.00778545f, 0.03680163f, 0.03924192f, -0.00412575f, -0.00426370f, 
    -0.11262040f, -0.19019100f, -0.02156186f, -0.14337559f, 0.01072894f, 0.00957108f, -0.08795883f, 0.01164393f, 
    -0.20574220f, 0.00978027f, 0.03977065f, -0.05031322f, -0.75071412f, -0.00386233f, -0.04345889f, -0.07301103f, 
    0.04656873f, -0.12525359f, 0.04470273f, 0.06281397f, -0.01073282f, -0.01900585f, 0.02431978f, 0.02300416f, 
    0.19790809f, 0.03650580f, 0.13859309f, 0.12782648f, -0.08183166f, -0.00699710f, 0.02124453f, 0.00876325f, 
    -0.02745680f, 0.02806780f, 0.11560274f, -0.03910752f, -0.06535495f, -0.05455432f, -0.11418581f, -0.01844506f, 
    0.00381975f, -0.11725082f, 0.10131623f, -0.17457716f, 0.01358416f, -0.08108955f, 0.06530994f, -0.12444921f, 
    -0.04171061f, 0.06246056f, 0.02220990f, 0.10134019f, -0.04217282f, -0.08084536f, 0.05472401f, 0.01038199f, 
    -0.08005464f, -0.14015588f, 0.02103578f, 0.00934305f, 0.16277568f, 0.05419048f, 0.05534367f, 0.12710190f, 
    -0.09492359f, -0.19802299f, 0.01338366f, 0.02695429f, -0.03098148f, -0.05020617f, -0.04007832f, -0.01400711f, 
    0.06976420f, 0.11600289f, -0.12684958f, 0.04633189f, -0.00797614f, 0.00980993f, -0.08930422f, -0.04530061f, 
    0.15094419f, 0.00567413f, -0.11425916f, 0.06232285f, 0.31141585f, 0.14410777f, 0.10703442f, 0.20906593f, 
    -0.12865420f, -0.05272022f, -0.05390554f, -0.02961858f, 0.03747878f, -0.01470779f, -0.11300392f, -0.01938177f, 
    -0.26112098f, -0.04123423f, -0.01558332f, -0.27013120f, -0.03467490f, -0.01789274f, -0.03707214f, 0.04044067f, 
    0.20660140f, 0.02040635f, -0.07619071f, -0.14488579f, 0.15215328f, -0.05084513f, -0.01591355f, -0.06672342f, 
    0.06740563f, -0.06988491f, 0.00964315f, -0.02801087f, 0.05153372f, -0.10552203f, 0.04145683f, 0.07625644f, 
    -0.07581808f, 0.04606475f, 0.03048745f, -0.09946422f, -0.13251984f, -0.04026012f, 0.04573091f, -0.04799695f, 
    0.05142063f, 0.01932768f, 0.00482123f, 0.00076512f, 0.13083060f, -0.12074006f, 0.16194510f, -0.13682833f, 
    -0.04180159f, -0.06257429f, 0.04000226f, -0.02994617f, -0.05330496f, -0.03670506f, -0.01915399f, -0.07384958f, 
    0.18888101f, -0.12873386f, -0.05771099f, 0.00455322f, 0.01638876f, 0.06180074f, 0.03355200f, 0.06966208f, 
    0.09022601f, -0.03615640f, 0.02245465f, 0.10572440f, -0.24945895f, 0.14709473f, -0.17099987f, 0.04263186f, 
    -0.04901251f, 0.09863652f, -0.01107170f, -0.12494384f, 0.14754611f, 0.09871793f, 0.00738093f, -0.04319186f, 
    -0.09308031f, -0.07051743f, -0.01647627f, -0.11356369f, 0.04234833f, 0.02845264f, -0.01218674f, -0.07712161f, 
    -0.02888895f, 0.08735716f, -0.00989231f, 0.05953260f, 0.33306989f, -0.53518075f, -0.05055592f, -0.21682835f, 
    0.04024811f, -0.08523888f, -0.05193989f, 0.02797234f, -0.07534850f, -0.00088402f, -0.00339893f, 0.11278905f, 
    0.17567039f, -0.03982182f, 0.06639019f, 0.06293685f, 0.08260094f, 0.08189423f, -0.13540965f, -0.00308464f, 
    -0.01081826f, -0.14593208f, 0.12590493f, -0.12739660f, -0.02804221f, -0.16198137f, -0.11956270f, -0.02936106f, 
    -0.08261043f, -0.06621878f, -0.02506199f, 0.01582139f, 0.14517809f, -0.01048090f, 0.03118158f, 0.02564518f, 
    -0.12640849f, 0.00558161f, -0.05999810f, -0.04914628f, -0.17194122f, -0.04503897f, -0.04257202f, 0.03723457f, 
    -0.01951050f, -0.05155414f, -0.05082623f, -0.07573250f, 0.11195466f, 0.10442457f, -0.10311716f, 0.11223790f, 
    0.00021868f, 0.12335145f, 0.01941421f, 0.00934012f, 0.02275741f, -0.02360475f, 0.03668473f, 0.11971462f, 
    -0.01788807f, 0.06497710f, 0.08988504f, 0.14803073f, 0.02304103f, 0.04985307f, 0.00614398f, 0.00343024f, 
    0.04248783f, -0.17654410f, 0.09846023f, -0.01001067f, 0.10253161f, 0.11196066f, 0.00475327f, -0.07292911f, 
    0.08125643f, 0.04396745f, 0.10705427f, 0.05909910f, 0.09287576f, -0.06285428f, 0.06958365f, 0.11009914f, 
    -0.05599967f, -0.12330585f, 0.08559483f, -0.15016319f, 0.01955345f, -0.04948553f, -0.01989742f, 0.05705993f, 
    0.02432846f, 0.12244631f, 0.00696407f, 0.07862286f, 0.02059031f, -0.12855841f, -0.30819386f, 0.09478208f, 
    0.04963002f, 0.12608226f, -0.07267991f, 0.11404225f, 0.07775556f, -0.02536863f, -0.03230911f, 0.03446426f, 
    -0.18692994f, -0.07283626f, -0.26388228f, -0.15735614f, 0.09780917f, -0.12367482f, -0.15422620f, -0.04560994f, 
    -0.01331419f, -0.12061369f, 0.01931976f, 0.04861213f, 0.07055742f, 0.09275979f, 0.05500949f, -0.04452988f, 
    -0.01711926f, -0.04030272f, -0.02890526f, 0.03089032f, 0.00591381f, -0.01075840f, 0.01464475f, 0.13673741f, 
    -0.19734113f, 0.00084741f, -0.17324045f, -0.00625417f, -0.03120305f, 0.01214565f, 0.07229182f, 0.01452467f, 
    0.05833512f, 0.03426928f, -0.02943512f, 0.15025954f, -0.12799652f, -0.09086371f, 0.07776672f, -0.05306275f, 
    -0.00514780f, 0.11234148f, -0.05046906f, 0.06142171f, -0.11250718f, 0.15120400f, 0.06381302f, 0.01990492f, 
    0.10632236f, 0.00548399f, -0.00589604f, 0.00021738f, 0.01070045f, -0.06056377f, 0.00856863f, -0.02343296f, 
    -0.04687902f, -0.18115634f, -0.09405634f, -0.15504926f, 0.25498986f, -0.21607602f, 0.03527206f, -0.05455976f, 
    0.03257592f, 0.06192445f, 0.07944442f, 0.00158742f, 0.07964212f, -0.06497154f, -0.01052799f, 0.01500255f, 
    0.09430344f, -0.09296183f, 0.04174751f, 0.47242486f, -0.10873996f, -0.00231869f, -0.03632104f, -0.05401846f, 
    0.00138354f, 0.11182406f, -0.05048535f, 0.08017562f, 0.26760069f, 0.02164977f, 0.10380576f, 0.16631886f, 
    -0.05822796f, -0.01443707f, 0.06327339f, -0.02512917f, -0.06693771f, 0.05471337f, -0.04013129f, 0.08771659f, 
    -0.44992229f, 0.08079593f, -0.14136480f, 0.19577068f, -0.04837140f, -0.12931073f, -0.08160192f, -0.10218924f, 
    -0.09254174f, 0.01159291f, -0.01833280f, 0.13936175f, 0.26817265f, -0.19133750f, 0.09268782f, 0.17538078f, 
    -0.12286597f, 0.02993047f, -0.02070295f, -0.00677278f, 0.04446856f, 0.02329380f, 0.01264085f, -0.00764466f, 
    -0.14702085f, -0.02041481f, -0.12458470f, 0.04569991f, 0.04922081f, -0.08083627f, 0.06922720f, 0.05387048f, 
    0.02540768f, 0.06335401f, -0.12369661f, -0.06693929f, -0.23105992f, 0.03947407f, -0.09425015f, 0.01799988f, 
    0.05202549f, -0.15914832f, -0.01449143f, -0.05997297f, 0.06629532f, 0.11537082f, 0.00461190f, 0.02398736f, 
    -0.06953812f, 0.02546533f, -0.12462516f, 0.06345943f, -0.01766560f, 0.02738871f, -0.01153436f, 0.00541721f, 
    0.12366088f, 0.20781688f, -0.02698774f, 0.07800754f, -0.23176271f, -0.06628334f, -0.12970984f, 0.01324036f, 
    0.03888024f, 0.02081482f, -0.07926161f, -0.08404263f, -0.06482840f, -0.04705530f, -0.10658371f, -0.20170446f, 
    0.20405604f, 0.04868483f, -0.02052041f, 0.13024971f, -0.18132725f, 0.01811269f, 0.01964083f, 0.02619153f, 
    -0.02018904f, -0.01785578f, 0.03328371f, -0.11372833f, -0.01917593f, -0.00337722f, -0.09216407f, -0.06555988f, 
    -0.04145626f, 0.05278490f, 0.06952486f, -0.07805835f, 0.03113800f, -0.03150531f, -0.05000821f, -0.03098185f, 
    0.22062159f, -0.10298008f, 0.09059864f, -0.14958224f, -0.04106111f, -0.08441120f, -0.19058250f, -0.05380136f, 
    0.01392347f, -0.09363847f, -0.02938391f, -0.02181281f, 0.13982470f, 0.03625870f, 0.14121303f, 0.21298072f, 
    -0.01554800f, 0.07523479f, -0.02287975f, -0.06286317f, 0.05135774f, 0.10351858f, -0.01188613f, 0.12133873f, 
    0.22817066f, -0.00143347f, -0.03869103f, 0.01421678f, -0.02734557f, 0.04299084f, -0.05697948f, -0.02893461f, 
    -0.00008423f, 0.01503875f, -0.03712073f, -0.10164695f, -0.07315546f, 0.11456876f, -0.11572869f, 0.05355582f, 
    0.10856142f, -0.01068885f, -0.08946732f, -0.03232590f, 0.02360519f, 0.06029649f, -0.10360932f, -0.01791001f, 
    0.02766145f, -0.03295667f, -0.12749441f, -0.06080396f, 0.05948560f, -0.04711105f, -0.04420132f, -0.01380082f, 
    0.02685128f, -0.02720484f, -0.05623841f, -0.12978087f, -0.05051985f, -0.00812717f, -0.01042889f, -0.08557400f, 
    0.11286110f, -0.09817408f, 0.11485384f, -0.06224229f, -0.03941492f, 0.14529060f, 0.03729588f, 0.00682911f, 
    0.28759784f, -0.05026940f, -0.35494673f, 0.03270868f, 0.08339322f, -0.00082096f, -0.01713785f, -0.12259665f, 
    -0.04852089f, 0.02348952f, -0.00047941f, 0.02001875f, -0.17465085f, -0.10386417f, -0.15025628f, -0.26636323f, 
    -0.14464895f, 0.06950499f, -0.04495450f, -0.00225242f, 0.02684900f, 0.05150948f, 0.03485807f, -0.00206491f, 
    -0.16447109f, 0.01234801f, 0.07396587f, -0.17047830f, 0.01239644f, 0.07017778f, 0.03290004f, -0.09672408f, 
    -0.04621175f, -0.04074385f, -0.01971482f, -0.02666700f, -0.11051994f, -0.05069305f, -0.13675520f, 0.02239316f, 
    -0.06028340f, 0.06935059f, -0.01880249f, 0.05500470f, -0.04742799f, -0.02247710f, 0.01850455f, -0.04304492f, 
    0.18978316f, -0.10986330f, -0.05656491f, -0.02274119f, -0.06264084f, -0.11341419f, -0.11998914f, -0.01547413f, 
    0.03733460f, 0.02857072f, 0.04923052f, 0.00215827f, -0.08953123f, -0.21253276f, -0.11626296f, 0.04723351f, 
    -0.06956253f, 0.03630104f, -0.01999684f, -0.02738565f, -0.04408937f, -0.03067845f, -0.04218917f, -0.15750542f, 
    0.20175515f, -0.03918185f, 0.14642066f, 0.03822330f, -0.02315176f, -0.06589678f, 0.00419858f, -0.00926669f, 
    -0.03621116f, -0.05948662f, 0.01681579f, -0.03649390f, 0.29263669f, 0.07151400f, 0.06336048f, 0.03233491f, 
    -0.13173398f, -0.02497707f, -0.06130332f, 0.06983520f, -0.00596454f, -0.01593101f, -0.05839316f, -0.04378546f, 
    0.13020165f, -0.03249193f, -0.36240911f, -0.08517323f, -0.03120555f, 0.02291694f, -0.03181194f, -0.08103675f, 
    0.01921386f, 0.10449306f, -0.11500897f, 0.03626316f, -0.14185652f, -0.04241100f, -0.18609013f, -0.13506427f, 
    -0.09044902f, -0.03364619f, -0.07396120f, -0.00184471f, 0.03005532f, -0.14931916f, 0.06504169f, 0.04598473f, 
    0.16388412f, 0.15373251f, -0.01409751f, 0.24175157f, 0.01900619f, -0.02331880f, -0.00583621f, 0.04039489f, 
    -0.06600527f, -0.09223299f, 0.05086100f, -0.00097020f, 0.38331711f, -0.08763663f, 0.06899817f, -0.18281119f, 
    -0.03606391f, -0.06767025f, -0.03534526f, -0.04042939f, -0.03205729f, -0.01299193f, -0.02677599f, -0.10966288f, 
    0.13465047f, -0.34226829f, 0.12793104f, 0.06538261f, -0.03868611f, 0.00446307f, -0.06722650f, -0.01992601f, 
    0.07102385f, -0.08927342f, -0.06604126f, -0.03978054f, -0.00769443f, 0.09829998f, 0.02078729f, -0.09440457f, 
    0.09182058f, -0.00800737f, 0.03752935f, 0.00161629f, -0.10235412f, 0.08781340f, -0.04037628f, 0.07476328f, 
    -0.04182994f, -0.11483362f, -0.09907378f, -0.23508061f, -0.09697358f, 0.08561781f, -0.07235305f, -0.02064911f, 
    0.03315351f, -0.11365107f, 0.00307958f, -0.07795603f, -0.36919042f, 0.09509875f, -0.01171416f, -0.05190020f, 
    0.04799639f, 0.01990605f, 0.02636975f, -0.04413806f, -0.11545826f, -0.02610656f, -0.09887826f, -0.08846535f, 
    0.27974463f, -0.07696494f, 0.10874523f, 0.13053595f, -0.08482968f, -0.12786938f, -0.01601356f, 0.04766218f, 
    0.14678924f, 0.02873818f, 0.04547397f, -0.07669327f, -0.11005697f, 0.07754342f, -0.17734520f, 0.00369990f, 
    0.07017474f, 0.06187423f, 0.08641420f, -0.15754762f, -0.03109283f, 0.03534973f, 0.05028404f, -0.15277600f, 
    0.17962514f, -0.07235466f, -0.02042492f, 0.16260290f, -0.01111788f, -0.02555380f, -0.01460413f, 0.03405100f, 
    -0.05772009f, -0.08699237f, -0.00585858f, -0.09796924f, 0.40483907f, 0.11227417f, -0.02853106f, -0.01285082f, 
    -0.05306124f, 0.03059526f, -0.01435947f, 0.04037943f, -0.16187938f, 0.03293912f, 0.06847622f, -0.02298206f, 
    -0.11881361f, 0.00794581f, 0.07259878f, 0.03812350f, 0.11098910f, -0.00232939f, 0.04097534f, -0.09236320f, 
    0.06325220f, 0.11041033f, -0.04049183f, 0.03555671f, -0.07905343f, 0.05332540f, -0.14437157f, -0.20058896f, 
    0.04881963f, 0.12082608f, -0.05682090f, -0.02161836f, -0.00816388f, -0.03743816f, -0.00795977f, -0.02113721f, 
    0.05214122f, 0.01750109f, 0.02237361f, 0.08315887f, 0.05651245f, 0.03346700f, 0.09707104f, 0.07195407f, 
    -0.03770185f, 0.00392398f, 0.08548319f, -0.09034552f, -0.04493335f, 0.00410608f, -0.03177921f, -0.08949560f, 
    -0.05501581f, 0.04361910f, 0.02902783f, 0.09294665f, -0.02807240f, 0.01655314f, 0.03691691f, -0.12909724f, 
    -0.25287515f, -0.06623692f, 0.08904098f, -0.02551477f, -0.12266027f, -0.03931288f, -0.02750332f, -0.01532077f, 
    -0.01081253f, -0.14820054f, -0.03427615f, 0.03109772f, 0.03261831f, 0.02615831f, -0.08833671f, 0.01330371f, 
    0.04570204f, -0.00004083f, 0.05267299f, -0.02179261f, -0.02619015f, 0.04431721f, 0.02238146f, 0.03787370f, 
    0.14077581f, -0.12002649f, -0.13834304f, 0.04123800f, 0.02118174f, 0.12210426f, -0.02883030f, 0.01135989f, 
    0.01997051f, -0.05722693f, -0.03080274f, -0.03284773f, 0.16626857f, 0.06361436f, 0.05329888f, 0.04166071f, 
    -0.11775051f, -0.03285779f, -0.06023652f, 0.11581016f, -0.04033597f, 0.00536776f, -0.03186810f, -0.06669976f, 
    -0.10525694f, 0.06154833f, -0.28148723f, 0.04409186f, -0.02305867f, 0.07687157f, -0.06505751f, 0.05016571f, 
    -0.03171647f, 0.01789347f, -0.15154408f, -0.06620701f, -0.06093077f, 0.02048514f, -0.00545347f, -0.09517842f, 
    0.04022392f, 0.00238127f, 0.03090782f, 0.03506828f, 0.07996263f, -0.03366898f, -0.09074707f, -0.07486208f, 
    0.23956650f, -0.03430434f, 0.15411195f, 0.19614810f, -0.14366584f, -0.06862946f, 0.01462967f, -0.01119920f, 
    -0.00864823f, 0.00751862f, 0.00246504f, -0.00575481f, -0.42763060f, -0.01614364f, -0.18278506f, -0.04028653f, 
    -0.02634023f, 0.06185838f, -0.06680134f, 0.00843123f, 0.02525525f, -0.01667255f, -0.00031649f, -0.15378903f, 
    0.20767111f, 0.08879022f, -0.21094881f, 0.04184120f, 0.07148707f, 0.03554833f, 0.01339152f, -0.22232796f, 
    -0.12888779f, -0.11421637f, -0.04285717f, -0.06131054f, 0.14222249f, 0.20864210f, 0.01134138f, 0.27098590f, 
    -0.20179923f, -0.07464914f, 0.14780341f, 0.04800184f, 0.01024104f, -0.05049764f, -0.00222836f, 0.07308619f, 
    0.41846079f, -0.10025507f, -0.12590285f, 0.03063813f, -0.07339945f, 0.12436093f, -0.14255722f, 0.05813832f, 
    -0.03608224f, 0.00638690f, 0.06532841f, -0.00076533f, -0.27681381f, -0.02314848f, -0.13164532f, -0.19689007f, 
    -0.04405339f, 0.00759641f, -0.03365877f, -0.03906285f, -0.07644901f, -0.03141199f, -0.08512235f, -0.06179735f, 
    0.04122130f, 0.04036020f, -0.00620861f, 0.11536521f, -0.05956253f, 0.01568882f, 0.02302999f, 0.07024029f, 
    -0.18504438f, -0.03757776f, 0.02705737f, -0.00507008f, 0.00720822f, -0.05901910f, 0.12111052f, -0.07109718f, 
    -0.12107859f, -0.00111101f, -0.06266177f, -0.00723279f, 0.07311117f, 0.01846256f, -0.08748406f, -0.08079817f, 
    0.10996086f, -0.04067741f, 0.02320819f, -0.00240785f, 0.04759499f, 0.03444795f, -0.07096460f, 0.10974941f, 
    -0.05740823f, 0.03808143f, -0.06775289f, -0.07443701f, -0.03173933f, -0.19473952f, -0.08868496f, 0.16980071f, 
    -0.16310574f, -0.10441687f, -0.08271365f, 0.05415250f, -0.03489829f, 0.04797612f, -0.06993363f, -0.04897152f, 
    0.10748420f, 0.14280115f, 0.00665918f, 0.08396206f, -0.06008042f, 0.00064816f, 0.01064408f, 0.00187384f, 
    -0.00829940f, -0.04654158f, -0.01870230f, -0.02145242f, 0.15102448f, -0.25791943f, -0.09695671f, 0.02527429f, 
    -0.08365409f, 0.01109556f, -0.00936180f, -0.03978052f, -0.03992471f, 0.08001874f, 0.05064152f, -0.02777736f, 
    -0.18091570f, -0.20062159f, 0.02134757f, -0.04121119f, 0.07474151f, -0.04970355f, -0.00198355f, -0.09495991f, 
    -0.05381982f, 0.00523854f, 0.00258351f, -0.06441700f, -0.00403680f, 0.12737238f, 0.09062621f, -0.04151490f, 
    0.07809729f, -0.10529988f, 0.07364718f, -0.10524739f, 0.03056058f, -0.06952293f, 0.02021554f, 0.03187292f, 
    0.33024976f, -0.08053052f, -0.19579485f, -0.08378430f, -0.04680742f, 0.01506090f, -0.13319165f, -0.01858140f, 
    -0.05109888f, -0.08409142f, -0.01753269f, -0.06619342f, -0.29790810f, -0.14609289f, -0.07786848f, -0.07241763f, 
    0.04772600f, 0.03567404f, 0.04322850f, -0.04399251f, 0.01320772f, -0.05499779f, 0.02126375f, 0.02307140f, 
    0.00111195f, 0.06378927f, 0.11741208f, -0.00880140f, 0.00409315f, 0.06318868f, -0.05704582f, 0.04283471f, 
    -0.00770133f, 0.01865428f, 0.04306873f, -0.03406701f, -0.00464071f, 0.03034299f, -0.02737536f, 0.14775813f, 
    -0.04185351f, 0.02778935f, -0.09789059f, 0.05423460f, 0.04185928f, 0.03655023f, 0.02482238f, 0.06031160f, 
    -0.11407476f, 0.13126558f, -0.12585495f, 0.05064195f, 0.10291822f, -0.03730521f, -0.01219224f, -0.04612052f, 
    0.03185981f, -0.01311650f, 0.05968158f, -0.11035733f, 0.09073351f, 0.04312979f, 0.08115932f, -0.14340228f, 
    0.00291534f, 0.04304532f, -0.01430243f, 0.00569465f, -0.02194917f, -0.04383992f, 0.04683878f, 0.01514641f, 
    0.21663667f, -0.03672880f, -0.25825509f, -0.03180557f, -0.10912561f, 0.00256671f, 0.02299910f, 0.03623787f, 
    0.04444240f, -0.04484130f, -0.06148469f, -0.09609279f, -0.09035554f, 0.10741030f, -0.06639192f, -0.13468820f, 
    0.11099298f, 0.07408975f, -0.03850003f, 0.09336448f, -0.03226047f, 0.05598057f, -0.05878071f, -0.04317250f, 
    0.32776406f, -0.05053017f, -0.06334481f, 0.02270029f, -0.14081208f, -0.09586263f, 0.09144991f, -0.00458230f, 
    0.02853054f, 0.06125694f, -0.02581530f, -0.00956192f, -0.24953447f, 0.15582201f, -0.10950196f, -0.12944733f, 
    0.08937690f, 0.05048314f, -0.00140214f, -0.02106385f, -0.01398340f, -0.00948531f, -0.06197689f, -0.02028548f, 
    0.17915030f, -0.09124752f, 0.06200224f, 0.15834270f, -0.04251999f, -0.07817634f, 0.00768925f, 0.09547720f, 
    0.02557868f, -0.00690022f, -0.02788838f, -0.02581562f, -0.21016908f, 0.06012991f, -0.06460159f, 0.04660065f, 
    0.02585106f, 0.00302690f, -0.02076830f, 0.02989998f, 0.04202940f, 0.05734820f, 0.00524017f, -0.08923441f, 
    0.00034155f, -0.04255658f, -0.06420907f, 0.04320211f, 0.06774288f, 0.06463526f, -0.01164533f, -0.04791443f, 
    0.04987755f, 0.04529576f, -0.01060422f, -0.05490343f, 0.15989879f, 0.01130588f, -0.22988470f, -0.04994627f, 
    -0.05789739f, 0.00662083f, 0.05958259f, 0.04071795f, 0.01745097f, 0.01589057f, -0.08856545f, 0.06318911f, 
    -0.13544363f, 0.06862754f, 0.15925722f, -0.00295802f, 0.11110558f, 0.08912808f, 0.08979133f, 0.08363760f, 
    -0.06558363f, -0.01992129f, -0.03192769f, -0.00886058f, 0.03080750f, 0.02376547f, 0.00062829f, 0.01607891f, 
    -0.02762358f, 0.00763221f, -0.08227407f, -0.09993283f, -0.04272186f, -0.00244011f, 0.01593199f, -0.05523958f, 
    0.34844711f, 0.05487498f, -0.05726875f, 0.13389280f, 0.05019604f, 0.02734846f, -0.03579537f, 0.02743920f, 
    0.00027247f, -0.00475885f, 0.09746688f, 0.01657897f, -0.10220981f, 0.01257318f, -0.20473309f, 0.03595721f, 
    -0.02560964f, 0.10467261f, 0.01054628f, -0.01616118f, -0.01191538f, -0.11035315f, 0.07215985f, -0.00038081f, 
    0.24844703f, 0.06056852f, -0.03455105f, 0.06758976f, -0.12241707f, -0.08749516f, -0.05701430f, -0.02146593f, 
    0.03393123f, 0.06580808f, -0.01665931f, 0.05696076f, -0.19993451f, 0.05769044f, -0.06299809f, -0.17562769f, 
    -0.00455737f, 0.08283654f, -0.03217309f, -0.07891890f, 0.05084133f, -0.03278581f, 0.01979865f, -0.05606095f, 
    0.22415864f, 0.19118994f, 0.21207187f, -0.08301298f, 0.03406693f, 0.01111599f, 0.03474189f, 0.14647202f, 
    0.03826017f, 0.01003927f, -0.03492954f, 0.00613210f, -0.00590311f, 0.21471258f, 0.01345502f, 0.03059481f, 
    -0.00153576f, -0.01799781f, -0.00048838f, 0.00489319f, -0.02749712f, 0.03399408f, 0.00653080f, 0.08879012f, 
    -0.02334817f, -0.14059432f, -0.15840837f, 0.18358113f, 0.00079892f, 0.09986665f, -0.01288931f, -0.07660818f, 
    -0.00415951f, -0.07753652f, -0.00738276f, 0.01147145f, -0.12538064f, 0.16498275f, 0.00980284f, -0.06345595f, 
    0.02537186f, 0.00797212f, 0.03214745f, -0.00462155f, 0.01038946f, 0.03898679f, -0.07524049f, -0.08578651f, 
    -0.10632753f, 0.17995219f, 0.03849769f, 0.03302447f, -0.01955777f, -0.03374918f, 0.05924787f, -0.04090986f, 
    0.07036150f, 0.01790279f, -0.08903037f, 0.00683286f, 0.18447001f, -0.08510750f, 0.00882239f, 0.05684425f, 
    -0.01782712f, 0.00483148f, 0.04943423f, 0.03602098f, -0.08540952f, 0.04033211f, 0.04393205f, -0.09023378f, 
    -0.03728129f, -0.03563868f, -0.14794689f, 0.00092242f, -0.14943783f, -0.00210832f, -0.02602875f, -0.05899620f, 
    -0.01087744f, -0.07852623f, -0.06107591f, 0.09572996f, 0.04108235f, -0.08072610f, -0.02153181f, -0.05377819f, 
    0.01825189f, -0.03805866f, -0.14103721f, -0.05585455f, 0.00610439f, -0.03861098f, -0.01096568f, -0.00626007f, 
    0.24029487f, 0.23293309f, -0.00557275f, 0.09817598f, 0.06354266f, 0.08875882f, 0.05566571f, 0.03989963f, 
    -0.05079782f, 0.02429754f, 0.04659916f, 0.06478132f, 0.09977998f, -0.02866673f, -0.09576105f, -0.04035923f, 
    -0.05990674f, -0.06765813f, 0.03060542f, -0.07909291f, 0.00574935f, -0.14714569f, 0.11467849f, -0.00898850f, 
    -0.14174296f, 0.01845076f, 0.00155737f, -0.17840828f, -0.05915794f, 0.03386649f, 0.05733987f, 0.00918329f, 
    -0.03611428f, -0.06672437f, 0.02285790f, -0.00392819f, 0.08184523f, 0.07769798f, -0.00606642f, 0.08451688f, 
    -0.01520622f, -0.03218193f, -0.09696474f, -0.01143544f, 0.00462883f, 0.08454113f, 0.08109567f, -0.03923078f, 
    -0.02239866f, 0.03346461f, 0.06087870f, 0.06447148f, 0.00163335f, 0.01979084f, 0.11451997f, -0.00013063f, 
    0.05699546f, 0.00963860f, 0.02295216f, -0.07962292f, -0.22389953f, -0.17412533f, -0.19439343f, -0.15442109f, 
    0.03350368f, -0.06258141f, -0.00512691f, -0.07046355f, -0.04851116f, 0.01400921f, -0.02106473f, 0.13436544f, 
    0.02232245f, -0.07978037f, -0.03888784f, 0.05375073f, -0.01607969f, 0.09631960f, -0.11306625f, -0.00530736f, 
    0.06344718f, 0.02085413f, 0.09827580f, -0.15139516f, -0.02456513f, -0.10131964f, -0.09072819f, 0.07500621f, 
    0.06338066f, 0.08652098f, 0.04542538f, 0.02335387f, -0.01724061f, -0.00143462f, -0.02691663f, 0.02566029f, 
    0.07141159f, -0.18858145f, 0.10210652f, -0.01742700f, 0.03483208f, -0.05617828f, 0.09475344f, -0.04193550f, 
    -0.05873740f, -0.03160558f, 0.08540791f, -0.05699203f, 0.20461254f, -0.08403379f, -0.02298106f, 0.14647050f, 
    0.02209752f, 0.10456897f, -0.05488412f, 0.04892389f, -0.00969910f, 0.04027357f, -0.15363517f, -0.09746272f, 
    0.02749641f, 0.02625043f, 0.05930597f, 0.16251239f, 0.15816112f, 0.02588330f, 0.02550775f, -0.07628570f, 
    -0.07737290f, -0.04644632f, -0.06991462f, -0.16736180f, -0.46554637f, 0.27952257f, 0.13210756f, -0.31877869f, 
    0.02049852f, 0.00800389f, -0.06576975f, 0.08176148f, 0.08273648f, -0.09302762f, -0.10041463f, -0.02954690f, 
    -0.21603809f, -0.60986102f, -0.11516970f, 0.19663334f, -0.04634864f, -0.02602101f, -0.01874477f, -0.00942325f, 
    0.03065536f, -0.07334261f, -0.15016745f, 0.04869899f, 0.26036844f, 0.08075328f, 0.00072016f, 0.14961921f, 
    -0.03859974f, 0.03369450f, -0.04936804f, 0.07467680f, -0.00565090f, 0.04288872f, 0.03761275f, 0.05664738f, 
    -0.19036096f, -0.00745538f, -0.00167085f, -0.01508598f, 0.00064142f, 0.16789542f, -0.06414643f, 0.00902026f, 
    -0.05500458f, 0.10212156f, -0.06789879f, 0.01812676f, 0.28796965f, -0.43098888f, -0.23644900f, -0.04615334f, 
    -0.04350802f, 0.02082364f, 0.05890351f, 0.06453501f, 0.03440523f, -0.00461915f, 0.02412375f, 0.03360343f, 
    0.12367853f, 0.02012162f, -0.10490795f, -0.03333415f, -0.22454765f, -0.04165690f, -0.01070539f, 0.06725418f, 
    0.00595183f, -0.02550791f, 0.04457527f, 0.04652886f, -0.16438216f, -0.47665799f, -0.20400089f, -0.03144784f, 
    -0.05789873f, -0.10759163f, -0.02618184f, -0.10980168f, -0.08459112f, 0.01394573f, -0.04376135f, 0.07398070f, 
    0.19532777f, 0.20690893f, 0.02456008f, -0.03536831f, -0.12152056f, 0.01171172f, 0.04468079f, 0.10075772f, 
    -0.04333554f, -0.02826768f, 0.06367969f, 0.01470685f, -0.01999684f, 0.09691737f, -0.02386548f, -0.09488892f, 
    -0.11397083f, -0.07045033f, -0.04021921f, -0.00618813f, -0.03911117f, -0.06565947f, 0.01619751f, 0.06714811f, 
    -0.11014112f, -0.09666837f, 0.05457031f, 0.03903477f, -0.06000257f, -0.05473128f, -0.00915262f, 0.00943448f, 
    0.00955368f, 0.07731754f, -0.04284850f, 0.05285865f, -0.12927279f, -0.21732317f, -0.08474282f, 0.11509605f, 
    -0.05157556f, -0.01854232f, -0.04673329f, 0.12090919f, -0.04164981f, -0.04989416f, 0.00625207f, -0.02490409f, 
    0.08269425f, -0.04097927f, -0.01625931f, -0.04000350f, -0.12631568f, -0.08627770f, -0.04056393f, -0.03887802f, 
    -0.04639533f, -0.02581830f, -0.07409770f, -0.01444968f, 0.25475419f, -0.13760509f, -0.02483244f, 0.16349372f, 
    0.01055088f, 0.09814071f, 0.06026705f, 0.01052716f, -0.06365661f, 0.07487720f, -0.06129145f, -0.03471389f, 
    -0.42724338f, 0.16971071f, 0.20651087f, 0.22508195f, 0.02368440f, 0.08803307f, -0.00617848f, 0.00227906f, 
    -0.08116256f, -0.10796563f, -0.03818987f, -0.16775440f, 0.20970635f, -0.20486243f, -0.07367466f, 0.05940787f, 
    -0.07524513f, 0.00545226f, 0.01033795f, 0.05565795f, -0.06089060f, -0.02266786f, -0.03734142f, 0.01620281f, 
    -0.05057461f, 0.06367388f, 0.25280496f, 0.06479429f, 0.00482726f, 0.02839440f, 0.09191525f, 0.06615019f, 
    0.00105938f, -0.00853590f, -0.10973065f, 0.09518174f, 0.39936066f, -0.46819898f, -0.16723466f, 0.14246573f, 
    -0.14715913f, 0.03694297f, 0.15209329f, 0.03954109f, 0.03778905f, -0.06826475f, -0.06772261f, 0.15474574f, 
    0.16171186f, -0.11500455f, 0.05202966f, -0.11265845f, -0.04605667f, 0.08778832f, -0.02228470f, 0.03634698f, 
    -0.03009711f, -0.03366696f, 0.02393932f, 0.10406940f, 0.00519242f, -0.14766951f, -0.19770923f, -0.07393444f, 
    0.03846314f, 0.00293122f, -0.00914760f, 0.05345672f, -0.00902438f, -0.00832349f, -0.01185083f, -0.03670948f, 
    -0.24893285f, -0.13998204f, 0.02649555f, 0.10636749f, 0.06710332f, 0.00673725f, 0.07193063f, -0.04868399f, 
    0.16472673f, 0.07998667f, 0.02463957f, -0.04253083f, 0.04314143f, 0.01985484f, -0.03765346f, -0.08276434f, 
    -0.19578084f, -0.10346038f, 0.03659609f, 0.00837202f, 0.08521096f, -0.00903116f, -0.01089858f, 0.02891959f, 
    -0.02777132f, 0.05173502f, -0.08636185f, -0.06222440f, -0.05814322f, -0.02901383f, 0.05154647f, 0.08220233f, 
    -0.09666561f, -0.14335649f, 0.10724879f, -0.03165139f, 0.20372556f, 0.05751059f, 0.01624757f, -0.02220189f, 
    0.02759749f, -0.10245897f, 0.05922127f, -0.08851174f, -0.09817056f, 0.00249981f, 0.05907796f, -0.00116821f, 
    0.12950024f, 0.17799538f, -0.02305133f, 0.22128344f, -0.04051051f, 0.13086966f, 0.03705576f, -0.00100749f, 
    -0.08756240f, 0.02992087f, -0.03302884f, 0.01185814f, -0.30607069f, -0.28300807f, -0.33132559f, -0.07010337f, 
    -0.14869931f, -0.01449450f, 0.05452586f, -0.06003882f, -0.07755316f, 0.01726827f, 0.01843678f, -0.02015554f, 
    -0.05775078f, 0.18912968f, 0.11779134f, 0.07270952f, -0.03489207f, -0.01252731f, -0.06921669f, 0.02073892f, 
    0.07570299f, -0.06221952f, 0.00495043f, -0.01812771f, 0.22895877f, 0.08302002f, 0.09876557f, 0.11951454f, 
    -0.10685790f, -0.02110574f, -0.04673276f, -0.09962652f, 0.07903074f, -0.04262218f, -0.04928365f, -0.13731177f, 
    -0.00219679f, 0.02350997f, -0.09289595f, -0.09502009f, -0.05878789f, -0.05735255f, -0.00892412f, 0.01793927f, 
    -0.02716170f, -0.02692201f, 0.01936475f, 0.11282464f, 0.16401659f, 0.14248206f, -0.12496521f, 0.08777557f, 
    0.00452536f, 0.05631075f, -0.12353776f, -0.12039262f, -0.03691792f, 0.03162776f, -0.01946221f, -0.00926943f, 
    -0.11909200f, -0.38975090f, 0.04163605f, 0.01410065f, -0.02220628f, 0.04286626f, 0.04684324f, -0.07216796f, 
    0.00670768f, -0.03822678f, -0.03321439f, -0.14477500f, -0.22098495f, -0.32756776f, -0.25074610f, -0.11771250f, 
    -0.09601875f, -0.16109684f, -0.12120618f, 0.03071171f, -0.00472546f, -0.04770224f, 0.04575998f, 0.04411661f, 
    -0.10453171f, 0.14527239f, 0.19570741f, 0.02996610f, 0.03944282f, -0.13634042f, 0.07370986f, 0.05879726f, 
    -0.04901852f, -0.10608844f, -0.01994064f, 0.03349202f, -0.24147049f, -0.28053924f, 0.02669006f, 0.01648058f, 
    -0.07508478f, 0.09344012f, 0.02992172f, -0.02108806f, -0.00790836f, -0.00259890f, 0.02420391f, 0.02255695f, 
    0.04052705f, 0.13380839f, 0.15217605f, -0.19161540f, -0.01733555f, -0.03228778f, 0.04283080f, 0.05114424f, 
    -0.03911660f, -0.06198325f, -0.02743413f, -0.04759644f, -0.23428559f, -0.08226217f, 0.02628450f, -0.01792086f, 
    -0.02169378f, 0.05253946f, 0.05934763f, 0.06076998f, -0.00239242f, -0.08858060f, 0.03911879f, 0.00609637f, 
    -0.29385099f, -0.17946689f, -0.08732145f, 0.00326078f, -0.08883941f, -0.13809969f, 0.08302744f, 0.05240859f, 
    -0.06675745f, -0.01882698f, 0.11778057f, -0.12900162f, 0.07032277f, 0.16048889f, 0.00204185f, 0.11840716f, 
    0.01871191f, -0.10766613f, 0.01369839f, 0.05969084f, 0.00169570f, -0.00776992f, 0.00012911f, 0.07986110f, 
    -0.16190034f, -0.39059684f, -0.28770521f, 0.09120551f, -0.04781729f, -0.12063582f, 0.05744168f, -0.00153551f, 
    0.09582004f, 0.09026151f, 0.00923350f, 0.02010511f, 0.00865875f, 0.06419997f, 0.05432642f, -0.11486846f, 
    0.09489212f, -0.06756716f, 0.02398296f, -0.03263006f, 0.03644662f, 0.01511107f, 0.01263660f, 0.00334175f, 
    -0.04093578f, 0.12983529f, -0.13471036f, 0.07703075f, -0.01634142f, 0.05421070f, -0.03542537f, 0.04363975f, 
    -0.01564518f, 0.08215546f, 0.06139523f, -0.05672526f, -0.34401649f, 0.01155031f, -0.05247134f, -0.03048655f, 
    -0.04605931f, -0.09461407f, -0.04608514f, -0.13724913f, 0.06132213f, 0.08919445f, 0.04213776f, -0.10188954f, 
    -0.05445152f, 0.06637280f, 0.04747752f, 0.03617151f, -0.03318559f, 0.02690662f, 0.06411306f, -0.02743619f, 
    0.01314495f, 0.07322872f, -0.12571229f, -0.03307519f, -0.00312165f, 0.12239522f, -0.02602454f, 0.09265250f, 
    -0.02531044f, -0.02273394f, 0.05079615f, -0.02493880f, 0.04184883f, 0.07495371f, 0.11748710f, 0.02185935f, 
    -0.01285187f, 0.03125821f, -0.00483580f, -0.02045320f, -0.05803022f, 0.02499818f, 0.04703166f, -0.01212167f, 
    -0.11648747f, 0.08038998f, -0.04445377f, 0.10211520f, 0.14542580f, 0.04360497f, 0.09321982f, 0.04527690f, 
    0.02501317f, 0.04992716f, -0.03766568f, 0.02123818f, 0.05719106f, -0.11103634f, 0.00707245f, -0.04046917f, 
    0.23177333f, 0.35912645f, -0.09958312f, -0.17650171f, -0.12354410f, -0.12544987f, 0.06953767f, -0.02123887f, 
    -0.08840048f, -0.07217508f, 0.02887164f, -0.05182012f, -0.03480441f, 0.01640276f, 0.16161771f, -0.07072010f, 
    0.05408427f, 0.04108528f, -0.14746861f, -0.00535866f, 0.07193790f, -0.01485081f, 0.01021845f, -0.02846791f, 
    -0.18648854f, -0.36475933f, -0.02172532f, 0.09232410f, -0.23025557f, -0.08954316f, -0.03185220f, -0.07231984f, 
    0.01372096f, -0.03204205f, 0.04362449f, -0.01352971f, 0.23687555f, -0.03789630f, -0.11819422f, -0.01927283f, 
    -0.03781979f, -0.09710950f, 0.12460117f, -0.03593438f, 0.00031495f, 0.01786263f, -0.01773074f, 0.04295592f, 
    -0.00320800f, 0.08204678f, -0.18813290f, -0.29540250f, 0.02275869f, 0.04656699f, 0.04676465f, 0.06141459f, 
    0.02240800f, -0.10646258f, 0.00202071f, -0.01558250f, 0.03375519f, 0.03019273f, -0.12454990f, -0.05320502f, 
    0.06691522f, -0.04266632f, 0.02238171f, 0.07835406f, 0.04070132f, 0.05661261f, -0.03325811f, 0.07267473f, 
    -0.36172083f, 0.11038720f, 0.19989951f, 0.21991667f, 0.02409032f, -0.01648636f, 0.01359714f, 0.05548282f, 
    -0.06589208f, 0.03693375f, -0.03396592f, 0.00321037f, -0.19663985f, 0.11798592f, 0.01260653f, 0.03731332f, 
    0.02735250f, 0.04372958f, 0.04581864f, 0.09545275f, 0.13915008f, 0.02038741f, -0.05774282f, 0.02377016f, 
    -0.00556008f, 0.19997896f, 0.08389920f, -0.15061297f, 0.03638522f, 0.10614739f, 0.02319624f, -0.02284140f, 
    0.06815733f, -0.01097430f, -0.05271012f, 0.11650525f, 0.00663238f, 0.01755167f, -0.10259911f, -0.22132744f, 
    0.08766024f, -0.01365276f, 0.05571197f, -0.01676476f, -0.05699248f, -0.20835143f, 0.15671070f, 0.04012252f, 
    -0.03231465f, -0.02337606f, 0.04415134f, 0.15472898f, -0.07080602f, -0.11096895f, 0.08276782f, 0.01755302f, 
    -0.00906242f, -0.05375499f, 0.10081834f, 0.08067457f, -0.10996222f, 0.05089527f, 0.00066088f, -0.00244107f, 
    0.07628396f, -0.01971634f, 0.02784408f, 0.00636347f, 0.04037626f, -0.02548419f, -0.06833123f, 0.00473900f, 
    -0.39339188f, 0.10074241f, -0.13178501f, -0.18027797f, -0.07592758f, 0.01161783f, 0.06955846f, -0.08487558f, 
    0.00898325f, -0.02080077f, -0.06949491f, -0.01815282f, -0.07852526f, 0.03262831f, 0.12717864f, -0.02329158f, 
    0.06785282f, 0.03851439f, -0.03030434f, 0.05675494f, -0.01312592f, -0.02967770f, -0.04513764f, -0.01274174f, 
    -0.21101856f, 0.05643697f, 0.13146903f, -0.06260766f, -0.01869681f, 0.00502597f, -0.04630111f, -0.04883821f, 
    -0.08556533f, 0.02208829f, 0.02942829f, -0.03069874f, -0.07091284f, -0.09594611f, 0.10607833f, -0.22606184f, 
    0.07495857f, 0.02219498f, -0.09912215f, -0.00022922f, 0.10092457f, 0.00274763f, 0.01140971f, -0.09743693f, 
    -0.90611374f, 0.01439349f, -0.04224509f, 0.11448415f, 0.03335690f, -0.05495201f, 0.01460986f, -0.00647946f, 
    -0.10125873f, -0.05640561f, 0.07759899f, 0.05082967f, -0.30258831f, -0.05714675f, 0.10770240f, 0.16634950f, 
    -0.11778918f, 0.06652296f, -0.08542410f, -0.01066245f, -0.06058380f, 0.00229595f, -0.00706121f, -0.03893438f, 
    -0.40260103f, 0.11661423f, 0.12132459f, 0.00015163f, 0.03554858f, 0.05486878f, -0.08411741f, 0.04360799f, 
    0.11104891f, -0.07212207f, -0.12527259f, -0.04073522f, 0.07477885f, 0.21992534f, -0.15815835f, -0.11315208f, 
    0.03058960f, -0.01963070f, -0.04091882f, 0.09536940f, -0.04874508f, 0.04405066f, -0.06342431f, -0.06570680f, 
    -0.05083957f, 0.12915182f, 0.03198968f, 0.07772439f, 0.02141669f, -0.05742574f, -0.02733127f, 0.05157185f, 
    0.04705044f, -0.10433018f, 0.01156037f, -0.02474510f, -0.02651508f, -0.12588888f, 0.07541189f, -0.07281907f, 
    -0.08044288f, 0.10008950f, -0.01607653f, 0.08226968f, 0.00758754f, -0.02613599f, -0.00623533f, 0.10423138f, 
    -0.25059667f, -0.15509433f, 0.24039780f, -0.09747521f, 0.00123602f, 0.08794547f, 0.06300734f, -0.00053897f, 
    -0.03695777f, 0.05041335f, -0.07178760f, 0.05715829f, 0.06890456f, -0.22252427f, 0.15387437f, 0.00088706f, 
    -0.02839274f, 0.07468405f, 0.02354321f, -0.07896060f, 0.03159356f, 0.11560976f, 0.06567871f, -0.03291585f, 
    -0.06673089f, -0.09121557f, -0.01659692f, 0.13420947f, 0.03173609f, 0.05345603f, 0.10746142f, -0.01227689f, 
    -0.05832130f, 0.02522533f, -0.01351616f, 0.04998387f, 0.11155988f, -0.04992180f, 0.14319327f, 0.07026891f, 
    -0.08239727f, 0.00814793f, 0.00723757f, 0.01018637f, 0.06263713f, 0.16410206f, 0.02687301f, -0.01656005f, 
    0.20315005f, 0.02932264f, 0.01281213f, 0.10754768f, -0.15094215f, 0.04872410f, -0.02777090f, 0.05828161f, 
    0.00968631f, 0.04670414f, 0.03208911f, 0.12831815f, -0.14253402f, 0.12688103f, -0.05048819f, 0.17146882f, 
    0.03493221f, 0.08959721f, -0.07778099f, 0.07803386f, 0.02515855f, 0.02741584f, 0.03164913f, -0.05315534f, 
    0.15236165f, 0.14976414f, -0.04015843f, 0.09100093f, -0.03323168f, 0.00604770f, 0.00137587f, 0.00895802f, 
    -0.00569872f, -0.10054171f, 0.06643371f, 0.02660352f, -0.31550685f, 0.07420969f, 0.15371445f, -0.03875378f, 
    0.05322855f, 0.02497712f, -0.20947570f, -0.03896327f, 0.04223093f, -0.02103957f, -0.01071863f, -0.05456294f, 
    -0.20821741f, 0.10084764f, 0.00976385f, 0.25089324f, 0.10833983f, 0.04470976f, -0.02284495f, 0.10005382f, 
    0.00382759f, 0.10664576f, 0.09690166f, -0.09855931f, 0.02421909f, 0.09359960f, 0.10499585f, -0.36921784f, 
    0.00696922f, 0.02629705f, -0.14874133f, 0.01238166f, -0.03793996f, -0.11327046f, -0.11238098f, 0.01367607f, 
    -0.07916813f, -0.00399884f, 0.19856037f, 0.10878498f, -0.03614205f, -0.02011407f, 0.03532534f, -0.07977957f, 
    -0.00444128f, 0.06203913f, -0.12948081f, -0.09833118f, 0.04698032f, 0.22920758f, 0.06540084f, 0.07263289f, 
    -0.06049253f, 0.02311708f, -0.00477726f, 0.04687269f, -0.05383719f, -0.04547273f, -0.09231942f, -0.09177563f, 
    -0.29694667f, 0.04451202f, -0.10523152f, -0.03608262f, 0.03894880f, -0.02834950f, 0.04823042f, -0.03945742f, 
    -0.05152151f, 0.05268354f, -0.05590744f, 0.07974193f, -0.16097601f, 0.02710106f, 0.02857593f, -0.11940863f, 
    -0.07220177f, 0.08975963f, 0.12633008f, -0.08094183f, -0.03900279f, 0.09942711f, 0.03666948f, -0.09600621f, 
    -0.18945083f, -0.24825607f, 0.15470879f, 0.04469602f, 0.21877114f, 0.01780519f, -0.21611400f, -0.06491464f, 
    0.02032769f, -0.02463453f, 0.02975344f, 0.05360949f, -0.35450917f, 0.09208624f, -0.27248496f, -0.19205037f, 
    -0.06985793f, -0.06405750f, 0.07690638f, 0.04099771f, 0.02439284f, 0.04557659f, -0.04781632f, -0.00714114f, 
    -0.08706066f, -0.07017435f, -0.04214102f, -0.10472604f, -0.04317178f, -0.06038144f, -0.05833983f, -0.00416213f, 
    -0.06317470f, -0.07924064f, -0.08711043f, 0.08595721f, 0.15549999f, 0.11515066f, -0.07745320f, 0.12055567f, 
    0.07361667f, 0.06309234f, 0.13211007f, 0.13890353f, 0.04013944f, -0.02909109f, 0.07392231f, 0.03814000f, 
    0.08915466f, 0.03215991f, 0.03572173f, 0.15678570f, -0.01813685f, 0.05704135f, 0.04850706f, -0.01313525f, 
    0.03790263f, -0.05179760f, 0.00110188f, 0.09524468f, -0.04084078f, 0.17815113f, -0.18790947f, -0.22854665f, 
    0.06227132f, -0.00101430f, 0.01105309f, 0.09106586f, 0.02315326f, -0.06583175f, -0.07927966f, -0.01714368f, 
    0.06791642f, -0.12666686f, -0.01901248f, -0.06279990f, -0.08771434f, 0.22246650f, 0.05420460f, 0.07065903f, 
    0.15227754f, -0.14464210f, 0.07465004f, 0.01517087f, 0.02347296f, -0.40853485f, -0.18861379f, -0.04845662f, 
    -0.04342907f, -0.02942034f, -0.05788750f, -0.03028104f, 0.06544285f, 0.04615105f, -0.08224085f, -0.07275460f, 
    0.05937421f, 0.09645900f, 0.08240643f, -0.08029248f, -0.00722789f, -0.06090878f, -0.06362038f, -0.00166952f, 
    -0.06976634f, 0.04455943f, -0.03548873f, -0.06784177f, -0.06681450f, -0.01222951f, -0.11474329f, 0.12667507f, 
    0.00766389f, -0.05606105f, 0.01424904f, 0.09000444f, 0.06357009f, -0.10356441f, 0.10101630f, -0.12722439f, 
    -0.20851567f, -0.03876787f, 0.00159782f, 0.09207381f, 0.03819024f, -0.03232187f, 0.11724446f, 0.06172250f, 
    -0.02740429f, 0.05637329f, 0.10329697f, 0.07980058f, -0.60331011f, 0.06307805f, -0.03761008f, 0.07417247f, 
    0.07909808f, -0.06974786f, 0.09521994f, -0.08934498f, -0.05607919f, 0.02831011f, -0.02170302f, -0.00210154f, 
    0.24452929f, -0.07003202f, 0.08215887f, 0.06918589f, -0.01449827f, -0.00729847f, 0.03139224f, 0.05302123f, 
    0.08059592f, -0.00494014f, -0.01224402f, -0.01349569f, -0.07900701f, 0.08367492f, 0.05516348f, 0.07530719f, 
    -0.05072906f, -0.06178015f, 0.00799165f, 0.06777348f, 0.00507542f, 0.01016901f, 0.00190506f, -0.07546947f, 
    -0.03380668f, -0.20757839f, 0.02016610f, -0.29453945f, 0.01669804f, 0.05574046f, 0.01857348f, 0.10355202f, 
    -0.03489809f, 0.05811998f, -0.02526869f, 0.01490788f, 0.04407682f, 0.23044842f, 0.00414971f, 0.01051818f, 
    0.00930833f, 0.13643435f, 0.06147244f, -0.02645203f, 0.05303991f, 0.02037091f, -0.03636240f, -0.00136761f, 
    -0.07458884f, -0.04309158f, 0.20838290f, 0.05501844f, 0.01411362f, -0.02938614f, -0.12668964f, 0.05204166f, 
    0.02848412f, 0.09037106f, 0.11444705f, 0.07350805f, -0.14455581f, -0.20909403f, 0.11336609f, 0.08706008f, 
    -0.05174185f, -0.01691953f, -0.10755139f, -0.18741435f, 0.06819548f, -0.05752241f, -0.04430866f, -0.11834211f, 
    -0.10025285f, 0.10101122f, -0.20187414f, -0.01153510f, -0.04111467f, -0.07450289f, -0.02655647f, -0.09361363f, 
    0.06043847f, -0.09522840f, -0.00653230f, 0.08440290f, -0.06394247f, 0.00522107f, -0.01230637f, -0.00741372f, 
    0.04934897f, 0.01775039f, -0.07066661f, -0.11525352f, -0.02332609f, -0.00413509f, -0.00098488f, 0.11549477f, 
    0.06180155f, 0.17933086f, -0.01295198f, -0.05182455f, -0.06206774f, 0.05140124f, 0.09772600f, 0.11099137f, 
    -0.03757561f, 0.03039098f, 0.05023674f, 0.15511273f, 0.32858664f, 0.16356823f, -0.10570415f, -0.21484737f, 
    0.02387586f, 0.02317633f, 0.05679895f, 0.00373075f, -0.11511865f, 0.14870943f, -0.02508666f, 0.04735472f, 
    -0.21493076f, -0.30166945f, 0.04587581f, 0.07871027f, 0.05476679f, -0.02831227f, 0.02774036f, -0.23464301f, 
    -0.16358113f, -0.07951684f, -0.01188861f, -0.05034576f, 0.03547818f, 0.08491642f, -0.09660791f, -0.02892965f, 
    0.04834896f, 0.06027123f, -0.03207574f, 0.11025359f, -0.14028385f, -0.14717327f, 0.12349574f, -0.15529683f, 
    -0.27002040f, 0.02802178f, -0.08172141f, 0.05886662f, -0.01370679f, 0.00282221f, 0.04874486f, -0.00523903f, 
    -0.00093858f, -0.14727290f, -0.01414638f, 0.05971805f, 0.19619866f, -0.12648788f, -0.05154702f, -0.08252218f, 
    0.04114184f, 0.19859190f, 0.07486157f, 0.08571342f, 0.07957717f, -0.12098767f, 0.02513039f, 0.04333810f, 
    -0.23572667f, -0.12765704f, 0.08166722f, -0.06357444f, 0.02508598f, 0.01413357f, 0.08125924f, 0.15975897f, 
    -0.06875208f, -0.12606208f, 0.05589748f, -0.01118512f, 0.06138984f, -0.01322592f, 0.12176336f, 0.00410228f, 
    -0.02802314f, -0.03781067f, 0.07571033f, 0.00940939f, -0.07534167f, 0.01014319f, 0.03410907f, 0.10629624f, 
    -0.22109345f, -0.37110212f, 0.28542590f, 0.37075949f, -0.00818317f, 0.00516954f, -0.00569215f, -0.00537899f, 
    0.04158555f, 0.08717489f, -0.00709887f, 0.02149193f, 0.05949137f, 0.09810142f, 0.05400776f, 0.18101904f, 
    -0.09315836f, -0.02691322f, 0.01230618f, 0.09507815f, -0.00156636f, -0.07482333f, -0.09320048f, -0.19690232f, 
    0.05775509f, 0.07116228f, 0.06142567f, 0.00121213f, -0.01036771f, -0.06205751f, 0.00066179f, 0.02579458f, 
    0.05441470f, -0.06672547f, 0.03695811f, -0.00820445f, 0.03480657f, -0.13816275f, 0.07260837f, 0.23757708f, 
    0.05752937f, 0.04103173f, 0.06735492f, 0.00137351f, 0.03544345f, -0.01179590f, -0.05853548f, 0.25186414f, 
    -0.33632571f, -0.04973042f, 0.07257847f, 0.14729159f, -0.01779429f, -0.02298428f, 0.19709985f, 0.03113719f, 
    0.15714484f, 0.03610241f, 0.02986197f, -0.07764866f, -0.04903880f, -0.24414618f, -0.13005626f, 0.00734017f, 
    0.05288422f, -0.03176231f, -0.03135553f, -0.10322710f, 0.05420568f, 0.07940273f, 0.00141278f, 0.26570162f, 
    -0.19126190f, -0.09787359f, -0.19702651f, -0.04180892f, -0.00912143f, 0.05306689f, -0.11992753f, -0.05858403f, 
    0.04478500f, -0.14217094f, -0.04087810f, 0.01043842f, -0.36607826f, -0.11316550f, -0.12841570f, -0.11399831f, 
    0.02663887f, 0.06418744f, -0.07051978f, -0.22381343f, 0.00641777f, 0.03355218f, -0.00571593f, 0.02452260f, 
    -0.06594650f, -0.06790969f, 0.23399912f, 0.18194637f, 0.04885317f, -0.03845040f, -0.12871131f, 0.07180019f, 
    -0.08418986f, 0.09562065f, 0.07143328f, -0.10855594f, -0.22375321f, -0.05513763f, 0.11769478f, -0.12300639f, 
    0.01516331f, 0.00422732f, 0.14447768f, 0.00882635f, 0.01162403f, 0.20216838f, -0.02501207f, -0.04821344f, 
    0.23422705f, -0.08941649f, -0.01900250f, -0.04910728f, 0.15653670f, 0.06195153f, -0.15765117f, -0.21903902f, 
    -0.09406853f, 0.00778010f, -0.00255528f, -0.08956238f, -0.23423766f, -0.08375598f, 0.00130645f, 0.08658640f, 
    0.02525368f, 0.04372374f, -0.04057910f, 0.05098654f, 0.00202000f, 0.02513902f, 0.03631912f, 0.12356042f, 
    -0.24754244f, 0.05726770f, 0.10016793f, -0.46804014f, 0.03219824f, 0.03199420f, 0.06671110f, -0.11372474f, 
    -0.08209731f, 0.11337177f, 0.02085954f, 0.01602367f, 0.12637231f, -0.03613567f, 0.05966603f, -0.14859268f, 
    -0.03862927f, 0.03059770f, -0.06562959f, -0.02653178f, 0.02907943f, -0.04290095f, 0.11863217f, -0.07187901f, 
    -0.00160478f, 0.07803125f, -0.03567960f, 0.26421320f, 0.01688180f, 0.13311930f, 0.14459454f, 0.14669859f, 
    0.04564888f, 0.05387877f, -0.18438350f, -0.11107641f, -0.21968225f, 0.03121733f, 0.16166042f, 0.08784785f, 
    -0.11172345f, -0.06993037f, -0.01266239f, -0.09449188f, 0.06501703f, 0.04255635f, 0.10193338f, 0.11341834f, 
    -0.19270074f, 0.26086295f, -0.12763266f, -0.32384390f, 0.02320505f, -0.01252686f, 0.00792025f, 0.09181271f, 
    -0.05267693f, -0.07434081f, -0.03398439f, -0.29248068f, 0.06466237f, 0.04011263f, 0.04906588f, 0.26282308f, 
    -0.10952254f, -0.09789859f, 0.04374318f, 0.03947777f, -0.11456771f, -0.10021640f, -0.04416522f, 0.20138809f, 
    0.09937363f, -0.12993434f, -0.09679117f, -0.05004138f, -0.09571487f, 0.05853019f, 0.06176469f, -0.03290823f, 
    -0.14930256f, 0.16130345f, 0.03796395f, 0.20577684f, -0.25848970f, -0.11537018f, -0.00896965f, 0.16938320f, 
    0.00868443f, -0.06621581f, -0.05864640f, -0.20984617f, 0.06132673f, 0.07670139f, -0.02856495f, 0.04002551f, 
    -0.01587654f, -0.08038347f, 0.22135150f, 0.07244054f, -0.02118996f, 0.12865634f, 0.03611553f, -0.01572202f, 
    -0.00929133f, 0.07990248f, 0.07189748f, 0.10213799f, -0.06626370f, 0.06864646f, 0.13100423f, 0.04751124f, 
    0.03288460f, 0.05850137f, 0.07962553f, 0.05124136f, -0.08012905f, -0.01788806f, -0.11698375f, 0.01431035f, 
    0.21343690f, 0.12218238f, -0.03420267f, -0.01686102f, -0.08301868f, -0.00263938f, -0.19601154f, -0.04873777f, 
    0.07537345f, -0.03884687f, 0.08883449f, -0.11592658f, 0.15532379f, 0.08678596f, -0.00338909f, 0.01566179f, 
    -0.07074377f, 0.05865466f, 0.01714760f, -0.15823430f, -0.14352392f, 0.03508688f, -0.17632160f, -0.00016802f, 
    -0.04749633f, -0.10884617f, -0.07282332f, 0.07762852f, 0.20201869f, -0.00495618f, -0.02105346f, 0.06528165f, 
    0.06356946f, 0.19600070f, -0.03245468f, -0.15759188f, 0.09849171f, -0.01565182f, 0.13086282f, -0.21787344f, 
    -0.11587103f, 0.04710923f, 0.04098707f, -0.02059868f, -0.00877444f, -0.14300500f, 0.06232155f, -0.10873508f, 
    0.18982023f, -0.09451341f, 0.07248970f, 0.01282813f, -0.04591144f, -0.09153499f, 0.02337473f, -0.10887381f, 
    -0.02343820f, -0.02110840f, 0.01467012f, -0.05140903f, -0.24665187f, -0.03890663f, -0.10099894f, -0.13325177f, 
    0.01401568f, 0.01517485f, 0.05832476f, -0.11225361f, 0.03818471f, 0.05778956f, 0.08430069f, -0.05299189f, 
    -0.15730678f, -0.42336729f, 0.07933480f, 0.06695792f, 0.14842401f, -0.06003657f, -0.05683208f, -0.10310406f, 
    0.05422159f, -0.03291313f, 0.10284353f, 0.04617815f, -0.01544193f, 0.13583370f, 0.03782914f, 0.23578051f, 
    -0.06492354f, -0.01119892f, 0.10090827f, 0.04968991f, 0.01674763f, 0.03321026f, -0.00146002f, 0.04325596f, 
    -0.31035224f, -0.00422327f, -0.09349106f, -0.00640678f, 0.06257045f, -0.03860825f, 0.02136153f, 0.00761011f, 
    -0.01773124f, 0.07264878f, -0.13795355f, 0.02382657f, -0.23862845f, -0.18540050f, 0.02144337f, 0.17342232f, 
    0.01259493f, -0.15483740f, 0.09392038f, 0.05856646f, -0.05454104f, -0.08874675f, -0.02666391f, 0.09981671f, 
    0.20154792f, -0.03450998f, -0.08245128f, -0.10737998f, -0.21659999f, -0.10673562f, -0.01255838f, 0.02408803f, 
    0.01837259f, -0.04833224f, 0.03497341f, 0.24878037f, -0.10684451f, -0.09285773f, -0.04608002f, 0.05594853f, 
    0.04385731f, -0.06287599f, -0.01522902f, 0.03989659f, 0.11013325f, -0.00146499f, 0.07241629f, 0.01555354f, 
    -0.24093691f, -0.12449781f, -0.13420774f, -0.16589530f, 0.12907305f, -0.08468673f, 0.02752154f, -0.03577795f, 
    0.00463836f, 0.14969856f, -0.02768437f, 0.02609682f, 0.11726514f, 0.07999618f, 0.01878670f, -0.06322408f, 
    0.01402153f, -0.03249656f, -0.10037145f, 0.10463364f, -0.13692600f, -0.15220024f, 0.05482060f, 0.08185918f, 
    0.14647403f, 0.03419678f, -0.23874409f, -0.03866729f, 0.07316888f, -0.04067713f, 0.27412778f, 0.02043772f, 
    0.07063456f, 0.02037835f, -0.13639432f, -0.23946495f, -0.41803968f, 0.29959977f, 0.10094757f, 0.14789681f, 
    0.09478123f, -0.05073108f, -0.08115176f, -0.12541394f, -0.01967382f, -0.08832307f, 0.08977170f, -0.09481997f, 
    -0.00632448f, 0.11106481f, 0.15719365f, 0.05268735f, -0.08292688f, 0.10768580f, 0.11363721f, -0.05970877f, 
    -0.01353065f, -0.07835581f, 0.11211424f, -0.09270947f, -0.25732693f, -0.14756045f, 0.02227028f, -0.03376538f, 
    0.07021028f, 0.12541540f, -0.09909454f, -0.10940229f, -0.04223744f, -0.00440700f, -0.07624856f, 0.09304973f, 
    -0.05684594f, -0.08768690f, -0.06273444f, -0.08541501f, 0.07910568f, -0.05870910f, 0.03513748f, -0.01535184f, 
    0.04631421f, 0.13208403f, 0.01985526f, -0.10709877f, -0.29404700f, -0.06534427f, 0.05789727f, -0.03114366f, 
    -0.06120195f, 0.07322554f, -0.01317279f, -0.02892567f, -0.03919020f, 0.02448960f, 0.06756380f, -0.04671811f, 
    -0.03136070f, 0.05882886f, -0.00406069f, -0.01711786f, -0.00098199f, -0.05365489f, -0.03909822f, 0.04937973f, 
    0.06325737f, 0.09132437f, -0.06304962f, 0.04756512f, 0.04647233f, 0.14336577f, 0.20764492f, 0.03052605f, 
    0.01110746f, 0.00390637f, -0.08945307f, 0.01327980f, 0.04693873f, -0.11002703f, -0.07116364f, 0.07959464f, 
    -0.11826115f, -0.03044605f, -0.00264872f, -0.04286017f, 0.00935989f, 0.05027438f, -0.00424393f, -0.01862351f, 
    -0.05195321f, -0.04685066f, 0.00609813f, 0.17113706f, 0.07590350f, -0.12865455f, -0.02632215f, 0.05888174f, 
    0.02676459f, -0.10406571f, -0.10440317f, -0.03338781f, -0.08989276f, 0.04359549f, 0.00594941f, 0.13937478f, 
    -0.08481781f, -0.17021593f, -0.10061918f, 0.02923937f, 0.13148889f, 0.03357233f, 0.03856643f, -0.02463107f, 
    -0.11115247f, -0.17991462f, 0.07617608f, -0.16127452f, -0.36824855f, 0.17899336f, -0.08121644f, -0.14233536f, 
    -0.04984148f, -0.01053522f, -0.00204224f, -0.04177467f, -0.04151280f, -0.11051770f, -0.03880979f, -0.02766893f, 
    -0.02951342f, -0.01311086f, 0.09299888f, -0.11989256f, 0.04287389f, -0.09262414f, -0.05421269f, 0.02593102f, 
    -0.00899232f, 0.00698596f, 0.07523818f, 0.26671496f, 0.04202886f, -0.00701036f, 0.17788883f, -0.12904176f, 
    0.01505598f, 0.06394749f, -0.00204327f, 0.06204427f, -0.04272635f, 0.00639353f, -0.03212925f, 0.09504049f, 
    0.25341466f, -0.03984777f, -0.11137773f, -0.09962907f, 0.03104795f, 0.05469657f, -0.14800005f, 0.13989238f, 
    0.05138788f, -0.03446753f, 0.09672570f, -0.07019142f, -0.23339513f, 0.09977552f, 0.07390635f, -0.12307846f, 
    -0.03567829f, -0.03353572f, -0.04337622f, 0.02278258f, 0.10389762f, -0.01305171f, 0.05968734f, -0.04752787f, 
    0.01145474f, 0.04468601f, -0.46330497f, -0.02099794f, 0.04375102f, 0.01331337f, 0.04082839f, 0.02919566f, 
    -0.00571040f, -0.16720259f, -0.00538004f, 0.05079338f, 0.27654058f, 0.14720398f, 0.14105037f, 0.09991504f, 
    -0.07816893f, 0.06514667f, 0.07213314f, 0.06701508f, -0.09564818f, 0.04906204f, 0.13124184f, 0.12190336f, 
    -0.07067467f, 0.15516609f, 0.04050472f, 0.01225144f, 0.04750309f, 0.07776703f, 0.10318578f, -0.19157337f, 
    0.06342167f, -0.09757001f, -0.06291018f, 0.08656818f, -0.05862269f, 0.01326196f, 0.00909455f, 0.06015242f, 
    -0.13430174f, 0.05070263f, -0.00468458f, 0.02715969f, -0.03737976f, -0.09703382f, 0.02100361f, -0.00123450f, 
    0.04407923f, -0.07740472f, 0.14978704f, 0.06352382f, 0.09662772f, 0.00976880f, -0.03176858f, -0.05510392f, 
    -0.03469826f, -0.03665462f, -0.06136225f, -0.06851806f, -0.24279676f, -0.18515103f, 0.11065388f, 0.21092778f, 
    0.04965067f, -0.02941894f, 0.00710364f, -0.02364881f, -0.12362219f, -0.10560232f, 0.09772319f, -0.12076972f, 
    -0.02330585f, -0.18584764f, -0.00194577f, -0.13818733f, -0.00700093f, -0.14875214f, 0.03870777f, -0.08125587f, 
    0.23745118f, -0.15022983f, -0.02242834f, -0.06663375f, -0.08671337f, 0.03432012f, -0.02848177f, -0.20938724f, 
    0.02827313f, -0.06620751f, 0.13296710f, 0.16692518f, 0.14375974f, 0.10321238f, -0.11687351f, -0.00129953f, 
    -0.43897259f, 0.04766981f, -0.11346081f, -0.29339221f, 0.07531565f, 0.07348230f, 0.02974737f, 0.03291300f, 
    0.01971520f, -0.08484320f, -0.08491116f, -0.03299748f, -0.00296365f, 0.23556389f, 0.21077669f, -0.14760794f, 
    -0.03589954f, -0.00384394f, -0.10033986f, -0.04233220f, -0.09969679f, 0.11990817f, -0.19483620f, -0.06488695f, 
    -0.19599974f, -0.06648415f, -0.19195904f, 0.05633732f, 0.08575294f, 0.12089127f, 0.01486353f, 0.09670638f, 
    0.10492977f, -0.00459093f, 0.01565415f, -0.06179766f, -0.12091015f, -0.27096522f, 0.02524048f, 0.21323089f, 
    0.03887251f, 0.02557823f, 0.07207262f, 0.01211576f, -0.01288148f, 0.12495289f, 0.03930213f, -0.03305438f, 
    -0.06450379f, -0.06680204f, -0.03422954f, 0.17343037f, 0.06344043f, -0.03309556f, -0.00218004f, -0.05716829f, 
    0.03579366f, -0.06701995f, -0.17763120f, -0.05682082f, 0.05697285f, -0.18423498f, -0.04300132f, -0.14367034f, 
    0.07342134f, -0.02067007f, -0.00272743f, 0.04783660f, -0.11699537f, 0.07272884f, 0.11085968f, 0.03158841f, 
    -0.12239634f, 0.25714192f, -0.06306349f, 0.08581768f, 0.03169912f, 0.11704371f, 0.00239324f, 0.09706175f, 
    0.02908030f, 0.09008438f, -0.07777133f, 0.02673507f, -0.11325149f, -0.00856794f, -0.09285793f, 0.20934184f, 
    0.04692384f, 0.05828072f, -0.03890033f, -0.07499025f, 0.08555516f, 0.00392410f, 0.02095716f, -0.26373056f, 
    0.29384989f, -0.10433598f, 0.12510166f, -0.06558627f, -0.00802489f, -0.11915620f, -0.07275838f, -0.09843862f, 
    -0.15717739f, -0.05035312f, -0.01675362f, 0.04083030f, -0.01612587f, 0.05086048f, 0.16103029f, -0.04394110f, 
    0.02487251f, 0.07646822f, 0.06531864f, -0.15970841f, 0.02057996f, -0.06974849f, -0.00629066f, -0.09356868f, 
    -0.10415455f, -0.04844435f, -0.12964198f, 0.00001486f, -0.02772091f, 0.02785379f, 0.01879778f, -0.07032874f, 
    0.04861276f, 0.04194820f, 0.00580674f, -0.00870026f, -0.19393218f, -0.34950772f, -0.08614952f, 0.09137587f, 
    -0.01829051f, -0.00821952f, 0.09757342f, 0.16375779f, -0.00461180f, -0.00952443f, -0.02839724f, 0.11896785f, 
    0.24169116f, -0.09089252f, -0.02735866f, -0.18687993f, 0.01556388f, 0.01407671f, 0.09172190f, 0.04726875f, 
    0.02947485f, -0.00892475f, -0.04774319f, -0.04845674f, 0.04075395f, 0.02707428f, -0.01679622f, 0.19207360f, 
    -0.03038576f, 0.07430587f, -0.12704979f, -0.09904829f, 0.11100762f, 0.01493671f, 0.01103113f, -0.05340630f, 
    0.09055023f, -0.00136791f, -0.30329329f, 0.18379238f, -0.15397528f, -0.11206852f, 0.04008930f, -0.01331059f, 
    0.01887098f, -0.06958441f, -0.09728552f, 0.01743943f, -0.04680355f, 0.04920509f, -0.10121463f, -0.24444093f, 
    -0.06836209f, 0.07414596f, -0.15085770f, -0.02028562f, 0.13412265f, -0.10092644f, -0.02842975f, -0.00768909f, 
    0.31939346f, -0.16709135f, -0.06598147f, -0.00690753f, -0.05056170f, 0.03917703f, 0.05500278f, 0.00396802f, 
    0.06243244f, 0.02975881f, -0.01853993f, -0.17182378f, -0.24170946f, 0.06813546f, 0.10111710f, 0.15260674f, 
    -0.07081880f, 0.01732353f, -0.00798962f, 0.03719299f, 0.03254703f, 0.03302665f, 0.00868459f, 0.17311765f, 
    0.03334843f, 0.03341244f, -0.08180758f, -0.13058685f, 0.10505275f, 0.01445837f, 0.11615261f, -0.05921455f, 
    -0.17945005f, 0.21957791f, 0.17407206f, 0.06435587f, 0.08241174f, 0.09662200f, 0.00792559f, 0.28030160f, 
    0.02789831f, -0.02152219f, 0.08216069f, -0.00519487f, 0.00125928f, -0.05997405f, -0.13350184f, -0.02544457f, 
    0.12595597f, -0.47689405f, -0.01368725f, -0.21613514f, 0.04849152f, 0.09493537f, 0.02990341f, -0.08196365f, 
    0.07342705f, 0.00948217f, 0.08031576f, 0.19568890f, -0.00004099f, 0.14260833f, 0.00498459f, -0.22024347f, 
    0.02501057f, 0.03374374f, -0.02187648f, -0.05946036f, -0.03214591f, -0.00524870f, -0.02069484f, 0.06695434f, 
    0.18802382f, 0.02708732f, 0.09369183f, -0.24560446f, -0.01477931f, 0.11300442f, 0.08292455f, -0.00909143f, 
    0.12040112f, -0.21077526f, -0.01932624f, -0.09190301f, 0.33743671f, -0.17835476f, -0.07093175f, 0.20927802f, 
    -0.19190849f, 0.04099308f, 0.05270122f, 0.05793125f, -0.13406560f, -0.03492842f, 0.03071381f, -0.17847058f, 
    0.01561877f, 0.03168263f, 0.11449447f, -0.18113320f, -0.04687680f, -0.02379273f, -0.01265711f, 0.07729477f, 
    0.02522281f, -0.01225366f, 0.01925713f, -0.10844178f, 0.17624363f, 0.02189692f, 0.10474916f, 0.15554802f, 
    0.05742353f, -0.06998706f, -0.01216114f, 0.09327098f, 0.00781627f, 0.07747684f, 0.02801114f, -0.01151023f, 
    0.16209818f, -0.08873933f, 0.14547755f, -0.07063386f, 0.10963851f, -0.01193056f, 0.02807594f, 0.15835497f, 
    -0.01578418f, 0.02555090f, -0.01926865f, 0.05522148f, -0.46716896f, 0.20143260f, 0.08587186f, 0.09386298f, 
    -0.05040426f, 0.08850584f, -0.07794368f, 0.19989464f, 0.04660498f, -0.03105190f, 0.09530461f, 0.01972886f, 
    -0.05185524f, -0.01641042f, -0.23284738f, -0.22094870f, -0.10394575f, -0.03434180f, -0.17516842f, -0.06897809f, 
    -0.13983725f, -0.00380778f, 0.02010580f, -0.09059823f, -0.31611294f, 0.22951320f, 0.17610124f, -0.00239880f, 
    0.04489683f, -0.03133591f, -0.05112650f, 0.04799348f, -0.05494722f, 0.14152771f, 0.00842320f, -0.11360441f, 
    -0.35499129f, -0.04922771f, 0.04485523f, 0.05598517f, 0.12843484f, 0.02919262f, -0.06081537f, -0.01583826f, 
    -0.09847670f, 0.06662241f, -0.02848400f, 0.10089657f, -0.15311885f, -0.14579062f, -0.09197169f, -0.20463318f, 
    -0.06824151f, 0.09040722f, -0.02012229f, -0.06566250f, -0.05337724f, 0.14337850f, -0.08507252f, 0.10706139f, 
    -0.09601827f, -0.05320198f, -0.01346588f, -0.16969675f, -0.05014092f, -0.09612292f, -0.00214084f, 0.04015491f, 
    -0.03747569f, 0.02488756f, -0.00987486f, -0.03372924f, -0.21847478f, -0.06414744f, -0.04947449f, 0.06160607f, 
    0.09581247f, -0.07004775f, -0.02396626f, -0.01962011f, 0.01583483f, -0.00876118f, 0.10781262f, -0.11112624f, 
    -0.08261380f, 0.04706658f, -0.12671618f, -0.25894457f, -0.00642550f, -0.04034466f, 0.04060538f, -0.13847876f, 
    -0.05285485f, -0.05348356f, 0.02693577f, -0.06510014f, -0.18418871f, -0.16357280f, 0.09672374f, 0.06886229f, 
    0.02814733f, 0.19366324f, 0.06681124f, -0.10100949f, -0.05284432f, -0.01524086f, 0.02706603f, 0.01077157f, 
    0.00390753f, 0.13839942f, 0.05470020f, -0.10614537f, 0.10469645f, 0.16195127f, -0.02387604f, -0.08367858f, 
    -0.10544834f, -0.01764737f, -0.12356301f, -0.21365494f, -0.04698205f, -0.28249282f, 0.07605586f, 0.09531047f, 
    0.03190332f, 0.09146544f, 0.14291087f, -0.08967456f, 0.01554262f, -0.03314938f, 0.03497666f, -0.15042910f, 
    0.03822280f, 0.02504281f, 0.00373696f, 0.03400409f, -0.16483866f, 0.03496216f, 0.05105205f, 0.12781556f, 
    0.07712412f, -0.00058098f, -0.04653309f, -0.06573696f, 0.07402922f, 0.03896516f, 0.22224484f, 0.20986791f, 
    0.08187641f, -0.02087219f, -0.08707870f, -0.08972625f, 0.05762070f, -0.05025980f, -0.00062780f, 0.08386116f, 
    -0.10645875f, -0.08746002f, 0.08595622f, -0.00208422f, 0.07958121f, -0.05646197f, -0.06294700f, 0.01250425f, 
    0.04721469f, 0.06768171f, -0.01930724f, 0.17414603f, 0.18770768f, -0.55296326f, -0.01566297f, -0.09133583f, 
    -0.07600585f, 0.03110296f, -0.01446842f, 0.07338101f, 0.03320027f, 0.07840696f, 0.06017093f, 0.03497405f, 
    0.15843838f, 0.00738982f, 0.00512928f, -0.21894065f, 0.00952028f, -0.03792528f, -0.02760996f, 0.05037516f, 
    0.08723514f, 0.03790039f, -0.09278111f, 0.08171991f, -0.28431788f, -0.13694166f, -0.12344715f, -0.30179656f, 
    -0.01010039f, -0.03094991f, -0.07241201f, -0.01960101f, -0.00757563f, -0.00313845f, 0.04113822f, 0.01702701f, 
    -0.07753426f, -0.11459278f, -0.02185289f, 0.05461294f, -0.09552953f, 0.10193447f, -0.05409758f, -0.01777364f, 
    0.03802915f, -0.11322986f, 0.12758996f, 0.08555925f, 0.17547555f, 0.09741983f, 0.18749636f, -0.03342222f, 
    -0.03269608f, -0.01666130f, 0.13977389f, -0.19543049f, 0.08786792f, 0.04548883f, 0.04705481f, 0.02861573f, 
    0.06371281f, 0.12329128f, 0.07252146f, -0.04982202f, -0.06500157f, 0.00314685f, 0.08659446f, 0.01092011f, 
    -0.11505961f, 0.03422385f, -0.06764296f, -0.07820717f, -0.48141554f, 0.19999871f, 0.14028034f, 0.16684809f, 
    -0.03085694f, -0.04811909f, 0.06079546f, 0.09864777f, -0.07794074f, 0.08828896f, 0.02635953f, -0.07627153f, 
    0.10072905f, -0.07083812f, -0.12410188f, -0.04225310f, -0.07837863f, 0.01502687f, 0.02243861f, 0.00375602f, 
    -0.04639531f, 0.03566343f, 0.08594069f, -0.17015088f, -0.09823646f, -0.02571721f, -0.13318263f, -0.24827138f, 
    0.02454410f, 0.06270493f, 0.10353409f, -0.05382954f, -0.04525728f, -0.19871387f, 0.02641742f, -0.04037273f, 
    -0.02615597f, 0.06785414f, -0.09582622f, -0.15177554f, -0.11749666f, -0.00287473f, -0.07785370f, -0.13901038f, 
    0.01984086f, 0.04771923f, -0.05090529f, 0.22918156f, 0.21391329f, -0.18459560f, 0.22271213f, -0.07516467f, 
    0.08122494f, -0.12332296f, 0.03329418f, -0.01173129f, 0.04403343f, 0.03790651f, 0.09941130f, 0.05853106f, 
    0.07871486f, 0.29945168f, 0.15232013f, -0.55076659f, -0.03140511f, 0.14375469f, 0.02864196f, -0.03461067f, 
    -0.08664788f, 0.00216745f, 0.01119503f, -0.09200628f, -0.26478937f, -0.03661661f, 0.12227125f, -0.11441417f, 
    -0.15126415f, -0.08529960f, 0.02727035f, 0.01540256f, -0.07895368f, -0.08315449f, -0.00001673f, -0.05058238f, 
    0.14297906f, -0.08844286f, 0.16001855f, -0.20509422f, 0.07915075f, -0.03124098f, 0.16677834f, 0.01693761f, 
    0.02454370f, 0.01593092f, -0.08686463f, -0.03901314f, 0.32688627f, 0.15176564f, 0.09776224f, -0.30843624f, 
    -0.05833621f, 0.13770700f, 0.05203179f, 0.03106271f, -0.16232640f, 0.05010491f, 0.07821181f, 0.06927317f, 
    0.10874130f, -0.23317251f, -0.18862705f, -0.00106279f, -0.09617242f, 0.01326088f, -0.03651336f, -0.07649498f, 
    -0.06628399f, 0.02104685f, 0.11874499f, 0.16980337f, -0.08683955f, 0.02325135f, 0.04391907f, -0.13491935f, 
    0.06410930f, -0.00689842f, -0.05935971f, 0.05666410f, -0.11349539f, -0.11380165f, -0.07789418f, -0.10428467f, 
    0.09723893f, -0.33082518f, -0.21789052f, -0.04144427f, -0.00390007f, 0.08332895f, -0.06214310f, 0.12014050f, 
    -0.03663897f, -0.03751034f, -0.04271978f, 0.03827883f, 0.02200388f, -0.00294578f, 0.05569051f, -0.15132089f, 
    0.04183601f, -0.10475499f, 0.09599335f, -0.03921850f, -0.00149516f, -0.01503012f, 0.06313980f, -0.02440519f, 
    -0.03638653f, 0.13140620f, 0.14306739f, -0.22957206f, -0.07583369f, -0.00214706f, 0.13104206f, 0.06167974f, 
    0.01467069f, 0.05085086f, 0.01023731f, 0.06955417f, 0.04428963f, -0.07232913f, -0.09601362f, 0.22455549f, 
    -0.09733232f, 0.01260626f, -0.09634338f, 0.08104713f, 0.05088854f, 0.00730020f, -0.03867371f, 0.03337697f, 
    -0.17896838f, -0.09176643f, 0.01860211f, 0.08348969f, -0.05553211f, 0.03380207f, -0.01036413f, 0.14014477f, 
    0.03004834f, 0.13349354f, 0.07155988f, 0.13918996f, 0.11225607f, -0.13198261f, 0.08190275f, -0.04133446f, 
    0.05351212f, -0.13402821f, -0.02122571f, -0.08101118f, -0.04124877f, -0.14267051f, 0.14723653f, -0.05411063f, 
    -0.18139239f, -0.10408128f, 0.06020452f, 0.01195178f, 0.01151843f, -0.09680837f, 0.10675059f, -0.05287153f, 
    0.03324965f, -0.08807804f, 0.14243437f, 0.01867849f, 0.06005940f, -0.11686771f, -0.00387538f, 0.06704741f, 
    0.05251398f, -0.03419372f, 0.01597393f, -0.03458573f, 0.03535251f, -0.02157137f, 0.08994646f, 0.00830515f, 
    0.06961927f, -0.03186397f, 0.00463311f, -0.14844747f, -0.13579625f, -0.00301345f, 0.05920031f, -0.20318128f, 
    -0.02325839f, -0.05587805f, 0.10017496f, 0.11606405f, -0.01214628f, 0.05548229f, -0.15746818f, -0.27224889f, 
    -0.04710285f, 0.05009472f, -0.05242596f, 0.06106948f, 0.00180008f, -0.12967068f, 0.04527049f, 0.02959615f, 
    0.22621778f, -0.24790825f, 0.23162313f, 0.29451388f, 0.02235919f, -0.08092298f, 0.00061231f, -0.03924489f, 
    -0.02165093f, -0.13710383f, -0.18028551f, -0.10057265f, 0.11571658f, -0.07179837f, 0.03907071f, 0.16071989f, 
    -0.02003491f, -0.06490240f, -0.00016067f, -0.11173863f, -0.04513200f, -0.05077870f, -0.02078052f, -0.03455189f, 
    -0.28785592f, -0.09030966f, -0.13776031f, -0.15277429f, 0.00663574f, -0.04654798f, -0.08619241f, -0.00398222f, 
    -0.13423596f, 0.03627446f, 0.04639644f, 0.00809232f, 0.08999429f, -0.14316422f, 0.04251158f, 0.04781313f, 
    0.08528209f, -0.03515744f, -0.10158946f, -0.02009843f, -0.04118510f, -0.07631149f, 0.01011677f, -0.10653746f, 
    0.06563514f, -0.03011489f, 0.15793757f, 0.01796621f, 0.09745674f, 0.01322673f, -0.05327453f, 0.01032607f, 
    -0.02542798f, -0.00579629f, 0.05806591f, -0.01593751f, 0.14136820f, 0.03742225f, 0.03545655f, 0.07055070f, 
    -0.03607422f, -0.03669826f, -0.06120750f, -0.03025275f, 0.00643075f, 0.00655535f, -0.04186505f, -0.09741265f, 
    -0.16573541f, 0.21105264f, 0.09453310f, 0.04527840f, 0.03126750f, 0.03872021f, -0.02596036f, -0.05857204f, 
    -0.03787145f, 0.02962357f, -0.05525626f, -0.06873687f, -0.07049017f, -0.04244449f, 0.04347481f, 0.03910903f, 
    0.06290098f, -0.00442469f, 0.02053616f, -0.05058612f, -0.00892604f, -0.03421130f, -0.02888269f, -0.01683887f, 
    0.05640312f, -0.09419905f, 0.15749688f, 0.15862109f, 0.08305679f, -0.04801686f, -0.00454541f, -0.02268497f, 
    -0.05247976f, 0.05475167f, -0.12325347f, -0.01530399f, 0.11295827f, 0.06347138f, 0.10245530f, 0.11816733f, 
    0.08810607f, 0.04806967f, -0.02436053f, 0.01433721f, -0.03052971f, 0.01733036f, 0.01096819f, -0.08759625f, 
    0.12316695f, 0.17944930f, 0.02706676f, 0.22670379f, 0.14162162f, -0.02731680f, 0.10638146f, 0.06669027f, 
    0.01986039f, -0.00495820f, -0.02628434f, -0.07335893f, 0.09268524f, 0.02479211f, 0.17410724f, 0.04299042f, 
    -0.09414744f, 0.00488209f, -0.02945025f, -0.07059936f, 0.03182052f, 0.00581127f, -0.05821720f, 0.03317907f, 
    -0.14873210f, -0.15036997f, 0.07198249f, -0.17528522f, -0.06230403f, -0.02224311f, -0.05087836f, -0.09008158f, 
    0.06995460f, 0.02468641f, -0.03997514f, -0.09755295f, -0.07061125f, -0.18122771f, -0.21122636f, -0.07040524f, 
    0.01513285f, 0.05292525f, -0.00316467f, -0.05329190f, -0.06111642f, -0.01682807f, 0.03023601f, -0.05802617f, 
    0.08524270f, 0.00054051f, -0.06620939f, 0.04943958f, -0.15907353f, -0.00751727f, -0.08421227f, -0.01029872f, 
    -0.06980941f, 0.01608943f, -0.02447828f, 0.05237983f, -0.18558116f, -0.10165381f, -0.12188710f, -0.13758452f, 
    -0.05379736f, -0.12072048f, -0.02788073f, 0.03245242f, -0.10288447f, -0.08945251f, -0.06821150f, -0.03727439f, 
    0.27687314f, 0.09382245f, 0.16584128f, -0.02034472f, 0.01337648f, 0.00256063f, -0.02019377f, 0.01812437f, 
    -0.03000084f, 0.07896304f, -0.03090448f, -0.00913682f, -0.25929061f, -0.10202218f, -0.11372925f, 0.04914133f, 
    -0.06688100f, -0.12626417f, -0.07080787f, -0.01869318f, -0.10249107f, -0.01396404f, 0.08862829f, -0.02361903f, 
    -0.17458338f, -0.04306161f, -0.03228535f, -0.06182557f, -0.09331909f, -0.12119533f, -0.00732381f, -0.03338616f, 
    0.00912085f, 0.00430851f, -0.01925479f, -0.05614830f, 0.19202343f, 0.05293605f, 0.04155902f, 0.08467985f, 
    0.15790337f, 0.05223774f, -0.01372580f, -0.04342077f, 0.04341743f, -0.04406580f, 0.00571977f, -0.01829995f, 
    -0.27033293f, 0.06362858f, -0.14797908f, -0.16329312f, 0.00328745f, -0.05517969f, 0.00668260f, -0.08515812f, 
    -0.00213255f, 0.04826261f, -0.01368329f, 0.04440333f, -0.00183850f, -0.05580579f, 0.03528864f, 0.20499440f, 
    0.00967377f, 0.00319378f, 0.01307361f, 0.01686000f, -0.01961115f, 0.03963919f, 0.03964865f, 0.02153261f, 
    0.17634873f, -0.02747755f, -0.14270465f, -0.20172118f, -0.09286545f, -0.04938145f, -0.03637599f, -0.07964887f, 
    -0.02978185f, -0.07634266f, -0.00261289f, -0.04703449f, -0.13071075f, 0.14961188f, -0.14015931f, -0.11661214f, 
    -0.04929891f, 0.06971393f, 0.02288117f, -0.00719850f, -0.08607920f, 0.01907815f, 0.00263559f, -0.13133168f, 
    0.02347166f, 0.13527746f, 0.10136575f, 0.19650191f, 0.09215657f, 0.05423516f, 0.04240585f, 0.01290119f, 
    -0.06244870f, -0.00672974f, 0.01360643f, -0.09582957f, -0.13043714f, -0.02987814f, -0.11235856f, -0.34729016f, 
    -0.01349505f, 0.05662299f, -0.05063425f, 0.00747820f, -0.02810368f, 0.01993337f, -0.03951756f, -0.03334751f, 
    -0.22403386f, 0.07624142f, 0.04097055f, 0.10795306f, 0.08413699f, -0.01024707f, -0.06652904f, -0.01448354f, 
    -0.00831127f, -0.03722473f, 0.00460541f, 0.05850923f, -0.14435130f, 0.04537470f, 0.08266713f, -0.02097970f, 
    0.01493828f, -0.02121836f, 0.02554808f, -0.03356620f, -0.01106557f, 0.01714042f, 0.00168346f, -0.09115925f, 
    0.07537501f, 0.12963061f, 0.04712662f, 0.07207324f, 0.15230322f, -0.03313752f, 0.02816316f, -0.01865643f, 
    0.03428967f, -0.07282619f, -0.01945360f, -0.06065181f, -0.07585160f, -0.28968054f, -0.15945117f, -0.01510587f, 
    -0.12012328f, -0.04696631f, 0.01358332f, -0.03119622f, -0.03174921f, -0.04075801f, -0.00790740f, 0.03264681f, 
    0.10841955f, 0.06904232f, 0.18617515f, 0.08550983f, 0.04078810f, 0.02448400f, 0.04865293f, -0.01930409f, 
    -0.03992106f, 0.05910303f, -0.00082526f, -0.08090580f, 0.13528891f, 0.05985036f, -0.12429996f, 0.04600898f, 
    -0.01153627f, -0.06851697f, -0.09225039f, 0.02275502f, -0.04122571f, -0.02027184f, -0.03245122f, -0.05356324f, 
    -0.01235373f, -0.34700838f, 0.07418326f, 0.03384841f, 0.00838602f, 0.01325176f, -0.04017774f, 0.00018071f, 
    -0.02900324f, -0.01006834f, 0.02272191f, -0.07182114f, 0.12691757f, 0.16019610f, 0.07499988f, -0.02543492f, 
    -0.10812692f, 0.05419474f, 0.00699343f, -0.04801798f, 0.02426906f, 0.03916575f, 0.03425273f, -0.03713074f, 
    0.19519842f, -0.21831891f, 0.07648160f, -0.03773056f, -0.05974471f, 0.01652594f, -0.09033852f, -0.06730042f, 
    -0.03964818f, 0.02163293f, -0.05284954f, -0.00357661f, -0.04447568f, 0.15329532f, -0.01291004f, 0.11241798f, 
    -0.10203493f, -0.06592087f, 0.01633003f, 0.03887406f, -0.01724204f, -0.02175412f, 0.03421104f, -0.08294776f, 
    0.12657429f, -0.09897175f, -0.05774861f, -0.02811579f, 0.03856064f, 0.07817081f, -0.05533704f, 0.01476934f, 
    0.04490626f, 0.06995281f, -0.02000475f, -0.01026215f, 0.02106803f, -0.08772677f, 0.14762023f, -0.00130400f, 
    -0.03291443f, 0.01549000f, -0.03140598f, -0.06502261f, -0.00809073f, 0.04554201f, -0.03250736f, -0.05459824f, 
    -0.18804984f, 0.02164673f, -0.06834618f, -0.09848681f, -0.12894818f, -0.07644618f, -0.05916084f, -0.09576545f, 
    -0.10264873f, 0.04982519f, -0.07397990f, -0.10901409f, 0.01243884f, 0.11519554f, 0.12078306f, 0.08069001f, 
    0.13902363f, 0.01932080f, -0.00818674f, -0.02680722f, -0.02932038f, -0.05906263f, -0.00446917f, -0.02189490f, 
    -0.05211429f, 0.08953661f, 0.00706599f, 0.04943585f, 0.04567827f, -0.00128479f, -0.00199478f, -0.04154771f, 
    0.04103393f, -0.07738469f, -0.07429382f, 0.00363540f, 0.10283590f, 0.00017525f, 0.14774995f, 0.06455544f, 
    0.01808453f, 0.00287601f, -0.07355772f, -0.11726386f, -0.02977685f, 0.02635385f, 0.10860532f, -0.05536887f, 
    -0.03334538f, -0.02310052f, -0.00223943f, -0.01126655f, 0.06012546f, -0.03500792f, -0.03663257f, -0.02316833f, 
    -0.05238462f, -0.04984417f, 0.00971286f, -0.04386555f, -0.15331270f, 0.01940681f, -0.15301539f, 0.01767859f, 
    0.02910091f, 0.01226872f, -0.02070133f, -0.03852105f, -0.03895960f, -0.00957476f, 0.00899021f, -0.10881060f, 
    0.10584261f, -0.09884169f, 0.08187700f, 0.04353966f, 0.01374258f, -0.00083719f, 0.00199034f, 0.00037679f, 
    -0.07862838f, -0.09001956f, -0.01009036f, -0.04283747f, 0.08640399f, 0.11023424f, 0.01703796f, 0.07286097f, 
    -0.03183128f, -0.06325267f, -0.03407491f, -0.03468493f, -0.06591021f, 0.00055046f, -0.03968629f, -0.00285674f, 
    -0.04409973f, 0.13044070f, 0.05399702f, 0.21257062f, 0.00624654f, 0.04016515f, 0.06036429f, 0.06038750f, 
    -0.06244252f, 0.05802667f, -0.06390473f, -0.04694879f, -0.15688936f, -0.12555288f, 0.03714478f, -0.00767939f, 
    -0.03845334f, 0.03256341f, -0.05940165f, -0.00596228f, -0.03203068f, 0.00411302f, -0.04795136f, -0.01745884f, 
    -0.10183112f, 0.03254789f, -0.04666493f, -0.05470804f, 0.03350112f, 0.02808322f, 0.03613473f, -0.05102750f, 
    -0.07003928f, 0.00109148f, 0.01155256f, -0.02027130f, -0.13782437f, 0.16298789f, -0.02967414f, -0.01051891f, 
    -0.04138495f, -0.03373447f, -0.03223051f, -0.07534061f, 0.00992123f, -0.04590152f, -0.04495594f, -0.08991276f, 
    0.30980402f, -0.12925635f, -0.00610957f, -0.03956530f, 0.06077775f, -0.01809645f, 0.03820990f, -0.09196894f, 
    0.07480627f, -0.03184795f, 0.02609721f, -0.10374842f, 0.09986762f, 0.06388060f, -0.18586890f, -0.10105499f, 
    -0.09436877f, -0.03956684f, 0.02331393f, -0.02895394f, -0.05398507f, -0.04680530f, -0.06690772f, -0.06837714f, 
    0.08573216f, 0.12050646f, 0.16938479f, 0.23678145f, 0.17887366f, 0.08990982f, 0.11481381f, -0.02851941f, 
    0.02271858f, -0.03541388f, -0.02228498f, -0.03787016f, 0.13117546f, -0.22006342f, 0.02042710f, -0.01641861f, 
    -0.06678054f, -0.06527422f, -0.05963229f, 0.03606961f, -0.06359398f, -0.06610058f, -0.01482790f, -0.03806898f, 
    -0.05533840f, 0.19975784f, 0.10636452f, 0.00044981f, 0.04260882f, 0.08288209f, -0.00782876f, -0.02208083f, 
    0.02613444f, 0.01960967f, 0.11062968f, 0.02271595f, 0.17229597f, -0.05866688f, -0.04598601f, 0.00097228f, 
    -0.06422787f, -0.04557194f, -0.02102744f, 0.00792238f, -0.06806228f, -0.03257838f, 0.00695710f, 0.00403932f, 
    -0.06599593f, 0.07703983f, -0.00972038f, -0.23318401f, -0.00922303f, -0.04878545f, 0.01965040f, -0.04012673f, 
    -0.05411061f, 0.00353516f, -0.07943092f, 0.02131822f, 0.15734635f, -0.16606398f, 0.06223730f, 0.09020802f, 
    0.05681932f, -0.05415811f, -0.06845427f, -0.04472227f, -0.03235858f, -0.06356574f, -0.12406979f, -0.10087977f, 
    0.13299286f, 0.03494247f, -0.27069330f, 0.02970120f, -0.00703529f, 0.01742664f, -0.02570266f, -0.07819059f, 
    0.01308252f, 0.07452070f, -0.02124612f, -0.08705418f, -0.07279022f, -0.03202560f, -0.07898796f, -0.15470836f, 
    -0.01672559f, -0.00073678f, -0.08247440f, 0.01443494f, -0.02655005f, -0.07896720f, 0.02935673f, 0.02704039f, 
    0.17848600f, -0.17416638f, 0.16405733f, -0.15811116f, -0.04646400f, 0.00513486f, -0.09728417f, -0.02644375f, 
    -0.04966465f, -0.01876118f, -0.03420068f, 0.00734136f, 0.13340485f, -0.01297227f, 0.11421799f, -0.09976694f, 
    0.02831741f, -0.04294471f, 0.03933246f, -0.10283696f, -0.01090238f, 0.04438911f, 0.01237193f, -0.08509111f, 
    0.11094219f, 0.09437449f, 0.14086075f, 0.15217261f, 0.09073953f, -0.01063566f, 0.03521609f, -0.02327327f, 
    -0.05314808f, 0.06811655f, 0.04789273f, 0.03100702f, 0.08637523f, 0.04662485f, 0.04018484f, 0.17575006f, 
    0.00241703f, -0.04658381f, -0.06010917f, -0.01415633f, -0.04613465f, 0.01225851f, -0.11362247f, -0.08092814f, 
    0.11347304f, 0.11472836f, -0.10282753f, 0.02798690f, -0.00858927f, -0.06688853f, -0.19499056f, -0.00231777f, 
    -0.10514639f, 0.04821499f, -0.01075119f, 0.01868031f, 0.01415043f, -0.16178720f, -0.13417669f, -0.21769065f, 
    -0.05263487f, 0.01804763f, 0.02032371f, 0.05191050f, 0.10829172f, -0.04694214f, -0.16155234f, -0.09335152f, 
    -0.13622198f, 0.00044074f, -0.20169328f, -0.04083903f, 0.08357237f, 0.05179743f, -0.06094914f, -0.00093972f, 
    0.04705901f, 0.06836410f, -0.00060784f, 0.01825104f, 0.09810096f, 0.01465370f, -0.06716499f, -0.16708271f, 
    0.05105272f, 0.03172871f, -0.08194894f, 0.07766265f, 0.00125155f, -0.06094966f, -0.08763418f, 0.14897001f, 
    -0.05166870f, -0.13029680f, 0.07658863f, -0.17157364f, 0.00409708f, 0.10974725f, 0.00164341f, 0.04621958f, 
    -0.01783614f, 0.03617652f, -0.06046965f, 0.04429689f, -0.12133130f, -0.11220736f, 0.13636437f, -0.14786536f, 
    -0.03443459f, -0.14665127f, -0.05035617f, -0.04859879f, -0.02298293f, 0.03390798f, -0.05900221f, 0.08040225f, 
    0.10033927f, 0.16346759f, 0.09197021f, 0.02621224f, -0.05436336f, 0.04495617f, -0.10412493f, -0.05098106f, 
    0.04150831f, -0.05893452f, 0.09575979f, 0.04448920f, -0.01864842f, -0.13353132f, 0.18450162f, 0.11943118f, 
    0.00094109f, -0.07659102f, -0.00343977f, -0.18720770f, -0.04237533f, -0.07802209f, 0.05904127f, -0.07502105f, 
    -0.04682305f, -0.13030623f, -0.26245192f, -0.06143815f, 0.02422493f, -0.04443460f, -0.09856344f, -0.01842029f, 
    -0.00558265f, 0.03409396f, 0.14476402f, -0.11121116f, -0.18488979f, -0.05781167f, -0.02313232f, -0.26377743f, 
    -0.02376773f, -0.10756274f, 0.03492184f, -0.05966572f, -0.05384935f, 0.03900849f, -0.06573860f, 0.14908884f, 
    0.00106703f, 0.01444536f, 0.00515174f, -0.02703484f, 0.00663773f, 0.08793072f, -0.07980973f, -0.07784204f, 
    -0.00783577f, 0.00193571f, -0.01833821f, -0.06032619f, -0.12837546f, 0.16047971f, -0.06410798f, -0.12450529f, 
    -0.09395151f, 0.07621682f, 0.01993590f, 0.00659588f, 0.03488416f, 0.01156628f, 0.06674021f, 0.10183878f, 
    -0.15359156f, -0.04028793f, 0.07206948f, 0.14322701f, -0.13539687f, -0.08918749f, 0.01975873f, 0.04744053f, 
    0.01879554f, 0.03323936f, -0.07820672f, 0.03066749f, 0.09790692f, -0.00384016f, -0.11220652f, 0.02292337f, 
    0.01029272f, -0.05894710f, 0.03977809f, -0.02616021f, 0.03195523f, 0.06343640f, 0.01736282f, -0.02901030f, 
    -0.03902631f, -0.00871459f, 0.00995812f, -0.08804446f, 0.00017620f, 0.01091101f, -0.04842115f, 0.01655998f, 
    -0.01903192f, 0.04259818f, -0.20356941f, 0.03236062f, 0.02617544f, 0.20053649f, -0.16720240f, 0.00335727f, 
    -0.06280239f, 0.03427631f, -0.10303224f, -0.06160920f, 0.09563775f, -0.01512545f, 0.05974852f, 0.01203665f, 
    0.10898808f, -0.06735756f, 0.04455473f, 0.05187114f, -0.00063587f, -0.13296235f, 0.12987703f, -0.09550037f, 
    0.02948273f, 0.00456513f, -0.23772876f, -0.00799410f, -0.25841799f, -0.12475737f, -0.14973786f, -0.13694270f, 
    0.08403561f, 0.04726250f, -0.05008011f, 0.02002447f, 0.05642728f, 0.11362642f, 0.01242853f, 0.00807257f, 
    -0.13964771f, -0.19489047f, -0.03746935f, 0.08260743f, -0.04051256f, -0.00042899f, -0.02716243f, -0.11460289f, 
    0.02066606f, 0.07178884f, -0.04689023f, 0.04868012f, 0.04873879f, -0.03199246f, 0.03779297f, 0.08627052f, 
    -0.02217690f, -0.04587414f, 0.01273649f, 0.03871747f, 0.05558739f, 0.01383254f, -0.05358440f, 0.00139542f, 
    0.07815649f, 0.01511505f, 0.05542646f, 0.18144001f, 0.06549755f, 0.01330413f, -0.07329869f, -0.02977252f, 
    0.02997534f, -0.02413859f, 0.01186042f, -0.05612155f, 0.08297896f, -0.18877709f, -0.30182019f, -0.05330773f, 
    0.04087664f, -0.12098079f, -0.02695124f, 0.00217081f, 0.02803234f, -0.09882925f, 0.02246285f, 0.05298086f, 
    0.12993322f, -0.03399281f, -0.09253922f, 0.12651405f, 0.02070519f, -0.07972845f, -0.01635872f, -0.11573945f, 
    0.06846830f, 0.04104259f, -0.03556929f, -0.02167243f, -0.04654331f, -0.12325208f, -0.05621760f, -0.02789654f, 
    0.11231002f, 0.01423120f, -0.08445849f, -0.01599508f, 0.05264606f, 0.08530216f, -0.11721580f, -0.01868445f, 
    -0.29657450f, 0.10103234f, 0.09920980f, -0.21144618f, 0.00450696f, -0.04998527f, -0.02077475f, 0.09285519f, 
    0.04513137f, 0.02807775f, -0.01563230f, 0.06499320f, 0.16035536f, -0.12395997f, -0.05742365f, 0.07552227f, 
    0.07241414f, 0.02720166f, 0.02728507f, 0.01435926f, -0.00217483f, -0.04048299f, -0.01218673f, 0.03930902f, 
    -0.03521391f, 0.16894633f, -0.21334624f, 0.13734458f, 0.06933283f, -0.11045531f, -0.09085744f, -0.00774526f, 
    -0.01573726f, 0.00038160f, -0.03925222f, 0.03441358f, -0.08199617f, 0.04278948f, 0.18357073f, 0.16080855f, 
    -0.11813136f, -0.04526647f, -0.04924018f, -0.07650185f, 0.06523622f, -0.05621002f, 0.05951974f, 0.05196668f, 
    -0.28164515f, -0.19466764f, 0.12118243f, -0.10708919f, 0.06404248f, 0.02356280f, 0.08441922f, -0.09173016f, 
    -0.12888500f, 0.02405169f, 0.05426772f, 0.06342113f, 0.17305197f, 0.05677559f, -0.21484163f, -0.01730217f, 
    0.08509587f, 0.03792097f, 0.02333641f, -0.04246741f, 0.01997424f, -0.04770774f, 0.05031815f, 0.09882585f, 
    -0.23312588f, -0.02821332f, 0.15635528f, 0.07332008f, -0.04784326f, -0.05360377f, -0.03654880f, 0.02615088f, 
    0.07242519f, -0.06208085f, -0.08942717f, 0.10417802f, -0.00083443f, 0.19567761f, 0.05056642f, -0.12322564f, 
    0.01424998f, -0.01986388f, -0.08491895f, -0.06699848f, 0.05040828f, -0.10091226f, 0.09001919f, 0.07876085f, 
    -0.15368158f, -0.15507561f, -0.33788753f, 0.01697029f, -0.02192922f, -0.06662423f, 0.01297675f, 0.01727982f, 
    0.08801842f, 0.04278056f, 0.04750446f, 0.17114347f, -0.01085752f, 0.32679030f, -0.03545587f, -0.01200328f, 
    0.00246110f, 0.01982571f, -0.08754564f, 0.10408361f, 0.12397258f, 0.02101626f, 0.06057272f, -0.06954442f, 
    -0.14421445f, -0.04261967f, 0.17835283f, -0.09370752f, 0.01843164f, -0.04909026f, 0.09574096f, -0.10819750f, 
    -0.01251071f, 0.08050372f, -0.00170420f, -0.01226123f, 0.01235804f, 0.04958830f, -0.11345714f, -0.07381669f, 
    0.06324978f, -0.07424068f, -0.04110718f, 0.04597233f, 0.11484401f, 0.02194403f, 0.14267728f, -0.01908048f, 
    0.01966128f, -0.05810305f, 0.02692402f, -0.16003232f, 0.00912614f, -0.03797309f, 0.17970119f, 0.00340396f, 
    -0.03372147f, -0.00117195f, -0.08133732f, 0.04067982f, 0.10059734f, -0.05548169f, 0.11246485f, -0.02339219f, 
    -0.21746133f, -0.10828479f, -0.06180063f, -0.05570805f, -0.05545816f, -0.07757922f, -0.10146581f, -0.02949641f, 
    -0.02700903f, 0.01915817f, -0.04917816f, 0.08440434f, 0.08041610f, 0.02096569f, -0.05552704f, -0.11371297f, 
    0.04880786f, 0.05013406f, 0.04381457f, 0.03029759f, -0.25726941f, -0.03138875f, 0.19536702f, -0.06127685f, 
    0.04249290f, 0.05530228f, -0.05045211f, -0.12696056f, -0.01380621f, 0.02803537f, -0.01759392f, 0.04160570f, 
    -0.00568372f, 0.09109381f, 0.00744220f, 0.11247580f, 0.00120211f, -0.02779699f, -0.08197330f, 0.01531436f, 
    -0.07978474f, 0.05279374f, -0.05478379f, -0.13661374f, -0.02765206f, -0.17947862f, 0.18421698f, -0.20052935f, 
    0.08086096f, -0.03937393f, -0.10975970f, 0.03296357f, -0.09091642f, 0.06988738f, -0.02639434f, 0.08675455f, 
    -0.21535397f, -0.16876328f, -0.02104061f, -0.14897802f, 0.03045569f, -0.10309111f, -0.12306366f, -0.01078375f, 
    0.06925984f, 0.01344867f, -0.02646526f, -0.04187793f, 0.14192693f, 0.08664925f, -0.07192802f, 0.04946507f, 
    0.01073154f, -0.03685521f, -0.09639107f, -0.01693489f, 0.00186967f, 0.05162143f, -0.14897838f, 0.06831918f, 
    0.11980893f, -0.23508334f, -0.10974330f, -0.18915829f, -0.04193885f, -0.00056114f, 0.01608669f, -0.11712852f, 
    0.04604641f, -0.00793909f, -0.03217932f, 0.13805605f, -0.22179243f, 0.03004944f, 0.10944676f, -0.26219600f, 
    -0.12141205f, 0.08074934f, -0.06890194f, 0.08164201f, 0.16068874f, 0.06193131f, -0.01533149f, 0.03639547f, 
    -0.13868429f, 0.10230116f, 0.13183619f, -0.10426500f, 0.17205466f, -0.05908532f, 0.08576515f, -0.00063100f, 
    -0.05987349f, -0.05175389f, -0.04782796f, -0.13737518f, -0.14335816f, 0.07199981f, 0.11022281f, 0.05545183f, 
    -0.03872655f, -0.01972498f, -0.03372881f, -0.05138452f, 0.05137783f, -0.09376831f, -0.02241019f, 0.00147995f, 
    -0.17754592f, -0.32072762f, 0.23963098f, 0.23476855f, 0.09414833f, -0.05751247f, -0.04266784f, -0.01022560f, 
    -0.02449630f, 0.13248827f, 0.10208059f, 0.06777725f, 0.21005960f, 0.00807949f, 0.04740982f, 0.11774407f, 
    0.11016831f, 0.00256713f, -0.05927900f, -0.08371311f, -0.06214115f, 0.03978140f, -0.01439341f, -0.08328075f, 
    -0.00518901f, -0.29332656f, 0.16921586f, -0.05382014f, 0.07268642f, -0.12100838f, 0.00459670f, -0.01826200f, 
    0.05991020f, -0.02082935f, 0.04678733f, 0.09583595f, 0.01847686f, -0.10414192f, 0.08204162f, 0.16330294f, 
    0.05455610f, -0.02305699f, -0.03859967f, -0.10221253f, 0.03773358f, -0.06100340f, 0.08804107f, 0.01261396f, 
    -0.07335242f, -0.22665998f, 0.07599044f, -0.01793510f, 0.05427736f, 0.06018998f, 0.10879862f, -0.06908140f, 
    0.08480621f, -0.21167469f, -0.00639744f, -0.01130946f, 0.05291521f, -0.20874079f, -0.12361526f, -0.05746098f, 
    0.10667572f, 0.03115421f, -0.01433110f, -0.04384727f, 0.09980677f, 0.05842543f, 0.08094541f, -0.01499865f, 
    0.05117370f, 0.01015364f, 0.17755985f, 0.01694633f, -0.05141205f, -0.04305992f, 0.04413028f, -0.11741864f, 
    -0.05346465f, -0.07522943f, -0.05230637f, -0.03493084f, -0.07375306f, -0.18695328f, 0.08634701f, -0.10128675f, 
    0.02071404f, -0.08550961f, -0.00662801f, -0.01335044f, -0.02141538f, -0.00307136f, 0.03746241f, 0.09783519f, 
    0.13751359f, -0.18274508f, 0.08453863f, 0.20207143f, 0.12085892f, -0.01912287f, -0.04753720f, -0.09535552f, 
    -0.03208379f, -0.06483089f, 0.14357971f, -0.05586119f, 0.07408509f, 0.05946637f, 0.00126779f, -0.21148954f, 
    0.04154561f, -0.04513047f, -0.10464870f, 0.05686951f, 0.03291288f, -0.02409121f, 0.03146486f, -0.03687164f, 
    0.09154361f, 0.10116751f, 0.06373588f, -0.04298054f, -0.06610047f, -0.04438170f, 0.03949521f, -0.07046435f, 
    -0.01199315f, 0.04160033f, -0.17317419f, 0.13961987f, 0.08356240f, -0.12391447f, 0.05585753f, 0.12343413f, 
    0.01584086f, 0.03796677f, 0.03891304f, 0.04849109f, -0.00671184f, -0.02313488f, -0.09147137f, -0.05285480f, 
    0.04200272f, 0.01331289f, 0.05540796f, -0.04664746f, -0.08974969f, -0.05162639f, 0.05656802f, -0.10161002f, 
    0.01801022f, 0.12489481f, -0.03482111f, -0.00889960f, 0.02768769f, -0.19404881f, 0.07492641f, 0.07346071f, 
    -0.04992361f, -0.28271547f, -0.16747028f, 0.11276421f, -0.05842375f, 0.12196079f, 0.00477915f, -0.12612700f, 
    0.03286896f, 0.05533073f, 0.09648951f, -0.07683142f, -0.02138551f, 0.07704534f, 0.05362398f, 0.05486060f, 
    -0.00916416f, -0.02440890f, -0.11149446f, -0.05589997f, -0.13321884f, 0.01383919f, 0.00455807f, -0.20568737f, 
    -0.09509121f, -0.17855415f, 0.09233195f, -0.04184246f, -0.06919961f, 0.03457974f, 0.07376646f, -0.00224334f, 
    0.21723087f, -0.50898963f, -0.12847289f, -0.22334413f, -0.10580529f, 0.00178235f, -0.02770635f, 0.01363110f, 
    -0.06149156f, -0.07712682f, 0.01914531f, -0.09422313f, -0.00604527f, -0.03191347f, -0.00645052f, -0.12403151f, 
    0.01736953f, -0.09905150f, 0.07753699f, -0.14586096f, -0.06488983f, 0.03918779f, 0.03843623f, 0.27247098f, 
    0.05204459f, 0.02932883f, 0.21757084f, -0.14572631f, -0.07691091f, 0.09702126f, 0.02772808f, -0.07551063f, 
    -0.03254791f, -0.03318758f, -0.10162898f, 0.02971848f, 0.14766815f, -0.20160571f, 0.20680654f, 0.01382262f, 
    -0.08643632f, 0.02233075f, -0.09520309f, 0.02179032f, -0.07493745f, 0.02740837f, 0.08075711f, 0.01512712f, 
    0.04353252f, -0.02693966f, -0.03757800f, 0.28393161f, 0.05114651f, 0.00917102f, -0.05953876f, 0.05970005f, 
    0.00022210f, 0.11674269f, -0.00994352f, 0.09235993f, 0.25759229f, 0.05865337f, -0.12993848f, 0.01030676f, 
    -0.05314881f, -0.04983550f, 0.05880545f, 0.00087695f, -0.07521564f, 0.03169939f, 0.03092476f, -0.16927828f, 
    -0.17324838f, -0.12541494f, 0.05251551f, -0.03094804f, 0.14395362f, 0.00813855f, -0.10937119f, 0.04034379f, 
    0.04943347f, 0.03201427f, -0.01194160f, -0.05986233f, 0.18603797f, -0.12271143f, -0.02820992f, -0.13261563f, 
    0.05184293f, -0.05501921f, -0.04851651f, -0.09016303f, 0.04359095f, -0.12602033f, 0.03706014f, -0.10927545f, 
    -0.06466459f, -0.23265098f, 0.00819094f, 0.00059950f, -0.10138369f, -0.12569384f, 0.02926173f, 0.03514878f, 
    -0.00143876f, -0.03325718f, -0.04055703f, 0.07741364f, -0.03979185f, -0.01938661f, -0.09049194f, 0.24233030f, 
    -0.01140754f, -0.02226032f, -0.05169279f, 0.15644753f, -0.12183966f, -0.10201029f, 0.04373658f, -0.09057698f, 
    -0.37642565f, -0.18403059f, 0.19812220f, -0.07190748f, -0.01148959f, 0.01158225f, 0.03099863f, 0.12576286f, 
    0.02971266f, -0.04324838f, 0.04505554f, -0.06199963f, -0.18123515f, -0.14142251f, -0.22160637f, 0.23977207f, 
    -0.01539853f, 0.05285354f, 0.01208321f, -0.12720419f, -0.04644301f, 0.10238416f, -0.03529013f, -0.06577000f, 
    -0.05307011f, 0.18045351f, -0.03545741f, 0.07886915f, -0.00852731f, 0.01517125f, -0.02529478f, 0.06961130f, 
    -0.01005449f, 0.02125398f, 0.02128335f, 0.06288573f, -0.06939691f, 0.18872751f, -0.05126423f, 0.07464744f, 
    -0.05649333f, 0.02136907f, -0.09268621f, 0.04623551f, -0.04035070f, 0.00546384f, -0.03616814f, -0.02383272f, 
    0.13579822f, 0.00853040f, -0.16993196f, -0.04971962f, -0.05970383f, 0.00575181f, -0.11044787f, 0.04547044f, 
    0.07819509f, -0.07133868f, 0.08638135f, 0.04003294f, 0.39041820f, 0.02464241f, -0.11013745f, -0.00971008f, 
    0.02618023f, 0.10165493f, 0.09015104f, 0.06560519f, -0.06647102f, -0.03761872f, -0.07456306f, 0.07915628f, 
    -0.04139154f, -0.01973290f, -0.00786481f, -0.04097264f, -0.02705056f, 0.04463806f, -0.01141169f, -0.04953496f, 
    0.03451152f, 0.12568447f, -0.00691168f, 0.07159200f, -0.16022645f, 0.07151472f, -0.04509262f, -0.37249157f, 
    0.01352862f, -0.00503681f, -0.03298540f, 0.01543349f, 0.07026438f, 0.03663357f, 0.03822134f, -0.04781812f, 
    -0.07549705f, 0.15827595f, -0.23644938f, -0.16735502f, 0.03833994f, -0.21518053f, 0.01767874f, 0.08264460f, 
    0.05127604f, -0.00874944f, -0.00175303f, -0.03764904f, -0.11490874f, -0.21926954f, 0.16609372f, -0.18194146f, 
    0.08575820f, 0.00715767f, -0.00515607f, -0.04195131f, 0.08144046f, -0.01114401f, 0.03926373f, 0.12146991f, 
    -0.13332090f, 0.25478232f, -0.37819609f, -0.23447613f, 0.10397363f, 0.04092162f, 0.06193387f, -0.04777938f, 
    -0.12964469f, -0.06210604f, -0.14504400f, -0.03648665f, -0.13218470f, -0.05392332f, 0.08691472f, -0.14370115f, 
    0.01089839f, 0.00406886f, -0.17805156f, 0.12372265f, -0.00067169f, -0.02071348f, -0.02461917f, 0.00101162f, 
    0.05494116f, -0.03044059f, 0.06349481f, 0.14093626f, 0.02815419f, 0.05572714f, 0.02667937f, -0.02179087f, 
    -0.00382618f, 0.03564639f, 0.00193109f, 0.00461151f, -0.10986326f, 0.12967113f, 0.02964250f, -0.03483822f, 
    -0.01230562f, -0.08156595f, 0.10668597f, -0.07775706f, 0.11899672f, -0.07457548f, 0.04184952f, -0.01343407f, 
    -0.05305368f, -0.02051216f, -0.01961030f, -0.03167912f, 0.06639201f, -0.00409990f, 0.00015299f, -0.06697725f, 
    -0.10421183f, -0.13705203f, 0.02952985f, 0.06465095f, 0.00397880f, 0.01108516f, -0.06884763f, 0.06659233f, 
    0.10223454f, 0.13113126f, 0.11245789f, 0.00172547f, 0.02992147f, -0.09033136f, 0.01029767f, 0.05707074f, 
    -0.00191777f, -0.33332014f, -0.04766423f, 0.00220310f, -0.03954848f, 0.04294840f, -0.01196404f, 0.00941255f, 
    0.00829599f, -0.00815368f, 0.06637459f, -0.02404021f, -0.00752301f, -0.32650098f, 0.10031649f, -0.08674723f, 
    0.07774247f, -0.07493950f, -0.01145393f, 0.02567164f, -0.03881489f, -0.03803607f, -0.00041804f, -0.08630142f, 
    0.17375815f, -0.08776903f, -0.21587521f, 0.17702824f, 0.06346278f, 0.02556116f, -0.06485395f, 0.06865071f, 
    0.07151953f, -0.01408122f, 0.00456470f, 0.06124946f, 0.05684291f, 0.21466514f, 0.01928403f, -0.23235896f, 
    -0.05956393f, 0.10774840f, 0.11305292f, 0.01611912f, -0.05725609f, 0.02541799f, -0.02509359f, 0.03727069f, 
    -0.04994972f, -0.22407515f, 0.00764104f, -0.05450216f, -0.02592110f, 0.04109034f, -0.04532965f, -0.03477724f, 
    -0.09725169f, -0.00081434f, -0.06955593f, -0.04993047f, 0.67492330f, 0.13048387f, -0.12887235f, -0.32552701f, 
    0.10138614f, -0.15348245f, 0.08043241f, 0.00448487f, -0.06299792f, 0.05494555f, 0.07459611f, 0.06065977f, 
    -0.09253342f, -0.03612540f, 0.18333618f, -0.18276891f, 0.01379201f, -0.00739567f, -0.09911969f, 0.04644758f, 
    0.10950999f, -0.03394779f, -0.04216074f, -0.07065934f, -0.48478943f, 0.14411987f, 0.12805426f, 0.05226515f, 
    0.00697679f, -0.06040461f, -0.14331956f, 0.01719032f, -0.01510186f, 0.00808301f, -0.08109314f, 0.08817846f, 
    0.14547050f, -0.10645347f, -0.14751369f, 0.08869202f, -0.06522516f, 0.05299774f, -0.04589210f, 0.03932716f, 
    0.09416396f, 0.01014167f, 0.13509302f, -0.11618274f, -0.31336454f, 0.06356712f, 0.10746595f, -0.08834390f, 
    0.06803173f, 0.07996579f, 0.02257342f, -0.04665336f, 0.02105091f, 0.02087568f, -0.02343197f, -0.10239757f, 
    0.28163329f, 0.29179782f, 0.04608582f, 0.11728898f, -0.04711867f, 0.04688587f, -0.07599168f, 0.07612576f, 
    -0.00670870f, -0.06469582f, 0.15477273f, 0.07256159f, 0.44567913f, 0.10398930f, -0.00760507f, 0.19487582f, 
    0.22561961f, -0.01110768f, 0.02853057f, -0.05711154f, -0.02675121f, -0.05066111f, -0.01640004f, 0.06030945f, 
    -0.13829345f, 0.19049107f, -0.09644382f, -0.28212404f, 0.04968404f, 0.02518113f, 0.01657799f, 0.01788836f, 
    -0.06601248f, 0.06853250f, -0.00412861f, -0.10448899f, -0.08533718f, -0.38328362f, -0.12649971f, 0.27033082f, 
    -0.09507438f, 0.03250842f, 0.02088707f, 0.07257144f, -0.09392950f, -0.05095066f, -0.04432271f, -0.12075602f, 
    -0.25968286f, -0.09652584f, 0.07792994f, -0.01755496f, 0.00666506f, -0.00527205f, -0.00337269f, 0.09590957f, 
    0.00502260f, -0.11641317f, -0.02844981f, -0.05283534f, -0.09758061f, -0.11070051f, 0.04196674f, 0.16669175f, 
    -0.07702195f, -0.02280253f, -0.02830855f, -0.06543630f, -0.06268281f, 0.06477705f, -0.07714273f, 0.06247465f, 
    -0.11149631f, -0.22210591f, 0.05029913f, 0.01410064f, -0.15276472f, 0.02843617f, -0.02002605f, -0.03981052f, 
    -0.05223576f, 0.05205176f, -0.05041404f, 0.01411307f, 0.19898246f, 0.15533625f, -0.08327578f, 0.03310281f, 
    -0.02589084f, 0.21373469f, 0.05499468f, -0.08429282f, -0.12044648f, -0.01246217f, 0.16836111f, -0.01658994f, 
    -0.11562416f, -0.09106000f, 0.14887932f, 0.11042534f, 0.06148207f, 0.05676645f, 0.00801585f, 0.05551780f, 
    0.06336538f, -0.09998150f, 0.06729026f, -0.04704747f, -0.01834757f, 0.08796050f, -0.07364931f, 0.04504727f, 
    -0.09756205f, -0.00650021f, 0.02278114f, -0.20299150f, -0.04122121f, 0.09524992f, -0.08489155f, 0.02869881f, 
    -0.08237525f, -0.05953998f, 0.10274129f, 0.07085499f, -0.06242658f, -0.02746016f, -0.02101821f, 0.08048443f, 
    0.17044096f, 0.15816912f, -0.01867245f, 0.00756203f, 0.32303005f, -0.02453775f, -0.09638464f, 0.10520087f, 
    -0.03591766f, -0.04351517f, -0.00712427f, 0.06078857f, 0.00411294f, 0.02796683f, 0.00136340f, 0.07035174f, 
    -0.28118926f, 0.15660752f, -0.26395902f, -0.18496446f, -0.05036218f, -0.00221127f, 0.06806014f, -0.04027439f, 
    -0.06821879f, -0.07415447f, 0.01721643f, -0.23940220f, -0.23070386f, 0.23316497f, -0.17176828f, -0.05455024f, 
    0.14891933f, 0.01148605f, 0.12169498f, -0.07270710f, 0.08869828f, -0.00716565f, 0.02721257f, -0.01836142f, 
    0.11751302f, 0.05434400f, -0.00028917f, 0.13109134f, -0.11328824f, 0.08047523f, -0.00386592f, -0.15916266f, 
    -0.01600341f, -0.04817525f, 0.02197531f, -0.15894078f, -0.34436843f, -0.03972432f, -0.06235830f, -0.20262359f, 
    0.07211317f, -0.14979079f, 0.02085238f, -0.00966767f, -0.06090200f, -0.05478030f, 0.02441735f, 0.13937877f, 
    -0.02671003f, -0.11931156f, 0.06919248f, -0.07680233f, 0.10209487f, 0.08559948f, -0.00316403f, -0.08673125f, 
    -0.18937775f, 0.08343804f, 0.03800633f, 0.09319834f, 0.09079067f, -0.15191397f, -0.08467320f, -0.00586033f, 
    -0.08260728f, 0.07077180f, 0.05440468f, -0.01778466f, -0.06481139f, 0.01031182f, -0.10757384f, -0.00807003f, 
    0.09456705f, -0.14509557f, 0.05546467f, 0.00460766f, 0.14945123f, -0.08664816f, 0.01435377f, -0.01092985f, 
    -0.17630042f, -0.01843232f, 0.09780880f, -0.00775422f, 0.19133320f, -0.03591297f, 0.06223106f, 0.02707432f, 
    -0.12052935f, -0.03828061f, 0.06625757f, 0.12617412f, 0.02117724f, 0.02493892f, 0.01268848f, 0.06695753f, 
    -0.16103929f, 0.06267792f, 0.06850342f, -0.06917556f, 0.06266040f, -0.02935166f, -0.01615632f, -0.07820628f, 
    -0.03139957f, -0.03312918f, 0.00142705f, -0.00578156f, -0.06067761f, -0.18563373f, 0.10784129f, -0.07496586f, 
    0.00337885f, 0.00376345f, 0.06968854f, 0.00692901f, -0.00601526f, 0.01057314f, 0.06040436f, 0.14487179f, 
    -0.15623637f, 0.48020864f, -0.07563091f, 0.08477001f, 0.04631697f, 0.05749752f, -0.05448289f, 0.11052535f, 
    0.07957158f, 0.05034440f, 0.09512410f, 0.07935271f, -0.00718713f, 0.12246976f, -0.03840285f, -0.17855865f, 
    0.02825673f, -0.02787984f, -0.13518533f, -0.14894845f, -0.00149896f, 0.00811740f, -0.13510837f, 0.02710250f, 
    0.22072187f, -0.30141294f, -0.10916806f, -0.01014790f, -0.05475370f, -0.00739847f, 0.03673777f, 0.03305266f, 
    -0.05623199f, 0.13382351f, 0.08272552f, -0.06174277f, -0.01282264f, -0.03637084f, -0.09526179f, 0.18483832f, 
    -0.06619307f, -0.04644190f, 0.01564361f, 0.08535209f, 0.01500819f, -0.04600664f, 0.05992183f, 0.09272578f, 
    0.13452688f, -0.15772775f, 0.02358305f, 0.11963551f, 0.08068029f, -0.03107107f, 0.01420057f, 0.06867871f, 
    -0.09982259f, 0.19659810f, -0.03520596f, 0.07650539f, 0.11012191f, 0.02215195f, -0.07820366f, 0.01698217f, 
    -0.00383713f, 0.08727546f, -0.09606574f, 0.00831223f, 0.03257456f, 0.04321182f, -0.10723859f, -0.02913199f, 
    -0.37987027f, 0.12839676f, -0.21675554f, -0.23449713f, 0.10810254f, 0.03220490f, -0.00964992f, -0.04107846f, 
    0.12432939f, 0.12839244f, -0.08424859f, 0.02987909f, -0.00426542f, 0.14396268f, 0.02367407f, 0.04080142f, 
    0.12766927f, 0.06292349f, 0.06337970f, -0.00831860f, 0.06837536f, -0.06438314f, -0.02180152f, -0.20346420f, 
    -0.40043229f, 0.02855457f, 0.08798546f, 0.02175013f, 0.08374676f, 0.00153490f, 0.06847187f, -0.02706389f, 
    -0.00253827f, 0.03169406f, 0.01731309f, 0.02062705f, -0.00368225f, 0.05351846f, 0.06712935f, -0.06769682f, 
    0.04304985f, 0.10324273f, -0.03692714f, -0.02881541f, 0.01982768f, 0.00781115f, -0.02953889f, 0.12309095f, 
    0.17545632f, 0.05579641f, -0.05717887f, -0.03496098f, -0.00102014f, 0.03933231f, -0.00160833f, -0.01070112f, 
    0.06174873f, 0.03242692f, 0.03949724f, 0.01772361f, 0.04290972f, 0.12543838f, 0.06309633f, -0.08904589f, 
    0.00334783f, -0.00939537f, 0.07076115f, 0.01866221f, -0.04514851f, 0.04913566f, 0.05628236f, 0.17281343f, 
    0.09972805f, 0.01705202f, -0.06091946f, 0.06099242f, -0.01344332f, -0.00754322f, 0.07622875f, 0.08128560f, 
    0.11187044f, -0.02007849f, 0.03118627f, 0.04313188f, 0.06206461f, 0.14315452f, 0.03743821f, 0.01516344f, 
    -0.16225162f, -0.11492363f, 0.09352586f, 0.00622403f, 0.00299911f, -0.01324608f, -0.02536812f, 0.04581828f, 
    -0.25756559f, 0.00044561f, -0.05068665f, 0.03218101f, 0.10008594f, 0.00424582f, -0.13015939f, 0.00483538f, 
    -0.01511997f, -0.08845997f, -0.08746132f, -0.24373811f, 0.16720439f, -0.12908384f, 0.06680362f, 0.17733869f, 
    0.02405048f, 0.05213767f, 0.02944151f, 0.00259861f, -0.02710239f, 0.14865008f, -0.07802063f, 0.04538351f, 
    0.12238313f, -0.08982804f, 0.04552922f, -0.05606542f, -0.13500468f, 0.06968416f, -0.03686414f, -0.05848465f, 
    0.08504385f, 0.08591438f, -0.15640868f, -0.08679574f, 0.16028559f, 0.07712664f, -0.02234068f, -0.05359843f, 
    0.03327870f, 0.13807079f, 0.07616480f, 0.02235148f, -0.00849508f, -0.07650550f, -0.07164034f, -0.00289206f, 
    0.25896764f, -0.03986826f, -0.00985315f, 0.18985286f, -0.05931567f, -0.18849473f, -0.04968482f, 0.13522659f, 
    0.00687880f, -0.02775213f, 0.00023122f, 0.05152264f, -0.32118118f, -0.25281486f, -0.01931379f, 0.10388584f, 
    -0.11630202f, 0.08627352f, 0.08792748f, -0.01703523f, 0.05645200f, -0.00435016f, -0.00609501f, -0.01634042f, 
    -0.26650003f, 0.12162770f, 0.11241881f, 0.12982044f, 0.14538990f, -0.03312091f, 0.03943750f, -0.10620227f, 
    0.09176207f, 0.00707009f, -0.03076098f, 0.12266588f, -0.20904435f, -0.14967349f, 0.07014795f, 0.07605118f, 
    0.00368673f, 0.03313081f, -0.06338001f, -0.00030658f, 0.01574609f, 0.06924238f, 0.09988091f, -0.00754360f, 
    0.29214200f, 0.06006037f, -0.12668835f, 0.02072307f, -0.12524880f, -0.07198994f, -0.02537937f, 0.03003753f, 
    0.00399427f, -0.11418662f, -0.16157280f, -0.08258991f, 0.24561016f, 0.08466350f, 0.09239679f, -0.23179176f, 
    0.11982056f, -0.01537387f, 0.03808693f, 0.05159550f, 0.04802386f, -0.02375292f, 0.04457788f, 0.08017703f, 
    0.29193512f, 0.22899391f, 0.04899239f, -0.08597534f, -0.00602985f, -0.01292690f, -0.02305383f, 0.12642568f, 
    0.09043713f, 0.06971150f, 0.06480493f, 0.15385434f, -0.22058581f, 0.06485774f, -0.17842238f, -0.02140690f, 
    -0.00377197f, -0.13308522f, 0.01564710f, -0.02828897f, -0.00890698f, -0.00642535f, 0.08915821f, 0.07186919f, 
    -0.31552792f, -0.19803135f, -0.17008643f, -0.39366001f, 0.01675118f, 0.00531112f, -0.08970074f, 0.00357869f, 
    0.05244753f, 0.04583570f, 0.10584281f, 0.01243828f, -0.46861577f, -0.04036022f, -0.08024826f, 0.03147075f, 
    0.06361908f, -0.11252128f, 0.04586739f, -0.11887206f, -0.10791375f, -0.04271200f, -0.02493123f, -0.06359901f, 
    -0.15311839f, -0.03116635f, -0.12516782f, -0.04399905f, 0.12292054f, -0.04266854f, -0.10066435f, -0.04697853f, 
    -0.00399922f, -0.10476218f, -0.07061362f, 0.04430524f, -0.60749340f, -0.25524545f, -0.02968974f, -0.05398684f, 
    0.09376104f, 0.06078884f, -0.11613318f, -0.17097305f, 0.05053248f, -0.13659835f, -0.15282807f, 0.14257844f, 
    0.06434980f, -0.00036478f, -0.02018373f, 0.00956868f, 0.03293936f, -0.03906415f, 0.01476011f, -0.07621273f, 
    0.03998926f, 0.10022098f, -0.01411499f, 0.02201866f, -0.39230892f, -0.14818510f, -0.10022047f, -0.06249151f, 
    0.03896818f, 0.01226919f, 0.00679736f, -0.07957967f, 0.08300879f, -0.00562720f, 0.03713074f, 0.01361277f, 
    -0.19780567f, -0.06547015f, -0.10398129f, 0.05724396f, 0.01599425f, -0.09755067f, -0.02022583f, -0.07876705f, 
    0.05977752f, -0.02984194f, -0.14581063f, -0.07712507f, 0.08435133f, 0.02460925f, -0.05627950f, 0.00457847f, 
    -0.06103164f, -0.09719944f, -0.00616146f, 0.01895308f, -0.00667452f, -0.01718538f, 0.06311561f, -0.03539423f, 
    0.10961194f, 0.07978347f, 0.01092442f, -0.19669345f, -0.00313541f, 0.03751694f, 0.00995416f, -0.05828022f, 
    -0.11103564f, -0.02988336f, 0.02130939f, -0.03568770f, -0.39743161f, -0.19955875f, -0.06386122f, -0.14183757f, 
    0.09072313f, -0.05208507f, 0.04002826f, -0.04804632f, 0.11295356f, 0.03398566f, 0.01151904f, 0.13662969f, 
    0.11503287f, 0.03314561f, 0.01771206f, -0.11246925f, 0.03545612f, 0.00632619f, 0.02018712f, 0.01942087f, 
    0.06836648f, -0.01923890f, 0.05840914f, 0.06726258f, -0.38409445f, -0.03640651f, 0.08984786f, 0.11040272f, 
    -0.01213419f, -0.06248566f, -0.06580275f, -0.00754525f, -0.00205972f, -0.02525376f, 0.02228014f, 0.03951294f, 
    0.15359959f, 0.08753031f, -0.04921007f, -0.14400713f, 0.01920230f, -0.12767600f, 0.05054667f, 0.03143406f, 
    0.00841705f, 0.10948395f, 0.09493349f, 0.11544089f, -0.15348844f, -0.24798901f, 0.08649982f, -0.08695565f, 
    0.01990495f, 0.09448691f, 0.03617770f, -0.08865938f, 0.11264716f, 0.04167138f, 0.04464201f, 0.07130120f, 
    0.03756440f, 0.06391065f, -0.10475777f, 0.08356390f, 0.03204260f, 0.03400835f, -0.08089120f, 0.01867669f, 
    -0.06463974f, 0.02454737f, 0.03843567f, -0.09528039f, -0.43740556f, -0.21432003f, -0.02137695f, -0.03089119f, 
    0.04726500f, 0.03506697f, 0.05334771f, -0.08412566f, 0.02642406f, 0.09152974f, 0.03026659f, 0.10199919f, 
    -0.17317110f, 0.15849800f, 0.07758129f, -0.02205152f, -0.07377096f, -0.09074823f, 0.09665842f, -0.14635012f, 
    0.11184445f, 0.08439551f, -0.07850308f, -0.10542111f, 0.14692473f, 0.05025360f, -0.10520543f, 0.02636153f, 
    -0.08895936f, -0.01294720f, -0.05107968f, -0.02138491f, -0.00276489f, -0.00584285f, -0.01033419f, -0.07964793f, 
    -0.17864685f, -0.09665610f, -0.03511345f, 0.13604686f, -0.01930542f, 0.03822504f, -0.01111182f, -0.05500944f, 
    -0.02259810f, 0.01012898f, 0.16455948f, 0.03498331f, 0.12475399f, 0.10901399f, 0.02900114f, -0.22353710f, 
    0.02335003f, -0.03828806f, 0.06360810f, -0.11029638f, -0.12911074f, -0.00063542f, -0.07400134f, -0.03134984f, 
    0.04591662f, -0.03774846f, 0.05214009f, 0.00364847f, -0.06823813f, -0.03773591f, -0.02443983f, -0.02592683f, 
    0.05456350f, 0.13263644f, -0.02838306f, 0.00999514f, 0.13158074f, -0.06119293f, 0.04876015f, 0.09073531f, 
    -0.04477486f, 0.11472012f, -0.07673832f, 0.12839320f, 0.06762920f, 0.09177934f, -0.01645260f, 0.07197943f, 
    0.22786008f, 0.17616518f, 0.05886035f, 0.02236236f, 0.07640167f, -0.20831273f, 0.07175216f, 0.03136716f, 
    -0.00237682f, 0.04331925f, 0.06609014f, 0.08546801f, -0.20199762f, -0.35269672f, 0.03868787f, 0.05718820f, 
    0.05132112f, 0.05555469f, -0.04716723f, -0.01950388f, 0.08203057f, 0.03881465f, -0.00328997f, 0.14957239f, 
    0.05874596f, 0.09277587f, -0.04455601f, 0.03537677f, 0.04767342f, 0.07977834f, 0.09794251f, -0.01890590f, 
    0.07396752f, 0.06152564f, -0.03562436f, 0.03801626f, 0.24604207f, 0.16516952f, 0.02448872f, -0.02782687f, 
    0.13641675f, 0.00897441f, 0.10400563f, 0.07267045f, 0.01419073f, 0.12429034f, 0.06713194f, 0.10825164f, 
    0.13429059f, 0.10757297f, 0.04804494f, -0.01851281f, -0.16127701f, -0.11647904f, 0.02810756f, -0.01113964f, 
    0.02112985f, -0.14699437f, -0.11536027f, -0.21846691f, 0.10591555f, -0.00689611f, 0.07386684f, -0.05139515f, 
    -0.01176223f, -0.04241616f, 0.06928822f, 0.07266045f, -0.05902420f, -0.06252234f, -0.08190802f, -0.11681271f, 
    -0.58458757f, -0.20566826f, -0.14462225f, -0.35897866f, 0.01099219f, -0.06234944f, -0.03639634f, 0.08253425f, 
    -0.05644352f, 0.08899935f, 0.03854967f, 0.13743284f, -0.29370427f, -0.15624002f, -0.11429116f, -0.20473172f, 
    0.03537135f, 0.10664929f, 0.00735276f, -0.10144183f, 0.07844224f, 0.04003275f, 0.06229292f, 0.03529645f, 
    -0.10593868f, 0.11816595f, -0.11629578f, 0.03777824f, 0.13056731f, 0.17087422f, 0.03074103f, 0.05593902f, 
    -0.08439115f, 0.02008011f, 0.05628744f, 0.04629726f, -0.41329142f, -0.37800607f, -0.06537367f, -0.09338100f, 
    0.01410147f, -0.02660701f, -0.01617680f, 0.05453473f, -0.01827019f, 0.02048925f, -0.07796218f, -0.04333570f, 
    0.10858504f, -0.00046861f, -0.06842224f, -0.01078538f, -0.13584742f, 0.01506457f, 0.02802451f, -0.04200341f, 
    0.11331665f, -0.07363991f, -0.01357753f, -0.15530261f, -0.13047956f, -0.01323948f, 0.11544190f, -0.06672502f, 
    -0.01108006f, -0.08865316f, -0.04370514f, 0.04501014f, 0.03566774f, 0.20404908f, -0.04079412f, 0.04360975f, 
    0.24924070f, 0.08352540f, -0.07977032f, -0.08816460f, -0.11493382f, -0.00887338f, -0.06456731f, 0.04366973f, 
    0.05115832f, 0.04525628f, -0.09721469f, -0.02761783f, -0.00233191f, 0.05786167f, 0.12219573f, -0.21644895f, 
    0.06441849f, 0.11338388f, -0.12141813f, -0.02743358f, 0.03650134f, 0.02739174f, -0.15751325f, -0.03245568f, 
    -0.47352907f, -0.26862803f, -0.05768486f, -0.15327361f, 0.02821996f, -0.03348996f, -0.15900423f, -0.04345048f, 
    -0.00614749f, -0.08391045f, 0.00271505f, -0.03382260f, -0.24158941f, 0.13313122f, -0.04902178f, -0.08009166f, 
    0.11468462f, 0.01757701f, -0.06661756f, 0.10223172f, 0.07639828f, 0.02033725f, -0.03428571f, -0.05177472f, 
    -0.21116510f, -0.01703651f, -0.05084370f, -0.00735354f, -0.07672948f, -0.14118689f, -0.10101177f, 0.02552037f, 
    -0.02486815f, -0.13742714f, -0.06847327f, 0.03714414f, 0.08119253f, -0.08583742f, -0.12351514f, -0.01410792f, 
    -0.00731220f, -0.11118492f, 0.09921853f, 0.10305691f, -0.00264219f, 0.08705274f, 0.04411450f, 0.18096793f, 
    0.13228431f, -0.08922793f, -0.06152849f, 0.07630361f, -0.02803567f, 0.00841532f, -0.07715458f, 0.09233567f, 
    0.03120259f, 0.05797835f, -0.09281000f, 0.01626368f, 0.10329580f, -0.13609792f, 0.00115597f, -0.12339850f, 
    0.03894301f, -0.18553804f, -0.16534379f, 0.01105118f, -0.01867087f, -0.09547836f, -0.18463762f, -0.06142681f, 
    0.12040916f, 0.01701238f, -0.00627827f, 0.01469333f, -0.07006657f, 0.00561201f, -0.00507352f, -0.05310211f, 
    0.13717079f, -0.06686831f, 0.02972964f, -0.10325227f, 0.11785895f, 0.06662279f, -0.06410434f, 0.00871905f, 
    -0.00660100f, 0.02171769f, 0.11460309f, -0.00694766f, 0.07102374f, 0.16649766f, 0.06692407f, 0.10208087f, 
    -0.34175032f, -0.04223271f, 0.18358113f, 0.31419489f, 0.02281093f, 0.03226934f, -0.07436437f, 0.16533530f, 
    -0.13324574f, -0.08733886f, 0.14202285f, 0.07143287f, 0.25027657f, -0.04486925f, 0.01810962f, 0.02386367f, 
    0.03639996f, -0.08941647f, -0.08974133f, -0.01781514f, 0.16114661f, -0.05892752f, 0.02378733f, 0.03524503f, 
    0.50151575f, 0.15867765f, -0.12588076f, -0.05393797f, 0.06366223f, 0.01720700f, -0.14452451f, 0.08828418f, 
    0.07272512f, 0.06394298f, 0.02264827f, 0.01918007f, 0.03337218f, 0.15744846f, 0.06430110f, -0.03756404f, 
    -0.05596717f, 0.10455468f, 0.04015828f, -0.00605408f, -0.00397247f, 0.01202589f, -0.05027666f, -0.09193375f, 
    -0.23568580f, -0.11355028f, 0.06935376f, -0.10114611f, -0.16338591f, -0.06618731f, -0.17137361f, -0.02277938f, 
    -0.06463672f, 0.09236628f, 0.16969302f, -0.01337613f, -0.01960335f, 0.05295479f, 0.14687651f, -0.05986863f, 
    -0.08454771f, 0.08354194f, -0.08313216f, -0.00240802f, -0.04357507f, -0.12903805f, -0.00497900f, -0.13061117f, 
    0.22571889f, -0.05235853f, 0.02086645f, 0.04817099f, 0.04858522f, -0.01827902f, 0.07205223f, 0.02556716f, 
    -0.05998130f, 0.00545303f, 0.05546600f, -0.15082106f, -0.20626870f, 0.09782585f, 0.02001949f, -0.01155086f, 
    -0.02389079f, 0.04737204f, 0.05859452f, 0.05154864f, -0.07420707f, 0.01419257f, 0.08355284f, -0.01058470f, 
    -0.12160315f, 0.02116664f, 0.02291933f, 0.02155634f, -0.12561683f, -0.04036812f, -0.02042407f, -0.06513613f, 
    0.15923713f, -0.05211978f, 0.08787978f, 0.17957780f, 0.07411865f, -0.02049268f, 0.14701720f, -0.05099428f, 
    -0.03005195f, -0.04432104f, -0.10009560f, -0.00840284f, -0.13582526f, -0.05661871f, -0.01365496f, 0.02632016f, 
    -0.01475064f, -0.05390467f, -0.04275536f, 0.06306726f, -0.08025005f, 0.09371472f, -0.06792159f, -0.15689881f, 
    -0.08625307f, 0.01744984f, -0.06946035f, -0.01726548f, -0.10443669f, 0.08299267f, -0.14339958f, 0.00092480f, 
    0.07718696f, -0.03013331f, 0.14928472f, 0.02932351f, -0.02378378f, 0.03236042f, 0.02820153f, 0.02065569f, 
    0.00804048f, 0.03021113f, 0.13908057f, 0.13742134f, 0.09131997f, -0.08125356f, 0.10320157f, -0.10501327f, 
    -0.08324288f, 0.05099986f, 0.00259818f, 0.13165987f, -0.08603107f, 0.12730902f, -0.21784800f, 0.09747005f, 
    0.09121507f, -0.01088428f, 0.05797634f, -0.08164664f, 0.02837146f, -0.02627924f, 0.02914802f, -0.03031297f, 
    0.21940988f, -0.09481122f, 0.07275233f, 0.07297878f, -0.03194428f, -0.21116750f, -0.04484591f, -0.00261163f, 
    -0.00310078f, -0.07108318f, 0.10221808f, 0.00179497f, -0.05725247f, -0.17620653f, -0.07065393f, 0.09409432f, 
    0.00603024f, -0.12869528f, -0.00399103f, -0.00911465f, -0.03404979f, -0.04354115f, -0.14080046f, -0.02743373f, 
    -0.23532780f, -0.03801034f, -0.02873365f, 0.15632229f, 0.03181396f, 0.05948194f, 0.03502849f, 0.02373133f, 
    0.09001163f, -0.04500240f, -0.00073824f, 0.02466921f, 0.29547212f, -0.04270142f, -0.23169899f, 0.30817220f, 
    0.08663793f, -0.07373816f, 0.08250945f, 0.09483802f, 0.02786773f, 0.10134130f, 0.06144693f, -0.01758084f, 
    0.06964967f, -0.15055747f, -0.07419303f, 0.25897005f, 0.03004183f, -0.00124927f, 0.04895130f, -0.00341779f, 
    0.06629251f, -0.03018407f, 0.04117168f, -0.00151521f, -0.29462719f, -0.05212745f, 0.03076257f, 0.05784177f, 
    -0.07654089f, 0.20533416f, -0.13263822f, 0.13381098f, -0.09530202f, 0.05702753f, -0.06010131f, -0.09190138f, 
    0.26721635f, -0.19538882f, -0.20527050f, -0.11167199f, -0.01840565f, -0.04965146f, 0.01045809f, -0.05863231f, 
    0.01094077f, 0.00150951f, 0.00140157f, 0.00969054f, 0.19876178f, -0.05948865f, -0.06245124f, 0.01543480f, 
    -0.07360005f, 0.06871372f, -0.06182201f, -0.12576315f, 0.06786684f, 0.02524065f, 0.08770582f, 0.00584217f, 
    -0.23038545f, 0.15082225f, -0.13156857f, -0.21778718f, -0.06637010f, -0.02660237f, 0.07311177f, 0.06776104f, 
    0.06302534f, 0.01208658f, -0.04292123f, 0.03793043f, 0.07332715f, 0.22495255f, -0.00617179f, -0.10133284f, 
    0.05286986f, 0.01201687f, -0.01146572f, 0.03771669f, 0.03579414f, 0.02553272f, 0.05565993f, 0.00348594f, 
    0.12304000f, -0.15254048f, 0.06913390f, 0.00730198f, -0.13557491f, 0.05335354f, -0.03202164f, -0.06344247f, 
    -0.10436711f, -0.11216316f, 0.00643947f, -0.11987008f, -0.14594343f, 0.20980752f, -0.14221780f, -0.19144933f, 
    0.11802067f, 0.00737957f, -0.00665672f, 0.12009615f, 0.04391814f, -0.00013500f, -0.08803324f, 0.03655144f, 
    -0.04116438f, 0.03739743f, -0.09398805f, 0.14439952f, 0.11028841f, 0.00235039f, 0.06346493f, 0.12609427f, 
    0.02382622f, 0.04566037f, 0.08859060f, 0.00958795f, 0.04914435f, -0.00848945f, 0.03856058f, -0.00595639f, 
    0.00146407f, -0.01111623f, 0.03895519f, 0.07044467f, -0.01984739f, 0.03866635f, -0.09740953f, -0.05840302f, 
    0.10425348f, 0.24509254f, 0.00894867f, -0.10446652f, -0.11599328f, 0.09136708f, -0.03538491f, -0.01544493f, 
    0.02452210f, 0.00256667f, -0.04227598f, -0.09529864f, 0.47679082f, -0.16019386f, -0.15199506f, 0.10209473f, 
    0.08428214f, -0.08551812f, -0.04935852f, -0.02780066f, 0.04797275f, -0.01628415f, -0.01117902f, -0.04953294f, 
    -0.01116391f, 0.17320350f, -0.10486540f, -0.09099121f, -0.05052801f, 0.04797215f, 0.05593608f, -0.14499961f, 
    -0.05315847f, 0.08281855f, 0.04663689f, -0.10512020f, -0.15670741f, -0.14580221f, 0.07428586f, -0.15435486f, 
    -0.08192699f, -0.06549299f, -0.07266466f, 0.10057540f, 0.04230202f, -0.05024447f, -0.01579941f, 0.01390445f, 
    0.22467595f, 0.02971887f, -0.25860909f, 0.04159553f, 0.04571819f, -0.03759483f, -0.02370025f, 0.17512599f, 
    -0.07131255f, -0.06684201f, 0.01232252f, -0.08602609f, -0.19305162f, 0.26743919f, -0.10028511f, 0.05558685f, 
    0.14897938f, -0.01665434f, -0.21514167f, -0.02199258f, -0.01528902f, 0.06803825f, -0.05727149f, 0.07422359f, 
    -0.22331201f, 0.17422195f, 0.05755289f, -0.14657214f, 0.05735496f, -0.03626614f, 0.06390472f, -0.04516652f, 
    -0.02810202f, 0.03679817f, 0.06301744f, -0.02171236f, 0.11220669f, 0.16237907f, -0.06557871f, -0.12349193f, 
    0.13095604f, -0.00596022f, -0.01378475f, 0.03080309f, 0.01136084f, 0.01460871f, 0.07674734f, -0.04214188f, 
    -0.14627677f, 0.20680209f, 0.09775601f, -0.02022678f, 0.08595883f, -0.07147523f, -0.09947232f, 0.15081993f, 
    -0.05244552f, -0.12242573f, 0.11878108f, -0.13845235f, -0.18719459f, -0.32512811f, 0.15405701f, -0.15291923f, 
    0.03184775f, 0.00339321f, -0.09832677f, 0.05320451f, 0.00302912f, 0.09230673f, 0.03268604f, 0.01222864f, 
    0.23580846f, -0.10814959f, 0.01944892f, -0.04866785f, 0.14108311f, -0.10304543f, -0.04161172f, 0.06201650f, 
    -0.02070548f, -0.01288458f, -0.08790925f, 0.03069039f, 0.15544248f, 0.10071796f, 0.00471528f, -0.11602358f, 
    -0.14819649f, -0.11911722f, 0.04661966f, -0.08592583f, -0.04394732f, 0.01075488f, 0.03980900f, -0.04864514f, 
    0.03839554f, -0.01840417f, -0.04126643f, 0.11147545f, -0.00811835f, 0.09233463f, -0.08164227f, -0.02103071f, 
    -0.10914619f, -0.00365490f, 0.01972395f, 0.08592827f, -0.03444676f, 0.12135237f, 0.11083691f, -0.28323305f, 
    -0.03137383f, -0.11583633f, 0.04317389f, -0.10843071f, -0.04409382f, -0.06096349f, -0.01582650f, -0.07255894f, 
    0.03875281f, 0.10564101f, 0.06931984f, -0.13827334f, 0.03454472f, 0.07458116f, -0.00613134f, -0.10224408f, 
    -0.03852196f, -0.06992663f, 0.00530454f, 0.01455434f, 0.16557947f, 0.03951429f, -0.07803006f, 0.13859321f, 
    0.06046510f, 0.00334142f, -0.01043273f, 0.15620002f, -0.02932999f, -0.06439092f, -0.00436707f, -0.02140438f, 
    0.03134582f, 0.14190187f, -0.00231436f, 0.07353241f, 0.05222372f, -0.16822089f, 0.01052399f, 0.03595792f, 
    0.07384963f, 0.04028979f, -0.05359944f, -0.03253969f, -0.05801021f, 0.12577766f, 0.00674531f, -0.00520311f, 
    0.08936770f, -0.10421561f, -0.06070686f, 0.01122319f, 0.03077587f, -0.06242172f, -0.10924701f, -0.05605581f, 
    0.08891418f, -0.28401613f, -0.06718779f, -0.00051226f, 0.00451297f, 0.03727570f, -0.01268792f, -0.05407500f, 
    0.13390552f, 0.07392607f, 0.02738587f, 0.10291316f, -0.24538110f, 0.00973344f, -0.16785379f, -0.06955973f, 
    0.03023978f, -0.08185253f, 0.05741636f, 0.11777476f, 0.02413049f, 0.14729451f, 0.02042458f, -0.02413595f, 
    0.08121037f, -0.04571709f, -0.04351981f, -0.09537330f, -0.02069203f, 0.03088998f, -0.05213213f, -0.01411763f, 
    0.05433832f, -0.09628726f, -0.04544134f, -0.05515888f, -0.11986891f, -0.48297027f, -0.09839104f, -0.14627543f, 
    0.08105493f, 0.01731255f, -0.04232856f, 0.02476476f, 0.04439861f, -0.09130181f, -0.08987638f, 0.00973066f, 
    -0.27720085f, 0.18995686f, 0.11037809f, -0.12735356f, -0.16342501f, 0.00160652f, -0.12040703f, -0.07205942f, 
    -0.01444936f, -0.05474761f, 0.00234691f, -0.03774037f, -0.16751775f, -0.01246397f, -0.13235612f, -0.33992264f, 
    0.16553125f, -0.03879413f, -0.00189094f, 0.03363470f, 0.04729572f, 0.00729352f, -0.09332632f, 0.06788355f, 
    -0.30921549f, 0.09068779f, -0.11195915f, -0.01233699f, -0.16193990f, 0.01697746f, -0.04920147f, -0.00913897f, 
    0.00760856f, -0.00271811f, -0.02653596f, -0.06935374f, 0.23669745f, 0.10020402f, -0.07673723f, 0.11727144f, 
    -0.08130291f, -0.04190079f, -0.05596631f, 0.09317393f, 0.07887903f, -0.06077826f, -0.09497642f, -0.05379980f, 
    -0.27510357f, -0.05342197f, 0.13634743f, -0.14261995f, 0.03011810f, -0.05748243f, -0.07065634f, 0.12718064f, 
    -0.10912622f, -0.07764351f, -0.00835589f, -0.15482600f, 0.01208153f, 0.07308245f, -0.06417926f, -0.09116612f, 
    0.06336846f, 0.00287463f, -0.01313539f, 0.09888446f, 0.07226750f, 0.04352068f, 0.08932649f, -0.00993460f, 
    0.09527550f, -0.09517287f, -0.08066517f, -0.35502970f, -0.00211368f, 0.02120820f, -0.06003595f, 0.10412167f, 
    0.01701550f, 0.04406989f, -0.06793620f, -0.00421725f, -0.18567447f, -0.08083291f, 0.08056651f, 0.22219630f, 
    -0.18634640f, 0.09953462f, -0.01940448f, 0.03551538f, 0.11249217f, 0.01701426f, 0.04838550f, 0.06645586f, 
    0.07323515f, -0.17370217f, -0.12175047f, 0.03698973f, 0.07917788f, 0.04193664f, 0.08636650f, -0.00749276f, 
    -0.15966985f, 0.09742320f, 0.04987749f, 0.01102316f, -0.07282587f, -0.12354536f, 0.04348605f, -0.04554748f, 
    -0.04802514f, 0.05866474f, 0.02804569f, 0.04991374f, -0.07377905f, -0.12037037f, -0.02047192f, -0.02411389f, 
    -0.18948556f, 0.17244270f, 0.00795133f, 0.00152078f, 0.01290756f, -0.06495640f, 0.02431701f, -0.02147688f, 
    -0.03499290f, -0.02261612f, 0.03870392f, -0.07439779f, -0.20354532f, -0.12157701f, 0.03403481f, -0.29862911f, 
    -0.03191066f, 0.01482872f, 0.05565432f, 0.01524262f, -0.01257032f, -0.03795213f, -0.04721039f, 0.03171762f, 
    -0.20203607f, 0.05662482f, 0.00902807f, 0.08223913f, -0.07388525f, -0.05178593f, -0.07893343f, -0.18858393f, 
    -0.01842364f, -0.06771013f, 0.06010021f, -0.04152209f, -0.07700067f, 0.10157106f, -0.01343911f, 0.14202470f, 
    -0.07460020f, -0.02483062f, -0.08708162f, 0.01567965f, 0.01911142f, -0.11824166f, 0.00638436f, -0.04575599f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04101195f, 0.03488765f, -0.03328558f, 0.01953279f, 0.00206575f, 0.03449757f, -0.02187910f, -0.09718316f, 
    0.01225972f, -0.02833631f, 0.08057352f, 0.00347917f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
