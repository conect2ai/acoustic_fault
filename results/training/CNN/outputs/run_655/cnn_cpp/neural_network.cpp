#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.20284426f, 1.16810846f, 1.25794208f, -0.88901019f, 0.23507339f, -0.58868456f, 0.30165213f, 0.08964815f, 
    -0.04850704f, -1.11680734f, -0.06228743f, -0.94218427f, -0.96168602f, 0.43717375f, 0.81969094f, 0.32004327f, 
    0.14105937f, 0.69021416f, 1.21946895f, -0.74576139f, 0.77242988f, 0.03824028f, -0.28481790f, -0.79070526f, 
    0.60718066f, 0.74209148f, 0.35109305f, 1.46474946f, -0.27639043f, -0.71589404f, -0.14403503f, -0.72833622f, 
    -0.00131532f, -0.57223350f, 0.40648729f, 0.58992636f, 0.57241499f, 1.24027622f, -0.51537490f, -1.19163787f, 
    -0.66878396f, -0.77507764f, 0.05039695f, 0.25060448f, -0.55814040f, -0.76121658f, -1.26841593f, -0.75785124f, 
    -0.00540659f, 0.48658249f, 0.40794393f, -0.42408085f, -0.18493333f, -0.32617041f, -0.21691577f, -1.33464527f, 
    0.35785243f, -0.92029279f, 1.22242105f, 0.17758308f, -0.08002313f, 0.43598399f, -0.01187274f, 0.04130251f, 
    -0.60901892f, -0.39368868f, -1.16997313f, -0.89336663f, -1.11979651f, 0.36291462f, -0.11784299f, 0.22094058f, 
    -0.87181675f, -0.03814780f, -1.01740670f, -0.09491096f, 0.26056793f, -1.09397781f, -0.06557462f, -0.31709519f, 
    0.17499819f, 0.31740561f, -1.00715744f, -1.10372579f, -0.01557091f, 0.48423421f, 0.56695455f, -0.48674008f, 
    0.49062929f, -0.54836398f, 1.51244247f, 0.85182393f, -0.80183351f, 0.32078251f, 0.76848799f, -0.30099526f, 
    0.25478771f, 0.01905023f, -0.10942543f, -1.01172781f, 0.14336365f, -0.63231963f, 0.56440604f, 1.41398954f, 
    -0.84814906f, -0.15905334f, 0.20663129f, 0.48457485f, 1.01497972f, 0.89071155f, 0.65754306f, 0.20940019f, 
    -0.00500320f, 1.02501619f, -0.64049977f, -0.67919737f, -0.09008123f, -0.72307402f, -0.16726615f, -0.78172660f, 
    0.57966858f, 1.43150711f, 0.95730960f, 0.12175515f, -0.53639108f, -0.11974169f, 0.94116825f, -0.73636174f, 
    -1.01394963f, 0.82117343f, -0.33974013f, -0.24066192f, -0.41923106f, -0.15582898f, -0.31629977f, -0.58064747f, 
    -1.14148533f, 0.30332589f, -0.69209737f, -0.89973491f, -0.24173571f, 0.46473500f, 0.25875527f, -0.31436795f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26649067f, 0.30785036f, -0.11480320f, -0.02396148f, 0.30643445f, 0.26273918f, 0.22872782f, 0.11917864f, 
    0.06273958f, 0.16714999f, 0.31393522f, 0.03529938f, 0.15845260f, 0.09548633f, 0.12921987f, 0.15114965f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13742690f, 0.03743234f, 0.18535046f, -0.02417327f, -0.13717701f, 0.10853685f, 0.05946514f, -0.11257392f, 
    -0.10835338f, -0.07572468f, 0.04902617f, 0.11520872f, -0.06758746f, -0.06375245f, -0.11098769f, 0.08743528f, 
    0.07399090f, -0.14307551f, 0.05214278f, -0.09568776f, 0.26382452f, -0.10542978f, 0.26005793f, 0.18512493f, 
    0.04908248f, -0.03293000f, 0.00365882f, 0.14988022f, -0.08999541f, 0.10335238f, -0.05536369f, -0.03978739f, 
    -0.08622308f, -0.01222941f, -0.02000717f, -0.02541351f, -0.04977961f, -0.21736869f, 0.08807649f, -0.15439086f, 
    0.22545820f, 0.32007548f, -0.36842170f, -0.37633026f, -0.04928984f, 0.02791617f, -0.02580593f, -0.16889630f, 
    -0.20390853f, -0.14645827f, -0.19842663f, 0.04161136f, -0.05110465f, -0.03138025f, -0.10549293f, 0.01341035f, 
    -0.00680506f, 0.20615973f, -0.10970047f, -0.07540613f, -0.05223990f, 0.48287264f, -0.30475518f, -0.04513928f, 
    -0.17583847f, -0.03867429f, 0.12315778f, 0.01816744f, -0.08024240f, 0.01665367f, -0.04258330f, 0.11839304f, 
    -0.12947960f, 0.12824997f, 0.11771385f, 0.08001161f, 0.36689234f, 0.15225141f, -0.02695110f, 0.06781308f, 
    -0.28337583f, 0.27259606f, 0.01183530f, -0.03835453f, -0.25696045f, 0.00945291f, 0.14251101f, 0.02441136f, 
    -0.09838599f, 0.08015005f, 0.06608081f, 0.02142118f, -0.04211409f, -0.15341784f, -0.11612957f, 0.12374275f, 
    0.13810933f, 0.15112101f, 0.21960358f, 0.15979281f, -0.01704344f, -0.20615579f, 0.37670082f, 0.03292232f, 
    0.30080608f, -0.01880675f, 0.06605149f, 0.03835574f, 0.04757538f, 0.08980925f, -0.09762512f, -0.16728269f, 
    0.12524644f, 0.15125166f, 0.07982285f, 0.04853545f, 0.08721613f, 0.04304222f, 0.15168177f, 0.16079032f, 
    0.50084406f, -0.07687784f, 0.28829816f, -0.19739416f, 0.01284315f, -0.01740045f, 0.04542880f, -0.00540549f, 
    -0.03157231f, -0.01668756f, -0.08093327f, -0.02525471f, 0.15909930f, 0.11975752f, 0.11439051f, -0.09560667f, 
    0.08291747f, 0.02046990f, 0.14762853f, -0.00604691f, -0.04567482f, 0.10595601f, -0.22193862f, -0.18384121f, 
    -0.02154329f, 0.05520653f, 0.08688521f, -0.08748703f, -0.10723072f, -0.09602211f, 0.04130415f, -0.04579936f, 
    -0.21262281f, -0.15909894f, -0.02808028f, 0.09765697f, 0.01586015f, 0.18458556f, 0.11665667f, 0.00744812f, 
    -0.07792664f, -0.11913086f, 0.15141290f, -0.15253820f, 0.09502134f, 0.05341255f, 0.07241631f, -0.12592833f, 
    -0.10161268f, -0.09626738f, -0.08142839f, -0.05779299f, -0.11408588f, 0.09228323f, -0.02117524f, 0.17715232f, 
    -0.06190139f, 0.29310319f, 0.26982602f, 0.21263538f, 0.02566682f, 0.30302039f, 0.12839727f, 0.07320898f, 
    0.02636855f, -0.00825933f, -0.03087361f, 0.14025173f, 0.15833294f, 0.08536957f, -0.03151236f, -0.01878351f, 
    0.12093206f, 0.13787645f, 0.09358843f, 0.02050588f, -0.04892583f, -0.05370256f, 0.03388217f, 0.11159824f, 
    -0.28833386f, 0.53147632f, -0.09973828f, 0.06964842f, -0.23397638f, 0.08320483f, 0.04871126f, 0.09178951f, 
    0.07880156f, 0.03762946f, 0.03107062f, -0.01107497f, -0.01072757f, 0.00799717f, 0.01742371f, 0.21411771f, 
    -0.08443552f, 0.07892820f, -0.32797363f, -0.04906543f, 0.58779138f, -0.08471626f, 0.09083891f, 0.21661289f, 
    0.19464675f, 0.02060041f, 0.07527842f, -0.04340595f, 0.05762898f, 0.04632113f, -0.06832025f, -0.14588585f, 
    -0.14413369f, 0.13294281f, -0.00746960f, -0.02693040f, -0.04586249f, 0.00575960f, 0.01934489f, 0.04007746f, 
    -0.35338432f, 0.12794521f, -0.26029021f, 0.08963681f, -0.18269369f, 0.01528055f, 0.04093128f, -0.02084534f, 
    0.13711286f, -0.15808088f, -0.06360812f, -0.03503997f, 0.04945599f, 0.02114926f, 0.07847645f, 0.08545923f, 
    0.08559243f, -0.45033029f, -0.37723756f, -0.13084735f, -0.03927572f, -0.63077867f, -0.07996451f, 0.14035130f, 
    0.19155253f, 0.01780827f, 0.01692938f, 0.13668706f, 0.27074686f, 0.20241791f, -0.20175262f, -0.10450051f, 
    0.20376348f, 0.18191357f, -0.07261812f, -0.10792407f, 0.10531429f, -0.21134789f, 0.04974094f, -0.13675532f, 
    -0.16020420f, 0.30935046f, -0.04211855f, 0.22015095f, 0.13436159f, 0.04040942f, -0.11696741f, 0.15705670f, 
    0.08792495f, -0.11501290f, -0.16389294f, -0.04328194f, -0.18272418f, 0.09056047f, 0.17577134f, 0.09261658f, 
    0.17813404f, 0.27854657f, -0.13028097f, 0.18984768f, 0.25834525f, -0.18125848f, -0.10371915f, -0.18568999f, 
    0.01340169f, -0.00865844f, 0.08714098f, -0.16747741f, -0.19351593f, -0.14265527f, -0.09054352f, 0.01639440f, 
    -0.10196225f, -0.13409194f, -0.07972994f, -0.05971898f, -0.08457883f, 0.00192943f, 0.42955172f, 0.16574247f, 
    0.04176911f, -0.10077675f, -0.16448554f, -0.22517879f, 0.33934298f, -0.15053980f, -0.06961974f, -0.02166126f, 
    0.04055296f, -0.03709257f, 0.03300989f, 0.03225392f, -0.15291511f, -0.11535953f, -0.09348716f, -0.00824532f, 
    0.12489150f, 0.00185244f, 0.01323320f, 0.08465454f, 0.60131550f, 0.21365838f, -0.07548984f, 0.14551555f, 
    -0.16723579f, -0.10722654f, -0.08745534f, -0.11057766f, 0.05288344f, 0.07060248f, -0.10681106f, 0.05804354f, 
    -0.01879853f, -0.09178943f, 0.08776542f, 0.07131507f, -0.12025128f, 0.01785625f, 0.08198567f, -0.17974138f, 
    -0.18525450f, -0.07411633f, 0.00479768f, -0.23349622f, -0.29608506f, -0.02539576f, 0.02591701f, -0.18580623f, 
    0.09611285f, -0.17685527f, -0.03192829f, 0.08145170f, 0.01474522f, -0.06929803f, -0.03097125f, -0.02085107f, 
    -0.12062561f, 0.08550823f, 0.03588068f, -0.01894260f, -0.08899505f, 0.14256805f, -0.02051312f, -0.01007272f, 
    -0.18406016f, -0.02015403f, 0.06668879f, 0.01651610f, 0.15743494f, -0.08765186f, -0.10415860f, 0.16859613f, 
    -0.05687467f, 0.08259585f, 0.05111605f, 0.05341174f, 0.08710665f, 0.06982467f, -0.05426708f, -0.06816621f, 
    -0.00043652f, -0.13852409f, 0.16027631f, -0.21830785f, 0.29654440f, -0.09264369f, -0.01443109f, 0.00436141f, 
    -0.10916358f, 0.06259155f, 0.10645626f, 0.10419010f, 0.10275234f, -0.25238192f, -0.03120699f, -0.01846130f, 
    -0.02423942f, 0.19063102f, 0.02106345f, -0.01193281f, 0.12728414f, 0.00061061f, 0.26744002f, 0.33086878f, 
    -0.18095239f, -0.05343730f, 0.05181191f, -0.03134996f, 0.10199678f, 0.06335915f, 0.05598212f, -0.04554084f, 
    0.17325647f, 0.07711170f, -0.00921275f, -0.07007112f, -0.11636362f, 0.14468655f, 0.08737807f, -0.00992401f, 
    -0.11209445f, 0.07609995f, 0.11483603f, -0.01405931f, 0.13646871f, -0.11710975f, -0.00280288f, -0.01256678f, 
    0.00074638f, 0.11968086f, -0.03106763f, 0.13413218f, -0.14854461f, 0.06759261f, 0.05584229f, -0.03237975f, 
    0.05762111f, 0.11861066f, 0.00073276f, -0.15568858f, 0.24275711f, -0.21780919f, 0.12137076f, 0.20301212f, 
    -0.10590142f, -0.00894141f, 0.07179984f, -0.02596020f, 0.04977112f, 0.01063109f, 0.09958261f, 0.05481657f, 
    -0.13789234f, -0.19267358f, 0.01088068f, 0.04623889f, -0.14741643f, 0.24129206f, 0.26263115f, 0.06069362f, 
    0.41265932f, -0.20022115f, 0.10579853f, -0.02205934f, -0.23567615f, 0.10928163f, -0.06022681f, 0.01688271f, 
    0.09740484f, 0.04296454f, 0.01953141f, 0.11687814f, -0.01391485f, -0.01123468f, -0.03855405f, 0.08657861f, 
    -0.15831727f, 0.21858087f, 0.11553618f, -0.12113962f, 0.23852362f, 0.16859268f, 0.17200418f, 0.41456625f, 
    -0.17872155f, -0.10941697f, 0.00872521f, 0.09442732f, -0.05360429f, 0.19787769f, -0.01909938f, 0.02867193f, 
    0.26123092f, 0.03996604f, -0.01509808f, 0.11462763f, -0.14131559f, 0.06967180f, -0.01061266f, -0.05381820f, 
    0.10011080f, -0.03702135f, 0.25582799f, -0.32738128f, 0.13790694f, -0.18297957f, -0.05036524f, 0.15319949f, 
    0.15126848f, -0.06252609f, -0.03947796f, 0.05770318f, -0.04801938f, 0.10082478f, -0.09518208f, 0.05634610f, 
    -0.02953480f, 0.04436220f, -0.09132388f, -0.00181645f, 0.74475920f, 0.12611076f, 0.31729335f, -0.10048359f, 
    0.05979536f, 0.13637763f, -0.06987805f, -0.03008764f, -0.00002510f, 0.04958552f, -0.06087437f, 0.02167131f, 
    -0.10769678f, 0.08828032f, -0.03348961f, -0.04946632f, -0.14648297f, 0.17666122f, -0.02167423f, -0.06834515f, 
    0.11107456f, -0.25529274f, -0.25647381f, -0.20257518f, -0.00753020f, -0.05585965f, -0.08255149f, 0.10031320f, 
    0.05213889f, -0.09299573f, -0.01085518f, 0.00922300f, 0.13207576f, -0.09398073f, -0.11622644f, 0.01597298f, 
    0.02489903f, -0.11340640f, -0.17081232f, 0.12138673f, 0.21940370f, 0.17809060f, 0.22600466f, 0.05526916f, 
    0.00154505f, 0.07489087f, 0.06606214f, -0.05889949f, 0.10643732f, 0.01598291f, 0.01941422f, 0.07630418f, 
    0.11706588f, 0.01050114f, 0.03739387f, 0.04999717f, 0.03783724f, -0.13608123f, 0.04715123f, 0.07579984f, 
    0.21392305f, 0.07701521f, 0.37681499f, 0.53406549f, -0.05761857f, 0.17161593f, 0.01748744f, 0.00287259f, 
    -0.09522486f, -0.03448737f, -0.17956099f, 0.11769556f, 0.06102013f, 0.06148391f, 0.08545236f, 0.14383745f, 
    0.12494916f, -0.00566697f, -0.19294137f, 0.19882666f, 0.10591845f, -0.35557374f, -0.07272379f, 0.31459352f, 
    0.02949357f, -0.20455764f, 0.09539304f, -0.10336079f, 0.02418832f, -0.03218364f, -0.01013516f, 0.12324440f, 
    -0.04482554f, -0.14546859f, -0.10500427f, 0.04996485f, 0.09290433f, -0.04603659f, 0.35471079f, -0.03520494f, 
    -0.00288633f, -0.01024126f, -0.03333296f, 0.00499289f, -0.01379086f, 0.03599785f, -0.05685922f, -0.03408700f, 
    -0.00607583f, -0.02340263f, -0.01667546f, -0.03640260f, -0.04238758f, 0.04214013f, 0.04407636f, 0.04573805f, 
    0.03981520f, 0.03282438f, 0.04892826f, 0.03464876f, -0.04361241f, 0.02951283f, -0.05015092f, 0.01695044f, 
    -0.00684588f, 0.03196500f, -0.06076473f, -0.05286118f, -0.02799873f, 0.04525407f, -0.04834101f, 0.01241705f, 
    -0.04446143f, -0.02261982f, -0.03457161f, 0.03605435f, -0.05930268f, 0.03684002f, 0.02282636f, 0.04782074f, 
    0.02030144f, -0.01472804f, -0.02088246f, -0.00486511f, 0.00914183f, 0.03540902f, -0.00502203f, -0.01529554f, 
    0.00587722f, -0.01524267f, -0.01451976f, -0.03192124f, -0.02017251f, -0.03305900f, -0.00018730f, -0.05741481f, 
    -0.03144381f, 0.01206533f, -0.02869842f, -0.01233884f, 0.01342454f, -0.01798225f, 0.01548895f, -0.03925976f, 
    -0.00800403f, -0.04471416f, -0.04524812f, -0.03373340f, -0.02991642f, -0.02802959f, 0.01051973f, 0.03838681f, 
    -0.03180543f, -0.04847466f, -0.03955309f, 0.01637490f, -0.01943207f, -0.01014603f, -0.02362343f, 0.03631013f, 
    -0.02489468f, -0.02290192f, 0.01718619f, 0.02457122f, 0.03453933f, -0.00197696f, -0.03542887f, -0.05860164f, 
    0.00124428f, 0.03501997f, 0.01662063f, 0.01071980f, -0.04087215f, -0.00956246f, 0.02006703f, 0.01080068f, 
    0.02477759f, 0.02512039f, -0.01351046f, -0.04018229f, 0.04470956f, -0.00974459f, -0.05689162f, -0.01289538f, 
    0.03677104f, -0.05113240f, 0.02986548f, -0.02161846f, -0.00117526f, -0.05407365f, 0.04203168f, 0.02430281f, 
    -0.04868061f, -0.02881023f, -0.01035008f, -0.02640588f, -0.00562339f, -0.05029960f, 0.03994728f, 0.03252166f, 
    0.04360862f, 0.02297930f, -0.05299084f, 0.02144196f, -0.05166268f, -0.01495700f, -0.05086711f, -0.04104708f, 
    -0.02057648f, -0.02161661f, -0.05161824f, 0.03608524f, -0.06066226f, 0.01458159f, -0.01722365f, 0.03672200f, 
    0.00258473f, 0.02750983f, -0.04941000f, 0.02323817f, -0.02887587f, 0.03067623f, -0.05873152f, 0.01730434f, 
    -0.04677485f, 0.00450970f, 0.03157219f, 0.00371705f, -0.00394149f, -0.03577347f, -0.03721563f, -0.03114583f, 
    -0.01629312f, 0.03653585f, 0.05106059f, -0.01293835f, 0.00726729f, -0.00809044f, -0.02526528f, -0.01694257f, 
    0.00560519f, -0.02833944f, 0.03527777f, 0.02238801f, 0.03033581f, -0.00072110f, 0.02103723f, -0.05171206f, 
    -0.01374237f, -0.05033342f, -0.00180240f, -0.01837806f, 0.02201584f, -0.02899345f, 0.01830877f, -0.04793462f, 
    -0.02976402f, 0.02255790f, 0.04819602f, -0.05300294f, -0.05009162f, 0.03458427f, 0.02833345f, -0.05244348f, 
    -0.01949794f, 0.03725417f, -0.05691740f, 0.02461096f, -0.04304010f, 0.02768801f, 0.01656387f, -0.02152777f, 
    0.03379820f, -0.04494485f, -0.05801547f, 0.02215503f, -0.05356117f, -0.02282428f, 0.00224763f, 0.01751417f, 
    -0.01542547f, -0.00682599f, -0.03678546f, -0.05351693f, -0.03747238f, 0.01952669f, -0.00901436f, -0.00283157f, 
    -0.02474329f, -0.00593917f, 0.02877367f, 0.03811754f, -0.02097023f, -0.03815715f, 0.01248871f, -0.01435661f, 
    -0.06139134f, -0.01840284f, -0.01036916f, 0.03089799f, -0.04706966f, -0.05923836f, -0.05993232f, -0.04778693f, 
    0.00419959f, -0.00403271f, 0.02942638f, -0.00611810f, 0.02217372f, -0.05894450f, -0.02238509f, -0.02415680f, 
    -0.05726234f, -0.01804877f, -0.01823245f, 0.02548569f, -0.05400734f, -0.00297332f, -0.02639934f, -0.05501233f, 
    -0.01583089f, -0.01344526f, -0.00476961f, -0.00422403f, 0.02892958f, 0.02809496f, -0.02611048f, 0.04729362f, 
    -0.05555922f, 0.00824203f, -0.06094405f, -0.02830508f, 0.02810283f, 0.03199044f, -0.03425887f, -0.04220469f, 
    -0.01433999f, 0.04262598f, -0.02186457f, -0.01983204f, -0.04237404f, -0.02086881f, -0.04656898f, 0.00258989f, 
    -0.00034027f, 0.01243058f, -0.04547203f, -0.05573529f, -0.04898918f, -0.03536900f, 0.00938550f, -0.01965975f, 
    -0.05684270f, 0.04395386f, 0.00048572f, -0.05897600f, 0.01935706f, -0.03194075f, -0.00447963f, 0.04324589f, 
    0.00375808f, 0.03900858f, -0.05714666f, 0.04233779f, -0.03419320f, 0.01379462f, 0.02856982f, 0.05031980f, 
    -0.05258616f, 0.03104908f, -0.02940914f, 0.01049929f, 0.01906989f, -0.01187276f, -0.03893249f, -0.01012556f, 
    0.04563788f, -0.06078971f, 0.03042288f, -0.02148070f, 0.01641348f, 0.02964140f, -0.01860084f, 0.00972536f, 
    -0.03192796f, -0.04435697f, 0.02780348f, 0.04724327f, 0.00795980f, 0.01402084f, -0.02864093f, 0.04595055f, 
    -0.01176611f, -0.04223322f, -0.06110723f, 0.03526884f, -0.02563985f, -0.02896604f, 0.01689927f, 0.04197180f, 
    -0.04653193f, 0.01237268f, -0.02767941f, 0.02361448f, 0.00226815f, 0.01177070f, 0.01784054f, -0.00306603f, 
    0.00567695f, -0.00449129f, -0.00272507f, 0.01821539f, 0.02399511f, -0.02867772f, -0.02949393f, -0.06200636f, 
    -0.02343035f, -0.01840507f, 0.00292065f, -0.03050239f, -0.03103005f, -0.03711792f, -0.06799143f, -0.02221111f, 
    -0.05069524f, -0.06072044f, -0.00428323f, -0.02029552f, -0.04942629f, -0.02592577f, 0.03292817f, -0.03449884f, 
    -0.03809530f, -0.04749118f, 0.03767975f, -0.06018957f, -0.05268986f, -0.04266170f, 0.03351318f, -0.00733580f, 
    -0.06306022f, -0.04449520f, 0.03985009f, -0.04836575f, -0.00990766f, -0.04968781f, -0.05333116f, -0.02426555f, 
    0.00216700f, 0.01126402f, -0.03380524f, 0.04873924f, -0.00048061f, -0.03160643f, -0.04302762f, -0.06283306f, 
    -0.00425087f, -0.01625560f, 0.04012445f, 0.01209241f, -0.03888476f, -0.04689266f, 0.04204061f, 0.03975766f, 
    0.00085152f, 0.02343066f, 0.01504085f, 0.02605935f, -0.00632446f, 0.01322341f, -0.04711632f, 0.03945307f, 
    0.00546534f, 0.00811389f, -0.03201582f, -0.01768632f, 0.02583500f, 0.04880614f, -0.02165157f, -0.05095100f, 
    -0.02925551f, -0.02664020f, -0.05479163f, -0.04601894f, 0.01931330f, 0.01895504f, -0.06144918f, 0.03318719f, 
    0.00958965f, -0.03221267f, 0.02497914f, -0.00869998f, 0.02172371f, -0.00350564f, -0.03528579f, -0.04462859f, 
    -0.05211764f, 0.04387919f, 0.04998950f, -0.00704811f, -0.04930866f, -0.04333032f, 0.03141082f, -0.05874010f, 
    0.00183679f, 0.01924594f, 0.03604469f, -0.05743434f, -0.06197565f, 0.02113274f, 0.00549160f, -0.00320206f, 
    -0.04481448f, 0.04292279f, 0.01225051f, 0.02616891f, -0.01763276f, -0.04185800f, 0.03805488f, 0.02714327f, 
    -0.06048215f, -0.04305984f, 0.01296765f, -0.00505309f, -0.00791485f, 0.00906924f, 0.02142156f, 0.04311280f, 
    0.00292687f, -0.00137822f, -0.00270590f, -0.04195429f, -0.05687051f, 0.01419961f, -0.05704704f, -0.00071209f, 
    -0.03921476f, 0.01698983f, 0.02905095f, 0.01265805f, -0.02996150f, 0.01939848f, 0.01833890f, -0.04001129f, 
    -0.00816147f, 0.04346428f, -0.03339603f, 0.02011071f, 0.02548930f, 0.00171437f, 0.02978947f, -0.03161314f, 
    0.01815929f, 0.04541697f, 0.00799575f, -0.06432115f, 0.02152665f, 0.01972813f, 0.03434812f, -0.03592751f, 
    -0.00736034f, -0.02179030f, -0.05001494f, -0.01542797f, -0.01402260f, -0.02725353f, 0.02709838f, 0.00089497f, 
    0.03680215f, -0.02363558f, -0.05836871f, 0.02863500f, 0.02997202f, 0.02222242f, 0.04201621f, 0.04771864f, 
    -0.01875051f, 0.01613073f, -0.05799332f, 0.03929397f, 0.00503181f, -0.04603588f, 0.02999572f, 0.00615065f, 
    -0.06881866f, 0.04389933f, -0.02012004f, -0.03623312f, 0.04211123f, -0.04792313f, -0.06456903f, -0.04871200f, 
    -0.03444244f, -0.00155586f, -0.05087115f, -0.06539224f, -0.01092513f, -0.04677803f, 0.04185938f, -0.01171615f, 
    -0.03559493f, -0.01884596f, 0.04136401f, 0.00184998f, 0.03223386f, 0.03501687f, 0.00098632f, -0.01408854f, 
    0.01119398f, 0.00687311f, -0.00619948f, -0.06369089f, 0.03202280f, 0.04125562f, 0.02151562f, -0.06504196f, 
    0.02203836f, 0.00076449f, 0.01643276f, -0.00434227f, 0.04401444f, 0.00978941f, -0.00862140f, 0.01642000f, 
    -0.05871521f, -0.03962345f, 0.01959800f, -0.05512568f, 0.03365139f, -0.02333435f, -0.01414736f, 0.02673964f, 
    0.03348810f, -0.03275355f, -0.01364635f, -0.04979152f, -0.02279746f, 0.03445875f, 0.01260759f, 0.01156149f, 
    0.02823686f, -0.01739983f, -0.05451510f, -0.05790782f, 0.03074311f, 0.01758549f, -0.01539527f, -0.05256581f, 
    -0.04801138f, 0.03926144f, -0.05550784f, -0.02381737f, -0.02187040f, 0.04647589f, 0.02362863f, -0.03387517f, 
    0.01055613f, -0.01321469f, -0.05697702f, 0.03207084f, -0.03504717f, -0.01091270f, 0.03610203f, -0.00395159f, 
    0.00354606f, -0.00741106f, 0.04943806f, 0.03990219f, 0.03557980f, 0.02990892f, 0.01003136f, -0.03294272f, 
    -0.00468024f, -0.05008860f, 0.03532050f, 0.03311761f, 0.04381764f, -0.04288316f, 0.01911422f, -0.03624164f, 
    0.01649395f, 0.01011515f, -0.01834005f, -0.01062041f, -0.04134753f, 0.04218667f, 0.04559296f, -0.01306674f, 
    0.03909490f, 0.02719839f, -0.01150113f, 0.03823085f, 0.00947110f, -0.02718801f, 0.03734642f, 0.04212680f, 
    -0.03332455f, 0.04623533f, 0.00325065f, -0.03542764f, -0.02166764f, 0.02981739f, 0.01403854f, 0.02833338f, 
    -0.03722534f, -0.06280824f, 0.01739400f, -0.03871630f, 0.03247151f, 0.01427988f, 0.03341787f, -0.02630888f, 
    -0.00735928f, 0.01389281f, -0.01867214f, 0.00062488f, 0.03678852f, -0.05297450f, 0.02258316f, 0.04496907f, 
    0.71243042f, 0.43676081f, -0.15436602f, 0.26395115f, 0.31294513f, -0.17720282f, -0.13428549f, -0.02135289f, 
    0.07342564f, 0.08640416f, 0.06996533f, -0.04640656f, 0.05338816f, -0.07164087f, 0.10407358f, 0.00909069f, 
    0.04771278f, -0.01952109f, 0.06978570f, 0.00486912f, -0.48125491f, 0.25600594f, -0.17079802f, -0.19225004f, 
    -0.04420201f, -0.04296697f, -0.07751299f, 0.02619982f, 0.05178618f, -0.04373875f, 0.02464885f, -0.06897968f, 
    0.03597553f, 0.00765326f, 0.04149120f, -0.02312989f, 0.06632831f, -0.01183113f, 0.02473787f, -0.04043899f, 
    0.24114233f, -0.15989189f, 0.21452820f, 0.25765002f, 0.07406256f, 0.04620324f, -0.05729966f, 0.22501412f, 
    0.16362466f, 0.07135181f, 0.12756564f, 0.01430614f, 0.02549433f, -0.00643673f, 0.00066443f, -0.00420708f, 
    -0.14596403f, -0.05477881f, -0.00194608f, -0.10158135f, 0.38211489f, -0.01351656f, 0.09812610f, 0.07105827f, 
    -0.05374112f, 0.06130281f, -0.17194387f, 0.01228991f, 0.11168346f, -0.08270179f, 0.01804186f, 0.08379231f, 
    -0.02238601f, 0.07042740f, -0.09531847f, -0.08720595f, -0.09470817f, -0.16832203f, 0.07016255f, 0.03797894f, 
    0.39908448f, 0.03551940f, -0.01132284f, 0.02739196f, 0.22256164f, -0.06118175f, 0.15526007f, -0.02098722f, 
    0.07059052f, 0.05024764f, 0.09283355f, -0.03371122f, -0.03040194f, 0.21816835f, 0.15397114f, 0.05725146f, 
    0.12969962f, 0.04104173f, 0.19499151f, 0.05652042f, -0.44549495f, 0.14817123f, -0.23319757f, -0.10940929f, 
    -0.27391303f, 0.18581630f, 0.08842143f, 0.03240225f, -0.00264935f, 0.02553943f, 0.03750207f, -0.03672915f, 
    0.00760929f, -0.15658042f, 0.04990926f, 0.08620778f, 0.11594043f, 0.05156166f, 0.05472361f, -0.04059235f, 
    -0.43684149f, 0.22289474f, -0.16045173f, 0.13899910f, -0.23824772f, 0.15347013f, -0.01569490f, -0.00236828f, 
    0.12417364f, -0.06055576f, 0.01840107f, -0.03812141f, -0.02519958f, -0.01309728f, -0.00533569f, -0.04679060f, 
    -0.12361667f, -0.05617443f, 0.01981919f, 0.00639079f, -0.21129674f, -0.19985256f, -0.00005763f, 0.10866272f, 
    0.02147408f, -0.06392951f, -0.09479833f, 0.01576035f, 0.06793663f, 0.00101503f, 0.04377716f, 0.10613286f, 
    0.14633052f, 0.17724755f, 0.10460706f, 0.11029541f, -0.03757775f, 0.10981708f, 0.09618575f, 0.11443404f, 
    0.23584947f, 0.00788189f, -0.04059144f, -0.05466425f, -0.13952269f, -0.03516088f, -0.01621659f, 0.01918608f, 
    -0.01250624f, 0.06455974f, 0.12295237f, -0.07736564f, 0.12438750f, -0.02307822f, 0.05157989f, 0.01866502f, 
    -0.06438942f, -0.11305358f, -0.11215848f, 0.01946142f, -0.17431232f, -0.09931421f, -0.24541613f, -0.14440845f, 
    -0.15176608f, 0.10505771f, 0.03126582f, -0.03244459f, -0.19464095f, 0.11559416f, -0.11631636f, 0.13378334f, 
    0.06029841f, -0.08986168f, -0.00649632f, 0.13507056f, 0.06293553f, 0.07869005f, -0.09801741f, 0.00454438f, 
    0.43831059f, 0.01897266f, -0.00034813f, 0.14682257f, 0.34903789f, -0.10682894f, -0.14644518f, -0.03243694f, 
    0.07120818f, 0.07290667f, -0.10320128f, -0.00349663f, 0.02445058f, 0.08476359f, 0.00089292f, -0.16705491f, 
    0.01229684f, -0.17069525f, 0.07621968f, -0.06168031f, -0.12305167f, 0.09291210f, -0.00842970f, -0.15234019f, 
    -0.19504532f, -0.02873253f, 0.15503977f, 0.08002874f, -0.03394904f, -0.01092702f, 0.10065635f, 0.04424414f, 
    0.00559557f, 0.15272515f, 0.09116974f, 0.04103651f, -0.04349678f, -0.15883861f, 0.04194605f, 0.06875160f, 
    0.53888136f, 0.26678595f, 0.19344069f, 0.18642575f, 0.30298838f, -0.11681359f, -0.13614504f, -0.10750911f, 
    -0.01644767f, 0.17490286f, -0.06756834f, 0.13683896f, 0.09790079f, -0.01722302f, -0.02832705f, 0.11520639f, 
    0.20032579f, 0.04460080f, 0.15867721f, 0.03916279f, -0.29396713f, 0.27393934f, 0.04595791f, -0.26697221f, 
    -0.14489032f, 0.11800505f, 0.09664626f, 0.22005168f, -0.05967733f, -0.00729770f, 0.13090999f, -0.04151076f, 
    -0.09301791f, -0.06060542f, 0.08559062f, 0.10087167f, 0.00314396f, 0.03463376f, 0.02289304f, 0.01617931f, 
    0.28533861f, -0.15024276f, -0.00172952f, -0.16591108f, -0.11969263f, 0.05042680f, -0.01566396f, 0.03518140f, 
    0.01387751f, 0.04990237f, 0.14026523f, 0.04167929f, 0.18131287f, 0.10622288f, -0.00213673f, -0.10375722f, 
    0.07046534f, 0.12299526f, 0.00262771f, 0.00698254f, -0.36632246f, -0.18787275f, -0.01486928f, 0.08109422f, 
    -0.03205856f, 0.01187202f, -0.09546784f, -0.06576954f, 0.25289735f, 0.08387344f, -0.00299148f, -0.03243038f, 
    0.09983123f, 0.10766383f, 0.14474335f, 0.01026911f, 0.09922443f, 0.07665767f, -0.16715801f, -0.07440092f, 
    -0.14173323f, -0.26291296f, -0.31772211f, 0.13568071f, 0.03939199f, -0.09598523f, -0.01789520f, 0.01959961f, 
    -0.05057184f, 0.03765610f, -0.02574709f, 0.07837379f, 0.08913860f, -0.17703316f, 0.01277685f, -0.02637147f, 
    0.02272281f, -0.04951143f, 0.05038542f, 0.08913630f, -0.31398767f, 0.01370780f, 0.04055672f, -0.06607773f, 
    -0.05165719f, -0.01812734f, -0.06128858f, 0.07096617f, -0.05106618f, 0.04143291f, 0.04936093f, 0.13546467f, 
    -0.03593809f, 0.14062506f, -0.05552518f, -0.13697672f, 0.02063805f, -0.01772447f, 0.04065042f, -0.03878358f, 
    -0.23614578f, 0.03221304f, -0.13519756f, 0.33439225f, 0.22029178f, -0.00173484f, -0.05123819f, 0.04922611f, 
    0.17320280f, 0.13245383f, 0.05538296f, -0.09924814f, 0.01008908f, 0.07306316f, 0.02752890f, -0.04446170f, 
    -0.12016166f, 0.10506574f, -0.04264299f, -0.06563547f, 0.27305862f, 0.31357265f, -0.09699164f, 0.26382405f, 
    0.09625576f, -0.12352042f, 0.12485503f, -0.01750089f, 0.11145440f, -0.00184240f, -0.08639174f, 0.14967763f, 
    -0.06805812f, -0.01829663f, -0.02924481f, 0.02373321f, 0.09736629f, -0.06843429f, 0.03260728f, 0.19224615f, 
    0.17557056f, -0.07298476f, 0.13223068f, 0.28922638f, 0.25221935f, 0.00740753f, 0.10744992f, -0.03012420f, 
    0.04336555f, 0.01530065f, -0.02989211f, 0.11439714f, -0.05497058f, -0.06677446f, 0.16784796f, 0.04530636f, 
    0.08638248f, 0.09555530f, 0.08716869f, 0.10600381f, -0.35422108f, 0.24956095f, 0.15503725f, -0.06296622f, 
    0.17698032f, 0.06694709f, 0.05952218f, 0.02292570f, 0.02794070f, -0.06815529f, -0.06095147f, -0.02409269f, 
    0.08756042f, -0.07038962f, 0.03677537f, -0.09035309f, 0.03469551f, 0.07485961f, 0.14156146f, 0.04102571f, 
    -0.33522364f, 0.37371296f, 0.10681104f, 0.05028348f, -0.05987331f, 0.11616606f, -0.04626621f, 0.00979854f, 
    0.14465360f, -0.13871589f, -0.07006311f, 0.05200523f, 0.07577631f, 0.09750289f, 0.12527181f, -0.09753171f, 
    0.07606028f, 0.01668827f, 0.14787674f, -0.08021947f, 0.05473846f, 0.13222492f, 0.00880805f, 0.11988127f, 
    0.20749162f, -0.06131049f, 0.05658155f, 0.03845933f, -0.02619506f, 0.01133862f, 0.05265408f, -0.10613400f, 
    0.16875663f, -0.02654429f, 0.00119803f, 0.03207094f, -0.06529339f, 0.10598520f, -0.06096759f, 0.05339110f, 
    0.15680857f, 0.12961227f, 0.10774322f, -0.09919451f, -0.24192216f, -0.12868424f, 0.02983148f, 0.02892092f, 
    -0.05675885f, -0.08411946f, 0.10138357f, -0.04774680f, 0.08733839f, 0.08024902f, -0.10650966f, 0.01716085f, 
    -0.01738202f, 0.08325884f, 0.04033557f, 0.06733755f, -0.13122463f, 0.13093098f, -0.03985475f, 0.03459997f, 
    0.08985957f, 0.04906708f, 0.01492483f, -0.08306557f, -0.15093105f, 0.02217921f, -0.08675059f, 0.17283015f, 
    -0.03528703f, -0.05891825f, 0.05956939f, -0.07733282f, -0.08481928f, -0.00617077f, 0.00939577f, -0.05412098f, 
    -0.37484875f, -0.02118472f, -0.19670199f, 0.13184047f, -0.00142553f, -0.01462713f, 0.06579607f, 0.02250310f, 
    0.03815901f, 0.10088552f, -0.04773212f, 0.10298175f, 0.07074522f, -0.02519787f, -0.10686064f, -0.03371609f, 
    0.02271855f, -0.05118477f, -0.07890534f, 0.03481830f, 0.00624597f, 0.34128937f, 0.18779294f, -0.09424714f, 
    -0.19271594f, -0.03570534f, 0.02114992f, 0.07295714f, 0.01012413f, -0.17326619f, -0.03279699f, 0.02117310f, 
    -0.12146804f, 0.12676589f, -0.00272342f, -0.00764879f, 0.07418451f, -0.05324643f, 0.05549867f, 0.18787487f, 
    -0.02171787f, -0.27184463f, -0.11247116f, -0.13472223f, -0.15399086f, -0.10831265f, 0.04302715f, -0.02883070f, 
    -0.06790873f, 0.08212630f, 0.02246848f, 0.06385737f, 0.06798092f, -0.01057331f, 0.05407041f, 0.09601142f, 
    0.04815496f, -0.04339811f, 0.01205192f, 0.11983163f, -0.42891365f, -0.18191855f, 0.04780411f, -0.14135772f, 
    -0.10806100f, -0.05752621f, -0.09495678f, 0.32036436f, -0.15272076f, -0.16361794f, 0.06646004f, 0.01550630f, 
    -0.02081688f, 0.01498521f, -0.13029231f, 0.05400729f, 0.04050916f, 0.04443795f, 0.04019484f, -0.13776286f, 
    0.02971715f, 0.31652051f, -0.11936776f, 0.27052590f, 0.04611067f, 0.01309782f, 0.04522960f, 0.06580620f, 
    0.10753492f, -0.02633162f, 0.05695932f, 0.04060912f, -0.01072279f, 0.05169510f, 0.08454303f, 0.00968819f, 
    0.00506762f, 0.09246515f, 0.02543777f, -0.02648722f, 0.07961382f, 0.04882358f, 0.10508117f, 0.15656285f, 
    0.42640677f, -0.03164420f, 0.07102568f, -0.05795380f, -0.01555398f, 0.13596606f, 0.02068243f, 0.09617953f, 
    0.11154457f, 0.04145066f, 0.05450077f, -0.06663356f, 0.07436965f, 0.05020669f, -0.02801071f, 0.06456916f, 
    -0.13441591f, 0.52862704f, 0.11440621f, 0.34146926f, -0.05814493f, -0.01282094f, 0.09166543f, 0.18583325f, 
    -0.00177598f, -0.03986446f, 0.05230423f, 0.06159860f, 0.03287943f, 0.04184512f, -0.07744817f, 0.07594003f, 
    0.00679660f, -0.20194145f, -0.05247920f, -0.00222527f, -0.10927687f, 0.22112791f, -0.14810446f, -0.13316701f, 
    0.14156257f, 0.07209339f, 0.01255826f, 0.15104979f, -0.27105823f, 0.09558091f, -0.02947180f, 0.03466525f, 
    -0.10945162f, -0.09228111f, -0.12808372f, -0.05822939f, -0.04551535f, -0.01788008f, 0.13810600f, -0.03674393f, 
    -0.28103071f, -0.03261079f, 0.17949323f, 0.36070275f, 0.53902662f, 0.13539788f, 0.03497534f, 0.07934360f, 
    0.02076417f, 0.11168807f, 0.11672779f, -0.15957272f, -0.10018890f, -0.15815425f, 0.08661761f, 0.06989903f, 
    -0.28162980f, 0.16255018f, -0.11814599f, 0.02182784f, 0.22808707f, 0.01121168f, 0.04744847f, -0.12646554f, 
    -0.05973646f, -0.03545103f, 0.04595739f, 0.04471671f, 0.06254162f, 0.19998528f, -0.04280842f, 0.01978452f, 
    -0.03044406f, -0.15704998f, -0.04496610f, 0.03761363f, 0.04195843f, 0.19234297f, -0.11617927f, -0.02176548f, 
    0.17490402f, 0.21790993f, -0.19638583f, 0.14858569f, -0.21123651f, 0.07568262f, 0.17570575f, 0.21217532f, 
    0.01549978f, -0.03356916f, 0.04108004f, 0.03805395f, 0.00617236f, 0.07841452f, -0.13922893f, 0.10433312f, 
    0.06927792f, 0.23126738f, 0.00444854f, 0.24460638f, 0.11833034f, -0.03453282f, -0.28595886f, -0.18904714f, 
    0.38625622f, -0.02526494f, -0.14148730f, -0.12077568f, 0.05296137f, -0.08854316f, -0.07709749f, 0.06237182f, 
    0.05577905f, 0.06070241f, 0.06258615f, 0.12786408f, 0.16973321f, 0.00199539f, 0.02820307f, 0.12603851f, 
    0.50275207f, 0.38061979f, -0.12738232f, 0.00406396f, 0.17735477f, -0.07102654f, 0.03102398f, -0.00475647f, 
    0.00992499f, -0.00001133f, 0.01627395f, -0.11687324f, 0.18257202f, 0.00917381f, -0.01281555f, 0.06966984f, 
    0.09384811f, 0.07982849f, 0.06886854f, -0.00276858f, 0.07206419f, 0.12905239f, -0.16585466f, 0.01484413f, 
    0.08653240f, 0.11092951f, 0.02799546f, -0.02537432f, -0.09747932f, 0.04108663f, -0.01165503f, -0.13203266f, 
    0.06823890f, 0.07105768f, 0.03995226f, 0.00613975f, -0.07796589f, 0.04564575f, 0.21915874f, -0.01037051f, 
    -0.04182031f, 0.22363304f, -0.01063165f, -0.26100144f, 0.26521075f, -0.04854527f, 0.08199449f, -0.01362498f, 
    0.02234748f, -0.06414017f, 0.00037174f, -0.18041119f, 0.06494886f, 0.06483380f, 0.09646956f, 0.17403102f, 
    0.08849054f, 0.05570871f, 0.07108283f, 0.10032669f, 0.10026282f, -0.34484464f, 0.05324115f, -0.01176632f, 
    0.26166251f, 0.17026868f, -0.05359085f, 0.13500716f, 0.00934509f, -0.06032981f, 0.01847320f, -0.00542469f, 
    -0.01396612f, -0.02719976f, -0.00062550f, 0.01312651f, 0.01674507f, -0.05001218f, 0.09318287f, -0.00118856f, 
    0.49657410f, -0.30078170f, -0.15077539f, 0.00003111f, -0.52333415f, 0.03867506f, -0.05492285f, 0.04092107f, 
    0.12046568f, 0.27056411f, -0.05127571f, -0.10501663f, -0.04530603f, 0.04099593f, -0.01620859f, -0.16909631f, 
    -0.08942169f, 0.01021587f, -0.11331984f, -0.03098790f, -0.45206866f, -0.13744475f, 0.00605859f, -0.13363266f, 
    0.06056150f, 0.05807585f, 0.13862093f, 0.00197763f, 0.01866235f, -0.03192413f, -0.09731902f, -0.01849693f, 
    0.02140594f, 0.09196687f, 0.05592325f, 0.01639745f, 0.01097583f, 0.10755537f, -0.14965597f, 0.07603204f, 
    -0.43444985f, 0.22189841f, 0.22594786f, 0.04667067f, -0.27465659f, -0.00031326f, -0.09763098f, 0.23588678f, 
    0.19984160f, 0.23037277f, -0.00254743f, -0.09503967f, 0.03335236f, 0.13088581f, 0.12061664f, -0.03900208f, 
    0.08303264f, -0.12746918f, 0.09355067f, -0.10072356f, -0.43164778f, -0.38156572f, -0.29564881f, 0.09793529f, 
    0.14355168f, 0.10271620f, 0.01040365f, 0.19928296f, -0.01542286f, 0.06011180f, -0.00947645f, 0.02217832f, 
    0.09821682f, 0.12313326f, -0.10132706f, -0.07823320f, -0.14058051f, -0.10208490f, -0.08153522f, -0.08636241f, 
    -0.17652555f, -0.37231368f, -0.55303925f, -0.26275349f, 0.08366127f, -0.10632402f, -0.07600065f, -0.00804919f, 
    0.12617107f, 0.11284055f, 0.16749901f, -0.08791733f, -0.03027070f, 0.03803534f, -0.11342068f, -0.04704832f, 
    -0.07363241f, 0.07074862f, 0.12079797f, 0.11313573f, 0.13897249f, 0.21110226f, 0.08928401f, -0.02894950f, 
    0.06963887f, 0.21204419f, 0.00750188f, -0.05663429f, -0.07014240f, 0.06543685f, 0.08895595f, -0.05426422f, 
    0.10063814f, 0.10999356f, 0.10705575f, -0.12920095f, -0.09084867f, 0.11566196f, 0.13464044f, -0.01563872f, 
    -0.38304353f, 0.06570505f, -0.31108409f, 0.19687901f, 0.42297027f, -0.01508897f, 0.05775906f, -0.03837910f, 
    -0.07523456f, 0.00620957f, -0.07208429f, -0.01043691f, 0.03117894f, 0.07995569f, 0.11255749f, 0.06478311f, 
    0.06510011f, -0.02097740f, -0.08355837f, 0.03025323f, 0.02217633f, 0.37633288f, -0.17852193f, -0.12311474f, 
    -0.04448458f, -0.04275652f, 0.03461080f, -0.04705793f, 0.03634307f, 0.05387131f, -0.05758204f, 0.04583626f, 
    0.05903840f, 0.02837504f, 0.01908486f, 0.09855546f, 0.19196358f, 0.09145885f, 0.05314944f, 0.08461549f, 
    -0.48212087f, -0.24921006f, 0.31144452f, 0.20576012f, -0.10658395f, 0.08883689f, 0.16867082f, 0.12585205f, 
    0.17036672f, 0.11470667f, 0.40581128f, -0.01462481f, 0.00548616f, -0.20449626f, -0.01832464f, 0.06844618f, 
    0.14582683f, -0.01126868f, 0.02635284f, -0.00588210f, -0.01608264f, -0.42142224f, 0.27615708f, 0.03135395f, 
    0.04953182f, 0.05838970f, -0.23386456f, 0.11862319f, 0.13859963f, -0.08162346f, 0.14902416f, 0.04122120f, 
    0.04936460f, 0.01931319f, -0.08835457f, -0.01753714f, -0.19427310f, -0.11264963f, -0.02341179f, 0.06598496f, 
    0.31111667f, -0.15832824f, 0.14793667f, 0.22653291f, 0.29347011f, 0.04471991f, 0.10383189f, 0.06921861f, 
    -0.00716147f, -0.02066570f, 0.03440738f, -0.05837132f, 0.03749186f, 0.19067797f, 0.23451015f, 0.06857260f, 
    -0.03194556f, -0.04509286f, -0.12515998f, -0.04247677f, -0.10992026f, 0.02673593f, -0.22704990f, 0.17213374f, 
    -0.12188156f, -0.11558837f, -0.08904939f, 0.05365466f, 0.12395708f, -0.02177548f, -0.04284312f, 0.08175412f, 
    -0.13366923f, -0.08004594f, 0.01664321f, -0.06943326f, -0.00345281f, 0.13002777f, -0.00149842f, -0.08790530f, 
    -0.16831610f, 0.44059759f, -0.23882338f, 0.10906415f, -0.02483341f, -0.00012555f, -0.03456280f, -0.01064937f, 
    0.14725931f, -0.05234313f, 0.00824096f, 0.07426627f, -0.10080228f, -0.02930520f, 0.01634068f, 0.08502839f, 
    0.02116580f, -0.01105584f, 0.08549399f, 0.13976887f, 0.31708360f, -0.01406429f, 0.34803668f, 0.17899302f, 
    -0.15642244f, 0.13910520f, 0.04137336f, 0.03429566f, 0.04880878f, -0.02994105f, -0.13726524f, -0.05843407f, 
    0.16348557f, 0.03511433f, 0.06648159f, 0.03586716f, -0.00980657f, 0.06649116f, -0.06028404f, 0.08611637f, 
    0.37523603f, 0.10115233f, -0.29663432f, 0.07542371f, -0.32428014f, -0.01419989f, -0.09506193f, 0.06092639f, 
    0.10668468f, 0.05667408f, 0.08637002f, -0.16317511f, 0.14334865f, -0.06902196f, 0.02370610f, -0.17621765f, 
    0.07447807f, -0.09024689f, -0.13666184f, -0.17269029f, 0.07005384f, -0.12567441f, -0.13651167f, 0.14364862f, 
    -0.05136484f, -0.03581116f, -0.05486302f, 0.04829665f, -0.13163622f, 0.17579708f, -0.13701226f, 0.03095946f, 
    -0.08022530f, -0.09738621f, -0.06156040f, -0.03284480f, 0.05137824f, 0.04698263f, 0.09063461f, 0.02243090f, 
    0.56917369f, -0.67679638f, -0.05357520f, -0.30390143f, 0.20769109f, -0.05095110f, -0.13604130f, 0.07122186f, 
    -0.15867446f, 0.05310453f, 0.04814102f, -0.04722133f, 0.03966752f, 0.00713986f, 0.03163509f, -0.12008366f, 
    0.10538623f, -0.14000630f, 0.21934573f, 0.05005810f, -0.07443228f, 0.29513741f, -0.20911250f, -0.21138592f, 
    -0.14159261f, 0.00769522f, -0.03260019f, 0.12663549f, 0.11602905f, 0.03556632f, 0.14303331f, -0.05770465f, 
    0.08410040f, 0.01769900f, 0.17196840f, 0.16952556f, 0.00510276f, -0.13739376f, 0.10680210f, -0.09521902f, 
    0.05517186f, -0.18513353f, 0.06652403f, -0.15076071f, 0.12530637f, 0.01102467f, 0.04383479f, -0.11495031f, 
    -0.09159861f, 0.17594138f, -0.03033031f, -0.00010420f, 0.18119209f, 0.13111620f, -0.02338856f, -0.05459549f, 
    -0.00808637f, 0.25915480f, 0.08772276f, 0.14790902f, 0.13372532f, 0.47572690f, -0.06796072f, -0.09969135f, 
    0.10447092f, -0.09351701f, -0.19188502f, 0.16795190f, -0.12321097f, -0.15206972f, 0.15546945f, -0.02034071f, 
    -0.15728483f, -0.06181252f, 0.06777792f, 0.06826212f, -0.02080689f, 0.06811795f, 0.06110642f, 0.06027386f, 
    -0.13758941f, -0.05105456f, -0.00757041f, 0.05777999f, -0.24806061f, -0.01567271f, 0.13128778f, 0.05969547f, 
    -0.08411903f, 0.12680621f, 0.25982437f, -0.00728882f, 0.11988858f, 0.02903295f, -0.08524012f, 0.00102079f, 
    -0.13483281f, -0.16041915f, 0.15052740f, -0.01885909f, -0.01418921f, -0.00352675f, 0.19129212f, 0.09851125f, 
    -0.27798787f, -0.01775214f, -0.05989672f, -0.07999538f, 0.30939329f, -0.00629725f, -0.07930519f, -0.11280748f, 
    0.15160559f, 0.20127060f, 0.12133221f, 0.02079178f, 0.16695610f, 0.01536785f, -0.26567036f, -0.11384769f, 
    0.01551166f, 0.03896224f, -0.01439951f, 0.02751730f, -0.00863499f, -0.04189127f, -0.03454562f, -0.00574557f, 
    -0.04401946f, 0.01442954f, -0.05141136f, -0.00193195f, 0.01323268f, -0.02957027f, 0.03671386f, -0.02880272f, 
    0.04483718f, 0.01575879f, -0.02726343f, -0.03924356f, 0.00732502f, -0.04795487f, -0.01056807f, 0.02929252f, 
    0.03062126f, 0.02403318f, 0.02526729f, -0.00279262f, -0.04459916f, 0.05061411f, 0.00447348f, -0.02408621f, 
    0.01168484f, -0.00628212f, -0.01563534f, -0.04573454f, -0.03407569f, 0.01743852f, -0.05457468f, -0.00283078f, 
    0.00575078f, 0.00485680f, 0.02839355f, -0.03367490f, -0.06171766f, -0.03547549f, -0.04141910f, -0.00990342f, 
    -0.03359015f, 0.00703827f, 0.00580615f, 0.04809976f, 0.05505657f, -0.02496409f, -0.04547881f, -0.04952242f, 
    -0.00739635f, -0.05290168f, -0.03929545f, -0.04929020f, -0.02799214f, -0.05235395f, 0.02980216f, -0.02856105f, 
    0.04329309f, 0.00178291f, -0.01449782f, 0.03012642f, 0.03466995f, -0.00966286f, 0.02180582f, -0.02096483f, 
    0.02906513f, 0.02755046f, 0.03730860f, -0.01980846f, -0.03853199f, -0.05189718f, 0.01728412f, -0.04551708f, 
    0.02151413f, -0.04724490f, -0.05764689f, -0.02629170f, -0.02245958f, -0.05969973f, -0.00038505f, -0.05212136f, 
    -0.02075718f, -0.05627597f, -0.02414129f, 0.02738207f, -0.05202356f, -0.01192913f, 0.02728803f, -0.02792290f, 
    -0.02379079f, -0.03584341f, 0.04573041f, -0.05168184f, 0.03362096f, 0.00604850f, -0.03436670f, 0.01691127f, 
    0.02523031f, 0.03883210f, -0.00526750f, -0.01008489f, -0.01328484f, 0.01232016f, 0.04722849f, 0.03580738f, 
    -0.02023867f, 0.02084283f, -0.01577129f, -0.00012706f, -0.04155678f, 0.00677382f, -0.03598485f, 0.04672242f, 
    -0.06215923f, -0.02728289f, 0.02365377f, -0.04054058f, -0.02000731f, 0.00266785f, -0.01734365f, 0.02816081f, 
    -0.03703207f, -0.02213018f, 0.04325090f, 0.03133564f, 0.01857400f, 0.01042588f, -0.03021604f, 0.01445817f, 
    -0.02460768f, -0.03933631f, 0.01572267f, -0.05062304f, 0.04120748f, 0.00878070f, -0.06197340f, -0.00803988f, 
    -0.03494764f, -0.05182539f, -0.00493830f, -0.03124793f, -0.06419548f, -0.01892270f, 0.02675909f, 0.02934775f, 
    -0.04342300f, -0.02401355f, -0.02567276f, 0.02347633f, -0.02753053f, 0.02254829f, -0.05654769f, -0.06097269f, 
    -0.02709982f, -0.00311789f, 0.01227154f, -0.00570929f, 0.03048301f, -0.01581226f, -0.04476346f, 0.02299965f, 
    0.02414866f, 0.04151357f, 0.01422769f, -0.04740381f, 0.00592762f, 0.00932885f, 0.03328681f, -0.02301987f, 
    0.03464098f, -0.02990298f, -0.02118197f, 0.01891197f, 0.04398976f, -0.02226623f, -0.00264439f, 0.04009867f, 
    0.02830944f, 0.02059384f, -0.02860133f, -0.00185602f, -0.05927211f, -0.03692820f, 0.04061807f, 0.04994919f, 
    -0.00611808f, -0.04129399f, 0.01781087f, 0.03824102f, 0.02316948f, -0.05731484f, -0.00555881f, 0.02331098f, 
    -0.05445896f, 0.00007432f, 0.00912682f, 0.00769632f, -0.02709663f, -0.04083059f, -0.02424455f, 0.00055745f, 
    0.01721718f, -0.00046606f, -0.02301555f, -0.01012511f, 0.03084016f, -0.02954872f, -0.05635178f, 0.01429333f, 
    -0.02595829f, -0.03444292f, -0.00702252f, 0.03746733f, -0.05545400f, 0.02361994f, 0.02728598f, -0.00637683f, 
    0.03463509f, -0.04673285f, -0.03044909f, 0.00264616f, 0.02239197f, 0.04012243f, 0.01630803f, -0.04101413f, 
    0.02413343f, 0.02402146f, -0.00369067f, -0.03636171f, 0.05487008f, -0.04751306f, -0.03284993f, -0.04086301f, 
    0.03294240f, 0.02756553f, 0.02122228f, 0.05199918f, -0.04060886f, -0.02448516f, 0.04662090f, -0.05432256f, 
    -0.03582300f, -0.05270246f, 0.00219982f, 0.04748674f, -0.00785500f, 0.00471174f, 0.04527475f, 0.00460787f, 
    -0.05250935f, 0.01545284f, -0.03997947f, -0.01176687f, 0.04845829f, -0.02518306f, -0.00406808f, -0.03493824f, 
    -0.01398007f, -0.03108732f, -0.02138414f, 0.03743310f, 0.03835242f, -0.00648947f, 0.03758995f, 0.00931930f, 
    -0.02165542f, -0.01703809f, 0.04418971f, -0.05344480f, -0.04606431f, -0.00249793f, -0.02083494f, -0.06032962f, 
    0.00581309f, 0.01294451f, -0.00451010f, -0.06258056f, -0.06141985f, 0.00710025f, 0.04220707f, -0.01118337f, 
    -0.03513402f, 0.03617425f, -0.03470058f, -0.03729998f, 0.00378850f, -0.05794125f, 0.04818511f, 0.01998778f, 
    -0.05965053f, 0.03896770f, 0.05975703f, -0.02805725f, -0.04102909f, 0.02431264f, -0.01834332f, -0.03932976f, 
    -0.03036322f, -0.00224046f, -0.03188419f, -0.05267076f, -0.01519449f, -0.00745236f, 0.00264838f, 0.00106888f, 
    -0.00733029f, -0.05027060f, -0.00453892f, -0.05117091f, -0.05574778f, 0.04619672f, 0.00876531f, -0.01300674f, 
    0.01569389f, -0.05948143f, -0.00089717f, -0.04507615f, 0.01947293f, -0.02852412f, -0.04928711f, -0.02844606f, 
    -0.02312709f, 0.04856040f, -0.05047591f, -0.03024244f, 0.03073942f, -0.05104404f, -0.03333303f, -0.02052521f, 
    0.01907302f, -0.01067107f, -0.02677404f, -0.03359944f, -0.00291396f, -0.02023777f, -0.02512622f, -0.03596308f, 
    -0.05551826f, -0.02809393f, -0.00116596f, 0.04334061f, 0.01384022f, -0.04152861f, -0.04122197f, -0.00896799f, 
    0.00905247f, -0.03668590f, -0.06076396f, -0.06044343f, 0.03489057f, -0.01972919f, -0.03184861f, -0.01313084f, 
    0.03655241f, -0.02794502f, 0.02978258f, 0.03176662f, -0.03986536f, 0.03295789f, 0.04157333f, -0.04219493f, 
    0.02434622f, 0.03392702f, 0.03986791f, 0.02091293f, -0.01251375f, 0.03657047f, -0.02380926f, 0.00094334f, 
    -0.02810036f, -0.02266041f, 0.03164985f, -0.05190751f, -0.00214856f, 0.00410088f, -0.02565105f, -0.04250516f, 
    0.03762319f, -0.01043355f, 0.03023017f, -0.05405528f, 0.02058224f, -0.02621681f, 0.02036222f, -0.02440793f, 
    -0.03167121f, 0.00538759f, 0.01749877f, 0.04663577f, 0.02858492f, 0.01227287f, -0.01406075f, -0.06026988f, 
    0.01195518f, -0.02701174f, -0.05926112f, 0.00285548f, 0.02290967f, -0.02827627f, -0.05547010f, -0.03659849f, 
    -0.03416504f, 0.04776926f, 0.02041164f, -0.03352540f, 0.01669445f, 0.01942277f, -0.05612592f, 0.00041406f, 
    0.03641476f, -0.03171261f, -0.01253868f, 0.03468523f, -0.03964822f, 0.00953025f, -0.04210203f, -0.03944101f, 
    -0.00662610f, 0.00697650f, -0.00023776f, 0.02583046f, -0.01926751f, -0.02481616f, -0.05236486f, 0.01348021f, 
    -0.05405380f, -0.04348423f, -0.05497399f, -0.03045741f, -0.05141122f, 0.00019252f, 0.02403396f, 0.04590868f, 
    0.03838826f, 0.04002996f, -0.04742770f, 0.05111946f, -0.01944608f, -0.00447073f, 0.00982184f, -0.01038914f, 
    -0.04889186f, 0.02586998f, 0.03653848f, -0.03861968f, -0.03474997f, 0.03299795f, 0.01605492f, 0.01185790f, 
    -0.03521311f, -0.00726915f, -0.06094121f, 0.02134608f, 0.00654081f, -0.03021291f, 0.02886410f, -0.05052928f, 
    0.04417142f, -0.03295607f, 0.02752156f, -0.04403630f, 0.04661075f, -0.02275339f, 0.00421690f, -0.03104854f, 
    0.02926482f, 0.00422418f, -0.05254135f, 0.04125432f, -0.05396343f, 0.00874955f, -0.02439077f, -0.05606727f, 
    0.03629193f, 0.04339315f, 0.00822155f, -0.02545652f, 0.04329004f, 0.04026420f, -0.00666089f, -0.03393991f, 
    -0.03597378f, -0.03401334f, -0.00960872f, 0.02724394f, 0.00012501f, 0.04640754f, -0.04959591f, 0.00905180f, 
    0.03585045f, -0.02788482f, -0.05797707f, 0.04466033f, 0.01232809f, -0.04498654f, -0.01020504f, -0.03888931f, 
    0.01400158f, -0.02932539f, -0.02135478f, 0.03704984f, -0.03428997f, 0.04689334f, 0.00661702f, -0.00756610f, 
    -0.02685896f, -0.05563959f, -0.01723338f, 0.02649208f, -0.05167849f, 0.04667155f, 0.02733639f, 0.02210001f, 
    -0.04443235f, -0.04208102f, 0.00851057f, -0.00749683f, 0.05299802f, -0.03083200f, 0.01048025f, -0.03458834f, 
    -0.02002053f, -0.02473822f, 0.02159524f, -0.00923753f, -0.00043716f, 0.03403348f, 0.01740768f, 0.02832616f, 
    -0.01290130f, 0.01955827f, 0.01520837f, -0.03978477f, 0.02975929f, -0.05998886f, -0.02722447f, -0.02819471f, 
    -0.04177939f, -0.02852633f, 0.01720089f, -0.05410318f, -0.05135800f, 0.04215256f, -0.00077545f, 0.02419352f, 
    -0.04388548f, 0.01722797f, -0.00889240f, 0.02429492f, -0.04052719f, -0.00319965f, -0.03301884f, 0.00208526f, 
    -0.03874765f, -0.00837189f, -0.01155837f, 0.00278524f, 0.00939927f, -0.01298045f, -0.00962490f, 0.00480200f, 
    0.03449034f, 0.00825108f, 0.03164926f, -0.04194825f, 0.03496634f, 0.05413366f, -0.00920873f, -0.04624420f, 
    -0.02731565f, -0.04191302f, -0.05254611f, -0.00224159f, -0.04589101f, -0.01840128f, -0.04115156f, -0.01554506f, 
    -0.04093153f, -0.05430425f, 0.02104577f, -0.05288888f, -0.05348232f, 0.05005972f, 0.03109170f, -0.03060142f, 
    0.02174890f, -0.02141880f, 0.03267841f, 0.03673669f, 0.01083730f, -0.04908864f, -0.02073407f, -0.02428681f, 
    0.01673016f, -0.06000833f, -0.03703687f, 0.01672311f, 0.02178469f, 0.03250018f, 0.05037129f, -0.02978666f, 
    -0.03564775f, 0.01519542f, -0.00805944f, 0.01145411f, -0.04090932f, 0.00962092f, 0.03728444f, 0.03778391f, 
    -0.01827165f, -0.01371542f, -0.05880116f, -0.05555587f, -0.00031361f, -0.05314688f, -0.01054683f, 0.00172590f, 
    -0.00597457f, 0.01120872f, -0.03325956f, 0.02202514f, -0.05695222f, 0.02053969f, 0.00483568f, -0.04180871f, 
    -0.01213785f, -0.00409016f, -0.00277466f, 0.00588725f, -0.04442353f, -0.02595025f, -0.04549193f, -0.02761753f, 
    0.07297632f, -0.37732616f, -0.35294545f, 0.10565132f, 0.02474048f, -0.12158024f, 0.03292165f, -0.02594672f, 
    0.01353600f, -0.12308666f, -0.11270577f, -0.03003160f, 0.00190877f, -0.10110291f, -0.05220873f, -0.11960150f, 
    0.00855557f, -0.03307176f, -0.04979245f, -0.02005310f, 0.28092667f, -0.13284092f, 0.10948846f, 0.04584165f, 
    -0.11790884f, -0.05897329f, -0.11972040f, -0.12442461f, -0.00482463f, -0.05317740f, -0.19294350f, 0.09366032f, 
    -0.09367376f, -0.07030004f, 0.01846782f, 0.01315414f, 0.02852531f, -0.04579682f, 0.08646096f, -0.10362785f, 
    -0.00809760f, -0.09326119f, -0.38934168f, -0.03717969f, -0.18741897f, -0.05565768f, 0.03376065f, -0.04790860f, 
    0.16875893f, -0.03138557f, -0.05047921f, -0.07016331f, -0.07548072f, 0.08047736f, -0.01994607f, -0.15581477f, 
    -0.18827388f, -0.07898817f, -0.06259636f, -0.02845836f, 0.32081231f, 0.43985826f, -0.13324453f, 0.26790756f, 
    -0.14814828f, -0.02585887f, -0.08077379f, -0.01092491f, 0.15183456f, 0.04769980f, -0.16475078f, -0.10072005f, 
    -0.12867555f, -0.07813364f, 0.09362309f, 0.00581546f, -0.02720506f, 0.11236655f, 0.01673498f, 0.04614476f, 
    0.14891574f, -0.12232874f, -0.04712698f, -0.11587401f, 0.23345339f, -0.10787050f, -0.05075342f, -0.04744809f, 
    0.02141774f, 0.06932593f, 0.20850638f, -0.00207746f, -0.00895896f, -0.17780079f, 0.09513926f, 0.04922678f, 
    -0.03480877f, 0.09914937f, -0.02812405f, 0.08471381f, 0.24454592f, -0.01178724f, 0.30836171f, 0.28906280f, 
    0.04504695f, -0.11406687f, -0.01985358f, 0.10904008f, 0.03101796f, 0.09542932f, -0.12163263f, 0.06504155f, 
    0.08562001f, 0.03263700f, 0.06018752f, 0.01409889f, 0.03641248f, 0.07807027f, 0.20758164f, 0.02773087f, 
    -0.23639622f, 0.13294038f, 0.18286180f, 0.10565058f, 0.26595849f, 0.12355287f, -0.08426862f, -0.10983229f, 
    0.20459175f, 0.02647436f, -0.15420434f, -0.01610403f, -0.22166048f, 0.12597269f, 0.12659274f, -0.07124019f, 
    0.14710058f, -0.10311591f, 0.05652735f, -0.05594244f, 0.29792446f, 0.20003709f, 0.05473379f, 0.12072732f, 
    0.15605712f, -0.17409037f, -0.03483202f, 0.04512596f, -0.15169010f, -0.00487046f, 0.03543691f, 0.08343640f, 
    -0.13631611f, -0.16838256f, -0.07890816f, -0.00210611f, -0.02774742f, 0.18459785f, 0.13289270f, 0.12114770f, 
    0.15353002f, 0.13320769f, 0.10425231f, 0.10362438f, 0.18216835f, 0.00949501f, -0.08012289f, 0.14317341f, 
    0.02960672f, -0.01397054f, -0.09712641f, -0.06440392f, -0.04958301f, 0.05571195f, 0.04180334f, 0.07808272f, 
    -0.12524624f, 0.24713141f, 0.23212175f, 0.04158837f, 0.15052089f, 0.05663236f, 0.12411603f, 0.35808209f, 
    -0.07601056f, -0.05753549f, 0.05457852f, 0.03263427f, -0.04162550f, 0.13178118f, -0.08122157f, 0.07525332f, 
    0.13677947f, 0.17220429f, 0.01527824f, 0.05788714f, -0.12614861f, 0.12025874f, -0.14833386f, 0.00748409f, 
    -0.00996428f, 0.18952210f, -0.00403165f, -0.12307345f, -0.23989490f, -0.08307516f, -0.22092627f, -0.06101779f, 
    0.14367567f, 0.00825814f, -0.04625775f, 0.06864778f, 0.06651843f, 0.10172066f, 0.04744568f, -0.01876237f, 
    0.00249547f, -0.04859858f, -0.24382919f, 0.00533179f, -0.03666111f, 0.19017199f, 0.22102322f, 0.06547669f, 
    0.14907104f, 0.05383475f, -0.10793733f, -0.02980817f, 0.07522957f, 0.02908412f, -0.05869042f, 0.04893123f, 
    0.01964339f, 0.01340101f, -0.20585601f, 0.02580399f, -0.13429876f, -0.00370540f, 0.09243440f, 0.03711486f, 
    0.38810518f, -0.42131123f, -0.37138721f, -0.14808856f, -0.29534614f, -0.14392796f, -0.03396606f, 0.13365658f, 
    0.01751728f, -0.19430029f, 0.04515615f, 0.04737605f, 0.08768402f, 0.13217016f, -0.03937938f, 0.02666838f, 
    -0.04446843f, -0.05974056f, -0.12907071f, 0.00537404f, -0.29031369f, -0.22000666f, 0.05297464f, -0.07740874f, 
    -0.24337299f, 0.01199011f, -0.01724631f, 0.01803569f, 0.11752558f, 0.03170376f, -0.03045658f, -0.00395072f, 
    0.10387164f, 0.02479250f, 0.01132332f, -0.00591043f, 0.02502617f, 0.04941850f, -0.00795663f, 0.09765781f, 
    0.19651864f, 0.30156338f, 0.14283997f, 0.47757956f, -0.04101221f, 0.04018527f, 0.16260459f, 0.00910045f, 
    -0.11436563f, 0.03251292f, -0.19489101f, 0.03788542f, -0.08322085f, 0.01636133f, 0.02025996f, 0.01272775f, 
    -0.02225429f, 0.13130882f, -0.23507921f, 0.11643422f, 0.15947200f, 0.14131927f, -0.02314437f, 0.30421481f, 
    0.50390142f, -0.25523445f, 0.07510111f, -0.01656177f, -0.10498273f, -0.14838769f, -0.09750304f, 0.07951716f, 
    -0.12161379f, 0.01986634f, -0.10885818f, 0.02829586f, 0.01609580f, -0.01322963f, 0.31836641f, -0.04631108f, 
    -0.42251521f, -0.58588398f, -0.01827433f, 0.02963423f, -0.09569227f, -0.07442309f, -0.02680682f, -0.15086104f, 
    -0.11217165f, -0.02003455f, -0.03780315f, -0.07188369f, -0.00505107f, -0.02639972f, 0.12225923f, 0.01669412f, 
    -0.04482415f, 0.08449614f, 0.04845694f, 0.08910649f, 0.14869855f, -0.15646733f, 0.04398948f, 0.05024777f, 
    0.01414925f, 0.07813276f, 0.07267488f, -0.03941745f, 0.16343465f, -0.05028575f, 0.00317166f, 0.16325884f, 
    0.13702676f, 0.03717915f, 0.01979556f, -0.05239127f, 0.00459662f, 0.05157270f, -0.12760073f, 0.03668981f, 
    -0.23228684f, -0.19646329f, -0.19309390f, 0.02624815f, -0.11812049f, 0.05212419f, 0.02929920f, -0.10418838f, 
    0.11305073f, 0.05226204f, 0.07088546f, -0.07425994f, -0.00307053f, 0.12439367f, 0.00676889f, -0.16068058f, 
    0.16862004f, -0.00337262f, 0.07728793f, 0.12710160f, -0.14119704f, 0.04002966f, -0.19727997f, 0.20171586f, 
    0.05768082f, -0.12568142f, -0.06137475f, -0.00149869f, -0.06839703f, -0.06417038f, 0.02330617f, -0.03847213f, 
    -0.05212328f, 0.07030165f, 0.07736340f, -0.07494430f, 0.04275051f, -0.06091074f, 0.04228507f, 0.04595837f, 
    0.08326689f, -0.11670439f, 0.37501186f, 0.31475490f, 0.22432953f, -0.08514402f, -0.02173582f, -0.08935963f, 
    -0.04711214f, -0.03089361f, 0.04615648f, 0.03043159f, -0.06680074f, 0.00877471f, 0.07091665f, 0.04483990f, 
    -0.02426782f, -0.10256923f, -0.11888832f, -0.03375030f, 0.08972165f, 0.22474243f, 0.11717343f, 0.23892137f, 
    0.16898063f, 0.07189980f, 0.12910397f, 0.08015907f, 0.11214686f, 0.06064302f, -0.08050897f, 0.00800884f, 
    0.06520732f, 0.00001362f, 0.07752320f, -0.06653903f, -0.04137863f, -0.01647878f, 0.03489498f, -0.07017100f, 
    -0.45109159f, 0.15112539f, -0.02892401f, -0.14536974f, 0.04050386f, 0.18241155f, -0.00988175f, -0.09442012f, 
    0.09464723f, 0.12912823f, -0.06511650f, -0.00937771f, 0.01673950f, 0.04252914f, 0.03249476f, -0.05111443f, 
    0.18567163f, -0.02069630f, -0.06330128f, 0.05464895f, 0.33448365f, 0.23871101f, 0.26677108f, 0.09066463f, 
    0.21893437f, 0.05958413f, 0.12678413f, 0.07963262f, 0.02270892f, -0.02849630f, 0.05772283f, 0.04106040f, 
    0.05840897f, -0.09247427f, 0.06996553f, 0.00449146f, 0.10976585f, -0.15494540f, -0.07912535f, 0.08117405f, 
    0.13788338f, -0.01473474f, 0.04624128f, 0.18879966f, -0.24254364f, 0.04130280f, 0.10970595f, 0.09586417f, 
    -0.00326920f, -0.02847791f, 0.02875252f, 0.05098441f, 0.10545038f, 0.02020152f, -0.07486855f, -0.10708669f, 
    0.07729661f, -0.13736466f, 0.02174302f, 0.04373752f, -0.15286776f, 0.25844902f, -0.07093219f, 0.30564919f, 
    0.00949874f, 0.05853966f, -0.05750552f, 0.00098059f, -0.02533959f, 0.01318337f, -0.06949421f, 0.14857417f, 
    -0.01843774f, -0.02981592f, 0.14195895f, -0.12288038f, 0.03548574f, -0.01054622f, 0.06019712f, -0.10640194f, 
    -0.55129206f, -0.32038817f, 0.09249198f, -0.05611674f, -0.17493398f, 0.07668651f, 0.06133191f, -0.07680885f, 
    -0.00852051f, 0.01051393f, 0.17601816f, 0.01806008f, 0.04410079f, 0.10817926f, 0.10313980f, 0.14920333f, 
    0.04581669f, -0.01049324f, 0.08573347f, 0.00134002f, -0.19347152f, 0.08509713f, -0.04654528f, 0.06926039f, 
    -0.21475473f, 0.10498644f, -0.06568958f, 0.16847794f, 0.05398576f, -0.13232496f, -0.03315693f, -0.08291849f, 
    0.06254312f, -0.00721104f, 0.02956622f, 0.04354052f, 0.15849015f, -0.13330673f, 0.15634036f, 0.05054232f, 
    -0.00955912f, -0.43431273f, -0.12850459f, -0.25076354f, -0.33428660f, -0.03834243f, 0.18513711f, -0.07777683f, 
    -0.06765082f, -0.06917074f, 0.09634291f, -0.15986566f, 0.09168622f, -0.01614888f, 0.12587352f, -0.03128473f, 
    -0.00404928f, 0.14213309f, -0.07805401f, -0.00766061f, -0.06052224f, -0.07892270f, -0.02139720f, -0.02135768f, 
    0.01700708f, 0.00451544f, 0.00124141f, 0.26349744f, 0.04158314f, -0.14638001f, -0.00236683f, -0.05595330f, 
    -0.02274836f, -0.03014866f, -0.02581922f, 0.01255259f, 0.08219370f, 0.04838389f, 0.01246717f, 0.01146986f, 
    -0.16835392f, 0.31696767f, -0.02050306f, 0.41291904f, -0.01870267f, 0.02554133f, 0.01053297f, -0.00273670f, 
    -0.16428174f, -0.00343336f, -0.04747687f, -0.00525290f, -0.07344709f, 0.06281465f, 0.08667476f, -0.04221578f, 
    -0.13153671f, -0.14883120f, 0.02814916f, -0.10329121f, 0.34746316f, 0.25537658f, 0.06710833f, 0.08188417f, 
    0.40096626f, 0.06698377f, 0.06683324f, 0.05756700f, -0.01859297f, 0.00619307f, 0.01696730f, 0.11248211f, 
    0.09170950f, 0.12361525f, 0.02341997f, -0.05154426f, 0.13185528f, -0.16813201f, -0.16533157f, -0.05187090f, 
    -0.00622460f, 0.18892774f, -0.18340769f, 0.20972060f, 0.17885934f, -0.03328512f, -0.24602515f, -0.12246796f, 
    0.01321192f, 0.14951490f, 0.17339247f, 0.10679932f, 0.00023147f, -0.00480814f, -0.04019666f, 0.15213811f, 
    0.13029172f, -0.08661219f, 0.13408886f, -0.01135143f, -0.49793321f, 0.46238235f, 0.24519601f, -0.11392424f, 
    0.16624150f, 0.05633332f, 0.02850492f, 0.11010857f, -0.18274066f, 0.04039590f, 0.15597592f, -0.04387366f, 
    0.02690310f, 0.05835149f, 0.07445434f, -0.03581841f, -0.05248972f, 0.00699896f, 0.13354583f, -0.10950817f, 
    -0.11465716f, -0.20449556f, 0.11048044f, 0.28032482f, 0.27921429f, 0.10069710f, -0.16839868f, -0.01349076f, 
    -0.10176729f, 0.16247979f, -0.01203479f, 0.02545462f, -0.03791403f, -0.02333125f, -0.10627454f, 0.09740619f, 
    -0.32407933f, 0.23120293f, -0.12754713f, 0.04634500f, 0.48569423f, -0.23492825f, 0.04583478f, 0.05169381f, 
    0.00715645f, 0.00813771f, 0.07933410f, -0.14511663f, 0.12441025f, -0.03333743f, -0.11292641f, 0.22493704f, 
    -0.01026824f, 0.00503902f, -0.03349745f, -0.00146574f, 0.07944554f, 0.03213582f, 0.01582246f, -0.06042283f, 
    0.01893867f, 0.21271943f, -0.00760762f, 0.25648880f, 0.26340774f, 0.07804800f, 0.15741743f, -0.10518840f, 
    -0.10498947f, -0.05403993f, 0.08175431f, 0.12668693f, -0.02051604f, -0.02377709f, 0.16462986f, 0.04780216f, 
    0.05296980f, 0.08489737f, 0.15155452f, 0.08869830f, -0.57254058f, 0.17058626f, 0.28922588f, -0.08485096f, 
    0.06857594f, 0.08576992f, -0.05316446f, -0.01931588f, 0.10631600f, -0.08915860f, -0.01649857f, -0.02717016f, 
    0.09189793f, 0.03465335f, -0.02898006f, -0.00605036f, 0.14600265f, 0.02667254f, 0.01306924f, 0.06368764f, 
    -0.33110753f, 0.40087339f, 0.01464046f, 0.07517618f, -0.09290487f, -0.05242683f, -0.02010424f, 0.09545270f, 
    0.11332287f, 0.00901965f, -0.01404348f, 0.08869708f, 0.01014582f, 0.09839260f, 0.02790641f, -0.03238229f, 
    -0.01087709f, 0.10623659f, 0.03543567f, -0.05414001f, -0.05360812f, -0.11132376f, 0.01245620f, 0.18719278f, 
    -0.03282164f, 0.09351277f, -0.10821420f, 0.05994134f, 0.07961095f, -0.05115376f, 0.03398529f, -0.11033502f, 
    -0.03553027f, -0.01746224f, 0.02510244f, 0.11426684f, -0.12297181f, 0.12555997f, 0.25623596f, -0.05954564f, 
    0.20573914f, 0.19316573f, 0.24893165f, -0.20348480f, -0.20122868f, -0.00685879f, -0.02178377f, -0.13357727f, 
    0.06672008f, -0.13042872f, 0.11481085f, -0.25148824f, 0.05612100f, 0.08310569f, -0.03454970f, 0.06599819f, 
    -0.19383198f, -0.01880470f, 0.00717421f, -0.17458637f, 0.04558183f, -0.08079164f, 0.07392450f, -0.07141171f, 
    0.05158792f, 0.08759385f, -0.06204844f, -0.06813178f, -0.10497978f, 0.04766374f, -0.06356605f, -0.01256834f, 
    0.09546142f, -0.13129704f, -0.10842872f, 0.08212942f, -0.01436166f, -0.12463160f, 0.14383130f, 0.07569885f, 
    0.18905020f, -0.22304785f, -0.32344064f, 0.12135263f, 0.04479967f, -0.22137910f, 0.18668458f, -0.14740552f, 
    0.09344304f, 0.11637869f, -0.01850019f, -0.05803525f, -0.12532547f, -0.04194089f, -0.11432700f, -0.24989949f, 
    -0.06033552f, -0.11479169f, -0.04416080f, -0.09893338f, 0.09295364f, 0.31867278f, -0.00473256f, -0.10098725f, 
    -0.19299243f, -0.03563590f, 0.06308529f, 0.15500835f, -0.12246810f, -0.06027389f, -0.06644506f, -0.05645966f, 
    -0.14921671f, 0.16863033f, 0.08733089f, 0.06546427f, 0.07125722f, 0.09336333f, -0.06320217f, 0.03194238f, 
    0.09380002f, 0.12003108f, -0.01318673f, -0.02903946f, 0.05726933f, -0.18588519f, -0.24559231f, -0.15992814f, 
    0.06885608f, 0.21210751f, -0.03025386f, 0.03066948f, 0.08080942f, -0.00520244f, 0.10025273f, 0.07123267f, 
    0.29521918f, -0.25209594f, 0.20583466f, 0.04091948f, -0.31008494f, -0.18146397f, 0.14483765f, -0.11334996f, 
    0.09516408f, -0.02172483f, -0.00018808f, 0.09320039f, -0.10596129f, -0.08717757f, -0.07963708f, -0.10693738f, 
    0.10937778f, 0.26672310f, 0.00072889f, 0.01848970f, 0.13826443f, -0.06952544f, 0.12696980f, -0.13446571f, 
    0.27993938f, -0.13817933f, -0.17724982f, 0.01931374f, 0.01841866f, -0.12113160f, 0.04583264f, 0.20136487f, 
    -0.06163900f, -0.19961992f, 0.00838445f, 0.01637003f, -0.00479537f, -0.02502763f, -0.08804149f, -0.04759748f, 
    -0.00273330f, 0.07533506f, -0.00432634f, 0.16996919f, -0.13471313f, -0.07932968f, 0.22960542f, 0.04770477f, 
    -0.07432768f, 0.08891524f, -0.01721521f, 0.03405818f, 0.08078680f, 0.07042332f, -0.02779157f, 0.04448529f, 
    -0.11339793f, -0.04595691f, -0.00263239f, -0.12002191f, -0.00656163f, -0.03649133f, 0.04821847f, 0.08052193f, 
    0.44876537f, -0.12964915f, 0.30524153f, -0.03971070f, -0.09732237f, 0.06708901f, 0.06100257f, 0.00250575f, 
    -0.04200529f, 0.12034915f, 0.16603895f, 0.02089397f, -0.00594998f, 0.15565860f, 0.09535306f, 0.00512203f, 
    -0.00265563f, 0.07892462f, -0.04774012f, 0.07812793f, 0.34935668f, 0.16182782f, -0.10417012f, 0.12358552f, 
    0.16019548f, 0.08417327f, 0.13725296f, -0.03107063f, 0.07171163f, 0.02509688f, -0.14457470f, -0.06870519f, 
    0.09002446f, -0.23464526f, 0.08674355f, 0.08355632f, 0.02739626f, 0.08481883f, 0.00193199f, 0.07969278f, 
    0.20533471f, -0.19091941f, -0.01741350f, -0.34714913f, -0.26799208f, 0.19451155f, 0.02476469f, -0.14519303f, 
    -0.09281843f, -0.00402506f, 0.03625687f, 0.06657077f, 0.06900442f, 0.13204092f, 0.11629245f, -0.00183016f, 
    0.16856962f, -0.06135168f, -0.13125284f, 0.09260529f, -0.14306623f, 0.08486800f, -0.15960582f, 0.09758227f, 
    0.01438305f, 0.06510457f, -0.01031864f, 0.14943281f, -0.21305990f, -0.07419535f, -0.01132690f, -0.06806294f, 
    0.00162431f, 0.00725669f, 0.09904010f, -0.11604086f, 0.09297933f, 0.07030245f, -0.15630133f, -0.07191356f, 
    0.14812489f, -0.10045948f, 0.10771185f, -0.13204183f, -0.28622979f, -0.19220738f, -0.13300852f, 0.04823061f, 
    0.03098530f, -0.06025549f, 0.09425462f, 0.03666657f, 0.07775233f, 0.14467508f, -0.03438344f, 0.05792060f, 
    -0.02709018f, -0.09133725f, -0.21698631f, -0.01954040f, 0.26772690f, -0.01771666f, -0.08443373f, 0.27039826f, 
    -0.07918686f, -0.02598525f, -0.06421297f, -0.02468615f, 0.02329427f, 0.09142277f, 0.08241846f, -0.01721506f, 
    0.05225329f, 0.08001362f, 0.01455224f, 0.03121085f, 0.01367003f, 0.11244568f, 0.00390523f, -0.03558549f, 
    -0.59920096f, -0.01773775f, -0.19530378f, 0.07048369f, 0.34997630f, 0.14786264f, -0.02797752f, 0.00333701f, 
    0.01395059f, 0.35577080f, -0.06970460f, 0.07542062f, 0.01869589f, 0.02269762f, 0.00043241f, 0.07708523f, 
    0.08486813f, 0.11527014f, -0.15046792f, 0.04254352f, -0.05172749f, -0.13749573f, -0.09887736f, -0.03305070f, 
    0.07320551f, 0.12296256f, -0.02049864f, 0.03259508f, 0.02874571f, -0.03967464f, 0.02168420f, -0.01252831f, 
    -0.08415215f, 0.15807801f, 0.16733646f, -0.17035140f, 0.02247609f, -0.22360551f, 0.10805346f, 0.07826617f, 
    -0.04330880f, -0.26037323f, -0.01692569f, 0.13252872f, 0.13373250f, -0.04278806f, 0.07367429f, 0.09894405f, 
    0.04051827f, 0.14097278f, 0.00331353f, 0.04740506f, -0.02055474f, -0.02232433f, 0.11087719f, -0.06872104f, 
    0.11930937f, 0.08474116f, 0.06978101f, 0.03266988f, -0.08849404f, 0.02214349f, 0.00676312f, 0.27010968f, 
    -0.01407076f, 0.10667127f, 0.00422097f, 0.06646691f, 0.00866063f, -0.01690087f, 0.06237250f, 0.00824751f, 
    0.13648771f, 0.13863412f, -0.01077747f, 0.09633411f, 0.07174137f, 0.02470134f, -0.01339804f, 0.00577017f, 
    0.16290985f, -0.03692709f, 0.29829526f, -0.05350704f, -0.28857157f, 0.18777215f, 0.17283720f, 0.05048971f, 
    -0.06853938f, -0.06163134f, 0.17248341f, -0.00518418f, -0.09593450f, 0.05582127f, 0.24743311f, 0.22825769f, 
    0.14799404f, 0.04904534f, -0.13508120f, 0.14639303f, -0.43543839f, -0.35788062f, -0.20978795f, 0.12495829f, 
    0.08488018f, 0.09256869f, 0.05313710f, 0.01102341f, -0.04327465f, 0.21941344f, -0.01565288f, 0.08479432f, 
    0.09281930f, -0.18582112f, -0.04387918f, 0.04604008f, 0.02502440f, 0.04503535f, -0.05685772f, -0.07850200f, 
    0.19885787f, 0.07065488f, 0.10677940f, 0.04342565f, -0.06284846f, 0.13995752f, 0.22239274f, 0.08004313f, 
    0.04403817f, -0.00693619f, 0.06610738f, -0.07294172f, -0.06001200f, -0.09117680f, -0.05154007f, 0.00158244f, 
    0.02981857f, 0.04676761f, 0.03987865f, -0.03333635f, 0.02969217f, -0.04969661f, -0.26950899f, 0.12846327f, 
    0.00006955f, 0.07017190f, 0.22568966f, -0.09989147f, -0.02339608f, 0.09912998f, -0.01240413f, 0.00768559f, 
    0.06573363f, -0.11418100f, 0.06451041f, -0.10453076f, 0.01939693f, 0.02250086f, -0.03920157f, 0.10668097f, 
    0.17933825f, -0.08637556f, 0.01817273f, 0.06959114f, -0.17625265f, 0.06008266f, -0.15086286f, 0.00602041f, 
    -0.12902744f, -0.00919153f, -0.05256075f, -0.12035941f, 0.05271737f, -0.01863530f, 0.13895483f, -0.04461284f, 
    0.12809704f, -0.10246448f, -0.04423849f, 0.02901137f, -0.14200887f, 0.23198031f, -0.30952433f, -0.03134466f, 
    0.13522701f, 0.01671404f, -0.11838849f, 0.05527034f, 0.15705153f, -0.02849205f, 0.06458109f, -0.01850433f, 
    0.01507698f, 0.16460693f, 0.04610396f, 0.13504183f, -0.09423211f, -0.06479443f, 0.12524286f, 0.06055510f, 
    0.03800429f, -0.04545499f, -0.01899586f, 0.00123382f, -0.00818486f, 0.02835288f, -0.05364728f, -0.00895670f, 
    -0.00641524f, -0.00619549f, 0.01898167f, -0.02014355f, -0.00857205f, 0.02532168f, -0.05550667f, 0.02124878f, 
    0.00769764f, 0.00329421f, 0.03054930f, -0.00073349f, -0.02201900f, -0.01960721f, -0.03639316f, -0.03337976f, 
    0.03430145f, 0.05342526f, 0.02043564f, 0.02267208f, -0.04068203f, -0.05628989f, -0.02308750f, -0.01577350f, 
    -0.00309093f, 0.02551235f, -0.05240404f, -0.04581583f, 0.01414386f, 0.04510321f, 0.01107433f, -0.00436515f, 
    -0.01453444f, -0.04198946f, 0.01942634f, -0.05256740f, 0.00634490f, 0.03819488f, -0.02960705f, -0.02446044f, 
    -0.00971033f, 0.00714157f, -0.05691221f, 0.03681531f, -0.05269890f, -0.02839250f, 0.03134271f, -0.02729663f, 
    -0.02246867f, 0.04283709f, -0.05341149f, -0.04970449f, -0.05462163f, 0.03838518f, 0.01890261f, 0.02543149f, 
    -0.04696047f, -0.04684062f, 0.00913591f, -0.01706430f, -0.00106497f, -0.04481827f, -0.05883927f, 0.03272970f, 
    0.03062640f, -0.02831462f, 0.03437791f, -0.01691563f, 0.04306516f, 0.00514491f, -0.02339963f, 0.02867780f, 
    -0.05993085f, -0.01741728f, 0.00595236f, -0.03361249f, -0.03424997f, -0.00012718f, -0.00328738f, 0.03018817f, 
    0.00657079f, 0.03041757f, 0.01581091f, -0.02996509f, 0.04947578f, -0.01504794f, 0.00279060f, -0.03375845f, 
    -0.02896255f, 0.04571638f, 0.03040132f, -0.05104883f, -0.01907879f, -0.00276268f, -0.05384596f, -0.03432722f, 
    -0.01837431f, -0.05896797f, -0.02714201f, 0.00930798f, 0.00003699f, 0.02439097f, 0.01143949f, 0.01008785f, 
    -0.02139271f, 0.04069611f, -0.05044862f, -0.03689240f, -0.00946748f, 0.01263664f, -0.06199273f, -0.04366497f, 
    0.03770997f, -0.00880203f, 0.01996628f, 0.04501261f, -0.01917029f, -0.03165378f, 0.03498025f, -0.00708373f, 
    -0.04754614f, -0.02150393f, -0.04311409f, -0.05429581f, 0.02347512f, -0.06057944f, 0.02042537f, -0.01242198f, 
    -0.05123123f, -0.00031375f, -0.01777118f, -0.03926156f, -0.00175747f, -0.02738590f, -0.05670946f, 0.01267800f, 
    0.02061047f, 0.03112035f, 0.00524747f, 0.04832374f, -0.02296708f, -0.02042534f, -0.03151567f, -0.03617581f, 
    0.01839667f, -0.03174074f, -0.04745356f, -0.02824018f, -0.05241263f, -0.01503168f, -0.00439457f, -0.05412683f, 
    -0.05156302f, -0.00048321f, -0.03742240f, -0.01184337f, -0.04339041f, 0.01042117f, 0.00928526f, 0.02614685f, 
    -0.03015315f, -0.00769326f, 0.03707862f, -0.05908754f, -0.06358240f, -0.00396489f, -0.05230267f, -0.05462806f, 
    0.02955630f, -0.01201751f, -0.01169504f, 0.02422101f, -0.00679302f, -0.04038636f, 0.01096363f, 0.02988114f, 
    0.04353203f, -0.03891018f, -0.01165147f, 0.03959594f, 0.03714435f, 0.04333577f, 0.04556574f, 0.01192686f, 
    0.03919335f, -0.03421937f, -0.02579228f, 0.02249432f, -0.02107929f, 0.00426781f, -0.00430078f, 0.01698813f, 
    0.02982968f, 0.04727179f, -0.00063117f, -0.02233150f, -0.05073119f, 0.04181730f, 0.02541794f, 0.03378053f, 
    -0.05418647f, 0.03854824f, -0.02540316f, -0.04904189f, -0.05878771f, -0.04046466f, 0.01033249f, -0.00468543f, 
    0.03317861f, -0.04908342f, -0.04742027f, -0.04655977f, -0.04155032f, 0.03688100f, -0.03186999f, -0.01577540f, 
    0.00993640f, -0.00113176f, -0.03362732f, -0.01415141f, -0.06225310f, -0.00629683f, -0.04017916f, 0.01214265f, 
    -0.03027994f, -0.02696767f, -0.04265188f, 0.00214130f, -0.00426318f, 0.02090981f, -0.06610717f, -0.06284284f, 
    0.02566797f, 0.00311069f, 0.03223730f, 0.04714370f, 0.03501923f, 0.02807168f, -0.04900999f, -0.04271103f, 
    -0.02031651f, -0.02055351f, -0.04559842f, 0.03524448f, -0.01943320f, -0.04607501f, -0.00333881f, -0.00056941f, 
    0.02531097f, 0.01615165f, -0.04438259f, -0.01831787f, -0.05451708f, -0.03172372f, 0.03947454f, 0.02272262f, 
    0.05400246f, -0.02797013f, -0.00846620f, 0.04020545f, 0.02024509f, 0.03666756f, 0.02263651f, -0.06498873f, 
    -0.03188764f, -0.05469966f, 0.03836937f, 0.04804653f, -0.04957006f, -0.06744084f, -0.01360320f, -0.00138450f, 
    -0.01992942f, 0.01682183f, 0.01179416f, 0.04870284f, -0.05465537f, 0.00113263f, -0.05183155f, 0.03251301f, 
    0.00414235f, -0.04538576f, -0.06096636f, -0.01506526f, -0.01604672f, -0.05257504f, -0.03606619f, -0.03667475f, 
    0.04957137f, -0.04382498f, -0.06854855f, -0.04144451f, 0.03801928f, -0.04775980f, 0.03604056f, -0.04414418f, 
    -0.02874674f, 0.05036038f, -0.02761146f, -0.00691758f, -0.00250537f, 0.03522345f, 0.01495303f, -0.01479235f, 
    -0.04398471f, 0.01070140f, -0.03012695f, 0.00308045f, -0.01736155f, 0.03454258f, 0.02450197f, -0.06060639f, 
    -0.01823761f, 0.04094660f, -0.02960435f, -0.00086673f, 0.02040965f, -0.01605676f, 0.00090349f, -0.03557328f, 
    -0.02908137f, 0.00472397f, 0.02380089f, 0.04053155f, -0.03474629f, 0.03832813f, -0.00603543f, 0.03680859f, 
    -0.05241517f, -0.00291717f, 0.02187424f, -0.04060124f, 0.02511140f, -0.03064570f, -0.02272811f, -0.04308079f, 
    0.03874617f, -0.04603537f, -0.00490518f, 0.02845267f, -0.04686131f, -0.05568848f, -0.02240469f, 0.04467145f, 
    0.03593770f, 0.00972838f, 0.02006029f, 0.02205926f, 0.02817576f, -0.01323545f, 0.00884020f, 0.01178216f, 
    -0.02161255f, -0.02893917f, -0.05429478f, -0.01306240f, -0.00026836f, 0.02847415f, -0.04436650f, -0.02683710f, 
    0.00554215f, -0.00744057f, -0.02966846f, 0.01610785f, -0.03242822f, 0.03021158f, 0.00284993f, 0.02346438f, 
    -0.04955979f, -0.01173651f, -0.04310077f, 0.00532642f, -0.03731642f, 0.00037059f, 0.04522050f, -0.05440017f, 
    0.04505281f, -0.04164027f, 0.02105599f, -0.06212649f, -0.04156121f, -0.05472079f, 0.02285809f, -0.03266229f, 
    -0.04084949f, -0.05739808f, -0.03144555f, -0.02227911f, 0.01988307f, 0.00505616f, 0.00061041f, 0.02290946f, 
    -0.05455798f, -0.03283632f, -0.02580820f, 0.03455400f, -0.01753205f, -0.04168639f, 0.02416423f, 0.04271760f, 
    -0.04547882f, 0.02000006f, -0.03465834f, -0.01283090f, -0.02377774f, 0.02969923f, 0.02043123f, -0.05034351f, 
    -0.05036692f, 0.02129627f, 0.00096154f, 0.01815862f, 0.03800377f, -0.00336034f, -0.05744817f, -0.04645754f, 
    -0.00094496f, -0.04282545f, 0.04341640f, 0.01381695f, -0.00476469f, -0.05464791f, -0.02451914f, 0.02211128f, 
    -0.04522685f, 0.02452466f, -0.01994944f, 0.02677143f, -0.01215295f, -0.05032289f, 0.01529237f, 0.00240427f, 
    -0.02527407f, -0.01676798f, -0.02671287f, -0.05306929f, -0.00398274f, 0.04590632f, 0.04455910f, -0.01762431f, 
    -0.01022544f, -0.00574397f, -0.04455368f, -0.01333838f, 0.02411681f, -0.03255011f, -0.03238506f, 0.00339230f, 
    0.01758073f, -0.01832662f, 0.00945967f, 0.00730236f, -0.04490066f, -0.01217466f, 0.00897624f, 0.00362666f, 
    -0.02387664f, -0.06231168f, -0.01838810f, -0.00604692f, -0.04002430f, -0.04295065f, 0.02944148f, -0.03769312f, 
    -0.05256013f, 0.02990743f, -0.02931976f, -0.01264019f, 0.03702069f, 0.01311782f, 0.00221929f, -0.04890753f, 
    -0.04198707f, -0.03106299f, -0.02069670f, -0.02549169f, 0.00875157f, 0.00699184f, 0.00138193f, 0.04198001f, 
    -0.00597929f, 0.03888949f, 0.03637601f, 0.02236615f, -0.06194238f, 0.03742636f, -0.00101599f, 0.01480295f, 
    0.02205962f, -0.04295647f, -0.02803840f, 0.00451254f, -0.05829639f, 0.01859676f, -0.01821701f, -0.01867332f, 
    -0.02944030f, 0.02904212f, 0.02951836f, -0.00590437f, 0.00251166f, 0.02423958f, 0.03678420f, 0.00557986f, 
    -0.03749073f, -0.04265869f, 0.02863606f, -0.02559275f, -0.04011140f, -0.01594207f, -0.03469989f, -0.06163360f, 
    -0.00856128f, 0.01107984f, -0.06142488f, -0.04203372f, -0.00804093f, 0.03797996f, -0.02149721f, -0.04747004f, 
    0.02693770f, -0.01992893f, 0.03141917f, -0.01303008f, -0.04103790f, -0.00913304f, -0.04350044f, -0.05916677f, 
    0.03639320f, 0.01347552f, -0.04083220f, -0.00466807f, -0.00955522f, -0.03603443f, -0.04044235f, -0.04185607f, 
    0.00805521f, -0.01708867f, -0.02578244f, -0.05751724f, -0.00930645f, -0.00174587f, -0.01135711f, -0.05752967f, 
    -0.00388298f, 0.03022414f, -0.03623586f, 0.02083947f, -0.01635365f, -0.01907135f, -0.05903421f, -0.01975149f, 
    0.01060058f, -0.05556263f, 0.00261996f, -0.00504843f, -0.06069786f, -0.01232496f, -0.03274610f, 0.03111676f, 
    0.00798047f, -0.02283128f, -0.01053982f, 0.01861833f, -0.00084040f, -0.02806133f, 0.00737470f, 0.02163929f, 
    -0.03531598f, 0.02286424f, 0.04697927f, 0.03790933f, -0.04157068f, 0.00578357f, -0.02026813f, -0.06097253f, 
    -0.05956474f, 0.01519240f, -0.03960192f, -0.01836517f, -0.02142086f, 0.02692609f, -0.05304242f, 0.01941731f, 
    0.03561035f, -0.04288075f, 0.01227255f, 0.03237547f, -0.06048368f, -0.00420376f, -0.06135589f, -0.02142910f, 
    -0.00179084f, -0.02420836f, 0.02872984f, -0.00581898f, -0.01425123f, -0.05802239f, 0.04574466f, 0.04584312f, 
    -0.00225024f, -0.00226312f, -0.00753010f, -0.04629954f, 0.03115550f, -0.03248866f, -0.02409944f, 0.02121065f, 
    -0.01717900f, 0.03867011f, 0.02293349f, 0.00760804f, -0.00173408f, -0.03740273f, -0.02258333f, 0.01816333f, 
    -0.05384393f, -0.05465468f, 0.02707926f, 0.01510182f, -0.00370840f, 0.01565107f, 0.02950202f, 0.00669074f, 
    0.00730332f, -0.02812580f, -0.01813575f, -0.01666684f, -0.03420581f, 0.01236230f, -0.05860731f, -0.03650139f, 
    0.04938119f, -0.00645362f, -0.03016554f, -0.00842121f, 0.04069343f, -0.03498526f, 0.04723892f, -0.06070347f, 
    0.04696957f, -0.00643821f, -0.02048450f, 0.02296965f, -0.04658054f, 0.02579303f, 0.02416360f, -0.05898504f, 
    -0.02800030f, -0.01755778f, -0.04985451f, 0.03679992f, -0.00233369f, -0.00092576f, 0.03554294f, 0.01740441f, 
    -0.01829990f, -0.05690211f, -0.04983133f, 0.04217035f, 0.00265428f, 0.03374690f, -0.03528415f, -0.02019270f, 
    -0.05206855f, -0.03376998f, -0.05890941f, 0.01384895f, 0.01976868f, -0.00066328f, -0.01686828f, 0.04566835f, 
    -0.03890702f, -0.04259001f, 0.01478724f, 0.01058548f, 0.04341144f, -0.00282391f, -0.04330675f, 0.02601558f, 
    -0.01750836f, 0.04009939f, 0.00278417f, -0.04518908f, 0.01959541f, 0.04714081f, -0.05801522f, -0.04354045f, 
    -0.06178613f, -0.03864444f, -0.03879672f, 0.03762015f, -0.04756780f, -0.03893181f, -0.00769384f, 0.04859734f, 
    -0.00972726f, -0.05943869f, -0.05965573f, -0.05340643f, -0.00850798f, -0.03631264f, -0.02658044f, 0.01854487f, 
    -0.05870579f, 0.03872299f, 0.04148328f, 0.00764086f, 0.02844544f, 0.03459322f, -0.00889875f, -0.03901773f, 
    -0.06050000f, 0.00658745f, 0.01803153f, -0.04193579f, -0.04343967f, 0.00767942f, 0.02044958f, -0.05954824f, 
    0.00331966f, 0.03047306f, -0.00668000f, 0.01994266f, 0.01994394f, -0.00576349f, -0.01052100f, 0.01248360f, 
    0.03026111f, 0.00839644f, -0.03310517f, 0.03553623f, -0.04163573f, 0.01515445f, -0.01121616f, -0.04161320f, 
    0.00542568f, 0.03656619f, -0.00381376f, -0.01318041f, 0.00952852f, -0.02686652f, -0.01005833f, 0.04324427f, 
    -0.00846156f, -0.05708865f, 0.01159761f, -0.05076721f, -0.05802709f, -0.01571395f, -0.05526370f, -0.01853622f, 
    -0.01077108f, -0.02647441f, -0.03372681f, 0.04826288f, -0.05650064f, 0.02200226f, -0.05607317f, 0.03321916f, 
    -0.04306862f, 0.04058882f, 0.01020349f, 0.02699556f, -0.00654456f, -0.02397591f, -0.05954079f, -0.00895626f, 
    -0.04663688f, -0.01164546f, -0.05881628f, -0.04992292f, 0.00057295f, 0.00929364f, 0.01309163f, -0.01014674f, 
    -0.03113890f, -0.05934355f, -0.03864793f, 0.03587805f, -0.00503758f, 0.00596478f, 0.01733828f, -0.00966737f, 
    -0.01967948f, 0.04719105f, -0.05950376f, 0.02347022f, -0.00795590f, 0.01583647f, -0.02470439f, -0.05161312f, 
    -0.01683495f, 0.01577508f, -0.04646427f, 0.02547185f, 0.01199301f, 0.03844163f, 0.03187447f, -0.04919832f, 
    -0.01684137f, -0.01738053f, -0.01233706f, 0.02584940f, -0.03993309f, -0.01099989f, -0.01284115f, -0.01891763f, 
    -0.02724824f, -0.00115556f, 0.00170248f, 0.04878154f, -0.03051203f, 0.03153652f, -0.04912786f, -0.03786680f, 
    -0.05947798f, -0.06013101f, -0.04140234f, 0.03196663f, -0.01304689f, -0.01975825f, 0.01170948f, -0.01804367f, 
    0.03708525f, -0.00440488f, 0.03404004f, 0.03263587f, 0.00077313f, 0.01499894f, 0.01250759f, 0.01527925f, 
    0.04787297f, 0.03669116f, 0.00009969f, -0.02002450f, 0.00214106f, -0.02741328f, -0.01454184f, 0.04657393f, 
    -0.05189416f, -0.00113540f, 0.04624163f, 0.00495443f, 0.02374792f, 0.04697730f, -0.05493508f, -0.02803769f, 
    0.01870386f, -0.03451648f, -0.02503937f, 0.00003522f, 0.00226934f, -0.03164422f, 0.02083022f, -0.02369222f, 
    0.04842907f, -0.00893767f, 0.04769158f, 0.03865908f, 0.04171503f, 0.04817800f, -0.04982875f, -0.02063678f, 
    -0.05252511f, 0.00239059f, 0.04849752f, -0.00111683f, -0.05493555f, 0.04584069f, 0.00390889f, -0.03796326f, 
    0.03476366f, -0.03801117f, -0.02379428f, 0.01234486f, 0.00270263f, -0.05250281f, -0.03847329f, -0.00643306f, 
    0.03498223f, -0.05380403f, 0.04711490f, -0.03932280f, -0.05650456f, 0.04114149f, -0.03152659f, -0.02224836f, 
    -0.03417186f, -0.02967660f, 0.01622300f, 0.04012011f, -0.02176146f, -0.04579783f, -0.05383505f, 0.00858591f, 
    0.01283548f, -0.00761419f, -0.04492189f, 0.04601679f, -0.01960512f, -0.03227695f, 0.01725665f, -0.05622603f, 
    0.00881207f, 0.02082445f, -0.01796247f, -0.05638334f, 0.04841878f, -0.00079523f, -0.01632543f, 0.02057646f, 
    -0.00255269f, -0.00086732f, 0.01105379f, -0.05199903f, -0.06052692f, 0.02940281f, -0.06081785f, -0.02598667f, 
    -0.01324842f, 0.03257003f, -0.02677270f, -0.02758439f, 0.01953361f, -0.02869660f, -0.03299803f, -0.02916996f, 
    -0.02152307f, 0.04794914f, -0.04552348f, -0.01433862f, -0.01445109f, -0.03929352f, -0.00708444f, -0.03646818f, 
    -0.03585187f, -0.03160019f, 0.04552658f, 0.00065640f, -0.00387590f, -0.05795514f, 0.04355419f, -0.03240380f, 
    0.01179814f, 0.00962286f, -0.03100785f, -0.02724051f, -0.02432881f, -0.03579002f, 0.02494629f, -0.02226438f, 
    -0.05269241f, 0.04115112f, 0.01097529f, 0.04581651f, -0.01372634f, -0.02108753f, -0.02835880f, 0.04793257f, 
    0.02676270f, 0.03635781f, -0.03001854f, -0.06217353f, 0.03812313f, 0.03566735f, 0.02091474f, 0.01028508f, 
    0.01658817f, 0.00783844f, 0.03604292f, 0.02808580f, 0.02187644f, -0.04873857f, -0.04707234f, -0.06126371f, 
    -0.03049702f, 0.04666558f, 0.01596123f, -0.00480153f, -0.00203416f, -0.01279598f, -0.04084621f, 0.02194780f, 
    0.02623663f, -0.04370509f, 0.03853153f, -0.02196674f, -0.02230479f, -0.02899150f, -0.06045523f, -0.03797077f, 
    -0.05794190f, -0.01522039f, -0.05110483f, 0.04229782f, 0.00206706f, -0.05563784f, -0.02516505f, -0.05576523f, 
    -0.01583822f, 0.00835012f, 0.04596305f, -0.05411368f, -0.02438222f, 0.01816449f, -0.03812264f, 0.04685781f, 
    -0.06010959f, -0.02530824f, 0.04677713f, -0.00434109f, 0.04151665f, -0.06282716f, -0.05140177f, -0.01731282f, 
    -0.06147056f, 0.00727328f, -0.02818619f, -0.03935510f, 0.03358067f, 0.04663398f, -0.01556494f, -0.02292585f, 
    0.03082549f, -0.02739643f, 0.00039423f, 0.00704364f, -0.02868596f, -0.04491533f, 0.02843154f, 0.02219537f, 
    -0.06172636f, 0.02627075f, -0.00378885f, 0.04376918f, 0.00750565f, 0.04580710f, 0.00338826f, -0.04802727f, 
    0.01680502f, -0.02690618f, 0.01883158f, 0.01930384f, 0.03370024f, -0.04582718f, -0.01444284f, 0.04816204f, 
    -0.04744174f, -0.02535270f, 0.00037923f, -0.02285600f, 0.03477053f, 0.00933343f, 0.01210363f, 0.01318162f, 
    -0.04979004f, 0.03360858f, -0.02960941f, -0.02475548f, 0.00135179f, -0.05210579f, -0.05453033f, 0.02243793f, 
    0.00569013f, -0.03726472f, -0.05297649f, -0.02472426f, -0.05719310f, -0.04799073f, -0.05264638f, 0.03603839f, 
    -0.02320539f, -0.02487853f, 0.02147784f, -0.01601471f, -0.03562127f, -0.02588353f, -0.01050568f, -0.02400881f, 
    -0.00233957f, -0.02726341f, -0.03311928f, -0.00202864f, 0.03556179f, 0.01157760f, -0.04781698f, 0.02101701f, 
    0.04678853f, -0.03140543f, -0.01184913f, -0.03752795f, 0.01066427f, -0.01962042f, -0.03979916f, 0.04344818f, 
    0.01692686f, -0.00452776f, 0.00471009f, -0.04308313f, -0.00553349f, 0.03923561f, -0.03920668f, -0.02347216f, 
    0.03607410f, -0.04023478f, -0.03017370f, -0.05239102f, -0.03746614f, -0.03095066f, 0.01869670f, -0.04275299f, 
    0.03646249f, -0.03825812f, 0.02535117f, -0.05852196f, 0.04313389f, 0.03194806f, 0.01571188f, 0.04713434f, 
    -0.05884292f, 0.00789718f, 0.03795990f, -0.01781746f, -0.03112168f, 0.02464676f, 0.04112913f, 0.01699514f, 
    0.00764101f, -0.06097792f, -0.01612606f, 0.03355046f, 0.04388041f, -0.03669149f, -0.02526255f, -0.01073585f, 
    -0.03218379f, 0.02540536f, 0.00356346f, 0.04113948f, -0.05583193f, 0.01602609f, -0.02589501f, 0.03718005f, 
    -0.05278673f, 0.00171108f, 0.02769119f, 0.01594398f, 0.03439647f, -0.04301324f, -0.03328764f, -0.03699775f, 
    -0.03107553f, 0.00203304f, -0.01779628f, -0.04369362f, 0.03904564f, 0.01406787f, -0.05191414f, -0.00753052f, 
    0.04704714f, 0.03072188f, -0.01549433f, 0.03954640f, -0.05165320f, -0.06031448f, -0.02808551f, 0.04073116f, 
    -0.04526566f, 0.04815698f, -0.06091482f, -0.00417359f, -0.00358960f, 0.02527191f, -0.05120318f, -0.00765895f, 
    0.04356559f, -0.04656965f, 0.01531457f, 0.00227807f, -0.02347944f, 0.01378014f, -0.00883074f, 0.04316951f, 
    -0.04713783f, 0.02624734f, -0.01597132f, 0.00554615f, -0.02529277f, -0.04662756f, -0.03879066f, -0.06272087f, 
    0.01911131f, -0.02011997f, 0.01507169f, 0.04346377f, -0.05058505f, -0.00739433f, 0.00279867f, -0.03802239f, 
    -0.05972982f, -0.04109946f, 0.02232739f, -0.05460354f, -0.05343705f, 0.03453913f, -0.03894391f, 0.00573889f, 
    0.03380806f, 0.03105501f, -0.02318969f, -0.04476687f, 0.01376488f, -0.04906120f, -0.05200569f, -0.01943850f, 
    -0.01038888f, 0.04773393f, -0.04859130f, -0.04564400f, -0.03330830f, -0.05086545f, -0.04663398f, -0.03110496f, 
    -0.03635265f, -0.01489880f, 0.01992359f, -0.01155736f, -0.01972752f, -0.00123189f, 0.03969150f, -0.00446960f, 
    0.02251257f, -0.04963240f, -0.06256046f, -0.00162839f, 0.03937643f, -0.05037947f, 0.03780262f, -0.00629975f, 
    -0.05819757f, 0.04808773f, -0.00874148f, 0.00375960f, -0.02026228f, 0.03939993f, 0.01370766f, -0.03912112f, 
    0.02779079f, -0.05360402f, -0.04543884f, 0.04207413f, -0.03392330f, -0.03545825f, -0.04390406f, 0.04051939f, 
    -0.04921036f, 0.00304374f, 0.01816307f, -0.02268576f, -0.00165263f, -0.03885658f, -0.00257587f, 0.01011627f, 
    -0.01378865f, 0.04818931f, -0.01488238f, -0.05163584f, -0.02575959f, 0.01840879f, 0.00759252f, -0.05526423f, 
    -0.32365137f, 0.10502412f, 0.73208630f, 0.03572032f, -0.43592355f, -0.18070449f, -0.17983815f, 0.04626900f, 
    0.10971436f, 0.07830202f, -0.06345084f, -0.11047819f, -0.02691331f, 0.01452319f, -0.08369591f, 0.04809655f, 
    -0.08490033f, -0.07446974f, 0.03240114f, 0.09225884f, 0.06853428f, -0.25391525f, -0.23279905f, 0.04641504f, 
    0.14332893f, 0.23744124f, 0.09921110f, 0.04318814f, 0.26967800f, 0.02418953f, 0.07640538f, -0.00124063f, 
    0.03346394f, 0.07688169f, 0.08354085f, -0.00480672f, -0.07838693f, -0.01897226f, -0.00318969f, 0.06178169f, 
    -0.05163838f, -0.05644263f, 0.48962659f, 0.10717181f, -0.26883942f, -0.20827207f, 0.08334018f, 0.11196841f, 
    -0.03488475f, -0.01954714f, -0.07038932f, 0.03000944f, -0.05381669f, 0.06488904f, 0.01478542f, -0.12925620f, 
    -0.07563028f, -0.11907107f, -0.04528315f, 0.03254261f, 0.23045681f, -0.38142097f, 0.31395835f, -0.05779058f, 
    0.11991162f, -0.24413939f, 0.03493688f, 0.01191101f, -0.00262821f, 0.04486409f, -0.09474436f, -0.05309547f, 
    0.01232080f, -0.01378759f, -0.09541848f, -0.15065783f, -0.08080752f, 0.06094341f, -0.02215568f, -0.04126783f, 
    -0.25379249f, -0.07939781f, 0.51932126f, 0.39902866f, -0.10452773f, -0.08733465f, -0.20803978f, 0.07801301f, 
    -0.03169373f, 0.08062973f, -0.21887121f, -0.12379634f, 0.02374839f, 0.08168101f, 0.00835997f, -0.03373126f, 
    -0.01771115f, 0.05489108f, 0.04806396f, -0.15808666f, -0.00291857f, 0.00712292f, -0.37460533f, -0.11628805f, 
    0.05291865f, 0.24011724f, 0.28958529f, -0.03668381f, 0.12389835f, 0.29467350f, 0.01257468f, -0.04141847f, 
    -0.01294291f, 0.06583076f, -0.01725012f, 0.17619619f, 0.09680873f, 0.02733813f, 0.00899679f, 0.11308464f, 
    0.29314545f, -0.48357356f, -0.04789321f, -0.00104945f, -0.27500305f, 0.06721329f, 0.07363850f, 0.05937565f, 
    0.02839053f, -0.13627140f, -0.04609382f, 0.00427659f, 0.10633483f, -0.10920525f, 0.00757445f, -0.06604542f, 
    0.06587026f, 0.09660464f, -0.08787345f, 0.10356484f, 0.04634516f, -0.29475966f, 0.03127956f, 0.50873572f, 
    -0.04113170f, -0.00647800f, 0.19624569f, 0.03595854f, 0.10002886f, 0.12805152f, 0.10358830f, -0.00283139f, 
    0.00224889f, 0.11086442f, 0.07196554f, 0.14434002f, 0.05514971f, -0.12138614f, 0.01193347f, -0.09644502f, 
    -0.17712045f, -0.07743960f, 0.09415412f, 0.02015410f, 0.40062344f, 0.25197834f, 0.23704532f, -0.03927778f, 
    0.12957786f, 0.15380993f, -0.02360093f, 0.09879799f, 0.06209379f, 0.01137753f, 0.16598295f, 0.04406267f, 
    0.08582570f, -0.05300567f, -0.05754645f, 0.07074121f, 0.20555158f, -0.14922661f, 0.07322007f, -0.17628828f, 
    0.17048939f, 0.08093455f, 0.11273076f, -0.04159972f, 0.07580684f, 0.17096616f, -0.05606286f, -0.05229226f, 
    -0.00967294f, 0.00388051f, 0.05188441f, 0.05719491f, 0.02204485f, 0.12963173f, 0.00919933f, 0.06964677f, 
    -0.18973564f, 0.07637631f, 0.39446083f, -0.14888585f, 0.37649402f, -0.11539849f, 0.05149675f, 0.03908304f, 
    0.18396717f, -0.05539273f, -0.02500528f, -0.04800775f, 0.01279314f, 0.01835964f, -0.07572621f, 0.17904687f, 
    0.03766434f, 0.22757579f, -0.12895554f, 0.02071072f, -0.38328946f, -0.21722072f, 0.14096500f, -0.16540989f, 
    0.30241010f, 0.04245939f, -0.00985253f, 0.16814162f, -0.00526739f, -0.04995836f, 0.18952104f, 0.19109626f, 
    0.04021494f, -0.05042439f, 0.17646533f, -0.11028012f, 0.14292528f, 0.30137020f, -0.03735079f, 0.04682297f, 
    0.19712310f, 0.37663957f, 0.44172004f, 0.16641268f, 0.34525117f, -0.27226245f, -0.08962590f, 0.12607186f, 
    0.05084148f, 0.01660103f, 0.01369549f, 0.02022663f, 0.00921723f, 0.15211521f, 0.04182259f, 0.27916685f, 
    0.02886339f, -0.18827669f, -0.02466712f, -0.07575845f, 0.10005565f, 0.32379991f, -0.17906946f, -0.00160525f, 
    0.03407270f, 0.16359612f, 0.19778802f, -0.05607488f, 0.11028937f, -0.11663610f, 0.13411097f, 0.14246602f, 
    0.05850805f, 0.18205608f, 0.18549082f, 0.18339942f, 0.07591396f, -0.01797813f, -0.08378507f, 0.05335241f, 
    0.07269697f, -0.16348769f, -0.17712295f, -0.02164579f, 0.19217218f, 0.20602839f, 0.15822460f, 0.16594616f, 
    0.03702398f, 0.12249175f, -0.04353087f, 0.03476484f, -0.07596737f, 0.07981448f, 0.12300710f, 0.16534819f, 
    0.02138121f, 0.21058160f, -0.11319287f, 0.02933626f, 0.31332695f, -0.33735126f, -0.23766056f, 0.33911943f, 
    -0.19099823f, 0.27759823f, 0.01099773f, 0.07895442f, 0.10809920f, 0.10691319f, 0.21794996f, 0.03418329f, 
    0.02339868f, -0.07398497f, 0.01589079f, 0.15055926f, -0.03836182f, 0.11502382f, 0.09563609f, 0.13797532f, 
    0.19208543f, 0.25729957f, -0.32274437f, 0.05923697f, 0.22458285f, 0.07583573f, -0.05901896f, -0.00258173f, 
    0.05678795f, -0.03591621f, 0.13371788f, 0.04765335f, -0.01976955f, 0.22730310f, 0.01034371f, 0.24184930f, 
    0.02324499f, 0.08556031f, -0.04780682f, -0.00350838f, -0.13125187f, 0.44546545f, 0.02987291f, -0.17238106f, 
    -0.01849009f, -0.00249219f, 0.07755005f, -0.02508508f, 0.02721895f, 0.07388861f, -0.02476516f, -0.13037455f, 
    0.08525502f, -0.07521986f, 0.16742402f, 0.09669610f, 0.12905960f, 0.04388977f, 0.03580365f, 0.02486377f, 
    0.10267778f, -0.19449256f, 0.00008474f, -0.08173566f, -0.03204222f, 0.15176809f, -0.01152629f, -0.03623513f, 
    0.04218525f, -0.03596433f, 0.11394876f, 0.17717141f, 0.02542204f, -0.13826752f, -0.14104038f, 0.20032810f, 
    0.08408792f, 0.03994596f, 0.15293731f, 0.13751516f, 0.01870768f, -0.32536158f, 0.21181905f, -0.01353281f, 
    0.24860984f, 0.32872826f, -0.16885132f, 0.08238178f, 0.05339073f, -0.11729947f, 0.10628516f, -0.03584400f, 
    0.02583997f, 0.09076802f, 0.08618744f, 0.07344709f, 0.02232524f, -0.08481701f, -0.07461662f, -0.08025308f, 
    0.20678285f, 0.16636743f, -0.18380986f, -0.14242208f, 0.13579980f, 0.08326392f, 0.15683217f, 0.02771524f, 
    0.04055466f, 0.04573723f, 0.16707206f, 0.11091723f, 0.06684312f, 0.10754658f, -0.09897865f, 0.08450303f, 
    0.04764677f, -0.06283492f, -0.03194293f, -0.01389871f, 0.37966835f, -0.22668253f, 0.00136210f, -0.11144894f, 
    -0.29866207f, -0.12573537f, -0.24139614f, -0.01747324f, -0.06370527f, -0.05036660f, 0.10839921f, 0.08851171f, 
    -0.01788916f, -0.04675081f, -0.01853735f, 0.02385015f, -0.00967022f, -0.06426170f, -0.09901926f, 0.06490089f, 
    0.22755562f, 0.20584220f, -0.18153220f, 0.24448892f, 0.09027302f, -0.10572784f, 0.00522456f, 0.06106660f, 
    -0.03356816f, 0.12772207f, 0.07174794f, 0.01947948f, -0.02186040f, 0.00642185f, 0.05802175f, 0.15439951f, 
    -0.05870391f, -0.00789040f, -0.09724199f, 0.11857563f, 0.19035228f, 0.12018190f, 0.07287618f, -0.18072250f, 
    -0.08312826f, 0.11401118f, -0.10445975f, 0.06994914f, 0.05229549f, -0.01260149f, -0.11214003f, 0.03841538f, 
    -0.10663865f, -0.05336364f, -0.04850603f, -0.00173319f, 0.01159088f, -0.00831461f, 0.15415040f, -0.03177711f, 
    0.43848169f, 0.11670611f, -0.29028520f, 0.10714761f, 0.16446804f, -0.01193763f, -0.19668579f, 0.09163518f, 
    0.07809280f, 0.05419657f, 0.01299620f, 0.00141158f, -0.09883751f, -0.03002082f, 0.13718668f, 0.08602542f, 
    -0.05107196f, -0.00136197f, -0.04985841f, -0.16574953f, 0.28113493f, -0.41296813f, -0.05899751f, -0.15019552f, 
    -0.21078973f, 0.01567179f, 0.06304379f, 0.06584018f, 0.07062506f, -0.04849485f, 0.06006173f, -0.03863513f, 
    0.11028697f, 0.06287146f, -0.10700094f, 0.06645595f, 0.07167982f, -0.03895023f, 0.10424806f, 0.12746863f, 
    0.40479970f, -0.36914894f, -0.22052671f, 0.08984054f, -0.06832504f, -0.18538329f, 0.13965374f, -0.09758230f, 
    -0.01616068f, -0.00528795f, 0.02274931f, -0.03264864f, -0.05535118f, 0.09980902f, 0.09808329f, -0.19062874f, 
    -0.01149242f, 0.00042272f, 0.07176381f, 0.07655822f, 0.35077465f, 0.11161209f, -0.33989233f, 0.19855101f, 
    -0.06572641f, -0.10671202f, 0.03173251f, -0.11126268f, -0.00545943f, 0.13068968f, -0.06035064f, -0.05696006f, 
    0.07636687f, 0.05410362f, -0.00380526f, 0.12910110f, -0.09315361f, -0.01636533f, 0.04240017f, -0.10253523f, 
    -0.24172415f, -0.05983337f, -0.03581674f, 0.15320837f, 0.10120008f, 0.04650286f, -0.07252423f, -0.08629309f, 
    0.01480639f, 0.02410865f, -0.01979117f, -0.12349027f, 0.00333144f, -0.03367371f, 0.05732536f, -0.00588353f, 
    0.10573099f, 0.01487365f, 0.05999444f, 0.09938496f, 0.32906792f, -0.02269640f, -0.03822877f, -0.04207086f, 
    -0.23354255f, -0.06381422f, -0.02240044f, -0.20798370f, 0.09799981f, 0.10382446f, -0.13742195f, 0.01363583f, 
    -0.00190534f, -0.05617634f, 0.12304461f, 0.04043086f, 0.02873558f, -0.03828449f, 0.06858609f, 0.13602045f, 
    0.14448434f, -0.33237201f, 0.12603275f, -0.25285062f, -0.04471905f, -0.09385857f, -0.01417283f, 0.10095791f, 
    0.04902612f, 0.07943774f, 0.07811034f, -0.02419929f, 0.10701001f, -0.02911462f, -0.09957857f, -0.14234245f, 
    -0.01137733f, -0.22120059f, 0.06174932f, 0.07826516f, -0.16280758f, 0.44527146f, 0.16922401f, -0.16104959f, 
    -0.44662115f, -0.04810021f, -0.13904157f, 0.01638723f, 0.03573297f, 0.01519802f, -0.08880827f, -0.22115165f, 
    -0.03712356f, -0.00014778f, -0.02819981f, 0.03854876f, 0.10271242f, -0.07302794f, -0.01022095f, -0.05267385f, 
    -0.33518234f, -0.17072302f, 0.00582924f, -0.38894066f, -0.34033886f, -0.08161914f, -0.03603449f, -0.04430048f, 
    0.05742927f, -0.00762189f, -0.11261810f, -0.05044222f, 0.07698605f, 0.07320820f, -0.00200645f, 0.12493967f, 
    -0.08024800f, 0.00265475f, -0.04189402f, 0.02121696f, -0.26700404f, -0.27446282f, -0.06546307f, -0.13369514f, 
    -0.14044826f, -0.03270623f, 0.00633523f, 0.00413023f, 0.13868140f, -0.03060138f, 0.04055195f, 0.11741383f, 
    0.07660497f, 0.17912135f, 0.09390683f, -0.07396903f, 0.26476708f, 0.02125017f, -0.04597858f, 0.20474106f, 
    -0.00854697f, 0.18457729f, -0.17314084f, 0.19052246f, 0.12333114f, -0.04549662f, 0.05396948f, 0.20164570f, 
    0.10735239f, -0.03272631f, -0.03987366f, 0.13656147f, -0.02841006f, -0.00427197f, 0.02733046f, 0.09863812f, 
    0.06691967f, -0.00228205f, 0.29567677f, 0.07340753f, -0.00319018f, -0.29808894f, 0.22493088f, 0.04799875f, 
    0.58263391f, 0.23634918f, 0.02266561f, -0.00487399f, 0.01506247f, 0.00673386f, 0.02108019f, 0.00473781f, 
    0.01111505f, 0.04755902f, 0.01698491f, 0.14767645f, -0.17262462f, -0.06947695f, 0.02436840f, 0.05539561f, 
    -0.02629393f, 0.01140341f, 0.16163902f, 0.15099324f, 0.23535056f, 0.11295561f, 0.01780666f, -0.04690706f, 
    0.16328320f, 0.08335995f, -0.11957201f, 0.00285126f, 0.06507105f, 0.10419738f, -0.03715752f, -0.08001887f, 
    -0.00817840f, -0.06465772f, 0.05705630f, -0.13198577f, 0.45766267f, -0.07141791f, -0.09951720f, -0.15510826f, 
    -0.13010260f, -0.00379664f, 0.16834681f, 0.06920929f, -0.08526351f, -0.06107636f, 0.00193433f, 0.16147177f, 
    -0.11660638f, -0.02104192f, -0.07979278f, 0.05998797f, -0.11466699f, -0.16695718f, -0.09992318f, 0.10968737f, 
    0.67458969f, -0.31764084f, 0.13420261f, 0.04928778f, -0.20572582f, 0.02401492f, 0.13520722f, 0.03331106f, 
    -0.02806760f, -0.17411436f, 0.10207718f, -0.03065483f, 0.00659393f, -0.03569327f, 0.03234359f, 0.03711522f, 
    0.00757674f, -0.09291706f, 0.08781360f, 0.15451565f, 0.25968239f, 0.36431131f, 0.16342667f, -0.08206097f, 
    0.07829668f, -0.02909605f, 0.03571937f, -0.01899475f, 0.00682834f, 0.22973581f, -0.09842104f, -0.07887374f, 
    0.08561553f, 0.02729893f, -0.04648909f, 0.05931718f, 0.11341985f, -0.06325149f, -0.08603877f, -0.02756538f, 
    0.14137755f, 0.33381099f, -0.15957385f, 0.27403736f, 0.35823843f, 0.03201313f, -0.07214318f, 0.05143348f, 
    -0.01739971f, 0.03670866f, -0.06628764f, 0.21707907f, -0.09969349f, -0.06609301f, 0.03884752f, 0.01619775f, 
    0.03934335f, -0.04113533f, -0.14080051f, 0.15612082f, 0.28927991f, -0.23746242f, 0.05892450f, -0.30447194f, 
    0.11891045f, -0.12522894f, 0.14794584f, -0.02443342f, 0.09016135f, -0.10322835f, 0.00653522f, -0.05995132f, 
    -0.11816516f, -0.02190909f, 0.01216919f, -0.08926514f, 0.06422785f, -0.00787248f, -0.04645201f, 0.07559894f, 
    -0.83560210f, 0.05415029f, -0.25748402f, 0.15983117f, 0.43850738f, -0.01391864f, 0.09910129f, 0.09185860f, 
    0.03147208f, -0.06855740f, 0.10054122f, 0.02400383f, 0.05001090f, -0.09147266f, 0.04761429f, -0.00898733f, 
    0.02829619f, 0.07107118f, 0.12974314f, 0.04479770f, 0.43737119f, 0.28647757f, -0.05134314f, 0.12905616f, 
    0.06328832f, -0.16437024f, 0.02766090f, 0.03833553f, 0.08916717f, -0.02949910f, 0.05663173f, 0.02875035f, 
    0.07735255f, -0.00699851f, -0.00517792f, 0.02768516f, 0.04652695f, -0.02759906f, 0.00082436f, 0.14230210f, 
    -0.31137127f, -0.22954148f, -0.10593107f, -0.09519834f, -0.02137662f, -0.10380983f, 0.00367625f, -0.03215270f, 
    -0.19606021f, -0.11513917f, 0.00325785f, -0.05075790f, -0.12388382f, 0.13675211f, -0.02353359f, 0.10270139f, 
    -0.10657511f, -0.08514512f, -0.07665502f, 0.04558048f, 0.40644395f, 0.25431430f, 0.12466445f, -0.27238533f, 
    -0.33634642f, 0.05538110f, 0.01026933f, -0.12321364f, 0.13141693f, -0.05933528f, 0.02773718f, 0.15742910f, 
    -0.13840675f, -0.08884358f, -0.03106410f, 0.09777489f, 0.05051364f, 0.04890127f, -0.02862002f, 0.12977320f, 
    0.02825013f, 0.02207914f, 0.04814572f, -0.18978465f, 0.35632581f, 0.07573498f, 0.17771585f, 0.01074104f, 
    0.11301623f, 0.14889492f, 0.02317270f, 0.13463272f, 0.04702386f, 0.01171306f, 0.01332139f, 0.03640755f, 
    -0.00886701f, 0.02156065f, 0.04719516f, -0.13768086f, 0.31638777f, 0.32022947f, 0.11271539f, 0.04670581f, 
    -0.19616811f, 0.11222729f, -0.07379607f, 0.11316034f, -0.08402710f, -0.04040553f, -0.04124361f, 0.00875584f, 
    0.10246410f, -0.09094894f, 0.04644977f, 0.16292676f, 0.04463230f, 0.08979055f, -0.07490994f, 0.04351090f, 
    -0.05040513f, -0.01696212f, -0.01445455f, 0.02179519f, 0.03139601f, -0.01958033f, -0.02771409f, -0.04359441f, 
    0.04639903f, 0.04649569f, -0.02359791f, 0.05362464f, -0.05485106f, -0.03046539f, 0.02678320f, 0.03412316f, 
    -0.01510208f, 0.00924769f, -0.05702034f, 0.00996904f, -0.05858992f, -0.02223285f, -0.00812630f, 0.01227943f, 
    -0.00136461f, 0.04481042f, -0.00517053f, -0.00216676f, -0.01923474f, -0.03465857f, -0.02820528f, 0.02636984f, 
    0.02030453f, -0.04540607f, -0.04505621f, 0.03765528f, 0.03574621f, -0.00945361f, -0.03300349f, -0.04315265f, 
    0.01409456f, 0.02666847f, -0.00442940f, 0.01866706f, -0.01085939f, -0.05609125f, 0.01597966f, -0.03017848f, 
    -0.01315059f, 0.03607931f, -0.03330159f, -0.00759603f, -0.04086817f, 0.02199859f, 0.04967323f, -0.04611179f, 
    -0.01253958f, -0.05765889f, 0.02462616f, -0.05664862f, -0.05090409f, -0.05123112f, -0.00521202f, -0.04814703f, 
    -0.03516440f, 0.01966912f, -0.03705866f, -0.05249160f, -0.01605198f, -0.05530662f, -0.01493988f, 0.03638952f, 
    0.02171866f, -0.01481732f, 0.00363382f, -0.03986609f, 0.02342506f, 0.03266801f, 0.00540472f, -0.01222514f, 
    0.05128047f, 0.00825582f, 0.03594696f, 0.03974808f, 0.02679846f, 0.00537037f, -0.04525287f, 0.00130534f, 
    -0.01014035f, -0.01709395f, 0.00003369f, -0.03410967f, 0.00784929f, 0.02070113f, 0.00604156f, 0.00305010f, 
    0.01608065f, -0.03066955f, -0.04043658f, -0.01351629f, 0.01924446f, 0.01864513f, -0.06917532f, -0.03417502f, 
    0.01371421f, -0.04621049f, 0.01374228f, 0.02717890f, -0.05071802f, -0.01172146f, -0.00163684f, -0.03644164f, 
    -0.02921898f, -0.04091429f, -0.05464887f, 0.04692856f, -0.02156448f, 0.00603294f, -0.02887695f, -0.00272213f, 
    -0.00822380f, -0.04482141f, 0.04037108f, 0.01760676f, 0.04276385f, -0.01392820f, 0.04207197f, -0.02175043f, 
    0.01860872f, 0.03955548f, -0.00790875f, 0.01482153f, 0.00150686f, -0.04957749f, 0.01127238f, 0.03256167f, 
    -0.05041093f, 0.00393039f, 0.04982409f, 0.02149753f, 0.00244625f, 0.03238254f, 0.00621435f, 0.00022475f, 
    0.03126847f, -0.04229707f, -0.05900005f, 0.00305786f, -0.06314528f, -0.00725746f, -0.04737829f, 0.02840867f, 
    -0.03932783f, 0.00471074f, -0.04446350f, -0.04585553f, 0.03734009f, -0.00130789f, 0.03709359f, 0.01574163f, 
    -0.03746987f, 0.00842062f, -0.02659514f, -0.05281174f, -0.00990394f, -0.00299782f, -0.06479391f, 0.04341769f, 
    0.03310324f, -0.05318739f, 0.00331980f, 0.04187955f, 0.04219447f, 0.04442626f, -0.02449488f, 0.04604346f, 
    -0.04258257f, -0.01141280f, -0.06763300f, 0.01916175f, -0.04428569f, 0.00580505f, 0.03476736f, -0.06723033f, 
    -0.02577763f, 0.00154459f, -0.02821431f, 0.03414102f, -0.02235803f, -0.02541209f, 0.04291155f, -0.05388727f, 
    -0.03034263f, 0.02937362f, -0.06597851f, 0.02367321f, 0.01581884f, -0.05210687f, -0.05335586f, 0.02091924f, 
    0.04965467f, -0.03946302f, -0.02457059f, 0.01671437f, -0.05835319f, -0.06073734f, 0.03608188f, -0.06277728f, 
    -0.04677902f, -0.05663848f, -0.01786902f, 0.04835850f, -0.00058591f, 0.03506057f, -0.02878480f, -0.03968215f, 
    0.03909744f, 0.03962495f, -0.04636826f, -0.03158755f, -0.03581680f, -0.01514654f, 0.02233005f, 0.03774429f, 
    0.03978337f, -0.04786893f, -0.05261187f, -0.04426049f, 0.03845687f, 0.01641495f, 0.01903148f, 0.01322533f, 
    -0.04795527f, 0.04609857f, 0.03594746f, 0.01718311f, 0.03540974f, 0.01123454f, 0.04774675f, -0.05395435f, 
    0.01676590f, 0.01452678f, 0.00583859f, -0.04886447f, -0.05927763f, 0.00005183f, 0.01559581f, -0.05718700f, 
    0.04669507f, 0.02975197f, 0.03898147f, -0.02436634f, -0.02440431f, 0.02071554f, -0.04670695f, 0.01087847f, 
    -0.03935893f, -0.01996120f, -0.00443236f, 0.01868659f, 0.03088914f, 0.01724559f, 0.02632716f, -0.01492078f, 
    -0.02619216f, -0.03012411f, -0.01399653f, -0.05276193f, 0.02853473f, -0.03382929f, 0.03161942f, 0.00056273f, 
    -0.05703069f, -0.00277864f, 0.00666865f, -0.04700807f, 0.00738989f, -0.01795804f, -0.06375068f, -0.02768938f, 
    -0.00123394f, -0.05495758f, -0.03871959f, 0.00895504f, -0.01972867f, -0.03900671f, -0.06691569f, -0.03884033f, 
    -0.02064336f, 0.01248362f, -0.03580498f, -0.06088427f, -0.05925171f, -0.03771647f, -0.00631660f, -0.03999212f, 
    -0.03153926f, -0.04319093f, 0.04236699f, 0.01163387f, 0.00408260f, 0.04706878f, 0.00306429f, -0.02113573f, 
    -0.04531541f, -0.04554207f, 0.01988935f, -0.02269556f, -0.06518587f, 0.02607556f, 0.03005745f, 0.01900802f, 
    -0.05275880f, -0.02787032f, 0.05300509f, 0.00335527f, 0.01741441f, 0.00720701f, 0.02843253f, 0.02171179f, 
    -0.16990811f, -0.36136648f, 0.14598447f, -0.08706316f, -0.42246148f, 0.14204791f, 0.06605062f, 0.01418801f, 
    -0.01903626f, 0.11926865f, 0.03466971f, 0.10181973f, 0.13333368f, 0.00173915f, 0.08315264f, -0.01392615f, 
    -0.10437732f, -0.04672694f, 0.07463615f, 0.00723074f, -0.17826273f, -0.08966807f, 0.13931294f, 0.03157549f, 
    0.09374151f, -0.05204757f, 0.04388274f, 0.22279739f, -0.04932591f, 0.00246403f, 0.04847846f, 0.20695350f, 
    0.01605704f, -0.00417547f, -0.05303646f, -0.03054270f, 0.10642101f, -0.02190113f, -0.06421898f, 0.03937578f, 
    -0.02889532f, 0.04630799f, -0.38498640f, 0.01049017f, 0.22936121f, 0.13619201f, -0.07450172f, -0.04672284f, 
    -0.02239312f, 0.08330711f, -0.04512622f, -0.00808457f, 0.04636553f, 0.14996591f, 0.10113845f, -0.03681650f, 
    -0.00338556f, 0.12788272f, -0.10882537f, 0.01260105f, 0.00128401f, 0.37725961f, -0.41402030f, 0.15622948f, 
    0.16488157f, 0.04379665f, 0.21182403f, 0.03036595f, -0.13132517f, 0.09575314f, 0.01744797f, -0.05358369f, 
    -0.02105825f, 0.04315818f, 0.09211167f, 0.02428292f, 0.22678919f, 0.07953693f, -0.01796290f, 0.05436800f, 
    -0.06285878f, 0.17613290f, 0.12062027f, 0.20231900f, -0.16315505f, 0.09218033f, 0.10137422f, 0.02542818f, 
    0.05723967f, -0.04124017f, 0.08688940f, 0.06581113f, -0.08553834f, -0.07403395f, 0.03982397f, -0.01099267f, 
    0.04719153f, -0.05104093f, -0.07817719f, 0.16500156f, -0.02970821f, 0.10553336f, 0.23717061f, -0.05331024f, 
    0.25824115f, -0.04899183f, -0.11655178f, 0.03220490f, -0.00527713f, -0.08132594f, -0.07480630f, -0.04860825f, 
    0.08511017f, -0.01691121f, 0.05889304f, -0.00820644f, 0.05408490f, -0.00522101f, 0.04899875f, 0.04642526f, 
    -0.24133839f, 0.29481465f, 0.09201823f, 0.00038838f, 0.15267654f, 0.14155883f, -0.05424959f, -0.03473153f, 
    0.03781138f, 0.13029531f, -0.00976860f, 0.07506373f, 0.16002236f, 0.07205824f, 0.12811667f, -0.06613677f, 
    0.09426578f, 0.06012965f, 0.06145865f, -0.00602473f, 0.05897163f, 0.44616863f, -0.02085279f, -0.06953317f, 
    0.33136880f, -0.00195052f, 0.00281693f, -0.03333472f, -0.01371714f, -0.01623046f, -0.01835228f, -0.13693242f, 
    0.05568713f, -0.01498290f, 0.03040176f, -0.00594157f, 0.06081031f, -0.12518437f, 0.04413922f, 0.11425968f, 
    -0.01660372f, 0.04587444f, 0.18074109f, 0.16044253f, 0.04111148f, -0.15055077f, 0.10665253f, 0.11545070f, 
    -0.06322552f, -0.15932152f, -0.01025243f, -0.09507642f, 0.04073212f, 0.13435936f, -0.00714237f, 0.06439837f, 
    0.13357709f, 0.12365885f, 0.17263055f, 0.13321996f, -0.24198283f, 0.20286891f, 0.02996388f, 0.08809013f, 
    0.19524619f, 0.10039449f, -0.07404588f, -0.02884413f, -0.00677836f, -0.07906682f, 0.10395669f, 0.10260506f, 
    0.03903222f, 0.06054794f, 0.09752385f, -0.06574633f, 0.04702389f, -0.16239391f, 0.08096916f, 0.00808590f, 
    -0.55974317f, 0.11286288f, -0.19581762f, 0.31738201f, -0.40574247f, 0.31831536f, 0.23736961f, -0.08889483f, 
    -0.04688399f, 0.08601440f, 0.21648480f, 0.07222316f, 0.06623903f, -0.06173899f, 0.07744011f, 0.10927029f, 
    0.17448118f, 0.02320739f, -0.07137769f, 0.06396157f, -0.11261580f, 0.04089583f, -0.08865836f, 0.29804447f, 
    -0.02522173f, -0.06065101f, 0.12226273f, 0.18694583f, 0.02252014f, -0.02654163f, -0.12857577f, -0.10283642f, 
    -0.01354870f, 0.05719303f, -0.00928260f, 0.04242038f, 0.17825778f, 0.02870266f, 0.03391819f, 0.12714101f, 
    -0.34801522f, -0.17402284f, -0.18681973f, -0.12800488f, -0.40644848f, 0.12782428f, 0.19618565f, 0.00179930f, 
    -0.04037941f, 0.02680218f, 0.10303663f, -0.06217640f, -0.07246067f, 0.03946702f, 0.21632819f, -0.04126329f, 
    0.02816072f, -0.06103989f, 0.00835330f, -0.00953639f, -0.22627711f, -0.48312026f, -0.13832738f, 0.04006403f, 
    -0.00883222f, -0.10816823f, -0.04543224f, 0.19541952f, -0.02621491f, -0.02159182f, -0.07163174f, -0.00661791f, 
    0.06182152f, 0.06586429f, -0.14609984f, -0.12065982f, 0.01012426f, 0.02225194f, -0.08055533f, -0.06940685f, 
    -0.09699100f, 0.41708729f, -0.19251113f, 0.10970728f, 0.21340209f, 0.02297655f, -0.10682579f, 0.03964887f, 
    0.12233070f, -0.18321837f, -0.04261929f, 0.01653544f, 0.01602282f, -0.01740578f, 0.11646191f, -0.04282458f, 
    0.03487369f, 0.08547626f, 0.09512055f, -0.00566696f, 0.20387654f, 0.58357298f, 0.12660773f, -0.07912789f, 
    0.48717406f, 0.08497375f, -0.04008171f, 0.14438382f, -0.14064719f, 0.03412746f, 0.04714230f, 0.14159143f, 
    0.05962889f, 0.07126538f, 0.08598362f, -0.04270833f, -0.04704643f, -0.04135736f, 0.05493814f, 0.20094873f, 
    -0.03884105f, -0.32720330f, -0.12549223f, 0.43664539f, 0.19048512f, 0.00582369f, -0.05794585f, 0.11885947f, 
    -0.02705412f, -0.02987099f, -0.04698773f, -0.09329138f, 0.14169016f, 0.11503896f, -0.00197448f, 0.03897882f, 
    0.16883585f, 0.05656629f, -0.03918535f, -0.02474317f, 0.14976338f, -0.07624593f, 0.18077730f, -0.02660665f, 
    0.09021592f, 0.17754315f, 0.13326137f, -0.07732733f, 0.12791321f, 0.01155951f, -0.00294205f, 0.00379494f, 
    0.02331710f, 0.09493832f, -0.12391590f, -0.00478682f, -0.01449684f, 0.01019960f, -0.03228109f, 0.17607054f, 
    0.09779708f, 0.20719184f, -0.02629952f, 0.25730231f, 0.14366522f, -0.11539000f, 0.04072592f, 0.05348980f, 
    -0.08407596f, 0.04690312f, 0.10770287f, -0.09210874f, -0.04237958f, 0.00028214f, -0.06037901f, -0.02966436f, 
    0.23274128f, -0.23270237f, -0.03053716f, 0.05628195f, 0.23496947f, -0.08169717f, 0.08169181f, 0.05294790f, 
    -0.03765045f, -0.00389555f, -0.09552265f, -0.15751183f, -0.01344780f, -0.05398471f, 0.03467852f, -0.00068122f, 
    -0.01957718f, -0.02491596f, 0.00514994f, -0.14224118f, -0.16745546f, -0.03613748f, -0.04393069f, 0.06184927f, 
    0.02056672f, -0.15213412f, -0.39364013f, 0.08076395f, 0.21949504f, 0.07466794f, -0.10361166f, -0.12347844f, 
    0.15213796f, 0.02574493f, -0.02412161f, -0.10523319f, -0.06264334f, 0.30945060f, 0.08228782f, -0.02308206f, 
    -0.04413060f, -0.24924521f, 0.03307820f, -0.03043871f, 0.20847371f, 0.02751312f, 0.07788401f, 0.04492401f, 
    -0.01812296f, 0.03706923f, 0.15077597f, 0.13360265f, -0.00758016f, 0.16033576f, 0.02049149f, 0.02483593f, 
    -0.20448947f, -0.04053682f, 0.02319522f, -0.01259954f, 0.21853340f, 0.07155612f, 0.08298524f, -0.12354921f, 
    -0.16371201f, -0.07157577f, 0.09026801f, -0.03415637f, 0.07061351f, 0.04340332f, 0.08273186f, -0.09393554f, 
    0.08948703f, -0.01884754f, -0.01996079f, -0.02216712f, -0.07588086f, 0.01836404f, -0.14205785f, -0.01860009f, 
    0.03690077f, -0.10701807f, 0.09089664f, 0.09603958f, -0.02626049f, 0.11194151f, -0.09506717f, 0.01674609f, 
    0.11334264f, -0.08043904f, -0.11005229f, -0.02635335f, -0.00245877f, -0.00262052f, -0.09343053f, 0.10825336f, 
    0.11121007f, 0.07737399f, 0.04457394f, -0.01847205f, 0.07162454f, -0.12562928f, -0.24308275f, 0.00731838f, 
    -0.44129762f, 0.26006061f, 0.02657458f, 0.14131474f, 0.02092770f, 0.10513366f, 0.12955473f, 0.09491903f, 
    0.08478637f, 0.22554567f, 0.03532177f, -0.02957861f, 0.11574636f, -0.15244263f, -0.00039028f, -0.11519250f, 
    0.18226098f, -0.16846031f, -0.10449327f, -0.13394478f, 0.11726503f, -0.15885501f, 0.19241568f, -0.12325270f, 
    0.16077228f, -0.03265728f, 0.14783156f, -0.04000365f, 0.05291644f, 0.10880651f, -0.00066389f, 0.15079838f, 
    -0.20367044f, -0.07400169f, -0.00823336f, 0.01867516f, 0.15562774f, 0.10123414f, 0.00090302f, 0.00850590f, 
    0.32859296f, -0.06045851f, -0.00319251f, -0.00970938f, -0.07460079f, -0.07225901f, -0.07783309f, -0.23688279f, 
    -0.19304799f, -0.08917938f, -0.07376004f, 0.04820215f, -0.07440116f, 0.16128446f, 0.08328552f, 0.01673255f, 
    0.05864191f, -0.17311195f, 0.10582275f, 0.01154213f, -0.84564078f, 0.14985284f, -0.07853830f, -0.05105998f, 
    -0.01894004f, 0.03035327f, -0.04281444f, 0.05508251f, 0.03614214f, 0.03022632f, 0.20460960f, 0.08254840f, 
    0.06571160f, -0.01230007f, -0.09899845f, 0.03872676f, 0.12978555f, -0.16813532f, 0.13878749f, -0.11181030f, 
    0.39009488f, 0.03511505f, 0.21299137f, 0.09881326f, 0.36288264f, -0.17428073f, -0.00338227f, -0.13185847f, 
    -0.12872972f, 0.06678294f, 0.08272956f, 0.03923680f, 0.09928205f, 0.07645091f, -0.15611570f, 0.14082526f, 
    -0.03026862f, 0.30113637f, 0.06507099f, -0.03349694f, 0.04380860f, 0.34021270f, -0.08702598f, -0.02606598f, 
    -0.04127019f, -0.10494516f, -0.04953010f, 0.05935501f, -0.22061847f, -0.15957431f, 0.13916342f, -0.04018347f, 
    -0.08691962f, -0.06643978f, 0.00590094f, 0.21554635f, 0.06279577f, 0.18574966f, 0.11324270f, 0.07541604f, 
    0.19023040f, 0.23103121f, 0.07785842f, -0.31082496f, -0.16761822f, -0.19034892f, 0.25983545f, -0.08049680f, 
    -0.04488499f, 0.01856075f, 0.08693295f, 0.04165054f, -0.02109738f, -0.07046167f, -0.08297166f, 0.11281868f, 
    -0.02665044f, -0.15728280f, 0.14668503f, -0.03268377f, -0.18008064f, 0.06614501f, 0.17300272f, -0.00431855f, 
    0.17858642f, 0.04901403f, -0.07941569f, -0.03298962f, 0.05255146f, 0.09200262f, -0.06401684f, 0.03539200f, 
    0.05183282f, 0.25727484f, -0.06897523f, -0.03263929f, 0.03534815f, -0.02282667f, -0.38551632f, -0.13555975f, 
    -0.27229646f, -0.09163082f, 0.22798140f, 0.51911706f, 0.08523871f, 0.06137438f, 0.20251372f, 0.08116114f, 
    -0.06009291f, -0.06110727f, -0.05059952f, -0.18181191f, 0.03727769f, -0.10679055f, -0.01578684f, -0.07498885f, 
    0.00499897f, -0.01238467f, 0.04784736f, 0.03292036f, 0.02901953f, -0.33469498f, -0.08240227f, -0.03013895f, 
    -0.00633970f, 0.00001004f, -0.07086058f, 0.03896585f, 0.02546943f, 0.01596845f, 0.12534833f, 0.08526061f, 
    -0.07353906f, 0.18467304f, -0.03899746f, -0.08926645f, -0.03218513f, -0.16069695f, 0.03449335f, -0.01267290f, 
    0.22610603f, 0.23844957f, -0.01281750f, 0.18676476f, 0.00614476f, -0.12249647f, 0.19599037f, 0.02599364f, 
    -0.05576135f, -0.00999385f, -0.06874053f, -0.27687424f, -0.01444895f, 0.05745635f, 0.06389336f, -0.06109080f, 
    -0.03639033f, -0.14816016f, -0.12663503f, -0.11270372f, 0.42646295f, 0.32339022f, 0.01297089f, 0.26525646f, 
    -0.33141798f, -0.22064862f, 0.07464038f, 0.04858502f, 0.02930495f, 0.12973391f, 0.19446586f, -0.11644621f, 
    0.03554674f, -0.04684117f, 0.02172172f, -0.12251192f, 0.02528235f, 0.03488509f, 0.07163526f, 0.25082195f, 
    -0.01216273f, -0.13009593f, -0.06492657f, 0.05636769f, -0.03140691f, -0.02198920f, 0.09314385f, 0.01250433f, 
    0.05644717f, 0.12155493f, 0.02896078f, -0.07563149f, -0.11727419f, 0.11942427f, 0.03739655f, 0.00598160f, 
    0.10180783f, 0.06029674f, 0.02821249f, 0.11869894f, -0.25332877f, -0.08566406f, -0.21417867f, -0.08644591f, 
    0.19406652f, 0.03860714f, -0.08928126f, 0.01399259f, 0.03134713f, 0.17342497f, -0.12603535f, 0.05520209f, 
    -0.01474112f, 0.05345373f, 0.24342251f, 0.08875363f, 0.09736695f, 0.06186489f, 0.09202418f, 0.00635229f, 
    -0.23619273f, 0.07164078f, 0.04767386f, 0.01909747f, -0.14722799f, 0.19297996f, -0.18340603f, -0.13256153f, 
    0.12940110f, -0.15352105f, -0.05918286f, -0.05040151f, 0.05685849f, 0.08671253f, 0.09974509f, -0.02633473f, 
    0.08578276f, -0.07156596f, 0.21618013f, 0.04052128f, -0.20309353f, 0.10479917f, -0.12282065f, 0.09734689f, 
    0.06162860f, -0.07934299f, 0.11345446f, -0.02951600f, -0.10339841f, 0.08681781f, -0.03698873f, 0.05648133f, 
    0.07786474f, 0.04079042f, 0.17711006f, 0.05596995f, 0.03212659f, 0.01004446f, -0.07618079f, 0.09612063f, 
    -0.32200110f, 0.02037324f, 0.00589793f, -0.05419376f, -0.03974487f, -0.02492256f, 0.15986103f, 0.06472961f, 
    -0.07139730f, 0.05315357f, 0.03080298f, 0.06241689f, 0.11650998f, 0.13382030f, 0.12708722f, -0.00931614f, 
    0.12108733f, 0.08612284f, 0.22270967f, 0.14809287f, -0.26684394f, 0.00551266f, -0.19057003f, -0.08916585f, 
    0.07400715f, 0.02160254f, 0.00491721f, 0.06281353f, 0.03954289f, 0.05845743f, -0.01754938f, 0.15614581f, 
    0.03170109f, 0.10562540f, 0.19097605f, 0.01767872f, -0.03429686f, 0.12116612f, -0.08970018f, 0.01307235f, 
    0.09856046f, 0.31738344f, -0.00533003f, 0.13474150f, -0.19955057f, 0.05675648f, -0.08707395f, -0.09890182f, 
    -0.04043224f, 0.04974579f, -0.05635485f, 0.00468811f, -0.03554276f, 0.11728151f, 0.02363123f, 0.03640617f, 
    0.05840059f, -0.12679233f, -0.10139246f, 0.00558358f, -0.61266947f, -0.07516810f, -0.05030013f, -0.12131603f, 
    0.05340972f, 0.04947515f, 0.02367635f, -0.08007767f, 0.02429636f, -0.06274490f, 0.01136452f, 0.09784976f, 
    -0.17891939f, 0.03971224f, 0.02979356f, 0.04665026f, 0.02653348f, -0.09835331f, 0.13145475f, 0.15975948f, 
    0.22938004f, 0.12254295f, 0.23347998f, 0.23276640f, 0.12825595f, -0.00973842f, 0.17399019f, 0.10036274f, 
    -0.03476038f, -0.12210249f, 0.05028876f, -0.01806521f, -0.03359076f, 0.05944511f, -0.05934022f, 0.09618685f, 
    0.07321315f, 0.17059916f, 0.05333643f, -0.14255653f, -0.31941918f, -0.21589659f, -0.36543787f, -0.12336973f, 
    -0.08438082f, 0.00216878f, -0.13280170f, 0.24877620f, -0.09524044f, 0.03641478f, 0.06043101f, -0.05051527f, 
    0.05346436f, 0.00620552f, 0.00353027f, 0.07326579f, -0.11281961f, 0.17975922f, 0.01420486f, -0.00123707f, 
    -0.12615053f, 0.44980928f, -0.16122189f, -0.14497782f, -0.12244938f, -0.01457236f, 0.06435821f, 0.01481550f, 
    0.06810229f, 0.16239409f, 0.12295752f, 0.01521355f, -0.03058439f, 0.10198645f, 0.16053845f, 0.01730071f, 
    -0.05306514f, 0.14615363f, -0.02811093f, 0.14544486f, -0.13577229f, -0.05864721f, 0.08642884f, 0.10294741f, 
    0.18694344f, 0.01425278f, 0.04066168f, -0.09145942f, -0.09436820f, 0.06933515f, -0.00767582f, 0.08601716f, 
    0.00196844f, 0.08836354f, 0.01764601f, -0.16655813f, -0.05943250f, 0.06705810f, -0.04077314f, 0.05527267f, 
    0.15732306f, 0.03877728f, 0.06724062f, -0.34409487f, 0.01312018f, 0.19545838f, 0.20072988f, -0.09786671f, 
    0.08003958f, 0.08896536f, -0.08703129f, 0.05264395f, 0.01124105f, -0.05751214f, 0.05864377f, -0.00324061f, 
    -0.08347160f, 0.14081015f, 0.05870782f, 0.03573412f, -0.16722482f, -0.09377604f, -0.07547145f, 0.13704945f, 
    -0.19722600f, -0.14849089f, -0.12176942f, -0.02515862f, 0.06044465f, -0.06927700f, 0.06665748f, 0.03486780f, 
    0.02317809f, 0.12631689f, 0.07095359f, 0.08697478f, 0.12436197f, -0.03406991f, -0.01245398f, 0.02780245f, 
    0.30810353f, 0.17077662f, -0.02762384f, -0.34210297f, -0.32420790f, -0.02535665f, 0.09568492f, 0.08459111f, 
    0.04873986f, -0.06681665f, -0.09230061f, 0.09317408f, 0.05864076f, -0.00904704f, 0.11070188f, -0.03900814f, 
    0.12347734f, 0.04487735f, 0.19560719f, -0.04998789f, -0.37069416f, 0.16860664f, 0.01598871f, 0.09170261f, 
    0.07954492f, 0.05181650f, 0.06821588f, 0.14415658f, 0.01757134f, 0.08762186f, 0.10832761f, 0.04128763f, 
    -0.05536420f, 0.13856615f, 0.11069980f, 0.10848933f, 0.02567557f, -0.00984030f, 0.21612702f, 0.11351455f, 
    -0.08849268f, 0.10819910f, 0.30452290f, -0.11131839f, -0.06867628f, 0.02120035f, 0.16370903f, 0.02085605f, 
    0.09558892f, 0.11497342f, -0.05101973f, 0.12266509f, 0.09396835f, -0.02851873f, 0.08557776f, -0.03291268f, 
    0.05136414f, 0.17877042f, 0.05619248f, -0.00815960f, -0.21079165f, -0.01081160f, -0.21249388f, 0.09141569f, 
    -0.17509490f, 0.02773770f, -0.08325465f, 0.04897333f, 0.02402054f, 0.08331396f, 0.06812288f, -0.03251827f, 
    0.05505316f, 0.06605136f, 0.02821038f, 0.04954143f, -0.14137816f, -0.05827770f, 0.04315246f, 0.08033016f, 
    0.00706732f, -0.19360329f, 0.00583987f, 0.09144261f, -0.25604457f, 0.04385452f, -0.11441452f, -0.03239950f, 
    -0.05629888f, -0.02556500f, 0.12504205f, 0.09184242f, -0.05486497f, 0.00169000f, 0.16850807f, -0.00994684f, 
    -0.07247330f, -0.06122622f, 0.12233060f, 0.03951175f, -0.19140652f, 0.00083348f, 0.13828634f, -0.00894973f, 
    -0.12624051f, -0.01251057f, 0.15055947f, -0.01690542f, 0.04045497f, -0.03290518f, 0.16438085f, 0.05462298f, 
    -0.01634055f, -0.01235790f, 0.00543165f, 0.11153249f, 0.15663177f, 0.09681972f, -0.11058863f, 0.14316058f, 
    0.20217338f, -0.33828229f, -0.06348234f, 0.13925420f, -0.10969478f, -0.10348587f, -0.14253762f, 0.00020575f, 
    -0.20056364f, -0.02153374f, -0.03533686f, 0.23413111f, -0.08801299f, 0.11718914f, -0.04308958f, 0.07750133f, 
    -0.02292065f, 0.10076983f, 0.06981027f, 0.25666466f, -0.35742244f, 0.44956493f, -0.32249549f, 0.01458477f, 
    -0.30633849f, -0.11029375f, -0.15635568f, -0.02300100f, 0.05841527f, -0.03658359f, 0.04987941f, -0.02271219f, 
    0.03434914f, 0.13700593f, 0.09343344f, 0.06405915f, -0.04465304f, -0.05951421f, -0.01414368f, 0.14427353f, 
    -0.32709000f, 0.49892211f, 0.05866389f, 0.24275994f, 0.37249225f, 0.19021519f, 0.02235361f, 0.22231248f, 
    0.10005666f, 0.01692091f, 0.06291363f, 0.07930385f, 0.22701414f, -0.04274711f, 0.10761075f, 0.13968524f, 
    0.00858234f, 0.10337593f, 0.05676910f, 0.10519353f, 0.87739259f, 0.05211091f, 0.02646470f, 0.12714048f, 
    -0.00391771f, -0.02857559f, -0.07658918f, -0.01543842f, -0.02664466f, 0.12536997f, 0.06061107f, -0.00885857f, 
    0.00593744f, 0.12356971f, 0.06421468f, -0.00633061f, -0.06082832f, -0.05631687f, 0.04396617f, 0.09831735f, 
    0.03176539f, -0.00995575f, -0.08991224f, 0.06902692f, 0.08787255f, 0.18252464f, 0.11470152f, -0.02655705f, 
    -0.03436816f, -0.15339237f, 0.01760597f, 0.10534347f, -0.03835683f, -0.05955971f, 0.03255607f, -0.01456346f, 
    0.04147713f, -0.07003371f, -0.11741347f, 0.00844878f, 0.13401407f, 0.02032912f, 0.17388900f, -0.07532705f, 
    0.05575658f, -0.00217226f, -0.04022967f, -0.02042174f, 0.24112780f, 0.15244719f, 0.03427272f, 0.03246498f, 
    -0.08856503f, -0.10182907f, 0.09958591f, -0.02506332f, 0.00390328f, -0.09826849f, -0.00592227f, 0.13300049f, 
    -0.18516715f, 0.23104952f, 0.24435298f, 0.33140349f, -0.03468494f, 0.29261655f, -0.14888579f, 0.01784179f, 
    0.09529088f, 0.05828387f, 0.04244284f, 0.02492902f, 0.16429919f, 0.11320250f, 0.19092011f, 0.00680822f, 
    0.14742625f, 0.22809745f, -0.02663870f, -0.13918880f, -0.06158060f, -0.20082931f, -0.16191593f, -0.00181450f, 
    -0.14883795f, -0.04763048f, -0.00319894f, -0.01106512f, -0.05431423f, -0.12809023f, 0.05100058f, 0.07614912f, 
    0.09266674f, -0.10860290f, 0.08844021f, 0.19077803f, 0.10562282f, 0.10285261f, 0.11974858f, 0.14357963f, 
    0.01279656f, 0.04932279f, -0.02908283f, 0.04891149f, -0.03012670f, 0.03266073f, 0.01052271f, 0.03928380f, 
    -0.04154148f, 0.00709580f, 0.00821541f, -0.04276649f, -0.03252633f, 0.03333578f, -0.02049760f, -0.03929421f, 
    0.02991915f, -0.00600212f, -0.03327177f, -0.05530547f, 0.01053863f, -0.01264666f, 0.02948781f, -0.00679059f, 
    -0.05655894f, -0.05686827f, 0.00445445f, -0.03586449f, 0.04697695f, -0.05527778f, -0.05334058f, 0.04252660f, 
    0.03383979f, 0.01671059f, -0.05011336f, 0.03843922f, -0.00115221f, 0.04101498f, 0.04170061f, -0.02508717f, 
    -0.02903990f, 0.03701761f, -0.01403156f, 0.04000323f, -0.05318148f, -0.05277853f, 0.04983932f, -0.04996957f, 
    0.02040664f, -0.02122186f, 0.01993057f, -0.05114724f, 0.00204146f, -0.00424418f, 0.04783180f, 0.00957701f, 
    0.01646985f, -0.04244432f, -0.02043768f, -0.05130657f, 0.04969897f, 0.02688719f, 0.00375708f, -0.05178021f, 
    -0.00356466f, -0.01895553f, 0.02607441f, -0.04388346f, -0.01805477f, 0.02522565f, 0.04780075f, 0.04978640f, 
    0.04940547f, 0.03760578f, 0.02639076f, 0.00836245f, -0.05088201f, -0.03078016f, -0.04136338f, -0.05218324f, 
    0.01865303f, 0.01096420f, -0.04434577f, -0.01496356f, 0.01489946f, 0.03269067f, 0.00750164f, -0.04467860f, 
    -0.05672997f, -0.01687032f, 0.03635188f, -0.02654038f, -0.04212050f, 0.00778652f, -0.03623783f, -0.04681895f, 
    -0.04502995f, 0.03659574f, 0.02884147f, -0.01809356f, 0.02557259f, -0.05947441f, 0.04113736f, 0.01985969f, 
    -0.02487913f, 0.02019829f, -0.02799058f, -0.05318035f, 0.00452917f, -0.03442576f, -0.05078368f, 0.00079793f, 
    0.01064411f, -0.02607378f, -0.06093153f, -0.05620722f, -0.01038489f, 0.04022278f, 0.01568453f, 0.01966012f, 
    -0.00931357f, -0.03599781f, 0.01565526f, -0.00804120f, 0.01657937f, -0.02284866f, -0.04113927f, -0.00420925f, 
    0.01910231f, 0.01539696f, -0.04711158f, -0.05413312f, 0.02382735f, -0.01599993f, -0.02948517f, -0.01378926f, 
    -0.00972604f, -0.01577130f, 0.00720994f, 0.01428925f, 0.01846653f, -0.00071277f, -0.03414948f, -0.01921046f, 
    -0.04838810f, -0.01971076f, 0.04704503f, 0.02503440f, -0.03314282f, 0.05153916f, 0.03310557f, -0.02529692f, 
    0.00302456f, 0.02902398f, 0.00374581f, -0.02680655f, 0.02987252f, -0.04217558f, -0.01352641f, 0.03659998f, 
    -0.04669555f, -0.05744331f, -0.01127605f, -0.05211709f, 0.01929925f, 0.00183970f, 0.00516324f, -0.05597273f, 
    -0.04631571f, -0.04403479f, 0.03457679f, -0.03866870f, -0.04579663f, -0.00868058f, -0.00509367f, 0.00156650f, 
    -0.01424588f, 0.01611580f, 0.02522472f, 0.03360943f, -0.00343906f, 0.04434879f, -0.05242413f, -0.03668435f, 
    0.00073514f, -0.06016561f, -0.01289234f, 0.01634479f, -0.03987289f, 0.04047988f, -0.01854574f, -0.00246261f, 
    -0.04234656f, -0.02823083f, -0.00814608f, -0.02550436f, -0.02635348f, 0.00067140f, -0.04334486f, -0.04306025f, 
    0.03518064f, -0.04654347f, -0.05812263f, -0.04711801f, -0.00970978f, -0.02868177f, -0.04639328f, -0.03954399f, 
    0.01012234f, 0.05052258f, -0.02036170f, -0.05184866f, 0.04597844f, -0.01504707f, -0.00420346f, -0.00367697f, 
    0.00481590f, -0.03332686f, -0.02262023f, 0.00999959f, -0.02767469f, -0.05109612f, 0.04610278f, 0.02410813f, 
    0.02128301f, 0.01629320f, -0.01430900f, -0.02544975f, 0.01450921f, 0.04645341f, 0.03685271f, 0.03679075f, 
    0.01363888f, -0.03749190f, -0.04520715f, 0.04423187f, 0.04390860f, 0.00315118f, -0.03957563f, -0.02605677f, 
    -0.04136927f, -0.02308589f, -0.00829225f, 0.00155615f, 0.04720970f, -0.03061448f, -0.00932227f, -0.00225157f, 
    -0.04607748f, 0.02887441f, 0.01401938f, -0.02278596f, -0.04048627f, -0.03062956f, -0.02969935f, -0.01157280f, 
    -0.02756608f, -0.02788283f, -0.02064635f, 0.04473508f, 0.01944837f, 0.01240438f, -0.05607351f, -0.02691764f, 
    -0.04301378f, -0.00059352f, -0.02893719f, 0.02492053f, -0.02996516f, -0.01835889f, 0.01418008f, -0.00594135f, 
    -0.04582841f, -0.01630267f, -0.05584479f, 0.01894386f, -0.01798676f, -0.00273756f, 0.03638951f, -0.00632245f, 
    0.02583642f, -0.02880168f, 0.01554771f, -0.04295238f, 0.01036167f, 0.00034759f, -0.00202507f, 0.04933200f, 
    0.00079363f, 0.04162698f, 0.02751835f, 0.00422816f, -0.05576065f, 0.00909814f, 0.04551663f, -0.01679377f, 
    0.00767590f, -0.02807795f, -0.05577608f, -0.01376557f, -0.05494773f, 0.00682290f, -0.02280627f, 0.01055667f, 
    -0.05165721f, -0.01197468f, -0.04542831f, 0.00726441f, -0.04231661f, 0.02090291f, -0.01338287f, -0.04374802f, 
    -0.05675514f, -0.00388937f, -0.00267866f, -0.05770611f, 0.00524240f, 0.00616284f, 0.01618152f, -0.02374804f, 
    -0.37946865f, -0.05843048f, -0.07146971f, 0.11141354f, 0.16250630f, 0.02803767f, -0.01643618f, 0.09429132f, 
    0.10127691f, -0.06508560f, 0.01003442f, 0.09814029f, -0.12177078f, 0.04978108f, -0.12998939f, 0.05933394f, 
    0.05578076f, -0.01532053f, -0.02227559f, -0.01082582f, 0.53661865f, 0.09294032f, 0.14736034f, 0.00959768f, 
    -0.05056568f, 0.03526259f, 0.00463403f, 0.00136929f, -0.02099893f, 0.06657138f, -0.05563422f, 0.03648923f, 
    -0.06055207f, 0.02108792f, 0.03929471f, -0.03402234f, 0.00349694f, 0.06104866f, 0.12788832f, 0.01106262f, 
    -0.14604741f, -0.02984344f, -0.04928933f, -0.29142010f, -0.08178739f, -0.00595120f, 0.01930715f, -0.10136781f, 
    -0.09758990f, -0.12502491f, -0.06617981f, 0.13454661f, 0.01264561f, -0.04449015f, -0.14654376f, 0.03507748f, 
    -0.01074619f, 0.04662312f, 0.00219240f, 0.16527143f, 0.01423577f, -0.14354588f, 0.17189153f, -0.05687883f, 
    0.04754965f, 0.18026212f, 0.13130558f, -0.08919957f, -0.03600619f, 0.01820181f, -0.01747562f, -0.05908422f, 
    0.05034265f, -0.01864055f, 0.16121684f, 0.03206056f, -0.01443106f, 0.06317344f, -0.04298003f, -0.15172686f, 
    -0.25185668f, -0.08959684f, -0.34392056f, -0.32744235f, 0.09019157f, 0.20419748f, 0.07649836f, 0.10678446f, 
    0.06096600f, 0.12710850f, 0.14174725f, 0.09168389f, 0.15527287f, -0.05545302f, -0.11629217f, -0.01141988f, 
    0.03067258f, -0.00637139f, -0.04211775f, 0.01883225f, 0.53681916f, -0.42525733f, 0.28371850f, -0.01650921f, 
    -0.14460711f, -0.07849981f, -0.09463563f, 0.06374996f, 0.02777315f, 0.16552992f, -0.01276024f, 0.12495585f, 
    0.09402550f, 0.06364658f, 0.10201768f, -0.00149459f, -0.01013724f, -0.05501980f, 0.05627400f, 0.11110781f, 
    0.72482479f, -0.03256391f, 0.04712438f, 0.01535463f, 0.07016896f, -0.02045682f, -0.02145297f, -0.01840453f, 
    -0.15785135f, 0.14318554f, 0.03334909f, 0.04482557f, -0.00992713f, 0.12576029f, 0.02761911f, 0.02454287f, 
    0.04106243f, -0.03362941f, -0.10152736f, 0.08129317f, 0.30444700f, -0.01563749f, -0.15538804f, -0.07302918f, 
    -0.10497747f, 0.09035283f, 0.10162003f, 0.07449749f, 0.03063102f, 0.02020601f, -0.04748193f, 0.07714327f, 
    -0.11336471f, -0.09756301f, -0.00556414f, -0.13318691f, -0.04332446f, -0.03118596f, 0.15274812f, -0.05817331f, 
    0.15252747f, 0.15485270f, -0.17683533f, 0.02858957f, 0.25895816f, 0.27598029f, -0.09028609f, 0.11217736f, 
    0.04041046f, 0.00756951f, -0.06461651f, 0.04557970f, -0.08546424f, 0.02926468f, 0.15454388f, 0.11088184f, 
    0.01959387f, 0.03884206f, 0.07178861f, -0.04384901f, 0.46118319f, -0.35923520f, 0.28662708f, -0.09810360f, 
    -0.16347931f, -0.01884942f, 0.10004479f, 0.10544021f, 0.13054787f, 0.04788535f, 0.09531456f, -0.15641807f, 
    0.09829482f, 0.07079887f, 0.03066426f, 0.05806042f, -0.15618640f, 0.08041447f, -0.01152371f, 0.18596628f, 
    0.23211795f, -0.06018141f, -0.03964231f, -0.12931089f, -0.30393896f, -0.31983849f, -0.01734530f, -0.04431855f, 
    0.03972835f, -0.11867929f, -0.01464404f, -0.05081792f, 0.03238036f, 0.03323633f, -0.01811104f, 0.08173428f, 
    0.02114364f, 0.07119872f, -0.02270162f, 0.01983774f, 0.14754251f, 0.06266826f, -0.12042632f, 0.22589478f, 
    0.18938108f, 0.05084625f, -0.09346629f, -0.08701620f, 0.05730186f, -0.02388202f, -0.04802330f, 0.04224750f, 
    -0.02928676f, 0.01941556f, -0.14497335f, 0.05793914f, 0.00174571f, 0.04132407f, 0.08964773f, -0.08647013f, 
    -0.33724248f, -0.03237761f, -0.12610061f, 0.21151975f, 0.11949240f, -0.03687361f, -0.05811217f, 0.12714504f, 
    0.11781456f, -0.15551320f, -0.08051390f, -0.03250114f, -0.08022072f, -0.11122997f, -0.05977151f, -0.01403788f, 
    0.00861102f, -0.01584730f, 0.03745355f, -0.04283276f, 0.29771629f, -0.17461872f, -0.04752068f, 0.13851972f, 
    -0.11257263f, -0.13857467f, -0.07332142f, -0.08177679f, 0.10104785f, 0.09325482f, -0.08446671f, 0.08333188f, 
    0.07887013f, 0.08623231f, 0.13798438f, -0.03590392f, -0.05772923f, -0.03977466f, 0.00703803f, 0.14405876f, 
    0.00224375f, -0.07023500f, 0.18386881f, -0.13884363f, -0.02310133f, -0.01647064f, 0.14057541f, -0.01848620f, 
    -0.03134550f, 0.03050241f, -0.16531302f, 0.06452572f, -0.00100586f, -0.01817519f, 0.01546617f, 0.03490371f, 
    -0.01038142f, -0.14781812f, -0.05950635f, 0.22364192f, 0.18781209f, 0.16620472f, 0.11833605f, -0.12796836f, 
    -0.39927909f, -0.04637300f, 0.08456770f, 0.08307210f, -0.12534496f, 0.03475565f, -0.04523179f, -0.02380625f, 
    -0.04679380f, -0.09741540f, -0.11484639f, -0.03231775f, 0.05155173f, -0.05203397f, 0.28507602f, -0.02915858f, 
    -0.71937710f, -0.31908527f, 0.34347314f, 0.31037527f, 0.16550955f, 0.16362080f, 0.05239151f, -0.04833100f, 
    0.02287783f, 0.15939637f, 0.00641578f, 0.04790007f, -0.04649292f, 0.03032301f, -0.01443501f, -0.04741399f, 
    0.14415199f, 0.02694985f, 0.06395110f, -0.02052192f, 0.51630366f, -0.00427993f, 0.10736863f, 0.28751236f, 
    0.23796184f, 0.15541284f, 0.08685796f, -0.00127142f, 0.04695823f, -0.00431893f, 0.01310203f, -0.03617805f, 
    0.03683341f, 0.02561891f, 0.01898057f, 0.08772095f, -0.15692474f, -0.01979960f, 0.05295310f, 0.06170973f, 
    -0.01407168f, -0.02980795f, 0.26925123f, -0.29657736f, -0.43758598f, -0.00851179f, 0.20292562f, -0.14252546f, 
    -0.22245494f, -0.02123008f, -0.00242625f, -0.01185918f, 0.05536144f, 0.00193133f, -0.11470427f, -0.06692855f, 
    0.21472470f, -0.06608664f, -0.07047504f, 0.15814303f, -0.13363345f, -0.19398475f, 0.16331835f, -0.01676274f, 
    -0.35093239f, -0.24422146f, 0.08301609f, -0.03580680f, -0.06461207f, -0.05907522f, 0.09262434f, -0.03080117f, 
    0.13075477f, 0.06640887f, 0.02715333f, -0.19068293f, -0.03370329f, 0.02355325f, 0.19724785f, 0.09959868f, 
    -0.34768561f, -0.17856951f, 0.15319015f, -0.00564710f, -0.17000225f, -0.10328334f, -0.15545502f, -0.00788451f, 
    -0.12293949f, 0.13516389f, 0.00878972f, -0.05797187f, 0.01802556f, -0.05436035f, 0.07401556f, 0.04309605f, 
    -0.07784114f, -0.00423882f, -0.06842086f, 0.01446849f, -0.31896400f, -0.07061056f, 0.08704913f, 0.18373486f, 
    0.09052093f, 0.00018944f, -0.11539527f, -0.03828518f, 0.21132772f, 0.27752230f, 0.02277361f, 0.01630934f, 
    0.00029949f, 0.07017928f, 0.01059572f, -0.02438339f, 0.02161713f, 0.12877016f, 0.00702703f, -0.00255877f, 
    -0.41480556f, -0.05319719f, 0.10926683f, -0.07183298f, -0.04541764f, 0.08090001f, 0.02437408f, -0.02773630f, 
    0.01382844f, 0.10626134f, -0.03018432f, 0.01958927f, 0.00175293f, 0.10487490f, 0.06176119f, 0.03718635f, 
    0.08997588f, 0.05222638f, 0.00768558f, 0.08225624f, -0.06477707f, -0.05113313f, 0.16645631f, 0.14394166f, 
    -0.32917237f, 0.01713993f, 0.21494745f, 0.02000537f, 0.00994549f, -0.16309980f, 0.13127492f, 0.06924194f, 
    -0.11737481f, -0.05548453f, 0.11808651f, 0.15520807f, -0.02834459f, -0.13738716f, -0.09429993f, 0.07093102f, 
    -0.14616664f, -0.19104616f, -0.03186317f, -0.14509375f, -0.27311808f, 0.23867674f, 0.19134012f, 0.01867198f, 
    -0.06265812f, 0.05805300f, 0.06664778f, 0.05261514f, 0.05880736f, 0.01843178f, -0.01481047f, -0.02528638f, 
    0.03108991f, 0.04171286f, 0.09911487f, 0.00061738f, -0.07786513f, 0.26471454f, -0.01154674f, 0.03060311f, 
    -0.05509032f, 0.05227816f, -0.10633806f, 0.00036792f, 0.12717301f, 0.21113874f, -0.01540473f, -0.00016623f, 
    -0.03920344f, 0.11563728f, 0.06283697f, -0.04414758f, -0.01446988f, 0.15411925f, -0.00939221f, 0.14890470f, 
    0.30528480f, 0.11270260f, 0.23617364f, -0.21788421f, -0.05306350f, -0.10949337f, 0.02441275f, -0.09434091f, 
    -0.01096835f, 0.01482673f, -0.01465050f, 0.01955681f, 0.00471337f, 0.12120914f, 0.00972946f, 0.28163511f, 
    0.03331243f, -0.03075853f, 0.02067546f, 0.07985761f, -0.23597337f, 0.04045985f, -0.26374078f, 0.01676896f, 
    0.09932582f, 0.04077417f, -0.13276801f, -0.04059760f, -0.10097115f, 0.07738692f, 0.10488994f, 0.16073819f, 
    -0.06666318f, -0.10815569f, 0.10191111f, -0.00340019f, 0.07683668f, 0.01248925f, 0.19069071f, 0.00361381f, 
    0.23986129f, 0.01936285f, 0.13323629f, 0.23773921f, 0.41908449f, 0.06630258f, 0.19085045f, -0.09340152f, 
    0.10024980f, -0.01652052f, 0.04874220f, 0.06813107f, 0.09543915f, -0.03070035f, 0.00882811f, -0.02497492f, 
    0.02173453f, 0.15404525f, 0.08092768f, -0.02238145f, 0.19968092f, -0.02784443f, -0.26973957f, 0.21378228f, 
    0.45705026f, -0.10021400f, -0.04154144f, 0.01455817f, -0.02436581f, -0.05745616f, 0.04680132f, -0.04705676f, 
    0.08813000f, 0.13619941f, 0.23991330f, -0.04184414f, 0.03764415f, 0.11373711f, 0.13751057f, -0.01684597f, 
    -0.23620729f, 0.35280785f, -0.01099277f, 0.14109465f, -0.35098729f, -0.02269269f, 0.02528745f, 0.09063480f, 
    -0.08389004f, -0.07145316f, 0.01561604f, -0.09772032f, -0.12283263f, 0.08914647f, 0.13703829f, 0.09578268f, 
    -0.07143441f, 0.04730927f, 0.00273102f, 0.09821371f, -0.09230341f, -0.23881833f, 0.15315820f, -0.02042872f, 
    -0.32488456f, 0.06742962f, -0.04719450f, -0.02949052f, 0.06880347f, -0.05394374f, 0.13539883f, 0.09817314f, 
    -0.06912825f, -0.06092793f, -0.17775334f, 0.02105869f, 0.04700463f, -0.04826697f, -0.10454957f, 0.07595107f, 
    0.94286716f, 0.23603170f, -0.11118063f, -0.01867595f, 0.16857341f, 0.13623564f, 0.18141384f, 0.14222847f, 
    0.03834428f, -0.16226541f, 0.00187282f, -0.04634830f, 0.11791213f, 0.15620707f, 0.07522472f, 0.04586728f, 
    0.05445566f, 0.08108441f, 0.06574661f, -0.06611127f, 0.13694750f, 0.03729354f, 0.10195289f, -0.01895178f, 
    0.10801309f, 0.01550181f, 0.20280269f, 0.01414913f, 0.03422072f, -0.01885926f, -0.00255273f, -0.06917676f, 
    0.13769488f, -0.00364585f, -0.09475098f, 0.14623702f, 0.01387075f, 0.17289399f, -0.03383132f, 0.12636206f, 
    0.22500849f, 0.22428054f, -0.04704043f, -0.02199371f, 0.33579054f, 0.09330627f, -0.06964245f, 0.03153871f, 
    -0.00929243f, 0.06719437f, 0.04466115f, 0.10949616f, 0.10261012f, 0.10799575f, 0.14909764f, 0.15530416f, 
    0.11560427f, 0.00348406f, 0.06244668f, 0.05173917f, -0.24886335f, 0.25830707f, -0.13159822f, -0.18652052f, 
    0.03214578f, 0.17300436f, 0.01047659f, 0.09662177f, 0.00676184f, 0.11483262f, -0.01788842f, 0.05450750f, 
    0.00644088f, 0.09609738f, 0.02351564f, 0.08969197f, 0.06019551f, 0.05304019f, -0.10291822f, -0.13168874f, 
    0.16242406f, 0.30065832f, -0.44365439f, -0.18412983f, -0.17329617f, 0.08676755f, -0.11237161f, 0.01270327f, 
    0.03795807f, -0.26131055f, 0.03536275f, 0.12831497f, 0.03491675f, 0.21402435f, -0.00167065f, 0.07498780f, 
    -0.04345277f, -0.17157567f, 0.00775111f, -0.00716195f, 0.25753725f, 0.18593863f, 0.12676890f, 0.01414898f, 
    0.07909014f, 0.18773912f, 0.18928944f, 0.01951678f, -0.09320366f, -0.19562529f, 0.12100997f, 0.03883728f, 
    -0.15747210f, 0.00611201f, -0.09076865f, 0.05487730f, -0.05962773f, -0.05983704f, -0.11138618f, 0.01311822f, 
    0.34405851f, -0.13812168f, 0.03235955f, -0.03831209f, 0.12998480f, -0.01600962f, 0.19842950f, 0.16074234f, 
    -0.02814313f, 0.16627540f, 0.15111797f, 0.04813185f, 0.05773864f, -0.00019314f, -0.19477460f, 0.01737817f, 
    -0.14287485f, 0.01731376f, -0.00448759f, -0.03270151f, -0.17905633f, -0.06868723f, -0.19181477f, -0.43521428f, 
    0.24261966f, 0.07062700f, -0.16367364f, 0.01863535f, 0.06324378f, -0.00220089f, -0.01082874f, 0.09402504f, 
    0.17549543f, 0.15406628f, -0.04590130f, -0.12271462f, 0.07234214f, 0.00463154f, -0.02344912f, -0.00114597f, 
    -0.27299014f, -0.13960527f, 0.13471441f, 0.02888331f, 0.14321719f, 0.00081128f, -0.10316204f, -0.01609945f, 
    -0.04081921f, 0.13408230f, 0.05820980f, 0.05317136f, 0.13440360f, 0.03784372f, 0.00248855f, -0.03708792f, 
    0.17835909f, -0.17873889f, -0.19519804f, 0.04946654f, 0.04565163f, 0.10218664f, 0.21485028f, 0.04835531f, 
    0.12863982f, 0.05314298f, 0.13889775f, 0.03109909f, 0.00258186f, -0.06417767f, 0.23603298f, 0.06496080f, 
    -0.07820558f, 0.07593849f, 0.01205294f, 0.07187363f, 0.08997163f, 0.02788485f, 0.14740042f, -0.08883455f, 
    0.37569630f, 0.21831647f, 0.13861948f, 0.10104019f, -0.04627697f, 0.22392809f, 0.03449804f, 0.13968617f, 
    -0.24467173f, -0.05922805f, 0.01562671f, 0.08157992f, 0.01515158f, 0.01956166f, 0.04545615f, -0.01843903f, 
    0.01491431f, -0.03198095f, 0.19897988f, -0.05575046f, 0.01746323f, -0.29886571f, 0.17625117f, -0.03359963f, 
    -0.06443421f, 0.09417378f, 0.11131010f, -0.05900992f, 0.04364283f, 0.20332517f, 0.03615607f, -0.04144342f, 
    0.25559679f, -0.00819002f, 0.04307350f, 0.01081344f, -0.02892028f, -0.11240470f, -0.02557024f, -0.08869708f, 
    0.28163007f, 0.47484133f, 0.07865658f, -0.04979891f, -0.10946454f, 0.16731244f, 0.03940203f, 0.01610193f, 
    0.05458201f, 0.06501170f, 0.06870656f, 0.00349332f, -0.08001824f, 0.02512535f, -0.02233982f, -0.10701235f, 
    -0.05208639f, 0.24097434f, -0.01175978f, -0.05375618f, 0.18613730f, 0.28405011f, 0.26305464f, 0.14197953f, 
    0.14362144f, 0.11397230f, 0.22828366f, -0.17395605f, 0.04085517f, 0.24269888f, 0.02730063f, -0.02441993f, 
    -0.00230301f, -0.11485993f, -0.02216217f, 0.08385393f, -0.06877426f, 0.00267953f, -0.02540490f, 0.03946445f, 
    0.05757829f, -0.33337536f, 0.18779558f, -0.29036495f, 0.13411395f, -0.05085362f, -0.15355749f, -0.17649700f, 
    0.06906841f, 0.13446657f, 0.09512354f, -0.04559820f, 0.13134883f, -0.03727955f, -0.05280133f, -0.06621766f, 
    0.14448377f, -0.03346420f, 0.17796881f, -0.17504996f, -0.18933558f, 0.04131991f, -0.13360947f, -0.33239463f, 
    0.20507103f, 0.12379178f, 0.00915944f, 0.07078762f, 0.03106762f, -0.00215597f, -0.01407803f, -0.00852829f, 
    0.09658753f, 0.31564224f, 0.19713444f, 0.11241937f, -0.06212607f, 0.00158478f, -0.21450315f, 0.05480361f, 
    -0.32955152f, -0.15880944f, -0.16908284f, 0.13208917f, 0.24678144f, 0.23121753f, 0.22868744f, 0.04533260f, 
    -0.07147881f, -0.16932020f, -0.00739129f, 0.08678932f, 0.06679088f, 0.03305999f, -0.01375127f, 0.04201470f, 
    0.08481339f, 0.08282170f, -0.03781734f, -0.07528631f, 0.33430612f, -0.11169095f, 0.25383213f, 0.06728870f, 
    0.06803868f, -0.03261796f, 0.07648077f, 0.02517910f, -0.19783863f, 0.05492635f, -0.05464287f, 0.12126259f, 
    0.02630339f, 0.07911944f, -0.05734779f, 0.02383983f, -0.02163960f, 0.00863496f, 0.06986918f, 0.09725966f, 
    -0.34777579f, 0.27833441f, -0.01408414f, -0.07081021f, 0.31537092f, -0.00063602f, 0.09737942f, -0.05511400f, 
    -0.08616684f, -0.06621013f, 0.21574759f, -0.09956224f, 0.03711601f, -0.02454663f, 0.04523503f, 0.03098376f, 
    0.17545554f, 0.03692570f, -0.01474909f, 0.02893437f, -0.37678269f, 0.11357982f, -0.10010071f, -0.28092664f, 
    -0.23887382f, 0.01019588f, 0.04306720f, 0.04210950f, -0.07436999f, 0.10777444f, 0.24952295f, 0.04595575f, 
    0.06834586f, 0.05224567f, 0.04617625f, 0.12691319f, -0.02574040f, 0.06073231f, -0.09005862f, 0.04932908f, 
    -0.14312951f, 0.03453748f, -0.46879086f, -0.10860025f, -0.10984280f, 0.20165350f, -0.04643819f, 0.04649965f, 
    -0.03144468f, -0.13120739f, 0.02772094f, 0.04246234f, -0.04907928f, 0.03800050f, -0.09988160f, 0.11915588f, 
    -0.02412947f, -0.05891725f, -0.11304777f, 0.13173287f, 0.28239056f, -0.03733850f, 0.33576536f, 0.18941239f, 
    0.48022643f, -0.05650444f, -0.02267060f, 0.11421396f, 0.00750321f, -0.06152968f, -0.02007440f, 0.01534813f, 
    -0.16698883f, 0.02144630f, 0.03393671f, -0.06823117f, 0.02853763f, 0.02329183f, -0.04567778f, -0.04923300f, 
    0.54313707f, 0.15915024f, 0.13747887f, -0.16779776f, 0.23244902f, -0.03163748f, 0.12148707f, 0.02319010f, 
    0.03619824f, 0.08756056f, 0.05227328f, -0.05975306f, 0.02540448f, 0.12398954f, -0.10015098f, 0.15977733f, 
    0.08428083f, -0.06657370f, 0.12057941f, 0.13737588f, 0.05560035f, 0.40672889f, 0.01803905f, -0.32376665f, 
    -0.06645922f, 0.01032746f, 0.09185710f, -0.08258257f, -0.00847181f, 0.03271298f, 0.00553412f, 0.04981067f, 
    0.10297712f, -0.04605975f, -0.13474597f, -0.02056374f, 0.01030235f, 0.04597930f, -0.13903449f, 0.01216973f, 
    -0.44436106f, 0.05011504f, 0.02212314f, -0.07368355f, -0.08096770f, 0.06598675f, 0.01350114f, 0.09247613f, 
    0.03560024f, 0.05604362f, -0.04199079f, -0.07894532f, 0.12223623f, -0.00639308f, 0.06698713f, 0.03907480f, 
    0.07502002f, -0.10198445f, 0.00400757f, -0.02547400f, 0.18801945f, 0.14605583f, 0.28035104f, 0.13720213f, 
    0.21838437f, 0.04218012f, -0.00162441f, 0.17379032f, 0.23192677f, -0.01338407f, 0.12895651f, -0.01541628f, 
    -0.20136553f, 0.06278659f, 0.00881045f, -0.01371931f, -0.03722206f, 0.07694548f, 0.20636408f, 0.00798153f, 
    0.44784299f, -0.10826937f, -0.07190090f, -0.17081168f, -0.23340254f, 0.13074820f, -0.16734424f, 0.00299498f, 
    -0.18612152f, 0.01029042f, 0.07494114f, -0.00475182f, 0.00710387f, -0.00350865f, 0.04461552f, -0.00225798f, 
    -0.04075866f, 0.02124281f, 0.16870356f, -0.02412735f, -0.11289912f, 0.04280977f, 0.04237019f, 0.00549369f, 
    -0.01818792f, 0.00175182f, -0.00463688f, -0.02777128f, 0.19234695f, 0.02820057f, -0.08054329f, -0.04508220f, 
    0.04213681f, 0.02072348f, 0.00336131f, 0.07770519f, 0.06374948f, -0.11723414f, 0.13565481f, 0.02879470f, 
    -0.19006130f, 0.05730342f, -0.08323878f, -0.07434843f, -0.06267454f, 0.13898802f, 0.10607492f, -0.04968240f, 
    -0.09490631f, -0.02443718f, -0.08507351f, -0.02144768f, 0.06672752f, 0.08660486f, -0.09833442f, -0.25263104f, 
    -0.12185687f, 0.22892964f, -0.01904487f, -0.03590468f, 0.22016920f, 0.02695927f, 0.08572265f, 0.25378469f, 
    0.39350682f, -0.24073170f, -0.18042372f, -0.01525316f, 0.01535176f, 0.13037580f, 0.02075976f, -0.09004490f, 
    -0.00597840f, -0.01071941f, 0.00646824f, -0.02719353f, -0.13018458f, 0.10719333f, 0.08209465f, 0.03730094f, 
    -0.42775896f, 0.07313880f, 0.10117227f, -0.17656215f, -0.15826619f, -0.20077404f, -0.07342953f, -0.03430577f, 
    0.04905155f, 0.06396401f, 0.15518631f, -0.06008955f, -0.07859872f, -0.01292754f, -0.01952411f, -0.02790225f, 
    -0.11721397f, -0.16097312f, 0.25586349f, -0.09650021f, 0.17294218f, 0.15944454f, 0.38364649f, -0.20614544f, 
    -0.01884208f, 0.02229667f, 0.13949068f, -0.02618757f, -0.07834563f, 0.03007756f, 0.01048751f, 0.00416273f, 
    0.09893286f, 0.08245073f, -0.05255039f, -0.06282760f, 0.03562177f, 0.03765386f, -0.19297335f, 0.00049348f, 
    0.04076150f, 0.00554237f, -0.03334658f, -0.04535085f, -0.04156598f, -0.01127483f, -0.00005464f, 0.00625264f, 
    -0.00496462f, -0.02178490f, -0.02429673f, -0.00014637f, 0.02947439f, -0.00581178f, 0.00025697f, -0.00822633f, 
    -0.01382895f, -0.02057527f, -0.02496684f, 0.02087215f, -0.05970329f, 0.04430234f, 0.00334398f, 0.01272456f, 
    0.03857420f, -0.06331803f, 0.04209853f, -0.03057822f, -0.00826467f, -0.04318535f, 0.02215089f, 0.04220133f, 
    0.01787272f, 0.02984368f, -0.01898833f, -0.00255026f, -0.06170500f, -0.00088615f, -0.01003619f, -0.01405952f, 
    0.01343401f, -0.01517092f, 0.05235428f, 0.00180737f, -0.03790152f, 0.02564505f, -0.05966774f, -0.00724135f, 
    -0.00687210f, 0.00147372f, 0.04575692f, 0.03963893f, 0.03773776f, -0.04341714f, -0.03387496f, -0.00632458f, 
    0.00325559f, -0.02389126f, -0.05475857f, -0.05431080f, 0.03821684f, 0.03623265f, -0.00430163f, -0.05911828f, 
    -0.05258390f, 0.04452502f, 0.04832826f, -0.00269255f, -0.02950461f, -0.04157005f, -0.05021288f, -0.04793471f, 
    -0.05083288f, -0.04967523f, 0.02148421f, -0.04226575f, 0.01665512f, 0.03385264f, 0.02483249f, 0.02154896f, 
    -0.03037761f, -0.00259550f, -0.01496257f, 0.02420505f, 0.02285320f, -0.05167546f, 0.03157545f, 0.03877461f, 
    -0.05750573f, -0.05096766f, 0.01210590f, 0.02378798f, 0.01801921f, 0.00154116f, -0.04834370f, -0.05003198f, 
    -0.05223225f, -0.04163933f, -0.06373366f, 0.02131277f, 0.02780584f, 0.00809545f, 0.03129922f, -0.00066192f, 
    -0.01947308f, -0.06240151f, -0.04678018f, 0.00294193f, 0.02779381f, 0.02417560f, 0.02730303f, -0.03448735f, 
    -0.04791865f, 0.00756096f, -0.05188613f, 0.01412791f, -0.00606314f, 0.03981392f, -0.04034179f, -0.03516299f, 
    -0.02173393f, 0.01712448f, 0.03928949f, -0.06039767f, 0.00072373f, -0.01925205f, 0.02599137f, -0.01554662f, 
    -0.03856142f, -0.04909951f, -0.01178320f, -0.05729583f, -0.02028024f, -0.04747820f, 0.02528320f, -0.00199656f, 
    0.01109400f, -0.01601544f, 0.03366154f, -0.00142359f, 0.02782592f, 0.01854807f, 0.00088866f, -0.05981409f, 
    -0.01301227f, -0.02109152f, -0.03019049f, -0.00684161f, -0.01583572f, -0.00401266f, 0.01037371f, 0.01489124f, 
    -0.03619355f, -0.05640689f, -0.04350410f, 0.00805488f, -0.00471904f, -0.01677371f, -0.03551634f, -0.02160478f, 
    -0.04706172f, 0.03949706f, -0.04136482f, 0.04803022f, 0.00067664f, 0.01223422f, 0.04899980f, -0.05354979f, 
    0.03979167f, -0.02687683f, 0.01136312f, -0.06159832f, -0.01877519f, 0.03858436f, -0.00674117f, -0.03335740f, 
    -0.02629108f, -0.06036106f, -0.05535932f, -0.03492091f, 0.01309113f, -0.02392667f, -0.02331103f, 0.01327304f, 
    0.04431898f, -0.05186317f, 0.05038813f, 0.01049066f, -0.05802406f, 0.00199753f, -0.00498353f, -0.05264400f, 
    0.01672049f, -0.05572328f, -0.01927274f, -0.01071186f, -0.03625401f, 0.01491241f, 0.01104156f, -0.04562095f, 
    -0.04403069f, 0.00376377f, 0.00808866f, 0.01393897f, -0.01646588f, 0.03330462f, 0.02570960f, -0.04343214f, 
    -0.05944418f, -0.03866596f, -0.04557137f, 0.01805802f, -0.00164615f, -0.00248855f, -0.00222117f, 0.03509134f, 
    0.01229664f, 0.02053233f, 0.04097738f, -0.04270092f, -0.03751596f, -0.03567779f, 0.00368977f, -0.01191471f, 
    0.00150466f, 0.00407735f, -0.05911493f, -0.03003439f, 0.03306921f, -0.02523396f, -0.00865263f, 0.02421559f, 
    -0.00530016f, 0.01897815f, 0.04129650f, -0.04582233f, -0.05448082f, -0.01217201f, -0.06168967f, 0.04554969f, 
    -0.00807438f, -0.00619453f, -0.03308633f, -0.03167817f, -0.01977610f, 0.03067207f, 0.03815082f, -0.04027709f, 
    0.04751309f, -0.06265523f, -0.01286034f, -0.02566808f, -0.04241217f, 0.05147649f, -0.00002343f, -0.04104771f, 
    -0.03118193f, -0.02861939f, -0.00940327f, -0.04017421f, 0.04483934f, 0.04259275f, 0.03650322f, 0.00863498f, 
    0.03634520f, -0.03787774f, -0.00315604f, -0.05142126f, -0.03219572f, -0.04928645f, -0.03757866f, -0.02992013f, 
    -0.02761679f, 0.02184152f, 0.04025542f, 0.01317601f, 0.03843829f, -0.06486458f, -0.02145736f, -0.03326762f, 
    0.00316572f, -0.00735968f, -0.00439437f, 0.04969832f, 0.02381477f, 0.00782140f, 0.02963358f, -0.03795477f, 
    -0.03620806f, -0.01759642f, 0.03154205f, 0.04203673f, -0.02583837f, 0.00787879f, 0.04669518f, -0.00660614f, 
    -0.01421649f, 0.01908441f, -0.00057548f, 0.02548296f, 0.01289669f, 0.01948936f, 0.02892749f, -0.04533146f, 
    -0.04165027f, 0.02496862f, -0.00909033f, -0.05690994f, 0.04064750f, 0.03992888f, 0.03817156f, -0.01044286f, 
    0.04373825f, -0.05268221f, -0.02599727f, 0.04525798f, -0.05759179f, -0.02968208f, -0.04077217f, -0.00510274f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01137342f, -0.08213242f, -0.05667068f, 0.02463625f, -0.03325646f, -0.01014506f, 0.05432366f, 0.02463625f, 
    -0.01478831f, -0.02408607f, 0.00680423f, 0.05123703f, -0.02019814f, 0.10413626f, -0.05168003f, -0.01523408f, 
    -0.00026708f, -0.00274471f, 0.03907550f, 0.07991686f, -0.01174190f, 0.03084528f, 0.07757916f, -0.02129091f, 
    0.06682440f, 0.04017553f, -0.04864749f, 0.02020167f, 0.10753283f, 0.04299306f, -0.01346113f, -0.04057251f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.20374675f, 0.40330410f, -0.00044089f, 0.14826588f, 0.37195891f, -0.00144337f, -0.42358926f, 0.16364568f, 
    0.01444250f, -0.12239928f, -0.21760918f, -0.24549481f, 0.42503244f, -0.27861619f, 0.04018270f, -0.05300418f, 
    -0.13460197f, 0.08007399f, 0.33793628f, 0.09896681f, 0.20655999f, -0.08502152f, -0.60861254f, -0.26302004f, 
    -0.40914023f, 0.23541707f, 0.10221104f, -0.14591926f, -0.10682281f, -0.10319947f, -0.75471693f, 0.12231464f, 
    -0.79922915f, -0.13001637f, -0.15263726f, 0.03934215f, 0.14337765f, -0.58746582f, 0.12821598f, 0.23994356f, 
    0.12389303f, 0.09677397f, 0.23955195f, -0.74716330f, -0.14489289f, 0.29527494f, -0.15652148f, -0.12745616f, 
    0.07322627f, -0.11701214f, 0.20081002f, 0.38615721f, -0.23210433f, 0.08990971f, -0.52455574f, 0.40598980f, 
    0.00611827f, -0.26421037f, 0.16598712f, 0.35626170f, 0.10417061f, 0.13160804f, -0.08815999f, 0.05011261f, 
    0.39523518f, 0.47408327f, -0.15851839f, 0.00019713f, -0.35379547f, -0.51295924f, 0.32558557f, 0.26102918f, 
    -0.02512521f, 0.00684429f, -0.38760704f, -0.55806077f, -0.59078407f, -0.27557436f, 0.12337772f, -0.05663517f, 
    0.09611144f, -0.05128659f, 0.02053241f, -0.04902310f, -0.25493512f, -0.12306269f, -0.59008259f, -0.66403031f, 
    -0.42916274f, 0.18296111f, -0.16977829f, 0.28579384f, 0.03088164f, 0.22412701f, 0.51469094f, -0.11792970f, 
    -0.00874073f, 0.17047451f, 0.01536359f, -0.09321135f, -0.01946116f, 0.39141974f, 0.05106477f, 0.38205737f, 
    -0.07058456f, -0.11733183f, 0.49259597f, 0.13966897f, 0.11018092f, -0.46196163f, 0.10446380f, 0.00913893f, 
    -0.04857969f, 0.11256546f, -0.31286266f, 0.21895014f, 0.11605877f, 0.05235246f, 0.05059709f, -0.01089487f, 
    0.24425218f, -0.03987597f, 0.15912497f, 0.29748347f, -0.10827960f, -0.51651299f, -0.08312531f, 0.08314409f, 
    0.11404133f, -0.01289935f, 0.04915353f, 0.07404836f, -0.00655488f, 0.15397230f, 0.15911426f, 0.04151587f, 
    -0.03268204f, -0.09999777f, 0.02604202f, 0.24087985f, 0.24895659f, 0.11508202f, 0.09525928f, -0.11166534f, 
    -0.17050849f, 0.04586347f, 0.17948623f, -0.53010535f, -0.82811493f, -0.09563254f, 0.11986747f, -0.01006184f, 
    0.28531823f, -0.13699463f, 0.02125016f, -0.23826273f, 0.46782827f, -0.20720738f, -0.14243849f, 0.10866734f, 
    -0.75787377f, -0.62554735f, 0.10432357f, -0.07050256f, 0.30228972f, 0.21432225f, 0.07615863f, 0.20489706f, 
    0.15376575f, -0.00513338f, -0.55455947f, 0.00330085f, -0.22717039f, -0.13818742f, 0.09243356f, 0.01074568f, 
    0.04623261f, -0.11310174f, 0.20683078f, -0.35881677f, 0.22231625f, -0.01454031f, 0.01375233f, 0.32884628f, 
    0.37707138f, 0.04550853f, -0.12060164f, -0.82319963f, -0.26610950f, 0.14766333f, -0.13377939f, 0.06328192f, 
    0.56841809f, -0.66525275f, 0.12125807f, 0.13509576f, -0.09571005f, -0.09944952f, 0.51438701f, -0.73076153f, 
    -0.15474543f, -0.17478703f, -0.74521279f, -0.75789934f, 0.26957616f, -0.22841541f, -0.15547514f, -0.12456454f, 
    0.11121720f, 0.16485307f, 0.27383488f, 0.07184600f, 0.24480890f, 0.06700274f, 0.25540349f, -0.36698094f, 
    0.14101946f, 0.00451862f, 0.11649222f, 0.25660452f, -0.23663995f, 0.00694882f, -0.10901386f, -0.03409844f, 
    0.33203891f, 0.31479856f, -0.15099750f, 0.07755727f, -0.57978815f, 0.24306555f, -0.25007963f, -0.66381067f, 
    -0.09137214f, 0.02839600f, 0.47041929f, 0.25494370f, -0.09923188f, -0.28477532f, -0.12291940f, -0.02728954f, 
    -0.10934373f, 0.14995770f, -0.01111665f, -0.46852207f, 0.19403251f, -0.09827504f, 0.16065444f, 0.44675863f, 
    -0.13666925f, -0.49345627f, -0.17136849f, 0.27588359f, -0.35663795f, 0.09147146f, 0.21548696f, -0.00570911f, 
    0.26537085f, -0.35298744f, -0.06024806f, -0.15583470f, 0.06001496f, -0.21548961f, -0.72233468f, -0.06469607f, 
    -0.05702354f, -0.00599933f, -0.76837212f, -0.10662992f, 0.05324445f, -0.23158391f, 0.03850297f, 0.08545008f, 
    -0.05589506f, -0.03415209f, -0.54130030f, 0.09195508f, -0.39825809f, -0.01967832f, -0.11008063f, 0.38176256f, 
    0.10183800f, 0.26826981f, 0.09353791f, 0.05663734f, 0.47434044f, 0.24374619f, 0.42751148f, -0.17906831f, 
    0.43065813f, 0.16240990f, -0.15965310f, 0.15590551f, -0.24385545f, -0.22919759f, -0.37194929f, -0.74192601f, 
    -0.16395801f, -0.01111945f, 0.19734454f, 0.09198403f, -0.88201010f, 0.32087865f, -0.14604107f, -0.07466204f, 
    0.02705129f, 0.02043391f, 0.20962296f, -0.29137850f, 0.00619824f, -0.14780279f, 0.18095158f, -0.36862332f, 
    0.16869813f, 0.37643042f, -0.08646726f, 0.09863127f, 0.22596452f, -0.04891741f, -0.33709326f, -0.00677293f, 
    -0.26509961f, -0.17224781f, 0.01591546f, -0.07244206f, -0.73969406f, -0.14893942f, -0.22202094f, 0.33424583f, 
    -0.01844272f, -0.02582677f, -0.41758174f, 0.48818418f, -0.24015446f, 0.08188171f, 0.04462066f, 0.16454472f, 
    -0.10889480f, 0.16969700f, 0.06942696f, 0.21195790f, 0.56582755f, -0.06698931f, 0.36226365f, -0.21658257f, 
    -0.83059108f, 0.05406821f, -0.06282831f, 0.15988393f, 0.13285939f, -0.14741360f, 0.13349248f, -0.03138676f, 
    0.06921893f, 0.04923761f, -0.17071217f, 0.13611566f, 0.22993529f, 0.20970032f, 0.18648854f, -0.14741307f, 
    0.03879042f, -0.13103792f, 0.08288441f, -0.03029760f, 0.26266620f, 0.25896960f, -0.04442824f, -0.09909161f, 
    -0.02602326f, -0.00530056f, -0.50603956f, 0.23403679f, -0.44557881f, 0.16289967f, 0.35452619f, -0.48336414f, 
    -0.36732498f, 0.05200161f, 0.16423492f, -0.27281249f, -0.84482759f, 0.32265922f, -0.19177115f, -0.04879504f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07188123f, -0.00528952f, -0.05400645f, -0.18508667f, -0.03495805f, 0.18357947f, 0.08051139f, -0.29279542f, 
    -0.20395277f, 0.21831425f, 0.06327724f, 0.07116216f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
